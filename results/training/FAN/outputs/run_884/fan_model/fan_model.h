/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.05627768e-01f, -9.48103592e-02f, -2.53215283e-01f, -5.16523025e-04f, -2.73048282e-01f, -2.00013116e-01f, -3.16053182e-01f, 1.36416918e-02f, 9.46294516e-02f, -3.00351251e-02f,
  -1.00552328e-02f, 1.95266053e-01f, 1.97657451e-01f, 1.29237533e-01f, 4.99238558e-02f, -1.78234339e-01f, -2.08693475e-01f, -5.38184270e-02f, 5.25071844e-02f, 1.79280702e-04f,
  -2.88124848e-02f, 9.32355877e-03f, 1.62702098e-01f, -4.76981979e-03f, -1.18881419e-01f, 6.56162426e-02f, 3.51017602e-02f, -4.50467542e-02f, -1.53672474e-04f, -2.26419240e-01f,
  2.09604558e-02f, -7.32561573e-02f, -3.27253938e-02f, -3.82835343e-02f, 1.23379594e-02f, -6.94758678e-03f, 3.68081592e-02f, 4.50904779e-02f, -6.25168830e-02f, 6.55840263e-02f,
  -7.05437884e-02f, 5.85377142e-02f, 5.29009216e-02f, 2.00960096e-02f, -1.28925135e-02f, -2.24842597e-03f, 8.41263011e-02f, -5.15744137e-03f, -2.81953905e-03f, 7.90056959e-02f,
  2.26030685e-02f, -8.49640891e-02f, 7.35681504e-03f, -2.25711707e-02f, -6.22983500e-02f, -6.79792985e-02f, 7.47563243e-02f, -2.73985490e-02f, 9.06966925e-02f, -3.74946510e-03f,
  1.12844342e-02f, 3.00749694e-03f, -5.28445952e-02f, -1.23774428e-02f, 1.34472717e-02f, 7.90079590e-03f, -7.18557090e-02f, -6.87577436e-03f, 2.61086971e-02f, 3.13393958e-02f,
  4.71909456e-02f, -4.59848940e-02f, 7.07882345e-02f, -7.16008898e-03f, 1.16009964e-02f, -1.83285084e-02f, 1.33024845e-02f, -4.80320267e-02f, 4.01274636e-02f, 2.88338605e-02f,
  -5.27727641e-02f, -6.96115121e-02f, 5.31342626e-02f, 5.08511811e-02f, -3.04440614e-02f, 1.26747022e-04f, 1.86189935e-02f, 2.14324258e-02f, 4.54085395e-02f, -1.56632051e-01f,
  2.64757723e-01f, -3.96381468e-02f, -2.80380026e-02f, 8.58425424e-02f, -1.22179791e-01f, 1.08595062e-02f, -8.65811929e-02f, 3.78993154e-03f, -2.62806052e-03f, -1.10143209e-02f,
  2.81182881e-02f, 3.10938377e-02f, 1.47921722e-02f, 1.27103925e-02f, -7.11280853e-02f, 8.12350865e-03f, 3.30137387e-02f, -5.79889640e-02f, -4.17822078e-02f, -7.79042114e-03f,
  3.38308550e-02f, -3.26874815e-02f, 6.26132488e-02f, 3.05684898e-02f, 5.52499667e-02f, -6.18540682e-02f, 5.31492941e-02f, 5.99182285e-02f, -6.62976922e-03f, 5.07726781e-02f,
  -7.34863043e-01f, -6.02837913e-02f, -8.80100355e-02f, -2.23057181e-01f, 1.15531579e-01f, 9.14244130e-02f, 7.58207366e-02f, -5.94506972e-02f, -1.34059608e-01f, 1.02565985e-03f,
  2.18817294e-02f, 1.03737459e-01f, 2.92448774e-02f, 9.38486159e-02f, -1.71062127e-01f, 4.11887653e-03f, -6.81049302e-02f, -2.50107143e-02f, -1.07683048e-01f, 1.27558812e-01f,
  2.91276157e-01f, 3.97162512e-02f, -2.09497914e-01f, -6.80685509e-03f, 3.84279303e-02f, 6.70777634e-02f, -2.76980735e-03f, 4.65462096e-02f, 8.42958391e-02f, 1.90268248e-01f,
  7.80578777e-02f, -1.45707354e-01f, 5.28150536e-02f, 1.12030007e-01f, 5.61447954e-03f, -7.36943185e-02f, -7.18686283e-02f, -1.15432627e-01f, 4.31033932e-02f, -4.31283787e-02f,
  1.19910076e-01f, 8.46443791e-03f, 7.47072026e-02f, 9.05103236e-02f, 3.50884199e-02f, -8.59154016e-03f, -5.48186759e-03f, -1.28928781e-01f, -1.47173526e-02f, 8.99565890e-02f,
  1.47826195e-01f, 7.67482519e-02f, -1.52043477e-01f, 9.07132775e-02f, -6.08391650e-02f, 1.15919821e-01f, 9.62107554e-02f, -2.44454276e-02f, -3.30118998e-03f, -2.05878198e-01f,
  2.63416711e-02f, 1.89107861e-02f, 3.27561945e-02f, -6.66012689e-02f, -1.06759444e-02f, 4.21162508e-03f, -3.14173363e-02f, -1.63879208e-02f, 6.49782568e-02f, -3.54176126e-02f,
  2.16548759e-02f, -3.08885500e-02f, 4.28673346e-03f, -7.18148202e-02f, 6.08427450e-02f, 2.20011454e-02f, 8.36588559e-04f, 3.00132204e-02f, -6.29775319e-03f, 1.00631202e-02f,
  2.42671948e-02f, 2.35850513e-02f, 6.60174619e-03f, 2.80142091e-02f, 2.33176816e-02f, -2.09667254e-02f, -8.38284101e-03f, 9.85418186e-02f, -3.57566588e-02f, -6.40615309e-03f,
  -1.69573441e-01f, 4.12832163e-02f, -3.86562981e-02f, -2.53311787e-02f, 3.16180885e-02f, -4.63932641e-02f, 5.19950539e-02f, 1.07916761e-02f, -3.11976601e-03f, 1.99835692e-02f,
  1.88011415e-02f, -8.42316747e-02f, -5.01192175e-02f, 1.41118700e-02f, -8.48391093e-03f, 2.95412932e-02f, -2.59021409e-02f, -7.19764158e-02f, 4.33732718e-02f, -5.88485152e-02f,
  -7.03790635e-02f, -1.79358125e-01f, -2.40125030e-01f, -6.70626089e-02f, -4.42458726e-02f, -1.14764877e-01f, -4.35896814e-02f, -5.49467616e-02f, -1.82389587e-01f, -3.61627042e-01f,
  -4.89815384e-01f, -1.12442009e-01f, -1.68280482e-01f, 7.14451745e-02f, 2.65765458e-01f, 4.20474410e-02f, -2.29583103e-02f, -9.19894055e-02f, 2.33108234e-02f, -6.61763325e-02f,
  1.18025191e-01f, 1.45256445e-01f, 6.69874176e-02f, 7.33574629e-02f, -9.56486762e-02f, -1.35979131e-01f, -2.42694393e-02f, -1.08548678e-01f, 2.51520891e-02f, 1.30235881e-01f,
  3.11786681e-01f, -1.71529758e-03f, -1.75788864e-01f, -3.55837569e-02f, 1.41752809e-01f, 9.87336487e-02f, -1.10153548e-01f, -1.04435263e-02f, 7.44709373e-02f, 1.84546992e-01f,
  -3.66074666e-02f, -2.21191913e-01f, 6.84474781e-02f, 3.41861807e-02f, 9.68807787e-02f, -1.53160363e-01f, -9.59322378e-02f, -2.73139905e-02f, -5.44950515e-02f, -3.93225476e-02f,
  4.80788723e-02f, -5.17690554e-02f, -9.14162584e-03f, 6.48572519e-02f, -6.00648560e-02f, -5.36052808e-02f, -6.61738068e-02f, -1.56533495e-01f, -9.69758183e-02f, -4.11875248e-02f,
  1.58605620e-01f, 6.20652810e-02f, -5.01293801e-02f, -8.63058418e-02f, -1.10167310e-01f, 1.50937587e-01f, -9.47078913e-02f, 4.25892659e-02f, -1.54987440e-01f, -2.01867923e-01f,
  1.23528363e-02f, -2.47695111e-02f, 4.06489344e-05f, -1.08976655e-01f, -5.30123618e-03f, -7.93614239e-03f, 8.30196887e-02f, 3.30451578e-02f, -3.84195372e-02f, -6.76774234e-02f,
  2.60387957e-02f, 2.20341086e-02f, 5.36963716e-02f, -1.08050488e-01f, 7.46556669e-02f, -2.47702450e-02f, -7.13194255e-03f, 3.12946178e-02f, 3.69745940e-02f, -2.33695912e-03f,
  -6.09890930e-02f, 4.15928438e-02f, -8.52530450e-02f, 4.04821001e-02f, 1.96568687e-02f, -7.90656209e-02f, 1.90796964e-02f, -3.66217420e-02f, -9.94541645e-02f, -2.90046539e-02f,
  -7.10967332e-02f, -2.15176828e-02f, -1.47846248e-02f, -7.35269338e-02f, -2.70941164e-02f, 1.63851231e-02f, 7.29887038e-02f, -2.40316279e-02f, 5.09426780e-02f, -5.72356544e-02f,
  1.17075667e-02f, -6.23804219e-02f, -2.27033626e-02f, 1.39320080e-04f, 2.36998666e-02f, -5.08115515e-02f, -4.97435667e-02f, 5.49246930e-02f, -2.26104390e-02f, 5.09258136e-02f,
  -3.93288508e-02f, 6.09318167e-02f, -3.60738225e-02f, -1.17089339e-01f, 7.99669698e-02f, -5.36189228e-02f, -1.08565323e-01f, -1.13602623e-01f, -1.54219076e-01f, -1.71271458e-01f,
  -3.12237591e-01f, -9.36581939e-02f, -7.37485588e-02f, -1.36552960e-01f, 1.54247880e-01f, 3.81802857e-01f, 3.85363638e-01f, 1.57781154e-01f, 4.10844339e-03f, -1.45125002e-01f,
  -7.33218715e-03f, -8.29987600e-02f, -1.67887688e-01f, 4.58767600e-02f, 1.26622111e-01f, -2.37960555e-02f, -8.51914212e-02f, 6.91019697e-03f, 2.10334465e-01f, 2.46721074e-01f,
  1.73766404e-01f, -1.73184574e-01f, -1.13620102e-01f, -7.73916692e-02f, -1.18324488e-01f, -2.18312126e-02f, -3.42575423e-02f, -6.20366707e-02f, -1.52267376e-03f, -2.36333266e-01f,
  -3.98992188e-02f, -1.57061487e-01f, 9.14429277e-02f, -7.10566118e-02f, -1.63625684e-02f, -8.24757665e-02f, 4.89852987e-02f, -1.38880894e-01f, -3.19056213e-02f, 2.55406322e-03f,
  -6.89865202e-02f, -4.10939939e-02f, -9.85867716e-03f, 2.81431689e-03f, -8.18324387e-02f, 2.21496224e-02f, -7.59081841e-02f, -7.37291649e-02f, -8.35929960e-02f, 7.99295306e-02f,
  -5.73702762e-03f, -1.78390685e-02f, 2.72376873e-02f, 2.00899951e-02f, 1.12987943e-02f, -1.17578963e-02f, -3.28240953e-02f, -1.84170604e-02f, -9.06394701e-03f, -4.54803929e-02f,
  -1.09868972e-02f, 3.48940529e-02f, 5.64034209e-02f, -6.31380156e-02f, 7.26063401e-02f, -6.10887110e-02f, -6.50865808e-02f, 1.08089998e-01f, 2.53938138e-02f, -8.76076594e-02f,
  1.32873813e-02f, 6.79860562e-02f, -2.13431418e-02f, -3.01275160e-02f, 1.39404889e-02f, -1.50868520e-02f, 8.62303972e-02f, -3.18135060e-02f, -5.92394583e-02f, -1.35073846e-03f,
  5.01193851e-02f, -3.10066179e-03f, -5.39867245e-02f, 2.66273580e-02f, -4.43285890e-02f, 2.86840796e-02f, -8.77331884e-04f, -1.05446009e-02f, -8.42851214e-03f, -8.17575678e-02f,
  -6.16420917e-02f, 3.55108269e-02f, -6.84629455e-02f, -1.63767096e-02f, -1.05217844e-02f, -9.58314911e-02f, -3.22224610e-02f, -3.98180075e-02f, -1.87101085e-02f, -3.45196389e-02f,
  6.22523502e-02f, -1.64640415e-02f, -6.58977926e-02f, -2.20439564e-02f, 6.52453154e-02f, 4.91608940e-02f, 1.56737957e-02f, -1.51035879e-02f, 6.40901476e-02f, -1.73037853e-02f,
  -3.42936208e-03f, 3.60687673e-02f, 6.73191473e-02f, 5.26791923e-02f, 3.61370370e-02f, 1.04452610e-01f, 1.68437697e-02f, 1.37994662e-01f, 8.54916647e-02f, 6.96123242e-02f,
  4.88505885e-02f, 2.36410916e-01f, 3.67235430e-02f, -1.91085294e-01f, 1.63417850e-02f, -8.18456151e-03f, 3.14285934e-01f, 7.23683881e-03f, -1.15575559e-01f, 1.83856875e-01f,
  -8.11305121e-02f, -1.93603039e-01f, -1.12085536e-01f, -1.74494758e-01f, 1.31083429e-02f, 1.02299713e-01f, 9.57696065e-02f, -1.41789988e-01f, -8.08176696e-02f, -9.01849493e-02f,
  -1.74496416e-02f, 1.71073657e-02f, -3.93605530e-02f, -3.93316373e-02f, 1.01096489e-01f, 5.32688573e-03f, -6.03673607e-03f, 1.22685328e-01f, 1.35848731e-01f, -1.85908299e-04f,
  2.39578247e-01f, 7.56688192e-02f, -8.97267759e-02f, -8.64952430e-02f, -1.11938557e-02f, 3.63159855e-03f, 3.81946340e-02f, -8.99963547e-03f, -5.74150272e-02f, 3.46383974e-02f,
  -1.68340076e-02f, 5.95046356e-02f, -6.57515451e-02f, -2.10650191e-02f, 9.40224230e-02f, 1.11104511e-01f, -7.45345578e-02f, -3.40204686e-02f, -6.68629631e-03f, 9.91609842e-02f,
  -7.53761753e-02f, 7.62310950e-03f, 1.12336896e-01f, 8.83211493e-02f, -3.01273689e-02f, -1.59716859e-01f, 1.28629461e-01f, 1.03342585e-01f, -1.42460177e-02f, 2.09559977e-01f,
  2.41516083e-02f, -4.73161181e-03f, -5.48891984e-02f, 1.90091170e-02f, 1.69079062e-02f, 1.23940231e-02f, -9.41284522e-02f, 7.71156475e-02f, -6.13154396e-02f, 8.20657387e-02f,
  -4.22849618e-02f, 9.69572142e-02f, 2.90249027e-02f, 4.51875106e-02f, -7.30941296e-02f, 1.31774200e-02f, -3.95390876e-02f, 1.51052363e-02f, 2.28627622e-02f, 4.00721990e-02f,
  -6.01192154e-02f, -1.55665185e-02f, -1.51863666e-02f, -5.29719889e-02f, 1.64221320e-02f, -7.21147880e-02f, 5.59632741e-02f, 3.93623896e-02f, 2.68619414e-02f, 1.01157613e-01f,
  1.43612772e-02f, -2.23214865e-01f, 7.93101862e-02f, -3.83418659e-03f, 1.72748920e-02f, -2.37772986e-02f, -5.31511977e-02f, -7.11136162e-02f, -4.18254286e-02f, 2.99265031e-02f,
  2.41164900e-02f, -3.09043732e-02f, 6.16974421e-02f, 2.39842236e-02f, -1.55417724e-02f, -7.47774029e-03f, 6.35617273e-03f, -2.28166766e-02f, -4.38176766e-02f, 9.52046439e-02f,
  8.17101002e-02f, 7.84172714e-02f, 1.33004740e-01f, 7.98166692e-02f, 3.89244445e-02f, 4.54235189e-02f, 1.67769149e-01f, 1.00174613e-01f, 9.44290608e-02f, 3.17217946e-01f,
  -2.63147891e-01f, 8.86805505e-02f, 1.62258551e-01f, -1.08680643e-01f, -1.59234434e-01f, -4.16220389e-02f, -1.44006208e-01f, -5.91941141e-02f, 7.40331085e-03f, 1.32150250e-02f,
  1.93862185e-01f, 1.49407461e-01f, 8.47725347e-02f, 1.16183691e-01f, 6.94271997e-02f, -1.56129092e-01f, -1.92295343e-01f, 5.44311255e-02f, -9.48993191e-02f, 2.92654727e-02f,
  -9.20776948e-02f, -1.75769646e-02f, 9.78894997e-03f, -6.19948506e-02f, -1.67396516e-02f, -3.17229191e-03f, 2.62442343e-02f, 9.31092277e-02f, 6.85594901e-02f, -4.50293645e-02f,
  3.53282392e-01f, 1.43173650e-01f, -6.37487182e-03f, -6.42267093e-02f, 1.15719818e-01f, 1.60139881e-03f, -8.29396322e-02f, -5.12287430e-02f, -2.13223938e-02f, -1.17066251e-02f,
  7.03619868e-02f, -1.01359114e-02f, -4.74348105e-02f, 2.62384433e-02f, 4.03739437e-02f, -7.78264105e-02f, -7.98126534e-02f, 3.83510627e-02f, 8.39801803e-02f, 3.18872668e-02f,
  -6.74848035e-02f, -9.10922186e-04f, 1.65840656e-01f, 1.71674322e-02f, 5.10283411e-02f, 2.31682342e-02f, 6.88804239e-02f, -5.69031723e-02f, -8.05034637e-02f, -7.16615990e-02f,
  -4.47942056e-02f, 7.85644278e-02f, -6.11515939e-02f, -1.88479722e-02f, 4.24996875e-02f, -3.37314755e-02f, -1.37382708e-02f, -2.52446532e-02f, -7.32854679e-02f, 4.74047661e-02f,
  -2.71649454e-02f, 3.45324911e-03f, -2.26852694e-03f, -2.08306033e-02f, 5.37732765e-02f, 4.26908396e-02f, 8.54669977e-03f, -1.85990874e-02f, -1.83954462e-02f, -2.55539338e-03f,
  -6.11493252e-02f, 4.71743941e-02f, 4.05763090e-02f, -1.47665571e-02f, -1.05089368e-02f, 7.87524134e-02f, -2.39175074e-02f, 2.11225562e-02f, 4.10598032e-02f, 2.09173765e-02f,
  6.36777952e-02f, 3.87154296e-02f, -7.01526599e-03f, -5.01871668e-02f, -4.23754863e-02f, 6.30434304e-02f, 9.54641625e-02f, 1.31838047e-03f, 2.55641546e-02f, -5.43285068e-03f,
  3.19657028e-02f, -5.29711992e-02f, 8.21381435e-02f, -6.08988032e-02f, -1.17319942e-01f, 3.41383216e-04f, -5.21149151e-02f, 3.87258939e-02f, 7.09272474e-02f, 3.12471036e-02f,
  1.13201083e-03f, -1.38228506e-01f, -1.21671092e-02f, 3.35504534e-03f, 8.03067908e-03f, 2.43300442e-02f, 1.55779898e-01f, 2.79536322e-02f, 2.97061820e-02f, -1.37071967e-01f,
  -2.23921940e-01f, -1.76131457e-01f, -8.73539522e-02f, -5.52464500e-02f, -1.34000942e-01f, -6.06180215e-03f, -1.04164034e-01f, -1.28528627e-03f, -5.62303653e-03f, -6.29499480e-02f,
  -2.03048676e-01f, 1.81131780e-01f, 9.09141824e-02f, 2.45280355e-01f, 2.22968042e-01f, 1.18827121e-02f, 1.09274924e-01f, 2.32436836e-01f, 3.24345946e-01f, 2.08283231e-01f,
  1.60593190e-03f, 8.10143352e-02f, -4.08294890e-03f, -6.81373663e-03f, -1.38902999e-02f, -3.11964285e-02f, -9.30516198e-02f, -4.47721295e-02f, -1.68227181e-01f, -2.07372792e-02f,
  1.16693243e-01f, -3.64512712e-01f, 2.00696290e-01f, 1.21329376e-03f, -1.07615866e-01f, -1.96395312e-02f, -9.27301496e-03f, 1.80134866e-02f, 2.03628354e-02f, 2.56242044e-03f,
  1.15976878e-01f, -3.97423171e-02f, -2.56265402e-02f, 3.18175065e-03f, -3.51521485e-02f, 6.84975013e-02f, -2.01741196e-02f, 2.08553150e-02f, 1.18309133e-01f, -2.89621484e-02f,
  4.10149880e-02f, -9.18757617e-02f, -1.50292588e-03f, -2.78344862e-02f, -1.20026693e-02f, 7.71494731e-02f, -7.31102526e-02f, -1.25756385e-02f, -1.28825203e-01f, -5.00938296e-02f,
  -3.01246904e-02f, -2.90035478e-05f, -9.86932293e-02f, -4.88145463e-02f, 1.27622150e-02f, -2.66109966e-02f, 7.02864304e-02f, 6.20431127e-03f, -1.33815333e-02f, -1.00779114e-02f,
  3.38445231e-02f, 4.57585743e-03f, 1.67006701e-02f, -1.86472107e-02f, 1.00375481e-01f, 2.22670962e-03f, 1.61199737e-02f, 5.78421056e-02f, 7.70823807e-02f, -2.20148265e-02f,
  -1.85736585e-02f, 7.64421374e-02f, 3.18628438e-02f, 4.56207506e-02f, -6.36444837e-02f, -1.50052458e-03f, 2.82744393e-02f, -6.02239277e-03f, -3.10143479e-03f, -1.11188196e-01f,
  1.05798736e-01f, 1.93551313e-02f, 5.57497703e-02f, 9.65737402e-02f, 4.21606302e-02f, 7.03869164e-02f, -2.93783247e-02f, -7.07482919e-02f, -2.60054860e-02f, 1.18652947e-01f,
  2.90764142e-02f, 4.35514152e-02f, 7.52028152e-02f, 3.91696729e-02f, 1.26719445e-01f, -3.65400203e-02f, 4.47590873e-02f, 9.66757834e-02f, 5.75559437e-02f, -1.24597894e-02f,
  4.48969267e-02f, 1.02644399e-01f, 9.57123637e-02f, 6.09716624e-02f, 4.70673181e-02f, 1.34064466e-01f, 7.13756531e-02f, -2.02552285e-02f, 1.68140516e-01f, 3.41619290e-02f,
  -3.11018944e-01f, 1.41354622e-02f, -3.18712831e-01f, -3.70899707e-01f, -2.15123728e-01f, -1.27364203e-01f, -1.01228692e-01f, -1.63889468e-01f, -8.06650668e-02f, -9.12263468e-02f,
  1.80904627e-01f, 1.51521876e-01f, 1.87321715e-02f, 5.84612638e-02f, -1.05944708e-01f, -1.41358033e-01f, -2.98272789e-01f, -2.87260205e-01f, -2.53791124e-01f, -3.57394665e-02f,
  -1.94022129e-03f, -1.69851318e-01f, -1.19494185e-01f, -1.12279914e-01f, -8.32097232e-02f, 1.59506183e-02f, -1.07606009e-01f, -6.91421106e-02f, -8.76602232e-02f, -3.66735011e-02f,
  4.38235421e-03f, -1.30409092e-01f, 4.03554104e-02f, -1.36149246e-02f, -3.75032835e-02f, -3.61020304e-02f, -1.10644866e-02f, 1.30370259e-02f, 5.45928665e-02f, -4.80737761e-02f,
  4.94162329e-02f, -1.27918981e-02f, 3.23062725e-02f, 2.10317131e-02f, -1.37398377e-01f, -6.26698881e-02f, -3.93586904e-02f, 2.15688348e-02f, -6.96123838e-02f, 7.08755180e-02f,
  1.52210202e-02f, 8.48346129e-02f, -3.62578779e-02f, 4.28122021e-02f, 1.15899369e-02f, -1.05771292e-02f, 1.11063838e-03f, 6.26965612e-02f, 9.85720428e-04f, 4.51533310e-02f,
  2.31400209e-05f, -3.69988382e-02f, -6.21815538e-03f, 3.36592980e-02f, 1.42526450e-02f, 1.23469241e-01f, -1.09393951e-02f, 1.08887978e-01f, -4.53695841e-02f, -4.05859714e-03f,
  4.48643863e-02f, -6.73942044e-02f, 1.75565965e-02f, -5.32249883e-02f, 3.65394019e-02f, -5.47911339e-02f, 3.35541256e-02f, 7.28658810e-02f, 2.06756983e-02f, 3.65785556e-03f,
  -6.53589368e-02f, 2.53051016e-02f, -8.06554332e-02f, 3.18707079e-02f, 5.53019643e-02f, -4.65801395e-02f, 5.45163974e-02f, 3.01722181e-03f, -2.16777846e-02f, 1.68294795e-02f,
  5.27976565e-02f, 7.62219653e-02f, 2.66662203e-02f, 3.97199736e-04f, 1.14812516e-02f, 9.29411948e-02f, 1.26900151e-02f, -2.48055439e-02f, -4.53999601e-02f, 5.03636524e-03f,
  9.90477204e-02f, 4.85177673e-02f, -3.67918164e-02f, 6.93192482e-02f, 9.72332619e-03f, 1.43245105e-02f, 1.53849162e-02f, 2.34350376e-02f, 1.07093856e-01f, 9.94876772e-02f,
  3.49904709e-02f, -1.52037553e-02f, 3.17434780e-02f, 1.39834052e-02f, -3.01718600e-02f, 3.12840194e-03f, -9.02770087e-03f, 6.22594766e-02f, -9.66120046e-03f, -3.47133540e-02f,
  -2.74379272e-02f, -1.48875462e-02f, -1.23217352e-01f, 2.93239579e-03f, 6.09583631e-02f, 1.50795981e-01f, -6.26474340e-03f, 5.21053560e-03f, -2.47535412e-03f, 1.25956954e-02f,
  5.50458618e-02f, 6.98792860e-02f, -5.66913374e-02f, -6.94510713e-02f, -3.61487083e-02f, -1.56238517e-02f, -1.95871860e-01f, -1.10299155e-01f, -2.35337159e-03f, 4.76710945e-02f,
  -4.27994095e-02f, -8.23757350e-02f, -4.62568104e-02f, 1.44070340e-02f, 7.88904279e-02f, 1.24939084e-01f, -8.39868039e-02f, -6.59951121e-02f, 8.42608958e-02f, 1.61467791e-02f,
  2.22366855e-01f, -1.05017960e-01f, 8.13139882e-03f, -9.55433622e-02f, 3.95925194e-02f, -4.12862152e-02f, 8.26919302e-02f, -2.79109608e-02f, 5.42160682e-02f, 2.64928080e-02f,
  -7.30905160e-02f, 1.61605477e-02f, -7.57861808e-02f, 1.82237625e-02f, 7.01784715e-03f, -2.76587475e-02f, -8.95722359e-02f, -3.52209136e-02f, -4.84618470e-02f, 1.12186641e-01f,
  -4.97426018e-02f, -5.98590598e-02f, 3.46968397e-02f, -9.07226726e-02f, -7.68205971e-02f, -2.85150893e-02f, 6.85804486e-02f, -9.60472897e-02f, -6.67110384e-02f, 1.27256989e-01f,
  7.92798772e-02f, -6.29796367e-03f, 2.87928563e-02f, 4.32778560e-02f, 4.34393121e-04f, 4.68539707e-02f, -1.86146162e-02f, -2.02620868e-02f, -4.35454696e-02f, 4.22214568e-02f,
  -1.33044738e-02f, 4.90634330e-02f, -4.83969739e-03f, -2.31192657e-03f, 7.99168050e-02f, -9.38851573e-03f, -2.29727868e-02f, 5.31609319e-02f, -6.44189492e-02f, 1.42852236e-02f,
  7.19939917e-02f, -4.06455919e-02f, 4.37886342e-02f, -6.78581074e-02f, -7.59294182e-02f, -5.46566397e-02f, 2.52544079e-02f, 3.80097367e-02f, -2.39273800e-06f, 3.20691392e-02f,
  2.81714946e-01f, -1.37132525e-01f, 1.36118755e-01f, -6.60314187e-02f, 6.42654970e-02f, -2.70111486e-03f, -2.02479158e-02f, -4.24931124e-02f, -7.41092907e-03f, 4.19472158e-02f,
  1.55961597e-02f, 2.63394229e-02f, -3.90686952e-02f, -4.98902835e-02f, 1.10693807e-02f, 6.45744279e-02f, 6.44600838e-02f, -5.07071875e-02f, -1.60222314e-02f, 9.18017775e-02f,
  -6.78025410e-02f, 1.61071092e-01f, 9.72147435e-02f, 1.42510429e-01f, 1.82082523e-02f, 4.71234992e-02f, 1.60332054e-01f, 1.62342116e-01f, 5.89923970e-02f, 2.51500905e-01f,
  1.13521688e-01f, -1.31060496e-01f, -4.63764742e-02f, 6.82646185e-02f, -2.39785567e-01f, -4.11762506e-01f, -4.13429886e-01f, -1.62907198e-01f, 1.04304209e-01f, -2.18119062e-02f,
  -1.19693808e-01f, 2.03822032e-01f, 7.92954862e-02f, 9.51851159e-02f, 8.03908035e-02f, -8.92804340e-02f, 1.30138628e-03f, 2.45006606e-01f, 1.47150591e-01f, -5.93562275e-02f,
  -1.90933701e-02f, 9.22624543e-02f, 1.88291267e-01f, 8.07467476e-02f, 6.13353448e-03f, 1.36435598e-01f, -2.84758434e-02f, 8.08533430e-02f, -8.48859772e-02f, 2.57154107e-01f,
  1.49441496e-01f, -1.28300965e-01f, 9.54316929e-02f, 5.91735728e-02f, -4.12972420e-02f, 4.39862944e-02f, -1.01910792e-02f, 4.97282259e-02f, -1.01585537e-01f, 3.89381275e-02f,
  2.69278064e-02f, 2.15185573e-03f, -6.43471908e-03f, -2.75051687e-02f, -2.41704229e-02f, -8.34587291e-02f, 2.34113801e-02f, 9.65798497e-02f, 1.00985557e-01f, -2.31275577e-02f,
  -7.45391622e-02f, -7.67702684e-02f, -1.81363806e-01f, -6.03529364e-02f, -7.11478293e-02f, 1.63780246e-02f, -1.30736887e-01f, -4.67679054e-02f, -1.11505091e-01f, 7.94117451e-02f,
  9.10433754e-03f, 2.10328661e-02f, -6.48072883e-02f, 5.83504699e-02f, 2.02469318e-03f, -1.59627739e-02f, 2.56917272e-02f, 3.01157758e-02f, 2.05030926e-02f, 2.56485790e-02f,
  2.93176863e-02f, -1.42023796e-02f, 2.25578286e-02f, -4.25050929e-02f, 2.39533149e-02f, -8.73622745e-02f, -1.03618875e-02f, 4.62349094e-02f, -8.46069679e-02f, 3.02272663e-03f,
  4.04063985e-02f, 2.11584456e-02f, -2.24460736e-02f, -1.62788760e-02f, -4.59380914e-03f, 8.59657601e-02f, -1.39209582e-02f, -5.35715409e-02f, -3.05242073e-02f, 4.29676939e-03f,
  2.02492416e-01f, -2.23399714e-01f, 1.16264604e-01f, 1.03259005e-01f, -4.66643497e-02f, -1.13016078e-02f, 5.13891205e-02f, -7.47254770e-03f, -1.95492450e-02f, 2.15489082e-02f,
  -9.50268731e-02f, 1.39206070e-02f, 5.64436661e-03f, 8.44750851e-02f, 1.36624202e-02f, 3.97353098e-02f, -3.03811319e-02f, 1.21842042e-01f, -8.85837674e-02f, 1.50639787e-02f,
  -1.58283301e-02f, -9.90027413e-02f, 7.78516233e-02f, 1.79481581e-02f, 5.09803966e-02f, -4.88426536e-02f, 2.47127446e-03f, 2.27166004e-02f, -4.82803583e-03f, 1.02817401e-01f,
  -4.93356586e-01f, 2.82409966e-01f, 3.58506948e-01f, -1.62759945e-01f, 9.69382301e-02f, 9.84549895e-02f, 3.93299848e-01f, -4.29376066e-02f, -1.82520211e-01f, 1.20328389e-01f,
  5.26907481e-02f, -1.82144687e-01f, -4.59759757e-02f, -9.53792781e-03f, 1.05857439e-01f, 3.37678015e-01f, 3.29049021e-01f, -6.19056858e-02f, -1.29398569e-01f, -1.14550270e-01f,
  -4.33715805e-02f, -1.38271749e-01f, -2.86516130e-01f, -5.76296113e-02f, 2.45207790e-02f, -9.00411233e-02f, 6.18343279e-02f, 7.08773807e-02f, 9.07603875e-02f, 1.30075797e-01f,
  3.13186683e-02f, -1.63301080e-02f, -5.60836196e-02f, -1.16724052e-01f, -5.27638476e-03f, -7.00791478e-02f, -8.73682052e-02f, 1.70901734e-02f, -1.72699708e-02f, 2.38547120e-02f,
  -2.67652422e-03f, -5.01722321e-02f, -1.58204685e-03f, -5.14726117e-02f, -5.45576960e-02f, -4.49076965e-02f, -1.71309225e-02f, 8.97934511e-02f, 2.51480155e-02f, 3.42834694e-03f,
  7.81932473e-02f, 7.40175843e-02f, 5.90783171e-03f, 3.32287550e-02f, 1.14237592e-01f, -6.38345405e-02f, 8.00016001e-02f, -6.86946660e-02f, -7.90276006e-03f, -4.38428745e-02f,
  -1.01030404e-02f, 7.95815792e-03f, 2.89201811e-02f, 6.98024407e-03f, -7.00680912e-02f, 2.83175111e-02f, 1.01403240e-02f, 6.57121167e-02f, -3.80301997e-02f, -2.27296837e-02f,
  -2.28333585e-02f, 1.03340171e-01f, 8.14389810e-03f, -4.58512008e-02f, 4.95340601e-02f, -9.64846089e-03f, 4.55283709e-02f, -4.87662479e-02f, -6.82467129e-03f, 2.88236346e-02f,
  -1.14003994e-01f, -3.63404700e-03f, -2.34287251e-02f, -2.75000185e-02f, 5.86398654e-02f, 5.57303317e-02f, 8.62728863e-04f, -1.90085322e-02f, -1.20728239e-01f, -3.07673141e-02f,
  -1.41654134e-01f, 1.16393320e-01f, -2.66329348e-02f, -5.85168488e-02f, 2.59086303e-03f, -5.20627014e-02f, 5.57293324e-03f, -3.12419292e-02f, -2.18901318e-02f, 2.10702550e-02f,
  -3.86658311e-02f, -3.26256119e-02f, -1.22961896e-02f, 5.28766364e-02f, -7.11039454e-02f, 3.92869842e-04f, 3.31892706e-02f, 3.96052673e-02f, 3.06341536e-02f, 8.57019275e-02f,
  1.00900464e-01f, -6.32058084e-02f, -1.43374175e-01f, 5.92017993e-02f, 2.61339769e-02f, -1.33760199e-01f, -1.56401414e-02f, 7.61311427e-02f, 2.87544169e-02f, -6.65985122e-02f,
  -1.71338931e-01f, -2.48835936e-01f, 2.54596304e-02f, 2.48795864e-03f, -2.89239865e-02f, -8.20580274e-02f, -2.25753009e-01f, 3.23102735e-02f, -6.15939088e-02f, -4.30710465e-02f,
  -5.77750728e-02f, 1.03816614e-01f, 2.55695768e-02f, 4.25101146e-02f, 4.71434034e-02f, -2.34513134e-01f, -2.04514727e-01f, -1.34452758e-02f, 1.31912634e-01f, 1.25048673e-02f,
  -1.04542427e-01f, -3.84542719e-02f, 1.05707005e-01f, -4.38821800e-02f, 2.93850452e-02f, 1.28794134e-01f, -4.44290861e-02f, -6.16008975e-02f, -5.78879267e-02f, -8.58576819e-02f,
  1.64606199e-01f, -6.38262108e-02f, 1.06615759e-01f, -1.09618001e-01f, 1.22666508e-01f, 4.85602487e-03f, 4.52219620e-02f, 1.12345675e-02f, 4.84753139e-02f, -8.91322792e-02f,
  -1.49470894e-02f, -2.17940509e-02f, 5.29003404e-02f, 8.86904374e-02f, 3.54525670e-02f, 5.69530725e-02f, -1.78716518e-02f, -1.57286022e-02f, -4.90505137e-02f, -7.16208816e-02f,
  -1.87915862e-02f, -1.42276213e-01f, -7.19331354e-02f, 9.54663903e-02f, 4.90622111e-02f, -3.36136185e-02f, 8.82891864e-02f, 1.26408115e-01f, 1.03810005e-01f, 3.24810334e-02f,
  -6.59341738e-02f, -3.22100446e-02f, -3.09389755e-02f, -5.43152802e-02f, 8.27462692e-03f, 2.13088337e-02f, -2.50030104e-02f, 2.19132705e-03f, -1.14733791e-02f, -2.75409259e-02f,
  -8.66713934e-03f, -3.62837547e-03f, 5.62991686e-02f, 3.17174867e-02f, -6.78786188e-02f, -4.55326363e-02f, -3.74192931e-02f, 2.56297272e-02f, 1.60760861e-02f, -5.20734536e-03f,
  3.84938866e-02f, -3.18590775e-02f, -5.70784416e-03f, 9.34482589e-02f, -3.15293623e-03f, -3.44913788e-02f, 4.30737510e-02f, 4.48674783e-02f, 8.67342297e-03f, -2.36631967e-02f,
  6.27863482e-02f, 8.64243284e-02f, -4.50747982e-02f, -6.42455518e-02f, 6.17489044e-04f, 1.54768331e-02f, 1.97895449e-02f, -1.95209705e-03f, -4.89482023e-02f, 7.77574349e-03f,
  -1.45944897e-02f, 2.36041043e-02f, -4.40184632e-03f, -3.20367925e-02f, 7.12867752e-02f, 4.36958782e-02f, -4.34076302e-02f, -8.69707838e-02f, -4.18630950e-02f, -6.66346028e-02f,
  1.86962890e-03f, -3.42289023e-02f, -4.68318537e-02f, -3.41500156e-02f, -4.73050103e-02f, 7.12330863e-02f, 9.29429978e-02f, 9.59332809e-02f, 3.61026414e-02f, -1.10198870e-01f,
  -3.45620841e-01f, 8.72673839e-02f, 1.05568521e-01f, -1.08529240e-01f, -2.85347062e-03f, 1.60270438e-01f, 2.03146666e-01f, -1.11124050e-02f, -1.43095165e-01f, -4.61234478e-03f,
  -2.78235748e-02f, -1.89081281e-01f, -2.11051792e-01f, -3.01956870e-02f, 4.00135368e-02f, 9.99523401e-02f, 1.62235826e-01f, 1.56511124e-02f, 1.98930167e-02f, -8.16419814e-03f,
  2.35975869e-02f, -7.53236637e-02f, -1.78891197e-01f, -4.25187945e-02f, 1.66534811e-01f, -1.18306652e-01f, -3.15937288e-02f, -1.07954629e-02f, 4.29072678e-02f, 2.35924408e-01f,
  1.95301980e-01f, -1.44088700e-01f, 3.67038846e-02f, -1.23991899e-01f, 4.38830182e-02f, 3.85464840e-02f, 2.29038019e-02f, -4.33649048e-02f, -9.95430746e-04f, 8.16732422e-02f,
  -4.54593189e-02f, -1.51949544e-02f, -9.06396210e-02f, 6.91444725e-02f, 2.52235159e-02f, 5.55202216e-02f, 2.61800587e-02f, -4.26077731e-02f, -3.37988771e-02f, 1.41074896e-01f,
  2.26383861e-02f, -8.85481238e-02f, -4.48368350e-03f, 5.54605462e-02f, 5.44580109e-02f, -7.75102302e-02f, 2.82514915e-02f, 5.25368266e-02f, -3.17489281e-02f, 2.16798056e-02f,
  5.40503152e-02f, 7.15123862e-02f, -7.85139948e-02f, 5.56716956e-02f, -4.21745591e-02f, -7.22726062e-02f, 7.49517158e-02f, -1.50042828e-02f, 6.68160543e-02f, -2.27626879e-02f,
  1.73699751e-03f, -2.75542531e-02f, -2.45955326e-02f, 3.87524590e-02f, 4.56581730e-03f, 1.91060118e-02f, -1.63193746e-03f, 3.68097872e-02f, 7.30645051e-03f, -8.79251286e-02f,
  -7.72421733e-02f, 5.55557050e-02f, -2.74020173e-02f, -4.52631228e-02f, 4.63868603e-02f, -3.61157060e-02f, 1.23770507e-02f, 2.90524755e-02f, 3.71151306e-02f, -8.86860304e-03f,
  -1.55225918e-01f, -2.38451496e-01f, 9.42604616e-02f, -4.18645218e-02f, -3.77410240e-02f, -8.54358450e-03f, -3.25695537e-02f, -7.43581057e-02f, -7.20604509e-02f, 5.79536371e-02f,
  2.08376497e-02f, -2.44302806e-02f, -8.02750587e-02f, 4.01984937e-02f, 1.14776818e-02f, 7.77553469e-02f, -3.13348882e-02f, 1.13229845e-02f, -5.47143929e-02f, -1.04040103e-02f,
  -5.57275899e-02f, 5.59157319e-02f, -9.78669599e-02f, -1.88316137e-03f, -7.04582930e-02f, -1.50748612e-02f, -1.90420114e-02f, 4.06774729e-02f, -6.47989437e-02f, 8.53420496e-02f,
  2.28881717e-01f, -1.98958088e-02f, -2.06724271e-01f, 1.92238521e-02f, 8.54074657e-02f, 2.38287508e-01f, 3.23490828e-01f, 1.50594845e-01f, 2.24142801e-02f, 2.90889647e-02f,
  6.62497357e-02f, -1.51732355e-01f, -1.45754606e-01f, -1.03052802e-01f, 8.15949142e-02f, 5.33287711e-02f, 4.23944592e-02f, -1.17115118e-01f, 5.58346659e-02f, 1.71598807e-01f,
  -3.99808623e-02f, 9.49134007e-02f, 7.13865552e-03f, 1.03593856e-01f, -7.03597367e-02f, -8.40607658e-02f, -1.77100852e-01f, -1.72009781e-01f, -1.39302686e-01f, -3.85511279e-01f,
  -3.58822405e-01f, -1.02241673e-01f, 3.01517025e-02f, 5.20731620e-02f, -1.23101883e-01f, -3.90669443e-02f, -5.26839234e-02f, -1.26811296e-01f, -7.62821957e-02f, -1.34722553e-02f,
  -7.83253536e-02f, -5.87097406e-02f, -3.60054933e-02f, -3.68342958e-02f, 8.68942589e-02f, 3.24594602e-02f, 6.07315712e-02f, -9.13362801e-02f, -2.66325474e-02f, -1.67450332e-03f,
  -2.23191082e-03f, -7.98671134e-03f, 3.98934968e-02f, 4.38928567e-02f, -8.35994333e-02f, 7.93946069e-03f, 9.27832723e-03f, -9.30083767e-02f, 5.50334603e-02f, -1.25591084e-01f,
  6.90631708e-03f, -5.10774478e-02f, -9.61869303e-03f, 6.26887903e-02f, 1.85981598e-02f, -4.74982709e-02f, -7.49007016e-02f, 2.16530549e-04f, 2.38063280e-02f, 4.51743193e-02f,
  -5.62930256e-02f, 6.25168812e-03f, -3.36582512e-02f, 6.49653934e-03f, -4.31352295e-02f, -6.13978580e-02f, 2.85086542e-04f, 5.96495047e-02f, 3.33605334e-02f, -1.61298346e-02f,
  1.80611368e-02f, 2.45116707e-02f, -2.58643012e-02f, -2.17916742e-02f, 3.44271883e-02f, -1.15694709e-01f, 6.68606758e-02f, -1.54738724e-02f, 3.86717357e-02f, -2.67704539e-02f,
  1.75275490e-01f, 9.56697613e-02f, -7.79169053e-02f, 5.92083260e-02f, -4.74588424e-02f, 6.45877142e-03f, -4.48267870e-02f, 8.21842626e-02f, -1.08016701e-02f, 6.24818690e-02f,
  1.24085195e-01f, -5.19035645e-02f, -1.32425514e-03f, 4.14428897e-02f, 8.72284025e-02f, 1.55507475e-01f, 1.81425154e-01f, 5.44061437e-02f, 7.32227787e-02f, 8.74795392e-03f,
  1.19047709e-01f, 1.30554020e-01f, 2.31713280e-01f, 3.02383397e-02f, 1.72838215e-02f, 5.88062555e-02f, 4.95136417e-02f, 3.74712721e-02f, 1.86719775e-01f, 2.91699439e-01f,
  -9.26211104e-03f, 2.93987006e-01f, -8.08833390e-02f, 2.82226831e-01f, 1.29851758e-01f, -7.91466609e-02f, 1.16103679e-01f, -5.54107018e-02f, 9.71331745e-02f, 2.97140092e-01f,
  1.74946964e-01f, 5.72722368e-02f, 7.22892061e-02f, -1.24179736e-01f, -2.71277040e-01f, 1.19252443e-01f, 8.89253467e-02f, -1.74509704e-01f, -3.74984503e-01f, -1.49633572e-01f,
  1.45347476e-01f, 2.33468562e-02f, -1.64757147e-01f, -1.08653933e-01f, 3.03699851e-01f, 1.77316681e-01f, 5.47062270e-02f, -1.51679264e-02f, 3.85018103e-02f, 3.90690625e-01f,
  1.27067149e-01f, -4.88781780e-02f, -4.86118048e-02f, 2.66086217e-03f, 4.32925820e-02f, -8.68423283e-02f, 3.05690411e-02f, 2.02259254e-02f, -9.55308825e-02f, 2.77744420e-02f,
  8.90561119e-02f, -1.06116980e-02f, 4.12782691e-02f, 4.54380773e-02f, -3.77296470e-02f, -3.25262398e-02f, -4.52276412e-03f, -1.73888192e-01f, -1.33225396e-01f, 2.25985590e-02f,
  1.06748112e-01f, 4.02403921e-02f, -5.47002954e-03f, -3.57613787e-02f, -1.19922377e-01f, -1.06594995e-01f, -3.88432816e-02f, -8.39780420e-02f, -2.25833908e-01f, 1.85660362e-01f,
  4.14095148e-02f, 8.47919029e-04f, -1.00531913e-01f, 7.03768199e-03f, 6.08161325e-03f, 6.53785393e-02f, 1.64365710e-03f, 6.52280673e-02f, -6.26388565e-02f, 3.11771724e-02f,
  -1.89445931e-02f, -1.14296461e-02f, -1.05499681e-02f, 2.27294974e-02f, -1.81204975e-02f, 3.37292366e-02f, -2.27587484e-02f, 7.52646178e-02f, 4.56553092e-03f, -6.36321008e-02f,
  2.34508738e-02f, -1.04011178e-01f, 6.61352649e-02f, -7.41725266e-02f, -1.29592335e-02f, 2.30558570e-02f, 2.59249918e-02f, -5.33529967e-02f, 6.92740530e-02f, -9.57208220e-03f,
  1.90019444e-01f, -3.44105214e-01f, 1.66319534e-01f, 1.90698616e-02f, 2.81275697e-02f, -1.66601669e-02f, 8.37158710e-02f, 2.75267866e-02f, 9.87879261e-02f, 3.69856060e-02f,
  -1.19556472e-01f, -1.98657494e-02f, 9.49404910e-02f, -1.03222057e-01f, 2.95995865e-02f, -6.74599037e-02f, 8.87800828e-02f, 1.04277208e-01f, -7.11710304e-02f, 3.34881246e-02f,
  -2.49826703e-02f, 4.20845151e-02f, 1.23486230e-02f, 1.10163711e-01f, -5.70974834e-02f, 7.19985217e-02f, 6.50956705e-02f, 1.16091352e-02f, -1.85896188e-01f, 1.51326850e-01f,
  2.77565271e-01f, -2.11157188e-01f, -6.26141354e-02f, 7.69444779e-02f, -1.51989803e-01f, -4.11823355e-02f, -8.56486410e-02f, 2.01203436e-01f, 1.78223178e-01f, -1.36260808e-01f,
  -1.22532822e-01f, 2.00391054e-01f, 2.26417273e-01f, 1.87957779e-01f, 1.97841048e-01f, -1.40759856e-01f, -2.18214214e-01f, 6.50088862e-02f, 1.90953001e-01f, 1.02685973e-01f,
  6.12222701e-02f, 5.04350588e-02f, 5.90561777e-02f, 2.09158137e-02f, -1.13451585e-01f, 4.65477519e-02f, -1.99432895e-01f, -1.99170470e-01f, -2.10075647e-01f, -3.54537994e-01f,
  -1.42620087e-01f, -1.14504412e-01f, 8.43900964e-02f, 3.74190733e-02f, -1.07155077e-01f, 1.07497238e-01f, -2.25800872e-02f, -4.76144217e-02f, -4.00869176e-03f, -1.86845604e-02f,
  -7.96477944e-02f, -1.80395227e-02f, -1.38340443e-02f, -2.34992262e-02f, -1.52131421e-02f, 3.00697535e-02f, -5.27693927e-02f, 6.38634041e-02f, 6.50646985e-02f, -8.64925832e-02f,
  -1.42995358e-01f, -1.46452695e-01f, -1.52456194e-01f, 4.81594913e-02f, 8.92464370e-02f, 3.97531241e-02f, -1.60412848e-01f, -5.82689047e-02f, 2.36595087e-02f, -8.26189592e-02f,
  8.55479762e-02f, -6.31486177e-02f, -1.94461625e-02f, -6.78145420e-03f, 1.37511380e-02f, 1.56922825e-02f, -1.44377770e-02f, -3.55001986e-02f, -2.84585659e-03f, 5.04785962e-02f,
  -7.26714265e-03f, 5.26689552e-02f, -2.11544484e-02f, 4.86674602e-04f, -2.55092718e-02f, -5.43208700e-03f, -8.19536950e-03f, -4.66781743e-02f, 1.55948633e-02f, -8.67146254e-03f,
  2.70133782e-02f, -4.83904108e-02f, -4.62710932e-02f, -2.72089094e-02f, -4.68389411e-03f, -7.35912398e-02f, 6.55736774e-02f, 8.81960392e-02f, 5.57955876e-02f, 4.76312544e-03f,
  1.90272301e-01f, -1.07238881e-01f, 2.68023703e-02f, 3.10439821e-02f, -2.88014822e-02f, -2.69834120e-02f, 6.87212963e-03f, 5.10636494e-02f, 2.96627283e-02f, -2.42574215e-02f,
  -7.78423948e-03f, 3.99686992e-02f, 1.54820306e-03f, -9.04709250e-02f, -1.36903813e-03f, 1.20705143e-02f, -8.98003057e-02f, 1.32704461e-02f, 1.57692693e-02f, -5.96711002e-02f,
  -1.32745374e-02f, 7.30123818e-02f, 8.05794299e-02f, 2.32699309e-02f, -3.44582461e-02f, 1.17606737e-01f, 5.53245172e-02f, 5.02502620e-02f, 1.74968123e-01f, 6.96215183e-02f,
  -1.80819258e-01f, -1.71756476e-01f, -3.32781881e-01f, -3.02308034e-02f, -5.57915829e-02f, -1.63858443e-01f, -2.10986793e-01f, 5.10706741e-04f, 1.31902710e-01f, -1.70463964e-01f,
  -1.30793666e-02f, 2.06593826e-01f, 4.40471023e-02f, 5.66259585e-02f, -6.00990131e-02f, -1.28816828e-01f, -4.02046815e-02f, 6.66901469e-03f, -3.31066996e-02f, -7.62805715e-02f,
  3.99447195e-02f, 1.37728468e-01f, 7.40380064e-02f, 7.87199512e-02f, -1.27178237e-01f, -2.99556684e-02f, -1.54506192e-01f, 3.28818597e-02f, -1.07960619e-01f, -1.49620935e-01f,
  -3.22936028e-01f, 2.70697259e-04f, -3.84428799e-02f, 1.22285537e-01f, -3.44761498e-02f, -4.43416312e-02f, -1.37295658e-02f, -5.49050374e-03f, -3.61641049e-02f, 1.59209166e-02f,
  6.02083765e-02f, 1.18367545e-01f, 3.00738141e-02f, 2.13626157e-02f, -3.39791924e-02f, -3.74785736e-02f, -3.11672711e-03f, -5.06791435e-02f, -7.35806078e-02f, 6.08861540e-03f,
  4.91374321e-02f, 6.81964159e-02f, 2.00551432e-02f, 7.64070731e-03f, -6.25501648e-02f, 1.15983887e-02f, -5.94248250e-02f, -1.50994509e-01f, -7.67698511e-02f, -1.45928860e-01f,
  6.30142912e-02f, 1.28559945e-02f, 4.22085300e-02f, 1.39829936e-02f, 4.17441353e-02f, 6.55268356e-02f, -3.21169347e-02f, 2.70347227e-03f, -1.50480196e-02f, 1.93220805e-02f,
  -2.94952095e-02f, 8.72806460e-02f, 4.71559614e-02f, -9.92608140e-04f, 3.18450890e-02f, -3.95817962e-03f, 1.74955484e-02f, -1.22538498e-02f, 1.15251737e-02f, 3.76012921e-02f,
  1.84810702e-02f, -7.55802393e-02f, 5.88722192e-02f, -3.49210389e-02f, 1.32574951e-02f, -4.79296558e-02f, -4.12483774e-02f, 9.65391248e-02f, 1.14338748e-01f, 9.03927833e-02f,
  2.74480563e-02f, 1.05163172e-01f, -1.74990501e-02f, -5.57097644e-02f, 3.11425421e-02f, 5.03083207e-02f, -1.22129535e-02f, -5.60119860e-02f, 8.85701627e-02f, -1.02830209e-01f,
  -1.03935301e-01f, -7.50137344e-02f, -1.27889784e-02f, -2.34630313e-02f, 5.19894585e-02f, 2.60115191e-02f, 1.67506337e-02f, -1.61481444e-02f, -2.44671106e-02f, -1.07437065e-02f,
  8.33969489e-02f, 4.36372822e-03f, -4.89180125e-02f, -5.75023424e-03f, 2.19143685e-02f, 8.19196645e-03f, -3.13685052e-02f, -1.73181742e-01f, -1.15120396e-01f, -2.97667712e-01f,
  -2.34014213e-01f, -1.03525378e-01f, -1.92000881e-01f, 4.41370765e-03f, -1.72523074e-02f, -1.94621399e-01f, -2.35146672e-01f, -1.06503658e-01f, 1.68474972e-01f, -8.84816498e-02f,
  -7.19390512e-02f, 4.21621874e-02f, 1.02842286e-01f, 1.36091471e-01f, -6.69359341e-02f, -1.74667150e-01f, 4.77455258e-02f, -7.82494545e-02f, 8.42931196e-02f, -4.59984131e-03f,
  2.58285888e-02f, 4.83576395e-02f, 1.45695835e-01f, 6.36612847e-02f, 9.00890678e-02f, 9.86700356e-02f, -2.97372565e-02f, 2.69974209e-02f, -8.59512240e-02f, 3.33344601e-02f,
  -1.84420764e-01f, -1.18926704e-01f, 7.81019777e-02f, 6.40940527e-03f, -8.71755183e-02f, 2.08787210e-02f, -4.75228205e-02f, 9.69722494e-02f, 4.87792343e-02f, -8.71830732e-02f,
  -6.58422261e-02f, 6.96026683e-02f, 7.98648875e-03f, 1.96207799e-02f, 9.17641632e-03f, 1.88195407e-02f, 1.20848179e-01f, 6.77868277e-02f, 4.79298271e-02f, -7.63298273e-02f,
  4.93208095e-02f, -7.36046135e-02f, -3.70777436e-02f, -5.64472489e-02f, -1.70294680e-02f, 8.60017315e-02f, -2.68934481e-02f, -7.01209763e-03f, 7.83377588e-02f, 9.74527467e-03f,
  3.96184511e-02f, 3.35146044e-03f, -1.22809447e-02f, 5.35845645e-02f, -3.82791273e-03f, 3.84850167e-02f, 3.47413443e-04f, 5.75565845e-02f, 8.07583556e-02f, -2.33656727e-02f,
  -2.92719472e-02f, 5.87074496e-02f, -5.19976169e-02f, 1.44229475e-02f, -3.97612825e-02f, 2.54320521e-02f, 2.50176601e-02f, 2.47672386e-02f, -9.44656599e-03f, 9.35264863e-03f,
  7.91386962e-02f, -2.30175778e-02f, 2.69188751e-02f, 1.24189854e-02f, 4.69543040e-02f, -4.39523943e-02f, 4.35165577e-02f, 4.09791656e-02f, 5.72214089e-02f, 3.78348529e-02f,
  -7.80771747e-02f, -3.21107451e-03f, -8.40080902e-02f, -5.18808179e-02f, 7.15443268e-02f, 2.42233574e-02f, -4.84316349e-02f, 1.06811919e-03f, -7.48365298e-02f, 9.01543628e-03f,
  -7.56123289e-02f, -9.38229321e-04f, -9.53100398e-02f, 8.42993408e-02f, 4.32452634e-02f, -6.41482603e-03f, -1.89713258e-02f, 5.31077906e-02f, 6.07283264e-02f, -6.40521571e-02f,
  -7.39131644e-02f, -2.38757990e-02f, -1.64535508e-01f, -9.39838588e-02f, 1.43768732e-04f, -1.47322133e-01f, -1.84016064e-01f, -5.84517941e-02f, -8.40221718e-02f, -1.21942170e-01f,
  -4.68980104e-01f, -5.01994342e-02f, -5.55978827e-02f, -1.68963075e-01f, -2.23894432e-01f, -1.02607697e-01f, -1.46043479e-01f, 6.37119189e-02f, 4.71412838e-02f, -4.62207198e-02f,
  -7.77065977e-02f, 8.27362910e-02f, 6.89114258e-02f, 9.89472717e-02f, 1.33462965e-01f, 6.53696712e-03f, 6.67245016e-02f, -2.36229170e-02f, 8.04562774e-03f, -1.24438927e-01f,
  -3.77056710e-02f, -1.75286636e-01f, 2.77187601e-02f, -7.22947642e-02f, -1.53056696e-01f, -1.69553027e-01f, -1.20440081e-01f, -2.67640680e-01f, -6.57329932e-02f, -2.94425368e-01f,
  -2.76391208e-01f, -3.09388191e-01f, 7.89414570e-02f, -5.13391383e-02f, 2.36330517e-02f, 4.94618714e-02f, 8.29598382e-02f, -1.75225008e-02f, -5.91154955e-03f, 3.55225150e-03f,
  -4.99417037e-02f, 8.06841999e-02f, 4.72564213e-02f, -5.94711769e-03f, -1.94642656e-02f, -3.93547602e-02f, 6.82699308e-02f, 4.75346632e-02f, 2.35431851e-03f, -1.14348847e-02f,
  9.42903310e-02f, -1.66781887e-01f, -1.80599794e-01f, 4.93255118e-03f, -2.36587245e-02f, 3.36563960e-02f, -1.39834806e-01f, -1.41278356e-01f, -7.24681318e-02f, -3.05578232e-01f,
  2.89335009e-02f, -7.62470663e-02f, 5.10214362e-03f, -6.13014661e-02f, 1.60677899e-02f, -2.25564484e-02f, -1.62248649e-02f, -1.08618885e-01f, 1.29537378e-02f, -6.93777278e-02f,
  3.22680324e-02f, 3.77859622e-02f, -4.68846830e-03f, -4.11912985e-02f, -3.87166962e-02f, -9.14667472e-02f, 4.06747721e-02f, -1.98640358e-02f, 3.02814208e-02f, 5.63326254e-02f,
  6.24490436e-03f, -1.04033640e-02f, -1.17930712e-03f, -3.78925027e-03f, 1.68452412e-02f, 4.26291339e-02f, -3.67125235e-02f, -3.48454565e-02f, -8.33231583e-02f, 4.90268916e-02f,
  -7.18323365e-02f, 2.56760120e-01f, -4.87967841e-02f, -2.86198165e-02f, -1.95697416e-02f, 7.38800317e-02f, -1.74780488e-02f, 3.80150117e-02f, 8.22516084e-02f, -3.74376923e-02f,
  -4.00815085e-02f, -1.25100883e-02f, 1.16627570e-02f, 1.87308691e-03f, -5.42619340e-02f, -6.59913719e-02f, 1.10528715e-01f, -1.02209359e-01f, 8.40806663e-02f, 3.54541652e-02f,
  9.25300941e-02f, 5.03620207e-02f, 5.37574349e-04f, 4.22458537e-02f, -3.43870819e-02f, 2.90397201e-02f, -4.84154448e-02f, -1.30625188e-01f, -2.82639358e-02f, -2.75218226e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.20630540e-01f, -1.02164268e-01f, -3.67156833e-01f, -6.85548633e-02f, -1.17869794e-01f, -1.22271171e-02f, -2.71333009e-01f, -6.27438575e-02f, 3.19143236e-02f, -2.92292774e-01f,
  -1.23775676e-01f, -1.08752280e-01f, -2.00983375e-01f, -1.58749312e-01f, -1.95521578e-01f, -3.19905400e-01f, -3.30342948e-01f, -2.76904136e-01f, -1.22865759e-01f, -5.04216962e-02f,
  -4.14538011e-02f, -1.64868042e-01f, -1.32588223e-01f, -2.04960480e-02f, 8.05085823e-02f, -8.20558667e-02f, -1.26118988e-01f, -7.40536153e-02f, -7.84380510e-02f, -7.54591525e-02f,
  -2.89595425e-01f, 1.11317582e-01f, 4.13157903e-02f, 5.13584800e-02f, -2.17252355e-02f, -3.28873955e-02f, 7.42605189e-04f, 6.43618405e-02f, 5.38587682e-02f, -6.17832877e-02f,
  5.04787937e-02f, 2.37581823e-02f, -3.38469148e-02f, 2.29533687e-02f, 4.82353307e-02f, -7.66944885e-02f, 5.24134934e-03f, -9.53817889e-02f, 7.70463794e-02f, 8.02295804e-02f,
  5.32131158e-02f, 2.91854236e-02f, -8.82673170e-03f, 1.38616592e-01f, 1.74895078e-01f, 1.01062870e-02f, 3.76821170e-03f, 1.69680312e-01f, 8.09707865e-02f, -5.36498846e-03f,
  -9.84886512e-02f, 1.05314171e-02f, 3.81838232e-02f, 7.48602599e-02f, -9.86570790e-02f, 5.68278730e-02f, 4.79103588e-02f, 1.31734014e-02f, -1.88366249e-02f, -1.45876650e-02f,
  6.78767124e-03f, -3.82339060e-02f, -2.95069665e-02f, 1.11226120e-03f, -4.47316654e-02f, 2.97943410e-03f, 2.63572056e-02f, -2.32328437e-02f, 9.76528693e-03f, -8.78390968e-02f,
  -5.26654124e-02f, 4.73835766e-02f, -4.32680137e-02f, -9.83296800e-03f, -2.34196167e-02f, 1.85198877e-02f, 1.12594729e-02f, 1.38087561e-02f, 6.25732243e-02f, 1.74518358e-02f,
  5.89098642e-03f, -1.79983810e-01f, -4.69031371e-02f, 4.23032083e-02f, 2.23767031e-02f, -6.66914955e-02f, -5.16196117e-02f, 5.47891371e-02f, 7.75780380e-02f, 6.19204773e-04f,
  7.28089288e-02f, 1.18108094e-02f, -6.08791001e-02f, -6.74576964e-03f, -1.44185051e-02f, -6.61399662e-02f, -8.31743404e-02f, 6.06227629e-02f, -5.13611697e-02f, 1.64320171e-01f,
  -8.13460350e-02f, 1.12895090e-02f, -2.70344224e-02f, 2.61819712e-03f, 1.61182329e-01f, 1.57392416e-02f, -1.17072985e-01f, 4.69490606e-03f, -1.01796061e-01f, -4.39653993e-02f,
  1.02002375e-01f, 1.41317233e-01f, -1.50231987e-01f, 1.26015246e-01f, -1.05946980e-01f, -1.19709261e-01f, -1.26732945e-01f, -5.64421825e-02f, -4.33253795e-02f, 3.24171856e-02f,
  -6.50315955e-02f, -2.41963156e-02f, -1.29354820e-01f, -1.62137002e-02f, -1.17162339e-01f, 1.94452070e-02f, -6.05032071e-02f, -1.55315310e-01f, -3.13591629e-01f, -6.98067397e-02f,
  -1.04966089e-01f, -5.43368720e-02f, -4.26290371e-02f, 3.76694910e-02f, 1.15082420e-01f, -6.43530637e-02f, 4.11010832e-02f, 8.89555831e-03f, 3.07908896e-02f, 1.64870217e-01f,
  6.05648346e-02f, -6.98571876e-02f, -1.51814088e-01f, -6.90085143e-02f, -5.15663717e-03f, -9.59895849e-02f, 1.33409686e-02f, 2.82003097e-02f, -3.91684622e-02f, -1.44311292e-02f,
  -1.17059842e-01f, 7.37310946e-03f, -1.33089334e-01f, 1.07864793e-02f, -3.93634662e-02f, -1.44426733e-01f, -3.93228047e-02f, -3.83539647e-02f, -1.25562489e-01f, 1.36329923e-02f,
  4.54812450e-03f, -1.29853457e-01f, -8.77013579e-02f, -1.09037071e-01f, -6.32949173e-02f, -8.35141167e-03f, -1.24422032e-02f, -8.54343697e-02f, -1.28874704e-01f, 2.07748815e-01f,
  -1.07656652e-02f, -8.28645751e-02f, 3.46718356e-02f, -2.08257232e-02f, -1.16383862e-02f, 5.44405729e-02f, -2.32968982e-02f, 3.80427316e-02f, -3.66720818e-02f, 5.56968246e-03f,
  -7.74374232e-02f, 1.16779037e-01f, 8.46703723e-02f, -1.81937637e-03f, 9.10280272e-02f, 5.02648950e-02f, 7.10528856e-03f, 3.00360043e-02f, -4.36074249e-02f, 2.83951666e-02f,
  2.46796403e-02f, -1.22416287e-03f, 1.28323250e-02f, 4.60715629e-02f, -5.30987568e-02f, -3.76649052e-02f, 3.99128459e-02f, -6.39191046e-02f, -3.86829115e-02f, 1.75928287e-02f,
  1.74958318e-01f, -2.55642146e-01f, 1.74618378e-01f, -1.03456806e-02f, 6.21225648e-02f, 4.78150547e-02f, 8.09981823e-02f, -5.98501153e-02f, 1.64802913e-02f, -7.08389729e-02f,
  -5.43212071e-02f, -7.06088319e-02f, 4.16182838e-02f, -3.04048993e-02f, -6.66124523e-02f, -3.88202374e-03f, 2.31208745e-02f, -9.01899040e-02f, 5.88091761e-02f, -5.71012497e-02f,
  4.90077436e-02f, 5.39087579e-02f, 7.95074180e-02f, -3.63831408e-02f, -2.54175160e-02f, -2.06653327e-02f, 5.16519472e-02f, -7.02335685e-02f, -1.01739936e-01f, 2.49545231e-01f,
  1.48746997e-01f, 4.90014777e-02f, 1.37065858e-01f, 1.95017103e-02f, 1.62150979e-03f, -1.47872314e-01f, -1.42310485e-01f, 3.03413090e-03f, -8.10289639e-04f, 6.02571294e-02f,
  1.88106224e-02f, -3.47878458e-03f, -3.49181183e-02f, -9.45598632e-03f, 5.69871999e-02f, -2.05879705e-03f, 5.53014763e-02f, 6.54805973e-02f, 1.44456372e-01f, 9.98598039e-02f,
  -6.47320226e-02f, 4.90559153e-02f, 1.69137686e-01f, 3.84411104e-02f, 1.06902219e-01f, 8.19971859e-02f, -4.29191720e-03f, 1.47275124e-02f, 5.76821566e-02f, 5.75922132e-02f,
  1.16095550e-01f, 7.27677271e-02f, -5.71404956e-02f, -2.77178939e-02f, 1.47274425e-02f, 1.22963667e-01f, -5.48095331e-02f, -1.22748679e-02f, -6.94054887e-02f, -6.51765091e-04f,
  3.89068834e-02f, -2.77938731e-02f, 6.78758249e-02f, -4.65837605e-02f, 6.49324805e-02f, -2.99307927e-02f, 1.12830773e-01f, 1.50661379e-01f, 3.97620862e-03f, -4.57807817e-02f,
  -2.78713293e-02f, -3.99445370e-02f, 3.04228999e-02f, -6.53951764e-02f, 5.76239862e-02f, -4.55070995e-02f, -4.46399339e-02f, -1.82176530e-02f, 2.21096743e-02f, 6.22167327e-02f,
  3.32937054e-02f, 8.34005699e-02f, 3.46215218e-02f, 7.73734553e-03f, -6.07945211e-02f, 1.24080237e-02f, 3.99354473e-02f, 6.12735152e-02f, -7.73072988e-02f, 4.56199460e-02f,
  -1.61354188e-02f, -4.78674248e-02f, -6.71054497e-02f, 8.07533935e-02f, -8.25910494e-02f, 9.56730265e-03f, 4.19688448e-02f, 6.30341992e-02f, 8.86025876e-02f, 7.19468221e-02f,
  -3.77179757e-02f, -6.83974847e-02f, 5.05613303e-03f, 3.27448957e-02f, -6.20974898e-02f, 5.44729643e-02f, -2.97124553e-02f, 1.17960563e-02f, 7.91822225e-02f, -5.38958944e-02f,
  -1.41978890e-01f, 4.45666537e-02f, 6.58971220e-02f, -5.56913242e-02f, -6.02411665e-02f, -5.45457713e-02f, -7.61652039e-03f, -5.65076210e-02f, 1.63589837e-03f, -7.34281540e-02f,
  1.09365396e-02f, 8.11248049e-02f, 3.81981977e-03f, 5.01011536e-02f, -2.66697165e-02f, -5.12879901e-03f, 3.92143950e-02f, -8.80547836e-02f, 4.46456075e-02f, -9.87286419e-02f,
  -1.02309316e-01f, -9.04550701e-02f, -1.30847186e-01f, 3.37878196e-03f, 4.21934240e-02f, -8.94806087e-02f, 1.29832234e-02f, -2.89289057e-02f, -3.69790383e-02f, -4.15157154e-02f,
  2.38509655e-01f, -1.58125669e-01f, 5.42821586e-02f, 3.19430456e-02f, 4.58062477e-02f, 8.06460753e-02f, 1.66255608e-02f, 1.18358554e-02f, 4.65213601e-03f, -9.82990563e-02f,
  -1.48174062e-01f, -3.58830169e-02f, -1.43964991e-01f, -1.07111804e-01f, -7.36430287e-02f, 2.82642804e-02f, -2.18962394e-02f, 7.88075402e-02f, 9.65371430e-02f, 1.14660850e-02f,
  2.64745392e-02f, 4.82857041e-02f, -1.77464392e-02f, -5.60298003e-02f, 3.25504094e-02f, 6.55614361e-02f, 7.33648688e-02f, -6.31513298e-02f, -7.12608099e-02f, -2.20332723e-02f,
  6.03243709e-02f, 6.66896114e-03f, 1.75779201e-02f, -1.50784507e-01f, -3.77151817e-02f, -1.36085898e-02f, -3.83073837e-02f, 2.14584004e-02f, 8.33474507e-04f, -1.04345046e-01f,
  -1.13387577e-01f, 4.68484424e-02f, -2.94205360e-02f, 5.79461642e-03f, -2.26882920e-02f, -9.06328037e-02f, 4.74505909e-02f, 5.24054319e-02f, 5.04395664e-02f, -7.89075866e-02f,
  -1.75026640e-01f, -1.11353889e-01f, 1.17718903e-02f, -3.37467343e-02f, 1.09028174e-02f, -5.18956268e-03f, 9.35307890e-03f, -8.41617957e-02f, -3.73698249e-02f, 5.83323464e-03f,
  -6.45760074e-02f, 5.67244664e-02f, -6.37865514e-02f, 1.88244767e-02f, 8.04942325e-02f, 8.32301080e-02f, 7.28427172e-02f, -1.03195794e-01f, 5.93985021e-02f, -2.78125405e-02f,
  6.72732666e-02f, 6.60582855e-02f, 5.41571453e-02f, 4.04248713e-03f, 3.55353579e-02f, 8.51006955e-02f, 4.96830083e-02f, -9.03594494e-02f, 8.27580169e-02f, -5.79267964e-02f,
  1.25487195e-02f, -3.16167399e-02f, -6.51414990e-02f, 7.95344487e-02f, -5.85611835e-02f, 3.97548191e-02f, -7.36546740e-02f, -4.11211550e-02f, 7.64670894e-02f, 4.23793681e-02f,
  -9.46235955e-02f, -9.22843441e-02f, -3.18746716e-02f, 5.43153696e-02f, -2.27631279e-03f, -3.13810706e-02f, -2.74695177e-02f, -1.67445354e-02f, -2.60740239e-02f, -1.69783756e-02f,
  -5.53760305e-02f, 3.09399292e-02f, -1.23537425e-02f, -3.60740200e-02f, 1.06772535e-01f, 4.62536924e-02f, -7.15158582e-02f, 1.02759197e-01f, -2.83582080e-02f, -3.91694643e-02f,
  -9.02880158e-04f, 1.64249256e-01f, 1.04131080e-01f, 1.02262333e-01f, -4.45077978e-02f, 1.11870021e-01f, 3.90426181e-02f, -4.43552136e-02f, 6.81982040e-02f, 3.16314623e-02f,
  2.68985797e-02f, -4.80558723e-02f, 5.39872088e-02f, -9.29551870e-02f, 4.62012552e-02f, 1.03926517e-01f, -1.72617286e-02f, 8.60391092e-03f, 5.63977659e-02f, -3.93859781e-02f,
  8.24165046e-02f, 1.11682722e-02f, 5.61110452e-02f, 5.93990199e-02f, -9.25072134e-02f, 1.76509675e-02f, -8.58470947e-02f, -1.41662536e-02f, 2.75205541e-02f, -8.41902196e-03f,
  -2.47261277e-03f, 3.23189571e-02f, 3.39291953e-02f, 1.47581315e-02f, -9.44930762e-02f, -3.60478982e-02f, -4.74192612e-02f, -2.22779326e-02f, -7.63251185e-02f, -1.33268327e-01f,
  2.76473295e-02f, 8.80309641e-02f, -6.65116534e-02f, 5.89024611e-02f, 2.45210528e-02f, -3.47301620e-03f, 9.92901400e-02f, 2.92786844e-02f, 7.15900771e-03f, 7.58479759e-02f,
  5.11572026e-02f, 4.16905023e-02f, -1.54593529e-03f, 7.80849308e-02f, 2.04688553e-02f, -7.87521303e-02f, 5.88732660e-02f, -9.50646177e-02f, 3.31868394e-03f, 9.45684165e-02f,
  -2.72744987e-02f, -2.40813121e-02f, -1.40478099e-02f, -7.59558305e-02f, -4.95219082e-02f, 1.74933195e-03f, 8.35701302e-02f, 2.98655219e-02f, -1.17072798e-02f, 7.29887187e-03f,
  4.57172617e-02f, -7.70563111e-02f, -1.11366324e-02f, 1.04980981e-02f, -1.81571655e-02f, 3.22714336e-02f, -3.17255105e-03f, -4.72172908e-02f, 4.98634875e-02f, -4.48427908e-02f,
  -9.40603111e-03f, 4.41425219e-02f, 6.02683276e-02f, 5.73912151e-02f, -3.35661657e-02f, -3.57479043e-02f, 6.99823946e-02f, -6.00110255e-02f, -5.68959564e-02f, -8.76541287e-02f,
  -7.35337734e-02f, -4.81376238e-02f, -6.95446581e-02f, -5.78158721e-02f, -1.14152173e-03f, -7.61881238e-03f, 2.32062750e-02f, 1.71923600e-02f, -5.74673177e-04f, 8.44751447e-02f,
  8.74280464e-03f, 3.32838073e-02f, -2.30682567e-02f, 4.99526151e-02f, -3.29235382e-02f, -4.85759834e-03f, 4.26149508e-03f, 6.26818389e-02f, 4.44629826e-02f, 8.81395042e-02f,
  -6.64076582e-02f, 5.76883182e-02f, -2.36445712e-03f, -5.79766408e-02f, 1.60503127e-02f, 7.13591427e-02f, 6.42933184e-03f, 2.83509437e-02f, -4.14141081e-02f, -7.53873065e-02f,
  -5.07880971e-02f, -1.63542442e-02f, -1.71911325e-02f, -7.17276847e-03f, -7.23425895e-02f, -2.32768357e-02f, 1.54722109e-02f, 3.39908712e-02f, 2.08242182e-02f, -5.52817388e-03f,
  2.78048575e-01f, -2.45810091e-01f, -4.30808356e-03f, 1.62176907e-01f, 1.28303155e-01f, 3.25432532e-02f, 3.41809355e-02f, -4.75895442e-02f, 7.44949467e-03f, 2.63123363e-02f,
  -1.54746547e-01f, -7.70278648e-02f, 5.52397110e-02f, 9.73030645e-03f, -1.10683404e-02f, 9.14124213e-03f, 1.25314659e-02f, 1.34824038e-01f, 1.78569958e-01f, 3.52231674e-02f,
  3.64369117e-02f, 2.85536312e-02f, -1.29498523e-02f, -4.51036170e-02f, -1.30870551e-01f, -6.47513196e-02f, -3.09695285e-02f, -1.00902304e-01f, -8.08734074e-02f, -4.42190208e-02f,
  -8.29110667e-02f, -1.19635230e-02f, 2.56846193e-02f, 7.53846914e-02f, -7.71490559e-02f, -1.53032085e-02f, 1.06034786e-01f, -5.28539307e-02f, 1.68862659e-02f, -6.00108393e-02f,
  -3.32532823e-02f, 4.80579026e-02f, -6.39351606e-02f, -8.37045312e-02f, -5.00588119e-02f, 4.02253307e-02f, -7.50396699e-02f, 3.87134776e-02f, -9.03011039e-02f, -2.03844253e-02f,
  -4.60973680e-02f, 7.59660676e-02f, 8.39382708e-02f, 1.00206591e-01f, -5.35749905e-02f, 8.25111344e-02f, -9.23949033e-02f, 5.73668703e-02f, 4.79350090e-02f, -5.66532239e-02f,
  3.55105102e-02f, 3.71217616e-02f, -2.82876529e-02f, -4.33218330e-02f, -3.22202072e-02f, -1.01697352e-02f, 3.08204927e-02f, -2.12232545e-02f, 6.87778071e-02f, -3.70190255e-02f,
  2.14699060e-02f, -4.31512520e-02f, -2.27460861e-02f, 8.36734008e-03f, -2.50048041e-02f, 2.86117718e-02f, 2.98921522e-02f, 1.04186507e-02f, 2.13038729e-04f, -7.55533725e-02f,
  5.55456989e-02f, 5.97927235e-02f, 4.82170209e-02f, -8.19677189e-02f, -1.02533825e-01f, -3.81256863e-02f, -8.34658556e-03f, -3.33880968e-02f, -6.30351231e-02f, 5.10644093e-02f,
  -5.99845238e-02f, 1.43720925e-01f, 5.24842516e-02f, 2.28584632e-02f, 3.83808538e-02f, -8.86982903e-02f, -7.46365637e-02f, 7.53895864e-02f, -2.26881094e-02f, 8.59115049e-02f,
  9.78482608e-03f, -3.15278880e-02f, 3.24539430e-02f, -1.05179407e-01f, 6.98229894e-02f, 2.41302419e-02f, -6.27505034e-02f, 6.45966502e-03f, -8.91573653e-02f, -2.32594386e-02f,
  -1.27992118e-02f, 1.29926920e-01f, 8.97150412e-02f, 1.46082461e-01f, 5.78514747e-02f, 1.93046421e-01f, 3.05482857e-02f, 5.35308160e-02f, 1.14252307e-01f, 9.72368848e-03f,
  -1.31282602e-02f, -6.85327500e-02f, -3.59540433e-02f, -4.30160947e-02f, -8.67962185e-03f, -4.14476730e-02f, -9.06837638e-03f, 5.28680794e-02f, 3.24540026e-02f, -6.20280057e-02f,
  -5.58445677e-02f, 9.00163054e-02f, -4.55377102e-02f, -4.51852940e-02f, 3.61613333e-02f, -1.24224469e-01f, -1.04911722e-01f, -7.88858682e-02f, 6.10810183e-02f, 5.03483089e-03f,
  -5.93155734e-02f, -4.73994873e-02f, -1.16141140e-02f, -5.15243225e-02f, 1.45258270e-02f, 1.61418803e-02f, -7.73458928e-02f, -4.78673959e-03f, -3.19525488e-02f, -5.13219014e-02f,
  -9.18423012e-02f, 5.80321997e-02f, -3.47035262e-03f, 8.65285173e-02f, -2.30273530e-02f, 5.16003110e-02f, -2.22568233e-02f, 4.29592468e-02f, -1.45149957e-02f, -3.06643769e-02f,
  -2.79107783e-03f, 3.86407115e-02f, 4.85468768e-02f, 1.73090417e-02f, -4.43249643e-02f, -1.23980994e-04f, -1.08355388e-01f, 1.85670832e-03f, -1.87650509e-02f, -9.50706005e-02f,
  -4.16611843e-02f, 4.00648415e-02f, 4.34116311e-02f, 4.18431722e-02f, 2.79374402e-02f, -7.68867433e-02f, 2.36912537e-02f, 5.54271378e-02f, 3.81774083e-02f, 2.68679075e-02f,
  -5.55122942e-02f, 2.22754888e-02f, -3.66332158e-02f, 3.06281596e-02f, -6.40804097e-02f, -2.94740852e-02f, 4.57116999e-02f, -4.24353871e-03f, 2.32764296e-02f, -3.22360396e-02f,
  -8.16905275e-02f, 2.21602917e-02f, 2.14089006e-02f, 2.48434674e-02f, 1.33566605e-02f, 6.94550760e-03f, 3.70866507e-02f, -4.44707880e-03f, -1.27558699e-02f, 2.53602676e-02f,
  4.46233861e-02f, -4.13677208e-02f, -7.37163201e-02f, 2.21703220e-02f, -4.76891473e-02f, -1.05560035e-01f, 1.58684533e-02f, -1.65038109e-02f, -1.17885098e-02f, 2.40160786e-02f,
  6.73789456e-02f, 7.25640282e-02f, -3.23911868e-02f, -2.86060460e-02f, -3.73036116e-02f, 3.17639075e-02f, -3.85956913e-02f, 5.83685450e-02f, -6.33307919e-02f, 4.99633849e-02f,
  -3.10880803e-02f, 7.15877861e-02f, 4.65874039e-02f, 7.13752881e-02f, 3.17610800e-02f, 6.03006855e-02f, 5.69226816e-02f, 3.47644091e-02f, -7.46823251e-02f, -1.00551788e-02f,
  -1.12472083e-02f, 5.35398424e-02f, 1.08001515e-01f, 7.74468109e-02f, 5.18006682e-02f, 8.35659578e-02f, 9.87485796e-02f, 5.95659576e-03f, -3.64728719e-02f, -2.99125426e-02f,
  2.83672094e-01f, -3.85872312e-02f, 2.52277553e-01f, 1.22951366e-01f, 2.64119413e-02f, 1.32449195e-02f, -7.96432607e-03f, -4.43996601e-02f, -1.50822792e-02f, -2.08009477e-03f,
  -1.77552968e-01f, -4.94963452e-02f, -9.53815728e-02f, 6.80040976e-04f, 9.35008600e-02f, 1.05287768e-01f, 1.26394734e-01f, 8.97772834e-02f, 1.05250783e-01f, 1.17690623e-01f,
  -7.72401914e-02f, 8.91962796e-02f, 5.04035428e-02f, 1.21195115e-01f, 7.54466653e-03f, 1.86083894e-02f, 7.30659813e-02f, -1.71674863e-02f, -3.26920785e-02f, 1.01856023e-01f,
  -9.85598639e-02f, 1.56718329e-01f, 2.08359701e-03f, -7.48848766e-02f, -9.92275104e-02f, 1.76533815e-02f, -1.74284782e-02f, 1.20647840e-01f, 1.55237494e-02f, -5.54209715e-03f,
  -3.46157496e-04f, -2.82717720e-02f, 5.68692312e-02f, 4.39564213e-02f, 1.12594277e-01f, 7.00473133e-03f, -3.28843892e-02f, 1.72517642e-01f, 1.01442166e-01f, -5.00473157e-02f,
  -5.39423851e-03f, -4.58375402e-02f, -2.24837568e-02f, -2.20855661e-02f, -3.57168801e-02f, 5.72619773e-02f, 7.07771350e-03f, 1.17965601e-01f, -5.72507968e-04f, 2.90195812e-02f,
  -6.05561174e-02f, -8.69391300e-03f, -2.62493957e-02f, -2.86999755e-02f, -4.80460338e-02f, -2.48645339e-02f, -9.23242196e-02f, -1.23615868e-01f, 4.87541072e-02f, -7.06805363e-02f,
  6.27865121e-02f, -2.74709519e-02f, 3.15109752e-02f, -4.57249619e-02f, 3.62603925e-02f, -6.71130419e-02f, 1.14107043e-01f, 5.40624559e-02f, 5.28365560e-03f, -2.14683916e-02f,
  7.25631695e-03f, -9.54645406e-03f, 4.56862226e-02f, 3.26274820e-02f, 2.76627690e-02f, 6.83239177e-02f, -6.64518625e-02f, 5.22898161e-04f, -5.11962511e-02f, -6.45571277e-02f,
  -2.80712694e-02f, -1.08087473e-01f, 2.71482468e-02f, -4.94765900e-02f, -3.35717201e-02f, -7.09287748e-02f, -1.18663318e-01f, 4.73595336e-02f, 8.46381336e-02f, 1.70663092e-02f,
  -7.37263262e-02f, 1.13320976e-01f, -7.92363286e-02f, 4.17801365e-02f, 3.61313811e-03f, -3.75755690e-02f, 5.55413309e-03f, 2.75176158e-03f, 6.24764431e-03f, -2.19868124e-02f,
  5.84740797e-03f, 9.27530155e-02f, 5.13070971e-02f, -4.81137149e-02f, -1.80728305e-02f, -3.16768698e-02f, -8.87216479e-02f, 2.30591800e-02f, 4.07473743e-02f, -2.13172473e-02f,
  5.18147163e-02f, 6.24797903e-02f, 1.52984649e-01f, -4.23827060e-02f, -8.74448046e-02f, -5.69446385e-03f, 5.76433092e-02f, 4.90631722e-02f, -1.13206118e-01f, 4.18745242e-02f,
  -4.96698990e-02f, -1.41654745e-01f, -2.82939170e-02f, 4.10595797e-02f, 3.56746744e-03f, -3.15123051e-02f, -8.58578458e-02f, -5.12447879e-02f, -4.99744006e-02f, -4.63061668e-02f,
  -8.56333300e-02f, -8.20396021e-02f, 5.17023448e-03f, 1.92409381e-02f, -6.48668334e-02f, -9.92645174e-02f, -3.63759920e-02f, 5.59330396e-02f, 1.01915404e-01f, 3.80295292e-02f,
  -2.08634604e-02f, 1.25695661e-01f, -1.25422657e-01f, -1.27967939e-01f, -7.64400661e-02f, -6.53965073e-03f, -5.30176796e-02f, -3.78286019e-02f, -6.33897185e-02f, 2.51277909e-02f,
  7.83187449e-02f, -1.02450535e-01f, -4.76223975e-02f, -4.87620421e-02f, 6.72103614e-02f, 8.87992755e-02f, 1.04442500e-01f, 2.07071863e-02f, -7.88545236e-03f, 1.10904407e-02f,
  3.06228232e-02f, -1.52631225e-02f, -5.45810396e-03f, 6.75108060e-02f, 1.00949444e-01f, -6.76391320e-03f, 9.39619839e-02f, 4.00314257e-02f, 1.04252227e-01f, -2.14268337e-03f,
  -8.42658654e-02f, 4.43496322e-03f, -7.30307922e-02f, -9.47568007e-03f, 4.93740328e-02f, 7.43062273e-02f, 8.75034034e-02f, 8.07204992e-02f, -7.85777941e-02f, 1.60813816e-02f,
  2.25312207e-02f, 5.91640286e-02f, -5.06320409e-02f, 3.75701115e-02f, 3.95070538e-02f, -2.57962593e-03f, -4.86450233e-02f, 1.19015589e-01f, -3.70451324e-02f, 2.99565513e-02f,
  4.29729074e-02f, 1.35363815e-02f, -1.45850666e-02f, 3.19516584e-02f, 4.57316823e-02f, -6.27026558e-02f, 6.73775077e-02f, 5.02989851e-02f, -5.38627356e-02f, 3.00050285e-02f,
  -3.90483290e-02f, 1.41652659e-01f, 4.74143550e-02f, 2.11277883e-02f, -5.95088396e-03f, -3.61592434e-02f, 5.56519888e-02f, -6.77383617e-02f, 9.06372350e-03f, 8.25866833e-02f,
  3.29091623e-02f, -4.40610796e-02f, 7.38736615e-02f, -8.48135874e-02f, -5.94281405e-02f, -7.52264494e-03f, -3.03896107e-02f, 6.79251878e-03f, -4.28606980e-02f, 4.58187982e-02f,
  -4.75610644e-02f, 5.77413328e-02f, -1.92216653e-02f, -1.90420225e-02f, -3.20573561e-02f, 3.41911986e-02f, -7.10920841e-02f, -5.52707133e-05f, 3.38343047e-02f, -1.72954425e-02f,
  5.29582798e-02f, 1.03761479e-01f, 1.02946147e-01f, -6.75241128e-02f, 1.06008165e-01f, 1.11162543e-01f, 2.81223476e-01f, 8.99278000e-02f, 3.13459411e-02f, 1.14013843e-01f,
  1.01399221e-01f, -1.58918947e-01f, -1.14173464e-01f, -1.29748181e-01f, 1.74888875e-02f, 7.73829222e-02f, -8.49267542e-02f, -5.16290702e-02f, -1.58116981e-01f, -8.90031233e-02f,
  -1.24809511e-01f, -7.00590014e-02f, 1.24561368e-02f, -7.37199336e-02f, -2.22328547e-02f, -2.21604146e-02f, -7.87624121e-02f, 1.30950836e-02f, 7.27304742e-02f, -1.79135874e-01f,
  1.09836608e-01f, 2.85757452e-01f, -1.10379197e-01f, -6.08556159e-02f, 1.03302635e-01f, 6.90653548e-02f, -2.74910592e-02f, 7.55720735e-02f, 8.19280669e-02f, -5.76771609e-02f,
  6.84678480e-02f, 9.50462818e-02f, -2.27854718e-02f, -7.05607012e-02f, 1.12618193e-01f, 9.34674963e-02f, -4.13701944e-02f, -9.05777141e-02f, 3.56657617e-02f, -4.51549254e-02f,
  4.92823757e-02f, 6.96269423e-02f, 1.25062559e-02f, -3.14190984e-02f, 3.33619006e-02f, -7.98836350e-02f, 8.90535638e-02f, -2.80686487e-02f, 9.81343091e-02f, 1.02952356e-03f,
  5.36104850e-02f, -4.14805003e-02f, -7.66967386e-02f, 2.84515135e-02f, 5.06291427e-02f, -2.92623099e-02f, 5.09161204e-02f, -6.66351765e-02f, -8.37286115e-02f, 4.69729528e-02f,
  2.54955515e-02f, -5.68678696e-03f, 6.84584081e-02f, 2.59741135e-02f, 1.59668140e-02f, 1.27195846e-02f, 8.06788057e-02f, -3.77037749e-02f, 1.78069789e-02f, -7.58007728e-03f,
  3.58283482e-02f, -2.26030201e-02f, -3.50702107e-02f, 4.90331426e-02f, 8.69347155e-03f, 8.56029317e-02f, -6.31410927e-02f, 4.34740894e-02f, 2.14287229e-02f, 5.20413555e-02f,
  -1.23779044e-01f, 5.44924475e-02f, -4.72272672e-02f, -1.00410208e-01f, 1.74694811e-03f, 5.93712740e-02f, 4.73963879e-02f, 2.70582307e-02f, 5.44336624e-02f, 5.16136223e-03f,
  -4.52972203e-02f, -3.12660150e-02f, 1.04001969e-01f, -4.72170785e-02f, 8.09526630e-03f, -3.32483724e-02f, -1.05343558e-01f, -5.41080944e-02f, -9.11269784e-02f, -8.11724737e-02f,
  -7.85621703e-02f, -2.08814852e-02f, -1.05343491e-01f, -5.33110946e-02f, -3.93461213e-02f, -3.12262475e-02f, -5.44148907e-02f, -3.57870455e-03f, -9.99324620e-02f, -1.38604894e-01f,
  8.62439647e-02f, 1.35725409e-01f, 3.50491889e-02f, 4.21899408e-02f, -3.90347950e-02f, -1.60735786e-01f, -6.97656721e-02f, -1.09107092e-01f, 4.00473624e-02f, 1.10229114e-02f,
  -5.02851307e-02f, 3.96387279e-02f, -9.90250707e-02f, -1.33581180e-02f, -1.36341006e-01f, -2.24186592e-02f, 3.59199196e-02f, -1.18933534e-02f, -2.33856484e-01f, -2.89480239e-02f,
  -1.93718933e-02f, -1.58546139e-02f, 8.50417167e-02f, -5.79152908e-03f, 4.71827351e-02f, 4.21727598e-02f, 1.82351962e-01f, 1.89454541e-01f, 8.52900892e-02f, 1.46248028e-01f,
  1.80846415e-02f, 9.21700671e-02f, -1.24208815e-01f, 1.23024344e-01f, 1.45848036e-01f, -1.45400101e-02f, -4.59241197e-02f, 8.37925896e-02f, 3.25562507e-02f, 1.05376251e-01f,
  9.27702039e-02f, 6.11220784e-02f, -9.39019099e-02f, -3.62166390e-02f, -3.51442094e-03f, 4.72134128e-02f, -2.06547044e-02f, 5.68138026e-02f, 3.08386870e-02f, 1.24490196e-02f,
  -2.53829807e-02f, 2.87312362e-02f, -1.06246240e-01f, -8.41481909e-02f, -4.53474931e-02f, -2.20239237e-02f, 2.59390883e-02f, -2.97837574e-02f, 7.59397075e-02f, 1.52890086e-01f,
  -9.54741463e-02f, -1.51841482e-02f, 3.65881585e-02f, 7.06477314e-02f, -4.10182886e-02f, 3.40628810e-02f, -5.77061474e-02f, -3.42725292e-02f, -1.28040075e-01f, 6.10512756e-02f,
  6.88792393e-02f, -2.96159703e-02f, 1.02768261e-02f, -3.32593136e-02f, -6.78506121e-02f, -5.03609851e-02f, 3.45914364e-02f, -5.63831031e-02f, 3.39068212e-02f, 9.04550180e-02f,
  -5.41169755e-02f, -6.34307191e-02f, 6.93777725e-02f, 3.55546884e-02f, 8.67679641e-02f, 1.64967645e-02f, 2.79931426e-02f, 1.10140234e-01f, 4.60193045e-02f, -2.90161576e-02f,
  -3.20773572e-02f, -1.00078724e-01f, -6.25650734e-02f, 2.19653337e-03f, 1.16884485e-01f, 1.17291205e-01f, -1.37403561e-02f, 4.35758941e-02f, 8.39390680e-02f, -4.63911705e-02f,
  6.05912283e-02f, 1.62474457e-02f, -2.57202182e-02f, -4.44717929e-02f, -8.22010189e-02f, 7.23890215e-02f, 1.11489147e-01f, -3.40105630e-02f, 1.07914070e-02f, 7.44430795e-02f,
  5.48258722e-02f, -8.69353786e-02f, -1.70234963e-01f, -1.74286794e-02f, -3.79980952e-02f, -8.53378549e-02f, -6.48685619e-02f, -1.10910453e-01f, -4.54911217e-02f, -4.94772829e-02f,
  -1.31341964e-01f, -6.21246845e-02f, -1.35821886e-02f, -1.02019638e-01f, -5.46476208e-02f, -1.87682752e-02f, 7.05174124e-03f, -7.83192962e-02f, -5.64778559e-02f, 2.85790414e-02f,
  4.41675680e-03f, -6.98954314e-02f, 3.33703347e-02f, -6.57593161e-02f, -3.26178111e-02f, 3.45638767e-02f, -3.88873592e-02f, -1.10253960e-01f, 2.68373303e-02f, 6.43987954e-02f,
  -6.14573583e-02f, -2.31879167e-02f, -1.11855812e-01f, -1.02213591e-01f, 6.88256025e-02f, -4.25081104e-02f, -4.06489782e-02f, -7.06757978e-02f, -7.29408041e-02f, -6.91753775e-02f,
  2.44121820e-01f, -1.93951000e-02f, 6.63930103e-02f, -5.17968275e-02f, 1.74281616e-02f, -7.77608389e-03f, 6.83163926e-02f, -9.99996513e-02f, 1.32526914e-02f, 3.04846596e-02f,
  -5.79838455e-02f, -3.62914652e-02f, 4.85072993e-02f, 5.85061349e-02f, 6.18220977e-02f, -6.05086889e-03f, -1.01831339e-01f, -1.82540454e-02f, -7.34096318e-02f, -6.56316504e-02f,
  -5.70923947e-02f, -7.64245959e-03f, -2.43260376e-02f, 1.51419453e-03f, 3.14330757e-02f, -8.35580528e-02f, -1.85471009e-02f, 5.40575124e-02f, 7.90526122e-02f, -7.32937232e-02f,
  5.16822822e-02f, 1.84615329e-02f, 5.84795177e-02f, 8.32691863e-02f, -9.89769679e-03f, 7.65444860e-02f, 3.69536062e-03f, 1.31868329e-02f, 1.52997747e-02f, -7.66030177e-02f,
  -3.23136672e-02f, -2.43586395e-02f, -4.58937436e-02f, -1.07896812e-02f, -4.92053526e-03f, -1.20701283e-01f, 7.11257942e-03f, -8.39380845e-02f, -3.74447991e-04f, -2.88148485e-02f,
  -7.07599074e-02f, -6.18090965e-02f, 1.48511063e-02f, 9.24792737e-02f, 3.96469384e-02f, -6.51924834e-02f, -5.25695831e-02f, -6.94571659e-02f, -2.45591626e-02f, 2.94686705e-02f,
  1.25792906e-01f, -1.22844405e-01f, 6.00796156e-02f, -4.41645607e-02f, 7.26712570e-02f, 1.62123684e-02f, -2.04443303e-03f, -3.12205032e-02f, -5.57190403e-02f, -2.86237448e-02f,
  -3.85210402e-02f, 7.16818571e-02f, 3.32143456e-02f, -1.02296537e-02f, 5.37953302e-02f, -3.29431668e-02f, -3.12745012e-02f, 6.53621107e-02f, -3.96246538e-02f, 1.39951203e-02f,
  4.65777777e-02f, 3.97585751e-03f, 9.68453139e-02f, 3.28063183e-02f, 4.58586179e-02f, 6.71903864e-02f, 1.62178889e-01f, 1.33087471e-01f, 1.36784524e-01f, 6.44915178e-02f,
  1.06366426e-01f, -4.54205833e-02f, 9.02135223e-02f, -2.96788923e-02f, -1.34670567e-02f, 1.05929948e-01f, -1.60739124e-02f, 1.21985167e-01f, -1.34326946e-02f, 7.28264004e-02f,
  9.65290293e-02f, 9.54414904e-02f, 6.30487651e-02f, 1.04345053e-01f, -9.32979025e-03f, 8.66028666e-02f, 5.50293066e-02f, 1.27103150e-01f, 4.10949774e-02f, 1.14216611e-01f,
  -7.77359977e-02f, -1.30133601e-02f, 6.93564042e-02f, -5.85115608e-03f, -6.87948540e-02f, 3.42574827e-02f, -8.08491558e-03f, -5.45893386e-02f, -7.70515576e-02f, 2.38444041e-02f,
  1.07894614e-02f, 1.36707813e-01f, 9.14494395e-02f, 5.68866869e-03f, 5.17646112e-02f, 1.12117648e-01f, 6.07981905e-02f, -1.38212480e-02f, -4.59384955e-02f, 2.20603738e-02f,
  4.19989116e-02f, 7.01344386e-02f, 3.41048986e-02f, 4.06258320e-03f, 2.26987135e-02f, 8.95262212e-02f, 6.37489185e-02f, 1.10055387e-01f, 3.93417776e-02f, 9.79212020e-03f,
  6.04722537e-02f, 2.16369797e-02f, 3.90270315e-02f, -4.74068616e-03f, 5.44291027e-02f, 5.24555147e-02f, 9.67218876e-02f, 4.68401723e-02f, 1.60421338e-02f, 8.62024948e-02f,
  -3.56430784e-02f, 5.06753512e-02f, 4.25041141e-03f, 1.28771150e-02f, -2.56812163e-02f, -3.20207365e-02f, -6.73799440e-02f, -4.04617041e-02f, -8.79557505e-02f, -9.24665034e-02f,
  3.64588052e-02f, 6.50652349e-02f, -4.49434593e-02f, 4.73006815e-02f, -8.45754705e-03f, -4.56357636e-02f, 6.46324903e-02f, 4.20050956e-02f, 5.60529493e-02f, 6.82725236e-02f,
  7.88605586e-02f, -5.85300801e-03f, -5.82508892e-02f, -1.77502446e-02f, 8.15720931e-02f, 8.95063393e-03f, 7.11924508e-02f, 9.05971453e-02f, -6.58712387e-02f, 5.71300648e-02f,
  -1.10297002e-01f, -2.49851327e-02f, 5.72506525e-02f, 6.53172284e-03f, -4.60370183e-02f, 6.77101489e-04f, -2.66159903e-02f, -1.83123499e-02f, -3.04791592e-02f, 5.29523473e-03f,
  -7.98212364e-02f, 9.09007415e-02f, 1.77581061e-03f, -7.90432096e-02f, 1.10888379e-02f, 7.44037405e-02f, -6.17558844e-02f, -8.61661807e-02f, 6.65975958e-02f, 7.74631724e-02f,
  -6.08880334e-02f, 7.41164237e-02f, -1.55281266e-02f, 3.80499363e-02f, -6.69030026e-02f, 8.55770707e-02f, -8.94913152e-02f, 1.59753747e-02f, 5.70973568e-02f, -6.57979771e-02f,
  -2.35719234e-01f, -5.60177676e-02f, -5.61866164e-02f, -1.87837109e-02f, 1.71229675e-01f, 2.63800975e-02f, 1.36794925e-01f, 1.15837619e-01f, 4.30773273e-02f, 6.94664866e-02f,
  -9.47518349e-02f, -6.21562526e-02f, 5.23797609e-02f, 1.42758489e-01f, 1.36864319e-01f, 1.19572701e-02f, 1.05814070e-01f, 1.06075242e-01f, 1.07994422e-01f, 2.30122339e-02f,
  -2.89596082e-03f, 4.39730547e-02f, -1.96154658e-02f, 4.27100211e-02f, -1.97137576e-02f, 7.53253624e-02f, -7.69350752e-02f, 5.88175841e-02f, 8.80707242e-03f, 8.58652964e-02f,
  -4.48859595e-02f, -6.56139702e-02f, 7.09389448e-02f, -4.47370447e-02f, -1.57692656e-03f, -9.78118107e-02f, -9.44117233e-02f, -6.13648109e-02f, 5.51297478e-02f, 2.60560904e-02f,
  -9.77640674e-02f, -5.41509502e-02f, 5.87315373e-02f, -3.48110646e-02f, -1.00487970e-01f, -5.04201204e-02f, -6.65398240e-02f, -9.39834118e-03f, -3.95994820e-02f, -3.57996747e-02f,
  -3.86926234e-02f, -1.28386721e-01f, -1.72835402e-02f, -1.59117393e-02f, 9.20460280e-03f, -5.81162348e-02f, 3.52795832e-02f, -4.51151319e-02f, -1.18546262e-01f, -1.12029135e-01f,
  -3.68329585e-02f, 2.77929083e-02f, -1.10256542e-02f, -1.52700190e-02f, -1.29073428e-03f, 5.54049127e-02f, -2.07101908e-02f, -1.96718983e-02f, 5.68340458e-02f, 2.32139174e-02f,
  2.87883189e-02f, -6.83865100e-02f, 6.98594078e-02f, 7.81847313e-02f, -7.56154954e-02f, 5.85626550e-02f, -4.36489172e-02f, -5.35120405e-02f, -6.27758503e-02f, 3.21051851e-02f,
  -1.00709382e-03f, -4.75352583e-03f, 2.53324360e-02f, 7.28457570e-02f, 4.60960045e-02f, 2.95079965e-02f, -1.87646672e-02f, 4.14292794e-03f, -2.80153770e-02f, -6.21475978e-04f,
  -6.93963394e-02f, 7.43959099e-02f, -5.96445613e-02f, -4.49684896e-02f, 3.20745558e-02f, -1.22678038e-02f, -2.35692281e-02f, -7.36058224e-04f, -5.86620495e-02f, -6.25345558e-02f,
  -9.50198248e-02f, 3.16489674e-02f, -5.65197282e-02f, -9.38390568e-02f, 6.19721301e-02f, 6.47271648e-02f, -7.65406862e-02f, -2.30878536e-02f, -8.20213854e-02f, -9.63729993e-02f,
  9.13383067e-02f, -1.11222886e-01f, -1.29168570e-01f, -8.72090310e-02f, -6.72228932e-02f, 9.76487063e-03f, 1.78101640e-02f, -1.16754673e-01f, -1.11665703e-01f, -3.91034484e-02f,
  1.81433722e-01f, -7.30242878e-02f, 1.11625344e-01f, 4.80232723e-02f, -7.05124065e-03f, -9.23820436e-02f, -1.14986844e-01f, 3.19200772e-05f, 6.10162243e-02f, 2.20390894e-02f,
  -8.37465674e-02f, 7.32835829e-02f, 9.47342888e-02f, -1.20086793e-03f, 2.09811553e-02f, 5.82332015e-02f, 1.20663811e-02f, 1.43138126e-01f, 1.21212386e-01f, 8.50200579e-02f,
  -9.80553403e-02f, 7.57520348e-02f, 1.51659757e-01f, 1.11939065e-01f, 2.32922304e-02f, 1.07988358e-01f, -4.95704450e-02f, 1.10485097e-02f, 3.49456035e-02f, 8.32728744e-02f,
  -6.17026612e-02f, 1.70929695e-03f, 6.03710413e-02f, 2.47783232e-02f, -1.28016705e-02f, -2.49424186e-02f, -5.15867621e-02f, 1.03152350e-01f, -9.22091231e-02f, -8.54640603e-02f,
  2.47085895e-02f, -5.43724708e-02f, 8.49870741e-02f, -7.10395277e-02f, -3.66895944e-02f, 4.10460643e-02f, 1.13123670e-01f, 1.30803168e-01f, -3.10904421e-02f, 7.10065961e-02f,
  -7.75871649e-02f, -2.63177417e-03f, -8.53671401e-04f, -2.36235675e-03f, -5.36490306e-02f, -1.07892454e-02f, 4.09143306e-02f, -2.95457263e-02f, -2.43189428e-02f, 7.00235516e-02f,
  2.28815130e-03f, 7.92173073e-02f, -9.77488887e-03f, -6.23406656e-02f, 1.03914691e-02f, 1.54255442e-02f, -1.60345435e-02f, 5.21669313e-02f, 5.52251451e-02f, 1.08798914e-01f,
  7.41393268e-02f, 8.01382307e-03f, 2.54180375e-03f, 8.44720155e-02f, 6.88826442e-02f, 3.29521298e-02f, 2.21981797e-02f, -7.67824128e-02f, -2.06694007e-02f, 4.21020910e-02f,
  6.36774153e-02f, 1.45421363e-02f, 4.91642207e-02f, 5.49733378e-02f, 7.37800375e-02f, -1.25387255e-02f, 1.69866141e-02f, 6.47802800e-02f, 4.01121862e-02f, -7.75180459e-02f,
  -1.07575335e-01f, 7.06575215e-02f, 8.62640068e-02f, -9.53545719e-02f, 5.79395071e-02f, 6.52362257e-02f, -7.11997747e-02f, 4.30809520e-03f, -1.87716577e-02f, 3.33360434e-02f,
  -5.65297604e-02f, 8.10216069e-02f, -8.59074369e-02f, -8.92793238e-02f, 5.88841252e-02f, -1.23070821e-01f, 4.07458320e-02f, 8.77894461e-02f, -3.92906815e-02f, -8.56473222e-02f,
  -6.46539032e-02f, -5.12987201e-04f, 5.24674170e-02f, 1.22780947e-03f, -2.26454046e-02f, 5.80089279e-02f, -8.93857032e-02f, -1.01723142e-01f, 1.85488269e-03f, -4.82912660e-02f,
  1.68202996e-01f, -1.45109236e-01f, 8.95977765e-02f, 1.24174707e-01f, 6.27332702e-02f, 1.26137480e-01f, 1.08481489e-01f, 8.27973559e-02f, 1.21501572e-01f, -7.22062290e-02f,
  -1.73530102e-01f, 1.95496399e-02f, 1.39869275e-02f, -3.15225609e-02f, 1.81265231e-02f, 1.07946590e-01f, 3.82564925e-02f, 9.72520635e-02f, 1.32997870e-01f, 1.64094210e-01f,
  1.52105326e-02f, -7.98620190e-03f, 1.03550844e-01f, -4.24500145e-02f, -7.44263008e-02f, -3.76698896e-02f, 4.63539772e-02f, -5.92805026e-03f, -4.81475815e-02f, 7.83877447e-02f,
  -1.52883783e-01f, -1.44416690e-01f, 1.89527288e-01f, 2.01352388e-02f, 9.48394649e-03f, -3.88076864e-02f, -2.99940142e-03f, -5.06800152e-02f, -4.06190939e-02f, 7.91767612e-02f,
  -5.35986274e-02f, 1.21556204e-02f, 8.26019887e-03f, -5.65733872e-02f, -2.02111453e-02f, -6.37462735e-02f, -2.25547440e-02f, 3.48547064e-02f, 4.07419950e-02f, -1.19684108e-01f,
  -5.76177649e-02f, -1.71709340e-02f, -8.34347233e-02f, -4.40956093e-03f, 3.50759327e-02f, -6.99798092e-02f, -2.06200872e-02f, -9.43551511e-02f, 2.13072170e-02f, -6.54617548e-02f,
  -1.47445956e-02f, 3.36304978e-02f, -1.48731722e-02f, 6.03215471e-02f, 3.81420180e-02f, 6.02699965e-02f, 1.09073073e-01f, 8.21433738e-02f, -5.16906269e-02f, -4.88080531e-02f,
  -8.05765092e-02f, -7.37074614e-02f, 2.40113586e-02f, 6.50988519e-02f, -2.97615752e-02f, 4.79241461e-02f, -4.20663208e-02f, 1.15307579e-02f, -2.09252294e-02f, -5.44231720e-02f,
  -1.79578029e-02f, -1.53490081e-02f, 5.18523082e-02f, 5.93190780e-03f, 1.73093323e-02f, 7.31537268e-02f, -2.91565340e-02f, 3.81358527e-02f, -4.11698148e-02f, 2.62960163e-03f,
  -1.81240216e-01f, -2.91669946e-02f, 1.60117596e-01f, -4.32729237e-02f, -3.16134132e-02f, 2.98998971e-02f, -1.28093716e-02f, -6.38803914e-02f, -9.66725126e-02f, -6.95354193e-02f,
  -9.94050577e-02f, 5.22164926e-02f, -1.12719581e-01f, -6.76061660e-02f, 3.76948677e-02f, 8.32199752e-02f, -9.58337914e-03f, 4.35070731e-02f, 6.01065978e-02f, -5.63693345e-02f,
  -8.79136622e-02f, 1.92909285e-01f, 1.40130311e-01f, 1.08706586e-01f, 3.30541618e-02f, 1.83166221e-01f, 7.78986439e-02f, 6.35442585e-02f, 1.23432301e-01f, 8.20966363e-02f,
  -9.57092922e-03f, 1.03610143e-01f, -9.20933187e-02f, 4.91539575e-02f, 7.60314614e-02f, -1.70962438e-01f, -9.38160494e-02f, 8.81385878e-02f, 1.69943824e-01f, 7.08599314e-02f,
  6.67784661e-02f, -7.81105980e-02f, -9.83902067e-02f, -1.68684542e-01f, -2.69134015e-01f, -2.24202782e-01f, -2.05574438e-01f, -1.74659103e-01f, -2.10809320e-01f, -5.68818860e-02f,
  -6.10881597e-02f, 9.16698761e-03f, -1.17571816e-01f, 2.64285766e-02f, -3.07815503e-02f, -1.11156106e-01f, -9.87448096e-02f, -9.23789963e-02f, -1.24867171e-01f, -5.06277531e-02f,
  -1.31292194e-01f, 7.89646804e-02f, 5.20810299e-03f, -6.19045496e-02f, -4.63357940e-03f, 7.47880638e-02f, -8.88843909e-02f, -3.79865966e-03f, 9.91762057e-02f, 8.54944885e-02f,
  2.27542948e-02f, -8.59464034e-02f, -3.04294955e-02f, 3.21169868e-02f, 3.65574565e-03f, 3.45269702e-02f, 6.02333294e-03f, -8.19746926e-02f, -8.92554373e-02f, 4.58177142e-02f,
  5.51041774e-02f, -1.44817710e-01f, -8.26200098e-02f, -5.13746403e-03f, 2.49959528e-02f, -9.47289169e-02f, -7.91854858e-02f, -5.24059217e-03f, -9.46728736e-02f, 9.87210125e-02f,
  -9.07421261e-02f, 6.59430325e-02f, -2.99460012e-02f, 2.87292600e-02f, 1.41067235e-02f, 2.35193446e-02f, 1.10841263e-02f, -9.09687653e-02f, 2.25897636e-02f, -3.43044996e-02f,
  2.18787584e-02f, -4.18526717e-02f, -3.34702954e-02f, 3.97074185e-02f, 1.01383794e-02f, -2.90190335e-02f, -6.10730015e-02f, -1.04771249e-01f, -2.64459141e-02f, -4.51030508e-02f,
  -6.23879023e-02f, 4.56431620e-02f, -2.61734128e-02f, -2.27936059e-02f, -5.60331084e-02f, -8.66318122e-02f, 1.06421290e-02f, -6.08249307e-02f, 1.03241712e-01f, -9.05438587e-02f,
  1.26547441e-01f, -1.01030454e-01f, -2.53261626e-03f, -6.57962859e-02f, -7.88707584e-02f, 6.75392747e-02f, -1.08714104e-02f, 1.24396887e-04f, -6.39275163e-02f, -4.75077108e-02f,
  -4.58800234e-02f, -6.93044290e-02f, -3.63734849e-02f, -4.87880521e-02f, -3.88946086e-02f, -7.06934109e-02f, 6.75380006e-02f, -5.63300066e-02f, -1.00304544e-01f, 1.05831452e-01f,
  5.39649874e-02f, -5.41883186e-02f, -1.32207707e-01f, 2.99319178e-02f, -5.92809506e-02f, -7.45366067e-02f, -6.07285425e-02f, 3.02714985e-02f, -1.87505987e-02f, -6.18537217e-02f,
  -2.87372231e-01f, -9.14193690e-02f, -1.80786058e-01f, -2.37757444e-01f, -1.11490428e-01f, 2.60566771e-02f, 5.14159054e-02f, 1.06299989e-01f, -1.60811841e-02f, -6.88535953e-03f,
  -1.07715288e-02f, 1.87327079e-02f, -3.57368700e-02f, -3.60671780e-03f, -8.53784680e-02f, -6.56050146e-02f, -8.05227011e-02f, -1.21063419e-01f, -3.19672525e-02f, 1.04002297e-01f,
  -2.17139367e-02f, -1.41383231e-01f, -1.31226286e-01f, 5.29175177e-02f, 5.22076674e-02f, -1.75716579e-02f, -1.36597455e-01f, -6.47708252e-02f, -5.33170961e-02f, -1.47331446e-01f,
  -7.91359544e-02f, 3.74089144e-02f, -1.75897870e-02f, -2.24022251e-02f, -3.69581953e-02f, -7.69625679e-02f, -3.29963863e-02f, -8.20281655e-02f, -2.72892993e-02f, -2.80573312e-02f,
  -5.67138474e-03f, 2.17388030e-02f, 3.21314223e-02f, -3.71527821e-02f, -2.81464979e-02f, 7.56335258e-02f, 4.58961204e-02f, 1.04381572e-02f, -5.55135459e-02f, -8.45853146e-03f,
  -8.84344801e-03f, -5.68823554e-02f, 3.22884284e-02f, 1.92222893e-02f, -2.04552501e-03f, -7.98254311e-02f, 1.33008197e-01f, 6.62916079e-02f, 6.82520419e-02f, -5.57338074e-02f,
  1.72207579e-02f, -4.53119203e-02f, 8.37137923e-02f, 5.72478995e-02f, -5.52810691e-02f, 5.55529892e-02f, 2.61416696e-02f, -2.03318298e-02f, 4.23820466e-02f, -5.76804094e-02f,
  6.84395134e-02f, 1.27123846e-02f, -3.74471806e-02f, -1.13979720e-01f, -1.01977073e-01f, -1.45145627e-02f, -8.57922994e-03f, -3.10698207e-02f, -6.15709871e-02f, -3.62530574e-02f,
  -1.38050346e-02f, 3.44643481e-02f, -5.13120741e-02f, -1.66041534e-02f, 1.82469580e-02f, 1.80637017e-02f, -2.44479328e-02f, 1.21843107e-01f, 1.06685385e-01f, 7.42295161e-02f,
  -1.01126447e-01f, 8.64077657e-02f, -9.60677713e-02f, 5.01152240e-02f, -1.19317258e-02f, 8.93297493e-02f, -4.49455492e-02f, 2.45809238e-02f, -1.09418452e-01f, 2.32056435e-02f,
  4.06546257e-02f, 2.47227848e-02f, -3.19717415e-02f, 3.79593740e-03f, 5.48699014e-02f, 6.58291429e-02f, -7.58505166e-02f, -8.18825662e-02f, 5.93872145e-02f, 4.90552187e-03f,
  -7.78936967e-02f, 3.17558013e-02f, -3.41362925e-03f, 5.92633896e-02f, 2.90353037e-02f, 1.93325952e-02f, -9.07600485e-03f, 6.40012398e-02f, -2.60631684e-02f, -1.34255821e-02f,
  -1.90791860e-02f, 1.45392507e-01f, -2.92895474e-02f, 1.63149163e-01f, 4.36031725e-03f, 2.31909379e-03f, 1.24737881e-01f, -4.82365787e-02f, 3.70491296e-02f, 1.17285162e-01f,
  1.15095899e-01f, 6.62859008e-02f, 5.66155799e-02f, 1.84065325e-03f, 9.82282311e-02f, 6.00183792e-02f, 2.13570148e-02f, 8.24282840e-02f, 2.97710579e-02f, -5.30049019e-02f,
  6.53583705e-02f, -1.46900686e-02f, 9.21756029e-02f, 9.99511629e-02f, 3.50616761e-02f, -5.68985427e-03f, 5.94113022e-02f, 1.34042829e-01f, 1.13705777e-01f, 1.58198848e-01f,
  1.43006502e-03f, -1.08664930e-02f, 2.05113124e-02f, 2.34974008e-02f, -8.80014226e-02f, 5.97866513e-02f, -1.20172249e-02f, -1.13931805e-01f, 4.32724841e-02f, -4.00943682e-02f,
  4.70471829e-02f, 4.02092971e-02f, 1.71956234e-02f, -3.18459347e-02f, -1.12542361e-02f, -6.44850135e-02f, -2.61693075e-02f, -8.58687051e-03f, -1.43669518e-02f, -1.35174934e-02f,
  -2.37823445e-02f, 8.85860175e-02f, -4.83810753e-02f, -5.23831397e-02f, 6.07215390e-02f, -8.45127404e-02f, 2.38973647e-03f, -4.92253676e-02f, -8.09205249e-02f, 4.69748899e-02f,
  -3.18959691e-02f, 4.99169789e-02f, -9.21093568e-04f, -3.19292955e-02f, 3.58754434e-02f, 4.62889224e-02f, 7.00457841e-02f, 3.74593846e-02f, 8.58239532e-02f, 1.85926463e-02f,
  -1.12810858e-01f, -2.00806055e-02f, -2.28430741e-02f, -2.16709431e-02f, 1.62787773e-02f, -6.01280965e-02f, 4.33290601e-02f, -9.96419787e-02f, -4.55659069e-02f, 4.33944203e-02f,
  -5.71129024e-02f, -4.50457260e-02f, -1.07969135e-01f, -6.51023760e-02f, -2.63882224e-02f, -4.97871544e-03f, 4.67950925e-02f, -8.26072097e-02f, -2.29326170e-02f, -3.98911349e-02f,
  -6.58117607e-02f, -1.35546103e-01f, 7.05642104e-02f, -1.26276948e-02f, 1.13983795e-01f, 5.46402670e-02f, 4.91811000e-02f, -9.31051001e-02f, -5.78624234e-02f, 7.69671053e-02f,
  -3.18556465e-02f, 3.71295996e-02f, 8.06501359e-02f, -6.19411618e-02f, -2.39297394e-02f, 6.27270490e-02f, -5.48454896e-02f, 8.30753893e-02f, -5.20621277e-02f, -7.82964751e-02f,
  9.75259021e-03f, 6.98829629e-03f, 3.88178974e-02f, -6.12592176e-02f, 6.90067932e-02f, -7.84353241e-02f, 2.58753784e-02f, 1.69145837e-02f, -1.03581131e-01f, -6.59177825e-02f,
  -5.01971208e-02f, 2.32328704e-04f, 2.40352042e-02f, -4.94826250e-02f, 1.02236718e-01f, 4.72326428e-02f, 1.23184204e-01f, 6.13692589e-02f, 5.29385470e-02f, 1.64993946e-02f,
  -5.99884279e-02f, 2.04656031e-02f, 1.06439404e-01f, 1.47919700e-01f, 1.07213661e-01f, 1.30875573e-01f, 1.87780727e-02f, 1.49189964e-01f, -3.95084471e-02f, -3.64276953e-02f,
  -3.16478088e-02f, -4.77484688e-02f, -7.00742677e-02f, -6.32356033e-02f, -6.76346049e-02f, -3.74823157e-03f, -2.28378493e-02f, -1.26180490e-02f, 1.00829788e-01f, 9.55809280e-02f,
  -4.71898764e-02f, -9.85821523e-03f, -1.95623413e-02f, -8.89412388e-02f, 6.99625835e-02f, -6.79555014e-02f, -1.72056463e-02f, -3.91861908e-02f, -2.44395453e-02f, -7.14193359e-02f,
  -6.69830292e-02f, 6.99983388e-02f, 3.56425308e-02f, 7.45858848e-02f, -9.55468044e-02f, -4.88770641e-02f, 5.59729896e-02f, 8.88899490e-02f, 2.31469963e-02f, 5.42787723e-02f,
  -9.02506616e-03f, -1.10093080e-01f, -8.90768319e-02f, 4.36110981e-02f, -3.65078375e-02f, -6.32210970e-02f, -7.52006993e-02f, 3.91395651e-02f, 4.44808379e-02f, -1.27127931e-01f,
  7.73486421e-02f, 6.72380552e-02f, 7.23009855e-02f, -8.49580020e-02f, 8.82542059e-02f, -1.80264171e-02f, 7.44189322e-02f, -3.92631553e-02f, 6.36658957e-03f, 4.44593243e-02f,
  3.47694121e-02f, -8.56146589e-02f, -4.82336394e-02f, -4.89293411e-03f, -4.77357022e-02f, 6.91215992e-02f, -2.54875943e-02f, -1.01245160e-03f, 6.48869276e-02f, -3.33786532e-02f,
  3.83262597e-02f, -4.77547646e-02f, -7.78809413e-02f, -7.21160099e-02f, 5.16517833e-02f, 5.32749295e-02f, 5.45507297e-02f, 5.66553287e-02f, -6.92406669e-02f, -4.68454398e-02f,
  -5.74526610e-03f, -2.93555297e-02f, -6.93407431e-02f, 1.14505179e-02f, -9.34578255e-02f, -6.82249889e-02f, 4.10483219e-02f, -6.16917908e-02f, -7.86445886e-02f, 6.87904060e-02f,
  7.26205483e-03f, -3.95813119e-03f, 3.66537310e-02f, -8.67262632e-02f, -6.02612309e-02f, -7.20876977e-02f, -3.51082869e-02f, -5.05376868e-02f, -4.04997095e-02f, -6.77906051e-02f,
  -4.74085769e-04f, 3.22112404e-02f, -8.85197520e-02f, 5.33274412e-02f, -7.62468502e-02f, -3.66674960e-02f, -9.04153958e-02f, -5.34160435e-02f, -4.90701906e-02f, -1.27271444e-01f,
  -1.62895828e-01f, -5.16694151e-02f, -6.62150830e-02f, -2.61398847e-04f, 4.34322618e-02f, 8.04843381e-02f, 1.75659880e-02f, 2.50531342e-02f, -5.03312284e-03f, -8.51047933e-02f,
  -1.80100817e-02f, 3.32246460e-02f, 4.58158106e-02f, -5.48866466e-02f, -5.30798696e-02f, -5.74785806e-02f, -9.96205658e-02f, 9.34588443e-03f, -7.37219229e-02f, 3.52417992e-04f,
  -1.01999603e-02f, -4.34487220e-03f, -4.60894257e-02f, 9.76787210e-02f, -7.14489724e-03f, 8.06574672e-02f, 6.52724430e-02f, 6.33867308e-02f, 1.40112108e-02f, -2.41352860e-02f,
  -1.38495164e-02f, -1.02110565e-01f, -1.42633272e-02f, -6.96669668e-02f, -6.75850213e-02f, -7.00105205e-02f, -8.05325434e-02f, -6.90984949e-02f, 8.63371193e-02f, 9.04266611e-02f,
  -2.39530820e-02f, 2.17308104e-02f, 2.01276112e-02f, -5.03408983e-02f, 1.08651422e-01f, 6.95360154e-02f, 9.13028196e-02f, -6.58161268e-02f, -5.94068468e-02f, 1.05109915e-01f,
  1.24432780e-01f, 6.70285374e-02f, 2.17262618e-02f, -3.93615700e-02f, 2.98096705e-02f, 4.51678969e-02f, 1.14120178e-01f, -2.31008753e-02f, -3.26423161e-02f, 4.40091081e-02f,
  -4.60788682e-02f, -8.01040009e-02f, 9.27053988e-02f, -1.69627164e-02f, 8.58390853e-02f, -7.50340298e-02f, 6.80024475e-02f, -1.49881179e-02f, 1.06216945e-01f, 1.72969233e-02f,
  6.83758631e-02f, 6.70872554e-02f, -4.36910242e-02f, 4.75851959e-03f, 1.06442481e-01f, 7.59873167e-02f, -4.23965640e-02f, 8.51102173e-02f, -2.34013237e-02f, 7.00984672e-02f,
  9.96218622e-02f, 5.69139011e-02f, 9.45463404e-02f, -2.88889110e-02f, 2.72626355e-02f, -4.01219688e-02f, 1.35169644e-02f, -3.84614896e-03f, 1.32346824e-02f, -8.83457363e-02f,
  9.46214870e-02f, 2.60330103e-02f, 3.50313336e-02f, -3.35650258e-02f, 2.05525644e-02f, -2.48898827e-02f, 9.70027149e-02f, 2.74265241e-02f, 1.87031310e-02f, 6.29783496e-02f,
  -3.54397632e-02f, 8.22949409e-02f, 1.01215336e-02f, 1.04016557e-01f, 4.55832332e-02f, 2.66338270e-02f, 3.14846113e-02f, 4.20553200e-02f, 1.08899854e-01f, 5.91385774e-02f,
  9.92284436e-03f, -3.57184634e-02f, -5.65571710e-02f, 5.60619421e-02f, 8.33984986e-02f, 6.17206357e-02f, -5.27668521e-02f, 7.10584819e-02f, 8.13138112e-03f, 4.77290750e-02f,
  1.67179868e-01f, -1.63808554e-01f, 1.65333107e-01f, -6.13190010e-02f, -1.63728654e-01f, -1.71988890e-01f, -2.41251096e-01f, -1.71443187e-02f, -2.34173033e-02f, -1.32459208e-01f,
  5.91609534e-03f, 1.31971434e-01f, 1.78982541e-01f, 1.17140181e-01f, 2.33385712e-01f, 1.65082663e-02f, 1.04269274e-01f, 2.24806651e-01f, 2.53425568e-01f, 1.01082791e-02f,
  3.23851290e-03f, -1.26665309e-01f, 1.54668853e-01f, 7.55091310e-02f, -1.54409096e-01f, 1.06086582e-01f, -1.06899478e-01f, 2.69088391e-02f, -1.02639288e-01f, -5.28555177e-02f,
  1.10871702e-01f, -1.94856189e-02f, 1.13781236e-01f, 4.44708839e-02f, 2.79036742e-02f, -8.33371803e-02f, -1.83796640e-02f, -1.76252704e-02f, 7.33701885e-02f, 1.11736520e-03f,
  4.40313034e-02f, 2.23197341e-02f, -5.81552088e-02f, 8.10455810e-03f, -3.08416933e-02f, -8.38508680e-02f, -4.49313261e-02f, 3.28007750e-02f, 8.33928287e-02f, -2.38143373e-02f,
  -7.23997280e-02f, -5.28960414e-02f, 1.04026213e-01f, 2.95486208e-02f, 1.67445932e-02f, 4.98774052e-02f, 4.40306477e-02f, -8.18342417e-02f, 6.09260313e-02f, -7.86703378e-02f,
  -8.11460055e-03f, -2.93427110e-02f, 2.57807579e-02f, 4.80456315e-02f, 6.08753413e-02f, 4.48862370e-03f, 2.66705398e-02f, 1.38595821e-02f, -4.65291031e-02f, -3.00682131e-02f,
  -4.04731743e-02f, 8.66580307e-02f, 7.86362588e-02f, -1.65619515e-03f, 6.08980209e-02f, 4.22379971e-02f, -5.79273589e-02f, -1.32745784e-02f, -1.80491675e-02f, -4.14862856e-02f,
  -4.33178693e-02f, -9.85053368e-04f, -6.50423169e-02f, -3.63950320e-02f, 1.89439952e-02f, -1.72470808e-02f, 5.76278241e-03f, -2.69985218e-02f, 6.28536791e-02f, -2.69327406e-02f,
  -6.88410699e-02f, 2.14250326e-01f, 4.05059382e-02f, 7.02141300e-02f, 2.33832859e-02f, -9.85013470e-02f, 6.96271881e-02f, 1.49153536e-02f, 9.63549167e-02f, 3.02077476e-02f,
  -5.20735197e-02f, 1.78284422e-02f, -3.15659381e-02f, -2.81554144e-02f, -4.20279503e-02f, -5.77375479e-02f, -4.85866405e-02f, 7.59553835e-02f, 7.95532390e-02f, -1.20547995e-01f,
  -7.54636824e-02f, 6.98832348e-02f, 1.07894994e-01f, 9.24719200e-02f, -5.36381314e-03f, 1.06170088e-01f, -5.32020396e-03f, 5.03830761e-02f, 1.20146386e-01f, -1.83792934e-01f,
  5.56901246e-02f, -1.64400816e-01f, 1.37897730e-01f, 4.89518940e-02f, 4.03577611e-02f, -7.39544407e-02f, -1.12809412e-01f, -8.12295973e-02f, -1.14174731e-01f, -1.20653629e-01f,
  -1.55622527e-01f, -1.45127222e-01f, -5.98155856e-02f, 2.94874627e-02f, 6.55086152e-03f, 5.11210971e-02f, -5.27803302e-02f, 1.40155375e-01f, 1.44611835e-01f, 2.29308307e-02f,
  -7.15906024e-02f, -2.87119560e-02f, 1.40826687e-01f, 7.33151808e-02f, 8.86773504e-03f, 5.67077361e-02f, -5.09469248e-02f, 2.66856663e-02f, -4.79878932e-02f, -9.49629843e-02f,
  -4.20741998e-02f, 7.51091912e-02f, 4.84145135e-02f, -8.62021595e-02f, 4.00813855e-02f, -2.62169447e-02f, 4.02802899e-02f, 6.15992472e-02f, 2.01908890e-02f, 3.52749601e-02f,
  -8.66893232e-02f, -7.49503896e-02f, -1.02956288e-01f, -8.50020051e-02f, -1.69958714e-02f, 4.44066674e-02f, -6.83514327e-02f, -6.07877262e-02f, -2.88317464e-02f, -9.23305098e-03f,
  8.73342715e-03f, 7.72807822e-02f, -3.78075875e-02f, -5.98972058e-03f, 6.38150573e-02f, 1.49503881e-02f, -8.80823135e-02f, 3.43506373e-02f, -4.67576906e-02f, -7.39857033e-02f,
  1.51528725e-02f, -2.28193235e-02f, -4.94821405e-04f, -1.10213012e-01f, -3.77717949e-02f, -4.07961830e-02f, 8.87970179e-02f, 4.40282449e-02f, 2.84312833e-02f, 3.80471312e-02f,
  -7.89908171e-02f, 2.15246864e-02f, -2.43866025e-03f, -4.43585776e-02f, -8.70877355e-02f, 3.62703092e-02f, 1.13684230e-03f, -9.44096670e-02f, 2.44595930e-02f, -9.47499275e-02f,
  -1.02609321e-02f, 4.86436747e-02f, 5.40611334e-02f, -9.67382193e-02f, -3.96804325e-02f, 8.90285373e-02f, -4.19779643e-02f, -5.49851917e-02f, -1.07598910e-03f, -7.01345280e-02f,
  -3.96342799e-02f, 6.43957853e-02f, -8.77708942e-02f, -5.64409532e-02f, 3.91094573e-02f, 7.33202547e-02f, 1.67506933e-02f, 2.44627576e-02f, 9.27430764e-03f, 1.00526586e-03f,
  -9.72834677e-02f, 3.03579727e-03f, -5.86795807e-02f, -8.23226497e-02f, 6.05743602e-02f, 9.30640548e-02f, 7.82566071e-02f, 5.91916256e-02f, 9.22115147e-02f, 2.40442567e-02f,
  -1.03791840e-02f, -5.36767021e-03f, 9.31333676e-02f, 9.01019722e-02f, 2.42629852e-02f, 9.76835489e-02f, -3.87530178e-02f, -3.20989005e-02f, 1.24063134e-01f, 1.40455797e-01f,
  -1.76509768e-02f, 1.93848163e-02f, 2.67743552e-03f, 5.61146513e-02f, 1.26381278e-01f, -8.33736658e-02f, -3.84383984e-02f, -1.00240923e-01f, -1.56353340e-02f, -5.94403856e-02f,
  -9.52435774e-04f, 1.34656951e-01f, 5.81797250e-02f, 1.59641188e-02f, -4.67663966e-02f, -5.45275398e-04f, -2.93334154e-03f, 4.23826762e-02f, -9.44333822e-02f, -4.90076989e-02f,
  1.26302063e-01f, 9.01287496e-02f, 8.29750150e-02f, 8.33571330e-02f, 1.47037551e-01f, 9.36900303e-02f, -1.00576822e-02f, 4.90242355e-02f, 1.98400673e-02f, 9.20716226e-02f,
  6.20889813e-02f, -2.76200585e-02f, 2.17104703e-02f, 6.86038658e-02f, 3.22000310e-02f, -3.92722860e-02f, 9.15360525e-02f, -4.97326441e-03f, -8.93394649e-02f, 8.13784227e-02f,
  4.79762182e-02f, 5.43178208e-02f, 2.24293936e-02f, 1.00266799e-01f, -7.20361397e-02f, 6.20909333e-02f, -6.89570159e-02f, -1.24987662e-01f, -8.41945633e-02f, 1.94546413e-02f,
  4.71713133e-02f, -2.17599468e-03f, -4.27843817e-02f, -4.90013734e-02f, -1.34745911e-01f, 7.41805807e-02f, 3.53100058e-03f, 8.00679997e-02f, 2.76436377e-02f, -3.24915834e-02f,
  -8.15774575e-02f, 5.63863181e-02f, -1.78177617e-02f, -1.91173665e-02f, 6.93588778e-02f, 4.85251397e-02f, 1.88219082e-02f, 6.33761212e-02f, -4.80668545e-02f, -6.61924854e-02f,
  -3.77736501e-02f, -3.56851853e-02f, -1.82822440e-02f, -3.02791391e-02f, 5.94555885e-02f, 7.07380027e-02f, -7.40804002e-02f, 3.08710942e-03f, -6.92330301e-02f, -5.40462881e-02f,
  -5.09454347e-02f, -9.39030349e-02f, 7.81267509e-02f, -3.06740571e-02f, 4.37181592e-02f, 1.21125523e-02f, 4.11043726e-02f, 8.54367390e-02f, 5.66007681e-02f, 3.48695405e-02f,
  -1.75057948e-02f, -1.60420790e-01f, 1.76526718e-02f, 1.01693250e-01f, -5.21565117e-02f, -6.95762187e-02f, -5.41360974e-02f, 2.80247554e-02f, 7.38719478e-02f, 4.43331711e-02f,
  3.14112976e-02f, -9.37603340e-02f, 9.49761569e-02f, -3.13680097e-02f, 3.28628123e-02f, 8.50680023e-02f, -3.47512849e-02f, -6.31041080e-02f, -1.80984475e-02f, -2.80355830e-02f,
  4.12186049e-02f, -7.90395774e-03f, -1.18504606e-01f, -8.07221383e-02f, -2.47729104e-02f, -4.58913110e-03f, -8.49460214e-02f, 6.25695195e-03f, -5.08801639e-02f, -2.13936605e-02f,
  1.96733549e-01f, -1.08338796e-01f, 9.13508013e-02f, 7.12232962e-02f, 1.83642879e-01f, 9.87771899e-02f, 2.16056943e-01f, 1.99160278e-01f, 1.32658094e-01f, 1.33761719e-01f,
  6.35265037e-02f, 1.60477385e-01f, 1.92140132e-01f, 2.69952081e-02f, 1.05678804e-01f, 1.95576046e-02f, -5.39431684e-02f, 8.47052224e-03f, 1.95450783e-01f, 1.25009850e-01f,
  8.71991590e-02f, 2.83006337e-02f, -4.75062877e-02f, 1.72611866e-02f, -5.68223149e-02f, 4.50397618e-02f, -2.20064260e-03f, -1.11693442e-01f, -7.59743378e-02f, -6.66597262e-02f,
  -6.44216537e-02f, -7.32140243e-02f, 1.08988874e-01f, -5.81264310e-02f, -1.02095261e-01f, 5.77648431e-02f, 4.24188077e-02f, -4.46328335e-02f, 2.09294334e-02f, 1.61855761e-02f,
  3.74734253e-02f, -5.57111911e-02f, 8.85978714e-03f, -1.19604897e-02f, -8.53470191e-02f, 1.84328519e-02f, -1.32529303e-01f, 3.63110332e-03f, 5.63875027e-02f, -9.76358727e-02f,
  2.00221571e-03f, -5.75492568e-02f, 5.60692400e-02f, -5.94328679e-02f, 7.69708604e-02f, 7.49542788e-02f, 8.93171132e-03f, -8.50269049e-02f, 5.27372546e-02f, 9.99283139e-03f,
  -1.34963645e-02f, -1.16240128e-03f, 7.39848986e-02f, 9.19827595e-02f, 7.83877522e-02f, 5.92598096e-02f, -3.57959457e-02f, -6.89218640e-02f, 9.59964618e-02f, 2.89742107e-04f,
  1.31072197e-02f, 1.13027796e-01f, -1.01866731e-02f, -1.53671419e-02f, 6.54776841e-02f, -5.39592765e-02f, 6.25712648e-02f, 2.21122727e-02f, -4.98469882e-02f, 6.53296858e-02f,
  4.33352450e-03f, 3.11872587e-02f, 1.39717832e-02f, -9.97718610e-03f, 7.83332214e-02f, -6.45169765e-02f, -5.17544709e-02f, 5.57827428e-02f, 2.53726542e-02f, -2.32503805e-02f,
  5.65252043e-02f, 7.44184479e-02f, 1.25822917e-01f, 2.55286545e-02f, -8.90974626e-02f, -3.03784087e-02f, 6.16708659e-02f, -6.08558655e-02f, -4.67684306e-02f, -5.65790758e-02f,
  -4.69807237e-02f, -2.83886958e-02f, -3.43294479e-02f, 7.05320900e-03f, 9.41723436e-02f, -6.74966052e-02f, -7.03638941e-02f, 9.42868143e-02f, 3.21711786e-02f, -9.43586826e-02f,
  -1.17004868e-02f, -3.07696089e-02f, 5.90417013e-02f, 1.72500201e-02f, 3.35484780e-02f, 1.46660775e-01f, -3.85395736e-02f, -5.60497772e-03f, -8.09469726e-03f, -5.49910069e-02f,
  2.71868676e-01f, 1.60484284e-01f, 1.00149095e-01f, 6.03752118e-03f, -4.47896868e-02f, -3.20814364e-02f, 9.37058777e-02f, 9.84204933e-03f, -2.85251681e-02f, -1.10263843e-02f,
  3.50025087e-03f, 5.97714912e-03f, 5.78985550e-02f, -8.19977522e-02f, -6.63330853e-02f, -9.72048659e-03f, 9.40431878e-02f, -4.56523411e-02f, 3.63171622e-02f, -6.31791800e-02f,
  1.79391913e-02f, 1.31844014e-01f, 1.51443571e-01f, -4.61100675e-02f, 1.62761882e-02f, 3.89818288e-02f, 1.95784196e-02f, -5.41770272e-02f, 8.41095150e-02f, -4.36398275e-02f,
  -6.81075007e-02f, 1.17077649e-01f, -9.87861082e-02f, 9.64076221e-02f, -1.57819912e-02f, -1.89162511e-02f, -1.30596654e-02f, -1.69881545e-02f, -3.96077149e-02f, -3.26869898e-02f,
  -3.45138577e-03f, -2.01140046e-02f, 1.96729191e-02f, -2.43146606e-02f, 1.02028243e-01f, -3.43230665e-02f, 1.32612959e-01f, 6.71710595e-02f, -3.49537991e-02f, 4.52897660e-02f,
  -6.26076981e-02f, -6.75477386e-02f, 1.91538185e-02f, 7.57096335e-02f, -2.99764294e-02f, -6.32183328e-02f, -2.84215342e-02f, 9.40675065e-02f, 4.72367136e-03f, 7.40901232e-02f,
  -7.34010758e-03f, -9.79560390e-02f, -2.92879008e-02f, -2.29197480e-02f, 4.65464629e-02f, -5.50475046e-02f, 3.34651843e-02f, -5.83326556e-02f, -6.54685423e-02f, -8.26763362e-02f,
  -8.81621167e-02f, -7.99922331e-04f, -7.28332102e-02f, -5.80043010e-02f, -5.07913418e-02f, 5.27149474e-04f, -2.52438821e-02f, 3.83792818e-02f, -5.19131497e-02f, -4.92095202e-02f,
  1.91750526e-02f, 5.14081381e-02f, -5.94454221e-02f, -8.83472338e-03f, -5.40202744e-02f, -7.06481785e-02f, -3.39500234e-02f, 3.06383595e-02f, 6.67957738e-02f, -7.30341598e-02f,
  -8.20782781e-02f, -7.91733563e-02f, 3.48017514e-02f, 1.09043121e-01f, -6.44817054e-02f, 1.19057424e-01f, 2.30540615e-02f, -1.35189742e-02f, 2.19948217e-02f, -1.18358545e-02f,
  1.43081434e-02f, 8.89899954e-03f, 7.34288096e-02f, -5.72235920e-02f, 3.91056649e-02f, 2.74132378e-02f, 7.05771074e-02f, 5.59115261e-02f, 2.21670251e-02f, 1.38422316e-02f,
  -3.44832754e-03f, 7.94603676e-02f, -2.44788155e-02f, -6.37875721e-02f, -1.80214886e-02f, -3.72890942e-02f, -2.38753040e-03f, -8.53062049e-02f, -5.97542711e-02f, 1.25985558e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.19133629e-01f, 2.44322851e-01f, 1.11288875e-01f, 5.48377968e-02f, -8.39014947e-02f, 8.79495069e-02f, 4.63117007e-03f, 9.86117274e-02f, 1.42819315e-01f, 1.59244522e-01f,
  1.72252104e-01f, -2.65613925e-02f, -4.64570858e-02f, -1.54243140e-02f, 2.16384586e-02f, 1.93317264e-01f, 4.27675620e-02f, 1.27095357e-02f, -2.70134639e-02f, -5.22090197e-02f,
  -6.79430813e-02f, 2.16044053e-01f, 9.85514745e-02f, -4.03978266e-02f, 9.72303301e-02f, 1.21855468e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  2.63245404e-01f, 9.94997323e-02f, 5.05908951e-02f, 3.66520993e-02f, -1.09865017e-01f, 6.84226006e-02f, -1.39496714e-01f, 2.43452474e-01f, -5.79490587e-02f, 6.81579635e-02f,
  3.14239174e-01f, 1.62255347e-01f, 1.78136781e-01f, -3.05585623e-01f, 1.15456492e-01f, 2.47695863e-01f, 1.93440914e-01f, 6.02357350e-02f, 7.28219822e-02f, 1.88933283e-01f,
  2.73468643e-01f, 4.96405847e-02f, -3.76015037e-01f, -1.27529248e-03f, 1.10922538e-01f, -9.61397365e-02f, -7.23138675e-02f, -1.68507174e-01f, 2.96875685e-01f, -8.18691254e-02f,
  -3.20815071e-02f, 1.49267703e-01f, -4.12439436e-01f, 3.01770985e-01f, -3.45423818e-01f, 1.76161781e-01f, 2.07409874e-01f, 7.79514089e-02f, -2.53345788e-01f, 2.28045121e-01f,
  5.52975610e-02f, -8.22342858e-02f, -1.02901580e-02f, -1.99294195e-01f, -9.55879092e-02f, -6.31651506e-02f, -1.61898490e-02f, -1.61460534e-01f, 2.06104562e-01f, -3.55453752e-02f,
  -1.07480049e-01f, -6.63798302e-02f, 1.33389339e-01f, -2.33035106e-02f, 8.13589692e-02f, -1.08010747e-01f, -4.33649123e-02f, -1.07319899e-01f, 4.38779369e-02f, -2.24956870e-02f,
  1.25684410e-01f, 1.84943393e-01f, -2.40037531e-01f, 1.14223883e-01f, -2.13880748e-01f, -6.37522489e-02f, 1.22717489e-02f, 2.64568534e-02f, -8.70478004e-02f, -1.22312441e-01f,
  4.65802141e-02f, -5.75031377e-02f, -4.16592173e-02f, -9.05360356e-02f, -2.27456260e-02f, 3.49030197e-02f, -1.10569805e-01f, 1.23509422e-01f, 2.17240706e-01f, -7.76694641e-02f,
  1.48903523e-02f, -9.29215848e-02f, 9.75574329e-02f, 8.36016089e-02f, -3.16534311e-01f, -2.67974794e-01f, 3.80787730e-01f, 3.68014157e-01f, -2.45828718e-01f, 1.56631723e-01f,
  -1.49009526e-01f, 1.90103620e-01f, -1.80899069e-01f, 6.36280701e-02f, -6.40178546e-02f, 2.18769133e-01f, 4.07512814e-01f, -2.01572310e-02f, 2.07128152e-01f, -3.13976318e-01f,
  -2.48513028e-01f, -7.51127005e-02f, -6.96642473e-02f, 1.32824972e-01f, -5.51970713e-02f, 4.82000969e-03f, 7.31127337e-02f, -2.85241455e-02f, 5.25704883e-02f, -3.02031096e-02f,
  -3.39654423e-02f, 6.05527312e-02f, -1.65120572e-01f, 1.54037267e-01f, -5.80008887e-02f, -7.49259163e-03f, 4.29141074e-02f, 3.00347749e-02f, -7.56434649e-02f, 1.10767640e-01f,
  2.61077587e-03f, -7.31490478e-02f, 1.41163707e-01f, -2.76211947e-01f, 2.54172329e-02f, 1.26344599e-02f, 9.94853973e-02f, -1.25996441e-01f, -1.01679690e-01f, -3.05052251e-02f,
  -1.99017406e-01f, 2.80710869e-02f, 9.80009697e-03f, -1.06112868e-01f, -2.15340897e-01f, 1.33540496e-01f, 1.28145903e-01f, -1.41218022e-01f, -2.00382888e-01f, -1.79264948e-01f,
  -9.06266943e-02f, -1.75164655e-01f, -1.85103506e-01f, -5.17841093e-02f, 1.35929650e-03f, 6.37911335e-02f, -1.37238771e-01f, 1.77290708e-01f, 2.74178833e-02f, 1.25886992e-01f,
  -6.20929822e-02f, 6.06757291e-02f, 1.12456560e-01f, -2.79226750e-01f, 4.81475502e-01f, 2.12456152e-01f, -2.33310640e-01f, -2.89695024e-01f, 9.97469015e-03f, -2.23002926e-01f,
  1.46657795e-01f, -2.18187168e-01f, 1.23317763e-01f, 2.62061447e-01f, 1.56365186e-01f, 4.05374497e-01f, 3.25711668e-01f, 1.29517034e-01f, -1.19075529e-01f, -1.18854247e-01f,
  1.22099772e-01f, 8.02617967e-02f, 6.66363463e-02f, -5.18284887e-02f, 4.43382747e-02f, 8.41638148e-02f, 4.90335934e-02f, -5.13120554e-02f, 1.72516286e-01f, -1.65312812e-01f,
  -1.23832747e-01f, 2.64224838e-02f, 2.37094119e-01f, 2.66422462e-02f, 9.03863285e-04f, -1.60281032e-01f, 1.50933206e-01f, 3.57186832e-02f, -5.65902591e-02f, 8.69956836e-02f,
  -3.55176278e-04f, -7.00267777e-02f, 1.28436655e-01f, -1.18477896e-01f, 1.34254038e-01f, 1.36895567e-01f, 1.27242785e-02f, 1.47420391e-01f, -2.50253975e-02f, 1.04561225e-01f,
  1.11060299e-01f, -1.35765523e-01f, 3.99651378e-02f, 1.11644588e-01f, -8.66640508e-02f, 1.02048181e-01f, -3.03019471e-02f, -9.80824679e-02f, 2.86064595e-02f, 7.00326264e-02f,
  -3.01627405e-02f, -1.69128940e-01f, -1.58769622e-01f, -3.19771707e-01f, 1.74119875e-01f, -6.50860146e-02f, -1.39015958e-01f, -1.35910407e-01f, -2.85125617e-02f, -1.67802259e-01f,
  -2.92239815e-01f, 1.49708599e-01f, -1.27224341e-01f, -7.43305758e-02f, 2.52478451e-01f, -5.00760496e-01f, 1.34480864e-01f, 2.19841115e-02f, -8.07527602e-02f, 2.04545796e-01f,
  -5.32835871e-02f, -1.72732890e-01f, 6.37963116e-02f, 8.30744579e-02f, 1.34114530e-02f, 1.37200981e-01f, -7.76087269e-02f, 1.83229268e-01f, 1.23562083e-01f, 1.51725754e-01f,
  5.34850769e-02f, -2.31136739e-01f, 6.21484034e-02f, 5.97025640e-02f, 2.60076914e-02f, 2.40087975e-02f, -5.93487546e-02f, 5.84942400e-02f, -1.61268890e-01f, 9.35747996e-02f,
  -3.48003879e-02f, 1.35754704e-01f, 1.41795233e-01f, -2.26418212e-01f, -3.77747975e-02f, 9.65836644e-02f, -4.99405973e-02f, 9.25540030e-02f, -8.51120576e-02f, 1.98479444e-01f,
  -2.74790032e-03f, 8.77537578e-02f, -6.65210560e-02f, -4.17443030e-02f, -1.06193557e-01f, 4.91389818e-02f, -9.37650651e-02f, -3.93418819e-02f, 9.84156728e-02f, 2.02527314e-01f,
  -5.53674102e-02f, -1.16771035e-01f, 7.75126591e-02f, -3.19122598e-02f, -8.54722783e-02f, 1.32448524e-01f, 1.21681854e-01f, -5.59113659e-02f, 1.98696524e-01f, 1.91479288e-02f,
  1.43501073e-01f, -1.74761519e-01f, 2.10005060e-01f, -1.42000124e-01f, -2.57765561e-01f, 2.92082042e-01f, 3.95915583e-02f, -7.53347501e-02f, -8.52021128e-02f, -1.12612359e-01f,
  -3.58489268e-02f, -4.77122776e-02f, -1.00767516e-01f, 2.09970012e-01f, 7.75279030e-02f, -5.01710139e-02f, -4.05227952e-02f, 9.67485644e-03f, 2.38462724e-02f, -4.96192649e-02f,
  1.59202665e-02f, -1.55488491e-01f, 1.91568568e-01f, 2.15184823e-01f, -9.43721831e-02f, 6.00769930e-02f, -5.85488230e-02f, -5.38435159e-03f, -1.07169449e-01f, -1.56495109e-01f,
  -1.05924524e-01f, 5.57667613e-02f, -1.30207136e-01f, 1.14219554e-01f, 3.20263281e-02f, -1.36793286e-01f, 1.00293033e-01f, 1.91998798e-02f, -1.26366526e-01f, 6.67465627e-02f,
  -1.61733866e-01f, -3.36849064e-01f, -2.08514750e-01f, -2.32562929e-01f, 1.43207079e-02f, -2.12228507e-01f, 3.62563021e-02f, -9.35865343e-02f, -7.17946514e-02f, 9.61108040e-03f,
  -2.31511310e-01f, -2.11615264e-02f, -2.27814853e-01f, 1.57367364e-02f, -1.05658755e-01f, 7.62947500e-02f, 8.66397843e-02f, -1.23610403e-02f, -4.86605056e-02f, -3.42537969e-01f,
  -3.29619609e-02f, 5.99053949e-02f, 2.46997535e-01f, 1.00307882e-01f, -2.23000571e-01f, -1.71536669e-01f, -3.13788593e-01f, -1.50622576e-01f, -4.14245874e-01f, 2.36352682e-01f,
  -5.58436960e-02f, 1.71734482e-01f, 3.15223426e-01f, -1.66118592e-01f, -1.97294608e-01f, 3.03306174e-03f, -2.14866400e-01f, -1.23467475e-01f, -2.62693435e-01f, -6.44639805e-02f,
  -4.89856116e-02f, 1.58482090e-01f, 7.00016618e-02f, 8.98060650e-02f, 3.33766788e-02f, 8.04407597e-02f, -1.23969121e-02f, 1.23005338e-01f, 1.00511196e-03f, 7.60785937e-02f,
  4.51957695e-02f, 9.83554199e-02f, 1.29352165e-02f, 1.30068451e-01f, -4.83535528e-02f, -4.23304141e-02f, 7.01580523e-03f, 1.94124226e-02f, 6.73755780e-02f, -1.51663259e-01f,
  3.80049571e-02f, -1.05479106e-01f, -9.57588293e-03f, 5.91713712e-02f, -3.50850672e-02f, -2.46988609e-02f, -6.04278632e-02f, 5.06588630e-02f, -9.87407416e-02f, -1.86043121e-02f,
  1.46329254e-02f, -5.58764078e-02f, -1.03953660e-01f, -4.17331979e-02f, -1.82361677e-01f, 5.01365997e-02f, -3.79783548e-02f, 1.76510945e-01f, 3.95062417e-02f, -1.05273694e-01f,
  -4.13725637e-02f, -8.63469392e-02f, 9.68832821e-02f, 4.07927856e-02f, -1.20281041e-01f, -1.62008181e-01f, 2.95973033e-01f, 1.08844265e-01f, -1.39366716e-01f, 2.18978003e-01f,
  3.56488340e-02f, 3.21729511e-01f, -3.64435390e-02f, -2.87769586e-01f, 1.10174023e-01f, -1.03060693e-01f, 2.53525257e-01f, 7.87571594e-02f, 3.25431764e-01f, -2.55662262e-01f,
  -1.02348298e-01f, -1.61100686e-01f, -5.30607291e-02f, 4.69368547e-02f, -5.13106920e-02f, 5.73056154e-02f, 1.42821789e-01f, 1.10410847e-01f, 1.73644703e-02f, -1.56031013e-01f,
  -3.08681112e-02f, 4.25684266e-02f, -2.27310136e-01f, 1.88271597e-01f, -6.56576231e-02f, 1.06864388e-03f, -3.81866172e-02f, 4.91575673e-02f, 4.12327098e-03f, 1.20711684e-01f,
  -1.41363144e-01f, -7.46460930e-02f, 5.98429292e-02f, -7.11657852e-02f, -2.69091763e-02f, 8.86347368e-02f, 1.64342433e-01f, -1.36201875e-02f, -8.48899931e-02f, -1.15173228e-01f,
  -1.61989808e-01f, 6.89687114e-03f, -1.55962393e-01f, -1.25279576e-01f, -4.41009067e-02f, 2.95599748e-04f, -1.33447140e-01f, 1.10514961e-01f, -5.90355881e-02f, -2.03694344e-01f,
  -1.71592519e-01f, 3.95744666e-02f, -3.28342676e-01f, -1.26538947e-01f, -4.50737542e-03f, -1.93203583e-01f, 1.32593930e-01f, 2.30820134e-01f, 3.83640200e-01f, 2.04379529e-01f,
  1.11197159e-01f, -2.90047437e-01f, 6.48338273e-02f, 2.33970210e-01f, 1.09139986e-01f, -7.00239763e-02f, 3.74848731e-02f, 1.44950807e-01f, 1.40927061e-01f, 5.30238450e-02f,
  -1.13179967e-01f, -2.26246253e-01f, 1.13143966e-01f, 1.82461292e-01f, 2.85283953e-01f, 3.60317409e-01f, 1.55266911e-01f, -8.64139795e-02f, -1.70107156e-01f, -2.08818391e-01f,
  9.59762856e-02f, -1.26885191e-01f, -3.55760343e-02f, -1.29911870e-01f, -1.05295792e-01f, -5.13189360e-02f, -1.31535500e-01f, -1.73888244e-02f, 1.19228877e-01f, 8.35503191e-02f,
  -1.41763091e-01f, -8.47287402e-02f, 7.04666078e-02f, 1.41812086e-01f, -1.04343593e-01f, 2.05059990e-01f, 1.51904628e-01f, -3.83339375e-02f, -1.56375051e-01f, -1.72493774e-02f,
  1.63469076e-01f, -6.59085140e-02f, -1.42242774e-01f, -1.01801336e-01f, 6.22302247e-03f, 5.75645305e-02f, -1.42672528e-02f, 1.34557914e-02f, 7.71074730e-04f, -5.85152246e-02f,
  3.97745445e-02f, 1.20115876e-02f, -1.58862889e-01f, 6.27997443e-02f, -2.82305405e-02f, -8.19347613e-03f, -8.43637660e-02f, 4.15052511e-02f, 2.19786391e-02f, -1.25852227e-01f,
  1.24344595e-01f, 1.65695980e-01f, -8.74724686e-02f, 1.59095451e-02f, -1.41918451e-01f, -1.96519300e-01f, -2.27552317e-02f, 2.98304409e-01f, -9.23866685e-03f, -1.33913994e-01f,
  3.65010679e-01f, -2.40000784e-01f, 3.34664285e-02f, -1.58301070e-01f, 1.97212622e-02f, 6.50892705e-02f, 2.93235928e-01f, 4.17642891e-02f, 1.17794633e-01f, 1.37336910e-01f,
  1.08054586e-01f, 7.52993533e-03f, 8.24766681e-02f, -2.18067467e-02f, -4.16570939e-02f, -8.13608244e-02f, 9.28969458e-02f, -7.71899223e-02f, -1.92672070e-02f, -9.15306956e-02f,
  -1.34380579e-01f, -1.53005973e-01f, 5.67696765e-02f, 1.20247923e-01f, -2.09354125e-02f, 1.15785360e-01f, 7.98124745e-02f, -1.53340131e-01f, -4.97878194e-02f, -8.03537071e-02f,
  8.33844170e-02f, 1.84350625e-01f, 4.14832979e-02f, 3.24842520e-02f, -3.06122303e-02f, 6.83775768e-02f, -1.01912230e-01f, 6.13627918e-02f, 3.23125049e-02f, -5.26088700e-02f,
  -1.96221128e-01f, -1.21127188e-01f, 1.92322940e-01f, -1.84090640e-02f, -3.86586040e-02f, -3.02522816e-02f, -3.04514676e-01f, -4.98237573e-02f, -1.77187160e-01f, 2.17182264e-01f,
  -1.57769904e-01f, -3.17263417e-02f, 6.19848818e-02f, -1.86064225e-02f, -4.65074293e-02f, 7.58044943e-02f, 3.95721085e-02f, 7.58767650e-02f, 2.95618568e-02f, -2.42390528e-01f,
  -1.51904017e-01f, 2.18268052e-01f, -2.35616162e-01f, -2.57921457e-01f, 2.63068050e-01f, -2.95739528e-02f, 1.08121976e-01f, -9.51030627e-02f, 1.17598042e-01f, -3.52237403e-01f,
  2.71627873e-01f, -9.73715261e-02f, 3.09313118e-01f, 2.53603369e-01f, -5.69316037e-02f, -2.10406870e-01f, -1.00049041e-01f, 8.45301524e-02f, -5.75962588e-02f, 1.75103262e-01f,
  -1.46639468e-02f, 1.75289840e-01f, -8.63244310e-02f, -1.82392210e-01f, -1.41895935e-01f, -2.09550913e-02f, -5.93178254e-03f, 9.41040367e-02f, 9.65128317e-02f, 6.97059482e-02f,
  -1.69251978e-01f, 3.70076448e-02f, -8.73414874e-02f, 1.33608252e-01f, -5.75531088e-02f, 2.89110661e-01f, 1.28595114e-01f, 3.47543024e-02f, 1.05397686e-01f, -1.14465751e-01f,
  1.01402272e-02f, 1.29406154e-01f, -5.14355600e-02f, 3.92043516e-02f, 6.62150010e-02f, 3.34373768e-03f, -7.25726187e-02f, -3.97523604e-02f, 8.19796696e-02f, -1.74618408e-01f,
  -1.49669319e-01f, -1.07991569e-01f, -1.24137104e-01f, 4.69790176e-02f, -2.04875111e-03f, -8.37642327e-02f, -5.40087838e-03f, 8.93592164e-02f, -5.83729707e-02f, -4.91924733e-02f,
  -1.91191211e-01f, -2.85023749e-01f, -2.36833945e-01f, -7.39420056e-02f, 9.83852223e-02f, -6.00139461e-02f, -2.54227757e-01f, -2.99530506e-01f, 9.28896442e-02f, 3.03279907e-01f,
  -1.50697827e-01f, -1.80945203e-01f, -1.44075871e-01f, -2.20449269e-01f, -1.13106027e-01f, 8.66601914e-02f, 1.15567550e-01f, 8.28740895e-02f, -2.39239082e-01f, -8.97909999e-02f,
  1.12217203e-01f, 6.17867149e-02f, -8.54971707e-02f, -3.02702505e-02f, -8.74407589e-02f, 9.75929424e-02f, 1.46085560e-01f, 7.82117322e-02f, -3.47400829e-02f, -7.23414123e-02f,
  7.52596259e-02f, -9.30867344e-03f, 1.75712287e-01f, -1.29043430e-01f, -9.25669149e-02f, -1.82869494e-01f, 1.33241296e-01f, 1.04571156e-01f, 2.13764384e-02f, 2.62121171e-01f,
  -8.08834583e-02f, -3.12262904e-02f, -8.05719495e-02f, 1.23856589e-01f, -2.88637187e-02f, 5.15478402e-02f, 2.42142886e-01f, -7.83529133e-02f, 1.21469326e-01f, -1.06505692e-01f,
  -7.40367249e-02f, -1.10840082e-01f, -7.98051357e-02f, 2.45843921e-02f, -1.47162760e-02f, 8.98418948e-02f, -1.20475844e-01f, 6.79429322e-02f, 2.20814988e-01f, -2.66652126e-02f,
  -7.05042332e-02f, 5.49758971e-02f, 4.39042412e-02f, -6.33697072e-03f, -4.05663252e-01f, -3.82364810e-01f, 6.64178357e-02f, 1.92472339e-01f, 6.34822473e-02f, 1.68640524e-01f,
  -1.79183066e-01f, 2.98755933e-02f, 5.81664219e-02f, 3.23031954e-02f, 2.69176364e-02f, 1.42570123e-01f, 1.72433868e-01f, -1.57113031e-01f, 2.73176134e-01f, -1.17784843e-01f,
  -1.30119979e-01f, -1.65813357e-01f, -2.41435111e-01f, -1.04560271e-01f, -9.81852412e-02f, 1.84958771e-01f, 9.26201940e-02f, 2.26133689e-01f, 9.97292623e-02f, 2.12596014e-01f,
  8.56195688e-02f, -1.27921388e-01f, -1.07187897e-01f, 1.44666051e-02f, 3.00936233e-02f, -1.12065569e-01f, -4.50807735e-02f, 1.50612503e-01f, -1.64176673e-01f, -1.15556652e-02f,
  -3.88682894e-02f, -4.62793261e-02f, -7.40348846e-02f, 1.90462574e-01f, 2.11060852e-01f, -1.33204520e-01f, -6.42167032e-02f, 1.10919453e-01f, 1.37343094e-01f, 2.17646822e-01f,
  2.42530212e-01f, 7.12594390e-02f, -2.57353187e-02f, -5.18786684e-02f, 9.35327038e-02f, -4.44606282e-02f, 2.28810459e-02f, 3.79681699e-02f, 2.14441881e-01f, 1.43041015e-01f,
  1.05013557e-01f, -1.68605506e-01f, 2.81003624e-01f, 7.84911588e-02f, 4.40440513e-02f, 1.28419966e-01f, -3.36425789e-02f, 1.86107174e-01f, -3.67008358e-01f, -3.48938197e-01f,
  -3.20865780e-01f, 1.74641237e-01f, -5.54776192e-02f, 3.86892520e-02f, 7.36257136e-02f, 2.29650706e-01f, 3.32033992e-01f, -1.47425413e-01f, 6.02486581e-02f, 3.14385705e-02f,
  -8.63981172e-02f, 4.18037437e-02f, 7.85934925e-02f, -1.22878686e-01f, 6.57481849e-02f, -1.89887043e-02f, -4.58806567e-02f, 2.63202578e-01f, 5.39845899e-02f, 1.40519664e-01f,
  -6.31007850e-02f, 1.10697895e-01f, -1.12509504e-01f, 1.76944301e-01f, -3.40979509e-02f, -1.05554812e-01f, 9.00701955e-02f, 1.00867204e-01f, 1.33791164e-01f, -6.69004321e-02f,
  9.09390002e-02f, 2.56421063e-02f, 5.69252372e-02f, -1.84302285e-01f, 1.02963008e-01f, -1.73732638e-01f, -9.78834108e-02f, 6.76716492e-02f, 9.00372863e-03f, -6.43935502e-02f,
  -8.50499198e-02f, 7.62638003e-02f, -4.95790951e-02f, 1.38222158e-01f, 4.75120470e-02f, -2.48846579e-02f, -1.80318490e-01f, 1.05801709e-01f, -1.13821000e-01f, 6.03081360e-02f,
  5.53704686e-02f, 8.23558867e-03f, 1.71466723e-01f, -6.57234415e-02f, 1.34105444e-01f, -6.17181584e-02f, 1.83277786e-01f, -6.66554868e-02f, -7.43137524e-02f, 6.14762260e-03f,
  -9.03354958e-02f, 2.49828607e-01f, -4.84034093e-03f, 8.91158730e-03f, -1.20408284e-02f, -1.17040309e-03f, 1.36464074e-01f, -1.38270050e-01f, 4.08863783e-01f, 1.27903014e-01f,
  5.07116280e-02f, -1.96366310e-01f, 1.81713253e-01f, 6.49376437e-02f, -1.70189291e-01f, 1.12612128e-01f, 1.07393689e-01f, -8.41262639e-02f, 5.15945740e-02f, 3.00691903e-01f,
  1.71361506e-01f, 5.95037565e-02f, 3.81874926e-02f, 6.79806340e-03f, 3.22594680e-02f, -2.14660186e-02f, -2.12022346e-02f, -2.10687533e-01f, 5.44389635e-02f, 2.63022017e-02f,
  1.13681741e-01f, 1.46649286e-01f, 3.97564620e-02f, -1.28385931e-01f, 4.81112441e-03f, -2.10994020e-01f, 2.46376872e-01f, 9.36713070e-02f, 1.91834122e-02f, -1.47654802e-01f,
  1.17339872e-01f, -2.18344908e-02f, 2.13544089e-02f, -6.71325773e-02f, -1.06282301e-01f, -9.61403698e-02f, -7.72830397e-02f, 2.27016851e-01f, 8.46641585e-02f, -1.87749758e-01f,
  -7.90044069e-02f, -3.31563056e-02f, -1.73885703e-01f, -2.41115108e-01f, -1.76145916e-03f, 5.61169200e-02f, -1.10511400e-03f, -7.45376796e-02f, -8.90853852e-02f, -7.20468462e-02f,
  1.86065454e-02f, 2.60361191e-02f, -2.27164954e-01f, 1.31987613e-02f, -1.81704044e-01f, -1.35427207e-01f, -9.16718021e-02f, -1.93162486e-01f, 8.55227113e-02f, 2.84485340e-01f,
  -1.70607939e-02f, -1.33808970e-01f, -1.88640967e-01f, -1.09427549e-01f, -6.36291280e-02f, 8.56722891e-02f, -1.03998594e-01f, 2.74800658e-01f, 4.43035476e-02f, -8.61738343e-03f,
  -1.24471681e-02f, -3.00196379e-01f, -4.39456888e-02f, -1.88252643e-01f, -1.27636045e-01f, -6.50341734e-02f, 2.14098841e-02f, 1.04303941e-01f, 4.48644944e-02f, 1.78872310e-02f,
  7.27985203e-02f, 1.43372759e-01f, 6.96577728e-02f, 1.42822981e-01f, -1.14137113e-01f, 1.02574684e-01f, 1.84739292e-01f, -7.37544149e-02f, -1.25270128e-01f, 4.19762805e-02f,
  -3.14861313e-02f, 4.37117741e-03f, -1.01601206e-01f, 1.01579994e-01f, 4.39991206e-02f, 6.01369664e-02f, -2.60519162e-02f, -8.39584246e-02f, 9.08329114e-02f, 1.35050699e-01f,
  3.48248659e-03f, -1.46738693e-01f, -5.85463382e-02f, -9.62822214e-02f, 1.23715386e-01f, -3.66921052e-02f, 2.30248153e-01f, -5.47181517e-02f, 8.61782730e-02f, 1.84931099e-01f,
  -1.21281177e-01f, 1.08673656e-02f, -4.09473814e-02f, -6.71269521e-02f, 1.07091017e-01f, -3.93025130e-02f, 9.25286934e-02f, -4.71466370e-02f, 1.03236102e-01f, -4.94369604e-02f,
  -5.87631091e-02f, -8.85111913e-02f, -8.22289195e-03f, 1.26914591e-01f, -3.06679517e-01f, 3.16055492e-02f, -1.67405933e-01f, -9.42123011e-02f, 2.10794494e-01f, -1.73140168e-01f,
  2.66682245e-02f, -1.69573709e-01f, 2.67876267e-01f, -3.25409696e-02f, 1.83026686e-01f, -1.54179350e-01f, -9.77919325e-02f, -8.23325366e-02f, -1.80158406e-01f, 1.36532634e-01f,
  1.12490192e-01f, 1.79776937e-01f, -5.35854958e-02f, 1.50421679e-01f, 8.75330120e-02f, 1.23735130e-01f, -1.68926373e-01f, -1.62960917e-01f, 5.55658713e-02f, -1.21249378e-01f,
  -2.01301113e-01f, 3.15224826e-02f, 1.49312932e-02f, 7.83916786e-02f, 3.95240858e-02f, -1.62234798e-01f, -6.14686636e-03f, 6.35008216e-02f, 4.59335633e-02f, -2.05646113e-01f,
  1.52630240e-01f, 8.25873613e-02f, -1.25219733e-01f, 1.51352704e-01f, -1.13761127e-01f, 2.48089924e-01f, 1.47108227e-01f, 3.15543190e-02f, -1.02687981e-02f, 2.20652111e-02f,
  -3.61901820e-02f, -1.10823415e-01f, -1.33545488e-01f, -5.87875508e-02f, 2.05760449e-01f, 8.98296684e-02f, 1.25095248e-01f, 1.45815864e-01f, 1.56212449e-01f, -9.65315700e-02f,
  1.69014499e-01f, -8.09514001e-02f, 1.25975981e-01f, -1.09708935e-01f, -3.13043028e-01f, -3.00621718e-01f, -2.49681324e-01f, 1.65919721e-01f, 1.97093591e-01f, 4.60345484e-02f,
  9.50359255e-02f, -7.26909861e-02f, 1.23109289e-01f, 1.17894553e-01f, 1.48096964e-01f, -5.42432927e-02f, -9.00749043e-02f, -7.13804811e-02f, -5.46379797e-02f, -2.05463618e-01f,
  -2.32413650e-01f, 3.38008255e-02f, -2.64416456e-01f, -6.42849132e-02f, 5.45654185e-02f, 1.20210998e-01f, 1.78687531e-03f, 1.64522566e-02f, -4.31228839e-02f, 1.19228706e-01f,
  -1.79469902e-02f, 1.82228275e-02f, -1.14548251e-01f, 1.37639418e-01f, 1.12645194e-01f, 2.67171301e-02f, 1.23229787e-01f, -1.33724408e-02f, -9.00307000e-02f, -2.02403069e-01f,
  -3.77486609e-02f, 5.75820208e-02f, -5.06422743e-02f, 1.43270180e-01f, 9.65901390e-02f, -7.23928660e-02f, -4.03211117e-02f, 6.63998351e-02f, -2.18777359e-01f, 5.02637625e-02f,
  -1.45691991e-01f, 1.14698425e-01f, -9.64226723e-02f, -9.74292010e-02f, -7.98344016e-02f, 4.32803854e-02f, -1.12106405e-01f, 4.23944630e-02f, -2.37087086e-01f, -9.71140787e-02f,
  -4.90800142e-02f, 1.65145621e-01f, -2.63595909e-01f, -3.41538563e-02f, 5.05471900e-02f, -4.31588441e-02f, 2.54765928e-01f, 2.80148208e-01f, 1.47169130e-03f, 1.87341765e-01f,
  1.50679946e-01f, -1.22102581e-01f, 9.91947278e-02f, 4.09011483e-01f, 1.72984689e-01f, 6.39848933e-02f, -3.75757273e-03f, 6.56889826e-02f, 2.64656246e-01f, -1.48494631e-01f,
  2.42866185e-02f, 2.80193612e-02f, 2.59249926e-01f, 5.39104789e-02f, 2.33049244e-02f, 3.09722096e-01f, 5.36257923e-02f, -1.71544373e-01f, -1.07638381e-01f, -1.52635291e-01f,
  4.71890457e-02f, 6.79864511e-02f, 1.36421248e-01f, -1.10267818e-01f, -1.33613953e-02f, -1.87913209e-01f, -2.51690507e-01f, 1.01133391e-01f, -2.30704620e-02f, 7.71327317e-02f,
  6.75332621e-02f, 6.71291277e-02f, -1.10010825e-01f, 7.33205304e-02f, 8.14231336e-02f, -7.25094602e-02f, 1.90220331e-03f, 1.95304900e-01f, -1.09290227e-01f, -9.82062966e-02f,
  2.42313504e-01f, -2.26462975e-01f, -1.03625385e-02f, 1.45864233e-01f, -4.85823676e-02f, -1.60951674e-01f, -1.61679953e-01f, -2.17259943e-01f, -6.42109141e-02f, -3.69982421e-02f,
  -1.39324844e-01f, -1.56232178e-01f, 2.57695228e-01f, -1.40168354e-01f, 9.56888571e-02f, -3.28456573e-02f, 2.26297274e-01f, 2.14289024e-01f, 7.56245330e-02f, -3.51397619e-02f,
  5.42392693e-02f, -1.60865843e-01f, 1.33700192e-01f, -4.19177674e-02f, -4.43699174e-02f, 1.04282834e-01f, -2.83019561e-02f, -1.85551524e-01f, -5.70099466e-02f, -8.28768536e-02f,
  8.31376538e-02f, 2.42498234e-01f, -1.83090717e-01f, 2.26165920e-01f, -2.97865272e-01f, 3.06687295e-01f, -3.32930773e-01f, -1.81361154e-01f, 2.10178532e-02f, -3.72553766e-01f,
  -1.92282960e-01f, 1.37353346e-01f, 3.85261886e-02f, 5.88886999e-03f, -1.53692260e-01f, -6.67648464e-02f, -1.69118896e-01f, 6.22418523e-03f, 6.33998513e-02f, 1.82225704e-01f,
  2.03657493e-01f, 1.22997381e-01f, 5.00938669e-03f, -1.71178579e-01f, -1.25607803e-01f, -1.80660591e-01f, -8.23701695e-02f, -4.45743650e-02f, 1.24854341e-01f, -8.51186961e-02f,
  8.77937376e-02f, -6.66611865e-02f, -7.79902562e-02f, 7.14471471e-03f, -7.50433952e-02f, 9.45957960e-04f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.78802773e-01f, 2.11810783e-01f, 1.28655002e-01f, 2.99290448e-01f, 1.35604963e-01f, 2.39528999e-01f, -5.88328503e-02f, 1.54402331e-01f, 1.77781850e-01f, -1.32907167e-01f,
  1.51177377e-01f, 1.84602961e-01f, 1.41197681e-01f, 3.46778184e-02f, 3.88653070e-01f, 1.28049031e-01f, 2.02749535e-01f, 2.03424498e-01f, -6.97238445e-02f, 6.87187836e-02f,
  -1.38690829e-01f, -8.29949677e-02f, -1.88272923e-01f, 2.47165024e-01f, -9.33336094e-02f, -5.19778669e-01f, 2.29300499e-01f, -1.47823403e-02f, -3.61120969e-01f, 2.79699881e-02f,
  -3.20142776e-01f, -9.07173380e-02f, 1.48558095e-01f, 3.87677461e-01f, -1.18407205e-01f, -1.89022459e-02f, -8.56731087e-02f, -1.51930839e-01f, 7.11015016e-02f, 2.32226312e-01f,
  -6.07853010e-02f, -1.69711918e-01f, -9.80071351e-03f, -2.17706025e-01f, -1.08107321e-01f, -1.06151663e-01f, 1.73683628e-01f, 3.42869371e-01f, 1.70372978e-01f, -5.79699576e-02f,
  7.54202891e-04f, -1.04468822e-01f, -1.30562827e-01f, -2.10892707e-01f, 2.96303123e-01f, -6.72014505e-02f, 1.04631782e-01f, -1.52604869e-02f, 7.53177032e-02f, -3.87950897e-01f,
  -1.42152518e-01f, 6.35136291e-02f, 2.27821781e-03f, 2.44851544e-01f, 1.11696228e-01f, -1.86538979e-01f, -1.47713006e-01f, 1.27129689e-01f, -4.45922576e-02f, 1.24103501e-01f,
  1.56709030e-01f, -4.71581705e-02f, -1.07819494e-02f, 1.85526028e-01f, -2.47759178e-01f, -9.23719704e-02f, 1.38380319e-01f, -2.97465920e-02f, -5.74472882e-02f, 7.31829694e-03f,
  1.38258412e-01f, -6.58410639e-02f, 1.24773949e-01f, -1.02927588e-01f, -1.49861043e-02f, 6.86793122e-03f, 1.85421586e-01f, 2.01920755e-02f, -1.15321532e-01f, 1.42375007e-01f,
  -2.00079098e-01f, -1.53290465e-01f, -2.67622489e-02f, 4.80096005e-02f, -1.55054092e-01f, 8.55307877e-02f, -8.35086331e-02f, 1.96313649e-01f, -1.81207761e-01f, 7.95310959e-02f,
  1.32550985e-01f, 4.09904793e-02f, 2.81839781e-02f, -4.86919098e-02f, -5.73994890e-02f, -3.66844460e-02f, -9.34381038e-02f, 6.92347586e-02f, -1.42172754e-01f, 9.41763073e-02f,
  -1.47642881e-01f, -1.27940234e-02f, 6.51806593e-02f, -1.60199236e-02f, 1.96885131e-03f, 2.86279470e-01f, 5.72661944e-02f, 1.63085267e-01f, -1.04788719e-02f, 7.72869959e-02f,
  2.10338637e-01f, 9.85390022e-02f, 1.19300738e-01f, 9.23906267e-02f, 4.88450155e-02f, 1.58353914e-02f, 1.96003839e-01f, -5.30567244e-02f, -6.53454736e-02f, 1.52925402e-01f,
  -5.84635250e-02f, 4.44398150e-02f, 6.23107329e-02f, -1.07631058e-01f, 2.94558927e-02f, -7.75874928e-02f, -8.90904292e-02f, 1.30528092e-01f, 1.46343887e-01f, -3.86856757e-02f,
  -6.73607364e-02f, -4.56396155e-02f, -1.22414427e-02f, 4.14789766e-02f, -3.98134887e-02f, 1.05344690e-01f, 5.04783131e-02f, 1.24265358e-01f, 9.18788686e-02f, 1.04022644e-01f,
  9.99444276e-02f, -5.29022999e-02f, 1.05909504e-01f, -4.96354066e-02f, -4.33762930e-02f, 6.44942820e-02f, 6.82232454e-02f, -1.03773952e-01f, 9.05540660e-02f, 1.15555786e-01f,
  -1.08604506e-01f, 1.78881735e-01f, -3.09309475e-02f, -1.22049540e-01f, 5.90161532e-02f, 1.21274553e-02f, 1.50734365e-01f, 1.27509490e-01f, 3.37558500e-02f, 9.18746442e-02f,
  3.81286368e-02f, 1.36731751e-02f, 1.00836977e-01f, -7.57402182e-02f, 1.93244882e-03f, 1.07603811e-01f, 1.85257420e-02f, -4.99935299e-02f, 1.41723216e-01f, -1.31153300e-01f,
  -2.05412507e-02f, -1.21369682e-01f, 6.24714345e-02f, 9.72598419e-02f, -1.05855554e-01f, 7.99498633e-02f, 4.18774551e-03f, -1.01158274e-02f, -1.04507029e-01f, -1.67808514e-02f,
  -1.06080785e-01f, 8.31906199e-02f, 1.72560126e-01f, -8.20613429e-02f, 1.43812463e-01f, 1.22209668e-01f, 1.16426975e-01f, 2.05765679e-01f, 1.63007557e-01f, 1.45961404e-01f,
  5.28591089e-02f, -5.25034256e-02f, 6.74434155e-02f, 1.66320577e-01f, 1.03581369e-01f, 6.91387802e-02f, -4.67927866e-02f, 1.72649138e-03f, 6.05046228e-02f, 5.80484804e-04f,
  1.00467093e-01f, -5.43465465e-02f, -2.45373189e-01f, -7.07649719e-03f, 9.81940329e-02f, -4.22189385e-02f, 6.56133741e-02f, 4.94855195e-02f, 1.15026750e-01f, 5.42335361e-02f,
  1.46687254e-01f, -1.22795306e-01f, 9.47293416e-02f, -3.23990323e-02f, 9.42421779e-02f, 3.50908265e-02f, 1.56942710e-01f, 6.33324869e-03f, -2.55488185e-03f, 8.45685659e-04f,
  -3.92556489e-02f, -9.62025393e-03f, 8.81676003e-02f, 8.37889835e-02f, -9.56563950e-02f, 2.83509530e-02f, -8.16846341e-02f, -4.90396619e-02f, -1.30073681e-01f, -7.21741095e-02f,
  -1.58074841e-01f, -2.55522709e-02f, 3.25274058e-02f, -1.26569718e-01f, 2.51788460e-03f, 1.37870491e-01f, -1.35687843e-01f, -8.71350393e-02f, -3.85083742e-02f, -2.47809161e-02f,
  -1.07899994e-01f, 4.42377031e-02f, 5.06400056e-02f, 8.51023011e-03f, 1.88821629e-01f, 8.92589763e-02f, 6.43539280e-02f, 5.70570119e-02f, 1.46526366e-01f, 6.97076768e-02f,
  -7.21370056e-02f, -1.05755357e-02f, -3.26093845e-02f, -5.80465347e-02f, 3.74001861e-02f, 7.69849420e-02f, 7.97154475e-03f, 5.57331406e-02f, -1.35751581e-02f, -2.66751722e-02f,
  1.23567544e-01f, 1.24900639e-01f, 1.53631806e-01f, 1.49757683e-01f, 9.22443420e-02f, 5.59321493e-02f, -6.88828826e-02f, -1.90063275e-03f, 8.17232206e-02f, 8.49323161e-03f,
  6.79610297e-02f, 1.12181090e-01f, 4.73826304e-02f, 4.17225920e-02f, 9.45664197e-03f, 1.83235928e-01f, 6.04963377e-02f, 1.09011948e-01f, 3.12194861e-02f, -5.56651093e-02f,
  -4.82504740e-02f, -1.74959078e-01f, -3.09566334e-02f, -1.90462135e-02f, -7.92067796e-02f, -3.10705900e-02f, -1.16896085e-01f, 1.34287953e-01f, -1.16961285e-01f, 4.35621440e-02f,
  -6.77796304e-02f, 3.14046368e-02f, -6.65038675e-02f, 5.70610492e-03f, -1.04082778e-01f, 9.43415910e-02f, 4.07589786e-02f, -1.11430064e-02f, 7.30390325e-02f, 9.59403589e-02f,
  -1.19095154e-01f, -5.57549484e-02f, 8.47317055e-02f, -3.77792716e-02f, 9.33954716e-02f, -1.11290216e-01f, 6.44370019e-02f, -6.88227117e-02f, -6.78358376e-02f, -1.05309173e-01f,
  1.44447699e-01f, 3.09526801e-01f, 2.54286855e-01f, 1.45340815e-01f, 1.04926467e-01f, 1.71305403e-01f, 9.65151042e-02f, 1.83235794e-01f, -1.03984676e-01f, 2.85639018e-01f,
  2.97627330e-01f, -3.92420404e-02f, 2.54513502e-01f, 5.43349795e-02f, 3.32253993e-01f, 1.76460937e-01f, -1.72743965e-02f, -7.82257039e-03f, 2.60612190e-01f, 3.32485110e-01f,
  -2.07457319e-01f, -2.25577787e-01f, -4.17267233e-01f, -9.94738117e-02f, 1.92061394e-01f, 7.70444572e-02f, 2.38278359e-01f, 1.70691878e-01f, 3.29781473e-01f, -2.83760130e-01f,
  1.65835053e-01f, -2.81601748e-03f, -2.69543946e-01f, 1.83077812e-01f, 3.27250838e-01f, 1.07598625e-01f, 1.07991837e-01f, 3.37171078e-01f, 1.36879548e-01f, 1.45056084e-01f,
  1.18591301e-01f, -2.17040200e-02f, -1.39374416e-02f, -1.16178162e-01f, 3.32945026e-02f, -1.31453931e-01f, 3.58028039e-02f, -5.95594943e-02f, 2.08086237e-01f, -1.04965121e-02f,
  -4.48131487e-02f, -9.48572606e-02f, 7.20242113e-02f, -4.74819355e-02f, 2.05617696e-01f, -8.38663876e-02f, -1.19297318e-01f, -6.86023850e-03f, 4.01105918e-02f, 3.69088165e-02f,
  -9.49878991e-02f, -9.39874426e-02f, 1.00332662e-01f, 2.10020971e-02f, 1.10310800e-01f, 5.84049560e-02f, 2.42524478e-03f, -8.36342871e-02f, -1.00391455e-01f, -1.07441306e-01f,
  5.67837954e-02f, 1.15446253e-02f, 5.74845225e-02f, 1.13220915e-01f, 2.35956181e-02f, 1.22314692e-01f, -7.40737393e-02f, 4.17647837e-03f, -5.28624170e-02f, 3.34107988e-02f,
  2.93993875e-02f, 4.68907617e-02f, 1.15607373e-01f, -9.35668778e-03f, -1.04032561e-01f, 1.24527179e-01f, -9.63520110e-02f, 4.75362362e-03f, -2.81472784e-02f, -2.43391227e-02f,
  8.58639404e-02f, 1.19855404e-01f, -3.94710572e-03f, -8.76251236e-02f, 1.02818638e-01f, 1.01102136e-01f, 1.10533126e-01f, -1.42041102e-01f, -8.32492486e-02f, 2.92137209e-02f,
  5.02838902e-02f, -8.17580223e-02f, -1.29628688e-01f, 9.74731147e-02f, 1.89554058e-02f, -3.80674377e-03f, -1.16807289e-01f, -8.88937041e-02f, 6.52212054e-02f, -2.05331706e-02f,
  3.20401266e-02f, -1.04761042e-01f, 1.19996935e-01f, 1.06265293e-02f, -3.97065207e-02f, -1.29003346e-01f, -1.07315574e-02f, 5.94998561e-02f, -8.75261799e-02f, -1.24349900e-01f,
  3.64241563e-02f, 4.32683378e-02f, 1.20363854e-01f, 6.13013981e-03f, -6.00063279e-02f, -5.56383878e-02f, 3.11520211e-02f, -1.93140320e-02f, 6.91270456e-02f, -1.71597689e-01f,
  1.31774083e-01f, 5.25661297e-02f, 8.61995816e-02f, 1.35193110e-01f, 1.85031623e-01f, -9.44584832e-02f, 1.48124933e-01f, 2.17735022e-01f, 1.29208684e-01f, 1.41448975e-01f,
  -4.94886339e-02f, -7.09636956e-02f, 1.69741780e-01f, 4.76321984e-05f, 1.41500318e-02f, 1.60505712e-01f, 3.76954302e-02f, 5.45231588e-02f, -3.24061573e-01f, -2.90247053e-01f,
  -1.01939373e-01f, 1.76578179e-01f, -2.84871101e-01f, 4.70708907e-02f, -1.63285181e-01f, 1.78930134e-01f, 2.10415259e-01f, -7.96724930e-02f, -1.10633992e-01f, -1.45537285e-02f,
  1.75271586e-01f, 6.92860782e-02f, 2.53870249e-01f, -1.82988971e-01f, 8.15771297e-02f, 3.77693847e-02f, 2.06893943e-02f, 2.23117769e-01f, -1.31761223e-01f, 8.70024338e-02f,
  1.00253997e-02f, 2.09759250e-01f, 5.30759059e-02f, 1.59563869e-01f, 8.53374749e-02f, -6.10363185e-02f, -7.30060712e-02f, -3.73558961e-02f, 2.05701850e-02f, -1.01993933e-01f,
  8.94846618e-02f, 2.55197495e-01f, 9.62660275e-03f, -1.34467497e-01f, -9.89304041e-04f, 5.58343418e-02f, -3.38915177e-02f, -8.24165419e-02f, 3.77559289e-02f, 6.47809729e-02f,
  1.52437821e-01f, -3.01742796e-02f, -2.45575607e-02f, -1.11237034e-01f, 9.83835906e-02f, 6.31083772e-02f, -2.18131673e-02f, 1.67247564e-01f, 5.23211714e-03f, 1.11073822e-01f,
  2.05774158e-02f, 5.72872907e-02f, -1.00371718e-01f, 7.62332454e-02f, 1.60500094e-01f, -4.44777384e-02f, 4.80926596e-02f, 1.15747303e-01f, -2.35887039e-02f, -4.32658568e-02f,
  6.21549003e-02f, -9.28524230e-03f, -3.62308398e-02f, 1.68851554e-01f, 1.66403353e-01f, -8.33846480e-02f, 4.04670089e-02f, -6.33202717e-02f, 5.52099645e-02f, 9.71858855e-03f,
  1.93601530e-02f, 4.82419170e-02f, -1.03605306e-02f, -8.78656283e-03f, 8.25491026e-02f, -1.40777946e-01f, -5.30094393e-02f, 1.52781889e-01f, 5.72579652e-02f, 6.83791786e-02f,
  1.18744820e-02f, 1.01429941e-02f, 6.56589959e-03f, -5.44471666e-02f, 8.80413428e-02f, 8.46952349e-02f, -4.37742434e-02f, -8.58890563e-02f, 7.78412819e-02f, 4.52029854e-02f,
  1.35402940e-02f, -7.32127503e-02f, -9.60989520e-02f, 1.68390870e-01f, -8.22490901e-02f, -9.59164500e-02f, 1.16055854e-01f, 8.67442414e-02f, -6.32127374e-02f, -6.42578676e-03f,
  -3.68324015e-03f, -2.46459693e-02f, 6.70482740e-02f, -8.21809098e-02f, 6.48082420e-02f, -1.16308518e-01f, -1.11366205e-01f, 1.16173372e-01f, 2.11888645e-02f, 7.10242167e-02f,
  1.28900468e-01f, 2.72233747e-02f, -1.72400065e-02f, -4.56765555e-02f, 5.69893159e-02f, -3.93610261e-02f, 1.01226540e-02f, 9.37633887e-02f, 2.90573761e-02f, 1.21909313e-01f,
  1.46744594e-01f, -9.34101194e-02f, 5.33695035e-02f, -8.14373940e-02f, -2.20143367e-02f, -2.13654619e-03f, -1.12254836e-01f, -9.14861411e-02f, -1.31711870e-01f, -3.59437335e-03f,
  2.24955883e-02f, -1.90619171e-01f, -1.65902838e-01f, -1.77894562e-01f, -9.37509686e-02f, 1.05334170e-01f, -1.60008565e-01f, 2.62640119e-02f, 6.90420344e-02f, -1.24421105e-01f,
  -5.24663292e-02f, 9.76885408e-02f, 8.04491863e-02f, -3.88685730e-03f, -5.46701625e-03f, 3.38213407e-02f, 1.52433529e-01f, -4.88741137e-02f, 1.16122268e-01f, -4.54862639e-02f,
  -1.41367572e-03f, 8.90435353e-02f, -3.53291221e-02f, 1.12874508e-01f, 4.74875830e-02f, 1.17101585e-02f, 1.92764431e-01f, -8.98680557e-03f, 1.18271507e-01f, 8.08617473e-02f,
  -6.36928901e-02f, -1.61394570e-02f, 6.31813630e-02f, -5.86236976e-02f, -1.22045897e-01f, -7.34546268e-03f, -1.36832550e-01f, -6.13982938e-02f, 2.34818131e-01f, 9.35821533e-02f,
  -6.56654611e-02f, -3.77425104e-02f, 3.35812755e-03f, 8.26757327e-02f, 1.24420524e-01f, 1.59725964e-01f, 1.79119453e-01f, 2.09579870e-01f, -7.00265318e-02f, -1.81644466e-02f,
  -3.53995301e-02f, 1.68955699e-01f, 2.01843783e-01f, 1.63571328e-01f, 1.54117808e-01f, 1.87074944e-01f, 2.85759151e-01f, 2.28224531e-01f, 1.17615677e-01f, -7.88526237e-02f,
  1.60560369e-01f, -4.10299934e-02f, -4.62892130e-02f, 7.56016448e-02f, -1.26771748e-01f, 1.25159733e-02f, -1.49397373e-01f, -9.24240053e-02f, 9.17528346e-02f, 1.38553038e-01f,
  -2.33371302e-01f, -8.88492987e-02f, -1.78477056e-02f, 1.98553622e-01f, 7.33213825e-03f, 8.69587287e-02f, 1.32108986e-01f, 1.41968522e-02f, -1.12115793e-01f, 8.39634091e-02f,
  3.53159942e-02f, -1.15936957e-01f, 9.18119773e-02f, -6.60892576e-02f, -2.84776464e-02f, 1.14523970e-01f, 9.61287096e-02f, -1.04255736e-01f, 9.61200669e-02f, 8.56762677e-02f,
  4.74859104e-02f, 6.25300184e-02f, -1.16651990e-01f, -3.72901410e-02f, -1.91351566e-02f, -1.61227137e-01f, 1.68334246e-01f, 1.51488945e-01f, -5.75526841e-02f, -5.34034632e-02f,
  1.55023672e-03f, 1.10746630e-01f, -1.51896775e-01f, -2.08046306e-02f, 8.92684162e-02f, 1.57793969e-01f, 1.85940370e-01f, 1.08057089e-01f, -1.25358999e-02f, 5.98091073e-02f,
  -2.60739159e-02f, 7.64612108e-02f, -9.55121964e-02f, 5.13674989e-02f, 1.95623800e-01f, 1.25111878e-01f, 3.08128092e-02f, 7.29727447e-02f, 2.77165473e-01f, 9.97040942e-02f,
  -1.75023396e-02f, 1.40916407e-01f, 1.60325184e-01f, 8.31317436e-03f, -1.47736236e-01f, -1.20322473e-01f, 4.96202670e-02f, 3.77957225e-01f, 8.15119222e-02f, 1.60825968e-01f,
  -9.30249542e-02f, 1.93478480e-01f, -7.27962609e-03f, 8.24632645e-02f, 1.29407465e-01f, 2.57244915e-01f, 7.42101157e-03f, 8.51931870e-02f, 8.95597115e-02f, -3.03945541e-01f,
  -2.54936606e-01f, -1.47113860e-01f, -8.25985428e-03f, -3.68273817e-02f, -1.26013324e-01f, -3.72458212e-02f, -5.45110703e-02f, -5.94341941e-02f, 1.17228732e-01f, 9.58384201e-02f,
  1.08490214e-01f, 1.52170494e-01f, -8.13218653e-02f, 5.80361150e-02f, 3.20482701e-02f, -8.80616605e-02f, -6.86604530e-02f, 1.63104951e-01f, 6.63962662e-02f, 8.66436511e-02f,
  -1.14658371e-01f, -2.68281214e-02f, 5.15064113e-02f, -1.06530964e-01f, 1.15123101e-01f, -7.00496659e-02f, 2.23103892e-02f, -5.93421571e-02f, 1.21746898e-01f, 2.21562665e-02f,
  4.40827012e-02f, 1.79648325e-01f, -1.47597175e-02f, 3.89706232e-02f, 1.79055452e-01f, 1.11154914e-01f, -7.70822763e-02f, 1.61426678e-01f, 1.01746239e-01f, 1.83383793e-01f,
  5.96953705e-02f, 4.25346047e-02f, 1.46500587e-01f, 2.43416220e-01f, 1.65622666e-01f, 5.29814772e-02f, -1.97876059e-02f, -2.22300105e-02f, 2.10029155e-01f, 1.53535873e-01f,
  3.28692943e-01f, 6.47027045e-02f, 6.93506822e-02f, 1.50054142e-01f, 2.91541275e-02f, 9.85998213e-02f, -1.90721616e-01f, 2.09938213e-01f, 1.71145365e-01f, 2.11614907e-01f,
  -5.33668026e-02f, -1.56996697e-01f, -7.46034160e-02f, -9.74032581e-02f, 3.56455967e-02f, -7.42351413e-02f, 5.26066460e-02f, 6.36034682e-02f, 1.29059013e-02f, 5.58682755e-02f,
  -1.00028783e-01f, 1.30429924e-01f, -4.23083678e-02f, -5.54964468e-02f, 1.13978222e-01f, 6.34425506e-02f, -1.17094062e-01f, 1.67566940e-01f, -1.26641050e-01f, 1.90329209e-01f,
  3.27140763e-02f, 1.74004972e-01f, -5.08718267e-02f, 1.84271455e-01f, -8.50104764e-02f, 7.58382678e-02f, -5.86665533e-02f, -9.36336629e-03f, 1.52800128e-01f, -7.27799386e-02f,
  -5.87842278e-02f, -2.16778908e-02f, 2.07642123e-01f, 2.00741068e-01f, 2.10894898e-01f, 4.26718518e-02f, 4.28572744e-02f, 1.07739851e-01f, -4.22189981e-02f, 6.50910586e-02f,
  1.27081588e-01f, -1.38054322e-02f, 1.41846880e-01f, 4.53140661e-02f, 2.25605935e-01f, -1.08052470e-01f, 1.38278857e-01f, 3.72394174e-02f, -4.10622098e-02f, 7.43660554e-02f,
  4.57282253e-02f, -2.01693445e-01f, 4.02173027e-03f, 6.29129410e-02f, -1.63199246e-01f, -6.33298699e-03f, 5.70804328e-02f, -2.40524020e-02f, -1.69281840e-01f, -2.37256810e-01f,
  2.07780927e-01f, -1.25387087e-01f, 6.74996749e-02f, 3.00483182e-02f, -1.76794603e-01f, 1.54540285e-01f, -2.22815678e-01f, -5.04554883e-02f, 2.24665597e-01f, -2.98481107e-01f,
  -5.34941852e-02f, 1.18034996e-01f, 2.32651591e-01f, -1.83165297e-02f, 7.29783773e-02f, -5.40094636e-02f, -4.78390828e-02f, 6.61556423e-02f, 1.10618778e-01f, -1.04683876e-01f,
  2.26460904e-01f, -8.73425826e-02f, 9.48525816e-02f, -2.89637633e-02f, 2.40256980e-01f, 1.20658182e-01f, 4.97275777e-02f, -2.06060782e-01f, -5.51031269e-02f, -2.81310733e-02f,
  -2.50600781e-02f, 8.06144923e-02f, 9.85302627e-02f, 6.52784854e-02f, -3.94498892e-02f, -1.52525324e-02f, 2.76261419e-02f, 7.65109137e-02f, -6.22781040e-03f, 1.90510586e-01f,
  1.99817777e-01f, 1.87915817e-01f, 1.37645230e-01f, -1.36971772e-01f, 1.02371000e-01f, 2.25561202e-01f, 4.13893024e-03f, -2.93983482e-02f, 1.98369045e-02f, 2.57632494e-01f,
  -7.47371539e-02f, -1.17680967e-01f, -7.38143772e-02f, -9.03921053e-02f, -8.06997195e-02f, 1.82732731e-01f, -2.50395089e-01f, -1.94080397e-01f, 9.00827423e-02f, 1.01945654e-01f,
  -8.19301233e-02f, 1.32120445e-01f, -1.30916342e-01f, 1.87355220e-01f, 1.97654381e-01f, -3.38373244e-01f, -5.16773090e-02f, -2.20179528e-01f, 3.30198139e-01f, -1.41328141e-01f,
  2.44879112e-01f, -4.90189046e-02f, -4.29716706e-02f, 2.04685777e-02f, 2.85054445e-01f, -8.32635835e-02f, 1.39692888e-01f, 1.10902779e-01f, -1.99871976e-02f, -1.17121963e-03f,
  2.03576889e-02f, -8.57349262e-02f, -2.56208889e-02f, -1.56386308e-02f, -1.11280471e-01f, -3.41701545e-02f, -3.23912092e-02f, 1.99387390e-02f, 1.75365716e-01f, 2.56620161e-02f,
  -6.63891584e-02f, 5.18035367e-02f, 6.63802847e-02f, 3.61120626e-02f, -1.84413701e-01f, 1.78616688e-01f, 8.19790959e-02f, -1.54947177e-01f, 2.13114277e-01f, 7.96313286e-02f,
  -1.28936902e-01f, 5.46121038e-02f, 3.13092247e-02f, 1.61116406e-01f, -1.90486059e-01f, 7.84913823e-02f, 7.26670176e-02f, -1.08159237e-01f, -1.48503631e-02f, 1.58380836e-01f,
  -5.40598556e-02f, -5.72591722e-02f, 1.81405813e-01f, 1.07532382e-01f, 2.86326613e-02f, -9.63638127e-02f, -1.93257406e-01f, 5.01660630e-02f, 1.57955304e-01f, 2.43017107e-01f,
  -1.04186079e-02f, 1.14813171e-01f, -2.35062242e-02f, -3.34656090e-02f, 7.96899796e-02f, 8.59942660e-02f, 1.28043696e-01f, -3.36967967e-02f, 1.59145057e-01f, -1.75862521e-01f,
  2.02362955e-01f, -6.93911780e-03f, -1.21144176e-01f, -4.32524905e-02f, 7.89297279e-03f, -1.51213214e-01f, 3.90740484e-03f, 1.05113171e-01f, 2.89903909e-01f, 1.90268755e-02f,
  -5.09875752e-02f, 1.03103079e-01f, -5.16445264e-02f, -1.04503036e-01f, 1.09585248e-01f, 6.28809212e-03f, -6.59226105e-02f, 9.05761346e-02f, 1.79677811e-02f, 5.14604747e-02f,
  -5.39984889e-02f, 7.20801810e-03f, 7.63797108e-03f, -1.60893515e-01f, 2.03205302e-01f, -5.81312850e-02f, -1.05418332e-01f, -2.82587614e-02f, 1.60763413e-01f, -1.18434504e-01f,
  4.18574102e-02f, 8.80818591e-02f, 5.77541851e-02f, 8.45774412e-02f, -1.36935323e-01f, -4.12058756e-02f, 1.96328778e-02f, 1.25394166e-01f, 8.65673572e-02f, -1.38470726e-02f,
  -9.93814841e-02f, -1.04812637e-01f, 4.88502420e-02f, 1.07256681e-01f, 1.12137005e-01f, 1.29941702e-01f, -9.09350216e-02f, 4.40004766e-02f, 1.40255719e-01f, -1.46603480e-01f,
  7.44025316e-03f, -2.30013169e-02f, 3.71752270e-02f, 6.25739470e-02f, 4.62290794e-02f, -2.72764731e-02f, -7.50895590e-02f, 6.55114055e-02f, 1.51750922e-01f, 1.30219549e-01f,
  -1.57462638e-02f, 4.06112000e-02f, 9.78637412e-02f, -2.00990885e-01f, -1.80540606e-02f, -1.60589382e-01f, 1.17860340e-01f, 1.31404415e-01f, 1.60671994e-01f, 3.47081944e-02f,
  1.49040464e-02f, 1.73712179e-01f, 1.51111305e-01f, 1.72062024e-01f, -5.16482675e-03f, -3.80723514e-02f, -3.27702835e-02f, 1.00303940e-01f, -7.28785843e-02f, -5.74836247e-02f,
  -2.85159908e-02f, -1.48326559e-02f, -1.08115695e-01f, -2.11907811e-02f, 7.11855432e-03f, -6.45214319e-02f, 1.15087561e-01f, 1.18670456e-01f, 2.04092879e-02f, -4.22508717e-02f,
  -4.16078381e-02f, 1.11692145e-01f, 9.07262564e-02f, 1.29993916e-01f, 1.91661697e-02f, 1.78459752e-02f, 8.12488496e-02f, -4.11637351e-02f, 7.71875158e-02f, -6.37506321e-02f,
  1.87504068e-01f, 1.83094487e-01f, 6.82589635e-02f, 3.10579687e-01f, 2.25483626e-01f, 2.63739061e-02f, 2.13750750e-01f, -1.31211830e-02f, -8.02985486e-03f, 1.34778842e-01f,
  1.32305011e-01f, 6.86802566e-02f, 3.28684971e-02f, 1.15928695e-01f, 2.64727566e-02f, 8.69581029e-02f, -1.49674624e-01f, 1.78645223e-01f, -2.11074084e-01f, -1.99366048e-01f,
  3.24522555e-02f, -1.89226389e-01f, -2.72511635e-02f, 1.29815815e-02f, 4.82351109e-02f, -1.66830093e-01f, -1.59917679e-02f, -1.42815188e-02f, 1.00811847e-01f, -1.51327163e-01f,
  1.11272760e-01f, -4.90908593e-01f, 3.19474012e-01f, 5.01974225e-02f, 8.52392092e-02f, 7.32561052e-02f, 1.63006335e-01f, -1.71336755e-01f, 1.33251265e-01f, -2.86505558e-02f,
  3.79907601e-02f, 1.34330869e-01f, 3.71566764e-03f, 1.78874388e-01f, 1.80781603e-01f, 2.84715239e-02f, 2.65413988e-03f, -2.31086500e-02f, 6.05371743e-02f, 1.36834970e-02f,
  1.36633590e-01f, 4.48313467e-02f, 3.76489423e-02f, 4.81104739e-02f, -8.13049600e-02f, -6.43299296e-02f, -9.34887677e-02f, -1.20936316e-02f, 1.26731202e-01f, -1.82889342e-01f,
  1.44415796e-01f, -5.84676042e-02f, 8.05599168e-02f, -1.12902813e-01f, -1.01833507e-01f, -7.45620951e-02f, -8.03264529e-02f, -1.82496440e-02f, -6.28288165e-02f, 1.79804824e-02f,
  5.22626787e-02f, 7.07612857e-02f, 9.59188938e-02f, -3.19486521e-02f, -4.62536607e-03f, 4.68316907e-03f, -4.33943793e-03f, -8.21756348e-02f, 1.14907280e-01f, 1.01394527e-01f,
  1.37141809e-01f, 1.15968145e-01f, -9.71269384e-02f, 5.83148748e-02f, 5.73139871e-03f, -6.42948300e-02f, -1.31148607e-01f, 2.37700250e-02f, -1.11452319e-01f, -8.51346627e-02f,
  4.71268781e-02f, -1.05300799e-01f, -1.65875331e-02f, -1.87249836e-02f, 6.18609749e-02f, 1.56431884e-01f, 5.00575900e-02f, 3.52089852e-02f, 1.07914083e-01f, 2.08155941e-02f,
  -1.32146716e-01f, 7.80090243e-02f, -2.80681048e-02f, 4.48720530e-02f, -1.32551091e-02f, 3.61746624e-02f, -1.19528055e-01f, 3.50363776e-02f, -1.83236208e-02f, -1.18943974e-01f,
  -9.46147144e-02f, -2.93045025e-02f, -4.97225150e-02f, 8.65439773e-02f, -2.11989284e-02f, -8.73382110e-03f, 1.12001173e-01f, 7.86902159e-02f, 9.68431383e-02f, -7.48248920e-02f,
  -1.26478663e-02f, 2.14180034e-02f, 5.93890250e-02f, 7.97366723e-02f, -1.04846843e-01f, 8.96613300e-02f, -7.33443424e-02f, -2.33818330e-02f, 3.31845172e-02f, 1.94463402e-01f,
  8.90351385e-02f, 6.20404817e-02f, 2.39904404e-01f, 1.14677243e-01f, 1.29132003e-01f, 1.37858927e-01f, -3.49723455e-03f, 1.74863636e-01f, -2.28342507e-02f, 8.51694196e-02f,
  1.02295056e-01f, 1.08549893e-01f, 1.15567721e-01f, 6.06718324e-02f, 8.78257081e-02f, -4.64273011e-03f, -2.53715754e-01f, -4.67572585e-02f, -8.21015462e-02f, -1.28501669e-01f,
  -2.42901519e-01f, 1.53064519e-01f, -1.22545265e-01f, 1.48124501e-01f, -3.00518349e-02f, -1.66665465e-01f, -8.74906927e-02f, -1.56247720e-01f, 1.82788208e-01f, -1.15166187e-01f,
  1.78831264e-01f, 5.76323792e-02f, -2.53686383e-02f, 1.70899376e-01f, 8.39590468e-03f, 6.38206676e-02f, -9.33775976e-02f, 1.23501964e-01f, -9.69421715e-02f, 2.12903023e-01f,
  -5.64661622e-02f, -3.20250802e-02f, 6.20894618e-02f, -1.24415360e-01f, -1.18011177e-01f, -1.24259197e-04f, 1.86320171e-02f, -7.33986199e-02f, 7.11745769e-02f, 1.96053967e-01f,
  -8.37671384e-02f, -9.70150158e-02f, 1.02582619e-01f, -9.58146080e-02f, -5.15494868e-02f, 1.01880450e-02f, 9.67326388e-02f, -6.97533861e-02f, 8.76914263e-02f, 5.19136637e-02f,
  6.03483878e-02f, -1.32158622e-02f, 4.86813188e-02f, -8.56848657e-02f, -6.09055571e-02f, 7.45206401e-02f, 6.85888380e-02f, -1.09123021e-01f, 9.32690129e-02f, -6.58499822e-02f,
  2.43319087e-02f, -1.31330147e-01f, -1.02717377e-01f, 1.44881150e-03f, -7.55734965e-02f, 1.03016198e-01f, -9.33300629e-02f, 9.20428187e-02f, 1.05581813e-01f, 1.41278699e-01f,
  -1.31633524e-02f, -4.47625332e-02f, -3.77731211e-02f, 8.30711722e-02f, -8.17205291e-03f, -8.42727199e-02f, 5.74125908e-02f, -5.83182201e-02f, 1.16845906e-01f, 3.72945406e-02f,
  -4.96349372e-02f, -8.64076614e-02f, 1.09036453e-01f, -5.90157397e-02f, 7.40996301e-02f, -7.33563304e-02f, -1.49017155e-01f, -1.12488993e-01f, -6.61359262e-03f, -7.33898878e-02f,
  1.24355182e-01f, -6.94856569e-02f, -7.71765113e-02f, -6.18383065e-02f, -4.03348543e-02f, 8.28621015e-02f, 1.15843982e-01f, 9.19086300e-03f, -3.24496962e-02f, 6.89718500e-02f,
  -4.05832492e-02f, 2.31922567e-02f, 6.35173321e-02f, 5.33873076e-03f, 7.39682987e-02f, 6.79525137e-02f, -8.54372382e-02f, -7.47716352e-02f, 7.83675388e-02f, 6.07336648e-02f,
  1.21198833e-01f, 8.19319859e-02f, -1.04501933e-01f, 3.34517658e-02f, 1.23511344e-01f, -1.59758516e-02f, 4.50788774e-02f, 9.00465026e-02f, 2.03708529e-01f, 6.37851730e-02f,
  2.13163823e-01f, -1.92050189e-02f, -5.36722727e-02f, 1.97793484e-01f, 1.08186039e-03f, -1.48477266e-02f, 2.47363746e-02f, -4.29456867e-02f, 9.91599560e-02f, 1.10174984e-01f,
  5.84044270e-02f, 2.32748866e-01f, 7.22758472e-03f, -1.57775149e-01f, -1.27418160e-01f, -3.00211739e-02f, 1.20579183e-01f, 8.32004622e-02f, -1.99411601e-01f, 1.77041605e-01f,
  -6.51092306e-02f, 6.72582462e-02f, 1.45810202e-01f, 4.68223281e-02f, -1.04945824e-01f, 1.00895166e-01f, 1.93176150e-01f, 2.49601722e-01f, 1.06908873e-01f, -3.06984391e-02f,
  -6.14409056e-03f, -2.26961151e-01f, 1.81412119e-02f, 1.84551999e-01f, 7.92652145e-02f, 1.57929331e-01f, -8.09885040e-02f, 5.48751093e-02f, 7.60720670e-02f, -1.57904346e-02f,
  -7.32795671e-02f, -6.77636713e-02f, 5.43758050e-02f, 1.11040875e-01f, 1.50619075e-02f, 4.25754860e-02f, -4.31750566e-02f, 2.36193508e-01f, -6.02221042e-02f, -4.15841527e-02f,
  1.84571803e-01f, 5.47310570e-03f, -1.35333896e-01f, -4.66291048e-02f, -2.11676881e-02f, -1.04972981e-01f, 2.28583604e-01f, 9.63140056e-02f, 6.59917518e-02f, 2.10160799e-02f,
  1.07326388e-01f, -9.34400782e-02f, -1.22856669e-01f, -1.50660397e-02f, -1.01885803e-01f, -5.67267276e-03f, 5.56152267e-03f, -8.07824805e-02f, 9.07307342e-02f, -8.40328112e-02f,
  3.95511873e-02f, -3.11967190e-02f, -6.29983470e-02f, -3.07382718e-02f, -1.64508492e-01f, -3.87899466e-02f, -1.48566306e-01f, 4.02414352e-02f, 1.61665939e-02f, -4.96535888e-03f,
  7.25384429e-02f, -2.97974865e-03f, 6.44045547e-02f, -3.70478295e-02f, -1.57789633e-01f, 1.92737654e-02f, -1.57301232e-01f, 2.05676332e-02f, -1.08932294e-01f, -5.82881719e-02f,
  1.41672671e-01f, -3.63483354e-02f, 7.63841420e-02f, -1.29155695e-01f, 6.47253469e-02f, -1.77823715e-02f, 2.11495355e-01f, 1.41734472e-02f, -2.33039744e-02f, 7.19462484e-02f,
  -9.10755172e-02f, 1.08549133e-01f, 6.30052164e-02f, 1.17217839e-01f, -7.38309473e-02f, 8.51395279e-02f, 7.19285831e-02f, 1.22142695e-01f, -9.68194827e-02f, -3.39263410e-04f,
  -9.25661102e-02f, 2.04460304e-02f, 1.07793942e-01f, -4.16178778e-02f, -3.13382186e-02f, -1.20552860e-01f, 1.61298458e-02f, 5.63953593e-02f, 9.37642008e-02f, 1.83671049e-03f,
  -3.39774750e-02f, -3.12450994e-03f, -7.94631168e-02f, -1.11523289e-02f, 1.37300268e-01f, 2.80578714e-02f, -4.75636160e-04f, -7.02210367e-02f, 1.98267281e-01f, 1.09042734e-01f,
  -4.74390313e-02f, 6.36526197e-02f, -5.05079255e-02f, 1.62218586e-01f, 1.21173017e-01f, -5.93630113e-02f, -1.25116676e-01f, 1.43789113e-01f, -4.99042124e-02f, -2.15910990e-02f,
  8.62139612e-02f, 4.44343127e-02f, -9.44191441e-02f, 9.86209437e-02f, 1.46971315e-01f, -1.63075969e-01f, -7.51520097e-02f, -6.58964068e-02f, 4.52868715e-02f, -1.53201688e-02f,
  2.02698577e-02f, -9.57944766e-02f, -7.98425972e-02f, 2.73243580e-02f, -5.57101667e-02f, -1.84718654e-01f, -3.79190072e-02f, 1.37475803e-01f, 9.97097716e-02f, 6.91417884e-03f,
  1.37903929e-01f, -4.06468809e-02f, 2.04982106e-02f, 1.26188159e-01f, 2.78177541e-02f, -5.76091819e-02f, 2.14759652e-02f, 1.08037345e-01f, 9.01919324e-03f, -8.62361193e-02f,
  6.97952360e-02f, 3.50242071e-02f, -9.39966738e-03f, -1.79139040e-02f, -2.38801241e-02f, 3.39718536e-02f, -1.09740458e-02f, -7.55712837e-02f, 7.15601072e-02f, -9.05332565e-02f,
  -2.19705291e-02f, -8.83513018e-02f, 9.94567107e-03f, -7.47744218e-02f, 1.48164686e-02f, 5.17963013e-03f, 1.85796976e-01f, 1.20839588e-01f, 5.51045015e-02f, 1.58045605e-01f,
  1.26681149e-01f, 2.60055751e-01f, 6.47964329e-02f, -8.83100927e-02f, 8.07054564e-02f, 1.39649540e-01f, 8.00692961e-02f, 1.39276028e-01f, 2.28298251e-02f, 1.00511141e-01f,
  1.18864521e-01f, -8.09106678e-02f, -1.25334516e-01f, 1.36148795e-01f, -8.50569606e-02f, 9.85915884e-02f, -5.67552298e-02f, 9.19805281e-03f, -4.59794700e-02f, -2.38723278e-01f,
  -1.64334968e-01f, -2.25634724e-01f, 1.88950911e-01f, -1.74599234e-02f, -1.68501526e-01f, -2.44288251e-01f, 3.78729664e-02f, -2.05137521e-01f, 2.21925512e-01f, -1.39660180e-01f,
  1.44912153e-01f, 6.01896681e-02f, 1.85132608e-01f, 3.25755030e-01f, 3.83582026e-01f, -4.53478377e-03f, -1.19904257e-01f, -1.13691920e-02f, 2.50744317e-02f, 3.19651105e-02f,
  1.19561002e-01f, 3.06289997e-02f, 9.57466476e-03f, 1.36695644e-02f, 1.19822167e-01f, 6.91948831e-02f, 1.62940979e-01f, -1.38816476e-01f, -4.11032103e-02f, -3.80611159e-02f,
  3.03726852e-01f, 2.55075961e-01f, -1.40550599e-01f, -6.30459711e-02f, 4.05144021e-02f, -8.15572664e-02f, 8.46835785e-03f, -1.29647525e-02f, -7.72643462e-02f, 1.56392857e-01f,
  -3.73117812e-02f, 1.17529586e-01f, 1.40059233e-01f, 1.73833832e-01f, 6.49480969e-02f, -3.77862565e-02f, -1.13848612e-01f, -3.15988585e-02f, -4.68297452e-02f, -3.59474942e-02f,
  2.14046642e-01f, -2.28972360e-02f, 1.73876092e-01f, 3.76283675e-02f, 1.29546717e-01f, 2.50897169e-01f, 2.39641294e-02f, 8.77103359e-02f, -2.84625888e-02f, 5.22242337e-02f,
  1.03360921e-01f, -1.28497437e-01f, 5.53180091e-03f, 8.57045129e-02f, -2.39481544e-03f, 9.04831514e-02f, 2.17389926e-01f, 1.89075083e-01f, 9.92720872e-02f, -2.07753778e-02f,
  1.30094677e-01f, 8.76516104e-02f, -1.30207703e-01f, 1.25353672e-02f, 1.40774455e-02f, -1.37416154e-01f, 9.79570597e-02f, 2.19919533e-01f, 1.36657700e-01f, 2.60881066e-01f,
  5.37490239e-03f, 6.53309226e-02f, 5.62211201e-02f, -1.06448494e-01f, -7.04737939e-03f, -1.53658941e-01f, -8.85357112e-02f, 8.15675259e-02f, -6.22609723e-03f, 1.06628641e-01f,
  -1.92285087e-02f, 5.56017235e-02f, 1.06790699e-02f, -1.14834867e-01f, 5.49678206e-02f, -7.72115141e-02f, -4.94019277e-02f, -9.79594439e-02f, 2.21015625e-02f, -1.92887291e-01f,
  -7.04493448e-02f, -8.63283947e-02f, -5.74781187e-02f, -2.32983306e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.66778290e-01f, 5.22078797e-02f, 1.53450876e-01f, 1.27829447e-01f, -5.71192876e-02f, 8.89618769e-02f, 3.26521322e-02f, 9.97583419e-02f, 3.83354910e-02f, 9.64010656e-02f,
  9.74948704e-02f, 3.69227827e-02f, 4.27745730e-02f, 3.40794884e-02f, 1.63460314e-01f, 8.60598236e-02f, 8.41004252e-02f, 1.61599740e-01f, 4.49227951e-02f, -1.93778444e-02f,
  -1.15490958e-01f, 7.81113058e-02f, 1.96064003e-02f, -7.46826008e-02f, 4.77080047e-02f, 4.79783230e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  4.54396456e-02f, 1.62751168e-01f, -1.89791068e-01f, 8.00871756e-03f, -3.82362306e-02f, -3.32485795e-01f, 1.49381980e-01f, -1.08897723e-01f, -8.24550763e-02f, 1.69690236e-01f,
  -4.08658683e-01f, -1.06334716e-01f, 1.72915414e-01f, -2.51517445e-01f, 7.09364340e-02f, 2.28704214e-02f, -3.46674591e-01f, 1.02162242e-01f, -5.50103068e-01f, -3.73921365e-01f,
  -2.15867341e-01f, 2.41874471e-01f, -4.91650291e-02f, 1.82451561e-01f, -1.03801534e-01f, 2.73711324e-01f, 5.11666894e-01f, 1.98146641e-01f, 3.00992310e-01f, -1.60163477e-01f,
  -1.86011329e-01f, -2.88516641e-01f, 1.73020348e-01f, 5.26939593e-02f, -6.01864196e-02f, -1.87863290e-01f, 2.28886142e-01f, -1.58435896e-01f, -2.55661011e-01f, -1.09801471e-01f,
  1.60224110e-01f, -1.20120749e-01f, -1.66292816e-01f, 2.16022693e-02f, -1.03374995e-01f, -1.95533544e-01f, 4.87522259e-02f, -9.04213935e-02f, -3.22568446e-01f, -8.65780488e-02f,
  -9.60111171e-02f, -2.49556422e-01f, 3.28134626e-01f, 4.50652152e-01f, 5.43086454e-02f, 2.92574137e-01f, -8.16171765e-02f, -1.81519389e-01f, 4.61086817e-02f, -2.21353412e-01f,
  2.43782312e-01f, 2.05371097e-01f, 5.57991624e-01f, -1.80592090e-02f, 2.44024739e-01f, 5.35435915e-01f, -1.73719347e-01f, -2.64078844e-03f, -1.28405571e-01f, -1.04601949e-01f,
  1.65491849e-01f, 2.26756588e-01f, -1.63233235e-01f, 2.20971182e-01f, 1.26769513e-01f, 5.07630501e-03f, -1.23322427e-01f, 4.32667434e-02f, -2.25313693e-01f, 1.32384613e-01f,
  5.02343439e-02f, 4.53308262e-02f, -5.70301414e-01f, -6.74558818e-01f, -8.94021988e-02f, 5.38493633e-01f, 3.47299337e-01f, -2.60026148e-03f, -1.57652125e-01f, 2.49339342e-01f,
  -3.82799387e-01f, 3.05288702e-01f, 4.16466475e-01f, 1.97943732e-01f, 5.37771583e-01f, 1.74777150e-01f, -1.37626246e-01f, 3.94965447e-02f, 1.00277059e-01f, 2.61856526e-01f,
  5.78194261e-01f, 7.08753709e-03f, -5.65515816e-01f, -3.66154388e-02f, -2.15141892e-01f, 3.31961423e-01f, -1.02629691e-01f, 8.92391950e-02f, -6.71313703e-02f, 2.32310578e-01f,
  -1.40598223e-01f, 1.21624798e-01f, -2.49909505e-01f, -1.65835142e-01f, -2.72551924e-01f, -6.45840466e-02f, 6.32917345e-01f, -1.14225149e-01f, 2.75266320e-01f, 4.37159181e-01f,
  -3.61950733e-02f, 2.92937249e-01f, 7.33893290e-02f, 1.70796171e-01f, -1.98847488e-01f, -3.69647797e-03f, 1.19739264e-01f, -2.68555760e-01f, -5.03126740e-01f, -4.47428107e-01f,
  3.89195025e-01f, -4.81778421e-02f, 7.96800200e-03f, -2.46646717e-01f, -1.34334549e-01f, 4.44365442e-01f, 4.78556976e-02f, -1.20066114e-01f, 1.47558779e-01f, 1.52917340e-01f,
  4.48635705e-02f, 4.58898813e-01f, -2.17950508e-01f, 8.88260901e-02f, 2.41217297e-02f, 2.70296127e-01f, 1.62263244e-01f, 2.88060486e-01f, -3.04835886e-01f, -4.81020331e-01f,
  4.24418688e-01f, -1.02326591e-02f, -1.58944860e-01f, -1.86168060e-01f, 7.42621124e-02f, 3.47852618e-01f, 7.29058862e-01f, 4.15688455e-01f, -1.62671566e-01f, 2.47657776e-01f,
  7.37595037e-02f, -4.05463606e-01f, 5.65238111e-02f, 1.42014936e-01f, -1.79489385e-02f, -3.17645937e-01f, -4.72229749e-01f, -1.71954796e-01f, -8.52031112e-02f, 5.51392511e-02f,
  3.48325470e-03f, 3.76312524e-01f, 1.03661798e-01f, -2.21980050e-01f, 4.91236635e-02f, -3.45966220e-02f, 1.94249637e-02f, -2.10844129e-01f, 5.13172597e-02f, 9.85060781e-02f,
  -1.04742616e-01f, 3.58909974e-03f, -4.82388586e-02f, 3.67598146e-01f, -1.30400462e-02f, 1.56788200e-01f, 6.91402378e-03f, -3.81071806e-01f, -1.52367651e-01f, 1.78910375e-01f,
  6.17788136e-02f, -6.73409831e-03f, 4.14936692e-01f, 1.05568916e-01f, 4.27836448e-01f, 1.13104075e-01f, -8.70061386e-03f, 4.92823452e-01f, -3.05453464e-02f, 3.43658119e-01f,
  4.41428199e-02f, 1.02651611e-01f, -1.19796069e-02f, -7.89892972e-02f, 2.19005078e-01f, 3.04507077e-01f, 8.97347406e-02f, -2.31094778e-01f, -2.00664058e-01f, 9.09631699e-02f,
  1.65190518e-01f, 6.05971776e-02f, -1.62246987e-01f, 4.22440886e-01f, 4.92554307e-01f, 4.74381417e-01f, -2.27340758e-01f, -2.97751963e-01f, 3.14105719e-01f, -4.83829468e-01f,
  -3.62134218e-01f, -3.81535351e-01f, -2.56567180e-01f, -5.08254468e-01f, 4.82416242e-01f, -7.79727325e-02f, -3.52782726e-01f, -4.57772732e-01f, -2.59013623e-01f, -3.33050221e-01f,
  1.72664002e-01f, -1.43865868e-01f, -2.80152913e-02f, -1.49525739e-02f, -2.06917543e-02f, -4.47417676e-01f, -1.62699912e-02f, -2.68739104e-01f, 1.21076554e-01f, -6.29943684e-02f,
  -1.05206370e-01f, 8.87865573e-02f, 4.30415481e-01f, -2.83046246e-01f, -2.15650812e-01f, -2.23580480e-01f, -2.12168917e-01f, 2.16839626e-01f, 1.64260995e-02f, -1.56750336e-01f,
  -5.14271483e-02f, -1.13238469e-01f, -5.36685288e-02f, 8.47169086e-02f, 2.13675633e-01f, 6.85786977e-02f, -2.42476434e-01f, -3.98441136e-01f, -1.47504851e-01f, -1.29233599e-01f,
  -1.20697588e-01f, -4.08268422e-01f, -7.34313428e-02f, 1.80961117e-02f, 4.76098917e-02f, -3.54532599e-01f, -1.30840102e-02f, -2.53978491e-01f, -2.80462448e-02f, -5.55911958e-01f,
  -5.24933115e-02f, -2.80138701e-01f, 2.83166356e-02f, 5.84553555e-02f, 8.22632238e-02f, 6.14499211e-01f, -2.65907884e-01f, 5.46805501e-01f, -1.56768724e-01f, 2.55965173e-01f,
  -1.15257487e-01f, -3.94058019e-01f, 2.04303846e-01f, -1.32500887e-01f, -3.75279367e-01f, -1.83103338e-01f, -2.49050409e-01f, 2.10363373e-01f, 5.54113872e-02f, 3.97925004e-02f,
  -3.33190590e-01f, -2.14003116e-01f, -2.02847943e-01f, -7.20315129e-02f, 3.40946674e-01f, -1.50484353e-01f, 8.83599818e-02f, -2.92393088e-01f, -9.15438086e-02f, 5.83753347e-01f,
  8.89766775e-03f, -3.97290066e-02f, -4.68510389e-03f, 9.42679122e-02f, -3.51429254e-01f, -8.03192481e-02f, -1.61948830e-01f, 1.41008953e-02f, -3.90931666e-01f, 1.42062753e-01f,
  1.25277102e-01f, -7.13720843e-02f, 3.23456638e-02f, -1.82263270e-01f, 2.33438574e-02f, -2.21485361e-01f, -3.42024416e-02f, -1.32691786e-02f, 3.15722585e-01f, 3.36860597e-01f,
  2.53365546e-01f, 2.60786861e-01f, 4.18668509e-01f, 7.68585652e-02f, 9.24893282e-03f, 2.81284004e-02f, 1.14095874e-01f, -1.11242093e-01f, 5.27866296e-02f, 7.68995136e-02f,
  -1.69083655e-01f, 3.55283380e-01f, -3.53179067e-01f, 5.06794602e-02f, -1.55949071e-01f, -1.79117352e-01f, 1.28481254e-01f, 1.56526089e-01f, -7.41197318e-02f, 2.52780795e-01f,
  4.20552045e-01f, 3.65360826e-01f, -1.12490263e-02f, -2.24530622e-01f, -8.16427320e-02f, 2.49880493e-01f, -3.22175413e-01f, 2.07450122e-01f, -1.82740554e-01f, -2.06888095e-01f,
  1.10980220e-01f, -7.83667266e-02f, 1.35570109e-01f, -2.24875167e-01f, 3.88867289e-01f, -1.72327980e-01f, -2.20678046e-01f, -5.71877599e-01f, 4.69587952e-01f, -1.18377373e-01f,
  -8.30345005e-02f, 6.56986907e-02f, -1.16526030e-01f, 2.54323661e-01f, -6.40648557e-03f, 4.23868179e-01f, -7.40190297e-02f, 4.73464876e-02f, 1.28879070e-01f, -9.80222039e-03f,
  -3.39430243e-01f, -3.51097286e-01f, 7.30826259e-02f, -6.88685775e-02f, 1.19988970e-01f, -2.99751535e-02f, 2.18603879e-01f, 3.45175892e-01f, 3.14733423e-02f, 2.22130418e-01f,
  -8.43927711e-02f, 1.13804013e-01f, 2.59574264e-01f, 1.44801363e-01f, -6.04597926e-01f, -1.10103972e-01f, -5.67608297e-01f, 2.46368393e-01f, -5.91073744e-02f, 8.53978917e-02f,
  -2.05206335e-01f, -3.47696692e-01f, -8.52376968e-03f, 4.66312133e-02f, -2.78296083e-01f, 2.15005726e-01f, -5.47940493e-01f, 1.78540945e-01f, 1.33885607e-01f, 4.22099605e-03f,
  -1.77789211e-01f, -6.29429579e-01f, -2.28749201e-01f, 2.39535600e-01f, -4.09683585e-01f, 6.34421175e-03f, -8.73976480e-03f, -3.68728310e-01f, -3.28377783e-01f, -2.77444512e-01f,
  -1.64405280e-03f, 2.47909073e-02f, -1.27125040e-01f, 4.19573575e-01f, 2.66065627e-01f, 1.59097239e-01f, -2.79017448e-01f, 4.05866891e-01f, 1.82831123e-01f, 1.81538612e-01f,
  8.18661042e-03f, 4.56671923e-01f, 4.65383492e-02f, -1.84064046e-01f, 5.18728942e-02f, -5.57323210e-02f, 6.68758713e-03f, 1.80867389e-02f, -9.30019021e-02f, 1.38823718e-01f,
  -2.88971066e-01f, 1.20836705e-01f, 1.18704170e-01f, 7.66942650e-02f, -1.85511753e-01f, 4.37650442e-01f, -9.47791431e-03f, -1.82623848e-01f, -1.51785523e-01f, -6.02122350e-03f,
  7.52365068e-02f, -2.25973681e-01f, 1.25105813e-01f, 1.68156311e-01f, 2.08963137e-02f, 5.26423641e-02f, -2.76857942e-01f, -1.21811721e-02f, 2.19564468e-01f, -1.78012755e-02f,
  -3.82036418e-01f, 7.95848668e-02f, 2.25270316e-01f, 9.13076997e-02f, 1.38597608e-01f, 3.32283139e-01f, 1.40112499e-03f, -2.93125417e-02f, 7.88156614e-02f, -4.02043425e-02f,
  1.59486160e-01f, -3.48020911e-01f, 3.12987007e-02f, -5.30251712e-02f, 1.94803134e-01f, 1.51749104e-01f, 2.36834958e-01f, 1.71026781e-01f, -2.88172483e-01f, -3.19950461e-01f,
  -7.42820948e-02f, 3.35571654e-02f, 5.51309943e-01f, -2.69087136e-01f, 2.24303797e-01f, 1.37512997e-01f, 3.12119275e-01f, 1.97496310e-01f, -2.38095701e-01f, -7.17519522e-01f,
  -4.18991238e-01f, -7.76544064e-02f, 1.87765494e-01f, -3.09987396e-01f, 1.72317743e-01f, 1.04956701e-01f, -2.06822976e-01f, 5.57099581e-01f, -5.38944490e-02f, -1.49212986e-01f,
  5.92844933e-02f, -5.20566523e-01f, -1.00637086e-01f, -4.42864746e-02f, 4.52483110e-02f, 7.47479200e-02f, 3.22969943e-01f, -9.56147164e-02f, 1.48770511e-01f, -1.03317760e-01f,
  -1.92760542e-01f, -9.14927572e-02f, -1.27664898e-02f, -2.79451877e-01f, 1.18977316e-01f, 3.35603282e-02f, -1.26015127e-01f, 2.48405337e-01f, -7.56534934e-02f, 8.63538980e-02f,
  -3.36718470e-01f, -1.64137274e-01f, 2.54265219e-01f, -8.48742425e-02f, -1.85065359e-01f, -8.79687443e-02f, -8.78494531e-02f, 1.86972380e-01f, -1.75627425e-01f, -5.35478294e-01f,
  -4.10589352e-02f, 1.61557645e-01f, -5.10834828e-02f, -4.25962538e-01f, -2.32970029e-01f, -7.22925738e-02f, 1.00792117e-01f, -2.32854947e-01f, 2.36395281e-03f, -2.02412102e-02f,
  1.02008887e-01f, -2.93174475e-01f, 5.67609072e-01f, -2.59264678e-01f, 8.05306137e-02f, -4.11826372e-01f, 5.26331246e-01f, 2.22577006e-01f, 8.44645724e-02f, -1.29801333e-01f,
  -2.41361652e-03f, -2.96947420e-01f, 1.62633970e-01f, 2.20580637e-01f, -2.10616469e-01f, 4.66118872e-01f, 4.67462659e-01f, 1.06432728e-01f, -2.42303342e-01f, -2.59495247e-02f,
  -3.38817954e-01f, -1.09652681e-02f, -1.78136155e-01f, 1.38567060e-01f, 1.38474002e-01f, -4.60220307e-01f, 1.27964303e-01f, 4.17535424e-01f, -3.73283029e-02f, -2.37415925e-01f,
  -1.75175101e-01f, 3.35370928e-01f, 2.39157364e-01f, 4.53441106e-02f, 1.23443179e-01f, -1.90816388e-01f, -6.15466796e-02f, 4.89751287e-02f, -2.96233501e-02f, 2.90533781e-01f,
  1.71254426e-02f, 2.97872186e-01f, 1.29823610e-01f, 1.09478228e-01f, -1.79576620e-01f, -3.78462858e-02f, -5.22636890e-01f, -6.69271708e-01f, 2.72887647e-01f, -3.63148749e-02f,
  -6.63748905e-02f, -2.17394248e-01f, -8.28614607e-02f, 6.77291602e-02f, 1.89441159e-01f, -3.23674418e-02f, 2.23989010e-01f, -2.29978323e-01f, 1.71304867e-01f, 2.27778167e-01f,
  -1.03836223e-01f, 2.15248838e-01f, 1.84581503e-01f, -9.70502123e-02f, 2.73647875e-01f, -2.99140215e-02f, -2.35085681e-01f, -3.28463465e-01f, -5.57803690e-01f, -3.70520711e-01f,
  -3.58065009e-01f, -4.07260954e-01f, -5.58060586e-01f, 1.01556279e-01f, -3.42341632e-01f, -8.49037766e-02f, -6.02489114e-01f, 2.80843645e-01f, 3.00006233e-02f, -4.53427136e-01f,
  7.29872147e-03f, -2.21457705e-01f, -4.41068590e-01f, 5.26696861e-01f, 2.62381256e-01f, -3.91172133e-02f, 1.30427703e-01f, 4.45733108e-02f, -1.15213633e-01f, -5.20074069e-02f,
  8.89486000e-02f, -3.17317307e-01f, -1.47955745e-01f, -2.12742493e-01f, 1.94155842e-01f, -2.72672325e-01f, -1.31074071e-01f, 3.75927269e-01f, -3.15701038e-01f, 2.25002747e-02f,
  5.82999433e-04f, -4.47536439e-01f, 9.83384252e-02f, -1.03788897e-01f, -1.28433183e-01f, -1.19546782e-02f, 9.93868057e-03f, 4.57776524e-02f, -1.07451238e-01f, -9.44036171e-02f,
  5.17401211e-02f, 2.02541724e-02f, 2.31326327e-01f, -7.28484765e-02f, -2.37574838e-02f, -4.07015413e-01f, -1.22824628e-02f, 1.23534925e-01f, -6.89478889e-02f, 5.89821637e-02f,
  -2.38881782e-01f, -8.61813203e-02f, -2.85148203e-01f, -1.26918539e-01f, 1.98548272e-01f, 2.19725862e-01f, -2.63755620e-01f, 1.53343856e-01f, 2.12785527e-01f, 2.57977992e-01f,
  4.67689484e-01f, -2.63177544e-01f, -5.25332153e-01f, 7.87440985e-02f, -3.35115194e-01f, 4.98183817e-01f, -1.83013588e-01f, 2.64266413e-02f, -1.71856776e-01f, -2.10135534e-01f,
  2.00303808e-01f, 1.90687060e-01f, 3.71493071e-01f, 7.57278949e-02f, -7.08608702e-02f, 3.33549470e-01f, 5.71085453e-01f, 1.29105076e-01f, -1.41832054e-01f, -2.30797693e-01f,
  1.63881779e-01f, 5.43604046e-03f, 1.93227634e-01f, 3.90022427e-01f, 1.90446284e-02f, -9.60798785e-02f, -1.34383291e-01f, -2.95758963e-01f, 1.60560794e-02f, 5.55592835e-01f,
  1.64915934e-01f, -2.06823915e-01f, -4.50688004e-02f, 2.14889407e-01f, 1.26782462e-01f, -4.01018530e-01f, 6.36584451e-03f, -1.89390868e-01f, 1.25362352e-01f, 1.05472073e-01f,
  -4.19684760e-02f, -1.12365834e-01f, -3.84392083e-01f, 3.63370508e-01f, 4.45405751e-01f, 4.05462623e-01f, -5.43247238e-02f, -8.60238299e-02f, 9.02656093e-03f, 2.88556844e-01f,
  1.56524658e-01f, -4.34793144e-01f, -1.88743517e-01f, -2.60154247e-01f, -1.06647283e-01f, 1.82094350e-01f, 3.27904314e-01f, 1.27744645e-01f, 8.81761685e-02f, -1.11649446e-02f,
  -1.03133515e-01f, -3.75483960e-01f, 8.34563281e-03f, 8.27127323e-03f, 1.03444204e-01f, -2.29976207e-01f, 3.70515913e-01f, 2.79932052e-01f, 4.08140540e-01f, -1.71714142e-01f,
  -5.89704625e-02f, -4.18516546e-01f, -3.91950637e-01f, 3.22186202e-01f, 1.50920287e-01f, 7.85666481e-02f, -1.97463319e-01f, 3.56099814e-01f, -2.58515365e-02f, 3.34894329e-01f,
  -2.19411969e-01f, 2.90130436e-01f, 7.58642852e-01f, -1.29017994e-01f, -3.46839265e-03f, -1.57154396e-01f, 4.76859920e-02f, -5.06034076e-01f, -3.26063931e-02f, -3.06389838e-01f,
  -2.84368638e-02f, 2.54821837e-01f, 7.11485967e-02f, 2.01333851e-01f, -1.43549755e-01f, -3.56351770e-02f, 2.15026625e-02f, -3.51107158e-02f, -1.49456292e-01f, 4.35909890e-02f,
  -1.92268059e-01f, -1.33763373e-01f, 1.03102975e-01f, -1.07603669e-01f, 1.54497772e-01f, -1.03253216e-01f, -1.22010499e-01f, -1.93648860e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  4.40476723e-02f, 1.20502636e-02f, -1.37500307e-02f, 2.76907235e-01f, -1.24356300e-01f, -1.90449372e-01f, -1.41298547e-01f, 1.82410181e-02f, 3.78900543e-02f, 1.59346879e-01f,
  3.91624607e-02f, -1.28131201e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    