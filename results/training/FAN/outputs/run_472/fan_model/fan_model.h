/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.65311629e-01f, 1.11961789e-01f, -2.85350811e-02f, -7.62912855e-02f, -1.44566894e-01f, 2.82336343e-02f, -8.69056880e-02f, -2.67496724e-02f, -2.44605131e-02f, 8.10635239e-02f,
  3.01063694e-02f, -1.16642661e-01f, 3.19653638e-02f, 8.72441679e-02f, -2.39616722e-01f, 1.33298263e-01f, -5.72843850e-02f, 4.12500650e-02f, 7.71474242e-02f, -9.92312208e-02f,
  -8.29034299e-02f, -1.56056210e-01f, 1.13277949e-01f, 1.17287703e-01f, -5.42950630e-02f, 8.43005776e-02f, -3.31766047e-02f, 1.14245154e-01f, -6.50207028e-02f, -1.68083180e-02f,
  -1.71599034e-02f, 7.64459148e-02f, 3.11499201e-02f, 1.01478934e-01f, -2.98432400e-03f, 9.99529948e-05f, -1.51928812e-02f, 3.92361730e-02f, 7.34261563e-03f, 3.01301349e-02f,
  -4.20505274e-03f, 1.25752222e-02f, -2.67023724e-02f, -1.47529244e-02f, -2.15152483e-02f, 4.48741168e-02f, 2.19296315e-03f, 6.51725307e-02f, 7.06777647e-02f, 1.33232474e-01f,
  8.69067907e-02f, 6.78956136e-02f, -3.83459206e-04f, 5.95106706e-02f, -2.43511121e-03f, 3.51972617e-02f, -3.40868626e-03f, -4.10475731e-02f, 3.36242281e-02f, -1.29759470e-02f,
  -1.84347555e-02f, 2.66860146e-03f, 3.85374427e-02f, 4.73692641e-02f, -3.10260188e-02f, 7.37612718e-04f, 2.96614654e-02f, 1.69981867e-02f, -4.42274027e-02f, -2.98823183e-03f,
  -1.64142400e-02f, -3.77861373e-02f, 3.64634544e-02f, 2.86575761e-02f, -6.31612316e-02f, -2.62511801e-02f, -2.91677173e-02f, -3.20260823e-02f, 2.80188844e-02f, 1.43486280e-02f,
  2.54401062e-02f, 2.66737528e-02f, 4.71608639e-02f, -4.23342995e-02f, 2.84332819e-02f, -5.80384135e-02f, 4.15031426e-03f, 3.33727635e-02f, 9.86253284e-03f, 4.85813944e-03f,
  -2.80710924e-02f, -6.02364354e-02f, 2.82547213e-02f, 7.99319893e-03f, 8.25166628e-02f, 2.03366000e-02f, 8.15746281e-03f, 3.21206730e-03f, -8.80331770e-02f, -6.19830713e-02f,
  -2.72370018e-02f, -1.17653660e-01f, 2.19562007e-05f, 1.47662433e-02f, -5.40685058e-02f, 3.51666063e-02f, -1.62033341e-03f, 6.66356906e-02f, -8.76581967e-02f, 2.35745460e-02f,
  1.29739158e-02f, -6.03106469e-02f, -2.01955345e-02f, -3.93447094e-02f, -1.02306297e-03f, -2.59721428e-02f, -1.49858490e-01f, 7.71707967e-02f, 3.73514965e-02f, -4.33680136e-03f,
  3.21236789e-01f, 6.19727653e-03f, 1.58152133e-01f, -1.40940864e-02f, -8.93986132e-03f, -3.52467358e-01f, -2.95311529e-02f, 2.06027515e-02f, -1.83142841e-01f, -2.70249248e-02f,
  -7.89876357e-02f, -4.99516875e-02f, -7.20309168e-02f, -6.46905899e-02f, -9.56850946e-02f, -1.69828236e-01f, -3.13105062e-02f, 7.25524686e-03f, -6.39576018e-02f, -7.59654120e-02f,
  -2.73502003e-02f, -1.06919974e-01f, 1.88967458e-03f, 4.65346165e-02f, 2.46166941e-02f, 2.32147157e-01f, 6.41883165e-02f, 3.10647744e-03f, -3.87593769e-02f, -3.82433161e-02f,
  1.49224535e-01f, 2.66623378e-01f, 6.76417723e-02f, 2.73164874e-03f, 2.67264377e-02f, 8.45666416e-03f, 4.09668759e-02f, 1.61463767e-02f, -1.81271359e-02f, -4.21817936e-02f,
  -3.01788989e-02f, -3.01432349e-02f, 1.10235149e-02f, -6.33817986e-02f, -1.02234110e-01f, 2.64223921e-03f, -6.41916692e-02f, -3.63332927e-02f, 1.00917546e-02f, 8.61833058e-03f,
  4.49789548e-03f, -2.37578675e-02f, -3.60664204e-02f, 4.79302369e-02f, 5.20992205e-02f, 2.35468149e-03f, -3.82360518e-02f, -1.19386604e-02f, 8.61072913e-03f, 2.07311194e-03f,
  1.53013663e-02f, 1.70819163e-02f, 2.61213854e-02f, -3.65915149e-02f, 6.59668893e-02f, 5.65196723e-02f, -4.63442691e-02f, -1.51268877e-02f, 3.27150673e-02f, -8.78223330e-02f,
  -5.79850888e-03f, 1.21015739e-02f, -5.61080948e-02f, -1.14302851e-01f, -2.27803327e-02f, 2.28254963e-02f, -5.14362892e-03f, -9.25956219e-02f, -2.24872287e-02f, -5.51726110e-03f,
  -1.56834684e-02f, 1.75660793e-02f, -1.51318200e-02f, 3.06292139e-02f, -5.52566536e-02f, -5.08708842e-02f, -1.10661611e-01f, -5.46372076e-03f, 5.44699468e-02f, 9.67891049e-03f,
  2.00763512e-02f, 1.87562071e-02f, -5.41053340e-02f, -2.22114827e-02f, -2.39455476e-02f, -4.95481677e-02f, -5.05953678e-04f, -3.28974538e-02f, -2.21540686e-02f, -1.51524721e-02f,
  6.99105766e-03f, 9.85365361e-03f, 4.99808043e-02f, -2.84728184e-02f, -2.81233229e-02f, -4.37269062e-02f, -1.99122839e-02f, 4.79972363e-02f, 2.07196400e-02f, 6.03572885e-03f,
  -4.86944132e-02f, 1.16376886e-02f, 3.78692895e-02f, 7.79122561e-02f, 3.69356722e-02f, 6.12116456e-02f, 6.17976151e-02f, 3.72253135e-02f, 2.03022677e-02f, -1.23379417e-02f,
  -4.18369502e-01f, 5.22381514e-02f, 6.90715834e-02f, -1.11978002e-01f, -3.76170874e-02f, -5.17629944e-02f, -1.91269282e-05f, 1.30255856e-02f, -1.46697583e-02f, 4.08587530e-02f,
  -1.30165055e-01f, -5.85129894e-02f, 6.30912418e-03f, -6.74439073e-02f, -1.66825190e-01f, -9.06490372e-04f, -1.53066844e-01f, 5.69808148e-02f, -3.90035808e-02f, -8.60286057e-02f,
  -1.73013341e-02f, -4.82328050e-02f, -5.04779257e-02f, -1.71035025e-02f, -2.75530405e-02f, -4.06515673e-02f, 3.03303041e-02f, 3.60065661e-02f, 2.00889390e-02f, -3.86854596e-02f,
  -9.16166678e-02f, -1.56096062e-02f, -4.86841379e-03f, 6.86301216e-02f, -4.20703851e-02f, 3.81861366e-02f, -2.08462998e-02f, -1.09039834e-02f, -1.59283243e-02f, -6.51893988e-02f,
  2.75326651e-02f, -1.16872527e-02f, -3.56690660e-02f, -5.28025860e-03f, 5.41418642e-02f, 2.26018988e-02f, -2.44248728e-03f, -3.77150215e-02f, -2.97928303e-02f, -1.31502328e-02f,
  1.79837793e-02f, 4.36575375e-02f, 9.38838422e-02f, 6.82886243e-02f, 9.94258001e-03f, 2.18290202e-02f, 2.91701946e-02f, 5.34064770e-02f, 5.79736428e-03f, 2.84352489e-02f,
  -2.53605079e-02f, 2.34082062e-02f, -1.18534500e-02f, -4.55484055e-02f, -6.79652840e-02f, -2.66813766e-03f, -1.72192212e-02f, 5.72203360e-02f, 1.09427283e-02f, -2.57563889e-02f,
  -4.17761505e-02f, -1.25782881e-02f, -5.20613268e-02f, 7.38756685e-03f, -1.73177458e-02f, -6.77029863e-02f, -1.25099262e-02f, -4.19404581e-02f, -1.62314400e-02f, -5.82862273e-02f,
  -1.36109516e-02f, -6.01117685e-02f, -3.46322395e-02f, 1.02475313e-02f, -1.11603392e-02f, 3.34217865e-03f, 1.67575628e-02f, -3.78352590e-02f, -1.84490215e-02f, -1.68021321e-02f,
  4.90170270e-02f, -6.19299859e-02f, -6.39899750e-04f, -5.33551052e-02f, 4.45007905e-02f, 1.51590165e-02f, 2.75839195e-02f, -4.62823035e-03f, -5.33610233e-04f, -1.37952128e-02f,
  -1.74488742e-02f, 8.51467550e-02f, -3.37399878e-02f, 2.10727975e-02f, 1.88238211e-02f, 3.79109792e-02f, 3.07549946e-02f, -6.51503056e-02f, 2.89440621e-02f, -9.09002498e-03f,
  -5.07117882e-02f, -3.02369427e-02f, -7.66648538e-03f, -2.27707718e-02f, 2.82817092e-02f, -2.68698446e-02f, -3.11429147e-02f, -3.02447360e-02f, -4.44524847e-02f, -1.75927337e-02f,
  1.42419785e-01f, 1.20793946e-01f, 4.84293252e-02f, 2.55890965e-01f, 1.14587881e-03f, -1.62329063e-01f, -2.73156136e-01f, 2.86659807e-01f, -5.40622137e-02f, 7.35128149e-02f,
  -6.83879852e-02f, -6.01104349e-02f, -1.51706204e-01f, 2.02069148e-01f, -1.55933619e-01f, -6.77154213e-02f, 1.47629529e-01f, 4.58210260e-02f, 7.77198002e-02f, 5.69802411e-02f,
  6.44763932e-02f, 1.43528923e-01f, 1.40879214e-01f, 1.83920234e-01f, 6.80391043e-02f, 6.06561899e-02f, 1.99625313e-01f, -1.08961754e-01f, 2.56597221e-01f, -2.82006226e-02f,
  -1.73085466e-01f, -5.50935902e-02f, 3.82048003e-02f, 2.09258366e-02f, 7.20546320e-02f, 5.77784367e-02f, 1.25025650e-02f, -2.73114033e-02f, -3.22602391e-02f, -1.02113718e-02f,
  -5.62451370e-02f, -2.27392018e-02f, 3.51280458e-02f, -5.85355796e-02f, -1.39529491e-02f, -3.69073041e-02f, -8.43511429e-03f, -1.97691172e-02f, -3.45921493e-03f, -1.44926701e-02f,
  -2.06213854e-02f, 2.26169638e-02f, 1.43169360e-02f, -3.97303961e-02f, 5.05792350e-03f, -4.29946557e-02f, 3.94611843e-02f, -8.11810717e-02f, 3.59029323e-02f, 3.89161557e-02f,
  -6.73368871e-02f, 3.26584205e-02f, 2.56879181e-02f, -2.89903348e-03f, -2.00678166e-02f, -2.81194318e-02f, -4.04434092e-02f, 2.12267209e-02f, -1.62837468e-02f, -5.84294051e-02f,
  7.96433389e-02f, 4.31311727e-02f, 2.53778342e-02f, 5.23290783e-02f, 2.14457121e-02f, 4.95198881e-04f, 4.55420762e-02f, -9.87881236e-03f, 2.27921419e-02f, -1.15577655e-03f,
  -3.21391993e-03f, 4.81447205e-02f, 1.42509835e-02f, 2.29097474e-02f, -4.49373387e-02f, -3.02860048e-02f, 1.53093962e-02f, -5.23884781e-02f, -1.78307854e-02f, 4.01964784e-02f,
  -3.57097127e-02f, 1.44805327e-01f, -6.18994795e-02f, -3.43059190e-02f, -2.57117730e-02f, -3.11335158e-02f, -4.13741656e-02f, 9.56572071e-02f, 4.15926836e-02f, 6.99221157e-03f,
  -2.90609319e-02f, 5.79393692e-02f, 4.56899107e-02f, 3.24030444e-02f, -1.92481733e-03f, 6.58065733e-03f, 5.16645238e-02f, -9.29600280e-03f, 4.76045497e-02f, 8.26384574e-02f,
  4.85858582e-02f, -2.80414354e-02f, -1.57241859e-02f, 1.63509548e-02f, 4.71077003e-02f, -2.36351695e-02f, -1.96810197e-02f, -3.85923013e-02f, 4.81849685e-02f, 5.82587197e-02f,
  -2.27186233e-01f, 2.08437175e-01f, 1.57997891e-01f, -7.88975656e-02f, 1.53430402e-01f, -2.28370965e-01f, -1.03912905e-01f, 1.39351159e-01f, -1.47910520e-01f, -2.17209235e-02f,
  -6.87868819e-02f, 8.69822279e-02f, -2.73369830e-02f, -4.31905799e-02f, -3.22462618e-01f, -1.92974612e-01f, -1.70060933e-01f, -8.35458711e-02f, -1.17451452e-01f, 1.28357917e-01f,
  2.29149368e-02f, -7.75411278e-02f, 4.71493155e-02f, 1.20653428e-01f, 7.43710622e-02f, 1.33451819e-01f, 1.05651714e-01f, 6.57116100e-02f, 1.89331025e-01f, -9.06763896e-02f,
  -2.26472747e-02f, 4.52167653e-02f, -1.23395361e-02f, 2.86091538e-03f, 1.10523505e-02f, -7.95690250e-03f, 7.46688470e-02f, -1.22554973e-01f, 9.65290666e-02f, 5.30389510e-03f,
  -2.70522907e-02f, -7.03411773e-02f, -7.96335936e-02f, 2.19243541e-02f, 2.52655391e-02f, 7.14382231e-02f, 3.74903977e-02f, 3.65597755e-02f, 6.94739670e-02f, -5.17975278e-02f,
  6.40167445e-02f, -3.77890095e-02f, 9.28128883e-03f, -9.64140445e-02f, 3.72995920e-02f, -1.53932869e-02f, -3.60466689e-02f, -5.99043854e-02f, -5.70226423e-02f, -6.62365183e-02f,
  -9.15446058e-02f, -4.57866229e-02f, 8.29711929e-03f, 3.66637670e-02f, 4.83973511e-02f, 4.93195280e-03f, 2.72719413e-02f, -6.80131167e-02f, 6.47051781e-02f, 4.39505503e-02f,
  -4.90499176e-02f, 6.73143715e-02f, -3.01906304e-03f, -8.09729565e-03f, -4.19084281e-02f, 2.31888611e-02f, 6.72389288e-03f, 7.47674331e-02f, -2.43333187e-02f, 2.51388736e-02f,
  -4.68528504e-03f, -5.54414541e-02f, -5.12913510e-04f, 4.83962074e-02f, -1.03818402e-02f, 1.00319916e-02f, -4.95165363e-02f, 8.66313428e-02f, 4.04665759e-03f, -3.27198696e-03f,
  4.82415361e-03f, -5.89819439e-02f, -2.16378253e-02f, 7.71559961e-03f, 1.20556671e-02f, -2.07157340e-02f, -8.38960782e-02f, 3.57662812e-02f, -3.27061974e-02f, -7.04820752e-02f,
  -2.15153545e-02f, 4.08248268e-02f, 2.68594064e-02f, -2.76353881e-02f, -2.12030131e-02f, -6.61137849e-02f, 1.32388547e-02f, 5.08517735e-02f, 3.74866612e-02f, 6.98755011e-02f,
  3.09629217e-02f, 4.60999366e-03f, -3.29224393e-02f, 4.52341512e-02f, 2.87401639e-02f, 2.36043311e-03f, 1.80174503e-02f, -6.09180257e-02f, -5.05362600e-02f, -1.02699585e-02f,
  -1.36595964e-01f, 3.17545772e-01f, 4.84665334e-02f, 2.24782694e-02f, -2.73435861e-01f, -2.71007955e-01f, -3.19174916e-01f, -3.80999446e-02f, -8.09477344e-02f, 8.84450451e-02f,
  -8.09525028e-02f, 2.16017850e-02f, 3.52682173e-02f, -1.37691453e-01f, -2.13314116e-01f, 4.62466739e-02f, -5.69689982e-02f, -3.23976278e-02f, -1.76443439e-03f, 7.46159405e-02f,
  -6.25270791e-03f, -7.39461780e-02f, -2.60976516e-02f, 4.73919958e-02f, 1.06443696e-01f, 1.65248513e-01f, 2.07195327e-01f, 1.24464057e-01f, -2.22898158e-03f, -9.06326249e-02f,
  -1.37917206e-01f, 7.89371952e-02f, -3.61830816e-02f, -4.90714014e-02f, 6.16653152e-02f, 1.85428783e-02f, 6.79723024e-02f, -4.15998064e-02f, -7.52024204e-02f, 3.85831296e-02f,
  4.23959792e-02f, -1.02066152e-01f, -2.67544463e-02f, -2.63488516e-02f, -1.99239347e-02f, -5.84733784e-02f, -4.94509982e-03f, 4.79176603e-02f, 1.34230237e-02f, -6.73022121e-02f,
  -2.92621255e-02f, -7.94298202e-03f, 3.29841897e-02f, 8.21999682e-04f, 5.13260923e-02f, -9.39522870e-03f, 2.13207789e-02f, 1.54273948e-02f, -3.68737504e-02f, -2.19166814e-03f,
  1.06013097e-01f, 3.92900296e-02f, -6.14620410e-02f, 4.68550399e-02f, -2.87276078e-02f, -5.16548902e-02f, -6.12198096e-03f, 1.77349281e-02f, 5.26615791e-03f, 2.77719814e-02f,
  -2.04363512e-03f, 2.93183960e-02f, 3.55615504e-02f, -1.58781707e-02f, 1.07150534e-02f, -2.17446033e-03f, -1.48628885e-02f, -1.34341950e-02f, -3.28569300e-02f, -6.86911270e-02f,
  2.69023068e-02f, -3.99968550e-02f, 4.63599805e-03f, 2.91865431e-02f, -1.83254983e-02f, 1.59262624e-02f, 9.16733518e-02f, 6.46477118e-02f, 2.37043332e-02f, -1.59054901e-02f,
  1.01586118e-01f, 2.35650003e-01f, 1.06956568e-02f, -4.82113138e-02f, -2.89211486e-04f, 2.42084190e-02f, 3.65355834e-02f, 3.21907923e-02f, 5.83517477e-02f, -1.20300706e-02f,
  1.35802655e-02f, 2.30122041e-02f, 6.64816126e-02f, -7.24773630e-02f, -2.40798164e-02f, 7.25333616e-02f, 6.30302429e-02f, 2.58580893e-02f, -3.94138806e-02f, 9.98788625e-02f,
  6.88337907e-02f, -1.99812669e-02f, -1.20566199e-02f, -5.97546622e-03f, 3.56566510e-03f, 6.07853867e-02f, -3.09579335e-02f, -2.11853464e-03f, 5.41495197e-02f, 6.20216727e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.01894599e-01f, 2.77968645e-01f, -1.18596859e-01f, 1.19872368e-03f, -3.89613099e-02f, 2.10133821e-01f, 1.84428394e-01f, -1.06914848e-01f, -5.80786727e-02f, 9.65517014e-02f,
  1.81584060e-02f, -2.35608354e-01f, 1.28594890e-01f, 1.81200251e-01f, -1.48877531e-01f, 2.91673094e-01f, 1.57826111e-01f, 6.16534092e-02f, 1.31609946e-01f, -7.85013661e-02f,
  -4.11619321e-02f, 1.13157488e-01f, 6.43617734e-02f, 1.15033463e-01f, -7.86989182e-02f, -5.22622764e-02f, -1.57824293e-01f, 4.01484892e-02f, -4.59520221e-02f, 6.06662454e-03f,
  1.35139748e-01f, -3.23285395e-03f, -8.61118585e-02f, -9.99343544e-02f, -2.04505604e-02f, 3.12758386e-02f, 7.60271177e-02f, -1.13304809e-01f, -4.50977832e-02f, 4.72562723e-02f,
  -6.90787658e-02f, 5.23679480e-02f, 5.39352931e-02f, 7.39007369e-02f, -7.68505633e-02f, -3.17506418e-02f, -5.13628125e-02f, -5.79638518e-02f, -1.19773865e-01f, 1.01408726e-02f,
  -1.30054401e-02f, 3.37909311e-02f, -6.12919277e-04f, 7.35697709e-03f, -3.95222642e-02f, -5.47147654e-02f, 4.79590939e-03f, -3.35819423e-02f, 5.15808873e-02f, -2.46452410e-02f,
  2.92102396e-02f, -5.73006691e-03f, 2.79518981e-02f, 3.48614417e-02f, 2.80159358e-02f, 7.72312954e-02f, -6.78826049e-02f, -9.18747410e-02f, -2.02584043e-02f, 4.40698005e-02f,
  3.20604518e-02f, -1.25993211e-02f, 1.06065318e-01f, -1.02460980e-02f, 3.75147909e-02f, 2.89513133e-02f, -3.82638164e-02f, 1.35790408e-02f, 2.36032618e-04f, -5.91803119e-02f,
  2.11666953e-02f, 1.71797778e-02f, 6.16123416e-02f, 1.02394141e-01f, 1.10121958e-01f, -1.12685755e-01f, -7.91842267e-02f, 2.83056106e-02f, 1.29531715e-02f, -1.63347612e-03f,
  5.98154739e-02f, 9.24990922e-02f, 1.01443365e-01f, 1.25387739e-02f, 3.03308349e-02f, -9.09490734e-02f, 1.03903692e-02f, -1.37819601e-02f, -1.22771757e-02f, -4.76679318e-02f,
  -5.66814654e-02f, 1.47792036e-02f, -7.90415257e-02f, -6.91944286e-02f, -5.46945399e-03f, 3.23040076e-02f, -3.10810748e-02f, -1.24277798e-02f, 1.87355524e-03f, -8.06247815e-02f,
  -3.57522517e-02f, 8.53579342e-02f, -8.52779299e-02f, 3.44964899e-02f, 9.11310432e-04f, -2.68687233e-02f, -1.05541684e-01f, -7.17680305e-02f, 1.90167818e-02f, 1.32673187e-03f,
  -1.29024103e-01f, 5.49167348e-03f, -9.24436823e-02f, -9.93263498e-02f, 1.64691806e-01f, -1.30219785e-02f, -1.02171682e-01f, 9.47783738e-02f, -6.86885342e-02f, 2.79944956e-01f,
  -6.16071783e-02f, 2.18614899e-02f, 7.91885853e-02f, -2.29788989e-01f, -4.05253559e-01f, -2.66781449e-01f, -2.33145744e-01f, 3.84625867e-02f, -1.07287683e-01f, -3.69025692e-02f,
  -1.26710117e-01f, -1.76484346e-01f, -2.89446771e-01f, -2.76269019e-02f, -2.26590429e-02f, 1.25433341e-01f, 1.45952366e-02f, 5.79375215e-02f, 8.27239826e-02f, -1.86877954e-03f,
  -1.19501147e-02f, 1.52792372e-02f, 7.12855980e-02f, -1.04096225e-02f, 9.31313038e-02f, 1.09111525e-01f, -9.74807714e-04f, -1.00229137e-01f, -1.20896213e-01f, 1.09330945e-01f,
  1.50668314e-02f, -9.78794992e-02f, 3.82522829e-02f, -9.53606293e-02f, 7.64969662e-02f, 5.41882180e-02f, -6.40835464e-02f, -3.95733267e-02f, 3.36313471e-02f, 6.17072806e-02f,
  7.75554925e-02f, 1.03008389e-01f, 2.31259000e-02f, 1.23255752e-01f, -7.69925937e-02f, 6.58187717e-02f, 1.00580923e-01f, 3.51515748e-02f, 1.16749860e-01f, -7.63745094e-03f,
  3.85035202e-02f, 1.02947995e-01f, 5.96075458e-03f, -1.12984637e-02f, -5.98691851e-02f, 5.26139550e-02f, -2.86244303e-02f, 2.02767532e-02f, 8.54570344e-02f, -1.05995918e-02f,
  6.01710491e-02f, -4.17140611e-02f, -4.60306555e-02f, -4.21129307e-03f, 8.57913401e-04f, 4.24170904e-02f, 1.59702040e-02f, 2.21017934e-02f, 5.15354015e-02f, -6.65493235e-02f,
  4.60958779e-02f, 3.40596624e-02f, 5.43459989e-02f, -7.34173432e-02f, 5.17338468e-03f, 7.16976002e-02f, -2.28630621e-02f, -1.84410773e-02f, 4.54152822e-02f, -1.04974471e-01f,
  9.25545171e-02f, 1.15424888e-02f, 6.28254637e-02f, 5.46631701e-02f, -4.22564857e-02f, 1.32259494e-02f, -1.45992097e-02f, 3.35058160e-02f, 5.11994064e-02f, -5.33859693e-02f,
  1.35851786e-01f, 9.17724892e-02f, 3.83223295e-02f, 2.36422867e-02f, 1.94700416e-02f, 6.72175214e-02f, -1.19267143e-01f, 7.81662315e-02f, 3.08323372e-02f, -3.94561402e-02f,
  3.62123847e-02f, 5.76591082e-02f, 8.73187706e-02f, 2.41128560e-02f, 7.69449677e-03f, -3.06043793e-02f, -5.40228784e-02f, 2.05040704e-02f, 4.92259637e-02f, 8.11768100e-02f,
  -2.59820133e-01f, 2.01674461e-01f, -2.05471531e-01f, 1.77892044e-01f, -1.94404706e-01f, 2.62554377e-01f, 2.72980928e-01f, 6.80349469e-02f, 8.54875594e-02f, 1.81320846e-01f,
  3.34819630e-02f, 1.59360588e-01f, 3.62685136e-02f, 1.63087443e-01f, -2.56540716e-01f, 1.70493230e-01f, 1.58703804e-01f, 6.36424497e-02f, 4.19022553e-02f, 6.44998848e-02f,
  -1.64442986e-01f, 7.55682448e-03f, -1.79202780e-01f, -9.51228738e-02f, -2.26271451e-02f, 1.14092801e-03f, -9.77355540e-02f, -4.21088710e-02f, 3.96329127e-02f, 4.54823440e-03f,
  7.70451576e-02f, 1.07657025e-03f, -2.27965731e-02f, -5.66477282e-03f, -3.51388827e-02f, -1.67473091e-03f, 2.53468193e-02f, -7.91134834e-02f, -1.71567108e-02f, -1.55219680e-03f,
  1.06994882e-01f, -5.47684655e-02f, 9.58856642e-02f, -3.45661864e-02f, -5.95375150e-02f, -1.32619202e-01f, -3.06564812e-02f, -6.35016114e-02f, 1.01953164e-01f, -2.44830959e-02f,
  -4.52050380e-02f, 2.91985869e-02f, -7.98023269e-02f, 2.65485272e-02f, -7.45544583e-02f, -5.32548353e-02f, 7.29394257e-02f, 7.16885403e-02f, -2.92620156e-03f, -2.07882724e-03f,
  -7.33049810e-02f, 1.04456052e-01f, 6.31354451e-02f, -6.56652153e-02f, -9.07104537e-02f, -1.36956172e-02f, 4.37944941e-02f, -2.78317295e-02f, -5.78147955e-02f, -5.23932390e-02f,
  -4.07825224e-02f, 2.17823442e-02f, -6.44147694e-02f, -1.41778039e-02f, 6.89957142e-02f, 8.21080580e-02f, 2.51404457e-02f, 4.79171351e-02f, 5.04396670e-02f, -2.80801058e-02f,
  -2.08581667e-02f, -1.05539121e-01f, -3.49875689e-02f, -7.45010655e-03f, -4.94245030e-02f, -1.39863594e-02f, -1.82320643e-02f, 1.90455429e-02f, -1.07504271e-01f, 4.46943045e-02f,
  1.43951699e-01f, 6.43194690e-02f, 3.18390429e-02f, 1.60181895e-02f, -7.56907985e-02f, -1.92360999e-03f, 1.27251493e-02f, -6.07290771e-03f, 1.86941903e-02f, 9.38041694e-03f,
  9.06620268e-03f, 5.31037338e-02f, -1.23279681e-02f, -3.47058959e-02f, -2.19567842e-03f, -1.20488638e-02f, 1.01461083e-01f, 9.36767161e-02f, 3.77060436e-02f, -1.40477512e-02f,
  -3.26073430e-02f, 4.66998629e-02f, 4.90013845e-02f, 4.29358743e-02f, -6.63017184e-02f, 9.44804698e-02f, 3.17182690e-02f, -1.01718577e-02f, -1.68735906e-01f, 3.78008336e-02f,
  3.70148122e-02f, -1.01394773e-01f, -1.71166211e-01f, -3.30679654e-03f, -2.00262386e-02f, -1.37978002e-01f, -1.01085722e-01f, 4.73553911e-02f, 3.66502166e-01f, 4.62404639e-02f,
  -2.17371836e-01f, 1.38024271e-01f, -1.38771327e-04f, -3.00293475e-01f, 6.65011108e-02f, 2.00566798e-01f, -1.04910418e-01f, -9.68877375e-02f, 1.05522476e-01f, -6.97068051e-02f,
  -3.36039849e-02f, -2.24265695e-01f, -1.59332573e-01f, -1.41958058e-01f, -1.67042866e-01f, -4.98505533e-02f, -3.39950413e-01f, -5.66835739e-02f, -3.05770963e-01f, 6.01158664e-03f,
  -1.32964909e-01f, 4.70979847e-02f, -1.31785169e-01f, 6.02899417e-02f, -2.91625969e-02f, -3.39535214e-02f, 6.25439659e-02f, -1.95655916e-02f, 1.57092065e-01f, 9.55710486e-02f,
  4.35607061e-02f, 1.07257351e-01f, 3.93517688e-02f, 3.91432792e-02f, 6.16283603e-02f, -8.09103847e-02f, 9.80166197e-02f, 4.65548411e-03f, 4.42169905e-02f, -2.19217334e-02f,
  5.09561822e-02f, 1.54216578e-02f, -7.68159181e-02f, 4.99970205e-02f, -1.55959174e-01f, 9.95044596e-03f, -6.04279898e-03f, -1.42122835e-01f, 6.08002283e-02f, 1.06184803e-01f,
  -6.03468865e-02f, 5.82568944e-02f, -1.08711682e-02f, 7.49883726e-02f, -1.02617115e-01f, 9.51980129e-02f, -4.92671765e-02f, 1.44847455e-02f, 1.82452023e-01f, 9.59764495e-02f,
  9.98929068e-02f, 4.89778928e-02f, -4.02099416e-02f, 7.58140832e-02f, -5.10532632e-02f, 5.96001633e-02f, -1.13978712e-02f, 1.44422334e-03f, -7.98201710e-02f, -1.29881084e-01f,
  -1.66938864e-02f, -5.83139472e-02f, -4.63498943e-02f, 5.12821041e-03f, 4.21286066e-04f, 5.71832694e-02f, 3.24417129e-02f, 5.75816585e-03f, -1.08406685e-01f, -7.86643103e-02f,
  2.16915123e-02f, 9.95262787e-02f, -1.98446885e-02f, -9.77402320e-04f, 8.38418677e-03f, -9.15538371e-02f, 6.65798113e-02f, 7.71334618e-02f, -4.60760631e-02f, -2.31781771e-04f,
  -6.82294071e-02f, 1.65539805e-03f, -3.92028689e-02f, 8.69436283e-03f, 2.06535328e-02f, 1.29574500e-02f, -2.54706144e-02f, -7.63047114e-03f, -7.78999254e-02f, -1.29454166e-01f,
  -5.60397916e-02f, 7.77648762e-02f, 1.48770735e-01f, -1.77053772e-02f, -3.57175395e-02f, -4.38326187e-02f, -8.24192725e-03f, -8.01190436e-02f, -3.13863307e-02f, -7.51168355e-02f,
  -8.51825178e-02f, -1.68936536e-01f, -3.45912993e-01f, -1.21386953e-01f, -2.31417999e-01f, -2.41447061e-01f, -3.05690289e-01f, -1.42346889e-01f, 3.15336362e-02f, 2.42944062e-01f,
  2.10376214e-02f, 8.02720785e-02f, 2.56301999e-01f, 1.49077950e-02f, -1.66404068e-01f, 2.44068414e-01f, -1.64621070e-01f, -6.21262714e-02f, 3.91961634e-02f, -1.80094808e-01f,
  -5.63332736e-02f, 7.44436085e-02f, -1.31058082e-01f, -1.93447880e-02f, -1.90643087e-01f, -1.33344099e-01f, -4.49011922e-02f, -8.27585068e-03f, -2.36137852e-01f, -1.61550611e-01f,
  -1.22461587e-01f, 1.75663739e-01f, -5.99128613e-03f, 1.19319007e-01f, -1.51826814e-01f, -7.58634880e-02f, -6.32207096e-02f, 3.97973582e-02f, 1.21659525e-02f, 1.84107460e-02f,
  4.60702814e-02f, -3.13587561e-02f, -3.28442901e-02f, 1.22316126e-02f, 7.68018421e-03f, -5.69519214e-02f, -7.76121691e-02f, 3.11612181e-04f, 7.38235097e-03f, -5.02119027e-02f,
  9.52451862e-03f, -1.77728683e-02f, -3.03054657e-02f, -2.60453951e-02f, -6.35277480e-02f, 1.78575404e-02f, -4.60822955e-02f, -1.23729400e-01f, -9.15469751e-02f, -8.05456117e-02f,
  4.10269238e-02f, -1.84329990e-02f, -4.98585515e-02f, -4.90984432e-02f, 1.24989403e-02f, -1.58257689e-02f, 2.65102088e-02f, 7.73371011e-02f, 7.82149136e-02f, -5.09265810e-02f,
  9.09286663e-02f, 1.78946815e-02f, 3.52991745e-02f, -5.18931150e-02f, 5.80133907e-02f, 7.61562362e-02f, 7.48069659e-02f, -1.36926360e-02f, -9.00832042e-02f, -3.10662221e-02f,
  7.75552392e-02f, 4.98228967e-02f, -2.92436918e-03f, 2.86503658e-02f, -2.76579075e-02f, -4.60333824e-02f, -1.50847640e-02f, 1.15060747e-01f, -6.95804879e-02f, -9.59134772e-02f,
  -1.25855759e-01f, -3.81332077e-02f, -6.17674692e-03f, -1.76775139e-02f, 3.46844224e-03f, 7.32666925e-02f, -8.16558376e-02f, 1.99091919e-02f, -1.32445768e-01f, -1.43150873e-02f,
  -5.98747656e-03f, 4.51027118e-02f, -1.30184889e-01f, 3.95351239e-02f, 1.38825206e-02f, -1.02924637e-01f, -1.32636696e-01f, -4.02114429e-02f, -1.30069396e-02f, -7.42849708e-02f,
  3.87169945e-04f, 3.29866959e-03f, 5.63041978e-02f, 6.76500872e-02f, 6.42923936e-02f, -1.29452512e-01f, -1.42878592e-01f, 7.76900500e-02f, -8.53162780e-02f, -3.96031477e-02f,
  -2.12297514e-01f, 2.06063241e-01f, 2.82247633e-01f, 1.66137025e-01f, 1.20130323e-01f, 3.74968916e-01f, 2.68185377e-01f, 1.71366811e-01f, 5.14085472e-01f, -3.41222808e-02f,
  -2.57217020e-01f, -6.89992160e-02f, -9.76365432e-02f, -5.28279878e-02f, -1.26813529e-02f, 1.03017196e-01f, 1.48550540e-01f, -6.38438314e-02f, 1.55003175e-01f, -5.01306355e-02f,
  3.69463079e-02f, -2.03211546e-01f, -2.68074777e-02f, -1.26773536e-01f, -2.09177211e-01f, -1.09244928e-01f, -3.74723315e-01f, -3.88804562e-02f, -2.09003389e-01f, 4.46618982e-02f,
  -6.54526725e-02f, -2.34781131e-02f, -1.72665879e-01f, 2.38299351e-02f, -7.54823536e-02f, -6.21917360e-02f, 7.26439944e-03f, 6.63926005e-02f, 5.00351284e-03f, 5.47940247e-02f,
  -4.49046195e-02f, -1.01296052e-01f, 8.87046382e-03f, 1.13156103e-01f, 1.24993019e-01f, -3.48408446e-02f, 7.39356950e-02f, -5.01537062e-02f, 1.70191787e-02f, -2.17104214e-03f,
  -4.22451459e-02f, 4.26927283e-02f, -4.60590757e-02f, 9.10716206e-02f, -2.35155281e-02f, 7.53291249e-02f, 1.36562213e-01f, -4.53174822e-02f, -9.92715433e-02f, 1.24749027e-01f,
  1.05303191e-01f, 2.27639318e-01f, -9.57344472e-03f, -4.63531800e-02f, -1.02548990e-02f, -4.28372510e-02f, -1.38097769e-02f, -1.21933773e-01f, 6.80569112e-02f, -5.58563322e-02f,
  -4.06042896e-02f, -8.24253261e-02f, 1.28641233e-01f, 2.63098180e-02f, 2.36125086e-02f, 2.08982360e-02f, 7.22862966e-03f, 7.21613988e-02f, 1.46118477e-01f, 3.90035585e-02f,
  -1.07674776e-02f, 1.15682678e-02f, -1.32046789e-01f, -7.05382302e-02f, -4.39938083e-02f, -3.33308913e-02f, -1.18700638e-01f, -3.71314697e-02f, 4.37251180e-02f, -6.45556077e-02f,
  1.53810963e-01f, 1.56104282e-01f, -3.27404700e-02f, 2.09399033e-02f, 3.45800966e-02f, -5.14903106e-02f, 7.76269212e-02f, -1.71271060e-02f, 2.10303739e-02f, -2.52357721e-02f,
  7.62546062e-02f, -7.18918741e-02f, -1.55916717e-02f, -5.33506414e-03f, 5.11644520e-02f, -2.53893398e-02f, -3.14554200e-02f, 5.67313097e-02f, -1.21495172e-01f, -5.98922633e-02f,
  -1.14973553e-01f, 2.18415391e-02f, -5.85194975e-02f, -8.94134343e-02f, 2.40378398e-02f, -1.21646032e-01f, 7.88434595e-02f, 2.62723328e-03f, -2.31751073e-02f, 3.69671285e-02f,
  -2.02301145e-02f, -7.13805668e-03f, 5.14542237e-02f, -2.92412847e-01f, 9.51251611e-02f, -2.66693860e-01f, -3.68406437e-02f, -1.56186834e-01f, 5.63544556e-02f, -2.60282338e-01f,
  -2.02472985e-01f, 1.87253490e-01f, 1.12876758e-01f, -2.81537324e-01f, 1.83482885e-01f, 1.39565170e-01f, -1.36268273e-01f, 1.38287265e-02f, 7.04338029e-02f, -2.29151115e-01f,
  1.18837692e-01f, -1.84038073e-01f, -6.27848431e-02f, -1.94970295e-01f, -1.16305366e-01f, -1.10128619e-01f, -4.91070002e-02f, 2.99675539e-02f, -3.04884583e-01f, 9.75793004e-02f,
  -3.06291208e-02f, -1.22287646e-01f, -1.05659731e-01f, -9.67587009e-02f, -7.36872032e-02f, -7.30296923e-03f, -2.91835070e-02f, -5.85051589e-02f, -1.38596535e-01f, 5.26699834e-02f,
  -3.53391394e-02f, 7.50451535e-02f, 4.91942391e-02f, 3.11974231e-02f, -9.62090120e-03f, -9.33022648e-02f, 8.12930912e-02f, -5.76234236e-02f, 2.14091167e-02f, 1.13556065e-01f,
  1.02531202e-01f, 5.16671129e-02f, -1.23543322e-01f, 4.22278158e-02f, 1.10166989e-01f, -1.11619703e-01f, -2.38204002e-02f, 9.85612497e-02f, -6.72073737e-02f, 2.68767085e-02f,
  -1.00427151e-01f, -2.90460512e-02f, 1.03883207e-01f, -2.24017669e-04f, -2.04809040e-01f, -4.91252467e-02f, -5.01414984e-02f, 1.54897626e-02f, 1.37365991e-02f, -3.65331993e-02f,
  -8.28309078e-03f, -2.13019736e-02f, 5.34617566e-02f, 8.26926157e-02f, -5.73870465e-02f, -1.04460586e-02f, 4.78881784e-02f, -1.95263547e-03f, 9.91748720e-02f, 1.04932055e-01f,
  -7.61989355e-02f, -8.48853067e-02f, 1.21691473e-01f, -6.75143078e-02f, -1.56409200e-02f, 6.99417144e-02f, -1.60376355e-02f, -1.56716648e-02f, -7.40488917e-02f, 6.62472248e-02f,
  -4.64127138e-02f, -4.83869493e-01f, 1.87460613e-02f, 1.02715408e-02f, 5.59886061e-02f, -8.04648548e-02f, 6.61336333e-02f, -5.59944101e-02f, -1.46610811e-01f, 1.74760073e-02f,
  -2.23084632e-02f, -6.58758059e-02f, -3.67717864e-03f, -3.04636862e-02f, 1.47061810e-01f, -1.12838805e-01f, -7.17498586e-02f, 8.08478668e-02f, -1.58772022e-02f, -4.87537421e-02f,
  1.28726466e-02f, 6.09741658e-02f, 5.24640903e-02f, -5.88021390e-02f, 7.00678956e-03f, 2.22196653e-02f, 9.95097831e-02f, -1.15008675e-01f, 2.89408695e-02f, 5.45074865e-02f,
  2.98384845e-01f, -3.49133581e-01f, -2.98318803e-01f, -1.16149895e-02f, 2.54859388e-01f, 2.38824040e-01f, -3.91037054e-02f, -1.37228686e-02f, -1.61475435e-01f, 2.63305008e-02f,
  4.37173471e-02f, -1.22193091e-01f, -3.10660779e-01f, 2.57263631e-01f, 1.85825095e-01f, -3.05122823e-01f, 1.28521025e-01f, 3.21334042e-02f, -5.90222701e-02f, -3.54890302e-02f,
  1.85957830e-02f, 3.67148608e-01f, -1.21476322e-01f, 2.02853635e-01f, 1.62609532e-01f, -1.07153244e-01f, -4.47376296e-02f, -1.66751310e-01f, 1.70143828e-01f, 1.21422507e-01f,
  9.48112905e-02f, -1.38032719e-01f, -1.44987740e-02f, 9.89739783e-03f, -5.69640212e-02f, 5.86513989e-02f, -3.73764932e-02f, 2.39013769e-02f, -7.70970387e-03f, -1.06100991e-01f,
  -6.75612944e-04f, 4.28470448e-02f, 8.82514566e-02f, -6.98863203e-03f, 5.87633997e-02f, 3.64539512e-02f, -8.75282213e-02f, -4.65633124e-02f, -8.29565078e-02f, -6.15660427e-03f,
  -3.06610409e-02f, 1.81200274e-03f, -4.16826308e-02f, -2.84154974e-02f, -5.59269078e-02f, -9.62090679e-03f, -7.06588104e-02f, -6.43479265e-03f, 1.11005623e-02f, 7.89175481e-02f,
  4.48149163e-04f, 7.57145435e-02f, -5.33185303e-02f, 9.17820036e-02f, -1.63120925e-02f, 3.57382186e-02f, 3.49927065e-03f, 7.34817423e-03f, -4.75585051e-02f, -1.84001040e-03f,
  1.21262884e-02f, 3.67762893e-03f, 3.28148231e-02f, 6.78370818e-02f, 5.99086992e-02f, 6.25822111e-04f, -3.52310911e-02f, 5.46605606e-03f, 3.23118195e-02f, -4.82184365e-02f,
  -1.43575957e-02f, -3.39377136e-03f, -3.40949707e-02f, -1.17224887e-01f, 3.79274301e-02f, -3.59668843e-02f, 4.58185486e-02f, 4.10535000e-02f, -4.09217142e-02f, -1.32423127e-02f,
  -1.43630922e-01f, -6.77587166e-02f, 1.24765364e-02f, 8.16139802e-02f, 3.90037484e-02f, 4.51802649e-02f, -6.17171302e-02f, -2.03311108e-02f, -9.15051028e-02f, 4.48538512e-02f,
  8.88385028e-02f, 3.82001325e-02f, -1.31109962e-02f, 7.49608278e-02f, 1.87428910e-02f, -4.87716869e-03f, 7.73553178e-03f, -9.65120550e-03f, -1.21752464e-03f, 6.12751730e-02f,
  -2.65554320e-02f, -3.36762443e-02f, -6.00570068e-02f, -2.53777783e-02f, 5.39177209e-02f, -5.32400161e-02f, -8.53156000e-02f, -3.58494334e-02f, -5.72272465e-02f, -7.03356937e-02f,
  1.87866732e-01f, -3.88630599e-01f, 1.94256201e-01f, 2.19617516e-01f, 1.72997013e-01f, 9.85783860e-02f, 3.30379099e-01f, -2.07009733e-01f, -1.13543481e-01f, -2.21009940e-01f,
  4.41113487e-02f, 1.89872310e-02f, -3.49231288e-02f, -8.37395117e-02f, 3.18096638e-01f, -1.29425794e-01f, -8.41070712e-02f, 2.02245614e-03f, -1.40271140e-02f, -1.24474548e-01f,
  1.27504976e-03f, 5.63707948e-02f, 1.04246341e-01f, -8.06740373e-02f, 1.17846727e-01f, 5.43571338e-02f, 8.32474083e-02f, 1.23811781e-01f, 2.53316425e-02f, 9.49805453e-02f,
  -4.68069911e-02f, -1.18558660e-01f, -7.75549859e-02f, -3.33257243e-02f, -4.34837714e-02f, -2.13948525e-02f, 9.58626643e-02f, 1.66151062e-01f, 2.37059630e-02f, -5.41364066e-02f,
  4.65152711e-02f, 1.35292951e-02f, 6.52925968e-02f, 8.44996125e-02f, -3.69696133e-02f, 2.07428485e-02f, 2.01028213e-02f, 1.94402970e-02f, -8.90971273e-02f, -3.74315903e-02f,
  -8.37366506e-02f, 5.07324794e-03f, -4.28150361e-03f, 6.86330572e-02f, -2.46648602e-02f, -1.05699096e-02f, 7.63300583e-02f, 1.23730097e-02f, -9.48670357e-02f, 2.27338653e-02f,
  5.57943657e-02f, 1.10762246e-01f, -2.23619640e-02f, -2.94844396e-02f, -1.02741197e-01f, 4.74089645e-02f, -3.03595811e-02f, -4.05057706e-02f, 8.30969773e-04f, -3.62389982e-02f,
  -5.78840002e-02f, 4.61357757e-02f, -2.78733671e-03f, -1.26186553e-02f, 2.68852711e-02f, -4.42547835e-02f, 6.98524266e-02f, -5.56063727e-02f, -3.09647936e-02f, -4.69811670e-02f,
  4.74826805e-02f, -3.54941227e-02f, 6.23736046e-02f, 6.78572431e-02f, 6.43641204e-02f, 1.75382439e-02f, -4.75802198e-02f, -2.30795164e-02f, 6.16454706e-02f, 7.53124356e-02f,
  -2.21142933e-01f, -3.14591765e-01f, 6.98880255e-02f, -2.26020589e-02f, -1.99794453e-02f, -5.99087141e-02f, 2.87463330e-02f, -1.41411975e-01f, -1.18131548e-01f, 2.45437119e-02f,
  -3.89070772e-02f, 1.03740282e-01f, -6.88554719e-02f, -6.52346062e-03f, 8.64908192e-03f, -1.88387055e-02f, -2.02713814e-03f, -5.50587848e-02f, 1.84426848e-02f, -1.45141304e-01f,
  3.85738816e-03f, 4.42986824e-02f, 3.01732551e-02f, 1.20754084e-02f, -2.23815860e-03f, -1.24121802e-02f, 1.40822111e-02f, -6.92939460e-02f, 2.95857210e-02f, 4.33879830e-02f,
  3.69489700e-01f, -3.41469198e-01f, 1.06481671e-01f, 2.08886653e-01f, 4.50727761e-01f, 3.14101607e-01f, 5.59839532e-02f, 2.60633051e-01f, 4.46829647e-01f, -2.73217291e-01f,
  7.04957172e-02f, -2.90209353e-01f, -3.23320240e-01f, -3.48026715e-02f, 2.66396571e-02f, -1.90666571e-01f, 2.19476819e-01f, -9.79388431e-02f, 1.10318258e-01f, -7.15119541e-02f,
  -1.73195321e-02f, 6.34095818e-02f, -1.45015329e-01f, -1.02584772e-01f, 1.08757876e-01f, 3.56405266e-02f, 2.30986904e-02f, -4.32232209e-02f, 2.89522633e-02f, -4.49825674e-02f,
  1.19788677e-01f, -7.96544272e-03f, -5.32681383e-02f, -1.95582002e-01f, -9.79450941e-02f, -9.07600019e-03f, 1.52492020e-02f, -1.42435670e-01f, -1.31960496e-01f, 2.63895206e-02f,
  -1.94959790e-01f, -5.40353134e-02f, 4.66425568e-02f, 6.99058771e-02f, 8.21394697e-02f, -5.56378858e-03f, -2.53611226e-02f, 2.33367104e-02f, -7.35908598e-02f, -2.54745632e-02f,
  -1.60491150e-02f, -7.96239972e-02f, -3.31802405e-02f, -4.82532382e-02f, -1.16554730e-01f, 5.88700958e-02f, 3.21335308e-02f, -6.59618061e-03f, 2.97294073e-02f, 2.33237036e-02f,
  -1.25452960e-02f, -2.93348841e-02f, 6.54932857e-02f, -2.66284570e-02f, 3.32563855e-02f, 9.86982360e-02f, -2.14257538e-02f, -3.91945662e-03f, 4.83836792e-02f, -4.01038444e-03f,
  1.09747313e-01f, 2.45087054e-02f, 3.22385170e-02f, -6.61225766e-02f, -6.56166300e-02f, 6.72916695e-02f, -5.38209155e-02f, 2.82349568e-02f, -7.43094310e-02f, -3.68850343e-02f,
  1.22719251e-01f, 4.24526446e-02f, -1.13398723e-01f, 3.41008753e-02f, -2.81238854e-02f, -3.29322703e-02f, 3.81679088e-02f, 6.15773536e-02f, -9.22423899e-02f, -5.28043620e-02f,
  -2.07959324e-01f, -7.61711523e-02f, -1.49194121e-01f, -1.00175239e-01f, -5.93891591e-02f, -9.18725729e-02f, 6.01239130e-02f, 2.28200462e-02f, -1.31892607e-01f, 1.67936515e-02f,
  -4.48283702e-02f, 9.04338285e-02f, -4.93573882e-02f, -1.36745465e-03f, -9.01765451e-02f, 6.47544116e-02f, -9.16206688e-02f, -9.74695981e-02f, -4.58374880e-02f, -2.82597188e-02f,
  1.42030567e-02f, -2.82520056e-02f, -2.04493888e-02f, 6.26745373e-02f, 2.73697544e-02f, -7.48075219e-03f, -1.20373070e-01f, 6.39214218e-02f, 6.27987683e-02f, -5.51462583e-02f,
  5.29502511e-01f, 2.68055648e-01f, 3.37346286e-01f, 5.11902153e-01f, -2.14911122e-02f, -7.69527676e-03f, 8.17136616e-02f, 1.77220598e-01f, 4.08500522e-01f, -1.72375571e-02f,
  -2.02233583e-01f, 2.17309654e-01f, -1.17857657e-01f, 1.71255574e-01f, -8.30071121e-02f, -1.63651332e-01f, 2.60895174e-02f, 1.19377010e-01f, 1.96935505e-01f, 2.60580480e-01f,
  2.03537852e-01f, -1.92626789e-01f, -2.59664860e-02f, -2.72692144e-01f, 1.36612922e-01f, 1.42588183e-01f, -2.94638842e-01f, -8.44036937e-02f, -1.60620242e-01f, -2.15822726e-01f,
  -7.69100040e-02f, 7.90916085e-02f, 1.11652836e-01f, 5.38165532e-02f, 5.75367175e-02f, -2.55751777e-02f, -1.48291990e-01f, -1.34376690e-01f, 1.29778132e-01f, -4.78395820e-02f,
  7.60251805e-02f, -3.02308705e-02f, 1.34337479e-02f, 2.13641301e-02f, 6.32259548e-02f, 1.06084220e-01f, 3.74615379e-02f, 1.88725725e-01f, -9.15629603e-03f, 5.35397418e-02f,
  9.31760445e-02f, 6.61055818e-02f, 8.28913525e-02f, -1.05655879e-01f, 6.46307468e-02f, -6.64379448e-03f, 7.93217123e-03f, 3.60292643e-02f, -6.13840856e-03f, 1.02417096e-02f,
  1.78982969e-02f, 5.27755804e-02f, -1.21161602e-02f, 3.85109745e-02f, -1.64062791e-02f, -3.17462324e-03f, 3.28024216e-02f, -1.08629815e-01f, -2.09959690e-03f, 9.67040285e-03f,
  2.82863341e-02f, -3.48260952e-03f, 9.48621258e-02f, 8.43051746e-02f, 1.91219859e-02f, 2.96227224e-02f, 1.15053486e-02f, -6.01712964e-04f, 1.17277168e-01f, 2.24826355e-02f,
  -2.05034185e-02f, -1.57891102e-02f, 2.63478737e-02f, -8.13219994e-02f, -5.88078005e-03f, -1.11756092e-02f, 3.01670320e-02f, 2.74603665e-02f, 2.92005707e-02f, 1.42059894e-02f,
  -1.32935897e-01f, 5.53223342e-02f, 6.32762015e-02f, 1.13663897e-02f, -1.89467780e-02f, 7.00856978e-03f, -2.62389183e-02f, 1.82443615e-02f, -3.66775841e-02f, -4.99636978e-02f,
  -1.00810230e-02f, -4.46249470e-02f, 2.87726577e-02f, -5.25131077e-02f, -1.15163093e-02f, -6.37019128e-02f, 1.80139206e-02f, -2.65455469e-02f, -1.74747463e-02f, 3.37472046e-03f,
  8.47246218e-03f, 2.06283033e-02f, 3.89443897e-02f, 2.09355522e-02f, 9.28881299e-03f, -9.39163566e-02f, 2.13349387e-02f, 6.51969090e-02f, -8.31134394e-02f, 2.04387624e-02f,
  2.51251370e-01f, 2.72026956e-01f, 1.55438632e-01f, 2.19869047e-01f, -1.74719065e-01f, 3.64371985e-02f, 5.38056791e-02f, -1.43157437e-01f, 2.89534599e-01f, -1.97542831e-02f,
  -2.28982016e-01f, 5.08099318e-01f, -1.17939554e-01f, 9.42884460e-02f, -3.43834549e-01f, -1.09357364e-01f, 5.30435853e-02f, 2.17700511e-01f, 7.81620294e-03f, -3.53158303e-02f,
  -8.73671025e-02f, -2.02255443e-01f, -2.32644081e-01f, -1.30071074e-01f, 7.49079958e-02f, 8.63525793e-02f, -2.98223138e-01f, -8.52008760e-02f, 7.70749450e-02f, -5.41511104e-02f,
  -1.12669013e-01f, -5.39880954e-02f, 9.64486524e-02f, -2.44317241e-02f, -1.32209659e-01f, 1.33292843e-02f, -9.41823702e-04f, -3.50010134e-02f, -1.24419428e-01f, -1.92674939e-02f,
  9.84297320e-02f, 2.00452600e-02f, 3.03339344e-02f, 3.07619255e-02f, 4.12344635e-02f, 1.04119509e-01f, -9.69238859e-03f, -2.15768721e-02f, 3.73187698e-02f, 2.92364450e-04f,
  8.89564902e-02f, -1.75447427e-02f, -1.81047991e-02f, 8.49126931e-03f, -4.20498699e-02f, 2.99476124e-02f, 1.74981561e-02f, -4.59388383e-02f, 8.92683566e-02f, 4.97729592e-02f,
  -5.62782325e-02f, -7.84660429e-02f, -7.88906291e-02f, 1.24814296e-02f, -2.88914610e-02f, -4.20044363e-02f, 1.61040202e-02f, -3.82298082e-02f, -3.16536091e-02f, -5.95235601e-02f,
  -2.85476111e-02f, 3.54210250e-02f, -4.19948250e-02f, 1.52629754e-02f, 6.60268143e-02f, 3.99427302e-02f, -7.18555301e-02f, -8.21793899e-02f, 3.82580422e-02f, -8.09475482e-02f,
  2.34041382e-02f, 3.42177786e-02f, 1.34611353e-01f, -3.13842040e-03f, 9.18976031e-03f, -3.47172208e-02f, 2.95770988e-02f, 8.51895213e-02f, 2.93878280e-02f, -3.36493291e-02f,
  -4.59236391e-02f, 1.26635348e-02f, 4.56803106e-02f, -7.90652167e-03f, -2.76674982e-02f, 2.45165657e-02f, -1.78143475e-02f, 3.43249328e-02f, 1.81587748e-02f, -2.91128494e-02f,
  2.35885512e-02f, 3.05746011e-02f, -3.01449820e-02f, -6.90426007e-02f, 1.55715095e-02f, -6.84000477e-02f, 1.25066806e-02f, -7.60937110e-02f, 3.33208987e-03f, -6.14888668e-02f,
  -2.22178493e-02f, -1.21604409e-02f, -4.52827103e-02f, -8.35414752e-02f, -5.78021333e-02f, -1.05380907e-03f, 1.14539839e-01f, 3.08318194e-02f, -4.92262617e-02f, -3.23623270e-02f,
  -6.47188962e-01f, 1.67441636e-01f, -7.79291317e-02f, 1.30230501e-01f, -2.20848143e-01f, -1.30215287e-01f, 1.04498796e-01f, -1.22160986e-02f, 7.06597343e-02f, 2.63449579e-01f,
  1.20614514e-01f, 1.41272694e-02f, 4.46155407e-02f, 1.80289522e-01f, -4.88873363e-01f, -1.52299218e-02f, -1.21917427e-01f, -8.51118863e-02f, -4.92285006e-02f, -7.69387260e-02f,
  -1.83127820e-01f, -1.78805590e-02f, -5.65714203e-02f, 4.75795716e-02f, -1.31888598e-01f, -5.35094067e-02f, -1.73698202e-01f, -6.34198859e-02f, 1.22036785e-02f, -1.40356079e-01f,
  -3.07637542e-01f, -1.68797765e-02f, -6.12172717e-03f, -1.47456929e-01f, -7.67531544e-02f, -1.61559686e-01f, 2.60549169e-02f, 2.41479259e-02f, -2.13802587e-02f, -4.75396141e-02f,
  -1.04162626e-01f, 3.63504291e-02f, 7.33341277e-02f, 6.60081208e-02f, -5.68366796e-02f, 3.84905525e-02f, -9.02357278e-04f, 2.97579058e-02f, 2.54382696e-02f, -8.18737447e-02f,
  -1.57584287e-02f, 1.31469555e-02f, -2.13720072e-02f, -6.63011745e-02f, -6.57089474e-03f, 6.49890155e-02f, 1.02445535e-01f, -6.64937645e-02f, 7.85437003e-02f, -2.26233546e-02f,
  -7.18448311e-02f, -6.56010360e-02f, -5.43204024e-02f, 7.72572234e-02f, 9.48614180e-02f, 2.82865111e-02f, 7.23851891e-03f, -4.03585322e-02f, 5.42113371e-02f, -4.48469967e-02f,
  6.36320412e-02f, 1.07540591e-02f, -3.66637446e-02f, -4.43178369e-03f, -2.71669421e-02f, 4.43738960e-02f, -1.24989701e-02f, -3.04142246e-03f, -1.06716668e-02f, -3.00473068e-02f,
  2.02471577e-02f, 3.40540446e-02f, 2.48086117e-02f, 3.17625515e-02f, -3.59484516e-02f, -4.38495390e-02f, 4.92013991e-03f, -9.16522294e-02f, -4.51259129e-03f, 8.68220255e-03f,
  -3.77744973e-01f, -1.94152266e-01f, -1.01393588e-01f, 8.54980014e-03f, -7.98047986e-03f, -1.07152939e-01f, -6.81518018e-02f, -1.49179325e-01f, -2.61399541e-02f, -1.84617750e-02f,
  3.02196667e-03f, 2.59152078e-03f, -2.89671309e-02f, 7.74749368e-02f, 7.76445344e-02f, -5.59243225e-02f, -3.12064253e-02f, -3.92014906e-02f, -6.14883527e-02f, -9.46125910e-02f,
  2.40976810e-02f, -1.19819075e-01f, 3.28976735e-02f, 4.52785678e-02f, 5.32738455e-02f, -5.28277382e-02f, -8.60409290e-02f, 4.15810049e-02f, -5.16164228e-02f, -2.31691115e-02f,
  -2.91633010e-01f, 5.78021817e-03f, -1.31634250e-01f, -2.52108514e-01f, 2.79009402e-01f, -2.54245829e-02f, -1.15660533e-01f, 9.59246010e-02f, -4.37372774e-02f, 2.34509706e-01f,
  2.02528223e-01f, -1.79880396e-01f, 1.04200773e-01f, -3.49867314e-01f, -4.19516623e-01f, -2.99041241e-01f, -3.42814177e-01f, -1.45426914e-01f, -1.63350701e-01f, -1.91615410e-02f,
  -2.07074806e-01f, 1.24501921e-02f, -3.08294266e-01f, 1.76988140e-01f, 2.47576218e-02f, 7.00534880e-02f, 1.36958882e-01f, 1.51810050e-01f, -3.57958600e-02f, 4.22567688e-02f,
  -9.10004303e-02f, 8.26394781e-02f, 6.49030805e-02f, 2.84338389e-02f, 3.25905606e-02f, 9.62331332e-03f, 1.70927569e-02f, 5.32589629e-02f, -3.82298790e-02f, -2.86134444e-02f,
  2.89936103e-02f, -5.95597739e-05f, -3.36644007e-03f, 2.00720504e-02f, 3.82902846e-02f, -7.45617300e-02f, -5.87188266e-02f, 6.01902716e-02f, -1.90436002e-02f, -6.68883994e-02f,
  -4.90364879e-02f, 3.31803411e-02f, -1.82527602e-02f, 2.73399008e-03f, -8.85022134e-02f, 1.00031257e-01f, -8.80308300e-02f, 4.35042605e-02f, 2.79626921e-02f, -5.32039441e-02f,
  -1.61261745e-02f, 2.28834338e-02f, 1.87087208e-02f, 2.32104436e-02f, -1.82112493e-02f, 6.44561350e-02f, -4.31813784e-02f, -9.81454831e-03f, -5.01701646e-02f, 3.78651135e-02f,
  7.58658871e-02f, 7.18694702e-02f, 8.17780793e-02f, -4.99919406e-04f, -8.77294242e-02f, 4.46560979e-03f, 3.01149045e-03f, 6.19148053e-02f, -6.16843328e-02f, 4.35772091e-02f,
  1.54156268e-01f, 5.59955016e-02f, 2.99659222e-02f, 4.01716046e-02f, 8.95156898e-03f, 1.78522877e-02f, 1.18904384e-02f, -1.52967200e-02f, -2.42714696e-02f, -6.96468959e-03f,
  3.99396755e-02f, 1.34877324e-01f, -1.51935555e-02f, -6.84884982e-03f, -2.14214213e-02f, 3.18549871e-02f, -5.34506589e-02f, 4.31017112e-03f, 5.60713606e-03f, 3.04718111e-02f,
  3.06711141e-02f, -1.12214327e-01f, 9.32424814e-02f, -8.42048898e-02f, -2.36497335e-02f, -6.99246004e-02f, 1.30899489e-01f, 2.10672654e-02f, 3.87851223e-02f, -2.17893207e-03f,
  1.93573516e-02f, 9.09331888e-02f, -9.57913771e-02f, -6.16857484e-02f, 9.07852352e-02f, 5.11757508e-02f, 6.66777343e-02f, 3.04766726e-02f, 4.05919328e-02f, -2.57884897e-02f,
  2.87053119e-02f, -4.78879362e-02f, 1.96808442e-01f, -2.54220843e-01f, -6.73937798e-02f, -5.34229986e-02f, -1.27861366e-01f, -2.33990967e-01f, 4.62531969e-02f, -1.10058211e-01f,
  -4.98380139e-02f, 4.26081233e-02f, 2.53193945e-01f, -1.22353114e-01f, 3.25908393e-01f, 1.15385987e-01f, -2.53417432e-01f, -8.24956521e-02f, 2.95719597e-02f, -1.44878656e-01f,
  -5.29920608e-02f, -2.19663382e-01f, -6.37382688e-03f, -2.36061811e-01f, -1.62293538e-01f, -1.77357972e-01f, -5.87617680e-02f, 9.76322070e-02f, -1.42832622e-01f, 2.07267981e-02f,
  -2.24024028e-01f, -5.45368567e-02f, -7.33499527e-02f, -1.03864014e-01f, -8.09170231e-02f, -3.30464616e-02f, -1.42062277e-01f, 9.26738307e-02f, -4.43446524e-02f, -2.82003125e-03f,
  5.89045584e-02f, -1.21975373e-02f, -4.40364815e-02f, 5.18773757e-02f, -1.10261627e-01f, -2.43346673e-02f, 2.68604774e-02f, -2.90732551e-02f, -9.97758880e-02f, 3.14878598e-02f,
  9.96169895e-02f, 1.56354055e-01f, -5.19848317e-02f, 5.01318909e-02f, 2.83452105e-02f, 7.42709916e-03f, 1.59107950e-02f, 1.47345409e-01f, 5.59777804e-02f, -3.44021507e-02f,
  -7.36865029e-02f, 7.57032214e-03f, 1.13806784e-01f, -8.55442658e-02f, 3.58745307e-02f, -5.32527408e-03f, 3.57135944e-02f, -9.26554799e-02f, -6.12245575e-02f, -1.29806707e-02f,
  4.04591486e-02f, -6.53184131e-02f, 1.20482491e-02f, 1.97062790e-02f, -1.09822661e-01f, -6.15186170e-02f, -1.67030317e-03f, 9.86266807e-02f, 4.43222076e-02f, -1.21379189e-01f,
  5.22948317e-02f, 7.82562792e-03f, -5.91879524e-02f, 6.11695163e-02f, 6.79227710e-02f, 5.87487854e-02f, -1.20323962e-02f, 3.63314152e-02f, 6.13593543e-03f, 1.58213913e-01f,
  -1.71294034e-01f, -2.61936039e-01f, -1.46841541e-01f, -6.21014759e-02f, 5.88759258e-02f, -2.87821367e-02f, 4.56619039e-02f, -9.36857685e-02f, -9.07172784e-02f, -3.69220227e-02f,
  -1.06172353e-01f, -3.74145284e-02f, -6.47095740e-02f, -1.12144820e-01f, -7.16599682e-03f, 2.66026910e-02f, -9.86462459e-02f, -3.04713957e-02f, -5.03150560e-02f, -3.51909176e-02f,
  -6.38919324e-02f, -3.07907420e-03f, 1.24404579e-01f, -1.61108956e-01f, -7.38220066e-02f, -4.48832028e-02f, 4.49479073e-02f, 3.08727231e-02f, 1.58016011e-02f, 3.80941480e-03f,
  -2.17024803e-01f, 3.53273571e-01f, -2.90994287e-01f, 1.26921367e-02f, -2.01421499e-01f, 3.55171353e-01f, 2.74234027e-01f, -1.04211152e-01f, 8.48868191e-02f, 3.03522289e-01f,
  1.27479717e-01f, 1.69904083e-02f, 1.36235014e-01f, 3.45793843e-01f, -7.82058388e-03f, 2.39923924e-01f, 2.69596040e-01f, 2.67199337e-01f, -5.28650619e-02f, 3.87678072e-02f,
  -7.09902635e-03f, 1.89326242e-01f, -4.58241887e-02f, -1.53437212e-01f, -1.09191805e-01f, -1.69184059e-01f, -7.43582994e-02f, -2.65655071e-01f, 4.33136272e-04f, 1.46016162e-02f,
  -2.05679722e-02f, -1.12398542e-01f, -9.17973295e-02f, -9.20422003e-02f, -2.38491707e-02f, -4.82131727e-02f, -9.63570327e-02f, -6.88217655e-02f, -6.15946092e-02f, -2.33095163e-03f,
  5.25230600e-04f, -6.67173043e-02f, 3.18227001e-02f, -7.09421784e-02f, 9.10148397e-03f, -2.76891124e-02f, -2.32295133e-02f, 1.73622370e-02f, -7.68261449e-03f, 2.99035516e-02f,
  8.58780816e-02f, -7.02626631e-02f, 7.59153068e-02f, 7.34562799e-02f, -3.00027756e-03f, 8.73840377e-02f, 5.17729856e-02f, -2.29782946e-02f, -4.34129164e-02f, 6.39835522e-02f,
  5.65254353e-02f, -8.45133960e-02f, -1.24011543e-02f, -3.62750776e-02f, 1.02431215e-02f, -3.39383036e-02f, 1.37816099e-02f, -7.04378933e-02f, 9.72416904e-03f, 5.72875701e-02f,
  2.96721011e-02f, -6.62747910e-03f, 3.83372768e-03f, 5.64544760e-02f, -2.75927521e-02f, 4.16155793e-02f, -4.79439162e-02f, -2.46733055e-02f, -1.27699008e-04f, -1.27834827e-02f,
  -2.69321748e-03f, 9.46120694e-02f, 3.13535556e-02f, 2.25886237e-02f, 4.02079001e-02f, -4.25461642e-02f, 1.01322886e-02f, 3.87562322e-03f, 2.35320274e-02f, -8.11380073e-02f,
  2.41409868e-01f, -1.79556594e-03f, 1.33309960e-02f, 9.24248621e-03f, 3.98784094e-02f, 3.56838480e-03f, 5.26941568e-02f, 3.57057862e-02f, 3.24007459e-02f, -2.01056246e-02f,
  -1.68712866e-02f, -7.63382483e-03f, 7.05121160e-02f, -4.44910936e-02f, 1.97951738e-02f, 2.74108816e-02f, -7.20140291e-03f, 6.21809587e-02f, 2.31747199e-02f, -5.65668643e-02f,
  -8.79505575e-02f, 1.60014015e-02f, 2.36908477e-02f, -8.18589982e-03f, -5.60727110e-03f, -6.49466459e-03f, 1.61659382e-02f, -3.73673141e-02f, 5.88144399e-02f, 4.96674813e-02f,
  4.96891029e-02f, -1.20585717e-01f, 8.84835869e-02f, -2.53065694e-02f, 7.68676251e-02f, -2.67553516e-02f, 1.87622130e-01f, -2.42957354e-01f, -1.10750824e-01f, -2.44197652e-01f,
  3.18361484e-02f, 1.30056992e-01f, 1.28816769e-01f, -1.83583915e-01f, 2.50179678e-01f, 1.55833125e-01f, -1.94792375e-01f, -2.39354763e-02f, 6.74213916e-02f, 1.89748090e-02f,
  -7.30159432e-02f, -1.66318685e-01f, 1.07599162e-01f, -2.56546825e-01f, -1.31748542e-01f, -4.75679748e-02f, 4.78034578e-02f, 4.38204780e-02f, -1.56108543e-01f, 1.21861011e-01f,
  -1.73744231e-01f, -5.63127846e-02f, 8.64358321e-02f, -8.75124037e-02f, -8.50752071e-02f, 1.02758957e-02f, 1.25570059e-01f, 9.98299271e-02f, 1.20325133e-01f, -1.18057787e-01f,
  4.49346984e-03f, -9.43207815e-02f, -4.14933935e-02f, -2.80265585e-02f, 7.81817660e-02f, -2.50954069e-02f, 8.06096185e-04f, 3.25886197e-02f, -1.40527403e-03f, 5.53264515e-03f,
  5.96061768e-03f, -4.17126529e-02f, 5.45976087e-02f, -3.80488560e-02f, 8.13960209e-02f, -2.84618214e-02f, 9.72427651e-02f, 6.22171015e-02f, -3.57703492e-02f, -9.49229393e-03f,
  9.27933753e-02f, 4.93017994e-02f, -4.82467376e-02f, -3.92330997e-02f, -8.39427710e-02f, -7.81719387e-02f, -4.83810483e-03f, 3.02390307e-02f, -1.37889013e-03f, -6.78007975e-02f,
  -5.96981607e-02f, 2.60547549e-02f, -4.07051146e-02f, -2.51016188e-02f, 7.00302422e-03f, -4.53546457e-02f, 5.66581264e-03f, -6.13216087e-02f, -7.29204342e-02f, 2.09048428e-02f,
  8.30033571e-02f, 1.12983562e-01f, -2.91651804e-02f, 4.94565209e-03f, -7.07769617e-02f, -7.55677000e-03f, 2.12763865e-02f, 2.13905443e-02f, 3.11010405e-02f, 1.42870983e-02f,
  -3.09996784e-01f, -2.37038493e-01f, 9.54048126e-04f, -2.11979784e-02f, -1.20353527e-01f, 8.98837894e-02f, 1.70332771e-02f, 4.91014756e-02f, -4.66909967e-02f, 4.70858365e-02f,
  -2.35101841e-02f, -9.88611132e-02f, 5.77695817e-02f, 4.97496612e-02f, 5.85560203e-02f, 8.67668539e-04f, 9.01018083e-02f, 3.24355736e-02f, 5.98083436e-02f, -3.67075601e-03f,
  -9.78744328e-02f, -3.95006239e-02f, -1.18965805e-02f, -8.72240886e-02f, 3.91171537e-02f, 3.52466144e-02f, -7.12410361e-02f, -8.71692598e-03f, 6.53201714e-02f, -1.89983323e-02f,
  -1.42298624e-01f, 1.47082239e-01f, -1.27622589e-01f, -2.79135376e-01f, 3.51311266e-03f, -4.02700067e-01f, -3.26147288e-01f, -8.10259059e-02f, 7.03808367e-02f, -1.95419401e-01f,
  -1.87562153e-01f, 7.56456256e-02f, 1.12529464e-01f, -1.15627833e-01f, -1.59116223e-01f, 1.50799155e-01f, -1.78385407e-01f, -2.55429715e-01f, 2.41422191e-01f, -2.67397791e-01f,
  -8.89847726e-02f, -3.20869498e-02f, -1.75332621e-01f, 2.90145651e-02f, -1.63142979e-01f, 7.63740251e-03f, -3.75826061e-02f, -4.89571579e-02f, -1.43968433e-01f, 9.94920209e-02f,
  -9.13317502e-02f, -9.43979770e-02f, 6.54281117e-03f, -1.68934762e-01f, -1.75539389e-01f, -1.03051938e-01f, -1.88247100e-01f, 5.58675155e-02f, -2.77034361e-02f, -4.87042367e-02f,
  1.41911693e-02f, 5.26130684e-02f, 5.89138940e-02f, 1.04291067e-01f, -1.08073764e-01f, 7.69601241e-02f, 3.52045633e-02f, -1.02757789e-01f, -3.66918370e-02f, 2.54017580e-02f,
  5.30081168e-02f, -1.31593734e-01f, -2.06728160e-01f, -8.60883147e-02f, -4.42418270e-02f, -5.83045930e-02f, -1.00023359e-01f, 5.48734777e-02f, -1.52448058e-01f, 7.76335690e-03f,
  -3.80955487e-02f, 3.19324732e-02f, -2.01050453e-02f, 4.96040545e-02f, 4.40575220e-02f, 1.07597038e-01f, -1.12222219e-02f, -5.00248224e-02f, -3.68950106e-02f, -5.62869683e-02f,
  -4.99633700e-02f, -3.41357291e-02f, 3.33785824e-02f, -1.08621150e-01f, -7.18243122e-02f, -1.08042816e-02f, 1.83452107e-02f, -5.44669153e-03f, -3.66746970e-02f, -9.52809229e-02f,
  -2.01596394e-02f, -2.72740927e-02f, 2.41709687e-03f, -5.74270301e-02f, -3.97752076e-02f, 8.56545940e-02f, -2.38692146e-02f, -5.95620796e-02f, 7.83909634e-02f, -2.00883504e-02f,
  -1.50781265e-02f, -2.27420405e-01f, 4.80436906e-02f, -3.48416492e-02f, 8.32540691e-02f, -2.40867864e-02f, -2.02680081e-02f, -1.29861115e-02f, -1.05706699e-01f, -9.05082449e-02f,
  -1.50079846e-01f, -5.56241646e-02f, -7.79858008e-02f, 3.83232255e-03f, 3.98223549e-02f, 1.32417567e-02f, -3.86712849e-02f, -3.67031284e-02f, -2.02235773e-01f, 1.35249002e-02f,
  -5.52009530e-02f, 1.53903244e-02f, 9.38013121e-02f, -9.74212736e-02f, -9.48321149e-02f, -6.21696860e-02f, 1.60047859e-02f, 1.34689100e-02f, -3.43199186e-02f, 1.69898923e-02f,
  -1.78989351e-01f, -8.09048638e-02f, 5.25629699e-01f, -2.04725847e-01f, 3.03387403e-01f, 2.48346657e-01f, 3.03508461e-01f, 1.78566828e-01f, -2.38267761e-02f, -1.78449452e-01f,
  -1.63280413e-01f, -1.67028382e-01f, 3.15446794e-01f, -1.27606079e-01f, 2.45815128e-01f, 8.39844942e-02f, -1.86158828e-02f, -7.02224970e-02f, 5.62062301e-02f, -1.05799079e-01f,
  -1.40986117e-02f, -1.64845988e-01f, 2.17759326e-01f, -4.67898883e-02f, 2.64616013e-02f, -2.06005782e-01f, -2.48951718e-01f, 1.86202511e-01f, -1.70574188e-01f, 2.90976036e-02f,
  -1.57856822e-01f, -2.52430439e-01f, -1.54304772e-03f, -2.75605135e-02f, 8.62820894e-02f, -2.65217908e-02f, -9.63708013e-02f, 9.09051001e-02f, -3.73209603e-02f, 2.40058340e-02f,
  4.82485741e-02f, 3.55680734e-02f, -5.28056957e-02f, -3.70009579e-02f, -1.79371461e-02f, 1.77441607e-03f, -6.22106856e-03f, 1.39741031e-02f, 8.84017572e-02f, 1.26971245e-01f,
  1.20189048e-01f, -4.23467718e-02f, 5.21655716e-02f, -1.39855489e-01f, 2.28047743e-02f, -7.94725679e-03f, -7.53043965e-02f, 6.79090619e-02f, -5.85458893e-03f, -8.90835971e-02f,
  -1.53426947e-02f, -4.68278974e-02f, -1.11414023e-01f, 5.98759158e-03f, 2.56574042e-02f, -8.59112367e-02f, -9.19631962e-03f, -8.54681153e-03f, -3.51099446e-02f, 3.99578623e-02f,
  1.45396320e-02f, 3.89424488e-02f, -4.72256988e-02f, 8.92279437e-04f, 1.99296745e-03f, -6.74382970e-02f, -1.03988918e-02f, -2.78280042e-02f, 9.72714217e-04f, -6.95166960e-02f,
  -3.93490680e-02f, 1.42628802e-02f, 2.20068172e-02f, -3.10468879e-02f, 7.64473341e-03f, 4.68875319e-02f, -1.27706788e-02f, 1.46417143e-02f, 2.50351662e-03f, 2.44599506e-02f,
  -2.16030329e-01f, -3.09506923e-01f, -8.72708634e-02f, -7.08118677e-02f, -9.64462310e-02f, -6.84562186e-03f, -4.41870801e-02f, 5.18199522e-03f, 4.47849110e-02f, 2.34653447e-02f,
  -1.78875104e-02f, -3.39611135e-02f, 3.06177214e-02f, -1.09071657e-02f, -1.26040522e-02f, -1.43748606e-02f, -9.10726041e-02f, -1.03896990e-01f, -1.28640041e-01f, 2.88919210e-02f,
  -2.63322704e-02f, -6.16025254e-02f, -1.77935045e-02f, -3.12471036e-02f, -1.60271034e-01f, 3.05351801e-02f, -4.56809886e-02f, -4.30600159e-02f, 2.03817431e-02f, 9.12589654e-02f,
  -3.50462571e-02f, 1.04263397e-02f, 1.04263388e-01f, -4.47175317e-02f, -9.96358022e-02f, 1.35146966e-02f, 1.21507756e-02f, -4.79891198e-03f, 3.28924179e-01f, 1.96741492e-01f,
  -3.08942460e-02f, 2.78777897e-01f, 8.88950154e-02f, -2.08507389e-01f, 1.81122497e-03f, -5.32231992e-03f, -1.80390656e-01f, 3.47216912e-02f, 7.44664073e-02f, -1.31447285e-01f,
  -8.35267007e-02f, -3.05023015e-01f, -1.94597229e-01f, -1.49621919e-01f, -3.00352573e-01f, 3.41520719e-02f, -2.19502851e-01f, -7.37654194e-02f, -1.53692123e-02f, 1.36258572e-01f,
  -3.71086933e-02f, 9.54708830e-02f, -1.22560799e-01f, 2.07387447e-01f, 8.27364177e-02f, 5.53446971e-02f, 9.70142253e-04f, 1.04331382e-01f, 3.44925448e-02f, 1.58589199e-01f,
  1.81464534e-02f, 1.46233593e-03f, -2.86669657e-02f, -4.33750451e-02f, 1.43539696e-03f, 3.07756793e-02f, -5.15213087e-02f, -4.27781641e-02f, 8.39513168e-02f, 8.87202844e-03f,
  -4.33503017e-02f, -3.89709882e-02f, -8.08138549e-02f, 1.22059792e-01f, 2.75473520e-02f, 1.01472773e-01f, -6.48882287e-03f, 4.48203683e-02f, -4.03363779e-02f, 7.74258450e-02f,
  -8.91821533e-02f, 1.12539325e-02f, 5.87064726e-03f, 5.04377484e-02f, 3.20895053e-02f, 5.62779186e-03f, -8.60761479e-02f, -8.45793262e-03f, 1.81812383e-02f, -1.31187290e-01f,
  -3.25290449e-02f, 5.03985249e-02f, -1.42380502e-02f, -1.29387066e-01f, -8.57388899e-02f, 3.61965857e-02f, 3.24602127e-02f, 1.00777410e-01f, -3.21832485e-02f, 1.05960451e-01f,
  7.67572820e-02f, 9.44645479e-02f, -2.24211700e-02f, -1.76941343e-02f, 8.79829079e-02f, -1.11900223e-02f, -8.02618917e-03f, 1.89106893e-02f, 5.40235974e-02f, -1.64456904e-01f,
  9.76076350e-02f, 2.27498695e-01f, 7.94977620e-02f, 1.35846168e-01f, 2.31444985e-02f, -6.78337738e-02f, -4.17267270e-02f, -5.34581505e-02f, 1.25833154e-01f, -5.19585200e-02f,
  -1.36783779e-01f, 1.20198257e-01f, -4.91374545e-03f, -9.68183428e-02f, -1.05699398e-01f, 7.25721866e-02f, 9.50604305e-02f, -5.94388321e-03f, -1.08898245e-02f, 1.78727452e-02f,
  -1.40320018e-01f, 5.38944565e-02f, -3.20238844e-02f, 2.82572117e-02f, -1.39935911e-01f, -1.04949050e-01f, -4.60269069e-03f, 5.74297085e-02f, -4.01346087e-02f, 3.85474041e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  2.93925971e-01f, 1.13918826e-01f, 1.99212536e-01f, 3.61049742e-01f, 1.54109254e-01f, 3.52536410e-01f, 2.65714347e-01f, -4.11554500e-02f, 3.17726110e-04f, 1.66586682e-01f,
  4.60602850e-01f, 1.50278658e-01f, 1.40425667e-01f, 5.84336482e-02f, 2.44476989e-01f, 1.24790251e-01f, 2.13637739e-01f, 2.73938905e-02f, 2.70610839e-01f, 1.31172121e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.07358673e-01f, 5.60696945e-02f, 1.04296245e-01f, 1.37752562e-04f, -2.37725869e-01f, -4.31170911e-02f, -1.44698694e-01f, 1.61895037e-01f, 1.43340424e-01f, 1.80544630e-01f,
  2.17722766e-02f, 3.38681340e-01f, 7.82586858e-02f, 1.23307154e-01f, 8.46493542e-02f, 1.03654422e-01f, 9.31960568e-02f, -9.51641873e-02f, 7.24383816e-02f, -2.59804249e-01f,
  -2.76142716e-01f, -2.34053969e-01f, -2.53847633e-02f, 2.70324349e-01f, -9.81075340e-04f, 2.74486899e-01f, -1.38527080e-01f, -1.01236500e-01f, -2.20635474e-01f, 2.98500489e-02f,
  -1.76030785e-01f, 6.79609403e-02f, -1.27052162e-02f, -1.05468117e-01f, -1.03160113e-01f, 1.78842455e-01f, 1.30884558e-01f, -5.14471903e-02f, 1.35606438e-01f, -2.84045875e-01f,
  -1.03942625e-01f, -3.10882572e-02f, -2.35672183e-02f, -1.32402226e-01f, 1.52720824e-01f, -1.08540706e-01f, 6.19750991e-02f, -1.97649270e-01f, -1.34747580e-01f, 8.36123154e-02f,
  -1.21310934e-01f, 1.65850282e-01f, 4.10177052e-01f, 1.52853176e-01f, -1.59465030e-01f, -3.90626341e-01f, -9.38119218e-02f, -1.70003399e-01f, 1.64418649e-02f, 2.07216009e-01f,
  7.11071864e-02f, -1.38671011e-01f, 2.96693921e-01f, -5.66400215e-02f, -6.42915964e-02f, 1.63390443e-01f, 8.43238831e-03f, -1.95312321e-01f, 1.76331818e-01f, -4.10035700e-02f,
  -5.37519529e-02f, 1.45795688e-01f, 5.12662483e-03f, -7.41668642e-02f, -2.77318829e-03f, 2.20699862e-01f, 2.58000214e-02f, -1.12653533e-02f, -2.09420621e-01f, -3.47662810e-03f,
  8.07391405e-02f, -2.05671072e-01f, 1.89578608e-01f, 6.43527806e-02f, 2.85175472e-01f, -1.79246083e-01f, -2.68460870e-01f, -3.00559223e-01f, 5.91314025e-02f, 2.90762573e-01f,
  2.12096721e-01f, -3.06332290e-01f, 1.78534955e-01f, 3.86502057e-01f, 1.84679464e-01f, 5.02372272e-02f, -1.79287136e-01f, -1.00929022e-01f, 8.12509209e-02f, 5.53236865e-02f,
  -2.46278215e-02f, 1.72779784e-01f, 1.91760913e-01f, -6.43997267e-02f, 3.26319076e-02f, -1.60501719e-01f, -3.05713266e-01f, -5.05365320e-02f, -6.33487403e-02f, -1.43180817e-01f,
  7.84969479e-02f, 1.14232615e-01f, 2.72826731e-01f, -1.36191025e-01f, -2.05460843e-02f, -1.95291951e-01f, -1.50911495e-01f, -1.19748704e-01f, -2.32961282e-01f, -1.06440507e-01f,
  -3.01876143e-02f, 3.60647477e-02f, 1.41851231e-01f, 8.51068422e-02f, 1.99452251e-01f, 3.50126505e-01f, -1.43798724e-01f, 1.82259947e-01f, 2.31879964e-01f, 1.52578503e-01f,
  -7.55585060e-02f, 3.48718017e-01f, -9.44031924e-02f, 4.05415475e-01f, 3.48964073e-02f, -1.72530815e-01f, 4.52156961e-01f, -1.41337439e-01f, 4.10488918e-02f, 3.31256515e-03f,
  2.39061043e-01f, 2.75595814e-01f, 2.58096248e-01f, -2.01980192e-02f, 1.33197710e-01f, 1.20251775e-01f, -1.95028350e-01f, -1.39704436e-01f, -1.32761806e-01f, -4.84674871e-02f,
  -9.74130407e-02f, 5.32694906e-02f, 1.78014725e-01f, 4.44538921e-01f, -1.66110352e-01f, 5.04152849e-02f, -1.20898515e-01f, -1.70765415e-01f, -7.65118077e-02f, 6.99835643e-02f,
  2.34380495e-02f, 1.75049767e-01f, 6.65049329e-02f, -3.57536823e-01f, 2.11424083e-01f, -6.19659536e-02f, 1.06019743e-01f, 3.38660210e-01f, -2.24353373e-02f, 7.67715126e-02f,
  2.09886562e-02f, -6.59554750e-02f, -1.57515377e-01f, -4.75879908e-02f, -2.60367364e-01f, 2.94594392e-02f, -1.89729612e-02f, -8.82505774e-02f, 4.79021892e-02f, -1.86259761e-01f,
  1.79608524e-01f, -1.07417330e-01f, 8.14919546e-02f, 1.63814053e-01f, -1.27788976e-01f, -1.20747343e-01f, 2.07278892e-01f, -2.44815856e-01f, 2.51402766e-01f, 1.35338649e-01f,
  -1.73890870e-02f, 3.29550356e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.99448720e-01f, 2.64552504e-01f, 4.10348684e-01f, -4.00496796e-02f, 3.79886836e-01f, -3.24019939e-02f, -4.72964644e-02f, -3.58007327e-02f, -1.98144987e-01f, -3.60100091e-01f,
  -2.25364804e-01f, -3.24534953e-01f, 4.17676792e-02f, -1.11928523e-01f, 1.53248951e-01f, 2.65014201e-01f, -1.24265216e-01f, 2.44154721e-01f, -6.15686961e-02f, 9.90126207e-02f,
  3.41528058e-01f, 4.17932928e-01f, 4.73125398e-01f, -6.72091097e-02f, -1.05924234e-01f, -2.11801752e-01f, 2.98012912e-01f, 1.75496042e-01f, 2.84337290e-02f, -1.66199043e-01f,
  3.83972138e-01f, 1.27415478e-01f, -3.44615690e-02f, -5.76107912e-02f, 1.98366463e-01f, 4.09811854e-01f, -5.55724166e-02f, 2.92722523e-01f, 3.44891429e-01f, -2.84097970e-01f,
  3.94436508e-01f, -1.00623265e-01f, 2.53777623e-01f, 1.74408183e-02f, 4.24417406e-01f, 2.84252524e-01f, 2.70229965e-01f, -1.46394536e-01f, 2.31155425e-01f, 2.50238955e-01f,
  5.37618659e-02f, 5.74572124e-02f, -3.70014369e-01f, -7.78260902e-02f, -1.88087285e-01f, 8.33308697e-02f, 4.57364768e-01f, 2.81350642e-01f, 4.42180671e-02f, 3.61913085e-01f,
  -1.88452855e-01f, 2.96793312e-01f, 2.58891881e-01f, -2.00664494e-02f, 2.32048497e-01f, 9.52472985e-02f, 3.39758813e-01f, 3.48377079e-01f, 2.70057172e-01f, 2.22535655e-01f,
  2.32296124e-01f, -3.47781807e-01f, 3.07840317e-01f, -2.20267147e-01f, 8.00894648e-02f, -7.72495242e-03f, 3.96796614e-01f, -5.91473803e-02f, 2.65247554e-01f, -3.19732130e-02f,
  4.84010391e-02f, 3.84692460e-01f, 1.03964344e-01f, -2.27823362e-01f, 1.73305154e-01f, -1.94460839e-01f, -1.04196809e-01f, -6.31978512e-02f, 2.86661029e-01f, 1.08520947e-01f,
  3.87912005e-01f, 2.05037549e-01f, 1.65129632e-01f, 1.35522187e-01f, 5.21496594e-01f, 3.92845005e-01f, 4.18631375e-01f, 2.88706839e-01f, 3.36201012e-01f, -4.17905420e-01f,
  1.21143959e-01f, -1.94184825e-01f, -1.29060686e-01f, 4.68282104e-01f, -2.53509134e-01f, 5.10802567e-01f, 3.24073911e-01f, 3.65377158e-01f, -6.91242591e-02f, 2.54825294e-01f,
  -1.52194574e-01f, -1.09900627e-02f, -2.03857020e-01f, -1.06214909e-02f, 1.22354120e-01f, -4.69450466e-02f, -1.11281984e-01f, -7.73616880e-02f, 3.05626929e-01f, 8.57501477e-02f,
  -9.23782364e-02f, 3.07592839e-01f, -4.99979258e-02f, -8.24550614e-02f, 1.69963073e-02f, -3.51493418e-01f, -4.98869866e-02f, -2.38742605e-01f, 6.73019588e-02f, 1.88266933e-01f,
  2.67489702e-01f, 1.75054744e-01f, 9.23240185e-02f, 2.79465895e-02f, 1.82219073e-01f, 1.63289785e-01f, 2.73422837e-01f, 1.21528953e-01f, 5.14154732e-01f, 3.67214322e-01f,
  1.56950623e-01f, 4.17481750e-01f, 1.98691100e-01f, 1.27396882e-01f, 1.92897901e-01f, 1.01257987e-01f, 1.98667318e-01f, -2.23314598e-01f, -1.49751082e-02f, 1.69628650e-01f,
  4.54445124e-01f, 3.12719822e-01f, 4.44090128e-01f, 3.35710615e-01f, 3.63537520e-02f, -2.96110243e-01f, 2.85339206e-01f, 2.54796743e-01f, 2.14110687e-01f, -7.70840654e-03f,
  -4.48313951e-02f, 4.46989127e-02f, 3.30075055e-01f, 1.35127589e-01f, 1.41411096e-01f, 2.63664983e-02f, -1.05218500e-01f, 2.75114924e-01f, -1.01491258e-01f, -1.50503159e-01f,
  -2.82423407e-01f, -2.84697801e-01f, 4.67403345e-02f, -2.08915137e-02f, -5.48570342e-02f, 4.24526751e-01f, 1.74998030e-01f, 1.90839961e-01f, 2.40164772e-01f, -8.26793239e-02f,
  2.91211367e-01f, 2.45994478e-01f, 2.37740383e-01f, -3.59118469e-02f, -1.61409110e-01f, -1.88863173e-01f, 2.10545212e-01f, -1.69915304e-01f, 4.06865239e-01f, 9.29719806e-02f,
  2.34585121e-01f, 3.95250559e-01f, 3.26635279e-02f, 2.65752465e-01f, 1.89015299e-01f, 2.89327979e-01f, 1.65214553e-01f, 3.51877779e-01f, 1.44265443e-01f, 2.83264130e-01f,
  9.66281593e-02f, -4.93956432e-02f, 3.08747828e-01f, 2.83873469e-01f, 6.88269734e-02f, 3.15801948e-01f, 4.05009650e-02f, 3.68329138e-01f, 1.46272838e-01f, 4.80313748e-01f,
  1.41882569e-01f, -2.95422137e-01f, -1.76461890e-01f, 4.14568871e-01f, 5.53661466e-01f, 5.22372663e-01f, 2.15285629e-01f, 1.49486274e-01f, 9.35160667e-02f, -1.92474023e-01f,
  1.90167695e-01f, -4.89244238e-02f, 2.77759820e-01f, 2.76916862e-01f, 1.51108969e-02f, 7.35995993e-02f, 1.04630917e-01f, 4.33437109e-01f, 5.54635152e-02f, 3.54126751e-01f,
  1.86506495e-01f, -1.03866331e-01f, 9.04255435e-02f, 1.86692476e-01f, 1.64485201e-01f, -6.59193620e-02f, 1.23410553e-01f, 2.14248337e-02f, 2.24922508e-01f, -6.23218454e-02f,
  8.45458135e-02f, 1.75398648e-01f, 1.22885078e-01f, -1.28363580e-01f, -9.93110165e-02f, 2.03355234e-02f, 8.81958976e-02f, 2.17098996e-01f, 3.05739075e-01f, 6.91768676e-02f,
  -1.60079598e-01f, 4.14473951e-01f, -2.03360692e-01f, -2.08593428e-01f, 2.38137558e-01f, 1.50336921e-01f, 2.36287639e-01f, -8.47984329e-02f, 2.94920355e-01f, 4.95602608e-01f,
  -1.15123622e-01f, 3.39595288e-01f, 1.65070713e-01f, -2.53870599e-02f, 3.49509567e-02f, 4.68679733e-04f, -2.51270663e-02f, 1.49055839e-01f, 2.12768123e-01f, 1.34134129e-01f,
  2.91400850e-01f, 3.92505765e-01f, 5.41116059e-01f, 3.97443086e-01f, -5.09661697e-02f, -1.65378779e-01f, -2.08354384e-01f, 2.80730814e-01f, 2.97615796e-01f, 3.70547563e-01f,
  -6.59986073e-03f, 1.22607887e-01f, -4.54055630e-02f, 3.47629994e-01f, -1.52723506e-01f, 1.57797143e-01f, -3.18857804e-02f, 7.50499144e-02f, 1.88374445e-01f, 1.87289625e-01f,
  4.92298119e-02f, 1.80764198e-01f, -1.12756547e-02f, 7.51978680e-02f, 2.46287555e-01f, -1.10435680e-01f, 3.16943705e-01f, 5.17493822e-02f, 1.95057262e-02f, 3.00810158e-01f,
  1.73249051e-01f, 2.12235734e-01f, 1.23291351e-01f, 3.46194565e-01f, 4.13143784e-01f, 7.53004029e-02f, 4.10754204e-01f, -1.41262889e-01f, 1.05906120e-02f, -2.14650482e-01f,
  -1.57117859e-01f, 2.96566069e-01f, 4.02160138e-01f, 1.68677308e-02f, 2.15629488e-01f, -2.16530841e-02f, 3.86914194e-01f, 4.68743026e-01f, 1.21438816e-01f, 4.40814674e-01f,
  2.16149017e-01f, 1.37032419e-01f, 7.11879209e-02f, 1.77922115e-01f, 1.47534862e-01f, 2.34323546e-01f, 3.44014317e-01f, -2.93433875e-01f, 4.52799380e-01f, -2.38571480e-01f,
  3.53254288e-01f, -4.05831486e-02f, 2.73915082e-01f, 1.27060726e-01f, 3.41851264e-02f, -8.96518305e-02f, -5.21181412e-02f, -1.86268494e-01f, 2.41486520e-01f, -6.28704429e-02f,
  2.23182276e-01f, -1.85431391e-01f, -2.64951259e-01f, -8.60729218e-02f, 3.60528082e-01f, 5.20669162e-01f, 2.63088159e-02f, -4.52510081e-02f, 4.34287898e-02f, 2.28852108e-01f,
  3.38376731e-01f, 1.33097991e-02f, 1.37671381e-01f, -7.75023177e-02f, 1.53101996e-01f, 2.70645142e-01f, 2.56063789e-01f, 1.09395199e-01f, -1.20641179e-01f, 7.85773098e-02f,
  -1.10890111e-02f, 3.83278221e-01f, 2.88020521e-02f, -6.29821271e-02f, -5.98167665e-02f, 8.58118907e-02f, 2.80470818e-01f, 2.03964654e-02f, -1.46305874e-01f, 2.30075791e-01f,
  1.03820696e-01f, 4.21034358e-02f, -9.69232544e-02f, 2.51130104e-01f, 4.25060958e-01f, 4.47598904e-01f, -6.15333430e-02f, -1.20266668e-01f, 1.68462656e-02f, 3.41379702e-01f,
  -1.48140982e-01f, -3.30050379e-01f, 2.81077158e-02f, 2.00924814e-01f, 3.13268006e-01f, 4.99811947e-01f, 2.39885807e-01f, -1.05480321e-01f, 1.35713607e-01f, -8.12716410e-02f,
  -2.58552795e-03f, 2.66050488e-01f, -2.13386118e-01f, 2.57902127e-02f, -2.50685394e-01f, -5.79312146e-02f, -1.13546550e-02f, 1.72968775e-01f, -3.55248123e-01f, 1.60027787e-01f,
  4.38121438e-01f, -1.81370482e-01f, 5.05703509e-01f, -2.74794810e-02f, 2.27101833e-01f, -1.74570277e-01f, -8.76577944e-02f, -3.15203428e-01f, 4.17302772e-02f, 3.62712622e-01f,
  1.88344777e-01f, -4.81346659e-02f, 3.82890880e-01f, 3.34146142e-01f, 2.04280436e-01f, 3.94975305e-01f, 3.04904163e-01f, -4.20951694e-02f, 2.60665989e-03f, 2.59224236e-01f,
  7.89641365e-02f, 2.51203299e-01f, -4.06967886e-02f, -3.29942316e-01f, 1.84188321e-01f, -4.41578813e-02f, -2.33593225e-01f, 1.49175093e-01f, 3.26411635e-01f, 1.05020709e-01f,
  3.31459284e-01f, -1.37297601e-01f, 2.37440616e-01f, 5.62923402e-02f, -1.48684531e-01f, 4.03153628e-01f, -3.52126956e-02f, -2.33622622e-02f, -1.58267468e-01f, -1.99499577e-01f,
  5.16900085e-02f, 2.84538060e-01f, -1.76678568e-01f, 4.67268020e-01f, -1.43734604e-01f, -7.71239400e-02f, -2.42873400e-01f, -5.64916730e-02f, 2.88065404e-01f, 7.02430829e-02f,
  2.18320027e-01f, 3.14174891e-01f, 3.21166337e-01f, 2.94840097e-01f, -2.36112282e-01f, -3.66296470e-01f, -3.62451911e-01f, -2.35918224e-01f, -2.31162935e-01f, -5.10122657e-01f,
  3.88890058e-01f, -1.03705011e-01f, 2.02866957e-01f, 2.24239975e-01f, 6.63720742e-02f, 3.64986807e-01f, 2.27885932e-01f, 3.26658607e-01f, 2.74928361e-01f, 4.28798616e-01f,
  -1.04126386e-01f, -2.76793420e-01f, -1.34125009e-01f, -3.94942850e-01f, 1.70209378e-01f, 4.04446125e-01f, 3.94810081e-01f, 2.20558181e-01f, 3.70721519e-01f, 9.69821289e-02f,
  1.78763479e-01f, 3.32119346e-01f, 3.87328357e-01f, 6.47037923e-02f, 1.56655535e-01f, 3.49227667e-01f, 7.04404265e-02f, -9.12623480e-02f, 2.42302433e-01f, -2.96426803e-01f,
  -2.43700132e-01f, 1.56144723e-02f, 9.04849246e-02f, -6.95346221e-02f, 9.99037847e-02f, 2.75597781e-01f, 2.79178292e-01f, 4.18402642e-01f, 4.28581148e-01f, -4.26515490e-01f,
  7.75669143e-02f, 5.41471988e-02f, 4.68657076e-01f, 4.33081180e-01f, 2.05140859e-01f, -1.90933481e-01f, 4.42148268e-01f, -1.87084362e-01f, 3.57007742e-01f, 2.59944767e-01f,
  3.30645859e-01f, 4.83104140e-01f, 1.80901408e-01f, 1.68698832e-01f, 7.27798119e-02f, 1.75068945e-01f, 2.99891710e-01f, 1.46801949e-01f, 3.11188698e-01f, -3.20897698e-01f,
  4.50647950e-01f, 1.33784395e-02f, 1.45735025e-01f, 1.47685528e-01f, 4.18802977e-01f, 1.35778517e-01f, 2.92082787e-01f, -1.63612410e-01f, 1.06845818e-01f, 1.58141807e-01f,
  -8.64265859e-02f, 8.49074044e-04f, -5.03650829e-02f, 8.88492167e-03f, -3.72473925e-01f, -7.74763944e-03f, 4.80488032e-01f, 2.56633878e-01f, 1.17084898e-01f, 3.07254881e-01f,
  1.97652578e-02f, 4.70528603e-02f, 2.62616843e-01f, 1.35216460e-01f, -1.26768604e-01f, 2.31566727e-01f, 1.34387478e-01f, 1.54770628e-01f, 3.43579829e-01f, 7.26331323e-02f,
  -8.03285465e-02f, -1.81498334e-01f, 7.12476969e-02f, -4.37738806e-01f, 9.36918110e-02f, -1.87805206e-01f, -6.27048761e-02f, -2.14246035e-01f, -1.78628013e-01f, -7.50911832e-02f,
  -2.48268038e-01f, -1.87771451e-02f, 1.68851286e-01f, 1.20892234e-01f, 4.50140208e-01f, 2.47289360e-01f, 2.15443317e-02f, -3.18346679e-01f, -9.14980844e-02f, -1.18093994e-02f,
  1.26687050e-01f, -1.51699781e-01f, 3.39529276e-01f, -5.03187738e-02f, 4.73052502e-01f, -6.49700239e-02f, 3.30571115e-01f, 2.86858261e-01f, 2.75762856e-01f, -3.71335670e-02f,
  1.94167793e-01f, -1.43247753e-01f, -4.61699963e-01f, 6.93607181e-02f, -8.00940394e-02f, 4.49032426e-01f, 5.19460738e-02f, 4.72957306e-02f, -1.01238936e-01f, 2.73700058e-01f,
  7.97703713e-02f, -1.75672725e-01f, -2.42297933e-01f, -2.85341412e-01f, -2.08172709e-01f, 8.14534962e-01f, 1.45952240e-01f, 3.67046356e-01f, 1.82257406e-02f, -4.50375587e-01f,
  -7.19716102e-02f, 3.67983103e-01f, -1.99651062e-01f, 1.45825461e-01f, -1.71405062e-01f, -2.19890878e-01f, -3.46458912e-01f, -1.89697638e-01f, 9.61675271e-02f, -2.90733486e-01f,
  -3.69803980e-02f, 2.58009166e-01f, -8.04467946e-02f, 2.12800682e-01f, -2.29303434e-01f, -3.69745106e-01f, -1.90818772e-01f, 1.09547123e-01f, -3.93254250e-01f, -1.40213117e-01f,
  9.46399495e-02f, -1.11233465e-01f, 2.90707350e-01f, -1.40597429e-02f, 1.03149928e-01f, 2.24270597e-01f, -6.26339540e-02f, 5.35388947e-01f, -1.06279604e-01f, 2.62666315e-01f,
  -8.30375925e-02f, 1.30608035e-02f, 5.95486350e-02f, -5.71217723e-02f, -1.20406538e-01f, 4.03543264e-01f, -1.46073520e-01f, -1.00066423e-01f, -2.53542840e-01f, -3.17515470e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  3.22492123e-01f, 2.56159931e-01f, 1.02867767e-01f, 2.60766298e-01f, 2.20855668e-01f, -1.58715416e-02f, 6.10267334e-02f, -1.47501910e-02f, 2.19448179e-01f, 3.02593261e-01f,
  2.86556352e-02f, 1.88905045e-01f, 4.20767635e-01f, 1.68633506e-01f, 3.32427919e-01f, 2.23128095e-01f, 8.82664844e-02f, 1.74084380e-01f, 1.84938625e-01f, 1.19615167e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.55319408e-01f, -8.29558522e-02f, 1.39597386e-01f, 9.72516015e-02f, -4.52263467e-02f, 4.28713895e-02f, 1.13293938e-01f, 7.39405975e-02f, -1.43176839e-01f, 1.51823416e-01f,
  8.13829601e-02f, -2.46391997e-01f, -7.90393576e-02f, 1.85993209e-01f, 4.56569456e-02f, -2.98520982e-01f, 2.36083582e-01f, -3.62567119e-02f, 3.02979778e-02f, 2.96927452e-01f,
  5.26994243e-02f, -1.90664321e-01f, 2.02704534e-01f, 1.77362263e-01f, -1.22251295e-01f, -1.16364285e-01f, -1.51951343e-01f, -7.57444352e-02f, 1.55834645e-01f, -3.37633267e-02f,
  -2.43239656e-01f, 6.50794990e-03f, 1.30388319e-01f, 5.00440933e-02f, 1.56175485e-02f, 7.96839744e-02f, -4.65276465e-02f, 1.00294799e-01f, 7.25026950e-02f, -2.02023998e-01f,
  3.66077304e-01f, -3.16460431e-02f, -2.30509881e-02f, 3.31004739e-01f, 1.57562234e-02f, 1.38410091e-01f, -4.65509444e-02f, 1.23672880e-01f, 7.74259567e-02f, -1.00857489e-01f,
  -1.13639946e-03f, -3.00261676e-02f, -2.36350089e-01f, 2.42170438e-01f, 5.06342873e-02f, -2.51062304e-01f, 1.93477049e-01f, -2.86153078e-01f, -1.48654342e-01f, 1.18434317e-01f,
  3.71900611e-02f, 2.65832990e-01f, -1.96008787e-01f, -3.39140832e-01f, 1.13351554e-01f, -1.83564037e-01f, 8.51603225e-02f, -7.58593455e-02f, 1.62162930e-01f, -1.58170894e-01f,
  -2.78026462e-02f, 2.62414902e-01f, 1.79401904e-01f, 3.55929434e-02f, -9.71103832e-02f, -2.19724864e-01f, -1.82694048e-01f, 1.97537854e-01f, -7.14968070e-02f, 3.32856745e-01f,
  4.83284257e-02f, -2.66566396e-01f, -1.42500833e-01f, 1.44638151e-01f, -1.20333351e-01f, 2.07376972e-01f, 2.30921552e-01f, -4.26632538e-02f, 6.02748245e-02f, 1.31153062e-01f,
  -2.64531765e-02f, -1.76625729e-01f, 2.26592362e-01f, 6.73160926e-02f, 1.69036016e-01f, -7.95509852e-03f, 1.68180883e-01f, 2.62111947e-02f, -2.50637412e-01f, 1.89272106e-01f,
  -1.01851083e-01f, -1.23933427e-01f, 4.25887061e-03f, 2.04097450e-01f, 9.60135236e-02f, 3.49765897e-01f, 1.19726412e-01f, 4.97786216e-02f, -3.75879444e-02f, 1.27372310e-01f,
  3.16909820e-01f, -2.45483384e-01f, -3.83378640e-02f, 1.57954603e-01f, -2.26912931e-01f, -4.73945215e-02f, -8.43720883e-02f, 1.48266420e-01f, 7.56067177e-03f, -2.60758400e-02f,
  -2.79790107e-02f, -1.10787250e-01f, 6.59282058e-02f, -4.06226292e-02f, 1.53365359e-01f, 8.80604163e-02f, -4.82277244e-01f, 1.02877200e-01f, -8.25366378e-03f, -1.05455546e-02f,
  -1.90172732e-01f, -1.71030968e-01f, 1.01470731e-01f, -1.85521364e-01f, 4.64045368e-02f, 6.63780272e-02f, -2.87724942e-01f, -1.62260771e-01f, 1.30798966e-01f, 2.05374479e-01f,
  1.41235277e-01f, -3.00831795e-01f, 2.41500980e-04f, 2.51562387e-01f, -2.51740187e-01f, -2.04230472e-03f, -1.00437440e-01f, -1.35686234e-01f, 1.98212832e-01f, 6.51270300e-02f,
  -2.31145978e-01f, 2.07394212e-01f, 1.93354130e-01f, 1.45858780e-01f, 3.22248712e-02f, 7.25353807e-02f, -8.54992941e-02f, -1.33703262e-01f, -2.21359685e-01f, -6.54073134e-02f,
  -3.53088491e-02f, 4.41329973e-03f, -1.69106677e-01f, -2.17658103e-01f, -1.77478651e-03f, 1.16478585e-01f, -1.02263473e-01f, 1.22704886e-01f, 1.94902703e-01f, 1.31426841e-01f,
  1.94659755e-01f, 2.18577087e-02f, -8.46897364e-02f, 2.35936940e-01f, 1.10014975e-01f, -1.64952025e-01f, -5.08060493e-02f, 1.26193866e-01f, -1.75595939e-01f, 5.46361990e-02f,
  -6.20807521e-02f, 8.72274265e-02f, 2.41288152e-02f, -2.83031851e-01f, 1.12533480e-01f, 2.67322719e-01f, 2.13896587e-01f, -5.71270920e-02f, 1.40509546e-01f, -8.96223076e-03f,
  8.86672884e-02f, 4.43778187e-02f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -3.15596871e-02f, 6.35759681e-02f, -7.35940877e-03f, -1.67263523e-01f, 1.37214541e-01f, -1.10697240e-01f, 2.29340605e-02f, -3.54979932e-02f, -5.24929501e-02f, -4.65534069e-02f,
  6.48709312e-02f, -9.23472866e-02f, -1.11200958e-01f, -1.53965905e-01f, -5.11570647e-02f, -1.52801380e-01f, -3.76947708e-02f, 1.25486299e-01f, -2.43926570e-02f, 1.40405908e-01f,
  3.40521671e-02f, 1.38464868e-01f, -3.03036459e-02f, 5.06028123e-02f, -1.50510550e-01f, -8.30619559e-02f, -4.95949127e-02f, -1.43352091e-01f, -2.23432239e-02f, -1.26840785e-01f,
  4.31543887e-02f, -3.08116209e-02f, 1.39605656e-01f, 1.56735286e-01f, -1.16507165e-01f, 4.18363921e-02f, -1.00692913e-01f, -2.79751662e-02f, 5.01977801e-01f, -5.60033679e-01f,
  -3.45858991e-01f, -2.75391698e-01f, 1.20536238e-01f, -6.25487184e-03f, 1.27537310e-01f, 1.39217511e-01f, -1.37139097e-01f, 4.03039515e-01f, 3.15461725e-01f, 1.88207656e-01f,
  2.62577862e-01f, 2.61186153e-01f, 3.18682611e-01f, 6.87995180e-02f, -9.70195532e-02f, 2.98869342e-01f, 1.07920244e-01f, -1.09796226e-01f, -3.52262817e-02f, 4.35109697e-02f,
  -1.84001818e-01f, -1.86591163e-01f, 1.52539879e-01f, 1.72832802e-01f, -2.27595732e-01f, 1.04042999e-02f, -1.19523602e-02f, 3.11521500e-01f, -2.25832433e-01f, 1.21594541e-01f,
  7.28323683e-02f, 8.43922645e-02f, 5.76982856e-01f, 1.53557852e-01f, 2.99715579e-01f, 5.31927422e-02f, -8.87848586e-02f, 4.04405177e-01f, 2.75370985e-01f, -1.39777228e-01f,
  2.79418677e-01f, -1.83478564e-01f, -8.03227723e-02f, -9.91022810e-02f, -1.50313944e-01f, 2.92393714e-01f, 6.44223511e-01f, -3.17525983e-01f, 3.07814837e-01f, 9.78722945e-02f,
  5.17593250e-02f, -8.94718766e-02f, 3.70945126e-01f, 2.49932259e-01f, -6.25065714e-02f, -2.95868695e-01f, -2.72482187e-02f, -2.75592366e-03f, -4.88167582e-03f, -9.25108120e-02f,
  3.79230022e-01f, 7.40740150e-02f, -5.81042469e-02f, -2.86786228e-01f, -5.81261627e-02f, 6.31693304e-02f, 6.13890775e-02f, 3.79352212e-01f, 4.17332023e-01f, -1.79192528e-01f,
  1.85216069e-01f, -2.18671530e-01f, 1.10474050e-01f, 5.34511864e-01f, 2.93948591e-01f, -1.52792379e-01f, 1.43225223e-01f, 2.87937194e-01f, -2.62429416e-01f, 6.76307380e-02f,
  3.85877490e-01f, -3.42732102e-01f, 3.52308303e-01f, 4.73222375e-01f, -4.12088968e-02f, 3.51170540e-01f, -4.07761782e-01f, -2.66718328e-01f, 1.39510363e-01f, -8.19756538e-02f,
  -2.72910986e-02f, 2.99195737e-01f, -7.07226545e-02f, -5.71124479e-02f, 3.27998161e-01f, -1.88702717e-01f, -2.82679588e-01f, 8.82621482e-03f, 3.71827126e-01f, -1.78883746e-01f,
  -8.98161456e-02f, 5.02711892e-01f, 6.08411096e-02f, 3.24554771e-01f, 3.27354938e-01f, -3.03027987e-01f, 1.90970302e-01f, 5.14850080e-01f, 2.43924677e-01f, 3.17661464e-01f,
  3.10853481e-01f, 2.68454880e-01f, -1.27558514e-01f, 4.30311412e-01f, 7.36646205e-02f, -1.88354105e-02f, 4.79026318e-01f, -2.46442139e-01f, 3.69732141e-01f, 4.03473914e-01f,
  2.31305867e-01f, 9.52372048e-03f, 6.99757114e-02f, 6.89140633e-02f, -1.28466934e-01f, -4.67233248e-02f, 2.57340491e-01f, -1.55529827e-01f, -1.66968599e-01f, 2.31477931e-01f,
  3.56374979e-01f, -2.20236868e-01f, -1.89604118e-01f, 4.63204831e-01f, 2.96483099e-01f, 1.00398615e-01f, 2.09198102e-01f, -5.66593148e-02f, 4.41555470e-01f, 5.34676731e-01f,
  4.35773313e-01f, 4.34763193e-01f, 1.84988201e-01f, 3.32606167e-01f, -2.28858273e-02f, 2.48001695e-01f, 2.53187120e-03f, 3.93635392e-01f, 2.71728098e-01f, -2.73065388e-01f,
  -2.48041302e-01f, 2.10911319e-01f, 2.49428395e-02f, 2.92775691e-01f, -1.07610978e-01f, 1.13576591e-01f, 9.54713896e-02f, 7.11671561e-02f, -1.63789123e-01f, 1.61707640e-01f,
  -2.63573062e-02f, 4.63786215e-01f, 3.42564881e-01f, -2.49232292e-01f, 4.11374032e-01f, 4.51747239e-01f, 5.67207932e-01f, -3.63719314e-01f, -2.31390268e-01f, 9.54191089e-02f,
  1.98723391e-01f, 3.72984320e-01f, 2.67237574e-01f, 2.09354267e-01f, 1.37798622e-01f, -1.22775108e-01f, 3.27378791e-03f, 4.06318903e-01f, 3.91091079e-01f, 3.38390321e-01f,
  2.98010170e-01f, 2.84839630e-01f, -2.80781657e-01f, 3.73214334e-01f, 7.45321661e-02f, 2.67523378e-01f, 2.44180486e-01f, 2.46398374e-01f, -1.19452246e-01f, -5.80907948e-02f,
  -1.28188655e-01f, 1.69517711e-01f, -1.69754490e-01f, 1.36973023e-01f, 4.67321455e-01f, -6.00335181e-01f, -2.46382970e-02f, 3.08800787e-01f, 1.41594768e-01f, -5.95368221e-02f,
  -1.20495521e-01f, -2.83591300e-01f, -1.37307718e-01f, 1.81204528e-01f, 2.59590030e-01f, -1.55577078e-01f, 2.68184364e-01f, 3.19481462e-01f, 5.37179746e-02f, 4.30674821e-01f,
  3.36648852e-01f, -1.73133776e-01f, 1.55546814e-01f, 1.07939718e-02f, 4.70219672e-01f, 3.81008476e-01f, 1.65974181e-02f, 3.28987092e-01f, 2.08087176e-01f, 2.81325161e-01f,
  4.00432408e-01f, 3.43484253e-01f, -6.04943261e-02f, 2.79377133e-01f, 4.95575011e-01f, -3.33540171e-01f, -2.24679410e-01f, 1.69269815e-01f, 2.57625341e-01f, -2.37974033e-01f,
  1.10559799e-01f, 5.61053514e-01f, -4.91267927e-02f, 9.50483531e-02f, -7.94803947e-02f, -2.82740742e-01f, -4.07418385e-02f, -1.07288882e-01f, 2.17373788e-01f, 1.91557989e-01f,
  4.20467198e-01f, -7.24703744e-02f, 3.06734264e-01f, -6.48562014e-02f, -1.26268715e-01f, 4.75892931e-01f, 5.36906958e-01f, 1.03132315e-01f, 1.93282977e-01f, 6.76763207e-02f,
  2.58619249e-01f, 3.10093552e-01f, 3.47421095e-02f, 1.20755434e-01f, 4.21084702e-01f, -4.44489181e-01f, -6.79040849e-02f, -3.01210403e-01f, 8.69689062e-02f, 2.89239526e-01f,
  2.05607370e-01f, -3.83150205e-02f, 5.85875381e-03f, 6.67604268e-01f, 5.16247630e-01f, -1.40748546e-01f, 6.05107248e-01f, 1.79691404e-01f, 1.76567391e-01f, -2.26705149e-02f,
  3.32829133e-02f, 3.28731358e-01f, -2.55967796e-01f, -2.18978956e-01f, -1.66388109e-01f, 1.37575254e-01f, -3.99619937e-02f, 1.16190471e-01f, 1.05171271e-01f, -3.82210940e-01f,
  2.38935530e-01f, 4.17682141e-01f, 5.53513169e-01f, 2.65711874e-01f, -3.38619947e-02f, 1.25608727e-01f, 2.22542644e-01f, -6.38314188e-02f, 4.64589477e-01f, -3.00721794e-01f,
  -2.42435485e-01f, -2.54326165e-02f, 8.47203135e-02f, 2.26074889e-01f, 6.79749697e-02f, 7.47350693e-01f, 2.17845753e-01f, -2.90679961e-01f, 3.42691764e-02f, 1.96144864e-01f,
  -1.64884731e-01f, -1.05512040e-02f, 2.82770395e-01f, -1.23688139e-01f, 1.64272785e-01f, 3.66280615e-01f, -1.27373174e-01f, -3.14236283e-01f, 3.62418503e-01f, 9.66914371e-02f,
  6.82420611e-01f, 1.11215889e-01f, 1.50631234e-01f, -3.07182401e-01f, -3.41896005e-02f, -2.21841991e-01f, 2.32558250e-01f, 8.97873044e-02f, 3.43869269e-01f, -4.33337778e-01f,
  3.38491112e-01f, 4.74104397e-02f, 1.34739289e-02f, 2.63400704e-01f, -2.15005040e-01f, 3.74995992e-02f, -9.33148116e-02f, 2.29122713e-01f, 3.50071698e-01f, 1.09213352e-01f,
  1.32096380e-01f, -2.24150315e-01f, 1.96604058e-01f, 3.63957793e-01f, 3.34885269e-01f, -2.41287183e-02f, 4.79807466e-01f, -2.07837850e-01f, -7.45212212e-02f, 2.34576136e-01f,
  -8.88621137e-02f, -1.51738435e-01f, 1.13591878e-02f, -4.66216385e-01f, 3.36977132e-02f, 1.18348189e-01f, 1.73360303e-01f, 1.14376262e-01f, 3.43356133e-02f, 2.73721725e-01f,
  -3.74086499e-01f, 1.86849043e-01f, 1.64669976e-01f, -1.86484769e-01f, -1.85071230e-01f, 4.55791831e-01f, 3.05603921e-01f, -1.40555426e-01f, 6.02660934e-03f, 4.77385595e-02f,
  2.09916130e-01f, 2.04560429e-01f, 1.79991856e-01f, -5.25075980e-02f, -7.84227476e-02f, 9.17515438e-03f, -1.56121291e-02f, 7.69715607e-02f, 1.69712856e-01f, -3.79250169e-01f,
  1.71917200e-01f, 2.32932135e-01f, -1.01556107e-01f, 5.58411241e-01f, 2.79305816e-01f, -2.42292687e-01f, 1.33425847e-01f, 1.18599728e-01f, -3.43871526e-02f, -1.60949022e-01f,
  1.11229062e-01f, 1.33423358e-01f, 9.47765261e-03f, -3.68484914e-01f, 1.53786659e-01f, -5.58375418e-02f, -2.18971685e-01f, 3.88983727e-01f, 3.59647870e-01f, -4.30470891e-02f,
  3.36792260e-01f, -1.85605083e-02f, 4.14767057e-01f, 4.92184728e-01f, 4.88882244e-01f, -1.88168027e-02f, 9.88009721e-02f, 2.19092190e-01f, 1.17965959e-01f, 1.69978157e-01f,
  3.11564147e-01f, -2.37559780e-01f, 1.45672321e-01f, 4.28635031e-01f, -2.16865931e-02f, 3.54874045e-01f, -3.14324886e-01f, -3.42006385e-01f, 4.98566702e-02f, 1.21476308e-01f,
  -1.25238419e-01f, 8.87720808e-02f, 4.07573357e-02f, 1.29203454e-01f, 1.16072588e-01f, 7.93185383e-02f, -3.71929221e-02f, 1.58781379e-01f, 9.78327394e-02f, -5.82309626e-02f,
  -4.58868919e-03f, -8.31863284e-02f, -6.40700459e-02f, -1.57271475e-01f, 9.87618864e-02f, 6.29563183e-02f, -1.41926289e-01f, -1.49766833e-01f, -1.58809856e-01f, -6.74102232e-02f,
  -1.18762463e-01f, 2.82652266e-02f, -9.70008075e-02f, -1.49006128e-01f, -1.65103719e-01f, -6.24623671e-02f, -1.79090619e-01f, -1.44769073e-01f, -1.06347896e-01f, 1.33261815e-01f,
  -3.60821337e-01f, -4.13138717e-01f, -4.67729688e-01f, -5.40853560e-01f, 2.46110186e-02f, -4.72559214e-01f, 2.60941476e-01f, -2.14523792e-01f, 2.11378094e-02f, 2.17853367e-01f,
  -4.24448252e-01f, 2.96506464e-01f, -2.04500139e-01f, -1.32274359e-01f, 1.42239928e-01f, -3.32740545e-01f, 4.11251560e-02f, 2.16841742e-01f, -8.87209624e-02f, -2.80744195e-01f,
  1.22144036e-01f, 3.02654684e-01f, 8.34488794e-02f, -3.93285900e-01f, 5.47417402e-01f, -2.31786557e-02f, 1.24761976e-01f, 1.97019652e-01f, 3.01217586e-02f, -7.64471963e-02f,
  -2.13677719e-01f, -8.67452919e-02f, -1.61860704e-01f, -9.67483595e-02f, -4.06510420e-02f, 1.56021550e-01f, -3.25053811e-01f, 1.70051321e-01f, 3.92180569e-02f, -7.81607181e-02f,
  3.51225138e-01f, 3.05919439e-01f, 1.44394919e-01f, 1.12050138e-01f, -9.92805436e-02f, 3.12605441e-01f, 4.36560899e-01f, -3.15832108e-01f, 3.53687376e-01f, 4.50321734e-02f,
  1.27621680e-01f, 1.39721325e-02f, 1.55533075e-01f, 3.27261358e-01f, 5.91460347e-01f, -3.73527259e-01f, 3.42396855e-01f, -1.55359088e-02f, -5.95956780e-02f, 2.68133759e-01f,
  3.75796676e-01f, 2.81217992e-01f, -2.52631068e-01f, -4.43813950e-01f, 1.69817507e-02f, 3.46676528e-01f, 1.42522320e-01f, 3.59314322e-01f, 4.20640290e-01f, 1.39975026e-01f,
  -5.33706963e-01f, 6.45659149e-01f, 5.34853898e-02f, 9.67043266e-02f, 2.81016290e-01f, -3.13028127e-01f, 4.10474420e-01f, -6.48351945e-03f, 5.49365208e-02f, -2.61944205e-01f,
  -1.36045977e-01f, 2.83577442e-01f, -1.05642065e-01f, 8.17607045e-02f, 6.62744343e-02f, 5.52314743e-02f, -1.83451563e-01f, 2.19995603e-01f, 1.71874147e-02f, 1.81606144e-01f,
  4.44609642e-01f, 7.81349242e-02f, 3.58397476e-02f, 5.92056870e-01f, 2.82811970e-01f, 5.24135888e-01f, 4.54522163e-01f, 4.84942198e-01f, 3.54830652e-01f, 1.93230584e-01f,
  1.26611546e-01f, 6.77197352e-02f, 3.83643024e-02f, 1.92211241e-01f, -2.69933105e-01f, -1.50861055e-01f, 2.83907741e-01f, -4.43239182e-01f, 3.66872817e-01f, 2.89935201e-01f,
  1.68707341e-01f, 3.15754771e-01f, 1.77340005e-02f, 1.93840444e-01f, 2.95322955e-01f, 4.06941712e-01f, 5.31912327e-01f, 2.19237223e-01f, -5.21116495e-01f, 3.66446376e-01f,
  1.98810339e-01f, 1.71164021e-01f, 3.86338979e-01f, 2.66094387e-01f, 2.09296402e-02f, -2.37557024e-01f, 3.93973172e-01f, 3.40401620e-01f, 1.21257268e-01f, 1.18782453e-01f,
  2.29268327e-01f, 3.44804943e-01f, 2.75391072e-01f, 3.42128217e-01f, -5.39809704e-01f, 2.71225750e-01f, 4.97278750e-01f, -3.03580672e-01f, -1.51514709e-01f, 1.79258779e-01f,
  2.24297434e-01f, -9.80770960e-02f, 1.12897038e-01f, 1.52067930e-01f, 2.89879423e-02f, 2.71636218e-01f, -8.46352354e-02f, -9.27422568e-02f, -2.24562064e-01f, -1.38313532e-01f,
  2.07270250e-01f, 3.37426551e-02f, 5.66808917e-02f, -1.02700941e-01f, 3.51466864e-01f, 4.24591340e-02f, 6.46168515e-02f, 4.32768255e-01f, 4.45410401e-01f, 6.82188803e-03f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  -1.73449710e-01f, -1.12243304e-02f, 6.86390176e-02f, 7.31315538e-02f, 1.44478232e-01f, 2.43425429e-01f, -8.73417929e-02f, 1.74343407e-01f, 3.41144741e-01f, 2.40129694e-01f,
  3.79559517e-01f, 3.79262166e-03f, 1.33628592e-01f, 2.30779812e-01f, -7.53424913e-02f, -9.57898125e-02f, 1.33401612e-02f, 9.35168341e-02f, 1.79533914e-01f, 2.86565691e-01f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -9.91507471e-02f, 1.02929875e-01f, -2.58089453e-01f, 1.24284692e-01f, 9.54102725e-02f, -4.90043648e-02f, 1.50188252e-01f, -1.21793218e-01f, -2.10966527e-01f, -3.45492959e-01f,
  7.14713754e-03f, -3.72615337e-01f, 6.43685013e-02f, 2.33445074e-02f, -1.44577637e-01f, 1.69505596e-01f, -3.00512407e-02f, -5.07770069e-02f, -4.20874450e-03f, 1.14852354e-01f,
  -1.30518265e-02f, 6.79814443e-02f, 5.77659253e-03f, -3.71055275e-01f, -6.75187558e-02f, 1.85318753e-01f, 4.64479290e-02f, -2.30204061e-01f, -6.78545833e-02f, -1.40947953e-01f,
  1.39186397e-01f, -2.18134254e-01f, -9.20592621e-02f, -8.33885819e-02f, -8.04122910e-02f, -7.69916102e-02f, 8.76551569e-02f, -1.00665331e-01f, 5.14013879e-02f, -1.57544941e-01f,
  8.91681165e-02f, 2.02280477e-01f, 9.77973416e-02f, 1.86121747e-01f, -1.32846860e-02f, -2.74399072e-01f, 1.98689803e-01f, -7.63002262e-02f, 3.66988517e-02f, 4.75572757e-02f,
  1.44909978e-01f, 1.09460749e-01f, 1.97985787e-02f, -2.15746537e-02f, -2.10432723e-01f, -2.91480171e-03f, -1.37840495e-01f, -2.56879516e-02f, -1.39454275e-01f, -1.96832314e-01f,
  4.63581383e-02f, -1.73089169e-02f, -5.30993158e-04f, 7.85841234e-03f, 8.41740891e-02f, 3.08027910e-03f, -9.60300788e-02f, 2.05594346e-01f, -1.52524114e-01f, 1.34430870e-01f,
  1.58427909e-01f, -1.65073991e-01f, -1.11833036e-01f, -7.09092468e-02f, -7.90869445e-02f, 1.89303696e-01f, 1.51622459e-01f, 4.71699499e-02f, -7.13018924e-02f, -4.26548943e-02f,
  3.30656767e-02f, 1.93092316e-01f, -7.24844486e-02f, 1.77567750e-01f, -2.33310714e-01f, 1.02748267e-01f, -3.88021097e-02f, 8.52372348e-02f, -1.72162205e-01f, 1.72763988e-01f,
  -4.10258807e-02f, -1.71634808e-01f, 1.26029164e-01f, -8.78079142e-03f, -6.88102394e-02f, 7.24892095e-02f, 1.02938630e-01f, 2.24146619e-01f, 1.12560898e-01f, 3.24594900e-02f,
  1.33536234e-01f, 2.36840084e-01f, 1.82337210e-01f, -2.54029304e-01f, -2.47366458e-01f, -3.22088182e-01f, 7.93888792e-03f, -1.62167251e-02f, 5.76322749e-02f, 2.52373308e-01f,
  -2.44487077e-01f, -1.09566860e-01f, 2.88750026e-02f, 5.74296117e-02f, -5.42939082e-02f, 3.79954837e-02f, -3.40022817e-02f, 2.56117553e-01f, -3.98902521e-02f, -1.45425841e-01f,
  -9.48874652e-03f, -4.40891944e-02f, -1.60063669e-01f, 7.97694996e-02f, 3.63264158e-02f, 8.70532990e-02f, 1.88833103e-02f, -1.97107568e-02f, -2.18327027e-02f, -2.12569479e-02f,
  -6.84082089e-03f, 2.13532850e-01f, -6.21741973e-02f, 1.28058925e-01f, 2.33077273e-01f, -2.50699013e-01f, -1.57189310e-01f, -1.61818326e-01f, -1.62427068e-01f, -1.64832503e-01f,
  1.29763797e-01f, 8.57431665e-02f, -3.05111825e-01f, 1.30417839e-01f, 9.81349573e-02f, -1.94513239e-02f, 7.81023549e-03f, -2.71658935e-02f, -8.16808492e-02f, 1.43906996e-01f,
  -7.17779994e-02f, -2.07355261e-01f, -3.37061174e-02f, -7.10746720e-02f, -5.42703830e-02f, -1.05245411e-01f, 1.18712939e-01f, -1.34556875e-01f, 1.41231805e-01f, -1.10908374e-01f,
  2.33645290e-01f, -1.93498041e-02f, 1.94583640e-01f, 1.06956229e-01f, 2.12448221e-02f, -1.61707941e-02f, 3.33419926e-02f, -6.34827167e-02f, 1.88976616e-01f, -2.13824585e-01f,
  7.13005662e-02f, 1.05906660e-02f, -1.33931562e-01f, -9.39190537e-02f, 1.11224838e-01f, -1.32318527e-01f, 2.30351817e-02f, 1.42628461e-01f, 1.05126776e-01f, 6.65024072e-02f,
  -9.17768329e-02f, -1.04759075e-01f, -1.47052659e-02f, 2.10174054e-01f, -1.26513883e-01f, -8.41910616e-02f, 2.91492473e-02f, 1.55304924e-01f, 1.88400131e-03f, -1.22414574e-01f,
  7.21092075e-02f, 2.99053509e-02f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -1.03103213e-01f, -1.80365250e-01f, -1.43313438e-01f, -9.75988284e-02f, -3.30491848e-02f, 1.21220455e-01f, -5.03437892e-02f, -3.63524221e-02f, 1.78693980e-01f, 1.26159474e-01f,
  3.77287865e-02f, -9.24379379e-03f, -1.65979341e-01f, -3.95723172e-02f, -1.69815987e-01f, 1.04834005e-01f, 1.76688451e-02f, -1.48293808e-01f, -1.44235641e-01f, -1.63809419e-01f,
  -1.89320073e-01f, -3.38421389e-02f, 5.64838983e-02f, 8.58285055e-02f, -6.42975643e-02f, 1.11450821e-01f, 3.08771171e-02f, 6.90028593e-02f, -1.62641689e-01f, -1.74655125e-01f,
  3.64562944e-02f, 5.62000759e-02f, 2.21882120e-01f, -7.90704116e-02f, 7.72726014e-02f, 5.47608547e-02f, 1.75377503e-01f, -1.64074197e-01f, 4.41507488e-01f, 1.53016970e-01f,
  4.29379821e-01f, 2.63710529e-01f, -6.51778728e-02f, 2.31341183e-01f, -1.18114479e-01f, 4.67940681e-02f, 5.02576590e-01f, -9.30244476e-03f, 5.53671300e-01f, 4.63850737e-01f,
  4.61963415e-01f, 4.06224430e-01f, -3.43868256e-01f, -2.55956203e-01f, 1.25019103e-02f, 1.96320221e-01f, -3.74610275e-01f, 1.55921811e-02f, 1.14954740e-01f, 4.31377053e-01f,
  4.90127772e-01f, 3.51087227e-02f, 2.43637294e-01f, -2.72100210e-01f, 1.07364338e-02f, -1.67431489e-01f, 1.52711377e-01f, 2.05749884e-01f, 1.64309964e-01f, -3.06517221e-02f,
  1.45904467e-01f, -2.76632786e-01f, -3.86941999e-01f, -1.06777750e-01f, 3.00941080e-01f, 7.21089914e-02f, 1.09945700e-01f, 3.21343094e-01f, -2.41670564e-01f, 3.67444009e-01f,
  1.78503156e-01f, 3.51940006e-01f, -2.82261334e-02f, -2.99842626e-01f, -4.53637809e-01f, -1.88965514e-01f, -5.38063109e-01f, 3.87724310e-01f, -4.31600064e-02f, 2.79883385e-01f,
  -4.54310216e-02f, 5.95646024e-01f, -1.31356635e-03f, -2.24390641e-01f, 2.37617806e-01f, -5.27954519e-01f, 5.24216853e-02f, 8.10412876e-03f, -9.78993177e-02f, 1.18061669e-01f,
  -2.19828174e-01f, 1.98720932e-01f, -6.62649944e-02f, 4.15923804e-01f, -3.19289505e-01f, 4.05013323e-01f, -1.61965087e-01f, 3.62885058e-01f, 1.70779809e-01f, -1.80277050e-01f,
  3.91782701e-01f, 2.26736993e-01f, -4.45628203e-02f, -6.29565641e-02f, 7.02456608e-02f, -1.39653519e-01f, 1.44569248e-01f, 3.34155522e-02f, -1.29753068e-01f, -1.85521301e-02f,
  2.59891242e-01f, 1.83507130e-01f, 5.07244989e-02f, -1.33137748e-01f, 2.86379308e-01f, 1.66998938e-01f, -8.70940611e-02f, 2.08207533e-01f, 3.74720320e-02f, -4.61707301e-02f,
  -1.26339830e-02f, -1.08825319e-01f, -1.29030153e-01f, 1.42641768e-01f, 8.85123312e-02f, 3.24873537e-01f, -4.49324280e-01f, 3.50429446e-01f, 2.94476524e-02f, 1.64523825e-01f,
  1.13536209e-01f, -1.73326936e-02f, 5.92577271e-02f, 3.83292824e-01f, -1.57998607e-01f, 4.61084247e-02f, 1.69492453e-01f, -2.13383302e-01f, -6.79906830e-02f, 6.52481765e-02f,
  -4.05556291e-01f, 2.04229102e-01f, 3.02845925e-01f, 1.65642440e-01f, 1.33008882e-01f, -8.64194632e-02f, 2.30649516e-01f, 1.97573096e-01f, -4.42493744e-02f, 4.61203652e-03f,
  2.94699997e-01f, 1.13116652e-01f, -8.21532458e-02f, 6.41185045e-02f, -2.15062916e-01f, -5.76141328e-02f, 3.06228012e-01f, 4.11286771e-01f, 3.93908858e-01f, -4.12621170e-01f,
  -2.70762146e-01f, -1.17073357e-01f, -1.28176197e-01f, 2.17889681e-01f, 5.01216531e-01f, -2.64107347e-01f, 3.95666629e-01f, 3.75559121e-01f, 9.39172804e-02f, 2.92949229e-01f,
  -3.46075892e-02f, 5.36491275e-01f, 6.64579511e-01f, 2.51473665e-01f, -3.05010259e-01f, 5.13097830e-03f, 1.83120295e-02f, -2.76437044e-01f, 3.74619067e-01f, -3.30761075e-01f,
  1.72972947e-01f, -2.26521075e-01f, 7.33786821e-02f, 4.70426947e-01f, -6.19377010e-02f, -1.14990048e-01f, -6.75343648e-02f, 4.66511808e-02f, 5.97937644e-01f, 2.90062428e-02f,
  2.92505741e-01f, -5.97974360e-01f, -3.50044072e-01f, -5.53322494e-01f, 1.19318314e-01f, 2.69225150e-01f, 1.18682289e-03f, 3.45868655e-02f, 2.00761259e-01f, 2.78613180e-01f,
  -8.13075230e-02f, -4.49700840e-02f, -9.06103477e-02f, 6.17323756e-01f, 1.51219606e-01f, 2.58340370e-02f, 2.47035816e-01f, 2.25669384e-01f, -3.60561423e-02f, -8.33015144e-01f,
  1.06710114e-01f, -2.03255787e-01f, 5.48216254e-02f, -6.80181256e-04f, -9.11671966e-02f, 1.48975000e-01f, -1.68348148e-01f, -1.57747597e-01f, -6.45050332e-02f, -7.49132931e-02f,
  -1.05858319e-01f, -2.15158574e-02f, -3.11334878e-02f, 7.94650689e-02f, -1.21993676e-01f, 1.28519475e-01f, -1.30908638e-01f, -1.07476369e-01f, 7.71354232e-03f, 3.52413431e-02f,
  -1.59734964e-01f, 8.94702226e-02f, 6.43509701e-02f, -1.32663652e-01f, -1.45818144e-01f, -1.53930753e-01f, 1.51294813e-01f, 9.06765237e-02f, 5.66150770e-02f, -1.05846897e-01f,
  -1.31893083e-02f, 9.49705243e-02f, -1.51336551e-01f, -9.28537697e-02f, -2.22133119e-02f, -1.76166326e-01f, -5.01261950e-02f, 6.04701936e-02f, -1.22676216e-01f, 7.07818493e-02f,
  -1.79952323e-01f, -8.55904073e-02f, -3.48421261e-02f, -5.64272031e-02f, -1.12034418e-02f, 9.23329312e-03f, 1.41537443e-01f, 1.05641939e-01f, 1.58021584e-01f, 2.61741667e-03f,
  -1.16556764e-01f, -1.47057801e-01f, -7.10733011e-02f, -2.03560263e-01f, 7.96017423e-02f, 1.36022374e-01f, -1.09038621e-01f, -3.21883708e-03f, -5.19713797e-02f, 5.21779656e-02f,
  -5.47132231e-02f, 8.31994712e-02f, -3.99981998e-02f, -7.01462617e-03f, -1.98759183e-01f, -1.35956004e-01f, 8.58324915e-02f, 1.13782115e-01f, 2.30870485e-01f, -8.15255567e-02f,
  -4.15365100e-02f, 1.84106737e-01f, 2.60075152e-01f, 9.61975455e-02f, -2.49125406e-01f, 3.77338403e-03f, -5.68525255e-01f, 2.46229947e-01f, 1.61964715e-01f, -1.28918812e-01f,
  8.18288624e-02f, 3.91502380e-01f, -3.72957379e-01f, 5.01540899e-01f, -2.19889522e-01f, -1.87372323e-02f, 2.39772692e-01f, -3.74044746e-01f, 6.00737408e-02f, 1.81461677e-01f,
  -6.20341897e-01f, 2.11044580e-01f, 1.22406267e-01f, 3.33338708e-01f, -1.30944490e-01f, 3.33171487e-01f, 1.68313324e-01f, 4.19890098e-02f, 1.46146461e-01f, 1.13598794e-01f,
  -1.87571779e-01f, 2.65273843e-02f, 3.19186032e-01f, -2.94633538e-01f, 3.88854742e-01f, -7.94960707e-02f, -1.40141398e-01f, 1.95940346e-01f, -2.33443424e-01f, 1.40885515e-02f,
  1.86098546e-01f, -4.22007859e-01f, 1.12967230e-01f, 3.79684158e-02f, -2.20542505e-01f, 4.33984429e-01f, -7.32994378e-02f, 2.87323952e-01f, -1.63756236e-02f, -1.29789189e-01f,
  -1.39177606e-01f, 3.35262150e-01f, -1.13871634e-01f, 2.04404905e-01f, 3.29999812e-02f, 2.34580621e-01f, 1.19850151e-01f, 4.87620771e-01f, 1.63674653e-02f, -9.15762782e-03f,
  5.21329455e-02f, -1.51548311e-01f, 5.83757639e-01f, -3.34821939e-01f, -1.05006695e-01f, 5.25546491e-01f, 1.42403781e-01f, 1.78140208e-01f, -5.38843088e-02f, -4.06069130e-01f,
  -5.62815547e-01f, -2.53851619e-02f, 5.05162597e-01f, 2.09530592e-01f, 1.37212053e-01f, 3.00635546e-01f, -4.00054693e-01f, 1.17959706e-02f, 5.41614853e-02f, -3.30079347e-02f,
  9.42430198e-02f, 5.07083200e-02f, 1.92026719e-01f, 3.12397778e-01f, -2.90162385e-01f, -1.13906816e-01f, -1.17293783e-01f, 1.37370199e-01f, 9.53430608e-02f, -3.16438407e-01f,
  -4.54951942e-01f, 1.30313873e-01f, 3.12651813e-01f, 4.91990484e-02f, -1.55835316e-01f, 1.53178602e-01f, -9.28493515e-02f, -1.91146061e-01f, -2.00508162e-01f, 2.89607719e-02f,
  -6.65902048e-02f, -7.17824921e-02f, 5.68234921e-02f, -2.95874868e-02f, 1.57593861e-01f, 4.82832827e-02f, -8.98916647e-02f, -5.55460118e-02f, -9.45925191e-02f, 2.15871893e-02f,
  -4.35835533e-02f, 9.26647037e-02f, -2.72605866e-02f, -2.15047412e-02f, -1.73675820e-01f, -9.94604453e-02f, -1.64727673e-01f, 8.40757340e-02f, -4.99168783e-03f, 1.14125282e-01f,
  1.67744502e-01f, -1.47119150e-01f, -5.88537604e-02f, -5.42984623e-03f, -1.38419494e-01f, -1.86290890e-01f, 1.76038519e-01f, 3.33726615e-01f, 1.79210857e-01f, -1.06103914e-02f,
  3.40616912e-01f, 3.41316909e-01f, -5.07272840e-01f, 3.02229553e-01f, 2.17398137e-01f, -1.79272458e-01f, 1.69126708e-02f, -3.07067186e-02f, -1.69134662e-01f, 1.10964619e-01f,
  -1.50077626e-01f, 3.29112023e-01f, -1.38116851e-01f, -1.52714387e-01f, -1.38221189e-01f, -1.50362298e-01f, 6.10697806e-01f, 1.27567425e-01f, 3.27221423e-01f, 1.12670161e-01f,
  2.64480859e-01f, 3.42808276e-01f, -1.12929471e-01f, -3.21220868e-04f, -3.36777382e-02f, 1.87629282e-01f, 2.06545532e-01f, 4.15825814e-01f, -3.62179697e-01f, -2.41278976e-01f,
  -1.50060400e-01f, -1.87050253e-01f, -3.37447643e-01f, -1.40324133e-02f, 1.31369457e-01f, 3.32633018e-01f, 3.22859466e-01f, 4.74222237e-03f, -1.14598691e-01f, 1.28528951e-02f,
  -1.56143516e-01f, 2.67156303e-01f, 5.35196900e-01f, -1.85591698e-01f, 3.13151032e-01f, 2.22695202e-01f, 1.24915019e-01f, -5.28184772e-02f, -2.09546775e-01f, 2.45573565e-01f,
  4.40803140e-01f, 4.54845786e-01f, -1.41385019e-01f, 2.51059502e-01f, -8.09404925e-02f, 1.77870899e-01f, 3.72478515e-01f, -4.07698274e-01f, 4.66524251e-02f, -2.46357098e-01f,
  -2.02379405e-01f, -2.52487987e-01f, -3.20613414e-01f, -9.03397650e-02f, 8.11199918e-02f, 1.29197221e-02f, -1.27495468e-01f, 1.67211220e-01f, -2.63651758e-01f, 4.87727314e-01f,
  2.54836887e-01f, -1.70727223e-01f, -2.57095564e-02f, -1.32080749e-01f, 1.91553161e-01f, 5.19569218e-01f, -1.66653514e-01f, 2.05498964e-01f, 4.11235482e-01f, -4.00632501e-01f,
  -1.33231670e-01f, 6.74739778e-02f, -3.44060242e-01f, -1.41697209e-02f, 1.78572685e-01f, 3.68198097e-01f, 1.43012807e-01f, 3.08784723e-01f, 2.91567296e-01f, 2.71375794e-02f,
  2.85675172e-02f, 1.25830874e-01f, 2.14949191e-01f, 4.60164607e-01f, 5.22244573e-01f, 9.55640227e-02f, 2.80516356e-01f, 1.38047838e-03f, -4.53416497e-01f, 4.15059149e-01f,
  3.37004483e-01f, -3.56430501e-01f, -2.27846280e-02f, 9.55194458e-02f, -1.51009291e-01f, 1.45284131e-01f, -1.27025321e-01f, 3.18780214e-01f, 4.74769250e-02f, -1.10931523e-01f,
  -2.83619553e-01f, -2.28430435e-01f, 8.72162163e-01f, 2.97117323e-01f, 4.08359647e-01f, 1.11686721e-01f, 6.44532621e-01f, 2.28320196e-01f, -4.71193343e-03f, -1.12404622e-01f,
  -1.11474961e-01f, 3.30170572e-01f, 1.62913665e-01f, 5.77048063e-01f, 3.74865323e-01f, 3.34861986e-02f, 6.94530979e-02f, 1.39990032e-01f, 1.83973044e-01f, 2.66256034e-01f,
  7.34608769e-02f, -5.95089316e-01f, -2.97022872e-02f, 1.67994112e-01f, 5.54076023e-02f, 3.23388487e-01f, 1.35255381e-01f, 8.10302123e-02f, -3.35172415e-01f, 1.92553420e-02f,
  1.03473403e-01f, 2.50042528e-01f, 2.83392996e-01f, 4.61155981e-01f, 7.08340108e-02f, -1.72078460e-01f, 2.12088898e-01f, -4.04631138e-01f, -1.39764026e-01f, -2.03707278e-01f,
  3.72339785e-02f, -3.17214698e-01f, -1.89823374e-01f, 4.63824481e-01f, 4.18774188e-01f, 1.01543680e-01f, -1.56681433e-01f, 1.31838709e-01f, 2.04033405e-01f, 2.27098558e-02f,
  -7.49914497e-02f, -1.08050913e-01f, -1.68518648e-01f, -3.50803316e-01f, 2.20841318e-02f, 3.16300094e-01f, -3.11516523e-01f, 3.92562091e-01f, 4.00486737e-02f, -4.16621923e-01f,
  6.67681918e-02f, 9.65413749e-02f, 6.91967010e-02f, -6.06212206e-02f, 4.14300531e-01f, 4.42037731e-01f, 3.53396386e-01f, -3.76961887e-01f, 1.09778531e-01f, -5.39105415e-01f,
  2.40262285e-01f, 1.63860798e-01f, 5.36770374e-02f, -5.30226529e-01f, 4.77878600e-02f, 6.50919914e-01f, 1.99885845e-01f, 6.24962389e-01f, 2.43166134e-01f, -2.30945885e-01f,
  -1.23596102e-01f, -1.76222296e-03f, 3.36444646e-01f, -5.91631867e-02f, 1.23372518e-01f, -5.80335975e-01f, 5.16397133e-02f, -8.47657993e-02f, 1.35937836e-02f, -3.10493279e-02f,
  1.62063465e-01f, 2.98440874e-01f, -3.37667048e-01f, 7.84470215e-02f, 2.50467360e-01f, 1.22835413e-01f, 2.39317566e-02f, 2.36413032e-01f, -2.25162461e-01f, 2.31118843e-01f,
  -3.35747749e-01f, -3.03286731e-01f, 1.00730591e-01f, 1.08111896e-01f, 9.56011862e-02f, -3.43345642e-01f, -2.15907052e-01f, 2.50854284e-01f, 2.27758035e-01f, -2.33978286e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  -4.12890688e-02f, 1.57507379e-02f, -2.76843328e-02f, -1.32012079e-02f, -5.59385009e-02f, 2.18528315e-01f, -2.45512333e-02f, -5.56739382e-02f, -7.76802376e-02f, 1.07178651e-01f,
  1.48592265e-02f, 2.14793801e-01f, -1.73865706e-01f, 2.00033903e-01f, 1.73897538e-02f, -9.85287353e-02f, 2.10465074e-01f, 3.24960381e-01f, 1.34588182e-01f, -1.61206368e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -1.12937205e-01f, -1.72232568e-01f, -2.38435730e-01f, 5.58458902e-02f, 1.26794696e-01f, -2.32163146e-01f, 1.28215641e-01f, -2.85384685e-01f, -2.68258937e-02f, 9.14960876e-02f,
  2.12398350e-01f, -1.60798073e-01f, 1.48546785e-01f, 3.03731978e-01f, -5.52850477e-02f, -3.27063113e-01f, -3.58839214e-01f, 7.40029290e-02f, -1.39674604e-01f, -1.43156663e-01f,
  1.37542397e-01f, -3.84150565e-01f, -1.12450942e-01f, -4.37658876e-01f, -1.45496260e-02f, -6.88573480e-01f, 4.57209498e-02f, 8.32375046e-03f, -7.11661041e-01f, 1.35888830e-01f,
  2.44108319e-01f, 2.22578406e-01f, 2.11189613e-01f, -1.05697640e-04f, 3.87801915e-01f, 4.40570489e-02f, 3.42621326e-01f, -9.46234912e-02f, -1.25414997e-01f, 5.74266613e-01f,
  3.67694110e-01f, 2.37428263e-01f, 7.16053369e-03f, 2.29777530e-01f, 1.14040906e-02f, 2.40703702e-01f, -2.64316469e-01f, -3.38250518e-01f, -2.61989385e-01f, -1.05923032e-02f,
  -5.36915004e-01f, -1.20885476e-01f, -9.69778448e-02f, -2.44015723e-01f, -4.36344892e-01f, 4.07712638e-01f, 6.34345934e-02f, -1.89563826e-01f, -4.51350808e-01f, -4.83571172e-01f,
  -4.65518497e-02f, 4.54345882e-01f, 2.00067103e-01f, 1.72567278e-01f, 1.83860049e-01f, 6.71812743e-02f, 1.42234460e-01f, 6.82889298e-02f, 1.05219766e-01f, 2.36234099e-01f,
  -3.68072987e-01f, -3.57612707e-02f, -4.35935944e-01f, 5.45000732e-02f, -4.64954406e-01f, -4.76424783e-01f, 1.62949309e-01f, -5.72026551e-01f, -1.11406662e-01f, 1.22897059e-01f,
  -4.70469981e-01f, -5.03967285e-01f, -6.02417231e-01f, -5.12801372e-02f, 1.07206851e-01f, -1.63468555e-01f, -8.49940181e-01f, -3.61849815e-02f, 1.40648246e-01f, 1.82082817e-01f,
  -6.14589214e-01f, -4.00775135e-01f, 3.84668916e-01f, 1.89142913e-01f, 4.48546052e-01f, -2.12728649e-01f, -1.94959283e-01f, 7.62716085e-02f, 1.11245975e-01f, 4.10341509e-02f,
  -1.88255340e-01f, 8.30276906e-02f, -6.64906576e-04f, 2.80017197e-01f, 1.77669004e-01f, -2.60125678e-02f, -2.23015938e-02f, -2.53773987e-01f, -1.32555664e-01f, 1.78775132e-01f,
  1.59784973e-01f, 1.57708228e-02f, -1.97735634e-02f, 1.98273301e-01f, -1.67102292e-01f, -1.77472681e-01f, -7.27553070e-02f, -2.16113806e-01f, 4.73057851e-02f, -3.88868332e-01f,
  1.12377681e-01f, -5.36477149e-01f, 2.44618878e-01f, 1.18932277e-01f, -3.11463356e-01f, -6.45586193e-01f, -4.02720571e-01f, -4.41706836e-01f, 2.29653325e-02f, 5.84737360e-02f,
  -5.80594204e-02f, 2.19346404e-01f, -6.61079735e-02f, 6.08867519e-02f, -1.71291500e-01f, 3.33082736e-01f, 2.53394723e-01f, -1.50276646e-01f, 5.49857803e-02f, 2.94540673e-01f,
  -1.86514363e-01f, 9.42261517e-02f, -1.59687981e-01f, 2.73122698e-01f, 1.32989809e-01f, -1.12498859e-02f, 1.89490398e-04f, 1.38309658e-01f, -1.99314747e-02f, -8.15942883e-02f,
  -1.65449642e-02f, -5.57508707e-01f, 9.01350975e-02f, -1.20530233e-01f, -6.53654635e-02f, 1.11909293e-01f, 1.19538084e-02f, -1.41033709e-01f, 2.39913166e-01f, -3.09391737e-01f,
  -4.31489408e-01f, 2.88563520e-01f, -1.53997108e-01f, -3.87713253e-01f, -4.00553703e-01f, 1.83265787e-02f, 2.16963500e-01f, 2.73098916e-01f, -5.44127449e-02f, -3.74712162e-02f,
  7.34096766e-02f, 1.46967113e-01f, -9.15086269e-02f, 8.06723684e-02f, 2.62671947e-01f, -5.69509268e-02f, -3.55064427e-03f, -1.09741405e-01f, -2.62569219e-01f, 5.81048289e-03f,
  9.27608982e-02f, 2.14519009e-01f, 9.95148122e-02f, 3.27284485e-01f, 9.47947428e-02f, -3.50886732e-01f, -2.67813444e-01f, 5.05280010e-02f, -3.79584432e-01f, 2.75192857e-01f,
  4.93866056e-02f, 2.22020566e-01f, -3.03095758e-01f, -2.31335595e-01f, 2.19729230e-01f, 8.71215388e-02f, 1.76688120e-01f, -1.40541270e-01f, 3.63882065e-01f, -1.81420013e-01f,
  2.45857164e-01f, 1.50764942e-01f, 5.89638315e-02f, -1.75162315e-01f, 1.48984253e-01f, -4.38569069e-01f, -7.25244060e-02f, -5.80471121e-02f, 8.53491947e-02f, -4.79374915e-01f,
  6.81284592e-02f, -8.72369036e-02f, 1.02357175e-02f, 2.32568860e-01f, -1.90675423e-01f, 2.67161012e-01f, -1.86522827e-01f, 1.87555581e-01f, -5.48914373e-01f, 1.01020791e-01f,
  5.45507148e-02f, 1.41502544e-02f, 1.08252317e-01f, 1.60086617e-01f, -1.10710286e-01f, 5.68111613e-02f, -2.17205167e-01f, 1.00802079e-01f, 1.42951831e-01f, -2.49739632e-01f,
  -1.43707111e-01f, -2.59215623e-01f, -1.33642361e-01f, -3.18559766e-01f, -1.18906990e-01f, -3.93868275e-02f, -1.40473381e-01f, 1.31448597e-01f, 3.58261973e-01f, -3.26407105e-02f,
  4.06710245e-02f, -1.63494796e-01f, -4.94228095e-01f, -1.10628903e-01f, -1.40271544e-01f, 1.54115170e-01f, 2.03686774e-01f, -3.43933046e-01f, -4.49057929e-02f, 1.61460824e-02f,
  -5.40125482e-02f, 3.89609821e-02f, 2.63409652e-02f, -4.53772128e-01f, -2.63714612e-01f, -2.86428422e-01f, 1.15538679e-01f, -1.87962890e-01f, 3.46323788e-01f, -9.35538560e-02f,
  2.72265583e-01f, 3.36075097e-01f, 1.61646917e-01f, -3.41548800e-01f, 6.43195733e-02f, 2.87817061e-01f, 2.90100515e-01f, -2.11577997e-01f, -1.16944872e-01f, -3.92848819e-01f,
  -3.30230176e-01f, -4.58195835e-01f, -6.17096186e-01f, 1.16743691e-01f, 1.22413464e-01f, -2.54076961e-02f, 1.31671801e-01f, -5.18858731e-02f, 2.66040862e-01f, -4.75169830e-02f,
  7.67674968e-02f, 4.92492318e-01f, -9.03299823e-02f, -4.49633539e-01f, 4.51345831e-01f, -3.70516479e-01f, -3.73965144e-01f, -1.69379935e-01f, 1.45917520e-01f, 1.25797957e-01f,
  1.15910470e-01f, 3.70563082e-02f, -2.23348960e-01f, -1.97946653e-01f, -2.47058362e-01f, -1.25748321e-01f, -2.30182186e-01f, -4.25818056e-01f, -2.08823085e-01f, -2.84673721e-01f,
  -1.14948988e-01f, -1.50882661e-01f, -3.04791600e-01f, 3.48371595e-01f, 2.30958477e-01f, -4.86940414e-01f, -6.25408709e-01f, 8.51978511e-02f, -1.11777537e-01f, 2.05518901e-01f,
  -1.22643173e-01f, -2.20694289e-01f, -1.33979008e-01f, 1.24101207e-01f, -4.48263973e-01f, 3.20727199e-01f, 1.57163650e-01f, -3.98606300e-01f, 1.64921984e-01f, -7.35183358e-01f,
  1.10027857e-01f, 2.85668373e-01f, -3.21820408e-01f, -2.66551450e-02f, 1.16609044e-01f, -3.62669766e-01f, -2.33270675e-01f, -1.29851907e-01f, -1.93312764e-01f, 2.90976137e-01f,
  4.37518992e-02f, 2.71227628e-01f, -1.92865487e-02f, 2.18978792e-01f, -2.83943802e-01f, -5.98142520e-02f, -4.96390313e-01f, 3.72075558e-01f, 1.65456846e-01f, -4.06189896e-02f,
  1.19122550e-01f, -4.26922917e-01f, -3.87451351e-01f, -7.56451249e-01f, -6.73296601e-02f, -5.80347925e-02f, 1.35995314e-01f, -4.84908640e-01f, 3.21748033e-02f, -2.72056907e-01f,
  -2.37438083e-01f, -2.55358666e-01f, 2.52293237e-02f, -2.31498972e-01f, -3.02733243e-01f, -1.81568265e-01f, -3.06851238e-01f, 1.85384244e-01f, 3.58027905e-01f, -2.10227817e-01f,
  5.74813336e-02f, 1.86997578e-02f, 1.57360524e-01f, 2.68979430e-01f, 5.08720651e-02f, -2.93785166e-02f, 3.27168673e-01f, -2.34739229e-01f, -1.12652205e-01f, 8.21962953e-02f,
  2.92167217e-01f, 1.32284939e-01f, 4.01247926e-02f, -2.72931531e-02f, 3.72127801e-01f, 7.73472488e-02f, -1.39994219e-01f, -3.36219847e-01f, -1.51145995e-01f, -1.57585755e-01f,
  1.10479221e-01f, -5.29223323e-01f, -4.10069615e-01f, 2.93778121e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -6.72481284e-02f, 3.65141779e-02f, 2.24880755e-01f, -2.49404415e-01f, -1.22101180e-01f, -2.09139749e-01f, 4.23869491e-02f, -1.23235129e-01f, 9.67739075e-02f, -1.38005510e-01f,
  -3.37354206e-02f, -1.13149509e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    