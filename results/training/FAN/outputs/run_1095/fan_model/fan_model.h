/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.77544415e-01f, 2.37335891e-01f, 2.54298478e-01f, 1.74168587e-01f, -1.29502853e-02f, -1.26528889e-02f, 9.97525677e-02f, -4.82005663e-02f, -4.92175370e-02f, 1.19034439e-01f,
  -2.03188390e-01f, -4.49994296e-01f, -1.95008114e-01f, -2.05275580e-01f, -3.11278570e-02f, 2.10790083e-01f, 2.24541992e-01f, 1.35998521e-02f, -2.88609087e-01f, -2.12537631e-01f,
  -2.51286119e-01f, -7.17711151e-02f, 1.06180226e-03f, -3.71064036e-03f, 1.42785713e-01f, -2.90413409e-01f, 6.91097304e-02f, -3.13422754e-02f, -8.43976662e-02f, 2.63836801e-01f,
  1.54040113e-01f, 3.93543720e-01f, -4.65713851e-02f, -7.03296661e-02f, 6.93474934e-02f, 1.23577267e-01f, 5.08117005e-02f, 2.46812955e-01f, 5.10937385e-02f, 4.65123579e-02f,
  5.42359985e-02f, -7.28005916e-03f, 3.55239515e-03f, 7.14294519e-03f, 8.70113894e-02f, 6.92853406e-02f, 7.47422129e-02f, 1.83090940e-01f, 2.21139207e-01f, 1.86862946e-01f,
  -9.79132392e-03f, 5.82335033e-02f, 8.69137570e-02f, 1.51066825e-01f, 1.84459582e-01f, -9.25078839e-02f, 1.31832361e-01f, 1.57193705e-01f, 1.66848972e-01f, 1.40551075e-01f,
  4.62175347e-02f, -6.05109707e-02f, -1.16259959e-02f, -3.32499929e-02f, 9.62654874e-03f, -3.19874063e-02f, -5.41409031e-02f, -8.95855278e-02f, -1.77316908e-02f, -4.15580235e-02f,
  -6.53305724e-02f, 1.90952327e-02f, -6.08201176e-02f, 7.50621706e-02f, -5.76808825e-02f, 4.26021703e-02f, -1.41603751e-02f, -1.02438284e-02f, -3.56452465e-02f, 5.80724031e-02f,
  -5.37641859e-03f, -3.65093276e-02f, -9.69159529e-02f, 4.72127683e-02f, -3.61396410e-02f, -8.26074779e-02f, -2.87829023e-02f, -3.22402678e-02f, -5.01652732e-02f, -1.16574243e-01f,
  4.54666354e-02f, 2.24999283e-02f, -1.35180308e-02f, 8.37313235e-02f, 1.02839410e-01f, 5.55288307e-02f, -5.18845581e-02f, 8.88878852e-02f, -8.39896351e-02f, 1.48213478e-02f,
  -7.39577189e-02f, 1.99318118e-02f, -2.16438081e-02f, -1.14349984e-02f, -2.54875496e-02f, 1.26977754e-03f, -1.42484074e-02f, -1.13284729e-01f, 4.46710624e-02f, 1.37810066e-01f,
  4.47233301e-03f, -3.69184092e-02f, -7.44584575e-02f, 6.46808445e-02f, -3.92564340e-03f, -7.54867494e-02f, 1.06287561e-02f, 9.68348980e-02f, -6.71523809e-02f, 8.23416412e-02f,
  -3.92030776e-01f, -5.43798581e-02f, -2.47659475e-01f, -2.13836417e-01f, -1.64246157e-01f, -1.59040034e-01f, -3.12090337e-01f, -2.53679335e-01f, -1.85668394e-01f, -9.41983834e-02f,
  9.39613283e-02f, 1.93267643e-01f, 1.81517884e-01f, 9.39008445e-02f, -1.26656592e-01f, -1.46187171e-01f, -2.59647816e-01f, -2.53772497e-01f, -2.35284224e-01f, -2.62435973e-01f,
  -5.45907058e-02f, -1.33854672e-01f, -1.47498429e-01f, -1.53763324e-01f, -1.05785973e-01f, -7.48349354e-02f, -1.02110870e-01f, -1.79641470e-01f, -7.70276189e-02f, -7.32160062e-02f,
  8.72349814e-02f, -3.45850289e-01f, -6.16011284e-02f, -6.72015846e-02f, -2.48927157e-02f, 4.48298156e-02f, -8.89117271e-02f, 2.81744990e-02f, -3.39247733e-02f, -5.41889258e-02f,
  6.14436977e-02f, -4.39131521e-02f, -1.50107434e-02f, 1.59128364e-02f, -8.94908682e-02f, -9.54418629e-03f, -1.46999629e-02f, -7.19172284e-02f, 6.80483878e-02f, -4.49125767e-02f,
  -8.22474528e-03f, 8.37041624e-03f, -2.58584470e-01f, -8.89991373e-02f, -1.04974210e-01f, 1.77609548e-03f, -1.02859887e-03f, -8.00785199e-02f, -1.59956366e-01f, 1.61801744e-02f,
  1.61339700e-01f, 1.08142212e-01f, 7.82953203e-02f, 3.61413918e-02f, 9.78499353e-02f, 8.92324001e-02f, 3.94090265e-02f, 1.01308882e-01f, 1.01202711e-01f, 1.09977223e-01f,
  3.20017487e-02f, 1.56348959e-01f, 8.30608979e-02f, -5.02351522e-02f, 9.49701220e-02f, 5.24323620e-02f, 9.30976570e-02f, 3.71403582e-02f, 1.41082481e-01f, 1.92962334e-01f,
  1.40681610e-01f, 5.60456477e-02f, 5.72856329e-02f, 9.89722610e-02f, 1.36814313e-02f, 1.01686634e-01f, 1.61279216e-01f, 1.38998985e-01f, 1.25933260e-01f, 5.50697520e-02f,
  1.54792100e-01f, -1.34350479e-01f, 4.54066647e-03f, -7.74240941e-02f, -5.31862397e-03f, -3.20243202e-02f, -8.88595264e-03f, -3.20543419e-04f, -8.68249219e-03f, -5.33188954e-02f,
  -1.81254551e-01f, -8.66159424e-02f, 9.00416374e-02f, -1.10427886e-01f, -7.52297342e-02f, -1.93422675e-01f, -1.11284526e-02f, 2.98122521e-02f, -7.27205202e-02f, -1.41434371e-01f,
  -8.79141614e-02f, -1.05178691e-02f, -1.14286631e-01f, -6.21598624e-02f, 5.00672683e-03f, 5.17559657e-03f, -3.22893672e-02f, -9.72360224e-02f, -2.02999040e-02f, -1.02371713e-02f,
  8.92806947e-02f, -1.47332162e-01f, 7.64498720e-03f, -1.61685735e-01f, -2.61250548e-02f, -1.12823218e-01f, -8.84225518e-02f, -1.00449003e-01f, -1.34090573e-01f, -8.94333720e-02f,
  2.20448017e-01f, 1.31897554e-01f, 3.45696881e-02f, -3.50332484e-02f, -4.09196727e-02f, -7.15969652e-02f, -1.49082735e-01f, 6.76500946e-02f, 9.53408033e-02f, 6.74629118e-03f,
  -1.62606284e-01f, 2.74278577e-02f, 1.04425818e-01f, -1.20712437e-01f, 1.45902067e-01f, 5.67422211e-02f, 2.69013140e-02f, 2.24075705e-01f, 2.33196482e-01f, 2.82072246e-01f,
  1.04598172e-01f, 1.32383466e-01f, -6.04660134e-04f, 1.87670946e-01f, 2.79540159e-02f, -1.08807767e-02f, 4.13733795e-02f, 1.09206028e-01f, -1.46408640e-02f, 2.65150927e-02f,
  1.54529750e-01f, 4.80658002e-03f, 8.18221793e-02f, -1.57513805e-02f, 2.81355213e-02f, -3.78975831e-02f, 3.99202220e-02f, 1.40633481e-02f, -2.66441070e-02f, 6.66371360e-02f,
  4.48390320e-02f, 2.93647498e-01f, 2.28808761e-01f, 8.95131528e-02f, 1.21742561e-01f, 1.46077484e-01f, 2.26583362e-01f, 6.36869222e-02f, 1.20290153e-01f, 3.47395726e-02f,
  -1.66131873e-02f, 1.71015516e-01f, 5.80893159e-02f, -7.74970800e-02f, -1.76515803e-01f, 3.85127515e-02f, 1.00667760e-01f, 3.57784145e-02f, -1.13720879e-01f, -7.59598389e-02f,
  2.95069884e-03f, -4.46742363e-02f, -3.52623430e-03f, -4.58824299e-02f, 2.89096776e-02f, 9.54956096e-03f, -8.20949078e-02f, 4.06371206e-02f, 4.21111621e-02f, -2.26660650e-02f,
  9.25448723e-03f, -1.89184919e-02f, 2.05248222e-02f, -4.85225208e-02f, 3.08035482e-02f, -5.84567674e-02f, -2.29732674e-02f, 2.46652830e-02f, -8.65685120e-02f, -7.85054713e-02f,
  -2.55579114e-01f, -5.57926185e-02f, -9.74459425e-02f, 6.25683144e-02f, -5.90756116e-03f, -1.06157973e-01f, -9.58189555e-03f, -7.90565610e-02f, 1.55762583e-02f, -5.76367183e-03f,
  3.11316885e-02f, 2.73624584e-02f, 5.28554842e-02f, 7.29540586e-02f, 3.95096838e-02f, 7.87833109e-02f, -8.38256627e-02f, 3.73327099e-02f, -5.43109924e-02f, -5.90006970e-02f,
  -1.98257923e-01f, 8.84362403e-03f, -4.51507941e-02f, -1.00302070e-01f, 1.75201843e-04f, 3.08579803e-02f, -2.11356003e-02f, 2.37294212e-02f, -6.51774108e-02f, -2.18070999e-01f,
  -4.96754702e-03f, -1.14499860e-01f, 1.07378080e-01f, -1.06189206e-01f, -1.31751196e-02f, -6.48149289e-04f, 3.37224789e-02f, -1.08271055e-01f, -2.43958786e-01f, -1.11246824e-01f,
  -1.68895215e-01f, -1.18488386e-01f, -9.36796367e-02f, -1.35726303e-01f, -9.68395732e-03f, 3.35688815e-02f, 1.59056604e-01f, 2.16402151e-02f, 8.51295441e-02f, -1.78224698e-01f,
  -1.64996177e-01f, -8.44014063e-02f, -5.88305853e-02f, -1.24069065e-01f, -2.27823317e-01f, -1.77790359e-01f, -3.97792980e-02f, -5.30522354e-02f, -2.93362103e-02f, 8.79496336e-02f,
  -1.01781987e-01f, -8.86989683e-02f, -6.32712319e-02f, -9.12001133e-02f, -8.66015777e-02f, 5.11809303e-05f, -1.05997093e-01f, -2.90838853e-02f, -7.80969560e-02f, -1.36311099e-01f,
  -1.36293590e-01f, -1.33404002e-01f, -1.50911883e-01f, -1.03255130e-01f, 7.40127871e-03f, -1.22774616e-01f, -4.75730151e-02f, -3.99707481e-02f, 1.62440166e-02f, -6.69956431e-02f,
  -2.12784857e-01f, 4.40271646e-02f, 2.87390463e-02f, -7.86218643e-02f, -1.31495565e-01f, -4.27331217e-02f, -1.87135175e-01f, -1.55198589e-01f, -1.46422952e-01f, -1.01250306e-01f,
  -7.75215635e-03f, 4.12566476e-02f, 2.64872070e-02f, 1.99979767e-02f, -1.62623614e-01f, 1.29302628e-02f, 1.52219608e-01f, 4.73762155e-02f, -1.38555840e-02f, -2.32006442e-02f,
  1.60604473e-02f, 5.08638844e-02f, 6.20871931e-02f, -5.08562336e-03f, 2.93265209e-02f, 1.14802480e-01f, 3.41870785e-02f, -1.76496394e-02f, 4.33542952e-02f, 6.53512925e-02f,
  3.60279270e-02f, 9.65415165e-02f, 1.28421947e-01f, 3.65963504e-02f, 1.02957353e-01f, -3.94966174e-03f, 1.16160966e-01f, -6.83458298e-02f, -1.14524938e-01f, 6.25495091e-02f,
  -3.21268141e-01f, -6.95605054e-02f, -7.03995228e-02f, -1.78385824e-01f, -2.52562612e-01f, -1.17372349e-01f, -8.39320123e-02f, -1.72331557e-01f, 1.45684844e-02f, -2.49265153e-02f,
  -1.12266198e-01f, -1.83830515e-01f, -1.11973122e-01f, -1.06150068e-01f, 3.75861041e-02f, -1.41168132e-01f, -2.77668476e-01f, -5.06817438e-02f, -1.37644991e-01f, -1.83796376e-01f,
  -1.01284571e-01f, -1.11338243e-01f, -1.33477211e-01f, -1.07022457e-01f, -1.90531865e-01f, -2.25171503e-02f, -2.63169408e-01f, -1.68112963e-01f, -1.85658604e-01f, -2.19117373e-01f,
  -4.40898806e-01f, 1.62810966e-01f, -3.81297231e-01f, -1.14895381e-01f, -1.84488297e-01f, -2.12722421e-01f, -1.80629715e-01f, -1.95696186e-02f, 1.72656044e-01f, -1.89366844e-02f,
  -6.80582523e-02f, 1.68906689e-01f, 2.37218905e-02f, 5.41195124e-02f, 4.54685576e-02f, -2.90756673e-02f, -5.24454601e-02f, -1.08995512e-01f, -8.96872133e-02f, 4.98676673e-02f,
  1.02267638e-01f, 2.71407329e-02f, 4.05439660e-02f, 5.27163893e-02f, 2.06511334e-01f, 1.46754131e-01f, 2.79524419e-02f, -7.86896702e-03f, 9.76163372e-02f, 2.18952343e-01f,
  7.40792649e-03f, 5.13047818e-03f, 4.25142981e-02f, 1.24298610e-01f, -5.47242463e-02f, -6.71546627e-03f, -7.45183751e-02f, -6.55224100e-02f, 3.68704572e-02f, 8.94007236e-02f,
  -5.94496876e-02f, 9.92363039e-03f, 3.31757814e-02f, 1.13308184e-01f, 2.48358455e-02f, 6.61664829e-02f, 2.04411671e-01f, 2.83600464e-02f, -1.08476216e-02f, 1.53768556e-02f,
  1.50321767e-01f, -2.91065890e-02f, -1.32820770e-01f, 4.99936566e-02f, -8.70982334e-02f, -1.40572004e-02f, 1.38289295e-02f, 1.14460878e-01f, 4.67644446e-02f, 1.61912188e-01f,
  2.08619218e-02f, -1.14053534e-02f, -8.88444856e-03f, 2.04649363e-02f, -7.98786152e-03f, -4.81747426e-02f, -4.81688455e-02f, -1.10609792e-01f, 2.81920787e-02f, 1.16632953e-02f,
  -6.07570931e-02f, 3.99123430e-02f, 5.78973144e-02f, -9.93345752e-02f, 1.91452391e-02f, -1.39675066e-01f, -9.55527127e-02f, 1.37996580e-03f, 1.08497087e-02f, -1.04697846e-01f,
  -4.12376896e-02f, -1.30722553e-01f, -9.68376622e-02f, 4.92377840e-02f, -5.43760844e-02f, -6.71751052e-02f, -1.94604412e-01f, -2.87009068e-02f, 1.05052218e-02f, -2.10825384e-01f,
  2.58945346e-01f, -8.41992050e-02f, -5.22152185e-02f, 2.42180917e-02f, -1.03604279e-01f, 6.05329797e-02f, 2.16658469e-02f, -6.29758239e-02f, -5.08106919e-03f, -1.76922735e-02f,
  8.10050685e-03f, 3.29492912e-02f, 6.55350089e-02f, 2.65388004e-02f, 3.94105278e-02f, 2.15011425e-02f, 6.06706813e-02f, -1.44138709e-01f, 3.50653045e-02f, -9.83010512e-04f,
  1.24661252e-01f, -1.60033442e-02f, -1.17428683e-01f, -1.06593989e-01f, -8.22095107e-03f, -8.25838968e-02f, -9.66457650e-03f, -1.30556226e-01f, -1.56480417e-01f, -3.29829268e-02f,
  -1.96667939e-01f, 1.14969313e-01f, 2.15801716e-01f, -1.80655479e-01f, -2.49833763e-02f, 3.74195958e-03f, 7.62463212e-02f, -1.77301437e-01f, -1.85182944e-01f, -5.37496507e-02f,
  -9.17969719e-02f, -1.67084679e-01f, -2.25168824e-01f, -7.20324814e-02f, -1.53613631e-02f, 1.46504611e-01f, 1.17279597e-01f, 1.57918241e-02f, -2.00895399e-01f, -1.43579721e-01f,
  -1.63231298e-01f, -9.76045877e-02f, -1.19266979e-01f, -7.12783635e-02f, 1.97593734e-01f, -2.40397602e-02f, 1.66888326e-01f, 8.18723142e-02f, 1.12253927e-01f, 3.60126585e-01f,
  1.20934539e-01f, 7.81684443e-02f, 1.17930155e-02f, -1.00636706e-02f, -1.29964709e-01f, -9.08974931e-02f, -1.79932848e-01f, -4.95654978e-02f, 3.63815390e-03f, 5.05560078e-03f,
  -7.46671110e-02f, -9.56035331e-02f, -2.72937771e-02f, -2.68292651e-02f, -9.90237966e-02f, -3.22036780e-02f, 5.09640388e-02f, -5.20884320e-02f, 7.90051445e-02f, -9.80198905e-02f,
  -1.06797472e-01f, -3.43487784e-02f, -1.33008901e-02f, -8.47349763e-02f, -8.08162317e-02f, -2.75454577e-02f, 8.77641961e-02f, -1.08259685e-01f, 7.87248984e-02f, -2.76257005e-03f,
  -4.87501398e-02f, 1.10642701e-01f, 5.33832721e-02f, -3.72259803e-02f, -2.88043804e-02f, 7.60246143e-02f, 1.15756109e-01f, -6.22955672e-02f, 8.04868899e-03f, -2.79142074e-02f,
  -4.22403552e-02f, -1.09251365e-02f, -5.37880510e-02f, -1.30939344e-03f, 3.44847515e-02f, -5.35623357e-03f, -8.89477506e-03f, -8.24598595e-02f, 2.43166517e-02f, -1.05643296e-03f,
  3.04106940e-02f, 8.13446492e-02f, -9.23672318e-02f, 5.22423200e-02f, 8.52365792e-02f, 8.38188902e-02f, 4.25926745e-02f, -1.18420772e-01f, -5.22608459e-02f, 4.45715897e-03f,
  -3.10894251e-01f, -3.67090758e-03f, -5.30746952e-02f, -1.46509092e-02f, 5.98159954e-02f, -1.08022511e-01f, 1.51553033e-02f, -9.82481390e-02f, 3.66973542e-02f, -6.18499368e-02f,
  -7.07120076e-02f, -6.54546842e-02f, -1.76869500e-02f, -1.09272888e-02f, -1.14420325e-01f, 4.74649062e-03f, -1.39110774e-01f, -6.54834434e-02f, 9.53512937e-02f, -7.59964958e-02f,
  -3.67739871e-02f, -1.17300175e-01f, -1.45193025e-01f, -1.24989729e-02f, 4.28316817e-02f, -1.30323201e-01f, -4.02245894e-02f, -9.10368115e-02f, -1.85711458e-01f, -1.85200915e-01f,
  2.79311925e-01f, -1.61468044e-01f, 1.33851245e-01f, -7.98962452e-03f, -1.84585243e-01f, -1.99039847e-01f, -2.56349385e-01f, -1.87096819e-01f, -4.93295081e-02f, -1.17742479e-01f,
  -1.46888912e-01f, 3.67654674e-02f, 1.23941541e-01f, -5.03728911e-02f, 2.37687267e-02f, -2.53966421e-01f, -1.07479855e-01f, 8.69418606e-02f, 6.34566098e-02f, -2.29175180e-01f,
  -2.72465289e-01f, -3.06619462e-02f, 3.32127325e-02f, 7.64159411e-02f, -2.68478423e-01f, -1.58765316e-01f, -9.44256783e-02f, -9.08117965e-02f, -4.79390994e-02f, -6.87193871e-02f,
  1.20256878e-01f, 3.65248546e-02f, -1.51590845e-02f, -9.34834257e-02f, -7.92275742e-02f, 8.61624107e-02f, -6.40418306e-02f, 2.71352027e-02f, -6.06458820e-02f, -2.15248000e-02f,
  -9.27309692e-02f, 4.56123091e-02f, 1.02247894e-01f, -4.81380671e-02f, -9.06849056e-02f, -8.66725445e-02f, -1.01378821e-01f, 7.44401813e-02f, 4.41138372e-02f, -2.27231905e-02f,
  1.40271196e-02f, -9.52700227e-02f, -5.03386483e-02f, -1.82797704e-02f, -6.23624213e-02f, -2.85564438e-02f, -1.12288691e-01f, -1.12223081e-01f, -2.18673311e-02f, -4.54100780e-02f,
  -3.57775949e-02f, 8.13410655e-02f, 4.20248918e-02f, -7.65831098e-02f, -1.14784032e-01f, 2.04748176e-02f, 9.05323103e-02f, -4.90882844e-02f, -3.80185060e-02f, -1.18185826e-01f,
  2.45487187e-02f, -3.24536324e-03f, -1.26420692e-01f, 9.86974910e-02f, 8.31526294e-02f, 8.73519927e-02f, -4.56811860e-02f, 1.03555121e-01f, 1.03633769e-01f, -7.11058266e-03f,
  -6.93491474e-02f, -2.42400188e-02f, 3.75428088e-02f, -1.87159982e-02f, 6.48176819e-02f, 8.91967714e-02f, -2.78912503e-02f, 8.88748243e-02f, 1.00167371e-01f, -1.72746517e-02f,
  -4.79202680e-02f, 1.05819413e-02f, -8.74970630e-02f, -6.28271028e-02f, -1.69868588e-01f, 7.36589031e-03f, -7.27732107e-03f, -1.24795118e-03f, -3.77280936e-02f, -2.69651823e-02f,
  -5.67925386e-02f, -6.20342158e-02f, -2.41507199e-02f, -5.43830059e-02f, -1.30078912e-01f, -9.27015319e-02f, -2.07491487e-01f, -1.06444573e-02f, -6.88199848e-02f, -4.53517474e-02f,
  -9.42302793e-02f, -2.08266884e-01f, -1.81597203e-01f, -1.32683218e-01f, -6.70584217e-02f, -1.01559937e-01f, -4.03441228e-02f, -2.48090297e-01f, -1.20201968e-01f, -3.31395477e-01f,
  -7.07459897e-02f, 3.14600587e-01f, 3.25812865e-03f, -1.13621689e-01f, 7.09180310e-02f, 6.86583295e-02f, 3.30872357e-01f, -9.75836143e-02f, -1.52150184e-01f, 6.22764081e-02f,
  4.19855937e-02f, -2.81171858e-01f, -1.37074217e-01f, -1.61195457e-01f, -8.22509229e-02f, 2.89202183e-01f, 1.15575716e-01f, -4.03917730e-02f, -2.46750236e-01f, 8.01194273e-03f,
  1.15249060e-01f, 8.57146606e-02f, -1.94573775e-01f, -1.85542041e-04f, 2.38516510e-01f, -4.38898131e-02f, 1.92212090e-01f, 4.57297713e-02f, 1.96895927e-01f, 3.79984736e-01f,
  2.35852413e-02f, 1.33245468e-01f, -1.26218364e-01f, 4.52144071e-02f, 1.23126410e-01f, -4.60355403e-03f, 1.38100758e-01f, 7.36463908e-03f, -6.49182051e-02f, 1.05766900e-01f,
  -6.04939237e-02f, -1.75484596e-03f, -5.60290962e-02f, 9.48408172e-02f, 7.37126023e-02f, -3.71753238e-02f, -7.12476373e-02f, 5.19046262e-02f, -8.32549483e-02f, 9.29658534e-04f,
  1.30082443e-01f, 1.27010107e-01f, 1.34417549e-01f, 3.40076238e-02f, -7.56601915e-02f, -1.14007981e-03f, 6.28802851e-02f, -1.76035482e-02f, -3.96060012e-03f, 2.29329482e-01f,
  5.32386005e-02f, -6.62663728e-02f, -5.92485890e-02f, -1.12790111e-02f, -5.18660410e-04f, 5.19833788e-02f, -4.92781289e-02f, 3.66135649e-02f, 1.88620519e-02f, -2.52094376e-03f,
  -4.30108467e-03f, 3.11251376e-02f, -3.34413424e-02f, -7.74253719e-03f, 4.69258688e-02f, 7.67294839e-02f, 6.82168826e-02f, 5.95052205e-02f, 2.59374287e-02f, 1.10721355e-02f,
  -2.37872172e-03f, 1.92042887e-02f, -9.18215960e-02f, 2.34200037e-03f, 2.01104069e-03f, -8.16008896e-02f, -5.62047586e-04f, -2.13289121e-03f, 5.95694669e-02f, 1.41585693e-01f,
  -3.34296003e-02f, -1.27615690e-01f, 3.86397243e-02f, -9.12282169e-02f, 2.88600493e-02f, 7.01284781e-03f, 5.85921854e-02f, 5.07829227e-02f, -7.73692597e-03f, -5.00097834e-02f,
  -5.69702201e-02f, 9.18737426e-03f, 5.02453819e-02f, -1.35698214e-01f, -8.04116204e-03f, -3.86622027e-02f, 6.85722828e-02f, -1.79922674e-02f, 4.40016687e-02f, -1.31043345e-02f,
  2.14557890e-02f, -1.67565830e-02f, 2.04505995e-02f, -3.41391750e-02f, -5.39110452e-02f, -3.96448970e-02f, -1.14132212e-02f, 1.26711177e-02f, -3.35682034e-02f, 1.11696519e-01f,
  4.17019735e-04f, -5.14297962e-01f, 3.35185565e-02f, -1.08571611e-02f, 2.76152436e-02f, 1.07548878e-01f, -1.34754330e-01f, -1.25237226e-01f, -3.65162641e-02f, -2.18270108e-01f,
  3.00703235e-02f, 1.14074856e-01f, 2.79606003e-02f, 6.49711490e-02f, -4.26495168e-03f, -2.07764491e-01f, -1.36879891e-01f, 7.42512718e-02f, 4.07847375e-01f, 1.84485465e-01f,
  1.60653219e-02f, -9.81656089e-03f, 4.10042703e-02f, -7.41421655e-02f, -1.94749102e-01f, 7.37033039e-02f, -9.36591849e-02f, -9.98950824e-02f, -7.12771341e-03f, -1.55143589e-01f,
  -4.61363904e-02f, -2.23650932e-01f, 2.60072853e-02f, 3.30060720e-02f, 2.39224806e-02f, -7.03007728e-02f, -9.87356156e-02f, -8.55042562e-02f, 6.67322725e-02f, -1.11632824e-01f,
  1.25780618e-02f, -5.63435331e-02f, 1.30174473e-01f, 1.86417550e-02f, 4.10738820e-03f, 1.29346615e-02f, -8.09698924e-02f, -9.42068920e-02f, 4.80144434e-02f, -6.43150136e-02f,
  -8.73062015e-02f, 1.14032373e-01f, 4.94322591e-02f, -5.88952154e-02f, 2.29929145e-02f, 2.19715208e-01f, -8.39656442e-02f, 4.65910137e-02f, 9.26182196e-02f, -1.60584912e-01f,
  5.99978305e-02f, 5.40356115e-02f, 7.52683058e-02f, -1.71216339e-01f, 1.03176117e-01f, 2.86914334e-02f, 4.99339849e-02f, -5.45476601e-02f, 1.79040823e-02f, -1.27435043e-01f,
  9.02119502e-02f, -6.95169196e-02f, -5.62050343e-02f, -4.97257113e-02f, 1.62487924e-02f, 4.29511070e-02f, -3.38614732e-02f, -1.60340257e-02f, 3.26300934e-02f, -2.27718629e-04f,
  4.73243892e-02f, -3.22862901e-02f, 1.00577269e-02f, 2.60185562e-02f, 4.33958732e-02f, 4.01192270e-02f, 2.21445318e-02f, -5.45439981e-02f, 2.22922564e-02f, -1.04449049e-01f,
  8.30105320e-02f, 4.18404154e-02f, -2.34828405e-02f, 7.95280561e-03f, 1.21949553e-01f, 9.93385240e-02f, -7.56406188e-02f, -4.76158895e-02f, 2.48351451e-02f, -4.82589193e-02f,
  6.68438450e-02f, -6.17659353e-02f, -1.49557944e-02f, -1.10289581e-01f, -2.85721067e-02f, 6.73497841e-02f, 7.72298547e-03f, 4.04744670e-02f, 2.21370403e-02f, -2.47124527e-02f,
  -6.98904544e-02f, 4.03236635e-02f, 1.29458621e-01f, 3.50890756e-02f, 7.10232649e-03f, 9.64199677e-02f, 2.85700411e-02f, 1.12542920e-01f, 1.99267089e-01f, -7.98154902e-03f,
  5.65292776e-01f, -2.17207327e-01f, 2.38910154e-01f, 3.97888161e-02f, -3.14425647e-01f, -9.57231373e-02f, 9.66095086e-03f, -9.37991664e-02f, -1.13221020e-01f, -2.08358064e-01f,
  -2.46347025e-01f, -1.94735214e-01f, -1.15761936e-01f, -1.19261801e-01f, 1.94419578e-01f, 2.27776617e-02f, 1.27493804e-02f, 4.50153768e-01f, 2.93586075e-01f, -4.58058640e-02f,
  -2.22491294e-01f, 7.97901396e-03f, 2.26586834e-01f, -2.78521068e-02f, -1.71877116e-01f, -2.97665186e-02f, -6.67068511e-02f, -2.52114586e-03f, -1.47586882e-01f, -3.21255848e-02f,
  1.92791805e-01f, 1.20652884e-01f, 4.73583415e-02f, 3.40073481e-02f, -5.04709221e-02f, 5.69696538e-02f, 9.66507941e-02f, 4.69810404e-02f, -4.97733578e-02f, 8.87051523e-02f,
  -1.11403719e-01f, 3.41769948e-04f, 6.08501881e-02f, -3.30849923e-02f, 5.31345606e-02f, -3.84562984e-02f, 6.22830391e-02f, 2.10887924e-01f, 1.33260414e-01f, 1.88150760e-02f,
  -1.08718015e-01f, 1.52979232e-02f, 1.02015853e-01f, -3.67387086e-02f, 1.33493274e-01f, -6.82452088e-03f, -1.92350075e-02f, 9.60671750e-04f, 9.34392363e-02f, 8.74200463e-02f,
  -1.24064438e-01f, -4.63169272e-04f, -1.08702909e-02f, 8.73458385e-02f, -1.25141512e-03f, 9.56451055e-03f, 3.92534845e-02f, -7.96876326e-02f, -4.05650400e-02f, -2.82013528e-02f,
  2.02110764e-02f, 7.16766864e-02f, -8.42686091e-03f, 7.85221085e-02f, -3.27011310e-02f, 1.67916976e-02f, 4.99747060e-02f, 3.48033682e-02f, -7.62072280e-02f, -3.55206802e-02f,
  1.03748754e-01f, 4.01176848e-02f, -4.97684292e-02f, 9.21373889e-02f, 7.08971396e-02f, -1.15830339e-02f, 2.58807391e-02f, 1.89948529e-02f, -2.08911747e-02f, -4.39555645e-02f,
  1.92939639e-02f, 1.19404905e-01f, 4.79895435e-02f, 1.84814036e-02f, -5.29710315e-02f, 3.29377204e-02f, 4.79767844e-02f, 7.14216381e-02f, 9.57722440e-02f, 4.89756130e-02f,
  -2.76534841e-03f, 9.96457338e-02f, -9.90427751e-03f, 1.79430563e-03f, -3.00106965e-02f, -6.44960767e-03f, -6.48005307e-02f, 4.54444326e-02f, 5.87909184e-02f, -1.81689098e-01f,
  -7.77512789e-02f, 7.80154616e-02f, 5.88430017e-02f, -4.98780888e-03f, -1.10918410e-01f, 5.61618321e-02f, 8.91866088e-02f, -5.96740805e-02f, 1.83966428e-01f, 2.71615870e-02f,
  2.38038823e-01f, 1.59862235e-01f, -1.30041480e-01f, 8.66864771e-02f, -2.70171762e-01f, -1.41039580e-01f, -1.75822943e-01f, 9.32415053e-02f, 4.07520384e-02f, -6.02650531e-02f,
  -2.03806553e-02f, 1.15335479e-01f, 6.88630491e-02f, 2.00776994e-01f, 2.31681406e-01f, -1.95650280e-01f, -7.43143857e-02f, -1.35535533e-02f, 8.25471953e-02f, -7.84378126e-02f,
  -1.35852724e-01f, 2.82942951e-02f, 1.94908068e-01f, -1.26932645e-02f, -2.11984903e-01f, -1.47002697e-01f, -2.34779134e-01f, -9.45306346e-02f, -9.10719205e-03f, -1.45789668e-01f,
  -8.62345174e-02f, 9.49436054e-02f, -4.83661480e-02f, 1.16030060e-01f, -5.71622401e-02f, 5.92390373e-02f, 6.43644780e-02f, 4.60999385e-02f, 1.14163525e-01f, 9.87893865e-02f,
  5.83801307e-02f, 1.54009432e-01f, 1.68856263e-01f, 6.73288628e-02f, 3.46288159e-02f, 8.05586651e-02f, 9.66671482e-02f, 1.75248384e-01f, 1.34625718e-01f, 3.11709512e-02f,
  -1.61497723e-02f, 5.35630584e-02f, -3.12965550e-02f, 1.23894826e-01f, 1.15401223e-01f, 6.90344274e-02f, 1.09375961e-01f, 1.83905140e-01f, 1.87284619e-01f, 1.00281335e-01f,
  1.51096154e-02f, -2.13642209e-03f, 1.63867939e-02f, -7.04400754e-03f, -7.79392347e-02f, -3.77361998e-02f, 1.07607022e-02f, -1.88857168e-02f, 1.10873859e-02f, 6.93481192e-02f,
  1.83999658e-01f, -6.54472187e-02f, 9.83274430e-02f, 5.50990999e-02f, -4.75980826e-02f, 4.95115854e-02f, 1.30724097e-02f, 1.00332052e-01f, 1.98559668e-02f, -3.78239527e-02f,
  4.94732745e-02f, 6.79105818e-02f, -2.18537240e-03f, 1.39249682e-01f, -1.45743620e-02f, -2.77357213e-02f, -6.19439110e-02f, 1.07657693e-01f, 6.54511973e-02f, -2.52016801e-02f,
  1.55541539e-01f, 8.01533833e-02f, -1.05060525e-02f, 1.08675212e-01f, -9.59202647e-03f, -1.05837183e-02f, 3.45271220e-03f, -2.65763737e-02f, -1.07704448e-02f, 5.53366430e-02f,
  -1.82290450e-02f, 1.50243059e-01f, 3.67887132e-02f, 9.46012735e-02f, -1.98699292e-02f, -6.90518469e-02f, 6.01555482e-02f, 5.24029545e-02f, 1.05192915e-01f, 5.91666922e-02f,
  -3.05744186e-02f, 4.77720387e-02f, -1.81115698e-02f, -3.64439338e-02f, -8.39026719e-02f, -1.23677127e-01f, -1.09535918e-01f, -1.08454250e-01f, 4.35897559e-02f, -1.05565898e-01f,
  9.14136842e-02f, -1.88729361e-01f, -1.87656819e-03f, 9.30697937e-03f, -1.75551344e-02f, 1.28318027e-01f, -4.69451025e-02f, 1.17194496e-01f, 2.31085926e-01f, -1.90639317e-01f,
  -1.11647449e-01f, 1.26954287e-01f, -4.99189831e-02f, 4.60713916e-02f, 8.75654295e-02f, -2.24354804e-01f, -6.44198433e-02f, 1.32491127e-01f, 1.72138065e-01f, 2.03656346e-01f,
  1.24958274e-03f, -6.24440461e-02f, 2.36719269e-02f, 1.77602321e-01f, -1.48423165e-01f, -1.37509227e-01f, -2.74554193e-01f, -3.58973257e-02f, -2.14820430e-01f, -2.61875153e-01f,
  -1.79685295e-01f, 1.08974753e-02f, 2.70180451e-03f, -3.41088139e-02f, 3.71375866e-02f, -3.96745913e-02f, -7.20627233e-02f, 4.31519970e-02f, 9.85103473e-02f, 1.10401930e-02f,
  -8.98855105e-02f, 1.85295902e-02f, -3.50295007e-03f, 1.05994726e-02f, 1.53682642e-02f, 3.72468308e-02f, 4.70717736e-02f, -1.51306763e-01f, -4.88053747e-02f, 7.78517574e-02f,
  -3.52815166e-02f, -7.88136274e-02f, 1.07756006e-02f, -5.44066690e-02f, -4.44365591e-02f, -1.15788803e-02f, -4.33602817e-02f, 3.06902584e-02f, -4.97628003e-03f, -2.46322542e-01f,
  1.11354761e-01f, 1.14742152e-01f, 5.18946797e-02f, -4.86213155e-02f, -3.60903740e-02f, 7.36784935e-02f, 6.74026161e-02f, -8.18765908e-02f, 7.16365725e-02f, -3.59635651e-02f,
  7.38170296e-02f, -1.26584634e-01f, 9.14140716e-02f, 1.78857252e-01f, 7.43015558e-02f, -1.27876783e-02f, 7.36986846e-03f, 1.88755069e-03f, 1.39601767e-01f, -1.50914295e-02f,
  -4.62503582e-02f, 4.63699661e-02f, 4.06411253e-02f, 5.54168783e-02f, 5.39425673e-05f, 4.47772257e-02f, 3.42502748e-03f, 1.23259582e-01f, 1.33340387e-02f, -4.06556837e-02f,
  -5.49704693e-02f, -1.27504463e-03f, -1.39910355e-01f, 3.81832905e-02f, -9.43493471e-02f, 5.38316295e-02f, -3.91643774e-03f, 1.00915924e-01f, -3.07509657e-02f, 1.18953213e-02f,
  9.59927496e-03f, 4.31544259e-02f, 2.85522882e-02f, -2.68778671e-02f, 1.07733384e-02f, 4.08244394e-02f, -1.77604914e-01f, -6.76053390e-02f, 2.01105084e-02f, 6.60434365e-02f,
  6.49624169e-02f, 4.51752692e-02f, -1.86068952e-01f, -4.69711423e-02f, -1.36695644e-02f, -8.25446472e-02f, -1.79802209e-01f, -9.90498997e-03f, -4.35011908e-02f, -2.35498905e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.69514686e-02f, 6.74080942e-03f, 6.61122724e-02f, 1.27294853e-01f, 1.16888367e-01f, -5.62260412e-02f, -1.83202267e-01f, -3.57976228e-01f, 2.71852799e-02f, 6.21135458e-02f,
  1.69053897e-01f, 1.36129841e-01f, 2.17781868e-02f, -2.10326061e-01f, -4.44676310e-01f, -2.15586618e-01f, -1.47201464e-01f, -3.88139665e-01f, -5.58621824e-01f, -2.43989214e-01f,
  -8.20898488e-02f, -1.23133741e-01f, -1.71238124e-01f, -1.27222821e-01f, 3.13913703e-01f, 1.99756891e-01f, 2.40315482e-01f, 1.38451651e-01f, 1.74562141e-01f, 2.98112601e-01f,
  2.64219671e-01f, 9.85855982e-02f, -8.96599516e-03f, 1.73329845e-01f, 1.35689542e-01f, -9.13646519e-02f, -9.38233882e-02f, 2.01243572e-02f, 6.07345514e-02f, -4.09320071e-02f,
  2.34229624e-01f, 6.05065450e-02f, 9.65734348e-02f, 7.89652914e-02f, -2.42675588e-01f, -1.61969647e-01f, -1.64603278e-01f, -1.90524340e-01f, -5.78945316e-02f, -1.47967771e-01f,
  4.32336703e-02f, 6.53657317e-02f, -1.11465484e-01f, -1.47874281e-01f, -1.48207188e-01f, 2.94645932e-02f, -1.70581173e-02f, -6.40887469e-02f, -2.26160362e-01f, -5.20925969e-02f,
  -6.10748352e-03f, 5.93692884e-02f, 3.55404429e-02f, 3.97934057e-02f, -1.01645635e-02f, 1.47317454e-01f, 6.11842573e-02f, -3.95330526e-02f, 8.24753940e-03f, -4.58334647e-02f,
  -8.00614953e-02f, -3.54629420e-02f, -6.24055415e-02f, -8.91240016e-02f, -1.81655977e-02f, 1.24691455e-02f, -7.65050352e-02f, -1.67041153e-01f, -1.55472279e-01f, -3.64232734e-02f,
  -2.30655055e-02f, -2.73038801e-02f, 1.41409993e-01f, 4.60181758e-02f, 1.22111984e-01f, 6.86229160e-03f, 8.43297988e-02f, -1.07693352e-01f, 3.19122523e-02f, 5.76663576e-02f,
  -2.05800459e-02f, -7.57886097e-02f, 9.00784358e-02f, -8.67847353e-02f, 6.92549869e-02f, 1.41384810e-01f, 1.92877486e-01f, -1.69414449e-02f, 8.56802315e-02f, -1.11945644e-01f,
  -1.03211693e-01f, -3.36348750e-02f, 7.30638355e-02f, 6.15803758e-03f, -7.40173608e-02f, 2.65693001e-04f, -1.70364201e-01f, -5.18172123e-02f, -8.95935595e-02f, -3.16456296e-02f,
  -8.51151422e-02f, -2.93128699e-01f, -2.13412136e-01f, 1.27671123e-03f, -5.20721935e-02f, -4.38379347e-02f, 1.00765750e-01f, 4.40328084e-02f, -1.38296366e-01f, -3.07897031e-01f,
  -9.67547148e-02f, -1.28802747e-01f, 2.62363464e-01f, 1.61255077e-01f, 1.27823845e-01f, -1.19332865e-01f, -2.92723417e-01f, -2.54356772e-01f, -1.74160555e-01f, -8.06269199e-02f,
  1.04410231e-01f, 3.62350233e-02f, -3.22938301e-02f, -3.32513750e-02f, -2.37608358e-01f, -3.22858334e-01f, 7.52038509e-03f, 1.84078142e-01f, 7.26299733e-02f, -3.33705358e-02f,
  -1.91547461e-02f, 7.16415420e-02f, 1.57616898e-01f, 6.03503399e-02f, 1.73831180e-01f, 8.94864574e-02f, 4.45231646e-02f, 9.23994705e-02f, 1.25556961e-01f, 1.39016911e-01f,
  1.81338683e-01f, 2.01800570e-01f, 1.08486762e-04f, 7.60913715e-02f, 1.36566803e-01f, -1.15398489e-01f, 5.49865216e-02f, -1.94512457e-02f, -5.48946066e-03f, -4.90096807e-02f,
  1.71612173e-01f, 1.16875753e-01f, 6.36641458e-02f, 5.73023148e-02f, 9.26333442e-02f, 2.24214289e-02f, 1.05455995e-01f, -4.32797782e-02f, -5.41265532e-02f, -6.12016348e-03f,
  3.72915044e-02f, 1.60301968e-01f, 2.17495449e-02f, -4.40602228e-02f, -1.82011247e-01f, 1.32644773e-01f, 4.40961607e-02f, 1.24441318e-01f, 7.55181164e-02f, -5.59776090e-02f,
  7.91280344e-02f, -1.46052957e-01f, -1.09552052e-02f, 2.55699549e-02f, 1.43462811e-02f, 2.32401304e-03f, 1.90282613e-02f, -1.01018719e-01f, -6.22795559e-02f, -1.05418950e-01f,
  5.66958152e-02f, 1.94625207e-03f, -7.16293305e-02f, 1.34177312e-01f, 2.80294836e-01f, 1.41051099e-01f, 1.37913376e-01f, 2.59130716e-01f, 2.53753334e-01f, 1.38867036e-01f,
  7.05193058e-02f, 6.62894128e-03f, 5.44101484e-02f, 1.12528749e-01f, 7.60197639e-02f, 1.41433537e-01f, 2.13922590e-01f, -5.69181843e-03f, 5.28707504e-02f, 1.03072159e-01f,
  -1.18894935e-01f, 2.45997578e-01f, 2.85381638e-02f, -2.26132665e-02f, 1.06260411e-01f, 8.29361528e-02f, 1.98320955e-01f, 7.18980432e-02f, 2.10141391e-01f, 1.86879709e-02f,
  6.36179969e-02f, 9.62481126e-02f, 1.59128174e-01f, -2.97899302e-02f, -1.21323608e-01f, 1.49954960e-01f, 6.96269646e-02f, -5.12970164e-02f, -2.05336679e-02f, 8.90227854e-02f,
  9.74850729e-02f, -1.45290986e-01f, -1.60069242e-01f, -9.82898548e-02f, -6.53466862e-03f, 4.56614718e-02f, -3.97662856e-02f, 8.94519761e-02f, 1.04507655e-02f, -3.18875492e-01f,
  -4.05446351e-01f, -8.00296515e-02f, 2.61698700e-02f, 8.10182095e-02f, 1.64227381e-01f, 7.27667436e-02f, 2.10805282e-01f, 6.96391463e-02f, 9.98269916e-02f, 6.29125610e-02f,
  2.90687174e-01f, 3.24077487e-01f, 2.29152173e-01f, 1.98292106e-01f, 2.45028779e-01f, 8.04867893e-02f, -4.20990996e-02f, -5.17508984e-02f, 1.22784086e-01f, 2.82721519e-01f,
  9.79246274e-02f, 1.22807249e-01f, -4.58111949e-02f, -4.30771187e-02f, 9.03420523e-02f, 1.40708894e-01f, 1.43063575e-01f, 3.81587930e-02f, 2.06571639e-01f, -1.38234213e-01f,
  4.62408990e-01f, -1.47956178e-01f, 4.12496030e-02f, -1.07463837e-01f, -1.25109389e-01f, -3.00432205e-01f, -6.43290356e-02f, -1.01226149e-02f, -9.05964226e-02f, -2.12413948e-02f,
  3.90491448e-02f, -8.79738703e-02f, -1.46915810e-02f, -3.26274149e-02f, 5.95396711e-03f, -5.99837350e-03f, -6.34737685e-02f, 5.04213981e-02f, 2.10270673e-01f, 5.10026589e-02f,
  3.65573242e-02f, 8.02942589e-02f, 2.40243822e-01f, 1.66148275e-01f, 1.14459477e-01f, -2.31977403e-02f, 8.68635699e-02f, 2.60163601e-02f, 8.73090923e-02f, -8.97242799e-02f,
  6.99854866e-02f, 8.45384449e-02f, 1.48011535e-01f, 1.09373622e-01f, 8.42928216e-02f, 2.53488272e-02f, -2.49208733e-02f, 1.41746998e-01f, 1.13562927e-01f, -6.88998867e-03f,
  6.92766765e-03f, 1.00498326e-01f, 1.55423479e-02f, -1.00807492e-02f, 2.72527579e-02f, 5.23781776e-03f, -2.48578703e-03f, -6.82063866e-04f, -8.01200420e-02f, 8.88752863e-02f,
  7.51734450e-02f, 2.33051609e-02f, -1.63396761e-01f, -9.63944420e-02f, -2.47442611e-02f, 3.33964005e-02f, -6.38153702e-02f, 3.28374356e-02f, -4.39299159e-02f, -6.68432862e-02f,
  2.45354086e-01f, -3.71748880e-02f, -3.63075659e-02f, -4.20446508e-03f, -1.51379019e-01f, -1.95736542e-01f, 5.67408539e-02f, -3.14813927e-02f, -6.40348643e-02f, 6.96318448e-02f,
  8.80341157e-02f, -1.55084744e-01f, -8.06827694e-02f, -7.04692528e-02f, -5.88292554e-02f, -1.81984976e-02f, -7.04402775e-02f, 1.63971812e-01f, 9.15675797e-03f, -1.03900284e-01f,
  -1.57618716e-01f, 2.42967486e-01f, 3.33552122e-01f, 8.28322992e-02f, 6.03330545e-02f, 4.12744693e-02f, -2.01952271e-03f, -2.18120776e-02f, 1.13551095e-01f, -7.14897290e-02f,
  3.87789726e-01f, 1.01886205e-01f, 4.58238959e-01f, 1.53525472e-01f, -4.60315822e-03f, 2.02402860e-01f, 3.92453879e-01f, 2.26553336e-01f, 2.31626518e-02f, -3.88569087e-02f,
  -1.89813226e-01f, -1.65756315e-01f, -1.59509346e-01f, -9.00796056e-02f, 1.22313477e-01f, 1.83686301e-01f, 1.30594954e-01f, 7.57394284e-02f, 1.33378848e-01f, 6.18665554e-02f,
  -7.73845538e-02f, -3.03882137e-02f, -4.76008095e-02f, 3.49830985e-02f, -1.72775686e-01f, -6.55980110e-02f, 1.07242242e-01f, 1.23880856e-01f, -5.53078949e-02f, -2.20716707e-02f,
  -5.77205457e-02f, 1.67734787e-01f, -1.29200622e-01f, -1.55137151e-01f, -6.80922642e-02f, 1.60604026e-02f, 6.60525784e-02f, 4.98446412e-02f, 1.06498793e-01f, 3.84817421e-02f,
  -4.93457690e-02f, -9.00752842e-02f, 7.52207339e-02f, 1.28414098e-03f, 3.41162011e-02f, 2.53187660e-02f, 5.96862882e-02f, 7.94215053e-02f, 2.32186273e-01f, -8.89114290e-02f,
  -1.18779436e-01f, 1.03112929e-01f, 1.20365322e-01f, 1.27352014e-01f, 2.44884536e-01f, 5.54108135e-02f, 1.37911169e-02f, 3.84126864e-02f, 8.57910812e-02f, 1.79200515e-01f,
  1.66445538e-01f, 1.28006041e-01f, -9.32947323e-02f, 1.16923496e-01f, 3.90141197e-02f, -7.23456731e-03f, -7.32014179e-02f, -6.07941039e-02f, 9.40511376e-03f, -8.74961168e-02f,
  -4.42490205e-02f, 1.62820488e-01f, 2.04896748e-01f, -7.57911950e-02f, -7.84934834e-02f, 1.21809602e-01f, -5.96769899e-03f, -6.27284274e-02f, -5.91740087e-02f, 1.84518081e-04f,
  3.43284160e-02f, 3.61711010e-02f, -4.48434167e-02f, -3.86903621e-02f, -1.04994416e-01f, 1.00651383e-01f, -2.60724947e-02f, -1.04018589e-02f, -4.61322404e-02f, -6.88846260e-02f,
  -2.60743797e-01f, 7.39255697e-02f, -8.67265910e-02f, -6.83300719e-02f, -3.35508734e-02f, -2.08292201e-01f, -5.34859207e-03f, -9.58781689e-02f, -7.77295008e-02f, -4.77783084e-02f,
  -9.68114510e-02f, 2.82535758e-02f, -3.10155377e-02f, 3.10210511e-02f, -4.02377993e-02f, -1.14112953e-03f, -1.82842523e-01f, 3.65030542e-02f, -1.83201581e-02f, -2.64121946e-02f,
  -1.09242849e-01f, 1.04028367e-01f, 5.73217832e-02f, 8.67502317e-02f, 4.99426899e-03f, -8.76961946e-02f, -1.56734526e-01f, -4.38173972e-02f, -9.36015695e-03f, -4.60681282e-02f,
  -8.86772990e-01f, 7.45529830e-02f, 1.67686939e-01f, -4.12134081e-01f, -4.88514341e-02f, 1.42407760e-01f, 2.15980053e-01f, -4.21598628e-02f, -2.73601800e-01f, 1.58808246e-01f,
  9.50420052e-02f, -1.95729911e-01f, -1.09799132e-01f, -6.49692714e-02f, -1.25197142e-01f, 1.17159948e-01f, -2.98497640e-02f, -2.13037461e-01f, -1.98476166e-01f, -3.16044912e-02f,
  -2.37110350e-02f, -4.68893468e-01f, -5.47785580e-01f, -2.34084919e-01f, -1.14971206e-01f, -2.15392247e-01f, -1.27070293e-01f, -1.67192519e-01f, 9.06176865e-02f, -7.27045685e-02f,
  3.42595965e-01f, 1.69279546e-01f, -1.82293765e-02f, -1.08289219e-01f, -2.35080719e-02f, -8.61699954e-02f, 4.84740287e-02f, -9.66311619e-02f, -4.04292792e-02f, 5.45950606e-02f,
  -6.85665458e-02f, -3.18815187e-02f, -1.02922291e-01f, 3.18375975e-02f, -6.58195093e-02f, -3.19220847e-03f, 5.26509583e-02f, 1.19634070e-01f, 1.12687223e-01f, 1.48123667e-01f,
  5.12786172e-02f, 1.78292483e-01f, 8.06659758e-02f, 1.47788540e-01f, 2.86004871e-01f, -1.07611390e-02f, 1.59680605e-01f, 1.08094729e-01f, 1.97218925e-01f, 1.47438452e-01f,
  -5.45983762e-02f, -2.82115582e-02f, 3.89691703e-02f, -6.32561669e-02f, 1.36962710e-02f, -1.67055000e-02f, -6.63580745e-02f, -6.37937710e-02f, -7.43651092e-02f, -1.43942714e-01f,
  1.26287580e-01f, 1.49200052e-01f, 1.17839932e-01f, -1.39789149e-01f, 4.94183451e-02f, -3.74369398e-02f, 2.82167811e-02f, 9.24208239e-02f, 1.86866999e-03f, 3.38701867e-02f,
  1.88152175e-02f, 2.01236997e-02f, -1.21016912e-01f, 3.97780091e-02f, 1.93949342e-01f, 1.23345785e-01f, 1.05553061e-01f, -8.38495418e-03f, -8.34267288e-02f, -9.70255118e-03f,
  -1.18559711e-01f, 1.09305099e-01f, -4.06488702e-02f, -9.70209986e-02f, -5.96222579e-02f, 6.04848936e-02f, 1.13681324e-01f, 8.31962526e-02f, 4.47444804e-02f, 1.98628604e-01f,
  8.96858275e-02f, -1.36043593e-01f, -9.17945430e-02f, 8.04993510e-03f, -1.60061821e-01f, -1.16230838e-01f, 4.11399677e-02f, -1.01696245e-01f, 7.96938762e-02f, 1.96784407e-01f,
  -3.01740728e-02f, 9.61639918e-03f, -9.78777111e-02f, -3.10939588e-02f, -2.19956925e-03f, -1.15173936e-01f, -5.91846816e-02f, -9.79189388e-03f, -4.88747135e-02f, -1.14590421e-01f,
  -3.37882549e-01f, 3.15065384e-01f, -1.95421606e-01f, -1.22883223e-01f, 8.43150243e-02f, 2.76531335e-02f, 3.19432408e-01f, 4.76262271e-02f, -1.33514171e-02f, 8.80921632e-02f,
  1.36374444e-01f, -3.68797332e-02f, 3.67143191e-02f, 5.25934249e-02f, 1.66956738e-01f, 3.46721530e-01f, 2.78378278e-01f, -1.54545635e-01f, -2.66509652e-01f, -9.77071598e-02f,
  1.62895441e-01f, -1.19689927e-01f, -3.30460697e-01f, -1.12450376e-01f, 9.57382396e-02f, -3.06515396e-02f, -6.72977269e-02f, -2.26853881e-02f, 1.51947260e-01f, 1.24319345e-01f,
  -2.34285191e-01f, -5.74259572e-02f, -7.26816207e-02f, 4.99921804e-03f, -1.81417279e-02f, -3.08853853e-02f, -2.62337481e-03f, -1.00084268e-01f, -1.20898105e-01f, -7.04396814e-02f,
  -4.49747182e-02f, -3.83150727e-02f, -1.25154659e-01f, -5.92355132e-02f, -2.06464633e-01f, -8.79082978e-02f, -6.72105551e-02f, -1.31215617e-01f, -1.69066682e-01f, -3.70249659e-01f,
  5.91227040e-02f, -1.13374725e-01f, -3.66846353e-01f, -6.92572594e-02f, -5.19380048e-02f, -8.24523643e-02f, -5.91458939e-02f, -1.23262741e-01f, -2.07895696e-01f, -1.10586815e-01f,
  1.33451773e-02f, -2.27016881e-02f, -7.40839925e-04f, 1.37161210e-01f, 9.56574753e-02f, 1.20205827e-01f, 1.09073937e-01f, 6.20568134e-02f, 1.16691835e-01f, -9.79162529e-02f,
  -6.01004027e-02f, -8.98142606e-02f, -7.92505145e-02f, 3.26945670e-02f, 4.37022485e-02f, 6.07377961e-02f, 5.27404957e-02f, -7.33020774e-04f, 7.50818029e-02f, 7.38911750e-03f,
  5.37903570e-02f, -8.70682150e-02f, 4.05862369e-02f, -9.17805731e-02f, -1.10705733e-01f, 1.41151696e-01f, 4.87977453e-02f, -7.32867606e-03f, -8.03008154e-02f, -5.55294417e-02f,
  -3.11218292e-01f, 5.23071811e-02f, -6.15959929e-04f, 1.02856770e-01f, -2.35195179e-02f, -1.26152530e-01f, 1.00842588e-01f, 9.30150449e-02f, -2.76408624e-02f, -2.01986834e-01f,
  7.45779127e-02f, -1.33461400e-03f, -6.48399666e-02f, -7.23586306e-02f, -1.61896363e-01f, -8.09893757e-02f, 1.29881799e-01f, -1.34624302e-01f, 1.37031123e-01f, -1.41682819e-01f,
  3.41249816e-02f, -1.26823662e-02f, -7.04175383e-02f, 2.09241770e-02f, 5.33445589e-02f, 7.27668926e-02f, 3.79512459e-02f, -6.18008561e-02f, 9.73919183e-02f, -9.56510827e-02f,
  7.46853590e-01f, 3.66999477e-01f, 3.12177837e-01f, 6.57663196e-02f, 1.71181351e-01f, 8.83225650e-02f, 2.39087388e-01f, 1.46249801e-01f, 5.77060215e-04f, 7.62643740e-02f,
  2.31655180e-01f, 1.64974138e-01f, 1.46547616e-01f, 1.09764874e-01f, 2.13366300e-01f, 1.11032151e-01f, -1.57166496e-01f, 6.42542914e-02f, 8.33947361e-02f, 9.27345902e-02f,
  -6.17272668e-02f, 3.07609290e-02f, 7.96654299e-02f, -5.49631640e-02f, -2.19182717e-03f, -1.58778261e-02f, -4.44414653e-03f, -3.30700651e-02f, -8.48720148e-02f, -1.50408164e-01f,
  -1.79687083e-01f, 3.35012674e-01f, -5.28947450e-02f, -7.63751045e-02f, -8.19752067e-02f, -1.17545471e-01f, 4.71085235e-02f, -9.68796909e-02f, -9.81251597e-02f, -7.34665841e-02f,
  -1.17360823e-01f, -7.11794868e-02f, -5.45768961e-02f, -6.39804825e-02f, -6.92599118e-02f, 2.31922735e-02f, -5.74523136e-02f, 2.89194696e-02f, 4.45772409e-02f, 5.91997243e-03f,
  4.93174270e-02f, 4.08702232e-02f, 1.18911296e-01f, 7.53517449e-02f, 1.32693708e-01f, 7.70267174e-02f, 1.10966615e-01f, 1.35788873e-01f, 1.43880889e-01f, 6.27392679e-02f,
  1.33993134e-01f, 1.47217706e-01f, 1.08992934e-01f, 2.12642863e-01f, 1.92918852e-01f, 8.94126967e-02f, -4.90551069e-02f, -1.10542171e-01f, -1.18003441e-02f, -8.45341682e-02f,
  6.26600161e-02f, 6.39851168e-02f, 4.67234924e-02f, 7.67869204e-02f, 9.07836407e-02f, 2.81660687e-02f, -4.42955159e-02f, 1.11478552e-01f, 8.83925930e-02f, -2.30587609e-02f,
  -2.22949069e-02f, 3.41843851e-02f, 3.79745029e-02f, 1.44744486e-01f, 9.96829644e-02f, 1.42078176e-01f, -3.02053392e-02f, 8.17104131e-02f, -8.37784447e-03f, 1.23181514e-01f,
  -6.41099930e-01f, 1.09513313e-01f, -1.16929226e-02f, 2.78177690e-02f, -7.69988969e-02f, -9.97047946e-02f, 7.83909261e-02f, -9.49855223e-02f, -1.08014718e-01f, -1.40239373e-01f,
  -1.30546004e-01f, -4.74843546e-04f, -2.76220199e-02f, -1.12511419e-01f, -1.14878759e-01f, -9.76480693e-02f, -3.27245891e-02f, 3.75692062e-02f, -4.09586355e-02f, -1.28046229e-01f,
  -7.33493967e-03f, -4.55607958e-02f, -1.32124960e-01f, -1.10223562e-01f, 1.78360473e-02f, -5.55952527e-02f, -1.30541623e-01f, 1.65437348e-02f, 1.32239028e-03f, -3.23264189e-02f,
  4.30129468e-01f, -1.22557074e-01f, 9.83307883e-02f, 1.99488103e-01f, 4.43751775e-02f, 2.70085391e-02f, -4.30511869e-02f, 3.34762931e-02f, 1.56423748e-01f, 9.87197012e-02f,
  2.35599831e-01f, 2.91141957e-01f, 1.69018567e-01f, 2.15847060e-01f, 1.39302969e-01f, 7.48240808e-03f, -2.40785684e-02f, 2.59427518e-01f, 2.54066437e-01f, 4.58336994e-02f,
  -6.05227388e-02f, -3.08685638e-02f, 1.31172929e-02f, 4.17237319e-02f, -1.65957496e-01f, 2.42970455e-02f, -1.25371441e-01f, -8.04730281e-02f, -1.44240901e-01f, -1.14747912e-01f,
  6.37398809e-02f, 7.21303746e-02f, 1.74830183e-01f, 8.81649181e-02f, 4.89795506e-02f, 9.62156355e-02f, 1.10772867e-02f, 5.96947223e-02f, 9.47961286e-02f, 1.39065787e-01f,
  6.16444461e-02f, -6.18545711e-02f, -1.73342794e-01f, -2.17673630e-02f, -1.63891077e-01f, -6.07683025e-02f, -8.57903361e-02f, 4.02125483e-03f, -2.75450274e-02f, -1.88975539e-02f,
  -1.67586565e-01f, 4.98411879e-02f, 8.18275884e-02f, -3.42390165e-02f, 2.44992338e-02f, 9.27630216e-02f, 5.88299520e-02f, 6.46682531e-02f, -2.82766800e-02f, -2.01410707e-02f,
  1.09918267e-01f, -2.60650571e-02f, -3.47696953e-02f, -7.28334263e-02f, -4.63710576e-02f, -3.44802849e-02f, 2.77161989e-02f, 3.22345793e-02f, 2.47496180e-02f, -1.34503469e-01f,
  -8.18600133e-02f, -2.45797355e-02f, -2.95283776e-02f, 3.71497162e-02f, -7.74670858e-03f, -1.22876577e-02f, 4.36235080e-03f, -4.74536419e-02f, 1.64205376e-02f, -2.47947015e-02f,
  -4.35207486e-02f, 7.71699613e-03f, -7.47833103e-02f, -1.33313522e-01f, -1.40017137e-01f, 6.56039491e-02f, -4.81209941e-02f, -2.25568786e-02f, 6.79826513e-02f, -1.80096943e-02f,
  -5.17351851e-02f, 9.33147892e-02f, 1.47403419e-01f, 8.06008801e-02f, -5.70784286e-02f, 4.23044451e-02f, 1.21117480e-01f, 1.07034490e-01f, 5.57035692e-02f, 4.88671660e-02f,
  -2.00843327e-02f, -7.96212757e-04f, -4.77727130e-02f, -1.41081899e-01f, -1.26663938e-01f, -2.96904128e-02f, -1.12106562e-01f, 6.25992194e-02f, 9.40449350e-03f, -1.47764347e-02f,
  -3.58673744e-02f, 7.76885897e-02f, 1.91647455e-01f, 1.48264021e-01f, 7.07404804e-04f, 2.23802269e-01f, 7.00756609e-02f, -1.62547994e-02f, -1.61819384e-02f, -1.25243187e-01f,
  -7.03357995e-01f, 2.71460563e-01f, 1.77569821e-01f, -2.64124900e-01f, 2.37287618e-02f, 2.35367715e-01f, 4.65153307e-01f, 1.17212065e-01f, -1.27196208e-01f, 1.49998873e-01f,
  1.35540381e-01f, -1.62406355e-01f, -8.63484666e-02f, -2.57948656e-02f, 1.60003945e-01f, 3.78045976e-01f, 1.49261206e-01f, -4.66433167e-02f, -1.26754820e-01f, -1.41244039e-01f,
  9.77580547e-02f, -2.47642770e-01f, -3.95394057e-01f, -1.41244426e-01f, -1.12390574e-02f, -1.52067002e-02f, 4.35232744e-03f, -8.60004351e-02f, 1.98204383e-01f, -1.83023959e-02f,
  -5.86543493e-02f, -1.94052681e-01f, 5.51351495e-02f, -9.05374438e-02f, -6.04368262e-02f, -6.02882840e-02f, 5.24826013e-02f, 3.96437049e-02f, -8.03716257e-02f, -3.84785645e-02f,
  7.32627213e-02f, -1.31684691e-01f, -5.92354052e-02f, 7.32560009e-02f, -2.48866919e-02f, 7.29861669e-03f, -1.23920299e-01f, 1.15365479e-02f, -1.16868794e-01f, -3.54322344e-02f,
  1.27422735e-01f, -8.73207375e-02f, -6.24850653e-02f, 5.15933335e-02f, 7.73431510e-02f, -1.45555317e-01f, 2.64676884e-02f, -1.97530001e-01f, -6.78658038e-02f, -1.05100267e-01f,
  -4.55628633e-02f, -1.60381887e-02f, -5.78043945e-02f, 1.69218064e-03f, -4.36753444e-02f, -8.86294097e-02f, -7.66433254e-02f, 9.02097076e-02f, 3.29140052e-02f, -2.02756356e-02f,
  9.92548391e-02f, 6.41005412e-02f, 7.80017301e-02f, 2.17140932e-02f, -2.94048153e-02f, 1.07929587e-01f, 8.50423127e-02f, -1.55267660e-02f, -2.18953472e-02f, 1.04117580e-02f,
  -3.92748639e-02f, -4.23802324e-02f, -6.85210899e-03f, -9.55672096e-03f, 6.87550008e-02f, 1.76274590e-02f, 1.50468960e-01f, 4.59775813e-02f, -9.38004907e-03f, 1.76217277e-02f,
  -2.78935730e-01f, 2.17208549e-01f, -1.71870384e-02f, 5.97387291e-02f, 9.00080726e-02f, 4.10691015e-02f, -7.02914316e-03f, 1.28716648e-01f, 5.70591353e-02f, -1.14627292e-04f,
  1.15587883e-01f, -5.19189099e-03f, 1.08552784e-01f, 3.10164839e-02f, 1.44968048e-01f, 1.15974575e-01f, 1.18318260e-01f, -1.10104956e-01f, 1.26309067e-01f, -9.44095850e-02f,
  5.73477186e-02f, -4.14492898e-02f, -5.99519424e-02f, 7.92441145e-02f, -1.71758253e-02f, -5.79046793e-02f, 2.34076723e-01f, -5.78997433e-02f, 8.88155028e-03f, 5.93747981e-02f,
  -1.69215426e-01f, -3.38078171e-01f, 8.05704072e-02f, 1.64863646e-01f, 3.06249738e-01f, 2.91277140e-01f, 2.94995785e-01f, 1.53500542e-01f, -1.59665644e-02f, 4.14505638e-02f,
  -3.26442868e-01f, -2.05886260e-01f, -2.82548219e-01f, -6.26281947e-02f, -4.51415554e-02f, 2.38414764e-01f, 3.30900103e-01f, 8.08707252e-03f, 2.84017939e-02f, 2.09386557e-01f,
  8.45953301e-02f, 4.95529845e-02f, -7.53582567e-02f, 1.91764068e-02f, 1.49940863e-01f, 1.09205037e-01f, 3.46732289e-02f, -7.04263453e-04f, -3.53670791e-02f, 1.21605843e-01f,
  -3.22814941e-01f, -2.96456665e-01f, 2.35122547e-01f, -1.20991811e-01f, -1.39933705e-01f, -3.76395173e-02f, -3.74193750e-02f, -1.09308563e-01f, -2.19957590e-01f, -1.56312153e-01f,
  -1.48562029e-01f, -3.25872689e-01f, -1.33060411e-01f, -1.21724196e-02f, -1.15996458e-01f, 1.26671836e-01f, -8.05382580e-02f, -2.43086085e-01f, -2.37283081e-01f, -6.27583042e-02f,
  1.96200032e-02f, -1.49826854e-01f, -2.50851721e-01f, 1.06979832e-01f, -5.18819205e-02f, -2.83185784e-02f, -1.45244092e-01f, -1.19897552e-01f, -1.85243532e-01f, -2.13312313e-01f,
  -5.69256544e-02f, -3.08759455e-02f, 1.79731697e-01f, 8.65652040e-02f, 1.72282830e-02f, 4.88859043e-02f, 4.81030176e-04f, -3.26847583e-02f, 5.13307713e-02f, 3.87956053e-02f,
  2.10909136e-02f, 5.51063903e-02f, -6.60972446e-02f, -7.61306658e-02f, 8.28077942e-02f, 5.84897138e-02f, 1.08457878e-02f, -1.09524995e-01f, -6.68931454e-02f, 5.87236546e-02f,
  -3.44426185e-02f, 2.32049283e-02f, -2.54004672e-02f, 9.18817818e-02f, 9.36225727e-02f, 5.81965875e-03f, 1.25538990e-01f, -1.14902191e-01f, 2.50374358e-02f, 9.29702446e-02f,
  4.40384895e-02f, 7.52964541e-02f, -3.15419920e-02f, 2.83816047e-02f, 3.44334468e-02f, 3.32878530e-02f, 5.85120209e-02f, -9.96774808e-02f, -4.96507660e-02f, -9.77037773e-02f,
  -1.06162511e-01f, -1.22666731e-01f, -4.94290330e-02f, 1.17442990e-02f, 1.00207657e-01f, 1.11916244e-01f, 5.59648164e-02f, 6.59852847e-02f, -7.41741508e-02f, 3.80811170e-02f,
  1.64593950e-01f, 1.16764367e-01f, 6.89490139e-02f, 1.47992089e-01f, -5.00747329e-03f, 1.04743391e-01f, 1.07027618e-02f, 1.25443742e-01f, -6.33751322e-03f, 1.13000378e-01f,
  -3.05997789e-01f, 1.23172544e-01f, -1.10654928e-01f, -5.17067909e-01f, -1.80725798e-01f, -1.05425432e-01f, 2.19096735e-01f, 6.44068718e-02f, -2.60839760e-01f, -1.25468269e-01f,
  5.40012829e-02f, 1.08464532e-01f, 6.44639041e-03f, 1.56130329e-01f, 1.25500321e-01f, -7.60164559e-02f, -2.16748610e-01f, 6.28511086e-02f, 2.31405333e-01f, 2.76276231e-01f,
  6.27397895e-02f, -1.21497838e-02f, -2.39520129e-02f, -8.15383941e-02f, -2.23199397e-01f, 4.10411414e-03f, -1.66825712e-01f, -2.00452268e-01f, -7.18454306e-04f, -3.32749575e-01f,
  1.90733016e-01f, -2.95072764e-01f, -2.97865625e-02f, -5.00859171e-02f, 7.96564594e-02f, 4.10686657e-02f, 8.15836117e-02f, -5.17956391e-02f, -1.94599889e-02f, -3.26279961e-02f,
  1.96857248e-02f, 8.18041712e-02f, -8.37915391e-02f, -4.99176681e-02f, 2.99966056e-02f, -3.71868722e-02f, -6.56462386e-02f, -6.97974414e-02f, -2.69156098e-02f, 1.02331638e-01f,
  2.18275897e-02f, 5.56106865e-02f, -1.91007048e-01f, -3.56688537e-02f, 2.19819620e-02f, -7.57625699e-02f, -1.03500374e-01f, -1.07853547e-01f, 2.66108867e-02f, -9.36736763e-02f,
  -3.51305529e-02f, 7.05067366e-02f, 1.30880162e-01f, 8.18560645e-02f, 7.59124160e-02f, -5.04044853e-02f, -2.44880635e-02f, 1.10083155e-01f, 5.82732745e-02f, 1.01158246e-02f,
  -9.33002401e-03f, -1.69593412e-02f, -1.03627136e-02f, -2.83286651e-03f, 7.59355398e-03f, -7.28616714e-02f, 4.95905802e-02f, 8.27267691e-02f, 8.13075807e-03f, 1.42796654e-02f,
  5.70986122e-02f, -2.62994738e-03f, -4.88166399e-02f, 1.39154240e-01f, -1.54516958e-02f, -6.16439320e-02f, -1.15743741e-01f, 1.92449838e-01f, -7.96953514e-02f, -1.11808211e-01f,
  8.29434246e-02f, -9.36880112e-02f, -4.69345152e-02f, 1.34357929e-01f, -1.52876377e-01f, 3.65259759e-02f, -2.64822207e-02f, 7.83543140e-02f, -2.13108920e-02f, 2.65529174e-02f,
  6.05462976e-02f, 8.04616362e-02f, -3.08128633e-02f, 8.49117041e-02f, 1.17060050e-01f, -3.52006517e-02f, -5.77782877e-02f, 6.38520420e-02f, -9.58318263e-02f, 2.48392336e-02f,
  -5.13740294e-02f, 1.73069015e-01f, 3.49686816e-02f, -4.04694267e-02f, -2.42369343e-03f, 1.00697204e-01f, 6.53577521e-02f, 9.62671638e-02f, 8.37491974e-02f, 8.08440298e-02f,
  -1.88848168e-01f, 7.90153295e-02f, 1.32832929e-01f, 6.11373968e-02f, -3.13950107e-02f, -7.07847625e-03f, -6.41042143e-02f, -3.48804072e-02f, 1.48145407e-01f, 8.72404352e-02f,
  2.10211370e-02f, -3.58438678e-02f, -1.55752916e-02f, -4.35037911e-02f, -1.51786849e-01f, -6.78100716e-03f, -5.82637265e-02f, -1.48887679e-01f, -2.14847907e-01f, -2.34162793e-01f,
  -7.70469084e-02f, -1.60771728e-01f, -1.65936455e-01f, -2.17179228e-02f, 3.86068947e-03f, -1.08654693e-01f, 1.04220130e-01f, -1.03252769e-01f, 4.27843118e-03f, -4.48034843e-03f,
  3.68731283e-02f, 2.13288926e-02f, -6.81489855e-02f, -2.46896386e-01f, -1.34026021e-01f, -7.96333700e-02f, -1.16784438e-01f, -5.71145304e-02f, -2.01721508e-02f, -6.56368881e-02f,
  -3.28591354e-02f, -2.17234511e-02f, -8.44440460e-02f, -1.93208903e-02f, -1.84760727e-02f, -7.03086853e-02f, 2.93942634e-03f, 1.09508738e-01f, -3.68423834e-02f, -2.91400924e-02f,
  -1.19896205e-02f, -9.51347649e-02f, 7.36134946e-02f, 7.32308254e-02f, -2.35956535e-02f, 1.00874025e-02f, 6.19209856e-02f, 2.96624657e-02f, 3.47096995e-02f, 7.95692205e-02f,
  9.09300447e-02f, 6.41569644e-02f, -7.01598004e-02f, 8.91565308e-02f, 2.73158960e-02f, 1.19864188e-01f, -1.53647557e-01f, -1.85925111e-01f, 5.77688366e-02f, -5.10658063e-02f,
  -3.98129597e-03f, 1.04325600e-01f, 6.22508042e-02f, 1.37332361e-02f, -1.74128294e-01f, -1.62896216e-01f, 1.35617973e-02f, -3.18877511e-02f, -1.39001727e-01f, 3.62193841e-03f,
  -1.32562835e-02f, -8.22393075e-02f, -4.76248004e-02f, -1.56191811e-01f, -4.78742532e-02f, 6.83836415e-02f, 7.47880861e-02f, 6.79876730e-02f, 1.20526254e-01f, 7.78063387e-02f,
  1.63932089e-02f, -1.44500703e-01f, 1.25596942e-02f, -2.20438138e-01f, -1.94969624e-01f, 5.91619313e-02f, 1.25139311e-01f, 7.76410252e-02f, -1.09375224e-01f, -2.11731210e-01f,
  -8.48228484e-02f, -1.25161678e-01f, -9.28612277e-02f, -4.60501835e-02f, -1.28217921e-01f, 1.27218351e-01f, -1.07211739e-01f, -1.57806277e-02f, 5.46198338e-02f, -1.12022050e-02f,
  -9.10697281e-02f, -1.53116345e-01f, -6.54564500e-02f, -1.65862441e-02f, 8.44746754e-02f, -2.16387168e-01f, -1.53767750e-01f, 3.48853171e-02f, -1.48860171e-01f, -1.14942074e-01f,
  2.20799446e-01f, 3.99299026e-01f, -1.88086912e-01f, 9.55989286e-02f, -1.78157166e-01f, -1.64364472e-01f, 7.11936504e-02f, -1.17153399e-01f, -4.89366278e-02f, 8.63093287e-02f,
  7.00206682e-02f, 6.19925447e-02f, 8.16124305e-02f, -3.30171958e-02f, -5.59126399e-02f, 8.13219026e-02f, -1.66593492e-02f, -1.52121916e-01f, -3.14113587e-01f, -2.67561734e-01f,
  -1.36776119e-01f, -2.79691424e-02f, -1.21719621e-01f, -5.28733134e-02f, -1.01524368e-01f, 8.26911349e-03f, 4.24924791e-02f, -1.59473956e-01f, -8.11913908e-02f, 1.86985116e-02f,
  1.63902529e-02f, 5.66327944e-02f, 1.33523032e-01f, 9.74804759e-02f, 7.10550621e-02f, 6.48455322e-02f, 1.11507058e-01f, 1.41551733e-01f, 2.22673535e-01f, 8.04028437e-02f,
  1.38598099e-01f, -1.14557065e-01f, 1.89522970e-02f, -7.69061521e-02f, 1.43920938e-02f, 4.02742103e-02f, -5.55564314e-02f, -1.03298882e-02f, 1.49387086e-03f, 4.84729651e-03f,
  1.16672069e-01f, 6.46931157e-02f, -1.91270430e-02f, -6.13138787e-02f, -7.70198703e-02f, 6.91535743e-03f, 7.04596341e-02f, 5.46478629e-02f, -1.03220213e-02f, 1.98393345e-01f,
  6.10327609e-02f, 6.11365438e-02f, -1.32687598e-01f, -4.36892062e-02f, -4.31973785e-02f, 7.94255883e-02f, -7.09517971e-02f, 5.94893144e-03f, -1.15262553e-01f, 1.87016353e-02f,
  -9.97110922e-03f, -1.29204854e-01f, -4.66705635e-02f, 2.74551325e-02f, 1.65096112e-02f, -1.87228158e-01f, 5.60217500e-02f, 1.78431254e-02f, 4.56776880e-02f, -7.33222887e-02f,
  -4.31927256e-02f, -1.22339264e-01f, -7.72039145e-02f, -1.81664214e-01f, -2.52286382e-02f, -9.79901254e-02f, -1.00085661e-01f, -1.16263032e-01f, -2.90441681e-02f, -9.33463424e-02f,
  3.15898091e-01f, -1.37440428e-01f, -8.76942202e-02f, -3.68317328e-02f, -8.59307945e-02f, -7.51386443e-03f, -3.74232940e-02f, -7.58496225e-02f, 1.06743917e-01f, 9.07412171e-02f,
  2.97123045e-02f, 1.02867194e-01f, 9.00726393e-02f, -2.71224082e-02f, -5.51545620e-02f, 1.44243462e-03f, 1.17207862e-01f, 1.00534774e-01f, 3.70364785e-02f, 1.50849540e-02f,
  7.83781633e-02f, 1.03334948e-01f, 1.77618489e-01f, 1.12654455e-01f, 3.29318494e-02f, -3.46714519e-02f, -7.83831440e-03f, -1.53350681e-02f, -8.11722130e-02f, 2.41005152e-01f,
  -2.48874784e-01f, -3.82021338e-01f, -1.56190470e-01f, -1.35899782e-01f, 4.76696230e-02f, 1.91133544e-01f, -1.44274518e-01f, 2.06554532e-01f, 1.00641474e-02f, -2.45652735e-01f,
  -2.37087021e-03f, 1.10672370e-01f, -6.12160750e-02f, 1.12606600e-01f, 1.94918454e-01f, -9.09645557e-02f, -1.25371851e-02f, 1.40334934e-01f, 3.55640441e-01f, 3.63398045e-01f,
  1.68145850e-01f, -2.30749771e-02f, 8.10061693e-02f, 9.72046107e-02f, -3.04050237e-01f, 2.31348593e-02f, -2.65342712e-01f, -1.45914912e-01f, -1.17012542e-02f, -3.62942576e-01f,
  -2.05215037e-01f, -2.07683727e-01f, 1.77593529e-01f, -3.10628787e-02f, -2.79154833e-02f, -7.65595958e-02f, -1.53516501e-01f, -4.57482524e-02f, -1.82980467e-02f, 1.70570239e-02f,
  -5.21382503e-02f, 4.43377495e-02f, -1.19017631e-01f, 1.25748971e-02f, 8.26741382e-02f, 9.19500291e-02f, 1.46162912e-01f, -6.58125728e-02f, 2.69518867e-02f, 2.23943535e-02f,
  4.76967432e-02f, 3.24607454e-02f, -1.23507328e-01f, -5.97881377e-02f, 4.25870866e-02f, 1.16130248e-01f, -1.90133333e-01f, -3.54834832e-02f, -6.19429834e-02f, -3.67848992e-01f,
  -1.22244926e-02f, -5.44711463e-02f, -4.24879938e-02f, -2.69670561e-02f, 1.16694286e-01f, -8.46458301e-02f, -4.61485833e-02f, 1.71007290e-01f, 5.62796257e-02f, -1.35384858e-01f,
  3.92825790e-02f, -4.70813774e-02f, 1.88234244e-02f, -4.31418456e-02f, -1.09392246e-02f, -1.58706591e-01f, 3.48416679e-02f, -1.90923065e-02f, 6.87301978e-02f, -1.44655602e-02f,
  -1.95689462e-02f, -5.24386838e-02f, -7.06576109e-02f, 8.32283217e-03f, -7.64876902e-02f, 3.43327671e-02f, -1.05298661e-01f, 5.63040040e-02f, -2.22318191e-02f, -2.20491171e-01f,
  -6.90563917e-02f, 1.42365605e-01f, -1.26170963e-01f, 7.65375942e-02f, -8.13688431e-03f, -2.83826496e-02f, -1.47491917e-01f, 1.69344917e-01f, 2.51140650e-02f, 9.72688571e-02f,
  -1.12994723e-02f, 6.02883808e-02f, -1.36208892e-01f, 2.42688973e-03f, 2.51875538e-02f, -7.15688765e-02f, -2.26218347e-02f, 3.92144136e-02f, -2.11131107e-02f, -7.02042580e-02f,
  -1.11640044e-01f, 5.15353605e-02f, -1.34368494e-01f, -1.27883941e-01f, -4.69766594e-02f, -8.19756761e-02f, -1.96028098e-01f, -9.18388590e-02f, -1.53205901e-01f, -2.69268066e-01f,
  -1.77924216e-01f, -1.72161013e-01f, -1.03027143e-01f, -1.04512788e-01f, 7.35527351e-02f, 1.37173370e-01f, -2.36692861e-01f, -2.26760339e-02f, 1.07480355e-01f, -1.76748395e-01f,
  5.41141815e-02f, 1.65879294e-01f, 6.17824420e-02f, -1.78600140e-02f, -2.30339512e-01f, -3.63237947e-01f, -2.30797693e-01f, -4.78368811e-02f, -2.92319022e-02f, 2.61180848e-02f,
  -3.02517135e-03f, 3.42316516e-02f, -7.83967040e-03f, 2.60410216e-02f, 6.46875426e-03f, 1.39545232e-01f, 1.51925057e-01f, 7.72652701e-02f, -3.74940075e-02f, -1.16545238e-01f,
  -1.06596850e-01f, 1.62866153e-02f, 7.85485730e-02f, -8.03821757e-02f, 2.29366980e-02f, -8.21163179e-04f, -9.00846273e-02f, -3.34403180e-02f, 9.49479789e-02f, -1.13095483e-02f,
  -1.62326485e-01f, -3.03880833e-02f, 6.60152212e-02f, -4.44151461e-02f, -5.00968508e-02f, -2.70875338e-02f, -8.49829763e-02f, -3.05928588e-02f, 4.48918305e-02f, -4.44323868e-02f,
  -1.74824730e-01f, 4.66709323e-02f, -1.00474104e-01f, 1.84557602e-01f, -9.34214219e-02f, 3.19741815e-02f, 1.61250994e-01f, 7.35767484e-02f, 1.12297893e-01f, -1.43803144e-02f,
  -4.67818119e-02f, -9.74150561e-03f, -1.29097089e-01f, -6.21536672e-02f, -2.92175878e-02f, 4.25517783e-02f, -3.27479914e-02f, -3.58473100e-02f, 4.39773351e-02f, 4.80261073e-03f,
  -1.96166914e-02f, -1.20740235e-01f, -4.30305675e-02f, -4.43386659e-02f, 3.38436589e-02f, 9.35780555e-02f, 5.03605464e-03f, -2.13684067e-01f, -3.55384648e-02f, 3.47563289e-02f,
  -1.04836300e-01f, -2.65560355e-02f, 6.61859289e-02f, 1.82505056e-01f, 7.94362798e-02f, 3.48650031e-02f, 1.01924285e-01f, -1.90365035e-02f, 2.89200265e-02f, 2.60442938e-03f,
  -5.49389720e-02f, 1.61174551e-01f, -1.75449893e-01f, -1.97059318e-01f, 2.57890597e-02f, -2.12425683e-02f, 2.06143633e-01f, -1.79127622e-02f, 3.05038411e-02f, 1.08939320e-01f,
  -1.23819150e-01f, -1.34085506e-01f, 1.63065359e-01f, -8.80470499e-02f, -5.81067502e-02f, -1.13819957e-01f, -1.10506609e-01f, 1.91039875e-01f, -4.16626371e-02f, 4.69706915e-02f,
  -1.44573957e-01f, -1.36067554e-01f, -2.05722451e-01f, -3.36973071e-02f, 4.85166870e-02f, -9.48048308e-02f, -1.19331777e-01f, 9.59008932e-02f, 8.92813504e-02f, -1.86630309e-01f,
  6.77813053e-01f, -2.28997901e-01f, 1.53729707e-01f, 2.46220618e-01f, 8.79134163e-02f, 2.53799081e-01f, 1.78162307e-01f, 1.55014992e-01f, 1.52948737e-01f, 1.02608725e-01f,
  1.24751426e-01f, 2.55466014e-01f, 2.20763147e-01f, -3.82093973e-02f, 7.65073970e-02f, 6.42633811e-03f, -5.02010547e-02f, 6.90499023e-02f, 2.34246597e-01f, 1.39692307e-01f,
  5.12873307e-02f, -1.74672380e-01f, -1.06408387e-01f, -1.33994922e-01f, -1.83450460e-01f, 3.81819010e-02f, 1.84731036e-02f, -2.00778291e-01f, -1.00313894e-01f, -3.13428909e-01f,
  -4.12139326e-01f, 3.09787281e-02f, 1.31609574e-01f, 2.58675255e-02f, -1.09352939e-01f, -9.39167440e-02f, 6.40126169e-02f, -5.61751798e-02f, 3.93966679e-03f, -1.19284414e-01f,
  -7.92727172e-02f, -1.96940988e-01f, 5.98890334e-02f, 5.78374900e-02f, -1.50741041e-01f, -3.17840502e-02f, -3.33710723e-02f, -6.46896139e-02f, -3.64250690e-02f, 1.54723384e-04f,
  -1.97630990e-02f, 4.57418617e-03f, -4.66673821e-02f, 1.20021082e-01f, 6.35697916e-02f, 2.45667342e-03f, 1.10483281e-02f, 2.54913885e-02f, 8.74142945e-02f, -2.14288682e-02f,
  1.20147333e-01f, 9.75966230e-02f, 3.75863463e-02f, 9.80523750e-02f, 5.19083068e-02f, 1.46083161e-01f, -9.92518738e-02f, 3.83253843e-02f, 2.14294475e-02f, 2.79848557e-02f,
  -6.21151999e-02f, -6.60740510e-02f, -3.24756932e-03f, -2.34970860e-02f, -1.38561067e-03f, -1.49939686e-01f, -1.17664114e-01f, -1.27374992e-01f, 2.26664916e-02f, -1.55585939e-02f,
  -3.60815413e-02f, 2.47419551e-02f, -5.96658811e-02f, -9.40409079e-02f, -1.18445255e-01f, 1.09160319e-01f, 3.04497946e-02f, -4.62215506e-02f, -5.14929444e-02f, 5.91395143e-03f,
  -5.03425539e-01f, 2.73248315e-01f, 4.55066599e-02f, -4.10893932e-02f, -1.45074084e-01f, -5.84010687e-03f, -1.37370098e-02f, -6.77551404e-02f, -1.49644420e-01f, -3.22763883e-02f,
  -3.61319482e-02f, 1.44156464e-03f, -6.59047961e-02f, 6.75253719e-02f, 9.40754265e-02f, -4.28178050e-02f, -1.01573713e-01f, 1.23858400e-01f, -4.99793142e-02f, -1.63610607e-01f,
  -7.27955252e-02f, 5.14421463e-02f, 1.79110378e-01f, 2.00530365e-01f, 7.13389069e-02f, 1.18285865e-01f, -6.26684204e-02f, -1.59493275e-02f, 9.06714723e-02f, 1.24145456e-01f,
  3.24780494e-01f, 2.78675139e-01f, 1.07757948e-01f, 4.84516770e-02f, 1.59177810e-01f, 1.89719573e-01f, 1.56078383e-01f, -9.02651474e-02f, -1.47071913e-01f, 1.33348584e-01f,
  3.65842432e-01f, 2.86626935e-01f, 1.65012628e-01f, 1.97696701e-01f, 9.39542800e-02f, -8.66805911e-02f, -9.64918509e-02f, 2.78967600e-02f, 1.51432946e-01f, 1.03365533e-01f,
  7.22297505e-02f, -1.35616660e-02f, 1.19543254e-01f, 6.24528043e-02f, 3.74152958e-02f, 4.13050540e-02f, 8.67503136e-02f, 1.66951105e-01f, 1.92249075e-01f, 1.43496748e-02f,
  4.06282768e-03f, 4.27081995e-02f, -1.88770607e-01f, 1.10928923e-01f, 1.90426305e-01f, -1.20870858e-01f, 4.82744677e-03f, -9.42911729e-02f, -5.55323213e-02f, -2.36277461e-01f,
  8.10335204e-02f, 4.15257215e-02f, 1.01885527e-01f, -9.15242136e-02f, -2.02990957e-02f, -9.88078043e-02f, -1.07520089e-01f, -4.94011939e-02f, 7.59267341e-03f, -1.51661057e-02f,
  4.58570048e-02f, 9.88257602e-02f, 1.65911436e-01f, 3.48018482e-02f, -2.26999912e-02f, 5.47424890e-02f, 1.42110422e-01f, 5.93715757e-02f, 2.17789672e-02f, -9.23914909e-02f,
  -5.47376722e-02f, 1.28284410e-01f, -6.87247738e-02f, -8.46638754e-02f, -1.89262107e-02f, -1.51556954e-01f, 6.24375679e-02f, 1.20195016e-01f, 1.05137967e-01f, 3.94267328e-02f,
  9.79738194e-04f, -3.34446505e-02f, 2.43202392e-02f, -9.14353207e-02f, -5.96967228e-02f, 9.92129147e-02f, -6.22365996e-02f, -5.49105592e-02f, 3.52532454e-02f, 3.63235101e-02f,
  7.21033961e-02f, -9.19775665e-02f, -5.03445603e-02f, -1.06735788e-02f, -1.01899415e-01f, -2.29982883e-02f, -1.24779135e-01f, -7.97795039e-03f, 7.54288509e-02f, 1.27929803e-02f,
  -3.63131791e-01f, 4.32575643e-02f, -1.17328078e-01f, 1.63214989e-02f, 3.06472909e-02f, -7.05085555e-03f, 6.00791648e-02f, 9.47197825e-02f, 1.44201726e-01f, 3.12829278e-02f,
  1.15618937e-01f, 1.76950358e-02f, -1.11594237e-02f, -2.19718665e-02f, -8.75773728e-02f, -7.64686465e-02f, -5.06210588e-02f, 3.94511893e-02f, -2.99031120e-02f, -1.95371713e-02f,
  -1.00255080e-01f, -9.23866630e-02f, 4.05030400e-02f, 5.19211330e-02f, -9.82247591e-02f, 2.91438289e-02f, 5.05802035e-02f, -1.40533999e-01f, -9.11756158e-02f, -1.50693655e-01f,
  -6.45279586e-01f, -1.06117740e-01f, 2.74251908e-01f, -1.90269604e-01f, 2.22383082e-01f, 2.54660696e-01f, 4.89119232e-01f, 2.76949350e-02f, -2.42981151e-01f, -7.32741877e-02f,
  -1.26419544e-01f, -2.06448123e-01f, -1.33366078e-01f, 1.85877867e-02f, 3.11065558e-02f, 3.76388401e-01f, 2.53459752e-01f, 9.60822925e-02f, 8.73408988e-02f, 1.52009097e-03f,
  1.99562609e-02f, -1.77473933e-01f, -3.29080909e-01f, -1.90703139e-01f, -6.81606531e-02f, -7.74716139e-02f, 1.36548966e-01f, 3.54560427e-02f, 6.53633624e-02f, -5.43855317e-02f,
  2.09939197e-01f, -1.83382168e-01f, 1.20585419e-01f, -1.41664088e-01f, 8.27855524e-03f, -1.67964935e-01f, 1.72776207e-02f, -3.67434658e-02f, -1.06878057e-01f, -1.01632588e-02f,
  -3.61807533e-02f, -8.19237083e-02f, 1.70632564e-02f, -2.45060008e-02f, 1.21006211e-02f, -1.44626632e-01f, 9.89977829e-03f, -1.60660058e-01f, -3.54027450e-02f, -1.92020442e-02f,
  -3.35849524e-02f, -1.39901098e-02f, -8.81671235e-02f, -3.66374105e-02f, -1.21033132e-01f, -1.29179314e-01f, -5.66229261e-02f, -2.50252008e-01f, -2.10755348e-01f, -1.38773024e-01f,
  2.22033188e-02f, -3.33313714e-03f, -2.17619855e-02f, 3.77333909e-02f, -7.95032084e-02f, 1.21200494e-01f, 6.59018159e-02f, -7.73882773e-03f, 6.32847147e-03f, 8.39745104e-02f,
  -6.41702414e-02f, -4.45188358e-02f, -5.22744842e-02f, -1.54449744e-02f, -1.25994757e-01f, 8.16221759e-02f, -4.05199081e-02f, -7.16903210e-02f, -7.10836500e-02f, -2.47337706e-02f,
  -2.17603520e-02f, 2.77348142e-02f, -4.39826846e-02f, -1.05640627e-02f, -5.30270003e-02f, 1.12892846e-02f, -1.00000780e-02f, -6.04014136e-02f, -9.75651145e-02f, -2.85728984e-02f,
  -1.02964967e-01f, 2.74586811e-04f, 5.67372553e-02f, -1.33531690e-01f, 9.35117006e-02f, -1.63911786e-02f, 1.04756874e-03f, -1.11809326e-02f, -9.07362401e-02f, 6.99044541e-02f,
  -3.77469882e-03f, -4.81384471e-02f, -4.32624333e-02f, -4.96474244e-02f, 3.98673564e-02f, -7.09921867e-02f, -9.10719633e-02f, -8.60022604e-02f, -1.24212056e-02f, 6.78071380e-02f,
  2.71359831e-02f, 5.78949936e-02f, 7.78605649e-03f, 4.24238779e-02f, 1.22176588e-01f, 1.80938944e-01f, 1.06067300e-01f, 7.42977932e-02f, 6.84206560e-02f, 1.76199317e-01f,
  -1.86037824e-01f, -1.58965170e-01f, -6.90331832e-02f, 7.00052315e-03f, 1.69551987e-02f, 1.07971057e-01f, -1.43236041e-01f, 5.17942980e-02f, 1.93036124e-02f, -2.54621267e-01f,
  -8.38708803e-02f, 1.17605679e-01f, -1.22636929e-01f, -9.53328833e-02f, -1.51212811e-01f, -2.71558583e-01f, -3.33138466e-01f, -1.82028383e-01f, 8.88170153e-02f, 7.75596127e-02f,
  1.10574208e-01f, -2.58559845e-02f, 9.06782784e-03f, 1.35057762e-01f, 7.58850425e-02f, -5.31481393e-03f, -3.91438827e-02f, -7.61539713e-02f, -8.45568329e-02f, -2.33753949e-01f,
  -1.93028420e-01f, -3.65298726e-02f, 2.40120068e-02f, -6.53782953e-03f, 4.15096954e-02f, -1.43218324e-01f, 2.39784531e-02f, -1.20505914e-01f, -4.07622382e-02f, -4.94611561e-02f,
  6.16386905e-03f, 9.60844383e-03f, 1.12076864e-01f, 1.87131017e-02f, 7.15163797e-02f, -1.23740487e-01f, -1.72278564e-02f, -3.04322876e-02f, 8.97810534e-02f, -8.04010332e-02f,
  -5.62282652e-02f, 2.35362500e-02f, -1.14050172e-01f, -9.21504274e-02f, 4.01741005e-02f, -1.10623658e-01f, 8.88095424e-02f, 1.12864189e-01f, -6.93877265e-02f, -9.19916779e-02f,
  -1.40435889e-01f, -6.40872940e-02f, -9.92640257e-02f, 8.08816701e-02f, 1.69116748e-03f, -7.69391879e-02f, -5.57397082e-02f, -1.65160090e-01f, 9.16142110e-03f, -1.30227029e-01f,
  -1.10058457e-01f, 3.72530264e-03f, 3.50264758e-02f, 1.05992090e-02f, 7.79443011e-02f, -8.49496573e-02f, -1.56170025e-01f, -1.84616596e-01f, -8.49748775e-02f, -3.20156403e-02f,
  -6.92866147e-02f, 4.37380373e-02f, 1.01119637e-01f, 6.35787770e-02f, 2.96186879e-02f, -1.16596691e-01f, -1.28588304e-01f, -5.78250512e-02f, -6.73689395e-02f, -2.09161371e-01f,
  -3.19695920e-02f, 2.31774189e-02f, -1.49654269e-01f, 2.08451245e-02f, -1.24466181e-01f, -6.87430426e-02f, 4.47443500e-03f, -6.57281801e-02f, -6.12855777e-02f, 8.50843936e-02f,
  -3.28888930e-02f, -4.26017269e-02f, 2.97786351e-02f, 2.14854509e-01f, -1.79977044e-02f, -3.01605295e-02f, -1.13152325e-01f, 1.47481561e-02f, -7.94703886e-02f, 2.73315944e-02f,
  -4.26263772e-02f, -1.73922896e-01f, -1.71584010e-01f, -6.08436875e-02f, -7.46126622e-02f, -6.20637201e-02f, -3.52388136e-02f, 5.90688037e-03f, -2.22161233e-01f, -1.72748908e-01f,
  -3.36989164e-01f, 4.68865544e-01f, -2.69262701e-01f, 1.56734034e-01f, -1.37959942e-01f, -3.40212673e-01f, -4.38516401e-02f, -6.25477731e-02f, -8.09703842e-02f, 4.43849042e-02f,
  3.69851142e-02f, -1.92937702e-01f, -1.66085213e-01f, -2.22063303e-01f, -3.44408125e-01f, -8.40681642e-02f, -3.31328839e-01f, -5.13876259e-01f, -5.93034804e-01f, -1.93802550e-01f,
  -1.16981179e-01f, -1.87520146e-01f, -2.43320614e-01f, -1.58336490e-01f, 1.66036621e-01f, 8.32747892e-02f, 9.71041024e-02f, 2.68646167e-03f, -1.11367464e-01f, 9.64187756e-02f,
  6.92125708e-02f, -1.75685994e-02f, -1.55170918e-01f, 2.21947879e-02f, 1.03370361e-01f, -6.58068359e-02f, -1.40365541e-01f, 5.44534735e-02f, 7.98407570e-02f, 6.00163080e-02f,
  -8.86092708e-02f, 4.07290421e-02f, -2.60189585e-02f, 6.21317849e-02f, 7.87995383e-02f, 4.85785343e-02f, 1.89808652e-01f, 1.11955799e-01f, 8.94287527e-02f, 1.58344865e-01f,
  1.48309633e-01f, 3.64773683e-02f, 6.27906770e-02f, 1.91755027e-01f, -5.56995533e-02f, -8.36201236e-02f, 1.47913709e-01f, 2.64802240e-02f, -6.41198531e-02f, 3.64452541e-01f,
  1.34698585e-01f, 2.98873875e-02f, 2.38378700e-02f, 1.50867151e-02f, 9.08499435e-02f, 8.69365036e-02f, 1.33220032e-01f, 4.03718278e-02f, -8.04168880e-02f, -6.17617518e-02f,
  1.02649547e-01f, -2.11666264e-02f, 4.95487452e-02f, -5.47886603e-02f, 9.28102341e-03f, -7.54450932e-02f, -5.12788966e-02f, 5.24855852e-02f, 6.42761737e-02f, 8.03828686e-02f,
  1.10225584e-02f, 2.08945852e-02f, 2.48021949e-02f, 6.23503402e-02f, -1.62587278e-02f, 1.29585207e-01f, -1.43229976e-01f, -1.91190004e-01f, -1.56027302e-01f, -1.04299784e-01f,
  2.23373145e-01f, -3.16567570e-01f, -9.26718712e-02f, -1.11822776e-01f, 6.34389594e-02f, 9.14068222e-02f, 7.53021166e-02f, 2.82024443e-02f, 3.89404595e-02f, 1.52571574e-01f,
  -5.69719039e-02f, 3.39638535e-03f, 1.82174742e-02f, 1.40746057e-01f, -9.74790603e-02f, -5.00773825e-02f, 1.86800689e-01f, 6.99057728e-02f, -1.59081910e-02f, 1.26069471e-01f,
  1.00628063e-01f, -4.61750850e-02f, 6.85442239e-02f, 1.04058906e-01f, -3.66700403e-02f, -1.77073911e-01f, 1.58972010e-01f, 5.92433996e-02f, -7.03843310e-02f, 2.84741849e-01f,
  -5.16615473e-02f, 3.46958995e-01f, 3.63368481e-01f, -1.63786456e-01f, 2.50867128e-01f, 1.90462440e-01f, 5.50186515e-01f, 6.26483336e-02f, -1.86062321e-01f, 2.96239465e-01f,
  1.82211906e-01f, -1.59217089e-01f, -2.09538549e-01f, -2.00269461e-01f, 1.05840974e-01f, 1.50049463e-01f, -1.62120238e-02f, -6.45423681e-02f, -2.03326806e-01f, -7.64833167e-02f,
  -1.01068914e-01f, -3.76662575e-02f, -8.20637792e-02f, -2.63258547e-01f, -1.23936474e-01f, -1.55208543e-01f, 1.73094213e-01f, 1.04756363e-01f, 6.79137483e-02f, -1.90293700e-01f,
  -3.35246511e-02f, 2.66446799e-01f, -2.40216658e-01f, -1.13076985e-01f, 3.41500007e-02f, -2.01179028e-01f, -5.10951430e-02f, 1.66720208e-02f, -5.98224215e-02f, -8.95437300e-02f,
  1.14453264e-01f, 4.00442295e-02f, 3.37852277e-02f, 9.87036601e-02f, 5.80864809e-02f, 3.20698693e-02f, 2.26798300e-02f, -1.99216213e-02f, 7.24179968e-02f, 3.20512010e-03f,
  -1.13812745e-01f, 1.71974331e-01f, 1.32597983e-01f, 1.23334244e-01f, 6.92375079e-02f, -2.17852503e-01f, 1.33502647e-01f, -7.10579902e-02f, 4.38718982e-02f, -2.04027906e-01f,
  -4.04791906e-02f, 6.21161833e-02f, 5.78557365e-02f, -1.07722789e-01f, -1.70209154e-01f, -1.06396012e-01f, -2.87392065e-02f, 1.14700552e-02f, -4.20245156e-02f, 3.83976661e-02f,
  -1.21677659e-01f, -1.83034991e-03f, -6.89189360e-02f, 9.07543525e-02f, -7.39196539e-02f, 7.76412040e-02f, 1.06000006e-02f, 9.86933634e-02f, 9.57538635e-02f, -4.50018533e-02f,
  -4.56216298e-02f, -1.83096770e-02f, -3.98186371e-02f, -1.11852633e-02f, 1.63582098e-02f, -2.96025723e-02f, 1.68367811e-02f, 9.11242515e-03f, -9.93515365e-03f, -1.37385158e-02f,
  -2.80508399e-01f, 2.28726923e-01f, -1.96722046e-01f, -1.58198074e-01f, 1.81462951e-02f, -1.24076322e-01f, 2.99322009e-02f, 1.00836053e-01f, 1.25664446e-04f, -5.50898388e-02f,
  5.19281179e-02f, -1.78987980e-02f, -9.76132415e-03f, -4.53646742e-02f, -1.05941787e-01f, 5.27373515e-02f, 2.12822929e-02f, -4.81472313e-02f, -3.46250422e-02f, -6.18165545e-02f,
  -1.03427313e-01f, -1.83604117e-02f, 5.11822663e-02f, -9.74558368e-02f, -1.98815957e-01f, -2.50415146e-01f, 8.48640203e-02f, -1.21981010e-01f, 4.11238335e-02f, -1.31921053e-01f,
  -3.18802968e-02f, 4.48517710e-01f, -3.74256112e-02f, -5.79860434e-03f, 1.42452851e-01f, 9.54203382e-02f, 2.87451178e-01f, 1.91324323e-01f, -9.52542573e-02f, 5.64678051e-02f,
  1.00759612e-02f, -4.97296602e-02f, -5.10441959e-02f, -1.45476714e-01f, -2.95378780e-03f, 2.55042106e-01f, 1.38553038e-01f, -8.90813917e-02f, -2.78616786e-01f, 2.42257919e-02f,
  3.15125324e-02f, -5.64356893e-02f, -9.15394425e-02f, -5.39726131e-02f, 6.32883236e-02f, -1.93688139e-01f, -6.15317114e-02f, 1.21175453e-01f, 1.57512248e-01f, 1.22624017e-01f,
  -2.25954995e-01f, 1.70001790e-01f, -3.40444267e-01f, -2.50177588e-02f, 1.08514121e-02f, -9.98841785e-03f, 5.96893281e-02f, 3.47673930e-02f, 4.24327962e-02f, -5.84397763e-02f,
  5.22676706e-02f, 6.77451864e-02f, 5.83017953e-02f, -1.54636111e-02f, 3.87758948e-03f, 1.38952211e-01f, 9.33873132e-02f, 1.57815143e-01f, -6.18435591e-02f, -1.65456831e-02f,
  1.04684815e-01f, 6.14715070e-02f, 1.94375038e-01f, 3.68386135e-02f, -7.75935054e-02f, -1.73946723e-01f, 5.72020561e-02f, -3.16588655e-02f, -1.32689532e-02f, -7.90656582e-02f,
  7.14388713e-02f, 8.18796605e-02f, 3.89810875e-02f, -1.63818840e-02f, -1.26000166e-01f, -3.36415544e-02f, 4.56937291e-02f, -5.72648682e-02f, -3.56484242e-02f, -5.92825785e-02f,
  -1.20320711e-02f, -7.61221498e-02f, -9.05783921e-02f, -1.61934838e-01f, -1.09692708e-01f, 1.55389644e-02f, -1.08044560e-03f, 9.63824168e-02f, -7.96590000e-02f, -2.19782069e-01f,
  -1.69338603e-02f, -2.63164695e-02f, -1.61375315e-03f, -1.38793578e-02f, -1.04844950e-01f, -2.17077695e-02f, -2.01416329e-01f, -2.48730369e-02f, 4.94996607e-02f, -8.24488699e-02f,
  -3.80297899e-01f, -2.08172128e-01f, -3.14836055e-01f, 1.65951047e-02f, -1.85010117e-02f, -1.14319429e-01f, -9.80820209e-02f, -1.17277794e-01f, 7.01854452e-02f, 7.68049955e-02f,
  -8.23699962e-03f, -5.48216924e-02f, -9.87177566e-02f, -5.05388081e-02f, -8.56646672e-02f, 1.14552677e-01f, 7.29732886e-02f, -7.07208365e-02f, -1.28805384e-01f, -1.45779222e-01f,
  -6.78588822e-02f, -1.05990939e-01f, -1.37056202e-01f, -1.71232447e-02f, -2.60936111e-01f, -2.02504143e-01f, -1.08348645e-01f, -1.54838040e-01f, -5.75573323e-03f, 7.97892585e-02f,
  -7.98639748e-03f, -3.93259432e-03f, 2.78714567e-01f, 1.67775825e-01f, 8.87580067e-02f, -2.48810932e-01f, -2.82148093e-01f, -1.26347780e-01f, 1.03169426e-01f, 5.49631156e-02f,
  4.35294621e-02f, 7.87366629e-02f, 1.44826382e-01f, 1.83217339e-02f, -3.80329639e-02f, -7.07263406e-03f, 1.07329205e-01f, -8.90333951e-02f, -1.77445695e-01f, -1.25928000e-01f,
  1.46919843e-02f, -2.99815554e-02f, 4.23098076e-03f, -1.02159411e-01f, 1.68145016e-01f, -1.18345797e-01f, 1.53659016e-01f, 1.11490451e-01f, -1.16638057e-02f, 3.66180182e-01f,
  1.66744247e-01f, 1.84690401e-01f, -1.56101286e-01f, -5.62474504e-02f, 5.09796888e-02f, 3.85669358e-02f, -9.42887962e-02f, 1.50855124e-01f, -3.60999666e-02f, -4.76584136e-02f,
  1.45629674e-01f, 1.18863672e-01f, -2.57876609e-02f, -6.20090682e-03f, -9.28447396e-02f, -1.53180614e-01f, -1.95731595e-02f, 1.16458476e-01f, -9.63307247e-02f, -5.83386421e-02f,
  4.89334613e-02f, 1.46274744e-02f, 4.51970147e-03f, -1.72318205e-01f, -2.98643708e-02f, -8.24054144e-03f, -4.11765510e-03f, -9.25453007e-03f, -2.07563117e-01f, 3.82069573e-02f,
  4.49596252e-03f, 3.65788001e-03f, 1.04950927e-01f, 1.04927532e-01f, -3.55942771e-02f, 9.34634507e-02f, 1.84139177e-01f, 7.15938676e-03f, 4.25394177e-02f, 1.45372273e-02f,
  -5.30194417e-02f, -1.06612146e-01f, 6.36581331e-03f, -2.87426915e-02f, -3.77836600e-02f, 6.98179603e-02f, -6.97013661e-02f, -1.00282125e-01f, -2.12210774e-01f, 7.21005946e-02f,
  -1.09868878e-02f, -4.01573554e-02f, -4.28790934e-02f, -4.66027260e-02f, -6.80618808e-02f, -3.02231386e-02f, -7.31470510e-02f, -6.89719319e-02f, 5.88588081e-02f, 8.02210718e-02f,
  -5.09852953e-02f, -1.13979250e-01f, -5.64709678e-02f, -3.89183825e-03f, 1.07011206e-01f, -1.02858216e-01f, 2.44643874e-02f, -5.45950532e-02f, -8.69900978e-04f, -4.72218357e-02f,
  -7.24102780e-02f, -1.02316529e-01f, 1.23158228e-02f, -9.74074751e-02f, -2.31223125e-02f, -1.92323122e-02f, -5.53532839e-02f, -1.72702238e-01f, -1.13466725e-01f, 1.07107967e-01f,
  -1.28124863e-01f, -3.27833712e-01f, -1.97305247e-01f, -2.33266652e-01f, -1.62788972e-01f, -1.74815908e-01f, -1.75746888e-01f, -8.50026608e-02f, -2.58685172e-01f, -3.56324255e-01f,
  -2.13870898e-01f, -2.53340453e-01f, -1.86054066e-01f, -2.83312768e-01f, -1.83056235e-01f, -2.08561239e-03f, -1.79854274e-01f, 3.10528949e-02f, -1.16924709e-02f, -3.70708078e-01f,
  -1.17235892e-01f, 8.70440006e-02f, 8.68625268e-02f, 1.03585832e-01f, 7.26800561e-02f, -2.63687491e-01f, -2.95032144e-01f, 1.54812276e-01f, 3.65638375e-01f, 7.12135658e-02f,
  -1.27792478e-01f, -6.51739687e-02f, 1.30226955e-01f, 8.33506212e-02f, -2.52690315e-01f, 4.02447134e-02f, -3.00048858e-01f, -4.82952781e-02f, -2.69996431e-02f, -3.44852000e-01f,
  -2.00591102e-01f, 3.00421808e-02f, 9.86330509e-02f, 1.62583515e-02f, -1.14254393e-01f, 5.15005104e-02f, -8.85888711e-02f, -2.87569147e-02f, 2.47007217e-02f, 3.92480642e-02f,
  -4.24615853e-02f, 4.30394933e-02f, 5.31886965e-02f, -1.35114416e-01f, -4.52159755e-02f, -4.17473540e-02f, -3.65427472e-02f, 8.22049454e-02f, 4.11947351e-03f, 2.66420133e-02f,
  -1.35701811e-02f, 6.24676943e-02f, 1.10993207e-01f, 1.49189979e-01f, 6.32019639e-02f, 1.38900340e-01f, 8.18339959e-02f, 6.81773722e-02f, 1.68166131e-01f, -3.66455823e-01f,
  -1.42809793e-01f, 6.31484343e-03f, 3.16903666e-02f, 6.02282137e-02f, 6.74698204e-02f, -2.61819102e-02f, 4.67067286e-02f, -1.55554742e-01f, -4.93572503e-02f, 8.48570168e-02f,
  6.19913936e-02f, -6.52456209e-02f, 1.91079807e-02f, -2.51786951e-02f, -2.07930729e-02f, -2.54428871e-02f, 2.02826299e-02f, -9.22582671e-02f, -1.03983134e-01f, 7.48108998e-02f,
  4.98057194e-02f, 1.13152139e-01f, -5.86213730e-03f, 5.72041087e-02f, -1.06240483e-02f, -1.05844028e-01f, -1.70543289e-03f, 9.58047733e-02f, 1.47088217e-02f, -6.48812950e-02f,
  -1.04872718e-01f, 2.78033912e-01f, -2.11399570e-01f, 8.51662904e-02f, -1.07985415e-01f, -3.39927897e-02f, -5.78983985e-02f, -3.25299203e-02f, 2.23509036e-02f, -7.94412419e-02f,
  1.82454392e-01f, -1.61545157e-01f, -4.38967161e-02f, 9.43788588e-02f, -9.21826586e-02f, 9.20875147e-02f, -8.04484934e-02f, 3.07230599e-04f, 1.21463493e-01f, -8.89539570e-02f,
  -3.05317827e-02f, 4.65445593e-02f, 3.31264473e-02f, 9.97055545e-02f, -6.41989559e-02f, 5.98705932e-02f, -2.76318043e-02f, -5.90224154e-02f, 5.18276654e-02f, -3.18690777e-01f,
  -1.27394170e-01f, -1.66239545e-01f, 4.85348910e-01f, -3.02651227e-02f, -3.99612516e-01f, -3.64318907e-01f, -3.39258105e-01f, -4.69598733e-02f, -1.11831995e-02f, -2.34255061e-01f,
  -2.58664638e-01f, 3.15662660e-02f, 1.60791636e-01f, 2.81727880e-01f, 2.39503160e-01f, 9.08696949e-02f, 3.73899072e-01f, 5.38381934e-01f, 1.84555352e-01f, 7.10054561e-02f,
  2.13911217e-02f, 6.70658648e-02f, 3.87347847e-01f, 3.23127002e-01f, 7.99031332e-02f, 5.25052324e-02f, 2.67702669e-01f, 1.32142961e-01f, 7.34609505e-03f, 3.97057831e-01f,
  -1.48745656e-01f, -2.42868155e-01f, -2.30232477e-02f, -1.63922682e-01f, 6.87730238e-02f, 1.30157843e-01f, -1.10521294e-01f, 2.15310484e-01f, 1.04696695e-02f, 1.55314326e-01f,
  -3.96102704e-02f, -1.07740499e-01f, -1.07986957e-01f, 1.00709759e-01f, -8.54315907e-02f, -1.65140390e-01f, 1.09505273e-01f, 3.18729848e-01f, 1.74288377e-01f, -5.36185615e-02f,
  -3.73660736e-02f, -1.47169039e-01f, -1.94025293e-01f, 1.86320413e-02f, 6.42105564e-02f, 3.30777466e-02f, -6.99440241e-02f, 3.62004377e-02f, 9.72151086e-02f, 2.57603638e-02f,
  9.37224627e-02f, 8.38741213e-02f, -3.13771442e-02f, -8.47483054e-02f, -7.29291737e-02f, 5.60502112e-02f, 5.21295890e-02f, 8.66171122e-02f, 4.93653119e-02f, -2.59726234e-02f,
  -5.65727148e-03f, 8.61845538e-02f, -2.14047986e-03f, -5.76025881e-02f, 1.21632874e-01f, -3.65183204e-02f, -4.95707393e-02f, -2.40468420e-02f, 6.83371574e-02f, 1.03298165e-02f,
  3.35564986e-02f, -4.01097424e-02f, 6.06491752e-02f, 1.36349544e-01f, -1.59507226e-02f, 5.62095009e-02f, -2.53475886e-02f, -7.49046728e-02f, -6.38767555e-02f, -9.26817581e-02f,
  -1.50143683e-01f, 1.31021351e-01f, -1.14629157e-01f, -5.64373769e-02f, -5.06984815e-02f, -1.80909887e-01f, -2.34664716e-02f, -4.72854041e-02f, -3.68392132e-02f, -4.73871641e-02f,
  -2.17996612e-01f, -9.52419415e-02f, -1.21114567e-01f, 1.41422778e-01f, -5.47552742e-02f, -2.08691671e-01f, -4.35653329e-02f, 1.72134209e-02f, 6.62728399e-02f, -7.18061700e-02f,
  9.57604572e-02f, -1.89489082e-01f, -2.43920922e-01f, -2.06403881e-01f, -1.25001520e-01f, -7.76392147e-02f, -2.03302950e-02f, -1.10122204e-01f, -1.78923845e-01f, -1.79461688e-01f,
  -5.61817400e-02f, -4.60324585e-02f, 1.43564120e-02f, -4.09312062e-02f, -4.47929725e-02f, 1.41830504e-01f, 1.30534574e-01f, -1.08983424e-02f, -7.18067586e-02f, 1.01192109e-01f,
  2.77000964e-01f, 3.02070320e-01f, 3.13930392e-01f, 2.73908526e-01f, 2.16044754e-01f, 3.52021232e-02f, -1.10383019e-01f, 1.09731123e-01f, 1.63927659e-01f, 1.22010373e-01f,
  7.25929299e-03f, -1.00143403e-02f, -4.96803075e-02f, -2.78662723e-02f, -1.21564819e-02f, 1.25812173e-01f, -5.64573258e-02f, -5.01840562e-02f, -1.54977348e-02f, -6.15129769e-02f,
  3.78721178e-01f, -1.43091455e-01f, -3.44536118e-02f, -2.71145487e-03f, -8.34791139e-02f, -3.39011282e-01f, -6.96538016e-02f, -3.94828804e-02f, -4.02910411e-02f, -6.67397603e-02f,
  -2.93278340e-02f, -1.42902926e-01f, 5.96235953e-02f, -9.64267924e-02f, -2.31648132e-01f, -9.61074308e-02f, -2.01144516e-01f, 1.03003643e-01f, 1.57892242e-01f, 7.78021142e-02f,
  -2.32100617e-02f, -9.25659984e-02f, 1.12957194e-01f, 1.40369639e-01f, 9.76848826e-02f, 6.71384111e-02f, -1.29192565e-02f, -1.42012417e-01f, 3.11027393e-02f, -1.22177459e-01f,
  1.59668585e-03f, 1.61648002e-02f, 1.05801769e-01f, 5.95088005e-02f, 7.84008875e-02f, 5.34523129e-02f, 4.36395556e-02f, 9.06543285e-02f, 6.89325631e-02f, -6.28758818e-02f,
  2.70071309e-02f, 5.46590611e-02f, 1.11146115e-01f, 1.63443625e-01f, 2.28719607e-01f, -3.24409269e-02f, -6.86035827e-02f, -2.19175350e-02f, -2.88190898e-02f, 9.63866338e-02f,
  -8.39455985e-03f, -7.29558766e-02f, -1.87417507e-01f, 2.34606173e-02f, -9.52172186e-03f, -1.64065845e-02f, -8.76117051e-02f, 4.87384051e-02f, -7.23537877e-02f, -1.09234482e-01f,
  2.05892637e-01f, 2.67530791e-02f, 8.90597925e-02f, 7.40401121e-03f, -2.25814164e-01f, -1.39192075e-01f, 7.76700601e-02f, -4.07305686e-03f, -1.16126284e-01f, 2.20938073e-03f,
  -8.17791931e-03f, -2.09549591e-02f, -4.72112000e-02f, -1.31527245e-01f, -9.38922167e-02f, -2.18729913e-01f, -2.57519889e-03f, 8.05322304e-02f, -4.55961749e-02f, 5.04100649e-03f,
  -5.51144183e-02f, -6.54333606e-02f, 1.71849579e-01f, 1.59983024e-01f, 4.10285555e-02f, 4.28866856e-02f, 2.95589287e-02f, -5.12925796e-02f, -4.77066450e-02f, 2.60707922e-02f,
  2.05087572e-01f, 1.11760072e-01f, 1.83733210e-01f, 1.15129165e-01f, -1.45669848e-01f, 1.05461098e-01f, 2.92633384e-01f, 1.63678586e-01f, 4.11498472e-02f, -4.54830267e-02f,
  -1.44601062e-01f, -9.87739265e-02f, -5.80246449e-02f, 1.77590102e-02f, 2.40475908e-01f, 9.55168605e-02f, 2.17175260e-01f, 1.99734986e-01f, 1.03812896e-01f, 6.28489852e-02f,
  2.04243157e-02f, -7.07337335e-02f, -7.33883977e-02f, 7.78627768e-02f, 1.65196545e-02f, -2.78188400e-02f, 7.99949691e-02f, 1.68658625e-02f, 6.50852919e-02f, 1.35451153e-01f,
  -3.81010145e-01f, 2.51562148e-01f, 5.98791540e-02f, -5.44209667e-02f, -2.39065476e-02f, 3.46310362e-02f, -9.09576118e-02f, -8.13587233e-02f, -5.73926307e-02f, -8.09249282e-02f,
  -1.17022812e-01f, -1.01738252e-01f, 1.24365419e-01f, 6.21903054e-02f, -9.11093205e-02f, -3.14408503e-02f, 5.09204390e-03f, 7.52443671e-02f, 9.16130915e-02f, -5.39336614e-02f,
  -1.44641111e-02f, -1.68996304e-01f, 3.11585795e-02f, 2.10363179e-01f, 2.55156875e-01f, -1.03233613e-01f, 8.53435025e-02f, 1.05529398e-01f, 1.53834179e-01f, 1.14515685e-01f,
  -1.49354100e-01f, 2.04509683e-02f, 4.68991585e-02f, 1.28251091e-01f, -1.00932308e-02f, -2.77594738e-02f, 4.56145816e-02f, -4.48212214e-02f, 6.92856386e-02f, 1.57859400e-01f,
  2.25313023e-01f, -6.38918811e-03f, -7.44433850e-02f, 1.27303734e-01f, -8.84792730e-02f, -5.38580678e-02f, 4.65360545e-02f, -3.98536101e-02f, -5.07283071e-03f, -4.64084856e-02f,
  -1.68709923e-02f, 1.86943874e-01f, -1.26317376e-03f, 2.17081144e-01f, -5.29001988e-02f, 8.66461620e-02f, -5.60378879e-02f, -9.09711570e-02f, 6.47159247e-03f, -1.06435403e-01f,
  -4.66020823e-01f, 1.15245551e-01f, 1.13883242e-03f, 7.88233206e-02f, -6.12836750e-03f, -9.45359915e-02f, -7.45535940e-02f, -1.04620039e-01f, -2.12406173e-01f, -8.50091875e-02f,
  -3.96964289e-02f, 4.94595803e-02f, 1.34768039e-01f, 3.31692323e-02f, -1.19859591e-01f, -1.12261496e-01f, -1.64484590e-01f, -1.61451221e-01f, -1.01444840e-01f, -6.67656288e-02f,
  -4.94553149e-02f, -1.84596613e-01f, -1.28852725e-01f, 5.08812629e-02f, -1.44047841e-01f, -2.78159022e-01f, -2.00578466e-01f, -1.83924839e-01f, -3.28198820e-02f, -1.51343793e-01f,
  1.15106352e-01f, -2.29876712e-01f, -2.50309795e-01f, -5.23532368e-02f, -1.65246069e-01f, -1.76191956e-01f, -3.02599072e-01f, -8.72851256e-03f, 5.49145564e-02f, -3.34015489e-01f,
  -1.91445872e-01f, 2.29200989e-01f, -1.74833946e-02f, 7.50841200e-02f, 1.68709472e-01f, -3.93294930e-01f, -2.74985492e-01f, 1.17857568e-01f, 2.50861675e-01f, 3.85862682e-03f,
  -9.41885337e-02f, 4.31699231e-02f, 2.51349270e-01f, 1.16441585e-01f, -3.35876316e-01f, -4.20520734e-03f, -2.85617828e-01f, -5.32102808e-02f, -1.71805039e-01f, -3.62226307e-01f,
  -2.38204136e-01f, -5.67855686e-02f, 2.30397452e-02f, -1.89639013e-02f, -9.39371958e-02f, 4.45173681e-03f, -1.58926114e-01f, -6.67288899e-02f, 8.25557671e-03f, -1.21674985e-01f,
  2.42538657e-02f, -1.51414238e-02f, 2.36470550e-01f, 9.10664499e-02f, 1.37546007e-02f, 7.72174494e-03f, -4.77097789e-03f, 1.68178009e-03f, 5.73417507e-02f, -1.25452265e-01f,
  -8.27845335e-02f, -9.95106027e-02f, 3.27986442e-02f, 6.55269846e-02f, 1.15560271e-01f, 1.70416936e-01f, -1.71576157e-01f, 1.20957352e-01f, 7.45997354e-02f, -1.31834865e-01f,
  -1.03845373e-01f, -8.68923664e-02f, -9.31167081e-02f, -4.56420928e-02f, -2.34587211e-02f, 2.73867901e-02f, -5.25371404e-03f, -6.02041483e-02f, 8.28816891e-02f, -6.61420524e-02f,
  2.26288196e-02f, -4.56171781e-02f, 2.09799018e-02f, -7.16914833e-02f, 1.57300476e-02f, 3.92713025e-02f, -1.75673235e-02f, -1.09717473e-01f, 1.99716873e-02f, -8.43877643e-02f,
  4.10121419e-02f, -1.73567999e-02f, 5.77797331e-02f, 9.90035087e-02f, -9.48384032e-02f, -7.30307847e-02f, 3.06565277e-02f, 5.67405112e-02f, 8.78608003e-02f, -6.47377549e-03f,
  1.36636063e-01f, 1.13162510e-01f, -3.97036672e-02f, 2.28530020e-02f, 9.02399048e-03f, -9.68619138e-02f, -5.53860404e-02f, -7.85498098e-02f, 7.39704743e-02f, -5.12258820e-02f,
  1.29619345e-01f, -9.52979457e-03f, -1.86233055e-02f, -2.69697532e-02f, 5.66220395e-02f, -1.43754175e-02f, 1.87845621e-02f, 8.50404650e-02f, -5.40049560e-02f, -1.44195631e-01f,
  -7.56784305e-02f, 9.30013806e-02f, 7.70269483e-02f, 3.92463394e-02f, -6.15830347e-02f, -6.20823679e-03f, -5.47497533e-02f, -1.20415740e-01f, 9.68516469e-02f, -7.95180872e-02f,
  -3.28341186e-01f, -9.62022692e-02f, -1.82982191e-01f, -3.90329584e-02f, -1.63166866e-01f, 9.39847529e-02f, -2.94609219e-02f, 9.49273407e-02f, 9.37493294e-02f, -2.22675025e-01f,
  -1.42231137e-01f, -2.54692025e-02f, -2.31172949e-01f, -3.48270647e-02f, -3.19345891e-02f, -2.66419798e-01f, -2.42174074e-01f, -2.38597989e-01f, 4.51003425e-02f, 2.24753827e-01f,
  -4.47272845e-02f, -1.33813396e-01f, -1.16887994e-01f, -6.05162466e-03f, -5.32373339e-02f, -2.51211524e-01f, -3.95698339e-01f, -5.84685877e-02f, -2.59118881e-02f, -3.40317816e-01f,
  -2.78499067e-01f, 1.28088677e-02f, 5.31412736e-02f, 1.89683344e-02f, -2.60926113e-02f, 7.77029842e-02f, -6.35204762e-02f, -7.17954151e-03f, 5.77788316e-02f, -4.14785966e-02f,
  4.91106845e-02f, 9.75001976e-02f, -4.65015694e-03f, -4.75094877e-02f, -1.99979637e-02f, 6.00148318e-03f, 1.04017742e-02f, 6.34326041e-02f, 1.14065157e-02f, 1.00649349e-01f,
  1.76938891e-01f, 6.88706636e-02f, 1.30351320e-01f, 6.37988001e-02f, 2.17873365e-01f, -9.85740405e-03f, 1.04658969e-01f, 6.11609779e-02f, 9.41585377e-02f, -7.39135593e-02f,
  -2.90468819e-02f, 2.53983261e-03f, 2.20465418e-02f, 2.14461796e-02f, 1.19160600e-01f, 6.62130043e-02f, -2.94705089e-02f, 6.26664981e-02f, -5.33491299e-02f, 4.92221378e-02f,
  6.77939728e-02f, -8.71864036e-02f, 2.70950440e-02f, -5.03472760e-02f, -8.78632292e-02f, 2.93579455e-02f, -1.03790440e-01f, 9.03424248e-02f, 3.72848287e-02f, -9.96215791e-02f,
  -1.86016150e-02f, 8.34536180e-02f, -3.54660861e-02f, 4.93380874e-02f, -4.10999879e-02f, 5.75753814e-03f, -1.61886625e-02f, 6.66502565e-02f, -7.20827803e-02f, 8.11313242e-02f,
  -1.65689975e-01f, -4.16105129e-02f, -8.00718069e-02f, -1.48650273e-04f, -1.66953951e-02f, 4.82314685e-03f, 2.28708293e-02f, -7.66506270e-02f, -1.88025400e-01f, -6.85994849e-02f,
  8.66738856e-02f, -7.77767301e-02f, -5.91995008e-02f, 9.53962328e-04f, 1.91941075e-02f, 3.65754142e-02f, 6.21523708e-02f, -1.38071746e-01f, 8.31051618e-02f, 2.70916730e-01f,
  2.44100899e-01f, 2.80850351e-01f, 1.05984053e-02f, -4.64864774e-03f, 3.40505093e-02f, -4.86881398e-02f, -1.26449764e-01f, 2.25909073e-02f, -8.05348232e-02f, -7.99033642e-02f,
  -3.10467005e-01f, -1.49715111e-01f, -1.76316172e-01f, -3.35468315e-02f, 5.20693995e-02f, 1.72132403e-01f, 1.34163350e-01f, 2.01486796e-01f, 2.07211122e-01f, -6.97276890e-02f,
  4.70856018e-02f, 1.79020330e-01f, -1.57367378e-01f, -4.68735211e-02f, -2.96255220e-02f, -1.60987660e-01f, -2.82003701e-01f, -1.68564022e-01f, 2.66134083e-01f, 2.33957976e-01f,
  1.77961752e-01f, 1.07212670e-01f, 4.54619937e-02f, -5.10713942e-02f, -9.19108093e-02f, -5.04398160e-02f, -2.53677875e-01f, -1.97531953e-01f, -1.45507663e-01f, -4.14855361e-01f,
  -2.19267219e-01f, -9.41878650e-04f, 5.32184280e-02f, -5.23183346e-02f, -3.87332006e-03f, 5.06842472e-02f, 2.31407210e-01f, -6.84489496e-04f, 4.25456688e-02f, 1.48641527e-01f,
  8.17041099e-02f, 1.65557161e-01f, 1.06286840e-03f, 6.54623359e-02f, 1.15927674e-01f, 1.14995152e-01f, -8.52397382e-02f, -1.98465101e-02f, -8.90180469e-02f, 1.28725529e-01f,
  -4.81963158e-02f, -4.40726317e-02f, -1.70021251e-01f, -2.26318426e-02f, 3.42739634e-02f, -1.17252313e-01f, -7.96601474e-02f, 1.27911521e-02f, -1.81944147e-02f, -2.07663089e-01f,
  6.89598126e-03f, -9.45091993e-02f, 3.31366472e-02f, 5.90726174e-02f, 3.72870751e-02f, -9.48304534e-02f, -1.19653642e-01f, -1.28221273e-01f, -7.69015308e-03f, -7.74415815e-03f,
  5.55760227e-02f, -1.80463325e-02f, 2.35377420e-02f, -8.22196454e-02f, -7.22724199e-03f, -1.07770287e-01f, -2.88813487e-02f, -7.60135055e-02f, -1.62450656e-01f, -1.02433655e-02f,
  8.34799651e-03f, -1.04757249e-01f, -1.67277232e-02f, 1.18217662e-01f, 3.14185508e-02f, -6.83405548e-02f, 4.20780443e-02f, 2.60214716e-01f, 8.60122144e-02f, 5.01123369e-02f,
  -3.19908336e-02f, -5.52324392e-02f, -1.01763099e-01f, 4.71837297e-02f, -1.81340829e-01f, -3.63605469e-03f, -3.84635255e-02f, 1.25351518e-01f, -2.57510878e-02f, 2.00144574e-01f,
  4.36328799e-02f, -2.58747092e-03f, -3.41205969e-02f, -5.56990178e-03f, 1.23681426e-01f, -4.48417962e-02f, -1.82984442e-01f, -1.74166664e-01f, -1.26623824e-01f, -2.73382179e-02f,
  -9.55842659e-02f, -1.18339341e-02f, -1.69037312e-01f, -1.07685938e-01f, -9.39878970e-02f, -2.57017970e-01f, -1.84419185e-01f, -2.45293509e-02f, -1.90107465e-01f, -3.34051818e-01f,
  2.17438757e-01f, 2.53889799e-01f, 2.78434724e-01f, 4.82282117e-02f, -2.61519244e-03f, 1.53244391e-01f, 3.02648813e-01f, 1.78057864e-01f, -5.11824079e-02f, 1.30925670e-01f,
  -5.40400036e-02f, -2.26739973e-01f, -2.52804667e-01f, -1.62614301e-01f, 2.59152707e-02f, 7.58915767e-02f, 4.25602421e-02f, 2.08307765e-02f, -1.39943600e-01f, -6.04120269e-03f,
  -2.74605006e-01f, 2.76360288e-02f, -3.89833450e-02f, -1.46832854e-01f, 1.87121518e-02f, -3.10036093e-01f, -4.17936035e-02f, 8.84206146e-02f, 1.72130037e-02f, -1.76292509e-02f,
  2.28205919e-01f, 3.86126548e-01f, -2.65583873e-01f, -3.79834920e-02f, 4.42590676e-02f, -2.97065871e-03f, -4.42671441e-02f, -1.24439606e-02f, -2.94296090e-02f, -5.65872760e-03f,
  8.54649842e-02f, -6.79256544e-02f, -5.09948060e-02f, -2.62426157e-02f, 1.38364762e-01f, -1.07409261e-01f, 2.98388097e-02f, 6.03872836e-02f, 1.25225514e-01f, 8.89859945e-02f,
  3.46624367e-02f, 1.66660413e-01f, 3.55204374e-01f, 6.70696348e-02f, 3.19577903e-02f, -1.34259192e-02f, 5.52560166e-02f, 1.03453442e-01f, -6.57332223e-03f, 6.89610513e-03f,
  -1.12113602e-01f, 5.04569672e-02f, 1.20763201e-02f, 1.03933457e-02f, -4.89676045e-03f, 2.24840157e-02f, -6.61744028e-02f, -3.22800390e-02f, 1.93595572e-03f, -1.59875378e-02f,
  -5.87165728e-02f, 8.93785059e-02f, 1.70043886e-01f, -6.86792582e-02f, -8.90133902e-02f, 1.02513589e-01f, 6.49047270e-02f, 3.36362273e-02f, 5.74263372e-02f, 5.34897521e-02f,
  -4.16698530e-02f, 9.41996425e-02f, 5.37313558e-02f, -4.63987887e-02f, 2.42716167e-02f, -1.08141704e-02f, 7.54348002e-03f, 6.35223240e-02f, 5.67211397e-02f, -2.82839257e-02f,
  1.01876825e-01f, 2.19800640e-02f, -2.43410602e-01f, -5.09486534e-02f, 2.95267510e-03f, -9.88610983e-02f, -3.93698104e-02f, -9.48125944e-02f, 4.31253836e-02f, 4.62260023e-02f,
  1.78807497e-03f, -8.50559622e-02f, 1.20537765e-02f, -1.04427114e-01f, -2.06660256e-01f, -1.46332338e-01f, -1.62201628e-01f, -4.75801490e-02f, 5.00383638e-02f, 5.96401542e-02f,
  -1.45193219e-01f, -1.06159717e-01f, 6.48294315e-02f, -1.57880068e-01f, -1.57507569e-01f, -2.42315352e-01f, -1.71961665e-01f, 4.17889878e-02f, -4.13320027e-02f, -1.71174154e-01f,
  -4.26920682e-01f, -1.26192719e-01f, -5.99166676e-02f, 1.97963625e-01f, 2.75377452e-01f, 9.95428339e-02f, 3.06929350e-01f, 2.46715426e-01f, 1.70170173e-01f, -7.87557438e-02f,
  -2.03027368e-01f, -2.13067606e-01f, -1.36251643e-01f, -1.51477545e-01f, 4.63597700e-02f, 2.50419855e-01f, 1.48397788e-01f, 5.14716394e-02f, 1.27502410e-02f, -2.97517311e-02f,
  7.05102906e-02f, 1.34341449e-01f, -2.19903320e-01f, -2.49615349e-02f, 1.02254972e-01f, 5.32255433e-02f, -2.02563871e-02f, 1.25154987e-01f, -1.70521112e-03f, 5.04384339e-02f,
  -3.32354128e-01f, -3.04657072e-01f, -6.94549680e-02f, -1.59184292e-01f, -8.04911032e-02f, -4.69415896e-02f, -2.31150836e-02f, -1.22296587e-02f, 1.69825852e-01f, 9.53608379e-02f,
  1.74257740e-01f, -7.05024078e-02f, -6.99702725e-02f, -8.96106064e-02f, 1.02043703e-01f, -6.86921254e-02f, -6.61772117e-02f, 5.71020432e-02f, 8.48434195e-02f, -1.24455251e-01f,
  -5.77937998e-02f, 6.02571331e-02f, 1.71906978e-01f, 4.11878228e-02f, -1.32372277e-02f, -5.18354364e-02f, -9.74289104e-02f, -4.68294807e-02f, -3.45446654e-02f, 3.08120679e-02f,
  -3.19271907e-02f, 2.08427925e-02f, -2.74747163e-02f, 6.17643306e-03f, -6.17500059e-02f, -8.88705403e-02f, 1.76368862e-01f, 1.41984269e-01f, 2.74181589e-02f, -2.67634895e-02f,
  2.50352025e-01f, 1.03236169e-01f, 1.39649928e-01f, 1.12273507e-01f, -6.04419298e-02f, -1.30378269e-02f, -1.65800732e-02f, 1.73655469e-02f, -1.59594834e-01f, -8.56191590e-02f,
  -9.52657461e-02f, 2.36131623e-01f, -9.09744874e-02f, 3.48983705e-02f, -4.44360487e-02f, 7.58690387e-02f, 1.40987411e-01f, -6.81452006e-02f, 3.88058610e-02f, 9.60878804e-02f,
  3.39810550e-02f, -2.61762500e-01f, -1.41936675e-01f, -2.94139655e-03f, -4.51180413e-02f, -1.26070321e-01f, -1.78461045e-01f, 8.59791711e-02f, 9.54313800e-02f, 1.69683263e-01f,
  1.39453754e-01f, 1.18591767e-02f, -1.19322374e-01f, 3.03075984e-02f, -1.89021695e-02f, 1.33877704e-02f, -1.49407193e-01f, 1.26616105e-01f, 1.77168623e-01f, 2.48704199e-02f,
  9.17690992e-02f, 7.81588554e-02f, 1.76375046e-01f, 5.58934174e-02f, 7.10633919e-02f, 3.00042909e-02f, 9.58068743e-02f, 4.45628427e-02f, 1.73487425e-01f, 1.18948832e-01f,
  -1.77356616e-01f, 2.67827213e-01f, 5.45593388e-02f, 1.15632266e-01f, -6.43805861e-02f, -1.16727144e-01f, -6.73270598e-02f, 7.95021839e-03f, 5.61966375e-02f, 8.51429775e-02f,
  2.78653447e-02f, -5.85807934e-02f, -8.59222859e-02f, -6.01784512e-02f, -1.20084144e-01f, -1.37387797e-01f, -9.51917022e-02f, -2.26997077e-01f, -2.18823850e-01f, -1.34000897e-01f,
  -1.39975801e-01f, -1.71397366e-02f, -1.22145779e-01f, -1.10914506e-01f, 1.71529174e-01f, -7.06401765e-02f, 7.10034072e-02f, 1.38554797e-01f, 4.17948812e-02f, 3.33029538e-01f,
  2.42274135e-01f, 3.34695160e-01f, -1.18170373e-01f, 2.79650418e-03f, -1.00828148e-02f, -4.36540656e-02f, -1.08072445e-01f, 7.84898922e-02f, -6.87428564e-02f, -7.26412982e-04f,
  9.63113904e-02f, -4.61610630e-02f, -2.66254544e-02f, -9.15963575e-02f, 1.05944455e-01f, 1.21585988e-01f, -5.54946475e-02f, 1.98441353e-02f, -7.41524398e-02f, 1.13028094e-01f,
  3.53681296e-02f, 1.09146327e-01f, -9.36364173e-04f, -1.15341581e-01f, -6.46089166e-02f, 9.00212675e-02f, 1.35163769e-01f, 8.80888849e-02f, 1.44885918e-02f, 7.60644376e-02f,
  -2.47535586e-01f, -2.09517851e-01f, 3.53029035e-02f, -3.22362036e-02f, -1.69182971e-01f, -1.80146754e-01f, -7.06550628e-02f, -1.71297774e-01f, -2.22708553e-01f, -1.31247282e-01f,
  -7.37430528e-02f, -7.57221803e-02f, -2.57161446e-02f, -6.69385567e-02f, 3.96809280e-02f, 1.47540316e-01f, -2.57303342e-02f, 9.36669260e-02f, 9.59089547e-02f, 1.44189537e-01f,
  -1.03409169e-02f, -1.08810522e-01f, 2.95997951e-02f, -2.52505038e-02f, 1.61561891e-01f, -3.30783017e-02f, 1.19353924e-02f, 7.47030601e-02f, -4.44941483e-02f, -2.86446698e-02f,
  2.52487749e-01f, -4.01154812e-03f, 2.97053740e-03f, 3.38151120e-02f, 2.60018371e-03f, 1.81538656e-01f, 1.92593485e-01f, 1.15583532e-01f, 8.36639702e-02f, 2.29959339e-01f,
  1.31532475e-01f, -1.69871841e-02f, -4.42524953e-03f, -8.19498375e-02f, -1.96760088e-01f, -1.62574016e-02f, 8.88942368e-03f, 1.63354054e-02f, 1.27388358e-01f, 2.71578074e-01f,
  1.38816535e-01f, -5.13116233e-02f, -1.12417519e-01f, 3.13178338e-02f, -1.05620399e-01f, -6.07066751e-02f, -8.24887380e-02f, 1.13194570e-01f, -1.08955298e-02f, -1.89448267e-01f,
  -9.15212989e-01f, 9.28704143e-02f, 1.17077969e-01f, -2.24982575e-01f, 2.18081355e-01f, 1.49165511e-01f, 3.69723111e-01f, -2.26776768e-02f, -2.77863055e-01f, 9.75125059e-02f,
  9.83811989e-02f, -1.32760465e-01f, -1.09111611e-03f, 1.69911876e-01f, 4.70892154e-02f, 3.62602144e-01f, 3.27295423e-01f, -8.86929110e-02f, -1.09348476e-01f, 2.86836531e-02f,
  9.62320995e-03f, -1.13583788e-01f, -3.86755586e-01f, -2.38055930e-01f, -1.20959589e-02f, -3.87057774e-02f, 9.40559879e-02f, 4.11587358e-02f, 1.04338303e-01f, 3.19763944e-02f,
  1.79031923e-01f, -1.33105740e-01f, 5.41101098e-02f, -1.23120405e-01f, -1.10036984e-01f, -1.70694456e-01f, 4.39984072e-03f, -9.28381011e-02f, -5.81183564e-03f, -1.32177368e-01f,
  -6.79607317e-02f, -1.91530753e-02f, -1.25492007e-01f, 9.10012275e-02f, -1.37525335e-01f, -1.27082765e-01f, -4.47122322e-04f, -4.38967571e-02f, 1.87900260e-01f, 7.01796860e-02f,
  1.90637454e-01f, -5.78182563e-02f, -3.66536016e-03f, 1.25061959e-01f, 1.41273394e-01f, -8.79589468e-02f, 5.25997393e-02f, -5.92701137e-03f, -2.59132367e-02f, -1.96515575e-01f,
  -4.96101193e-03f, -1.39724119e-02f, 8.71772617e-02f, -8.24293643e-02f, -3.95522974e-02f, -2.21162196e-02f, 4.97967517e-03f, 1.29596189e-01f, 2.23979820e-02f, 6.38174787e-02f,
  2.52481587e-02f, 5.88934235e-02f, 1.02397226e-01f, -7.08691627e-02f, 2.14185260e-04f, -7.41997734e-03f, 1.56283181e-03f, -1.34087861e-01f, -5.07903919e-02f, -7.31433332e-02f,
  -6.52658055e-04f, 2.76730675e-02f, -1.50214538e-01f, 8.84815678e-02f, 7.71173984e-02f, -1.55376121e-01f, -2.24925596e-02f, -7.60375485e-02f, -9.50603373e-03f, 4.12718728e-02f,
  1.29742071e-01f, 7.55415931e-02f, -2.20947359e-02f, -1.12910417e-03f, 1.01678997e-01f, -5.76920547e-02f, -5.20411953e-02f, -3.47190374e-03f, 6.18005544e-02f, 3.51774022e-02f,
  -1.11142330e-01f, -1.23258187e-02f, 8.28276053e-02f, -4.86024134e-02f, -5.66969365e-02f, -5.46718799e-02f, 7.34816045e-02f, 9.97219756e-02f, 1.59649953e-01f, 6.51482493e-02f,
  2.21949704e-02f, 3.65209691e-02f, -3.35040838e-02f, 4.16822098e-02f, 7.56373480e-02f, -2.70994082e-02f, 2.25862097e-02f, -1.03019722e-01f, 8.97418186e-02f, -4.79143113e-03f,
  -1.75492600e-01f, -6.53747842e-02f, 3.11660528e-01f, 1.52115718e-01f, 2.81259894e-01f, -8.00075606e-02f, -4.72197026e-01f, -4.32227880e-01f, -7.43580684e-02f, -1.22533329e-02f,
  1.96619228e-01f, 2.18224928e-01f, 1.17060013e-01f, 3.59927416e-02f, -3.16487640e-01f, -2.37581387e-01f, -5.47191575e-02f, -7.05802515e-02f, -1.48182780e-01f, -6.33944497e-02f,
  2.16181539e-02f, -2.48093321e-03f, 7.13677555e-02f, -9.23110545e-02f, 5.75856632e-03f, 7.46546239e-02f, 1.80303618e-01f, 1.55705333e-01f, 1.25378743e-01f, 7.57229626e-02f,
  2.07595214e-01f, -1.20240472e-01f, -1.03779212e-01f, 2.47569367e-01f, 2.34589398e-01f, -1.71695083e-01f, -2.45651171e-01f, 3.80269513e-02f, 1.52824864e-01f, -7.27418140e-02f,
  2.58835554e-01f, 1.27761796e-01f, 2.17366621e-01f, -9.45316926e-02f, -9.01307911e-03f, -1.25982836e-01f, -8.76018256e-02f, -8.82629082e-02f, -1.29421145e-01f, -4.19821404e-03f,
  4.46661301e-02f, 2.33243614e-01f, 3.94804403e-02f, -6.99681789e-02f, -2.04511344e-01f, 1.14223696e-01f, -1.31939411e-01f, -1.17348902e-01f, -3.06510448e-01f, -3.26099843e-01f,
  1.49984304e-02f, 8.70285630e-02f, 8.65373164e-02f, 6.45623822e-03f, -9.66269523e-02f, 1.59282461e-01f, 9.22408421e-03f, -5.53080328e-02f, 5.37851155e-02f, 5.87774208e-03f,
  6.65102229e-02f, -1.22021660e-02f, 1.35897268e-02f, 3.07419933e-02f, 7.57087115e-03f, 2.52717398e-02f, -7.56651461e-02f, -4.96203452e-02f, 4.41088714e-02f, -1.17516890e-02f,
  -4.28294949e-02f, -3.90437362e-03f, 1.05581447e-01f, -1.90309472e-02f, 3.40612978e-02f, -9.44503918e-02f, -2.00608913e-02f, -2.31685013e-01f, -2.11684909e-02f, -3.52618322e-02f,
  8.09110049e-03f, 7.91907683e-02f, -8.76082778e-02f, -5.74500076e-02f, 1.29132256e-01f, 8.77489001e-02f, -3.38260308e-02f, 2.87309065e-02f, 4.82819974e-02f, -1.53842881e-01f,
  -6.11462295e-02f, -1.64631769e-01f, 3.62337194e-02f, 3.95259149e-02f, -9.88051444e-02f, 4.86635827e-02f, -1.38458852e-02f, 6.41259030e-02f, 7.82438144e-02f, 2.89015882e-02f,
  6.27601370e-02f, -1.86192021e-01f, -1.71605647e-01f, -1.76231146e-01f, -9.46138874e-02f, -9.32348743e-02f, -1.57171875e-01f, -1.28209621e-01f, -2.33031064e-01f, -4.04704392e-01f,
  -3.59624922e-01f, -1.47601709e-01f, -1.72806740e-01f, -4.64048296e-01f, -1.66090250e-01f, 1.12330720e-01f, -4.60510291e-02f, 1.71682909e-01f, -4.43094671e-02f, -2.29919642e-01f,
  -8.99683461e-02f, -4.85624075e-02f, -1.55903623e-01f, -4.46000472e-02f, 3.39663140e-02f, -2.47133344e-01f, -2.03036293e-01f, 9.02132038e-03f, 2.74165183e-01f, 3.91479939e-01f,
  1.22205734e-01f, -1.49808034e-01f, -2.49301735e-02f, -1.74266156e-02f, -1.02485947e-01f, 1.04419097e-01f, -7.15147033e-02f, -7.82770384e-03f, 1.44704163e-01f, -1.91278398e-01f,
  -2.64271319e-01f, -9.88852456e-02f, 2.66777817e-02f, -4.40680161e-02f, -2.06213996e-01f, 9.47499066e-04f, 2.07105316e-02f, -9.95125845e-02f, -3.38258296e-02f, -8.78165364e-02f,
  3.93964984e-02f, -1.23821886e-03f, -8.87261629e-02f, -1.54181728e-02f, -3.65690961e-02f, 1.10519715e-01f, -1.60766765e-04f, 6.83009923e-02f, 1.50982410e-01f, 1.83403846e-02f,
  1.57135621e-01f, 4.74363640e-02f, 1.00743026e-02f, 2.10056767e-01f, 3.35907489e-01f, 9.68405455e-02f, 1.90827176e-01f, 2.23871052e-01f, 2.48118266e-01f, 5.18396758e-02f,
  1.57011673e-01f, -4.06356528e-02f, 1.12246171e-01f, 6.07641004e-02f, -3.93346846e-02f, -5.58610745e-02f, 3.73581871e-02f, 5.83939254e-02f, 5.66409305e-02f, -4.71566431e-02f,
  2.59202868e-02f, 8.43755901e-03f, 1.36706186e-03f, 5.10016270e-02f, -7.30041042e-02f, -1.18794322e-01f, 5.86264729e-02f, 1.27178999e-02f, 7.90800080e-02f, -2.51847841e-02f,
  1.84907194e-03f, 9.04311612e-02f, -1.00939080e-01f, 3.25284749e-02f, -6.31762994e-03f, -1.34564564e-01f, 1.69202164e-02f, 1.06759734e-01f, -9.47964415e-02f, 5.06641530e-02f,
  -1.24144010e-01f, 1.06143773e-01f, -2.83091277e-01f, 1.05495945e-01f, -2.14443371e-01f, -8.76165032e-02f, -1.43085554e-01f, -1.27986506e-01f, -7.70465806e-02f, -2.56721508e-02f,
  1.81893110e-01f, -3.01300529e-02f, -4.03995290e-02f, -6.94794878e-02f, 5.75362332e-02f, 3.02854758e-02f, -9.06627029e-02f, -1.46057725e-01f, 1.38182014e-01f, -2.55775210e-02f,
  -1.71092600e-02f, 9.10576805e-02f, -1.66141000e-02f, 2.72422563e-02f, 1.44221738e-01f, -2.42797378e-02f, -4.16541770e-02f, 7.85162970e-02f, 2.27397420e-02f, -1.06751636e-01f,
  -2.27565214e-01f, -4.42170441e-01f, 2.84109950e-01f, 1.54094100e-01f, 3.75171214e-01f, 3.05458993e-01f, 1.88304082e-01f, 7.53484294e-03f, 1.03821956e-01f, -9.50296372e-02f,
  -3.06947827e-01f, -3.00318986e-01f, -2.28461295e-01f, -2.28836700e-01f, -1.52793542e-01f, 6.37758523e-02f, 2.02292293e-01f, 1.29534066e-01f, 1.92235485e-01f, 1.73983335e-01f,
  4.35330607e-02f, 4.81689572e-02f, -1.01256333e-01f, -3.59443687e-02f, 2.46659368e-02f, 5.72766066e-02f, -5.36434501e-02f, -2.76787765e-02f, -1.59666259e-02f, -5.80482073e-02f,
  -4.60197441e-02f, -2.11360335e-01f, 6.60195649e-02f, -1.17087401e-01f, -1.42954782e-01f, -1.20964751e-01f, 1.98693499e-02f, 5.65587170e-02f, 7.69753233e-02f, 1.38061568e-01f,
  -2.98634153e-02f, -5.50211929e-02f, 3.57785495e-04f, 1.92150623e-02f, 4.98845391e-02f, -3.64092104e-02f, -1.42356247e-01f, 1.11399470e-02f, 1.05297357e-01f, -5.67263141e-02f,
  -1.05745196e-01f, 3.25369136e-03f, 6.63332492e-02f, 2.09264457e-02f, -4.65209149e-02f, 8.95215273e-02f, -5.76991811e-02f, -7.94291496e-02f, 9.35880989e-02f, 1.18886814e-01f,
  2.59253662e-03f, 1.27630875e-01f, -1.57485664e-01f, -1.44212078e-02f, -2.77668796e-02f, 1.88601106e-01f, 8.91411081e-02f, 9.16453153e-02f, 2.19546980e-03f, -8.27492550e-02f,
  1.97481513e-02f, 1.03805147e-01f, 3.70197706e-02f, -2.04453524e-03f, -2.36740232e-01f, -3.11370417e-02f, 1.01869382e-01f, -1.56521033e-02f, -7.26427510e-02f, -1.43271461e-01f,
  -1.40546575e-01f, 4.11420129e-02f, -2.12915484e-02f, -7.35401139e-02f, -3.49939638e-03f, 4.65893894e-02f, -4.14083563e-02f, -1.42628923e-01f, -4.41175736e-02f, 4.22312282e-02f,
  5.20554546e-04f, -2.84046710e-01f, -3.28560546e-02f, -4.89297807e-02f, -1.76618770e-02f, -1.61159128e-01f, -2.47062579e-01f, 3.88923325e-02f, 3.07383649e-02f, 1.13151088e-01f,
  -4.74538617e-02f, 2.71295048e-02f, -9.85325649e-02f, 1.33810872e-02f, 8.16832036e-02f, 6.59157485e-02f, -1.17711350e-01f, 1.08288944e-01f, -5.81348725e-02f, 2.96583325e-02f,
  4.93893623e-02f, 1.98516235e-01f, 2.43033230e-01f, 6.77829310e-02f, 1.19854242e-01f, 2.00529993e-01f, 6.16565719e-02f, 3.09258811e-02f, 1.79879263e-01f, 1.83784008e-01f,
  -4.14166190e-02f, 4.38708812e-01f, -6.12115860e-02f, 2.62170415e-02f, -2.12068424e-01f, -2.77468354e-01f, 5.13740815e-03f, 1.12357214e-01f, -1.12580573e-02f, 5.94200939e-02f,
  -3.25214565e-01f, -2.61274666e-01f, -9.61776078e-02f, -1.41888773e-02f, 8.72021839e-02f, 2.28541955e-01f, 3.10441226e-01f, 1.18120216e-01f, -2.61077762e-01f, -2.10397020e-01f,
  3.53983231e-02f, -7.83582591e-03f, -9.19695124e-02f, 7.24529997e-02f, 1.26456067e-01f, -8.06403011e-02f, -3.81245986e-02f, -1.23876348e-01f, -2.50508748e-02f, 4.15279835e-01f,
  -2.53087044e-01f, -1.37478024e-01f, -5.52591495e-02f, 3.38666216e-02f, -4.97039855e-02f, 1.95658371e-01f, 2.04453077e-02f, 4.70389193e-03f, -1.25565767e-01f, -7.57286027e-02f,
  -3.16115958e-03f, -3.44363600e-02f, -7.13928742e-03f, -2.07636133e-02f, -9.20009688e-02f, -3.86565030e-02f, 1.68571509e-02f, 1.09726682e-01f, 1.08302407e-01f, 4.53629345e-02f,
  1.87261373e-01f, -2.49430165e-01f, -1.32626757e-01f, 5.67415468e-02f, 1.27616391e-01f, -2.40863919e-01f, -1.92016736e-01f, -5.83608299e-02f, -1.33174151e-01f, 1.22868717e-01f,
  -1.49786547e-01f, 2.72458550e-02f, 1.06986180e-01f, 6.22457685e-03f, -7.75494352e-02f, -5.75987883e-02f, 1.21677620e-02f, -7.63549760e-04f, -1.37413181e-02f, 4.30326797e-02f,
  -1.49388229e-02f, -1.49083003e-01f, -1.84121560e-02f, 2.86748149e-02f, -4.00733836e-02f, 6.52913377e-03f, 4.85036597e-02f, 5.55983894e-02f, -1.23513229e-01f, -2.92118285e-02f,
  8.14126525e-03f, 9.26188827e-02f, -7.10532889e-02f, -1.34757934e-02f, 9.27962810e-02f, -2.00497024e-02f, 8.06194320e-02f, -5.45780249e-02f, 2.66201477e-02f, -1.27215624e-01f,
  -2.48999402e-01f, -4.93102521e-01f, -1.66037455e-02f, 2.13055909e-01f, 4.75449562e-02f, 7.34765306e-02f, 1.69927627e-03f, -7.59970546e-02f, 4.06236090e-02f, -7.94730112e-02f,
  1.52895063e-01f, 6.98070275e-03f, 1.31340012e-01f, -3.83957662e-02f, 1.23266634e-02f, -7.53435248e-04f, 4.19275165e-02f, 3.83712798e-02f, 1.79063275e-01f, -7.97865763e-02f,
  1.04776971e-01f, -4.89494205e-02f, -8.48566890e-02f, 5.91842271e-02f, -6.90964703e-03f, -1.41464144e-01f, -1.66612357e-01f, 1.94640514e-02f, -1.05810530e-01f, 1.32456526e-01f,
  -3.68942529e-01f, 2.19505131e-01f, -4.15783703e-01f, 9.52230990e-02f, 1.30557671e-01f, 2.75792237e-02f, 2.54640460e-01f, 1.47782773e-01f, 1.87854663e-01f, 5.37018105e-02f,
  -2.39365309e-01f, -1.46623299e-01f, -1.54167458e-01f, -8.54284391e-02f, -1.46555277e-02f, 2.70319641e-01f, 3.30467999e-01f, -5.66487089e-02f, -2.28833452e-01f, 6.37783408e-02f,
  2.66745210e-01f, 1.50241852e-01f, -5.07876985e-02f, 9.87712108e-03f, 4.14393172e-02f, 1.93257723e-02f, -1.90884173e-02f, -3.44580188e-02f, 3.13737281e-02f, 1.67485133e-01f,
  -5.25617301e-01f, -2.57007807e-01f, 4.13550623e-02f, 6.89067468e-02f, -1.24995179e-01f, -1.53898178e-02f, 5.11334650e-02f, 6.99104592e-02f, 1.18567934e-02f, 2.02213719e-01f,
  8.86149798e-03f, -5.07286713e-02f, -5.97470552e-02f, 3.40408348e-02f, 8.55512172e-02f, -7.88608864e-02f, 1.67917591e-02f, 3.27090174e-02f, 2.43459940e-02f, -1.58472911e-01f,
  -1.37917427e-02f, -1.85115635e-01f, -6.37232140e-02f, 1.38193905e-01f, -1.85029715e-01f, -4.74633873e-02f, -1.24346703e-01f, -4.10943143e-02f, -1.45596638e-01f, 1.58063740e-01f,
  1.03848651e-01f, 3.23044471e-02f, -1.71389401e-01f, -4.61566523e-02f, 1.41343465e-02f, 3.98808457e-02f, -6.42185509e-02f, -5.95575683e-02f, -1.15097009e-01f, 1.04445396e-02f,
  1.35517851e-01f, -8.08552504e-02f, 2.29016021e-02f, 3.08731608e-02f, 2.26113456e-03f, 4.39942405e-02f, -3.53262424e-02f, -3.88868339e-02f, -1.32009104e-01f, 6.97592050e-02f,
  -1.79790795e-01f, 1.11668050e-01f, -4.06288318e-02f, 2.62264349e-02f, 5.18155433e-02f, -1.16824642e-01f, -1.01142973e-01f, -5.14327502e-03f, 2.87568604e-04f, 1.58347428e-01f,
  4.92935687e-01f, -2.46002808e-01f, -2.07594093e-02f, -2.20384356e-03f, -9.16957483e-02f, -1.61718309e-01f, -1.82440013e-01f, -1.45687446e-01f, 4.53862622e-02f, 8.51484463e-02f,
  7.03681409e-02f, -6.82265460e-02f, -7.58345649e-02f, -4.23223153e-02f, 2.33770814e-02f, -8.18638802e-02f, -1.61716342e-02f, 1.04570121e-01f, 4.73571708e-03f, 8.13071951e-02f,
  2.40998864e-01f, 1.83741704e-01f, 5.44648916e-02f, 7.79768899e-02f, 9.16432440e-02f, 8.00447315e-02f, 1.44223675e-01f, 1.09195419e-01f, 3.11344620e-02f, 3.34453613e-01f,
  -4.42291677e-01f, -5.37797511e-02f, 7.50002488e-02f, -4.58214998e-01f, -1.92658186e-01f, -2.13588968e-01f, 8.46935362e-02f, -3.51899147e-01f, -3.93288195e-01f, -3.68567221e-02f,
  -7.38227814e-02f, -4.70711142e-02f, 4.17019092e-02f, 4.71155494e-02f, 4.92888577e-02f, 1.80745184e-01f, 3.60246142e-03f, 1.57784283e-01f, 1.82330325e-01f, -9.80857238e-02f,
  -4.28106114e-02f, 1.33191394e-02f, -1.45248905e-01f, -9.59119946e-02f, -8.68744478e-02f, 2.34815348e-02f, -2.37478074e-02f, -4.40674759e-02f, -1.16073638e-01f, -1.41514033e-01f,
  3.88886780e-01f, -3.06889683e-01f, -1.52226007e-02f, -1.30261526e-01f, -1.08931646e-01f, -1.63782582e-01f, 7.31681734e-02f, -5.10430597e-02f, -2.00872153e-01f, -1.09159220e-02f,
  -3.76543887e-02f, -2.76624281e-02f, 7.06103805e-04f, 9.89366099e-02f, -7.79222399e-02f, 7.36151412e-02f, -4.38521914e-02f, -1.63454250e-01f, -4.02045287e-02f, -4.91226427e-02f,
  -7.84571543e-02f, -4.13961932e-02f, -3.17711830e-02f, -3.68702505e-03f, -6.50598183e-02f, 3.73615697e-02f, -7.49554634e-02f, -1.74432501e-01f, -7.36649409e-02f, -9.20875967e-02f,
  7.75549561e-02f, 2.16097087e-02f, -7.91886374e-02f, 2.90647261e-02f, -4.91885189e-03f, -1.74907092e-02f, 7.25862160e-02f, -5.80017194e-02f, -4.10908051e-02f, -3.48649779e-03f,
  9.42077546e-04f, -4.02261354e-02f, -1.00509234e-01f, 2.65278388e-02f, -4.02165502e-02f, -1.49282664e-01f, -7.26234540e-02f, -4.30832105e-03f, -1.87396482e-02f, -1.18296914e-01f,
  -1.53188914e-01f, -5.26347496e-02f, -5.78449015e-03f, 5.78023121e-02f, -9.83998030e-02f, -5.78701161e-02f, 1.78750872e-03f, -2.39054170e-02f, 3.88147496e-02f, -7.07393438e-02f,
  1.38671219e-01f, -3.06148212e-02f, 2.65985638e-01f, -4.14463095e-02f, -9.44997221e-02f, -4.50978056e-02f, -9.90588963e-02f, 1.20582700e-01f, 1.85233206e-02f, 1.02547586e-01f,
  -2.52125338e-02f, 6.49506897e-02f, 1.20246507e-01f, 1.28892753e-02f, 1.25574008e-01f, 4.69116829e-02f, -4.87652272e-02f, 1.67538710e-02f, -8.80124792e-02f, 3.59280370e-02f,
  -1.64711475e-01f, 6.22901600e-03f, 1.16445377e-01f, 1.06123529e-01f, 6.67396933e-02f, 1.22689448e-01f, 2.52413452e-01f, 8.47164243e-02f, 1.42889887e-01f, 1.20363049e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  -5.14100306e-03f, 1.50616378e-01f, -2.32495703e-02f, 3.73421647e-02f, 1.68384854e-02f, 9.20158848e-02f, 4.95313294e-03f, -1.01884484e-01f, 7.79017955e-02f, 1.48698865e-02f,
  4.74525653e-02f, 3.70372692e-03f, 1.92015562e-02f, 6.41051531e-02f, 1.18286042e-02f, 3.13736908e-02f, 1.17424890e-01f, 1.29178792e-01f, -4.34588343e-02f, 1.85361370e-01f,
  -2.07959395e-02f, 1.62758037e-01f, 2.64176726e-02f, 7.59411603e-02f, 1.06745973e-01f, -2.43441090e-02f, 6.77104890e-02f, 1.14516884e-01f, 4.35642898e-02f, -8.65258574e-02f,
  -2.65505607e-03f, -1.05789699e-01f, -1.27075255e-01f, 1.12262331e-01f, 1.68726279e-03f, -1.62315033e-02f, -2.16675490e-01f, 5.39731793e-02f, 6.40512779e-02f, -1.69734657e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  7.89064243e-02f, 1.68652087e-02f, -5.81771210e-02f, 2.31510773e-02f, -2.03083321e-01f, -1.33648157e-01f, -7.30290785e-02f, -1.22575216e-01f, -2.83214808e-01f, 1.35957953e-02f,
  5.82271367e-02f, -1.51588082e-01f, -3.04788649e-01f, 1.08944349e-01f, -1.63528234e-01f, -1.71531990e-01f, 1.96482673e-01f, -1.31162778e-01f, -7.53917098e-02f, -1.57357603e-02f,
  1.06552854e-01f, 6.25333339e-02f, -6.72200918e-02f, -2.32130840e-01f, -6.76953346e-02f, -5.21205366e-02f, 1.44149572e-01f, 9.05784518e-02f, 2.10769139e-02f, 7.33352313e-03f,
  1.08253602e-02f, 8.86468440e-02f, 1.06170564e-03f, 2.16888875e-01f, -1.00469645e-02f, -2.55038232e-01f, 2.34159186e-01f, -1.37609065e-01f, -9.97046158e-02f, 2.34949440e-01f,
  -1.47051513e-01f, 1.90881323e-02f, -2.03603387e-01f, 1.64590806e-01f, -3.48896086e-01f, -1.05321087e-01f, -2.09797487e-01f, -2.52685636e-01f, -2.62610316e-01f, 1.92937896e-01f,
  -7.16707781e-02f, -2.36296263e-02f, -1.07913978e-01f, -2.57833809e-01f, -4.96725664e-02f, 2.51217365e-01f, 7.73356557e-02f, -4.70074266e-02f, -3.08811188e-01f, 1.11199850e-02f,
  1.77438527e-01f, -5.54540474e-03f, 3.28928977e-01f, 1.26415730e-01f, 9.94798690e-02f, 9.65872034e-02f, -6.84756786e-02f, -2.00224598e-03f, 5.18665314e-02f, 2.52056401e-02f,
  -5.34903184e-02f, -9.12807509e-02f, 1.48415014e-01f, -1.22488976e-01f, 5.40057793e-02f, 9.56018567e-02f, -2.17701457e-02f, -4.20773476e-02f, -1.32674962e-01f, 8.01463351e-02f,
  9.04666260e-02f, 1.64780691e-02f, 1.60052080e-03f, 6.22899458e-02f, -1.95969492e-01f, -3.22825462e-02f, 8.23686570e-02f, -1.00291090e-05f, 1.48028582e-01f, 1.70225844e-01f,
  4.64090966e-02f, 5.80491349e-02f, -1.52029350e-01f, 1.07666869e-02f, -3.50732952e-02f, 4.24466878e-02f, -1.55682504e-01f, 6.43050149e-02f, -2.90038317e-01f, 2.84809228e-02f,
  9.46648568e-02f, -3.65028419e-02f, 8.36000219e-02f, 6.42162887e-03f, 7.43171200e-02f, -2.70850112e-04f, 7.67763853e-02f, -5.51639013e-02f, 2.71618795e-02f, 1.20841265e-01f,
  2.31835127e-01f, -1.07395843e-01f, 2.72268593e-01f, 1.17926835e-03f, 5.13165891e-02f, -2.46702358e-02f, -9.51717645e-02f, -1.57006651e-01f, 3.93739752e-02f, 2.23394200e-01f,
  7.77751058e-02f, 9.00145695e-02f, 2.81187415e-01f, -1.99705556e-01f, -3.53534473e-03f, 1.83767378e-01f, 7.69699141e-02f, -1.72202766e-01f, 2.12790053e-02f, 3.21351327e-02f,
  9.32059288e-02f, 8.56211782e-02f, 9.05026346e-02f, 5.20736799e-02f, -4.00257595e-02f, -1.59774870e-01f, -3.87169160e-02f, 6.06024917e-03f, -1.42098039e-01f, -1.45964805e-04f,
  -1.52759925e-02f, -2.36446470e-01f, -2.54206210e-01f, 8.06641579e-02f, -2.47215882e-01f, -1.28791273e-01f, 4.50757630e-02f, -1.31313860e-01f, -9.41899195e-02f, 2.69016117e-01f,
  6.86504170e-02f, 1.87168449e-01f, -2.54103720e-01f, -1.18436450e-02f, 5.28122038e-02f, 1.58876568e-01f, -8.03293511e-02f, -5.08367121e-02f, -2.61940092e-01f, 1.03113413e-01f,
  -2.07950119e-02f, 1.98694319e-01f, -5.27010486e-02f, -1.97572690e-02f, 1.65381745e-01f, 1.71785355e-01f, 6.97091967e-03f, 1.58394635e-01f, -2.77192801e-01f, -1.05042852e-01f,
  -7.56131038e-02f, -1.70883834e-01f, -1.87784865e-01f, -1.66851774e-01f, -8.46191272e-02f, 2.55458951e-01f, 9.78321061e-02f, -1.77497283e-01f, -3.48248743e-02f, 1.68694571e-01f,
  2.76358396e-01f, 2.16035306e-01f, 2.73046866e-02f, 2.34990582e-01f, 1.31608859e-01f, -1.41843170e-01f, -1.72276512e-01f, -1.09774582e-01f, 2.88039446e-01f, 3.06148753e-02f,
  2.20151737e-01f, -2.38317341e-01f, -4.23229970e-02f, 1.07463695e-01f, -1.56252965e-01f, -5.09946346e-02f, 2.62362361e-02f, -4.48143296e-02f, 4.20493260e-03f, -1.61945269e-01f,
  9.26989317e-02f, 1.00542396e-01f, 1.29629329e-01f, -2.47311400e-04f, -3.61464210e-02f, 6.14358261e-02f, -1.25677466e-01f, 1.60423126e-02f, 2.05913350e-01f, -1.13386676e-01f,
  -5.05082645e-02f, -1.62637427e-01f, 9.75437388e-02f, -3.61381918e-01f, 9.97633636e-02f, 2.00962409e-01f, 1.30479932e-01f, 1.85969502e-01f, 2.45343938e-01f, -7.80005455e-02f,
  -4.27198298e-02f, 7.81184703e-04f, 8.80191773e-02f, 2.25508407e-01f, -2.21023604e-01f, -7.38680139e-02f, -8.76166001e-02f, -7.51000047e-02f, 2.36043453e-01f, 1.75253019e-01f,
  1.51180446e-01f, 1.03128642e-01f, -1.05470292e-01f, -3.32703978e-01f, 2.50764757e-01f, 1.00881651e-01f, -3.52117807e-01f, -1.41543984e-01f, 3.34537812e-02f, 7.98324198e-02f,
  4.07714993e-02f, 4.37011197e-02f, -2.50590652e-01f, 9.83586237e-02f, 6.96815848e-02f, 2.14238856e-02f, 5.90692274e-02f, -2.81043462e-02f, 2.28485897e-01f, -6.85613900e-02f,
  1.62798852e-01f, 5.44085801e-02f, -9.41014066e-02f, -1.06616251e-01f, 7.02762157e-02f, -2.22356692e-01f, 5.84467277e-02f, -2.15270117e-01f, 1.28429502e-01f, -1.20630726e-01f,
  1.11599945e-01f, 7.63156870e-03f, -1.75135329e-01f, 4.73101959e-02f, -9.23768952e-02f, -6.55403435e-02f, -1.98945448e-01f, -1.62438527e-01f, 6.36968687e-02f, 2.23577432e-02f,
  6.38629720e-02f, -4.64546448e-03f, -3.04822534e-01f, 1.35044426e-01f, -1.89253576e-02f, -1.35583401e-01f, 3.01896274e-01f, 1.87738210e-01f, -1.83874927e-02f, 3.05274855e-02f,
  -3.08027938e-02f, 1.21792994e-01f, 1.89511240e-01f, -7.05356970e-02f, 9.46602225e-03f, -1.03220448e-01f, 1.39848471e-01f, -4.41435724e-02f, 4.83196452e-02f, 9.29771140e-02f,
  -1.23374596e-01f, -1.52988195e-01f, 1.24824435e-01f, -3.08836788e-01f, -1.31860748e-01f, 4.25811633e-02f, 1.42666012e-01f, 1.26523718e-01f, -1.03642210e-01f, -1.45588309e-01f,
  2.75516082e-02f, 7.32456595e-02f, -2.13727608e-01f, -8.73032659e-02f, -4.28326011e-01f, -4.70777079e-02f, -3.09441313e-02f, -1.74440935e-01f, -4.04306352e-02f, -3.13890994e-01f,
  4.42379341e-02f, 1.36698797e-01f, -8.80677924e-02f, -1.42291129e-01f, -2.35387817e-01f, -4.39165980e-02f, 1.53508604e-01f, -7.83499330e-02f, -1.70356229e-01f, 1.94793954e-01f,
  2.32301667e-01f, 2.63637930e-01f, -1.57764480e-01f, -3.97656709e-02f, -6.21477666e-04f, 1.95799544e-01f, -2.03679070e-01f, 1.59913581e-02f, 7.03744888e-02f, 1.66456074e-01f,
  7.03128129e-02f, 1.71403706e-01f, 1.61669284e-01f, -4.90595773e-02f, 3.88574935e-02f, 1.45475745e-01f, 2.58586612e-02f, 2.60545492e-01f, 8.45468566e-02f, 2.64047444e-01f,
  -1.05881493e-03f, 1.62116066e-01f, 6.70463815e-02f, -1.93192288e-01f, 2.33591218e-02f, 2.17558909e-02f, 4.77475710e-02f, -4.86776493e-02f, 6.05327636e-02f, 1.06671937e-01f,
  8.44643340e-02f, -8.64647254e-02f, 3.96850556e-01f, -6.80719409e-03f, -9.72256064e-02f, -5.98075725e-02f, 8.80479291e-02f, -1.46091685e-01f, 7.98675269e-02f, -1.03635035e-01f,
  5.30692823e-02f, 2.12454692e-01f, 2.28360482e-02f, 9.67291072e-02f, 3.76889184e-02f, 3.33500683e-01f, 1.60190389e-01f, -2.29539558e-01f, 1.21162355e-01f, -7.80311599e-02f,
  5.64207621e-02f, -1.82787195e-01f, -4.68853787e-02f, -1.47620186e-01f, -4.48214170e-03f, 1.43334627e-01f, 2.79730256e-03f, 3.34550083e-01f, 1.25384614e-01f, -2.36350000e-01f,
  2.90377717e-02f, 1.17726229e-01f, 2.36127898e-01f, 1.25352427e-01f, -1.74968302e-01f, -4.68485383e-03f, -1.25775591e-01f, -6.42390102e-02f, -6.14318773e-02f, 6.99154809e-02f,
  6.19542785e-03f, 9.67588276e-03f, -1.44523174e-01f, -1.46717608e-01f, -1.45676538e-01f, -9.63296145e-02f, 4.06172365e-01f, -7.61556104e-02f, -5.89763280e-03f, 8.28936172e-04f,
  2.17446983e-02f, 1.50876328e-01f, 1.83236286e-01f, 4.11307625e-02f, -1.25577614e-01f, 2.90928364e-01f, 3.89048271e-02f, -8.70964751e-02f, -2.24411875e-01f, 9.02241468e-02f,
  -8.72362480e-02f, 1.84814155e-01f, 6.03112802e-02f, 8.03660825e-02f, 1.93986461e-01f, -7.26091815e-03f, 1.85110852e-01f, -7.13752285e-02f, -1.57945067e-01f, -2.90736109e-02f,
  1.17598688e-02f, -5.59469722e-02f, -1.61792323e-01f, 5.06776236e-02f, 5.92361030e-04f, 1.04364306e-02f, -7.39879310e-02f, -2.90881962e-01f, 2.69809157e-01f, 1.10590853e-01f,
  -3.68770435e-02f, -5.10355420e-02f, 8.77011046e-02f, -1.86545342e-01f, -5.28167412e-02f, -1.14246644e-01f, -1.58923827e-02f, -2.75222749e-01f, 2.94198662e-01f, 3.85064036e-02f,
  1.32836178e-01f, 9.27710831e-02f, -2.23886192e-01f, 1.59623101e-01f, 8.63192007e-02f, 3.08215350e-01f, 8.91982391e-02f, -3.30942094e-01f, -3.47410999e-02f, -9.00883153e-02f,
  -2.00517997e-01f, 3.50352153e-02f, -8.83163325e-03f, -3.35432775e-03f, 2.16807052e-02f, -2.55633015e-02f, 6.04601689e-02f, 4.70858905e-03f, -9.29902494e-03f, -1.87338982e-02f,
  7.74132013e-02f, -8.52071121e-02f, -1.91652998e-02f, 1.17043123e-01f, 1.93644390e-01f, -6.63519725e-02f, 3.08224149e-02f, 9.91084427e-03f, -1.31776273e-01f, 5.71348742e-02f,
  1.93688095e-01f, -2.65250858e-02f, 2.51559228e-01f, -1.10162236e-01f, 2.81690322e-02f, -1.24896593e-01f, 1.25423372e-02f, 1.26810260e-02f, 4.10521589e-02f, 3.35251614e-02f,
  -1.76706761e-01f, -1.54363319e-01f, -1.18877903e-01f, 2.16005355e-01f, 2.20435746e-02f, 7.35406503e-02f, 1.14238009e-01f, -6.63609579e-02f, -1.11946143e-01f, -1.29370376e-01f,
  8.00590888e-02f, -4.57639024e-02f, -2.34389305e-01f, -9.85284671e-02f, 4.65186164e-02f, 2.13205479e-02f, 2.25589052e-01f, 9.37170535e-02f, -5.56463674e-02f, -1.55824404e-02f,
  1.53181568e-01f, 1.16082586e-01f, -4.31055948e-02f, -5.44731133e-02f, -1.11775212e-02f, -6.26341300e-03f, 4.32634540e-02f, 1.65262371e-02f, -1.38397351e-01f, 1.07665159e-01f,
  2.00726882e-01f, -2.27742806e-01f, -1.31497115e-01f, -3.74559476e-03f, -6.41674846e-02f, 3.34673636e-02f, -4.79326071e-03f, -4.38249633e-02f, 2.99580432e-02f, -3.84749770e-02f,
  1.16865724e-01f, -2.71317158e-02f, -8.56864303e-02f, -3.45867760e-02f, 9.35590640e-02f, 4.47897650e-02f, 1.68969572e-01f, -2.53077634e-02f, 3.62643376e-02f, -1.82866049e-03f,
  1.01611584e-01f, -1.17311254e-01f, 1.60944596e-01f, 4.12383378e-02f, 6.09649606e-02f, 6.32380694e-03f, 5.25143594e-02f, 4.76129204e-02f, -1.66416213e-01f, -6.81380406e-02f,
  9.33803618e-02f, -2.05757678e-01f, -7.40073696e-02f, 1.76173113e-02f, -2.81124800e-01f, -7.97166526e-02f, -1.20559946e-01f, 5.77735044e-02f, -1.76314265e-02f, 2.10312858e-01f,
  9.56187099e-02f, -1.50951996e-01f, 4.40017357e-02f, -7.50207901e-02f, -2.19506044e-02f, -1.26959622e-01f, -1.72248796e-01f, -5.72296008e-02f, 1.02406489e-02f, 2.70118862e-01f,
  2.85634160e-01f, -2.47665942e-01f, 4.01117727e-02f, 1.91907689e-01f, 5.78093827e-02f, 1.08864978e-01f, 4.43448499e-02f, 2.61107809e-03f, 5.06802415e-03f, -3.00748110e-01f,
  1.52874693e-01f, 1.02202281e-01f, -9.17929411e-02f, -1.62544176e-01f, -3.76553982e-02f, -7.07649812e-02f, -1.26354232e-01f, 2.78820693e-02f, 1.31451756e-01f, -1.01306491e-01f,
  2.78239734e-02f, -3.36799137e-02f, 1.98021337e-01f, -3.03906277e-02f, -1.90641964e-04f, -5.81913143e-02f, 5.26827760e-02f, -6.59772158e-02f, -1.27095640e-01f, 3.38001624e-02f,
  8.12062323e-02f, -3.19752805e-02f, 1.43172607e-01f, -1.18082434e-01f, -1.73570793e-02f, -1.54445156e-01f, 1.21125124e-01f, -1.75646003e-02f, 6.06578030e-02f, 1.51322842e-01f,
  -3.77739042e-01f, -1.32842824e-01f, -3.89699377e-02f, -1.69570446e-01f, 9.12530869e-02f, 1.62115127e-01f, -1.65538117e-01f, -3.67312320e-02f, 1.95184201e-01f, -1.51772410e-01f,
  3.18405569e-01f, -1.60147324e-01f, -3.90145853e-02f, 3.59758556e-01f, 5.18168248e-02f, -1.17336407e-01f, 1.23044647e-01f, 1.20780632e-01f, -3.02709043e-02f, -7.96575919e-02f,
  -1.57424039e-03f, -1.86138466e-01f, -2.14351416e-01f, 2.19341546e-01f, 3.03464562e-01f, 1.64904386e-01f, 1.69409811e-01f, 1.58327147e-02f, 4.61459644e-02f, 1.16747677e-01f,
  -2.47168198e-01f, -1.26663670e-01f, -9.62439477e-02f, 1.49918318e-01f, -2.50205040e-01f, 2.23430470e-01f, -1.76590055e-01f, -4.49450500e-02f, -1.62379313e-02f, 1.58495247e-01f,
  -1.09844647e-01f, -1.93595234e-02f, 1.96920142e-01f, 1.21739516e-02f, -5.54872043e-02f, 8.81425887e-02f, -3.33180167e-02f, -8.68355781e-02f, -1.37042060e-01f, -1.08088471e-01f,
  -6.35184571e-02f, 1.09240383e-01f, -6.18494377e-02f, -3.45204137e-02f, 1.16016626e-01f, -9.44921840e-03f, -2.45153859e-01f, 2.82896250e-01f, -1.14286512e-01f, 1.36424944e-01f,
  -8.10573101e-02f, -1.38117835e-01f, -2.13044778e-01f, -4.63608503e-02f, -1.13452272e-02f, 4.89632115e-02f, 1.58472314e-01f, 1.05926678e-01f, 2.00259954e-01f, 8.04517493e-02f,
  -1.10562161e-01f, 2.27254540e-01f, 2.56143361e-01f, 1.14102043e-01f, 2.56414358e-02f, -2.13892870e-02f, 9.91250947e-02f, -1.31404363e-02f, 3.65560465e-02f, 1.27674729e-01f,
  2.23010093e-01f, 3.65772098e-01f, -1.30436057e-03f, -2.54530609e-01f, 2.34034956e-01f, 1.64809212e-01f, 6.26397803e-02f, -1.32545903e-01f, -2.41094112e-01f, 4.77026589e-02f,
  1.25186890e-02f, -7.99742267e-02f, -1.73539996e-01f, -9.65659544e-02f, 1.55074358e-01f, -1.48653746e-01f, 4.62435149e-02f, 3.35474133e-01f, 1.21629005e-02f, -9.14226845e-02f,
  1.78399965e-01f, -7.46013150e-02f, -1.45082176e-01f, 1.15415081e-01f, 4.09798790e-03f, 9.96511802e-02f, 7.50951618e-02f, -3.21085658e-03f, -1.28441706e-01f, -2.27289032e-02f,
  -2.14488339e-02f, 7.23923743e-02f, -1.78935632e-01f, -2.14764297e-01f, -1.46128833e-01f, 1.27893325e-03f, 4.92417105e-02f, -2.08196446e-01f, 9.15037245e-02f, -6.03216328e-03f,
  -3.61837864e-01f, -7.66220987e-02f, 1.17466561e-01f, -2.91035503e-01f, 2.80635983e-01f, 3.24608028e-01f, -1.01845190e-01f, 1.26277834e-01f, -2.55502373e-01f, -5.96550964e-02f,
  -5.17844409e-02f, 9.94858444e-02f, -1.80773839e-01f, -2.26879105e-01f, 5.13634942e-02f, 5.39474860e-02f, -3.19773674e-01f, 5.53918295e-02f, -3.81765701e-03f, 4.89977263e-02f,
  -1.78598031e-01f, 2.43661091e-01f, -4.16339561e-02f, 5.09608164e-02f, -1.24886923e-01f, 3.70339081e-02f, 6.44044057e-02f, -3.39257747e-01f, -2.00640410e-01f, -3.10023546e-01f,
  -8.30915570e-02f, 2.76518792e-01f, 1.76341400e-01f, -3.71988025e-03f, -1.30229704e-02f, 1.93984658e-01f, 2.08742082e-01f, 7.71040991e-02f, 1.47601347e-02f, -2.90670730e-02f,
  -1.40276402e-01f, -2.18388006e-01f, 1.82942808e-01f, 1.58378616e-01f, 2.31382385e-01f, -2.21061602e-01f, -3.11476022e-01f, -3.34315933e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.34821251e-01f, 1.50747836e-01f, 1.73491880e-01f, 4.85008489e-03f, 6.10323288e-02f, 9.26547274e-02f, 6.14111498e-02f, 5.81283160e-02f, 2.11663712e-02f, -5.75138815e-02f,
  6.60884753e-03f, 1.30974248e-01f, -1.05792001e-01f, 3.63438576e-02f, 2.91938692e-01f, 6.38672709e-02f, 6.13265410e-02f, 1.08171664e-01f, 7.59765459e-03f, 1.05289415e-01f,
  -2.13610046e-02f, 2.17293933e-01f, -1.68038875e-01f, 1.00489527e-01f, -1.66533247e-01f, 3.45154285e-01f, -3.15328181e-01f, -9.38225091e-02f, -1.00051731e-01f, -2.81468779e-01f,
  -2.30265763e-02f, 9.24926177e-02f, -4.28103283e-02f, -3.48613262e-01f, -1.07343353e-01f, -1.02055699e-01f, 4.75772657e-02f, 2.10281610e-01f, -6.71202019e-02f, -2.43401617e-01f,
  1.37570560e-01f, -2.11360306e-01f, 1.53409377e-01f, -2.32897133e-01f, -1.43676206e-01f, -1.18494928e-01f, 1.09127656e-01f, 6.18164130e-02f, 4.06035036e-01f, -1.67347282e-01f,
  -2.28438675e-01f, 6.30564690e-02f, 5.20418547e-02f, 6.69365600e-02f, 8.11539143e-02f, -2.61395752e-01f, 2.04266682e-01f, -2.40517065e-01f, -1.86609440e-02f, 2.96663237e-03f,
  -1.54156998e-01f, 2.98129711e-02f, -1.43069327e-01f, 1.46863997e-01f, 1.47271797e-01f, 2.06898332e-01f, 4.17170078e-02f, 8.26821998e-02f, -3.07036899e-02f, -2.85350848e-02f,
  -1.06680073e-01f, 7.13829547e-02f, 1.03196129e-01f, 1.46085113e-01f, 1.88060954e-01f, -5.64833172e-02f, 1.91693678e-01f, 1.62952527e-01f, 1.55147165e-01f, -2.53465436e-02f,
  -3.16123404e-02f, 2.42680132e-01f, 1.11910440e-01f, -7.61183212e-03f, 6.44514784e-02f, 2.70693339e-02f, 1.55323213e-02f, 9.38195586e-02f, 1.34293512e-01f, 7.84242377e-02f,
  6.75686300e-02f, 3.42475362e-02f, -3.51473577e-02f, -1.77003264e-01f, -6.35248274e-02f, -6.26024082e-02f, -6.82210326e-02f, -2.53730357e-01f, -4.15308475e-02f, 1.36288941e-01f,
  -9.35702920e-02f, 6.41388670e-02f, 9.65703353e-02f, 1.10956412e-02f, -2.30919570e-02f, -1.07258670e-01f, 8.46976265e-02f, -7.66556635e-02f, -5.34306131e-02f, 3.93042937e-02f,
  -6.80365488e-02f, 1.08444944e-01f, 3.10536414e-01f, -1.70494497e-01f, 2.90213823e-02f, -6.34662136e-02f, -4.23220992e-02f, -3.96233387e-02f, -1.07803293e-01f, -4.82203923e-02f,
  -3.69363045e-03f, -7.39629045e-02f, 2.08709955e-01f, -1.60298385e-02f, -1.95555165e-01f, -6.65028719e-03f, -1.95043281e-01f, -1.80555522e-01f, 1.20715220e-02f, 1.19408719e-01f,
  5.40857054e-02f, 1.48881674e-01f, -6.78676413e-03f, 2.88427845e-02f, 8.94978829e-03f, 5.14522828e-02f, 3.82526591e-02f, -7.12655708e-02f, 7.65341446e-02f, -5.75344302e-02f,
  -1.27165005e-01f, 1.42207563e-01f, 1.34048656e-01f, -5.34068644e-02f, -4.55901437e-02f, 1.64504558e-01f, 3.03845536e-02f, 1.09485470e-01f, -2.25156527e-02f, -1.76809374e-02f,
  -1.24672391e-01f, 1.27647534e-01f, 2.69411504e-01f, 3.77271362e-02f, 8.03516582e-02f, -8.92419741e-02f, 2.78790563e-01f, 1.76512375e-02f, 8.55746213e-03f, 3.75897288e-02f,
  -1.16552271e-01f, -5.33352755e-02f, -1.72366947e-01f, -4.05170806e-02f, -5.86242473e-04f, -8.46966580e-02f, 1.78766787e-01f, -6.40946329e-02f, -3.43882106e-02f, -1.84824690e-01f,
  4.98644859e-02f, 2.90753990e-01f, -3.55160013e-02f, 7.42049068e-02f, 1.75454825e-01f, 7.09727034e-03f, 2.05689259e-02f, -2.13658899e-01f, 5.80793805e-02f, -1.62192896e-01f,
  1.58762157e-01f, 1.03646941e-01f, 5.70968352e-02f, -6.76102862e-02f, 1.45030674e-02f, -2.31940001e-02f, 1.00814149e-01f, 5.89433825e-03f, -6.50560111e-02f, -1.31814390e-01f,
  -1.58932596e-01f, -1.84284851e-01f, 1.50948375e-01f, 1.73801124e-01f, 1.72936112e-01f, 7.10179731e-02f, 2.32900023e-01f, 2.94200964e-02f, -2.39586085e-02f, -9.56485942e-02f,
  -6.64765686e-02f, -2.76190080e-02f, 1.25230566e-01f, 6.56055883e-02f, -6.22789301e-02f, 1.06721267e-01f, -2.79172063e-01f, -1.16955684e-02f, -5.97146004e-02f, -1.00483492e-01f,
  3.85531157e-01f, -2.06378162e-01f, 2.42986202e-01f, 4.69580978e-01f, 1.13647081e-01f, 1.87957995e-02f, -4.14341569e-01f, -4.39131334e-02f, -2.50630714e-02f, -1.94523577e-02f,
  -2.37453967e-01f, -3.33204925e-01f, 2.04419553e-01f, 1.82745215e-02f, -1.99430645e-01f, 1.18316539e-01f, 1.88610360e-01f, -6.34395517e-03f, -2.47769848e-01f, 5.56381419e-02f,
  -8.51126201e-03f, 1.99817389e-01f, -1.82987750e-03f, -1.53178051e-01f, -1.07427523e-01f, 1.05049536e-02f, -3.53228509e-01f, -2.53772616e-01f, -2.64717042e-01f, 3.49923104e-01f,
  7.12602139e-02f, 1.74234509e-01f, 1.92170501e-01f, 3.00824732e-01f, 7.12757483e-02f, -1.26100063e-01f, -1.50553778e-01f, 1.17197179e-03f, -1.90148294e-01f, -1.03149265e-01f,
  -8.84549972e-03f, -1.21059261e-01f, -1.99446231e-01f, 1.55546144e-02f, -1.25391269e-02f, 1.10723048e-01f, 8.53786543e-02f, 8.63607004e-02f, 3.42800096e-02f, 7.49143586e-02f,
  1.06392287e-01f, 4.41841297e-02f, 9.09567345e-03f, 1.12714335e-01f, -9.46007222e-02f, 1.52442763e-02f, 8.41124281e-02f, 1.20832600e-01f, -4.72733639e-02f, 1.54617622e-01f,
  1.92334935e-01f, 1.24861702e-01f, -1.26169454e-02f, 1.90608159e-01f, 2.80235529e-01f, -2.42058247e-01f, 1.33997411e-01f, 2.64819443e-01f, 7.07433671e-02f, -1.23929139e-02f,
  -1.92610815e-01f, 1.93826512e-01f, -8.65803733e-02f, -3.58341485e-02f, -1.99516430e-01f, -3.00433457e-01f, 1.27570732e-02f, 9.34104398e-02f, -4.82860476e-01f, -3.42931718e-01f,
  -1.94018215e-01f, -8.78730863e-02f, 2.19176468e-02f, 2.78375857e-02f, 1.15292460e-01f, 1.20187670e-01f, 2.14572474e-01f, -2.47643411e-01f, 2.55521666e-02f, -1.90933958e-01f,
  -2.88716078e-01f, 6.79640397e-02f, 1.17108509e-01f, 3.10615867e-01f, 3.96352857e-01f, -2.90476339e-04f, -1.58345569e-02f, 1.79067791e-01f, -1.77321821e-01f, -2.13894203e-01f,
  -8.93927664e-02f, -1.17081247e-01f, -1.04318388e-01f, -1.43933982e-01f, 1.07061706e-01f, -3.08382381e-02f, -2.11307764e-01f, 1.19087607e-01f, -3.61542106e-01f, 6.48480281e-02f,
  1.58521116e-01f, 1.88722491e-01f, -1.22666778e-03f, -2.33127140e-02f, 1.10523120e-01f, 4.63174805e-02f, -6.16077594e-02f, 7.05716908e-02f, -1.97594538e-02f, 1.79043505e-02f,
  -5.49668819e-02f, 1.92213416e-01f, 1.24477401e-01f, -1.47606358e-02f, -2.51164078e-03f, 1.48320407e-01f, 1.23938948e-01f, 3.00779892e-03f, -5.50823426e-03f, 1.21610470e-01f,
  -2.12162018e-01f, -8.87082145e-02f, 4.11672965e-02f, -1.34780835e-02f, 3.57928514e-01f, 2.12905914e-01f, -2.30189990e-02f, -1.34855751e-02f, 1.87749073e-01f, 6.76544532e-02f,
  -1.96498707e-01f, 1.55880675e-01f, -9.44720507e-02f, -2.22769335e-01f, -2.88153082e-01f, -2.77302749e-02f, 1.53876334e-01f, -2.91979551e-01f, 8.69806707e-02f, -1.26390561e-01f,
  -1.50860652e-01f, -3.46326381e-01f, 6.57483488e-02f, 1.81612998e-01f, -1.28258690e-01f, 5.54881357e-02f, 1.55360490e-01f, -1.06908657e-01f, -3.55918445e-02f, 6.39982298e-02f,
  -3.11353207e-01f, -6.16394728e-02f, -6.73488602e-02f, -1.51527151e-01f, 6.31439835e-02f, 8.45808908e-02f, 2.70495743e-01f, 3.84967178e-02f, 1.85072511e-01f, -1.74946114e-01f,
  6.24572448e-02f, 1.58268556e-01f, 1.69217020e-01f, -2.66076773e-02f, -2.32534125e-01f, -1.26818882e-03f, -4.53948742e-03f, 8.26101154e-02f, 8.65092799e-02f, 5.98032475e-02f,
  1.55215621e-01f, 7.46046007e-02f, 1.28373764e-02f, 2.35315844e-01f, 5.95342666e-02f, 4.39322144e-02f, -5.44562042e-02f, -2.10535410e-03f, -3.03071365e-03f, 1.30383587e-02f,
  -5.43364696e-02f, 1.84942149e-02f, 3.37879844e-02f, -1.71482608e-01f, 4.65299003e-02f, 1.57032255e-02f, 8.43905732e-02f, 1.85000256e-01f, -9.09136608e-02f, -8.69716853e-02f,
  3.05552393e-01f, 1.75969198e-01f, 2.95426548e-01f, -3.14458907e-02f, -3.76773365e-02f, 8.42741057e-02f, 2.50176527e-02f, -4.66338992e-02f, 6.60449415e-02f, 1.00323886e-01f,
  -8.29804465e-02f, 1.34525061e-01f, 1.71754826e-02f, -3.33641283e-02f, 5.65775968e-02f, -2.00855955e-01f, 2.84301490e-01f, 1.58084467e-01f, 5.74581698e-02f, -7.01871291e-02f,
  -4.11628671e-02f, 1.05013937e-01f, -4.16932344e-01f, 2.87128687e-01f, -6.39469102e-02f, 1.80396318e-01f, -1.24413669e-01f, 1.03135921e-01f, 2.68348932e-01f, -3.26802256e-03f,
  -2.24427003e-02f, -7.20940977e-02f, 5.88693470e-02f, 3.61282043e-02f, -6.41384795e-02f, -2.42455363e-01f, 9.38715041e-02f, -5.89470007e-02f, -9.58968550e-02f, -1.86329186e-01f,
  8.60585198e-02f, 1.20097473e-01f, 1.00040570e-01f, -1.02039486e-01f, 1.15692772e-01f, 9.68542509e-03f, 6.72522336e-02f, -3.19237225e-02f, 1.61646962e-01f, -1.05332241e-04f,
  9.36816484e-02f, -1.53902709e-01f, 2.54797369e-01f, 7.71455541e-02f, -2.45337725e-01f, 1.78979799e-01f, 1.63494393e-01f, 1.00919530e-01f, 9.09677669e-02f, 2.05821201e-01f,
  -1.08288594e-01f, -1.09824473e-02f, 2.35436931e-01f, 1.18291825e-01f, -3.65187153e-02f, 4.69428226e-02f, -9.05346870e-02f, -2.28042901e-01f, 2.63027012e-01f, -1.16481476e-01f,
  -5.70279919e-02f, -1.68543413e-01f, -1.69241816e-01f, 4.80264202e-02f, -1.77233771e-03f, -3.81234623e-02f, -6.81088045e-02f, 2.20147930e-02f, 3.46933126e-01f, -5.64046465e-02f,
  5.01642339e-02f, -5.35465442e-02f, 2.96272129e-01f, 1.81176350e-01f, 5.38664572e-02f, 3.46856229e-02f, -1.31444201e-01f, 2.72238702e-02f, 1.41972616e-01f, -1.10255271e-01f,
  -1.18015051e-01f, -7.69059211e-02f, 2.88151026e-01f, -7.03869984e-02f, -2.45667174e-02f, 2.34544575e-02f, 1.57628357e-01f, -2.47912526e-01f, -1.35488391e-01f, -4.59612124e-02f,
  -2.66586959e-01f, -1.29196659e-01f, 1.00036012e-03f, 1.86132684e-01f, 8.34445208e-02f, 4.78924699e-02f, 2.13676840e-02f, -3.16849677e-03f, 6.27472997e-02f, 1.91281125e-01f,
  3.37531194e-02f, 1.14262536e-01f, 2.04928398e-01f, -9.60717648e-02f, -4.38053638e-01f, 1.49092048e-01f, 2.36148417e-01f, -7.28650838e-02f, 1.86830416e-01f, -1.63459107e-02f,
  -1.17573477e-01f, -8.44507217e-02f, 9.03910547e-02f, -4.15265560e-01f, -8.95387605e-02f, -1.32267624e-01f, 4.14518625e-01f, 1.54482082e-01f, 1.34128898e-01f, -4.18114692e-01f,
  8.76480341e-02f, 1.64963305e-01f, -1.06784508e-01f, -9.23574865e-02f, -5.33418395e-02f, -7.55391121e-02f, -3.14399034e-01f, -7.02454969e-02f, -7.64528736e-02f, 9.34949741e-02f,
  3.93405072e-02f, -1.56443089e-01f, 1.02670848e-01f, -2.43314445e-01f, 5.09099737e-02f, 1.86889410e-01f, -1.82038248e-01f, -2.62667127e-02f, 2.02392787e-01f, -2.28538420e-02f,
  -3.25320400e-02f, -6.51432127e-02f, -2.60093868e-01f, -1.65391728e-01f, -2.10496411e-02f, -3.74441482e-02f, -1.67348802e-01f, -5.52234091e-02f, 1.66219980e-01f, -6.85773715e-02f,
  3.45819771e-01f, -2.51245052e-01f, -3.14438506e-03f, -1.16154134e-01f, 1.45402536e-01f, -1.45686179e-01f, 2.36312225e-01f, 1.11642942e-01f, 3.48449424e-02f, 1.11744650e-01f,
  2.34183997e-01f, 1.65380523e-01f, 9.35296938e-02f, 1.81183681e-01f, 6.31764010e-02f, 6.17524199e-02f, 6.45345375e-02f, -9.32336692e-03f, 1.95801869e-01f, 8.08207542e-02f,
  -4.83838618e-02f, -3.91956866e-02f, 3.42056870e-01f, -1.24555565e-02f, 2.04105407e-01f, 5.76767772e-02f, -1.24436505e-01f, 2.03526333e-01f, 2.67985374e-01f, -9.63218138e-03f,
  -1.53678373e-01f, -1.95672318e-01f, -6.99153617e-02f, 1.10797748e-01f, -4.34637338e-01f, 3.81935053e-02f, -1.26388952e-01f, 1.19015433e-01f, -2.25213561e-02f, -2.11794558e-03f,
  8.20235908e-03f, 1.99783370e-01f, 1.03739597e-01f, 1.14241997e-02f, 6.13826327e-03f, 3.69477533e-02f, 7.26704374e-02f, -1.01104535e-01f, -9.90132913e-02f, -1.14139013e-01f,
  -3.59048843e-01f, 1.09582089e-01f, 4.53403182e-02f, 1.52215004e-01f, 3.84282112e-01f, 5.04348949e-02f, 1.03846714e-01f, 3.53974283e-01f, -1.31976336e-01f, -2.48946592e-01f,
  4.11117263e-02f, 8.19608476e-03f, 8.10547993e-02f, 2.47761101e-01f, -1.34834915e-01f, -2.21466035e-01f, -1.23772081e-02f, 3.92736614e-01f, 2.38364235e-01f, -3.02868813e-01f,
  -1.79361142e-02f, 1.05690859e-01f, -2.24653352e-02f, -6.79914132e-02f, 6.57363832e-02f, 5.94468303e-02f, 6.69693947e-02f, -6.90547079e-02f, -1.46774456e-01f, 1.02974892e-01f,
  -5.91640137e-02f, 2.96989940e-02f, 2.18724862e-01f, -1.30766630e-01f, -3.18146087e-02f, 6.66868463e-02f, -1.08565755e-01f, 8.87956396e-02f, 1.44873604e-01f, 3.07809711e-01f,
  -9.10842344e-02f, 2.18027145e-01f, -1.19825214e-01f, 1.11401401e-01f, -1.40202478e-01f, 1.21373475e-01f, 4.69324365e-02f, 4.93258387e-02f, 1.65937766e-01f, 1.85961984e-02f,
  1.55824140e-01f, -1.08019494e-01f, 3.68091136e-01f, -1.14289939e-01f, -2.00092550e-02f, -3.07078753e-03f, -1.47637695e-01f, -3.58618908e-02f, -2.46651657e-02f, 1.17909551e-01f,
  1.77084193e-01f, 1.40756756e-01f, -6.24288395e-02f, -2.69339383e-01f, 2.87789404e-01f, 5.30005954e-02f, 7.86668137e-02f, 4.73408066e-02f, -1.06250353e-01f, 6.15565330e-02f,
  2.24041328e-01f, -1.32342249e-01f, 1.14002213e-01f, -1.14596255e-01f, 1.74200922e-01f, 2.16006055e-01f, -1.83211137e-02f, 1.99241370e-01f, 3.65249254e-02f, 1.74212888e-01f,
  2.73081474e-02f, -4.07757051e-02f, -1.08995233e-02f, -9.79530066e-02f, 9.37980115e-02f, 5.45734838e-02f, -3.51989642e-02f, 1.14026070e-02f, 6.11536345e-03f, 6.58989474e-02f,
  1.47836342e-01f, 2.44636953e-01f, 1.92567095e-01f, 2.23331988e-01f, 1.78939462e-01f, 1.73481777e-02f, 6.93921149e-02f, 8.31175819e-02f, -1.62477180e-01f, 9.55434591e-02f,
  -1.69317260e-01f, 1.46950230e-01f, -3.58154029e-02f, 1.29310369e-01f, -2.30061293e-01f, -8.55474100e-02f, 8.26667845e-02f, -1.82505846e-01f, 1.82068646e-01f, -2.40826994e-01f,
  1.63779825e-01f, -1.37776673e-01f, 2.45013550e-01f, 1.94412738e-01f, -9.55274701e-02f, -1.18728027e-01f, 5.06613016e-01f, -1.21997260e-01f, 9.21535119e-02f, 2.87460238e-02f,
  1.82807855e-02f, -2.05383137e-01f, 8.87165442e-02f, -9.20169130e-02f, -2.23515797e-02f, 2.47114778e-01f, -1.79969788e-01f, 4.62666005e-02f, 3.05360526e-01f, 3.12643319e-01f,
  1.48664443e-02f, -6.00032806e-02f, -3.30511183e-01f, 1.22346752e-03f, 9.48173031e-02f, -1.52624249e-01f, -3.04431263e-02f, -5.83902188e-02f, 6.87117651e-02f, -1.06555119e-01f,
  2.76456047e-02f, 4.01536763e-01f, 6.21590391e-02f, -2.13062596e-02f, -1.62333280e-01f, 8.53298008e-02f, 1.52206719e-01f, -4.37631346e-02f, -2.11980715e-01f, -1.82268992e-02f,
  1.37095377e-01f, -3.52041870e-02f, 8.28346610e-03f, 8.87838230e-02f, 5.59223182e-02f, -3.27558927e-02f, 6.66252747e-02f, 1.78911000e-01f, 1.20638385e-01f, 3.76533270e-02f,
  -1.78183585e-01f, -2.04552244e-02f, -6.91340491e-02f, -2.20063999e-02f, 3.99311669e-02f, -1.83315918e-01f, 5.04809059e-02f, -2.01986253e-01f, 5.95421642e-02f, 1.15410142e-01f,
  1.61632836e-01f, 1.51265398e-01f, -1.82985663e-01f, -8.56084302e-02f, 7.32706562e-02f, 1.51454151e-01f, 6.18096255e-02f, -1.18538685e-01f, 6.56874403e-02f, 1.58318475e-01f,
  -7.54230767e-02f, -4.42986898e-02f, -7.67009426e-03f, 8.55565518e-02f, 1.59998462e-01f, 2.96860605e-01f, 1.65289059e-01f, 2.29631320e-01f, -1.65996701e-02f, -4.57928658e-01f,
  6.40001446e-02f, -4.82381098e-02f, -1.99012503e-01f, -2.03749821e-01f, -1.26484483e-01f, 2.93463945e-01f, -3.92104015e-02f, 8.76359865e-02f, -7.89255649e-02f, 1.73024163e-01f,
  9.18399263e-03f, 1.57512695e-01f, 1.06031962e-01f, -1.24687828e-01f, 1.05847558e-02f, -1.61032289e-01f, -9.63915959e-02f, 5.43028004e-02f, -1.09894373e-01f, 2.39139888e-03f,
  3.94805893e-02f, -4.36340392e-01f, 1.09530461e-03f, 2.10057095e-01f, 2.60136500e-02f, 9.23257396e-02f, 1.18241094e-01f, 1.58591360e-01f, 9.77714881e-02f, -9.66512635e-02f,
  -5.84485531e-02f, -8.17600191e-02f, -7.32848123e-02f, 2.64769733e-01f, 1.77801549e-01f, -6.22029305e-02f, 7.40054175e-02f, 3.67570855e-02f, 2.71262050e-01f, 4.40798514e-02f,
  9.89443734e-02f, 2.82465070e-01f, -1.17494442e-01f, 1.38344705e-01f, -4.08151634e-02f, 1.00106806e-01f, -8.39338824e-02f, -7.75917023e-02f, 6.82488456e-02f, -6.74686357e-02f,
  7.92669803e-02f, 2.86149800e-01f, -2.85531729e-01f, 2.42294185e-02f, 4.74176332e-02f, 8.59785601e-02f, -2.27128983e-01f, -6.41856119e-02f, -2.76012085e-02f, 1.06667029e-02f,
  6.04359582e-02f, -1.80412903e-01f, 1.08597698e-02f, 4.85077612e-02f, 4.25529927e-02f, -3.70967567e-01f, -8.90094414e-02f, 1.33116677e-01f, 2.89004952e-01f, 9.39656347e-02f,
  2.34268755e-01f, 5.99411353e-02f, 6.04868419e-02f, -1.31376594e-01f, -6.73179999e-02f, -1.54757425e-01f, 2.43875384e-01f, 1.35559067e-01f, 1.63470283e-01f, 4.22957301e-01f,
  1.23373680e-01f, -8.36607348e-03f, -2.96315849e-02f, 2.78979480e-01f, 1.37043551e-01f, -2.32054964e-01f, 8.84262100e-03f, 1.96723435e-02f, -3.42235900e-02f, 1.06843211e-01f,
  1.17742056e-02f, -2.52371971e-02f, -3.33486944e-02f, 5.92666231e-02f, 3.35286707e-02f, -1.31251171e-01f, -1.10588469e-01f, -2.79561598e-02f, 2.72216290e-01f, -1.60039604e-01f,
  9.63946283e-02f, 1.84402883e-01f, 8.12538490e-02f, 1.58426449e-01f, -7.54866153e-02f, 1.57191098e-01f, -2.72770941e-01f, -2.20909398e-02f, 4.48078066e-02f, -2.21359357e-02f,
  -6.19643442e-02f, -2.56358594e-01f, -6.07690476e-02f, -9.40176621e-02f, 1.63492858e-01f, 2.49093160e-01f, -4.45726030e-02f, -2.02628728e-02f, 3.44571888e-01f, 1.72745675e-01f,
  9.11963824e-03f, -3.60197350e-02f, -1.11405971e-02f, -6.19713925e-02f, 6.62170202e-02f, -9.25990716e-02f, -6.85802326e-02f, 2.20631242e-01f, -1.77142560e-01f, -1.22571707e-01f,
  -5.10139875e-02f, 1.99703332e-02f, -1.87561028e-02f, -6.91999942e-02f, 1.20258041e-01f, -2.09892705e-01f, 1.29940867e-01f, -1.62004620e-01f, 2.48298664e-02f, 7.21253827e-02f,
  5.05135432e-02f, 9.65843629e-03f, -2.69912034e-02f, 2.29737580e-01f, -7.41309151e-02f, 8.80025700e-02f, -7.85081685e-02f, 1.04161568e-01f, 7.07513019e-02f, -2.50495613e-01f,
  1.06594466e-01f, -6.13528229e-02f, 1.89974546e-01f, 5.52408583e-02f, -1.36616781e-01f, 1.34636655e-01f, 1.70107763e-02f, 1.72507465e-01f, 8.05455297e-02f, 1.72219917e-01f,
  7.64136165e-02f, 8.61842558e-02f, -6.90271854e-02f, -5.39370552e-02f, -6.63333312e-02f, 1.43248707e-01f, -3.14808398e-01f, 1.49438709e-01f, -1.13396972e-01f, -7.41259977e-02f,
  -6.11786507e-02f, 1.75122246e-02f, -1.73191011e-01f, -8.59275237e-02f, 2.01186463e-01f, -1.19458605e-02f, 5.13278693e-02f, -1.29157752e-01f, -3.05604041e-02f, 1.11796081e-01f,
  -3.26776467e-02f, -7.27038309e-02f, 1.63923234e-01f, 2.51752406e-01f, -3.67647633e-02f, 3.94514129e-02f, -2.03349069e-02f, -2.65317529e-01f, 9.96056870e-02f, -3.39002162e-02f,
  2.63645470e-01f, -3.66775915e-02f, 8.66547972e-02f, 8.78788158e-02f, 4.76937979e-01f, 2.68946558e-01f, 2.19662338e-02f, -1.29268110e-01f, -3.65697026e-01f, 3.75101119e-02f,
  -3.37022655e-02f, -6.42611906e-02f, -1.29392266e-01f, 6.84547517e-03f, 5.81216216e-02f, -7.76840374e-02f, -1.45248786e-01f, 1.17957592e-02f, 2.04267547e-01f, -1.40739962e-01f,
  -1.11088958e-02f, 4.23709229e-02f, -5.66868223e-02f, -2.41683945e-02f, -1.76799595e-02f, 4.31681098e-03f, 4.16148566e-02f, 5.95485792e-02f, 3.21220644e-02f, -1.38850631e-02f,
  1.52715608e-01f, 3.12776603e-02f, 1.69268757e-01f, 1.72143072e-01f, 2.51833767e-01f, -3.24334279e-02f, -1.94064956e-02f, -4.79124039e-02f, -6.42880499e-02f, -4.18349206e-02f,
  -2.86567844e-02f, 2.59504355e-02f, -1.13374650e-01f, -2.30137501e-02f, -2.64500439e-01f, -3.96697104e-01f, -7.48744085e-02f, 1.22417569e-01f, 2.15294361e-01f, 2.48248205e-02f,
  -2.40348876e-02f, -1.60321131e-01f, 2.77959794e-01f, 2.53637940e-01f, -4.60017733e-02f, -1.86536580e-01f, -1.76417772e-02f, 7.57291913e-02f, 1.49864450e-01f, 1.64981171e-01f,
  8.62344131e-02f, 1.76592469e-01f, 2.02504724e-01f, -1.27898246e-01f, -5.45265786e-02f, -1.24143951e-01f, 1.81813776e-01f, 3.81941170e-01f, 1.76546589e-01f, -3.40346992e-02f,
  1.75209567e-01f, -7.68181458e-02f, -7.01976418e-02f, -6.60109594e-02f, -9.61330310e-02f, -3.99704203e-02f, 2.95293361e-01f, 1.31704912e-01f, -8.27424005e-02f, -1.97482705e-02f,
  1.17285728e-01f, -4.50550541e-02f, 2.83909649e-01f, 5.04662879e-02f, -7.14175031e-02f, -2.11036056e-02f, 7.70183513e-03f, -5.88058047e-02f, -9.76220295e-02f, 1.79468766e-02f,
  1.12137854e-01f, 1.47608608e-01f, 1.60252690e-01f, 7.51893148e-02f, 5.36233895e-02f, 4.39381674e-02f, 7.14881718e-02f, 9.47286040e-02f, -6.41192198e-02f, 1.25145996e-02f,
  -6.93923682e-02f, 8.15463513e-02f, 1.27381578e-01f, 8.12604874e-02f, -4.06436384e-01f, -8.01427197e-03f, 1.98771939e-01f, -1.70217007e-01f, 2.14024499e-01f, 1.79005608e-01f,
  -1.31005362e-01f, -3.22093517e-02f, -2.36706972e-01f, 3.77232092e-03f, 1.39755741e-01f, 3.19416970e-02f, 5.85868582e-02f, -3.27986419e-01f, 1.70807660e-01f, 1.21645831e-01f,
  -1.44372746e-01f, 1.20030064e-02f, -1.71949193e-02f, -1.95349216e-01f, 5.88998497e-02f, 1.52012557e-01f, 1.09121256e-01f, 1.78072035e-01f, 1.37537464e-01f, 1.63163729e-02f,
  -6.79560676e-02f, -2.52695650e-01f, 1.61172032e-01f, -2.24581569e-01f, -1.80664212e-01f, 2.61659920e-01f, -5.13796508e-02f, 1.04625314e-01f, 8.47563297e-02f, 1.46903232e-01f,
  3.23801935e-02f, -3.62453014e-01f, 5.73595054e-02f, -1.12459831e-01f, 3.45397778e-02f, -1.42669663e-01f, 9.95680615e-02f, -9.30364653e-02f, -4.12782840e-03f, -3.18923563e-01f,
  -3.05838346e-01f, 2.82275043e-02f, 2.55146682e-01f, 1.27550736e-02f, 9.66745540e-02f, 4.71287966e-02f, 1.46012217e-01f, 7.54652694e-02f, -7.33918622e-02f, 1.71893984e-01f,
  -9.72258672e-02f, -9.12593398e-03f, -7.20094144e-02f, 2.14454949e-01f, 4.08658326e-01f, -2.03700647e-01f, -2.21608996e-01f, 4.54633776e-03f, 8.85159802e-03f, 2.10375428e-01f,
  -1.92678198e-02f, 2.91119441e-02f, -2.98223644e-02f, 3.22154909e-01f, -1.69610590e-01f, -7.38969296e-02f, -1.77708015e-01f, -1.67610094e-01f, -1.85851976e-01f, -5.38337743e-03f,
  -2.89143294e-01f, -5.74058713e-03f, 2.12424789e-02f, -1.70092702e-01f, 9.61808041e-02f, 2.07555056e-01f, -1.54659763e-01f, -1.33036092e-01f, -5.49843609e-01f, -5.64827472e-02f,
  -2.04584807e-01f, -9.21486840e-02f, -1.55371606e-01f, 1.59358516e-01f, -4.20019716e-01f, -3.61466229e-01f, -1.75129801e-01f, 1.65021971e-01f, 1.74540654e-01f, -1.30731845e-03f,
  2.33189598e-01f, -2.58723766e-01f, 2.65852779e-01f, 3.73697393e-02f, -2.31195047e-01f, -1.34604499e-01f, 1.02692015e-01f, 1.49433911e-01f, -5.35135791e-02f, 2.35404357e-01f,
  -2.11878493e-01f, -5.66089712e-03f, 1.91639978e-02f, 1.59659684e-01f, 1.65000647e-01f, -9.93239209e-02f, 3.90705280e-02f, 1.57532528e-01f, 2.42710095e-02f, 1.30208835e-01f,
  1.65494874e-01f, 1.10954251e-02f, 1.28596187e-01f, -1.38361275e-01f, 1.21365160e-01f, 7.23965913e-02f, -1.77556481e-02f, -7.80094713e-02f, -1.55558780e-01f, -4.37328182e-02f,
  8.36237147e-03f, -1.20798461e-01f, 1.09792255e-01f, -1.26754597e-01f, 1.57067135e-01f, -9.15674344e-02f, 1.84195489e-01f, 2.05648672e-02f, 1.29468054e-01f, 1.67874590e-01f,
  -2.28542104e-01f, 7.42513761e-02f, -6.06830306e-02f, -5.01883253e-02f, -1.81738377e-01f, -1.11289188e-01f, 6.95843920e-02f, 1.50254220e-01f, -4.10191059e-01f, -1.08159475e-01f,
  1.09696515e-01f, -1.49028962e-02f, 6.07369207e-02f, 1.86512083e-01f, 1.52208373e-01f, 2.04088047e-01f, 6.44289255e-02f, -4.13382798e-01f, 1.57970250e-01f, -2.27188449e-02f,
  -3.21926981e-01f, -2.88121313e-01f, -1.91230789e-01f, 9.61484984e-02f, 3.60995919e-01f, 3.25297788e-02f, 1.89268857e-01f, 2.94600844e-01f, 2.96462141e-03f, 2.25812256e-01f,
  -7.99303651e-02f, -1.33997247e-01f, -1.06299005e-01f, -4.24952149e-01f, -1.21598020e-02f, 2.42555052e-01f, -5.38652800e-02f, -8.93839076e-02f, -7.48738348e-02f, -8.29439014e-02f,
  1.04657017e-01f, 4.25894298e-02f, -5.51801510e-02f, 1.01522990e-01f, -1.35885868e-02f, 1.95445288e-02f, 1.14717886e-01f, -1.33541599e-02f, 1.22125655e-01f, 2.39126474e-01f,
  2.28507742e-01f, 4.01993543e-02f, 3.33926119e-02f, 2.97553483e-02f, -1.61211893e-01f, -1.34480357e-01f, 8.92801881e-02f, -1.22115381e-01f, -2.26860121e-02f, -2.64984012e-01f,
  -1.28468752e-01f, 3.77490595e-02f, 1.86653554e-01f, 2.19134107e-01f, 5.25391772e-02f, -1.04762189e-01f, -7.68408999e-02f, -2.58689910e-01f, -3.22623141e-02f, -2.89014764e-02f,
  7.25811943e-02f, -1.07043169e-01f, -3.60713422e-01f, -9.56098586e-02f, -1.10813864e-01f, 2.01947838e-01f, 4.96403165e-02f, 2.42189728e-02f, 1.24972679e-01f, 1.15468979e-01f,
  -7.22629279e-02f, -1.19514242e-01f, 1.17997646e-01f, 1.82836235e-01f, -2.76011437e-01f, -2.82476307e-03f, -4.14272444e-03f, 2.03753725e-01f, -8.37523416e-02f, 1.06058933e-01f,
  -4.94152047e-02f, 3.14170033e-01f, 1.37938842e-01f, 2.34471664e-01f, -1.10214382e-01f, 3.66811492e-02f, -2.63002887e-02f, -4.49150920e-01f, 1.23723537e-01f, 9.57571045e-02f,
  -1.10386692e-01f, -7.57868290e-02f, -1.31961256e-02f, -3.73110026e-02f, 1.07445672e-01f, 1.73665464e-01f, 1.59917027e-01f, 2.57779080e-02f, -5.84405698e-02f, 4.83873859e-02f,
  -1.51762022e-02f, 7.25698769e-02f, 1.32945329e-01f, -3.73757146e-02f, -1.13035917e-01f, 1.59278110e-01f, 3.50294001e-02f, -7.41410851e-02f, 2.54370600e-01f, 2.58872304e-02f,
  -4.85431366e-02f, 5.08575961e-02f, 2.49409135e-02f, -3.32947411e-02f, 9.68009755e-02f, 2.02570021e-01f, -2.20601514e-01f, 4.36877534e-02f, -3.54086339e-01f, 3.81619446e-02f,
  -2.18425225e-02f, 1.95698217e-02f, -4.49890904e-02f, -2.92797405e-02f, -2.91449696e-01f, 8.92190114e-02f, 4.01075929e-02f, 3.71477425e-01f, -2.89830327e-01f, -2.43710071e-01f,
  -2.87398999e-03f, 7.77759701e-02f, -6.55944943e-02f, -9.84716346e-04f, -3.10549587e-01f, 3.64132017e-01f, -1.86012819e-01f, -3.27606320e-01f, -5.42197116e-02f, -1.03858225e-01f,
  1.11484148e-01f, -2.44341627e-01f, 1.58782318e-01f, -4.11902256e-02f, -1.00425310e-01f, -9.69622359e-02f, -1.41480386e-01f, -4.78648674e-03f, 1.79713368e-02f, 2.63433784e-01f,
  5.12809828e-02f, 2.40281120e-01f, -5.05146720e-02f, 1.45310506e-01f, 2.46680111e-01f, -1.13624260e-02f, 1.74374923e-01f, 7.92738572e-02f, -1.85348824e-01f, 1.12064600e-01f,
  1.19279765e-01f, -1.30024403e-02f, 1.40035093e-01f, -6.97591379e-02f, -7.56300380e-03f, -3.40107791e-02f, -1.29580989e-01f, -1.81005388e-01f, -7.97796473e-02f, -1.29822288e-02f,
  -1.83017761e-01f, 2.29696810e-01f, 5.18793017e-02f, -7.22835958e-02f, -8.68883207e-02f, 9.46361646e-02f, 2.31618248e-02f, 1.36916026e-01f, 4.90042642e-02f, 1.76450610e-02f,
  -6.92597330e-02f, 3.33638564e-02f, -1.80845350e-01f, -1.27081960e-01f, 1.61605924e-01f, -8.37667137e-02f, 2.29474157e-01f, 2.99187928e-01f, 7.54800513e-02f, -5.88009469e-02f,
  3.36329907e-01f, -2.74975039e-02f, 3.55530053e-01f, -1.77391201e-01f, -1.41624406e-01f, 3.98492008e-01f, -6.30555898e-02f, -6.97522834e-02f, 1.92947701e-01f, 2.38162860e-01f,
  -5.85977435e-02f, -1.56641096e-01f, 2.84428895e-02f, 2.51433477e-02f, -2.08236709e-01f, 1.65477917e-01f, -1.13428116e-01f, 2.33028367e-01f, 9.25114080e-02f, -2.62537971e-02f,
  -2.38629687e-03f, -4.28447537e-02f, -2.11200550e-01f, -5.68076521e-02f, -1.32859349e-02f, 3.84303659e-01f, -1.19056918e-01f, 3.14485788e-01f, -3.22141722e-02f, -1.12234997e-02f,
  1.46402597e-01f, 1.65947720e-01f, 7.66259953e-02f, -1.75283983e-01f, 1.94240406e-01f, 1.45494074e-01f, 8.99475068e-02f, 1.02001444e-01f, 1.84091732e-01f, 2.13620380e-01f,
  2.34483391e-01f, 1.85725957e-01f, 1.52141675e-01f, 5.68090007e-02f, -1.95977405e-01f, -9.08974782e-02f, -2.62191921e-01f, -1.73033029e-01f, -1.59253344e-01f, -2.13239044e-01f,
  4.68645655e-02f, 1.04450561e-01f, 7.93361887e-02f, 1.84062153e-01f, 2.34358216e-04f, -4.20682207e-02f, -6.86059669e-02f, -3.12965274e-01f, -6.66335821e-02f, -4.08111438e-02f,
  -2.26144671e-01f, -2.71822996e-02f, -7.94716552e-03f, 9.29332301e-02f, -3.21983069e-01f, 3.21244448e-01f, 5.45048974e-02f, -3.28193232e-03f, 9.89496261e-02f, -2.32109368e-01f,
  2.22495608e-02f, 1.41463935e-01f, 4.37264368e-02f, 3.73006910e-02f, 4.01995592e-02f, 2.06958085e-01f, -6.23717569e-02f, -3.61028463e-02f, -8.14002529e-02f, -1.37774035e-01f,
  -3.00322264e-01f, -2.03569442e-01f, -3.68904658e-02f, 1.82823002e-01f, -5.95765449e-02f, -2.89816502e-02f, -5.67246694e-03f, 1.25304908e-01f, -1.61879390e-01f, -3.26807261e-01f,
  -1.69196114e-01f, -2.32562691e-01f, 2.52005428e-01f, -2.88137138e-01f, 4.67246398e-02f, 6.70107007e-02f, -7.89153874e-02f, 1.97666004e-01f, 1.55059710e-01f, 1.01941295e-01f,
  -2.36943420e-02f, 3.23030017e-02f, 9.76702273e-02f, -1.37755737e-01f, 2.30424836e-01f, 1.26070023e-01f, 1.51225239e-01f, -1.30862901e-02f, -2.02283561e-01f, 1.44259393e-01f,
  1.83847994e-01f, -1.34638280e-01f, 1.82451248e-01f, 1.09587014e-01f, 5.34171499e-02f, -1.83058470e-01f, 1.42255053e-01f, -1.52805924e-01f, -8.96353573e-02f, 2.50566393e-01f,
  7.07446262e-02f, 1.42798230e-01f, 2.44197305e-02f, -2.19005182e-01f, 2.52414420e-02f, 9.88886654e-02f, -1.98644057e-01f, 5.62261194e-02f, -2.40421042e-01f, -1.27326194e-02f,
  -1.12065770e-01f, -1.16154656e-01f, -2.72264063e-01f, 3.92199844e-01f, 1.60796002e-01f, 6.15634471e-02f, 3.63768041e-02f, -7.97980502e-02f, 2.11802363e-01f, -2.14812413e-01f,
  -2.51218885e-01f, -1.27387613e-01f, 1.29114732e-01f, -5.32148853e-02f, 2.05932841e-01f, 1.00585064e-02f, -7.21807331e-02f, -7.30946884e-02f, -8.46787691e-02f, 2.06607148e-01f,
  -2.53659427e-01f, -1.28497556e-01f, -2.47729987e-01f, -2.55300760e-01f, 1.63507983e-01f, 2.23458081e-01f, -5.81423603e-02f, -1.98543444e-01f, -1.22173280e-01f, -1.50854379e-01f,
  6.62176758e-02f, 2.19442070e-01f, 4.99607250e-02f, 5.37122637e-02f, 3.41411158e-02f, 3.88794132e-02f, 2.00675696e-01f, 2.32872024e-01f, 1.97701573e-01f, 1.71357766e-01f,
  1.84904873e-01f, 3.24267969e-02f, -2.16928542e-01f, 1.04235999e-01f, 1.60319749e-02f, -1.47881746e-01f, -1.04899734e-01f, 2.15580724e-02f, 8.57848078e-02f, 9.02078003e-02f,
  2.43090555e-01f, 6.06350787e-02f, 1.07292514e-02f, 1.40749440e-01f, -1.89754963e-01f, -2.79355496e-02f, 1.51745170e-01f, -4.30757135e-01f, 7.03072399e-02f, 1.91619858e-01f,
  -4.40653265e-02f, -1.25100046e-01f, 3.21158201e-01f, -1.25687450e-01f, 2.40068167e-01f, -5.63254543e-02f, 2.06328377e-01f, 1.65138841e-01f, -9.74781141e-02f, -2.12080702e-01f,
  1.78277031e-01f, 1.06822602e-01f, -8.69512632e-02f, -9.83094890e-03f, 7.77169019e-02f, 1.00021539e-02f, -2.14999616e-01f, 1.52500823e-01f, -5.14892265e-02f, 1.28683746e-01f,
  -2.69257315e-02f, 7.81875402e-02f, 1.48864344e-01f, -1.15952343e-01f, -3.68247151e-01f, -1.66661054e-01f, -2.78765619e-01f, 1.49574488e-01f, 4.66071777e-02f, 4.17223983e-02f,
  -9.09715593e-02f, -1.97260708e-01f, -1.21811911e-01f, 1.94303617e-01f, -2.31207777e-02f, -3.21637578e-02f, 1.09454885e-01f, -6.86537400e-02f, -3.84238474e-02f, 1.16572723e-01f,
  -3.35263908e-02f, 1.29471630e-01f, 1.29647985e-01f, 1.16262630e-01f, 3.32805999e-02f, -4.56495881e-02f, -1.92315608e-01f, 6.98493794e-02f, 9.72060114e-02f, -3.59356478e-02f,
  2.39455923e-01f, 2.15022136e-02f, 1.04656391e-01f, -1.06744766e-01f, 6.61934689e-02f, -5.59178069e-02f, -7.37340972e-02f, 3.45902964e-02f, 3.52925122e-01f, 3.04150194e-01f,
  -7.58705586e-02f, -1.87611371e-01f, 2.33087000e-02f, -5.20385467e-02f, -1.88769504e-01f, 1.57357883e-02f, -2.74649948e-01f, 1.33020505e-01f, -3.47030126e-02f, 9.66014788e-02f,
  -7.50942305e-02f, 1.04527257e-03f, 2.49433905e-01f, -1.87427804e-01f, 7.40616024e-02f, -3.93372118e-01f, 8.37541297e-02f, 8.54396820e-02f, -3.13522995e-01f, -1.32974729e-01f,
  9.11059827e-02f, -7.47878179e-02f, 1.84680328e-01f, -1.80767626e-01f, -2.04005599e-01f, 1.10291824e-01f, -6.39757216e-02f, -9.58538800e-02f, -6.25184700e-02f, -1.38809592e-01f,
  2.19191596e-01f, -1.26990914e-01f, 3.04912418e-01f, -1.94601327e-01f, 5.42179272e-02f, -4.47209775e-02f, 2.34246664e-02f, -5.23787700e-02f, 8.61692876e-02f, 1.04965605e-02f,
  -1.27147481e-01f, 7.72142336e-02f, -3.44497897e-02f, -3.89897525e-02f, 4.48259898e-02f, 9.81435329e-02f, 8.38532522e-02f, 1.22512884e-01f, 4.24664654e-02f, 2.26323530e-02f,
  1.05154485e-01f, -2.61517800e-02f, -2.05289856e-01f, -5.21897078e-02f, -1.31356031e-01f, 1.07794985e-01f, 2.23120209e-02f, -1.19931288e-01f, -9.54969376e-02f, -2.55143583e-01f,
  5.51708974e-02f, 2.44147461e-02f, 1.48712069e-01f, -1.09997757e-01f, -1.67103335e-01f, 1.92517206e-01f, 3.90213221e-01f, 4.93215322e-02f, -8.00580159e-02f, -1.75604090e-01f,
  1.02076545e-01f, 7.81083666e-03f, 2.43471600e-02f, 1.51693687e-01f, 4.99802046e-02f, 7.80098513e-02f, 1.00033753e-01f, -2.96419002e-02f, -1.64035290e-01f, -6.17181025e-02f,
  1.26829207e-01f, 1.97026849e-01f, 3.05281103e-01f, 8.43237638e-02f, 5.45032322e-02f, -1.46184266e-02f, -1.94166139e-01f, -3.43722761e-01f, 6.26151860e-02f, -9.60929021e-02f,
  2.67298639e-01f, 3.92671108e-01f, 2.18544900e-01f, -9.48041379e-02f, 8.42816904e-02f, 8.38329047e-02f, -3.49901360e-03f, 1.53275520e-01f, -8.00165441e-03f, 9.05162171e-02f,
  3.75646167e-02f, -2.48125225e-01f, 7.89313838e-02f, 1.18688315e-01f, 7.58360699e-02f, 2.98319990e-03f, -2.48806719e-02f, 9.68346223e-02f, 1.68046534e-01f, -1.65033787e-01f,
  1.34496585e-01f, -7.64135569e-02f, 9.10054222e-02f, -9.80680063e-02f, -6.36802167e-02f, 2.63348874e-02f, 8.71310979e-02f, -1.27874225e-01f, 3.13753337e-01f, -7.60959741e-03f,
  -6.80629611e-02f, 9.32415500e-02f, 4.70408127e-02f, -8.87575671e-02f, 9.71117839e-02f, 2.04755306e-01f, -1.36891808e-02f, 6.36725053e-02f, 1.74043015e-01f, -5.56214377e-02f,
  3.73705655e-01f, 5.68274371e-02f, -1.11152910e-01f, 3.73045285e-03f, 3.81422937e-01f, -7.46862814e-02f, 1.03091836e-01f, 5.18725179e-02f, 8.06297809e-02f, 1.40867576e-01f,
  -7.78099969e-02f, -1.20705247e-01f, -2.59627491e-01f, 1.82116076e-01f, -4.43648174e-02f, 2.98616048e-02f, 1.15814745e-01f, -1.15533117e-02f, -1.84516981e-01f, 1.00233018e-01f,
  -1.59686580e-01f, 1.52561545e-01f, -4.36232090e-02f, 1.15120877e-02f, 7.43419379e-02f, 2.55636781e-01f, 5.29337153e-02f, 3.19449767e-03f, -5.17795943e-02f, 2.75989056e-01f,
  -1.51580483e-01f, 3.58200371e-01f, 5.12401499e-02f, 2.83987913e-02f, -3.79224196e-02f, -9.78705194e-03f, -6.74686506e-02f, 1.21615812e-01f, -4.33273949e-02f, 6.76443661e-03f,
  -1.39147285e-02f, 5.42480946e-02f, -8.05808604e-03f, -1.04680799e-01f, -3.60173844e-02f, -1.04862258e-01f, 1.00525707e-01f, -1.53376302e-02f, -1.78499445e-02f, 4.66800034e-02f,
  6.06674626e-02f, -1.71971500e-01f, 1.35462200e-02f, 2.56304026e-01f, 1.14830188e-01f, 8.82661492e-02f, 7.90820271e-02f, -4.52310950e-01f, -1.32838652e-01f, 1.97349101e-01f,
  -6.50409935e-03f, 3.93638834e-02f, -1.42575219e-01f, 4.10923846e-02f, 1.33184150e-01f, 1.28245443e-01f, 7.90588483e-02f, -1.81244567e-01f, 3.61423016e-01f, 2.10189924e-01f,
  -1.84091423e-02f, 4.38613743e-02f, -1.71547249e-01f, 2.40399182e-01f, 5.86717948e-02f, 4.61436948e-03f, 9.41925794e-02f, 7.92159289e-02f, 7.18100369e-02f, -3.34293605e-03f,
  4.32861120e-01f, 2.79490530e-01f, 4.86538187e-02f, 1.65150404e-01f, -4.18479145e-02f, -1.06709555e-01f, 1.67622149e-01f, -4.34813201e-02f, 1.12314053e-01f, 1.73164129e-01f,
  4.96283397e-02f, 7.74657428e-02f, -1.28808513e-01f, 2.09974304e-01f, 7.24435747e-02f, 3.27327132e-01f, -6.28249720e-02f, -3.83678265e-02f, 2.20795482e-01f, -3.47969115e-01f,
  1.74692079e-01f, 1.15978912e-01f, -1.47379726e-01f, 8.79098549e-02f, 1.28787681e-02f, -8.86524376e-03f, 1.37596354e-01f, 1.91704765e-01f, 1.02302544e-01f, 2.08877578e-01f,
  -2.78814789e-02f, 4.37427685e-02f, -1.80880487e-01f, -8.85941237e-02f, -1.54036418e-01f, -6.04621023e-02f, 1.51234776e-01f, -2.17875808e-01f, 4.16541193e-03f, 4.85720672e-02f,
  5.81586659e-02f, 2.90349692e-01f, 8.91685262e-02f, 8.13196748e-02f, -2.24171832e-01f, -1.41848817e-01f, -2.66053170e-01f, -7.84756057e-03f, -3.62670541e-01f, 2.92222291e-01f,
  -2.67414451e-01f, 1.02253472e-02f, -8.39081407e-03f, 3.19500804e-01f, 2.09551398e-02f, -2.51171142e-02f, -5.24361013e-03f, 1.69883683e-01f, -7.37143308e-02f, 2.40821149e-02f,
  -7.49565065e-02f, -1.86155677e-01f, 1.42751783e-01f, 7.70816728e-02f, -2.38075480e-01f, 8.87735039e-02f, 2.09415108e-02f, -6.14229403e-02f, 2.30970234e-01f, -5.76996841e-02f,
  1.39015481e-01f, 2.54243076e-01f, 1.10684186e-01f, 1.64879829e-01f, -8.60854536e-02f, 2.90765196e-01f, -1.87223583e-01f, -1.78872198e-01f, -2.71917075e-01f, -7.67011568e-02f,
  1.84095204e-02f, 1.99127376e-01f, 4.20487523e-01f, -2.18172759e-01f, -5.31931296e-02f, 7.82043338e-02f, 7.50352591e-02f, 6.80991337e-02f, 1.19301863e-01f, 8.94516259e-02f,
  -3.27492245e-02f, -9.26954448e-02f, -2.57311226e-03f, 1.03256501e-01f, 8.45176540e-03f, 6.46965578e-02f, -7.37195760e-02f, 9.33388621e-02f, -3.36430781e-02f, -1.11598864e-01f,
  -1.28293857e-01f, 1.88164860e-02f, -1.75079536e-02f, -3.47840935e-01f, 1.79200277e-01f, 1.34439468e-01f, 3.07859890e-02f, 3.17335188e-01f, -1.46713406e-01f, -1.43146396e-01f,
  -1.07293189e-01f, 2.39133798e-02f, 5.64936884e-02f, -2.46136084e-01f, -1.90018252e-01f, -3.14268768e-02f, -4.63370085e-02f, 6.63276538e-02f, -6.69490099e-02f, -6.76335022e-02f,
  -2.41053151e-03f, 2.50437021e-01f, 1.40673876e-01f, 5.66655546e-02f, -3.68020823e-03f, -1.59871668e-01f, 3.96078639e-02f, -4.39346060e-02f, -1.04889385e-01f, -3.12082976e-01f,
  1.09249111e-02f, 3.50450754e-01f, 1.84981659e-01f, 1.04916267e-01f, -1.28666102e-03f, 1.68650389e-01f, 2.32132465e-01f, 2.07106531e-01f, -2.40556121e-01f, -1.17965966e-01f,
  -1.65882468e-01f, -6.61638426e-03f, 1.82686433e-01f, 2.06483394e-01f, 5.45964874e-02f, -4.00705814e-01f, -4.52062428e-01f, 1.01594239e-01f, 8.33949298e-02f, 1.54708177e-01f,
  -6.29533306e-02f, 7.85972774e-02f, 3.30616497e-02f, 7.63628259e-02f, 7.26137427e-04f, -4.48388308e-02f, 1.12729713e-01f, 1.53364241e-01f, -6.13690242e-02f, -3.58221843e-03f,
  -2.47104783e-02f, 3.72079276e-02f, 2.49642268e-01f, 5.63374944e-02f, -4.46440838e-02f, -1.03189135e-02f, -1.35914356e-01f, 2.85175204e-01f, 7.33289346e-02f, 8.38991627e-02f,
  -1.78552032e-01f, -5.05380109e-02f, 2.84787834e-01f, 4.57092300e-02f, 2.23687500e-01f, 1.10186949e-01f, 5.15428968e-02f, 2.19467834e-01f, -2.91541182e-02f, 5.91004863e-02f,
  1.39665693e-01f, 1.35065719e-01f, -8.29546601e-02f, 4.66510579e-02f, -1.53705463e-01f, 1.07731313e-01f, -9.63237882e-03f, -1.01055413e-01f, 6.02001883e-02f, 2.40841940e-01f,
  -1.27506703e-01f, -2.70244807e-01f, 3.52647156e-02f, -4.49931622e-02f, 1.43408924e-01f, -5.63916191e-02f, -2.42533430e-01f, 1.83104828e-01f, -9.80650261e-02f, -2.11086482e-01f,
  -1.44939587e-01f, -7.42694214e-02f, 1.62755087e-01f, 2.72815496e-01f, -8.34336132e-02f, 2.36227244e-01f, 2.32818797e-01f, 3.63914929e-02f, 1.41596928e-01f, -8.91595781e-02f,
  1.98932469e-01f, -2.70508397e-02f, 1.22437619e-01f, 2.87447631e-01f, 1.03174843e-01f, 3.46467495e-02f, -4.87458101e-03f, 9.36759338e-02f, 4.38527167e-02f, 7.55859818e-03f,
  -1.14761196e-01f, -1.70241529e-03f, 1.26135483e-01f, 4.47960682e-02f, 9.40030888e-02f, -1.56196430e-01f, -1.27059609e-01f, 1.48074359e-01f, -2.00257763e-01f, 1.82965428e-01f,
  -4.77785766e-02f, 1.36130661e-01f, 1.13306746e-01f, -7.31951371e-02f, -1.88568875e-01f, 7.02740848e-02f, -1.45112738e-01f, 2.09896564e-01f, 6.08316697e-02f, 9.49596316e-02f,
  1.91340625e-01f, 2.36605793e-01f, -8.41863230e-02f, -1.15137845e-01f, 4.11339998e-01f, 2.73944587e-01f, 8.11586715e-03f, 2.22811755e-02f, -2.29986534e-01f, 3.16878498e-01f,
  -5.49483672e-02f, 4.45054583e-02f, -2.13961095e-01f, 2.71060318e-01f, -3.83479372e-02f, -2.70660251e-01f, 2.48186570e-02f, 1.51532203e-01f, -8.96280035e-02f, 1.38526335e-01f,
  5.65492027e-02f, -8.99695456e-02f, -2.17364095e-02f, -2.33648613e-01f, 9.67752337e-02f, 8.52291360e-02f, -9.26039442e-02f, 1.80992901e-01f, -1.29258752e-01f, 2.59490162e-01f,
  2.98818443e-02f, 1.63011551e-01f, 1.58475220e-01f, -1.40667651e-02f, 2.66692899e-02f, -5.80563061e-02f, -1.40551269e-01f, 4.97533567e-02f, 1.19429387e-01f, 1.31131589e-01f,
  -6.33492097e-02f, -2.56701801e-02f, 1.80999085e-01f, 1.45994306e-01f, -6.76157549e-02f, 2.85340790e-02f, -4.88093197e-02f, 6.87887669e-02f, 5.24035692e-02f, -1.19184293e-02f,
  -7.25344867e-02f, 4.95681912e-03f, 6.20554090e-02f, 2.30158463e-01f, -1.25209406e-01f, 1.23695783e-01f, -4.48298864e-02f, -1.21925354e-01f, -8.78547430e-02f, -1.05853148e-01f,
  -8.88462365e-02f, -2.72974283e-01f, 2.59869248e-02f, 6.83324933e-02f, 8.13218281e-02f, 2.41122931e-01f, 3.03304289e-02f, -7.76568651e-02f, 1.85115010e-01f, 1.38053998e-01f,
  1.17006414e-01f, 8.23574737e-02f, -8.11452121e-02f, 9.31666270e-02f, -7.43617117e-02f, -8.55330154e-02f, 1.66535348e-01f, 2.70651728e-01f, -1.85981952e-02f, -1.78374499e-02f,
  2.65353173e-01f, 3.18157613e-01f, -1.30533516e-01f, 1.09829810e-02f, -7.09065795e-02f, 1.13115333e-01f, 2.19290912e-01f, -2.14647707e-02f, -3.78699861e-02f, -1.75605401e-01f,
  2.47319136e-02f, -1.12146046e-02f, -1.23653919e-01f, 2.38506213e-01f, -1.58014521e-01f, -9.18745548e-02f, -1.08772233e-01f, -2.36752592e-02f, 1.38876081e-01f, 1.24446817e-01f,
  2.03524396e-01f, 9.10831988e-03f, -1.38776714e-03f, 3.42797972e-02f, 2.02054933e-01f, 2.33025268e-01f, -8.77705216e-02f, 1.73517942e-01f, -1.05388574e-02f, 5.80197712e-03f,
  1.93970799e-01f, 9.55800563e-02f, 6.48186654e-02f, -5.36954477e-02f, 1.72665462e-01f, 2.15891138e-01f, 1.24752223e-01f, 2.25612909e-01f, 5.96711449e-02f, 1.91555172e-01f,
  -1.50808871e-01f, 1.70898680e-02f, 1.56312749e-01f, -2.97292485e-03f, 2.14676827e-01f, 2.35453159e-01f, -1.47835970e-01f, 1.43843487e-01f, 1.19580761e-01f, 9.96001959e-02f,
  1.94557413e-01f, -2.58257926e-01f, 2.85444468e-01f, -8.67198631e-02f, -2.44304910e-01f, 1.68899223e-01f, -1.80814177e-01f, -1.80608898e-01f, -2.57155560e-02f, -2.86156088e-01f,
  2.39960715e-01f, 6.05735891e-02f, -1.49224296e-01f, 1.86851285e-02f, 3.01538378e-01f, 2.52810389e-01f, 2.78313309e-01f, 1.10172741e-02f, 1.20543219e-01f, -1.99179109e-02f,
  8.67477506e-02f, -5.31303175e-02f, -3.88675816e-02f, 1.41745070e-02f, 1.23064071e-01f, 3.22550386e-02f, -1.52439997e-01f, 1.55571118e-01f, 1.33084729e-01f, -1.64155409e-01f,
  -3.03506348e-02f, 1.40207827e-01f, -1.97810903e-01f, -1.17281303e-01f, 1.70603335e-01f, 7.38491192e-02f, 4.85344939e-02f, 1.47622302e-01f, 1.66365981e-01f, 1.83272913e-01f,
  -9.78718102e-02f, 2.67041236e-01f, 1.00677252e-01f, 3.02971095e-01f, 1.66798327e-02f, 2.79642288e-02f, 1.40981562e-02f, 1.36074230e-01f, -1.82657689e-01f, -6.66489974e-02f,
  5.82315028e-03f, -1.18646875e-01f, -1.26358673e-01f, 6.58454746e-02f, -8.36787745e-02f, 3.33313420e-02f, -1.11096874e-01f, -1.94748104e-01f, -6.34557232e-02f, -3.04473966e-01f,
  5.05480506e-02f, 2.95226946e-02f, -1.33785576e-01f, 1.38664931e-01f, -2.28985816e-01f, 3.09353583e-02f, -8.50774944e-02f, 2.30263323e-01f, 5.42922840e-02f, 7.87945557e-03f,
  7.87248164e-02f, -1.64192021e-01f, -7.14463741e-02f, 1.21257097e-01f, -1.09072320e-01f, 3.36440653e-01f, 1.67035516e-02f, 7.18040839e-02f, -1.07579872e-01f, 1.07584009e-02f,
  8.39817058e-03f, -2.95543402e-01f, -2.33111992e-01f, -4.92497608e-02f, -4.56611030e-02f, 1.13921516e-01f, 6.39417022e-02f, 7.88239613e-02f, -6.99658617e-02f, 2.08625153e-01f,
  -2.64257520e-01f, -1.63731426e-02f, -1.55723318e-01f, -1.56286851e-01f, 1.97626635e-01f, 1.44064184e-02f, 4.14875478e-01f, -2.16741697e-03f, -6.44628704e-02f, -9.27435234e-02f,
  1.79690450e-01f, 1.35118961e-01f, 3.94990901e-03f, 1.38890669e-01f, 1.26008153e-01f, 6.68203039e-03f, -8.24426636e-02f, -1.37707546e-01f, 4.38993759e-02f, 1.02700487e-01f,
  2.19256356e-02f, 7.07798004e-02f, 1.09695002e-01f, -4.21136431e-02f, -2.32299969e-01f, 2.10335441e-02f, 1.23869374e-01f, -1.20439030e-01f, 4.09638062e-02f, 1.01802349e-01f,
  1.49292022e-01f, 2.70837825e-02f, 2.44959012e-01f, 1.44937053e-01f, 1.14518262e-01f, 1.70841187e-01f, -3.05272173e-02f, -2.21300200e-01f, 3.90010267e-01f, 1.57719657e-01f,
  -1.72351778e-01f, -1.87010378e-01f, -2.04556510e-01f, 6.94000274e-02f, -1.08252186e-02f, -1.35632455e-01f, 1.95360988e-01f, 2.39599392e-01f, 1.36760950e-01f, -4.17416871e-01f,
  1.08372189e-01f, -5.51741347e-02f, 1.08823031e-01f, 1.62006363e-01f, 1.10638589e-01f, 2.05108657e-01f, -2.62407124e-01f, 1.97419338e-02f, 2.36999728e-02f, 1.84052303e-01f,
  -3.97370532e-02f, -8.41460004e-02f, -3.67883258e-02f, 6.90162322e-03f, 6.32595122e-02f, -8.18732157e-02f, 2.33376518e-01f, -1.12002283e-01f, -4.56130616e-02f, -2.18841091e-01f,
  -3.40976447e-01f, 2.53684316e-02f, 2.72293715e-03f, 1.80101335e-01f, 3.51529568e-02f, 1.42135546e-01f, -7.66052157e-02f, -8.45855325e-02f, 1.18086495e-01f, -1.55362114e-01f,
  4.73056808e-02f, 1.05690323e-01f, 5.21625020e-02f, -7.05044419e-02f, -2.80178655e-02f, -2.26994548e-02f, 1.04907155e-01f, 1.47632182e-01f, 1.92605585e-01f, 1.86756477e-02f,
  9.83944759e-02f, -7.25652575e-02f, 1.52374923e-01f, -2.51492590e-01f, -1.73627734e-01f, 7.23081268e-03f, 9.10258144e-02f, 2.57016838e-01f, -5.19096889e-02f, -2.12056443e-01f,
  1.42163467e-02f, 1.04497574e-01f, -1.51191875e-01f, -2.77312417e-02f, -4.46285680e-02f, -5.37286662e-02f, 5.99258728e-02f, 9.52695236e-02f, -2.77045012e-01f, 3.86934370e-01f,
  -3.08608059e-02f, 6.09749705e-02f, 2.29985025e-02f, -1.18399253e-02f, 2.00992152e-01f, -8.39964226e-02f, -3.26567888e-02f, 3.75991594e-03f, -2.39458736e-02f, 2.22808614e-01f,
  3.21788728e-01f, -2.90464967e-01f, -1.15229309e-01f, 8.12106952e-02f, 3.56245674e-02f, 2.42951527e-01f, -2.17185140e-01f, 2.36864127e-02f, -3.16085182e-02f, 6.60962760e-02f,
  1.54575497e-01f, 3.89540404e-01f, 2.06742942e-01f, 1.93456616e-02f, -3.72989615e-03f, -1.00179300e-01f, -3.40246037e-02f, 9.17569175e-02f, -6.93053976e-02f, 6.87154755e-02f,
  -2.02024821e-02f, 1.72145141e-03f, -4.81686294e-02f, -1.60700575e-01f, -1.57490909e-01f, -1.47590995e-01f, -6.34465143e-02f, -1.55306086e-01f, -8.00932292e-03f, 1.14835307e-01f,
  -9.58444774e-02f, -3.37833539e-02f, -1.39266685e-01f, -1.54564744e-02f, 7.85101280e-02f, -1.62256762e-01f, 3.78455408e-02f, -1.65067613e-01f, 9.20234323e-02f, 1.35307517e-02f,
  -8.99918899e-02f, 1.41661733e-01f, 1.92482367e-01f, 8.55208561e-02f, 7.42692724e-02f, -1.04127653e-01f, 1.90817639e-01f, 1.09100536e-01f, -3.55369188e-02f, -1.83146119e-01f,
  -1.32481664e-01f, -1.28881663e-01f, 1.35890618e-01f, 7.42302313e-02f, 9.43955407e-02f, 4.90505025e-02f, 6.63162544e-02f, -2.80942887e-01f, 1.91248626e-01f, -2.52317581e-02f,
  1.67515323e-01f, -1.37243196e-01f, -1.37543544e-01f, 1.29203305e-01f, -2.17988700e-01f, 1.37246937e-01f, -2.84954943e-02f, 1.91161096e-01f, 2.02526134e-02f, -7.13256598e-02f,
  8.69152695e-02f, 7.62441754e-02f, 1.28909677e-01f, -1.76353514e-01f, -1.17722824e-01f, 6.75151050e-02f, -3.25194374e-02f, -1.80899814e-01f, -7.84798805e-03f, -2.01870486e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  2.39526317e-01f, 1.58830926e-01f, -5.12443744e-02f, 1.97065502e-01f, 1.57083035e-01f, -8.25619176e-02f, 4.60246718e-03f, 1.71805933e-01f, 1.25965670e-01f, 2.06161499e-01f,
  5.19930609e-02f, 2.02040717e-01f, -1.70270413e-01f, 1.05271809e-01f, 1.97530314e-02f, 4.93722819e-02f, 9.08702090e-02f, -3.05025876e-02f, -2.41930736e-03f, -1.08550359e-02f,
  4.97814491e-02f, 4.37412038e-02f, 9.65323001e-02f, 1.83078602e-01f, 8.25649053e-02f, -7.06018433e-02f, 3.02192699e-02f, -6.70350194e-02f, -1.21966466e-01f, -2.07215294e-01f,
  2.62694508e-01f, 1.69951335e-01f, 1.67393491e-01f, 8.60218853e-02f, -2.90386565e-02f, 1.78634554e-01f, 1.27035990e-01f, 3.26927900e-02f, 1.52132288e-01f, -2.67698973e-01f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.39458507e-01f, -2.03131080e-01f, 1.86889052e-01f, 8.18382204e-02f, -1.42913327e-01f, -1.38959646e-01f, -2.30015218e-01f, -8.48005638e-02f, -1.16588332e-01f, -5.22659793e-02f,
  -1.15779668e-01f, -1.31920010e-01f, -8.15991089e-02f, 8.94950926e-02f, -3.81477214e-02f, -6.45427108e-02f, -1.45279437e-01f, 8.36511925e-02f, 1.48201048e-01f, 1.77586805e-02f,
  -7.16657639e-02f, 2.98494428e-01f, -2.74097681e-01f, -1.22130863e-01f, 2.17523694e-01f, 6.39660582e-02f, 5.30934967e-02f, -1.57998577e-01f, -5.76717369e-02f, 1.44463733e-01f,
  -2.63840318e-01f, 7.89199919e-02f, 2.36223429e-03f, 9.25889388e-02f, -1.78527817e-01f, -1.67572498e-01f, -7.81382993e-02f, 2.05577523e-01f, -1.22899108e-01f, -1.72460809e-01f,
  9.90114454e-03f, -9.38431919e-02f, 2.72962838e-01f, 2.36043315e-02f, -5.24838641e-02f, 4.22652811e-02f, -2.64122561e-02f, -4.87160757e-02f, 1.74207866e-01f, 7.95101672e-02f,
  1.54704759e-02f, -1.61232911e-02f, -3.74220647e-02f, 9.02066082e-02f, 2.54769266e-01f, -6.01676814e-02f, -1.00757696e-01f, 6.90751523e-02f, -1.83093511e-02f, -2.06093881e-02f,
  -2.04405606e-01f, -1.67531282e-01f, 1.85237736e-01f, -4.47435863e-03f, 1.72414169e-01f, -6.00540414e-02f, 9.91130695e-02f, 8.36441368e-02f, 4.88744862e-03f, 1.34355068e-01f,
  1.67337850e-01f, 2.54507866e-02f, 3.84196162e-01f, 7.52473772e-02f, 1.21211268e-01f, 1.27440736e-01f, -1.26654105e-02f, 1.30379155e-01f, -8.68990794e-02f, 7.27900043e-02f,
  -1.39892250e-01f, 1.64256606e-03f, 1.11206077e-01f, 2.99014486e-02f, -1.22865602e-01f, -4.28172022e-01f, -1.61717720e-02f, -2.65785217e-01f, -5.39727733e-02f, 3.36710885e-02f,
  1.85392544e-01f, -2.83364579e-02f, 4.02506925e-02f, 2.00721212e-02f, -1.56550214e-01f, 1.19176179e-01f, 2.50433548e-03f, 7.81981423e-02f, 8.37676227e-02f, 3.50708276e-01f,
  -1.15924753e-01f, 7.52078444e-02f, 6.90898225e-02f, 1.37251802e-02f, -3.60636413e-02f, -6.16445094e-02f, -2.05879305e-02f, -1.32663921e-01f, 9.17144027e-03f, -1.18034683e-01f,
  1.09110051e-05f, 1.06535833e-02f, -2.06818119e-01f, -1.57885696e-03f, -5.29492535e-02f, -1.52293744e-03f, 2.80083194e-02f, 1.36546880e-01f, 4.26777042e-02f, 4.90658693e-02f,
  -9.22966599e-02f, 2.06894986e-02f, 8.61075446e-02f, 2.98197001e-01f, 9.21259895e-02f, 1.18640829e-02f, -1.62811145e-01f, -6.85522333e-02f, -1.09209128e-01f, 5.97174801e-02f,
  6.74259216e-02f, -1.70780912e-01f, -1.37625292e-01f, -1.95893258e-01f, -1.79283664e-01f, -4.43221703e-02f, 2.36247685e-02f, 1.90452665e-01f, 1.17605321e-01f, -8.89576748e-02f,
  1.43239886e-01f, -8.29669908e-02f, 1.97243690e-01f, -1.10733420e-01f, -7.21213743e-02f, -3.39464068e-01f, 4.79088277e-01f, 1.19267412e-01f, 1.50065154e-01f, 7.36202374e-02f,
  -2.45487705e-01f, 5.52756190e-02f, -1.28291279e-01f, -1.01906829e-01f, -3.57443392e-02f, 1.00388899e-01f, -8.23119953e-02f, -3.57776210e-02f, 1.37228206e-01f, -1.81807458e-01f,
  -2.41623983e-01f, 2.15351030e-01f, -7.21627772e-02f, -2.42202386e-01f, 1.76738665e-01f, 1.41064957e-01f, 3.38931754e-02f, -2.08207369e-02f, -5.11453412e-02f, -2.52568778e-02f,
  2.98123330e-01f, 3.87888104e-02f, 9.16109905e-02f, 2.69382954e-01f, -8.90148208e-02f, 2.30543502e-02f, -1.53813809e-01f, -2.68215925e-01f, -1.33211955e-01f, 1.10059209e-01f,
  -4.90017645e-02f, 4.17830907e-02f, 2.05979690e-01f, -8.98776427e-02f, 2.90149432e-02f, 1.61662903e-02f, -1.85454234e-01f, 4.02453728e-02f, 4.59813066e-02f, 2.68770475e-03f,
  5.44950739e-02f, 1.02583922e-01f, 1.11034095e-01f, 3.30944061e-02f, 8.19310695e-02f, -1.72227755e-01f, -2.21453607e-02f, -1.37141362e-01f, -8.02938938e-02f, 1.46813411e-02f,
  -8.81955996e-02f, -7.91429952e-02f, 3.51734236e-02f, 1.31456479e-01f, -2.70081107e-02f, -6.12597428e-02f, 1.21359535e-01f, 1.36067495e-01f, 1.18312247e-01f, -1.41368449e-01f,
  -1.25323655e-02f, 2.68176105e-02f, 1.50131524e-01f, 2.70845801e-01f, 2.15506628e-02f, 3.05376619e-01f, 3.42914127e-02f, 5.37970550e-02f, -2.53062714e-02f, 5.42291105e-02f,
  1.16506368e-01f, -7.54190609e-02f, 5.95953725e-02f, -2.03839466e-02f, 5.09985387e-02f, -6.22594692e-02f, 8.37852433e-02f, -3.56679648e-01f, 1.67229339e-01f, 1.02781923e-03f,
  -4.66344580e-02f, -1.03586949e-01f, -3.53255086e-02f, 1.14433013e-01f, -1.18061662e-01f, 1.25177771e-01f, 7.11596608e-02f, -5.08757979e-02f, -8.04004669e-02f, 1.02353163e-01f,
  1.26791611e-01f, -1.33668169e-01f, 6.98183477e-02f, -8.52797031e-02f, 6.46147951e-02f, -9.99656245e-02f, -3.23826373e-02f, 1.08775713e-01f, 3.69533547e-03f, 7.32814893e-02f,
  -1.57262698e-01f, -1.66057110e-01f, -1.10932507e-01f, 1.42442256e-01f, 1.68705285e-01f, 1.11180529e-01f, 8.31857249e-02f, 1.22133009e-01f, 1.99349135e-01f, -3.99023257e-02f,
  1.18664885e-02f, -1.23860322e-01f, -1.50243104e-01f, -9.19603929e-02f, -8.49371962e-03f, 5.34584448e-02f, 7.49820843e-02f, -5.96667342e-02f, 9.83301476e-02f, -2.45799094e-01f,
  3.65008004e-02f, -1.13793379e-02f, -6.42853081e-02f, -8.71648043e-02f, 5.55838980e-02f, 6.39831051e-02f, 7.78968483e-02f, 9.99481827e-02f, -1.90190330e-01f, -3.00340708e-02f,
  -2.10120499e-01f, 4.74139936e-02f, -2.78219767e-02f, -1.21378303e-01f, -1.29709467e-01f, 7.77717540e-03f, 2.11113542e-01f, -1.55268848e-01f, 4.32009846e-02f, -1.16918191e-01f,
  3.30883972e-02f, 6.47357851e-02f, 3.01691163e-02f, -1.26058772e-01f, -1.86705198e-02f, 2.87408549e-02f, 8.15540627e-02f, -1.01927839e-01f, -2.30501175e-01f, 2.84156520e-02f,
  2.12860674e-01f, -2.15111420e-01f, -3.88425402e-02f, -2.00166013e-02f, -5.28698638e-02f, 4.85505201e-02f, -1.31265730e-01f, 2.26917207e-01f, 6.86722174e-02f, 1.58507481e-01f,
  4.98526404e-03f, 7.68421078e-03f, 5.21850027e-03f, -8.72071553e-03f, 1.93721633e-02f, -3.87381688e-02f, -1.11628405e-03f, 1.59770146e-01f, -4.56242673e-02f, 1.74826130e-01f,
  2.13936552e-01f, -6.57962188e-02f, -3.56246270e-02f, 7.00754523e-02f, 4.45379727e-02f, -2.16490589e-02f, 2.74147429e-02f, 2.24056039e-02f, -3.98646221e-02f, -1.11703143e-01f,
  -8.43607336e-02f, 1.53942093e-01f, 1.87374353e-01f, 8.22412297e-02f, 3.85184065e-02f, -3.35521400e-01f, 8.64670798e-02f, 4.78955321e-02f, 2.79711306e-01f, -1.34465292e-01f,
  -2.94723570e-01f, -1.31825626e-01f, 3.75259258e-02f, -1.49927527e-01f, -9.14042294e-02f, -4.55015190e-02f, 5.54841496e-02f, -1.57560214e-01f, 5.20512387e-02f, 2.81394094e-01f,
  7.72745833e-02f, 1.07033312e-01f, -3.98053899e-02f, 7.07524344e-02f, 7.98462182e-02f, 9.06311050e-02f, 1.36398956e-01f, 4.92650382e-02f, -2.56234892e-02f, -6.65072212e-03f,
  -1.55257523e-01f, 1.00999728e-01f, 2.80960262e-01f, -1.84071567e-02f, 1.12399589e-02f, 2.71246940e-01f, -1.37280747e-01f, 1.20105587e-01f, -1.61386669e-01f, -1.37053370e-01f,
  1.96727142e-02f, -9.50108021e-02f, 7.73234591e-02f, -1.42027944e-01f, 1.46852270e-01f, -2.49867514e-01f, 1.04399674e-01f, -1.43836856e-01f, -4.75558266e-02f, 4.13979478e-02f,
  2.89069325e-01f, 1.90953404e-01f, -2.47188851e-01f, 1.54226199e-01f, -6.36222586e-02f, 1.08819343e-01f, 8.90517756e-02f, -1.83181196e-01f, -1.72992662e-01f, 9.88653004e-02f,
  -7.86773413e-02f, 1.05965637e-01f, -1.02805808e-01f, 6.74728863e-03f, -4.27017771e-02f, -1.39419234e-03f, -4.89080176e-02f, 1.87671363e-01f, 5.69133125e-02f, 1.75867751e-01f,
  -5.00209481e-02f, -5.80563769e-02f, 1.82485998e-01f, 9.40164924e-02f, 1.67300612e-01f, -2.28337929e-01f, -2.68352419e-01f, -5.92958815e-02f, -1.01759993e-01f, 3.81348282e-03f,
  1.58471093e-02f, -8.72923210e-02f, -1.79063946e-01f, -1.61964893e-01f, -4.08272296e-02f, -1.99466590e-02f, -5.98181449e-02f, -1.91853032e-01f, -3.60021815e-02f, -1.82061046e-01f,
  -7.14151263e-02f, -2.49723829e-02f, 4.59256992e-02f, -5.54203987e-02f, 1.87372997e-01f, -1.66103736e-01f, 1.67928696e-01f, 5.07952347e-02f, 1.62007406e-01f, -7.56691247e-02f,
  -1.75465703e-01f, 8.48496035e-02f, -5.36167473e-02f, -7.86920860e-02f, -6.84464425e-02f, 1.31317064e-01f, 7.73390681e-02f, 6.73766732e-02f, 7.05489814e-02f, 1.57398909e-01f,
  -5.61441816e-02f, -1.40802532e-01f, 5.23231998e-02f, -1.31018788e-01f, 1.15853347e-01f, -1.13093749e-01f, -3.46185900e-02f, -2.17015535e-01f, 1.71269402e-01f, 2.84088310e-02f,
  1.07992686e-01f, -1.14317285e-03f, 1.91497087e-01f, 2.09626585e-01f, -3.20697725e-02f, -1.16419092e-01f, 1.17467985e-01f, 5.96690457e-03f, 3.37658823e-01f, -8.84358808e-02f,
  -1.87164202e-01f, 1.16348326e-01f, -6.19185455e-02f, 3.00058156e-01f, -2.79491216e-01f, 5.98239852e-03f, -1.41248554e-01f, 6.93422779e-02f, 8.20595846e-02f, -1.11967973e-01f,
  1.18502960e-01f, -1.68443382e-01f, 5.08552007e-02f, 1.41504891e-02f, 6.98821098e-02f, 2.32506245e-02f, 8.79534408e-02f, 3.93717200e-01f, 6.16300814e-02f, -1.25617370e-01f,
  5.98725453e-02f, 1.87562034e-01f, -6.82214499e-02f, 4.54855859e-02f, 1.35159016e-01f, 1.26113091e-02f, -3.69413421e-02f, -1.27966762e-01f, -7.21019879e-02f, 2.26386592e-01f,
  -3.17992687e-01f, 1.22943603e-01f, 6.46420717e-02f, 8.92548934e-02f, -1.69547841e-01f, 4.18051220e-02f, -1.32949367e-01f, -4.65809256e-02f, 1.07674159e-01f, -3.04973405e-02f,
  -6.61523342e-02f, -1.89401973e-02f, -1.67084187e-01f, 6.80675730e-02f, 4.36317064e-02f, -8.88356790e-02f, -1.56505063e-01f, 7.91598782e-02f, -6.47203848e-02f, 2.74211675e-01f,
  -8.96075275e-03f, 3.04676354e-01f, -1.45257041e-01f, 2.55335402e-02f, 1.66573986e-01f, -2.01179963e-02f, -4.54212315e-02f, -1.50686309e-01f, -3.22288722e-02f, -7.74160326e-02f,
  -3.03093009e-02f, 7.87529275e-02f, -5.06275520e-02f, -8.42159316e-02f, -1.04572773e-01f, 5.91303892e-02f, -1.51343971e-01f, 7.42530823e-02f, -6.32819235e-02f, -1.28436178e-01f,
  9.04563721e-03f, -3.56817693e-02f, 2.46242106e-01f, 1.33949310e-01f, 2.18170643e-01f, 3.23877215e-01f, 2.67210573e-01f, 7.98378512e-02f, 6.41618967e-02f, 4.28784937e-02f,
  1.27406895e-01f, 8.89116600e-02f, -2.08588503e-02f, 7.69020468e-02f, 1.10906594e-01f, -5.63084073e-02f, 1.72747195e-01f, 7.34558627e-02f, -6.68720305e-02f, 1.72199994e-01f,
  8.66411179e-02f, -6.78998753e-02f, 4.96304892e-02f, 2.82179173e-02f, -6.89884201e-02f, -7.08312839e-02f, -1.04847848e-01f, -1.63961202e-02f, 8.66246521e-02f, -1.57463580e-01f,
  2.19739154e-01f, -1.19401604e-01f, 1.67251334e-01f, -7.32056871e-02f, 7.36460984e-02f, 1.15359657e-01f, -1.90051809e-01f, -5.45558408e-02f, -2.77637709e-02f, 1.11118451e-01f,
  1.38015226e-01f, 5.58199249e-02f, -2.08138376e-01f, -1.78515411e-03f, 2.51960576e-01f, 4.10230048e-02f, -6.16913603e-04f, 3.22283894e-01f, -1.49780035e-01f, -1.53170064e-01f,
  1.26092985e-01f, 7.80490562e-02f, 1.46707058e-01f, -2.58780438e-02f, -1.42378464e-01f, 2.07958296e-01f, 2.02464715e-01f, 1.49673268e-01f, -1.40504465e-01f, 1.03438400e-01f,
  9.34483707e-02f, 1.06013425e-01f, 1.45008639e-01f, -5.67327812e-02f, 1.26954108e-01f, -2.94664484e-02f, 7.58175552e-02f, -1.07372500e-01f, 1.37058333e-01f, 3.06323886e-01f,
  -8.03931132e-02f, 1.02338664e-01f, 1.44458145e-01f, -6.38323128e-02f, 1.05061866e-01f, 2.42877184e-04f, -7.48558789e-02f, 8.48901719e-02f, 8.71333256e-02f, 9.85370800e-02f,
  -4.74075563e-02f, -1.27760684e-02f, 1.43578574e-01f, -1.46842465e-01f, -5.16678579e-02f, 2.58103371e-01f, 1.28482893e-01f, 1.57672629e-01f, -3.96450050e-02f, 2.12489720e-02f,
  7.94550776e-02f, 5.44443838e-02f, -1.61665335e-01f, 7.04042539e-02f, 9.52546075e-02f, -2.07415726e-02f, 4.41441797e-02f, -2.50161290e-02f, -1.26845524e-01f, -1.09431319e-01f,
  8.68397113e-03f, 6.73760846e-02f, 8.06502104e-02f, -3.17017399e-02f, 6.58013150e-02f, -1.77993521e-01f, -5.80095649e-02f, 3.08602210e-02f, -1.01771750e-01f, 1.00707717e-01f,
  -2.39656284e-01f, -7.78182372e-02f, 7.28339283e-03f, -7.44810328e-02f, -7.77443722e-02f, -6.02166280e-02f, -9.06406641e-02f, -1.07294552e-01f, 3.08156554e-02f, -1.15117580e-01f,
  -3.13684228e-03f, -1.79920774e-02f, -8.85025635e-02f, 1.37190387e-01f, -5.63258193e-02f, -3.58530916e-02f, -5.36619872e-03f, 8.33057016e-02f, 1.84942052e-01f, 2.41592541e-01f,
  1.35624006e-01f, 1.16675183e-01f, -2.05447331e-01f, 2.90854797e-02f, 1.72011375e-01f, 1.28678218e-01f, 7.46677145e-02f, -1.80386260e-01f, 8.42327923e-02f, 2.78857648e-02f,
  2.25351448e-03f, 3.03780455e-02f, 8.40160772e-02f, -5.92688285e-02f, 5.41014830e-03f, -1.94384724e-01f, -1.27961382e-01f, -2.85888985e-02f, -1.66908547e-01f, -7.28464350e-02f,
  -1.20787159e-01f, -1.10691726e-01f, 1.31197765e-01f, -7.24011585e-02f, 1.32514447e-01f, -1.29156023e-01f, -1.13115534e-01f, -9.06298459e-02f, 9.36215445e-02f, -1.73965767e-01f,
  2.19453663e-01f, -4.86720353e-03f, -1.44257341e-02f, -7.30933920e-02f, -1.75070718e-01f, 9.32348296e-02f, 8.88655782e-02f, 3.47333029e-02f, -1.70724653e-02f, 1.38589650e-01f,
  -1.66261166e-01f, -1.42426506e-01f, 1.31492466e-01f, -2.90238317e-02f, -1.12929754e-01f, 2.74413303e-02f, -4.10234258e-02f, -9.27974656e-02f, 3.56115922e-02f, 1.12432256e-01f,
  1.12217411e-01f, 4.13290858e-02f, 1.86634406e-01f, 6.27307743e-02f, 2.93276817e-01f, 1.03193805e-01f, -4.54599150e-02f, 2.07542241e-01f, 2.61654202e-02f, 6.15531094e-02f,
  -3.61103080e-02f, 2.84282994e-02f, 2.67499745e-01f, 2.33304754e-01f, 1.51628613e-01f, -3.13498020e-01f, -9.81513504e-03f, -1.11906871e-01f, 8.48485529e-02f, 1.26233593e-01f,
  2.20116656e-02f, -1.92365542e-01f, 2.55059004e-01f, 2.17725873e-01f, 1.89908296e-02f, 3.36236745e-01f, 9.15624723e-02f, 8.41361433e-02f, -1.04851520e-03f, 3.51300836e-02f,
  -5.37349423e-03f, -4.62996960e-02f, -2.61847209e-02f, 1.25760078e-01f, -9.95587930e-02f, 1.51360393e-01f, 2.22732220e-02f, -9.85538140e-02f, -1.08403072e-01f, 1.12262718e-01f,
  -2.04181224e-01f, 4.55165654e-02f, 3.47285122e-02f, -1.15999281e-01f, 5.54412901e-02f, -2.68230289e-02f, -5.52835055e-02f, -1.32336676e-01f, -1.34266213e-01f, -2.03811005e-01f,
  4.88345325e-03f, -1.85505733e-01f, -2.05001384e-01f, 1.48299962e-01f, -6.34961110e-03f, 7.90702403e-02f, 4.67348797e-03f, 1.69618860e-01f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.21786155e-01f, 6.89655021e-02f, 7.89078847e-02f, 3.56134064e-02f, -1.31130293e-01f, -4.67128754e-02f, -1.24163650e-01f, 1.26497358e-01f, 5.81200384e-02f, -5.21485992e-02f,
  9.18344967e-03f, 1.07887574e-01f, -1.76562712e-01f, -4.00417671e-02f, -2.37870574e-01f, 2.51135498e-01f, 9.74797551e-03f, 2.57348716e-01f, -4.05921310e-01f, -6.20228574e-02f,
  -2.29183286e-01f, 4.58901562e-03f, 1.03165373e-01f, -5.48205316e-01f, -1.78430066e-01f, 1.10173367e-01f, 1.19019099e-01f, -2.20212191e-01f, -1.85338646e-01f, 1.42463064e-02f,
  3.56995538e-02f, 9.18086842e-02f, 4.06649619e-01f, -1.91228673e-01f, -4.62832004e-02f, 2.79139757e-01f, -4.90283184e-02f, -1.03886701e-01f, 5.30655682e-02f, 1.71324179e-01f,
  3.33453119e-01f, -9.81064960e-02f, -2.66407758e-01f, -6.33620024e-02f, 1.24952316e-01f, -8.49456787e-02f, -4.75147106e-02f, -1.35761559e-01f, 1.27256095e-01f, 2.02964455e-01f,
  2.20569372e-01f, 2.39882454e-01f, -2.69183982e-02f, 1.95664749e-01f, 5.66386431e-02f, -2.55797338e-02f, 4.73096669e-02f, 3.12758684e-02f, 2.39583421e-02f, 1.82192057e-01f,
  6.06206362e-04f, 8.49727243e-02f, 1.07340388e-01f, -1.83742687e-01f, -2.40162909e-01f, 8.45803171e-02f, -8.21264312e-02f, 7.92949423e-02f, -2.44399354e-01f, -8.04358255e-03f,
  2.45080739e-01f, 8.39788467e-02f, 1.17147684e-01f, -7.68493488e-02f, 2.10242923e-02f, 2.37483326e-02f, -3.30319196e-01f, 5.48653528e-02f, -1.54753074e-01f, 3.34889382e-01f,
  8.61705393e-02f, 5.24502993e-02f, -2.47596607e-01f, 2.33053356e-01f, 1.17900148e-01f, -2.15064332e-01f, 9.68587026e-02f, -1.94403634e-03f, 1.21369496e-01f, 1.49864599e-01f,
  1.62624046e-01f, -3.76704261e-02f, 1.88253134e-01f, 6.25456721e-02f, 1.44183543e-02f, -4.16470319e-02f, 3.14313859e-01f, -1.95384890e-01f, 1.26582561e-02f, 1.58666936e-03f,
  -9.15245488e-02f, 1.11933455e-01f, -1.59020629e-02f, -7.24979863e-02f, 7.72399679e-02f, 8.81404988e-03f, -1.19335018e-01f, -1.24185622e-01f, -4.58566844e-02f, 1.50914723e-03f,
  -1.42883360e-01f, -4.28982764e-01f, 2.59252548e-01f, 8.25313851e-02f, 2.53473878e-01f, 1.70722276e-01f, 7.34990463e-02f, 1.85082823e-01f, -2.96434462e-01f, 9.82685387e-03f,
  6.95238858e-02f, 6.67323247e-02f, -8.77061039e-02f, 1.55411005e-01f, -7.84784704e-02f, -2.06585437e-01f, 2.42756516e-01f, -1.33005306e-01f, -5.69642112e-02f, -1.74785435e-01f,
  1.98527157e-01f, 2.31131017e-02f, -9.83206904e-04f, 8.57808366e-02f, -2.48340428e-01f, 9.42528099e-02f, -1.99269131e-02f, -3.23515981e-02f, 2.09776714e-01f, 6.75332770e-02f,
  -2.77356386e-01f, 1.17117569e-01f, -1.29893705e-01f, 2.10182920e-01f, -3.90540808e-02f, 2.64376938e-01f, 1.04419634e-01f, -7.37110153e-02f, -1.50690839e-01f, -1.79426581e-01f,
  2.58875251e-01f, -2.75743484e-01f, -2.09831577e-02f, 1.01470023e-01f, 1.06464170e-01f, -1.62871376e-01f, 1.22676529e-01f, -1.09772220e-01f, 7.07201138e-02f, 2.50877887e-01f,
  4.91708033e-02f, 1.49218664e-01f, 1.02385595e-01f, 1.87697262e-01f, 1.16999224e-01f, 2.36783147e-01f, -1.59312580e-02f, 1.96353957e-01f, 5.49541670e-04f, 1.10394970e-01f,
  -1.62536666e-01f, -1.49083331e-01f, -7.91188888e-03f, -1.31351978e-01f, 1.13284297e-01f, -2.31267706e-01f, 1.00399544e-02f, 5.55792488e-02f, 3.92992534e-02f, -1.52739227e-01f,
  -2.03832790e-01f, 1.16695166e-01f, -1.81995258e-01f, 1.31767258e-01f, 6.46262541e-02f, -9.33699682e-02f, 1.08255558e-01f, 1.50200158e-01f, -1.90100908e-01f, 1.09258465e-01f,
  -8.79656803e-03f, 7.32966885e-02f, 1.19013183e-01f, 6.59774393e-02f, -4.36274260e-02f, 8.50440413e-02f, 8.06941688e-02f, 6.81736320e-02f, -6.45241141e-02f, 1.09486513e-01f,
  -9.58341919e-03f, 3.82868685e-02f, 1.16869248e-01f, 2.05426570e-02f, -9.74509344e-02f, 4.22184430e-02f, 2.10918948e-01f, -1.57348916e-01f, 3.54266167e-02f, -1.71571791e-01f,
  1.97021216e-02f, -1.91586643e-01f, 1.33574799e-01f, 1.21706896e-01f, 3.19331765e-01f, 7.38668621e-01f, 7.96478465e-02f, 2.32120916e-01f, 4.50684726e-02f, 2.27879673e-01f,
  2.61487901e-01f, -2.84476787e-01f, -1.28459156e-01f, 1.86735794e-01f, -2.87225455e-01f, -6.35754541e-02f, 2.39024311e-01f, -2.07190126e-01f, -7.63382688e-02f, 5.09451889e-02f,
  1.16661042e-01f, -7.64091536e-02f, -1.63216799e-01f, 6.64389282e-02f, 1.92623347e-01f, -7.68945515e-02f, 3.09929997e-02f, 7.50620142e-02f, 6.99128434e-02f, -3.92519198e-02f,
  2.26218984e-01f, 1.12557113e-01f, -1.81016549e-01f, -1.08246118e-01f, -1.32571505e-02f, 2.35353529e-01f, 1.54409513e-01f, 3.69937330e-01f, 9.08486173e-02f, 2.76660383e-01f,
  3.73661215e-03f, 3.97927985e-02f, -2.39986241e-01f, 2.33768243e-02f, 3.78230661e-02f, -1.83841780e-01f, 1.74973570e-02f, -1.12104498e-01f, 1.61313012e-01f, 3.87848988e-02f,
  -2.20351085e-01f, -3.15659344e-02f, 8.09072554e-02f, 1.35757744e-01f, -1.14633709e-01f, 1.26981735e-01f, 1.55645475e-01f, 7.56763741e-02f, 9.68452692e-02f, 1.49137661e-01f,
  1.46571517e-01f, 8.43837019e-03f, -2.91556597e-01f, -1.51991826e-02f, 3.84824246e-01f, 1.69866174e-01f, 9.14773867e-02f, 1.38402551e-01f, -2.55053282e-01f, -7.17863292e-02f,
  1.08112209e-01f, 1.24420404e-01f, -1.78101212e-02f, 2.94947922e-02f, 3.98735739e-02f, -9.40946043e-02f, -1.36140034e-01f, -1.44347504e-01f, -2.44122997e-01f, 9.08010080e-02f,
  -6.44935481e-03f, -9.56408232e-02f, -1.45947754e-01f, 2.00721234e-01f, 1.44850284e-01f, -2.27228910e-01f, 1.93626783e-03f, -2.35789746e-01f, 4.49172407e-01f, 1.59232154e-01f,
  -6.58587087e-03f, 2.69234568e-01f, -1.61102656e-02f, -4.18010391e-02f, 1.69589594e-02f, -5.13507985e-02f, 9.18795243e-02f, 1.63232788e-01f, 1.64797693e-01f, 1.36440367e-01f,
  2.23262623e-01f, 2.55744904e-01f, 9.00001358e-03f, 1.24739625e-01f, 1.98206659e-02f, 6.07027523e-02f, 4.31136787e-02f, -3.16384971e-01f, 2.34957099e-01f, -2.13664949e-01f,
  8.52789953e-02f, 1.20678000e-01f, 4.47376072e-02f, 1.32961586e-01f, -9.53395944e-03f, 1.01586282e-01f, 1.78414017e-01f, 8.53514448e-02f, 4.18308340e-02f, 3.86723764e-02f,
  2.50407636e-01f, 9.32189971e-02f, -9.81233194e-02f, 6.07999042e-02f, 2.61088967e-01f, 2.27718249e-01f, -9.56821665e-02f, -1.71232566e-01f, -2.97987759e-01f, 1.26315966e-01f,
  5.25008701e-03f, -1.05005078e-01f, -2.84290045e-01f, 8.91681910e-02f, -1.73061732e-02f, 4.75322604e-02f, 1.63295060e-01f, 1.09258376e-01f, -7.82794226e-03f, -8.90965834e-02f,
  1.20777182e-01f, 1.64123829e-02f, 2.42177695e-01f, -1.27809331e-01f, -1.10925585e-01f, -1.34324118e-01f, 1.10791512e-01f, -5.44794276e-02f, 1.86231434e-01f, 1.42571047e-01f,
  2.11951420e-01f, 4.39924784e-02f, -2.77433038e-01f, 8.11814070e-02f, 2.19637215e-01f, -1.49357870e-01f, -2.53119677e-01f, 1.34191558e-01f, 1.64965000e-02f, -8.80267173e-02f,
  1.95681021e-01f, 2.41764516e-01f, 4.33621649e-03f, -3.45367305e-02f, 1.52214915e-01f, -5.14587276e-02f, -2.25464385e-02f, 3.80878560e-02f, 5.19833490e-02f, -1.31638438e-01f,
  -2.77594458e-02f, 5.24062477e-02f, 2.53502000e-02f, -5.77454530e-02f, -2.01911461e-02f, -6.42383173e-02f, 5.81484176e-02f, 1.38746843e-01f, -8.42931401e-03f, -3.90185528e-02f,
  -6.79570362e-02f, -1.21011779e-01f, -9.05524641e-02f, -9.78184212e-03f, -1.46673486e-01f, 3.29209631e-03f, -8.89342465e-03f, -1.61579683e-01f, -1.51400164e-01f, -6.67091534e-02f,
  4.09058146e-02f, -1.54046357e-01f, -2.11159557e-01f, -1.06828712e-01f, -4.47660312e-02f, 3.85242134e-01f, 2.87283808e-01f, 1.91021383e-01f, 7.25518912e-02f, 7.19045550e-02f,
  1.90995097e-01f, 7.52964094e-02f, -1.54430553e-01f, -5.80494180e-02f, 9.77075621e-02f, -9.35026780e-02f, 5.38156070e-02f, -2.34304503e-01f, -7.22253546e-02f, 2.05231458e-01f,
  6.47797585e-02f, -1.10804878e-01f, 6.36587515e-02f, -8.58862028e-02f, 1.44418836e-01f, -4.00791429e-02f, -3.92126232e-01f, -4.41354699e-02f, 1.70968458e-01f, -3.53852838e-01f,
  2.32653961e-01f, -9.12872404e-02f, -3.47305019e-03f, 5.01557440e-02f, 3.38698924e-02f, 4.12350476e-01f, 1.87499896e-01f, 2.97012359e-01f, -3.40575337e-01f, 2.16374233e-01f,
  -2.22580209e-01f, 9.25705656e-02f, 5.88033795e-02f, -2.17438295e-01f, -2.19535947e-01f, 7.39955455e-02f, 1.03339307e-01f, 1.09450586e-01f, -4.74934466e-03f, 2.18380943e-01f,
  -5.90609126e-02f, 5.42780086e-02f, 2.26506889e-02f, 7.15197846e-02f, -3.49171050e-02f, 1.92306936e-01f, 1.69155344e-01f, 2.67637134e-01f, 3.58804226e-01f, -1.07479375e-03f,
  -1.50236621e-01f, 2.68797744e-02f, 1.37058884e-01f, 2.10085049e-01f, -1.87984064e-01f, -9.29637253e-02f, -3.37063789e-01f, 1.68428376e-01f, 7.38135306e-04f, -2.60441691e-01f,
  -4.15379316e-01f, -1.37454197e-01f, -1.56348929e-01f, 1.78147554e-01f, 1.61708623e-01f, 1.12601809e-01f, 2.52987985e-02f, -2.22146995e-02f, 1.65398419e-01f, -1.93021335e-02f,
  3.74284424e-02f, 1.29371043e-02f, -1.90399066e-01f, -9.85543206e-02f, 1.41623691e-01f, -5.98192513e-02f, -2.13988841e-01f, 4.75082546e-03f, 1.27172038e-01f, -8.64230096e-02f,
  -7.39768073e-02f, 1.82064742e-01f, 1.19464353e-01f, -5.77877462e-02f, -5.32236159e-01f, 1.83366075e-01f, 1.84939280e-01f, -1.76057760e-02f, 1.10943459e-01f, 1.92174241e-01f,
  -1.48201108e-01f, 1.38231739e-01f, 2.39163339e-01f, 1.35403171e-01f, -2.18992040e-01f, -1.93877667e-01f, -7.03285933e-02f, -7.76601434e-02f, 1.18886091e-01f, -7.27898031e-02f,
  -9.41283070e-03f, -2.79475361e-01f, 6.50569722e-02f, 1.13503784e-01f, 1.16609260e-01f, 1.81706443e-01f, 1.18846357e-01f, 2.25896791e-01f, -9.83494669e-02f, 3.10062952e-02f,
  1.79111257e-01f, 2.63787597e-01f, -7.75084049e-02f, 1.03993848e-01f, 6.87797368e-02f, 1.64512604e-01f, 2.90477742e-02f, 3.70325781e-02f, 1.11745577e-02f, 2.97889858e-01f,
  1.63838431e-01f, -2.31443182e-01f, -1.58371270e-01f, -4.30109292e-01f, 2.08446562e-01f, -1.31515831e-01f, -1.97324067e-01f, 5.78180030e-02f, 3.34034748e-02f, -1.72603548e-01f,
  -1.22177601e-01f, -1.45252138e-01f, 7.42308274e-02f, 2.12645069e-01f, 1.67618170e-02f, -1.84496656e-01f, 1.75509289e-01f, 3.92424852e-01f, -1.26920849e-01f, -5.51360771e-02f,
  4.88807783e-02f, 2.04235181e-01f, 1.52335852e-01f, -1.40080720e-01f, -6.15349934e-02f, -1.92381456e-01f, 2.10600384e-02f, -1.09625436e-01f, -1.30959630e-01f, 1.41162142e-01f,
  -2.07145602e-01f, 2.22638194e-02f, 9.38767493e-02f, 2.15631783e-01f, 1.22167738e-02f, -7.20700296e-03f, -1.13153651e-01f, -1.96124222e-02f, -3.03306095e-02f, 1.91872075e-01f,
  1.31484836e-01f, 2.60448188e-01f, 1.22249648e-01f, -8.62359703e-02f, -2.07809374e-01f, -5.98120801e-02f, 2.93343484e-01f, 5.75088076e-02f, 9.40996855e-02f, 2.83940714e-02f,
  3.77065241e-01f, 8.74565989e-02f, 1.34805935e-02f, 8.86534303e-02f, 3.87700126e-02f, 4.57403138e-02f, -4.97834273e-02f, 1.90842692e-02f, 1.74460158e-01f, -3.43583971e-01f,
  -5.40045165e-02f, -9.28475931e-02f, -3.42041515e-02f, 1.29122538e-02f, -3.13841522e-01f, -1.22483522e-01f, -1.27377927e-01f, 2.58854300e-01f, -4.47475277e-02f, -3.25031579e-01f,
  4.60335352e-02f, -4.98888828e-02f, -9.73022357e-03f, 2.14039490e-01f, -2.40990981e-01f, -1.64760187e-01f, 2.44955886e-02f, -1.84446171e-01f, 7.04388097e-02f, 4.44812234e-03f,
  -1.30822003e-01f, 1.54739738e-01f, 5.88577837e-02f, -8.22867230e-02f, -1.81069210e-01f, -4.63059507e-02f, 6.58463538e-02f, -2.44426206e-01f, -3.58513176e-01f, -3.25234458e-02f,
  -4.15599272e-02f, -2.41567478e-01f, 1.23578548e-01f, 3.66451293e-02f, -1.09354742e-01f, 3.00492376e-01f, -6.78623095e-02f, -9.35471877e-02f, 6.51394650e-02f, -3.82376015e-02f,
  1.25902757e-01f, -2.53275279e-02f, -1.05539568e-01f, -6.44952431e-03f, 1.27087355e-01f, -1.79424539e-01f, 8.86290297e-02f, -3.58838916e-01f, -4.60794233e-02f, -1.35660425e-01f,
  2.43359089e-01f, -5.40282056e-02f, 1.30902484e-01f, -5.92831820e-02f, 1.82376459e-01f, 1.03088118e-01f, -1.47880092e-01f, 1.37923211e-01f, -1.67507499e-01f, 1.39242470e-01f,
  -1.57972183e-02f, 1.12566613e-01f, 7.28336349e-02f, -1.95719838e-01f, 9.77218449e-02f, -1.68590248e-02f, 6.43620491e-02f, -4.46050346e-01f, -3.09265465e-01f, -1.37238503e-01f,
  -8.79764482e-02f, 4.33087736e-01f, -1.57467172e-01f, 1.03714600e-01f, 1.00805014e-01f, -1.00112772e-02f, 4.67660883e-03f, 2.82731473e-01f, 1.52312011e-01f, -3.45464677e-01f,
  -5.36388298e-03f, -9.30503458e-02f, 2.67748479e-02f, 5.47752641e-02f, 1.16126560e-01f, -2.45915260e-02f, 2.37491149e-02f, -1.88868061e-01f, -2.16896608e-02f, -1.20218433e-01f,
  2.81721214e-03f, 1.21382765e-01f, -2.26705432e-01f, 3.02015632e-01f, 7.76467174e-02f, -4.59277123e-01f, 2.42447019e-01f, 1.70346975e-01f, 5.77543862e-02f, 2.97044158e-01f,
  2.88075451e-02f, -6.75406754e-02f, 6.01605140e-02f, -4.82351668e-02f, -3.43180262e-02f, 1.54062927e-01f, -7.73813352e-02f, -6.39440790e-02f, 1.16856351e-01f, -2.66148120e-01f,
  5.99077009e-02f, 3.21705900e-02f, -8.35136846e-02f, -5.52849025e-02f, -1.20517045e-01f, 7.47289434e-02f, -1.33570701e-01f, 7.12310001e-02f, -1.13587277e-02f, 1.71897724e-01f,
  -1.32401213e-01f, 7.30559230e-02f, -1.16912752e-01f, -2.07905397e-01f, -1.07267961e-01f, 2.21391782e-01f, -3.84001844e-02f, 7.91886151e-02f, 1.45845264e-01f, -1.64700136e-01f,
  4.68226559e-02f, 4.60545011e-02f, 7.97686502e-02f, -2.13277310e-01f, -2.59469321e-04f, -1.16723627e-01f, 4.27211560e-02f, 2.14103982e-02f, -4.73938584e-02f, -4.57804985e-02f,
  7.36730695e-02f, 2.74297837e-02f, -1.29023731e-01f, -1.64894164e-01f, 4.08321470e-02f, 2.92172551e-01f, -1.65911287e-01f, -1.66879490e-01f, 2.59543717e-01f, -2.82003246e-02f,
  -1.61111563e-01f, -6.47796169e-02f, 4.81539071e-02f, 1.82260752e-01f, -1.19459771e-01f, -3.51844728e-02f, -1.48241997e-01f, -1.95512827e-02f, -8.48315135e-02f, -1.80836782e-01f,
  -4.48195003e-02f, 1.15108602e-01f, -2.38762572e-01f, -9.46855992e-02f, -4.45346653e-01f, 2.23779634e-01f, -8.68765861e-02f, 2.48971522e-01f, -2.16760531e-01f, -2.26397902e-01f,
  1.40702024e-01f, -1.96062550e-02f, 1.35851994e-01f, 5.38147986e-02f, -1.51670739e-01f, 1.90802455e-01f, -3.96036714e-01f, 2.62540448e-02f, -8.48358274e-02f, -3.97576429e-02f,
  1.01240605e-01f, -3.38500272e-03f, 1.37538463e-01f, 1.98813930e-01f, -1.15542851e-01f, 9.82789919e-02f, 5.31391688e-02f, -1.88988835e-01f, 7.23190606e-02f, 4.96551134e-02f,
  -2.74140537e-01f, 2.06723973e-01f, -5.70549332e-02f, 1.49347737e-01f, -1.51463272e-02f, -1.17809169e-01f, -1.62702635e-01f, -1.08966649e-01f, 3.51530388e-02f, 9.78490785e-02f,
  9.06335413e-02f, 8.45974535e-02f, 3.84367853e-01f, 1.89483946e-03f, -3.04285344e-02f, 3.40778619e-01f, 4.39120322e-01f, 1.21545065e-02f, -7.99897651e-04f, 3.37479800e-01f,
  2.20439821e-01f, 2.94476021e-02f, 9.24378857e-02f, -5.80855608e-02f, -4.85180616e-02f, 7.27453679e-02f, -8.84723589e-02f, 2.10420102e-01f, -2.18337700e-01f, 1.91151440e-01f,
  -1.25480264e-01f, 8.17240924e-02f, -5.15837735e-03f, -2.03420609e-01f, -9.97665673e-02f, 2.40491703e-02f, 2.17645824e-01f, 3.65489796e-02f, 1.41574234e-01f, -2.75860459e-01f,
  -3.28114092e-01f, -1.70162916e-02f, -1.15365587e-01f, 9.49905366e-02f, 2.62862332e-02f, -1.38013497e-01f, 3.46282646e-02f, 2.00454257e-02f, -2.64604658e-01f, 2.34216765e-01f,
  9.41687673e-02f, -5.20742163e-02f, 7.94066936e-02f, 1.12564653e-01f, 1.00652315e-01f, 1.83668062e-01f, 6.45444021e-02f, 2.49866784e-01f, 1.56925559e-01f, 1.21756658e-01f,
  1.25546142e-01f, 2.52103895e-01f, 8.39515030e-02f, 7.74273351e-02f, -1.00306049e-01f, 3.01359981e-01f, 5.46726771e-02f, -5.54244816e-02f, -2.61201531e-01f, -1.98248010e-02f,
  2.22827680e-02f, -4.02167812e-02f, -1.86210051e-02f, -6.43509850e-02f, -2.14778528e-01f, -5.89352194e-03f, 2.23857835e-01f, 1.79507226e-01f, -1.56258211e-01f, 2.96319306e-01f,
  2.48331949e-01f, -1.21270776e-01f, -2.89642483e-01f, 1.37448132e-01f, -2.57822841e-01f, 3.91419321e-01f, 2.32369602e-02f, -8.30618292e-02f, 4.11210135e-02f, 2.45462552e-01f,
  1.63630918e-01f, 1.62645038e-02f, -2.30708763e-01f, 1.63719207e-02f, 2.85281926e-01f, 1.56102762e-01f, -1.44553840e-01f, 3.51365775e-01f, -2.34726921e-01f, 3.07589740e-01f,
  2.77486388e-02f, 8.11298937e-02f, 1.28913119e-01f, -3.65630329e-01f, -1.94712028e-01f, -1.67363808e-01f, 2.96817750e-01f, 2.44969204e-02f, -1.62238762e-01f, 8.28610286e-02f,
  3.85840535e-02f, 6.90215752e-02f, 2.38929614e-01f, -1.72260955e-01f, -2.15140041e-02f, -7.68086389e-02f, 5.36601618e-02f, 4.74778116e-02f, 6.46123886e-02f, 2.00795624e-02f,
  2.33538032e-01f, 2.73103327e-01f, 3.16791683e-02f, 3.24262768e-01f, 2.27038041e-01f, 1.50762364e-01f, 3.08440566e-01f, 3.03449064e-01f, -1.54257551e-01f, 3.18266422e-01f,
  -9.49621201e-02f, 1.47405118e-01f, -1.79657191e-01f, 2.73938656e-01f, 9.11232159e-02f, 1.53600574e-01f, -1.26842305e-01f, -6.67693853e-01f, -1.68152109e-01f, -5.35570383e-01f,
  6.38307929e-02f, 4.24519666e-02f, 4.80361618e-02f, -9.98502895e-02f, 1.25250006e-02f, -4.35197055e-02f, 8.98690671e-02f, 1.76175863e-01f, 2.03556404e-01f, 1.59046218e-01f,
  -4.54467759e-02f, 3.78984958e-03f, 3.15495059e-02f, -1.00687509e-02f, -1.28230214e-01f, 2.36743957e-01f, 1.04201891e-01f, -1.88061073e-01f, 2.43780557e-02f, -1.37020513e-01f,
  2.99121253e-02f, -9.69778448e-02f, -2.70498991e-01f, 1.66067809e-01f, -9.68266279e-02f, -9.47719067e-02f, 2.54907876e-01f, 1.59483484e-03f, -2.11567417e-01f, -8.95690620e-02f,
  9.01437849e-02f, 5.33646308e-02f, -1.69501811e-01f, -3.68879378e-01f, 9.67108905e-02f, 2.81208813e-01f, -2.33529918e-02f, 4.32680622e-02f, -9.12004039e-02f, -2.08462149e-01f,
  2.00073734e-01f, 5.43884188e-02f, 1.60183549e-01f, 1.14085712e-01f, 1.75997078e-01f, -1.40365781e-02f, -1.06457569e-01f, 4.56033982e-02f, -1.92066461e-01f, 1.18332714e-01f,
  6.04424365e-02f, -5.95029853e-02f, 1.90143093e-01f, -3.53746675e-02f, 2.17298254e-01f, -2.43408874e-01f, -6.69279993e-02f, 5.19599691e-02f, -1.44809842e-01f, -9.38433632e-02f,
  -2.88004547e-01f, -2.40562987e-02f, 1.08728655e-01f, -1.96700674e-02f, -2.11649016e-01f, -7.22863376e-02f, -1.56720206e-01f, -2.68220510e-02f, -1.23919703e-01f, -1.97614878e-01f,
  2.01569855e-01f, 1.09446287e-01f, 5.86859584e-02f, 1.42324001e-01f, 1.52580172e-01f, 9.38249752e-02f, 1.40909180e-01f, 5.74545301e-02f, -8.77379924e-02f, 8.29525888e-02f,
  -9.32568312e-03f, 1.25057846e-01f, 1.08104587e-01f, 6.41582236e-02f, -6.77591860e-02f, 1.14098817e-01f, 8.25145468e-02f, 6.84760064e-02f, -1.92786485e-01f, 1.86546788e-01f,
  -1.65015221e-01f, -1.15119822e-01f, 1.02588996e-01f, -9.67924446e-02f, 1.09393314e-01f, -2.73381211e-02f, 2.72697389e-01f, 1.33758083e-01f, 1.94130108e-01f, -6.04463071e-02f,
  2.69350350e-01f, 3.44040841e-02f, -6.77202642e-02f, -1.80554092e-02f, 1.03841767e-01f, 4.32232097e-02f, 6.71493495e-03f, 3.02921794e-03f, -1.82506312e-02f, 1.78748310e-01f,
  -4.74352464e-02f, 1.57764450e-01f, -3.56883593e-02f, 9.38257053e-02f, 2.64328867e-01f, 1.30016863e-01f, -2.82566816e-01f, 5.14435908e-03f, 9.52323005e-02f, 2.87649363e-01f,
  -6.65654242e-02f, -1.90136358e-01f, -1.16559915e-01f, 2.95756042e-01f, 1.83697298e-01f, -3.97629887e-02f, -1.67801864e-02f, 2.20205635e-01f, 1.14977375e-01f, 1.49428457e-01f,
  -5.88211305e-02f, 3.83027107e-01f, 3.14897329e-01f, -4.94211465e-02f, -1.15978770e-01f, 8.93912911e-02f, 4.41523418e-02f, 3.01557273e-01f, -1.08799249e-01f, -2.13672981e-01f,
  1.49371162e-01f, -6.49221241e-02f, 3.61404568e-02f, -7.38733932e-02f, -1.27668127e-01f, 9.50374678e-02f, -2.73250043e-01f, 3.19670647e-01f, 8.69875550e-02f, -1.13286719e-01f,
  -6.38306066e-02f, 2.88809925e-01f, 4.12304103e-02f, 1.91254675e-01f, 1.65197194e-01f, -2.11326271e-01f, -2.85265118e-01f, -1.34086087e-01f, 5.59504591e-02f, 2.36899659e-01f,
  -4.80618849e-02f, -1.66912585e-01f, 1.40228048e-01f, 6.50629848e-02f, 1.95686415e-01f, 1.71597779e-01f, 1.33109778e-01f, 2.81655160e-03f, 1.23289078e-01f, -8.34568813e-02f,
  1.39128253e-01f, 9.30325165e-02f, -1.04138423e-02f, -1.87950432e-02f, -1.77925691e-01f, -5.06483018e-02f, -1.81758717e-01f, -2.40764171e-02f, -4.70635593e-02f, -8.13297331e-02f,
  -1.47414682e-02f, 8.54355320e-02f, 1.48728108e-02f, -3.37801099e-01f, -1.16030887e-01f, -8.01368877e-02f, 2.78522640e-01f, -5.61445430e-02f, -2.85506278e-01f, 1.61247686e-01f,
  -5.66342212e-02f, -1.04314350e-01f, 2.95100566e-02f, -8.88884440e-02f, -4.68968302e-02f, -1.80864900e-01f, -4.23775427e-02f, -1.61927819e-01f, 1.55968174e-01f, 6.14549965e-02f,
  -8.82316530e-02f, -3.52262370e-02f, 8.11702833e-02f, 2.22658038e-01f, -2.01505229e-01f, 2.74683982e-01f, -6.39708480e-03f, 7.19853342e-02f, -9.65846851e-02f, 7.05013946e-02f,
  3.29343915e-01f, -2.95521736e-01f, -2.82000005e-01f, 1.47541493e-01f, 2.69130170e-01f, -2.77610451e-01f, -1.84635147e-01f, -3.88061516e-02f, -3.29896599e-01f, 1.53583184e-01f,
  2.13229701e-01f, 2.53853977e-01f, -3.37393880e-02f, 2.85669863e-02f, 2.53318369e-01f, 2.88838536e-01f, 1.66483805e-01f, 1.45149529e-01f, -3.25992145e-02f, -4.01065685e-02f,
  -1.64190471e-01f, -4.98838611e-02f, -3.19860838e-02f, 1.96457133e-01f, 6.73480332e-02f, 4.62531857e-02f, 1.78888872e-01f, 3.98016721e-02f, -3.03982615e-01f, 2.52613109e-02f,
  1.17342807e-01f, 3.82780731e-01f, 2.02571139e-01f, 6.67860135e-02f, -1.14317853e-02f, 1.17500789e-01f, -2.05819517e-01f, -1.11945368e-01f, -3.24447900e-01f, 9.97306034e-02f,
  4.76275057e-01f, 1.38848826e-01f, 5.36076948e-02f, -3.15837264e-01f, -2.00179778e-02f, -1.58560351e-01f, -1.26992375e-01f, 3.85547280e-02f, 4.40478921e-02f, -2.23074675e-01f,
  4.81961966e-02f, 2.26956531e-01f, 7.74512738e-02f, 1.37549922e-01f, -1.46989286e-01f, 3.40679079e-01f, -1.01643831e-01f, 1.79735333e-01f, 4.82690223e-02f, 5.18807136e-02f,
  7.21898675e-02f, 5.13484031e-02f, 1.46440864e-01f, 6.60766438e-02f, 5.00118956e-02f, -2.67559998e-02f, 1.86170250e-01f, 2.29708459e-02f, -2.20030352e-01f, 9.81477797e-02f,
  -1.10785961e-01f, -1.49030998e-01f, 5.35488352e-02f, 3.87316085e-02f, 9.17097786e-04f, -1.70517400e-01f, -1.68243185e-01f, -2.80936342e-02f, -2.03575902e-02f, -4.18362826e-01f,
  -8.39781296e-03f, 6.06618449e-02f, 2.37545650e-02f, 9.03662965e-02f, -1.30845830e-01f, -1.26061160e-02f, -2.34693456e-02f, -6.42505586e-02f, 7.01361746e-02f, 2.47732848e-01f,
  1.37608826e-01f, -4.43167277e-02f, 3.92426960e-02f, 1.72823414e-01f, 2.14784518e-01f, 1.46003857e-01f, 1.86309665e-01f, 2.00652570e-01f, -5.67979664e-02f, -2.51303911e-02f,
  7.04097226e-02f, 1.56943217e-01f, -1.60840273e-01f, 1.79261595e-01f, -3.95735204e-01f, 1.15189172e-01f, -7.07302019e-02f, 2.70326585e-01f, 8.32226425e-02f, -3.32910597e-01f,
  8.30455218e-03f, 1.11966580e-01f, 9.19250324e-02f, 5.34068160e-02f, 8.80160462e-03f, -1.94321528e-01f, 1.88634217e-01f, 7.38116652e-02f, 2.21591353e-01f, -1.81967840e-01f,
  -1.80482849e-01f, 2.60613441e-01f, 3.04595605e-02f, -7.60416090e-02f, 1.19971119e-01f, 1.13268659e-01f, 2.76883781e-01f, -1.84890285e-01f, -3.00754070e-01f, -5.33306114e-02f,
  2.19879642e-01f, -3.82870644e-01f, 1.82061538e-01f, 3.06235496e-02f, 7.78591214e-03f, 2.51469553e-01f, 4.30930369e-02f, 2.31290415e-01f, 1.76660106e-01f, -3.90578471e-02f,
  -2.35568229e-02f, 1.35534957e-01f, -2.67795548e-02f, -4.52752002e-02f, -1.80228148e-02f, -1.59018397e-01f, -1.44678485e-02f, -3.23076904e-01f, 9.43280384e-02f, -1.22620068e-01f,
  2.13018730e-02f, -5.02165034e-02f, -5.12790680e-02f, -2.96024028e-02f, 1.63051188e-01f, 6.83370531e-02f, -3.95635422e-03f, 1.20300606e-01f, -3.15900892e-02f, -1.22107558e-01f,
  -8.06756020e-02f, 1.31305382e-01f, -3.14855576e-02f, -7.94532746e-02f, 1.79444477e-02f, -1.93389460e-01f, 6.63421303e-02f, -1.58118650e-01f, 3.50503087e-01f, 3.46150547e-02f,
  3.05093117e-02f, 2.91080445e-01f, 2.80707270e-01f, 2.86750853e-01f, 4.91767861e-02f, -1.14630926e-02f, 1.95574030e-01f, 1.56903028e-01f, 1.18807681e-01f, -5.35732508e-02f,
  2.71615803e-01f, 3.32841165e-02f, -2.70873964e-01f, 8.81152898e-02f, 1.57191828e-01f, 1.93328056e-02f, 2.64609635e-01f, 1.63369596e-01f, 2.02879220e-01f, -6.34433553e-02f,
  -7.71988630e-02f, 1.79475084e-01f, 1.85689211e-01f, 1.13266103e-01f, 1.10588536e-01f, -1.95386354e-02f, 2.33248979e-01f, -1.44063801e-01f, -1.11246377e-01f, 1.30673379e-01f,
  -2.37613410e-01f, -1.21113531e-01f, 2.63665080e-01f, 2.23180100e-01f, -9.30832028e-02f, 6.48729922e-03f, 8.40932131e-02f, -2.65634898e-02f, 1.39322162e-01f, 1.03516981e-01f,
  -1.16952710e-01f, 1.87555909e-01f, -3.13184597e-02f, -1.69887282e-02f, 3.62668815e-03f, -3.15553956e-02f, 1.26383945e-01f, 1.10296324e-01f, 1.42799050e-01f, 9.20887142e-02f,
  -3.77151445e-02f, 1.19600199e-01f, -1.28985837e-01f, 2.02770792e-02f, 9.70470458e-02f, 1.47713408e-01f, -2.99929474e-02f, -5.45743667e-02f, -3.98163013e-02f, 2.18140304e-01f,
  -1.06585935e-01f, -1.83577299e-01f, -6.84438169e-01f, 1.63259134e-01f, 8.20767134e-02f, 8.27981830e-02f, -7.17699602e-02f, 7.77003318e-02f, 1.06917329e-01f, 7.74191767e-02f,
  4.75091673e-02f, 3.08203757e-01f, 2.27385730e-01f, -2.62901008e-01f, -3.49704474e-02f, -5.87761812e-02f, 3.55962336e-01f, -6.61679870e-03f, -1.07706413e-01f, -7.10971355e-02f,
  -6.18575187e-03f, -4.55998816e-02f, -1.06959948e-02f, -3.09763681e-02f, 1.62056267e-01f, -4.04837988e-02f, -4.25575465e-01f, 1.40131474e-01f, 2.50324637e-01f, -3.38454217e-01f,
  8.78682211e-02f, 5.62674999e-02f, 1.44153416e-01f, 1.69969708e-01f, 2.50114143e-01f, -1.61194384e-01f, -5.56558743e-02f, 8.77195820e-02f, 2.01456949e-01f, 8.24122969e-03f,
  1.30027726e-01f, 8.23124796e-02f, 1.09373108e-01f, -1.42193869e-01f, -2.36751214e-02f, 5.58024161e-02f, 1.26905292e-01f, 5.17895035e-02f, -6.35108948e-02f, -1.25831217e-01f,
  -3.49602476e-02f, -2.14327127e-01f, 1.14189312e-01f, -1.28048569e-01f, -7.77465701e-02f, -4.13232557e-02f, -2.58837223e-01f, -7.33408630e-02f, -9.99019854e-03f, 1.03923626e-01f,
  1.17555954e-01f, -2.10747778e-01f, 1.40269056e-01f, -2.51968671e-02f, 9.81837213e-02f, -4.40425813e-01f, 3.84021848e-02f, -4.30256836e-02f, 6.02444038e-02f, 2.96079189e-01f,
  -1.18334241e-01f, 3.14134330e-01f, 5.46679944e-02f, -6.44917339e-02f, 2.38349773e-02f, 1.20496236e-01f, -2.38762069e-02f, -2.14255422e-01f, 6.47047013e-02f, -1.19753614e-01f,
  1.91360377e-02f, 3.98597345e-02f, 1.45008534e-01f, -2.37841308e-01f, 1.02396056e-01f, 8.79063457e-02f, -2.62453575e-02f, -1.66743860e-01f, -2.17467397e-02f, 1.17807843e-01f,
  6.13706931e-02f, 1.87621057e-01f, 9.86271277e-02f, -2.55126297e-01f, 3.50606851e-02f, -7.72267282e-02f, 4.23953943e-02f, 4.33182977e-02f, -1.39512628e-01f, -6.16627969e-02f,
  -6.70471862e-02f, 1.09573908e-01f, 1.04751989e-01f, 1.09167822e-01f, -8.19815025e-02f, 1.10032126e-01f, 3.66475545e-02f, -2.58337438e-01f, -1.86825618e-01f, -6.99348003e-03f,
  8.27489123e-02f, 4.73507568e-02f, -1.09305680e-02f, -4.88252155e-02f, 1.15692951e-01f, 2.75688767e-02f, -1.32902056e-01f, 4.03831266e-02f, -5.83822979e-03f, 1.04505904e-01f,
  1.54363245e-01f, 3.69952433e-02f, 3.30572091e-02f, -9.51905325e-02f, -4.30665433e-01f, 3.37738782e-01f, -5.59169687e-02f, 1.43869504e-01f, -5.64169101e-02f, 2.82361865e-01f,
  3.29443932e-01f, -5.47174783e-03f, 1.69198170e-01f, -2.17144296e-01f, 4.80385646e-02f, -2.62656987e-01f, 3.12131196e-01f, 1.51052222e-01f, 1.87809885e-01f, -2.11504221e-01f,
  1.29291102e-01f, 9.90537107e-02f, -8.72336030e-02f, 1.40693963e-01f, 1.14559270e-01f, 5.59270903e-02f, 1.70599639e-01f, 1.97596252e-01f, -1.55733466e-01f, 1.63102180e-01f,
  5.44819385e-02f, -9.16114673e-02f, -4.74115051e-02f, -1.10515952e-01f, -4.13557701e-02f, -3.01230758e-01f, -9.44165960e-02f, -1.76245779e-01f, -9.27704945e-02f, -4.55052078e-01f,
  1.28934667e-01f, 2.07405332e-02f, -5.08097932e-02f, 1.02654733e-01f, 5.62506504e-02f, 1.76969320e-01f, -2.37996578e-01f, -2.07103733e-02f, -4.03036401e-02f, 1.50338173e-01f,
  2.71185506e-02f, 3.36425692e-01f, -2.25935727e-01f, -6.95962831e-02f, 1.12798974e-01f, -2.41849676e-01f, -1.98720008e-01f, -3.85157615e-02f, 1.18417941e-01f, -1.09027252e-01f,
  2.12378018e-02f, -1.68819621e-01f, -5.15219234e-02f, -1.94977194e-01f, -1.73564956e-01f, 4.46709730e-02f, 3.65496054e-02f, 1.24871098e-01f, -1.48168966e-01f, 5.45328371e-02f,
  1.71926364e-01f, -9.16790813e-02f, 1.84847176e-01f, -2.48869583e-01f, -2.61316244e-02f, -1.14195250e-01f, 1.06619887e-01f, 4.58576381e-01f, -2.22417414e-01f, 4.29105014e-01f,
  2.13544071e-01f, 1.79245800e-01f, 1.84492946e-01f, 1.80574015e-01f, 2.16515034e-01f, 2.15468672e-03f, 1.32476851e-01f, -1.14261672e-01f, -4.48896438e-02f, -8.42477530e-02f,
  -3.46162289e-01f, -4.04884905e-01f, 1.74500063e-01f, -1.35595798e-01f, -2.38970399e-01f, -1.71749204e-01f, -6.01463653e-02f, 4.08591963e-02f, 1.37504563e-01f, 1.86133951e-01f,
  1.78772777e-01f, 1.85000494e-01f, -1.44895613e-01f, -2.55136460e-01f, 1.47246063e-01f, -6.65505379e-02f, 1.48848981e-01f, 7.69987851e-02f, 5.32517843e-02f, 3.73211652e-02f,
  6.12689294e-02f, 1.79642096e-01f, -2.59207159e-01f, -1.98509917e-02f, -2.28477508e-01f, -1.63292333e-01f, -2.26351202e-01f, -1.22644238e-01f, 1.60682783e-01f, -2.61331741e-02f,
  6.21395037e-02f, 7.24432617e-02f, 1.71338111e-01f, 7.45650381e-02f, 3.29819411e-01f, 1.34761631e-01f, 1.85769841e-01f, 8.42363164e-02f, 2.64830627e-02f, -4.94229496e-02f,
  4.67131808e-02f, 1.62706152e-01f, 1.26252770e-01f, -1.73983246e-01f, 1.10361040e-01f, -8.85006040e-02f, -2.55161703e-01f, -9.46726799e-02f, -2.93490123e-02f, -8.05294737e-02f,
  -1.29429951e-01f, 2.92524070e-01f, -2.05379412e-01f, -2.67676502e-01f, -9.30256844e-02f, -2.72187088e-02f, 6.79273382e-02f, 1.39472201e-01f, 1.62595287e-02f, -1.29935712e-01f,
  2.22687379e-01f, -1.90566063e-01f, -1.45615444e-01f, -5.63299954e-02f, 7.58022591e-02f, 1.76793158e-01f, 2.53779799e-01f, -1.28604352e-01f, -8.13382417e-02f, -3.29220407e-02f,
  1.61539555e-01f, -1.43314227e-01f, -1.91351265e-01f, 1.10915557e-01f, 2.10921377e-01f, -1.23229600e-01f, 2.81506479e-02f, 1.99899152e-01f, 3.66796218e-02f, 5.57040758e-02f,
  1.56164855e-01f, 1.70713350e-01f, 9.45089757e-02f, 1.76634174e-02f, 2.59831250e-01f, 1.11024089e-01f, -7.23234145e-03f, -9.27872062e-02f, 4.69845422e-02f, -1.39827713e-01f,
  2.39746705e-01f, -2.08658487e-01f, 1.50293767e-01f, -1.72329754e-01f, -5.36323488e-02f, -1.72914881e-02f, 2.20393091e-02f, 1.42246857e-02f, -1.14087656e-01f, 2.07220674e-01f,
  2.16332264e-02f, -8.21066499e-02f, 1.69733599e-01f, 3.43733467e-02f, 2.23372847e-01f, -1.17810033e-01f, -1.63373083e-01f, 1.51663786e-02f, -6.61247000e-02f, 1.63783923e-01f,
  -9.50016007e-02f, 1.88041702e-01f, -3.33267391e-01f, 7.94143379e-02f, 1.06867380e-01f, -1.41546419e-02f, -1.43783409e-02f, -2.17633724e-01f, 9.96258482e-02f, 7.04277828e-02f,
  6.16287477e-02f, -1.89631209e-01f, -1.14455074e-01f, 1.24624930e-01f, -8.19673762e-02f, -6.05335943e-02f, 5.91408573e-02f, -2.51576602e-01f, -1.85164303e-01f, 1.44708320e-01f,
  7.88576230e-02f, 2.57663112e-02f, 4.96401861e-02f, 1.44066036e-01f, 1.91772223e-01f, 9.26597510e-03f, -1.23696744e-01f, -2.13374600e-01f, 7.64015689e-02f, 2.47021280e-02f,
  -6.54253885e-02f, -2.05339231e-02f, 2.96955377e-01f, -2.33547054e-02f, 1.41695693e-01f, 2.40681618e-01f, 2.28606798e-02f, 6.07027262e-02f, -1.66079119e-01f, -1.99093092e-02f,
  -1.00490436e-01f, -7.61382180e-05f, -1.55119300e-01f, 5.66815101e-02f, -1.04744183e-02f, 2.35423055e-02f, 2.77382821e-01f, 1.00606168e-02f, -7.04363808e-02f, -1.79778963e-01f,
  -1.00430343e-02f, -8.15179944e-02f, -3.59349810e-02f, -1.22360103e-01f, 3.10939878e-01f, 9.33057293e-02f, -3.24820429e-02f, -3.04358244e-01f, 3.20329666e-02f, 6.52349517e-02f,
  -2.55010009e-01f, -1.14182308e-01f, 2.17853606e-01f, -4.06584404e-02f, -6.23581260e-02f, -1.96082503e-01f, -1.71942025e-01f, 1.54434964e-01f, 5.64117432e-02f, 4.47590023e-01f,
  1.02595314e-01f, -1.44936526e-02f, 4.53006744e-01f, 1.79544896e-01f, -7.88909569e-02f, 2.39129979e-04f, 1.90622091e-01f, 5.69319837e-02f, -1.40169919e-01f, 1.09482728e-01f,
  -4.93986085e-02f, 9.60407592e-03f, 3.29727829e-02f, -1.58185527e-01f, -1.09490938e-02f, 6.66405037e-02f, 6.98734745e-02f, -1.19632520e-01f, -8.50834474e-02f, -1.12343803e-01f,
  -9.96600166e-02f, 2.06775695e-01f, -6.82064891e-03f, 2.84048989e-02f, 1.51428908e-01f, -2.56472081e-01f, 5.85729815e-02f, 8.91733542e-02f, 1.57682002e-01f, -9.88642275e-02f,
  1.85455263e-01f, 3.11970394e-02f, 1.51360288e-01f, 1.41065061e-01f, -9.57771987e-02f, 2.79970646e-01f, 9.19263363e-02f, 3.20740975e-02f, -1.12326376e-01f, -1.14601972e-02f,
  1.49558678e-01f, -5.77526446e-03f, -1.42345905e-01f, 2.54720002e-01f, 7.80993775e-02f, 1.16714428e-03f, -5.89575656e-02f, 4.28191349e-02f, 1.57900512e-01f, -8.74262769e-03f,
  2.18225531e-02f, -1.06397666e-01f, 5.84205016e-02f, -6.14607558e-02f, -1.02295257e-01f, 1.14616655e-01f, 1.50968924e-01f, 1.06564514e-01f, -1.35112271e-01f, -1.07131653e-01f,
  -1.14741400e-01f, 1.14095673e-01f, 1.35843486e-01f, 1.25727907e-01f, -2.26653993e-01f, 2.00920239e-01f, 5.79158030e-02f, 1.86888427e-01f, 4.52509932e-02f, 2.94808261e-02f,
  4.24811393e-02f, 1.14809975e-01f, -3.83300595e-02f, -7.05609992e-02f, 3.07226982e-02f, -2.87227370e-02f, -2.49991521e-01f, -1.16467826e-01f, 5.58235087e-02f, 6.96025267e-02f,
  -2.37489436e-02f, -1.13082439e-01f, 1.69093743e-01f, 1.03850804e-01f, -2.32094247e-02f, 9.43760127e-02f, 2.39597023e-01f, 1.49207357e-02f, -1.07838407e-01f, -8.00229833e-02f,
  2.69193649e-01f, 8.96559209e-02f, 2.30347380e-01f, 1.60386816e-01f, -3.02031469e-02f, -5.47360815e-02f, 6.34783367e-03f, 2.65071839e-01f, -1.96680889e-01f, -5.77987805e-02f,
  -1.40189409e-01f, -2.21048966e-02f, -7.45751187e-02f, -4.88216355e-02f, 2.69754440e-01f, -6.10798113e-02f, 2.60562487e-02f, 9.30513367e-02f, -3.06257326e-02f, -2.45159358e-01f,
  -1.37664735e-01f, -1.66595981e-01f, -1.21717274e-01f, -2.21820280e-01f, -2.88099080e-01f, 1.79009557e-01f, -8.24821144e-02f, 5.32054342e-02f, -6.07445948e-02f, -1.78091690e-01f,
  -9.11514387e-02f, 2.36135758e-02f, -4.17342111e-02f, -1.33566946e-01f, 2.15681158e-02f, 2.89183766e-01f, 8.63914862e-02f, 2.05869228e-01f, -3.20265144e-01f, 7.10621178e-02f,
  -1.85735852e-01f, 3.84900905e-02f, 1.35374948e-01f, -2.33228326e-01f, -1.84057981e-01f, 1.84542924e-01f, 3.06363523e-01f, -1.88251883e-01f, 1.23601612e-02f, -1.64206009e-02f,
  3.74466442e-02f, -1.88170850e-01f, 2.14995787e-01f, 4.82485816e-02f, 1.33709133e-01f, 2.34634653e-02f, 8.79268534e-03f, 9.69095603e-02f, -5.46135604e-02f, -4.69346084e-02f,
  1.75581798e-01f, 5.93731180e-02f, 3.85640264e-02f, -8.07966366e-02f, -7.26671005e-03f, -1.42340034e-01f, 1.49834484e-01f, 1.92780897e-01f, 8.10737461e-02f, -5.26594408e-02f,
  -1.07203305e-01f, 2.14818060e-01f, 1.95584476e-01f, -3.47320527e-01f, -2.16336504e-01f, -1.73739970e-01f, 1.28805146e-01f, 5.82630634e-02f, 1.11882038e-01f, 8.29987824e-02f,
  8.30657557e-02f, -3.43833677e-02f, 3.82779315e-02f, 3.04059386e-01f, 1.33437440e-01f, 8.14344883e-02f, -1.56333551e-01f, 8.50475430e-02f, 7.40996655e-03f, -5.19723678e-03f,
  -9.46496129e-02f, -6.72503039e-02f, 1.42603055e-01f, -2.16445103e-01f, 1.66469827e-01f, -1.21467756e-02f, 7.26708919e-02f, 5.34645543e-02f, -1.15266852e-01f, -4.82060939e-01f,
  -3.29472989e-01f, 2.90711492e-01f, 3.06376487e-01f, -2.10884400e-02f, -1.84269294e-01f, 5.86357750e-02f, 2.98173539e-03f, 1.43699452e-01f, -7.96563327e-02f, -2.96683311e-01f,
  5.95337972e-02f, 8.34196508e-02f, -1.84597939e-01f, -2.12665200e-01f, 1.58491075e-01f, 2.41933286e-01f, -1.78465784e-01f, -4.39590588e-02f, 5.94521239e-02f, 1.91663742e-01f,
  8.93259328e-03f, 1.15036555e-01f, -7.26751909e-02f, -1.13493457e-01f, -7.57492632e-02f, -4.99337427e-02f, 1.14855044e-01f, 1.63000166e-01f, -8.68195593e-02f, 1.66382447e-01f,
  -6.28615618e-02f, 8.08556974e-02f, 6.97691143e-02f, 6.12274110e-02f, 6.77615255e-02f, -1.26719195e-02f, 1.09156556e-02f, 8.72943848e-02f, 2.51734674e-01f, -4.60078642e-02f,
  1.99762881e-01f, -2.02166796e-01f, 3.37554030e-02f, -9.03180167e-02f, 7.15636238e-02f, 2.86053658e-01f, -3.54322530e-02f, 2.35885352e-01f, 8.19988141e-04f, -5.81799001e-02f,
  5.50922990e-01f, 2.18710035e-01f, 2.67289251e-01f, -1.92552414e-02f, 8.17821994e-02f, 2.49333936e-03f, -6.25394657e-02f, -2.15460315e-01f, 2.40077630e-01f, -8.09194520e-02f,
  -6.58525601e-02f, 1.97877422e-01f, -1.86298281e-01f, -1.95910744e-02f, 7.18407216e-04f, -6.07182086e-02f, 6.71359757e-03f, 2.83168733e-01f, 7.92909821e-04f, 4.52813655e-02f,
  -6.47742227e-02f, 1.19236007e-01f, -1.47167623e-01f, -2.69087136e-01f, 1.53970253e-02f, -1.81819603e-01f, -1.55029297e-01f, -1.05733559e-01f, -7.93418149e-05f, 1.16295360e-01f,
  -9.49813500e-02f, -1.30899981e-01f, -5.62088862e-02f, 1.11625746e-01f, 2.15969775e-02f, -8.18284377e-02f, -6.12392612e-02f, -8.90511796e-02f, -9.66126621e-02f, 1.08838588e-01f,
  -1.08648390e-01f, 1.93174735e-01f, -7.02556670e-02f, 1.10572010e-01f, -1.78644165e-01f, 1.51331797e-01f, 7.94394761e-02f, 6.69691786e-02f, -1.49353659e-02f, 1.54897064e-01f,
  -5.81041127e-02f, 2.36550808e-01f, -1.21269718e-01f, -8.25126246e-02f, 8.65048766e-02f, -1.23910435e-01f, 2.13368200e-02f, -3.49427722e-02f, 1.25784069e-01f, 7.52630038e-03f,
  6.50595278e-02f, 3.46692689e-02f, -3.53016928e-02f, 6.18981197e-02f, 1.58589631e-02f, 9.25072953e-02f, 1.93028241e-01f, 4.11150269e-02f, 2.48341635e-01f, 4.84606363e-02f,
  -4.21225615e-02f, 3.14463288e-01f, -1.83433965e-01f, 2.09046975e-01f, -7.51277879e-02f, 6.33935854e-02f, -3.41243774e-01f, 8.96220207e-02f, -4.95189428e-02f, -3.38997930e-01f,
  -2.84864545e-01f, -5.07579684e-01f, -3.28012183e-02f, -2.67043859e-02f, 6.09486960e-02f, -6.84201345e-02f, -3.42075527e-02f, 7.00582936e-02f, 1.47259474e-01f, -7.05323182e-03f,
  5.00866354e-01f, 1.66985527e-01f, 9.10892617e-03f, 2.29086317e-02f, -1.03007853e-01f, 2.09106192e-01f, -1.60132661e-01f, 1.37955934e-01f, -9.10469219e-02f, -8.52228776e-02f,
  -2.13503197e-01f, -1.25264257e-01f, 1.38993278e-01f, -1.40881553e-01f, -3.88648473e-02f, -1.52706951e-01f, 1.01039708e-01f, 2.08876394e-02f, 3.48905414e-01f, -1.75724790e-01f,
  -2.60222405e-01f, 6.38038367e-02f, 1.85066193e-01f, -1.04560249e-01f, 1.79177761e-01f, -2.36156970e-01f, 8.48606899e-02f, 2.43951991e-01f, -1.01439632e-01f, 7.32594132e-02f,
  -2.87395809e-02f, -6.49071578e-03f, 1.50874794e-01f, -7.19257146e-02f, 1.00319222e-01f, 1.33342221e-02f, 1.45214587e-01f, 2.62887608e-02f, 2.17458420e-02f, 2.79419757e-02f,
  -1.04305498e-01f, 5.12778759e-03f, 1.04613781e-01f, 6.85933232e-02f, -2.89958399e-02f, -1.34578496e-01f, 3.25330377e-01f, 8.66709724e-02f, 5.11684157e-02f, -2.99266040e-01f,
  -2.29263529e-01f, -8.28533545e-02f, 1.01760469e-01f, 4.11380917e-01f, -2.46426940e-01f, 3.99710715e-01f, 1.95393592e-01f, -4.93927076e-02f, -9.74939317e-02f, 2.52579302e-01f,
  1.73511460e-01f, -4.94506627e-01f, 6.32869825e-02f, 4.78344932e-02f, -1.04787834e-01f, 8.27382356e-02f, 9.43414271e-02f, -1.83900997e-01f, 8.81830230e-03f, -6.53545186e-02f,
  -1.04346909e-01f, -2.67452747e-01f, 4.42789588e-03f, 1.14436828e-01f, -1.32943407e-01f, 2.31664494e-01f, 2.09683463e-01f, -3.14778090e-01f, 1.52082145e-02f, 6.90472573e-02f,
  1.47449300e-01f, 1.47904977e-01f, -6.52528601e-03f, 2.24308074e-02f, -1.92969695e-01f, -1.14912437e-02f, 1.06805436e-01f, 1.24039009e-01f, -1.31614879e-01f, 1.86922982e-01f,
  -7.99473971e-02f, -2.09479555e-01f, -7.95947015e-02f, 3.97308171e-02f, 8.18106011e-02f, -2.99268588e-02f, -1.24358214e-01f, -5.84136657e-02f, -4.97383773e-02f, 1.47695199e-01f,
  -7.42789805e-02f, 8.17893371e-02f, 1.99101195e-01f, -2.44064312e-02f, 1.26157954e-01f, 2.31980588e-02f, 1.05950937e-01f, 7.86268637e-02f, -3.78037244e-01f, 3.66178527e-02f,
  -4.99542765e-02f, 1.00583352e-01f, -1.10684847e-02f, 2.59752572e-01f, 1.02941483e-01f, 1.07553452e-01f, 1.85658544e-01f, -1.18223034e-01f, 4.95677702e-02f, -2.72770710e-02f,
  2.66256690e-01f, 7.55496603e-03f, 4.26884927e-02f, -2.14668468e-01f, -2.92138401e-02f, 1.21586666e-01f, 2.07179077e-02f, 1.18976630e-01f, -2.90646926e-02f, -2.25655332e-01f,
  9.62416753e-02f, -4.15618680e-02f, 2.44039129e-02f, 9.39023346e-02f, 1.39080748e-01f, -2.12371990e-01f, 1.69048682e-01f, -1.27880394e-01f, -2.03949288e-01f, -3.69041637e-02f,
  -7.63833001e-02f, -4.41094004e-02f, -1.94071550e-02f, -2.62432814e-01f, 2.51497447e-01f, -8.48480687e-02f, 1.28845617e-01f, 2.85714000e-01f, 4.86111939e-02f, 1.35684252e-01f,
  -2.88361132e-01f, 4.31009680e-02f, -8.53249431e-02f, 1.13005303e-01f, 7.87421688e-02f, 2.11991474e-01f, -2.81630754e-01f, -1.04548633e-01f, 2.06045285e-01f, -7.38869384e-02f,
  7.02668205e-02f, 4.75872168e-03f, 2.00535685e-01f, 1.93772480e-01f, -2.17490271e-02f, 2.25676820e-01f, -1.87681422e-01f, 2.85752833e-01f, -4.92898608e-03f, 2.27188617e-01f,
  1.36350691e-02f, 3.84849831e-02f, -2.72561144e-02f, 3.21909249e-01f, 8.62820074e-02f, -2.29449555e-01f, -4.65599597e-01f, 1.74089298e-01f, 2.80552506e-01f, 7.98814222e-02f,
  -8.41602609e-02f, 3.98726389e-02f, -4.29392368e-01f, -4.17114347e-01f, 3.01177859e-01f, 1.73712939e-01f, 9.93708242e-03f, 1.87044382e-01f, 2.26747692e-01f, 7.41245672e-02f,
  -1.66126430e-01f, -3.72813232e-02f, -1.44698218e-01f, 3.47775966e-01f, 1.33828357e-01f, 1.35285586e-01f, 2.12720558e-02f, 1.83640346e-01f, 1.84040412e-03f, -1.26681373e-01f,
  -9.14945155e-02f, -2.97253698e-01f, 3.31140995e-01f, 7.96782821e-02f, -4.78714071e-02f, 1.73631459e-01f, -1.54182732e-01f, -7.35162050e-02f, -4.16345410e-02f, 2.90331859e-02f,
  -2.02190261e-02f, -5.36146760e-02f, -2.44026378e-01f, -7.86859635e-03f, 3.01606268e-01f, -7.43253753e-02f, -7.41102472e-02f, 6.50358573e-02f, 1.38665125e-01f, 1.04611196e-01f,
  5.91960130e-03f, -3.21095049e-01f, -1.62566211e-02f, -3.14227253e-01f, 2.71738678e-01f, -4.27207127e-02f, 6.01820499e-02f, 1.22466728e-01f, 5.82579821e-02f, 2.44623683e-02f,
  1.05201870e-01f, 3.30206931e-01f, -4.62564453e-03f, 1.67768806e-01f, 7.79843852e-02f, -5.16343340e-02f, -1.04524508e-01f, 2.59680539e-01f, 2.35807925e-01f, 1.49142638e-01f,
  -3.37388128e-01f, -2.24954128e-01f, 3.36860687e-01f, 3.87121648e-01f, -1.43950665e-02f, 4.39556502e-02f, -2.44738221e-01f, -3.31508338e-01f, -5.16031422e-02f, 8.05115048e-03f,
  -1.62857026e-01f, -2.80561205e-02f, -7.52656832e-02f, 7.55763277e-02f, 1.13663673e-01f, -1.14118263e-01f, 3.05825584e-02f, 3.72297317e-01f, -1.07503876e-01f, 1.98943570e-01f,
  2.33769760e-01f, 2.76388884e-01f, 1.92644104e-01f, -2.86288513e-03f, -1.08532002e-02f, 2.96463948e-02f, 7.11548626e-02f, 2.32623909e-02f, 1.31011084e-01f, -8.98834020e-02f,
  1.19509026e-01f, -1.42834038e-01f, -4.15770374e-02f, -7.53104612e-02f, -2.25387886e-01f, -9.74889100e-02f, -8.56966898e-02f, -9.57246274e-02f, 3.22968721e-01f, -1.25744656e-01f,
  5.02968654e-02f, -1.27651989e-01f, 3.72433662e-02f, 6.29439251e-03f, 2.45880544e-01f, -1.10805131e-01f, -6.71333671e-02f, 1.03391878e-01f, 2.17202634e-01f, 6.82153553e-02f,
  1.12267658e-02f, 2.05839977e-01f, -1.34601444e-01f, 1.77270666e-01f, 3.61204296e-01f, 2.40246296e-01f, 6.50814474e-02f, 3.45505401e-02f, 2.27069974e-01f, 6.83700293e-02f,
  1.01900615e-01f, 2.39389777e-01f, 1.79364815e-01f, 2.72541910e-01f, -4.32337016e-01f, 1.87819779e-01f, -9.22727138e-02f, 3.18681419e-01f, -1.00385696e-01f, -1.31784767e-01f,
  -3.89910191e-01f, -4.96215016e-01f, -1.26918077e-01f, -6.04021084e-03f, 4.62381722e-04f, -1.30896285e-01f, -1.62820533e-01f, 1.28767133e-01f, -1.91120520e-01f, -2.35062584e-01f,
  2.47806847e-01f, 1.07947707e-01f, -6.58584535e-02f, 1.28412634e-01f, -8.84750560e-02f, 2.67582268e-01f, 1.43082201e-01f, 2.55807266e-02f, 5.16769476e-02f, -2.49177441e-01f,
  1.32763222e-01f, 5.16499914e-02f, 3.05266865e-02f, -4.17871540e-03f, -8.23196676e-03f, -1.81655716e-02f, 1.56914964e-01f, -3.81239913e-02f, 3.55190523e-02f, 6.64006770e-02f,
  3.44089940e-02f, 1.51474491e-01f, 2.99256891e-01f, -1.74914673e-01f, 1.54488876e-01f, 8.83932784e-02f, 1.11528195e-01f, 4.09317128e-02f, 2.20962554e-01f, -3.07574242e-01f,
  2.54926354e-01f, -2.57389724e-01f, 2.09919494e-02f, 2.42771700e-01f, -1.16489865e-01f, 2.33385991e-02f, 1.02152571e-01f, 7.92127773e-02f, 2.45396465e-01f, 2.44348217e-02f,
  8.55932385e-02f, -1.17100114e-02f, -5.34044355e-02f, -5.18659949e-02f, 1.46249399e-01f, -2.83348352e-01f, 6.88232854e-02f, -1.49884924e-01f, -1.62594467e-02f, -1.74836665e-02f,
  -1.18158363e-01f, -1.18205130e-01f, -2.68902212e-01f, -4.65557158e-01f, 5.90576716e-02f, 4.02364969e-01f, -4.03992921e-01f, -1.84798881e-01f, -1.62790641e-01f, 7.82892015e-03f,
  -1.63953498e-01f, -3.13425786e-03f, -3.80769884e-03f, -2.82093734e-01f, -1.79896563e-01f, -1.74260795e-01f, 9.61958468e-02f, -2.16598958e-01f, -2.81813204e-01f, 5.04277200e-02f,
  -4.80870251e-03f, -4.35821377e-02f, -4.24219549e-01f, 8.88729542e-02f, 3.16836596e-01f, -3.51206154e-01f, -6.19952559e-01f, 2.70610780e-01f, -2.26722080e-02f, 1.73896208e-01f,
  -2.06783831e-01f, -3.16005856e-01f, -3.42047513e-01f, -3.62204492e-01f, -1.05726399e-01f, -3.05336341e-02f, -6.43660128e-03f, 1.66237950e-01f, 2.19319984e-01f, 3.12241256e-01f,
  -1.68875054e-01f, -1.16286814e-01f, 1.56384528e-01f, 7.01363757e-02f, 4.31897715e-02f, 8.43815580e-02f, 2.37718850e-01f, -1.42805442e-01f, -7.35828280e-03f, 1.98044479e-01f,
  -5.14339004e-03f, 5.54310866e-02f, -8.34643394e-02f, 1.32491857e-01f, -9.46988091e-02f, -1.61866501e-01f, -3.11911907e-02f, -1.46266231e-02f, 1.36311650e-02f, -1.44864127e-01f,
  -3.48246813e-01f, 1.06323101e-01f, -1.52415717e-02f, 6.19557463e-02f, -5.08421719e-01f, -5.81258442e-03f, 2.59797722e-02f, 3.08372617e-01f, 1.52938440e-01f, -4.69381273e-01f,
  3.96726318e-02f, -6.73157275e-02f, 1.13111481e-01f, -2.43889794e-01f, -1.34435385e-01f, 5.91321513e-02f, 6.24065585e-02f, -1.69654608e-01f, 3.51575404e-01f, -6.65161088e-02f,
  2.66890693e-02f, 2.72941679e-01f, -9.08170044e-02f, 1.21540055e-01f, 1.48842335e-01f, -2.96881907e-02f, 1.23113751e-01f, -1.85193822e-01f, -2.59898573e-01f, 5.67693971e-02f,
  -3.24801393e-02f, -6.61565214e-02f, 4.01075304e-01f, -2.98135281e-01f, 2.58697599e-01f, 1.89547673e-01f, -1.29370661e-02f, -7.78329223e-02f, 2.03913629e-01f, -8.57398361e-02f,
  -1.53713068e-02f, -1.60411149e-01f, 9.74646062e-02f, 2.87424289e-02f, 2.19531372e-01f, 6.72873408e-02f, 1.02000669e-01f, -3.31864119e-01f, 1.67665169e-01f, -3.08490485e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  2.84229126e-02f, -3.53675373e-02f, 8.93817395e-02f, 1.00566119e-01f, 1.57589182e-01f, -6.90671802e-02f, -1.07101664e-01f, 5.53660542e-02f, 2.23506354e-02f, 8.54949281e-02f,
  8.63971263e-02f, -2.27173418e-02f, 1.26663670e-01f, 1.51870981e-01f, 2.03397661e-01f, 1.31379351e-01f, -2.26378515e-02f, 1.45652622e-01f, -2.38481499e-02f, 7.08326027e-02f,
  -1.21637881e-02f, 1.63111389e-01f, -1.82925224e-01f, 1.94135651e-01f, -1.47493422e-01f, 2.45531499e-01f, -1.74457923e-01f, -3.19929444e-03f, -6.10300079e-02f, -1.93866089e-01f,
  5.37864380e-02f, -5.74458763e-02f, 1.37720987e-01f, 1.67555496e-01f, -8.92298147e-02f, 1.12490028e-01f, -1.17643056e-02f, 1.26420110e-01f, -7.64896721e-02f, 8.52403343e-02f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -6.18865043e-02f, -1.22016231e-02f, 6.69521168e-02f, -1.79801062e-01f, -9.06052650e-04f, 3.37186396e-01f, 2.92350411e-01f, -2.14104295e-01f, 1.67403728e-01f, -2.02113137e-01f,
  -1.24545932e-01f, -1.69327557e-01f, 1.07119396e-01f, -2.77485222e-01f, 1.75542071e-01f, 7.99590871e-02f, 1.52421877e-01f, -2.13430122e-01f, -8.90653953e-02f, -3.94733027e-02f,
  1.14615329e-01f, 1.15477242e-01f, -3.65135446e-02f, 9.19387788e-02f, -3.79824750e-02f, 1.78004518e-01f, -1.28295079e-01f, 1.15691818e-01f, 1.26473084e-01f, 8.22040886e-02f,
  3.69282179e-02f, 3.38741317e-02f, -2.72190031e-02f, -2.14783877e-01f, -8.56671482e-02f, 6.33478388e-02f, -1.47614971e-01f, -2.04115316e-01f, -1.90132573e-01f, 2.72430270e-03f,
  -6.36462048e-02f, 1.50029659e-01f, -1.77395552e-01f, 8.20218027e-02f, -6.50171936e-02f, 1.09381257e-02f, 1.38148859e-01f, -2.37244777e-02f, 4.03355658e-02f, -3.53433006e-02f,
  -2.86243893e-02f, 3.29835452e-02f, 7.00370669e-02f, 3.12871188e-02f, -7.76463673e-02f, 2.81226672e-02f, -6.85914978e-02f, 1.54100671e-01f, 1.21717125e-01f, -1.06705800e-01f,
  -7.85941035e-02f, 1.79520011e-01f, 1.59273520e-01f, 1.21481838e-02f, -2.21585020e-01f, -1.48811474e-01f, 1.62615955e-01f, -2.16576904e-01f, 3.40252556e-02f, 1.28759757e-01f,
  -5.39959967e-02f, -9.16259810e-02f, -1.31034419e-01f, 1.45150926e-02f, -3.54765262e-03f, 2.48256885e-02f, -4.99197701e-03f, -8.69243294e-02f, -1.14430428e-01f, 2.99270228e-02f,
  1.96266264e-01f, 2.24660724e-01f, 2.57925056e-02f, 1.52009055e-01f, -1.85434092e-02f, 1.36578113e-01f, -3.39170396e-02f, 1.76897973e-01f, -2.42996626e-02f, -5.50721511e-02f,
  -7.04996884e-02f, 1.57842990e-02f, -1.43997535e-01f, 1.54252157e-01f, -5.14765382e-02f, 1.33055091e-01f, -1.30629286e-01f, 5.91622293e-02f, 1.93343870e-02f, -2.80351248e-02f,
  2.02377617e-01f, -7.31004104e-02f, -5.60473911e-02f, -1.03957031e-03f, 1.20576411e-01f, -8.52301493e-02f, -8.54852721e-02f, 1.11580854e-02f, 1.30633578e-01f, -5.10009974e-02f,
  1.30310535e-01f, -1.57373086e-01f, 9.03972685e-02f, 6.98194886e-03f, 2.73292847e-02f, -6.42527454e-03f, -5.36509827e-02f, 2.04241499e-01f, -2.10995585e-01f, -2.84278691e-02f,
  6.44193888e-02f, 4.24696729e-02f, -4.26445603e-02f, -1.12001158e-01f, 1.22312531e-01f, -2.29840912e-02f, 8.01477954e-03f, -1.22977525e-01f, -7.15036616e-02f, 1.57612637e-01f,
  1.68131366e-01f, 1.16534948e-01f, 1.31708696e-01f, 1.51776135e-01f, -1.62263662e-01f, -2.57768512e-01f, -1.70570821e-01f, -1.38603985e-01f, 1.32131636e-01f, -7.73281008e-02f,
  -1.27325013e-01f, -9.68277752e-02f, 5.14927022e-02f, 5.36523685e-02f, 7.60943145e-02f, 1.09882027e-01f, -1.65774494e-01f, -6.09794026e-03f, -4.15556468e-02f, -3.97899300e-02f,
  -2.45362490e-01f, -1.42235160e-01f, 7.52128139e-02f, -1.61757290e-01f, 6.05467409e-02f, -1.21775411e-01f, -1.92277925e-03f, 6.64192289e-02f, 5.84945977e-02f, -1.21865787e-01f,
  8.39006975e-02f, 4.67449501e-02f, 3.53975706e-02f, -8.71927738e-02f, 1.96442649e-01f, -1.84152678e-01f, -1.89495906e-02f, 6.67088032e-02f, -6.80284053e-02f, 1.96320280e-01f,
  8.95119980e-02f, 7.53210858e-03f, 2.34911412e-01f, -1.05490439e-01f, -1.28806550e-02f, -6.69944137e-02f, -2.61303931e-02f, -4.57557850e-02f, 1.57450184e-01f, 6.45731464e-02f,
  -3.51343453e-02f, 8.89110342e-02f, -4.75285016e-02f, -1.06920645e-01f, 6.23837560e-02f, 1.71232410e-02f, -5.20580038e-02f, -6.97561773e-03f, 8.26466680e-02f, 1.70175165e-01f,
  5.51311225e-02f, -4.19414192e-02f, 1.10512994e-01f, -2.74508130e-02f, 5.49592674e-02f, 2.03035362e-02f, 9.34958085e-02f, 5.93946539e-02f, 1.18950352e-01f, 1.07032001e-01f,
  -4.80024703e-02f, 1.97308093e-01f, 9.26175863e-02f, 2.47510478e-01f, -1.21346954e-02f, 3.74728516e-02f, 1.46864643e-02f, -2.74118651e-02f, 3.07836570e-02f, -6.06425330e-02f,
  3.01145524e-01f, 1.64916888e-01f, -7.14848489e-02f, -6.14071861e-02f, -1.50892556e-01f, 1.68159425e-01f, 3.38982441e-03f, 1.28537431e-01f, -2.31338888e-02f, -1.06163442e-01f,
  -4.15757746e-02f, 6.47680461e-02f, -1.83590166e-02f, 2.30379090e-01f, -1.74738467e-02f, -1.25544295e-01f, 1.19942509e-01f, -1.90113172e-01f, 2.20653079e-02f, -4.01592031e-02f,
  1.35813192e-01f, -9.92316529e-02f, 4.82700579e-02f, -1.26809657e-01f, -2.30509773e-01f, 5.08979335e-03f, -2.11967319e-01f, 5.80912121e-02f, 5.17355911e-02f, -6.36286288e-02f,
  2.38567546e-01f, 1.36704206e-01f, -7.64036030e-02f, -4.13432531e-03f, 1.72182113e-01f, -1.09475628e-01f, -6.77958205e-02f, -2.21802890e-02f, 1.63447447e-02f, 1.20836243e-01f,
  -6.45475462e-02f, 5.40380254e-02f, -6.94121122e-02f, -1.24899922e-02f, -1.16469264e-01f, -5.00415489e-02f, -9.94587317e-02f, 9.49606821e-02f, 3.72500680e-02f, -1.92295592e-02f,
  -9.76109579e-02f, 3.75617743e-02f, 2.11306676e-01f, 9.96546969e-02f, 5.79140522e-02f, -1.65783092e-01f, -1.65985763e-01f, -1.04351357e-01f, -5.10249510e-02f, -1.28389448e-01f,
  -1.04160927e-01f, -1.27414018e-02f, 2.44477063e-01f, -9.21423957e-02f, 5.48448265e-02f, -1.03954144e-03f, 6.76209107e-02f, 2.38678947e-01f, -2.18008067e-02f, 1.43258870e-01f,
  1.08593158e-01f, -2.03843489e-02f, 4.15744483e-02f, 1.35855917e-02f, -6.44307584e-02f, -8.13613236e-02f, 1.03319503e-01f, 6.89269975e-02f, 8.23999271e-02f, 1.21971086e-01f,
  -1.15198106e-01f, 2.22563326e-01f, -3.75706963e-02f, -1.86188146e-01f, 1.14563620e-02f, -7.32894987e-02f, -1.85368031e-01f, -5.47185279e-02f, -5.88269606e-02f, 1.53004840e-01f,
  -1.40193328e-01f, 7.24556223e-02f, 3.08001153e-02f, -1.74025595e-02f, 7.57719502e-02f, -5.57438210e-02f, -7.90745951e-04f, 7.89236426e-02f, -5.91376983e-02f, -7.02226255e-03f,
  -1.61617231e-02f, -3.35986242e-02f, -6.94652572e-02f, -1.41091542e-02f, -1.04873041e-02f, -1.34323493e-01f, -2.45747983e-01f, 3.60634439e-02f, -1.67884663e-01f, 7.55045265e-02f,
  3.13396007e-01f, 2.65598744e-01f, -9.22356099e-02f, 1.73710406e-01f, -1.50152789e-02f, -2.11628769e-02f, 1.25853300e-01f, 3.75738740e-02f, -8.47117379e-02f, 9.68348682e-02f,
  6.65362850e-02f, -5.89811616e-02f, -9.31904316e-02f, 2.29564324e-01f, -4.37311828e-02f, -1.07175305e-01f, -2.08540544e-01f, 4.20191027e-02f, 1.58002108e-01f, -3.41567695e-02f,
  -1.57002881e-01f, 2.65924335e-01f, 3.15870009e-02f, -8.33901614e-02f, 2.01459035e-01f, 1.23213135e-01f, 7.52732307e-02f, 5.64443283e-02f, -7.77568668e-02f, -1.53253928e-01f,
  1.04682930e-01f, -1.73618067e-02f, -1.31616583e-02f, 3.59437317e-02f, 2.57687327e-02f, 5.90262935e-02f, -4.20684591e-02f, -9.88118723e-02f, 2.27335077e-02f, -1.09803088e-01f,
  -9.06791985e-02f, -7.29029924e-02f, -1.12766363e-01f, -1.01472199e-01f, -4.66172472e-02f, -6.16730936e-02f, -3.52582857e-02f, 3.04396432e-02f, -1.97052270e-01f, -4.78149615e-02f,
  9.43148211e-02f, -8.24187323e-02f, -9.17803124e-02f, -5.45204319e-02f, 6.77257925e-02f, 5.02527505e-02f, -5.29148728e-02f, -1.62350625e-01f, 4.71761003e-02f, -1.82084978e-01f,
  -1.78933814e-01f, 7.82666579e-02f, 2.26692289e-01f, -7.21989141e-04f, 3.90339121e-02f, 1.58450454e-01f, 9.20413807e-03f, 9.77095068e-02f, 1.94616720e-01f, -1.90198213e-01f,
  -1.33411989e-01f, 3.95045057e-02f, 8.64398554e-02f, -6.39919266e-02f, 1.29651099e-01f, 8.53372738e-02f, -2.25524992e-01f, -5.11479601e-02f, -8.80829170e-02f, 2.44896263e-01f,
  -6.86550587e-02f, -2.22979918e-01f, -1.38290286e-01f, -1.31768107e-01f, 1.21225446e-01f, 1.26071393e-01f, -1.65178075e-01f, -1.27358556e-01f, -9.56810415e-02f, -1.16719268e-01f,
  -2.39540339e-02f, 9.98798236e-02f, -4.63669039e-02f, 6.07231557e-02f, -7.71250352e-02f, -3.08960192e-02f, -1.35161161e-01f, -5.61042281e-04f, -5.62636927e-02f, 1.38007671e-01f,
  3.98994423e-02f, -1.33257404e-01f, 3.07989344e-02f, -2.28831992e-01f, 1.53967217e-02f, 3.67730334e-02f, -4.06733006e-01f, -5.38653927e-03f, 6.55446053e-02f, 1.26205564e-01f,
  1.40075728e-01f, 1.32449463e-01f, 1.82061736e-02f, -7.60065168e-02f, -7.13106394e-02f, 1.18999556e-01f, 3.73954177e-02f, -2.94223398e-01f, 1.03938781e-01f, 1.57519132e-01f,
  -1.79050803e-01f, 1.21204637e-01f, 1.65336385e-01f, -2.33962998e-01f, -2.11882010e-01f, -1.91919833e-01f, -1.47734836e-01f, -1.02543004e-01f, 4.53564636e-02f, -1.61795348e-01f,
  -2.47646391e-01f, -3.00459594e-01f, 7.89413676e-02f, -1.36725456e-01f, -3.67567509e-01f, -4.66898121e-02f, -4.81751189e-02f, 7.95424804e-02f, -1.60389289e-01f, -5.52548505e-02f,
  -1.17358655e-01f, -4.37171683e-02f, -1.99731570e-02f, 1.54887065e-01f, -2.00199746e-02f, 9.49731767e-02f, -6.27918839e-02f, 1.22010753e-01f, 8.96245465e-02f, -1.54567207e-03f,
  6.29018918e-02f, -1.04544260e-01f, -9.26017091e-02f, -9.10202190e-02f, 1.32585108e-01f, 8.98421109e-02f, 1.88799631e-02f, -4.84407507e-02f, 8.58438089e-02f, 1.60057098e-01f,
  -8.28681961e-02f, -1.08034775e-01f, 2.42742419e-01f, 1.03600390e-01f, 2.67065406e-01f, -1.18255094e-01f, 1.07196122e-01f, 1.31364977e-02f, 1.94224328e-01f, 1.99091852e-01f,
  1.12401105e-01f, 1.15674473e-02f, 1.91971034e-01f, 1.12582818e-01f, 1.10698856e-01f, -5.20138033e-02f, 1.54396713e-01f, 1.51045755e-01f, -4.52229083e-02f, 2.09372379e-02f,
  1.13466501e-01f, 1.51896581e-01f, 7.02882633e-02f, -1.04956508e-01f, 7.97144845e-02f, 1.17872218e-02f, 5.98762855e-02f, -2.43168831e-01f, 8.44537839e-03f, -1.84734389e-01f,
  8.73920973e-03f, 5.47691882e-02f, 5.29803373e-02f, 9.33674574e-02f, -6.28618598e-02f, -1.42421663e-01f, 1.37924850e-01f, 8.93366337e-02f, -1.76581647e-02f, 1.59367323e-02f,
  1.87585711e-01f, -1.01385780e-01f, 9.93368700e-02f, -9.39804614e-02f, 8.97041932e-02f, -9.79833379e-02f, 1.13962598e-01f, 1.50151715e-01f, -1.32019430e-01f, -8.30755234e-02f,
  -2.47668102e-02f, 3.45096253e-02f, -1.03004694e-01f, -4.55452651e-02f, -1.36827156e-01f, -2.76514232e-01f, -7.27937603e-03f, -5.67111410e-02f, -1.04874922e-02f, -5.49443178e-02f,
  1.88835010e-01f, 8.13842490e-02f, -7.15208426e-02f, 7.58789480e-02f, -1.80000693e-01f, 2.00700015e-01f, 2.62246639e-01f, -1.89718634e-01f, -2.48312242e-02f, 1.18852675e-01f,
  -1.03738353e-01f, 6.13109395e-02f, 9.03963149e-02f, 8.97990540e-02f, -3.36173996e-02f, -1.78265292e-02f, 2.05091357e-01f, 1.77047521e-01f, 2.11864308e-01f, -1.13455817e-01f,
  1.35323787e-02f, 1.69836506e-02f, -1.14392869e-01f, -3.28825489e-02f, 1.01553790e-01f, 1.20820373e-01f, -6.22369125e-02f, 6.05721287e-02f, 2.45476756e-02f, 2.19667882e-01f,
  -1.12198316e-01f, 7.17029944e-02f, 2.47794464e-02f, -5.57200238e-02f, 2.44925320e-01f, 1.55476660e-01f, -5.12819253e-02f, -1.04771934e-01f, 1.14852609e-02f, 1.78975854e-02f,
  1.68933675e-01f, 1.79882959e-01f, 1.13712154e-01f, -1.81780532e-01f, -2.04298690e-01f, 2.82808654e-02f, 5.41658737e-02f, -1.00227065e-01f, 1.04734264e-01f, 1.31855011e-01f,
  -1.51515350e-01f, 1.02972396e-01f, 9.32687819e-02f, -3.84208933e-03f, -1.48017690e-01f, 1.66595951e-02f, 3.32564026e-01f, 1.77110404e-01f, -9.94424149e-02f, 3.23620260e-01f,
  -1.17948763e-01f, 5.90960383e-02f, 2.30674103e-01f, 1.57162901e-02f, -1.06341511e-01f, -3.68311442e-02f, -2.76913255e-01f, -2.67581176e-02f, 8.87660384e-02f, -2.61373729e-01f,
  -2.06619799e-01f, 8.18505138e-02f, 2.32543975e-01f, -1.14094064e-01f, 8.01541060e-02f, 1.01574920e-01f, 9.62791741e-02f, 1.11883849e-01f, -4.07102369e-02f, -1.79868609e-01f,
  -5.61169870e-02f, 8.24528039e-02f, 1.40675768e-01f, 2.60508666e-03f, -1.48209229e-01f, -2.17168048e-01f, 2.64460538e-02f, 9.61099416e-02f, -2.25559399e-01f, -1.61525860e-01f,
  8.08376968e-02f, -1.87155068e-01f, 1.47052422e-01f, -4.89291130e-03f, -3.65544222e-02f, -1.16159834e-01f, 8.42639580e-02f, 8.93755630e-02f, 1.90194756e-01f, 7.60575235e-02f,
  7.13154599e-02f, 3.04341853e-01f, 1.77791968e-01f, 2.46767819e-01f, 6.53473809e-02f, -9.95834097e-02f, 1.18350491e-01f, 1.25081405e-01f, 2.40568608e-01f, 1.34785980e-01f,
  -2.25647047e-01f, 1.31231425e-02f, 1.72793731e-01f, 7.33975023e-02f, 1.40520766e-01f, -8.87073204e-02f, -6.65663183e-02f, -7.15961605e-02f, 1.71325564e-01f, 1.05485087e-02f,
  2.67546661e-02f, -1.78296626e-01f, -1.17723770e-01f, 1.61440104e-01f, -1.40649542e-01f, -2.64456086e-02f, -1.44439653e-01f, 7.09405914e-02f, 2.03306541e-01f, -2.23697983e-02f,
  -1.27853453e-02f, -5.65133579e-02f, 1.70347765e-01f, -6.94767758e-02f, -1.02108628e-01f, -1.61022809e-03f, -2.09364489e-01f, 3.06792408e-01f, -3.01432237e-02f, 2.21854635e-02f,
  1.12851478e-01f, 6.76520728e-03f, -7.30544031e-02f, -1.26690447e-01f, 1.57548022e-02f, -7.51061365e-02f, 2.53908653e-02f, -2.69083697e-02f, -4.61109094e-02f, 8.58876705e-02f,
  -1.11413106e-01f, 7.79720470e-02f, 2.08565942e-03f, -1.07806221e-01f, -9.59654525e-02f, -7.10300133e-02f, -6.78278282e-02f, 8.55071396e-02f, -2.62865461e-02f, 9.30753723e-02f,
  2.10131109e-01f, 1.30008057e-01f, 1.01772889e-01f, -1.43550206e-02f, 1.89071730e-01f, 1.36505696e-03f, 1.13344751e-01f, 5.58216730e-03f, 1.30200237e-01f, 7.50002936e-02f,
  1.93927437e-01f, -1.78510845e-01f, 9.17710885e-02f, 1.50042206e-01f, 9.41829681e-02f, -5.83845414e-02f, -7.93255344e-02f, -5.02221994e-02f, -5.46795651e-02f, -1.71377406e-01f,
  4.85164113e-02f, 1.09000027e-01f, -5.62373139e-02f, -1.08208761e-01f, -1.70671791e-01f, 1.01115964e-02f, 1.97489634e-02f, 8.46892521e-02f, -4.95018214e-02f, -7.63704404e-02f,
  -6.14263564e-02f, -3.10299881e-02f, -6.38045371e-02f, -5.45564182e-02f, 1.34078547e-01f, 1.52890161e-01f, -1.03486679e-01f, 1.88757971e-01f, -1.84269100e-02f, -3.71175259e-02f,
  -9.00319964e-03f, -3.75250774e-03f, -3.66677716e-02f, -1.41687974e-01f, -1.99564844e-01f, -1.75514892e-01f, -6.37383293e-03f, 1.25640094e-01f, -1.68047562e-01f, 1.06933318e-01f,
  2.55894121e-02f, 6.58832937e-02f, 2.93916110e-02f, -7.40508665e-04f, 1.44791026e-02f, 3.41949351e-02f, -9.26235616e-02f, -1.57501340e-01f, 2.15396434e-02f, 1.98324129e-01f,
  -2.63578482e-02f, 8.90439469e-03f, -3.43246162e-02f, -6.65886104e-02f, -2.56143332e-01f, 1.97985306e-01f, -8.37574080e-02f, 6.56570792e-02f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  2.60247942e-02f, 1.98920548e-01f, 1.77499041e-01f, -3.46330315e-01f, -1.88994147e-02f, 2.88361698e-01f, 9.95017961e-02f, -7.38485903e-02f, -4.64600958e-02f, 2.36471333e-02f,
  1.61898378e-02f, 1.26632124e-01f, -6.88225105e-02f, -3.04992437e-01f, 1.93158552e-01f, 1.35658041e-01f, 1.05663417e-02f, -3.29308212e-02f, -1.45512149e-01f, 2.42123693e-01f,
  -2.08709836e-02f, 1.62060082e-01f, -2.33034149e-01f, 1.98058084e-01f, -3.33836168e-01f, -1.64218903e-01f, -6.47948459e-02f, 2.09861755e-01f, 2.09210455e-01f, 2.73753069e-02f,
  -5.85388578e-02f, 2.26612329e-01f, -1.88349877e-02f, -2.72099245e-02f, 1.38472676e-01f, 9.75379869e-02f, 2.11693123e-01f, 2.00163737e-01f, -4.44608405e-02f, -1.42303616e-01f,
  1.93808183e-01f, -6.29156455e-02f, -5.45781106e-02f, 6.07857741e-02f, 7.13188499e-02f, 1.25715137e-01f, 1.62032172e-01f, -1.04448140e-01f, 3.16886127e-01f, 1.10698834e-01f,
  5.23309931e-02f, 2.74649203e-01f, 2.53909528e-01f, -7.14356378e-02f, 7.47408867e-02f, 2.42939189e-01f, -1.06918998e-01f, 2.26314276e-01f, -4.00432870e-02f, 2.97916740e-01f,
  5.13823368e-02f, 1.09651156e-01f, -5.73182665e-02f, -2.44067416e-01f, -1.28658786e-01f, -1.30435362e-01f, -1.15044147e-01f, -6.19908161e-02f, -4.51299936e-01f, 7.12250620e-02f,
  1.38006896e-01f, -5.50687797e-02f, 2.89140463e-01f, 1.50263071e-01f, 9.57057998e-02f, 1.15506142e-01f, 1.14878919e-02f, 7.16411546e-02f, 3.55441198e-02f, -1.79550961e-01f,
  8.29396620e-02f, 1.74316958e-01f, 3.17068696e-01f, 8.97203758e-02f, -5.98911429e-03f, 1.32459819e-01f, 1.61258355e-01f, 1.87443301e-01f, 7.59971067e-02f, 4.88725603e-02f,
  -7.60037154e-02f, -1.22801498e-01f, 1.66398585e-01f, 1.74047664e-01f, 1.45094976e-01f, 1.94472522e-01f, 7.53489286e-02f, -8.27988908e-02f, 2.63463464e-02f, -1.63771994e-02f,
  -4.86731417e-02f, -5.02474546e-01f, -9.13579017e-02f, -2.98942477e-01f, -1.60205916e-01f, -3.44486803e-01f, 2.09188119e-01f, 1.44021600e-01f, -3.01293820e-01f, 1.23987705e-01f,
  3.97085026e-03f, 3.98614407e-02f, 1.47732347e-01f, 1.46233678e-01f, 1.78289358e-02f, -7.40021393e-02f, 5.79732396e-02f, 1.82294160e-01f, -2.85904080e-01f, -1.06091835e-01f,
  -1.83226809e-01f, 1.02388419e-01f, 1.62481144e-01f, -3.68481487e-01f, -1.92374766e-01f, -8.06014314e-02f, -1.57230616e-01f, -2.94728447e-02f, 9.19735059e-02f, -1.38676852e-01f,
  -2.00675633e-02f, 1.34570345e-01f, -1.28918231e-01f, -2.09838182e-01f, 8.67047980e-02f, 9.11164209e-02f, 7.36939311e-02f, 7.15940595e-02f, 3.25133726e-02f, 2.53861219e-01f,
  5.77645202e-04f, 1.43312678e-01f, -5.10538965e-02f, 1.22719303e-01f, 9.49230045e-02f, -1.42739818e-01f, 2.27203250e-01f, 5.83513901e-02f, -4.69874740e-02f, 2.00474286e-03f,
  2.32345566e-01f, 9.43418816e-02f, 1.07464464e-02f, -1.82703063e-02f, -1.39728621e-01f, -1.94393381e-01f, 1.42834216e-01f, 2.58951217e-01f, 6.15614764e-02f, 3.13271254e-01f,
  4.11909670e-02f, 1.54229281e-02f, -1.00981005e-01f, 1.43772319e-01f, -4.74537686e-02f, -7.03642145e-02f, 1.94930434e-01f, -4.41987216e-02f, 1.23533092e-01f, -3.38594466e-01f,
  1.29511461e-01f, 3.34492549e-02f, -8.98527205e-02f, 1.77343190e-01f, 6.68794960e-02f, -2.52195485e-02f, 6.96214288e-02f, 1.12715393e-01f, 1.38055474e-01f, -1.12776026e-01f,
  1.41694069e-01f, 1.63364023e-01f, -8.78701583e-02f, 5.44665288e-03f, 6.28814995e-02f, 8.67384374e-02f, 1.65731292e-02f, -6.82363054e-03f, 7.15796575e-02f, 6.12319596e-02f,
  2.55738404e-02f, 2.14776397e-02f, 1.06622763e-01f, -1.12769492e-02f, -6.47792816e-02f, -2.44891107e-01f, 1.12127870e-01f, 2.10882962e-01f, -1.53888479e-01f, -6.47147447e-02f,
  -2.25091740e-01f, 4.09609824e-02f, 2.36613750e-01f, 6.50351867e-02f, 2.33804226e-01f, -9.23160091e-02f, -2.55630642e-01f, 1.16911322e-01f, -8.06323066e-02f, -2.80583411e-01f,
  -2.69811690e-01f, 7.11891428e-02f, 1.83655426e-01f, 2.78427064e-01f, 3.61193746e-01f, 1.90043196e-01f, -9.51551571e-02f, 2.04032212e-01f, 6.74925819e-02f, 5.81998229e-02f,
  8.79639294e-03f, 9.00619198e-03f, -6.95890933e-02f, -2.54740808e-02f, -2.74756886e-02f, -2.78317302e-01f, -1.61702573e-01f, -1.85894281e-01f, 3.23796630e-01f, 1.37684703e-01f,
  -4.13124301e-02f, -3.26286972e-01f, 1.20218575e-01f, -1.16063200e-01f, -1.38473138e-01f, 6.65854141e-02f, -2.25094825e-01f, 6.87300414e-02f, -1.41016096e-01f, 1.37321800e-01f,
  2.44200319e-01f, -5.56339882e-02f, 2.36404631e-02f, 1.22681648e-01f, 1.73121095e-01f, -1.79604411e-01f, -3.45477462e-01f, -3.10048521e-01f, 4.08889763e-02f, -3.31421159e-02f,
  2.16434836e-01f, 5.81409670e-02f, -2.08812565e-01f, 8.17903131e-02f, -1.43169224e-01f, 1.27396271e-01f, -6.29567802e-02f, 1.64214194e-01f, -1.35259461e-02f, -2.36512274e-01f,
  2.15690345e-01f, 5.12811653e-02f, 1.61444694e-02f, -9.61942896e-02f, -3.75511311e-02f, -2.73380522e-02f, 1.06070219e-02f, -1.05174795e-01f, 2.27994293e-01f, -1.36322513e-01f,
  1.11278184e-01f, 1.33621141e-01f, 5.89223625e-03f, 6.40853867e-02f, -1.88767120e-01f, -1.95370927e-01f, 6.18905686e-02f, -2.45946556e-01f, -1.48382738e-01f, -3.35028201e-01f,
  -4.90498915e-03f, -1.69245258e-01f, -1.12741418e-01f, 8.43032673e-02f, 2.77620703e-01f, 4.24707830e-02f, -7.66518041e-02f, -5.68784326e-02f, -1.47102401e-01f, 3.35143059e-01f,
  2.87274182e-01f, -1.87214434e-01f, -4.32047285e-02f, 2.09901109e-01f, -1.45513266e-01f, 9.10354182e-02f, -9.07470137e-02f, 1.49757653e-01f, -2.53530502e-01f, 1.30763933e-01f,
  3.74423936e-02f, 1.70755535e-01f, 5.30389473e-02f, -1.12176448e-01f, 4.65059839e-02f, 1.90788791e-01f, -1.03683986e-01f, 8.73755813e-02f, -9.66994315e-02f, -5.72485998e-02f,
  1.30528718e-01f, -7.99072236e-02f, -6.63580671e-02f, 1.16686434e-01f, -1.35160670e-01f, 3.01856577e-01f, 1.36755377e-01f, 2.27894410e-01f, -1.23622499e-01f, 2.84755468e-01f,
  1.09396026e-01f, 2.39446573e-02f, 6.37061819e-02f, 2.14943945e-01f, -8.69216695e-02f, -4.87342514e-02f, 1.41412303e-01f, 2.59353244e-03f, -2.19323933e-02f, 1.93520933e-01f,
  -1.05121292e-01f, -2.86690474e-01f, 3.98891233e-03f, -2.46660225e-02f, 1.68977842e-01f, -8.86765569e-02f, -2.71860242e-01f, 3.62801164e-01f, -4.86060865e-02f, 2.65304409e-02f,
  -4.05191071e-02f, 1.31877184e-01f, -2.10163429e-01f, 8.22214410e-02f, -2.41374932e-02f, -9.61911678e-02f, 1.46554008e-01f, 9.62691605e-02f, 8.23700726e-02f, -7.53521621e-02f,
  1.13370344e-01f, -2.49177262e-01f, 2.32406214e-01f, -3.81566286e-01f, -5.71650080e-02f, -7.36499652e-02f, -9.10812914e-02f, 1.02990353e-02f, 9.30644125e-02f, 1.90306306e-01f,
  -1.97437465e-01f, 3.48351419e-01f, -9.21923518e-02f, -2.27688789e-01f, 5.57461530e-02f, -1.73696652e-01f, -5.24597503e-02f, 1.40756398e-01f, -3.32915545e-01f, -2.29060352e-01f,
  -1.34586304e-01f, -1.95768103e-02f, -1.09457508e-01f, 6.40329439e-03f, 1.16754092e-01f, -4.06667888e-02f, 1.09007560e-01f, -3.40829670e-01f, 8.77090320e-02f, 1.61153078e-01f,
  -5.09745255e-02f, 7.70691410e-02f, 2.81479001e-01f, -1.34418622e-01f, 8.32604617e-02f, -1.69032514e-02f, -5.77124134e-02f, 3.61519814e-01f, 2.79437602e-02f, 1.04935549e-01f,
  -1.24614246e-01f, 1.28039509e-01f, -1.71197519e-01f, 1.70580834e-01f, 2.71641403e-01f, 1.66364238e-02f, -3.07542473e-01f, 3.26244414e-01f, -4.34088290e-01f, 1.86809991e-02f,
  -1.74312323e-01f, -1.70877669e-02f, -1.29406095e-01f, 1.42581940e-01f, 9.75272134e-02f, 9.59582776e-02f, -1.21648759e-01f, 2.42534712e-01f, 1.86478004e-01f, 1.59786239e-01f,
  1.90568477e-01f, -1.25264838e-01f, -1.33805200e-01f, 1.81901306e-02f, -1.06768876e-01f, -1.47416681e-01f, 1.98610410e-01f, 1.21905036e-01f, -7.25192949e-02f, 9.16575268e-02f,
  4.03254405e-02f, -1.07153365e-02f, 2.05763295e-01f, -1.06923223e-01f, -3.51587590e-03f, -6.12552278e-02f, -1.27092555e-01f, 1.57113984e-01f, -1.23927824e-01f, -1.99715700e-02f,
  -2.20126167e-01f, 8.52365941e-02f, -1.32621512e-01f, -7.20128790e-02f, 1.53303921e-01f, -9.81136225e-03f, -1.13439232e-01f, -2.72209138e-01f, 1.84685737e-01f, -5.23101464e-02f,
  2.35859305e-01f, -1.46498531e-01f, 2.01477006e-01f, 4.44946103e-02f, -3.56467851e-02f, -1.33225434e-02f, -1.28163218e-01f, 2.21867383e-01f, 2.21977338e-01f, -1.09186344e-01f,
  -7.45964423e-02f, 1.15030691e-01f, 5.16410843e-02f, -3.13891709e-01f, -9.55014080e-02f, -6.81576319e-03f, -7.23155439e-02f, 2.45756641e-01f, 1.67059526e-01f, -2.08504647e-01f,
  -9.01128128e-02f, 3.25867742e-01f, -4.35402282e-02f, 9.38683301e-02f, -2.02753782e-01f, 2.18539268e-01f, -7.32209310e-02f, 6.92591593e-02f, 3.09938431e-01f, 1.17856659e-01f,
  3.28252949e-02f, 1.14740774e-01f, -3.77210788e-02f, -3.97844166e-02f, 1.84481874e-01f, -1.24179048e-03f, 6.78213090e-02f, -1.62410542e-01f, 5.19498484e-03f, -1.47122428e-01f,
  2.11733714e-01f, -6.80951998e-02f, -9.65748951e-02f, -2.03347467e-02f, 4.96556349e-02f, 9.30308029e-02f, 1.80133581e-01f, 8.66978243e-02f, -9.81449112e-02f, 7.34563619e-02f,
  2.87522301e-02f, -2.19337642e-01f, 2.57629552e-03f, -1.01464659e-01f, -1.61974311e-01f, 2.57727236e-01f, -3.01452726e-01f, -4.22551662e-01f, -6.25352338e-02f, -3.15238908e-02f,
  -1.90102726e-01f, -9.28958058e-02f, -4.17284146e-02f, -3.31660688e-01f, 1.01527654e-01f, -3.80749077e-01f, 9.52413399e-03f, 1.95724919e-01f, 1.14397235e-01f, 1.90546513e-02f,
  -3.47540975e-01f, -3.38833872e-03f, 1.38775595e-02f, 3.11460704e-01f, -5.05064055e-02f, -2.17183921e-02f, 3.86466920e-01f, 3.30975235e-01f, -5.48455911e-03f, 2.31912822e-01f,
  1.39093950e-01f, 3.76549326e-02f, 1.25273615e-02f, 9.51731354e-02f, -2.55249113e-01f, -8.05033743e-02f, -1.52780920e-01f, 2.02330038e-01f, 2.57677495e-01f, -1.59107715e-01f,
  -2.92398185e-01f, -1.60375491e-01f, -1.07472502e-02f, 5.52281691e-03f, -4.90264475e-01f, -9.88244638e-02f, 2.90570464e-02f, -2.17771158e-01f, 2.10617483e-01f, 4.57189120e-02f,
  -3.65027428e-01f, 1.13622714e-02f, 3.58460806e-02f, -8.11083615e-02f, 9.05536264e-02f, 1.36637002e-01f, 3.25765967e-01f, 1.92208454e-01f, 1.33704007e-01f, 8.62908289e-02f,
  -4.25385237e-02f, 6.37986660e-02f, -9.37046707e-02f, 2.06161365e-01f, -4.78791893e-02f, 8.27785954e-02f, 9.26665664e-02f, 2.11771324e-01f, -3.05033810e-02f, 1.97134670e-02f,
  -7.57924914e-02f, 1.14617139e-01f, -1.60139352e-01f, -9.80755389e-02f, -1.10235095e-01f, -2.76149064e-01f, 2.76969939e-01f, -9.02315602e-02f, 1.13439173e-01f, 4.72442694e-02f,
  -1.68266490e-01f, -2.16157734e-01f, -8.94545242e-02f, 2.94356812e-02f, -3.24793190e-01f, 2.13280231e-01f, -1.95380505e-02f, 2.38265455e-01f, 9.49358419e-02f, -2.35026285e-01f,
  3.55299532e-01f, 2.60687977e-01f, 2.44425178e-01f, 9.05227512e-02f, 3.73372436e-01f, -1.37604550e-01f, -1.48478031e-01f, 1.80901319e-01f, -1.43659696e-01f, -2.08189175e-01f,
  -1.46214336e-01f, 3.04877684e-02f, 2.63260394e-01f, -1.29889846e-01f, -2.68842101e-01f, -1.14306092e-01f, -2.58370370e-01f, 2.52503783e-01f, -4.77899820e-01f, -1.03652082e-01f,
  -1.80419967e-01f, -3.95106494e-01f, -1.31019661e-02f, 2.24153548e-01f, -3.41452003e-01f, 1.21276475e-01f, 2.87244748e-02f, 6.17668405e-02f, 1.90565228e-01f, 1.14875242e-01f,
  2.72483498e-01f, 5.92386052e-02f, 1.06484644e-01f, 4.50087786e-02f, -1.93320457e-02f, 4.85716052e-02f, 1.37825891e-01f, 2.39714086e-02f, -2.64867127e-01f, 1.40654787e-01f,
  -1.08323634e-01f, 5.35773598e-02f, 8.69239718e-02f, -2.50581741e-01f, -1.90011576e-01f, 1.10522166e-01f, -3.25438768e-01f, 6.52804226e-02f, -2.23852515e-01f, -2.96888143e-01f,
  2.28932321e-01f, -2.58447323e-02f, 8.55621323e-02f, 2.08615780e-01f, -2.20547870e-01f, -2.61592507e-01f, -4.86870185e-02f, -5.59860617e-02f, -2.14862823e-02f, 5.95106855e-02f,
  2.46155575e-01f, -1.31669417e-01f, 2.15875998e-01f, 2.31919095e-01f, 1.35973081e-01f, 7.06989393e-02f, -1.08699031e-01f, -3.88058200e-02f, -7.70415440e-02f, 1.41892225e-01f,
  2.68256932e-01f, -2.62089670e-02f, 5.55997677e-02f, 2.97915041e-01f, -1.06058940e-01f, 7.70107806e-02f, 1.64823979e-01f, -1.88682795e-01f, -2.05628648e-01f, 7.68023059e-02f,
  -1.04658708e-01f, 1.66774377e-01f, 7.29736611e-02f, -1.63456395e-01f, 1.24172784e-01f, 4.43746634e-02f, 1.20828059e-02f, -2.73495466e-01f, -2.32072361e-02f, 1.09282069e-01f,
  -3.52419674e-01f, 1.12050898e-01f, -9.92883928e-03f, 1.21092565e-01f, -2.52376311e-02f, -1.31833464e-01f, -6.87165335e-02f, 2.70152748e-01f, 3.01372319e-01f, -2.00472511e-02f,
  2.15169609e-01f, -1.26853898e-01f, 7.09815174e-02f, 3.04166265e-02f, -7.82622173e-02f, 1.99755058e-01f, -7.36305341e-02f, -5.37664741e-02f, -1.97518125e-01f, 4.06595916e-02f,
  6.20331615e-02f, -1.74849313e-02f, 4.31714058e-02f, -5.06127626e-02f, -5.66414744e-02f, -7.92517290e-02f, 2.68128723e-01f, -9.17703751e-03f, -6.13586046e-02f, 1.57424122e-01f,
  2.62503445e-01f, 2.36742258e-01f, -2.97005312e-03f, 2.85146423e-02f, 8.51824060e-02f, 1.19903870e-01f, 5.54555729e-02f, 1.64253861e-01f, 1.87098846e-01f, 2.59363472e-01f,
  7.97751769e-02f, 1.84998050e-01f, 4.25583171e-03f, 4.89200838e-03f, 8.01153108e-02f, -1.03119150e-01f, -5.94142750e-02f, 1.86293200e-01f, -1.49709303e-02f, -2.56953865e-01f,
  2.53027678e-01f, 6.58360198e-02f, -8.57335106e-02f, 2.90610883e-02f, -7.37125129e-02f, -9.91254002e-02f, -9.24162269e-02f, 2.68614311e-02f, 1.19912708e-02f, -1.35766640e-01f,
  3.49330381e-02f, -1.87269062e-01f, -1.45869240e-01f, -6.91647679e-02f, -2.39768922e-02f, 1.03012741e-01f, 1.81128770e-01f, 2.59742945e-01f, 1.50059357e-01f, 1.09027937e-01f,
  -1.39613256e-01f, -1.36058703e-01f, -1.43831568e-02f, 1.75115660e-01f, -9.69918445e-02f, 1.80497542e-02f, -1.06410921e-01f, 1.73742816e-01f, 4.72979806e-02f, -1.16541907e-01f,
  -7.16249421e-02f, -4.17975597e-02f, -1.97770774e-01f, 7.21946508e-02f, -4.53668348e-02f, -7.06680790e-02f, -5.09353243e-02f, -3.70542482e-02f, 1.82827488e-01f, 1.06748775e-01f,
  3.06741316e-02f, -2.53129192e-02f, -3.21103027e-03f, 6.35035485e-02f, 1.15676388e-01f, -5.84790297e-02f, -3.84792596e-01f, -8.06536749e-02f, 1.14034176e-01f, 9.10840705e-02f,
  1.83866963e-01f, 9.28771272e-02f, -2.17127115e-01f, 3.16596106e-02f, -1.02846930e-02f, 2.43919380e-02f, 2.44319245e-01f, 2.09808955e-03f, 4.27039973e-02f, -1.70867756e-01f,
  1.43153936e-01f, -2.71410421e-02f, 2.58142859e-01f, -3.23138870e-02f, -6.49529845e-02f, 9.64518636e-02f, 5.76537885e-02f, -2.01607689e-01f, -6.79119006e-02f, -2.25734174e-01f,
  -1.37902066e-01f, 6.14788271e-02f, -4.10053164e-01f, -2.30021954e-01f, -4.25114296e-02f, 6.93276897e-02f, 2.14998528e-01f, -1.22738265e-01f, 6.26328588e-02f, -2.89315999e-01f,
  -7.90600926e-02f, -1.17461771e-01f, -8.66285637e-02f, -1.78979430e-02f, -8.28882530e-02f, 2.27790341e-01f, 9.54451188e-02f, 3.61908600e-02f, -1.01852238e-01f, 1.12459794e-01f,
  1.67166859e-01f, -3.32954705e-01f, 2.49519870e-01f, -2.86107600e-01f, 5.42877726e-02f, 7.71479309e-02f, 1.70094147e-01f, -5.82941771e-02f, -1.43767446e-01f, 5.94682433e-02f,
  7.57597387e-02f, 1.70829743e-02f, 6.77487776e-02f, 2.07183510e-01f, 5.00760041e-02f, -1.79758459e-01f, -2.23921170e-03f, 1.08773082e-01f, 1.69606939e-01f, -1.69602353e-02f,
  2.05591276e-01f, -9.09759849e-03f, 1.54154021e-02f, -2.09684029e-01f, -1.70804799e-01f, 1.74090341e-01f, 3.03507835e-01f, -1.84418276e-01f, -1.23985618e-01f, 7.15711042e-02f,
  -2.42863923e-01f, -2.55070448e-01f, -1.32420529e-02f, -8.70262235e-02f, 2.29811385e-01f, 1.68831334e-01f, -1.45557672e-01f, 9.61356908e-02f, -2.26996094e-01f, 6.56982511e-02f,
  -1.22030139e-01f, -1.36478245e-01f, 9.93344635e-02f, -1.58061042e-01f, -1.73815861e-01f, -1.80060685e-01f, 6.62612990e-02f, 1.33702636e-01f, 2.37851277e-01f, -6.92855939e-02f,
  -1.47114508e-02f, -3.54859419e-02f, -5.44848889e-02f, -2.22035676e-01f, 1.40633181e-01f, -4.90860082e-02f, 2.30960734e-03f, 2.35837549e-02f, 4.25614491e-02f, -8.23661461e-02f,
  -9.99324548e-05f, 5.56360036e-02f, -1.74225315e-01f, 1.10761479e-01f, -3.46486509e-01f, 1.62488252e-01f, 1.03949226e-01f, 5.16572967e-02f, -7.89478496e-02f, 2.76166022e-01f,
  -1.46464333e-01f, -1.57107666e-01f, 9.91374105e-02f, 2.01112643e-01f, -1.15475446e-01f, -2.30620205e-01f, 1.15490071e-01f, 7.14331418e-02f, 1.00237057e-01f, -8.65486935e-02f,
  1.62674412e-01f, 6.32838979e-02f, 1.48819193e-01f, -4.69694892e-03f, -2.30669498e-01f, 1.66902795e-01f, 3.28271896e-01f, 3.15790892e-01f, 1.08892471e-01f, 3.75127494e-01f,
  -1.94355905e-01f, 1.73015580e-01f, 2.34135658e-01f, 2.29493096e-01f, 6.54663742e-02f, 2.67343968e-01f, -1.41296580e-01f, 3.69193792e-01f, 2.36232504e-02f, 1.99058622e-01f,
  1.30479485e-01f, -3.81993651e-01f, -5.99195622e-03f, -7.15980399e-03f, 4.17686626e-02f, -6.00990467e-02f, -4.11958992e-01f, 4.60483730e-01f, -2.25994542e-01f, -2.05518633e-01f,
  2.02162504e-01f, -9.93515626e-02f, -1.56527266e-01f, -1.66442692e-01f, 1.14415355e-01f, 1.61796227e-01f, -1.16807297e-01f, 1.67734250e-01f, 1.50092214e-01f, -9.39698219e-02f,
  -1.38106644e-01f, -8.29567090e-02f, -2.82646716e-01f, 2.29194522e-01f, 2.56400824e-01f, 1.26312867e-01f, -5.11655994e-02f, -8.22797120e-02f, -3.18429470e-02f, -2.01356020e-02f,
  -2.28548780e-01f, 7.24135488e-02f, -2.92024255e-01f, -6.08990565e-02f, -1.85480669e-01f, 5.35807237e-02f, 3.51884924e-02f, -3.30912203e-01f, 6.41448051e-02f, -2.26655379e-01f,
  1.24405891e-01f, 1.97633818e-01f, 6.19663717e-03f, -1.56994835e-01f, -1.01576552e-01f, 7.46772364e-02f, -1.20217830e-01f, 1.15985118e-01f, 2.80828387e-01f, -1.94503874e-01f,
  5.66414073e-02f, 1.58976912e-01f, 3.10373694e-01f, 1.04737259e-01f, 5.19455969e-02f, -1.40729293e-01f, -9.74427164e-02f, 7.82052148e-03f, 3.02796692e-01f, 6.84796721e-02f,
  2.26537168e-01f, -1.75627425e-01f, 3.05814594e-01f, 1.83457434e-01f, 3.82593095e-01f, -1.10669129e-01f, -1.64905578e-01f, 2.20594645e-01f, 2.75815371e-02f, -1.73943415e-01f,
  6.36717528e-02f, -8.25607926e-02f, 4.98420410e-02f, -2.06083581e-01f, -3.61139834e-01f, -7.72132501e-02f, -2.08936315e-02f, 2.17086360e-01f, 1.45692006e-01f, -3.15172702e-01f,
  -3.96266067e-03f, -3.91715914e-01f, -2.03035511e-02f, -8.34494382e-02f, -2.01185018e-01f, -2.14291558e-01f, -1.15992531e-01f, 5.31197637e-02f, 1.90006971e-01f, -5.14302067e-02f,
  -1.44059986e-01f, 1.47902831e-01f, -1.39587978e-02f, -4.35411125e-01f, 6.84236735e-02f, -4.77734566e-01f, -2.52549082e-01f, 8.32012370e-02f, -2.03574374e-01f, -1.68578193e-01f,
  -2.67239422e-01f, 7.43137747e-02f, -1.03156470e-01f, -2.63622582e-01f, -4.53975797e-02f, -1.38500422e-01f, -1.39024615e-01f, -3.42463225e-01f, 1.30303651e-01f, 2.98744977e-01f,
  1.35183200e-01f, 1.41220018e-01f, -2.37401590e-01f, -2.91317739e-02f, 1.70822978e-01f, 5.89355789e-02f, 1.58148408e-01f, -5.34971617e-02f, 4.27495986e-01f, 1.37620732e-01f,
  -7.62054026e-02f, -1.60811558e-01f, -9.72964540e-02f, -2.23605186e-02f, 2.00241789e-01f, -6.58475086e-02f, 3.26591849e-01f, 1.01832405e-01f, 1.14447147e-01f, 3.45970631e-01f,
  -1.78332778e-03f, 5.91276661e-02f, -1.56406481e-02f, 8.27145725e-02f, 1.62857726e-01f, 1.11725971e-01f, -4.62717237e-03f, 8.77704173e-02f, -1.55475244e-01f, -6.75800964e-02f,
  7.94864595e-02f, -1.07017651e-01f, -4.48463298e-02f, 7.20635653e-02f, -3.64990771e-01f, -7.23439902e-02f, -1.83795512e-01f, 9.86136049e-02f, 2.01417506e-01f, -1.77209333e-01f,
  8.69766399e-02f, 3.25837195e-01f, 1.96214512e-01f, -1.02163941e-01f, 3.97242159e-01f, 1.36607680e-02f, 4.36245874e-02f, -1.30839944e-01f, 1.48190251e-02f, 1.91131458e-01f,
  -7.13927522e-02f, 1.65414885e-01f, -8.99606496e-02f, 7.67075457e-03f, -7.16314390e-02f, 3.04564804e-01f, 1.90877646e-01f, -5.30671850e-02f, 4.82883751e-02f, 3.60567160e-02f,
  2.54937589e-01f, -7.63525767e-03f, 8.26217681e-02f, 2.51505345e-01f, 3.48391563e-01f, 2.41246879e-01f, -1.58697665e-01f, 1.19316891e-01f, 9.45046470e-02f, 2.33031511e-01f,
  7.46471360e-02f, -3.24612157e-03f, -9.57267173e-03f, 2.66818017e-01f, 1.13759860e-01f, -2.89998502e-01f, 2.97802866e-01f, -1.85699239e-02f, 1.06761739e-01f, -2.37574074e-02f,
  -3.44285853e-02f, 2.40849275e-02f, -7.27622211e-02f, 1.06337704e-01f, 3.74058992e-01f, -1.81863561e-01f, 8.11335351e-03f, 4.56236094e-01f, 4.10406858e-01f, 1.67718545e-01f,
  4.74338904e-02f, 3.51915359e-01f, -7.62198642e-02f, 5.35677634e-02f, 2.20858619e-01f, -6.88680708e-02f, -9.80798006e-02f, 9.84106585e-02f, -1.01148419e-01f, 1.26411453e-01f,
  2.63906531e-02f, -1.09761015e-01f, 1.12915449e-01f, 9.25484374e-02f, 1.62329078e-01f, -4.39876281e-02f, 3.08430612e-01f, 1.89891115e-01f, 2.49427423e-01f, 1.13499546e-02f,
  2.47394875e-01f, 5.52581623e-02f, 9.40977111e-02f, 1.71498820e-01f, 6.91624060e-02f, 5.92731647e-02f, -1.04471311e-01f, -4.81760986e-02f, -7.35377893e-02f, -1.82513133e-01f,
  2.28941832e-02f, 4.78505827e-02f, -1.26094833e-01f, -2.07997829e-01f, 3.10411125e-01f, 1.62064824e-02f, 8.19897559e-03f, -2.10656270e-01f, 2.25020573e-01f, -2.78172158e-02f,
  -6.62271380e-02f, -1.35431260e-01f, 4.42932583e-02f, 1.86839208e-01f, 1.35635167e-01f, -1.73896290e-02f, -3.30597833e-02f, 1.96034789e-01f, 3.28396022e-01f, 1.53243169e-01f,
  3.44531894e-01f, 3.08985114e-02f, -3.53309438e-02f, 4.22170095e-04f, -3.49542886e-01f, 9.97252241e-02f, 7.15617388e-02f, -1.57436609e-01f, 1.63918629e-01f, -1.83777556e-01f,
  -4.09865603e-02f, -6.61658123e-02f, -3.10906708e-01f, -7.26703256e-02f, -1.98689923e-01f, -2.99901158e-01f, 1.18375920e-01f, -2.02817708e-01f, -1.03336059e-01f, -1.01182103e-01f,
  -7.84764513e-02f, 2.46991366e-01f, 1.72378346e-01f, 1.33106306e-01f, 2.96074420e-01f, 3.56481165e-01f, 1.86992079e-01f, -9.99295637e-02f, -2.90057480e-01f, 6.51014075e-02f,
  3.10287829e-02f, 3.09368402e-01f, 3.28898393e-02f, 1.02258697e-01f, 2.13270467e-02f, 1.29136920e-01f, 1.04382196e-02f, 8.29405617e-03f, 6.84159063e-03f, -1.86589912e-01f,
  -9.43783596e-02f, 2.04259261e-01f, 2.51337308e-02f, -1.86224505e-01f, -3.28422040e-02f, 2.17605308e-01f, 1.80784807e-01f, 1.07820094e-01f, 2.03357022e-02f, 7.36851543e-02f,
  9.29745380e-03f, 8.69938545e-03f, 7.06396848e-02f, 1.62088960e-01f, 2.98395485e-01f, 1.26869410e-01f, -1.49501219e-01f, -2.84393430e-01f, -1.81629863e-02f, -1.11136876e-01f,
  1.13106236e-01f, -9.17221904e-02f, -1.76354796e-01f, 1.73523650e-01f, -3.12792689e-01f, 2.14781433e-01f, 1.82002127e-01f, -7.31944386e-03f, 4.23335999e-01f, -1.19375691e-01f,
  8.24363232e-02f, 1.12327464e-01f, -3.44675779e-01f, 3.06217015e-01f, -1.72277335e-02f, -1.31284863e-01f, 4.01831865e-02f, -1.49127701e-02f, 6.89854100e-02f, -1.69446141e-01f,
  -1.39101490e-01f, 2.53926292e-02f, -1.14774760e-02f, 8.93498361e-02f, 2.02073306e-01f, 1.04688883e-01f, 3.28585021e-02f, -2.84894282e-04f, -2.60623068e-01f, -1.49557367e-01f,
  7.55319074e-02f, -8.04746822e-02f, 1.57272086e-01f, 1.57585680e-01f, 7.10481703e-02f, -3.59406769e-01f, 7.02137575e-02f, -2.12643400e-01f, 1.49306163e-01f, -6.62479596e-03f,
  2.26158299e-03f, -6.74313977e-02f, 1.14683427e-01f, 3.35947648e-02f, 1.52518749e-01f, -2.02054940e-02f, 1.40931740e-01f, 2.33287618e-01f, 6.31309748e-02f, 4.78024781e-02f,
  -3.12976599e-01f, -9.60680936e-03f, 1.70389175e-01f, 1.67984828e-01f, 1.93741694e-01f, 1.49443641e-01f, -8.88961777e-02f, 1.35802612e-01f, -4.09703314e-01f, -5.33263125e-02f,
  1.23701997e-01f, 3.27301323e-01f, 3.08039218e-01f, 4.45449203e-01f, -1.89583555e-01f, -3.01150791e-02f, 7.40974993e-02f, -1.08257815e-01f, 2.44540483e-01f, 1.23647779e-01f,
  1.19577840e-01f, 1.56776696e-01f, 2.64802463e-02f, 2.27353454e-01f, -1.22809619e-01f, -5.50260991e-02f, -2.58783132e-01f, -4.44376608e-03f, 4.78483550e-02f, 6.62698299e-02f,
  3.17256659e-01f, 5.07261515e-01f, 2.62479782e-02f, 3.37238908e-01f, -9.23922136e-02f, 6.88041523e-02f, -1.26946426e-04f, 1.54727221e-01f, 1.38446644e-01f, -3.38100977e-02f,
  6.79385811e-02f, -7.96105862e-02f, 2.62781262e-01f, -3.34293127e-01f, -2.22250611e-01f, 2.53797695e-03f, 6.84053004e-02f, 1.76991418e-01f, 2.21648052e-01f, -7.71874115e-02f,
  -9.32805538e-02f, 1.53906852e-01f, -2.66571576e-03f, -1.64779872e-02f, -1.07434809e-01f, -4.09796573e-02f, -3.36697876e-01f, 3.89352530e-01f, -1.07369065e-01f, -5.63604385e-02f,
  1.55834764e-01f, 1.12631783e-01f, 8.80712345e-02f, -2.81329662e-01f, -4.03437838e-02f, 2.27687918e-02f, -2.22400315e-02f, -1.98443487e-01f, 2.41314948e-01f, 1.49268910e-01f,
  -1.07782014e-01f, 1.86853021e-01f, 1.81431025e-01f, 7.69433677e-02f, -1.16341989e-02f, -3.76699209e-01f, -3.03709581e-02f, 6.52718619e-02f, -2.99299181e-01f, -2.37219781e-01f,
  -1.27455890e-01f, 2.75574028e-01f, 1.67800173e-01f, 3.61077309e-01f, -3.53438631e-02f, 3.26060534e-01f, -7.38291666e-02f, 1.30373277e-02f, 5.22610098e-02f, -9.48863551e-02f,
  -6.46232516e-02f, -6.64607659e-02f, 2.54633814e-01f, 1.04746006e-01f, 7.62629807e-02f, -1.12179048e-01f, 2.52422631e-01f, 1.27015620e-01f, 1.23656087e-01f, 4.46083471e-02f,
  1.29979715e-01f, 1.05722714e-02f, 1.14950679e-01f, 7.08012059e-02f, -3.93230356e-02f, 1.31376684e-02f, 1.00519918e-01f, -2.00900108e-01f, 4.45417278e-02f, 2.45557114e-01f,
  2.57405173e-02f, -1.52066752e-01f, 2.53984243e-01f, -2.02620685e-01f, -2.27436218e-02f, 7.25006079e-03f, 1.69961900e-01f, -3.17817437e-03f, 2.59948475e-03f, -1.03448321e-04f,
  1.71752185e-01f, -1.18479901e-03f, 1.37320638e-01f, 1.91047303e-02f, -5.04997261e-02f, -1.06609747e-01f, -8.18450749e-02f, 8.11103135e-02f, -5.94381168e-02f, -1.54101908e-01f,
  9.24036428e-02f, 1.55383781e-01f, 1.48187771e-01f, -1.54575184e-01f, -9.75175798e-02f, -1.37492508e-01f, 5.11896890e-03f, -7.69115761e-02f, 7.96305016e-02f, 3.24043296e-02f,
  1.07504725e-02f, -4.04641293e-02f, 2.03264114e-02f, 1.24853134e-01f, 1.98667243e-01f, 1.19576581e-01f, -1.61476638e-02f, 1.45800620e-01f, -7.28865638e-02f, -1.55656382e-01f,
  -2.11059451e-02f, -4.78127636e-02f, 1.97258845e-01f, -1.03301294e-02f, -2.50736356e-01f, 1.22705929e-01f, 1.00185005e-02f, -2.93775052e-01f, -4.19882298e-01f, -1.18159294e-01f,
  -1.73926011e-01f, -2.92906851e-01f, -4.82783057e-02f, -2.02848434e-01f, -1.98981717e-01f, 2.01350376e-02f, 3.02454740e-01f, 8.41696933e-02f, 7.54632801e-02f, 5.86792082e-02f,
  1.34699956e-01f, 1.74231872e-01f, 1.04114823e-01f, -5.60655929e-02f, -2.91327655e-01f, 7.80036151e-02f, -1.09818153e-01f, -1.48897422e-02f, -1.06663413e-01f, 1.91138566e-01f,
  5.57267405e-02f, 9.20459162e-03f, 2.58862320e-02f, -6.33059144e-02f, 2.72525218e-03f, -9.84259248e-02f, 1.21790767e-01f, 9.49407816e-02f, 5.03627136e-02f, 1.18258476e-01f,
  7.66492961e-03f, 2.14236557e-01f, 5.25612384e-02f, 7.48557150e-02f, 2.80614244e-03f, 1.45167530e-01f, -8.02088005e-04f, 2.64203548e-01f, 1.45654112e-01f, 1.80330023e-01f,
  1.64499611e-01f, -3.22125703e-02f, 1.09815747e-01f, -9.67651308e-02f, 5.76810054e-02f, 6.98510855e-02f, 1.08537283e-02f, -1.80594608e-01f, 2.63361726e-02f, 2.18462631e-01f,
  1.20143488e-01f, 6.83473200e-02f, -1.25784725e-01f, -1.26520798e-01f, -1.11912593e-01f, -1.26526877e-01f, -1.04201369e-01f, -1.64914072e-01f, -1.86612502e-01f, 2.77130995e-02f,
  -4.77718003e-02f, -3.86386931e-01f, -3.09019059e-01f, -1.51256830e-01f, -4.73640822e-02f, -3.18566352e-01f, 3.44246142e-02f, -3.35465111e-02f, -1.78362459e-01f, 6.53189346e-02f,
  3.52108553e-02f, -1.01746626e-01f, 2.70424724e-01f, -5.54127768e-02f, -2.16688728e-03f, 1.30355656e-01f, 1.52442306e-01f, -6.50758967e-02f, -1.55369267e-01f, -1.96880586e-02f,
  -2.82226443e-01f, 2.11406320e-01f, -1.59932867e-01f, 1.39686063e-01f, -4.76619542e-01f, 1.31808832e-01f, 1.48198262e-01f, 7.93511793e-02f, 2.39251271e-01f, -1.73595905e-01f,
  -3.07010245e-02f, 2.32016832e-01f, 5.82064539e-02f, 1.07130833e-01f, 3.40881869e-02f, -6.66399077e-02f, 2.92025387e-01f, 2.64259994e-01f, -1.86476186e-01f, 1.17690094e-01f,
  1.87279209e-02f, -1.38607040e-01f, -3.84937018e-01f, -2.99180355e-02f, 1.99436575e-01f, 4.69870530e-02f, -6.58825859e-02f, 1.40256539e-01f, 1.61947951e-01f, -1.11627840e-01f,
  -1.65701974e-02f, -1.24551076e-02f, 9.85132456e-02f, -1.83904860e-02f, 2.35391065e-01f, 1.08988680e-01f, -9.66183022e-02f, 1.85281068e-01f, -1.35503277e-01f, -2.13780269e-01f,
  -5.67975678e-02f, -1.43456280e-01f, -3.06661606e-01f, -2.85628498e-01f, -3.39784771e-01f, -1.06032811e-01f, -4.70272213e-01f, 1.82633087e-01f, 3.73932868e-02f, 1.64561555e-01f,
  -4.47618186e-01f, 5.62292300e-02f, 5.06166071e-02f, 3.46577615e-01f, 1.33082569e-01f, -2.15366227e-03f, -1.54795662e-01f, 2.67910026e-02f, -3.85692604e-02f, -3.99536677e-02f,
  6.21709935e-02f, 2.25573987e-01f, 1.02046147e-01f, 2.95995116e-01f, -2.42966246e-02f, 1.25811204e-01f, 6.29306883e-02f, -2.70851273e-02f, -2.63944626e-01f, -2.77507246e-01f,
  2.47967988e-02f, 9.57059488e-02f, 1.27982693e-02f, -4.54161987e-02f, 2.01071247e-01f, -1.22299954e-01f, -1.37719303e-01f, 1.16565153e-02f, 3.83145288e-02f, -1.15987942e-01f,
  -2.80583370e-03f, 1.34364888e-01f, 4.00479995e-02f, 1.94985926e-01f, 4.84059043e-02f, 1.92874283e-01f, -2.99890429e-01f, -9.79277566e-02f, 2.90882111e-01f, -2.71911323e-01f,
  -5.72500750e-02f, -1.84650358e-03f, 3.41924220e-01f, 9.69040841e-02f, -4.74283285e-02f, -6.55388534e-02f, -4.58609238e-02f, -4.10349481e-02f, -2.41101384e-01f, -4.65977937e-03f,
  1.02621526e-01f, -7.98232779e-02f, 1.83385223e-01f, -7.13077784e-02f, -2.02081576e-01f, 3.86117697e-02f, 1.93009838e-01f, -1.11311398e-01f, -1.47733003e-01f, 5.33847809e-02f,
  8.14939365e-02f, 5.63326254e-02f, 6.27236664e-02f, 2.94094950e-01f, -1.09327078e-01f, 1.47186518e-01f, 3.40496600e-02f, -1.09609753e-01f, 2.19558045e-01f, -8.05912241e-02f,
  -5.40300384e-02f, 7.34569803e-02f, 7.22768456e-02f, 1.70858838e-02f, -1.88464520e-03f, -2.10054889e-01f, 7.31575042e-02f, -5.70630468e-03f, -2.57101711e-02f, -1.95982099e-01f,
  7.68026933e-02f, -2.99348999e-02f, -9.78041366e-02f, 1.02126375e-01f, -1.51217490e-01f, 3.96842211e-02f, -1.63832560e-01f, 1.79251894e-01f, -1.93978809e-02f, 9.92126986e-02f,
  5.38559929e-02f, -1.40428871e-01f, 7.13617504e-02f, -1.18458383e-01f, 7.83537403e-02f, 1.46016151e-01f, -1.57825425e-01f, 4.38187905e-02f, 1.66341346e-02f, 2.92892724e-01f,
  6.14931632e-04f, 2.83500046e-01f, -1.33333772e-01f, 1.02906145e-01f, -1.32111192e-01f, 1.31281644e-01f, -1.47452116e-01f, -4.74460274e-02f, 2.84782201e-01f, 5.45158535e-02f,
  -3.08887567e-02f, -4.24635038e-02f, 4.74333018e-01f, -2.21890062e-01f, -1.08009363e-02f, -2.13974878e-01f, -3.33128095e-01f, -2.86141753e-01f, -1.37597322e-01f, 2.17276514e-02f,
  2.34790713e-01f, -1.47329703e-01f, -2.26269856e-01f, -1.18059687e-01f, -1.75516810e-02f, -5.64545542e-02f, -3.38044047e-01f, -1.52583823e-01f, 5.89510100e-03f, 2.99936365e-02f,
  1.82659060e-01f, 1.43403068e-01f, -2.56289393e-01f, -1.18538126e-01f, 2.57653564e-01f, -9.72049460e-02f, 2.34327897e-01f, 1.18584476e-01f, 1.65343568e-01f, 1.87016249e-01f,
  1.49216071e-01f, -4.99122357e-03f, -6.18413165e-02f, 1.13183223e-02f, 3.27702761e-02f, 6.33106306e-02f, -2.86101490e-01f, 8.11207220e-02f, 1.38069451e-01f, 1.79218844e-01f,
  8.20318088e-02f, 5.41656017e-02f, -1.71119452e-01f, 9.03931111e-02f, -1.80328563e-01f, 4.41455245e-02f, -1.63445562e-01f, -1.17176346e-01f, 2.48317346e-01f, 8.58217105e-02f,
  -1.85023859e-01f, 2.18812957e-01f, 6.39571548e-02f, -2.67735332e-01f, -1.15408450e-01f, -2.06004933e-01f, 2.85526109e-03f, 1.15925074e-01f, 1.04490608e-01f, 9.44280252e-02f,
  8.30362514e-02f, -2.41397843e-02f, 2.47475915e-02f, 1.57022342e-01f, 1.91030353e-01f, 1.30116254e-01f, 3.47349435e-01f, 1.12295605e-01f, -9.52266809e-03f, 1.86444134e-01f,
  -4.45454448e-01f, 1.73688382e-01f, -1.57745451e-01f, -1.05409257e-01f, 4.01790172e-01f, 8.00061598e-02f, 2.58361608e-01f, 7.16014132e-02f, -4.46361959e-01f, 3.50685306e-02f,
  -1.43326491e-01f, -1.57990038e-01f, 2.05637097e-01f, -1.17325991e-01f, -1.73898801e-01f, -2.34404057e-01f, -2.14196116e-01f, 1.79176971e-01f, 1.61983818e-01f, 1.86873019e-01f,
  2.46323720e-01f, 3.69423896e-01f, 2.95575619e-01f, -1.75381541e-01f, -2.74174958e-01f, -2.77863264e-01f, 1.83720186e-01f, 8.12803674e-03f, 6.02444969e-02f, -2.14651465e-01f,
  4.32365527e-03f, 2.60352373e-01f, -9.97404158e-02f, 1.31485522e-01f, -2.39129402e-02f, -3.00589263e-01f, 7.33872876e-02f, 2.60987312e-01f, -9.06573515e-03f, 2.14987211e-02f,
  5.06587960e-02f, 9.63909477e-02f, -2.12829504e-02f, 3.57878990e-02f, -1.81301177e-01f, 2.04109117e-01f, 4.15916881e-03f, -8.32487792e-02f, 9.89010483e-02f, 3.18204463e-02f,
  -3.09418142e-01f, 1.05519168e-01f, 3.19960453e-02f, 4.39841002e-02f, 1.11680232e-01f, -2.90977508e-02f, 1.33507684e-01f, 7.37120286e-02f, 1.01304494e-01f, 3.19810547e-02f,
  -2.23547563e-01f, 8.18193033e-02f, -3.32214348e-02f, 2.40063906e-01f, 2.32056975e-01f, 1.32341027e-01f, -2.84140974e-01f, -1.94157362e-02f, 4.06210460e-02f, -2.04348996e-01f,
  1.09084427e-01f, -1.83155574e-02f, 2.82131247e-02f, 1.29452839e-01f, 6.18994385e-02f, 2.81684492e-02f, 3.84461343e-01f, 1.51634470e-01f, -2.72489302e-02f, -3.61042097e-02f,
  1.91794962e-01f, 2.81534821e-01f, 1.47387953e-02f, 2.16920018e-01f, 1.02192700e-01f, -2.27751613e-01f, -1.44712731e-01f, -1.84315681e-01f, -1.24970444e-01f, -1.68917164e-01f,
  -5.21900058e-02f, -2.34807152e-02f, -9.07493606e-02f, -1.61750734e-01f, -2.71386623e-01f, 1.05645366e-01f, -1.87410355e-01f, 1.56236261e-01f, 1.44360557e-01f, 8.44587982e-02f,
  3.00371833e-02f, 1.75597236e-01f, 3.31845045e-01f, 1.58206955e-01f, 2.81150997e-01f, 1.92143731e-02f, -8.83478001e-02f, -2.30498426e-03f, -1.10004768e-02f, 4.86762300e-02f,
  2.08839282e-01f, -1.55728653e-01f, -1.42754577e-02f, 2.95003444e-01f, 2.05559023e-02f, 1.46999359e-01f, 2.69366857e-02f, 5.66442236e-02f, 1.25892803e-01f, 4.12456781e-01f,
  -2.02816110e-02f, 2.56890263e-02f, 1.22516654e-01f, 2.64049232e-01f, -2.71876067e-01f, 3.27255279e-01f, 2.74936592e-05f, 1.52539939e-01f, 1.62517399e-01f, 3.91011417e-01f,
  8.32251459e-02f, -4.07367721e-02f, 1.59043729e-01f, 2.44851217e-01f, 2.01764256e-01f, 1.18867643e-01f, -2.16000259e-01f, 7.29602575e-02f, -1.75124698e-03f, 1.38818640e-02f,
  1.35511920e-01f, -2.02591181e-01f, -1.38267264e-01f, -5.13142586e-01f, 1.05826057e-01f, 7.74071664e-02f, -7.93097988e-02f, 2.18957797e-01f, 1.37466535e-01f, 6.39365315e-02f,
  9.50699206e-03f, 5.16958237e-02f, -1.01352088e-01f, 1.75013635e-02f, 2.37850606e-01f, 4.10736166e-02f, -9.77292508e-02f, -2.82761812e-01f, -4.05706502e-02f, 7.83757344e-02f,
  -2.93726742e-01f, 2.34270114e-02f, -1.14841938e-01f, -3.18370640e-01f, -8.48584995e-02f, 1.82997525e-01f, -4.41142172e-02f, -1.99420899e-01f, -1.26899123e-01f, -2.72645026e-01f,
  1.39848009e-01f, 2.66136210e-02f, 1.63172588e-01f, -8.65644366e-02f, -2.22358912e-01f, 4.08432364e-01f, 2.05368504e-01f, 2.57172346e-01f, -2.98950732e-01f, 1.27764866e-01f,
  -2.26198241e-01f, 5.08808345e-02f, -1.39895007e-01f, -8.42787325e-02f, 3.43155891e-01f, 1.06347390e-01f, 1.10281885e-01f, -1.58635959e-01f, -3.18645611e-02f, 5.12237847e-02f,
  -1.39766395e-01f, -8.75338688e-02f, 9.12375152e-02f, -7.36922696e-02f, 2.20633149e-01f, 1.46846905e-01f, 9.97393727e-02f, -2.63679195e-02f, -7.39876404e-02f, -5.01025617e-02f,
  1.31751016e-01f, -3.31353426e-01f, -8.78217146e-02f, -2.29213372e-01f, 1.16357349e-01f, -3.46041054e-01f, -1.04340240e-01f, -7.95125142e-02f, 2.02348679e-01f, -1.35245711e-01f,
  -2.84019202e-01f, -1.82084829e-01f, -1.08369328e-01f, 9.11690965e-02f, -1.03464998e-01f, -3.57008666e-01f, -4.67570275e-01f, 7.23359585e-02f, -2.48928756e-01f, 3.25696617e-02f,
  -3.40015769e-01f, 2.14635596e-01f, -7.41963387e-02f, 2.18191762e-02f, 9.92761832e-03f, -8.67788866e-02f, 1.20017482e-02f, -7.16190925e-03f, 8.43338147e-02f, 1.44929381e-03f,
  -3.13005894e-01f, -1.43420860e-01f, -1.02748469e-01f, 7.09977187e-03f, 1.90294266e-01f, -8.38556737e-02f, -1.84587196e-01f, -2.11695611e-01f, -2.16252342e-01f, 9.29287300e-02f,
  1.40694991e-01f, 2.01564789e-01f, -1.20523468e-01f, 2.11165771e-01f, 3.02051827e-02f, 2.16076493e-01f, 1.10460259e-01f, -3.55904885e-02f, 5.98799177e-02f, 1.41261011e-01f,
  2.06141770e-01f, -1.48817137e-01f, 3.36551130e-01f, 2.01292112e-02f, -2.48785019e-01f, 2.46915191e-01f, -1.30567640e-01f, -3.78757641e-02f, 2.70877570e-01f, 3.71443667e-02f,
  -1.51503876e-01f, -3.44579443e-02f, 1.04406729e-01f, 3.42060737e-02f, -7.02176392e-02f, 7.59527972e-03f, -2.62416929e-01f, -5.09407111e-02f, 1.21761197e-02f, -2.03489900e-01f,
  1.37925401e-01f, 2.22280636e-01f, 1.35827765e-01f, 4.97013777e-02f, -2.04289541e-01f, -9.40908343e-02f, -6.05884939e-02f, -6.47503361e-02f, 2.28979532e-02f, 9.23103839e-02f,
  -8.93169455e-03f, -1.04587965e-01f, -1.97397217e-01f, 3.64389867e-01f, 5.14323004e-02f, 1.62831873e-01f, -2.00363159e-01f, -2.01394364e-01f, 3.27245653e-01f, 5.42917438e-02f,
  3.21711242e-01f, -7.24703297e-02f, -2.06996035e-02f, -1.12961806e-01f, -1.48186967e-01f, 1.18464809e-02f, -1.16718017e-01f, 7.14217499e-02f, -5.47271594e-02f, 4.78506908e-02f,
  2.49119237e-01f, 1.45637795e-01f, -1.78767905e-01f, -7.53138736e-02f, 1.05143666e-01f, 1.49424508e-01f, 2.57611185e-01f, -1.47523656e-01f, 2.68125981e-01f, 9.17333513e-02f,
  3.79444398e-02f, 4.00468826e-01f, -9.04503539e-02f, -1.71556175e-01f, 1.65839106e-01f, 3.21663693e-02f, -2.47109875e-01f, 1.09099276e-01f, 1.09390303e-01f, -5.96764572e-02f,
  -5.40068373e-02f, 3.70987326e-01f, -1.84017792e-02f, -1.03227019e-01f, -1.12782955e-01f, 2.11479902e-01f, 6.72553182e-02f, -1.85167626e-01f, -4.22983766e-02f, 9.87599716e-02f,
  -1.59884423e-01f, -2.40555890e-02f, 1.65717989e-01f, 1.60455376e-01f, 9.09336284e-02f, 7.75131434e-02f, 1.22432694e-01f, 1.31124184e-02f, 9.68961418e-02f, -3.27751972e-02f,
  2.68926740e-01f, 1.74608096e-01f, -2.51512796e-01f, 5.02761863e-02f, -5.98335378e-02f, -1.06991746e-01f, 8.50272477e-02f, 4.32176255e-02f, -1.21349797e-01f, 1.74890563e-01f,
  -2.70414446e-02f, 6.63839877e-02f, -7.14250505e-02f, -1.13568470e-01f, -8.77200514e-02f, 1.88656881e-01f, -2.69915879e-01f, 1.57044008e-01f, -1.96759403e-02f, -6.20746687e-02f,
  -6.08114451e-02f, -1.32729411e-01f, 1.10717759e-01f, 2.82134175e-01f, -4.33162749e-02f, -4.01094109e-02f, 1.08593561e-01f, 7.27160322e-03f, -1.91673748e-02f, 1.71194717e-01f,
  6.73258007e-02f, 8.80436748e-02f, -1.76935762e-01f, -1.47305086e-01f, 3.95586677e-02f, -9.37977433e-02f, 8.56457502e-02f, -1.62342384e-01f, -9.72317159e-02f, -1.94797382e-01f,
  -1.07230388e-01f, -1.27217710e-01f, -1.83018595e-02f, 8.75678658e-02f, 4.25922364e-01f, -1.90353975e-01f, -1.46110028e-01f, -6.67872727e-02f, -9.23051015e-02f, -1.96929663e-01f,
  2.26568859e-02f, -8.71006846e-02f, 1.21493943e-01f, -2.02699766e-01f, 1.89766541e-01f, -9.71746892e-02f, 4.99242805e-02f, 3.84476811e-01f, 1.11975305e-01f, 2.02834725e-01f,
  2.25533247e-01f, 1.85557678e-01f, 2.63696790e-01f, -6.67867204e-03f, -2.14846343e-01f, -1.85793877e-01f, -1.25054479e-01f, -1.86958462e-01f, 1.16228566e-01f, -1.42253652e-01f,
  -8.56267214e-02f, -1.21938795e-01f, 4.23546359e-02f, 5.76215535e-02f, -1.72543764e-01f, 4.28235866e-02f, 5.45854773e-03f, 1.90631196e-01f, 1.04523204e-01f, 1.26268983e-01f,
  -7.26514235e-02f, 3.48810256e-02f, 1.32732481e-01f, 2.37286940e-01f, 2.25484148e-01f, 8.43831897e-02f, -7.99031928e-02f, 1.68051873e-03f, 1.14470504e-01f, -4.16025706e-03f,
  3.19188625e-01f, 7.11413100e-02f, -1.18921092e-02f, 2.83793986e-01f, -3.91743109e-02f, 7.81351849e-02f, 5.50891347e-02f, 5.76115772e-02f, 7.52904564e-02f, -2.33025968e-01f,
  -1.53093025e-01f, 1.57353859e-02f, 2.19320342e-01f, -1.84958160e-01f, 2.80592322e-01f, -4.91856337e-02f, -4.63258997e-02f, 8.44792202e-02f, -1.13827236e-01f, -7.54794851e-02f,
  1.17137127e-01f, -1.48329899e-01f, 5.26541173e-01f, -2.06778973e-01f, -2.06458699e-02f, 9.14601609e-04f, 2.08884716e-01f, 3.10907215e-02f, -2.82913655e-01f, 1.19193114e-01f,
  1.57162085e-01f, -8.19744263e-03f, 1.58415234e-03f, 6.84455931e-02f, -1.77711755e-01f, 2.28929058e-01f, 2.82451689e-01f, -9.38444957e-03f, 9.81190503e-02f, 2.21106976e-01f,
  3.13803703e-01f, -1.42833248e-01f, -1.28981516e-01f, -2.57593215e-01f, -3.26199174e-01f, 1.25190660e-01f, -6.12460673e-02f, -1.36112887e-02f, 9.80310664e-02f, 1.81957349e-01f,
  2.03049630e-01f, 1.99455973e-02f, 5.30158132e-02f, 9.08135623e-02f, 9.00179818e-02f, -1.28075313e-02f, 1.24214992e-01f, -4.51302677e-02f, 1.05140008e-01f, -2.12384900e-03f,
  8.66399631e-02f, 6.54163510e-02f, -2.19107985e-01f, 1.42215565e-01f, 1.33746415e-01f, -3.69428664e-01f, 1.11111492e-01f, -4.69416603e-02f, -1.81260005e-01f, 2.49371789e-02f,
  -2.23342389e-01f, -1.39451146e-01f, 3.10431272e-01f, -9.38624740e-02f, -1.28628820e-01f, -2.62548119e-01f, -1.07343309e-02f, -1.85074024e-02f, 2.01924536e-02f, -7.68137723e-02f,
  4.73263534e-03f, -7.70059749e-02f, 1.03438623e-01f, -2.67409086e-01f, -8.94524679e-02f, -1.78431138e-01f, 1.88454643e-01f, 4.47287746e-02f, -5.62840067e-02f, 6.23862557e-02f,
  2.65890032e-01f, -1.46623552e-01f, 1.29932284e-01f, 3.35177809e-01f, -9.45893079e-02f, 1.75896674e-01f, 1.15512930e-01f, 1.19365990e-01f, 1.63637370e-01f, 1.08575724e-01f,
  1.87106043e-01f, -1.14596896e-02f, 4.25461754e-02f, -1.53100863e-01f, 5.18608913e-02f, 9.46827754e-02f, 5.73877431e-03f, 4.63155378e-03f, -1.35440573e-01f, -5.08772433e-02f,
  -4.64138277e-02f, 6.40033260e-02f, 1.11550443e-01f, 7.90721774e-02f, 1.30487144e-01f, -7.65212029e-02f, 1.08441841e-02f, 1.24274172e-01f, -9.37371105e-02f, -3.00485641e-03f,
  9.17670205e-02f, -7.05467537e-02f, -2.27396339e-02f, 3.84190073e-03f, -3.33023593e-02f, 1.88568175e-01f, -3.65055650e-02f, -1.00313146e-02f, 1.07226066e-01f, -2.59426069e-02f,
  7.09830299e-02f, -6.65642545e-02f, -1.98317870e-01f, -1.27567112e-01f, 7.98918977e-02f, -1.14737846e-01f, -1.37654096e-01f, 1.75892666e-01f, 6.56180382e-02f, 1.74237505e-01f,
  8.64183530e-02f, -6.14959188e-02f, 1.26268610e-01f, 1.47935688e-01f, 1.47149920e-01f, 1.19649343e-01f, -1.81744203e-01f, 2.64096677e-01f, -2.77081937e-01f, -4.84530181e-02f,
  5.26515581e-02f, -1.13573983e-01f, 1.52511457e-02f, 8.04079026e-02f, 2.62470156e-01f, 1.04352105e-02f, 1.70516014e-01f, -1.40227810e-01f, 3.70379806e-01f, 2.59342253e-01f,
  6.58145919e-02f, -1.83874041e-01f, 3.80863920e-02f, 1.23365633e-01f, -6.37574494e-02f, 1.61271289e-01f, 2.22597629e-01f, -5.07445596e-02f, -1.04256943e-01f, -5.34434430e-02f,
  -5.00434935e-02f, -3.00329059e-01f, -4.22256365e-02f, 1.77063882e-01f, -2.06638604e-01f, -2.95585711e-02f, 8.07507988e-03f, 2.62514234e-01f, -1.58291668e-01f, 7.53400698e-02f,
  -4.29913998e-02f, 2.19875470e-01f, 1.63024552e-02f, 1.75523106e-02f, 5.83408512e-02f, -8.94969553e-02f, 1.40548348e-02f, -6.40006438e-02f, 1.59928668e-02f, 7.10550770e-02f,
  1.91393599e-01f, -8.48995447e-02f, 1.10017873e-01f, -2.74427626e-02f, 2.04076469e-02f, 1.27776995e-01f, -6.06377088e-02f, 3.28402549e-01f, -8.20421707e-03f, -1.06195435e-01f,
  1.17413841e-01f, 3.85141671e-01f, 3.05223577e-02f, -1.93001971e-01f, -2.60466933e-01f, 2.39399016e-01f, 1.15412131e-01f, 1.95272252e-01f, -2.69457828e-02f, -1.64185148e-02f,
  -2.53667086e-01f, 1.76170394e-01f, 9.32052210e-02f, -5.42247333e-02f, -1.15848176e-01f, 1.29698962e-01f, -4.47919853e-02f, -8.97259824e-03f, 1.44094288e-01f, 2.09182486e-01f,
  -3.25388193e-01f, 2.77705371e-01f, -4.31605242e-02f, 6.08538371e-03f, 1.39110357e-01f, 8.24525207e-02f, -1.76907763e-01f, -1.32490680e-01f, 2.03188360e-01f, -1.86707273e-01f,
  2.06561893e-01f, -1.52071685e-01f, -1.25635758e-01f, 2.38578573e-01f, 1.44559056e-01f, 1.95482507e-01f, 1.52860135e-01f, 1.04421685e-02f, -9.82802287e-02f, 1.52481750e-01f,
  4.08838242e-02f, -1.29588753e-01f, -5.70003390e-02f, -3.43263566e-01f, -9.94206816e-02f, 1.39491335e-01f, -7.38285929e-02f, -1.16296478e-01f, -1.97722241e-01f, -1.14768058e-01f,
  -3.04917485e-01f, -2.46804506e-01f, 1.60548076e-01f, 7.63000026e-02f, -2.80943085e-02f, -2.83152126e-02f, 1.01666287e-01f, 1.64219692e-01f, -9.49997455e-02f, -3.25459927e-01f,
  -1.33978441e-01f, -4.20642287e-01f, -1.28442422e-01f, 6.50915653e-02f, 1.34912077e-02f, 6.10240251e-02f, 5.87340705e-02f, -5.63458167e-02f, -1.88978501e-02f, 1.51307821e-01f,
  1.63275562e-02f, -3.03183071e-04f, 1.33409262e-01f, -1.65259570e-01f, -4.48135845e-02f, 1.25862464e-01f, 3.11427921e-01f, 9.78514627e-02f, 4.87644486e-02f, 2.57107526e-01f,
  -4.56180945e-02f, 2.11650640e-01f, 2.35211983e-01f, 8.39861408e-02f, 2.02247268e-03f, 5.61347567e-02f, -3.21729928e-01f, -1.79155663e-01f, 2.48434812e-01f, 5.73268235e-02f,
  1.48718376e-02f, -9.64432210e-02f, -9.54690203e-02f, -2.18208820e-01f, 1.99508533e-01f, -1.12226985e-01f, 1.81474797e-02f, 1.56821012e-02f, -5.36477193e-02f, -6.75712666e-03f,
  1.79086342e-01f, 1.08459540e-01f, -1.25998065e-01f, 3.06002945e-01f, 5.40506504e-02f, -2.89507538e-01f, 2.27317035e-01f, -4.66918409e-01f, 1.49606228e-01f, 6.45900965e-02f,
  -1.77414447e-01f, -1.77759841e-01f, -1.83595613e-01f, -1.61025133e-02f, -2.10659936e-01f, 1.61144715e-02f, -2.86812726e-02f, -9.90181193e-02f, 4.10094531e-03f, -2.87603945e-01f,
  -7.15582892e-02f, 2.65046805e-01f, 4.57297191e-02f, 3.50419208e-02f, -6.66965619e-02f, -2.13228822e-01f, 7.14081153e-02f, 1.06940426e-01f, 2.13876337e-01f, -1.08287759e-01f,
  1.20627329e-01f, 5.87943085e-02f, 4.59134988e-02f, -3.95928361e-02f, 1.23353414e-01f, -8.04518908e-02f, -6.49104491e-02f, 2.53495306e-01f, -7.02879950e-02f, -1.48433194e-01f,
  -8.71143937e-02f, 9.40013006e-02f, 2.59759724e-01f, -3.36742759e-01f, 9.91174355e-02f, 2.07197204e-01f, -2.01507472e-02f, 9.37386677e-02f, -2.17402175e-01f, 2.73167849e-01f,
  -2.17998594e-01f, -1.71013117e-01f, -9.41387713e-02f, 1.65315077e-01f, 1.06029838e-01f, 1.42673001e-01f, 1.61352023e-01f, 5.49394861e-02f, 3.26548778e-02f, -2.41878559e-03f,
  1.92339763e-01f, 1.15360893e-01f, 7.99558535e-02f, 1.90581143e-01f, 1.05918594e-01f, -1.06450796e-01f, 2.75145203e-01f, -1.60028756e-01f, 7.23863319e-02f, -3.72295119e-02f,
  1.39159173e-01f, 1.39446139e-01f, -1.06657952e-01f, 2.32992340e-02f, 1.65806308e-01f, 2.50303578e-02f, 1.21558264e-01f, 1.09187782e-01f, 4.86519262e-02f, -1.39565244e-01f,
  -7.02974200e-03f, 1.90204039e-01f, -2.52168149e-01f, 1.36059955e-01f, 2.16595039e-01f, 7.35746622e-02f, 8.26997384e-02f, 4.14676107e-02f, 2.38347203e-02f, -1.50304928e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  2.09896266e-01f, -1.67277828e-01f, 1.69423632e-02f, -5.01165353e-02f, -2.87703127e-02f, 1.46521345e-01f, -4.03265841e-02f, 4.08399999e-02f, 2.13221200e-02f, 3.02320030e-02f,
  1.35493437e-02f, 1.29753128e-01f, -2.73198746e-02f, -1.31003857e-01f, 7.76552334e-02f, 1.80530548e-01f, 2.18807697e-01f, 2.17097610e-01f, 6.26505911e-02f, 1.24046594e-01f,
  1.01359978e-01f, -1.19585104e-01f, 3.61927710e-02f, -1.02108039e-01f, 1.20827474e-01f, 2.48413589e-02f, 2.00342774e-01f, 1.36154607e-01f, -1.51311636e-01f, -2.75664572e-02f,
  -1.29889240e-02f, 2.73011997e-02f, 1.96559653e-02f, -7.68124312e-02f, -2.70637833e-02f, 1.27257332e-01f, -2.95286700e-02f, 4.51506823e-02f, 6.16091490e-02f, 1.38012215e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -1.91675365e-01f, -1.09942541e-01f, -3.97867933e-02f, -1.53758466e-01f, -1.25237465e-01f, -1.89060271e-01f, -6.72909468e-02f, 1.36790797e-01f, 1.19954562e-02f, -5.89154325e-02f,
  -1.52488127e-01f, -1.05494052e-01f, -3.39145889e-04f, -2.18886301e-01f, -3.41067791e-01f, 1.76496744e-01f, 1.17657833e-01f, 2.82235704e-02f, -4.51216325e-02f, -1.92717507e-01f,
  -2.08006916e-03f, -1.83766261e-01f, 4.41410579e-02f, 5.10093383e-03f, 7.20680133e-02f, 1.99592173e-01f, 1.26812637e-01f, -2.42700824e-03f, 8.46816748e-02f, -2.44844750e-01f,
  -2.97355205e-01f, -1.15850918e-01f, -2.36243084e-01f, -2.36167297e-01f, -1.84270188e-01f, -1.56029329e-01f, -4.19905921e-03f, -2.94305325e-01f, -3.39268088e-01f, 7.84545019e-03f,
  -1.71511829e-01f, -1.64448962e-01f, -4.31449749e-02f, 2.19970480e-01f, -4.01878238e-01f, 1.13116980e-01f, 9.79213193e-02f, 1.76496461e-01f, -2.50941187e-01f, -5.56649268e-02f,
  -1.28864720e-01f, 1.41940817e-01f, 1.39203146e-01f, -1.70523345e-01f, 2.26402387e-01f, -3.50559235e-01f, -1.92729309e-01f, 1.82162941e-01f, 8.71977434e-02f, 7.13143647e-02f,
  1.04798861e-02f, 5.11346869e-02f, -7.51292855e-02f, 4.25583683e-02f, -1.21536097e-02f, -1.18748985e-01f, -2.07073420e-01f, -1.46616653e-01f, 2.67355144e-01f, 7.96726439e-03f,
  1.82959288e-02f, -1.36374339e-01f, -1.59404337e-01f, -3.10793053e-02f, 2.06424132e-01f, -9.12960917e-02f, 2.55693108e-01f, 2.11175919e-01f, 1.18955456e-01f, -8.98371711e-02f,
  -1.02947079e-01f, -1.90958738e-01f, 1.53768256e-01f, 2.44057015e-01f, 5.63910492e-02f, 7.95484148e-03f, -4.63794954e-02f, 4.14178520e-02f, 1.28416196e-01f, -3.99569608e-02f,
  2.35565174e-02f, -2.00826794e-01f, 1.39461368e-01f, 4.57477896e-03f, -2.07425937e-01f, -7.66862482e-02f, 1.28364503e-01f, 3.21137220e-01f, -2.46294141e-02f, 3.20964456e-02f,
  3.70771959e-02f, 4.70527168e-03f, -1.32605538e-01f, -2.44198516e-01f, 5.98423332e-02f, 1.88237920e-01f, 1.15836160e-02f, -1.53353006e-01f, -1.89656049e-01f, -1.55813284e-02f,
  -3.84962978e-03f, -1.44483268e-01f, 1.46587193e-01f, -7.55118057e-02f, 1.39194414e-01f, 1.21255361e-01f, -1.27446026e-01f, -3.03746402e-01f, -4.34448533e-02f, 6.54884204e-02f,
  -3.02537829e-01f, -7.53656775e-02f, 1.66067809e-01f, 2.93818448e-04f, -3.13491821e-01f, -3.08933086e-03f, 2.96463538e-02f, 2.05866814e-01f, 3.56802076e-01f, -1.40760645e-01f,
  -1.91679284e-01f, -1.15620732e-01f, 2.44887874e-01f, -7.22176861e-03f, -7.83140436e-02f, -2.78102756e-02f, 4.98063825e-02f, 2.17526972e-01f, -1.63340241e-01f, 1.19313963e-01f,
  2.79884219e-01f, 9.27863494e-02f, -1.95300803e-01f, -1.52830973e-01f, -4.40876298e-02f, -2.47871906e-01f, -4.35700305e-02f, 1.33747846e-01f, 2.66208440e-01f, 3.44469008e-04f,
  -7.66671151e-02f, -4.47556049e-01f, 2.73650050e-01f, -2.39799529e-01f, -5.19642569e-02f, 2.61996806e-01f, 1.68744028e-01f, -3.46612871e-01f, -7.07524195e-02f, -3.10420096e-01f,
  -4.23866093e-01f, -4.27567393e-01f, -3.67353758e-04f, -3.74875441e-02f, -9.94939730e-02f, -1.44322947e-01f, -2.00336903e-01f, -2.20479384e-01f, 1.30246198e-02f, -1.53188631e-02f,
  -3.52311075e-01f, 1.50918677e-01f, 5.66822328e-02f, -1.55156314e-01f, -1.80189788e-01f, -4.85214293e-01f, 3.09028268e-01f, 1.87573433e-01f, -5.56667984e-01f, -3.78014416e-01f,
  -6.70816302e-02f, -1.04574803e-02f, -1.08520659e-02f, -3.90600026e-01f, -3.22629958e-01f, 7.38478005e-02f, -1.35242894e-01f, 1.10069476e-01f, -2.55788684e-01f, -3.28942478e-01f,
  -3.72208059e-01f, 2.25209624e-01f, -3.92345816e-01f, -2.31768072e-01f, -1.70184568e-01f, 4.41412181e-02f, -7.82855451e-02f, -1.32889211e-01f, -4.66500334e-02f, -2.32914731e-01f,
  4.78321910e-02f, 6.71882108e-02f, 8.41491744e-02f, -6.78193122e-02f, 1.67550534e-01f, 6.90478012e-02f, -1.70544788e-01f, 6.97713420e-02f, 3.31586739e-03f, 4.91434447e-02f,
  7.60701746e-02f, -1.21812234e-02f, 1.21723197e-03f, -9.41872671e-02f, 1.97597146e-01f, -3.55355777e-02f, -3.47092181e-01f, -1.33300871e-01f, -6.21675029e-02f, -1.95900008e-01f,
  2.05332637e-02f, 2.60825045e-02f, 5.87684251e-02f, -3.84875178e-01f, -8.51306021e-02f, -1.35208994e-01f, -5.69048762e-01f, 7.28019178e-02f, -1.57666564e-01f, 1.84110731e-01f,
  -3.51904392e-01f, -2.51712650e-01f, -2.41259426e-01f, -6.67643011e-01f, 2.02096999e-02f, -1.82387784e-01f, -1.34222493e-01f, -2.13329196e-01f, 2.47994997e-02f, 2.42280796e-01f,
  -1.07157193e-01f, 9.30606723e-02f, 1.19205423e-01f, 6.16972661e-03f, 1.25145957e-01f, -3.92503113e-01f, -1.15968309e-01f, -1.56437784e-01f, 2.64129281e-01f, 1.49018914e-01f,
  1.54562980e-01f, 1.03643313e-01f, 7.85127059e-02f, -2.02390507e-01f, -2.58596927e-01f, -5.62742464e-02f, -1.09251030e-01f, 1.11806951e-02f, 1.10029988e-01f, 1.62932407e-02f,
  -3.15321207e-01f, -2.73179710e-02f, 3.89003605e-02f, -1.48504883e-01f, -2.91441262e-01f, -3.25172879e-02f, -8.33279639e-02f, 1.15895689e-01f, 1.40457168e-01f, 1.05667211e-01f,
  -8.29498693e-02f, 2.20986411e-01f, 2.77133465e-01f, 4.73615080e-02f, -2.92132162e-02f, -1.44210115e-01f, -3.57308537e-01f, 8.70100409e-02f, -1.59491226e-02f, 4.11039203e-01f,
  -2.07956344e-01f, 1.62347123e-01f, 1.01476535e-01f, -5.43861417e-03f, -3.87784362e-01f, -5.86640090e-02f, 2.46260818e-02f, -2.30179459e-01f, -2.44965136e-01f, -1.80672601e-01f,
  -1.81169324e-02f, -6.88917860e-02f, -1.38560329e-02f, -2.04027385e-01f, -4.66490649e-02f, -8.64428431e-02f, -1.25745356e-01f, 1.97735265e-01f, -7.59426737e-03f, -1.64687127e-01f,
  4.95556816e-02f, 8.22155476e-02f, -1.72651082e-01f, -2.43015647e-01f, -2.44794842e-02f, 4.11784127e-02f, -2.75268644e-01f, 6.36328459e-02f, 1.20983243e-01f, -1.09089851e-01f,
  -9.34472773e-03f, 1.58103064e-01f, 8.09641927e-02f, 5.82598485e-02f, 4.06620651e-03f, 8.55907872e-02f, 1.83844790e-01f, -1.28791705e-01f, 1.03012867e-01f, -1.13044605e-02f,
  -8.35455060e-02f, 6.52623698e-02f, 8.69319364e-02f, -3.08708269e-02f, 2.00509150e-02f, 3.31942439e-02f, -7.10125864e-02f, 4.93982583e-02f, 3.79549526e-02f, 1.54818609e-01f,
  8.75504389e-02f, -9.39927399e-02f, -9.75701138e-02f, 3.86893481e-01f, 1.80738553e-01f, 2.99208343e-01f, 7.49485120e-02f, -6.14565760e-02f, -3.19518805e-01f, -1.41566157e-01f,
  1.63818330e-01f, -1.17943414e-01f, 8.73817056e-02f, 2.07264587e-01f, 8.41119909e-04f, -1.00799061e-01f, 7.26277083e-02f, -2.87306696e-01f, 8.89362320e-02f, -2.45952040e-01f,
  -9.34007298e-03f, -9.64799076e-02f, -3.29622142e-02f, 1.10144354e-02f, 2.60991991e-01f, 1.51795477e-01f, -8.41384456e-02f, -1.55563951e-01f, 2.28078544e-01f, -2.58329928e-01f,
  3.54488790e-02f, -1.25742713e-02f, 1.44175202e-01f, -2.11434364e-01f, -2.77966619e-01f, -1.09605573e-01f, 1.44180223e-01f, -4.95614000e-02f, -1.88127398e-01f, 3.40278186e-02f,
  -2.20159516e-01f, 2.06709146e-01f, -8.41614138e-03f, 5.30755341e-01f, -2.73978144e-01f, -1.22153081e-01f, 7.14243874e-02f, -2.59792507e-01f, -9.55673307e-02f, -1.37520894e-01f,
  -1.63867086e-01f, -2.59934012e-02f, -2.51459777e-01f, 5.90972835e-03f, -2.82163501e-01f, 1.76329575e-02f, 3.80404741e-02f, 2.17625752e-01f, -2.26854369e-01f, -1.16604850e-01f,
  -9.35809389e-02f, 5.70741035e-02f, -5.91865508e-04f, 1.61350057e-01f, 1.39668316e-01f, -7.35178292e-02f, -2.52950806e-02f, -1.07609212e-01f, 1.22737914e-01f, -1.64846197e-01f,
  1.43773081e-02f, 1.07661776e-01f, 3.25230747e-01f, -9.01763886e-02f, 1.03523411e-01f, 7.37255299e-03f, 1.36319533e-01f, 1.70851856e-01f, 5.64656965e-02f, -2.44197682e-01f,
  -8.22740197e-02f, -7.04939961e-02f, -1.17123127e-01f, 5.92431165e-02f, 7.80334510e-03f, 2.01360375e-01f, -3.56656164e-01f, -2.21087247e-01f, 1.01158790e-01f, -3.18652064e-01f,
  1.94431111e-01f, -1.51061174e-02f, -2.19053566e-01f, 3.61214757e-01f, 1.86644360e-01f, -3.38090956e-02f, -3.83351117e-01f, 1.80650786e-01f, 1.74824446e-01f, 6.28532143e-04f,
  -1.69239696e-02f, -1.70017272e-01f, -1.47774741e-01f, -2.05396172e-02f, -3.92251581e-01f, -2.48890564e-01f, -6.01077080e-01f, -1.02837965e-01f, -3.38887870e-01f, -3.24864298e-01f,
  1.25375956e-01f, -6.07640371e-02f, -3.18298459e-01f, 1.50456876e-02f, -2.49362156e-01f, 1.27263263e-01f, 1.80021524e-01f, 7.89207071e-02f, 2.11919680e-01f, -1.71109468e-01f,
  -4.48460467e-02f, 5.35154305e-02f, -9.27730352e-02f, -1.44979641e-01f, 7.52044022e-02f, -7.70065710e-02f, -1.45990729e-01f, -7.29758441e-02f, -2.91135848e-01f, -1.50726840e-01f,
  3.38359714e-01f, -1.92509457e-01f, -1.23710006e-01f, -7.03126118e-02f, -1.11159563e-01f, -2.21261472e-01f, -1.77113190e-01f, 2.22521573e-02f, 8.48303884e-02f, 7.33771622e-02f,
  6.79465160e-02f, -1.91766843e-02f, 6.29011542e-03f, -3.90085310e-01f, -1.78768322e-01f, -2.57998616e-01f, 3.00880671e-01f, 1.75003067e-01f, -3.24799091e-01f, 1.65065229e-02f,
  -4.22209650e-02f, -4.29699570e-01f, -9.63458195e-02f, 4.37053703e-02f, 1.15142711e-01f, 8.41280594e-02f, -1.38775215e-01f, 1.53754443e-01f, -2.59421766e-02f, 5.25545552e-02f,
  5.52820750e-02f, -2.73395658e-01f, -6.95352405e-02f, -2.24789917e-01f, 1.77773938e-01f, -2.22521305e-01f, -1.97674528e-01f, -1.35416761e-01f, -2.18774959e-01f, -2.84962624e-01f,
  -1.06276777e-02f, -9.19824988e-02f, 4.08177584e-01f, 2.05840915e-01f, 4.50873822e-02f, -6.26023188e-02f, 1.15667060e-01f, -1.64477695e-02f, 5.53205013e-02f, -2.71588624e-01f,
  1.77748367e-01f, -2.42719099e-01f, 1.31762028e-01f, 7.85733908e-02f, 3.31522554e-01f, 4.25334722e-02f, -4.98798452e-02f, -3.51772979e-02f, 1.20345004e-01f, 2.93824881e-01f,
  -9.25762728e-02f, 2.57870674e-01f, -1.47726804e-01f, 2.56902337e-01f, -5.72947562e-02f, -3.17489445e-01f, 1.57513365e-01f, -2.74942666e-01f, -3.06134850e-01f, 4.31317568e-01f,
  -1.52353361e-01f, -2.53194422e-01f, 1.23627186e-01f, -4.34516259e-02f, 2.73837358e-01f, -3.62126380e-01f, 7.16433674e-02f, -3.50052565e-01f, -2.61594862e-01f, -1.87165484e-01f,
  -1.50656313e-01f, 2.20096111e-01f, -3.12618673e-01f, -2.80685216e-01f, -5.51332533e-02f, 9.31061059e-02f, -1.88091129e-01f, -2.36374602e-01f, 8.36705193e-02f, -2.26407692e-01f,
  3.89241427e-01f, 5.18395985e-03f, -3.45058411e-01f, -2.90587306e-01f, 6.49537444e-02f, -2.10959107e-01f, 2.02691287e-01f, -5.15442342e-02f, 1.42435312e-01f, 2.67103136e-01f,
  3.45343947e-01f, -3.04268032e-01f, 2.76899114e-02f, -1.75935984e-01f, -2.66550601e-01f, -2.20124349e-02f, -2.50355840e-01f, 2.12643474e-01f, 1.46984592e-01f, -1.04621805e-01f,
  -3.97998542e-01f, -2.39611894e-01f, -3.03253472e-01f, 9.86543447e-02f, 1.48008680e-02f, -2.74799485e-03f, 1.39414325e-01f, 1.49857849e-01f, 1.76997960e-01f, 1.59017310e-01f,
  1.72669694e-01f, 1.67760089e-01f, -1.79228172e-01f, 1.41360506e-01f, 1.86016724e-01f, -2.36917257e-01f, 1.37194209e-02f, 6.88029751e-02f, -2.02974319e-01f, 1.27173454e-01f,
  1.27986118e-01f, 2.86546618e-01f, -8.24183077e-02f, -1.88773587e-01f, 2.61209905e-02f, 2.56104589e-01f, -2.87880212e-01f, -1.44545436e-01f, -1.06602430e-01f, -2.11200953e-01f,
  -1.60532668e-01f, -4.00266916e-01f, -7.17176124e-03f, 1.39136180e-01f, -6.37749583e-02f, -2.08315998e-02f, 2.22049281e-01f, 9.84286983e-03f, -2.20042914e-02f, -1.50982097e-01f,
  1.73941895e-01f, -2.56286323e-01f, -2.95259804e-01f, 1.89508662e-01f, -1.17068306e-01f, -1.80663288e-01f, 1.82669371e-01f, 5.31315953e-02f, -5.50419092e-01f, 1.54521257e-01f,
  1.26056388e-01f, -2.29016114e-02f, -3.25602144e-01f, -1.73845768e-01f, -4.01006877e-01f, -3.72186787e-02f, -2.58615047e-01f, -5.42683184e-01f, 5.59569933e-02f, 2.68063601e-03f,
  -4.93241847e-02f, -6.26099184e-02f, 9.62612107e-02f, 1.08768776e-01f, -6.67765319e-01f, -9.87909660e-02f, 1.40850171e-01f, -2.73145109e-01f, -2.11809039e-01f, -6.12073056e-02f,
  1.85042188e-01f, -4.64211293e-02f, -7.37361312e-02f, -8.68302807e-02f, 3.59471105e-02f, -2.54546180e-02f, -1.69236183e-01f, -8.39705542e-02f, -1.69138163e-02f, -1.04543142e-01f,
  4.24701627e-03f, 9.87083241e-02f, -1.43790767e-01f, -4.44406420e-01f, 1.77678570e-01f, -4.22321379e-01f, 2.82304794e-01f, 2.66075492e-01f, -2.12152764e-01f, 1.24666758e-01f,
  9.62704048e-02f, -3.46908003e-01f, -2.07518607e-01f, 3.36318433e-01f, -3.88075233e-01f, -1.68882906e-01f, -2.88740396e-01f, -1.34133890e-01f, 2.32472330e-01f, -2.38640293e-01f,
  8.02059993e-02f, -2.31721640e-01f, 2.11765766e-01f, 2.39952207e-01f, -3.23542595e-01f, 1.59011930e-01f, -4.53222305e-01f, -1.43179432e-01f, -1.92827404e-01f, -1.61016449e-01f,
  -5.16930819e-01f, -4.99822617e-01f, 1.86048403e-01f, -1.96350321e-01f, -4.54755992e-01f, -1.06082670e-01f, 4.23728488e-03f, 2.82709628e-01f, -1.21904708e-01f, -3.19241226e-01f,
  2.30777115e-01f, 2.30007797e-01f, -3.05952638e-01f, -1.13115244e-01f, 1.77431017e-01f, -3.05905402e-01f, -8.16821754e-02f, -4.50243980e-01f, 1.21615924e-01f, -4.03857470e-01f,
  2.81550810e-02f, -2.06101701e-01f, -2.91431040e-01f, -5.36070645e-01f, -2.83383101e-01f, 1.63068756e-01f, -1.89999659e-02f, -2.22819388e-01f, 3.02141815e-01f, 1.79679200e-01f,
  1.91469491e-01f, -1.28350690e-01f, -1.13133583e-02f, 2.19434127e-03f, -1.08940616e-01f, -1.59175247e-01f, -4.91604619e-02f, -1.18474774e-02f, 1.02814427e-02f, -2.15947479e-01f,
  -6.50551990e-02f, 2.16478124e-01f, 1.79151297e-01f, 1.78406432e-01f, -3.79156351e-01f, -1.39787853e-01f, -1.59972847e-01f, -1.67582363e-01f, -2.88790077e-01f, -4.90820706e-02f,
  -3.47537875e-01f, -1.21312961e-01f, -2.84304410e-01f, 1.30844235e-01f, 1.64558873e-01f, 1.34044603e-01f, 1.23479597e-01f, -1.94601715e-01f, -2.45103508e-01f, 1.46649107e-01f,
  -2.81952888e-01f, 1.76124126e-01f, -4.23233472e-02f, -1.16725385e-01f, -2.55011141e-01f, 2.07903199e-02f, -1.97333097e-01f, -3.09691757e-01f, 1.45838678e-01f, 9.84565318e-02f,
  -3.83213192e-01f, -2.75189996e-01f, -1.61726922e-01f, -3.56429636e-01f, 6.47338033e-02f, -2.72377938e-01f, -2.57134706e-01f, 4.86123115e-02f, -1.25341773e-01f, -5.70916310e-02f,
  1.99384794e-01f, -3.62920880e-01f, 4.12642770e-02f, 6.25536367e-02f, 9.23443660e-02f, 3.78943354e-01f, 1.44357130e-01f, -1.05446227e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -3.60447355e-02f, 1.31233901e-01f, -3.63360904e-02f, -1.28688276e-01f, -4.39583473e-02f, 3.01040318e-02f, -7.66524896e-02f, -5.12083247e-02f, -1.29164271e-02f, 3.54750035e-03f,
  4.13377620e-02f, 7.67071906e-04f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    