/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.02073300e-01f, 3.20952207e-01f, -4.99139220e-01f, -3.20495129e-01f, 2.47245401e-01f, 1.93530396e-02f, 2.54971385e-01f, -7.19525889e-02f, -1.43860862e-01f, 1.27096489e-01f,
  6.50497526e-02f, 8.96125566e-03f, -1.00743480e-01f, 3.93562242e-02f, -1.68081909e-01f, 7.60460570e-02f, 1.06229641e-01f, -2.22771674e-01f, -2.60350436e-01f, 2.20604669e-02f,
  3.96806777e-01f, 5.76841496e-02f, -3.72721910e-01f, -9.00618061e-02f, 5.85267060e-02f, 7.13886768e-02f, -5.21820039e-02f, -5.63222207e-02f, 1.18401945e-01f, 2.64206797e-01f,
  -9.87998918e-02f, -1.54850841e-01f, -8.30475092e-02f, 3.53599563e-02f, 8.81352946e-02f, -2.38712989e-02f, 7.15388078e-03f, -8.08185115e-02f, 2.23368704e-02f, -7.91453794e-02f,
  -1.61048342e-02f, 1.48464190e-02f, -1.32249389e-02f, 6.82665110e-02f, 3.46419513e-02f, -2.65274458e-02f, -2.76746564e-02f, -1.86881423e-01f, -6.15869127e-02f, 5.38680516e-02f,
  3.25190306e-01f, 8.75576288e-02f, -1.71145588e-01f, 2.61627650e-03f, -4.85230200e-02f, -8.19366053e-02f, -1.13213949e-01f, -1.07277937e-01f, -1.68668106e-01f, -4.43534702e-02f,
  6.53553233e-02f, -5.71898483e-02f, -9.23168939e-03f, -1.40854763e-02f, 1.19121951e-05f, -6.58130646e-02f, 2.28302665e-02f, -3.42719723e-03f, 1.65581815e-02f, -1.50162848e-02f,
  -2.78519820e-02f, -1.49523159e-02f, -2.14344580e-02f, -6.44534826e-02f, -2.79486310e-02f, -7.32157826e-02f, 9.38747908e-05f, -3.70602049e-02f, -5.36532290e-02f, -2.28380468e-02f,
  -7.42995143e-02f, -2.95509724e-03f, -3.16007435e-02f, -2.77520753e-02f, -7.31800944e-02f, -1.06181011e-01f, -8.58767778e-02f, 4.18654755e-02f, -8.13383386e-02f, -2.76169032e-02f,
  6.75316751e-02f, -1.16787776e-01f, -9.54393968e-02f, -1.22061288e-02f, -5.19474447e-02f, 3.21717933e-02f, -6.00004522e-03f, -1.83922183e-02f, 1.45003879e-02f, -5.25220595e-02f,
  -1.71445962e-02f, -8.82256702e-02f, -1.09830536e-02f, 6.08541891e-02f, -3.97355631e-02f, -2.65108254e-02f, 5.12540080e-02f, 3.61915343e-02f, -2.53314003e-02f, -3.31244059e-02f,
  -1.69624723e-02f, 1.45000219e-02f, -8.49881619e-02f, -7.80357644e-02f, -5.76477647e-02f, -1.86784379e-02f, -3.05265896e-02f, -6.81259995e-03f, -1.58468843e-01f, 3.41500267e-02f,
  5.56784630e-01f, -4.80298176e-02f, -1.27815513e-03f, -5.88952973e-02f, 1.70977727e-01f, 4.09379482e-01f, 5.93058228e-01f, 1.85397297e-01f, -1.50082186e-01f, 1.36595387e-02f,
  -1.62034303e-01f, -3.64920676e-01f, -4.23234284e-01f, -3.05836976e-01f, 8.39010552e-02f, 2.58949697e-01f, 1.50473386e-01f, 8.37112591e-02f, 2.13207245e-01f, 2.94522166e-01f,
  1.90783858e-01f, 5.43410145e-02f, 5.96661232e-02f, -7.64707662e-03f, -5.38737848e-02f, -1.01491906e-01f, -1.54270962e-01f, -9.00537521e-02f, 4.35597375e-02f, -1.83962032e-01f,
  -9.51124355e-02f, -1.40097449e-02f, 1.93931013e-02f, -6.38189018e-02f, -9.46016610e-02f, -7.00381771e-03f, 8.52420703e-02f, -9.07907933e-02f, -4.94602276e-03f, -3.15502919e-02f,
  -4.18678857e-02f, -9.17168185e-02f, -5.47847990e-03f, -5.46801873e-02f, 8.95868167e-02f, 2.93934420e-02f, -9.33886543e-02f, -2.55121887e-02f, -1.05668239e-01f, -6.93197772e-02f,
  -4.60018925e-02f, 6.95683360e-02f, -7.32429931e-03f, -1.72332898e-02f, 3.85309011e-02f, 1.97769725e-03f, -8.71505961e-02f, 1.63102038e-02f, -8.05376917e-02f, -1.12181120e-01f,
  -5.55687360e-02f, 2.09473204e-02f, 6.14888072e-02f, -1.31328693e-02f, 2.80928668e-02f, -1.78256053e-02f, 7.26854661e-03f, 9.58878826e-03f, -1.67590752e-02f, 3.04218177e-02f,
  -2.48909071e-02f, 1.50816105e-02f, 1.34141492e-02f, 1.07411034e-02f, -3.23706344e-02f, 8.89772829e-03f, 1.06828704e-01f, 4.32863086e-03f, -5.10886572e-02f, 4.35867608e-02f,
  -7.62481019e-02f, 1.49032017e-02f, 2.43903548e-02f, -8.59663039e-02f, 6.12482131e-02f, -3.36295553e-02f, 1.39123965e-02f, 2.31967401e-02f, -1.77666526e-02f, 3.46115902e-02f,
  -1.18905313e-01f, -6.00568242e-02f, -7.43303895e-02f, -1.01371482e-01f, 8.28103535e-03f, -1.43094972e-01f, -1.29720226e-01f, -8.50078538e-02f, -5.39269932e-02f, 5.27341440e-02f,
  -2.75383964e-02f, -7.26605183e-04f, -8.77013206e-02f, 8.22458416e-02f, 2.18850281e-02f, -4.88658510e-02f, 1.43889738e-02f, 1.54261040e-02f, 6.61679311e-03f, 4.34120409e-02f,
  9.57156904e-03f, 2.68772952e-02f, 9.08185616e-02f, -7.23893149e-03f, -2.76398212e-02f, 1.66557983e-01f, 2.75718421e-02f, 3.49369980e-02f, 1.08956590e-01f, 8.91487971e-02f,
  -3.14020254e-02f, -7.87098259e-02f, 2.86719680e-01f, 5.05363166e-01f, 5.99259794e-01f, 8.66236836e-02f, -1.39566317e-01f, -2.68049687e-01f, 2.00731546e-01f, 1.98651806e-01f,
  8.62449314e-03f, 7.58045465e-02f, -3.32828164e-02f, -7.18371719e-02f, -4.35880035e-01f, 6.57314211e-02f, 1.75386131e-01f, 1.21990284e-02f, -9.33222845e-02f, -2.41665635e-02f,
  2.18372166e-01f, 1.92366987e-01f, -2.68342227e-01f, -1.59075022e-01f, 3.90748143e-01f, 1.78767085e-01f, 1.00953594e-01f, 4.14038114e-02f, -1.99607179e-01f, 6.00747764e-01f,
  2.89938420e-01f, -1.55610824e-02f, 9.93440300e-03f, -4.61364910e-02f, 1.50778323e-01f, -9.54974890e-02f, -1.02420986e-01f, -4.15254980e-02f, -6.26158267e-02f, 1.50516641e-03f,
  9.85455215e-02f, 1.47995157e-02f, -3.33159305e-02f, -3.56964320e-02f, 2.86343507e-02f, -2.82826331e-02f, -6.59711286e-02f, -1.34780020e-01f, 9.56501290e-02f, 1.47804944e-02f,
  1.88692093e-01f, 1.42894119e-01f, -3.78232971e-02f, -1.53931960e-01f, -6.61380142e-02f, 7.71541297e-02f, -5.15320338e-02f, -6.86998591e-02f, -6.93915784e-02f, 1.59662627e-02f,
  -2.83229072e-02f, 5.99075155e-03f, 8.66453815e-03f, 2.12551579e-02f, 3.86538655e-02f, 5.74415689e-03f, 1.06224485e-01f, 1.60954893e-02f, -1.25843603e-02f, -4.28290851e-02f,
  -3.29543347e-03f, 8.09466466e-02f, -4.72409214e-04f, -1.49150910e-02f, 5.36261983e-02f, -1.06817167e-02f, 6.08056784e-02f, -3.98758426e-02f, -2.43871436e-02f, -2.97748465e-02f,
  -9.74471215e-03f, 1.45711461e-02f, 7.72786215e-02f, 1.69801861e-02f, 5.62218055e-02f, 1.36866365e-02f, 6.51106760e-02f, -4.78104576e-02f, -6.68673664e-02f, -9.12546143e-02f,
  -2.03130409e-01f, -1.51067168e-01f, 1.22136608e-01f, -3.65302898e-02f, 6.02184050e-02f, -5.04740998e-02f, 9.63205323e-02f, 7.32356831e-02f, 1.01103202e-01f, 6.56076968e-02f,
  -4.59584109e-02f, -2.86116246e-02f, 4.14719731e-02f, -3.64624523e-02f, 4.03026007e-02f, 9.85997915e-03f, 2.34450344e-02f, 1.77388787e-01f, 2.88033634e-02f, 9.14793834e-02f,
  1.43717788e-02f, -1.20440714e-01f, -1.45607576e-01f, 1.58649520e-03f, -4.03685234e-02f, -3.60808223e-02f, -1.05728649e-01f, 5.75221106e-02f, -1.06980145e-01f, -2.01236576e-01f,
  -6.31131411e-01f, 7.98412487e-02f, 2.47055531e-01f, -1.61455765e-01f, 1.34081498e-01f, 2.14986026e-01f, 3.70565087e-01f, 4.93548773e-02f, -7.15376884e-02f, 1.52573571e-01f,
  -9.70002264e-02f, -2.52757937e-01f, -6.45199642e-02f, 1.00310996e-01f, -7.97989368e-02f, 4.62966979e-01f, 4.71795022e-01f, -9.86407548e-02f, -2.95376293e-02f, -4.35907021e-02f,
  3.21910270e-02f, -2.10065797e-01f, -4.25166309e-01f, -4.44307588e-02f, -2.55115535e-02f, -4.90682833e-02f, 2.09915161e-01f, -1.38937056e-01f, -4.90388740e-03f, 1.46376416e-01f,
  3.90439760e-03f, -3.56401093e-02f, 3.14328335e-02f, -9.86497477e-02f, -3.93769257e-02f, -5.18925600e-02f, 1.86878331e-02f, -9.83691216e-02f, -5.53070679e-02f, 1.39294760e-02f,
  -2.01457608e-02f, -4.00419421e-02f, -5.46529256e-02f, -1.19336061e-02f, -6.06184788e-02f, 2.44816300e-02f, 3.10246833e-02f, 7.14704813e-03f, 8.81507322e-02f, 9.86049771e-02f,
  1.27212241e-01f, -3.63728590e-02f, 9.92139801e-03f, 8.79213214e-02f, 8.39630365e-02f, -2.74577830e-02f, -7.28983581e-02f, -2.21147109e-02f, 3.95877324e-02f, -5.33694401e-02f,
  2.09323335e-02f, -1.01840608e-02f, 2.94654276e-02f, -7.91760627e-03f, 7.51254009e-03f, 2.09757350e-02f, 6.20641783e-02f, 9.13076662e-03f, 2.77314242e-02f, -4.88443449e-02f,
  -6.63122488e-03f, 3.42317000e-02f, -6.47006882e-03f, -1.39447693e-02f, -6.10010792e-03f, 2.61606388e-02f, -1.14602065e-02f, 1.59636922e-02f, -4.39348631e-02f, -1.76237263e-02f,
  -3.48905176e-02f, -3.77378315e-02f, 1.02502238e-02f, -4.35901135e-02f, 4.31363247e-02f, 1.25544704e-02f, -5.25418017e-03f, 1.85987819e-02f, 1.20341722e-02f, -5.05481809e-02f,
  -1.34701252e-01f, 7.68323541e-02f, -3.39474492e-02f, 2.32574847e-02f, 3.41923372e-03f, -3.46204303e-02f, -4.32722233e-02f, 4.49046120e-02f, -2.07276344e-02f, 1.35883149e-02f,
  -1.36646386e-02f, 2.91533712e-02f, 1.19358478e-02f, -1.03030102e-02f, -2.77889706e-02f, 3.57700326e-02f, -2.74566449e-02f, -8.57098922e-02f, 2.95412075e-02f, -1.91524401e-02f,
  1.18988696e-02f, 7.97643289e-02f, -2.27199569e-02f, 9.08268802e-03f, 1.38954527e-03f, 8.62558652e-03f, -9.12497193e-03f, 2.71963328e-02f, 1.13477129e-02f, -2.79687885e-02f,
  -1.54333860e-01f, 3.18511516e-01f, 5.35936296e-01f, -1.19531244e-01f, 3.23182434e-01f, 2.79846847e-01f, 4.71273214e-01f, -2.28001460e-01f, -3.34306270e-01f, -1.67944655e-02f,
  3.14732969e-01f, 9.00216550e-02f, -3.62659059e-02f, 1.14669530e-02f, -2.89852452e-02f, 4.05228231e-03f, -2.63638664e-02f, 3.11420802e-02f, -9.68294963e-02f, -5.61321564e-02f,
  2.83945389e-02f, -3.15956250e-02f, -1.76418141e-01f, -8.91977698e-02f, -9.45775360e-02f, -5.95480502e-02f, -2.61997301e-02f, 5.84075153e-02f, -1.88438576e-02f, 2.67713308e-01f,
  3.00679237e-01f, 3.97739708e-01f, -6.20923936e-02f, 9.96329039e-02f, 1.78494215e-01f, -8.05217475e-02f, 1.11953996e-01f, 4.85970341e-02f, 1.37329428e-02f, 8.75561610e-02f,
  1.89523369e-01f, 1.38383761e-01f, 2.45317310e-01f, 2.60523818e-02f, 1.61881614e-02f, 6.31586015e-02f, -1.17571607e-01f, 1.03881404e-01f, -7.38185048e-02f, -2.73547526e-02f,
  1.56674966e-01f, 2.38805130e-01f, 2.21053749e-01f, 3.94135788e-02f, 8.62298757e-02f, 1.45963714e-01f, 1.00341715e-01f, -2.62242183e-02f, 3.78363989e-02f, -5.34126684e-02f,
  -1.14738747e-01f, 5.00743501e-02f, -1.26378331e-02f, 4.46604118e-02f, -8.49317461e-02f, -1.89001188e-02f, 4.76223044e-02f, 4.15974203e-03f, 3.20556797e-02f, -6.17764294e-02f,
  4.64830957e-02f, 1.74019183e-03f, 4.80826851e-03f, 7.44847432e-02f, -6.79111341e-03f, 1.29143847e-02f, 1.30017502e-02f, -9.66340750e-02f, 1.47085609e-02f, -2.87187155e-02f,
  6.79949904e-03f, 8.96814372e-03f, 6.28445223e-02f, -5.62626459e-02f, 3.38697322e-02f, 8.23937804e-02f, -1.25249764e-02f, 4.07688990e-02f, 7.41185546e-02f, 3.28201950e-02f,
  -3.87591004e-01f, 1.19732805e-01f, -9.04269964e-02f, -9.25190598e-02f, 5.13643585e-02f, -1.24117965e-02f, 8.38444848e-03f, 5.59039414e-03f, 1.74048498e-01f, 7.48462230e-02f,
  1.59702882e-01f, 1.82546079e-02f, 2.50545498e-02f, 2.42158342e-02f, 5.29507510e-02f, 7.88230263e-03f, -5.69559857e-02f, 1.10717192e-02f, 6.39023036e-02f, -7.22655505e-02f,
  -1.00465350e-01f, -1.14064939e-01f, -6.07793666e-02f, 3.11410334e-02f, 1.43598523e-02f, -2.24037860e-02f, 4.87497002e-02f, -1.86916459e-02f, 1.94552615e-02f, -3.01207691e-01f,
  5.52421153e-01f, 4.07139957e-01f, -1.02142163e-01f, 2.38494933e-01f, -1.17135175e-01f, -9.04108211e-02f, 2.77730584e-01f, 1.47910446e-01f, 4.05904762e-02f, 1.21217087e-01f,
  -5.84576242e-02f, -2.65270919e-01f, -2.59533554e-01f, -2.10290447e-01f, -6.46254141e-03f, 1.24984771e-01f, -2.89868079e-02f, -1.29185572e-01f, -2.92038530e-01f, -1.27515554e-01f,
  -2.04434484e-01f, 4.98512015e-02f, 4.18178551e-02f, -1.63802207e-01f, 1.89352274e-01f, -2.31285647e-01f, 7.52910823e-02f, 1.41095519e-01f, -6.03817217e-02f, 2.18248814e-02f,
  -4.58705686e-02f, 3.09097677e-01f, -1.69758171e-01f, -1.36459721e-02f, 7.27452561e-02f, 8.15885067e-02f, -1.27226822e-02f, 8.27251971e-02f, 1.48090888e-02f, 1.79875623e-02f,
  -9.63388570e-03f, 5.42526226e-03f, 9.76049528e-03f, -4.32156250e-02f, 8.69230255e-02f, 6.27266094e-02f, 7.22805858e-02f, 4.95531969e-02f, 5.32511882e-02f, 1.42537337e-02f,
  -5.81208579e-02f, -1.73628777e-02f, 1.07491389e-01f, 6.91370443e-02f, 4.35402691e-02f, -2.80739330e-02f, 6.74126074e-02f, -8.64206441e-03f, -1.36391208e-01f, 5.68271019e-02f,
  -9.13728902e-04f, -5.02180308e-02f, -7.70317530e-03f, 4.04818729e-02f, -2.80575287e-02f, -3.66274230e-02f, 8.45272280e-03f, 1.69188378e-03f, -3.62103023e-02f, 8.16071592e-03f,
  -8.47375616e-02f, 6.38007000e-02f, -2.11866554e-02f, 7.80505463e-02f, -7.49109089e-02f, -1.80850981e-03f, 1.51188187e-02f, 6.89011300e-03f, -2.34414432e-02f, 2.23695636e-02f,
  -6.42054016e-03f, -5.18341251e-02f, 5.27105443e-02f, 4.02212795e-03f, 1.31969666e-02f, -3.24726850e-02f, 5.87357441e-03f, 1.35919387e-02f, -1.22394916e-02f, -7.45739276e-03f,
  5.44850975e-02f, -1.16255872e-01f, 8.71975496e-02f, -1.62787586e-02f, 3.88744771e-02f, -1.25249326e-02f, -6.69955136e-03f, -4.34301011e-02f, 6.10702904e-03f, 7.43075460e-02f,
  2.48216186e-02f, -2.15304978e-02f, 2.23092362e-02f, -5.10089844e-02f, -3.62702794e-02f, 3.40826530e-03f, -4.44258563e-02f, -3.99218798e-02f, 4.33659591e-02f, 2.87454929e-02f,
  -1.96393151e-02f, 2.54649054e-02f, 3.53062786e-02f, 1.65165998e-02f, 6.54647499e-02f, -1.24619752e-01f, 1.26807373e-02f, 2.19441447e-02f, 3.33698420e-03f, 1.33556813e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.27654923e-02f, 3.22994113e-01f, 6.22246087e-01f, 2.16943502e-01f, -3.65305394e-01f, -3.54635358e-01f, -1.73137397e-01f, -1.12066060e-01f, -7.15586022e-02f, -5.60267009e-02f,
  -3.81303579e-01f, -1.34096175e-01f, -5.17091937e-02f, 1.92920744e-01f, 2.88064837e-01f, 1.21236853e-01f, 5.07879436e-01f, 5.94033420e-01f, 1.66155279e-01f, -2.92503417e-01f,
  -7.01354025e-03f, 2.68528223e-01f, 4.26237822e-01f, 2.59243876e-01f, 1.61015257e-01f, -1.75075158e-01f, 2.00918764e-01f, 2.29703829e-01f, 7.99190551e-02f, 9.84005332e-01f,
  -2.74338853e-02f, 2.49057159e-01f, -1.39202654e-01f, -1.03883706e-01f, 8.35463405e-02f, 1.01678595e-01f, -7.68572316e-02f, 1.44419461e-01f, -1.10471815e-01f, 2.95653846e-02f,
  5.19722700e-03f, -5.17801493e-02f, 1.11931875e-01f, 3.61989662e-02f, 1.25153698e-02f, -1.11273885e-01f, 1.48801297e-01f, 2.80083925e-01f, 1.00639388e-01f, -1.28461167e-01f,
  1.96387187e-01f, 8.06103721e-02f, -1.19982168e-01f, -1.26311406e-01f, 1.42526492e-01f, 2.97158696e-02f, -1.19886599e-01f, 6.98790103e-02f, -1.56514093e-01f, 1.85643598e-01f,
  -1.09178402e-01f, 2.15514228e-02f, 5.42630926e-02f, -6.29191287e-03f, 1.36675954e-01f, -8.01716372e-02f, 1.35736978e-02f, -9.51946825e-02f, 1.83279701e-02f, 2.99233664e-02f,
  -8.19748193e-02f, 3.40599418e-02f, -7.47327432e-02f, -1.22416094e-01f, -3.31417918e-02f, 1.23025596e-01f, 3.99666578e-02f, 3.73907052e-02f, -9.50040296e-02f, 5.53271584e-02f,
  1.27770886e-01f, 8.98040459e-02f, -5.30932769e-02f, 1.63591161e-01f, 1.92215107e-02f, 1.06402740e-01f, 3.32444869e-02f, -3.80036049e-02f, -4.25290465e-02f, -1.73362195e-02f,
  -4.91018564e-01f, -2.54827946e-01f, -1.63502544e-01f, 1.29498526e-01f, 8.90053716e-03f, 5.66089386e-03f, 2.04459623e-01f, -6.84980452e-02f, -5.05571142e-02f, -7.47856172e-03f,
  -7.55135864e-02f, 1.23093780e-02f, 3.43330242e-02f, 4.44464982e-02f, -2.42901132e-01f, -1.50578335e-01f, 6.90859482e-02f, -6.90207630e-02f, 7.38505647e-02f, -1.61400825e-01f,
  1.43130362e-01f, -2.84758627e-01f, -4.60705757e-01f, -3.03970337e-01f, -2.84601659e-01f, -3.25981319e-01f, -2.37739250e-01f, -2.06359923e-01f, -5.12118995e-01f, -4.98043895e-01f,
  7.14680493e-01f, 7.11118519e-01f, -7.16741905e-02f, 2.94401616e-01f, 1.97843343e-01f, 1.16492607e-01f, 4.56250459e-01f, 1.29477084e-01f, 7.22467899e-02f, 2.19609499e-01f,
  5.59829295e-01f, 1.35939583e-01f, 2.03773558e-01f, 6.47518486e-02f, 2.20861390e-01f, -3.69784273e-02f, -2.23404422e-01f, -2.03893796e-01f, -1.52665526e-01f, 1.99528202e-01f,
  1.36738911e-01f, 1.27398551e-01f, 9.57253501e-02f, 5.83601519e-02f, 1.78850606e-01f, -6.76342892e-03f, 6.92142919e-02f, 1.54744461e-01f, 1.60190269e-01f, -4.03683409e-02f,
  -9.00041983e-02f, 2.30195105e-01f, -2.84417510e-01f, 4.70856242e-02f, -1.33124124e-02f, -1.76310286e-01f, -6.75236210e-02f, -9.34913158e-02f, 2.28807405e-02f, -5.36321327e-02f,
  6.49311244e-02f, -1.21518206e-02f, 2.16597348e-01f, -1.85515862e-02f, -3.95231619e-02f, 1.83211789e-02f, -6.63165972e-02f, -5.47298277e-03f, 4.74552438e-02f, 1.12117596e-01f,
  2.23585472e-01f, 2.70578891e-01f, 1.27829164e-01f, 1.56113133e-01f, 5.10463975e-02f, -6.34902492e-02f, 1.73951343e-01f, 4.94729280e-02f, -1.42177213e-02f, -7.36045465e-02f,
  4.73224651e-03f, 7.66429305e-02f, -8.51058066e-02f, 3.47148217e-02f, 1.12608440e-01f, -1.78617202e-02f, -9.33900103e-02f, -5.16306944e-02f, 9.85395834e-02f, 1.27805872e-02f,
  -1.30719349e-01f, 4.46217172e-02f, -5.74542657e-02f, -5.00359610e-02f, 1.98115259e-02f, 2.20598400e-01f, -6.52187839e-02f, 4.28587402e-04f, 1.25433624e-01f, 3.56875993e-02f,
  2.32753068e-01f, 1.87079869e-02f, -4.92759012e-02f, 1.53419271e-01f, -4.84534614e-02f, 5.19944467e-02f, 6.33539259e-02f, 1.15581654e-01f, -2.08470076e-02f, 1.18327312e-01f,
  -1.87744334e-01f, 2.90724486e-01f, -8.08460824e-03f, 5.30065550e-03f, -1.71805900e-02f, -1.46980649e-02f, 2.76559561e-01f, -1.72184943e-03f, -5.79221137e-02f, -8.97198543e-02f,
  4.01870571e-02f, 8.92657712e-02f, 1.44527659e-01f, -9.63162184e-02f, -8.09039697e-02f, -1.47804171e-01f, 1.67464808e-01f, 8.89639109e-02f, 6.13094028e-03f, -1.08491808e-01f,
  8.39436948e-02f, -8.82368833e-02f, -5.71510848e-03f, -1.58555344e-01f, -1.06034026e-01f, -1.65182129e-01f, -2.29923651e-01f, -1.87171713e-01f, -2.08965525e-01f, -3.13034803e-01f,
  1.61402002e-01f, -5.52758038e-01f, -2.01704189e-01f, 2.56095752e-02f, -1.62168205e-01f, 1.29888207e-01f, -4.19689536e-01f, 3.02142918e-01f, 1.42504677e-01f, -4.55646276e-01f,
  2.99879402e-01f, 3.97406518e-01f, -3.83636989e-02f, 2.70094723e-01f, 3.05497080e-01f, -3.29358697e-01f, -3.96642834e-01f, 1.19258533e-04f, 6.02498174e-01f, 6.34051561e-01f,
  1.29254267e-01f, -4.56257641e-01f, 1.33827612e-01f, 4.01010633e-01f, -3.59213740e-01f, 1.39134541e-01f, -5.58890402e-01f, -4.38270420e-01f, -2.25719647e-03f, -1.10574114e+00f,
  -2.73195595e-01f, -7.28831813e-02f, 1.91087589e-01f, 2.28217663e-03f, -7.26722255e-02f, 1.55141512e-02f, 7.31290504e-02f, -2.08564833e-01f, -6.07079491e-02f, 7.78539479e-02f,
  -6.64894059e-02f, 1.37134179e-01f, 5.81241027e-02f, -5.27118035e-02f, -9.78706405e-02f, -4.50170822e-02f, 4.03566062e-02f, 7.65593499e-02f, -2.50284858e-02f, -1.16687149e-01f,
  -4.09276113e-02f, -8.09146687e-02f, -1.97375566e-01f, -5.62194511e-02f, 1.83071285e-01f, 8.49130750e-02f, -2.22944506e-02f, 6.94335252e-02f, 5.58712780e-02f, -4.94816214e-01f,
  1.08124735e-02f, -7.65322521e-02f, 1.95522103e-02f, -4.03494276e-02f, 4.80316319e-02f, -1.32302595e-02f, 1.84792764e-02f, -6.35341217e-04f, 5.69303669e-02f, -1.69237465e-01f,
  1.21661052e-01f, -9.07806233e-02f, 4.98475693e-02f, -6.08179308e-02f, 3.41794570e-03f, -9.05557796e-02f, 2.70871911e-02f, -3.90326567e-02f, 4.29855194e-03f, -6.63268268e-02f,
  7.97039792e-02f, -2.65814699e-02f, -9.92184877e-02f, 1.65591370e-02f, -4.22131754e-02f, 1.09394111e-01f, -1.53494962e-02f, 1.11959383e-01f, -4.18990478e-02f, -3.87578197e-02f,
  -9.76852328e-02f, 2.24487022e-01f, -1.28865153e-01f, 7.75619447e-02f, -7.21722096e-02f, 6.25229850e-02f, -1.32648855e-01f, 1.40922666e-01f, -6.94141239e-02f, 7.16944188e-02f,
  4.77394275e-02f, -2.25465577e-02f, -1.02627903e-01f, -3.13098468e-02f, 6.22676350e-02f, 4.98825349e-02f, -1.06173856e-02f, -4.85992841e-02f, 8.01389888e-02f, 8.41587111e-02f,
  -9.02009830e-02f, -2.94343065e-02f, 1.29681036e-01f, -6.15732335e-02f, -5.43687679e-02f, 9.12684575e-02f, -1.59764394e-01f, -1.82697237e-01f, 1.24667868e-01f, -3.37173641e-01f,
  -1.26922679e+00f, 2.17503265e-01f, -2.66912561e-02f, -2.19503820e-01f, -1.30087033e-01f, -2.14044377e-01f, -5.79563260e-01f, 3.22983712e-01f, 4.30160463e-01f, -9.99350324e-02f,
  -1.93604812e-01f, -1.66774780e-01f, -1.79381162e-01f, -3.78713198e-02f, -7.51171887e-01f, -3.25683326e-01f, -4.54824328e-01f, -8.30478370e-01f, -7.77225494e-01f, -5.02325082e-03f,
  -1.76008672e-01f, -6.56868696e-01f, -5.39114475e-01f, 2.01781467e-01f, 3.54502738e-01f, 5.46969250e-02f, 2.71924764e-01f, -2.89485604e-01f, 4.75885011e-02f, -4.35311168e-01f,
  -5.87896228e-01f, 3.02976608e-01f, -9.87210944e-02f, -1.32232293e-01f, -3.68911140e-02f, -7.80484173e-03f, -3.53953019e-02f, 8.43411684e-02f, 6.00160509e-02f, 1.38198584e-01f,
  -2.61126384e-02f, 1.26431972e-01f, -9.45749432e-02f, -6.15245253e-02f, -3.59534658e-02f, -7.46870041e-02f, 5.76578341e-02f, -3.13051082e-02f, -1.02637574e-01f, 2.28309497e-01f,
  1.10017464e-01f, -2.16774970e-01f, 3.53010781e-02f, 1.42046884e-01f, 1.22726835e-01f, -2.60412812e-01f, 2.65012234e-01f, 2.75851935e-01f, 7.93967247e-02f, 2.20231250e-01f,
  -3.00567746e-02f, 4.90387306e-02f, 6.60310080e-03f, 5.75530678e-02f, -6.18061200e-02f, 1.18736148e-01f, -1.09793089e-01f, 2.03258488e-02f, -7.21836016e-02f, -2.90367962e-03f,
  7.70696998e-02f, -2.69259829e-02f, 2.70630699e-02f, -1.09688714e-02f, 2.88774092e-02f, 5.20072617e-02f, -9.25196037e-02f, 2.19306517e-02f, 3.29260565e-02f, 1.72652137e-02f,
  6.99235350e-02f, 4.09684889e-02f, 3.19350511e-02f, 9.37685296e-02f, -6.55262545e-02f, -3.10188401e-02f, -4.16904166e-02f, -3.02806683e-02f, 1.20077066e-01f, 5.44283353e-02f,
  2.89138973e-01f, -2.21964642e-01f, -1.13644123e-01f, 1.50862873e-01f, 2.71069519e-02f, 1.62663266e-01f, -2.21580379e-02f, -1.87476457e-03f, -1.61266010e-02f, -1.07649229e-01f,
  8.70745108e-02f, -6.31393641e-02f, -1.41272452e-02f, 9.60670337e-02f, -1.27171293e-01f, 1.08868569e-01f, 4.77337874e-02f, -2.35080823e-01f, 3.52511741e-02f, 1.65585011e-01f,
  1.29459262e-01f, 6.43769056e-02f, -1.01670496e-01f, -3.88418660e-02f, 8.94968137e-02f, -3.35942447e-01f, -2.46197395e-02f, 9.41794142e-02f, -2.82266676e-01f, 4.91038151e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  8.63488734e-01f, 7.61453748e-01f, 3.12985927e-01f, 4.48971450e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -3.17427337e-01f, 3.65878522e-01f, 1.68342128e-01f, -2.75356233e-01f, 2.03005504e-02f, 2.37331942e-01f, -3.63682896e-01f, 3.27033609e-01f, 4.76928949e-02f, 1.51698008e-01f,
  1.75730899e-01f, 8.23463380e-01f, 3.44593018e-01f, 2.28702445e-02f, -9.50923860e-02f, -3.24485034e-01f, -3.45167108e-02f, -5.88210747e-02f, -2.18770832e-01f, -2.09708691e-01f,
  -3.14021796e-01f, -1.68091848e-01f, -4.15541470e-01f, 1.14999466e-01f, 1.54582292e-01f, -6.42509997e-01f, 6.29971968e-03f, 2.60433465e-01f, -3.09563041e-01f, 2.29381680e-01f,
  5.46411157e-01f, -2.50343293e-01f, 2.51523435e-01f, -2.01580673e-01f, 1.50504513e-02f, 2.19388202e-01f, -2.42282599e-01f, 3.29645686e-02f, 4.91876006e-01f, -9.71130468e-03f,
  -7.47988373e-02f, 2.13961676e-01f, 5.93073741e-02f, 3.13165516e-01f, -2.26758435e-01f, 2.66276449e-01f, -9.35934842e-01f, -1.94552645e-01f, 2.57297516e-01f, -2.71614641e-01f,
  5.88379145e-01f, 2.88564563e-01f, -3.09638709e-01f, -1.74127445e-01f, 1.15927383e-01f, 5.63635349e-01f, 2.13225279e-02f, -2.62796372e-01f, -2.59731263e-01f, 6.44289672e-01f,
  -3.22972387e-01f, 3.23484480e-01f, 5.74411713e-02f, 5.22648454e-01f, 1.87922660e-02f, -7.04608679e-01f, 4.17785943e-01f, 8.51379454e-01f, -1.99585065e-01f, 2.25751698e-01f,
  -5.83445311e-01f, 3.43607366e-01f, 3.71621013e-01f, -4.51504439e-01f, -2.37766162e-01f, 4.54674572e-01f, 2.14283869e-01f, -1.50531858e-01f, -1.34052143e-01f, -1.03668958e-01f,
  -1.15395516e-01f, 4.15065497e-01f, -3.78331631e-01f, -8.53393257e-01f, -2.20712528e-01f, -1.19697884e-01f, 4.02588785e-01f, 2.23776922e-01f, -1.27192950e-02f, -3.95426542e-01f,
  5.94700463e-02f, 1.45273358e-01f, -4.09532279e-01f, 4.26459521e-01f, 2.53206611e-01f, 1.52166650e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.23058379e+00f, 1.11188734e+00f, 2.02355281e-01f, 1.61381924e+00f, -2.49098778e-01f, 3.87005806e-01f, -5.45788467e-01f, -6.54602587e-01f, 1.27503663e-01f, -1.71032166e+00f,
  -2.98728108e-01f, 5.60557723e-01f, 4.95175451e-01f, 1.66936263e-01f, 1.15132317e-01f, -3.66856083e-02f, -5.91281772e-01f, 2.66318470e-01f, -9.34755027e-01f, -1.28564835e+00f,
  4.87260163e-01f, 1.27455425e+00f, 3.05227432e-02f, 4.20982897e-01f, 8.22542727e-01f, 1.86202139e-01f, 1.38231024e-01f, 1.58202916e-01f, 6.92139030e-01f, 4.25633371e-01f,
  3.46772373e-01f, 1.83921218e-01f, -3.68499428e-01f, -8.21952999e-01f, 1.13114321e+00f, 8.21231365e-01f, -6.79803342e-02f, -4.48995620e-01f, -3.94783437e-01f, 9.00450587e-01f,
  6.97026730e-01f, 6.82609975e-01f, 1.92482974e-02f, 1.01548421e+00f, 2.97580987e-01f, 3.91974300e-01f, 2.23730549e-01f, 4.92067337e-01f, 1.11636750e-01f, -3.54530931e-01f,
  5.48881114e-01f, 7.51203239e-01f, 8.54459584e-01f, 1.60170555e+00f, -5.89008272e-01f, 5.86881876e-01f, -4.57192719e-01f, 8.03163409e-01f, -3.22484583e-01f, -6.86947823e-01f,
  -8.13254714e-01f, -2.97199637e-01f, 9.01987493e-01f, 1.08596802e+00f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  8.79303873e-01f, 4.31506336e-01f, -2.95220595e-02f, 8.16520095e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -9.03518081e-01f, 7.28869379e-01f, -4.31477875e-01f, -9.09823418e-01f, -3.78457516e-01f, -9.73750651e-01f, -3.21680009e-02f, 1.83127189e+00f, 1.87249339e+00f, 4.45787817e-01f,
  -8.73445153e-01f, 8.53006542e-01f, -3.98402452e-01f, -4.51902419e-01f, -1.49329454e-01f, 4.61790085e-01f, 5.25704324e-01f, -7.31753945e-01f, -1.94342017e+00f, 1.04092658e+00f,
  6.63506508e-01f, 1.83107674e-01f, -2.74231821e-01f, 1.87503910e+00f, -1.85954168e-01f, 1.49414256e-01f, -1.06313020e-01f, 1.08516061e+00f, 5.13333231e-02f, 3.10338229e-01f,
  7.23601431e-02f, -3.67558119e-03f, 1.51146185e+00f, 1.92860946e-01f, -1.62849176e+00f, 5.28110087e-01f, 6.35580063e-01f, -1.69229925e+00f, 4.87876087e-01f, -7.60186672e-01f,
  1.69648349e-01f, -1.28720331e+00f, 8.22824121e-01f, -9.72457409e-01f, 7.43042111e-01f, -1.08751154e+00f, -4.95261699e-01f, -7.89867520e-01f, 8.20657194e-01f, -1.04185843e+00f,
  -1.48637235e+00f, 3.49417105e-02f, -1.63278461e+00f, 4.26128715e-01f, -6.29858017e-01f, -9.57064211e-01f, -6.54683530e-01f, 9.38955843e-01f, -1.06046546e+00f, 1.07198524e+00f,
  -2.30057144e+00f, 1.68803649e-03f, -2.57779419e-01f, 7.52325952e-01f, -1.18490613e+00f, -5.22145331e-01f, -4.54251379e-01f, -9.68383968e-01f, 8.27437580e-01f, 7.76913941e-01f,
  -7.45303750e-01f, -1.25888920e+00f, -1.39538038e+00f, -8.49597216e-01f, 2.84015059e-01f, 8.76115859e-02f, -5.27526677e-01f, -3.70889485e-01f, 7.17773199e-01f, 2.71080732e-01f,
  1.00965285e+00f, 1.10216284e+00f, 1.47765028e+00f, -2.48552656e+00f, 3.74621421e-01f, -3.94647904e-02f, -5.03804207e-01f, 6.77639991e-02f, -7.80965865e-01f, 1.24765825e+00f,
  5.55790029e-02f, 1.19666076e+00f, 4.75645155e-01f, -4.60113972e-01f, -4.23457146e-01f, -2.71496475e-01f, -1.32337725e+00f, 4.33193207e-01f, 1.99654520e-01f, 8.18555653e-01f,
  -1.03356743e+00f, -6.72722578e-01f, -7.15719163e-01f, -2.85618484e-01f, -1.02132297e+00f, -2.33194027e-02f, 3.57211053e-01f, -3.51840079e-01f, 5.06350517e-01f, -1.10039689e-01f,
  -2.68901289e-01f, -1.17605329e+00f, -9.68397558e-02f, 2.42931992e-01f, -2.56946653e-01f, -1.82453111e-01f, 5.97603142e-01f, 1.11110938e+00f, 9.41758037e-01f, -5.27976334e-01f,
  1.86115697e-01f, -1.00849247e+00f, -7.98398674e-01f, 6.60080433e-01f, -8.77489328e-01f, 7.62926161e-01f, -3.85618389e-01f, -5.18084168e-01f, 9.04358268e-01f, 1.25662053e+00f,
  1.07934904e+00f, 5.22471845e-01f, -1.33866322e+00f, -6.67709053e-01f, 1.32636511e+00f, -6.24390244e-01f, 1.06415868e-01f, 3.00373137e-01f, 1.06940317e+00f, -1.41883278e+00f,
  -6.97924018e-01f, -8.07844251e-02f, 3.07552278e-01f, 2.22189561e-01f, 1.08478093e+00f, 1.57943025e-01f, 1.64509773e+00f, -7.64161199e-02f, 1.30145693e+00f, 6.74528658e-01f,
  1.13399923e+00f, -6.17544353e-01f, -1.34072095e-01f, -7.15970635e-01f, 6.41493142e-01f, -8.17940772e-01f, 6.34047210e-01f, 1.23208269e-01f, -1.70702565e+00f, -2.08862185e+00f,
  -1.04013525e-01f, -1.44607675e+00f, 1.54518461e+00f, 1.19536710e+00f, 3.92815381e-01f, 2.24231154e-01f, -8.86462629e-01f, -1.15764916e+00f, -2.19517380e-01f, 8.54867622e-02f,
  -7.45958626e-01f, -1.92753589e+00f, -1.24267012e-01f, -1.27655554e+00f, -2.04761267e+00f, 5.23379803e-01f, -1.41289377e+00f, 8.72606754e-01f, 1.12955727e-01f, -5.64420223e-01f,
  -4.76390958e-01f, 9.77266669e-01f, 9.75516319e-01f, 1.11472178e+00f, 1.75345886e+00f, 1.10053158e+00f, 4.69544172e-01f, 2.34648939e-02f, 1.83577463e-01f, -5.76104939e-01f,
  6.30265713e-01f, -1.49973583e+00f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  5.23662865e-01f, -2.73135662e-01f, 8.65554988e-01f, -2.34610900e-01f, -1.52301297e-01f, -8.67281780e-02f, 2.92022645e-01f, 5.25735378e-01f, -1.65551081e-01f, -4.26869422e-01f,
  -2.46012211e-03f, -3.52578133e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    