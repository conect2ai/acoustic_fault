/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.03050306e-01f, 8.46305713e-02f, 8.69045965e-04f, -2.09010407e-01f, -1.48854688e-01f, -1.67756468e-01f, -1.58186883e-01f, 1.79680495e-03f, -2.63530791e-01f, 9.97098833e-02f,
  -7.01075494e-02f, 2.03883685e-02f, 1.17026858e-01f, -1.08315408e-01f, -2.54150867e-01f, 3.43579389e-02f, -6.89836740e-02f, -3.56196873e-02f, -4.26293276e-02f, 1.64779406e-02f,
  4.71673645e-02f, -1.57302916e-01f, 6.23593703e-02f, 1.78474948e-01f, -2.09900849e-02f, 1.23323776e-01f, 6.14904426e-03f, 1.76982153e-02f, 1.82374548e-02f, -1.57277137e-01f,
  -5.48571795e-02f, 2.23275684e-02f, 9.05322097e-03f, 1.26106024e-01f, 1.06869861e-02f, 5.54837286e-02f, 1.07107431e-01f, -5.45744933e-02f, 8.29291996e-03f, 4.31375466e-02f,
  7.91868940e-02f, -1.93493068e-02f, -4.93846275e-02f, 2.30911020e-02f, -5.51306754e-02f, -3.76124270e-02f, -2.46253535e-02f, -2.27262527e-02f, -5.44086695e-02f, 5.20527437e-02f,
  -4.12309682e-03f, 5.94611913e-02f, -3.64689343e-02f, 3.80593538e-02f, -3.10558174e-02f, -2.57375948e-02f, -3.16326320e-02f, -2.91088652e-02f, -6.48407638e-02f, -1.28865773e-02f,
  4.64165695e-02f, 7.03307092e-02f, 3.17619219e-02f, -3.11911609e-02f, 2.16665100e-02f, -9.83906835e-02f, 1.82860866e-02f, -3.87854688e-03f, -2.55080070e-02f, -2.01698337e-02f,
  3.38325202e-02f, -8.70226994e-02f, 7.75163993e-02f, 2.85486318e-02f, -1.69757265e-03f, 2.52022501e-02f, -2.27044094e-02f, -2.63657346e-02f, -3.68977292e-03f, -3.33837345e-02f,
  9.01293475e-03f, -8.67300779e-02f, -1.35659836e-02f, 1.41073391e-02f, -1.35127474e-02f, -1.55167338e-02f, -9.10309795e-03f, 5.79253174e-02f, 9.88626480e-03f, -1.22025916e-02f,
  -4.66967002e-02f, 6.86959773e-02f, -3.89470011e-02f, -8.46337676e-02f, 6.59413338e-02f, 1.35261953e-01f, -1.35025848e-02f, -5.98009601e-02f, -8.22244585e-02f, 5.73506579e-03f,
  2.03400180e-02f, 8.21989495e-04f, 6.18156865e-02f, -3.89545634e-02f, -4.41029556e-02f, -4.08506505e-02f, 1.99783575e-02f, 1.03959804e-02f, -6.52988553e-02f, -4.05294038e-02f,
  9.77584422e-02f, -4.67721149e-02f, 3.45370434e-02f, 2.95889527e-02f, 2.40942035e-02f, 7.69652575e-02f, -2.12394129e-02f, -5.97838983e-02f, -1.99148078e-02f, -4.00244333e-02f,
  1.33413926e-01f, -3.46226245e-01f, -4.12202589e-02f, -3.09643224e-02f, -3.98649722e-02f, -8.13785419e-02f, 8.52450430e-02f, -1.07324667e-01f, -6.44984320e-02f, -1.68611839e-01f,
  1.92951132e-02f, -2.63233036e-02f, -6.99475333e-02f, -4.00757529e-02f, 1.20870627e-01f, -4.28063748e-03f, -1.20236814e-01f, -1.10018574e-01f, 1.89908389e-02f, 2.49136686e-02f,
  4.84397002e-02f, -5.87589890e-02f, -5.47915995e-02f, 3.39063853e-02f, -7.81309530e-02f, -2.75118686e-02f, 2.41824575e-02f, 8.90165493e-02f, 4.53889482e-02f, -1.50181381e-02f,
  3.98735963e-02f, 3.46390717e-02f, -2.57362090e-02f, 6.97379634e-02f, 2.19571143e-02f, 7.61752054e-02f, 8.36434811e-02f, -1.09028285e-02f, 4.86678854e-02f, -4.00575027e-02f,
  2.17153169e-02f, -4.19893302e-02f, 8.55978131e-02f, -5.73947839e-02f, -4.38827835e-02f, 5.87524511e-02f, 2.24761143e-02f, 3.60788917e-03f, -7.58097917e-02f, 1.03252359e-01f,
  -7.22805560e-02f, 8.90813209e-03f, -6.72813505e-03f, 7.16516376e-02f, -6.04042783e-02f, -5.68722095e-03f, 6.81609148e-03f, 2.95190383e-02f, -1.74990613e-02f, -1.81638934e-02f,
  -3.82999890e-02f, 8.82315710e-02f, -9.86346416e-03f, 4.42533940e-02f, -6.05247468e-02f, -8.68340209e-02f, 1.12127997e-02f, -6.72301138e-03f, -5.19456761e-03f, -3.09213698e-02f,
  9.48722661e-02f, 3.59311439e-02f, 8.25588498e-03f, 4.16821241e-02f, 4.78135906e-02f, -3.82463634e-02f, 3.98298390e-02f, 7.19518773e-03f, 3.99389528e-02f, -5.46037368e-02f,
  -3.90985683e-02f, -6.26232550e-02f, -5.56063838e-02f, 3.83037515e-02f, -3.04387696e-02f, 7.34855328e-03f, -1.98328379e-03f, 3.63912322e-02f, -7.83510134e-02f, 2.75975764e-02f,
  -3.66124325e-02f, -1.04004629e-02f, -3.48975807e-02f, 4.25729640e-02f, 7.62618287e-03f, -4.80872206e-02f, -4.30245064e-02f, -3.77758518e-02f, 7.52267241e-03f, 6.92289025e-02f,
  -1.70546416e-02f, -6.71835169e-02f, 4.62985337e-02f, 3.86163890e-02f, 1.20590152e-02f, 4.39224765e-02f, -3.28173973e-02f, -9.36988443e-02f, 8.16942751e-02f, 3.86691876e-02f,
  -2.76708901e-02f, -2.38385797e-03f, -1.35078374e-03f, -6.29265532e-02f, 4.03577946e-02f, 2.49085724e-02f, -2.47057565e-02f, 7.17449561e-02f, 3.81801315e-02f, 3.23250778e-02f,
  -3.76920961e-03f, 1.50463864e-01f, 1.51307791e-01f, 1.74865574e-01f, -3.43783610e-02f, -1.23930484e-01f, -1.44357935e-01f, -7.57959159e-03f, 4.01023477e-02f, -8.65850076e-02f,
  1.98768266e-02f, 1.81248516e-01f, -8.55529401e-03f, 2.72247717e-02f, 8.06735829e-02f, 8.83795246e-02f, -4.59540486e-02f, -6.99937269e-02f, 3.11846845e-02f, 6.80174902e-02f,
  3.65496427e-02f, 2.18679737e-02f, 1.93609774e-01f, -4.51683551e-02f, -5.33595718e-02f, 1.66723859e-02f, 5.25221154e-02f, 5.11180684e-02f, 1.05935656e-01f, -3.40512954e-02f,
  -2.09816545e-02f, 8.54012519e-02f, 3.87275568e-03f, -4.19549551e-03f, -7.27703795e-02f, -4.56760600e-02f, 5.38284704e-02f, -5.74169680e-02f, 6.02200329e-02f, 5.20777255e-02f,
  -1.85821205e-02f, -2.41642892e-02f, 1.89723354e-02f, -5.14412001e-02f, -4.69657406e-02f, 1.26505373e-02f, -4.03222479e-02f, -2.49272007e-02f, 2.82668397e-02f, -3.84124145e-02f,
  6.27188534e-02f, -6.96260184e-02f, -8.10657069e-03f, -1.73108820e-02f, 2.69332230e-02f, 1.04584657e-01f, 5.87803200e-02f, -2.34530922e-02f, 9.85600147e-03f, 4.51194420e-02f,
  -5.36379814e-02f, 5.36265187e-02f, 7.61085451e-02f, 2.71189120e-03f, 2.48129684e-02f, 1.12495674e-02f, 5.66425584e-02f, -2.15239730e-02f, -2.87019741e-02f, 3.48287858e-02f,
  6.36683078e-03f, 4.92684469e-02f, 6.54069846e-03f, 1.32731367e-02f, -4.87030596e-02f, -3.77454190e-03f, 1.49562219e-02f, -1.35531137e-03f, 1.37045560e-02f, -7.91481975e-03f,
  4.97904830e-02f, 7.39721358e-02f, 7.64501095e-02f, 3.15278433e-02f, 7.91690573e-02f, 3.74993570e-02f, 2.10405067e-02f, 2.46723685e-02f, 4.85795140e-02f, -8.91085044e-02f,
  -2.35400572e-02f, 4.32357378e-02f, -5.13877682e-02f, 5.27859218e-02f, 8.10355134e-03f, 3.61088328e-02f, 6.15142025e-02f, -7.21504688e-02f, 7.82961696e-02f, -5.33558354e-02f,
  4.62843031e-02f, -1.40835075e-02f, -1.77948212e-03f, -2.02154983e-02f, 2.35376209e-02f, 1.78581942e-02f, 3.83188240e-02f, 2.69105304e-02f, -9.73643269e-03f, 2.49409419e-03f,
  1.02674879e-01f, -1.87408756e-02f, 1.61613952e-02f, -5.27786911e-02f, 3.70913222e-02f, -2.37380192e-02f, -1.61838029e-02f, 7.29843462e-03f, -7.43817315e-02f, -7.95959122e-03f,
  3.27278227e-01f, 9.98100638e-02f, -1.14741623e-01f, 3.74451160e-01f, -9.31469128e-02f, 1.32539123e-01f, 1.21809589e-02f, 9.10961553e-02f, 1.11455344e-01f, 1.86905757e-01f,
  8.16552415e-02f, -9.82930791e-03f, -2.12583348e-01f, 1.20535299e-01f, -2.14166358e-01f, -8.30572173e-02f, 1.03227042e-01f, 1.13106407e-01f, -1.44814160e-02f, 8.77126902e-02f,
  -5.00908606e-02f, 2.02516280e-02f, -1.08515061e-01f, -5.87433606e-05f, 1.23097040e-02f, 1.27899677e-01f, -4.38257791e-02f, -1.04646020e-01f, 5.22720478e-02f, 3.67211327e-02f,
  8.58361647e-03f, 1.75926730e-01f, 1.19483499e-02f, -2.31075175e-02f, -2.84089260e-02f, -3.89647670e-02f, -2.88202381e-03f, -4.40610833e-02f, 5.04984185e-02f, -4.70091589e-03f,
  3.10185328e-02f, 4.27478142e-02f, 6.97548315e-02f, 2.10584067e-02f, -2.88559054e-03f, 3.02106980e-02f, -1.25196269e-02f, 4.58788089e-02f, 5.57423919e-04f, -5.31162098e-02f,
  7.06137791e-02f, 7.49299452e-02f, -4.43850681e-02f, 5.71760386e-02f, -6.06565475e-02f, 2.58329324e-02f, 5.37420325e-02f, -1.18003143e-02f, 8.42349306e-02f, 4.66648601e-02f,
  -7.80685917e-02f, 1.18394000e-02f, 7.56450146e-02f, 2.10279459e-03f, 3.43957245e-02f, 8.80852621e-03f, 4.92908061e-02f, -2.24814508e-02f, 2.45604739e-02f, -4.08262350e-02f,
  2.43615303e-02f, -3.91843952e-02f, 2.15774309e-02f, 1.14896949e-02f, -8.90592951e-03f, 8.77769142e-02f, -4.77903858e-02f, 2.52800919e-02f, -1.37480563e-02f, 5.00581153e-02f,
  4.71739620e-02f, 7.76143968e-02f, -6.52527064e-03f, -5.77595308e-02f, 3.67153808e-02f, -2.41399892e-02f, -3.78473960e-02f, 8.67467001e-02f, 7.80616328e-02f, -4.82025035e-02f,
  4.45398726e-02f, 2.72457898e-01f, -5.47920261e-03f, 7.11087734e-02f, 6.56952113e-02f, -2.76044384e-02f, 1.19347740e-02f, -3.85726020e-02f, -1.05647882e-02f, -8.36270023e-03f,
  -3.80704477e-02f, -4.34650034e-02f, -1.65506676e-02f, 1.91954095e-02f, -4.21307003e-03f, -1.92060582e-02f, 4.52135429e-02f, -3.16473246e-02f, 7.44308159e-02f, 5.23895696e-02f,
  6.00312054e-02f, 3.29221152e-02f, 2.52346508e-02f, -3.42103392e-02f, -4.55527790e-02f, 7.16135046e-03f, 4.47969958e-02f, 4.71936576e-02f, -1.06031165e-01f, -1.98134594e-02f,
  4.20057505e-01f, -1.73289821e-01f, -8.33180791e-04f, 6.24599084e-02f, 5.33343256e-02f, 8.54618177e-02f, 9.99788940e-02f, -1.78945698e-02f, -2.63987333e-02f, -1.60518438e-01f,
  1.31072760e-01f, 9.60330144e-02f, 1.00175686e-01f, 5.43413833e-02f, 1.94867760e-01f, -1.73873268e-02f, 1.32471338e-01f, -2.09999476e-02f, -9.97367427e-02f, 2.25040205e-02f,
  1.19345519e-03f, 2.78621968e-02f, 1.24526061e-01f, 2.15354562e-02f, 1.22974783e-01f, -1.07827090e-01f, -5.34897298e-02f, -1.37765119e-02f, 3.70283350e-02f, 7.81214014e-02f,
  -5.64656891e-02f, 6.23246543e-02f, -5.66176744e-03f, -1.15848435e-02f, 3.76192592e-02f, -3.22623402e-02f, 4.01974507e-02f, 8.06045905e-02f, -3.81933004e-02f, 2.74406914e-02f,
  -7.01320032e-03f, -2.47184932e-02f, 1.02494154e-02f, 9.56658833e-03f, -9.99248400e-03f, -1.24393329e-02f, -6.47690147e-02f, 4.57697688e-03f, -1.98612791e-02f, -2.17179656e-02f,
  -4.58717123e-02f, -5.27759716e-02f, 2.22374573e-02f, -7.21420147e-05f, 4.80710529e-02f, -1.81165542e-02f, -1.22094899e-02f, -1.00988951e-02f, -4.63929623e-02f, -6.63258089e-03f,
  3.78573313e-02f, 4.23703641e-02f, 1.42854999e-03f, 3.41149010e-02f, 5.25760539e-02f, -2.47247852e-02f, -5.25263101e-02f, -1.11590251e-02f, 2.74215546e-02f, 3.80589403e-02f,
  -4.79862373e-03f, -1.74229487e-03f, -2.45610904e-03f, 4.81376313e-02f, -6.90451115e-02f, 5.11184521e-02f, 1.67267937e-02f, -4.07024324e-02f, 1.99909471e-02f, -3.29227708e-02f,
  1.29570588e-02f, 3.19387726e-02f, -6.89844266e-02f, 3.85383777e-02f, -2.70642317e-03f, 2.70928314e-04f, -2.05545537e-02f, 1.98297128e-02f, -2.93777809e-02f, 5.14962003e-02f,
  -4.74728085e-02f, -1.17651466e-02f, 1.61445923e-02f, 4.69516125e-03f, -5.61299585e-02f, 4.30912003e-02f, -1.06188422e-02f, -1.86045989e-02f, -7.58005232e-02f, -1.96788684e-02f,
  2.42516566e-02f, 2.20669191e-02f, -4.74381335e-02f, 6.55359104e-02f, 8.74140952e-03f, 3.19615826e-02f, -2.45981887e-02f, -6.61328994e-03f, -6.73825433e-03f, 2.62830220e-02f,
  1.00994319e-01f, -2.00129915e-02f, -3.95560600e-02f, 7.30887894e-03f, 1.09139308e-02f, 4.00797762e-02f, -4.78573367e-02f, -7.80520365e-02f, -1.08478451e-02f, -6.73609972e-02f,
  -1.87044516e-01f, 7.63941556e-02f, 1.31430492e-01f, -2.30945572e-02f, 6.01058044e-02f, 7.10316747e-02f, 4.35716771e-02f, -2.64200605e-02f, 5.50972950e-03f, 9.34602097e-02f,
  -1.68340370e-01f, 8.56835302e-03f, -4.06337064e-03f, -1.78987727e-01f, -3.08224142e-01f, 5.25222272e-02f, -9.06479359e-02f, 6.02898784e-02f, 4.03820463e-02f, -5.98325729e-02f,
  -1.20685719e-01f, -2.23336086e-01f, 6.95069757e-05f, -1.92864627e-01f, 4.89381514e-02f, 5.01049273e-02f, -6.07778132e-02f, -4.34633307e-02f, -9.54871923e-02f, -1.40850082e-01f,
  4.41130660e-02f, 6.96325079e-02f, -2.81998366e-02f, -7.71569982e-02f, -2.30213739e-02f, 4.96892333e-02f, 5.31827696e-02f, 3.82934287e-02f, -7.70104630e-03f, 9.49093923e-02f,
  8.22699443e-02f, 1.67317837e-02f, 4.42034751e-03f, -1.04014762e-02f, 6.96032587e-03f, 8.60122815e-02f, 4.40638140e-02f, -6.56254403e-03f, 9.71494541e-02f, -1.68906245e-02f,
  -4.13949005e-02f, 1.72454156e-02f, 9.37241018e-02f, 2.01493055e-02f, -2.34386958e-02f, 1.11138569e-02f, 7.37623824e-03f, 2.41380241e-02f, 9.02209338e-03f, -2.99838968e-02f,
  -1.96166243e-02f, 2.67791227e-02f, 2.84495503e-02f, 1.66459952e-03f, -1.73954573e-02f, 5.54898046e-02f, -5.62246796e-03f, -3.73643599e-02f, 5.27276769e-02f, -2.17870604e-02f,
  4.97120246e-03f, 8.61661602e-03f, -1.79765597e-02f, -1.31168021e-02f, -5.84965535e-02f, 6.21126778e-02f, 3.84882092e-02f, 9.36642941e-03f, 5.06615676e-02f, -3.64654884e-02f,
  4.22678404e-02f, 5.34223625e-03f, -1.29275657e-02f, -2.24419869e-03f, -9.38580278e-03f, 3.75805013e-02f, -6.85041398e-02f, -2.18914263e-02f, 8.82822871e-02f, 3.09107802e-03f,
  -1.36742834e-03f, -9.99436826e-02f, 5.45022674e-02f, 4.47733812e-02f, -4.72411625e-02f, -2.36399975e-02f, -4.25355397e-02f, -8.70329440e-02f, -5.93984686e-02f, -7.34782591e-02f,
  4.71966527e-02f, 8.36386979e-02f, 4.87625673e-02f, 2.65259705e-02f, -5.61344326e-02f, 3.11187431e-02f, -6.16109371e-02f, -7.71875754e-02f, -5.51528893e-02f, -8.75210762e-02f,
  3.65458205e-02f, -2.24401020e-02f, -8.09828416e-02f, -7.56146736e-04f, 6.88702241e-02f, 2.84379236e-02f, 4.24597599e-02f, -6.24780729e-03f, -1.71624701e-02f, -1.13606546e-02f,
  -3.14633511e-02f, 7.38225058e-02f, -3.63673829e-02f, 6.68867826e-02f, -1.00209676e-01f, -1.43052489e-01f, -4.48100343e-02f, 3.14520448e-02f, -4.83734021e-03f, 2.55465042e-03f,
  1.39429169e-02f, -9.41188559e-02f, -8.48498475e-03f, 9.10119992e-03f, -8.14756751e-02f, 7.32112005e-02f, -7.21723028e-03f, -7.79879913e-02f, -4.17512050e-03f, -2.12967563e-02f,
  -1.49514992e-02f, 3.32151749e-03f, 2.22837757e-02f, 1.88383728e-01f, 8.87884572e-02f, -3.86663601e-02f, 7.24508241e-02f, 3.03702801e-02f, 1.49541631e-01f, 4.68218327e-03f,
  -7.23200738e-02f, 9.48150177e-03f, 4.50545475e-02f, 5.25229238e-02f, 2.35812832e-02f, -1.00632012e-01f, -3.72148529e-02f, 9.40735713e-02f, 1.41219087e-02f, 3.03717311e-02f,
  -2.61667967e-02f, -4.17121537e-02f, 1.94073434e-03f, 7.64411986e-02f, 9.79565270e-03f, 1.05183333e-01f, -4.78939228e-02f, -4.18811329e-02f, 9.16796795e-04f, 3.67274992e-02f,
  -6.04472868e-02f, -4.85922471e-02f, -3.16361636e-02f, 5.80121316e-02f, 5.75400963e-02f, -9.51241702e-02f, -1.06282858e-02f, -4.93568950e-04f, -1.34066135e-01f, -2.04889327e-02f,
  -1.13773504e-02f, 5.80105595e-02f, -4.43290547e-02f, 3.52626555e-02f, -1.15446805e-03f, -5.60388304e-02f, -2.03941390e-02f, 6.80729300e-02f, -3.26516712e-03f, 3.59396264e-02f,
  -5.46351522e-02f, 5.72496429e-02f, 3.02262865e-02f, -3.51292640e-02f, -3.24505381e-02f, 1.77290607e-02f, -2.79203840e-02f, -7.63157755e-02f, 6.68196380e-02f, -2.34351512e-02f,
  -6.56248629e-03f, -1.53528778e-02f, 1.03951201e-01f, 8.99684653e-02f, -1.37451291e-02f, -4.04172167e-02f, -8.72536283e-03f, -4.64351997e-02f, -2.14360878e-02f, -3.25270221e-02f,
  -3.77435759e-02f, 8.08390081e-02f, 5.58675416e-02f, 2.15029921e-02f, -5.85842133e-02f, -1.06489733e-01f, 3.30691598e-03f, 4.93937582e-02f, 4.01724465e-02f, 3.06087900e-02f,
  4.19977456e-02f, -5.80610484e-02f, -3.92650776e-02f, 8.37943237e-03f, 1.74253229e-02f, 1.22516137e-02f, 1.55913970e-02f, -7.37484694e-02f, -4.98861633e-02f, 7.53432810e-02f,
  6.14844523e-02f, -2.60854922e-02f, -5.12800962e-02f, -7.93482661e-02f, 5.53173311e-02f, 9.11371969e-03f, -8.58032107e-02f, -9.72997677e-03f, 3.23443264e-02f, -4.87374887e-02f,
  1.69488490e-02f, 2.47776628e-01f, -1.78084493e-01f, -3.90204489e-02f, -3.75743806e-02f, -4.49423157e-02f, -1.18145458e-01f, -4.48545143e-02f, -1.82303414e-01f, 1.45645753e-01f,
  8.69767964e-02f, 7.53479302e-02f, -1.04350120e-01f, 2.35925645e-01f, -1.81733146e-01f, -6.81333095e-02f, 1.12328142e-01f, 1.11327447e-01f, -5.03479727e-02f, 6.86729476e-02f,
  4.37979065e-02f, 1.42227441e-01f, 1.24023214e-01f, 1.95962027e-01f, 1.06922984e-01f, -3.38980323e-03f, 2.20649596e-02f, -5.07513918e-02f, 1.47545725e-01f, 1.05300240e-01f,
  -4.56411503e-02f, -6.35715667e-03f, -7.44433478e-02f, -2.55028959e-02f, 6.13384396e-02f, -4.76396177e-03f, 5.11263218e-03f, 4.24235687e-02f, -7.25602284e-02f, -5.48402891e-02f,
  1.60679705e-02f, -3.15767303e-02f, 1.00261882e-01f, -4.44854312e-02f, -4.70502451e-02f, 4.51249629e-02f, -4.92164381e-02f, -1.11826900e-02f, 3.77858095e-02f, -2.74616722e-02f,
  -2.50240183e-03f, 3.86139527e-02f, -2.67338101e-02f, -7.05136880e-02f, -3.46740223e-02f, -4.38512154e-02f, -3.68897542e-02f, -4.96464856e-02f, 1.34853087e-02f, -5.99200912e-02f,
  3.44181955e-02f, 2.13160627e-02f, 6.96417540e-02f, -3.95792052e-02f, 1.98983606e-02f, 8.94289929e-03f, 7.24914595e-02f, -1.17842155e-02f, -3.58776227e-02f, 1.06949611e-02f,
  -3.97376083e-02f, 6.32447675e-02f, -1.28871342e-02f, -1.34968106e-02f, 1.58668738e-02f, 1.73125640e-02f, 7.21912598e-03f, -3.40950005e-02f, -4.27892469e-02f, -8.35444331e-02f,
  1.59906372e-02f, -2.01753322e-02f, -6.71861097e-02f, -1.69474427e-02f, -4.91384929e-03f, -5.98608330e-03f, 1.64019186e-02f, -1.07669337e-02f, -7.92756863e-03f, -2.37144399e-02f,
  5.76112270e-02f, 3.25057246e-02f, -1.76101383e-02f, -1.85876023e-02f, -2.00336892e-02f, 2.89053023e-02f, -4.76699509e-02f, -4.42132391e-02f, 8.28030240e-03f, -4.99052275e-03f,
  1.20299426e-03f, 2.57270131e-02f, -3.85049805e-02f, 8.36487208e-03f, -4.94638197e-02f, -2.72228126e-03f, 2.74864398e-02f, 3.49159576e-02f, 3.34233977e-02f, -4.14286405e-02f,
  6.39634728e-02f, -2.88611632e-02f, 4.87429835e-02f, 5.87498993e-02f, -2.94039585e-02f, 5.68105467e-02f, 1.37087917e-02f, 7.52766132e-02f, 3.86134395e-03f, 6.96445033e-02f,
  3.17809969e-01f, 7.32100457e-02f, 4.08822000e-02f, 1.51155785e-01f, 8.61192495e-03f, -1.14908129e-01f, -2.30548814e-01f, 2.30503920e-02f, -1.28720999e-01f, -1.47780553e-01f,
  1.41294122e-01f, -1.79347947e-01f, -2.10268348e-01f, -1.24197770e-02f, 1.21377692e-01f, -2.01070160e-01f, 4.77076769e-02f, 6.08555088e-03f, -1.19751908e-01f, 5.25383390e-02f,
  -4.15549316e-02f, 8.88630152e-02f, -2.85207238e-02f, 2.35833004e-01f, 3.46635096e-02f, 2.31656298e-01f, 2.06045419e-01f, -5.19773476e-02f, 1.42727762e-01f, 4.74767238e-02f,
  -9.18327495e-02f, -9.13633481e-02f, 2.49952008e-03f, 2.28699800e-02f, 1.51316244e-02f, 7.18092993e-02f, -3.66139971e-02f, 3.01511623e-02f, -4.16849740e-02f, -1.67195555e-02f,
  -1.59839205e-02f, 1.03188148e-02f, 5.41751832e-02f, -3.39670782e-03f, 1.59957055e-02f, 3.82867269e-02f, -1.80575009e-02f, -2.36161537e-02f, -5.78089543e-02f, -5.39528728e-02f,
  -7.16758817e-02f, 7.30287209e-02f, 3.74420956e-02f, 6.30382895e-02f, 1.13154377e-03f, 1.97916292e-02f, -1.56979188e-02f, -6.17878996e-02f, 5.74134476e-03f, -1.14191912e-01f,
  3.44630219e-02f, 5.29388199e-03f, 4.01723236e-02f, 2.32375935e-02f, 3.68876904e-02f, 2.74401736e-02f, 1.07570905e-02f, 2.42532361e-02f, -1.76852755e-02f, -6.30298406e-02f,
  8.86431150e-03f, 4.46086116e-02f, -1.48453685e-02f, -3.02349925e-02f, 1.88362487e-02f, -4.44317162e-02f, 2.77703200e-02f, 3.75042334e-02f, -1.92971509e-02f, -8.70546419e-03f,
  -1.45934988e-03f, 6.79583773e-02f, 3.29676457e-02f, 3.12881656e-02f, 5.08645512e-02f, 7.19352588e-02f, 6.39977679e-03f, -4.16849665e-02f, -6.61113039e-02f, 7.55229592e-02f,
  2.41322946e-02f, 5.43742031e-02f, -3.50148305e-02f, -3.78377661e-02f, -3.02905701e-02f, 4.80374247e-02f, -3.79874557e-02f, -4.79013585e-02f, 4.90470938e-02f, 3.52711082e-02f,
  1.14916572e-02f, 5.59630394e-02f, 2.79386509e-02f, 6.06054999e-02f, 5.03055938e-02f, 4.73561101e-02f, -2.81719156e-02f, -6.20123893e-02f, -2.99417544e-02f, 4.15962785e-02f,
  2.66042724e-02f, -1.69858355e-02f, -2.50064628e-03f, -2.51768380e-02f, 1.64653808e-02f, -5.19900694e-02f, 3.44725586e-02f, 1.77030824e-02f, 1.79984216e-02f, -4.37654108e-02f,
  -2.04447936e-02f, -5.53155504e-03f, 5.01782075e-02f, -1.36429211e-03f, -7.91502222e-02f, -4.67451960e-02f, -9.38052610e-02f, -4.84761633e-02f, -1.33950815e-01f, -1.16077745e-02f,
  -4.85346764e-02f, -8.79945159e-02f, -7.35950023e-02f, 5.34192026e-02f, 8.80998746e-02f, -1.63904354e-01f, 1.43284956e-02f, -1.24583006e-01f, -3.30489576e-02f, 4.95044282e-03f,
  -7.28003383e-02f, 2.11678192e-01f, 8.22274387e-02f, 1.59469113e-01f, 1.29334077e-01f, -1.03795948e-02f, 1.82257980e-01f, 1.05389185e-01f, 8.94776359e-02f, 1.59326002e-01f,
  -8.51401128e-03f, -1.25688761e-02f, 5.33860438e-02f, -1.34786572e-02f, -5.53864576e-02f, 1.17362790e-01f, 7.95244873e-02f, -4.65635546e-02f, -6.93116486e-02f, -4.23486419e-02f,
  -8.58514234e-02f, 5.27272448e-02f, -3.33697200e-02f, -3.94433811e-02f, 8.63385275e-02f, 9.90686659e-03f, -2.55894102e-03f, -6.67191148e-02f, 6.99807424e-03f, -1.06067378e-02f,
  -6.23743832e-02f, -6.30633384e-02f, 7.75570348e-02f, -2.81475368e-03f, 1.70941520e-02f, -4.18388918e-02f, -4.03145747e-03f, 8.32725540e-02f, 7.11165741e-02f, 3.26823257e-02f,
  2.74652522e-03f, -3.75014432e-02f, 3.96424942e-02f, 6.28442168e-02f, -2.55856588e-02f, -1.51018286e-02f, -4.46643978e-02f, 3.44596244e-02f, 7.55688697e-02f, 9.27397888e-03f,
  8.37010220e-02f, 1.28351310e-02f, 2.21027583e-02f, -4.55750301e-02f, -4.82377559e-02f, 1.48665737e-02f, -6.74649328e-02f, 1.06984198e-01f, 2.44757924e-02f, -1.90087780e-02f,
  1.39036449e-02f, -2.47385018e-02f, -1.51912151e-02f, -1.80303995e-02f, -1.02689685e-02f, -2.46158242e-02f, 4.51913849e-02f, 3.32559459e-02f, 1.36691695e-02f, -8.55670422e-02f,
  6.79602772e-02f, -7.24476762e-03f, -3.62047777e-02f, 3.94265167e-02f, -8.60594958e-02f, -1.94735471e-02f, 3.89045104e-02f, 1.86615847e-02f, 1.87308416e-02f, 9.12759826e-03f,
  3.64649668e-02f, 2.00468022e-02f, -7.97050074e-03f, -8.21007229e-03f, 6.77374229e-02f, 3.72728817e-02f, -6.55036047e-03f, 6.79564429e-03f, 1.38424993e-01f, -2.22583450e-02f,
  -1.86767150e-02f, 1.65691674e-02f, 5.60955666e-02f, -1.74620207e-02f, -7.44798034e-02f, -1.20267414e-01f, 1.50665164e-03f, 1.71921924e-02f, 1.02656573e-01f, -3.91548611e-02f,
  -1.93786263e-01f, 9.12645832e-02f, -1.10837698e-01f, 9.00118947e-02f, 1.08711004e-01f, 3.65940511e-01f, 2.44889036e-01f, -1.07975602e-01f, -8.79435912e-02f, 1.38876423e-01f,
  1.01998508e-01f, -1.75399616e-01f, -5.46711013e-02f, 1.25369713e-01f, 6.55451715e-02f, 6.83269352e-02f, 1.24408200e-01f, 4.47237603e-02f, -2.70827264e-02f, -2.36581322e-02f,
  -4.59211580e-02f, 1.61205888e-01f, 3.52691524e-02f, -7.21388385e-02f, -2.34160270e-03f, -8.20272341e-02f, -1.70375931e-03f, -1.14386268e-01f, 1.82418898e-02f, 1.00166976e-01f,
  9.04457793e-02f, -1.53693676e-01f, -8.46412778e-02f, -5.01485504e-02f, 7.73909092e-02f, 5.62426485e-02f, 4.97954898e-02f, 1.03194833e-01f, -6.38244227e-02f, 2.09299512e-02f,
  1.02783842e-02f, 9.70640033e-03f, -8.05092230e-03f, -2.86787599e-02f, -8.28950480e-03f, -2.25890838e-02f, -9.29729119e-02f, 8.22254494e-02f, -1.70915410e-01f, -1.15030058e-01f,
  1.52589567e-02f, 7.39293471e-02f, -3.95901389e-02f, 7.14651942e-02f, 8.33612308e-03f, 6.26811087e-02f, 5.90103306e-02f, 9.69936512e-03f, 1.61031187e-02f, 2.92277634e-02f,
  2.34897286e-02f, -4.17783037e-02f, 9.40206274e-03f, 3.28104161e-02f, 3.06833722e-02f, -9.60444286e-03f, -4.46158573e-02f, -3.91951166e-02f, 6.19962299e-03f, -1.94023456e-02f,
  7.57972524e-02f, -2.68838033e-02f, -6.19171299e-02f, 5.82532324e-02f, -1.92911513e-02f, 5.00859469e-02f, 5.36436476e-02f, -6.66704178e-02f, 6.32868893e-03f, -3.07345502e-02f,
  -2.36922846e-04f, -3.16541381e-02f, 1.78611055e-02f, 3.61804776e-02f, -6.16115145e-02f, 2.21950300e-02f, -4.06224243e-02f, -2.13933457e-02f, -4.00450593e-03f, 6.05012104e-02f,
  2.50945818e-02f, 4.61675115e-02f, 6.44853851e-03f, 4.28822003e-02f, -1.93944257e-02f, -3.53154750e-03f, 4.03129235e-02f, -5.71587794e-02f, -6.50140131e-03f, -3.03935837e-02f,
  -2.85752304e-02f, -6.96893549e-03f, 5.04814833e-02f, -1.71000715e-02f, 7.91805834e-02f, 3.41359861e-02f, 2.16122381e-02f, -1.20375883e-02f, 7.58980140e-02f, 5.02522383e-03f,
  -2.80679017e-02f, 1.28177609e-02f, -3.19440998e-02f, 5.93998767e-02f, 4.52025235e-03f, 4.04464640e-02f, 3.26120742e-02f, -4.88807485e-02f, -9.23045911e-03f, -2.93951668e-02f,
  1.26060471e-01f, -4.48066533e-01f, 1.18213557e-02f, -5.42126410e-02f, 3.90580099e-04f, 5.04138991e-02f, 1.28390044e-01f, -1.49748638e-01f, -1.00124769e-01f, -1.15368851e-01f,
  9.14218500e-02f, -1.10486202e-01f, -7.79306814e-02f, -2.28392750e-01f, 1.35594457e-01f, -7.84810930e-02f, -1.65204871e-02f, -7.71864057e-02f, -9.13871601e-02f, -6.64044544e-02f,
  -6.73487559e-02f, -8.25164560e-03f, -2.03781091e-02f, 1.29909441e-02f, 2.29893792e-02f, 9.66578126e-02f, 1.47302970e-01f, 2.58917548e-02f, -1.49312457e-02f, 5.24399662e-03f,
  1.35601908e-02f, 1.12146288e-01f, 5.73123023e-02f, -6.13651983e-02f, 1.08628593e-01f, 1.08983107e-01f, 8.83103907e-02f, 8.79610553e-02f, 2.20427625e-02f, 3.69303301e-02f,
  9.00437310e-02f, 6.38648076e-03f, -7.11868852e-02f, 6.27710447e-02f, 6.84751943e-02f, -2.60555348e-03f, 1.08417179e-02f, -5.50721772e-02f, 4.41087708e-02f, 1.55085688e-02f,
  2.91672628e-02f, 3.18106823e-02f, -8.73398501e-03f, -1.26163370e-03f, 2.90852245e-02f, 8.36223140e-02f, 3.98984328e-02f, 1.00042736e-02f, -6.43577650e-02f, -3.24496664e-02f,
  -3.89961079e-02f, 4.07337137e-02f, 6.38379380e-02f, 4.22935421e-03f, 1.63755529e-02f, 4.52005304e-02f, 2.73416638e-02f, -8.63008797e-02f, -8.64896849e-02f, 3.61014791e-02f,
  -4.73028272e-02f, -3.44374590e-03f, 1.51351665e-03f, -1.85911246e-02f, -1.86818130e-02f, 7.82582760e-02f, -4.49190550e-02f, 3.24187875e-02f, -9.25400704e-02f, 4.23968397e-02f,
  7.07676494e-03f, 8.24029837e-03f, 3.03885862e-02f, -3.46700326e-02f, 6.06678911e-02f, 1.84926204e-02f, -5.66449240e-02f, -4.12513576e-02f, 5.68374107e-03f, -5.11469366e-03f,
  -4.31859866e-02f, -1.05241232e-01f, 9.80695244e-03f, 7.49588013e-02f, -2.17006598e-02f, 1.38067668e-02f, -3.90378051e-02f, -2.12150309e-02f, 1.13113807e-03f, -5.43920919e-02f,
  4.53982353e-02f, 7.16838613e-02f, 9.54625234e-02f, -1.97839458e-02f, -4.49108109e-02f, -8.13447610e-02f, 1.02437176e-02f, -7.62049761e-03f, -7.01669231e-02f, -4.22300920e-02f,
  -2.30935346e-02f, 2.28905492e-02f, 2.17179526e-02f, 4.05902267e-02f, -1.59342196e-02f, -2.60884743e-02f, -4.94407602e-02f, -4.30471562e-02f, 3.87849286e-02f, -2.82198656e-02f,
  4.08647239e-01f, -4.70416360e-02f, -1.39104739e-01f, 6.59401193e-02f, 1.01627551e-01f, -2.78555840e-01f, -2.36197278e-01f, 1.46679273e-02f, 7.07417950e-02f, -2.54146680e-02f,
  -3.65238562e-02f, 6.90920427e-02f, -7.30049796e-03f, -1.19462751e-01f, 4.35123220e-03f, -6.73354492e-02f, -1.78800151e-01f, -5.14251888e-02f, 5.06111374e-03f, -5.35595156e-02f,
  9.69450772e-02f, -9.56501216e-02f, -8.71362016e-02f, -3.28459404e-02f, -6.50999621e-02f, -5.86131699e-02f, 6.93509057e-02f, -1.30706966e-01f, -1.13383502e-01f, -5.64635172e-02f,
  1.31035060e-01f, 1.82805881e-01f, 7.82424957e-02f, 9.63085964e-02f, -2.64561735e-02f, 7.32138008e-02f, -2.51230448e-02f, 1.81931965e-02f, 4.07320783e-02f, -5.07668182e-02f,
  -5.74834608e-02f, 2.81669144e-02f, 1.94374453e-02f, -6.22412935e-03f, 1.33589692e-02f, 5.15677072e-02f, -8.53690580e-02f, -2.26380327e-03f, -5.21321036e-02f, -2.11353302e-02f,
  -1.07277758e-01f, -3.39923124e-03f, 1.04504274e-02f, -5.39280213e-02f, -3.21900845e-02f, -1.06730964e-02f, 1.02600204e-02f, -2.45324820e-02f, -7.25525245e-02f, 1.94917712e-03f,
  3.70399430e-02f, 3.49493325e-02f, -6.23803250e-02f, 2.16980577e-02f, -8.24886002e-03f, 3.11297495e-02f, -3.64642777e-02f, 1.06338225e-01f, -2.44631842e-02f, 8.46857727e-02f,
  6.74637854e-02f, -7.12345075e-03f, 6.05683774e-02f, -7.77276978e-02f, -2.70343237e-02f, 9.14728120e-02f, -5.82502782e-03f, 3.42556164e-02f, -3.54232676e-02f, 3.06791272e-02f,
  -3.91030349e-02f, -9.31679178e-03f, 5.77233592e-03f, 6.92580491e-02f, -1.11832619e-02f, -1.52313029e-02f, 2.75608711e-02f, 2.61701178e-02f, -3.61779742e-02f, -7.14799985e-02f,
  -8.54885355e-02f, -6.07379377e-02f, -2.42146384e-02f, -2.22928915e-02f, -1.06070815e-02f, 6.63364604e-02f, -5.08292131e-02f, -5.92942089e-02f, -1.52237490e-01f, -3.63955498e-02f,
  3.42913717e-02f, 8.21869075e-02f, 7.83985108e-02f, 6.77753007e-03f, 1.68090425e-02f, -1.14784297e-02f, 4.99620996e-02f, -2.32034978e-02f, 1.39777176e-02f, 2.44988387e-05f,
  5.23570925e-02f, 1.40638845e-02f, -4.67293188e-02f, 7.06188008e-02f, 1.11933900e-02f, 5.27861575e-03f, 9.74591151e-02f, 3.68369073e-02f, -3.01520191e-02f, -5.17245429e-03f,
  -9.64669287e-02f, -7.41473362e-02f, 3.28427032e-02f, 3.34024616e-02f, 6.33585751e-02f, -1.71611831e-01f, -1.75802186e-01f, -7.75901675e-02f, -7.74428993e-03f, -9.40768570e-02f,
  2.71793883e-02f, 7.70047605e-02f, -3.96653786e-02f, 6.60328194e-02f, -6.37056231e-02f, -2.45658550e-02f, -4.57510129e-02f, -1.03503175e-01f, 1.51202539e-02f, 8.92493967e-03f,
  -4.85591628e-02f, 7.99892843e-02f, 4.44355235e-02f, 2.08913051e-02f, 6.11891970e-02f, -1.94372032e-02f, -3.08153257e-02f, 3.21089141e-02f, 3.07837017e-02f, 5.12584224e-02f,
  -1.57595202e-02f, 9.45781842e-02f, -4.44552279e-04f, -5.64985797e-02f, -3.70072983e-02f, -4.08250615e-02f, -4.76167277e-02f, 1.31138237e-02f, 2.93152649e-02f, 2.47480273e-02f,
  -7.15486556e-02f, 1.35849165e-02f, 1.24324067e-02f, 2.60936227e-02f, -8.77503157e-02f, -5.32193296e-02f, 1.17973834e-02f, -3.24088261e-02f, 5.97684532e-02f, -5.46572246e-02f,
  8.48468468e-02f, -1.24583738e-02f, 3.51402499e-02f, -7.28314742e-02f, -4.02442291e-02f, -7.00277183e-03f, 2.79165688e-04f, -4.57777968e-03f, 7.02625662e-02f, -2.54137022e-03f,
  -1.12163946e-01f, -9.13883150e-02f, 7.25565478e-02f, 7.51397982e-02f, 8.90219584e-02f, 6.65373882e-05f, 7.01422244e-02f, -1.43447137e-02f, -2.78387661e-03f, -7.21821561e-02f,
  -3.18361931e-02f, -1.13450900e-01f, -4.03220113e-03f, -7.20891505e-02f, 1.16286529e-02f, -7.71491081e-02f, 2.79344805e-02f, -1.41235637e-02f, 4.65758108e-02f, -4.26833034e-02f,
  2.28577312e-02f, 2.44290158e-02f, -5.15447669e-02f, 7.87021709e-04f, 1.17740966e-02f, 2.04112828e-02f, 1.43618481e-02f, 6.88683465e-02f, -4.07537483e-02f, -2.52047461e-02f,
  -5.94817288e-03f, 2.98754927e-02f, 3.23789828e-02f, 4.08621393e-02f, 1.72569267e-02f, -7.58093521e-02f, -2.20713131e-02f, -3.42782736e-02f, -9.50929150e-02f, 1.88312549e-02f,
  -1.00503601e-01f, -7.74649158e-02f, -5.00821583e-02f, 4.57762890e-02f, -3.82140242e-02f, 9.86101013e-03f, 2.71864887e-02f, -2.95735653e-02f, 6.73509948e-03f, 5.51084541e-02f,
  -5.86395108e-05f, -1.99946724e-02f, 2.47020405e-02f, -5.95491827e-02f, 6.98407996e-04f, 4.80105123e-03f, 4.69861872e-04f, -9.53156501e-02f, -9.85310897e-02f, -5.94852306e-02f,
  1.49981782e-01f, -8.62529650e-02f, 8.48491862e-02f, 5.59682921e-02f, 4.06253934e-02f, 5.04842624e-02f, 1.92496613e-01f, -3.23313102e-02f, 1.21243879e-01f, -2.19646230e-01f,
  -1.56468868e-01f, -3.37437019e-02f, -3.15969624e-02f, 7.77961984e-02f, 3.96541923e-01f, 2.78390586e-01f, 1.07769512e-01f, 9.10835713e-03f, 3.83243524e-02f, -1.21116854e-01f,
  6.43992946e-02f, -8.72361585e-02f, 1.63277596e-01f, -1.64809257e-01f, -3.82598415e-02f, -1.50775149e-01f, -1.38041660e-01f, -5.70717864e-02f, -1.41207144e-01f, 8.51582140e-02f,
  1.16855659e-01f, 3.57290022e-02f, -2.04836205e-03f, 3.92216705e-02f, -3.28756385e-02f, -4.33865190e-02f, -5.87963089e-02f, 2.20120978e-02f, 3.64314355e-02f, -3.87107208e-02f,
  -1.09512703e-02f, 2.35217679e-02f, 8.40069577e-02f, -1.16579076e-02f, -5.27621619e-02f, -9.65216849e-03f, -3.25730513e-03f, 2.32707877e-02f, 6.62574125e-03f, 3.11910175e-02f,
  7.92284459e-02f, -6.64890744e-03f, -1.15800299e-01f, 5.96293341e-03f, 4.04602401e-02f, -1.55258281e-02f, -3.07561439e-02f, 1.07177710e-02f, 1.82531830e-02f, 7.73388594e-02f,
  -2.92947646e-02f, -3.16970013e-02f, 1.03825852e-02f, 2.20886935e-02f, -4.89936210e-02f, -9.14102979e-03f, -5.07036671e-02f, 9.96111520e-03f, -3.86937745e-02f, -5.44489212e-02f,
  3.45312315e-03f, -5.21135405e-02f, 2.85945032e-02f, -6.29977584e-02f, 2.94889677e-02f, -3.84502448e-02f, 3.42115313e-02f, -1.72674470e-02f, 5.94171248e-02f, 3.63147166e-03f,
  5.04879914e-02f, 8.70177671e-02f, -1.75656062e-02f, 2.12396402e-02f, 4.42219824e-02f, -6.07372634e-03f, -1.21873999e-02f, -1.51246833e-02f, 3.40333395e-02f, -9.70409252e-03f,
  -7.09121525e-02f, -1.48489848e-01f, -6.82668239e-02f, -1.52460402e-02f, 4.50051315e-02f, -6.62552789e-02f, 5.56476749e-02f, 2.69806609e-02f, 5.18596126e-03f, 3.41557786e-02f,
  -9.06557590e-02f, -7.52865300e-02f, -4.55413200e-02f, 5.38000884e-03f, 7.74494046e-03f, -7.90723562e-02f, 1.69164296e-02f, -4.67648543e-03f, -4.41343077e-02f, -1.02554627e-01f,
  -1.73670780e-02f, -4.58246050e-03f, 4.87156436e-02f, -3.90986428e-02f, -7.54349157e-02f, 5.52094951e-02f, 1.62674468e-02f, 6.27294008e-04f, -1.13584911e-02f, 1.57470834e-02f,
  -2.20869482e-01f, -9.04643442e-03f, 1.04822837e-01f, -6.43836632e-02f, -5.39768562e-02f, 2.17232391e-01f, 1.03858046e-01f, -3.21921892e-02f, -1.77997537e-03f, 1.48844663e-02f,
  1.18901893e-01f, -5.81198335e-02f, 1.35855660e-01f, 5.95236663e-03f, -5.37866354e-03f, 1.00471094e-01f, 7.73553690e-03f, 2.17364123e-03f, 4.24096435e-02f, -7.97688439e-02f,
  -5.53218611e-02f, -1.17042027e-01f, 4.37007211e-02f, -5.91443153e-03f, -2.22830847e-02f, -1.67646304e-01f, -6.21687621e-02f, -4.17099334e-02f, -4.74676229e-02f, -8.07866082e-02f,
  1.05293458e-02f, -1.08893931e-01f, -3.47187137e-03f, 1.13879601e-02f, 1.55052473e-03f, -4.61921431e-02f, -3.70044149e-02f, 2.85400748e-02f, -6.24872297e-02f, -5.68088517e-02f,
  -3.52136493e-02f, -4.98565771e-02f, -3.56031619e-02f, 4.52227108e-02f, -4.06527333e-02f, -3.48232277e-02f, -2.70726457e-02f, 1.72355790e-02f, -5.98651096e-02f, 4.45998497e-02f,
  4.27090637e-02f, -8.84298086e-02f, 1.31743308e-03f, 2.16229283e-03f, 5.03539816e-02f, -1.83092058e-02f, 6.33202940e-02f, -1.23209003e-02f, 1.79039277e-02f, -1.27149653e-02f,
  1.44261336e-02f, -7.56360590e-02f, 3.28807384e-02f, -9.69720408e-02f, 1.18942838e-02f, -5.55170700e-02f, 7.32522979e-02f, 3.78309228e-02f, -1.03788644e-01f, 8.14310089e-02f,
  5.45366816e-02f, 6.82773814e-02f, 2.30567474e-02f, -5.50175644e-02f, -1.61722105e-03f, 1.89016070e-02f, -6.67005405e-02f, 2.74401214e-02f, -1.01959957e-02f, -5.21350056e-02f,
  2.57187244e-02f, -9.54028033e-03f, 2.88714319e-02f, 2.14311723e-02f, 6.67454451e-02f, 4.81833983e-03f, 4.70802072e-04f, 4.94919978e-02f, -4.28716466e-02f, -1.01232845e-02f,
  3.94758098e-02f, 6.97217435e-02f, -4.78877360e-03f, -3.85741293e-02f, -4.67525944e-02f, 3.03780474e-02f, 1.33992434e-02f, -4.44013290e-02f, 6.79851323e-02f, 5.66139296e-02f,
  -9.62894352e-04f, 8.82809609e-03f, -9.57631022e-02f, 3.79656181e-02f, 2.98484806e-02f, 8.87844115e-02f, 6.06819764e-02f, -3.65347825e-02f, 5.54952212e-02f, 1.60197876e-02f,
  5.22748977e-02f, -9.25971474e-03f, -1.47505449e-02f, 5.72962454e-03f, -7.51107698e-03f, -4.37531024e-02f, -8.73197094e-02f, 4.05310132e-02f, -5.94395548e-02f, -2.12054439e-02f,
  2.37365752e-01f, 1.66474320e-02f, -1.59898903e-02f, 2.28881180e-01f, -1.19755521e-01f, 7.89612010e-02f, -2.47776452e-02f, 4.68842648e-02f, 1.42302200e-01f, -4.53997776e-02f,
  3.41450386e-02f, -7.17576370e-02f, -4.75646146e-02f, 2.06814289e-01f, 1.46497563e-01f, 3.82140838e-02f, 2.64565945e-01f, 7.31545389e-02f, 3.43544148e-02f, 2.81299334e-02f,
  5.81777915e-02f, 8.08710009e-02f, 5.80444969e-02f, -1.37207797e-02f, -2.61793658e-02f, -1.37554295e-02f, 9.39147621e-02f, -1.04014590e-01f, -7.32260616e-03f, -4.26435284e-02f,
  8.50887373e-02f, 2.96093654e-02f, 6.13947362e-02f, -3.98227153e-03f, -1.43426470e-02f, -5.43019660e-02f, -8.65588486e-02f, -2.33103968e-02f, 1.65147651e-02f, 1.43328365e-02f,
  -6.46834448e-02f, -8.38132799e-02f, 3.59067358e-02f, 1.86122451e-02f, 3.16734575e-02f, 2.44104885e-03f, -2.43618619e-02f, -1.23852350e-01f, -2.97091790e-02f, 1.55240623e-02f,
  -1.42479032e-01f, -4.89325002e-02f, 3.64844538e-02f, 1.28173726e-02f, 3.97253707e-02f, 1.18868556e-02f, -5.80517054e-02f, -3.67919020e-02f, 3.15804183e-02f, 7.65036196e-02f,
  -3.94149385e-02f, -6.47303611e-02f, 3.06129418e-02f, -1.91474613e-02f, -9.22886282e-02f, -5.82061000e-02f, -4.76524234e-03f, 6.42494187e-02f, -3.80968340e-02f, -7.04121031e-03f,
  6.18326776e-02f, 3.98046859e-02f, 1.24222171e-02f, -1.79716684e-02f, 2.52938643e-03f, 2.51472136e-03f, 1.82155930e-02f, 4.94838087e-03f, 4.76786047e-02f, -3.06896959e-03f,
  2.08693650e-02f, 3.99238197e-03f, -1.96631812e-02f, 1.67638417e-02f, -1.87408291e-02f, 1.57458102e-03f, -1.87868327e-02f, -2.46227290e-02f, 8.34765732e-02f, -9.00949538e-03f,
  -6.31930828e-02f, 6.96326420e-02f, -1.14412913e-02f, -5.65199666e-02f, -4.97136526e-02f, 1.73360724e-02f, 9.55104083e-02f, -4.60818224e-03f, 2.17881147e-02f, 5.87765127e-02f,
  -7.55032152e-02f, -2.51377411e-02f, -7.13151097e-02f, -4.65759682e-03f, -2.84577813e-02f, -6.37617311e-04f, -3.76685262e-02f, 4.46673110e-02f, -1.55136245e-03f, 3.83499637e-02f,
  -5.14999367e-02f, -3.40167992e-02f, 6.04136027e-02f, -6.20536730e-02f, -9.61304549e-03f, 6.54846604e-04f, -7.25163892e-02f, -4.02469933e-03f, -8.69817100e-03f, -4.00738977e-02f,
  3.32903236e-01f, -4.03792076e-02f, 1.04168423e-01f, 1.44554600e-01f, 1.09147616e-01f, 9.00990292e-02f, 1.24422461e-01f, 1.85853183e-01f, 7.50477836e-02f, -4.27979417e-02f,
  -3.80123965e-02f, 3.04064974e-02f, -2.45032892e-01f, -6.80860206e-02f, 1.02007529e-03f, -2.55163282e-01f, 7.47836977e-02f, 1.46636084e-01f, -9.86794159e-02f, 1.45604223e-01f,
  1.15369476e-01f, 8.22001398e-02f, -1.12173796e-01f, 3.34924348e-02f, 7.77676478e-02f, 4.82884943e-02f, 7.57454485e-02f, -1.09749936e-01f, 5.00816368e-02f, -1.88019916e-01f,
  7.96519127e-03f, -1.90747723e-01f, -4.18924205e-02f, 3.75985578e-02f, 5.85978068e-02f, 2.76786815e-02f, 5.72555996e-02f, -8.02454725e-02f, 4.74538421e-03f, 1.31029301e-04f,
  1.23307901e-02f, 2.13375501e-02f, 2.49952674e-02f, 1.93728656e-02f, -6.08211793e-02f, 3.99763696e-02f, 9.17909369e-02f, -3.04945856e-02f, -2.22328119e-02f, -2.99003981e-02f,
  4.77040298e-02f, 1.00367516e-02f, 5.80353364e-02f, 3.64020243e-02f, -1.74408592e-02f, 1.16667440e-02f, 3.80538888e-02f, -3.16740088e-02f, 7.81062571e-03f, -1.99614675e-03f,
  7.24821985e-02f, 3.06699574e-02f, -1.78069044e-02f, 4.26052585e-02f, 1.08975479e-02f, 4.39920463e-02f, 8.80235061e-02f, 5.05727641e-02f, -2.65652128e-02f, 8.78373832e-02f,
  4.54536863e-02f, 9.87730920e-03f, 3.06447428e-02f, 3.89676616e-02f, 1.24692440e-01f, -9.17705335e-03f, -4.68779020e-02f, 7.81194046e-02f, 7.87558928e-02f, -2.44150665e-02f,
  -6.06972948e-02f, -1.89685095e-02f, -5.67223169e-02f, 4.07523364e-02f, -2.39247661e-02f, 2.23397017e-02f, -7.70067750e-03f, -9.00500640e-02f, -1.60434451e-02f, 2.49544196e-02f,
  1.70040820e-02f, 9.42346901e-02f, 3.03240772e-02f, -3.09352241e-02f, -3.90489772e-02f, 4.39948961e-02f, -2.78681591e-02f, -7.98845217e-02f, 5.79191446e-02f, 4.58710194e-02f,
  1.10293634e-01f, 2.61277426e-03f, 1.65569596e-02f, -4.32662852e-02f, 2.44127009e-02f, 2.02383753e-02f, 8.17404687e-03f, -3.86672318e-02f, 6.69307634e-03f, -7.11572915e-02f,
  -2.13173889e-02f, 3.71301509e-02f, 6.24480471e-02f, -2.13726033e-02f, 4.84436713e-02f, -2.54820120e-02f, 2.20630392e-02f, -1.22253653e-02f, 2.99269171e-03f, 7.94392638e-03f,
  8.49261433e-02f, -1.64605193e-02f, -7.62764961e-02f, -1.74471494e-02f, -5.34486808e-02f, 1.36176804e-02f, -3.49950306e-02f, -1.23436250e-01f, -6.71583638e-02f, -3.92945372e-02f,
  -2.00873211e-01f, 1.29272088e-01f, 1.28884418e-02f, 3.90199721e-02f, 2.78614104e-01f, 1.91623688e-01f, -9.39265862e-02f, 9.50278714e-02f, 6.37819543e-02f, -5.38251176e-02f,
  1.96297970e-02f, 8.97812769e-02f, 1.62700295e-01f, -6.78394660e-02f, 8.77553783e-03f, -3.16013619e-02f, -2.31794678e-02f, 5.76493479e-02f, -7.10796863e-02f, -1.14630656e-02f,
  -6.94946502e-04f, -4.42488119e-02f, -1.08652622e-01f, 2.17977557e-02f, 2.09981930e-02f, -8.31128731e-02f, 4.50565945e-03f, -8.32707738e-04f, -1.45299528e-02f, 4.28411625e-02f,
  1.18231043e-01f, -3.50304693e-02f, -3.27072330e-02f, 3.28228436e-02f, -4.53699008e-02f, -4.88620847e-02f, 7.71175250e-02f, -1.43455639e-02f, -5.76869510e-02f, -1.82388909e-02f,
  1.09056970e-02f, -1.99126452e-02f, 4.27516364e-02f, -5.43024912e-02f, -2.44696736e-02f, -1.71073854e-01f, 7.45984316e-02f, 3.64176754e-04f, -7.28559587e-03f, 1.94472205e-02f,
  3.03253885e-02f, -8.25140327e-02f, -3.43910903e-02f, -8.95149484e-02f, 1.66564900e-02f, -1.21172391e-01f, 1.42362323e-02f, 4.71541658e-02f, 5.07054627e-02f, -8.90705618e-04f,
  3.85296755e-02f, 8.88213702e-03f, 1.25383511e-01f, 5.33819087e-02f, -5.06119393e-02f, -4.46127616e-02f, 4.50873002e-03f, -2.80553158e-02f, -2.93573141e-02f, 3.35294120e-02f,
  -3.57783735e-02f, 7.39914877e-03f, -4.09893366e-03f, -3.81160453e-02f, -3.94436046e-02f, 1.08513452e-01f, -5.29047139e-02f, -4.62466106e-02f, -4.45300005e-02f, -2.08491720e-02f,
  -2.94597596e-02f, -1.25972539e-01f, 5.57614071e-03f, -1.15364033e-03f, 1.54250581e-02f, -2.65680347e-02f, 7.00661391e-02f, -4.61222380e-02f, -9.19850692e-02f, -1.99131910e-02f,
  -1.20047987e-01f, 4.48120758e-02f, -3.91954993e-04f, 6.45469595e-03f, -5.71148619e-02f, -7.48008564e-02f, -6.21540546e-02f, 1.22719910e-02f, -3.47160287e-02f, -1.03616312e-01f,
  -3.08354869e-02f, 2.37055160e-02f, 7.72375939e-03f, 5.68055362e-02f, 9.12691206e-02f, 2.57502906e-02f, -7.86067918e-02f, -4.98158373e-02f, -1.15502859e-02f, -6.63607894e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.95368303e-02f, -2.24120498e-01f, -1.40524566e-01f, -1.37918890e-02f, -9.74273458e-02f, -4.18051071e-02f, -9.42860842e-02f, -1.06106997e-01f, 3.20237055e-02f, -1.08437471e-01f,
  -3.29103731e-02f, 6.91218227e-02f, 8.11757594e-02f, -1.25773937e-01f, 1.87401235e-01f, 1.44098513e-02f, -1.52792528e-01f, 4.55601215e-02f, -4.01753350e-04f, -5.20424061e-02f,
  8.34063441e-02f, -1.06194995e-01f, -4.06117439e-02f, -1.83976218e-01f, -6.19582310e-02f, -6.74158931e-02f, -1.45400455e-02f, 1.28722945e-02f, -1.00198435e-02f, -6.72301184e-03f,
  -2.91903801e-02f, 1.40152471e-02f, -3.45338061e-02f, -2.90828776e-02f, 6.24439493e-03f, -6.03187568e-02f, 5.67912534e-02f, 8.09196681e-02f, 2.67860815e-02f, -6.57691658e-02f,
  2.10390817e-02f, -6.18197536e-03f, -2.96680965e-02f, 1.16973734e-02f, -2.30801515e-02f, -3.69310565e-03f, -4.35883291e-02f, -1.44108513e-03f, -4.55691889e-02f, 6.68858439e-02f,
  -4.42533977e-02f, -2.72902865e-02f, 3.11299581e-02f, 1.54260090e-02f, -1.22346710e-02f, -1.00892903e-02f, -2.38230694e-02f, -2.26443782e-02f, -3.28416415e-02f, -3.61549705e-02f,
  -2.34267954e-02f, 9.99066606e-03f, 2.92273387e-02f, 1.94647368e-02f, -4.51738723e-02f, -8.78916159e-02f, -4.63788584e-02f, 7.18929023e-02f, 2.83835679e-02f, -3.31894830e-02f,
  -9.22425371e-03f, 4.65003308e-03f, -6.12610653e-02f, 6.55021518e-02f, 6.96401671e-02f, -1.16684828e-02f, -2.61367764e-02f, -1.19076623e-02f, -9.52529609e-02f, 3.71761397e-02f,
  -1.04782293e-02f, 9.31592193e-03f, -9.28272307e-02f, -4.49914597e-02f, -7.84135312e-02f, -3.57462950e-02f, -1.15163788e-01f, -9.31156576e-02f, 1.00936331e-01f, 2.22871080e-02f,
  -4.10842448e-02f, -3.93210091e-02f, 5.23521937e-02f, -3.29302326e-02f, -1.04298247e-02f, -9.43030976e-03f, 4.98766638e-02f, -1.03950970e-01f, 1.23980660e-02f, 1.25466391e-01f,
  3.97267081e-02f, -6.69516474e-02f, 4.38427515e-02f, 6.11336231e-02f, -9.89248790e-03f, -5.13603017e-02f, -3.86806168e-02f, -4.35006060e-02f, 1.86209474e-02f, 3.88030037e-02f,
  7.04525709e-02f, 3.92309837e-02f, 8.39901040e-04f, -5.14597483e-02f, -1.44952559e-03f, -5.59902098e-03f, 4.01597656e-03f, -5.34433760e-02f, -7.59088472e-02f, -7.71499425e-02f,
  1.38139114e-01f, 2.37397134e-01f, 2.36112818e-01f, 1.56152904e-01f, -6.78042620e-02f, -2.62266934e-01f, -1.34232998e-01f, 6.54374138e-02f, -2.10236181e-02f, 2.26345519e-03f,
  -1.15022637e-01f, 1.86131075e-01f, 4.56418283e-02f, -1.89294592e-02f, -1.60624906e-01f, -5.08264601e-02f, -1.56330422e-01f, -1.15091339e-01f, -3.09510175e-02f, 9.35461596e-02f,
  1.13296229e-02f, -2.05770992e-02f, 1.38938710e-01f, 4.07348238e-02f, -3.41182202e-02f, 5.34656458e-02f, -3.99669679e-03f, 7.32774436e-02f, 1.73228513e-02f, -8.22130591e-02f,
  -1.16607405e-01f, 1.44591570e-01f, 3.14994156e-02f, 1.58972368e-02f, 1.80763751e-02f, -6.22494370e-02f, 4.49386984e-02f, -7.99119622e-02f, 9.93606728e-03f, 6.87637692e-03f,
  -2.69436352e-02f, -6.57347664e-02f, 4.56587188e-02f, 8.53263307e-03f, -9.12831444e-03f, 5.03740646e-02f, 1.26744226e-01f, 2.56304778e-02f, 6.60484359e-02f, 5.90632334e-02f,
  1.32109419e-01f, -9.09180846e-03f, -2.79130246e-02f, -8.29881988e-03f, 4.95964177e-02f, 4.06655855e-03f, -5.03442176e-02f, 4.07103971e-02f, -1.96862649e-02f, -1.60837602e-02f,
  2.43127868e-02f, -8.05501118e-02f, 3.69095802e-02f, 1.90590750e-02f, 9.32323039e-02f, -1.69282313e-02f, -2.23726383e-03f, -2.34075524e-02f, 6.81878952e-03f, -1.74087230e-02f,
  -1.02993801e-01f, 6.93621635e-02f, -4.05167229e-02f, -5.17656729e-02f, 4.43440564e-02f, 6.77734390e-02f, -2.86296383e-03f, 6.00687088e-03f, -3.21601219e-02f, 3.36198136e-02f,
  -2.15630978e-02f, -3.54966223e-02f, 1.72650348e-02f, 7.53773153e-02f, -7.99493641e-02f, 5.07120192e-02f, 3.05987503e-02f, -3.77600491e-02f, 2.17285454e-02f, -2.61180215e-02f,
  4.89878934e-03f, 4.21347134e-02f, -8.95895716e-03f, -5.05236611e-02f, -1.85693596e-02f, -2.84202471e-02f, -1.24105047e-02f, -2.40912586e-02f, 7.43156224e-02f, -1.18298836e-01f,
  2.27845085e-04f, -9.16811600e-02f, -2.98266057e-02f, 4.18005958e-02f, -5.05441464e-02f, -7.93741420e-02f, -1.65953506e-02f, -4.37414795e-02f, 1.95544176e-02f, -1.40257850e-02f,
  8.26838613e-03f, 7.46724370e-04f, -7.55585283e-02f, 4.60121445e-02f, 5.01644984e-02f, -1.74976420e-02f, -7.25034252e-02f, -2.12711561e-02f, -1.65984668e-02f, 7.54953325e-02f,
  -4.62333001e-02f, -1.29747260e-02f, 8.81876647e-02f, -1.81139819e-02f, 2.38498747e-02f, -7.16999592e-03f, -6.12204410e-02f, 1.50117964e-01f, 1.41324162e-01f, -1.15736209e-01f,
  -7.85674229e-02f, -6.47460669e-02f, 3.14413682e-02f, -3.74747477e-02f, -2.86260191e-02f, -1.23498395e-01f, -6.63758144e-02f, 3.41312252e-02f, -4.44297902e-02f, 1.10373415e-01f,
  7.02725798e-02f, -9.34976190e-02f, -3.88621837e-02f, 7.45709240e-02f, 9.22128707e-02f, 2.57635619e-02f, -6.61566108e-02f, 1.95309836e-02f, -6.91443160e-02f, 4.91487943e-02f,
  -4.30369982e-03f, 1.86453424e-02f, -5.64005636e-02f, 4.64055948e-02f, 7.21672103e-02f, -2.90750712e-02f, -5.04741743e-02f, 1.65975609e-04f, -5.52356727e-02f, -2.13489272e-02f,
  9.84845217e-03f, -4.16483544e-02f, 7.53627270e-02f, 8.42841119e-02f, 5.29207736e-02f, 3.56127396e-02f, 7.86540210e-02f, -1.32919997e-02f, -6.56945780e-02f, -5.84599003e-02f,
  -5.60128577e-02f, 6.89117014e-02f, -1.83692202e-02f, 2.04978865e-02f, -2.05396451e-02f, -2.57589836e-02f, 6.13132352e-03f, -4.49355468e-02f, 2.73120217e-02f, -2.26659440e-02f,
  -9.91576687e-02f, -2.63308547e-02f, 6.06445894e-02f, -5.05457446e-02f, 9.03925076e-02f, -5.05501367e-02f, -4.92496230e-02f, 7.51111954e-02f, 8.89888778e-02f, -7.52882585e-02f,
  9.09396484e-02f, -3.72336549e-03f, 1.06281452e-01f, 4.68484573e-02f, -1.96920745e-02f, -7.16910809e-02f, -8.26486677e-04f, -7.31663704e-02f, 7.09170010e-03f, 1.30699575e-02f,
  1.83396898e-02f, -3.22550014e-02f, -1.92483049e-02f, -1.05013298e-02f, -1.67382918e-02f, 5.61824366e-02f, -6.28616288e-02f, -8.05435032e-02f, -7.25088567e-02f, 5.66434450e-02f,
  -1.03936955e-01f, 4.07162085e-02f, 6.91131875e-03f, -3.06294113e-03f, 9.54665523e-03f, -1.07212014e-01f, 3.49668488e-02f, 6.43825382e-02f, -4.17133272e-02f, 8.10179487e-02f,
  -1.26536429e-01f, 1.06455050e-02f, -5.21185398e-02f, -5.69042265e-02f, -2.77245231e-02f, 1.13848401e-02f, -4.94812466e-02f, 4.69505228e-03f, -1.72990672e-02f, 3.11610214e-02f,
  2.48208940e-02f, 8.46768245e-02f, 1.08314343e-02f, -6.90386817e-02f, 6.58491161e-03f, 1.51567366e-02f, 2.52268426e-02f, -5.61595969e-02f, 1.57792941e-02f, -1.15469389e-01f,
  4.36065346e-02f, -2.09957939e-02f, -1.65800266e-02f, 1.72999166e-02f, 5.32812579e-03f, -4.37893160e-02f, 1.42413909e-02f, -1.20995427e-03f, 2.94106267e-02f, 4.28800918e-02f,
  -9.57459770e-03f, -3.12164761e-02f, -3.41265425e-02f, -4.60587330e-02f, -7.25052580e-02f, 4.24335897e-02f, 5.77910524e-03f, 2.35548392e-02f, -1.23627502e-02f, 1.17750011e-01f,
  1.90387741e-02f, -3.44845466e-02f, 3.16224657e-02f, 2.05100384e-02f, 6.64666519e-02f, -4.99219224e-02f, -2.38385014e-02f, 8.92862901e-02f, -1.35735776e-02f, -1.38479555e-02f,
  -5.27485088e-02f, 1.69544816e-02f, -2.99866945e-02f, 1.48486802e-02f, 1.98202971e-02f, -6.37665316e-02f, 8.19419324e-02f, -2.12745443e-02f, 9.79121700e-02f, 8.89168296e-04f,
  3.42742093e-02f, -4.41521667e-02f, -4.17576134e-02f, 3.57250758e-02f, 1.98363736e-02f, -2.42396351e-02f, -5.17110154e-02f, 4.21041772e-02f, 5.59276827e-02f, -6.12649880e-03f,
  -9.54723582e-02f, 3.36817913e-02f, 8.78442004e-02f, -6.91443086e-02f, 1.93827506e-02f, 3.73555794e-02f, -6.90643415e-02f, 1.18239345e-02f, -6.15110993e-02f, 1.03704510e-02f,
  1.08626008e-01f, -2.72130258e-02f, 7.88645819e-02f, -9.43101272e-02f, -6.57584667e-02f, -4.80439402e-02f, -4.75592241e-02f, -4.30232361e-02f, -9.61432606e-02f, 3.28223817e-02f,
  1.00166932e-01f, -1.08048566e-01f, -3.38529907e-02f, -5.54927066e-02f, -1.27515141e-02f, 7.77028576e-02f, -4.33987901e-02f, -7.23351091e-02f, -1.48279658e-02f, -3.29316556e-02f,
  7.77327493e-02f, 6.30340651e-02f, 5.34845442e-02f, 5.10446876e-02f, -2.91888323e-02f, -1.53644448e-02f, -6.00756817e-02f, 9.46838036e-02f, -5.21145649e-02f, 8.53203908e-02f,
  6.64468333e-02f, -3.56223956e-02f, -1.44133568e-02f, -4.13247384e-02f, 4.96372655e-02f, -6.30021468e-03f, 6.48196787e-02f, -5.03576323e-02f, 1.55329164e-02f, 5.39295822e-02f,
  3.83809693e-02f, 6.71019331e-02f, -4.74998690e-02f, -3.47556733e-02f, 1.87152792e-02f, 3.33679803e-02f, -8.38424265e-02f, -5.52209467e-02f, 2.27986965e-02f, 2.51039192e-02f,
  -3.94904800e-02f, -5.85001484e-02f, -6.61068261e-02f, 7.05551803e-02f, -6.86136633e-02f, 1.06375068e-01f, -3.47136669e-02f, -4.64677662e-02f, -8.24833661e-02f, -1.11252004e-02f,
  1.84762284e-01f, 1.95638195e-01f, 1.46675020e-01f, 1.74146816e-01f, -3.02945916e-02f, -1.32863805e-01f, -9.86267999e-02f, 6.71794415e-02f, 1.41399950e-02f, -4.36173752e-02f,
  -8.28693509e-02f, 1.94453344e-01f, -1.33492227e-03f, 4.95029539e-02f, -8.11368003e-02f, -7.22054318e-02f, -2.14332193e-02f, 5.92757128e-02f, 1.08108241e-02f, 1.05530700e-04f,
  7.14698285e-02f, -8.55860636e-02f, 6.69938400e-02f, -1.13339134e-01f, 3.52542736e-02f, 1.34655625e-01f, -7.40686879e-02f, -4.88579832e-02f, 9.44892019e-02f, -9.81380418e-02f,
  -2.07558405e-02f, 1.29335397e-03f, 7.61589333e-02f, -2.35596206e-02f, -4.32505412e-03f, 8.15832317e-02f, 3.59555148e-02f, -5.77167273e-02f, 3.87374833e-02f, -6.03374541e-02f,
  6.92690015e-02f, 6.11627735e-02f, 2.34791287e-03f, -5.44088446e-02f, -5.87555170e-02f, 3.66391465e-02f, 1.11351572e-01f, -3.41111720e-02f, 8.74626338e-02f, 1.20628357e-01f,
  6.96299523e-02f, 1.13636613e-01f, -2.12485436e-02f, 1.47442473e-02f, -1.54279908e-02f, 4.19157445e-02f, 3.58861759e-02f, -1.18832076e-02f, -4.74958727e-03f, 6.25844151e-02f,
  5.60192168e-02f, -4.34090346e-02f, -1.32516949e-02f, 1.36830742e-02f, -6.37893891e-03f, -1.10308707e-01f, 2.68318690e-02f, -1.22552536e-01f, -3.07804048e-02f, -5.04599959e-02f,
  5.43200150e-02f, 4.45056194e-03f, 4.52291779e-02f, 5.10238186e-02f, 7.83289522e-02f, 3.88692804e-02f, -3.14661749e-02f, -7.96927512e-02f, -1.44332945e-02f, 4.74848263e-02f,
  4.07186002e-02f, -2.66150665e-02f, 6.33500740e-02f, 1.28590707e-02f, -4.11414653e-02f, -1.04734875e-01f, -1.42680369e-02f, 9.21696946e-02f, -2.53028190e-03f, 9.38524902e-02f,
  4.61073928e-02f, 1.81698464e-02f, 7.96885509e-03f, 2.51863450e-02f, 2.45292597e-02f, -1.14486001e-01f, -3.83872762e-02f, 2.19523832e-02f, 1.60301067e-02f, 4.96172756e-02f,
  9.77355149e-03f, -2.45859902e-02f, -6.35136366e-02f, 4.63896282e-02f, 6.18207529e-02f, 1.29404664e-02f, -1.18964054e-01f, 4.25484553e-02f, 1.51070105e-02f, 3.66261452e-02f,
  -6.31116554e-02f, 1.47180101e-02f, 3.84220220e-02f, -9.79668945e-02f, -4.83967140e-02f, 2.35925633e-02f, 1.11010754e-02f, 6.06156178e-02f, 1.03679322e-01f, -3.86463915e-04f,
  3.91288139e-02f, -1.78388745e-01f, -2.83058658e-02f, 1.72985390e-01f, -9.51781031e-03f, -6.57485798e-02f, -4.81396653e-02f, -2.95360982e-02f, -6.48625568e-02f, -4.09664437e-02f,
  -5.10687567e-02f, -1.20292202e-01f, -1.46148980e-01f, -5.97137287e-02f, 1.28747523e-01f, -7.80924410e-02f, -9.08292532e-02f, -6.41777813e-02f, 6.90192282e-02f, 7.31120631e-03f,
  8.80883634e-02f, 1.08291768e-01f, 1.44578114e-01f, 3.29922847e-02f, 8.28413218e-02f, 1.53475627e-01f, 3.71887237e-02f, 1.01181678e-01f, 1.25798106e-01f, 9.02962387e-02f,
  7.03330943e-03f, -1.67696234e-02f, 2.36697681e-02f, -7.59807006e-02f, -8.43584314e-02f, -1.09808566e-02f, -1.37288189e-02f, 7.36419261e-02f, -1.98480319e-02f, 5.13484217e-02f,
  2.86196042e-02f, 2.44345814e-02f, -4.27930951e-02f, 4.43222263e-04f, -9.80382711e-02f, -2.69765966e-03f, 3.00460774e-03f, 7.24112391e-02f, -8.25939402e-02f, -1.98993813e-02f,
  7.46612176e-02f, -8.34640190e-02f, 3.94707769e-02f, -4.16864827e-02f, 2.48645134e-02f, 5.66958375e-02f, -6.69093579e-02f, -3.52708884e-02f, 3.43767293e-02f, 1.06262207e-01f,
  2.36654226e-02f, -1.77099537e-02f, 5.77734644e-03f, 1.78187527e-02f, 5.73758967e-02f, -5.56431152e-02f, 3.67587656e-02f, -6.67418316e-02f, 6.34190254e-03f, -7.78529346e-02f,
  5.55463620e-02f, 3.51740830e-02f, 9.88125335e-03f, 9.20608360e-03f, -2.81508565e-02f, -4.37746719e-02f, 9.47520211e-02f, -4.74930368e-02f, 6.90846890e-02f, 4.62892167e-02f,
  4.54345495e-02f, -1.69557668e-02f, 3.03175393e-02f, -3.97772305e-02f, -2.62874663e-02f, 2.81766225e-02f, -4.44828793e-02f, -1.69270323e-03f, 5.27056232e-02f, -4.13129032e-02f,
  -1.69692665e-01f, 5.64794568e-03f, 6.19090907e-03f, -7.27238208e-02f, -5.59669957e-02f, -8.41605514e-02f, -2.95199733e-02f, 1.54038926e-03f, -2.33175289e-02f, 3.91730200e-03f,
  -6.65755346e-02f, 4.22583595e-02f, -4.23211120e-02f, 1.50898239e-02f, -6.72791749e-02f, -9.03471839e-03f, 5.15929274e-02f, -2.23990455e-02f, -1.02394074e-02f, -5.48716150e-02f,
  -6.82954676e-03f, 2.38744225e-02f, -5.28403595e-02f, 9.01070014e-02f, -2.27435073e-03f, -1.77393556e-02f, 7.75371119e-02f, -7.31348097e-02f, -2.35774536e-02f, 2.43997648e-02f,
  -4.88980785e-02f, 6.32808805e-02f, -1.67008296e-01f, -8.40918943e-02f, 9.06552970e-02f, -5.40127754e-02f, -7.06235096e-02f, 8.84480700e-02f, -3.13881412e-02f, 9.85680744e-02f,
  -2.02546176e-02f, -8.02868679e-02f, -6.39310479e-02f, -2.03259200e-01f, -2.95264781e-01f, -8.95645097e-02f, -2.02688396e-01f, -3.55066769e-02f, 2.45112926e-02f, 4.63792793e-02f,
  -1.32132202e-01f, 6.45011067e-02f, -9.00936499e-02f, 1.23167988e-02f, 6.13688491e-02f, 8.38242024e-02f, -1.44298805e-03f, 9.05677304e-02f, -9.56003591e-02f, 3.99192516e-03f,
  -1.11664962e-02f, -2.00850442e-02f, 6.91399053e-02f, -1.11873165e-01f, -1.21545624e-02f, 6.65201619e-02f, -3.43845338e-02f, -6.82952115e-03f, -6.95787370e-02f, -4.36862698e-03f,
  -1.00734346e-02f, 2.91718952e-02f, 5.35762683e-03f, 5.11666387e-02f, 3.26492712e-02f, -7.70853180e-03f, -7.25310147e-02f, -5.52646220e-02f, 2.35848762e-02f, -1.93969756e-02f,
  -1.11232050e-01f, -2.95416955e-02f, -2.71096211e-02f, 2.14244891e-02f, -4.15464677e-02f, 2.58915895e-03f, -6.39814138e-02f, -2.52731424e-02f, 3.46936956e-02f, -9.41356495e-02f,
  -4.68297489e-02f, -8.77995864e-02f, -2.93598473e-02f, 1.08162709e-01f, -8.21722746e-02f, -6.40378520e-02f, 1.28894020e-02f, -1.74879830e-03f, -3.32137533e-02f, 1.69960260e-02f,
  1.85776427e-02f, 6.51947409e-03f, -3.05788331e-02f, 3.22998166e-02f, -1.46599514e-02f, 5.76875396e-02f, 2.18031351e-02f, 3.27156298e-02f, -6.55319681e-03f, -8.84124115e-02f,
  7.32481703e-02f, -1.85296349e-02f, -1.74520519e-02f, -4.38442193e-02f, -1.76482294e-02f, 8.10782090e-02f, -2.66071260e-02f, 3.81418541e-02f, 1.38058737e-02f, -2.00446378e-02f,
  -2.99262088e-02f, -1.89309809e-02f, -1.66471452e-02f, 1.27996271e-02f, 5.72938323e-02f, -5.26715145e-02f, -8.42475072e-02f, -3.68323699e-02f, 2.86589861e-02f, -8.85740966e-02f,
  -5.69436960e-02f, -2.08550263e-02f, -6.76754415e-02f, -4.43414487e-02f, 6.25766441e-02f, 2.68625375e-03f, -6.95429444e-02f, 6.62184227e-03f, -8.03422481e-02f, 8.58249441e-02f,
  5.43917827e-02f, -2.68091727e-03f, -2.35662069e-02f, 9.70755368e-02f, -3.43731605e-02f, 1.09950453e-01f, 6.41371831e-02f, -6.12404756e-02f, -6.62459508e-02f, 1.62998885e-02f,
  -1.90822072e-02f, -6.79132566e-02f, 5.71190789e-02f, -6.96275309e-02f, 1.24420770e-01f, -5.89256734e-02f, -4.59886566e-02f, 1.85362827e-02f, 1.02652647e-01f, -8.11325461e-02f,
  7.47313201e-02f, -7.71133974e-02f, -4.12713317e-03f, 7.66018033e-02f, -5.54789752e-02f, -1.32736622e-03f, -1.58745833e-02f, -6.39284849e-02f, 8.86879712e-02f, 2.05119140e-02f,
  -7.83388242e-02f, -3.73312645e-02f, -5.53999580e-02f, 1.06589124e-03f, 5.28320558e-02f, 6.68469742e-02f, 3.93883735e-02f, -7.22535476e-02f, -9.53031890e-03f, -6.71255141e-02f,
  -7.21742287e-02f, 1.03406370e-01f, 6.66660741e-02f, -2.02826224e-02f, -6.06869869e-02f, 4.04706178e-03f, 3.94573808e-02f, 7.91420862e-02f, 6.24235384e-02f, -2.14164201e-02f,
  -9.83494706e-03f, 5.04257157e-02f, -4.39682081e-02f, 2.04308666e-02f, 1.93892960e-02f, -8.19843728e-03f, 8.80224556e-02f, 3.39222290e-02f, 6.00472242e-02f, -7.75063261e-02f,
  2.79462198e-03f, 4.32097390e-02f, 4.40983400e-02f, -9.07492340e-02f, 6.41881078e-02f, 5.65370694e-02f, -3.05095259e-02f, -3.62798795e-02f, 2.34291423e-02f, 6.51210621e-02f,
  -5.05034951e-03f, -5.34354672e-02f, 8.69528428e-02f, 7.15769082e-02f, 8.58588964e-02f, 1.02322675e-01f, 1.57914888e-02f, 3.67099866e-02f, -2.61511765e-02f, -8.00331756e-02f,
  -1.30968662e-02f, -4.67068069e-02f, 6.38627857e-02f, -6.93952888e-02f, -8.30888748e-02f, 9.93189588e-02f, 6.36636317e-02f, -4.48610336e-02f, 4.91704009e-02f, -1.44596882e-02f,
  -7.12893978e-02f, -4.93597016e-02f, 8.36971030e-02f, 6.21042922e-02f, -8.21568817e-02f, 3.20139527e-03f, 3.84699814e-02f, 7.82496184e-02f, 2.88395602e-02f, 2.04961579e-02f,
  -7.76666105e-02f, 7.16031790e-02f, -9.58575755e-02f, 4.74720336e-02f, -2.72243973e-02f, -1.13915270e-02f, -8.95994529e-02f, 8.14630985e-02f, -6.58042775e-03f, -5.98392412e-02f,
  -1.02031035e-02f, -7.07243234e-02f, -7.69885108e-02f, 5.95284440e-02f, 4.35495637e-02f, 7.66432136e-02f, 1.00585453e-01f, -4.82045263e-02f, 2.51906849e-02f, -3.55293788e-02f,
  7.74497315e-02f, -6.83113188e-02f, -4.05577058e-03f, -6.06196485e-02f, 4.67014164e-02f, 4.42966521e-02f, -1.47203272e-02f, -3.26946117e-02f, -7.58458674e-02f, 1.51072098e-02f,
  -5.07645570e-02f, -9.29414630e-02f, -9.18750167e-02f, -3.99983004e-02f, -1.47219583e-01f, -8.15759152e-02f, -1.00104488e-01f, -5.47794215e-02f, 1.36571109e-01f, 3.33160684e-02f,
  1.13239912e-02f, 7.80031681e-02f, 3.98993827e-02f, -1.13393992e-01f, 3.91795896e-02f, -1.99278761e-02f, -1.05198696e-01f, -4.62856144e-02f, -9.42812115e-02f, -1.35620415e-01f,
  -2.79965010e-02f, -1.09678820e-01f, -8.14333558e-02f, -1.35673225e-01f, -1.69582903e-01f, 1.03680603e-02f, 1.23699442e-01f, -1.36446893e-01f, -4.53125313e-02f, 6.29262673e-03f,
  1.61412975e-03f, -1.23592153e-01f, -1.66773781e-01f, -8.17823187e-02f, -2.46362910e-02f, -2.89151799e-02f, -1.07276827e-01f, 8.14317074e-03f, 5.11917584e-02f, -3.37156840e-02f,
  -2.83671282e-02f, 5.59295993e-03f, 1.43618986e-01f, 2.91238744e-02f, -5.60758524e-02f, 1.56688076e-02f, -1.02279363e-02f, -4.31022532e-02f, 3.93629037e-02f, -4.49766085e-04f,
  3.06568872e-02f, -1.44506572e-02f, 4.38883305e-02f, 9.99088138e-02f, -6.87445775e-02f, 2.41077505e-02f, 2.40884256e-02f, 4.17860001e-02f, -8.78495723e-02f, 5.51829971e-02f,
  -2.77678352e-02f, 1.16849307e-03f, -9.21102017e-02f, 5.40366918e-02f, 3.32581662e-02f, 1.04182392e-01f, -2.24070456e-02f, 5.83762564e-02f, 5.80292940e-02f, -1.39123900e-02f,
  3.09926849e-02f, -2.75075771e-02f, -4.26049493e-02f, -5.78466393e-02f, -3.84836532e-02f, 2.71363873e-02f, -3.33907339e-03f, 1.60250068e-02f, 2.91518271e-02f, 8.06788728e-02f,
  -9.45066810e-02f, 2.33554225e-02f, -5.24646528e-02f, 3.57457586e-02f, -8.58907625e-02f, -6.73287883e-02f, 1.90189630e-02f, -5.24766110e-02f, 3.37571315e-02f, 2.42841467e-02f,
  -5.56899905e-02f, 1.99099630e-03f, 5.10555468e-02f, -9.55949202e-02f, -7.71814287e-02f, -4.22916003e-03f, -1.28952429e-01f, -5.37909605e-02f, 3.29321879e-03f, -1.72300264e-02f,
  8.87244474e-03f, 4.39020619e-03f, -3.23146768e-02f, -1.47584658e-02f, 6.39133155e-02f, 8.52826685e-02f, -1.08792940e-02f, -5.22829294e-02f, 1.69986654e-02f, -2.81732678e-02f,
  4.83176224e-02f, 2.65857521e-02f, 7.87993446e-02f, -5.90872727e-02f, -1.02639906e-01f, 3.48181166e-02f, -2.63634175e-02f, 5.65334521e-02f, -1.20911784e-01f, 7.83476979e-02f,
  9.59378108e-02f, 1.63746834e-01f, 7.96375871e-02f, 7.70765767e-02f, -8.07276070e-02f, -4.33701463e-02f, -5.48140034e-02f, 6.52480274e-02f, -5.43232113e-02f, -5.56394225e-03f,
  -6.75037280e-02f, 8.62388089e-02f, -7.43989050e-02f, 1.14629127e-01f, -4.99984212e-02f, -2.64570918e-02f, 7.58265778e-02f, -2.16071494e-03f, 8.18923861e-03f, 6.91024736e-02f,
  2.76532210e-02f, -9.76524204e-02f, 3.39908828e-03f, 4.38567400e-02f, -7.24906335e-03f, 1.53543649e-03f, 3.57662067e-02f, -8.07065889e-02f, 4.52451147e-02f, 4.99126613e-02f,
  -3.72696035e-02f, 6.90367371e-02f, 8.67379457e-02f, 9.24859717e-02f, 5.30599579e-02f, 9.02111083e-02f, 2.73948926e-02f, 5.37517369e-02f, 1.99860539e-02f, 3.64470705e-02f,
  4.27299514e-02f, -9.11175534e-02f, 1.17083145e-02f, 6.21959232e-02f, -3.38524254e-03f, 3.18972114e-03f, -5.74006215e-02f, 8.15547034e-02f, -1.41479038e-02f, -2.01927759e-02f,
  3.86060737e-02f, 1.44724594e-03f, -7.44864717e-02f, 6.27603680e-02f, -2.76838392e-02f, 4.31281701e-03f, 1.72584206e-02f, 7.26476731e-03f, 5.29423989e-02f, 4.32625264e-02f,
  -5.00167385e-02f, -3.72527801e-02f, -3.29273730e-03f, -9.76028591e-02f, -2.18557790e-02f, 9.95149016e-02f, -7.46827424e-02f, -1.52829103e-02f, -4.24008742e-02f, 5.43830507e-02f,
  3.77419665e-02f, -1.05854394e-02f, -5.67061044e-02f, 5.35760894e-02f, -5.19308746e-02f, -6.87726066e-02f, -2.54572891e-02f, 9.56230536e-02f, -3.46910916e-02f, 1.01102265e-02f,
  -8.05752203e-02f, 4.77349237e-02f, -1.47701455e-02f, -5.38630448e-02f, 4.17156704e-02f, -4.42473330e-02f, 1.29691409e-02f, 5.55398986e-02f, -9.07857269e-02f, 2.57420857e-02f,
  3.57739627e-02f, 6.96433261e-02f, -1.00223742e-01f, -5.95722422e-02f, 4.90397997e-02f, -4.64248993e-02f, 2.93947626e-02f, 3.49898599e-02f, -1.73194278e-02f, 2.92402189e-02f,
  -2.76775230e-02f, -4.23873179e-02f, 6.43598288e-02f, -5.53017333e-02f, -8.56790598e-03f, -4.19794060e-02f, -8.97002034e-03f, -7.25641847e-02f, 5.23428768e-02f, 8.74598399e-02f,
  3.06758471e-02f, 2.05119196e-02f, 3.65601596e-03f, -9.27728713e-02f, -4.53793406e-02f, -8.40879008e-02f, -8.33196044e-02f, -7.91469887e-02f, 3.80064617e-03f, -2.39597540e-02f,
  6.76868483e-02f, -1.90839007e-01f, -9.35210139e-02f, 9.81852859e-02f, 1.41446203e-01f, 6.94369227e-02f, -1.49353668e-02f, 4.74667549e-02f, 3.31986919e-02f, -1.00633919e-01f,
  -3.94106358e-02f, -1.16239712e-01f, -5.92493489e-02f, 1.06869161e-01f, 8.72962698e-02f, -5.90046644e-02f, -1.67943519e-02f, -1.37837902e-02f, -1.38176484e-02f, -1.80808816e-03f,
  1.08145982e-01f, 1.16241798e-01f, -4.24241275e-02f, 6.99820276e-03f, 1.28043905e-01f, 1.70502469e-01f, 1.09847859e-02f, -6.95354939e-02f, 1.28499404e-01f, 5.64363003e-02f,
  6.38713464e-02f, 3.90118249e-02f, -8.30421820e-02f, -4.71541174e-02f, 4.95673995e-03f, -2.87069250e-02f, -1.01432942e-01f, 5.10647967e-02f, 5.51113784e-02f, -1.59900691e-02f,
  7.13848136e-03f, -2.89819222e-02f, 1.29035264e-01f, 3.82936150e-02f, -7.12483525e-02f, 7.89852887e-02f, 6.50699288e-02f, -3.67870033e-02f, -5.50597534e-02f, -1.78772900e-02f,
  6.27929792e-02f, -1.03047214e-01f, 1.10075762e-02f, -6.49618283e-02f, 6.47343993e-02f, 9.97556560e-03f, -6.95884302e-02f, 7.90017620e-02f, 4.87505458e-02f, 1.57936234e-02f,
  -2.75307931e-02f, -9.20104310e-02f, 1.18799019e-03f, 8.70571285e-02f, 5.02328277e-02f, 5.66396974e-02f, 7.39828572e-02f, -1.03237364e-03f, 8.54288861e-02f, 1.42402081e-02f,
  2.67049880e-03f, -4.15789373e-02f, -2.27848087e-02f, 8.14866275e-03f, 3.82074795e-04f, -6.21638186e-02f, 1.23303616e-02f, -1.50013389e-02f, -5.84756657e-02f, 2.45180205e-02f,
  -9.31591317e-02f, -3.62898856e-02f, 4.62876121e-03f, -4.29005809e-02f, -3.00505641e-03f, -5.52859865e-02f, -3.85331400e-02f, 2.12621260e-02f, 4.16571200e-02f, -5.67457732e-03f,
  1.58295073e-02f, -7.22268447e-02f, -2.56339628e-02f, -6.25635162e-02f, -4.41967510e-04f, -1.21989893e-02f, -3.72529098e-06f, -9.21034664e-02f, -4.61942106e-02f, -4.96390387e-02f,
  -1.57984383e-02f, -1.17438762e-02f, 1.25479177e-02f, 2.16451660e-02f, 3.11430246e-02f, -6.24015816e-02f, 7.71735758e-02f, 5.55473343e-02f, 8.25628787e-02f, 4.81710732e-02f,
  -3.67342830e-02f, -5.55800647e-02f, -6.88742101e-03f, 6.36163205e-02f, 5.57389148e-02f, 2.49873344e-02f, 1.16314270e-01f, 3.93582433e-02f, -2.03594193e-02f, 5.70214866e-03f,
  8.46815035e-02f, 7.07073463e-03f, -1.39885873e-01f, -3.00942156e-02f, 6.69690520e-02f, -3.86412293e-02f, -1.41573593e-01f, 9.65234451e-03f, -1.53333154e-02f, 1.34119382e-02f,
  -6.19312674e-02f, 7.50616267e-02f, -4.59291078e-02f, 6.04401678e-02f, 1.54426008e-01f, 6.56249225e-02f, 6.96795527e-04f, 5.96549772e-02f, 2.25300472e-02f, -7.20377117e-02f,
  1.14986971e-01f, 1.08763538e-01f, 9.81062427e-02f, 4.21695635e-02f, 5.71070910e-02f, 3.28309811e-03f, 6.92521185e-02f, -3.56174447e-02f, -2.34392658e-03f, 1.31929263e-01f,
  -3.81466560e-02f, -3.85737023e-03f, -3.55437100e-02f, -2.15704609e-02f, -6.25790283e-03f, -3.14281769e-02f, 5.40801212e-02f, -3.29382382e-02f, 3.90203968e-02f, -7.71688893e-02f,
  2.25168839e-02f, -7.88318925e-03f, 6.91987351e-02f, 3.74491103e-02f, -4.11653928e-02f, -4.85578701e-02f, 2.14329883e-02f, 4.20742016e-03f, -8.87342095e-02f, -7.77603313e-02f,
  -7.09547475e-02f, -7.09523782e-02f, 6.19698912e-02f, -5.84953977e-03f, -2.29455195e-02f, 1.03135675e-01f, -3.39140296e-02f, -2.06355024e-02f, 6.34691417e-02f, 7.47430697e-02f,
  -1.26007318e-01f, 8.79973769e-02f, -9.78197437e-03f, 6.85547069e-02f, 4.52656904e-03f, 7.91718438e-02f, 3.30241434e-02f, -3.61996964e-02f, -3.69551182e-02f, -7.77621344e-02f,
  -6.64773509e-02f, -2.19483022e-02f, -4.39294428e-02f, -5.25197424e-02f, 6.52279481e-02f, -8.77467990e-02f, 7.64243230e-02f, 6.97885081e-02f, 3.50911310e-03f, -4.61523868e-02f,
  -5.12815416e-02f, -9.30405036e-02f, -2.24229544e-02f, -7.91131239e-03f, 4.70640846e-02f, -6.40469342e-02f, 8.93337131e-02f, -6.93467185e-02f, 8.93134717e-03f, -9.13812146e-02f,
  -5.69483452e-02f, 6.45876378e-02f, 1.07126711e-02f, 9.13812444e-02f, 1.02094719e-02f, 1.04565650e-01f, 9.47014242e-02f, 7.00270012e-02f, -4.06726375e-02f, -6.26114160e-02f,
  2.77660731e-02f, 2.20792573e-02f, 1.00842848e-01f, 4.70418483e-02f, -2.09220015e-02f, 6.36725919e-03f, 3.70403640e-02f, -7.32350955e-03f, -1.60237972e-03f, -7.13994429e-02f,
  -1.39789749e-02f, -2.30292603e-02f, 6.33316413e-02f, 1.53735252e-02f, -1.37507990e-02f, -2.17764899e-02f, 3.06525789e-02f, 2.46338602e-02f, -1.39456615e-02f, 2.36893166e-02f,
  -6.03477582e-02f, -1.16832189e-01f, -3.62015843e-01f, -1.53388813e-01f, -6.54535070e-02f, -4.48949218e-01f, -2.74148554e-01f, 3.87646985e-04f, 1.95830315e-01f, -6.59728749e-03f,
  -7.25099668e-02f, 1.00857623e-01f, 6.70469329e-02f, -6.50501400e-02f, -7.62451068e-02f, 5.12472503e-02f, -2.64070868e-01f, -1.52901426e-01f, 3.39979753e-02f, -1.87561169e-01f,
  -1.10289037e-01f, -1.20947190e-01f, -1.90542862e-01f, 3.18695866e-02f, -1.42103434e-01f, -1.07873585e-02f, 6.05077855e-02f, -1.28480881e-01f, -8.75318944e-02f, 4.88548987e-02f,
  1.21785654e-02f, 9.99867544e-02f, -3.96844074e-02f, -2.59147845e-02f, -1.09855503e-01f, -6.04095049e-02f, -7.48425573e-02f, 4.63631041e-02f, -1.29224537e-02f, 4.11342084e-02f,
  1.01101197e-01f, 8.46560672e-03f, -1.05538834e-02f, 5.99970520e-02f, -9.83341336e-02f, 8.31792504e-02f, 2.37646829e-02f, -9.03369300e-03f, -1.76106934e-02f, -8.64567533e-02f,
  -7.27218390e-03f, -4.53313887e-02f, -1.34689897e-01f, 4.02433276e-02f, -2.73597296e-02f, -3.21455523e-02f, -5.67540806e-03f, 4.14613140e-04f, -9.87673998e-02f, -8.21504518e-02f,
  1.16621954e-02f, -2.12914702e-02f, 1.85959842e-02f, 2.04103645e-02f, -1.98215172e-02f, 3.22240144e-02f, -2.61769835e-02f, -6.00219816e-02f, -1.44778762e-03f, -3.85941006e-03f,
  2.28928253e-02f, 8.85755848e-03f, -8.60088691e-03f, -1.00444080e-02f, -7.13381767e-02f, 6.51226789e-02f, -3.18040699e-02f, 1.38894981e-02f, -8.23133513e-02f, -3.86290886e-02f,
  8.42373520e-02f, -3.05067636e-02f, 4.18068469e-03f, -8.54128320e-03f, -1.09412326e-02f, 5.08403666e-02f, -3.07720043e-02f, -4.58227172e-02f, 3.35833617e-02f, -1.78260580e-02f,
  -7.66895190e-02f, -1.44255400e-01f, 1.03953831e-01f, 3.63266580e-02f, 8.05736929e-02f, -4.31374833e-02f, 6.99415356e-02f, -3.52637358e-02f, -4.72761132e-02f, -1.10769514e-02f,
  -1.07929237e-01f, 2.06584353e-02f, -6.99690431e-02f, -7.05202296e-02f, 3.46155502e-02f, 1.41902165e-02f, 3.47122289e-02f, -3.83021310e-02f, -8.66400972e-02f, -2.74216197e-02f,
  -1.60097945e-02f, 3.70369628e-02f, 8.11158270e-02f, 4.75170650e-02f, -4.16604243e-02f, 4.20683902e-03f, -1.92375779e-02f, 7.25756912e-03f, 2.06844043e-02f, -8.88562948e-03f,
  1.06894240e-01f, 1.04266899e-02f, -4.05942611e-02f, -1.19504690e-01f, -6.30842075e-02f, -3.56147215e-02f, -8.21317434e-02f, -1.09543920e-01f, -1.13025665e-01f, 6.66422918e-02f,
  1.78819317e-02f, 1.09801911e-01f, 1.13179073e-01f, 1.74741764e-02f, 1.44177556e-01f, 8.61199424e-02f, -8.21211636e-02f, 8.46524090e-02f, -3.25005432e-03f, -5.21760173e-02f,
  6.42948002e-02f, 6.07957840e-02f, -3.81842488e-03f, -5.11164404e-02f, -1.15790337e-01f, -1.16653197e-01f, -2.77975528e-03f, -4.41509299e-02f, -1.15846694e-01f, -1.29574522e-01f,
  9.13065150e-02f, -4.37973533e-03f, 6.93184063e-02f, 1.21571481e-01f, -8.92245322e-02f, 5.52125229e-03f, 5.10710403e-02f, -7.91896693e-03f, 3.92477028e-02f, 4.32867520e-02f,
  -1.34963337e-02f, -8.74397461e-04f, 5.84179126e-02f, -6.14714101e-02f, -1.71608129e-03f, 2.08164100e-02f, -5.81101514e-02f, 4.75406349e-02f, -4.75178808e-02f, -2.88452990e-02f,
  1.84527354e-03f, 8.67462307e-02f, -2.97540687e-02f, 5.55926375e-02f, 1.85912624e-02f, -7.93313608e-02f, -1.88766718e-02f, -6.70141801e-02f, 2.90241092e-02f, -6.73546493e-02f,
  5.08278832e-02f, 5.90905473e-02f, 2.50069704e-02f, -7.40693063e-02f, 1.05921216e-01f, 6.48328364e-02f, 6.22866824e-02f, -8.08349550e-02f, 3.84009741e-02f, 2.06423402e-02f,
  -4.75843735e-02f, -3.19452472e-02f, 5.76774888e-02f, -4.66156118e-02f, -3.20795439e-02f, -1.37048969e-02f, -5.92551641e-02f, -9.56337526e-02f, -2.91341096e-02f, -6.13370948e-02f,
  3.79595645e-02f, 2.29723565e-02f, -3.24837118e-02f, 4.30270433e-02f, 1.56461988e-02f, 3.77635062e-02f, 7.09693320e-03f, 5.57016069e-03f, -2.73176655e-02f, -5.57087958e-02f,
  -6.33942857e-02f, -2.50753108e-02f, -1.51344738e-03f, 7.34408349e-02f, 1.57539416e-02f, -3.39011848e-02f, -1.24553684e-02f, 1.31926928e-02f, -5.44472970e-03f, 8.65110159e-02f,
  -6.16533123e-02f, 5.14663756e-02f, 4.59766835e-02f, -9.95384343e-03f, 8.70430768e-02f, 9.04481262e-02f, -2.94535719e-02f, 2.41694171e-02f, -9.58232582e-02f, 8.09387711e-05f,
  -2.75362872e-05f, -1.69146117e-02f, 5.09565659e-02f, -4.29377332e-02f, 2.95627378e-02f, -4.39105853e-02f, 4.57189344e-02f, -1.95478257e-02f, -4.73981500e-02f, -7.30063766e-02f,
  6.55871630e-03f, 3.80570665e-02f, -1.90118000e-01f, 3.36390883e-02f, -2.61134356e-01f, 4.89307158e-02f, 9.50482711e-02f, -1.00246720e-01f, -9.57204103e-02f, 1.52033597e-01f,
  1.94087490e-01f, -7.57284462e-02f, 2.04960540e-01f, 3.10903698e-01f, 8.84892344e-02f, 2.55215198e-01f, 1.45641938e-01f, 1.09137692e-01f, 2.50465306e-03f, -9.00896564e-02f,
  7.54196271e-02f, 2.06026658e-01f, 6.67761415e-02f, 2.65649036e-02f, 2.17726058e-03f, -3.72581147e-02f, 1.23321481e-01f, -1.19474113e-01f, 1.34669244e-01f, 3.61008532e-02f,
  6.15724176e-02f, 1.51207736e-02f, -5.14317639e-02f, -1.07566975e-01f, -6.62206858e-02f, -1.89670641e-02f, -5.53400777e-02f, -4.97048497e-02f, -2.10014805e-02f, 3.36183794e-02f,
  5.33890575e-02f, 2.13500112e-02f, -5.38532883e-02f, -2.08211821e-02f, -9.68488976e-02f, -5.49360514e-02f, -4.15816754e-02f, -4.06035632e-02f, 2.22921930e-03f, -2.33090855e-02f,
  -1.28873393e-01f, 3.31694186e-02f, -7.91795775e-02f, 7.35206604e-02f, -6.61667660e-02f, -1.59868617e-02f, 9.16182646e-04f, 2.87646824e-03f, -8.81272554e-03f, -7.18269125e-02f,
  -2.29612403e-02f, -2.12974418e-02f, -1.88303683e-02f, 9.15182754e-02f, 2.45382544e-02f, 2.46413760e-02f, -2.32492723e-02f, 3.87369134e-02f, -2.86767054e-02f, 3.74812745e-02f,
  -1.50658917e-02f, -6.03005402e-02f, -1.06558338e-01f, 2.62978487e-02f, -2.65076011e-02f, -5.21149412e-02f, -2.35167202e-02f, -7.85581693e-02f, -4.27026562e-02f, -2.26319619e-02f,
  3.04382183e-02f, -1.12939373e-01f, 2.21496969e-02f, 8.42741057e-02f, -3.54677439e-02f, -2.16012988e-02f, 3.23673002e-02f, -2.08387170e-02f, -1.09304123e-01f, 1.17722712e-02f,
  8.20099190e-02f, -3.74388508e-02f, -2.17774920e-02f, -3.68371382e-02f, 2.46277414e-02f, 1.89972259e-02f, -2.89096572e-02f, -1.46050341e-02f, -4.64805663e-02f, -7.13240504e-02f,
  5.43643124e-02f, -7.44072050e-02f, 2.95618810e-02f, 4.60663326e-02f, -3.19369882e-02f, 7.47970268e-02f, 3.75908427e-02f, -3.26945744e-02f, -4.91035767e-02f, -1.83077045e-02f,
  -3.71373817e-02f, -9.82510000e-02f, 3.85423303e-02f, 2.61625135e-03f, 3.27695943e-02f, -2.06652842e-02f, 7.34949950e-03f, -7.98417702e-02f, 9.67845414e-03f, 1.87352672e-02f,
  -7.69979283e-02f, 6.67062849e-02f, -2.37748437e-02f, -6.92707747e-02f, -1.40856311e-01f, -1.80315170e-02f, 7.72407092e-03f, -8.65797698e-02f, -5.12496149e-03f, 1.38878003e-01f,
  -5.36970571e-02f, -4.98703718e-02f, 1.87197942e-02f, 8.01080987e-02f, -6.91696955e-03f, 4.37969714e-02f, 1.13276273e-01f, 5.38034737e-02f, 7.71876425e-03f, -7.27238357e-02f,
  -2.09703203e-02f, 2.74729878e-02f, 3.09864227e-02f, -1.17783034e-02f, -3.16101946e-02f, -3.83925512e-02f, 8.30271244e-02f, -6.60229176e-02f, 5.28357513e-02f, 8.93524438e-02f,
  -5.05000763e-02f, -5.62735423e-02f, -9.28921402e-02f, -1.58380605e-02f, -6.53854534e-02f, 7.00259656e-02f, 5.34164198e-02f, 4.07651775e-02f, -1.02824502e-01f, -4.18196581e-02f,
  8.35537445e-03f, 3.05436272e-02f, -2.17399336e-02f, -2.53543667e-02f, -5.75293005e-02f, -2.42327861e-02f, 8.78187642e-02f, 2.39172038e-02f, -5.63551784e-02f, 5.49256839e-02f,
  2.48321686e-02f, -8.31835121e-02f, -4.44682203e-02f, 7.98660505e-04f, -2.68754642e-02f, 6.43664673e-02f, 5.82361734e-03f, -8.03284943e-02f, 3.70211303e-02f, -2.55782269e-02f,
  -6.21632226e-02f, -6.41213432e-02f, -6.15762137e-02f, 2.40742564e-02f, -8.08009282e-02f, 5.28676994e-02f, -1.34537062e-02f, 1.14330649e-01f, -6.76518679e-02f, 8.04517418e-02f,
  2.22442653e-02f, 4.86346846e-03f, 6.63488358e-02f, -4.17395942e-02f, 1.88137237e-02f, 7.49837533e-02f, -8.33507180e-02f, 6.78270822e-03f, -1.56475250e-02f, 5.37286364e-02f,
  -3.56288180e-02f, 1.76522546e-02f, 3.30753922e-02f, 1.00203164e-01f, -5.35413437e-02f, 8.28204751e-02f, -3.33930813e-02f, -2.70346142e-02f, -2.51112618e-02f, -8.20235536e-02f,
  9.52045918e-02f, -2.04839949e-02f, -6.94267526e-02f, -4.88580205e-02f, -1.83654670e-03f, -1.89271308e-02f, 1.06617603e-02f, -8.00596699e-02f, 1.15299493e-03f, -9.84135941e-02f,
  -2.53239926e-02f, 6.59326538e-02f, -6.25181012e-03f, -1.61078144e-02f, 5.93476929e-02f, -5.00137359e-02f, 3.35159190e-02f, -5.01327924e-02f, -1.47739798e-02f, 7.04395249e-02f,
  -4.67911623e-02f, -7.95553997e-02f, -5.16574793e-02f, -1.98773891e-02f, 3.59568968e-02f, 4.40754667e-02f, -4.49401177e-02f, 1.74745917e-02f, -5.46238869e-02f, 3.86008471e-02f,
  1.11019157e-01f, 2.83587091e-02f, -3.00153419e-02f, -7.93846399e-02f, 4.58481780e-04f, 1.02187946e-01f, 5.91000952e-02f, 5.63623309e-02f, -1.11977793e-01f, -2.17325278e-02f,
  7.15241060e-02f, 4.72587310e-02f, -4.62150574e-02f, 8.77862275e-02f, -5.89405410e-02f, 6.28193766e-02f, -3.71820852e-02f, -4.58985521e-03f, -2.75458433e-02f, -2.38566101e-02f,
  -7.61295035e-02f, 1.25861153e-01f, -1.05992496e-01f, -7.46593624e-02f, 2.83597074e-02f, -4.35831323e-02f, 4.99350689e-02f, -6.91838712e-02f, 3.89359072e-02f, -4.48572338e-02f,
  1.15498222e-01f, 1.07409604e-01f, 4.91234697e-02f, -3.34992819e-03f, 9.96804088e-02f, 3.39253917e-02f, -3.43562551e-02f, -1.61416468e-03f, 3.53776477e-02f, 5.56213632e-02f,
  8.12575221e-02f, 5.39893471e-02f, 5.60672954e-02f, -7.13980645e-02f, -8.22814256e-02f, -1.35534415e-02f, 1.67207941e-02f, 2.42779329e-02f, 3.00358254e-02f, 7.29800574e-03f,
  3.49893123e-02f, -3.42931934e-02f, -9.16928425e-03f, 9.42651629e-02f, 1.38807371e-02f, 1.08485604e-02f, -4.12922129e-02f, 7.04938844e-02f, -4.95305471e-02f, -4.42085322e-03f,
  -5.37690111e-02f, -6.14690445e-02f, -4.86503355e-02f, 5.65320849e-02f, 1.79400910e-02f, -6.78903311e-02f, -1.19165266e-02f, -6.99353172e-03f, 5.37152179e-02f, 2.98035871e-02f,
  5.65164983e-02f, -2.60096341e-02f, 2.36323755e-02f, -5.37872463e-02f, 8.33679438e-02f, 4.07708660e-02f, -2.27121245e-02f, 5.71145713e-02f, 2.91426126e-02f, 8.60039592e-02f,
  -3.07294596e-02f, 1.72735304e-02f, 1.24632912e-02f, 1.81104634e-02f, -6.64400756e-02f, -7.75746182e-02f, 4.00392786e-02f, 6.65243492e-02f, 8.08287819e-04f, 1.02180569e-03f,
  7.58120716e-02f, -2.73658913e-02f, 4.26077209e-02f, 8.75099972e-02f, 1.85568444e-02f, 8.63781944e-02f, -4.29116078e-02f, -5.08819818e-02f, 1.60921272e-02f, 5.30543663e-02f,
  -5.08073345e-02f, -8.42539072e-02f, -5.97918518e-02f, -9.51054785e-03f, 5.70540503e-02f, 1.95551254e-02f, 3.89848836e-02f, -6.10574335e-02f, -3.92141566e-03f, 7.74513707e-02f,
  -6.07183985e-02f, 3.22068371e-02f, 7.63745159e-02f, -3.23623233e-02f, 3.73063907e-02f, -7.89956599e-02f, 2.95360871e-02f, -3.82716730e-02f, 6.53101280e-02f, 9.29184034e-02f,
  -8.34457651e-02f, 1.20348223e-01f, -1.21896550e-01f, 4.46067750e-02f, -1.10764578e-01f, 2.06062451e-01f, 1.75316393e-01f, 8.02671611e-02f, 7.40125775e-02f, 2.42971539e-01f,
  1.08725496e-01f, -1.45508219e-02f, 6.77681267e-02f, 1.96373433e-01f, -1.07071558e-02f, 1.82121873e-01f, 1.52338833e-01f, 1.01910390e-01f, -5.44824526e-02f, 4.21369560e-02f,
  -1.64280236e-02f, 8.25591832e-02f, -7.15426207e-02f, -4.30412553e-02f, -5.83546143e-03f, -8.39901417e-02f, 4.17588279e-02f, -7.79388249e-02f, 8.36369172e-02f, 8.04950744e-02f,
  5.55998683e-02f, 3.73503976e-02f, -7.99992010e-02f, 9.38412361e-03f, 4.28590886e-02f, -1.77435689e-02f, 1.62186958e-02f, -2.88956929e-02f, -7.14761689e-02f, 3.59185901e-03f,
  -4.04975610e-03f, -9.11807269e-02f, 4.31346409e-02f, -2.46064388e-03f, 5.12844287e-02f, 2.81885192e-02f, -5.57215363e-02f, 8.67125392e-03f, 1.56457257e-02f, 3.83978477e-03f,
  -3.37485187e-02f, 7.84419179e-02f, 6.18319437e-02f, 1.26244808e-02f, -2.96501685e-02f, -5.67902625e-03f, -1.52637037e-02f, -2.52516586e-02f, 7.45631196e-03f, -6.16820017e-03f,
  -4.67614084e-02f, 2.21601836e-02f, -1.27377994e-02f, -6.52664229e-02f, -3.49929705e-02f, -1.01624005e-01f, 3.27724963e-02f, -7.15110777e-03f, -5.66085689e-02f, -3.01649701e-02f,
  1.64418761e-02f, 2.93127932e-02f, 3.71471941e-02f, -1.87788140e-02f, 5.23177087e-02f, 6.23735264e-02f, 9.81997699e-03f, 8.21557119e-02f, 5.06939329e-02f, 1.01226261e-02f,
  -1.59140136e-02f, 4.66142036e-02f, -8.19896534e-03f, -2.40316875e-02f, 1.56244906e-02f, -8.54996666e-02f, 4.30995338e-02f, 9.01058130e-03f, 2.58458313e-02f, -4.22648080e-02f,
  1.11525536e-01f, -3.60037610e-02f, 6.19105957e-02f, -3.68101597e-02f, 3.01187709e-02f, -7.91975781e-02f, 1.01952348e-02f, 8.85471702e-03f, 4.46580239e-02f, 4.66471091e-02f,
  -6.79980293e-02f, 4.42574173e-02f, 5.57039082e-02f, -8.14046338e-02f, 3.19555216e-02f, 5.21850176e-02f, -3.72717939e-02f, -2.32693814e-02f, 1.79568306e-03f, -9.21938918e-04f,
  -7.17379451e-02f, 2.52001290e-03f, -9.90563910e-03f, -4.80749123e-02f, 1.71032958e-02f, -5.67579158e-02f, 8.42854660e-03f, 3.98024581e-02f, -9.54859331e-03f, -2.38504522e-02f,
  1.51262015e-01f, -7.61793228e-03f, -2.83266529e-02f, -2.57035904e-02f, 1.40607312e-01f, -4.10003103e-02f, 1.12697884e-01f, 4.90331240e-02f, 6.06944785e-02f, -1.08272128e-01f,
  1.65935419e-02f, -7.07817450e-02f, -1.40392065e-01f, -4.15250398e-02f, -4.52079996e-02f, -1.16079161e-02f, 5.89131303e-02f, -6.99402764e-02f, 6.48454428e-02f, -3.24236192e-02f,
  6.12904085e-03f, -1.58526674e-02f, 1.98407397e-02f, 4.87685911e-02f, -7.95667246e-03f, 4.53170389e-02f, -3.21197398e-02f, -9.95311886e-02f, 7.41939992e-02f, 5.24469353e-02f,
  -2.37049535e-03f, 6.68010190e-02f, 1.05511956e-01f, -8.21437165e-02f, 5.13924807e-02f, -3.97519991e-02f, -2.41828663e-03f, -2.00405680e-02f, -4.09691110e-02f, 1.82694439e-02f,
  8.17089714e-03f, 4.77190353e-02f, -4.00380157e-02f, -5.47892042e-02f, 1.30875083e-02f, -5.65129267e-05f, -4.67780419e-02f, -3.62927020e-02f, 2.41356920e-02f, 1.00533329e-02f,
  3.66372196e-03f, -8.53273869e-02f, -5.98931722e-02f, -4.42474475e-03f, 1.71963871e-02f, -3.61031368e-02f, 2.75333468e-02f, 1.00639127e-01f, -4.06155586e-02f, 5.84260188e-02f,
  3.74049433e-02f, 3.50486189e-02f, 4.37630750e-02f, -5.44271469e-02f, 3.97440605e-02f, 6.63046092e-02f, -4.36853878e-02f, -2.21292656e-02f, 5.04145846e-02f, 1.12786302e-02f,
  -7.16861635e-02f, -3.05474307e-02f, 8.62610266e-02f, -9.75655913e-02f, 1.79408584e-02f, 1.10042609e-01f, -6.32044300e-02f, -7.07352832e-02f, -4.46960852e-02f, -7.07617551e-02f,
  -5.13287820e-02f, 1.60149410e-02f, -3.60181592e-02f, 7.02772290e-02f, -6.15927018e-03f, 4.74655181e-02f, 2.80059725e-02f, -8.57756380e-03f, -7.73470998e-02f, -1.36897583e-02f,
  -9.94751006e-02f, -1.12559266e-01f, 4.37341817e-03f, -4.00147028e-02f, -3.72888856e-02f, -7.63041973e-02f, -6.45330548e-02f, -5.70476912e-02f, -7.18125999e-02f, -6.90573454e-02f,
  5.04700802e-02f, -3.76828723e-02f, 2.07588617e-02f, -4.58818041e-02f, -3.01491041e-02f, -6.21844567e-02f, 5.55645861e-03f, 4.36597280e-02f, -3.45405824e-02f, 2.04156637e-02f,
  1.59813911e-02f, -5.53091010e-03f, 3.59927528e-02f, -2.31416188e-02f, 6.65361062e-02f, -3.00150290e-02f, -3.78541164e-02f, -7.02253208e-02f, -7.60742053e-02f, -2.36047916e-02f,
  1.68883324e-01f, -1.07948057e-01f, -4.17130291e-02f, 3.59688662e-02f, -7.93292299e-02f, 7.22190086e-03f, 3.08586899e-02f, -1.48826972e-01f, -1.45667672e-01f, 6.96266964e-02f,
  5.49696535e-02f, -2.84859054e-02f, -1.24745932e-03f, 5.91024086e-02f, 9.39744189e-02f, -4.51072529e-02f, 1.89321607e-01f, 9.58155617e-02f, -5.10448515e-02f, 1.47948861e-02f,
  -6.69569662e-03f, 9.54596549e-02f, 4.19115946e-02f, 8.17643851e-02f, 8.90690759e-02f, -1.36466041e-01f, -2.26536263e-02f, -3.27888271e-03f, -5.62983938e-02f, -7.46201072e-03f,
  8.43587220e-02f, -7.30108395e-02f, 5.47955558e-03f, -1.68220177e-02f, -1.05827544e-02f, 8.57475773e-02f, 5.39338961e-02f, 6.10924624e-02f, -8.57058391e-02f, -5.92428669e-02f,
  -2.74369828e-02f, -4.06274423e-02f, -5.52088134e-02f, 5.05523570e-02f, 6.46838248e-02f, -9.76479352e-02f, -9.34348106e-02f, -2.83155255e-02f, -2.28456389e-02f, -5.75271202e-03f,
  -2.14186702e-02f, 4.68071625e-02f, -6.33306205e-02f, -2.70961318e-02f, -4.74467240e-02f, 7.64994919e-02f, 3.21003539e-03f, -5.55573069e-02f, -1.17355421e-01f, -3.54097481e-03f,
  2.13536117e-02f, -5.93837649e-02f, 9.42622498e-02f, -1.60225444e-02f, 2.01805588e-03f, 7.49550387e-02f, 3.26456353e-02f, 6.91157803e-02f, 3.19298804e-02f, -4.45672534e-02f,
  1.51216576e-03f, -3.44411582e-02f, 7.24834353e-02f, -1.02307070e-02f, 3.65348570e-02f, 3.32717821e-02f, -6.74493313e-02f, -7.51946121e-02f, -1.11145107e-02f, -7.03313500e-02f,
  9.60366875e-02f, -4.60211188e-02f, 4.86358851e-02f, 9.72158834e-03f, -2.33404078e-02f, -3.94495763e-02f, 9.96915102e-02f, -1.41918305e-02f, 3.91261801e-02f, -6.12085983e-02f,
  -5.31706735e-02f, -1.25571311e-01f, -3.01521551e-02f, -1.58201344e-02f, -2.99967919e-02f, -4.27549742e-02f, 6.63377345e-02f, 4.85459827e-02f, 4.93068993e-02f, -6.86236545e-02f,
  1.16126947e-02f, 5.13581149e-02f, -5.74983284e-02f, -8.16834792e-02f, -7.88068175e-02f, 3.13629163e-03f, 2.68552899e-02f, -2.83337180e-02f, 7.76722655e-03f, -8.98942128e-02f,
  2.98085473e-02f, 1.99000407e-02f, 3.35290581e-02f, 3.76306660e-02f, 7.35134305e-03f, 1.15370013e-01f, -3.75039056e-02f, -7.24738091e-02f, 3.74255776e-02f, 2.61210874e-02f,
  7.65440539e-02f, 1.26327977e-01f, -1.53375998e-01f, 4.98733409e-02f, -1.17804661e-01f, 4.88161258e-02f, 1.07154414e-01f, 1.01220779e-01f, 4.17891033e-02f, 2.07194895e-01f,
  9.95717049e-02f, -3.84252854e-02f, -4.16333415e-02f, 1.72595426e-01f, -4.82755452e-02f, 6.87004104e-02f, 1.59455657e-01f, 1.53822616e-01f, 2.21162364e-02f, 6.73556924e-02f,
  -6.54859319e-02f, 7.46563077e-02f, -4.59095798e-02f, 6.57814462e-03f, -3.21667716e-02f, -1.67434081e-01f, 3.04651670e-02f, -6.83720037e-02f, 1.09287299e-01f, 6.52863011e-02f,
  1.09008150e-02f, 5.51696084e-02f, 8.04967433e-02f, -4.54888642e-02f, -4.19749133e-02f, 1.16323441e-01f, -4.64889966e-03f, -3.84318009e-02f, 3.21342200e-02f, -8.83633923e-03f,
  3.93515565e-02f, -1.05624907e-02f, 9.79684591e-02f, 1.70899481e-02f, -1.57010835e-02f, -8.77325982e-02f, 6.84424788e-02f, -1.60229243e-02f, -1.71732884e-02f, 4.66046929e-02f,
  3.48617993e-02f, -3.80277191e-03f, 5.88021688e-02f, -7.44249374e-02f, 8.80028179e-04f, 3.19754728e-03f, -9.11815464e-03f, 5.94456010e-02f, -4.79941303e-03f, -3.88478339e-02f,
  3.46662453e-03f, -1.62732899e-02f, 8.64550769e-02f, 8.32237527e-02f, -4.20162715e-02f, 1.55933890e-02f, -1.68821327e-02f, -7.37892687e-02f, -3.54244262e-02f, -4.17923369e-02f,
  9.01223440e-03f, -6.61105812e-02f, 2.04268023e-02f, 8.03804211e-03f, -5.40798856e-03f, 7.15213418e-02f, 2.89213695e-02f, 1.94757991e-02f, -4.60213842e-03f, -5.61037175e-02f,
  -2.51314342e-02f, 2.86508091e-02f, -3.44299823e-02f, 5.84613271e-02f, 1.53480060e-02f, 7.52925947e-02f, 5.74645959e-03f, -6.69739768e-02f, -4.73126024e-02f, 7.09136873e-02f,
  2.96311826e-02f, 2.97338795e-02f, -2.38489918e-02f, 1.75440088e-02f, -8.80905148e-03f, 8.85405242e-02f, -5.92017099e-02f, 9.25567225e-02f, -3.50905396e-02f, 4.52405177e-02f,
  -4.32179719e-02f, -7.89203774e-03f, 1.07129343e-01f, -1.73779950e-02f, -4.64247949e-02f, 7.81873986e-02f, -5.38010001e-02f, -5.75465932e-02f, 1.97405033e-02f, -8.73108953e-03f,
  4.84724864e-02f, 4.22052704e-02f, -3.90384756e-02f, -3.89570519e-02f, -2.90431902e-02f, -1.77312773e-02f, -2.47144066e-02f, -2.03136597e-02f, 8.01128522e-02f, -3.16525884e-02f,
  8.71503428e-02f, 8.81128237e-02f, 1.44751281e-01f, 8.85566100e-02f, -6.37936443e-02f, -1.75648406e-01f, -1.67315658e-02f, 1.03167351e-02f, -9.90942419e-02f, 4.43345979e-02f,
  -9.92673412e-02f, 7.51496153e-03f, 8.88917223e-02f, 8.28258228e-04f, -4.92715389e-02f, 7.97760859e-02f, 1.55828875e-02f, -2.50946805e-02f, -1.47439539e-02f, 1.14913382e-01f,
  8.38696212e-02f, -5.95529042e-02f, 1.51620820e-01f, 4.57579680e-02f, -9.69176181e-03f, 6.24010675e-02f, 1.42939717e-01f, 4.61298786e-02f, 1.16152786e-01f, -7.05415606e-02f,
  -8.61464292e-02f, -1.31787341e-02f, -2.97018010e-02f, -7.60811493e-02f, -5.64021291e-03f, 2.42096465e-02f, -4.41533029e-02f, -1.17463075e-01f, -7.59476656e-03f, 4.44898149e-03f,
  1.78097803e-02f, -2.23053358e-02f, -3.18160839e-02f, -1.78754237e-02f, -3.07319965e-02f, -3.94975282e-02f, -2.12266147e-02f, 7.12143704e-02f, -3.45251001e-02f, 5.53925857e-02f,
  1.93119142e-02f, -4.95631360e-02f, 8.91861785e-03f, 3.48889492e-02f, 9.38843638e-02f, 7.32759833e-02f, 4.50163446e-02f, -5.26236296e-02f, 3.34078558e-02f, -1.43370703e-02f,
  -7.64636770e-02f, 4.42800485e-02f, -1.37544926e-02f, 9.17228535e-02f, 2.17615534e-02f, 2.73235906e-02f, 6.25864193e-02f, -4.73863967e-02f, 6.48868084e-02f, 2.36394331e-02f,
  9.30841174e-03f, 1.25784392e-03f, -6.33853078e-02f, -8.14754665e-02f, -6.60314560e-02f, -8.57484117e-02f, -5.10239787e-02f, -1.41259702e-02f, -1.31382039e-02f, 1.61719378e-02f,
  -3.93119790e-02f, 2.77688503e-02f, -3.46509591e-02f, -7.59468973e-02f, 4.21523266e-02f, 2.04504188e-02f, 5.99582419e-02f, 3.69069986e-02f, 7.43479207e-02f, -7.77566433e-02f,
  -2.58678664e-02f, 1.27710029e-01f, 4.80227768e-02f, 3.60108763e-02f, 8.14977139e-02f, 7.01911971e-02f, 9.53525007e-02f, 7.53134564e-02f, 1.04679540e-01f, 1.01434803e-02f,
  -9.52815078e-03f, 3.15760486e-02f, -8.85438360e-03f, 3.18391956e-02f, -1.71877909e-02f, 1.38554135e-02f, 5.09726368e-02f, 4.53625694e-02f, 3.03206388e-02f, -8.07928294e-03f,
  5.36504947e-02f, -1.06388502e-01f, 6.12529814e-02f, 6.08652271e-02f, -2.68539712e-02f, 9.22660753e-02f, 8.26349109e-02f, -3.41039822e-02f, -3.53855938e-02f, -1.23721855e-02f,
  -9.97187868e-02f, 8.77984166e-02f, 8.26421529e-02f, -9.55308080e-02f, -4.03982215e-02f, 4.81236652e-02f, 1.11105815e-02f, 5.60765713e-02f, -8.13507810e-02f, -2.92051714e-02f,
  8.38865247e-03f, -3.82304490e-02f, -7.53938854e-02f, -6.60717711e-02f, -8.04119483e-02f, -6.88490346e-02f, 8.51626620e-02f, 7.33766109e-02f, 6.85232878e-02f, -2.86826044e-02f,
  2.32617259e-02f, -6.76811710e-02f, 2.94251274e-02f, 1.47818075e-02f, 6.32920116e-02f, 2.36306787e-02f, 2.06505898e-02f, -5.37217893e-02f, -5.15806489e-03f, -3.34400753e-03f,
  7.04221353e-02f, 6.96254894e-02f, -5.67157455e-02f, 1.01661086e-01f, 1.12091050e-01f, -4.97567952e-02f, 5.85120320e-02f, -1.29431346e-02f, 2.01924033e-02f, -3.73095796e-02f,
  -1.52511336e-02f, -6.09958395e-02f, 5.45513667e-02f, -2.74505578e-02f, -8.36972520e-02f, -2.59654177e-03f, -2.36826278e-02f, 8.76455903e-02f, -9.26706418e-02f, -6.66604266e-02f,
  -4.79475670e-02f, 5.72955422e-02f, 2.74536647e-02f, 4.56268415e-02f, -5.35386708e-03f, 3.24942395e-02f, -8.85338858e-02f, -3.85091193e-02f, -5.71782961e-02f, 5.31299710e-02f,
  5.78514040e-02f, -5.41741326e-02f, 9.14042145e-02f, 6.51530698e-02f, 1.20058581e-02f, 4.06130590e-02f, 7.46922866e-02f, -6.23136647e-02f, -5.36665246e-02f, -6.33491902e-03f,
  -3.87224443e-02f, -3.94394733e-02f, -1.76689476e-02f, 7.55694732e-02f, -1.50071010e-02f, 3.11380569e-02f, 3.83249186e-02f, 5.39532229e-02f, 5.81917586e-03f, 3.54927331e-02f,
  -9.11226496e-02f, 3.73141840e-03f, -4.28004451e-02f, 1.25780376e-02f, -1.54116785e-03f, -9.84473228e-02f, 5.48750907e-02f, -4.32344228e-02f, 4.50762250e-02f, 6.80614039e-02f,
  -3.83134559e-02f, 3.56387980e-02f, -1.64975189e-02f, 7.19377026e-02f, -6.07305113e-03f, -1.22885117e-02f, 3.58936898e-02f, -2.34969705e-02f, 2.25520097e-02f, -2.85835303e-02f,
  1.92116704e-02f, -2.89539602e-02f, 2.24766079e-02f, -4.83752601e-02f, -1.05852855e-03f, -5.45652770e-02f, -7.11816782e-03f, -5.03670275e-02f, -7.19515048e-03f, 7.91327730e-02f,
  3.74890305e-02f, 1.53239220e-02f, 3.54913101e-02f, -4.13962193e-02f, -2.19805799e-02f, 5.80135062e-02f, -1.35965273e-02f, 4.91832159e-02f, 4.68383953e-02f, 5.90785220e-02f,
  4.55187336e-02f, 1.69098496e-01f, 1.00941598e-01f, 4.01347764e-02f, -3.74992490e-02f, -1.57743573e-01f, 3.61579657e-03f, 4.96121086e-02f, 7.40966871e-02f, 1.53257987e-02f,
  -4.74481508e-02f, 6.10928945e-02f, 1.16694763e-01f, -3.65387052e-02f, -3.74355577e-02f, 7.68529847e-02f, 5.14229126e-02f, -8.11958015e-02f, -2.44755410e-02f, 1.05874941e-01f,
  1.01582684e-01f, 5.17784581e-02f, 4.73499745e-02f, -4.27027941e-02f, 7.41174743e-02f, 6.25804663e-02f, 1.38855517e-01f, 9.70471837e-03f, -2.89602429e-02f, 2.27298141e-02f,
  1.05010280e-02f, 1.13813706e-01f, -2.09738836e-02f, -6.24135397e-02f, 3.25420424e-02f, -4.95225824e-02f, -2.62294896e-02f, -4.75226901e-02f, 2.69789286e-02f, 6.86162114e-02f,
  -3.05216480e-02f, 5.86231127e-02f, -4.45853844e-02f, -7.01508671e-02f, -1.02731036e-02f, 4.07765843e-02f, 8.31023827e-02f, -3.90052088e-02f, -6.66376501e-02f, 4.58935052e-02f,
  6.79695681e-02f, -2.55284533e-02f, 6.87040612e-02f, 5.72565012e-02f, -1.51691437e-02f, 7.72801861e-02f, 7.58809131e-03f, 1.43683879e-02f, -8.86389241e-02f, 4.78746593e-02f,
  7.72311864e-03f, -3.50696174e-03f, 4.36955038e-03f, -6.56257123e-02f, -2.10387472e-04f, -6.76690936e-02f, -8.77888128e-02f, -5.64215099e-03f, -5.60441501e-02f, -3.26816589e-02f,
  -3.65561037e-03f, -8.99533704e-02f, 1.09650539e-02f, -5.26426658e-02f, 3.73848863e-02f, -6.46966770e-02f, 5.34456149e-02f, 4.68540601e-02f, -7.08083585e-02f, 1.27973426e-02f,
  -1.67941209e-03f, -5.05816638e-02f, -5.99739142e-02f, 4.75123487e-02f, -9.13495943e-02f, -9.09881480e-03f, -2.52451422e-03f, -3.34768370e-02f, -4.84020784e-02f, -5.44830300e-02f,
  -1.09704686e-02f, 2.23745294e-02f, 2.66662221e-02f, 4.98189442e-02f, -5.33486390e-03f, -9.52111855e-02f, -1.01549059e-01f, 1.16658971e-01f, 1.52870910e-02f, -2.04146393e-02f,
  2.79072709e-02f, -7.86805376e-02f, 3.86837646e-02f, -2.66390610e-02f, 9.17211622e-02f, -9.16341990e-02f, 5.35174012e-02f, -5.58290817e-03f, -7.40463063e-02f, -8.55406374e-02f,
  4.95376736e-02f, 2.19515692e-02f, -1.10240459e-01f, 1.71166416e-02f, 8.64729583e-02f, -2.72119362e-02f, -8.24282616e-02f, 8.07082057e-02f, -4.80652750e-02f, 8.48580003e-02f,
  9.35392007e-02f, 3.03775482e-02f, -2.56830677e-02f, 5.03583141e-02f, 3.39264907e-02f, 6.52255341e-02f, -9.47594363e-03f, 1.19488522e-01f, 1.06127225e-01f, 7.50835752e-03f,
  -3.44260558e-02f, 6.60148486e-02f, -1.86421573e-02f, 1.94790424e-03f, 7.46765286e-02f, 9.93274003e-02f, 6.93617463e-02f, -4.60730977e-02f, -1.33909741e-02f, 9.79227666e-03f,
  -6.84270710e-02f, -7.68113285e-02f, -8.09707195e-02f, -4.08672430e-02f, 1.00223050e-01f, 6.86678737e-02f, 1.47903748e-02f, 1.74527615e-02f, -3.99065344e-03f, 1.23882461e-02f,
  1.25515070e-02f, 1.64575670e-02f, -1.68594960e-02f, -3.66381672e-03f, 5.18622585e-02f, -3.35754044e-02f, 5.65433763e-02f, -2.63420232e-02f, -5.67473583e-02f, -2.03098692e-02f,
  6.48405924e-02f, 4.80771735e-02f, -8.90546963e-02f, -8.37811455e-02f, 7.03825057e-02f, 1.78714208e-02f, 4.68192697e-02f, 3.44138183e-02f, 7.40026236e-02f, 2.46386919e-02f,
  1.27238734e-02f, 3.94518003e-02f, -3.05676591e-02f, 6.38382137e-02f, -5.20028248e-02f, 4.63954685e-03f, -7.96597749e-02f, -6.22471347e-02f, 8.23778510e-02f, 8.42553899e-02f,
  5.85918762e-02f, 7.71003217e-02f, -8.11618194e-02f, -1.74120744e-03f, 5.01265526e-02f, 4.64496464e-02f, 4.92194202e-03f, 9.35019627e-02f, 5.77116422e-02f, 7.03329444e-02f,
  9.63080376e-02f, 7.71331415e-02f, 1.43627170e-04f, 4.73498963e-02f, -6.79020509e-02f, -6.71166852e-02f, 7.64234662e-02f, -7.09570497e-02f, 2.48787664e-02f, 5.24334311e-02f,
  2.75463108e-02f, -3.65012549e-02f, -9.19819027e-02f, 1.58285238e-02f, 4.86363024e-02f, -9.57048091e-04f, 8.83801803e-02f, 3.97945754e-02f, 8.55883658e-02f, 8.58164057e-02f,
  -6.36004880e-02f, -6.82509020e-02f, -7.83908963e-02f, -4.66353493e-03f, -8.80818591e-02f, 1.66132674e-02f, -8.12186450e-02f, 4.61349934e-02f, -7.92472810e-02f, 3.51830982e-02f,
  -1.06109900e-03f, 1.10512916e-02f, 1.61044933e-02f, -3.69712897e-02f, 2.68108565e-02f, 9.97035652e-02f, -8.33029449e-02f, -7.29330033e-02f, 4.93232273e-02f, 2.50522289e-02f,
  7.19546080e-02f, -1.70941390e-02f, -6.09794743e-02f, 1.51021834e-02f, 1.20258387e-02f, -1.59108862e-02f, 7.14634731e-02f, -1.74818039e-02f, -4.00841832e-02f, 1.33457053e-02f,
  -9.50192660e-02f, -2.98408238e-04f, 1.20445816e-02f, -9.42336470e-02f, -1.52792007e-01f, 3.03818602e-02f, 9.93463211e-03f, 9.95855499e-03f, -3.93306930e-03f, -2.72029452e-02f,
  -4.95817028e-02f, -8.65820944e-02f, -8.72946810e-03f, 5.22739887e-02f, -4.35203277e-02f, 1.27095163e-01f, -8.08130950e-02f, 7.05443621e-02f, -4.88929413e-02f, 5.62072080e-03f,
  -1.87152065e-02f, 1.88418347e-02f, 4.31362428e-02f, -3.90016884e-02f, 2.48520765e-02f, -3.80178951e-02f, 4.94136550e-02f, -5.49529977e-02f, 9.27043986e-03f, -1.06385708e-01f,
  -5.43579049e-02f, -8.24060366e-02f, 7.89757967e-02f, -5.68098575e-02f, -2.02565398e-02f, -6.54441938e-02f, 1.11008331e-01f, -6.11027367e-02f, 7.78889284e-02f, -1.25732794e-01f,
  -6.80471957e-02f, -4.76792902e-02f, -8.24308768e-02f, 1.80193328e-03f, 3.55899967e-02f, -5.92202600e-03f, 9.57546290e-03f, 1.16905496e-02f, 3.24565731e-02f, -1.95909645e-02f,
  -4.74920757e-02f, 6.45970553e-02f, -2.72847991e-02f, -1.11265909e-02f, 3.32764015e-02f, 1.09320037e-01f, 4.06458527e-02f, -3.10788713e-02f, -4.88616005e-02f, 5.44744246e-02f,
  2.17437577e-02f, -5.42438440e-02f, 6.90594912e-02f, 2.05435529e-02f, 1.55626200e-02f, -1.05103567e-01f, 1.04291516e-03f, 3.23119350e-02f, -7.09395856e-02f, -2.73129866e-02f,
  1.16618499e-02f, 3.18254083e-02f, 1.42045608e-02f, -2.21376885e-02f, 3.03056976e-03f, 4.01292294e-02f, 4.75755855e-02f, -3.28104272e-02f, 1.76232308e-02f, -8.75591412e-02f,
  3.06861419e-02f, 9.50019732e-02f, -1.57453364e-03f, 7.82037824e-02f, 6.92582726e-02f, 1.26414910e-01f, 7.91397616e-02f, 4.16980274e-02f, 2.95231864e-02f, -6.94290772e-02f,
  -6.34890646e-02f, 2.10158117e-02f, 1.46716442e-02f, 1.86792258e-02f, 1.16050839e-02f, 8.13178420e-02f, -3.07495575e-02f, 6.70099165e-03f, 5.17808693e-03f, -7.88459405e-02f,
  -1.04830898e-02f, -2.82781906e-02f, -1.78562887e-02f, 1.10932313e-01f, 3.49276289e-02f, 8.28936137e-03f, -7.12022260e-02f, 7.60927098e-03f, 2.87858229e-02f, -2.26131100e-02f,
  -9.44281146e-02f, 2.49400605e-02f, 7.63255432e-02f, 2.25950591e-02f, 4.45777141e-02f, -3.90469888e-03f, -9.08639356e-02f, 6.38493896e-02f, 7.07413629e-02f, -5.34051545e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.07856207e-01f, 1.26191929e-01f, 1.23515919e-01f, -6.65462762e-02f, -4.27377447e-02f, -2.14075595e-02f, 9.08921733e-02f, -5.09417430e-02f, 5.89295141e-02f, -6.81934878e-02f,
  2.14194264e-02f, -1.47323301e-02f, -8.90917182e-02f, 9.70725194e-02f, 6.92480803e-02f, 3.05193588e-02f, -4.40077335e-02f, -4.21987893e-03f, 5.36995605e-02f, -6.30717864e-03f,
  9.85086635e-02f, -2.79859193e-02f, 2.01397035e-02f, -4.73682098e-02f, -6.60992265e-02f, 3.03683709e-02f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -6.85951710e-02f, -5.08348318e-03f, 9.11209360e-02f, -4.39963676e-02f, -6.94382042e-02f, 1.04240119e-01f, 1.31783485e-01f, -1.09594889e-01f, 5.45934662e-02f, -2.52012685e-02f,
  1.07110791e-01f, -3.58852260e-02f, -8.54109749e-02f, -1.04069330e-01f, 1.55917453e-02f, -5.36803119e-02f, -1.86470263e-02f, -9.33363140e-02f, -4.23145480e-02f, 2.46074926e-02f,
  -1.67468097e-02f, -3.71680409e-02f, -1.60041422e-01f, -3.95020880e-02f, -6.75084963e-02f, 1.21033505e-01f, 1.07042335e-01f, -5.86622134e-02f, 7.32365996e-02f, -1.14197440e-01f,
  -6.72561396e-03f, 7.94511810e-02f, 1.60304263e-01f, -9.00737569e-02f, 2.03307923e-02f, -1.18245006e-01f, -1.35289758e-01f, 5.52892722e-02f, 1.25431865e-01f, -7.14735836e-02f,
  8.93354937e-02f, -1.20542340e-01f, 4.34064753e-02f, 2.00503543e-02f, 1.13406241e-01f, 4.24485467e-02f, -3.78981838e-03f, -6.94639534e-02f, 7.92363584e-02f, -5.75102260e-03f,
  2.22287893e-01f, -2.97627877e-02f, 2.32391339e-02f, 5.95688913e-03f, 2.18560826e-02f, -8.60934034e-02f, 3.67258675e-02f, -2.84022707e-02f, -1.13582850e-01f, -1.04460880e-01f,
  -1.18339509e-01f, -6.95417523e-02f, -2.68066972e-02f, 8.12904239e-02f, -5.53464191e-03f, 3.12288459e-02f, -7.48241618e-02f, 1.18641436e-01f, -7.30025992e-02f, 1.05226962e-02f,
  -9.74909589e-02f, -3.63331102e-02f, -2.00383455e-01f, 1.55716836e-02f, -5.47197871e-02f, -1.64071675e-02f, 8.16159882e-03f, 5.91949262e-02f, -3.78355794e-02f, -1.10782817e-01f,
  -5.20416209e-03f, 1.58108369e-01f, 1.24099322e-01f, -1.95587967e-02f, -1.35656938e-01f, -1.46437317e-01f, 1.58936188e-01f, 7.34160393e-02f, 1.25147146e-03f, 1.09995365e-01f,
  1.52235687e-01f, 1.27414733e-01f, 7.28654936e-02f, 1.40780285e-01f, 1.54346758e-02f, -1.77192509e-01f, -1.22068264e-01f, -8.48974288e-02f, 1.13080718e-01f, 1.87031776e-02f,
  -4.82990444e-02f, 7.80946538e-02f, -3.97660397e-02f, -5.18247187e-02f, -1.21440955e-01f, 6.93851709e-02f, 2.35756226e-02f, -3.12512740e-02f, -8.36425647e-02f, 4.80904281e-02f,
  -1.34441435e-01f, -5.99048324e-02f, -2.17094156e-03f, -8.85185897e-02f, -3.66106294e-02f, -4.17063236e-02f, 2.17431914e-02f, 2.17159446e-02f, -9.39736664e-02f, 3.67980450e-02f,
  -1.56353414e-02f, -3.46380472e-02f, 1.53688744e-01f, 1.59187749e-01f, -8.00616667e-02f, 3.69275734e-02f, 1.03515774e-01f, 5.41104190e-02f, 2.40374580e-02f, 2.72862986e-03f,
  -1.79361217e-02f, -1.13254353e-01f, -8.16952735e-02f, -4.60878201e-02f, -9.00684148e-02f, -5.04283234e-02f, 1.37938201e-01f, 4.10011448e-02f, -2.80990656e-02f, -1.07827179e-01f,
  -1.12023145e-01f, 4.76723239e-02f, 6.53082654e-02f, -1.28203228e-01f, -4.05973196e-02f, -1.03312537e-01f, 3.37391905e-02f, 8.33955333e-02f, 7.00202361e-02f, 1.41585767e-01f,
  -7.69403353e-02f, 5.56442104e-02f, -5.29944412e-02f, -9.75371245e-03f, 6.34568511e-03f, -5.63374944e-02f, 1.48884533e-02f, -2.04459857e-02f, -1.17395325e-02f, -1.32481214e-02f,
  1.27416819e-01f, 5.54813258e-02f, 1.04594631e-02f, 1.03324756e-01f, -1.93646923e-01f, 3.63561213e-02f, 9.72900242e-02f, 1.25206247e-01f, 2.11260412e-02f, -8.33976865e-02f,
  -1.05162501e-01f, 1.76337138e-02f, -1.00344218e-01f, -2.14890614e-02f, 1.63627088e-01f, 1.72165968e-02f, -5.21441437e-02f, 9.72991958e-02f, 1.97386473e-01f, -8.80239066e-04f,
  8.78959596e-02f, 1.25234336e-01f, -1.00580268e-01f, 2.70439815e-02f, 9.20529291e-02f, 6.50978759e-02f, 4.35363837e-02f, -9.56674367e-02f, 4.27759476e-02f, -4.95902076e-02f,
  -5.80042601e-02f, 1.16577767e-01f, 5.65177985e-02f, -6.03038557e-02f, 5.83723607e-03f, 3.90996784e-02f, -9.60442517e-03f, 2.69409753e-02f, -6.38307035e-02f, 3.62713635e-02f,
  5.87357674e-04f, -7.33943358e-02f, -4.14587855e-02f, 1.97353773e-02f, 5.02853692e-02f, 8.47424567e-02f, -6.87072277e-02f, -9.04159248e-02f, -9.63636488e-02f, 4.28524651e-02f,
  3.00887949e-03f, 8.47559124e-02f, 5.78330755e-02f, 4.77042720e-02f, 2.13565864e-02f, 7.35914111e-02f, 3.62974666e-02f, 3.23432148e-03f, -6.57944381e-02f, 3.74463014e-02f,
  1.08075328e-01f, -1.02177814e-01f, -1.89906195e-01f, 9.78873763e-03f, -5.30681312e-02f, -1.41199052e-01f, 2.12585311e-02f, 7.25857466e-02f, 1.49370432e-01f, -2.04644296e-02f,
  -1.72025442e-01f, 7.65324803e-03f, -4.70741419e-04f, 6.69888556e-02f, 5.12160733e-02f, -8.89172256e-02f, 1.14080608e-01f, 2.76393462e-02f, -1.46927029e-01f, 7.71133453e-02f,
  -1.87116154e-02f, 2.04352289e-02f, 1.45000499e-03f, -2.73618679e-02f, -7.89363161e-02f, -2.09665522e-02f, -7.55661577e-02f, 7.48999789e-02f, 5.94432801e-02f, 1.00899771e-01f,
  -7.92424232e-02f, 1.67732969e-01f, 3.88694853e-02f, 1.27888441e-01f, 1.21844612e-01f, -6.80514006e-03f, 1.32863939e-01f, -5.28301746e-02f, 1.52115181e-01f, 1.58407748e-01f,
  1.19035825e-01f, -1.32524054e-02f, -2.78558191e-02f, -3.90471108e-02f, 5.57781793e-02f, 6.88659996e-02f, 1.04809646e-02f, -9.64653865e-02f, 8.23189970e-03f, 1.21877804e-01f,
  8.10654536e-02f, 7.16612414e-02f, -5.26615717e-02f, 4.91838232e-02f, 1.06615245e-01f, -1.78302184e-01f, -1.24244094e-01f, -1.11758098e-01f, 1.01958573e-01f, 7.11494461e-02f,
  3.17844898e-02f, -7.62488171e-02f, 2.12316550e-02f, 9.68227535e-02f, 2.40488760e-02f, 1.13547422e-01f, -5.19443899e-02f, -1.82977244e-01f, -1.72992229e-01f, 3.91528709e-03f,
  9.25402939e-02f, -2.61301938e-02f, 1.38579488e-01f, 9.43661928e-02f, -7.42325112e-02f, -1.09162666e-01f, -5.80437034e-02f, 8.54624286e-02f, 7.59753361e-02f, -1.21934362e-01f,
  -1.95287034e-01f, -5.98554872e-02f, 1.28141521e-02f, -1.56177254e-02f, 8.13616291e-02f, -1.47020102e-01f, -4.04209852e-01f, -2.92883869e-02f, 1.70698509e-01f, -1.06063001e-01f,
  -4.84642088e-02f, 1.49527565e-01f, 6.53649271e-02f, 2.13348433e-01f, 9.68312994e-02f, 5.85556887e-02f, 1.42655298e-01f, 5.52822314e-02f, -1.50576178e-02f, -8.81254673e-02f,
  1.30884081e-01f, 2.70736441e-02f, 1.62452027e-01f, -3.41124199e-02f, 7.15950057e-02f, 2.01962903e-01f, 1.33385673e-01f, 6.71113580e-02f, 6.24272302e-02f, -5.68984486e-02f,
  9.51695163e-03f, 1.24626067e-02f, -1.36956165e-03f, 5.43451421e-02f, -8.36264156e-03f, -1.94562285e-03f, 1.35450482e-01f, -6.48406893e-02f, -1.41637564e-01f, -8.07927027e-02f,
  1.63759932e-01f, -8.73507708e-02f, -1.97786555e-01f, 1.50926188e-01f, 1.22626290e-01f, -1.67257249e-01f, -1.98652416e-01f, 3.94333415e-02f, -3.63991261e-02f, 1.18863411e-01f,
  2.19496012e-01f, -9.03795287e-02f, 3.55442949e-02f, 1.11244574e-01f, 5.30614741e-02f, -6.73333853e-02f, 8.53464156e-02f, -3.65682654e-02f, -4.82695401e-02f, -6.14834875e-02f,
  3.77089605e-02f, -5.88963216e-04f, -1.55424505e-01f, 8.40030890e-03f, -1.28030196e-01f, -9.83523875e-02f, 1.43855929e-01f, -1.31312773e-01f, 1.14926688e-01f, 5.59274331e-02f,
  -2.75424030e-02f, -7.11455988e-03f, 1.08533865e-02f, -1.07413501e-01f, -9.17688850e-03f, 3.82284746e-02f, 9.91659760e-02f, -1.86518673e-02f, -1.24437526e-01f, 1.13392659e-02f,
  1.06469788e-01f, -1.97422028e-01f, -7.79786110e-02f, -1.12564564e-01f, 7.56654665e-02f, -6.62660524e-02f, -2.81642154e-02f, -3.73892747e-02f, -1.29676759e-01f, 6.86333776e-02f,
  -5.84121644e-02f, 4.43558255e-03f, -1.35076761e-01f, -3.48262973e-02f, 4.21556495e-02f, 3.59766930e-02f, 5.32195307e-02f, 1.11416444e-01f, -2.76822336e-02f, 4.16699536e-02f,
  -1.30682096e-01f, 6.58337548e-02f, 1.42751694e-01f, 2.08620001e-02f, -5.00201322e-02f, -5.94363175e-03f, -1.04904093e-01f, 6.94646733e-03f, -1.16168708e-01f, 1.02922253e-01f,
  -2.04885309e-03f, 1.13609351e-01f, -3.75412256e-02f, 6.41822210e-03f, 5.44976033e-02f, 3.10552563e-03f, 4.00368460e-02f, -9.77512151e-02f, 9.48615223e-02f, 4.11333814e-02f,
  4.65736277e-02f, 1.44575194e-01f, -9.24186036e-02f, 1.06098764e-01f, 3.04495282e-02f, -1.02716528e-01f, 8.53178278e-02f, 1.03670120e-01f, -1.80624221e-02f, -3.30234468e-02f,
  -1.75437164e-02f, -7.81838745e-02f, 8.57160017e-02f, 3.17562409e-02f, -1.22415222e-01f, -1.03234805e-01f, -1.83366776e-01f, -4.75484394e-02f, -1.69798341e-02f, -1.02762952e-01f,
  1.35663331e-01f, -5.15746549e-02f, -6.86064065e-02f, 1.28690936e-02f, -2.29205973e-02f, -4.38863747e-02f, 8.02060142e-02f, -1.25447035e-01f, -3.86797711e-02f, -1.46673173e-01f,
  7.90875107e-02f, 3.79070230e-02f, 5.55850528e-02f, 1.10903576e-01f, 2.69076843e-02f, 1.25457188e-02f, 4.10928130e-02f, 9.44562703e-02f, -1.87988728e-01f, 1.24264639e-02f,
  -4.95350547e-02f, 8.22847337e-02f, 1.28512979e-01f, -1.39290288e-01f, -6.73930272e-02f, -9.31683928e-02f, -1.20256208e-01f, 5.45406714e-02f, 5.53672016e-02f, 1.24112098e-02f,
  -3.67752016e-02f, -1.28017329e-02f, -1.39475637e-03f, -2.43387967e-02f, -8.98424760e-02f, -7.85764381e-02f, 2.37245159e-03f, 2.50448845e-02f, -3.88929024e-02f, -8.39345232e-02f,
  5.71227819e-02f, 6.65569352e-03f, -4.54030819e-02f, 1.55471325e-01f, -1.35845607e-02f, 1.09618254e-01f, -1.01098821e-01f, -1.75939754e-01f, -1.36204019e-01f, -1.08584195e-01f,
  -1.37201265e-01f, -4.93146665e-02f, -1.73105732e-01f, -5.93357421e-02f, 1.16447531e-01f, -1.05798423e-01f, 6.90899044e-02f, -9.25171524e-02f, -1.91473421e-02f, 1.91091131e-02f,
  8.10591206e-02f, 1.19908676e-01f, 5.58340102e-02f, 1.84544638e-01f, 4.94379438e-02f, 5.45255207e-02f, 5.87804876e-02f, -6.16974384e-02f, -4.24051024e-02f, 7.42020458e-02f,
  5.59982844e-02f, 1.01448689e-03f, -4.38054986e-02f, -3.30756679e-02f, -1.53137833e-01f, 7.94135556e-02f, 3.89740895e-03f, -1.65660948e-01f, 1.60334911e-02f, 2.63788607e-02f,
  -2.11894631e-01f, -1.73481211e-01f, -8.55028480e-02f, 7.41311386e-02f, -7.33926147e-02f, 4.15360369e-02f, 2.31117569e-02f, 5.51393665e-02f, -1.70203716e-01f, 7.27681741e-02f,
  1.64016411e-01f, -5.20886295e-02f, -3.14395614e-02f, 2.76607908e-02f, 2.00252086e-01f, 1.56213194e-02f, -2.61523053e-02f, 1.29972890e-01f, 8.05162787e-02f, 2.18882442e-01f,
  1.15076974e-01f, -6.37381673e-02f, -4.56599332e-02f, 1.05214700e-01f, -5.47094084e-02f, -2.00162038e-01f, -1.88556567e-01f, -7.47557171e-03f, 1.90453872e-01f, 1.12213202e-01f,
  -1.02036245e-01f, 1.83282226e-01f, -1.17230862e-01f, 1.13024019e-01f, 7.11922646e-02f, -2.42202636e-02f, 1.41470835e-01f, 2.98790429e-02f, -1.94423154e-01f, -9.17951167e-02f,
  9.16257352e-02f, 1.41010091e-01f, -5.02246432e-02f, -7.95670077e-02f, 1.44530330e-02f, -8.94388109e-02f, -5.73389269e-02f, -4.97152172e-02f, -2.92748325e-02f, 5.11843376e-02f,
  -5.71772270e-02f, 9.28437933e-02f, -5.78375161e-02f, 1.05212979e-01f, -2.37328392e-02f, 2.96466164e-02f, 1.34271845e-01f, -2.40386603e-03f, -4.28613499e-02f, -1.91333398e-01f,
  -5.29437363e-02f, 4.03380133e-02f, 1.24023087e-01f, 2.58761123e-02f, 1.04588792e-01f, 1.70044854e-01f, -5.02226315e-02f, -7.02220425e-02f, -8.04299861e-02f, 6.97849179e-03f,
  -5.07166097e-03f, -1.32781481e-02f, 1.40492305e-01f, -6.09434508e-02f, -6.09336272e-02f, 1.52821824e-01f, 3.63703212e-03f, 8.64576027e-02f, -3.04400355e-01f, -1.48768768e-01f,
  1.19222648e-01f, -7.09937140e-02f, -2.70169377e-02f, -8.30088407e-02f, -9.82377082e-02f, -6.16332479e-02f, 3.41511741e-02f, -2.56624103e-01f, 1.44815013e-01f, 2.72792932e-02f,
  2.08646566e-01f, -1.87978581e-01f, -2.57017434e-01f, 1.12283677e-01f, 9.76496413e-02f, -1.59593627e-01f, -5.16855195e-02f, -9.55914482e-02f, -1.59839019e-01f, 4.96759638e-02f,
  6.35904446e-02f, -9.65062529e-03f, 1.13086626e-01f, -7.92501494e-02f, -1.41841322e-01f, 2.10882407e-02f, 1.42385364e-01f, -5.48319472e-03f, 1.86121434e-01f, 1.19653508e-01f,
  3.56662944e-02f, 3.71622369e-02f, -8.71606395e-02f, 5.78286760e-02f, -9.22755003e-02f, 1.95572395e-02f, 6.14082590e-02f, -4.42003906e-02f, -1.31647840e-01f, 1.47011206e-01f,
  -1.05709426e-01f, -3.46354321e-02f, 5.81074879e-02f, 4.93150838e-02f, -1.66045398e-01f, 9.37764496e-02f, 4.59949672e-02f, 4.62840125e-02f, -5.98345399e-02f, 1.93400681e-02f,
  -5.67430817e-02f, -9.37798172e-02f, -9.54251885e-02f, 1.06665142e-01f, 2.78705149e-03f, 3.92598510e-02f, -2.07913443e-02f, -1.04157150e-01f, 6.63280934e-02f, -1.66176692e-01f,
  1.92522302e-01f, -1.42323136e-01f, -1.27907559e-01f, 2.34242737e-01f, -2.42576487e-02f, -1.24875724e-01f, 4.73402254e-02f, 1.52444333e-01f, 7.24277720e-02f, 2.78194044e-02f,
  2.15479046e-01f, 8.37771520e-02f, 5.76535016e-02f, 7.05428347e-02f, 1.65052246e-02f, -7.04619735e-02f, 1.34912565e-01f, -6.43455535e-02f, 1.66288391e-01f, -1.92869559e-01f,
  -7.61468410e-02f, -3.84270437e-02f, -1.54251710e-01f, 9.56155658e-02f, -1.31122423e-02f, 6.97067901e-02f, -3.07262298e-02f, -1.28815040e-01f, 9.11934078e-02f, 1.76937550e-01f,
  -6.49662241e-02f, 3.43071148e-02f, -3.10535729e-02f, -5.28049748e-03f, -5.88465780e-02f, -7.51917483e-03f, 1.31243572e-01f, 1.63507953e-01f, 8.93696919e-02f, -1.38022855e-01f,
  9.10435431e-03f, -5.87439388e-02f, 2.07127687e-02f, 6.33506337e-03f, -3.56376022e-02f, -1.28718391e-01f, -5.69222011e-02f, -1.43587574e-01f, -3.77110727e-02f, 1.08469687e-01f,
  -1.04532376e-01f, 2.95385439e-02f, 1.32868132e-02f, -4.65057418e-03f, 2.47223023e-02f, 1.11577399e-01f, -8.55460316e-02f, -1.28009290e-01f, -1.38704628e-01f, 2.04911847e-02f,
  -3.67296189e-02f, -4.31961231e-02f, 8.30038041e-02f, 1.85722098e-01f, -8.52241889e-02f, -1.07620746e-01f, -7.62408301e-02f, -1.51126459e-01f, -1.88561920e-02f, 1.16920635e-01f,
  1.23095118e-01f, 5.22815883e-02f, -4.23505120e-02f, 1.74350366e-02f, 9.10719261e-02f, 8.75747949e-02f, 9.66181606e-02f, -1.85287103e-01f, -4.08268385e-02f, 3.17194834e-02f,
  3.98901924e-02f, 3.22098397e-02f, 4.46000509e-02f, 1.26890251e-02f, -2.73038391e-02f, -2.90001165e-02f, -2.30481904e-02f, 4.51934226e-02f, 1.66412011e-01f, -5.94649324e-03f,
  1.12025931e-01f, 8.44462961e-02f, -4.07503843e-02f, 5.08696996e-02f, 1.82339340e-01f, -7.98803419e-02f, 3.86349000e-02f, -6.10485151e-02f, -2.81415060e-02f, 1.93947088e-02f,
  -7.20075145e-02f, 5.78903742e-02f, 8.18685740e-02f, 1.22479185e-01f, 1.11283623e-01f, 5.62412180e-02f, -1.02776863e-01f, 7.86855146e-02f, 1.07008994e-01f, -1.20073937e-01f,
  -1.39511690e-01f, 2.35038232e-02f, 6.57926798e-02f, 1.62254144e-02f, -6.39851093e-02f, -4.85867523e-02f, 7.87782222e-02f, -2.70351544e-02f, -2.01354921e-01f, 8.28446150e-02f,
  -1.11933373e-01f, -4.30306559e-03f, 2.31885184e-02f, -9.08901822e-03f, -8.14935565e-02f, 5.66718802e-02f, -1.28268436e-01f, 8.14987645e-02f, -8.04826170e-02f, 1.07700825e-01f,
  -5.73887080e-02f, -1.67872265e-01f, 9.23943594e-02f, 1.22064717e-01f, 1.21862076e-01f, -5.95351234e-02f, 6.84126318e-02f, -2.91320384e-02f, -1.79646879e-01f, -2.58465149e-02f,
  3.34929787e-02f, 3.82083729e-02f, 8.99235681e-02f, -4.08087559e-02f, -5.61039187e-02f, 8.36850237e-03f, 1.46885021e-02f, -2.68882699e-02f, -6.43697754e-02f, -1.35793090e-01f,
  5.23455925e-02f, -1.63172632e-01f, -1.46816343e-01f, -5.26396409e-02f, 2.07528714e-02f, 8.15888271e-02f, -3.87080908e-02f, 7.47045949e-02f, 3.42977382e-02f, -8.04063305e-02f,
  2.12607384e-01f, 1.29189476e-01f, 6.60610478e-03f, 1.42879799e-01f, -1.56351507e-01f, 8.57422575e-02f, 7.74747953e-02f, 7.43900910e-02f, -4.55417372e-02f, 9.78658348e-02f,
  4.10254300e-03f, 1.19262166e-01f, -1.21766202e-01f, 6.61074743e-02f, -1.45202830e-01f, -3.41095850e-02f, -7.52595142e-02f, -1.65086970e-01f, -1.28574409e-02f, -5.97035885e-03f,
  -1.89701915e-01f, -3.68122533e-02f, -1.76025674e-01f, -1.19006559e-01f, 7.53490552e-02f, -9.81023386e-02f, 1.23444460e-01f, -1.58516496e-01f, 7.93873593e-02f, 8.40921700e-02f,
  -7.37611428e-02f, -1.28372774e-01f, -1.76174760e-01f, -1.15376577e-01f, 7.83182904e-02f, 4.34605181e-02f, 6.73706159e-02f, -9.40521136e-02f, 1.41820729e-01f, -4.14074026e-02f,
  -2.07238365e-02f, 5.88009357e-02f, -1.58284158e-01f, -8.85235071e-02f, 7.32561201e-02f, -6.55571669e-02f, 1.23713419e-01f, 1.32773325e-01f, 9.18104202e-02f, 4.06242870e-02f,
  -1.50206625e-01f, 1.10619791e-01f, -1.26520798e-01f, 2.87948828e-02f, 8.82944018e-02f, -1.54439658e-01f, -1.38759971e-01f, 1.94104239e-02f, 1.18860163e-01f, 5.15635014e-02f,
  -1.54064909e-01f, 8.17237571e-02f, -7.50700533e-02f, 2.01406237e-02f, 2.02794582e-01f, 6.26217648e-02f, 1.37061983e-01f, 1.99514955e-01f, 6.22288994e-02f, 1.56890735e-01f,
  1.09943569e-01f, 1.26489967e-01f, 5.30869560e-03f, 3.33203934e-02f, 7.15207160e-02f, -6.97541833e-02f, 7.27451313e-03f, -4.54675704e-02f, -5.18163405e-02f, 8.99404213e-02f,
  1.07458318e-02f, -1.24314986e-01f, -8.62499028e-02f, 2.16073133e-02f, -2.86312431e-01f, -3.92142944e-02f, -1.62800669e-03f, 1.46619260e-01f, 1.09717928e-01f, 1.49650961e-01f,
  2.02263907e-01f, -9.85679328e-02f, 9.77591202e-02f, 1.34033933e-01f, 7.02684745e-02f, -6.76671937e-02f, -9.50102955e-02f, 1.06922381e-01f, 1.60734773e-01f, 1.98873758e-01f,
  -1.15840510e-01f, -4.83301952e-02f, 1.51126295e-01f, 1.58315822e-01f, -1.68469436e-02f, 5.80770969e-02f, -2.41818838e-02f, -8.79635662e-02f, 1.05141930e-01f, 5.45283444e-02f,
  2.04992276e-02f, 8.25973526e-02f, 3.93485166e-02f, 1.74509943e-01f, -1.96661130e-02f, 9.00663957e-02f, -1.01931855e-01f, 7.69857019e-02f, 8.66750255e-02f, 8.10299127e-04f,
  -1.96888566e-01f, 3.42773385e-02f, -7.31505826e-02f, 6.68988079e-02f, 3.44907679e-02f, 1.95062250e-01f, -1.32636070e-01f, 1.35946423e-01f, 2.18908608e-01f, -6.69619590e-02f,
  8.60975012e-02f, 1.91088527e-01f, 1.38258655e-02f, 8.98545831e-02f, 3.88937593e-02f, 8.79361853e-02f, -4.77702357e-02f, 2.86760870e-02f, 1.26958452e-02f, -1.94518436e-02f,
  1.25938147e-01f, 5.32449363e-03f, 2.97604166e-02f, 1.13469534e-01f, -4.25735600e-02f, 2.49005612e-02f, 1.32197395e-01f, 8.75047594e-02f, -1.06073497e-02f, 5.30098900e-02f,
  4.39300342e-03f, 6.53529242e-02f, 5.70994802e-02f, 8.11895654e-02f, 1.24987788e-01f, -9.84223746e-03f, -4.50724140e-02f, 1.84517071e-01f, 7.91503564e-02f, -1.14284053e-01f,
  -7.86575675e-02f, 5.05035147e-02f, 1.47244960e-01f, -4.19919519e-03f, -8.17471072e-02f, 4.40776274e-02f, 5.26829511e-02f, -2.72578150e-02f, -1.98818427e-02f, 1.66816503e-01f,
  8.64953324e-02f, -7.54385963e-02f, -1.80085301e-02f, -6.18869066e-02f, 1.31855831e-01f, 9.56450552e-02f, 1.24960311e-01f, -6.48910329e-02f, -3.50797474e-02f, -7.25690126e-02f,
  1.09234221e-01f, 1.19185537e-01f, -5.27542979e-02f, 6.67076139e-03f, -5.35008647e-02f, -9.91880894e-02f, -4.36727293e-02f, -1.01273365e-01f, 1.06568538e-01f, 7.44820237e-02f,
  -2.80598879e-01f, -1.21646389e-01f, 2.94822222e-03f, -1.74655709e-02f, -7.08359703e-02f, 1.72466233e-01f, -5.77959530e-02f, 9.79050025e-02f, -8.00909102e-02f, 4.66108285e-02f,
  1.09173127e-01f, -7.46665746e-02f, -1.12819366e-01f, 9.45261121e-02f, -4.58146892e-02f, 1.03562109e-01f, 3.64764594e-02f, 5.55080734e-02f, -3.25767659e-02f, -9.04357508e-02f,
  4.28732559e-02f, -1.24789380e-01f, -2.85352096e-02f, -1.70420390e-02f, -1.44107848e-01f, 5.02592660e-02f, -8.85659978e-02f, -7.39631131e-02f, 1.02832705e-01f, -1.04357578e-01f,
  -1.23820258e-02f, 5.45434467e-02f, 7.78365806e-02f, 1.48926467e-01f, -1.15206100e-01f, 2.15371251e-02f, -6.25684783e-02f, -4.07609381e-02f, 5.68249635e-02f, 6.77860230e-02f,
  -1.00685298e-01f, 1.72627158e-02f, -4.47978228e-02f, -1.31268293e-01f, -1.93587974e-01f, 7.45547935e-02f, 6.67302087e-02f, 7.50002563e-02f, -1.00216262e-01f, 9.42267254e-02f,
  -1.54155508e-01f, 5.97266257e-02f, -7.05196485e-02f, 7.00292289e-02f, 1.14488773e-01f, 6.87876865e-02f, 6.06256677e-03f, -4.25774567e-02f, -1.12644449e-01f, 2.73017474e-02f,
  -2.96726022e-02f, 9.12275240e-02f, -6.56810850e-02f, -9.17569324e-02f, 1.52797610e-01f, 6.61528036e-02f, -9.33216047e-03f, -5.96506707e-03f, 1.33174639e-02f, 5.73075898e-02f,
  7.01084659e-02f, 7.24743009e-02f, -1.62912589e-02f, -1.08867120e-02f, 1.22498702e-02f, 6.96154386e-02f, 6.47977367e-02f, -3.63706499e-02f, 8.68159980e-02f, -3.32914703e-02f,
  -1.17580965e-01f, 4.96152379e-02f, 1.68715402e-01f, -9.87576693e-02f, -1.40803093e-02f, 1.84236184e-01f, 1.23425163e-01f, -8.96474998e-03f, 7.43180290e-02f, 2.63121407e-02f,
  5.10567948e-02f, 7.08107662e-04f, -6.31216019e-02f, 4.98183668e-02f, 4.19358425e-02f, -2.85634771e-02f, -2.91409194e-02f, 1.00631647e-01f, -7.57962465e-02f, 4.30427603e-02f,
  5.55393621e-02f, -1.03688478e-01f, 1.52595967e-01f, -4.57910374e-02f, 1.05479725e-01f, 1.16132021e-01f, 3.84338722e-02f, 7.32443556e-02f, -4.73150946e-02f, 6.09968044e-02f,
  -1.25591561e-01f, -1.47891805e-01f, 7.14484882e-03f, 6.31758496e-02f, 1.35230780e-01f, -1.42794818e-01f, -8.78923088e-02f, 1.57222569e-01f, 1.07340634e-01f, 1.11430392e-01f,
  2.87574083e-02f, -1.30952686e-01f, 1.50446072e-02f, 1.24260247e-01f, 2.29273625e-02f, 1.06889166e-01f, -2.34407857e-02f, -1.18537813e-01f, -4.17459048e-02f, -7.51924887e-02f,
  -7.23499283e-02f, 7.00198929e-04f, 8.73603597e-02f, 9.44695324e-02f, -6.20908476e-02f, -1.43203393e-01f, 9.08795744e-02f, 6.17583320e-02f, 9.49974433e-02f, 3.97001915e-02f,
  -3.01483949e-03f, -4.63624671e-02f, -1.39789954e-01f, -7.84243047e-02f, 4.94257435e-02f, 1.18434178e-02f, -1.30491704e-01f, -3.96484323e-02f, 3.45272711e-03f, 5.60402088e-02f,
  1.65852346e-02f, -9.02282298e-02f, 8.66326597e-03f, -1.03451602e-01f, -1.09754898e-01f, 7.54404664e-02f, 9.52253491e-03f, -1.57067716e-01f, 1.18471369e-01f, -7.46424496e-02f,
  9.18389261e-02f, -2.05165803e-01f, 1.09942138e-01f, -8.05176646e-02f, 6.88218623e-02f, 1.50907099e-01f, -1.37937456e-01f, 7.30204284e-02f, 1.68303579e-01f, -6.60846336e-03f,
  8.92989039e-02f, 2.32884318e-01f, 1.92703500e-01f, -1.33037597e-01f, -1.10042043e-01f, 7.92345703e-02f, 1.17344968e-01f, 1.19515546e-01f, 1.08632214e-01f, -9.89481807e-02f,
  8.09410140e-02f, -1.57787323e-01f, -1.61424384e-01f, 1.01914376e-01f, -1.53991342e-01f, -6.23721257e-02f, -1.00966081e-01f, 3.96957286e-02f, -6.95310012e-02f, 1.44693078e-02f,
  1.21309325e-01f, -4.31076363e-02f, -1.03245914e-01f, 9.44084153e-02f, 1.13205217e-01f, 7.95845687e-02f, 1.32370755e-01f, 1.79246590e-01f, -6.11410476e-02f, 1.50868669e-01f,
  1.77328259e-01f, -8.74364823e-02f, 1.23173393e-01f, -4.45821583e-02f, 9.20433402e-02f, -1.00418203e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.23769626e-01f, 3.90796140e-02f, -1.84051581e-02f, -6.80314451e-02f, -5.60588837e-02f, 8.78079906e-02f, 6.43152371e-02f, 1.17350638e-01f, 2.05085024e-01f, 1.24449782e-01f,
  -1.27442226e-01f, 4.25627828e-02f, -1.01716429e-01f, 3.39953252e-03f, 1.68266848e-01f, -1.41349910e-02f, -1.39702735e-02f, 3.59365828e-02f, 7.03989044e-02f, 1.08327836e-01f,
  -2.86545325e-03f, -1.21878237e-01f, -7.23506808e-02f, -1.19287066e-01f, 1.31459072e-01f, -4.23283204e-02f, 1.28619686e-01f, 2.17153840e-02f, 7.63645247e-02f, 1.02671422e-01f,
  -1.52009428e-01f, -1.30820796e-01f, -6.39084131e-02f, -5.78765431e-03f, -4.85682711e-02f, -5.77351823e-02f, -5.53283468e-02f, -6.61045685e-03f, 8.51886645e-02f, -1.61111020e-02f,
  -7.48147815e-02f, 1.07971691e-01f, -1.88007243e-02f, -5.17650545e-02f, 4.27815467e-02f, 1.24754779e-01f, 1.84470326e-01f, 6.65554106e-02f, 6.21782616e-02f, 9.10539851e-02f,
  2.97960341e-01f, 1.64930820e-01f, 1.67832986e-01f, 1.43294511e-02f, 1.02224253e-01f, -6.65941164e-02f, -4.28310111e-02f, -6.05004765e-02f, 1.22487560e-01f, -7.23897517e-02f,
  5.63010201e-02f, -6.46184310e-02f, 1.11116599e-02f, -2.02232990e-02f, -5.70292659e-02f, 5.92261460e-03f, -2.29994897e-02f, -1.33999651e-02f, 8.24641213e-02f, -2.36820262e-02f,
  1.82059497e-01f, 2.97191106e-02f, 7.72707909e-02f, -7.40581974e-02f, 7.25297555e-02f, 1.34120002e-01f, 1.04657717e-01f, 1.62312105e-01f, 1.37956724e-01f, 9.44692641e-02f,
  -1.89232361e-02f, -5.76613918e-02f, 1.61631256e-01f, -1.66060589e-02f, -1.13945454e-01f, -7.78811201e-02f, 1.82843655e-01f, -4.97395992e-02f, -4.59179543e-02f, 9.46363509e-02f,
  3.36922742e-02f, -1.58053488e-01f, -4.43484560e-02f, 1.47033244e-01f, -2.68906653e-01f, -3.69290239e-03f, -1.00903936e-01f, -1.87058702e-01f, 1.45733923e-01f, -9.78309289e-02f,
  6.50580898e-02f, -1.00139387e-01f, -1.09052978e-01f, 6.05474822e-02f, 1.33171126e-01f, 9.99280289e-02f, 2.51809619e-02f, -1.66720405e-01f, 8.33540857e-02f, -7.43677989e-02f,
  -1.59443747e-02f, 6.00189604e-02f, -1.69033587e-01f, -1.48586351e-02f, 8.84360150e-02f, 6.31716847e-02f, 1.64711252e-01f, 8.99632946e-02f, -1.51774567e-03f, 1.17888771e-01f,
  -6.10417649e-02f, -1.31413564e-01f, 9.91709530e-02f, 1.27382830e-01f, 1.53790772e-01f, 9.12878439e-02f, -1.05088921e-02f, 7.99968541e-02f, 5.44359051e-02f, 4.50400189e-02f,
  1.34536445e-01f, 9.43411514e-02f, -6.57316819e-02f, -1.02430489e-03f, 5.56947710e-03f, -3.65139507e-02f, -4.21478925e-03f, 6.33417219e-02f, 8.58901814e-02f, 5.39789237e-02f,
  -6.55586720e-02f, 1.29597917e-01f, 1.63139582e-01f, 5.87367043e-02f, 1.52581455e-02f, 1.10415235e-01f, -7.57080689e-02f, 1.02669179e-01f, -7.43294954e-02f, 3.00015621e-02f,
  -1.74884364e-01f, 6.07052371e-02f, 9.66260806e-02f, 2.89367810e-02f, -2.96256840e-02f, -1.10531695e-01f, 6.98135875e-04f, 1.45054892e-01f, -6.92357272e-02f, -3.32172737e-02f,
  -1.04420573e-01f, 1.35673195e-01f, 6.23278394e-02f, -1.00769766e-01f, -2.05744535e-01f, 9.10874456e-02f, 8.12673047e-02f, 4.53294516e-02f, -4.81429882e-02f, -2.53276639e-02f,
  -4.21156473e-02f, -6.78631477e-03f, -1.10038467e-01f, -1.45550976e-02f, 9.20747221e-02f, 7.70864263e-02f, 2.78412569e-02f, -4.07165624e-02f, 2.20135786e-02f, 1.48219153e-01f,
  2.04426095e-01f, 6.78100735e-02f, -9.58839208e-02f, -2.76947208e-02f, -1.28102362e-01f, -7.84966126e-02f, 6.49439096e-02f, -2.06885468e-02f, -5.91427386e-02f, -9.50901806e-02f,
  3.86710130e-02f, 1.07418932e-01f, 1.47801772e-01f, -1.92227587e-03f, -7.96262324e-02f, -6.01321086e-03f, -3.04971747e-02f, 4.29955013e-02f, 5.11030294e-02f, 1.06437974e-01f,
  -7.78008550e-02f, 1.13955634e-02f, -5.09119369e-02f, 2.62018130e-03f, 8.73593539e-02f, 1.67277977e-01f, 2.16455698e-01f, 7.28656203e-02f, 1.43796697e-01f, -4.60175425e-02f,
  9.93019789e-02f, -7.16863722e-02f, -1.65468052e-01f, 1.03245825e-02f, 1.90156490e-01f, -1.11737899e-01f, 5.26867248e-02f, 5.06535023e-02f, 1.62040055e-01f, -4.74805981e-02f,
  3.86410132e-02f, -2.29634587e-02f, -1.85111135e-01f, -9.49374139e-02f, -8.50762352e-02f, -9.83767360e-02f, 7.93110058e-02f, 1.24502040e-01f, -2.06077695e-02f, 1.15807772e-01f,
  -5.45307286e-02f, 1.30113289e-01f, 1.83725134e-02f, -8.47610980e-02f, 1.78620175e-01f, -1.51522914e-02f, -6.95646256e-02f, -9.42214578e-02f, -1.06129490e-01f, 1.18552230e-01f,
  7.63056055e-02f, 1.03155546e-01f, 1.72401350e-02f, -1.12226330e-01f, 1.25734687e-01f, 7.93347955e-02f, -6.11261651e-03f, 1.38871923e-01f, 8.97544995e-02f, 5.70045188e-02f,
  1.05425261e-01f, 9.24155861e-02f, -1.39093604e-02f, 1.84800610e-01f, 1.16510272e-01f, -3.73719148e-02f, -1.17852680e-01f, 9.09065157e-02f, -2.22755242e-02f, -7.66170248e-02f,
  1.42740682e-01f, -5.07250428e-02f, 9.29602832e-02f, -1.10447705e-01f, -5.63060790e-02f, -1.11130767e-01f, 1.17145421e-03f, -5.70333786e-02f, 9.67805237e-02f, -9.93401259e-02f,
  3.53234224e-02f, -1.15805894e-01f, 7.95048475e-02f, 2.07595620e-02f, 7.89627135e-02f, -4.66958359e-02f, 2.59785056e-02f, -4.72056381e-02f, 3.52224968e-02f, -1.70050465e-04f,
  -2.35049445e-02f, -5.03481738e-02f, 4.62999605e-02f, -9.47115049e-02f, -3.74145582e-02f, -4.08315808e-02f, -7.61497067e-03f, 8.37447308e-03f, -5.57977557e-02f, 6.89125285e-02f,
  3.54283373e-03f, -6.58517778e-02f, -8.22247639e-02f, 3.54267173e-02f, 9.79604051e-02f, 9.53227207e-02f, 1.76353883e-02f, 3.21801454e-02f, 8.33745021e-03f, -1.04420461e-01f,
  -9.07582119e-02f, 5.02157956e-02f, 1.78918187e-02f, -6.77734986e-02f, 9.34585705e-02f, 6.86065778e-02f, 1.85315639e-01f, -1.47547685e-02f, 1.69468075e-02f, -9.24624130e-02f,
  1.39907543e-02f, 1.13867268e-01f, 3.14099491e-02f, -7.03763291e-02f, -9.42169428e-02f, -7.63635784e-02f, 4.44362015e-02f, -1.18381456e-02f, -1.90461073e-02f, 4.76952679e-02f,
  1.96965300e-02f, 3.81810889e-02f, -1.37746289e-01f, -4.78636958e-02f, 5.14161065e-02f, -1.24125801e-01f, 1.05770342e-02f, -7.84947798e-02f, -2.44152039e-01f, -2.16505006e-01f,
  2.37356145e-02f, -6.43568709e-02f, -1.31790610e-02f, -2.48394497e-02f, 8.65125582e-02f, -1.27031609e-01f, 4.88864928e-02f, 1.15304641e-01f, 7.64643028e-02f, -2.45703384e-02f,
  1.09612256e-01f, 1.56968758e-01f, 1.40151769e-01f, 1.43510923e-01f, -2.99037784e-01f, 1.99088708e-01f, 1.53154284e-01f, 2.75655299e-01f, 1.06526509e-01f, -1.54300138e-01f,
  -5.63162751e-03f, -3.08465213e-02f, -1.99437328e-02f, 1.20524853e-01f, -1.55994520e-01f, 2.08207726e-01f, 1.03702553e-01f, 4.50928546e-02f, -4.36514542e-02f, 9.55443159e-02f,
  5.45127392e-02f, 1.84332635e-02f, -1.70976855e-02f, 1.79323032e-01f, -1.12523131e-01f, -5.72383255e-02f, -1.41205741e-02f, 1.09974273e-01f, 1.72932550e-01f, 1.11636892e-01f,
  -7.63881430e-02f, 1.07941795e-02f, 5.99913858e-02f, 1.62519459e-02f, -5.64286634e-02f, -8.68332833e-02f, -4.92471643e-02f, 8.02083835e-02f, -1.29754484e-01f, 1.85058981e-01f,
  3.40316854e-02f, 3.23077589e-02f, -2.59065032e-02f, -1.63371637e-02f, -1.72139611e-02f, 6.91119134e-02f, -4.45894301e-02f, 7.35041350e-02f, -2.81593408e-02f, -2.80236620e-02f,
  1.16519490e-02f, 1.25924453e-01f, 8.01025257e-02f, -8.41123760e-02f, 7.63134956e-02f, 1.72737926e-01f, -1.13209672e-02f, 1.02959141e-01f, 1.20715708e-01f, -5.16193509e-02f,
  5.25620244e-02f, 3.66062522e-02f, 4.54512499e-02f, 1.15083493e-01f, -3.35888937e-02f, 2.18564160e-02f, 1.36249751e-01f, -6.67858496e-03f, 1.04904741e-01f, -1.15364723e-01f,
  9.44064185e-03f, -7.57677704e-02f, -1.00249454e-01f, -1.09022506e-01f, -2.82117333e-02f, 1.19521499e-01f, -1.22303993e-01f, 8.61937366e-03f, -8.41135979e-02f, 9.62225199e-02f,
  6.33147806e-02f, 1.67067405e-02f, 1.06516488e-01f, 1.29014865e-01f, -4.26254943e-02f, -2.88933385e-02f, 5.88811859e-02f, -1.12842306e-01f, 3.89822945e-02f, 7.40172416e-02f,
  -3.74002382e-02f, -5.49413338e-02f, 1.03079110e-01f, 1.29652917e-01f, 1.02563828e-01f, 1.08979881e-01f, 1.56519830e-01f, 4.43549380e-02f, 1.15426116e-01f, 7.23999217e-02f,
  -5.94173186e-02f, -6.60903454e-02f, 1.44357279e-01f, 8.93987492e-02f, 2.52115205e-02f, -1.00676887e-01f, -6.45068288e-02f, -7.37946406e-02f, -8.18064734e-02f, 1.66428745e-01f,
  -2.80714054e-02f, 1.03413895e-01f, 8.25026557e-02f, 5.98942535e-03f, -2.49588415e-02f, 1.32550225e-01f, 1.70968585e-02f, -2.08036527e-02f, 2.10622177e-01f, 1.63137555e-01f,
  1.85444549e-01f, 6.15701862e-02f, 7.21497312e-02f, 1.00465275e-01f, -2.46404670e-02f, -2.08652280e-02f, 2.65428219e-02f, -8.73623341e-02f, 7.15973899e-02f, -7.98182040e-02f,
  7.51084136e-03f, 3.54941748e-02f, -1.16537176e-02f, -1.77836806e-01f, -2.04000935e-01f, -1.68499313e-02f, -7.80234709e-02f, 1.14327550e-01f, 1.35096073e-01f, 1.44517273e-01f,
  -6.38418198e-02f, 1.27232820e-01f, 1.04064144e-01f, 1.17281869e-01f, 1.76583081e-01f, -5.05353883e-02f, 1.15909465e-01f, -1.10672995e-01f, 3.06761283e-02f, 1.30141065e-01f,
  -7.64023094e-03f, 9.42816958e-02f, -7.11687058e-02f, -1.18510149e-01f, -2.45499015e-02f, 6.51109144e-02f, 8.02750811e-02f, -2.35933699e-02f, -7.06376359e-02f, 1.01188123e-02f,
  -1.68788597e-01f, -4.22932841e-02f, -1.23060429e-02f, -4.12598737e-02f, 1.33651048e-01f, 1.05587281e-01f, 7.55051598e-02f, 1.03265092e-01f, -2.61687096e-02f, 9.36243683e-03f,
  -2.17705723e-02f, 9.28316936e-02f, 1.12363786e-01f, -1.84598714e-02f, 1.00326419e-01f, -9.74648595e-02f, 2.97635738e-02f, 3.03934842e-01f, 1.92553237e-01f, 1.84140027e-01f,
  2.40641698e-01f, 2.09542394e-01f, 1.83643892e-01f, 1.30598024e-01f, 4.62019742e-02f, 4.29411158e-02f, 1.71250142e-02f, 2.66299061e-02f, 1.06533952e-01f, -9.58201736e-02f,
  -7.80892186e-03f, 1.23415947e-01f, 7.55203441e-02f, -6.27484843e-02f, -7.36778900e-02f, -1.57303005e-01f, 1.20213613e-01f, -1.15580365e-01f, -4.32882793e-02f, -5.78633212e-02f,
  4.81429808e-02f, -2.50826310e-02f, 5.44743501e-02f, -9.07163173e-02f, -5.62932976e-02f, 1.10636376e-01f, 1.23413421e-01f, -2.24184051e-01f, -1.94745868e-01f, 4.49072644e-02f,
  2.00979397e-01f, 3.41044068e-02f, 1.07576363e-01f, 9.04539749e-02f, -1.17805608e-01f, -1.22781485e-01f, -1.00328531e-02f, 1.03433341e-01f, 2.09525302e-01f, -6.50605559e-02f,
  -2.94439886e-02f, -7.66882896e-02f, 3.42480332e-01f, 1.10487886e-01f, -1.91106766e-01f, -3.37011442e-02f, 7.12760612e-02f, -1.85661644e-01f, 6.77339584e-02f, -5.58299199e-02f,
  6.73503522e-03f, -1.56684518e-02f, 1.03681237e-01f, -9.37407389e-02f, 9.31424499e-02f, 1.36965171e-01f, 1.26367614e-01f, 1.42022863e-01f, 3.01086865e-02f, 1.41285583e-01f,
  8.28124061e-02f, 2.13473886e-02f, -2.15648040e-02f, 1.34239733e-01f, -1.28267501e-02f, 8.36314633e-02f, 1.22374542e-01f, -2.89405771e-02f, 1.51500955e-01f, 2.54016444e-02f,
  -1.11959346e-01f, 1.25445336e-01f, 3.40440758e-02f, 1.43648401e-01f, 1.69508189e-01f, 1.23969950e-01f, -2.75393855e-02f, 5.84232658e-02f, 1.63278252e-01f, -1.04202703e-01f,
  1.16378672e-01f, -1.65450340e-03f, 1.86697859e-02f, 1.34427607e-01f, 8.82769898e-02f, -1.97892562e-01f, -2.99314465e-02f, 1.55429989e-01f, 1.13151722e-01f, -1.59457654e-01f,
  -5.44016883e-02f, -4.35798801e-02f, -4.18357924e-02f, -1.05648145e-01f, -9.27803963e-02f, 9.06279758e-02f, -8.22740607e-03f, -4.28632386e-02f, 1.32658139e-01f, 1.35659441e-01f,
  6.49052337e-02f, -3.35729234e-02f, -1.19982421e-01f, -2.03829166e-02f, -7.23702461e-02f, 2.96911262e-02f, -2.01060250e-02f, -4.00490910e-02f, -1.18566580e-01f, -7.72305131e-02f,
  -1.13560535e-01f, -1.10448986e-01f, 1.37192443e-01f, -9.27455425e-02f, 1.02936693e-01f, 5.68407141e-02f, -1.26806768e-02f, 5.59651889e-02f, -7.58973360e-02f, -2.90404800e-02f,
  -2.95305662e-02f, 6.69121742e-02f, -3.29002850e-02f, 9.16906968e-02f, 1.18053876e-01f, -1.17517002e-01f, -1.17135175e-01f, 6.10352047e-02f, -8.29615444e-02f, -5.24717644e-02f,
  -1.18236624e-01f, -3.18793282e-02f, 6.66378513e-02f, 1.09268881e-01f, 1.26116455e-01f, -2.82031298e-02f, 6.21815957e-02f, 2.89426930e-02f, -3.69806401e-02f, -2.18375437e-02f,
  8.23912248e-02f, 4.33888519e-03f, -4.32307459e-02f, -6.94295466e-02f, -2.43079346e-02f, -1.27658260e-03f, -8.65895003e-02f, 7.93361068e-02f, 7.13180378e-02f, 1.14852488e-01f,
  1.11890882e-01f, -4.68116067e-02f, 4.17654812e-02f, -6.52016746e-03f, -3.21490094e-02f, 5.66112436e-02f, -6.78638369e-02f, -1.08954825e-01f, -3.55758108e-02f, 1.34989142e-01f,
  -5.24041727e-02f, 9.87812579e-02f, -7.85258710e-02f, -2.75065023e-02f, -1.23172909e-01f, -8.65629762e-02f, 1.71502260e-03f, -9.74794268e-04f, -5.67247793e-02f, -9.83222201e-02f,
  -8.22872669e-02f, -1.02605037e-01f, 1.01816475e-01f, -5.84176145e-02f, 9.26951244e-02f, -6.10564724e-02f, -1.02960408e-01f, -9.71498638e-02f, -7.22841918e-02f, -7.00391317e-03f,
  -1.20084584e-02f, 1.82969123e-02f, 7.32737929e-02f, 8.45692754e-02f, 5.20511717e-03f, 1.16630234e-01f, 1.66779354e-01f, 9.59412456e-02f, 4.67262752e-02f, 2.52865940e-01f,
  2.44237944e-01f, 5.37132099e-02f, 1.88621700e-01f, 1.34747609e-01f, 4.11965512e-02f, 1.03890963e-01f, -3.35339345e-02f, 6.48810863e-02f, -2.98586860e-02f, 1.09730855e-01f,
  -3.51032056e-02f, 4.87037152e-02f, 6.12190999e-02f, 1.91417888e-01f, -1.44712806e-01f, -6.15255348e-02f, -1.55959532e-01f, -1.87361121e-01f, 1.68876529e-01f, 1.27403408e-01f,
  7.20415041e-02f, -1.35437489e-01f, -6.01564571e-02f, -9.23596099e-02f, 2.50280164e-02f, -1.19990222e-01f, 1.19829848e-01f, -7.71123469e-02f, 2.98108961e-02f, -9.13816690e-02f,
  -1.31719664e-01f, -1.47457689e-01f, -1.17127066e-02f, 1.41821802e-01f, 2.65466161e-02f, 9.03084651e-02f, 2.46263910e-02f, -8.46577715e-03f, 1.18173510e-01f, 1.06336296e-01f,
  1.53099045e-01f, -8.54467899e-02f, 5.70124649e-02f, -8.93264264e-02f, 2.47271731e-01f, -6.12667128e-02f, -9.68334228e-02f, 8.02387744e-02f, -1.04665704e-01f, -1.39326481e-02f,
  -9.99789014e-02f, 7.29737943e-03f, -9.91244465e-02f, 3.66964415e-02f, 1.39449015e-01f, 3.25695015e-02f, 5.57008833e-02f, 4.92972182e-03f, 5.87104680e-03f, 1.35387018e-01f,
  -7.52234459e-03f, 5.17807528e-02f, 1.45703137e-01f, 7.26510510e-02f, 1.51321039e-01f, -6.29105866e-02f, -7.95930102e-02f, 3.86108384e-02f, 7.95220807e-02f, 8.73452350e-02f,
  -2.01691245e-03f, 6.57962710e-02f, 1.13167875e-02f, 2.74145219e-04f, -1.19601637e-02f, 1.43155840e-03f, 1.88992254e-03f, 8.60675797e-02f, 1.18793920e-01f, -5.07797897e-02f,
  1.09423235e-01f, 1.08861431e-01f, -1.14806466e-01f, -1.13475852e-01f, -8.50357637e-02f, -3.38770892e-03f, -7.52199292e-02f, -6.75646961e-02f, 1.02188975e-01f, -6.01998940e-02f,
  -6.47609159e-02f, 1.04376540e-01f, -2.88749114e-02f, 5.47529804e-03f, -6.16078638e-02f, 5.55893742e-02f, -5.97737581e-02f, -5.63370921e-02f, 1.08750239e-01f, 9.73007381e-02f,
  -8.97292793e-02f, 5.30537292e-02f, -1.20960511e-01f, -7.44718164e-02f, 1.19965255e-01f, 3.94241549e-02f, 7.89282992e-02f, 2.28850543e-02f, -4.29922864e-02f, -2.98384912e-02f,
  2.90791821e-02f, -2.15684045e-02f, -5.09149656e-02f, -8.53200555e-02f, 4.56364229e-02f, -8.19055960e-02f, -6.14357367e-02f, -9.10782604e-04f, -3.01721059e-02f, 4.25508665e-03f,
  1.04049772e-01f, 4.65397872e-02f, -5.06304987e-02f, 8.09477493e-02f, -9.40219313e-02f, 9.18461308e-02f, -1.48577895e-03f, -1.71457212e-02f, 1.11323707e-01f, 1.75661907e-01f,
  4.45825905e-02f, -5.55986017e-02f, -1.59665778e-01f, -7.72522949e-03f, -7.36928582e-02f, 1.65243875e-02f, 1.34969622e-01f, 7.25541338e-02f, -4.56240121e-03f, 1.57691568e-01f,
  1.79388419e-01f, 9.59232636e-03f, -1.07756615e-01f, 6.88642412e-02f, 1.66239470e-01f, 8.84114504e-02f, 7.11102709e-02f, 1.32940993e-01f, 1.87924847e-01f, 1.83204599e-02f,
  4.63549122e-02f, -2.14901902e-02f, -2.52665550e-01f, -1.08704448e-01f, 1.13614194e-01f, -1.83112934e-01f, -1.04408853e-01f, 1.30877852e-01f, -3.13107856e-02f, -4.74565290e-02f,
  5.84536057e-04f, 2.11635277e-01f, -5.67757450e-02f, 4.39586565e-02f, 1.26876026e-01f, 8.59447345e-02f, -1.21834464e-01f, -5.09970784e-02f, -8.20889547e-02f, 1.21241763e-01f,
  -7.12949336e-02f, 1.14838988e-01f, -6.91883639e-02f, 4.41234596e-02f, 1.14291757e-01f, 1.47163063e-01f, 2.98422445e-02f, -4.10257131e-02f, 7.23416507e-02f, 8.14736709e-02f,
  1.51608720e-01f, 1.81299999e-01f, 8.77050683e-02f, 5.90748060e-03f, -3.72240171e-02f, -7.63530657e-02f, -5.43285012e-02f, 4.88274172e-02f, 1.12959459e-01f, 2.32256681e-01f,
  5.41157685e-02f, -1.03300311e-01f, -4.91557345e-02f, 1.02511629e-01f, -3.70785818e-02f, -1.07633501e-01f, -2.22425926e-02f, 1.40932947e-01f, 2.11876839e-01f, 3.25953215e-02f,
  1.43982649e-01f, -2.64012627e-02f, 7.80662373e-02f, 5.67039736e-02f, 2.21046612e-01f, -2.14229599e-01f, 6.18400946e-02f, -2.16727126e-02f, 1.31804407e-01f, 1.64224476e-01f,
  1.65639799e-02f, -1.23998806e-01f, 8.75892416e-02f, 4.76325676e-02f, 2.76532918e-02f, 8.24625939e-02f, 1.04858026e-01f, 9.84492376e-02f, 4.86126095e-02f, -1.58057138e-02f,
  -8.60967189e-02f, 1.07785076e-01f, 6.97635561e-02f, 5.70816398e-02f, 5.39907627e-02f, 8.61394498e-03f, -3.69349755e-02f, -7.96364546e-02f, 2.09021606e-02f, 1.27617061e-01f,
  1.09918572e-01f, 3.33794244e-02f, 6.81695668e-03f, -7.68516585e-02f, 8.96536559e-02f, 5.95086366e-02f, -1.55296117e-01f, 1.60062462e-02f, 4.34353352e-02f, 7.19290227e-02f,
  3.95184942e-02f, 1.04761846e-01f, 7.75572844e-03f, 9.54646245e-02f, 6.18363312e-03f, 6.54045343e-02f, -4.41697277e-02f, 4.96673323e-02f, -2.23046681e-03f, 8.40911269e-02f,
  9.52637196e-02f, 1.27130121e-01f, 4.25150730e-02f, 1.50942728e-01f, 6.69422885e-03f, 4.43872400e-02f, 9.43329856e-02f, 7.10488781e-02f, 6.48792163e-02f, 3.04717161e-02f,
  5.44152185e-02f, 1.60364300e-01f, 1.78654701e-01f, 1.01569872e-02f, -4.43346873e-02f, -1.49280736e-02f, -2.18143733e-03f, 3.57583500e-02f, -7.37085659e-03f, 1.43598154e-01f,
  1.85535867e-02f, -1.51786953e-01f, 1.59093767e-01f, -8.36471841e-02f, 1.67798460e-01f, -8.03727061e-02f, 7.10794295e-04f, 3.43798622e-02f, -3.28894444e-02f, -5.72617650e-02f,
  -1.27092183e-01f, -3.61509398e-02f, -2.25282349e-02f, -2.76883721e-01f, -5.53877130e-02f, -1.38603911e-01f, 3.66025046e-02f, -1.54040664e-01f, -8.31747651e-02f, 8.45844597e-02f,
  7.96655193e-03f, 3.15571204e-02f, 1.48579910e-01f, 7.78853595e-02f, 9.09128711e-02f, 5.24725057e-02f, -3.19859274e-02f, 1.56214878e-01f, 4.94618192e-02f, -1.89575683e-02f,
  -1.35542899e-01f, -1.62791356e-01f, 2.71571223e-02f, -8.65584612e-03f, 1.18432321e-01f, -8.61199573e-02f, -5.29808737e-02f, -4.08144780e-02f, 1.32391706e-01f, 9.58823040e-02f,
  -7.06315860e-02f, 1.55105993e-01f, 4.04376127e-02f, -5.95292486e-02f, -3.95771004e-02f, -1.15124602e-02f, 1.87950313e-01f, 2.27592111e-01f, 4.97603714e-02f, 3.10290754e-02f,
  7.81157687e-02f, -8.91110376e-02f, -2.31838673e-01f, 3.69661115e-02f, 1.15281500e-01f, 9.55636576e-02f, 2.66921461e-01f, 5.78022040e-02f, 2.19385013e-01f, 1.11531280e-02f,
  -6.90750033e-03f, 8.12964067e-02f, 1.37884632e-01f, -3.33316833e-01f, 5.37623987e-02f, 1.65858362e-02f, 2.17038155e-01f, 2.54497170e-01f, -1.91771865e-01f, 2.79575828e-02f,
  -1.27665818e-01f, 1.46883413e-01f, -1.10269599e-01f, -1.44043490e-01f, -1.26996025e-01f, 1.73355877e-01f, -5.87954372e-02f, 2.59878874e-01f, 3.27004269e-02f, 1.41600206e-01f,
  7.44126961e-02f, 2.61810303e-01f, 3.85469049e-02f, 1.32883653e-01f, 4.24545109e-02f, 1.14750780e-01f, 1.61634833e-01f, 1.67726278e-01f, -1.21312579e-02f, 1.27138838e-01f,
  -1.04404591e-01f, 2.81938817e-02f, 1.31973863e-01f, 4.64251675e-02f, -1.26915663e-01f, 1.84477553e-01f, 3.06147784e-02f, -6.22917563e-02f, 7.84397796e-02f, -1.53805315e-02f,
  6.49710223e-02f, 1.90872386e-01f, 6.76034242e-02f, 1.06051020e-01f, -9.39675942e-02f, 1.51094213e-01f, 9.46871191e-02f, -1.24174304e-01f, 1.85992643e-02f, -4.84148450e-02f,
  -3.41468342e-02f, 1.06684975e-01f, 9.15985741e-03f, -8.25880840e-02f, -5.06462865e-02f, 7.40733668e-02f, 9.52345431e-02f, -9.72267315e-02f, 8.14469159e-02f, 1.23901755e-01f,
  7.57494867e-02f, 5.69099225e-02f, 1.41267732e-01f, 6.21692762e-02f, -1.49859995e-01f, 1.02181397e-01f, 1.85375035e-01f, 5.12288660e-02f, 4.29339036e-02f, 1.19153306e-01f,
  1.45782188e-01f, 4.99369726e-02f, -1.37125432e-01f, -9.43912119e-02f, 1.41519457e-01f, 2.08892941e-01f, -7.10601732e-02f, -1.60653204e-01f, 7.27574527e-02f, 1.24934562e-01f,
  7.60087147e-02f, -1.35149598e-01f, -8.61486346e-02f, 8.49673972e-02f, 1.98842604e-02f, -9.05845501e-03f, -1.27495989e-01f, 1.86984181e-01f, 5.98898306e-02f, 1.36176241e-03f,
  1.40362129e-01f, -8.50359127e-02f, 9.75401774e-02f, 1.41155213e-01f, -1.14548624e-01f, 1.16025038e-01f, 8.31017271e-02f, -9.04378593e-02f, 2.74605565e-02f, -1.05818950e-01f,
  -6.90831989e-03f, -6.58080876e-02f, 1.23873904e-01f, -2.84670410e-03f, -1.00123389e-02f, 1.11730576e-01f, 1.22293964e-01f, 1.30678833e-01f, -9.65188071e-03f, 8.04200619e-02f,
  1.20514676e-01f, 1.56661228e-03f, 1.84265032e-01f, 5.55327050e-02f, 2.88771000e-02f, 2.22699880e-03f, 1.65004507e-01f, -8.98191705e-03f, 1.17536761e-01f, -9.23376456e-02f,
  7.13914856e-02f, 9.04117376e-02f, -1.55514359e-01f, 2.80888900e-02f, -1.21428654e-01f, 1.83336839e-01f, 2.73700297e-01f, -2.36534085e-02f, 1.10120006e-01f, 7.52988532e-02f,
  3.09903622e-02f, 2.72047427e-02f, 7.12326020e-02f, 5.66445105e-02f, 3.01639605e-02f, -1.13989435e-01f, -1.21404685e-01f, -1.31542489e-01f, 1.54956415e-01f, -1.60720363e-01f,
  -1.01914041e-01f, 1.02658488e-01f, -2.03910517e-04f, -2.39945054e-01f, -1.32714018e-01f, 1.29487291e-01f, 1.39601588e-01f, -7.30789751e-02f, -9.66321081e-02f, 1.35079220e-01f,
  1.27748147e-01f, -1.24190845e-01f, -1.55312479e-01f, -1.08069507e-02f, -1.18948370e-01f, -1.02761917e-01f, -1.48164392e-01f, -1.20013833e-01f, 7.35881925e-02f, 7.00382702e-03f,
  -9.40898880e-02f, 8.04269612e-02f, -3.90066281e-02f, 2.06653818e-01f, 2.80984789e-01f, 1.39212430e-01f, 1.22337282e-01f, 2.34561607e-01f, -4.63291705e-02f, 1.43879667e-01f,
  2.09146246e-01f, -8.20750445e-02f, -7.67168030e-02f, 1.70775317e-02f, -3.07651144e-02f, 1.16435945e-01f, -4.95919632e-03f, 2.40746383e-02f, 7.63057172e-02f, 2.92424504e-02f,
  9.87703875e-02f, -7.78217018e-02f, 8.29479992e-02f, 1.37225494e-01f, 5.72898192e-03f, -7.14879707e-02f, -5.21071590e-02f, 8.30956325e-02f, -8.01433176e-02f, 5.41336760e-02f,
  9.42630544e-02f, -4.31107134e-02f, 1.07658617e-01f, -7.31711090e-02f, 2.92896591e-02f, 3.29651348e-02f, -2.71058176e-02f, 5.38384318e-02f, 1.22355809e-02f, -8.47655907e-02f,
  -7.64624849e-02f, -1.50286620e-02f, -1.10518239e-01f, 3.33451554e-02f, -4.04475778e-02f, 8.69543776e-02f, 6.31859675e-02f, 3.81543264e-02f, 3.71937454e-02f, 8.89218971e-02f,
  -4.97025959e-02f, -3.83564993e-03f, -7.28383660e-02f, 1.38606355e-01f, 1.37449220e-01f, -6.62588030e-02f, 2.47731749e-02f, 1.16034754e-01f, 3.30085456e-02f, 3.92128676e-02f,
  -8.26781243e-02f, 1.19238287e-01f, 1.10568836e-01f, -5.97779118e-02f, -1.08813673e-01f, 1.55915059e-02f, 3.93962637e-02f, -4.43703942e-02f, -3.14864963e-02f, -9.77862775e-02f,
  7.87844658e-02f, -1.13908380e-01f, -9.67407078e-02f, -7.66999647e-02f, -9.00410116e-02f, 9.43699107e-02f, 1.27340248e-02f, -3.94302309e-02f, -8.99201781e-02f, -3.27044763e-02f,
  1.49594575e-01f, 1.67121619e-01f, 7.34856427e-02f, 5.26954569e-02f, -7.07654376e-03f, 2.07448602e-01f, 4.09141444e-02f, 1.46532536e-01f, 9.53580290e-02f, -3.97029659e-03f,
  2.46702969e-01f, -6.96559623e-02f, 1.19955465e-01f, 6.04018569e-02f, -8.31562057e-02f, 1.05978280e-01f, 7.31460378e-02f, 5.04767187e-02f, 5.15672043e-02f, 7.28679076e-02f,
  1.48904860e-01f, -9.05214995e-03f, -1.25754505e-01f, 1.12311527e-01f, 1.09675871e-02f, -6.57312274e-02f, -2.19730809e-01f, -5.90779353e-03f, -2.29488988e-03f, 3.51970047e-02f,
  6.32035658e-02f, -1.35438532e-01f, -2.87890192e-02f, 2.50396639e-01f, 8.44068453e-02f, -2.39242166e-02f, -1.36240944e-01f, -3.66029306e-03f, 7.27797002e-02f, -9.90319625e-02f,
  5.54957278e-02f, -1.97714288e-02f, -1.00747280e-01f, -2.60321163e-02f, 8.51447955e-02f, 1.26009554e-01f, 1.87625960e-02f, -1.10547118e-01f, 1.15961716e-01f, 3.82495932e-02f,
  1.20701514e-01f, 7.19315559e-02f, -8.11285749e-02f, -7.57032633e-02f, -1.01477087e-01f, 5.00751846e-02f, -4.93156761e-02f, 7.77891129e-02f, -1.00967258e-01f, -8.25049132e-02f,
  3.01173124e-02f, 1.09790549e-01f, -4.71274182e-03f, 1.35306999e-01f, 6.36570305e-02f, 3.28217484e-02f, -2.60287430e-02f, -4.24076691e-02f, -1.13551216e-02f, 5.12728505e-02f,
  -9.58156288e-02f, 5.73840998e-02f, 1.06039651e-01f, 1.24674149e-01f, 3.36544402e-02f, 1.00672707e-01f, 1.99288409e-03f, 6.33228198e-02f, -1.25241429e-01f, 1.75650753e-02f,
  -3.12621407e-02f, -5.51856272e-02f, -2.46274984e-04f, 3.99934016e-02f, -1.21666947e-02f, -9.47973430e-02f, -1.16327927e-01f, 8.12104270e-02f, 8.50460380e-02f, 6.24197051e-02f,
  -1.32847205e-02f, -3.21274847e-02f, 6.59165084e-02f, -2.99183652e-03f, 6.39100373e-02f, -2.77853496e-02f, 8.47051889e-02f, 1.54464379e-01f, 2.30395049e-02f, 5.08612432e-02f,
  9.80003327e-02f, 6.37025386e-02f, 1.11016795e-01f, 5.73443342e-03f, -7.04394281e-02f, 1.05897896e-01f, 1.20764673e-01f, 8.06984454e-02f, 5.58084750e-04f, -2.53064074e-02f,
  -3.51134762e-02f, -3.31143327e-02f, -2.78379079e-02f, -1.08865589e-01f, -2.78507732e-02f, -7.55488053e-02f, 6.95848614e-02f, -7.84182996e-02f, -6.82812631e-02f, -7.75931701e-02f,
  1.12722069e-02f, 7.09668249e-02f, -1.10446461e-01f, 1.49840135e-02f, -2.51321727e-03f, 5.56639358e-02f, -8.79299194e-02f, -1.41632725e-02f, -1.06507435e-01f, 4.95315436e-03f,
  -2.52946522e-02f, 8.12873021e-02f, 8.12599882e-02f, 6.24014772e-02f, 6.26782933e-03f, 4.18695323e-02f, 2.99840085e-02f, -8.47094879e-02f, 3.31634954e-02f, 2.56403685e-02f,
  1.83190078e-01f, -2.35622171e-02f, -5.58428615e-02f, 1.41799152e-01f, 1.31782249e-01f, 8.35690722e-02f, 2.15030909e-01f, -1.69561476e-01f, 1.21322282e-01f, -5.84691167e-02f,
  8.35098028e-02f, 8.81582722e-02f, -1.05422102e-01f, 1.07863158e-01f, -1.85041316e-02f, 1.12797223e-01f, -6.46058619e-02f, -4.71177883e-02f, 3.58571857e-02f, 1.34406343e-01f,
  -5.23411371e-02f, 5.93834780e-02f, -1.19459793e-01f, 1.61893308e-01f, 1.52296454e-01f, 8.20892826e-02f, 2.18246039e-02f, -1.18463196e-01f, 5.39207160e-02f, 9.07364935e-02f,
  -9.76794437e-02f, 1.91253886e-01f, -7.96653703e-02f, 9.73539799e-02f, -1.17927812e-01f, -8.36419687e-02f, 1.34602949e-01f, 1.85992420e-01f, 3.93783525e-02f, 2.44369302e-02f,
  -5.75943217e-02f, -6.35752827e-02f, 1.52128972e-02f, -6.50357231e-02f, 9.62180272e-02f, -2.63115279e-02f, 6.77827150e-02f, -7.94887319e-02f, -4.79770415e-02f, -4.94725890e-02f,
  6.75246790e-02f, -9.55027193e-02f, 2.02675443e-02f, -4.58330438e-02f, 1.22812083e-02f, 1.37701213e-01f, 4.35516350e-02f, -1.34136400e-03f, 1.17172964e-01f, 1.11187615e-01f,
  -7.36488681e-03f, -8.87518078e-02f, -2.07077013e-03f, 1.08777836e-01f, -5.69803044e-02f, -4.32183892e-02f, -2.16179804e-04f, -5.81148313e-04f, 1.40812561e-01f, -3.19346972e-02f,
  2.69488804e-02f, 1.02676816e-01f, 1.94469783e-02f, 2.00574510e-02f, 8.66532102e-02f, 9.08186957e-02f, -5.09575717e-02f, -5.44076711e-02f, 4.06683758e-02f, 5.68104349e-02f,
  4.56107706e-02f, 1.43576153e-02f, -1.15848780e-01f, -3.19071710e-02f, -1.15917340e-01f, -9.48120281e-02f, 8.82591400e-03f, 1.22450069e-01f, -8.98481235e-02f, -1.48483152e-02f,
  -8.49652439e-02f, 1.08009547e-01f, -1.02234341e-01f, -4.97265020e-03f, 1.15115054e-01f, -1.16158508e-01f, 1.16340872e-02f, -6.23382740e-02f, 1.13833718e-01f, 9.38932449e-02f,
  -7.97322839e-02f, 2.12896168e-02f, -2.55115461e-02f, 1.13436624e-01f, 1.54940635e-01f, 8.35217312e-02f, -4.26214561e-02f, 1.36290584e-02f, -8.54341984e-02f, 3.58282030e-02f,
  5.95195591e-03f, 1.39300069e-02f, -4.75942716e-02f, 1.48907706e-01f, -7.66565949e-02f, 8.72619823e-02f, 8.49285051e-02f, 5.03579602e-02f, -7.84620494e-02f, 7.85316378e-02f,
  -1.05439343e-01f, 6.91391975e-02f, 5.96753247e-02f, -2.53687729e-04f, -5.34452982e-02f, -7.73665830e-02f, 8.01961496e-02f, -9.98549089e-02f, -4.36644554e-02f, 9.35277045e-02f,
  5.91197684e-02f, -5.18675894e-02f, -4.28168662e-02f, 1.52956126e-02f, -2.19419971e-02f, -6.84228688e-02f, 9.35244188e-02f, 1.10601187e-01f, 1.09495044e-01f, -8.09050575e-02f,
  2.75277160e-02f, -3.01814731e-02f, 2.20348053e-02f, 1.05796307e-02f, 5.45027703e-02f, -4.98833805e-02f, 6.68630525e-02f, -1.84900295e-02f, -9.41611007e-02f, -5.44329267e-03f,
  -4.83112223e-02f, -1.10356405e-01f, -4.70694005e-02f, 1.12632632e-01f, 2.20475718e-02f, -1.18131779e-01f, 7.07700402e-02f, -5.82988262e-02f, -5.03318533e-02f, 7.48859346e-02f,
  -1.02694221e-01f, -1.93871185e-02f, 4.59126681e-02f, 1.19454272e-01f, 7.49483034e-02f, -6.86234832e-02f, -5.52281551e-02f, -1.15342639e-01f, -1.03977047e-01f, -3.64643671e-02f,
  5.88567294e-02f, 9.84656811e-02f, -2.50821020e-02f, 2.87318323e-02f, 4.99680787e-02f, 4.16850066e-03f, -4.86430041e-02f, -1.13817029e-01f, -9.64189693e-02f, -1.06183231e-01f,
  3.75727788e-02f, -1.99284367e-02f, 1.08433753e-01f, 3.20061762e-03f, 1.06950685e-01f, 1.55968852e-02f, -5.90364784e-02f, 1.98402181e-01f, 1.87535748e-01f, 4.39335443e-02f,
  5.34586888e-03f, -1.64927784e-02f, 1.86214596e-01f, 4.62316871e-02f, 8.45575426e-03f, -1.75665431e-02f, 3.97909917e-02f, 1.08013675e-02f, 1.68457985e-01f, 1.77503243e-01f,
  3.75085734e-02f, -1.52218401e-01f, 2.54577063e-02f, -1.23797990e-01f, 7.10358173e-02f, 2.25721430e-02f, 6.99233115e-02f, 1.45579502e-01f, -2.45961510e-02f, -1.03823394e-01f,
  -6.95903599e-02f, -2.27556434e-02f, 5.78388236e-02f, -1.82109684e-01f, 4.20921715e-03f, -8.19008276e-02f, 1.38096824e-01f, -9.78861749e-02f, -8.90668929e-02f, 6.14361092e-02f,
  2.23737508e-02f, 1.22730777e-01f, -6.23119399e-02f, 3.43544595e-02f, 2.18248278e-01f, 1.56467855e-01f, -5.59457354e-02f, 4.11136113e-02f, -9.65979546e-02f, -4.60953042e-02f,
  -8.30057934e-02f, -1.15947746e-01f, -1.53704554e-01f, -1.04111714e-05f, -3.25355045e-02f, -7.42506832e-02f, 1.52303070e-01f, 7.40230642e-03f, 3.01403105e-02f, -4.66098748e-02f,
  -5.42318486e-02f, 8.12694803e-02f, -3.60080693e-03f, -1.10295657e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  5.26115438e-03f, 1.78962320e-01f, -8.36464018e-03f, -2.23254617e-02f, -3.57998870e-02f, -2.66484413e-02f, 8.06083605e-02f, 1.45085573e-01f, 9.56487935e-03f, -6.58681393e-02f,
  1.08452197e-02f, 2.11991314e-02f, 6.18448853e-02f, 1.46361575e-01f, 7.67022073e-02f, 1.54234216e-01f, 2.23614603e-01f, 7.95299485e-02f, 4.77269813e-02f, -4.27508093e-02f,
  7.37058297e-02f, -6.44737482e-02f, 1.04665101e-01f, 6.49422705e-02f, -4.46418766e-03f, 1.32930577e-01f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -8.77236128e-02f, -8.38511139e-02f, -3.26560019e-03f, 1.15913399e-01f, 1.51719674e-01f, -1.10995159e-01f, -6.39900193e-02f, 4.30160686e-02f, 1.22731784e-02f, 1.09475590e-01f,
  9.53944400e-02f, -1.02910891e-01f, 2.63332948e-02f, 9.42501798e-02f, 1.51316702e-01f, 4.57919538e-02f, 4.43669595e-02f, 1.36925653e-01f, 6.69016391e-02f, 1.22531928e-01f,
  3.91277038e-02f, -5.10568619e-02f, -1.64454356e-01f, -1.70384347e-01f, 1.59342036e-01f, -6.86410293e-02f, -8.99853408e-02f, -1.81647956e-01f, 1.89736605e-01f, 4.11559939e-02f,
  1.25991747e-01f, -2.83539221e-02f, -1.51626542e-01f, -7.48370960e-02f, -9.70227346e-02f, -3.10436599e-02f, -1.74205154e-01f, -8.08603466e-02f, 1.36934921e-01f, -1.33764178e-01f,
  -9.14895628e-03f, -1.62810892e-01f, 1.12008914e-01f, -4.73003089e-02f, -1.23937726e-02f, -1.05045818e-01f, 2.01523826e-01f, -2.80997553e-03f, 3.01576890e-02f, 2.53864173e-02f,
  5.88917434e-02f, -1.44602343e-01f, -1.25202788e-02f, -7.94459209e-02f, -8.90991017e-02f, -1.75802216e-01f, -4.15387228e-02f, 1.20396301e-01f, 2.05476254e-01f, -7.88380951e-02f,
  7.65259489e-02f, -3.30244713e-02f, -8.48018527e-02f, 1.10423386e-01f, 6.09035045e-03f, 3.92829925e-02f, -1.31714657e-01f, -5.81481867e-03f, 1.72788098e-01f, -1.26933912e-02f,
  5.47167249e-02f, -4.11112048e-02f, -8.91094506e-02f, -7.56188408e-02f, 7.54159689e-02f, -1.17623374e-01f, 3.03709954e-02f, -9.96626318e-02f, 9.09772590e-02f, -9.13389698e-02f,
  -8.29334036e-02f, -2.18201540e-02f, 5.01861461e-02f, -1.24261238e-01f, 7.03626126e-02f, -9.97836068e-02f, 1.28780097e-01f, -5.60145651e-04f, 9.22778249e-02f, -2.91028544e-02f,
  -1.08407319e-01f, 4.87263538e-02f, -1.89365327e-01f, -6.03225641e-02f, 8.91532823e-02f, -7.10080862e-02f, -6.51144460e-02f, -2.90872399e-02f, 6.75124228e-02f, -1.76204652e-01f,
  6.06223941e-02f, 6.97305575e-02f, -1.48076870e-04f, -9.85260680e-02f, -1.52034491e-01f, 5.42602539e-02f, 7.34987203e-03f, 1.65913478e-01f, 6.19724877e-02f, 6.56695068e-02f,
  -1.12741746e-01f, 1.57409355e-01f, 4.70557138e-02f, -9.32830125e-02f, 3.79704274e-02f, -1.23021066e-01f, 3.41493301e-02f, -1.20615391e-02f, 1.79983163e-03f, 3.29279117e-02f,
  -1.71553507e-01f, 5.78589179e-02f, 8.23409203e-03f, 1.16280923e-02f, 6.71688542e-02f, 9.72426012e-02f, -5.21740876e-02f, 1.24289349e-01f, 1.20519539e-02f, -8.31259117e-02f,
  6.24260083e-02f, 4.62381616e-02f, 1.70075282e-01f, -1.56685501e-01f, 1.27982572e-01f, 1.20331675e-01f, -1.92047089e-01f, 1.61107201e-02f, 4.78792898e-02f, 3.03014275e-02f,
  1.19371392e-01f, 2.51635909e-02f, -9.70642939e-02f, 2.99308263e-02f, 1.35831654e-01f, 1.21295191e-01f, 1.23828068e-01f, -6.24068007e-02f, -4.42786627e-02f, 6.60927519e-02f,
  5.79294078e-02f, -7.41708949e-02f, -3.78227755e-02f, 2.13330165e-01f, -5.39107099e-02f, 1.71631128e-01f, -1.21442623e-01f, -2.67346688e-02f, -1.92175940e-01f, -7.16073066e-02f,
  -1.99728236e-02f, 2.78443601e-02f, 4.75808606e-02f, -2.61893477e-02f, -8.64320025e-02f, -1.00833766e-01f, -2.22382009e-01f, -1.35171071e-01f, 2.99271382e-02f, 3.27657498e-02f,
  -1.09477863e-01f, 2.79391199e-01f, -7.64347836e-02f, -5.88991307e-03f, -1.64487287e-01f, 7.74333626e-02f, 1.18069975e-02f, -1.16542682e-01f, -1.52775552e-02f, -4.38529626e-02f,
  -2.51692515e-02f, -6.25990108e-02f, 2.81951874e-01f, 2.61232182e-02f, -1.01749919e-01f, 3.12070530e-02f, 1.42644346e-01f, -6.37809653e-03f, 9.45510417e-02f, -7.42102042e-02f,
  -4.87690940e-02f, -5.63695394e-02f, -4.08290811e-02f, -6.55846819e-02f, -1.78315770e-02f, -3.50208543e-02f, -3.07063432e-03f, -1.05839595e-01f, -5.39233461e-02f, 4.51870449e-02f,
  3.88177894e-02f, -4.74534892e-02f, -5.83205223e-02f, -2.80331355e-02f, -7.64198303e-02f, 3.41535620e-02f, -1.54863093e-02f, 2.80985776e-02f, -3.75637002e-02f, 5.03391549e-02f,
  8.61021727e-02f, -1.44296095e-01f, 5.31634502e-02f, -4.13734354e-02f, -7.01965019e-02f, 5.82941212e-02f, 1.73058942e-01f, 5.77123277e-02f, 3.24063525e-02f, -9.69876647e-02f,
  4.24426980e-02f, 2.34155819e-01f, -7.11910008e-03f, -4.59936485e-02f, 5.24246432e-02f, -2.03984510e-02f, -8.44624639e-02f, -1.62187412e-01f, -2.60351170e-02f, 1.08145133e-01f,
  -8.87235627e-02f, -1.63184062e-01f, -1.03903301e-01f, -7.90704265e-02f, -2.64216084e-02f, 7.38866478e-02f, -8.95754918e-02f, 9.20074247e-03f, -1.32879866e-02f, -5.76459104e-03f,
  -4.28189076e-02f, -1.55663937e-01f, 1.06133160e-03f, -2.01481491e-01f, 1.76562816e-01f, -7.78900906e-02f, 1.93757415e-01f, -1.23477630e-01f, -9.24207643e-02f, -1.09524995e-01f,
  -8.59423075e-03f, 6.70365915e-02f, 1.84665963e-01f, -2.03543790e-02f, -5.96618168e-02f, 8.24881420e-02f, -1.42317101e-01f, 5.38990498e-02f, 7.34222075e-03f, 4.11749482e-02f,
  -1.55903190e-01f, 8.39086324e-02f, -1.41482770e-01f, 4.16439213e-02f, 6.53097034e-02f, 1.71007663e-02f, -3.45885903e-02f, -1.00348853e-01f, -4.31389324e-02f, 2.91096903e-02f,
  4.21888493e-02f, -8.88883397e-02f, -1.04546756e-01f, -7.88287669e-02f, -1.32982731e-01f, -9.47196335e-02f, -9.21442285e-02f, 4.82985340e-02f, 9.68059450e-02f, -2.29291879e-02f,
  -3.32316235e-02f, -7.48723894e-02f, 6.38856813e-02f, -1.32074982e-01f, -5.10783307e-02f, -1.59437999e-01f, -1.53102040e-01f, 1.33744717e-01f, 4.96430090e-03f, 1.14263259e-01f,
  -2.50055343e-02f, 1.66594461e-01f, 2.06042062e-02f, -3.43416333e-02f, 6.90179840e-02f, 9.69703346e-02f, 1.01282313e-01f, 6.67263195e-02f, -3.81608158e-02f, 7.76385069e-02f,
  -5.35517894e-02f, -8.26272815e-02f, 9.76863578e-02f, -1.05548613e-01f, -1.24723762e-02f, -3.91403846e-02f, 1.17878005e-01f, 7.18089342e-02f, -6.12118877e-02f, -4.76634093e-02f,
  8.95448625e-02f, 1.95910726e-02f, 2.13764444e-01f, 1.06202401e-01f, -2.17957702e-03f, 3.55086289e-02f, -1.25266686e-01f, -8.68941192e-03f, -3.00714504e-02f, 3.21848696e-04f,
  8.52452964e-02f, 2.97545716e-02f, 3.47222611e-02f, -3.65390368e-02f, -8.80535245e-02f, 1.39800400e-01f, -4.06074673e-02f, 3.96421226e-03f, -3.57949233e-04f, -4.20315675e-02f,
  9.71332192e-02f, 3.70196886e-02f, 2.01613028e-02f, 1.00737967e-01f, 2.25695258e-04f, -4.57793387e-04f, -1.22307099e-01f, 2.30430029e-02f, -9.43797529e-02f, 1.78554848e-01f,
  7.60304229e-03f, 1.87734202e-01f, 6.62286133e-02f, -1.96896836e-01f, -7.56443366e-02f, -1.17069960e-01f, -9.79577303e-02f, 7.49372765e-02f, 1.26387045e-01f, -1.39216244e-01f,
  9.22882706e-02f, 1.53485015e-01f, -1.09055616e-01f, -1.09825082e-01f, -1.43703192e-01f, -2.18024924e-02f, 8.03193077e-02f, -1.49276108e-01f, 6.42307550e-02f, 1.14619336e-03f,
  5.70173562e-03f, 2.77622826e-02f, 2.87352558e-02f, 2.06968356e-02f, 3.00176907e-02f, -1.62562415e-01f, 1.32341860e-02f, 1.03128552e-01f, -5.23381084e-02f, 1.45718977e-01f,
  5.81997372e-02f, 1.59509584e-01f, -6.77056536e-02f, 1.57737620e-02f, -2.05725282e-01f, -6.81009516e-02f, 1.22877933e-01f, 9.90392566e-02f, 5.97958528e-02f, -1.25083059e-01f,
  -1.47536397e-01f, 6.21419139e-02f, 4.01755422e-02f, -1.96055826e-02f, 4.67089787e-02f, 9.89078209e-02f, -1.76396072e-02f, 7.51262084e-02f, -7.40071684e-02f, 4.67668474e-02f,
  3.24681401e-02f, -4.96111438e-02f, 2.47013364e-02f, -1.87053308e-02f, -8.89418274e-02f, -1.49010792e-02f, 2.21665818e-02f, 1.19949998e-02f, 5.30629829e-02f, 6.24201745e-02f,
  4.54984047e-02f, -2.00591404e-02f, 1.22999154e-01f, 2.90420689e-02f, -7.17696697e-02f, 1.27403229e-01f, -1.13711037e-01f, -3.61027494e-02f, 5.19761816e-02f, -1.33124860e-02f,
  2.37900540e-02f, -2.14619935e-01f, 1.86549857e-01f, 5.02156094e-02f, -8.72526541e-02f, -1.40731677e-01f, -2.69382864e-01f, -2.01814130e-01f, -7.87699223e-02f, -6.06652796e-02f,
  -3.91903743e-02f, -6.00982197e-02f, 1.29938826e-01f, 5.54248039e-03f, -8.83778110e-02f, -1.57733455e-01f, 8.01905338e-03f, -2.97963172e-01f, -9.05419588e-02f, -1.59242161e-04f,
  2.42241636e-01f, 3.09840078e-03f, -1.16324104e-01f, 2.23891780e-01f, -8.06122124e-02f, -1.79584384e-01f, -1.98898554e-01f, 4.58202362e-02f, -2.37982303e-01f, 2.57095154e-02f,
  -2.76849349e-03f, -5.63186333e-02f, 1.79152474e-01f, -3.93266324e-03f, -1.45379737e-01f, -7.49263242e-02f, 8.32585692e-02f, -5.30625358e-02f, 7.45458081e-02f, 1.24319546e-01f,
  -3.42050530e-02f, 3.31558287e-02f, -2.92407554e-02f, 7.72299897e-03f, -8.07674974e-02f, -5.49778379e-02f, 1.21688120e-01f, 5.24872802e-02f, -8.27301368e-02f, -4.93072346e-02f,
  -6.73822537e-02f, -6.62405416e-02f, 1.18970297e-01f, -9.73581746e-02f, -5.11054210e-02f, -1.39998337e-02f, 1.09123744e-01f, -9.54590589e-02f, 1.21901922e-01f, -5.24596311e-02f,
  -3.77923064e-02f, 2.01985613e-01f, -4.82874364e-02f, -4.15242612e-02f, -9.55068842e-02f, 4.70756693e-03f, -1.63352862e-01f, -9.30794850e-02f, -1.39981061e-01f, -4.39313874e-02f,
  1.38106858e-02f, -5.35677485e-02f, 1.64659023e-01f, -1.63893476e-01f, -6.44460553e-04f, 3.98412310e-02f, -9.63114724e-02f, 1.02890201e-01f, -5.39105199e-02f, -1.14722140e-02f,
  -9.38357338e-02f, -1.07329868e-01f, -1.12327807e-01f, -5.79978153e-02f, 5.64801786e-03f, -6.08749315e-02f, -8.06410909e-02f, -1.30160138e-01f, -4.04364876e-02f, -6.59240782e-02f,
  1.12147979e-01f, 6.83799982e-02f, 8.95833597e-02f, -1.40038073e-01f, -2.00533505e-05f, -3.78328636e-02f, -9.02497704e-05f, -2.84730759e-03f, -1.69028360e-02f, -4.66442965e-02f,
  8.04034770e-02f, 5.91202714e-02f, -5.08618578e-02f, -8.82764682e-02f, 8.73118863e-02f, -3.56409810e-02f, -2.71017347e-02f, -3.12426239e-02f, 3.18953358e-02f, -5.84572367e-02f,
  -1.61147695e-02f, -4.04797308e-02f, -1.70945637e-02f, -9.92608070e-02f, 7.07198456e-02f, -1.51374817e-01f, 5.05093709e-02f, -6.77326992e-02f, 7.93155357e-02f, -1.75224617e-01f,
  9.57579166e-02f, 6.99909329e-02f, 7.97253996e-02f, -9.52272043e-02f, -2.43630446e-02f, -1.54127479e-01f, -2.10429877e-01f, -1.04500845e-01f, -9.54606459e-02f, 1.04147634e-02f,
  4.41584289e-02f, 2.31555961e-02f, 9.73267853e-02f, 1.52977541e-01f, -9.19671208e-02f, -1.49514616e-01f, -1.18326224e-01f, -1.10073909e-02f, 1.38651431e-01f, -9.83790755e-02f,
  1.15945488e-01f, 1.73018668e-02f, 7.40665346e-02f, 1.57582629e-02f, 8.59405175e-02f, -5.98533824e-02f, -2.10668948e-02f, -2.15902343e-01f, 1.33438542e-01f, 1.74941376e-01f,
  2.23568268e-02f, 3.36572379e-02f, 1.98963508e-02f, 7.95802996e-02f, -1.06759913e-01f, 4.27010432e-02f, -2.75017023e-01f, 1.50180012e-01f, -6.92709163e-02f, -1.24734342e-01f,
  -1.68202981e-01f, -5.36662899e-02f, -4.50379997e-02f, 5.21398894e-02f, -5.20444438e-02f, 1.62498698e-01f, -6.18901523e-03f, -4.16765660e-02f, 6.48364797e-02f, 1.21892005e-01f,
  5.03658690e-02f, -9.60082486e-02f, 5.90891577e-02f, -9.51007300e-04f, -1.19863570e-01f, 4.94502187e-02f, 2.48498786e-02f, 6.97612390e-02f, 5.98870963e-02f, 1.24789737e-01f,
  -1.20495066e-01f, -7.99204856e-02f, -1.10360339e-01f, -8.11750218e-02f, 1.88153852e-02f, -1.36086270e-01f, 8.52354914e-02f, 2.38748770e-02f, 9.91696119e-02f, 1.79584935e-01f,
  -1.12236418e-01f, -7.87464976e-02f, 1.13524139e-01f, 1.98102295e-01f, -1.07336044e-01f, -1.02860816e-02f, -4.48235236e-02f, 7.76638314e-02f, 7.17505440e-02f, 1.40567631e-01f,
  1.29404634e-01f, -5.04699796e-02f, 3.27143446e-02f, 1.53628981e-03f, -6.02031201e-02f, 1.11900024e-01f, 6.62273839e-02f, -2.59328038e-02f, 4.34977822e-02f, 2.47238427e-01f,
  1.94610339e-02f, 8.23887661e-02f, -2.59078026e-01f, 4.08908539e-02f, 7.89618790e-02f, -1.06783509e-01f, -6.95661977e-02f, 4.85087782e-02f, 2.10931987e-01f, 1.13352448e-01f,
  1.50478091e-02f, 4.24339585e-02f, 1.61273167e-01f, 5.52309081e-02f, -5.85227124e-02f, 6.73307329e-02f, -8.00051820e-03f, 1.22771867e-01f, -3.36681455e-02f, -9.87587869e-02f,
  1.52332798e-01f, 1.00435456e-02f, 3.84046957e-02f, -3.49767134e-02f, 9.76722389e-02f, 1.08983725e-01f, 1.44926146e-01f, 8.62574950e-03f, -8.39923546e-02f, 1.30401626e-01f,
  5.01750447e-02f, -4.80489545e-02f, -9.46382582e-02f, 1.27051741e-01f, 1.11222431e-01f, 1.40002472e-02f, -4.82367203e-02f, 1.17133625e-01f, 2.16051996e-01f, -9.30915400e-02f,
  1.03324816e-01f, -1.64268702e-01f, -1.23412404e-02f, 1.21898577e-01f, 2.03281119e-01f, 1.68681517e-02f, 4.76687141e-02f, -1.11630365e-01f, 7.19717443e-02f, -7.58078992e-02f,
  8.97789076e-02f, -1.44823611e-01f, -1.92619134e-02f, 7.38833174e-02f, 1.39931723e-01f, -7.08498731e-02f, 1.09149240e-01f, 6.94350451e-02f, -1.69213846e-01f, -8.06542486e-02f,
  -4.39864770e-02f, -1.16872437e-01f, 1.12387806e-01f, 5.77889346e-02f, -1.16546340e-01f, 1.36180237e-01f, -1.16061285e-01f, 1.94584038e-02f, -7.22477445e-04f, 6.13968633e-02f,
  3.58373225e-02f, -1.97168767e-01f, -2.20056046e-02f, 1.59773359e-03f, 3.15504707e-03f, -1.34765923e-01f, 3.69541235e-02f, -1.24829233e-01f, 2.65337750e-02f, 1.24482952e-01f,
  1.04867853e-01f, 1.20270010e-02f, 1.09254830e-02f, -8.27852711e-02f, -6.29849453e-03f, 5.37189543e-02f, -1.08583450e-01f, -1.34158665e-02f, -1.22528963e-01f, -1.20992132e-01f,
  -2.03260668e-02f, 4.05904204e-02f, -1.53998837e-01f, -3.19117717e-02f, -8.07551742e-02f, -7.38176629e-02f, 2.42040232e-02f, 9.07105058e-02f, -8.56309533e-02f, -1.21473454e-01f,
  -9.41973403e-02f, 8.90077725e-02f, -9.67437252e-02f, 1.59837361e-02f, -8.82352665e-02f, 1.16758533e-01f, -3.01986020e-02f, 1.64551008e-02f, 1.47471204e-01f, -1.74779370e-01f,
  2.20713913e-02f, -2.25672632e-01f, 2.36157794e-02f, 1.98186919e-01f, -7.07978979e-02f, 8.63570943e-02f, 1.40088886e-01f, 1.99284658e-01f, -1.44910961e-01f, -2.71162447e-02f,
  -1.76978812e-01f, 1.62162796e-01f, 1.41575128e-01f, -1.61525264e-01f, 1.51104882e-01f, -5.29791880e-03f, 7.44921565e-02f, -6.94145635e-02f, 1.28928319e-01f, 1.09711871e-01f,
  2.00378709e-02f, -1.97835818e-01f, 3.55251543e-02f, -2.00846508e-01f, -1.05426237e-02f, -1.39446154e-01f, 1.06377862e-01f, -2.24941611e-01f, 1.51962087e-01f, -5.67377470e-02f,
  1.43222436e-01f, 1.31248489e-01f, 1.37834335e-02f, -4.36750911e-02f, -3.69152613e-02f, 7.93055370e-02f, -4.43416387e-02f, -2.46442810e-01f, -4.70029563e-02f, -1.05372049e-01f,
  -2.30998490e-02f, -7.88649470e-02f, -8.78480077e-02f, 2.18898367e-05f, -9.83887911e-02f, 6.94563463e-02f, -2.17372961e-02f, -6.22248426e-02f, 2.32218616e-02f, 1.91697404e-02f,
  -7.34387562e-02f, -1.38040245e-01f, 2.00760081e-01f, -1.04814537e-01f, 3.72459032e-02f, 7.75630102e-02f, -1.01167247e-01f, -1.13619193e-02f, -1.86249271e-01f, -4.46135849e-02f,
  -1.81994457e-02f, 5.18392436e-02f, 1.60017252e-01f, -1.34239674e-01f, 9.19104815e-02f, -2.04242751e-01f, 1.73338115e-01f, -1.23418212e-01f, 9.39467400e-02f, -1.01384625e-01f,
  -1.90401092e-01f, -1.94493771e-01f, -6.94637373e-02f, 8.82804245e-02f, 1.01763003e-01f, -1.35294497e-01f, 1.13653071e-01f, -8.47236887e-02f, -7.24405870e-02f, -1.38411596e-01f,
  1.83991417e-02f, -1.07143492e-01f, -3.92520279e-02f, 5.33831976e-02f, 3.63853201e-02f, -4.46279999e-03f, 7.34707788e-02f, 9.94293168e-02f, 9.75066498e-02f, -1.75080433e-01f,
  -1.32066654e-02f, 4.80755344e-02f, -1.99739143e-01f, 4.80401628e-02f, 2.24663261e-02f, -5.36711216e-02f, 1.23644203e-01f, -3.22401561e-02f, -1.37532815e-01f, -6.35758787e-02f,
  -1.21385813e-01f, -6.18081242e-02f, 2.76563279e-02f, 1.14753492e-01f, 6.43536896e-02f, -1.22973002e-01f, 9.36606079e-02f, -7.33524561e-02f, -5.29044401e-03f, -6.47031963e-02f,
  8.63894075e-02f, 2.62294915e-02f, 1.02189705e-01f, -1.02097191e-01f, -2.58540362e-02f, -2.06778627e-02f, -2.65155751e-02f, 9.26791783e-03f, -2.63668634e-02f, -6.24694750e-02f,
  4.18485962e-02f, 9.21436772e-02f, -3.83318141e-02f, 6.25803247e-02f, 1.83791816e-01f, -1.34507909e-01f, -1.44481257e-01f, -1.68783069e-02f, -1.33887216e-01f, 9.73472074e-02f,
  -7.88374096e-02f, -1.77917749e-01f, 8.37792233e-02f, 5.57129923e-03f, -1.52965754e-01f, -1.48444086e-01f, 6.15958758e-02f, 4.09722254e-02f, 2.09612086e-01f, -2.29125708e-01f,
  -3.55310366e-02f, -6.92841262e-02f, -7.00634196e-02f, 2.84289774e-02f, -1.45205464e-02f, 1.27972260e-01f, -9.27206874e-02f, 3.31232883e-02f, -1.64756820e-01f, 1.94333807e-01f,
  -8.42199754e-03f, 7.83297867e-02f, -1.38239801e-01f, 5.45094647e-02f, 2.69089453e-02f, 2.04686940e-01f, -1.47724569e-01f, 1.78814247e-01f, -2.51273662e-01f, -1.97199490e-02f,
  -1.13508023e-01f, -4.05222960e-02f, -2.82929670e-02f, -5.48837930e-02f, 5.25929406e-02f, 1.06729113e-01f, -8.52067247e-02f, -9.27488972e-03f, -6.39620796e-02f, -9.23541933e-03f,
  2.30475795e-02f, 8.87673050e-02f, 8.14112201e-02f, 8.64194185e-02f, 8.29297453e-02f, 1.13499254e-01f, -8.58303457e-02f, -4.97149229e-02f, 1.51245324e-02f, 5.30706421e-02f,
  -3.90679725e-02f, 2.49248426e-02f, 2.75606290e-02f, 9.95362084e-03f, -7.96697065e-02f, -1.17106065e-01f, 1.17117517e-01f, -2.13001877e-01f, 1.69744015e-01f, 1.21298783e-01f,
  3.41237821e-02f, -3.16766091e-02f, -1.20897010e-01f, 4.36675847e-02f, -2.50916630e-01f, 4.16311696e-02f, 7.49319941e-02f, -1.06233791e-01f, 9.78134647e-02f, 9.51723084e-02f,
  8.50466192e-02f, -1.27835259e-01f, 1.06658444e-01f, 4.31180857e-02f, -6.56499118e-02f, -1.00105271e-01f, -1.11151896e-01f, -1.48360769e-03f, 7.01385662e-02f, 6.76726624e-02f,
  8.21897984e-02f, 7.74254948e-02f, -1.46040976e-01f, 1.33511692e-01f, -1.07385173e-01f, -1.63393661e-01f, 1.07664786e-01f, -1.11443751e-01f, 1.77419513e-01f, 1.51509747e-01f,
  9.10182223e-02f, 7.25579411e-02f, -1.94955334e-01f, -6.01004772e-02f, -1.34001508e-01f, -9.42819864e-02f, 1.69154480e-01f, -6.37033815e-03f, -2.91382968e-02f, 1.61238760e-01f,
  1.09875858e-01f, 1.28925413e-01f, -1.02743208e-01f, 3.82603593e-02f, -9.70498100e-02f, -8.68966877e-02f, -3.03701200e-02f, 1.43014297e-01f, 1.29712699e-02f, -8.52273661e-04f,
  -5.02794944e-02f, -5.29707409e-02f, -5.71232773e-02f, -6.29198104e-02f, -9.22303125e-02f, 3.49970162e-02f, -4.73986790e-02f, -7.45229376e-03f, -2.34593768e-02f, 8.86896811e-03f,
  1.46509167e-02f, 3.78339477e-02f, -9.56206992e-02f, 1.99720994e-01f, 1.58763885e-01f, 6.15895614e-02f, -3.82588953e-02f, -1.39077172e-01f, -1.18664570e-01f, 2.13694528e-01f,
  -1.40307620e-01f, 1.15037495e-02f, 4.20381688e-02f, 1.51580619e-02f, 3.27353105e-02f, -9.82362852e-02f, -3.39565203e-02f, 1.08713761e-01f, -5.92554137e-02f, -1.54009849e-01f,
  1.27737567e-01f, -1.00499481e-01f, -7.79728889e-02f, 8.13670605e-02f, 6.13096282e-02f, 2.88504213e-02f, 1.16757534e-01f, -1.11037180e-01f, 3.58798765e-02f, -2.14188933e-01f,
  8.09300616e-02f, 1.29249990e-02f, 1.90397445e-02f, -1.47927627e-01f, 8.43063146e-02f, 9.56696197e-02f, 7.52635449e-02f, -8.87315646e-02f, 1.63950473e-01f, 6.18764274e-02f,
  1.46550372e-01f, -1.28013566e-01f, -1.00573123e-01f, -1.71966732e-01f, -7.79108936e-03f, 5.45113683e-02f, 1.17673926e-01f, 4.83431630e-02f, 2.57663354e-02f, 8.17007869e-02f,
  1.22393206e-01f, 8.53429139e-02f, 8.64648670e-02f, 5.19010425e-02f, 1.68570131e-02f, -5.73863983e-02f, 2.61971708e-02f, -1.83969997e-02f, 1.06112815e-01f, -2.39301249e-02f,
  -7.36631975e-02f, -7.06876665e-02f, 1.34616181e-01f, -8.41992199e-02f, 1.20676205e-01f, -1.89329967e-01f, -1.09070288e-02f, 2.70959675e-01f, 9.25501287e-02f, -6.40513897e-02f,
  -2.86271982e-02f, -1.04399823e-01f, -1.24936588e-01f, 1.16890758e-01f, -2.04914510e-01f, 1.06709696e-01f, 8.97869691e-02f, 1.53489605e-01f, 1.88518718e-01f, -1.39729634e-01f,
  4.38724868e-02f, 1.68210194e-01f, -1.18677951e-01f, -1.00264482e-01f, 1.08155318e-01f, 1.18332114e-02f, -1.17823683e-01f, -3.50148883e-03f, 8.24818946e-03f, 1.88462809e-01f,
  -9.11348835e-02f, 2.23479867e-02f, 7.64150023e-02f, -1.33484364e-01f, -5.88126900e-03f, 9.16019902e-02f, 3.70777510e-02f, 5.50283752e-02f, 4.69922945e-02f, 7.39568993e-02f,
  1.90174252e-01f, -6.41238391e-02f, 4.65228818e-02f, 8.75007808e-02f, -5.00228070e-02f, -8.50502402e-02f, 3.72532904e-02f, -9.18545425e-02f, -9.30524468e-02f, -1.07781209e-01f,
  5.21658659e-02f, -3.50315608e-02f, -3.40664834e-02f, -2.39792047e-03f, 8.87749866e-02f, -4.06951085e-02f, -4.31712493e-02f, -1.54669032e-01f, -6.86558560e-02f, -5.37126102e-02f,
  -7.18007050e-03f, -1.65600758e-02f, -1.67708486e-01f, 7.17530772e-02f, 1.11584226e-02f, 6.78057745e-02f, -8.19210112e-02f, 1.69335037e-01f, -8.47659111e-02f, 1.72887281e-01f,
  -4.97433320e-02f, -1.63639501e-01f, -1.55534133e-01f, -5.35862520e-02f, 2.72321310e-02f, 7.54591599e-02f, -8.01702309e-03f, 9.51960385e-02f, 1.81224018e-01f, -1.20822586e-01f,
  -1.44779876e-01f, -1.54347673e-01f, -2.28196025e-01f, -4.69352417e-02f, -1.55179992e-01f, -2.23535728e-02f, -3.12253218e-02f, 1.63379405e-02f, 2.89649907e-02f, -1.15518309e-01f,
  1.04508720e-01f, 1.13115601e-01f, -7.56319985e-02f, -5.72430864e-02f, -5.23099601e-02f, 4.94162701e-02f, -5.98499663e-02f, 5.48574626e-02f, -3.20799947e-02f, 2.34574992e-02f,
  -9.21031013e-02f, -1.61429346e-01f, 1.15730882e-01f, -6.90419078e-02f, -1.53827354e-01f, 9.21460018e-02f, 1.17974520e-01f, -3.27417552e-02f, 1.54799342e-01f, 7.04288036e-02f,
  2.55131125e-02f, 1.90739706e-02f, -9.92750004e-02f, 9.83709767e-02f, 3.63621600e-02f, 4.28967811e-02f, -1.19702123e-01f, 1.52165636e-01f, -1.16611712e-01f, -9.28783938e-02f,
  -1.00808665e-01f, -1.38701294e-02f, 6.11686260e-02f, -5.31010106e-02f, 7.38818422e-02f, 9.50102061e-02f, -1.14256620e-01f, -5.98244881e-03f, -5.51847816e-02f, -2.93301456e-02f,
  -1.35122523e-01f, -1.40361488e-01f, 1.38806507e-01f, 4.36466150e-02f, 8.45839381e-02f, 7.98852146e-02f, -2.30299234e-01f, 8.16056430e-02f, 4.75472733e-02f, -5.22782393e-02f,
  1.20549798e-01f, -2.44714305e-01f, 6.40108511e-02f, 2.41387382e-01f, 2.40900487e-01f, 1.14745870e-01f, -3.97965945e-02f, 5.61934896e-02f, 9.05062258e-03f, -2.03950852e-01f,
  7.13619730e-03f, 1.41750962e-01f, 1.39811099e-01f, 8.98965001e-02f, 1.11598186e-01f, -7.12928250e-02f, 6.38284683e-02f, -2.02444956e-01f, -6.17763326e-02f, 1.54371142e-01f,
  -9.36052855e-03f, 1.60382763e-01f, 3.46314013e-02f, 1.46851122e-01f, -1.37277499e-01f, 1.04444236e-01f, 5.35079464e-02f, 3.08329239e-02f, 2.43457519e-02f, 6.45671338e-02f,
  -2.90420484e-02f, -4.79047336e-02f, -2.11189285e-01f, 1.47646308e-01f, -1.72766931e-02f, 1.69201102e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.08893864e-01f, 1.20917849e-01f, -4.10049371e-02f, -2.11663302e-02f, -1.21684246e-01f, -7.28584379e-02f, 1.07660390e-01f, 3.86667848e-02f, 1.34937301e-01f, 1.06681742e-01f,
  5.59910797e-02f, -1.19916402e-01f, 2.26728339e-02f, -9.21046436e-02f, -2.75478326e-02f, 6.56990483e-02f, -7.65401721e-02f, 1.03709996e-01f, -1.13954984e-01f, 6.97903857e-02f,
  -1.50961531e-02f, -1.02837726e-01f, -8.39764401e-02f, -6.66939020e-02f, -8.73217657e-02f, -6.14672452e-02f, 1.25703877e-02f, 1.25141339e-02f, -8.27220231e-02f, 9.56374705e-02f,
  -1.11761009e-02f, -1.25382438e-01f, 1.14250496e-01f, -8.78285319e-02f, 3.37814577e-02f, -1.06286190e-01f, 8.13895762e-02f, -1.12052560e-01f, -1.52670348e-03f, 1.35947108e-01f,
  1.00380361e-01f, 6.67836368e-02f, -1.13230310e-01f, -6.31119013e-02f, -1.01325572e-01f, 4.15908620e-02f, -4.11687046e-02f, 1.47699174e-02f, 4.95775230e-02f, 7.72272721e-02f,
  4.64492589e-02f, 8.24053213e-03f, -6.49657845e-02f, 1.31531522e-01f, -6.93722069e-02f, 5.97356260e-02f, -7.52615482e-02f, 3.40002254e-02f, 1.18265964e-01f, -6.01766817e-02f,
  -7.13008568e-02f, -8.30941871e-02f, 1.85260028e-02f, 1.34371042e-01f, 1.23514965e-01f, 1.13685301e-03f, 1.16810158e-01f, 3.88333015e-02f, 1.98328979e-02f, -1.58669930e-02f,
  1.35922089e-01f, 2.70318184e-02f, 4.43386994e-02f, 8.16889927e-02f, 1.04249924e-01f, 5.77999391e-02f, -4.59179468e-02f, 1.75510630e-01f, 1.15458183e-01f, 1.32611930e-01f,
  1.51520502e-02f, 1.94801837e-01f, 1.79394051e-01f, -9.50582996e-02f, 7.18095973e-02f, 1.32236868e-01f, 3.03749591e-02f, 4.69249859e-03f, 1.61827773e-01f, -1.08575627e-01f,
  2.59541571e-02f, -1.47310540e-01f, 1.21577166e-01f, 1.14487924e-01f, -1.30252438e-02f, 5.60855791e-02f, 8.99554323e-03f, 6.12421632e-02f, 2.02966817e-02f, -4.54449393e-02f,
  -2.78297509e-03f, 6.95112720e-02f, -6.29635379e-02f, -4.05739769e-02f, 4.67958860e-02f, -5.56754209e-02f, -1.08700082e-01f, -1.04919106e-01f, -1.23096406e-01f, 1.20898217e-01f,
  8.90671164e-02f, -1.06758632e-01f, -4.33693938e-02f, 1.00822086e-02f, 1.49627053e-03f, 9.59248841e-02f, -6.12358674e-02f, -1.24962710e-01f, 5.68218157e-02f, -1.90339714e-01f,
  1.63021982e-01f, -2.34708679e-03f, 2.22535267e-01f, 1.18519552e-01f, -4.42874134e-02f, 6.92411810e-02f, -4.13631350e-02f, 3.78570110e-02f, 1.14848264e-01f, 1.93047643e-01f,
  4.33375128e-02f, 1.79570273e-01f, 6.00193329e-02f, -6.70819879e-02f, 1.89030811e-01f, 2.16865137e-01f, -2.03280617e-02f, 8.25283378e-02f, 8.56250077e-02f, -1.25315832e-02f,
  1.97538644e-01f, -3.54438238e-02f, 2.11102754e-01f, 1.41365573e-01f, 1.05205566e-01f, 2.47795507e-02f, 1.55938128e-02f, 2.26221420e-02f, -8.38795900e-02f, -1.09297104e-01f,
  7.49784783e-02f, 1.08841173e-01f, 1.59303874e-01f, 1.12901635e-01f, -4.50689252e-03f, 1.12065095e-02f, -1.59788445e-01f, 2.47093340e-06f, -7.40602762e-02f, -2.39500001e-01f,
  -2.47259289e-01f, -8.41840878e-02f, -3.15400362e-02f, 1.42452118e-04f, 2.34237649e-02f, -1.58500642e-01f, -1.23670824e-01f, -1.38815522e-01f, -7.63877854e-02f, 7.68638179e-02f,
  -7.14282272e-03f, 3.39406393e-02f, -1.14737190e-02f, 1.23504542e-01f, 1.18757591e-01f, 1.46622509e-01f, 3.84093858e-02f, 1.50657117e-01f, 1.48851857e-01f, -3.71115208e-02f,
  -3.04445662e-02f, 6.97670430e-02f, 1.81742445e-01f, 1.43265650e-02f, -1.81059510e-01f, 8.86137970e-03f, 9.64462459e-02f, 6.98728859e-02f, -1.06260171e-02f, -3.25483978e-02f,
  -1.94084235e-02f, 1.22208975e-01f, -3.91438939e-02f, 8.75922218e-02f, 9.60403457e-02f, -3.70773077e-02f, 1.24431476e-01f, 3.36914603e-03f, -4.84532304e-03f, 1.77119330e-01f,
  1.12307698e-01f, 1.46379843e-01f, 4.48033474e-02f, 1.32594198e-01f, 3.24149430e-02f, 1.74783528e-01f, -6.04790114e-02f, 9.37647000e-03f, -1.73680054e-03f, 6.66228980e-02f,
  1.31674007e-01f, -9.22497362e-03f, 8.31106119e-03f, 3.41992383e-03f, 3.20789963e-02f, 1.70394629e-01f, -6.40861457e-03f, -6.15699030e-02f, -2.68671215e-02f, 6.85583651e-02f,
  -2.51662046e-01f, 2.08792791e-01f, -1.56916920e-02f, -1.92814693e-01f, -5.67516349e-02f, 9.65978429e-02f, 1.85009390e-01f, -6.83768168e-02f, -1.04525298e-01f, 3.57871838e-02f,
  -1.05322570e-01f, 1.03611715e-01f, -7.49470219e-02f, -4.52548452e-02f, 9.36861634e-02f, 1.18539460e-01f, 4.02325168e-02f, 2.52397686e-01f, -1.81419164e-01f, -6.12886250e-02f,
  -1.09923437e-01f, -1.25065640e-01f, 9.89436433e-02f, 1.14170589e-01f, 2.64340639e-01f, 1.34702399e-01f, 3.17560315e-01f, 5.70363216e-02f, 7.22269015e-03f, 4.84787337e-02f,
  5.86314499e-03f, 1.58903003e-02f, 1.78261563e-01f, -9.45238248e-02f, 5.52902967e-02f, 2.93671340e-02f, 2.11650096e-02f, 1.43066376e-01f, -3.77964415e-02f, 9.31478664e-02f,
  1.08989730e-01f, 1.63687170e-01f, -2.47183722e-02f, 6.86252192e-02f, 4.75400202e-02f, 3.34325396e-02f, -8.77073631e-02f, 1.25745669e-01f, 1.30206689e-01f, -1.45495282e-02f,
  4.13918570e-02f, -1.29802693e-02f, -1.72070358e-02f, -5.61471917e-02f, -1.95792485e-02f, -1.33516071e-02f, 8.30380619e-02f, -5.85696325e-02f, -6.27415022e-03f, 1.74143929e-02f,
  -1.36039227e-01f, -1.02250233e-01f, -2.60308366e-02f, 2.56140023e-01f, -2.02084035e-01f, 1.17159396e-01f, 8.50254893e-02f, -1.25672415e-01f, 1.64962299e-02f, 7.54137188e-02f,
  -1.01193450e-01f, 2.18578335e-02f, 5.14389910e-02f, 9.33788791e-02f, 1.09238304e-01f, -6.38123453e-02f, -8.97421539e-02f, 9.15882438e-02f, 2.60554738e-02f, 2.52421021e-01f,
  1.81328550e-01f, 9.96914357e-02f, -9.65391286e-03f, 2.83581801e-02f, -2.79568415e-02f, -1.27183244e-01f, 6.01689704e-02f, 1.23042427e-01f, -2.28953618e-03f, 1.31317051e-02f,
  2.48521462e-01f, 2.49771461e-01f, -1.70245662e-01f, -7.35966116e-03f, -1.66254237e-01f, -7.47635588e-02f, 1.02226913e-01f, -5.91108128e-02f, -1.05582617e-01f, 1.30255029e-01f,
  -6.17488436e-02f, -3.30024697e-02f, -6.97776079e-02f, 3.58312912e-02f, -7.10021034e-02f, 1.20845968e-02f, -7.08414614e-02f, -5.08802617e-03f, -1.73832327e-02f, -1.23289116e-01f,
  7.85455629e-02f, 5.51738106e-02f, -6.24511614e-02f, 1.18858382e-01f, -7.87621289e-02f, -2.41296347e-02f, 8.72365460e-02f, -1.34774568e-02f, -6.06341735e-02f, 9.70398411e-02f,
  -1.40398601e-02f, 1.14849001e-01f, -6.56097522e-03f, 1.22123681e-01f, -8.02500993e-02f, 1.19072582e-04f, -5.38635962e-02f, -1.41275292e-02f, 1.22385450e-01f, -1.07930735e-01f,
  5.45213185e-02f, 8.98242667e-02f, 1.10952973e-01f, 6.44101202e-03f, -4.16605473e-02f, -6.57723770e-02f, 9.04399082e-02f, 1.22361057e-01f, 4.55176830e-03f, -9.58138406e-02f,
  -3.14551108e-02f, 7.06027895e-02f, 7.68293440e-02f, 8.54663402e-02f, -8.04562047e-02f, -7.83130899e-02f, -1.02872893e-01f, -1.12170316e-01f, -8.11715499e-02f, -8.27438310e-02f,
  -8.80226120e-02f, -9.46660265e-02f, -8.61212462e-02f, 5.02196625e-02f, -6.34397790e-02f, 6.06264658e-02f, -7.63776228e-02f, 1.82163753e-02f, -1.02582194e-01f, 3.50303738e-03f,
  8.54249075e-02f, -2.57980041e-02f, -5.90894893e-02f, 2.07780004e-02f, 1.19969912e-01f, 1.67008996e-01f, 9.68680754e-02f, 1.15271330e-01f, 1.93996072e-01f, 1.25264704e-01f,
  1.71045512e-01f, -5.71653433e-02f, 1.40473917e-01f, 2.02951193e-01f, -4.21970859e-02f, 3.87662351e-02f, 2.24863961e-01f, 8.61098766e-02f, -8.96340162e-02f, 1.47521630e-01f,
  5.07711992e-02f, -5.41879311e-02f, -1.67511422e-02f, -9.57858264e-02f, 7.90193677e-02f, -1.26738489e-01f, 1.62639827e-01f, -6.14949390e-02f, -1.28019929e-01f, 1.22458942e-01f,
  -1.62121117e-01f, 3.15813750e-01f, -3.38837147e-01f, -1.75486431e-01f, 5.22378907e-02f, -1.15680054e-01f, 2.67809201e-02f, -8.46834406e-02f, -5.32510551e-03f, 6.76462650e-02f,
  2.89062530e-01f, -1.37167990e-01f, -1.67683195e-02f, 2.43548274e-01f, -1.62347078e-01f, 2.09948003e-01f, 1.13870032e-01f, 3.14834386e-01f, 1.90318093e-01f, 7.95934424e-02f,
  -1.00135796e-01f, 2.33245552e-01f, 9.40555781e-02f, 1.21570170e-01f, -9.45612341e-02f, 1.92522645e-01f, 2.49822512e-02f, 3.23265344e-01f, 2.41180435e-01f, 1.95726559e-01f,
  -2.12652281e-01f, -1.14613891e-01f, 3.15803736e-02f, 1.85248479e-02f, 2.48229802e-02f, 7.54003227e-02f, -9.71208587e-02f, 2.20838442e-01f, -4.82197888e-02f, -8.71390253e-02f,
  6.95332661e-02f, -2.32203584e-02f, -1.19277373e-01f, 1.33377016e-01f, 1.08145522e-02f, -1.77510008e-02f, -3.03075905e-03f, 9.18197185e-02f, -2.97376458e-02f, -2.22529881e-02f,
  -4.26238924e-02f, 3.11439880e-03f, -2.11804863e-02f, 6.08654283e-02f, -3.02617010e-02f, 8.96182880e-02f, -6.82839528e-02f, 2.82809846e-02f, -2.69507654e-02f, 1.15904965e-01f,
  1.86261684e-02f, 6.61838129e-02f, -1.23312242e-01f, 4.95883934e-02f, 6.26966655e-02f, 1.24466240e-01f, -8.55649039e-02f, -1.56409070e-02f, -1.10528402e-01f, -2.42547542e-02f,
  9.70608965e-02f, -7.74529353e-02f, -5.46440855e-02f, 7.79473921e-03f, 3.66008803e-02f, 4.21441570e-02f, 1.04902081e-01f, -7.85231963e-02f, 1.45700723e-02f, -5.04385307e-02f,
  9.56730247e-02f, 5.33452211e-03f, -6.44720420e-02f, -1.05554514e-01f, -1.06544457e-02f, -1.43032800e-02f, -9.90574509e-02f, -9.45731625e-03f, 1.29030615e-01f, 1.02793775e-01f,
  8.18940252e-02f, 2.02130415e-02f, 7.51622468e-02f, -6.84060669e-03f, 8.93268213e-02f, 4.26423326e-02f, 5.98691031e-02f, -3.23445350e-02f, -6.57517463e-03f, -1.69718638e-03f,
  -3.92095745e-02f, 1.14584938e-01f, -3.20460387e-02f, 1.54273942e-01f, 2.01538697e-01f, 1.41419962e-01f, -5.23234159e-02f, -4.80326004e-02f, 1.57101765e-01f, 1.96821496e-01f,
  8.10968950e-02f, -8.16849340e-03f, 1.33938134e-01f, -2.18832623e-02f, 1.94971070e-01f, -1.92785654e-02f, -3.73519063e-02f, -1.23315640e-02f, 1.54633373e-02f, 5.99237382e-02f,
  1.25657618e-01f, -1.93635032e-01f, 1.09479152e-01f, 1.83070041e-02f, -1.27300873e-01f, 2.25959674e-01f, 1.79242626e-01f, -7.59577230e-02f, 1.12777241e-01f, 5.86569533e-02f,
  -1.36887748e-02f, 6.71043023e-02f, -1.68326348e-01f, 1.29239231e-01f, -1.20072858e-02f, 2.88711905e-01f, 7.15229139e-02f, 5.09955874e-03f, -1.52127981e-01f, 2.39788517e-01f,
  3.83032337e-02f, 7.61802942e-02f, 1.38415992e-01f, 7.45068043e-02f, 1.06730089e-01f, 7.54811391e-02f, 1.05649732e-01f, 8.57919529e-02f, -5.37137464e-02f, 5.39098792e-02f,
  6.54097497e-02f, 3.19662914e-02f, 1.27102003e-01f, -1.74967106e-02f, 1.48044601e-01f, -1.58283547e-01f, 3.33421946e-01f, -3.26340385e-02f, 3.18594873e-01f, -7.25907013e-02f,
  1.64178431e-01f, -5.40998541e-02f, 1.42964169e-01f, -6.50041476e-02f, 8.34681988e-02f, -1.90656394e-01f, 2.55397465e-02f, 5.52810542e-02f, -4.73813862e-02f, 6.16549365e-02f,
  -5.58689497e-02f, 2.90773511e-02f, 5.51758558e-02f, -6.46863729e-02f, -8.55922885e-03f, -1.05143160e-01f, 9.95307490e-02f, -4.89993729e-02f, -1.14022503e-02f, 1.11080647e-01f,
  -6.72496110e-02f, -1.00682221e-01f, 8.23741034e-02f, 2.67196912e-02f, 8.29122588e-02f, -1.81541452e-03f, 1.35676295e-01f, 3.83346528e-02f, 2.55557094e-02f, -1.58127263e-01f,
  -3.32553051e-02f, 5.78837283e-02f, 1.05348147e-01f, 3.30378227e-02f, 8.60369354e-02f, -1.35025486e-01f, 1.63241014e-01f, 5.37244081e-02f, 4.75011654e-02f, -4.56766225e-02f,
  -2.12633908e-02f, -5.70732802e-02f, -1.32112816e-01f, -7.97758438e-03f, -4.61103693e-02f, 2.77025178e-02f, 9.47370082e-02f, 5.23848683e-02f, -1.03148572e-01f, 1.36384815e-02f,
  8.11466053e-02f, -1.01416424e-01f, 3.82734872e-02f, 2.37562018e-03f, 2.66308207e-02f, 6.98074177e-02f, -8.79098102e-03f, -7.44143203e-02f, -2.83736289e-02f, -6.16526194e-02f,
  7.95480311e-02f, 5.82420453e-02f, -2.77041439e-02f, 3.57847437e-02f, 1.02817426e-02f, -1.66111477e-02f, -1.61458384e-02f, -7.52007812e-02f, -1.07856236e-01f, 8.16820189e-02f,
  8.80816802e-02f, -6.77466467e-02f, -5.63473143e-02f, -7.53193200e-02f, -1.23469509e-01f, 1.16087636e-02f, -6.73486218e-02f, -6.57403097e-02f, 1.21870287e-01f, 1.87995974e-02f,
  1.20731018e-01f, -6.92701265e-02f, -2.21204222e-03f, 8.78925472e-02f, -7.42784217e-02f, -1.00634387e-02f, -6.69320449e-02f, 9.42262784e-02f, -7.55533278e-02f, -1.23573139e-01f,
  5.79330325e-02f, 1.23425007e-01f, 1.15296394e-01f, -1.21062152e-01f, -6.53643459e-02f, 3.33970673e-02f, 4.57073599e-02f, -9.58571676e-03f, 6.30192459e-02f, 1.22940019e-01f,
  -6.86613172e-02f, 9.02288929e-02f, 4.12993208e-02f, -1.93716008e-02f, -1.54753616e-02f, -6.26435056e-02f, 8.05283040e-02f, -2.20874064e-02f, 1.15431203e-02f, 2.80850800e-03f,
  5.86851537e-02f, 3.76442708e-02f, 2.04971209e-02f, -1.07188404e-01f, 6.97423099e-03f, 2.86729597e-02f, -8.18727612e-02f, -3.68128493e-02f, 2.43670885e-02f, -1.53402076e-03f,
  1.04763404e-01f, 3.51493396e-02f, 7.46259242e-02f, -4.75510694e-02f, -9.12764594e-02f, -9.68684107e-02f, -1.08676672e-01f, -1.23862609e-01f, -6.61772415e-02f, -1.01718009e-01f,
  -1.13319822e-01f, -8.32923874e-02f, -1.03395164e-01f, -2.14353222e-02f, -5.71110621e-02f, 4.35737446e-02f, 5.18767349e-03f, 6.85123205e-02f, -3.76379378e-02f, -3.13988291e-02f,
  1.15239590e-01f, -5.85156456e-02f, 3.57297137e-02f, 8.71090442e-02f, -9.97122750e-02f, -1.04206465e-02f, 5.06431162e-02f, 1.51304593e-02f, -1.12396486e-01f, 1.12682670e-01f,
  2.68828589e-02f, -4.26482186e-02f, -1.36720702e-01f, -5.26777178e-04f, 1.91873685e-02f, 3.88155021e-02f, -8.06151852e-02f, 1.01323880e-01f, -1.36503100e-01f, 7.13255331e-02f,
  5.52516803e-02f, 2.59658694e-01f, -1.17544174e-01f, -1.22009642e-01f, -9.20811892e-02f, 1.01098225e-01f, 9.51464996e-02f, 1.39124855e-01f, 1.49808109e-01f, 7.52533823e-02f,
  -1.68367997e-02f, -6.09780699e-02f, 7.76839629e-02f, 9.27689970e-02f, 3.77048515e-02f, 2.26159498e-01f, -1.51531966e-02f, 2.55447000e-01f, -3.66422608e-02f, -6.12788387e-02f,
  -2.42556855e-01f, 1.23688713e-01f, 4.55079116e-02f, -1.76307976e-01f, 8.14780295e-02f, 2.45782271e-01f, 1.86798975e-01f, -4.84663956e-02f, 1.90997794e-01f, 2.13038400e-01f,
  1.73072115e-01f, -1.35526387e-02f, -1.67477235e-01f, -6.11336194e-02f, 1.23239182e-01f, 1.34202018e-01f, 8.42977166e-02f, 4.48291562e-02f, 9.64251235e-02f, 2.98684128e-02f,
  2.86132898e-02f, 1.11742519e-01f, 5.45555726e-02f, 9.76206213e-02f, 7.02851415e-02f, -9.57627818e-02f, -1.34840356e-02f, -1.05460182e-01f, -1.26871854e-01f, 2.08064951e-02f,
  -1.00376353e-01f, -3.12806517e-02f, 1.10249771e-02f, -1.99689693e-03f, 6.35051029e-03f, -9.55154523e-02f, -8.43289495e-02f, -1.65458862e-02f, -6.91928342e-02f, -1.21409819e-01f,
  -3.46256271e-02f, 3.36730629e-02f, -5.37385903e-02f, 4.90068048e-02f, -2.40145735e-02f, 4.13662381e-02f, 3.83992270e-02f, -1.20912097e-01f, 8.20692405e-02f, -5.90355136e-02f,
  3.60562503e-02f, 3.26212421e-02f, 4.19662781e-02f, 1.31098226e-01f, -9.97511074e-02f, -4.31446657e-02f, 2.62942072e-03f, -3.63607854e-02f, 5.07225804e-02f, 5.44510633e-02f,
  -1.00905150e-01f, 9.21233594e-02f, 1.29668519e-01f, -5.30819222e-02f, -4.96464930e-02f, 5.22865728e-02f, 1.05584256e-01f, -5.13959602e-02f, 3.52833010e-02f, -8.62284750e-03f,
  -1.80444364e-02f, 6.71401843e-02f, -6.99611530e-02f, 5.18395863e-02f, 2.51260400e-02f, 3.73247229e-02f, 9.61982086e-02f, 5.05504794e-02f, -7.88955986e-02f, 1.06328605e-02f,
  4.56569754e-02f, -5.73619753e-02f, 1.55063868e-02f, 1.54328734e-01f, -1.97756048e-02f, 1.49209604e-01f, 5.74636925e-03f, 1.21861510e-01f, -1.84182003e-02f, 1.74418204e-02f,
  3.01111359e-02f, 1.06865771e-01f, 2.41562903e-01f, 1.82320192e-01f, 1.37483448e-01f, 2.08571434e-01f, 2.91119784e-01f, -4.24966514e-02f, 7.19287097e-02f, 1.16876692e-01f,
  2.65123546e-01f, -3.96745615e-02f, -1.21388957e-01f, 3.52821425e-02f, -1.18977226e-01f, 4.75127734e-02f, 1.34976909e-01f, -2.24436477e-01f, 1.01546362e-01f, -2.45702595e-01f,
  1.89686224e-01f, -2.14767084e-01f, -2.22827345e-02f, 1.46168560e-01f, 1.16927400e-02f, -9.45434347e-02f, 4.90054823e-02f, -2.81517897e-02f, 6.67622611e-02f, -1.62246555e-01f,
  1.43300980e-01f, 2.44002953e-01f, 8.17759484e-02f, 4.02736925e-02f, 5.03827296e-02f, -2.46048450e-01f, 1.21314272e-01f, 3.45521867e-02f, 4.05718535e-01f, 7.68732727e-02f,
  -1.19240470e-01f, 3.54270309e-01f, 5.96317723e-02f, -1.12049349e-01f, -4.27696705e-02f, 1.33880237e-02f, -2.71853805e-01f, -1.51823893e-01f, 3.09787914e-02f, 5.79213798e-02f,
  1.58780456e-01f, 8.01617205e-02f, -4.15685773e-02f, -4.67551723e-02f, 1.10335797e-01f, 1.42470911e-01f, 6.29693270e-02f, -1.18984217e-02f, 1.48499697e-01f, 1.69444293e-01f,
  -1.26049286e-02f, -7.91553706e-02f, 1.75081775e-01f, 1.72004044e-01f, -9.80245546e-02f, 4.06907462e-02f, -1.58517784e-03f, 1.36706218e-01f, 2.98269223e-02f, 6.08847551e-02f,
  2.10195109e-01f, 5.78891858e-02f, 9.45060775e-02f, 1.08218431e-01f, 7.32019842e-02f, 1.06235392e-01f, -1.35759145e-01f, 1.83660150e-01f, -1.78980857e-01f, -1.73077792e-01f,
  4.39551584e-02f, -3.64306457e-02f, -8.68183970e-02f, -1.32069126e-01f, 2.14633524e-01f, -3.75174135e-02f, 1.49133623e-01f, 3.62497829e-02f, -2.39964277e-01f, -1.21642135e-01f,
  -1.40268579e-01f, -6.73167631e-02f, -1.46622345e-01f, -1.13740757e-01f, 7.62948692e-02f, 6.62943861e-03f, 1.76850051e-01f, -1.04330510e-01f, 1.05567046e-01f, -1.69426519e-02f,
  1.19735789e-03f, 1.11336604e-01f, 4.10695136e-01f, -6.48512393e-02f, 6.17557205e-02f, 1.51491970e-01f, 6.94162026e-02f, -1.55095726e-01f, -1.96887866e-01f, -1.03979588e-01f,
  -5.11130355e-02f, -1.52402027e-02f, 1.26682371e-01f, 1.11221867e-02f, 2.37571433e-01f, 2.61682775e-02f, 3.76145579e-02f, -5.03425933e-02f, -2.88268756e-02f, 5.58656938e-02f,
  9.91165563e-02f, -2.05310713e-02f, 1.13208085e-01f, 9.78828594e-02f, 1.89828292e-01f, 1.31091252e-01f, 1.46558180e-01f, 1.20423533e-01f, -4.51795049e-02f, 7.17345551e-02f,
  6.96253702e-02f, 1.12050921e-02f, -4.84831780e-02f, 1.46109834e-01f, 1.76354930e-01f, 1.15074091e-01f, 1.65766254e-01f, 1.85159687e-02f, 1.65014476e-01f, -5.69044128e-02f,
  -1.85467780e-01f, 4.65739742e-02f, -5.91378957e-02f, -6.54955655e-02f, 1.31529033e-01f, 1.09261237e-01f, -1.05721474e-01f, -6.98196441e-02f, -1.37057275e-01f, -1.04292832e-01f,
  1.85996164e-02f, -1.90727770e-01f, -1.36399090e-01f, -7.61624500e-02f, -8.06820169e-02f, -4.48578387e-04f, 1.14780270e-01f, -1.01060383e-01f, -8.86599161e-03f, 8.79869387e-02f,
  -5.09918705e-02f, -4.82532661e-03f, -6.95721805e-02f, 1.02074243e-01f, 1.01272985e-01f, 1.85683966e-01f, 4.72704992e-02f, 1.80619791e-01f, -7.69336075e-02f, -5.87328523e-02f,
  6.41837865e-02f, 4.49845903e-02f, 9.35784429e-02f, -4.26185206e-02f, 1.03473373e-01f, 1.25652626e-01f, -9.65540260e-02f, 9.86823663e-02f, 1.24616534e-04f, 2.14240327e-02f,
  9.31622013e-02f, -7.96811953e-02f, 8.88229012e-02f, -6.92525739e-03f, -5.24509251e-02f, -9.93390456e-02f, 3.70236044e-03f, -6.60924464e-02f, -7.37015158e-02f, -1.30794793e-02f,
  1.18222110e-01f, 1.45314718e-02f, 1.80830434e-02f, -4.46284227e-02f, 2.87349485e-02f, 2.60960646e-02f, -1.09231755e-01f, 2.12079771e-02f, 4.79839556e-02f, -4.29006666e-03f,
  -2.90937535e-02f, -7.65661001e-02f, 1.07320718e-01f, -9.37538520e-02f, -1.03346057e-01f, 1.00062136e-02f, -1.12353582e-02f, -1.14398725e-01f, -4.35991250e-02f, -9.10266340e-02f,
  -7.75549859e-02f, 4.00218479e-02f, -8.63577351e-02f, 6.84936121e-02f, -4.71052527e-02f, 1.04442656e-01f, 7.72623643e-02f, 5.24591580e-02f, 4.53788266e-02f, 1.19812496e-01f,
  -5.07632196e-02f, 7.97197819e-02f, 6.36006668e-02f, -6.47704303e-02f, -3.18016447e-02f, -7.19450116e-02f, 4.92112264e-02f, -6.78561395e-03f, -4.95352708e-02f, 8.44192225e-03f,
  -2.75316909e-02f, 3.19727212e-02f, -3.94736715e-02f, -6.56558871e-02f, -7.69743919e-02f, 5.32783940e-02f, 9.15948525e-02f, -1.23158030e-01f, 1.30873099e-01f, 1.37237519e-01f,
  -8.35739747e-02f, 5.76946065e-02f, 9.16840956e-02f, 1.15831956e-01f, 4.42801714e-02f, 9.85220149e-02f, -6.95545673e-02f, -4.91427891e-02f, 1.72848970e-01f, 1.04435042e-01f,
  2.08267439e-02f, 1.76818147e-01f, 1.39003292e-01f, 2.66961996e-02f, 1.05695643e-01f, -2.76388302e-02f, 1.34326175e-01f, 1.16061598e-01f, 9.32618752e-02f, 5.03226295e-02f,
  1.31594315e-01f, 1.81369185e-01f, -7.24934973e-03f, 1.49700105e-01f, 4.01080586e-02f, 5.52105233e-02f, 6.03769086e-02f, -5.60627021e-02f, 1.42496467e-01f, -1.96178555e-01f,
  6.84899241e-02f, 2.05458298e-01f, -1.08127020e-01f, 3.01159336e-04f, -6.66545630e-02f, -2.62233987e-02f, 4.81819957e-02f, -1.97287634e-01f, 8.65458772e-02f, 8.68127719e-02f,
  1.37847215e-01f, 2.63423398e-02f, 1.48452118e-01f, -6.05118424e-02f, 1.99118063e-01f, 6.95208460e-02f, 1.00151330e-01f, 2.49962583e-01f, 5.37028983e-02f, 2.12955877e-01f,
  -6.67202249e-02f, -1.13051005e-01f, 4.11215127e-02f, -6.18580393e-02f, -8.69924054e-02f, 7.60343820e-02f, 3.41460407e-02f, 2.94539914e-03f, -1.43115938e-01f, 2.43093848e-01f,
  -4.60036770e-02f, 1.64789632e-01f, 1.04349228e-02f, 1.73350006e-01f, 2.23028407e-01f, -3.15817483e-02f, -4.87543233e-02f, -6.40307441e-02f, 1.88366342e-02f, 1.47463843e-01f,
  -3.54234762e-02f, 1.64152786e-01f, 3.19482349e-02f, 1.01657622e-01f, 1.08688533e-01f, 7.00126663e-02f, -6.23392388e-02f, 5.18626347e-02f, 1.93915833e-02f, 1.35048419e-01f,
  -7.78047368e-02f, -5.84844239e-02f, 1.56240031e-01f, 8.45612865e-03f, -6.45935386e-02f, -5.25076874e-03f, 1.15153356e-03f, -1.22783827e-02f, 1.61857277e-01f, -1.34192947e-02f,
  1.99535057e-01f, 1.66240558e-02f, -1.32446378e-01f, -1.55720249e-01f, 9.29914638e-02f, 6.91561922e-02f, 1.78663656e-01f, 1.44303804e-02f, 7.83591568e-02f, -3.17212828e-02f,
  4.25426383e-03f, 7.55545422e-02f, -1.85692273e-02f, -5.67004979e-02f, -1.15701243e-01f, -1.15229033e-01f, -4.79977876e-02f, -8.68728384e-02f, 1.28400400e-01f, -5.34893498e-02f,
  -1.16737820e-01f, 1.26201600e-01f, 1.09508649e-01f, -1.17471725e-01f, 8.69932100e-02f, -6.95751458e-02f, 5.35942353e-02f, 1.01955824e-01f, 1.72039881e-01f, 1.52228074e-02f,
  -1.15049034e-01f, 7.53371939e-02f, 8.68686475e-03f, -1.08454771e-01f, 8.18994269e-02f, 3.47792543e-02f, 3.28364111e-02f, 8.56925733e-04f, 3.42120393e-03f, 1.30518138e-01f,
  1.21106923e-01f, 9.72265527e-02f, 1.23398848e-01f, 8.84558335e-02f, -2.17694174e-02f, 8.16388801e-02f, 9.88499820e-02f, 1.40991807e-01f, 1.41962618e-01f, 1.22771397e-01f,
  1.06876828e-01f, 2.15743091e-02f, -5.73888682e-02f, 2.66544186e-02f, 3.34279984e-02f, 1.21905968e-01f, 1.05890743e-01f, 8.39329585e-02f, -5.77026866e-02f, -9.39131132e-05f,
  -8.01959485e-02f, 1.58948839e-01f, 1.44099891e-01f, -2.39845011e-02f, 1.47729084e-01f, -1.91591140e-02f, 6.45331517e-02f, -1.23871919e-02f, -4.26473171e-02f, 5.86515777e-02f,
  6.42178068e-03f, 1.61843523e-01f, -7.46729523e-02f, 3.35222967e-02f, -1.26088172e-01f, 5.87869808e-03f, -1.72890708e-01f, -2.32097313e-01f, -3.96226645e-02f, 5.48427831e-03f,
  1.52113780e-01f, 6.32109940e-02f, -7.74960518e-02f, 4.49336208e-02f, -1.90507829e-01f, -1.56656519e-01f, 1.23311982e-01f, -1.21215150e-01f, -1.13811716e-01f, 1.63942859e-01f,
  -6.32799864e-02f, 1.94096029e-01f, 6.89238980e-02f, 1.19965412e-01f, -6.55874163e-02f, 4.75053973e-02f, 1.26012132e-01f, -6.62089363e-02f, 2.25116551e-01f, -1.17280602e-01f,
  3.47444057e-01f, 1.46430656e-01f, -1.82540253e-01f, 7.08869323e-02f, 2.27193519e-01f, 1.47054404e-01f, 2.56317258e-01f, -8.08518454e-02f, -1.05569132e-01f, 3.15765217e-02f,
  2.10979301e-02f, 3.29108648e-02f, -2.63948627e-02f, 5.08942716e-02f, -5.67344278e-02f, 9.93931144e-02f, 1.02174908e-01f, 8.85631144e-02f, -7.77239203e-02f, -5.05007394e-02f,
  5.86285703e-02f, 1.53035775e-01f, 2.24200338e-02f, 1.28714517e-01f, -1.34621143e-01f, -1.05326641e-02f, 3.51127386e-02f, 4.29054350e-02f, -3.08249556e-02f, -2.62567699e-02f,
  1.79605603e-01f, 5.41950203e-02f, 1.49504039e-02f, 1.32901475e-01f, -1.35114342e-01f, -3.59900296e-02f, 1.47409499e-01f, 2.34362204e-02f, -5.46089374e-03f, -1.26060903e-01f,
  7.42103606e-02f, 1.04325429e-01f, 1.82492420e-01f, 3.45512033e-02f, -6.61907718e-02f, 1.76176190e-01f, -5.34111634e-02f, -7.98514336e-02f, 1.05166689e-01f, 2.64251202e-01f,
  9.23144370e-02f, 2.51782298e-01f, 4.93889824e-02f, -3.25718932e-02f, 1.31036088e-01f, -1.14231937e-01f, -5.62667996e-02f, -5.94952591e-02f, 3.35877910e-02f, 6.97821081e-02f,
  6.65376708e-03f, 1.53204694e-01f, 1.46456331e-01f, 4.21072580e-02f, 5.16105071e-02f, 1.04769692e-01f, 2.77917951e-01f, 1.34252027e-01f, -1.05042674e-01f, -1.03036880e-01f,
  -7.51373991e-02f, 1.95350066e-01f, -1.27285540e-01f, -1.12472720e-01f, 1.28198475e-01f, 9.65927616e-02f, 1.27657071e-01f, 5.28450906e-02f, 6.21156916e-02f, 1.16902784e-01f,
  8.99597332e-02f, 1.36714280e-01f, 7.65723735e-03f, 1.54572884e-02f, 8.50677416e-02f, 7.47882873e-02f, 8.99330229e-02f, 1.21581055e-01f, 9.08283815e-02f, -5.49557619e-03f,
  -8.00778798e-04f, 1.31914197e-02f, 1.87724307e-01f, 8.04876164e-02f, -1.60636202e-01f, -1.50708646e-01f, 1.17195316e-01f, -7.70025849e-02f, 6.79313764e-02f, 1.60192519e-01f,
  -1.30086675e-01f, 5.35513833e-02f, -6.54161267e-04f, -1.62395425e-02f, 4.98674437e-02f, -7.19990656e-02f, -2.57480681e-01f, -1.72582343e-02f, 7.57294595e-02f, -6.20510131e-02f,
  4.00996767e-02f, -1.69498563e-01f, -3.27870026e-02f, 4.28182678e-03f, -9.29784551e-02f, -1.35005727e-01f, -1.29276484e-01f, 3.91185936e-03f, -2.45600101e-02f, -6.40328787e-03f,
  1.65208191e-01f, 2.41815567e-01f, 6.87052533e-02f, 5.68165965e-02f, 1.48741379e-01f, 1.84891559e-02f, 9.61103812e-02f, -2.36175116e-02f, 1.26200244e-01f, 7.86966607e-02f,
  -1.46930680e-01f, 2.31693368e-02f, 1.52868181e-01f, -7.14972150e-03f, 2.74884850e-02f, 1.71061680e-02f, -2.56570689e-02f, 8.92972425e-02f, 7.13770688e-02f, -5.48304506e-02f,
  -1.15733556e-02f, -1.28199235e-01f, -1.04545556e-01f, 8.15551504e-02f, -7.02775568e-02f, -5.57130910e-02f, -6.20637871e-02f, -1.19940393e-01f, 8.65853205e-03f, -9.81216505e-03f,
  -7.39649162e-02f, 8.59103352e-02f, -8.55045989e-02f, 9.95627046e-02f, 7.08559528e-02f, -3.28247808e-02f, -2.48777680e-02f, 3.31835300e-02f, 5.47537431e-02f, -1.03879288e-01f,
  4.80840504e-02f, -6.06038049e-02f, 9.97612476e-02f, -4.99179922e-02f, -6.85265884e-02f, 3.01922821e-02f, 1.14143930e-01f, -9.78478324e-03f, 2.93929316e-02f, -1.20141283e-01f,
  1.48005513e-02f, -9.49674919e-02f, 1.09423183e-01f, -4.53062132e-02f, 1.19079061e-01f, -7.71399736e-02f, 6.71220652e-04f, -5.37209623e-02f, -1.00778654e-01f, 6.39382610e-03f,
  4.49670330e-02f, 5.85995279e-02f, 4.66783233e-02f, -4.73012403e-02f, 1.50213195e-02f, 9.73166246e-03f, 5.16634528e-03f, 5.34179062e-02f, 1.16969340e-01f, 1.03655495e-01f,
  6.40100911e-02f, -6.17328808e-02f, -7.58711770e-02f, 4.40150239e-02f, -1.06462792e-01f, 3.20980437e-02f, -3.94705124e-02f, 1.96929649e-02f, 2.44091470e-02f, -5.76195568e-02f,
  4.49512564e-02f, -3.26741003e-02f, 1.09433606e-01f, 7.05413818e-02f, 1.54996827e-01f, 1.89578295e-01f, 4.23160978e-02f, 3.51346731e-02f, 8.16494748e-02f, 1.89068571e-01f,
  9.94523242e-02f, -8.14576373e-02f, 1.12964720e-01f, 2.13190094e-01f, 5.88893816e-02f, 4.75032954e-03f, 2.51796156e-01f, 6.12062179e-02f, 1.83846101e-01f, 1.03857942e-01f,
  1.33343652e-01f, 1.69522136e-01f, -5.18265292e-02f, 9.85038951e-02f, -7.66088217e-02f, -8.12907815e-02f, 1.10976160e-01f, -1.40301719e-01f, -5.72767295e-02f, -2.52540648e-01f,
  7.95587152e-02f, 7.52726048e-02f, 1.63882487e-02f, 8.45773071e-02f, 4.87719942e-03f, 1.25152003e-02f, 1.77045465e-02f, 3.12037989e-02f, 9.20081958e-02f, -1.45522105e-02f,
  2.09701896e-01f, -3.96289490e-03f, 1.55227959e-01f, -3.65910567e-02f, 6.85763508e-02f, -7.21967816e-02f, 1.27020240e-01f, -1.60999596e-02f, 1.26572803e-01f, -7.88219273e-02f,
  -3.85043062e-02f, 1.59782901e-01f, -9.69897956e-02f, -5.44702299e-02f, -1.26891106e-01f, -1.05998330e-01f, -7.57229403e-02f, -8.32788050e-02f, 1.87925935e-01f, -3.76548357e-02f,
  1.20034747e-01f, -5.77992387e-02f, 4.14709467e-03f, 8.10468495e-02f, -5.67596965e-02f, -4.88009974e-02f, -8.94996375e-02f, -5.73498793e-02f, 4.92569916e-02f, -4.57165726e-02f,
  9.00441855e-02f, -1.07810706e-01f, 3.16832475e-02f, -4.94492725e-02f, 2.51426697e-02f, -3.23494226e-02f, 1.01163268e-01f, 4.03413549e-02f, -1.00777425e-01f, -7.81195313e-02f,
  9.75598395e-02f, -1.11896493e-01f, 8.88995752e-02f, 5.30219115e-02f, -4.17522117e-02f, 5.68037294e-02f, 1.16881490e-01f, -1.24623351e-01f, 1.04241721e-01f, -9.23798531e-02f,
  -1.12611175e-01f, 1.21143736e-01f, 1.13233507e-01f, 1.13112584e-01f, -1.16121791e-01f, -6.76820725e-02f, 1.13591144e-03f, -1.23016275e-01f, 1.24160632e-01f, -3.36031951e-02f,
  5.42652905e-02f, 3.40118483e-02f, 9.63912383e-02f, -4.03927900e-02f, -3.69148701e-03f, -7.43584782e-02f, -8.89737066e-03f, 7.33555332e-02f, 4.24901433e-02f, 1.54340435e-02f,
  1.21974282e-01f, -3.08593884e-02f, -8.26031417e-02f, -1.12552449e-01f, 7.85638019e-02f, -5.06137870e-02f, 2.64207926e-02f, -8.75947997e-02f, -7.80133456e-02f, 6.84131607e-02f,
  -5.37234321e-02f, -6.45569712e-02f, -8.97167847e-02f, -4.51270230e-02f, 5.22362776e-02f, -8.34345743e-02f, -9.10073519e-03f, -2.93361302e-03f, 7.81509727e-02f, 3.52563597e-02f,
  -8.45080316e-02f, -9.93483365e-02f, -3.67081203e-02f, 2.12739781e-02f, -3.09859533e-02f, -4.39971760e-02f, -1.18700348e-01f, 7.56221823e-03f, -5.03266342e-02f, 6.86620027e-02f,
  1.65944882e-02f, 7.45305121e-02f, 5.15441317e-03f, 1.22951325e-02f, -6.34748116e-02f, -1.13365546e-01f, -4.66328636e-02f, -9.59164649e-02f, -1.18447110e-01f, 3.04726511e-02f,
  -3.61934416e-02f, -2.08003819e-02f, -5.69519168e-03f, -1.23070970e-01f, -9.04415399e-02f, -8.63685645e-03f, -5.64737730e-02f, -9.96994749e-02f, -7.15198889e-02f, 6.03842810e-02f,
  -6.09175637e-02f, 5.36647476e-02f, -9.24236923e-02f, -1.01734567e-02f, -4.46601361e-02f, 2.07626540e-02f, 9.99325067e-02f, -9.23410878e-02f, 6.89014653e-03f, 7.99773932e-02f,
  1.99906714e-02f, 7.49062598e-02f, 9.61830765e-02f, -1.18782170e-01f, 2.50598434e-02f, 4.10041325e-02f, -7.93150440e-02f, 1.55023728e-02f, -5.83426543e-02f, 2.73646601e-02f,
  -3.08961980e-02f, -2.85638031e-02f, -4.91040871e-02f, 5.03490604e-02f, -1.04611419e-01f, -1.56187378e-02f, 1.26172155e-02f, -6.00002473e-03f, -5.39678745e-02f, -8.13611522e-02f,
  -1.17593994e-02f, -4.70361970e-02f, -5.97378723e-02f, -3.47251967e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  -8.23854730e-02f, 4.81701642e-02f, 1.44427955e-01f, 9.76311862e-02f, 4.76316214e-02f, -7.04083592e-02f, 4.07944173e-02f, 6.14338927e-02f, 1.99500218e-01f, 1.04602717e-01f,
  9.34628099e-02f, 7.89039806e-02f, 1.04336463e-01f, 1.86238527e-01f, 1.38173133e-01f, -2.88531110e-02f, 7.85301626e-02f, 3.24808545e-02f, -2.60089412e-02f, 7.30468705e-02f,
  1.65132701e-01f, -3.39498483e-02f, -1.17431149e-01f, 4.41539213e-02f, -9.53798965e-02f, 6.58745840e-02f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  3.48165669e-02f, -7.43963569e-02f, -1.20468751e-01f, 1.11736014e-01f, 4.07090969e-02f, -4.48382571e-02f, -9.40571949e-02f, -7.80537426e-02f, -1.88605990e-02f, -8.08801576e-02f,
  -4.59459834e-02f, -6.06878363e-02f, -4.54922207e-02f, -7.06667593e-03f, -1.03024475e-01f, 6.15148768e-02f, -7.05258027e-02f, -5.42557724e-02f, -8.18253905e-02f, -1.42997086e-01f,
  -4.55524959e-02f, 1.92472637e-01f, -6.73190579e-02f, 3.64546590e-02f, -1.53941840e-01f, -2.85062760e-01f, 6.85885772e-02f, 2.70949919e-02f, 2.00363785e-01f, 4.00887020e-02f,
  -4.93811667e-02f, -1.44934148e-01f, 2.89429557e-02f, 1.30141497e-01f, -5.77824675e-02f, 1.37673393e-01f, 7.48488307e-02f, 4.00455715e-03f, 6.17558025e-02f, -1.86499193e-01f,
  2.40292139e-02f, 1.83216989e-01f, 1.63057059e-01f, -7.72932842e-02f, 1.40489936e-01f, -3.98515724e-02f, 3.82267404e-03f, 1.74618252e-02f, -5.47300354e-02f, 9.50569361e-02f,
  4.57669385e-02f, -2.97926635e-01f, -1.70071289e-01f, 5.63530773e-02f, -1.39070079e-02f, -1.04306303e-01f, -9.53365415e-02f, 1.62918836e-01f, 1.29964411e-01f, -4.84443232e-02f,
  9.22479257e-02f, 1.59098804e-02f, -5.50803728e-03f, 1.21344022e-01f, -3.19026336e-02f, -1.64007209e-02f, 4.47486565e-02f, 1.48896962e-01f, 1.44452661e-01f, 9.38377157e-02f,
  7.18830526e-02f, 1.31572127e-01f, 4.50785756e-02f, 4.77768034e-02f, -7.63852568e-03f, 2.10235417e-01f, 1.08653463e-01f, -2.30750665e-02f, 1.49891153e-02f, 1.04883388e-01f,
  1.09315135e-01f, 2.47559440e-03f, 3.79180722e-02f, -4.43244092e-02f, 7.99770467e-03f, -9.50913224e-03f, 1.88141599e-01f, -1.83705706e-03f, -1.75164029e-01f, 1.22687615e-01f,
  1.38481706e-01f, -1.86565772e-01f, -8.13884735e-02f, 6.70806644e-03f, -4.83894236e-02f, -6.78827614e-02f, -2.07295239e-01f, -8.41196701e-02f, 1.21501133e-01f, 1.05762973e-01f,
  -3.44887823e-02f, -1.97819665e-01f, -3.13602649e-02f, 1.43562078e-01f, 1.44174293e-01f, 1.76192578e-02f, -1.39691129e-01f, 4.86701168e-02f, -1.01712614e-01f, -5.47219105e-02f,
  7.80212879e-02f, -1.12262882e-01f, -5.55453412e-02f, -1.06637381e-01f, 6.12691678e-02f, -1.14014499e-01f, -1.16329767e-01f, -1.16953766e-02f, 4.48994190e-02f, 8.39892998e-02f,
  2.78972313e-02f, 1.72000378e-01f, -1.70360640e-01f, -3.63318361e-02f, 2.31777392e-02f, 4.95217927e-02f, 2.73480359e-02f, 1.19641356e-01f, -2.09427308e-02f, 5.23760021e-02f,
  3.84361260e-02f, -1.07690163e-01f, -1.03445858e-01f, -9.15749744e-02f, -1.40225157e-01f, -1.48944005e-01f, 1.23466134e-01f, -1.41165163e-02f, -1.18249916e-01f, 1.59807608e-01f,
  -4.27329205e-02f, -2.42978651e-02f, -6.19713925e-02f, 1.35282502e-01f, -9.48692486e-02f, -2.54595634e-02f, 9.06352326e-02f, -1.86641961e-01f, -9.97006744e-02f, -2.09292188e-01f,
  -1.59691557e-01f, 2.03317598e-01f, 9.55800042e-02f, -9.62733477e-02f, -2.34257290e-03f, -1.21035285e-01f, 3.20698768e-02f, -7.06233084e-02f, -5.34953102e-02f, -6.55914694e-02f,
  -1.47848308e-01f, -1.31513923e-01f, -1.40465260e-01f, 1.01143986e-01f, 4.13296111e-02f, 2.83843607e-01f, 2.42531933e-02f, 8.13323632e-02f, -2.69178450e-01f, -3.43244150e-02f,
  -1.10349236e-02f, -2.95641553e-02f, 3.40634473e-02f, 6.30497113e-02f, 1.52799100e-01f, 1.26638755e-01f, -4.41967696e-02f, 1.33896127e-01f, 5.86344525e-02f, 2.67769434e-02f,
  -1.39504150e-01f, 7.88387551e-04f, -1.05141796e-01f, 4.65153530e-02f, -3.59660760e-03f, -9.03986841e-02f, 2.20440432e-01f, -1.69625759e-01f, -5.38157532e-03f, -1.25528127e-01f,
  -1.62060056e-02f, 9.61327106e-02f, 3.23657282e-02f, 8.80572421e-04f, -2.89492253e-02f, 4.95756939e-02f, 3.66447791e-02f, -1.45223916e-01f, -1.73799783e-01f, 1.16860149e-02f,
  -9.99628454e-02f, -1.57997504e-01f, 7.47515820e-04f, -2.25400692e-03f, -1.45899475e-01f, -1.04766995e-01f, -2.62731295e-02f, 2.39891969e-02f, 6.20833710e-02f, 5.47024757e-02f,
  -5.99881411e-02f, -5.73711246e-02f, 1.17286488e-01f, 2.13551626e-01f, 1.80144966e-01f, -1.11789957e-01f, -1.10549212e-01f, -2.24952742e-01f, 6.72168285e-02f, -8.14169943e-02f,
  6.49044104e-03f, -6.87064156e-02f, -1.03812799e-01f, -5.89332916e-02f, -5.99575453e-02f, 2.00940967e-01f, -3.81413624e-02f, 4.29194700e-03f, 8.25090855e-02f, -6.96622655e-02f,
  3.39087695e-02f, -1.71413928e-01f, -3.92062478e-02f, 2.27342963e-01f, 1.50491238e-01f, -2.41726674e-02f, 2.36005217e-01f, -5.78176454e-02f, 2.70216167e-02f, -1.29396394e-01f,
  8.71831551e-02f, -2.79601812e-02f, -1.02722667e-01f, -2.72196114e-01f, -5.97781874e-02f, 5.32898232e-02f, -5.23519516e-02f, -1.57756224e-01f, 1.69196725e-02f, 3.70157359e-04f,
  6.23939782e-02f, -8.78824443e-02f, 6.88750669e-02f, -1.01198696e-01f, -1.16164535e-02f, 8.07048008e-02f, 6.13211915e-02f, -1.17985541e-02f, 3.76936421e-02f, -1.78377249e-03f,
  -2.48358417e-02f, 3.53687890e-02f, 5.58335297e-02f, 7.39529654e-02f, 2.49991473e-02f, -1.29108801e-01f, -1.94851905e-02f, 1.63362622e-01f, 9.88781601e-02f, -1.33149609e-01f,
  1.27079159e-01f, 3.86120677e-02f, -7.05183521e-02f, -8.22740346e-02f, 4.11548279e-02f, -3.36092114e-02f, -1.11738972e-01f, -2.69882213e-02f, -1.90056823e-02f, 2.15911224e-01f,
  -1.33682162e-01f, -1.15722053e-01f, 1.05742581e-01f, -1.76375583e-01f, 1.36463627e-01f, 4.69551943e-02f, -7.70197734e-02f, 8.40303302e-03f, 2.04704143e-02f, -2.53673065e-02f,
  -6.26469702e-02f, 1.51669994e-01f, -1.90507025e-01f, 1.36753067e-01f, -1.06676683e-01f, 2.56281309e-02f, -1.75931320e-01f, -8.25349092e-02f, -9.83519107e-02f, -1.00465260e-01f,
  -2.74438225e-02f, 9.24869964e-04f, 2.12751612e-01f, -5.80778830e-02f, -8.17795023e-02f, 1.32932201e-01f, 8.60144570e-02f, -4.77217361e-02f, -7.41550922e-02f, -1.34709463e-01f,
  9.03758779e-02f, 8.97493735e-02f, 7.14764968e-02f, -1.10831760e-01f, 1.07589781e-01f, -1.32735282e-01f, 9.65785459e-02f, -3.99220958e-02f, 1.22443698e-01f, -2.17944589e-02f,
  1.23206057e-01f, -9.63843018e-02f, 1.46248072e-01f, 9.13456024e-05f, -1.27787918e-01f, -3.03003620e-02f, 1.66066036e-01f, -4.94239032e-02f, 3.11879646e-02f, 4.96288650e-02f,
  -8.86450112e-02f, 2.59814486e-02f, -6.86055003e-03f, 6.75013214e-02f, -9.23407301e-02f, -4.44353092e-03f, -3.39226946e-02f, -9.61675793e-02f, 8.01005363e-02f, -7.53784403e-02f,
  -1.26687959e-02f, -3.69060002e-02f, -7.17788637e-02f, 9.27858204e-02f, -1.19938716e-01f, -6.39546849e-03f, 1.17739886e-01f, -1.69717461e-01f, -2.10576262e-02f, -3.79243568e-02f,
  1.92297399e-02f, -1.17383391e-01f, -2.20089957e-01f, 4.66933511e-02f, -5.75474463e-02f, 4.07664804e-03f, -5.84864663e-03f, 4.51511666e-02f, 1.13643914e-01f, 7.21059069e-02f,
  -4.73949127e-03f, -3.63465548e-02f, -2.73062475e-02f, -1.04144379e-01f, -1.78949118e-01f, -7.97603130e-02f, 2.44360566e-02f, 3.17559019e-02f, 4.16036919e-02f, -9.62152034e-02f,
  5.23743927e-02f, 1.47387728e-01f, -4.39988822e-02f, -1.51764631e-01f, -1.21229447e-01f, 7.51877725e-02f, -2.79475306e-03f, -7.41021261e-02f, 1.19983271e-01f, -1.92248151e-01f,
  4.27880976e-03f, 1.24344833e-01f, 4.30237725e-02f, -3.37427040e-03f, 3.29408124e-02f, 5.49186468e-02f, -2.86726337e-02f, -4.12766114e-02f, 3.79496515e-02f, -3.97567302e-02f,
  3.69880237e-02f, -6.28195331e-02f, 3.05076782e-02f, -4.61499058e-02f, 8.63141716e-02f, 1.59898996e-01f, 7.70776197e-02f, -7.88757354e-02f, -8.54836628e-02f, -1.31122604e-01f,
  -1.53517360e-02f, -5.64500317e-02f, 6.46258891e-02f, 9.53127518e-02f, -6.50678501e-02f, -1.23136155e-01f, 6.73080385e-02f, 5.18844509e-03f, -2.01276923e-03f, 2.22750142e-01f,
  -4.43952382e-02f, -9.25028399e-02f, -5.34987636e-02f, -4.01474610e-02f, 5.68237342e-02f, 6.65769428e-02f, -1.28891423e-01f, -2.98999786e-01f, 1.01435468e-01f, -9.10542533e-02f,
  1.33312717e-01f, 3.19185704e-02f, -5.33080362e-02f, 1.11884430e-01f, -6.25866577e-02f, -1.32988662e-01f, -1.47358671e-01f, -1.22149520e-01f, -2.13536426e-01f, -2.79725716e-02f,
  2.00542659e-02f, 1.23379163e-01f, 1.12691313e-01f, -1.63570032e-01f, 2.62194667e-02f, 2.69001871e-02f, 1.17095366e-01f, -5.09206131e-02f, -8.88025165e-02f, -1.97178498e-01f,
  -6.12683371e-02f, -1.26846775e-01f, 9.75519642e-02f, 3.41970511e-02f, 3.69761959e-02f, 1.70608699e-01f, 9.51542184e-02f, -7.78792724e-02f, 1.37180820e-01f, 8.04294497e-02f,
  5.19226231e-02f, 1.63218230e-01f, 4.21585441e-02f, 9.13136601e-02f, -1.39979899e-01f, 8.51269737e-02f, 6.84775412e-02f, 3.06372326e-02f, -3.93323749e-02f, 6.62033483e-02f,
  -1.81522027e-01f, -8.16581249e-02f, 3.78638953e-02f, 1.51350692e-01f, 7.58842602e-02f, -1.55175542e-02f, 5.49250981e-03f, -1.83678314e-01f, 7.16326013e-03f, -5.14546083e-03f,
  -2.68128719e-02f, -9.85144526e-02f, -2.07306966e-01f, -2.32839465e-01f, 9.50656980e-02f, -1.81058526e-01f, 1.25181749e-01f, 1.76143229e-01f, -1.17589474e-01f, -2.45796833e-02f,
  -6.26748726e-02f, 1.69143453e-01f, 3.52597088e-02f, 1.48238286e-01f, -6.64028972e-02f, -1.69455912e-02f, -8.68455395e-02f, -1.12033337e-01f, -7.21878931e-02f, 8.38134661e-02f,
  8.78372863e-02f, 1.64873563e-02f, 1.25931144e-01f, -5.87834530e-02f, 1.73316717e-01f, -9.11531784e-03f, -1.84324998e-02f, 2.16358081e-01f, 1.48963491e-02f, -1.38274599e-02f,
  -1.88122272e-01f, -1.33490905e-01f, -1.02375954e-01f, 2.46674061e-01f, -1.09293997e-01f, 7.27632269e-02f, 1.41988054e-01f, -1.08360827e-01f, -6.37411103e-02f, -1.22370519e-01f,
  4.26717438e-02f, -8.23791251e-02f, -9.29897428e-02f, -2.32961141e-02f, 9.44083780e-02f, 1.58670112e-01f, 8.51376206e-02f, -5.01405299e-02f, 1.31852299e-01f, -8.12423378e-02f,
  1.26421705e-01f, -7.30012506e-02f, -3.67827676e-02f, 2.76982695e-01f, 7.85849690e-02f, 6.58253580e-02f, 1.07108027e-01f, 1.59795191e-02f, 6.93883002e-02f, -3.24553996e-02f,
  -6.35059699e-02f, 9.79782082e-03f, -6.45354241e-02f, -1.87260136e-01f, 1.20477285e-02f, 1.55707777e-01f, -8.97868723e-02f, -3.65440510e-02f, 1.44572467e-01f, -1.03996895e-01f,
  -9.39327553e-02f, -4.65415232e-03f, 7.61335418e-02f, 9.69935432e-02f, -1.59136653e-01f, -1.76364839e-01f, 1.57629967e-01f, 1.01947121e-01f, -3.67094949e-02f, 3.36220637e-02f,
  -3.27227861e-02f, 9.72514078e-02f, 9.23980679e-03f, -4.74870689e-02f, -1.21774644e-01f, 9.95309427e-02f, -1.53325066e-01f, -8.27713236e-02f, 1.87863261e-02f, 8.43695253e-02f,
  5.87023795e-02f, -1.15032151e-01f, -3.02052498e-03f, 1.09565422e-01f, 1.45214006e-01f, -3.92212234e-02f, -4.66058441e-02f, -1.15068130e-01f, 2.00557243e-03f, -1.11215100e-01f,
  1.15291383e-02f, -6.60110787e-02f, 1.19278923e-01f, 1.42145440e-01f, -1.02613531e-02f, -8.70555174e-03f, -9.73557606e-02f, 9.73441601e-02f, -9.57185403e-02f, -6.29031584e-02f,
  9.01736543e-02f, 3.47757083e-03f, -1.22164913e-01f, -4.90349792e-02f, -6.78308085e-02f, -8.55123699e-02f, -6.07139315e-04f, 1.27611995e-01f, -2.19562456e-01f, -9.82172936e-02f,
  -1.15844132e-02f, 1.36120766e-01f, 8.79712403e-02f, -8.91255066e-02f, 1.35420337e-01f, -3.19100656e-02f, 1.27269864e-01f, -4.24300805e-02f, -5.02722040e-02f, -6.02168702e-02f,
  -1.06227092e-01f, -1.86911598e-01f, -3.15767005e-02f, -3.36567126e-02f, 1.16196990e-01f, 1.82948224e-02f, -9.46418270e-02f, -1.04033567e-01f, -1.27241239e-01f, -4.22347002e-02f,
  -9.57965255e-02f, 1.51887402e-01f, 7.32760653e-02f, 1.77597657e-01f, 4.57728915e-02f, 6.61948845e-02f, -1.83501139e-01f, 1.24018699e-01f, 4.77297716e-02f, -9.39592049e-02f,
  1.56176433e-01f, 6.09540520e-03f, 2.14593843e-01f, 9.86425802e-02f, 9.46673378e-03f, 1.65450960e-01f, -1.25624016e-01f, -1.44054815e-01f, -2.57069498e-01f, -1.54749691e-01f,
  7.59538636e-02f, 1.27425939e-01f, 1.70859247e-02f, -7.31276944e-02f, 1.45906672e-01f, -1.37182653e-01f, 1.18061669e-01f, -1.43104091e-01f, 9.59075242e-02f, 2.93026883e-02f,
  -5.85045442e-02f, -1.63856465e-02f, -5.50329015e-02f, -3.08775920e-02f, -1.06548198e-01f, -7.80854933e-03f, 2.65464507e-04f, -5.16526587e-02f, -5.60028926e-02f, 1.85624342e-02f,
  -8.52167383e-02f, -2.24292904e-01f, 7.01623857e-02f, 4.00724337e-02f, 1.23620719e-01f, -1.58158675e-01f, -5.53382002e-02f, -9.49603245e-02f, -1.27885580e-01f, -7.41664902e-04f,
  2.70186720e-04f, 8.77875611e-02f, 4.66878340e-02f, -2.92159449e-02f, -6.41922802e-02f, -2.45102327e-02f, 4.71116714e-02f, 1.21852666e-01f, -9.23628286e-02f, 2.57329457e-02f,
  4.00487613e-03f, -1.25550196e-01f, 2.56447643e-01f, 1.53565183e-01f, -7.77263567e-02f, 2.88073458e-02f, 6.83690906e-02f, 1.55146658e-01f, -9.39661488e-02f, 1.55985625e-02f,
  1.62816301e-01f, 9.60292295e-02f, 1.10869199e-01f, 5.27291559e-03f, 2.41407976e-01f, -1.70348249e-02f, -2.25184217e-01f, 1.01314224e-02f, -1.01786137e-01f, -1.28454622e-02f,
  8.78999084e-02f, -1.91416207e-03f, -1.93158150e-01f, 3.45223285e-02f, 5.79779893e-02f, 1.04307353e-01f, -1.34093285e-01f, 1.59044027e-01f, -6.08920678e-02f, -6.93291798e-02f,
  -4.49644104e-02f, -2.93249190e-02f, -2.97213793e-02f, 2.64961366e-02f, -2.65901610e-02f, 1.14293672e-01f, 9.71669629e-02f, -3.53314802e-02f, -5.79220392e-02f, 2.15237066e-01f,
  -4.50577550e-02f, 8.62891227e-02f, -1.29957357e-02f, -3.49840820e-02f, -5.04348278e-02f, -2.70267352e-02f, -5.64558506e-02f, -1.23733670e-01f, 3.04196663e-02f, -2.76748813e-03f,
  -7.13778511e-02f, -1.94210067e-01f, 8.94099548e-02f, -1.27684936e-01f, -7.10539669e-02f, 1.32408943e-02f, -1.28263384e-01f, 1.50191352e-01f, 1.24331564e-01f, 4.06682901e-02f,
  3.00988834e-02f, -1.78319607e-02f, 1.78580388e-01f, -8.29449669e-02f, -1.36294931e-01f, -3.46328840e-02f, -3.98625471e-02f, 1.72170866e-02f, 5.89799471e-02f, 1.52693763e-02f,
  -1.24533184e-01f, 2.56091028e-01f, 3.46404761e-02f, -2.36244872e-02f, -1.08152673e-01f, -2.55038142e-02f, -2.98122000e-02f, -2.57807951e-02f, 8.87111649e-02f, -1.18250968e-02f,
  -7.47940987e-02f, -1.91529226e-02f, 2.99368855e-02f, 2.30884403e-02f, 1.24884382e-01f, -8.07621852e-02f, -1.76700547e-01f, -1.61733046e-01f, -7.26522356e-02f, 3.09424400e-01f,
  -1.37654096e-02f, -1.57124877e-01f, 2.06426963e-01f, -1.35907769e-01f, 5.72791919e-02f, -4.04522680e-02f, 4.50495817e-03f, -1.04185387e-01f, -1.41811207e-01f, -1.06441922e-01f,
  1.60411056e-02f, 1.88607704e-02f, -1.98767707e-02f, -6.88700378e-02f, -8.60863850e-02f, -1.73290335e-02f, 6.09253272e-02f, -3.03322338e-02f, 1.32994995e-01f, 1.56560302e-01f,
  -2.34440174e-02f, 1.20671049e-01f, -2.79851519e-02f, -3.03749032e-02f, -1.54140294e-02f, 6.52002394e-02f, 5.89994043e-02f, -4.52825651e-02f, -1.35462433e-01f, -1.34438992e-01f,
  -1.39207870e-01f, 5.30365668e-02f, 9.57088545e-02f, 1.87239721e-01f, -9.19121280e-02f, -5.95462024e-02f, -1.92171872e-01f, -2.04358324e-01f, 1.72305673e-01f, 1.08688682e-01f,
  -1.36211976e-01f, -2.91938901e-01f, -1.30074888e-01f, -1.58870593e-01f, 1.73764274e-01f, 1.61039203e-01f, 8.56731161e-02f, 3.51725891e-02f, -8.81661177e-02f, -1.99955493e-01f,
  1.01310126e-01f, 1.04499850e-02f, -1.48126826e-01f, 6.68436810e-02f, -1.06210068e-01f, -1.78119019e-02f, 9.51347202e-02f, 6.35303855e-02f, 8.56317021e-03f, 1.24587610e-01f,
  1.53354496e-01f, 1.45365773e-02f, 4.31644842e-02f, -8.89809523e-03f, -1.32552370e-01f, -1.39909536e-01f, 1.57880727e-02f, -8.56630355e-02f, -1.63630042e-02f, -3.98482569e-03f,
  5.11914901e-02f, -5.20369299e-02f, -6.68993145e-02f, -6.31908104e-02f, 1.30706921e-01f, 1.20539099e-01f, -5.85319139e-02f, -1.67835038e-02f, -7.92212114e-02f, 8.00187066e-02f,
  1.61384091e-01f, 1.66176558e-01f, 1.20155975e-01f, -5.73875867e-02f, 1.08241834e-01f, 1.05610058e-01f, 1.33632690e-01f, 8.79943967e-02f, 8.92968401e-02f, -8.25194791e-02f,
  7.93692842e-02f, 2.15367630e-01f, 1.10536993e-01f, -2.44096220e-02f, -8.81170970e-04f, 8.79944339e-02f, 9.76395756e-02f, 3.06128114e-02f, -7.03388229e-02f, 1.74340159e-01f,
  -5.61167337e-02f, 5.78361843e-03f, -1.38657451e-01f, 1.49328413e-03f, 2.25992426e-02f, -6.69348836e-02f, 1.76511388e-02f, -1.77881196e-01f, -8.72996300e-02f, -1.14486646e-03f,
  1.41589433e-01f, 6.17342032e-02f, 1.32784516e-01f, -1.65581644e-01f, -5.34259789e-02f, -4.70093004e-02f, 1.22350693e-01f, -1.45956259e-02f, -1.73138693e-01f, 5.49269170e-02f,
  8.68237168e-02f, -1.12134010e-01f, -7.06135407e-02f, 6.15885407e-02f, -3.16402651e-02f, -6.70454353e-02f, -5.28700426e-02f, 1.15684442e-01f, 1.32167771e-01f, -5.80166504e-02f,
  -7.81783611e-02f, 1.55382633e-01f, -3.22937556e-02f, -2.09936630e-02f, -1.11263163e-01f, -1.70018338e-02f, -1.51886672e-01f, 1.02509193e-01f, 4.69225645e-02f, 4.80487086e-02f,
  -5.77032901e-02f, -5.91515116e-02f, 2.61230450e-02f, 1.96803212e-02f, 3.30187380e-02f, -2.81757768e-02f, -3.74043174e-02f, -4.32261676e-02f, 4.98148799e-02f, -4.84353804e-04f,
  -4.01233397e-02f, 4.64977436e-02f, -6.51359279e-03f, 5.03090359e-02f, 3.45384628e-02f, 1.26068303e-02f, -1.12781383e-01f, -2.07486078e-01f, -8.49973634e-02f, -4.09483016e-02f,
  2.24405557e-01f, 2.61527061e-01f, -3.58182751e-02f, 8.75637904e-02f, -1.43888429e-01f, 3.02053429e-03f, -1.27843112e-01f, 3.19681391e-02f, -3.78382467e-02f, -8.55748430e-02f,
  -6.72694892e-02f, -1.70046076e-01f, -1.17939441e-02f, -5.30887544e-02f, -1.46033755e-02f, 8.23167861e-02f, 1.67679191e-02f, -6.01572655e-02f, -1.85924068e-01f, 2.63023078e-02f,
  -1.19023070e-01f, 6.81807697e-02f, -1.94194973e-01f, -1.19869612e-01f, -8.56089313e-03f, -1.99235663e-01f, 4.68922500e-03f, 2.28714481e-01f, 1.96823314e-01f, 4.35825139e-02f,
  1.76072828e-02f, -1.33761659e-03f, 1.35290667e-01f, -2.12819070e-01f, -9.60641503e-02f, -7.25363195e-02f, 8.52930844e-02f, 1.39912590e-01f, -6.19689710e-02f, 3.30262333e-02f,
  2.46784254e-03f, -8.98100808e-02f, -1.00659668e-01f, 2.44331616e-03f, -1.13909312e-01f, 1.65506274e-01f, -1.01360574e-01f, 7.61375800e-02f, 1.19310446e-01f, 6.69835955e-02f,
  -1.10629447e-01f, -7.79180378e-02f, -8.86334777e-02f, -1.28522977e-01f, 1.11914270e-01f, 6.39248490e-02f, -5.21118678e-02f, 1.26891490e-02f, 3.11909020e-02f, -1.35662658e-02f,
  -1.46129325e-01f, 8.04746076e-02f, -2.05870762e-01f, 1.17288888e-01f, 2.47287244e-01f, 2.80880332e-02f, -6.29443377e-02f, 1.56117469e-01f, 8.18996727e-02f, -1.33864954e-01f,
  -5.17366119e-02f, 8.81775916e-02f, 1.02205880e-01f, -2.32221901e-01f, -1.46181956e-01f, -1.44919440e-01f, -5.76854497e-02f, 2.27085173e-01f, -2.17791907e-02f, 1.23239644e-01f,
  7.15462193e-02f, -2.43064880e-01f, -2.24689081e-01f, 1.06693983e-01f, -1.47230729e-01f, -3.03729828e-02f, -1.22978918e-01f, 6.00524805e-03f, 8.25475156e-03f, 8.62813368e-02f,
  -9.78096575e-02f, 2.35154659e-01f, 2.47353956e-01f, -9.71939266e-02f, 2.94558760e-02f, 4.97516012e-03f, -5.25247864e-02f, 5.40970974e-02f, -4.36777845e-02f, 6.72887564e-02f,
  -8.35337937e-02f, 1.06439926e-02f, -5.67233302e-02f, 2.88743209e-02f, -4.42652265e-03f, -1.86505411e-02f, 3.12220063e-02f, 3.33391801e-02f, -5.21010812e-03f, -6.02675714e-02f,
  -1.71790421e-01f, -5.13132028e-02f, 7.99969828e-04f, -6.54087141e-02f, 1.60027474e-01f, -1.66523248e-01f, -1.69615969e-01f, 7.50126764e-02f, 6.80176467e-02f, -1.38745993e-01f,
  4.22392786e-02f, 1.07635304e-01f, -2.27018315e-02f, -1.20150030e-01f, -9.49027613e-02f, 5.98043650e-02f, -1.06318697e-01f, 6.53565116e-03f, 1.46871179e-01f, -2.28089780e-01f,
  -5.42842932e-02f, 1.71870306e-01f, 1.26868829e-01f, -1.15435570e-01f, -1.69002429e-01f, 4.08947058e-02f, 7.71886110e-02f, 3.08015049e-02f, -7.22217485e-02f, -1.35911405e-01f,
  -5.06832749e-02f, 2.08053738e-01f, 4.13927063e-03f, -5.07997274e-02f, -9.73667875e-02f, 6.27834862e-03f, 6.72976598e-02f, 9.62184295e-02f, 2.26270288e-01f, 1.99308563e-02f,
  -1.04423448e-01f, 1.78705096e-01f, 8.66116136e-02f, 1.40617535e-01f, -1.10253364e-01f, -1.45823300e-01f, -2.10996017e-01f, -6.26663864e-02f, -3.24980579e-02f, 2.12527961e-01f,
  -1.23098314e-01f, 4.62680236e-02f, 1.18742488e-01f, 2.00600084e-02f, -1.18108533e-01f, 5.08653596e-02f, 1.15388066e-01f, -2.00904603e-03f, 2.47648042e-02f, -7.34576806e-02f,
  -1.82188600e-01f, -2.86368877e-02f, -1.30726593e-02f, -1.64697498e-01f, -2.56640941e-01f, 8.83352086e-02f, 2.54072770e-02f, -1.54056028e-01f, 7.63134137e-02f, -5.26219644e-02f,
  -1.65175810e-01f, 3.02948784e-02f, -1.66308209e-01f, -1.33803204e-01f, -1.01025142e-01f, 3.65137719e-02f, 7.69118890e-02f, -2.11886510e-01f, -8.68245959e-02f, -9.35947299e-02f,
  6.01745509e-02f, 5.82283251e-02f, -1.13226004e-01f, -1.75770625e-01f, -1.28944233e-01f, 6.74650520e-02f, 1.81166048e-03f, -1.83255672e-01f, 1.40293203e-02f, -8.28182772e-02f,
  4.18668874e-02f, -4.55048634e-03f, -3.29923369e-02f, -8.81322846e-02f, 1.62406847e-01f, -5.54022491e-02f, -2.42899098e-02f, -1.47444800e-01f, 7.47081218e-03f, 1.15281053e-01f,
  1.51930109e-01f, 3.27752233e-02f, -2.06647180e-02f, 6.51011989e-02f, 2.21211463e-02f, 1.05387494e-01f, 8.36157352e-02f, 2.53496289e-01f, -4.12328355e-02f, -2.20543116e-01f,
  4.13527116e-02f, -8.25784281e-02f, 3.24761569e-02f, -1.81943513e-02f, 2.70830635e-02f, -8.89481530e-02f, 1.50283754e-01f, -1.06943332e-01f, 2.84301024e-02f, 3.65704708e-02f,
  2.73261350e-02f, 9.04788524e-02f, 2.34370474e-02f, 1.31478444e-01f, 1.32799894e-01f, -7.54665881e-02f, 5.68265617e-02f, -8.73337910e-02f, 9.85003542e-03f, -1.29030749e-01f,
  -7.82024339e-02f, -3.41080055e-02f, 2.54615191e-02f, 1.31818622e-01f, -7.31216073e-02f, 8.11567008e-02f, 3.46192531e-02f, 1.20153479e-01f, -9.84727666e-02f, -5.00764400e-02f,
  1.29321124e-02f, 9.19401124e-02f, 2.64601577e-02f, 1.39953017e-01f, -4.52599302e-02f, -1.25411168e-01f, -3.54662910e-02f, -1.55585604e-02f, 8.40205997e-02f, -1.84560586e-02f,
  -4.24654130e-03f, 1.31617871e-03f, -6.85753077e-02f, -3.64902243e-02f, -1.44538820e-01f, -8.11201632e-02f, -2.72372477e-02f, 9.40533951e-02f, 3.30440030e-02f, -7.34934956e-02f,
  -6.09260611e-02f, -3.80577669e-02f, 1.61749139e-01f, 9.46402084e-03f, 1.03591628e-01f, -8.54350403e-02f, -1.18541032e-01f, 7.23186657e-02f, 9.75228697e-02f, -4.17601094e-02f,
  2.78445389e-02f, -2.01092914e-01f, -1.17409974e-01f, 8.80315602e-02f, 1.01020969e-01f, 1.39159307e-01f, 7.49194622e-02f, -7.55731910e-02f, 1.45594478e-01f, 1.17368139e-01f,
  -2.03180104e-01f, 5.75560294e-02f, 7.50704408e-02f, 1.15456477e-01f, 6.71133026e-02f, -1.45657882e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  2.54943550e-01f, 1.30625576e-01f, 1.12571709e-01f, 1.38184696e-01f, 6.99624866e-02f, 2.69225389e-01f, 1.25377387e-01f, 1.51446253e-01f, 7.84295052e-03f, 4.50938642e-02f,
  2.53901854e-02f, 2.96596497e-01f, -4.47376482e-02f, 8.82911235e-02f, 1.59156397e-01f, 2.29965463e-01f, -4.34550494e-02f, -5.85691370e-02f, 2.65039086e-01f, -2.30239153e-01f,
  -5.49432710e-02f, -3.87445949e-02f, 9.60188881e-02f, 8.02697986e-02f, -2.34387279e-01f, -2.95637697e-01f, 2.14778513e-01f, -2.89707750e-01f, 2.76713997e-01f, 2.06445187e-01f,
  -2.68592983e-02f, -6.31155819e-02f, -1.06775448e-01f, 2.47691467e-01f, 1.43078431e-01f, 4.24876034e-01f, -2.90701985e-01f, 8.09133425e-02f, -9.73955542e-02f, 2.19216704e-01f,
  1.03267126e-01f, 3.94991636e-01f, 8.92068446e-02f, -3.66968401e-02f, 2.57077783e-01f, 8.40749964e-02f, 3.94248813e-01f, -9.10862833e-02f, -3.00567262e-02f, 1.32702678e-01f,
  6.67577162e-02f, 1.78632990e-01f, -1.92502707e-01f, 1.52285904e-01f, -5.99684045e-02f, 2.79686481e-01f, 7.72909001e-02f, 8.73996764e-02f, 5.33918366e-02f, -7.44841620e-02f,
  -1.14242315e-01f, -3.22925784e-02f, 9.28861126e-02f, -2.21261345e-02f, 9.21749622e-02f, -8.98917392e-02f, -1.15100086e-01f, -1.32800847e-01f, -5.52979521e-02f, 8.60995278e-02f,
  -6.79891407e-02f, 1.03589885e-01f, -5.34423161e-03f, -6.57529607e-02f, -2.65798401e-02f, 1.59033053e-02f, 7.95263201e-02f, -7.55678117e-02f, -9.18429270e-02f, -1.13772474e-01f,
  -8.16029906e-02f, -9.21648145e-02f, -1.29662126e-01f, -6.45191297e-02f, 1.01168431e-01f, 7.66001865e-02f, -5.14726937e-02f, 7.06754625e-02f, 8.86086524e-02f, 2.51078177e-02f,
  -1.08856298e-01f, -7.83366561e-02f, 1.01451084e-01f, 6.35827109e-02f, -1.84787940e-02f, -1.11759543e-01f, 3.63260247e-02f, -1.17791936e-01f, -9.96139720e-02f, 7.52189755e-02f,
  5.83802871e-02f, -4.79973890e-02f, -6.70616850e-02f, -1.17971994e-01f, 7.61953890e-02f, 8.92066061e-02f, 5.24186436e-03f, -3.63562331e-02f, -2.94430014e-02f, -4.08090688e-02f,
  -6.56239614e-02f, -8.13740715e-02f, 2.83830483e-02f, -1.31576687e-01f, -9.62633640e-02f, -1.03260733e-01f, -7.30457827e-02f, -6.63361698e-02f, 1.16618155e-02f, 3.98391411e-02f,
  3.55440974e-02f, 8.40210542e-02f, -2.22896785e-02f, 4.95662168e-02f, 4.99993823e-02f, -7.54831880e-02f, 5.77708595e-02f, 1.22122750e-01f, 7.41197392e-02f, 8.64816308e-02f,
  3.71949971e-02f, -6.22952655e-02f, -6.19898438e-02f, 1.22685377e-02f, -5.02515305e-03f, -1.14976108e-01f, 9.93761867e-02f, 6.27950579e-02f, 6.94928095e-02f, -5.04733995e-02f,
  -6.47176281e-02f, -1.22106515e-01f, -6.06367588e-02f, -8.44577402e-02f, -1.29844233e-01f, -8.11518133e-02f, -1.12672478e-01f, -2.03865245e-02f, -6.24537505e-02f, 1.17163986e-01f,
  1.34735093e-01f, 1.78571194e-02f, 6.94645122e-02f, 4.71756235e-02f, 9.62257162e-02f, 5.70457689e-02f, 8.44185650e-02f, 7.33561963e-02f, 3.01007610e-02f, 1.09149821e-01f,
  9.48278382e-02f, -1.78416856e-02f, -4.32302319e-02f, -5.17318910e-03f, -6.20020926e-02f, 2.48189624e-02f, 9.69431698e-02f, 1.14955351e-01f, 1.52866151e-02f, 1.50395110e-02f,
  -1.21619470e-01f, 2.26326529e-02f, -3.56433243e-02f, 7.13458136e-02f, 1.07981674e-01f, 6.48398623e-02f, 4.69461642e-02f, 9.53472778e-02f, 2.65805796e-02f, 2.34319340e-03f,
  9.36144516e-02f, 1.00540929e-01f, -7.82523379e-02f, -1.46625936e-01f, 7.50754634e-03f, -7.43161887e-02f, 1.07773520e-01f, 3.11953463e-02f, 1.10280298e-01f, -1.11266099e-01f,
  -8.73775035e-02f, -2.52710376e-02f, -3.70839499e-02f, 1.56267539e-01f, -1.66277528e-01f, 5.73700219e-02f, 8.70374888e-02f, 8.51603225e-02f, -1.89186752e-01f, 2.12884590e-01f,
  2.20241815e-01f, -7.95629546e-02f, 5.89865744e-02f, -6.73020119e-03f, -1.65721640e-01f, 4.77568507e-02f, 1.02886863e-01f, 1.45186856e-01f, 2.04742447e-01f, 1.69577822e-01f,
  2.09382743e-01f, -1.77184179e-01f, 1.72482133e-01f, 3.16900790e-01f, -2.26325057e-02f, -4.64200601e-02f, -5.60713038e-02f, -2.34684959e-01f, -1.06654756e-01f, -1.59223810e-01f,
  9.57651362e-02f, 2.21213363e-02f, -2.52318591e-01f, -4.80926521e-02f, 1.53270468e-01f, 2.65950680e-01f, 3.43139060e-02f, 1.43942550e-01f, -8.17180574e-02f, 1.44977182e-01f,
  1.79111809e-02f, 9.52685345e-03f, 2.93811679e-01f, 1.59333184e-01f, 1.77689269e-01f, -6.45358637e-02f, 5.69492221e-01f, -8.60416051e-03f, 5.01655824e-02f, 1.87334083e-02f,
  7.36663863e-02f, 3.22405398e-01f, 1.32170945e-01f, -1.93691120e-01f, 2.21809894e-02f, 2.93047279e-01f, 1.40761718e-01f, 2.20245928e-01f, 5.50316535e-02f, 3.93353939e-01f,
  1.54425710e-01f, 2.57860273e-01f, -1.11110024e-01f, -2.14410961e-01f, -5.90588562e-02f, 8.67334604e-02f, -9.36809480e-02f, 2.83125695e-02f, -1.26616150e-01f, -3.64166079e-03f,
  8.56467113e-02f, -5.54387309e-02f, -1.24561504e-01f, 9.24034640e-02f, 1.23429552e-01f, 4.67795543e-02f, -9.51297116e-03f, -1.39202088e-01f, -1.05634160e-01f, -4.69715036e-02f,
  4.92890216e-02f, 8.12133402e-02f, -1.84617285e-02f, 1.29724085e-01f, -1.26755074e-01f, 1.58618242e-02f, 1.81568768e-02f, 2.67575756e-02f, -1.39400169e-01f, -2.63476204e-02f,
  6.88128844e-02f, -1.27893761e-02f, 4.46110032e-02f, -4.19131741e-02f, 7.02783391e-02f, -4.98157367e-02f, 2.42644362e-02f, 4.10034359e-02f, 2.04106063e-01f, 8.81592929e-02f,
  4.78972793e-02f, -1.60525739e-01f, 1.40310079e-01f, 9.71234068e-02f, 8.71475711e-02f, -7.29183108e-02f, 1.11695148e-01f, -1.34675443e-01f, 6.06103204e-02f, -7.11198673e-02f,
  2.53080130e-01f, 3.95924831e-03f, -1.40068859e-01f, -2.95473579e-02f, -3.82150859e-02f, -1.94365773e-02f, 4.60745841e-02f, 8.37574899e-02f, -1.43698379e-02f, -8.74230713e-02f,
  2.04479173e-02f, 6.34761080e-02f, -9.72501487e-02f, 1.70865059e-02f, 5.73456176e-02f, 1.52986437e-01f, 4.52639423e-02f, -1.20770015e-01f, 3.03025804e-02f, 2.25911029e-02f,
  1.19829990e-01f, -5.68834804e-02f, 7.47306719e-02f, 5.20386035e-03f, -7.56325871e-02f, 1.22734949e-01f, 1.26925543e-01f, -6.09789789e-02f, -9.32124779e-02f, -7.17607290e-02f,
  -8.68184566e-02f, 2.75361873e-02f, -5.21200616e-03f, -1.76668037e-02f, 7.99073577e-02f, -5.28661273e-02f, -4.48679291e-02f, -7.97305107e-02f, 1.05593786e-01f, 6.79428875e-02f,
  -1.80247854e-02f, -8.27488601e-02f, 1.11981537e-02f, -2.67202612e-02f, -1.72773171e-02f, 8.04611593e-02f, 6.33818656e-02f, -4.22144867e-03f, -3.83110158e-02f, 7.03928992e-02f,
  -9.53890830e-02f, -4.36384417e-02f, -7.16184154e-02f, -8.96423608e-02f, -1.31734349e-02f, -4.60905023e-02f, 1.73377059e-02f, 5.86804636e-02f, 4.15855609e-02f, -1.63594770e-04f,
  -4.78246659e-02f, 6.03338368e-02f, -1.09669201e-01f, 1.08913727e-01f, 5.52497320e-02f, -5.99864721e-02f, 2.30510090e-03f, -1.16681866e-01f, -1.22828018e-02f, 6.50683716e-02f,
  -4.94016074e-02f, 1.62094116e-01f, 3.73566970e-02f, 4.75396402e-03f, -1.03356548e-01f, 1.11797834e-02f, 1.00446425e-01f, -6.29988387e-02f, 1.43765479e-01f, -1.61881045e-01f,
  -1.70572475e-02f, -1.06955804e-02f, -4.57442105e-02f, 1.04274422e-01f, 2.41244137e-02f, 3.34486999e-02f, -5.76166473e-02f, -1.10847943e-01f, -1.28018185e-02f, -1.78535120e-03f,
  3.04625053e-02f, -6.00232705e-02f, -2.55910549e-02f, -4.59343083e-02f, 2.62466893e-02f, -8.87424499e-02f, 7.46937767e-02f, -9.99468495e-04f, 2.17259806e-02f, -1.32623419e-01f,
  -2.63515450e-02f, 7.62069300e-02f, -6.35441691e-02f, -1.06175810e-01f, 7.42404014e-02f, -7.51979053e-02f, 2.03313455e-02f, -1.46412790e-01f, 1.02298617e-01f, -9.06304494e-02f,
  7.92127252e-02f, 1.54191479e-01f, 3.49968523e-02f, 7.22801536e-02f, 2.61297747e-02f, 4.62959334e-02f, -5.52867465e-02f, -7.62529746e-02f, -1.02423891e-01f, -8.13884735e-02f,
  -8.84660631e-02f, 5.82039393e-02f, -4.90631834e-02f, -9.63231698e-02f, 5.00436947e-02f, 8.19480419e-02f, -7.55503550e-02f, 6.54725172e-03f, 1.40024096e-01f, 8.41361508e-02f,
  -6.87657893e-02f, -9.08491686e-02f, -1.64199155e-02f, 2.65712440e-02f, 9.11377817e-02f, -5.60068823e-02f, 1.30693033e-01f, 1.38014346e-01f, -1.46102710e-02f, -2.46158317e-02f,
  1.22636788e-01f, -7.57759735e-02f, 3.62496562e-02f, 1.34209469e-01f, -1.20606035e-01f, -9.81891379e-02f, -6.58135787e-02f, 1.05775692e-01f, 7.54039511e-02f, 1.94918826e-01f,
  2.81012177e-01f, -1.01240858e-01f, 1.23950616e-01f, 4.90937158e-02f, 1.43498242e-01f, 1.71673506e-01f, 1.99331552e-01f, 1.55573770e-01f, 2.55502433e-01f, -7.38490000e-02f,
  7.67512098e-02f, 2.06512272e-01f, 2.02637583e-01f, 2.86606569e-02f, 7.73406327e-02f, 1.49703445e-02f, 2.58029431e-01f, -3.47609079e-04f, -2.05003366e-01f, -1.55663460e-01f,
  -1.02832392e-01f, 5.59237972e-02f, 2.61660069e-01f, 4.65519503e-02f, -3.03201023e-02f, 2.81701386e-01f, -4.07631509e-02f, -2.01125398e-01f, -4.44679782e-02f, 6.97786501e-03f,
  1.33279875e-01f, -2.38934979e-01f, -2.44778723e-01f, -2.73658574e-01f, 6.17394075e-02f, 2.38038585e-01f, 4.57124524e-02f, -5.18767722e-02f, -4.22708504e-02f, -1.80487916e-01f,
  1.49364904e-01f, -8.13538134e-02f, 2.61085242e-01f, 3.99225056e-02f, -1.22192852e-01f, -3.21844034e-02f, -6.20075613e-02f, -4.83172759e-02f, -6.08873181e-02f, 4.16014552e-01f,
  8.76567215e-02f, 2.05100253e-01f, -8.90242755e-02f, 2.22743481e-01f, 1.72901779e-01f, -1.57969952e-01f, 2.25655124e-01f, 7.54804388e-02f, -3.67478505e-02f, 2.99837947e-01f,
  -1.13731809e-01f, -4.53175344e-02f, -5.35212643e-02f, 8.93635675e-02f, -8.25721547e-02f, 9.42793414e-02f, -2.64141075e-02f, -1.17429763e-01f, -2.88147014e-03f, -5.66812418e-02f,
  -4.08273488e-02f, 3.74509431e-02f, -6.07411303e-02f, 1.74060501e-02f, -1.01908676e-01f, -9.30784494e-02f, -1.15994565e-01f, -6.74885437e-02f, -7.99245760e-02f, 1.03655003e-01f,
  1.15928836e-01f, 6.58374354e-02f, 5.22537529e-02f, -1.19712174e-01f, -1.14917070e-01f, 1.15746833e-01f, -5.58193922e-02f, 1.49125848e-02f, -7.23321810e-02f, 1.00492656e-01f,
  3.41824219e-02f, 8.35267976e-02f, -8.43030289e-02f, 5.01522720e-02f, 2.56130937e-02f, -7.03755096e-02f, 1.27063975e-01f, -2.95265783e-02f, 6.61217794e-02f, -5.83627410e-02f,
  5.16908802e-02f, -2.41426844e-02f, -2.69952826e-02f, -7.97051266e-02f, -5.78180254e-02f, -9.62480679e-02f, -7.98012316e-02f, -2.74837185e-02f, 7.98504949e-02f, 8.96109641e-02f,
  -3.38711850e-02f, 9.71021727e-02f, 3.82274128e-02f, 1.10621117e-02f, -4.21931930e-02f, -2.45046932e-02f, -3.43488082e-02f, -1.52859073e-02f, -9.78811458e-02f, 5.55946343e-02f,
  -7.05602486e-03f, -9.13367793e-02f, 6.82387203e-02f, 4.74171788e-02f, 6.11232892e-02f, -1.24297604e-01f, 6.99909627e-02f, 1.87504262e-01f, -4.33527194e-02f, -5.59328310e-02f,
  1.69693261e-01f, 1.08007200e-01f, 1.42355040e-01f, 1.71263412e-01f, -2.79014632e-02f, 1.35421246e-01f, 6.07721172e-02f, 6.39776140e-02f, 2.17246592e-01f, 1.23052225e-01f,
  1.94045693e-01f, 3.13593894e-02f, 2.74892505e-02f, -2.28188597e-02f, 1.18679814e-01f, 1.75253242e-01f, -3.92725468e-02f, 2.13541105e-01f, 2.17576977e-02f, 5.19230068e-02f,
  -1.41842261e-01f, 1.84188232e-01f, -5.89163639e-02f, -1.18317157e-01f, -1.08033068e-01f, 1.88564688e-01f, -5.20097688e-02f, 9.22151655e-02f, -1.27735138e-01f, 2.33932678e-02f,
  1.05297998e-01f, -4.08680700e-02f, -5.12002315e-03f, -7.01997206e-02f, -1.36340735e-02f, 6.57002181e-02f, 3.65771383e-01f, 6.08235821e-02f, -1.45613372e-01f, 1.28661217e-02f,
  -1.08393503e-03f, -3.84625699e-03f, -2.47267056e-02f, 1.60861425e-02f, -1.50848255e-02f, -1.99017853e-01f, 1.29460208e-02f, 2.21961483e-01f, 1.40585393e-01f, 2.41951481e-01f,
  -5.64915165e-02f, -2.10097358e-01f, 1.67799369e-01f, 2.78882951e-01f, -2.41751850e-01f, 2.02946886e-01f, 5.21483533e-02f, 5.97117618e-02f, 5.74181080e-02f, -3.71187547e-04f,
  -1.26073778e-01f, -4.50265370e-02f, -9.69639122e-02f, -8.70823767e-03f, 4.84573878e-02f, -1.10417590e-01f, -6.16737679e-02f, -1.82657495e-01f, -7.98337255e-03f, -8.41443837e-02f,
  -1.02464728e-01f, 2.05252141e-01f, 1.24850355e-01f, -7.82164186e-02f, 9.25427303e-03f, 1.15922496e-01f, 7.46986419e-02f, 1.16274334e-01f, 8.88287276e-02f, 1.57313064e-01f,
  -1.37941584e-01f, -7.80652538e-02f, -1.14195999e-02f, 1.13168351e-01f, 1.89388797e-01f, 7.98820257e-02f, -1.73832625e-01f, 6.77043945e-02f, -3.71169858e-02f, 1.29816439e-02f,
  1.83735579e-01f, 8.07118341e-02f, -1.29305914e-01f, -1.48240805e-01f, 9.79911759e-02f, -2.68301308e-01f, 2.35630274e-01f, 2.89856922e-02f, 5.75857908e-02f, 1.05779067e-01f,
  1.76865775e-02f, -2.28495792e-01f, 3.62056084e-02f, 1.37434220e-02f, -1.75199151e-01f, 2.72109974e-02f, 1.36892319e-01f, 1.05448835e-01f, -8.22903663e-02f, -4.89854552e-02f,
  -1.02617085e-01f, 1.97111681e-01f, 3.47249776e-01f, 4.21134382e-02f, -5.27356081e-02f, -1.32240281e-01f, -3.12942639e-02f, 4.98672074e-04f, 1.45526811e-01f, -2.40950081e-02f,
  2.88320947e-02f, 2.05116332e-01f, 6.58636913e-02f, -1.11056611e-01f, 5.46417981e-02f, 1.85730513e-02f, 1.67121485e-01f, 2.37074882e-01f, 2.06601825e-02f, 9.10913423e-02f,
  -4.56787124e-02f, 1.26328126e-01f, -1.00655377e-01f, 1.74792573e-01f, 7.90622011e-02f, 2.94617176e-01f, 1.10352032e-01f, 3.96707132e-02f, 1.39377743e-03f, -3.57667133e-02f,
  -7.11062327e-02f, 1.35271505e-01f, 2.94067394e-02f, 9.36097056e-02f, -4.19621505e-02f, 3.65310535e-02f, 2.18131453e-01f, -6.38949722e-02f, -2.32529432e-01f, -1.11405969e-01f,
  -8.99855196e-02f, -1.66972429e-01f, 4.62043993e-02f, 1.34088337e-01f, 1.46169826e-01f, -5.83484657e-02f, -3.18362921e-01f, 2.61113001e-03f, 2.44217649e-01f, 2.16484278e-01f,
  -2.67317966e-02f, -2.76832581e-01f, 5.10278046e-02f, 1.92267135e-01f, -2.69484147e-03f, 1.19527578e-01f, 7.52396956e-02f, -1.13464050e-01f, -2.29573548e-01f, -2.21275091e-02f,
  2.46393740e-01f, -1.40137985e-01f, -1.11715518e-01f, -3.82851041e-03f, -5.08299321e-02f, 1.18388645e-01f, 2.46981278e-01f, 5.92724271e-02f, -6.81692436e-02f, 4.68676351e-02f,
  1.91898227e-01f, 1.79061770e-01f, -6.16095141e-02f, 5.83475530e-02f, -2.09463760e-02f, 3.97714972e-02f, 1.62952337e-02f, -2.02784594e-02f, 1.91858988e-02f, 1.61568061e-01f,
  1.35417983e-01f, -8.65490288e-02f, -2.15172376e-02f, -1.02075018e-01f, 3.54240127e-02f, 2.70813331e-02f, 1.19854189e-01f, 1.37490153e-01f, 1.81666479e-01f, -1.13128565e-01f,
  2.00292662e-01f, 1.56531960e-01f, -1.67231578e-02f, -1.07693151e-01f, 2.05639854e-01f, 1.54934488e-02f, 2.36313697e-02f, -3.47361946e-03f, -4.41320240e-02f, -1.68669671e-01f,
  -2.46088460e-01f, -2.45456286e-02f, 2.02871382e-01f, 1.66466057e-01f, -7.48966485e-02f, 2.32779443e-01f, -1.79265574e-01f, -5.78710018e-03f, -2.54768163e-01f, -2.20550410e-02f,
  2.78215975e-01f, 1.24070622e-01f, -1.98658779e-01f, 3.08866352e-02f, -2.79930662e-02f, 9.14541855e-02f, 2.15703443e-01f, 2.48586703e-02f, 1.80661827e-01f, -3.09439003e-02f,
  3.56034301e-02f, 2.62836888e-02f, 3.74020129e-01f, -1.08181179e-01f, -3.24701697e-01f, -4.32472117e-02f, -1.04098469e-01f, 1.80741232e-02f, 2.24255212e-02f, 2.06063926e-01f,
  1.38953462e-01f, 2.24593997e-01f, -1.24525078e-01f, 1.17247075e-01f, -7.77230089e-05f, -3.00762579e-02f, -9.53285694e-02f, 2.23316163e-01f, -1.98628455e-02f, -5.02821878e-02f,
  2.29861010e-02f, -5.76334260e-02f, 7.48960525e-02f, 1.59185212e-02f, 7.26436600e-02f, 1.43015981e-01f, 9.83203575e-02f, 6.43514320e-02f, -7.95248225e-02f, -1.33038526e-02f,
  2.24300828e-02f, 5.19515164e-02f, 1.24380194e-01f, -2.71849278e-02f, -6.70404434e-02f, -8.05631950e-02f, -8.36200565e-02f, -2.57142354e-02f, 1.21113032e-01f, 1.69481516e-01f,
  1.14096692e-02f, -7.32148215e-02f, 1.18093751e-02f, 1.28065869e-01f, 1.85052231e-01f, -1.75710410e-01f, -9.83389914e-02f, -6.64106682e-02f, 2.14996133e-02f, -4.25308570e-02f,
  3.95386666e-02f, 2.44252048e-02f, 7.66547620e-02f, -1.06719658e-01f, 6.64250553e-02f, 2.10910276e-01f, 1.38538525e-01f, -5.05501367e-02f, -1.12260081e-01f, -1.63647130e-01f,
  6.16819784e-02f, 8.33225697e-02f, 2.01352760e-01f, 2.79476017e-01f, 3.09495986e-01f, 6.51904866e-02f, 2.48485789e-01f, 7.23666251e-02f, 1.17752187e-01f, -9.47827846e-02f,
  -8.04381259e-03f, 1.68462142e-01f, -1.42340427e-02f, -2.80419052e-01f, -6.88267723e-02f, 1.02771230e-01f, 4.81566787e-02f, 1.16751939e-01f, -3.33565958e-02f, 1.32222816e-01f,
  -3.87045406e-02f, 1.89900160e-01f, 3.94876711e-02f, -1.44538850e-01f, -1.14590432e-02f, -1.01082362e-01f, -1.24265395e-01f, -2.07275189e-02f, 1.17312357e-01f, 8.27530175e-02f,
  4.93967161e-02f, 5.64180464e-02f, -6.35732412e-02f, -4.30361032e-02f, -3.80554311e-02f, -7.71949142e-02f, -6.01820461e-02f, 5.80200702e-02f, 3.56623903e-02f, -3.88820507e-02f,
  -1.64766647e-02f, -1.56311854e-03f, -4.75418679e-02f, 6.49861759e-04f, -8.40878934e-02f, 3.04956529e-02f, -4.19741273e-02f, -2.30930205e-02f, -7.53400102e-02f, -1.18362419e-01f,
  -1.32089034e-01f, 7.11216033e-02f, -3.16213518e-02f, -4.25873399e-02f, 4.23692400e-03f, 6.79291263e-02f, 3.83840837e-02f, 4.60408963e-02f, -1.14889555e-01f, -6.19777152e-03f,
  8.54774192e-02f, -2.34010555e-02f, -4.02835682e-02f, -2.07138322e-02f, -1.19784191e-01f, 7.12246969e-02f, 3.46551239e-02f, 7.69612119e-02f, -1.08304374e-01f, 6.63476661e-02f,
  -8.23401585e-02f, -6.72767013e-02f, 3.61459292e-02f, -4.43375818e-02f, 7.74567798e-02f, 2.39996072e-02f, 3.92684937e-02f, -8.47101435e-02f, -6.86249882e-02f, 1.07306600e-01f,
  -6.74663484e-02f, -9.59029943e-02f, 5.73524870e-02f, 1.35066390e-01f, 4.58786339e-02f, 2.52488200e-02f, -2.69192215e-02f, 1.83821954e-02f, 6.10652044e-02f, 5.86465411e-02f,
  -5.46305180e-02f, 1.03911590e-02f, 1.16546778e-02f, 1.22014351e-01f, -3.07622533e-02f, 1.13886297e-01f, -1.17071822e-01f, 9.54387933e-02f, -7.67912045e-02f, -8.98123533e-02f,
  8.32163822e-03f, 1.80135727e-01f, -9.34032537e-03f, -3.07485703e-02f, -2.56161415e-03f, -8.04232508e-02f, -9.92112681e-02f, 1.24812797e-02f, 7.85437822e-02f, 7.01884553e-02f,
  1.85808167e-04f, 1.72819287e-01f, 6.53471947e-02f, -1.37227342e-01f, -4.06788588e-02f, -1.32129326e-01f, -8.97144005e-02f, -1.44599527e-01f, 1.12806365e-01f, 4.91137132e-02f,
  1.46460608e-01f, -1.36057734e-01f, -1.82916597e-01f, 9.34125409e-02f, 8.86417478e-02f, -5.08725978e-02f, -1.59606826e-03f, -1.15844101e-01f, -3.36455107e-02f, 1.53948575e-01f,
  6.75999075e-02f, 1.59925759e-01f, 5.61115742e-02f, -1.50448633e-02f, -9.00869071e-02f, 3.15106139e-02f, 2.20427960e-01f, -4.28433418e-02f, -8.29927996e-02f, 7.02453554e-02f,
  4.35538124e-03f, -8.62131566e-02f, 1.23715587e-01f, 1.28736496e-01f, -1.90224107e-02f, -7.99620599e-02f, 1.77805182e-02f, 2.15001971e-01f, -1.07348993e-01f, 2.10190322e-02f,
  -5.60766086e-03f, 4.11637425e-02f, -7.96095133e-02f, 5.27616963e-02f, 4.11913916e-02f, 5.10892197e-02f, -1.73001457e-02f, 1.09278545e-01f, 1.87095124e-02f, -5.78400418e-02f,
  1.24259174e-01f, -6.29863888e-02f, 1.61691740e-01f, 1.21503212e-01f, -4.93105054e-02f, -7.99720138e-02f, 1.73112109e-01f, 1.50064722e-01f, 1.45762801e-01f, -6.97082886e-03f,
  1.48709506e-01f, -1.27627002e-02f, -4.14410010e-02f, 2.61240359e-02f, 8.98850933e-02f, -7.11572468e-02f, 3.80978063e-02f, -1.10634550e-01f, 7.36760795e-02f, 9.58202928e-02f,
  3.00750919e-02f, -2.56524272e-02f, -4.27267477e-02f, 1.64839596e-01f, -1.37658641e-01f, 6.01090193e-02f, 1.43080607e-01f, 1.02085052e-02f, -7.28599131e-02f, 1.07021622e-01f,
  -1.18749216e-01f, -8.49699154e-02f, 7.69060329e-02f, -4.12416421e-02f, 2.32671931e-01f, 1.19901448e-02f, 9.75765567e-03f, 9.76511240e-02f, 6.32396117e-02f, -4.48135547e-02f,
  -1.59312129e-01f, 1.20707378e-01f, -1.33246817e-02f, -1.46986634e-01f, -3.63266729e-02f, 9.63285491e-02f, -3.18201557e-02f, -4.03243490e-03f, 1.03594042e-01f, 1.03745386e-01f,
  1.58838779e-01f, 2.66071167e-02f, -1.79384857e-01f, 2.15951838e-02f, 4.21395302e-02f, 1.13743670e-01f, -1.14215948e-01f, -2.78430190e-02f, 2.69098245e-02f, 3.30469385e-02f,
  9.07310620e-02f, -1.06896996e-03f, 9.28678513e-02f, -1.46078775e-02f, 3.85162979e-02f, -1.12677082e-01f, -2.63901725e-02f, 1.96716804e-02f, 2.90516317e-02f, -4.28177863e-02f,
  5.23739718e-02f, -2.88980678e-02f, -4.02305312e-02f, -9.63661447e-02f, -1.10145427e-01f, -6.41498994e-03f, 4.19721892e-03f, -2.17562355e-02f, -4.14352454e-02f, 1.27517479e-02f,
  4.75828908e-02f, -4.41097617e-02f, -8.77582729e-02f, -3.76177020e-02f, 1.09687418e-01f, -4.18939330e-02f, 6.32016808e-02f, 5.48184030e-02f, -8.03800970e-02f, -7.33194798e-02f,
  -1.22030163e-02f, -5.12894392e-02f, 5.06749079e-02f, 1.23783648e-01f, 5.93142696e-02f, 7.59900063e-02f, -5.60813444e-03f, -8.00334960e-02f, -8.47875550e-02f, 9.42606386e-03f,
  -1.07672689e-02f, 1.16569236e-01f, -3.54300290e-02f, -7.28643164e-02f, 1.07135862e-01f, -2.60062069e-02f, 7.60178044e-02f, 8.10694695e-02f, -1.28356107e-02f, -3.71526070e-02f,
  -1.10322453e-01f, -1.27868727e-02f, 8.63056779e-02f, 2.85894722e-02f, 9.07035172e-02f, -9.61613208e-02f, -9.79329124e-02f, 9.64887440e-02f, 4.15270850e-02f, -5.03934547e-02f,
  -1.06273860e-01f, -8.88566449e-02f, -4.11530845e-02f, -3.99569459e-02f, 2.59522319e-01f, 7.45923221e-02f, 1.16136245e-01f, 1.45112015e-02f, 9.08625796e-02f, 9.26199332e-02f,
  2.09682375e-01f, 1.09634198e-01f, 2.21427172e-01f, 2.34905347e-01f, 1.73225015e-01f, 1.28764212e-01f, 9.64869410e-02f, 1.21392302e-01f, 1.03462398e-01f, -1.19028151e-01f,
  -4.14683782e-02f, 3.77300642e-02f, -2.78072298e-01f, -5.48161902e-02f, -1.61951318e-01f, 1.00614622e-01f, 1.53554797e-01f, -3.58440764e-02f, -1.68489218e-01f, 7.95899611e-03f,
  3.94950435e-02f, -2.73788944e-02f, 1.07851848e-01f, 4.70145838e-03f, -1.21815495e-01f, -2.60722011e-01f, 1.26500145e-01f, 1.62359551e-01f, -2.79949922e-02f, 1.76118359e-01f,
  2.24439073e-02f, 1.91715121e-01f, -4.84540239e-02f, -1.11538045e-01f, -1.72172636e-01f, 6.35668188e-02f, -2.36560941e-01f, 1.19916104e-01f, 2.66998261e-01f, -6.82380423e-03f,
  6.80828989e-02f, 7.29524419e-02f, 1.14521056e-01f, 1.76903144e-01f, 1.10386238e-01f, -4.31632251e-03f, -9.85841304e-02f, 3.11824799e-01f, -4.68350649e-02f, -4.99061830e-02f,
  3.43012065e-01f, -1.69345632e-01f, 4.28052992e-02f, 3.25903654e-01f, 6.62301332e-02f, 8.76406729e-02f, 1.61217898e-02f, -3.40112746e-02f, -6.13495242e-03f, 1.16570786e-01f,
  -7.62557015e-02f, 1.06938303e-01f, -7.13181123e-02f, 3.44672464e-02f, 6.86490117e-03f, 4.83814999e-02f, -6.90728277e-02f, 2.42173344e-01f, 3.54357772e-02f, 1.50617501e-02f,
  4.67129871e-02f, 1.37283146e-01f, 2.77729053e-03f, 1.17136486e-01f, -3.50533910e-02f, 2.53742963e-01f, -1.26186192e-01f, 1.84440762e-01f, 1.00237712e-01f, -7.15950504e-03f,
  -1.77781135e-01f, -3.40746269e-02f, 1.08556330e-01f, -1.72160193e-01f, 3.48536260e-02f, 1.68118209e-01f, -4.94869128e-02f, -1.21383183e-01f, -1.69436619e-01f, -1.46925643e-01f,
  6.80235475e-02f, 6.45671189e-02f, 3.26586366e-02f, -1.86989784e-01f, -1.37687057e-01f, 2.32057810e-01f, 5.93982711e-02f, 1.55272827e-01f, -1.14675993e-02f, -7.00452402e-02f,
  -2.07584411e-01f, 1.08848386e-01f, 1.95106715e-01f, 1.72482356e-02f, 4.10902267e-03f, -1.16474405e-01f, -8.33375826e-02f, -4.22673337e-02f, 5.60715795e-02f, 6.88102245e-02f,
  -9.38756093e-02f, -1.73970684e-01f, 1.27197936e-01f, 3.21333557e-01f, -1.04291432e-01f, 1.14905283e-01f, -7.38156140e-02f, 8.88669640e-02f, -1.18569778e-02f, 5.63541837e-02f,
  6.45746738e-02f, 1.39670581e-01f, 9.06578004e-02f, 1.66842919e-02f, -6.95842057e-02f, 1.64711371e-01f, 4.59570177e-02f, 4.29008715e-02f, -4.79978994e-02f, 1.81551531e-01f,
  -2.26480030e-02f, -9.57213864e-02f, 1.20403461e-01f, -4.79702987e-02f, 5.46492785e-02f, 1.37213379e-01f, 4.21484560e-03f, 8.80467445e-02f, 8.92582089e-02f, 1.77082062e-01f,
  5.35565689e-02f, -1.13151968e-01f, 3.30738574e-02f, -1.38732210e-01f, 1.58052132e-01f, 1.87311873e-01f, 8.47934932e-02f, -6.94315806e-02f, -1.49950445e-01f, 1.70219764e-01f,
  -1.52297616e-01f, 6.94487169e-02f, 9.05861780e-02f, -8.87709018e-03f, -5.09612001e-02f, -1.43312365e-02f, 5.68815216e-04f, -1.00512855e-01f, 8.34482387e-02f, 1.48572281e-01f,
  3.29690985e-02f, -2.69294363e-02f, -2.04471007e-01f, 1.11194572e-03f, -1.84958324e-01f, -2.55054422e-03f, -6.27716407e-02f, 7.11187720e-02f, 6.70199394e-02f, -1.49961293e-01f,
  -1.05839707e-01f, 2.60757089e-01f, 1.51102975e-01f, 2.76714913e-03f, -1.22615490e-02f, 1.40923306e-01f, 1.84956454e-02f, 1.03338674e-01f, -1.32082418e-01f, 1.95516825e-01f,
  -1.14581391e-01f, 1.84656143e-01f, -8.87901783e-02f, 3.16522531e-02f, -5.90489693e-02f, -5.37176132e-02f, 3.13979350e-02f, -1.59367397e-01f, -3.24692875e-02f, 3.57092805e-02f,
  4.30944301e-02f, -3.61419357e-02f, 3.34888585e-02f, -5.47553562e-02f, 7.78728258e-03f, 8.20183381e-03f, -1.14562951e-01f, 8.51652473e-02f, -1.31057411e-01f, -1.12549968e-01f,
  4.53516468e-02f, -7.52094761e-02f, -1.40648291e-01f, 4.80355360e-02f, 2.59718224e-02f, -1.51659340e-01f, -3.79841588e-02f, 6.66754469e-02f, -8.09113532e-02f, -2.83682887e-02f,
  -6.49783164e-02f, -3.15714814e-02f, 4.25403342e-02f, -5.27659133e-02f, -7.90843070e-02f, -1.81580186e-02f, 6.34695869e-03f, -2.52917614e-02f, -1.24737717e-01f, -8.61820355e-02f,
  1.23065442e-01f, 5.10605462e-02f, 2.04074848e-02f, -1.11471072e-01f, 3.06803379e-02f, -2.00445810e-03f, 9.94409770e-02f, -9.20810699e-02f, -7.88738206e-03f, 4.55925465e-02f,
  -1.20267188e-02f, 3.60244662e-02f, -1.06063187e-01f, -1.10747918e-01f, -1.05393343e-01f, 1.29983932e-01f, 3.43164220e-03f, 3.29000466e-02f, 4.20785770e-02f, 5.70965447e-02f,
  -7.90087879e-02f, -1.16916895e-01f, 1.04586475e-01f, -1.31195690e-02f, 6.81988746e-02f, 9.60067809e-02f, -2.75649838e-02f, -8.00187439e-02f, 1.00373603e-01f, -6.46747202e-02f,
  -7.92245045e-02f, 1.01076916e-01f, 4.31305543e-02f, -2.37236060e-02f, 3.18549983e-02f, 1.11956209e-01f, -2.65920218e-02f, 8.83921087e-02f, -1.15907013e-01f, -1.25941455e-01f,
  2.57313326e-02f, 1.07361838e-01f, -2.16876320e-03f, 4.58473898e-02f, 1.11390196e-01f, -8.81295949e-02f, 4.45970744e-02f, 3.05553190e-02f, -1.94759741e-02f, -8.05788189e-02f,
  4.15157117e-02f, -1.22280754e-01f, -7.86942765e-02f, -1.22844949e-02f, 1.04250140e-01f, 1.12834431e-01f, 3.17884348e-02f, 1.48507491e-01f, -5.53756095e-02f, -9.64048132e-02f,
  9.65547934e-02f, 2.18757495e-01f, -9.90676433e-02f, 9.73585099e-02f, -1.45053893e-01f, -1.24443509e-01f, -1.00178398e-01f, 2.16577314e-02f, 1.40820190e-01f, 3.35369781e-02f,
  6.21201433e-02f, 2.55558603e-02f, 1.37495011e-01f, -1.26549199e-01f, 3.80701162e-02f, -1.14339190e-02f, 1.13422148e-01f, -5.44235297e-02f, 8.68681446e-02f, 9.52097867e-03f,
  -3.65898013e-02f, 1.28305450e-01f, -1.75038651e-02f, 2.25766525e-02f, 5.13947532e-02f, 6.75378889e-02f, -4.33050059e-02f, 1.14447609e-01f, -9.98450518e-02f, -8.04927200e-02f,
  3.10820974e-02f, 2.53014453e-02f, -1.18080966e-01f, 4.09093127e-02f, 7.15185478e-02f, 1.25294432e-01f, 6.08874392e-03f, -4.95012105e-02f, -1.02780052e-02f, 5.56886159e-02f,
  -7.75723532e-02f, 6.57917783e-02f, -8.73304680e-02f, -3.37164365e-02f, 5.34854308e-02f, 7.70947635e-02f, 5.78390509e-02f, -6.31950349e-02f, -8.34912732e-02f, 3.36454995e-02f,
  -1.81960203e-02f, 4.80755940e-02f, 5.27541451e-02f, -5.08086123e-02f, -9.93985683e-02f, 1.05882220e-01f, -3.47749777e-02f, -4.55545746e-02f, 8.36653709e-02f, 7.79240727e-02f,
  -8.74235928e-02f, -5.79247177e-02f, 1.02882378e-01f, 9.93827805e-02f, -6.74999356e-02f, -1.43577671e-02f, 6.32195175e-02f, 7.18495846e-02f, -8.03736076e-02f, 1.87443830e-02f,
  -3.66584919e-02f, 9.32091698e-02f, 3.82471969e-03f, -3.73965278e-02f, -1.16570167e-01f, 9.14501324e-02f, 7.91749656e-02f, -5.00037521e-02f, 3.67491692e-02f, -6.29373454e-03f,
  1.33008780e-02f, 1.34996638e-01f, 5.47865294e-02f, 8.32583010e-03f, -1.16199188e-01f, 3.57552106e-03f, -8.30923095e-02f, -7.77399316e-02f, -3.48073952e-02f, -1.31147161e-01f,
  1.50010630e-01f, 6.72262087e-02f, 6.83596209e-02f, -1.06585130e-01f, 8.22661817e-02f, -1.35360630e-02f, -6.61295280e-02f, 2.18199030e-03f, 9.76523012e-02f, 2.83007137e-02f,
  3.83927450e-02f, 3.45970616e-02f, 5.48217930e-02f, 7.94970337e-03f, 2.67405789e-02f, -5.72440289e-02f, -1.45138368e-01f, 1.26804084e-01f, 2.77802744e-03f, -1.94738805e-02f,
  6.65448159e-02f, 1.26128748e-01f, -3.00676208e-02f, 1.13252409e-01f, -7.26505965e-02f, 6.98412955e-02f, -7.00704604e-02f, 1.75440148e-01f, 1.20251209e-01f, -1.50696989e-02f,
  5.57034947e-02f, 1.81302413e-01f, 6.38561510e-03f, -8.34987387e-02f, -1.98921144e-01f, 4.31335066e-03f, 3.35354730e-02f, -3.74723896e-02f, -1.04873635e-01f, 2.14861054e-02f,
  1.27397254e-01f, -8.06558654e-02f, 3.01918481e-02f, -9.77800488e-02f, 2.74996329e-02f, 6.46495447e-02f, 1.38756141e-01f, 8.55461787e-03f, 4.15219963e-02f, -9.53712687e-02f,
  -1.27497837e-01f, 7.29877651e-02f, -1.69178471e-02f, 4.73643281e-02f, -5.75279817e-02f, -4.41843010e-02f, 4.48063016e-02f, 5.63679785e-02f, 1.57691866e-01f, 2.91260649e-02f,
  8.81769508e-02f, -1.92329362e-02f, 4.16097455e-02f, 1.95305437e-01f, -4.37964574e-02f, 1.46349117e-01f, -1.17968000e-01f, 1.15772173e-01f, -3.43163162e-02f, 2.80660465e-02f,
  1.46490276e-01f, 1.26026362e-01f, 2.06356600e-01f, 4.73100925e-03f, 1.35422498e-01f, 2.70512840e-03f, 2.05578953e-01f, 1.19234748e-01f, 1.61196083e-01f, 1.36617735e-01f,
  1.17251158e-01f, -3.05626411e-02f, 1.46459922e-01f, 2.29493886e-01f, 1.92279905e-01f, 2.20595613e-01f, 8.46175700e-02f, -2.77096294e-02f, 1.45394430e-01f, 1.75346538e-01f,
  -6.86183944e-02f, -5.85269369e-02f, -1.48576304e-01f, -1.56410679e-01f, 1.60286829e-01f, 2.07454175e-01f, -5.56407087e-02f, 1.46969438e-01f, 2.72086151e-02f, 2.10616797e-01f,
  -2.77236681e-02f, 1.61060747e-02f, -5.48731871e-02f, -1.87784851e-01f, -1.00369520e-01f, -1.98694821e-02f, -1.54057115e-01f, -5.33287376e-02f, -6.39224350e-02f, 1.83061361e-01f,
  1.42290741e-01f, -1.20208874e-01f, -1.94559574e-01f, 6.62863702e-02f, -8.80422965e-02f, -1.16787590e-01f, -1.13041207e-01f, 7.62957782e-02f, -7.65475854e-02f, -2.01465130e-01f,
  -1.19414344e-01f, 4.76563066e-01f, 3.90189767e-01f, 3.73372287e-02f, 9.31653455e-02f, 1.26164988e-01f, 2.05817357e-01f, -1.07006393e-01f, 1.26383603e-01f, 4.32921350e-02f,
  -4.51468229e-02f, 3.44114393e-01f, -8.63143504e-02f, 8.96045044e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  1.62265509e-01f, 9.04254913e-02f, -9.88915712e-02f, -2.66980585e-02f, 6.23082276e-03f, -1.21358164e-01f, 5.98524287e-02f, 5.87093085e-02f, -1.14049107e-01f, 1.56905949e-01f,
  -5.58150187e-02f, 3.58579680e-02f, 8.73810276e-02f, 1.63961738e-01f, 7.79732019e-02f, 2.77255140e-02f, 3.15313078e-02f, -1.82102323e-02f, 6.68195933e-02f, 1.54748231e-01f,
  1.32631317e-01f, 7.10962415e-02f, -3.43140513e-02f, -3.32139060e-02f, -5.63626476e-02f, 2.29034200e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  2.53320396e-01f, 7.12939426e-02f, -3.37857097e-01f, -2.72517085e-01f, -7.22542033e-02f, -8.17644298e-02f, 2.86952168e-01f, -2.30250254e-01f, 9.44932699e-02f, 4.15214570e-03f,
  6.74527287e-02f, 1.57320276e-02f, 2.75385827e-01f, 2.02908188e-01f, 2.95584381e-01f, 6.17103763e-02f, 8.36275741e-02f, 8.28211904e-02f, 2.56250560e-01f, -2.63419539e-01f,
  -5.55407116e-03f, 3.80576670e-01f, -1.93404034e-01f, 1.16462082e-01f, 3.48396420e-01f, 7.05735832e-02f, 2.56865144e-01f, 2.42938221e-01f, 2.21337885e-01f, -2.48221725e-01f,
  2.74689645e-01f, -1.59966834e-02f, -6.36544973e-02f, -1.40690774e-01f, 1.72594026e-01f, 2.99605932e-02f, 2.87881810e-02f, -1.94937393e-01f, 2.54129946e-01f, 8.16564858e-02f,
  -1.68781951e-02f, -3.91394526e-01f, -9.99394283e-02f, 1.55943364e-01f, -4.42555584e-02f, 1.13686055e-01f, 9.78638679e-02f, -3.93742144e-01f, -7.77630089e-03f, -3.38021517e-02f,
  -2.68638730e-01f, -3.13704699e-01f, -1.33403525e-01f, -1.10858321e-01f, -9.11442786e-02f, -8.73883888e-02f, 5.88464439e-01f, -1.11152120e-04f, 1.01422153e-01f, 2.72876583e-02f,
  -5.22623546e-02f, 2.04698481e-02f, -1.97594553e-01f, 3.08858395e-01f, -6.44759983e-02f, 7.69283324e-02f, -5.02941199e-02f, 2.46021494e-01f, 4.08355519e-02f, 1.39693305e-01f,
  -1.60397038e-01f, -2.96531767e-01f, 1.00692965e-01f, -3.67618471e-01f, 1.75976440e-01f, 9.57541019e-02f, 9.35854018e-02f, 8.46782997e-02f, -3.23634028e-01f, -2.63796777e-01f,
  -8.31077844e-02f, 1.37129888e-01f, 1.78574011e-01f, 3.93725783e-01f, 1.06386952e-01f, 4.66813534e-01f, 2.04523072e-01f, 2.22688243e-01f, 1.47236362e-01f, -1.16515510e-01f,
  -6.61382079e-02f, -1.01849072e-01f, 2.37833440e-01f, -1.62064895e-01f, 4.13163573e-01f, -3.16663176e-01f, -3.02193630e-02f, -2.87949920e-01f, -3.91194135e-01f, 3.61457795e-01f,
  2.89804131e-01f, -6.27564564e-02f, 5.69256723e-01f, 6.83340281e-02f, -1.24413416e-01f, 1.35287225e-01f, -1.69738531e-01f, -5.65663427e-02f, -2.23122514e-03f, -1.32094234e-01f,
  9.14291367e-02f, -5.20843148e-01f, -9.88961384e-02f, 2.04880416e-01f, -2.50020444e-01f, 2.68205464e-01f, 2.79216748e-02f, 8.96832645e-02f, -8.26620311e-02f, 3.30682881e-02f,
  2.14980468e-01f, -1.86297730e-01f, -3.21032822e-01f, 3.11925299e-02f, -1.39603466e-01f, 1.36667490e-01f, -1.84404850e-01f, -4.56603557e-01f, -4.11475092e-01f, 1.94609035e-02f,
  9.93296728e-02f, -7.25858957e-02f, 3.47566418e-02f, -8.01226050e-02f, -1.58996806e-01f, -3.17764908e-01f, -1.27629012e-01f, -1.52809605e-01f, 1.06667764e-01f, -1.69508776e-03f,
  -1.89972043e-01f, 3.17207389e-02f, -3.34495842e-01f, -3.63483727e-01f, 5.94088249e-02f, 8.31196159e-02f, -6.38206899e-02f, 2.05376208e-01f, 1.35339171e-01f, -3.17871034e-01f,
  2.69608408e-01f, -9.03421938e-02f, -3.08227599e-01f, 7.59740621e-02f, -6.58302754e-02f, -3.04735780e-01f, 2.91845143e-01f, -1.75231379e-02f, -2.66536742e-01f, 1.68162808e-01f,
  -1.84971675e-01f, 3.60094681e-02f, -4.98987064e-02f, 3.03371191e-01f, 1.55546531e-01f, 6.53525740e-02f, 2.18308747e-01f, 1.32678993e-04f, 1.69187468e-02f, 3.31227899e-01f,
  -1.04386263e-01f, -5.06400205e-02f, -4.29525599e-02f, -5.48488140e-01f, 1.03724800e-01f, -1.30230308e-01f, -1.41200259e-01f, 1.21830888e-01f, -2.80490726e-01f, 3.39620978e-01f,
  3.91856469e-02f, 3.22026998e-01f, -1.86424434e-01f, 2.27721650e-02f, -4.39980775e-01f, 3.66954923e-01f, -2.96983540e-01f, 5.43457791e-02f, 1.05610147e-01f, -1.25686824e-01f,
  4.84858714e-02f, -6.19829476e-01f, 2.34717932e-02f, -3.65697145e-02f, 1.44975871e-01f, -7.30936974e-02f, -1.84083179e-01f, -5.69464825e-02f, 3.37087125e-01f, -1.99693888e-02f,
  2.10295066e-01f, -9.74729583e-02f, 1.70931444e-01f, 4.48111817e-03f, 1.49591014e-01f, -2.34226823e-01f, -1.01989344e-01f, -9.12349522e-02f, -8.38210899e-03f, 1.75921574e-01f,
  -1.59327742e-02f, -2.31998414e-01f, -2.14548305e-01f, -1.90623507e-01f, -7.38288835e-02f, -1.99949801e-01f, -1.40887260e-01f, 3.78063996e-04f, -4.51782703e-01f, -2.12813485e-02f,
  -1.40604824e-01f, 2.07829699e-01f, -7.03779459e-02f, 3.74069989e-01f, 1.68030009e-01f, 3.13149840e-01f, 1.80814207e-01f, 2.72045046e-01f, -2.37976108e-02f, -1.06746498e-02f,
  -7.96475112e-01f, -3.28957289e-02f, -1.08757563e-01f, -2.58846343e-01f, 2.46853769e-01f, -2.36286409e-02f, 1.78714156e-01f, 5.78568339e-01f, 3.05213016e-02f, 4.82436009e-02f,
  6.91340268e-02f, -4.26573902e-01f, 4.98657197e-01f, -2.11302683e-01f, 1.97114460e-02f, -2.05046251e-01f, 1.31303847e-01f, -4.26698811e-02f, -4.04976569e-02f, -1.13802038e-01f,
  2.62538284e-01f, 1.40651688e-01f, -1.57580167e-01f, -1.14320613e-01f, 4.32588682e-02f, 1.49313197e-01f, -7.57137164e-02f, -6.26320252e-04f, 1.70005485e-01f, -1.55443728e-01f,
  1.56892300e-01f, -4.28320607e-03f, 1.85547918e-01f, 3.62330019e-01f, 5.77027202e-02f, 5.93696609e-02f, 2.77935360e-02f, 1.17911316e-01f, 2.89315879e-01f, -1.54880494e-01f,
  -2.45037898e-02f, -6.20785318e-02f, 8.59365985e-02f, -2.46574596e-01f, -9.37590897e-02f, -1.45447493e-01f, 3.04290503e-01f, -7.52586052e-02f, -1.48710394e-02f, 3.99407260e-02f,
  6.49053901e-02f, 7.63390884e-02f, -1.26418993e-01f, 3.40782166e-01f, -1.56373084e-01f, -2.78375208e-01f, -1.83546022e-02f, 2.80454278e-01f, 2.24308416e-01f, 4.41539973e-01f,
  3.00321490e-01f, -3.29856575e-01f, 3.53567265e-02f, -3.91146727e-02f, -8.55772272e-02f, 5.53737208e-02f, -1.15281887e-01f, -6.52666315e-02f, -2.03280702e-01f, 3.34177949e-02f,
  -1.93277761e-01f, 1.58776149e-01f, -1.77157838e-02f, 2.64526367e-01f, -1.49741415e-02f, 3.52737829e-02f, 1.26246899e-01f, -3.66543174e-01f, -7.46706948e-02f, -1.50312975e-01f,
  1.98806986e-01f, 2.45526116e-02f, 2.61116713e-01f, 1.35375008e-01f, 1.66368380e-01f, -1.36688590e-01f, -9.66166854e-02f, 5.99094927e-02f, 1.55885801e-01f, 3.37606758e-01f,
  3.50131303e-01f, -2.12695003e-02f, 3.74174386e-01f, 1.89391732e-01f, 7.23590627e-02f, 8.25770199e-02f, 7.36807585e-02f, -3.48307252e-01f, 1.40904993e-01f, 1.77250475e-01f,
  1.03014506e-01f, 3.34777564e-01f, -1.52140453e-01f, 2.00181514e-01f, 1.75074875e-01f, 1.26849607e-01f, 1.63221180e-01f, -1.43237829e-01f, -9.01177451e-02f, 6.76286817e-02f,
  9.95080695e-02f, 3.57038051e-01f, -2.40538836e-01f, 3.80767137e-01f, 2.24690542e-01f, -1.92390442e-01f, 2.52981663e-01f, 1.89191371e-01f, 3.34996074e-01f, -9.68549773e-02f,
  1.15189306e-01f, -2.31082976e-01f, 8.94378126e-02f, -1.85789317e-01f, -2.29512066e-01f, -2.96026379e-01f, -2.68057972e-01f, 1.65789559e-01f, 5.38327813e-01f, 5.19658774e-02f,
  5.98806236e-03f, -2.71947291e-02f, 2.41307802e-02f, 1.96059361e-01f, -8.39816555e-02f, 3.53504233e-02f, -1.27571905e-02f, 1.20305233e-01f, -1.33017302e-01f, 1.64643943e-01f,
  -1.71618134e-01f, -1.81260154e-01f, -4.55084033e-02f, -1.94644704e-02f, -5.20872734e-02f, -1.27862707e-01f, 7.36218132e-03f, 7.38079399e-02f, -3.04375086e-02f, 1.00274952e-02f,
  1.50142923e-01f, -1.21666461e-01f, 7.12650642e-02f, 5.47982492e-02f, 1.17838867e-01f, -1.15407214e-01f, -2.28021458e-01f, 1.65421292e-01f, 1.18347324e-01f, -5.63785695e-02f,
  -6.19646534e-02f, 6.47074915e-03f, 2.34394178e-01f, 2.44709998e-01f, 8.77664760e-02f, -3.55361402e-01f, -2.64881432e-01f, 1.23564072e-01f, -9.54315886e-02f, -3.36430073e-01f,
  -7.59011460e-03f, 7.26880133e-02f, -2.16182247e-01f, 3.28895092e-01f, 5.38077727e-02f, -2.44708359e-01f, 2.41426155e-01f, -1.38840035e-01f, 4.22040299e-02f, -5.39606884e-02f,
  4.03089851e-01f, -1.30524665e-01f, -1.81043491e-01f, 7.69741014e-02f, -2.02490836e-01f, -2.97140237e-02f, -4.47308272e-02f, -4.65820700e-01f, -3.34723353e-01f, -3.74431461e-01f,
  -1.37210518e-01f, -2.64757480e-02f, 1.13498770e-01f, 5.14550619e-02f, 6.20000362e-02f, 1.47127986e-01f, -1.22956140e-02f, -1.51596665e-01f, 1.06941245e-01f, -4.07829106e-01f,
  -8.12846944e-02f, 3.92459989e-01f, -2.12701097e-01f, 2.88039625e-01f, -8.90133306e-02f, 1.88435033e-01f, 5.22751100e-02f, 2.25388333e-02f, 1.86546490e-01f, -6.29747137e-02f,
  -2.94309378e-01f, 2.10152969e-01f, 1.43747693e-02f, -3.91086116e-02f, 2.08731174e-01f, -1.19675010e-01f, 1.33046597e-01f, -1.52096972e-01f, -2.32085615e-01f, -5.47977947e-02f,
  1.23826638e-01f, -1.37226686e-01f, -1.29710928e-01f, 2.32322179e-02f, -2.27998476e-02f, -1.73720688e-01f, -1.41847506e-01f, -8.91439617e-02f, -2.08236694e-01f, -2.57085323e-01f,
  -4.82047170e-01f, 5.87499095e-03f, -6.93239048e-02f, -1.57634076e-02f, -9.69041437e-02f, 1.64449334e-01f, -8.55052993e-02f, -2.09002063e-01f, -1.88305303e-01f, 9.00026485e-02f,
  1.15673274e-01f, -2.50426382e-02f, 3.70990485e-02f, 4.33551073e-01f, -3.49341303e-01f, 3.89623076e-01f, -2.41183609e-01f, -1.24370225e-01f, -7.40167797e-02f, 3.19975883e-01f,
  9.21243355e-02f, 2.36265689e-01f, 3.64498002e-03f, -2.94660211e-01f, 1.04835421e-01f, 9.10380036e-02f, -6.36617422e-01f, 1.21234521e-01f, -5.17963544e-02f, -6.88178778e-01f,
  5.93529791e-02f, -1.19700789e-01f, -6.18185513e-02f, 3.67335230e-01f, -2.25508977e-02f, 2.30974145e-02f, 6.34185731e-01f, 1.04270898e-01f, -1.35766342e-01f, -2.97901928e-01f,
  -2.32550204e-02f, -8.57364833e-02f, -5.15782312e-02f, -5.44685535e-02f, 2.38154501e-01f, -3.34849022e-02f, -2.98181716e-02f, 1.20409280e-01f, -1.33834705e-01f, -6.13972582e-02f,
  9.48519483e-02f, 3.09932619e-01f, -4.31386113e-01f, 1.20801419e-01f, 3.66393365e-02f, -6.85573975e-03f, -1.59413051e-02f, -3.30337822e-01f, -1.95774570e-01f, -1.05030991e-01f,
  -3.31928730e-01f, -4.45213437e-01f, -1.26057714e-01f, 1.10264443e-01f, -3.61055285e-02f, -6.63004369e-02f, -3.63882929e-01f, 1.43923566e-01f, -4.86969143e-01f, -1.94928259e-01f,
  1.58736724e-02f, 1.02582447e-01f, -3.18041801e-01f, 1.91097811e-01f, 1.90265730e-01f, 7.70873204e-02f, -1.47864550e-01f, -3.61253768e-02f, -3.36840376e-02f, -3.42429914e-02f,
  7.03060552e-02f, 7.45664909e-02f, 1.86469600e-01f, -2.44654223e-01f, 4.26873155e-02f, -1.06424667e-01f, -5.15433885e-02f, 6.86883852e-02f, 2.83198655e-01f, -1.75604895e-01f,
  2.00207829e-02f, -1.26756653e-01f, 5.34357652e-02f, 7.91878819e-01f, 2.55427688e-01f, 7.19764084e-02f, 4.90488485e-02f, -2.33917609e-01f, 6.49319440e-02f, -2.01441735e-01f,
  4.20035198e-02f, -4.53436255e-01f, -8.42379630e-02f, 2.38291964e-01f, 5.82952499e-02f, -6.04026318e-02f, -5.33617474e-02f, -1.17612578e-01f, -3.90643418e-01f, -1.88961476e-01f,
  -4.85081188e-02f, -1.11917205e-01f, 4.72639240e-02f, -9.93272588e-02f, -1.74381480e-01f, -4.82211262e-01f, -2.18347553e-02f, -2.58064002e-01f, -1.81131899e-01f, -6.03384599e-02f,
  1.96135104e-01f, -1.31256701e-02f, 2.71374345e-01f, 2.76742011e-01f, 9.56823453e-02f, 4.82025445e-02f, -4.47501801e-03f, -1.54893309e-01f, 1.44325927e-01f, 2.09710002e-01f,
  4.29972619e-01f, 2.84010798e-01f, -2.41717249e-01f, -1.43333837e-01f, -1.78312823e-01f, -2.98616409e-01f, 1.21183097e-01f, -2.50091791e-01f, -2.06850901e-01f, -7.23219886e-02f,
  -7.00139254e-02f, 2.10031703e-01f, -1.94121543e-02f, 1.75720319e-01f, -1.79165751e-01f, -2.41543829e-01f, -1.83999419e-01f, -2.17042014e-01f, 7.78510468e-03f, 4.06869613e-02f,
  -4.82165329e-02f, -1.53199196e-01f, -9.73914936e-02f, -5.16933808e-03f, -4.50695381e-02f, 1.14022240e-01f, 7.09160492e-02f, -3.42002571e-01f, -1.65258646e-02f, -1.61395699e-01f,
  4.44313288e-02f, -3.89274150e-01f, -2.32440829e-02f, 3.99384052e-01f, 7.34081045e-02f, 4.05637980e-01f, -4.13857847e-01f, 4.17649746e-02f, 1.06103584e-01f, 3.13972443e-01f,
  2.34288350e-02f, 2.19461154e-02f, 1.78771466e-01f, 4.43467826e-01f, 2.24060312e-01f, 7.32382163e-02f, -1.26951531e-01f, -8.63807648e-02f, 1.47579283e-01f, 2.83967052e-02f,
  1.27177969e-01f, 1.62651807e-01f, -2.07899988e-01f, 9.35128331e-02f, -1.30531892e-01f, 2.75855344e-02f, -2.04191387e-01f, 4.05585200e-01f, 1.31212190e-01f, 1.69286028e-01f,
  5.94804920e-02f, 1.62483692e-01f, 1.48624703e-01f, -1.97314531e-01f, 3.55558246e-01f, 4.48834412e-02f, 2.36577168e-01f, -2.16397554e-01f, 4.07432504e-02f, -2.74480641e-01f,
  -1.17632113e-01f, -1.56115904e-01f, -1.78029314e-01f, -1.75240412e-01f, -9.44071934e-02f, -3.19073945e-01f, 5.44398129e-02f, -1.89321369e-01f, -2.79462427e-01f, 9.35855582e-02f,
  -1.17364608e-01f, -3.25015545e-01f, -1.72184911e-02f, 3.85100216e-01f, -2.67734788e-02f, 1.12849720e-01f, -3.95854041e-02f, 8.89347121e-02f, -1.03891473e-02f, 5.83183058e-02f,
  1.15070760e-01f, -6.37982711e-02f, 1.13493539e-01f, 3.06722969e-02f, 9.01968703e-02f, 1.08712316e-01f, 1.01357743e-01f, 5.96948564e-02f, -3.81573021e-01f, -1.64512396e-01f,
  3.53660494e-01f, 1.14264160e-01f, -8.34886879e-02f, -2.09983185e-01f, 4.26864624e-01f, 7.45261535e-02f, -3.01443070e-01f, -3.09295714e-01f, 4.11198556e-01f, -1.81358233e-01f,
  3.04050505e-01f, 3.52853239e-02f, -1.47916675e-01f, 3.47020239e-01f, 2.07164630e-01f, 1.10244833e-01f, 2.01249957e-01f, 2.36968800e-01f, 1.13142200e-01f, -2.12421957e-02f,
  -2.39827767e-01f, 7.33578429e-02f, -1.62353158e-01f, 1.68268770e-01f, -1.15316644e-01f, 1.60593703e-01f, 1.46047713e-03f, 7.33031183e-02f, 1.06897719e-01f, 1.34726748e-01f,
  -3.11956853e-01f, 8.54468644e-02f, -8.62209871e-02f, 2.79087543e-01f, -1.17995806e-01f, -2.08331551e-02f, -7.87060931e-02f, -8.58387128e-02f, -2.07170188e-01f, -5.66007718e-02f,
  3.19139391e-01f, -7.74858445e-02f, 7.87641183e-02f, 2.36162111e-01f, 2.41937667e-01f, 1.41744444e-03f, 2.40779519e-01f, -3.35971236e-01f, 1.42054427e-02f, 3.73911917e-01f,
  -1.43425584e-01f, -1.20216131e-01f, 1.82233348e-01f, -1.25766516e-01f, -6.82174936e-02f, 2.41350487e-01f, 1.86016202e-01f, -1.20732792e-01f, 9.37186256e-02f, 3.77286971e-01f,
  -1.46622872e-02f, -5.01803458e-02f, -2.12264359e-01f, -3.83606106e-01f, 4.09961998e-01f, 6.73023015e-02f, -4.75548953e-02f, -1.62990019e-01f, 1.13483764e-01f, -4.29064073e-02f,
  -1.28282038e-02f, -3.45532835e-01f, -2.48606756e-01f, 4.92030475e-03f, 1.41605377e-01f, -8.66437703e-02f, -2.31481105e-01f, -1.38674185e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -5.29248379e-02f, -2.63002608e-02f, -3.22864652e-02f, -1.10765290e-03f, -3.86478342e-02f, 6.02005050e-03f, -1.93457715e-02f, 7.62590542e-02f, -1.02625221e-01f, -1.36957085e-02f,
  5.55197857e-02f, 1.06548838e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    