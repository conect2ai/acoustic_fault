/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.42487046e-02f, -2.21465111e-01f, 1.53213769e-01f, 1.73650712e-01f, 4.87139896e-02f, 2.32599512e-01f, 2.65668899e-01f, 1.36103341e-02f, 3.09654564e-01f, 9.76504087e-02f,
  -6.36586314e-03f, -1.13608181e-01f, -1.00418299e-01f, 1.61603779e-01f, 1.75174281e-01f, 1.68179959e-01f, 1.40188932e-01f, 8.52857158e-02f, 8.80107691e-04f, -5.64777888e-02f,
  4.14050855e-02f, 1.85221364e-03f, 6.31412817e-03f, -1.51559293e-01f, 7.82281905e-02f, -4.18012552e-02f, -1.48777850e-02f, 5.33749815e-03f, -3.77375111e-02f, 8.20873212e-03f,
  -6.64771572e-02f, -4.77495380e-02f, -4.79937829e-02f, -7.63861835e-02f, -7.58150145e-02f, 2.52043456e-02f, -5.41188903e-02f, 7.90874436e-02f, -2.90962141e-02f, 5.02953194e-02f,
  4.01127897e-02f, 6.87768459e-02f, -7.78023899e-02f, 4.82709631e-02f, 1.50344474e-02f, -5.58221675e-02f, -2.85115950e-02f, 4.32124995e-02f, -6.66033477e-02f, 6.50964677e-02f,
  -2.98567582e-03f, -6.58578277e-02f, 1.56673547e-02f, 3.07223834e-02f, 2.37707072e-03f, 1.27220023e-02f, 5.10558523e-02f, 1.64799485e-02f, 2.42194347e-02f, 5.91027290e-02f,
  -6.94466308e-02f, -2.42857523e-02f, 4.67923330e-03f, -3.07866540e-02f, -8.90045688e-02f, -9.97828022e-02f, 2.33374294e-02f, -1.78120341e-02f, -8.66421033e-03f, -8.20306093e-02f,
  1.14879929e-01f, -7.08922595e-02f, -1.51815601e-02f, 3.26046124e-02f, 5.66220507e-02f, 2.01088991e-02f, 8.18717666e-03f, 6.52722493e-02f, 3.02487034e-02f, 2.72687599e-02f,
  7.61967227e-02f, -1.11374836e-02f, -1.00286655e-01f, 5.66662103e-02f, -1.42317368e-02f, -4.33689356e-03f, -4.44890605e-03f, 1.66066196e-02f, 1.41345905e-02f, -4.85300310e-02f,
  -8.32309127e-02f, -2.24143699e-01f, -9.68726948e-02f, 5.18202148e-02f, 2.23232247e-02f, -2.57100221e-02f, 1.75072234e-02f, 5.11817411e-02f, -9.21727419e-02f, 5.15917875e-02f,
  2.10148990e-02f, 4.14734297e-02f, -5.94132096e-02f, -2.62430385e-02f, -9.64424573e-03f, 6.92993551e-02f, 4.94178161e-02f, -7.60177001e-02f, -3.13948654e-02f, -1.05819419e-01f,
  -4.77165915e-02f, 3.45480852e-02f, -3.44010219e-02f, -2.35673543e-02f, -4.33469117e-02f, -2.61054300e-02f, -1.83176715e-02f, -9.33287200e-03f, -2.10263152e-02f, -2.00312380e-02f,
  -2.14579049e-02f, -1.17679155e-02f, 3.61030161e-01f, -5.51963784e-02f, -4.11359556e-02f, 1.35308936e-01f, 1.77277215e-02f, 6.34204894e-02f, 1.29891157e-01f, -2.10832432e-01f,
  -1.39857277e-01f, 3.63065787e-02f, 1.18513711e-01f, -1.96974501e-01f, 7.16720521e-02f, 1.38376504e-01f, -1.04079500e-01f, -1.11092538e-01f, 8.32881704e-02f, -2.18761172e-02f,
  1.69071600e-01f, -2.85199910e-01f, 1.28338918e-01f, -1.15221970e-01f, -9.52738002e-02f, 4.83492091e-02f, -1.87402710e-01f, 1.64800942e-01f, -2.84143180e-01f, 1.03553515e-02f,
  -6.98593333e-02f, 4.97247055e-02f, -5.02446964e-02f, -6.67198468e-03f, -1.37572065e-01f, -1.06563186e-02f, 2.41187564e-03f, 1.29909635e-01f, 1.55806346e-02f, -2.47004554e-02f,
  4.15825620e-02f, 4.17713225e-02f, -6.79257512e-02f, 7.13654980e-02f, 1.10368431e-01f, 2.91883834e-02f, 2.24784836e-02f, 2.44290717e-02f, 5.83516294e-03f, 3.24610472e-02f,
  1.02307111e-01f, 4.56861034e-02f, -1.17116468e-02f, 1.52047491e-03f, 5.06993644e-02f, 2.06529386e-02f, 4.90898304e-02f, 2.06908956e-02f, 1.19165117e-02f, 6.37081917e-03f,
  6.81193769e-02f, 2.07350552e-02f, -5.05777411e-02f, -1.78429708e-02f, -4.53101024e-02f, -4.09246888e-03f, -3.78593989e-03f, -1.55162183e-03f, -7.75764836e-03f, 2.66812239e-02f,
  -6.95837289e-02f, -3.73764634e-02f, 9.37549323e-02f, 5.10188863e-02f, -2.80291382e-02f, -3.69829722e-02f, 4.66758125e-02f, 1.48830062e-03f, -3.96932922e-02f, -3.42358015e-02f,
  3.07455920e-02f, -1.82650685e-02f, -2.66257650e-03f, -5.64390756e-02f, 5.17389625e-02f, 7.75525942e-02f, 8.86804163e-02f, 1.36442184e-01f, 5.34945168e-02f, 1.77922789e-02f,
  -1.29411221e-01f, -1.22000217e-01f, -3.88303362e-02f, -9.53511298e-02f, 1.88554835e-03f, -1.24376714e-02f, 1.13065593e-01f, -7.25526223e-03f, 4.59637344e-02f, 2.17853021e-03f,
  -6.15161620e-02f, -5.52799515e-02f, -3.70449610e-02f, -6.77024946e-02f, -5.53214177e-02f, 3.53981666e-02f, -1.26180779e-02f, -5.71736731e-02f, -1.47055909e-01f, -6.88682571e-02f,
  -8.40128139e-02f, 3.65744717e-03f, 4.73090447e-02f, -9.41199213e-02f, -2.67393850e-02f, -2.37048790e-02f, 4.76637706e-02f, 4.79213148e-03f, -7.58951306e-02f, -2.84198597e-02f,
  2.80846357e-01f, 2.02404767e-01f, -2.30197012e-01f, 8.10194165e-02f, 7.70462900e-02f, -1.23468235e-01f, -1.55914083e-01f, 5.47946356e-02f, 2.34364033e-01f, 1.34109154e-01f,
  -1.08103536e-01f, 1.02569766e-01f, -1.22571044e-01f, -2.48721149e-02f, -2.29656309e-01f, -9.05324221e-02f, -9.44136735e-03f, 6.20816052e-02f, 1.58198327e-02f, -2.11206414e-02f,
  -4.87787127e-02f, 5.53810298e-02f, -2.97252923e-01f, -3.16730179e-02f, 9.60034877e-02f, -4.18628417e-02f, -2.01564968e-01f, -1.94765985e-01f, -9.01251584e-02f, -7.93966800e-02f,
  1.97136343e-01f, 4.09821346e-02f, -1.67520847e-02f, -3.36608589e-02f, -6.19315915e-02f, -1.45766009e-02f, -9.51745808e-02f, -6.75893351e-02f, -7.74995610e-02f, -3.86225875e-03f,
  4.46733870e-02f, -2.88299322e-02f, 3.36347669e-02f, 2.97711492e-02f, 1.41602233e-01f, -2.10206043e-02f, 3.90440598e-02f, -1.23801734e-02f, 3.37663591e-02f, -6.72655404e-02f,
  -7.62669891e-02f, -5.52067952e-03f, -1.29711078e-02f, -4.39208634e-02f, -4.70256582e-02f, -4.74431030e-02f, -4.46073227e-02f, -3.76749672e-02f, -5.61782494e-02f, 6.09515831e-02f,
  -7.47430399e-02f, -4.37664650e-02f, 5.95859140e-02f, 7.60359019e-02f, -2.12922413e-02f, 4.04187515e-02f, -5.40128648e-02f, -3.49465832e-02f, -7.42980884e-03f, 9.07104164e-02f,
  8.36140662e-02f, 9.33038592e-02f, 2.68026404e-02f, 4.15691398e-02f, 5.01560532e-02f, 7.28755221e-02f, -3.28525789e-02f, 4.80962023e-02f, 1.09500952e-01f, 3.29486728e-02f,
  -2.34355442e-02f, -2.52402052e-02f, 6.16193702e-03f, 2.66490206e-02f, -6.78071752e-02f, -4.59776632e-02f, -6.72785193e-02f, -3.25113125e-02f, -4.44757454e-02f, -1.00018971e-01f,
  1.22812785e-01f, -1.15051948e-01f, 9.16527398e-03f, 6.15818612e-02f, -1.82205793e-02f, -1.70630985e-03f, -6.24411739e-02f, 4.80730645e-03f, 3.00101470e-02f, -1.90390386e-02f,
  -1.89579558e-02f, 5.80046736e-02f, 1.86841730e-02f, 5.37966937e-02f, -2.30911896e-02f, -3.02946046e-02f, -4.34221476e-02f, 5.27205430e-02f, -4.52159308e-02f, -2.68793898e-03f,
  4.26539108e-02f, -7.12767765e-02f, -9.20933783e-02f, 4.64814939e-02f, 1.85796265e-02f, 3.05536017e-02f, 4.77578342e-02f, -3.12381554e-02f, -7.63501450e-02f, -1.42453909e-01f,
  -2.09540159e-01f, 3.30557711e-02f, 9.09145698e-02f, -2.93472290e-01f, 9.04856771e-02f, -1.12303503e-01f, -1.79380968e-01f, 5.96147813e-02f, 3.26672085e-02f, 1.05638951e-01f,
  -1.18820749e-01f, -1.14578128e-01f, 8.13593939e-02f, -3.19677800e-01f, -3.85977626e-01f, -1.04629785e-01f, -3.72633964e-01f, -2.62073249e-01f, -9.38807577e-02f, -1.33492842e-01f,
  -5.22279106e-02f, -2.36765534e-01f, -8.92247483e-02f, 1.45117834e-01f, 5.35346642e-02f, 2.08089352e-01f, 1.58325601e-02f, 1.87757760e-01f, -1.23392329e-01f, -8.29195306e-02f,
  1.68375298e-02f, -1.72263645e-02f, 5.13630696e-02f, 2.65501644e-02f, -3.56339850e-02f, 4.35423441e-02f, -3.22116446e-03f, 8.52056127e-03f, 4.60813269e-02f, -2.10529678e-02f,
  5.65734804e-02f, -7.09215924e-02f, -8.01924765e-02f, -1.61539167e-02f, 3.39416899e-02f, 2.07659788e-02f, 9.00386740e-03f, 1.11876413e-01f, -3.77426622e-03f, -7.00540841e-02f,
  -2.37915143e-02f, -1.28595764e-02f, -4.61913198e-02f, 1.93878096e-02f, -1.20808212e-02f, -6.43460006e-02f, -5.75073212e-02f, 5.30962236e-02f, -1.05837816e-02f, -5.03605343e-02f,
  -7.81062171e-02f, -7.01650418e-03f, 1.10185323e-02f, 1.05477509e-03f, -7.47064203e-02f, 8.19227565e-03f, -1.87907871e-02f, -1.79743469e-02f, 3.54803205e-02f, -6.98511973e-02f,
  2.41643433e-02f, -1.60791613e-02f, -4.04057801e-02f, 4.18796316e-02f, -4.54168804e-02f, -3.44959274e-02f, -2.58182120e-02f, -3.80783319e-03f, -1.08612366e-02f, 4.56107818e-02f,
  -5.03973253e-02f, -1.32344281e-02f, 1.68547463e-02f, 5.86199127e-02f, -2.56698783e-02f, 5.19247465e-02f, -1.84595063e-02f, 6.64270073e-02f, 7.02810362e-02f, -3.05719171e-02f,
  -3.22934203e-02f, -1.05348527e-01f, 3.45924273e-02f, 7.55558908e-02f, -3.28880064e-02f, -7.62307346e-02f, -5.18443435e-02f, -2.00132057e-02f, 1.62611995e-02f, -5.54118343e-02f,
  -4.91631739e-02f, -6.08106367e-02f, 4.18672562e-02f, 5.78351431e-02f, -2.60245521e-02f, -3.66388522e-02f, -2.97899991e-02f, -2.53793821e-02f, -4.90105003e-02f, -8.07932913e-02f,
  2.48991065e-02f, -2.48870570e-02f, -1.06765423e-03f, 7.52922334e-03f, 7.14785978e-03f, -1.90414041e-02f, -2.33202595e-02f, 2.64629740e-02f, 4.45078732e-03f, 1.78207178e-02f,
  3.67927909e-01f, -2.70941794e-01f, 2.21845135e-01f, 2.04801843e-01f, -6.33721724e-02f, -1.17876753e-01f, -1.37544340e-02f, 1.24112271e-01f, 2.01473475e-01f, -1.34870276e-01f,
  -3.64358239e-02f, 2.74256170e-02f, -1.17634580e-01f, 6.80522248e-03f, 2.58408427e-01f, -4.04185988e-03f, 1.53639257e-01f, 6.93020597e-02f, 5.67410551e-02f, 1.55435249e-01f,
  1.24200940e-01f, 6.29798323e-03f, 2.15524673e-01f, -8.65309313e-02f, 1.37877658e-01f, 9.83982235e-02f, 2.42358297e-02f, -2.32964884e-02f, -2.45184936e-02f, -1.32928714e-01f,
  9.87452790e-02f, 6.42514005e-02f, 1.37751073e-01f, 5.67457415e-02f, -2.52490095e-03f, -7.90431630e-03f, -3.61910835e-03f, -5.14215864e-02f, 6.47227885e-03f, -3.44872773e-02f,
  -6.81774542e-02f, 2.91225314e-02f, -3.30032930e-02f, 1.81164835e-02f, -1.06850790e-03f, -2.54295077e-02f, -6.04954436e-02f, -2.75474656e-02f, -5.51733300e-02f, -7.73202116e-03f,
  9.22539085e-03f, 1.42774666e-02f, -3.91276628e-02f, -3.49361748e-02f, 3.61053199e-02f, -8.37907270e-02f, 1.94539968e-02f, 2.85241641e-02f, -4.68160585e-02f, 3.89046827e-03f,
  -5.01108617e-02f, 2.68842112e-02f, 3.20360921e-02f, 9.72617927e-05f, -3.94317955e-02f, -9.46124643e-03f, 2.48583290e-03f, 4.28144960e-03f, -2.87578125e-02f, -3.59183252e-02f,
  5.87102957e-02f, 8.69737845e-03f, 7.15169534e-02f, 1.70758758e-02f, -6.91773295e-02f, 1.16843758e-02f, -4.59688948e-03f, 2.69279312e-02f, 7.16551989e-02f, -4.12974181e-03f,
  -1.14800467e-03f, -2.22072247e-02f, -1.00348261e-03f, 1.40665984e-02f, -4.77712229e-02f, 1.04202582e-02f, 4.68759127e-02f, -2.99478266e-02f, -1.46723748e-03f, 1.41979903e-02f,
  -4.36615758e-02f, 2.26715982e-01f, -1.24953315e-02f, 1.08908871e-02f, 2.99420580e-02f, -2.09150929e-02f, 9.14256498e-02f, -1.13418000e-02f, -8.35245624e-02f, 2.84944773e-02f,
  -3.55538763e-02f, -3.83982016e-03f, 8.53160322e-02f, -5.82557395e-02f, -1.10310828e-02f, 1.16339745e-02f, 7.92724267e-02f, -1.03963353e-02f, 9.97834280e-02f, 1.51780499e-02f,
  3.08792498e-02f, 7.71508887e-02f, -2.72848383e-02f, 2.31430121e-02f, -5.73343150e-02f, -2.17712764e-02f, 5.49790226e-02f, -2.37587392e-02f, 5.80056617e-03f, -1.44547392e-02f,
  -2.79606819e-01f, 8.58899876e-02f, 4.08437923e-02f, -1.01971909e-01f, -1.19901083e-01f, -3.08701783e-01f, -2.62969583e-01f, -2.84131300e-02f, -2.27008089e-01f, 4.76767197e-02f,
  3.53494249e-02f, 1.15635797e-01f, 1.23496652e-01f, -1.79343596e-01f, -3.53835046e-01f, -1.57268660e-03f, -2.50405908e-01f, -5.65833086e-03f, -5.37111387e-02f, -5.16657792e-02f,
  -6.05955608e-02f, -2.15642571e-01f, 7.08322749e-02f, -6.50983490e-03f, 9.31520946e-04f, 1.78173378e-01f, 2.22761154e-01f, 6.24008402e-02f, 3.06645837e-02f, -2.18183026e-02f,
  3.30218077e-02f, -1.85379814e-02f, -1.88483447e-02f, -4.41343002e-02f, -7.25740269e-02f, 1.70639548e-02f, -1.38333151e-02f, 8.07271302e-02f, 1.04623437e-02f, -1.37393177e-02f,
  -2.08698940e-02f, -4.27090600e-02f, -5.62176332e-02f, -4.04565893e-02f, -1.31564764e-02f, 2.63587013e-02f, -2.15599332e-02f, 4.55294363e-02f, -5.90481348e-02f, 8.25726893e-04f,
  -3.00484058e-02f, 2.08230056e-02f, 1.99917052e-03f, 6.64283708e-02f, 8.70445967e-02f, 1.30058359e-02f, 9.39569809e-03f, 3.19187567e-02f, -4.94915619e-02f, -3.41648720e-02f,
  6.50783405e-02f, -2.34690476e-02f, 2.02942733e-02f, 1.56679768e-02f, -7.21324533e-02f, 1.53996088e-02f, 3.07669342e-02f, 8.66536424e-02f, 4.25166115e-02f, -1.32130813e-02f,
  -2.73044482e-02f, -8.17934796e-02f, 5.26957260e-03f, -3.77001241e-02f, 1.19035412e-02f, -6.65365830e-02f, 6.82995766e-02f, -3.13702002e-02f, -3.74193094e-03f, -3.33326161e-02f,
  9.24592167e-02f, -1.22290790e-01f, 5.20668505e-03f, 6.14240617e-02f, 8.93027056e-03f, 9.55648895e-04f, 1.47349238e-02f, 3.79814059e-02f, 5.32023981e-02f, -8.88708308e-02f,
  -1.74530447e-02f, 5.58742508e-02f, 4.32726778e-02f, 6.26985356e-03f, 6.99006468e-02f, 3.94434817e-02f, -5.61438873e-02f, -5.09913303e-02f, 1.67277623e-02f, -1.08700275e-01f,
  5.85962869e-02f, -1.94835605e-03f, -1.49992537e-02f, -1.81781538e-02f, -6.42677397e-02f, -9.10533741e-02f, 5.44235595e-02f, 3.55735496e-02f, 1.37868784e-02f, 6.43780455e-02f,
  7.15025961e-02f, -5.10630906e-02f, -3.66385393e-02f, -6.39520213e-02f, -2.45039184e-02f, 4.15169038e-02f, -9.55062266e-03f, -4.71102819e-02f, -6.61850395e-03f, 8.98703933e-02f,
  3.21395636e-01f, -1.08127497e-01f, 1.60963595e-01f, 2.35275328e-01f, 4.77022715e-02f, -1.41223110e-02f, 8.79797805e-03f, -1.09581398e-02f, 2.07890779e-01f, -2.87372172e-01f,
  -1.64814547e-01f, 2.49003068e-01f, -2.64760137e-01f, -3.05100940e-02f, 1.90512791e-01f, -1.07336886e-01f, 2.20235493e-02f, -7.33384117e-02f, 6.99611083e-02f, -1.68110430e-02f,
  8.14381912e-02f, -1.72602102e-01f, 9.57326964e-02f, -2.21207857e-01f, 3.21847834e-02f, 9.62092280e-02f, -2.08633676e-01f, -5.62145039e-02f, 6.50908379e-03f, 2.25421116e-02f,
  8.99553075e-02f, 2.41257697e-02f, 6.69374019e-02f, 8.75719488e-02f, -6.27976358e-02f, -1.01784557e-01f, 1.65333524e-02f, -5.56161394e-03f, 7.60369524e-02f, -1.25528816e-02f,
  -1.45732239e-03f, 3.34348641e-02f, -3.91597226e-02f, 1.42345391e-02f, -2.13174131e-02f, 1.16504207e-01f, 3.09012495e-02f, -5.49170151e-02f, 6.21155649e-02f, 8.86085816e-03f,
  1.80182699e-02f, -6.21088967e-03f, 3.71718258e-02f, -1.76772662e-02f, 2.06140075e-02f, 6.43254369e-02f, 5.45585947e-03f, -2.12836973e-02f, 6.43463712e-03f, -6.30785972e-02f,
  -1.31755695e-01f, -8.36605206e-02f, -1.74147300e-02f, 8.04948956e-02f, 4.96778637e-02f, 4.82415333e-02f, -2.11267304e-02f, -6.35434762e-02f, 8.60841200e-03f, 1.90620814e-02f,
  5.90624362e-02f, 3.23471017e-02f, -1.72014143e-02f, 3.02738212e-02f, -3.85394432e-02f, 7.81882629e-02f, 4.75339368e-02f, -3.02751027e-02f, -5.95224760e-02f, 1.87867731e-02f,
  -1.11933574e-02f, -6.94755930e-03f, -8.64554103e-03f, -4.62036878e-02f, -4.36908901e-02f, 5.70591597e-04f, -1.36160431e-02f, 2.27259547e-02f, 3.46236676e-02f, -1.12450691e-02f,
  -1.88441128e-01f, -3.06783199e-01f, -1.76729914e-02f, 6.88693859e-03f, -3.64655778e-02f, -8.65182132e-02f, -3.36673930e-02f, 5.04841805e-02f, 3.58086675e-02f, 3.05767125e-03f,
  -3.85017917e-02f, 1.89735778e-02f, -4.63543236e-02f, 6.65200800e-02f, 6.40478432e-02f, -8.37704763e-02f, -4.15035971e-02f, -2.47704796e-02f, -2.97436025e-02f, -8.66848677e-02f,
  -6.69284835e-02f, -3.49647142e-02f, -1.78872179e-02f, -3.39884125e-02f, -7.20969960e-02f, -2.23748628e-02f, -6.45027980e-02f, 2.66390648e-02f, -1.04998022e-01f, -5.35097159e-02f,
  -8.35777298e-02f, 7.28798434e-02f, -2.82568961e-01f, -1.65691763e-01f, -1.11965172e-01f, 7.71437213e-02f, 1.49680302e-03f, -4.83071357e-02f, 1.57109618e-01f, 1.20280892e-01f,
  -1.08522013e-01f, 3.95641364e-02f, 1.91187486e-01f, 4.19128872e-02f, 7.32364058e-02f, 2.61272937e-01f, 7.62458146e-02f, -3.44535895e-02f, -1.21933883e-02f, -5.88714741e-02f,
  -7.74316490e-02f, 2.34690621e-01f, -2.85782907e-02f, 8.57385397e-02f, -8.58355165e-02f, -1.65295392e-01f, 3.24942805e-02f, -1.47908209e-02f, -1.55948579e-01f, 1.73877016e-01f,
  -2.47067399e-02f, 6.10980317e-02f, -6.17439076e-02f, 4.76893485e-02f, -6.22476637e-02f, 2.74827424e-02f, -2.40613148e-02f, 4.59038727e-02f, -6.94891214e-02f, -1.33362622e-03f,
  1.24833420e-01f, -2.33500525e-02f, 8.99714828e-02f, 4.63651121e-02f, -5.03312796e-02f, 6.87496411e-03f, -1.69782974e-02f, -1.22416899e-01f, -5.65571636e-02f, -1.27814999e-02f,
  -3.35455239e-02f, -6.73444793e-02f, -5.53383306e-02f, 4.88258488e-02f, -3.86555865e-02f, -7.96126574e-03f, 1.45631726e-04f, -8.25063139e-02f, 7.02944696e-02f, 4.28904630e-02f,
  4.46950160e-02f, 2.00599506e-02f, -2.01156158e-02f, -5.93530312e-02f, 2.42457557e-02f, -4.38983440e-02f, 2.98528131e-02f, 4.10052724e-02f, -7.23233894e-02f, -4.89804000e-02f,
  -8.95354375e-02f, -2.92442124e-02f, 1.79407187e-02f, -6.38041124e-02f, -5.88937514e-02f, 3.99999395e-02f, -1.08959317e-01f, 3.59681249e-02f, -1.41753405e-01f, -7.68859833e-02f,
  1.79923829e-02f, 1.14225345e-02f, -3.77263725e-02f, -1.32283391e-02f, 5.52361272e-02f, -8.10855068e-03f, 4.21090424e-02f, -1.43221561e-02f, -9.42137465e-03f, 3.72757241e-02f,
  3.85175645e-02f, 2.66927034e-01f, 3.39233801e-02f, -7.45916516e-02f, 3.74795459e-02f, -5.58581278e-02f, 6.94828331e-02f, 8.02866966e-02f, 1.95494131e-03f, 7.19366148e-02f,
  -4.09552939e-02f, -8.93639401e-03f, 3.46968435e-02f, -3.87636833e-02f, 5.77893388e-03f, -5.86421750e-02f, 5.97199500e-02f, 3.08034457e-02f, 1.73285080e-03f, -5.63745461e-02f,
  1.20653501e-02f, -3.35300155e-02f, 1.21170066e-01f, -4.14693030e-03f, 2.32969318e-02f, -2.05974057e-02f, -6.27649873e-02f, -2.55998336e-02f, 6.45582825e-02f, -1.08588357e-02f,
  1.12194538e-01f, 2.95502484e-01f, 7.56920576e-02f, 5.27535342e-02f, -5.45117073e-03f, -2.32281595e-01f, -1.58190548e-01f, 5.01887873e-02f, 8.03554431e-02f, -1.17951864e-02f,
  -1.48881093e-01f, 1.87483713e-01f, 2.62451861e-02f, -1.29770547e-01f, -1.24909602e-01f, 8.28608125e-03f, -1.57190874e-01f, -8.10255557e-02f, 9.26509574e-02f, 1.77662283e-01f,
  8.51676762e-02f, -1.64755046e-01f, -1.45856425e-01f, -1.38991233e-02f, -7.00442120e-02f, 1.83480382e-01f, -2.35295296e-02f, 6.21531978e-02f, -9.14430991e-02f, -1.23447940e-01f,
  -4.14130799e-02f, 4.43380214e-02f, -8.71578883e-03f, 3.25308368e-02f, -9.16850343e-02f, 3.18758525e-02f, -5.79074509e-02f, -4.06174138e-02f, 2.03898847e-02f, 8.59348476e-02f,
  -9.42043029e-03f, -2.74975202e-03f, -7.74810417e-03f, -5.89101538e-02f, 3.42264548e-02f, 2.96212193e-02f, 7.11537246e-03f, -1.32060975e-01f, 2.50552166e-02f, 6.12344220e-03f,
  2.20726356e-02f, 2.30144765e-02f, -2.54921243e-03f, -1.84571650e-02f, -2.26982553e-02f, 4.08751182e-02f, -4.95022684e-02f, 3.32840458e-02f, 1.10762725e-02f, 1.17165921e-02f,
  1.82053819e-02f, 5.21310419e-02f, 7.29904091e-03f, 5.88288978e-02f, 4.25293110e-02f, -4.44270410e-02f, 6.05193861e-02f, -1.05075300e-01f, 4.40919437e-02f, 2.59201601e-02f,
  -1.12988643e-01f, 9.29624680e-03f, 1.82856433e-02f, -1.55001488e-02f, 1.49684157e-02f, -6.21443838e-02f, -9.47496593e-02f, -6.33151457e-03f, 1.82143953e-02f, -8.57823193e-02f,
  -9.20278300e-03f, -2.85684306e-04f, -2.04447545e-02f, -4.95568588e-02f, -3.41145359e-02f, 5.24609815e-03f, -1.43345604e-02f, -5.01137041e-02f, 1.15207816e-02f, 2.08241008e-02f,
  1.49798378e-01f, 2.07990974e-01f, -5.97985201e-02f, -7.54220635e-02f, 4.64245975e-02f, -4.57010530e-02f, -3.84751670e-02f, -2.66417097e-02f, 4.15752009e-02f, -4.79779430e-02f,
  -4.35177386e-02f, -9.11994197e-04f, 1.09336823e-01f, 2.85400189e-02f, -8.26532952e-03f, 6.58303201e-02f, -2.58154050e-02f, 2.39686687e-02f, -4.74396572e-02f, 2.57406440e-02f,
  7.04291044e-03f, -3.66520323e-02f, -4.48008142e-02f, -2.13487204e-02f, -9.98954251e-02f, 6.46637613e-03f, 1.58499042e-03f, 4.65011038e-02f, 1.27497017e-02f, 3.94392386e-02f,
  -1.46399871e-01f, -1.91571489e-02f, -1.49417490e-01f, -1.53605148e-01f, -9.70579311e-02f, 1.70265704e-01f, -1.15234122e-01f, 8.99078697e-03f, -1.67795181e-01f, 7.49699622e-02f,
  1.29620228e-02f, -1.87875986e-01f, 9.17524546e-02f, 1.58475608e-01f, 2.46970311e-01f, 2.05039531e-01f, 4.84598950e-02f, -9.25251096e-02f, 5.31359464e-02f, -1.14833370e-01f,
  3.06600686e-02f, 2.39252150e-01f, 4.41153012e-02f, 1.43060371e-01f, -3.32357399e-02f, -8.67404491e-02f, 1.49730861e-01f, -1.09027110e-01f, 5.40941916e-02f, 4.75630574e-02f,
  -5.41831600e-03f, -1.95654735e-01f, -1.57886624e-01f, -1.00335982e-02f, 3.49898413e-02f, 4.33730036e-02f, 1.27629181e-02f, -5.69974817e-03f, -7.35590681e-02f, 6.69896677e-02f,
  -2.09629145e-02f, 5.21551184e-02f, 1.91754401e-02f, -6.52652141e-03f, -6.86913952e-02f, -9.63255484e-03f, 3.11093424e-02f, 2.95546325e-03f, -9.82475504e-02f, -8.10733661e-02f,
  2.85450253e-04f, 3.55370753e-02f, -1.10099897e-01f, -4.30037938e-02f, -7.16086244e-03f, -1.16430312e-01f, -2.09064800e-02f, -2.07522847e-02f, -3.25201899e-02f, -1.73150692e-02f,
  3.21818180e-02f, 2.42984295e-02f, -2.98187174e-02f, 4.96215709e-02f, 2.89084893e-02f, 1.27508398e-02f, -6.69002533e-02f, 4.64992411e-02f, -1.11250833e-01f, 3.89059773e-03f,
  -5.67436889e-02f, -9.11202654e-02f, -2.87458096e-02f, -5.57483407e-03f, -1.77647322e-02f, -7.72335008e-02f, 9.91157256e-03f, 6.61467984e-02f, 1.64700616e-02f, 1.15989977e-02f,
  4.47931215e-02f, -4.30070572e-02f, 2.94610709e-02f, -4.61674072e-02f, 8.36876631e-02f, -3.89312916e-02f, 4.62273881e-02f, -4.53930870e-02f, -6.00533374e-02f, -4.14644834e-03f,
  1.32143393e-01f, -2.75562634e-03f, -5.75485304e-02f, 6.04025945e-02f, 2.84750829e-03f, 4.17296067e-02f, 2.03362629e-02f, 3.32665932e-03f, -5.90533530e-03f, 3.53743732e-02f,
  8.58551189e-02f, 2.50988137e-02f, 2.25379188e-02f, 4.62335497e-02f, 8.88001639e-03f, 7.60857314e-02f, -2.15519592e-02f, 2.50082258e-02f, -2.97143590e-02f, 5.06474003e-02f,
  -4.76054251e-02f, 1.47856046e-02f, -6.45631105e-02f, 2.23537646e-02f, -2.82082204e-02f, 5.53349499e-03f, -6.67372427e-04f, -5.94520420e-02f, 4.29193862e-02f, 1.47989411e-02f,
  -1.73695594e-01f, 4.12609041e-01f, -1.90189809e-01f, 1.88487753e-01f, 1.06308840e-01f, 1.18884280e-01f, -6.37473166e-02f, 2.20335439e-01f, 4.59368378e-02f, 2.02275887e-01f,
  -1.93027668e-02f, -1.90903738e-01f, -1.22460328e-01f, 3.83886456e-01f, -1.44487277e-01f, -5.79062244e-03f, 2.31629059e-01f, 8.84956401e-03f, 1.63044427e-02f, 2.77256608e-01f,
  4.10624072e-02f, 2.82920092e-01f, -5.83898425e-02f, 1.83308348e-01f, 1.06604628e-01f, -2.21920125e-02f, 3.98381501e-02f, -1.40899703e-01f, 1.35286197e-01f, -9.03737620e-02f,
  4.80531417e-02f, 9.05941501e-02f, -1.15178764e-01f, -1.34493202e-01f, -5.00885136e-02f, -7.92736337e-02f, -8.15541670e-02f, -1.55139118e-01f, -7.99315497e-02f, -4.45506833e-02f,
  -7.64192119e-02f, 2.60302201e-02f, 5.46046048e-02f, -1.43353024e-03f, 7.18095750e-02f, -1.13407731e-01f, -8.54828022e-03f, -3.10711898e-02f, -1.24168387e-02f, 2.32839603e-02f,
  2.22276952e-02f, 4.12979871e-02f, 4.91741709e-02f, 5.22455387e-02f, -6.94601014e-02f, 5.96379004e-02f, 4.32463139e-02f, -6.05449751e-02f, -6.80324715e-03f, 3.89927924e-02f,
  -4.13592644e-02f, -3.88951935e-02f, -2.87394933e-02f, -6.95836693e-02f, 2.79030539e-02f, -5.15653566e-02f, 1.63386185e-02f, -7.26947859e-02f, -1.76440440e-02f, 2.16919370e-02f,
  8.73619542e-02f, -8.90446390e-05f, 6.13658130e-02f, 8.02877694e-02f, 7.37140281e-03f, 5.62881567e-02f, -1.31956160e-01f, -1.29290028e-02f, 2.19027046e-02f, -4.06564735e-02f,
  -5.39121665e-02f, 3.89647819e-02f, -1.54733239e-02f, -4.53581959e-02f, 1.34900473e-02f, -4.98095602e-02f, 4.81702238e-02f, -5.74169345e-02f, -7.81478453e-03f, 1.32015664e-02f,
  1.01833075e-01f, 2.14953318e-01f, -1.92425847e-02f, 4.90596220e-02f, 2.29228325e-02f, 4.79969755e-02f, -2.78634280e-02f, 5.59148304e-02f, 5.48087293e-03f, 6.16214238e-02f,
  -3.26726362e-02f, -3.03413719e-02f, 2.34302096e-02f, 6.33038208e-03f, 1.20653780e-02f, 3.85020673e-02f, -5.92584070e-03f, -3.87607366e-02f, -4.34330245e-03f, 4.04493064e-02f,
  2.69091595e-02f, -1.15057537e-02f, -6.94007874e-02f, 6.39114752e-02f, 8.29615146e-02f, -1.71127915e-02f, 1.05530165e-01f, -4.46242765e-02f, -5.23637310e-02f, 2.42374875e-02f,
  2.93794781e-01f, -2.35357434e-01f, -7.59716518e-03f, -2.41974548e-01f, 3.67189720e-02f, -9.87941623e-02f, 2.60349866e-02f, -1.56324536e-01f, -1.04156621e-01f, -1.89334080e-01f,
  -2.24167034e-02f, -6.52860664e-03f, 5.70883453e-02f, -2.58567750e-01f, 3.74678791e-01f, 2.42999799e-04f, -2.41623953e-01f, -1.45688713e-01f, 1.70431193e-02f, -1.33152977e-01f,
  4.41452228e-02f, -1.52388215e-01f, -3.98885412e-03f, -9.53850597e-02f, -2.82218140e-02f, -2.63753720e-02f, 9.64192525e-02f, 1.94235936e-01f, -1.89313293e-01f, 1.23615459e-01f,
  -4.53065485e-02f, -5.93231693e-02f, -1.63803231e-02f, -2.13609301e-02f, -7.66517296e-02f, -8.03125929e-03f, 2.45535057e-02f, 1.76045924e-01f, -1.75037459e-02f, 3.47793140e-02f,
  -6.88951649e-03f, 7.42890313e-02f, -1.09924376e-01f, 3.14069241e-02f, 4.79496736e-03f, -1.68949384e-02f, -9.11748968e-03f, -8.39053690e-02f, -8.67202133e-02f, -1.06447833e-02f,
  -1.18493317e-02f, -4.81710136e-02f, -3.10822390e-02f, -5.23257703e-02f, 6.50241897e-02f, -8.95922706e-02f, -1.58398375e-02f, 5.15224300e-02f, -1.34332273e-02f, -5.16736470e-02f,
  8.37774649e-02f, 5.66859590e-03f, -2.73770746e-02f, -1.12131275e-02f, 7.08252890e-04f, -3.89059521e-02f, -1.34209730e-02f, -2.68689748e-02f, 3.32389548e-02f, -5.17326742e-02f,
  -1.60517227e-02f, -7.20303729e-02f, -2.12821625e-02f, -1.08290585e-02f, -2.02324074e-02f, -6.86455965e-02f, 7.86737725e-02f, -4.15823683e-02f, -3.15964222e-02f, -4.68880916e-03f,
  3.37305814e-02f, 1.02804350e-02f, 1.32309608e-02f, 2.22474746e-02f, -3.27231660e-02f, 4.92411405e-02f, -4.01963219e-02f, -2.50192638e-02f, -5.39361686e-03f, 5.70049509e-02f,
  -6.69343770e-02f, -1.09069802e-01f, -2.68505830e-02f, 7.58946873e-04f, 3.58330347e-02f, -3.92841958e-02f, -5.26332743e-02f, -4.20158282e-02f, 4.93541434e-02f, -3.04338504e-02f,
  3.26034729e-03f, -8.14079866e-02f, 5.23414537e-02f, 6.58872351e-02f, 2.86370590e-02f, -2.53872778e-02f, 5.68413697e-02f, 5.87656209e-03f, 3.88171598e-02f, -3.22420262e-02f,
  -2.60266382e-02f, 5.89897744e-02f, 5.59947900e-02f, -3.22902501e-02f, -8.83206651e-02f, 6.35096431e-02f, -4.35096994e-02f, 2.22534314e-02f, 4.73300554e-02f, 3.45013035e-03f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.09207484e-02f, -1.34452283e-01f, -1.84915617e-01f, -8.65301117e-02f, 1.34241119e-01f, 1.58697173e-01f, -5.50441034e-02f, -4.52016145e-02f, -1.88612282e-01f, -3.22710052e-02f,
  8.20573866e-02f, -1.43809110e-01f, -1.34571165e-01f, -2.04039559e-01f, -2.07838908e-01f, -2.80711085e-01f, -5.86553253e-02f, 5.98386638e-02f, -1.63487062e-01f, 1.28487349e-01f,
  -7.85577819e-02f, 4.23964448e-02f, -1.60920262e-01f, 1.80930018e-01f, 2.26854950e-01f, 1.84429869e-01f, 2.51431644e-01f, 4.58683707e-02f, 2.32545555e-01f, 8.34649727e-02f,
  -1.50647247e-02f, -1.11130983e-01f, 2.74575204e-02f, 3.68355680e-03f, 9.75778550e-02f, 1.88387349e-01f, 1.40225351e-01f, 3.44855450e-02f, 5.81934415e-02f, -1.03226751e-01f,
  7.88000301e-02f, 8.26363042e-02f, 5.81681281e-02f, -3.41271162e-02f, 5.53740300e-02f, -3.46374065e-02f, -1.76428437e-01f, 3.56373563e-02f, -9.59637091e-02f, -8.56754035e-02f,
  -1.24444775e-02f, 7.37325894e-03f, 8.28634501e-02f, 1.30206319e-02f, -8.28025118e-02f, 3.28619629e-02f, 1.32906795e-01f, 9.22467709e-02f, 1.01828568e-01f, -9.86115858e-02f,
  7.73209706e-02f, -1.31964004e-02f, -6.34531677e-02f, -1.14226863e-01f, -1.07415661e-01f, 4.39224467e-02f, -7.51145184e-02f, 8.12159479e-02f, -7.29340538e-02f, -7.64412656e-02f,
  -1.36694149e-03f, -4.48449515e-02f, 2.29643174e-02f, 3.31179239e-02f, -2.03554198e-04f, -1.57086868e-02f, 3.33096534e-02f, -1.01157408e-02f, -6.98116198e-02f, 1.43586472e-02f,
  -6.01269421e-04f, 6.15725070e-02f, -4.72817719e-02f, 9.54000950e-02f, -8.67811367e-02f, -3.04490095e-03f, -5.03700897e-02f, 4.17392813e-02f, -1.40714161e-02f, 1.62094757e-01f,
  5.73350303e-02f, -1.02243870e-02f, -9.01063234e-02f, -1.14691235e-01f, -5.89472800e-02f, -3.52377556e-02f, -7.51177073e-02f, 5.05136838e-03f, -3.16853374e-02f, 6.88723624e-02f,
  1.51141122e-01f, 1.39291644e-01f, 1.79903522e-01f, -4.48884033e-02f, 8.09548870e-02f, 1.01766838e-02f, 1.24021675e-02f, 3.50721218e-02f, 1.68594331e-01f, 8.55340585e-02f,
  3.67259346e-02f, 4.70622890e-02f, 2.23755483e-02f, 1.67409540e-03f, 1.28396124e-01f, 4.11107466e-02f, 1.27904415e-01f, 3.49134044e-03f, 5.01375012e-02f, 3.72980232e-03f,
  -1.01308882e-01f, -7.08278418e-02f, 3.06173824e-02f, -3.01597089e-01f, 1.14061512e-01f, -1.40677258e-01f, -9.98409167e-02f, -2.88453937e-01f, -2.08932325e-01f, -2.29221985e-01f,
  -2.56452948e-01f, 2.15323642e-01f, 2.95460850e-01f, -3.41759026e-01f, 1.06985427e-01f, 1.33550853e-01f, -3.29096675e-01f, -4.01782617e-02f, -8.66076648e-02f, -3.25817019e-02f,
  -7.63336495e-02f, -2.99742281e-01f, 5.35723232e-02f, -1.77590474e-01f, -1.75341621e-01f, -8.97579119e-02f, -7.73861678e-03f, 1.77819431e-01f, -1.92067847e-01f, -4.55370173e-03f,
  -1.15373626e-01f, -1.58719957e-01f, 9.41330716e-02f, 1.34688675e-01f, -1.22174576e-01f, 5.55458218e-02f, 1.90000817e-01f, 9.01490673e-02f, 3.46794836e-02f, 1.41582377e-02f,
  4.84670997e-02f, -5.58502832e-03f, -1.16476484e-01f, 1.75556228e-01f, -4.43476588e-02f, -5.31604104e-02f, -1.23795316e-01f, 3.11546903e-02f, -3.79640982e-02f, 1.36311387e-03f,
  5.95679507e-03f, 2.51734499e-02f, -5.88454530e-02f, 5.74557073e-02f, -6.79130014e-03f, -3.49808820e-02f, -4.71613370e-02f, 2.16132715e-01f, -5.33321835e-02f, -8.91886353e-02f,
  -2.98146959e-02f, -7.04879314e-02f, 8.97568837e-02f, -3.67230251e-02f, -9.66562554e-02f, 2.79703904e-02f, -1.52224451e-02f, 4.08797190e-02f, -1.37442976e-01f, -3.42463963e-02f,
  4.71452400e-02f, 3.27571407e-02f, -4.12931889e-02f, 6.00996334e-03f, -3.39713283e-02f, 3.60781252e-02f, 1.04327105e-01f, -2.15240274e-04f, 2.24357452e-02f, -3.69907804e-02f,
  -5.23969792e-02f, -7.62611860e-03f, -8.75663236e-02f, 1.92928351e-02f, 1.28648832e-01f, 4.73173261e-02f, 2.46744398e-02f, 7.55272284e-02f, 5.82214780e-02f, 9.51076895e-02f,
  -2.15717897e-01f, -2.13792607e-01f, -5.65455407e-02f, 5.13668656e-02f, 2.99973576e-03f, -1.65414549e-02f, 2.15852819e-02f, -3.96637544e-02f, -1.05366208e-01f, -5.81399798e-02f,
  -3.17659155e-02f, 2.43934356e-02f, 1.62749714e-03f, -4.25895564e-02f, 3.64941768e-02f, -3.17159034e-02f, -8.53674039e-02f, 9.24044624e-02f, 6.24163114e-02f, -2.82916799e-02f,
  -6.56312555e-02f, -6.25698864e-02f, -6.73059076e-02f, -9.55353975e-02f, 9.48706865e-02f, 6.50193542e-02f, 2.21699532e-02f, 3.02891191e-02f, 1.22065514e-01f, -1.34094097e-02f,
  -2.88448632e-01f, 2.34373599e-01f, -1.14925705e-01f, -3.67016792e-01f, 3.55706662e-02f, -1.02744594e-01f, -3.05108696e-01f, -5.60333692e-02f, -1.58543664e-03f, -9.64573547e-02f,
  -1.82857603e-01f, -3.47914770e-02f, 9.31410566e-02f, -1.43094555e-01f, 3.80922817e-02f, 2.72669256e-01f, -1.60381645e-01f, -2.01053962e-01f, 7.79427141e-02f, -8.62575769e-02f,
  -4.16484512e-02f, -9.86580700e-02f, 4.22783196e-02f, -1.25212176e-02f, -2.10528225e-01f, -1.46405414e-01f, -1.96686700e-01f, -4.79000658e-02f, -2.40344703e-01f, -6.72502890e-02f,
  -2.68990099e-01f, -3.65868539e-01f, -4.67600562e-02f, -8.27291757e-02f, -3.42108905e-02f, -1.25329532e-02f, -9.68483537e-02f, 7.20491447e-03f, -7.72833303e-02f, -1.16068684e-01f,
  -2.14782692e-02f, 5.61864115e-02f, 1.36979222e-02f, 8.51151571e-02f, -4.81742397e-02f, -4.48326096e-02f, 1.54887307e-02f, -1.75482919e-03f, -5.57553358e-02f, 9.64708477e-02f,
  -2.89914105e-02f, -1.01361210e-02f, -2.46446468e-02f, 5.34863956e-03f, 6.33771569e-02f, -6.29126877e-02f, 2.34580394e-02f, 1.48014203e-01f, -2.35178526e-02f, 4.14694548e-02f,
  1.41066790e-01f, 1.03621662e-01f, 5.76614402e-02f, 6.00089319e-03f, -2.89425417e-03f, -4.23202068e-02f, -4.92106564e-02f, 8.09367895e-02f, -2.64790747e-02f, 9.30753071e-03f,
  4.04214226e-02f, 2.09987406e-02f, 2.83955527e-03f, -2.68604653e-03f, -1.11111710e-02f, -4.98889498e-02f, 3.49979177e-02f, -1.11836242e-02f, -3.44904475e-02f, 6.84613362e-02f,
  1.83349811e-02f, 4.24641110e-02f, 7.96534717e-02f, 4.75902669e-02f, -1.08866328e-02f, 3.58472168e-02f, -8.08374733e-02f, 3.44156176e-02f, -1.00826785e-01f, -1.09428121e-02f,
  -2.87119716e-01f, -2.26042777e-01f, 3.75421764e-03f, -2.15696558e-01f, 1.96818970e-02f, -7.60083944e-02f, 6.12540431e-02f, -6.08887263e-02f, -1.22456014e-01f, -2.86012497e-02f,
  -4.38653789e-02f, -6.95007890e-02f, -1.43129945e-01f, 6.92185536e-02f, 3.74825411e-02f, 1.34979002e-03f, -9.21171457e-02f, -9.81436893e-02f, -1.86762497e-01f, 3.23073380e-02f,
  -9.92557481e-02f, 3.43632884e-02f, 3.20813507e-02f, -3.71940956e-02f, 1.18470602e-01f, -1.13624305e-01f, -3.32926102e-02f, -9.00511816e-03f, 2.26761959e-02f, 3.03669274e-02f,
  -5.94781339e-02f, 3.66305630e-03f, 1.21689133e-01f, 2.48917282e-01f, -3.44792232e-02f, 2.44037315e-01f, 3.74288410e-01f, -2.70748287e-02f, 2.79962361e-01f, 4.29318435e-02f,
  3.99697311e-02f, 6.02247333e-03f, 1.05001166e-01f, 2.02038854e-01f, 2.30036490e-02f, 2.37559661e-01f, 1.98338076e-01f, 2.42947072e-01f, 1.12332136e-03f, -1.25730392e-02f,
  -5.65920807e-02f, 4.11017565e-03f, 8.68180841e-02f, -2.58967787e-01f, -4.05824818e-02f, -1.93564594e-01f, -8.84329677e-02f, -3.03199943e-02f, -1.83524922e-01f, 1.41564859e-02f,
  -1.74619883e-01f, -1.06142852e-02f, 2.18434297e-02f, -3.54910493e-02f, 2.28710566e-02f, 1.12247966e-01f, 3.88933308e-02f, 6.88040555e-02f, 5.11869341e-02f, -7.58515373e-02f,
  -5.63734397e-02f, -7.84923211e-02f, -3.73329930e-02f, 1.08011737e-01f, 5.93869388e-02f, -7.27091953e-02f, 3.46587040e-02f, 2.68076975e-02f, -2.32770946e-02f, -3.27315070e-02f,
  -2.61920374e-02f, -3.42133865e-02f, 3.87711376e-02f, -2.94340234e-02f, -3.44591513e-02f, 3.56026962e-02f, 1.14353694e-01f, -9.56709310e-03f, -1.57164205e-02f, -5.15691750e-02f,
  4.48831394e-02f, 2.50301380e-02f, 1.80161502e-02f, -9.26612392e-02f, -9.85412970e-02f, -1.38762459e-01f, 6.52185827e-02f, 8.18125010e-02f, -1.09565645e-01f, 1.88409314e-02f,
  6.92994744e-02f, -4.12583984e-02f, 1.44938473e-03f, -1.17653897e-02f, 4.35655266e-02f, -5.81761934e-02f, 7.88687356e-03f, -1.37340754e-01f, 7.89534897e-02f, -7.43506849e-03f,
  5.97727932e-02f, -6.92149159e-03f, -3.07686776e-02f, 5.74511010e-03f, -8.88539478e-03f, -1.69353131e-02f, -2.39371322e-02f, 1.97687335e-02f, 3.97709981e-02f, 8.03331565e-03f,
  -6.22735247e-02f, -1.24178931e-01f, -2.19640564e-02f, -1.06179692e-01f, -6.32873923e-02f, -1.12593718e-01f, 1.20295279e-01f, -1.07609369e-01f, 4.19971682e-02f, -1.34959361e-02f,
  2.75112502e-03f, -3.07967830e-02f, -1.02813337e-02f, 6.89095557e-02f, -1.52179878e-02f, -2.31609540e-03f, 1.16636194e-02f, 4.11283523e-02f, -1.60356145e-02f, -8.53038356e-02f,
  7.31437653e-02f, -6.36993945e-02f, -2.47514956e-02f, 2.89868563e-02f, -2.44990252e-02f, 6.42547160e-02f, -1.25041753e-02f, -1.26160802e-02f, -1.27956346e-01f, 4.82115783e-02f,
  2.52667993e-01f, 8.68046731e-02f, 1.78806365e-01f, 2.85372347e-01f, -6.17247969e-02f, 9.87058654e-02f, 2.44502887e-01f, 6.71093091e-02f, 3.26565295e-01f, -6.44175857e-02f,
  -1.11418709e-01f, 1.54131591e-01f, 7.82733560e-02f, -2.09779851e-02f, 3.43154460e-01f, -7.02216197e-03f, 1.99740544e-01f, -1.30040318e-01f, 1.55424744e-01f, 2.22065315e-01f,
  3.25313538e-01f, 1.23191498e-01f, 1.78635400e-02f, -1.22974783e-01f, 1.15426257e-01f, -6.38681129e-02f, -1.02643885e-01f, -9.30510387e-02f, -2.03652903e-01f, 1.24686528e-02f,
  -1.27711803e-01f, 1.22120269e-01f, -4.21931595e-02f, -6.41368926e-02f, 3.35588977e-02f, -1.15720131e-01f, -7.04807490e-02f, -1.03579909e-01f, -3.25652026e-02f, 4.46454361e-02f,
  2.45357100e-02f, -6.34721220e-02f, 1.51823955e-02f, 1.57706235e-02f, -9.09608603e-02f, -5.20817004e-02f, -7.68422484e-02f, 3.39241251e-02f, 7.14343786e-02f, -9.84394923e-02f,
  2.75228173e-02f, -1.93982627e-02f, -1.05830118e-01f, -8.86442512e-02f, 5.05418330e-02f, 1.65009107e-02f, 5.31837046e-02f, -6.87026158e-02f, 1.58279799e-02f, -4.39797007e-02f,
  8.60973597e-02f, -5.73455282e-02f, -7.11945519e-02f, -1.43804267e-01f, -7.75682926e-02f, 1.09273054e-01f, -9.53167863e-03f, -3.87317762e-02f, 8.92943740e-02f, -2.69341040e-02f,
  -9.40655321e-02f, -4.09419946e-02f, -6.96725473e-02f, 1.96127798e-02f, 9.24622566e-02f, 2.70083118e-02f, -1.00530684e-02f, -1.73960611e-01f, 6.39699921e-02f, -1.00518554e-01f,
  1.78546011e-01f, 4.91962805e-02f, -8.35409164e-02f, -5.14162257e-02f, -3.95969599e-02f, -9.89310443e-03f, 5.37862629e-02f, -2.52180174e-03f, -6.22377545e-02f, 2.02392131e-01f,
  4.82182689e-02f, 2.49861091e-01f, 8.98820087e-02f, 1.05400002e-02f, -3.02376579e-02f, 1.03304570e-03f, 1.51460702e-02f, 6.38605654e-02f, 1.47533402e-01f, 6.34461418e-02f,
  7.10947961e-02f, 2.55145337e-02f, -3.24785337e-02f, -2.09015846e-01f, -1.11190090e-02f, 5.03601246e-02f, 1.41979203e-01f, 1.09035574e-01f, 2.43689734e-02f, -4.24725525e-02f,
  2.09351853e-02f, 6.69890940e-02f, -1.00656204e-01f, -6.63565919e-02f, -2.40733307e-02f, -1.37996182e-01f, 2.50532199e-02f, -7.99316540e-02f, 3.68871652e-02f, 3.37728150e-02f,
  -4.29226846e-01f, 3.27910453e-01f, 2.26219490e-01f, -8.67766887e-03f, 1.76814392e-01f, 3.02260756e-01f, 2.56239116e-01f, 2.84310043e-01f, 3.07424009e-01f, 5.13609685e-02f,
  -1.89580172e-01f, -3.48265171e-02f, 2.57994700e-02f, -4.88079041e-02f, 2.01693818e-01f, 1.42518386e-01f, 5.52800857e-02f, 5.08617088e-02f, 1.64425880e-01f, -1.74427494e-01f,
  1.83482505e-02f, -4.74925376e-02f, -1.04919061e-01f, 8.31326470e-02f, -2.04614967e-01f, 2.85025854e-02f, -2.88448751e-01f, 3.02880090e-02f, -1.08728975e-01f, 6.48318455e-02f,
  2.83771269e-02f, 2.77112331e-02f, -1.01919137e-01f, 6.01981245e-02f, 5.23133315e-02f, -1.06236331e-01f, -7.10201412e-02f, -4.77380492e-02f, -3.51557136e-02f, -7.51705654e-03f,
  -6.36875182e-02f, -2.82776332e-03f, 6.73752204e-02f, 5.37178032e-02f, -9.35287960e-03f, 1.78505499e-02f, 2.42655370e-02f, -1.12259582e-01f, 1.08850924e-02f, -5.31251468e-02f,
  -7.24279806e-02f, -6.42944202e-02f, -7.29559511e-02f, 7.29039460e-02f, -8.00021887e-02f, 6.44162595e-02f, 7.23996311e-02f, -4.61199246e-02f, 3.29147130e-02f, 1.74154669e-01f,
  -5.25528677e-02f, 2.53128987e-02f, -3.38795185e-02f, -2.57109385e-02f, 2.38068532e-02f, 1.30668115e-02f, 7.31921196e-03f, 2.64561409e-03f, -3.69949779e-03f, -1.09662957e-01f,
  -5.35283461e-02f, -2.34985575e-02f, 4.97746840e-03f, 1.62791722e-02f, 7.44656846e-02f, -9.88547355e-02f, -1.17893763e-01f, 7.71828294e-02f, 3.25917937e-02f, 4.13579009e-02f,
  3.39525789e-02f, 8.57710242e-02f, -4.45035771e-02f, -8.43882468e-03f, -1.95548292e-02f, -5.77020235e-02f, 1.09035503e-02f, -2.26850379e-02f, 1.02414209e-02f, -7.03399777e-02f,
  1.50176644e-01f, 3.07267696e-01f, -3.97283286e-02f, 4.70511243e-02f, -1.86083373e-02f, -3.93486097e-02f, -2.22355239e-02f, 3.24018113e-03f, 1.71318874e-01f, 1.02754012e-01f,
  -9.04437806e-03f, -6.29065931e-02f, -6.04234450e-02f, -5.82019165e-02f, 6.47894591e-02f, 1.48188606e-01f, -1.28495935e-02f, 8.91532227e-02f, 1.62083551e-01f, -3.16295736e-02f,
  -1.47774950e-01f, 4.08075042e-02f, -6.71508014e-02f, 6.37226999e-02f, -3.69248092e-02f, -7.69079551e-02f, 1.02569580e-01f, 5.21352366e-02f, 3.93169075e-02f, 1.95681453e-02f,
  -3.34642172e-01f, 3.22241366e-01f, 3.16855125e-02f, 2.71912217e-01f, -2.27528408e-01f, -1.23819165e-01f, -9.26159173e-02f, 1.42649099e-01f, -2.24206284e-01f, 2.82455593e-01f,
  1.49536282e-01f, -2.99725950e-01f, 2.51222938e-01f, 2.59731650e-01f, -2.24781692e-01f, 1.99802190e-01f, 1.78444475e-01f, 6.77521378e-02f, -6.33253483e-03f, 1.09975316e-01f,
  1.22799456e-01f, 1.62688881e-01f, 2.83898920e-01f, 1.09261021e-01f, -4.87275422e-02f, 3.13200690e-02f, 2.08281711e-01f, 1.19733073e-01f, 1.83023259e-01f, -1.17452957e-01f,
  8.92396793e-02f, 5.42079797e-03f, -1.58529803e-02f, -4.93147932e-02f, 1.05426215e-01f, 2.87573468e-02f, 6.95154369e-02f, -6.30809739e-02f, 5.69319390e-02f, 7.56358132e-02f,
  -1.27480403e-01f, 5.63134067e-02f, -8.04419070e-02f, -1.82901040e-01f, -2.15425283e-01f, 2.33930182e-02f, 4.72531803e-02f, -1.26186296e-01f, -5.33994362e-02f, -6.52016625e-02f,
  -3.92226502e-02f, 3.22921462e-02f, -1.20360507e-02f, -5.07362895e-02f, -5.33238053e-02f, 2.09725685e-02f, 4.82082069e-02f, -2.36867759e-02f, 8.37530494e-02f, -8.78272951e-02f,
  -5.44750653e-02f, -7.04738423e-02f, 1.89162791e-02f, 8.97094011e-02f, -1.10301331e-01f, 6.96820095e-02f, -3.48905325e-02f, -9.31981299e-03f, -3.63991112e-02f, 1.20875835e-01f,
  1.00863747e-01f, 2.92208176e-02f, 4.64946590e-02f, -1.90342665e-02f, -3.67103815e-02f, 1.82815213e-02f, -1.18430145e-02f, 1.09488005e-02f, -3.83350663e-02f, 2.07210593e-02f,
  2.08489485e-02f, -9.17060673e-02f, 3.08001954e-02f, 9.12440047e-02f, 1.23897657e-01f, -1.18369520e-01f, -2.85699945e-02f, -1.59674603e-02f, 1.58625200e-01f, -2.97338273e-02f,
  5.15769385e-02f, 5.11369817e-02f, 8.12845677e-02f, 1.46578727e-02f, 4.22439687e-02f, -4.11671177e-02f, 4.64399457e-02f, -5.02586253e-02f, 3.40215452e-02f, -4.81293947e-02f,
  -1.97686702e-02f, 5.19425757e-02f, 7.76045620e-02f, -8.99223760e-02f, 6.03333414e-02f, -7.67958462e-02f, 2.09820289e-02f, -1.18249515e-02f, -5.72263002e-02f, 1.04541361e-01f,
  5.75428195e-02f, -3.33795436e-02f, 3.40473317e-02f, -2.98092682e-02f, -1.21987760e-02f, 5.54036796e-02f, -1.19586535e-01f, 3.80365178e-02f, 3.75735648e-02f, 5.94040714e-02f,
  3.22171114e-02f, -3.14124852e-01f, -2.11466581e-01f, -2.94620633e-01f, -6.83355629e-02f, -3.07860941e-01f, -2.47299820e-01f, -7.65798837e-02f, 2.63719056e-02f, -9.75552574e-02f,
  -1.88965231e-01f, -1.12280637e-01f, 6.22946024e-02f, -3.27248305e-01f, 1.02939464e-01f, 1.61143437e-01f, -3.07625204e-01f, -2.12128699e-01f, -6.33736774e-02f, -2.05036789e-01f,
  -9.54666585e-02f, -2.53300846e-01f, -1.14936374e-01f, -1.86263055e-01f, -2.45799601e-01f, -8.34449753e-02f, 2.25831077e-01f, -1.60347283e-01f, -1.51656866e-01f, -5.82356714e-02f,
  -7.03600794e-02f, -9.09135416e-02f, -1.79689843e-02f, -1.65550702e-03f, 2.95392219e-02f, 7.56340055e-03f, -5.80754951e-02f, -3.41347568e-02f, 6.28154725e-02f, -1.71597261e-04f,
  -1.43007264e-02f, 2.57000346e-02f, -4.04108390e-02f, 8.70847180e-02f, -5.34334704e-02f, 7.83194788e-03f, 3.48648243e-02f, -5.53981699e-02f, -4.65378910e-02f, 6.17768839e-02f,
  -1.22011162e-01f, -3.03298570e-02f, 3.05099669e-03f, 2.95661036e-02f, -1.88051518e-02f, -1.02835059e-01f, 1.04773842e-01f, -5.53442277e-02f, 5.57502918e-02f, 6.02221154e-02f,
  7.78895393e-02f, 9.26344544e-02f, -3.45400982e-02f, 9.89958830e-03f, 1.21621620e-02f, 1.53595619e-02f, -1.25270728e-02f, 2.35674139e-02f, 3.52634639e-02f, -4.29262966e-02f,
  -5.81883341e-02f, 4.51642014e-02f, 5.92794009e-02f, -3.53922956e-02f, -4.84509729e-02f, 8.94321501e-02f, 3.31894471e-03f, -4.73451689e-02f, -8.12485814e-02f, -3.33508924e-02f,
  5.75577002e-03f, 5.46327885e-03f, -1.32644959e-02f, 2.11583879e-02f, -8.54225382e-02f, 5.98712731e-03f, 1.07865240e-02f, -3.47143859e-02f, 1.53381392e-01f, -2.61359029e-02f,
  7.94066023e-03f, -5.70115708e-02f, -2.81882770e-02f, 3.03983316e-02f, 3.43889021e-03f, 5.53187765e-02f, -1.39826015e-01f, -1.62693843e-01f, -7.27192536e-02f, -1.71518594e-03f,
  3.46793048e-02f, 9.16262940e-02f, 7.11935712e-03f, -8.39904882e-03f, -9.12145674e-02f, -1.04642592e-01f, 1.18257683e-02f, 7.41067603e-02f, -6.43542632e-02f, 3.51756848e-02f,
  5.67427240e-02f, 9.00420547e-02f, 9.67032090e-02f, 1.90144323e-03f, 2.04138421e-02f, 5.54624461e-02f, 6.33596852e-02f, -6.58198893e-02f, -1.36550320e-02f, -6.45346567e-02f,
  3.34471285e-01f, -3.49583119e-01f, 5.88999353e-02f, 3.59568238e-01f, 2.88839757e-01f, 6.87540509e-03f, 1.34604275e-01f, 4.19363230e-02f, 2.17804804e-01f, -3.86918426e-01f,
  -2.82935966e-02f, -2.55091786e-01f, -2.61058688e-01f, 4.08404917e-02f, 2.25138754e-01f, -2.09759012e-01f, 1.82302758e-01f, -1.29336298e-01f, 5.97352721e-02f, -7.11970851e-02f,
  3.08775723e-01f, 1.70998424e-01f, 1.53254777e-01f, 5.94427176e-02f, 3.60872597e-02f, -4.26981300e-02f, 4.68168370e-02f, -5.40991426e-02f, 1.07419088e-01f, 1.27545707e-02f,
  -2.09826827e-02f, 1.37551486e-01f, 5.62564768e-02f, 2.19746097e-03f, -7.32707679e-02f, 9.69810819e-04f, -1.27119264e-02f, 3.77435200e-02f, 1.01094864e-01f, -8.21211003e-03f,
  -5.12219779e-02f, 5.53855635e-02f, 6.27194941e-02f, 7.70986974e-02f, 3.91532518e-02f, 1.21113837e-01f, 1.99495833e-02f, -5.18920086e-02f, -5.33635281e-02f, -2.14222409e-02f,
  1.58823282e-02f, -2.45116092e-02f, 1.29074261e-01f, -2.75037647e-03f, 7.90283456e-02f, -2.23108428e-03f, 3.35924178e-02f, -6.69131428e-02f, -7.50378415e-04f, 1.20417871e-01f,
  -8.25072974e-02f, 6.41467497e-02f, -1.49341166e-01f, -1.09584760e-02f, -1.11286473e-02f, 1.58222347e-01f, 4.46283258e-02f, -5.66707645e-03f, 6.43077912e-03f, -6.15628324e-02f,
  3.55360620e-02f, -4.64816093e-02f, 7.89207816e-02f, 2.29526702e-02f, 1.16607593e-02f, 1.48321111e-02f, -6.28589392e-02f, 4.52566743e-02f, 4.28342819e-02f, 1.23109072e-01f,
  7.55329710e-03f, 7.39713237e-02f, -7.82366171e-02f, -2.69941837e-02f, -3.70625928e-02f, -1.83234010e-02f, 4.51073200e-02f, -1.06552683e-01f, 6.64285049e-02f, 2.51381081e-02f,
  -2.04200700e-01f, -4.47249383e-01f, 2.57471874e-02f, -1.52969193e-02f, -1.21967748e-01f, -6.45960420e-02f, -1.32629378e-02f, 8.23868345e-03f, -1.09177880e-01f, 5.05561456e-02f,
  5.67136779e-02f, 1.57776400e-02f, -1.29661232e-01f, 4.87470813e-02f, -5.40867858e-02f, -5.08329161e-02f, 1.64871160e-02f, -2.50164215e-02f, 7.44295493e-02f, -1.20148279e-01f,
  -6.99289516e-02f, 3.90602252e-03f, 4.53811809e-02f, 1.76355317e-01f, 6.66186437e-02f, 4.19953316e-02f, -1.84478285e-03f, -6.71400130e-02f, -4.20206934e-02f, -4.41128723e-02f,
  3.64931971e-01f, 4.55552876e-01f, 2.90845662e-01f, 2.07589313e-01f, -2.49707043e-01f, -2.29110718e-01f, -1.00859597e-01f, -4.84116748e-02f, 4.29950058e-02f, 5.01620956e-02f,
  -2.20742762e-01f, 4.65863585e-01f, -1.58769086e-01f, 1.75207257e-01f, -2.14597613e-01f, -2.60913074e-01f, -2.43501961e-02f, 8.69711488e-02f, -1.75886136e-02f, 1.53987810e-01f,
  -1.03708943e-02f, -2.86283404e-01f, 7.11687133e-02f, 2.70728022e-02f, 1.27631724e-01f, 2.52295464e-01f, -6.21197447e-02f, -1.16290905e-01f, 2.67752349e-01f, 8.05911887e-03f,
  -1.10377043e-01f, -1.58559419e-02f, 9.88903120e-02f, 8.84502381e-03f, -5.17554171e-02f, 1.86129455e-02f, 1.38293859e-02f, 3.99923921e-02f, -1.16636261e-01f, 2.15994064e-02f,
  1.11539215e-01f, 4.76416647e-02f, 6.10910058e-02f, 5.90328723e-02f, 2.96000838e-02f, 1.20091818e-01f, 4.53163218e-03f, 8.49168450e-02f, 9.45166871e-02f, 3.54219601e-02f,
  1.39252439e-01f, 5.42545132e-02f, -4.68018129e-02f, 8.22084323e-02f, 1.24149740e-01f, -3.11193746e-02f, 9.17942226e-02f, 6.95097297e-02f, 1.24955997e-01f, 7.75259435e-02f,
  2.96790921e-03f, -1.13756023e-01f, -4.35301103e-02f, -4.81053963e-02f, -2.55775210e-02f, -5.06416038e-02f, 6.81500975e-03f, -3.86947468e-02f, 7.27293342e-02f, -8.39954987e-02f,
  -1.02422219e-02f, 3.76273901e-03f, -5.75382859e-02f, 2.39781849e-02f, 2.90648732e-02f, 5.75944670e-02f, 5.58311939e-02f, 9.65230167e-02f, 4.26452756e-02f, 6.60768598e-02f,
  3.15083489e-02f, -1.22101977e-01f, 6.34755120e-02f, -4.49417904e-02f, -1.67156219e-01f, -2.14270642e-03f, 7.32154846e-02f, 1.04080729e-01f, -8.00659582e-02f, -1.36029106e-02f,
  -2.31163323e-01f, -7.49824941e-02f, 1.82828642e-02f, 1.25946002e-02f, -2.57838648e-02f, -1.23687461e-02f, -7.90126920e-02f, 5.87604269e-02f, -1.02451816e-01f, -3.03131733e-02f,
  -3.64185423e-02f, -1.31902352e-01f, -4.25407290e-02f, -2.22342019e-03f, 3.52491532e-03f, -2.79499795e-02f, 4.99828113e-03f, 8.36714059e-02f, -3.65105048e-02f, 4.45662737e-02f,
  7.81215206e-02f, -1.92002803e-02f, -1.00563973e-01f, 3.65864336e-02f, -1.17867701e-02f, -5.01972884e-02f, 7.39107877e-02f, 6.96390122e-02f, -4.14803252e-02f, -2.38218233e-02f,
  2.55509764e-01f, 5.81351947e-03f, -7.57535473e-02f, 1.79587200e-01f, -2.37926796e-01f, 1.34357752e-03f, -2.15557590e-02f, -4.20932509e-02f, 2.63127089e-01f, 9.32764262e-03f,
  -7.54435807e-02f, -3.25122625e-02f, 6.16127439e-02f, -8.23759381e-03f, 7.31457472e-02f, 1.03190944e-01f, -1.62690580e-02f, 4.68080416e-02f, -1.77866016e-02f, -4.78386804e-02f,
  2.24304385e-02f, -1.17074557e-01f, -1.33827195e-01f, -2.46988580e-01f, -4.22234386e-02f, 4.68627363e-02f, -3.12883079e-01f, -1.72854334e-01f, -2.94036657e-01f, -1.15800068e-01f,
  1.25866085e-01f, 1.63789451e-01f, 5.87671772e-02f, 1.06248304e-01f, 5.93897887e-02f, -1.33535028e-01f, -4.24364768e-02f, -1.22358896e-01f, 1.19801946e-01f, 1.04293935e-01f,
  4.65436913e-02f, 3.43135335e-02f, 7.79988393e-02f, -6.17908612e-02f, 1.02781832e-01f, -1.82228480e-02f, 3.96397747e-02f, 5.23403883e-02f, 6.33594170e-02f, -1.33657187e-01f,
  2.86345556e-02f, -2.19717063e-02f, -2.59728241e-03f, 1.43915294e-02f, -3.99491331e-03f, 5.09861000e-02f, -9.95382294e-02f, -1.06474981e-01f, -4.69278507e-02f, -5.06384335e-02f,
  -1.06648132e-01f, 6.32709544e-03f, -4.52405401e-02f, -7.31548965e-02f, 1.13608791e-02f, -4.60818131e-03f, -3.36835459e-02f, -1.82828808e-03f, 1.55721441e-01f, -4.06277217e-02f,
  5.52430637e-02f, 3.36818174e-02f, 8.32976401e-02f, -1.17464237e-01f, -7.52299950e-02f, 9.70154777e-02f, -1.28938735e-01f, 2.64304429e-02f, 7.74151087e-02f, -4.55960594e-02f,
  6.90972386e-03f, -4.25567031e-02f, -4.82564867e-02f, -2.79426705e-02f, 3.46437469e-02f, -6.39562830e-02f, 2.22555525e-03f, 8.89419764e-02f, -4.22580987e-02f, -1.14029996e-01f,
  3.08618881e-02f, -4.98290695e-02f, 2.00095940e-02f, 1.32238641e-01f, 9.22346041e-02f, -6.27272725e-02f, -7.32473955e-02f, 6.31199926e-02f, 1.19041614e-02f, 2.91888881e-02f,
  -2.08856408e-02f, 1.58918217e-01f, -3.48793827e-02f, -8.40399191e-02f, -1.71399862e-02f, -5.60219623e-02f, 7.70263188e-03f, 5.95554616e-03f, -5.62999025e-02f, -2.24908352e-01f,
  -8.13027658e-03f, 2.15862296e-03f, 5.11412360e-02f, 1.30939156e-01f, -4.65099178e-02f, -5.51322922e-02f, 2.25127898e-02f, 5.54006211e-02f, -1.09401578e-02f, 7.41105177e-05f,
  1.84138790e-01f, 3.71978581e-02f, 2.77133524e-01f, 2.73135871e-01f, 2.32719988e-01f, -1.78599775e-01f, -1.47055760e-01f, 2.81019837e-01f, 1.42721847e-01f, -9.03033465e-02f,
  -2.09554330e-01f, -6.95461854e-02f, -1.06257476e-01f, -3.04965898e-02f, -2.08063349e-01f, -3.75230044e-01f, 3.78570557e-02f, -2.21085861e-01f, -1.93269476e-01f, 6.57848045e-02f,
  1.17431581e-01f, -9.66524258e-02f, 1.66405514e-01f, 6.87405169e-02f, 2.74199486e-01f, 1.63103446e-01f, 4.52973656e-02f, -7.60473609e-02f, 2.03613594e-01f, -9.74898189e-02f,
  2.15635952e-02f, -7.39793032e-02f, 9.35969204e-02f, 3.20842862e-02f, 1.98663935e-01f, -1.28700268e-02f, 6.34118170e-02f, -1.40962124e-01f, 5.93751371e-02f, -3.83812524e-02f,
  4.99093011e-02f, 8.14020187e-02f, 3.97667140e-02f, -7.16559738e-02f, 8.90904814e-02f, 1.30512804e-01f, 6.33667335e-02f, 2.24579200e-01f, 8.61589760e-02f, -3.35488692e-02f,
  5.32302149e-02f, 1.00243710e-01f, 8.50019753e-02f, -3.30843031e-02f, 1.14365220e-01f, 4.11311863e-03f, -6.01204857e-02f, -8.52136239e-02f, 6.22421242e-02f, 2.67031919e-02f,
  -2.73285457e-03f, -4.03821431e-02f, -2.75687110e-02f, 3.09116393e-02f, -1.28486052e-01f, 4.02214751e-02f, 9.51230340e-03f, -4.83665280e-02f, 2.42371932e-02f, -3.14845145e-02f,
  1.08903855e-01f, -1.76871999e-03f, -3.03931255e-02f, 9.79865566e-02f, 2.95983776e-02f, 5.08143147e-03f, 6.66551711e-03f, -1.04137018e-01f, 6.37722481e-03f, 6.42912611e-02f,
  -7.06717521e-02f, -1.59379467e-02f, -1.22341841e-01f, 4.65361625e-02f, 3.16408612e-02f, -7.58104550e-04f, -3.64978425e-02f, 7.44709074e-02f, -7.14560598e-02f, -1.43290594e-01f,
  -3.73144411e-02f, -1.59519896e-01f, -1.02937751e-01f, -3.02342279e-03f, 1.92334093e-02f, -7.64211416e-02f, 1.21331863e-01f, 9.31649059e-02f, -1.79198030e-02f, 2.78146416e-02f,
  2.02887446e-01f, 5.78486547e-02f, -4.61223945e-02f, -1.55423386e-02f, -3.02961674e-02f, 4.08086069e-02f, -3.93026657e-02f, 5.68895787e-02f, 4.84846234e-02f, 8.48201364e-02f,
  4.85995747e-02f, 6.44397810e-02f, 1.18474908e-01f, 4.45610844e-02f, 7.74017349e-02f, 2.44744606e-02f, -1.97826959e-02f, 1.12940028e-01f, -1.21978328e-01f, 1.52361663e-02f,
  1.78451464e-01f, 1.69479981e-01f, -2.09658787e-01f, 7.99683556e-02f, -1.14469342e-01f, -4.15723287e-02f, -4.66736779e-02f, 4.51806234e-03f, -4.24621142e-02f, 1.68783367e-01f,
  1.53616816e-01f, 1.40845641e-01f, 7.59558678e-02f, 3.61824632e-01f, 7.17762858e-02f, 1.71620935e-01f, 2.54014820e-01f, 1.49541199e-01f, -7.57976472e-02f, 2.26550132e-01f,
  -4.92037134e-03f, 3.33223164e-01f, 1.32655114e-01f, 5.28473128e-03f, 2.45729759e-01f, -1.22907780e-01f, 1.89962700e-01f, -2.67297149e-01f, 1.26705430e-02f, -1.00789957e-01f,
  -3.44655477e-02f, 7.72176236e-02f, 3.26509736e-02f, -7.20381588e-02f, 9.59060490e-02f, -6.96855858e-02f, -2.13246793e-02f, -4.15566936e-02f, -1.70172006e-01f, 8.63980651e-02f,
  6.65828958e-02f, -2.82643698e-02f, -1.22421123e-02f, -8.68764371e-02f, 9.96400714e-02f, -4.33370005e-03f, -3.97820435e-02f, 9.59654525e-03f, 5.24719432e-02f, 1.31638557e-01f,
  -5.23127764e-02f, 2.31913105e-02f, -3.24675702e-02f, 4.44925874e-02f, 1.44162532e-02f, -7.35003501e-02f, -1.33694842e-01f, 1.13836750e-01f, -9.12259221e-02f, 1.11426711e-01f,
  -5.50189875e-02f, 8.08569863e-02f, -3.94457951e-03f, 3.81630175e-02f, -1.09435832e-02f, 2.04382315e-02f, -3.15873045e-03f, 3.02288849e-02f, -8.17837119e-02f, 7.18127266e-02f,
  -3.86992283e-02f, -1.18945353e-01f, -2.58363746e-02f, -5.76021932e-02f, 2.46975962e-02f, -8.06897208e-02f, -7.21415728e-02f, -2.27363352e-02f, -1.30482689e-02f, -2.71363389e-02f,
  9.98438802e-03f, -6.90337792e-02f, -4.29896824e-02f, -1.59104187e-02f, 6.08874783e-02f, 9.66034308e-02f, 1.53477877e-01f, 1.12520708e-02f, -4.13544178e-02f, -5.53447083e-02f,
  6.12738952e-02f, 1.30905241e-01f, 2.09236294e-02f, -2.67053787e-02f, -6.93700537e-02f, 1.56001719e-02f, -3.34896781e-02f, 2.92268712e-02f, -2.97648720e-02f, -5.91542646e-02f,
  9.56642106e-02f, -1.56608075e-01f, 6.29737899e-02f, -4.80143912e-03f, -9.74603519e-02f, 7.98874348e-02f, 1.01330034e-01f, -4.59737368e-02f, -1.83980092e-02f, 1.01233404e-02f,
  -5.75200468e-02f, 3.64667401e-02f, 1.30799472e-01f, -1.22082278e-01f, -3.02936994e-02f, 1.93239935e-02f, -7.15052113e-02f, 4.50283997e-02f, -2.73201019e-02f, 2.41856370e-02f,
  4.45198953e-01f, 6.39158562e-02f, 1.89006507e-01f, 3.98789257e-01f, 2.24817470e-02f, -8.97005647e-02f, 1.82345763e-01f, 8.85526240e-02f, 4.27961081e-01f, -1.52241945e-01f,
  -1.61827400e-01f, 1.95848480e-01f, -1.44341812e-01f, 1.09464496e-01f, -9.59699228e-02f, -1.18347093e-01f, 9.78565738e-02f, 3.96552980e-02f, 1.60435393e-01f, 1.38534993e-01f,
  1.42669186e-01f, -1.54351607e-01f, -9.88728553e-02f, -2.48258606e-01f, 1.84176967e-01f, 1.69658929e-01f, -3.26424807e-01f, -1.32764667e-01f, -2.30974317e-01f, -2.07710877e-01f,
  5.79544865e-02f, 1.02769077e-01f, 7.07503557e-02f, -4.39780317e-02f, 7.33598769e-02f, 4.18771543e-02f, -1.15171475e-02f, -1.14781737e-01f, -3.03330440e-02f, -5.18489741e-02f,
  7.87656903e-02f, -4.17922065e-02f, 2.01841947e-02f, -4.65209819e-02f, 3.01455352e-02f, -2.58308332e-02f, 7.99311399e-02f, 1.55330867e-01f, 2.52162125e-02f, 1.13597639e-01f,
  1.38089195e-01f, 1.32890970e-01f, 1.29343107e-01f, -1.32056281e-01f, 5.89307882e-02f, 3.52915674e-02f, -6.16997853e-02f, 1.04282796e-02f, 8.50111060e-03f, 5.85795604e-02f,
  4.76141758e-02f, 3.04867011e-02f, -8.64006206e-02f, 2.03160793e-02f, 1.45695833e-02f, -3.90738435e-02f, -3.56000513e-02f, -3.57664749e-02f, -6.19444698e-02f, -1.91305876e-02f,
  -5.39827114e-03f, 6.05362467e-02f, 6.21932298e-02f, 1.72920059e-02f, 9.40620303e-02f, -3.81019944e-03f, -8.91930237e-02f, -5.96232899e-02f, 6.00072779e-02f, 1.77582055e-02f,
  -4.83313389e-02f, -6.17072247e-02f, 5.34897335e-02f, -1.65395066e-02f, 1.25457915e-02f, 5.39165968e-03f, 1.49987906e-03f, 9.04339328e-02f, 1.05716757e-01f, -9.56533328e-02f,
  -2.11011678e-01f, -1.87741101e-01f, 6.62217885e-02f, 2.77663656e-02f, -4.42819968e-02f, 3.86339054e-02f, -3.07467231e-03f, 5.92542179e-02f, -5.91225661e-02f, -7.18514100e-02f,
  8.73488858e-02f, -5.63676953e-02f, -2.16764677e-02f, -1.05538189e-01f, 1.97857432e-02f, -5.50095551e-02f, -2.81300559e-03f, -8.06349590e-02f, -1.87042810e-03f, 4.56593418e-03f,
  -8.04249942e-03f, 4.52226843e-04f, 2.11294312e-02f, 1.74167175e-02f, 5.08471392e-03f, 1.13485120e-02f, 8.67638886e-02f, 1.90615654e-02f, 6.02044584e-03f, 2.80758031e-02f,
  2.27954641e-01f, -2.84545392e-01f, 1.07651085e-01f, 5.61915971e-02f, 7.80517980e-02f, -3.19548436e-02f, 3.40188980e-01f, -3.20449650e-01f, -2.57467568e-01f, -3.24382991e-01f,
  2.32655741e-02f, 1.47173181e-01f, 2.78549612e-01f, -2.81378835e-01f, 3.72773260e-01f, 6.97733313e-02f, -1.96743473e-01f, 4.05872427e-02f, -6.88815266e-02f, -2.21668214e-01f,
  1.16622383e-02f, -2.90183425e-01f, 1.65544793e-01f, -3.30424935e-01f, -1.38602182e-01f, -1.37921304e-01f, 8.53837729e-02f, 1.90745637e-01f, -2.68532306e-01f, 1.97177827e-01f,
  -8.67402181e-02f, -1.61012083e-01f, -6.40446171e-02f, -1.06113784e-01f, -1.62304565e-03f, -3.63082741e-03f, 9.78582874e-02f, 1.20965444e-01f, 7.73633868e-02f, -6.86586183e-03f,
  1.40671119e-01f, -3.56755666e-02f, -1.32048130e-01f, 7.09876493e-02f, -8.48090742e-03f, -1.51197463e-01f, -7.14386702e-02f, -2.56516412e-02f, -8.79524946e-02f, -4.49534832e-03f,
  5.89889772e-02f, 1.82439182e-02f, -5.64859919e-02f, -8.94911662e-02f, -4.41960953e-02f, -8.05509686e-02f, -7.17737824e-02f, 7.05851242e-02f, -1.04126438e-01f, -9.71024483e-02f,
  -3.48940380e-02f, 6.97749201e-03f, 6.26886450e-03f, -2.38950904e-02f, -7.04277481e-04f, -6.39659986e-02f, -7.55283833e-02f, 8.33128020e-02f, 7.47696236e-02f, -5.84372617e-02f,
  -6.63196370e-02f, -2.20301356e-02f, -6.10957146e-02f, 5.10233380e-02f, 2.59069167e-02f, -3.90518047e-02f, 7.99624547e-02f, 5.46288155e-02f, 3.87365720e-03f, 6.75971201e-03f,
  3.06111202e-02f, 1.46881221e-02f, 3.20602432e-02f, 3.52960713e-02f, -5.73243499e-02f, 1.61163479e-01f, -1.06445283e-01f, -2.23014373e-02f, 8.14914145e-03f, 8.86559039e-02f,
  -1.47122949e-01f, -2.40565166e-01f, -4.78045382e-02f, -3.10350507e-02f, 7.97132179e-02f, -2.44216975e-02f, -4.23919521e-02f, -6.79954439e-02f, 3.59350443e-02f, -9.92801040e-04f,
  1.44155591e-03f, 5.65052293e-02f, -4.67400998e-02f, -3.72762978e-02f, -5.46881594e-02f, -4.43002880e-02f, 5.13404608e-02f, 8.54581129e-03f, 2.69768368e-02f, -9.23139900e-02f,
  -7.40149766e-02f, 5.85924871e-02f, 2.00869180e-02f, -1.95630696e-02f, -3.26341726e-02f, 5.42515330e-02f, 4.26821709e-02f, 3.84206213e-02f, -5.37837595e-02f, -4.23155017e-02f,
  -1.78188175e-01f, -1.36794010e-02f, 2.44386822e-01f, 3.23070973e-01f, -1.02060199e-01f, -3.25373083e-01f, -4.81284261e-01f, 6.14997149e-02f, -1.73116982e-01f, -2.84657389e-01f,
  -7.69290747e-03f, 9.22068730e-02f, -2.11484611e-01f, 2.57431656e-01f, 1.91964820e-01f, -1.00143358e-01f, 2.40595654e-01f, 1.07819274e-01f, 1.10362768e-01f, 7.79146850e-02f,
  2.27947250e-01f, 2.33469993e-01f, 3.28298330e-01f, 1.77303717e-01f, 1.14452146e-01f, 2.40037292e-01f, 3.06275755e-01f, -1.11812714e-03f, 3.28944504e-01f, 1.02690898e-01f,
  -2.62427926e-01f, 1.04798280e-01f, -9.29208566e-03f, -8.61418024e-02f, -4.28333227e-03f, -8.72870088e-02f, -4.23051491e-02f, 4.16839048e-02f, 5.41233681e-02f, -1.96403521e-03f,
  -1.55091792e-01f, 6.88998997e-02f, 1.66766658e-01f, 2.32525002e-02f, -2.82233488e-02f, 4.55092117e-02f, -8.12500492e-02f, -6.03423901e-02f, 2.59448346e-02f, -4.06362489e-02f,
  -5.28935306e-02f, -3.43723372e-02f, -3.54547538e-02f, -1.67436544e-02f, 6.09221049e-02f, -1.23081533e-02f, 7.17451051e-02f, 2.60809585e-02f, 2.94875838e-02f, 6.13911785e-02f,
  1.00852020e-01f, 2.76100426e-03f, -4.19170633e-02f, 5.29239960e-02f, -5.96722960e-02f, 2.88125779e-02f, 7.89426193e-02f, -4.66954410e-02f, 1.47289010e-02f, -7.17183948e-02f,
  -1.49576031e-02f, -1.54609224e-02f, 4.30346793e-03f, -7.84250908e-03f, 1.12806004e-03f, -5.22716343e-02f, -3.65552083e-02f, -2.30417941e-02f, -1.63919609e-02f, -2.09312867e-02f,
  5.22929765e-02f, 3.30822431e-02f, -6.00050855e-03f, 2.11255886e-02f, -3.02341226e-02f, 3.68242222e-03f, 3.20950970e-02f, -1.34292662e-01f, 2.67704371e-02f, 2.79042050e-02f,
  -2.88374513e-01f, 1.82290465e-01f, -1.50301605e-02f, -1.06932014e-01f, -7.37211062e-03f, -5.06230742e-02f, 3.70643139e-02f, -9.99982953e-02f, 2.04241723e-02f, -5.01123480e-02f,
  -3.74559197e-03f, -5.25037125e-02f, -1.28966346e-01f, -2.10775230e-02f, 5.50522581e-02f, -5.96946850e-02f, 4.45890753e-03f, -3.15928347e-02f, -1.20286969e-02f, 9.75150391e-02f,
  2.25940142e-02f, -3.31145525e-02f, 1.11521393e-01f, 7.42549673e-02f, -5.41044511e-02f, -4.99275625e-02f, 2.88194697e-02f, -1.08954562e-02f, 2.68976763e-02f, 7.56204128e-03f,
  8.87137931e-03f, -2.94086248e-01f, -1.71309873e-01f, 1.06761150e-01f, 2.42646471e-01f, 2.36799493e-01f, -8.96127522e-02f, 1.61781594e-01f, -1.08711481e-01f, -2.91359663e-01f,
  -1.54837161e-01f, -1.85595930e-01f, -2.59764165e-01f, 4.54633832e-02f, 3.79984707e-01f, -1.25575781e-01f, 1.65262729e-01f, -1.86282098e-02f, 3.53677720e-02f, -6.77894056e-02f,
  9.95448902e-02f, 1.63372949e-01f, 1.15158595e-01f, 1.39292508e-01f, 2.96559725e-02f, 2.92039756e-02f, 6.42290190e-02f, 5.59676699e-02f, 9.82035920e-02f, 2.22365722e-01f,
  -5.86934872e-02f, -1.99889109e-01f, -1.03769340e-01f, -1.47283763e-01f, 7.07256496e-02f, -1.65233798e-02f, -8.06783736e-02f, 6.90166354e-02f, 8.08759257e-02f, 7.78625607e-02f,
  -1.51008815e-01f, 6.73719570e-02f, 1.33909717e-01f, 5.01675643e-02f, 6.58330247e-02f, -4.38336730e-02f, 2.40804125e-02f, -8.80982503e-02f, -3.59773748e-02f, 5.40147014e-02f,
  -3.39996107e-02f, 1.42153054e-02f, 5.31064495e-02f, 8.17042887e-02f, -3.75544541e-02f, 4.23149392e-02f, 5.57257198e-02f, 1.24383345e-02f, 9.07059908e-02f, 1.01616234e-01f,
  9.96028259e-02f, -1.06715612e-01f, 1.06873478e-04f, 4.09795679e-02f, -6.82892883e-03f, 5.23429029e-02f, -7.73755368e-03f, 7.76714087e-02f, -7.91730508e-02f, -8.49421024e-02f,
  1.03198336e-02f, 6.65809661e-02f, -4.61683683e-02f, -8.57599080e-02f, -2.14322284e-03f, -1.52797354e-02f, -3.59535255e-02f, -5.27759343e-02f, -5.79184256e-02f, 2.26978604e-02f,
  1.57945845e-02f, -1.91468671e-02f, 8.31398647e-03f, 6.17104545e-02f, 6.32480830e-02f, -4.46634628e-02f, -7.81442448e-02f, -5.79543002e-02f, 1.45216221e-02f, 7.48538449e-02f,
  -4.73660290e-01f, -3.80507976e-01f, -8.48912522e-02f, -6.84586354e-03f, -7.21672848e-02f, -7.46902898e-02f, -1.21466398e-01f, 1.87539145e-01f, -1.27717733e-01f, -5.74520614e-04f,
  -1.43626379e-02f, -1.89490933e-02f, 2.86367256e-02f, -5.67882136e-03f, 3.00524067e-02f, -4.17784266e-02f, -9.46294442e-02f, -6.85377866e-02f, -1.14079051e-01f, -1.67858582e-02f,
  -7.90599659e-02f, -8.37878138e-02f, 5.53160673e-03f, 1.54108152e-01f, -1.78697556e-02f, 2.11480143e-03f, 7.18445480e-02f, 1.56865679e-02f, 9.44990143e-02f, -6.43592626e-02f,
  3.46656679e-03f, 1.62548333e-01f, 4.50553223e-02f, 1.79651052e-01f, -1.78473115e-01f, -2.66318947e-01f, -3.46839368e-01f, 8.20624083e-02f, -1.72322854e-01f, -2.87418872e-01f,
  -1.54346955e-04f, 7.24159628e-02f, -2.24111393e-01f, 1.75255716e-01f, 3.45437109e-01f, 4.47239690e-02f, 2.27928951e-01f, -9.03674811e-02f, 2.64161155e-02f, 1.48563117e-01f,
  1.11508317e-01f, 1.47761256e-01f, 3.01658005e-01f, 2.41113648e-01f, 1.21453337e-01f, 9.97455269e-02f, 2.24409133e-01f, 3.42130028e-02f, 1.60131842e-01f, 1.32902890e-01f,
  -6.37470856e-02f, 3.46326642e-02f, 1.03661111e-02f, 4.18252833e-02f, 7.52596557e-02f, -1.49769366e-01f, -3.43809463e-02f, 3.39389406e-02f, -6.63608313e-02f, -4.65114079e-02f,
  -4.54529412e-02f, -6.84327781e-02f, -2.07391046e-02f, 5.66477003e-03f, 2.43924502e-02f, 3.84872109e-02f, 1.16695978e-01f, 4.25515175e-02f, 5.03076590e-04f, 6.28249124e-02f,
  4.55615856e-02f, -3.17167155e-02f, 5.16293151e-03f, 2.58876439e-02f, 4.85220663e-02f, -6.45342469e-02f, -1.29530877e-01f, 4.64807032e-03f, -5.88924214e-02f, -4.83862497e-03f,
  3.26056667e-02f, -2.15245083e-01f, -9.21508595e-02f, -1.65755644e-01f, -2.76372975e-05f, -9.67794582e-02f, 6.22520186e-02f, 2.59123668e-02f, -1.08429633e-01f, 4.16798331e-02f,
  -1.20005952e-02f, 5.10589741e-02f, -8.55191723e-02f, -9.56106558e-02f, 5.83989397e-02f, -2.75037102e-02f, 3.10700312e-02f, 6.35029674e-02f, -5.75992689e-02f, 3.34031731e-02f,
  2.79931985e-02f, 1.39947440e-02f, -8.42431411e-02f, 2.83075087e-02f, -1.71576545e-01f, -2.79108202e-03f, 6.98905438e-02f, 6.77997470e-02f, 3.93348150e-02f, 8.28676298e-02f,
  1.23297870e-01f, 1.78144425e-01f, 2.56781769e-03f, -5.58126671e-03f, -1.77245103e-02f, 6.86775073e-02f, 6.67566573e-03f, -1.55439777e-02f, 1.46157041e-01f, 2.14284174e-02f,
  4.13049757e-02f, -5.93515784e-02f, 4.72140685e-03f, 5.65988496e-02f, -7.45528785e-04f, 1.42891735e-01f, 2.00815331e-02f, -6.44402653e-02f, 8.25034007e-02f, 8.04221481e-02f,
  8.45135674e-02f, -1.07679665e-02f, 4.32986692e-02f, -9.43797156e-02f, 1.24991126e-02f, 2.87900083e-02f, -1.65223181e-02f, -1.02410220e-01f, 1.68645650e-01f, -8.41282960e-03f,
  -5.73234916e-01f, 4.53137755e-01f, 3.04826647e-01f, -3.49467218e-01f, 2.86599219e-01f, 1.43927976e-01f, -4.18683141e-02f, 2.19068691e-01f, 3.50236073e-02f, 8.95733461e-02f,
  -6.30209893e-02f, 1.50734827e-01f, 1.40053347e-01f, 3.55993584e-02f, -3.01712066e-01f, 8.07510130e-03f, -2.15312943e-01f, -1.59269139e-01f, 1.38469279e-01f, -3.24764624e-02f,
  -1.62229195e-01f, -1.33726329e-01f, 3.20292241e-03f, 2.10546926e-01f, 1.50228277e-01f, 1.14101015e-01f, -2.12050781e-01f, 9.46672931e-02f, 4.01894413e-02f, 6.80908188e-02f,
  -5.77952079e-02f, 6.79689497e-02f, 1.03360072e-01f, 6.23468012e-02f, -7.13511109e-02f, -1.07480720e-01f, -9.49068964e-02f, -5.85915856e-02f, -8.11056793e-03f, 2.31019203e-02f,
  -2.33184285e-02f, -1.01025447e-01f, 2.14986373e-02f, 5.44640236e-02f, 1.26861800e-02f, 7.37820342e-02f, 1.54481456e-01f, 9.32444856e-02f, 1.60101533e-01f, 5.12115546e-02f,
  1.19196698e-01f, 6.22519925e-02f, 2.17587315e-02f, -1.28345340e-01f, 2.27252208e-02f, -4.19821154e-04f, -1.21011399e-02f, -8.75665247e-02f, -6.33761734e-02f, -9.71028232e-04f,
  4.87988181e-02f, -5.71167022e-02f, 2.59249378e-02f, 6.59513054e-03f, 3.99365649e-02f, 3.65566574e-02f, 1.45830717e-02f, -7.73355812e-02f, -7.12363496e-02f, -5.94388358e-02f,
  -1.78510308e-01f, 1.38278576e-02f, 2.03703484e-03f, -3.62674929e-02f, 1.30502013e-02f, 6.78599775e-02f, -2.43737996e-02f, -5.75777739e-02f, -1.45703377e-02f, -2.23619826e-02f,
  -3.47552896e-02f, -2.02368889e-02f, -3.70556451e-02f, -4.36386727e-02f, -4.85854968e-02f, 3.26206572e-02f, 4.17742226e-03f, 8.77439082e-02f, -3.06688715e-02f, -6.05956353e-02f,
  -1.78580657e-01f, -3.51880640e-01f, -5.41940555e-02f, -1.42943521e-03f, 6.11864738e-02f, -1.37376813e-02f, -1.27298804e-03f, 6.33983091e-02f, 1.82103142e-02f, 8.70915651e-02f,
  3.68306041e-02f, 3.23055983e-02f, -1.42414480e-01f, 4.90663275e-02f, -1.49327973e-02f, -1.11280702e-01f, -1.26360297e-01f, -5.37025668e-02f, -2.92870216e-02f, 3.53450552e-02f,
  -6.66545033e-02f, -6.77974671e-02f, 4.35188264e-02f, -4.07126583e-02f, -1.10473692e-01f, 6.50878111e-03f, -1.06040500e-01f, 3.83471027e-02f, 5.66090196e-02f, -4.76261303e-02f,
  -3.65457356e-01f, -1.05431201e-02f, 4.25857484e-01f, -2.29612842e-01f, 1.95532545e-01f, 3.85005504e-01f, 1.22441366e-01f, 1.20978698e-01f, 8.09811521e-03f, -2.22222134e-01f,
  -1.52563825e-01f, -1.11546025e-01f, 1.46158591e-01f, -1.99646689e-02f, 1.72032163e-01f, 4.14391272e-02f, -6.59559816e-02f, -1.68680623e-01f, 9.94056910e-02f, -8.14155489e-02f,
  -2.73666028e-02f, -2.03333899e-01f, 2.51107752e-01f, -2.75011566e-02f, 1.79071829e-01f, -1.05399720e-01f, -1.41345456e-01f, 4.27533649e-02f, -8.89130533e-02f, 1.31299883e-01f,
  -1.32658958e-01f, -1.45350739e-01f, 3.98781374e-02f, -7.06502993e-04f, -1.07876565e-02f, 6.50723130e-02f, -1.80512909e-02f, 6.19298480e-02f, 2.73105782e-02f, 7.65422732e-02f,
  3.72488834e-02f, 8.36353377e-02f, -3.05175781e-02f, -4.24822457e-02f, -2.61557959e-02f, -1.18788630e-02f, 1.45770624e-01f, 4.38603535e-02f, 3.40325162e-02f, 6.17719889e-02f,
  1.16887830e-01f, 1.39539301e-01f, 1.56345349e-02f, -1.71120256e-01f, 1.50735229e-01f, -7.50794495e-03f, 3.70519608e-02f, 6.18653856e-02f, 6.54720888e-02f, 6.67695701e-02f,
  -1.66602824e-02f, -7.45188736e-05f, 5.71521465e-03f, -7.62114674e-02f, 1.17507152e-01f, 8.16713960e-04f, 7.17734545e-03f, -4.48032580e-02f, 6.63892031e-02f, 6.41118214e-02f,
  -3.56839076e-02f, -6.29107058e-02f, 4.02265787e-02f, -4.36382368e-02f, -6.22770488e-02f, -9.33007449e-02f, -7.45861828e-02f, 6.94576949e-02f, 4.60331850e-02f, 1.92016773e-02f,
  -8.95973444e-02f, -3.95928621e-02f, 2.55744848e-02f, -2.41392218e-02f, -7.78445378e-02f, 9.04633012e-03f, -6.20037597e-03f, 5.22189178e-02f, -4.01263908e-02f, 1.79898161e-02f,
  -4.28762257e-01f, -3.66221070e-01f, -5.04229665e-02f, -7.73831233e-02f, -1.88171312e-01f, -7.68695548e-02f, -7.97344092e-03f, -7.90522769e-02f, -1.29170671e-01f, -7.48256147e-02f,
  -3.75883095e-02f, -8.91943797e-02f, 6.60973266e-02f, -9.96230319e-02f, -3.31844762e-02f, 3.46609727e-02f, -1.34620354e-01f, -1.87448680e-01f, -2.10575044e-01f, -1.91337280e-02f,
  -1.75318494e-02f, -1.18261859e-01f, 7.81163350e-02f, -1.12329086e-03f, -4.68117669e-02f, -1.48251057e-02f, -8.85268897e-02f, -5.24632540e-03f, -4.79578227e-02f, -5.86284921e-02f,
  2.96997756e-01f, -3.19075078e-01f, -3.54741514e-01f, -7.45887235e-02f, 2.19748646e-01f, 3.34805757e-01f, 9.45723504e-02f, 1.09882867e-02f, -2.11225241e-01f, -8.25607330e-02f,
  1.78010255e-01f, -7.26126805e-02f, -2.68602639e-01f, 1.42496616e-01f, 3.24808121e-01f, -3.49031508e-01f, 8.21284950e-02f, 1.28192008e-01f, -1.98020563e-01f, 7.40715265e-02f,
  1.10480160e-01f, 3.82378876e-01f, -1.13169208e-01f, 1.53434932e-01f, 1.43550068e-01f, -5.70381097e-02f, 2.04381198e-01f, -7.03554079e-02f, 2.26106167e-01f, 1.82492495e-01f,
  7.66679943e-02f, -6.60532266e-02f, -9.62820351e-02f, 4.12709750e-02f, -4.54446077e-02f, 6.70115352e-02f, -8.97063389e-02f, 2.45851278e-02f, 6.72947317e-02f, -6.22622259e-02f,
  8.66014883e-02f, 9.99593809e-02f, -4.07982469e-02f, -2.84407493e-02f, 5.18309996e-02f, -2.85504740e-02f, -2.83754691e-02f, -1.29519880e-01f, -3.73475924e-02f, -6.57971995e-03f,
  -1.70333460e-01f, -4.22939332e-03f, -5.01481928e-02f, -7.90939480e-02f, -2.63128188e-02f, 3.24600860e-02f, -5.91485314e-02f, 2.50296202e-02f, 2.06869412e-02f, -1.37533862e-02f,
  1.24577925e-01f, 5.27085662e-02f, 5.18469177e-02f, -1.09113060e-01f, -1.41599542e-02f, -1.13274746e-01f, 5.60518615e-02f, -2.19798479e-02f, -2.69226339e-02f, -1.33361267e-02f,
  -7.34680425e-03f, -2.64834594e-02f, 7.62145668e-02f, 3.44885811e-02f, -4.37915884e-02f, 9.89500154e-03f, 6.02025464e-02f, -7.86633864e-02f, -1.56542853e-01f, 7.13008223e-03f,
  -1.49623069e-04f, -4.96794842e-02f, 1.77294742e-02f, 6.23541810e-02f, -1.43932980e-02f, -5.60751483e-02f, 8.67290273e-02f, -3.18548754e-02f, -9.47182775e-02f, -3.17205861e-02f,
  2.47487072e-02f, -3.30971889e-02f, -1.42448932e-01f, -1.20805511e-02f, -7.10420683e-02f, 3.98214795e-02f, 1.91320609e-02f, 3.51017490e-02f, -1.59724765e-02f, -2.02087536e-02f,
  9.70582590e-02f, 8.37573595e-03f, -5.02143912e-02f, -9.79370438e-03f, 8.60366374e-02f, -6.25662971e-03f, 1.04690865e-02f, -1.11356124e-01f, 2.46392637e-02f, 4.36136350e-02f,
  2.86317952e-02f, 5.98405264e-02f, 4.67039980e-02f, -9.29468647e-02f, -7.07807615e-02f, -2.17182431e-02f, 2.27500107e-02f, 4.32070009e-02f, -2.98807751e-02f, -5.66118248e-02f,
  1.71433195e-01f, 3.26188952e-02f, 1.55107886e-01f, 1.71274200e-01f, 1.74246788e-01f, 2.19597355e-01f, 1.95518583e-01f, 2.58721650e-01f, 3.51196229e-01f, -1.88578159e-01f,
  -2.35751137e-01f, -7.03592552e-03f, -7.16281077e-03f, -1.47246912e-01f, 8.84658396e-02f, 1.25469685e-01f, 1.55399457e-01f, 8.19571912e-02f, 2.52294481e-01f, -2.89667994e-02f,
  8.62730592e-02f, -1.84684455e-01f, -1.63715616e-01f, -1.98360085e-01f, -1.58688083e-01f, -6.75703958e-02f, -2.77372569e-01f, -4.04385105e-02f, -2.69048005e-01f, -7.27220951e-03f,
  -2.85460032e-03f, 9.11342129e-02f, -1.96032465e-01f, 1.72093678e-02f, 1.00207403e-02f, 6.11925907e-02f, -3.67926769e-02f, 3.16802673e-02f, -2.08982751e-02f, -3.53439478e-03f,
  -8.68387371e-02f, -7.14751482e-02f, -5.19735217e-02f, 2.23305617e-02f, 1.26048610e-01f, 1.06575945e-02f, -9.31042656e-02f, 4.52314466e-02f, -1.73103716e-02f, 1.00650236e-01f,
  -7.80537799e-02f, -5.46690039e-02f, -8.04869607e-02f, 1.56368569e-01f, -6.59942478e-02f, 9.26275924e-02f, -6.22960664e-02f, 1.42945098e-02f, -1.20646730e-01f, 7.72581473e-02f,
  1.24680072e-01f, 9.73533913e-02f, 4.50999103e-02f, 1.40536912e-02f, -9.47191939e-02f, -7.15578049e-02f, -1.33584782e-01f, -6.77024946e-02f, 4.54620980e-02f, -1.13395778e-02f,
  -1.86943710e-02f, -1.29204597e-02f, 6.28260449e-02f, 1.14030562e-01f, -7.82472938e-02f, 1.18431836e-01f, 5.19641787e-02f, 7.52739757e-02f, 4.39381674e-02f, -1.11301159e-02f,
  -4.17348668e-02f, 4.42427993e-02f, -4.59487326e-02f, 1.47650307e-02f, 7.32619837e-02f, -5.64904734e-02f, -8.12182352e-02f, 1.86612166e-03f, 5.67213744e-02f, -4.09628190e-02f,
  -4.79211025e-02f, 1.01890624e-01f, -9.23319981e-02f, -1.59885913e-01f, -8.72049332e-02f, -5.02826087e-02f, -6.57307683e-03f, -8.57562423e-02f, 4.45821956e-02f, 4.20162044e-02f,
  1.35340942e-02f, -8.17220192e-03f, -6.69152960e-02f, 1.01503290e-01f, -2.67726406e-02f, -4.63488027e-02f, -9.44362953e-02f, 3.81056517e-02f, -4.66807485e-02f, 3.17181908e-02f,
  -1.00403354e-01f, -7.43780509e-02f, 4.78306487e-02f, -1.23734884e-01f, 2.09148880e-02f, -7.26232678e-02f, 7.65427127e-02f, 1.78406984e-02f, -1.86793245e-02f, 9.47348122e-03f,
  -3.69453192e-01f, -1.88814159e-02f, 1.01257391e-01f, -2.64612526e-01f, 4.94948961e-02f, -2.30469350e-02f, -2.40806788e-01f, -1.58739220e-02f, -2.56265551e-01f, -2.55186677e-01f,
  -1.81619570e-01f, 8.68016947e-03f, -6.60494044e-02f, -1.73252061e-01f, 3.90909821e-01f, 1.80275306e-01f, 4.53040143e-03f, 2.47131232e-02f, 2.09979728e-01f, -1.59486890e-01f,
  4.31102104e-02f, -3.08943745e-02f, 1.92777291e-01f, 1.33038804e-01f, -1.17723897e-01f, -8.46482739e-02f, -3.82964984e-02f, 3.88257839e-02f, 4.34530695e-04f, 3.00834118e-03f,
  6.92972392e-02f, -3.30050290e-01f, 9.17876419e-03f, 1.28508449e-01f, 5.59914447e-02f, 2.37914398e-02f, 7.90741369e-02f, 3.49410810e-02f, 6.92794546e-02f, 6.15742207e-02f,
  3.83613259e-02f, 1.96054243e-02f, -1.11938365e-01f, 1.27604594e-02f, 4.18763869e-02f, 5.31310961e-02f, 9.34780836e-02f, 7.72083923e-02f, 1.89269502e-02f, 5.94680235e-02f,
  -3.55526283e-02f, 1.00137524e-01f, -5.20642549e-02f, 1.27319202e-01f, 8.39869380e-02f, -3.38462964e-02f, -6.62550423e-03f, -6.42950507e-03f, 1.25997022e-01f, -6.15390949e-02f,
  5.73264100e-02f, -9.83565673e-02f, -9.70222522e-03f, 6.00438416e-02f, -1.80679172e-01f, -1.81487706e-02f, -1.23083265e-02f, 2.85894778e-02f, -1.18949786e-01f, 2.31062099e-02f,
  -6.14174409e-03f, 6.99450299e-02f, -1.90955382e-02f, 4.01912397e-03f, -4.02016304e-02f, -6.69347448e-03f, -4.20998074e-02f, 7.95146525e-02f, -3.29257734e-02f, -2.88268588e-02f,
  1.54422354e-02f, -1.91061087e-02f, -1.92218032e-02f, 4.28796858e-02f, -7.13622794e-02f, 2.37882864e-02f, 2.16754861e-02f, -6.10713325e-02f, -1.93927567e-02f, 8.11624080e-02f,
  5.58488481e-02f, -3.01759243e-01f, -5.82506973e-03f, 2.78336760e-02f, 7.79529363e-02f, 1.07232198e-01f, 1.27096117e-01f, -5.66133298e-02f, -3.21693830e-02f, -1.02759957e-01f,
  9.12309885e-02f, -2.68207993e-02f, -8.08845535e-02f, -2.59193908e-02f, -1.12177636e-02f, 2.60474384e-02f, -2.49705762e-02f, 1.57066397e-02f, -4.72185016e-02f, -5.81664499e-03f,
  -6.94964034e-03f, -3.34140994e-02f, -4.23104037e-03f, -1.25965267e-01f, -8.44380111e-02f, -1.15518928e-01f, -2.79140342e-02f, -1.17725752e-01f, 1.23364218e-01f, 5.50549813e-02f,
  -4.22307044e-01f, 2.50537783e-01f, -1.47588804e-01f, 2.17352007e-02f, -3.22673857e-01f, 1.92466542e-01f, 2.89115429e-01f, -2.20462605e-01f, -1.66388065e-01f, 2.25983426e-01f,
  1.45554498e-01f, -1.89167142e-01f, 2.61764884e-01f, 3.11568469e-01f, -1.32878572e-01f, 3.76862973e-01f, 2.18375102e-01f, 1.31191969e-01f, -9.74296927e-02f, -1.51389346e-01f,
  -7.88947344e-02f, 1.40539080e-01f, 2.72233039e-01f, -1.16875559e-01f, -1.16410792e-01f, -1.49942830e-01f, 7.84287676e-02f, -1.99024200e-01f, 3.57297286e-02f, -1.13673843e-01f,
  -1.25658065e-01f, -2.20880076e-01f, -6.33230507e-02f, -9.55788121e-02f, -1.76699553e-02f, -4.23047552e-03f, -1.36153232e-02f, -4.31098379e-02f, -1.35823816e-01f, -8.73110965e-02f,
  -1.43105872e-02f, -1.27553582e-01f, 2.16665957e-02f, -4.05877717e-02f, -1.87929049e-02f, -9.02812835e-03f, 3.87883373e-02f, 1.00510947e-01f, 2.05359841e-03f, -8.49696919e-02f,
  -1.89729575e-02f, 5.42176515e-03f, 8.93338770e-02f, 7.54612014e-02f, -6.20747879e-02f, 1.49434367e-02f, 5.00378907e-02f, 6.23684004e-02f, -7.90048763e-03f, -7.18771219e-02f,
  -2.54294509e-03f, -1.18040785e-01f, 6.98443204e-02f, -1.25843495e-01f, 2.50879880e-02f, 2.47724168e-03f, 9.41324607e-02f, -1.99084654e-02f, 1.52256992e-02f, 1.37484327e-01f,
  -7.79307038e-02f, -1.10870078e-01f, -1.07557317e-02f, 1.36909008e-01f, 8.20427313e-02f, 4.05586623e-02f, -2.05422807e-02f, -1.11501612e-01f, 7.45933726e-02f, 6.19950853e-02f,
  4.67530191e-02f, -4.86534424e-02f, 5.58796786e-02f, 5.96865229e-02f, -9.22359005e-02f, 2.85900570e-02f, -2.50373334e-02f, 2.13596597e-02f, 3.57975811e-02f, 1.13963177e-02f,
  -1.68502346e-01f, -2.98400313e-01f, -6.63020276e-03f, 6.88712820e-02f, -6.42883265e-03f, -9.42311883e-02f, -1.37131084e-02f, -7.75107369e-02f, 9.22185928e-03f, 1.25576127e-02f,
  3.15848142e-02f, 2.48312149e-02f, -1.26659960e-01f, -4.20765057e-02f, 1.82043780e-02f, 3.46484333e-02f, 8.65071453e-03f, -3.63355828e-03f, -1.25473291e-02f, -7.42084533e-02f,
  2.49879099e-02f, 5.16224876e-02f, -1.54813007e-02f, 5.12035787e-02f, -2.38904878e-02f, 9.12308544e-02f, -2.35859659e-02f, -1.02194272e-01f, 5.07528149e-02f, 1.04316927e-01f,
  1.55196041e-01f, -2.12664470e-01f, -2.21670553e-01f, 3.37560773e-02f, 1.40489161e-01f, 2.24334538e-01f, 2.73321807e-01f, 9.68339369e-02f, 1.62782550e-01f, 1.44548461e-01f,
  2.22827300e-01f, -2.22627077e-05f, 1.13643687e-02f, 4.35402691e-01f, 2.11483240e-01f, 5.67202717e-02f, 3.17887902e-01f, 1.96608886e-01f, 6.30929321e-02f, 5.19504473e-02f,
  7.88535476e-02f, 2.46508494e-01f, -1.99364841e-01f, -7.82338623e-03f, 1.83048546e-01f, -2.89141953e-01f, -6.84494823e-02f, -2.44619429e-01f, 1.92037001e-01f, 1.82480186e-01f,
  1.19066149e-01f, 1.76961757e-02f, 4.93122600e-02f, -6.49888590e-02f, 8.01762659e-03f, -1.15064003e-01f, -9.92009137e-03f, 1.12308478e-02f, -1.50422662e-01f, 7.82928169e-02f,
  -4.59155366e-02f, -7.99446404e-02f, 1.30484834e-01f, 7.07908859e-03f, -1.97078325e-02f, -1.29757941e-01f, -6.43269643e-02f, 1.07655376e-02f, 1.89543273e-02f, -1.54464319e-01f,
  -1.59722149e-01f, 1.30083244e-02f, 1.80465300e-02f, 1.13659175e-02f, -3.73695791e-02f, 9.00779292e-02f, -1.79350466e-01f, -1.71209008e-01f, 6.89273253e-02f, 7.09050447e-02f,
  8.48312303e-02f, -1.39915287e-01f, 1.83125660e-02f, 7.65722618e-02f, -6.19414560e-02f, 9.84230265e-02f, 1.39119208e-01f, -4.11574282e-02f, 3.66618298e-02f, 2.36204546e-02f,
  8.45222548e-03f, -2.32039709e-02f, 1.36727899e-01f, -6.08970858e-02f, 1.53402150e-01f, -2.75510421e-04f, 3.56747545e-02f, 1.34609967e-01f, -2.81130504e-02f, 3.83178480e-02f,
  9.09348130e-02f, 2.25462322e-03f, 7.81539232e-02f, 9.58442986e-02f, 1.87155157e-02f, 1.81590412e-02f, 5.21912575e-02f, -2.27225218e-02f, -2.41080113e-02f, -1.67509709e-02f,
  -1.77874506e-06f, -3.38807888e-02f, -1.94747262e-02f, -7.85937440e-03f, -3.42534110e-02f, 7.46802315e-02f, -5.07644713e-02f, 1.57073326e-02f, 1.49923321e-02f, 3.06175724e-02f,
  -5.15693948e-02f, -9.69828442e-02f, -6.68321922e-03f, 1.72058865e-02f, -6.73169196e-02f, 6.15817122e-02f, 1.43530862e-02f, 3.21426392e-02f, 3.91719081e-02f, 1.13806678e-02f,
  -1.20597288e-01f, 1.01627603e-01f, -4.13999408e-02f, -9.30059552e-02f, 8.34594816e-02f, -6.29917011e-02f, 9.33862627e-02f, -1.52117729e-01f, 8.62888992e-02f, 8.67356081e-03f,
  -1.80794939e-01f, 4.78632227e-02f, 2.91959286e-01f, -7.44373128e-02f, 2.44976893e-01f, 4.22618330e-01f, 1.73614576e-01f, -1.92766171e-02f, 2.10971422e-02f, 1.50112823e-01f,
  -5.54264113e-02f, 1.32208303e-01f, -1.21975861e-01f, -1.60899162e-01f, 1.01216952e-03f, -1.59337193e-01f, 4.28629778e-02f, 9.19897109e-02f, -1.37379155e-01f, 4.79405560e-02f,
  -2.38922685e-02f, -9.91974771e-02f, -2.62132287e-01f, -3.42814326e-02f, -2.43568327e-02f, -3.15351575e-03f, -2.48967513e-01f, 6.35901392e-02f, -1.59952343e-02f, 3.45887430e-02f,
  6.69324994e-02f, -1.89040065e-01f, -9.82263610e-02f, 2.31006909e-02f, -1.67603157e-02f, 8.84594917e-02f, 9.80735794e-02f, 2.85993647e-02f, -2.32938435e-02f, 4.22400832e-02f,
  1.36293173e-01f, 5.54375425e-02f, -5.06678820e-02f, -5.51241599e-02f, -9.93884448e-03f, -3.71335745e-02f, 2.02555489e-02f, 5.88917136e-02f, -1.98712815e-02f, 1.84606947e-02f,
  5.90121672e-02f, 3.27783264e-02f, 5.65504022e-02f, 8.24127495e-02f, -2.81947087e-02f, -1.29287764e-01f, -1.32995546e-02f, 4.79725488e-02f, 1.31203517e-01f, 1.26483917e-01f,
  1.29435975e-02f, 1.60514042e-01f, 3.05763120e-03f, -3.23835202e-03f, 3.71639766e-02f, -5.56385405e-02f, 3.84774953e-02f, -9.79088172e-02f, -4.53630127e-02f, 4.76114191e-02f,
  -3.41666825e-02f, -6.20101057e-02f, -4.77890559e-02f, 8.29498097e-02f, -6.11863248e-02f, 9.37281828e-03f, 3.16707976e-02f, 1.35248406e-02f, 8.11070055e-02f, 5.98987192e-02f,
  -9.50559601e-02f, -5.89062087e-03f, -1.43258721e-01f, -2.35156901e-02f, 6.33317083e-02f, -8.35717022e-02f, 7.26744458e-02f, -5.90112545e-02f, -9.82415117e-03f, 1.34946212e-01f,
  1.51621625e-01f, 2.99250960e-01f, -1.32628545e-01f, -1.14072084e-01f, -5.86266965e-02f, 1.34487852e-01f, 4.75310311e-02f, -7.64942020e-02f, 3.51471305e-02f, 7.73489997e-02f,
  5.02446704e-02f, -7.90458694e-02f, 1.07114375e-01f, 5.36174215e-02f, 6.19806051e-02f, -1.08063100e-02f, 1.52071118e-01f, 1.19309202e-01f, 1.51324272e-01f, 2.87347008e-02f,
  4.39696424e-02f, 1.35729492e-01f, 6.54509962e-02f, 1.03409238e-01f, -3.48301083e-02f, 1.03166252e-01f, 2.40902621e-02f, -1.15017675e-01f, 1.07284889e-01f, 1.66914329e-01f,
  -1.08508646e-01f, 8.07428360e-02f, -2.15751290e-01f, -1.46904603e-01f, 4.29344177e-02f, 9.15630981e-02f, 1.10830918e-01f, 2.18826588e-02f, -7.28072673e-02f, 2.65026569e-01f,
  1.34072714e-02f, 4.33520153e-02f, -4.28010337e-02f, -3.74968410e-01f, -2.66449153e-01f, -1.27653643e-01f, -1.23552578e-02f, 4.39573117e-02f, -2.90117115e-02f, 1.65941536e-01f,
  -7.86425322e-02f, 1.13244094e-01f, -2.07702339e-01f, 1.49555206e-01f, -3.62113267e-02f, 8.63108709e-02f, 2.13152424e-01f, 9.30221602e-02f, 6.65506199e-02f, -5.90272099e-02f,
  -1.55089736e-01f, -4.00795639e-02f, -3.68702114e-02f, -4.08787802e-02f, -2.50859722e-03f, -3.16457115e-02f, 1.05850920e-01f, -5.84040508e-02f, -1.49004138e-03f, 3.17734927e-02f,
  1.36438832e-01f, 5.78899272e-02f, 5.53449132e-02f, -1.40021458e-01f, 1.58411935e-02f, -3.98415066e-02f, -3.79348919e-02f, -1.00496270e-01f, 5.19255511e-02f, -1.05748765e-01f,
  -7.66772479e-02f, -1.18655309e-01f, 1.77028909e-01f, -4.06271704e-02f, -8.59473180e-03f, -2.21491456e-02f, 3.24682705e-02f, 6.88954396e-03f, 5.81493527e-02f, 7.04721212e-02f,
  1.59649514e-02f, -1.96473505e-02f, -2.88507883e-02f, -2.51373788e-03f, -1.19561527e-03f, 2.41587032e-02f, -5.07289218e-03f, 2.40320209e-02f, 8.50308686e-02f, -1.41290668e-02f,
  5.64760901e-02f, 5.27462363e-03f, -4.36030738e-02f, 3.79716791e-02f, 1.17008023e-01f, -1.11267187e-01f, 2.84251869e-02f, -3.56150307e-02f, 5.93892895e-02f, 2.32602507e-02f,
  -5.98771460e-02f, 5.53202741e-02f, 1.67340226e-02f, 7.06445053e-02f, 3.42968293e-02f, -1.45364366e-02f, 4.82152216e-03f, -9.24514532e-02f, -1.94432121e-02f, 7.95800537e-02f,
  1.39455169e-01f, 3.18869650e-01f, 2.33894065e-02f, -1.19450368e-01f, 2.93112118e-02f, -4.23998982e-02f, -4.56020422e-02f, -2.20803581e-02f, 4.17782925e-02f, 7.08644539e-02f,
  1.12969853e-01f, 1.05638236e-01f, 8.12368393e-02f, -6.71406165e-02f, -1.29971746e-02f, 1.50774628e-01f, 1.04773706e-02f, 6.31714389e-02f, 1.97712868e-01f, 4.58150543e-02f,
  4.13808040e-02f, 1.40257359e-01f, 7.35661611e-02f, 2.75205318e-02f, 6.64142147e-02f, 7.05372989e-02f, 1.09048575e-01f, 1.20423930e-02f, 1.18918866e-01f, 2.91954186e-02f,
  -3.67373526e-01f, -7.24721700e-02f, -9.96391177e-02f, -3.53900790e-01f, 2.07278997e-01f, 6.28508106e-02f, -1.82068512e-01f, 1.18320294e-01f, -2.60673106e-01f, 1.62490800e-01f,
  -3.15721966e-02f, -2.54127949e-01f, -4.57675010e-02f, -2.46581778e-01f, -3.68848622e-01f, -2.65737683e-01f, -1.59708813e-01f, -2.37376481e-01f, -1.81220189e-01f, 2.09169928e-02f,
  -1.67391971e-01f, -7.44751617e-02f, -2.40978688e-01f, 2.32459575e-01f, 1.47379220e-01f, 1.07199706e-01f, 3.18681926e-01f, 1.89764842e-01f, 1.47570893e-01f, -1.87124182e-02f,
  -1.34786889e-01f, -1.59494281e-01f, -3.33189704e-02f, 1.99665558e-02f, 4.52707745e-02f, 1.44555777e-01f, 1.91001862e-01f, 2.35930718e-02f, -7.48954937e-02f, -9.03483189e-04f,
  1.06420457e-01f, -1.35625720e-01f, -4.75221761e-02f, -3.10100745e-02f, 1.21971555e-02f, -7.10165352e-02f, -7.78851733e-02f, 3.14559154e-02f, -9.52081531e-02f, -1.46621674e-01f,
  -5.39801344e-02f, -7.61519000e-02f, 6.83200434e-02f, 5.71819134e-02f, 1.83692179e-03f, 1.19560035e-02f, -8.28422680e-02f, 4.57956120e-02f, -6.08978979e-02f, -2.48568002e-02f,
  1.37628643e-02f, 2.98270080e-02f, -7.22862035e-03f, -8.45072418e-02f, -9.99736413e-02f, 1.63398460e-02f, 4.41040955e-02f, 1.85966697e-02f, 6.94981823e-03f, -1.24481795e-02f,
  2.57396083e-02f, 7.12676067e-03f, -9.92163718e-02f, 8.07875916e-02f, -7.54883513e-03f, -1.00179262e-01f, 6.00770079e-02f, 1.04614817e-01f, 1.60962362e-02f, 3.60042974e-02f,
  8.47677216e-02f, 4.80139852e-02f, 5.58758453e-02f, 7.00567141e-02f, -1.54115483e-01f, -4.19314243e-02f, 1.20588213e-01f, -3.09200236e-03f, 1.15243662e-02f, 1.02199413e-01f,
  1.23680376e-01f, 1.77464083e-01f, -1.31420614e-02f, -1.95355359e-02f, 2.35106423e-02f, 3.47685069e-02f, -7.46959224e-02f, -6.71805590e-02f, 1.23635130e-02f, -7.50873750e-03f,
  4.94007729e-02f, -3.52939740e-02f, 1.39203757e-01f, 1.52781093e-02f, 7.87880570e-02f, 4.09826636e-02f, 1.18799746e-01f, 6.79179356e-02f, 9.07331929e-02f, -4.50471323e-03f,
  1.51021227e-01f, 7.62952715e-02f, -5.92006594e-02f, 2.38616671e-02f, 7.58340582e-02f, 4.78625223e-02f, 9.06366184e-02f, -5.78288957e-02f, -2.42487770e-02f, -4.09934632e-02f,
  1.96939021e-01f, 3.12831283e-01f, 4.42098975e-02f, -3.94053617e-03f, -2.75997579e-01f, 1.32509440e-01f, 2.04675585e-01f, -8.08207020e-02f, 1.30583540e-01f, 2.38989100e-01f,
  -2.27680013e-01f, 3.09092820e-01f, -7.37689510e-02f, 3.96810919e-02f, -1.23905547e-01f, 9.27103311e-02f, 1.07503325e-01f, 2.77241737e-01f, -4.40990925e-03f, -8.39393307e-03f,
  -1.26658961e-01f, -1.19909123e-01f, -2.08538398e-01f, -7.31818900e-02f, 6.08117646e-03f, -7.03918864e-04f, -1.66448891e-01f, -1.16267420e-01f, 1.02390014e-01f, -1.91548970e-02f,
  -1.85387246e-02f, 1.84144199e-01f, 4.79526781e-02f, 1.52866229e-01f, 9.32004396e-03f, 1.72118187e-01f, 4.65756021e-02f, -4.17640619e-02f, -1.14558257e-01f, 1.35615438e-01f,
  2.08227988e-02f, 7.95660615e-02f, 3.68727632e-02f, -3.57773639e-02f, 3.17790955e-02f, 1.15413830e-01f, -9.14811939e-02f, -1.43080369e-01f, -2.65278798e-02f, 6.65206183e-03f,
  5.47856428e-02f, 7.47907683e-02f, 3.65991183e-02f, 6.55858517e-02f, -8.57403576e-02f, -8.57909303e-03f, 5.40868565e-02f, 2.95395739e-02f, 1.27019197e-01f, 1.16560139e-01f,
  2.13710833e-02f, 9.94346440e-02f, 1.26870155e-01f, -3.49381007e-02f, -2.33747251e-02f, -3.24379234e-03f, 6.76486418e-02f, -7.02782720e-02f, -1.53600203e-03f, -2.45357454e-02f,
  2.50697527e-02f, -2.60905158e-02f, -1.60748493e-02f, -1.19623775e-03f, -1.20968081e-01f, 7.70180598e-02f, -1.26684909e-05f, 9.58997309e-02f, -2.23561898e-02f, -2.25911111e-01f,
  -2.57360153e-02f, -3.54560354e-04f, 8.18884298e-02f, -6.67176098e-02f, 1.06837470e-02f, -4.40052301e-02f, -5.07459091e-03f, 1.61018409e-03f, -8.12276080e-02f, -5.52824289e-02f,
  3.92414629e-02f, 1.69676930e-01f, 1.20707691e-01f, 1.50445737e-02f, -1.11687034e-02f, 1.59580991e-01f, 4.76722606e-02f, 1.41334325e-01f, 2.65008230e-02f, 9.36192833e-03f,
  -1.45892696e-02f, -3.16115469e-02f, 7.99921975e-02f, -1.19277388e-01f, -4.23505902e-02f, -7.09467055e-03f, 2.37820502e-02f, -7.45869130e-02f, -1.04913153e-01f, -8.16387832e-02f,
  -4.43946831e-02f, 4.66091186e-02f, 8.63585919e-02f, -6.79595745e-04f, -3.78132053e-02f, 4.43965010e-03f, 7.88665116e-02f, 2.71511357e-03f, -1.30129740e-01f, -4.81136367e-02f,
  -2.13680372e-01f, 1.27387151e-01f, 5.27436845e-02f, -3.24746698e-01f, 2.08560795e-01f, 3.21338087e-01f, -2.88345013e-02f, 2.06950098e-01f, -1.59028739e-01f, -1.73281938e-01f,
  -1.41224787e-01f, -2.38248810e-01f, -1.34965286e-01f, -2.06148580e-01f, -1.32468447e-01f, -1.18081152e-01f, -8.18998292e-02f, -1.23415500e-01f, 6.39618039e-02f, -6.87060133e-02f,
  -5.06163463e-02f, 4.57928292e-02f, 5.03883623e-02f, 4.10851449e-01f, 5.20792268e-02f, -6.44880813e-03f, -9.91040543e-02f, 2.96462983e-01f, -8.15432966e-02f, 5.97883426e-02f,
  1.14449495e-02f, -1.65737614e-01f, 1.44557446e-01f, 8.05079117e-02f, 9.56164673e-02f, -2.96491683e-02f, -9.26419254e-03f, 1.50816264e-02f, -7.28213787e-02f, -2.87530273e-02f,
  -1.06420126e-02f, 6.69637397e-02f, -5.92965074e-03f, 1.05783455e-01f, 6.15394935e-02f, -2.14481298e-02f, -1.02460325e-01f, -5.36615439e-02f, 8.39064941e-02f, -4.25961427e-02f,
  -1.08428523e-01f, 1.55710159e-02f, -1.15518376e-01f, -1.29958361e-01f, -9.78599563e-02f, -2.62768641e-02f, -3.55710685e-02f, 5.37521876e-02f, -1.36297286e-01f, -1.12843074e-01f,
  7.50442892e-02f, -4.38821167e-02f, 4.70624715e-02f, -4.65840697e-02f, -1.12227201e-02f, -1.44690285e-02f, -1.05609164e-01f, -7.81836584e-02f, 1.32546145e-02f, 2.85801701e-02f,
  4.05594446e-02f, -6.27849773e-02f, -9.43562314e-02f, -1.30256638e-03f, -8.75209179e-03f, 1.77014228e-02f, -6.05109308e-05f, -1.09254673e-01f, -4.91996780e-02f, -3.99579778e-02f,
  -6.66091070e-02f, -7.34496862e-02f, 3.10569052e-02f, -5.18255830e-02f, 1.02032296e-01f, -4.04460765e-02f, -6.20378107e-02f, -2.22274335e-03f, 8.69777054e-02f, -3.07231955e-02f,
  1.63687218e-03f, 1.26077170e-02f, 3.12277582e-02f, 6.52401000e-02f, 1.00671306e-01f, 1.49854764e-01f, 2.50237752e-02f, 5.14987297e-02f, 1.12883039e-01f, 5.28517924e-02f,
  4.53834049e-02f, 2.53073201e-02f, 8.70843942e-05f, -1.20587885e-01f, 2.21066270e-02f, 9.58574787e-02f, -3.95234451e-02f, 8.11915249e-02f, 2.05550808e-02f, 1.16848061e-03f,
  -1.50656756e-02f, 3.90907265e-02f, -1.48165315e-01f, 5.32767251e-02f, -2.26361752e-02f, -1.09192289e-01f, 4.62143905e-02f, 3.91741805e-02f, -1.81836188e-01f, -6.78911731e-02f,
  -4.99019027e-01f, 2.00319275e-01f, -2.59782225e-01f, -1.65823027e-01f, -1.33833796e-01f, -1.81526884e-01f, -1.38779178e-01f, 8.27530026e-03f, 7.09326342e-02f, 2.64314413e-01f,
  1.39927194e-01f, 2.42644884e-02f, 3.82401556e-01f, 2.54915357e-02f, -2.18140736e-01f, 2.73744702e-01f, -2.13367924e-01f, -1.92070808e-02f, 1.41056284e-01f, -5.88840842e-02f,
  -1.78922594e-01f, 7.16516562e-03f, -1.56794429e-01f, 1.08262934e-01f, -2.31218576e-01f, -2.24434674e-01f, -1.35133520e-01f, 6.44207448e-02f, -2.79227674e-01f, -2.91884895e-02f,
  -3.51578653e-01f, 8.15808401e-03f, -6.48201182e-02f, -1.17227934e-01f, -2.12065101e-01f, -2.26296559e-02f, -1.80117503e-01f, 6.45179227e-02f, 7.84776285e-02f, 2.07032543e-02f,
  8.20782408e-02f, -3.12805399e-02f, -3.26061551e-03f, 8.60276222e-02f, -4.46883850e-02f, -6.60343394e-02f, -4.56405804e-03f, -9.80339497e-02f, -1.59634501e-02f, -2.73275711e-02f,
  6.24559559e-02f, -1.10463664e-01f, -2.07914382e-01f, -1.58988331e-02f, -2.85092276e-02f, -9.87789780e-02f, -3.55650149e-02f, -1.55095682e-01f, -1.20953783e-01f, -1.24932230e-01f,
  -7.28838071e-02f, 4.07679044e-02f, 1.40781943e-02f, -1.16267651e-02f, 2.30978429e-02f, -1.24212345e-02f, 1.77499233e-03f, -7.08419234e-02f, -7.14517161e-02f, -5.36850933e-03f,
  -3.92167903e-02f, -4.09212336e-02f, -2.26866677e-02f, -6.69426396e-02f, 1.83812063e-03f, -1.96953514e-03f, -1.04628969e-02f, -2.56538261e-02f, -2.01805886e-02f, -2.04088911e-02f,
  4.31379005e-02f, -5.36849275e-02f, 3.00668888e-02f, 3.57952081e-02f, -5.71069755e-02f, 9.98601783e-03f, 1.90466121e-02f, -1.60170812e-02f, 9.88900289e-03f, -3.97412218e-02f,
  -3.70173365e-01f, -2.75909662e-01f, 2.75862589e-02f, -4.93208617e-02f, -1.01041399e-01f, -1.08511578e-02f, 7.80412182e-02f, -4.68181185e-02f, -8.05181041e-02f, -1.08315907e-02f,
  -4.33823317e-02f, -8.48980434e-03f, -1.24072105e-01f, -4.85935472e-02f, 4.76627871e-02f, -2.85530388e-02f, 1.22235471e-03f, 8.18550494e-03f, -1.25963345e-01f, 2.45838203e-02f,
  -6.10679723e-02f, 1.39841899e-01f, 3.69568961e-03f, -5.39683849e-02f, -7.12306648e-02f, -1.07284993e-01f, -6.35288190e-03f, 2.60898322e-02f, -1.26649201e-01f, 4.09588367e-02f,
  -3.00732493e-01f, 1.09566242e-01f, -1.21811025e-01f, 4.82517816e-02f, -3.79259765e-01f, 2.28139743e-01f, 4.25911725e-01f, -2.52766699e-01f, 1.18383251e-01f, 2.87418902e-01f,
  1.24075018e-01f, -6.99069202e-02f, 2.44972169e-01f, 2.91434586e-01f, -1.00140095e-01f, 3.47679794e-01f, 2.94664741e-01f, 2.45376974e-01f, -1.54511809e-01f, -1.57247990e-01f,
  -1.82469159e-01f, 1.62888058e-02f, 1.15744792e-01f, -1.77678406e-01f, -1.28253073e-01f, -1.51988894e-01f, -6.67068288e-02f, -3.06567121e-02f, 2.84287017e-02f, 5.04597574e-02f,
  -5.08149825e-02f, -1.11288875e-01f, -6.13737218e-02f, 2.91779023e-02f, 7.11635128e-02f, -8.06261525e-02f, 4.14692797e-02f, -9.96254664e-03f, 1.62234437e-02f, -4.51802425e-02f,
  3.07996455e-03f, -1.46171778e-01f, 2.16684188e-03f, -1.86882801e-02f, -1.27705753e-01f, 3.32330586e-03f, -1.12466216e-01f, 2.20182873e-02f, -9.11109075e-02f, -8.26122463e-02f,
  -3.54217477e-02f, -4.13152575e-03f, 8.01946968e-02f, 4.77524064e-02f, -7.57423490e-02f, 1.31929608e-03f, 8.05394128e-02f, -1.64441727e-02f, -5.88976359e-03f, -1.00741275e-01f,
  1.44029573e-01f, 7.18441308e-02f, 4.60175909e-02f, -5.72241619e-02f, 4.48705107e-02f, 4.12985943e-02f, 5.11776842e-03f, -3.06789973e-03f, 1.40376408e-02f, -2.01555640e-02f,
  -7.07498342e-02f, -8.82732794e-02f, -5.99500127e-02f, 9.67025384e-02f, 1.31526794e-02f, 3.20841670e-02f, 1.06638372e-01f, -7.58243799e-02f, -2.42265780e-02f, -6.17352501e-02f,
  4.01072949e-02f, -1.05901724e-02f, 4.78352271e-02f, 4.33691069e-02f, 4.07729037e-02f, 5.91657404e-03f, -7.29669780e-02f, 4.46545053e-03f, 9.12144408e-02f, -3.48797068e-02f,
  -2.42952779e-02f, -7.22101256e-02f, 7.14197829e-02f, -3.54498141e-02f, 1.50241936e-02f, 2.98251901e-02f, 6.78625628e-02f, -9.94356945e-02f, 6.39465172e-03f, -9.05063935e-03f,
  1.03415549e-02f, 9.79975611e-02f, -6.37499243e-02f, 6.82734177e-02f, 7.01094270e-02f, 3.93425301e-02f, 1.31077617e-01f, -5.87445349e-02f, 7.25122243e-02f, -2.09153611e-02f,
  1.62871573e-02f, 3.18007432e-02f, 1.73608717e-02f, 1.43216494e-02f, 2.08244976e-02f, -2.90448163e-02f, -8.60175118e-02f, -9.77367461e-02f, -1.03745557e-01f, 4.50781621e-02f,
  -3.17979664e-01f, -1.08021468e-01f, -9.55600515e-02f, -8.77866596e-02f, 1.73622146e-01f, -2.57803172e-01f, 6.22745836e-03f, 1.28008306e-01f, 2.08222345e-01f, 1.52445123e-01f,
  8.98506269e-02f, -3.30150634e-01f, 2.21852735e-01f, -3.18541855e-01f, -4.50255603e-01f, -1.47741094e-01f, -4.64503407e-01f, -2.71166682e-01f, -4.93871495e-02f, -7.51319155e-02f,
  -2.81129796e-02f, 5.03837538e-04f, -2.36383706e-01f, 2.56685793e-01f, 1.29475862e-01f, 1.73995823e-01f, 4.16096486e-02f, 2.40917280e-01f, -1.97892055e-01f, -1.58194732e-02f,
  -8.50533471e-02f, 1.12304725e-01f, 6.24005720e-02f, 9.98912603e-02f, -7.90806785e-02f, -1.97453965e-02f, -4.15433496e-02f, -5.05296933e-03f, -4.69977548e-03f, 4.79483642e-02f,
  -4.39108871e-02f, 1.18509971e-01f, -9.33554918e-02f, 2.06331536e-01f, 1.44579872e-01f, 4.01612185e-02f, -1.31537944e-01f, -1.77065715e-01f, 4.62758020e-02f, -1.03106350e-02f,
  -1.00514062e-01f, 1.26328850e-02f, -5.50895445e-02f, -2.03139205e-02f, -1.43566310e-01f, 1.30449934e-02f, -1.16271943e-01f, -1.65095910e-01f, -6.94218948e-02f, -4.86241616e-02f,
  -3.30102406e-02f, -5.73127009e-02f, -4.44825776e-02f, 1.45909145e-01f, -3.40601765e-02f, 4.30407487e-02f, 2.31929272e-02f, 3.11533324e-02f, -3.05676237e-02f, 2.48930641e-02f,
  1.92896072e-02f, -1.46275144e-02f, 1.49079829e-01f, -1.39639517e-02f, -7.78696239e-02f, 4.01171558e-02f, -1.10181846e-01f, 1.28503665e-01f, -1.38259843e-01f, -1.15476679e-02f,
  1.16762727e-01f, -6.08560890e-02f, 4.99873161e-02f, -6.52754214e-03f, -5.12049161e-02f, 6.16551079e-02f, 4.49649766e-02f, -8.87198895e-02f, 4.03293222e-02f, -2.17924137e-02f,
  -1.51585162e-01f, -1.23050958e-02f, 2.68762130e-02f, 1.10721953e-01f, -5.26139475e-02f, -3.54818255e-02f, -1.27138853e-01f, 1.98717713e-02f, -7.45355114e-02f, 1.04400173e-01f,
  7.26623014e-02f, 2.63440236e-03f, -1.30752891e-01f, -2.31404323e-02f, -1.45775592e-02f, -3.78415659e-02f, 4.67308089e-02f, -5.41887768e-02f, -9.18576121e-02f, -5.44261076e-02f,
  -5.85353225e-02f, 9.92375761e-02f, -6.93938732e-02f, 8.54714215e-02f, 6.54551620e-03f, 6.57183826e-02f, 5.27704507e-02f, 3.35727702e-03f, -4.01963405e-02f, -6.02596253e-02f,
  -6.26452938e-02f, 2.09277526e-01f, -1.60969079e-01f, -1.72050953e-01f, 2.09780112e-01f, 3.25701147e-01f, 2.35117182e-01f, 1.14814781e-01f, 1.93861112e-01f, 1.74118564e-01f,
  3.70530754e-01f, -1.00746639e-01f, 6.42969459e-02f, 2.06257343e-01f, 1.42219543e-01f, 2.06918746e-01f, 2.87109405e-01f, -6.24865033e-02f, -1.07237078e-01f, 4.13320288e-02f,
  4.87231240e-02f, 1.37173191e-01f, 3.12354714e-02f, -8.14341307e-02f, 6.23802878e-02f, -1.47040546e-01f, -7.14856163e-02f, -3.12562734e-01f, -2.82092858e-02f, 2.72507221e-02f,
  9.04238001e-02f, -6.94305599e-02f, -1.37322918e-01f, -2.20272273e-01f, -6.49792477e-02f, -1.22506753e-01f, -2.36200050e-01f, -5.57802208e-02f, 2.27570105e-02f, 3.61816175e-02f,
  -3.04460898e-02f, -4.27759532e-03f, 3.85757312e-02f, -9.31636319e-02f, 4.91298456e-03f, 7.24315569e-02f, 8.03006813e-02f, 1.15757719e-01f, 4.22389880e-02f, 1.30956933e-01f,
  9.85338390e-02f, 2.94417888e-02f, 4.28147130e-02f, 5.74057736e-02f, 9.23599228e-02f, 1.53303251e-01f, -2.58110408e-02f, -1.05323009e-01f, 5.55925630e-02f, 1.00184483e-02f,
  -2.77895443e-02f, -6.77975342e-02f, 4.31576334e-02f, 2.50289571e-02f, 9.22657270e-03f, 1.63627133e-01f, 4.59028706e-02f, 1.21564753e-01f, 2.10098922e-02f, 1.70598216e-02f,
  4.33469517e-03f, 9.50309858e-02f, -1.85172055e-02f, 1.07627129e-02f, 1.06605254e-02f, -4.73119728e-02f, -7.04870597e-02f, 5.60960583e-02f, 1.46564038e-03f, 1.32761568e-01f,
  6.39213016e-03f, -2.93941852e-02f, -3.86535600e-02f, -1.09402062e-02f, -1.62186846e-02f, -1.01361675e-02f, 3.54888551e-02f, 1.22665361e-01f, 4.60861847e-02f, -4.98854881e-03f,
  1.18194655e-01f, -1.33995533e-01f, 3.59235369e-02f, -6.19370341e-02f, -1.27043143e-01f, -4.47913911e-03f, -1.60374537e-01f, 1.15723424e-01f, -8.48426372e-02f, 9.84370261e-02f,
  -1.28846718e-02f, -1.41561642e-01f, -1.07599841e-02f, -4.77250740e-02f, -3.64626199e-03f, 7.51598552e-02f, 8.64032134e-02f, -1.32807702e-01f, 8.83122757e-02f, 2.44299322e-02f,
  -1.01319030e-01f, -7.19061717e-02f, 1.23629719e-02f, 4.43385318e-02f, -1.31121073e-02f, 1.58846468e-01f, -1.28830343e-01f, -4.86682057e-02f, 6.78111091e-02f, 1.53853586e-02f,
  3.33982825e-01f, -2.03909218e-01f, -1.28959700e-01f, -7.15168491e-02f, 1.54669955e-01f, 2.90869802e-01f, 1.87123746e-01f, -9.05194208e-02f, -1.73246697e-01f, -8.42866078e-02f,
  2.61880398e-01f, -9.95210558e-02f, 3.82010080e-02f, 1.46433786e-01f, 2.47680768e-01f, -1.77744076e-01f, 1.94764003e-01f, 5.02159186e-02f, -6.70743510e-02f, 1.90779477e-01f,
  6.35847524e-02f, 2.17941061e-01f, -6.41000792e-02f, -1.43202692e-01f, 3.15120608e-01f, -1.76751971e-01f, -2.08038017e-02f, -1.21341653e-01f, -9.20148045e-02f, 3.68438335e-03f,
  1.69727981e-01f, -3.59878652e-02f, 7.87903294e-02f, 6.98384345e-02f, 1.68819167e-02f, 8.50313827e-02f, -9.82141588e-03f, -4.93130600e-03f, 1.24756340e-02f, -8.77349824e-02f,
  -5.07663339e-02f, -4.48452085e-02f, -7.32502863e-02f, -1.84822525e-03f, 1.94653738e-02f, 5.16458089e-03f, -8.74864608e-02f, 3.49680521e-02f, -2.51991361e-01f, 2.88873110e-02f,
  -3.94912511e-02f, -6.47132918e-02f, 1.21144734e-01f, -6.21924661e-02f, -3.07347886e-02f, -5.62191941e-02f, -3.31921019e-02f, -3.66765484e-02f, 2.64665820e-02f, 6.22427650e-02f,
  9.42690764e-03f, -2.28618495e-02f, 7.92725310e-02f, 4.18426935e-03f, -9.87740140e-03f, 7.63651505e-02f, 1.32012824e-02f, -1.26527354e-01f, -4.47795466e-02f, 5.85558638e-02f,
  -5.21269743e-04f, 5.32322284e-03f, 1.84262525e-02f, 5.91065995e-02f, 6.41743243e-02f, 1.22471012e-01f, -4.71423566e-02f, 2.30995845e-02f, -7.82565773e-02f, -1.22895017e-01f,
  -5.84821180e-02f, 6.44588247e-02f, 1.28709197e-01f, -8.71567875e-02f, -3.91006693e-02f, -7.78861493e-02f, -2.61392351e-02f, -8.07958767e-02f, 9.32942778e-02f, 6.50985613e-02f,
  -4.23330702e-02f, -1.21413007e-01f, -9.62919891e-02f, 2.36278959e-02f, -1.43275693e-01f, 1.74776480e-01f, -4.58901636e-02f, -1.01588078e-01f, 5.42370863e-02f, -1.03865648e-02f,
  -9.83875990e-03f, -5.61030768e-02f, -5.80960624e-02f, 2.07468141e-02f, -3.37247290e-02f, 3.17523219e-02f, -7.00313523e-02f, -6.58395588e-02f, -7.30337352e-02f, -3.55146192e-02f,
  4.54373769e-02f, -1.83509830e-02f, 4.69918363e-02f, -3.80239412e-02f, -1.52891591e-01f, -1.51112527e-01f, 7.87317529e-02f, -5.89225702e-02f, -4.49526962e-03f, -6.53474182e-02f,
  -3.34868342e-01f, 5.84970079e-02f, 3.69001418e-01f, -3.28564674e-01f, -9.99680459e-02f, 3.78691256e-01f, 3.07375222e-01f, -1.71742484e-01f, -2.24690780e-01f, -3.73920910e-02f,
  -6.09116144e-02f, -6.33164123e-02f, 2.97268212e-01f, -1.03065804e-01f, 4.87571388e-01f, 2.85994649e-01f, -3.93864326e-02f, -5.04718311e-02f, -1.71673670e-01f, -1.08565897e-01f,
  -9.47054848e-02f, -3.07451874e-01f, 1.46175906e-01f, -2.45218530e-01f, -7.57282898e-02f, -2.06973001e-01f, -9.61628556e-02f, 4.82141897e-02f, -7.26546124e-02f, 4.06455845e-02f,
  -1.50620686e-02f, -2.23888338e-01f, 3.34381983e-02f, -5.06973360e-03f, 4.05358896e-02f, -5.20544387e-02f, -2.63073090e-02f, 2.01308832e-01f, -8.94204080e-02f, -3.12030278e-02f,
  8.24992545e-03f, 6.47636428e-02f, -9.38459188e-02f, 1.01629896e-02f, -1.08211361e-01f, -5.96392788e-02f, -2.19145883e-02f, -8.90779644e-02f, 1.00337334e-01f, 1.25599653e-01f,
  1.17253717e-02f, 1.35821402e-02f, 2.89201550e-02f, 2.40998492e-02f, 3.99741344e-02f, 1.30645102e-02f, 7.05849826e-02f, 1.06554158e-01f, -1.29050657e-01f, -1.07880287e-01f,
  -9.66316983e-02f, 3.02817114e-02f, -4.89486456e-02f, 2.34097708e-02f, -4.69750576e-02f, -1.77871138e-02f, 5.58551513e-02f, -6.32670298e-02f, 4.26293388e-02f, 4.70301099e-02f,
  -7.41299940e-03f, -3.31595466e-02f, -7.02268258e-02f, -1.91527288e-02f, -4.67285924e-02f, 5.80977229e-03f, -1.00115445e-02f, -3.73288542e-02f, -4.21790555e-02f, -1.42146898e-02f,
  -5.18860742e-02f, 4.62288707e-02f, -9.27790925e-02f, -6.50942102e-02f, 1.27912775e-01f, 5.71829751e-02f, -1.54763773e-01f, -1.96579657e-02f, 9.94707178e-03f, 2.72521675e-02f,
  1.11762360e-02f, -2.61672348e-01f, -9.67040285e-02f, -1.09521793e-02f, -3.47512029e-02f, 9.26048309e-03f, -1.27811089e-01f, 3.15245353e-02f, -8.50451440e-02f, -5.22450954e-02f,
  -1.10898398e-01f, -4.95553724e-02f, -9.45796967e-02f, 2.93726083e-02f, 1.96955055e-02f, -1.16402367e-02f, 5.94868883e-03f, -2.72277202e-02f, 2.24480815e-02f, -2.25892942e-02f,
  4.87422422e-02f, -1.35082215e-01f, 7.41491094e-02f, -5.19172028e-02f, -1.87878516e-02f, 1.38537005e-01f, -2.21250430e-02f, 6.38842359e-02f, 2.12417147e-03f, -4.84808534e-02f,
  2.24644821e-02f, -1.17564887e-01f, -2.37053081e-01f, -1.48361668e-01f, 2.90439166e-02f, 6.59309626e-02f, -2.62292832e-01f, 5.98268658e-02f, -2.28044093e-01f, -9.13028885e-03f,
  8.98024067e-02f, -1.64134249e-01f, -1.01200923e-01f, 1.58235416e-01f, 1.00381516e-01f, -1.01451725e-01f, 1.77753136e-01f, 9.38621312e-02f, 1.96471941e-02f, 2.32756853e-01f,
  1.72744304e-01f, 3.47403169e-01f, 2.80963093e-01f, 3.57311755e-01f, 1.67157248e-01f, 1.73624948e-01f, 9.59862769e-02f, 3.94389853e-02f, 2.69004613e-01f, 1.11210808e-01f,
  5.85430451e-02f, 5.51167317e-02f, 4.65133563e-02f, -5.14930263e-02f, 9.36883986e-02f, 9.92919281e-02f, 3.62137109e-02f, 1.46371387e-02f, -1.11453868e-01f, 5.66670336e-02f,
  -3.94847207e-02f, -2.67327559e-04f, 9.30534303e-02f, -2.74210628e-02f, -1.36619695e-02f, -6.32086247e-02f, -6.80639073e-02f, -2.19819676e-02f, -1.82693645e-01f, -1.40682783e-03f,
  -1.31710693e-01f, -3.61867696e-02f, -2.49901563e-02f, -2.34525595e-02f, -1.04845613e-01f, -8.11092183e-03f, -5.91970831e-02f, -5.47771305e-02f, -1.63685493e-02f, 3.97795029e-02f,
  1.41445259e-02f, 1.66862998e-02f, 1.29579399e-02f, -1.57794524e-02f, 9.11296159e-03f, -1.61032863e-02f, -7.32849687e-02f, -4.34489623e-02f, -1.02800220e-01f, -2.98604160e-03f,
  -7.15856850e-02f, -5.05477637e-02f, -3.33958305e-02f, 3.24082491e-03f, 1.48775637e-01f, -8.38500559e-02f, 2.13152599e-02f, 8.63182247e-02f, -5.83683364e-02f, 8.89940839e-03f,
  -7.66733363e-02f, 6.60939440e-02f, -1.22919632e-02f, -5.02991043e-02f, -5.27666067e-04f, 6.27270639e-02f, 7.46190473e-02f, 3.75162438e-02f, 5.60503006e-02f, -1.00468062e-02f,
  4.37920876e-02f, 1.66327566e-01f, 6.81345761e-02f, -8.09463561e-02f, 1.36358636e-02f, 9.07096714e-02f, 6.40746951e-02f, -2.27408763e-03f, 9.81670320e-02f, 5.41063584e-03f,
  5.91784492e-02f, -3.03065218e-02f, -1.12070125e-02f, 1.18614092e-01f, -3.80781367e-02f, 1.06622539e-01f, -1.14102652e-02f, 3.86255942e-02f, 7.80916288e-02f, 1.01865821e-01f,
  7.12346062e-02f, -5.47728762e-02f, -3.11436653e-02f, -8.00951123e-02f, 4.14953083e-02f, -8.64237770e-02f, 9.28869992e-02f, -7.77948275e-02f, -7.36942366e-02f, -5.27071320e-02f,
  3.24432179e-02f, -7.54648149e-02f, 2.78539449e-01f, 2.41642877e-01f, -1.21562675e-01f, -2.16372207e-01f, -1.28391713e-01f, -1.27579989e-02f, -6.08625636e-02f, -1.43309847e-01f,
  -1.11646853e-01f, 6.87837079e-02f, -2.42854320e-02f, 2.06710905e-01f, 2.70579755e-01f, 8.75190645e-02f, 5.24050519e-02f, 1.43264299e-02f, -1.23232277e-02f, 9.20143351e-02f,
  1.62431877e-02f, 1.39958099e-01f, 1.85939655e-01f, 1.05731845e-01f, 1.36947647e-01f, 1.36202812e-01f, 2.40493611e-01f, 2.05247328e-01f, 2.24908918e-01f, 1.13621242e-01f,
  -5.74698253e-03f, 5.19215167e-02f, -4.99563739e-02f, 2.59460360e-02f, -7.33567122e-03f, -6.85489625e-02f, -6.19487800e-02f, 6.07216135e-02f, 5.71089610e-02f, -2.07363665e-02f,
  -1.55393193e-02f, 4.82598096e-02f, 8.40766542e-03f, 6.80385623e-03f, -3.58104743e-02f, 5.98060340e-02f, 8.30626022e-03f, -1.10116348e-01f, -3.27165499e-02f, -7.20379800e-02f,
  -7.70949498e-02f, -5.42094149e-02f, 6.45143986e-02f, 5.78374136e-04f, 8.87118354e-02f, -2.33395980e-03f, -3.37588154e-02f, -2.09490769e-02f, -4.03489247e-02f, 6.76565245e-02f,
  5.47466800e-03f, -2.44700387e-02f, -4.34537753e-02f, -7.82566816e-02f, -5.05899936e-02f, 1.16413990e-02f, -1.04353316e-01f, -3.55875380e-02f, 6.93108290e-02f, -3.33912708e-02f,
  5.22068292e-02f, 9.13134068e-02f, -8.40831548e-03f, -3.18882130e-02f, 3.91940847e-02f, -7.74047710e-03f, 2.26287581e-02f, 3.78377587e-02f, -9.14329663e-02f, 1.02985390e-01f,
  -3.45712118e-02f, 1.25871599e-02f, 9.92749631e-02f, -2.85676885e-02f, -9.55609903e-02f, 9.63073298e-02f, -7.61542991e-02f, -1.37803042e-02f, 3.68991159e-02f, -5.94477765e-02f,
  4.44407463e-02f, 2.94860423e-01f, -7.54731195e-03f, -6.41432181e-02f, 3.61978523e-02f, -5.63442223e-02f, 6.39389176e-03f, 1.39049172e-01f, 1.94381207e-01f, 1.56912189e-02f,
  5.24330027e-02f, 9.63808522e-02f, -2.40691602e-02f, -1.39707350e-03f, 1.38236731e-01f, 6.25602081e-02f, 6.63740709e-02f, -9.13369805e-02f, 4.80872206e-02f, 1.52943414e-02f,
  5.80011159e-02f, -3.20180207e-02f, 8.23301524e-02f, -7.42110536e-02f, 5.90373948e-02f, 1.18572652e-01f, -2.04516128e-02f, 3.14596272e-03f, 4.47779484e-02f, -2.61236466e-02f,
  1.05993547e-01f, -1.84511319e-01f, -2.73454577e-01f, -1.68235585e-01f, -4.64639254e-02f, -7.13331997e-02f, -3.59586567e-01f, -1.30348772e-01f, -2.31660247e-01f, -1.78720698e-01f,
  -1.25212684e-01f, 6.22090846e-02f, -2.75122851e-01f, -5.06215245e-02f, 9.17048156e-02f, -1.03912294e-01f, 9.14371237e-02f, 6.49382398e-02f, 1.24143124e-01f, 3.32931839e-02f,
  4.97719981e-02f, 2.44029656e-01f, -6.74433187e-02f, 4.18876633e-02f, 1.19821593e-01f, -8.10909644e-03f, 2.40339965e-01f, -1.14573114e-01f, 6.94725811e-02f, 1.84551090e-01f,
  5.99687733e-02f, 4.63020019e-02f, -8.68701488e-02f, 3.21601480e-02f, -7.51125813e-02f, -1.81303453e-02f, 9.99010205e-02f, -7.75875002e-02f, 3.05184498e-02f, -3.51039432e-02f,
  8.66024867e-02f, 1.30115092e-01f, 2.19921526e-02f, 1.37802586e-01f, -5.82183199e-03f, 6.48592710e-02f, -7.27390647e-02f, 9.02910531e-02f, -8.86481702e-02f, -3.45588773e-02f,
  -5.45992926e-02f, -2.17764992e-02f, -3.72837149e-02f, -4.98690605e-02f, -6.96632788e-02f, 5.41922040e-02f, 5.57211414e-02f, -5.54052927e-02f, 1.17044924e-02f, 2.14314833e-02f,
  -5.78846075e-02f, 1.60224095e-01f, -1.10548526e-01f, -3.86896729e-02f, -5.29000498e-02f, -1.35135487e-01f, -2.59110034e-02f, -7.93646723e-02f, 3.02389618e-02f, 8.96249339e-03f,
  -4.99952771e-02f, -1.17174223e-01f, -3.30040455e-02f, 6.74894173e-03f, 1.43510774e-01f, 1.97004542e-01f, 5.74015975e-02f, 5.58242835e-02f, -4.04923894e-02f, -1.57614723e-01f,
  -6.93089291e-02f, 7.54491091e-02f, -8.21914747e-02f, -6.74761459e-02f, 1.00167766e-02f, 7.58829936e-02f, 2.62401463e-03f, -3.06421090e-02f, -7.21110404e-02f, -4.14112955e-02f,
  -4.66588847e-02f, -6.14135414e-02f, -1.56584099e-01f, 2.55043432e-02f, -6.61438555e-02f, -4.55840603e-02f, -5.66874351e-03f, -9.52476785e-02f, -1.06353424e-01f, 3.92099321e-02f,
  8.32699763e-04f, -1.29046533e-02f, -1.12441815e-01f, -3.44926603e-02f, -6.81165233e-02f, 7.33585504e-04f, 5.93913198e-02f, 7.16916174e-02f, -2.07850058e-02f, 1.53562669e-02f,
  -5.88224381e-02f, -2.74987482e-02f, 1.12989157e-01f, 2.33375374e-02f, 8.88422132e-02f, 9.62434933e-02f, 3.67368273e-02f, 6.61458895e-02f, 6.75399303e-02f, -5.47305793e-02f,
  -5.45184672e-01f, 2.22389191e-01f, -2.32686952e-01f, -1.20175883e-01f, -1.13913164e-01f, -2.87094504e-01f, -1.72394186e-01f, 1.03874151e-02f, 1.12935044e-02f, 3.07520837e-01f,
  1.91521361e-01f, 4.33564894e-02f, 3.03633869e-01f, 2.53276110e-01f, -2.31492177e-01f, 2.66229302e-01f, -1.86969489e-01f, -2.89990753e-02f, 3.29146571e-02f, -2.30734155e-01f,
  -4.26089484e-03f, 1.35466233e-01f, 8.53082091e-02f, 1.51744843e-01f, -1.91488311e-01f, -8.91402364e-02f, 9.14241187e-03f, 7.49894083e-02f, -1.60280187e-02f, 1.01325139e-02f,
  -3.06675225e-01f, 5.42307720e-02f, -1.55840337e-01f, -6.11676052e-02f, -1.89663664e-01f, -1.05130523e-01f, -1.67895645e-01f, -3.81000414e-02f, -6.13567308e-02f, -1.01866089e-01f,
  -2.23277435e-02f, 6.73375055e-02f, 2.89890151e-02f, 1.07568093e-01f, -8.99553522e-02f, -9.98035744e-02f, -7.55694807e-02f, -2.32797824e-02f, 1.97424088e-02f, -1.18166516e-02f,
  8.06920230e-02f, 2.95183286e-02f, -5.85340383e-03f, 9.58515257e-02f, -3.66778784e-02f, 4.33424339e-02f, -2.87135746e-02f, -4.38991206e-04f, -8.75946954e-02f, -7.59364143e-02f,
  -2.69853342e-02f, -6.39063418e-02f, -4.41782363e-02f, 7.70569369e-02f, 5.39898127e-02f, 6.02794737e-02f, 1.13556278e-03f, 9.91124287e-02f, -1.21536367e-02f, -1.46442314e-03f,
  4.17025946e-02f, 3.62183675e-02f, 5.64237796e-02f, -5.97957261e-02f, 1.92786392e-03f, -3.22716776e-03f, 1.94224110e-03f, -3.04290634e-02f, -4.04904271e-03f, -4.82364334e-02f,
  -1.10766385e-02f, 2.83742510e-02f, 9.28925946e-02f, 4.43385616e-02f, -1.81193161e-03f, 7.56520825e-03f, 7.31781423e-02f, -9.05329827e-03f, -1.06259041e-01f, 3.81097291e-03f,
  -3.92504662e-01f, -1.82158321e-01f, -9.50811282e-02f, 6.73805103e-02f, -8.12336579e-02f, -9.58515629e-02f, -5.46490662e-02f, -6.92353919e-02f, -1.52646437e-01f, -9.80404392e-02f,
  -1.05488777e-01f, 1.06371166e-02f, -7.09943250e-02f, 6.21360652e-02f, 5.75854890e-02f, 5.29272184e-02f, -7.07909763e-02f, 1.44343590e-02f, -1.09557301e-01f, -8.21475163e-02f,
  -3.55027802e-02f, -3.12094204e-02f, -3.12153362e-02f, 5.43824211e-02f, -2.81487070e-02f, -7.27296155e-03f, -6.23681024e-02f, 9.94158089e-02f, -1.10371016e-01f, 3.70795541e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  3.02145392e-01f, 2.13877246e-01f, 2.39952520e-01f, 3.06437075e-01f, 2.21714079e-01f, 1.75748304e-01f, 2.36311942e-01f, 1.59858286e-01f, 1.21389486e-01f, 2.84387738e-01f,
  1.24491043e-01f, 3.93769443e-01f, 1.28665194e-01f, 3.23796630e-01f, 1.37269691e-01f, 6.20528385e-02f, 1.45287544e-01f, 1.50414720e-01f, 2.14618430e-01f, 2.74808705e-01f,
  2.36662894e-01f, 1.66706905e-01f, 1.38752609e-01f, 8.21130946e-02f, 3.15824509e-01f, 4.15586352e-01f, 3.71466190e-01f, 2.95772523e-01f, 3.78038466e-01f, 3.57122689e-01f,
  1.06432080e-01f, 1.19251139e-01f, 3.80159020e-01f, 2.61171013e-01f, 2.17310265e-01f, 2.58550137e-01f, 2.93521881e-01f, 5.32340929e-02f, 1.14749454e-01f, 1.87311471e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  9.46020484e-02f, 4.43973159e-03f, 5.19272201e-02f, 1.10065892e-01f, -5.95849752e-02f, -1.30604088e-01f, 1.73663065e-01f, -8.98595974e-02f, 1.40026445e-02f, 5.15082143e-02f,
  -1.79725867e-02f, 9.71960574e-02f, -8.21457207e-02f, 1.81065518e-02f, 3.98343727e-02f, -2.25395471e-01f, -3.76801491e-02f, 2.78394558e-02f, -1.35595113e-01f, 2.63490647e-01f,
  2.18141198e-01f, -5.28195649e-02f, 1.70271635e-01f, 1.39567584e-01f, -1.91881984e-01f, 1.13129511e-01f, 1.94383293e-01f, -8.60505402e-02f, 1.04607925e-01f, 3.00011843e-01f,
  -8.88429135e-02f, 1.96211293e-01f, -2.12140188e-01f, -1.20965332e-01f, 6.33951873e-02f, -8.55221376e-02f, -6.27540126e-02f, -1.68827042e-01f, 5.61392345e-02f, 1.13448948e-02f,
  -2.09658816e-01f, 2.39313126e-01f, -5.62112182e-02f, -1.71574876e-01f, -1.34567216e-01f, 9.05159935e-02f, -1.71867106e-02f, -2.75160335e-02f, 5.08211087e-04f, 7.67050609e-02f,
  -2.62785275e-02f, -2.29988247e-01f, 1.60423771e-01f, 3.25464606e-02f, 2.49244407e-01f, -1.04120888e-01f, -1.81998685e-02f, -1.29670843e-01f, -2.35700488e-01f, 1.60498638e-02f,
  5.24186864e-02f, 2.79642463e-01f, -2.37896759e-03f, 1.88650563e-01f, 5.21139391e-02f, -2.46850383e-02f, -4.86276336e-02f, 2.75583618e-04f, -1.50996223e-01f, 1.55946955e-01f,
  -5.53592704e-02f, -2.41542850e-02f, -1.43909112e-01f, 5.17234839e-02f, -8.31902772e-02f, 5.70749491e-03f, 8.17876831e-02f, 2.66145647e-01f, -2.78112203e-01f, 4.05404009e-02f,
  2.58452564e-01f, -1.48066757e-02f, 1.35748878e-01f, -2.13952541e-01f, 1.56172454e-01f, -1.39844298e-01f, -2.49662682e-01f, 1.40073046e-01f, -1.70047149e-01f, 1.20796271e-01f,
  8.47493038e-02f, -1.09107010e-01f, 6.62779212e-02f, 5.78360409e-02f, 5.34551255e-02f, -1.09172249e-02f, 1.79820076e-01f, 2.19920233e-01f, 7.22370967e-02f, -3.00676525e-02f,
  6.42044656e-03f, 2.40021616e-01f, 6.27988353e-02f, 6.83567747e-02f, 1.55907556e-01f, 1.85767457e-01f, 6.03267848e-02f, 2.63964474e-01f, -2.04116389e-01f, 1.91016346e-01f,
  2.54471183e-01f, -1.63964882e-01f, -1.95059374e-01f, -7.59399384e-02f, -2.08174780e-01f, -1.72998622e-01f, -7.84415752e-02f, -1.13312528e-01f, -6.89007789e-02f, -2.16668606e-01f,
  -8.59313309e-02f, -4.88700718e-02f, -1.16985582e-01f, 2.14585096e-01f, -4.05235477e-02f, 1.03353091e-01f, 2.05810349e-02f, -6.55106921e-03f, 1.57259539e-01f, 1.76999509e-01f,
  -8.92641842e-02f, 1.10581212e-01f, -6.56729788e-02f, 1.46141618e-01f, 1.43797442e-01f, 1.04760163e-01f, 4.38523479e-02f, -6.39103949e-02f, 3.96176893e-03f, -1.20710894e-01f,
  7.67446235e-02f, 2.75525153e-01f, -2.28338331e-01f, 9.16049927e-02f, -1.88476279e-01f, 1.67090803e-01f, -1.96705665e-02f, 1.35964274e-01f, 1.17344648e-01f, -5.09807132e-02f,
  -1.03952087e-01f, -5.09669557e-02f, -2.02122241e-01f, 3.08361888e-01f, 1.30645692e-01f, 1.26483113e-01f, -1.35299265e-01f, 8.62676371e-03f, 9.58607881e-04f, 1.05315641e-01f,
  -9.68783498e-02f, 1.66064501e-01f, -2.30839755e-02f, -1.14259720e-01f, -1.65931717e-01f, -1.16891868e-01f, 1.71323791e-01f, -1.93279773e-01f, -1.15429461e-01f, -4.22704220e-02f,
  1.52949482e-01f, 3.40610333e-02f, -9.06462744e-02f, 1.01164758e-01f, 8.86410847e-02f, 2.08242863e-01f, -2.08297029e-01f, 3.55540849e-02f, 1.16054103e-01f, 5.40211750e-03f,
  4.93818074e-02f, 3.77832390e-02f, 2.22705051e-01f, 1.72745019e-01f, 1.13729928e-02f, -3.51346210e-02f, -5.01243658e-02f, 1.21185437e-01f, 3.15800086e-02f, -3.69123034e-02f,
  -1.79372281e-01f, 1.59068897e-01f, 3.08577344e-02f, 6.23035170e-02f, -1.49696454e-01f, 2.08151922e-01f, 1.40551224e-01f, 1.47528857e-01f, 1.66809991e-01f, 1.37205413e-02f,
  9.41792876e-02f, 6.51633516e-02f, 7.13497996e-02f, -1.08180538e-01f, 2.29142547e-01f, 2.74599373e-01f, -1.95749238e-01f, -1.98473819e-02f, -1.08797476e-01f, 1.39178514e-01f,
  -4.86130528e-02f, 1.48401290e-01f, -1.75339859e-02f, 1.34665566e-02f, -4.82126065e-02f, 3.21470574e-02f, -2.10962296e-01f, 6.63859248e-02f, 1.97599038e-01f, 1.05344243e-01f,
  3.12158521e-02f, 2.37678409e-01f, 6.09580688e-02f, 3.62468138e-02f, -1.29741713e-01f, 8.11881274e-02f, 1.65830582e-01f, -1.28620580e-01f, -2.33192760e-02f, -4.46887054e-02f,
  2.35127628e-01f, 5.28137274e-02f, -1.32129103e-01f, 5.39357811e-02f, 7.38779008e-02f, 2.10110083e-01f, -1.00917779e-01f, 5.52111454e-02f, 6.56084865e-02f, 5.02352137e-03f,
  -6.26135916e-02f, 6.21094443e-02f, -6.60783574e-02f, -2.84904838e-01f, 2.67998427e-01f, 1.53159499e-02f, 1.00465976e-01f, 1.01359539e-01f, -1.62120223e-01f, 1.75449383e-02f,
  -1.58976868e-01f, 2.82064736e-01f, -1.09576970e-01f, 1.45559330e-02f, -1.15700159e-02f, 1.48694500e-01f, -1.99231207e-02f, -1.51427284e-01f, -1.59167156e-01f, -1.15018904e-01f,
  1.21073745e-01f, -4.01589312e-02f, -8.27746168e-02f, -7.39828646e-02f, -9.00735632e-02f, -4.91025262e-02f, -1.27753899e-01f, 8.71157390e-04f, 1.63548235e-02f, -1.97868839e-01f,
  -2.81527698e-01f, -2.52362620e-02f, -5.48719056e-02f, 1.96632966e-01f, -1.17046982e-01f, -2.89015239e-03f, -1.75627396e-01f, 1.74658671e-01f, -2.81667002e-02f, 1.09095685e-01f,
  1.90947354e-01f, 1.62990212e-01f, -1.56918149e-02f, -1.67607125e-02f, -2.23938767e-02f, -1.56630259e-02f, 1.42400399e-01f, 1.62299037e-01f, -2.02056244e-02f, -2.45961890e-01f,
  -2.02212825e-01f, -1.74283132e-01f, -7.84793869e-02f, -2.79239088e-01f, 2.74032623e-01f, 1.36908427e-01f, 4.38815989e-02f, 1.68989003e-01f, -1.03469901e-01f, -5.58713786e-02f,
  1.54893294e-01f, -1.37833163e-01f, 1.00579351e-01f, 1.81658447e-01f, 4.31131832e-02f, 1.89657748e-01f, 9.55305547e-02f, 1.40307903e-01f, -2.27880269e-01f, 3.99520341e-03f,
  -1.05519161e-01f, -4.25053723e-02f, -1.47166699e-01f, -5.99833913e-02f, -6.88598584e-03f, 2.22618401e-01f, 2.80676305e-01f, 1.73399806e-01f, 6.10875040e-02f, -2.82026529e-01f,
  2.52872892e-02f, -1.11577459e-01f, -3.07292268e-02f, 2.77797095e-02f, 8.32192227e-03f, -1.83678150e-01f, -1.46418914e-01f, -9.27229449e-02f, -1.37142479e-01f, 5.53113297e-02f,
  -5.53505495e-03f, -7.95638412e-02f, -3.85181084e-02f, -1.67126551e-01f, 1.39348462e-01f, -8.47471431e-02f, 8.97055492e-02f, -8.85789841e-02f, -5.68477847e-02f, -1.74825653e-01f,
  2.46735327e-02f, 6.98957369e-02f, -2.17903823e-01f, 2.40180358e-01f, 2.82519490e-01f, 8.10807273e-02f, 1.21454615e-03f, 3.38307838e-03f, -9.21474472e-02f, -2.06087187e-01f,
  -2.22365245e-01f, 2.09288955e-01f, 2.63152063e-01f, -7.89515674e-02f, 5.53175248e-02f, 3.07866484e-02f, 1.01479553e-01f, -1.03821689e-02f, 3.02316606e-01f, -2.84022003e-01f,
  2.42071673e-01f, -7.80974552e-02f, -2.82107919e-01f, 4.56487946e-02f, 1.88820720e-01f, -6.21153526e-02f, 1.26116171e-01f, -5.20723797e-02f, 1.70222893e-01f, 1.10180609e-01f,
  -4.10542972e-02f, -4.25255951e-03f, -2.13642776e-01f, -5.00661135e-03f, -2.45809168e-01f, -1.34398714e-01f, -5.93918655e-03f, 1.95072442e-01f, 1.92669332e-01f, -7.21182674e-02f,
  1.43486962e-01f, -2.42436260e-01f, 1.64380267e-01f, -9.70472768e-02f, 3.83745902e-03f, 1.32641748e-01f, -1.17838770e-01f, -9.60621312e-02f, 1.90619882e-02f, -1.76825970e-02f,
  -1.14723422e-01f, 2.79915296e-02f, -1.18514694e-01f, -2.09396675e-01f, -1.31772533e-02f, -1.40858412e-01f, -1.73757970e-01f, -1.25409335e-01f, 8.57378915e-02f, 8.36922377e-02f,
  -1.31806895e-01f, 1.85244530e-01f, -9.49289277e-02f, -2.14531854e-01f, 1.42665923e-01f, -1.36114568e-01f, -3.03060864e-03f, -2.61509508e-01f, 1.36962563e-01f, 2.48863874e-03f,
  -5.39160557e-02f, 9.64743644e-03f, -1.47967562e-01f, -1.43760920e-01f, 2.93635398e-01f, -2.64952965e-02f, -1.53492451e-01f, 1.27869859e-01f, 1.01602763e-01f, 1.65046453e-01f,
  7.53085017e-02f, -8.54039863e-02f, -1.20784014e-01f, 5.94856404e-02f, -1.80895150e-01f, -4.55411486e-02f, 1.28048435e-01f, -1.73082873e-01f, -1.74498096e-01f, -2.14033380e-01f,
  1.16588203e-02f, 5.84933832e-02f, 6.39333297e-03f, -7.75562748e-02f, 1.07053816e-01f, 1.40787214e-01f, 6.35128245e-02f, -2.44081602e-01f, 1.95361763e-01f, 1.88119859e-01f,
  1.69643193e-01f, -1.90712810e-01f, -1.74700812e-01f, 8.27041455e-03f, -7.01450631e-02f, -3.49084474e-02f, -4.55572195e-02f, 2.07825512e-01f, -7.56758824e-02f, -1.83957592e-02f,
  -9.86761749e-02f, 6.88443705e-02f, 4.36568893e-02f, 9.01538953e-02f, 3.89083065e-02f, 8.79634097e-02f, -3.06532811e-02f, 3.74859665e-03f, -1.16407298e-01f, 1.34969689e-03f,
  1.29266288e-02f, 2.90399045e-01f, -1.72020331e-01f, -5.60484128e-03f, 1.58982009e-01f, 2.03138277e-01f, 2.05346823e-01f, -1.76044479e-01f, 1.90608576e-01f, -8.99480842e-03f,
  -2.34216675e-01f, 1.46912724e-01f, -4.66937311e-02f, 7.58983791e-02f, 1.34369954e-01f, -5.67278937e-02f, 1.27216369e-01f, -1.55445382e-01f, -3.17180492e-02f, 5.80896027e-02f,
  5.39389364e-02f, 1.32877782e-01f, 1.44343814e-02f, -4.00247313e-02f, -1.28128022e-01f, 2.11415946e-01f, 2.27332309e-01f, 1.90720037e-01f, -1.14593513e-01f, 2.02523500e-01f,
  -2.48373561e-02f, 1.32642999e-01f, -1.15404129e-01f, 1.44924764e-02f, -2.65761055e-02f, -3.84970121e-02f, -2.10503668e-01f, -2.22630911e-02f, -7.43878782e-02f, -8.11227337e-02f,
  3.02595813e-02f, -9.43530574e-02f, -9.67733040e-02f, 1.52189303e-02f, -2.64974624e-01f, 2.36567366e-03f, 8.89850408e-02f, 1.21383317e-01f, -9.93030295e-02f, 2.13025868e-01f,
  -2.00453311e-01f, 3.71178947e-02f, 2.79338155e-02f, -1.59525257e-02f, 1.10683545e-01f, 1.74466800e-02f, 1.81652993e-01f, -1.19234614e-01f, -1.38189197e-01f, 8.04132447e-02f,
  1.09130509e-01f, -1.67730136e-03f, 3.59307788e-02f, 1.61551997e-01f, -3.90708447e-02f, 6.60069585e-02f, 1.37723148e-01f, 2.16333389e-01f, -1.00253254e-01f, -2.30270643e-02f,
  -1.30719831e-02f, -1.86222732e-01f, 1.11410916e-01f, -1.43196419e-01f, -1.74404979e-01f, 1.59721807e-01f, 8.22174624e-02f, 1.38469830e-01f, 1.68048218e-01f, 7.35138804e-02f,
  -1.07795753e-01f, -1.39924154e-01f, -1.42462641e-01f, 2.28438348e-01f, 3.09795719e-02f, -7.95466080e-02f, 1.20149143e-01f, 1.86413042e-02f, -1.56448483e-01f, 1.38402671e-01f,
  1.43849477e-01f, -6.47324994e-02f, 1.19395414e-02f, -2.24446669e-01f, -8.53884220e-03f, 1.51210338e-01f, 8.17605332e-02f, 2.02542663e-01f, 3.98231372e-02f, -1.33932874e-01f,
  6.17993400e-02f, -2.26854216e-02f, 2.31538583e-02f, 1.05970331e-01f, -3.49139087e-02f, 1.99187547e-01f, -2.86154971e-02f, -2.25169688e-01f, 1.71022326e-01f, 8.26167539e-02f,
  1.10358126e-01f, -9.92874876e-02f, -1.39632791e-01f, -1.87544614e-01f, 8.95416290e-02f, -1.14034154e-01f, -2.87809651e-02f, 5.91413938e-02f, -8.92916098e-02f, 1.06043816e-01f,
  -1.29358321e-02f, 4.89906408e-02f, -4.48933654e-02f, 4.33147773e-02f, 3.56758991e-03f, 2.79048849e-02f, 2.27048293e-01f, -2.96345428e-02f, -1.05390549e-01f, 3.37293297e-02f,
  1.99219555e-01f, 8.70624483e-02f, 1.03997037e-01f, 3.23663615e-02f, 3.47525954e-01f, -1.61265209e-01f, 4.72780764e-02f, -1.64619416e-01f, 5.81889115e-02f, -1.67667359e-01f,
  -1.96690746e-02f, -1.66174009e-01f, -2.03885674e-01f, 5.52160069e-02f, 3.10871527e-02f, -1.03799365e-01f, 6.79802075e-02f, -2.36193180e-01f, 1.71477959e-01f, 2.44392976e-01f,
  1.96901530e-01f, 2.29945481e-01f, 2.86798347e-02f, 2.64174193e-01f, -2.44866490e-01f, 2.64718026e-01f, 5.61772101e-02f, 1.80460662e-01f, -1.85253825e-02f, -6.24266127e-03f,
  -1.56069482e-02f, 1.69709653e-01f, -1.08600035e-01f, -2.50628352e-01f, 8.36782008e-02f, -2.00578511e-01f, -4.99145277e-02f, -2.29743257e-01f, 1.23546019e-01f, -1.54781237e-01f,
  -2.23045111e-01f, -1.42719358e-01f, -4.59408946e-02f, -2.24619061e-01f, -8.01441520e-02f, -2.03739733e-01f, -1.69707179e-01f, -5.73414518e-03f, -3.45619582e-02f, -2.28458166e-01f,
  1.02482900e-01f, 1.51286751e-01f, 3.08757350e-02f, 8.75828043e-02f, 2.07989126e-01f, 9.21986178e-02f, -2.82068644e-02f, -1.21737737e-02f, 5.75016998e-03f, -7.63807520e-02f,
  -1.04727067e-01f, 9.79048312e-02f, -1.91701725e-01f, -2.16448992e-01f, -5.48326410e-02f, -3.11279837e-02f, -7.61030167e-02f, 2.01927423e-02f, -1.80734083e-01f, -1.51789680e-01f,
  -1.01025188e-02f, -1.15150496e-01f, -1.21138103e-01f, -5.99569231e-02f, 9.62642133e-02f, 2.26032957e-01f, -1.75747499e-01f, -8.29280447e-03f, 1.79222156e-03f, -2.22718671e-01f,
  -4.25703488e-02f, -5.03696389e-02f, -2.48680264e-01f, 5.14305532e-02f, -2.09758252e-01f, -1.70087576e-01f, 4.44310047e-02f, -1.82003137e-02f, 1.67792588e-01f, -2.21979827e-01f,
  -1.79536179e-01f, -5.20079583e-03f, 1.16125839e-02f, 9.69083160e-02f, 5.46266288e-02f, -2.10150763e-01f, -2.27427453e-01f, 1.79704633e-02f, 2.17979372e-01f, 2.44843394e-01f,
  1.70009643e-01f, 1.60559595e-01f, 5.51020429e-02f, 7.95157999e-02f, -8.66532773e-02f, -1.72212929e-01f, 1.59335449e-01f, -7.69452229e-02f, 7.26301298e-02f, 2.37818025e-02f,
  -1.11306593e-01f, -8.15163553e-02f, -8.03075358e-03f, -7.25866407e-02f, -1.35672897e-01f, -3.84810828e-02f, 1.27138868e-01f, 1.75263360e-01f, 2.00090185e-02f, 4.34469692e-02f,
  -4.80531761e-03f, 4.48011123e-02f, 5.32006472e-03f, -6.66597262e-02f, -1.41158566e-01f, 2.30007060e-02f, 1.58450499e-01f, 1.50277251e-02f, 5.10892309e-02f, -2.14401230e-01f,
  8.56647193e-02f, -1.94497481e-01f, 4.26810439e-04f, 2.15789527e-01f, 1.18732145e-02f, -8.39608163e-02f, -1.35347798e-01f, 1.37174474e-02f, -1.84686765e-01f, 1.66177571e-01f,
  -7.67323822e-02f, 1.20469101e-01f, 4.69342023e-02f, 1.07670762e-01f, -2.11518910e-02f, 1.98362902e-01f, -1.56432062e-01f, -7.46393725e-02f, 1.07519887e-01f, -1.32826403e-01f,
  2.33147424e-02f, -9.65351015e-02f, 2.09021911e-01f, -1.35965556e-01f, -1.15318164e-01f, -7.02471584e-02f, -2.14282274e-01f, 2.17723772e-02f, -5.08045852e-02f, -1.02677360e-01f,
  -1.24356128e-01f, 1.47194922e-01f, -5.74319772e-02f, -5.15706502e-02f, -3.10151596e-02f, -1.23581067e-01f, 1.23526573e-01f, -1.90496624e-01f, 1.74518168e-01f, 2.39928082e-01f,
  1.06088873e-02f, 1.19526885e-01f, 8.42005536e-02f, 1.77915469e-02f, -6.72962740e-02f, 1.23682298e-01f, -9.12339836e-02f, -1.62834134e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -7.28273019e-02f, -2.72144321e-02f, 2.79737860e-01f, -8.13285410e-02f, -3.55519801e-01f, -9.72431377e-02f, -7.43885860e-02f, 1.02087297e-01f, 7.53129125e-02f, 8.64415169e-02f,
  2.68224955e-01f, 2.23979816e-01f, -4.00858186e-02f, 2.41143718e-01f, -2.33951136e-02f, 3.50457549e-01f, 2.73830354e-01f, 1.00388162e-01f, 1.74954802e-01f, -4.45023656e-01f,
  8.37162212e-02f, -3.77031177e-01f, 4.40983996e-02f, 1.72865707e-02f, 2.55033284e-01f, -3.24658722e-01f, -7.16313869e-02f, 2.79236287e-02f, 3.09815615e-01f, -2.04995200e-01f,
  2.58441657e-01f, -1.38465255e-01f, 4.60945129e-01f, 2.14112625e-01f, 1.86616197e-01f, 4.24083173e-01f, 2.32084230e-01f, 2.69600242e-01f, -5.80993965e-02f, 2.10251018e-01f,
  8.85932073e-02f, 2.41615698e-01f, 3.37009430e-01f, 8.95958543e-02f, -6.12435378e-02f, 2.12239370e-01f, -2.25529417e-01f, -3.77569586e-01f, 5.93952052e-02f, -2.15969786e-01f,
  1.30467772e-01f, 4.69631195e-01f, -2.01301917e-01f, 2.86112636e-01f, 1.34558067e-01f, -3.72765332e-01f, 6.18461490e-01f, 1.71082020e-02f, 5.62245399e-02f, -3.96809220e-01f,
  1.64821044e-01f, 1.21354461e-01f, -1.85704589e-01f, 7.09610507e-02f, 4.20897305e-02f, -9.01635364e-02f, -1.29088521e-01f, 2.50922352e-01f, 3.83770131e-02f, 2.88052738e-01f,
  2.32911572e-01f, 1.35408923e-01f, 8.94463137e-02f, 6.36705980e-02f, -6.69318661e-02f, -1.16329193e-01f, 1.16912112e-01f, 2.40121543e-01f, -2.38450646e-01f, -1.85147934e-02f,
  -9.35277119e-02f, -8.95958673e-03f, -9.39513221e-02f, 1.95457011e-01f, -1.32290530e-04f, 3.26648176e-01f, -1.20971985e-01f, 1.50281126e-02f, -2.44925752e-01f, 2.90352464e-01f,
  2.82121271e-01f, 2.04449847e-01f, -1.33132502e-01f, 1.24351405e-01f, 2.85086066e-01f, 2.99950629e-01f, -2.51668185e-01f, -1.68453664e-01f, 1.53744996e-01f, -2.03994364e-01f,
  1.97783828e-01f, -2.81842649e-01f, 2.45366752e-01f, 1.47545829e-01f, -9.82012674e-02f, 2.03360423e-01f, -5.14365211e-02f, 3.05387139e-01f, -1.04223624e-01f, 1.78694054e-02f,
  3.70236993e-01f, 3.76372695e-01f, -8.98931697e-02f, 2.04233024e-02f, -2.19525084e-01f, -2.24943340e-01f, 7.63902292e-02f, 1.20226674e-01f, 2.15984687e-01f, 3.59212309e-01f,
  -1.88492954e-01f, 3.34655344e-01f, 1.32982358e-01f, 4.42735583e-01f, 3.59881073e-01f, 3.07960927e-01f, 2.28720158e-01f, 1.22243032e-01f, 2.00463831e-01f, -3.04875653e-02f,
  -1.07267112e-01f, -1.20242429e-03f, 3.09538320e-02f, 1.20628218e-03f, 1.35727569e-01f, 1.69248566e-01f, -9.10343155e-02f, 1.48360878e-01f, -1.02162875e-01f, 2.11839244e-01f,
  -2.22802594e-01f, -2.74055600e-01f, -3.20444964e-02f, 4.31732461e-02f, 4.87926789e-02f, -3.93762179e-02f, -2.55267054e-01f, -1.13168724e-01f, -2.02934537e-02f, 3.28009099e-01f,
  3.21597338e-01f, -2.36823812e-01f, 2.00992659e-01f, -7.80401472e-03f, -1.25778615e-01f, 2.38040518e-02f, -1.08733520e-01f, -8.50902125e-02f, 2.99360931e-01f, -8.44085738e-02f,
  5.09153120e-02f, -7.19586909e-02f, -1.31640434e-01f, 2.09428146e-01f, 2.83022046e-01f, -1.56957626e-01f, -1.69340611e-01f, 2.98379958e-01f, 1.48480311e-01f, 3.63270760e-01f,
  -9.39797759e-02f, -6.29998296e-02f, 2.58982390e-01f, -2.98670739e-01f, 2.82350600e-01f, 1.35499969e-01f, 1.01333454e-01f, 4.56956066e-02f, 3.16707119e-02f, 2.71512181e-01f,
  6.25563934e-02f, 1.93509743e-01f, -2.88052917e-01f, -7.93462172e-02f, -2.28579938e-01f, 2.10415527e-01f, 1.63256153e-01f, 6.11897521e-02f, 3.44772935e-01f, 1.20061152e-01f,
  3.28414053e-01f, -1.00449726e-01f, 9.09600127e-03f, 2.34665021e-01f, 9.90875959e-02f, 1.16416696e-03f, 2.21063763e-01f, -8.20855126e-02f, 1.60642322e-02f, 1.52520493e-01f,
  2.47097194e-01f, 5.50882742e-02f, 2.19467834e-01f, 1.79767594e-01f, -1.72029898e-01f, 1.42118976e-01f, 2.87998170e-01f, -8.70199949e-02f, 1.91563800e-01f, -1.14344813e-01f,
  5.39161675e-02f, -6.07099235e-02f, 1.54610679e-01f, -1.25776753e-01f, 2.51101524e-01f, -2.49046698e-01f, 8.57253894e-02f, -2.40130007e-01f, -4.05004155e-03f, 2.26092115e-02f,
  4.18950498e-01f, 2.42799699e-01f, -4.55721505e-02f, 1.37634939e-04f, 8.79879519e-02f, 3.92534941e-01f, 2.82184452e-01f, 1.85932308e-01f, 8.54954422e-02f, 4.58730787e-01f,
  -9.97693688e-02f, 1.36419743e-01f, -1.71535075e-01f, -5.83669469e-02f, -1.47764636e-02f, -1.02348953e-01f, -1.41702872e-02f, 3.81037205e-01f, -1.71029925e-01f, -1.54070050e-01f,
  -4.10615839e-02f, 2.19429314e-01f, 2.14825571e-01f, 6.01614639e-02f, 2.29977399e-01f, 1.69558581e-02f, 3.56224142e-02f, -6.41089156e-02f, 2.57997483e-01f, -1.01028450e-01f,
  -1.43839121e-01f, -2.01364562e-01f, -1.31771475e-01f, 1.33395540e-02f, -1.49992913e-01f, -1.98755398e-01f, -2.96102073e-02f, 1.75013945e-01f, -9.07646143e-04f, -8.04518089e-02f,
  -2.40063369e-01f, -6.10229410e-02f, 5.92289604e-02f, 1.27833560e-01f, -1.84161048e-02f, -9.03703347e-02f, 1.99777856e-01f, 8.64373222e-02f, -9.49143544e-02f, 2.49706447e-01f,
  1.89898744e-01f, 4.49322201e-02f, 2.53964245e-01f, 1.85326189e-01f, 2.47144029e-02f, 1.87056184e-01f, 3.50959033e-01f, -2.20861763e-01f, -4.34414521e-02f, -1.65752187e-01f,
  -2.73605049e-01f, -2.02786941e-02f, 2.13808745e-01f, 1.46020353e-01f, 2.73205072e-01f, 7.54625350e-02f, 2.15975925e-01f, 2.00386524e-01f, 1.66305434e-02f, 4.09342676e-01f,
  3.60867620e-01f, 2.27477849e-01f, 1.65028632e-01f, 3.10228169e-01f, -6.22448176e-02f, 3.33475053e-01f, -1.38964459e-01f, 1.54704094e-01f, 2.21583337e-01f, 2.30017826e-02f,
  -2.56339252e-01f, 2.77803659e-01f, -2.36629974e-02f, 2.41785914e-01f, 3.75519730e-02f, -2.38176003e-01f, 6.26244396e-02f, -2.21008748e-01f, 1.76037788e-01f, -1.82895675e-01f,
  5.16684175e-01f, 2.09014267e-01f, 3.21505278e-01f, -1.40799999e-01f, -1.77083030e-01f, -1.37030512e-01f, -5.96825294e-02f, 2.36615524e-01f, -1.01814074e-02f, 4.27849233e-01f,
  9.25040767e-02f, 2.55361021e-01f, 1.92815468e-01f, -6.81241527e-02f, -1.43279836e-01f, 3.23020518e-02f, 9.86575633e-02f, 1.33158192e-01f, 1.69864789e-01f, 7.24416897e-02f,
  8.71584862e-02f, 8.61939415e-02f, -1.62946761e-01f, 1.39069259e-01f, 8.65571648e-02f, 2.74361759e-01f, -2.88964182e-01f, 3.21844816e-01f, -2.02055022e-01f, 3.22242558e-01f,
  3.56545120e-01f, -2.00303383e-02f, -2.32564770e-02f, 5.67013100e-02f, -2.14849144e-01f, 1.57473728e-01f, 3.06278884e-01f, 6.56574443e-02f, -1.88634023e-02f, 1.81467056e-01f,
  5.56164347e-02f, 3.09442550e-01f, -3.34965199e-01f, 1.16508931e-01f, 1.50364816e-01f, -7.18763471e-02f, -1.36571154e-02f, -2.92887967e-02f, 1.74540747e-02f, 1.82202347e-02f,
  -1.11047335e-01f, 1.38260379e-01f, 3.34473342e-01f, 6.82745874e-02f, -1.94840387e-01f, 2.00352713e-01f, 1.42143369e-01f, 2.27846745e-02f, -7.86127076e-02f, 1.72814146e-01f,
  9.35119689e-02f, 1.41148210e-01f, 1.92559287e-01f, 6.53679818e-02f, 4.51749921e-01f, 2.30898950e-02f, 3.74079227e-01f, -8.10495317e-02f, -2.42824763e-01f, 1.97469980e-01f,
  -1.09328985e-01f, -5.50077446e-02f, -3.11219878e-02f, 2.27067456e-01f, 1.81353152e-01f, 1.25968054e-01f, 9.56271663e-02f, 8.74413252e-02f, -2.03008614e-02f, 2.84663826e-01f,
  1.54472560e-01f, 1.35542020e-01f, 2.36210942e-01f, 8.92471522e-02f, 9.86945033e-02f, 2.98433155e-01f, -2.95698524e-01f, 9.03828293e-02f, -1.18771151e-01f, 2.53287792e-01f,
  3.95807512e-02f, 1.40919477e-01f, -5.73649146e-02f, -1.06930017e-01f, 1.46120563e-01f, -1.60787284e-01f, -3.65098640e-02f, -7.69925565e-02f, 1.01248600e-01f, -1.80942379e-02f,
  7.97906518e-02f, -2.24772766e-01f, 1.78321749e-01f, 2.20562518e-01f, 1.24293692e-01f, -1.27687216e-01f, -1.88948661e-01f, 3.81851822e-01f, -2.70901695e-02f, 2.11395785e-01f,
  -8.37326422e-03f, 5.30497618e-02f, -2.89246678e-01f, 1.93289563e-01f, 7.95374587e-02f, 2.84325033e-01f, 4.87620026e-01f, 1.66035518e-01f, -1.25035390e-01f, 6.11662492e-02f,
  1.33654982e-01f, -1.33625671e-01f, -2.40093052e-01f, 2.42379025e-01f, 2.92410880e-01f, 3.62128884e-01f, 1.49107277e-01f, 2.84288257e-01f, -3.68136317e-02f, -2.02770919e-01f,
  6.79392666e-02f, 6.56779483e-02f, -1.75726250e-01f, 5.07514141e-02f, 2.11252466e-01f, 2.33701274e-01f, -1.38924792e-01f, 3.30198295e-02f, 1.27818689e-01f, 5.51676527e-02f,
  1.88994542e-01f, 1.86241552e-01f, 1.13877960e-01f, 2.74908006e-01f, 4.04250026e-02f, 1.50304988e-01f, 1.90027609e-01f, 1.44725710e-01f, 3.76898170e-01f, 8.99680778e-02f,
  5.66607900e-02f, 1.00167610e-01f, -7.42624104e-02f, 1.29637554e-01f, -1.42178357e-01f, 5.36443703e-02f, -3.05962056e-01f, -2.06506960e-02f, 4.59504128e-02f, 2.77205575e-02f,
  3.19269031e-01f, -2.77099818e-01f, 1.10838331e-01f, -9.63255316e-02f, 7.37499744e-02f, 2.09490344e-01f, -5.37692793e-02f, 4.06283140e-01f, 4.18049514e-01f, -1.72873497e-01f,
  -1.43250465e-01f, 4.36780974e-02f, 1.70507982e-01f, 1.50108933e-01f, 1.14510812e-01f, 3.14899385e-02f, -3.39427650e-01f, -1.16602406e-01f, -8.64167362e-02f, -2.80635983e-01f,
  4.36599851e-01f, 1.75622120e-01f, -3.07981342e-01f, 3.22481751e-01f, -8.68801251e-02f, 3.75922114e-01f, -2.66080312e-02f, 2.60028720e-01f, 3.78739119e-01f, 3.08606267e-01f,
  3.60610574e-01f, 3.19208920e-01f, 2.24232003e-01f, 4.21463102e-01f, 3.33878458e-01f, 3.84266600e-02f, -1.74673468e-01f, -7.72620598e-03f, 5.40308654e-02f, -1.40200391e-01f,
  -6.93717152e-02f, 2.46268660e-01f, 1.26358882e-01f, 3.80498148e-03f, -7.81191699e-03f, -5.71132302e-02f, -1.94873437e-01f, 1.60572723e-01f, 6.41525015e-02f, 2.02714235e-01f,
  2.38098532e-01f, 1.00100059e-02f, 2.23148555e-01f, 2.49455646e-01f, 1.77661031e-02f, 4.47208613e-01f, -1.92243591e-01f, 2.37720072e-01f, -2.18026061e-02f, 2.69521981e-01f,
  -4.39132750e-02f, -5.20244725e-02f, 1.35650083e-01f, -9.44650248e-02f, -2.22707644e-01f, 2.53486276e-01f, -2.39746720e-01f, 2.69323587e-01f, 3.54599416e-01f, -2.73680955e-01f,
  -3.74948829e-02f, 5.41600809e-02f, 8.42456371e-02f, -1.56628597e-03f, 2.18958482e-01f, 3.67015116e-02f, -1.12247221e-01f, 8.88375007e-03f, -3.23266178e-01f, 3.56386341e-02f,
  -6.73858449e-02f, 1.07884835e-02f, 2.71307528e-01f, 1.22511961e-01f, 4.68176901e-01f, 4.87313151e-01f, -4.36198443e-01f, -1.57384714e-03f, 3.14363033e-01f, -8.18096921e-02f,
  -4.23193306e-01f, 3.89499357e-03f, -4.09243144e-02f, 5.80047667e-02f, 1.25000209e-01f, 3.46920431e-01f, 2.14134157e-01f, -2.40346611e-01f, 2.58185476e-01f, 3.46553735e-02f,
  1.03277266e-01f, 2.22265661e-01f, 7.24686831e-02f, -1.20548069e-01f, -1.30675271e-01f, 3.26218158e-01f, 4.38821130e-02f, -7.25684464e-02f, 1.45124748e-01f, -1.32080838e-01f,
  1.09263897e-01f, -1.28826909e-02f, 2.58552402e-01f, 1.86066389e-01f, 2.29718164e-01f, 2.05598816e-01f, 5.09415008e-02f, 1.15439827e-02f, -1.44412220e-01f, 2.39943210e-02f,
  -7.91806653e-02f, -2.21627519e-01f, -2.38647200e-02f, -3.18686143e-02f, -2.39098251e-01f, 9.54732075e-02f, 1.68591831e-02f, 7.00938925e-02f, 3.14200401e-01f, -2.09920071e-02f,
  5.64850718e-02f, -8.93202648e-02f, -5.14067151e-02f, -8.24923590e-02f, 2.37063929e-01f, 3.77346933e-01f, -1.35980561e-01f, -1.32475793e-02f, -3.00081909e-01f, -4.84408513e-02f,
  -1.80885851e-01f, -2.04028711e-02f, 5.59864305e-02f, -3.04639101e-01f, -1.90230340e-01f, 1.53809592e-01f, 9.59277228e-02f, 3.25961858e-01f, 2.18809694e-01f, 1.39215067e-01f,
  3.15302819e-01f, 4.70555108e-03f, 1.07116234e-02f, -2.16056213e-01f, 1.41631022e-01f, 2.55605489e-01f, 1.86614260e-01f, -3.56759168e-02f, 1.16368249e-01f, 1.44246116e-01f,
  1.29011944e-02f, -2.18773067e-01f, -1.53254066e-02f, 4.26671691e-02f, 8.35125297e-02f, 8.38640705e-02f, 2.31199458e-01f, 2.84857720e-01f, 1.04364909e-01f, -2.68663596e-02f,
  1.72677204e-01f, -3.12986486e-02f, -5.23716025e-02f, -4.91148867e-02f, 4.12188023e-02f, 4.92872149e-02f, 8.02396759e-02f, 1.14669695e-01f, 1.49235204e-01f, 1.92440748e-01f,
  1.37469202e-01f, 1.63812339e-01f, 1.65633306e-01f, 1.80466428e-01f, -3.07706464e-02f, -3.53234001e-02f, 1.20583698e-01f, -1.64545268e-01f, 3.16606387e-02f, 2.63976425e-01f,
  -1.43309876e-01f, -8.12608600e-02f, -2.70016909e-01f, 3.06966007e-01f, -3.08403391e-02f, 2.80785590e-01f, 1.56458154e-01f, -5.22466712e-02f, 2.66980946e-01f, 2.30229765e-01f,
  -2.55725116e-01f, -1.38040423e-01f, 3.16358328e-01f, 1.37764690e-02f, 5.32659814e-02f, -2.00632021e-01f, -1.12343110e-01f, -1.87197790e-01f, 3.10663640e-01f, 1.53375804e-01f,
  2.84475774e-01f, 4.54136878e-02f, 2.04301521e-01f, 1.86630130e-01f, 2.57945865e-01f, 2.32473969e-01f, 2.05252022e-01f, -2.15889990e-01f, 8.75791758e-02f, -8.67492631e-02f,
  1.89745333e-02f, -8.61534923e-02f, -4.49233726e-02f, 1.84608057e-01f, 1.75833747e-01f, -1.34843513e-01f, 1.60766989e-01f, 9.39105824e-02f, 9.91220176e-02f, 6.41651973e-02f,
  9.12309065e-02f, 1.01927273e-01f, 1.28394499e-01f, 3.02991141e-02f, -4.33385633e-02f, 1.08562306e-01f, 2.61950999e-01f, 6.16835542e-02f, 3.11828434e-01f, -1.00457132e-01f,
  2.46299088e-01f, 8.28689337e-02f, 2.73320407e-01f, 1.11682162e-01f, 1.96509287e-01f, 2.36802921e-01f, -5.35382330e-02f, -1.03616074e-01f, 4.87045556e-01f, -2.12187707e-01f,
  2.73087680e-01f, -2.73755848e-01f, 1.10778920e-01f, 7.33625665e-02f, 1.69890240e-01f, -1.36840239e-01f, 2.92614043e-01f, -2.92078614e-01f, 9.07672942e-02f, -3.17516446e-01f,
  -5.54990508e-02f, 1.84033900e-01f, 4.39437240e-01f, 2.31430665e-01f, -1.96126789e-01f, -1.47388265e-01f, -2.85938792e-02f, 3.59829336e-01f, 1.90377176e-01f, 2.24874169e-01f,
  1.34469479e-01f, 4.92700636e-01f, -2.90690988e-01f, -2.48073906e-01f, -2.22300723e-01f, 1.58643007e-01f, -1.84936300e-01f, -2.61798203e-01f, 1.99611887e-01f, 3.54488969e-01f,
  -3.78845036e-01f, -1.25664830e-01f, 2.03306586e-01f, 1.73197463e-01f, 1.35975629e-01f, -8.75173062e-02f, 2.78462917e-01f, 5.10237142e-02f, -1.66850209e-01f, 3.36327031e-02f,
  -5.14292568e-02f, 1.14045575e-01f, 1.09641187e-01f, -2.20094964e-01f, 2.65709106e-02f, -5.62376492e-02f, 1.26647353e-02f, -3.05848271e-01f, -2.39144892e-01f, -5.04837744e-02f,
  6.54871538e-02f, -2.22718611e-01f, 1.30680487e-01f, 4.13169451e-02f, 1.31091624e-01f, 3.04816887e-02f, 2.43011061e-02f, 1.05095603e-01f, -3.82975608e-01f, -1.18462823e-01f,
  -1.66450709e-01f, -3.01166475e-01f, 2.46128917e-01f, -1.00045450e-01f, -1.05285600e-01f, 1.31131411e-01f, -5.16619921e-01f, 1.65310740e-01f, -3.03723142e-02f, 2.59185165e-01f,
  3.68154854e-01f, -3.22574407e-01f, 2.97285914e-01f, -8.49976495e-04f, -2.01780930e-01f, 2.00566530e-01f, -4.37589623e-02f, 5.39575256e-02f, 4.28341061e-01f, 1.11580409e-01f,
  -3.82518947e-01f, -2.52014160e-01f, -1.89831838e-01f, 2.29666140e-02f, 3.00675064e-01f, -2.17208132e-01f, 1.32441863e-01f, -2.34916687e-01f, -2.18591720e-01f, -3.63476686e-02f,
  -3.59339267e-01f, -7.94800296e-02f, 2.89993882e-01f, -4.06196654e-01f, -3.04635316e-01f, 2.51715958e-01f, 2.84948915e-01f, 6.96239807e-03f, 1.56384647e-01f, 1.16624892e-01f,
  7.91384056e-02f, 2.60754162e-03f, -2.71621168e-01f, 1.72731876e-01f, -4.77529913e-02f, 4.45208699e-01f, 3.09943229e-01f, 3.16512957e-02f, 3.04550678e-01f, -2.23737564e-02f,
  1.90357063e-02f, 5.46832681e-02f, -1.08392658e-02f, -1.18128352e-01f, 2.28249431e-02f, 2.80097537e-02f, -8.18376616e-02f, 2.19199598e-01f, 1.53609261e-01f, 1.68254793e-01f,
  -3.68668176e-02f, -1.32678196e-01f, 2.58758187e-01f, 2.56944031e-01f, 2.84874350e-01f, 8.22066888e-02f, -6.46911561e-02f, -2.39811391e-02f, -1.27197698e-01f, -1.95246324e-01f,
  -1.61788285e-01f, -3.05817109e-02f, -9.38224941e-02f, 2.11288378e-01f, 2.40895182e-01f, -3.13703358e-01f, -1.26244605e-01f, -2.56106585e-01f, 1.15585914e-02f, -1.41859064e-02f,
  -1.33954257e-01f, 1.71581477e-01f, 2.56951898e-01f, -9.30524543e-02f, 2.92375773e-01f, -1.73272684e-01f, 2.46460199e-01f, 2.01016471e-01f, 1.73263907e-01f, 4.75743338e-02f,
  -2.25007653e-01f, 3.22958492e-02f, 2.09239677e-01f, 6.99973926e-02f, 2.14836776e-01f, 2.56046951e-01f, -4.72642062e-03f, 7.48137385e-02f, 2.26259813e-01f, 2.08670288e-01f,
  2.41367891e-01f, -2.35998090e-02f, -2.80493975e-01f, -2.38161683e-01f, 3.05341911e-02f, 1.11539416e-01f, 7.34692439e-02f, 4.72914092e-02f, -6.78643119e-03f, 3.01837713e-01f,
  2.08524227e-01f, 1.35319605e-01f, 4.01548743e-01f, -1.97207943e-01f, 4.49981801e-02f, 1.93766013e-01f, 1.02930628e-01f, 1.47562265e-01f, 1.07576571e-01f, 2.12942854e-01f,
  9.47445780e-02f, 1.27144426e-01f, 8.15826058e-02f, 2.40883350e-01f, 2.32413813e-01f, -8.03819820e-02f, 2.72076339e-01f, 2.04067647e-01f, 1.62571549e-01f, 2.48229191e-01f,
  9.33644623e-02f, 1.13050073e-01f, 1.23367801e-01f, -2.31012423e-02f, 1.25694051e-01f, -1.82833355e-02f, 5.02433665e-02f, -2.28472933e-01f, 2.26685107e-02f, -1.56773910e-01f,
  -1.71775430e-01f, -6.92102611e-02f, 1.81555465e-01f, 2.38188654e-01f, 1.33057177e-01f, 3.23346615e-01f, 1.57522649e-01f, -2.92761534e-01f, -3.73494625e-02f, 2.98601031e-01f,
  3.11426908e-01f, 2.08536983e-01f, -1.34790912e-02f, 2.15906084e-01f, -1.59917131e-01f, -1.14438847e-01f, 6.47912454e-03f, 1.03262618e-01f, 4.79156017e-01f, 4.23837006e-01f,
  -3.25154841e-01f, 3.54410172e-01f, 1.96670890e-01f, 1.06988505e-01f, -2.30238184e-01f, 1.66497871e-01f, -1.32218301e-01f, -2.92004973e-01f, 3.68344396e-01f, 2.59280324e-01f,
  1.71123877e-01f, 2.17003934e-02f, 4.23139669e-02f, 9.99628231e-02f, -8.71320534e-03f, 2.14359030e-01f, -1.69386968e-01f, 3.99985835e-02f, -2.90485352e-01f, 9.35992002e-02f,
  -1.00456901e-01f, 9.18090269e-02f, 1.15402885e-01f, 2.77720183e-01f, 1.83571354e-01f, 9.26758349e-02f, 1.85658820e-02f, 1.81104779e-01f, 2.38688990e-01f, 2.97982693e-01f,
  6.38057664e-02f, 1.36046976e-01f, 2.62970179e-01f, 3.49137068e-01f, -1.57539114e-01f, -1.18255086e-01f, 2.41762742e-01f, -3.32484841e-01f, 1.36581704e-01f, 9.97746512e-02f,
  1.87556609e-03f, -9.25262086e-03f, -1.74156606e-01f, 3.08344990e-01f, -7.07623810e-02f, 8.63389745e-02f, 1.11408435e-01f, 2.88751125e-01f, 4.49990869e-01f, 2.67497271e-01f,
  -1.97039247e-01f, 1.63231373e-01f, 3.03278029e-01f, -8.96597579e-02f, 1.53944567e-01f, -3.57937277e-03f, -1.97002888e-01f, 3.20944339e-01f, 2.22475410e-01f, -2.68757135e-01f,
  4.88152020e-02f, -4.47199084e-02f, -7.87129551e-02f, 1.79739207e-01f, 3.16136256e-02f, 3.76584113e-01f, -1.26795501e-01f, -1.51384488e-01f, 1.59659415e-01f, 5.79943508e-02f,
  -1.79429054e-02f, -3.15638006e-01f, -2.06669718e-02f, 1.86909720e-01f, -6.80118203e-02f, -1.17846049e-01f, 6.79949075e-02f, 1.30363837e-01f, 1.52575240e-01f, 2.64697969e-01f,
  -3.01156223e-01f, 4.71462086e-02f, -2.36271963e-01f, -1.81956053e-01f, 7.25294054e-02f, 1.88255355e-01f, 1.50486737e-01f, 1.51652753e-01f, 2.26570711e-01f, 8.66603181e-02f,
  7.08578229e-02f, 1.30098209e-01f, 1.98047772e-01f, 2.29778334e-01f, 2.44733572e-01f, 2.40405530e-01f, 5.52496240e-02f, -4.44114655e-02f, -1.86438844e-01f, 4.59410660e-02f,
  7.54080489e-02f, -1.35922015e-01f, -3.21606137e-02f, -3.10880750e-01f, -1.30651146e-01f, -1.41095862e-01f, -1.51910260e-01f, 1.43025115e-01f, 2.57708102e-01f, -1.58454310e-02f,
  -9.94328409e-02f, 1.66937739e-01f, 8.99670124e-02f, -8.51137638e-02f, -5.36174662e-02f, -7.45050907e-02f, 2.87519693e-01f, 8.14195536e-03f, 3.96756344e-02f, 9.64122489e-02f,
  -7.65191838e-02f, 1.61503389e-01f, 3.93172860e-01f, -2.17150763e-01f, 1.40751928e-01f, -2.43022203e-01f, -3.06636542e-01f, 1.52373286e-02f, 1.20476060e-01f, 1.92564130e-01f,
  4.46692109e-03f, 1.62163615e-01f, -6.32549822e-02f, 2.63502985e-01f, 2.68760294e-01f, 3.56529117e-01f, 7.07666343e-03f, 2.92872824e-02f, -2.85929888e-01f, 1.26893029e-01f,
  -7.71604758e-03f, -4.57367487e-02f, 9.44097787e-02f, 1.32586241e-01f, -9.26437825e-02f, -7.47817308e-02f, -5.36221787e-02f, -3.29591632e-01f, 1.39572248e-01f, 1.77074909e-01f,
  2.40012527e-01f, 1.39956906e-01f, 1.59583464e-01f, -9.15809721e-02f, -1.37279406e-01f, 1.89099953e-01f, 1.55984715e-01f, 2.68792927e-01f, 2.11084753e-01f, 1.51091069e-01f,
  -5.64057427e-03f, -3.09814721e-01f, 1.23874344e-01f, 9.51039419e-02f, 2.15177517e-02f, 5.42448685e-02f, 4.94257221e-03f, -4.03084099e-01f, -2.56805658e-01f, -1.43427342e-01f,
  9.31990817e-02f, -7.15282783e-02f, 2.36690551e-01f, -2.59326190e-01f, -2.74101108e-01f, 1.61786769e-02f, 4.69843745e-02f, -1.94784328e-01f, 6.81222603e-02f, 5.92113510e-02f,
  4.08276469e-01f, -1.21620588e-01f, 4.12005521e-02f, 3.10033470e-01f, 2.52573062e-02f, 2.69196421e-01f, -4.54509109e-02f, 2.42885932e-01f, 3.04027200e-01f, -4.75723185e-02f,
  -9.91653651e-02f, -5.34955747e-02f, 3.11204344e-01f, -6.51313663e-02f, -1.61720365e-01f, -1.72713310e-01f, 1.98429316e-01f, 1.17537424e-01f, 1.48372561e-01f, 3.82536739e-01f,
  -1.93951577e-01f, 1.44004688e-01f, -2.55823016e-01f, -1.90732002e-01f, 1.12270534e-01f, 1.70591310e-01f, 2.53670722e-01f, -3.34127039e-01f, 2.02994272e-01f, 1.84935611e-02f,
  1.53863862e-01f, -3.05846453e-01f, -1.32110804e-01f, 1.31146535e-01f, 1.89317185e-02f, -8.61966684e-02f, 1.42878070e-01f, 2.41299700e-02f, 1.71582162e-01f, -3.04837283e-02f,
  9.90471453e-04f, 1.51415899e-01f, -1.60533562e-01f, -9.42679271e-02f, -2.14172695e-02f, -2.86553711e-01f, 2.71252364e-01f, -2.27841780e-01f, -2.40500644e-01f, 1.22796655e-01f,
  -3.73314977e-01f, 2.76283085e-01f, -4.45534736e-02f, 2.47432277e-01f, 2.65719324e-01f, -9.03961211e-02f, -8.55496451e-02f, 5.70490845e-02f, 6.73932210e-02f, 7.53016844e-02f,
  4.38666567e-02f, 9.43382904e-02f, 1.58719122e-01f, 3.38713616e-01f, -2.47997731e-01f, -1.41170233e-01f, 9.73310694e-02f, -2.08878785e-01f, 4.09982681e-01f, -1.99762806e-01f,
  3.86065021e-02f, -1.51788980e-01f, -2.79012233e-01f, 6.03806637e-02f, -4.68979105e-02f, -2.25760400e-01f, 1.57374054e-01f, 1.84076354e-02f, -8.73950422e-02f, 3.31048369e-01f,
  1.74428716e-01f, -1.01547958e-02f, 2.53206611e-01f, 1.07674591e-01f, 1.31728262e-01f, -1.10126540e-01f, 3.12812924e-01f, 3.30976456e-01f, 3.64291519e-01f, 1.89925328e-01f,
  4.98918742e-02f, 1.26528323e-01f, 1.49321333e-01f, -1.75204799e-02f, 1.92075074e-01f, 2.70569235e-01f, 5.81812710e-02f, -1.30416945e-01f, 3.88411246e-02f, 6.57393262e-02f,
  -9.62727219e-02f, 2.40663007e-01f, 1.01188548e-01f, 2.14562371e-01f, 8.70883930e-03f, 4.59993035e-02f, 3.63067798e-02f, 1.97643608e-01f, 3.02830964e-01f, -1.48285821e-01f,
  -3.71513724e-01f, -2.12533101e-01f, 1.83704272e-01f, -1.08362161e-01f, 7.52908736e-02f, -1.71069354e-02f, -2.48039424e-01f, 3.05830538e-01f, 1.94429159e-01f, -2.53835946e-01f,
  -9.03902277e-02f, -2.19888866e-01f, 1.16864048e-01f, 1.30183354e-01f, 3.77970785e-02f, 3.72074604e-01f, 3.48374039e-01f, -5.90225533e-02f, 2.72365242e-01f, -1.32808447e-01f,
  -7.33556598e-02f, 1.82769984e-01f, 1.27686039e-01f, -1.84073031e-01f, -2.51021147e-01f, 3.65901142e-01f, 2.19030172e-01f, 3.28922033e-01f, 1.68057293e-01f, 1.77314028e-01f,
  4.02542837e-02f, -3.36031243e-02f, 2.78268814e-01f, 3.43322277e-01f, 1.75848946e-01f, 6.15159050e-02f, -1.93000093e-01f, -1.51993722e-01f, -4.44630496e-02f, 1.93190709e-01f,
  1.33902788e-01f, 1.95882320e-01f, -2.80065358e-01f, 3.08780879e-01f, 4.71528433e-02f, 2.46696517e-01f, 3.95547658e-01f, 3.28472018e-01f, 1.27937004e-01f, 6.81784749e-02f,
  2.87168145e-01f, 5.87722734e-02f, 1.10394694e-01f, 1.26060158e-01f, 2.27776363e-01f, 1.84168920e-01f, 1.14735186e-01f, 1.50579408e-01f, 2.19271243e-01f, 1.17607996e-01f,
  -1.70225993e-01f, 1.88675020e-02f, -1.74021140e-01f, -1.75893366e-01f, -3.37278619e-02f, 1.95321947e-01f, -2.82036632e-01f, 2.23745301e-01f, -1.68245211e-01f, -9.00989696e-02f,
  -1.53452472e-03f, 9.38301757e-02f, -3.31310555e-02f, 5.48573211e-02f, 3.08356643e-01f, 3.76320451e-01f, 7.86003172e-02f, -6.99844807e-02f, -1.88454270e-01f, -1.37576014e-02f,
  -8.56829584e-02f, 2.70043731e-01f, -3.24720889e-01f, 1.85505286e-01f, -1.90404698e-01f, -2.52180733e-02f, -2.71828449e-03f, -5.87155931e-02f, 3.91840339e-01f, -1.19671121e-01f,
  5.14364839e-02f, -6.59850836e-02f, 6.11574426e-02f, 3.30756217e-01f, 3.15095007e-01f, -1.37545943e-01f, 3.01517725e-01f, -2.00796407e-02f, 7.80658647e-02f, 3.22305501e-01f,
  1.02816321e-01f, 2.13049546e-01f, 1.34134606e-01f, 1.25034362e-01f, -3.49637598e-01f, 2.55724229e-02f, -1.38304219e-01f, 1.40325919e-01f, 2.73740232e-01f, 2.79552490e-01f,
  2.33617842e-01f, -1.64714426e-01f, 1.36220694e-01f, -2.08870932e-01f, 4.72917594e-02f, 4.93409038e-02f, 2.01556578e-01f, -6.62683025e-02f, 3.30942094e-01f, -1.80920511e-02f,
  1.83195576e-01f, 1.83884650e-02f, 2.36801043e-01f, 1.58680096e-01f, -1.52587980e-01f, -5.72429188e-02f, -1.58677757e-01f, -2.69032586e-02f, 2.25365892e-01f, -1.91417933e-01f,
  2.71012664e-01f, -3.61560255e-01f, 1.94526583e-01f, 3.66185218e-01f, -3.47490497e-02f, 1.08458757e-01f, -3.75775434e-02f, 4.06338573e-01f, 1.63923502e-01f, 9.07008797e-02f,
  1.71226278e-01f, -3.28923529e-03f, 4.39904839e-01f, 2.86078215e-01f, -3.34210128e-01f, 3.87520224e-01f, 3.18446279e-01f, -8.63338709e-02f, 2.18215898e-01f, -1.35134608e-01f,
  1.19933248e-01f, -1.34309217e-01f, 3.58310282e-01f, 1.10765129e-01f, 3.22659314e-01f, 3.41108054e-01f, -4.66309130e-01f, -2.28192583e-01f, 4.02637601e-01f, 3.29421341e-01f,
  3.00738420e-02f, -2.59601682e-01f, 1.57483056e-01f, 3.06167096e-01f, 1.83517039e-01f, 4.13294733e-02f, 3.80931459e-02f, 8.42380002e-02f, 4.64961231e-02f, -5.28916111e-03f,
  -4.69678156e-02f, 1.41828865e-01f, 5.50874323e-02f, 1.52912617e-01f, 2.14904509e-02f, 2.45519131e-01f, 3.27499688e-01f, -1.69154599e-01f, 3.12514275e-01f, -4.57605794e-02f,
  -7.89600238e-02f, 6.52991012e-02f, 7.47377099e-03f, 1.66616201e-01f, 2.33913511e-01f, 2.30033118e-02f, -2.86457408e-02f, 1.41251281e-01f, -1.61019757e-01f, -2.35265791e-02f,
  -2.43486151e-01f, 3.50570083e-01f, -3.76900852e-01f, 2.06179261e-01f, -1.17271110e-01f, 2.73968130e-01f, 8.77863094e-02f, -9.08710212e-02f, 5.00810929e-02f, 7.71898264e-03f,
  -2.11458758e-01f, 3.67071331e-01f, 1.18382193e-01f, 3.11858594e-01f, 3.42198640e-01f, -3.92650999e-02f, 6.42491728e-02f, 1.50593385e-01f, 2.23687086e-02f, 3.37779254e-01f,
  -2.00308010e-01f, 2.70817548e-01f, -1.19175129e-01f, -9.00658518e-02f, -1.74726006e-02f, -1.68026373e-01f, 3.59154701e-01f, 4.27999228e-01f, 5.96259683e-02f, 3.17127347e-01f,
  2.10403264e-01f, 3.17603588e-01f, -9.39520374e-02f, -1.61588043e-02f, 4.28205162e-01f, 6.61709905e-02f, -2.81746626e-01f, 2.09200203e-01f, -6.34988174e-02f, 1.56533256e-01f,
  -3.61610092e-02f, 2.66032014e-02f, 4.01550494e-02f, -8.03704113e-02f, -5.45578478e-05f, -6.04602881e-03f, 3.09059564e-02f, 2.89677948e-01f, 1.45580709e-01f, 9.47930440e-02f,
  2.08994314e-01f, 4.17887904e-02f, -1.03250621e-02f, 9.97933969e-02f, 2.25217596e-01f, 2.85980314e-01f, 1.47957444e-01f, 1.45201907e-01f, 2.11710334e-01f, 1.21696450e-01f,
  1.89413186e-02f, 9.50642601e-02f, 1.70597389e-01f, 2.27952361e-01f, 3.25395375e-01f, 1.44760668e-01f, -2.60909438e-01f, -9.96565223e-02f, 8.89286324e-02f, -3.32418233e-01f,
  2.66305506e-01f, 8.69666189e-02f, -2.78394192e-01f, 1.94007635e-01f, 6.13830378e-03f, 4.89997193e-02f, 4.73175608e-02f, -1.50323570e-01f, 3.19730639e-02f, 2.92529762e-01f,
  1.12180963e-01f, 1.37339771e-01f, 3.72183346e-03f, -3.86592327e-03f, 3.95280927e-01f, -1.89351708e-01f, 1.12243086e-01f, 1.50032163e-01f, -9.47360992e-02f, -2.33663227e-02f,
  1.90542847e-01f, 3.07523031e-02f, 3.27931643e-01f, -1.09073386e-01f, 4.44013812e-03f, 3.36418599e-01f, 2.71366119e-01f, 2.79210240e-01f, 1.34024441e-01f, 1.54705852e-01f,
  1.79501355e-01f, 1.47261053e-01f, -1.07633643e-01f, -1.56744018e-01f, -7.43291974e-02f, 1.56830013e-01f, -1.53390020e-01f, 2.91303813e-01f, -5.47589734e-03f, 2.08401680e-01f,
  2.35579982e-01f, 2.73710847e-01f, 5.62476255e-02f, -7.86067694e-02f, 1.37629554e-01f, 8.18213634e-03f, 3.19052972e-02f, 2.55804434e-02f, 2.22851261e-01f, 3.16187404e-02f,
  -1.19329490e-01f, 1.01517051e-01f, 6.59007803e-02f, 6.54344112e-02f, 3.92678529e-02f, -1.73505947e-01f, 2.65026003e-01f, 3.46082538e-01f, -1.63299814e-01f, 1.97670326e-01f,
  3.20467532e-01f, 4.41948980e-01f, -4.52267379e-02f, 3.10287565e-01f, 1.77432999e-01f, -4.35132146e-01f, 1.78160787e-01f, -3.48671556e-01f, -2.01828226e-01f, -1.13020167e-01f,
  9.24182385e-02f, 1.01454914e-01f, 2.31043592e-01f, -3.66733447e-02f, -1.86092600e-01f, -1.58054054e-01f, -7.95618892e-02f, 3.12866926e-01f, 2.70176381e-01f, 2.73897588e-01f,
  1.95544198e-01f, 3.52965593e-01f, -1.05347298e-01f, 4.25567627e-01f, -1.12654142e-01f, 2.42823452e-01f, 4.12829399e-01f, 3.47372778e-02f, 4.87119317e-01f, 1.61388054e-01f,
  1.17658027e-01f, 1.46988690e-01f, 1.93369895e-01f, -2.47938186e-01f, 2.58485302e-02f, -9.45764482e-02f, -2.96890680e-02f, 1.65943444e-01f, 1.97701007e-01f, 1.30252317e-01f,
  3.35798353e-01f, -2.94118762e-01f, 4.51618701e-01f, -8.30654334e-03f, 6.56740516e-02f, -2.74420559e-01f, -3.15810554e-02f, -1.92215115e-01f, 9.80388969e-02f, 2.21613601e-01f,
  2.04106376e-01f, 1.37003601e-01f, 1.03570268e-01f, 8.39393362e-02f, 3.43868554e-01f, -1.33584822e-02f, 5.57439774e-02f, -1.80583838e-02f, -7.81571493e-02f, 1.80472523e-01f,
  -2.80773610e-01f, 4.35200706e-02f, -3.30280751e-01f, -2.38470659e-01f, 1.17038593e-01f, -2.50198066e-01f, 7.23639876e-02f, 1.57440901e-01f, 2.25662455e-01f, 3.04809753e-02f,
  1.23706073e-01f, 1.42459214e-01f, -1.08446211e-01f, 3.02637428e-01f, 3.69475126e-01f, 2.62551665e-01f, 2.70701442e-02f, -2.86577679e-02f, 2.49555960e-01f, -1.35046259e-01f,
  -6.59811124e-02f, 2.04482898e-01f, 1.03148624e-01f, 2.77255505e-01f, -7.07688704e-02f, 1.96547255e-01f, 3.17969263e-01f, 9.56309140e-02f, 4.54061776e-01f, 1.99872255e-01f,
  -8.82044714e-03f, 3.11306953e-01f, -3.23451072e-01f, 2.27601416e-02f, 5.30630350e-01f, -7.80432373e-02f, 1.85523912e-01f, -2.02892870e-01f, 3.31622601e-01f, 1.48027256e-01f,
  2.05617994e-01f, 1.32196203e-01f, 1.29678072e-02f, -1.93481848e-01f, -1.94518998e-01f, -1.30103767e-01f, -1.05501503e-01f, -1.72643010e-02f, -7.07775280e-02f, 2.37566814e-01f,
  2.09428638e-01f, 1.42293811e-01f, 2.84507751e-01f, -4.41144258e-02f, 6.96733370e-02f, 1.07681833e-01f, 8.44273940e-02f, -1.05280504e-01f, 1.79529801e-01f, 7.21677095e-02f,
  2.56846011e-01f, -2.75863595e-02f, -7.14891627e-02f, 6.83064833e-02f, 1.23460352e-01f, 1.44176736e-01f, -6.74976176e-03f, -3.38449806e-01f, 1.94122598e-01f, -2.96164423e-01f,
  8.64065345e-03f, -1.58636972e-01f, 1.21579960e-01f, 1.64657772e-01f, -9.29026455e-02f, 1.44136369e-01f, 1.99489936e-01f, -2.44097441e-01f, 5.59115335e-02f, -2.68680323e-02f,
  -3.65615726e-01f, -2.65140105e-02f, -1.53543595e-02f, 1.35740668e-01f, -1.52027071e-01f, -1.45822763e-01f, 7.70774856e-02f, 4.84432667e-01f, -1.26242056e-01f, -1.29043544e-02f,
  -1.50514869e-02f, -1.13084763e-01f, -3.59677017e-01f, 3.32443714e-01f, 2.64451325e-01f, 1.39499888e-01f, 3.96636724e-02f, -2.97386914e-01f, 3.51113617e-01f, -1.11788772e-02f,
  1.25318035e-01f, -2.47162029e-01f, 3.33945602e-01f, 1.27669185e-01f, -7.83201754e-02f, -1.16353735e-01f, 2.22939953e-01f, 2.35074069e-02f, -1.58795342e-01f, -1.66222945e-01f,
  -3.07411641e-01f, -8.31392035e-03f, 8.78935903e-02f, 5.75617589e-02f, 1.28368810e-01f, 1.87041193e-01f, 3.22739869e-01f, -2.34100863e-01f, -1.43884365e-02f, 8.85666907e-02f,
  6.85251877e-02f, -6.97269291e-02f, 2.10275844e-01f, 7.77083933e-02f, 1.39089555e-01f, 1.23997554e-01f, 1.64722160e-01f, -4.00537886e-02f, -1.41330093e-01f, 1.84071937e-03f,
  -2.35208869e-01f, -1.75754115e-01f, 3.68580610e-01f, -1.68806948e-02f, -1.02561459e-01f, -1.00319609e-01f, -1.34876296e-01f, 8.85344669e-02f, 1.78128123e-01f, 6.48169518e-02f,
  2.48804271e-01f, -1.23325266e-01f, 2.84723699e-01f, 1.40730351e-01f, -5.22906100e-03f, -4.11397219e-02f, 6.83291331e-02f, 6.19358085e-02f, -1.16277352e-01f, 2.78092474e-01f,
  -2.35217303e-01f, 2.46125743e-01f, -1.22342426e-02f, 2.24476814e-01f, 2.50025302e-01f, 2.20694229e-01f, 4.11348417e-02f, -3.23374718e-01f, -9.86330435e-02f, -1.12143524e-01f,
  -1.63404226e-01f, -1.57011807e-01f, 2.06398740e-01f, 1.44130692e-01f, -9.16962400e-02f, -2.81487964e-02f, 1.52607501e-01f, 1.87178031e-01f, 2.09877327e-01f, 1.47411190e-02f,
  2.14721173e-01f, -2.05958840e-02f, -2.80554384e-01f, -8.20565447e-02f, -3.30265164e-02f, 2.84925640e-01f, 1.62772551e-01f, -4.08180915e-02f, 1.16060771e-01f, -1.00962907e-01f,
  2.27777869e-01f, -2.16694772e-01f, 6.88944235e-02f, 2.91950908e-02f, 1.38436615e-01f, -4.00989838e-02f, 1.84504002e-01f, -5.35856001e-02f, 1.26665473e-01f, 2.93961773e-03f,
  5.03094308e-02f, 9.60284844e-02f, -9.87332091e-02f, -1.52222201e-01f, 4.60905507e-02f, -2.08876371e-01f, 2.83400983e-01f, -2.71382093e-01f, -1.02468543e-01f, 1.29428491e-01f,
  -1.99716181e-01f, 2.63908952e-01f, -5.80803398e-03f, 9.00445953e-02f, 1.17413476e-01f, -2.02746559e-02f, -1.37009338e-01f, 1.76014528e-01f, 1.29570693e-01f, 8.03738832e-02f,
  5.05415201e-02f, 6.71746805e-02f, 4.98712212e-02f, 2.58709371e-01f, -3.11490268e-01f, 8.97136629e-02f, 2.22286344e-01f, -1.31460980e-01f, 3.00631076e-01f, -7.18210042e-02f,
  -1.52366944e-02f, -2.65115559e-01f, -7.40823895e-02f, 5.29260039e-02f, -2.54679888e-01f, -9.45701301e-02f, -3.43113486e-03f, -6.66441023e-02f, -7.79435458e-03f, 9.43615660e-02f,
  1.71796426e-01f, 5.38488999e-02f, 4.21544239e-02f, -1.15738638e-01f, 2.58910328e-01f, -1.89633459e-01f, 9.74532217e-02f, 1.78620666e-01f, -1.41355107e-02f, 2.22927094e-01f,
  2.08281294e-01f, 7.50859380e-02f, 2.31044684e-02f, -1.41359553e-01f, 1.93523005e-01f, 1.89946443e-01f, -2.42070239e-02f, 6.42131865e-02f, 1.19838538e-02f, -1.30676493e-01f,
  -1.13662481e-01f, 1.72803894e-01f, 8.98817405e-02f, 9.96711329e-02f, 1.68248057e-01f, 2.38499001e-01f, -1.96364596e-02f, 2.27442607e-01f, -1.30483523e-01f, -1.58532470e-01f,
  -1.67880982e-01f, -1.87917411e-01f, 6.83070347e-02f, 2.13593990e-02f, -3.06256324e-01f, 1.48942396e-01f, -8.09557661e-02f, 1.17523216e-01f, 3.41248780e-01f, -1.64871976e-01f,
  2.76543438e-01f, -1.25335395e-01f, -8.62708017e-02f, -1.39517814e-01f, 1.14821240e-01f, 7.26549476e-02f, 2.84670383e-01f, -8.62410069e-02f, -2.62847692e-02f, -2.16945529e-01f,
  -1.29357681e-01f, 1.16979823e-01f, 8.30703974e-02f, -7.69483447e-02f, -1.43900424e-01f, 2.64758885e-01f, 1.89396694e-01f, 3.09326559e-01f, -3.49075496e-02f, -1.63486078e-01f,
  3.08485806e-01f, -3.07958484e-01f, -6.38021752e-02f, 2.24632561e-01f, 2.40676552e-01f, 6.11344911e-03f, 2.11216465e-01f, 2.32692882e-01f, -1.41492914e-02f, 1.92010790e-01f,
  1.17368743e-01f, 2.13910900e-02f, 2.91558444e-01f, -3.22976485e-02f, 1.31183248e-02f, 2.09525954e-02f, 3.66777837e-01f, 3.23545367e-01f, 1.23759530e-01f, 2.64106154e-01f,
  6.41050339e-02f, 2.26655036e-01f, 1.13945767e-01f, -8.08193237e-02f, -5.42654917e-02f, 1.03161253e-01f, 1.05848007e-01f, 1.77903906e-01f, 6.93800971e-02f, 1.23978436e-01f,
  2.06561700e-01f, 1.56050399e-01f, -9.97491926e-02f, -1.65412590e-01f, -1.03007713e-02f, -7.09275976e-02f, -2.78490633e-01f, 2.18846247e-01f, -4.07875061e-01f, 3.20227891e-01f,
  2.21216008e-02f, 1.36571437e-01f, 2.95942128e-01f, -2.93830514e-01f, 5.01970798e-02f, 1.54691011e-01f, 2.11091131e-01f, 2.00285137e-01f, -4.70694005e-02f, 8.94511640e-02f,
  4.12651241e-01f, 2.14735523e-01f, -2.83209294e-01f, -1.80304423e-01f, 1.00586958e-01f, -1.72289908e-01f, 1.17371127e-01f, -1.95057943e-01f, -1.08068466e-01f, -1.39682636e-01f,
  -2.82263607e-01f, -3.89674753e-02f, 3.07233147e-02f, -1.56608984e-01f, -1.39917567e-01f, -4.59629335e-02f, -7.46869147e-02f, 3.98579299e-01f, 2.49789730e-01f, 8.71677250e-02f,
  3.57695967e-01f, 1.41220108e-01f, 2.14707538e-01f, 5.70234619e-02f, 3.77984405e-01f, 4.28754270e-01f, 4.34434950e-01f, 1.95798218e-01f, -3.93189490e-02f, -1.45464353e-02f,
  1.57861471e-01f, -5.22595644e-02f, -1.32551761e-02f, 3.56078953e-01f, 1.42228350e-01f, 1.68819666e-01f, 1.05483674e-01f, 2.94919491e-01f, 2.35905588e-01f, 2.43996054e-01f,
  4.05164026e-02f, 5.67262480e-03f, 9.80200171e-02f, 2.66860351e-02f, -1.51370298e-02f, -4.13495563e-02f, 2.11333454e-01f, 4.08381969e-02f, -1.42644653e-02f, -1.45212039e-01f,
  3.57648246e-02f, -1.37740105e-01f, 2.83742934e-01f, 1.69520099e-02f, -7.89368078e-02f, -1.78375259e-01f, -1.85203657e-01f, 1.77019835e-01f, 4.90674675e-02f, 2.76291847e-01f,
  1.27345338e-01f, 2.92400658e-01f, 1.11223675e-01f, 7.73854852e-02f, -1.36481756e-02f, 2.28311777e-01f, 5.96457496e-02f, 2.25393668e-01f, 3.19670528e-01f, 1.54769672e-02f,
  3.02262604e-02f, 3.55940431e-01f, 3.05803180e-01f, -2.87564784e-01f, 7.61808977e-02f, -4.47752699e-02f, -2.01018661e-01f, 2.11710155e-01f, -4.15780731e-02f, 2.82034010e-01f,
  5.36152767e-03f, 2.78776854e-01f, 1.82106137e-01f, 1.60008088e-01f, -1.33401394e-01f, -3.19541454e-01f, 2.37359494e-01f, -4.90469001e-02f, -8.82737711e-03f, 2.56804585e-01f,
  -1.40093029e-01f, 1.70347646e-01f, 2.24454671e-01f, 3.74704808e-01f, -9.09893289e-02f, 1.42002394e-02f, 4.21948843e-02f, 5.08649610e-02f, 1.90744817e-01f, 1.51291966e-01f,
  3.13235335e-02f, 3.29934925e-01f, 1.12382911e-01f, 1.94308072e-01f, 6.89343363e-02f, 1.50994629e-01f, 1.65258169e-01f, 1.50210291e-01f, 2.19430789e-01f, 6.31571040e-02f,
  3.51904988e-01f, 1.46206737e-01f, 9.04616266e-02f, -1.88916132e-01f, 1.12423167e-01f, -2.86127716e-01f, 1.83890104e-01f, -3.40099260e-03f, 1.38219148e-01f, -2.19458982e-01f,
  2.86191795e-02f, -2.58640219e-02f, 1.05528871e-03f, -1.24286339e-02f, -6.62850291e-02f, 3.56887937e-01f, 1.57317922e-01f, 1.63882196e-01f, 6.48166891e-03f, -2.92989671e-01f,
  4.92637940e-02f, 2.35652387e-01f, 2.23748475e-01f, 1.33393019e-01f, 9.26880091e-02f, 3.24551642e-01f, 9.28883255e-02f, -2.23689511e-01f, -1.83589473e-01f, -1.74516335e-01f,
  1.87920287e-01f, 2.48272181e-01f, -2.09740311e-01f, 2.69981086e-01f, 7.14722648e-03f, 2.15910763e-01f, 1.01458989e-01f, 3.31382513e-01f, 1.20732963e-01f, -2.06055373e-01f,
  3.80483896e-01f, -5.81674539e-02f, -8.67427960e-02f, 3.62268269e-01f, -1.62639156e-01f, 1.40845791e-01f, 8.95287842e-02f, 3.09434891e-01f, -2.16548294e-01f, -4.58288714e-02f,
  -9.17604640e-02f, 3.17534283e-02f, 1.68411151e-01f, 2.05913648e-01f, -9.03647684e-04f, 1.68791950e-01f, 1.55488728e-02f, 2.12636337e-01f, 1.92770466e-01f, 1.15468882e-01f,
  2.54001290e-01f, 3.54692698e-01f, 7.36031234e-02f, 2.52938233e-02f, 3.57386976e-01f, 3.60789537e-01f, -3.90131652e-01f, -1.43625915e-01f, 2.22175777e-01f, -3.61392409e-01f,
  5.32681309e-02f, 2.53140122e-01f, 1.73221044e-02f, 5.27334511e-02f, -1.30600616e-01f, 3.73811126e-01f, -1.68857738e-01f, 9.06019658e-02f, 1.57148734e-01f, 2.88748503e-01f,
  2.43224725e-01f, 2.98458457e-01f, -6.43278658e-02f, 5.45808561e-02f, 2.75016040e-01f, -1.58314109e-01f, 2.50344396e-01f, 1.74744724e-04f, -9.07444358e-02f, 1.09436341e-01f,
  2.64934778e-01f, 4.75793928e-02f, -2.18047239e-02f, 5.84953576e-02f, -2.36345306e-01f, 2.58190095e-01f, -1.28990952e-02f, 3.88774574e-01f, 2.19020203e-01f, 5.53889759e-02f,
  -7.90408328e-02f, 2.23283023e-01f, 6.01508990e-02f, -1.77772865e-01f, 4.47309352e-02f, -1.11569136e-01f, 1.03938647e-01f, 1.36534318e-01f, -1.51714295e-01f, 2.18756907e-02f,
  6.61106035e-02f, 3.88668269e-01f, -1.54655948e-01f, 2.55986780e-01f, -1.33758545e-01f, -4.97231707e-02f, 1.86087638e-02f, 1.08049169e-01f, 1.04058310e-01f, 1.48415893e-01f,
  2.42309839e-01f, 1.43914729e-01f, 6.43810332e-02f, 1.93706781e-01f, 8.09438974e-02f, 1.38514832e-01f, 1.22439815e-02f, 1.23297565e-01f, 2.65426785e-01f, 4.76468168e-02f,
  -8.78327340e-02f, -3.04987013e-01f, 1.35112301e-01f, -2.25317657e-01f, -9.49944034e-02f, 1.75464407e-01f, -1.39562562e-01f, 1.68811977e-01f, -5.55369817e-03f, -5.54204769e-02f,
  -6.18082508e-02f, 3.92480381e-02f, 1.54012237e-02f, 3.64143759e-01f, 1.61471620e-01f, 1.40035510e-01f, 5.96922934e-02f, -1.63803697e-01f, 9.60858837e-02f, -2.86634237e-01f,
  1.06481366e-01f, -1.41995624e-01f, 3.29505235e-01f, 4.56919968e-02f, 3.09561998e-01f, -5.28332889e-02f, 2.78796647e-02f, -2.95855608e-02f, -1.92818210e-01f, -2.75237206e-03f,
  1.60589516e-01f, 1.84814051e-01f, 3.74759771e-02f, 2.28522792e-01f, 3.55996281e-01f, 2.27212235e-02f, -7.94989523e-03f, -1.78628236e-01f, 2.03821704e-01f, 2.64122132e-02f,
  9.58077312e-02f, 4.15856004e-01f, -1.86606213e-01f, 2.30056673e-01f, 3.38141501e-01f, 2.69162655e-01f, 6.49633929e-02f, 1.12061657e-01f, 4.09304909e-03f, 5.73801845e-02f,
  2.06915408e-01f, 2.26253912e-01f, -8.80811363e-02f, 2.01399714e-01f, 6.24987334e-02f, 2.26662770e-01f, -6.53935447e-02f, 2.69204788e-02f, -6.64432421e-02f, 5.69136366e-02f,
  7.19738007e-02f, -6.50272369e-02f, -6.66949451e-02f, 9.35900137e-02f, -2.80007899e-01f, 1.33827075e-01f, 1.64907068e-01f, 5.88033050e-02f, 1.91857770e-01f, -3.57572198e-01f,
  -2.57432759e-01f, -2.35152349e-01f, -4.73101228e-01f, 2.92187154e-01f, 3.57617527e-01f, 1.79506272e-01f, 1.31061049e-02f, 9.92530733e-02f, 1.22205488e-01f, -4.38292980e-01f,
  2.52762347e-01f, -1.32588178e-01f, 3.01704437e-01f, 4.49943066e-01f, -2.67294198e-02f, 3.24919701e-01f, 1.06063625e-02f, 7.14490488e-02f, 4.66862798e-01f, 3.75724316e-01f,
  3.26741695e-01f, 2.12113127e-01f, 2.60059368e-02f, 1.17332533e-01f, 1.98178083e-01f, -4.50357646e-02f, 1.43800648e-02f, 2.59824079e-02f, -5.78288734e-03f, 8.56630951e-02f,
  9.13860872e-02f, 2.94354796e-01f, -6.84722885e-02f, 5.59565835e-02f, -2.65660614e-01f, 1.30597815e-01f, -1.77172542e-01f, -1.72805056e-01f, 5.06062917e-02f, 2.78187811e-01f,
  -3.20755760e-03f, 2.82434344e-01f, -1.04396939e-02f, -1.61794037e-01f, 1.83044091e-01f, -6.65059686e-02f, 7.66134411e-02f, -1.45090729e-01f, -6.41236901e-02f, 1.97093144e-01f,
  -3.30471201e-03f, 1.81654230e-01f, 1.70077682e-01f, 1.07035473e-01f, 2.30401754e-01f, 1.90569073e-01f, -1.95876032e-01f, 9.77219641e-02f, -1.50344998e-01f, 3.85723472e-01f,
  -2.09992558e-01f, 2.58930415e-01f, -1.20445199e-01f, 9.09900367e-02f, 4.49901596e-02f, 1.12485357e-01f, -9.35672447e-02f, 1.22553162e-01f, 7.85838291e-02f, 1.67979583e-01f,
  2.17353359e-01f, -2.68554538e-01f, -2.09614545e-01f, 2.01484442e-01f, -1.63638256e-02f, 3.50805819e-01f, 4.55470346e-02f, -3.17609459e-02f, 5.59224971e-02f, 1.54899076e-01f,
  -3.45286787e-01f, -3.09799552e-01f, -2.54329115e-01f, 1.09174877e-01f, 9.96202528e-02f, 1.01738181e-02f, 3.87156636e-01f, 1.12231836e-01f, 1.50907189e-01f, 6.12127334e-02f,
  3.37218851e-01f, -1.71143472e-01f, -7.48321861e-02f, 7.16854632e-02f, 5.68811335e-02f, 3.82319987e-01f, -4.31008041e-02f, 3.92284811e-01f, 1.78286254e-01f, -2.80197263e-01f,
  2.89175898e-01f, -2.01562960e-02f, -1.64258569e-01f, 1.21163584e-01f, 1.38793290e-01f, -4.60581258e-02f, 1.72150001e-01f, 2.45309725e-01f, 1.01869784e-01f, 9.28030163e-03f,
  1.94105551e-01f, -4.03220020e-02f, 2.51085281e-01f, 1.48107782e-01f, -5.33011695e-03f, 1.13335706e-01f, 1.86377823e-01f, 1.48202464e-01f, 1.36187240e-01f, 1.39230415e-01f,
  1.60005793e-01f, -9.72150192e-02f, 3.39729428e-01f, -6.01866916e-02f, 1.85630843e-01f, -1.04509428e-01f, 3.56230527e-01f, -1.85911685e-01f, -2.65022218e-01f, 4.92041893e-02f,
  -5.61521277e-02f, 2.24996731e-01f, 2.96245366e-01f, 1.33781061e-01f, -1.16096698e-01f, 1.67192578e-01f, 1.41131245e-02f, -1.78159013e-01f, -3.18159193e-01f, -8.22497085e-02f,
  4.42275256e-01f, 3.06228131e-01f, 2.39545137e-01f, 2.45652616e-01f, -6.74526161e-03f, 4.44004595e-01f, 2.31303900e-01f, -4.65221740e-02f, 3.89130712e-01f, -1.60115026e-02f,
  8.44513252e-02f, 2.23190099e-01f, 4.19792831e-01f, 1.48149282e-02f, -1.50104417e-02f, -2.30662718e-01f, 3.50921094e-01f, 8.80328938e-03f, -8.43402073e-02f, -1.08806141e-01f,
  4.16353531e-02f, 1.49894893e-01f, -3.10020655e-01f, -2.18509719e-01f, 6.54798970e-02f, 1.65515780e-01f, 4.39843476e-01f, 8.42873007e-02f, 9.04435590e-02f, -8.84566754e-02f,
  5.25710844e-02f, -7.98880979e-02f, 1.56866774e-01f, 7.24546254e-01f, -4.14554551e-02f, -2.76549757e-02f, 2.45037720e-01f, -2.65116423e-01f, 5.34612000e-01f, -1.53804272e-01f,
  1.30355179e-01f, 1.84652016e-01f, 1.10429235e-01f, -2.40880027e-01f, -5.16782343e-01f, 1.21069483e-01f, 4.71927583e-01f, -5.85420012e-01f, 1.36037901e-01f, 1.22966200e-01f,
  2.07111910e-01f, 5.62445462e-01f, 6.00678980e-01f, -2.92889297e-01f, 3.15109313e-01f, -1.19351231e-01f, -4.69803065e-01f, 3.59140575e-01f, 2.82691449e-01f, -1.35205919e-02f,
  5.79291284e-01f, 2.78824002e-01f, -2.76960254e-01f, 4.95690286e-01f, -6.82668507e-01f, 1.07664084e+00f, 2.69679099e-01f, -1.66211918e-01f, 6.20301329e-02f, 1.56843230e-01f,
  -1.10846356e-01f, 5.47484457e-01f, -6.66977525e-01f, 5.28860986e-01f, 2.88072857e-03f, -4.66822594e-01f, -2.97490746e-01f, 3.51714104e-01f, 6.12698384e-02f, -2.33029366e-01f,
  -9.62442681e-02f, 2.53542185e-01f, 5.07176161e-01f, 5.74193150e-02f, 4.63335663e-01f, -2.92678297e-01f, 4.36223358e-01f, 3.36262099e-02f, 3.44485372e-01f, -4.77833658e-01f,
  -3.19077671e-01f, -2.94467688e-01f, -2.49830648e-01f, 5.37585378e-01f, 1.05543151e-01f, -4.76867780e-02f, -6.67567626e-02f, -6.45545721e-02f, 1.45394325e-01f, -1.25178387e-02f,
  -3.25360112e-02f, 1.12382062e-01f, 1.05195373e-01f, 2.04211771e-01f, 3.64208631e-02f, 3.47507372e-02f, 2.53794432e-01f, 1.17842928e-01f, 1.64003968e-01f, -2.34960720e-01f,
  1.66123714e-02f, 8.28008130e-02f, -1.13864020e-01f, -2.44962960e-01f, -2.70210892e-01f, 4.80414703e-02f, -2.65450358e-01f, 2.12475881e-01f, 2.40751863e-01f, 3.50053119e-03f,
  1.07227430e-01f, -1.91243231e-01f, -4.25860956e-02f, 5.88327460e-02f, -8.23355094e-02f, 1.46872714e-01f, 1.26577765e-01f, -1.41877204e-01f, 1.96271375e-01f, -3.05732727e-01f,
  1.87565293e-02f, 1.35093138e-01f, 1.70479883e-02f, -1.33633101e-02f, -1.76548362e-01f, -1.57951921e-01f, 2.78493255e-01f, -4.85648066e-02f, 2.82951266e-01f, 1.29452914e-01f,
  1.91415906e-01f, -7.65474886e-02f, 1.67425454e-01f, 2.65915036e-01f, 2.36178204e-01f, -3.95622384e-03f, -2.62566749e-02f, 2.39552096e-01f, 6.24694824e-02f, 3.57422203e-01f,
  1.14728257e-01f, 1.07313739e-02f, 3.31893355e-01f, 1.89003736e-01f, 2.68780380e-01f, 6.94420785e-02f, 9.78257135e-02f, -1.93665981e-01f, 8.25761929e-02f, 2.72335559e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  8.31693783e-02f, 1.83063403e-01f, 2.28103604e-02f, 1.76167443e-01f, 1.64438844e-01f, 2.02753320e-01f, 2.02269673e-01f, 2.44034946e-01f, 6.10998049e-02f, 1.80409491e-01f,
  1.08546183e-01f, 2.37662658e-01f, 8.23923647e-02f, -5.19883633e-02f, 2.07068786e-01f, 8.94792247e-05f, 2.27385327e-01f, 8.32058564e-02f, 2.01449201e-01f, 9.42587852e-02f,
  7.27771665e-04f, 9.86490548e-02f, 1.63270280e-01f, 5.75815188e-03f, 1.53390616e-01f, 5.50640635e-02f, 5.36804460e-02f, 1.33327901e-01f, 1.59805566e-01f, 1.32126763e-01f,
  2.09903374e-01f, 2.24002793e-01f, 1.02369174e-01f, 1.28187137e-02f, 1.22403637e-01f, 1.81494966e-01f, 1.48083389e-01f, 2.39051491e-01f, 7.67770559e-02f, 2.33600765e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  3.74634527e-02f, -1.20646454e-01f, 1.04918163e-02f, -1.78512335e-01f, 5.87117560e-02f, -5.09465933e-02f, 9.62373894e-03f, 9.66890380e-02f, 2.48098262e-02f, -2.96160039e-02f,
  3.25034261e-02f, -1.53485015e-01f, -7.15381056e-02f, -7.80157372e-02f, 1.25493735e-01f, 1.88368306e-01f, 2.85925679e-02f, -9.73826498e-02f, 4.21146542e-01f, -1.91009045e-01f,
  -3.28828096e-01f, -6.29426911e-02f, -1.70295030e-01f, 2.70363837e-01f, -8.78721029e-02f, 2.15933338e-01f, 4.82027568e-02f, -3.05583626e-01f, 1.16702005e-01f, -2.03784928e-01f,
  -4.02585775e-01f, 3.00660878e-01f, -3.68175745e-01f, -3.24090272e-01f, -3.39821279e-01f, -2.26074815e-01f, 2.60877639e-01f, 2.81609982e-01f, -4.33190465e-02f, -3.31448734e-01f,
  1.34065561e-03f, -2.51876861e-01f, 3.05382252e-01f, 2.09787861e-01f, -2.02162445e-01f, -4.94748414e-01f, -2.79813766e-01f, 1.36063576e-01f, -3.87599349e-01f, -3.74120653e-01f,
  -5.39901614e-01f, -1.96712717e-01f, 1.90528527e-01f, 3.38039957e-02f, 3.51126343e-01f, 1.32457078e-01f, 1.28919959e-01f, -9.30914283e-03f, 2.65058070e-01f, -1.38160780e-01f,
  -2.60528475e-01f, -4.38726425e-01f, -1.12321591e+00f, 2.02674776e-01f, 5.00534810e-02f, -2.63006061e-01f, 1.56941786e-02f, 2.14448780e-01f, 2.87413113e-02f, -4.70822640e-02f,
  6.82283491e-02f, -1.32116094e-01f, 3.34495232e-02f, 4.32130508e-02f, 7.23936632e-02f, 4.32179235e-02f, -1.79250669e-02f, -2.71096379e-01f, -4.11792576e-01f, -1.07821353e-01f,
  9.76976305e-02f, 3.07745010e-01f, -2.62700379e-01f, -1.99455246e-01f, -1.64711565e-01f, -3.26271623e-01f, 1.77259535e-01f, 1.18355289e-01f, -4.56640482e-01f, 1.97007204e-03f,
  2.00292587e-01f, -1.36119768e-01f, -3.51725101e-01f, -6.82929873e-01f, -2.05082044e-01f, -1.42959639e-01f, -2.26476878e-01f, 2.20635310e-01f, -5.87965883e-02f, 2.66180724e-01f,
  5.37924826e-01f, 1.30650327e-01f, -2.77740747e-01f, -1.48412868e-01f, -1.62134781e-01f, -2.69118324e-02f, 2.57351249e-01f, 6.94602281e-02f, 2.50740051e-01f, 1.63050532e-01f,
  -3.19559216e-01f, 2.71028727e-02f, -3.15021813e-01f, 7.77232498e-02f, 2.18609497e-01f, 3.61748964e-01f, 2.69020021e-01f, 9.34362635e-02f, -4.03156057e-02f, -1.86745524e-02f,
  -9.60978568e-02f, -2.20691234e-01f, 1.98122442e-01f, -3.89130682e-01f, -1.62556902e-01f, 1.39209837e-01f, -6.49103284e-01f, 1.54538840e-01f, -9.08701569e-02f, 1.33966133e-01f,
  -1.61635682e-01f, 4.27399091e-02f, -1.56020805e-01f, 3.56907845e-02f, 6.40626997e-02f, 1.14901543e-01f, 1.07974268e-01f, 8.45847279e-02f, -1.09935224e-01f, -1.96275204e-01f,
  -2.57752597e-01f, -8.40853751e-02f, -1.94715962e-01f, -2.06368819e-01f, 1.41787767e-01f, 2.59994924e-01f, -1.83870271e-01f, -1.91813499e-01f, -8.98293555e-02f, 1.52696326e-01f,
  -2.74626464e-01f, -2.51431525e-01f, 3.78203690e-02f, -1.65425360e-01f, 2.55807728e-01f, -2.56492794e-01f, -3.39446902e-01f, -2.74757653e-01f, -1.31404743e-01f, -3.62313896e-01f,
  -6.78988397e-01f, 4.61571589e-02f, 1.91475973e-01f, -1.66335642e-01f, -5.10408700e-01f, 1.44705236e-01f, -4.12292600e-01f, -2.72465020e-01f, 1.28705483e-02f, 2.27655515e-01f,
  -2.82506555e-01f, 2.90708244e-01f, -1.41610339e-01f, 1.72999412e-01f, -1.82632595e-01f, 2.41086274e-01f, 8.17661360e-02f, 9.84304771e-02f, 3.82027954e-01f, -2.32119367e-01f,
  -3.34959894e-01f, 2.16466323e-01f, -4.28783566e-01f, -1.85844958e-01f, -4.18243974e-01f, -1.43936098e-01f, -3.67162190e-02f, 3.42619300e-01f, 1.65091112e-01f, 2.49235511e-01f,
  -1.51589632e+00f, 1.78618923e-01f, -2.51929034e-02f, 1.07336923e-01f, -1.23289734e-01f, 2.06133083e-01f, -2.11011339e-02f, -1.80611849e-01f, -2.34537050e-01f, 1.62351727e-02f,
  7.53821209e-02f, -5.40581159e-02f, 7.29211122e-02f, 4.09613625e-04f, 2.97709644e-01f, -2.66228110e-01f, 1.93151385e-01f, 1.52459711e-01f, -3.02843422e-01f, -2.76313484e-01f,
  1.09091178e-01f, -2.24587262e-01f, 1.60845041e-01f, -3.03931572e-02f, 2.48021618e-01f, -2.43381187e-02f, 2.19691634e-01f, -2.13227153e-01f, -5.58282137e-01f, -8.82717967e-03f,
  2.74640977e-01f, 2.44414926e-01f, 1.11594304e-01f, 2.10712433e-01f, 3.01929921e-01f, 5.52972853e-02f, 1.73626542e-01f, -1.56872496e-01f, -5.95159173e-01f, -2.23578826e-01f,
  -3.57417800e-02f, -3.88501555e-01f, -3.87792349e-01f, -2.87164241e-01f, 1.33723810e-01f, -2.95841724e-01f, -2.02744275e-01f, -3.03358823e-01f, -6.13657990e-03f, -4.54500586e-01f,
  1.67500481e-01f, -4.97935086e-01f, -2.88040936e-01f, -3.53128910e-01f, -2.42893510e-02f, 7.39189535e-02f, 2.90239364e-01f, -4.53998625e-01f, -2.87839055e-01f, -5.19771218e-01f,
  -4.23905045e-01f, -4.86277550e-01f, 2.66647696e-01f, -2.86469996e-01f, 3.23685020e-01f, 8.12418535e-02f, 8.40992108e-02f, 2.25405861e-02f, -8.74345675e-02f, -2.65255064e-01f,
  8.79532695e-02f, 9.13495384e-03f, 8.66232812e-02f, 1.48255304e-01f, 1.64981872e-01f, 2.98828539e-02f, 4.45881225e-02f, 6.91392347e-02f, 9.12396461e-02f, 3.49628747e-01f,
  2.13663384e-01f, -4.93945926e-02f, 2.55275518e-02f, -3.70112546e-02f, -2.34219149e-01f, 2.09881395e-01f, 1.34013221e-01f, -2.91215390e-01f, -1.95273399e-01f, -2.29292847e-02f,
  -1.44635499e-01f, 2.10029244e-01f, 1.16130695e-01f, -2.32375890e-01f, -1.31974339e-01f, -1.81686180e-03f, 2.68490374e-01f, 1.77419782e-01f, 3.84055316e-01f, 1.50390029e-01f,
  1.16458662e-01f, -2.73728758e-01f, -4.35506284e-01f, 3.10889810e-01f, 2.20743954e-01f, -4.67000864e-02f, -1.50279969e-01f, -3.30137521e-01f, -2.74595171e-01f, 2.32248724e-01f,
  1.90240696e-01f, -2.55804390e-01f, 2.81313121e-01f, 1.62695453e-01f, -1.04555096e-02f, -4.24824238e-01f, -2.95802534e-01f, -1.83357939e-01f, -1.34880856e-01f, -1.27141520e-01f,
  -1.61082923e-01f, -5.11988252e-02f, 4.25400510e-02f, 8.09343383e-02f, -1.00734614e-01f, -1.64745212e-01f, 3.30894172e-01f, -1.11033998e-01f, -9.24482226e-01f, 1.70758620e-01f,
  -6.13524206e-02f, 1.68915510e-01f, 8.06528702e-02f, -1.46314248e-01f, -8.27928483e-02f, 5.37169091e-02f, -7.82343373e-03f, 6.04669601e-02f, 1.67994574e-01f, 6.22130148e-02f,
  -4.46387418e-02f, -7.87378177e-02f, 3.73478591e-01f, -1.81352139e-01f, 1.79995388e-01f, -3.73507924e-02f, -2.66315013e-01f, -4.63022321e-01f, -2.95984834e-01f, -9.49983969e-02f,
  -1.07358530e-01f, 6.44930527e-02f, -1.05564773e-01f, 2.44359761e-01f, -4.50978100e-01f, -5.35619296e-02f, -3.20137650e-01f, 3.32581967e-01f, 5.59131205e-02f, -1.03289828e-01f,
  -9.39488634e-02f, 1.97538003e-01f, -5.91677606e-01f, 1.26288131e-01f, 4.99611869e-02f, 3.39939058e-01f, -5.40498495e-01f, -8.56581703e-02f, 1.21978536e-01f, 1.78205878e-01f,
  1.00906588e-01f, -3.03800970e-01f, -6.42735139e-02f, -1.49405627e-02f, -3.49189699e-01f, 2.15341672e-01f, -3.37039053e-01f, 9.93070677e-02f, -4.90754843e-01f, -1.70109019e-01f,
  9.24919471e-02f, -4.85380506e-03f, 3.93557213e-02f, -1.52201504e-01f, 5.05241603e-02f, 1.02927387e-01f, 2.70874113e-01f, 2.76840359e-01f, 1.87844902e-01f, -4.63723749e-01f,
  -2.32602820e-01f, -1.90711841e-01f, 6.17798984e-01f, -1.62539244e-01f, 4.13470231e-02f, -4.35398053e-03f, 1.13555215e-01f, 1.92832783e-01f, -1.41721234e-01f, 7.00542890e-03f,
  -7.97873884e-02f, -8.38733017e-02f, -1.99109718e-01f, -2.01354809e-02f, 2.85809096e-02f, 3.07607986e-02f, -3.47437143e-01f, 1.44501299e-01f, -3.34595621e-01f, -1.10767689e-02f,
  -4.85085964e-01f, 4.15444940e-01f, -2.47549295e-01f, 9.75657701e-02f, 2.01994494e-01f, 3.34645599e-01f, -3.02365541e-01f, 3.29123661e-02f, 5.04858375e-01f, -2.95379758e-01f,
  -2.61459649e-01f, 2.49863595e-01f, 7.54691735e-02f, -4.60622489e-01f, -2.01156810e-01f, -1.73695888e-02f, -6.12649545e-02f, -2.83293128e-01f, 4.56693806e-02f, 2.07687140e-01f,
  -1.45448133e-01f, 1.82055488e-01f, 6.97086751e-02f, 2.67298639e-01f, 1.94937631e-01f, 3.06975394e-01f, -3.20867270e-01f, -9.00993347e-02f, -4.66179907e-01f, 9.32238158e-03f,
  -5.62235355e-01f, 2.36300871e-01f, 1.70176685e-01f, -2.32623473e-01f, -3.56409371e-01f, -1.11092240e-01f, -8.78570974e-02f, -2.77907372e-01f, -3.53561014e-01f, 1.52849510e-01f,
  1.22006238e-01f, 1.26865879e-01f, 1.06501795e-01f, -6.04560450e-02f, -1.08644173e-01f, 2.63007402e-01f, -1.45447564e+00f, 1.41006187e-01f, -2.33218685e-01f, 6.08857609e-02f,
  -6.67342618e-02f, -8.93062279e-02f, 1.18907906e-01f, -6.88513070e-02f, 9.08047482e-02f, 4.24764901e-02f, -6.60859933e-03f, 3.12467907e-02f, 4.41729873e-02f, -1.59225807e-01f,
  1.73146930e-03f, 2.51200885e-01f, 7.85895437e-03f, 4.82472479e-02f, 5.52468421e-03f, 3.50625068e-01f, 1.06778376e-01f, 1.65612116e-01f, 7.23879486e-02f, -6.70813546e-02f,
  -2.81841934e-01f, 1.63974211e-01f, -4.35904324e-01f, 1.98915064e-01f, -8.31725746e-02f, -7.62097239e-02f, 1.79788008e-01f, 2.72975892e-01f, -3.13852131e-01f, -2.45499089e-01f,
  -1.07602648e-01f, -2.73766369e-01f, -4.47887136e-03f, -1.44890204e-01f, -3.07565808e-01f, -1.56554863e-01f, -2.69510359e-01f, -7.50273839e-02f, -2.32047647e-01f, -2.22330153e-01f,
  1.67242348e-01f, -3.45696807e-01f, 1.26283327e-02f, 2.66495496e-01f, 2.85410851e-01f, -2.14980453e-01f, 9.62114930e-02f, 2.05020726e-01f, -1.32378280e-01f, 7.44027048e-02f,
  2.29501173e-01f, -3.26503873e-01f, 4.73860912e-02f, 8.92147049e-02f, -2.50565827e-01f, 3.46182361e-02f, -1.65086374e-01f, -2.26294890e-01f, 2.03266948e-01f, -1.72143623e-01f,
  5.46666920e-01f, -3.61558795e-01f, -4.38243784e-02f, 7.10885674e-02f, -6.07367605e-02f, 1.23530477e-01f, 1.06102556e-01f, -1.53627113e-01f, 1.10928826e-01f, -9.15262625e-02f,
  -1.85903251e-01f, -1.29778981e-01f, 9.10513252e-02f, -2.04094704e-02f, 1.84664756e-01f, 2.88113326e-01f, -2.43012935e-01f, -1.20682135e-01f, 1.07147157e-01f, -1.53373390e-01f,
  1.28407285e-01f, 2.70885706e-01f, -2.72345781e-01f, 2.50205308e-01f, -1.62436381e-01f, -2.08636597e-01f, 3.34844142e-01f, -3.30766104e-02f, 2.26934358e-01f, 1.18072100e-01f,
  2.27934733e-01f, -3.67065698e-01f, 2.68654317e-01f, -1.39895901e-01f, -3.30615938e-01f, 1.31720677e-01f, -2.11404443e-01f, 9.02155712e-02f, -8.56294855e-03f, -1.54331952e-01f,
  -1.62846103e-01f, -1.43420905e-01f, -2.19717100e-01f, 5.53604998e-02f, -8.10789317e-02f, 2.43250266e-01f, -2.86231458e-01f, -3.82963754e-02f, 1.63127810e-01f, -3.25641125e-01f,
  -2.28891119e-01f, 2.04031065e-01f, -1.47843966e-02f, -1.05827123e-01f, -1.86870471e-01f, 1.99186623e-01f, -1.44447252e-01f, -3.32887977e-01f, -1.97859570e-01f, -1.34809958e-02f,
  -9.98554453e-02f, 2.65292168e-01f, -1.62420958e-01f, -2.34105662e-01f, 2.98555374e-01f, -4.88720089e-01f, 7.80983195e-02f, -4.96411696e-02f, 5.17732240e-02f, -2.10002631e-01f,
  1.21125363e-01f, 1.58911459e-02f, -3.81306559e-02f, -2.63612330e-01f, 5.56261390e-02f, 1.59259468e-01f, 8.64448249e-02f, -4.85774539e-02f, -8.31380486e-02f, 1.88180700e-01f,
  2.63485849e-01f, 1.01531290e-01f, 4.75649148e-01f, 3.26993585e-01f, -1.54737890e-01f, 2.99385369e-01f, 1.92468286e-01f, -3.54077905e-01f, 1.67084679e-01f, 3.12731594e-01f,
  -3.39787483e-01f, 1.33517727e-01f, -3.23866189e-01f, -3.92443091e-01f, -3.35824400e-01f, -3.58959109e-01f, -3.41796666e-01f, -3.69811535e-01f, -4.06461507e-02f, -1.15462340e-01f,
  2.54390180e-01f, -4.03184146e-01f, -1.21092878e-01f, -2.26915956e-01f, -7.45545253e-02f, 2.77523488e-01f, 2.43174151e-01f, -1.66886792e-01f, -1.84213847e-01f, -6.65567145e-02f,
  2.15690553e-01f, 1.47418812e-01f, 1.95198923e-01f, 1.94559261e-01f, -4.29506063e-01f, 1.71929434e-01f, -3.56788486e-01f, -2.81865299e-01f, -6.62098825e-02f, -1.94127142e-01f,
  -3.13687980e-01f, 3.06055397e-01f, 1.31223619e-01f, 2.98746526e-01f, 2.73059547e-01f, 3.97929460e-01f, -3.58863235e-01f, 1.71201497e-01f, -4.70504880e-01f, -1.77162439e-01f,
  1.33117661e-01f, -1.90309912e-01f, 2.45605499e-01f, -5.12627326e-02f, 1.00680098e-01f, 1.06636949e-01f, 2.42378097e-02f, -4.46830317e-03f, -8.19010437e-02f, -3.05672903e-02f,
  -1.34753525e-01f, -1.49622053e-01f, -2.53714293e-01f, -5.13025001e-02f, 8.33186060e-02f, -3.49742323e-01f, 3.75005305e-01f, 1.39201775e-01f, 2.68978864e-01f, -2.99652904e-01f,
  2.87134469e-01f, -2.45568946e-01f, 3.01882595e-01f, -2.76578516e-01f, 1.01547785e-01f, -3.18945825e-01f, 9.70888138e-02f, 1.00026093e-01f, -3.91224563e-01f, -6.20694421e-02f,
  1.96760878e-01f, 2.45915368e-01f, -2.30119556e-01f, 4.16647643e-02f, -2.48956263e-01f, 7.07362816e-02f, 2.10256860e-01f, -3.87791127e-01f, -4.51299012e-01f, -2.03504324e-01f,
  3.68397444e-01f, 3.56454372e-01f, -2.53430684e-03f, -3.82382244e-01f, 3.57052565e-01f, -6.83563724e-02f, 2.06391811e-02f, -2.20491871e-01f, -2.19173953e-02f, 5.11420518e-02f,
  -3.75628799e-01f, 2.32618257e-01f, -1.59496799e-01f, 1.39450803e-01f, 2.09251493e-01f, -3.49764317e-01f, -1.87544897e-01f, -2.63636798e-01f, -3.37101251e-01f, 8.99380073e-02f,
  2.54118949e-01f, -1.22980379e-01f, -3.24808925e-01f, 5.76367117e-02f, 5.38559742e-02f, 1.46714628e-01f, -1.58360247e-02f, 4.62550968e-02f, -2.22574100e-01f, 1.18158512e-01f,
  9.04737785e-02f, 1.29204854e-01f, 1.26001775e-01f, -2.22073689e-01f, 1.19756706e-01f, 1.43522725e-01f, -2.04268545e-01f, 2.25338310e-01f, 1.36766389e-01f, 1.48255140e-01f,
  -2.64470190e-01f, -1.83256581e-01f, 3.53038102e-01f, 2.71806061e-01f, 1.14636742e-01f, 2.04569876e-01f, 2.33688474e-01f, -2.34076574e-01f, 5.36040403e-03f, -3.69171232e-01f,
  -1.69787660e-01f, 2.61784911e-01f, 1.83590412e-01f, -1.03294000e-01f, 2.26168722e-01f, 1.37706131e-01f, -1.58077180e-01f, -2.29324535e-01f, -2.58159012e-01f, 2.62722611e-01f,
  -6.23100281e-01f, -2.40809008e-01f, 2.52257854e-01f, -2.28221700e-01f, -1.24234613e-02f, -9.57169458e-02f, -4.36707884e-01f, -4.29084629e-01f, 1.70972973e-01f, -5.51533043e-01f,
  -1.56278387e-02f, -2.78521419e-01f, 2.82877266e-01f, 1.60021633e-02f, 1.07905649e-01f, 2.13960543e-01f, -1.30936941e-02f, -4.43544626e-01f, -3.11037451e-01f, 1.60538644e-01f,
  2.82962382e-01f, -4.04947191e-01f, -3.46884757e-01f, 2.68419713e-01f, -1.48079723e-01f, 2.19212875e-01f, 4.88909274e-01f, -4.95492309e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  8.12226832e-02f, -5.95784783e-02f, -9.16794986e-02f, 4.39783074e-02f, 8.19531381e-02f, -1.11048527e-01f, 1.15157366e-01f, -4.27882075e-02f, 1.03546577e-02f, -2.85779405e-02f,
  8.29934403e-02f, -8.01872984e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    