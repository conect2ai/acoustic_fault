/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.72316834e-01f, 1.36473998e-02f, -1.63099557e-01f, -5.38189849e-03f, -8.65653157e-02f, -1.26990061e-02f, -1.96918100e-01f, -4.68692183e-02f, 4.40907711e-03f, 4.11901437e-02f,
  -5.79920933e-02f, 3.72718908e-02f, 1.06975608e-01f, -7.51160160e-02f, 3.55273373e-02f, 1.09112196e-01f, -1.15817680e-03f, -3.25348489e-02f, 7.79758627e-03f, -1.03068151e-01f,
  -7.12871104e-02f, -3.06205247e-02f, -2.33808365e-02f, -5.76287396e-02f, -1.55620798e-01f, -3.44473720e-02f, 3.41339596e-02f, -1.64259210e-01f, 6.22061491e-02f, 5.45869693e-02f,
  1.17765646e-02f, 3.66870947e-02f, -3.95429172e-02f, 3.88889425e-02f, -3.94661389e-02f, 1.66007727e-02f, 9.91811082e-02f, -6.55671582e-02f, -2.29211058e-02f, -3.29436851e-04f,
  1.61686838e-02f, -1.06116161e-02f, -5.98249538e-03f, -4.35665511e-02f, 2.31961776e-02f, 3.25086676e-02f, 1.54208569e-02f, -2.73210201e-02f, 5.00779785e-02f, -4.06563058e-02f,
  -9.13893953e-02f, 3.25698778e-02f, -7.74432570e-02f, 2.91250087e-02f, -7.95905590e-02f, -3.57435532e-02f, 5.90671562e-02f, -5.71674332e-02f, 5.42057268e-02f, -4.34360951e-02f,
  5.19922078e-02f, -7.36566484e-02f, 1.29990699e-02f, -2.23721284e-02f, 2.03792192e-02f, 3.18102539e-02f, 1.19644869e-02f, 7.31835589e-02f, -8.19184780e-02f, 5.75597771e-02f,
  -4.96365838e-02f, -7.45695597e-03f, -1.77792143e-02f, 4.99113835e-02f, -9.13332310e-03f, 5.75407594e-02f, 5.47133610e-02f, 4.23919149e-02f, -1.98930390e-02f, 8.77433345e-02f,
  8.62230267e-03f, 5.31405360e-02f, 4.24647965e-02f, 3.51311080e-02f, 5.35268188e-02f, -8.30081105e-02f, 1.18334964e-02f, 4.63529341e-02f, -5.44143422e-03f, -3.14693451e-02f,
  -6.16125902e-03f, 4.30021174e-02f, 7.22465068e-02f, -2.99126487e-02f, 9.72606242e-03f, 7.46859461e-02f, 2.53416933e-02f, -9.22599528e-03f, -1.39686726e-02f, -4.26055416e-02f,
  -8.42978880e-02f, 1.02528566e-02f, -1.78092234e-02f, 1.82457883e-02f, -7.54553601e-02f, -3.27454247e-02f, 4.36962359e-02f, 3.07505671e-02f, -6.60294816e-02f, 7.64218066e-03f,
  5.28847910e-02f, -8.62651691e-03f, -2.56443769e-03f, 3.92048061e-02f, -1.37141915e-02f, 4.37798612e-02f, -1.61326732e-02f, -5.01442589e-02f, 2.15718541e-02f, -6.05483958e-03f,
  5.26679978e-02f, 1.55816376e-01f, 3.60391252e-02f, 1.60544872e-01f, 9.07703340e-02f, -4.36891876e-02f, 1.46668568e-01f, 7.88974836e-02f, 3.28974351e-02f, 1.86142281e-01f,
  2.88376305e-02f, -5.48730895e-04f, -6.76366389e-02f, 1.68563887e-01f, -2.75249779e-01f, -1.56927139e-01f, 1.81456983e-01f, 5.01735993e-02f, -5.94628416e-02f, 1.68161422e-01f,
  -9.02557820e-02f, 1.74935326e-01f, -9.14227888e-02f, 7.52752349e-02f, 1.05115555e-01f, 2.87912600e-02f, 3.67272794e-02f, -2.79837679e-02f, 5.72522655e-02f, -5.49500845e-02f,
  2.22367905e-02f, 3.34649347e-02f, 7.16187283e-02f, 1.69909075e-02f, -7.09101483e-02f, 8.45946297e-02f, 3.76506965e-03f, -4.44256328e-03f, -8.80348086e-02f, 2.58758385e-02f,
  -5.50582111e-02f, 2.13651210e-02f, 2.17640027e-02f, 2.47931597e-03f, 4.47112098e-02f, -1.06790960e-02f, -4.36097495e-02f, -1.65721364e-02f, 2.45218910e-02f, -5.20060621e-02f,
  -5.81454076e-02f, -4.65874448e-02f, -9.56187607e-04f, -3.66555080e-02f, 1.31192813e-02f, 1.24672372e-02f, 9.04531684e-03f, -7.44518824e-03f, -9.23126340e-02f, -5.39416857e-02f,
  9.09950733e-02f, -5.11085875e-02f, 2.68623256e-03f, 1.96295436e-02f, -5.56129497e-03f, 7.26854205e-02f, -3.62715572e-02f, -5.84748760e-03f, 1.43726505e-02f, 5.70215657e-02f,
  -3.91899012e-02f, 2.79072598e-02f, 6.54539047e-03f, 6.08043373e-02f, 9.53392163e-02f, 9.19436961e-02f, -1.15692820e-02f, -2.11480521e-02f, -5.46074733e-02f, 8.08558241e-03f,
  -4.82715108e-02f, 2.80864071e-02f, 5.00843348e-03f, -2.93315277e-02f, 3.74659710e-02f, -1.06360942e-01f, 4.72725034e-02f, -8.98797996e-03f, -4.46299417e-03f, -9.08576325e-02f,
  -6.66292682e-02f, 5.41449264e-02f, -1.86889973e-02f, -1.87533051e-02f, -8.56079012e-02f, -4.27526496e-02f, -2.63136462e-03f, -9.16168019e-02f, -9.94376652e-03f, 4.65519838e-02f,
  6.75824657e-02f, 1.03629660e-02f, -4.51455601e-02f, -3.25854383e-02f, -1.00623732e-02f, -1.01333894e-02f, 2.02824716e-02f, -5.76984622e-02f, 4.51726988e-02f, 4.58968543e-02f,
  5.97253107e-02f, 4.24269028e-02f, -7.85149857e-02f, 5.27499132e-02f, -3.52894440e-02f, 1.22060115e-02f, -2.65370961e-02f, -1.20347450e-02f, -6.16171844e-02f, -1.27548091e-02f,
  9.36111733e-02f, -1.14357739e-03f, 2.64509797e-01f, -6.27461299e-02f, 8.59767722e-04f, -5.14778756e-02f, 8.22198540e-02f, 2.12294757e-02f, 1.80765182e-01f, -8.44786838e-02f,
  -1.47767544e-01f, 2.15568021e-01f, 7.79544413e-02f, -1.99443653e-01f, 5.75810671e-02f, 1.37240931e-01f, -1.18135042e-01f, -6.00098297e-02f, 7.32965991e-02f, -1.60778016e-02f,
  2.01552529e-02f, -2.33387157e-01f, -6.25062883e-02f, -5.52426167e-02f, -1.90329570e-02f, 7.05700889e-02f, -1.69515893e-01f, -1.07541811e-02f, -8.69150162e-02f, -1.95206515e-02f,
  1.34183494e-02f, 2.15855092e-02f, 4.38096449e-02f, -5.22679947e-02f, 2.56457645e-02f, -1.16119176e-01f, 4.84373160e-02f, 4.61347401e-02f, 6.94937482e-02f, -3.22491154e-02f,
  -4.61225910e-03f, 4.87191044e-03f, -4.76248972e-02f, -9.96381138e-03f, 3.59104387e-02f, 6.15277067e-02f, 3.11640836e-03f, -4.41470779e-02f, 3.29161398e-02f, -8.55269581e-02f,
  6.10571727e-02f, -4.18893807e-02f, -2.97784675e-02f, -4.19578366e-02f, 4.53747138e-02f, -1.94656709e-03f, 1.77586395e-02f, 6.19742312e-02f, 3.34877260e-02f, -6.55055570e-04f,
  -1.17534064e-01f, 8.08776170e-02f, -1.90982353e-02f, -5.70171177e-02f, -5.46920784e-02f, 7.87552563e-04f, -1.85720399e-02f, -7.20677245e-03f, 5.52567244e-02f, 2.88245976e-02f,
  -4.29761969e-02f, -4.08979356e-02f, -1.32240867e-02f, -2.78399885e-03f, 1.58514909e-03f, 2.39004642e-02f, 1.41784153e-03f, -2.84863692e-02f, 2.79162917e-02f, 3.59286480e-02f,
  -5.16387001e-02f, 6.68721050e-02f, -2.47755833e-02f, -4.59757894e-02f, -4.80931364e-02f, 4.40066233e-02f, -3.97279523e-02f, 1.67715847e-02f, -1.24999667e-02f, 5.87297790e-02f,
  1.98330544e-02f, 1.00924950e-02f, 2.68292297e-02f, -1.62255168e-02f, -8.80898759e-02f, 2.55155694e-02f, -4.16101553e-02f, 2.74241203e-03f, 3.70815513e-04f, 5.19188493e-02f,
  -1.33036762e-01f, 2.50877682e-02f, 1.11430045e-02f, -2.11627521e-02f, 3.31156217e-02f, -8.21313784e-02f, 2.13913191e-02f, 3.79641876e-02f, 1.59109440e-02f, 1.56981088e-02f,
  -9.15653259e-02f, 2.92956866e-02f, -1.47870195e-03f, 2.33926382e-02f, -2.58100647e-02f, -2.02812869e-02f, 4.59088087e-02f, -5.18332608e-02f, 4.32188287e-02f, -9.15553421e-03f,
  -2.24113137e-01f, -1.18854083e-01f, 7.21808299e-02f, -9.23051015e-02f, 2.22434402e-02f, -1.81011781e-01f, -9.90871340e-02f, 2.78864652e-02f, -1.49935901e-01f, -4.48306724e-02f,
  6.21331818e-02f, -1.80693239e-01f, 1.62764370e-01f, 1.72212310e-02f, 1.18974678e-01f, 1.25089690e-01f, -6.12544082e-02f, -9.35430080e-02f, 2.43372507e-02f, -3.26630659e-02f,
  -1.21976444e-02f, 5.68122230e-03f, 1.72951192e-01f, 1.32733494e-01f, -9.82829109e-02f, -3.40984799e-02f, 8.26159492e-02f, 1.05352886e-01f, -1.05506759e-02f, 8.04159716e-02f,
  -3.34726162e-02f, 2.80960575e-02f, 4.48896028e-02f, -9.92004573e-03f, 1.61970612e-02f, -1.72095187e-03f, -3.21761775e-03f, 4.28453684e-02f, 7.19906315e-02f, 1.29685188e-02f,
  -4.26234491e-02f, 4.10662778e-02f, -3.48727815e-02f, -2.42619240e-03f, -7.17641860e-02f, -2.53317300e-02f, -4.30174954e-02f, 5.12068644e-02f, -2.55743023e-02f, 7.22407410e-03f,
  -1.26721011e-03f, -5.06272689e-02f, -1.48546905e-03f, -3.58727388e-03f, 5.27601177e-03f, -3.75732668e-02f, -4.37499620e-02f, 7.14976713e-02f, -5.94078470e-03f, -4.82967272e-02f,
  -1.30861387e-01f, 1.90582778e-02f, 7.51505196e-02f, 2.59716958e-02f, -7.42221391e-03f, -2.58515198e-02f, -2.19818484e-02f, 9.38278972e-04f, 1.62728000e-02f, 4.86511923e-02f,
  -5.06036840e-02f, 4.04169317e-03f, 7.91763235e-03f, -8.15486610e-02f, -1.38755506e-02f, -6.65093660e-02f, -6.80422084e-03f, -1.37302307e-02f, -8.39696266e-03f, 1.74474958e-02f,
  -6.04782701e-02f, 7.67379859e-03f, -2.48127133e-02f, 3.27399857e-02f, 5.73908053e-02f, 5.36256805e-02f, -3.01179551e-02f, 1.95115302e-02f, -1.11258496e-02f, 4.10648845e-02f,
  -1.17678419e-01f, -2.74815839e-02f, 6.64650053e-02f, 9.01801570e-04f, 1.08598303e-02f, -1.62445288e-02f, -1.33540193e-02f, -7.53625706e-02f, -3.82653102e-02f, -2.28313766e-02f,
  3.89779103e-03f, 8.58304352e-02f, -6.99452907e-02f, 4.91010100e-02f, 2.56386679e-02f, -1.87494829e-02f, 3.90425697e-02f, 1.37336049e-02f, -4.65502515e-02f, -2.31883815e-03f,
  5.02547696e-02f, -5.87614700e-02f, -4.13345732e-02f, -5.86448200e-02f, -3.92857790e-02f, -1.69937685e-02f, -5.25790453e-03f, -8.28665197e-02f, 8.54372606e-03f, 1.35267689e-03f,
  1.34012282e-01f, 2.28109807e-01f, -8.67816582e-02f, 1.43944800e-01f, -1.18378259e-01f, 1.11859173e-01f, -7.18490919e-03f, 6.83019608e-02f, 1.62452385e-02f, 1.33670479e-01f,
  7.84271806e-02f, 5.08358963e-02f, 2.61536967e-02f, 1.08321771e-01f, -2.46419702e-02f, 2.71224650e-03f, 1.42695040e-01f, 3.17610689e-02f, -6.61519393e-02f, -6.37673819e-03f,
  4.15661233e-03f, 3.95029001e-02f, -1.11226372e-01f, -3.32068130e-02f, 4.04895470e-03f, -2.06958503e-02f, -4.23005782e-02f, -6.96009994e-02f, -2.05855183e-02f, -1.23156281e-02f,
  1.00293450e-01f, 5.02543710e-02f, 1.85451936e-02f, 7.17640221e-02f, -2.88378801e-02f, -5.53472415e-02f, -4.29511778e-02f, -5.93528263e-02f, 1.06658321e-02f, -2.77921017e-02f,
  -4.94055077e-03f, 7.17724562e-02f, -6.12390339e-02f, 3.31038982e-02f, 9.17814858e-03f, 3.37749533e-02f, -2.77468357e-02f, -4.96218801e-02f, -5.34616411e-02f, -1.22530915e-01f,
  -5.83257414e-02f, -2.58827023e-02f, -8.76777247e-03f, -1.95857789e-02f, -8.90458748e-02f, 1.13065178e-02f, -6.78534713e-03f, -7.80300125e-02f, -1.82437361e-03f, 4.18120576e-03f,
  -6.78149387e-02f, -1.17018959e-02f, 6.05743304e-02f, 4.21509147e-02f, 1.94826145e-02f, 3.13355401e-02f, 1.09046558e-02f, 1.76106803e-02f, 1.00514628e-02f, 3.51485237e-02f,
  6.89107478e-02f, -2.87873782e-02f, 5.75233400e-02f, -5.16810454e-03f, -1.28473714e-03f, -1.72530431e-02f, -3.29755479e-03f, 4.95445840e-02f, -6.84324205e-02f, -3.24294120e-02f,
  5.48962615e-02f, 1.30549269e-02f, 4.50897552e-02f, -6.74814917e-03f, -2.27079485e-02f, -2.21880432e-02f, -3.68356472e-03f, 7.76165724e-02f, -5.21064401e-02f, 4.14788350e-02f,
  2.29527652e-01f, 2.30627373e-01f, -4.37380001e-02f, 3.53671499e-02f, -6.77491818e-03f, -1.49801159e-02f, -8.32371637e-02f, -4.01263172e-03f, -2.25444213e-02f, -1.78219099e-02f,
  -4.73983176e-02f, 3.07776546e-03f, -1.89630780e-02f, 6.01792373e-02f, 1.61401965e-02f, -2.59973481e-02f, 5.74384890e-02f, 5.78885972e-02f, -7.25512020e-03f, 6.13709278e-02f,
  5.93061000e-02f, -3.33059616e-02f, -5.40405922e-02f, 2.73690689e-02f, 1.12053677e-02f, -6.70200586e-02f, 3.00313141e-02f, -4.49600779e-02f, 1.15160551e-02f, 3.03846765e-02f,
  -6.42161071e-02f, -2.80898828e-02f, -9.27063003e-02f, -6.34146109e-02f, -4.88170162e-02f, -2.12209791e-01f, -1.44309461e-01f, -5.56657165e-02f, 4.65373136e-02f, 5.14191389e-02f,
  -1.08918548e-01f, -5.60704172e-02f, -9.36631337e-02f, -2.20245093e-01f, -2.56522924e-01f, -4.64870334e-02f, -9.18410569e-02f, -7.88827017e-02f, -4.28576060e-02f, -6.30910993e-02f,
  -3.69682275e-02f, -7.53387362e-02f, -1.96060434e-01f, 2.40341276e-02f, -7.73133859e-02f, 2.98905681e-04f, 4.31030020e-02f, 4.28795815e-02f, -3.34983952e-02f, -5.41673638e-02f,
  -7.88884237e-02f, 3.27235321e-03f, -3.91915068e-02f, -6.92349002e-02f, -7.58611709e-02f, 2.16851924e-02f, -3.66901942e-02f, 1.33920535e-02f, 1.41627258e-02f, 9.09955800e-03f,
  6.31525964e-02f, 1.16218897e-02f, 1.02314381e-02f, 4.53823283e-02f, 3.95558327e-02f, -3.69432792e-02f, -7.70101845e-02f, -1.89785324e-02f, -5.13804816e-02f, -6.55807480e-02f,
  -6.23750538e-02f, 2.99801934e-03f, -2.11008415e-02f, -1.28702503e-02f, -1.86312776e-02f, -3.39898504e-02f, -7.80341104e-02f, -3.75346020e-02f, 3.84307168e-02f, -3.57277319e-02f,
  -4.50193658e-02f, 8.53046700e-02f, -2.79922802e-02f, 1.28162224e-02f, -5.66720255e-02f, -3.46608763e-03f, -5.35725430e-02f, 9.73925516e-02f, 3.20248827e-02f, 6.53981930e-03f,
  3.08565218e-02f, 3.15404013e-02f, -6.11082539e-02f, 2.13608444e-02f, -1.55893601e-02f, -3.50705758e-02f, -1.45658087e-02f, 8.02718289e-03f, 3.29927541e-02f, -7.79862003e-03f,
  -3.66752446e-02f, -4.11235467e-02f, 1.74444877e-02f, -1.00709321e-02f, -2.10586805e-02f, 4.59257364e-02f, 5.20301722e-02f, 3.88309471e-02f, 5.08244969e-02f, -3.30218077e-02f,
  6.08352013e-02f, -1.85612887e-02f, 3.00845969e-02f, 3.97565849e-02f, 1.59342331e-03f, 2.69338861e-02f, 3.19704898e-02f, 3.81075963e-02f, 1.75200421e-02f, -1.49363605e-02f,
  2.14154776e-02f, -4.89017852e-02f, -3.50932288e-03f, -3.38415392e-02f, -4.56025563e-02f, 4.95942757e-02f, 3.33613791e-02f, 3.29972692e-02f, -5.34360223e-02f, -5.64243160e-02f,
  3.02822404e-02f, 4.04068688e-03f, 3.92141156e-02f, -2.79127061e-02f, -1.37765687e-02f, -8.12320039e-03f, -2.40969416e-02f, 3.43770720e-02f, 4.63659726e-02f, 6.77644983e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.69106573e-01f, -1.51274353e-01f, -1.86510146e-01f, 3.39894928e-02f, 3.80331539e-02f, 1.77207708e-01f, -7.30075911e-02f, 5.10871820e-02f, 4.44929339e-02f, -7.26432502e-02f,
  1.47470897e-02f, -1.09285556e-01f, -1.82309225e-01f, 3.00192572e-02f, 6.78962767e-02f, -1.03635885e-01f, 1.34497270e-01f, -8.31248760e-02f, 1.05346623e-03f, -2.89426055e-02f,
  8.12594593e-02f, 1.58079222e-01f, -4.62262854e-02f, 1.42513484e-01f, 7.56857768e-02f, -8.91879760e-03f, 3.60442512e-02f, 4.74956930e-02f, 1.63697768e-02f, 1.12901375e-01f,
  -5.00047244e-02f, 2.60619242e-02f, -1.99687369e-02f, -1.10652141e-01f, -4.98708673e-02f, -3.78783559e-04f, -6.41954839e-02f, -2.97311209e-02f, -8.84553641e-02f, -2.65717525e-02f,
  -9.49180350e-02f, -2.92034280e-02f, 1.47663251e-01f, 3.85350473e-02f, 4.70865518e-02f, 2.82641035e-02f, -3.41821276e-02f, 2.19590887e-02f, -6.48632646e-02f, 6.47348687e-02f,
  -8.25145934e-03f, -1.49424877e-02f, -4.69483398e-02f, 6.14435151e-02f, -1.09761134e-01f, 6.09710254e-03f, -4.01757695e-02f, 2.05512196e-02f, 7.50006735e-02f, -9.40188691e-02f,
  5.53961284e-03f, 5.98049387e-02f, -1.09602369e-01f, -4.66931947e-02f, 7.54260048e-02f, 5.10063171e-02f, -8.29591155e-02f, -9.84478649e-03f, -3.19880582e-02f, -4.79889251e-02f,
  5.76794334e-02f, -2.31884755e-02f, -5.77241108e-02f, 5.52018546e-02f, 8.81111398e-02f, -2.02067364e-02f, 8.33730474e-02f, 6.17364384e-02f, -2.46041380e-02f, 3.15452144e-02f,
  -1.20382547e-01f, 3.18643972e-02f, 3.37436274e-02f, -4.72490601e-02f, 1.65290385e-02f, 5.47186397e-02f, 4.78945114e-02f, -2.07281560e-02f, -7.76032209e-02f, -1.00405365e-02f,
  -5.76692224e-02f, -4.67215711e-03f, 5.58905490e-02f, 4.71648835e-02f, 1.24987857e-02f, 1.07195355e-01f, 1.32653601e-02f, -6.94303587e-02f, -4.27298136e-02f, 6.51982352e-02f,
  3.71424146e-02f, 8.21378902e-02f, -6.66807517e-02f, 1.89105514e-02f, -4.15219441e-02f, -3.49555276e-02f, 4.18489948e-02f, -2.44955998e-03f, 3.00125703e-02f, -3.50056216e-02f,
  4.10497896e-02f, 1.27396971e-01f, -6.39529228e-02f, 2.53314022e-02f, -3.95533815e-02f, -4.01587598e-02f, 3.41368020e-02f, -1.30099487e-02f, -3.26544121e-02f, -2.77771242e-02f,
  -1.98281899e-01f, 2.40170769e-02f, 1.24548279e-01f, 1.47627577e-01f, 1.49960324e-01f, 3.09864819e-01f, 2.99297333e-01f, -7.34987110e-02f, 1.13853179e-01f, -7.17513785e-02f,
  -9.34298933e-02f, 8.82115215e-02f, 8.28437805e-02f, 1.94590632e-02f, 2.24111781e-01f, 4.99159768e-02f, 8.69292691e-02f, 5.57571948e-02f, -5.46768606e-02f, -5.87829947e-02f,
  4.20162492e-02f, -1.75355212e-03f, 7.88650438e-02f, -2.68607646e-01f, -5.92996776e-02f, -1.51952624e-01f, -1.38492942e-01f, 8.50059167e-02f, -1.52988136e-01f, 1.41229006e-02f,
  -6.28605783e-02f, -1.47855684e-01f, -1.01416469e-01f, -1.01934560e-01f, -7.47446623e-03f, 3.61426249e-02f, -1.83469038e-02f, 6.24216581e-03f, -4.74346057e-02f, 5.88593856e-02f,
  4.34099734e-02f, -3.34987454e-02f, -2.70041656e-02f, -2.82896720e-02f, 9.44292396e-02f, -1.84707996e-02f, 1.50213502e-02f, 4.16503437e-02f, 2.62841433e-02f, -1.78099070e-02f,
  -3.16821644e-03f, 1.26565984e-02f, 1.40734948e-02f, -3.73210423e-02f, -7.86978155e-02f, -2.09158659e-02f, 4.87149172e-02f, 5.57741225e-02f, -2.07574777e-02f, 4.42408025e-02f,
  2.81947516e-02f, 6.08396791e-02f, -2.68525239e-02f, -3.81110944e-02f, -3.44189652e-03f, -3.04932259e-02f, 2.57266704e-02f, 3.47348489e-02f, 8.72104312e-04f, 3.73151563e-02f,
  -1.08500442e-03f, -1.42980702e-02f, -5.59447818e-02f, 7.97320977e-02f, -5.25663942e-02f, 3.31436060e-02f, 2.12737471e-02f, -6.97314218e-02f, 1.25456164e-02f, 2.26397179e-02f,
  -2.72444095e-02f, -1.98916271e-02f, -4.38839430e-03f, 9.68676060e-03f, -4.20424454e-02f, 1.05759025e-01f, 2.61820517e-02f, -4.97102598e-03f, 3.01267523e-02f, 7.11675063e-02f,
  1.62907168e-02f, 1.41109712e-02f, -2.68968716e-02f, 5.43901548e-02f, -4.87214290e-02f, -3.45546938e-02f, -2.25200355e-02f, 9.21003986e-03f, 2.16212645e-02f, -5.35306595e-02f,
  2.01042816e-02f, 5.09358309e-02f, -1.82684232e-02f, -5.04594259e-02f, -5.35507947e-02f, 2.91375145e-02f, -2.61166263e-02f, -5.36229163e-02f, -2.17160620e-02f, -1.22133136e-01f,
  -9.75791365e-02f, 1.48050906e-02f, 5.09192199e-02f, -3.75791863e-02f, 1.44058643e-02f, -4.53134254e-02f, -4.59320433e-02f, 2.52035446e-02f, -2.49172021e-02f, 3.45921591e-02f,
  -3.55293900e-01f, 7.13211372e-02f, -4.51337732e-02f, -2.27658406e-01f, -2.57203169e-02f, 4.09642458e-02f, -8.07804763e-02f, 1.20746069e-01f, -6.11342862e-02f, -3.08933295e-02f,
  -1.65084317e-01f, -8.60333666e-02f, -4.53214794e-02f, -5.77810630e-02f, -1.49546072e-01f, 8.15125853e-02f, -1.69383854e-01f, -1.15932159e-01f, 1.09732244e-02f, -1.52538553e-01f,
  4.76873256e-02f, 5.43090887e-02f, 1.05159558e-01f, 9.31149796e-02f, -6.94880933e-02f, -8.07518214e-02f, -2.83864941e-02f, 5.03573678e-02f, -1.25726417e-01f, 3.18793692e-02f,
  -3.51999663e-02f, -1.38931246e-02f, 2.09900998e-02f, -2.24807058e-02f, 1.51262591e-02f, 7.21250474e-02f, -6.67645037e-02f, -4.49757464e-02f, -1.53102772e-02f, 5.81411757e-02f,
  -3.56482305e-02f, 2.76552904e-02f, -8.68200138e-02f, 3.16152871e-02f, 6.67112470e-02f, -7.39502301e-03f, 4.06416096e-02f, -3.31543386e-02f, -8.50707144e-02f, -2.60495842e-02f,
  5.18601388e-02f, -8.04199255e-04f, 3.85263115e-02f, -4.32213843e-02f, 8.75006244e-02f, 1.06814362e-01f, -2.94386242e-02f, -4.19589207e-02f, 3.39137353e-02f, -7.32014626e-02f,
  5.34016192e-02f, 9.19789746e-02f, 1.59011595e-03f, 7.45370761e-02f, -2.36956161e-02f, -3.62058356e-02f, 1.69093329e-02f, 2.13780943e-02f, 5.34203760e-02f, 3.84101905e-02f,
  4.34517190e-02f, 1.08698063e-01f, 2.08844747e-02f, 4.22746055e-02f, -7.82168582e-02f, -1.09444186e-01f, -1.35493055e-01f, -6.05628453e-02f, 7.43702874e-02f, 6.64502606e-02f,
  5.13106994e-02f, -8.38838983e-03f, 4.34200130e-02f, 6.11743750e-03f, 4.58647087e-02f, -1.75535120e-02f, 8.95860717e-02f, 1.17484881e-02f, -3.91191104e-03f, 4.23572250e-02f,
  -2.09507227e-01f, -1.19733930e-01f, 3.70819531e-02f, -1.24534480e-02f, -1.44036738e-02f, 1.19626382e-02f, 1.20971794e-03f, -1.66490804e-02f, -2.74921246e-02f, -1.62607431e-02f,
  1.61212822e-03f, 3.46731693e-02f, -2.88577434e-02f, -9.88966227e-02f, -6.80466667e-02f, -1.25101404e-02f, -7.15335757e-02f, -1.63794026e-01f, -9.75168869e-02f, 8.17315504e-02f,
  -1.06168337e-01f, 8.21085349e-02f, 5.08187413e-02f, 3.02746426e-02f, 1.23162180e-01f, -1.00762330e-01f, -3.93771306e-02f, -5.24724573e-02f, -2.22325642e-02f, -5.55253103e-02f,
  9.93391573e-02f, 1.39609814e-01f, 1.57847166e-01f, 1.66337937e-01f, -4.42705750e-02f, 2.44592428e-02f, -1.55122392e-02f, 1.29867628e-01f, 2.09280252e-01f, 1.04208253e-02f,
  -2.43860856e-03f, -1.43754944e-01f, -1.90358851e-02f, 1.88809878e-03f, -3.94747825e-03f, 9.11029503e-02f, 2.29526117e-01f, 1.06130261e-02f, 1.09055169e-01f, 3.53931561e-02f,
  1.65376559e-01f, 6.64823055e-02f, 5.27532771e-02f, -5.76196983e-02f, 5.78343570e-02f, 9.84370783e-02f, 1.02927946e-02f, 1.96684245e-02f, -8.12331662e-02f, 1.06233880e-02f,
  -3.10094841e-02f, 3.20855193e-02f, 1.39517542e-02f, -3.86837907e-02f, -4.84140813e-02f, -1.29772320e-01f, -1.13257706e-01f, -1.96238365e-02f, -8.36390108e-02f, -7.76978070e-03f,
  -1.20110102e-01f, -1.16906129e-02f, 1.01965293e-01f, 2.62232423e-02f, 5.22543862e-02f, 5.20299785e-02f, -4.63230200e-02f, 6.42119199e-02f, -6.82454333e-02f, -7.01443925e-02f,
  -6.67898431e-02f, -4.32231277e-02f, -3.14141363e-02f, 1.01612471e-01f, 4.52878103e-02f, -6.42988039e-03f, -9.71922204e-02f, -4.10783738e-02f, 5.31034395e-02f, 1.39636071e-02f,
  -3.26981358e-02f, -1.63030215e-02f, -5.95673546e-02f, -3.03309737e-03f, 9.56997275e-02f, -2.59285234e-02f, 1.79140214e-02f, 3.88402827e-02f, 2.77915057e-02f, -6.75361231e-03f,
  8.98748562e-02f, -1.92278472e-03f, 5.74870966e-02f, -2.65658833e-02f, 6.83558136e-02f, -9.16073844e-02f, -1.27810491e-02f, 8.87385309e-02f, 4.77924896e-03f, -1.47709185e-02f,
  7.29171112e-02f, 1.03454106e-02f, -5.20744100e-02f, -2.36399844e-02f, 6.29907474e-02f, -2.26638764e-02f, -4.01656814e-02f, -4.26042974e-02f, -5.82541898e-02f, 7.74857998e-02f,
  5.39684035e-02f, 1.62760794e-01f, 9.81998071e-03f, -1.66000694e-01f, -2.12767790e-03f, 3.62394638e-02f, -5.66778518e-02f, -2.52348334e-02f, 5.47622740e-02f, 8.90859589e-03f,
  2.82003041e-02f, 1.08776167e-02f, -1.37531282e-02f, 3.45472209e-02f, 8.66276864e-03f, 7.44782165e-02f, 5.00844866e-02f, 2.54926067e-02f, -6.70322124e-03f, -1.32103665e-02f,
  1.46497302e-02f, -3.29973958e-02f, -9.82801840e-02f, -2.88129002e-02f, 8.86633247e-03f, -8.96717906e-02f, 1.53816314e-02f, -9.42196175e-02f, -6.88792691e-02f, 8.39273632e-02f,
  8.58653411e-02f, -1.49561524e-01f, -1.20839037e-01f, 4.48354818e-02f, 2.63402700e-01f, 8.54392722e-02f, 3.34266610e-02f, 5.02875494e-03f, -7.65752196e-02f, -1.26869082e-01f,
  1.00068718e-01f, 4.28275503e-02f, -4.85393554e-02f, 1.92904755e-01f, 1.81729253e-02f, -1.59979761e-01f, 1.15328796e-01f, 1.71143487e-01f, -9.22056362e-02f, -4.94009964e-02f,
  -5.11469655e-02f, 1.87440038e-01f, -1.15514182e-01f, 7.65558779e-02f, 1.83240920e-02f, -1.60017952e-01f, 7.18843043e-02f, -4.08777371e-02f, 5.60335591e-02f, 6.34315982e-03f,
  8.16315338e-02f, -3.76068018e-02f, -7.15218112e-02f, -5.40602915e-02f, -5.52243926e-02f, 8.43096599e-02f, -8.32000524e-02f, 1.02625921e-01f, -1.23132868e-02f, 4.23627235e-02f,
  -3.30614089e-03f, -5.26366457e-02f, 9.28336307e-02f, -3.59124020e-02f, 3.90750691e-02f, 1.10335924e-01f, -1.07870642e-02f, -3.19024473e-02f, 5.71176559e-02f, -2.30765697e-02f,
  -3.12150810e-02f, 8.81869718e-02f, 2.63371393e-02f, 9.31228027e-02f, 5.21711595e-02f, -4.34727147e-02f, 7.95088559e-02f, -6.05741963e-02f, 8.16312879e-02f, 1.98821630e-02f,
  -2.02848632e-02f, -4.79324088e-02f, 3.97697277e-02f, 1.05094053e-02f, 7.37546235e-02f, 6.67444244e-02f, -2.16672868e-02f, 5.22023290e-02f, -4.60607447e-02f, -5.24644973e-03f,
  8.54353048e-03f, 9.86462738e-03f, -7.82031268e-02f, 2.43550539e-02f, 8.93795863e-02f, 4.26796414e-02f, 6.57879794e-03f, 9.18068960e-02f, 3.35831642e-02f, 2.24681608e-02f,
  -5.65869249e-02f, 1.24576345e-01f, 1.27493031e-02f, -5.42570651e-02f, 3.26326452e-02f, -2.38996763e-02f, -1.20729860e-02f, -2.51683742e-02f, -2.68311705e-02f, 1.85459070e-02f,
  4.44255993e-02f, -3.37645449e-02f, -7.18963593e-02f, -4.94977199e-02f, -8.59426335e-02f, 4.71202796e-03f, 3.22872028e-02f, 9.42996144e-02f, -8.89792517e-02f, 8.69444683e-02f,
  5.10645770e-02f, 6.84369877e-02f, 8.06310177e-02f, -2.40668599e-02f, -7.18237311e-02f, 5.80518804e-02f, -1.20528914e-01f, -1.14996620e-01f, 4.65266258e-02f, 1.83982290e-02f,
  9.94532183e-03f, -4.48009893e-02f, -5.70939155e-03f, 2.00555716e-02f, 1.38432443e-01f, -4.18264866e-02f, 5.60324192e-02f, -3.35554890e-02f, 1.50310993e-02f, 3.75572480e-02f,
  5.21969125e-02f, -9.55942720e-02f, -1.07971981e-01f, 8.13055784e-02f, -3.22699621e-02f, 6.01885952e-02f, 6.30780160e-02f, -6.80257231e-02f, -1.95132196e-01f, 2.71636564e-02f,
  1.19735770e-01f, 1.17174476e-01f, -5.37007004e-02f, 1.38858587e-01f, 1.78400949e-01f, -2.67155617e-02f, 9.89972278e-02f, 2.35457458e-02f, -1.15332678e-01f, 2.47024968e-02f,
  -8.43612999e-02f, 1.36589617e-01f, 1.04412988e-01f, 8.96286666e-02f, 1.74161300e-01f, -8.91142339e-02f, 6.65940419e-02f, 5.09542748e-02f, 5.69855310e-02f, 1.39568433e-01f,
  5.89590110e-02f, 3.11131962e-02f, 6.54652063e-03f, -1.41870514e-01f, 6.27442077e-02f, 1.07866056e-01f, 7.63098076e-02f, 9.45022926e-02f, -9.69366133e-02f, -1.17261879e-01f,
  6.29436597e-03f, 5.35275750e-02f, 2.48552649e-03f, -1.41429529e-03f, 8.20132717e-02f, 1.49925575e-02f, 3.74937356e-02f, -8.60392675e-02f, -1.19760856e-01f, -3.13280225e-02f,
  4.53312561e-04f, -1.42236352e-01f, 8.09056759e-02f, -8.50989521e-02f, -1.87369026e-02f, 4.14819792e-02f, 2.72088777e-02f, 2.38381308e-02f, -1.23433806e-01f, 5.93571998e-02f,
  2.37696734e-03f, 2.47859880e-02f, 4.75389436e-02f, 4.21278104e-02f, 3.26352082e-02f, -7.89003670e-02f, 2.64864229e-02f, -1.60669535e-02f, -5.08122668e-02f, 5.19151464e-02f,
  2.87446715e-02f, -1.29970219e-02f, -2.54602227e-02f, 8.62652622e-03f, -1.98443457e-02f, -8.77781510e-02f, -3.33780162e-02f, -4.11634371e-02f, 6.38258606e-02f, -3.72924805e-02f,
  -2.82846298e-02f, -3.40823382e-02f, -9.24895555e-02f, -2.72383615e-02f, 6.01224601e-02f, 1.05653927e-01f, 2.03795545e-02f, 3.48127983e-03f, -5.13993166e-02f, 2.45826207e-02f,
  -1.04334401e-02f, -1.67063205e-03f, 3.44378836e-02f, 1.55332629e-02f, -8.97951424e-02f, 1.05098598e-01f, 6.29774332e-02f, 2.50245072e-02f, -3.24871838e-02f, -5.64819574e-02f,
  -2.76799239e-02f, -5.47480434e-02f, 3.09651028e-02f, -8.03962946e-02f, 7.14036301e-02f, 4.61487435e-02f, -9.07655805e-02f, 6.59251586e-02f, -5.39638400e-02f, -1.13564190e-02f,
  -1.94782130e-02f, -1.65287226e-01f, 9.26215947e-02f, 5.76168448e-02f, 3.86995003e-02f, -9.58402306e-02f, -7.40055069e-02f, 3.82206813e-02f, -6.14200942e-02f, 4.90238853e-02f,
  -1.47214159e-01f, -2.57325470e-02f, -1.81126088e-01f, 5.37308343e-02f, 7.32582211e-02f, 2.24235747e-02f, 7.47778937e-02f, 1.61544949e-01f, -9.55261067e-02f, 1.56815514e-01f,
  1.57406971e-01f, -1.24418614e-02f, -1.24879874e-01f, 1.94342896e-01f, 2.15757787e-01f, 2.78425477e-02f, 1.26604840e-01f, 1.54736161e-01f, -8.01403224e-02f, -1.89493820e-02f,
  5.78755699e-02f, 2.49511227e-01f, -3.13948989e-02f, 3.40596288e-02f, 3.13219018e-02f, -1.53301790e-01f, -1.42108314e-02f, -1.31009296e-01f, 2.42578760e-01f, 1.55783251e-01f,
  9.00825486e-02f, -2.78585106e-02f, 5.89378886e-02f, -1.29439116e-01f, 8.07878971e-02f, -9.46562663e-02f, -1.06283434e-01f, -4.90735052e-03f, 4.55603302e-02f, -2.27640141e-02f,
  -7.38238618e-02f, 7.27771893e-02f, 7.68230902e-03f, -8.91763717e-02f, 2.52279378e-02f, -1.93310715e-02f, -4.98956814e-02f, 6.40442446e-02f, 5.40728159e-02f, -7.19974786e-02f,
  -1.00872919e-01f, 5.46348467e-02f, -8.55862945e-02f, -3.58813293e-02f, -3.71656660e-03f, 5.44311777e-02f, -1.10247349e-02f, 3.07350010e-02f, -4.99459878e-02f, 1.91838108e-02f,
  7.45555460e-02f, -1.11850031e-01f, 4.57129851e-02f, -6.48689345e-02f, 4.34287079e-02f, 4.98661548e-02f, 1.05131187e-01f, 6.89828843e-02f, -3.15955654e-02f, 6.69629052e-02f,
  -5.29027246e-02f, 5.49536161e-02f, -7.33065186e-03f, -2.43212413e-02f, -2.99079120e-02f, 3.42454650e-02f, -5.70468046e-02f, 8.66992492e-03f, -2.20613685e-02f, 5.56811653e-02f,
  3.84020135e-02f, -1.68883856e-02f, 7.65880123e-02f, 1.50794694e-02f, 8.24966058e-02f, 3.46760750e-02f, 9.15517733e-02f, -4.45784144e-02f, 1.71332750e-02f, -8.21417104e-03f,
  1.04013614e-01f, -4.57247235e-02f, -5.54700121e-02f, -5.88237196e-02f, 2.35692095e-02f, 6.42140731e-02f, -3.17752510e-02f, -1.40148634e-02f, -2.81373579e-02f, -5.87007292e-02f,
  5.47991693e-03f, 3.69565375e-02f, -8.63541737e-02f, -7.60906041e-02f, -4.28312197e-02f, 1.57687217e-02f, 5.41022904e-02f, 4.20213677e-03f, -2.90778689e-02f, 1.00652099e-01f,
  4.09774818e-02f, 2.98615061e-02f, 3.05541120e-02f, 5.46328798e-02f, 1.95964426e-02f, 3.98732759e-02f, 7.76994228e-02f, -6.36193305e-02f, -3.99712957e-02f, 2.23698448e-02f,
  -8.09399635e-02f, 8.86874273e-02f, 1.57712889e-03f, -1.52127460e-01f, -9.09186974e-02f, -8.53145495e-03f, -5.34865744e-02f, 8.53681415e-02f, 3.10703908e-04f, -9.30205509e-02f,
  -1.73278570e-01f, -1.00472001e-02f, 1.43729508e-01f, -2.04029068e-01f, -6.03093579e-02f, 7.04967557e-03f, -2.17202440e-01f, -8.59651528e-03f, 7.60444775e-02f, -1.35111541e-01f,
  -4.77987677e-02f, -1.99336410e-01f, -4.34894897e-02f, 5.24306856e-02f, -1.46489933e-01f, -2.54023192e-03f, -1.00046746e-01f, -1.05404006e-02f, -8.00818764e-03f, 2.15299288e-03f,
  -1.69355869e-01f, 2.96896026e-02f, -5.83391599e-02f, 3.23577859e-02f, -5.28901331e-02f, 1.23769324e-03f, -1.13066740e-03f, -1.53571675e-02f, 1.26448125e-02f, 3.13917026e-02f,
  -9.32388976e-02f, 1.48559269e-02f, 3.90440971e-03f, -9.09120589e-02f, 1.28729250e-02f, 7.72446245e-02f, -1.14392908e-03f, -7.17833787e-02f, 3.80580574e-02f, 5.79190068e-02f,
  -5.05745597e-02f, 3.39520685e-02f, -1.14322864e-01f, 1.03853934e-01f, 4.72656116e-02f, -9.93077233e-02f, -6.48575276e-02f, 8.82007927e-02f, 2.66964491e-02f, -7.64549524e-02f,
  -2.09663785e-03f, -6.76563904e-02f, 6.38607815e-02f, 8.08152254e-04f, -3.33425053e-03f, 1.53010441e-02f, -7.08253309e-02f, -1.18436404e-02f, 3.87449786e-02f, -2.70638112e-02f,
  3.42054777e-02f, -2.71654390e-02f, 6.91579357e-02f, -2.59920862e-02f, 4.47199531e-02f, 7.06490204e-02f, -5.77621572e-02f, 2.84066983e-02f, -2.72707827e-02f, -7.76931420e-02f,
  -6.63972870e-02f, 8.66175629e-03f, 9.02716164e-03f, -1.67536847e-02f, 2.11096387e-02f, -5.57345673e-02f, -1.26711838e-02f, 1.33892626e-01f, -2.87084393e-02f, -8.38048011e-02f,
  -2.46358439e-01f, -1.01562768e-01f, -7.48474672e-02f, -7.12004900e-02f, -7.04252943e-02f, -7.76473656e-02f, -2.42158379e-02f, -4.34902385e-02f, -2.08506659e-02f, -8.04110393e-02f,
  -9.89497975e-02f, -2.59625055e-02f, -1.10321388e-01f, 2.06446368e-02f, 7.59223625e-02f, -6.45400360e-02f, 2.79583223e-02f, -1.06860407e-01f, -1.62500944e-02f, -3.55833992e-02f,
  -1.36930142e-02f, -8.09990689e-02f, 1.53664676e-02f, 7.80065805e-02f, -3.28938439e-02f, -5.91991059e-02f, 1.08290531e-01f, 2.14226190e-02f, -7.09532499e-02f, -1.02082491e-01f,
  -3.83796662e-01f, 9.17540565e-02f, 1.50644973e-01f, -1.52395606e-01f, -5.59144132e-02f, 7.28621259e-02f, 1.50858343e-01f, 3.02602611e-02f, -6.16691895e-02f, 1.77106187e-01f,
  8.90543312e-02f, -1.18319832e-01f, 9.84127074e-02f, 1.14492238e-01f, -1.85522348e-01f, 1.11408956e-01f, -6.18029684e-02f, -6.63266471e-03f, -7.01327920e-02f, -1.27243295e-01f,
  -2.29866486e-02f, 1.10365048e-01f, 1.10818475e-01f, 6.20049499e-02f, 2.59424727e-02f, -8.50329027e-02f, -8.01047832e-02f, 1.70997977e-02f, 4.23599370e-02f, -9.40021127e-02f,
  -3.01577479e-01f, -1.02736667e-01f, -5.82772605e-02f, -1.24188714e-01f, -9.35654938e-02f, -6.53177872e-02f, 6.17296388e-03f, 1.07472915e-04f, -7.81240016e-02f, 3.91368940e-02f,
  8.48414674e-02f, -5.05652018e-02f, 2.74834987e-02f, 6.06404021e-02f, -3.48186754e-02f, 3.10404748e-02f, -5.93162179e-02f, -5.28980978e-02f, -1.83218401e-02f, 9.62673649e-02f,
  8.58346652e-03f, -4.28195199e-04f, -7.21938089e-02f, 6.37125671e-02f, -5.91734089e-02f, 1.12219462e-02f, 5.22338077e-02f, -6.76599564e-04f, 4.64555100e-02f, -2.86512990e-02f,
  -3.05871740e-02f, 7.30080828e-02f, 9.28335786e-02f, -2.24314332e-02f, 1.76618528e-03f, 9.89561528e-03f, 4.02327664e-02f, -7.71112414e-03f, -1.07840560e-01f, 7.03376830e-02f,
  -6.03514388e-02f, 2.39433302e-03f, -1.28875347e-02f, 8.70106518e-02f, -3.10650971e-02f, 1.97859984e-02f, 5.05367778e-02f, -2.76845191e-02f, 8.42070952e-02f, -6.86974227e-02f,
  -1.24974260e-02f, -6.63148314e-02f, 1.01407506e-01f, -2.26421691e-02f, 1.28069669e-02f, -1.83351655e-02f, 1.21978146e-03f, -3.57373655e-02f, 5.37346341e-02f, -2.15295646e-02f,
  -3.24275345e-01f, -2.94425428e-01f, 5.12165576e-02f, -1.33313149e-01f, 7.57643161e-03f, -4.09827121e-02f, -6.79038391e-02f, -6.02921434e-02f, -8.62364620e-02f, -1.18136324e-01f,
  -4.74730916e-02f, -1.69995818e-02f, 3.05136703e-02f, 8.76164809e-03f, -3.37692313e-02f, -6.18022215e-03f, -9.96669009e-03f, -7.79099241e-02f, -1.29112881e-02f, -3.15804370e-02f,
  8.24917853e-03f, -4.66344096e-02f, 9.10337269e-02f, -4.32846434e-02f, -5.78114837e-02f, -4.71884310e-02f, -9.93136466e-02f, 3.49229798e-02f, -6.46731928e-02f, 9.97989550e-02f,
  6.98689520e-02f, -1.65675506e-01f, -1.32372066e-01f, 1.09069206e-01f, 1.07986473e-01f, 1.32304365e-02f, -1.39656439e-01f, -4.25102785e-02f, -1.07440092e-01f, -1.63452923e-01f,
  -4.49205227e-02f, 3.20077278e-02f, -4.96868156e-02f, 1.48289815e-01f, 8.47066119e-02f, -1.44681618e-01f, 1.76791325e-01f, 1.09944440e-01f, -7.97586143e-02f, 6.06094347e-03f,
  -3.93628282e-03f, 1.98414922e-01f, -7.33362064e-02f, -2.89686577e-04f, 1.65193260e-01f, -1.16074309e-01f, -6.02739714e-02f, -1.06166370e-01f, 1.00806005e-01f, 5.47091626e-02f,
  1.43317044e-01f, -1.33613320e-02f, -4.63358909e-02f, 9.05415416e-02f, -1.68188825e-01f, 5.91949038e-02f, 5.03320508e-02f, 7.25809112e-02f, 9.86489132e-02f, -7.54100829e-02f,
  -4.60698158e-02f, 6.47330284e-02f, 4.89660874e-02f, 4.49324213e-02f, 6.05430119e-02f, 3.95603441e-02f, -2.62320340e-02f, 8.23384225e-02f, 7.95008242e-03f, 3.22471373e-02f,
  -2.62678396e-02f, 7.48864785e-02f, 1.23000490e-02f, 2.39772908e-02f, -2.12543528e-03f, -6.05283156e-02f, 7.99892619e-02f, 3.72790918e-02f, 8.02370012e-02f, 8.57430398e-02f,
  4.26828861e-02f, 4.12625037e-02f, -1.82013456e-02f, 5.61834946e-02f, -6.11651130e-02f, -7.06469044e-02f, -8.72092992e-02f, 1.31487036e-02f, -5.62432632e-02f, -2.71798554e-03f,
  5.73165715e-02f, 3.33466614e-03f, 9.31049511e-02f, -8.29507634e-02f, -5.68341743e-03f, 6.87550455e-02f, 4.80414033e-02f, -1.70241464e-02f, -5.20363525e-02f, -8.61776322e-02f,
  6.19473271e-02f, 8.45731497e-02f, 1.32924616e-02f, -6.88549131e-02f, 1.09056108e-01f, 7.45166186e-03f, -7.28266984e-02f, 4.38390933e-02f, -8.13421234e-02f, -5.95181957e-02f,
  -4.91607338e-02f, -1.85869589e-01f, -7.61977062e-02f, 1.57548375e-02f, -2.65138727e-02f, -9.24616307e-02f, -6.07357398e-02f, 9.26840901e-02f, -3.03961802e-02f, -1.70786050e-03f,
  -2.52156556e-02f, 4.15097922e-02f, -7.73204565e-02f, 2.59101968e-02f, -7.62729868e-02f, 7.94742554e-02f, -5.56160919e-02f, 1.14965215e-02f, 2.29682121e-02f, 2.08230950e-02f,
  2.91719511e-02f, 3.52656953e-02f, 9.34061855e-02f, -1.39928749e-02f, -6.77544530e-03f, -3.16665322e-02f, -1.23380944e-02f, -5.68217374e-02f, 2.61322558e-02f, 7.81169236e-02f,
  -3.16707492e-01f, 9.84087307e-03f, 1.89758256e-01f, -4.39230129e-02f, -7.43446723e-02f, 2.90507406e-01f, 3.31428111e-01f, 2.08330732e-02f, -1.14460118e-01f, 2.49844883e-02f,
  1.22066133e-01f, -3.22359614e-02f, 1.66299403e-01f, 1.00871824e-01f, 1.53006256e-01f, 1.99030668e-01f, 1.19307376e-01f, 5.77234942e-03f, -1.08945586e-01f, -5.99366762e-02f,
  -2.80397758e-02f, 8.68695900e-02f, 1.57795295e-01f, -1.16284214e-01f, -1.16619794e-02f, -1.38233453e-01f, 1.22967057e-01f, 5.73840514e-02f, 1.93085931e-02f, 1.65727094e-01f,
  -1.42029300e-01f, -1.72635272e-01f, -1.21528022e-02f, 6.47037104e-02f, 6.62227049e-02f, 5.36513142e-02f, 9.17918608e-02f, 4.86190356e-02f, -1.13397300e-01f, 7.44892657e-02f,
  6.50124848e-02f, 1.21640721e-02f, -4.68855277e-02f, 4.86983210e-02f, -1.14797473e-01f, -3.66029404e-02f, -1.29806846e-01f, -3.79464403e-02f, -7.78645650e-02f, 3.16685960e-02f,
  1.10876739e-01f, 2.62928363e-02f, 5.14814593e-02f, 7.23860115e-02f, 5.71061336e-02f, 3.21947671e-02f, 1.83471479e-02f, 4.86131497e-02f, -1.58253703e-02f, 2.23745834e-02f,
  7.80446678e-02f, -4.32237014e-02f, -3.97225320e-02f, -3.01910210e-02f, 1.91712845e-02f, 1.03416452e-02f, -1.80839449e-02f, 4.43598703e-02f, -2.33415850e-02f, -7.21879900e-02f,
  2.25943103e-02f, 4.91070037e-04f, -9.28866789e-02f, -1.53464507e-02f, 7.59667084e-02f, -2.41422784e-02f, 2.10902803e-02f, -5.64858913e-02f, -9.01160538e-02f, 1.73184858e-03f,
  -8.65500048e-03f, 1.09020934e-01f, 2.45978730e-03f, -5.57339676e-02f, 8.35451782e-02f, 6.41281009e-02f, 4.13633175e-02f, -4.88460213e-02f, 4.26456332e-02f, 7.06102885e-03f,
  5.95708843e-03f, -9.02717039e-02f, 2.00607404e-02f, -5.92823289e-02f, -6.73607811e-02f, 2.74888165e-02f, 8.48239940e-03f, 1.01716900e-02f, 6.83458820e-02f, -1.19738713e-01f,
  -1.72209740e-02f, -2.61259004e-02f, 1.88658796e-02f, 1.19199585e-02f, 1.19393304e-01f, 1.95296407e-02f, -4.30942550e-02f, -8.21072534e-02f, 8.07615966e-02f, 1.39817968e-01f,
  -5.80854947e-03f, 3.35087366e-02f, 4.44581434e-02f, 1.71803273e-02f, -3.56554985e-02f, 7.27486536e-02f, -7.71562308e-02f, 7.55975605e-04f, 6.57629371e-02f, 7.71522447e-02f,
  8.17826167e-02f, -3.93484756e-02f, -3.51390429e-02f, -9.62821245e-02f, -3.37679125e-02f, -2.41809756e-01f, -1.49267286e-01f, -6.65126815e-02f, 1.00673094e-01f, 9.18352082e-02f,
  -8.11245143e-02f, 1.35227993e-01f, -2.22906992e-02f, -1.35603338e-01f, -1.48570448e-01f, 2.34113578e-02f, -2.35733733e-01f, -1.10490553e-01f, 7.86034539e-02f, -1.87418208e-01f,
  -5.51919527e-02f, -2.12972030e-01f, -1.23224169e-01f, -2.03848407e-01f, -2.30327904e-01f, 5.81193045e-02f, 1.80173740e-02f, -1.75921217e-01f, -3.17137279e-02f, -1.60455238e-02f,
  -2.33623534e-02f, 3.87941301e-02f, 6.93901926e-02f, 5.18242866e-02f, -9.42650586e-02f, 1.88162979e-02f, -2.16191579e-02f, 1.94384586e-02f, 2.21203677e-02f, -5.63121885e-02f,
  -5.97979426e-02f, -6.09604223e-03f, -6.96488246e-02f, -5.56102544e-02f, 1.32892663e-02f, 3.75540294e-02f, -4.70207296e-02f, -8.77832770e-02f, 1.85645241e-02f, 2.82325484e-02f,
  8.50325357e-03f, 6.47987425e-02f, 3.38173620e-02f, 1.35097340e-01f, 7.14675859e-02f, 4.21968289e-02f, -7.08082551e-03f, -6.36471584e-02f, 5.84244914e-03f, 4.83318903e-02f,
  5.49812913e-02f, -7.81640410e-02f, -5.50391376e-02f, -4.65264656e-02f, 9.80283692e-02f, -3.51447575e-02f, 5.64926937e-02f, 2.80545801e-02f, -1.57959554e-02f, -8.02506655e-02f,
  -1.04172409e-01f, 4.79956791e-02f, 1.34334629e-02f, 9.92884859e-02f, -1.67914312e-02f, 1.23222798e-01f, -5.84032200e-02f, 1.27121108e-02f, -7.65980184e-02f, 4.05747667e-02f,
  2.43348014e-02f, 7.78740924e-03f, 3.88488881e-02f, -6.90674186e-02f, -4.70169000e-02f, 5.09628700e-03f, 2.72830166e-02f, 2.39933319e-02f, -8.94605443e-02f, -6.24216273e-02f,
  -7.18569830e-02f, 8.12519863e-02f, -2.27650963e-02f, 2.45119296e-02f, 2.76169665e-02f, -2.77885352e-03f, -5.16715534e-02f, -4.23069336e-02f, 7.28264377e-02f, -4.94561233e-02f,
  5.61941834e-03f, -7.34026134e-02f, -4.84236181e-02f, 8.05777386e-02f, 5.22387074e-03f, 1.40902139e-02f, -4.25619669e-02f, -9.81535465e-02f, 6.18992373e-02f, 3.06206625e-02f,
  -6.87047616e-02f, -2.70578880e-02f, 6.31417856e-02f, -3.48356888e-02f, 7.96962008e-02f, 1.80974249e-02f, 1.23843197e-02f, 4.72469591e-02f, -1.01493038e-01f, 8.38596523e-02f,
  1.81759104e-01f, 1.94683015e-01f, 1.33354943e-02f, 9.56520885e-02f, -6.51500514e-03f, -1.90159380e-01f, -1.96837217e-01f, 3.59014422e-03f, 2.75071315e-03f, -1.27242431e-02f,
  -5.66031272e-03f, 1.28164053e-01f, -1.56762436e-01f, 1.35044158e-01f, -3.82378213e-02f, -1.46499664e-01f, 1.66672185e-01f, -7.66466483e-02f, -7.27926567e-02f, 7.39335790e-02f,
  7.32711405e-02f, 8.22229609e-02f, 1.11368887e-01f, 1.25067353e-01f, 1.72320291e-01f, -3.40709314e-02f, 7.51530230e-02f, -9.48703662e-02f, 6.36571348e-02f, 3.36029707e-03f,
  -2.26913132e-02f, 9.28326026e-02f, 3.86315808e-02f, -4.33038585e-02f, 3.29781808e-02f, 5.42701557e-02f, -1.24288574e-01f, -1.27094731e-01f, -3.21227196e-03f, -8.48986208e-02f,
  4.47614267e-02f, 7.82042649e-03f, 1.98879484e-02f, 2.91564185e-02f, -1.83060784e-02f, 3.00708879e-02f, -6.69094324e-02f, -5.51970042e-02f, 8.85348320e-02f, 2.05158629e-02f,
  3.86552326e-02f, 4.31840792e-02f, 4.55283001e-02f, 3.20782177e-02f, 1.54374912e-02f, -6.42854124e-02f, -1.24698684e-01f, 5.14156744e-02f, -1.13999611e-03f, -1.72669012e-02f,
  2.57373995e-05f, -3.77215557e-02f, -5.11804856e-02f, 1.59801710e-02f, 1.37214661e-02f, -4.15306585e-03f, -7.53974020e-02f, -1.45916477e-01f, -9.69568789e-02f, -2.86709219e-02f,
  -6.50877357e-02f, -1.82112248e-03f, 6.38007149e-02f, 1.46254543e-02f, 3.36719863e-02f, 2.90913023e-02f, -3.04625276e-02f, -4.32559662e-02f, -8.02973360e-02f, -2.86175702e-02f,
  -1.00796223e-02f, 8.68821293e-02f, -9.80720222e-02f, 3.05140577e-02f, -5.56188449e-02f, 8.85964632e-02f, 5.16529428e-03f, -3.14029306e-02f, -7.42031112e-02f, -2.11336892e-02f,
  1.49330599e-02f, 1.33678362e-01f, -6.63041696e-02f, -4.98163775e-02f, 6.09160550e-02f, 5.55403307e-02f, -5.76600470e-02f, -7.34833488e-03f, 7.80730844e-02f, -7.40172043e-02f,
  1.00774318e-01f, -3.45518775e-02f, 1.11383826e-01f, 5.00705130e-02f, 4.94724978e-03f, 2.51041595e-02f, -5.58163412e-02f, 5.84170781e-02f, -2.99519822e-02f, 8.73219296e-02f,
  1.09131999e-01f, 5.48628606e-02f, -7.51327584e-03f, 2.25430746e-02f, 3.76877561e-02f, -3.25048752e-02f, -3.43981236e-02f, -8.86212140e-02f, 7.93315470e-02f, 1.18141053e-02f,
  -2.87963271e-01f, 6.16142824e-02f, -2.42674023e-01f, 7.51803070e-02f, -1.28438190e-01f, -1.54521435e-01f, -1.66867137e-01f, -6.88784271e-02f, -8.21500421e-02f, 2.38531128e-01f,
  -6.97802305e-02f, 9.03633386e-02f, -3.36527750e-02f, 2.57758230e-01f, -3.73811880e-03f, 1.91072404e-01f, 1.14665501e-01f, 1.64534166e-01f, -1.75720509e-02f, -1.10658228e-01f,
  4.17261161e-02f, 8.98986757e-02f, 4.43584211e-02f, 3.09923831e-02f, 4.25916053e-02f, -3.67884077e-02f, 1.47388324e-01f, -6.83392659e-02f, 1.38928220e-02f, -3.04987095e-02f,
  -6.92450404e-02f, -8.39807733e-04f, -4.43587862e-02f, -6.31009042e-02f, -5.64989783e-02f, -1.62665099e-01f, -5.22923432e-02f, -8.11212808e-02f, -5.91055155e-02f, -3.35990191e-02f,
  -3.30444723e-02f, 5.63170053e-02f, 7.91949481e-02f, -8.92832726e-02f, -8.68418142e-02f, -1.33305881e-02f, 6.20487891e-02f, -1.40168471e-03f, -5.89837208e-02f, -1.85280498e-02f,
  9.20358021e-03f, 3.27379741e-02f, 5.18031232e-02f, 9.26930457e-02f, 4.85548340e-02f, 7.35516399e-02f, 7.29762465e-02f, -3.84004340e-02f, -3.30653191e-02f, 5.47541641e-02f,
  -6.96058422e-02f, 6.14653565e-02f, -3.53144556e-02f, 9.28547755e-02f, -6.24488071e-02f, -2.77939141e-02f, 6.56111017e-02f, 2.36042235e-02f, -2.79566478e-02f, -1.01844827e-02f,
  -9.62933525e-02f, -1.05518391e-02f, 2.07784753e-02f, -1.00580998e-01f, -3.96416988e-03f, -5.80565892e-02f, -4.92874682e-02f, -4.77777747e-03f, -4.84780371e-02f, -3.82830575e-02f,
  6.15806058e-02f, -4.73421030e-02f, 1.06730973e-02f, -7.49215707e-02f, -8.66549984e-02f, -4.50655147e-02f, 4.94562499e-02f, -5.04957885e-02f, 3.22442986e-02f, 2.71557998e-02f,
  -6.07147887e-02f, 3.17456909e-02f, -5.82112446e-02f, 1.61033950e-05f, -8.47198814e-02f, -5.44031560e-02f, 6.28086319e-03f, -4.51217294e-02f, -1.79328397e-02f, -1.21138938e-01f,
  -1.08548909e-01f, 8.67725089e-02f, -5.17742485e-02f, -6.65486902e-02f, 3.28500122e-02f, 6.40013367e-02f, -2.02615163e-03f, 2.80997646e-03f, -5.29571138e-02f, 1.39831109e-02f,
  -4.14209366e-02f, -9.59134027e-02f, -1.29809850e-04f, 6.83610737e-02f, 7.42247924e-02f, 7.10674911e-04f, -8.17238316e-02f, 9.76834632e-03f, -1.50384484e-02f, 1.12479525e-02f,
  2.53178418e-01f, -1.57637373e-01f, -2.29677651e-02f, 1.75847918e-01f, 1.70956299e-01f, 8.85406286e-02f, -1.08834058e-01f, 1.78033948e-01f, 1.92200661e-01f, -6.77344901e-03f,
  8.50827470e-02f, -1.28972381e-01f, -2.47921646e-01f, 1.91035509e-01f, 1.63170949e-01f, -1.18711658e-01f, 1.88533098e-01f, 4.52883504e-02f, 8.20059776e-02f, 1.18576206e-01f,
  1.89056590e-01f, 1.10759057e-01f, -1.07407287e-01f, -6.53146803e-02f, 1.78211648e-02f, -4.12538946e-02f, -7.54442066e-02f, -4.57439907e-02f, -2.85883490e-02f, 9.98014584e-03f,
  3.46521585e-04f, 1.42736500e-02f, -6.49818033e-03f, -7.29638264e-02f, -3.10673541e-03f, -1.03256784e-01f, 2.54189894e-02f, -9.43632796e-03f, 1.78288408e-02f, 2.43005566e-02f,
  -6.68903664e-02f, -4.06671837e-02f, -5.01916930e-02f, -1.26211541e-02f, -2.36680135e-02f, -3.31327692e-02f, 6.95491657e-02f, -3.46501507e-02f, 5.50348684e-02f, 3.95750068e-02f,
  -5.66839017e-02f, -9.75960940e-02f, 1.08814590e-01f, -3.22269425e-02f, -7.42564201e-02f, -9.80882067e-03f, -3.70766260e-02f, -8.75477567e-02f, -2.40876749e-02f, 5.46265393e-02f,
  3.67261954e-02f, -6.20467663e-02f, 8.73256568e-03f, 9.02093872e-02f, -1.74609162e-02f, 4.77287360e-02f, 9.54746455e-02f, 5.79192452e-02f, 3.82077359e-02f, -3.23892869e-02f,
  3.18022892e-02f, 1.09677892e-02f, 9.41293836e-02f, -1.54683797e-03f, 2.48485189e-02f, 9.33544617e-03f, -4.14336622e-02f, 8.86495784e-03f, 2.88640130e-02f, 5.67575656e-02f,
  6.47558868e-02f, -1.90953221e-02f, -9.40558687e-02f, -1.64875537e-02f, 7.30326995e-02f, 4.93952306e-03f, 5.43711483e-02f, -7.74416178e-02f, -1.74791999e-02f, -9.41647813e-02f,
  4.07667831e-02f, -9.86063778e-02f, -6.50532320e-02f, 1.37972608e-02f, 3.38741094e-02f, 5.40148728e-02f, 6.44588890e-03f, -2.19973680e-02f, 5.63552715e-02f, -6.14527464e-02f,
  -3.43360528e-02f, -2.31569493e-03f, -3.03032827e-02f, 3.44276801e-02f, 8.70105028e-02f, 4.61932011e-02f, -4.72328141e-02f, 4.78550792e-03f, 3.93878967e-02f, -9.71062183e-02f,
  -5.55067509e-02f, -4.93574999e-02f, 6.37872070e-02f, 4.05071303e-02f, -4.00312543e-02f, -1.57795742e-01f, -3.46324816e-02f, -2.80263252e-03f, 8.78953654e-03f, 5.75804189e-02f,
  -1.39265105e-01f, 2.03200266e-01f, 2.25425914e-01f, 2.55727530e-01f, -1.85239628e-01f, 1.54986531e-01f, 1.38966620e-01f, 1.06423974e-01f, 1.34828597e-01f, 1.69446915e-01f,
  6.70684781e-03f, 5.79647385e-02f, 7.31210783e-02f, 1.11495495e-01f, -6.52635768e-02f, 8.76166448e-02f, 1.59471899e-01f, 1.08383648e-01f, -2.11966336e-02f, 1.06877275e-01f,
  -1.44105237e-02f, 4.99227382e-02f, 7.19001219e-02f, -3.77638564e-02f, -1.27159327e-01f, -4.22225967e-02f, 5.28231822e-02f, 6.11022189e-02f, -1.32728770e-01f, -1.35238357e-02f,
  4.83999774e-02f, 7.75561854e-02f, -8.59902203e-02f, -7.10679069e-02f, -1.02210492e-01f, -1.04490370e-01f, 3.20313647e-02f, -2.70290934e-02f, -7.53676742e-02f, -3.08876764e-02f,
  -7.06794858e-02f, -2.02637687e-02f, -4.48080041e-02f, 8.51577520e-02f, -3.23586091e-02f, 6.24033362e-02f, -1.58380643e-02f, -1.29385656e-02f, -4.67370562e-02f, -1.38082830e-02f,
  -4.71866690e-03f, -1.01620853e-01f, 2.38378160e-02f, -1.95577070e-02f, -1.48051642e-02f, -6.13291636e-02f, 1.11271128e-01f, -4.49443003e-04f, 1.63563974e-02f, -1.40605273e-03f,
  -3.09169963e-02f, 1.11868970e-01f, 2.26959679e-02f, 3.66704874e-02f, -4.23984490e-02f, -2.76013147e-02f, 8.02523717e-02f, 9.07426402e-02f, -9.29650888e-02f, 2.36944538e-02f,
  -5.67364134e-02f, 3.28431316e-02f, -5.67867495e-02f, -1.64452177e-02f, -3.67960930e-02f, 2.30073128e-02f, -3.96457277e-02f, -1.00352868e-01f, -2.18742508e-02f, -4.21583056e-02f,
  8.36768672e-02f, 4.16481681e-02f, 1.57350954e-02f, -4.68890406e-02f, 7.17695504e-02f, 7.05263987e-02f, 6.40408397e-02f, -5.59122860e-02f, -6.43049851e-02f, -9.67136696e-02f,
  2.95696929e-02f, 1.32246077e-01f, -1.99245736e-02f, -1.26801422e-02f, -3.45583074e-02f, -6.77491054e-02f, 6.00461895e-03f, -8.87594745e-02f, -2.02566218e-02f, -9.48295370e-02f,
  -2.28577703e-02f, 8.07748809e-02f, 8.87809619e-02f, -1.44721707e-02f, -7.09019229e-02f, -7.04777911e-02f, 5.06989248e-02f, 9.00871903e-02f, 6.22925870e-02f, -1.32793467e-02f,
  -1.03220612e-01f, 3.52279246e-02f, 1.86924040e-02f, -1.02065310e-01f, -4.31593284e-02f, -1.00406952e-01f, 5.90166561e-02f, 7.26698488e-02f, -1.33607477e-01f, 6.38895631e-02f,
  -3.56053591e-01f, 2.05747724e-01f, -7.16217309e-02f, -1.86587244e-01f, -1.30244559e-02f, -4.48851362e-02f, -1.31606758e-01f, -1.07740559e-01f, -5.80489188e-02f, -4.81178537e-02f,
  -1.29273608e-01f, -8.37820545e-02f, -7.95860868e-03f, -4.73964848e-02f, 2.50750408e-02f, 9.88301039e-02f, -1.38162924e-02f, -7.16672838e-02f, 6.86518624e-02f, -2.01017573e-01f,
  7.77979419e-02f, -7.71144181e-02f, 7.60474876e-02f, 1.27755171e-02f, -2.09082335e-01f, -1.19540051e-01f, -1.27179855e-02f, -4.59253080e-02f, -6.18360005e-02f, -2.72891279e-02f,
  -1.15455516e-01f, -2.38389120e-01f, -1.98746830e-01f, -1.57504946e-01f, -1.11153573e-01f, -9.24185142e-02f, -7.67097771e-02f, 1.84402207e-03f, -3.57160047e-02f, 2.01513786e-02f,
  -4.74432036e-02f, 1.21663697e-02f, 4.56892923e-02f, 8.53630230e-02f, -3.67870741e-02f, -9.30300057e-02f, 1.36997243e-02f, -3.53975184e-02f, 3.85395950e-03f, 7.03438534e-04f,
  6.50121495e-02f, -1.50649007e-02f, -7.48153776e-02f, 3.16605046e-02f, 3.04887560e-03f, -4.99093309e-02f, -1.58085127e-03f, 9.50995833e-03f, -3.39383222e-02f, 2.76359972e-02f,
  -1.04144597e-02f, -1.98167786e-02f, -8.07290617e-03f, -2.89393645e-02f, -5.55019034e-03f, 6.23269519e-03f, 2.83174198e-02f, -6.48289248e-02f, 4.10769135e-02f, 5.82767539e-02f,
  6.58721849e-02f, 5.63265942e-02f, -7.86629245e-02f, 1.03154756e-01f, 5.95187321e-02f, 1.91639066e-02f, 3.72495614e-02f, -2.27705413e-03f, -2.00037844e-02f, -5.28152706e-03f,
  7.26846308e-02f, 7.77316913e-02f, 4.88310307e-02f, -5.68855703e-02f, -8.86697546e-02f, -8.81310776e-02f, -4.36916612e-02f, 6.18987978e-02f, 5.72971366e-02f, 1.63591038e-02f,
  -1.35830417e-01f, -2.57419199e-01f, -8.58342797e-02f, -8.89775082e-02f, -3.74057926e-02f, 1.48925558e-02f, 3.66379283e-02f, -1.19037665e-02f, 2.87247133e-02f, 4.17486206e-02f,
  3.34086008e-02f, -1.12543158e-01f, -6.76356405e-02f, 7.06743170e-03f, 3.00210640e-02f, 3.27113234e-02f, 3.66064794e-02f, 1.54572222e-02f, -8.69111530e-03f, 5.84164038e-02f,
  -2.83797178e-03f, 1.11281057e-03f, 2.22866070e-02f, -7.65976980e-02f, 4.65791523e-02f, -4.93249334e-02f, -3.24239247e-02f, 3.22926715e-02f, 4.26034536e-03f, 1.02493642e-02f,
  1.07798360e-01f, -3.55581075e-01f, 1.17741264e-01f, -4.84396517e-03f, 1.34226561e-01f, -1.00427099e-01f, 1.68267787e-02f, -1.12724565e-01f, 1.40507624e-01f, -2.32114792e-01f,
  -6.76627085e-02f, -8.85709301e-02f, 5.86084053e-02f, -1.90488115e-01f, 2.38168895e-01f, 4.78531383e-02f, -2.35156417e-02f, -5.57367727e-02f, 2.57438533e-02f, -4.99102622e-02f,
  1.42774388e-01f, -1.34453952e-01f, 8.55465420e-03f, -1.71078414e-01f, 2.98463553e-02f, 6.15905002e-02f, 1.45940306e-02f, 5.56186177e-02f, -1.48628175e-01f, -1.66116154e-03f,
  -1.18279725e-01f, -9.90463719e-02f, 4.14688587e-02f, -4.83443961e-02f, -1.58114940e-01f, -4.42486443e-02f, -2.69484837e-02f, -7.43493205e-03f, 2.90626567e-02f, 8.31920058e-02f,
  -8.97910167e-03f, 2.33217962e-02f, 3.91270109e-02f, 2.19982099e-02f, -6.14332668e-02f, -6.82391524e-02f, 2.11382341e-02f, -7.87547082e-02f, 1.42330024e-02f, 1.58535726e-02f,
  -7.92470668e-03f, 5.12744598e-02f, 1.08771324e-01f, 1.46724675e-02f, 3.51563729e-02f, -7.67079145e-02f, 1.25068635e-01f, 9.01405439e-02f, -7.16947466e-02f, -2.14412957e-02f,
  7.61015192e-02f, 7.30807185e-02f, 7.32557997e-02f, 5.23908511e-02f, 1.25252903e-02f, 1.07783787e-02f, -5.28566390e-02f, -5.69720678e-02f, -3.18640992e-02f, -3.25350203e-02f,
  3.37419391e-04f, -5.61833531e-02f, 3.35072130e-02f, 5.34470417e-02f, -3.65615152e-02f, 2.74218507e-02f, 8.64604115e-03f, -1.97149515e-02f, 3.65030840e-02f, -3.69137600e-02f,
  -3.98631133e-02f, -3.68429124e-02f, 1.59880202e-02f, 5.54504171e-02f, 3.47078182e-02f, 1.16159409e-01f, -7.68711939e-02f, 9.96761769e-02f, 5.27255833e-02f, 3.30351628e-02f,
  -3.19182366e-01f, -2.47327909e-01f, -3.75637412e-02f, -8.84691924e-02f, -2.58920379e-02f, 4.52265926e-02f, -4.22279425e-02f, 7.28609934e-02f, -6.20336644e-02f, 2.37549450e-02f,
  2.19315588e-02f, 1.64920501e-02f, -5.97847812e-03f, 4.47333492e-02f, -4.55192402e-02f, -2.31265724e-02f, -9.61847007e-02f, -5.27027156e-03f, -7.30726123e-02f, -5.79076000e-02f,
  -3.56646458e-04f, -1.56328939e-02f, 1.25208776e-02f, 7.34182894e-02f, 3.42860594e-02f, 8.47385358e-03f, -1.19363964e-02f, 6.50515035e-02f, -3.46937440e-02f, 6.81335628e-02f,
  -1.21319540e-01f, -1.29745752e-01f, -8.14601481e-02f, 1.32162705e-01f, 1.09862238e-01f, -6.24950156e-02f, -1.13235936e-01f, 1.45627066e-01f, -1.17603086e-01f, -5.05260825e-02f,
  5.60924076e-02f, -1.32843539e-01f, -1.05264843e-01f, -8.55401829e-02f, -3.38854566e-02f, -1.94594398e-01f, 2.61853375e-02f, -3.26941237e-02f, -1.91718768e-02f, 2.87700649e-02f,
  5.38999327e-02f, -3.35695669e-02f, 4.54032086e-02f, 1.68425590e-01f, 4.50287424e-02f, 7.33668506e-02f, 1.64596051e-01f, 2.80089509e-02f, 1.02473512e-01f, 8.04241747e-02f,
  4.15358320e-02f, -1.18519522e-01f, -2.66182814e-02f, -1.23019837e-01f, 1.38450757e-01f, 1.10047936e-01f, 9.39475074e-02f, -1.01652987e-01f, 5.08994795e-02f, -7.08050951e-02f,
  -7.94459879e-02f, -2.42936760e-02f, 1.13304406e-02f, -6.10151701e-02f, 1.02194130e-01f, 1.65039357e-02f, -6.63425848e-02f, -4.14318442e-02f, -8.14554542e-02f, -1.18844613e-01f,
  -1.11433212e-03f, 6.65949052e-03f, 2.32783072e-02f, 3.08502559e-02f, 1.21871941e-02f, -4.61159423e-02f, 2.33027292e-03f, 5.26481010e-02f, 6.50256574e-02f, 1.24687869e-02f,
  2.04082113e-02f, 7.48330131e-02f, 7.93573931e-02f, 1.65714305e-02f, 6.00132300e-03f, 4.34892140e-02f, 4.24127281e-02f, 6.11492097e-02f, 5.97348250e-02f, -5.01039922e-02f,
  4.51746024e-02f, -4.53936082e-05f, -7.26000741e-02f, -5.54594025e-02f, 8.04486871e-03f, -5.13792783e-02f, 6.80886209e-02f, -3.16294618e-02f, -2.14540232e-02f, 8.12984109e-02f,
  -3.12078614e-02f, 4.42117453e-02f, -4.19396348e-02f, -1.11107500e-02f, -7.62336329e-02f, -1.18729696e-01f, -9.54687595e-03f, -1.07738584e-01f, -1.74227543e-02f, 3.37659083e-02f,
  -5.29977009e-02f, 6.43993318e-02f, -3.92743532e-04f, 1.34428516e-02f, -8.87797680e-03f, 5.59064224e-02f, -1.38588110e-02f, 7.26808012e-02f, -2.94378325e-02f, -6.40166085e-03f,
  -2.73615755e-02f, 6.34612143e-02f, 1.46526307e-01f, -7.09294248e-03f, 9.93107408e-02f, -4.70602810e-02f, -3.29860523e-02f, 4.53571044e-02f, 8.62060189e-02f, -6.55462444e-02f,
  -3.13301161e-02f, 2.56205890e-02f, 1.41182154e-01f, 5.30506708e-02f, 8.30844492e-02f, 1.25545800e-01f, 9.47826430e-02f, 4.80641127e-02f, 7.79568553e-02f, -2.27783178e-03f,
  -3.43065917e-01f, 2.43341297e-01f, 8.23246017e-02f, 5.49485758e-02f, 7.85266515e-03f, 2.83663899e-01f, 2.91800320e-01f, 1.10758677e-01f, 8.88765603e-02f, 1.96575269e-01f,
  7.06850085e-03f, 4.19451930e-02f, 3.38428654e-02f, 3.67562734e-02f, 8.05946141e-02f, 8.92556012e-02f, 7.74957463e-02f, 1.31974563e-01f, 1.34593502e-01f, -1.60157785e-01f,
  -1.25815570e-01f, 6.12908490e-02f, 4.42249216e-02f, -9.34455097e-02f, -1.00654759e-01f, -9.72635746e-02f, -6.28412813e-02f, 2.89732199e-02f, -3.84906940e-02f, 2.57881489e-02f,
  2.63360031e-02f, -1.04566418e-01f, -1.90261215e-01f, -8.89675990e-02f, -2.12334599e-02f, -3.79181700e-03f, -2.41292920e-02f, 4.24981564e-02f, -1.09926939e-01f, -3.95723283e-02f,
  -6.89252629e-04f, 3.77312191e-02f, 2.27351710e-02f, -5.62270544e-03f, -2.31732931e-02f, -2.88327970e-02f, -4.79380228e-02f, -2.55510192e-02f, -1.68722812e-02f, 3.78367811e-04f,
  -3.93079408e-02f, 2.91269068e-02f, -3.08975745e-02f, 5.24456799e-02f, -3.52800265e-02f, -5.67006692e-03f, 5.99459670e-02f, 5.31741306e-02f, -2.03935453e-03f, -1.29042845e-02f,
  -6.65509552e-02f, 3.96297649e-02f, -3.28126922e-03f, 3.61104347e-02f, 4.53084223e-02f, 1.46842040e-02f, -4.81843129e-02f, -7.16819465e-02f, 1.65166333e-02f, -6.42860010e-02f,
  5.35260662e-02f, -4.01478782e-02f, 3.30605619e-02f, 4.01178114e-02f, 2.58714836e-02f, -2.95359213e-02f, -4.06789817e-02f, -2.20421664e-02f, 2.18152050e-02f, -4.92471270e-02f,
  -4.41277623e-02f, -4.27756198e-02f, 6.64218515e-02f, -3.39451581e-02f, 4.23729159e-02f, 1.89242475e-02f, -5.49849123e-02f, 7.58607686e-02f, -8.61978978e-02f, -5.88126183e-02f,
  1.48192376e-01f, -1.32765127e-02f, -4.26623486e-02f, -4.56324406e-02f, 7.59113673e-03f, -3.65768895e-02f, 6.49665594e-02f, -3.65401665e-03f, 6.60497546e-02f, -7.53155202e-02f,
  1.18091963e-02f, 1.11331698e-02f, 3.96409407e-02f, -6.77761361e-02f, 1.14976659e-01f, 4.75054514e-03f, -2.12098565e-02f, 3.12525444e-02f, -8.01120326e-02f, 1.58030633e-03f,
  -3.10014971e-02f, 1.50341459e-03f, 6.62699863e-02f, -3.59713729e-03f, 6.55753762e-02f, -1.71122479e-03f, -5.46531416e-02f, -1.57299992e-02f, 3.44181135e-02f, 4.51218337e-02f,
  -5.20871170e-02f, -2.48100515e-02f, -2.19112456e-01f, -9.71280262e-02f, -7.04485551e-02f, 1.66718084e-02f, -3.80857065e-02f, -1.08609445e-01f, -1.92545444e-01f, 2.91844338e-01f,
  1.14804246e-01f, -1.44100606e-01f, 1.84003301e-02f, 1.10281587e-01f, -2.15509057e-01f, 1.50900837e-02f, -1.75877605e-02f, 1.32201463e-01f, -9.28984061e-02f, 1.08019002e-01f,
  -5.92516623e-02f, 1.73652157e-01f, -1.63553298e-01f, 5.12265302e-02f, 6.73808232e-02f, 3.04330047e-02f, -4.83191758e-02f, -7.40626082e-02f, 1.05332524e-01f, -3.26325977e-03f,
  1.55747965e-01f, 1.00765161e-01f, 9.94229391e-02f, 1.14839366e-02f, 3.40060331e-02f, 1.05246328e-01f, 5.40311635e-02f, 6.36931732e-02f, -1.19528398e-01f, -8.62969384e-02f,
  6.59940392e-02f, -1.21297516e-01f, -4.56751185e-03f, -1.82145536e-02f, -1.78665593e-02f, 3.14265266e-02f, 3.22885290e-02f, -1.87864095e-01f, 7.32439980e-02f, 6.47281483e-02f,
  4.22921330e-02f, 4.82005849e-02f, -4.84071299e-02f, -1.40088797e-02f, -1.62700251e-01f, 2.53653098e-02f, 2.75807679e-02f, -4.50123139e-02f, 3.75886895e-02f, -1.30837336e-01f,
  1.03554845e-01f, 1.46290977e-02f, 4.61053923e-02f, 1.22446427e-02f, -6.33306727e-02f, 1.07208632e-01f, -5.43431602e-02f, 1.06937744e-01f, -1.95293024e-01f, 9.31586996e-02f,
  6.57618977e-03f, -9.82823893e-02f, -1.54419662e-02f, -2.26764055e-03f, 8.16974342e-02f, -5.93134435e-03f, 8.71307179e-02f, 1.75629426e-02f, 1.88915357e-02f, -7.88318738e-02f,
  3.34799802e-03f, 2.67995000e-02f, -1.02824233e-02f, 2.09526671e-03f, -5.51264435e-02f, 1.59744581e-03f, 6.36906773e-02f, 2.99460385e-02f, -4.11107652e-02f, -7.39452392e-02f,
  1.21538304e-01f, 5.15067056e-02f, 8.83974880e-02f, 3.47471386e-02f, -1.84220728e-03f, 6.67617619e-02f, 3.89281027e-02f, 6.22020997e-02f, -5.59518002e-02f, 1.29119426e-01f,
  4.61692810e-02f, -3.00124343e-02f, -3.91489547e-03f, -2.15464309e-02f, -1.12914063e-01f, 4.99250321e-03f, 1.08833782e-01f, -1.12429619e-01f, 5.71684837e-02f, -2.86711771e-02f,
  4.57878970e-02f, 1.25840738e-01f, -5.56769744e-02f, -3.94425876e-02f, 7.65226455e-03f, 9.40085799e-02f, -4.14431579e-02f, 1.25488238e-02f, 9.48504433e-02f, 5.48923342e-03f,
  3.25652324e-02f, -1.04107400e-02f, -1.95207760e-01f, -1.20360583e-01f, 2.33964454e-02f, -3.65012325e-02f, -9.87724066e-02f, -5.97320050e-02f, -1.50022253e-01f, -5.54443989e-03f,
  -4.18590643e-02f, -3.84104438e-02f, -1.43381894e-01f, -1.64879948e-01f, 2.41630748e-02f, -5.40961325e-02f, -1.59192726e-01f, -1.19297892e-01f, -5.42046167e-02f, -1.11443356e-01f,
  -3.09801362e-02f, -2.37339698e-02f, -2.14608684e-01f, 7.76174590e-02f, -1.57450870e-01f, -4.25750799e-02f, 7.62478858e-02f, -1.20297529e-01f, 5.15109003e-02f, 5.50904647e-02f,
  1.22532926e-01f, 6.71299994e-02f, 2.58228555e-02f, -8.50390792e-02f, -3.78909968e-02f, 3.19562145e-02f, -4.75976206e-02f, -7.00066760e-02f, 3.59532274e-02f, 4.11607474e-02f,
  1.00812413e-01f, -7.48308823e-02f, -1.39797717e-01f, 1.01527877e-01f, 6.50535971e-02f, 1.40131442e-02f, 5.90206347e-02f, 5.23990281e-02f, -4.07875888e-02f, -1.03059009e-01f,
  -1.40283838e-01f, 5.62168360e-02f, -2.31808256e-02f, -3.85346785e-02f, -1.61688142e-02f, -4.76431847e-02f, 2.71754786e-02f, 8.01483542e-02f, -1.09098010e-01f, -5.46353683e-02f,
  2.66857054e-02f, -5.87162785e-02f, -7.15637058e-02f, -5.15608303e-02f, -5.33164889e-02f, 1.09027840e-01f, -9.74590853e-02f, 2.58204550e-03f, -9.89993587e-02f, 5.65645285e-02f,
  1.84802450e-02f, 2.60467343e-02f, 2.90203486e-02f, -6.40875995e-02f, 6.78846985e-02f, 1.67795103e-02f, -7.07207387e-03f, -3.65192033e-02f, -7.08833486e-02f, 2.55228188e-02f,
  -3.20053473e-02f, 3.86217684e-02f, -3.73261422e-02f, -1.07597217e-01f, 4.92893048e-02f, -7.02522993e-02f, 2.13249736e-02f, -4.88668717e-02f, -3.89062986e-02f, -4.79508266e-02f,
  1.25250772e-01f, -5.58115430e-02f, -2.87759453e-02f, 3.80360149e-02f, -2.39194911e-02f, 1.25278965e-01f, -5.95371611e-02f, -5.08195758e-02f, -2.84665227e-02f, -3.94035727e-02f,
  1.89482346e-02f, 4.67226207e-02f, 4.09490727e-02f, 8.73608291e-02f, 2.16377657e-02f, 8.74455720e-02f, -8.27766880e-02f, 2.74350699e-02f, 4.27279295e-03f, 9.24196169e-02f,
  1.00998962e-02f, -2.39215996e-02f, -1.05998278e-01f, -4.13090689e-04f, -1.03945293e-01f, -1.91375613e-02f, 8.98595974e-02f, 6.64237589e-02f, -6.11471534e-02f, 1.56178521e-02f,
  1.14529572e-01f, -9.17167068e-02f, -4.74702343e-02f, 1.63480602e-02f, 1.03457868e-01f, -1.25872865e-01f, -6.99988306e-02f, 2.49752775e-02f, -1.09580725e-01f, -2.91119050e-02f,
  -5.29840291e-02f, -3.75920869e-02f, -1.01570539e-01f, 1.18496098e-01f, 1.92393996e-02f, -2.18967438e-01f, 1.42299347e-02f, -7.00992793e-02f, -6.28808513e-02f, -3.50596942e-02f,
  1.41765386e-01f, 1.98405847e-01f, 5.40429465e-02f, 1.56501710e-01f, -6.06051367e-03f, 1.25952348e-01f, 2.97035966e-02f, -6.66772872e-02f, 1.51210040e-01f, 5.67424893e-02f,
  -7.09766150e-02f, 1.00929169e-02f, 1.29804924e-01f, -1.03235692e-01f, 6.01292737e-02f, -1.93975947e-03f, -3.71410400e-02f, 2.24135723e-02f, -5.32422774e-02f, 3.93808112e-02f,
  -7.00838342e-02f, 5.59455119e-02f, 2.99370605e-02f, -8.63149092e-02f, -1.01864208e-02f, 3.23497094e-02f, -6.44330531e-02f, -9.96030197e-02f, 1.05751259e-02f, 6.49997890e-02f,
  -3.52012701e-02f, -4.96922098e-02f, -3.49228904e-02f, 1.54990070e-02f, 8.09482485e-03f, 5.01100346e-02f, 1.66700743e-02f, -7.17052817e-02f, 5.77544458e-02f, 1.47695899e-01f,
  3.01970206e-02f, 4.19597737e-02f, 3.73958871e-02f, 6.18096292e-02f, 1.01252999e-02f, 3.88887823e-02f, 5.34434095e-02f, 2.43639536e-02f, -2.67318096e-02f, -4.21833061e-03f,
  -4.50972021e-02f, 6.14024773e-02f, -1.31004043e-02f, 7.32448548e-02f, 6.65920079e-02f, 7.22152069e-02f, -4.14060317e-02f, -4.01745997e-02f, 7.64942393e-02f, -1.05198666e-01f,
  3.85914259e-02f, -1.89388660e-03f, -5.91827091e-03f, -2.56608482e-02f, -4.42545712e-02f, 6.38213605e-02f, 4.04332727e-02f, -4.56203893e-02f, 8.99675582e-03f, -4.83243167e-02f,
  1.13350302e-02f, 2.76453979e-02f, 4.07474674e-03f, 1.13734268e-02f, -2.40802043e-03f, -5.44627681e-02f, 4.03676108e-02f, 7.76560381e-02f, 4.40148301e-02f, 7.43930042e-02f,
  2.63377242e-02f, 5.81360646e-02f, 4.60954458e-02f, -8.95733163e-02f, -1.66963171e-02f, -3.57191749e-02f, 7.75621086e-02f, 9.41898208e-03f, -7.30035678e-02f, 9.64873582e-02f,
  4.23684865e-02f, -1.58426926e-01f, 4.30666059e-02f, -2.04499997e-02f, 9.78143737e-02f, -1.01707121e-02f, -4.65153307e-02f, 7.81343803e-02f, -9.79684410e-04f, -4.26758304e-02f,
  -2.01251999e-01f, 2.27536350e-01f, 1.09526217e-01f, 1.66916102e-01f, -1.90424278e-01f, 7.75703192e-02f, 1.57332331e-01f, -1.51257869e-02f, 4.16882411e-02f, 2.21074462e-01f,
  7.99886435e-02f, 4.28903587e-02f, 1.79870486e-01f, 1.34693250e-01f, -4.24649380e-02f, 1.75346717e-01f, 1.58133551e-01f, 7.82064945e-02f, -1.90939289e-02f, 6.71307072e-02f,
  4.76615271e-03f, 9.63764340e-02f, -8.02704170e-02f, -5.48956171e-02f, -9.12192315e-02f, -7.19693527e-02f, -4.37751878e-03f, -1.48636252e-01f, -4.88702022e-02f, 1.40714291e-02f,
  -5.48440637e-03f, 2.96976510e-02f, 4.43342365e-02f, 5.35526052e-02f, -4.20960523e-02f, -5.22964913e-03f, -9.77712199e-02f, 6.60837814e-02f, 2.87355259e-02f, 9.03604478e-02f,
  -5.54634817e-02f, -8.09371024e-02f, 4.18206528e-02f, -4.01715562e-02f, -2.82453503e-02f, -3.85384224e-02f, -1.17030784e-01f, -5.46524078e-02f, 6.14170879e-02f, -4.76382033e-04f,
  5.07209152e-02f, -8.60473290e-02f, 1.01027466e-01f, 1.13740303e-01f, 2.72396374e-02f, 7.60051375e-03f, 2.80977357e-02f, -2.50734072e-02f, 6.89982176e-02f, -3.81035991e-02f,
  -3.91895883e-02f, -6.50930107e-02f, -1.44233648e-03f, -1.61571175e-01f, -5.98626547e-02f, -9.04182047e-02f, 3.51824984e-02f, -6.54874891e-02f, 8.65302533e-02f, -3.71527523e-02f,
  -7.59336874e-02f, 3.58308665e-02f, -4.68924791e-02f, 2.97539886e-02f, -1.27199767e-02f, 4.65182103e-02f, 7.77471252e-03f, 5.60018746e-03f, 5.54879569e-02f, 1.18406601e-02f,
  -3.70108970e-02f, -1.69085152e-02f, 7.75707588e-02f, 5.87556474e-02f, 1.27916439e-02f, -7.36026978e-03f, 1.09669410e-01f, 3.61812338e-02f, 1.01737678e-02f, -4.43211012e-02f,
  -1.70061458e-02f, 1.36717722e-01f, -8.41163192e-03f, 4.65031341e-02f, 6.18522093e-02f, 7.64890537e-02f, 2.89830030e-03f, 5.79822622e-02f, 1.10892564e-01f, 1.11863859e-01f,
  -5.75281605e-02f, 7.86982477e-02f, 2.44494118e-02f, 7.07378536e-02f, -1.53582031e-02f, 1.62244782e-01f, 3.87632959e-02f, 7.78362826e-02f, 7.64527544e-02f, -8.45164806e-02f,
  -1.02353655e-02f, -8.63013864e-02f, -1.47703942e-03f, -2.28325594e-02f, 1.94550864e-02f, 8.67394265e-03f, 1.89761724e-02f, -4.36701663e-02f, -1.10253207e-01f, 7.15751424e-02f,
  -8.99372399e-02f, 9.18614864e-02f, -2.48184092e-02f, -1.60514072e-01f, -4.46779728e-02f, -2.50769645e-01f, -2.09412336e-01f, 2.81630661e-02f, 1.21272177e-01f, 1.21403880e-01f,
  4.53631161e-03f, 3.19855176e-02f, -5.23723215e-02f, -2.44877666e-01f, -2.47970477e-01f, -2.10807174e-01f, -2.42158890e-01f, -7.32525811e-02f, -4.31108475e-02f, -6.35683462e-02f,
  -1.06545635e-01f, -1.68442592e-01f, -4.60109822e-02f, 2.75003035e-02f, -8.12711120e-02f, 1.47621274e-01f, 3.88061181e-02f, 1.67654026e-02f, 6.13683313e-02f, -7.55249038e-02f,
  -7.46183246e-02f, -5.00729633e-03f, 3.44030596e-02f, 3.01590580e-02f, -5.34934439e-02f, 6.74961507e-02f, 6.14773482e-02f, 3.11293080e-02f, -7.79499114e-02f, -3.34966071e-02f,
  1.00445174e-01f, 6.03261637e-03f, 3.71825956e-02f, 4.46078666e-02f, 5.63261993e-02f, -1.17346589e-02f, 3.58594246e-02f, 3.62738594e-02f, -3.83557081e-02f, -9.01693180e-02f,
  -1.21431416e-02f, -6.38515651e-02f, 8.65386426e-02f, 1.21183228e-02f, -2.81951856e-02f, 2.81214919e-02f, -2.34411508e-02f, 1.34703731e-02f, 6.35163087e-05f, 8.12009647e-02f,
  4.38138284e-02f, 6.98358342e-02f, -1.21322703e-02f, 8.82119313e-02f, 5.37122674e-02f, 1.10137656e-01f, 8.54951888e-02f, -3.48903872e-02f, 4.68009934e-02f, 1.16035249e-02f,
  3.20390873e-02f, 4.46360260e-02f, 2.59260889e-02f, -9.54209939e-02f, -1.36653125e-01f, 9.37218890e-02f, 5.32849692e-02f, -2.79499199e-02f, -6.94648875e-03f, -1.80585275e-03f,
  -2.39251666e-02f, -2.88643893e-02f, 5.27891107e-02f, -3.01794503e-02f, -7.90372789e-02f, 8.76692906e-02f, 3.70447710e-02f, 5.60169294e-02f, -6.79159863e-03f, 7.77529040e-03f,
  -5.69075979e-02f, -4.58344743e-02f, 2.20353287e-02f, -5.81385102e-03f, 4.90555502e-02f, -1.16709061e-02f, -5.63796759e-02f, 1.24725448e-02f, -7.30682537e-02f, -2.59741377e-02f,
  7.85686076e-02f, 1.56808663e-02f, 4.57948856e-02f, 2.39849351e-02f, -1.32200886e-02f, -9.92837399e-02f, 2.58533210e-02f, 5.21957278e-02f, 2.47415546e-02f, 2.26491899e-03f,
  3.59077863e-02f, 4.50232476e-02f, 1.02319084e-01f, -8.96239560e-03f, 4.22628270e-03f, 7.97808245e-02f, -2.53642816e-02f, -5.02894409e-02f, 3.73529978e-02f, -6.98477402e-03f,
  2.50559878e-02f, -2.16853879e-02f, 1.10915288e-01f, -2.10807454e-02f, 5.12922369e-03f, -6.54374436e-02f, 7.26813152e-02f, -1.38992950e-01f, 5.21754846e-04f, 3.33461910e-02f,
  8.21061209e-02f, 1.20451719e-01f, 1.44552097e-01f, -7.77428970e-02f, -1.08194843e-01f, -1.52239040e-01f, -1.81858689e-01f, -8.28232542e-02f, 5.86097967e-03f, -4.11037132e-02f,
  -1.14320584e-01f, -1.00854479e-01f, -6.03018254e-02f, -1.24960259e-01f, 2.08078492e-02f, 1.52735999e-02f, -6.70825988e-02f, 2.12141484e-01f, -3.56938168e-02f, 1.90158039e-01f,
  -1.52885392e-02f, -7.42977252e-03f, -2.64374614e-02f, -4.45907749e-02f, -2.66313669e-03f, 1.46545358e-02f, 3.22603993e-02f, 6.75614029e-02f, 9.80546921e-02f, -1.01032071e-01f,
  1.04821622e-01f, -1.91566311e-02f, -7.62483925e-02f, 1.41800186e-02f, -4.30278964e-02f, -6.08891025e-02f, 2.98523307e-02f, -7.03513101e-02f, -3.30786593e-02f, 1.21123277e-01f,
  -8.42003748e-02f, -4.26824614e-02f, -2.22538151e-02f, -6.78331777e-02f, -2.10864581e-02f, 1.00474112e-01f, 9.18044373e-02f, 1.05308764e-01f, 5.27599733e-03f, 2.73760892e-02f,
  -6.04509823e-02f, 2.73708683e-02f, 1.94154065e-02f, 4.64334115e-02f, 9.48785990e-02f, 1.26553350e-03f, 4.06747498e-02f, -1.74718052e-02f, -2.52922103e-02f, 3.79571412e-03f,
  6.50716946e-02f, -2.38989014e-02f, 5.71246855e-02f, -8.37868974e-02f, 4.69157249e-02f, -3.25898975e-02f, -1.07835852e-01f, -9.92952101e-03f, -6.07780814e-02f, 8.78006816e-02f,
  -1.33173957e-01f, -1.90189648e-02f, 3.90731320e-02f, 2.94897500e-02f, -1.00050226e-01f, 2.73582451e-02f, 7.90559594e-03f, -5.01280911e-02f, 5.73537536e-02f, 2.95954011e-02f,
  4.77147102e-02f, -2.63743289e-02f, 4.97392528e-02f, 6.47091493e-02f, 3.74710336e-02f, -1.12164557e-01f, -1.44129097e-01f, 2.56448053e-02f, 7.04327151e-02f, -9.00033209e-03f,
  1.70808472e-02f, 8.54234248e-02f, -1.33479804e-01f, 8.73530097e-03f, -7.87620619e-02f, -4.99021150e-02f, 8.19669664e-03f, 2.02703732e-03f, -9.33601260e-02f, 6.14449754e-02f,
  2.95275338e-02f, 3.00932117e-02f, 6.99375123e-02f, -1.76828878e-04f, 2.20625792e-02f, 7.73844495e-02f, -7.37029836e-02f, -2.48862002e-02f, 5.36561124e-02f, 2.74777133e-02f,
  4.13207650e-01f, 4.86022867e-02f, 1.13845505e-01f, 1.88947886e-01f, -1.19741403e-01f, -3.74261402e-02f, -1.28077036e-02f, -1.75524212e-03f, 3.33550088e-02f, 4.45292965e-02f,
  -1.48238719e-01f, 1.94045186e-01f, -9.24949795e-02f, 1.15946606e-02f, -1.92179769e-01f, -1.25532731e-01f, -3.34099382e-02f, 4.97359335e-02f, -2.42088493e-02f, 8.91810209e-02f,
  1.05671190e-01f, -4.83087562e-02f, -1.62818864e-01f, -1.51935279e-01f, 1.54617339e-01f, 6.23943880e-02f, -2.00328335e-01f, -1.59558699e-01f, 1.12298086e-01f, -1.03827253e-01f,
  5.07133640e-02f, -3.45290713e-02f, 2.79096281e-03f, -6.47610053e-02f, 2.68092323e-02f, 8.18831921e-02f, 5.25555722e-02f, -1.22717679e-01f, -2.76730303e-02f, 3.05427033e-02f,
  1.29165605e-01f, -2.48743873e-02f, 3.52336802e-02f, -1.06891409e-01f, -2.79860012e-02f, 6.02128021e-02f, 1.03316925e-01f, 2.81790108e-03f, 3.28517482e-02f, 1.41438916e-01f,
  6.21363781e-02f, 1.37527540e-01f, -2.43141241e-02f, -1.07571874e-02f, 1.31282300e-01f, -5.42824296e-03f, 3.63279432e-02f, 7.09524611e-04f, -7.11693615e-03f, 8.47420692e-02f,
  4.47581373e-02f, 5.88940941e-02f, 5.09792976e-02f, -4.63858657e-02f, -1.24843810e-02f, 2.72141490e-03f, 5.94433919e-02f, -2.60691158e-02f, 6.20914362e-02f, 3.56126926e-03f,
  2.46287100e-02f, 8.44163895e-02f, -5.07377908e-02f, 5.07315584e-02f, 1.02479033e-01f, -2.67868917e-02f, 5.03562614e-02f, 5.82739152e-02f, 1.39932916e-01f, -6.72943518e-02f,
  -1.44560352e-01f, 4.21196558e-02f, -3.99647169e-02f, 5.92537373e-02f, -8.80170614e-02f, 6.25054762e-02f, 1.10090680e-01f, 1.35457680e-01f, 1.13192583e-02f, -1.38224483e-01f,
  -3.61736007e-02f, 2.45650392e-02f, 7.98099786e-02f, 3.00834253e-02f, -3.77366729e-02f, 7.81085566e-02f, 2.76043992e-02f, 1.32541552e-01f, 4.69847657e-02f, 6.11694343e-02f,
  4.61907126e-02f, -1.18535934e-02f, -1.03197351e-01f, 4.26048078e-02f, -1.02944888e-01f, -3.08115277e-02f, 2.20648572e-02f, 1.15792342e-02f, -4.51538526e-02f, 7.83987343e-03f,
  5.73478714e-02f, -5.03327809e-02f, 1.18906893e-01f, -5.80732375e-02f, 4.48942594e-02f, 9.34758931e-02f, -3.23800668e-02f, 7.68606290e-02f, 1.47802746e-02f, 6.18166476e-02f,
  1.44602749e-02f, 1.20514229e-01f, 1.31111592e-01f, 3.00324410e-01f, -3.59668769e-02f, -2.24037096e-01f, -2.26134270e-01f, 1.64679974e-01f, -6.01033308e-02f, -5.53547069e-02f,
  5.30070812e-02f, 1.74797758e-01f, -1.84610575e-01f, 7.38320174e-03f, -8.87628123e-02f, -9.88315642e-02f, 8.46779495e-02f, 7.41465119e-05f, 7.58506358e-02f, 1.29041046e-01f,
  3.69810648e-02f, 2.95179319e-02f, 1.57484800e-01f, 4.04240489e-02f, 1.38861105e-01f, 1.11980662e-01f, 2.32396141e-01f, 1.29809435e-02f, 1.58087164e-01f, -2.48502474e-04f,
  -1.04978815e-01f, 7.08177090e-02f, 8.91413689e-02f, 4.81009483e-03f, 2.73697861e-02f, -8.61051753e-02f, -7.56335855e-02f, -2.35839300e-02f, -8.01945999e-02f, -2.25909613e-02f,
  -1.08698107e-01f, -5.02476804e-02f, -3.06812394e-02f, 1.03056077e-02f, 2.83283269e-04f, 3.30682807e-02f, 6.49849921e-02f, 5.05285375e-02f, 3.38310078e-02f, 1.01949453e-01f,
  8.26496035e-02f, 3.66885178e-02f, 1.49863167e-02f, -6.33420944e-02f, -6.94894642e-02f, -5.79869747e-02f, 1.26590058e-02f, 8.58974531e-02f, 1.42393932e-01f, -5.28567433e-02f,
  -8.28490406e-02f, 6.50043925e-03f, 4.58774231e-02f, -2.75487695e-02f, -3.27625610e-02f, 3.47622856e-02f, -5.89185990e-02f, -1.18016973e-01f, -7.22822873e-03f, 9.78610143e-02f,
  2.85859779e-02f, -2.88269278e-02f, -1.06834710e-01f, -3.27736214e-02f, -4.78845015e-02f, 5.63278273e-02f, 1.31593514e-02f, -1.36912549e-02f, 6.72192276e-02f, -1.17945792e-02f,
  -2.23925747e-02f, 1.50126843e-02f, -2.97675971e-02f, -1.82770211e-02f, 1.11726932e-02f, 3.28053944e-02f, 6.60456419e-02f, -3.23933996e-02f, 3.25250737e-02f, 4.52188067e-02f,
  4.52287048e-02f, 8.23579952e-02f, -6.68899268e-02f, -5.54126687e-02f, -1.20557053e-02f, -2.07277182e-02f, 1.56913407e-03f, 2.88107749e-02f, -1.97023861e-02f, 7.06712157e-02f,
  -8.11152309e-02f, 3.60769406e-02f, 5.20131811e-02f, 4.11170088e-02f, -7.76899606e-02f, 1.00119345e-01f, -5.51020540e-02f, 5.08333594e-02f, 2.57565733e-02f, -3.45820119e-03f,
  8.61880556e-02f, -1.09450825e-01f, -5.61243221e-02f, -1.54484063e-02f, 5.94302490e-02f, -6.10033385e-02f, 3.34450006e-02f, 8.99151117e-02f, 3.09776422e-02f, 7.57496357e-02f,
  1.34317636e-01f, 2.39083603e-01f, 5.40613979e-02f, 1.22677535e-01f, -1.49983987e-01f, -9.44412053e-02f, 6.80038473e-03f, -1.93767603e-02f, -1.18503785e-02f, 5.48354127e-02f,
  -2.37568267e-04f, 1.71646059e-01f, -1.22767121e-01f, 7.86585361e-02f, -2.05046386e-01f, -4.06417437e-02f, 4.74147722e-02f, -4.95795533e-02f, -1.52478576e-01f, 1.13334671e-01f,
  -7.44229183e-02f, 1.39365823e-03f, 2.36249696e-02f, 5.38626909e-02f, 9.83583108e-02f, 1.67162552e-01f, -7.29248440e-03f, 8.02743062e-02f, 2.21612215e-01f, -1.16853669e-01f,
  -7.41424710e-02f, 6.73534200e-02f, 7.46199638e-02f, 7.17567205e-02f, 7.77980462e-02f, 6.41029477e-02f, -3.97941060e-02f, -7.20905364e-02f, 3.92671824e-02f, -6.32607117e-02f,
  4.30865027e-02f, 5.54422382e-03f, 8.71446878e-02f, 7.03648776e-02f, 5.17772185e-03f, -4.57090735e-02f, -9.82641149e-03f, 5.52142821e-02f, 7.48525374e-04f, 3.86717543e-02f,
  3.42275761e-02f, 3.81454788e-02f, 1.32222623e-01f, 1.02080703e-01f, 8.46992359e-02f, 1.70295946e-02f, 4.03701924e-02f, 7.18909577e-02f, 4.86691156e-03f, -7.33649582e-02f,
  -1.88566055e-02f, 3.61865610e-02f, 3.09874155e-02f, -2.76578212e-04f, 1.80615783e-02f, -1.08300984e-01f, 5.00218756e-02f, -2.69373879e-02f, 4.04936559e-02f, 9.18470416e-03f,
  9.42827463e-02f, -2.27961671e-02f, -9.44842473e-02f, -8.33979063e-03f, -5.58708236e-02f, -2.27082185e-02f, -2.18346585e-02f, 7.25550130e-02f, 3.61804962e-02f, -8.99006426e-02f,
  2.59064278e-03f, 4.61316407e-02f, -2.48412974e-02f, -6.31410331e-02f, 2.69619226e-02f, -1.39826626e-01f, -1.01389691e-01f, -2.20463853e-02f, -7.51866624e-02f, -7.50037134e-02f,
  3.15098055e-02f, 5.81787489e-02f, 3.09150331e-02f, -3.07258759e-02f, 3.10022440e-02f, 7.88896903e-02f, -8.80936254e-03f, 1.03304461e-01f, -6.05040081e-02f, 7.85081536e-02f,
  2.78607989e-03f, 9.49878097e-02f, 5.69989122e-02f, 9.07124132e-02f, 8.86031985e-02f, -6.62497580e-02f, -5.05835265e-02f, -4.41527460e-03f, -3.20176892e-02f, -9.92310420e-02f,
  -3.88140902e-02f, -4.51581329e-02f, 6.04047589e-02f, 8.34819153e-02f, -6.74931472e-03f, -7.83979055e-03f, 2.44491659e-02f, 9.91262570e-02f, -1.01573527e-01f, 1.52222281e-02f,
  -4.82580006e-01f, 1.14365302e-01f, 1.86520711e-01f, -2.08301052e-01f, 2.64079012e-02f, -7.11205676e-02f, -8.95102769e-02f, 3.03132273e-02f, 3.21449228e-02f, 8.44222605e-02f,
  9.05355811e-02f, -5.50257694e-03f, 1.89288571e-01f, 5.91621473e-02f, -7.06735030e-02f, 1.09178841e-01f, -9.22838524e-02f, -9.81852412e-02f, 1.68407001e-02f, 4.06420184e-03f,
  6.11871528e-03f, -3.00829560e-02f, 9.37911719e-02f, 1.19541593e-01f, 1.54210646e-02f, -6.26631305e-02f, -1.34199128e-01f, 1.55083448e-01f, -6.11717850e-02f, -4.63353507e-02f,
  -1.89758003e-01f, 3.97213399e-02f, -9.92025062e-02f, 4.21744436e-02f, -6.05746284e-02f, 3.89689468e-02f, -3.36771198e-02f, 6.63050935e-02f, 6.73786253e-02f, 7.76959136e-02f,
  -1.43532958e-02f, 3.33600342e-02f, -5.06550958e-03f, 1.06497601e-01f, -4.18761373e-02f, 1.46567579e-02f, 2.10282039e-02f, 8.84169620e-03f, 1.50340777e-02f, 5.39008193e-02f,
  6.03484735e-02f, 8.43415782e-03f, 4.17868532e-02f, -1.25539273e-01f, -3.95020023e-02f, 2.13837195e-02f, 1.31391231e-02f, -7.18378648e-02f, -1.47256643e-01f, -1.62566174e-02f,
  7.59819523e-02f, 2.27345265e-02f, -1.01995021e-01f, 3.15615274e-02f, 5.70504665e-02f, 8.34506601e-02f, 2.27720048e-02f, -5.64590888e-03f, 4.23184372e-02f, -7.30925649e-02f,
  -2.86531840e-02f, -6.44960180e-02f, -3.48405130e-02f, -8.92551392e-02f, 1.99530628e-02f, -7.56119862e-02f, 9.89791658e-03f, 3.56817432e-02f, -7.66047835e-02f, -6.97194189e-02f,
  -3.56700718e-02f, -4.23983112e-02f, -8.60641971e-02f, -5.10053616e-03f, 1.85825080e-02f, 4.78478372e-02f, -3.43610998e-03f, -7.36785457e-02f, -8.76714960e-02f, -7.49901608e-02f,
  -9.44728851e-02f, -3.32229361e-02f, -9.21733677e-02f, -2.37869844e-03f, -7.64345676e-02f, 1.33379456e-02f, -7.69053996e-02f, 6.84975535e-02f, -2.91286502e-02f, -2.97529362e-02f,
  -5.51817827e-02f, -7.28689730e-02f, 4.86688316e-03f, 2.20586304e-02f, 1.08648546e-01f, -2.97362059e-02f, -3.03512868e-02f, -1.11515447e-02f, -1.71353407e-02f, 1.01439562e-02f,
  1.49159422e-02f, -6.67953193e-02f, -4.89596128e-02f, 3.32597755e-02f, -2.37083458e-03f, -2.41220985e-02f, -1.14070669e-01f, 2.53562499e-02f, -3.45551856e-02f, 6.45485660e-03f,
  -2.21481398e-01f, 1.92226991e-01f, 5.28628007e-03f, -2.00310722e-01f, 1.31838202e-01f, -1.25236720e-01f, -1.85890257e-01f, -1.98831968e-02f, -8.27822164e-02f, 1.58924293e-02f,
  3.74588720e-03f, -9.60097387e-02f, 1.57319203e-01f, -6.38345331e-02f, -1.84868336e-01f, 3.61020267e-02f, -1.10077083e-01f, -1.24724627e-01f, -5.95790297e-02f, 5.42624965e-02f,
  1.01048881e-02f, -3.72960269e-02f, -1.34474486e-01f, 4.14532311e-02f, -4.19668071e-02f, 7.36704320e-02f, 2.52073612e-02f, 1.02101862e-01f, -1.62912250e-01f, 2.85013653e-02f,
  -1.01397216e-01f, -3.05953473e-02f, 6.54529184e-02f, -1.27038449e-01f, -5.15501834e-02f, -1.17181122e-01f, -1.16814069e-01f, -2.70464048e-02f, 1.31793162e-02f, -1.08413883e-02f,
  -7.52386004e-02f, 1.00685656e-02f, -2.02262532e-02f, -5.89108355e-02f, -7.46319368e-02f, 6.18321449e-02f, 5.17906621e-02f, -3.30362581e-02f, 5.90378866e-02f, -3.48875523e-02f,
  -2.46028602e-02f, -3.28844204e-03f, -7.36461356e-02f, 3.10204760e-03f, -8.62447172e-02f, 2.82077901e-02f, -1.65942274e-02f, -3.56820859e-02f, -1.28541172e-01f, -9.17953700e-02f,
  1.33432196e-02f, -8.40153694e-02f, 6.00091070e-02f, 9.82907563e-02f, -4.06694338e-02f, -4.53327410e-02f, -5.95888048e-02f, -4.34269197e-02f, -6.54561073e-02f, 8.45425576e-03f,
  1.41322426e-03f, -8.14979970e-02f, 7.91856200e-02f, -1.42706623e-02f, -3.79069112e-02f, 4.92960326e-02f, 1.49106409e-03f, -5.09462506e-02f, 1.26756486e-02f, -2.89724898e-02f,
  -5.90808317e-02f, -1.24895535e-02f, -6.80236816e-02f, 1.29196979e-02f, -8.68311909e-04f, 3.07630319e-02f, 1.25241810e-02f, -1.06313759e-02f, 3.66721340e-02f, -5.76322079e-02f,
  -6.38006255e-02f, -1.33486301e-01f, 2.27055768e-03f, 3.39015424e-02f, 4.27935682e-02f, -5.80747873e-02f, -8.01616460e-02f, 9.81809124e-02f, -2.04845909e-02f, 1.32146757e-02f,
  -1.61251538e-02f, 2.68860962e-02f, -3.90987433e-02f, 2.47363076e-02f, 1.82086881e-03f, -6.04875125e-02f, -7.02406466e-02f, -3.47968489e-02f, 3.98165965e-03f, 3.12719680e-02f,
  -7.59979337e-02f, -7.09498972e-02f, -1.45698031e-02f, 1.99254900e-02f, -3.82580683e-02f, -2.53457949e-02f, 5.79177327e-02f, 8.45388044e-03f, -4.32265066e-02f, -3.58281620e-02f,
  -1.33144796e-01f, 6.11113720e-02f, 1.16114244e-01f, 1.16596863e-01f, -1.08793110e-01f, -1.34458140e-01f, -8.39736313e-03f, 5.25741018e-02f, -8.72308947e-03f, 6.08411096e-02f,
  3.22260037e-02f, 1.02949897e-02f, 1.46356866e-01f, 1.65389124e-02f, 6.20719828e-02f, 8.49190429e-02f, 1.29579753e-01f, -1.24359757e-01f, 1.72796231e-02f, 7.14375824e-02f,
  5.78934588e-02f, -6.77344725e-02f, 7.20157996e-02f, 8.10956433e-02f, -9.17808414e-02f, 2.43360735e-02f, 8.69104862e-02f, -6.13408610e-02f, -5.79661280e-02f, -6.38976395e-02f,
  5.60023785e-02f, 8.22094083e-02f, 9.37649459e-02f, 1.33490145e-01f, 5.11003658e-02f, 1.64064392e-02f, -1.87711976e-02f, -2.61678211e-02f, -3.21471058e-02f, 1.03058629e-01f,
  -1.20417448e-02f, 8.55490565e-02f, 4.90730740e-02f, -2.25185417e-03f, -3.44575755e-02f, 8.66105855e-02f, -6.00977316e-02f, 7.50835985e-02f, -4.89905942e-03f, 1.02792099e-01f,
  8.09315220e-03f, 8.29255879e-02f, 1.55535759e-02f, 7.85719603e-02f, 1.86563395e-02f, 4.53273952e-03f, 5.91315441e-02f, 8.02219734e-02f, 3.47279496e-02f, 4.98086363e-02f,
  7.80225396e-02f, -2.58535538e-02f, 8.95138830e-03f, 4.71471436e-02f, 7.33540431e-02f, -9.67235584e-03f, 6.65636286e-02f, 6.74525509e-03f, -6.75229207e-02f, -1.98713504e-02f,
  7.03258887e-02f, 7.60551495e-03f, 7.89463297e-02f, 2.38638651e-02f, -7.23000839e-02f, -3.68105695e-02f, -1.98333301e-02f, 9.79778022e-02f, 5.22952080e-02f, -6.56063482e-02f,
  -3.75774615e-02f, -1.10862784e-01f, 1.02769891e-02f, 9.58078355e-02f, 4.87744026e-02f, -1.24143464e-02f, 3.22487950e-02f, -4.18513604e-02f, 4.99682985e-02f, 5.84220327e-02f,
  2.14775074e-02f, 9.35549363e-02f, 1.52190076e-02f, 3.45119908e-02f, 6.92443475e-02f, 4.93381545e-02f, 4.78698052e-02f, -4.55287583e-02f, 3.70970257e-02f, 1.02211662e-01f,
  -1.27472533e-02f, -7.85943493e-02f, -8.98706447e-03f, -5.21477051e-02f, 1.46679759e-01f, 9.35696289e-02f, 3.56386229e-02f, 3.41982841e-02f, 4.25924547e-02f, 4.93020117e-02f,
  6.10265546e-02f, -4.69287001e-02f, -4.44915406e-02f, 7.46077895e-02f, -6.65107891e-02f, -4.73919362e-02f, -1.46330446e-01f, 1.46587491e-02f, 3.74980532e-02f, -6.82849661e-02f,
  1.51707763e-02f, -3.28139067e-02f, 3.26874740e-02f, 1.23846263e-01f, -6.05176799e-02f, -1.64805979e-01f, -2.04773501e-01f, 1.87141582e-01f, 6.94053294e-03f, -2.60195974e-03f,
  1.19478449e-01f, -4.07246388e-02f, -1.84101257e-02f, 2.05647528e-01f, 1.47350896e-02f, 7.19118118e-02f, 4.02020738e-02f, 9.15828273e-02f, 1.12671196e-01f, 2.70515904e-02f,
  1.15473680e-01f, 1.99555188e-01f, 9.55131277e-02f, 7.92622045e-02f, 1.18405931e-01f, 1.48695707e-01f, 1.75328642e-01f, -6.79525882e-02f, 9.29990932e-02f, 9.25419331e-02f,
  4.08942476e-02f, -1.46811390e-02f, -9.70351696e-02f, -1.09054269e-02f, 3.66805047e-02f, -9.67545137e-02f, -3.95740308e-02f, -7.10352808e-02f, 2.89106555e-02f, 1.01829723e-01f,
  -1.94604192e-02f, 8.37620422e-02f, -4.77567203e-02f, -1.62602650e-04f, -4.67729643e-02f, 2.39485614e-02f, -4.09913994e-02f, 4.55458499e-02f, 5.26514091e-02f, -7.49380141e-02f,
  -2.36608237e-02f, -7.38489479e-02f, -1.40734296e-02f, -4.45265919e-02f, 2.21293438e-02f, 5.50396182e-02f, 6.33409712e-03f, -4.86641899e-02f, 4.96430509e-03f, 6.99006720e-03f,
  -6.32470548e-02f, 7.39438012e-02f, 2.18700524e-02f, 4.25483435e-02f, 9.03439447e-02f, -8.36101547e-02f, 4.08865176e-02f, 2.50248220e-02f, -2.70261094e-02f, -4.27060425e-02f,
  5.93862720e-02f, 3.38756591e-02f, 6.28703982e-02f, 7.32338652e-02f, 5.22805192e-02f, 8.15966800e-02f, -5.28366528e-02f, -4.91696075e-02f, -1.88224204e-02f, 6.68893754e-02f,
  -4.69642058e-02f, 4.46843132e-02f, 4.28739563e-02f, -1.35053352e-01f, -4.75504845e-02f, 7.16235638e-02f, 7.70232007e-02f, -2.75711697e-02f, 8.03976506e-03f, 2.33673528e-02f,
  1.57322623e-02f, 9.39050913e-02f, 7.76158646e-02f, 1.14277825e-02f, -1.29833091e-02f, 3.23866941e-02f, -2.53817458e-02f, 3.47017944e-02f, -2.28786077e-02f, 7.80969858e-03f,
  -1.49366464e-02f, -3.68090831e-02f, -3.07771042e-02f, -4.08378690e-02f, -6.23206235e-02f, -4.06498089e-02f, -4.71023172e-02f, 6.62774369e-02f, 1.18085690e-01f, 7.48302862e-02f,
  -9.01327133e-02f, 5.32900495e-03f, -2.41651535e-02f, 2.79904716e-02f, 2.23315414e-03f, 7.81031251e-02f, -2.02049986e-02f, 3.15927975e-02f, 3.44517231e-02f, 1.98808033e-02f,
  -2.37180978e-01f, 9.01018232e-02f, -7.25168660e-02f, 5.61998375e-02f, -1.36499584e-01f, 1.74696177e-01f, 1.33776382e-01f, 2.32396368e-02f, 1.12956092e-01f, 1.95301726e-01f,
  1.09205522e-01f, -1.08105823e-01f, 1.89541504e-01f, 2.78056383e-01f, 3.80877107e-02f, 1.42572716e-01f, 1.39172077e-01f, 1.13207623e-01f, -8.19354877e-02f, 8.22473392e-02f,
  4.79421578e-02f, 1.02617793e-01f, 5.23167429e-03f, -7.38187274e-03f, -5.97509071e-02f, -5.05807325e-02f, 5.23196757e-02f, -1.39111251e-01f, 1.69817612e-01f, -7.12310746e-02f,
  -1.37331694e-01f, -5.26988655e-02f, -2.48032473e-02f, -1.44696474e-01f, -3.75130661e-02f, -5.20010963e-02f, -1.96044166e-02f, -7.34617785e-02f, 1.82399135e-02f, -5.03172306e-03f,
  -8.36969092e-02f, -7.93021619e-02f, -1.60300881e-02f, -7.11188689e-02f, 5.01553807e-03f, -1.17102772e-01f, -4.70297039e-02f, 1.22242011e-01f, -1.14672305e-03f, 4.67419736e-02f,
  -6.09791800e-02f, 2.09787954e-03f, 5.44552021e-02f, 7.06865862e-02f, 2.77528912e-02f, -3.63735855e-02f, 9.72232968e-02f, -2.99486089e-02f, 6.03603898e-03f, 2.44904775e-02f,
  -8.02936554e-02f, 2.89251395e-02f, 3.04694846e-02f, -8.39254633e-02f, -8.54285285e-02f, 1.54848471e-02f, -3.32457200e-03f, -8.02966133e-02f, -6.27341717e-02f, 5.91049828e-02f,
  6.89157918e-02f, 5.75486980e-02f, -7.71492049e-02f, -1.90082416e-02f, -2.44726464e-02f, 7.74575248e-02f, -8.47010463e-02f, -5.53151071e-02f, 1.86614115e-02f, 4.56968136e-02f,
  6.86747506e-02f, -1.75812561e-02f, -4.17324491e-02f, -1.03868246e-02f, 2.09804457e-02f, 6.17797077e-02f, 3.62694971e-02f, 7.03696311e-02f, 5.75922616e-02f, 4.95584980e-02f,
  -6.06917357e-03f, 5.47615625e-02f, 3.04622296e-02f, -3.10371220e-02f, 2.70677712e-02f, -1.25573166e-02f, 5.20359427e-02f, 4.10332717e-02f, -4.95314859e-02f, 8.08136165e-02f,
  -2.24066637e-02f, 2.25999132e-02f, -9.13089067e-02f, 7.62010291e-02f, 3.90085801e-02f, -4.15336937e-02f, 4.27751392e-02f, 3.80428359e-02f, 1.31576493e-01f, -3.43452021e-02f,
  1.13212392e-02f, -4.08662437e-03f, -2.68726144e-02f, -8.74965452e-03f, 8.02641436e-02f, 7.23383725e-02f, -4.61723134e-02f, -5.64727783e-02f, 1.76489949e-02f, 6.96900040e-02f,
  2.96974123e-01f, -1.26753047e-01f, 1.22011356e-01f, 2.85854936e-01f, 1.37157559e-01f, 1.07410267e-01f, 1.76689386e-01f, 8.91975984e-02f, 1.57610103e-01f, -2.20310420e-01f,
  2.35577393e-02f, -5.36281243e-02f, -9.26094428e-02f, 8.82486776e-02f, 1.60072550e-01f, -7.53951073e-03f, 7.20351264e-02f, 5.48036285e-02f, 1.22151516e-01f, 3.39675993e-02f,
  1.15949333e-01f, 4.21547852e-02f, -1.36233037e-02f, -9.87171754e-02f, 3.30750383e-02f, 1.13920644e-02f, -1.67342812e-01f, -4.08711396e-02f, -1.14787139e-01f, 2.94571947e-02f,
  7.01723024e-02f, 1.13278463e-01f, 1.55655034e-02f, 1.29371779e-02f, -2.34285984e-02f, -6.86711259e-03f, 3.01197749e-02f, 5.45239411e-02f, 2.50546392e-02f, -1.11222994e-02f,
  -1.40412644e-01f, 4.76161540e-02f, 7.00015724e-02f, 6.85909837e-02f, 3.18641961e-02f, 6.48570359e-02f, -2.54151202e-03f, -3.59173752e-02f, -6.09559491e-02f, 1.89221278e-02f,
  3.54392943e-03f, -5.42073585e-02f, -2.50705052e-02f, -3.89820198e-03f, -7.52030388e-02f, 8.17718059e-02f, -1.03749223e-02f, 1.64374232e-03f, -1.14095174e-01f, -2.43642158e-03f,
  4.33880836e-02f, -5.83631247e-02f, 8.96299258e-02f, -3.14294137e-02f, 8.39690939e-02f, 5.26650771e-02f, 5.63270003e-02f, -1.21873632e-01f, 2.41010282e-02f, 1.73334137e-03f,
  1.16092660e-01f, 1.39920592e-01f, 5.09343073e-02f, -2.98360847e-02f, 8.68742019e-02f, 1.00528104e-02f, 3.46543342e-02f, 8.05354044e-02f, -5.96956909e-02f, -5.63009456e-02f,
  -2.50856038e-02f, -2.86732204e-02f, 3.76638398e-02f, -8.23245570e-02f, -4.40990105e-02f, -5.66578396e-02f, -2.03866977e-02f, -2.14606188e-02f, 7.94167444e-02f, -6.34637997e-02f,
  -9.07410681e-02f, -4.15543653e-02f, -9.11940858e-02f, -2.04915684e-02f, -4.38898429e-03f, -1.02460526e-01f, 2.32204460e-02f, 4.23014835e-02f, -7.40636885e-02f, -4.51978073e-02f,
  -3.60491797e-02f, -7.74059743e-02f, -2.78272089e-02f, 1.22323640e-01f, -5.98221123e-02f, 2.74191480e-02f, -6.63168132e-02f, 1.91414915e-03f, -1.06916346e-01f, 7.06259534e-02f,
  -5.04939025e-03f, -3.86675075e-02f, 2.18298323e-02f, 6.58076927e-02f, -1.14977293e-01f, 7.80877471e-02f, -7.40260035e-02f, 5.42971008e-02f, 1.90390181e-02f, -5.45367599e-02f,
  2.31270313e-01f, 1.42933816e-01f, 2.10055679e-01f, 2.21874714e-01f, -7.67255109e-03f, -8.35654810e-02f, 1.04417823e-01f, 7.56509751e-02f, 3.03623289e-01f, -8.46959874e-02f,
  -1.22219071e-01f, 1.25548542e-01f, -4.95481640e-02f, 1.01432398e-01f, -1.51909254e-02f, -1.39171585e-01f, 1.24098830e-01f, -8.86613801e-02f, -1.54831726e-02f, 1.12708144e-01f,
  1.99099556e-01f, -9.42561701e-02f, 8.33998173e-02f, -1.73479617e-01f, 3.12410593e-02f, 8.51894990e-02f, -1.20007291e-01f, -1.79992780e-01f, -2.83600902e-03f, -7.13297054e-02f,
  8.19076300e-02f, 1.46650910e-01f, 6.86736638e-03f, -1.03728168e-01f, 4.04524542e-02f, 5.71106300e-02f, -3.85929942e-02f, -9.74371880e-02f, 4.89592319e-03f, 1.03044987e-01f,
  8.25881884e-02f, -4.46951687e-02f, 3.41254473e-02f, 2.82410458e-02f, 1.81820672e-02f, -1.38987452e-02f, 6.54909983e-02f, 8.23801905e-02f, 4.34287973e-02f, -4.40560915e-02f,
  1.16000623e-01f, -1.34656439e-02f, 1.13931485e-01f, -1.04521886e-01f, 1.43457875e-01f, 4.48189527e-02f, 3.67880017e-02f, -6.45892099e-02f, 8.07740390e-02f, 6.92529082e-02f,
  -1.72681212e-02f, -6.64181709e-02f, -8.43813568e-02f, -4.27420177e-02f, -4.09406424e-02f, 1.96613651e-02f, -1.53759167e-01f, -1.75376870e-02f, 2.61427127e-02f, -2.41699871e-02f,
  -2.78826375e-02f, 1.75366383e-02f, -5.14847413e-02f, -3.62152271e-02f, 9.47629213e-02f, -2.14485335e-03f, 3.72344963e-02f, -1.55520186e-01f, 3.67340595e-02f, 9.25928727e-03f,
  -3.67997889e-03f, 1.39282849e-02f, 6.13998957e-02f, 2.06325799e-02f, -4.06718887e-02f, -3.82586978e-02f, 6.26613945e-02f, 5.58916628e-02f, 4.93327482e-03f, 4.20789868e-02f,
  -1.10972449e-02f, -3.04790698e-02f, 9.95371565e-02f, -5.84058762e-02f, -6.23964854e-02f, -7.86268190e-02f, 3.28240804e-02f, -3.80880497e-02f, -1.61290374e-02f, 3.79090644e-02f,
  -2.14113714e-03f, -6.33701831e-02f, 1.23600401e-02f, -6.72087893e-02f, 2.82177664e-02f, 5.47857098e-02f, -5.65268239e-03f, -6.69101775e-02f, 1.03573665e-01f, 1.07743377e-02f,
  1.02704875e-02f, 3.46548222e-02f, -4.20604758e-02f, 1.00319842e-02f, -6.91731647e-02f, 2.47232825e-03f, -6.88601006e-03f, -5.84203340e-02f, -6.36694953e-02f, -2.48157475e-02f,
  1.59363285e-01f, -9.01986361e-02f, -2.35596001e-01f, -7.00772405e-02f, 1.31586567e-01f, 1.14972018e-01f, -1.79800913e-01f, 9.36553180e-02f, -6.76058093e-03f, -2.34388709e-02f,
  4.26123850e-02f, -1.89657524e-01f, -7.47649968e-02f, 9.85471904e-02f, 1.00576989e-01f, -1.42632440e-01f, 1.41501367e-01f, -6.06158078e-02f, -9.93389264e-02f, -6.27082139e-02f,
  -3.61192711e-02f, 2.22807795e-01f, -8.62076506e-02f, 1.14139259e-01f, 8.40622857e-02f, -2.98544373e-02f, 1.24406576e-01f, -1.58207610e-01f, 8.23064744e-02f, -1.59961097e-02f,
  -1.88561138e-02f, -6.26033023e-02f, -1.08884953e-01f, -3.80709432e-02f, -8.94969776e-02f, -1.67825688e-02f, -4.53297347e-02f, -8.24666172e-02f, 5.48582301e-02f, -6.82749301e-02f,
  3.04060709e-02f, -1.30581837e-02f, 9.17400718e-02f, 2.76580695e-02f, -2.90914555e-03f, -2.07951143e-02f, 1.36626614e-02f, -8.48545060e-02f, -1.35076210e-01f, -8.39213356e-02f,
  -1.72457322e-02f, -3.76600623e-02f, -1.27251027e-02f, -3.39094102e-02f, 6.38606474e-02f, 4.06719036e-02f, -8.40775445e-02f, -1.11112840e-01f, 1.39668137e-01f, -1.32830247e-01f,
  8.23783316e-03f, 4.50982749e-02f, -2.69429144e-02f, -2.18316098e-03f, -5.43735921e-02f, -2.74974816e-02f, 8.86742026e-03f, 3.53699736e-02f, -4.37431857e-02f, -2.59553008e-02f,
  -1.55901527e-02f, 4.98919468e-03f, -9.79387760e-03f, 9.96998884e-03f, 2.94404919e-03f, -3.54388505e-02f, -5.73243834e-02f, -8.80251452e-03f, -2.71980427e-02f, 5.19180149e-02f,
  3.78159620e-03f, -5.33203706e-02f, -1.11334719e-01f, -1.73305646e-02f, 6.89090565e-02f, 1.92732103e-02f, -6.13493240e-03f, 6.68348745e-02f, -3.32507794e-03f, -6.43442050e-02f,
  4.58481424e-02f, 3.98639888e-02f, -5.70984669e-02f, 9.10527483e-02f, -8.69289711e-02f, -6.99371397e-02f, -5.01642190e-02f, 5.38713709e-02f, 1.22379083e-02f, -1.05747394e-01f,
  6.09761998e-02f, -3.41239497e-02f, 1.07331611e-01f, 1.12023771e-01f, 8.11153725e-02f, -2.65213475e-02f, 2.74057835e-02f, -6.94880486e-02f, -6.10779971e-02f, 8.10500309e-02f,
  4.02205773e-02f, 3.59647535e-02f, -7.97256231e-02f, -5.93983456e-02f, 5.02672642e-02f, -2.02855356e-02f, 2.60478929e-02f, -1.66391637e-02f, 1.16073653e-01f, -3.32228020e-02f,
  -1.73511028e-01f, -9.80085954e-02f, 5.14125302e-02f, -1.38501689e-01f, 1.20577097e-01f, 6.93496838e-02f, 4.64262255e-02f, -8.08592886e-02f, -1.57182917e-01f, 6.58352077e-02f,
  8.45848322e-02f, -9.93091986e-02f, 3.39975879e-02f, -1.65059939e-01f, -2.08461046e-01f, -1.26557067e-01f, -2.06493869e-01f, -1.51730627e-01f, -1.31661490e-01f, -6.68101832e-02f,
  -1.06783040e-01f, -2.01638028e-01f, -1.35865927e-01f, -5.59520014e-02f, 7.08500519e-02f, 3.73720452e-02f, 2.37604424e-01f, 1.56205341e-01f, 9.91717726e-03f, -6.18877746e-02f,
  2.90937014e-02f, 6.31969720e-02f, -3.94307682e-03f, 2.31477488e-02f, 9.83775184e-02f, 4.27623428e-02f, 5.17750457e-02f, 2.89658597e-03f, 7.70823881e-02f, 7.14723114e-03f,
  5.72331622e-03f, 7.86583200e-02f, -1.21002734e-01f, 3.28988675e-03f, -3.28559875e-02f, -1.06942050e-01f, 1.90429054e-02f, 4.94983569e-02f, 3.19272242e-02f, -1.07746460e-01f,
  -7.75033236e-02f, 1.08477443e-01f, 4.78337854e-02f, 1.11312149e-02f, -1.03357574e-03f, 9.77440402e-02f, -8.87842700e-02f, 4.36122306e-02f, 5.21896929e-02f, -4.30812351e-02f,
  9.31174904e-02f, 1.16838500e-01f, -1.84001983e-03f, -7.80442283e-02f, 3.32609825e-02f, -1.18927434e-02f, -3.54564413e-02f, -9.03858840e-02f, -7.17669434e-04f, -7.87433311e-02f,
  -4.66522165e-02f, -2.89571024e-02f, -4.86125313e-02f, 9.67582501e-03f, 2.51740869e-02f, 1.72607154e-02f, -1.34484489e-02f, -1.29645476e-02f, -8.87462050e-02f, 9.43212584e-03f,
  -4.00197506e-03f, 6.93806559e-02f, 1.51178113e-03f, 9.13374647e-02f, 4.89336587e-02f, -3.18549164e-02f, -8.23310018e-02f, -2.02355459e-02f, 3.74170057e-02f, 2.97273155e-02f,
  2.84740701e-02f, 5.23819029e-02f, -7.47116208e-02f, 2.15688981e-02f, 1.80590060e-03f, 1.10106297e-01f, -9.44364145e-02f, -6.48975149e-02f, -9.11917314e-02f, 3.93109620e-02f,
  1.15783937e-01f, 3.05893980e-02f, 7.39099458e-02f, -6.79518953e-02f, -4.67323810e-02f, -1.20743625e-02f, 7.36664385e-02f, 4.53554913e-02f, 6.09457716e-02f, -2.11720038e-02f,
  5.97624965e-02f, 7.32463673e-02f, -3.20171192e-02f, -4.87555303e-02f, -2.71788482e-02f, 6.52769208e-02f, 3.03441361e-02f, -4.32000533e-02f, -4.27977368e-02f, -4.99873571e-02f,
  -1.25970855e-01f, 2.66505331e-01f, 2.09697962e-01f, 2.16145530e-01f, -2.52490565e-02f, 5.89754134e-02f, 3.51521038e-02f, 1.87480241e-01f, 2.23974377e-01f, 9.33499858e-02f,
  2.10592058e-02f, 2.05708191e-01f, -3.18569727e-02f, -1.96556617e-02f, 1.92704648e-02f, 3.74324806e-02f, -2.17409711e-02f, 1.01609983e-01f, -8.12492544e-07f, -4.12381813e-03f,
  1.01947419e-01f, 1.25193987e-02f, 1.61399655e-02f, 3.51322182e-02f, -3.18167009e-03f, 1.42398715e-01f, -1.46041468e-01f, 4.87849936e-02f, -8.35488811e-02f, -1.06432855e-01f,
  3.23149078e-02f, 4.51330431e-02f, -1.98134892e-02f, 8.62190723e-02f, 5.60719483e-02f, -4.07100916e-02f, 7.29483515e-02f, -6.08254746e-02f, -1.19120389e-01f, 4.98519912e-02f,
  7.98266828e-02f, -6.26665503e-02f, 4.91536632e-02f, 6.27525523e-03f, -1.07469959e-02f, 1.07191633e-02f, 1.24180041e-01f, 5.06221019e-02f, 1.06509157e-01f, -4.46666442e-02f,
  2.92063095e-02f, -2.67277118e-02f, 3.78148332e-02f, 9.27145872e-03f, -7.83217922e-02f, -5.41401394e-02f, 5.19763529e-02f, -1.70314888e-04f, -1.58720724e-02f, -2.15583388e-02f,
  -7.90017024e-02f, -3.53098512e-02f, 2.04803143e-02f, 3.58041599e-02f, 4.32517193e-02f, 5.15133888e-02f, -1.80243850e-02f, -6.54070498e-03f, 5.47905006e-02f, 2.97908522e-02f,
  1.94468424e-02f, -9.95732695e-02f, 6.86794668e-02f, -1.52684664e-02f, 1.06437936e-01f, 8.19176361e-02f, 3.50901037e-02f, -8.90276432e-02f, -1.99294072e-02f, -2.26924345e-02f,
  -2.45464798e-02f, -4.22600508e-02f, 3.41594890e-02f, 7.85667226e-02f, 7.87314698e-02f, 8.97623748e-02f, 7.46744052e-02f, -3.99772190e-02f, -1.31093590e-02f, -6.00299053e-02f,
  3.09803542e-02f, 4.13196627e-03f, -9.93006006e-02f, 5.23778982e-02f, 3.54280584e-02f, 3.18236016e-02f, 9.51333866e-02f, 6.69881999e-02f, -1.56109743e-02f, -4.04967815e-02f,
  3.68669666e-02f, -2.45965868e-02f, 6.81772158e-02f, -1.00752659e-01f, -5.12024239e-02f, 7.42847398e-02f, 2.02109776e-02f, 1.01257861e-02f, -8.27396587e-02f, 8.29495490e-02f,
  3.52788419e-02f, 2.09926348e-02f, -5.48114367e-02f, -9.22909603e-02f, 2.85728020e-03f, -2.93302797e-02f, 1.15606457e-01f, 3.44407349e-03f, 2.12980788e-02f, 3.39927780e-03f,
  2.35822927e-02f, -6.84090182e-02f, -7.52683803e-02f, 1.21301226e-01f, 7.49171972e-02f, 3.26936990e-02f, -1.27096787e-01f, 5.68210073e-02f, 4.49738391e-02f, -2.10532229e-02f,
  3.75299938e-02f, -6.16019852e-02f, -1.73282325e-01f, -1.71201732e-02f, -8.85230973e-02f, -2.01800779e-01f, 1.99283287e-02f, 2.68828832e-02f, 3.83559950e-02f, -1.57566566e-03f,
  3.61421295e-02f, 1.63453907e-01f, 1.22759961e-01f, 9.92222875e-02f, 9.06853452e-02f, 1.66705400e-01f, 1.78711623e-01f, 8.70358497e-02f, 9.00737494e-02f, -7.62829464e-03f,
  1.22574465e-02f, -5.06070741e-02f, 2.04814738e-03f, -1.18510546e-02f, 8.19963887e-02f, 5.51972203e-02f, 7.94761553e-02f, 7.78503120e-02f, -2.62605529e-02f, -1.81694087e-02f,
  1.90795790e-02f, -6.74074981e-04f, 3.37480083e-02f, 9.03949738e-02f, 3.44231799e-02f, 2.42247079e-02f, 7.09188208e-02f, -8.33436847e-02f, 5.76728806e-02f, -8.73880181e-03f,
  7.39117414e-02f, -6.30474463e-02f, 5.70916943e-02f, 1.00620575e-01f, -9.23977718e-02f, -7.69702569e-02f, 3.73179056e-02f, -4.54403125e-02f, -4.67583351e-02f, 7.77133480e-02f,
  2.97984071e-02f, -4.88743410e-02f, -5.98061550e-03f, -6.09898865e-02f, 3.87729220e-02f, -1.28324341e-03f, -5.17485514e-02f, -4.08736430e-02f, -7.43576884e-02f, 5.04346751e-02f,
  1.52399618e-04f, 1.37549996e-01f, 5.44292666e-02f, 6.08211607e-02f, 5.99282049e-02f, -6.95541725e-02f, 5.10917865e-02f, -6.83006318e-03f, 3.73668857e-02f, 4.69691344e-02f,
  -5.58602922e-02f, -5.93327917e-02f, 6.67786226e-02f, 6.91378862e-02f, 4.76968177e-02f, 6.40296265e-02f, -1.13220230e-01f, -1.42047293e-02f, 4.06168401e-02f, 8.01696703e-02f,
  4.92941923e-02f, -7.28358850e-02f, -5.92000037e-02f, -2.40910314e-02f, -1.60628073e-02f, 1.48155987e-02f, -8.24608207e-02f, 6.48452118e-02f, 6.50148988e-02f, -4.23686691e-02f,
  8.57587755e-02f, 6.42445832e-02f, -4.75028008e-02f, 4.52860892e-02f, -2.35369746e-02f, -9.74866562e-03f, -2.91683222e-03f, 1.03785901e-03f, 7.14326724e-02f, -3.25165056e-02f,
  1.35047480e-01f, 8.82687941e-02f, -1.10796234e-02f, -5.59504852e-02f, -4.39672656e-02f, -5.70381247e-02f, 1.19568147e-01f, 8.99398550e-02f, -2.40857452e-02f, 1.89852994e-02f,
  -2.25838125e-01f, 1.29104212e-01f, 1.98439613e-01f, -2.61986554e-01f, -7.62698799e-02f, -7.81937316e-02f, -9.09677148e-02f, 1.10427082e-01f, -2.07873490e-02f, -8.00445080e-02f,
  1.93062909e-02f, 1.79502949e-01f, 1.48213983e-01f, 1.43822785e-02f, -9.74122360e-02f, -4.76759039e-02f, -5.27932569e-02f, -1.40258268e-01f, 3.98829579e-02f, 6.14400348e-03f,
  -1.45607010e-01f, -9.22952443e-02f, -1.57333408e-02f, 2.29944974e-01f, -4.42121327e-02f, 8.83921224e-04f, -2.29046881e-01f, 1.07187644e-01f, -1.90444943e-02f, 3.37865800e-02f,
  -1.31182864e-01f, -1.25261411e-01f, -9.44920406e-02f, -5.83907217e-02f, -7.62599483e-02f, 3.66724394e-02f, -9.19376090e-02f, -3.89397033e-02f, -3.09264958e-02f, 4.89823371e-02f,
  -1.57337580e-02f, 1.15166791e-01f, 9.65017676e-02f, 3.50248702e-02f, 1.08591784e-02f, 7.95066208e-02f, 7.69211054e-02f, 3.83459628e-02f, 4.11720909e-02f, 5.63083068e-02f,
  1.15563400e-01f, -6.18172698e-02f, -1.34125873e-01f, -2.80050058e-02f, -8.16094950e-02f, -4.85172123e-02f, 1.18461084e-02f, -8.67240131e-02f, 8.14295374e-03f, -2.88630780e-02f,
  4.71695419e-03f, 2.49380395e-02f, -1.34940194e-02f, -3.95500101e-02f, -3.57552394e-02f, 2.44825780e-02f, 5.56560606e-02f, -8.07969738e-03f, -3.76874842e-02f, -7.31241629e-02f,
  -4.30962294e-02f, 3.75155848e-03f, -8.63465369e-02f, -6.02029637e-02f, -6.64251298e-02f, -4.57079411e-02f, -3.26560624e-02f, -6.38692528e-02f, 5.72412163e-02f, 5.98115809e-02f,
  3.41716968e-02f, -5.15817255e-02f, 8.25646594e-02f, -6.88785538e-02f, 4.86355610e-02f, -2.85841282e-02f, 1.01411410e-01f, 2.17645336e-02f, 5.90514727e-02f, -5.07861935e-02f,
  -2.18594790e-01f, -1.98933005e-01f, -8.39187279e-02f, 4.55679186e-03f, -7.87246972e-02f, -5.87369986e-02f, 9.63721145e-03f, -4.66954224e-02f, -9.37209949e-02f, -1.94333978e-02f,
  1.83270331e-02f, -7.93245360e-02f, 4.76590823e-03f, -1.35535076e-02f, -3.89667079e-02f, -5.57006523e-02f, -1.16360024e-01f, 4.56389077e-02f, -1.28597096e-01f, 3.56297344e-02f,
  5.46760224e-02f, 3.87903824e-02f, -4.95659336e-02f, -7.28643825e-03f, -1.17901333e-01f, -1.03918038e-01f, -6.55554906e-02f, 1.95401367e-02f, 2.14877049e-03f, 9.33367908e-02f,
  -7.12704509e-02f, -2.19588473e-01f, -7.29159340e-02f, 2.10019603e-01f, -4.70978804e-02f, -1.48408130e-01f, -2.09362000e-01f, 8.67959186e-02f, 1.35838473e-02f, -1.72655508e-01f,
  -4.39117588e-02f, -1.05725035e-01f, -1.39860839e-01f, -5.89478910e-02f, 2.25116964e-02f, -1.65191799e-01f, 6.75671697e-02f, -1.11739479e-01f, 3.21211442e-02f, 1.68336526e-01f,
  1.56942427e-01f, 1.88671321e-01f, 2.12878644e-01f, 2.12535664e-01f, -6.95274770e-02f, 2.07339317e-01f, 2.01593935e-01f, 4.98223007e-02f, 1.80756375e-01f, 5.12891486e-02f,
  -7.63034821e-02f, -5.18768951e-02f, 9.42312554e-03f, 8.17190930e-02f, 4.91689779e-02f, 8.55988264e-02f, -1.81054287e-02f, -3.38228084e-02f, -1.67421475e-02f, 5.66545352e-02f,
  -6.93959072e-02f, 2.71275286e-02f, 7.32260123e-02f, 8.56827572e-02f, 1.23108961e-02f, -3.24850753e-02f, 5.66954203e-02f, 5.96705414e-02f, 1.71300229e-02f, 1.62700880e-02f,
  -7.60394782e-02f, -4.86550033e-02f, -2.62508914e-02f, -2.27784272e-02f, -5.86747117e-02f, 5.72996885e-02f, 4.05670628e-02f, -3.14245336e-02f, -1.74531098e-02f, 5.56433238e-02f,
  -1.75899435e-02f, -8.53596181e-02f, -8.94821249e-03f, -1.09497152e-01f, -4.70641106e-02f, 2.97101624e-02f, -1.35488540e-01f, -1.21052511e-01f, -3.77591588e-02f, -2.10331120e-02f,
  8.47298875e-02f, -7.01889768e-03f, 2.05671531e-03f, -4.83349664e-04f, 2.30507180e-02f, 3.57751921e-02f, 7.21497927e-03f, 1.33334445e-02f, 4.86989841e-02f, -9.15147662e-02f,
  -5.31783439e-02f, 4.48725224e-02f, 3.28243710e-02f, 1.08878380e-02f, -4.54277098e-02f, 5.81960529e-02f, 5.64795546e-02f, 1.24055883e-02f, -1.74761675e-02f, 2.75060758e-02f,
  3.73191051e-02f, 1.34126931e-01f, 1.60505355e-03f, 5.32126287e-03f, 2.17763353e-02f, -3.94740254e-02f, 2.85138227e-02f, 3.10143605e-02f, -4.57057394e-02f, -2.58599911e-02f,
  7.05239475e-02f, 6.18191138e-02f, -3.33698168e-02f, 1.46525294e-01f, 1.04610048e-01f, 2.97173887e-04f, 9.09363255e-02f, 2.33794693e-02f, 5.99781610e-02f, 1.40803829e-01f,
  2.25689858e-02f, -1.47382487e-02f, -5.34466058e-02f, -9.25383419e-02f, -7.32860267e-02f, -8.00546259e-02f, -6.34256005e-02f, 3.18954885e-02f, 4.82871868e-02f, -6.43125847e-02f,
  1.98096707e-01f, 1.59854274e-02f, -9.58923250e-02f, 5.19109294e-02f, -1.55649856e-01f, 6.64459914e-02f, 1.12927474e-01f, -5.51945355e-04f, -5.79816550e-02f, 8.73705521e-02f,
  5.00787497e-02f, -7.85967261e-02f, 9.71916616e-02f, 1.69149816e-01f, 9.97638702e-02f, 1.99047089e-01f, 2.03934520e-01f, -2.40066517e-02f, -5.21362610e-02f, 1.19047053e-01f,
  1.53683335e-01f, 1.78067163e-01f, 1.00720458e-01f, -4.53180708e-02f, 1.44594178e-01f, -7.37094656e-02f, 3.93318851e-03f, -2.51991861e-02f, -9.93354246e-02f, -1.32958844e-01f,
  6.34137914e-02f, -3.36150788e-02f, 5.40499203e-02f, 4.39330898e-02f, 3.75566259e-02f, 2.74883751e-02f, -3.18421610e-02f, -4.62239124e-02f, 2.09436403e-03f, -4.48467247e-02f,
  2.57172640e-02f, 1.11542568e-02f, 8.58575329e-02f, -8.01373050e-02f, 3.86890434e-02f, -5.23082390e-02f, -1.33064361e-02f, -6.77718148e-02f, -1.26898512e-02f, -2.68767565e-03f,
  -3.88393849e-02f, 5.17538972e-02f, -1.19203217e-01f, -5.60425520e-02f, 1.66466888e-02f, -6.65649772e-02f, -6.34206161e-02f, -5.89685366e-02f, -2.11340412e-02f, -6.89803883e-02f,
  -2.47058980e-02f, -2.00270209e-02f, 6.67262077e-02f, 2.65517775e-02f, 7.33257681e-02f, 3.26449350e-02f, -6.18380308e-02f, 1.51617350e-02f, 7.73622021e-02f, 4.73909639e-03f,
  -7.89749552e-04f, 5.99724299e-04f, 6.23937370e-03f, 7.78845418e-03f, 1.34658031e-02f, -8.85924399e-02f, 2.96557955e-02f, -8.91310535e-03f, -5.39715961e-02f, -4.81689423e-02f,
  3.27912010e-02f, -5.38298786e-02f, 1.47798443e-02f, 5.29958121e-02f, 5.61580211e-02f, 1.16896098e-02f, -2.43954994e-02f, -6.40816763e-02f, -6.95030252e-03f, -7.17845708e-02f,
  3.57564092e-02f, 1.13832630e-01f, 2.40297560e-02f, 3.73184159e-02f, 3.72768492e-02f, 5.89111038e-02f, 9.59154312e-03f, 8.43354464e-02f, 2.77664214e-02f, 9.73972753e-02f,
  6.94857240e-02f, 7.06565799e-03f, -2.86979740e-03f, -1.06067814e-01f, -1.34954751e-01f, 7.21208937e-03f, -1.17859151e-02f, -6.80138990e-02f, -5.44655286e-02f, -8.86496902e-02f,
  -1.00794360e-01f, 5.38352095e-02f, 1.69084445e-02f, -2.86432412e-02f, -1.01944923e-01f, -7.48230293e-02f, -8.59050974e-02f, -9.60732922e-02f, 1.27048120e-02f, 8.41652602e-02f,
  -1.42600074e-01f, 1.27748519e-01f, -2.06067324e-01f, -1.16297536e-01f, 6.45766258e-02f, -4.47563492e-02f, -4.98119891e-02f, -2.51221545e-02f, -1.55580729e-01f, 2.18091130e-01f,
  -2.26257928e-02f, 1.02986200e-02f, -2.67591770e-03f, -2.02286288e-01f, -4.03825521e-01f, -2.58534133e-01f, -1.73176467e-01f, -1.46459326e-01f, -5.64466901e-02f, -8.25463678e-04f,
  -1.06043383e-01f, -4.28627431e-02f, -1.56672448e-01f, 9.83066112e-02f, 9.99827310e-02f, 2.18275547e-01f, 1.83038950e-01f, 1.64090514e-01f, 1.04565777e-01f, -7.40947947e-02f,
  -8.86725634e-02f, 2.33124997e-02f, -3.61381983e-03f, -1.10949101e-02f, -9.20849666e-02f, 8.53822678e-02f, 1.60619877e-02f, -3.79741453e-02f, -1.00203464e-02f, 3.34399790e-02f,
  -2.18786411e-02f, 4.28977087e-02f, 5.18484116e-02f, -2.92650126e-02f, 7.79544115e-02f, 8.36797357e-02f, -6.58933297e-02f, 1.89009439e-02f, -6.25418208e-04f, -8.02284107e-02f,
  -5.10202609e-02f, -1.52801792e-03f, 9.57794636e-02f, -6.70715496e-02f, -1.99049395e-02f, -5.98362982e-02f, 1.04848020e-01f, 8.53367746e-02f, -6.73355488e-03f, 8.22678581e-02f,
  4.26560938e-02f, 5.36014549e-02f, -2.70901285e-02f, 2.82473378e-02f, 5.19458279e-02f, -4.14477922e-02f, -9.40346569e-02f, -2.69689038e-02f, 5.96315637e-02f, 7.61929108e-03f,
  4.75820415e-02f, 6.48750067e-02f, -1.16772333e-03f, 5.52502200e-02f, 1.51494034e-02f, 6.16997294e-02f, -1.47841116e-02f, -3.41332667e-02f, -5.00696003e-02f, -3.38497981e-02f,
  -9.55599733e-03f, -1.23393331e-02f, 1.16537092e-02f, 9.41284653e-03f, 3.09376121e-02f, -6.95709363e-02f, 5.29989265e-02f, 6.80398643e-02f, -1.50112174e-02f, 6.57220706e-02f,
  9.38182580e-04f, 8.08646381e-02f, 7.58372471e-02f, 4.08003889e-02f, 2.39504650e-02f, 2.50037592e-02f, -4.56113704e-02f, -5.52955493e-02f, 2.71288631e-03f, -5.00066057e-02f,
  2.14296523e-02f, 7.06197508e-03f, 1.17282227e-01f, 5.57438191e-03f, 4.45281565e-02f, 6.16287217e-02f, 1.50430920e-02f, -3.10987321e-04f, -1.13299647e-02f, 5.38493097e-02f,
  2.31978763e-02f, -4.91463998e-03f, -1.60462987e-02f, 4.59752940e-02f, 1.00982741e-01f, -1.49454512e-02f, 6.35811910e-02f, 9.35181677e-02f, -3.13229077e-02f, 2.90477909e-02f,
  -2.39530131e-01f, 9.90544111e-02f, 1.11070439e-01f, -1.62750274e-01f, 6.47042915e-02f, 1.30643412e-01f, -7.43351355e-02f, 1.27397776e-01f, -3.76565978e-02f, -7.74588659e-02f,
  -1.05895475e-01f, 1.22785188e-01f, 5.46618737e-02f, -1.03425793e-01f, -5.67368716e-02f, -1.48121994e-02f, -1.94238618e-01f, 4.24122205e-03f, 3.05706896e-02f, -3.89208235e-02f,
  -4.51865271e-02f, -5.20285219e-02f, 1.00890368e-01f, 1.07698821e-01f, 3.81795838e-02f, -1.87346097e-02f, -1.91798940e-01f, 7.46935159e-02f, -4.53357324e-02f, 4.30120938e-02f,
  -6.53319955e-02f, 1.19119979e-01f, 1.76361859e-01f, 6.95921406e-02f, -7.85408691e-02f, 1.86407715e-02f, 8.45217854e-02f, 4.77218740e-02f, -6.46433001e-03f, -3.28528285e-02f,
  -7.41884187e-02f, 4.15841900e-02f, -3.68359461e-02f, 2.89244112e-02f, 5.52777797e-02f, 1.45890698e-01f, 1.45675167e-01f, 3.27659063e-02f, 3.22026648e-02f, 5.38831651e-02f,
  2.35411357e-02f, 1.43242329e-02f, 6.24405146e-02f, -5.49180582e-02f, 7.87469000e-02f, 1.03555195e-01f, -1.36009410e-01f, -3.70617323e-02f, 5.63006066e-02f, -7.02175349e-02f,
  5.65624833e-02f, -3.12701426e-02f, 7.30781630e-02f, 6.81270957e-02f, 3.42855863e-02f, -8.44670162e-02f, -1.14651369e-02f, -2.61238441e-02f, -1.87287405e-02f, -3.42016034e-02f,
  -4.79482971e-02f, 1.22585483e-02f, 6.07131086e-02f, -1.25769731e-02f, -2.76597496e-02f, -1.78935111e-03f, 5.20260669e-02f, -3.28618730e-03f, -1.39723912e-01f, -4.90906239e-02f,
  7.28711188e-02f, 5.97572103e-02f, -3.72936763e-02f, -4.70596068e-02f, 6.24038018e-02f, 2.60209143e-02f, 4.42469493e-02f, 2.92764902e-02f, 6.49188762e-04f, -2.76159197e-02f,
  -1.54274434e-01f, -8.29887763e-02f, 5.50490990e-02f, 1.22676134e-01f, 1.38327047e-01f, -5.08132624e-03f, 9.11123492e-03f, 1.88702308e-02f, -8.88562351e-02f, 1.09213199e-02f,
  -4.47056480e-02f, 3.93239297e-02f, -5.57721555e-02f, 8.31452236e-02f, -9.92108360e-02f, -8.93250704e-02f, -3.67779694e-02f, -1.06169656e-01f, -4.97141294e-02f, -3.25359814e-02f,
  3.05424519e-02f, 4.42769453e-02f, 7.57513288e-03f, -3.76684628e-02f, -3.58739458e-02f, -5.13326600e-02f, 2.30598897e-02f, 5.39547503e-02f, 5.42945676e-02f, -7.93467760e-02f,
  -2.00708061e-01f, 1.42328218e-01f, -4.99907807e-02f, -7.21953213e-02f, 4.12114412e-02f, -1.58419073e-01f, -1.08086407e-01f, 5.11360988e-02f, 7.57443979e-02f, 5.74620441e-02f,
  -6.86632693e-02f, -3.12966555e-02f, -7.66916201e-02f, -1.55578226e-01f, -2.54439563e-01f, -2.24641323e-01f, -2.48316005e-01f, -5.97340055e-02f, -4.05886024e-02f, -5.14069982e-02f,
  -1.59721479e-01f, -8.51819068e-02f, -1.67684525e-01f, 2.65359104e-01f, 1.42726585e-01f, 2.33480304e-01f, -3.59494910e-02f, 1.64490476e-01f, 6.24022447e-02f, -5.54492138e-02f,
  -9.16552022e-02f, 2.89435256e-02f, -6.76411316e-02f, 8.46348107e-02f, 2.62500364e-02f, -2.40234192e-02f, 4.41856682e-02f, -2.76180468e-02f, -4.21302812e-03f, 1.02858702e-02f,
  6.47361018e-03f, -1.32399173e-02f, 2.58291960e-02f, 2.95815468e-02f, 4.66946065e-02f, -9.89221036e-03f, -1.10215135e-02f, 2.63982527e-02f, 8.85506123e-02f, 9.00378078e-02f,
  3.40933651e-02f, -3.57551093e-04f, -4.42688689e-02f, 4.79275919e-02f, -7.29327574e-02f, -3.89675759e-02f, -6.44134954e-02f, 5.15952706e-02f, 6.40193075e-02f, -5.08321859e-02f,
  -9.12045967e-03f, -3.17557878e-03f, 1.55543853e-02f, 5.76787032e-02f, -2.58547384e-02f, 5.46868406e-02f, 8.70958716e-02f, -1.11169424e-02f, 8.05841014e-03f, -4.78884131e-02f,
  -5.79506084e-02f, 1.08197741e-02f, -1.71885658e-02f, 1.00487694e-02f, -2.67668124e-02f, -4.07579280e-02f, -9.10848528e-02f, 5.25726490e-02f, -6.30323216e-03f, 9.92723461e-03f,
  8.11294168e-02f, -1.07359387e-01f, 1.21280439e-01f, -4.24463433e-05f, -1.32452347e-03f, 7.95590132e-02f, 5.20161204e-02f, 2.71134097e-02f, 2.66176313e-02f, 6.76447824e-02f,
  -2.74857860e-02f, -9.77660194e-02f, -8.17909930e-03f, 7.00359568e-02f, -8.04849621e-03f, -5.73022589e-02f, -1.08415924e-01f, -1.09450491e-02f, 2.52568182e-02f, 5.28243370e-02f,
  -1.23923337e-02f, -7.38176005e-03f, 4.75868955e-03f, -4.15833667e-02f, -8.79334137e-02f, 2.95899268e-02f, -7.31058046e-02f, -4.82704192e-02f, -4.98291105e-02f, 6.96582347e-02f,
  1.10307552e-01f, 7.47954696e-02f, 4.07583453e-02f, 4.34590690e-02f, -1.14221619e-02f, 2.19432041e-02f, -5.70717119e-02f, -2.90409401e-02f, -1.76116929e-03f, -3.81649993e-02f,
  5.27851656e-02f, 1.38263360e-01f, 1.85663700e-01f, 1.55562729e-01f, -5.90739492e-03f, -2.88155496e-01f, -1.55854017e-01f, 1.96595684e-01f, 4.73148040e-02f, -1.48718849e-01f,
  -1.86421320e-01f, 5.06504513e-02f, -2.15478376e-01f, 1.40304901e-02f, 1.73313677e-01f, -8.16732198e-02f, 1.22481309e-01f, -1.85409009e-01f, 2.42233559e-01f, 3.65398638e-02f,
  2.34147698e-01f, 1.07611135e-01f, 2.01726481e-01f, 1.57185286e-01f, 8.40609744e-02f, 1.31241843e-01f, 2.62838215e-01f, 9.11957398e-02f, -1.87623017e-02f, -1.22501530e-01f,
  7.87473097e-03f, -4.25054394e-02f, -5.62194688e-03f, -9.57671646e-03f, -4.55657952e-02f, 1.47508075e-02f, -5.42896450e-04f, -1.55773936e-02f, -4.93481616e-03f, -8.30100179e-02f,
  -5.61332256e-02f, 8.59437138e-02f, -3.30608562e-02f, -7.60728568e-02f, 4.29851897e-02f, 7.43798725e-03f, 3.50093208e-02f, -5.00484332e-02f, 5.02193086e-02f, 1.63182765e-01f,
  1.41013250e-01f, 7.22298622e-02f, -5.63488714e-02f, -4.12145555e-02f, 3.88811864e-02f, -4.31597754e-02f, -4.40528505e-02f, 8.47639050e-03f, -5.47348708e-03f, 6.97147548e-02f,
  1.97201371e-02f, 3.60601023e-02f, -5.22015579e-02f, 1.10340044e-02f, 2.40963250e-02f, 6.49539232e-02f, 2.38384604e-02f, 4.08663340e-02f, 1.02092974e-01f, 1.22902161e-02f,
  -1.37414420e-02f, 6.86369911e-02f, -2.45492738e-02f, 6.74048811e-02f, 5.91117442e-02f, 4.95826406e-03f, 3.64612043e-02f, -1.30420789e-01f, -2.47329939e-03f, 9.24735516e-02f,
  6.48014471e-02f, -3.23191136e-02f, 4.94853929e-02f, -1.81838293e-02f, 1.28334938e-02f, -4.03446034e-02f, -4.90235575e-02f, 2.58796681e-02f, 9.11445692e-02f, 4.78018075e-02f,
  -9.23848301e-02f, 6.85343742e-02f, -8.32473934e-02f, -5.12286238e-02f, 4.75064777e-02f, 5.43250814e-02f, 7.70497397e-02f, -2.06361394e-02f, 1.27044931e-01f, -1.20927714e-01f,
  3.37226316e-02f, -3.12589458e-03f, -3.72733292e-03f, -1.50320083e-01f, -5.22480384e-02f, -3.07184346e-02f, -9.18686986e-02f, -6.36992455e-02f, 1.51709951e-02f, 6.55548573e-02f,
  1.04034565e-01f, -3.56289931e-02f, -2.81567909e-02f, 1.10662416e-01f, -7.71429762e-02f, -1.95760857e-02f, 1.76244434e-02f, -2.70794425e-03f, 1.03392228e-01f, -3.82642262e-02f,
  1.85860187e-01f, 7.21278712e-02f, 3.25016258e-03f, -1.14936149e-03f, -1.60591200e-01f, -1.26775846e-01f, -1.48904435e-02f, 4.57394719e-02f, -3.33719589e-02f, 8.73076171e-02f,
  8.74686521e-03f, -6.04087971e-02f, 2.95157023e-02f, 1.26216009e-01f, 8.48758668e-02f, -6.86337128e-02f, 1.03035338e-01f, -2.31548995e-02f, -8.32633078e-02f, 1.29161790e-01f,
  4.44115102e-02f, 2.68162102e-01f, 2.15711482e-02f, 1.99929342e-01f, 9.36109796e-02f, 2.79527660e-02f, 1.18444249e-01f, 2.97957137e-02f, 1.32660747e-01f, 6.00063615e-02f,
  4.98559102e-02f, 7.35440254e-02f, -4.81520668e-02f, -1.21838469e-02f, -3.90505269e-02f, -1.86349005e-02f, -4.38352078e-02f, 3.41782055e-04f, -4.39204127e-02f, -5.50456271e-02f,
  5.04357889e-02f, -9.93500352e-02f, 7.34713227e-02f, 5.74198812e-02f, -7.00471476e-02f, -1.09174684e-01f, -3.39296460e-02f, 1.38639798e-02f, -3.37779662e-03f, 8.26920569e-02f,
  -7.78618902e-02f, -6.68674484e-02f, 4.08880413e-02f, -4.70966659e-02f, 7.66881695e-03f, -8.58566724e-03f, 2.30426546e-02f, 6.69487342e-02f, 3.78744269e-04f, 9.07851309e-02f,
  7.88947865e-02f, -1.38288056e-02f, 1.70870032e-02f, -5.07414937e-02f, -3.65932025e-02f, -1.04137406e-01f, 5.45777045e-02f, -5.11525348e-02f, -4.06455137e-02f, 1.09125108e-01f,
  -6.99804425e-02f, -7.01819174e-03f, -8.18197243e-03f, 6.04403876e-02f, 1.38702458e-02f, 3.12790237e-02f, 1.59005858e-02f, 6.14190437e-02f, 4.37344238e-02f, 6.28675008e-03f,
  -5.35914600e-02f, 3.21585611e-02f, -2.24397480e-02f, 7.94370249e-02f, -5.33453794e-03f, 4.41606194e-02f, 4.00038511e-02f, 8.91442075e-02f, -8.95798132e-02f, -6.35857508e-02f,
  1.08780071e-01f, 5.81580848e-02f, -6.90263137e-02f, -3.60463299e-02f, -1.31064123e-02f, 4.28175107e-02f, 4.72361855e-02f, 1.09959438e-01f, 9.86513123e-02f, 6.40498623e-02f,
  6.80523291e-02f, -1.27761558e-01f, 2.87990700e-02f, -4.08941554e-03f, 7.71912634e-02f, 9.33548808e-02f, -6.47774152e-03f, -5.87406158e-02f, -4.91286889e-02f, 7.77444690e-02f,
  -2.89085275e-03f, 6.07201979e-02f, 6.86440617e-02f, 5.81379933e-03f, -7.87923709e-02f, 9.56007764e-02f, -1.66433305e-02f, 4.17602770e-02f, -5.98904379e-02f, 2.75372644e-03f,
  4.10575978e-02f, 2.92672455e-01f, 1.55550003e-01f, 2.42723554e-01f, 5.28593361e-02f, 7.20939860e-02f, 1.00717656e-01f, 7.96168000e-02f, 2.00091332e-01f, -2.30700113e-02f,
  -1.54282153e-01f, 1.79485470e-01f, -5.16863987e-02f, 8.04721639e-02f, -1.69109181e-01f, -1.78894978e-02f, 3.28232795e-02f, 1.32905468e-01f, 2.01476604e-01f, -4.56922986e-02f,
  -8.23194459e-02f, -1.52028769e-01f, -1.58471107e-01f, -5.00967801e-02f, 6.73879161e-02f, -6.91918714e-04f, -2.59066761e-01f, 9.58324317e-03f, -7.12780356e-02f, 4.21284772e-02f,
  -1.26986489e-01f, 7.07029626e-02f, 5.91019355e-02f, 2.35800329e-03f, -5.11066578e-02f, 5.23975752e-02f, -4.83654626e-02f, 1.70784611e-02f, 6.92489147e-02f, 1.38430158e-02f,
  8.19620788e-02f, -7.75370225e-02f, -2.72961184e-02f, -7.50514567e-02f, 1.18618876e-01f, 4.32499452e-03f, -4.64252867e-02f, 8.19477662e-02f, 1.22528665e-01f, 7.62551278e-02f,
  -5.63906170e-02f, 7.66406953e-02f, -3.52156088e-02f, 6.33225543e-03f, -5.29075190e-02f, 6.85988218e-02f, 5.70171326e-02f, 1.53824538e-02f, -3.74997663e-03f, 6.34731650e-02f,
  1.60269648e-01f, -5.68269193e-03f, -5.17206499e-03f, -5.38070221e-03f, 3.27913612e-02f, -1.60337724e-02f, -6.56627566e-02f, -3.16062570e-02f, -1.63961332e-02f, -1.04886718e-01f,
  -1.95603780e-02f, 6.51593432e-02f, -4.70436877e-03f, 1.81238316e-02f, 1.49402125e-02f, -5.50475456e-02f, 2.24341657e-02f, 4.92400527e-02f, 5.93715683e-02f, -8.40659663e-02f,
  9.04349424e-03f, -5.75138442e-02f, -5.49833626e-02f, -6.64745197e-02f, -3.15301120e-02f, 4.87708710e-02f, -1.35789260e-01f, 3.89887094e-02f, 6.78317249e-02f, 6.16885051e-02f,
  -1.01718366e-01f, 4.27425019e-02f, 2.80746240e-02f, -6.27969056e-02f, 9.97992009e-02f, -1.16835237e-01f, -5.39151579e-02f, -8.72559175e-02f, -2.83031855e-02f, -6.68433607e-02f,
  -1.18969129e-02f, 5.86971380e-02f, -9.79133602e-03f, -6.43957332e-02f, 6.62411824e-02f, -1.18728327e-02f, -6.24936186e-02f, 1.97556335e-02f, -2.75912751e-02f, -7.40108043e-02f,
  -6.52705431e-02f, -6.85582832e-02f, -3.74133363e-02f, 2.66730655e-02f, -2.64027808e-02f, -5.05051389e-02f, 1.66420117e-02f, 6.48124218e-02f, 3.11644785e-02f, -2.13095658e-02f,
  -1.55174822e-01f, 3.09030980e-01f, 1.44384772e-01f, 2.12026939e-01f, -4.63953167e-02f, 9.71700773e-02f, 8.38285536e-02f, 1.16508082e-01f, -1.88355390e-02f, 1.10554934e-01f,
  5.60683012e-02f, 1.99532602e-02f, -1.42426491e-01f, 2.00692251e-01f, -1.78003028e-01f, -3.25371101e-02f, 1.30336910e-01f, 4.39256653e-02f, -3.62686142e-02f, -5.68401963e-02f,
  8.00841004e-02f, 3.34725007e-02f, 1.89472102e-02f, 8.27857573e-03f, 3.21120434e-02f, -2.44864374e-02f, 1.38118714e-02f, -8.88268172e-04f, 4.12406512e-02f, 1.75222624e-02f,
  1.21594205e-01f, 2.92635616e-02f, 9.78978500e-02f, 1.44249322e-02f, 3.00945453e-02f, -3.97622325e-02f, -3.98309231e-02f, 2.25258041e-02f, -2.23255754e-02f, 4.21249382e-02f,
  -6.77742064e-02f, -8.49913582e-02f, 1.85848735e-02f, -2.70252805e-02f, -8.80478546e-02f, 5.37707917e-02f, 6.66487589e-02f, -8.49752277e-02f, 6.34036809e-02f, -2.97033638e-02f,
  -9.03551430e-02f, -4.72211838e-03f, 4.92551215e-02f, 5.50915264e-02f, 5.03482744e-02f, 1.32550418e-01f, 4.52390462e-02f, -1.24809863e-02f, -4.87758517e-02f, 1.26690976e-02f,
  1.39555074e-02f, -6.26470745e-02f, 2.46080291e-02f, 1.24703599e-02f, 1.34323528e-02f, 8.23861659e-02f, -6.58276603e-02f, -6.08736910e-02f, -5.91068380e-02f, -1.09178554e-02f,
  8.12780708e-02f, 7.92013034e-02f, 4.69993688e-02f, -6.35561869e-02f, 6.99670538e-02f, -7.58514106e-02f, 1.55053828e-02f, 8.54273066e-02f, 1.33597041e-02f, 7.63221681e-02f,
  -4.35879640e-02f, -3.78458165e-02f, 6.81362255e-03f, 3.05843204e-02f, 9.22297165e-02f, -7.18118772e-02f, -6.82442784e-02f, -4.57362048e-02f, 8.28906074e-02f, 2.39810776e-02f,
  1.11373685e-01f, 1.94905609e-01f, -2.17829682e-02f, 9.18023810e-02f, -2.50604115e-02f, -2.54588444e-02f, 8.60072672e-02f, 1.09119087e-01f, 1.50375903e-01f, -3.19222584e-02f,
  -7.78052583e-02f, -4.20182906e-02f, -4.27830853e-02f, 1.39332013e-02f, -3.57592031e-02f, 7.92381540e-02f, -1.13996016e-02f, -5.65227941e-02f, 7.49883279e-02f, -5.08358181e-02f,
  3.99508663e-02f, 6.67122453e-02f, 1.16668336e-01f, -3.64908054e-02f, 4.91162762e-03f, 1.21084876e-01f, 1.79722644e-02f, 9.63029116e-02f, -7.59714991e-02f, 6.56363890e-02f,
  1.97644040e-01f, -3.00368071e-01f, -1.44370764e-01f, 1.50514662e-01f, 2.17882261e-01f, 1.82295337e-01f, 3.05389985e-02f, 1.37224123e-01f, 6.60380572e-02f, -1.31155044e-01f,
  1.08019166e-01f, -5.58873825e-03f, -1.44178778e-01f, 6.24142438e-02f, 1.31954759e-01f, -3.40157002e-02f, 1.30001217e-01f, 6.36007711e-02f, -8.17577764e-02f, -7.65149966e-02f,
  7.64540061e-02f, 1.94780633e-01f, -1.01145864e-01f, 3.33260335e-02f, 1.64085656e-01f, -6.60654232e-02f, -8.75696018e-02f, -1.20280527e-01f, 3.51440087e-02f, 1.10494278e-01f,
  6.51128888e-02f, -3.14695351e-02f, -3.73118706e-02f, 4.23709425e-05f, -8.30876082e-02f, -8.16689506e-02f, 3.72128561e-02f, -1.57871295e-03f, -3.45157720e-02f, -7.28321895e-02f,
  -7.62166157e-02f, -5.68208471e-02f, 1.10942321e-02f, 2.19634511e-02f, 2.01526228e-02f, 9.09051150e-02f, -2.14823671e-02f, -1.03767384e-02f, 2.26308983e-02f, -1.42581329e-01f,
  -8.74815956e-02f, 3.39306928e-02f, -9.93962749e-04f, 2.56574880e-02f, 7.52431247e-03f, 2.32384577e-02f, -8.64703730e-02f, -1.53236818e-02f, 4.19809967e-02f, -1.80377252e-02f,
  -9.22076255e-02f, -1.22636274e-01f, -5.03614061e-02f, 1.98333059e-02f, 1.79744093e-03f, -1.85485147e-02f, 4.38350625e-02f, 4.87478599e-02f, 1.78053640e-04f, 5.23743443e-02f,
  2.39825286e-02f, -4.32748273e-02f, 7.78347626e-02f, -1.88637897e-02f, -4.82547581e-02f, -1.75398588e-02f, 2.65319441e-02f, -4.95607667e-02f, -5.35960160e-02f, 6.06432147e-02f,
  -2.24592891e-02f, -2.71755294e-03f, 5.14326282e-02f, 2.93838643e-02f, -2.18970347e-02f, 6.64183199e-02f, 4.24888767e-02f, 7.89308771e-02f, 1.04598729e-02f, 1.97628923e-02f,
  -9.13151577e-02f, -2.01628074e-01f, -3.91043946e-02f, 6.28526285e-02f, 2.54965294e-03f, 8.83620381e-02f, -8.45460445e-02f, -1.27822282e-02f, 3.13090044e-03f, -1.18045611e-02f,
  -3.48647162e-02f, -5.35030775e-02f, -3.75860333e-02f, 6.53531970e-05f, 3.87380272e-02f, 2.68410258e-02f, -6.29421845e-02f, 3.39942127e-02f, 1.08236194e-01f, 6.94324896e-02f,
  -2.51943711e-02f, -5.66938184e-02f, -4.57489640e-02f, -1.08734593e-01f, 8.61623511e-02f, -4.34265956e-02f, -1.06212951e-01f, -3.28053087e-02f, -4.63434607e-02f, 2.74224058e-02f,
  -3.71354610e-01f, -1.33889737e-02f, -2.80287236e-01f, -8.53123143e-02f, -2.83102039e-02f, -7.82955363e-02f, 6.15555756e-02f, -1.17542461e-01f, -1.58481225e-01f, 2.13737547e-01f,
  1.87802255e-01f, -1.40531197e-01f, -2.02601869e-02f, 6.59032241e-02f, -2.88260251e-01f, 8.45353156e-02f, 9.64469537e-02f, -2.22474374e-02f, -1.57046318e-02f, -1.02577470e-01f,
  -2.97474936e-02f, 1.38731480e-01f, 1.99126955e-02f, 7.45150819e-02f, -1.04634643e-01f, 3.03645991e-02f, 1.70135006e-01f, -5.73476255e-02f, 1.13681354e-01f, -4.56734151e-02f,
  -1.33555338e-01f, -1.51602328e-01f, -1.02279641e-01f, -1.60957232e-01f, 4.17833962e-02f, 1.82964392e-02f, 2.62091774e-02f, -7.87035972e-02f, -1.72259435e-02f, -1.59758270e-01f,
  -2.52119657e-02f, -1.29051656e-01f, -9.17090327e-02f, 2.66437996e-02f, -2.53382069e-03f, 2.78631151e-02f, 7.30493665e-02f, -5.10096960e-02f, 2.47797556e-02f, -1.19999938e-01f,
  -9.62101854e-03f, 3.28065716e-02f, -1.03525072e-02f, 6.05140887e-02f, 5.91314398e-02f, 6.16295300e-02f, -4.74417694e-02f, -7.95175955e-02f, -1.10280693e-01f, -5.66891432e-02f,
  4.48758602e-02f, 2.94357110e-02f, -1.21778302e-01f, 2.18417160e-02f, 2.51208935e-02f, 9.03914422e-02f, -2.46352032e-02f, 7.67219290e-02f, 5.56357503e-02f, 8.92108232e-02f,
  -1.24268599e-01f, -2.99635576e-03f, 3.94553728e-02f, 5.98737486e-02f, 4.79749702e-02f, -8.45554769e-02f, 1.08593561e-01f, -5.74412048e-02f, 5.70800491e-02f, -3.82622555e-02f,
  -1.28542572e-01f, -1.43400311e-01f, 1.04392335e-01f, 2.55566519e-02f, -4.76668924e-02f, 9.35032666e-02f, -7.75425741e-03f, 1.53254177e-02f, 3.38338874e-02f, -8.68309885e-02f,
  -2.22882181e-01f, -7.46578872e-02f, -2.00317223e-02f, -3.31756622e-02f, -9.39369723e-02f, 5.45625687e-02f, -4.84154224e-02f, -6.53990358e-02f, -5.64102195e-02f, 7.82434195e-02f,
  4.22100239e-02f, -2.83928141e-02f, -9.88783389e-02f, 4.02267165e-02f, 3.13778128e-03f, -3.97721045e-02f, -9.16199088e-02f, -4.57306504e-02f, 6.07589483e-02f, 8.80575832e-03f,
  -1.31389452e-02f, 1.40287699e-02f, -1.82979219e-02f, 9.44015477e-03f, -4.08265926e-02f, -3.95375378e-02f, -5.65533563e-02f, -1.05526261e-01f, 1.17359675e-01f, -5.78005277e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  -7.19671883e-03f, 8.89140442e-02f, 2.20916092e-01f, 1.42769158e-01f, 1.96335092e-01f, 7.15538114e-02f, 6.34841323e-02f, 1.83912903e-01f, 5.65269776e-02f, 1.33099034e-01f,
  1.27020955e-01f, 6.71481863e-02f, 1.06305405e-01f, 1.83281839e-01f, 7.99295679e-02f, 1.48852214e-01f, 7.65668154e-02f, 1.55160248e-01f, 6.89943507e-02f, 9.02661979e-02f,
  2.35499233e-01f, 1.24461398e-01f, 3.01858522e-02f, 1.18984468e-01f, 1.93686426e-01f, 1.29160926e-01f, 2.00760484e-01f, 8.26258287e-02f, 2.50926197e-01f, 1.27219886e-01f,
  -3.06316707e-02f, -4.48197499e-02f, 1.30877495e-01f, 1.82015747e-01f, 1.01916991e-01f, 8.62142295e-02f, 4.33030948e-02f, 1.91766217e-01f, 1.09465614e-01f, 8.64985287e-02f,
  9.25166383e-02f, 1.36145294e-01f, 1.01712190e-01f, 1.29128948e-01f, 5.72977252e-02f, 2.46196389e-01f, 4.75905016e-02f, 1.33613199e-01f, 7.35849738e-02f, 2.49607489e-01f,
  1.30437195e-01f, 3.01652789e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.43819138e-01f, -1.37605920e-01f, -1.03121080e-01f, 1.19414637e-02f, -1.39838055e-01f, -1.43098816e-01f, 1.56146318e-01f, -9.98439044e-02f, -6.07783645e-02f, 1.14811659e-01f,
  -1.27817675e-01f, 1.42948672e-01f, 6.73635304e-02f, 3.37954387e-02f, 9.68079194e-02f, -7.32064098e-02f, 1.99237056e-02f, -6.23683706e-02f, 2.95780450e-02f, 5.39638326e-02f,
  3.27862166e-02f, 5.71571440e-02f, 1.36203274e-01f, 2.07106128e-01f, 1.13479882e-01f, 2.00631857e-01f, -1.89090252e-01f, -4.45004180e-02f, 6.45342981e-03f, -4.87121716e-02f,
  4.22809757e-02f, -1.51407754e-03f, 1.82138421e-02f, 6.29264414e-02f, -2.80766357e-02f, 7.05345720e-02f, -6.74774051e-02f, -8.62661526e-02f, -1.94196641e-01f, -3.74047793e-02f,
  -1.43234298e-01f, 8.87173638e-02f, 1.26462415e-01f, 5.90219498e-02f, 1.56146199e-01f, 6.04159608e-02f, -1.15594551e-01f, -8.77530426e-02f, 5.61392196e-02f, -4.39176820e-02f,
  -3.29324752e-02f, -5.17500900e-02f, 5.90450875e-02f, 7.84299448e-02f, 6.73526227e-02f, -1.50237083e-01f, 7.46092247e-03f, -7.76737481e-02f, 9.58956778e-02f, 9.03678313e-02f,
  -1.29723758e-01f, 9.42996237e-04f, 7.18263760e-02f, -1.00973817e-02f, 1.38478121e-02f, 7.30229691e-02f, -9.42159593e-02f, 8.33827183e-02f, -4.18262966e-02f, -3.14556137e-02f,
  -1.91471681e-01f, 1.47935584e-01f, 1.71196878e-01f, -2.01628581e-01f, 3.97278853e-02f, -9.61745605e-02f, -6.15653954e-02f, 1.01417206e-01f, -1.75320327e-01f, 1.26747072e-01f,
  1.53959412e-02f, 1.13547889e-04f, -2.26749495e-01f, -6.75096586e-02f, -8.96425173e-02f, -9.62187871e-02f, -9.05873626e-03f, 2.73132399e-02f, -1.57914907e-02f, -2.22123578e-01f,
  1.56134292e-01f, 1.53334707e-01f, -2.02116072e-01f, 3.37884985e-02f, 9.17757899e-02f, -8.88984874e-02f, -1.75873131e-01f, -2.73896512e-02f, -6.62387237e-02f, 5.70021346e-02f,
  -3.99129540e-02f, 1.24353506e-01f, 2.16695011e-01f, -7.85333104e-03f, 1.46611691e-01f, -1.66483000e-01f, -1.68130115e-01f, -1.68310646e-02f, -2.03381613e-01f, -3.60304005e-02f,
  1.07154064e-01f, 1.92890525e-01f, -1.25336960e-01f, 6.98376745e-02f, 1.22053131e-01f, 9.79151484e-03f, -6.72704130e-02f, -2.00158730e-01f, 5.47529049e-02f, -6.78419247e-02f,
  -3.43666933e-02f, -1.28080035e-02f, -2.24678498e-02f, -1.40891477e-01f, 2.88737789e-02f, -6.47823066e-02f, 2.48304401e-02f, -2.58081615e-01f, 2.22498383e-02f, -1.73821047e-01f,
  -3.85241322e-02f, -1.13709629e-01f, 7.02516213e-02f, -1.61940321e-01f, 5.82288913e-02f, -2.34414320e-02f, 1.15699947e-01f, -4.65251207e-02f, 1.13765977e-01f, 5.88808134e-02f,
  -1.11046635e-01f, -1.08696505e-01f, 2.69982591e-03f, 2.11197808e-02f, -5.28547429e-02f, 8.12295005e-02f, -2.04049662e-01f, 1.47387281e-01f, -1.14169093e-02f, -1.32041410e-01f,
  -2.28023157e-02f, 1.79035813e-02f, -3.80471274e-02f, -1.43121645e-01f, -1.60838645e-02f, -2.48659644e-02f, 3.07942573e-02f, -9.28302556e-02f, -1.19215876e-01f, -8.77894163e-02f,
  -4.43757735e-02f, -8.93233642e-02f, -4.05075289e-02f, 7.04068840e-02f, 7.25296065e-02f, 1.26028970e-01f, 6.98546320e-02f, 1.44038677e-01f, 1.96710244e-01f, 1.89766243e-01f,
  9.83341709e-02f, -1.15551248e-01f, -4.68311608e-02f, -1.90629251e-02f, -1.43072039e-01f, -1.56859905e-02f, -2.19136313e-01f, 8.42227191e-02f, -1.02197509e-02f, 8.09462890e-02f,
  1.75792500e-01f, -5.99371009e-02f, -9.19376835e-02f, -6.96385652e-02f, 9.05447975e-02f, -1.23156302e-01f, -4.71336842e-02f, -4.71990146e-02f, 1.55773079e-02f, -8.38379413e-02f,
  -8.62301290e-02f, 2.30137128e-02f, -5.89677505e-02f, 5.76912984e-02f, 3.05446871e-02f, -6.53334409e-02f, -1.27326727e-01f, 1.71702672e-02f, 4.74029966e-02f, 1.26184553e-01f,
  -8.03167075e-02f, -4.06554416e-02f, 7.62467682e-02f, -8.78066719e-02f, -7.50511587e-02f, 1.03891203e-02f, -5.60436808e-02f, -1.44846840e-02f, -5.50327636e-02f, -7.88061619e-02f,
  -7.13479817e-02f, -4.20915224e-02f, 1.07090339e-01f, -9.96866543e-03f, -1.95281934e-02f, 4.93863821e-02f, 1.39133736e-01f, 1.41264349e-01f, -1.79585218e-01f, 2.00746685e-01f,
  1.33832350e-01f, -2.11093485e-01f, -1.89136237e-01f, 1.95084527e-01f, 1.48919225e-01f, -1.65154532e-01f, -7.07435533e-02f, 7.46152103e-02f, -1.83042642e-02f, -9.60631073e-02f,
  -1.47941448e-02f, 6.07242659e-02f, -2.27236412e-02f, 1.25196725e-01f, -9.11452025e-02f, 5.83656132e-02f, 8.03098381e-02f, 5.96833043e-02f, -1.49355546e-01f, 1.72285736e-02f,
  -9.76210237e-02f, -9.48555097e-02f, 6.10785522e-02f, -7.25403726e-02f, 1.76208034e-01f, -1.50837585e-01f, 8.97011086e-02f, -6.55989721e-03f, 8.81437212e-02f, -4.19668928e-02f,
  -2.43267566e-02f, 1.77291825e-01f, 1.74170509e-02f, 2.05732509e-01f, -1.77355900e-01f, 1.84096105e-03f, 1.87387109e-01f, 1.28258467e-01f, 3.22525762e-02f, -7.31569305e-02f,
  6.50089830e-02f, 1.27199432e-02f, -2.05059409e-01f, 1.13381103e-01f, 1.87022924e-01f, -8.97110701e-02f, 9.73773748e-02f, -6.31397543e-03f, 1.20284945e-01f, 1.24947578e-01f,
  -2.42508855e-02f, 2.16456801e-02f, -7.83888027e-02f, 1.59604959e-02f, -9.84458402e-02f, -6.62966892e-02f, 1.53475339e-02f, -5.02092615e-02f, -1.95017919e-01f, -9.60564539e-02f,
  1.82620417e-02f, -1.40611917e-01f, 2.26811282e-02f, 4.32192236e-02f, -1.63306504e-01f, -7.78100863e-02f, 2.25420408e-02f, 5.40736280e-02f, -1.99128613e-01f, -1.43531039e-01f,
  1.07349865e-01f, 7.86174983e-02f, -1.35643557e-01f, 6.82978034e-02f, 1.21710576e-01f, -7.59614408e-02f, 2.23438859e-01f, -3.02858688e-02f, -8.76803771e-02f, -4.24220227e-02f,
  2.42868196e-02f, -1.33769616e-01f, 2.02196583e-01f, 2.92119533e-01f, -3.74034084e-02f, -1.72888160e-01f, 9.13539901e-02f, -1.76463388e-02f, 1.08695433e-01f, -3.76376361e-02f,
  1.18760549e-01f, 4.69298288e-02f, -5.83632663e-02f, 1.21827766e-01f, 4.37181294e-02f, 1.33507922e-01f, 1.67356998e-01f, 3.10220812e-02f, -1.20654523e-01f, -2.27836162e-01f,
  -1.14552461e-01f, -1.31969184e-01f, -3.83040160e-02f, 5.66780902e-02f, 1.96750127e-02f, 6.18093908e-02f, -4.12589088e-02f, -1.02911070e-01f, -1.66307062e-01f, 5.62170222e-02f,
  -1.25294179e-01f, 1.28706589e-01f, 1.83808841e-02f, -6.17535859e-02f, 1.33833870e-01f, -1.21397309e-01f, -7.58636892e-02f, -2.94314837e-03f, -1.56815484e-01f, -2.15155967e-02f,
  1.82358727e-01f, -7.99055770e-02f, 7.75231495e-02f, 8.45403783e-03f, -2.16657817e-01f, -1.18282102e-02f, -1.89149931e-01f, 1.04898863e-01f, 1.20111011e-01f, -8.89191106e-02f,
  -2.07726091e-01f, 6.87731802e-02f, -3.76345441e-02f, -1.05226099e-01f, -7.53919929e-02f, 1.75832957e-01f, -1.26072848e-02f, 3.59900370e-02f, -1.66343793e-01f, -2.16548905e-01f,
  -5.24462201e-04f, 6.00591823e-02f, 7.79154748e-02f, 4.74053212e-02f, -1.84284061e-01f, 1.17207885e-01f, -1.43333003e-01f, -1.38061941e-01f, -1.27155676e-01f, 1.26091838e-01f,
  3.42328921e-02f, -1.46857396e-01f, -4.02091956e-03f, -1.77648380e-01f, -1.82116941e-01f, 4.73069921e-02f, 1.59342349e-01f, 2.52274349e-02f, -1.13228939e-01f, -1.07685804e-01f,
  -1.47703320e-01f, -1.91185437e-02f, -9.34925526e-02f, 1.43792495e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -5.43757118e-02f, -2.73937965e-03f, 1.37730122e-01f, 2.14415081e-02f, 3.85536663e-02f, 9.01739225e-02f, -3.01837940e-02f, 1.21499449e-01f, 1.38462847e-02f, -5.93268648e-02f,
  -1.84945747e-01f, -1.15748923e-02f, -4.53841574e-02f, -1.32041099e-02f, 2.04750244e-02f, -6.03453554e-02f, -9.88554675e-03f, 4.69641909e-02f, -1.47250772e-01f, 1.29168585e-01f,
  -3.85849401e-02f, 6.67521432e-02f, -2.10111305e-01f, 2.76875615e-01f, 3.54688428e-02f, 7.88881108e-02f, -9.62272659e-02f, -2.21748976e-03f, 1.84619904e-01f, 3.54664661e-02f,
  -1.61102757e-01f, -1.60421237e-01f, 4.61848937e-02f, 1.13053724e-01f, 3.63477692e-02f, -5.12078404e-03f, 1.89589292e-01f, -3.84203494e-02f, 8.89766589e-02f, 2.54809350e-01f,
  5.75410947e-02f, 1.89003795e-01f, 1.38832614e-01f, 1.37311280e-01f, 9.94601287e-03f, -1.89860791e-01f, -8.16496927e-03f, 2.45036319e-01f, -8.89286865e-03f, 1.12216122e-01f,
  8.47880989e-02f, 4.04414423e-02f, 1.58747390e-01f, -8.94882157e-02f, -1.19019918e-01f, 1.59832075e-01f, 3.82978059e-02f, 1.54789329e-01f, 2.27161691e-01f, -1.06287919e-01f,
  2.29181334e-01f, 1.88671872e-02f, -1.41131341e-01f, 1.69685140e-01f, 6.15215823e-02f, 2.15227798e-01f, 1.69092879e-01f, 3.56466770e-02f, -3.38927843e-02f, 1.27984047e-01f,
  3.17133889e-02f, 2.09687874e-01f, -1.58375934e-01f, -8.15878436e-03f, 2.01728195e-02f, 2.34577879e-01f, 5.71295246e-02f, -2.48671144e-01f, 2.42484696e-02f, -8.36615562e-02f,
  1.95419341e-01f, -6.52811006e-02f, 7.08470447e-03f, -8.77176672e-02f, 1.92313686e-01f, 2.00902417e-01f, -5.18200584e-02f, -1.55517384e-01f, 6.14915229e-02f, 7.81885460e-02f,
  1.64197341e-01f, -1.34213328e-01f, 6.83087483e-03f, -2.63429880e-01f, 5.32755330e-02f, -7.00520277e-02f, 7.69362524e-02f, -6.01572394e-02f, 5.36344871e-02f, -3.50111537e-02f,
  1.23547137e-01f, 4.13572453e-02f, 4.55389358e-02f, -7.39140213e-02f, 1.22579508e-01f, 1.54604256e-01f, 1.44647703e-01f, -1.34689599e-01f, 1.21713160e-02f, 3.60291712e-02f,
  -4.01051641e-02f, -1.80583224e-01f, 1.63405761e-01f, 1.20978139e-01f, -5.77331558e-02f, 4.70070951e-02f, 6.70586675e-02f, -7.80699914e-03f, -4.81355824e-02f, 3.42043936e-01f,
  2.65564397e-02f, 1.86518684e-01f, -1.47366643e-01f, 6.02156408e-02f, -4.76136990e-02f, -4.62562330e-02f, 1.39780134e-01f, 2.29088411e-01f, -2.44996808e-02f, 7.44886920e-02f,
  1.46260247e-01f, 8.88792500e-02f, 4.64316877e-03f, 5.84844016e-02f, 7.03349486e-02f, -2.91575402e-01f, 8.82967860e-02f, 9.97185186e-02f, -3.14279288e-01f, -1.96231797e-01f,
  -3.50137195e-03f, 1.35793939e-01f, -3.60481665e-02f, -2.33325392e-01f, -1.12202228e-03f, 1.43682450e-01f, -5.27877472e-02f, 2.32345238e-01f, -5.93878934e-03f, 2.14363873e-01f,
  3.70615900e-01f, 1.63967744e-01f, -1.34010464e-01f, -1.18840687e-01f, -1.62996188e-01f, -5.68840429e-02f, 2.33672693e-01f, 3.53183568e-01f, -4.55404781e-02f, 1.42803192e-01f,
  -7.85754099e-02f, 1.33873895e-01f, -1.97804533e-02f, -1.86051339e-01f, -9.07322913e-02f, 1.45437062e-01f, -9.24526080e-02f, -1.03726111e-01f, -1.59886762e-01f, -1.57480501e-02f,
  -1.46277338e-01f, 5.25323078e-02f, -1.35478616e-01f, -3.90257724e-02f, 7.26556554e-02f, -4.01143637e-03f, -1.79350048e-01f, 1.12667687e-01f, -1.23017028e-01f, 5.03702499e-02f,
  2.13081583e-01f, 5.21406941e-02f, 7.09150806e-02f, -2.94147402e-01f, 2.31173083e-01f, -1.48424491e-01f, -3.11865620e-02f, -7.27409497e-02f, -2.11771384e-01f, -4.64840233e-02f,
  -6.01692311e-02f, -9.31577235e-02f, 2.02683613e-01f, 6.04076795e-02f, 2.08200533e-02f, 4.85395566e-02f, 1.93549678e-01f, 1.10385686e-01f, 5.57780266e-02f, -1.37657762e-01f,
  -7.15870038e-02f, 2.67719537e-01f, -2.13290200e-01f, -1.46450430e-01f, -1.52105689e-02f, 1.67765111e-01f, 7.84817636e-02f, 1.14065662e-01f, -7.06563592e-02f, -6.69352338e-03f,
  -1.51529104e-01f, -2.47809067e-02f, 8.44993368e-02f, -1.72716588e-01f, 1.58057272e-01f, -3.82153392e-02f, -1.14095747e-01f, 3.39114256e-02f, -1.93049565e-01f, 1.22885957e-01f,
  1.65748522e-01f, 1.21010132e-01f, -1.05639026e-02f, 6.40245304e-02f, 2.62715369e-02f, -5.08402772e-02f, -5.49855381e-02f, 1.63670972e-01f, -1.74696967e-01f, -5.29551990e-02f,
  -2.64959354e-02f, -7.09543452e-02f, -2.56992914e-02f, 6.49545491e-02f, 4.27459273e-03f, 1.93492875e-01f, 6.46689609e-02f, 7.76223466e-02f, -1.13387309e-01f, -1.10356644e-01f,
  -2.92198975e-02f, -3.17445546e-02f, 2.00244710e-01f, -7.30021894e-02f, 2.04862416e-01f, 2.44826656e-02f, 1.31981790e-01f, -1.91666529e-01f, 2.19460949e-01f, -3.92390834e-03f,
  1.91158384e-01f, 3.93505767e-02f, 6.42867908e-02f, 2.35887110e-01f, 4.13753428e-02f, 2.42361128e-02f, 1.22547266e-03f, 8.14988017e-02f, 6.80986568e-02f, 9.02587101e-02f,
  1.13877863e-01f, 8.33467990e-02f, -7.80693889e-02f, 1.45147309e-01f, -2.16681480e-01f, -6.22396842e-02f, 4.83398736e-02f, -4.67802435e-02f, 1.80678397e-01f, -1.17036454e-01f,
  8.41547921e-02f, -3.94280590e-02f, 1.56391755e-01f, 6.71796277e-02f, 3.91159020e-02f, -1.72343343e-01f, -1.20600961e-01f, 1.53751433e-01f, 1.75082125e-02f, -1.54762585e-02f,
  -1.67269334e-02f, 1.57543253e-02f, 1.38411865e-01f, -1.76161557e-01f, -1.34144753e-01f, -6.73699006e-02f, 1.81824982e-01f, -2.44460166e-01f, -4.83512804e-02f, 8.87432471e-02f,
  3.95098403e-02f, -1.48791701e-01f, 8.14808160e-02f, -9.69096050e-02f, -5.66915330e-03f, 9.69059318e-02f, 1.78291965e-02f, -2.45898500e-01f, 7.68259391e-02f, -1.59133840e-02f,
  -5.54593466e-02f, 5.27034961e-02f, 1.76253006e-01f, 8.30656476e-03f, 1.25228256e-01f, 3.65643464e-02f, -1.49900839e-01f, 9.91558507e-02f, -2.58839250e-01f, 1.35357365e-01f,
  -5.36855571e-02f, 1.98080406e-01f, -2.22092479e-01f, 1.01192445e-01f, -8.37685242e-02f, 9.03313700e-03f, -2.18622431e-01f, 1.18230611e-01f, 4.90520112e-02f, 1.13231018e-01f,
  2.44974285e-01f, 2.44434685e-01f, 3.04626018e-01f, 7.50521198e-02f, 1.66937813e-01f, 1.82282388e-01f, -1.74981967e-01f, -3.91570441e-02f, -5.80000393e-02f, 1.74335554e-01f,
  7.14092925e-02f, -1.16917983e-01f, -1.52694350e-02f, -1.23401187e-01f, 9.20637771e-02f, 9.31477025e-02f, -1.47479415e-01f, -1.04819037e-01f, 7.98421167e-03f, -7.11130351e-02f,
  1.40391365e-01f, -4.14073132e-02f, 1.87424690e-01f, -1.30102009e-01f, 2.37942263e-02f, -1.33828357e-01f, -1.74802974e-01f, 1.90051690e-01f, 6.97158650e-02f, 4.27814061e-03f,
  1.41673937e-01f, 8.53392556e-02f, 8.86866376e-02f, -4.14209627e-02f, 1.00825988e-01f, 1.26408553e-02f, 1.05181046e-01f, 1.83848217e-01f, 1.65570080e-01f, 9.40198600e-02f,
  1.50715098e-01f, 1.67660132e-01f, 1.30276784e-01f, -4.39213179e-02f, -5.38558662e-02f, 4.30413634e-02f, -9.25135165e-02f, 1.68137670e-01f, -7.43810646e-03f, 2.00806156e-01f,
  2.06997111e-01f, 1.92259729e-03f, 1.45770118e-01f, 1.79996610e-01f, -2.98401751e-02f, 2.16534749e-01f, 1.80271894e-01f, 2.32447490e-01f, -5.98107539e-02f, 1.38657659e-01f,
  1.82330251e-01f, 1.57008722e-01f, -6.78080618e-02f, 2.13390857e-01f, 4.46374901e-02f, 2.32596293e-01f, 1.22458525e-01f, 5.71985915e-02f, 1.25270739e-01f, 2.42792934e-01f,
  1.97817702e-02f, -2.27816537e-01f, 3.45859192e-02f, 1.52264953e-01f, -2.87814941e-02f, -2.21869081e-01f, -9.91493091e-02f, 1.08532839e-01f, -1.19706830e-02f, -1.18859671e-01f,
  3.61039490e-02f, 7.17114136e-02f, 3.25100124e-03f, 4.61235605e-02f, 1.59887850e-01f, 1.29656568e-01f, 3.29516768e-01f, -2.81862114e-02f, -2.16147840e-01f, -2.68287770e-02f,
  -2.00688422e-01f, 2.09611505e-01f, 1.37179255e-01f, -3.45242433e-02f, -4.22737338e-02f, 9.37141702e-02f, 1.10022593e-02f, 3.92515474e-04f, -1.98631495e-01f, 1.48614466e-01f,
  -2.12850466e-01f, 9.58244428e-02f, -9.60849673e-02f, -1.46854907e-01f, -7.15571418e-02f, 2.15741634e-01f, -1.02968432e-01f, 1.24981217e-02f, -1.42045300e-02f, 1.99782342e-01f,
  -4.40944396e-02f, -1.28307998e-01f, -7.58458078e-02f, 7.18448162e-02f, 4.31719162e-02f, -9.57960933e-02f, 1.34205576e-02f, -1.93279058e-01f, 1.14553183e-01f, -1.41169444e-01f,
  1.74871325e-01f, -2.22108811e-01f, -1.07122228e-01f, -1.48627497e-02f, -2.99017038e-02f, 1.95798919e-01f, -8.00171196e-02f, 5.35217263e-02f, 4.78466935e-02f, 2.75787134e-02f,
  1.81622542e-02f, 4.55372110e-02f, -2.35502236e-03f, -1.15956701e-01f, -3.37648503e-02f, 1.46978706e-01f, -1.52706474e-01f, -5.76118054e-03f, 2.18992308e-01f, -1.98351994e-01f,
  9.18455496e-02f, -2.64452118e-03f, -1.17596097e-01f, -1.28570870e-01f, 2.14796409e-01f, 1.68099497e-02f, 1.91323474e-01f, -1.43844768e-01f, -2.12200865e-01f, 2.70393491e-01f,
  7.39172054e-03f, -1.64848626e-01f, 1.45130739e-01f, 7.68150091e-02f, 2.57332679e-02f, -1.11088447e-01f, -1.56656384e-01f, -1.09235696e-01f, -6.47027120e-02f, 1.20766260e-01f,
  7.56299123e-02f, 9.36603472e-02f, -1.60837208e-03f, -1.02337031e-03f, -3.85014974e-02f, -5.46717644e-02f, 1.82404369e-01f, -2.30683126e-02f, 9.89708751e-02f, -1.73598737e-01f,
  -5.00076776e-03f, -7.89085329e-02f, 9.87906307e-02f, 9.20938179e-02f, 8.88701752e-02f, -1.79177880e-01f, 1.27740547e-01f, 9.55320895e-02f, -1.59936860e-01f, 9.51097235e-02f,
  -1.27617503e-02f, 1.08386809e-02f, -2.68062931e-02f, 1.47222191e-01f, -2.08528697e-01f, 7.90230706e-02f, 4.85940930e-03f, 1.13462448e-01f, -1.41991884e-01f, -5.01622371e-02f,
  1.24020427e-01f, 6.47087097e-02f, -3.47301438e-02f, 2.30426535e-01f, 2.09501073e-01f, 1.38010636e-01f, 1.46687344e-01f, 2.35477984e-01f, -3.43060978e-02f, -2.43299171e-01f,
  -1.22200167e-02f, 1.44690827e-01f, -3.38022649e-01f, -6.97987378e-02f, 9.28077474e-02f, 1.46614075e-01f, 2.31912613e-01f, -7.47330859e-02f, 6.08681999e-02f, -6.74352720e-02f,
  7.23339841e-02f, 1.41254351e-01f, 2.04147503e-01f, 8.21944624e-02f, 1.17601641e-01f, 9.09434282e-04f, 1.17465183e-02f, 9.93650258e-02f, 2.51189694e-02f, 1.18753035e-02f,
  1.85760185e-01f, 1.90430507e-01f, 2.02012938e-02f, -2.36598845e-03f, -6.99582398e-02f, 1.93419501e-01f, -7.57998303e-02f, -1.28849093e-02f, 5.74987680e-02f, 8.60098973e-02f,
  -1.66551977e-01f, -6.78868592e-02f, -4.27517518e-02f, 5.52079752e-02f, 1.08015187e-01f, -8.29526335e-02f, 8.19433182e-02f, 1.28597632e-01f, 8.43929350e-02f, 9.26328450e-02f,
  -8.03465322e-02f, 1.02682687e-01f, -3.61347385e-02f, 4.92679700e-02f, 9.68050659e-02f, 1.33417606e-01f, 8.01881403e-02f, 9.10944715e-02f, 2.09520787e-01f, 1.25962049e-01f,
  1.47879630e-01f, -1.67818174e-01f, 7.74116144e-02f, 9.78298262e-02f, 2.44046137e-01f, 1.93758950e-01f, 4.54672128e-02f, -2.86790431e-02f, 1.33295000e-01f, -3.69318612e-02f,
  6.02567904e-02f, 4.92660105e-02f, 7.16721490e-02f, 5.40631041e-02f, 9.82509460e-03f, 8.85885209e-02f, -1.42721191e-01f, 8.99552777e-02f, -1.36979744e-01f, -2.01937705e-01f,
  2.28747264e-01f, -2.35165805e-02f, 4.47286330e-02f, -1.57408729e-01f, -9.02156457e-02f, 2.29823306e-01f, 1.77616090e-01f, 4.47799675e-02f, 2.86080129e-02f, 2.44731039e-01f,
  9.60973203e-02f, 5.25398627e-02f, -1.75234862e-02f, 3.45198140e-02f, 9.82119367e-02f, -1.38939396e-01f, -6.89690560e-02f, 8.25878531e-02f, 1.65961757e-01f, 8.44600722e-02f,
  -6.21966235e-02f, -1.83980465e-02f, 8.03087428e-02f, 9.60081592e-02f, 1.89731061e-01f, 2.33150616e-01f, 1.72406986e-01f, 2.16381595e-01f, 2.22231284e-01f, -6.59362823e-02f,
  1.79844886e-01f, -1.91452727e-01f, -1.79595694e-01f, 1.87807992e-01f, -1.35015741e-01f, 9.77762863e-02f, 1.96161628e-01f, 8.21909979e-02f, 2.91086555e-01f, -1.26673698e-01f,
  -1.71296790e-01f, 1.97795346e-01f, 5.88944815e-02f, 2.56621361e-01f, -2.96330564e-02f, 6.27587214e-02f, 1.21005177e-01f, 9.50060785e-02f, -5.90158701e-02f, -4.89981808e-02f,
  1.86593801e-01f, 5.91494069e-02f, 1.37718886e-01f, 1.30631343e-01f, 1.00070268e-01f, 1.86994702e-01f, 6.78240657e-02f, 3.84287648e-02f, 3.24385613e-02f, -1.09918028e-01f,
  4.99777570e-02f, -1.87615797e-01f, 2.38791659e-01f, 2.66609937e-01f, 8.44454616e-02f, 1.41656995e-01f, 2.03554779e-01f, 1.75658226e-01f, 1.99204072e-01f, 8.58260542e-02f,
  -3.23763192e-02f, 6.76921755e-02f, 5.23682218e-03f, 1.38265416e-02f, 1.75609946e-01f, -7.64393136e-02f, 1.18809007e-01f, 8.84856284e-02f, -3.38328187e-03f, 1.03987522e-01f,
  5.07572293e-02f, 1.75478518e-01f, 1.66786045e-01f, 1.73315912e-01f, -2.27763597e-02f, 1.72016516e-01f, -1.01285227e-01f, 7.32427016e-02f, 2.41462842e-01f, 2.21590730e-04f,
  4.80235294e-02f, 6.56649545e-02f, -1.16064511e-01f, 3.07340231e-02f, 1.11258835e-01f, 4.63669561e-02f, 2.37291336e-01f, 2.33659789e-01f, 1.86047032e-01f, -1.26542911e-01f,
  1.71543449e-01f, 2.65958607e-02f, -1.01710431e-01f, -1.79594941e-03f, 1.97780862e-01f, -8.48156065e-02f, -2.11563855e-02f, 6.31168578e-03f, 1.47464052e-01f, 2.23858207e-01f,
  9.34363455e-02f, 1.11979082e-01f, 1.27290532e-01f, -4.46962304e-02f, 1.06101356e-01f, -3.96811217e-02f, 2.31598824e-01f, 1.20038558e-02f, 8.22003707e-02f, 8.62072594e-03f,
  1.42659590e-01f, 5.20043075e-02f, -1.49251714e-01f, 2.54592985e-01f, -1.63746014e-01f, 1.98954180e-01f, -1.04480319e-01f, -1.07197419e-01f, 2.23378286e-01f, 1.18125565e-01f,
  -9.29921120e-02f, 1.96919497e-02f, 1.51446432e-01f, 8.69707167e-02f, 2.09745795e-01f, 6.69431910e-02f, -4.82524708e-02f, 1.58310875e-01f, 2.33062301e-02f, 2.23326400e-01f,
  -1.48551911e-01f, -5.59031079e-03f, 2.40641892e-01f, 8.78631845e-02f, -1.37226293e-02f, -3.09912786e-02f, 3.10670100e-02f, 1.22494444e-01f, -6.97652772e-02f, 1.06735460e-01f,
  2.62515843e-02f, -4.77366857e-02f, -2.04523057e-01f, 8.67986307e-02f, -1.16672553e-01f, 1.05587579e-01f, 1.67773679e-01f, 1.73594877e-01f, 1.61958665e-01f, 4.19874378e-02f,
  -2.18651339e-01f, -1.87153906e-01f, -1.04404286e-01f, 6.83497116e-02f, 2.29204260e-02f, -7.42101148e-02f, 2.25250036e-01f, 1.17682867e-01f, -9.76689346e-03f, -4.73803543e-02f,
  5.17195016e-02f, 8.85963663e-02f, 1.27296271e-02f, 3.71581465e-02f, -1.04779735e-01f, 2.34626636e-01f, -5.43454327e-02f, 3.02561760e-01f, 1.87714621e-01f, 1.05533399e-01f,
  8.37056488e-02f, 6.13790043e-02f, 1.54537067e-01f, 2.94242322e-01f, -1.55723244e-01f, -2.45286152e-01f, 3.78252864e-01f, 4.33530621e-02f, -1.96926832e-01f, -1.80143476e-01f,
  -1.10312767e-01f, 2.48392716e-01f, 1.52995095e-01f, 1.00064047e-01f, 5.30972406e-02f, -4.89388332e-02f, -1.51148826e-01f, 1.99179158e-01f, 7.99043700e-02f, 1.18131511e-01f,
  1.22698598e-01f, 9.40401480e-02f, -1.60765380e-01f, -1.96481332e-01f, 3.50977108e-02f, 1.11790337e-01f, 2.59218961e-02f, 1.62498206e-01f, -9.24876034e-02f, 6.33336529e-02f,
  -1.94432914e-01f, -1.91017747e-01f, -1.05564974e-01f, -4.81581204e-02f, 7.57649094e-02f, 2.27277875e-01f, 2.91846633e-01f, -1.41900241e-01f, -2.04679668e-02f, 2.10051127e-02f,
  5.31961098e-02f, 8.23598430e-02f, -1.65353879e-01f, -1.25999436e-01f, 2.84240633e-01f, 2.24724635e-01f, -4.07021157e-02f, -6.22950718e-02f, 9.96455085e-03f, -8.12218525e-03f,
  2.79073864e-01f, -4.23340872e-02f, 2.96597406e-02f, -1.30545139e-01f, 9.16568264e-02f, 5.33395186e-02f, 1.52488634e-01f, -7.67663643e-02f, 1.95176139e-01f, 7.75859281e-02f,
  1.72152385e-01f, -2.91789286e-02f, 1.42164687e-02f, 1.83463410e-01f, 1.92126289e-01f, 1.13202278e-02f, 1.63955018e-01f, 1.18146606e-01f, 1.27032161e-01f, 2.42772922e-01f,
  1.58648274e-03f, -2.47904718e-01f, 3.38325679e-01f, 4.16622497e-02f, 1.41524794e-02f, 1.69777095e-01f, 1.56147301e-01f, 8.77051800e-02f, 1.48580655e-01f, 7.10904822e-02f,
  5.51549606e-02f, 4.43611816e-02f, 7.52215162e-02f, -4.96048480e-02f, -1.60326764e-01f, 1.45686492e-01f, 7.37050921e-02f, 1.09036297e-01f, -1.41824499e-01f, 2.17679486e-01f,
  7.64579698e-02f, -1.56819478e-01f, -7.62772784e-02f, 1.12416223e-01f, 1.89590886e-01f, 2.84770015e-03f, -5.87903447e-02f, 1.39431462e-01f, 1.77453384e-01f, -1.02010919e-02f,
  2.22822651e-01f, -1.41171841e-02f, 2.15389922e-01f, 6.05892204e-03f, 1.16891511e-01f, -4.62364107e-02f, 7.44871199e-02f, 1.60356835e-01f, 3.08739347e-03f, 1.84416771e-01f,
  2.93825045e-02f, -1.16343997e-01f, 2.51089931e-01f, 1.31242305e-01f, 1.36650115e-01f, -2.44264603e-01f, 1.00072175e-01f, 2.16786891e-01f, 3.87447253e-02f, 6.27333000e-02f,
  -8.44048932e-02f, 1.34847686e-01f, 2.24314824e-01f, 2.17827260e-01f, -5.78579633e-03f, 6.19770102e-02f, 6.65239096e-02f, 1.30254254e-01f, 1.29857302e-01f, 7.34485360e-03f,
  2.47901734e-02f, -5.51392883e-02f, 1.30474225e-01f, -3.61829326e-02f, 1.56610832e-01f, -3.91154550e-02f, -2.22543418e-01f, 1.90318406e-01f, -1.29014477e-01f, -2.30384827e-01f,
  1.83247060e-01f, 2.29098406e-02f, 3.96759808e-02f, -1.38875753e-01f, 4.15279977e-02f, 2.27280423e-01f, 4.41173799e-02f, -1.23717286e-01f, -1.31409228e-01f, 2.19663396e-01f,
  -5.49317664e-03f, 3.70464511e-02f, -1.57844946e-01f, -8.26233029e-02f, 1.41597107e-01f, 1.33341059e-01f, 1.14162736e-01f, 4.15477790e-02f, 6.27994388e-02f, 1.20255448e-01f,
  6.85668662e-02f, -8.09835270e-02f, 1.67134017e-01f, 6.05479404e-02f, 9.12087187e-02f, 6.00245781e-03f, 3.42408083e-02f, 4.61139567e-02f, 5.82975224e-02f, 2.43496485e-02f,
  6.80122450e-02f, -6.84362203e-02f, -2.63221055e-01f, -7.62319416e-02f, 2.52049696e-03f, 2.37146467e-01f, 2.11787242e-02f, 2.57724542e-02f, 2.44435370e-01f, 7.28194267e-02f,
  -2.09816247e-01f, 8.12172517e-02f, 2.57458482e-02f, 2.84882449e-02f, 1.02839172e-01f, 3.84656787e-02f, -2.86928955e-02f, 9.04699937e-02f, 3.48748975e-02f, 1.14354588e-01f,
  -2.54186764e-02f, -1.97896108e-01f, -1.28614111e-02f, 9.01367366e-02f, -1.43016115e-01f, -1.56260073e-01f, 1.07342541e-01f, -2.61628274e-02f, 1.53756514e-01f, 6.29009232e-02f,
  -9.48860720e-02f, 6.91976920e-02f, -1.61435619e-01f, -1.50220945e-01f, -1.91991571e-02f, -1.49836332e-01f, -2.36230358e-01f, -8.98109451e-02f, -1.24830781e-02f, 2.19130501e-01f,
  1.20543558e-02f, -1.54932454e-01f, -9.00502950e-02f, 2.38810867e-01f, 1.03618592e-01f, 1.04201749e-01f, 3.73740792e-02f, -1.36155009e-01f, 1.67856798e-01f, 2.48977244e-01f,
  -9.47779790e-02f, -6.05155043e-02f, 6.35938570e-02f, 7.98730329e-02f, -1.03071377e-01f, -1.44226581e-01f, 1.39290377e-01f, 4.91809137e-02f, -4.22521085e-02f, -1.06719680e-01f,
  -8.16520825e-02f, 1.15078874e-01f, 4.01223339e-02f, -1.85546558e-02f, 1.34230465e-01f, -1.65516168e-01f, -2.57750243e-01f, -1.46542579e-01f, 6.41936287e-02f, 1.85581539e-02f,
  9.95849445e-03f, -4.44597974e-02f, 1.05983742e-01f, 1.14978209e-01f, -9.90115944e-03f, -4.28304747e-02f, -4.42782640e-02f, -1.55660957e-01f, 1.05502671e-02f, -5.98413870e-02f,
  7.16331452e-02f, -6.98894709e-02f, -2.40184203e-01f, 9.30579193e-03f, 4.36313674e-02f, 8.25412869e-02f, 1.22492582e-01f, 4.33068424e-02f, 5.37216291e-02f, 1.10596836e-01f,
  -1.29871398e-01f, 9.07912329e-02f, -3.25835273e-02f, -1.40599430e-01f, -1.78388610e-01f, -4.03541699e-02f, 1.04330808e-01f, -1.49549335e-01f, 4.37587202e-02f, 1.62665412e-01f,
  1.00811310e-01f, -1.06779747e-01f, -7.78536573e-02f, 6.57360926e-02f, -2.29922190e-01f, 1.22156009e-01f, -1.95299447e-01f, -1.46493852e-01f, 4.19022962e-02f, 2.38406062e-02f,
  2.47126997e-01f, -1.86679199e-01f, -1.55892164e-01f, 5.83677031e-02f, 2.79318720e-01f, -2.23519549e-01f, 2.82191616e-02f, -9.57755446e-02f, 1.28465006e-02f, -9.05221850e-02f,
  8.37383047e-02f, 3.41549329e-03f, 3.22092101e-02f, 6.02528080e-02f, 3.58801223e-02f, -2.53536344e-01f, -1.13899261e-01f, -8.54592100e-02f, -1.62400659e-02f, 1.98773537e-02f,
  8.27213675e-02f, 2.48412043e-01f, 3.92337330e-02f, 1.19414553e-01f, 3.12895630e-03f, 1.67142749e-01f, -2.90892571e-02f, 1.43740997e-01f, -1.19820602e-01f, 7.14109689e-02f,
  -1.62864864e-01f, 1.57780021e-01f, 6.61741197e-02f, -1.77026447e-02f, 1.42196000e-01f, -7.96144083e-03f, 2.38582894e-01f, 5.97044863e-02f, 1.96942315e-01f, 4.65086848e-02f,
  1.06397510e-01f, 2.50261009e-01f, 2.16590017e-01f, 5.93113042e-02f, -1.96668386e-01f, 5.43131232e-02f, -2.80396473e-02f, -1.00631325e-03f, -6.19910434e-02f, -5.76684885e-02f,
  1.12821072e-01f, 5.60604818e-02f, 1.53877288e-01f, 2.39652738e-01f, 2.32154012e-01f, 1.06184222e-01f, -1.22729521e-02f, -1.17551293e-02f, -7.77126700e-02f, 8.44521523e-02f,
  -1.25599995e-01f, -4.17467579e-03f, -6.52067224e-03f, -4.15024050e-02f, 3.06216598e-01f, 1.34957358e-01f, -1.99127704e-01f, 5.07746115e-02f, 1.34144127e-01f, -1.61203831e-01f,
  -9.79921296e-02f, 1.27312362e-01f, 1.73501924e-01f, -5.29278703e-02f, 3.02386414e-02f, -1.09717309e-01f, 2.67671704e-01f, 1.35290682e-01f, 1.27977803e-01f, -1.83241025e-01f,
  -1.21464439e-01f, -6.00235462e-02f, -3.89455110e-02f, 4.53670435e-02f, 2.94524521e-01f, 1.76989704e-01f, 1.96039572e-01f, 1.24069162e-01f, -1.07974023e-01f, 2.02270925e-01f,
  -9.26739201e-02f, 2.28896052e-01f, 1.44318923e-01f, -1.24005545e-02f, 2.21925564e-02f, 2.04256535e-01f, 1.18387610e-01f, 6.23963960e-03f, 6.17488846e-02f, 3.77405472e-02f,
  2.61732966e-01f, -8.14357698e-02f, 6.60322458e-02f, 1.09997392e-01f, 1.99540854e-01f, 2.62994736e-01f, 1.03770643e-01f, 8.68901312e-02f, -1.21145129e-01f, -1.34875461e-01f,
  5.41251563e-02f, 6.18354082e-02f, -9.08467174e-02f, -1.21162467e-01f, -3.49465907e-02f, 1.11831747e-01f, -8.99567530e-02f, 3.29580456e-02f, 2.18764003e-02f, 3.52428630e-02f,
  1.84291884e-01f, -3.87324691e-02f, -7.42776245e-02f, -6.36875033e-02f, -1.01380851e-02f, -2.18125388e-01f, -1.25958353e-01f, -1.34880871e-01f, 1.33888841e-01f, 6.32273182e-02f,
  -2.34269157e-01f, 2.82327294e-01f, 1.38565958e-01f, -8.91197771e-02f, -5.38457073e-02f, 2.40245666e-02f, -6.53794687e-03f, -1.43031105e-01f, 3.69126685e-02f, -2.46806187e-03f,
  9.52013806e-02f, -1.29891127e-01f, -8.28037485e-02f, 1.84785873e-02f, -4.71266843e-02f, -6.88251331e-02f, 5.89871518e-02f, -3.35296523e-03f, 1.60929620e-01f, 1.33574679e-01f,
  2.01620653e-01f, 2.20525160e-01f, -1.10188752e-01f, 8.77910554e-02f, -3.20821553e-02f, -6.38617054e-02f, 1.15299881e-01f, 1.28995195e-01f, -2.15049803e-01f, 4.62160446e-02f,
  -7.92827755e-02f, 4.69360501e-02f, -1.84327200e-01f, -1.53805137e-01f, 1.53812468e-01f, 8.90637413e-02f, 3.31105925e-02f, 1.43357843e-01f, 3.57402638e-02f, -8.20190907e-02f,
  3.25881913e-02f, -3.61978672e-02f, 6.19962364e-02f, -3.82835306e-02f, -1.23148054e-01f, -8.05936828e-02f, 1.10188469e-01f, -1.31491452e-01f, -2.82037947e-02f, -6.43989444e-02f,
  -1.30810976e-01f, 1.22118719e-01f, 3.43950558e-03f, 9.39035341e-02f, -8.49438086e-02f, -9.22899246e-02f, -1.17524497e-01f, -1.25610024e-01f, 7.84348473e-02f, 9.18350220e-02f,
  4.65840101e-02f, -1.67585731e-01f, 5.48010357e-02f, 2.46204853e-01f, 2.40221433e-02f, -2.52158999e-01f, -6.16155751e-02f, 1.57011405e-01f, 9.82126147e-02f, -1.43755472e-03f,
  1.57884791e-01f, 1.65591985e-01f, 6.88947663e-02f, 1.24633051e-01f, 9.36428308e-02f, 1.45866513e-01f, 1.95499301e-01f, 7.90499523e-02f, -7.84607157e-02f, 4.88832556e-02f,
  1.55879363e-01f, -3.08757443e-02f, 7.75189325e-02f, 1.74657211e-01f, 9.15150996e-03f, -2.38587670e-02f, 2.63318722e-03f, 1.42470766e-02f, -5.75306006e-02f, 6.59023523e-02f,
  1.72560830e-02f, -2.38035209e-02f, -1.90681338e-01f, -1.33980840e-01f, 4.82176840e-02f, 1.46395385e-01f, 1.91860363e-01f, 1.98742628e-01f, -2.00781539e-01f, -2.48804484e-02f,
  2.30836585e-01f, 1.71741351e-01f, 5.15251011e-02f, 1.49644494e-01f, 1.21260263e-01f, 2.66552478e-01f, 2.07998082e-02f, 1.04049206e-01f, 1.94146052e-01f, -1.92342445e-01f,
  2.16549352e-01f, -1.47677079e-01f, -1.39358337e-03f, 7.82524496e-02f, 9.53392684e-02f, 1.88357413e-01f, 1.09077627e-02f, -3.62651385e-02f, -5.55216372e-02f, 2.06345320e-01f,
  -2.96955984e-02f, -6.36799354e-03f, 9.80212986e-02f, -1.01179890e-01f, 1.74359322e-01f, -4.45733033e-02f, -9.53504145e-02f, 5.52451126e-02f, 4.51211110e-02f, -9.71651003e-02f,
  -9.18660834e-02f, 2.26189360e-01f, -6.24387898e-02f, -1.00205734e-01f, -3.15714255e-02f, 1.42432064e-01f, -1.63205892e-01f, -3.32927220e-02f, 1.99246351e-02f, 4.11020517e-02f,
  2.42235675e-01f, 9.82898921e-02f, -1.29418552e-01f, 7.35188881e-03f, 9.31780934e-02f, 2.05438450e-01f, 1.42315567e-01f, 9.81973186e-02f, -9.24680009e-02f, -2.59153806e-02f,
  2.46701196e-01f, 1.67924985e-02f, 1.30069658e-01f, -1.40814021e-01f, -1.83817819e-02f, -1.15712862e-02f, 1.36802375e-01f, -1.14782892e-01f, 2.08840799e-02f, 1.91503271e-01f,
  1.33414403e-01f, -5.20106452e-03f, 5.31568676e-02f, -8.65115523e-02f, 1.26938179e-01f, 1.19404547e-01f, 9.48740076e-03f, -1.25705535e-02f, 6.37638802e-03f, 3.39046605e-02f,
  1.77336082e-01f, -1.17314264e-01f, 1.78493857e-01f, -1.39283106e-01f, 1.30245805e-01f, 6.65912926e-02f, -4.69567552e-02f, -2.92810705e-02f, 2.37654477e-01f, 1.77267820e-01f,
  -1.70944825e-01f, -8.54425225e-03f, 4.94601354e-02f, 1.67501986e-01f, 9.85118970e-02f, -7.25370869e-02f, 1.30950063e-01f, 3.62562597e-01f, 1.25989601e-01f, 1.54011384e-01f,
  7.48984590e-02f, 1.33282647e-01f, 2.77681857e-01f, -7.20390901e-02f, 2.87932977e-02f, 2.67454416e-01f, 2.72313915e-02f, 1.08553991e-02f, 7.00605214e-02f, 1.20679155e-01f,
  2.51846798e-02f, -8.10411870e-02f, 1.80661142e-01f, 1.10621013e-01f, 1.86817590e-02f, 8.73896629e-02f, 4.15624753e-02f, 8.93877819e-02f, 2.01693371e-01f, 1.01797596e-01f,
  -1.49386123e-01f, 1.32479966e-01f, -5.00601344e-02f, -7.08902553e-02f, 2.62646526e-01f, 9.21814218e-02f, 5.76061867e-02f, 1.87026665e-01f, -6.63240403e-02f, 2.38784496e-03f,
  1.48549914e-01f, -1.09572135e-01f, 2.62841582e-01f, 7.25322813e-02f, 2.75129676e-01f, 1.96528524e-01f, -2.49408692e-01f, -1.05935037e-01f, 1.51057750e-01f, 5.21776006e-02f,
  1.51015326e-01f, 2.00903475e-01f, 1.83161125e-01f, -3.46283391e-02f, -8.23641345e-02f, 3.29350531e-02f, -1.56700924e-01f, -5.76911122e-02f, 1.98429182e-01f, -1.26741111e-01f,
  2.57324189e-01f, 1.15743481e-01f, -2.68941913e-02f, 1.40542462e-01f, 1.05024733e-01f, 2.01673120e-01f, 1.84801802e-01f, 3.53655703e-02f, 1.39855966e-02f, 1.27623081e-01f,
  1.61232099e-01f, -6.80636242e-02f, 3.83803761e-03f, 6.59960434e-02f, 2.80872434e-01f, 7.78109282e-02f, 4.98860702e-02f, 1.82688445e-01f, -5.27202412e-02f, 7.36173540e-02f,
  -1.84897881e-03f, 1.35700017e-01f, 6.70995936e-02f, 5.63154854e-02f, -9.39366668e-02f, -9.87846702e-02f, -2.48793680e-02f, -1.24695323e-01f, 5.49753234e-02f, -1.40076026e-01f,
  -6.54121861e-02f, 5.71491458e-02f, 1.46592095e-01f, 2.19555095e-01f, 4.03120629e-02f, 8.46888572e-02f, 2.82121867e-01f, -8.34032707e-03f, -8.26784745e-02f, 4.26837280e-02f,
  -1.61395565e-01f, 1.84054956e-01f, 1.45388916e-01f, 1.10164825e-02f, -1.48562312e-01f, -3.40524353e-02f, 1.52531669e-01f, 1.60736173e-01f, -1.12566201e-03f, 3.76896672e-02f,
  9.94442105e-02f, 3.46879363e-02f, 1.32324755e-01f, 2.55294479e-02f, 2.45857742e-02f, 1.59612726e-02f, 1.09738246e-01f, 2.50890464e-01f, -1.87915895e-04f, -9.89061128e-03f,
  2.73780096e-02f, -1.42225504e-01f, 1.37501091e-01f, -1.03416376e-01f, -1.45099303e-02f, 6.50654221e-03f, 1.54784575e-01f, 8.49582255e-02f, -1.06178381e-01f, 1.89313628e-02f,
  7.55543709e-02f, 1.66394990e-02f, 2.06048310e-01f, -8.77512321e-02f, 1.57303169e-01f, 1.01390637e-01f, -2.94842441e-02f, -2.26959051e-03f, 3.15138064e-02f, 1.32145345e-01f,
  5.32544516e-02f, -1.87917680e-01f, -1.55019969e-01f, 2.75992841e-01f, -7.64041170e-02f, -1.96386099e-01f, -9.30621773e-02f, 7.47721568e-02f, -1.19660012e-01f, 1.45312920e-02f,
  -1.81762595e-02f, 1.47393212e-01f, 1.86324835e-01f, 1.59293085e-01f, 8.71702507e-02f, 2.20774606e-01f, -3.26313674e-02f, 1.72753468e-01f, -1.07421748e-01f, -3.73919378e-03f,
  -1.47699296e-01f, 4.13123667e-02f, 1.56240955e-01f, -6.25068741e-03f, 1.87549502e-01f, -6.80127963e-02f, 1.15755405e-02f, -7.48576000e-02f, 1.29591316e-01f, 1.16297141e-01f,
  2.83480692e-03f, -9.23642237e-03f, 1.38195068e-01f, 1.76537320e-01f, -2.69726515e-02f, 1.39124021e-02f, 3.40762660e-02f, -4.69286703e-02f, 1.42130733e-01f, 6.19483516e-02f,
  -7.79540613e-02f, 7.93074816e-02f, 8.32625479e-02f, 4.79489155e-02f, -2.37360001e-01f, -1.59184635e-01f, 2.80787557e-01f, 3.44836973e-02f, 1.06184475e-01f, 4.00463343e-02f,
  2.07442492e-02f, 1.05694599e-01f, 9.14507508e-02f, 6.79407418e-02f, 9.54724252e-02f, -1.79805495e-02f, 1.83954760e-01f, 1.37404893e-02f, 1.07929118e-01f, -5.88541180e-02f,
  1.40299439e-01f, 1.09010942e-01f, 4.68178615e-02f, 5.47044948e-02f, 1.05002120e-01f, -3.32950890e-01f, -1.31542072e-01f, 2.04449132e-01f, 1.24376498e-01f, 1.01466946e-01f,
  8.38194937e-02f, 2.26160064e-01f, -1.85822234e-01f, 2.38991510e-02f, -1.68614704e-02f, -5.55645814e-03f, 1.43698677e-01f, -2.46801730e-02f, -1.03328779e-01f, 1.46837413e-01f,
  9.50150490e-02f, 2.39810228e-01f, -9.29251760e-02f, -9.45069343e-02f, 6.28531575e-02f, -1.59495145e-01f, 8.03979710e-02f, -7.79028758e-02f, 2.55991593e-02f, 2.47727558e-02f,
  2.35165641e-01f, -7.37507865e-02f, -8.27718675e-02f, -2.77022682e-02f, -1.03363700e-01f, 1.50849685e-01f, 1.20333970e-01f, 1.70513719e-01f, 1.55776918e-01f, 4.03389819e-02f,
  1.74935475e-01f, 1.40635788e-01f, 2.53717989e-01f, 1.69413567e-01f, 1.51238739e-01f, 1.55516654e-01f, -1.63970023e-01f, -8.56782719e-02f, 1.73832685e-01f, -2.97899526e-02f,
  -9.10367891e-02f, 7.49942847e-03f, -1.22664377e-01f, 2.79427674e-02f, 8.58042315e-02f, 1.16130292e-01f, 2.04799864e-02f, -6.27750009e-02f, -1.13249019e-01f, 2.13044509e-01f,
  1.13439649e-01f, 9.71483067e-03f, 1.03056058e-01f, 1.82013493e-02f, -6.14161929e-03f, -2.02538092e-02f, -1.49957791e-01f, 9.82724428e-02f, 1.96762562e-01f, -1.52393989e-02f,
  -1.58238098e-01f, 1.89896375e-01f, 7.54233375e-02f, -3.57863791e-02f, -9.70133618e-02f, 2.46596001e-02f, 1.08996809e-01f, 4.81492169e-02f, 5.91517985e-02f, -8.53272155e-02f,
  2.13756993e-01f, 2.70727187e-01f, 1.70957342e-01f, -9.53210145e-03f, 8.59265178e-02f, -3.90199795e-02f, 5.14703058e-02f, -4.16980907e-02f, -2.00301558e-01f, -9.82533768e-02f,
  1.52843133e-01f, -2.93312613e-02f, 2.69434333e-01f, -1.42046228e-01f, 5.98337948e-02f, -4.93918061e-02f, 1.05676346e-01f, 1.91160798e-01f, -3.59665640e-02f, -4.94513288e-02f,
  2.49153331e-01f, 9.97636914e-02f, 3.13835172e-03f, 3.93318683e-02f, -5.42560555e-02f, 1.23418421e-01f, -2.95532607e-02f, 2.00708900e-02f, -4.46653590e-02f, 1.08405359e-01f,
  1.57555073e-01f, 1.24248236e-01f, -2.35099196e-01f, 3.80532853e-02f, 7.40279853e-02f, -7.63975307e-02f, 3.41888294e-02f, -7.69209191e-02f, -9.02018920e-02f, 4.96310852e-02f,
  1.36166379e-01f, 1.85195938e-01f, 1.64903536e-01f, -1.60234854e-01f, 3.76193002e-02f, 9.83270109e-02f, 1.03257611e-01f, -1.44734621e-01f, -3.30439769e-02f, 7.64958486e-02f,
  -7.46739144e-03f, -7.32064620e-02f, 6.56982362e-02f, -3.36766273e-01f, 1.95599258e-01f, -3.77261601e-02f, 2.11669952e-02f, -1.02089860e-01f, 1.71977252e-01f, -2.41334401e-02f,
  8.35594069e-03f, -2.07419291e-01f, -2.85009760e-02f, 1.65495425e-02f, 1.05309412e-01f, -2.85828896e-02f, 8.27507377e-02f, -6.06868081e-02f, 4.08216901e-02f, 2.36783430e-01f,
  -6.69249371e-02f, -1.10788800e-01f, 1.61432385e-01f, 1.13892937e-02f, -1.49156034e-01f, 1.41433045e-01f, -4.55866456e-02f, 2.32759595e-01f, 1.19558973e-02f, 2.50120228e-03f,
  -1.86517164e-01f, 6.73550144e-02f, 2.16262005e-02f, 1.97255760e-01f, -2.83314794e-01f, 1.77282915e-01f, 1.45883307e-01f, 1.55098990e-01f, 1.43539505e-02f, 1.09841965e-01f,
  1.87913194e-01f, 1.31135449e-01f, 8.27403963e-02f, 1.76528126e-01f, -5.56626953e-02f, 1.43512875e-01f, 6.33402765e-02f, -1.28999710e-01f, 1.50665879e-01f, -1.38146281e-01f,
  -4.62271608e-02f, 1.84256181e-01f, -1.60870757e-02f, 2.24064961e-02f, 5.32612503e-02f, 3.31444805e-03f, 1.12508275e-01f, 1.25557501e-02f, 2.03122899e-01f, -1.08583055e-01f,
  1.40552819e-01f, -1.39290810e-01f, 1.08641513e-01f, 1.82423204e-01f, -9.65222344e-02f, 2.32911840e-01f, 1.78891346e-01f, -1.60134718e-01f, 1.67821199e-02f, 3.14857066e-01f,
  -3.48979533e-02f, -9.25424471e-02f, -1.62964910e-01f, 2.04926521e-01f, -1.36908457e-01f, 1.80443987e-01f, 3.19056362e-02f, 1.23484187e-01f, 1.57019533e-02f, 1.77756280e-01f,
  -8.21029842e-02f, 1.55253008e-01f, 6.67771101e-02f, 1.85911447e-01f, 4.07090187e-02f, 4.96896431e-02f, -5.30918762e-02f, 9.41511765e-02f, 1.52063072e-01f, -4.67999205e-02f,
  8.48810151e-02f, -9.97859538e-02f, 1.31404594e-01f, -1.19451717e-01f, 6.46970123e-02f, -2.76882593e-02f, 9.41420197e-02f, 2.08766639e-01f, 9.91009772e-02f, 4.46692556e-02f,
  -1.27302557e-01f, 7.79834390e-02f, 6.16261587e-02f, -1.23538479e-01f, 4.98662330e-02f, 9.81253609e-02f, 2.59292722e-02f, 8.23876038e-02f, 4.69608009e-02f, 3.70778367e-02f,
  -8.65107402e-02f, 1.87379822e-01f, 1.62072048e-01f, 4.53205639e-03f, -8.40049330e-03f, -1.09849498e-01f, 1.16006158e-01f, 2.75952127e-02f, -8.32691267e-02f, -6.72690272e-02f,
  -4.17523012e-02f, 1.38977068e-02f, 7.11298212e-02f, -1.61439598e-01f, 1.48264840e-01f, 7.00836629e-02f, 1.37638524e-01f, 1.90797523e-01f, 4.99461684e-03f, 1.32643089e-01f,
  7.21380413e-02f, -2.21752107e-01f, 1.07229315e-01f, 1.68586850e-01f, -6.07196018e-02f, -1.34497777e-01f, -2.12414432e-02f, 1.48116320e-01f, -6.06361963e-02f, -1.97511643e-01f,
  3.32806855e-02f, 1.04920827e-01f, 7.78707713e-02f, 1.46982387e-01f, -1.58236802e-01f, 8.61615017e-02f, 1.89749748e-01f, 1.47051647e-01f, -6.18517399e-02f, 1.15695924e-01f,
  -1.24813989e-01f, -1.41452014e-01f, 1.25939935e-01f, 1.05836466e-01f, -2.03535765e-01f, 2.21241757e-01f, 1.57636508e-01f, -7.06038550e-02f, -9.24498141e-02f, -2.37579256e-01f,
  1.76724821e-01f, -2.09151246e-02f, 1.85511746e-02f, 2.47038715e-02f, -1.75485387e-01f, 1.74085096e-01f, 1.51190802e-01f, 1.79567456e-01f, 6.50733933e-02f, 1.47302940e-01f,
  1.95756868e-01f, -5.85844414e-03f, -1.39798656e-01f, -1.07226044e-01f, 7.42598530e-03f, 2.83312917e-01f, -1.80361494e-01f, -7.17446432e-02f, -6.37469739e-02f, 2.06175983e-01f,
  1.69611871e-01f, 1.18569853e-02f, 2.61406563e-02f, 1.29432693e-01f, -1.33168653e-01f, -4.37871777e-02f, 3.20920378e-01f, -1.03400938e-01f, 2.56692946e-01f, -1.47924781e-01f,
  -2.73764580e-01f, -1.74036603e-02f, -1.98902950e-01f, 2.57406123e-02f, 2.19335392e-01f, -2.83128563e-02f, -7.80003145e-02f, 1.48679912e-01f, 3.92895900e-02f, 8.48013386e-02f,
  -1.89253494e-01f, 9.91835818e-02f, -5.85203730e-02f, 1.82588398e-01f, -1.07367359e-01f, -5.55565767e-02f, -8.36426765e-02f, 3.06715310e-01f, 9.45479199e-02f, 1.10728957e-01f,
  -1.23710111e-01f, 9.37898271e-03f, -1.14785187e-01f, -1.84594825e-01f, -1.18703820e-01f, -2.54669785e-02f, 3.22720408e-02f, -1.51965022e-01f, 2.49248281e-01f, -1.60272550e-02f,
  4.30892967e-02f, -8.30894783e-02f, 1.27758965e-01f, 1.22292042e-01f, -9.75823179e-02f, -4.30571623e-02f, 5.89542352e-02f, 5.33543937e-02f, -5.50856553e-02f, 2.18013719e-01f,
  4.44657914e-02f, 6.02987744e-02f, -4.25734819e-04f, -3.49395424e-02f, 7.40610156e-03f, 1.87071398e-01f, -1.17263012e-02f, 2.00035274e-01f, -2.82049179e-01f, 1.16168350e-01f,
  5.10913730e-02f, -1.67614311e-01f, 5.10313995e-02f, 8.44256058e-02f, -1.20652549e-01f, 4.07261439e-02f, 2.35206336e-02f, 1.47676453e-01f, 7.02978224e-02f, 1.28362700e-03f,
  1.53525501e-01f, -4.48328182e-02f, 3.58793065e-02f, -8.37813914e-02f, 1.62639171e-01f, 1.77490488e-01f, -8.22440088e-02f, 1.70361638e-01f, 4.92595062e-02f, -2.26965725e-01f,
  1.74604744e-01f, 1.82775095e-01f, 1.90806668e-03f, 5.69144003e-02f, 5.65620735e-02f, 7.63371810e-02f, -9.79231223e-02f, -5.14154062e-02f, -5.86662535e-03f, 2.11615011e-01f,
  1.81102440e-01f, 1.33787915e-01f, -7.13721365e-02f, 1.29799157e-01f, 1.04233705e-01f, 2.42876232e-01f, -2.02676822e-02f, -8.37185979e-02f, 6.55559301e-02f, -8.89053196e-02f,
  1.30650371e-01f, 1.95629939e-01f, -1.46453187e-01f, 1.30515680e-01f, 4.10351343e-02f, -9.59336236e-02f, -1.91536725e-01f, -1.82711780e-01f, 2.25646868e-02f, 1.84121698e-01f,
  9.34713800e-03f, 1.58599943e-01f, -7.27630630e-02f, 1.47781745e-01f, 5.76821330e-04f, 6.45101517e-02f, 3.27196456e-02f, 1.52848914e-01f, 7.48656914e-02f, 8.02087411e-02f,
  1.52119234e-01f, 1.60700697e-02f, -2.59233654e-01f, 2.10364714e-01f, -9.48748589e-02f, 2.50737369e-02f, 4.50969972e-02f, -1.54632032e-01f, 1.72721252e-01f, 1.45186886e-01f,
  8.07041898e-02f, -2.02406831e-02f, 1.62946820e-01f, 4.21567187e-02f, 4.60706316e-02f, -6.02226816e-02f, 1.11448377e-01f, 1.17952460e-02f, 1.82983667e-01f, 1.97906882e-01f,
  1.16985247e-01f, 1.09751880e-01f, 8.16061199e-02f, 1.11347511e-01f, 3.46264504e-02f, -2.11840365e-02f, 1.48252174e-01f, -7.31996894e-02f, 1.39121443e-01f, -6.65247627e-03f,
  1.81402802e-01f, -1.40530169e-01f, -6.95387041e-03f, 2.00687960e-01f, 5.71066104e-02f, 1.64685160e-01f, -4.03708816e-02f, 1.58496410e-01f, 1.17359713e-01f, 5.12846373e-02f,
  2.84454431e-02f, -8.48480314e-02f, -1.78285746e-03f, 7.38326013e-02f, 7.54695619e-03f, -2.44716778e-02f, 9.54324938e-03f, 2.85142779e-01f, 1.18350014e-01f, -9.99299437e-02f,
  -5.46129197e-02f, -6.29005209e-02f, 2.96571344e-01f, 1.50244489e-01f, -8.18816421e-04f, 1.00810472e-02f, 1.02032460e-01f, 2.93309033e-01f, 1.35629522e-02f, 1.51152745e-01f,
  -1.33692352e-02f, 1.71206996e-01f, -2.76161339e-02f, -5.98065928e-02f, -1.54442880e-02f, 1.06776603e-01f, 1.91773221e-01f, -1.87212229e-01f, 2.19174679e-02f, 2.67632753e-01f,
  1.45991780e-02f, -2.70086735e-01f, -4.44963314e-02f, -4.28842790e-02f, -5.38654327e-02f, -2.13824622e-02f, -1.30190402e-01f, 7.40127861e-02f, -1.11689694e-01f, 3.88168469e-02f,
  -2.34160841e-01f, 2.11148709e-01f, 1.13056377e-01f, 1.76834911e-01f, -2.30983734e-01f, 1.12058379e-01f, 1.66531689e-02f, 1.48216849e-02f, -9.36991796e-02f, -1.94139287e-01f,
  -3.90358046e-02f, 1.61555231e-01f, -9.04818624e-03f, 5.39972894e-02f, 2.41032958e-01f, 1.41073734e-01f, 9.85507369e-02f, 2.06982642e-01f, 9.48266983e-02f, 8.41319934e-02f,
  2.43355781e-01f, 1.67866424e-02f, -1.08172894e-02f, -1.70648456e-01f, -1.29243687e-01f, 1.66370496e-01f, -1.61184803e-01f, 1.20086363e-02f, 1.60127118e-01f, -4.54887263e-02f,
  1.05225369e-01f, -8.98840725e-02f, -1.26816481e-01f, 2.35756233e-01f, 1.01134948e-01f, 1.96637481e-01f, 1.02101043e-01f, -1.08596720e-01f, 2.30780885e-01f, 1.42249212e-01f,
  -7.75644854e-02f, 1.23739824e-01f, -2.75828242e-02f, 1.21946804e-01f, 1.25789642e-01f, -9.11745578e-02f, 1.66350514e-01f, 1.36726677e-01f, -1.95896655e-01f, 1.62416860e-01f,
  -1.11598223e-02f, 1.13953672e-01f, 7.14766532e-02f, 8.98915976e-02f, 3.94659936e-02f, -1.74670294e-01f, 1.13334499e-01f, 8.17538276e-02f, -8.30382779e-02f, -6.68619722e-02f,
  -7.96502680e-02f, 4.04589474e-02f, 1.25645801e-01f, -1.12590184e-02f, -2.43987367e-01f, 5.65407798e-02f, 1.06129915e-01f, -8.27101991e-02f, 9.90772545e-02f, 2.34009713e-01f,
  -1.51736245e-01f, 1.40412524e-02f, 1.17201544e-01f, -2.63636142e-01f, -1.68892354e-01f, -2.00837061e-01f, 7.91828856e-02f, -4.44440246e-02f, -6.09527193e-02f, -4.29172534e-03f,
  8.83537158e-02f, 2.55192608e-01f, 1.89567015e-01f, 6.06335327e-02f, 1.44622073e-01f, 1.03633843e-01f, 1.60105675e-01f, -1.11595029e-03f, 3.19558620e-01f, 2.36057028e-01f,
  -2.79955529e-02f, -1.90970778e-01f, 1.01814128e-01f, 7.67486617e-02f, -2.23678183e-02f, 1.86204344e-01f, -7.09433481e-02f, 1.65907159e-01f, 3.45800370e-02f, 8.43395591e-02f,
  3.20920616e-01f, 2.35845950e-02f, 9.65071544e-02f, 1.16108857e-01f, 6.15256391e-02f, 2.59625353e-02f, 1.63281679e-01f, 1.09452672e-01f, 1.45635739e-01f, -5.91231734e-02f,
  -1.06807100e-02f, 1.20357029e-01f, -2.83685531e-02f, 1.66960150e-01f, -1.84487645e-02f, -5.49820019e-03f, 3.00596654e-01f, -3.74858128e-03f, -5.04366569e-02f, 8.53456855e-02f,
  -7.16933012e-02f, 1.85852468e-01f, -1.59186304e-01f, -3.99105400e-02f, 6.42967820e-02f, -1.39578864e-01f, 1.12978294e-02f, 5.45529537e-02f, 3.61328833e-02f, -5.12341596e-02f,
  1.49640650e-01f, 1.97896749e-01f, 4.39317003e-02f, 2.81370044e-01f, -1.91006828e-02f, -2.01082513e-01f, -5.98493256e-02f, 1.43160343e-01f, 1.12175561e-01f, -6.37067184e-02f,
  1.14449456e-01f, 2.15192199e-01f, -1.30818546e-01f, -1.29914030e-01f, 1.48170218e-02f, 9.77426171e-02f, 1.73460633e-01f, -5.55414073e-02f, 5.76426871e-02f, 5.48066720e-02f,
  7.39994720e-02f, 1.07231580e-01f, 1.46244904e-02f, 9.51845199e-03f, 5.99812828e-02f, -8.63366872e-02f, 1.95894331e-01f, -5.98024428e-02f, -5.25708683e-02f, 8.31386968e-02f,
  1.93978965e-01f, -1.83878094e-01f, -2.09129587e-01f, -2.45935276e-01f, 6.97627366e-02f, 2.20638633e-01f, 1.77400872e-01f, 7.54071772e-02f, -8.93995240e-02f, 4.58796583e-02f,
  1.29510656e-01f, -8.78748894e-02f, -4.61440533e-02f, -6.72426969e-02f, 2.15680748e-02f, 2.87344903e-02f, -3.36505882e-02f, 1.13201201e-01f, -6.17376082e-02f, -2.72928849e-02f,
  -1.64720193e-02f, -1.25883341e-01f, 4.54064719e-02f, 1.10938519e-01f, -4.09049029e-03f, -3.88931967e-02f, -1.40945554e-01f, -1.33456280e-02f, 8.63990858e-02f, 1.28500676e-03f,
  1.47171676e-01f, -2.54330840e-02f, 1.65192381e-01f, 3.75915915e-02f, -7.68758208e-02f, 1.91124618e-01f, -1.46156877e-01f, -2.10958067e-02f, 2.49170437e-02f, -1.52413145e-01f,
  -1.31690845e-01f, 2.00790197e-01f, -1.93827841e-02f, -1.13226399e-01f, -4.49689813e-02f, 2.37988271e-02f, 6.66359067e-02f, -1.14697419e-01f, 1.45192355e-01f, 1.14003262e-02f,
  2.26605132e-01f, 2.81542595e-02f, 4.63579223e-02f, 1.61236629e-01f, -8.90977085e-02f, -3.81140821e-02f, -1.27442986e-01f, -4.71278876e-02f, -1.17432289e-01f, -5.09119444e-02f,
  1.08426623e-01f, -9.17564481e-02f, 6.09035380e-02f, -1.37367621e-01f, -4.35474142e-02f, 1.19729362e-01f, 3.58371958e-02f, 1.19142018e-01f, 8.62365961e-03f, -2.86053456e-02f,
  1.69533029e-01f, 8.46498460e-02f, -2.03187973e-03f, 1.67819008e-01f, 1.22714452e-01f, 3.26130427e-02f, 7.12034032e-02f, 1.85560897e-01f, 1.24246880e-01f, -2.54418012e-02f,
  1.75936352e-02f, -2.32705288e-02f, 1.22921932e-02f, 2.04148903e-01f, -2.49924153e-01f, 8.63610953e-03f, 1.13298774e-01f, -4.21391092e-02f, 2.25037128e-01f, 1.32901054e-02f,
  1.68027878e-01f, 4.89399135e-02f, 1.94775879e-01f, 1.25310734e-01f, 4.21237648e-02f, 8.13746750e-02f, 2.01280117e-02f, 1.13853902e-01f, -8.37341696e-02f, 2.34134704e-01f,
  5.67495525e-02f, -4.61365543e-02f, 1.95307896e-01f, 1.10803947e-01f, 9.04870406e-03f, 5.51662035e-02f, 1.52265757e-01f, -2.94228503e-03f, 7.66118765e-02f, -5.19410931e-02f,
  1.40791655e-01f, 4.63787206e-02f, -2.19557971e-01f, 5.52139885e-04f, -8.52152109e-02f, 1.53974384e-01f, 1.17696129e-01f, -3.00397035e-02f, 1.57176346e-01f, -2.84495987e-02f,
  -1.16119996e-01f, -2.28397399e-01f, 1.30921062e-02f, 1.82269603e-01f, -1.16682440e-01f, 5.25211878e-02f, 7.95910973e-03f, 2.48486072e-01f, -8.92280638e-02f, 2.21307412e-01f,
  1.38020366e-01f, 1.89253539e-01f, -7.98953995e-02f, 3.70642100e-03f, -1.03287779e-01f, 2.51434259e-02f, 6.03167387e-03f, 2.38433003e-01f, -1.05608754e-01f, 1.77172329e-02f,
  -8.04833472e-02f, -4.32128459e-02f, -3.95948403e-02f, 1.13652319e-01f, 1.08242713e-01f, 1.77836820e-01f, 2.63361959e-04f, 1.85326025e-01f, 3.51860411e-02f, -4.60721590e-02f,
  -1.98983431e-01f, -8.92175138e-02f, -1.28907308e-01f, 7.34907985e-02f, 5.03790528e-02f, 4.35448997e-02f, 5.13114966e-02f, 6.67781979e-02f, 2.16009527e-01f, -1.19078882e-01f,
  -3.83531787e-02f, -7.85181299e-02f, 3.27624232e-02f, 7.44632334e-02f, -6.16284385e-02f, 1.53955117e-01f, -1.18776031e-01f, -1.35757893e-01f, 1.01010337e-01f, 6.75579980e-02f,
  8.29369277e-02f, -1.36308849e-01f, -4.76853456e-03f, 2.41907854e-02f, -1.79094095e-02f, 3.24647352e-02f, -1.15611084e-01f, 1.77357674e-01f, 1.49364561e-01f, -9.51413810e-03f,
  -4.67203297e-02f, 1.65483147e-01f, 1.52422741e-01f, 2.32110083e-01f, -4.00984250e-02f, 1.59425475e-03f, -9.50716138e-02f, -1.61896288e-01f, -7.54258707e-02f, -1.84100885e-02f,
  1.68065466e-02f, 1.17037900e-01f, 8.61325115e-03f, -3.22452262e-02f, -1.65202707e-01f, -1.77446589e-01f, 1.61760926e-01f, -1.05192930e-01f, -1.14573690e-03f, 9.98826474e-02f,
  1.49944248e-02f, 2.05156028e-01f, 1.49705231e-01f, 1.88470572e-01f, 1.15161695e-01f, 3.44278365e-02f, -4.84957686e-03f, 7.59148598e-02f, 8.31832811e-02f, 1.27425984e-01f,
  -2.61632681e-01f, 8.76064599e-03f, 9.99041274e-02f, 9.68057364e-02f, 2.26173531e-02f, -1.48066863e-01f, 8.37518275e-02f, -1.18803084e-01f, 2.21994698e-01f, 1.90068975e-01f,
  1.93871245e-01f, 2.17713472e-02f, -6.98190853e-02f, 1.22925043e-01f, 1.27364978e-01f, -1.36310920e-01f, 1.36186317e-01f, 1.65682640e-02f, -6.27543852e-02f, -1.44528911e-01f,
  -8.27101246e-02f, -2.09511697e-01f, 7.63880312e-02f, -8.94554630e-02f, 1.65875018e-01f, 1.32405505e-01f, -6.69821203e-02f, 9.41563249e-02f, 5.45360446e-02f, 6.93780035e-02f,
  -4.51212004e-02f, -9.08855498e-02f, 5.01664504e-02f, -2.15188321e-02f, 2.25208730e-01f, -1.34339899e-01f, 7.07148537e-02f, -1.47154406e-02f, -6.89577684e-02f, -2.09052905e-01f,
  1.08505681e-01f, 2.80718595e-01f, -1.19991787e-01f, 8.09349567e-02f, -4.57545891e-02f, 4.39743437e-02f, -1.38062432e-01f, 2.75441259e-01f, 2.50900611e-02f, 1.63178504e-01f,
  -1.31902114e-01f, 7.46278912e-02f, -1.06380530e-01f, 5.03643528e-02f, 9.40544903e-02f, 2.71058023e-01f, 7.77556524e-02f, 1.18474223e-01f, -5.33547066e-02f, -3.70248407e-02f,
  -2.99983956e-02f, -3.02752163e-02f, 7.98217859e-03f, 1.48567960e-01f, -2.39082739e-01f, 3.91767882e-02f, 4.11205972e-03f, -1.24555334e-01f, 1.31011024e-01f, 9.56086591e-02f,
  3.83476242e-02f, 1.66196018e-01f, 1.04467236e-01f, 4.41746302e-02f, 1.60740048e-01f, -3.29497294e-03f, -1.01410151e-01f, 6.85085431e-02f, 1.61470678e-02f, -1.15067855e-01f,
  3.21379304e-02f, 9.62022692e-02f, 1.31601140e-01f, -1.65789984e-02f, -8.87254253e-02f, -1.79529592e-01f, 1.64961845e-01f, -8.53429213e-02f, 1.44565880e-01f, -4.01532128e-02f,
  3.58667821e-02f, 4.61462215e-02f, -6.41552731e-02f, -1.47765264e-01f, -9.23603699e-02f, 1.35031223e-01f, -3.59236039e-02f, -1.01102926e-01f, 4.32115570e-02f, 5.96002750e-02f,
  1.28613189e-01f, 1.68722019e-01f, 1.47795072e-02f, -7.04367878e-03f, 2.59496987e-01f, 1.84713736e-01f, 1.29305311e-02f, 1.32760033e-01f, -1.93822175e-01f, 2.06789941e-01f,
  6.04428090e-02f, 1.78994119e-01f, -2.33560920e-01f, 9.43533331e-02f, 7.60781094e-02f, 1.56467766e-01f, -2.00306803e-01f, -4.36841212e-02f, 1.44369528e-01f, 2.58271694e-02f,
  3.00020278e-01f, 2.13413656e-01f, 2.77905643e-01f, 1.95361748e-01f, 1.65318534e-01f, 1.94744259e-01f, -1.50509790e-01f, 6.90312088e-02f, -1.06037892e-01f, 1.92650273e-01f,
  -4.90062088e-02f, -2.63059676e-01f, 2.16577619e-01f, 2.42318243e-01f, 1.58627227e-01f, 8.07370245e-03f, 2.38690838e-01f, 1.00767389e-01f, 1.17177978e-01f, -7.80439451e-02f,
  2.98112869e-01f, 2.79115647e-01f, 2.70233095e-01f, -1.12755351e-01f, -4.90632653e-02f, 9.24120396e-02f, 1.24022141e-01f, 1.76433235e-01f, 1.12951979e-01f, 4.09800224e-02f,
  -4.75379080e-02f, 2.10768417e-01f, 1.02248639e-01f, -3.40359472e-02f, 6.27177209e-02f, 2.31204093e-01f, 5.87846339e-02f, 3.16209272e-02f, -7.16114864e-02f, -2.32160658e-01f,
  3.89431939e-02f, 1.78842783e-01f, -1.13664484e-02f, 4.59244065e-02f, -4.46681976e-02f, 9.10793170e-02f, 1.97992340e-01f, -6.98040724e-02f, 1.62149727e-01f, -2.54533663e-02f,
  8.20966884e-02f, 8.10704976e-02f, 6.33458123e-02f, -1.37867048e-01f, 1.09988943e-01f, 1.44500300e-01f, 2.30486065e-01f, 2.03934148e-01f, -1.68151110e-01f, -3.08535546e-02f,
  5.20289354e-02f, 4.84216437e-02f, 2.50098705e-01f, 3.12207639e-01f, 1.38048962e-01f, 8.19101110e-02f, 7.13084787e-02f, 6.95627406e-02f, 9.60216224e-02f, -1.06111407e-01f,
  9.38974768e-02f, -2.15044711e-02f, -2.33172774e-01f, 4.32738587e-02f, -5.84770851e-02f, -2.18237564e-01f, -8.96412134e-03f, 5.67617267e-02f, -1.43279746e-01f, -1.30444169e-01f,
  1.30593508e-01f, 7.60811269e-02f, 2.53651679e-01f, -1.87549964e-01f, -2.13427898e-02f, 1.98102161e-01f, 2.08682582e-01f, -1.83480367e-01f, -8.21061879e-02f, 1.52933329e-01f,
  -3.58211771e-02f, -1.03297517e-01f, -2.13263649e-02f, 7.67879561e-03f, 1.69402167e-01f, -2.48019081e-02f, -2.13042222e-04f, 1.27878591e-01f, 1.77833542e-01f, -1.22017220e-01f,
  -2.29857536e-03f, 1.33631647e-01f, -1.32764205e-01f, 5.12230285e-02f, -4.92914952e-02f, -1.87165231e-01f, -1.03741534e-01f, 3.03141847e-02f, -5.24338186e-02f, 1.31063402e-01f,
  7.78190047e-02f, 2.40167435e-02f, 6.58368990e-02f, 1.74796104e-01f, -1.54699594e-01f, 1.41471863e-01f, -4.96536642e-02f, 6.02720417e-02f, -8.07735026e-02f, 2.56629530e-02f,
  -1.49156928e-01f, -5.31865433e-02f, -1.35130035e-02f, -8.16842914e-02f, -8.33440125e-02f, 3.03609786e-03f, 2.02490285e-01f, 2.15119824e-01f, 7.46703222e-02f, -1.79326851e-02f,
  1.75275479e-03f, 5.98905049e-02f, 1.21794328e-01f, 1.60150468e-01f, -2.04071268e-01f, 6.34607077e-02f, -1.07189983e-01f, 1.67498350e-01f, -1.95953339e-01f, -1.34220287e-01f,
  7.55603388e-02f, -3.81143880e-03f, 5.77611849e-03f, -4.00411822e-02f, 8.27228278e-02f, 1.47957385e-01f, 1.85710460e-01f, 1.65358126e-01f, -8.64646509e-02f, 7.88102895e-02f,
  1.30164027e-01f, -2.05069944e-01f, -1.61517598e-02f, 1.16628483e-01f, 2.85077929e-01f, 1.32810205e-01f, -1.74011201e-01f, 2.74849951e-01f, 2.28415772e-01f, -4.98760454e-02f,
  -6.21532202e-02f, -1.06711499e-01f, 1.69225872e-01f, 4.77051325e-02f, -1.15781911e-02f, -1.30750882e-02f, -4.59495969e-02f, 1.38964113e-02f, 3.75489518e-02f, 2.16675643e-02f,
  -1.05405159e-01f, 6.48726076e-02f, 9.75172222e-02f, 4.77601364e-02f, 2.63312578e-01f, 2.08622590e-01f, 9.10923183e-02f, 1.33877188e-01f, 7.87517875e-02f, 2.08678976e-01f,
  -5.35470955e-02f, 2.20234051e-01f, 8.39633048e-02f, -9.74883884e-02f, -6.16917871e-02f, 1.01746116e-02f, 2.02931002e-01f, 7.06692189e-02f, -8.32123384e-02f, 1.87391527e-02f,
  3.96567881e-02f, 1.04513451e-01f, -3.85553605e-04f, -3.52427065e-02f, 2.35209301e-01f, 1.31446242e-01f, -1.94839854e-02f, 1.55565947e-01f, -6.35881498e-02f, -3.07604168e-02f,
  4.72367890e-02f, 2.42532402e-01f, -2.55689800e-01f, 1.15189500e-01f, 7.44104162e-02f, 6.73046708e-02f, 5.75839877e-02f, -2.83581465e-02f, -1.69597268e-02f, -2.00382080e-02f,
  -5.30800819e-02f, 1.69418007e-01f, -4.37755790e-03f, -8.87220167e-03f, 3.72554585e-02f, 4.73028980e-02f, -1.30393252e-01f, -6.18809424e-02f, 1.29568756e-01f, 1.66240409e-02f,
  2.21697837e-01f, 2.70361751e-01f, 1.17200971e-01f, 7.01033324e-03f, -7.25987405e-02f, 1.81127921e-01f, -5.65634891e-02f, -2.08783761e-01f, 4.49176803e-02f, 1.59354001e-01f,
  -1.43548220e-01f, -8.46530721e-02f, -1.60192400e-01f, 2.10559070e-01f, 9.29205716e-02f, 1.41071856e-01f, 4.69236374e-02f, 2.57771946e-02f, -2.05452722e-02f, 1.86379701e-02f,
  1.88741311e-02f, 2.15351731e-01f, 6.99233785e-02f, -6.13331422e-02f, 2.46995702e-01f, -7.17625814e-03f, 5.26985005e-02f, 1.69658989e-01f, 1.23039506e-01f, 2.37024680e-01f,
  1.98998585e-01f, -5.31974137e-02f, -9.59024057e-02f, 6.08647130e-02f, 2.39168610e-02f, 3.97878326e-02f, 9.23777670e-02f, 2.81345069e-01f, 7.47464150e-02f, 1.42256916e-01f,
  1.37369961e-01f, 1.24292046e-01f, -2.16967389e-01f, 2.77599812e-01f, 5.69433346e-02f, -2.12201267e-01f, 1.50385514e-01f, 1.19643576e-01f, -4.40028235e-02f, 3.26742902e-02f,
  -2.52431235e-03f, 7.78193548e-02f, 5.65608740e-02f, -8.87532905e-02f, 8.26606248e-03f, 3.21332403e-02f, -1.28911284e-03f, -5.46427704e-02f, -2.16443345e-01f, -5.72920032e-02f,
  9.76357087e-02f, -4.67205457e-02f, 8.61748829e-02f, 8.02063569e-02f, -2.18036305e-02f, -1.37076333e-01f, 2.01856926e-01f, 2.49152724e-02f, 4.72677983e-02f, -4.37774882e-02f,
  1.02482447e-02f, 7.47851282e-03f, 1.75679699e-01f, -3.97461914e-02f, 6.51089549e-02f, 2.01032236e-01f, 1.81125149e-01f, 3.99769749e-03f, 1.78365290e-01f, 9.47307497e-02f,
  1.10323103e-02f, 1.05894633e-01f, 1.19915843e-01f, 1.40377924e-01f, -1.30226631e-02f, 4.56912182e-02f, 4.01668660e-02f, 1.92946643e-02f, 1.87298637e-02f, 1.86023220e-01f,
  -7.69801065e-02f, 2.95069903e-01f, 1.01828538e-01f, 2.65155613e-01f, 1.05959766e-01f, 7.43770823e-02f, 2.47989953e-01f, 1.39169365e-01f, 9.24891680e-02f, 2.28543133e-01f,
  1.16572455e-01f, 6.33656308e-02f, 7.92043582e-02f, 1.64864793e-01f, 1.93740770e-01f, 1.53501913e-01f, 2.51527373e-02f, 5.23020923e-02f, -1.27505511e-01f, -3.41779888e-02f,
  1.68353930e-01f, -4.54405770e-02f, 1.01680979e-01f, 2.40970984e-01f, 4.58710156e-02f, -5.74748889e-02f, 1.75286382e-02f, 1.93128318e-01f, -1.77134238e-02f, -8.86808932e-02f,
  9.52173248e-02f, -4.66970615e-02f, 1.63151294e-01f, -1.42118707e-01f, -6.75467923e-02f, 5.67723922e-02f, -4.35653701e-02f, 2.09309950e-01f, 9.30708051e-02f, -5.64876013e-03f,
  -1.69473246e-01f, 7.74869099e-02f, 1.88202649e-01f, -4.79700044e-02f, -5.76676205e-02f, 2.29361743e-01f, -1.09476723e-01f, 1.70863867e-01f, 1.07244812e-01f, -2.46841111e-03f,
  1.13788076e-01f, 8.67680684e-02f, 1.01483755e-01f, -8.98766071e-02f, -5.51570952e-02f, 2.03018099e-01f, -8.75016302e-02f, -1.41109282e-03f, -2.34605912e-02f, -7.56000429e-02f,
  3.59994508e-02f, 4.04131822e-02f, 1.04160644e-02f, -2.55207926e-01f, 1.29782960e-01f, -9.05743428e-03f, -4.69810665e-02f, -5.07287718e-02f, -2.45644450e-01f, 2.07833335e-01f,
  1.73039988e-01f, 1.47161379e-01f, 3.76903340e-02f, 2.03359157e-01f, 5.21500502e-03f, -5.03855087e-02f, 1.34217381e-01f, 1.65848628e-01f, -4.11979407e-02f, 1.26973718e-01f,
  1.83130592e-01f, -1.65382832e-01f, -6.57488257e-02f, 1.43971547e-01f, -3.07451580e-02f, 2.46870108e-02f, -1.12526724e-02f, 1.07354537e-01f, 1.41964024e-02f, -2.48273402e-01f,
  -2.15772931e-02f, -3.88743468e-02f, 1.13864563e-01f, 1.39754549e-01f, 2.19927430e-01f, 2.10844979e-01f, 8.06411952e-02f, 3.68197523e-02f, -6.51229545e-02f, 2.45085791e-01f,
  -1.23165488e-01f, -4.18841839e-02f, 2.39537522e-01f, 1.40990302e-01f, -3.75781432e-02f, -3.97067051e-03f, 2.06560642e-01f, 8.32845271e-02f, 6.93228692e-02f, 1.22608550e-01f,
  -7.48649612e-02f, 1.02229625e-01f, -1.35629103e-01f, 5.17772883e-02f, -1.69457942e-01f, 4.82882410e-02f, 1.24105655e-01f, 5.95849380e-03f, -3.61991003e-02f, 1.63773954e-01f,
  -1.32147387e-01f, -1.24292299e-01f, -1.90988332e-02f, 1.58797190e-01f, 7.93037117e-02f, 7.41372332e-02f, -1.66051593e-02f, 1.35243190e-02f, 1.38342127e-01f, -2.01005921e-01f,
  2.66390949e-01f, -1.04903407e-01f, 2.34728437e-02f, -1.72411941e-03f, -2.13074666e-02f, -4.36647832e-02f, 5.09535298e-02f, 1.20122872e-01f, 1.73807815e-01f, 2.14768454e-01f,
  4.68447208e-02f, -2.89984345e-02f, 6.41260594e-02f, 1.17030993e-01f, -4.25969213e-02f, 1.86633036e-01f, -6.98778555e-02f, -1.21389762e-01f, 4.29402590e-02f, 8.84896666e-02f,
  -4.67816507e-03f, -1.53291285e-01f, -1.37050543e-02f, -1.24020308e-01f, 2.01638699e-01f, 2.96351165e-02f, 1.56042650e-01f, 7.95016885e-02f, -1.17869198e-01f, 2.42710561e-02f,
  -1.12951390e-01f, -7.35211372e-02f, 1.51660413e-01f, -5.66408373e-02f, 1.45972103e-01f, 3.17712612e-02f, -1.88581675e-01f, -8.89704898e-02f, 5.24815656e-02f, -3.18043157e-02f,
  -1.47084182e-03f, 6.08700439e-02f, 4.34092544e-02f, -5.06016836e-02f, 2.48301670e-01f, 1.22682616e-01f, 1.51104271e-01f, -4.88947369e-02f, 2.55607992e-01f, -1.13452844e-01f,
  7.59189576e-02f, -1.54993102e-01f, -9.51861516e-02f, 5.62853105e-02f, -4.62707989e-02f, 1.46813914e-01f, 5.36630116e-02f, 4.21240516e-02f, -2.77805328e-03f, -6.72785714e-02f,
  1.88075099e-02f, 9.23057497e-02f, -1.00310266e-01f, 3.07826936e-01f, 7.19988719e-02f, 2.12621436e-01f, -1.13840498e-01f, 8.63616094e-02f, 1.10730909e-01f, 1.20272234e-01f,
  1.21512063e-01f, 3.91446017e-02f, 7.82870054e-02f, 6.23908490e-02f, 2.59888977e-01f, 2.54299104e-01f, 1.06794752e-01f, 1.63399160e-01f, -1.66206539e-01f, -5.19233644e-02f,
  1.85220778e-01f, 2.24981144e-01f, -2.00411320e-01f, 1.01054244e-01f, -6.33512959e-02f, -1.61565423e-01f, 2.28812367e-01f, -1.13485195e-02f, 1.46932825e-01f, 4.82826643e-02f,
  3.14504653e-02f, 1.62155196e-01f, 1.88483801e-02f, -2.36634258e-02f, 1.57314807e-01f, -1.44523596e-02f, 2.15780362e-02f, -1.39612362e-01f, 4.19326872e-02f, -5.18023893e-02f,
  2.88993735e-02f, 1.31118894e-01f, -4.94797193e-02f, 6.61889324e-03f, 5.58670051e-02f, 1.68428123e-01f, -6.09298004e-03f, -1.36187896e-01f, 1.63622290e-01f, 1.28991216e-01f,
  4.26195972e-02f, -2.06779428e-02f, 8.67783949e-02f, 2.56794542e-01f, 7.52735436e-02f, 6.26289472e-02f, -1.81228966e-02f, -1.54359713e-01f, -1.65189594e-01f, -1.31864101e-02f,
  -2.33542416e-02f, 2.31049299e-01f, 8.60987753e-02f, -5.80063276e-02f, 9.36981738e-02f, 3.48150656e-02f, -1.80634052e-01f, 2.99898535e-01f, 1.13102503e-01f, 1.95488587e-01f,
  -8.37119371e-02f, -9.68191773e-02f, -9.58409384e-02f, -7.83941075e-02f, -8.96631368e-03f, 8.81192163e-02f, -7.80379251e-02f, -1.18883781e-01f, 1.34348750e-01f, 1.94930732e-01f,
  1.59853980e-01f, -5.20191081e-02f, 4.66776490e-02f, 5.67140952e-02f, 1.02707222e-01f, 1.44907743e-01f, -3.86280119e-02f, 1.54864818e-01f, -1.07288919e-01f, -2.54172117e-01f,
  2.11253371e-02f, 6.40195981e-02f, 1.91450030e-01f, 8.78668055e-02f, -5.51047921e-02f, 4.15081307e-02f, -8.52508023e-02f, 6.04942590e-02f, -2.76085079e-01f, 2.52822280e-01f,
  8.60549957e-02f, 1.64994314e-01f, 1.56969145e-01f, 3.56824733e-02f, 1.01188935e-01f, 2.47200623e-01f, 1.26918942e-01f, -2.72462189e-01f, 2.20284965e-02f, -2.15951763e-02f,
  8.13404247e-02f, -8.20735991e-02f, 2.29015186e-01f, 7.88984820e-02f, 7.16459751e-02f, 2.99096078e-01f, 9.36224067e-04f, -3.81423756e-02f, 4.66950014e-02f, 3.46474051e-02f,
  1.82345301e-01f, 1.31137967e-01f, 1.68713070e-02f, 1.32615417e-01f, -7.12174922e-02f, -5.48420753e-03f, -1.79074481e-02f, 1.37303397e-01f, 8.66365135e-02f, 2.08123073e-01f,
  -2.09969684e-01f, 1.58015475e-01f, -2.13104971e-02f, 2.18590662e-01f, 2.96706796e-01f, 1.01704419e-01f, 3.31046351e-04f, 1.62748825e-02f, -5.43973558e-02f, 1.52792513e-01f,
  1.67672813e-01f, 1.32563367e-01f, 1.08118251e-01f, 1.00787051e-01f, 1.28367677e-01f, -2.73164697e-02f, 1.09031297e-01f, 1.89859882e-01f, -1.21101290e-02f, -8.30624029e-02f,
  1.06183834e-01f, -5.88856712e-02f, 8.47378522e-02f, 2.04805955e-01f, -1.28497481e-01f, 6.04391880e-02f, -3.20639461e-02f, 3.05083320e-02f, 9.89314467e-02f, -6.17635995e-02f,
  -6.73159212e-02f, 7.37908110e-02f, -6.39313236e-02f, 4.69406433e-02f, 1.30233020e-01f, 2.00326428e-01f, 1.90650254e-01f, 2.98228022e-02f, 5.58104478e-02f, 1.05148263e-01f,
  2.90632322e-02f, -4.74670716e-02f, -1.29044596e-02f, -1.54372185e-01f, 1.14148580e-01f, 2.31670905e-02f, 4.90952991e-02f, -1.70790672e-01f, 2.19359070e-01f, 1.98293567e-01f,
  1.42475739e-01f, 7.82582983e-02f, -9.52914730e-02f, -7.24155875e-03f, 5.48891239e-02f, 1.01173341e-01f, 5.49124330e-02f, 3.15568477e-01f, 5.45999706e-02f, -1.36975706e-01f,
  2.11807434e-02f, 3.44135016e-02f, -1.02657020e-01f, 1.07384957e-01f, 1.88059360e-01f, -4.72841933e-02f, -2.90478449e-02f, -6.47833422e-02f, 7.12702647e-02f, 1.20852888e-01f,
  2.32594535e-01f, -3.09946891e-02f, 1.01910345e-01f, 3.09700612e-02f, 1.64882354e-02f, -1.37423053e-01f, -1.41717410e-02f, 4.28263731e-02f, 1.30187407e-01f, 3.39052416e-02f,
  -3.76676098e-02f, 1.88987926e-02f, 1.61976576e-01f, 6.93875272e-03f, 4.31773402e-02f, 1.36772349e-01f, -1.71692342e-01f, -1.52999520e-01f, 1.39783900e-02f, -3.57800251e-04f,
  -1.18973508e-01f, 5.39784180e-03f, -3.07103656e-02f, 9.66017544e-02f, 1.79537594e-01f, -1.07901178e-01f, -8.47816318e-02f, 2.16153026e-01f, 1.33495843e-02f, 9.81789976e-02f,
  -1.46756377e-02f, -3.32222097e-02f, 3.93564105e-02f, 5.40535897e-02f, -1.47375435e-01f, -1.23597279e-01f, -2.30781827e-02f, 1.44912839e-01f, -1.40567031e-02f, 1.13145888e-01f,
  2.19872400e-01f, 1.21781997e-01f, 1.04805857e-01f, 1.27716526e-01f, 1.21833421e-01f, 1.52154744e-01f, 6.85883313e-02f, 1.14901036e-01f, 5.34605756e-02f, 4.98537533e-02f,
  1.16527770e-02f, 1.32743746e-01f, 3.52821238e-02f, -9.85447541e-02f, -1.61243062e-02f, -1.13546662e-01f, 7.61530250e-02f, 1.23986844e-02f, 6.75549284e-02f, 4.25420590e-02f,
  1.39395833e-01f, 2.04887778e-01f, 2.21361011e-01f, 1.25469461e-01f, 8.70038494e-02f, 1.44535834e-02f, -1.64518580e-01f, -6.98809475e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  1.02891460e-01f, 2.08837554e-01f, 1.46603778e-01f, 3.44474427e-02f, -1.63960252e-02f, 2.34242558e-01f, 1.06591955e-01f, 6.90049259e-03f, 5.25683053e-02f, 9.12571624e-02f,
  9.79724824e-02f, 8.51142183e-02f, 2.33080342e-01f, -2.72494275e-02f, 2.29328290e-01f, -8.89721736e-02f, 4.68335999e-03f, 1.94044903e-01f, 2.39737436e-01f, 6.05294779e-02f,
  1.48809254e-01f, 8.26563761e-02f, 1.81768730e-01f, 2.25777984e-01f, 5.58786690e-02f, 1.84116319e-01f, 7.31980279e-02f, 4.93116677e-02f, 6.82507269e-03f, -7.52703846e-03f,
  -3.35398577e-02f, 1.65955797e-01f, 1.42247662e-01f, 1.27342880e-01f, 3.58364433e-02f, 1.13324970e-01f, 6.61834329e-02f, -8.98589715e-02f, 1.99630156e-01f, 1.46019623e-01f,
  2.53635347e-01f, 9.53082591e-02f, 1.64299890e-01f, 1.25979617e-01f, 2.36765236e-01f, 8.95909891e-02f, 1.26950815e-01f, 2.02160701e-01f, 2.12362558e-01f, 1.73136696e-01f,
  -4.83735986e-02f, -8.96154195e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  3.68625694e-03f, 6.01045899e-02f, 4.78707962e-02f, 1.32275820e-02f, 1.32996634e-01f, 1.49863079e-01f, -1.58039436e-01f, 2.03260377e-01f, 9.75131243e-02f, 2.46405341e-02f,
  2.15712935e-01f, -5.95140234e-02f, 1.01262331e-01f, -5.52255437e-02f, -1.21121846e-01f, -4.21736129e-02f, -2.03328696e-03f, 1.42218083e-01f, -4.66173925e-02f, -8.15954804e-02f,
  -3.33226994e-02f, -5.35339266e-02f, 1.87190510e-02f, 7.32500106e-02f, 1.70233637e-01f, -8.40290636e-02f, 2.53994018e-03f, -4.53460775e-02f, 9.21683460e-02f, -7.16326088e-02f,
  1.14712849e-01f, -9.92220789e-02f, 4.37948182e-02f, -9.70022976e-02f, -7.04387203e-02f, -5.31159155e-02f, -1.48105785e-01f, 1.10011958e-02f, -1.73896879e-01f, -5.14706112e-02f,
  -1.09088376e-01f, 1.26953155e-01f, -1.68577313e-01f, -3.09899393e-02f, 6.92123845e-02f, 2.82393526e-02f, -2.05079000e-02f, 1.03436168e-02f, -1.16409145e-01f, -1.83619875e-02f,
  -9.70566273e-02f, 4.69799303e-02f, 3.99297737e-02f, -1.36443838e-01f, 1.13484293e-01f, 1.30817115e-01f, 1.31633906e-02f, -4.14882302e-02f, -1.74888119e-01f, 1.33553460e-01f,
  1.45715639e-01f, -4.95169051e-02f, 3.88916247e-02f, 1.67396858e-01f, -7.93966651e-02f, 7.03404248e-02f, 7.54874051e-02f, -1.21070229e-01f, 6.92603365e-02f, 3.61793078e-02f,
  1.46432787e-01f, -8.59416425e-02f, 1.36649936e-01f, 1.95820779e-01f, 7.21086264e-02f, 1.61393821e-01f, 1.61524750e-02f, 5.87574542e-02f, 9.81979966e-02f, 1.37604997e-01f,
  -1.28961578e-01f, 5.06453291e-02f, -1.61143485e-02f, -1.71387225e-01f, 3.88230011e-02f, 6.82016835e-02f, -1.33680418e-01f, 6.33016303e-02f, -4.78601754e-02f, 7.34206513e-02f,
  -1.40861124e-01f, 1.17922120e-01f, -1.38993815e-01f, -1.66713372e-01f, -4.75858003e-02f, 9.18175727e-02f, 1.51262924e-01f, 3.81079838e-02f, 4.97327968e-02f, 7.60015771e-02f,
  -4.18572091e-02f, 1.57028750e-01f, -1.13631956e-01f, 9.50893164e-02f, 1.92514554e-01f, 1.30208015e-01f, -1.30253313e-02f, 2.34600361e-02f, -7.89206550e-02f, 2.05835581e-01f,
  1.65136054e-01f, 9.06769484e-02f, 3.52459494e-03f, 8.69224444e-02f, -1.13238566e-01f, -7.06041083e-02f, -5.70627749e-02f, -1.44042730e-01f, -8.85307342e-02f, 1.03016116e-01f,
  -4.26034704e-02f, 5.64076472e-03f, 5.19369319e-02f, -6.51573166e-02f, -1.33319601e-01f, 9.60608795e-02f, 4.51631397e-02f, 7.26225227e-02f, 6.74046949e-02f, -6.95426092e-02f,
  -1.39223844e-01f, -1.54751018e-01f, -8.54397118e-02f, -1.42988060e-02f, 1.82536572e-01f, 8.73802509e-03f, 6.26211464e-02f, -1.81513671e-02f, -2.22137213e-01f, -1.14240693e-02f,
  -9.06341299e-02f, 6.68908795e-03f, 2.39287868e-01f, -4.44954485e-02f, 9.05497447e-02f, 4.29667346e-02f, 1.64353520e-01f, -2.63103545e-02f, -4.38128002e-02f, -1.11250035e-01f,
  2.43427642e-02f, -1.07259646e-01f, -1.37599140e-01f, -6.19134903e-02f, -2.37350576e-02f, 4.19135252e-03f, 2.37429161e-02f, -1.95404124e-02f, 1.37276230e-02f, 5.71004897e-02f,
  -1.10550158e-01f, 6.35465011e-02f, 1.06324241e-01f, 4.23209779e-02f, 5.31250350e-02f, -7.19197914e-02f, 1.00598529e-01f, 1.81434525e-03f, 8.38860050e-02f, -1.48024205e-02f,
  1.41822323e-02f, 8.30767527e-02f, -3.50652641e-04f, -7.83034638e-02f, 2.58688983e-02f, 5.45024052e-02f, 5.30422432e-03f, 2.17562199e-01f, -6.85681626e-02f, 1.55393660e-01f,
  -6.00903807e-03f, 1.72665372e-01f, 8.70773569e-02f, 2.26375181e-02f, -1.64568126e-01f, -6.10885546e-02f, -6.68400154e-03f, -1.52341217e-01f, -2.82650162e-02f, 1.25545040e-01f,
  9.42142531e-02f, 2.37232521e-02f, -7.54033923e-02f, -6.22726269e-02f, 9.72171724e-02f, 3.91896218e-02f, -4.47204486e-02f, 1.41174230e-03f, -5.62561080e-02f, 1.37860820e-01f,
  -9.86601785e-02f, 1.22792520e-01f, 4.89812680e-02f, 9.17370617e-02f, -1.20256655e-01f, -7.46544600e-02f, -8.63499716e-02f, 1.60478443e-01f, -1.19778447e-01f, -3.95122431e-02f,
  5.84578328e-02f, -9.62898508e-02f, 2.76781637e-02f, 4.49969172e-02f, 1.04347914e-01f, -1.24805316e-01f, -3.82991806e-02f, 5.81399314e-02f, -1.44616619e-01f, -9.01791677e-02f,
  -7.96795636e-02f, 2.64761392e-02f, -1.51342541e-01f, 1.54852316e-01f, 6.43311515e-02f, 1.37314290e-01f, -9.65166166e-02f, 9.45383757e-02f, 1.63234142e-03f, 3.40921544e-02f,
  -1.57773167e-01f, 1.20221049e-01f, 1.70661032e-01f, 9.23767313e-02f, 1.22853346e-01f, 3.72789800e-02f, -7.89354146e-02f, 1.08930208e-01f, 8.94413143e-02f, 1.37416318e-01f,
  -1.53519586e-01f, 9.08832029e-02f, -3.47102843e-02f, -9.80021656e-02f, 9.01937932e-02f, -6.18156940e-02f, 1.06536977e-01f, -2.83595286e-02f, 5.89725003e-02f, 1.20159565e-02f,
  2.33678091e-02f, -6.32769838e-02f, -1.11433744e-01f, -1.42014369e-01f, 6.42228723e-02f, -1.05755784e-01f, -1.19988412e-01f, 3.21201272e-02f, -8.08923021e-02f, -8.69150087e-02f,
  -1.75596215e-02f, 6.92160651e-02f, 1.19209580e-01f, -6.94557698e-03f, 2.84244064e-02f, -1.28620043e-01f, -1.33462071e-01f, 1.99242756e-01f, 7.72488937e-02f, -1.08996928e-01f,
  7.39081278e-02f, -8.82127732e-02f, -7.27730319e-02f, 9.94062051e-03f, -3.20379324e-02f, -1.95412248e-01f, 7.10771186e-03f, -1.08886652e-01f, -1.68733150e-01f, 1.83253497e-01f,
  -1.91632137e-01f, 1.06138252e-01f, 9.43890437e-02f, 9.20420885e-02f, -1.08204102e-02f, -1.15922220e-01f, 9.10445526e-02f, 9.57079008e-02f, -6.21519089e-02f, 7.01976642e-02f,
  -1.25512909e-02f, -4.60392684e-02f, 9.44327414e-02f, -1.20819643e-01f, -4.11714204e-02f, 9.70935300e-02f, 1.07027858e-01f, 7.87484944e-02f, 1.02783106e-01f, 5.43531477e-02f,
  3.55994925e-02f, -1.17436565e-01f, 1.90619770e-02f, -6.03608750e-02f, 1.21823058e-01f, 2.43002370e-01f, 1.08276479e-01f, -1.05420262e-01f, -9.40054730e-02f, 9.21256244e-02f,
  4.74450225e-03f, 7.50766620e-02f, 3.00174076e-02f, 2.65975408e-02f, 4.82661687e-02f, -7.34633729e-02f, -5.21715730e-02f, 1.32740393e-01f, 4.28700298e-02f, 3.89398597e-02f,
  9.56619680e-02f, -2.21520141e-02f, 1.33974301e-02f, -7.52990842e-02f, 1.09835096e-01f, -3.16465721e-02f, 1.56759292e-01f, -6.44648895e-02f, -5.55695221e-02f, 9.12404135e-02f,
  -1.47321194e-01f, 5.54834083e-02f, -7.99840025e-04f, -6.22149445e-02f, -9.49724391e-02f, 2.04199720e-02f, 8.48781667e-04f, -7.16716498e-02f, 8.54060650e-02f, -2.71486565e-02f,
  1.78501368e-01f, -1.40312966e-02f, -1.21539898e-01f, 1.78571880e-01f, -2.46599875e-02f, -5.54242590e-03f, 8.39973390e-02f, 5.99468797e-02f, -2.14231368e-02f, -1.04888514e-01f,
  -6.59545437e-02f, -5.83497062e-02f, -1.77358285e-01f, -3.85413021e-02f, 7.77374953e-02f, -3.38999368e-02f, 9.66990739e-02f, 1.45393535e-01f, -2.27727264e-01f, 1.63315132e-01f,
  8.65720287e-02f, 1.70992479e-01f, -1.37036860e-01f, -9.79592744e-03f, -4.57686931e-03f, -1.51978731e-01f, -6.85967654e-02f, 9.81538221e-02f, 6.55460730e-03f, -1.37025252e-01f,
  7.04566613e-02f, -1.48907498e-01f, 3.58940326e-02f, -1.04252487e-01f, -1.71163604e-01f, 1.76267952e-01f, -6.44810572e-02f, 5.12731560e-02f, 2.40498900e-01f, -1.38165399e-01f,
  6.48924783e-02f, -1.24232145e-02f, -7.48608401e-03f, -5.66371121e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.40462190e-01f, 5.96867539e-02f, -1.14112511e-01f, -3.28019708e-02f, 1.36357129e-01f, 2.63699107e-02f, 1.27660200e-01f, -2.13124707e-01f, -2.50639528e-01f, 2.33285025e-01f,
  -1.66474491e-01f, 3.32684256e-02f, -2.37650752e-01f, 9.32439417e-02f, -3.55790071e-02f, 1.81232020e-02f, 1.02849238e-01f, 8.84559229e-02f, 9.89275724e-02f, 9.93673056e-02f,
  -1.64460503e-02f, 7.68827274e-03f, 1.91629186e-01f, 1.29175633e-01f, -1.04143888e-01f, 1.21973574e-01f, -1.01958208e-01f, -5.76594993e-02f, -6.30450901e-03f, -1.10773742e-01f,
  -1.73489407e-01f, -7.32096434e-02f, 1.48326188e-01f, 5.18928766e-02f, 2.68333524e-01f, 2.20911980e-01f, 2.57764101e-01f, 1.21628314e-01f, 2.72911519e-01f, 1.74394608e-01f,
  1.56746849e-01f, 9.44136307e-02f, 1.14703283e-01f, 1.35921955e-01f, -1.95069775e-01f, -2.80396432e-01f, 2.76930064e-01f, 8.95072967e-02f, -1.04097858e-01f, -3.59210260e-02f,
  3.33591998e-02f, 2.00067312e-01f, 1.75404504e-01f, 1.82354644e-01f, -8.34640041e-02f, -2.20273182e-01f, 5.84129244e-02f, 1.08089224e-01f, 2.76343465e-01f, -9.21894461e-02f,
  -1.95310578e-01f, -2.31857806e-01f, -3.05279478e-04f, -1.87252745e-01f, -6.74172072e-03f, 9.96206924e-02f, 5.56091368e-02f, 1.24480292e-01f, 4.36200723e-02f, -8.96123871e-02f,
  2.54889756e-01f, -2.26695940e-01f, 1.04639642e-01f, -9.25091729e-02f, -2.53492594e-01f, 3.17060538e-02f, 1.81964993e-01f, -3.70028615e-01f, 3.08092564e-01f, 3.01069058e-02f,
  -2.46171989e-02f, -1.51465997e-01f, -1.49662071e-03f, 1.41347915e-01f, -5.04822172e-02f, 4.81385328e-02f, 7.11908340e-02f, 1.79934353e-01f, 1.36820331e-01f, -2.07908284e-02f,
  1.67112112e-01f, 1.72500953e-01f, 2.91177854e-02f, 2.91102827e-02f, -1.69769779e-01f, 5.24468627e-03f, 7.64172375e-02f, 1.83850884e-01f, 4.75453772e-02f, -4.12411615e-02f,
  -2.54407283e-02f, 1.15518291e-02f, 1.16196178e-01f, -1.82453194e-03f, 1.59354389e-01f, -3.66731137e-02f, 1.58596382e-01f, 1.19791359e-01f, 8.29362124e-02f, 9.77430791e-02f,
  5.72230928e-02f, 3.91453644e-03f, 8.85427818e-02f, 8.62039533e-03f, -2.17579156e-01f, 2.29450390e-01f, -2.89501756e-01f, -1.22567959e-01f, 1.34886488e-01f, 1.60341620e-01f,
  -2.07605481e-01f, -1.44689217e-01f, 1.57817259e-01f, -2.96916366e-01f, -1.80666111e-02f, 1.24743834e-01f, 1.40020594e-01f, 3.76029946e-02f, 1.38639018e-01f, 5.55912741e-02f,
  -1.07882515e-01f, 4.57279198e-02f, 1.38017893e-01f, -1.76348567e-01f, -7.70067051e-02f, -1.25582039e-01f, -7.61897489e-02f, -2.23587468e-01f, -1.92546938e-02f, -1.41938716e-01f,
  -1.66859254e-01f, 5.81502244e-02f, -1.89121187e-01f, -1.27671316e-01f, 1.56813592e-01f, -2.58886460e-02f, -2.09629998e-01f, 2.25878119e-01f, 6.16787979e-03f, -2.28532702e-02f,
  5.53904511e-02f, -1.28720120e-01f, -2.07412452e-01f, 4.66389842e-02f, -5.03974631e-02f, -1.39929265e-01f, 1.39008224e-01f, 1.52560905e-01f, 1.54823631e-01f, 5.73415076e-03f,
  -7.47577250e-02f, -1.13432147e-01f, 1.98155999e-01f, -1.65078238e-01f, 9.61388350e-02f, -2.30552092e-01f, 2.08048597e-01f, -6.31218106e-02f, -5.25550172e-02f, -1.50173023e-01f,
  1.31012574e-01f, 1.58678710e-01f, -1.56573057e-01f, 3.61466631e-02f, -8.20236430e-02f, -1.50731981e-01f, 1.36016160e-01f, -1.58713132e-01f, 2.01022670e-01f, 1.54191032e-01f,
  1.30102322e-01f, 1.89218387e-01f, 1.35730937e-01f, 6.78854957e-02f, 1.53682739e-01f, -1.02402620e-01f, -1.14817411e-01f, 1.03573583e-01f, -7.20571801e-02f, 1.41043156e-01f,
  5.40311337e-02f, -6.49482682e-02f, 9.78965461e-02f, 1.79273076e-02f, 2.28693523e-02f, 1.67962268e-01f, 3.76317278e-02f, 2.06175931e-02f, 5.69178201e-02f, -4.73304987e-02f,
  -8.21740851e-02f, -2.78393298e-01f, -1.49917349e-01f, -2.27000058e-01f, 1.43841654e-01f, -1.26603007e-01f, 3.24811965e-01f, 7.10507780e-02f, 1.55853868e-01f, -1.14514664e-01f,
  -2.08735485e-02f, 2.34897122e-01f, 2.34741241e-01f, 6.20325692e-02f, 8.24150071e-02f, 1.45633454e-02f, 1.70025602e-01f, -1.33424476e-01f, 1.53099477e-01f, 2.52346307e-01f,
  6.44184127e-02f, 2.15897843e-01f, 1.68887362e-01f, -2.13158101e-01f, 4.14307229e-02f, -2.29378771e-02f, 2.82768548e-01f, -3.52019295e-02f, -1.74636785e-02f, 1.55169647e-02f,
  4.88513149e-02f, -3.16929584e-03f, -1.69806227e-01f, -1.47531345e-01f, -2.39584986e-02f, 6.16892949e-02f, -7.06817582e-02f, -1.78828254e-01f, -9.86319687e-03f, -1.46736279e-01f,
  1.36972576e-01f, -1.65068373e-01f, -1.94942821e-02f, 8.42769444e-03f, 8.56417418e-02f, 2.02041611e-01f, 1.05100609e-01f, 2.19482109e-01f, -2.51816779e-01f, -8.55973884e-02f,
  1.63508192e-01f, -1.12657808e-01f, -2.49366052e-02f, 3.90273891e-02f, 7.73537112e-03f, -2.60877609e-02f, 1.52316559e-02f, -1.12886339e-01f, 1.18873879e-01f, -1.12631284e-01f,
  -2.88075171e-02f, -9.05573815e-02f, -1.62223473e-01f, 2.78411537e-01f, -8.85126665e-02f, -2.40248397e-01f, 1.11140199e-01f, -7.30408058e-02f, 1.05729342e-01f, -9.08577740e-02f,
  -1.92943141e-01f, -1.11178132e-02f, 1.97331548e-01f, 2.46149600e-02f, -3.12717468e-01f, -8.80572051e-02f, 5.62186800e-02f, -2.27025785e-02f, 6.70899376e-02f, -1.30212352e-01f,
  9.08940285e-02f, 6.46441355e-02f, -2.40982343e-02f, -2.45229118e-02f, 2.98464209e-01f, 2.15262905e-01f, 9.60335657e-02f, -4.61084694e-02f, 5.74191660e-02f, 3.81113961e-02f,
  9.32808593e-03f, 3.27772461e-02f, -8.51640552e-02f, 7.07229748e-02f, -6.33734241e-02f, 4.61850651e-02f, 9.39657241e-02f, -1.86137378e-01f, 1.24193817e-01f, 8.67924839e-02f,
  7.73808407e-03f, 3.42030376e-01f, 1.06852897e-01f, -1.37464345e-01f, -4.33374830e-02f, 9.20473039e-02f, -1.57337859e-01f, 9.52194855e-02f, -6.93190843e-02f, -9.55811981e-03f,
  1.40486747e-01f, 3.31994221e-02f, 4.82412837e-02f, -1.38757929e-01f, -3.02415580e-01f, -4.72130291e-02f, -1.20798260e-01f, 1.64875552e-01f, 1.31157771e-01f, 1.67721480e-01f,
  -3.47419381e-02f, -4.66303295e-03f, 7.47825950e-02f, 2.64782310e-02f, 8.67769718e-02f, 5.91022223e-02f, 1.46112055e-01f, -3.15397471e-01f, 7.07947537e-02f, -2.36393269e-02f,
  -6.91961721e-02f, 2.93344371e-02f, 1.18374407e-01f, 9.27579626e-02f, -9.01011974e-02f, -7.65548199e-02f, 1.25062689e-01f, 5.30932844e-02f, -7.34023303e-02f, -1.26086667e-01f,
  8.96476209e-02f, 2.26057515e-01f, -2.24087071e-02f, 2.23703444e-01f, 1.24234810e-01f, 1.16158657e-01f, 2.30293348e-01f, 2.70381182e-01f, -2.91188601e-02f, -1.47694707e-01f,
  -5.11600189e-02f, -4.60388474e-02f, -2.31506720e-01f, 2.20371366e-01f, -1.75619498e-01f, 1.89499452e-03f, -6.35694191e-02f, 1.23734400e-01f, 4.68227714e-02f, -9.80294310e-03f,
  -4.14969809e-02f, 1.25809267e-01f, -3.14380130e-04f, 1.86174259e-01f, 1.72348082e-01f, 3.28942649e-02f, -5.10602593e-02f, 4.43987995e-02f, 2.06792369e-01f, -2.07028091e-01f,
  1.67942613e-01f, 4.89922129e-02f, -1.09442972e-01f, -1.36008903e-01f, -1.12529531e-01f, 2.67083347e-01f, -9.77367908e-03f, -1.50817364e-01f, 4.74493615e-02f, 2.54830308e-02f,
  2.13924050e-01f, 5.85903414e-02f, -2.53093839e-01f, 1.93456803e-02f, 1.82912409e-01f, -3.64962616e-03f, 1.76827580e-01f, 9.08226296e-02f, 9.51717645e-02f, 8.54545459e-02f,
  -1.56106457e-01f, 1.51661262e-01f, -5.34273311e-02f, 2.38040328e-01f, 1.21833690e-01f, -8.73309150e-02f, 3.60150635e-02f, -7.96766020e-03f, -9.85251833e-03f, 2.06443444e-01f,
  -1.54252440e-01f, 2.33975857e-01f, 2.25777671e-01f, 6.77083107e-03f, -2.37844232e-02f, 4.04730625e-02f, 1.14901803e-01f, -8.18728120e-04f, 5.33684716e-02f, 1.28196821e-01f,
  8.95604212e-03f, -2.30928183e-01f, -2.51807451e-01f, 1.95809007e-02f, 5.29756136e-02f, 1.94748014e-01f, 3.03727359e-01f, 4.05601151e-02f, 1.05002120e-01f, 2.91557968e-01f,
  1.14957944e-01f, 2.59976059e-01f, 3.26289609e-02f, 2.02324390e-01f, 1.17473327e-01f, 2.54768342e-01f, 2.16421366e-01f, -7.10543394e-02f, -5.15354685e-02f, 8.76991749e-02f,
  2.63185978e-01f, 2.47172400e-01f, -5.27309924e-02f, -8.52632523e-02f, 1.57126295e-03f, -9.06450823e-02f, 2.35172331e-01f, -9.01881754e-02f, -1.11264616e-01f, -5.97543083e-03f,
  1.46359168e-02f, 2.83701748e-01f, 8.53753164e-02f, 8.63114446e-02f, 9.55997093e-04f, -2.22094521e-01f, -3.52410488e-02f, -4.87052538e-02f, 1.25952393e-01f, 6.32405579e-02f,
  1.14722170e-01f, -4.90135550e-02f, -2.49366509e-03f, -3.54258879e-03f, -1.11894220e-01f, 2.21048057e-01f, -1.72135130e-01f, -2.49578401e-01f, 9.99158695e-02f, -2.09422663e-01f,
  -1.11829117e-01f, -1.24142379e-01f, 2.62233555e-01f, 1.94427595e-01f, 1.04404278e-01f, 7.21235424e-02f, 1.09094158e-01f, -1.93377569e-01f, 1.74336761e-01f, 2.26400550e-02f,
  1.48098662e-01f, -6.60136119e-02f, 1.22964099e-01f, -8.30789357e-02f, -3.14970165e-02f, -1.95084944e-01f, 1.92060560e-01f, 2.48936340e-01f, 1.35502309e-01f, 1.92790162e-02f,
  7.88848922e-02f, 7.16050640e-02f, 1.98884040e-01f, 1.19658582e-01f, -1.23420052e-01f, 1.04712807e-01f, -2.23266438e-01f, -9.63995606e-02f, -1.24787807e-01f, 1.43892780e-01f,
  -3.31765682e-01f, -4.01905924e-02f, -1.27727389e-01f, -3.46711278e-02f, -1.88295618e-01f, -1.70374751e-01f, 4.09360528e-02f, -1.16989322e-01f, -2.99877256e-01f, -2.40403414e-02f,
  1.94673747e-01f, 1.02756128e-01f, 6.59925267e-02f, 2.35326603e-01f, -5.19774295e-02f, -9.73908901e-02f, -8.05767952e-04f, -5.33926859e-02f, -4.55567427e-02f, 1.10878265e-02f,
  1.15389675e-01f, -9.58417952e-02f, 8.20685998e-02f, -1.03989271e-02f, 6.87348768e-02f, -9.49122850e-03f, -3.51667218e-02f, 9.72784460e-02f, -1.34908259e-01f, 6.41962364e-02f,
  1.38344169e-01f, -2.20356554e-01f, -1.57787725e-02f, 1.01621367e-01f, 9.03381407e-03f, 1.51496604e-01f, -3.12204450e-01f, -2.88770407e-01f, 2.36808121e-01f, 1.25298232e-01f,
  -1.42447263e-01f, 1.52107090e-01f, -2.18925644e-02f, 5.82511276e-02f, -1.54526502e-01f, 8.82245004e-02f, -1.42831936e-01f, 3.51909697e-02f, 1.49011731e-01f, -1.88935339e-01f,
  1.98097855e-01f, 3.72390496e-03f, -1.28609012e-03f, 1.48459807e-01f, -7.06196353e-02f, -5.44211455e-02f, -8.85278508e-02f, 1.73059665e-02f, -5.31002395e-02f, 1.45487627e-02f,
  4.47550975e-02f, -5.67825213e-02f, 1.92671828e-02f, -7.42608234e-02f, -1.83141474e-02f, -4.37160879e-02f, 1.71112686e-01f, 5.19118123e-02f, -1.92335457e-01f, 1.19864745e-02f,
  1.95799306e-01f, -9.24142599e-02f, 2.17179805e-01f, -2.31429245e-02f, -1.80257801e-02f, 1.93453163e-01f, 6.90446943e-02f, -6.09381534e-02f, 1.33153662e-01f, 4.62182090e-02f,
  2.74259746e-02f, 2.41349757e-01f, 1.88879922e-01f, 2.61655390e-01f, 6.69836923e-02f, 3.18012647e-02f, 1.58729315e-01f, 1.14462726e-01f, -4.84853424e-02f, -4.88169417e-02f,
  -4.61686030e-02f, -5.75634688e-02f, 4.48451713e-02f, -6.98815584e-02f, 3.30715105e-02f, 1.82319552e-01f, -1.26561364e-02f, -5.28200567e-02f, -2.74461955e-01f, 1.48514882e-02f,
  -1.53763950e-01f, 1.26028582e-01f, -1.05779748e-02f, 5.74751422e-02f, 5.62758185e-02f, 2.25987941e-01f, -2.16639470e-02f, -2.07776368e-01f, 2.01875314e-01f, 2.56454130e-03f,
  -1.40174180e-01f, 9.45417359e-02f, -2.22835332e-01f, -2.22697984e-02f, 1.52725041e-01f, 1.43787831e-01f, -3.54924686e-02f, 1.80431351e-01f, 1.77347600e-01f, -1.73404459e-02f,
  7.44869635e-02f, 6.86600134e-02f, 2.42030397e-01f, 8.74439850e-02f, 8.54477212e-02f, 1.67968750e-01f, 1.47516459e-01f, -6.50773048e-02f, 2.32355982e-01f, 1.01201706e-01f,
  -2.83004254e-01f, -1.91250015e-02f, 1.16600916e-01f, -8.70436616e-03f, -1.26784220e-01f, 2.44010180e-01f, -5.91552593e-02f, 2.08307490e-01f, 1.64245680e-01f, 2.48459820e-03f,
  1.21886708e-01f, -2.23637938e-01f, 6.65692519e-03f, 2.03035876e-01f, 9.14711431e-02f, -1.06214158e-01f, -1.89146727e-01f, -1.00505941e-01f, 1.41624540e-01f, -1.56958401e-01f,
  1.11593485e-01f, -4.49700095e-02f, 2.16563661e-02f, 1.99328065e-01f, 1.98118374e-01f, 1.03271440e-01f, -1.83962435e-01f, -2.79166047e-02f, -1.77783012e-01f, 5.69892190e-02f,
  2.43968159e-01f, -1.44452855e-01f, 1.21367678e-01f, 2.94150442e-01f, -4.36018556e-02f, -1.92105085e-01f, 2.27395386e-01f, -6.12284355e-02f, 4.52711451e-04f, 1.05038650e-01f,
  1.11159608e-01f, 3.94318961e-02f, 2.63628159e-02f, -8.66718516e-02f, 1.82685420e-01f, 1.37536049e-01f, 1.21706076e-01f, -1.85915753e-01f, 6.02278486e-02f, 1.63207263e-01f,
  9.96813476e-02f, 3.76626924e-02f, 1.06765106e-02f, -4.32824306e-02f, 1.36564791e-01f, 9.09877792e-02f, 9.50313136e-02f, 1.09144002e-01f, 1.83222666e-02f, -7.12550282e-02f,
  -1.83043286e-01f, -9.91671830e-02f, -1.59131333e-01f, -8.53319839e-02f, 9.42449272e-02f, -4.62944731e-02f, -4.80348170e-02f, -7.28647709e-02f, 1.84100196e-02f, -2.54348367e-01f,
  -1.05391610e-02f, -2.29936745e-02f, 1.38640240e-01f, -9.13383067e-02f, 2.60319840e-02f, -2.95622256e-02f, 1.37076467e-01f, 1.87705740e-01f, -1.07803168e-02f, 2.63662249e-01f,
  6.85520843e-02f, 6.57027736e-02f, 4.48608063e-02f, -1.48684392e-02f, 8.26299191e-02f, -1.58212502e-02f, 2.08242666e-02f, -2.73205582e-02f, -4.68500033e-02f, 1.31212726e-01f,
  -1.83571309e-01f, 1.27999201e-01f, 2.30897926e-02f, -3.28605250e-02f, 1.63054168e-01f, -1.12373002e-01f, 1.90838948e-01f, 3.22823495e-01f, -1.25441194e-01f, -7.00274855e-02f,
  6.37231991e-02f, 2.43570954e-01f, -2.81332910e-01f, -2.77810227e-02f, 1.95573539e-01f, 2.77948976e-01f, -3.38275805e-02f, 5.56798428e-02f, 1.36663735e-01f, 8.06593895e-02f,
  1.40988812e-01f, -1.23402551e-01f, 3.19345772e-01f, 2.21357465e-01f, 7.64275193e-02f, -1.34011373e-01f, -6.71646744e-02f, -1.63860917e-01f, 2.72704102e-03f, -8.91214411e-04f,
  -2.50391394e-01f, 1.76016688e-01f, -6.06136546e-02f, -1.66525662e-01f, -1.10240906e-01f, 7.89015293e-02f, -6.97996467e-02f, 4.40512784e-02f, 2.34945983e-01f, 2.15058684e-01f,
  -2.44936958e-01f, -2.00914741e-02f, 1.46179423e-01f, -1.08335435e-01f, 9.64624435e-02f, 4.56198119e-02f, 1.71837300e-01f, 8.19115564e-02f, 5.64120598e-02f, 1.91788450e-01f,
  2.23493323e-01f, -9.05283019e-02f, -5.14847971e-02f, 2.10756794e-01f, 1.99528679e-01f, 1.79304093e-01f, -4.15276773e-02f, 3.00246030e-02f, 3.34747471e-02f, -1.20257609e-01f,
  -4.45289835e-02f, 1.49988592e-01f, -6.22487925e-02f, 2.00867057e-02f, -1.06706563e-02f, 2.33398557e-01f, -8.03276077e-02f, 1.09039485e-01f, 1.53005704e-01f, -1.74538687e-01f,
  1.68553934e-01f, -1.67075038e-01f, -7.26875141e-02f, -1.47867963e-01f, 3.95431593e-02f, 4.07842100e-02f, -2.34899655e-01f, -1.24855004e-01f, -6.57233670e-02f, 1.23275667e-01f,
  1.95695803e-01f, -1.45071140e-02f, 1.91440001e-01f, 2.06638068e-01f, 1.86813816e-01f, -1.39887929e-02f, 1.77801862e-01f, 2.39421472e-01f, -1.68421157e-02f, 1.94761947e-01f,
  9.51445699e-02f, 2.82374740e-01f, 8.48614648e-02f, 1.34902797e-03f, 9.29535255e-02f, 1.32988855e-01f, -1.60233140e-01f, 1.86924383e-01f, 9.49492231e-02f, -3.18525612e-01f,
  1.10085048e-01f, 7.25880265e-02f, 1.65067449e-01f, 1.66957200e-01f, 8.91576856e-02f, -4.74071279e-02f, -2.00804785e-01f, -1.33243548e-02f, -1.34140709e-02f, 7.97543898e-02f,
  -7.71992356e-02f, -2.68559188e-01f, 5.55500053e-02f, -1.49909988e-01f, 1.57964975e-01f, -6.22124746e-02f, -1.57450661e-01f, 1.41378477e-01f, 1.16167322e-01f, 1.33398116e-01f,
  2.67528325e-01f, 1.02026127e-01f, 1.90305665e-01f, 2.11978465e-01f, 1.31319776e-01f, 1.91671908e-01f, 8.32558200e-02f, 2.20976576e-01f, -2.27465540e-01f, 1.83254510e-01f,
  9.98680200e-03f, 7.18245804e-02f, 1.05392091e-01f, 4.61597182e-02f, 1.35599047e-01f, 7.29408413e-02f, 9.13556442e-02f, 3.04298345e-02f, -1.40109047e-01f, 1.26639456e-01f,
  2.34906420e-01f, 5.43157570e-02f, 1.20212503e-01f, 1.56332329e-01f, 1.48168579e-01f, -3.27125490e-02f, 1.44366771e-01f, 2.49244004e-01f, 5.05775586e-02f, -2.51367182e-01f,
  -1.10229969e-01f, -8.82219523e-02f, -4.84233610e-02f, 1.52928561e-01f, 1.48829266e-01f, -1.39996022e-01f, -6.07269332e-02f, 1.36012390e-01f, -3.93816531e-02f, 1.95915118e-01f,
  -9.57294628e-02f, 1.34545445e-01f, -1.20678894e-01f, 2.42398754e-01f, -3.50884683e-02f, -1.17363013e-01f, 1.18883036e-01f, -5.05455323e-02f, 4.98552360e-02f, 2.74112672e-01f,
  -2.34061703e-02f, -2.63196044e-02f, 1.96797505e-01f, 5.64336125e-03f, 1.97079062e-01f, -2.24029105e-02f, 7.64474133e-03f, 7.32379854e-02f, 1.66537106e-01f, 2.70211667e-01f,
  4.23700921e-02f, 1.93320379e-01f, 1.64391354e-01f, -1.67323388e-02f, -1.03750288e-01f, -7.36021921e-02f, 1.25786513e-01f, -2.18166262e-02f, -8.24715123e-02f, 2.78110504e-02f,
  8.17832053e-02f, -7.53885359e-02f, -3.55726108e-02f, -8.35437700e-03f, -3.00804358e-02f, -1.78654730e-01f, -1.86999053e-01f, -1.40632749e-01f, 1.25064626e-01f, -1.29820593e-02f,
  6.40747249e-02f, -4.44876403e-02f, 1.46351650e-01f, -1.51046783e-01f, -1.12238489e-01f, 2.84315199e-01f, 8.59919563e-02f, -1.31331339e-01f, 2.23327875e-02f, -8.52806494e-02f,
  -1.45988479e-01f, -2.01168172e-02f, 1.93690643e-01f, 1.77668825e-01f, 8.31117406e-02f, 1.21362895e-01f, -3.59873548e-02f, -4.29069065e-02f, -9.59172323e-02f, 6.62927851e-02f,
  2.20819250e-01f, -1.35071129e-01f, 7.50346715e-03f, 1.09556261e-02f, 6.22739904e-02f, -1.59212291e-01f, -1.21144533e-01f, -2.55936950e-01f, 8.10147002e-02f, 7.13279843e-02f,
  -4.94205905e-03f, 1.78149547e-02f, 5.23639396e-02f, -1.09346852e-01f, 1.06401287e-01f, -2.61344492e-01f, 9.32387188e-02f, 8.53056386e-02f, -5.18923141e-02f, 2.23118812e-01f,
  1.89060569e-01f, -1.60563719e-02f, 5.91932721e-02f, 8.24033655e-03f, 9.29800272e-02f, 5.14335670e-02f, 6.04249388e-02f, 9.43747461e-02f, 2.12366000e-01f, -4.76004779e-02f,
  6.96068034e-02f, 1.07665338e-01f, 2.22547818e-02f, 1.50441796e-01f, -4.11026813e-02f, 2.79518515e-02f, 7.30504543e-02f, -2.93534487e-01f, -9.28987190e-02f, 1.18637994e-01f,
  -2.33034551e-01f, 4.61346097e-03f, 1.53553888e-01f, -2.28430182e-02f, 7.15154335e-02f, -4.52040024e-02f, -3.56297195e-02f, 1.00609109e-01f, -1.41055614e-01f, 3.00123934e-02f,
  1.55200690e-01f, 8.92937034e-02f, -9.35544595e-02f, 2.84899175e-01f, -8.63817409e-02f, 3.48138735e-02f, 1.35918453e-01f, 2.12978259e-01f, -9.40331966e-02f, -6.48495108e-02f,
  3.42734084e-02f, -5.18683381e-02f, -2.00083286e-01f, 2.15561271e-01f, -8.92863348e-02f, 3.20675857e-02f, -7.64273331e-02f, -6.53139316e-03f, 6.00152370e-03f, -5.81055097e-02f,
  2.33223096e-01f, 1.34113982e-01f, 1.09512493e-01f, 9.71848294e-02f, 1.69845626e-01f, 6.44422695e-02f, 9.13635939e-02f, -1.58800095e-01f, 8.88608173e-02f, -4.39998768e-02f,
  1.68945700e-01f, 1.42675918e-02f, -7.03783557e-02f, -7.53313676e-02f, -1.21476077e-01f, 2.31503025e-01f, 8.01769495e-02f, -1.21441014e-01f, 2.37362981e-02f, -3.36443707e-02f,
  1.97974145e-01f, 3.00171345e-01f, -3.41820754e-02f, 1.07364088e-01f, 9.22734365e-02f, -1.16782151e-01f, 2.17539705e-02f, -1.51746180e-02f, 6.80148154e-02f, -1.18022770e-01f,
  1.38060853e-01f, -2.71655619e-01f, -5.00838086e-02f, 2.18455195e-01f, -2.37962171e-01f, 2.25662246e-01f, 2.20799789e-01f, 1.47382408e-01f, -1.88818097e-01f, 2.27450430e-01f,
  -1.87457744e-02f, 9.46940482e-02f, 1.54014498e-01f, -1.24675348e-01f, 6.88881055e-02f, 2.09495977e-01f, -5.95715865e-02f, 3.31775218e-01f, -4.57765758e-02f, 1.29504412e-01f,
  1.53599590e-01f, 2.05636248e-01f, -1.78133085e-01f, -1.37140825e-01f, -1.47770405e-01f, 1.20669566e-01f, -3.41287628e-02f, 1.73182368e-01f, -1.25008849e-02f, 1.59467414e-01f,
  2.18868971e-01f, 8.55700821e-02f, 1.31808817e-01f, 2.90489215e-02f, 2.82877803e-01f, 1.37974799e-01f, 2.75188833e-01f, 2.62477040e-01f, 5.53923659e-02f, 1.53953940e-01f,
  2.04035312e-01f, 8.50945264e-02f, 7.58713782e-02f, 1.52429745e-01f, 1.47931069e-01f, 1.01380087e-01f, 1.25331879e-01f, -3.71183194e-02f, 1.15774430e-01f, -3.41760851e-02f,
  1.53447092e-02f, 1.11514986e-01f, 8.83932188e-02f, 5.97140864e-02f, -6.02273010e-02f, 2.44898468e-01f, 1.06865779e-01f, 2.18793690e-01f, 8.05018917e-02f, 8.89018178e-02f,
  -1.53748086e-03f, 7.44322687e-02f, 4.35383990e-02f, -3.01395990e-02f, -2.23006811e-02f, -1.74482316e-01f, -1.45056814e-01f, -1.80789735e-02f, 5.97581789e-02f, -3.80132757e-02f,
  -1.46410435e-01f, -1.06511109e-01f, -7.30941221e-02f, 1.26259223e-01f, -9.63153839e-02f, 4.65391204e-03f, 1.56844363e-01f, -3.37906033e-02f, 1.13977171e-01f, -5.49053885e-02f,
  -4.00846526e-02f, 2.42997080e-01f, -1.32771090e-01f, 9.65800509e-02f, -1.00307249e-01f, 3.46380174e-02f, 1.37939841e-01f, 1.30400360e-01f, -1.76171791e-02f, 5.19848540e-02f,
  1.59780264e-01f, 1.24069721e-01f, 7.11871982e-02f, 1.29481897e-01f, 1.67868018e-01f, 2.99140811e-03f, 2.13217914e-01f, 6.03832714e-02f, 2.68215179e-01f, 1.04138486e-01f,
  1.54582992e-01f, 7.17956945e-02f, -2.07473382e-01f, 1.71436295e-01f, 1.00622140e-01f, 1.65570155e-01f, -1.30927982e-02f, 1.20706625e-01f, -1.73892826e-01f, 9.26930904e-02f,
  5.09898849e-02f, -9.19936150e-02f, 7.04693049e-02f, -1.89492246e-03f, -1.13839377e-02f, 9.72682089e-02f, 5.40643465e-03f, -1.46010891e-01f, -7.49850497e-02f, 1.15153164e-01f,
  1.03329509e-01f, -4.27011698e-02f, 1.15227200e-01f, 1.00747123e-01f, 1.39810354e-01f, 1.62481144e-01f, 1.68423340e-01f, 3.29286158e-01f, -1.48241892e-01f, 7.57523924e-02f,
  -1.26987025e-01f, -1.26124816e-02f, 2.59866640e-02f, 5.27107194e-02f, -4.59519178e-02f, 1.36506960e-01f, 9.10482407e-02f, 1.79858923e-01f, 2.36778874e-02f, 1.95263147e-01f,
  2.14500293e-01f, 1.05784796e-01f, 6.09753188e-03f, -9.68187489e-03f, 1.48811325e-01f, -1.19406097e-01f, 1.00919150e-01f, 1.28609613e-01f, -3.20480876e-02f, -1.48831055e-01f,
  -2.15333119e-01f, 7.70074725e-02f, 2.62083054e-01f, 1.08767428e-01f, 2.44285077e-01f, -2.42551741e-05f, 5.81856966e-02f, 2.48386919e-01f, 8.75474066e-02f, 2.28279948e-01f,
  -1.10698780e-02f, 1.72002852e-01f, -1.81292817e-01f, 2.15454146e-01f, 4.87047359e-02f, -1.44621044e-01f, -4.37023714e-02f, -2.20747665e-01f, -1.35311618e-01f, 1.38170933e-02f,
  7.47026950e-02f, -1.41035661e-01f, 2.16233045e-01f, 5.77000938e-02f, 1.62475869e-01f, 7.65372440e-02f, -1.54928416e-01f, 7.01216375e-03f, 1.31492272e-01f, 2.74282128e-01f,
  -2.71109529e-02f, 1.02685332e-01f, 1.81899980e-01f, -2.54057765e-01f, -1.32059604e-01f, -1.21992648e-01f, -4.57711145e-02f, -9.71019492e-02f, 7.47219622e-02f, -5.31622767e-02f,
  -5.91792911e-02f, -8.77321512e-02f, 1.95158765e-01f, -7.52909631e-02f, 1.08335447e-02f, 2.55593717e-01f, -1.36242405e-01f, 1.01677261e-01f, 1.77738488e-01f, -7.76919490e-03f,
  -1.06038004e-01f, 1.47539213e-01f, -2.24046752e-01f, -4.07793671e-02f, -1.16223700e-01f, -8.25531185e-02f, 4.56787236e-02f, 1.32682577e-01f, 1.28329888e-01f, 2.44652972e-01f,
  -8.71601179e-02f, 2.71287680e-01f, 1.13697685e-01f, 2.78672725e-01f, -1.12607956e-01f, 8.63968860e-03f, -1.77400157e-01f, 1.12171933e-01f, 8.17471370e-02f, 2.48725250e-01f,
  5.33076003e-02f, 8.26004967e-02f, 1.38665959e-01f, 7.27691576e-02f, -4.61508669e-02f, 1.48292080e-01f, 2.73662508e-01f, 4.24072705e-03f, 2.02814400e-01f, 2.30427518e-01f,
  1.99309930e-01f, 1.13366857e-01f, 2.67101914e-01f, 2.21895315e-02f, 1.50863364e-01f, 2.22131953e-01f, -1.24328114e-01f, 2.75338581e-03f, 9.79824662e-02f, -1.50638625e-01f,
  -5.68788052e-02f, -1.03697525e-02f, 2.14434937e-01f, 1.83439329e-01f, 2.26026058e-01f, -3.15965451e-02f, 7.39274025e-02f, 2.33660594e-01f, 1.30098611e-01f, 2.48483539e-01f,
  9.15808976e-02f, 7.51269758e-02f, 2.48032175e-02f, 1.66916788e-01f, 1.24378033e-01f, -1.75105017e-02f, -1.10722840e-01f, 1.90919265e-01f, -5.66016994e-02f, 6.53497502e-02f,
  2.56478608e-01f, -1.14141785e-01f, 5.79059422e-02f, -1.09849483e-01f, 1.81220623e-03f, 2.26215962e-02f, 7.57027119e-02f, 1.67624682e-01f, -1.66113913e-01f, 1.57956928e-01f,
  -1.16198517e-01f, 9.28835049e-02f, 2.28982627e-01f, -2.54777402e-01f, 5.76629192e-02f, 1.86575241e-02f, -1.40227720e-01f, -7.81257376e-02f, 3.67659405e-02f, 1.52298629e-01f,
  -3.89652401e-02f, 2.06114188e-01f, 1.75028563e-01f, 1.84274837e-01f, 2.14002021e-02f, 7.21408725e-02f, 1.13569438e-01f, -4.77484390e-02f, 1.83545332e-02f, 1.28368065e-01f,
  2.00385645e-01f, -1.91327274e-01f, 9.35786739e-02f, 8.23809430e-02f, -4.89270175e-03f, 2.00386092e-01f, 1.88848183e-01f, 9.69298556e-02f, -2.46443927e-01f, 8.64056572e-02f,
  -6.53299093e-02f, 4.22926843e-02f, -1.22414701e-01f, -8.45226943e-02f, -2.52317954e-02f, -1.77494571e-01f, 3.80573198e-02f, 1.28677309e-01f, -2.02178329e-01f, 1.27100393e-01f,
  -8.72004405e-03f, 1.36277482e-01f, 1.45098686e-01f, 2.04666816e-02f, 9.97424573e-02f, -3.41680972e-03f, 4.80932966e-02f, -4.15829243e-03f, -3.37926252e-03f, 1.18135333e-01f,
  -1.32190257e-01f, 1.74085312e-02f, -5.02429903e-02f, -4.01551127e-02f, -1.66957334e-01f, -4.22141105e-02f, -6.16280884e-02f, 4.88192402e-02f, 8.20216015e-02f, -1.20256037e-01f,
  1.65805221e-01f, 1.55232042e-01f, 2.62070745e-02f, 4.65269461e-02f, 2.48766810e-01f, -2.58096140e-02f, -5.68937920e-02f, 1.96160242e-01f, 1.03298955e-01f, -1.67718217e-01f,
  3.42652090e-02f, -2.00358599e-01f, 1.27807409e-01f, 9.97623727e-02f, 1.45259932e-01f, -1.66423589e-01f, -6.56138435e-02f, -8.33098814e-02f, 5.19739725e-02f, -1.38175383e-01f,
  -1.57011807e-01f, -5.20630851e-02f, 8.19986835e-02f, -1.27697131e-02f, 9.72165242e-02f, 4.46766131e-02f, 1.44951522e-01f, 1.85682371e-01f, -5.51455058e-02f, -2.27870960e-02f,
  -2.83084009e-02f, -7.62204453e-02f, 3.38712752e-01f, 7.08659440e-02f, 2.15200797e-01f, 4.15335223e-02f, 1.99195057e-01f, 2.85047889e-01f, 1.56064585e-01f, 1.11164697e-01f,
  -1.69062298e-02f, 3.72068323e-02f, 1.34415120e-01f, 8.13341960e-02f, 9.67411995e-02f, 2.34816581e-01f, 8.43447149e-02f, -6.76760226e-02f, 1.47345483e-01f, 1.36257157e-01f,
  7.45552704e-02f, 1.97234288e-01f, 1.24625064e-01f, 9.33286995e-02f, -1.37685612e-01f, 1.76576883e-01f, -1.63961157e-01f, -6.90112412e-02f, 2.09781937e-02f, -1.95126832e-01f,
  -1.87874943e-01f, -1.46503940e-01f, 6.37992322e-02f, 1.98597431e-01f, -1.05368443e-01f, 1.36022747e-01f, 2.22070143e-01f, -9.92704332e-02f, 1.32518187e-01f, -4.22320403e-02f,
  1.23122148e-01f, -3.16856056e-02f, 1.44006178e-01f, 9.10225660e-02f, -2.60000322e-02f, -1.09731011e-01f, -9.71737653e-02f, 4.91595194e-02f, 2.03582212e-01f, 1.67743474e-01f,
  2.22218066e-01f, 2.32630540e-02f, 1.93059444e-01f, 1.86936915e-01f, 7.63280317e-02f, -8.03682115e-03f, -5.77857979e-02f, 1.39400616e-01f, 1.95757940e-01f, 1.60865039e-02f,
  -4.00134996e-02f, 1.22833744e-01f, -1.37139037e-01f, -1.06266990e-01f, 2.27583840e-01f, -1.21864907e-01f, -9.15089473e-02f, -2.94512957e-02f, -7.00530261e-02f, -1.62101369e-02f,
  -9.17351246e-03f, -8.85823444e-02f, 1.68332100e-01f, 1.02232084e-01f, 1.12898555e-02f, 1.07720986e-01f, 5.08108735e-02f, -9.14819911e-02f, -6.07762709e-02f, -1.01323776e-01f,
  5.26075345e-03f, 1.10376671e-01f, -5.77955246e-02f, 1.56633258e-01f, 6.53360318e-03f, 4.46605831e-02f, 2.21105106e-02f, 5.30536212e-02f, -1.94824010e-01f, 9.96899009e-02f,
  1.05193369e-02f, -2.00227410e-01f, 1.08074516e-01f, -2.02045575e-01f, 1.75915480e-01f, 1.83530152e-01f, -2.40253434e-01f, -2.44035840e-01f, 2.35983148e-01f, 1.07988827e-01f,
  -2.56978512e-01f, 1.51077643e-01f, -1.37529850e-01f, 6.26872852e-02f, 1.11272834e-01f, 4.39820699e-02f, -2.70944554e-02f, 1.81951642e-01f, 1.36785239e-01f, -2.03040373e-02f,
  1.38206303e-01f, 1.85095996e-01f, 8.54341537e-02f, 1.11228690e-01f, 2.22047374e-01f, 1.52199224e-01f, 5.94385043e-02f, 4.76744138e-02f, -3.10950615e-02f, -8.21092799e-02f,
  1.66701928e-01f, 4.92675118e-02f, 1.05584040e-01f, -2.48487964e-01f, 1.43481821e-01f, 1.54413581e-01f, 8.81530270e-02f, 1.67360440e-01f, 2.05507830e-01f, -1.52189285e-01f,
  -2.99731735e-02f, -1.45320281e-01f, 2.02050671e-01f, 3.00521795e-02f, -4.47333343e-02f, -1.47002369e-01f, -4.00176831e-02f, -1.51461795e-01f, 2.69748539e-01f, -2.82710940e-02f,
  -1.81261063e-01f, 2.61160880e-01f, 1.05994396e-01f, 2.49037087e-01f, 2.27783099e-01f, -1.06457062e-02f, 1.29435137e-01f, -2.22864896e-02f, 1.82235479e-01f, 7.48263532e-03f,
  -6.94229230e-02f, 8.71017724e-02f, 4.68635075e-02f, -9.78852883e-02f, 5.38397320e-02f, -1.06585538e-03f, -2.23234534e-01f, 1.26453519e-01f, 6.83202818e-02f, -1.04721628e-01f,
  -6.76167533e-02f, 1.63210824e-01f, -7.88967162e-02f, 1.20453008e-01f, -2.50427052e-02f, -1.76422745e-01f, 1.06614724e-01f, -2.07172576e-02f, -5.41202314e-02f, 5.49496599e-02f,
  2.91898865e-02f, -3.05186808e-02f, 2.28285730e-01f, 7.37876743e-02f, -1.89678684e-01f, 3.72116752e-02f, -1.14261962e-01f, -1.19899340e-01f, -1.42469138e-01f, 1.65097073e-01f,
  -5.54165207e-02f, 1.29479200e-01f, 7.47736841e-02f, 1.82621226e-01f, -2.05177069e-01f, -9.15896893e-02f, 1.36258498e-01f, 2.79499106e-02f, -8.41214415e-03f, 5.90865985e-02f,
  1.82698414e-01f, -9.45262238e-02f, -2.12791532e-01f, 3.67828384e-02f, 3.30688432e-02f, -1.16419867e-01f, -5.75266443e-02f, 3.02503351e-02f, 2.87899957e-03f, -1.48957789e-01f,
  -9.99869853e-02f, 1.53790995e-01f, -1.47371516e-01f, -1.61735490e-01f, 5.60941808e-02f, -1.76438704e-01f, 1.63479924e-01f, -1.14588765e-03f, -1.47561744e-01f, 1.74970433e-01f,
  1.75038546e-01f, 1.43933967e-01f, 9.53920633e-02f, 4.75482531e-02f, 1.35678515e-01f, 7.84069449e-02f, -2.01381221e-01f, 2.14428812e-01f, -1.93739906e-01f, -2.81130195e-01f,
  9.92957130e-02f, -1.54402763e-01f, -1.14136487e-02f, 2.52857447e-01f, -7.64600560e-02f, 6.96636215e-02f, 6.30660057e-02f, 1.50764361e-01f, -1.62559330e-01f, -6.42878711e-02f,
  2.10156396e-01f, -1.36446476e-01f, 7.11783813e-03f, 5.89808784e-02f, 1.19374074e-01f, -1.41162649e-02f, 9.95690078e-02f, -6.99476972e-02f, 2.23626524e-01f, 2.76672244e-01f,
  2.81824201e-01f, -1.00920051e-02f, -1.10170558e-01f, -1.18633889e-01f, 3.16111408e-02f, -1.41357973e-01f, -8.88907760e-02f, 5.43370321e-02f, -1.81881767e-02f, -1.77410945e-01f,
  -1.04043081e-01f, -3.08284108e-02f, -1.06423348e-01f, 1.50793558e-02f, -5.69767281e-02f, 9.83425975e-02f, 2.43563037e-02f, -1.66591242e-01f, 1.51200518e-01f, -2.58632511e-01f,
  1.71962216e-01f, 1.09310314e-01f, 1.39172047e-01f, -1.04200114e-02f, 1.75552100e-01f, 5.01260832e-02f, 5.35503440e-02f, 8.35874081e-02f, -1.83148846e-01f, 1.39861643e-01f,
  1.28584906e-01f, 3.50260884e-02f, -3.13307606e-02f, -1.78646266e-01f, -7.45454431e-03f, -5.75675890e-02f, 1.79471802e-02f, 8.90998989e-02f, -1.09350674e-01f, 2.12972715e-01f,
  2.16242537e-01f, -1.93017736e-01f, 3.81294414e-02f, 4.31572646e-02f, -2.84132540e-01f, -1.10996127e-01f, -1.86859481e-02f, -3.71445864e-01f, 2.73628086e-01f, 1.21974081e-01f,
  -3.94053981e-02f, -2.23794058e-01f, -1.02177985e-01f, -2.54086405e-02f, 5.54796048e-02f, 6.43162504e-02f, 3.47214267e-02f, 8.94587487e-02f, -8.39585997e-03f, 3.94614749e-02f,
  4.02854122e-02f, 2.48202071e-01f, -4.66224179e-02f, -7.85695091e-02f, -2.33655646e-01f, -5.61621375e-02f, -1.27516896e-01f, 2.02463239e-01f, 4.36868779e-02f, 1.83930006e-02f,
  -1.32076489e-02f, 8.22119787e-02f, -6.21959902e-02f, -1.40465900e-01f, 1.24082915e-01f, 1.49565618e-02f, -1.33466437e-01f, 9.80189666e-02f, 1.52550891e-01f, -1.20511420e-01f,
  -5.92505485e-02f, -6.49496242e-02f, 1.45574927e-01f, -2.06666812e-01f, -1.60618633e-01f, -1.31610408e-01f, -9.46273059e-02f, 8.19059163e-02f, -1.70112133e-01f, 7.52377659e-02f,
  -2.88846612e-01f, -2.41352409e-01f, 2.62396157e-01f, -2.12756857e-01f, -3.71012017e-02f, 2.75462270e-01f, 2.66294610e-02f, 6.98822066e-02f, 2.22039521e-01f, 6.03905432e-02f,
  6.70951083e-02f, 1.10269301e-02f, 1.47306010e-01f, 1.15696318e-01f, -2.14747027e-01f, 2.67605245e-01f, 2.94735022e-02f, -8.89158025e-02f, 2.80885339e-01f, -1.00360386e-01f,
  3.48470435e-02f, 1.24312472e-02f, 2.02036068e-01f, 1.56186044e-01f, 1.70671850e-01f, -5.64019531e-02f, -2.65073706e-03f, -3.67353894e-02f, -2.97791138e-02f, -1.47728264e-01f,
  1.42917410e-01f, -1.21029258e-01f, 2.32041344e-01f, -7.41278082e-02f, -1.45746619e-01f, -5.75882383e-02f, 1.62899464e-01f, 3.96456271e-02f, 7.06877708e-02f, 1.61973745e-01f,
  1.82915553e-01f, 6.77658767e-02f, 1.92674816e-01f, 1.35640651e-01f, 2.64715254e-02f, -1.50682023e-02f, 9.11040902e-02f, 1.54778257e-01f, 3.17808464e-02f, 9.86088365e-02f,
  1.60531029e-01f, 1.39006808e-01f, -3.01565342e-02f, 1.20004676e-01f, 4.71747629e-02f, -2.98182461e-02f, -5.84196672e-03f, -1.66391492e-01f, -1.42182693e-01f, 5.66426702e-02f,
  1.92483366e-01f, -8.36553425e-03f, 2.24652916e-01f, -4.16675732e-02f, -2.63305753e-02f, 1.85088009e-01f, 4.45770174e-02f, 5.26030138e-02f, 2.14624573e-02f, 1.97985340e-02f,
  1.72410339e-01f, -4.10309248e-02f, 1.13629341e-01f, 5.03228530e-02f, 5.29294927e-03f, 6.58745691e-02f, 2.13741027e-02f, 5.81165329e-02f, -1.06207207e-01f, 1.62249014e-01f,
  7.00879842e-02f, -1.93833679e-01f, 8.76864269e-02f, -1.47047207e-01f, 1.68919757e-01f, 1.62090868e-01f, -3.25836837e-01f, -8.36320743e-02f, 4.46788501e-03f, 1.58417091e-01f,
  -1.84887260e-01f, 1.11788109e-01f, 9.27063227e-02f, 1.79754302e-01f, 1.22375607e-01f, -7.37065151e-02f, -7.58761466e-02f, 1.05067223e-01f, 1.90889612e-01f, 6.78305030e-02f,
  1.49482414e-01f, 1.49716154e-01f, 3.17452438e-02f, -2.99676247e-02f, -2.31777262e-02f, 3.58881019e-02f, 1.15030691e-01f, -1.62574366e-01f, 8.35739728e-03f, -2.92861313e-02f,
  8.32021385e-02f, -1.39727473e-01f, -6.62943870e-02f, -1.49504155e-01f, -1.15986772e-01f, 1.51138991e-01f, 2.06358716e-01f, 7.77394325e-02f, -1.51339218e-01f, 5.41835241e-02f,
  5.65083958e-02f, 3.83199975e-02f, 2.27250442e-01f, 7.83210546e-02f, -6.51941076e-02f, 5.13473079e-02f, -5.18501140e-02f, 5.28923236e-02f, 2.36367211e-01f, -1.26508683e-01f,
  5.06773312e-03f, 1.66334346e-01f, 1.14521034e-01f, 2.37842783e-01f, 8.08184743e-02f, 1.30440369e-01f, 1.38658971e-01f, -5.25431857e-02f, 1.57934725e-01f, 1.05746783e-01f,
  -7.59782046e-02f, 1.65087432e-01f, 5.17145917e-02f, 3.14588705e-03f, -1.27376512e-01f, 2.98064426e-02f, -2.39253715e-02f, -1.95392847e-01f, 2.61258781e-01f, -1.54208913e-01f,
  1.45012990e-01f, 7.99746290e-02f, 1.10613108e-01f, 1.44038036e-01f, -2.31961738e-02f, 1.16594136e-02f, 1.94836363e-01f, 1.68924093e-01f, 1.81289837e-01f, 1.16917126e-01f,
  2.03245804e-01f, -7.49448836e-02f, 8.86090472e-02f, 1.46369398e-01f, -7.26621896e-02f, 1.37854386e-02f, -9.75188836e-02f, 1.66657604e-02f, 1.86123550e-01f, 2.12983206e-01f,
  -4.22073565e-02f, 4.67090867e-02f, 1.31919786e-01f, 1.77095875e-01f, -6.94323629e-02f, -1.13232717e-01f, -3.87047492e-02f, 4.88912538e-02f, -1.82728395e-01f, -8.06656107e-02f,
  2.09037140e-01f, -5.53596951e-02f, -1.14165641e-01f, -1.01151586e-01f, -7.10518053e-03f, -3.54458183e-01f, -1.49450973e-01f, 1.44169619e-02f, 4.65088524e-02f, -1.92221686e-01f,
  4.19463366e-02f, 1.09999940e-01f, 1.51101463e-02f, -1.42109826e-01f, 6.47297204e-02f, 2.26804148e-02f, 1.62573680e-01f, 1.53756961e-02f, 6.80306777e-02f, 2.64233172e-01f,
  2.31931314e-01f, 1.38820454e-01f, 1.41148567e-01f, 1.50832742e-01f, -1.00938240e-02f, 2.45093733e-01f, 8.77822936e-02f, -2.72827834e-01f, 2.75877975e-02f, -1.64852552e-02f,
  -8.41824412e-02f, 1.75871551e-01f, 4.20105495e-02f, 9.39920768e-02f, 8.13900232e-02f, 1.41341791e-01f, -1.41865075e-01f, 1.24593951e-01f, 1.12840116e-01f, -1.15199760e-01f,
  9.14922133e-02f, 5.23155630e-02f, 1.83359475e-03f, 1.77269906e-01f, 4.41094004e-02f, -3.39448974e-02f, 1.87061712e-01f, -3.78113389e-02f, -1.20182686e-01f, -1.85930391e-03f,
  1.37681410e-01f, -4.64949086e-02f, 6.98765665e-02f, 1.15441866e-01f, 8.55363682e-02f, 6.59917342e-03f, -1.12245016e-01f, 7.39273429e-02f, -1.09893836e-01f, -1.21087350e-01f,
  -1.50082171e-01f, 6.56854957e-02f, -1.15870193e-01f, 1.52076790e-02f, -1.62471589e-02f, -1.57579139e-01f, -2.05098651e-02f, 9.26918238e-02f, 1.20832533e-01f, -2.85541326e-01f,
  1.68572158e-01f, 6.01957813e-02f, 6.92138309e-03f, -8.23213533e-03f, -1.25915617e-01f, 1.79606169e-01f, -3.68956961e-02f, 8.00504982e-02f, 1.00121170e-01f, 7.66658783e-02f,
  2.83725739e-01f, 6.21525086e-02f, -1.56335309e-01f, -2.55224202e-02f, -4.69302610e-02f, 1.57310471e-01f, 7.34897628e-02f, 1.45044163e-01f, 1.40227526e-01f, 5.74687161e-02f,
  -2.09197387e-01f, 3.90909612e-01f, -6.17640801e-02f, -1.12988524e-01f, 2.62378931e-01f, -1.81903034e-01f, 6.11081459e-02f, -1.32067025e-01f, 1.61802962e-01f, 9.42815691e-02f,
  -1.54669032e-01f, 9.66531411e-03f, 1.50992170e-01f, 3.65920998e-02f, 7.05020726e-02f, 1.66483775e-01f, 3.71695384e-02f, -3.07314038e-01f, 2.17232108e-01f, 1.33442014e-01f,
  -1.51851671e-02f, -1.94781229e-01f, 1.27160087e-01f, 1.04428232e-01f, 1.58324957e-01f, 8.65622796e-03f, 2.84083396e-01f, 1.35958984e-01f, -7.63858035e-02f, 6.44751713e-02f,
  -5.17826229e-02f, 2.57161558e-01f, -2.82036841e-01f, 1.25036672e-01f, -1.54972509e-01f, -8.14259797e-02f, -1.18045099e-01f, -1.62864149e-01f, 1.34298638e-01f, -8.90275091e-02f,
  -2.12303605e-02f, 1.16561592e-01f, -2.72323698e-01f, -2.24500418e-01f, -3.29903746e-03f, -1.96196467e-01f, 1.75815113e-02f, -1.32753596e-01f, 1.58311367e-01f, 2.23159138e-02f,
  1.61292870e-02f, 1.51557311e-01f, -1.36836082e-01f, 1.92614675e-01f, -1.44944275e-02f, -2.38513704e-02f, 4.66135852e-02f, -9.84070823e-03f, 6.65610358e-02f, 5.77567220e-02f,
  -3.94507833e-02f, 1.31983653e-01f, 2.27952272e-01f, 3.19096968e-02f, -1.07123919e-01f, -3.48911993e-02f, -1.43603548e-01f, -2.33929217e-01f, 6.47197962e-02f, -1.96562648e-01f,
  -1.15348317e-01f, 2.31049836e-01f, 1.53602093e-01f, -9.38135609e-02f, 1.29859045e-01f, 2.02186480e-02f, -5.38312867e-02f, 1.83818787e-01f, 6.57029403e-03f, -1.50715977e-01f,
  1.62617102e-01f, -9.05061662e-02f, 7.26907551e-02f, -1.18531153e-01f, -1.40300155e-01f, -1.05163574e-01f, 2.28446890e-02f, 1.89168185e-01f, 1.84532344e-01f, -1.34841874e-01f,
  2.19288543e-02f, -3.22990894e-01f, 2.22947016e-01f, -2.03410149e-01f, 1.80488497e-01f, -3.95256802e-02f, 1.64933115e-01f, 5.96257718e-03f, -1.71775967e-01f, -5.75317256e-02f,
  1.37210205e-01f, -2.26450190e-02f, -1.85278967e-01f, -2.24928126e-01f, -6.47994727e-02f, -1.64725646e-01f, 5.63323349e-02f, -1.12917982e-01f, 1.75506189e-01f, 2.32370719e-01f,
  2.23470435e-01f, 2.20285207e-01f, 1.39116049e-01f, 3.68173607e-02f, -8.96149054e-02f, 4.19194289e-02f, -9.48428214e-02f, 2.25962952e-01f, 1.95987105e-01f, -8.61760303e-02f,
  1.29702479e-01f, -9.09915119e-02f, -1.45382315e-01f, -4.89482284e-02f, 4.57100570e-02f, 5.37772104e-02f, -1.66077390e-01f, -2.66999781e-01f, 5.04656993e-02f, 1.50119320e-01f,
  -1.15801848e-03f, -1.45260682e-02f, 1.14715919e-01f, -1.24287903e-01f, 1.87337816e-01f, -2.07171634e-01f, -1.44529700e-01f, 1.42681926e-01f, -3.38192806e-02f, 1.02232762e-01f,
  -1.19472340e-01f, -1.51778653e-01f, 1.84492931e-01f, 6.09460883e-02f, 1.27150252e-01f, 2.26067811e-01f, 4.13587131e-03f, -1.21086396e-01f, 1.78030655e-01f, 8.23716447e-02f,
  2.82424808e-01f, 1.29493773e-01f, -9.96591002e-02f, -5.32931648e-03f, 3.34774964e-02f, 1.09722599e-01f, 3.59951295e-02f, 6.68180035e-03f, 6.63915426e-02f, 1.01822917e-03f,
  1.08148329e-01f, 1.11584580e-02f, 8.96059945e-02f, -5.36402166e-02f, 8.91774744e-02f, 1.60253897e-01f, -2.37858258e-02f, 2.45760590e-01f, -2.43277326e-02f, 6.10816851e-02f,
  -3.36018577e-02f, 2.15771407e-01f, -2.28557870e-01f, -3.94862629e-02f, 9.21312906e-03f, 3.17185512e-03f, 2.17060000e-01f, 1.81638837e-01f, 2.03063592e-01f, -7.88697228e-02f,
  -1.88521724e-02f, -1.74159348e-01f, -8.79572630e-02f, 2.44099647e-01f, -1.32571450e-02f, 1.32141650e-01f, 5.58354147e-02f, 4.25575227e-02f, -1.54731357e-02f, 1.09215756e-03f,
  7.91799277e-02f, 1.15278482e-01f, 1.12522230e-01f, -2.97336012e-01f, -2.12110542e-02f, -6.16120454e-03f, -8.67493972e-02f, 4.72130775e-02f, 1.95393085e-01f, -6.22699633e-02f,
  1.33657634e-01f, 7.86608364e-03f, -6.54116198e-02f, 2.08723396e-02f, 3.81740183e-02f, -1.12791218e-01f, 1.91338405e-01f, 2.49356791e-01f, 5.37724346e-02f, 6.80005252e-02f,
  3.95315662e-02f, -1.00267090e-01f, 2.20001638e-01f, 2.53363222e-01f, -8.23585689e-02f, 1.43684819e-01f, -1.48018941e-01f, -3.78601290e-02f, 2.22195182e-02f, 1.85951218e-01f,
  -8.79134759e-02f, -3.03699765e-02f, -8.55177194e-02f, 6.27256334e-02f, -4.52207290e-02f, -7.36493096e-02f, 1.55758500e-01f, 1.34204641e-01f, 4.85578328e-02f, 9.86264274e-02f,
  6.16857549e-03f, -3.55788544e-02f, -1.60233244e-01f, 6.64906725e-02f, 2.45283663e-01f, -1.97011396e-01f, -3.64875570e-02f, 1.41075060e-01f, -8.53581503e-02f, 1.37824492e-04f,
  5.35656773e-02f, 2.79184222e-01f, 5.78751937e-02f, -1.11135848e-01f, 3.03715765e-02f, -5.15654944e-02f, 2.66597390e-01f, 1.62008315e-01f, -1.31218553e-01f, 1.71432972e-01f,
  8.96805674e-02f, 7.88715854e-02f, 1.07799299e-01f, 1.55598149e-01f, 2.06523657e-01f, 1.33495452e-02f, -5.30461688e-03f, -7.12521076e-02f, -3.52043211e-02f, 1.95331395e-01f,
  7.74473697e-02f, -7.05543682e-02f, -9.53307673e-02f, -7.32706115e-02f, 2.57708412e-02f, 1.31135046e-01f, -4.11873795e-02f, 1.96396604e-01f, 3.54892284e-01f, 1.59629151e-01f,
  6.71405997e-03f, -1.64142221e-01f, 1.76536858e-01f, -3.93633684e-03f, 2.39883941e-02f, -3.74749228e-02f, -1.73222914e-01f, -1.04332156e-01f, -1.30907685e-01f, -1.02991223e-01f,
  1.31481826e-01f, 1.26427695e-01f, 1.98800892e-01f, 2.08852828e-01f, 1.92991778e-01f, 1.80548131e-01f, 1.23587698e-01f, -1.55008705e-02f, 7.91846290e-02f, 2.85580963e-01f,
  1.95956737e-01f, 1.98685899e-01f, 1.72230422e-01f, 1.41904503e-01f, -2.90340722e-01f, -6.50877059e-02f, 2.04903618e-01f, 1.50823131e-01f, 4.96498607e-02f, -2.89078802e-03f,
  1.35785595e-01f, 1.11906961e-01f, 6.56020865e-02f, 1.07427292e-01f, 3.29680443e-02f, -4.12959680e-02f, 5.52205853e-02f, 2.50446141e-01f, 2.15103582e-01f, -1.36262953e-01f,
  7.62825534e-02f, -1.37582183e-01f, -8.26250166e-02f, -6.51172176e-02f, -2.75794007e-02f, 1.57404378e-01f, 4.24010269e-02f, 1.80545449e-01f, 1.29962578e-01f, 1.66024759e-01f,
  1.10743724e-01f, -6.13901913e-02f, -2.52581649e-02f, 9.98866782e-02f, 1.20999329e-01f, 8.24703351e-02f, -9.60640311e-02f, 6.06299341e-02f, 1.23230837e-01f, 2.28398591e-02f,
  2.11678259e-02f, 8.80654976e-02f, 6.74791932e-02f, -1.08514398e-01f, 2.09711447e-01f, 1.05036139e-01f, 5.03201969e-02f, 4.34256010e-02f, 2.66524196e-01f, 1.99014679e-01f,
  1.01688571e-01f, -1.29943088e-01f, -2.64205277e-01f, 9.71913524e-03f, -1.14401489e-01f, -6.50566816e-02f, 1.98931322e-01f, 1.51854232e-01f, -4.85560223e-02f, 2.79345632e-01f,
  1.14547864e-01f, 2.19188899e-01f, -1.68624446e-01f, 2.05241919e-01f, -9.06577334e-02f, 9.04610455e-02f, -7.94386715e-02f, -5.05786017e-02f, -6.13535941e-02f, -7.78978020e-02f,
  1.18474983e-01f, -5.87338060e-02f, 1.57746821e-04f, -6.35794848e-02f, 5.39041050e-02f, -1.45293444e-01f, 1.69721469e-01f, -1.03403278e-01f, -1.23662420e-01f, 6.38223626e-03f,
  6.39247298e-02f, 1.43912971e-01f, 2.11223304e-01f, 4.55407239e-02f, 1.06092012e-02f, -1.35149449e-01f, 8.17619190e-02f, 1.70578778e-01f, 1.13621406e-01f, 1.32626235e-01f,
  5.67103960e-02f, -1.03669047e-01f, 5.38664572e-02f, -1.19834796e-01f, 1.97459280e-01f, -2.11157247e-01f, -1.98187798e-01f, 2.04060256e-01f, 1.31649096e-02f, -5.17413728e-02f,
  -9.49844252e-03f, 6.76031038e-02f, -4.20874059e-02f, 5.63282147e-02f, 1.64990779e-02f, -8.27860087e-02f, 1.38814867e-01f, 8.05377290e-02f, 1.58875391e-01f, -1.97638184e-01f,
  1.74934432e-01f, 8.12972486e-02f, 1.38629591e-02f, 2.42446437e-01f, -1.57007858e-01f, -1.19114451e-01f, -1.14238434e-01f, -8.16565529e-02f, -1.78496078e-01f, -8.61744434e-02f,
  1.38377339e-01f, 4.87252101e-02f, 1.08751148e-01f, -1.67850908e-02f, 2.63628155e-01f, -1.01994433e-01f, 2.09624156e-01f, 2.31399596e-01f, 4.99806553e-02f, 3.38708200e-02f,
  1.48963720e-01f, 8.86706114e-02f, -1.98862568e-01f, -1.48499265e-01f, 1.54555097e-01f, 1.82886824e-01f, 7.44507611e-02f, 1.68207684e-03f, -6.08695969e-02f, 2.09773719e-01f,
  1.65684357e-01f, 1.62971690e-01f, -4.80456190e-04f, 5.28142834e-03f, -7.05580488e-02f, 1.34678483e-01f, 6.07741624e-02f, 3.95934395e-02f, -7.97523186e-02f, 2.02265978e-02f,
  5.89701422e-02f, -1.99522436e-01f, 2.21116409e-01f, 8.50144625e-02f, 1.60582647e-01f, 1.52142584e-01f, 1.38384104e-01f, 1.85552955e-01f, 8.84634331e-02f, -2.73843855e-01f,
  6.09027110e-02f, -6.64644241e-02f, -2.04213038e-01f, 8.21020454e-02f, 6.28817454e-02f, -9.18325111e-02f, 2.54254729e-01f, 1.75885081e-01f, -1.73635840e-01f, 4.82645296e-02f,
  2.03917354e-01f, -1.67755589e-01f, 2.30350435e-01f, -2.10342300e-03f, -2.83986237e-02f, 7.02554658e-02f, 4.61432822e-02f, -1.84382915e-01f, 1.41670644e-01f, -1.15577482e-01f,
  -1.42521843e-01f, 4.00446691e-02f, 1.87312454e-01f, -1.92734659e-01f, -4.85175885e-02f, -1.17139228e-01f, 6.02854341e-02f, -6.52680397e-02f, -5.48287854e-02f, 8.89301673e-02f,
  2.54271012e-02f, 1.04207031e-01f, -1.01847341e-03f, 1.21140547e-01f, 7.02673057e-03f, 1.97191119e-01f, -9.91182476e-02f, -2.40950912e-01f, -2.13392675e-01f, -6.22147089e-03f,
  2.91766375e-01f, -8.98839235e-02f, 1.74553052e-01f, -1.35196105e-01f, 1.75677270e-01f, 2.07250416e-02f, 1.60792753e-01f, 2.18936175e-01f, -9.71325263e-02f, 6.03433475e-02f,
  1.85489789e-01f, -1.75721467e-01f, 2.46764779e-01f, -1.25403538e-01f, -1.29374474e-01f, -2.71398388e-02f, 9.28558484e-02f, 3.43793109e-02f, 1.31753683e-01f, 1.72551230e-01f,
  1.21103466e-01f, -1.64172817e-02f, 8.53260532e-02f, -2.52681255e-01f, 1.19461663e-01f, 2.14083403e-01f, 7.55760074e-02f, 1.50941312e-01f, 8.65605474e-02f, 8.18028599e-02f,
  1.09210514e-01f, 2.37786621e-01f, -3.07896614e-01f, 2.00092256e-01f, 2.34310329e-01f, -1.85154855e-01f, 2.66172498e-01f, 1.88961402e-01f, -7.94105828e-02f, 1.75858572e-01f,
  1.36437029e-01f, -6.36132583e-02f, 1.20584123e-01f, -4.99889851e-02f, -2.58419991e-01f, -7.85488859e-02f, -1.83833957e-01f, -1.23726428e-01f, 5.33903912e-02f, 8.51994231e-02f,
  -1.55667379e-01f, 2.21178114e-01f, 8.12675729e-02f, 1.93493858e-01f, -1.22964703e-01f, 1.58321857e-01f, -3.45500209e-03f, 1.43387467e-01f, 4.14129235e-02f, 1.39301375e-01f,
  1.06337346e-01f, 1.52313963e-01f, -1.76086351e-01f, 1.25975430e-01f, 5.51935658e-02f, -1.59751270e-02f, -1.49423197e-01f, -1.42205119e-01f, 7.99139589e-02f, -9.15398598e-02f,
  3.62674966e-02f, 1.38814345e-01f, 1.33814454e-01f, 1.66015714e-01f, 8.57474878e-02f, 5.89883812e-02f, 1.23365521e-01f, -1.05510645e-01f, -5.24408557e-02f, 6.47503287e-02f,
  1.61031812e-01f, 1.30813003e-01f, 6.02282919e-02f, 1.76052172e-02f, 7.67749697e-02f, -1.24220803e-01f, 1.06243961e-01f, -1.52354747e-01f, -1.38625130e-01f, -1.35817053e-02f,
  8.72865543e-02f, -1.91179916e-01f, -6.95716366e-02f, 2.23129630e-01f, -1.49562791e-01f, -1.95105448e-01f, 2.16369018e-01f, 8.27588066e-02f, -1.04703777e-01f, 7.41262585e-02f,
  -7.94054493e-02f, -8.75556245e-02f, 6.75832480e-02f, 4.96848188e-02f, -1.79752111e-01f, -3.73187438e-02f, 1.30997058e-02f, -1.45268977e-01f, 9.49981138e-02f, 1.83087930e-01f,
  -2.40603741e-02f, 8.69394615e-02f, 9.50482953e-03f, -6.99571222e-02f, 1.95575610e-01f, -3.76416594e-02f, 9.00978148e-02f, -2.15846702e-01f, 2.10107371e-01f, -8.52073804e-02f,
  5.91048878e-03f, -2.50604481e-01f, 7.81972408e-02f, 1.98976904e-01f, 3.12912352e-02f, 2.79592839e-03f, 1.56629637e-01f, -2.28836209e-01f, 7.31334686e-02f, 1.24704234e-01f,
  2.23720461e-01f, 2.66785532e-01f, -1.23949265e-02f, 1.10103197e-01f, 4.82957326e-02f, -5.22034578e-02f, 9.79648158e-02f, 9.78994817e-02f, -2.22692490e-02f, 1.43013388e-01f,
  -9.87103581e-02f, 1.39436334e-01f, 1.15205675e-01f, -1.09293409e-01f, 1.47878677e-01f, 8.81036744e-02f, -2.84791272e-02f, 1.47143483e-01f, -3.51735838e-02f, -2.26019546e-02f,
  -5.11757880e-02f, -4.68314579e-03f, 4.81764525e-02f, 1.37720972e-01f, -4.02827933e-02f, 1.76207051e-01f, 1.81912631e-01f, 8.60490203e-02f, -2.53452063e-01f, 9.41383988e-02f,
  -1.66638717e-01f, 1.08570002e-01f, -1.19875699e-01f, -1.81057736e-01f, -2.73559820e-02f, 2.96422124e-01f, -1.30618334e-01f, 1.83258504e-01f, -3.54841426e-02f, 1.95415124e-01f,
  9.52250361e-02f, 1.04686819e-01f, 2.82335393e-02f, -1.12800347e-03f, -2.38605440e-01f, 2.42565162e-02f, 5.31624146e-02f, 1.97928295e-01f, -1.78828210e-01f, 2.31718227e-01f,
  8.58938545e-02f, 1.62996382e-01f, -1.03917480e-01f, 1.24617346e-01f, 5.68313189e-02f, 1.79088190e-01f, 1.05403140e-01f, 1.31653190e-01f, 3.16955388e-01f, 1.21669784e-01f,
  7.23450035e-02f, -5.93726384e-03f, 2.20741108e-01f, 8.52250010e-02f, 9.86174121e-03f, -9.87616554e-02f, 1.48618728e-01f, -2.24089965e-01f, -7.82293305e-02f, 1.90467909e-01f,
  1.72622547e-01f, -5.18640354e-02f, 6.42926572e-03f, -2.28570923e-02f, 1.90092921e-01f, 1.33065417e-01f, -8.04034099e-02f, 1.48941815e-01f, 1.06620654e-01f, -4.90686931e-02f,
  -4.53255177e-02f, 2.10749581e-02f, 1.58441544e-01f, -1.02511890e-01f, -2.62433328e-02f, 7.33085647e-02f, -1.27216905e-01f, 8.72562155e-02f, 1.75538540e-01f, -2.03232899e-01f,
  -1.94514409e-01f, -9.37017277e-02f, -1.22108914e-01f, 9.48934990e-04f, 1.40396729e-01f, -4.70156670e-02f, 7.30374157e-02f, 2.50896871e-01f, -1.26479998e-01f, 8.95693246e-03f,
  5.77664413e-02f, -3.36238146e-02f, -7.72450194e-02f, 7.33608752e-02f, -2.10519642e-01f, -1.40158385e-02f, 5.43725230e-02f, 1.68409243e-01f, 7.39591196e-02f, 9.80753899e-02f,
  6.38785586e-02f, 5.08289300e-02f, 1.98817536e-01f, 1.62472531e-01f, 1.32251546e-01f, -1.43601671e-01f, 2.76237205e-02f, 6.18567392e-02f, 1.06641270e-01f, 5.09028733e-02f,
  4.69355993e-02f, 1.53918847e-01f, -2.45545387e-01f, 3.55992606e-03f, 2.54565030e-01f, 1.74255185e-02f, -2.11855825e-02f, 9.37996581e-02f, 1.37067214e-01f, 1.21598221e-01f,
  -7.40021318e-02f, 1.57837011e-02f, 1.47959873e-01f, -9.56766382e-02f, 8.45710933e-02f, 1.84936836e-01f, -2.85484549e-02f, 2.72121802e-02f, -1.87963098e-01f, -6.22668639e-02f,
  7.98470154e-02f, -1.04070336e-01f, 1.79343730e-01f, 1.32911056e-01f, 5.91831543e-02f, 2.17233837e-01f, 2.61821747e-01f, 1.40819520e-01f, -9.89480093e-02f, 5.05188964e-02f,
  -2.61802107e-01f, -2.68126190e-01f, 1.01290271e-01f, -1.19050099e-02f, -1.08180545e-01f, -1.97393242e-02f, 3.21753561e-01f, 2.34710455e-01f, -9.86557733e-03f, 1.76505744e-02f,
  2.08570510e-01f, 7.63951614e-02f, 3.02265018e-01f, -8.68807361e-02f, 1.50298938e-01f, -8.19644853e-02f, 3.04105818e-01f, -1.69966757e-01f, 1.07140258e-01f, -3.12569052e-01f,
  3.65863480e-02f, 1.85359895e-01f, 1.70255810e-01f, -1.28754467e-01f, 6.72407821e-02f, -1.91464841e-01f, 1.45377338e-01f, 6.60102069e-02f, -5.54416813e-02f, 2.34740507e-02f,
  -6.77755401e-02f, 1.69039547e-01f, -1.63546637e-01f, 2.62563191e-02f, 2.77399085e-02f, 1.16114862e-01f, -1.87178344e-01f, -1.27640918e-01f, -1.63857445e-01f, -6.40676767e-02f,
  4.76860106e-02f, -7.55678043e-02f, 3.26881893e-02f, 2.65611801e-02f, 4.80594002e-02f, 2.44973645e-01f, 1.62834942e-01f, 1.16932966e-01f, -1.16145507e-01f, 8.87781531e-02f,
  2.55994081e-01f, -7.83759579e-02f, 2.07108870e-01f, -2.14808464e-01f, 7.34323487e-02f, -2.27921978e-01f, 1.71889171e-01f, 1.44270947e-02f, 1.61891446e-01f, 2.30142489e-01f,
  9.50929448e-02f, 2.08037630e-01f, -2.38921106e-01f, 1.74876258e-01f, 9.77667570e-02f, 1.17014021e-01f, 2.77026176e-01f, -3.58709134e-02f, -1.09028965e-02f, -1.35050386e-01f,
  -3.71622480e-02f, 8.91614705e-02f, -2.24138081e-01f, 1.64662078e-01f, 9.83050764e-02f, -2.30825797e-01f, 1.02203272e-01f, -1.25301648e-02f, 5.28931767e-02f, -5.94025031e-02f,
  3.51784319e-01f, 1.57507122e-01f, -6.72611222e-02f, -1.06877461e-01f, 9.03034657e-02f, 1.42713562e-01f, -3.35227908e-03f, 2.23362043e-01f, 2.99448103e-01f, 3.15540940e-01f,
  1.44436166e-01f, 2.19474792e-01f, 5.19260205e-02f, 2.61027038e-01f, -7.66048431e-02f, 2.18170956e-01f, 1.39713675e-01f, 2.84554791e-02f, 1.49845943e-01f, 1.09581165e-01f,
  1.07202657e-01f, 2.32735351e-01f, 1.40698850e-01f, -1.75419990e-02f, -7.94924796e-02f, -1.42947555e-01f, -2.13741347e-01f, -1.14521571e-02f, 1.44723445e-01f, -1.99972227e-01f,
  -4.51769494e-02f, 6.36567473e-02f, 1.01834677e-01f, 1.28467411e-01f, -8.70103389e-02f, -7.58905336e-02f, -5.56222238e-02f, -1.73998661e-02f, 1.26794100e-01f, 1.50056064e-01f,
  1.35582283e-01f, 5.91380708e-02f, 8.86918902e-02f, 1.90965474e-01f, 2.80998070e-02f, 2.11022422e-02f, -7.60872662e-02f, 3.57234441e-02f, -1.86306775e-01f, -1.19162768e-01f,
  -1.05884939e-01f, 9.82842967e-03f, 1.52968675e-01f, 1.99168578e-01f, 1.45451009e-01f, -6.74330443e-02f, 1.72199756e-01f, 8.48430395e-02f, -1.15745179e-01f, -3.11860703e-02f,
  1.87530532e-01f, 1.01895355e-01f, 7.83296674e-02f, 5.44361994e-02f, 1.86555475e-01f, -3.48508707e-04f, 1.26394093e-01f, 7.25305155e-02f, 7.97233284e-02f, 9.24170613e-02f,
  1.32234216e-01f, -1.53215840e-01f, -1.26820832e-01f, -1.71365276e-01f, 3.58710028e-02f, -1.80220842e-01f, -1.59706026e-01f, -3.08567542e-03f, 7.71752298e-02f, -1.01664878e-01f,
  -7.76552409e-02f, 1.17249444e-01f, -1.80206239e-01f, 8.33493937e-03f, 3.38577032e-02f, 7.95391500e-02f, -1.39867827e-01f, -1.74606442e-01f, 2.15708971e-01f, -2.87201226e-01f,
  1.78836524e-01f, 1.61775142e-01f, 1.92162082e-01f, 2.35176042e-01f, 4.23593223e-02f, 2.67427206e-01f, 1.01230703e-01f, -6.37458861e-02f, 5.68591766e-02f, -9.04672220e-03f,
  7.09976554e-02f, 1.83759764e-01f, 2.32758988e-02f, 9.28085148e-02f, -5.16476594e-02f, 1.34276032e-01f, -1.06629863e-01f, -1.38384983e-01f, 6.09134138e-02f, -9.07603949e-02f,
  -1.20358266e-01f, 8.37179199e-02f, 3.17826793e-02f, -9.39790085e-02f, 2.51247257e-01f, -2.75482647e-02f, 1.35007864e-02f, -1.55465469e-01f, -8.11948255e-02f, 2.42256224e-02f,
  3.38922739e-02f, -1.11425109e-01f, 1.15508460e-01f, -2.47354936e-02f, 7.16270786e-03f, -2.82127082e-01f, 1.92346588e-01f, -1.58316091e-01f, 1.27925634e-01f, -1.82303991e-02f,
  -4.45124432e-02f, -1.76476277e-02f, 1.28284529e-01f, 1.59742191e-01f, 8.47858638e-02f, -1.18893962e-02f, 1.39875442e-01f, 1.47171378e-01f, 1.86255172e-01f, -9.80229899e-02f,
  -8.20632204e-02f, 3.26604992e-02f, 6.70105740e-02f, 1.62014633e-01f, 2.03100771e-01f, 3.80957946e-02f, 1.71855465e-01f, 3.07748234e-03f, -1.99546486e-01f, 2.17135593e-01f,
  1.11185133e-01f, -5.34805432e-02f, -9.24486946e-03f, 7.54996985e-02f, -7.42522776e-02f, -8.94632377e-03f, 9.84789133e-02f, 1.11759327e-01f, 1.27139375e-01f, -1.09655663e-01f,
  9.79806036e-02f, -9.89828482e-02f, -3.93326245e-02f, 7.51943886e-02f, -6.33786544e-02f, 1.97889984e-01f, 1.49681091e-01f, -1.35583818e-01f, -2.88185216e-02f, -9.35100541e-02f,
  -5.94225936e-02f, -8.81872103e-02f, 2.76090181e-03f, 6.62561832e-03f, 6.80350885e-02f, -1.25845745e-01f, -9.86394361e-02f, -6.98648095e-02f, -2.61277229e-01f, 1.95971817e-01f,
  4.10488471e-02f, 2.61372715e-01f, -1.70843318e-01f, 4.62419577e-02f, 3.50721478e-02f, 1.52335137e-01f, -9.87026691e-02f, 6.71687648e-02f, 1.23374604e-01f, 1.20166145e-01f,
  -9.39324275e-02f, 3.19345415e-01f, -1.75435748e-02f, 2.22481857e-03f, 1.71690241e-01f, 2.44024433e-02f, 6.13057986e-02f, -5.98069504e-02f, -6.02732366e-03f, -1.21142920e-02f,
  -1.43369466e-01f, 3.74495611e-02f, 1.18405320e-01f, -1.12759978e-01f, 2.49146912e-02f, 9.76238027e-02f, 1.81683019e-01f, 1.10523095e-02f, -1.72854457e-02f, 4.65251021e-02f,
  1.17982566e-01f, 2.54979074e-01f, 2.00898543e-01f, 1.29339769e-01f, -1.34099826e-01f, 9.67659131e-02f, 2.35673159e-01f, -7.05175474e-02f, 3.13271165e-01f, 2.22680584e-01f,
  1.54769108e-01f, 2.51737654e-01f, 5.85455783e-02f, 6.21690005e-02f, 1.49927884e-01f, -9.89953279e-02f, 1.51478395e-01f, 2.14518845e-01f, 5.49975783e-02f, 5.42164594e-02f,
  -1.19865678e-01f, -9.17753670e-03f, -9.76128951e-02f, -1.54027725e-02f, 1.89882398e-01f, -6.18122071e-02f, -1.75077409e-01f, -8.83076712e-02f, -2.55866259e-01f, 3.73486131e-01f,
  -1.28191104e-02f, 1.38589293e-01f, 2.18530536e-01f, -1.45624921e-01f, 1.04785718e-01f, -8.08647349e-02f, -1.04195096e-01f, -7.12198615e-02f, -1.09200768e-01f, 4.96195778e-02f,
  5.45344241e-02f, -2.79538125e-01f, -1.15353651e-01f, 3.03021702e-03f, 1.19805215e-02f, -2.74584889e-01f, 1.56077668e-01f, 1.68520942e-01f, -1.41912490e-01f, -5.80484159e-02f,
  4.61017251e-01f, 1.25176802e-01f, 4.71455604e-02f, 1.45304292e-01f, 2.12682292e-01f, 2.47795179e-01f, 1.08349383e-01f, 5.15855514e-02f, -6.21905876e-03f, -4.06028405e-02f,
  -3.40931654e-01f, 6.55755177e-02f, 8.71273726e-02f, -1.70140803e-01f, -4.02148850e-02f, -3.92061705e-03f, 5.41677400e-02f, 2.24625096e-01f, 1.92100927e-01f, 1.41572043e-01f,
  -3.78696531e-01f, -2.07236595e-02f, -2.32763320e-01f, -1.18585736e-01f, 1.20387658e-01f, -2.86425650e-01f, 1.08295912e-02f, -9.36909765e-02f, 5.23667149e-02f, -3.97804454e-02f,
  -3.22669923e-01f, 1.75539196e-01f, -2.05564480e-02f, 3.62645499e-02f, 3.49990755e-01f, 1.03815533e-02f, -8.42132868e-05f, 1.75975412e-01f, 9.29317847e-02f, 3.00363079e-03f,
  1.40961736e-01f, -2.59285718e-02f, -8.42203051e-02f, 1.54145226e-01f, -3.89986597e-02f, -3.48448157e-02f, 2.57052302e-01f, -2.31492743e-01f, -2.86070239e-02f, 1.39532492e-01f,
  -1.95440009e-01f, -1.14026949e-01f, 1.35225251e-01f, -9.95482430e-02f, 3.27145234e-02f, 2.55203098e-01f, -2.87803765e-02f, -1.58661038e-01f, 2.81039387e-01f, -2.53391594e-01f,
  9.33545008e-02f, 6.33083805e-02f, -8.36362466e-02f, -2.11866885e-01f, 2.65260249e-01f, 5.76538444e-02f, 8.73303115e-02f, 5.89256221e-03f, 8.68188888e-02f, 3.37636434e-02f,
  2.43735820e-01f, -6.53510913e-02f, 1.38375327e-01f, -3.65415066e-02f, 2.58914661e-02f, 1.86557546e-01f, 7.37559348e-02f, -1.21199489e-01f, -2.33104290e-03f, 1.83896497e-02f,
  1.00648187e-01f, -8.98332596e-02f, 1.03766233e-01f, -8.02587271e-02f, -2.29036629e-01f, -2.06553504e-01f, -6.29220158e-02f, 1.47239128e-02f, 8.18686709e-02f, 3.77687998e-02f,
  9.52267833e-03f, -1.41868303e-02f, 2.01693788e-01f, 1.19469993e-01f, 1.93177257e-02f, 1.00038685e-01f, -1.73035517e-01f, 7.17074275e-02f, 1.49496168e-01f, -5.31257689e-02f,
  -2.18541268e-02f, -1.64213276e-03f, 1.18977547e-01f, 1.55882791e-01f, 1.11551760e-02f, -3.32102627e-02f, -5.62337115e-02f, -9.29728597e-02f, 6.42597163e-03f, 1.17894188e-01f,
  4.42334861e-02f, -1.58573478e-01f, -8.28717798e-02f, -1.53033063e-02f, -1.57208592e-01f, 6.96947947e-02f, 1.04720458e-01f, 1.79138303e-01f, -7.16168880e-02f, 1.37026802e-01f,
  -2.29820460e-01f, -4.68481705e-02f, 1.62044019e-01f, -8.61646980e-02f, -3.16956453e-02f, -4.96893078e-02f, 6.58845678e-02f, 8.06293041e-02f, -1.41986474e-01f, 2.30716299e-02f,
  -1.00631945e-01f, 7.56235793e-02f, 1.15286008e-01f, 1.32485718e-01f, 1.54232726e-01f, 4.95704636e-02f, 3.75852138e-02f, -7.83846453e-02f, 1.12932272e-01f, 1.65074989e-01f,
  -4.68381587e-03f, -4.07762788e-02f, 1.72150403e-01f, -5.39958924e-02f, -1.78390160e-01f, 6.95576370e-02f, 6.43124059e-02f, 7.57946372e-02f, 7.06417188e-02f, 1.01273656e-01f,
  1.50935605e-01f, 1.37651607e-01f, -1.40477002e-01f, 3.80744152e-02f, 1.17572462e-02f, -1.60507590e-01f, 1.53271332e-01f, 2.73110848e-02f, -8.01387522e-03f, 3.15483622e-02f,
  -1.49072366e-04f, 4.90353554e-02f, 9.18660313e-02f, 1.29027337e-01f, 6.62842244e-02f, 5.72099276e-02f, 4.74380776e-02f, 1.08455844e-01f, 2.70676930e-02f, 1.24150075e-01f,
  -5.13353497e-02f, -5.10671129e-03f, -2.17678785e-01f, -3.13883394e-01f, 1.17939018e-01f, -1.08877011e-01f, -1.04792766e-01f, -4.76437658e-02f, 9.07090828e-02f, 1.45013034e-01f,
  2.71564662e-01f, 3.01610976e-02f, -1.26798362e-01f, -7.09548593e-02f, 1.34772241e-01f, -1.82782054e-01f, 9.13159624e-02f, 8.13714936e-02f, -4.59109209e-02f, -2.17273578e-01f,
  -1.55345406e-02f, -5.76000288e-02f, 1.77589178e-01f, 1.34306237e-01f, 2.88795233e-01f, -1.89748667e-02f, 9.27278474e-02f, -1.51669517e-01f, 1.42833546e-01f, -1.50274724e-01f,
  -2.01800704e-01f, 4.52822000e-02f, 1.98686108e-01f, 3.46680395e-02f, -1.14104804e-02f, -2.37921290e-02f, 1.23345539e-01f, 7.19721168e-02f, -1.89235523e-01f, 2.04824299e-01f,
  7.84623204e-04f, -2.22597778e-01f, 1.13129415e-01f, 7.21168444e-02f, -1.96809601e-02f, 1.09681360e-01f, 8.01793039e-02f, 7.63226748e-02f, 2.66567707e-01f, 1.27771616e-01f,
  2.14162052e-01f, -1.63763016e-01f, -7.30552673e-02f, 3.19123222e-03f, 2.12348804e-01f, 2.40889326e-01f, -4.21263613e-02f, -1.20989524e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  -2.18100250e-02f, 7.17345774e-02f, 4.72900756e-02f, 2.17555657e-01f, 1.46861136e-01f, 6.20764010e-02f, 1.69162214e-01f, 1.56226754e-01f, -4.96766232e-02f, 7.30875880e-02f,
  7.51502141e-02f, 1.78701291e-03f, -5.74958622e-02f, -2.63989363e-02f, 8.43101088e-03f, -5.15699610e-02f, 9.01613235e-02f, -1.09463163e-01f, 5.67740873e-02f, 1.42938882e-01f,
  -4.87275198e-02f, 1.53879523e-01f, 1.08029224e-01f, 1.40599802e-01f, -3.76805365e-02f, 4.17582355e-02f, 5.95256053e-02f, 1.65703848e-01f, 4.89063188e-03f, 1.96601570e-01f,
  1.96099445e-01f, 7.45813921e-02f, 1.48563504e-01f, -8.18279982e-02f, 7.59641528e-02f, 1.66879594e-01f, 3.70583311e-02f, 6.70401230e-02f, 8.19075480e-02f, 1.29872814e-01f,
  -3.09591219e-02f, 4.85483818e-02f, -4.94472422e-02f, 1.33727580e-01f, 1.92776158e-01f, 2.01008305e-01f, 3.34069245e-02f, 7.20549375e-02f, -6.56238347e-02f, 9.92581770e-02f,
  2.49015130e-02f, 1.27751201e-01f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  1.20429255e-01f, -3.42980549e-02f, 4.14816029e-02f, 1.06308676e-01f, 4.01799940e-02f, 5.88993691e-02f, 1.51330248e-01f, -7.62526318e-02f, -8.29579309e-02f, -4.22291793e-02f,
  -1.58894330e-01f, -5.46716750e-02f, -3.88224944e-02f, 1.20187059e-01f, -5.97840324e-02f, 8.32654461e-02f, 1.20889485e-01f, -1.04717225e-01f, 1.45478128e-02f, 3.51750962e-02f,
  -1.44575626e-01f, 9.38152298e-02f, 1.50846168e-01f, 9.18114707e-02f, -1.27833605e-01f, -8.54594558e-02f, -3.18165980e-02f, -1.01697743e-01f, -1.26236632e-01f, 5.11038117e-04f,
  1.22560766e-02f, 2.39848178e-02f, -4.89302948e-02f, -6.11458942e-02f, 1.19697578e-01f, -7.09192902e-02f, -7.76120052e-02f, 5.93455462e-03f, 1.75247602e-02f, 1.47147283e-01f,
  1.28700644e-01f, -8.71422365e-02f, -1.01627760e-01f, 1.21443465e-01f, 1.28753528e-01f, -7.40943477e-02f, -4.09827307e-02f, -6.54442087e-02f, 1.16341621e-01f, -2.32019611e-02f,
  -8.85342732e-02f, 6.70133978e-02f, 2.37646736e-02f, -9.28914845e-02f, -5.56497872e-02f, 7.42896367e-03f, 1.44043220e-02f, 1.09881602e-01f, 6.29182681e-02f, -1.20765969e-01f,
  -7.97291920e-02f, -2.14639939e-02f, -5.14312349e-02f, 9.97932255e-02f, -5.64416349e-02f, 6.03820607e-02f, -4.31893878e-02f, 1.02179930e-01f, 9.41538438e-02f, 4.70391251e-02f,
  6.64806040e-03f, 8.07575956e-02f, -1.39033780e-01f, 9.53926295e-02f, 6.02283850e-02f, 1.57575998e-02f, 2.78420467e-02f, -1.55667126e-01f, -1.22934937e-01f, -1.11400224e-01f,
  3.38919833e-02f, -7.34476745e-02f, 1.33232638e-01f, 3.07490695e-02f, 6.20396212e-02f, -1.06934927e-01f, -3.13663222e-02f, -3.67256738e-02f, -1.29855424e-01f, 9.85149667e-02f,
  3.06144282e-02f, -1.59998126e-02f, 7.54497796e-02f, -9.75219980e-02f, 4.70049046e-02f, 2.49962620e-02f, 5.42455018e-02f, -3.69649827e-02f, 1.94321200e-02f, -8.66216198e-02f,
  6.19215071e-02f, -1.53051056e-02f, -1.88227683e-01f, 9.26293731e-02f, -5.05452007e-02f, 1.05792068e-01f, 2.76141725e-02f, 8.33308324e-02f, 1.05512977e-01f, -1.04092620e-01f,
  -1.10891342e-01f, -3.67614552e-02f, 1.31863534e-01f, -2.63635609e-02f, 1.18027562e-02f, -4.53244708e-02f, -1.31392479e-01f, 1.29418522e-01f, -5.63853383e-02f, 8.21236596e-02f,
  4.89098430e-02f, 1.23512134e-01f, 1.16450980e-03f, -8.03202614e-02f, -2.36212760e-02f, 1.21914679e-02f, 7.98161253e-02f, -4.62369062e-02f, 7.20437318e-02f, 1.07708685e-02f,
  -4.29823324e-02f, 1.28836539e-02f, 3.41386683e-02f, 2.20853370e-02f, -8.39082599e-02f, 4.11742292e-02f, 1.53714521e-02f, -1.07734902e-02f, 6.05205297e-02f, -8.62140656e-02f,
  8.68304260e-03f, -1.24806181e-01f, 5.55686541e-02f, -1.62283957e-01f, -8.71365443e-02f, 9.95994210e-02f, 8.81335884e-02f, -2.36877009e-01f, 1.01968706e-01f, 1.22996546e-01f,
  -7.17087537e-02f, -2.54300963e-02f, 4.53316085e-02f, 7.28892386e-02f, -8.43550637e-02f, 1.20714866e-01f, -8.33033398e-02f, -4.13549729e-02f, 8.96737203e-02f, -1.19871490e-01f,
  1.51638031e-01f, -5.77268600e-02f, 1.23983532e-01f, 4.95320782e-02f, -1.22643419e-01f, 5.84032685e-02f, 8.17429554e-03f, 2.60739364e-02f, 1.05320692e-01f, -3.83145921e-02f,
  5.40766828e-02f, -4.51059788e-02f, 8.70166421e-02f, 1.34122580e-01f, 8.23208224e-03f, 4.05916348e-02f, 2.35796459e-02f, -1.04994990e-01f, -6.15586117e-02f, -1.14712790e-01f,
  1.10540539e-01f, 1.39299184e-01f, 2.96221189e-02f, -2.28047222e-01f, -7.90334493e-02f, -8.78879577e-02f, 6.40662238e-02f, 1.60463914e-01f, 1.49536610e-01f, -6.03803918e-02f,
  7.72606805e-02f, -6.64742216e-02f, 1.01315089e-01f, -8.50304291e-02f, 5.35185039e-02f, -9.26262811e-02f, 6.76104352e-02f, 1.72388256e-02f, -9.18782353e-02f, -4.95777465e-02f,
  -7.72338733e-03f, -2.92952005e-02f, -1.18347723e-02f, -8.58184174e-02f, -1.57184809e-01f, 1.65880084e-01f, 7.49080256e-02f, -5.05723841e-02f, 4.73981202e-02f, -1.01830490e-01f,
  6.20136485e-02f, 1.65035389e-02f, 3.59994434e-02f, 2.81318538e-02f, -3.68039776e-03f, -3.34858894e-02f, 1.25912711e-01f, 6.53006211e-02f, 1.01458788e-01f, 7.90232643e-02f,
  -1.59472618e-02f, 4.71084379e-02f, -7.40556046e-02f, 5.91655225e-02f, 1.68254316e-01f, -2.65920833e-02f, -4.89713885e-02f, 1.06268279e-01f, -4.33559269e-02f, -4.77013737e-02f,
  -3.90050597e-02f, 4.70628962e-02f, 7.29007795e-02f, -3.74535695e-02f, -3.45157534e-02f, 1.01099283e-01f, 5.59642054e-02f, -6.24209642e-02f, -9.61990729e-02f, -6.80906400e-02f,
  2.05346271e-02f, -2.33850814e-02f, -1.51186824e-01f, 2.52517406e-04f, -1.70058422e-02f, -1.47355618e-02f, 3.19912583e-02f, -1.93329409e-01f, 7.13808869e-04f, 3.99475219e-03f,
  -8.21718350e-02f, 1.09949149e-02f, 6.39785687e-03f, 1.23471677e-01f, 8.22014287e-02f, 6.25593215e-02f, 3.74342985e-02f, -7.20226616e-02f, 5.67487553e-02f, 6.99281320e-02f,
  1.13802157e-01f, -2.17845361e-03f, 1.46115199e-01f, -1.42285407e-01f, 1.19168289e-01f, 7.66282454e-02f, 1.07782014e-01f, -1.67960659e-01f, -2.91301124e-02f, -1.00163324e-02f,
  -8.33178386e-02f, -5.32486662e-02f, -7.31529966e-02f, -1.16574019e-01f, 2.63107307e-02f, -1.40210152e-01f, 8.85083601e-02f, 6.27982318e-02f, 1.54506221e-01f, 3.47568430e-02f,
  1.08533219e-01f, 5.61221614e-02f, -5.36919199e-02f, -4.69635054e-02f, -1.55924737e-01f, -3.08587924e-02f, 9.16928425e-02f, -1.37137830e-01f, 2.62109935e-02f, -9.53288674e-02f,
  8.84050876e-02f, 1.47027552e-01f, -1.14602394e-01f, 1.18757755e-01f, 2.58660037e-02f, 4.04893346e-02f, 1.49571806e-01f, 6.88811913e-02f, -1.03785209e-02f, 1.20587140e-01f,
  1.25979587e-01f, -1.28604576e-01f, -2.00579222e-02f, 9.24697667e-02f, -3.90123799e-02f, -5.32995909e-02f, -1.12897024e-01f, -4.28380370e-02f, 7.88724516e-03f, -8.67315605e-02f,
  6.12385012e-02f, -1.04003824e-01f, 1.13884553e-01f, 5.44497184e-02f, 4.83117625e-02f, -1.17485762e-01f, -6.11157976e-02f, 6.83774501e-02f, -6.47880509e-02f, -3.86753045e-02f,
  -7.23305270e-02f, 8.73493180e-02f, -3.36954780e-02f, 9.80565175e-02f, 1.02455013e-01f, -3.42943184e-02f, 8.28288123e-02f, 2.13698708e-02f, -5.48402853e-02f, 1.06352188e-01f,
  -1.06495492e-01f, 2.55846046e-02f, 9.17763859e-02f, -9.16934460e-02f, -4.24915105e-02f, -7.07148165e-02f, 9.00329798e-02f, 5.28520569e-02f, 1.06632747e-01f, 8.49528238e-02f,
  -1.18742630e-01f, 6.86486661e-02f, -1.71526428e-02f, -7.92816002e-03f, -1.57215312e-01f, -1.50122503e-02f, 5.64705357e-02f, -4.63010482e-02f, -1.16848275e-01f, 4.06939723e-02f,
  1.26482666e-01f, -6.43531904e-02f, -1.22904606e-01f, -4.38396856e-02f, 7.37421438e-02f, -9.40474048e-02f, -5.88164702e-02f, 9.55909863e-02f, -2.33850442e-02f, 5.73985055e-02f,
  2.83117946e-02f, 1.77632775e-02f, 1.10059671e-01f, -7.88024887e-02f, 1.10482261e-01f, 4.50934805e-02f, -3.01084593e-02f, 9.13985074e-02f, -3.78206335e-02f, 1.20960973e-01f,
  -9.42391679e-02f, 1.04173563e-01f, -8.70380476e-02f, -1.40948504e-01f, 6.25468493e-02f, 1.81117952e-01f, 1.21440865e-01f, -3.02387923e-02f, -6.48324639e-02f, -1.25307187e-01f,
  -8.28079209e-02f, 7.97815099e-02f, -1.56697594e-02f, 1.10047360e-04f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -3.00910021e-03f, -6.64457455e-02f, 1.85612768e-01f, -2.47228500e-02f, -3.55291069e-02f, 7.33100995e-02f, -3.64833586e-02f, 1.29686380e-02f, -1.10317720e-02f, 1.97994962e-01f,
  5.43649960e-03f, 9.81687382e-02f, 1.73012331e-01f, 8.40808079e-03f, -3.90831940e-02f, 6.25278279e-02f, 8.34871158e-02f, -3.80535275e-02f, 5.35198711e-02f, 2.19047278e-01f,
  -8.60727504e-02f, 2.68900990e-01f, -3.99881043e-02f, -2.04252928e-01f, -2.50277370e-02f, 1.59751438e-02f, -1.01816699e-01f, -1.35424271e-01f, 1.27160728e-01f, 2.19609573e-01f,
  1.91807941e-01f, 1.24984078e-01f, 1.01799592e-01f, 1.87178046e-01f, 2.22184613e-01f, -1.69812083e-01f, -1.30713955e-01f, 1.41952217e-01f, 3.87789793e-02f, 2.27137536e-01f,
  -2.30305359e-01f, 6.91204844e-03f, -3.49786542e-02f, 6.19266778e-02f, 6.45062653e-04f, 1.11270040e-01f, -7.38420337e-02f, 1.47193000e-01f, 1.58756942e-01f, 1.59883872e-01f,
  1.56398147e-01f, -1.46104759e-02f, 6.74678758e-02f, -7.27940872e-02f, 3.86719505e-04f, 2.89330065e-01f, 9.69054252e-02f, 3.30708548e-02f, 2.36818030e-01f, -2.09048748e-01f,
  -2.32191592e-01f, 9.36214328e-02f, -3.42411026e-02f, 5.22148535e-02f, 3.71421836e-02f, 1.62059329e-02f, 1.22516705e-02f, 5.43699525e-02f, 8.50544199e-02f, -6.73245639e-02f,
  -4.10927646e-02f, -1.55022115e-01f, -1.10943429e-01f, -1.98498592e-01f, -9.43833031e-03f, -1.16544843e-01f, -1.65941305e-02f, -2.87701666e-01f, 1.15513198e-01f, -1.04485206e-01f,
  1.84178129e-02f, 1.77552313e-01f, -1.66109592e-01f, -1.56062290e-01f, 2.91473389e-01f, 3.43114659e-02f, 1.14036061e-01f, 1.68542773e-01f, -6.03153929e-02f, 7.53595605e-02f,
  -9.55234934e-03f, 4.26354744e-02f, -1.04818769e-01f, -7.92511329e-02f, 1.20840691e-01f, -9.13321972e-02f, 3.11628859e-02f, 2.14600444e-01f, -1.70036823e-01f, 1.26234129e-01f,
  -6.50839284e-02f, 2.05098644e-01f, -2.25872934e-01f, 2.10222299e-03f, 1.92594811e-01f, -1.03811264e-01f, 7.81749114e-02f, -4.75240462e-02f, 1.54809594e-01f, -9.00796205e-02f,
  1.35686249e-02f, -6.05725273e-02f, -7.93600008e-02f, -1.39388934e-01f, 5.53402342e-02f, -1.36636999e-02f, -6.41645193e-02f, 5.98895829e-04f, -3.79841588e-02f, -4.47417144e-03f,
  -1.47223175e-01f, 9.89126116e-02f, -1.03986472e-01f, 2.41507024e-01f, 2.80217789e-02f, -4.08997163e-02f, -1.48892254e-01f, 1.39394641e-01f, 1.62615806e-01f, 1.48794159e-01f,
  1.19141959e-01f, 1.47205800e-01f, -2.83969194e-02f, 1.55314788e-01f, 2.74767429e-01f, -1.86229110e-01f, -3.38454209e-02f, -3.84357646e-02f, 1.10324686e-02f, 8.31155181e-02f,
  -1.77746728e-01f, -1.48020372e-01f, -9.43551213e-02f, -1.43885147e-02f, 4.82756197e-02f, -1.02723688e-02f, 3.39876823e-02f, 1.35695208e-02f, 1.06313705e-01f, -7.42210895e-02f,
  -1.29127428e-02f, 1.12283044e-02f, -1.46853447e-01f, 1.51286438e-01f, -1.21057592e-02f, -2.81471666e-02f, -2.33924016e-01f, -3.11863571e-02f, 2.11288795e-01f, -2.44085923e-01f,
  -1.71656050e-02f, 1.12938546e-02f, 6.07618093e-02f, 9.26209018e-02f, -5.39019890e-02f, 1.42148938e-02f, -2.15999663e-01f, 8.30654576e-02f, -3.60999145e-02f, 1.04212426e-01f,
  1.14744365e-01f, 1.40661672e-01f, 1.17497733e-02f, -3.29438061e-01f, -7.90188741e-03f, 5.87262139e-02f, -4.37368080e-02f, -8.27925354e-02f, 1.09139152e-01f, -1.19477428e-01f,
  3.92066948e-02f, -1.12429917e-01f, -1.54647767e-03f, 2.27783114e-01f, -3.01744118e-02f, 1.95488036e-01f, -3.05831358e-02f, -2.23912802e-02f, -1.11076899e-01f, 2.05178093e-02f,
  -1.79922078e-02f, 4.99852709e-02f, -1.35257438e-01f, -3.35994773e-02f, -2.48640373e-01f, -3.88997458e-02f, -1.94444746e-01f, -2.32840195e-01f, 5.56492880e-02f, -3.12976167e-02f,
  8.12551081e-02f, -3.36111672e-02f, 1.05279259e-01f, -5.03772013e-02f, -8.08241367e-02f, 8.93448889e-02f, -1.09291300e-01f, -7.48879462e-02f, 1.22017592e-01f, 2.28427052e-02f,
  6.52197301e-02f, -3.76266330e-01f, 2.21795544e-01f, 9.80078205e-02f, -1.76696122e-01f, 7.70618618e-02f, -1.01880869e-02f, 2.60411706e-02f, -2.44425833e-02f, 1.30410150e-01f,
  1.51528031e-01f, 5.40080154e-03f, -1.71598420e-01f, 7.48340413e-02f, 1.08456142e-01f, 7.13130459e-03f, 4.27496508e-02f, 7.08470270e-02f, 8.02699700e-02f, -2.00747643e-02f,
  8.61458946e-03f, 4.87176143e-02f, 1.91778138e-01f, 6.01310432e-02f, -1.40906693e-02f, -1.61507711e-01f, -6.60520121e-02f, 1.10981844e-01f, -4.07688357e-02f, -6.37788400e-02f,
  3.15092392e-02f, -4.11235429e-02f, -2.82740965e-02f, 1.75517576e-04f, 1.18740752e-01f, 2.51715183e-01f, -4.55847047e-02f, -2.33974308e-01f, -2.27674041e-02f, 4.18133996e-02f,
  -6.95575122e-03f, 2.08006069e-01f, 1.44696474e-01f, -1.85713153e-02f, 1.69819444e-01f, -3.63656692e-02f, 2.89244223e-02f, -1.72652349e-01f, -5.95441321e-03f, -1.63816273e-01f,
  4.11820747e-02f, -3.66649665e-02f, -2.37421006e-01f, -1.97964966e-01f, 2.11552128e-01f, -1.62889481e-01f, 2.39833280e-01f, -7.02115670e-02f, 2.31198356e-01f, 9.88383144e-02f,
  1.10928230e-01f, 5.67394197e-02f, -7.31628016e-02f, -6.75014779e-02f, 8.26024786e-02f, -3.35571826e-01f, 2.14944333e-01f, 1.99006304e-01f, -1.06599843e-02f, 1.91138349e-02f,
  -8.90026987e-02f, -2.16660574e-02f, 2.37170607e-01f, 7.72364810e-03f, 8.73465016e-02f, 2.23099049e-02f, -7.30297193e-02f, 7.73946941e-02f, -2.17489861e-02f, 9.59352553e-02f,
  7.76060745e-02f, 1.67571083e-01f, -1.15513138e-01f, 2.51718983e-03f, -5.46995364e-02f, 6.76003098e-02f, 9.88434106e-02f, -4.41640131e-02f, -7.63250068e-02f, -2.55541056e-01f,
  2.00455576e-01f, -7.30496943e-02f, 1.69517137e-02f, 1.88653186e-01f, -1.96750581e-01f, 1.65746421e-01f, 5.34953997e-02f, -1.26813017e-02f, 1.70345530e-01f, -1.31172523e-01f,
  5.09019829e-02f, -7.99562782e-02f, -9.68187824e-02f, -1.06083220e-02f, 4.16866578e-02f, 8.62425491e-02f, -2.98174024e-01f, -5.17558083e-02f, 2.30499238e-01f, -3.91122978e-03f,
  6.81904331e-02f, 1.01088978e-01f, 1.91244349e-01f, 2.18686745e-01f, 1.56717911e-01f, 6.17845058e-02f, 1.38552338e-01f, -6.94461837e-02f, -1.56080917e-01f, 1.46888411e-02f,
  -1.92289501e-01f, 2.25841403e-02f, -1.13626145e-01f, -2.04967469e-01f, -8.07806253e-02f, 1.30373612e-01f, -8.85006040e-02f, 8.93497467e-02f, 7.62566626e-02f, 5.44803366e-02f,
  -7.39347562e-02f, 1.00635951e-02f, 1.19403256e-02f, 1.23178616e-01f, -1.94611703e-03f, 1.43660530e-01f, -4.12063301e-02f, -1.60074309e-01f, -1.51934102e-01f, -1.06487654e-01f,
  1.65661603e-01f, -1.17514551e-01f, 1.46472715e-02f, 9.03369784e-02f, 7.43931979e-02f, -4.97925002e-03f, 1.31221816e-01f, 1.84035629e-01f, -3.02210361e-01f, 7.92989060e-02f,
  3.19599807e-02f, 1.52045622e-01f, 7.10857585e-02f, 1.50222272e-01f, 1.16764925e-01f, -2.25282654e-01f, 1.26461282e-01f, 3.31297778e-02f, -4.49040197e-02f, -1.74538836e-01f,
  9.62528735e-02f, 4.87411097e-02f, -5.84568270e-02f, 7.33494237e-02f, 3.98891084e-02f, 2.21127659e-01f, 7.48686045e-02f, 1.96702912e-01f, -1.18041039e-01f, 7.53797442e-02f,
  -1.51924133e-01f, -1.00695100e-02f, 3.59429903e-02f, 8.73578563e-02f, -1.56601351e-02f, -5.95059758e-03f, 5.95675223e-02f, -8.63756239e-03f, -1.00666963e-01f, 4.27122265e-02f,
  -5.76641364e-03f, -2.12274760e-01f, -1.16443574e-01f, -3.45838144e-02f, -1.28764361e-01f, -1.89672440e-01f, -8.48210976e-02f, 1.68936267e-01f, 3.21367010e-02f, 1.17385991e-01f,
  3.15282375e-01f, 4.26126793e-02f, 4.47849371e-02f, 1.63235426e-01f, 1.47476405e-01f, 1.32941073e-02f, -6.89194947e-02f, 1.82543695e-02f, 1.59499139e-01f, -7.45127574e-02f,
  1.12655960e-01f, -4.98654274e-03f, -9.82643738e-02f, -5.60295135e-02f, 1.55915739e-02f, 5.62845618e-02f, 5.68120275e-03f, -5.25853410e-02f, 1.45131722e-01f, 2.81518605e-02f,
  9.28940028e-02f, 7.28206635e-02f, 3.63827273e-02f, 1.02970056e-01f, 2.07074717e-01f, 9.05732736e-02f, -9.69885215e-02f, -1.52073829e-02f, 6.01478256e-02f, 2.64540136e-01f,
  9.16529521e-02f, 1.23702116e-01f, -1.69816703e-01f, 7.66357630e-02f, -2.38378912e-01f, -1.57381803e-01f, 4.16911021e-02f, -8.16151425e-02f, 2.22220063e-01f, 6.32959753e-02f,
  -1.76936493e-03f, 1.24798588e-01f, 2.49956131e-01f, -2.44727843e-02f, 2.75950164e-01f, 7.74989426e-02f, 1.13029957e-01f, 3.69114764e-02f, -3.13793756e-02f, -9.14986506e-02f,
  -1.10017613e-03f, -5.99815585e-02f, 1.45345315e-01f, -7.80780613e-02f, -1.63659856e-01f, -3.17929983e-02f, 2.06744716e-01f, 4.52545360e-02f, 4.43456359e-02f, 1.81724906e-01f,
  2.05333367e-01f, -2.49730587e-01f, 1.15316369e-01f, 6.81737214e-02f, -9.34425369e-02f, -1.59523338e-02f, 1.97248235e-01f, 5.76192923e-02f, -8.30977038e-03f, 1.46201625e-01f,
  9.87368673e-02f, -8.24698433e-02f, -1.66573748e-01f, 1.33734480e-01f, -3.19025069e-02f, -4.48309630e-02f, 1.30332351e-01f, 1.26583353e-01f, 1.77946702e-01f, -8.13190937e-02f,
  -1.55703602e-02f, 1.94947228e-01f, -2.50594970e-02f, -1.56477004e-01f, -5.96155114e-02f, -1.10682353e-01f, -2.50774562e-01f, 9.51995999e-02f, -7.88448378e-03f, 4.21212278e-02f,
  -4.33920845e-02f, -1.57787278e-01f, 2.14536309e-01f, -6.74235523e-02f, 6.86962828e-02f, 2.53058553e-01f, -8.77286540e-04f, 2.46083766e-01f, 2.83466317e-02f, 2.06966072e-01f,
  1.85809940e-01f, 2.22033020e-02f, 2.21381988e-02f, 8.80209208e-02f, -3.63981468e-03f, 2.80202366e-02f, 4.36962619e-02f, 1.56315580e-01f, -2.71603137e-01f, -7.51871467e-02f,
  -6.16344847e-02f, -8.08045864e-02f, 1.19524114e-02f, 2.81279888e-02f, 3.00929472e-02f, -1.98619694e-01f, -1.29607722e-01f, 2.15193667e-02f, -1.43663168e-01f, 9.07495022e-02f,
  6.47613406e-02f, -8.22011977e-02f, 2.31567949e-01f, 1.14306360e-01f, -7.17526525e-02f, 2.51376450e-01f, 9.18998718e-02f, 1.72541752e-01f, 1.78382263e-01f, 1.64057374e-01f,
  -1.28131554e-01f, -5.50232232e-02f, 5.18328436e-02f, 1.35096181e-02f, -2.37169206e-01f, -1.24416202e-01f, 8.83195773e-02f, -2.16795638e-01f, 3.19235362e-02f, 9.14846882e-02f,
  1.88018620e-01f, 1.46996379e-01f, -2.75064319e-01f, 1.07563123e-01f, 1.31148681e-01f, 6.00707121e-02f, -3.46166715e-02f, 1.39199406e-01f, 4.03925106e-02f, -2.20327139e-01f,
  1.46501467e-01f, 8.00332054e-02f, 1.75326585e-03f, 1.33128345e-01f, 6.23901433e-04f, -4.60810810e-02f, -7.82993957e-02f, 2.48682112e-01f, 2.07524911e-01f, -1.20054603e-01f,
  -7.04846531e-02f, -1.40446305e-01f, -1.03323452e-01f, 4.92766127e-03f, 9.99933342e-04f, 3.31804603e-02f, 4.86430675e-02f, -1.09624742e-02f, 1.02118254e-01f, -2.91703939e-02f,
  -1.13907764e-02f, -7.33267739e-02f, 1.61423728e-01f, 7.08107501e-02f, 5.36827035e-02f, 8.35823640e-02f, -6.74331039e-02f, -2.06248760e-02f, 1.58001110e-01f, 6.86491504e-02f,
  1.48334488e-01f, 1.69645861e-01f, -1.84964761e-02f, -1.67618632e-01f, -1.54991880e-01f, -9.79878008e-02f, 1.58125445e-01f, -6.30504778e-03f, -7.16801137e-02f, 2.33417094e-01f,
  -5.80373853e-02f, 2.47671921e-02f, -2.81328678e-01f, 1.51823595e-01f, 3.38682272e-02f, -1.03268206e-01f, 1.38609171e-01f, -1.52213529e-01f, -2.49354332e-03f, 1.47524464e-03f,
  6.70344234e-02f, 7.72439167e-02f, 3.12364809e-02f, 1.58111125e-01f, 2.04160377e-01f, -1.31441578e-01f, 1.63460597e-01f, -2.16159020e-02f, -9.55348536e-02f, 1.21481232e-01f,
  1.00165740e-01f, -1.79360379e-02f, 2.16554418e-01f, 6.60637692e-02f, 1.47410095e-01f, -1.06349297e-01f, 1.65085331e-01f, -5.44023234e-03f, 2.80009687e-01f, -6.61576167e-02f,
  7.29445070e-02f, -2.31166229e-01f, 1.10815302e-01f, 1.12127416e-01f, 7.29753869e-03f, -1.07133305e-02f, 2.84924477e-01f, -6.45944923e-02f, 5.07107340e-02f, 1.35903329e-01f,
  5.16709723e-02f, 1.64980069e-01f, -4.62578945e-02f, 2.03613997e-01f, -6.59205914e-02f, 2.09962443e-01f, -2.15341568e-01f, 4.40922417e-02f, 6.97867423e-02f, -1.03726452e-02f,
  -1.58170182e-02f, -1.02456458e-01f, 4.38603461e-02f, -4.21876609e-02f, 7.73316175e-02f, -1.44471139e-01f, 6.23647906e-02f, -3.01485378e-02f, -5.71879521e-02f, 2.21041124e-02f,
  7.55573511e-02f, 2.16869339e-02f, 4.22650622e-03f, 2.87330896e-03f, 1.47491604e-01f, 4.49351110e-02f, 2.51824260e-01f, -1.71396524e-01f, 1.14494383e-01f, 1.57781363e-01f,
  -1.68290421e-01f, 4.40050438e-02f, -3.20238248e-02f, -6.09644204e-02f, 4.01301645e-02f, -1.81291267e-01f, 1.16602093e-01f, -5.24774678e-02f, 1.30240202e-01f, 1.74806237e-01f,
  -7.88525343e-02f, -2.00323155e-03f, 2.37670466e-01f, -1.75247975e-02f, 8.45251009e-02f, 1.55752212e-01f, -1.13407508e-01f, 3.42045538e-02f, -1.01663701e-01f, -4.88427468e-02f,
  -2.31676586e-02f, 7.04986230e-02f, -1.95643067e-01f, 4.02921028e-02f, 3.57186608e-02f, 2.39986449e-01f, 4.42625664e-04f, 1.23074755e-01f, -6.61510825e-02f, 6.40681908e-02f,
  -2.11904749e-01f, -2.43340552e-01f, 3.45496833e-02f, -1.51398420e-01f, 1.89138666e-01f, 1.66885592e-02f, 1.45399347e-01f, -7.09902076e-03f, 1.00125372e-01f, -1.38913497e-01f,
  2.25592360e-01f, 1.98690310e-01f, 6.47639297e-03f, 1.46866381e-01f, 2.26123817e-02f, 1.14820041e-01f, 5.02833426e-02f, 1.90649256e-02f, 3.26446407e-02f, 8.81458968e-02f,
  1.96393117e-01f, -5.54081937e-03f, -2.67578829e-02f, 9.99975353e-02f, -4.46078144e-02f, -9.66369733e-02f, -1.68304101e-01f, 1.56204283e-01f, 7.33986322e-04f, 1.23953469e-01f,
  2.86650080e-02f, -6.51602149e-02f, -2.05478594e-02f, 2.67016530e-01f, -1.49109393e-01f, 6.21817410e-02f, -1.55760944e-02f, 8.09759423e-02f, 3.17020565e-02f, 8.56833681e-02f,
  -2.75074951e-02f, 3.66078578e-02f, -5.24851866e-02f, 5.38169406e-02f, -1.44007981e-01f, -6.04541562e-02f, 1.01937540e-01f, 1.45633668e-01f, 1.76758111e-01f, -6.76591024e-02f,
  -6.61913827e-02f, 1.45176694e-01f, -1.92875087e-01f, 8.41010734e-02f, -1.24732345e-01f, -5.36522223e-03f, -5.27859926e-02f, 6.05687164e-02f, 1.15927279e-01f, 3.87273282e-02f,
  -2.29998920e-02f, -1.49829518e-02f, -2.83036549e-02f, -7.73265064e-02f, 7.62383193e-02f, -6.26791418e-02f, -1.17751390e-01f, -2.07905218e-01f, -8.59575197e-02f, 2.27106735e-02f,
  1.40080974e-01f, -2.99889259e-02f, 2.15589643e-01f, -2.13275030e-01f, 1.52596921e-01f, -2.22394317e-02f, 1.05400808e-01f, 1.98194727e-01f, 5.19369692e-02f, -1.02467677e-02f,
  1.83829069e-01f, 1.60812512e-01f, 6.53348416e-02f, 9.00797993e-02f, 2.01742128e-01f, -2.14865897e-02f, -1.98186174e-01f, 1.15829147e-01f, -3.22024487e-02f, -1.54125363e-01f,
  -1.09056517e-01f, -2.77508587e-01f, -6.52139857e-02f, -8.56805686e-03f, 8.74611661e-02f, 4.62376736e-02f, 7.47514367e-02f, 3.04769892e-02f, 1.46988496e-01f, -1.01220794e-01f,
  1.98997602e-01f, 1.10029094e-01f, 1.73517227e-01f, 1.31067142e-01f, -1.79551780e-01f, -2.15169206e-01f, -1.76878408e-01f, -1.61435097e-01f, 1.93860784e-01f, -1.66632831e-01f,
  6.87104464e-02f, -4.12202626e-02f, 1.88469708e-01f, 4.89749610e-02f, -4.27219905e-02f, 1.78914577e-01f, -1.36298567e-01f, 1.46631658e-01f, 2.25094393e-01f, 4.92685065e-02f,
  1.97513744e-01f, 2.17410788e-01f, 1.17524024e-02f, 3.39461342e-02f, 5.00403903e-02f, -2.08735727e-02f, 3.69562395e-02f, -2.09645838e-01f, -1.02005538e-03f, 2.75121164e-02f,
  -9.43546146e-02f, 1.93627313e-01f, -2.08062008e-01f, 1.78007647e-01f, 1.57779619e-01f, 4.06317785e-02f, -7.77925327e-02f, 1.73698273e-02f, 1.97862104e-01f, -6.94899708e-02f,
  -7.98451826e-02f, 7.07273930e-02f, -1.63988486e-01f, -1.24983542e-01f, -1.54494420e-01f, 2.60584317e-02f, -1.84064824e-02f, -1.48089498e-01f, 3.42405289e-02f, 5.12153879e-02f,
  -1.03701115e-01f, 2.30758384e-01f, 8.59492421e-02f, -1.24931432e-01f, 1.27172722e-02f, 2.32862439e-02f, 4.93213348e-02f, -1.05877951e-01f, 2.83183426e-01f, -1.45314470e-01f,
  1.28907651e-01f, -1.33184791e-01f, -2.01419160e-01f, 1.31766483e-01f, 7.23577663e-02f, 1.00652836e-01f, 1.66017100e-01f, 1.04186855e-01f, -1.33712515e-01f, -5.41199036e-02f,
  2.52327621e-01f, 1.64697215e-01f, -1.48845240e-01f, 2.42721483e-01f, 1.89433530e-01f, 5.27055971e-02f, -1.27530554e-02f, -6.57071620e-02f, 1.88753605e-02f, -4.50273231e-02f,
  -1.88465804e-01f, 1.43082678e-01f, 8.28755796e-02f, 2.75574089e-03f, -6.09192103e-02f, 2.70047076e-02f, -1.66451205e-02f, 3.67442101e-01f, 4.44646887e-02f, 2.82406379e-02f,
  -6.98435903e-02f, 1.24069393e-01f, -2.34816354e-02f, 2.00577870e-01f, -1.04876742e-01f, 1.90234259e-01f, 4.05062921e-02f, -1.23480387e-01f, 8.66368264e-02f, -6.58417866e-02f,
  1.05589285e-01f, 3.39033641e-02f, 2.96914697e-01f, 4.89824638e-02f, 9.79118142e-03f, 3.49177010e-02f, 2.57415082e-02f, 1.01351857e-01f, 3.59723382e-02f, 2.18777508e-01f,
  1.14821799e-01f, 1.36732776e-03f, 1.64699614e-01f, -1.97091773e-01f, 1.12239383e-01f, -7.12057725e-02f, -1.36984855e-01f, -1.89877432e-02f, 8.11806172e-02f, 2.15204388e-01f,
  1.98871538e-01f, 3.83767158e-01f, -3.69549803e-02f, -6.22511692e-02f, -7.98206180e-02f, 1.16735272e-01f, -3.87728959e-02f, 4.33130562e-02f, 1.36265576e-01f, -2.10746508e-02f,
  -7.93268438e-03f, 6.72269473e-03f, 2.06195503e-01f, -1.59891695e-02f, -2.64558122e-02f, -1.11321807e-01f, -6.67245910e-02f, 3.75495665e-02f, 6.33703172e-02f, 9.72195417e-02f,
  9.41043496e-02f, -1.40665889e-01f, -6.59546033e-02f, 1.70061693e-01f, 2.58489817e-01f, 3.48220468e-02f, 1.63677186e-01f, 8.90520811e-02f, 8.90715495e-02f, -1.54641885e-02f,
  2.61036277e-01f, -1.89774171e-01f, 7.29877055e-02f, -6.84424536e-03f, 5.92808500e-02f, 1.60787385e-02f, 1.42335311e-01f, -6.58408329e-02f, 1.77670985e-01f, -2.15596542e-01f,
  9.79492906e-05f, 8.76277760e-02f, -3.80163155e-02f, 1.18130252e-01f, -5.98551240e-03f, -8.91439170e-02f, -2.26910368e-01f, 1.93033844e-01f, -8.42775106e-02f, 1.81149706e-01f,
  8.63887221e-02f, -2.81820018e-02f, 4.69238758e-02f, 1.25077695e-01f, 2.21221540e-02f, 1.68320447e-01f, 1.12945355e-01f, 1.34171292e-01f, 3.64966765e-02f, -3.18784676e-02f,
  1.08059980e-01f, 2.02536330e-01f, 1.01469018e-01f, 4.68645208e-02f, -9.16877314e-02f, 2.67770857e-01f, -1.82187229e-01f, -5.55976257e-02f, -3.91261764e-02f, 1.06899716e-01f,
  4.92489114e-02f, -8.88014734e-02f, 8.56446289e-03f, 1.35645485e-02f, -2.37051770e-01f, 8.32320601e-02f, 2.21017966e-04f, -1.38339773e-02f, -3.50827314e-02f, 7.31619298e-02f,
  -4.17768070e-03f, -8.15225840e-02f, -9.49009359e-02f, 2.32716709e-01f, 8.35141018e-02f, -1.40863061e-01f, 1.70353651e-01f, 4.69968133e-02f, -8.69659148e-03f, 4.33592349e-02f,
  -6.46768659e-02f, 7.50377402e-02f, 1.80584967e-01f, 1.35932257e-02f, 7.24828169e-02f, -1.38902590e-01f, 4.39805351e-02f, 7.43033141e-02f, 1.42210573e-01f, -7.14221895e-02f,
  2.76828229e-01f, 2.29605868e-01f, -1.90304905e-01f, 1.22948326e-01f, -2.81168632e-02f, 1.85372084e-01f, -1.50270713e-02f, 3.72765474e-02f, -2.88869590e-02f, 1.57654248e-02f,
  -3.63313019e-01f, -8.97990987e-02f, -1.64013699e-01f, 1.49008080e-01f, -1.21611923e-01f, 1.66670972e-04f, 1.35478035e-01f, -1.50856590e-02f, 9.03857574e-02f, 1.26741022e-01f,
  1.40462339e-01f, -1.77231520e-01f, 9.60458741e-02f, -1.13755919e-01f, -5.79159223e-02f, -6.18918389e-02f, 4.74390015e-02f, -1.05579965e-01f, 2.43904069e-01f, -2.77882107e-02f,
  1.68252289e-01f, -4.15340438e-02f, -2.28208629e-03f, 1.33513570e-01f, 1.15970774e-02f, 2.12155789e-01f, 1.13495924e-01f, 1.42344877e-01f, 1.53865442e-01f, -1.20212033e-01f,
  1.76672488e-01f, -6.23968318e-02f, 1.50626823e-01f, 2.02383280e-01f, -5.11209443e-02f, -9.03237164e-02f, 1.18501119e-01f, 1.64000660e-01f, 1.42802283e-01f, 2.11356372e-01f,
  -1.28170431e-01f, 1.69514805e-01f, -1.98704302e-01f, 7.52870142e-02f, 4.20533344e-02f, -1.84124321e-01f, 3.11936103e-02f, -1.25933900e-01f, 1.22556612e-01f, 1.63870871e-01f,
  -1.73182905e-01f, 5.76567650e-02f, -1.57166258e-01f, 2.02193007e-01f, -1.05821677e-01f, -1.78098544e-01f, 1.54308558e-01f, -1.74175531e-01f, 1.68077081e-01f, 1.16245247e-01f,
  1.14034884e-01f, 1.21941812e-01f, 1.67889863e-01f, 1.18015677e-01f, -1.73991993e-02f, 2.00344369e-01f, 2.59985644e-02f, 2.00300440e-01f, -5.18028537e-05f, 9.59977284e-02f,
  2.17804909e-01f, 4.56468388e-02f, 1.33936226e-01f, 1.14825301e-01f, 1.08605884e-02f, 2.61078477e-01f, -9.39417705e-02f, 2.29174510e-01f, 1.76445581e-02f, 2.43981674e-01f,
  1.38030708e-01f, -2.43592262e-02f, -1.73803538e-01f, 2.31959634e-02f, -2.35600118e-02f, -1.60393879e-01f, 1.69687480e-01f, 3.54863927e-02f, -1.13965414e-01f, 1.43887168e-02f,
  -6.23807237e-02f, -1.67267591e-01f, -2.00621888e-01f, 7.72723779e-02f, -2.15145022e-01f, -1.30921587e-01f, 1.72961369e-01f, 1.16420150e-01f, 2.77932912e-01f, 6.39158264e-02f,
  1.28376922e-02f, -3.29636261e-02f, 2.78233081e-01f, -1.39699534e-01f, -1.03899054e-01f, 1.09086707e-02f, -4.57865186e-02f, 1.75788552e-01f, -1.84594050e-01f, 4.57070619e-02f,
  3.36192958e-02f, 1.14113642e-02f, 1.25022754e-01f, -1.57289505e-01f, 9.53871682e-02f, 3.15058708e-01f, 5.86910918e-02f, 1.96993202e-01f, 2.32580930e-01f, 1.39248475e-01f,
  -6.72997069e-03f, -7.03204125e-02f, -7.10133165e-02f, 2.27643073e-01f, 2.51162291e-01f, -1.27871007e-01f, 7.22725503e-03f, 1.61751434e-02f, -1.69242531e-01f, 2.99214735e-05f,
  -3.32515687e-02f, -9.77143412e-04f, 1.43223122e-01f, 1.62931174e-01f, 1.92171901e-01f, 2.01393843e-01f, -2.87927352e-02f, 6.65180087e-02f, 1.43197596e-01f, -6.95034787e-02f,
  1.01662621e-01f, 2.17418605e-03f, -2.70440042e-01f, -8.95841047e-03f, -2.41208710e-02f, 2.33715214e-02f, 1.02886714e-01f, 4.52049404e-01f, -2.52640601e-02f, -9.12672654e-02f,
  -2.90304348e-02f, 3.66108537e-01f, 9.58494395e-02f, -6.19637966e-02f, 1.29597276e-01f, 7.14711696e-02f, 1.00155368e-01f, -5.73005304e-02f, 1.21157140e-01f, -1.97600331e-02f,
  -4.54495773e-02f, 6.57851025e-02f, -5.37480116e-02f, -1.69306412e-01f, -1.26695065e-02f, 1.68879360e-01f, 6.31807139e-03f, -1.07404433e-01f, -6.50156215e-02f, 3.02623454e-02f,
  1.72198325e-01f, 2.01011285e-01f, -1.64357573e-02f, 1.35637492e-01f, -9.81566459e-02f, 1.08437076e-01f, 2.32403547e-01f, 3.17614824e-02f, -4.86417965e-04f, 5.28647006e-02f,
  2.26784647e-02f, -3.30093154e-03f, 1.74894378e-01f, -1.30162342e-02f, -1.39575487e-03f, -1.31978974e-01f, -2.21007131e-02f, 3.25096697e-01f, -1.00920850e-03f, 2.72386283e-01f,
  -8.36216062e-02f, 4.65500954e-04f, -2.55238682e-01f, 1.36953861e-01f, 6.14039078e-02f, 5.67581318e-02f, -8.04466829e-02f, 4.02376167e-02f, 1.60855561e-01f, 5.68673015e-02f,
  1.52260616e-01f, 9.18716043e-02f, 4.26574610e-03f, 8.45735073e-02f, -4.01810184e-02f, 1.27603665e-01f, -5.64928874e-02f, -1.57736033e-01f, 3.53047885e-02f, -1.02123857e-01f,
  -1.16884075e-01f, -1.84631109e-01f, -8.99893939e-02f, -2.20219463e-01f, 2.30737299e-01f, -1.26582295e-01f, -2.86331046e-02f, 1.97166607e-01f, 2.55550887e-03f, 3.94268939e-03f,
  1.58991605e-01f, 1.80130035e-01f, -1.04675703e-01f, -1.73662335e-01f, 7.48344213e-02f, -1.26899118e-02f, 1.01339817e-01f, 1.95992723e-01f, 1.25995681e-01f, -2.24141553e-02f,
  1.32412821e-01f, 2.13052869e-01f, -5.38180061e-02f, -9.01637599e-02f, -8.69161338e-02f, 1.44765854e-01f, -7.55382031e-02f, -1.41497999e-01f, -1.50049729e-02f, 1.10211641e-01f,
  4.41881530e-02f, -3.28192227e-02f, -2.40430668e-01f, 2.02007741e-01f, 4.27725399e-03f, -1.84519142e-02f, -1.62275136e-01f, 8.16885531e-02f, -3.42856273e-02f, -2.47507207e-02f,
  1.54354602e-01f, -4.29175235e-02f, 2.33028814e-01f, -2.05065995e-01f, 7.29642585e-02f, -1.63698211e-01f, 7.20311850e-02f, 1.58592328e-01f, 1.93982139e-01f, -4.09667157e-02f,
  1.52542844e-01f, -8.20300356e-02f, -9.03734192e-02f, 9.10008326e-02f, 1.27816573e-01f, 9.18138400e-02f, 2.00039849e-01f, -1.13737397e-02f, -1.09136499e-01f, -1.31703243e-01f,
  1.62891537e-01f, 8.32941383e-02f, -1.53703436e-01f, -2.43443832e-01f, -1.30292937e-01f, -1.67052880e-01f, -1.08774416e-01f, -5.34708202e-02f, 2.27827579e-01f, -1.22440439e-02f,
  2.14737996e-01f, -1.37660518e-01f, 1.03007533e-01f, 1.92847192e-01f, -1.44699335e-01f, 2.77894765e-01f, -2.48873949e-01f, 5.41047938e-03f, 1.80979282e-01f, 3.89549397e-02f,
  2.80420631e-01f, 3.80172096e-02f, -1.23595513e-01f, 2.17553243e-01f, 2.96176486e-02f, 2.65760925e-02f, -1.95144136e-02f, 5.10021672e-02f, -3.19243282e-01f, 7.02218935e-02f,
  -3.04598138e-02f, -7.03598857e-02f, 9.32662562e-02f, 9.53607783e-02f, -1.00634456e-01f, -2.88395345e-01f, -1.03842402e-02f, 1.36006221e-01f, -4.26141918e-03f, -3.98391671e-02f,
  2.21198469e-01f, 7.14494884e-02f, -2.95766648e-02f, 1.02396514e-02f, -1.60458967e-01f, 1.62579864e-01f, 4.65405881e-02f, 5.33876047e-02f, -1.76218316e-01f, 1.65305212e-02f,
  -1.18570119e-01f, -2.26944745e-01f, 3.88641320e-02f, 8.76284540e-02f, -1.05888061e-02f, 1.66047245e-01f, -1.12586021e-01f, 8.79525468e-02f, 6.47203550e-02f, 7.22423792e-02f,
  8.34759250e-02f, -2.71480847e-02f, -1.83437750e-01f, -3.49451564e-02f, 2.04909414e-01f, 1.20044373e-01f, -1.71551853e-01f, 2.02650530e-03f, 1.50966784e-02f, 3.55957001e-02f,
  2.66817790e-02f, 2.25966632e-01f, -8.71357918e-02f, -2.41781503e-01f, 1.22941911e-01f, -1.92224786e-01f, 2.51881719e-01f, 2.98860162e-01f, 6.42422661e-02f, 8.53530765e-02f,
  -1.57494634e-01f, 3.12183648e-01f, 1.75384253e-01f, -1.80544630e-01f, 4.48806249e-02f, 2.45372012e-01f, -5.11684120e-02f, -5.71664348e-02f, -1.31856412e-01f, 2.44784579e-01f,
  1.98359936e-01f, 4.29036692e-02f, 1.31844297e-01f, -2.18906701e-01f, 2.58169889e-01f, 2.24760950e-01f, 1.48883611e-01f, 1.72816873e-01f, -2.66729575e-02f, -6.14679744e-03f,
  2.66541600e-01f, -5.27001135e-02f, 4.26829793e-02f, -2.72385240e-01f, -1.27532613e-03f, 1.98767409e-01f, 1.00318633e-01f, 1.62317738e-01f, -2.60180593e-01f, -1.00363210e-01f,
  3.47467251e-02f, 6.40478805e-02f, -1.98370576e-01f, 1.29261166e-01f, -4.47826385e-02f, -1.24468068e-02f, -6.30033985e-02f, 1.35120586e-03f, 1.16467386e-01f, 9.66270342e-02f,
  -2.26413384e-02f, -2.06766673e-03f, 1.37217805e-01f, 3.93646024e-02f, 1.81350261e-02f, 2.39067540e-01f, -1.26482740e-01f, 5.61999492e-02f, 4.81900899e-03f, 1.27599031e-01f,
  8.00763220e-02f, 1.24990717e-01f, -1.15076415e-01f, -3.47036347e-02f, -5.29602766e-02f, -2.10862793e-02f, 1.92608997e-01f, 1.01848319e-01f, -1.24181092e-01f, 7.14997947e-02f,
  -2.03202441e-01f, 1.86995473e-02f, 5.20300083e-02f, -1.48602491e-02f, -9.60620642e-02f, 9.89472345e-02f, 2.12933853e-01f, 1.90847665e-01f, 7.95618594e-02f, 1.02560900e-01f,
  8.33397880e-02f, 4.46779765e-02f, -2.05255542e-02f, -1.49085924e-01f, -2.95194741e-02f, -1.57105736e-02f, -1.48950994e-01f, -6.68957606e-02f, -1.50777742e-01f, -3.59005220e-02f,
  1.81385368e-01f, -1.67443663e-01f, -5.69723099e-02f, 8.84273052e-02f, 4.05648574e-02f, 1.98815063e-01f, 6.91179931e-02f, -9.03509036e-02f, 2.02744365e-01f, 1.79176107e-01f,
  -4.60052714e-02f, 6.60231933e-02f, 3.75238247e-02f, 1.96305197e-02f, 1.81225225e-01f, 4.02121134e-02f, -6.57549500e-02f, -2.63434853e-02f, -1.15304356e-02f, -1.85138345e-01f,
  7.61602968e-02f, 1.63403064e-01f, 1.24817878e-01f, 7.84491599e-02f, 8.19793940e-02f, 2.02317238e-01f, 1.63226336e-01f, 1.70620978e-01f, 1.56305790e-01f, 1.04820728e-01f,
  2.47861296e-02f, 2.58116990e-01f, -9.19579566e-02f, -1.03207426e-02f, -1.20158710e-01f, 1.11995086e-01f, -5.44807017e-02f, 5.22840321e-02f, 2.45065883e-01f, -1.91430226e-01f,
  1.82682574e-01f, 1.17821373e-01f, -1.45895079e-01f, -8.03510994e-02f, 4.71910350e-02f, 3.59856188e-02f, 2.00338587e-01f, 1.24252498e-01f, -3.48355956e-02f, 2.13918723e-02f,
  -2.24701270e-01f, 5.12460284e-02f, -4.65452075e-02f, 3.79862613e-03f, 2.74587050e-02f, -4.99864854e-02f, 1.76271021e-01f, 1.15357876e-01f, 2.18150597e-02f, -9.82727669e-03f,
  -6.60575107e-02f, 1.03861369e-01f, 6.70348927e-02f, 9.11342055e-02f, 1.94837674e-02f, 2.84306765e-01f, 2.60504950e-02f, 9.53093320e-02f, -5.40698394e-02f, 6.80566803e-02f,
  7.09007904e-02f, -5.04363328e-02f, 1.04970001e-01f, -9.66093987e-02f, -7.53124207e-02f, -7.59305209e-02f, 9.91091728e-02f, 1.12036914e-01f, 2.30820477e-01f, 9.45084076e-03f,
  1.58726841e-01f, -1.09975256e-01f, 7.31264353e-02f, 1.68808222e-01f, 6.74391165e-02f, 6.38087764e-02f, 1.79726079e-01f, 9.39039886e-02f, 6.03188388e-02f, -5.43233678e-02f,
  9.78507325e-02f, -8.15802515e-02f, -2.62991488e-01f, 2.01711863e-01f, -1.10430978e-01f, 2.17574984e-02f, 1.09052926e-01f, 1.87679857e-01f, 2.38594994e-01f, 6.95129558e-02f,
  -1.22688845e-01f, 1.21675946e-01f, -8.49182978e-02f, 8.81877467e-02f, 4.13675793e-02f, -2.82333288e-02f, -8.53209272e-02f, 1.03691563e-01f, 7.91662186e-02f, -4.51408662e-02f,
  1.57931373e-02f, 1.76450774e-01f, -1.63296863e-01f, 1.79127142e-01f, 1.69537976e-01f, 4.49478403e-02f, 1.00931711e-01f, 1.45484492e-01f, 8.88679624e-02f, -7.33422190e-02f,
  2.06599608e-02f, 2.80909967e-02f, 1.45650536e-01f, -1.22460656e-01f, 6.05935231e-02f, -3.22515443e-02f, -7.99292997e-02f, 3.50290502e-04f, 1.14724129e-01f, -5.11200167e-02f,
  -1.22661971e-01f, -5.46565689e-02f, 2.52474472e-02f, 3.85803096e-02f, 1.96085528e-01f, 1.42557770e-01f, 5.51510155e-02f, -6.20096782e-03f, 7.85484314e-02f, 7.08189234e-02f,
  1.10962905e-01f, -1.96294505e-02f, 1.35973409e-01f, -4.09956649e-02f, -7.79650509e-02f, 3.58757935e-03f, -3.02629769e-02f, 1.37861684e-01f, 8.09550881e-02f, -1.66885480e-01f,
  -6.82215318e-02f, 1.36479974e-01f, -3.62632610e-03f, -6.23375103e-02f, 5.86877875e-02f, -4.18702029e-02f, -1.34774715e-01f, 1.17037691e-01f, -8.01459253e-02f, 1.14104912e-01f,
  -1.80676043e-01f, -2.42617037e-02f, 1.74990207e-01f, -2.72461981e-01f, -1.07022069e-01f, -2.64915466e-01f, -6.69880882e-02f, 8.04681033e-02f, 1.97912037e-01f, -1.26567408e-01f,
  1.63473021e-02f, 1.48385793e-01f, 1.95053846e-01f, 1.15216352e-01f, 1.99207649e-01f, 1.91913828e-01f, 3.56470197e-02f, -1.01408176e-01f, -9.08352882e-02f, 1.32680103e-01f,
  1.04087889e-01f, 1.60547554e-01f, 1.63168281e-01f, -1.09986112e-01f, 2.39347126e-02f, 1.67978138e-01f, -1.35492340e-01f, -4.60689748e-03f, -1.49850130e-01f, 1.63703009e-01f,
  1.27684042e-01f, 2.52434574e-02f, -7.08644688e-02f, 1.85803734e-02f, 2.50413362e-02f, -1.87695518e-01f, -2.13383347e-01f, 4.99781035e-02f, 8.55015740e-02f, 1.84979543e-01f,
  -2.39894271e-01f, -6.10292964e-02f, 2.98674274e-02f, 3.21961218e-03f, 1.50609419e-01f, -1.87008128e-01f, 1.31788895e-01f, -1.21730290e-01f, -9.68334079e-03f, -3.90410051e-02f,
  8.15356970e-02f, 2.01534614e-01f, 6.19871654e-02f, -1.34230703e-01f, -1.33514538e-01f, -1.14606097e-01f, -8.19128528e-02f, -1.26066938e-01f, 5.60326735e-03f, -8.94898996e-02f,
  -1.94183271e-02f, -1.13005407e-01f, 1.32001370e-01f, -7.50780031e-02f, -3.70077416e-02f, 1.18598096e-01f, 1.23085089e-01f, 1.68171808e-01f, 1.64559394e-01f, 5.24279959e-02f,
  1.08133368e-01f, -1.32531049e-02f, 1.98717117e-02f, -1.16179526e-01f, -4.36325409e-02f, 1.96973816e-01f, -1.29077330e-01f, -1.04987927e-01f, -7.28399903e-02f, -9.36106741e-02f,
  2.41050288e-01f, -4.05367687e-02f, 4.61192876e-02f, 5.46259806e-02f, -1.22403763e-01f, 4.51410189e-02f, -2.93082595e-02f, 2.63398979e-02f, -3.21280621e-02f, -2.08101831e-02f,
  6.50539845e-02f, -9.04230848e-02f, -3.72432694e-02f, -6.50688075e-03f, 3.85868642e-03f, -1.09422496e-02f, -1.54795840e-01f, -3.45848143e-01f, 8.40889290e-02f, 6.30745292e-02f,
  4.69842330e-02f, 1.49497166e-01f, -1.91646159e-01f, 8.86413828e-02f, -6.94646165e-02f, -9.31658410e-03f, 2.06189957e-02f, -1.19466763e-02f, 1.73062921e-01f, 5.64151593e-02f,
  2.21134610e-02f, 5.08212447e-02f, 1.38113007e-01f, 2.33469099e-01f, -2.90840775e-01f, 8.99077356e-02f, 9.24407840e-02f, 6.42554536e-02f, 8.46061856e-02f, -3.36553040e-03f,
  7.26728961e-02f, 1.51469573e-01f, 6.70250729e-02f, -3.13756689e-02f, 1.27688035e-01f, -3.07299588e-02f, 1.73589632e-01f, -1.63535833e-01f, -1.83132052e-01f, -6.55220598e-02f,
  -8.51523280e-02f, -2.66577393e-01f, 4.64902557e-02f, -1.68777257e-02f, -1.44108966e-01f, -3.86431180e-02f, 1.19981676e-01f, 1.64281926e-03f, 1.38362557e-01f, 8.65985155e-02f,
  8.81032571e-02f, 2.04573154e-01f, -5.01758531e-02f, 9.83125567e-02f, 3.87509465e-02f, 1.55724296e-02f, 1.20198928e-01f, 6.47786912e-03f, 7.43608773e-02f, -1.43942863e-01f,
  -1.77640721e-01f, 1.82785466e-01f, -7.90894702e-02f, -1.16027847e-01f, -1.32202044e-01f, 5.16887195e-02f, -1.88829511e-01f, 1.64439946e-01f, -1.19834049e-02f, -1.33914739e-01f,
  1.04432076e-01f, -5.58738783e-02f, 7.99476057e-02f, -6.43837005e-02f, -5.90909757e-02f, -7.89093897e-02f, 1.23755634e-01f, -3.99423689e-02f, 3.88650298e-02f, -4.96412665e-02f,
  -2.25029010e-02f, 7.11555481e-02f, 3.68814310e-03f, 1.72668219e-01f, -3.77524234e-02f, 2.23199144e-01f, 5.64803034e-02f, 1.50049120e-01f, -2.67708063e-01f, 1.31535068e-01f,
  -1.58622175e-01f, 1.62739977e-01f, -1.03642717e-01f, 3.84322219e-02f, 6.98063383e-03f, -2.60483623e-02f, 3.65544669e-02f, -8.06836262e-02f, 1.61852747e-01f, 7.87426904e-02f,
  -2.24533509e-02f, -3.63298170e-02f, -1.02343643e-02f, -1.59224868e-01f, -1.76112041e-01f, 1.84218690e-01f, -7.83147737e-02f, 3.83064337e-02f, 2.36082092e-01f, 2.12322429e-01f,
  -1.24470070e-01f, -6.73563257e-02f, 1.22384526e-01f, -3.71426716e-02f, 1.95560679e-01f, 2.14560032e-01f, 1.73341930e-01f, 2.95616146e-02f, -1.03073299e-01f, 2.90042698e-01f,
  2.10024133e-01f, 3.50898467e-02f, -1.36733532e-01f, 2.19674110e-01f, 1.56598896e-01f, -1.25904512e-02f, -5.71154170e-02f, 1.50642186e-01f, 1.51921853e-01f, 1.51319325e-01f,
  2.28436768e-01f, -1.08181953e-01f, 2.21370474e-01f, 1.63632810e-01f, -6.28713984e-03f, -5.03400229e-02f, -1.14579290e-01f, 2.81918287e-01f, 1.40564457e-01f, -1.89063028e-01f,
  -9.34157968e-02f, -1.98627606e-01f, -1.88021399e-02f, 1.85576200e-01f, 4.38374653e-02f, 1.62938029e-01f, 8.34802389e-02f, -1.50164992e-01f, 1.64517075e-01f, 2.41444796e-01f,
  4.62357998e-02f, 2.28295803e-01f, 1.06811635e-01f, 1.50221139e-02f, -8.41596499e-02f, 3.13017853e-02f, -8.00027251e-02f, -1.79589033e-01f, -6.98814765e-02f, -6.34083301e-02f,
  5.08567244e-02f, -4.77074869e-02f, 2.08751068e-01f, -1.79449290e-01f, -6.15679026e-02f, -1.67577818e-01f, -1.65723696e-01f, -5.48588112e-03f, -5.71965091e-02f, 1.45691738e-01f,
  1.06198408e-01f, 5.91425896e-02f, 2.35880166e-01f, -2.39987690e-02f, -1.61980435e-01f, 1.06339738e-01f, 8.14993903e-02f, -6.25340641e-02f, 1.38174117e-01f, 6.63802996e-02f,
  -2.21569296e-02f, -9.86344591e-02f, 7.62450844e-02f, -5.64234965e-02f, -1.20312134e-02f, -1.52539760e-02f, -1.47545621e-01f, -1.20732307e-01f, 9.45865288e-02f, 1.96247846e-01f,
  -1.12610526e-01f, 1.60787731e-01f, -1.53938279e-01f, 6.88847825e-02f, -1.03874505e-02f, 4.77587283e-02f, 1.47820622e-01f, 2.69059129e-02f, -3.19594443e-02f, 8.58148560e-03f,
  1.34320378e-01f, 1.33606613e-01f, 2.68023424e-02f, -6.40256330e-02f, -2.13074356e-01f, 7.66578764e-02f, -2.09809616e-02f, -5.22908680e-02f, 1.55401587e-01f, -4.17550616e-02f,
  1.23612089e-02f, 3.56588103e-02f, -4.76066954e-02f, 4.39024046e-02f, 1.31271139e-01f, 1.43814117e-01f, 1.50515810e-01f, 1.26640961e-01f, -5.31976819e-02f, 2.04457939e-01f,
  2.37282082e-01f, -1.12072863e-01f, 1.68184176e-01f, 4.35807556e-02f, 1.82633817e-01f, -4.12017368e-02f, 1.49961542e-02f, 1.01045556e-01f, -1.73848361e-01f, 2.36602068e-01f,
  -2.40620375e-01f, -1.33070676e-02f, -9.15709287e-02f, -1.29658552e-02f, -1.01588495e-01f, 7.08499830e-03f, 2.43346423e-01f, 1.23597369e-01f, -1.83186084e-02f, 3.33786696e-01f,
  -1.96284011e-01f, -2.49127466e-02f, -9.39516053e-02f, 5.99930808e-02f, 2.01803762e-02f, -8.47244486e-02f, -1.37865497e-02f, -2.35863682e-02f, -1.44510731e-01f, 1.87349152e-02f,
  3.79680544e-02f, -1.13607422e-01f, 2.26180125e-02f, -1.51947990e-01f, 1.73770443e-01f, -1.36761293e-02f, 1.44385174e-01f, 1.65648863e-01f, -5.82913943e-02f, 1.51575893e-01f,
  -1.23179026e-01f, 1.25437349e-01f, -2.32640821e-02f, 6.13431223e-02f, -6.70733228e-02f, 2.16429994e-01f, 1.16265386e-01f, 1.35077193e-01f, 8.45414773e-02f, -8.17465335e-02f,
  4.09949310e-02f, 2.14189589e-02f, 2.05604304e-02f, 5.58977760e-02f, -8.61573443e-02f, 5.86935356e-02f, 1.80021465e-01f, -1.17660023e-01f, 1.10134356e-01f, -2.75948644e-02f,
  1.51993945e-01f, 1.57035813e-01f, -4.32381928e-02f, 1.53214917e-01f, -4.38453704e-02f, 1.59950480e-02f, 8.02389681e-02f, 1.62816912e-01f, 7.77580366e-02f, 1.00198306e-01f,
  4.26196121e-02f, -2.59048581e-01f, 8.17512348e-02f, 1.24869421e-02f, -1.70074448e-01f, -7.39877895e-02f, 8.74310136e-02f, 1.43624440e-01f, 2.29852006e-01f, 4.10583854e-01f,
  -6.21875888e-03f, -1.24675877e-01f, -1.21735811e-01f, 1.80255011e-01f, -8.93550888e-02f, 1.42918348e-01f, 6.40336126e-02f, 1.40941173e-01f, -8.81202295e-02f, 5.22942990e-02f,
  2.57865846e-01f, -6.05241992e-02f, -6.68884143e-02f, -1.74286291e-02f, 3.91203091e-02f, 7.67802633e-03f, 2.37236656e-02f, 2.60517627e-01f, -1.83458067e-02f, -1.44589748e-02f,
  4.82311565e-03f, 6.73577487e-02f, 8.00414011e-02f, -8.20873212e-03f, -5.17953299e-02f, 9.53472555e-02f, -7.77380168e-02f, 1.11059090e-02f, 1.92663610e-01f, -7.38648251e-02f,
  5.54840192e-02f, -6.99950159e-02f, 4.56102304e-02f, 1.83603451e-01f, 1.09901771e-01f, -7.55530000e-02f, -2.69322470e-02f, -2.54463136e-01f, 5.90006560e-02f, 2.21607089e-01f,
  -1.42451480e-01f, 2.32758477e-01f, 7.47978464e-02f, 1.75470755e-01f, -2.97832459e-01f, 9.01960656e-02f, -5.61624877e-02f, 2.80279871e-02f, -5.73107600e-02f, 9.87446383e-02f,
  4.87920046e-02f, -3.43333334e-02f, -1.87792610e-02f, -1.15012489e-01f, -6.49874359e-02f, 2.41695598e-01f, -1.85096279e-01f, 1.93078220e-01f, -9.92495418e-02f, -2.28077658e-02f,
  1.96221441e-01f, -2.50366498e-02f, -1.81179598e-01f, -1.78816766e-01f, 1.17967881e-01f, 6.59194365e-02f, 2.13250846e-01f, 1.98287442e-02f, -1.42066807e-01f, 1.11595325e-01f,
  1.11471921e-01f, 1.24668941e-01f, 9.32229012e-02f, 1.91481635e-01f, -4.12535183e-02f, -4.80804071e-02f, 2.34271809e-01f, 6.91443831e-02f, 5.27791083e-02f, 2.52216965e-01f,
  -3.33357193e-02f, -9.87689048e-02f, 3.20154242e-02f, -3.81969586e-02f, 4.66816500e-02f, 2.19578631e-02f, -2.08554454e-02f, -1.43107455e-02f, -1.55605540e-01f, 1.50705472e-01f,
  1.71195343e-01f, 1.16499385e-03f, -1.68835342e-01f, 6.10317513e-02f, -3.28656398e-02f, 1.70245230e-01f, 2.85427243e-01f, 1.58276409e-01f, 5.70288254e-03f, 1.40336230e-01f,
  -1.31703153e-01f, 2.39108935e-01f, -7.09387809e-02f, 1.86091810e-02f, 2.61689305e-01f, 4.01535742e-02f, 1.26074791e-01f, -1.60381511e-01f, 5.03816083e-02f, 5.88912442e-02f,
  5.26932366e-02f, 7.25155026e-02f, 6.23362325e-02f, 1.45878829e-02f, -7.47328326e-02f, -7.91283399e-02f, 7.73628727e-02f, -7.08847046e-02f, -8.22165236e-02f, -2.85378676e-02f,
  1.15795493e-01f, 6.22697622e-02f, -3.08431294e-02f, -1.11240745e-01f, 7.62186125e-02f, 1.09211855e-01f, 1.38726264e-01f, -5.92976175e-02f, 1.54852137e-01f, -8.24972987e-02f,
  -6.63196072e-02f, -6.70444369e-02f, 6.20197691e-02f, 1.55424476e-01f, -4.81777377e-02f, -2.14880314e-02f, -2.54135430e-02f, -7.72804096e-02f, 2.09763303e-01f, 3.07541229e-02f,
  -8.16730130e-03f, 1.63309261e-01f, -1.71128660e-01f, 1.07225783e-01f, 9.69474614e-02f, 1.12881877e-01f, 1.73778862e-01f, 1.70761421e-01f, 1.50574949e-02f, 1.82387725e-01f,
  1.14054456e-01f, 1.63899958e-01f, 4.56801541e-02f, -1.03044249e-01f, -2.12910213e-02f, -2.46772364e-01f, 1.25775367e-01f, 1.08049519e-01f, 1.24460705e-01f, 1.01666851e-02f,
  -1.58066228e-01f, 7.70805180e-02f, -5.58403134e-02f, -1.49246365e-01f, 2.13177249e-01f, 3.15767452e-02f, 1.69300005e-01f, 5.33957593e-02f, -1.25706539e-01f, 5.46163656e-02f,
  1.28444210e-01f, 2.34383017e-01f, -2.18388557e-01f, -4.51999940e-02f, 1.65754631e-01f, 1.41076684e-01f, 4.64674495e-02f, 1.35540133e-02f, -1.73957467e-01f, -6.17836080e-02f,
  6.24861270e-02f, -1.31628618e-01f, -1.87819023e-02f, 1.15057707e-01f, 1.40215337e-01f, 1.83480121e-02f, -1.07616514e-01f, -1.28692582e-01f, 4.79446724e-02f, -1.07539684e-01f,
  9.62535292e-02f, -5.40405773e-02f, -8.57537389e-02f, 1.68239847e-01f, 1.38578519e-01f, -1.97164059e-01f, 1.11743860e-01f, 1.29664451e-01f, 2.21234839e-02f, -1.66762210e-02f,
  1.18606552e-01f, -1.66556027e-04f, -4.81751449e-02f, -3.54079604e-02f, -3.86176556e-02f, -7.72931203e-02f, 7.73215666e-02f, 3.01616266e-03f, 2.52637506e-01f, 1.85623076e-02f,
  -4.94495817e-02f, 3.60779688e-02f, 5.42516075e-02f, 5.79641014e-02f, -8.01477134e-02f, 9.51660424e-02f, 5.54391667e-02f, -6.21949807e-02f, 2.28289403e-02f, -3.62581667e-03f,
  -7.17623383e-02f, 9.49879736e-02f, 1.06417544e-01f, -5.47462627e-02f, -4.75725196e-02f, -5.49914725e-02f, -1.08204007e-01f, -9.75171253e-02f, 1.65780023e-01f, 1.62014648e-01f,
  3.33385877e-02f, -2.20749930e-01f, 7.76149631e-02f, -1.31175518e-01f, 1.68637127e-01f, 7.03116655e-02f, 2.65620232e-01f, 1.27519518e-01f, 2.43054852e-01f, -8.80301222e-02f,
  -1.32216319e-01f, 1.34792790e-01f, -1.23562738e-01f, 2.06191316e-01f, 6.93913847e-02f, -7.49911321e-03f, -1.01227686e-01f, 1.26614094e-01f, 7.60190859e-02f, -1.08828850e-01f,
  -5.37772067e-02f, 1.58676967e-01f, 3.81383114e-02f, -2.25726753e-01f, -9.32622850e-02f, 2.29364987e-02f, -1.68580383e-01f, -6.14168122e-02f, 2.38450050e-01f, -9.09299105e-02f,
  -9.35016125e-02f, 1.56333134e-01f, 1.25157014e-01f, 5.05841151e-02f, -6.99860901e-02f, 2.20033482e-01f, -4.89942618e-02f, -5.84843121e-02f, 1.67190433e-01f, 1.26297250e-01f,
  2.05587149e-01f, 7.40578547e-02f, -5.15063107e-03f, -9.39897634e-03f, -1.12749450e-01f, -1.41692072e-01f, 4.45268899e-02f, -1.02272213e-01f, -2.98506409e-01f, -7.03123659e-02f,
  6.64450135e-03f, 8.43204781e-02f, 1.03868239e-01f, -6.17425237e-03f, -1.22353518e-02f, -6.60139471e-02f, 6.66846335e-02f, 2.23276261e-02f, 2.27203310e-01f, -3.11495503e-04f,
  1.11989766e-01f, 2.39559293e-01f, -6.02018610e-02f, 3.65529954e-02f, 6.90263063e-02f, 7.80070126e-02f, 1.32483244e-01f, -5.03577990e-03f, -1.28729373e-01f, 1.17710963e-01f,
  -1.63673401e-01f, -1.03425212e-01f, -2.49053314e-02f, 2.59921718e-02f, -1.05453975e-01f, -4.79368083e-02f, 9.16213077e-03f, -6.62044957e-02f, -1.41499117e-02f, 1.06098928e-01f,
  2.44737789e-01f, -7.24209175e-02f, -5.70222996e-02f, -6.95257261e-02f, -9.12669897e-02f, -2.50694633e-01f, -3.01523715e-01f, 6.49923608e-02f, 8.22272971e-02f, -5.43206744e-03f,
  2.74874210e-01f, -1.47848845e-01f, -6.95046633e-02f, 2.36124024e-01f, 1.26985401e-01f, -4.75602597e-02f, 4.94751497e-04f, 1.21620528e-01f, 2.18453541e-01f, -4.96403463e-02f,
  7.29141245e-03f, -1.44270277e-02f, -2.04843417e-01f, 9.41930041e-02f, 4.79194187e-02f, 1.82041689e-03f, 4.42510098e-02f, 1.19744085e-01f, 1.33163020e-01f, 1.39532357e-01f,
  -1.26662314e-01f, 3.43133099e-02f, -1.29747391e-01f, 2.00092588e-02f, 7.25898519e-02f, 1.23085029e-01f, 2.07909737e-02f, 1.53222039e-01f, -8.73347595e-02f, 2.93679208e-01f,
  -3.67420129e-02f, -1.59785733e-01f, -2.67284997e-02f, -3.65091600e-02f, -1.50257528e-01f, -1.07191294e-01f, 4.09652218e-02f, -5.98364957e-02f, -5.71756922e-02f, 4.29040231e-02f,
  1.74481019e-01f, 1.09702766e-01f, 6.24950901e-02f, -5.28598540e-02f, 2.82249182e-01f, 1.45635992e-01f, -1.09964889e-02f, 7.57807819e-03f, 1.18403845e-02f, -8.60406533e-02f,
  1.24657243e-01f, -4.78062779e-02f, 6.61834925e-02f, -2.93420926e-02f, 1.61500588e-01f, -2.51068734e-02f, 1.59864835e-02f, -1.69811472e-01f, -1.39984027e-01f, 4.37479503e-02f,
  -1.66785508e-01f, -2.39950061e-01f, -4.39977124e-02f, 1.84829250e-01f, 1.10367462e-01f, 6.02954701e-02f, -1.14122465e-01f, 9.27757621e-02f, 2.16238257e-02f, 2.54436061e-02f,
  2.10397113e-02f, 2.04997182e-01f, -8.87379944e-02f, 1.03491858e-01f, 1.38762370e-01f, 5.49766757e-02f, -2.51340240e-01f, -1.49505615e-01f, 1.54571429e-01f, -3.14046860e-01f,
  -1.07179679e-01f, 2.72722512e-01f, 7.23144785e-03f, 6.87659532e-02f, 2.81915758e-02f, 2.65827179e-01f, -2.49873325e-01f, 1.04651498e-02f, -4.64403071e-02f, -1.29958717e-02f,
  6.07663766e-02f, -3.34601738e-02f, 1.53578982e-01f, -2.80742589e-02f, -1.21916361e-01f, -4.32363302e-02f, -9.97557789e-02f, -1.24498457e-01f, 1.14479074e-02f, 3.74336988e-02f,
  -5.28418571e-02f, 5.83930239e-02f, 9.67931002e-02f, 2.05477044e-01f, 1.44354382e-03f, 2.46921763e-01f, 1.04968153e-01f, 3.69857103e-02f, -6.93785399e-02f, 6.86514154e-02f,
  -1.78380579e-01f, 1.54079407e-01f, 1.72560602e-01f, 8.12977925e-02f, 5.44710085e-02f, -2.36780830e-02f, 1.20075993e-01f, 1.14727214e-01f, 1.08282223e-01f, 6.30783588e-02f,
  -8.55037048e-02f, 1.29331067e-01f, -3.15567970e-01f, -8.73637423e-02f, -9.84334275e-02f, 4.45507541e-02f, 9.41041782e-02f, -6.47324920e-02f, 1.16848774e-01f, -1.76123664e-01f,
  1.77447990e-01f, 1.75917923e-01f, -1.00971937e-01f, 1.34325549e-01f, 1.70405254e-01f, -1.71206176e-01f, 6.64277524e-02f, 1.01564109e-01f, 7.99382403e-02f, -1.67368457e-01f,
  -1.83695450e-01f, 3.03001776e-02f, 1.31738663e-01f, 5.42828701e-02f, 2.60207802e-01f, -2.75357459e-02f, -7.36888824e-03f, 1.09355457e-01f, -7.13779330e-02f, 4.02877517e-02f,
  8.78102183e-02f, 2.06782758e-01f, -6.45857863e-03f, 2.90107541e-03f, -6.61337003e-02f, 1.44114390e-01f, 1.78193510e-01f, -1.39997602e-01f, -2.20008090e-01f, 8.45261589e-02f,
  2.54072901e-02f, -4.44957577e-02f, -1.69470623e-01f, -1.73637010e-02f, 1.93778649e-01f, -3.19895335e-02f, 1.50458053e-01f, 1.08301073e-01f, 1.21042751e-01f, -1.49397597e-01f,
  2.08717570e-01f, -2.89965391e-01f, 1.82251811e-01f, 2.04205289e-01f, 2.13941708e-01f, 1.19902447e-01f, 1.16966709e-01f, 9.70651507e-02f, 1.45027280e-01f, -1.80795379e-02f,
  9.11179483e-02f, -4.80424128e-02f, -2.61526227e-01f, 2.48321980e-01f, -7.34856427e-02f, 1.26117766e-01f, 3.64181846e-02f, 2.34088957e-01f, 3.38693082e-01f, 2.34291017e-01f,
  -1.26827016e-01f, 1.98328346e-01f, -2.35433325e-01f, 1.96793154e-02f, 2.51425296e-01f, 2.45391950e-03f, -3.23983788e-01f, 1.90565094e-01f, 3.77033092e-02f, -2.30838448e-01f,
  -9.95454118e-02f, 6.12936616e-02f, -1.27024362e-02f, 5.78583479e-02f, 1.03933968e-01f, 1.78359419e-01f, 8.95996541e-02f, 2.59385873e-02f, -8.40880722e-02f, -1.60792898e-02f,
  2.59902865e-01f, -2.18767047e-01f, 2.16396689e-01f, -1.59302980e-01f, 3.11330020e-01f, 1.08417515e-02f, -2.25579008e-01f, 2.21929073e-01f, 1.93075746e-01f, 7.61550292e-02f,
  1.66485980e-01f, -1.22179091e-01f, 1.33542567e-01f, 5.30586988e-02f, 1.81895882e-01f, 2.80098140e-01f, 1.97648808e-01f, 1.18008286e-01f, -1.75055750e-02f, 1.63820937e-01f,
  1.06951848e-01f, 1.94619521e-01f, 1.70636252e-01f, 8.47577825e-02f, -1.17330573e-01f, -6.00405335e-02f, -1.89537466e-01f, 2.38708518e-02f, 4.08751070e-02f, 2.20125504e-02f,
  1.62655473e-01f, 1.90731049e-01f, 5.11400774e-02f, 9.12383050e-02f, 7.94572581e-04f, 2.41669193e-01f, 2.13321984e-01f, 1.18273333e-01f, -1.88049395e-02f, 1.29159614e-01f,
  -2.28571936e-01f, -1.45130739e-01f, -1.06260955e-01f, -1.28522560e-01f, 2.46033147e-02f, -3.97928990e-02f, 5.46978787e-02f, -7.05476999e-02f, 1.83777452e-01f, 1.29637763e-01f,
  1.45137191e-01f, 6.38027722e-03f, 6.14869501e-03f, 1.26956940e-01f, 1.43353626e-01f, 6.67701885e-02f, -1.03950068e-01f, -4.58004922e-02f, -5.25041623e-03f, -1.67031705e-01f,
  1.21866889e-01f, -1.49510801e-01f, 1.51014432e-01f, 6.20463602e-02f, 5.68244532e-02f, 1.06944606e-01f, -6.13621110e-03f, 1.64595649e-01f, -2.09080786e-01f, 3.59382741e-02f,
  1.90022841e-01f, 1.84789240e-01f, -4.27043065e-02f, 3.14239383e-01f, 1.19419865e-01f, -2.21745521e-01f, 8.19359347e-02f, 2.02828627e-02f, 5.70301991e-03f, -1.28373697e-01f,
  9.16180387e-02f, -4.95232781e-03f, -1.23079762e-01f, -4.28026989e-02f, -1.43660218e-01f, 1.14163049e-01f, 1.97100490e-01f, 2.56503951e-02f, 8.24469328e-02f, -1.28640726e-01f,
  1.04522921e-01f, 9.68321115e-02f, 1.74786579e-02f, -5.21817803e-02f, 8.19925070e-02f, 1.83537602e-01f, -5.58208637e-02f, -1.48435934e-02f, 1.16019830e-01f, 7.86995292e-02f,
  1.49726033e-01f, -6.83400780e-02f, -2.52383053e-01f, -9.62902904e-02f, -2.06755221e-01f, 8.57741572e-03f, -1.61315948e-01f, 3.13489735e-02f, -1.66577011e-01f, 9.22089890e-02f,
  3.84521075e-02f, 2.17788130e-01f, 8.92606676e-02f, 1.51193127e-01f, 5.96347712e-02f, -1.45338118e-01f, 2.01956600e-01f, 2.37502113e-01f, 2.18567744e-01f, 2.01069340e-01f,
  -8.51710960e-02f, 6.44156933e-02f, -4.94686700e-02f, -1.96402743e-01f, 8.32095593e-02f, 3.64770577e-03f, -1.43233286e-02f, 1.08776428e-01f, 3.82774584e-02f, 4.37192097e-02f,
  8.59177038e-02f, -2.10006740e-02f, 4.80138175e-02f, 1.15403784e-02f, 1.26472324e-01f, 2.35826254e-01f, 1.28688127e-01f, 6.16264120e-02f, -2.36583725e-02f, 1.40205175e-01f,
  2.34850347e-01f, -1.74935549e-01f, 1.95751458e-01f, -3.79240289e-02f, 8.22729431e-03f, 1.76558495e-01f, 8.32817052e-04f, 1.32229567e-01f, -1.56767845e-01f, 1.03941001e-01f,
  1.44036934e-01f, 2.23041475e-01f, -5.20161241e-02f, 2.73055080e-02f, 3.06873824e-02f, -1.57701746e-01f, -2.13624716e-01f, 7.55876973e-02f, 1.43533662e-01f, 1.31133959e-01f,
  -1.94129739e-02f, -9.19737965e-02f, 5.46578839e-02f, 1.60729080e-01f, 1.67885572e-01f, -3.36963125e-02f, -1.78004071e-01f, -1.94603175e-01f, -3.45293507e-02f, -1.69528395e-01f,
  -1.38917610e-01f, -1.68518797e-01f, -1.56743437e-01f, -2.39799142e-01f, 1.91016540e-01f, 2.27854159e-02f, -2.06821058e-02f, -3.79231498e-02f, 2.06952393e-01f, -1.06261998e-01f,
  9.21545103e-02f, 1.23395674e-01f, 9.69422683e-02f, 1.08407214e-01f, -2.71896034e-01f, 6.00148439e-02f, 4.63602878e-02f, 4.58058752e-02f, 1.45807564e-01f, -2.42385715e-02f,
  1.11557551e-01f, 9.96953547e-02f, -6.48953998e-03f, 2.01796249e-01f, -1.55503497e-01f, 9.38195065e-02f, -3.30235988e-01f, 5.98931909e-02f, 2.46095479e-01f, 8.74957964e-02f,
  -6.12906478e-02f, 1.50922060e-01f, -1.92630187e-01f, -5.49915954e-02f, -4.02493067e-02f, -3.47874500e-02f, 1.80085748e-01f, -2.21955776e-01f, -8.37858468e-02f, -2.64540948e-02f,
  -7.42783919e-02f, 1.76876426e-01f, -1.14965755e-02f, -9.57722366e-02f, 2.14553848e-01f, -2.70269960e-02f, 1.70245498e-01f, -2.41513215e-02f, 3.87949824e-01f, 6.28580600e-02f,
  -6.46892190e-02f, 3.05688083e-02f, 1.59644976e-01f, 7.72562996e-02f, 1.70996174e-01f, 1.67098552e-01f, 6.37746835e-03f, 4.87604178e-02f, -3.58271636e-02f, 1.44454554e-01f,
  -2.74813827e-02f, 1.97814241e-01f, -1.46878332e-01f, -3.33954766e-02f, -3.62631977e-02f, 2.13237837e-01f, 2.42700335e-02f, 8.30781087e-02f, -5.20513728e-02f, -1.28022134e-02f,
  8.48903060e-02f, 7.96401128e-02f, -1.25371680e-01f, 1.65257752e-02f, 1.32518396e-01f, -4.25579548e-02f, 1.51713774e-01f, 1.45295829e-01f, 8.16785470e-02f, -5.36657497e-02f,
  -4.93815877e-02f, 1.18840940e-01f, 1.32566735e-01f, -9.72597450e-02f, 1.60839453e-01f, -1.92290425e-01f, 7.65329525e-02f, 1.92141131e-01f, 1.46441653e-01f, -1.43366620e-01f,
  2.01935530e-01f, 3.84433158e-02f, -1.29859760e-01f, 1.20015129e-01f, 1.68801382e-01f, 2.16203198e-01f, -8.16629827e-02f, -1.20252386e-01f, 5.12281172e-02f, 1.88030496e-01f,
  1.49635926e-01f, 3.97307612e-02f, -1.40674070e-01f, 5.57463281e-02f, 7.04099005e-03f, -2.51721460e-02f, 1.25139490e-01f, 1.10259861e-01f, 1.09111749e-01f, -3.98759507e-02f,
  -7.17320442e-02f, -1.93426609e-01f, 1.04671828e-01f, 9.25664008e-02f, 1.08186856e-01f, -3.60191390e-02f, 1.72293279e-03f, 1.30189642e-01f, 1.24405973e-01f, 5.81803247e-02f,
  1.71308722e-02f, -9.20219943e-02f, -1.38829231e-01f, 1.13643318e-01f, 5.93469925e-02f, 1.33004531e-01f, 8.35194346e-03f, -7.95339942e-02f, 3.58069949e-02f, -1.38359115e-01f,
  -5.72603717e-02f, -2.41993338e-01f, -5.17467782e-02f, -1.10348031e-01f, 1.52949557e-01f, -2.96616465e-01f, -1.04389146e-01f, 1.37017384e-01f, -1.26102492e-01f, -9.47303027e-02f,
  1.34159327e-01f, 2.97250785e-02f, -1.28869368e-02f, -9.02815908e-02f, 2.70189762e-01f, 5.90016879e-02f, 3.03061567e-02f, 1.43188447e-01f, 2.05864742e-01f, 1.37310445e-01f,
  8.53297710e-02f, 9.81293395e-02f, -1.09957203e-01f, -1.41360238e-01f, -1.65924914e-02f, 4.11424860e-02f, -5.07592782e-02f, -1.22942671e-01f, -1.05554111e-01f, -2.35341936e-02f,
  -1.53787620e-02f, -8.75312777e-04f, -2.63224274e-01f, 2.13563383e-01f, 4.91139181e-02f, 1.22616939e-01f, -8.82004127e-02f, -5.78318117e-03f, 9.82455723e-03f, 1.73182134e-02f,
  1.38406366e-01f, -8.62378851e-02f, 6.03432618e-02f, -2.16316089e-01f, 4.01258953e-02f, 5.67165799e-02f, 3.66533324e-02f, 7.96538293e-02f, 1.91327184e-01f, 4.87497747e-02f,
  -3.89067084e-02f, -1.00525402e-01f, 1.48520276e-01f, 1.56632867e-02f, 1.00752778e-01f, -4.41983603e-02f, -3.78289521e-02f, -1.75539747e-01f, 9.22360644e-02f, -1.21948212e-01f,
  -1.55926049e-01f, -4.31198366e-02f, 7.29009658e-02f, -2.27199271e-01f, 2.39345089e-01f, 8.65719244e-02f, 2.04926744e-01f, -9.01301354e-02f, 6.34363890e-02f, 8.20886195e-02f,
  1.28772259e-01f, -7.19940895e-03f, 1.53513134e-01f, 1.21913850e-01f, 1.99397475e-01f, -1.21620797e-01f, 2.39987075e-01f, 5.87306842e-02f, -7.48780146e-02f, 1.34114638e-01f,
  7.84935057e-02f, -1.44968867e-01f, -4.35594507e-02f, 8.24407861e-02f, -3.50962840e-02f, 1.59067303e-01f, -4.08660285e-02f, 2.41836503e-01f, 4.82000187e-02f, 6.66058883e-02f,
  1.47660807e-01f, -5.98015934e-02f, -8.25439617e-02f, -1.41838193e-01f, 1.26684874e-01f, 2.67577879e-02f, -3.85152400e-02f, 4.90803458e-02f, -2.20327541e-01f, -5.51839210e-02f,
  -4.37025875e-02f, -8.93582329e-02f, 2.23528221e-01f, -2.22040504e-01f, 7.81815350e-02f, 4.94863912e-02f, -9.97087210e-02f, 1.65738642e-01f, -2.43460741e-02f, -9.54451412e-03f,
  -2.38073111e-01f, 1.04282521e-01f, 9.89202634e-02f, 2.09939256e-01f, 1.20690733e-01f, 8.31615105e-02f, 1.40861064e-01f, 9.96161848e-02f, 9.56026092e-02f, 9.19537917e-02f,
  3.97514217e-02f, -2.74610668e-01f, 6.60228580e-02f, 7.66204596e-02f, -9.68076065e-02f, -1.38613462e-01f, 4.50124741e-02f, -1.63863733e-01f, 1.89753935e-01f, 2.45268837e-01f,
  -1.60463043e-02f, -3.07483021e-02f, 8.04140791e-02f, 2.16906741e-01f, -5.22225797e-02f, 8.04971904e-02f, 2.17197478e-01f, 1.57370090e-01f, -9.55714583e-02f, 1.52264029e-01f,
  1.10642828e-01f, -9.83740240e-02f, -1.79855540e-01f, -6.74266964e-02f, 2.31022328e-01f, -1.71000287e-02f, 1.15410261e-01f, -2.56323200e-02f, 5.98036721e-02f, 6.56113252e-02f,
  -1.85266361e-01f, 2.35534057e-01f, -1.00579254e-01f, 3.95171046e-02f, 5.92101328e-02f, -5.15474789e-02f, -3.39412726e-02f, -2.04860717e-02f, 2.40300149e-01f, -1.09409213e-01f,
  -1.40333995e-01f, 3.62039730e-02f, -9.41266939e-02f, 2.42273197e-01f, 4.16986980e-02f, 2.33543571e-03f, 1.99973881e-01f, -9.14649591e-02f, 9.54748243e-02f, 2.83023059e-01f,
  7.87326172e-02f, 6.59324005e-02f, 1.59374904e-02f, -7.67283365e-02f, -2.45018825e-01f, 1.51940301e-01f, 4.20954637e-02f, 1.67794541e-01f, -5.14171682e-02f, -7.20935985e-02f,
  1.51155785e-01f, 1.19102895e-02f, -7.48452842e-02f, 3.25606056e-02f, -1.01166368e-01f, -2.23641276e-01f, 1.60343841e-01f, -1.43122286e-01f, 6.58415705e-02f, 1.05666528e-02f,
  2.49030545e-01f, 1.89975366e-01f, 2.74265558e-01f, -8.58945213e-03f, 8.96977931e-02f, 1.85399085e-01f, 9.39974489e-05f, -1.82530895e-01f, 2.87751555e-02f, 4.75323573e-03f,
  1.33362293e-01f, -1.41463969e-02f, 1.00944981e-01f, -1.47835687e-01f, 1.03687733e-01f, 2.17692018e-01f, 1.21027581e-01f, 1.33296534e-01f, 5.78597151e-02f, 1.58775643e-01f,
  5.44315390e-02f, -5.69407865e-02f, 1.18562944e-01f, 1.22503899e-01f, 7.36328810e-02f, -2.00065132e-02f, 3.08470517e-01f, 1.36366069e-01f, 1.74671531e-01f, 1.03244387e-01f,
  7.12115467e-02f, -1.38859957e-01f, 1.16621457e-01f, 1.35051180e-02f, 1.86990023e-01f, 3.49407247e-03f, -7.17386603e-02f, 1.92949191e-01f, -3.33572291e-02f, -1.26494184e-01f,
  2.54334241e-01f, 5.70175517e-03f, 1.00576498e-01f, -9.80793536e-02f, 7.89862219e-03f, -4.49090824e-02f, -2.46238504e-02f, 2.18968764e-01f, -1.88179329e-01f, 1.97874025e-01f,
  1.63577124e-01f, 1.52376115e-01f, -2.37040613e-02f, -1.16070680e-01f, -2.54884246e-03f, 8.87465477e-03f, 1.28014833e-01f, -2.65513230e-02f, -1.46463960e-01f, 6.97267503e-02f,
  -3.63892652e-02f, -2.51533806e-01f, 2.56777644e-01f, 2.15167314e-01f, -9.90466475e-02f, 2.47661829e-01f, -3.44005935e-02f, 2.58290339e-02f, -6.73789382e-02f, 2.32201591e-01f,
  -2.19954993e-03f, -2.15227216e-01f, 9.51443389e-02f, -1.23100832e-01f, -1.22941971e-01f, 2.21886083e-01f, 5.48209921e-02f, -3.47522125e-02f, 1.57279551e-01f, 2.26633593e-01f,
  2.54361480e-01f, 1.32469505e-01f, -7.70623088e-02f, 2.30405942e-01f, -4.64134365e-02f, 2.37443611e-01f, -5.52710555e-02f, 1.44972399e-01f, 7.85151795e-02f, 5.33443019e-02f,
  1.49001926e-01f, -3.47842388e-02f, 8.84268284e-02f, 3.71771008e-02f, 2.38264427e-01f, -2.22309768e-01f, 7.16742203e-02f, 5.41056581e-02f, 1.36978373e-01f, 3.46251465e-02f,
  7.70029873e-02f, -1.53155893e-01f, 4.53338362e-02f, 1.27727702e-01f, 6.06979094e-02f, 2.49052152e-01f, -5.74243553e-02f, 1.58572625e-02f, -4.07164581e-02f, 2.68323928e-01f,
  -1.57685667e-01f, 3.01621437e-01f, -2.27875218e-01f, -9.62875262e-02f, -1.20825991e-02f, 9.51165929e-02f, 4.98197936e-02f, -1.42463874e-02f, 5.54381795e-02f, -1.20028183e-01f,
  -2.86446735e-02f, -8.41070041e-02f, -1.24874733e-01f, -2.32265014e-02f, 1.38516426e-01f, -1.41366228e-01f, 7.61556327e-02f, 1.73174262e-01f, -5.04548056e-03f, 2.25745827e-01f,
  -2.08287403e-01f, 1.58122350e-02f, -7.91330710e-02f, 2.30563894e-01f, -7.39411712e-02f, -1.86803848e-01f, -1.28838107e-01f, -5.56323938e-02f, -1.69350073e-01f, 4.10366692e-02f,
  1.93218887e-01f, 7.48014152e-02f, 1.05074430e-02f, 1.20063320e-01f, 2.74545997e-01f, 1.69147030e-01f, -1.18690580e-01f, 1.92399681e-01f, -1.18383475e-01f, 1.11785829e-01f,
  1.17111824e-01f, -1.11105911e-01f, 1.40131444e-01f, -2.32334077e-01f, 3.36926728e-01f, -1.41355433e-02f, -1.56997573e-02f, 6.19990863e-02f, -7.77417095e-03f, -1.57157063e-01f,
  -2.05486670e-01f, 2.92835504e-01f, 1.49292141e-01f, -7.46462792e-02f, -2.78145890e-03f, 1.43520027e-01f, 1.38172776e-01f, 1.08897630e-02f, 4.97311503e-02f, 1.64705619e-01f,
  8.70602205e-03f, -1.29880896e-03f, -1.05574243e-02f, 6.48037493e-02f, 9.80186909e-02f, 9.98418555e-02f, -1.43701583e-01f, 4.98941960e-03f, -1.16888873e-01f, -1.86697587e-01f,
  1.97621569e-01f, 5.03894016e-02f, -9.14189592e-03f, -1.02916561e-01f, 1.48136273e-01f, -9.18357223e-02f, -8.02537799e-02f, 1.24619976e-01f, 1.43749462e-02f, -2.83994287e-01f,
  -1.17037017e-02f, 2.74888098e-01f, -1.48690924e-01f, 1.05039634e-01f, 1.96322933e-01f, 1.37515858e-01f, -1.10275127e-01f, 2.19809622e-01f, -1.02748327e-01f, 6.63389191e-02f,
  1.13852151e-01f, -1.51904106e-01f, 7.68874437e-02f, 1.18772537e-01f, -1.09957300e-01f, -3.71794440e-02f, 1.03692755e-01f, 1.17287740e-01f, -1.25721181e-02f, -1.44273667e-02f,
  -1.32321283e-01f, 1.35748871e-02f, -2.02132821e-01f, 2.17565790e-01f, -1.27012640e-01f, -7.38779455e-02f, 7.56384060e-02f, 1.17317196e-02f, 4.84150574e-02f, 5.45467772e-02f,
  6.59140944e-02f, 1.11173943e-01f, 2.69375473e-01f, -1.10869810e-01f, -5.42838685e-03f, -3.30002643e-02f, 2.51997560e-01f, -3.73243243e-02f, 1.08829014e-01f, 5.71797825e-02f,
  8.88668224e-02f, 1.29424423e-01f, 3.54418978e-02f, -1.63851064e-02f, -8.34099427e-02f, 1.08102404e-01f, -6.18845597e-03f, 2.67876714e-01f, 5.50365523e-02f, 1.22156575e-01f,
  -3.32946897e-01f, 4.73623201e-02f, 2.98357941e-03f, 2.07597673e-01f, -8.16910621e-03f, 1.93035435e-02f, -2.50323880e-02f, -1.18944570e-01f, -1.87883489e-02f, -8.91148001e-02f,
  1.62112400e-01f, 2.40365043e-01f, -1.90209344e-01f, 1.90771803e-01f, 1.06431283e-02f, -5.69075122e-02f, -4.06316714e-03f, -1.44344687e-01f, -2.14264929e-01f, -1.17533505e-01f,
  4.20200871e-03f, -6.74435124e-02f, 1.68590277e-01f, 5.07576875e-02f, 1.02121472e-01f, 3.34827369e-03f, 5.34303719e-03f, -4.89875339e-02f, 1.20814487e-01f, 7.54957646e-02f,
  -1.47705063e-01f, -7.16629112e-03f, 1.92064997e-02f, 1.07636012e-01f, -3.53894196e-04f, 1.36027634e-01f, 1.20671988e-01f, -9.91945863e-02f, 3.91937569e-02f, -9.54858661e-02f,
  -2.38961782e-02f, -7.20756724e-02f, -1.80808768e-01f, 5.23554869e-02f, 3.76882330e-02f, -5.88212954e-03f, -9.79504082e-03f, 2.04585940e-01f, -1.88112721e-01f, 1.33195728e-01f,
  3.67339551e-02f, -4.68660817e-02f, 1.27809182e-01f, 1.48190046e-02f, 1.09746363e-02f, 2.14797661e-01f, 2.92519685e-02f, 7.36778080e-02f, -3.48105468e-02f, 1.27581537e-01f,
  1.72996804e-01f, -6.73987269e-02f, -9.58533287e-02f, -1.08660810e-01f, 1.00364618e-01f, -1.64104357e-01f, 1.84315704e-02f, 1.21801428e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  2.00340021e-02f, -9.59856138e-02f, 4.98869531e-02f, -1.10885918e-01f, 2.21146476e-02f, 7.26256594e-02f, 1.28717557e-01f, 1.05308563e-01f, -9.99101996e-02f, 9.10029411e-02f,
  -1.21109514e-02f, -2.09671799e-02f, 1.49130583e-01f, -3.55082341e-02f, -9.86048326e-05f, 1.08833909e-01f, 1.20799355e-01f, 2.91460776e-03f, 1.45532861e-02f, 1.00065082e-01f,
  -1.39671471e-02f, 2.20860471e-03f, -5.93310669e-02f, -1.35330297e-02f, 9.47769433e-02f, 2.29759188e-03f, 3.01150209e-03f, 7.25633651e-02f, 7.29522258e-02f, 3.86601724e-02f,
  1.14128202e-01f, 1.00245088e-01f, 4.01160270e-02f, 3.65589336e-02f, -4.55028713e-02f, 1.16056569e-01f, 5.92132248e-02f, 6.91703409e-02f, 2.46883538e-02f, 1.51319459e-01f,
  1.43022180e-01f, 4.84205708e-02f, -3.16342190e-02f, 1.49420395e-01f, -8.23541544e-03f, 8.43194574e-02f, -3.55662331e-02f, 1.43072158e-01f, 8.82037953e-02f, -3.38008106e-02f,
  -4.78431247e-02f, 9.89919528e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  6.34431988e-02f, -5.42760361e-03f, 1.89463422e-02f, -6.50011823e-02f, 7.54885450e-02f, -1.39776124e-02f, -1.13608792e-01f, 1.14670783e-01f, -2.13951059e-02f, -1.53378159e-01f,
  -1.82612985e-01f, -2.64519127e-03f, 1.89422071e-01f, -3.80480866e-04f, -1.10581212e-01f, 6.15989678e-02f, 1.64416909e-01f, -2.15930924e-01f, -2.51627535e-01f, 1.94950819e-01f,
  4.42344975e-03f, -9.17716995e-02f, -4.55207676e-02f, -9.78689417e-02f, -3.45334858e-01f, 1.88250482e-01f, -9.73480716e-02f, 1.05055803e-02f, 3.61095257e-02f, 1.93426028e-01f,
  -2.55178928e-01f, 9.25191492e-02f, 7.61289373e-02f, -2.54349709e-01f, 1.25716463e-01f, -1.44657835e-01f, 2.59280521e-02f, 3.80701269e-03f, 8.48263279e-02f, 1.84452627e-02f,
  -1.96328297e-01f, -1.58518940e-01f, -1.99105665e-01f, -7.46314004e-02f, 1.57289684e-01f, -3.46100070e-02f, -1.47926047e-01f, 5.25928810e-02f, -1.29316896e-01f, -9.94936675e-02f,
  -2.02831894e-01f, 8.10283422e-02f, -3.70326996e-01f, -1.97862044e-01f, -1.94842353e-01f, -1.50020078e-01f, 1.41725644e-01f, -2.31209069e-01f, -6.45248815e-02f, -3.67461629e-02f,
  -9.49774534e-02f, 5.86425290e-02f, -2.13734731e-01f, 1.15612693e-01f, 1.69614419e-01f, 1.10179305e-01f, -1.93772703e-01f, -1.04334541e-01f, -1.26128286e-01f, -1.91223100e-02f,
  -1.18007995e-02f, -4.84122057e-03f, 1.42213598e-01f, 1.23368703e-01f, 1.28245369e-01f, -4.55729477e-02f, 5.93237802e-02f, -1.16270535e-01f, -4.51708175e-02f, -1.06292091e-01f,
  1.66133761e-01f, 6.32296056e-02f, 3.93963642e-02f, 1.24954380e-01f, -2.03933552e-01f, -3.68487835e-02f, 5.64641431e-02f, -1.84317693e-01f, -1.83939278e-01f, -3.13203000e-02f,
  1.73246965e-01f, -2.98085690e-01f, 1.30725577e-01f, 4.77452949e-02f, 3.49980057e-03f, 1.05421349e-01f, -2.46014342e-01f, -9.39910710e-02f, -1.20302610e-01f, 2.64993943e-02f,
  -6.54402748e-02f, 1.40277401e-01f, 4.89537269e-02f, -2.83805151e-02f, -2.41399959e-01f, -1.14075884e-01f, -1.36125982e-01f, 1.01120718e-01f, -7.77705759e-02f, 6.01679012e-02f,
  8.39897096e-02f, -5.34923859e-02f, -2.36269847e-01f, -2.03111395e-01f, 1.18668534e-01f, -2.61596637e-03f, -4.29675020e-02f, -2.97333807e-01f, -3.23804140e-01f, 1.26027748e-01f,
  1.16213150e-01f, 5.32279462e-02f, 1.69236228e-01f, 2.13601738e-01f, -2.00074553e-01f, -2.32601389e-01f, -2.33203933e-01f, -2.98666000e-01f, -9.50268954e-02f, 1.43368519e-03f,
  4.27856743e-02f, -8.97358283e-02f, 6.73403516e-02f, 1.51550146e-02f, 3.02328598e-02f, -4.44713980e-02f, 4.51224670e-02f, 5.49372323e-02f, 1.16524562e-01f, -7.26251900e-02f,
  3.62034440e-02f, 1.70544758e-01f, -1.70800418e-01f, -8.32735896e-02f, 1.58438206e-01f, -1.80872753e-01f, 6.47607744e-02f, 1.47738025e-01f, 1.77878141e-02f, -2.46617883e-01f,
  -4.07990243e-04f, -6.88484833e-02f, -2.62627035e-01f, -4.18871567e-02f, 9.63589400e-02f, 1.48904640e-02f, 1.12536021e-01f, -2.11901978e-01f, 1.56025916e-01f, -2.36084670e-01f,
  -3.07990789e-01f, -2.18851864e-01f, -2.32170478e-01f, -1.15838565e-01f, -3.57805729e-01f, -7.16473311e-02f, 1.85485721e-01f, 1.32513031e-01f, -4.73816060e-02f, 2.14552388e-01f,
  -4.12846468e-02f, 1.74424678e-01f, -3.76624823e-01f, 1.62262186e-01f, 8.14618319e-02f, -2.48475477e-01f, 1.87964961e-02f, 1.92390501e-01f, 1.22801708e-02f, -1.76318064e-01f,
  -1.11752287e-01f, -2.59246498e-01f, -1.87224209e-01f, -2.56570727e-01f, -2.25586474e-01f, 1.21321976e-01f, 6.91887960e-02f, 4.87168841e-02f, -4.32997309e-02f, 5.27759083e-02f,
  1.44343778e-01f, 4.36532721e-02f, 3.61796506e-02f, -1.13935046e-01f, -1.19545467e-01f, 8.09194893e-02f, 5.90468608e-02f, 4.50205058e-03f, 7.37309977e-02f, 1.71598569e-01f,
  1.21743046e-01f, -1.17023967e-01f, -1.71292901e-01f, 4.31199893e-02f, -3.35955530e-01f, 1.07481061e-02f, -1.35102704e-01f, 1.52028158e-01f, -2.32396200e-01f, 4.54115421e-02f,
  -2.37910911e-01f, -1.38208056e-02f, -1.77381918e-01f, -1.77877638e-02f, -1.47527888e-01f, -9.17139351e-02f, -1.46155618e-02f, -4.16995026e-02f, -3.01841646e-01f, 1.13577098e-01f,
  -2.01505914e-01f, -1.59585118e-01f, -2.62991488e-01f, -1.43570632e-01f, 1.11355007e-01f, 2.03334942e-01f, 2.81877612e-04f, -2.59039432e-01f, -3.12513597e-02f, -3.03220116e-02f,
  -1.11145228e-01f, 1.00864530e-01f, 2.01900288e-01f, -2.22543567e-01f, -2.26430684e-01f, -2.21079782e-01f, 6.27713576e-02f, -2.22916514e-01f, 1.03973709e-01f, 1.58311531e-01f,
  -2.02326402e-01f, 2.71819141e-02f, -1.32380817e-02f, -1.39044762e-01f, -8.25672522e-02f, 2.98230238e-02f, 9.24318135e-02f, -2.03904927e-01f, -8.86050537e-02f, -2.59635389e-01f,
  -2.71906048e-01f, -1.00604489e-01f, 1.48531035e-01f, 3.07129640e-02f, 1.08278401e-01f, -3.99948731e-02f, 1.50320694e-01f, -3.08920885e-03f, 6.64286837e-02f, 6.28164783e-02f,
  -9.15241838e-02f, 5.65196536e-02f, -2.06789464e-01f, 1.51249483e-01f, -1.94320560e-01f, -1.92823350e-01f, -1.51191175e-01f, 2.91658551e-01f, 1.47029348e-02f, -3.06627721e-01f,
  -1.43125623e-01f, -2.91413665e-01f, -1.73358902e-01f, 1.84752658e-01f, -9.15611014e-02f, -9.27300844e-03f, -1.51931882e-01f, 1.64531954e-02f, -1.68574452e-01f, -1.70749202e-01f,
  3.53649706e-02f, 7.59433508e-02f, -4.29025367e-02f, 8.26183259e-02f, -1.98022619e-01f, 1.77336425e-01f, 7.62191322e-03f, -1.94929063e-01f, 8.82505924e-02f, 1.91593207e-02f,
  2.08468616e-01f, -1.40851540e-02f, -1.17473230e-02f, -1.76501989e-01f, -1.68260708e-01f, -6.59252182e-02f, -7.26771951e-02f, -5.55530526e-02f, 1.83092326e-01f, 4.62583778e-03f,
  1.11369982e-01f, -1.11947479e-02f, -1.80477515e-01f, 3.66123170e-02f, -2.20465869e-01f, -1.73703671e-01f, -2.92789787e-01f, 1.41754836e-01f, -4.57663350e-02f, 1.21969640e-01f,
  -1.39145717e-01f, 1.63872480e-01f, -1.41164809e-01f, -1.81425825e-01f, -6.30089864e-02f, -1.50210839e-02f, 2.42488296e-03f, -6.43118322e-02f, 5.43375872e-02f, 4.64135669e-02f,
  1.27482101e-01f, 1.17093885e-04f, -3.07480786e-02f, -6.67751804e-02f, -7.58153573e-02f, -8.95979926e-02f, 2.10044935e-01f, 9.21254158e-02f, 9.53890979e-02f, 9.43382680e-02f,
  1.55557185e-01f, 1.57373860e-01f, 9.60329324e-02f, -2.20305249e-02f, -4.17949259e-02f, -1.41608894e-01f, -1.34452194e-01f, -7.96646774e-02f, 6.00774772e-02f, 1.35185644e-02f,
  -1.24275006e-01f, -2.82167107e-01f, 3.82599421e-02f, -9.46198311e-03f, -3.72159295e-02f, -1.53763837e-03f, -1.68418944e-01f, 6.59150211e-03f, -9.59453359e-02f, 1.42529771e-01f,
  -1.29493803e-01f, 1.63956955e-01f, 2.25358736e-02f, -2.58530915e-01f, 2.41662711e-02f, 7.21504167e-02f, 1.52476043e-01f, 1.87120169e-01f, -2.57453591e-01f, -1.41140074e-01f,
  -2.21062049e-01f, -2.18170077e-01f, 2.07466125e-01f, -2.87930340e-01f, 1.24746844e-01f, -1.43418580e-01f, 1.35426596e-01f, -8.08217600e-02f, -1.02623895e-01f, -1.12698786e-01f,
  2.44910896e-01f, 9.02748778e-02f, 6.44620433e-02f, -1.17551401e-01f, 1.04081780e-01f, 2.32241035e-01f, 6.51550144e-02f, -1.39316484e-01f, -3.65498438e-02f, -1.13195501e-01f,
  -3.97939563e-01f, -3.20845306e-01f, -1.42782629e-01f, 1.40418574e-01f, -9.60390419e-02f, -6.55627549e-02f, 1.61620140e-01f, 7.56935179e-02f, -4.45492379e-03f, -7.65873566e-02f,
  5.19866198e-02f, 2.06117388e-02f, -4.24205102e-02f, 1.43530175e-01f, 5.62963560e-02f, 1.49860397e-01f, 4.79161292e-02f, -4.36173007e-03f, 2.73338165e-02f, -2.51674384e-01f,
  -1.78127244e-01f, 1.21814422e-01f, 1.67451888e-01f, -2.35159770e-01f, -7.43490756e-02f, -2.46637374e-01f, 1.65582895e-01f, 1.57746822e-01f, 1.77171230e-01f, 9.06209648e-02f,
  1.21336922e-01f, -1.42320618e-01f, 1.65847301e-01f, -1.14501290e-01f, 7.05618560e-02f, -8.31290781e-02f, -8.39571729e-02f, -8.16243812e-02f, -1.00522824e-01f, 1.60212055e-01f,
  -2.96319157e-01f, -9.79920775e-02f, -2.19041765e-01f, -1.32922437e-02f, 9.27575752e-02f, 6.09019250e-02f, 1.34800673e-01f, 4.22542505e-02f, -5.12966998e-02f, -8.19758922e-02f,
  -1.65442124e-01f, -1.90520972e-01f, 2.23635018e-01f, 1.44750327e-01f, 2.34303419e-02f, -1.64362013e-01f, 1.02525223e-02f, 6.81644902e-02f, -1.99708380e-02f, -9.20062959e-02f,
  -1.31696954e-01f, 6.54345453e-02f, 9.96632800e-02f, 5.59956534e-03f, -2.38822997e-01f, -1.03039563e-01f, -1.87805966e-01f, -3.07602193e-02f, 5.68914413e-02f, 8.46763849e-02f,
  9.86455977e-02f, 8.19166526e-02f, -5.93453608e-02f, -9.28805619e-02f, -1.28061295e-01f, -1.17009617e-01f, -1.25050515e-01f, -5.07568084e-02f, -1.51038393e-01f, -2.20753163e-01f,
  -1.36997938e-01f, -2.71545351e-01f, -1.79483667e-02f, 5.48242629e-02f, 4.24270853e-02f, -1.46878824e-01f, -3.84410173e-02f, -3.16582441e-01f, 2.96087772e-01f, 1.19577996e-01f,
  -1.19819643e-03f, -1.55574054e-01f, -2.47284681e-01f, -1.78309277e-01f, 1.77384257e-01f, 8.13105479e-02f, -2.01850876e-01f, -2.22902507e-01f, 2.47272551e-02f, -1.12877585e-01f,
  -3.31919611e-01f, 1.73218414e-01f, -1.06029436e-01f, -1.19945683e-01f, 7.37732053e-02f, -1.63518503e-01f, -7.93589130e-02f, -3.19336027e-01f, 1.99235082e-01f, -1.17132396e-01f,
  -1.68824479e-01f, 6.21671863e-02f, -2.57551484e-02f, -1.41983882e-01f, -1.25073522e-01f, -1.25239044e-01f, -1.42594995e-02f, -2.78947532e-01f, -9.24333856e-02f, 4.41430062e-02f,
  -2.52393037e-01f, 1.01255113e-02f, -1.63013548e-01f, -2.45914739e-02f, -2.16697925e-03f, -2.57857423e-02f, -2.15014145e-01f, 1.09749809e-01f, 1.56223357e-01f, 2.94723541e-01f,
  1.53258577e-01f, -2.08772808e-01f, -6.52596587e-03f, -5.92369772e-02f, -2.71649305e-02f, -1.14152402e-01f, 7.16785640e-02f, -1.02399342e-01f, -1.81421906e-01f, -1.90412164e-01f,
  2.27150954e-02f, -5.86628504e-02f, 2.23622024e-02f, -2.00258628e-01f, 8.11307654e-02f, -1.10201746e-01f, -2.68213246e-02f, 2.45065108e-01f, 1.42644018e-01f, -1.51100561e-01f,
  1.04387671e-01f, -2.13849470e-02f, 2.29082331e-01f, -1.60701022e-01f, 1.23887815e-01f, 1.12205736e-01f, -1.92988828e-01f, 1.40729055e-01f, -1.23897597e-01f, -1.15536958e-01f,
  1.07778057e-01f, -1.09794792e-02f, -2.46723741e-01f, 6.25245050e-02f, -5.35915904e-02f, -1.05129294e-01f, 1.06467657e-01f, 1.76285263e-02f, -1.96655646e-01f, -6.84511960e-02f,
  1.37452394e-01f, -1.92437664e-01f, 2.16963038e-01f, 2.67821159e-02f, 1.70219820e-02f, -2.09032595e-01f, -9.33187753e-02f, 1.69988021e-01f, 7.86880180e-02f, -2.67001301e-01f,
  4.33053076e-03f, -1.74450502e-01f, 3.72599028e-02f, -2.28447229e-01f, -1.77071124e-01f, -1.99219406e-01f, -3.88060734e-02f, -4.41520996e-02f, 1.10277392e-01f, -5.38430735e-02f,
  -1.04171112e-01f, 9.35970023e-02f, 2.38769390e-02f, 2.11819217e-01f, -1.92092285e-02f, 7.86924735e-02f, -1.06184274e-01f, -1.50766701e-01f, -3.17797139e-02f, -6.67761313e-03f,
  2.28271499e-01f, -4.42932025e-02f, 1.83650985e-01f, 1.17828600e-01f, 2.64107939e-02f, -2.20236465e-01f, 2.38417014e-01f, 6.55234009e-02f, 1.00591265e-01f, -5.63013293e-02f,
  3.32073599e-01f, -3.16079222e-02f, -8.21427554e-02f, 1.67594314e-01f, -6.83835223e-02f, 8.85686576e-02f, 6.66629300e-02f, 5.46195507e-02f, -1.73188105e-01f, 1.33624017e-01f,
  1.50681168e-01f, -2.82425791e-01f, 1.66402712e-01f, 2.20100656e-01f, -6.97295740e-02f, 1.95325404e-01f, 1.45857409e-01f, 3.53091657e-02f, 1.68224946e-01f, -2.41489351e-01f,
  5.90438470e-02f, 1.08152993e-01f, -2.04812005e-01f, -1.29806101e-01f, -2.44633332e-02f, 1.67025656e-01f, -4.10266012e-01f, -1.01910308e-01f, 4.87644132e-03f, 1.43245384e-01f,
  -7.17139393e-02f, -2.31270075e-01f, -9.84190032e-02f, -2.87749991e-03f, -8.91071782e-02f, 1.66991383e-01f, -9.68678389e-03f, -4.26229537e-02f, 1.60887673e-01f, -5.70534430e-02f,
  -5.82818463e-02f, -6.54029101e-03f, -5.82945012e-02f, -1.20334052e-01f, 7.39316791e-02f, -3.16458762e-01f, -2.34015465e-01f, -4.33489889e-01f, 3.79754044e-03f, 1.01611502e-01f,
  -1.20999506e-02f, 8.92289728e-02f, -2.51281005e-03f, 7.46472105e-02f, 6.02074414e-02f, 1.18940845e-01f, -1.41710848e-01f, -7.75843561e-02f, 9.14844573e-02f, 1.63453937e-01f,
  1.78597182e-01f, -2.40550950e-01f, -2.58652359e-01f, 2.04919338e-01f, 1.65662602e-01f, -2.72508897e-02f, 1.59398094e-01f, 1.20459564e-01f, 1.42519129e-03f, -1.09580509e-01f,
  -1.36721581e-01f, 1.76043689e-01f, -1.55362412e-01f, -1.37804329e-01f, 1.34608358e-01f, -2.77095973e-01f, 2.86463113e-03f, -5.99241816e-02f, 9.01076943e-02f, -2.43179858e-01f,
  -1.33352615e-02f, -1.26765713e-01f, 1.77115187e-01f, 1.15656354e-01f, -9.02678296e-02f, -2.08201766e-01f, -1.75345883e-01f, -7.45401606e-02f, -1.68821260e-01f, 6.99874945e-03f,
  5.40137216e-02f, 5.33434115e-02f, -1.95308566e-01f, 2.16961149e-02f, -1.94428772e-01f, 7.13622347e-02f, -7.80094564e-02f, -1.87834248e-01f, -1.67095270e-02f, 1.36814147e-01f,
  -1.98977754e-01f, -2.47464418e-01f, 2.40043625e-02f, 1.12977494e-02f, 1.33928940e-01f, -3.77126336e-02f, -1.24613911e-01f, 9.01202336e-02f, 1.03096552e-01f, 1.20496675e-01f,
  5.98726049e-02f, -2.21265391e-01f, 6.24432825e-02f, -2.41848797e-01f, 6.15375936e-02f, -7.29129836e-02f, -1.90937903e-03f, -1.05594866e-01f, -1.01497769e-01f, 1.59867883e-01f,
  7.72140250e-02f, 3.52812409e-02f, 4.13891561e-02f, 4.32886668e-02f, 5.91129847e-02f, -8.95484537e-02f, -2.66386837e-01f, -4.20159064e-02f, 7.38666803e-02f, 1.01974502e-01f,
  -1.35941759e-01f, 4.95868959e-02f, -1.09029882e-01f, -2.28438631e-01f, 5.40959015e-02f, -1.26599878e-01f, -1.37374058e-01f, -1.76376343e-01f, 2.02850670e-01f, 1.83187872e-01f,
  -1.29635468e-01f, -1.81163386e-01f, -1.07681274e-01f, -2.00381055e-01f, -5.11245355e-02f, 1.95614710e-01f, 2.14236174e-02f, 2.08276153e-01f, -1.33832917e-01f, 5.64594604e-02f,
  -1.65587202e-01f, 1.98457450e-01f, -7.43504316e-02f, -2.36744061e-02f, 1.36182502e-01f, -3.99075113e-02f, -1.39669359e-01f, -9.34039578e-02f, 4.62379195e-02f, -2.27847636e-01f,
  1.12798020e-01f, -9.40072071e-03f, 1.50033593e-01f, -1.70747429e-01f, 2.94409562e-02f, -2.99309552e-01f, 2.32828200e-01f, 8.34919438e-02f, 2.23567471e-01f, 7.14456961e-02f,
  4.93219085e-02f, -1.80735990e-01f, -6.01164885e-02f, -2.41034120e-01f, -1.94600135e-01f, -8.63911733e-02f, -2.32700557e-01f, 1.40758634e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.09649166e-01f, -1.80553049e-02f, -7.96634033e-02f, 2.02992614e-02f, 3.55263539e-02f, 7.82694444e-02f, -8.11743066e-02f, 1.16634741e-01f, 3.27908956e-02f, 1.10729620e-01f,
  -3.99999358e-02f, 1.05570994e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    