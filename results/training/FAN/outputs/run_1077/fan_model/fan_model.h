/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.32152835e-02f, 1.42087534e-01f, 1.33349253e-02f, 4.22258787e-02f, 1.76977277e-01f, 4.90082651e-02f, 1.16309077e-01f, -9.27415788e-02f, -2.74511930e-02f, 7.52288401e-02f,
  5.05371653e-02f, 1.53817475e-01f, 1.81505065e-02f, 4.87084165e-02f, -4.44948627e-03f, 1.61385998e-01f, 1.38679653e-01f, 3.84180509e-02f, 2.17029154e-02f, 2.31471628e-01f,
  2.98850685e-01f, 7.91898146e-02f, -1.29833192e-01f, 1.49487136e-02f, 2.71664619e-01f, 1.82810828e-01f, -7.06642792e-02f, -8.70132446e-03f, 1.14953056e-01f, 2.74271578e-01f,
  1.09349392e-01f, -8.27453509e-02f, -1.68725699e-02f, 3.27275246e-02f, -2.59071798e-03f, -2.68994048e-02f, 6.91701099e-02f, 2.46571340e-02f, -6.94728792e-02f, -4.13417257e-02f,
  -2.88638808e-02f, 5.79919331e-02f, -1.03761181e-02f, 4.86488268e-03f, 5.20202368e-02f, -2.76054908e-02f, -3.16687883e-03f, -1.62111018e-02f, -5.35733579e-03f, 6.32717693e-03f,
  1.28832698e-01f, 1.04154430e-01f, 5.37559390e-03f, -1.00900128e-01f, -4.72426154e-02f, -1.00464234e-02f, -6.43559638e-03f, -6.08621165e-02f, -1.85019359e-01f, 8.64191502e-02f,
  -9.82681364e-02f, 4.90035228e-02f, 1.42374307e-01f, 1.07796684e-01f, 2.52398998e-02f, 1.80990081e-02f, 2.97956839e-02f, 9.25750136e-02f, 6.36684150e-02f, 7.65740573e-02f,
  -2.92223096e-02f, -1.20360116e-02f, 4.79919091e-03f, 2.89567038e-02f, 8.98786038e-02f, 4.88460138e-02f, 1.19185157e-01f, 6.11824282e-02f, -5.00241853e-03f, -9.75764543e-02f,
  -1.09771863e-02f, 5.09334786e-04f, -1.15511604e-02f, 8.52557421e-02f, 1.00985698e-01f, -1.17631638e-02f, 8.09639245e-02f, 5.06721251e-02f, 5.78674674e-02f, 3.23714502e-02f,
  2.29101896e-01f, -2.94775397e-01f, 7.35793635e-02f, 8.65086541e-02f, -7.05256611e-02f, -4.03847359e-02f, -3.34112756e-02f, -3.38883400e-02f, 1.15674116e-01f, 3.16102654e-02f,
  1.19632550e-01f, -1.21767083e-02f, 4.36440483e-03f, 7.47452304e-02f, 6.33235574e-02f, -3.57061699e-02f, -3.31882685e-02f, 1.35093167e-01f, 5.94283566e-02f, 5.00594564e-02f,
  -2.78627314e-02f, 6.03272170e-02f, 1.58257306e-01f, 1.28016369e-02f, 4.71907184e-02f, 9.82377529e-02f, 1.26556382e-01f, 1.76299259e-01f, 5.21964133e-02f, 1.12494469e-01f,
  2.43885979e-01f, -2.97238380e-01f, -1.74496442e-01f, -2.04909816e-02f, 7.99633861e-02f, 1.51465550e-01f, -1.80354133e-01f, 6.77488372e-02f, 9.72041860e-02f, -3.54468301e-02f,
  1.38589919e-01f, 2.48201981e-01f, 5.89097291e-02f, 2.42723506e-02f, 1.20334797e-01f, -2.61934131e-01f, -2.53773600e-01f, -4.60245349e-02f, 2.82418698e-01f, 2.35743314e-01f,
  9.61713642e-02f, -5.40134013e-02f, -3.53716202e-02f, -5.57878613e-02f, -3.13740224e-02f, 8.13687220e-02f, -1.96189135e-02f, -4.86253053e-02f, -7.32311383e-02f, -2.73877978e-01f,
  1.38589442e-01f, 6.50871247e-02f, 5.85504957e-02f, 1.73357700e-03f, -8.98567960e-03f, 1.14236459e-01f, 1.51471691e-02f, 7.67537355e-02f, 1.89352911e-02f, -2.54333508e-03f,
  2.56014969e-02f, 1.69633273e-02f, 3.09024230e-02f, -1.73465386e-02f, 1.63732599e-02f, 7.13804737e-04f, -1.66438911e-02f, -3.38864722e-03f, -8.59369338e-02f, 9.53342244e-02f,
  -1.56637862e-01f, -7.98352584e-02f, 1.27727941e-01f, -7.73644373e-02f, 1.01778507e-01f, 1.17771573e-01f, -5.79148047e-02f, 3.24863158e-02f, -8.35369714e-03f, 2.52340771e-02f,
  -1.82639614e-01f, -1.19801648e-01f, -2.29168180e-02f, -1.43164814e-01f, 2.30007749e-02f, 5.17232679e-02f, -5.18507920e-02f, -3.96742970e-02f, -3.66815180e-02f, 5.85420690e-02f,
  1.12452423e-02f, 9.53655876e-03f, 1.52329844e-03f, 3.69230583e-02f, -1.41975917e-02f, -2.21276786e-02f, 4.39905934e-02f, -8.70006010e-02f, -6.41072914e-02f, -4.21923585e-02f,
  -2.29800884e-02f, 3.93423066e-02f, 2.48184688e-02f, 5.10746948e-02f, -4.45238352e-02f, -4.18735445e-02f, -7.41128027e-02f, 4.14307788e-02f, -9.34156030e-02f, -5.56328474e-03f,
  1.57917306e-01f, -3.33682150e-02f, 4.13286798e-02f, 6.64902776e-02f, 8.35672989e-02f, -3.73079330e-02f, 6.57003373e-02f, 4.46287431e-02f, -3.02340016e-02f, 3.25881131e-02f,
  7.44111091e-02f, -9.19901533e-04f, 5.53698465e-02f, -1.13529135e-02f, 9.03758127e-03f, 1.05560087e-01f, -1.53015599e-01f, -2.69767381e-02f, -1.57105979e-02f, 5.40888049e-02f,
  -6.51870295e-02f, 1.32156238e-01f, 1.68700889e-01f, 8.43903422e-02f, 1.29298037e-02f, 1.91099182e-01f, 1.48014069e-01f, 1.59049064e-01f, 9.01853815e-02f, 6.87395856e-02f,
  2.72690743e-01f, 1.44056931e-01f, -7.09686801e-02f, 1.63466886e-01f, -1.88269615e-01f, -3.79097104e-01f, -4.18288141e-01f, -3.77863124e-02f, 1.55049339e-01f, 9.15206596e-02f,
  -5.55857318e-04f, 1.43196151e-01f, 6.46374598e-02f, 7.54438415e-02f, -2.15150535e-01f, -2.92616785e-01f, -7.36317784e-02f, -4.00962569e-02f, -2.12580308e-01f, -2.31147204e-02f,
  -2.11533625e-02f, 2.93600708e-02f, 2.61868626e-01f, 6.88459724e-02f, 1.88263461e-01f, -8.77009258e-02f, 8.73375311e-02f, 7.82340616e-02f, 1.32134119e-02f, 2.66423076e-01f,
  5.00050336e-02f, 1.99566007e-01f, -3.82190049e-02f, 4.26254310e-02f, 4.72255237e-02f, 1.27916336e-01f, -4.79723774e-02f, 1.32049978e-01f, -4.15574498e-02f, 9.08759981e-02f,
  1.01976804e-01f, 7.64661878e-02f, 4.55574431e-02f, 1.45260766e-01f, -2.76056156e-02f, 3.82205378e-03f, 3.44549045e-02f, 4.32134345e-02f, 3.28172930e-02f, 2.19139643e-02f,
  4.77747247e-03f, 1.89796835e-02f, -2.60504782e-02f, -1.40053660e-01f, 4.50658947e-02f, 6.08831197e-02f, -5.19232675e-02f, 8.33714753e-02f, 3.72081250e-02f, 5.66348247e-02f,
  3.52500501e-04f, -4.00043242e-02f, -3.11307865e-03f, -3.01837865e-02f, -3.01651973e-02f, 4.49507609e-02f, -3.62895727e-02f, -3.15605216e-02f, 1.99392866e-02f, 8.94708466e-03f,
  1.40202901e-04f, -7.45565072e-03f, -5.51450439e-02f, 6.80489242e-02f, -1.15706678e-02f, -7.08770826e-02f, -3.42323594e-02f, 4.69405353e-02f, -3.10492178e-04f, 9.04376730e-02f,
  7.15678781e-02f, -5.88197373e-02f, 4.84440662e-02f, 2.44300328e-02f, -3.18167582e-02f, -6.25184178e-02f, 6.26698062e-02f, -1.07990010e-02f, 2.23124004e-03f, 3.14791873e-02f,
  -1.14981301e-01f, -1.58857763e-01f, 5.42299822e-02f, 1.02676108e-01f, 5.19686379e-02f, 1.14480443e-01f, -4.48726304e-03f, -3.39960083e-02f, 9.58274454e-02f, -7.23876758e-03f,
  -9.56862583e-04f, 3.46290283e-02f, -3.37460660e-04f, -1.34076411e-02f, 2.13244595e-02f, 2.06980705e-02f, 1.86519101e-02f, -5.95213771e-02f, -3.34938765e-02f, -2.42283400e-02f,
  -4.85372245e-02f, -8.35574940e-02f, -1.74706116e-01f, -8.16031024e-02f, -1.02692187e-01f, -1.28882349e-01f, -6.14186898e-02f, -5.63855357e-02f, -1.86528891e-01f, -2.26409033e-01f,
  4.83374864e-01f, 9.24886093e-02f, 2.62982041e-01f, 2.61817485e-01f, 3.50154459e-01f, 2.16840982e-01f, 3.74151945e-01f, 2.15686768e-01f, 1.21314682e-01f, 2.05102667e-01f,
  2.35366691e-02f, 1.22000731e-03f, 4.25147600e-02f, 2.35712416e-02f, 9.36361328e-02f, 2.99159020e-01f, 3.21382552e-01f, 2.51724303e-01f, 2.36125857e-01f, 2.06781745e-01f,
  9.15403813e-02f, 1.70894712e-01f, 1.63968980e-01f, 4.94161956e-02f, 1.62145436e-01f, 4.65846471e-02f, 1.19718455e-01f, 3.89427729e-02f, 3.72003093e-02f, 6.21126741e-02f,
  2.66063243e-01f, 5.87600060e-02f, 2.26919502e-02f, -5.64301163e-02f, 6.46587275e-03f, -4.49917130e-02f, 6.87686121e-03f, -1.43382773e-01f, -1.01344481e-01f, 2.09548585e-02f,
  5.89320138e-02f, 7.08018169e-02f, -2.62181293e-02f, 3.74293514e-02f, 2.12046672e-02f, 3.94116975e-02f, 3.62186432e-02f, 1.05170354e-01f, 6.89386129e-02f, -1.02513924e-01f,
  4.12283316e-02f, -3.70868593e-02f, -6.48068264e-02f, -3.45455334e-02f, -9.35666487e-02f, -8.82912576e-02f, -5.51998392e-02f, 3.10005359e-02f, -6.84582591e-02f, 1.01966485e-02f,
  -1.40934095e-01f, -5.83928749e-02f, 7.83220381e-02f, -4.01391536e-02f, -3.30760404e-02f, -1.41644450e-02f, 1.03925943e-01f, 8.87579322e-02f, 1.10457063e-01f, -8.36329460e-02f,
  1.23079019e-02f, -5.47695979e-02f, 5.93097471e-02f, -4.99754362e-02f, -5.05808415e-03f, 3.62103730e-02f, 2.86704954e-02f, -2.91808341e-02f, -1.20074354e-01f, -1.09090302e-02f,
  -1.56749301e-02f, -1.14436038e-02f, 1.22887059e-03f, 2.14449689e-03f, -2.13144366e-02f, -3.38869356e-02f, -3.20900492e-02f, 1.74022149e-02f, -4.42379452e-02f, 4.17787656e-02f,
  3.17682289e-02f, -1.44632578e-01f, -9.15042404e-03f, 7.16389045e-02f, 4.92256805e-02f, -8.72554332e-02f, -2.58187633e-02f, 1.35463150e-02f, 1.41996099e-02f, 5.10959700e-02f,
  2.73964833e-02f, -2.92606689e-02f, -5.02790101e-02f, -1.15963696e-02f, 5.60896248e-02f, 5.31497672e-02f, -3.50224450e-02f, 6.30670935e-02f, -7.58780465e-02f, -1.84337161e-02f,
  4.22652774e-02f, 1.50792032e-01f, 9.55998898e-02f, 5.48509732e-02f, 2.35239789e-02f, 1.49119318e-01f, -6.33495599e-02f, -1.49486931e-02f, 3.46352644e-02f, 9.70699415e-02f,
  2.12021768e-01f, -2.69446194e-01f, -3.30010235e-01f, 9.06980261e-02f, 1.82395745e-02f, -1.70774937e-01f, -3.34768325e-01f, -4.78212498e-02f, 1.35954246e-01f, 2.13801805e-02f,
  2.65677243e-01f, 3.29361022e-01f, 1.61316752e-01f, 1.07097790e-01f, -8.27764198e-02f, -3.69651228e-01f, -3.85895550e-01f, -1.41285494e-01f, 1.27815947e-01f, 1.06392309e-01f,
  1.46110371e-01f, 1.56562433e-01f, 1.25618011e-01f, 5.80078457e-03f, 4.65894714e-02f, 2.90497839e-02f, -1.36928141e-01f, -2.22660638e-02f, -1.14696912e-01f, -2.03159302e-01f,
  -1.02594025e-01f, -1.54538341e-02f, 1.95045639e-02f, 8.46245587e-02f, 7.96995461e-02f, -7.45168105e-02f, -5.57794720e-02f, 3.46610416e-03f, 1.89616326e-02f, 1.03806565e-02f,
  1.40649810e-01f, 1.16828173e-01f, 8.13879594e-02f, -1.29421419e-02f, 5.54012060e-02f, -4.77844430e-03f, -6.52788393e-03f, -9.48751494e-02f, -1.49472043e-01f, -6.87591285e-02f,
  8.02687183e-02f, 4.33750823e-02f, -1.28872752e-01f, -2.42530350e-02f, -1.28399014e-01f, 5.45298122e-02f, 5.60118258e-02f, -4.06287843e-03f, -4.56656218e-02f, -1.49953932e-01f,
  3.33756544e-02f, -3.24125253e-02f, -2.67651919e-02f, 3.49227190e-02f, -3.18885967e-02f, 2.98087578e-02f, 6.56262711e-02f, -2.60704733e-03f, 1.08394083e-02f, -1.81862190e-02f,
  3.06230802e-02f, -1.40044037e-02f, 4.97626886e-03f, -6.23945296e-02f, 1.76032372e-02f, -6.41137660e-02f, -9.30717811e-02f, 3.48844789e-02f, -1.06126238e-02f, 1.60283800e-02f,
  -3.12853581e-03f, 3.07426844e-02f, 1.06103793e-02f, 3.14037986e-02f, -7.19046816e-02f, -3.31714228e-02f, -7.55577255e-03f, 4.51871939e-02f, 2.42877249e-02f, 1.93521695e-03f,
  4.60929126e-02f, 2.53932700e-02f, 4.67195511e-02f, -2.49888785e-02f, -7.32818022e-02f, -1.33889422e-04f, -3.22504565e-02f, 5.99280139e-03f, 6.73144730e-03f, -2.25627571e-02f,
  -9.34423786e-03f, 1.26510151e-02f, 7.27534620e-03f, -4.90719802e-04f, 5.89317083e-03f, 9.90011916e-03f, 6.02350794e-02f, 8.36309418e-02f, -4.11557965e-02f, -2.05607153e-02f,
  -5.55223711e-02f, -5.00885770e-02f, 7.14820176e-02f, 2.94002406e-02f, -5.28202392e-02f, 4.10935171e-02f, -8.42435509e-02f, 2.04656124e-02f, -1.89530298e-01f, -2.10887790e-01f,
  5.68711609e-02f, -6.82227239e-02f, -1.16592556e-01f, -6.50722012e-02f, 1.40593454e-01f, 3.75780165e-01f, 4.26402479e-01f, 3.03806037e-01f, 1.19601361e-01f, 7.74996281e-02f,
  1.53654829e-01f, -1.63616259e-02f, -1.55290524e-02f, 5.16072400e-02f, 2.49127075e-02f, -4.57458533e-02f, -1.86528429e-01f, -1.67782575e-01f, 6.76171631e-02f, 1.51637271e-01f,
  4.85834107e-02f, -7.66074136e-02f, -1.14369430e-01f, 9.01716668e-03f, -1.74145922e-01f, -7.04467595e-02f, -9.71267894e-02f, -1.98002696e-01f, -1.88936666e-01f, -4.05777901e-01f,
  -1.75903633e-01f, -2.93460004e-02f, 1.89710818e-02f, -1.24391295e-01f, -1.03507578e-01f, -1.28283640e-02f, -5.85501082e-02f, -1.65769055e-01f, -6.66381270e-02f, -9.21742022e-02f,
  -3.05683762e-02f, -1.20275086e-02f, -1.21710368e-01f, -4.37726639e-02f, -1.05286263e-01f, -4.96712103e-02f, -1.37262240e-01f, -1.10338524e-01f, -1.60440728e-01f, 6.58818195e-03f,
  -1.39611989e-01f, -1.29676610e-01f, -1.16875619e-01f, 5.32290637e-02f, 2.89898049e-02f, -1.21470824e-01f, -2.29393411e-02f, 8.91994219e-03f, -1.38656408e-01f, -2.01005518e-01f,
  8.82995606e-04f, 1.36892214e-01f, 3.87091041e-02f, -7.59571642e-02f, 1.13607980e-02f, 5.34952059e-02f, -4.29544337e-02f, 6.28535748e-02f, 1.38051361e-01f, 1.06737800e-02f,
  9.39847827e-02f, -1.32313827e-02f, 6.05627820e-02f, -1.38355838e-02f, -5.24811854e-04f, 8.68567079e-02f, 1.05298497e-01f, -3.87124419e-02f, -6.99543674e-03f, 1.87693648e-02f,
  -1.44836807e-03f, 1.48161486e-01f, 8.71560946e-02f, -4.47454862e-02f, -3.79008725e-02f, 2.47558765e-03f, 1.05024315e-01f, 1.29386127e-01f, 3.40605155e-02f, 1.70134425e-01f,
  2.37080790e-02f, -5.73964678e-02f, -1.20303378e-01f, -6.24952093e-03f, -4.26772907e-02f, 1.39521882e-02f, -9.71221253e-02f, -5.55353202e-02f, -3.39028537e-02f, -3.70355733e-02f,
  2.00899802e-02f, 4.05314527e-02f, -1.55640626e-02f, 2.33915239e-03f, 1.21416882e-01f, -1.03737216e-03f, -1.32987350e-02f, -9.94995385e-02f, -5.15159331e-02f, 6.20130822e-02f,
  3.06814592e-02f, 1.34463295e-01f, 1.30010754e-01f, 7.42404023e-03f, 2.19338685e-02f, 3.03982262e-04f, 7.85628483e-02f, 8.05257931e-02f, -8.13798420e-03f, 2.13505015e-01f,
  -2.63150185e-01f, 1.36148721e-01f, 8.71012807e-02f, -2.10089181e-02f, 2.59770542e-01f, 1.35822564e-01f, 1.86743170e-01f, -9.06879008e-02f, -1.41323954e-01f, 1.30847484e-01f,
  1.37759998e-01f, 2.09124133e-01f, 1.20102391e-01f, 1.25162423e-01f, 6.71628341e-02f, 1.47936121e-01f, 1.30530670e-01f, 4.28600982e-02f, -1.21623101e-02f, -1.21024176e-01f,
  1.67051945e-02f, -4.77230996e-02f, -1.54332817e-01f, -1.70431018e-01f, -5.95458634e-02f, 3.12063750e-02f, 1.86238103e-02f, 2.62215901e-02f, 5.34632429e-02f, 9.17995796e-02f,
  3.00708860e-01f, -1.46108806e-01f, 9.92823858e-03f, -1.83168389e-02f, 9.15216506e-02f, -4.37743068e-02f, 8.00583512e-02f, -2.18643472e-02f, -1.24595566e-02f, 8.97229686e-02f,
  1.45666465e-01f, 6.11976162e-02f, 3.90875004e-02f, -1.80236083e-02f, -5.37284687e-02f, 2.29766197e-03f, -1.17416449e-01f, -9.80524197e-02f, -3.66707938e-03f, -9.38180313e-02f,
  -3.29182968e-02f, 3.13798040e-02f, 4.02393378e-02f, -6.73186854e-02f, 3.52071673e-02f, -4.59975563e-02f, 5.55891059e-02f, -6.24904707e-02f, -1.74949132e-02f, -1.77976102e-01f,
  -2.41298042e-02f, 1.11368008e-01f, 6.29406050e-03f, -3.95064130e-02f, 8.70468393e-02f, -1.43180704e-02f, -2.58877338e-03f, 1.92082692e-02f, -2.83066481e-02f, 1.78280415e-03f,
  -3.35910581e-02f, 1.36579737e-01f, 5.44684008e-04f, 6.79837987e-02f, 9.67373848e-02f, 7.79743269e-02f, 5.91728128e-02f, -1.14077413e-02f, 1.31328143e-02f, 1.19112432e-02f,
  1.12822838e-01f, 2.46824678e-02f, 4.70834151e-02f, -6.09108508e-02f, 8.72026011e-02f, -3.56370248e-02f, 4.95173596e-02f, 1.19711794e-02f, -7.27614909e-02f, 8.53397995e-02f,
  1.43936098e-01f, 9.35302395e-03f, 6.01796135e-02f, -1.44020870e-01f, 5.14910072e-02f, -6.76549152e-02f, 4.55520637e-02f, -8.04742333e-03f, 3.58299352e-02f, -2.76900660e-02f,
  -2.91811228e-02f, -1.06896851e-02f, 8.35848972e-02f, -3.39459516e-02f, -1.61756054e-02f, 1.94711629e-02f, -1.06697880e-01f, -4.92915958e-02f, 7.30203316e-02f, -1.90876741e-02f,
  -5.36801405e-02f, -3.06314006e-02f, 1.89385191e-02f, 1.78688411e-02f, -2.66363602e-02f, 9.45548639e-02f, -2.90387440e-02f, 1.57836848e-03f, 1.11272275e-01f, -1.60466552e-01f,
  1.83288425e-01f, 1.89938545e-01f, -1.52324796e-01f, -5.82393780e-02f, 1.96752269e-02f, 3.92564423e-02f, 2.97859609e-01f, 5.13662286e-02f, -1.97016254e-01f, 6.35690019e-02f,
  8.95399973e-02f, 4.68500070e-02f, -6.71732351e-02f, -3.00835334e-02f, 7.69094378e-02f, 7.36076236e-02f, -7.38532096e-02f, -1.78722888e-01f, -5.74620664e-02f, -7.75698572e-02f,
  -1.21808976e-01f, -1.03445500e-01f, -1.01704687e-01f, -2.03883573e-01f, 1.20838638e-02f, 7.74605796e-02f, -9.92587060e-02f, -3.52262035e-02f, 1.08781308e-01f, 4.47766483e-02f,
  9.40435100e-03f, 5.45196906e-02f, -1.33856356e-01f, -4.39581834e-02f, 1.47347739e-02f, -4.04213481e-02f, -4.00529578e-02f, -9.62605998e-02f, -8.27548578e-02f, -2.33297385e-02f,
  7.91866630e-02f, -7.36303953e-03f, 9.03829560e-03f, -9.14381891e-02f, -2.91734766e-02f, 7.42305145e-02f, -2.66386680e-02f, -1.26467839e-01f, 1.62057299e-02f, -3.56159955e-02f,
  8.31084922e-02f, 7.71662891e-02f, 4.08386625e-02f, 6.60804287e-02f, -8.76195058e-02f, 5.05327061e-03f, 1.54483803e-02f, 9.52133983e-02f, 5.68715781e-02f, 9.38751623e-02f,
  1.15804998e-02f, 3.13269161e-02f, -1.79621216e-03f, 2.57522129e-02f, -2.25618798e-02f, -4.26656567e-02f, -5.90727255e-02f, -2.20686533e-02f, -4.80761342e-02f, 7.21900165e-02f,
  5.20830117e-02f, 5.77805862e-02f, -8.56757015e-02f, 8.07229951e-02f, -4.58853804e-02f, -4.64002676e-02f, 2.70944182e-02f, 5.97860441e-02f, 1.11733139e-01f, 1.39834106e-01f,
  5.92493266e-02f, 4.94390875e-02f, 1.98127124e-02f, 6.08773297e-03f, 5.00876643e-03f, 4.93920548e-03f, 1.00583155e-02f, 2.46730838e-02f, 3.88616733e-02f, 3.96479387e-03f,
  -1.16524473e-01f, -5.99036999e-02f, 1.57281488e-01f, 5.05931042e-02f, 1.29636779e-01f, 4.24921364e-02f, 6.18027076e-02f, -4.14667018e-02f, -5.60749099e-02f, 4.07440476e-02f,
  4.16471921e-02f, 5.81862777e-02f, 4.72864956e-02f, -5.94377667e-02f, 6.76873326e-02f, 7.07316622e-02f, 1.67189211e-01f, 8.40087235e-02f, -7.99911190e-03f, -5.04255341e-03f,
  9.21603143e-02f, 1.41525939e-01f, 7.87258521e-02f, 1.17623940e-01f, 7.48485625e-02f, 1.36280641e-01f, -4.66594808e-02f, 1.43113747e-01f, 1.95540026e-01f, 2.33541146e-01f,
  -2.71477669e-01f, -6.24541119e-02f, -5.10150753e-02f, -1.68722421e-02f, -2.07619801e-01f, -2.56801218e-01f, -3.62596989e-01f, -3.21299911e-01f, -1.19162299e-01f, -1.83788076e-01f,
  1.23088546e-02f, 3.43576334e-02f, 8.80662203e-02f, 1.09330796e-01f, -1.66490212e-01f, -2.73591191e-01f, -2.41830781e-01f, -1.55008122e-01f, -1.67693302e-01f, -1.63770273e-01f,
  4.34809476e-02f, 4.50352859e-03f, -3.27184275e-02f, -6.33505359e-02f, -5.61633520e-02f, -2.81010140e-02f, -8.88259616e-03f, -1.04096502e-01f, -4.03083004e-02f, 3.36078070e-02f,
  1.46415368e-01f, -2.69973725e-01f, -6.68537766e-02f, -1.02930307e-01f, 3.22743552e-03f, -1.99707225e-01f, -1.16941236e-01f, -1.17475145e-01f, -1.37453198e-01f, -1.48198649e-01f,
  -1.41748518e-01f, -9.24647748e-02f, -4.82775718e-02f, -3.14679593e-02f, -6.56172037e-02f, -1.65586010e-01f, -1.65071443e-01f, -1.74064934e-01f, -6.66387081e-02f, -4.97145057e-02f,
  -5.74228652e-02f, -8.88170302e-02f, -1.99404135e-01f, -1.15407489e-01f, -1.95445329e-01f, -1.59983486e-01f, -1.23304047e-01f, -9.69211310e-02f, -2.21996784e-01f, -1.55082494e-01f,
  -6.82039782e-02f, 1.06851853e-01f, 7.60408342e-02f, 6.48194626e-02f, 1.10507391e-01f, 1.24500655e-01f, 1.28611669e-01f, 1.23381808e-01f, 8.69247988e-02f, 6.89877868e-02f,
  1.16719529e-01f, 8.35392773e-02f, 1.15190789e-01f, 1.06763169e-01f, 1.03967145e-01f, 1.17228888e-01f, 9.01429802e-02f, 9.12640616e-02f, 1.01402432e-01f, 8.51226524e-02f,
  2.53843199e-02f, 4.92563099e-02f, 1.29938543e-01f, 5.75376190e-02f, 1.57338560e-01f, 3.72423492e-02f, 1.24707617e-01f, 2.59330124e-02f, 1.40260115e-01f, 1.72704551e-02f,
  2.32151270e-01f, -9.05917734e-02f, 4.39932160e-02f, -4.66471836e-02f, -1.40630916e-01f, -7.79311657e-02f, -6.51027039e-02f, -1.17977798e-01f, -6.89748733e-04f, -1.05680764e-01f,
  -7.84302503e-02f, -1.27295986e-01f, 1.41141284e-02f, -4.34731320e-02f, -7.84228146e-02f, -8.92995298e-02f, -7.01314211e-02f, -4.30181921e-02f, -7.47737363e-02f, -3.69641446e-02f,
  1.31449651e-03f, -1.22461453e-01f, 2.87954491e-02f, -6.30113184e-02f, -1.02592073e-01f, -1.69847645e-02f, 1.28158461e-02f, -9.53673199e-02f, -1.02548383e-01f, 1.33913634e-02f,
  6.53950125e-02f, 2.19447330e-01f, -9.77756456e-02f, 1.68415740e-01f, -2.78605241e-02f, -1.65227190e-01f, -1.32605676e-02f, -1.17152989e-01f, -7.60340095e-02f, 1.84564605e-01f,
  1.14156239e-01f, -1.51658714e-01f, -7.89970998e-03f, -1.15167871e-01f, -2.36365005e-01f, 7.63365403e-02f, 1.28452733e-01f, -2.06180617e-01f, -4.41097915e-01f, -3.04609776e-01f,
  2.38868315e-02f, 1.79260567e-01f, 7.10027525e-03f, -1.00833230e-01f, 1.30296037e-01f, -5.41626476e-02f, 5.40327504e-02f, 8.37417170e-02f, -7.88489580e-02f, 2.40006030e-01f,
  -1.39510900e-01f, 5.45654353e-03f, -1.77797168e-01f, 3.20946574e-02f, -4.32639048e-02f, -6.58037066e-02f, -7.50467405e-02f, -1.64587915e-01f, -2.92830542e-02f, -7.27232769e-02f,
  -3.10760569e-02f, -8.59213714e-03f, -1.42547134e-02f, -6.55769184e-02f, -1.27555691e-02f, -1.18192911e-01f, -5.66766299e-02f, -9.65173021e-02f, -1.53254882e-01f, -5.08154035e-02f,
  6.65310919e-02f, 7.44075105e-02f, -7.69735174e-03f, -1.21665642e-01f, -2.08029702e-01f, -1.29880190e-01f, 6.74835779e-03f, -8.01225156e-02f, -7.59407580e-02f, -8.73497650e-02f,
  1.00662455e-01f, 8.44594836e-03f, 1.19065950e-02f, -4.83547002e-02f, 1.37304693e-01f, 5.94213791e-02f, -1.07404683e-02f, 9.75097790e-02f, -1.36359604e-02f, 3.53435017e-02f,
  -5.17581962e-02f, 8.97594839e-02f, -7.31841922e-02f, 3.01025398e-02f, 6.67284057e-02f, 5.92253078e-03f, -1.34313051e-02f, 5.23795560e-02f, -3.36957686e-02f, 5.69531918e-02f,
  -4.28011129e-03f, 9.61162709e-03f, 1.15570173e-01f, -1.17648549e-01f, 2.96808165e-02f, 3.57822739e-02f, -1.05098858e-02f, 1.02003627e-02f, 1.12900749e-01f, 4.67370823e-02f,
  -1.55468434e-02f, -2.94419769e-02f, -2.88927089e-02f, -8.15084502e-02f, -5.42548625e-03f, -1.13907605e-01f, 4.54480434e-03f, -9.10465568e-02f, -7.11188689e-02f, -8.72727409e-02f,
  -5.07386848e-02f, -1.45994708e-01f, -2.54746322e-02f, -3.26162949e-02f, -1.25116691e-01f, -6.20832630e-02f, 4.38726619e-02f, -1.18433505e-01f, -6.31391332e-02f, 7.69130187e-03f,
  6.83688149e-02f, -1.06607735e-01f, -1.63827688e-01f, -7.32316524e-02f, -3.32517847e-02f, -4.14748229e-02f, -1.73249066e-01f, -1.73955336e-01f, -1.93356693e-01f, 2.51730904e-02f,
  -2.12822040e-03f, -1.47666812e-01f, 7.26122037e-02f, -1.33737832e-01f, -6.01798557e-02f, 2.38011610e-02f, -3.61609496e-02f, -1.58200960e-03f, 3.52908410e-02f, -2.06371799e-01f,
  -1.66471630e-01f, 7.31098130e-02f, 3.47542751e-04f, 1.07015088e-01f, 2.11982340e-01f, 1.35860117e-02f, -1.76751852e-01f, 2.82621264e-01f, 4.07389820e-01f, 6.85787797e-02f,
  4.57110777e-02f, -7.55403042e-02f, 3.61005664e-02f, -1.53948748e-02f, -1.73026934e-01f, 1.30170301e-01f, -1.09480746e-01f, -1.73210204e-01f, 1.21346265e-02f, -3.24140102e-01f,
  -8.91549047e-03f, -1.43056601e-01f, 1.37271121e-01f, 1.06273638e-02f, -8.47168937e-02f, -3.74797322e-02f, 6.07218407e-02f, 5.97071238e-02f, 2.02694796e-02f, -4.95459102e-02f,
  -2.35477532e-03f, -5.47822379e-02f, -1.21570192e-01f, 3.79701592e-02f, -3.39033753e-02f, -6.06061406e-02f, -1.28684729e-01f, 7.41203353e-02f, 4.21108156e-02f, -5.89429401e-02f,
  -6.75460622e-02f, 6.74967282e-03f, 1.21966517e-03f, -4.93703038e-02f, 5.48350625e-02f, 1.86838508e-02f, 1.87487621e-02f, -5.74135892e-02f, 1.17922559e-01f, -1.23364307e-01f,
  7.45505420e-03f, -8.74303505e-02f, 2.69300379e-02f, 5.02813347e-02f, -5.61196357e-02f, 4.04684357e-02f, 6.31165365e-03f, 2.89265569e-02f, -2.27584597e-02f, 8.57833177e-02f,
  -7.28615187e-03f, 7.52312541e-02f, 2.36711912e-02f, 8.68950635e-02f, 4.31215875e-02f, 2.31212210e-02f, 7.31537715e-02f, 3.92965972e-02f, 2.71417014e-02f, 5.26013151e-02f,
  -5.77471917e-03f, 7.37627074e-02f, -3.21114957e-02f, 1.16955414e-01f, 1.28678959e-02f, 1.79812293e-02f, 1.22755729e-02f, 7.50578120e-02f, 7.58154504e-03f, -7.00693205e-02f,
  5.79061732e-02f, 1.14849545e-02f, -3.38508859e-02f, 2.12552045e-02f, -2.50651292e-03f, -2.04313383e-03f, -5.96588030e-02f, -4.83666062e-02f, -4.67683598e-02f, -1.80138312e-02f,
  1.54584749e-02f, 4.00337018e-02f, -4.38086577e-02f, -4.29586321e-02f, 2.49153748e-02f, -1.45054050e-02f, -2.86060479e-02f, 2.11869590e-02f, 2.04088464e-02f, -6.80788234e-02f,
  -1.61949247e-01f, 2.16093622e-02f, 8.05686936e-02f, 4.72499020e-02f, -4.08086479e-02f, 8.69953111e-02f, 1.46254748e-01f, 6.91882446e-02f, 2.77235180e-01f, 1.28054813e-01f,
  -5.44383228e-02f, 2.06923317e-02f, 1.21325068e-01f, -1.31109580e-01f, 1.19386517e-01f, 3.29909712e-01f, 4.55001682e-01f, 1.96745053e-01f, -1.68232322e-01f, 9.18752253e-02f,
  -9.23795104e-02f, -6.99335933e-02f, -2.45778281e-02f, -1.06558643e-01f, 5.39145321e-02f, 2.96619058e-01f, 8.74665454e-02f, -8.49348754e-02f, 1.51056901e-01f, 7.09944665e-02f,
  1.05698250e-01f, 5.06934337e-02f, -1.30545527e-01f, -7.10023716e-02f, -1.46149054e-01f, -5.02753742e-02f, -1.06529087e-01f, -1.00961022e-01f, -1.90102849e-02f, -2.76888907e-01f,
  1.55491726e-02f, -8.73300508e-02f, -4.66475077e-02f, -1.43953666e-01f, -9.07694325e-02f, -8.48218873e-02f, 4.64012735e-02f, -7.09532946e-02f, 3.22991051e-02f, 1.13594334e-03f,
  -7.38351494e-02f, 7.33902818e-03f, -2.65234243e-02f, -1.35795800e-02f, -2.10856814e-02f, -3.00885793e-02f, -8.60066339e-02f, -8.36542398e-02f, 4.42706048e-02f, -1.05293635e-02f,
  -5.71153015e-02f, -5.14196754e-02f, 1.56149338e-03f, 7.84130841e-02f, -3.81043367e-02f, -7.70378187e-02f, 3.24357152e-02f, -7.44658560e-02f, 7.20875785e-02f, 5.10546826e-02f,
  -2.95555051e-02f, 3.88210975e-02f, -1.71775576e-02f, 4.29010950e-03f, 5.56229800e-02f, 1.02661678e-03f, 1.24740591e-02f, 2.64557283e-02f, 3.59311886e-02f, 4.05255817e-02f,
  1.07579259e-02f, 4.86581353e-03f, 1.71657540e-02f, 3.45521942e-02f, -1.69232003e-02f, -9.28646768e-04f, -1.62288733e-02f, 4.39901203e-02f, -7.78296366e-02f, -3.49338166e-02f,
  -4.08985931e-03f, -1.48612661e-02f, 9.77239162e-02f, 2.66724862e-02f, 9.56455898e-03f, -4.01064008e-03f, 9.78401378e-02f, 8.77572410e-03f, 6.63665608e-02f, 1.41316671e-02f,
  1.02239503e-02f, -4.51502018e-02f, 1.59229673e-02f, 4.87376302e-02f, -4.01580073e-02f, -3.70531082e-02f, -2.07365490e-02f, -3.12770791e-02f, -1.06378995e-01f, 5.00850268e-02f,
  -3.84138115e-02f, -3.15545909e-02f, 1.89543813e-02f, -6.50646240e-02f, 5.38061224e-02f, -4.46266718e-02f, 5.35450224e-03f, 6.14334196e-02f, 1.30399289e-02f, -8.39493945e-02f,
  2.20138505e-02f, -4.76931315e-03f, 1.03307113e-01f, 4.22990173e-02f, 6.97091445e-02f, 5.57538494e-02f, 9.21893641e-02f, 7.40455091e-02f, 8.74526650e-02f, 1.70147538e-01f,
  -1.82146460e-01f, -2.04430461e-01f, -2.31213838e-01f, -2.00842366e-01f, 6.87231645e-02f, 7.53860995e-02f, -1.54074043e-01f, 7.57389190e-03f, -1.52177319e-01f, -1.75212339e-01f,
  1.22011662e-01f, 1.09659411e-01f, 1.35665178e-01f, 1.19485475e-01f, 9.98004451e-02f, -1.75725549e-01f, 3.91262863e-03f, 1.00532785e-01f, 1.18355691e-01f, 4.74135876e-02f,
  5.47907427e-02f, -2.09038913e-01f, -8.64227712e-02f, 5.08784922e-03f, -1.36747420e-01f, -1.44981772e-01f, -2.97735959e-01f, -3.97570170e-02f, 1.42779332e-02f, -1.40820280e-01f,
  -1.33875251e-01f, -7.76537582e-02f, 7.49857798e-02f, 2.71836128e-02f, -1.32880688e-01f, -1.23885222e-01f, -9.26304236e-02f, -1.18000790e-01f, -7.60356411e-02f, -8.77537653e-02f,
  -1.50932018e-02f, -2.82736458e-02f, -2.33119521e-02f, -7.75696570e-03f, -7.89798200e-02f, -2.45432719e-03f, -1.21147625e-01f, 8.51741806e-03f, -4.95678280e-03f, -1.01245753e-01f,
  1.62481389e-03f, -1.77855883e-02f, -7.75426403e-02f, -5.19877039e-02f, 3.96610387e-02f, 1.94433376e-01f, -1.09026566e-01f, -6.57917978e-03f, -9.38287079e-02f, -2.24395454e-01f,
  -6.67502061e-02f, -9.54336897e-02f, 5.78465797e-02f, 3.78630534e-02f, 4.52722013e-02f, 9.30112377e-02f, -1.63763557e-02f, -1.34111866e-02f, 3.58922929e-02f, -8.73541161e-02f,
  2.82774009e-02f, -8.77739396e-04f, 1.56813103e-03f, 1.58619508e-02f, -2.72095092e-02f, 4.30612415e-02f, 1.11170327e-02f, 1.44479387e-02f, 5.80963232e-02f, 5.82777290e-03f,
  8.94817039e-02f, 6.88895059e-04f, 6.01571705e-03f, -6.40811119e-03f, 8.69464129e-02f, -3.62208206e-03f, -6.40476681e-03f, 3.95931005e-02f, -3.25603634e-02f, -3.92028950e-02f,
  -1.86176300e-01f, 1.11675963e-01f, -2.32679024e-01f, -4.22134809e-02f, -1.78033054e-01f, -3.78632620e-02f, -1.52597383e-01f, -9.95975807e-02f, -1.57493055e-02f, -1.17138781e-01f,
  -5.59724085e-02f, -3.54938209e-02f, -1.23659514e-01f, -6.73379228e-02f, -1.41080916e-01f, -1.83766350e-01f, -1.72931161e-02f, -4.17213626e-02f, -5.49236089e-02f, -6.95752427e-02f,
  -8.68042856e-02f, -6.14837520e-02f, -1.25813827e-01f, -1.87497467e-01f, -9.89276245e-02f, -1.19038656e-01f, -1.49293482e-01f, -1.04049549e-01f, -9.11777690e-02f, -4.37137812e-01f,
  -3.11900109e-01f, 4.31635886e-01f, -1.07981833e-02f, -9.04329568e-02f, 2.62475619e-03f, -7.17951283e-02f, -7.77572393e-02f, 2.63443543e-03f, 8.21985379e-02f, 2.31605187e-01f,
  4.20520127e-01f, 2.86763698e-01f, 2.64030784e-01f, 1.19616412e-01f, 1.97103675e-02f, 7.93971587e-03f, -1.41102508e-01f, -1.32667407e-01f, -1.23155430e-01f, -9.71777458e-03f,
  1.63946241e-01f, 7.07727596e-02f, -1.82847846e-02f, 6.63399249e-02f, 1.29160538e-01f, 1.03871909e-03f, 1.09042577e-01f, 3.49923857e-02f, 2.24638388e-01f, 1.58716127e-01f,
  1.35411903e-01f, 4.52818014e-02f, 1.42042143e-02f, 1.78741798e-01f, 1.19545236e-01f, 2.11362734e-01f, 4.85757925e-02f, 2.24508822e-01f, 5.05993292e-02f, 2.11580753e-01f,
  9.40446109e-02f, 6.90334141e-02f, 4.81650420e-03f, 1.50651306e-01f, 4.80565289e-03f, 1.29496843e-01f, 1.32355064e-01f, 7.86700845e-02f, 1.06977619e-01f, 2.22257569e-01f,
  2.59503812e-01f, 7.98647627e-02f, 1.08392663e-01f, 1.47549242e-01f, 1.00953681e-02f, 7.81273842e-02f, 1.16896585e-01f, 9.13409516e-02f, 9.02608559e-02f, 2.57000118e-01f,
  1.39611483e-01f, -4.67605740e-02f, -8.19921866e-02f, -8.85149539e-02f, -9.47061256e-02f, -4.39929292e-02f, -9.87459570e-02f, -9.15868953e-02f, -1.42904475e-01f, -6.43253475e-02f,
  -2.62904428e-02f, -4.25983742e-02f, -1.06165938e-01f, -5.18034697e-02f, -8.79882183e-03f, -3.68367098e-02f, -1.44961953e-01f, -3.38409469e-02f, -1.98940951e-02f, -2.07970992e-01f,
  -7.61676058e-02f, -1.73856452e-01f, -1.24458931e-01f, -6.42979145e-02f, -8.70517790e-02f, -1.17856190e-01f, -9.85108390e-02f, -2.29685195e-02f, -1.31551642e-02f, -6.74360171e-02f,
  2.67690927e-01f, 9.59285870e-02f, 1.14289157e-01f, 2.21788185e-03f, -2.05317363e-02f, 7.57755786e-02f, 9.82216001e-02f, 9.72032547e-03f, -3.59058492e-02f, -5.78107359e-03f,
  5.33596389e-02f, -2.82677207e-02f, 6.13812320e-02f, 9.24497843e-02f, 4.99077179e-02f, 8.62476751e-02f, 1.27002746e-01f, 1.97991133e-02f, 5.95782399e-02f, 5.17668389e-02f,
  8.48306790e-02f, -2.41860412e-02f, -4.56732232e-03f, 6.37337044e-02f, -4.21520025e-02f, -2.17050072e-02f, 1.23856567e-01f, 5.17115332e-02f, -7.15262350e-03f, 1.00898288e-01f,
  5.67627311e-01f, -4.94874679e-02f, 2.42902357e-02f, 1.92161024e-01f, -2.07374856e-01f, -2.35066533e-01f, -4.28187847e-01f, -1.44319773e-01f, 1.10706329e-01f, -6.12767972e-02f,
  4.16006055e-03f, 2.79055744e-01f, 2.28808418e-01f, 2.58815318e-01f, 2.91006774e-01f, -2.56779581e-01f, -2.15881526e-01f, 3.04831952e-01f, 2.44511217e-01f, 8.75351951e-02f,
  -1.79956064e-01f, 9.84394923e-02f, 2.63197422e-01f, 1.29072636e-01f, -1.87193260e-01f, -3.17856297e-02f, -2.12943628e-01f, -3.13922111e-03f, -1.21399604e-01f, 8.74369033e-03f,
  1.54528186e-01f, 1.43145606e-01f, 7.49669150e-02f, 1.28254727e-01f, 8.35713297e-02f, 9.54235494e-02f, 4.81964201e-02f, 6.48412928e-02f, 1.05280235e-01f, -3.06925103e-02f,
  5.04484624e-02f, 1.79895479e-02f, 1.37714759e-01f, 2.27308180e-02f, 4.89804000e-02f, -1.98399257e-02f, 5.55017702e-02f, 1.85987681e-01f, 1.57242998e-01f, -3.38740423e-02f,
  8.20242893e-03f, 8.76502320e-02f, 1.01500958e-01f, 1.90297943e-02f, 7.77260065e-02f, 1.68267488e-01f, 8.89341980e-02f, 1.72236428e-01f, 1.25943244e-01f, 3.34027633e-02f,
  -5.12265153e-02f, 1.53299561e-02f, -6.93446491e-03f, -2.60618124e-02f, -7.74126276e-02f, -9.63431597e-02f, -2.96439286e-02f, -5.86183295e-02f, 1.10543310e-03f, -7.91079774e-02f,
  4.83088046e-02f, -5.67342155e-02f, 1.90822892e-02f, -5.39986677e-02f, -1.76214259e-02f, -1.01006338e-02f, -6.43260181e-02f, 7.00575486e-02f, -5.77815287e-02f, -1.03899978e-01f,
  -2.70321481e-02f, -1.22157400e-02f, 2.90185623e-02f, 1.83596294e-02f, 3.08887251e-02f, -2.01525539e-02f, 3.67854908e-02f, 2.88696531e-02f, -4.32645828e-02f, -3.81740555e-02f,
  -2.88356841e-02f, 5.49318865e-02f, 5.69515154e-02f, 1.23862632e-01f, 9.99227613e-02f, 1.23472646e-01f, 6.79113343e-02f, 1.02838613e-01f, 4.92656231e-03f, 1.23662896e-01f,
  1.14737950e-01f, 1.07049473e-01f, 3.83120850e-02f, 9.19835120e-02f, 9.67152789e-03f, 8.97810310e-02f, -2.47959904e-02f, 3.81645299e-02f, 1.02706701e-01f, -1.66484285e-02f,
  1.16446959e-02f, -4.26123813e-02f, 1.70376748e-01f, -1.73387844e-02f, 8.67100880e-02f, 4.08274308e-02f, -9.05503780e-02f, -1.26919867e-02f, 6.41020015e-02f, -1.58888265e-01f,
  2.90418208e-01f, -7.80494511e-02f, 3.91877085e-01f, 1.78141426e-02f, 6.95712864e-02f, 1.30907953e-01f, 5.84647730e-02f, 1.78874936e-02f, -8.46297666e-02f, -1.20470382e-01f,
  -2.26928592e-01f, 1.09666483e-02f, -1.54628092e-03f, 1.15265079e-01f, 3.27241242e-01f, 1.84087858e-01f, 2.81017214e-01f, 5.32432199e-01f, 4.82568979e-01f, 3.32539417e-02f,
  -1.75844207e-02f, -1.06982350e-01f, 8.52028430e-02f, 5.73024079e-02f, -4.38909717e-02f, 7.34425560e-02f, 9.01328623e-02f, 1.79683082e-02f, -2.73383502e-03f, 1.37233332e-01f,
  1.67966992e-01f, 3.64111662e-02f, 1.13323309e-01f, -3.56305055e-02f, 9.43956301e-02f, 1.61004085e-02f, -7.57134240e-03f, 1.33584470e-01f, 3.17207985e-02f, 7.28645176e-02f,
  8.14964995e-02f, 2.50605494e-02f, 1.01005167e-01f, 2.31961887e-02f, 1.09055132e-01f, 2.52977069e-02f, 6.84058294e-02f, 6.83485419e-02f, 6.92886636e-02f, -4.28495416e-03f,
  -1.98995117e-02f, -1.91418696e-02f, 1.02419868e-01f, 6.14873916e-02f, 1.53197333e-01f, 1.86219916e-01f, 2.19771620e-02f, -4.05785479e-02f, 1.16560116e-01f, -7.37552484e-03f,
  -2.29519550e-02f, 1.91777828e-03f, 4.25143689e-02f, -6.00608662e-02f, -5.85469753e-02f, -7.95577690e-02f, 1.81527976e-02f, -2.24254262e-02f, 6.35740608e-02f, -7.19742700e-02f,
  -3.35265733e-02f, -9.95866954e-04f, 5.95379993e-02f, -3.93444039e-02f, -6.93079606e-02f, 3.35559286e-02f, 3.34023521e-03f, -1.40056964e-02f, -3.70642543e-02f, -7.65450373e-02f,
  5.17477281e-04f, 7.30631128e-02f, 2.41510812e-02f, 5.47966845e-02f, -9.91847888e-02f, 4.07647640e-02f, 2.05070656e-02f, -5.15087321e-02f, -9.49091092e-02f, -3.90085950e-02f,
  3.82833816e-02f, 9.29239839e-02f, 4.72737700e-02f, 6.48173988e-02f, 2.54156571e-02f, 2.70501450e-02f, 4.98214178e-02f, 3.49186286e-02f, 4.04445976e-02f, 4.70931008e-02f,
  2.52763890e-02f, 1.05006896e-01f, 3.75887491e-02f, -1.68890338e-02f, 9.97829437e-02f, -2.53926683e-03f, -1.05350643e-01f, 9.46459621e-02f, 3.57846729e-02f, 1.52357267e-02f,
  -1.00016594e-01f, 1.87357888e-02f, 8.61998796e-02f, 1.28885150e-01f, -6.39617741e-02f, 8.98152217e-02f, 1.60152122e-01f, 1.14594996e-01f, 1.64567217e-01f, -7.57248029e-02f,
  -2.06982598e-01f, -4.96990047e-02f, 1.29244244e-02f, -1.85291380e-01f, 2.20151708e-01f, 1.34845883e-01f, 1.35574594e-01f, -1.63979426e-01f, -1.35961056e-01f, 2.63165869e-02f,
  2.07462952e-01f, 2.47208610e-01f, 2.61237323e-01f, 1.48700446e-01f, 1.39424905e-01f, 3.60108516e-03f, 4.00857180e-02f, 5.43002896e-02f, 1.89161971e-01f, 2.59086490e-01f,
  2.56449133e-01f, -5.95251992e-02f, -1.37005985e-01f, -4.82908189e-02f, -6.03891164e-02f, 2.58920580e-01f, -1.93193421e-01f, 2.22662743e-03f, 2.65542299e-01f, -2.42815223e-02f,
  3.42812985e-01f, -4.84395325e-02f, 7.43484348e-02f, 1.07082330e-01f, 2.42704656e-02f, -7.21334815e-02f, 1.14641353e-01f, -1.13294534e-01f, -9.47332475e-03f, 5.14784595e-04f,
  8.38968903e-02f, 8.92223120e-02f, 1.71473712e-01f, 4.91586961e-02f, 6.34763166e-02f, -3.77272852e-02f, -1.04976900e-01f, -1.64124310e-01f, -6.68210983e-02f, 9.81310606e-02f,
  2.03884825e-01f, 1.61614269e-01f, 2.70212404e-02f, 6.74509481e-02f, 4.07670401e-02f, 1.62432551e-01f, -1.60070974e-02f, 9.27184001e-02f, 1.13104850e-01f, -1.23446032e-01f,
  3.36502790e-02f, 2.06394047e-02f, -2.56911200e-02f, -1.88683011e-02f, -1.54819429e-01f, -7.83313252e-03f, -2.42174789e-02f, 6.06721118e-02f, -1.59227774e-02f, -9.18864310e-02f,
  -1.37665629e-01f, -1.19116060e-01f, -1.11973509e-01f, -1.61672235e-01f, -2.35400442e-02f, -1.19035505e-01f, -9.87590477e-02f, -4.22498919e-02f, -1.44024476e-01f, -1.26897722e-01f,
  1.63965952e-02f, -3.20250839e-02f, -1.60033956e-01f, -4.00335761e-03f, -3.64812016e-02f, 1.00573292e-03f, 8.73391330e-03f, -3.70453559e-02f, -8.91280621e-02f, -2.64683478e-02f,
  1.59243885e-02f, 1.33156314e-01f, 6.41234368e-02f, 8.36000293e-02f, 1.83095410e-01f, 1.15474649e-02f, 8.48592445e-02f, 8.80125836e-02f, 3.49261574e-02f, 3.60865332e-02f,
  1.72742158e-01f, 4.59949076e-02f, 4.40502539e-02f, 7.50881210e-02f, 1.00841351e-01f, 1.13731064e-01f, 5.09269349e-02f, 1.13613054e-01f, 1.34746999e-01f, 6.36248663e-02f,
  1.35363247e-02f, 1.91762999e-01f, 1.35453060e-01f, 8.89444128e-02f, 1.72731549e-01f, 1.59580335e-01f, 2.45230004e-01f, 6.45739511e-02f, 1.17561914e-01f, -6.17016628e-02f,
  -4.95049208e-01f, -4.78576533e-02f, 3.10070127e-01f, -1.40386313e-01f, -4.08707745e-02f, -1.52785880e-02f, -1.87089473e-01f, -2.44365290e-01f, -1.48401231e-01f, -3.27551328e-02f,
  -6.83386996e-03f, 1.79573540e-02f, -1.23515818e-03f, 1.65521637e-01f, -4.39392515e-02f, 2.08866879e-01f, 2.15330169e-01f, 1.88421369e-01f, -9.25947800e-02f, -1.09884068e-02f,
  -7.94196352e-02f, -3.34237404e-02f, -7.41029084e-02f, 8.54525417e-02f, 1.61484480e-01f, 1.48631826e-01f, 1.90553725e-01f, 7.01723173e-02f, 2.20851451e-01f, 3.84849370e-01f,
  7.66962469e-02f, -1.07354939e-01f, 9.56426337e-02f, -1.57395634e-03f, 1.19097486e-01f, 1.84207279e-02f, 7.57570192e-02f, 1.56214103e-01f, 1.44549027e-01f, 5.64554110e-02f,
  1.30766228e-01f, -1.86016280e-02f, 8.69341195e-02f, 6.99963272e-02f, 1.58772692e-02f, -1.50207952e-02f, 1.10349908e-01f, 3.95499021e-02f, 5.82452416e-02f, 1.13619991e-01f,
  2.04784513e-01f, 3.17149498e-02f, 8.74975289e-04f, 1.29033923e-01f, 1.50855839e-01f, -3.21171917e-02f, 1.27695799e-01f, 1.32606894e-01f, 8.34225491e-02f, 4.44837771e-02f,
  -1.64273709e-01f, 3.05231176e-02f, -3.46845645e-03f, -7.97251984e-02f, -3.78303230e-02f, -5.04024699e-02f, 8.41008797e-02f, -2.42853500e-02f, -2.38488298e-02f, -5.48522845e-02f,
  1.00038880e-02f, -5.31865060e-02f, -3.81053053e-02f, -6.57972917e-02f, 1.50070386e-02f, 3.83434258e-03f, 2.46395450e-02f, 8.33621528e-03f, -1.77113637e-02f, -7.52528803e-03f,
  -2.97465436e-02f, -6.57933438e-03f, -4.29166161e-04f, 3.77173047e-03f, -1.55048193e-02f, 9.70972478e-02f, -5.48211038e-02f, 9.55923647e-03f, 6.10000174e-03f, -6.22975230e-02f,
  -1.96724907e-01f, 1.85635760e-02f, -7.76279867e-02f, -3.26863006e-02f, 2.87670530e-02f, 1.54841736e-01f, 1.53527372e-02f, 1.11502282e-01f, -4.34497604e-03f, -3.79512236e-02f,
  -4.11169119e-02f, -2.62207296e-02f, -7.93100595e-02f, 1.43968359e-01f, 4.12956327e-02f, -1.27963955e-02f, 8.38843349e-04f, -4.45576385e-03f, 6.66136295e-02f, -1.84900649e-02f,
  -5.42474762e-02f, -2.41074450e-02f, -2.00238705e-01f, -1.53320851e-02f, -1.02891423e-01f, -8.42299759e-02f, -2.26671528e-02f, -3.74944997e-03f, -1.63064182e-01f, -1.33979842e-01f,
  -2.86293358e-01f, -1.22383848e-01f, -2.41260454e-01f, -4.87596989e-01f, -1.09733798e-01f, -8.11166689e-03f, -1.02914989e-01f, -2.03361642e-02f, -7.70014450e-02f, -2.07947373e-01f,
  5.97479939e-02f, 6.72516525e-02f, 1.36058688e-01f, 8.89372751e-02f, 1.58280134e-01f, -1.58829033e-01f, -3.13823581e-01f, 4.52571958e-02f, 1.30571127e-01f, -1.32587617e-02f,
  -1.12699382e-02f, -1.04256429e-01f, 9.02123824e-02f, -2.63564475e-03f, -2.66645461e-01f, -8.55095610e-02f, -1.31728649e-01f, -5.28431162e-02f, 3.34916897e-02f, -2.89119631e-01f,
  -3.24167371e-01f, -5.95721975e-03f, -4.86662760e-02f, 1.43517360e-01f, -3.52460667e-02f, 7.20665306e-02f, -4.09348160e-02f, -5.52312657e-02f, -4.60148267e-02f, -5.06310798e-02f,
  -4.59839851e-02f, 1.06628470e-01f, -4.63678092e-02f, 1.20173087e-02f, -1.17659390e-01f, 2.14497615e-02f, -2.90838070e-02f, -4.04964872e-02f, 6.35615587e-02f, -1.28870144e-01f,
  -4.34356518e-02f, -6.03303276e-02f, 3.03771738e-02f, 5.40899038e-02f, -3.12988870e-02f, 2.01801192e-02f, -2.69062072e-03f, -2.28798389e-02f, 8.48535970e-02f, -1.46921083e-01f,
  -3.90353091e-02f, 7.04236999e-02f, 7.79562490e-03f, 4.65058945e-02f, 3.39364596e-02f, 5.32480404e-02f, 7.53962947e-03f, 4.21428643e-02f, 5.98338097e-02f, 5.78302480e-02f,
  5.90922646e-02f, -2.22416762e-02f, 4.75561880e-02f, -8.92456528e-03f, 2.38481537e-03f, 9.60362405e-02f, 3.07593364e-02f, -7.47034326e-02f, 5.72518073e-02f, 9.77713615e-02f,
  9.36231911e-02f, 4.86188754e-02f, -3.15507664e-03f, -8.99821706e-03f, 5.03710657e-03f, -3.99717502e-02f, -2.01733764e-02f, 1.30717829e-01f, 2.93127317e-02f, 7.47228935e-02f,
  -2.62384247e-02f, 3.32753688e-01f, -2.78899372e-01f, 2.32189391e-02f, -6.08071946e-02f, -3.38809043e-02f, -1.28880844e-01f, -9.02269334e-02f, 1.75062194e-02f, -1.55510083e-01f,
  6.51765764e-02f, 6.95371674e-03f, 2.93083340e-02f, 1.59768225e-03f, -8.68993029e-02f, 3.71139646e-02f, -9.93166864e-02f, -3.93176004e-02f, 9.69989374e-02f, -8.92899483e-02f,
  -4.73801941e-02f, 1.08353263e-02f, 2.38505583e-02f, -4.81016841e-03f, -4.04550731e-02f, 8.78926590e-02f, -4.62455601e-02f, -4.53866422e-02f, 1.09698966e-01f, -2.36638173e-01f,
  3.76814634e-01f, -2.34575495e-01f, -2.03134771e-02f, 1.61943033e-01f, -5.51002994e-02f, -4.73061278e-02f, -3.01969528e-01f, -5.44518940e-02f, -8.28197412e-03f, -2.12313592e-01f,
  2.48202905e-02f, 3.97019684e-01f, 3.11586827e-01f, 1.57194182e-01f, 1.12070300e-01f, -3.07894975e-01f, -1.52776152e-01f, 2.49326289e-01f, 3.88956040e-01f, 2.27082029e-01f,
  -6.16080724e-02f, 8.60607326e-02f, 2.59387076e-01f, 1.10160515e-01f, -1.47556067e-01f, 5.41866897e-03f, -2.25640953e-01f, -7.13306293e-02f, -2.32037809e-03f, -3.08317214e-01f,
  -2.39738207e-02f, 8.44448730e-02f, 1.70318320e-01f, 1.74900487e-01f, 9.96628925e-02f, 6.90246895e-02f, 4.07076776e-02f, 8.53870064e-02f, 8.62189755e-02f, -2.11021993e-02f,
  2.68293619e-02f, 1.26799777e-01f, 1.24644734e-01f, 3.07441242e-02f, 7.74031179e-03f, 2.58616582e-02f, -2.69139037e-02f, 9.65284407e-02f, 9.13791656e-02f, -2.65423045e-03f,
  1.33983204e-02f, -2.84432825e-02f, 1.33502692e-01f, 5.54012321e-02f, -1.38785858e-02f, 1.59191549e-01f, -4.77995947e-02f, -4.85771894e-02f, 4.24393229e-02f, -1.86326236e-01f,
  4.61262502e-02f, -4.57216464e-02f, 6.49700910e-02f, -8.73333141e-02f, -4.66155969e-02f, -2.52276305e-02f, 5.33154933e-03f, -5.05882241e-02f, 5.32044731e-02f, -1.53086009e-02f,
  9.16278437e-02f, -3.38305198e-02f, -2.01293007e-02f, -2.77790576e-02f, 9.67488065e-02f, -8.38957280e-02f, 4.84305900e-03f, -1.20453639e-02f, 1.02873050e-01f, -4.76768762e-02f,
  6.72374889e-02f, 3.15697752e-02f, 6.55831620e-02f, 4.96658497e-02f, -2.15129070e-02f, 1.75780070e-03f, -6.64895847e-02f, -5.99757582e-03f, 7.23588318e-02f, 4.46918719e-02f,
  -9.13414545e-03f, 2.28876710e-01f, 1.09014079e-01f, 1.01652786e-01f, 6.73269853e-02f, 5.12919538e-02f, 9.99354124e-02f, 9.76970419e-02f, 8.07664469e-02f, 6.12938777e-02f,
  1.04450248e-01f, 4.75686938e-02f, 4.85153683e-02f, -5.32470010e-02f, 8.82060304e-02f, 3.98257859e-02f, -4.56510521e-02f, 6.71559125e-02f, 4.35484089e-02f, -4.19167131e-02f,
  -6.68165386e-02f, -1.71846822e-02f, 1.07467584e-01f, -3.32809500e-02f, -1.85275753e-03f, 6.42153993e-02f, -2.82317679e-02f, -1.38230935e-01f, 7.13139251e-02f, -2.69136488e-01f,
  1.37760758e-01f, 3.58015209e-01f, -3.15195262e-01f, 2.50679582e-01f, 8.62116590e-02f, -1.10228978e-01f, 1.20297648e-01f, 9.43186413e-03f, 9.74060968e-02f, 1.82892576e-01f,
  3.16643231e-02f, -2.59703159e-01f, -1.16865940e-01f, -2.54618704e-01f, -1.79105267e-01f, 1.62637800e-01f, 1.57057375e-01f, -2.05616713e-01f, -3.17335159e-01f, -1.77694529e-01f,
  1.75728589e-01f, 3.51083487e-01f, 1.26973033e-01f, 8.91417265e-02f, 4.51512277e-01f, -4.14315909e-02f, 2.00285688e-01f, 1.80373996e-01f, 1.41060486e-01f, 4.64189142e-01f,
  -1.17007181e-01f, 3.65710482e-02f, -8.51169676e-02f, 3.66919637e-02f, 2.86558382e-02f, 1.45202121e-02f, -8.18388686e-02f, 8.35416988e-02f, 4.01893295e-02f, 1.65911466e-02f,
  9.40846354e-02f, -3.16393077e-02f, -4.07841895e-03f, -5.38872667e-02f, 6.19594380e-02f, 3.83174121e-02f, 1.55775383e-01f, 3.23432237e-02f, -1.08313546e-01f, -3.54634412e-02f,
  3.95980552e-02f, 4.66006584e-02f, -2.28889119e-02f, -7.53310369e-03f, 2.18094736e-02f, -1.14230819e-01f, -5.79127036e-02f, -4.45150770e-03f, -2.48807967e-01f, 2.25767404e-01f,
  8.51304382e-02f, 2.52553285e-03f, 3.70408525e-03f, 4.01811190e-02f, -6.41648695e-02f, -6.34996817e-02f, 4.41814214e-02f, 2.02138815e-02f, 2.58988440e-02f, 1.41418604e-02f,
  -2.01414637e-02f, -1.11649580e-01f, 2.94964667e-02f, -2.38498971e-02f, 3.22218463e-02f, 6.72234520e-02f, -4.56963256e-02f, 2.58164946e-02f, -1.72376223e-02f, -4.21898589e-02f,
  -1.47908218e-02f, -2.71307621e-02f, 5.67072583e-03f, 2.80324183e-02f, -1.25887729e-02f, 1.33601045e-02f, -2.06507575e-02f, 5.68848923e-02f, 9.71214473e-03f, 3.45055424e-02f,
  1.76435604e-03f, -2.99231112e-01f, 7.31971040e-02f, 6.52817339e-02f, 7.06854016e-02f, 2.24913023e-02f, 8.52317214e-02f, 3.82150896e-03f, 3.50825898e-02f, -8.81873257e-03f,
  2.42357850e-02f, -3.99158224e-02f, 9.51222796e-03f, 7.17058778e-02f, -1.95056275e-02f, 2.81408112e-02f, 9.37830508e-02f, 7.55549893e-02f, 4.76412065e-02f, 8.26971978e-02f,
  1.26454890e-01f, 9.08093303e-02f, -3.58634070e-02f, -1.44102201e-02f, 5.47689013e-02f, -1.44414648e-01f, 5.30077480e-02f, -3.90802044e-03f, -1.33429870e-01f, 2.21299723e-01f,
  2.73596793e-01f, 9.75567847e-02f, 9.82303768e-02f, -5.25152264e-03f, -1.47387888e-02f, 1.10354118e-01f, 2.39935860e-01f, 1.51790977e-01f, -1.42311022e-01f, -4.44681272e-02f,
  -8.52522254e-02f, -3.78434420e-01f, -3.39399397e-01f, -1.84392616e-01f, 1.52523052e-02f, 9.67371389e-02f, 2.72160210e-02f, 5.69245126e-03f, -3.73371914e-02f, 9.68182608e-02f,
  -3.09737306e-02f, 7.28188530e-02f, 1.14071947e-02f, 4.42836508e-02f, 4.71602976e-02f, -1.42936870e-01f, -7.89499283e-02f, 1.11394271e-01f, 7.53136948e-02f, -5.61630959e-03f,
  -2.20939234e-01f, 2.83819616e-01f, -1.15727857e-01f, -7.82943070e-02f, -1.03153817e-01f, 3.00352219e-02f, 3.68077047e-02f, 2.22026128e-02f, -3.93529460e-02f, 1.50445262e-02f,
  2.50864513e-02f, 1.04199536e-01f, 1.00907408e-01f, 3.81656252e-02f, 6.01574816e-02f, 9.92187485e-03f, 5.56762656e-03f, 5.61099872e-02f, 5.11743017e-02f, 3.31860557e-02f,
  -7.33559877e-02f, 7.34692737e-02f, 1.04180023e-01f, 1.45850517e-02f, 1.73575133e-02f, -8.33634287e-02f, 3.68655734e-02f, 1.07887626e-01f, 1.00513302e-01f, 1.24253698e-01f,
  -2.60811346e-03f, 6.13115057e-02f, -2.58479044e-02f, 8.80733039e-03f, -1.41803687e-02f, -5.80993714e-03f, 8.32437798e-02f, -7.16134682e-02f, -2.01131906e-02f, 6.50251880e-02f,
  8.32988769e-02f, -3.86388823e-02f, 9.13038775e-02f, 1.05518989e-01f, -4.49143499e-02f, 9.60400328e-02f, -1.26646049e-02f, -1.95338111e-02f, 4.24181335e-02f, 1.56556778e-02f,
  -6.35853410e-02f, 4.12182212e-02f, 3.98648269e-02f, -5.11320345e-02f, 6.05145320e-02f, 9.12118554e-02f, -1.88059434e-02f, -2.02074982e-02f, 7.71703199e-02f, 6.30904809e-02f,
  -2.88026392e-01f, 6.73041269e-02f, -6.50375243e-03f, -1.59796216e-02f, -6.78945566e-03f, -2.20438857e-02f, -3.81588973e-02f, 2.79633515e-02f, 1.86224375e-02f, 6.19168878e-02f,
  4.49994355e-02f, -3.35894898e-02f, -4.96101715e-02f, -5.68138435e-02f, 1.60357468e-02f, 1.71589330e-02f, -8.88136625e-02f, -5.24641201e-02f, -3.98651883e-03f, -1.88331585e-02f,
  -5.64055331e-02f, -9.45286453e-03f, -9.94660705e-02f, -8.76255482e-02f, 3.41947563e-02f, -1.01302750e-01f, 2.04338748e-02f, 4.05446552e-02f, -3.94317927e-03f, -8.37966725e-02f,
  7.17705488e-01f, 1.22791249e-02f, -2.58804351e-01f, 1.36690214e-01f, -3.43127429e-01f, -4.10367817e-01f, -4.36528862e-01f, -3.81675363e-02f, 4.80195209e-02f, -3.28864567e-02f,
  -6.72270358e-02f, 1.51827767e-01f, 2.29128063e-01f, 5.81802540e-02f, 1.61240429e-01f, -4.42937948e-02f, -1.38136268e-01f, 2.26910606e-01f, -1.27367573e-02f, -8.42924342e-02f,
  1.45048443e-02f, 2.20276624e-01f, 3.57102901e-01f, 4.89465818e-02f, -6.57498613e-02f, -1.26330573e-02f, -5.53103164e-02f, -4.66697291e-02f, -2.17185393e-01f, 3.48149799e-02f,
  1.62887067e-01f, -7.23805558e-03f, -9.52728614e-02f, 3.70268300e-02f, -6.14650473e-02f, 1.58009753e-01f, -2.45364029e-02f, 7.03579485e-02f, -2.60756630e-02f, -2.96160318e-02f,
  -1.93042662e-02f, 7.38326386e-02f, -5.41886780e-03f, 2.18963344e-02f, -1.59550402e-02f, -7.73885706e-03f, 2.02113334e-02f, 1.15502119e-01f, 5.97768165e-02f, -2.51950454e-02f,
  -2.22919192e-02f, -8.67605209e-02f, -1.37901902e-01f, -4.76224422e-02f, 2.05714311e-02f, -2.70324796e-02f, -8.73141363e-02f, -5.80561953e-03f, -9.28197876e-02f, 6.52452260e-02f,
  -7.06232265e-02f, -3.95290069e-02f, -5.58339506e-02f, 2.91269571e-02f, 9.12633687e-02f, 1.61377043e-02f, 1.04094250e-02f, 1.28564592e-02f, -5.61888271e-04f, 1.26649337e-02f,
  -3.78320068e-02f, 9.18539613e-02f, -3.53280492e-02f, -5.12794182e-02f, 2.68217623e-02f, -6.89763352e-02f, -4.45092767e-02f, 2.00857371e-02f, 9.79782455e-03f, 2.25988030e-02f,
  5.34028672e-02f, 3.62706417e-03f, 1.40018668e-02f, 6.38959780e-02f, 2.87725125e-02f, 3.70665379e-02f, -4.25904579e-02f, 1.36612048e-02f, -4.97218128e-03f, -1.49760516e-02f,
  1.92462280e-01f, 1.57745499e-02f, 1.20760500e-01f, 6.88053370e-02f, -8.40862766e-02f, -5.81153929e-02f, 5.54436035e-02f, 1.19131785e-02f, 2.17801332e-03f, 4.84414659e-02f,
  -4.35443334e-02f, 5.61439954e-02f, 9.42765400e-02f, -6.59026355e-02f, -6.53231367e-02f, 1.06746061e-02f, -6.47536069e-02f, 4.55101877e-02f, -7.38256648e-02f, -8.38929415e-02f,
  5.85869439e-02f, -6.82386234e-02f, 1.23914108e-02f, 6.26823492e-03f, -6.81004897e-02f, 4.14321423e-02f, -8.30313340e-02f, -5.46088666e-02f, -1.01874955e-02f, 1.48399144e-01f,
  -1.37921304e-01f, 3.13282043e-01f, 2.69489795e-01f, -2.59580519e-02f, 1.33221522e-01f, 4.77995247e-01f, 4.36924070e-01f, 2.32526183e-01f, -5.34158535e-02f, 2.57678598e-01f,
  1.19221389e-01f, -2.25629300e-01f, -5.84834032e-02f, -1.05954468e-01f, 2.14585751e-01f, 3.46922606e-01f, 3.96384478e-01f, 9.04530287e-02f, 1.31657615e-01f, 1.11880973e-01f,
  8.04883987e-02f, -5.80952913e-02f, -1.27114996e-01f, 4.93345186e-02f, 4.78301346e-02f, -3.29003446e-02f, 1.26103461e-01f, 1.08722180e-01f, 1.93800718e-01f, 1.66293427e-01f,
  1.54181987e-01f, 1.25245914e-01f, 7.40718991e-02f, -1.29890731e-02f, -1.06324740e-02f, 3.68584394e-02f, 7.54331723e-02f, 2.20315829e-02f, 2.82134786e-02f, 4.73451205e-02f,
  -2.64541097e-02f, 1.42397005e-02f, 3.56913432e-02f, 3.00904107e-03f, 3.04270759e-02f, 7.92784914e-02f, -7.84298182e-02f, 2.28368826e-02f, -1.60642043e-02f, 8.49155933e-02f,
  5.23639508e-02f, 3.12430207e-02f, 1.32210270e-01f, 1.54218525e-01f, 6.60897465e-03f, -1.19061656e-02f, 4.70119230e-02f, 2.86878236e-02f, 5.10526709e-02f, 4.95709293e-03f,
  -2.34630425e-02f, -4.63442057e-02f, 9.20865219e-03f, 4.39049304e-02f, 5.61908670e-02f, -5.87754175e-02f, 2.48444621e-02f, 3.87956873e-02f, -1.13990024e-01f, 3.25417854e-02f,
  1.35645103e-02f, 1.26812875e-01f, 1.57547202e-02f, 6.46610186e-02f, 5.06009497e-02f, 1.36256712e-02f, 2.22524032e-02f, 1.92858633e-02f, -1.63958278e-02f, -1.16520161e-02f,
  -3.77684203e-03f, -1.61701534e-02f, 1.40580637e-02f, 4.63514682e-03f, 1.20993130e-01f, 5.20362891e-02f, 6.03756085e-02f, -2.44436339e-02f, -4.06158231e-02f, -5.35670929e-02f,
  -1.91319063e-01f, 2.64063496e-02f, 4.18685330e-03f, 2.43266206e-02f, 5.71132172e-03f, -3.86390090e-02f, -4.97593638e-03f, 1.81188900e-02f, -6.16149753e-02f, 4.64115106e-02f,
  4.74220477e-02f, -2.94449013e-02f, 6.83875680e-02f, 1.10566832e-01f, 8.16708431e-02f, 6.34898320e-02f, 7.79556334e-02f, 8.94686580e-02f, 2.18158215e-02f, -2.67346110e-02f,
  -4.28383611e-02f, 1.33872032e-01f, 1.81601420e-01f, 8.55321512e-02f, -5.22879250e-02f, 7.19568059e-02f, 8.84050652e-02f, 7.04847202e-02f, 1.01501718e-01f, 1.52868018e-01f,
  -5.22675753e-01f, -2.22013578e-01f, -3.55151966e-02f, -4.17716801e-01f, -2.10863538e-02f, 2.00345948e-01f, 8.04449692e-02f, -3.84765416e-02f, -2.08931416e-01f, -1.18338175e-01f,
  -4.82263155e-02f, -1.34157017e-01f, -3.91414501e-02f, 5.29932454e-02f, 1.82940252e-02f, 1.45593025e-02f, 1.58311144e-01f, 6.80742189e-02f, 2.52715558e-01f, 1.12965137e-01f,
  1.44571289e-01f, -1.74533263e-01f, -6.86205775e-02f, -8.99836235e-03f, -1.67588666e-01f, 6.64185584e-02f, -1.27220109e-01f, -1.16589621e-01f, 1.35883257e-01f, -5.27769700e-03f,
  -2.01290071e-01f, -3.19633007e-01f, 7.40939304e-02f, 2.70296074e-02f, -5.63353859e-02f, 2.85697356e-02f, -1.06397629e-01f, -1.03357278e-01f, 3.61588132e-03f, -9.56858620e-02f,
  -1.24148823e-01f, -4.05879915e-02f, -3.20244879e-02f, -2.79926937e-02f, -9.98223200e-02f, -2.69599585e-03f, -5.83755262e-02f, -5.06847911e-02f, -1.45885125e-01f, 1.46057340e-03f,
  1.04774252e-01f, 3.71536426e-02f, -1.50059372e-01f, 2.49956902e-02f, -5.17469049e-02f, -1.84304025e-02f, -1.21003136e-01f, 2.98746210e-02f, 3.33044631e-03f, -1.72911301e-01f,
  -9.88416150e-02f, 6.63217157e-03f, 4.06466760e-02f, 6.64784107e-03f, 3.32622863e-02f, -6.04100786e-02f, 1.75885726e-02f, 1.13141179e-01f, 1.04869336e-01f, 8.19236320e-03f,
  1.10186689e-01f, -3.90766859e-02f, 1.47273332e-01f, -7.68681839e-02f, 1.10380240e-01f, 8.28036200e-03f, 7.25807473e-02f, -1.66904293e-02f, -4.42096815e-02f, 2.62443982e-02f,
  4.52843383e-02f, 9.24158767e-02f, -8.32562894e-02f, 1.59914315e-01f, 1.05428010e-01f, 2.62801331e-02f, -1.00266509e-01f, 7.20556155e-02f, -7.73017704e-02f, 4.22801487e-02f,
  -2.82336563e-01f, 1.06720268e-04f, -1.71603546e-01f, -1.38104958e-02f, -1.06862769e-01f, -4.04921733e-02f, -5.54372743e-02f, -6.08882345e-02f, -8.85888562e-02f, 1.93640143e-02f,
  -3.61765400e-02f, -1.06181175e-01f, -1.09909959e-01f, 2.74712294e-02f, 5.58327809e-02f, -2.92504672e-02f, -1.25321606e-02f, -4.60843928e-02f, 6.02774918e-02f, -7.46387914e-02f,
  4.35751751e-02f, -3.29726823e-02f, -1.16392590e-01f, -4.55827937e-02f, -1.49963275e-01f, -2.12675352e-02f, -1.04855038e-01f, 2.53907908e-02f, 2.59537250e-02f, -1.52069032e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.26656222e-01f, -2.70718694e-01f, -7.74198174e-01f, 2.91593522e-01f, 1.09557323e-01f, -2.66199969e-02f, -1.02592539e-02f, 4.16814923e-01f, 4.81950760e-01f, -5.59803508e-02f,
  -2.49742851e-01f, -6.25847876e-02f, -3.02551717e-01f, -2.47486606e-01f, -1.65842608e-01f, -3.35888445e-01f, -2.58251578e-01f, -3.28578085e-01f, 1.15685396e-01f, 1.86025649e-01f,
  2.71660328e-01f, 3.02474976e-01f, 2.28695050e-01f, 6.82504326e-02f, -1.06696136e-01f, -9.84873995e-02f, -3.40481311e-01f, -2.84321934e-01f, -4.30104911e-01f, -6.15850091e-01f,
  -7.44340658e-01f, -2.95704842e-01f, 1.42758712e-01f, 1.42014101e-01f, 8.37785006e-02f, 1.48536742e-01f, 5.41988313e-02f, 9.86845270e-02f, 1.91748038e-01f, 6.32051826e-02f,
  -8.40188861e-02f, 1.43995985e-01f, 1.25605762e-01f, -1.62056871e-02f, 2.59520829e-01f, 8.44975747e-03f, 4.45246808e-02f, -4.24177200e-02f, -1.63925216e-01f, -1.30607247e-01f,
  -1.58160537e-01f, -2.83725490e-03f, -7.18845874e-02f, -1.58384051e-02f, -1.41142741e-01f, -3.97127531e-02f, -1.40982956e-01f, -1.16959095e-01f, -1.96918696e-01f, 2.43253157e-01f,
  -3.04873250e-02f, -4.82748002e-02f, -1.20739989e-01f, 2.48468090e-02f, 1.64483503e-01f, 2.14479137e-02f, -1.69544425e-02f, 1.19937360e-01f, 1.04477312e-02f, 5.44770658e-02f,
  7.93720260e-02f, -8.02011490e-02f, -3.79649922e-02f, 4.67090495e-02f, -1.26284346e-01f, -1.15841426e-01f, -6.96639419e-02f, -2.92524882e-02f, -7.44810477e-02f, 1.51212364e-01f,
  4.06633765e-02f, -4.50453870e-02f, -4.42143679e-02f, -2.37760190e-02f, -1.41958877e-01f, -5.04850522e-02f, -1.43420011e-01f, -4.73706909e-02f, 1.70497909e-01f, 1.79776382e-02f,
  4.01926339e-01f, -2.71018654e-01f, 6.62282258e-02f, 3.92734744e-02f, -1.30178317e-01f, -6.61287010e-02f, -2.77045578e-01f, -3.52103412e-02f, -2.17704568e-02f, -1.32082537e-01f,
  -1.15633257e-01f, -3.25588174e-02f, -4.85134088e-02f, -7.82855153e-02f, 2.56465375e-01f, -5.17492965e-02f, 4.32649516e-02f, -2.01552529e-02f, 4.56719426e-03f, -1.54138245e-02f,
  -1.11533133e-02f, 1.38274238e-01f, 1.77380949e-01f, 1.15040950e-01f, 3.16648148e-02f, 9.26629454e-02f, 4.17000279e-02f, 5.58223054e-02f, -3.00013497e-02f, 3.08507532e-01f,
  -8.15219700e-01f, -2.86269069e-01f, -1.64408728e-01f, -6.09271884e-01f, -7.46645629e-02f, 3.10650945e-01f, -8.98253322e-02f, 2.30773970e-01f, 1.16584944e-02f, -2.57082969e-01f,
  7.16681331e-02f, -3.02448217e-02f, -3.52635920e-01f, -6.28253594e-02f, -5.54527156e-02f, -3.43752235e-01f, -4.10756201e-01f, -5.03111817e-02f, 2.63373345e-01f, 4.57392603e-01f,
  1.17802978e-01f, -2.18974367e-01f, -1.03551276e-01f, -2.12787334e-02f, -3.81802261e-01f, -1.99464411e-01f, -5.43149173e-01f, -2.50265151e-01f, -5.55708632e-02f, -5.28257370e-01f,
  -3.77276659e-01f, 1.48206487e-01f, 1.18666828e-01f, -1.37771308e-01f, -1.15947187e-01f, 5.65295927e-02f, -7.28016272e-02f, -1.10145308e-01f, 4.38806303e-02f, -3.71944569e-02f,
  4.14573587e-02f, 3.04538548e-01f, -1.65688977e-01f, 6.38913438e-02f, -4.58186120e-02f, 6.73019290e-02f, 3.19600254e-02f, 6.15638196e-02f, 3.62308323e-03f, 2.52379239e-01f,
  8.52232799e-02f, -7.62571767e-03f, 8.21015388e-02f, 2.15984896e-01f, 2.11874649e-01f, 9.05067697e-02f, 9.94552746e-02f, 2.61877418e-01f, 3.12362254e-01f, -4.24566984e-01f,
  -3.85559015e-02f, -7.11470842e-02f, -7.58860931e-02f, 1.07728362e-01f, 2.10535210e-02f, -5.06599173e-02f, -5.31433076e-02f, 9.58389193e-02f, 7.12232143e-02f, -9.80042741e-02f,
  2.34910864e-02f, 4.96611893e-02f, 3.39914882e-03f, -7.56583810e-02f, -5.99235035e-02f, -2.35217046e-02f, -4.96749207e-02f, -4.34806608e-02f, 1.22690164e-01f, 1.31144598e-02f,
  2.76367031e-02f, 5.81056112e-03f, -2.79633962e-02f, -7.26146298e-03f, -4.74306047e-02f, -2.72113625e-02f, 7.18441531e-02f, 1.59448788e-01f, 8.27088505e-02f, 1.62439197e-01f,
  -4.68735844e-01f, 1.90855831e-01f, -5.52587450e-01f, 1.08673707e-01f, -9.04512685e-03f, 3.29501815e-02f, -7.50684887e-02f, 1.20992206e-01f, -6.51799738e-02f, 6.50110021e-02f,
  2.99733013e-01f, -4.47534360e-02f, -3.26618075e-01f, 1.00564308e-01f, -6.56370521e-02f, 4.76579964e-02f, -8.32278877e-02f, -6.08724803e-02f, 2.44536921e-01f, 5.03062867e-02f,
  3.94970849e-02f, 3.56660634e-02f, -1.61488041e-01f, -9.03994739e-02f, 1.64911542e-02f, 4.27479148e-02f, -1.41129181e-01f, -3.16544138e-02f, 1.06477089e-01f, -3.65721762e-01f,
  3.46621692e-01f, 4.49005455e-01f, 3.10032338e-01f, -1.91821046e-02f, 1.83561966e-01f, 1.22933477e-01f, 3.97156864e-01f, 1.01551779e-01f, -6.72300756e-02f, 2.56169587e-01f,
  7.38482848e-02f, -2.94179469e-01f, -7.19864815e-02f, -1.57746732e-01f, -5.51356077e-02f, 1.49485663e-01f, -5.44522665e-02f, -1.76335290e-01f, -3.90013486e-01f, -2.96925128e-01f,
  -2.78691202e-01f, 5.58468066e-02f, -4.24541906e-02f, -1.14753973e-02f, 1.49057299e-01f, -2.41178170e-01f, 1.56645358e-01f, 3.03084284e-01f, 2.17586961e-02f, -1.17032140e-01f,
  1.64583519e-01f, 4.87751484e-01f, -4.55715477e-01f, -2.11057648e-01f, 1.48290023e-01f, -1.14323765e-01f, -5.25785908e-02f, -2.05686633e-02f, 3.72443944e-02f, -7.53103420e-02f,
  4.85021770e-02f, 8.44009966e-02f, -5.06619066e-02f, -2.14894097e-02f, 7.28347227e-02f, 1.27684578e-01f, 7.72002935e-02f, 8.10973272e-02f, 1.30531136e-02f, 1.28141940e-01f,
  -1.56357124e-01f, 9.85772237e-02f, 2.53622323e-01f, -1.54421851e-02f, 2.10803505e-02f, -2.61334211e-01f, 8.85621160e-02f, 2.14079525e-02f, -9.83244367e-03f, -1.48827195e-01f,
  -2.63753831e-01f, -1.32241353e-01f, 1.11898638e-01f, -5.40046766e-02f, 3.20243686e-02f, -6.50884062e-02f, -7.51566142e-02f, 1.39830122e-02f, -2.91451160e-02f, 4.19088677e-02f,
  -1.08899444e-01f, -4.81724441e-02f, 1.40595976e-02f, -1.54009452e-02f, -1.08574927e-01f, 1.04853548e-01f, 8.08714405e-02f, 1.86457839e-02f, 1.54294744e-01f, 4.62961681e-02f,
  -5.73402606e-02f, 6.49862364e-02f, 1.64029717e-01f, 2.59852372e-02f, 2.24021263e-02f, -1.26759663e-01f, -1.32117450e-01f, -5.69360256e-02f, 1.95085425e-02f, -1.07275575e-01f,
  -6.82393238e-02f, 9.80195254e-02f, -7.65191987e-02f, 2.05038092e-03f, 2.10723430e-01f, 8.52033645e-02f, 5.13566732e-02f, -1.26441875e-02f, 6.86194897e-02f, -6.87796846e-02f,
  4.49013375e-02f, -1.37679547e-01f, 2.43965730e-01f, -5.71812503e-03f, -1.77822381e-01f, -1.37848392e-01f, -4.19125669e-02f, 8.27242434e-03f, -2.87481509e-02f, 5.63964136e-02f,
  -5.81457913e-02f, -1.88277587e-01f, -2.14371175e-01f, -5.73880412e-02f, -1.74043939e-01f, -4.12185282e-01f, -5.10778371e-03f, -3.97981144e-02f, -1.39451593e-01f, -1.54051945e-01f,
  -2.75611550e-01f, 1.06124114e-02f, -2.44660769e-03f, 2.34073937e-01f, 4.37251240e-01f, -4.70169336e-02f, -4.28938776e-01f, -2.67868251e-01f, 4.36563164e-01f, -2.40772050e-02f,
  1.24838322e-01f, 2.02475995e-01f, 1.14118136e-01f, -1.41160255e-02f, -5.53489625e-01f, -1.15574315e-01f, 4.18286622e-02f, -3.97448629e-01f, -5.48864245e-01f, -3.80588949e-01f,
  4.64377515e-02f, -1.04183376e-01f, -4.30344433e-01f, -3.94193605e-02f, 4.13313925e-01f, 3.11083376e-01f, 2.37408102e-01f, 2.27161542e-01f, -4.22450388e-03f, 2.33922571e-01f,
  2.24540452e-03f, 1.07966483e-01f, 8.72446597e-02f, 2.46240437e-01f, 2.20977157e-01f, -4.03556935e-02f, -1.45016700e-01f, 4.55420800e-02f, 1.07753806e-01f, 1.33697921e-02f,
  2.66828507e-01f, -3.94332260e-02f, -5.91964759e-02f, 2.66259052e-02f, 1.45124667e-03f, -2.32030481e-01f, -6.69951811e-02f, -1.93480507e-01f, -2.38112420e-01f, -3.24761927e-01f,
  -6.00085482e-02f, 1.04076862e-01f, -1.94526881e-01f, -3.00674210e-03f, -1.30255729e-01f, -9.03224945e-02f, -1.81631580e-01f, -7.36661851e-02f, -2.09694907e-01f, -9.18923393e-02f,
  -2.30595786e-02f, 1.15814109e-04f, 5.41792326e-02f, -5.16743399e-02f, -3.56008708e-02f, 1.88503787e-01f, -5.66373244e-02f, -3.82453599e-03f, 5.20029962e-02f, -5.66294119e-02f,
  3.29047441e-02f, -6.00817539e-02f, -4.40375321e-02f, -9.92093086e-02f, -8.47369432e-02f, 2.03451633e-01f, 7.32478648e-02f, -2.11558238e-01f, -3.11082631e-01f, 1.33384997e-02f,
  2.76201125e-02f, 6.00827597e-02f, 2.00413883e-01f, -1.85470749e-02f, 2.32254919e-02f, 1.31778128e-03f, 1.26835912e-01f, 1.07555494e-01f, 5.66357002e-02f, 3.39503773e-02f,
  7.93443248e-02f, 1.95862986e-02f, 4.27207686e-02f, 1.37507424e-01f, 2.88361348e-02f, 1.19582236e-01f, 2.59537995e-01f, 6.34308532e-02f, 3.63692008e-02f, -1.96835995e-01f,
  -8.30088258e-02f, -1.94154859e-01f, 7.85668641e-02f, -2.76235603e-02f, -1.83426678e-01f, 2.33562272e-02f, -2.32461125e-01f, 2.85440776e-02f, -1.94346532e-02f, 4.62423488e-02f,
  -6.32348955e-02f, -1.88792631e-01f, -4.12038684e-01f, -1.25079200e-01f, 1.36083364e-01f, -1.15368947e-01f, -1.77278131e-01f, -4.90806326e-02f, -3.28254074e-01f, -3.86088610e-01f,
  6.13323390e-01f, 4.71758485e-01f, -6.03285618e-02f, 2.64999390e-01f, 1.96491256e-01f, -2.19223946e-01f, -8.50301702e-03f, -1.99843302e-01f, -5.40312976e-02f, 2.95781270e-02f,
  5.93347773e-02f, -3.15439492e-01f, -7.68044963e-02f, -3.48160684e-01f, -3.22119921e-01f, -2.01366723e-01f, -6.31818995e-02f, -2.91373402e-01f, -6.24224186e-01f, -3.76394689e-01f,
  -2.54367352e-01f, 4.05652225e-02f, -1.61964130e-02f, -1.40034750e-01f, 3.05458218e-01f, -1.43854052e-01f, 2.35416219e-01f, 2.58387089e-01f, 8.45740736e-02f, 1.96803316e-01f,
  2.46840045e-02f, 2.67495841e-01f, -2.41342038e-01f, 1.62189789e-02f, 1.75359786e-01f, -1.20676458e-02f, -2.95220707e-02f, 5.16569279e-02f, 6.45582080e-02f, 4.06962112e-02f,
  1.06766343e-01f, 9.49521661e-02f, -1.52429873e-02f, -1.02288038e-01f, -1.66940223e-02f, -1.56587631e-01f, -7.09405169e-02f, -8.43738243e-02f, -3.42692994e-02f, -2.09279209e-02f,
  8.06314275e-02f, 6.12956770e-02f, 1.08572647e-01f, -1.25515237e-01f, 5.12977466e-02f, 2.82097049e-03f, -3.30429934e-02f, 1.05087757e-02f, -8.82448331e-02f, 1.50157958e-01f,
  9.44048166e-02f, 9.99974832e-02f, 1.99858528e-02f, 6.23055473e-02f, 1.95560843e-01f, -1.42127993e-02f, 7.84426183e-02f, -2.78696069e-03f, -1.28190845e-01f, 2.08802763e-02f,
  -1.00211613e-01f, 1.02580838e-01f, -6.06498029e-03f, 6.15011714e-02f, 4.65692207e-02f, 1.58681244e-01f, 6.39243424e-02f, -3.83013971e-02f, 4.54178974e-02f, 5.86604662e-02f,
  -1.08459793e-01f, 7.36685172e-02f, 9.59265139e-03f, -1.34967947e-02f, 5.25869466e-02f, 7.39690140e-02f, 2.42496785e-02f, 1.28213868e-01f, 1.70868129e-01f, 1.32854268e-01f,
  -3.42334598e-01f, -3.37796867e-01f, 5.41296713e-02f, -1.43477768e-01f, 7.96533301e-02f, 1.48319349e-01f, 1.69494390e-01f, 8.64251629e-02f, 1.10861003e-01f, 1.03436321e-01f,
  4.45201844e-02f, 5.75340055e-02f, 3.17952521e-02f, -7.77116641e-02f, -1.14345416e-01f, -4.11431938e-02f, 7.29119629e-02f, -4.21179645e-02f, -5.00876196e-02f, 1.49584144e-01f,
  4.50233258e-02f, -1.35245189e-01f, -2.07703486e-01f, -9.47518200e-02f, 6.54726699e-02f, -4.81863357e-02f, -5.64995147e-02f, -9.54206884e-02f, -5.01802657e-03f, 8.59946311e-02f,
  -6.91379428e-01f, 4.46803778e-01f, 2.99408108e-01f, -2.45044082e-01f, 5.04162133e-01f, 3.69181007e-01f, 4.56067413e-01f, 4.27843221e-02f, -2.17794746e-01f, 9.53489318e-02f,
  2.27670833e-01f, -1.76400036e-01f, -1.13151915e-01f, -1.45937866e-02f, -2.22823739e-01f, 2.43551895e-01f, 4.10158962e-01f, -2.19194248e-01f, -4.92794186e-01f, -3.23957473e-01f,
  1.33171026e-02f, -3.15999538e-01f, -5.18049061e-01f, -3.25915396e-01f, 7.33387396e-02f, -1.64171495e-02f, 2.78486639e-01f, 4.00029421e-02f, 1.60623103e-01f, 3.82493436e-01f,
  -1.82322681e-01f, -1.20478243e-01f, 6.15497045e-02f, -1.43925995e-01f, 1.37243822e-01f, -1.96721792e-01f, -2.28653774e-01f, 5.81657467e-03f, -4.76538762e-02f, -1.74314603e-02f,
  1.63689032e-01f, 8.77982099e-03f, 1.16000891e-01f, 8.54002014e-02f, -1.60679277e-02f, -4.85532098e-02f, 1.12794526e-02f, -2.98103929e-01f, -2.65143365e-01f, -2.49575321e-02f,
  2.75523216e-01f, 1.63640112e-01f, -1.07949667e-01f, 2.10035115e-01f, 8.57499689e-02f, -1.81982741e-01f, -1.04875706e-01f, -3.29633117e-01f, -2.22328141e-01f, -3.21949869e-01f,
  7.84641877e-03f, 3.93156670e-02f, 2.52699181e-02f, -7.57393390e-02f, 8.06347504e-02f, 1.30556116e-04f, 1.84802771e-01f, -1.02539118e-02f, -7.63178766e-02f, -1.94753200e-01f,
  1.49031252e-01f, 1.04165584e-01f, -1.42191872e-01f, -6.01969510e-02f, -9.03484821e-02f, 2.09313706e-02f, -6.21730760e-02f, -9.39977542e-02f, -7.76342601e-02f, -7.34760240e-02f,
  -1.31035343e-01f, 1.09903980e-02f, -5.05836196e-02f, -1.62641212e-01f, 1.47024840e-01f, -7.65197426e-02f, 5.60884550e-02f, 3.11767608e-02f, -1.35146305e-01f, 5.97753376e-02f,
  -4.75098521e-01f, 1.96221054e-01f, -8.67778957e-02f, -1.06405973e-01f, 9.43653584e-02f, 8.33475143e-02f, -9.46183037e-03f, -2.60396693e-02f, 1.62418485e-02f, 2.22804192e-02f,
  8.79510939e-02f, -6.22539315e-03f, 1.68573722e-01f, 8.54319856e-02f, -5.20077758e-02f, 8.74511674e-02f, 9.15322751e-02f, -1.87280137e-04f, -4.59467396e-02f, 7.81981274e-02f,
  5.92494011e-02f, -2.65273929e-01f, -3.00760746e-01f, 8.78694952e-02f, -1.17722899e-03f, -1.98795736e-01f, -2.41261542e-01f, -1.75000355e-01f, -2.64826715e-01f, -3.64987552e-01f,
  8.12663853e-01f, -6.64734185e-01f, 2.32415229e-01f, 3.22052956e-01f, 1.65065035e-01f, 1.26014099e-01f, 2.49113534e-02f, 1.52152432e-02f, 2.52614766e-01f, -8.12714919e-02f,
  -1.89644977e-01f, -1.38333999e-02f, -5.99711835e-02f, -8.21895599e-02f, -7.96670094e-02f, -1.01725431e-02f, 3.96923088e-02f, 1.67589918e-01f, 4.03343648e-01f, 2.51215816e-01f,
  1.27931619e-02f, 5.23996726e-02f, 1.61534369e-01f, 5.97703643e-02f, -1.69620767e-01f, 6.64903969e-02f, -4.36812826e-02f, -8.97352025e-02f, -2.00074568e-01f, -2.07109287e-01f,
  -2.14398816e-01f, -1.18439116e-01f, 2.34501824e-01f, -8.29704106e-02f, -2.07918406e-01f, 6.95157498e-02f, -4.53487262e-02f, -1.74113497e-01f, -6.82994723e-02f, 2.59687845e-02f,
  -1.08446032e-01f, -4.95587327e-02f, -1.27696851e-02f, -1.98676363e-01f, -8.28435197e-02f, 7.31510520e-02f, -1.36697501e-01f, -8.79763961e-02f, -3.87994386e-02f, -1.25830933e-01f,
  -2.36178949e-01f, 1.53352022e-02f, -5.67513295e-02f, -1.16123185e-02f, 1.34142369e-01f, 1.35279909e-01f, -7.20739812e-02f, 2.75819246e-02f, 4.39174138e-02f, 2.61667483e-02f,
  2.36279368e-01f, 2.09697321e-01f, -8.15024674e-02f, 2.50687487e-02f, 6.99629262e-02f, 1.15188204e-01f, 1.51037082e-01f, 7.20432103e-02f, 9.18798968e-02f, 5.23818545e-02f,
  -1.21007815e-01f, -4.55039814e-02f, -1.80667154e-02f, 9.51169059e-02f, 2.74939053e-02f, -4.95204665e-02f, 5.74037768e-02f, -1.62057817e-01f, -1.29655421e-01f, -1.41374916e-01f,
  -1.10788457e-02f, 5.95761538e-02f, 6.36925101e-02f, -1.59360006e-01f, -2.04520315e-01f, -8.17241147e-02f, -1.38147902e-02f, -1.79719061e-01f, 2.91437823e-02f, 3.08013074e-02f,
  -3.18887085e-01f, -1.29623652e-01f, 2.03237683e-01f, -6.85356837e-03f, 1.33157194e-01f, -9.07596201e-02f, 4.47300188e-02f, -5.50364703e-02f, -6.62020817e-02f, -4.44337837e-02f,
  1.70219950e-02f, 1.45777881e-01f, -5.11129685e-02f, -2.07385153e-01f, 1.19900033e-01f, 1.96543917e-01f, -7.26182386e-02f, 1.66610628e-02f, 2.54022777e-02f, -9.32576284e-02f,
  -1.06334746e-01f, 2.14787409e-01f, 2.87055314e-01f, 2.31579602e-01f, 1.51392773e-01f, 3.68660629e-01f, -4.40543983e-03f, 5.02614416e-02f, 2.03062475e-01f, 1.50134370e-01f,
  -5.32630801e-01f, -2.35404357e-01f, -5.57197750e-01f, -1.08582214e-01f, 3.31122696e-01f, 3.42229977e-02f, -3.79954204e-02f, -1.96616784e-01f, -5.69380037e-02f, -9.46084037e-02f,
  5.67239486e-02f, 1.11774050e-01f, -5.70331179e-02f, 6.29011765e-02f, -1.60909086e-01f, -1.02664046e-01f, 1.15557596e-01f, -7.61764273e-02f, -4.33292761e-02f, 3.54927778e-01f,
  4.25180107e-01f, 2.91645154e-02f, -1.58256337e-01f, 4.03705575e-02f, 1.68054670e-01f, 1.33353829e-01f, -2.29574695e-01f, 3.40647693e-03f, 2.29497790e-01f, 4.04615641e-01f,
  -6.03543781e-02f, -7.24901780e-02f, 6.89669400e-02f, 9.05918106e-02f, 1.70415327e-01f, -1.29242450e-01f, -5.90610579e-02f, -1.50797591e-01f, 8.49016104e-03f, -1.23040535e-01f,
  1.88060418e-01f, 4.56661619e-02f, 2.09085271e-01f, 7.13534467e-03f, -4.88615073e-02f, -1.17397398e-01f, -2.03870505e-01f, -2.13105261e-01f, -4.28532064e-01f, -5.41809993e-03f,
  4.87667739e-01f, 3.47252756e-01f, -1.68104142e-01f, -2.79480159e-01f, -2.59205043e-01f, -3.63754258e-02f, -1.39505684e-01f, 1.25075817e-01f, -4.80124593e-01f, -1.75967351e-01f,
  -1.10050857e-01f, 4.15950418e-02f, -5.69992214e-02f, -6.79756403e-02f, 9.51290689e-03f, -7.89594799e-02f, 5.76197207e-02f, 9.72690508e-02f, 1.39057711e-01f, -4.78361957e-02f,
  -1.10502020e-01f, -8.14832151e-02f, -1.93364769e-02f, -6.38241023e-02f, -1.51974827e-01f, -8.47191084e-03f, 1.30179226e-01f, 1.32544979e-01f, 8.26763362e-02f, -1.71151431e-03f,
  6.26387149e-02f, -5.26180454e-02f, -5.82688004e-02f, 8.67890939e-02f, -1.54747386e-02f, -1.97715476e-01f, -2.11757477e-02f, 4.93841991e-03f, -1.08384505e-01f, -1.17629945e-01f,
  -2.45117813e-01f, -8.52003843e-02f, -1.86397761e-01f, 4.94438298e-02f, 1.34964973e-01f, 9.61516127e-02f, 3.58707048e-02f, 8.73345137e-02f, -1.29415974e-01f, -1.05917223e-01f,
  5.18632792e-02f, -3.11712883e-02f, -1.19778410e-01f, -9.93499067e-03f, 2.02828571e-01f, 1.19238973e-01f, 9.59798917e-02f, 7.06691518e-02f, -5.93628846e-02f, 1.08276129e-01f,
  -1.70155808e-01f, 6.49972707e-02f, -2.05569398e-02f, -2.84052223e-01f, -7.02899322e-02f, -1.48857549e-01f, -1.17730096e-01f, -1.43708780e-01f, -3.65587890e-01f, -4.08079475e-01f,
  -9.14157927e-01f, -1.26360640e-01f, -1.26379579e-01f, -3.57011914e-01f, -2.17441842e-01f, -1.87652007e-01f, -4.33312282e-02f, -1.68701425e-01f, -2.85646349e-01f, -1.18304648e-01f,
  2.25925259e-02f, 1.70314461e-01f, 6.33048713e-02f, 6.13454133e-02f, 8.31538066e-02f, 3.23462114e-02f, -6.36367425e-02f, -1.33648634e-01f, -1.40106544e-01f, -4.10317518e-02f,
  -8.31492692e-02f, -5.48399501e-02f, -2.95721322e-01f, -1.90975621e-01f, 4.46570292e-02f, 1.82707861e-01f, 1.07000858e-01f, -2.31435020e-02f, -3.70103456e-02f, -4.22653556e-02f,
  6.28288567e-01f, -1.76423654e-01f, -1.79155488e-02f, -7.72948787e-02f, -4.48182039e-03f, -1.18495904e-01f, -2.83817146e-02f, -1.28246397e-01f, 8.20236560e-03f, 8.55322257e-02f,
  3.08915861e-02f, -7.40701482e-02f, -6.40824735e-02f, 2.05454305e-02f, -2.73960810e-02f, -7.80968368e-02f, -9.21186991e-03f, -6.47526607e-02f, 4.15178537e-02f, 2.30195299e-01f,
  -9.85443778e-03f, 1.46959070e-03f, 1.10856868e-01f, 2.39324756e-02f, 1.58564709e-02f, 8.68756101e-02f, 1.09553434e-01f, -2.34331787e-02f, 1.24975689e-01f, 6.16858527e-02f,
  -1.70532539e-01f, -1.03914455e-01f, -1.05917461e-01f, 1.75283104e-02f, 4.42482308e-02f, -5.95870316e-02f, 1.48924198e-02f, 1.26316786e-01f, 1.41769215e-01f, -1.74402166e-02f,
  2.37591676e-02f, 1.48205176e-01f, 9.05399304e-03f, -2.67930999e-02f, 2.90174857e-02f, -1.72041357e-01f, -1.02963306e-01f, 5.31876273e-02f, -3.57847475e-02f, -9.47305635e-02f,
  3.17032337e-02f, 9.43095237e-02f, -1.47383232e-02f, 1.08430944e-01f, -2.38931105e-02f, -1.18966848e-01f, -2.58950144e-02f, -7.14919046e-02f, -1.03186816e-01f, -6.70599416e-02f,
  5.14160812e-01f, -1.10004552e-01f, 5.52964546e-02f, 5.32527454e-02f, -7.64073208e-02f, -5.06255701e-02f, -6.75056726e-02f, 5.70079908e-02f, 4.75853905e-02f, 8.01047087e-02f,
  8.10500756e-02f, -5.56055922e-03f, 1.45307966e-02f, 2.66977586e-02f, 1.39087597e-02f, 6.88525289e-02f, -9.03355237e-03f, 1.56018540e-01f, 5.33092879e-02f, 4.99110632e-02f,
  3.06348503e-02f, 1.34600177e-02f, 9.27317068e-02f, 1.35575548e-01f, 1.78173706e-01f, 7.16163740e-02f, 2.59407014e-01f, 3.90473530e-02f, 2.06035912e-01f, 1.94244102e-01f,
  -3.45109493e-01f, 1.28519341e-01f, -3.55971396e-01f, -8.61279815e-02f, 3.35546657e-02f, 2.23505974e-01f, 1.51193783e-01f, 3.11080873e-01f, 3.69495034e-01f, -1.43487185e-01f,
  -1.41385943e-01f, -1.81127444e-01f, -3.85595143e-01f, -2.23475993e-01f, -1.54552981e-01f, -2.66643375e-01f, -4.07081723e-01f, -3.17721725e-01f, 7.46045485e-02f, 2.29150623e-01f,
  1.09907061e-01f, -8.60598162e-02f, -1.47490323e-01f, -9.16610286e-02f, -6.38185516e-02f, -3.74031425e-01f, -3.93573731e-01f, -2.07772762e-01f, -2.27392286e-01f, -5.79078853e-01f,
  -2.16416404e-01f, 1.30262956e-01f, 9.47515070e-02f, -1.54738531e-01f, -6.22567013e-02f, -9.97163132e-02f, 2.99710874e-02f, -4.17489447e-02f, -3.64822522e-02f, -1.82816200e-02f,
  -2.35105038e-01f, 7.51413777e-02f, -6.23808289e-03f, -9.88630056e-02f, 3.12499963e-02f, 9.01676528e-03f, 7.62171447e-02f, 4.62379009e-02f, -4.27835099e-02f, 1.67166293e-01f,
  -5.33829303e-03f, -2.41899356e-01f, -3.04788530e-01f, -6.28817007e-02f, 3.17530483e-01f, -2.24606708e-01f, 9.48555488e-03f, 1.83291063e-01f, -1.45866752e-01f, -2.88607448e-01f,
  2.07438290e-01f, 8.78591910e-02f, 1.44178405e-01f, -4.81163748e-02f, -9.85794142e-02f, -1.03402056e-01f, -8.30030814e-02f, -2.97201611e-02f, 9.26180091e-03f, 7.59629756e-02f,
  -2.99931783e-02f, 9.61018428e-02f, 8.92698467e-02f, -2.50757299e-02f, -8.77115205e-02f, -4.37351242e-02f, -2.42828410e-02f, 3.33615355e-02f, -9.96320024e-02f, -3.43597569e-02f,
  -3.29323187e-02f, -1.10801294e-01f, 2.57123280e-02f, 1.52648389e-01f, -3.50385569e-02f, 8.80877748e-02f, 5.43454923e-02f, -6.45875465e-03f, 1.52398810e-01f, 1.33858353e-01f,
  -1.22417919e-01f, -1.14656817e-02f, -1.93806365e-01f, 4.22809087e-02f, 5.26689850e-02f, 9.27467793e-02f, -5.77326529e-02f, 2.00996652e-01f, 7.49494210e-02f, 1.87094271e-01f,
  2.18047857e-01f, 1.15434108e-02f, 5.95597811e-02f, -7.01231277e-03f, 7.25330189e-02f, 3.00097577e-02f, -6.31016418e-02f, -1.91805825e-01f, -2.46110540e-02f, 2.80138820e-01f,
  7.40528330e-02f, -1.92166850e-01f, -3.31767470e-01f, -3.82393450e-01f, -2.47130375e-02f, -5.02393186e-01f, -3.54359210e-01f, 4.98514026e-02f, -3.00087214e-01f, -3.25033247e-01f,
  6.57356262e-01f, 1.11131437e-01f, 3.41206610e-01f, -6.66106716e-02f, -4.44382519e-01f, -4.23721641e-01f, -5.01569927e-01f, -1.64040804e-01f, -1.31345391e-01f, 2.53331847e-02f,
  -2.22227454e-01f, -2.39632413e-01f, -2.86094081e-02f, 8.92637968e-02f, 2.07258299e-01f, 1.44759595e-01f, 1.83052704e-01f, 4.56922382e-01f, 1.75882742e-01f, 3.80806923e-02f,
  -6.11327700e-02f, 1.96946859e-01f, 4.48523283e-01f, 2.00182244e-01f, 4.84019034e-02f, 4.76666912e-03f, -9.49996263e-02f, -1.14975788e-03f, 3.86357680e-02f, 4.63325799e-01f,
  2.96285987e-01f, 2.17839167e-01f, -1.32950485e-01f, 5.84551059e-02f, 1.45217836e-01f, 2.60206848e-01f, 6.34770170e-02f, 1.28590614e-01f, -3.15743499e-02f, 5.26130497e-02f,
  -1.31218350e-02f, 6.98250905e-02f, -3.43942828e-02f, -3.14706340e-02f, 1.09558674e-02f, -1.04254767e-01f, 4.74231951e-02f, 7.03323931e-02f, 1.03967026e-01f, 4.06259745e-02f,
  -1.71969891e-01f, -1.18754141e-01f, -1.19058326e-01f, -1.78460881e-01f, -3.69201414e-02f, -1.10307023e-01f, -6.76524192e-02f, -2.61926707e-05f, -2.58837976e-02f, 1.98483374e-02f,
  -1.28023610e-01f, 2.56704614e-02f, -1.18347276e-02f, -4.48980331e-02f, -7.25187138e-02f, -8.79797898e-03f, -5.91413863e-02f, -9.72820148e-02f, 4.12735790e-02f, 3.45513634e-02f,
  -6.79642186e-02f, -3.03989518e-02f, 6.96471408e-02f, -6.30016476e-02f, 1.04894429e-01f, 7.03231990e-02f, -2.43084948e-03f, -8.84488374e-02f, -1.51001990e-01f, 4.22779359e-02f,
  2.77277790e-02f, 1.40614435e-03f, 1.06976666e-01f, 2.33684219e-02f, -7.22679123e-03f, -1.00072352e-02f, 2.36186646e-02f, -1.12996943e-01f, -1.81374773e-02f, 5.44415694e-03f,
  -1.90164760e-01f, -1.39851332e-01f, 2.14414522e-01f, 2.50580460e-01f, 1.07853644e-01f, -8.88708339e-04f, 1.66090205e-01f, 9.39828455e-02f, -3.07172667e-02f, 2.30600070e-02f,
  8.50264207e-02f, 1.44851834e-01f, 6.55355603e-02f, 1.39913335e-01f, 5.20419404e-02f, -7.12842494e-02f, -7.22329877e-03f, -3.70991454e-02f, -5.13603874e-02f, 3.27456854e-02f,
  -3.43333483e-02f, -2.01948211e-01f, -3.10638040e-01f, -2.98946023e-01f, -1.85511991e-01f, -2.09103599e-01f, -1.08414389e-01f, -4.98425448e-03f, -2.27700353e-01f, -1.66536972e-01f,
  -2.65956402e-01f, -2.31055822e-02f, 1.11317016e-01f, 2.54579067e-01f, 3.22647721e-01f, 1.65180042e-01f, 2.14191496e-01f, 2.17067245e-02f, 1.82434916e-01f, 1.34063497e-01f,
  1.09542102e-01f, 1.18542455e-01f, 2.54959911e-01f, 9.01809558e-02f, 1.66752994e-01f, 1.08833186e-01f, 3.23965460e-01f, 1.40594393e-01f, 7.24742264e-02f, 8.04865807e-02f,
  1.43566251e-01f, -5.88945560e-02f, -2.31434405e-01f, 1.83812380e-02f, 2.19981074e-01f, 2.05483779e-01f, 1.60216559e-02f, 1.14622265e-01f, 2.19367325e-01f, 2.90039778e-01f,
  -2.10144892e-02f, 4.00180817e-02f, 1.62666813e-01f, 7.18791410e-02f, -7.61959925e-02f, -2.79806197e-01f, -3.63632068e-02f, -1.21834449e-01f, -1.99313492e-01f, -8.27092379e-02f,
  -1.35469034e-01f, -9.13790911e-02f, 1.15095600e-02f, 3.27901496e-03f, -1.61646351e-01f, -2.43889034e-01f, -8.69338587e-02f, 8.22197497e-02f, 1.31802857e-01f, 1.22728027e-01f,
  1.98034704e-01f, 1.46865621e-01f, 1.10833846e-01f, 4.63136546e-02f, 2.23980442e-01f, 8.29315707e-02f, -3.62903886e-02f, -3.49606089e-02f, -3.78766209e-02f, 8.64479393e-02f,
  3.51406753e-01f, -3.80310677e-02f, 2.40072414e-01f, 1.39443651e-01f, 6.83509931e-02f, 4.06726077e-02f, 2.58924924e-02f, 1.22409128e-01f, 1.52643457e-01f, 8.30099732e-02f,
  6.01382367e-02f, 2.94194609e-01f, 9.83480215e-02f, -6.37264326e-02f, 6.03509210e-02f, 1.45934150e-01f, 2.76032053e-02f, -1.49537558e-02f, 6.56099916e-02f, -1.20740170e-02f,
  4.98466976e-02f, -1.36269704e-01f, -1.32146761e-01f, 3.36636007e-02f, -6.28367215e-02f, 6.18968010e-02f, 2.23268550e-02f, -1.32403560e-02f, 3.34074460e-02f, -5.88240214e-02f,
  3.35734487e-02f, 3.19183022e-01f, 1.84194237e-01f, 3.04335468e-02f, -6.84537366e-02f, -2.23256961e-01f, 2.25086659e-01f, -6.17613755e-02f, -3.72021757e-02f, 6.75429869e-03f,
  -5.30401804e-02f, -1.63079411e-01f, -1.15378322e-02f, 2.18184702e-02f, -8.81333947e-02f, -1.99571833e-01f, 1.54636378e-04f, 1.22925945e-01f, -2.66599655e-02f, 2.99542509e-02f,
  -1.67419389e-02f, 2.10157856e-02f, -3.18165869e-02f, 1.13610834e-01f, 1.35184437e-01f, -2.62176022e-02f, -7.17115328e-02f, -6.08823150e-02f, -1.26431257e-01f, -1.83204055e-01f,
  6.00808620e-01f, 3.81359011e-01f, 2.87030309e-01f, 1.77808940e-01f, 2.30763286e-01f, 2.74360061e-01f, 2.97730297e-01f, 1.88584924e-01f, 1.14789397e-01f, 2.63078004e-01f,
  1.78587541e-01f, 2.24067457e-02f, 2.82177385e-02f, -3.94337550e-02f, -2.04503052e-02f, -6.98155016e-02f, -2.05196649e-01f, -7.35434070e-02f, -4.44662347e-02f, -5.39432615e-02f,
  -2.60909230e-01f, -6.42012134e-02f, 8.54986012e-02f, -2.05684796e-01f, -7.86186159e-02f, -2.00861573e-01f, -7.25880191e-02f, -8.87836069e-02f, -2.15337321e-01f, -3.82073462e-01f,
  4.83925976e-02f, 3.22254002e-01f, 3.82811166e-02f, 1.59880351e-02f, 1.98216707e-01f, 9.27298144e-02f, 1.17783353e-01f, 5.80668226e-02f, 1.38191476e-01f, -3.71570177e-02f,
  1.14332564e-01f, 1.07272929e-02f, 5.00243530e-03f, 1.11129936e-02f, 8.69394243e-02f, 1.31049808e-02f, 1.85112525e-02f, -3.57204229e-02f, 3.22582647e-02f, 1.00999184e-01f,
  6.82257414e-02f, 2.17062443e-01f, 2.60187179e-01f, 1.41146466e-01f, 6.26105294e-02f, 3.42964754e-02f, 1.78425536e-01f, 3.41540016e-02f, -1.81923974e-02f, 4.31951545e-02f,
  -2.08794937e-01f, -6.21616095e-02f, 9.82841179e-02f, 6.60616159e-03f, -1.15205478e-02f, -2.95903794e-02f, -4.85888188e-04f, -6.30903542e-02f, 7.71327391e-02f, 6.07853681e-02f,
  5.54858446e-02f, 4.44326475e-02f, 9.76390690e-02f, -7.13767186e-02f, 6.63127005e-02f, 7.32921958e-02f, -1.26777496e-02f, 2.35572048e-02f, 9.41729099e-02f, 3.06471493e-02f,
  1.20325036e-01f, 4.27301861e-02f, 3.62189785e-02f, 5.36718890e-02f, -4.42534359e-03f, 3.79519910e-03f, -2.76144687e-03f, -8.92674550e-02f, -5.22399023e-02f, -1.43074449e-02f,
  8.58481228e-02f, 3.02777618e-01f, -1.51934147e-01f, -9.23661962e-02f, 1.85461435e-02f, 1.74822330e-01f, 9.29300785e-02f, -1.46911725e-01f, -1.03538809e-02f, -2.49594264e-02f,
  1.40943483e-01f, -4.58936393e-02f, -1.43555459e-03f, 8.36061239e-02f, 1.56540766e-01f, -6.97498098e-02f, -3.20779569e-02f, 7.79936314e-02f, -6.65615052e-02f, 1.53319150e-01f,
  -3.49915437e-02f, 1.17119066e-01f, 1.02039404e-01f, -5.93656451e-02f, -1.82760254e-01f, -1.08184025e-01f, 8.72864947e-03f, -7.21020997e-02f, 4.80159149e-02f, -1.58442229e-01f,
  -2.86217839e-01f, -1.33292554e-02f, -6.07273355e-02f, 1.79301023e-01f, 2.92139292e-01f, -2.14460015e-01f, -4.83435154e-01f, -3.20683002e-01f, 1.81024075e-01f, -2.81035155e-01f,
  -1.26830935e-01f, 1.82236761e-01f, 1.57334178e-03f, -2.61826128e-01f, -8.20510447e-01f, -5.12044132e-01f, -3.92407000e-01f, -4.55299169e-01f, -3.96854073e-01f, -7.60817230e-02f,
  6.08280040e-02f, 4.35176417e-02f, -2.40484208e-01f, 3.30574512e-02f, 3.31983387e-01f, 1.90394297e-01f, 1.90118298e-01f, 1.41884744e-01f, 2.91837640e-02f, 2.02353075e-01f,
  3.21250528e-01f, -9.55773611e-03f, 9.13066491e-02f, -7.55559206e-02f, 3.00711095e-01f, -8.96034464e-02f, 6.34591430e-02f, -3.96917611e-02f, -3.01961359e-02f, 2.43205875e-02f,
  1.52288422e-01f, -1.08468108e-01f, 1.65835768e-01f, 1.00696735e-01f, -1.04207117e-02f, -1.55294746e-01f, -7.91080892e-02f, -3.52832198e-01f, -2.73787469e-01f, -3.95028590e-04f,
  -2.35491153e-02f, -6.57972321e-02f, -2.14985013e-01f, -1.95539281e-01f, -2.00673789e-01f, 6.64755553e-02f, 1.52949989e-01f, 9.21723768e-02f, -6.59278333e-02f, 2.78892457e-01f,
  -4.75732982e-02f, -2.50096116e-02f, 8.62641782e-02f, 4.63105319e-03f, -5.52827939e-02f, 7.06448928e-02f, -3.08399536e-02f, -8.17391798e-02f, -3.52064557e-02f, 3.63768227e-02f,
  9.16479453e-02f, -6.59966767e-02f, 3.14210393e-02f, -1.27702191e-01f, 1.27258703e-01f, -5.38516715e-02f, -8.87538493e-02f, -9.05451402e-02f, -1.05578952e-01f, -8.94838721e-02f,
  -5.50525449e-02f, 5.45189977e-02f, 1.37833133e-01f, 6.48356751e-02f, -1.31308734e-01f, -1.26516014e-01f, -3.45430635e-02f, -1.69929042e-01f, -7.27593005e-02f, -1.48526266e-01f,
  1.42676756e-01f, -3.69160354e-01f, 6.67463383e-03f, -2.27828369e-01f, -1.91530418e-02f, -5.29436953e-02f, 4.40377370e-02f, -5.93686663e-02f, -6.92466646e-02f, -1.59632087e-01f,
  -1.97146043e-01f, 2.34745769e-03f, 1.69781297e-01f, 6.64855465e-02f, 3.07626072e-02f, 1.61664173e-01f, -1.39302323e-02f, 5.46446554e-02f, -3.49763870e-01f, 9.65114683e-02f,
  -5.74928820e-02f, -2.97300428e-01f, -1.43815130e-01f, 9.47649684e-03f, 5.38987778e-02f, -8.93361270e-02f, 7.32389912e-02f, 1.97297171e-01f, -2.86772519e-01f, -1.25429064e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.36989272e-01f, 1.42761886e-01f, 4.03168350e-01f, 2.07940400e-01f, 3.40148717e-01f, 3.58691275e-01f, 4.05603349e-01f, 2.46253222e-01f, 9.66218337e-02f, -1.06296949e-01f,
  3.91270250e-01f, 3.40198427e-01f, -1.18306838e-01f, 1.69874623e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -8.65909010e-02f, 4.29403782e-02f, 1.78631604e-01f, -7.96684697e-02f, 4.34377044e-02f, -7.99608901e-02f, -1.74113661e-02f, -1.55427560e-01f, -9.11723997e-04f, -4.00672853e-03f,
  1.05385929e-02f, -1.44233197e-01f, 5.21221012e-02f, -7.55722597e-02f, -3.00810467e-02f, -8.86117294e-03f, -3.21472175e-02f, -1.49259582e-01f, 1.94835395e-01f, -1.37191683e-01f,
  1.36587009e-01f, 5.30329049e-02f, 1.12027474e-01f, 5.21128662e-02f, 1.52802793e-02f, -2.17667222e-01f, -7.24956533e-03f, 2.89979666e-01f, -1.21643916e-01f, 1.84930965e-01f,
  -7.00258613e-02f, 1.10324712e-04f, -1.26751075e-02f, 7.27481246e-02f, 2.49189720e-01f, -1.57532230e-01f, -1.29491523e-01f, 5.88183925e-02f, 5.63613027e-02f, -1.57486182e-02f,
  -5.02122305e-02f, -4.96391095e-02f, 2.02016398e-01f, 1.10548191e-01f, 6.12748004e-02f, 4.16215099e-02f, -8.01578015e-02f, 2.94951975e-01f, -1.93892136e-01f, -4.82812747e-02f,
  1.92617513e-02f, 1.40131861e-01f, -1.34467110e-01f, 2.80467778e-01f, 4.41209450e-02f, -3.31171542e-01f, 6.99594393e-02f, -2.23596632e-01f, -1.75628304e-01f, -3.26902382e-02f,
  3.02704517e-02f, -1.89281568e-01f, 1.79969966e-01f, 1.27226800e-01f, -2.08781790e-02f, 2.54201982e-03f, 1.03878267e-01f, -1.35829318e-02f, -8.34985301e-02f, 5.46441451e-02f,
  -9.46244746e-02f, 1.28026292e-01f, 4.72058952e-02f, -1.41570577e-02f, 2.59431507e-02f, 2.68494785e-02f, 2.12584555e-01f, 1.15953252e-01f, 8.64255875e-02f, 1.14971995e-01f,
  1.56586841e-01f, -8.53485689e-02f, -2.25812241e-01f, -4.27063666e-02f, -3.71506959e-02f, -3.17400433e-02f, -1.31417751e-01f, 3.52473259e-02f, -1.66417956e-01f, 5.83540499e-02f,
  1.38457641e-01f, -1.76756382e-01f, -8.83515328e-02f, 2.76646584e-01f, 1.08729191e-01f, 2.00818166e-01f, 7.75211528e-02f, 8.65666270e-02f, -8.22890475e-02f, 1.70016557e-01f,
  9.86672118e-02f, 2.88516805e-02f, -9.70018879e-02f, 2.11091772e-01f, -8.50936994e-02f, 2.81928509e-01f, -2.27985278e-01f, -5.03943563e-02f, 1.65637046e-01f, -1.35904968e-01f,
  -1.93766043e-01f, 1.47030465e-02f, -8.76936838e-02f, -7.46783093e-02f, 1.58791587e-01f, 1.64538309e-01f, 9.68986601e-02f, -1.99721187e-01f, 2.89481670e-01f, 6.92255571e-02f,
  -7.83361774e-03f, 3.29013497e-01f, -2.81075060e-01f, 3.98592874e-02f, -5.40541746e-02f, 1.70695111e-01f, -3.57732065e-02f, -3.20599452e-02f, -1.98046537e-03f, 4.56755348e-02f,
  6.48631305e-02f, -7.01198354e-02f, -1.41215101e-01f, -5.56812249e-02f, 3.49844457e-03f, 7.96460882e-02f, -1.04145333e-01f, 2.27144524e-03f, -1.58048421e-01f, -2.60620862e-02f,
  3.65459956e-02f, -6.92545176e-02f, -1.65534005e-01f, -4.30564880e-02f, 1.22317940e-01f, 1.85423553e-01f, -1.75209373e-01f, -6.30925149e-02f, -1.40075773e-01f, -6.01297356e-02f,
  -1.09515889e-02f, -9.54840854e-02f, 8.33536908e-02f, -2.37380918e-02f, 1.41972870e-01f, -4.35947552e-02f, -5.54961525e-02f, 3.10893189e-02f, -1.16923666e-02f, 1.87531412e-01f,
  3.30094010e-01f, 2.20260974e-02f, -1.18850127e-01f, 1.52102426e-01f, 5.87314852e-02f, 1.24891348e-01f, 1.63440108e-01f, 1.42069697e-01f, 2.01845486e-02f, 2.18122810e-01f,
  -5.70080467e-02f, 8.17680433e-02f, 2.21507281e-01f, -1.96781382e-01f, 1.04151154e-03f, -1.76501006e-01f, 1.99171640e-02f, 1.18370885e-02f, 5.77170402e-03f, 1.88177273e-01f,
  2.40694553e-01f, -2.31914118e-01f, -8.33761618e-02f, 8.03028867e-02f, 1.35611281e-01f, 7.40566105e-03f, 1.34599775e-01f, -4.29616310e-02f, -2.29414910e-01f, 8.96301419e-02f,
  1.39035314e-01f, 2.66579376e-03f, 7.46197775e-02f, -1.00649096e-01f, 1.24684632e-01f, 1.39066607e-01f, 1.44806296e-01f, -7.46136822e-04f, 8.81387740e-02f, -1.00655518e-01f,
  6.36788234e-02f, 4.77012619e-02f, -2.16381196e-02f, 1.99429259e-01f, -6.25329167e-02f, -3.24567407e-02f, -2.10903119e-02f, 1.40995249e-01f, 8.37777182e-02f, 5.22927046e-02f,
  -8.52653012e-02f, -1.90880131e-02f, 1.04846107e-02f, -4.89732400e-02f, -2.11239606e-02f, -1.06385285e-02f, 1.18074834e-01f, -6.10202178e-02f, -4.01606224e-02f, -3.10969651e-01f,
  2.09981829e-01f, -1.61001682e-01f, -8.05196017e-02f, -1.19137421e-01f, 2.40744408e-02f, -4.50368710e-02f, 1.00851856e-01f, 9.75615159e-02f, -1.44369602e-02f, -2.30454385e-01f,
  -2.17260435e-01f, 2.60082006e-01f, 2.06789017e-01f, -3.96806300e-02f, 4.84158807e-02f, 7.82346651e-02f, -2.50303149e-02f, -1.16992213e-01f, 4.07388620e-02f, 1.64163500e-01f,
  2.49152794e-01f, -5.91953211e-02f, 6.85160384e-02f, 2.10077181e-01f, -3.60381365e-01f, -3.29965889e-01f, -3.30028802e-01f, 1.08979717e-01f, 1.06277205e-01f, 1.50933906e-01f,
  -1.03224013e-02f, -2.15529010e-01f, 2.79114991e-01f, 2.02893361e-01f, -7.24057257e-02f, -2.92010009e-01f, 7.48988092e-02f, 3.56935114e-02f, -2.14282930e-01f, -8.57813582e-02f,
  -1.31775215e-01f, 3.30701061e-02f, 1.19654924e-01f, 6.24711178e-02f, 1.02076158e-02f, 2.09920295e-02f, -1.53637873e-02f, -3.86142284e-02f, -4.40346785e-02f, -2.06227638e-02f,
  6.76121861e-02f, -1.19602298e-02f, 5.84104434e-02f, -3.98005135e-02f, -1.47192687e-01f, -2.61568613e-02f, -3.48802395e-02f, 1.08692475e-01f, -2.58280993e-01f, 3.05362456e-02f,
  -1.95464820e-01f, 1.32967129e-01f, 3.77312005e-02f, -2.74881124e-01f, 6.37506694e-02f, -1.25188619e-01f, 1.47115774e-02f, -8.80846847e-03f, -5.12721315e-02f, -7.82923177e-02f,
  -8.71228334e-03f, -2.40768585e-02f, 1.39669171e-02f, 1.67867560e-02f, -1.13457210e-01f, -3.21059697e-03f, -5.39092235e-02f, 3.31462324e-02f, 3.96907330e-02f, -1.21250637e-01f,
  8.93005356e-02f, 1.10032395e-01f, 1.19967975e-01f, -1.34730279e-01f, 2.34433450e-02f, 8.63173828e-02f, 9.30740014e-02f, 4.87444103e-02f, -2.11883038e-01f, -1.93971604e-01f,
  -2.59612411e-01f, 7.47086704e-02f, 2.91384578e-01f, 3.18494022e-01f, -1.21465288e-01f, 1.36348665e-01f, 3.54005426e-01f, -9.38093290e-02f, -1.20375425e-01f, -3.04335356e-01f,
  2.46335015e-01f, -6.87140413e-03f, -1.22583598e-01f, 3.20727658e-03f, 4.89784516e-02f, -4.10402864e-02f, 1.36693254e-01f, -6.48732344e-03f, -2.95276637e-03f, 1.61908895e-01f,
  4.20442037e-02f, -1.75584834e-02f, 7.03373030e-02f, -8.35974813e-02f, -8.78678337e-02f, -7.57745355e-02f, 1.16696768e-01f, -6.72065616e-02f, -1.64359331e-01f, -1.98237896e-02f,
  -1.21468566e-02f, -1.77624484e-03f, -8.28048214e-02f, 9.05307825e-04f, -5.62641174e-02f, 7.33599290e-02f, -3.71128730e-02f, 1.43816220e-02f, 3.03135458e-02f, -1.21601865e-01f,
  -2.67279804e-01f, -1.34995952e-02f, -1.40178606e-01f, 4.29543667e-02f, -7.83100128e-02f, 2.53832102e-01f, -3.39393951e-02f, 2.07965165e-01f, -8.08859020e-02f, 2.15209592e-02f,
  1.55431136e-01f, -1.21213369e-01f, 2.27128401e-01f, 2.09067702e-01f, 1.06638439e-01f, -1.15586407e-01f, 1.15546569e-01f, -1.08583279e-01f, 3.84238102e-02f, 1.57393664e-01f,
  -1.54075906e-01f, 3.02247226e-01f, -4.62290086e-02f, -1.94359079e-01f, -4.15222913e-01f, 2.27581054e-01f, 1.82636917e-01f, 1.47677422e-01f, -2.22399041e-01f, 1.08036222e-02f,
  3.05397660e-02f, 3.04682590e-02f, -1.39455870e-01f, -2.10202307e-01f, -9.55611095e-03f, 1.63175166e-01f, 1.21151134e-01f, -1.46844819e-01f, 5.14985397e-02f, 8.51029605e-02f,
  -4.07484397e-02f, -1.74623087e-01f, 8.09112862e-02f, 1.21809721e-01f, 1.24604516e-01f, 7.38199055e-02f, 8.31874646e-03f, 3.25348191e-02f, 7.50120804e-02f, 3.10583506e-02f,
  1.54039472e-01f, 2.15798151e-02f, 4.23377007e-02f, 3.70672047e-02f, 1.67141065e-01f, 4.87978756e-02f, 1.88353524e-01f, -6.76716715e-02f, 2.63447642e-01f, 3.86282913e-02f,
  -3.54469079e-03f, 8.85766000e-02f, -1.92028508e-01f, 1.03000812e-01f, 1.26775041e-01f, 1.41607877e-03f, -1.27100304e-01f, 1.59179211e-01f, -5.24284765e-02f, 8.37455392e-02f,
  -5.87056093e-02f, -4.16584015e-02f, 9.16391015e-02f, 8.72148052e-02f, 7.65907019e-02f, -1.18236933e-02f, -5.08022914e-03f, 2.88919270e-01f, 3.21809202e-01f, -1.49113148e-01f,
  -8.39929804e-02f, 4.74031270e-02f, -1.53889805e-01f, 8.12239498e-02f, 3.80267620e-01f, -2.09229663e-02f, -1.75148815e-01f, 2.60570407e-01f, -5.97461462e-02f, -1.63061514e-01f,
  1.92367464e-01f, -3.62483375e-02f, 1.25328079e-01f, 2.01027095e-01f, -7.76741356e-02f, -9.17632729e-02f, -1.68861985e-01f, 3.92984778e-01f, 5.82706183e-02f, -4.31332104e-02f,
  2.28375852e-01f, 9.12043964e-04f, -5.74986227e-02f, 1.48914363e-02f, -5.49610332e-02f, 3.16950902e-02f, -9.52362940e-02f, 8.47991258e-02f, 1.09348372e-01f, 1.33222342e-01f,
  4.16641729e-03f, -5.10764010e-02f, -3.63156237e-02f, 2.06864178e-02f, -3.36117037e-02f, -4.45912071e-02f, 7.84841329e-02f, -1.38740569e-01f, 7.63734654e-02f, 1.15517110e-01f,
  1.16160199e-01f, 5.92231611e-03f, 6.00797236e-02f, -1.75077066e-01f, 1.52257527e-03f, 1.70759737e-01f, -6.92172423e-02f, 1.52342841e-01f, 8.95486120e-03f, 1.20438315e-01f,
  9.83448699e-02f, 1.15782917e-02f, -1.17418483e-01f, -2.58326926e-03f, -1.07615612e-01f, 1.64944939e-02f, 1.08660467e-01f, 1.38757080e-01f, -2.55436413e-02f, 1.70290172e-02f,
  6.72809184e-02f, 1.37158826e-01f, 1.59395859e-01f, 2.28403006e-02f, 6.31981418e-02f, 2.36168638e-01f, -8.03634003e-02f, -5.20790592e-02f, 1.55631542e-01f, 2.10586593e-01f,
  -1.23455383e-01f, -1.90790087e-01f, -3.99391800e-02f, -3.93524915e-01f, -2.00507626e-01f, 1.53007999e-01f, -1.53765474e-02f, 8.32925141e-02f, -8.02934393e-02f, -5.38571179e-02f,
  -1.74016923e-01f, 8.17129090e-02f, 1.31048113e-01f, -3.88156436e-02f, -2.27316692e-01f, 7.16073737e-02f, 1.34288389e-02f, 1.31342128e-01f, 4.77444381e-02f, 1.55073196e-01f,
  -2.94807740e-03f, -1.28480166e-01f, -6.08666725e-02f, -3.90299596e-02f, 3.82302999e-02f, -1.47338165e-02f, -1.42983273e-01f, -1.66232601e-01f, 1.61228944e-02f, 6.70342520e-02f,
  3.91986482e-02f, -1.05337746e-01f, -7.07338154e-02f, 1.53287891e-02f, -3.61961164e-02f, 8.85979552e-03f, -1.84669062e-01f, 1.26880482e-01f, 2.54682526e-02f, 4.65008914e-02f,
  1.19873229e-02f, -9.07063410e-02f, 1.29078021e-02f, 1.40931353e-01f, -4.97812144e-02f, -9.77328327e-03f, 1.94970846e-01f, -1.30470783e-01f, 7.82334898e-03f, 1.26909137e-01f,
  7.29079023e-02f, -1.06260769e-01f, -1.29493132e-01f, 8.18958431e-02f, -5.51033616e-02f, -1.19567215e-01f, -3.30241710e-01f, 8.75856802e-02f, 4.10714746e-02f, 7.85858557e-03f,
  1.15979150e-01f, -3.09060644e-02f, -1.76232725e-01f, -2.85598934e-01f, 3.24151933e-01f, 1.90754116e-01f, 1.47691771e-01f, 1.83325246e-01f, -1.81724265e-01f, 2.54315026e-02f,
  -1.19158238e-01f, -1.18406147e-01f, 1.49258852e-01f, 9.43204463e-02f, 2.38771260e-01f, -1.07223623e-01f, 6.49617240e-02f, 1.03431894e-03f, -3.72830927e-02f, 4.68201824e-02f,
  -7.52082840e-02f, 8.38640779e-02f, -7.43944049e-02f, 5.76479025e-02f, 4.83320989e-02f, -1.36860281e-01f, 1.55321723e-02f, 3.16304825e-02f, -1.45753413e-01f, -1.49061128e-01f,
  1.34396240e-01f, -6.94265217e-02f, -9.69193652e-02f, 5.07616326e-02f, 1.80698618e-01f, 7.74316043e-02f, 1.29711792e-01f, -5.93568534e-02f, 1.26502633e-01f, -2.17013657e-02f,
  9.51725170e-02f, -6.23605549e-02f, -6.87383190e-02f, -9.09149945e-02f, 1.39883667e-01f, -1.52183950e-01f, 1.71575651e-01f, 7.55226519e-03f, -2.68059615e-02f, 1.77446187e-01f,
  6.54812679e-02f, -2.16470063e-01f, 1.51076838e-01f, -2.67868906e-01f, 1.36893272e-01f, -4.27606225e-01f, -2.73184836e-01f, 1.59520365e-03f, -6.62251860e-02f, -1.19549707e-01f,
  -1.64475605e-01f, 2.85580695e-01f, -1.95382647e-02f, -7.94002190e-02f, 8.72187167e-02f, -1.39314579e-02f, 1.87507465e-01f, -3.10205460e-01f, -1.93730008e-03f, 3.57937157e-01f,
  2.66137332e-01f, -5.21670133e-02f, 3.31852515e-03f, 6.01060912e-02f, 1.54007241e-01f, -2.70238593e-02f, -1.34310767e-01f, -1.32402316e-01f, 1.25834942e-01f, 1.22521088e-01f,
  9.45472568e-02f, 6.67172819e-02f, 1.99516743e-01f, -4.41362895e-02f, 1.32504895e-01f, -1.72588534e-05f, 1.29318982e-01f, -7.16480762e-02f, -5.14219068e-02f, 8.31931382e-02f,
  3.25154699e-02f, 6.17130771e-02f, 1.06924504e-01f, 1.25056311e-01f, -5.09150093e-03f, 1.14161022e-01f, 3.99106182e-02f, 3.60068157e-02f, 1.22019723e-01f, -1.13534361e-01f,
  -2.50539480e-04f, -3.92506793e-02f, -6.24396326e-03f, -4.39166352e-02f, 1.29995808e-01f, -1.61946163e-01f, -2.35752687e-02f, 1.96260065e-01f, -1.12265162e-02f, 1.12303481e-01f,
  3.03368103e-02f, -6.09726533e-02f, -4.31085341e-02f, 1.25682997e-02f, 7.15350807e-02f, 1.33795545e-01f, -1.30261943e-01f, 1.43019766e-01f, -1.83987081e-01f, 2.51873821e-01f,
  1.86468035e-01f, -2.51024943e-02f, 1.33293597e-02f, 1.83939025e-01f, 1.11091882e-01f, -1.75784200e-01f, -2.23814286e-02f, 1.76176056e-01f, -1.38460293e-01f, -7.51618072e-02f,
  2.89961454e-02f, -8.53808448e-02f, 2.41732568e-01f, 3.28957438e-02f, 8.89906660e-02f, -8.68234411e-02f, 1.78382635e-01f, -2.55213171e-01f, -1.74183130e-01f, -1.60987303e-01f,
  -2.36130934e-02f, 3.07140481e-02f, 2.72302687e-01f, 3.63888079e-03f, 3.66483890e-02f, -6.96147308e-02f, 1.73827589e-01f, -3.01769506e-02f, -2.77788401e-01f, 6.47458583e-02f,
  -1.24080479e-01f, -1.99777484e-01f, -6.56110281e-03f, -3.28130387e-02f, 8.11706856e-02f, -6.89818859e-02f, 1.48808524e-01f, 8.04127660e-03f, -1.02376379e-01f, -4.38368842e-02f,
  6.18357398e-02f, -8.63848403e-02f, -1.27817824e-01f, -5.76177798e-03f, 4.36483789e-03f, 1.38716146e-01f, 3.22803706e-02f, 7.78694579e-04f, -2.37072065e-01f, -5.41122770e-03f,
  -5.05420938e-02f, 2.36096233e-01f, 3.41228805e-02f, 2.22681269e-01f, -2.36736964e-02f, 6.85799196e-02f, -9.05034915e-02f, 9.11403447e-02f, 1.24035291e-01f, -1.60448123e-02f,
  -2.47687176e-01f, 1.98438138e-01f, 1.07031204e-01f, 9.88027379e-02f, -1.58841208e-01f, 7.68782422e-02f, 3.79784927e-02f, 2.60454379e-02f, 3.80813777e-02f, -1.26644596e-01f,
  1.20461043e-02f, 2.73786843e-01f, -9.22165290e-02f, -4.99571394e-03f, 1.55863792e-01f, 1.96247444e-01f, -4.00198013e-01f, 4.29217815e-02f, 5.12646176e-02f, -9.20293778e-02f,
  -1.12940624e-01f, 2.97982186e-01f, 1.18670888e-01f, 1.98732331e-01f, -2.07045570e-01f, 1.60109356e-01f, 5.65559091e-03f, 2.31911317e-01f, 6.86315969e-02f, 4.68489043e-02f,
  -3.43355201e-02f, -5.42774722e-02f, 1.68046914e-02f, 2.19133287e-03f, -7.48858228e-02f, -4.21226062e-02f, 6.84926137e-02f, 3.29927541e-02f, 1.86541979e-03f, 1.24865128e-02f,
  9.14399847e-02f, 3.74291069e-03f, -5.56305945e-02f, 2.11818703e-02f, 8.61334950e-02f, -1.50711894e-01f, -2.63073351e-02f, -1.10574245e-01f, -2.72503309e-02f, 3.28244902e-02f,
  6.23549297e-02f, 1.04309335e-01f, 5.52174002e-02f, -1.08497649e-01f, -5.93286566e-02f, 3.13769042e-01f, -6.67047948e-02f, 1.13521680e-01f, 1.62227396e-02f, -6.53814301e-02f,
  1.75131001e-02f, -1.00219227e-01f, -4.80812117e-02f, 2.17712224e-02f, -1.72660947e-01f, 3.82367969e-02f, 8.46285746e-02f, 3.44980985e-01f, 1.29002901e-02f, 1.00597516e-01f,
  6.89173713e-02f, 1.47815123e-01f, 1.11685671e-01f, -6.77594095e-02f, -8.64328742e-02f, 3.35872203e-01f, -6.46832660e-02f, 1.68473721e-01f, -1.43227831e-01f, 3.63334119e-01f,
  3.91776152e-02f, 3.63039859e-02f, 1.24890640e-01f, -4.80155557e-01f, -2.38693789e-01f, 1.36182830e-02f, -6.44750521e-02f, 1.40013874e-01f, 8.44158307e-02f, 4.80463319e-02f,
  1.56112820e-01f, 6.64104968e-02f, -7.34175742e-02f, -3.12001146e-02f, -1.36603966e-01f, 7.66703412e-02f, 9.52911302e-02f, 2.72052493e-02f, 3.69188637e-02f, -4.69126068e-02f,
  -6.07234761e-02f, -3.14941071e-02f, -1.47829384e-01f, -3.98042984e-02f, -8.11696872e-02f, 9.58267774e-04f, 3.25353630e-02f, -1.64096624e-01f, 1.95654593e-02f, 2.60088574e-02f,
  7.96106681e-02f, 4.58006281e-03f, -1.80035140e-02f, -4.90055755e-02f, 3.35159190e-02f, 7.74173439e-02f, 6.32265629e-03f, 6.65817931e-02f, -3.80972624e-02f, -1.45857051e-01f,
  1.24201633e-01f, -2.50831842e-01f, -4.39781360e-02f, 4.90145162e-02f, -1.02008082e-01f, -9.91881080e-03f, 1.83286637e-01f, -4.64470387e-02f, 1.36299506e-01f, -3.33937220e-02f,
  -6.47977218e-02f, -2.19683334e-01f, 1.49117876e-02f, 9.70815420e-02f, 2.05082297e-02f, -1.30777106e-01f, -1.84561491e-01f, 3.90227623e-02f, -5.32404184e-02f, -1.18107788e-01f,
  3.60169224e-02f, 1.46543235e-01f, -4.71870840e-01f, -3.34064811e-01f, 1.62436724e-01f, -6.37147352e-02f, -7.11570308e-02f, 3.10777783e-01f, 1.43114239e-01f, -6.99111596e-02f,
  8.72870442e-03f, -3.95941325e-02f, -8.10472518e-02f, 5.11911185e-03f, 1.80766284e-01f, 4.75441292e-02f, 1.32562622e-01f, -1.27805606e-01f, -1.33180544e-01f, 4.67732958e-02f,
  1.84691861e-01f, 1.32850334e-01f, 4.70227078e-02f, 1.02384999e-01f, -8.92123282e-02f, 1.11111552e-01f, -2.03434080e-01f, 4.83145975e-02f, 1.80403218e-01f, -9.01577547e-02f,
  -2.82403469e-01f, 2.39074811e-01f, -1.10575728e-01f, -1.04839206e-01f, -1.97080970e-01f, -3.59893441e-02f, -8.34786445e-02f, 1.58056110e-01f, -2.65780408e-02f, 1.32356295e-02f,
  -1.99153975e-01f, -2.61360034e-02f, -4.37427917e-03f, -5.20047918e-02f, 3.42413709e-02f, 6.82149082e-03f, -1.40615664e-02f, 1.50621355e-01f, -9.04755294e-02f, 2.34521609e-02f,
  -9.65199545e-02f, -4.52339835e-02f, -5.02560139e-02f, 2.87769943e-01f, 3.45096439e-02f, 2.27923781e-01f, 7.28649646e-02f, 7.20093772e-02f, -5.37728593e-02f, 7.08005130e-02f,
  4.11893576e-02f, -1.55046225e-01f, -2.90545356e-02f, 7.32407197e-02f, 1.71406582e-01f, 6.20039143e-02f, -3.41834396e-01f, 3.44497003e-02f, 2.86003590e-01f, -1.16756603e-01f,
  1.76220924e-01f, 4.16966975e-01f, -1.72460526e-01f, 3.48931039e-03f, -1.22003205e-01f, -1.30974293e-01f, 2.86554277e-01f, -2.24569384e-02f, -8.98462627e-03f, -2.03346983e-01f,
  -9.70280245e-02f, -1.51265669e-03f, -1.79405008e-02f, 5.22848824e-03f, -7.31593817e-02f, 1.67673975e-02f, 6.83845729e-02f, 1.02216541e-03f, 1.03196569e-01f, 6.70506954e-02f,
  7.12289102e-03f, -8.53235722e-02f, 3.94475348e-02f, -4.62096091e-03f, -1.76285028e-01f, 1.13677688e-01f, 6.60741627e-02f, -1.80050079e-02f, -1.54532511e-02f, -1.15835294e-01f,
  1.55546563e-02f, 1.32569432e-01f, -3.15480022e-04f, 6.19320152e-03f, -1.22688241e-01f, -4.40149456e-02f, -7.47532956e-03f, 9.53420773e-02f, -1.07362889e-01f, 2.57917732e-01f,
  -1.98285848e-01f, 1.27016082e-01f, -2.16499195e-02f, -4.97131497e-02f, 1.22853838e-01f, 8.70418455e-03f, -1.75909042e-01f, 2.77245313e-01f, 1.16398714e-01f, -3.03403474e-02f,
  -3.53698358e-02f, 1.05539337e-01f, 2.60558397e-01f, 1.20394297e-01f, -8.77791177e-03f, -1.26645535e-01f, 2.33552027e-02f, 4.22115400e-02f, -8.06464106e-02f, 2.16801688e-01f,
  -5.33485651e-01f, 1.59281880e-01f, -1.15536414e-01f, 1.79504320e-01f, 7.98820630e-02f, 4.73320812e-01f, -1.91546660e-02f, 8.92838761e-02f, 1.72875166e-01f, -5.73310554e-02f,
  -3.21318567e-01f, -3.46217342e-02f, 6.82392791e-02f, -1.45906970e-01f, -4.41209339e-02f, -8.56029466e-02f, -2.94317938e-02f, 1.56469882e-01f, -8.53329152e-02f, -5.91022372e-02f,
  1.14531040e-01f, 5.13707511e-02f, -1.37094945e-01f, -7.45941550e-02f, -3.87332216e-02f, -2.18813345e-01f, -4.02369944e-04f, -9.20176227e-03f, 1.00581199e-01f, -1.36359856e-01f,
  5.22748083e-02f, -3.29142623e-02f, 3.75811271e-02f, 2.30818242e-02f, -3.24117169e-02f, -2.40816195e-02f, -1.60722230e-02f, -8.69271383e-02f, -9.32579562e-02f, 6.26088828e-02f,
  -4.21990044e-02f, 1.29479924e-02f, -6.80406243e-02f, 3.48251760e-02f, 6.29259720e-02f, 4.13463861e-02f, -6.90919608e-02f, 3.19131315e-02f, 2.33815238e-01f, -3.45747501e-01f,
  1.35126308e-01f, -1.38233200e-01f, -2.14388356e-01f, -2.48713970e-01f, -2.57882308e-02f, -2.15963461e-02f, -1.04315989e-01f, -1.64020255e-01f, -1.80679321e-01f, 1.74105942e-01f,
  -1.78299233e-01f, 2.13788792e-01f, 9.13793147e-02f, 3.18136066e-02f, 3.50327305e-02f, -5.17612398e-01f, -9.10493508e-02f, -3.66602652e-02f, 4.33221273e-02f, -8.60081092e-02f,
  -1.94680747e-02f, 2.60938797e-02f, -1.09942555e-01f, -5.60178887e-03f, -1.49849162e-01f, 1.20476462e-01f, 1.63486734e-01f, -6.69543818e-03f, -5.42064160e-02f, 4.64407690e-02f,
  -1.74661443e-01f, 9.36928168e-02f, 9.69953761e-02f, 4.34084721e-02f, 5.07672550e-03f, 5.59792072e-02f, 9.52273384e-02f, 1.05215743e-01f, 5.00841402e-02f, 1.59456246e-02f,
  2.35293850e-01f, 1.21103309e-01f, -2.59723794e-02f, 5.31882495e-02f, 1.92850474e-02f, 8.31937864e-02f, -1.60113752e-01f, 6.15312532e-02f, 8.86147171e-02f, 1.22830771e-01f,
  7.44118840e-02f, 1.98179826e-01f, -5.82075538e-03f, -5.18332608e-02f, -1.15474621e-02f, 9.36728790e-02f, -2.60385387e-02f, 1.87000573e-01f, -9.08673406e-02f, 6.60292581e-02f,
  -3.02600041e-02f, 1.00931488e-01f, 5.28250821e-02f, -2.60092504e-02f, -1.09351866e-01f, 7.56127015e-02f, 1.27839714e-01f, -9.22176167e-02f, -1.11114264e-01f, 1.80526182e-01f,
  2.84273088e-01f, 8.64618346e-02f, -1.91475381e-03f, 4.44580726e-02f, -9.63915884e-02f, 5.83143607e-02f, -4.70496006e-02f, 1.30627647e-01f, -3.10286969e-01f, -1.62022471e-01f,
  -1.43430233e-01f, 1.38359219e-02f, 8.40082392e-02f, 1.88987181e-01f, -4.36732844e-02f, 1.33919626e-01f, 1.72884256e-01f, -1.31557316e-01f, 3.01201105e-01f, -1.02920465e-01f,
  -1.42648974e-02f, 4.31299321e-02f, -7.84901157e-02f, 1.62874460e-02f, 1.68232352e-01f, 4.98832725e-02f, 4.38290425e-02f, 1.20677501e-01f, -6.92623332e-02f, -1.28818065e-01f,
  -7.37124234e-02f, -8.94403830e-02f, 8.73477533e-02f, 1.36464024e-02f, 1.25852585e-01f, -2.81253713e-03f, 9.72065702e-02f, -1.11083277e-01f, -1.30043570e-02f, 6.63068369e-02f,
  4.94753830e-02f, 1.43554702e-01f, 5.21118939e-02f, -1.25315279e-01f, 7.46787935e-02f, -2.60619484e-02f, 1.92010418e-01f, -1.62394606e-02f, -6.90804701e-03f, 6.37493879e-02f,
  4.47464213e-02f, -6.08837306e-02f, 9.94493440e-02f, -2.99567468e-02f, 1.16260819e-01f, 1.24283172e-02f, -1.71165708e-02f, -6.86297426e-04f, 6.74727857e-02f, 1.79449804e-02f,
  -1.03861548e-01f, 9.39231515e-02f, 2.15448409e-01f, 2.96126120e-02f, -8.11020136e-02f, -5.87142222e-02f, 5.99494949e-03f, 3.37085798e-02f, -1.45554587e-01f, 6.14260584e-02f,
  6.03967905e-02f, -9.00020525e-02f, 3.46796900e-01f, -2.52189606e-01f, 3.49277616e-01f, -3.86867672e-02f, 1.13240078e-01f, -6.71001524e-02f, 8.25430825e-02f, -2.53156573e-01f,
  -8.51951241e-02f, -1.93118155e-01f, 3.15737724e-01f, -3.12728852e-01f, 1.30193859e-01f, 1.32485285e-01f, 1.74172044e-01f, 4.26830053e-02f, 5.94054833e-02f, 4.59719747e-02f,
  1.10091522e-01f, 1.02087751e-01f, 6.36738092e-02f, 6.96418658e-02f, -8.24097171e-03f, 1.11524843e-01f, 6.41265586e-02f, 3.14431489e-02f, 1.94763944e-01f, -2.33080927e-02f,
  -1.90316111e-01f, 1.65735990e-01f, -1.36478797e-01f, 1.47300856e-02f, 1.36796579e-01f, -5.01568569e-03f, 1.04565911e-01f, 5.45925722e-02f, 5.64854629e-02f, 1.34344220e-01f,
  5.09608313e-02f, -1.84860915e-01f, -1.93498120e-01f, -1.17560990e-01f, -2.69476384e-01f, -1.48921460e-02f, 4.03473377e-02f, -1.22795910e-01f, -1.37439981e-01f, 7.35919699e-02f,
  1.24540329e-01f, 2.36085281e-01f, 5.11196330e-02f, 4.09425832e-02f, 1.27228335e-01f, 1.17382012e-01f, 1.08071953e-01f, -1.41921118e-01f, -2.56894846e-02f, 2.53670931e-01f,
  -2.31382668e-01f, -2.69152910e-01f, 5.25540523e-02f, 8.75160694e-02f, 4.05014679e-02f, 4.39770967e-02f, -1.32994398e-01f, 1.00490145e-01f, 2.07360566e-01f, -3.74110222e-01f,
  -2.81676799e-01f, -5.30002117e-02f, -1.33032158e-01f, -4.67765540e-01f, -1.36627108e-01f, 1.40377298e-01f, 4.83887583e-01f, 4.08965349e-02f, -5.13313822e-02f, -8.64500329e-02f,
  -1.77459773e-02f, -6.53106868e-02f, 1.11413114e-01f, -2.53335275e-02f, 2.47710478e-03f, 2.98320092e-02f, 4.70775999e-02f, -9.72225294e-02f, -5.13513871e-02f, -5.90963289e-02f,
  -6.36451542e-02f, 2.38520615e-02f, 4.91266772e-02f, 7.80752450e-02f, 9.08656567e-02f, 5.94265684e-02f, -1.54603571e-02f, 6.89550787e-02f, 2.43251082e-02f, -6.05503246e-02f,
  -2.28422098e-02f, -1.80039793e-01f, 5.58128729e-02f, 1.71947274e-02f, -4.39505205e-02f, -7.20793605e-02f, 1.81708094e-02f, -1.88642919e-01f, 2.04237029e-02f, -2.23699853e-01f,
  3.79199423e-02f, -7.03051686e-02f, 7.70474151e-02f, 4.71961126e-03f, 7.35779852e-02f, -6.76403847e-03f, 1.82557523e-01f, 3.32820532e-03f, -2.52384186e-01f, -1.60397634e-01f,
  6.34085983e-02f, -2.44719367e-02f, -6.60772398e-02f, -1.16691329e-01f, -4.98016141e-02f, -9.21011418e-02f, -8.41410086e-02f, -2.07937583e-01f, 1.34403914e-01f, 1.16873980e-01f,
  -1.22182339e-01f, -5.54725192e-02f, 2.86688030e-01f, -2.32902780e-01f, -6.83786049e-02f, 3.46620291e-01f, -2.51206666e-01f, -1.01392999e-01f, 2.89370298e-01f, -2.26110682e-01f,
  -1.24977574e-01f, -1.45353889e-02f, 2.60393955e-02f, -2.28523254e-01f, -8.80721882e-02f, 2.90792398e-02f, 7.24733248e-02f, -2.13108435e-02f, 2.25569084e-01f, 8.77813101e-02f,
  -1.26155719e-01f, 1.12329274e-01f, -1.19199298e-01f, 6.88294619e-02f, -6.33579418e-02f, 1.33172646e-02f, 2.14613885e-01f, -7.19461367e-02f, -1.56082660e-01f, 1.21720888e-01f,
  -1.33695351e-02f, -8.28294903e-02f, 2.47788406e-03f, 4.56923358e-02f, 3.95141840e-02f, 1.49486493e-02f, 1.33210018e-01f, 9.64695439e-02f, -1.50596090e-02f, -8.87786970e-02f,
  6.73387572e-02f, 3.29080045e-01f, -7.72845671e-02f, 3.67109209e-01f, 7.00005889e-02f, -1.03701629e-01f, -3.34177501e-02f, 1.59657836e-01f, 9.78962108e-02f, -3.61037664e-02f,
  -4.15063351e-02f, 1.24259042e-02f, 6.51354119e-02f, 5.29001690e-02f, 6.03530072e-02f, -1.83913503e-02f, -8.06053132e-02f, 9.32758674e-02f, 5.16779646e-02f, 5.06365262e-02f,
  -1.32585004e-01f, 5.50562263e-01f, -2.12842911e-01f, -1.22780710e-01f, 3.44392061e-02f, -1.70957848e-01f, -4.06199723e-01f, 4.28527854e-02f, 1.17475025e-01f, -2.04373106e-01f,
  -9.08267871e-03f, -1.52525529e-01f, 1.55022696e-01f, -1.27212167e-01f, 2.16606587e-01f, 2.03205049e-01f, -7.66372606e-02f, 8.39265212e-02f, 1.53543036e-02f, -1.28887268e-02f,
  2.58317918e-01f, -2.59998124e-02f, -2.07617842e-02f, 7.55162537e-02f, -1.22225754e-01f, -7.05116838e-02f, 1.98845584e-02f, 2.13360429e-01f, 2.30407286e-02f, 9.98548940e-02f,
  8.64689797e-02f, -1.19464658e-02f, -3.88381109e-02f, 1.05279483e-01f, -9.08291414e-02f, -3.90538909e-02f, -3.21243890e-02f, -3.12446579e-02f, 2.69243885e-02f, -1.53978858e-02f,
  1.44874588e-01f, -7.16828331e-02f, 6.81247413e-02f, -1.97476625e-01f, -5.25332429e-02f, 5.29341437e-02f, -1.31108060e-01f, 1.03502221e-01f, 4.05905806e-02f, -5.06738834e-02f,
  3.67937312e-02f, -3.51042077e-02f, -7.06956349e-03f, -4.70277630e-02f, -1.84634060e-01f, 9.15382653e-02f, 3.58092599e-02f, 2.53374994e-01f, 4.13859524e-02f, -5.80058508e-02f,
  -3.62328231e-01f, 1.20517083e-01f, 9.80545729e-02f, -7.58335814e-02f, -4.25694957e-02f, 3.13399345e-01f, 4.37907465e-02f, -6.78886697e-02f, 1.88351259e-01f, 2.37186719e-02f,
  3.64608675e-01f, -1.13704845e-01f, -7.50047490e-02f, -3.53274345e-01f, 4.09663480e-04f, -2.75966208e-02f, -2.22892657e-01f, 5.83037250e-02f, -3.67218666e-02f, -5.90233020e-02f,
  2.47573212e-01f, -9.22637898e-03f, -5.51562384e-02f, 1.77495964e-02f, 3.81339900e-02f, 2.89182365e-02f, 1.53517518e-02f, -5.73028252e-02f, 7.46213943e-02f, 8.74112844e-02f,
  6.03811629e-02f, -3.24016213e-02f, -1.39138028e-02f, 1.25974745e-01f, -1.84079714e-03f, 3.61540727e-03f, -8.34157467e-02f, 3.86682712e-02f, -3.85891199e-02f, 7.18277916e-02f,
  1.63712241e-02f, -7.03641623e-02f, 2.72297375e-02f, -9.05787498e-02f, 1.25600979e-01f, 2.63369549e-02f, -8.14039484e-02f, 3.69357951e-02f, -2.40638275e-02f, 1.45582035e-01f,
  -1.34973563e-02f, -6.70530796e-02f, -3.56394649e-02f, -5.45967482e-02f, -1.11559272e-01f, 3.06404028e-02f, 9.09835175e-02f, -1.07549533e-01f, -1.18090190e-01f, 8.69439095e-02f,
  7.32641965e-02f, -7.78198987e-02f, -7.22864345e-02f, -7.62815848e-02f, 3.50305557e-01f, 1.55162781e-01f, -6.68268278e-02f, 4.80016321e-02f, 1.02818258e-01f, -9.64578167e-02f,
  -8.37772414e-02f, 7.57061020e-02f, -4.08363879e-01f, -7.94133693e-02f, 1.60336182e-01f, 1.69350967e-01f, 2.27106899e-01f, 4.66193855e-01f, -7.00738728e-02f, 9.18495581e-02f,
  -2.50588059e-01f, -1.48066923e-01f, 8.68975967e-02f, 1.44083664e-01f, -1.94116727e-01f, 1.98707566e-01f, -1.86031625e-01f, 9.40646529e-02f, -6.95154369e-02f, 6.93670884e-02f,
  -1.51138589e-01f, 3.59896831e-02f, 1.12221083e-02f, -5.57752140e-03f, -4.93330183e-03f, -7.80760050e-02f, -1.40772704e-02f, -1.82372615e-01f, 5.10127097e-02f, 1.23638846e-02f,
  2.09706828e-01f, -1.10458784e-01f, -1.28625438e-01f, 4.20527067e-03f, 3.68946232e-02f, -7.55450204e-02f, -1.81777552e-02f, -5.24799451e-02f, -9.70802978e-02f, -1.18530085e-02f,
  8.15186277e-03f, -5.32192849e-02f, 4.40507755e-03f, 2.97334075e-01f, 1.99568160e-02f, 2.01535419e-01f, 2.53281891e-02f, 3.15409787e-02f, -1.91494189e-02f, -1.61094010e-01f,
  2.14575469e-01f, -2.34693080e-01f, -1.61909744e-01f, -9.03414488e-02f, 7.43599907e-02f, -1.12542018e-01f, -1.63321450e-01f, -1.26789585e-01f, 9.05594304e-02f, -1.24025270e-01f,
  -1.39541790e-01f, 2.27693096e-01f, 1.45839408e-01f, 1.40581295e-01f, -2.12946087e-01f, -1.71556085e-01f, -1.77816793e-01f, -1.27164900e-01f, 2.97579020e-01f, 1.02293929e-02f,
  2.30075195e-01f, -1.06944226e-01f, -2.03363925e-01f, -1.61812082e-01f, -1.25696063e-01f, -1.57060474e-02f, 3.34740281e-01f, -3.02420463e-02f, 1.87630221e-01f, 1.25074208e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.10287437e-01f, 2.00792804e-01f, 4.93458092e-01f, 1.07748970e-01f, 3.57149512e-01f, 1.62359715e-01f, 8.85441303e-02f, 2.95417935e-01f, -8.57745111e-02f, 1.10609613e-01f,
  -5.95801063e-02f, 2.53661126e-01f, 3.35372478e-01f, 9.76253003e-02f, -4.78353016e-02f, 2.87504524e-01f, 6.02865890e-02f, 1.11441404e-01f, 1.67608917e-01f, 3.94504406e-02f,
  2.56223649e-01f, 3.01125646e-01f, 2.31748044e-01f, 1.09528266e-01f, 1.82913959e-01f, 1.26812086e-01f, 5.19893318e-02f, -2.21615851e-01f, -9.71702933e-02f, 1.88656062e-01f,
  1.02389082e-01f, 3.49062905e-02f, 2.17608977e-02f, 3.32315713e-01f, -7.65299648e-02f, 3.16437542e-01f, -8.66924599e-02f, -1.12145647e-01f, -2.10673013e-03f, 5.37757613e-02f,
  6.38193190e-02f, 3.94103259e-01f, -2.86549270e-01f, 1.06030107e-01f, 9.82261151e-02f, -1.26285076e-01f, -4.01963174e-01f, 2.57211238e-01f, -7.08009209e-03f, -1.58686358e-02f,
  9.17608440e-01f, -2.95666099e-01f, -7.42313206e-01f, 3.76761436e-01f, -1.51444972e-01f, -6.07897900e-02f, 2.15447590e-01f, 6.39829695e-01f, 1.16392046e-01f, -1.76480785e-01f,
  -1.84206560e-01f, 2.18030661e-01f, -6.21452648e-03f, 4.03133601e-01f, 1.32649407e-01f, 1.01092666e-01f, 3.44706267e-01f, 5.16421124e-02f, 4.80900824e-01f, 3.47877622e-01f,
  2.80892938e-01f, -2.96048611e-01f, 1.54625073e-01f, 4.67545725e-02f, 3.37024122e-01f, 9.04161036e-02f, 3.52455974e-02f, 7.01271519e-02f, 5.27139865e-02f, 4.37521972e-02f,
  8.70602578e-02f, -4.95294109e-02f, 5.57560384e-01f, -1.97890088e-01f, 1.95101306e-01f, -1.21875927e-01f, 2.63315290e-01f, 1.94139212e-01f, 1.54033825e-01f, -3.87490809e-01f,
  -3.05159569e-01f, 1.34251177e-01f, -1.40573427e-01f, -2.29686275e-02f, -2.54565567e-01f, -1.26729444e-01f, -1.35919496e-01f, -1.15766294e-01f, -2.12525874e-02f, -1.17680281e-01f,
  -1.66904047e-01f, 1.90099925e-01f, -1.00253727e-02f, -3.40860367e-01f, 3.73755395e-01f, -2.91099936e-01f, 5.34723222e-01f, 2.98675001e-01f, -7.13425037e-03f, -1.20549947e-01f,
  3.57523710e-02f, -1.96001843e-01f, -1.45469278e-01f, 2.35597566e-01f, -7.78140426e-01f, 4.70877737e-02f, 7.54516840e-01f, 3.18119407e-01f, 2.37003610e-01f, 7.63260722e-01f,
  -5.09517670e-01f, -2.15362772e-01f, -1.49091780e-01f, 1.79173076e-04f, 8.19569230e-02f, -1.95501179e-01f, 7.08505958e-02f, 1.44479394e-01f, 3.86770666e-01f, -5.90904132e-02f,
  3.07292581e-01f, -2.30945870e-01f, -5.09819053e-02f, 1.72045887e-01f, 1.83914974e-01f, 1.24046817e-01f, 3.79557349e-02f, 6.17313199e-03f, 3.99152488e-02f, 1.01780646e-01f,
  3.12600911e-01f, 2.68899202e-02f, -8.26413929e-03f, 4.60508093e-02f, 2.40424760e-02f, 1.15591228e-01f, -6.81544915e-02f, -1.12882368e-01f, -8.76154602e-02f, 3.94427180e-02f,
  4.38617058e-02f, -3.68680023e-02f, 7.73357898e-02f, -2.02532753e-01f, 6.01895526e-02f, -1.41949236e-01f, 6.70284331e-02f, 1.69781428e-02f, 9.74179208e-02f, 8.45220685e-02f,
  3.08291763e-01f, -2.16881216e-01f, -1.87675223e-01f, 7.74064139e-02f, 1.83873400e-02f, -5.45093305e-02f, -2.47732416e-01f, 2.67909735e-01f, 2.08167568e-01f, -2.74543092e-02f,
  -3.55713576e-01f, 3.31829526e-02f, 1.66388884e-01f, -1.40828744e-01f, 2.20258296e-01f, -3.09256781e-02f, 8.72783884e-02f, -1.45521343e-01f, 1.56018108e-01f, 1.06527992e-02f,
  6.39616907e-01f, 1.41508669e-01f, 2.07521006e-01f, 4.55299079e-01f, 2.39678666e-01f, 3.96040976e-02f, -1.48378581e-01f, -3.27952683e-01f, -1.44053191e-01f, 6.91393971e-01f,
  1.80025538e-03f, -2.97554880e-01f, 9.70058814e-02f, 2.88768318e-02f, 3.00780445e-01f, -1.34748489e-01f, 2.15391755e-01f, 6.94823414e-02f, -1.38542190e-01f, -7.01359883e-02f,
  1.15109205e-01f, 2.50236988e-01f, 2.13609830e-01f, -9.91680920e-02f, -3.94890010e-02f, 8.14021826e-02f, 4.36234772e-01f, -2.56486936e-03f, 4.08913903e-02f, 1.50548741e-01f,
  3.88818711e-01f, 2.11876154e-01f, 2.64961183e-01f, 1.07502654e-01f, 1.43708602e-01f, 1.02559172e-01f, 9.82872173e-02f, -5.60476109e-02f, -1.01495959e-01f, -1.41588626e-02f,
  -9.15924087e-02f, -6.57141879e-02f, 1.75627887e-01f, 3.40714538e-03f, 6.64938688e-02f, -1.48258701e-01f, 1.13431387e-01f, -8.23511183e-02f, 4.60627645e-01f, -3.83193009e-02f,
  -7.39749297e-02f, -5.49203515e-01f, -2.75253892e-01f, -1.77922234e-01f, -3.87050360e-01f, -2.36287504e-01f, -3.28084797e-01f, 4.15217519e-01f, 3.06375548e-02f, -5.91956377e-01f,
  1.35947436e-01f, -1.96851224e-01f, 5.38487375e-01f, 3.88493389e-01f, 6.02200747e-01f, 1.99908569e-01f, 2.22215280e-01f, 8.41483623e-02f, -1.61948100e-01f, 5.82504738e-03f,
  -8.46888646e-02f, 7.97019124e-01f, -5.64766407e-01f, -1.50055960e-01f, 8.17302167e-02f, 1.17050812e-01f, 1.99017435e-01f, -3.42304411e-04f, -4.86886948e-01f, 1.44937739e-01f,
  3.33428755e-02f, -2.75860608e-01f, -7.05326945e-02f, 1.06307670e-01f, 3.12156409e-01f, 5.75537197e-02f, 3.18322666e-02f, -1.18433923e-01f, -2.41658650e-02f, 2.76992738e-01f,
  1.45789742e-01f, 9.81649235e-02f, 4.35274206e-02f, 2.62622327e-01f, -2.36688465e-01f, 4.35035378e-01f, -1.68835577e-02f, -1.55745763e-02f, 9.65577811e-02f, 3.21146965e-01f,
  1.18982345e-01f, 3.82371247e-01f, 3.94584797e-02f, 4.74190801e-01f, 1.99650615e-01f, 4.01821584e-02f, -7.36365020e-02f, -1.12785093e-01f, 1.56075120e-01f, 4.04994041e-02f,
  3.00188720e-01f, -3.63591373e-01f, -7.89147019e-02f, -1.38793707e-01f, 2.03725696e-01f, 1.49978131e-01f, -1.99022442e-01f, -6.01704828e-02f, 3.70500050e-02f, -3.05757046e-01f,
  -3.18618059e-01f, 4.44327533e-01f, 6.04461059e-02f, 4.48216081e-01f, 7.30278250e-03f, -4.75052178e-01f, 3.46624166e-01f, -2.87390411e-01f, 2.29215711e-01f, 2.51326203e-01f,
  6.59206748e-01f, -2.59880334e-01f, -3.84335548e-01f, 4.32818651e-01f, 2.88365297e-02f, 1.89486533e-01f, 4.41942543e-01f, -2.67735440e-02f, -2.30197608e-01f, 6.67876601e-01f,
  1.06506802e-01f, 2.08635300e-01f, -3.93264815e-02f, 4.12588060e-01f, 3.86384040e-01f, 1.84527770e-01f, -1.11931577e-01f, 1.86562926e-01f, 3.29473540e-02f, -4.10565250e-02f,
  2.43978009e-01f, 1.46014854e-01f, 1.51948005e-01f, 3.62117141e-01f, 3.95621240e-01f, 3.79475892e-01f, 1.25488257e-02f, 1.37724444e-01f, 1.83242053e-01f, 3.23356688e-01f,
  6.44966587e-02f, 1.13612957e-01f, 1.97385013e-01f, 2.82677084e-01f, 1.54282123e-01f, 4.12178278e-01f, -2.69581825e-01f, 2.85804898e-01f, 6.48480505e-02f, -7.87719637e-02f,
  -1.96198151e-01f, 9.25815552e-02f, -2.31270492e-01f, 2.55954534e-01f, 5.19370198e-01f, -4.06606764e-01f, -2.77410805e-01f, -8.84967297e-02f, -1.18104285e-02f, 9.19603333e-02f,
  -2.70293653e-02f, -2.59219378e-01f, 2.43064225e-01f, -3.57122421e-01f, -4.40420002e-01f, 5.69489002e-01f, -2.74693310e-01f, 5.48830569e-01f, -3.72585543e-02f, 6.09113164e-02f,
  4.03782070e-01f, -4.52715218e-01f, -2.89651006e-01f, 2.61536449e-01f, 2.06554309e-01f, 1.25608265e-01f, -5.28806627e-01f, 6.18244112e-01f, -2.23956063e-01f, -4.73804437e-02f,
  3.50931674e-01f, 1.58956841e-01f, -3.71843666e-01f, 1.38835777e-02f, 2.68290013e-01f, -1.33318484e-01f, 1.50764048e-01f, -1.78482383e-01f, -3.99695724e-01f, -2.15865932e-02f,
  2.74181534e-02f, -8.54679942e-02f, 1.36487573e-01f, -1.96103707e-01f, 1.62460446e-01f, 3.89087126e-02f, 5.54738529e-02f, -1.74508039e-02f, 1.14768790e-02f, 1.45756394e-01f,
  9.40828174e-02f, 9.42293108e-02f, -2.31730133e-01f, 4.40959036e-02f, -1.03733025e-01f, 1.93590969e-02f, 7.36436397e-02f, -1.22162133e-01f, 2.09587097e-01f, -1.40786305e-01f,
  3.42141569e-01f, -4.26927358e-02f, -2.25409493e-01f, 2.70378172e-01f, 2.68152446e-01f, -1.21823646e-01f, 4.38462086e-02f, 1.07927918e-01f, -5.36802113e-01f, -8.09545722e-03f,
  -1.22580327e-01f, -4.63697575e-02f, 1.24507658e-01f, 7.76141807e-02f, -1.96105599e-01f, 9.68587622e-02f, -7.52604678e-02f, 3.68056178e-01f, 2.67609566e-01f, -3.77390832e-01f,
  1.21008968e-02f, -2.61452615e-01f, -1.05775096e-01f, 2.31385782e-01f, 4.49408256e-02f, 8.88173223e-01f, 1.61548369e-02f, 5.01363337e-01f, -2.62764215e-01f, 1.34362772e-01f,
  -1.28778264e-01f, 3.50979745e-01f, 1.98851526e-01f, 5.08375227e-01f, -5.40019870e-01f, -3.30471814e-01f, 1.32463127e-01f, 3.42644513e-01f, 1.20656379e-01f, 3.01952153e-01f,
  6.64313361e-02f, -8.34228471e-03f, 2.99516857e-01f, 2.78857928e-02f, 2.07129531e-02f, -1.05506755e-01f, 2.29042038e-01f, 1.08375885e-01f, 1.43617779e-01f, 1.35920227e-01f,
  -4.00390700e-02f, 1.52994335e-01f, 4.41867173e-01f, -5.25003001e-02f, -8.26445222e-02f, -2.11753622e-02f, 5.18653095e-01f, 2.86735475e-01f, 2.65504211e-01f, -6.77839145e-02f,
  1.86030231e-02f, 2.18654960e-01f, -1.13971412e-01f, -1.37661383e-01f, -2.34793931e-01f, 4.20637310e-01f, -3.11108053e-01f, 5.15516847e-02f, 5.23792692e-02f, -9.31337774e-02f,
  3.47819589e-02f, 1.24681555e-02f, 4.93005067e-01f, -4.91726041e-01f, 5.24571985e-02f, -2.88800985e-01f, 3.44222903e-01f, -1.95724174e-01f, -2.70382017e-01f, -2.36008734e-01f,
  -9.63684693e-02f, -1.85932085e-01f, -2.05116212e-01f, 5.67901433e-01f, 1.93719435e-02f, 1.99979842e-01f, -4.47691754e-02f, -5.32950878e-01f, 3.24228942e-01f, -3.28611881e-01f,
  4.92031693e-01f, 2.30189547e-01f, 7.90498555e-01f, -1.95895463e-01f, -5.30431807e-01f, -2.12190256e-01f, -1.73278198e-01f, 1.16096392e-01f, 1.82110399e-01f, -1.57642752e-01f,
  -1.15035754e-02f, 7.79270455e-02f, 7.35772029e-02f, -1.18591316e-01f, -6.00610785e-02f, -1.67724460e-01f, -1.77165808e-03f, 1.69066675e-02f, 1.74503252e-01f, 1.08811073e-01f,
  -4.07957174e-02f, -1.79966196e-01f, 9.51413810e-02f, -8.84218663e-02f, 1.33349389e-01f, 5.97772785e-02f, 2.77386419e-03f, -7.95645341e-02f, -4.28678170e-02f, -3.11187692e-02f,
  -3.04638495e-04f, 6.34092391e-02f, -4.52880040e-02f, 8.04003850e-02f, 1.01403538e-02f, -2.54375283e-02f, 5.82474060e-02f, 3.26336890e-01f, -1.01223119e-01f, -2.09518090e-01f,
  5.61766863e-01f, -3.42921823e-01f, -2.05888376e-01f, 3.23425561e-01f, 9.50460956e-02f, -2.94203848e-01f, -2.11880192e-01f, 4.01923135e-02f, 1.55784085e-01f, -2.83683389e-01f,
  -3.29181552e-01f, -7.77263865e-02f, 2.98201263e-01f, 1.62293091e-02f, 1.40729323e-01f, -5.27027667e-01f, -1.52346104e-01f, 1.99063212e-01f, 3.44091207e-01f, -2.51800150e-01f,
  1.93291023e-01f, -1.06810004e-01f, 1.87784120e-01f, -2.79463768e-01f, 1.77796155e-01f, 1.68848375e-03f, 3.31552699e-02f, 5.10602832e-01f, 2.10156798e-01f, 3.29728186e-01f,
  -3.96190584e-01f, -4.11477029e-01f, 4.52828497e-01f, 2.34510124e-01f, -1.49720490e-01f, -7.02186525e-01f, 2.48662025e-01f, -2.54952479e-02f, 1.73309922e-01f, 1.59572318e-01f,
  2.52386153e-01f, 3.48598533e-03f, 1.98804408e-01f, 4.20167953e-01f, 1.87469609e-02f, 1.63567960e-01f, -6.44047037e-02f, 4.17201221e-01f, 4.17529970e-01f, 2.18543544e-01f,
  -2.75755614e-01f, 3.03461224e-01f, 2.12035522e-01f, 8.19621235e-02f, -2.15103999e-01f, 9.83861014e-02f, -6.74062222e-02f, 2.21857294e-01f, -1.75059035e-01f, 2.33919203e-01f,
  -1.33960500e-01f, -2.97828782e-02f, -1.28034398e-01f, -1.01055801e-01f, 2.03388482e-02f, 3.85086447e-01f, 2.74557378e-02f, 5.89915812e-02f, 2.24813540e-02f, -1.58631116e-01f,
  6.35815039e-02f, 7.73795843e-02f, -2.10663259e-01f, 3.66162330e-01f, 4.99072783e-02f, 5.19355476e-01f, 2.81293485e-02f, 3.64014626e-01f, 3.96432951e-02f, 1.83800030e-02f,
  8.31943285e-03f, -2.76188970e-01f, -1.29428044e-01f, 2.39103213e-01f, 1.82579104e-02f, -1.35460347e-01f, -2.08599329e-01f, 2.60305166e-01f, 5.07666707e-01f, -6.64391592e-02f,
  5.77050865e-01f, 6.57374561e-01f, 7.83532262e-02f, 2.41983503e-01f, -2.47439831e-01f, -2.64044374e-01f, 4.51689333e-01f, 2.43871763e-01f, -1.58296824e-01f, -2.44600713e-01f,
  2.16406435e-01f, 3.29520047e-01f, 5.26215509e-02f, 1.03789270e-02f, 3.23722631e-01f, 3.02378207e-01f, 2.72215337e-01f, -5.95795643e-03f, 3.45492512e-01f, 2.04429865e-01f,
  2.80347168e-01f, 1.76022604e-01f, -1.46742061e-01f, 2.70103723e-01f, 2.92867154e-01f, -1.68481484e-01f, 6.25507310e-02f, 1.51092093e-02f, 4.10179019e-01f, 3.41681898e-01f,
  2.80874789e-01f, 2.76316494e-01f, -6.94744810e-02f, 3.15672576e-01f, 3.61503720e-01f, 3.32130700e-01f, 7.25424588e-02f, -4.10684645e-01f, -5.30968547e-01f, -5.36088288e-01f,
  2.60879844e-01f, 8.42766240e-02f, 1.62537515e-01f, 7.99013674e-02f, 1.19215129e-02f, 3.27111781e-02f, 4.94875610e-01f, -3.30790222e-01f, 3.20979416e-01f, -6.95142865e-01f,
  -3.33884060e-01f, 2.33400300e-01f, -1.18421949e-01f, 9.73612964e-02f, -3.82713139e-01f, -1.11206966e-02f, -1.75103247e-01f, -4.34666216e-01f, 8.07313621e-02f, 6.75820094e-03f,
  -2.07442939e-01f, 1.47545844e-01f, -1.68337971e-02f, 2.08601713e-01f, -8.24597627e-02f, 2.39346355e-01f, -1.59707874e-01f, -2.32408255e-01f, 3.41905862e-01f, 3.59361470e-01f,
  -4.93634194e-01f, -7.11709633e-02f, -5.52597463e-01f, 3.64232391e-01f, 8.50428492e-02f, -5.26447855e-02f, 2.34280854e-01f, 2.27167606e-01f, 1.92320675e-01f, 2.94036806e-01f,
  6.84545934e-02f, 9.29065794e-02f, -2.20462784e-01f, -1.65736973e-01f, 5.62682301e-02f, 1.87422596e-02f, 1.95380077e-02f, 9.41726416e-02f, 4.08148579e-02f, 1.51287662e-02f,
  1.86550379e-01f, 1.71433464e-01f, 3.35811824e-01f, 8.69167969e-02f, -5.76828532e-02f, -1.24525800e-01f, 3.31041038e-01f, 6.54179379e-02f, 9.77162421e-02f, 1.95743695e-01f,
  3.47895138e-02f, -6.76058233e-02f, -2.21937463e-01f, -1.36079662e-03f, -1.90224871e-02f, 3.36368144e-01f, 1.81074753e-01f, 1.93349853e-01f, 5.09410836e-02f, -1.36423379e-01f,
  1.21063486e-01f, -1.03104105e-02f, 2.32845023e-01f, -4.22780842e-01f, -1.11749507e-01f, 2.30038255e-01f, 1.23030260e-01f, -4.44149151e-02f, -2.94052690e-01f, -1.36268174e-03f,
  -1.06929868e-01f, -3.27362746e-01f, 1.84017032e-01f, -2.45564446e-01f, -4.80558991e-01f, -9.13091674e-02f, 6.44296706e-01f, 3.59528840e-01f, 5.46062410e-01f, 6.77704930e-01f,
  -4.25093800e-01f, 1.50930122e-01f, 3.50407839e-01f, -1.31880537e-01f, -4.20041829e-01f, 1.80683106e-01f, -1.71447590e-01f, 3.39351118e-01f, 2.14342177e-01f, 1.52794108e-01f,
  1.77385256e-01f, -1.10890858e-01f, 3.59331399e-01f, 4.46907105e-03f, 1.20225511e-01f, 1.29020244e-01f, 1.96179152e-01f, 2.09297270e-01f, 2.19267011e-01f, 2.61536241e-01f,
  1.55333832e-01f, 1.50118440e-01f, 2.65730351e-01f, 2.13719130e-01f, 1.43468395e-01f, 1.73959937e-02f, 2.42613390e-01f, 1.63116470e-01f, 2.13497162e-01f, 1.35348037e-01f,
  -1.68606520e-01f, 2.19615117e-01f, 1.98172450e-01f, -7.19258189e-02f, -2.74774954e-02f, -1.90849170e-01f, 1.62664816e-01f, -3.30958992e-01f, 4.96247075e-02f, -3.93037349e-01f,
  8.93747620e-03f, -2.77564734e-01f, 1.67547226e-01f, 1.32458270e-01f, 1.36624634e-01f, -1.83671921e-01f, -2.31455430e-01f, 5.37816957e-02f, 2.04921573e-01f, -5.23114324e-01f,
  -2.30432227e-01f, -3.96521278e-02f, -1.48777723e-01f, 9.05164480e-02f, 1.54347360e-01f, 2.27541670e-01f, 8.73672143e-02f, -1.87236160e-01f, 7.16560900e-01f, -4.33585383e-02f,
  3.98400217e-01f, -4.97236550e-01f, 6.96953014e-02f, -3.14150274e-01f, 4.35697585e-01f, -2.57272303e-01f, -1.60886720e-01f, 2.14380890e-01f, 4.41108495e-01f, -3.59286308e-01f,
  3.39731090e-02f, -4.65168357e-01f, 1.13404989e-01f, 1.43138781e-01f, 1.33845896e-01f, 2.82524616e-01f, -2.52793074e-01f, -7.24014714e-02f, 2.43652537e-01f, -1.57363683e-01f,
  2.59709597e-01f, 2.92344391e-01f, 1.88145384e-01f, 7.56055117e-02f, -1.87409207e-01f, 1.93284795e-01f, 3.30988377e-01f, 6.00340366e-02f, 1.05485171e-01f, -3.66878510e-02f,
  4.35637161e-02f, 1.03980020e-01f, 3.30269516e-01f, 3.58680665e-01f, 2.91310161e-01f, 8.50435793e-02f, -1.47442371e-01f, -1.41311530e-02f, -2.71553218e-01f, 1.54847279e-01f,
  -2.46719681e-02f, 1.67048335e-01f, -4.99814421e-01f, 2.30137363e-01f, -5.06222844e-01f, 1.58513620e-01f, -2.95680583e-01f, 1.84274539e-02f, -1.92522332e-01f, 4.89112347e-01f,
  -3.66839417e-03f, 9.22442600e-02f, -8.38406160e-02f, 9.43906307e-02f, 6.15319073e-01f, 2.35486895e-01f, 9.84336361e-02f, -8.78879707e-03f, -2.19137929e-02f, -5.38004875e-01f,
  -1.99491009e-01f, 6.67996287e-01f, -3.23507220e-01f, 6.33418679e-01f, -2.21263453e-01f, 6.08838141e-01f, -4.28842992e-01f, 5.92776835e-01f, -2.34987974e-01f, 8.67324352e-01f,
  -3.39178026e-01f, 4.43409979e-01f, -5.68746701e-02f, 1.76319882e-01f, -4.96340841e-01f, 3.17470253e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  3.02140385e-01f, 1.53842077e-01f, 1.61519006e-01f, 8.60794932e-02f, 1.66315451e-01f, 2.75284111e-01f, 9.09745842e-02f, 1.94184259e-01f, 1.29349694e-01f, 4.52951401e-01f,
  2.92794466e-01f, 3.94227982e-01f, 2.36438319e-01f, 2.56564021e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  5.46353012e-02f, -1.48330048e-01f, 9.75924507e-02f, -1.23386405e-01f, -2.84795463e-01f, 4.35121179e-01f, -2.05763459e-01f, -2.61933804e-01f, -4.40734684e-01f, -2.17446755e-03f,
  -1.17433369e-01f, -6.68394612e-03f, -3.98005754e-01f, -2.12535352e-01f, -2.78804839e-01f, 1.27000049e-01f, -3.33718330e-01f, -5.57884276e-01f, -1.56781718e-01f, -9.63361338e-02f,
  -4.90384072e-01f, 2.07288773e-03f, -1.18328013e-01f, -1.09334238e-01f, 2.17554742e-03f, 2.26752833e-01f, 2.86578447e-01f, -7.82144368e-02f, -4.14178878e-01f, 1.87228844e-01f,
  3.23971778e-01f, -3.16694111e-01f, 2.55565405e-01f, -5.02267992e-03f, -2.79306352e-01f, -2.95317769e-01f, -1.62666380e-01f, -6.93207011e-02f, -6.34254795e-03f, -1.84306636e-01f,
  -1.82074517e-01f, 1.82463273e-01f, -2.32708320e-01f, -3.05592060e-01f, -1.21189885e-01f, -4.64877874e-01f, -1.60945013e-01f, 3.62343132e-01f, -4.22490388e-01f, -6.35037571e-02f,
  -1.43683434e-03f, -7.42283106e-01f, -6.76123023e-01f, 2.91694224e-01f, -3.66562419e-02f, -2.41755262e-01f, 3.91741067e-01f, -2.17951864e-01f, -6.33971840e-02f, -5.56294739e-01f,
  -7.16520548e-02f, -6.24082148e-01f, -1.47986069e-01f, 3.71438652e-01f, 3.93635929e-01f, -5.24932623e-01f, 1.30580172e-01f, 1.21613592e-01f, 5.59306383e-01f, 3.92582536e-01f,
  -2.36813203e-02f, -4.45943981e-01f, -1.86359167e-01f, 6.71852380e-02f, -5.05232692e-01f, 1.76865220e-01f, 4.95322347e-01f, -5.61220467e-01f, 2.84854442e-01f, 4.22668040e-01f,
  -2.97377288e-01f, 2.54144222e-01f, 4.68300998e-01f, 3.54148716e-01f, 5.49157821e-02f, -1.40687123e-01f, -1.15673751e-01f, 2.96748877e-01f, 1.77971646e-01f, 2.67877787e-01f,
  1.12916701e-01f, 5.97081184e-01f, 4.30546880e-01f, -2.06652313e-01f, 1.66412264e-01f, -1.26573697e-01f, 3.39899749e-01f, 1.28008306e-01f, -4.83039916e-01f, 2.79383659e-01f,
  2.70935953e-01f, 2.52595067e-01f, 4.23207641e-01f, -1.22598976e-01f, -4.17373240e-01f, 7.89598748e-02f, -3.33724499e-01f, 1.64021611e-01f, 3.26229304e-01f, -5.36014318e-01f,
  5.12600482e-01f, 4.92184192e-01f, -5.30153573e-01f, -1.61839604e-01f, 2.40815327e-01f, -6.72792971e-01f, 3.01212579e-01f, -4.13430303e-01f, -7.11181760e-01f, -4.64655638e-01f,
  8.28116462e-02f, -6.30815804e-01f, 4.80012059e-01f, 4.18105483e-01f, -4.04454023e-01f, -7.27553368e-01f, 1.13254540e-01f, -6.47731543e-01f, 5.31022549e-02f, 5.51084522e-03f,
  -2.32080162e-01f, 2.91044693e-02f, 3.05042900e-02f, -3.74507457e-01f, -5.72301447e-01f, -3.08438271e-01f, 1.09689802e-01f, -2.56135851e-01f, -1.49720758e-01f, 2.70383388e-01f,
  -1.01041451e-01f, -3.41573387e-01f, 2.57095277e-01f, 2.00020447e-01f, -4.91146557e-02f, -2.82473981e-01f, -1.14588119e-01f, -2.92754382e-01f, -1.64620727e-01f, 5.18299118e-02f,
  -6.77884594e-02f, 2.34763861e-01f, 1.28655657e-01f, 3.60481590e-01f, -1.50170133e-01f, -4.30533707e-01f, 4.39087927e-01f, -2.94897467e-01f, 6.02582753e-01f, 2.54933089e-01f,
  3.83016258e-01f, -8.32955182e-01f, -2.57192791e-01f, 3.94942254e-01f, 1.51113942e-01f, 1.60757884e-01f, -1.77168667e-01f, 2.95684516e-01f, 3.97705644e-01f, -5.04156426e-02f,
  4.71230477e-01f, 1.96980119e-01f, 3.19738150e-01f, -3.53639461e-02f, 3.16803724e-01f, 1.59589663e-01f, 5.04821479e-01f, -1.57810673e-01f, 9.84596387e-02f, 7.80309081e-01f,
  -3.07851017e-01f, -4.97425109e-01f, -6.94972515e-01f, 2.30244860e-01f, -2.15084955e-01f, -2.99187172e-02f, -6.99550629e-01f, 2.61849537e-02f, -5.57787716e-01f, -3.89071941e-01f,
  2.36405469e-02f, 6.59467638e-01f, 4.52852696e-02f, 3.09907317e-01f, 3.50557677e-02f, 1.97299629e-01f, 5.00575304e-01f, -5.04827350e-02f, 2.32809082e-01f, 2.66357958e-01f,
  1.33666039e-01f, 8.40505585e-02f, -3.49109322e-02f, -9.09321457e-02f, 3.02332461e-01f, 3.19401234e-01f, 4.18043315e-01f, -3.63905340e-01f, -3.42339844e-01f, 2.09783629e-01f,
  -6.45717561e-01f, 4.30141948e-02f, 5.09334087e-01f, -5.19215047e-01f, -5.61043136e-02f, -2.99450934e-01f, -5.97369932e-02f, -5.87756753e-01f, 4.70892191e-02f, 2.31657997e-01f,
  -2.23025665e-01f, 4.12274778e-01f, 7.74777710e-01f, 6.19160652e-01f, -4.48066704e-02f, -8.27403367e-02f, -3.14306676e-01f, -6.15172803e-01f, 3.79189909e-01f, 1.49145067e-01f,
  -1.31684110e-01f, 3.77710253e-01f, 2.82471418e-01f, 2.75161058e-01f, 6.20663539e-02f, -5.23300827e-01f, 4.08459008e-01f, 1.27295643e-01f, -3.20744246e-01f, -8.50991726e-01f,
  2.08377056e-02f, -4.20091957e-01f, -5.12511492e-01f, 2.11086303e-01f, -1.32766992e-01f, 2.82344427e-02f, -7.64925003e-01f, -7.49291301e-01f, 8.20127726e-02f, -2.88627505e-01f,
  -6.37369394e-01f, 2.78990388e-01f, 3.44380051e-01f, -2.55784355e-02f, -4.75054383e-01f, 2.26415843e-01f, -1.35407940e-01f, 1.68387637e-01f, 2.70213097e-01f, -4.34857577e-01f,
  -6.96143150e-01f, 1.12591162e-01f, -1.81561276e-01f, 5.09413898e-01f, 3.54176342e-01f, -8.58569592e-02f, 7.35743344e-01f, -2.26101562e-01f, -2.64656961e-01f, 2.28181139e-01f,
  9.25400555e-02f, 2.99240965e-02f, -1.12930462e-01f, 3.74626279e-01f, 5.99048555e-01f, -6.93715960e-02f, -1.01525269e-01f, 3.21694285e-01f, 1.36803538e-01f, 1.04366682e-01f,
  1.61870301e-01f, 4.94951755e-01f, -5.77198684e-01f, -1.04671076e-01f, 2.30007336e-01f, -1.68650568e-01f, -3.36038023e-01f, -3.11133385e-01f, 1.69376686e-01f, -1.53773665e-01f,
  2.42088169e-01f, 3.30637038e-01f, 1.45249337e-01f, 2.84882218e-01f, -4.38710302e-01f, -4.28846627e-01f, 5.28469920e-01f, -5.32165885e-01f, -1.73802763e-01f, -1.61419258e-01f,
  -4.57249373e-01f, -3.84119041e-02f, -1.55047283e-01f, -3.16098541e-01f, 6.09598994e-01f, 5.56784391e-01f, -1.94103301e-01f, 4.27547544e-01f, 8.63576382e-02f, 7.38556236e-02f,
  1.03529694e-03f, -3.86850804e-01f, 1.22901194e-01f, 2.81950980e-01f, -1.67979881e-01f, -3.98804456e-01f, -2.23981328e-02f, 1.95520461e-01f, -3.94391865e-01f, 1.05120596e-02f,
  5.69698624e-02f, 4.17455733e-02f, 2.79533118e-01f, 9.58035216e-02f, 2.60688245e-01f, -2.62684345e-01f, -6.34483481e-03f, 2.78945833e-01f, 4.47140545e-01f, -1.13975555e-01f,
  -3.12520564e-02f, 5.86707518e-02f, 3.02288920e-01f, -1.63711175e-01f, -1.16972081e-01f, -3.59303415e-01f, 2.66366810e-01f, 8.63599330e-02f, -1.80393904e-01f, -1.63122252e-01f,
  2.72424728e-01f, 3.90553102e-02f, -1.21990554e-01f, 2.86623091e-01f, 3.10337424e-01f, 2.54581213e-01f, 3.08482647e-01f, -5.48934639e-01f, -3.19306552e-01f, -4.85816412e-02f,
  -3.18812668e-01f, -1.09496908e-02f, 1.61161244e-01f, 3.11039519e-02f, 2.22561032e-01f, -5.99083230e-02f, -9.84040201e-02f, -1.24706373e-01f, -5.08931398e-01f, -1.12089239e-01f,
  -2.44841203e-01f, 2.40891710e-01f, -3.07386756e-01f, 8.02008435e-02f, 2.74599940e-01f, -2.00092226e-01f, 2.69778460e-01f, 3.31158459e-01f, -4.61782068e-01f, 3.75850871e-02f,
  1.65816858e-01f, -6.61687970e-01f, -2.81788141e-01f, 3.35474759e-01f, 3.87960896e-02f, 3.84466052e-01f, -3.44801962e-01f, 6.91638350e-01f, -2.98896223e-01f, -4.98111188e-01f,
  2.02875808e-01f, -4.92661536e-01f, 2.92041242e-01f, -7.27908432e-01f, 2.88253315e-02f, 3.05668116e-02f, -3.13380033e-01f, 6.46902323e-02f, 2.10624993e-01f, 1.32999197e-01f,
  3.66607875e-01f, 1.03418613e-02f, -1.47433370e-01f, -5.40862530e-02f, 1.09124430e-01f, 1.82022884e-01f, 1.52600169e-01f, 1.25148043e-01f, -3.27390991e-02f, -3.14568244e-02f,
  9.34456363e-02f, -2.97780484e-01f, -2.52229035e-01f, -1.66401163e-01f, 3.42686236e-01f, -8.21871608e-02f, 2.10051145e-02f, -2.28144247e-02f, -4.13814545e-01f, -1.02803633e-01f,
  -6.39638484e-01f, -1.83600485e-01f, 5.38612127e-01f, 4.41590488e-01f, 2.30033509e-02f, -4.83701557e-01f, -3.86805862e-01f, 3.05045873e-01f, -1.21586248e-01f, 7.93689787e-02f,
  -6.58453941e-01f, 5.06673813e-01f, 7.74267092e-02f, 1.87745631e-01f, -2.78818280e-01f, -2.91592609e-02f, 2.99732834e-02f, 1.47223696e-01f, 3.27130467e-01f, -1.97725967e-01f,
  3.79130870e-01f, 3.29718292e-01f, 1.02624141e-01f, 3.96050096e-01f, -5.23271799e-01f, -2.01012060e-01f, -1.06330670e-01f, -8.95824194e-01f, 4.99710411e-01f, 3.23322237e-01f,
  -6.65088519e-02f, 1.75992131e-01f, 2.52787143e-01f, 8.40416849e-02f, -3.74951929e-01f, -5.09178758e-01f, 4.57509160e-01f, -5.34441292e-01f, -3.35110545e-01f, 1.33735433e-01f,
  -1.68265760e-01f, -7.47907162e-02f, -2.13182613e-01f, -2.84127221e-02f, 9.44516659e-02f, -3.28480810e-01f, -3.86771023e-01f, 5.15660532e-02f, -3.74440663e-02f, -1.57019526e-01f,
  -4.71575893e-02f, -2.81923741e-01f, -1.63159445e-01f, -2.67543465e-01f, -2.05371544e-01f, 3.84222478e-01f, -1.19881094e-01f, -6.72065839e-02f, -9.55436286e-03f, -1.46774113e-01f,
  1.78569123e-01f, -6.71041369e-01f, 1.37973294e-01f, -1.74321517e-01f, -4.26291704e-01f, -3.20792608e-02f, 3.18365157e-01f, 4.65350412e-02f, -2.73172230e-01f, -4.27405149e-01f,
  -2.27722988e-01f, 2.79937655e-01f, 3.47340673e-01f, -4.13691849e-01f, 7.86491018e-03f, -1.84847012e-01f, 2.09920913e-01f, -5.92413452e-03f, 5.18049538e-01f, 2.18854561e-01f,
  1.19514979e-01f, -5.76071143e-01f, -5.68731904e-01f, 6.96261585e-01f, -2.99139619e-01f, -4.00079191e-01f, 1.21428169e-01f, -2.63448536e-01f, 1.30747244e-01f, 5.94671331e-02f,
  2.24024639e-01f, -2.85022795e-01f, -4.24480110e-01f, 3.45824033e-01f, -4.69306529e-01f, -7.60191917e-01f, -9.44269542e-03f, 1.34148421e-02f, -4.75924343e-01f, 3.82619649e-01f,
  -7.92621136e-01f, 3.48397106e-01f, -2.81655073e-01f, 3.19027930e-01f, 1.92711223e-02f, -2.47169752e-02f, -2.57870197e-01f, 2.29466230e-01f, -1.15234859e-01f, 1.18471168e-01f,
  6.34898916e-02f, 6.98878542e-02f, 3.00995916e-01f, -4.52351242e-01f, -6.27106845e-01f, 5.43065250e-01f, -4.56826240e-01f, -3.65980715e-01f, 5.32952011e-01f, 4.87410165e-02f,
  -4.86171022e-02f, -1.58403426e-01f, 1.58786803e-01f, 1.08263202e-01f, 2.94189483e-01f, -3.38226497e-01f, -1.85995817e-01f, -1.92966819e-01f, 6.53592721e-02f, 3.30001801e-01f,
  9.64863300e-02f, 1.05796409e+00f, 3.17700565e-01f, 5.99367797e-01f, -7.80699015e-01f, -4.78971928e-01f, 5.58129966e-01f, 5.55832088e-01f, -4.03703809e-01f, -7.07147896e-01f,
  2.83880770e-01f, -3.15475672e-01f, -1.70659006e-01f, 5.39470352e-02f, -2.58734584e-01f, 3.03931504e-01f, -4.46064174e-01f, -1.52574062e-01f, -7.40467846e-01f, -5.36395550e-01f,
  3.69883925e-01f, -2.14805320e-01f, 7.83101842e-02f, -4.50372994e-01f, 2.24965245e-01f, -5.21936733e-03f, -6.41939104e-01f, -2.90416330e-01f, -4.77270424e-01f, -9.31954145e-01f,
  4.44346577e-01f, -3.28686088e-01f, 6.62219077e-02f, -3.06226462e-01f, 2.69322991e-01f, -1.90058872e-01f, 2.08766505e-01f, -2.41434738e-01f, -3.67567316e-02f, -2.74522036e-01f,
  -8.95234793e-02f, -2.54607141e-01f, 2.45430663e-01f, 9.08269212e-02f, -1.30751431e-01f, -1.84971049e-01f, 1.39980525e-01f, 6.63890615e-02f, 1.78239360e-01f, 7.57861957e-02f,
  2.51563221e-01f, 3.75471234e-01f, 3.89946938e-01f, -5.99306703e-01f, 2.64113992e-01f, 4.85191762e-01f, -5.56735694e-01f, -2.88785785e-01f, 4.14341301e-01f, -4.19091910e-01f,
  -8.10931697e-02f, -1.43388053e-04f, 2.79730648e-01f, -1.67912021e-02f, -7.23100781e-01f, -2.09992945e-01f, -2.76935756e-01f, 2.98996419e-01f, -1.82677045e-01f, 4.87195015e-01f,
  3.80097121e-01f, 3.11964989e-01f, 4.92273092e-01f, 2.71140009e-01f, 3.06656770e-02f, 3.35078835e-01f, 4.88089055e-01f, 1.81693181e-01f, 1.22577481e-01f, 2.12223828e-01f,
  -4.52688932e-01f, -1.51392221e-01f, 2.48344526e-01f, -1.91013083e-01f, 5.67649662e-01f, 3.77551854e-01f, -2.68872604e-02f, -4.40947443e-01f, -2.44849384e-01f, -6.09273314e-01f,
  4.59506184e-01f, 3.53150129e-01f, -3.14218909e-01f, 2.37059340e-01f, -3.42416763e-01f, 2.73078471e-01f, -7.47971773e-01f, 1.81687742e-01f, -7.18853414e-01f, 2.40108728e-01f,
  -2.82762855e-01f, 1.44473925e-01f, 1.74979553e-01f, 1.70460790e-02f, -2.06742555e-01f, 2.95434315e-02f, -4.67259258e-01f, 3.01977456e-01f, -8.26419294e-02f, 1.93384007e-01f,
  -2.10795149e-01f, 1.58458546e-01f, -1.09176867e-01f, 5.08701444e-01f, 1.15499355e-01f, 3.69499564e-01f, -4.60511446e-02f, 7.05250651e-02f, 3.78570855e-01f, 4.55732569e-02f,
  -2.85315394e-01f, 1.31528825e-01f, -1.80142745e-01f, 3.36178184e-01f, -4.10940737e-01f, -5.53923130e-01f, -8.49637389e-02f, 2.48274326e-01f, -4.49536666e-02f, -4.56610620e-01f,
  -4.87098068e-01f, 4.65168297e-01f, -1.00417539e-01f, -5.07093966e-01f, 4.22779083e-01f, -6.34177685e-01f, -1.33586824e-01f, -6.82342649e-01f, 1.09188609e-01f, -9.19401348e-02f,
  -1.99643329e-01f, -5.27056098e-01f, 3.98556739e-01f, -4.72415417e-01f, 1.81834444e-01f, 4.75712180e-01f, 2.99254864e-01f, -5.92946589e-01f, -4.60194737e-01f, -3.22282583e-01f,
  2.28907064e-01f, -5.32179356e-01f, -8.86469662e-01f, -3.44783813e-01f, -4.80230302e-02f, -1.72722459e-01f, -3.69098186e-01f, -6.94552779e-01f, -4.22398359e-01f, -4.43124354e-01f,
  6.86843872e-01f, 8.37466240e-01f, -5.58113277e-01f, -8.01715076e-01f, -4.50333767e-02f, 9.81433317e-03f, -1.32065102e-01f, 1.85451925e-01f, -2.15680301e-01f, 1.45542532e-01f,
  -1.77720599e-02f, -1.05899028e-01f, -2.65142828e-01f, 2.13516638e-01f, -4.52913791e-01f, -3.49936068e-01f, 4.39552590e-02f, -1.08766109e-01f, 4.43524905e-02f, -4.81636226e-02f,
  -7.49525204e-02f, 2.63478309e-01f, -2.41377279e-01f, 2.04942673e-01f, -1.55119628e-01f, 1.36548847e-01f, -2.35256314e-01f, 4.52268153e-01f, 1.23005360e-02f, -2.84282833e-01f,
  3.03481311e-01f, 3.87278557e-01f, -4.87842023e-01f, -2.78339416e-01f, -3.52431089e-01f, -2.41803482e-01f, -4.72347975e-01f, 1.82046443e-01f, 6.84640855e-02f, 2.64827788e-01f,
  -3.02012384e-01f, -1.95291594e-01f, 6.02919936e-01f, 5.26325703e-01f, -8.67301077e-02f, 6.66380534e-03f, -4.29106206e-01f, 1.24956354e-01f, 2.62081265e-01f, 6.19360089e-01f,
  -7.67832339e-01f, 5.12415349e-01f, -9.19829234e-02f, 3.38479042e-01f, -8.52849305e-01f, 5.25267422e-01f, 2.75094777e-01f, 3.06662083e-01f, -2.69641906e-01f, -3.95445228e-01f,
  -4.66648012e-01f, 2.19036400e-01f, -7.43355155e-02f, 1.93744555e-01f, -6.10383272e-01f, 4.29083377e-01f, 4.65718145e-03f, -7.83386171e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  5.40095475e-03f, 5.07749654e-02f, 2.70789206e-01f, -6.83472082e-02f, 8.26733245e-04f, -1.01593539e-01f, -2.47824565e-02f, -1.85050461e-02f, -1.00637048e-01f, -1.22674659e-01f,
  -1.35379225e-01f, -2.38659143e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    