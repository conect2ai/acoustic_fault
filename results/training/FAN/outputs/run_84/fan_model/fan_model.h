/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.68440932e-01f, -6.18036324e-03f, 1.56095056e-02f, -1.81926474e-01f, 9.02212784e-02f, 1.12598948e-01f, 4.87656258e-02f, 1.01602778e-01f, 4.55986783e-02f, 5.39510511e-02f,
  4.06059995e-02f, 7.14902952e-02f, 5.70214875e-02f, -3.64679061e-02f, -1.83885008e-01f, -1.27067879e-01f, 8.16325396e-02f, 9.38455295e-03f, -2.31004097e-02f, 1.29642680e-01f,
  -1.56466380e-01f, -4.62399460e-02f, -1.29858688e-01f, 2.53108963e-02f, -2.86759669e-03f, -6.90288190e-03f, -8.21138695e-02f, -1.67946383e-01f, -6.16121516e-02f, -4.90009859e-02f,
  1.59315228e-01f, 1.71280373e-02f, 8.06994364e-02f, -4.80612777e-02f, 1.02352731e-01f, 7.26633668e-02f, -7.64285326e-02f, -7.41882622e-02f, -9.65227606e-04f, 7.34783784e-02f,
  1.30386511e-02f, -8.95594619e-03f, 8.36385787e-02f, 1.74199883e-02f, -3.22182924e-02f, -6.77703321e-02f, 2.88379025e-02f, 6.09685145e-02f, 4.11945246e-02f, 1.92865711e-02f,
  5.34736644e-03f, 5.25149591e-02f, 3.50124352e-02f, 1.73033401e-02f, -3.56825516e-02f, 6.00471757e-02f, -5.74917160e-02f, 4.31753136e-02f, -1.89946741e-02f, 6.20496944e-02f,
  5.87691069e-02f, -3.32046449e-02f, -6.06185943e-02f, 8.38402137e-02f, -3.09069976e-02f, 3.96683440e-02f, -6.26772121e-02f, -1.92276891e-02f, -4.56127971e-02f, 2.45788880e-02f,
  6.09841645e-02f, -2.94344574e-02f, 6.92610592e-02f, -3.81237529e-02f, -2.24952009e-02f, 6.00054488e-02f, -4.09696400e-02f, 8.46959054e-02f, 2.46565156e-02f, 5.02736270e-02f,
  -3.38623263e-02f, -2.94441134e-02f, 2.50927471e-02f, -4.91993036e-03f, 1.64452642e-02f, -9.20835733e-02f, -1.78922396e-02f, 2.00883648e-03f, -1.45819988e-02f, -1.16241327e-03f,
  6.14580475e-02f, -4.52831760e-02f, -1.56249404e-02f, 2.67539583e-02f, -2.72483341e-02f, -6.67141601e-02f, -3.82707417e-02f, 6.05423413e-02f, -1.46848351e-01f, 1.16509646e-02f,
  -7.55275041e-03f, 4.92983945e-02f, 4.33806702e-02f, 5.18549141e-03f, 2.04768088e-02f, 1.32986838e-02f, -3.97949107e-02f, 2.50003990e-02f, -4.75755194e-03f, 2.00823098e-02f,
  -7.89236277e-03f, -6.56071454e-02f, -2.12461371e-02f, 4.70392918e-03f, -2.99910586e-02f, 5.12073785e-02f, 5.82527742e-02f, -3.78150977e-02f, -9.90685727e-03f, 1.59112401e-02f,
  2.68002570e-01f, -1.24304555e-02f, -2.02009943e-03f, 7.03240409e-02f, -1.53969437e-01f, 1.11341015e-01f, 4.55641933e-02f, 9.72701330e-03f, 4.05530743e-02f, 2.17058975e-02f,
  4.30097766e-02f, -2.52122432e-02f, 8.38251114e-02f, -1.35651333e-02f, 1.63477838e-01f, 1.02120005e-01f, 1.24859773e-01f, 4.68533821e-02f, 1.37423221e-02f, -4.05406691e-02f,
  -2.88698226e-02f, 8.35288018e-02f, 2.48863176e-02f, -7.07836375e-02f, -6.68995753e-02f, -6.74348772e-02f, -5.31966705e-03f, -9.98801738e-03f, -7.38027245e-02f, -3.81378718e-02f,
  -4.47086431e-02f, 4.69974875e-02f, -3.22577693e-02f, -9.55444053e-02f, -3.97824161e-02f, -2.24478077e-03f, -8.26412812e-02f, 2.16083545e-02f, 1.82185078e-03f, -3.96157382e-03f,
  -2.80155931e-02f, -4.79195938e-02f, 4.33106795e-02f, -4.49085161e-02f, -5.76145723e-02f, -5.17808646e-02f, -6.95123449e-02f, -4.59648622e-03f, -6.67952606e-03f, -3.90901342e-02f,
  -1.84946116e-02f, -8.24369639e-02f, 3.85711044e-02f, 5.08773066e-02f, 1.81835201e-02f, -1.20591540e-02f, 1.41952988e-02f, -5.65100112e-04f, -1.74076296e-02f, 4.05977592e-02f,
  3.35009396e-02f, 3.96640077e-02f, 4.22534607e-02f, -1.15217976e-02f, 8.44538808e-02f, -3.23080905e-02f, -3.95224132e-02f, 3.70039903e-02f, 7.09047318e-02f, 3.10358908e-02f,
  1.65972044e-03f, 2.97402777e-02f, -3.01154386e-02f, 2.58957129e-03f, 3.89811373e-03f, 4.93784286e-02f, 5.20154387e-02f, -4.98497747e-02f, 5.89788565e-03f, 3.73951904e-03f,
  -9.35320463e-03f, -1.51663302e-02f, -1.38719268e-02f, 9.44942934e-04f, -6.61156625e-02f, -4.87917885e-02f, -1.09361866e-02f, -3.32419798e-02f, 3.35665159e-02f, 2.83077899e-02f,
  -2.03405805e-02f, 8.65974650e-02f, 2.16569472e-02f, 2.53688619e-02f, 1.03497572e-01f, -2.79503353e-02f, 9.29537117e-02f, -4.44218889e-03f, -2.01554168e-02f, 4.89219539e-02f,
  -3.12038511e-02f, 2.97056679e-02f, -6.98143393e-02f, 2.47403905e-02f, -2.92524174e-02f, 3.27808969e-02f, -1.44065367e-02f, 1.74947530e-02f, 4.03316878e-02f, 4.27697301e-02f,
  5.37934341e-03f, 2.36676857e-02f, 5.28213605e-02f, 2.54382808e-02f, 3.99612933e-02f, 6.79419488e-02f, 4.43858318e-02f, -5.57615422e-02f, -8.05925280e-02f, -6.29023239e-02f,
  -3.24156225e-01f, -1.03450656e-01f, 1.14376862e-02f, -6.94857389e-02f, -9.46619660e-02f, -1.12287335e-01f, -1.77005857e-01f, -3.19635943e-02f, -2.18656242e-01f, 4.64930646e-02f,
  -6.66626357e-03f, -5.28265350e-02f, -7.40146860e-02f, -2.60697119e-02f, -1.41884968e-01f, -4.55340594e-02f, -8.11582580e-02f, 4.70296666e-02f, -8.13975260e-02f, -3.35201211e-02f,
  -5.27470894e-02f, -5.35911471e-02f, 4.31165211e-02f, 2.02791825e-01f, 1.04483450e-02f, 6.28427714e-02f, 1.50348201e-01f, 1.48650274e-01f, 1.36523724e-01f, 2.53582075e-02f,
  -1.83767900e-01f, -1.05600417e-01f, 1.91585384e-02f, -1.13248071e-02f, -9.56811756e-02f, 6.84449226e-02f, 5.12591042e-02f, 8.10597166e-02f, -3.39552425e-02f, -4.83627468e-02f,
  -2.02193763e-02f, -9.69786942e-02f, 4.26268168e-02f, -5.23620006e-03f, -4.07177024e-02f, -8.46503824e-02f, -1.86564010e-02f, -3.58130634e-02f, -4.15057838e-02f, -2.33365949e-02f,
  -6.69263229e-02f, 2.39579994e-02f, -1.82346121e-04f, 4.49693054e-02f, 2.46213153e-02f, -9.43644047e-02f, 5.73723875e-02f, 5.36895767e-02f, -4.13608737e-03f, -1.94320623e-02f,
  1.52425151e-02f, 8.06700513e-02f, 3.88125703e-02f, 2.53147185e-02f, 1.02617759e-02f, 4.10961099e-02f, 1.85546745e-02f, 2.77177654e-02f, 1.22725345e-01f, -6.68760389e-02f,
  5.11336960e-02f, 1.79909635e-02f, 4.73205149e-02f, -1.94743723e-02f, 5.21570183e-02f, -6.69178879e-03f, 3.42824347e-02f, 1.89772211e-02f, 2.62395293e-02f, 1.67360306e-02f,
  -4.02923003e-02f, -6.91211447e-02f, 2.08293870e-02f, 2.12910250e-02f, -5.47996573e-02f, 7.29539013e-03f, 2.76829489e-03f, -2.71748770e-02f, -3.13744359e-02f, 7.77095854e-02f,
  -1.43690154e-01f, 5.98034039e-02f, -1.73238683e-02f, 2.43760385e-02f, 5.49311340e-02f, 3.03515363e-02f, 3.91484573e-02f, -1.18853780e-03f, 9.54856351e-03f, 2.34624296e-02f,
  5.33372350e-02f, 1.11217298e-01f, 7.34973466e-03f, 4.33577597e-03f, 1.74620468e-02f, -3.53908981e-03f, 3.15286815e-02f, 1.58115905e-02f, 5.01197018e-03f, 5.72995916e-02f,
  1.02839470e-02f, 3.02398540e-02f, 8.77743140e-02f, -1.29393535e-02f, 4.38447371e-02f, 6.71965107e-02f, -4.25409079e-02f, -3.80079821e-03f, 8.00330043e-02f, -1.52612207e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.90771386e-01f, -3.10310751e-01f, -9.38891619e-02f, 2.01850012e-01f, 2.14513391e-01f, -1.95403788e-02f, 4.67936099e-02f, 1.50480226e-01f, 1.75848361e-02f, -1.25049636e-01f,
  -3.09894010e-02f, -1.71639502e-01f, -1.22517675e-01f, -4.95743901e-02f, 1.83871999e-01f, -1.36816949e-01f, -2.49815937e-02f, -8.15726910e-03f, -3.22238244e-02f, -4.14642580e-02f,
  9.91391167e-02f, 1.97850004e-01f, 5.71529344e-02f, 2.77317744e-02f, 1.08674271e-02f, 1.08628802e-01f, 2.08693780e-02f, -1.95036344e-02f, 1.06628172e-01f, 5.35613894e-02f,
  8.37818459e-02f, -6.41805530e-02f, -1.86881740e-02f, 4.01514955e-02f, -6.34498000e-02f, -2.12922283e-02f, 2.33068294e-03f, 3.05766668e-02f, 7.54527152e-02f, -4.02524769e-02f,
  -2.96147112e-02f, 3.69727947e-02f, 6.74001426e-02f, 4.02691662e-02f, 8.01286399e-02f, 4.95131724e-02f, -2.16219779e-02f, -5.54635609e-03f, -6.12554997e-02f, -6.89777210e-02f,
  1.03306286e-02f, -2.14305315e-02f, -7.98194297e-03f, -3.03382776e-03f, -5.21171354e-02f, 3.64579111e-02f, 6.13923259e-02f, -1.04900308e-01f, 1.21724280e-02f, 8.16325843e-02f,
  2.25360747e-02f, -7.50717707e-03f, 2.28105653e-02f, 9.31174755e-02f, -2.88765412e-02f, 4.62505631e-02f, 2.49737017e-02f, -1.01887397e-01f, -2.39895191e-02f, -1.25419125e-01f,
  -6.19030558e-02f, 1.28948137e-01f, -2.35339254e-02f, -2.80710533e-02f, 1.09008320e-01f, -7.16262981e-02f, -3.05185728e-02f, -5.76118305e-02f, 1.73330598e-03f, -1.78675503e-02f,
  -5.52946441e-02f, -6.93942886e-03f, -2.62022801e-02f, -1.13712691e-01f, -7.00250790e-02f, 5.68884648e-02f, 5.34415059e-02f, 4.05659992e-03f, -3.35090072e-03f, 4.59393337e-02f,
  -3.49956118e-02f, -2.34490082e-01f, -2.28614490e-02f, 3.75616476e-02f, -9.51071978e-02f, -5.40455477e-03f, -3.80767882e-02f, 1.84849687e-02f, -2.37160770e-04f, -5.22675738e-02f,
  -6.34643883e-02f, 1.16097197e-01f, 3.15084904e-02f, 9.34857056e-02f, 6.75695315e-02f, -1.70549266e-02f, 3.39951888e-02f, -2.46979645e-03f, 1.23304538e-02f, -4.26657312e-02f,
  -8.81716982e-03f, -3.48401256e-02f, -1.35382963e-02f, 2.51593199e-02f, 8.36410299e-02f, -3.97724807e-02f, 3.28503288e-02f, 7.26379454e-02f, -7.62346089e-02f, -1.44291529e-02f,
  6.31807297e-02f, 1.14098266e-01f, 1.25741541e-01f, 3.14097762e-01f, -5.45483939e-02f, -3.41503114e-01f, -2.05099329e-01f, -1.64556578e-02f, -6.44525141e-02f, -1.98997095e-01f,
  -7.81241879e-02f, 1.12507246e-01f, -8.29739273e-02f, 5.76128513e-02f, 1.83868825e-01f, -1.09926588e-03f, 2.97987852e-02f, -5.26565500e-02f, 5.24996482e-02f, 3.60708833e-02f,
  6.12141863e-02f, -4.76116408e-03f, 2.12120160e-01f, 1.17431702e-02f, -1.00819096e-02f, 1.69863090e-01f, 2.90760547e-01f, -5.79476617e-02f, 5.61972074e-02f, 3.64428088e-02f,
  -7.53093809e-02f, 8.93574730e-02f, 3.64713296e-02f, -7.07950629e-03f, 6.18960261e-02f, -1.75913885e-01f, -6.09039329e-02f, 1.75357964e-02f, 5.01467064e-02f, 2.84801554e-02f,
  -1.89278717e-03f, 5.87012433e-02f, 6.67964295e-02f, 3.36037092e-02f, -1.01100139e-01f, 4.30786051e-02f, 5.34723401e-02f, -3.21978033e-02f, 6.29164577e-02f, -1.43610938e-02f,
  -4.85509709e-02f, -6.92337826e-02f, -2.27875616e-02f, 9.46521163e-02f, 5.54677211e-02f, -6.81622624e-02f, -7.13555291e-02f, 6.25694394e-02f, 3.78653556e-02f, 7.38130733e-02f,
  -8.86801351e-03f, -1.04301954e-02f, 3.64585333e-02f, 8.23059678e-02f, -9.17969868e-02f, 1.86744630e-02f, -2.84243422e-03f, -1.05972374e-02f, 6.34013815e-03f, 2.92263329e-02f,
  1.29360072e-02f, -3.40292044e-02f, -5.14002778e-02f, -5.39497361e-02f, -3.15312296e-02f, 2.88027152e-02f, 5.23934029e-02f, -7.96283223e-03f, 6.88452646e-03f, 4.08986732e-02f,
  3.98948826e-02f, -4.72457483e-02f, -9.78027377e-03f, 1.88904125e-02f, -4.46165577e-02f, 8.67014304e-02f, 8.52797404e-02f, -2.51715034e-02f, 4.21722420e-02f, 1.47292130e-02f,
  4.35837843e-02f, 1.68912232e-01f, -8.84262845e-03f, -3.47217955e-02f, 2.62167566e-02f, 1.23658543e-02f, 1.96289830e-02f, 7.10117724e-03f, 7.38207400e-02f, -7.32526332e-02f,
  -1.39121795e-02f, 3.81155312e-02f, 1.93556100e-02f, 7.92709552e-03f, 3.27254534e-02f, 1.11025004e-02f, -2.65723355e-02f, 1.33814186e-01f, 5.17097265e-02f, 4.11390029e-02f,
  4.03051153e-02f, -4.15908955e-02f, 2.19484456e-02f, -1.28205374e-01f, -6.45866469e-02f, 5.88662438e-02f, 7.15297088e-03f, -2.53174622e-02f, 1.08368672e-01f, 4.14570048e-02f,
  -1.28135070e-01f, 1.47035560e-02f, -1.06839009e-01f, -6.75864294e-02f, -1.55899331e-01f, -2.00444669e-01f, 1.37309972e-02f, -2.97697056e-02f, 2.45938040e-02f, 2.06570238e-01f,
  5.60295843e-02f, -1.14797959e-02f, 8.03651512e-02f, -7.47258663e-02f, -9.44568664e-02f, 8.78522098e-02f, -1.57192782e-01f, 4.97833788e-02f, -5.59348315e-02f, -2.33276784e-01f,
  -1.41544059e-01f, -1.52760252e-01f, -6.61641806e-02f, -1.65065020e-01f, -1.83519274e-01f, 5.32623613e-03f, 2.90175416e-02f, -1.08723924e-01f, -1.44304456e-02f, 1.08946171e-02f,
  -1.06633782e-01f, 1.97514030e-03f, -2.93738395e-02f, -7.92030543e-02f, -9.63724479e-02f, 4.31164801e-02f, -7.89436623e-02f, 4.11338732e-02f, -2.84473654e-02f, -5.02026305e-02f,
  -2.00867802e-02f, -1.57323387e-02f, 1.79516152e-02f, 1.57399997e-02f, 4.01562219e-03f, 7.00241178e-02f, -1.72560941e-02f, -7.26965442e-02f, -6.02046326e-02f, 7.26625919e-02f,
  -1.67061128e-02f, 1.50176762e-02f, -8.73125941e-02f, -3.82604338e-02f, -2.83117518e-02f, 4.46397625e-02f, 5.34327328e-02f, 1.56651507e-03f, -7.50850886e-02f, -7.44448826e-02f,
  9.50283036e-02f, -1.87317040e-02f, -6.19826354e-02f, 1.24021508e-02f, 1.97730996e-02f, 4.83594388e-02f, 1.46120489e-02f, 5.85328639e-02f, -8.06633011e-02f, -5.94751947e-02f,
  6.92796707e-03f, -9.24430974e-03f, -4.73449734e-04f, -3.87634598e-02f, 2.20539700e-03f, -3.39012705e-02f, -3.19279777e-03f, 2.47093625e-02f, -6.90126270e-02f, -2.61341259e-02f,
  1.01760827e-01f, 2.71719210e-02f, 2.09127087e-02f, -8.52591991e-02f, -1.43967550e-02f, -4.75895591e-03f, -9.88748670e-02f, -7.19299307e-03f, 7.10138083e-02f, -9.85354707e-02f,
  -2.82966822e-01f, -1.24122143e-01f, 5.02024107e-02f, -5.79528231e-03f, 4.26473692e-02f, -5.63036948e-02f, -1.06610851e-02f, -5.31125590e-02f, -8.50017890e-02f, -4.48804721e-02f,
  -8.11608657e-02f, 4.30746749e-02f, -8.53341669e-02f, -3.33117768e-02f, -1.23911714e-02f, -2.06252630e-03f, 1.96799189e-02f, -5.46972640e-02f, -6.77763000e-02f, -3.22989523e-02f,
  6.81256875e-02f, 1.16626583e-02f, 9.23110619e-02f, 4.90941340e-03f, 6.43398985e-02f, -7.95725286e-02f, -6.58485293e-02f, 7.06289411e-02f, -1.37550950e-01f, 7.80874342e-02f,
  1.65838256e-01f, -1.72679543e-01f, -2.58640528e-01f, 3.72629687e-02f, 1.26251847e-01f, 1.27108142e-01f, 4.75742742e-02f, 2.77900267e-02f, 5.35661168e-03f, -8.24786574e-02f,
  1.26675501e-01f, -1.05488047e-01f, -1.97369903e-01f, 7.57162422e-02f, 2.08644688e-01f, -1.46041363e-01f, 1.12303808e-01f, 2.73433868e-02f, -4.27070372e-02f, 5.36908433e-02f,
  -1.52301602e-02f, 2.72164792e-01f, -1.06314309e-01f, 2.60763522e-02f, 7.24503817e-03f, -1.78058609e-01f, 4.55937423e-02f, -1.64845258e-01f, 1.48181513e-01f, 5.52447736e-02f,
  9.05752927e-02f, -1.90028902e-02f, -2.91442815e-02f, -3.02826776e-03f, -3.10191195e-02f, 3.13782580e-02f, 4.10155468e-02f, -2.40968205e-02f, 3.36074457e-02f, -6.03254661e-02f,
  -1.53940439e-01f, -6.47448301e-02f, -1.99667960e-02f, 4.00458947e-02f, 8.60596895e-02f, 9.58867669e-02f, -3.28464620e-03f, -9.35603008e-02f, 3.16027291e-02f, -7.82260299e-03f,
  -8.78429636e-02f, 1.13456547e-02f, 5.74549921e-02f, -1.22879967e-01f, -5.05988523e-02f, -4.23912220e-02f, -3.86616550e-02f, 5.35890413e-03f, -3.86641659e-02f, -4.36947830e-02f,
  1.63271613e-02f, -2.86052059e-02f, 2.18587853e-02f, 9.68740433e-02f, 1.10190168e-01f, -5.16511798e-02f, -9.31750908e-02f, 4.17910703e-02f, 5.83329983e-02f, 8.83796439e-02f,
  -1.94079541e-02f, 1.92034934e-02f, 7.19295442e-02f, 6.63553327e-02f, 3.25301588e-02f, -8.61010700e-02f, 5.82588986e-02f, 9.08809155e-02f, -4.07136157e-02f, 4.43793572e-02f,
  -4.58154082e-02f, -2.68781893e-02f, 6.96299747e-02f, -2.85141766e-02f, -2.56153885e-02f, 2.07460430e-02f, 8.39340538e-02f, 3.06894798e-02f, -5.33148199e-02f, -2.72439681e-02f,
  -2.29237992e-02f, -2.22085431e-01f, -9.15563628e-02f, 3.69885862e-02f, -1.29028754e-02f, 7.08775148e-02f, -2.29639411e-02f, -1.85033232e-02f, -1.56907085e-02f, 6.02944419e-02f,
  -3.22138332e-02f, 7.47656683e-03f, -3.78157981e-02f, 4.74338941e-02f, -2.10512672e-02f, 4.33458127e-02f, -1.09724618e-01f, -2.42916606e-02f, -2.70911250e-02f, 4.55827080e-02f,
  1.14461984e-02f, 2.76873745e-02f, 2.19968017e-02f, -2.71127708e-02f, 6.51182840e-03f, -1.15601331e-01f, 6.51702145e-03f, 1.23641090e-02f, 1.09032243e-01f, -3.61952186e-02f,
  -1.94322005e-01f, 2.66332761e-04f, -3.30977261e-01f, -2.23923430e-01f, 1.24501050e-01f, -4.07889009e-01f, -3.26866925e-01f, -1.42428866e-02f, 8.44063610e-02f, -3.52417678e-02f,
  -2.17129126e-01f, 5.94966821e-02f, 1.01131484e-01f, -3.38378847e-01f, -3.03290009e-01f, -1.63903926e-02f, -4.39915746e-01f, -2.47208476e-01f, 3.52290571e-02f, -1.13902584e-01f,
  -1.10607177e-01f, -6.00122102e-02f, -1.87495872e-01f, 8.59830528e-02f, -1.63900286e-01f, -5.12274131e-02f, 9.35270190e-02f, 9.13104415e-02f, -1.43194705e-01f, -3.54780070e-02f,
  -8.42931867e-02f, 3.84096429e-02f, 1.15296878e-02f, -2.81120688e-02f, -1.49108469e-01f, 1.67670529e-02f, -1.00387998e-01f, 2.28631198e-02f, 6.61752895e-02f, -2.67636962e-04f,
  -2.03133989e-02f, -9.67508368e-03f, -6.42032037e-03f, 5.84653541e-02f, -5.09684384e-02f, 3.41074690e-02f, -5.74046921e-04f, -4.52040782e-04f, 2.38032881e-02f, -7.60557279e-02f,
  -5.48202209e-02f, -4.22528163e-02f, -4.56262194e-03f, 5.50873987e-02f, 1.89897139e-02f, -1.56572331e-02f, -1.16419047e-01f, -1.15047686e-03f, -3.46876904e-02f, 5.01431264e-02f,
  -4.05009510e-03f, 3.89016457e-02f, -2.13868842e-02f, -1.82669722e-02f, -1.34613402e-02f, 2.21032323e-03f, -1.64290890e-02f, 1.70063023e-02f, 7.64518082e-02f, -4.11024503e-03f,
  -1.07031791e-02f, -2.31316276e-02f, 6.88525811e-02f, -6.59218952e-02f, -5.66166565e-02f, 1.77905746e-02f, -1.83263067e-02f, 2.23657372e-03f, -7.87447765e-02f, -1.92939974e-02f,
  -1.01723056e-02f, 5.47041604e-03f, 8.89229216e-03f, 1.82726234e-02f, -6.14417642e-02f, 1.05050527e-01f, 7.80069605e-02f, -6.20945282e-02f, -8.76161084e-03f, 9.90756787e-03f,
  -9.39564705e-02f, 2.79150587e-02f, -1.73160675e-04f, 9.11493972e-02f, 2.18923558e-02f, -1.06058665e-01f, -2.71473993e-02f, 5.71599230e-02f, -3.66541231e-03f, -2.44969353e-02f,
  -2.98922639e-02f, -4.07825503e-03f, -6.89678043e-02f, -1.23413913e-02f, 1.39059694e-02f, -1.05644688e-01f, 1.62079819e-02f, 3.90942395e-02f, -8.73297751e-02f, 1.24841956e-02f,
  -4.79642302e-02f, -1.22354366e-02f, 5.87726757e-02f, 3.91196385e-02f, -8.75081494e-03f, -3.40664946e-02f, 6.72886595e-02f, -5.92171662e-02f, -3.60908695e-02f, -5.25361411e-02f,
  3.99019718e-02f, 4.63540941e-01f, 1.82309166e-01f, 3.91732961e-01f, -7.61763826e-02f, 2.19636321e-01f, 2.66499043e-01f, 1.33521736e-01f, 3.11375797e-01f, 2.82755345e-01f,
  -6.71919137e-02f, 2.74514705e-01f, -1.82342567e-02f, 1.16231598e-01f, -7.93244466e-02f, 1.28738424e-02f, 2.73851633e-01f, 1.84580788e-01f, -2.94815432e-02f, 1.67616561e-01f,
  5.66301756e-02f, 2.48632748e-02f, -8.42811242e-02f, -5.81391305e-02f, 2.25438513e-02f, 9.78018064e-03f, -1.35057092e-01f, -1.18638270e-01f, -1.83422528e-02f, -1.99935343e-02f,
  -3.80129367e-02f, 4.77568731e-02f, -1.14149945e-02f, -1.13106531e-03f, 6.99502649e-03f, -2.79229227e-02f, -9.86602716e-03f, -1.31539442e-02f, -5.00621013e-02f, -1.46309789e-02f,
  3.21519524e-02f, 5.45975054e-03f, 6.13675900e-02f, -6.16566604e-03f, -2.43220013e-02f, 9.03533213e-03f, -1.82955395e-02f, -6.10783808e-02f, -1.52700674e-02f, -7.55072534e-02f,
  6.65922184e-03f, 1.73153460e-03f, 3.00573166e-02f, 3.67720090e-02f, -1.08260913e-02f, 1.79909598e-02f, 1.13825567e-01f, 1.80854984e-02f, 1.95531808e-02f, -2.77403612e-02f,
  1.26529019e-03f, 1.01478338e-01f, 3.81858796e-02f, 3.50036435e-02f, 4.34725992e-02f, -2.00425442e-02f, -7.33305060e-04f, -3.89423333e-02f, 4.70643528e-02f, -6.99810386e-02f,
  -5.53878117e-03f, 7.62222856e-02f, 3.36539373e-03f, 1.37990126e-02f, -2.94087883e-02f, 2.91638058e-02f, -4.17691842e-02f, 4.08158900e-04f, 4.73123379e-02f, -4.69673313e-02f,
  -2.96930578e-02f, 4.48943749e-02f, 3.91126387e-02f, -5.94095374e-03f, 4.35266234e-02f, 6.12240098e-02f, 5.66486120e-02f, -2.71453578e-02f, 2.57225409e-02f, 3.86611074e-02f,
  1.85608536e-01f, 2.86622316e-01f, 5.14122508e-02f, 4.19548079e-02f, 1.41636841e-02f, 2.80152131e-02f, -1.92816164e-02f, 5.89022064e-04f, 3.25943530e-02f, 4.56115492e-02f,
  4.57666516e-02f, 5.17998300e-02f, -2.83825081e-02f, -3.94722521e-02f, 2.35253368e-02f, 1.34512782e-01f, 8.23320225e-02f, 6.59560636e-02f, 7.77367279e-02f, -3.30057666e-02f,
  -1.41235851e-02f, 1.88515000e-02f, 1.78505052e-02f, -3.55552845e-02f, 1.09201269e-02f, 1.30881323e-02f, 6.41596615e-02f, 3.12300883e-02f, -2.54589766e-02f, 9.63033438e-02f,
  -1.80599183e-01f, -5.06905988e-02f, 1.81240186e-01f, -3.29022080e-01f, 1.67067364e-01f, 6.51881397e-02f, 2.22856656e-01f, 8.80745705e-03f, -8.63010138e-02f, -3.39698195e-01f,
  -1.50155589e-01f, -9.13802311e-02f, 1.35874793e-01f, -2.02333599e-01f, 2.28464201e-01f, 9.01269987e-02f, 9.99178812e-02f, -3.59880924e-02f, 6.00183159e-02f, -5.44272326e-02f,
  5.61095886e-02f, 2.16631442e-02f, 1.85378030e-01f, 2.45642150e-03f, -2.17506494e-02f, -4.88745198e-02f, -2.71061976e-02f, 1.72739863e-01f, -1.86433524e-01f, 6.09472319e-02f,
  -9.00216177e-02f, -2.03065947e-02f, -3.01347077e-02f, 6.77567720e-02f, 2.86215190e-02f, -1.16166389e-02f, 5.19783646e-02f, 8.01329240e-02f, -2.80279829e-03f, -3.12061086e-02f,
  -2.24625766e-02f, 3.65343667e-03f, -1.17626347e-01f, 9.03604925e-02f, 4.58618030e-02f, 3.93081643e-02f, 2.67042103e-03f, -3.65689769e-02f, -3.63017549e-03f, 8.06432292e-02f,
  9.09559205e-02f, 1.11274431e-02f, -6.28671562e-03f, -4.61987294e-02f, 1.41626656e-01f, -9.56166908e-02f, -8.94469321e-02f, 5.34881093e-02f, -3.76015669e-03f, -7.28069246e-02f,
  8.35504830e-02f, -2.03656126e-02f, 2.82044280e-02f, -6.07999042e-03f, -7.75673687e-02f, -9.21013430e-02f, -3.00217457e-02f, -8.94798413e-02f, -4.44515720e-02f, -6.13167658e-02f,
  2.72470876e-03f, 2.01342236e-02f, 1.00825861e-01f, 1.13616005e-01f, -5.16830198e-02f, -4.28086333e-02f, 5.02954982e-02f, -3.58270742e-02f, -4.34523150e-02f, -5.37947528e-02f,
  -6.04802705e-02f, -3.20339724e-02f, 6.06954917e-02f, -6.15889244e-02f, -6.77681249e-03f, 1.09594524e-01f, 4.46765646e-02f, 4.42604385e-02f, 4.12574969e-02f, 1.06412537e-01f,
  -6.14560172e-02f, -9.28660184e-02f, 8.43085423e-02f, 2.58390512e-02f, -2.81997006e-02f, 1.52766863e-02f, 1.93884950e-02f, -1.93561837e-02f, -2.07557585e-02f, 3.56329307e-02f,
  -2.96990070e-02f, 1.14112161e-02f, -8.77827406e-03f, 7.42814224e-03f, 2.08630301e-02f, -4.55579609e-02f, -3.10971998e-02f, 2.51000579e-02f, 2.52395472e-03f, -1.08522028e-02f,
  -2.66985092e-02f, -2.21544113e-02f, -1.81793850e-02f, -3.11666839e-02f, -4.54541557e-02f, 1.30642140e-02f, -6.13092482e-02f, 4.81674746e-02f, 9.24525708e-02f, -5.43511957e-02f,
  -1.09144948e-01f, -7.60974661e-02f, -1.29749745e-01f, -6.87503964e-02f, -1.63685411e-01f, -2.22403869e-01f, -2.80107986e-02f, -6.53405413e-02f, -1.36620730e-01f, 2.17253208e-01f,
  8.70425161e-03f, -1.44278511e-01f, 2.59177089e-01f, 1.86715603e-01f, -2.92377830e-01f, 2.91681617e-01f, 8.41722116e-02f, 1.31990150e-01f, -1.29548702e-02f, -8.05720314e-02f,
  1.03223138e-02f, 1.59863293e-01f, 1.16625749e-01f, -9.34249982e-02f, -1.08552940e-01f, -2.45061759e-02f, 7.57086128e-02f, -2.81757605e-03f, -4.34836335e-02f, -8.67621452e-02f,
  -2.75796577e-02f, 1.83459684e-01f, 1.12346165e-01f, 1.06946506e-01f, -2.74820942e-02f, 4.25608456e-03f, -2.10813191e-02f, 1.16744908e-02f, -3.44594964e-03f, 5.08406870e-02f,
  3.77041809e-02f, -7.06947744e-02f, -6.32698238e-02f, 1.08215422e-03f, -4.59796563e-03f, 5.20177633e-02f, -4.19673175e-02f, -2.49417238e-02f, 1.06732205e-01f, -1.71794500e-02f,
  -2.88097840e-02f, 6.13201922e-03f, 1.05519937e-02f, 1.06242619e-01f, -4.12902385e-02f, 7.74824917e-02f, -4.10529114e-02f, 5.95148318e-02f, -7.42262229e-02f, -6.07808121e-02f,
  4.21137502e-03f, -1.28151610e-01f, 6.85869232e-02f, -4.91311736e-02f, -1.97383836e-02f, -1.70129922e-03f, -1.81165691e-02f, 3.05594429e-02f, -6.10289611e-02f, -4.06787582e-02f,
  -8.43349397e-02f, -4.27554324e-02f, 4.64719459e-02f, -4.57922742e-02f, -1.15040755e-02f, -3.00599704e-03f, 1.01476699e-01f, 6.97902292e-02f, -7.07657337e-02f, -8.85761380e-02f,
  6.57103807e-02f, -9.18840915e-02f, -1.42863588e-02f, 2.80025676e-02f, -8.52133241e-03f, 1.18528688e-02f, 3.41274589e-02f, 2.10230630e-02f, -4.50598262e-03f, -1.21270485e-01f,
  -5.23905456e-02f, 4.34484109e-02f, 6.68024421e-02f, 4.53573139e-03f, 9.16394293e-02f, -1.49662560e-02f, 2.53600329e-02f, -4.54933243e-03f, 1.03425737e-02f, -1.09582305e-01f,
  -6.89546242e-02f, 1.34357512e-02f, -3.53009738e-02f, 4.65093702e-02f, -7.08979517e-02f, 3.43156271e-02f, -2.09731777e-04f, 6.31166697e-02f, -1.66780315e-02f, -7.74578825e-02f,
  4.17002849e-02f, 6.70610555e-03f, 1.67106763e-02f, 4.97720949e-02f, 1.24315852e-02f, 1.07636815e-02f, -1.13433599e-01f, -3.67133617e-02f, -9.18433368e-02f, -2.79595628e-02f,
  2.65539736e-01f, -2.38743469e-01f, 1.00416757e-01f, 1.87085614e-01f, 2.15403229e-01f, 3.74734104e-02f, 4.80634272e-02f, 3.33724618e-02f, 9.20621604e-02f, -2.13116527e-01f,
  -1.11897225e-02f, 1.65919308e-02f, -1.48532152e-01f, 1.25113234e-01f, 2.99537927e-01f, -4.94876206e-02f, -2.55676098e-02f, 3.88779975e-02f, 5.98458536e-02f, -1.39049543e-02f,
  1.62246704e-01f, 2.11785976e-02f, 7.52823427e-02f, -8.92312601e-02f, -3.39097081e-04f, 2.25809533e-02f, -8.58925730e-02f, -5.04301675e-02f, -2.24569123e-02f, -1.19619863e-02f,
  -3.92069481e-02f, -6.45316169e-02f, -3.81263979e-02f, -6.42531440e-02f, -1.92012172e-02f, -4.37410884e-02f, -7.22137913e-02f, -3.70193906e-02f, 4.16092128e-02f, 2.25790683e-02f,
  2.06162743e-02f, 6.73356578e-02f, 3.69778872e-02f, 4.09998558e-02f, -2.37576216e-02f, 4.73403558e-02f, 9.65317935e-02f, -2.00002026e-02f, -4.95147407e-02f, 1.03822805e-01f,
  1.52431671e-02f, -2.72665136e-02f, 8.77983496e-03f, -1.60946250e-02f, 4.45213318e-02f, 6.31276742e-02f, -6.27422854e-02f, 1.71065256e-02f, -8.25543981e-03f, 1.33372052e-02f,
  -1.99403409e-02f, -7.67347170e-03f, 5.41719748e-03f, 8.10944960e-02f, -1.92863997e-02f, 7.46861994e-02f, 3.54184955e-02f, 3.00333761e-02f, 1.01635270e-02f, 6.82773348e-03f,
  -1.60144195e-02f, 6.23441674e-03f, -4.96061295e-02f, -1.31928667e-01f, -4.82253693e-02f, 7.27591524e-03f, 8.61773640e-03f, -1.03484847e-01f, -4.90239915e-03f, 2.14237515e-02f,
  -1.97216645e-02f, -2.06258707e-02f, -4.98920865e-02f, 7.30383918e-02f, -2.83526862e-03f, -3.78986709e-02f, -6.06811084e-02f, -7.33239353e-02f, 2.79554538e-02f, -1.06334850e-01f,
  -1.91353470e-01f, -2.50672519e-01f, -5.69377057e-02f, -7.25227082e-03f, -5.36448844e-02f, -7.11436942e-02f, -5.65276258e-02f, -2.57430924e-03f, -1.13733202e-01f, 1.43555580e-02f,
  3.30956727e-02f, -1.39279934e-02f, -1.29826829e-01f, -2.73314845e-02f, -4.86960895e-02f, -1.47386380e-02f, -1.64780896e-02f, -1.15404092e-01f, -2.53540464e-02f, -2.24302504e-02f,
  2.58000903e-02f, 1.32290414e-02f, 1.17086492e-01f, 1.85400508e-02f, -5.65190352e-02f, -5.94164096e-02f, -5.89960665e-02f, 2.26613376e-02f, 3.58048603e-02f, -3.59457545e-02f,
  -1.49222091e-01f, 1.10155022e-04f, -1.21323079e-01f, -6.88677877e-02f, -1.85026795e-01f, -1.32303670e-01f, -8.88723210e-02f, -1.88440576e-01f, -3.44640836e-02f, 4.36497629e-02f,
  -1.44504964e-01f, 4.40393351e-02f, 1.45557627e-01f, -8.71883109e-02f, -4.65481170e-02f, 1.54651523e-01f, -1.23488396e-01f, 1.55457761e-02f, 1.53299524e-02f, -8.41343403e-02f,
  -9.13449898e-02f, -1.69268832e-01f, -7.15795085e-02f, -1.31888816e-03f, -2.22312897e-01f, -6.24463111e-02f, -6.70782244e-03f, -1.02634981e-01f, -3.46443988e-02f, -1.01979710e-01f,
  -1.20066203e-01f, -9.38614383e-02f, -9.77175962e-03f, -4.95220795e-02f, -8.55947211e-02f, 9.96996462e-03f, -6.52091801e-02f, -3.14836092e-02f, -6.50740182e-03f, -3.54667082e-02f,
  4.08486761e-02f, 5.51799359e-03f, -5.77795692e-03f, -4.71951589e-02f, 7.95444474e-02f, 1.74428709e-02f, 8.81177746e-03f, 3.09090205e-02f, -1.68423764e-02f, -1.58454105e-02f,
  5.44479378e-02f, -1.13929592e-01f, -8.78462717e-02f, 1.22788802e-01f, -8.43467712e-02f, -9.72557813e-02f, 4.00411263e-02f, -7.11808261e-03f, 1.05863437e-02f, -1.15183085e-01f,
  -1.58301771e-01f, 3.36485654e-02f, 4.31033783e-02f, -2.45835688e-02f, -2.98038423e-02f, -2.52175462e-02f, -8.95232242e-03f, -8.09364580e-03f, 3.65693588e-03f, -4.90205130e-04f,
  -8.20939019e-02f, 2.89904755e-02f, -6.71303347e-02f, 8.08650479e-02f, 1.53028835e-02f, 6.35846704e-03f, -5.94075657e-02f, -1.03864141e-01f, -3.86124775e-02f, -1.29219517e-02f,
  -1.00756558e-02f, 3.21260579e-02f, 1.33305937e-01f, 1.22208364e-01f, -5.57197109e-02f, -4.96128537e-02f, 2.67260354e-02f, 7.34221861e-02f, 2.42427625e-02f, -5.62726222e-02f,
  -1.42047837e-01f, -2.93755054e-01f, -2.30271779e-02f, -3.59889232e-02f, -2.49811001e-02f, -3.56078260e-02f, 3.51532549e-02f, -9.70870703e-02f, -2.87770219e-02f, -8.10693130e-02f,
  3.01906113e-02f, 6.16345108e-02f, -7.33333901e-02f, 6.90130144e-03f, 4.30389270e-02f, 7.18760258e-03f, 2.47225687e-02f, 8.36164430e-02f, -6.96254149e-02f, 2.40000524e-02f,
  -4.61428389e-02f, -1.31504964e-02f, -1.49174165e-02f, 3.18956599e-02f, 8.43872949e-02f, -3.23786773e-02f, 2.86748521e-02f, 8.13190043e-02f, 2.09344178e-02f, -3.33960168e-03f,
  -4.95106697e-01f, 1.28240183e-01f, 1.25659317e-01f, -2.30810374e-01f, -4.14168909e-02f, 2.29988798e-01f, -1.99305806e-02f, 7.49912336e-02f, -1.58560947e-01f, 6.26884550e-02f,
  1.47888204e-02f, -8.75801295e-02f, 2.47201428e-01f, 1.44661024e-01f, 3.09679117e-02f, 1.78050175e-01f, 2.00030673e-02f, -7.59144649e-02f, -6.59737512e-02f, -5.26105473e-03f,
  -1.95634030e-02f, 8.86631105e-03f, 9.59109366e-02f, 1.36756092e-01f, 2.25206539e-02f, -1.43788472e-01f, -1.19984550e-02f, 5.70849255e-02f, 8.10759366e-02f, -3.54700983e-02f,
  -1.63762704e-01f, -1.58626154e-01f, -5.15187234e-02f, 3.54979187e-02f, 2.71871891e-02f, 4.60571013e-02f, -8.64856914e-02f, -6.92990515e-03f, -4.89861965e-02f, 5.88927492e-02f,
  -7.41187632e-02f, 3.79373058e-04f, -7.43551776e-02f, 9.95770190e-03f, -4.77801748e-02f, -2.14581378e-02f, -8.43753200e-03f, 2.50684712e-02f, 4.08851244e-02f, 3.67313921e-02f,
  6.30096421e-02f, 5.72246499e-03f, 7.52042532e-02f, 3.90847214e-02f, 2.14348994e-02f, 1.13794478e-02f, 1.02722654e-02f, 4.57952507e-02f, -5.53255938e-02f, -3.46417874e-02f,
  8.39602724e-02f, 5.13177970e-03f, -3.48242000e-02f, 3.40458490e-02f, -4.51544523e-02f, 1.62657220e-02f, -2.90599968e-02f, -6.02273531e-02f, -1.69232450e-02f, 5.02650738e-02f,
  -6.76035956e-02f, -9.82167851e-03f, -3.16399895e-02f, 5.64518720e-02f, -8.28100443e-02f, 1.33064399e-02f, 6.69343024e-02f, -2.00052448e-02f, 4.35888059e-02f, -5.81487194e-02f,
  -5.00277132e-02f, -7.78835863e-02f, -2.65419837e-02f, 5.43129295e-02f, 6.09033462e-03f, 4.40201014e-02f, 6.84629828e-02f, -1.30622499e-02f, 2.86515784e-02f, 1.66354738e-02f,
  -2.02528685e-01f, -2.51059979e-01f, -1.56307086e-01f, -1.00043237e-01f, -5.65761980e-03f, -3.22470404e-02f, -1.29439142e-02f, -9.78977513e-03f, -1.58441626e-02f, -3.18852370e-03f,
  -7.76078328e-02f, 1.05600432e-02f, -6.69453666e-02f, 3.89885367e-03f, 3.25794108e-02f, -6.93600997e-02f, -5.25258705e-02f, 1.00923814e-02f, 4.36758287e-02f, 7.02263787e-02f,
  -4.28233258e-02f, -3.13107446e-02f, -3.26092094e-02f, -1.30906487e-02f, 3.69514823e-02f, -2.82586627e-02f, 6.05542213e-02f, -3.70411458e-03f, 3.10821384e-02f, 1.32778222e-02f,
  8.78686458e-03f, -2.08039731e-01f, -2.38164365e-01f, -1.49330718e-03f, 2.67270297e-01f, 1.32262766e-01f, 6.15602434e-02f, 8.34039301e-02f, -6.14884533e-02f, -2.36214977e-02f,
  2.09400952e-02f, -2.15670362e-01f, -2.50800163e-01f, -2.72526324e-01f, -1.15650661e-01f, -2.56436765e-01f, -1.78095400e-02f, -7.39881173e-02f, -1.01679757e-01f, 1.48976175e-02f,
  9.59679112e-02f, 1.00168787e-01f, 1.34258308e-02f, 8.00003707e-02f, 3.50066158e-03f, 1.97394162e-01f, 3.13738108e-01f, 3.09162438e-02f, 1.36022925e-01f, -1.91667192e-02f,
  -2.14951988e-02f, -1.17907725e-01f, 2.44878810e-02f, -5.95772974e-02f, 1.12418354e-01f, 1.03045359e-01f, 3.98890022e-03f, 1.17435288e-02f, 8.92184898e-02f, -2.79788133e-02f,
  -5.67894168e-02f, 2.77239438e-02f, -3.47524956e-02f, 3.23754437e-02f, 4.97267880e-02f, 1.03503965e-01f, -5.77262379e-02f, 8.95439684e-02f, 2.61333445e-03f, -1.21285215e-01f,
  -6.82418346e-02f, -4.28130142e-02f, -1.05040632e-02f, 6.37591630e-02f, -4.95518632e-02f, -1.69151798e-02f, 7.06086829e-02f, 2.56083924e-02f, -1.46349799e-02f, 3.24134938e-02f,
  2.26846952e-02f, 3.41287442e-02f, -4.83611673e-02f, -1.38738170e-01f, -5.68446293e-02f, 2.83636041e-02f, -3.57675180e-02f, 5.48791587e-02f, -6.39962181e-02f, 4.28351499e-02f,
  7.92008564e-02f, -5.67672066e-02f, -1.20731510e-01f, 9.59919021e-02f, 1.86077002e-02f, 9.99919232e-03f, 9.05565545e-02f, 3.18430699e-02f, 2.80326214e-02f, 4.08977121e-02f,
  1.63785014e-02f, 2.70268470e-02f, -1.01043601e-02f, 3.66772078e-02f, -5.94295189e-02f, 5.16447276e-02f, -8.03160202e-03f, -1.30269323e-02f, 4.20851931e-02f, 9.67803877e-03f,
  -9.01472475e-03f, -8.93428102e-02f, 6.54101837e-04f, 5.16768508e-02f, -9.42895282e-03f, -1.32348221e-02f, -6.51572505e-03f, -2.01880280e-02f, 2.82283593e-02f, -9.26934630e-02f,
  1.46973997e-01f, 9.78389829e-02f, 3.77030559e-02f, -4.23183255e-02f, 5.75246103e-02f, 2.59917323e-02f, 3.79962772e-02f, 3.01172212e-02f, -1.28662558e-02f, -1.10563319e-02f,
  8.44436213e-02f, 6.12598620e-02f, -3.50843882e-03f, 4.78111543e-02f, 9.27254632e-02f, -6.26654411e-03f, 5.73583581e-02f, 2.74024475e-02f, -1.08178042e-01f, 1.89176332e-02f,
  5.82109690e-02f, 5.05675375e-02f, -3.19174200e-01f, 3.65745611e-02f, 6.93105310e-02f, 2.49844536e-01f, 2.31133103e-01f, 1.90094318e-02f, -1.62706032e-01f, 2.60360450e-01f,
  2.18909085e-01f, -9.42732468e-02f, 9.01269615e-02f, 3.81195515e-01f, 1.23168722e-01f, 9.42963287e-02f, 3.57481241e-01f, 1.71569124e-01f, -1.46228969e-01f, 1.23829208e-02f,
  -3.38742957e-02f, 3.67992371e-01f, 4.08203900e-02f, -5.25484085e-02f, 3.17984223e-02f, -2.70626396e-01f, 1.25175819e-01f, -1.72460541e-01f, 1.46586806e-01f, 1.59103677e-01f,
  -6.93134125e-03f, 5.44113889e-02f, 3.58336680e-02f, -7.85228163e-02f, 7.02052414e-02f, 3.01611982e-02f, -7.03002214e-02f, -9.02603269e-02f, -8.42326880e-02f, -1.58662174e-03f,
  -8.59504566e-03f, 4.79725450e-02f, 1.96586102e-02f, -3.43001075e-02f, -9.80946887e-03f, -6.33310750e-02f, -8.80431011e-02f, -1.11331299e-01f, -4.42274250e-02f, 3.46194394e-02f,
  -3.95157523e-02f, -5.61111085e-02f, -2.90485639e-02f, -7.13395625e-02f, -9.92797390e-02f, 7.60591254e-02f, -7.77318925e-02f, -3.83837009e-03f, 5.83715066e-02f, -3.68609093e-02f,
  -1.82033554e-02f, 2.20188852e-02f, 6.34676665e-02f, -1.21243279e-02f, 1.67908408e-02f, -3.64896059e-02f, 1.32977888e-01f, -3.65857221e-02f, -4.29775901e-02f, 2.69880090e-02f,
  7.58707663e-03f, -2.01747473e-02f, 3.95793747e-03f, 1.19655216e-02f, -9.83844744e-04f, -2.01936681e-02f, -9.84370429e-03f, -6.02255128e-02f, -5.01119196e-02f, -2.79254168e-02f,
  2.71459203e-02f, 3.20642665e-02f, 2.13245731e-02f, -8.97207204e-03f, 2.49713305e-02f, -4.59367875e-03f, 2.07376312e-02f, 1.42480657e-02f, -3.18874227e-04f, 6.79077879e-02f,
  6.01928532e-02f, 1.30379777e-02f, -1.80782357e-04f, 3.33149661e-03f, -1.49347708e-02f, 1.71004772e-01f, 8.81260186e-02f, -4.70769145e-02f, -4.40499857e-02f, -6.54397458e-02f,
  -2.60817204e-02f, -2.65138540e-02f, -1.69957392e-02f, 8.12892336e-03f, -8.37066174e-02f, 1.02054879e-01f, 7.12191388e-02f, -6.14381954e-03f, 2.49300022e-02f, 7.52141550e-02f,
  1.43218543e-02f, 8.34758654e-02f, -2.60501727e-02f, -1.98338218e-02f, 2.00639702e-02f, -4.67842370e-02f, 1.42539730e-02f, 3.01141422e-02f, 8.67849588e-02f, 1.37511604e-02f,
  1.89334720e-01f, 2.65345663e-01f, 2.06191778e-01f, 3.05470586e-01f, -1.40510157e-01f, -2.78222769e-01f, -2.62444288e-01f, 7.06265420e-02f, -2.52551623e-02f, -4.87822928e-02f,
  -1.96437538e-01f, 2.60871053e-01f, -1.71109393e-01f, 1.23493351e-01f, -1.66708767e-01f, -1.70160279e-01f, 6.67301193e-02f, -3.54033485e-02f, 9.60046127e-02f, 1.63529754e-01f,
  -2.01561302e-02f, -1.56403601e-01f, 6.62382226e-03f, -1.31039888e-01f, 7.24238157e-02f, 2.15126842e-01f, 1.76868103e-02f, 7.06853494e-02f, 1.34607956e-01f, -1.10697739e-01f,
  -9.77689400e-02f, 1.01586826e-01f, 5.20849749e-02f, 8.15585554e-02f, -5.95542602e-03f, 8.76825079e-02f, 5.68757243e-02f, -6.51480034e-02f, 4.89692613e-02f, 4.87678275e-02f,
  6.76812083e-02f, -5.46159744e-02f, 1.67402253e-02f, -6.04394414e-02f, 5.02270982e-02f, 8.87409374e-02f, 1.78712904e-02f, -5.26993461e-02f, 9.63510871e-02f, 1.30025908e-01f,
  5.50026596e-02f, 9.52002332e-02f, -6.19809935e-03f, 1.84412990e-02f, 1.52001604e-02f, 3.41541991e-02f, -5.31827146e-03f, 5.56897782e-02f, 1.59446120e-01f, 6.94403648e-02f,
  3.62404920e-02f, 4.27438878e-02f, -4.71160486e-02f, 1.83876418e-02f, 9.95773822e-04f, -1.81828272e-02f, -4.40996513e-02f, -8.26388772e-04f, 2.54201610e-02f, -5.99129610e-02f,
  -1.13488287e-02f, 8.18033665e-02f, 3.62956263e-02f, 2.92947143e-02f, -3.14207822e-02f, -2.03942508e-03f, 5.15535800e-03f, -3.56931835e-02f, -3.34354416e-02f, 6.52322844e-02f,
  5.02777733e-02f, -9.49923396e-02f, 1.48319229e-02f, -5.98769635e-02f, -3.50924470e-02f, 2.07248628e-02f, -5.14264554e-02f, 3.61389257e-02f, 3.48365940e-02f, -4.17407639e-02f,
  -2.69497428e-02f, 3.21325064e-02f, 1.83150172e-02f, -1.45569788e-02f, 4.42152619e-02f, -6.03353903e-02f, -5.82911856e-02f, -1.11636790e-02f, 2.12949999e-02f, -3.23426463e-02f,
  -7.31308199e-03f, -8.45793411e-02f, -4.37954366e-02f, -1.32627331e-03f, -8.47841054e-02f, -1.35516468e-02f, -8.84184092e-02f, -8.88403803e-02f, 2.46941503e-02f, 1.16891541e-01f,
  4.37510423e-02f, 5.30878603e-02f, 1.51564588e-03f, -3.98579985e-02f, -7.98061490e-02f, -9.40674171e-02f, 1.92949064e-02f, -7.56031135e-03f, 3.84093560e-02f, -4.21148315e-02f,
  1.83604240e-01f, 8.49462077e-02f, 8.80282596e-02f, 2.13859499e-01f, 2.97374595e-02f, -1.15809746e-01f, -8.90238881e-02f, 8.67877975e-02f, -1.73529625e-01f, -3.62679511e-02f,
  8.12921897e-02f, -5.05554955e-03f, -1.32123411e-01f, 2.16085583e-01f, 5.32488637e-02f, -1.82913363e-01f, 4.92980629e-02f, -7.38769397e-02f, -4.13180552e-02f, 3.07559874e-02f,
  1.58038333e-01f, 1.11086756e-01f, 1.77823722e-01f, 1.67284191e-01f, 2.06945762e-02f, 2.05651358e-01f, 1.75344810e-01f, -3.89164276e-02f, 1.78097695e-01f, -6.67542964e-03f,
  -6.88651577e-02f, 9.22155008e-03f, 6.73731640e-02f, -1.14776492e-02f, 3.17287110e-02f, -1.24823498e-02f, 5.12121357e-02f, -5.24585024e-02f, 2.88576875e-02f, 1.95453539e-02f,
  -4.28774059e-02f, 4.49837781e-02f, -4.53418680e-02f, -4.48818691e-02f, 7.70817250e-02f, 9.31365266e-02f, 6.53151125e-02f, 5.11414632e-02f, 7.07196146e-02f, -5.46253193e-03f,
  -6.56662136e-03f, -7.39413127e-02f, -6.32234961e-02f, 6.76280707e-02f, -1.02595724e-02f, -2.18403637e-02f, -1.15428187e-01f, 1.19072814e-02f, -3.21543999e-02f, 4.59166318e-02f,
  -7.61646219e-03f, -1.17698766e-01f, 2.36569699e-02f, -1.85226351e-02f, 4.16541891e-03f, 5.50167635e-02f, 1.11313257e-02f, 6.48263097e-02f, 1.87196136e-02f, 4.64194678e-02f,
  4.05848920e-02f, 1.93172507e-02f, 1.55749004e-02f, -3.86361182e-02f, -6.27518669e-02f, -4.95457500e-02f, -3.64783369e-02f, 2.04357319e-02f, 2.68301554e-02f, 5.94875365e-02f,
  -7.36011267e-02f, 1.00922227e-01f, -1.85653958e-02f, -2.92771645e-02f, -4.04901430e-02f, 5.78749441e-02f, 1.45702073e-02f, 2.29604691e-02f, -5.31186536e-03f, 6.93080015e-03f,
  -1.53864706e-02f, 6.74654394e-02f, -1.02051288e-01f, -7.30578080e-02f, -1.96548793e-02f, -5.34414873e-03f, -8.18573609e-02f, 1.02803402e-01f, -6.41593635e-02f, 7.88236931e-02f,
  9.96621326e-03f, 2.23524100e-03f, -4.59787063e-02f, 4.60608080e-02f, 4.28190418e-02f, 6.32944405e-02f, 2.05218960e-02f, 4.57079895e-02f, -1.21796678e-03f, 1.36082187e-01f,
  -1.91445909e-02f, 1.94986220e-02f, -6.22153245e-02f, 1.06348358e-02f, 9.08941180e-02f, 1.23418989e-02f, -3.65982205e-02f, 1.30954050e-02f, -5.83825586e-03f, -6.64769858e-02f,
  -1.53077304e-01f, 5.14476821e-02f, -2.61344373e-01f, 2.84166411e-02f, -2.18255252e-01f, -1.26176849e-01f, 8.97417217e-02f, -1.52993381e-01f, -3.06485277e-02f, 1.67285129e-01f,
  8.42185840e-02f, -7.23545030e-02f, 7.62695149e-02f, -5.74342124e-02f, 3.91128995e-02f, 2.00567618e-01f, 8.30734670e-02f, 5.85097484e-02f, -5.38339689e-02f, -1.76842764e-01f,
  5.00633605e-02f, -7.68266618e-02f, -3.17977034e-02f, -1.44333810e-01f, -1.25409707e-01f, -9.19663832e-02f, 9.22409520e-02f, -1.49915338e-01f, -4.06302176e-02f, -1.08017683e-01f,
  -3.48601267e-02f, -8.06606188e-02f, -1.90184996e-01f, 3.89165222e-03f, -1.12513125e-01f, -4.08860296e-02f, -1.65709443e-02f, 5.27305454e-02f, 2.74818321e-03f, -2.03423556e-02f,
  -1.59950983e-02f, 4.86876741e-02f, 3.74707766e-02f, 6.84754774e-02f, -6.60494249e-03f, -1.25849798e-01f, 7.89683163e-02f, 4.80114468e-05f, -4.74374630e-02f, -4.99931201e-02f,
  -8.55087340e-02f, -1.11352131e-02f, -5.16642295e-02f, -2.37790551e-02f, -5.34471050e-02f, -4.33033556e-02f, 2.92712413e-02f, -4.61666025e-02f, -9.03226361e-02f, 3.62084694e-02f,
  -1.98945608e-02f, -4.67214584e-02f, -5.98380156e-02f, 5.71781099e-02f, -1.00704111e-01f, 1.61320402e-03f, -4.73113880e-02f, 4.24863286e-02f, -1.47654181e-02f, 5.12187555e-02f,
  9.16647899e-04f, 2.76182126e-02f, -5.64667434e-02f, 3.64246964e-03f, 3.80916893e-02f, 2.41713822e-02f, -2.60956381e-02f, -2.37325951e-02f, 1.20767668e-01f, 1.39062017e-01f,
  -7.37611651e-02f, 1.52656045e-02f, -2.12424924e-03f, -4.14634906e-02f, -7.50580244e-03f, 6.96437284e-02f, -4.24339883e-02f, 7.55760632e-03f, -7.34871328e-02f, -6.49441555e-02f,
  -5.81916943e-02f, -6.36973754e-02f, -3.33134048e-02f, -4.27567028e-02f, 1.59669500e-02f, -5.84614351e-02f, 1.94758788e-04f, 4.43111770e-02f, 1.18252330e-01f, 9.10520740e-03f,
  1.53444353e-02f, -2.23929528e-02f, -3.86052858e-03f, -1.16987927e-02f, 1.31472498e-01f, -3.14258672e-02f, -1.63444616e-02f, -4.82012294e-02f, -5.76130077e-02f, -1.01004899e-01f,
  1.26215126e-02f, 2.76840981e-02f, 9.98752043e-02f, -2.98717786e-02f, -1.71902068e-02f, -3.90675515e-02f, -2.28123385e-02f, 2.09658127e-02f, -2.02305466e-02f, -1.66175421e-02f,
  2.85162143e-02f, -1.47008169e-02f, -3.78288552e-02f, 1.31361172e-01f, 1.76448580e-02f, -5.97453713e-02f, -1.48601800e-01f, 1.60244107e-01f, -1.09407693e-01f, -4.05208841e-02f,
  1.65527865e-01f, 2.72003375e-02f, -1.19049869e-01f, 3.26233894e-01f, 1.92244112e-01f, -4.13800813e-02f, 1.78916961e-01f, -4.60155221e-04f, -8.37370679e-02f, 8.63722041e-02f,
  1.42598107e-01f, 2.46507227e-01f, 1.58701628e-01f, 2.15604201e-01f, 1.34850278e-01f, 1.27813086e-01f, 2.65354365e-01f, 8.51644855e-03f, 2.98522115e-01f, 1.60421148e-01f,
  -6.67060763e-02f, 2.23203562e-02f, -2.52689831e-02f, -1.15622692e-02f, -2.78834403e-02f, -3.95489186e-02f, -6.74201846e-02f, -1.27511388e-02f, -9.09635914e-04f, -3.64544019e-02f,
  -2.66838670e-02f, 2.02362239e-02f, 1.91763714e-02f, 2.43796259e-02f, -5.58360554e-02f, 2.00710688e-02f, -6.50965795e-02f, 1.13117341e-02f, -8.13324526e-02f, -8.60305429e-02f,
  -1.00905187e-01f, -2.61253100e-02f, -4.43821959e-02f, -1.14927106e-02f, 3.49069797e-02f, 2.71532666e-02f, -2.40760902e-03f, -4.92788898e-03f, -3.22855487e-02f, 8.83929152e-03f,
  -4.48580645e-02f, 6.57709129e-03f, -6.98299706e-02f, -4.44389582e-02f, -4.06350680e-02f, -1.52531927e-02f, -2.72824708e-02f, -5.47480956e-02f, -6.62197694e-02f, -2.88960058e-02f,
  4.88395356e-02f, -4.58117574e-02f, -4.05186825e-02f, -1.35725806e-03f, 4.64028306e-03f, -1.59739181e-02f, -5.13419546e-02f, 5.87423369e-02f, -3.79382931e-02f, -8.73589702e-03f,
  -4.92848344e-02f, 1.81393679e-02f, 1.55192902e-04f, 3.00970301e-02f, 4.92440760e-02f, 5.29836528e-02f, 6.25701249e-02f, -3.83204035e-02f, -6.86302839e-04f, -6.77087158e-02f,
  9.71018150e-02f, 1.13786101e-01f, -1.75796188e-02f, 3.46251093e-02f, -2.76804585e-02f, -1.08059086e-01f, 2.90933400e-02f, -2.14044135e-02f, -1.88466249e-04f, -1.42100761e-02f,
  -2.80867852e-02f, -1.68688092e-02f, 6.60935566e-02f, 2.10836791e-02f, 1.33903906e-01f, -2.74897646e-02f, 7.28462115e-02f, -4.16698381e-02f, 5.54504544e-02f, 5.91059662e-02f,
  4.80696298e-02f, -9.53032598e-02f, -6.13107570e-02f, -4.93697934e-02f, 6.36287555e-02f, 1.13953482e-02f, -6.55459147e-03f, -6.91525266e-02f, -8.50425847e-03f, -4.46074232e-02f,
  -2.52704203e-01f, 9.06381011e-02f, -2.79973820e-02f, -2.04322353e-01f, 5.53742647e-02f, -1.30381167e-01f, -1.26911074e-01f, 5.78790456e-02f, 3.64069338e-03f, 1.39817297e-01f,
  2.52659116e-02f, 4.27028611e-02f, 9.53136683e-02f, -3.16677988e-01f, -3.73243183e-01f, -2.59693801e-01f, -3.24952006e-01f, -2.45176360e-01f, -1.20968230e-01f, -1.57663107e-01f,
  -2.09715739e-01f, -2.63386905e-01f, -2.82620847e-01f, -2.59480276e-03f, 6.59130514e-02f, 1.47585586e-01f, 6.45051822e-02f, 1.54697523e-01f, -3.34381610e-02f, -5.90457544e-02f,
  -3.26081589e-02f, 3.74804512e-02f, 9.11048874e-02f, 1.94391813e-02f, 3.72293517e-02f, 4.61659841e-02f, -1.38253607e-02f, -1.37146311e-02f, 1.20615058e-01f, -7.53851160e-02f,
  5.05937114e-02f, 1.36369094e-02f, -9.13861617e-02f, 3.51998284e-02f, -1.20144403e-02f, 3.57853360e-02f, -4.30935547e-02f, 3.52962525e-04f, 3.37040648e-02f, 1.04369540e-02f,
  -5.14300354e-02f, -5.12398295e-02f, 8.43378133e-04f, -1.18921950e-01f, -2.00179331e-02f, 8.99016112e-02f, -6.33978173e-02f, 3.11022867e-02f, 2.23396756e-02f, -3.24065723e-02f,
  -6.81675300e-02f, -5.72974458e-02f, -3.55843268e-02f, 7.27919489e-02f, 3.84987295e-02f, 7.27280006e-02f, -2.58330368e-02f, -3.29836868e-02f, -2.71108747e-03f, -4.21682112e-02f,
  -1.43823158e-02f, 5.83103858e-02f, -6.14648983e-02f, -2.36191042e-02f, -5.36051504e-02f, 3.84604355e-05f, -1.21812314e-01f, 1.63069263e-03f, -1.12309968e-02f, 8.77555013e-02f,
  5.35540469e-02f, -4.48057353e-02f, 4.85961735e-02f, 6.04401343e-03f, -1.01942653e-02f, -2.43646875e-02f, 1.88673586e-02f, -7.39293620e-02f, -3.35995592e-02f, -3.04351393e-02f,
  7.28074685e-02f, -1.37096475e-04f, 1.14443816e-01f, -3.52770090e-02f, 9.83434394e-02f, 9.08299256e-03f, -1.64548621e-01f, -2.15709116e-02f, -4.72701937e-02f, -9.65207070e-03f,
  3.75475152e-03f, -2.62981057e-02f, 8.24023038e-02f, -5.21543510e-02f, 1.44325290e-02f, 3.04236561e-02f, -3.75269540e-02f, 5.44029810e-02f, 3.24025378e-02f, 4.28804196e-03f,
  4.17478532e-02f, 9.37898383e-02f, -1.44100422e-02f, -5.94852567e-02f, 5.11997985e-03f, 1.02230333e-01f, 3.87845607e-03f, 1.05617968e-02f, -2.85426974e-02f, 1.60185453e-02f,
  1.45430431e-01f, -3.07936016e-02f, -8.27296749e-02f, 1.69578239e-01f, -1.18557677e-01f, -1.35912463e-01f, -2.09521905e-01f, 1.30740171e-02f, -1.09044664e-01f, -1.37938336e-01f,
  2.68094074e-02f, -1.06499180e-01f, -4.74454984e-02f, 2.22238496e-01f, 2.25356534e-01f, 4.73367311e-02f, 9.24130157e-02f, -4.79504876e-02f, -6.43420126e-03f, 1.21653654e-01f,
  9.29128230e-02f, 1.92481026e-01f, 1.64170697e-01f, 1.63343877e-01f, 1.07683204e-01f, 1.08747438e-01f, 2.07237437e-01f, 2.94680111e-02f, 1.70317322e-01f, 7.09991232e-02f,
  1.70511175e-02f, -4.00963565e-03f, -6.44472893e-03f, -3.91870290e-02f, 8.13696086e-02f, 2.57187849e-03f, -2.73627304e-02f, 7.24975020e-02f, -4.43322212e-03f, 8.76638219e-02f,
  -1.04704425e-01f, 6.19562641e-02f, 2.13113073e-02f, 5.18735237e-02f, -5.15897106e-03f, 4.34479564e-02f, -7.26388246e-02f, -6.29400983e-02f, -7.00063035e-02f, 9.88067407e-03f,
  -2.05708575e-02f, 2.99130045e-02f, 4.47902381e-02f, -1.12976059e-02f, -6.36595115e-03f, -3.03904898e-03f, -9.33019146e-02f, -3.56116183e-02f, -3.18297185e-02f, 5.57512902e-02f,
  -8.74507707e-03f, -8.26375186e-03f, -5.00778072e-02f, 3.00277602e-02f, 2.77632382e-02f, 2.56966893e-03f, -1.00381702e-01f, -5.92092751e-03f, -2.19047107e-02f, 8.54042768e-02f,
  4.20132047e-03f, 6.64512219e-04f, -6.11274205e-02f, -8.38770717e-03f, 3.21989991e-02f, -7.66581371e-02f, 6.88736141e-02f, 6.73238933e-03f, 1.13813523e-02f, -3.85347158e-02f,
  3.33614983e-02f, 5.61706796e-02f, 4.42014448e-02f, -2.72480045e-02f, 2.63627414e-02f, -4.25955914e-02f, 4.52297516e-02f, -3.57516808e-03f, -4.09758016e-02f, -7.08840638e-02f,
  9.06009898e-02f, 1.69465601e-01f, 1.27170272e-02f, 1.98296793e-02f, 2.05046162e-02f, 4.52794135e-02f, 7.53707718e-03f, 6.14505522e-02f, 5.50657697e-02f, 1.65215302e-02f,
  1.08757173e-03f, -2.51499284e-02f, 6.20876160e-03f, -6.23910688e-03f, 4.28827219e-02f, 2.41560442e-03f, 3.92195098e-02f, 1.88173093e-02f, 8.14275816e-02f, -3.33174951e-02f,
  -6.27068663e-03f, -5.75716868e-02f, 3.90950814e-02f, -6.01931959e-02f, -4.30961028e-02f, -9.77356806e-02f, 1.01873567e-02f, -1.09918863e-01f, 4.58373036e-03f, 4.98619229e-02f,
  1.74812432e-02f, -4.49380040e-01f, 1.39233142e-01f, 5.11534065e-02f, 1.19368188e-01f, -1.26571059e-01f, 1.55307740e-01f, -2.75503576e-01f, -1.52034625e-01f, -2.98833668e-01f,
  5.89828901e-02f, 1.04398213e-01f, 9.58657786e-02f, -1.52321979e-01f, 4.51774120e-01f, 3.23175229e-02f, -1.25338003e-01f, -5.61596937e-02f, -6.68664426e-02f, -7.30504915e-02f,
  1.44094918e-02f, -1.04503155e-01f, 6.49693161e-02f, -3.05765748e-01f, -4.52122800e-02f, -1.67800859e-01f, 1.38263330e-01f, 6.55292198e-02f, -8.89812112e-02f, 1.57051682e-01f,
  -9.86072719e-02f, -1.76461637e-01f, -2.93630138e-02f, -4.01473567e-02f, -9.70641077e-02f, 5.64790554e-02f, 1.50135448e-02f, 1.41629189e-01f, 2.65872423e-02f, 4.79614623e-02f,
  6.29393384e-02f, 2.28921212e-02f, -1.06436037e-01f, -3.11540291e-02f, -6.16446882e-02f, -2.63214931e-02f, -2.63104588e-03f, -1.69567391e-02f, -2.15947125e-02f, -6.26185462e-02f,
  2.56108232e-02f, 1.10297026e-02f, -1.70758329e-02f, 3.61138186e-03f, 3.77703123e-02f, 8.65669828e-03f, 2.02826969e-02f, 1.19782954e-01f, -4.26684842e-02f, -4.19768244e-02f,
  -1.36769831e-01f, -2.70207748e-02f, -1.84397437e-02f, -2.70821042e-02f, 1.62738673e-02f, 1.10189216e-02f, -9.93720666e-02f, 1.52138080e-02f, 1.76543056e-03f, -2.37845983e-02f,
  -6.95229508e-03f, 2.32988503e-02f, 1.77161433e-02f, 6.46278411e-02f, -7.29045197e-02f, -2.21915524e-02f, 3.80099826e-02f, 2.41362629e-03f, 2.85359155e-02f, -1.44872302e-02f,
  -4.76271351e-04f, 2.61053871e-02f, -7.64703844e-03f, 3.60291824e-02f, -8.77925567e-03f, 4.32144888e-02f, -2.32887659e-02f, -2.72606518e-02f, 2.22571120e-02f, 7.13214949e-02f,
  -2.50622630e-01f, -2.44118318e-01f, -8.45725164e-02f, -4.46223021e-02f, -1.06010605e-02f, 7.35071488e-03f, 1.16125969e-02f, -1.18631020e-01f, -8.24048296e-02f, -1.67202372e-02f,
  -2.87996531e-02f, 3.69668715e-02f, -6.72181249e-02f, 2.51074843e-02f, -6.81470037e-02f, -5.85640222e-02f, -1.56193748e-02f, -2.47081332e-02f, -1.95019022e-02f, 2.06452031e-02f,
  -2.45405808e-02f, -5.37742525e-02f, 7.22525790e-02f, -5.44392616e-02f, -2.98788492e-02f, 5.50096706e-02f, 9.38747637e-03f, -3.46737951e-02f, 4.49602157e-02f, -1.14598498e-02f,
  -3.70048702e-01f, 6.78439364e-02f, -1.19647002e-02f, -2.58153051e-01f, 3.28809917e-02f, 4.37054746e-02f, -1.41327996e-02f, 8.71077701e-02f, -1.38962135e-01f, 1.75947934e-01f,
  2.28227943e-01f, -2.08317623e-01f, 1.37163609e-01f, -1.46658584e-01f, -3.19593400e-01f, -5.88616543e-02f, -1.23458818e-01f, -1.84291638e-02f, -1.63403619e-02f, 1.14404643e-02f,
  -1.69788107e-01f, 5.54611124e-02f, -1.19226854e-02f, 2.26165175e-01f, -6.17684424e-02f, 1.92975625e-02f, 1.10499159e-01f, 1.60699800e-01f, -2.95064859e-02f, 6.28367439e-03f,
  -1.74606014e-02f, 7.72880986e-02f, 6.76264763e-02f, -4.99439314e-02f, 2.91093625e-02f, 1.79709382e-02f, -5.62363630e-03f, 2.02961899e-02f, 1.26667386e-02f, -1.40562635e-02f,
  -3.28800678e-02f, 3.13034579e-02f, -9.66978166e-03f, 2.22513974e-02f, 9.02595185e-03f, 2.73733940e-02f, -8.38817209e-02f, -5.60698211e-02f, 6.92408020e-03f, -5.55386804e-02f,
  5.46975285e-02f, 3.58156301e-02f, -1.48754761e-01f, -1.43357785e-02f, -1.32362396e-01f, 6.98155537e-02f, -1.35814473e-02f, 2.70043854e-02f, 1.92845450e-03f, -3.81151885e-02f,
  -1.05275288e-01f, 5.36499824e-03f, 5.51916212e-02f, -3.03795212e-03f, -8.81008245e-03f, 8.06708187e-02f, -1.00425899e-01f, 5.56709282e-02f, -1.44909188e-01f, -4.27469574e-02f,
  -7.28030354e-02f, -1.14135645e-01f, 2.54662242e-02f, -5.74413054e-02f, -1.18771836e-01f, -5.89067340e-02f, -1.23101221e-02f, -9.03763343e-03f, -9.01603401e-02f, 6.60415888e-02f,
  9.71000567e-02f, -4.52479422e-02f, 3.03633157e-02f, 1.57710109e-02f, 1.23942330e-01f, -1.40850851e-02f, -3.54435220e-02f, 5.89972362e-02f, 1.08360976e-01f, -5.95615841e-02f,
  8.29014853e-02f, 1.16999902e-01f, 1.06335454e-01f, 8.73603076e-02f, 4.50840872e-03f, -2.88091414e-02f, -2.85151484e-03f, -1.03007607e-01f, -6.72853962e-02f, -8.52374882e-02f,
  -3.35300975e-02f, 5.02157304e-03f, -9.02993828e-02f, -8.66906997e-03f, -3.46361250e-02f, 7.27385953e-02f, 1.07316405e-01f, -1.00475852e-03f, 4.40079570e-02f, 4.29024287e-02f,
  2.86108516e-02f, 4.75108400e-02f, -7.46627450e-02f, 5.29013276e-02f, -4.03563641e-02f, -6.49239123e-02f, 2.72892732e-02f, 9.43815261e-02f, -6.22605644e-02f, 2.61895228e-02f,
  -7.41603449e-02f, 1.82906247e-03f, 4.88583967e-02f, -2.09746376e-01f, -2.80816182e-02f, -4.15966175e-02f, -1.67082012e-01f, -7.55945966e-02f, -1.88165963e-01f, -1.26439109e-01f,
  -2.10446179e-01f, 2.22481817e-01f, 1.29425600e-01f, -1.95699930e-01f, 2.26563886e-01f, -1.55651597e-02f, -2.30773360e-01f, -4.43403684e-02f, 2.04512011e-02f, -1.88163668e-01f,
  -1.09957024e-01f, -2.81742066e-01f, 1.20575540e-01f, -1.20927498e-01f, -1.03091516e-01f, -1.76639315e-02f, 4.75122258e-02f, -7.01259375e-02f, -5.66649921e-02f, -2.26638224e-02f,
  -5.66540472e-02f, -3.08560908e-01f, 6.99951202e-02f, 4.04501185e-02f, 3.14535154e-03f, 4.48471606e-02f, -1.06140580e-02f, 6.23882785e-02f, -2.85658091e-02f, 8.43217783e-03f,
  9.62738991e-02f, 6.32935613e-02f, -1.06078321e-02f, 4.27003019e-03f, -1.14747241e-01f, -2.00226456e-02f, 2.26089321e-02f, 2.78151315e-02f, 4.39112298e-02f, 1.06710084e-01f,
  1.70642570e-01f, 3.92711684e-02f, -8.18705484e-02f, -4.43096738e-03f, 2.07802448e-02f, -4.32178155e-02f, 3.16353589e-02f, 1.40801296e-01f, -5.66674769e-02f, -5.95740527e-02f,
  4.62518893e-02f, -1.86795928e-02f, -9.04016476e-03f, 1.45031046e-03f, -1.20924609e-02f, -1.68741941e-02f, 7.20899999e-02f, -1.50402896e-02f, 2.25793812e-02f, 2.83731311e-03f,
  -5.27169183e-03f, -1.35335242e-02f, -3.74327898e-02f, -5.96828274e-02f, -9.51981470e-02f, -3.61471064e-02f, 7.23220408e-02f, 1.73608381e-02f, 5.95605001e-02f, 3.86560196e-03f,
  -8.74984637e-03f, -4.23125587e-02f, 1.12252356e-02f, -4.23725247e-02f, -3.89987342e-02f, 8.07748213e-02f, 9.03116260e-03f, 1.07696071e-01f, -9.60206091e-02f, 4.27750126e-02f,
  2.35034283e-02f, -3.21589440e-01f, -1.78688187e-02f, 1.79817993e-02f, 6.93747923e-02f, 1.71133988e-02f, -8.06586891e-02f, 6.26253290e-03f, -1.38540685e-01f, -1.50643317e-02f,
  -1.28702536e-01f, -7.66862975e-03f, 3.08385212e-02f, 5.58575802e-02f, 1.23263914e-02f, 1.24476068e-02f, -7.54077435e-02f, 1.97439883e-02f, -1.82491057e-02f, 5.17521286e-03f,
  9.75341499e-02f, 7.85785913e-02f, 9.81983766e-02f, -3.43032703e-02f, -1.13580838e-01f, -6.08810559e-02f, 1.67771485e-02f, 8.97690579e-02f, 7.19159618e-02f, 1.23997824e-02f,
  2.50086129e-01f, 2.69199342e-01f, 3.09285909e-01f, 2.76930947e-02f, -4.76813912e-02f, -1.88492343e-01f, -1.59006894e-01f, -5.22969365e-02f, -1.44289896e-01f, 1.93333160e-02f,
  -1.18593983e-01f, 1.78408340e-01f, -1.69189572e-01f, -7.57433623e-02f, -4.09075290e-01f, -3.34157407e-01f, -1.25034899e-01f, -5.23422249e-02f, -9.12518203e-02f, 9.64034870e-02f,
  -9.58709642e-02f, -2.08178043e-01f, 5.69833703e-02f, -6.86149895e-02f, 2.20249951e-01f, 2.57446408e-01f, -7.37184957e-02f, 2.85414569e-02f, 1.60652235e-01f, -1.49327412e-01f,
  -8.45718980e-02f, -1.30776502e-02f, 1.51033312e-01f, 3.11747529e-02f, -7.07526086e-03f, 4.23090868e-02f, 8.28598887e-02f, -5.33084609e-02f, 2.18763202e-03f, -2.14616256e-03f,
  6.01021610e-02f, -6.49345433e-03f, -4.34041508e-02f, -1.10551856e-01f, 1.02000304e-01f, -5.03390888e-03f, 2.36948449e-02f, 7.96776488e-02f, 7.54281122e-04f, 6.32178858e-02f,
  8.42012018e-02f, 4.38065827e-02f, 8.57272446e-02f, -6.14933334e-02f, -3.61291389e-03f, -3.86071429e-02f, -2.40072957e-03f, 1.13024563e-02f, -1.60297751e-02f, 3.61702144e-02f,
  8.73657316e-02f, -1.52094197e-02f, 5.50481118e-02f, -8.44007079e-03f, -1.54015571e-02f, -1.44433724e-02f, -5.78207485e-02f, -1.94941740e-02f, -1.78233571e-02f, 5.41789178e-03f,
  -9.32923183e-02f, 5.11252545e-02f, -2.49010511e-02f, 8.06382075e-02f, 7.84487128e-02f, -4.93798265e-03f, 2.66523324e-02f, 2.30430793e-02f, 1.05450429e-01f, -7.39077255e-02f,
  -7.60322111e-03f, -1.30978795e-02f, 1.06932275e-01f, 5.08602113e-02f, -1.01826496e-01f, 5.48738427e-02f, -3.68434042e-02f, 5.88644296e-02f, -6.64532334e-02f, -5.77922314e-02f,
  1.59781706e-02f, 1.45430248e-02f, -2.85535250e-02f, -5.49841449e-02f, -5.87628074e-02f, -5.91985695e-02f, -4.55418862e-02f, 1.80579554e-02f, 1.35281039e-02f, -7.88687915e-02f,
  1.15015239e-01f, 5.54617308e-02f, -1.80501323e-02f, 5.68740591e-02f, -8.39987621e-02f, -7.16668889e-02f, 5.03879003e-02f, -1.53037347e-02f, 7.97362346e-03f, 6.94896095e-03f,
  1.41711265e-01f, 7.01795816e-02f, -3.30331773e-02f, -5.46261519e-02f, 4.70361896e-02f, 3.50031480e-02f, 6.42981306e-02f, 9.84094664e-02f, 4.28168243e-03f, 5.87442368e-02f,
  -5.30543141e-02f, -2.00770721e-01f, 1.71165690e-01f, -7.77822733e-02f, 7.95027763e-02f, 2.04332054e-01f, 2.40040541e-01f, -1.72422558e-01f, 4.85535972e-02f, -2.00140774e-01f,
  -8.23256150e-02f, 5.21859794e-04f, 1.48860902e-01f, -3.26859415e-01f, 3.68314922e-01f, 2.12338895e-01f, -8.91267806e-02f, -6.91822544e-02f, -3.08476072e-02f, -1.40609801e-01f,
  -1.65530160e-01f, -3.02809268e-01f, 3.45755741e-02f, -2.89242327e-01f, -1.98862925e-01f, -1.49801806e-01f, -7.62987584e-02f, 1.05231732e-01f, -1.13230720e-01f, 6.51477426e-02f,
  6.98289275e-02f, -3.29526402e-02f, 4.02570404e-02f, 1.42855775e-02f, -4.18058783e-02f, 5.39796762e-02f, -2.45673303e-02f, 9.36447904e-02f, 5.33020869e-02f, 5.36507070e-02f,
  -5.79874888e-02f, -3.03877238e-02f, -2.83934511e-02f, -8.00765958e-03f, 5.77818900e-02f, -2.02390552e-02f, 1.16235241e-02f, -8.02373812e-02f, 1.78132672e-02f, 3.30066681e-02f,
  -1.55401723e-02f, -3.22067998e-02f, -7.03244507e-02f, -1.37521094e-02f, -4.53188270e-02f, 6.00959584e-02f, -6.81466935e-03f, 2.50928942e-02f, 3.43002379e-02f, 5.60143888e-02f,
  1.54959494e-02f, 8.23414102e-02f, 3.48619968e-02f, -2.58605201e-02f, 4.33346070e-02f, -7.62250125e-02f, -1.14801601e-02f, -8.62820074e-03f, -3.75377648e-02f, -3.45341042e-02f,
  -7.35900998e-02f, -7.68038630e-02f, 1.26220414e-03f, -3.81392688e-02f, 1.35077406e-02f, -7.00902715e-02f, -6.02716357e-02f, 1.08571146e-02f, -9.71717834e-02f, 3.45787071e-02f,
  7.44043067e-02f, 3.69460694e-02f, -3.70069668e-02f, -3.61973536e-03f, -2.48813513e-03f, 1.00953896e-02f, -1.26061246e-01f, -2.42525581e-02f, 7.58374780e-02f, -4.00921851e-02f,
  9.19781700e-02f, 6.83983415e-02f, -1.34818461e-02f, -1.99219789e-02f, 2.12425943e-02f, -5.71054332e-02f, 3.56507264e-02f, -7.34121958e-03f, 1.41525328e-01f, -1.14095032e-01f,
  -1.01005636e-01f, -2.05901060e-02f, -6.67959685e-03f, 3.20995376e-02f, 1.06319925e-02f, 1.96285397e-02f, 5.18215895e-02f, 7.03857839e-02f, 2.43565328e-02f, -4.91806157e-02f,
  -9.80568603e-02f, 6.09876327e-02f, -5.47005460e-02f, -4.08495925e-02f, -8.62315893e-02f, -1.62629485e-02f, -2.53861044e-02f, -4.00294103e-02f, -5.28363399e-02f, 4.08398360e-02f,
  -6.38043344e-01f, 1.28214255e-01f, 2.02972427e-01f, -7.96589777e-02f, 3.95531580e-02f, 1.61352411e-01f, 1.84806913e-01f, 3.50891389e-02f, -5.22738732e-02f, 1.02184370e-01f,
  1.78648502e-01f, -1.09935582e-01f, 1.12133466e-01f, 5.68971736e-03f, -7.50001073e-02f, 6.60285645e-04f, -4.21049856e-02f, -2.75483094e-02f, -9.58900712e-03f, -1.13642946e-01f,
  -8.40932876e-02f, 4.06132825e-02f, 6.37504086e-02f, 8.73960555e-02f, -1.19260609e-01f, -2.72241794e-02f, -7.95009807e-02f, 1.25316605e-01f, 2.83712838e-02f, 5.92145659e-02f,
  -1.93008929e-01f, -1.84071258e-01f, -2.07176179e-01f, -1.09033071e-01f, -7.48107135e-02f, -5.39844483e-02f, -9.12881941e-02f, 6.49951547e-02f, -1.61647145e-02f, 6.21850491e-02f,
  -1.97931603e-02f, 5.43999001e-02f, 6.20347587e-03f, -9.36238840e-03f, -8.06801170e-02f, -1.53187045e-03f, 9.22492966e-02f, 3.94015871e-02f, 6.12654760e-02f, 2.10964680e-02f,
  6.37219846e-02f, 3.73115577e-02f, 5.57626151e-02f, -2.64839400e-02f, -3.92916240e-02f, 7.66979456e-02f, -5.57071390e-03f, -1.18676305e-01f, 9.27860383e-03f, -3.38203199e-02f,
  -1.12399608e-02f, -4.39359900e-03f, 3.00762150e-02f, 8.72109085e-02f, 8.97249803e-02f, -2.96191666e-02f, -6.75717667e-02f, -1.72242485e-02f, 2.55626943e-02f, 1.04634121e-01f,
  -1.73361488e-02f, -4.13062572e-02f, -1.26551852e-01f, -7.05120191e-02f, 4.68002558e-02f, -3.14887203e-02f, -2.40118559e-02f, -2.51828954e-02f, 3.03579844e-03f, -2.69440990e-02f,
  -2.40758713e-02f, 8.02138746e-02f, 2.78399512e-02f, 2.39238497e-02f, -4.75119315e-02f, -1.10206641e-01f, -1.54382819e-02f, -9.08716992e-02f, -5.41816503e-02f, 1.21916933e-02f,
  -2.63675064e-01f, -2.35140115e-01f, -1.98900467e-03f, -3.49432491e-02f, -4.14727479e-02f, -3.06275915e-02f, -4.25063707e-02f, -1.27263919e-01f, -2.97286697e-02f, -1.12599751e-03f,
  4.77571152e-02f, -1.43868893e-01f, -6.43626228e-02f, -2.33472354e-04f, -3.94478850e-02f, 5.60254883e-03f, -1.22587740e-01f, -6.74675405e-02f, -5.82674704e-02f, 3.72723527e-02f,
  -1.42859453e-02f, 1.33821284e-02f, 6.95607588e-02f, -2.93890554e-02f, 2.47928221e-02f, 7.71389669e-03f, -1.29512817e-01f, -1.73160117e-02f, -3.26674618e-02f, -2.56015584e-02f,
  2.08422199e-01f, -2.36769706e-01f, -1.19250335e-01f, -2.63121668e-02f, 8.08707401e-02f, 2.20559031e-01f, 1.24403708e-01f, -2.02368155e-01f, -3.26872766e-01f, -1.21177137e-01f,
  5.32823168e-02f, 2.75142286e-02f, 7.86103159e-02f, 1.19417854e-01f, 3.77846450e-01f, -2.78518889e-02f, 1.21930689e-01f, 1.62057862e-01f, -1.60987318e-01f, 1.35585265e-02f,
  -2.73699444e-02f, 2.58301675e-01f, -2.75382604e-02f, 1.11381486e-01f, 1.70666814e-01f, -1.35719255e-01f, 6.16510920e-02f, 7.74447843e-02f, 8.92155319e-02f, 1.74620524e-01f,
  9.03533474e-02f, -1.60410684e-02f, 2.34298185e-02f, 1.76046453e-02f, -3.52266356e-02f, 3.72774899e-02f, 6.41006827e-02f, 2.30331793e-01f, 3.07515077e-02f, -5.74143678e-02f,
  2.33676825e-02f, 1.74656548e-02f, 3.80510651e-02f, 4.44693351e-03f, 4.48574778e-03f, -1.70826875e-02f, -7.74479806e-02f, 4.71273117e-04f, -1.00228898e-01f, 1.83728971e-02f,
  -5.38236052e-02f, 8.82778913e-02f, -2.60151755e-02f, 2.01921910e-02f, 1.11205736e-02f, 2.30916366e-02f, 7.45392917e-03f, -3.21637504e-02f, 2.56534293e-02f, -1.09820418e-01f,
  9.97884050e-02f, 2.61870045e-02f, 5.35167232e-02f, -2.17823777e-02f, 4.62079458e-02f, 8.93229991e-03f, 3.16265859e-02f, 4.96942848e-02f, -4.50392067e-02f, -6.40271679e-02f,
  -1.51088443e-02f, 2.52606086e-02f, -4.50890586e-02f, 1.59100629e-02f, -7.27347583e-02f, -6.44853571e-03f, 2.92550214e-02f, -8.58043581e-02f, -1.30267724e-01f, -6.88063800e-02f,
  -3.71041009e-04f, 3.31922830e-03f, 1.12944590e-02f, -1.22510723e-03f, 1.02342740e-01f, -4.98169027e-02f, -1.31761553e-02f, -2.14125328e-02f, -6.03514314e-02f, 9.14861187e-02f,
  -1.20901153e-03f, -1.13352910e-01f, -2.97386479e-02f, 6.65682852e-02f, -6.03342839e-02f, -2.20160037e-02f, 6.73718145e-03f, -1.65049899e-02f, -3.40046771e-02f, 1.36540802e-02f,
  6.65267706e-02f, 5.00257052e-02f, -5.19205518e-02f, -3.68433930e-02f, 1.77045316e-02f, -9.69794169e-02f, 2.86496561e-02f, 1.39047978e-02f, 7.96396583e-02f, -2.78262403e-02f,
  -9.55445785e-03f, 1.31886983e-02f, -3.41452882e-02f, 3.00257020e-02f, -2.84689255e-02f, 2.68923827e-02f, 4.48878808e-03f, -5.50047401e-03f, 2.46072058e-02f, -7.07399053e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.12670444e-01f, 8.16799775e-02f, 1.49254844e-01f, 7.35829100e-02f, 4.24222127e-02f, 3.69905144e-01f, 1.56120822e-01f, 1.88528374e-01f, 1.96972489e-01f, 1.74992621e-01f,
  1.05654225e-01f, 8.71571600e-02f, 1.39625490e-01f, 1.25938848e-01f, 1.16644606e-01f, 8.68108347e-02f, 5.40751405e-02f, 3.06105852e-01f, 1.31291719e-02f, 1.82687089e-01f,
  9.74667072e-02f, 2.15986788e-01f, 2.47184590e-01f, 3.95207405e-01f, 2.23125041e-01f, 2.62440890e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.73748016e-01f, -3.68480831e-02f, 6.70892522e-02f, -1.26872063e-01f, -1.08086273e-01f, -6.41498566e-02f, -1.29763484e-01f, 2.77387291e-01f, 1.84823126e-01f, -2.03010201e-01f,
  2.16728956e-01f, 3.05293381e-01f, 5.66813834e-02f, 1.88322425e-01f, -1.90223768e-01f, 4.87998240e-02f, 6.06585070e-02f, -2.86229730e-01f, -9.87346247e-02f, 2.76797026e-01f,
  5.95961139e-02f, 1.66823700e-01f, -1.22897141e-02f, -3.21242213e-02f, 1.60506830e-01f, -2.09486231e-01f, 1.23923421e-01f, -6.21631742e-02f, 4.20148931e-02f, -1.13241458e-02f,
  1.00719646e-01f, -3.71779203e-01f, -6.09723926e-02f, 1.29696488e-01f, 9.72092152e-02f, -3.44977044e-02f, 1.93340424e-02f, -8.25597942e-02f, -1.56187221e-01f, 2.67135520e-02f,
  1.58471212e-01f, -6.79313838e-02f, 4.08435076e-01f, 6.13112263e-02f, -1.85990587e-01f, 1.16699934e-01f, -1.73262581e-01f, 1.26309723e-01f, -1.04552969e-01f, -1.59844160e-01f,
  2.93482840e-01f, 2.25903273e-01f, 2.76769400e-02f, 1.41081631e-01f, 1.21227195e-02f, 1.25753909e-01f, -4.23384383e-02f, -4.67747673e-02f, 2.69528832e-02f, -1.84226632e-01f,
  1.37539685e-01f, -1.40451849e-01f, -4.49903263e-03f, -1.41398430e-01f, 1.09996654e-01f, 1.17753074e-01f, -8.75992794e-03f, 1.79119095e-01f, -9.85800661e-03f, -1.47491368e-02f,
  1.59824029e-01f, 1.58097029e-01f, -1.32104605e-01f, 1.41699672e-01f, -1.86013192e-01f, 9.24205482e-02f, -1.33839041e-01f, -2.78283387e-01f, 1.45529071e-02f, -1.72454461e-01f,
  -1.30678311e-01f, 9.29205343e-02f, 6.72683343e-02f, 2.21735030e-01f, 1.82377025e-01f, -1.22182854e-01f, 1.95195019e-01f, -1.07664792e-02f, 1.11195445e-01f, -3.47018428e-02f,
  -1.60820276e-01f, -1.26296699e-01f, 2.37897620e-01f, -1.41941905e-01f, -1.57600805e-01f, -5.46654575e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  6.60345564e-03f, 1.38945237e-03f, 8.16761851e-02f, 1.96760312e-01f, 1.14141397e-01f, -1.13554411e-01f, 8.17347094e-02f, -6.42692745e-02f, -4.24510799e-02f, 1.52438834e-01f,
  -2.99517717e-02f, 1.33629039e-01f, -8.84835050e-02f, -1.45159392e-02f, 2.01817781e-01f, 1.67794917e-02f, -6.72973096e-02f, -2.30669100e-02f, 2.08533451e-01f, 5.94655387e-02f,
  1.85395390e-01f, 8.50759521e-02f, 1.60602212e-01f, -3.12149767e-02f, 5.50948344e-02f, 1.74537580e-02f, -6.90140203e-02f, -4.93573304e-03f, 1.83872536e-01f, 1.36858821e-01f,
  -1.08082913e-01f, 3.05124968e-01f, 1.19410478e-01f, 1.91697702e-02f, 2.04921514e-02f, 4.85127866e-02f, -4.92314342e-03f, -2.44717300e-02f, 1.31119089e-02f, 2.09334344e-01f,
  -8.05818439e-02f, 1.89876780e-01f, -2.22337171e-02f, -1.11033255e-03f, -1.98297173e-01f, -2.98903603e-02f, 1.70418903e-01f, -8.85359868e-02f, -6.11772761e-02f, 1.65532902e-03f,
  1.15822196e-01f, 1.95422322e-01f, 2.35047609e-01f, 2.07715780e-02f, 2.40289941e-01f, -9.20222234e-03f, 2.25066096e-01f, -1.34245291e-01f, -1.29272252e-01f, 9.25560761e-03f,
  2.58410424e-01f, -1.19370252e-01f, -4.33235653e-02f, 1.48660809e-01f, 2.11917788e-01f, 1.49516851e-01f, 1.90262750e-01f, 7.48374686e-02f, -3.04365188e-01f, 3.15442324e-01f,
  -1.00280307e-01f, -6.34617060e-02f, 1.34361669e-01f, -2.94676740e-02f, 3.34007055e-01f, 1.95781235e-03f, -1.78000331e-01f, 2.52242297e-01f, -1.20028369e-01f, 1.82122886e-01f,
  1.40814604e-02f, 1.49661507e-02f, 9.66177210e-02f, 1.58969671e-01f, 2.38768607e-02f, 6.12430498e-02f, -5.22612892e-02f, 2.84360647e-01f, -2.26682931e-01f, -4.65341546e-02f,
  3.30511779e-01f, -1.07379481e-01f, 3.01894188e-01f, -2.28811681e-01f, 4.66146953e-02f, -1.02507666e-01f, 9.66583639e-02f, 2.82527536e-01f, 3.80071282e-01f, 8.48844647e-02f,
  -2.13332117e-01f, 6.59749359e-02f, 7.91970789e-02f, 1.03218786e-01f, 1.68273643e-01f, -1.25347704e-01f, 4.79729399e-02f, 3.95196557e-01f, 2.26875603e-01f, 2.67883390e-02f,
  1.23786926e-01f, 2.42161453e-01f, 1.17666580e-01f, 6.38489127e-02f, -2.48681039e-01f, 2.34643236e-01f, -6.03014566e-02f, 1.04455888e-01f, -1.40454575e-01f, 3.17336440e-01f,
  -1.55451044e-01f, 1.16090588e-01f, 9.54580605e-02f, 4.16680515e-01f, 2.99121052e-01f, 2.59200275e-01f, 3.02124143e-01f, -1.54062258e-02f, -5.41200042e-02f, 1.60459012e-01f,
  3.19074392e-01f, -9.00179818e-02f, -1.73516218e-02f, -1.25005543e-01f, 1.07826572e-02f, 1.48152530e-01f, 3.41145903e-01f, -3.65897045e-02f, 1.23951390e-01f, 3.46479088e-01f,
  1.02666624e-01f, 2.56199062e-01f, -1.78826571e-01f, 2.87430525e-01f, 2.90360570e-01f, -2.35759720e-01f, 3.00414145e-01f, -5.24362028e-02f, -7.83923045e-02f, 2.17611387e-01f,
  1.29204094e-01f, 1.38969086e-02f, 5.10851294e-02f, 7.85066187e-02f, 5.51457293e-02f, 1.35344118e-01f, -2.10486650e-01f, 3.94017875e-01f, 3.96082997e-01f, 1.42400771e-01f,
  3.52922529e-01f, 1.05731227e-01f, 1.67227924e-01f, 3.92109901e-02f, -4.40236218e-02f, 1.61546141e-01f, 1.92735329e-01f, 1.16794005e-01f, -4.18849429e-03f, 1.41278446e-01f,
  1.75703183e-01f, -1.01231553e-01f, -5.97768687e-02f, -5.07640280e-02f, 1.36779100e-01f, -3.85521762e-02f, -1.92809641e-01f, 2.78027207e-01f, -3.49561349e-02f, 1.61694705e-01f,
  1.53607354e-01f, -2.18036901e-02f, 2.11003125e-01f, 9.84077752e-02f, 7.41957724e-02f, 3.91391635e-01f, -1.27183035e-01f, 4.78541702e-02f, 1.30878106e-01f, 2.21302882e-01f,
  -1.66025788e-01f, 1.11759514e-01f, 1.89197049e-01f, 7.98499137e-02f, 1.30435213e-01f, 8.69570524e-02f, -3.51720989e-01f, 2.02046618e-01f, -1.21935993e-01f, -1.15192302e-01f,
  9.31460038e-02f, -1.62372384e-02f, 2.87534267e-01f, -5.90815209e-02f, 1.02619812e-01f, 3.33692208e-02f, -5.95201785e-03f, -2.30519269e-02f, 3.43435407e-01f, 2.05302417e-01f,
  -1.24384664e-01f, 1.44103304e-01f, 2.24992763e-02f, -9.35301781e-02f, -1.02924407e-01f, 2.61345059e-01f, -2.18004972e-01f, -1.64521441e-01f, 3.34832013e-01f, 9.87825319e-02f,
  3.64345759e-01f, -1.48890555e-01f, 2.22228199e-01f, -1.09855294e-01f, 7.08068833e-02f, 5.70603239e-04f, -1.89970825e-02f, -1.04228459e-01f, 3.39620635e-02f, 3.00790966e-02f,
  1.84013546e-01f, 1.71247542e-01f, -3.06447572e-03f, 9.13454127e-03f, -1.78836286e-02f, -5.89893982e-02f, 1.09093174e-01f, 2.16445103e-02f, 1.76632643e-01f, -8.05857703e-02f,
  -1.60693809e-01f, 5.14619276e-02f, 1.44145370e-01f, 8.56833756e-02f, 3.26035321e-02f, -5.31921908e-02f, 1.90373972e-01f, -9.64501500e-02f, 1.72259986e-01f, 3.99680823e-01f,
  -2.44189739e-01f, -1.22343786e-02f, 2.41305400e-02f, 1.30743906e-01f, -6.52839392e-02f, 1.20438553e-01f, 2.27771878e-01f, 2.93234646e-01f, 7.55766109e-02f, 1.56856030e-01f,
  3.01546156e-01f, -1.19967856e-01f, 2.93234795e-01f, 4.07763347e-02f, -1.07743502e-01f, 2.19235897e-01f, -7.81588163e-03f, 1.92389086e-01f, 6.41909614e-02f, -1.00701541e-01f,
  3.60472172e-01f, -1.04012616e-01f, -1.63017482e-01f, 1.62763566e-01f, 1.02239214e-01f, -8.64156559e-02f, 2.27233507e-02f, -1.09317645e-01f, 3.35209891e-02f, 1.15003094e-01f,
  7.98116904e-03f, 3.04486424e-01f, -1.95705593e-01f, -4.11041789e-02f, 2.72613764e-02f, 2.30460465e-01f, -1.03892751e-01f, 1.78841949e-01f, 2.83071876e-01f, 3.02284569e-01f,
  8.05071443e-02f, 1.12681702e-01f, -1.92986410e-02f, -1.09251671e-01f, 2.28057250e-01f, 5.68171889e-02f, 4.68337908e-02f, 1.86309084e-01f, 1.40089631e-01f, 1.52475134e-01f,
  1.47003084e-01f, -3.78817506e-02f, 2.59618700e-01f, 8.36669877e-02f, -1.23429574e-01f, 2.28919074e-01f, 6.56707212e-02f, 2.23876119e-01f, 1.80133879e-01f, -9.04179588e-02f,
  4.46521454e-02f, 2.56286323e-01f, -5.49560133e-03f, 2.47000411e-01f, -1.42771184e-01f, 2.44814187e-01f, 1.55991137e-01f, 1.55461907e-01f, -2.27811709e-02f, 9.38322842e-02f,
  1.40516665e-02f, 2.31817469e-01f, 2.87674874e-01f, -1.58879548e-01f, 3.82456519e-02f, -2.85349879e-02f, -1.45614490e-01f, 2.83873916e-01f, 2.58804768e-01f, -2.21227258e-01f,
  6.94733635e-02f, 4.33668554e-01f, -7.03144372e-02f, 2.09712774e-01f, -9.67283621e-02f, 2.16208830e-01f, 9.83329937e-02f, -2.96239316e-01f, 7.42579326e-02f, 2.85941720e-01f,
  1.62116304e-01f, 2.79770553e-01f, 1.76600128e-01f, -1.38356164e-01f, 1.08222857e-01f, 2.24829707e-02f, 5.94991371e-02f, -3.12083960e-03f, 2.12025777e-01f, 1.31097967e-02f,
  2.95502637e-02f, -1.70877218e-01f, 1.33144140e-01f, 1.46973342e-01f, 1.56004786e-01f, -1.13379769e-01f, -2.62864083e-01f, 3.24385375e-01f, -9.95800942e-02f, 4.61808220e-03f,
  2.46385485e-01f, -4.05887235e-03f, 4.90230232e-01f, -1.47652164e-01f, -5.27239665e-02f, 2.07654819e-01f, 4.08438360e-03f, 2.20459819e-01f, 1.76898181e-01f, 1.05480552e-01f,
  1.40918016e-01f, 1.63211137e-01f, -6.94969073e-02f, 1.88287526e-01f, -2.64390279e-02f, 3.60397995e-01f, -2.78261136e-02f, -7.33650243e-03f, 2.64756083e-01f, 5.17903902e-02f,
  8.39639381e-02f, -6.76353574e-02f, 1.36221424e-01f, -4.37730066e-02f, -4.32217270e-02f, 1.37901321e-01f, 6.28141984e-02f, 7.01614246e-02f, 2.24702477e-01f, 1.21621378e-01f,
  1.17472284e-01f, 1.02193028e-01f, 6.27550110e-02f, 2.16739401e-01f, -1.13972403e-01f, -1.45913912e-02f, -4.22029108e-01f, 1.54321611e-01f, -1.43407375e-01f, 5.22201918e-02f,
  1.37800828e-01f, 3.06543577e-02f, 5.37516236e-01f, 3.87510657e-02f, 1.78751096e-01f, 3.05881619e-01f, 4.05441254e-01f, -4.08875883e-01f, 2.28289142e-01f, -1.91330507e-01f,
  7.32103214e-02f, -3.13763708e-01f, -1.99212041e-02f, -2.89277554e-01f, 1.54888466e-01f, 3.94223481e-01f, -1.03428271e-02f, 5.95327802e-02f, 1.57535151e-01f, 1.08719230e-01f,
  7.45652467e-02f, -2.78723359e-01f, -1.19958617e-01f, 9.29675624e-03f, 7.46007115e-02f, 4.37604971e-02f, 4.42506187e-02f, 4.32190299e-01f, -1.63701877e-01f, 2.71861047e-01f,
  -1.60711750e-01f, 1.49273634e-01f, -7.77523518e-02f, -1.47082821e-01f, 3.53973746e-01f, 2.64753848e-01f, 8.31267610e-02f, 1.55135393e-01f, 1.35381490e-01f, -5.89870848e-02f,
  1.10413283e-01f, -2.59620786e-01f, -1.95455849e-01f, 1.31877407e-01f, 2.10960686e-01f, 1.00046173e-01f, 5.54274991e-02f, -3.73302959e-02f, 1.20082768e-02f, -2.53388863e-02f,
  3.21781665e-01f, -3.50562423e-01f, -2.69842371e-02f, 2.88810223e-01f, 4.74500470e-03f, 1.47958219e-01f, 2.36509934e-01f, 8.73940531e-03f, 1.72099262e-01f, -1.89033806e-01f,
  2.35703319e-01f, 6.49734288e-02f, -1.03062719e-01f, 2.35891342e-01f, 2.69064963e-01f, -1.55679077e-01f, -3.87178063e-02f, -2.29923949e-02f, -6.43527061e-02f, 9.25341100e-02f,
  1.74738199e-01f, 1.19450748e-01f, -7.85750076e-02f, 2.69381642e-01f, -2.02729162e-02f, 3.40214729e-01f, -2.16894642e-01f, 2.63303161e-01f, 4.17482346e-01f, 2.84423828e-01f,
  1.95355475e-01f, 2.82865256e-01f, 4.60621668e-03f, 2.40805671e-01f, -4.23947424e-02f, 2.64351636e-01f, 3.24535608e-01f, -1.65253013e-01f, -1.24288134e-01f, 2.94225693e-01f,
  2.22143665e-01f, -7.77981207e-02f, -1.55297846e-01f, 6.17237501e-02f, 2.20701218e-01f, -1.03144281e-01f, -7.84870684e-02f, 2.91537046e-01f, 2.42937595e-01f, -3.50207761e-02f,
  1.10185876e-01f, -9.42897052e-02f, 8.30516815e-02f, 2.81155378e-01f, -1.84240565e-01f, 3.25481175e-03f, 2.72232175e-01f, -1.29497871e-01f, 2.26306424e-01f, -4.55708196e-03f,
  -3.28266658e-02f, -3.35020460e-02f, 1.44516364e-01f, 1.56309083e-01f, 2.69413620e-01f, 3.00935525e-02f, -1.53865770e-01f, 2.19264373e-01f, 6.20862730e-02f, -1.62820488e-01f,
  -1.67098325e-02f, 2.46794298e-01f, 1.69050261e-01f, 3.09639401e-03f, 3.37870419e-02f, 2.30576739e-01f, -1.12764001e-01f, 6.16321079e-02f, 4.07611340e-01f, 2.66236693e-01f,
  3.28682125e-01f, -2.29576528e-01f, -5.07151075e-02f, 1.25097260e-01f, 4.19574790e-02f, 2.31240377e-01f, -3.84675376e-02f, -3.03100228e-01f, 3.13010782e-01f, -2.05339566e-01f,
  1.42045766e-01f, -3.30611855e-01f, 3.19641680e-01f, 1.77352563e-01f, -5.96440360e-02f, -4.80347089e-02f, -8.71472508e-02f, -2.15700567e-01f, 3.81659195e-02f, 3.03179234e-01f,
  7.18096271e-02f, 1.86848328e-01f, 3.90557991e-03f, 7.55677745e-02f, 1.20333452e-02f, -8.84889439e-03f, -2.30633751e-01f, 1.07095003e-01f, 1.10601448e-01f, -9.84236524e-02f,
  -1.75060891e-02f, 1.00741178e-01f, 9.53099970e-03f, 9.52503681e-02f, 2.62271076e-01f, 1.04987081e-02f, 2.64232278e-01f, -2.10687637e-01f, 3.14475745e-01f, -4.87738363e-02f,
  -1.86090589e-01f, -9.55901295e-02f, -1.21908501e-01f, -1.38977289e-01f, -2.97604445e-02f, 1.47335067e-01f, 4.03229028e-01f, 2.04131216e-01f, 2.17454433e-02f, 2.80659497e-01f,
  1.92200363e-01f, -1.93048239e-01f, 3.04822206e-01f, -1.47497952e-02f, -2.86257863e-02f, 3.07474017e-01f, -1.01644546e-01f, 1.21125609e-01f, 1.85510516e-01f, -1.57262325e-01f,
  3.46654147e-01f, -3.98571696e-03f, -1.11081965e-01f, 2.70445228e-01f, -5.85940741e-02f, 3.84693332e-02f, 1.42920598e-01f, -4.38367315e-02f, 6.72983304e-02f, 1.12489201e-01f,
  1.14652142e-02f, 2.16389894e-01f, -3.70712914e-02f, -3.86528159e-03f, 2.09933817e-01f, 2.54725248e-01f, -5.39581245e-03f, 9.04338062e-03f, 1.47189684e-02f, 6.27757460e-02f,
  1.87163740e-01f, -1.20934419e-01f, -1.61109790e-01f, 1.08983561e-01f, -3.47566642e-02f, 1.97973654e-01f, 3.35957743e-02f, -1.50648668e-01f, 1.05221860e-01f, 1.30398080e-01f,
  2.76134282e-01f, 6.98745176e-02f, 1.23966010e-02f, -4.94559994e-03f, -1.37320217e-02f, 2.54200939e-02f, 1.27259747e-03f, 9.99784321e-02f, -1.58510525e-02f, -3.73746105e-03f,
  -1.40561191e-02f, 1.58083856e-01f, 1.09568499e-01f, 2.42640659e-01f, 1.31702453e-01f, 2.69670635e-01f, 2.67079845e-02f, 2.69635618e-01f, 1.40861183e-01f, 7.83011466e-02f,
  -1.37997970e-01f, -4.79259975e-02f, 1.93566009e-01f, -2.36016706e-01f, -1.27474681e-01f, 2.29907572e-01f, -8.67578685e-02f, 2.50515670e-01f, 1.83021396e-01f, -9.93200988e-02f,
  3.16863090e-01f, 6.47697896e-02f, 2.25686148e-01f, 1.75381869e-01f, -4.49500196e-02f, 2.59011060e-01f, -1.24165611e-02f, -2.40851611e-01f, 1.52538568e-02f, 3.47158834e-02f,
  -1.76506490e-02f, 1.64873675e-01f, 8.40313211e-02f, 1.10768639e-01f, 2.38415990e-02f, 2.96107650e-01f, 4.80809994e-02f, 3.37244093e-01f, -1.84459656e-01f, 2.50182182e-01f,
  1.08032480e-01f, 9.49172154e-02f, 1.98219448e-01f, 7.33240619e-02f, 3.52779806e-01f, 9.71498936e-02f, 1.33659482e-01f, -3.54279786e-01f, -1.18752152e-01f, 8.88354778e-02f,
  1.23743594e-01f, -3.09096240e-02f, -2.52648264e-01f, 5.46499074e-01f, 1.17199585e-01f, 3.00986350e-01f, -1.87780961e-01f, 2.37717569e-01f, 2.36304760e-01f, -1.36336342e-01f,
  4.49446030e-02f, 1.35129899e-01f, 6.46543503e-02f, 2.72211134e-01f, -3.29074562e-02f, -1.77675620e-01f, 6.45050704e-02f, -2.74502009e-01f, -6.69609830e-02f, 3.21207270e-02f,
  2.58159101e-01f, 2.90011376e-01f, 1.82943851e-01f, 1.51503623e-01f, 2.11829264e-02f, 2.14282930e-01f, 1.44438654e-01f, 1.31703064e-01f, -2.06262171e-01f, 2.97518820e-01f,
  5.98055252e-04f, 2.23295331e-01f, 1.44119561e-01f, 1.26030960e-03f, 3.31262797e-01f, -5.75760566e-02f, -1.93596095e-01f, -1.24260290e-02f, -5.97120915e-03f, 1.92479312e-01f,
  -2.84685642e-01f, -8.11428726e-02f, -6.90251216e-02f, 4.12714988e-01f, 2.30052128e-01f, -8.70992616e-02f, 2.78124779e-01f, 2.76545256e-01f, 1.27798840e-01f, -5.53226843e-02f,
  -1.37223750e-01f, 2.65897632e-01f, 4.76416349e-01f, -1.44847214e-01f, -1.85377181e-01f, 1.13350200e-02f, 3.40342447e-02f, 2.80251410e-02f, 1.54495463e-02f, -6.87178746e-02f,
  1.09165899e-01f, 1.22420236e-01f, 7.73793831e-02f, 3.17146629e-01f, 9.55197886e-02f, -8.07689801e-02f, 1.42401546e-01f, 2.97431573e-02f, -5.27620018e-02f, -3.89415096e-03f,
  2.94775926e-02f, 1.46940067e-01f, -2.72846609e-01f, -4.07846197e-02f, 3.64340353e-03f, 7.41790310e-02f, 2.65460581e-01f, 1.42548624e-02f, 1.95259303e-01f, 1.11997360e-02f,
  3.03637311e-02f, 3.47183615e-01f, -2.48453468e-01f, 2.01799393e-01f, 9.00413468e-02f, 1.82073206e-01f, -1.01527005e-01f, 9.50416848e-02f, 3.35441917e-01f, 2.99445033e-01f,
  7.92869627e-02f, 1.90192342e-01f, 2.79810905e-01f, -4.20742840e-01f, 1.81365326e-01f, -4.54810821e-02f, 1.27194494e-01f, 8.62083137e-02f, -6.65043220e-02f, 2.21854091e-01f,
  -3.29324305e-02f, 1.92853421e-01f, 6.56378567e-02f, 4.96646166e-02f, -8.54062140e-02f, 9.77564454e-02f, 3.09961170e-01f, 1.86487883e-01f, 1.67730644e-01f, 1.15619250e-01f,
  1.64336726e-01f, -1.08027577e-01f, 2.13804841e-01f, 5.86100705e-02f, -2.44709373e-01f, -2.43499707e-02f, 7.46477172e-02f, 1.89950511e-01f, 9.11565125e-03f, 3.18981767e-01f,
  1.70302615e-01f, 1.62748128e-01f, 2.18143135e-01f, -2.10558087e-01f, -1.33160979e-01f, 3.62974219e-02f, 1.11303642e-01f, -6.88017858e-03f, 1.16943158e-01f, 8.69973674e-02f,
  5.36433458e-02f, -1.32416725e-01f, 3.37335587e-01f, 2.48360764e-02f, 1.44041151e-01f, 1.52502090e-01f, 2.22285420e-01f, -7.46461377e-02f, -4.03763317e-02f, -9.59370956e-02f,
  -3.14333430e-03f, -3.29864658e-02f, -1.21757627e-01f, 2.29411364e-01f, 1.14223719e-01f, 2.74523675e-01f, 3.54845375e-01f, 2.23900929e-01f, -1.24363050e-01f, 8.99163485e-02f,
  3.37114722e-01f, 2.13056266e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.87382191e-01f, -3.96214351e-02f, 1.04106158e-01f, 3.50409746e-01f, 7.42172897e-02f, 1.33794039e-01f, 2.09896281e-01f, 1.19004600e-01f, 3.37312758e-01f, 3.16344291e-01f,
  1.78559840e-01f, 1.63339779e-01f, 3.81640382e-02f, 1.60957143e-01f, -8.21990054e-03f, 1.35187954e-01f, 2.48005003e-01f, 4.15088981e-02f, 3.27759057e-01f, 9.62757841e-02f,
  1.76998779e-01f, 2.14120299e-01f, 5.67529500e-02f, 1.72265753e-01f, 1.16118267e-01f, 2.84882218e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.00181378e-01f, 1.79649562e-01f, 5.86164854e-02f, -5.73440492e-02f, -6.09435737e-02f, -1.30294368e-01f, -6.96582571e-02f, -1.68697834e-01f, -2.33411819e-01f, -8.07266161e-02f,
  1.92887917e-01f, -3.43850143e-02f, -1.67418793e-01f, -1.59811422e-01f, -4.43201251e-02f, 4.40501459e-02f, -4.80292588e-02f, -1.13618650e-01f, -1.69686958e-01f, -2.48871092e-02f,
  1.79460794e-01f, -1.06863976e-02f, -8.33514109e-02f, -1.06803894e-01f, -5.96070401e-02f, 8.66861641e-02f, -9.36631262e-02f, 2.34506205e-01f, -2.59579331e-01f, -4.34174836e-02f,
  9.87411067e-02f, 1.47281870e-01f, 1.35710299e-01f, 3.38227637e-02f, -1.20078154e-01f, 3.92599702e-02f, 5.67661412e-02f, 1.85942814e-01f, 6.43274635e-02f, 1.65114924e-01f,
  -5.04251756e-02f, 5.79882925e-03f, -2.19746187e-01f, -2.31580921e-02f, 1.21288419e-01f, -3.55256312e-02f, 4.15205956e-02f, 1.54921770e-01f, -5.73605709e-02f, -5.47645837e-02f,
  1.33290708e-01f, 8.90998915e-03f, -2.21793085e-01f, 1.41943216e-01f, 9.06896889e-02f, 2.37289183e-02f, 1.80602118e-01f, -1.63519666e-01f, -2.81270087e-01f, 9.78112221e-02f,
  1.74281985e-01f, 1.31174520e-01f, 8.43601450e-02f, -2.14303344e-01f, -4.99944529e-03f, 4.68102843e-02f, -1.25564948e-01f, -1.43087178e-01f, -4.57374975e-02f, 1.15040801e-01f,
  1.49665680e-02f, 1.27088100e-01f, -1.70812875e-01f, 9.89413783e-02f, 1.50768921e-01f, 1.59606919e-01f, -8.60869661e-02f, 1.03597015e-01f, 1.61663532e-01f, 1.37485817e-01f,
  -1.13725387e-01f, -1.75244823e-01f, -2.06286795e-02f, -1.16678610e-01f, 3.68547998e-02f, -1.71654046e-01f, -7.49514848e-02f, 1.88237980e-01f, -9.51849595e-02f, -2.99971588e-02f,
  -5.96609153e-02f, -2.67614853e-02f, 1.35958582e-01f, 1.82575643e-01f, 9.82111543e-02f, -5.77946045e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.01276241e-01f, 6.15612417e-03f, -1.08762704e-01f, -1.91161036e-01f, -2.03200981e-01f, -6.96265488e-04f, 6.43558577e-02f, 3.74059193e-02f, -1.28295934e-02f, -7.68301785e-02f,
  1.16660796e-01f, 1.97376668e-01f, -8.37597623e-02f, 2.34803572e-01f, 2.91080624e-01f, 6.26544133e-02f, -7.11468384e-02f, -1.16619453e-01f, -8.59051049e-02f, -2.88106143e-01f,
  2.42727607e-01f, 9.90900397e-02f, -1.87179327e-01f, -4.65681627e-02f, 2.29155704e-01f, 2.61709467e-02f, 1.21768571e-01f, -2.12627754e-01f, 4.32004593e-02f, 2.08383024e-01f,
  3.78818624e-02f, 2.13468120e-01f, 2.74093598e-01f, 3.08734953e-01f, 2.10978225e-01f, -5.54931089e-02f, -3.12680811e-01f, -6.15484007e-02f, 1.81258675e-02f, -4.65000793e-02f,
  -3.65334451e-01f, 1.31823421e-01f, 1.01188734e-01f, 8.35535452e-02f, -1.14445455e-01f, 1.46323994e-01f, 2.83434927e-01f, 1.93834692e-01f, -1.87574811e-02f, -1.53574660e-01f,
  -3.96738648e-01f, -1.50839433e-01f, 1.07296243e-01f, 1.58326759e-03f, 4.97338688e-03f, -1.97308630e-01f, 4.08764660e-01f, 2.23765045e-01f, 4.83092517e-02f, 1.97821092e-02f,
  -2.95041949e-01f, 8.44083875e-02f, 2.10020423e-01f, 3.77262354e-01f, 5.30171990e-02f, 7.20277131e-02f, 1.25258625e-01f, 3.15374076e-01f, 1.76854610e-01f, -1.31215751e-01f,
  -6.29895777e-02f, -6.76721334e-02f, 5.63372374e-02f, 3.92908067e-01f, 4.01767254e-01f, -1.91002443e-01f, 1.17802642e-01f, -1.40341073e-01f, -6.23693727e-02f, 9.26284192e-05f,
  3.89296472e-01f, 5.77708185e-02f, 7.84008577e-02f, 1.95793971e-01f, 3.50693613e-01f, -1.14893638e-01f, 1.70231089e-01f, -1.16050377e-01f, -9.77046415e-02f, 1.07300736e-01f,
  2.28587732e-01f, 4.85942900e-01f, -7.74374530e-02f, -9.58024934e-02f, 2.21597806e-01f, 2.64102846e-01f, 1.89691857e-01f, 1.61421031e-01f, 1.83990404e-01f, -3.35917361e-02f,
  1.88587189e-01f, 1.11661024e-01f, 1.52321666e-01f, -2.93809306e-02f, 9.87720191e-02f, 1.62865281e-01f, 2.17579514e-01f, -5.15435003e-02f, -2.66322270e-02f, -1.71721607e-01f,
  -1.25420634e-02f, -1.02367751e-01f, 1.67652965e-01f, -4.37379517e-02f, 1.89828306e-01f, 2.76820689e-01f, -2.55554557e-01f, -5.12209460e-02f, 3.64257321e-02f, -2.00563148e-01f,
  -3.07239853e-02f, -6.00904934e-02f, -1.24777317e-01f, 4.55604494e-01f, 1.52573586e-01f, -6.86057732e-02f, 3.22588444e-01f, -1.84994236e-01f, -2.61719942e-01f, -2.64700294e-01f,
  -1.91995859e-01f, 3.47170159e-02f, -2.35990286e-02f, 6.50087371e-03f, -5.65169640e-02f, 1.69447884e-01f, -4.13467688e-03f, -6.87861117e-03f, 1.66050971e-01f, 2.37223238e-01f,
  -1.61533296e-01f, 9.81095582e-02f, 1.00775741e-01f, 6.46502599e-02f, 1.43608199e-02f, 1.83840871e-01f, 2.38856860e-02f, -4.83352654e-02f, 2.07809851e-01f, -4.55907620e-02f,
  -3.05032223e-01f, 2.64719903e-01f, 6.00409284e-02f, 2.46287256e-01f, 2.49374688e-01f, -1.64914519e-01f, 2.63726801e-01f, 3.42669874e-01f, -7.96076283e-02f, -5.88306896e-02f,
  8.76070112e-02f, 9.36775059e-02f, 1.02547660e-01f, -2.74369735e-02f, 9.85659882e-02f, 9.38634500e-02f, 1.34357378e-01f, 1.00242786e-01f, -1.42079502e-01f, -1.83224678e-01f,
  2.39043310e-01f, 7.54748434e-02f, -2.27636993e-01f, 5.79327270e-02f, 1.94323063e-01f, -2.78875623e-02f, 8.17266405e-02f, -9.73774344e-02f, 4.05179381e-01f, 2.58847654e-01f,
  -5.13635725e-02f, -9.93203744e-03f, 1.17183320e-01f, 2.05300719e-01f, 1.10858649e-01f, -1.77368205e-02f, -2.28962395e-02f, 2.00217396e-01f, -1.20449536e-01f, 6.18416741e-02f,
  2.58796215e-01f, -4.27858196e-02f, -1.73055634e-01f, -1.94864228e-01f, -1.68800235e-01f, -6.56432584e-02f, -4.19772565e-02f, -1.81383520e-01f, 9.56100225e-03f, 5.05945943e-02f,
  1.82828959e-02f, 2.10720506e-02f, 1.52887955e-01f, 2.31291920e-01f, -1.25488892e-01f, 1.19021788e-01f, -1.71167124e-02f, 5.59090786e-02f, -8.44669566e-02f, 8.85403678e-02f,
  1.03659712e-01f, -1.27857640e-01f, 3.17601472e-01f, 3.49185206e-02f, -1.66586071e-01f, 2.65281141e-01f, -8.58487114e-02f, 2.29227245e-01f, 2.02244356e-01f, -1.10197857e-01f,
  1.30599692e-01f, 2.03251317e-01f, -5.34808263e-02f, 6.27498850e-02f, -2.67335940e-02f, 9.49959159e-02f, -3.43223521e-03f, -2.05437243e-01f, -8.29821005e-02f, 3.43690664e-02f,
  2.07722574e-01f, 1.25125453e-01f, -1.77008092e-01f, -1.40067101e-01f, 1.88236032e-02f, 2.17756405e-01f, -2.32276320e-01f, 2.75849104e-01f, 2.33904675e-01f, 1.75922796e-01f,
  2.33152993e-02f, -2.25924611e-01f, 2.87565708e-01f, -8.85239318e-02f, 3.05057801e-02f, 5.20519577e-02f, -4.34904695e-02f, 1.24093629e-01f, 1.67866185e-01f, -5.06805964e-02f,
  -4.33133394e-02f, -5.10326624e-02f, 4.44374122e-02f, 1.04610838e-01f, 3.68212938e-01f, 1.26915863e-02f, -3.09739232e-01f, -2.59380966e-01f, -3.36498201e-01f, 1.26238227e-01f,
  1.36009455e-01f, -6.78013265e-03f, -1.21317305e-01f, 3.67604829e-02f, 1.57831179e-03f, 2.68843174e-01f, 1.06406502e-01f, 1.40959784e-01f, -1.03126034e-01f, 1.93034112e-01f,
  -4.54022102e-02f, 2.82777876e-01f, 1.14452265e-01f, 2.02753708e-01f, -2.56851166e-02f, 1.40819713e-01f, 2.03324065e-01f, -9.54657122e-02f, -3.75049055e-01f, 3.43237609e-01f,
  -3.18977945e-02f, 2.47380167e-01f, 4.21209455e-01f, -2.06873834e-01f, 2.59889156e-01f, 3.31511736e-01f, 4.02928144e-03f, 6.05986547e-03f, -1.75218225e-01f, -1.44499138e-01f,
  -1.81462511e-01f, -1.01678744e-01f, 1.98238969e-01f, -1.03533134e-01f, 1.87232316e-01f, 1.95717573e-01f, 8.35891068e-03f, -2.50210732e-01f, 1.15762874e-01f, 9.54166353e-02f,
  -1.21415287e-01f, 1.86466232e-01f, -2.55268868e-02f, -2.17805114e-02f, 1.18935570e-01f, 1.26574293e-01f, 5.06142557e-01f, 8.21948573e-02f, 1.48656011e-01f, 7.52490833e-02f,
  2.02337846e-01f, 3.17433178e-01f, -1.31538510e-01f, -4.50508706e-02f, 1.12618573e-01f, -4.79209349e-02f, 2.00210884e-01f, 8.84268954e-02f, 2.45166242e-01f, 1.17916115e-01f,
  1.38074100e-01f, 7.18284771e-02f, 3.28691781e-01f, -1.19207963e-01f, 1.33154839e-01f, 1.54207826e-01f, 2.13018984e-01f, 9.86281559e-02f, -1.66498125e-01f, -1.40577838e-01f,
  3.03116560e-01f, -1.08986787e-01f, -2.35558853e-01f, 5.47762215e-02f, 2.67842233e-01f, 1.04805194e-01f, 1.05500547e-02f, -1.54508740e-01f, 4.19660330e-01f, 1.98266536e-01f,
  -1.52949408e-01f, 5.05655333e-02f, 1.84610933e-01f, 2.32170895e-02f, 2.93057144e-01f, -1.37286872e-01f, -1.27258480e-01f, 1.75804213e-01f, -2.21238151e-01f, -8.11070669e-03f,
  4.40779865e-01f, -2.50370800e-02f, 1.11056998e-01f, -7.01104626e-02f, -3.23838666e-02f, 1.56334504e-01f, 6.92462623e-02f, -2.95039833e-01f, -1.64209187e-01f, -9.92841646e-02f,
  3.62940192e-01f, 1.27583042e-01f, 1.71061903e-01f, -2.20895275e-01f, 3.68412763e-01f, -1.58353537e-01f, -2.48351321e-01f, -2.31175814e-02f, 8.96318257e-02f, 4.64230478e-01f,
  2.22355306e-01f, -1.76374227e-01f, 1.92010388e-01f, 2.44382203e-01f, 4.77904707e-01f, -4.23303582e-02f, -2.22197667e-01f, 8.35247785e-02f, 8.99092853e-02f, -1.30712777e-01f,
  -7.92941749e-02f, -1.93507507e-01f, -1.66650862e-01f, 3.60927701e-01f, 1.98100820e-01f, 1.73491016e-01f, 1.47653282e-01f, -2.59184897e-01f, -3.35359089e-02f, 1.80204719e-01f,
  2.22357273e-01f, 7.91402608e-02f, -3.32243298e-03f, 1.59530953e-01f, -8.45438838e-02f, 1.59608886e-01f, 1.46349713e-01f, 4.17561568e-02f, 3.52621078e-01f, 3.33696187e-01f,
  -2.10368056e-02f, -1.28862873e-01f, -1.04179934e-01f, 1.01076968e-01f, -2.13424966e-01f, 2.18146414e-01f, 1.06345760e-02f, -1.00915574e-01f, 3.46000075e-01f, 5.59643693e-02f,
  -1.40218869e-01f, 9.59888026e-02f, 3.33654881e-02f, 1.87037438e-02f, 2.87720323e-01f, 1.18019521e-01f, 1.34785399e-01f, 5.45883141e-02f, -2.91055646e-02f, 3.06767449e-02f,
  2.50960082e-01f, 2.18028903e-01f, 1.64714187e-01f, 2.53446102e-01f, 2.15108588e-01f, -1.28163649e-02f, 2.18770280e-02f, -4.85162213e-02f, 5.62104210e-02f, 2.72970796e-02f,
  8.13813582e-02f, 2.03417033e-01f, 1.18975587e-01f, 8.05484205e-02f, 4.74123150e-01f, 3.80135238e-01f, -2.61823982e-01f, 9.74719152e-02f, 3.19855452e-01f, 5.05991094e-02f,
  1.46060109e-01f, -1.07536927e-01f, -8.18594620e-02f, 1.94089159e-01f, 3.05939525e-01f, 4.05117348e-02f, 3.68617475e-01f, -1.95364609e-01f, 8.03546309e-02f, 1.33869648e-01f,
  6.50236532e-02f, -3.27164754e-02f, -1.17855649e-02f, -4.34821621e-02f, 1.37041762e-01f, 4.06174827e-03f, 6.08535707e-02f, 3.48753095e-01f, 2.50987619e-01f, 2.27417573e-01f,
  1.76959381e-01f, 1.42400682e-01f, 1.98030129e-01f, 2.01171175e-01f, -2.11894698e-02f, 1.78386107e-01f, 3.19998972e-02f, -1.26214745e-02f, 2.37260967e-01f, 8.51604119e-02f,
  1.61019295e-01f, -4.78964858e-02f, 1.45476729e-01f, 2.00351059e-01f, 1.83124647e-01f, 6.67836592e-02f, 6.56044707e-02f, 1.87878124e-02f, 1.66243389e-01f, 3.06314826e-01f,
  6.61671907e-02f, 1.49790958e-01f, 1.15573965e-01f, 3.81522328e-01f, 4.83857989e-02f, -1.55538008e-01f, 5.82609233e-03f, 1.06037989e-01f, -1.39612362e-01f, 3.68807346e-01f,
  4.49477434e-01f, -1.18482068e-01f, -2.07647100e-01f, 5.97895682e-02f, 1.24243625e-01f, 8.95549208e-02f, 4.24205273e-01f, -2.87644621e-02f, 5.81207499e-02f, 3.30292791e-01f,
  2.48586893e-01f, -3.42764914e-01f, -1.69915691e-01f, -7.43416697e-02f, 3.71487513e-02f, 1.90478474e-01f, 2.83500612e-01f, 4.18499321e-01f, 1.08455375e-01f, 4.27475460e-02f,
  9.30583924e-02f, 2.01527089e-01f, -6.71003461e-02f, -1.10347010e-01f, -5.79437381e-03f, -2.19367415e-01f, -4.47777659e-02f, 5.53025976e-02f, 1.67103752e-01f, 3.94693278e-02f,
  2.79964149e-01f, 1.27952516e-01f, -7.67977387e-02f, 2.63479263e-01f, 1.96112588e-01f, 8.28661248e-02f, 3.10121149e-01f, 2.11669922e-01f, -2.01282591e-01f, 1.53348267e-01f,
  2.16558099e-01f, -2.17122748e-01f, 5.55529222e-02f, 3.80907238e-01f, 2.99367726e-01f, 3.83283198e-02f, 2.24007621e-01f, -1.60769671e-02f, 4.74132895e-02f, -2.73097873e-01f,
  1.20873019e-01f, 3.69150029e-03f, 1.54003814e-01f, 1.91940024e-01f, 2.38035664e-01f, 3.88734579e-01f, 3.08824450e-01f, 1.25445798e-02f, -1.85116425e-01f, -1.54170617e-02f,
  -7.69554600e-02f, -9.48671699e-02f, -8.07034150e-02f, 3.66690338e-01f, -5.17193861e-02f, 1.12441391e-01f, -4.83921319e-02f, 6.87994957e-02f, 2.88821608e-01f, 2.24949807e-01f,
  3.53671461e-02f, -1.96220756e-01f, -4.55821484e-01f, -1.63721293e-01f, -1.29448297e-02f, -5.13938703e-02f, -1.32491719e-02f, -1.81375861e-01f, 3.70431840e-01f, 1.36493459e-01f,
  4.11331058e-02f, 2.51040816e-01f, -1.97483674e-01f, 7.39975646e-02f, -1.00171436e-02f, 8.43754336e-02f, 3.48360054e-02f, 1.00881189e-01f, 8.12071003e-03f, -1.22628897e-01f,
  2.01316923e-02f, 2.04738155e-01f, 1.81881085e-01f, 1.72650352e-01f, -7.67344534e-02f, 8.13217908e-02f, -1.83521703e-01f, 1.92503437e-01f, -5.07021658e-02f, 9.48081091e-02f,
  1.04556501e-01f, 2.60856569e-01f, 1.60241529e-01f, -9.93242860e-03f, 1.88687481e-02f, 1.67998612e-01f, -2.78086718e-02f, 5.13540916e-02f, -1.82691604e-01f, 3.59934010e-02f,
  1.58752948e-01f, 4.37724367e-02f, 6.42511696e-02f, 4.82651517e-02f, 3.25841606e-01f, 1.90080509e-01f, 2.30382457e-01f, -1.00170169e-02f, -1.41341537e-02f, -1.18821310e-02f,
  -2.79676523e-02f, -5.88862859e-02f, 1.27358153e-01f, 2.25166738e-01f, 6.09073788e-02f, 2.33730644e-01f, 3.07351381e-01f, 4.48293276e-02f, -1.34809285e-01f, 1.60412386e-01f,
  1.94092408e-01f, 1.55591309e-01f, 1.30908549e-01f, 5.79980761e-02f, 1.54577002e-01f, 8.17683116e-02f, 1.41123772e-01f, 5.23089804e-02f, -2.14304134e-01f, 3.09211046e-01f,
  2.64842272e-01f, 2.19718888e-02f, 1.81012511e-01f, -6.61629140e-02f, -5.50984181e-02f, -2.08528101e-01f, 4.16780591e-01f, 1.48499593e-01f, 3.95218730e-02f, -3.34784351e-02f,
  2.11682752e-01f, 1.69159859e-01f, 2.16484413e-01f, -2.82763541e-01f, -4.82373647e-02f, 1.90223400e-02f, -6.55355155e-02f, -6.70034736e-02f, 2.97767997e-01f, 4.16108429e-01f,
  -2.07854241e-01f, 2.46291712e-01f, 2.80024678e-01f, -9.74778458e-03f, 2.21894681e-01f, 3.44634891e-01f, -2.40763381e-01f, 3.02861333e-01f, -2.36193433e-01f, -2.02611670e-01f,
  -1.35892043e-02f, 4.16143924e-01f, 2.07646728e-01f, -1.02181017e-01f, 3.25499833e-01f, 2.15571761e-01f, -6.64116889e-02f, -2.18813956e-01f, 4.39551212e-02f, -1.49583131e-01f,
  2.39351708e-02f, 2.13623255e-01f, -1.49375079e-02f, 5.71118407e-02f, 1.62808243e-02f, 2.91590333e-01f, -9.33240876e-02f, -3.19927096e-01f, -6.62962571e-02f, -1.45928100e-01f,
  -2.70421393e-02f, 1.20496087e-01f, 4.67519552e-01f, -1.47168204e-01f, -5.01560159e-02f, -1.23463027e-01f, -1.13961482e-02f, 9.22552645e-02f, 3.44363093e-01f, 1.74551517e-01f,
  5.65219969e-02f, -4.00783643e-02f, 4.90222484e-01f, -2.94339746e-01f, 5.67914061e-02f, 3.05400137e-02f, -8.48838761e-02f, 9.16760489e-02f, 3.59598994e-01f, 3.36996675e-01f,
  -3.12810063e-01f, -3.80605310e-02f, -1.38557022e-02f, 2.77984291e-01f, 1.08617425e-01f, 3.10335476e-02f, -1.57246310e-02f, -1.97898790e-01f, 4.58577350e-02f, 1.90771148e-01f,
  1.80563554e-01f, 1.67617887e-01f, 2.76409715e-01f, -1.60805941e-01f, -1.68387026e-01f, 2.32317016e-01f, 2.81217724e-01f, 4.85360958e-02f, 1.91229463e-01f, 1.66459352e-01f,
  -7.17668533e-02f, 2.17392892e-01f, 2.42082492e-01f, -7.15500489e-02f, -2.32141122e-01f, 3.53792191e-01f, 3.32067847e-01f, 1.99775249e-01f, 1.42392680e-01f, -1.66712344e-01f,
  -1.00626960e-01f, -1.85814649e-01f, 6.55634403e-02f, -3.05274874e-02f, 1.59675911e-01f, 1.01859728e-02f, 1.38942912e-01f, -5.74449077e-02f, 5.33955544e-02f, 2.19895989e-01f,
  2.15759352e-01f, -9.12039801e-02f, -1.92750487e-02f, -5.82447909e-02f, 2.91816652e-01f, 4.16142136e-01f, 1.80567250e-01f, 3.40604596e-02f, 3.40612710e-01f, -1.52437493e-01f,
  -1.87338233e-01f, 9.61544067e-02f, 1.96122542e-01f, 3.73140514e-01f, -2.07885861e-01f, 1.30053908e-01f, 1.40387356e-01f, 9.44019258e-02f, 1.15985185e-01f, -1.46110490e-01f,
  -4.66132537e-03f, 1.80674091e-01f, 2.31601045e-01f, 1.75820976e-01f, 3.55473101e-01f, 8.25702865e-03f, -9.15848538e-02f, 2.45894969e-01f, 5.66380937e-03f, -6.24899659e-03f,
  -7.01597929e-02f, 1.55773520e-01f, 9.96628180e-02f, 2.08418638e-01f, 2.10932851e-01f, 1.68979183e-01f, -3.22174355e-02f, 1.17881149e-01f, 1.21499754e-01f, 1.72415286e-01f,
  -2.17671618e-01f, 3.03037334e-02f, 4.30911183e-02f, 1.95482641e-01f, 3.58094931e-01f, -6.34739399e-02f, 7.72359595e-02f, 2.54330695e-01f, -9.39780176e-02f, -2.13930696e-01f,
  -1.52660832e-01f, 2.24538147e-01f, 1.71326939e-02f, 4.78609465e-02f, 5.59879504e-02f, 3.19501668e-01f, 3.39515448e-01f, 3.18854570e-01f, 2.94967204e-01f, -1.81232065e-01f,
  -2.95289785e-01f, -2.95544207e-01f, -2.48495385e-01f, 9.23107713e-02f, 3.04525401e-02f, -6.98357495e-03f, -4.85058390e-02f, 9.93125439e-02f, 2.32818231e-01f, -1.86916143e-02f,
  4.07228284e-02f, 1.36557862e-01f, -6.76165223e-02f, 1.07987717e-01f, -2.09293235e-02f, -4.50321212e-02f, 3.32342595e-01f, 4.49637771e-02f, 1.54611558e-01f, 5.43998741e-02f,
  1.66604832e-01f, 1.17567685e-02f, 7.30786473e-02f, 2.54455745e-01f, 8.58004019e-02f, 1.19765319e-01f, 2.28381321e-01f, -1.46780466e-03f, 2.08651051e-01f, 2.31922582e-01f,
  2.41833385e-02f, -1.50475865e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  -1.08082145e-01f, 1.32287860e-01f, 1.99161008e-01f, 8.75067413e-02f, -1.70958996e-01f, 1.32319808e-01f, -1.31794348e-01f, 1.20254971e-01f, -1.36451945e-01f, 1.82718579e-02f,
  1.81256264e-01f, 1.97947845e-01f, 1.88145429e-01f, 7.56899302e-04f, 1.95004940e-01f, 2.18538761e-01f, -3.41754034e-02f, 2.09076554e-01f, 1.22210473e-01f, -4.21518423e-02f,
  1.80040717e-01f, 2.41493862e-02f, -1.15945749e-02f, 4.77302782e-02f, 3.44832707e-03f, -1.73250258e-01f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -9.50334147e-02f, -3.33137698e-02f, -6.81292489e-02f, -6.01277426e-02f, 1.03477515e-01f, 1.08203597e-01f, -3.15463692e-02f, -1.93641365e-01f, 5.96531779e-02f, 2.13211283e-01f,
  6.98680580e-02f, -4.20047604e-02f, 4.09487151e-02f, 5.24331927e-02f, -8.65750238e-02f, 1.43754900e-01f, 5.26625402e-02f, -2.33741701e-01f, -3.02565675e-02f, 1.06234193e-01f,
  -1.98911950e-02f, 7.77473077e-02f, 6.98427781e-02f, -5.32939332e-03f, 1.31468609e-01f, -2.07428355e-02f, -1.78016976e-01f, 2.87740002e-03f, -3.82177383e-02f, 2.82930173e-02f,
  6.18664213e-02f, 3.47104110e-02f, 2.65109353e-02f, -1.08436510e-01f, 6.29585013e-02f, -2.33897269e-02f, -1.64750129e-01f, -4.32118215e-02f, -5.51649220e-02f, -5.40414713e-02f,
  -6.39504045e-02f, -9.79282260e-02f, 5.00446633e-02f, -1.02738157e-01f, 6.31044358e-02f, -8.74307603e-02f, 1.13612294e-01f, 1.63854901e-02f, -4.68390770e-02f, 6.11249022e-02f,
  -1.21395729e-01f, 7.91360289e-02f, -1.10725731e-01f, 1.21875890e-01f, 1.70163717e-02f, -1.11506276e-01f, 1.08025819e-01f, -7.96050504e-02f, 3.70503590e-02f, 5.33088818e-02f,
  -7.45058730e-02f, 1.25150949e-01f, -5.51749617e-02f, 2.06331033e-02f, -9.77530628e-02f, 5.97888157e-02f, -2.24312171e-02f, -1.46595091e-02f, 6.77791610e-03f, -1.29267322e-02f,
  8.45636800e-02f, -2.52388455e-02f, -1.03788853e-01f, -1.95209049e-02f, 2.72441264e-02f, -9.67151672e-02f, -3.93246673e-02f, 4.91614006e-02f, 7.04463050e-02f, -9.27447900e-02f,
  1.12036735e-01f, -1.17372617e-01f, -9.32407752e-02f, 8.77517387e-02f, -1.95460841e-01f, -1.16759360e-01f, -1.00114867e-02f, 1.41367778e-01f, -4.67600562e-02f, 1.24558121e-01f,
  -2.04484519e-02f, -1.87140238e-02f, 1.49920180e-01f, -1.90992936e-01f, 1.84825346e-01f, 1.10028936e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -6.15959056e-02f, 1.35125548e-01f, -1.33255050e-01f, -7.04688355e-02f, -1.19776875e-01f, -1.76120251e-01f, -6.03571460e-02f, -1.59348384e-01f, 2.33678803e-01f, -1.56079335e-02f,
  -1.46249160e-01f, 5.67876101e-02f, -3.35726105e-02f, -8.41653049e-02f, -1.87309355e-01f, -2.58326847e-02f, 1.16524950e-01f, 4.36329514e-01f, -2.18041450e-01f, -1.69487093e-02f,
  -1.49433641e-03f, 1.35147721e-01f, 2.01721728e-01f, -7.75031373e-02f, -2.88419545e-01f, -1.60346441e-02f, 2.55470097e-01f, 6.82155937e-02f, 5.26832193e-02f, 1.65189251e-01f,
  -1.75836563e-01f, 5.89651428e-02f, 9.67183113e-02f, -1.78535189e-02f, 1.72814339e-01f, 9.26880687e-02f, 1.44651979e-01f, 1.67953968e-01f, 2.08544098e-02f, 1.57998502e-01f,
  2.75150269e-01f, 3.90881598e-01f, -6.96646720e-02f, 2.96603799e-01f, -1.19129904e-01f, 2.85051644e-01f, -1.34777546e-01f, 1.17048062e-01f, 3.06148469e-01f, -2.10439622e-01f,
  1.12654470e-01f, 3.75529617e-01f, 2.12692216e-01f, 1.30238205e-01f, -6.44657984e-02f, 1.81988329e-02f, 8.32522586e-02f, 1.32412137e-02f, -1.34322643e-01f, 1.31092638e-01f,
  1.19644135e-01f, -1.80736601e-01f, 3.37966681e-01f, -1.07101500e-01f, 5.86293712e-02f, 2.26144016e-01f, 1.03756331e-01f, 3.17690760e-01f, -2.28271395e-01f, -8.92674550e-02f,
  1.17064916e-01f, 2.09169611e-01f, 3.66153598e-01f, -7.12676644e-02f, -2.73505505e-02f, 1.04531117e-01f, 6.37544245e-02f, -1.73021808e-01f, 7.72258639e-02f, -9.82706696e-02f,
  1.02094471e-01f, 2.34534100e-01f, -3.69528420e-02f, -2.89743751e-01f, 1.97999865e-01f, 4.10521239e-01f, -2.05574512e-01f, 3.18258017e-01f, -6.35216460e-02f, -3.07285130e-01f,
  -6.89835623e-02f, 5.13617873e-01f, -3.02448243e-01f, 6.75842836e-02f, -8.84768963e-02f, -6.47615120e-02f, 2.36715935e-02f, -9.35435742e-02f, 3.57432812e-02f, -1.52171671e-01f,
  2.42912143e-01f, 1.52040258e-01f, 1.12525254e-01f, 7.05613568e-02f, -6.21127151e-02f, 7.65627027e-02f, 2.64797751e-02f, 6.96101487e-02f, -3.85833345e-02f, 3.02781343e-01f,
  -4.04385030e-02f, 6.49576783e-02f, 2.46682778e-01f, -3.23148191e-01f, 2.78408736e-01f, 3.10042650e-01f, 1.07635967e-01f, 9.60389152e-02f, 1.28356263e-01f, 2.09335133e-01f,
  3.37282002e-01f, 1.31932721e-01f, -4.69510108e-02f, -1.54309422e-01f, 2.68182814e-01f, 6.60296530e-02f, 3.15255791e-01f, -1.97701789e-02f, -5.08135445e-02f, -9.91904270e-03f,
  9.47020277e-02f, 1.06018968e-01f, -6.43285364e-02f, 9.36015472e-02f, 3.51569116e-01f, 4.66450959e-01f, -8.01540241e-02f, -2.42032945e-01f, 1.61501765e-01f, -1.98120117e-01f,
  1.33928359e-01f, 1.44944832e-01f, 2.97128707e-01f, -3.15571696e-01f, -1.29300937e-01f, -1.78594545e-01f, 3.18428665e-01f, -1.57851428e-01f, 3.28770071e-01f, 1.06929310e-01f,
  1.54864565e-01f, 3.27212065e-01f, 1.45704284e-01f, 9.87944081e-02f, 3.67201865e-01f, 9.77289006e-02f, -9.02777240e-02f, 9.17402729e-02f, 7.17341304e-02f, 4.07379866e-03f,
  -1.44832820e-01f, -1.83452424e-02f, 5.15355133e-02f, -5.64784370e-02f, -6.11674674e-02f, 2.03187335e-02f, 5.57237454e-02f, -6.28303215e-02f, 1.94640741e-01f, 2.29192376e-02f,
  2.66792595e-01f, 9.21371579e-02f, 1.33258864e-01f, -6.37841970e-02f, 3.14856917e-01f, -3.98733951e-02f, -2.17770040e-01f, -3.54119986e-01f, 2.48193881e-03f, -1.87691767e-02f,
  -1.48913771e-01f, 3.68729055e-01f, -1.24371052e-01f, 2.16360539e-01f, 1.09401271e-01f, 1.30273730e-01f, -1.39112860e-01f, -4.48988415e-02f, -1.67763740e-01f, 2.14573070e-01f,
  3.09782892e-01f, 2.43815213e-01f, -9.55183953e-02f, -1.82870641e-01f, -1.69251099e-01f, -1.88479438e-01f, -2.11751796e-02f, 9.46278274e-02f, 2.87773103e-01f, -9.46740881e-02f,
  -8.65317695e-03f, -2.95937121e-01f, 3.14263791e-01f, 6.88766837e-02f, 2.68670768e-01f, 8.75394940e-02f, 4.05783653e-01f, 1.47419810e-01f, -1.08518004e-01f, -1.95927039e-01f,
  1.08440638e-01f, 5.90662472e-02f, 1.81818530e-01f, -8.32286999e-02f, 3.04634750e-01f, -1.85704399e-02f, 1.57595843e-01f, 2.92344719e-01f, 1.88344374e-01f, -1.64670318e-01f,
  2.59924084e-01f, 3.97749580e-02f, 1.85715109e-01f, 1.69509441e-01f, -1.32978454e-01f, -1.39346555e-01f, -9.31029096e-02f, 1.82499722e-01f, -3.40073049e-01f, -6.35410175e-02f,
  2.52191305e-01f, 1.18394390e-01f, 8.59682858e-02f, -3.30762982e-01f, 3.90054524e-01f, -3.05347238e-02f, 3.65758091e-01f, 1.77071065e-01f, 4.44339573e-01f, 1.60582036e-01f,
  -1.56925008e-01f, 2.12267444e-01f, -1.53258815e-01f, -2.03008756e-01f, 2.01242074e-01f, 2.63333917e-01f, 5.82268238e-02f, -2.60819606e-02f, 8.41971040e-02f, 2.72390246e-02f,
  -3.17770950e-02f, 3.92001271e-01f, -2.19378382e-01f, 1.62700340e-01f, 1.13447346e-01f, 3.14513206e-01f, 8.45347717e-02f, 1.30305082e-01f, 1.46846384e-01f, 1.58970743e-01f,
  -5.28762750e-02f, -9.67320353e-02f, 1.43249243e-01f, 1.72288805e-01f, 2.78041571e-01f, -9.06895548e-02f, -3.80790159e-02f, -1.18608318e-01f, 2.63700578e-02f, -8.34285375e-03f,
  -3.80612984e-02f, -2.27627292e-01f, -1.03888754e-02f, 8.44972581e-02f, 1.24333762e-01f, -1.21327154e-01f, 2.15162873e-01f, 2.07696661e-01f, -2.50056735e-04f, 2.51347810e-01f,
  -1.13297254e-02f, -1.19548813e-01f, 2.96023190e-01f, 3.29962343e-01f, -1.81576699e-01f, 1.64901629e-01f, -9.70483869e-02f, -9.16277319e-02f, -1.45710781e-02f, -1.40210882e-01f,
  -5.46708517e-02f, 3.42693813e-02f, -2.18333304e-01f, -7.26635903e-02f, 1.09133512e-01f, -1.81321263e-01f, 2.89411336e-01f, 1.37269452e-01f, 1.53858632e-01f, 4.32761274e-02f,
  2.70539582e-01f, -2.45926362e-02f, 1.52543962e-01f, 3.26379299e-01f, 2.34820336e-01f, 1.05846382e-03f, -1.08417392e-01f, 5.52255847e-02f, 5.97325526e-02f, 2.02819899e-01f,
  1.11341253e-01f, -7.28248581e-02f, 4.61471044e-02f, -1.22572243e-01f, -1.41273618e-01f, 2.08484858e-01f, -1.18357174e-01f, 2.68040840e-02f, 1.40829742e-01f, 1.28991038e-01f,
  4.55956832e-02f, 1.05516557e-02f, 1.43943563e-01f, 3.62569392e-02f, 2.43401974e-01f, 2.14216843e-01f, -1.12864085e-01f, -2.74198353e-02f, 1.64959021e-02f, 3.78271669e-01f,
  -2.28303913e-02f, 1.93105623e-01f, -1.03963546e-01f, 1.47110015e-01f, 1.45525606e-02f, 1.44148126e-01f, 3.00621271e-01f, -2.98783779e-01f, 1.82151929e-01f, 2.73117334e-01f,
  1.37840599e-01f, 2.35641912e-01f, -2.50243157e-01f, -5.58514744e-02f, 2.60771662e-01f, 1.98485389e-01f, -6.37624040e-02f, 6.98177442e-02f, -4.56941910e-02f, -5.02825901e-02f,
  3.90930742e-01f, 5.56569435e-02f, 9.33290794e-02f, -1.88009217e-02f, 1.03299627e-02f, -1.44048885e-01f, -7.21691176e-02f, -1.66452438e-01f, -5.40727787e-02f, -1.13037832e-01f,
  2.85186805e-02f, -6.80614561e-02f, -1.90025456e-02f, -2.43263900e-01f, 2.97322255e-02f, -3.19369495e-01f, 2.26956815e-01f, -8.77296701e-02f, -3.33054721e-01f, 2.84630984e-01f,
  -1.34101631e-02f, -8.49462580e-03f, 2.60279328e-01f, 1.00194953e-01f, 1.88204587e-01f, 1.43295461e-02f, 1.03623807e-01f, 5.88942021e-02f, 2.30206355e-01f, -3.09856981e-02f,
  5.17244078e-02f, 3.95450115e-01f, 4.57887277e-02f, -2.14341581e-02f, 6.12230338e-02f, 5.77282719e-02f, 6.95361272e-02f, -3.46653759e-02f, 5.70703894e-02f, -1.69622391e-01f,
  -1.95988625e-01f, -1.50983363e-01f, 1.44011855e-01f, 2.42592096e-01f, -5.08526601e-02f, -1.19818732e-01f, -4.86354157e-02f, -3.18416327e-01f, 1.68371662e-01f, -2.76655018e-01f,
  -9.27395448e-02f, 2.72087842e-01f, 3.38667706e-02f, 1.90677345e-01f, 5.26064113e-02f, 1.36239566e-02f, -3.11345439e-02f, -1.29687143e-02f, -1.50400743e-01f, 9.36489031e-02f,
  1.85060531e-01f, 1.49241313e-01f, -3.06230783e-02f, 4.08612996e-01f, 4.63815331e-02f, -5.52777480e-03f, 1.99796885e-01f, 1.44142687e-01f, -1.22683756e-02f, -1.13711320e-01f,
  6.05876409e-02f, 3.30927246e-03f, 1.37550816e-01f, 3.67631525e-01f, -7.29900002e-02f, -9.88335162e-02f, -2.49474198e-01f, 2.31513172e-01f, -1.21289290e-01f, 2.07605317e-01f,
  -1.26406163e-01f, -4.22050543e-02f, 3.20892364e-01f, 2.14919835e-01f, 2.39769712e-01f, 7.56731704e-02f, 1.04742385e-01f, -1.22962162e-01f, 3.63707751e-01f, 1.61989808e-01f,
  -5.49446493e-02f, 8.92558843e-02f, 4.69050556e-01f, -3.38897295e-02f, 3.12033147e-01f, -5.78265041e-02f, -2.10958153e-01f, -3.01758289e-01f, -8.56823381e-03f, -3.07811238e-02f,
  -6.40984327e-02f, -1.80588320e-01f, -8.65629986e-02f, 3.00041605e-02f, -6.68604812e-03f, -3.24931502e-01f, 2.01683253e-01f, 1.20947458e-01f, 2.01208051e-02f, 3.28622282e-01f,
  7.80647248e-02f, 8.70630220e-02f, 7.51558989e-02f, 4.84596878e-01f, 7.83020779e-02f, 2.47411698e-01f, -2.26250198e-02f, 3.04670870e-01f, 5.54947443e-02f, 1.86705619e-01f,
  -3.46989445e-02f, -3.81627321e-01f, 1.02742933e-01f, 2.38263071e-01f, -2.85472721e-01f, 1.40915111e-01f, 3.32102738e-02f, 1.36742726e-01f, 1.96601048e-01f, 2.44454220e-01f,
  2.08918005e-01f, -3.17923650e-02f, 2.50298381e-01f, 5.17939366e-02f, 2.06041768e-01f, 1.43547744e-01f, -2.61208653e-01f, 1.52816862e-01f, 1.52877837e-01f, 2.26497218e-01f,
  -3.03248584e-01f, -9.38921198e-02f, -2.61179775e-01f, -1.36318669e-01f, -3.84677708e-01f, -2.14447200e-01f, 1.27256081e-01f, -4.91494499e-02f, 3.27430993e-01f, 1.77936614e-01f,
  9.94158462e-02f, 6.00209534e-02f, -4.00189869e-02f, 3.27363759e-01f, 1.27485201e-01f, 1.85597092e-01f, 3.28040481e-01f, -4.23529744e-03f, -8.30581263e-02f, 1.12080738e-01f,
  -2.56772973e-02f, -2.06460148e-01f, 1.16199411e-01f, 1.28459573e-01f, 2.63985217e-01f, 2.70144165e-01f, 2.59197149e-02f, 2.37072469e-03f, -3.00040871e-01f, 1.26958057e-01f,
  3.86069208e-01f, 1.51229858e-01f, -1.62666008e-01f, 2.20048785e-01f, -7.01878816e-02f, 8.98983609e-03f, -4.78684045e-02f, -1.14306226e-01f, 2.81758845e-01f, 1.33279357e-02f,
  9.33977962e-02f, 6.72907606e-02f, 2.20158413e-01f, 3.59337062e-01f, -2.82168537e-01f, 1.69599250e-01f, 2.91319788e-02f, -1.77241430e-01f, -7.81190172e-02f, 3.30034137e-01f,
  -1.45730689e-01f, 1.18624829e-01f, 1.53084204e-01f, -2.22332999e-01f, 4.03209738e-02f, 7.35049471e-02f, 2.05751330e-01f, -9.21092480e-02f, 2.29022220e-01f, 1.14638545e-01f,
  4.05074917e-02f, 3.00088823e-01f, 5.53510450e-02f, 1.32331893e-01f, -1.79552615e-01f, -2.51668338e-02f, -1.63769037e-01f, -3.27933393e-03f, -2.23975733e-01f, -3.44650358e-01f,
  9.18075889e-02f, -7.57950246e-02f, 2.81991452e-01f, -8.37722197e-02f, 1.77040085e-01f, -3.78955081e-02f, 9.63487700e-02f, 3.87163162e-01f, 2.71996737e-01f, 1.53708056e-01f,
  3.22313845e-01f, -1.19339719e-01f, 1.47715107e-01f, 1.71445549e-01f, 3.40230390e-02f, -2.96502233e-01f, -1.60634041e-01f, -5.35768196e-02f, -2.74675310e-01f, -7.11838230e-02f,
  -3.17534775e-01f, -1.48141533e-01f, 8.42170492e-02f, -7.99726471e-02f, 8.58995989e-02f, -2.72422016e-01f, 2.75716871e-01f, 1.58486888e-01f, 3.14433783e-01f, 6.02292493e-02f,
  2.45888337e-01f, 3.52543712e-01f, -2.24898625e-02f, 3.86151582e-01f, -7.96033293e-02f, -8.17981809e-02f, 2.53772318e-01f, -3.00002079e-02f, 1.21727429e-01f, -2.10589021e-01f,
  -1.74971111e-02f, 1.08236521e-01f, -1.02350026e-01f, 3.98563713e-01f, 1.24476194e-01f, 4.40142155e-02f, 2.59836428e-02f, 3.10584784e-01f, -7.00934902e-02f, -3.37204970e-02f,
  -9.95641947e-03f, -6.24327175e-02f, 4.14184071e-02f, 4.02278975e-02f, -4.89367433e-02f, -1.25018418e-01f, -7.56925419e-02f, -4.51737829e-03f, 5.08968905e-02f, 3.03113181e-02f,
  1.08634727e-02f, 1.66645646e-02f, 4.61632796e-02f, 1.74941376e-01f, 1.08529683e-02f, -6.41704425e-02f, 5.51976599e-02f, 1.37857184e-01f, -1.83285028e-02f, 1.34249981e-02f,
  -2.26758718e-02f, -1.14355586e-01f, 1.72871768e-01f, 1.13405548e-01f, -1.32255062e-01f, -6.73676506e-02f, 1.17199235e-01f, -5.24003543e-02f, 6.43913001e-02f, 1.13560461e-01f,
  1.64557904e-01f, 1.39157306e-02f, 1.71602562e-01f, 2.56441176e-01f, -1.29421085e-01f, -6.88572973e-02f, -4.71883304e-02f, 3.40796500e-01f, 3.22728783e-01f, -8.05994943e-02f,
  4.72560786e-02f, -8.90638754e-02f, 3.78212035e-02f, 1.28931645e-02f, 1.79738447e-01f, -6.93718866e-02f, -1.64151758e-01f, 1.43959433e-01f, -6.12398759e-02f, -2.35783845e-01f,
  2.00128824e-01f, 4.08097774e-01f, -5.55166379e-02f, 2.80340642e-01f, 2.30708774e-02f, -3.47602248e-01f, 1.01778366e-01f, 3.75157624e-01f, -3.59558284e-01f, 1.82690218e-01f,
  -7.59016722e-02f, -7.71900043e-02f, 2.30834782e-02f, 5.81114739e-02f, -1.93496302e-01f, -3.33705217e-01f, 2.05482036e-01f, 1.26978997e-02f, -3.43927927e-02f, -2.55533457e-01f,
  -9.47421342e-02f, -5.95168993e-02f, -2.59827614e-01f, 1.44547880e-01f, -1.94671094e-01f, 8.61968473e-02f, -2.39664942e-01f, 2.03117952e-01f, 2.92474568e-01f, 4.28721875e-01f,
  1.90723822e-01f, 1.85172930e-01f, 1.47768661e-01f, -2.20781937e-01f, 4.62001950e-01f, -1.72219649e-01f, -1.32312262e-02f, 2.65618950e-01f, 3.94850284e-01f, -7.35051855e-02f,
  4.92453486e-01f, 2.51913611e-02f, -1.92760721e-01f, 1.91747248e-02f, 1.06401086e-01f, 4.54662889e-02f, 1.00025926e-02f, -1.05682030e-01f, -7.37120658e-02f, 1.03319839e-01f,
  -3.15698177e-01f, -3.26099724e-01f, 3.18345129e-01f, 2.83935100e-01f, 9.04598460e-03f, 2.57607371e-01f, -3.63123603e-02f, -4.72485907e-02f, 2.36461118e-01f, 1.16061799e-01f,
  1.57360137e-01f, 1.07328985e-02f, -6.57607242e-02f, 2.90182382e-01f, -9.01164934e-02f, 4.30139869e-01f, -1.95048332e-01f, -2.43158266e-01f, -1.55971460e-02f, 1.09824240e-02f,
  -2.52943516e-01f, 2.31821269e-01f, -1.22856803e-01f, 3.02276820e-01f, 3.71156037e-01f, 2.68650800e-01f, -1.87367216e-01f, -1.18410930e-01f, -1.18606322e-01f, -3.64551693e-01f,
  -1.28552578e-02f, -7.15745538e-02f, -4.41965908e-02f, -3.07053566e-01f, 8.62942636e-03f, -3.05097289e-02f, 2.98969746e-01f, -2.28343941e-02f, 1.32635161e-01f, -6.43172115e-02f,
  3.62223685e-01f, 1.32444113e-01f, -1.63016990e-01f, 1.10571064e-01f, 3.39242490e-03f, 8.27773511e-02f, 1.04763046e-01f, -1.75242946e-01f, 2.04579085e-01f, -2.20281318e-01f,
  1.91605091e-01f, 3.89945894e-01f, 2.04311281e-01f, -1.86080873e-01f, 1.07059412e-01f, 1.27830386e-01f, 2.54580885e-01f, 2.62388468e-01f, -1.97445415e-02f, 9.40377340e-02f,
  4.25258689e-02f, -1.09014310e-01f, -2.17586830e-02f, -1.50349975e-01f, 8.10176600e-03f, -1.89667791e-01f, 2.21090525e-01f, 2.12104693e-01f, -2.23983020e-01f, -1.84060514e-01f,
  -1.08857341e-01f, -2.12299153e-01f, -2.66587913e-01f, -1.25695929e-01f, -2.25883827e-01f, 3.19217324e-01f, 1.24237463e-02f, 1.87329635e-01f, 1.94096088e-01f, -9.70578864e-02f,
  -2.03060545e-02f, 6.69964030e-02f, -1.99798476e-02f, 1.63549989e-01f, 2.00099826e-01f, 1.06479712e-02f, 1.80928670e-02f, 2.81677663e-01f, -1.74680669e-02f, 6.74886554e-02f,
  5.11780009e-02f, 1.47017732e-01f, -8.38270262e-02f, 1.42512038e-01f, 7.27926716e-02f, 2.01913327e-01f, 2.60711133e-01f, 3.44965190e-01f, -1.68926254e-01f, -2.40131859e-02f,
  6.45486116e-02f, 2.86024302e-01f, -4.20064526e-03f, 2.93317318e-01f, -4.57066223e-02f, 2.20311210e-02f, 3.30040336e-01f, -4.93497252e-01f, 2.15376660e-01f, -2.18903366e-02f,
  5.45918234e-02f, 2.20636189e-01f, 1.08981065e-01f, 2.13839278e-01f, 1.95006013e-01f, -1.46408463e-02f, -9.53118354e-02f, -1.81423463e-02f, -3.43765393e-02f, -2.41569921e-01f,
  1.61067054e-01f, -3.10573913e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  3.93507592e-02f, 1.50818720e-01f, 1.00258172e-01f, 7.09070340e-02f, 1.14228753e-02f, -4.31859158e-02f, 2.32968535e-02f, -4.48407680e-02f, 1.18881464e-01f, -3.83871011e-02f,
  7.02291578e-02f, 1.32297635e-01f, 1.78431690e-01f, 9.03563127e-02f, -8.21028501e-02f, 2.41368443e-01f, 3.57821211e-02f, 1.47927199e-02f, -5.14435172e-02f, -1.37407845e-02f,
  1.77351668e-01f, -1.28202059e-03f, 2.32234262e-02f, -1.17016979e-01f, 7.13396445e-02f, 8.15273747e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -1.91427711e-02f, 1.36563599e-01f, -1.21622138e-01f, 2.13665381e-01f, 1.43255264e-01f, -7.66471215e-03f, 2.98033476e-01f, 4.95926403e-02f, 1.64308921e-01f, -1.41218394e-01f,
  -6.53086483e-01f, -1.29216671e-01f, -4.63638723e-01f, 4.49354798e-02f, 1.06303774e-01f, 2.26470232e-01f, -8.08844194e-02f, -1.26092955e-01f, 1.43264726e-01f, -2.80372649e-01f,
  3.57139468e-01f, -5.19028306e-02f, 5.77661954e-02f, -4.96659964e-01f, 1.87948391e-01f, -7.02179000e-02f, -1.86170042e-02f, 8.52155313e-02f, 2.75370717e-01f, -2.35766143e-01f,
  2.30922863e-01f, -3.75960439e-01f, -1.43497974e-01f, 5.96651845e-02f, 1.87477142e-01f, -7.20125660e-02f, -1.09502159e-01f, -1.13807067e-01f, -1.16311073e-01f, 3.24278891e-01f,
  -3.64779949e-01f, 8.19901824e-02f, -4.32011396e-01f, -3.01017106e-01f, -1.13823242e-01f, -5.30507863e-01f, -2.93946862e-01f, 1.04548343e-01f, 3.23208421e-01f, -1.73734441e-01f,
  -4.42906171e-01f, 1.99680462e-01f, 2.06522807e-01f, 1.50420323e-01f, 9.83487219e-02f, 5.72113357e-02f, -1.47014454e-01f, 5.72174378e-02f, -5.52759767e-01f, 2.66336620e-01f,
  1.77867059e-02f, -1.52336344e-01f, -3.82960707e-01f, 3.75645645e-02f, -3.16378437e-02f, -6.52502403e-02f, 5.19494452e-02f, 1.73371136e-01f, -1.61207661e-01f, 1.74022168e-01f,
  -3.40728201e-02f, 7.97291771e-02f, -2.11405784e-01f, 2.03503177e-01f, 7.57842213e-02f, -2.11300284e-01f, 2.83445507e-01f, 1.52665809e-01f, -3.64571780e-01f, -7.75508117e-03f,
  -1.12252846e-01f, -2.85564661e-01f, -8.40899050e-02f, 2.18237951e-01f, 7.88681135e-02f, -3.88558596e-01f, -4.23211843e-01f, -9.97979268e-02f, 2.22125858e-01f, 6.87290803e-02f,
  -2.52122462e-01f, 2.38711551e-01f, -4.59170699e-01f, 1.77539825e-01f, -1.12343304e-01f, 7.56680965e-02f, 3.03277071e-03f, -1.28542721e-01f, 1.15539029e-01f, -9.05978680e-02f,
  2.02765554e-01f, 1.07518218e-01f, 3.66963059e-01f, -5.33299625e-01f, 7.76921734e-02f, -5.15362382e-01f, -2.25081161e-01f, -2.69494563e-01f, -1.48717597e-01f, 7.63714090e-02f,
  -1.09504573e-02f, 5.27433492e-02f, -4.48575348e-01f, 1.94377422e-01f, 2.32831746e-01f, 9.94486436e-02f, 1.67571366e-01f, -2.54667729e-01f, -7.83107951e-02f, -1.95099652e-01f,
  3.33099812e-01f, 1.06905531e-02f, -1.15042582e-01f, 3.16329658e-01f, 1.01266325e-01f, 1.48745611e-01f, 2.04475746e-01f, -1.32015310e-02f, -3.67239453e-02f, 1.00999132e-01f,
  -1.11014150e-01f, -3.69865030e-01f, 2.35949025e-01f, 3.64757329e-02f, 8.90751556e-02f, -1.53474182e-01f, 3.02505583e-01f, -4.52384591e-01f, 6.25388771e-02f, -2.71024555e-01f,
  -3.79726827e-01f, 1.87193885e-01f, 2.95285344e-01f, -5.71243018e-02f, -4.65408295e-01f, 1.35378480e-01f, 2.46518962e-02f, 6.32419139e-02f, -1.61772609e-01f, 3.11089724e-01f,
  2.71045059e-01f, 2.09421627e-02f, 1.10110715e-01f, -6.95890654e-03f, 3.50431144e-01f, -2.54656792e-01f, -1.56726316e-01f, -4.43776876e-01f, 7.50025138e-02f, -4.26736206e-01f,
  4.61589471e-02f, -4.05596979e-02f, 5.05018048e-02f, 2.59265691e-01f, -1.40359849e-01f, -2.81293809e-01f, -1.23176716e-01f, 1.75616354e-01f, 3.35507661e-01f, -3.32516581e-02f,
  -1.58073470e-01f, 2.26483315e-01f, -4.29702193e-01f, -2.65994698e-01f, 8.20377246e-02f, 1.06393397e-02f, 1.67029083e-01f, -2.87652463e-01f, 3.43288928e-02f, -2.44504660e-02f,
  -7.67318532e-02f, 1.36181027e-01f, 3.79420280e-01f, 9.92928892e-02f, -3.95211965e-01f, -1.61714837e-01f, 3.92047949e-02f, -6.49240077e-01f, 1.10069111e-01f, -2.08445609e-01f,
  -1.65209696e-01f, 1.39369115e-01f, -1.25448070e-02f, -1.37450220e-02f, 1.41236484e-01f, -1.41257867e-01f, -6.70218766e-02f, 1.07250340e-01f, -9.57333073e-02f, 1.06506042e-01f,
  -9.83371139e-02f, 1.97046325e-01f, 2.94811130e-01f, -3.39812428e-01f, -4.33225147e-02f, -2.91303873e-01f, 3.93502712e-02f, -5.22609830e-01f, 8.84387456e-03f, -2.63263255e-01f,
  -3.02988499e-01f, 3.53979021e-01f, -5.33139944e-01f, 3.40132356e-01f, -1.92338973e-01f, 3.74143034e-01f, -3.58921796e-01f, -1.59822494e-01f, -2.30474114e-01f, 2.63968706e-01f,
  -4.67920125e-01f, -2.30119556e-01f, -1.74254954e-01f, 1.82974786e-01f, 1.34609923e-01f, -1.65543541e-01f, 3.23899686e-02f, -1.11920396e-02f, 7.79301766e-03f, -1.41412225e-02f,
  -1.74788192e-01f, -1.79895237e-01f, 1.06004544e-01f, -1.52827904e-01f, 2.75669526e-02f, 8.69268104e-02f, 1.91534042e-01f, 1.91011116e-01f, 4.13045324e-02f, 2.12342307e-01f,
  -2.56490469e-01f, 1.13278501e-01f, 9.39466730e-02f, -3.61846387e-01f, 1.19009204e-01f, -3.09145451e-01f, 8.08053091e-02f, -3.44828129e-01f, 2.27868721e-01f, -1.63916484e-01f,
  1.01158425e-01f, -3.14883798e-01f, 1.20032124e-01f, 2.44774789e-01f, -2.92018741e-01f, -2.49176398e-01f, -3.48814614e-02f, 7.84568042e-02f, 9.75773856e-02f, -2.55589690e-02f,
  -9.99150053e-02f, 2.23459318e-01f, -4.31830548e-02f, 7.07656294e-02f, -1.89173892e-01f, 4.02171500e-02f, -1.91681758e-01f, 3.25889975e-01f, 8.39980617e-02f, 1.86242640e-01f,
  -2.95485467e-01f, -5.40423729e-02f, 2.11055383e-01f, -1.96785748e-01f, -2.02658236e-01f, -4.59795505e-01f, 1.78222850e-01f, -2.70577043e-01f, -2.69366890e-01f, -2.46725172e-01f,
  2.80630380e-01f, 2.89285451e-01f, -2.67525345e-01f, -2.48766199e-01f, 2.52947062e-01f, 2.11079642e-01f, -1.95545629e-01f, 7.16333464e-02f, 1.31842658e-01f, 1.50300965e-01f,
  -1.69898540e-01f, 3.10394913e-03f, -9.00124311e-02f, -1.12848960e-01f, -3.31704766e-01f, -1.39488325e-01f, 1.88860714e-01f, -6.33232966e-02f, 3.14335853e-01f, 2.05976665e-01f,
  9.19622108e-02f, 2.38037035e-01f, 1.92496553e-01f, 2.03176171e-01f, -5.43071590e-02f, -1.56787500e-01f, -4.41093177e-01f, 8.50636438e-02f, -3.00036103e-01f, -1.10108420e-01f,
  -1.49547562e-01f, 8.54303688e-02f, 2.50359178e-01f, -7.48189241e-02f, 5.94992079e-02f, -2.30379984e-01f, -3.91240835e-01f, -2.87340015e-01f, -1.62401304e-01f, 1.32311568e-01f,
  5.01127504e-02f, 9.69195142e-02f, -5.23803309e-02f, -2.49222845e-01f, -7.37339929e-02f, -2.16125593e-01f, 1.43839285e-01f, -3.49235266e-01f, -3.71226966e-01f, -6.83306754e-02f,
  -1.15836099e-01f, -3.10825676e-01f, 7.64781535e-02f, -3.80121887e-01f, 6.74984679e-02f, -3.71705920e-01f, -2.13672072e-01f, 2.44029775e-01f, 2.40379900e-01f, 3.35425198e-01f,
  -1.95526376e-01f, 2.66208887e-01f, -2.59599835e-01f, 3.00174683e-01f, -1.73808746e-02f, -3.42505015e-02f, -2.37908408e-01f, 3.99489999e-01f, -5.20188332e-01f, 1.88836768e-01f,
  2.91179836e-01f, -2.99465299e-01f, -7.72561505e-02f, 4.57977094e-02f, -1.01383805e-01f, 1.74128249e-01f, 1.88822672e-01f, 7.69995004e-02f, -2.63637602e-01f, -8.10187832e-02f,
  -3.46901119e-01f, 1.42660856e-01f, 1.31927669e-01f, 2.81742692e-01f, 9.46474355e-03f, -1.37071341e-01f, -8.31701607e-02f, -3.43935788e-02f, 1.62140682e-01f, 2.78946936e-01f,
  1.92209333e-01f, -1.98454514e-01f, 7.28759021e-02f, 2.78479517e-01f, -4.96055409e-02f, 2.02394858e-01f, -3.72751474e-01f, 8.76545254e-03f, -1.63431421e-01f, -7.84856752e-02f,
  9.69817191e-02f, 2.55937248e-01f, 2.34348655e-01f, -3.73972654e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.38085941e-02f, 5.61530292e-02f, -1.47788227e-01f, -2.04796299e-01f, 4.75749820e-02f, 1.58759430e-01f, 4.20778000e-04f, -9.51629654e-02f, -6.66620731e-02f, -4.77862246e-02f,
  7.69435689e-02f, 2.69844998e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    