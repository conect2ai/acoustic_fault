/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.50757924e-01f, 1.90291181e-01f, 2.18344152e-01f, -3.56806139e-03f, -5.63886017e-02f, 7.41865411e-02f, -5.19069396e-02f, 6.29856288e-02f, 7.13001415e-02f, 8.36992413e-02f,
  2.19882466e-03f, 3.82537395e-02f, 6.41936138e-02f, -1.05101734e-01f, -6.58113211e-02f, 7.20932335e-02f, -1.22267045e-01f, -1.32148013e-01f, -2.29121894e-02f, -6.84640780e-02f,
  -7.33501185e-03f, -2.12552939e-02f, 2.66918316e-02f, -5.25378734e-02f, 1.74009278e-02f, 1.11973226e-01f, 6.24664407e-03f, -2.29086671e-02f, 4.02948819e-02f, -1.21969059e-01f,
  2.62713224e-01f, -1.95682384e-02f, -1.58609208e-02f, 1.29292049e-02f, 1.47157311e-02f, -7.82249589e-03f, 3.89700048e-02f, 6.80912733e-02f, -1.51325297e-02f, 1.67440567e-02f,
  -8.10302049e-02f, -1.10962361e-01f, -3.03897168e-02f, -7.16732293e-02f, -1.05843395e-02f, -5.56939542e-02f, -4.09365855e-02f, -1.76519156e-02f, -5.97064905e-02f, 1.09104954e-01f,
  -6.64959326e-02f, -4.76893708e-02f, 1.86115168e-02f, 8.70926604e-02f, -1.34674236e-01f, -1.03401951e-01f, -3.07234526e-02f, -6.95056245e-02f, -4.74184416e-02f, 1.35218501e-01f,
  -1.95351504e-02f, 4.43456583e-02f, 4.54958454e-02f, -2.51370110e-02f, 5.00843255e-03f, 4.40505482e-02f, -6.03715815e-02f, 1.79633573e-02f, -2.94616316e-02f, 7.31495097e-02f,
  -5.79777407e-03f, 2.87075080e-02f, -7.06492178e-03f, 3.15984413e-02f, 6.06766455e-02f, 3.88612822e-02f, -7.75368437e-02f, 8.94994196e-03f, 1.41829439e-02f, -6.63453564e-02f,
  -4.39341366e-02f, -3.87987262e-03f, 5.15498668e-02f, -3.64648961e-02f, -4.92503382e-02f, -2.32185889e-02f, -2.38471925e-02f, 5.26113901e-03f, 6.04809076e-03f, -1.98047236e-03f,
  3.05318356e-01f, -1.86853945e-01f, -1.85648594e-02f, 9.14839562e-03f, 2.31007542e-02f, -5.14487326e-02f, -6.60324702e-04f, -6.38622642e-02f, 9.77008883e-03f, 3.56146879e-02f,
  3.41359116e-02f, 1.58543643e-02f, 4.47029844e-02f, 9.76334140e-03f, 5.09107206e-03f, 8.79713744e-02f, 3.83196473e-02f, 1.27347745e-02f, -2.19069887e-02f, 5.55829629e-02f,
  -3.95506918e-02f, 4.07520570e-02f, 1.27345756e-01f, 3.63049991e-02f, 1.67852025e-02f, 3.75261297e-03f, 1.88343391e-01f, 6.41731843e-02f, 1.89501017e-01f, 3.17307711e-01f,
  -9.58102822e-01f, -7.30544478e-02f, -8.13523084e-02f, -1.85149878e-01f, 9.56126451e-02f, 2.50004262e-01f, 2.07330123e-01f, 1.67020693e-01f, -3.24567296e-02f, -1.13875158e-01f,
  -1.77153118e-03f, -9.17498320e-02f, -1.60472438e-01f, 1.04673192e-01f, -7.86918104e-02f, -1.00087970e-02f, 1.26513857e-02f, -1.42000601e-01f, 6.03987500e-02f, 2.62129933e-01f,
  2.65015692e-01f, -2.09964551e-02f, -2.48898283e-01f, 1.05820410e-03f, 4.07754723e-03f, -3.05391140e-02f, -7.84193426e-02f, -5.13880998e-02f, 6.42309561e-02f, 6.44662976e-02f,
  -5.44006936e-02f, -1.00595132e-01f, 1.56668156e-01f, 5.66084287e-04f, 2.93314327e-02f, -3.58051024e-02f, -1.64084267e-02f, 1.83428393e-03f, -2.04919614e-02f, 6.21514134e-02f,
  -6.96746111e-02f, 5.84253781e-02f, -1.01577237e-01f, 8.72602165e-02f, 6.87665306e-03f, 8.54030252e-02f, -4.83741276e-02f, 2.42549460e-02f, -3.08635682e-02f, -3.01787686e-02f,
  8.92369971e-02f, -4.00314853e-02f, -1.09715484e-01f, 1.60929367e-01f, -2.24450100e-02f, -5.14391111e-03f, 1.47295920e-02f, 3.64393629e-02f, 3.99247631e-02f, 4.57703657e-02f,
  8.51466060e-02f, -4.15348336e-02f, 5.26131652e-02f, 3.03204115e-02f, -4.44102399e-02f, -1.19102467e-03f, -4.63230349e-02f, 7.14281723e-02f, 1.45242168e-02f, -5.22391200e-02f,
  6.52188249e-03f, -1.81639437e-02f, 3.52530740e-02f, -4.50082198e-02f, -2.35572811e-02f, 9.60900076e-03f, -2.67108772e-02f, 1.37245590e-02f, -3.85445394e-02f, -4.46319729e-02f,
  2.69746799e-02f, -9.13039315e-03f, -5.35071418e-02f, 3.17304470e-02f, 1.98218729e-02f, -1.32021476e-02f, -1.94684858e-03f, 2.93077994e-02f, -5.97241037e-02f, 3.91345061e-02f,
  -1.05498359e-01f, 5.43962047e-02f, -1.13223612e-01f, -6.99711964e-03f, -8.26729015e-02f, -2.10905988e-02f, -1.01429604e-01f, 1.77923199e-02f, -6.05456419e-02f, 1.87359266e-02f,
  5.80846444e-02f, -7.62883201e-02f, -3.30099203e-02f, 2.82071345e-02f, 1.36954412e-02f, 1.02897016e-02f, -9.11910385e-02f, -5.09800613e-02f, 1.01915099e-01f, 3.38083729e-02f,
  -4.23399508e-02f, 6.11785725e-02f, -6.90271184e-02f, -7.05605224e-02f, 7.56713003e-02f, -8.21951926e-02f, 3.99705544e-02f, 3.54426578e-02f, -6.91345185e-02f, 2.12806204e-04f,
  3.69507015e-01f, -7.45488554e-02f, 3.92993450e-01f, -1.85889043e-02f, -1.50406584e-01f, -2.16089875e-01f, -3.53344440e-01f, -2.58732378e-01f, -3.52996290e-02f, -1.98610827e-01f,
  6.69851676e-02f, 6.38361881e-03f, 1.23186283e-01f, -5.04421331e-02f, 6.42938241e-02f, -1.60682559e-01f, 9.03257951e-02f, 3.13121945e-01f, 1.14635907e-01f, -8.73131603e-02f,
  -1.24296106e-01f, -2.44611427e-02f, 2.07166150e-01f, 4.76644328e-03f, 1.24123141e-01f, -6.16633035e-02f, 2.91334912e-02f, 1.87382817e-01f, -6.45500720e-02f, 2.56284177e-01f,
  2.52992839e-01f, 2.56374657e-01f, -1.09246053e-01f, -2.25139521e-02f, 7.67293498e-02f, 1.16884848e-02f, -1.39396414e-02f, 8.65545943e-02f, 2.31693555e-02f, -3.13702710e-02f,
  1.30781472e-01f, 4.06813361e-02f, 1.65110230e-01f, -5.25755715e-03f, 2.16182074e-04f, 3.84065956e-02f, 6.56296685e-02f, 9.73284170e-02f, 5.43806106e-02f, 1.89682972e-02f,
  -1.11556076e-01f, 1.05842903e-01f, 1.86627373e-01f, -1.24716118e-01f, 2.43297871e-02f, 7.21799955e-02f, 5.49358465e-02f, 3.06534488e-02f, -1.68358032e-02f, 2.66313590e-02f,
  -7.47821853e-02f, 3.76071259e-02f, 5.03688492e-02f, -8.93329084e-03f, -2.90246550e-02f, -2.45618261e-02f, -4.04486572e-03f, 1.57387219e-02f, -4.81991880e-02f, -2.19688099e-02f,
  2.11705342e-02f, 1.07164597e-02f, 1.76749553e-03f, -3.74931321e-02f, 7.07637612e-03f, 6.76416010e-02f, -9.49623005e-04f, -3.88544463e-02f, -1.76359527e-02f, 2.03717910e-02f,
  -1.26369204e-02f, 4.56246585e-02f, 7.15670409e-04f, 6.53593764e-02f, -6.23678118e-02f, 8.29222500e-02f, -1.06955878e-02f, -4.80747968e-02f, 1.69554818e-02f, -2.47581806e-02f,
  -2.37545922e-01f, 1.23070963e-01f, -7.67037198e-02f, -1.01659531e-02f, 1.30989492e-01f, -4.14719582e-02f, 1.59728881e-02f, 6.90870658e-02f, 3.80882286e-02f, 7.27891107e-04f,
  -4.58964631e-02f, -6.07475778e-03f, -4.69982401e-02f, -1.95886511e-02f, -1.70843340e-02f, -5.74304536e-02f, -2.58518588e-02f, 2.25129593e-02f, -4.92161401e-02f, 5.48514500e-02f,
  -1.15123123e-01f, -1.14575416e-01f, -7.09924921e-02f, -1.16680048e-01f, -8.96409154e-02f, -5.38688060e-03f, -7.97274709e-02f, 3.21329311e-02f, -2.60192039e-03f, -4.30934399e-01f,
  -3.55808347e-01f, 1.98131576e-02f, -3.75823319e-01f, -3.19055771e-03f, -6.64348453e-02f, -6.04906864e-02f, -9.37012881e-02f, 1.38644740e-01f, 4.54402231e-02f, -1.17190450e-01f,
  1.06701806e-01f, 1.23447530e-01f, 2.40265697e-01f, 1.85336977e-01f, 1.13551319e-01f, -1.39070019e-01f, -2.00790197e-01f, -1.17145985e-01f, -9.43499506e-02f, -1.46899875e-02f,
  1.94410965e-01f, 7.14956149e-02f, 9.23785493e-02f, 1.68061584e-01f, -2.64599919e-01f, -1.06252432e-01f, -1.55367404e-01f, -2.08200574e-01f, -5.76674417e-02f, -4.50194597e-01f,
  -4.00622368e-01f, -1.24207839e-01f, 1.22209229e-01f, 9.98621359e-02f, -8.67728069e-02f, -3.91531624e-02f, -1.99158620e-02f, -3.80007550e-02f, 5.86766861e-02f, -4.03662324e-02f,
  3.16628031e-02f, 2.95423754e-02f, 6.32395921e-03f, -2.82859639e-03f, -9.46364254e-02f, 4.72610258e-02f, 3.92508991e-02f, -1.34210065e-02f, -8.75732861e-03f, -7.83295259e-02f,
  1.05871670e-01f, -3.38069610e-02f, -1.43725842e-01f, -1.51088357e-03f, -4.14207876e-02f, -2.58256625e-02f, -1.27496406e-01f, -1.66904718e-01f, -1.43496424e-01f, -3.09463590e-01f,
  5.59523217e-02f, -4.86071780e-02f, 1.26930175e-03f, 6.77480102e-02f, 8.79175812e-02f, 1.80547684e-03f, 9.93878767e-03f, 5.29197790e-02f, 6.31491020e-02f, -5.66521212e-02f,
  1.10663861e-01f, -5.98274320e-02f, 5.71336001e-02f, -4.55499925e-02f, 5.12678027e-02f, -4.84316275e-02f, -8.68531060e-04f, -1.61787532e-02f, 5.96290715e-02f, -2.04350092e-02f,
  5.41920625e-02f, -5.17407022e-02f, -3.06590497e-02f, -2.46338397e-02f, -4.96262126e-02f, 2.24114419e-03f, -4.27748039e-02f, -1.73381735e-02f, 8.53277594e-02f, 5.14346212e-02f,
  1.30849272e-01f, 1.41749129e-01f, -1.67327061e-01f, -5.81418648e-02f, -6.89885812e-04f, -3.35444994e-02f, -7.12173991e-03f, 4.89083864e-02f, 5.41148372e-02f, -5.32166399e-02f,
  -2.29975656e-02f, -2.34263949e-02f, -2.07170728e-03f, 4.04772162e-02f, 4.04712558e-02f, 2.84470282e-02f, 9.54736322e-02f, 1.48191145e-02f, -2.68981066e-02f, -1.48447296e-02f,
  1.32781016e-02f, -1.86366998e-02f, -3.15766642e-03f, -4.36144955e-02f, -1.18867941e-01f, -1.04204370e-02f, -5.30677959e-02f, -2.09737465e-01f, -6.24313280e-02f, 5.37068099e-02f,
  5.49133182e-01f, -3.94453228e-01f, -2.29868712e-03f, -1.02387294e-02f, -3.55830044e-01f, -2.71484584e-01f, -3.74393880e-01f, 1.02038562e-01f, 1.78014591e-01f, -1.69128820e-01f,
  -2.47155234e-01f, 7.37000629e-02f, -2.73343213e-02f, -9.79721919e-03f, 8.99958238e-02f, -7.88142905e-02f, 3.83876893e-03f, 1.85465530e-01f, 3.63788545e-01f, 9.48799998e-02f,
  -1.25152573e-01f, 1.67270690e-01f, 4.10830677e-01f, 1.97220013e-01f, -1.12685822e-01f, 8.45699906e-02f, -4.17549685e-02f, 1.62925832e-02f, -1.23527601e-01f, -2.80922711e-01f,
  -1.40672326e-01f, 1.36828832e-02f, 1.30451262e-01f, 1.43613182e-02f, -7.57374018e-02f, 1.16135485e-01f, -1.07476590e-02f, 9.12043080e-02f, 3.92999426e-02f, 1.48762139e-02f,
  -3.07779554e-02f, 3.34211588e-02f, 9.14332122e-02f, 6.07866570e-02f, 4.41965684e-02f, 1.65913016e-01f, 1.03070453e-01f, 2.15340942e-01f, 1.25657171e-01f, 5.56453541e-02f,
  -1.80875883e-01f, -1.92549363e-01f, 1.92235559e-02f, -2.35403106e-02f, 1.07968725e-01f, -1.50430831e-03f, -7.23565593e-02f, 3.72814797e-02f, 8.82766619e-02f, 2.14659926e-02f,
  -4.10431577e-03f, -7.15925694e-02f, -1.91025306e-02f, 7.34625384e-02f, -5.13224751e-02f, 1.38029056e-02f, -2.66154278e-02f, 2.84410119e-02f, 7.75486082e-02f, -1.46224787e-02f,
  1.22275704e-03f, -4.14128229e-02f, 2.65314747e-02f, 8.04665014e-02f, -2.30363514e-02f, -1.13446238e-02f, -4.95457910e-02f, 4.83398847e-02f, -1.87646709e-02f, 2.50490997e-02f,
  1.35957360e-01f, -1.13440774e-01f, -1.07849278e-02f, 3.21612693e-02f, -4.39629741e-02f, -4.78875861e-02f, 1.08623914e-01f, -3.60796601e-02f, 1.21810339e-01f, 1.30680539e-02f,
  9.56784263e-02f, -1.07464701e-01f, 8.76994431e-02f, 1.97824046e-01f, -5.29973544e-02f, 2.87390910e-02f, -9.80615169e-02f, 4.40372303e-02f, -4.57262574e-03f, 5.45996390e-02f,
  1.57220047e-02f, 8.29504281e-02f, -8.02320912e-02f, 7.49403015e-02f, 5.11589795e-02f, 6.95026480e-03f, 7.05389008e-02f, 3.31104584e-02f, 4.31870893e-02f, -5.20585896e-03f,
  -4.39376011e-02f, 6.99937195e-02f, 8.81586373e-02f, 7.31007755e-02f, 9.44557227e-03f, 1.01228073e-01f, -3.19084451e-02f, 3.93257625e-02f, 1.80044159e-01f, 9.46599469e-02f,
  1.31483227e-01f, -2.76020259e-01f, -9.73355174e-02f, 3.04704458e-02f, -6.31045736e-03f, -3.88761461e-02f, -3.66493344e-01f, 3.61459032e-02f, 1.85980573e-01f, -1.59688368e-01f,
  -6.76860511e-02f, 8.51815343e-02f, 1.31161302e-01f, 8.71860385e-02f, 1.94357205e-02f, -2.62829274e-01f, -1.04641743e-01f, 6.44006059e-02f, 1.80589780e-01f, 9.32955742e-02f,
  -9.40358490e-02f, 2.96987332e-02f, 1.48089811e-01f, 1.22666441e-01f, -8.56081322e-02f, 1.25296086e-01f, -5.21344580e-02f, -2.46115718e-02f, -2.32492030e-01f, -2.77585924e-01f,
  -1.02801584e-01f, -1.31820574e-01f, 1.07705519e-01f, -1.76104996e-02f, 4.62705716e-02f, 4.01902795e-02f, 2.02689413e-02f, 7.53386319e-02f, 6.94599673e-02f, 1.94726977e-02f,
  -2.53960565e-02f, -4.51826565e-02f, -2.43618079e-02f, 4.60715257e-02f, 9.45850741e-03f, -5.04515022e-02f, 1.59019399e-02f, 1.55196982e-02f, 2.37922631e-02f, -1.12363860e-01f,
  -1.22388564e-01f, -1.81712568e-01f, -1.04702383e-01f, -2.62355618e-02f, 1.13731995e-02f, 1.12789594e-01f, -4.59036976e-02f, -6.05687462e-02f, -3.78028601e-02f, -2.30679917e-03f,
  2.55100466e-02f, -4.76024998e-03f, -7.14019015e-02f, -5.01185656e-03f, 4.04243395e-02f, 1.48474239e-02f, -3.85241234e-03f, -1.32617010e-02f, -2.99079064e-02f, 2.37031821e-02f,
  -2.57414840e-02f, -6.40837103e-02f, 2.99707130e-02f, 1.77232791e-02f, 1.17193097e-02f, -5.27841263e-02f, 4.60929377e-03f, -3.09342220e-02f, 2.51583643e-02f, -1.45936310e-02f,
  -4.79262918e-02f, -3.57812317e-03f, 2.71803606e-02f, 1.20648891e-02f, -9.90593880e-02f, 1.59049183e-02f, -6.17080256e-02f, 1.95606161e-04f, 9.01161209e-02f, -2.08188612e-02f,
  4.26197886e-01f, -1.67954415e-01f, -5.07385377e-03f, 1.55473202e-02f, -8.28301813e-03f, 3.76438946e-02f, 3.25563811e-02f, 2.70054936e-02f, -1.38818263e-03f, -1.11005753e-02f,
  -8.17062631e-02f, 2.08600219e-02f, 4.62417305e-03f, -1.11038998e-01f, 2.07368471e-03f, 2.46293955e-02f, -4.32447046e-02f, 2.50893068e-02f, -8.03240463e-02f, 7.79168855e-04f,
  -5.88718764e-02f, 8.04459527e-02f, 7.95361251e-02f, 5.37191220e-02f, 5.60468920e-02f, 1.55773416e-01f, 2.01814473e-02f, 5.69717176e-02f, -2.57730726e-02f, 1.51071697e-01f,
  1.47097353e-02f, 6.69515356e-02f, 1.82112664e-01f, -5.08377962e-02f, 2.12850496e-01f, 4.00941879e-01f, 4.77595448e-01f, 2.66619120e-02f, -9.01428089e-02f, 8.55232682e-03f,
  5.25101721e-02f, 5.58019057e-02f, 3.07708737e-02f, -3.63064110e-02f, -1.68718733e-02f, 5.69912866e-02f, -2.46899892e-02f, -1.91546157e-02f, 9.08906534e-02f, 6.23306483e-02f,
  -4.31652330e-02f, -5.34222685e-02f, -1.25494376e-01f, -1.53808072e-01f, -5.45900427e-02f, 1.22183368e-01f, -4.17945758e-02f, 2.11481322e-02f, -6.53448105e-02f, -1.20833881e-01f,
  2.03271016e-01f, -6.95468113e-02f, 1.38454363e-01f, -5.78150079e-02f, -3.23268250e-02f, -7.36306012e-02f, 8.15438852e-02f, -4.24190946e-02f, 5.27753457e-02f, -5.96835203e-02f,
  8.59806128e-03f, -5.85773848e-02f, 7.87696019e-02f, -5.52605093e-02f, -3.26145031e-02f, -4.86288499e-03f, -1.94544524e-01f, -1.10337682e-01f, -5.24960943e-02f, -6.86663166e-02f,
  -1.05196424e-03f, 1.08477063e-01f, 1.70476988e-01f, 5.06303534e-02f, -1.84722934e-02f, -1.19031966e-01f, -8.08252115e-03f, -1.01702489e-01f, 4.72807838e-03f, -1.10839829e-01f,
  -6.13222942e-02f, 2.32251436e-02f, 6.93496177e-03f, 2.90242769e-02f, 3.81619781e-02f, -1.64414980e-02f, -3.81535152e-03f, 1.32767662e-01f, -5.30345812e-02f, -4.87742107e-03f,
  -2.46444941e-02f, -7.22793723e-03f, 1.21973185e-02f, -1.01874610e-02f, -4.98633385e-02f, -2.84231044e-02f, 2.78724451e-02f, 2.92684548e-02f, -5.22623248e-02f, -9.45677832e-02f,
  -4.21811491e-02f, 6.86144605e-02f, -8.98568984e-03f, -5.52138267e-03f, -8.43590274e-02f, -3.68614309e-02f, -1.90267079e-02f, -1.73765607e-02f, 7.27998046e-03f, 1.61228441e-02f,
  3.53431255e-02f, 1.57930283e-03f, 1.10930502e-01f, -3.27344164e-02f, 8.23000669e-02f, -2.63334811e-02f, 7.27100149e-02f, -6.70962185e-02f, 2.53977589e-02f, 7.91552067e-02f,
  8.10343027e-02f, 1.85931325e-02f, 4.68577556e-02f, -6.55534789e-02f, 1.10966243e-01f, 6.92487136e-02f, 2.91614737e-02f, 7.85579309e-02f, -1.01350080e-02f, -9.87791866e-02f,
  9.52721399e-04f, 1.09740458e-01f, 7.34815598e-02f, 1.63409024e-01f, 9.36061367e-02f, 1.46384254e-01f, 2.44006455e-01f, 1.02597676e-01f, 1.58463940e-01f, 1.34134144e-01f,
  3.82566839e-01f, 6.68086112e-02f, 1.66039541e-01f, 2.38222972e-01f, 5.49491458e-02f, -4.13909182e-02f, 2.99860090e-02f, -4.38654236e-02f, 3.74930985e-02f, 4.73320186e-02f,
  -1.25835925e-01f, -1.15334496e-01f, 4.27082777e-02f, 2.32246574e-02f, 2.30067838e-02f, 1.64903089e-01f, 2.64813751e-01f, 2.01795802e-01f, 5.44165075e-02f, -1.44576862e-01f,
  2.79794205e-02f, 2.16593176e-01f, 1.31390288e-01f, 6.20005354e-02f, 1.98215052e-01f, 3.93404672e-03f, 8.44119191e-02f, 8.43396857e-02f, -1.36131272e-01f, 2.65155643e-01f,
  1.66126654e-01f, -4.79742326e-02f, -8.03135484e-02f, -2.63673300e-03f, -5.78387342e-02f, -5.05736284e-02f, -7.28108212e-02f, 3.82020697e-02f, -8.63354281e-02f, 5.22123836e-02f,
  -3.46101820e-02f, -2.95734573e-02f, 4.76682335e-02f, -4.48839962e-02f, 1.45100027e-01f, -3.65283862e-02f, 5.53235225e-02f, 1.15657829e-01f, 2.59782132e-02f, 9.92058543e-04f,
  -5.59270829e-02f, 4.94436128e-03f, 6.66592792e-02f, -9.76149440e-02f, -5.52012883e-02f, 2.07829452e-03f, -8.99775475e-02f, -2.79565230e-02f, -1.47971869e-01f, 1.39322896e-02f,
  2.01760270e-02f, -3.19366867e-04f, -5.58064841e-02f, 1.47388205e-02f, 4.91022170e-02f, -1.01889214e-02f, 4.01400775e-02f, 5.26907817e-02f, -9.32376646e-03f, -1.10109318e-02f,
  -2.50616446e-02f, -2.76244562e-02f, 3.36720385e-02f, -2.40846118e-03f, 5.95303401e-02f, -1.29303271e-02f, 2.27290131e-02f, -1.77781787e-02f, 2.85108127e-02f, -2.78185196e-02f,
  1.55323958e-02f, -5.89949079e-02f, 2.49730181e-02f, -9.01662260e-02f, 4.19198498e-02f, 3.83652537e-03f, 2.35683899e-02f, -9.70514640e-02f, -1.48969993e-03f, 2.85154637e-02f,
  6.59070686e-02f, -2.68966913e-01f, 1.38983428e-01f, -2.08241530e-02f, 4.05447893e-02f, 6.24519400e-03f, 5.80582768e-02f, 6.57163281e-03f, 1.51037714e-02f, 8.85860529e-03f,
  -7.84508809e-02f, 4.19965433e-03f, 6.16015196e-02f, -2.21026819e-02f, -3.85700241e-02f, 2.21401779e-03f, -4.27190261e-03f, 2.41615139e-02f, -2.68555917e-02f, -5.04110716e-02f,
  -3.03769181e-03f, 4.96623181e-02f, 1.18176481e-02f, -7.64367580e-02f, -4.28138673e-02f, 1.21605210e-01f, -8.30292888e-03f, -4.12078016e-02f, -4.89388313e-03f, 7.36967921e-02f,
  -7.91111529e-01f, 2.67557472e-01f, 5.56312911e-02f, -1.34728566e-01f, 2.88274214e-02f, -1.20689340e-01f, -1.31123543e-01f, -4.61409763e-02f, 1.94522925e-02f, -2.86066774e-02f,
  -1.12999165e-02f, -1.37369102e-02f, -2.13030651e-02f, 7.24054426e-02f, -2.40563780e-01f, 6.53287992e-02f, 7.54912719e-02f, -1.63443834e-01f, -2.22372100e-01f, -7.48630464e-02f,
  8.31505805e-02f, 6.68551102e-02f, -9.26090479e-02f, -2.95350626e-02f, 2.73334116e-01f, -5.71146198e-02f, 1.49117365e-01f, 1.33822232e-01f, 1.33385491e-02f, 3.63009989e-01f,
  1.63265556e-01f, -4.65726592e-02f, -8.68806690e-02f, -8.58440697e-02f, 1.21111609e-01f, -3.99930067e-02f, 1.28278770e-02f, 1.25333846e-01f, -5.46477437e-02f, 5.43707237e-02f,
  -1.30136656e-02f, 1.83020700e-02f, -2.78369505e-02f, 8.11063424e-02f, -8.22153036e-03f, -5.76575063e-02f, 4.34636362e-02f, -5.55512682e-02f, -1.19869586e-03f, 9.98498574e-02f,
  1.08782686e-01f, -3.25502008e-02f, -5.82238510e-02f, 8.56678337e-02f, -6.54327422e-02f, -4.20328081e-02f, 8.64901170e-02f, -5.68393990e-02f, -3.63305211e-02f, 1.05883785e-01f,
  1.06621655e-02f, -6.27211407e-02f, -1.03420801e-02f, 3.90426838e-03f, -2.91430950e-02f, -9.53849964e-03f, 4.93552610e-02f, -1.81925874e-02f, -1.73793472e-02f, 3.29216719e-02f,
  1.53351771e-02f, 3.02823521e-02f, 4.77015553e-03f, -2.23326907e-02f, 2.19074432e-02f, -5.17864432e-03f, -5.06110489e-02f, 1.93266794e-02f, 1.08237239e-02f, 3.59212584e-03f,
  -7.34513812e-03f, -6.63993433e-02f, 6.89558238e-02f, 2.82642525e-02f, -4.18817066e-03f, 2.22638026e-02f, -4.46595922e-02f, 4.50365571e-03f, 2.10959688e-02f, -2.74980534e-02f,
  -2.28928532e-02f, -1.65183753e-01f, 3.97582054e-02f, 1.80331022e-02f, -3.86028662e-02f, 9.52080786e-02f, 5.98123204e-03f, 2.08538934e-03f, 2.96486244e-02f, 6.50941879e-02f,
  -2.28688624e-02f, -2.41270326e-02f, 5.25420271e-02f, 8.40493478e-03f, -2.66058408e-02f, -1.00380220e-02f, 5.95726408e-02f, -2.74004173e-02f, 2.36602761e-02f, 5.56236058e-02f,
  3.15243341e-02f, -6.39403760e-02f, -1.29450500e-01f, -1.74278906e-03f, 2.58799829e-02f, -1.51131600e-01f, 5.67981377e-02f, 9.86931100e-02f, -1.39762804e-01f, -6.43287450e-02f,
  -3.19250301e-02f, -1.06661633e-01f, -4.31244791e-01f, -1.52373612e-01f, -1.36155292e-01f, -3.02343249e-01f, -4.81777966e-01f, -1.00544602e-01f, -2.31679585e-02f, -1.38054445e-01f,
  4.78526540e-02f, 4.09203321e-01f, 2.43174136e-01f, 1.66239887e-01f, -4.93741855e-02f, -4.63189721e-01f, -4.22711939e-01f, -1.29150197e-01f, 2.08427049e-02f, -2.82012969e-02f,
  9.07363817e-02f, -9.18707773e-02f, -2.92628687e-02f, -4.20653895e-02f, -8.89768973e-02f, 1.34850711e-01f, -7.08408188e-03f, 4.12471406e-03f, 1.05580064e-02f, -7.31045082e-02f,
  2.97505930e-02f, -1.20827869e-01f, -1.29769892e-01f, 1.11219823e-01f, -3.16028073e-02f, 1.44727435e-02f, 3.03635206e-02f, -4.91120070e-02f, 3.53480317e-02f, -3.15179303e-02f,
  9.62563455e-02f, 1.57222912e-01f, 2.10247785e-02f, 5.21024503e-02f, -3.18056233e-02f, -5.61847948e-02f, -5.37852198e-02f, -2.42573675e-02f, 9.23307438e-04f, -4.16496284e-02f,
  -4.94985506e-02f, 1.74334683e-02f, -2.63996609e-02f, -9.30347666e-02f, -2.00327095e-02f, -2.45545264e-02f, -3.98698030e-03f, -4.12914567e-02f, -1.24518592e-02f, -2.27025356e-02f,
  -2.87582260e-02f, -2.61334032e-02f, 2.95729116e-02f, 1.57941226e-02f, 5.83982505e-02f, 3.07546500e-02f, -1.85255222e-02f, -1.95873324e-02f, -2.00550109e-02f, 3.36824544e-02f,
  1.94958467e-02f, -7.00104386e-02f, 4.95085418e-02f, -9.07444581e-02f, 4.13317755e-02f, -7.16770217e-02f, 3.14019769e-02f, -2.92138681e-02f, 6.99112266e-02f, 3.04280054e-02f,
  7.21798092e-02f, -1.75972171e-02f, 2.96071749e-02f, 2.50555631e-02f, -3.31055149e-02f, -4.45744507e-02f, -1.60338506e-02f, 5.37821390e-02f, 6.32552058e-02f, -5.53196557e-02f,
  2.16058418e-01f, -8.39437470e-02f, 2.41910089e-02f, -1.02919573e-02f, 1.07391626e-02f, 1.08286757e-02f, -5.78576028e-02f, 1.64695233e-02f, 1.62832979e-02f, -2.18445845e-02f,
  2.29020454e-02f, -1.11160278e-02f, -1.94441471e-02f, 1.15988227e-02f, 3.67780440e-02f, 6.09262846e-03f, 4.36906330e-02f, -4.96655777e-02f, 4.03407998e-02f, 1.11254551e-01f,
  1.72881619e-03f, -4.13351133e-02f, 8.97355750e-02f, 5.63553795e-02f, 4.81029339e-02f, 6.73212931e-02f, 4.12279777e-02f, 6.13447800e-02f, 2.48029400e-02f, -3.78507860e-02f,
  4.33352977e-01f, -1.17344921e-02f, 1.10095270e-01f, 4.42416966e-02f, 1.30298501e-02f, 3.16054933e-02f, 1.85423046e-01f, 7.22575337e-02f, 4.98497672e-02f, -8.43476970e-03f,
  -1.54624075e-01f, -4.19982135e-01f, -4.44347680e-01f, -2.99724519e-01f, -1.90624483e-02f, 7.00614601e-02f, 4.43715602e-03f, 4.56410274e-02f, 3.51848714e-02f, 6.66488782e-02f,
  -2.78570522e-02f, 1.91578060e-01f, 3.20253849e-01f, 7.31275305e-02f, -5.51602356e-02f, -2.57027596e-01f, -2.37076916e-02f, -2.76664719e-02f, 2.18891632e-02f, -1.21308841e-01f,
  4.79024742e-03f, 6.15266711e-02f, -1.56957045e-01f, -3.86888646e-02f, 7.40328208e-02f, -2.36824881e-02f, 9.63979736e-02f, 1.15591720e-01f, 9.15405899e-03f, 1.11470856e-01f,
  -6.00164980e-02f, -3.76724079e-02f, -3.50243002e-02f, -5.06437756e-03f, 9.90821198e-02f, -3.09395734e-02f, 1.65113404e-01f, 4.89146002e-02f, 6.48429990e-02f, -4.35794219e-02f,
  -2.28713885e-01f, 2.00687181e-02f, 1.76646993e-01f, 4.72729243e-02f, -2.74744891e-02f, -1.45344287e-01f, 5.56841679e-03f, -2.38144752e-02f, 6.01126552e-02f, 2.73576584e-02f,
  -1.10197775e-02f, -5.87284565e-02f, 7.87098333e-03f, 5.10080904e-02f, 5.13812713e-02f, -6.56270161e-02f, -1.46506457e-02f, -6.24542683e-02f, 2.15517301e-02f, 4.48100641e-02f,
  -2.51659378e-03f, 2.37380080e-02f, -7.41302967e-03f, 2.56248917e-02f, -1.13796361e-01f, 1.30214635e-02f, 4.37333249e-02f, -3.37815136e-02f, 2.65260059e-02f, 6.25988320e-02f,
  -3.38172377e-03f, -3.28407511e-02f, 4.57089804e-02f, 1.99204534e-02f, 2.15647593e-02f, -6.86202720e-02f, -6.73584789e-02f, -3.37900384e-03f, -4.10705172e-02f, 2.91327704e-02f,
  -1.53140202e-02f, -5.45010716e-02f, -7.62886479e-02f, -1.10069469e-01f, 1.71756800e-02f, -1.53514920e-02f, -1.09912880e-01f, -3.11754737e-02f, -9.60859135e-02f, 8.46915971e-03f,
  -5.77053288e-03f, -2.16897856e-02f, -3.38686742e-02f, 1.82787105e-02f, -6.01567910e-04f, 2.75581758e-02f, -3.46984640e-02f, -6.20680377e-02f, -5.87111562e-02f, 1.22713424e-01f,
  6.56763613e-02f, 7.70422667e-02f, 1.89029495e-03f, -8.46556351e-02f, 1.11641018e-02f, -7.38529786e-02f, -3.95330489e-02f, 3.32635678e-02f, 2.17259955e-02f, 1.46113262e-01f,
  6.77224696e-02f, -3.79694164e-01f, -1.08048901e-01f, -8.83588917e-04f, -2.26748049e-01f, 1.17194848e-02f, -8.34453199e-03f, 5.78440502e-02f, 6.12194650e-02f, -1.96764484e-01f,
  -1.78802699e-01f, -4.41746898e-02f, 2.33181015e-01f, 1.59979999e-01f, 1.70678750e-01f, 3.40588368e-03f, 4.24874499e-02f, 2.68302053e-01f, 4.87053603e-01f, 1.65260032e-01f,
  -4.07111421e-02f, 5.28398864e-02f, 6.11180253e-02f, 1.43969387e-01f, -2.07125276e-01f, 4.49385867e-02f, -1.57280937e-01f, -2.08478227e-01f, -1.50379241e-01f, -4.47987020e-01f,
  -9.18175951e-02f, -4.54796344e-01f, 2.17858464e-01f, -9.75365285e-03f, -1.44921899e-01f, 2.08666939e-02f, 8.30158591e-02f, -5.50517850e-02f, -4.98652309e-02f, 1.68310553e-02f,
  -9.26632285e-02f, -9.98531431e-02f, -9.49712992e-02f, 5.08694025e-03f, -1.04188338e-01f, 4.61203977e-02f, 1.53211262e-02f, 9.78616178e-02f, 1.29512802e-01f, -2.81654242e-02f,
  -2.00365484e-01f, -9.10440981e-02f, -2.69730699e-05f, -3.51515715e-03f, 6.46037534e-02f, 1.24004059e-01f, -9.46500376e-02f, -1.56611785e-01f, 9.10451710e-02f, -1.54977262e-01f,
  2.68972591e-02f, -1.05044939e-01f, -1.43244909e-02f, -1.03622295e-01f, 8.24563354e-02f, -1.22723160e-02f, -9.22974292e-03f, -2.25452296e-02f, 4.41421866e-02f, 2.24115630e-03f,
  -1.17210206e-02f, 1.06783219e-01f, 2.74883192e-02f, 2.06844583e-02f, 3.22082713e-02f, -5.12963859e-03f, -1.13475127e-02f, 3.51118371e-02f, 1.82677638e-02f, 3.09193097e-02f,
  -6.50323695e-03f, 5.97480917e-03f, -4.76044565e-02f, 9.18026082e-03f, -4.74003963e-02f, 1.77255310e-02f, -2.12516473e-03f, -1.21395020e-02f, 1.56653523e-02f, -1.09432740e-02f,
  2.19961211e-01f, 1.72241271e-01f, 9.73300934e-02f, 5.29986210e-02f, -1.95367187e-02f, 3.76224443e-02f, -4.84614410e-02f, -6.32729605e-02f, -8.94733891e-02f, 1.13351690e-02f,
  3.37320641e-02f, 6.21631145e-02f, 4.88723768e-03f, 4.89887968e-02f, 8.68098289e-02f, -1.08723028e-03f, -3.34317535e-02f, 4.54607978e-02f, 1.08175077e-01f, -1.36877922e-02f,
  4.61647771e-02f, 1.53328016e-01f, 2.45054767e-01f, 1.82781562e-01f, -2.29352545e-02f, 2.29384765e-01f, 4.86188382e-02f, 1.12965330e-01f, 3.04507405e-01f, 2.56074369e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.86731055e-01f, 2.08146214e-01f, -1.78970963e-01f, 2.33933907e-02f, -7.14142667e-03f, -1.71350300e-01f, -3.06324139e-02f, 1.22427002e-01f, 1.29070252e-01f, 4.17054556e-02f,
  1.90773327e-02f, -1.08002931e-01f, 1.34425284e-02f, -1.08381882e-01f, -7.05459267e-02f, -1.88072585e-03f, 8.89798552e-02f, -2.61738468e-02f, -9.15229544e-02f, 2.26659793e-02f,
  -6.89730980e-03f, 1.45765573e-01f, 1.60215512e-01f, 1.30685717e-01f, -3.92380031e-03f, -7.36076310e-02f, 6.77382648e-02f, 3.86015475e-02f, -6.14102371e-02f, 1.30185664e-01f,
  -9.26661119e-02f, -1.97531609e-03f, -8.08058307e-02f, 3.75739895e-02f, -6.80811033e-02f, 5.57422787e-02f, 4.42027152e-02f, 6.96579069e-02f, 5.12336865e-02f, 1.70008354e-02f,
  8.62696394e-02f, -1.00705959e-02f, -3.93542461e-02f, 3.68887186e-02f, 1.11356959e-01f, 5.85571826e-02f, 6.09242357e-02f, -2.34222505e-02f, 7.68967159e-03f, -6.64537326e-02f,
  6.26082644e-02f, -5.26277870e-02f, -5.44382818e-02f, -5.78059442e-02f, -5.21914586e-02f, -4.46180515e-02f, -8.54686424e-02f, -9.66890156e-02f, 2.46057101e-02f, 5.30319214e-02f,
  -8.18685740e-02f, -1.16347119e-01f, 3.90595533e-02f, 2.62419526e-02f, -3.00423754e-03f, 2.00545266e-02f, -3.30243334e-02f, -1.84948277e-02f, 1.48471380e-02f, 5.09228557e-02f,
  1.33550745e-02f, -9.49398503e-02f, 9.00045875e-03f, -2.46154461e-02f, 4.53177691e-02f, 3.88090126e-02f, 3.22987176e-02f, -7.21720804e-04f, -7.50829056e-02f, -4.28677723e-02f,
  1.27929533e-02f, -7.05855712e-02f, 5.05739078e-02f, 7.08655491e-02f, -4.44460884e-02f, -5.41577712e-02f, 5.42158000e-02f, -4.93537746e-02f, -2.51744781e-02f, 3.31044942e-02f,
  2.59242952e-01f, -1.68712378e-01f, 9.13695246e-03f, 6.64383918e-02f, 6.96054921e-02f, -3.03253066e-03f, 2.43368000e-03f, 4.64692302e-02f, 1.38940178e-02f, 3.06388568e-02f,
  -3.74205830e-03f, 2.34400481e-02f, 2.09430791e-02f, 8.34416747e-02f, 6.51962310e-02f, -5.42655438e-02f, 2.89114136e-02f, -8.94893184e-02f, -6.52511641e-02f, 5.31491823e-02f,
  1.55242473e-01f, 9.21396762e-02f, 8.23902637e-02f, -6.03383631e-02f, -4.70680781e-02f, -8.31222013e-02f, 8.26179758e-02f, 7.30971396e-02f, -8.34446177e-02f, 2.25552186e-01f,
  2.81854011e-02f, -2.37786025e-01f, -1.31186202e-01f, 6.87613245e-03f, -1.45125315e-01f, -8.70100558e-02f, -2.23195761e-01f, 4.41363379e-02f, 6.87331557e-02f, -1.44273043e-01f,
  -1.05427034e-01f, 9.70454738e-02f, 5.97760566e-02f, -4.42557186e-02f, -1.17365398e-01f, -1.55788690e-01f, -2.79959410e-01f, -1.78961102e-02f, 5.44963703e-02f, 2.73240115e-02f,
  -1.54527664e-01f, -8.45215246e-02f, -1.22244582e-02f, 6.31039962e-02f, -2.66412869e-02f, 8.91456082e-02f, -1.04855202e-01f, -5.36532998e-02f, -8.46001133e-02f, -1.31510720e-01f,
  2.47014388e-02f, 2.35882223e-01f, 2.34979242e-02f, 3.02131269e-02f, 2.73304451e-02f, 5.86389937e-03f, 1.91034600e-02f, 7.28505477e-02f, 7.21031800e-02f, 8.97007063e-03f,
  -4.33582291e-02f, -4.75140065e-02f, 6.89297095e-02f, 7.62171438e-03f, 7.80572891e-02f, -5.13725504e-02f, -3.60060558e-02f, 1.39755160e-01f, 2.02097688e-02f, -1.17090084e-01f,
  2.02743150e-02f, -5.85267507e-02f, 1.48119077e-01f, 3.01574524e-02f, 1.28625959e-01f, 1.04032725e-01f, -2.32119625e-03f, 1.30353361e-01f, 1.52053967e-01f, 4.03000563e-02f,
  -6.76876307e-02f, 2.12118328e-02f, -3.55915911e-02f, 6.20649233e-02f, -1.30411126e-02f, 1.96857825e-02f, 5.19626215e-03f, -3.30921449e-02f, 9.32613946e-03f, -4.98849154e-02f,
  1.48111694e-02f, -4.56400737e-02f, -5.19019850e-02f, -2.52588857e-02f, -1.06619239e-01f, -1.87974386e-02f, -2.33060475e-02f, -3.81249078e-02f, 3.57896350e-02f, -2.64941063e-02f,
  1.68164857e-02f, 5.10994382e-02f, -1.90333594e-02f, 4.98472750e-02f, 2.40672491e-02f, -6.61853775e-02f, 7.88393766e-02f, -5.80528826e-02f, 2.98455311e-03f, 2.24749465e-02f,
  1.81324426e-02f, 1.40252888e-01f, -2.25450192e-02f, 5.53573668e-03f, 2.21734168e-03f, 2.86699906e-02f, -4.17433260e-03f, -4.10990231e-02f, 5.62018156e-02f, 3.77393849e-02f,
  1.25112727e-01f, -9.45639834e-02f, -4.71293814e-02f, 4.02740240e-02f, -9.11745522e-03f, 3.18586603e-02f, -1.29757315e-01f, 7.02891648e-02f, 2.17203560e-04f, -1.31842017e-01f,
  -1.28269777e-01f, -5.62232845e-02f, -5.73068261e-02f, 6.30397275e-02f, 9.27266106e-02f, 1.13792298e-02f, 2.15733349e-02f, 1.02530211e-01f, -5.31692244e-02f, -1.39200404e-01f,
  3.04663062e-01f, -2.08212018e-01f, -3.60033482e-01f, 1.09776400e-01f, -8.19983557e-02f, -1.95896655e-01f, -1.39993638e-01f, 3.86457890e-02f, 1.97833683e-02f, -4.77539189e-02f,
  -2.33193487e-02f, 1.21092938e-01f, -9.15772393e-02f, -3.67832519e-02f, -1.94494456e-01f, -3.31217527e-01f, -1.75667375e-01f, -1.58115417e-01f, 5.61771728e-02f, 1.00461915e-01f,
  9.00951624e-02f, 5.20873889e-02f, 1.45297199e-01f, -1.25618605e-02f, 1.55326352e-01f, 9.73395333e-02f, -1.26836389e-01f, -7.87089169e-02f, -9.43095833e-02f, -1.07835308e-01f,
  -1.31275430e-01f, 1.10962875e-01f, -2.51107365e-02f, 1.07796066e-01f, -7.57114142e-02f, -1.10461507e-02f, -2.88451891e-02f, -1.20142736e-02f, 3.89918387e-02f, -8.51702616e-02f,
  1.93898717e-03f, 2.34918799e-02f, 8.09479039e-03f, 1.69162787e-02f, 2.09559407e-02f, 2.50704102e-02f, -6.93214238e-02f, -5.39320223e-02f, -5.71029596e-02f, -3.85934003e-02f,
  7.83672258e-02f, 3.99199761e-02f, 5.02794981e-03f, -1.14865370e-01f, -4.08738889e-02f, -7.39126578e-02f, 2.24106275e-02f, 4.39186022e-02f, -1.54415146e-01f, 1.17916605e-02f,
  4.27906541e-03f, -1.67069421e-03f, -1.44703612e-02f, 5.33550195e-02f, -1.67124849e-02f, -7.86136463e-02f, -3.59157398e-02f, 3.71333845e-02f, 3.89097035e-02f, -3.96348163e-02f,
  -3.10623646e-02f, -4.65824939e-02f, 3.90483998e-02f, -1.43156538e-03f, 1.15520107e-02f, -3.15809213e-02f, 1.61758587e-02f, 1.64718460e-02f, -9.50868279e-02f, -3.81391346e-02f,
  1.84239205e-02f, -5.62273664e-03f, -2.86697689e-03f, 4.81213368e-02f, 1.50370803e-02f, -7.34655410e-02f, 5.51120527e-02f, -4.63289162e-03f, 3.40972058e-02f, -4.51141037e-02f,
  3.70793566e-02f, -2.81782985e-01f, 1.46684311e-02f, 7.26382583e-02f, -6.01211302e-02f, -7.89698660e-02f, 5.27732596e-02f, -8.63083266e-03f, -5.00357822e-02f, 7.42533132e-02f,
  6.95224404e-02f, 8.13602880e-02f, -9.07136276e-02f, -3.03688645e-02f, -1.41513608e-02f, 5.98300286e-02f, -4.81713600e-02f, -1.66252758e-02f, -1.32416552e-02f, 7.79404268e-02f,
  -1.30174667e-01f, -7.92405978e-02f, -1.24435388e-01f, -1.23652890e-01f, 6.17140904e-02f, -3.34441252e-02f, -2.02879235e-01f, -2.26906184e-02f, -1.10534728e-01f, -2.33838335e-01f,
  -1.73650146e-01f, 1.18375584e-01f, -3.15240771e-02f, 6.04475103e-03f, 4.35148878e-03f, -2.59245969e-02f, -1.43818408e-02f, -9.38563794e-02f, -4.25414816e-02f, -1.10439539e-01f,
  3.28643546e-02f, -6.21355101e-02f, -6.54699355e-02f, -1.55323967e-01f, -2.46691540e-01f, -1.69035509e-01f, -6.29908815e-02f, -1.87626585e-01f, -1.49763823e-01f, -1.60861313e-02f,
  -9.81961116e-02f, -4.96752821e-02f, -1.66160360e-01f, -1.80046096e-01f, 5.28113693e-02f, -1.14169993e-01f, -1.13905095e-01f, 4.12969477e-02f, -2.14481330e-03f, -7.22337738e-02f,
  -1.84088983e-02f, -1.98321231e-02f, -2.40129195e-02f, -1.45901702e-02f, 5.13484282e-03f, 2.91171782e-02f, -1.71939675e-02f, 6.37312606e-02f, 8.28480907e-03f, -4.51622754e-02f,
  -6.11906610e-02f, 2.01123580e-02f, 1.47034237e-02f, -3.94376256e-02f, 3.18529718e-02f, -5.01616932e-02f, -5.74749038e-02f, -6.15290664e-02f, 3.15737464e-02f, 3.82419601e-02f,
  -5.75318081e-05f, -8.11241847e-03f, 3.83339636e-03f, -8.81819949e-02f, 3.09350565e-02f, -5.41083515e-02f, -4.98122275e-02f, -4.00337055e-02f, -9.31358524e-03f, -9.69456285e-02f,
  -6.02074265e-02f, 1.08776707e-02f, 7.52210468e-02f, -3.89708616e-02f, -8.89579356e-02f, -3.53915361e-03f, 4.79108430e-02f, -2.67282613e-02f, -4.52968478e-02f, -1.68662034e-02f,
  3.08069922e-02f, -4.39500585e-02f, -8.89867917e-02f, -6.43308982e-02f, 8.58309269e-02f, -1.26172677e-02f, -1.92481540e-02f, -1.12294881e-02f, -7.26309344e-02f, -2.71815201e-03f,
  2.47644335e-02f, 3.24775092e-02f, -4.86867540e-02f, -8.37164298e-02f, -3.92596722e-02f, 1.99848060e-02f, 4.12031226e-02f, -3.53973918e-02f, -9.74657852e-03f, 5.42054921e-02f,
  -1.51479229e-01f, -4.61379476e-02f, -7.57190734e-02f, 1.10607874e-02f, -2.07388803e-04f, 6.00719042e-02f, 4.16021198e-02f, 2.51695327e-02f, 8.97426605e-02f, -8.07846859e-02f,
  6.04400299e-02f, -9.81977880e-02f, 3.27732563e-02f, 5.14940545e-02f, -9.60898250e-02f, -3.70867401e-02f, -1.43561829e-02f, -9.60567445e-02f, -8.07890110e-03f, 9.70243216e-02f,
  -3.62613089e-02f, -1.08117551e-01f, -1.87677205e-01f, -4.06834930e-02f, -5.55766448e-02f, -6.78459257e-02f, -1.02133572e-01f, -8.98530409e-02f, -3.10248509e-02f, -1.40983060e-01f,
  6.37983531e-02f, 7.35258535e-02f, -9.64077264e-02f, 2.28921369e-01f, 2.21501231e-01f, 2.18411595e-01f, 1.18731856e-01f, 1.88885361e-01f, 1.95253804e-01f, 2.00006187e-01f,
  2.96043873e-01f, 2.12493584e-01f, 3.15752059e-01f, 1.79608032e-01f, 1.96625143e-01f, 9.19477269e-02f, -5.37561662e-02f, -7.17099980e-02f, 2.33170092e-02f, 1.01501308e-01f,
  -9.00042010e-04f, 6.73428830e-03f, -3.78881171e-02f, -3.17607932e-02f, -1.53490920e-02f, 7.10190162e-02f, 2.64586229e-02f, -7.56273279e-03f, 1.58246346e-02f, -2.22957504e-04f,
  -9.26201791e-02f, 2.19533704e-02f, 9.68417153e-02f, 7.27428123e-02f, -2.45540543e-03f, -1.27840906e-01f, -3.67945619e-02f, -1.78971559e-01f, 1.94115099e-02f, -4.26351465e-02f,
  -7.10843056e-02f, -9.31053609e-02f, 2.17296947e-02f, 4.41357540e-03f, -1.09759994e-01f, -8.35993066e-02f, -6.64277896e-02f, 5.12678027e-02f, 7.22870752e-02f, 4.54507358e-02f,
  7.70576522e-02f, -3.59429605e-02f, -7.84284100e-02f, 1.04296535e-01f, -5.23473881e-03f, 7.38713369e-02f, -6.36001155e-02f, -8.04674327e-02f, -6.68170527e-02f, -1.30061254e-01f,
  2.18119174e-02f, -1.37351789e-02f, 6.40812442e-02f, 5.61883226e-02f, 4.44155559e-02f, -9.82038900e-02f, 4.69702519e-02f, 5.18028997e-02f, 6.13815226e-02f, -8.70197341e-02f,
  1.08121345e-02f, -4.13242960e-03f, 8.05319771e-02f, -4.20275284e-03f, 1.11141372e-02f, -3.52111310e-02f, -5.56420907e-03f, -1.29684061e-02f, -6.86182231e-02f, -6.85586035e-03f,
  1.02501474e-01f, -5.44240214e-02f, -2.17854157e-02f, 4.70925868e-02f, -2.76292749e-02f, 1.47420214e-02f, -6.14177883e-02f, 1.58442780e-02f, 3.80748473e-02f, -7.72664230e-03f,
  -3.19156237e-02f, 1.76766679e-01f, -3.79321277e-02f, 4.08072770e-02f, -7.31578544e-02f, -6.84357584e-02f, -1.77921914e-02f, 1.31140063e-02f, -6.56376407e-02f, -2.95382757e-02f,
  -3.64541225e-02f, 3.32823694e-02f, -4.75841798e-02f, -3.79092656e-02f, 1.34871085e-03f, 6.30572140e-02f, 5.60038760e-02f, 3.22924219e-02f, -4.72479127e-02f, -2.18106508e-02f,
  7.94272590e-03f, -2.13746168e-02f, 6.25689030e-02f, 2.55956426e-02f, 6.75337091e-02f, 3.34487520e-02f, -9.98555124e-02f, 1.66656096e-02f, 5.27751409e-02f, -5.17715700e-02f,
  -9.68673378e-02f, 5.32853045e-03f, 5.85632725e-03f, -1.59016289e-02f, -1.46908775e-01f, -2.51121521e-01f, -2.84461468e-01f, -8.52364600e-02f, 6.82579130e-02f, -6.83839843e-02f,
  -1.67187393e-01f, 9.03122798e-02f, 1.48168951e-01f, 4.73783761e-02f, 4.28684475e-03f, 1.67528853e-01f, 1.84633672e-01f, 2.84326315e-01f, 1.26623601e-01f, 3.02392486e-02f,
  1.32038087e-01f, 1.77520394e-01f, 2.10997626e-01f, 9.40667167e-02f, 1.52474046e-01f, 1.18680425e-01f, 1.42578423e-01f, 6.07609190e-02f, 3.08192279e-02f, 3.11231673e-01f,
  -9.42727402e-02f, -1.69111624e-01f, 5.05484566e-02f, 7.42526129e-02f, -1.67375132e-02f, 5.09984279e-03f, 5.40962815e-03f, 2.73111295e-02f, -3.52477841e-02f, -3.85823287e-02f,
  -4.97771688e-02f, -3.39555962e-04f, 5.72752133e-02f, 8.20725784e-02f, -8.73145759e-02f, -3.36353295e-02f, -1.92255061e-02f, 7.86438584e-02f, 5.52163273e-02f, -1.08070679e-01f,
  3.99104878e-02f, 7.49689387e-03f, -1.76306024e-01f, -1.63963456e-02f, -6.25914037e-02f, -9.16096494e-02f, -1.29608840e-01f, -5.15823066e-02f, -8.52978677e-02f, 6.78108726e-03f,
  -5.01612807e-03f, 5.43528832e-02f, 5.32079749e-02f, -2.45232247e-02f, 1.24678845e-02f, -2.76032537e-02f, 2.36310950e-03f, -1.89357001e-04f, -5.57589671e-03f, 2.31537689e-02f,
  -1.51114119e-02f, -1.89750064e-02f, -5.17396082e-04f, -3.46188061e-02f, 2.42759716e-02f, 1.83031596e-02f, -7.87747428e-02f, 6.94996119e-02f, -2.84891552e-03f, -2.06643660e-02f,
  1.01482468e-02f, -2.07341891e-02f, -3.92901786e-02f, 5.74835874e-02f, -2.04322878e-02f, 8.85695498e-03f, -3.94602157e-02f, -1.10448264e-02f, 8.04482214e-03f, 1.43362377e-02f,
  6.05026037e-02f, -8.02278891e-02f, -3.45840082e-02f, 2.10893210e-02f, -1.29474048e-02f, -3.40004191e-02f, -7.10401610e-02f, -4.11927775e-02f, -1.22447964e-02f, 2.96460856e-02f,
  -1.07389040e-01f, -4.03830148e-02f, -8.19916278e-03f, -1.84102152e-02f, -8.34935680e-02f, -6.57276064e-02f, 4.72497791e-02f, 8.68140832e-02f, 1.27813434e-02f, -6.37250990e-02f,
  1.45974047e-02f, -1.64787084e-01f, -9.34005380e-02f, -1.09926477e-01f, -4.69698869e-02f, -1.67342365e-01f, -9.73065346e-02f, -1.27893493e-01f, -1.52273327e-01f, -1.75765395e-01f,
  -1.85105085e-01f, -1.92477237e-02f, -4.31296192e-02f, 2.08897874e-01f, 1.50997177e-01f, -1.92632422e-01f, -2.80640274e-01f, -3.28182131e-01f, 3.81125249e-02f, 4.36251909e-02f,
  1.69027135e-01f, 2.66945928e-01f, 8.94117281e-02f, 5.83664365e-02f, -2.75373578e-01f, -1.44701570e-01f, -1.24323674e-01f, -2.32022166e-01f, -2.20397621e-01f, -6.53810857e-04f,
  1.42887399e-01f, 9.38459933e-02f, -5.46975508e-02f, -1.06771644e-02f, 1.57494292e-01f, 1.50885120e-01f, 3.88882011e-02f, 1.46375418e-01f, 1.03653453e-01f, 2.93015301e-01f,
  4.49299484e-01f, -1.13436654e-01f, -3.53200617e-03f, 1.02913350e-01f, 1.98249489e-01f, -8.00217092e-02f, -5.91243431e-03f, 7.34612122e-02f, -6.26320168e-02f, -1.75790731e-02f,
  1.78400740e-01f, 9.05050337e-03f, 2.27549113e-02f, 1.10866860e-01f, 1.86278075e-02f, -2.94687301e-02f, -1.77114725e-01f, -1.44584224e-01f, -1.91273838e-01f, -3.79938707e-02f,
  3.62192206e-02f, 8.59835073e-02f, -5.88336634e-03f, -2.02376559e-01f, -7.27227107e-02f, 3.92522477e-03f, 1.57668535e-02f, -4.41181585e-02f, -6.33911490e-02f, 1.43101186e-01f,
  -1.69607326e-02f, -1.22510502e-02f, -2.72640120e-02f, -1.23666832e-02f, 2.33634040e-02f, 7.62253702e-02f, 3.03122513e-02f, 6.01203181e-02f, -2.94206128e-03f, -6.58921450e-02f,
  2.20997799e-02f, 3.18275318e-02f, -4.07506265e-02f, 6.80115446e-02f, -1.25061506e-02f, -1.06258783e-02f, -2.02293005e-02f, -1.18070496e-02f, -4.16999497e-02f, 9.27077048e-03f,
  5.77467456e-02f, -3.62940095e-02f, 5.10464869e-02f, -6.29949057e-03f, 2.76264306e-02f, -7.40178600e-02f, 8.07013735e-03f, 7.73671409e-03f, -7.09150285e-02f, 5.35189286e-02f,
  1.42810017e-01f, -1.65418938e-01f, 1.79895133e-01f, 9.79082566e-03f, -1.63927115e-02f, -2.01463178e-02f, 1.40866533e-01f, -8.90492946e-02f, 9.54900905e-02f, -7.91107342e-02f,
  -1.68246254e-02f, -1.20604962e-01f, 1.05940290e-01f, 2.73993425e-02f, 5.36420429e-03f, -7.78012127e-02f, 6.69125393e-02f, 1.78422257e-02f, -5.07090203e-02f, -1.76557638e-02f,
  -3.73135731e-02f, -5.92936315e-02f, -2.73908898e-02f, 1.75110400e-02f, -4.77408469e-02f, 9.10056159e-02f, 1.49493071e-03f, 6.70316070e-02f, -1.16299286e-01f, 7.14763161e-03f,
  -1.62154734e-01f, 2.29886901e-02f, 1.36540815e-01f, 1.71051268e-02f, -1.62143670e-02f, -8.26880261e-02f, -1.43192649e-01f, -1.30616352e-01f, -8.34887568e-03f, 1.28897661e-02f,
  2.36534011e-02f, 8.16055387e-02f, 3.23866159e-02f, -9.68023315e-02f, -9.89892632e-02f, -2.98337769e-02f, -6.94809556e-02f, -1.77181616e-01f, -2.00033098e-01f, -1.01663485e-01f,
  -5.13690524e-02f, -1.38647586e-01f, -1.46225244e-01f, -8.76282454e-02f, 5.51753007e-02f, -1.23266047e-02f, 6.37247786e-03f, 3.37061286e-02f, -9.51627567e-02f, 8.23420584e-02f,
  1.76804125e-01f, 4.29885536e-02f, -5.02723195e-02f, -9.76241082e-02f, -6.92613795e-03f, -4.56772186e-02f, -4.99879271e-02f, -8.63455608e-02f, 5.00197634e-02f, 4.89611290e-02f,
  2.62110475e-02f, -6.98733181e-02f, -6.59634396e-02f, -2.36579794e-02f, -4.41866182e-02f, 3.86176966e-02f, -1.99174397e-02f, 4.33650576e-02f, -2.49692891e-02f, 7.15996996e-02f,
  1.25283316e-01f, -7.44813168e-03f, -4.95066009e-02f, 1.13959767e-01f, 5.28746843e-02f, -8.52031559e-02f, -3.02123488e-04f, 2.76130680e-02f, 9.93196964e-02f, 8.07274505e-02f,
  -3.99593972e-02f, 3.09393853e-02f, 3.42592411e-02f, 2.89028604e-02f, 2.86637880e-02f, 4.19354364e-02f, -6.99169114e-02f, -5.59632033e-02f, -3.29035968e-02f, 1.02814101e-02f,
  -2.53414009e-02f, 9.67385843e-02f, 2.58164499e-02f, 9.44313034e-02f, 1.66147947e-03f, -2.29757559e-02f, -6.55862130e-03f, 4.56991158e-02f, 2.78050415e-02f, 2.83725336e-02f,
  -4.45219055e-02f, 1.39519069e-02f, 8.42875615e-02f, 4.39677685e-02f, 2.16660816e-02f, -9.52094141e-03f, 3.87534052e-02f, -1.90175464e-03f, -1.24855107e-02f, -1.50794513e-03f,
  1.81177452e-01f, -1.61273867e-01f, 5.70572093e-02f, -3.54194343e-02f, -1.77988391e-02f, 3.70093808e-03f, 6.73962086e-02f, 5.08922413e-02f, -6.10036682e-03f, 6.05027080e-02f,
  4.33545150e-02f, 4.13245149e-02f, 3.87577862e-02f, 9.51543748e-02f, 1.05659226e-02f, -7.53053464e-03f, -2.54060738e-02f, 5.52812032e-03f, 3.84414643e-02f, 1.00119859e-01f,
  2.22455468e-02f, -1.07560582e-01f, 7.91670829e-02f, 1.23159766e-01f, 4.63884398e-02f, -3.90546508e-02f, 1.21717975e-01f, 8.60773176e-02f, -9.13657621e-02f, 2.58398056e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  4.98738997e-02f, -1.06520362e-01f, 4.45876643e-03f, 1.69172157e-02f, 7.43865408e-03f, 1.99033737e-01f, 3.16425592e-01f, 2.42563225e-02f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -4.47323889e-01f, -3.43992591e-01f, -1.99613333e-01f, 8.18532556e-02f, -8.81974325e-02f, -1.72302589e-01f, -9.81953666e-02f, -2.87953854e-01f, -6.78673163e-02f, -3.72866951e-02f,
  -1.07056104e-01f, 1.17392413e-01f, -1.67138994e-01f, 2.52076745e-01f, -9.68243852e-02f, -4.48847502e-01f, -7.96030834e-02f, -2.88390607e-01f, 1.89786300e-01f, 3.87281418e-01f,
  2.36688152e-01f, -1.85281739e-01f, -5.21943986e-01f, -2.19317570e-01f, 7.41406977e-02f, -5.67674860e-02f, 1.93249688e-01f, -2.45744199e-01f, 9.03370902e-02f, 3.42989028e-01f,
  3.61892700e-01f, 1.04008287e-01f, 2.26482406e-01f, -9.59983841e-02f, -3.94099116e-01f, 8.01888034e-02f, 1.73698887e-02f, -2.18364596e-02f, 2.99063325e-02f, -1.19796716e-01f,
  4.13835496e-01f, 3.34795862e-01f, -8.01946744e-02f, 1.83273643e-01f, -1.18174009e-01f, -3.16501316e-03f, -8.98929834e-02f, -1.69107154e-01f, -1.24578580e-01f, -4.65762377e-01f,
  -9.63308960e-02f, 1.47274703e-01f, 2.17721567e-01f, -1.11792944e-01f, 3.29804540e-01f, -4.15800393e-01f, 2.92569429e-01f, -3.35265726e-01f, 3.37860882e-02f, 8.88157636e-02f,
  -2.34987184e-01f, 1.57351628e-01f, -4.79999520e-02f, -7.62778148e-02f, -1.76091745e-01f, 1.87041890e-02f, 1.03128508e-01f, -1.80989265e-01f, 1.28724664e-01f, -2.18037724e-01f,
  -2.48801619e-01f, -1.76047951e-01f, -1.30401418e-01f, -3.43673676e-01f, 6.52251998e-03f, 8.15730244e-02f, 5.88529408e-02f, 1.49099633e-01f, 4.62355092e-02f, -6.21424317e-01f,
  4.80504096e-01f, 2.18826815e-01f, 4.65726525e-01f, 2.11865708e-01f, -1.70429334e-01f, -2.77560920e-01f, 6.90717623e-02f, 4.21666354e-01f, -3.16136837e-01f, 3.90779525e-01f,
  1.76467761e-01f, -1.59402803e-01f, 4.46251817e-02f, 2.53574140e-02f, -2.38346666e-01f, -1.63711995e-01f, -3.82829681e-02f, 2.25011751e-01f, 1.79187991e-02f, 1.60361513e-01f,
  2.41826579e-01f, -1.13633975e-01f, -1.89949974e-01f, 1.65942922e-01f, -1.92767009e-01f, -1.39022440e-01f, -8.97978172e-02f, -1.10054016e-01f, 4.62265193e-01f, -3.97430584e-02f,
  -3.63408536e-01f, 1.36960596e-01f, 7.36942291e-02f, 4.05882180e-01f, 3.06283087e-01f, -3.40302765e-01f, -1.60020813e-01f, 1.65758565e-01f, -9.26945508e-02f, 3.65902960e-01f,
  -2.11802907e-02f, -4.43862490e-02f, 1.15164064e-01f, 2.97435056e-02f, 8.24209303e-02f, -4.62105513e-01f, 2.75617409e-02f, 1.60559285e-02f, 5.56198172e-02f, 1.81977630e-01f,
  -1.83493361e-01f, -7.76261603e-03f, -1.22127570e-01f, 2.19056755e-01f, -2.23985970e-01f, -3.22313607e-02f, -2.10112736e-01f, 5.85013181e-02f, -6.54855696e-03f, -4.44588065e-01f,
  5.21206893e-02f, -4.14240390e-01f, 6.46840811e-01f, -4.26955819e-01f, 9.12871808e-02f, -2.53428221e-01f, -3.02856237e-01f, 3.10353637e-01f, -3.51034813e-02f, -2.69906223e-01f,
  1.37073591e-01f, -3.63740236e-01f, -1.06453381e-01f, -6.00099331e-03f, -1.10405013e-01f, -9.22185555e-02f, -2.01106846e-01f, 8.18513706e-03f, 9.47497264e-02f, -1.31241336e-01f,
  -7.45196044e-02f, 2.93726593e-01f, -1.94705203e-01f, 6.50357679e-02f, -1.33553585e-02f, -1.52785987e-01f, -2.44101658e-01f, -8.46188609e-03f, 2.77856618e-01f, -1.15993187e-01f,
  -2.36888856e-01f, 9.77374315e-02f, -2.68382490e-01f, 2.89957494e-01f, 3.63414317e-01f, -1.48734063e-01f, 6.75326139e-02f, -6.92918450e-02f, -2.15218201e-01f, 4.57974732e-01f,
  4.89792675e-01f, -3.64623696e-01f, 3.13183278e-01f, -4.91752446e-01f, 2.93050885e-01f, -1.99130163e-01f, 1.00892656e-01f, -1.67378232e-01f, -2.38543347e-01f, 4.03325588e-01f,
  1.06154047e-01f, 1.37173399e-01f, -1.92262381e-01f, 4.26555686e-02f, 2.04270899e-01f, 8.41947943e-02f, 1.20744310e-01f, 2.31561497e-01f, -9.34956074e-02f, -2.13325337e-01f,
  -1.16790287e-01f, 2.17593357e-01f, 2.13777840e-01f, -1.15790240e-01f, -8.44208002e-02f, 2.91167647e-01f, -1.41417116e-01f, 9.91761014e-02f, -3.24583352e-01f, 1.09919243e-01f,
  -6.33945018e-02f, -3.66953999e-01f, 3.63607883e-01f, 5.67194104e-01f, -3.46967429e-01f, -1.99905261e-01f, -1.25137210e-01f, 1.32843032e-01f, 1.21684469e-01f, 1.07618712e-01f,
  -4.55865124e-03f, 1.39261529e-01f, 4.53914642e-01f, 1.05052173e-01f, 5.25465235e-02f, 5.17379232e-02f, -8.96398127e-02f, -3.51758808e-01f, 1.77187491e-02f, 8.38854089e-02f,
  -3.65426719e-01f, -3.03558320e-01f, 1.17667817e-01f, -7.00005144e-02f, 1.18197680e-01f, -1.12363070e-01f, -9.59487574e-04f, 4.73898172e-01f, -2.75413003e-02f, -2.73133755e-01f,
  1.42813742e-01f, 2.00933605e-01f, -2.17430338e-01f, -1.71763636e-02f, 2.06362531e-01f, -1.60792749e-02f, 1.17898501e-01f, -8.73617604e-02f, -5.77840321e-02f, -4.80866507e-02f,
  3.75086814e-01f, 7.67715722e-02f, -3.17175061e-01f, -3.82740200e-02f, 1.30527452e-01f, -1.74109284e-02f, -1.50481686e-01f, 1.02069840e-01f, 3.63007456e-01f, -1.50040686e-01f,
  -3.15949231e-01f, 7.32321714e-05f, -2.39485074e-02f, -2.43169256e-02f, -2.28059247e-01f, -3.03285718e-01f, 4.12479751e-02f, -2.95138389e-01f, 1.81128502e-01f, 3.86713743e-01f,
  -3.33383530e-01f, 8.88143256e-02f, -3.99380833e-01f, -3.20540249e-01f, 4.25847024e-01f, -9.93062630e-02f, 3.50088365e-02f, -1.37800917e-01f, 3.16925310e-02f, -1.28331482e-01f,
  -1.41409934e-01f, 5.98072016e-04f, -2.65219837e-01f, 1.50632799e-01f, 1.43235147e-01f, -2.43344367e-01f, -1.41059577e-01f, 7.21786097e-02f, 2.87192464e-01f, -2.33226329e-01f,
  -4.79408465e-02f, -2.59776711e-01f, -1.04310580e-01f, -7.67637044e-02f, 1.40034646e-01f, -8.10141042e-02f, -7.05650374e-02f, -2.44327381e-01f, -1.24825705e-02f, -3.39578569e-01f,
  -2.21516192e-01f, -1.31161585e-01f, 5.20534158e-01f, -5.98955452e-01f, 1.59456745e-01f, -2.45391890e-01f, 1.60122737e-01f, 3.31680626e-01f, -5.04872382e-01f, -3.60179693e-01f,
  4.15673226e-01f, -2.55092710e-01f, 6.33124560e-02f, 4.61571589e-02f, 3.28775883e-01f, -2.95531992e-02f, -5.39572304e-03f, -7.39329010e-02f, -6.09657317e-02f, -3.12719136e-01f,
  2.24254206e-01f, 4.31442410e-01f, -6.77108690e-02f, 8.12800676e-02f, 4.32287246e-01f, -6.74178675e-02f, -3.23863506e-01f, 5.00628054e-01f, 3.17681611e-01f, -3.78320627e-02f,
  -5.86316511e-02f, -1.87450778e-02f, 2.35132903e-01f, -2.01843202e-01f, 1.27332136e-01f, -3.81892055e-01f, 9.37880948e-04f, 1.02159299e-01f, 2.55740881e-01f, -2.30580959e-02f,
  -2.27185532e-01f, -9.05702934e-02f, 4.12532240e-01f, -1.39902174e-01f, 3.55216600e-02f, -5.91786858e-03f, 2.76789308e-01f, 1.31496042e-01f, -4.35686372e-02f, -2.70306915e-01f,
  3.85483176e-01f, 9.41848084e-02f, 2.61809200e-01f, -7.12893084e-02f, 1.07610617e-02f, -1.01088487e-01f, -7.97155499e-02f, -2.18264669e-01f, 3.73853594e-02f, -8.76152813e-02f,
  -1.02253996e-01f, 6.45715892e-02f, -8.87156650e-02f, 1.28337026e-01f, 2.66593218e-01f, -2.85889208e-01f, -4.37941819e-01f, -2.12582067e-01f, 2.25781724e-01f, -1.33109763e-01f,
  2.15385914e-01f, 1.69682875e-01f, -5.92159986e-01f, -3.72150987e-01f, 4.75818574e-01f, 3.03143591e-01f, 1.95764259e-01f, -1.35355219e-01f, -3.10063474e-02f, -1.77021489e-01f,
  5.22009935e-03f, -1.58143431e-01f, -3.02322894e-01f, -2.04859540e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  4.58753496e-01f, 1.77970991e-01f, 4.30629998e-02f, -4.05270934e-01f, -7.15736672e-03f, 1.62643597e-01f, 2.27156803e-01f, -2.85633206e-01f, -7.42502734e-02f, -9.94635075e-02f,
  3.99098575e-01f, -1.81686863e-01f, -4.95777205e-02f, 4.22906280e-02f, -9.73581150e-02f, 3.21640193e-01f, -3.16802680e-01f, 2.21241131e-01f, -4.30133849e-01f, -4.83338624e-01f,
  2.40249097e-01f, 4.27987486e-01f, 3.45708318e-02f, -4.67880666e-01f, 2.48115603e-02f, 3.57109576e-01f, 5.88441849e-01f, 4.47994560e-01f, -9.81614813e-02f, -2.12580204e-01f,
  7.63567388e-02f, 9.51011404e-02f, -7.03717098e-02f, 4.62927699e-01f, 3.08989603e-02f, 3.46355617e-01f, 4.99691755e-01f, 4.42726523e-01f, -5.90151548e-03f, 5.16959846e-01f,
  2.15459436e-01f, 2.29181841e-01f, 3.01494569e-01f, 2.22282231e-01f, 2.83821106e-01f, 3.08042523e-02f, -3.15664470e-01f, 1.16087697e-01f, 3.46049190e-01f, 5.26989818e-01f,
  -9.00927372e-03f, -3.90693136e-02f, -3.89148630e-02f, 1.24069579e-01f, 1.49146736e-01f, 3.95887375e-01f, 2.19834715e-01f, -3.10014337e-01f, 1.02108225e-01f, -2.48379577e-02f,
  -1.39533266e-01f, 3.38580489e-01f, 1.96303502e-01f, -5.63983843e-02f, 1.01376049e-01f, 6.80495128e-02f, -9.90120173e-02f, 2.75756508e-01f, -3.21427017e-01f, 2.92201191e-01f,
  2.40761429e-01f, 1.60848096e-01f, 2.29258239e-01f, 3.65380734e-01f, 1.95453659e-01f, -1.77697361e-01f, -2.14896455e-01f, 4.17619586e-01f, -1.67667255e-01f, -1.80721417e-01f,
  -6.09227121e-01f, -4.05453175e-01f, 8.51146132e-02f, -4.90154093e-03f, 4.90169823e-01f, 1.05918199e-01f, -4.21549410e-01f, -3.55354041e-01f, -5.35588525e-02f, -2.34763488e-01f,
  -2.26649627e-01f, 2.44307816e-01f, 4.60104942e-02f, -2.79968288e-02f, 4.79118198e-01f, 3.29921573e-01f, 1.90840647e-01f, 7.62651414e-02f, 2.10951447e-01f, 2.14185521e-01f,
  -2.96096236e-01f, -1.72238052e-01f, 2.27779433e-01f, 1.95979029e-01f, -1.85050100e-01f, -2.46430397e-01f, 3.60978991e-02f, -1.38114214e-01f, -4.04979289e-02f, -3.83025348e-01f,
  6.78265318e-02f, 3.40879381e-01f, -9.05380696e-02f, -9.81853679e-02f, 2.26858370e-02f, 1.00028887e-01f, -3.39358389e-01f, 1.09122708e-01f, -2.76179552e-01f, -1.48425251e-01f,
  -2.13904426e-01f, 1.03560328e-01f, 2.94611722e-01f, -1.00895174e-01f, 5.94670534e-01f, -1.08496826e-02f, 2.62735754e-01f, -2.48041470e-02f, 4.75659687e-03f, 4.43807691e-01f,
  4.69671547e-01f, 5.52255929e-01f, 1.75304458e-01f, -1.47096977e-01f, 3.40664610e-02f, 4.43953186e-01f, -7.64066949e-02f, -1.22028045e-01f, 2.67334670e-01f, -4.88349289e-01f,
  1.88446313e-01f, -4.91522014e-01f, 4.08932209e-01f, -1.69182926e-01f, -4.29956287e-01f, 1.01647981e-01f, 3.23466718e-01f, -4.64639328e-02f, 2.10491568e-01f, 2.68314540e-01f,
  -3.71506125e-01f, -2.49022618e-01f, -1.89572960e-01f, 4.39408161e-02f, 7.54445493e-02f, 6.47063181e-02f, 3.16033751e-01f, 3.64424959e-02f, 5.90826750e-01f, 2.51656592e-01f,
  1.42357826e-01f, 2.18198046e-01f, -1.16060026e-01f, -1.69424474e-01f, 1.27616465e-01f, 3.41134481e-02f, -2.14086529e-02f, 2.01410547e-01f, 8.32319334e-02f, 1.31172061e-01f,
  8.52556899e-02f, 1.82155207e-01f, 4.07919019e-01f, 1.65025771e-01f, -4.97039825e-01f, -3.40897083e-01f, 1.42832801e-01f, 3.33488315e-01f, 3.27501774e-01f, 2.12082446e-01f,
  -1.59373313e-01f, -1.16340615e-01f, 3.34937125e-01f, 3.94365370e-01f, 1.41972631e-01f, -1.63060904e-01f, 6.65861964e-02f, 3.95351350e-02f, -4.79398370e-02f, 6.59599761e-03f,
  1.67309001e-01f, 2.49982700e-01f, 1.75777167e-01f, -5.35267442e-02f, 1.39437418e-03f, -1.31821960e-01f, 1.50510445e-01f, 9.74076390e-02f, -1.41968966e-01f, 2.04286654e-03f,
  -3.09493151e-02f, 2.51332760e-01f, 2.00494945e-01f, 5.36944009e-02f, 1.28317038e-02f, -1.84452042e-01f, 2.48846725e-01f, -1.95902973e-01f, 2.45639697e-01f, 9.24598426e-02f,
  -1.50321960e-01f, 2.46940732e-01f, 5.92446374e-03f, -2.43715525e-01f, -1.22847281e-01f, -4.10975963e-02f, 2.27456704e-01f, 4.30541560e-02f, 9.68686119e-02f, -1.02031685e-01f,
  -6.66373819e-02f, 3.13822150e-01f, 2.04463348e-01f, 1.41014308e-01f, -1.70961082e-01f, -1.00628033e-01f, -8.32071900e-02f, -8.15652162e-02f, -3.74036729e-02f, 3.37269120e-02f,
  -1.36040762e-01f, -7.74037465e-02f, 8.72863010e-02f, 6.45084456e-02f, -8.68821144e-02f, -3.55503778e-03f, -1.24471039e-01f, -4.83740643e-02f, 5.18183485e-02f, -9.17028338e-02f,
  -1.01665884e-01f, 1.06203586e-01f, -7.47794211e-02f, 1.23242393e-01f, 1.46915540e-01f, 1.28934048e-02f, 9.82988551e-02f, 8.07625055e-02f, -1.21023960e-01f, 4.24305024e-03f,
  -1.53543949e-01f, -2.79329158e-02f, -6.93207458e-02f, -1.60510659e-01f, 1.65031135e-01f, -1.45091757e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.14340812e-01f, 3.19527015e-02f, 2.13382438e-01f, 2.38495275e-01f, 3.50775182e-01f, -1.21994233e-02f, -5.25613949e-02f, -1.27795964e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  2.59124070e-01f, 2.09451899e-01f, 8.65219533e-01f, 1.59180731e-01f, -5.85176051e-01f, 9.57839265e-02f, -3.54245067e-01f, -6.88595474e-01f, 2.38204271e-01f, 3.78106028e-01f,
  8.25691223e-02f, -3.13109368e-01f, -1.67760491e-01f, -4.22782987e-01f, 3.13355058e-01f, 1.03510536e-01f, -4.10217226e-01f, 5.24159567e-03f, 3.05121273e-01f, 5.31867206e-01f,
  -1.58455923e-01f, -2.89246440e-01f, 8.33633542e-03f, -5.05096912e-01f, 9.39379811e-01f, -2.01784268e-01f, -7.75375366e-01f, 4.55966173e-03f, -8.48161697e-01f, -1.02248862e-01f,
  8.43377709e-02f, -9.06666666e-02f, -2.08015844e-01f, -4.96495605e-01f, 4.18956667e-01f, 2.44907871e-01f, 1.66557312e-01f, -7.60205388e-01f, 3.99269611e-01f, -2.35197410e-01f,
  2.12101087e-01f, 5.89775085e-01f, 3.93937141e-01f, 6.31549060e-01f, -5.07467464e-02f, -8.26926351e-01f, 4.92405891e-01f, 6.49453282e-01f, -1.92469209e-01f, -6.72965646e-01f,
  -7.87363872e-02f, -4.72976118e-01f, -2.17013344e-01f, -7.14633316e-02f, -1.22408129e-01f, 4.30517048e-01f, 1.29413649e-01f, -1.51270524e-01f, -3.71002853e-01f, 7.22177207e-01f,
  3.90275598e-01f, -3.89825702e-01f, 2.58369260e-02f, 9.11144726e-03f, 3.45287360e-02f, 1.77428842e-01f, -1.30395606e-01f, 1.28614992e-01f, 5.38720250e-01f, 4.14854765e-01f,
  2.49830887e-01f, 3.28685373e-01f, -7.62802124e-01f, 3.90059412e-01f, 1.87799975e-01f, 6.54051360e-03f, -7.58734465e-01f, 2.05254592e-02f, -2.50947535e-01f, -6.76727116e-01f,
  5.94534837e-02f, 6.94964230e-01f, 1.40612945e-01f, -2.57600844e-01f, -5.03148198e-01f, -6.54493570e-01f, 9.93361250e-02f, -6.04598224e-01f, -3.22000504e-01f, 6.80965900e-01f,
  -2.92873800e-01f, -3.15740228e-01f, -2.82405674e-01f, -4.67072189e-01f, 1.63948625e-01f, 1.40803337e-01f, 4.89868879e-01f, 4.60901745e-02f, -5.77131629e-01f, 1.12333693e-01f,
  -1.46852821e-01f, 1.55125275e-01f, -3.50822389e-01f, 3.04854631e-01f, 2.16211408e-01f, 4.33132946e-02f, 1.61689207e-01f, -9.54712853e-02f, -2.74815321e-01f, 5.02070010e-01f,
  -3.45485419e-01f, -5.22930384e-01f, -1.92205548e-01f, -3.72176111e-01f, 3.59106123e-01f, 2.45190576e-01f, 4.71402794e-01f, -2.98874229e-01f, -9.21674073e-01f, -3.76500785e-01f,
  4.06757981e-01f, -4.35845107e-01f, 8.12876105e-01f, -2.98136920e-01f, -8.70871007e-01f, -1.82360914e-02f, 7.66499415e-02f, 1.47064820e-01f, -1.81693867e-01f, -1.78296436e-02f,
  -6.94694042e-01f, 2.96945602e-01f, 2.65359372e-01f, 3.38676721e-01f, -5.15276551e-01f, -8.07419941e-02f, 2.71819770e-01f, -3.43978256e-01f, 1.98470056e-01f, -6.43269300e-01f,
  -3.50453854e-01f, -3.01739365e-01f, -3.30260217e-01f, 1.27987608e-01f, -1.41380221e-01f, -1.07289515e-02f, -2.01609358e-01f, 2.92391568e-01f, 1.93833858e-01f, -1.24869302e-01f,
  1.67384028e-01f, 1.08101107e-01f, 7.29204714e-01f, -1.81867287e-01f, 2.00270952e-04f, 1.88337848e-01f, 2.57442266e-01f, -2.51034945e-01f, 1.04811482e-01f, 1.65168554e-01f,
  -4.10158575e-01f, 4.51026857e-01f, 6.31261617e-03f, 7.29258284e-02f, -3.51592958e-01f, 1.41004637e-01f, 4.44962502e-01f, -1.65026844e-01f, -1.91632822e-01f, -1.13880754e-01f,
  -9.39321220e-02f, 2.24483967e-01f, -2.48771429e-01f, -1.11884005e-01f, -5.29110670e-01f, 6.50641143e-01f, -5.94001710e-01f, -7.28921115e-01f, 8.89084488e-03f, -3.37577641e-01f,
  -5.49848497e-01f, -6.27205372e-01f, 3.18459302e-01f, 5.40956199e-01f, -2.53145657e-02f, 8.49979043e-01f, -4.22499925e-01f, -1.11682460e-01f, -4.22724634e-01f, 3.78292412e-01f,
  -8.81407410e-02f, -9.41113904e-02f, 3.09755296e-01f, -4.81894672e-01f, 4.43678290e-01f, -6.93107545e-01f, -2.97061890e-01f, -6.50264978e-01f, 4.67942208e-01f, 1.94573730e-01f,
  -4.23706025e-01f, -1.22328743e-01f, 3.74659956e-01f, 5.77983797e-01f, 6.32439494e-01f, 3.28487635e-01f, 2.10845783e-01f, -3.11747879e-01f, 7.66475499e-01f, 2.95315266e-01f,
  -3.86092782e-01f, -2.40206886e-02f, -5.20535171e-01f, 6.29007459e-01f, 2.08413422e-01f, -2.90623080e-04f, -2.87249863e-01f, -4.17808145e-02f, -1.06013119e-02f, -2.46720046e-01f,
  -1.33070245e-01f, -1.19865559e-01f, 5.69019079e-01f, 1.16788797e-01f, -7.54321456e-01f, 3.25480193e-01f, 1.89120080e-02f, -3.51968229e-01f, 1.60459317e-02f, -1.80490196e-01f,
  6.90463856e-02f, -1.26057670e-01f, 1.99719816e-01f, 2.88088888e-01f, -2.83353359e-01f, -8.67033824e-02f, 7.14987338e-01f, 2.15460077e-01f, -1.68130025e-01f, -5.08777618e-01f,
  -4.51495826e-01f, 5.28753579e-01f, 2.61725992e-01f, -4.41984743e-01f, 4.33494121e-01f, -4.37250763e-01f, -1.12123454e+00f, -4.62323189e-01f, -4.18618441e-01f, -3.53156209e-01f,
  4.52727973e-01f, 4.80108678e-01f, 1.89294219e-01f, 4.45171073e-02f, -2.48501897e-01f, 8.18141848e-02f, 4.75849807e-02f, 3.44521135e-01f, -3.19556475e-01f, 1.12986691e-01f,
  3.64781588e-01f, 3.82574886e-01f, -3.04007120e-02f, 1.67301685e-01f, 9.35096890e-02f, 2.40584493e-01f, -4.82488394e-01f, -4.08031136e-01f, -3.72083157e-01f, -3.74822855e-01f,
  8.17356110e-01f, 1.95966288e-01f, 4.72521037e-01f, -1.67741001e-01f, -5.51058829e-01f, 1.11171983e-01f, 1.65761083e-01f, 7.54867435e-01f, 2.91418999e-01f, 7.00208306e-01f,
  -3.59757125e-01f, 4.02066886e-01f, -2.99818158e-01f, -2.07003638e-01f, -1.49658874e-01f, 7.31600940e-01f, 1.88566372e-01f, -1.69768989e-01f, 1.08910836e-01f, -3.00937355e-01f,
  -6.37484074e-01f, -3.42962265e-01f, 9.04165581e-02f, -9.48207006e-02f, -2.07088843e-01f, -1.01964727e-01f, -5.68171263e-01f, 5.35760641e-01f, -1.16902739e-01f, -4.56582487e-01f,
  4.48271543e-01f, 1.76868975e-01f, -2.47901395e-01f, -2.86142677e-01f, 8.27746212e-01f, 4.23992276e-01f, 6.03305578e-01f, 1.90481008e-03f, -3.40949386e-01f, 4.01853591e-01f,
  1.11054420e-01f, -4.65458572e-01f, 1.14549905e-01f, -9.67590138e-02f, 4.53540474e-01f, 1.77806318e-01f, 5.57252705e-01f, -1.88781857e-01f, 2.16882169e-01f, 6.02400266e-02f,
  4.51019347e-01f, -1.93790764e-01f, -5.25826141e-02f, -4.35490042e-01f, -3.06166738e-01f, 1.50530010e-01f, -4.17353362e-01f, 1.96971655e-01f, 1.86061949e-01f, -6.94740117e-01f,
  -1.49779812e-01f, -1.37741759e-01f, 4.42382544e-01f, -4.50602323e-01f, 4.73520786e-01f, 6.73318624e-01f, -4.08542514e-01f, -3.49316090e-01f, 3.52942824e-01f, -8.48776251e-02f,
  1.15446754e-01f, -3.36787194e-01f, 2.33514816e-01f, -4.80315834e-01f, -5.57812333e-01f, 3.59468609e-01f, 3.52563053e-01f, -3.22926372e-01f, 5.03251195e-01f, 2.21218258e-01f,
  -1.46495983e-01f, 1.48613721e-01f, 3.18894804e-01f, 1.91471148e-02f, 3.81251603e-01f, 2.90527225e-01f, 3.08933318e-01f, 1.98308125e-01f, 7.88050517e-03f, -7.77343474e-03f,
  5.77801943e-01f, -3.94623786e-01f, -4.06558663e-01f, 2.17012137e-01f, -2.34256089e-01f, 5.49757838e-01f, -1.90650672e-02f, -5.96955359e-01f, 4.85055447e-01f, 5.24730146e-01f,
  -6.83625579e-01f, -5.55873692e-01f, 2.44864285e-01f, 4.43967104e-01f, 3.34199995e-01f, 5.50331056e-01f, -3.52246612e-01f, -4.93134409e-01f, 1.11043639e-01f, 1.62988424e-01f,
  4.43389773e-01f, -2.56201059e-01f, -2.72040844e-01f, 8.44291523e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  2.30811477e-01f, 5.43416627e-02f, 1.62812054e-01f, -7.89275467e-02f, -1.79297701e-01f, -1.01899765e-01f, 4.71237749e-02f, 1.52716279e-01f, -5.42378761e-02f, -3.51975352e-01f,
  -1.98614106e-01f, 1.80299073e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    