/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.14394882e-01f, 2.47831896e-01f, -3.67460310e-01f, -2.33989030e-01f, -1.32861108e-01f, -3.73728648e-02f, 2.48462662e-01f, 1.21689431e-01f, 6.36446923e-02f, 3.12463164e-01f,
  3.65169793e-01f, 2.71994740e-01f, 2.25201368e-01f, 9.66795906e-02f, -5.62189929e-02f, 1.61542162e-01f, -2.06238553e-01f, -4.17741001e-01f, -4.14526671e-01f, -1.12927929e-01f,
  7.06968829e-02f, -2.16061711e-01f, -3.41830432e-01f, -8.17467272e-02f, 5.73155992e-02f, 1.35868192e-01f, 1.73271686e-01f, -2.31340691e-01f, 1.85808521e-02f, -2.00794950e-01f,
  3.38779166e-02f, -6.04624627e-03f, -6.82647200e-03f, 6.00352101e-02f, -6.38612881e-02f, -2.78478675e-02f, 4.03349437e-02f, 3.07462178e-02f, 7.91130215e-02f, 2.92832106e-02f,
  1.02218442e-01f, 1.90512314e-02f, 1.52411349e-02f, -2.83387862e-02f, 1.53086567e-02f, 3.19951251e-02f, -4.40856591e-02f, -1.19060963e-01f, -2.73503195e-02f, 7.96240568e-02f,
  1.02110125e-01f, -5.74110523e-02f, -6.28725365e-02f, 6.02186248e-02f, 3.93246301e-02f, -3.36755812e-02f, 6.01763427e-02f, -2.40183938e-02f, 7.06235543e-02f, 2.09122635e-02f,
  1.01403445e-01f, 9.64795239e-03f, -3.92245874e-02f, -9.33529437e-02f, 1.61105115e-02f, -2.47627925e-02f, -8.22780952e-02f, -1.75098199e-02f, -7.56017417e-02f, -5.36591597e-02f,
  4.22513392e-03f, -1.50429504e-02f, 1.52951824e-02f, 3.85016315e-02f, 1.05930299e-01f, -1.12063676e-01f, -4.62811179e-02f, -1.55116254e-02f, -3.39963883e-02f, -1.03607327e-01f,
  -4.79299873e-02f, -4.51463461e-03f, -6.22323994e-03f, 1.86765175e-02f, -5.80999954e-03f, -5.23289330e-02f, 9.98527780e-02f, 3.82720493e-02f, 8.42168368e-03f, -9.73801017e-02f,
  3.54605466e-01f, -9.42522660e-02f, 1.37362301e-01f, 1.02979578e-01f, 3.61959562e-02f, -4.19707820e-02f, -6.48380909e-03f, 4.40713316e-02f, 1.67290922e-02f, 1.04315840e-01f,
  1.23299032e-01f, 1.16800852e-02f, 8.97296369e-02f, 5.44093922e-02f, -9.61653190e-04f, 1.09747589e-01f, 1.38459384e-01f, -3.29668038e-02f, 8.38001370e-02f, 6.07711188e-02f,
  1.49519473e-01f, 7.81953558e-02f, -3.64511274e-02f, 1.77904785e-01f, 1.26361430e-01f, 1.70358285e-01f, 8.12172666e-02f, 3.47913080e-03f, 1.01293705e-01f, 2.90107250e-01f,
  5.10990322e-01f, 1.83123052e-01f, 1.89134270e-01f, 2.37408653e-01f, -9.66685712e-02f, -8.16230848e-02f, -1.50091439e-01f, 8.41095299e-03f, 4.16771434e-02f, -1.81533799e-01f,
  1.13838375e-01f, 4.80179004e-02f, 1.26557276e-01f, -2.71623069e-03f, 2.11364806e-01f, -2.00615171e-02f, -4.75745574e-02f, 5.36880083e-02f, 2.48698629e-02f, -9.50932875e-02f,
  -7.53423944e-02f, -3.08687650e-02f, 1.59400553e-01f, 5.77666275e-02f, -2.46189415e-01f, -1.35245025e-01f, -2.54218336e-02f, -5.15967198e-02f, -1.14438303e-01f, -5.60735464e-01f,
  1.33201107e-01f, 1.74637094e-01f, -2.49378365e-02f, 7.05423951e-02f, 8.53255913e-02f, -5.83416112e-02f, 8.55070800e-02f, -1.45038394e-02f, 1.74851529e-02f, -4.19267081e-02f,
  1.65923417e-01f, 5.39638177e-02f, 2.31389981e-02f, -3.14564966e-02f, 1.16108716e-01f, -2.61218138e-02f, 1.35633677e-01f, 1.45327836e-01f, 8.31693709e-02f, 8.00579786e-02f,
  7.27896169e-02f, 1.21011935e-01f, 1.41307130e-01f, 7.61949867e-02f, 7.61878677e-04f, 1.38174996e-01f, 1.34278342e-01f, 4.38622870e-02f, 2.92836055e-02f, -1.71318263e-01f,
  1.27553806e-01f, -2.32730228e-02f, -8.67123455e-02f, -5.32328524e-02f, -4.55708355e-02f, 1.61127578e-02f, -5.73859476e-02f, 1.08103082e-02f, -2.92552970e-02f, -5.44162616e-02f,
  7.47388005e-02f, -3.41250412e-02f, -6.05152780e-03f, 3.70316161e-03f, -1.47502810e-01f, 1.88765582e-02f, -1.00063965e-01f, -8.85797944e-03f, 1.95182003e-02f, -9.77809578e-02f,
  -3.56852673e-02f, -1.06868604e-02f, -2.71072495e-03f, -2.21696217e-02f, 4.28538211e-02f, 1.18948527e-01f, -1.69951506e-02f, -2.96434853e-02f, 2.28571184e-02f, -2.58631893e-02f,
  1.32274523e-01f, 1.69163436e-01f, -9.10179503e-03f, -1.80747062e-02f, 9.18716192e-02f, 1.13733582e-01f, 4.45670225e-02f, 4.55805101e-02f, 1.35420084e-01f, -8.02649930e-02f,
  1.46205844e-02f, 5.51834404e-02f, 1.39265999e-01f, -6.08728863e-02f, -5.82211129e-02f, 4.20608371e-02f, -9.50627308e-03f, 3.01442500e-02f, -5.66571690e-02f, -6.25756457e-02f,
  -1.89403873e-02f, -7.73543343e-02f, 1.13372616e-01f, -3.36162746e-02f, -4.08878103e-02f, -1.13161756e-02f, -7.10458532e-02f, -1.38550043e-01f, 2.21407171e-02f, -3.89605686e-02f,
  -1.40095949e-01f, 1.26937136e-01f, 1.56120315e-01f, -1.89089775e-01f, -5.61668389e-02f, -2.42791072e-01f, -1.49277329e-01f, -8.12081397e-02f, -1.12260625e-01f, -8.25608522e-02f,
  7.58969039e-03f, -2.03935485e-02f, 4.81364466e-02f, 1.73770294e-01f, -1.39581449e-02f, 2.82701086e-02f, 1.94568902e-01f, 2.18855783e-01f, 3.09850629e-02f, -3.05570215e-02f,
  8.39711428e-02f, 1.10887550e-02f, 8.81516635e-02f, 8.25651512e-02f, -2.84030810e-02f, -7.42274802e-04f, 1.03028789e-02f, -6.98448047e-02f, 8.03405885e-04f, 4.01158988e-01f,
  1.23686597e-01f, 9.02636722e-02f, -3.79896462e-02f, -3.41177918e-02f, -5.89818321e-02f, 1.00164205e-01f, 1.39779806e-01f, 9.65623930e-02f, 5.66469319e-02f, 7.90832266e-02f,
  -2.39208359e-02f, 4.30919081e-02f, -3.76772173e-02f, -9.35077667e-03f, -3.08040939e-02f, -1.05738029e-01f, -2.29352284e-02f, 1.40227839e-01f, 1.25723705e-01f, -1.05865046e-01f,
  1.39403686e-01f, 9.98402983e-02f, -7.80181214e-02f, -2.54721455e-02f, -5.89138418e-02f, 8.64782277e-03f, -9.47990641e-03f, 4.31284197e-02f, -2.00917013e-03f, -1.11756057e-01f,
  -1.29528433e-01f, 8.63421485e-02f, 1.04269624e-01f, 3.80128659e-02f, -3.40148322e-02f, -8.22188705e-03f, 8.52222443e-02f, -8.53951438e-04f, -1.12384148e-02f, -6.81831613e-02f,
  4.51220013e-02f, -1.41826823e-01f, 7.63711333e-02f, 6.78081438e-03f, 1.85290165e-02f, -1.57422926e-02f, 1.36617720e-01f, 6.05819225e-02f, -7.71062151e-02f, 3.41799334e-02f,
  4.10758629e-02f, 2.19502449e-02f, 6.67257756e-02f, -2.56528705e-02f, 9.59259868e-02f, 1.04568176e-01f, -2.56330310e-03f, 2.34221686e-02f, 2.98783612e-02f, 1.37953237e-02f,
  -3.80593121e-01f, 1.67769775e-01f, -1.02204911e-01f, -5.97397685e-02f, -9.19831991e-02f, -8.25665444e-02f, 8.33040401e-02f, 1.09135382e-01f, 4.33139652e-02f, -5.80552220e-02f,
  2.63335910e-02f, -2.04988923e-02f, 7.88569730e-03f, -2.87700593e-02f, -1.32790372e-01f, -1.83178056e-02f, -1.32866919e-01f, -5.19110858e-02f, -1.77428324e-03f, -5.60018197e-02f,
  -1.08511589e-01f, -2.53305465e-01f, -2.00387701e-01f, -1.26254961e-01f, -1.75212398e-01f, -2.02149883e-01f, -2.19142586e-01f, -2.23096430e-01f, -8.47752467e-02f, -4.07496125e-01f,
  8.33092809e-01f, -1.15858153e-01f, -1.20712116e-01f, 1.84879109e-01f, -9.25097167e-02f, 1.24956682e-01f, 8.50890204e-02f, 9.70177054e-02f, -2.85295658e-02f, -1.73090801e-01f,
  -1.56789571e-01f, -6.48874491e-02f, -1.84295937e-01f, -1.63876474e-01f, 1.49658352e-01f, -7.96949640e-02f, -8.73456672e-02f, 1.61418261e-03f, 2.14702725e-01f, 7.14602917e-02f,
  -6.97195604e-02f, 1.36699811e-01f, 1.36606306e-01f, 1.00526892e-01f, -1.56600863e-01f, -3.49201560e-02f, -2.33342648e-01f, -1.16764449e-01f, -5.66436499e-02f, -2.08078101e-01f,
  -5.29773533e-02f, 9.58035737e-02f, -2.38891933e-02f, 5.85367568e-02f, -1.52531505e-01f, 1.23680965e-03f, -1.05454817e-01f, -2.15260491e-01f, -7.82328025e-02f, -3.80546227e-02f,
  -1.01138309e-01f, -7.08158836e-02f, -3.18836272e-02f, -1.78405672e-01f, -1.04026891e-01f, 6.39886260e-02f, -7.84237981e-02f, -8.94991010e-02f, -1.47248775e-01f, -1.00185154e-02f,
  -5.83038144e-02f, -1.20115792e-02f, -3.66783850e-02f, -3.78862321e-02f, -8.91156420e-02f, -6.49300143e-02f, -5.59369512e-02f, -4.31846008e-02f, -5.27794957e-02f, -1.54272348e-01f,
  -1.36089884e-02f, 1.06555335e-02f, 6.00344278e-02f, 3.87121662e-02f, 1.40105784e-01f, 8.66252258e-02f, 2.34679226e-02f, 4.71948534e-02f, 4.09670882e-02f, 6.78098351e-02f,
  5.60474321e-02f, 3.78523581e-03f, 2.75626518e-02f, 4.07749303e-02f, -5.68794198e-02f, 2.39930842e-02f, 5.07739596e-02f, 2.87348293e-02f, 3.57526983e-03f, 1.53894648e-02f,
  1.03542199e-02f, -1.22235669e-02f, 8.20214376e-02f, 4.18546982e-03f, -4.62952033e-02f, -1.46933105e-02f, -2.78917309e-02f, 4.12250943e-02f, 1.23939492e-01f, 9.45698693e-02f,
  4.96308133e-02f, -1.02441143e-02f, 1.79462750e-02f, -8.06375518e-02f, -4.61662188e-02f, -1.03615165e-01f, -1.06143951e-01f, -6.20690472e-02f, 3.20864022e-02f, -2.30286513e-02f,
  -3.49772125e-02f, 4.35343683e-02f, -1.75068080e-02f, 2.26702634e-03f, 1.05528958e-01f, 1.90549474e-02f, -5.30646071e-02f, 4.76781838e-02f, -2.21896078e-02f, -1.03742510e-01f,
  -5.94278462e-02f, 4.31607887e-02f, 1.20061293e-01f, 5.74407950e-02f, 5.81221506e-02f, 1.89476088e-01f, -9.54299867e-02f, -8.80611390e-02f, 6.92146793e-02f, 9.87122580e-02f,
  5.36190093e-01f, 3.69583704e-02f, -1.09335527e-01f, 4.57049012e-01f, 1.56825379e-01f, -2.42609188e-01f, -1.48757398e-01f, -2.45876849e-01f, 1.14935808e-01f, 7.56051466e-02f,
  -1.68671131e-01f, -6.88055344e-03f, -5.56764416e-02f, -1.86602071e-01f, -2.48769566e-01f, 9.20070708e-02f, 8.95315632e-02f, -2.58762692e-03f, -5.97892739e-02f, -2.60202661e-02f,
  1.69843376e-01f, 3.71060640e-01f, 1.12002715e-01f, 2.71349363e-02f, 2.05416188e-01f, 7.22277211e-03f, -2.44892407e-02f, 5.73095120e-02f, -6.32971674e-02f, 3.52020949e-01f,
  1.47811130e-01f, -1.29945977e-02f, -8.86825398e-02f, -2.39489544e-02f, -2.93324459e-02f, -3.93955782e-02f, 7.24918693e-02f, -6.71031279e-03f, -2.22797319e-03f, -7.10546896e-02f,
  7.36439154e-02f, 3.07543296e-02f, 2.75945719e-02f, -4.91766371e-02f, 7.24825114e-02f, -2.78725605e-02f, 2.58439668e-02f, -7.71727264e-02f, -7.89093226e-02f, -1.46119028e-01f,
  -6.86260760e-02f, 8.61221831e-03f, -5.53619191e-02f, -1.63820043e-01f, -1.42169297e-01f, -2.04803534e-02f, -3.67985256e-02f, -2.00881213e-02f, -2.18137309e-01f, 1.45573216e-02f,
  5.58878183e-02f, 1.44828139e-02f, 6.82543367e-02f, 3.33310850e-02f, -2.14922670e-02f, -4.19644304e-02f, 4.07355689e-02f, 6.83760410e-03f, -6.32451177e-02f, 2.19292217e-03f,
  -1.02406539e-01f, 5.46624511e-02f, -1.81765966e-02f, -4.04778831e-02f, 3.08105838e-03f, 2.65227482e-02f, 2.94036884e-02f, 5.17626852e-02f, -7.40591660e-02f, 5.26358634e-02f,
  2.57737171e-02f, 2.38572229e-02f, 1.28735542e-01f, -2.61618067e-02f, 7.02876747e-02f, 4.91918996e-02f, 7.06023052e-02f, -1.51408225e-01f, 3.62588502e-02f, -7.34428167e-02f,
  2.90092498e-01f, -2.51899511e-01f, 1.12750098e-01f, 1.81374308e-02f, -1.74055099e-02f, 2.52609979e-02f, 1.20971784e-01f, 4.68135737e-02f, 4.70443815e-02f, 6.40795603e-02f,
  -5.10670766e-02f, 9.54266861e-02f, 4.63553220e-02f, -2.93542538e-02f, 1.08090844e-02f, -1.06811887e-02f, 2.19249278e-02f, 4.15325761e-02f, -7.35549480e-02f, 4.51699756e-02f,
  5.67409657e-02f, -4.71200310e-02f, -7.90130347e-03f, -5.47545888e-02f, -6.15963675e-02f, 3.15767676e-02f, -1.31111285e-02f, 2.05683503e-02f, -7.29167163e-02f, 6.91087767e-02f,
  5.40440142e-01f, -1.00884520e-01f, -8.04083422e-02f, 3.12906265e-01f, -1.03478074e-01f, -1.17884792e-01f, -1.20116971e-01f, -2.36835107e-02f, 7.39795044e-02f, -1.71694774e-02f,
  -2.89997086e-02f, 1.04796708e-01f, 8.23233426e-02f, -4.97681613e-04f, 2.70011183e-02f, -3.92834796e-03f, -3.24847028e-02f, 8.17836896e-02f, 2.08386987e-01f, 5.24853170e-02f,
  -1.24721248e-02f, 1.85096383e-01f, 1.72476783e-01f, 5.96685410e-02f, -3.36322980e-03f, -4.44925688e-02f, -5.17455563e-02f, 3.74065246e-03f, -2.43760735e-01f, -4.44734134e-02f,
  1.95968166e-01f, -1.40994236e-01f, -1.15604155e-01f, -1.19741946e-01f, -1.49157926e-01f, -6.61894381e-02f, 6.15728125e-02f, -7.76847228e-02f, -1.16540305e-01f, -4.62499261e-02f,
  -1.19290508e-01f, -1.09113425e-01f, -4.80463952e-02f, -7.71014914e-02f, -3.52426060e-02f, 2.87972149e-02f, 3.10021639e-02f, 1.03606391e-04f, -3.48904878e-02f, 5.85055798e-02f,
  -7.95757100e-02f, -1.11935511e-01f, -7.40609923e-03f, -1.25550553e-01f, 2.59404406e-02f, -7.83087239e-02f, -1.63764164e-01f, -1.16372511e-01f, -7.80977458e-02f, 1.32461824e-02f,
  7.24906176e-02f, 5.06029241e-02f, 4.03846949e-02f, 1.70317814e-02f, 9.14227962e-03f, 3.45588056e-03f, 8.73821303e-02f, -5.35785593e-03f, -2.28148507e-04f, 6.88237920e-02f,
  -2.23578084e-02f, 9.94723514e-02f, 2.00997712e-03f, 5.07599972e-02f, -4.85566407e-02f, 8.14065784e-02f, 6.66481927e-02f, -8.44627097e-02f, -1.28541276e-01f, -3.39805819e-02f,
  -3.26661952e-02f, 1.29786953e-02f, 5.43861575e-02f, -4.03268449e-03f, 4.15390357e-02f, -4.49676439e-02f, 7.31287152e-03f, -3.38558890e-02f, 3.50260921e-02f, -3.79029736e-02f,
  1.85592026e-01f, -1.68704808e-01f, 9.62535068e-02f, 1.41783282e-02f, 2.84913648e-03f, -1.04590707e-01f, -3.67140435e-02f, -4.61845547e-02f, 8.52742717e-02f, -4.00560303e-03f,
  -7.78994560e-02f, 1.49483398e-01f, 1.33772958e-02f, 2.65854262e-02f, 2.25987248e-02f, -5.85273057e-02f, -2.24798732e-02f, 1.80054102e-02f, 7.44225970e-03f, -1.85980778e-02f,
  -4.55893129e-02f, -2.99559301e-03f, 1.19621143e-01f, -3.19946967e-02f, 9.13791358e-03f, 4.44708988e-02f, 1.04174823e-01f, -9.72172536e-04f, 1.29745081e-02f, 6.07239828e-02f,
  -3.99699062e-01f, -5.22379756e-01f, 8.32932591e-02f, -1.22274011e-01f, 5.74314333e-02f, 2.06124887e-01f, -1.92585409e-01f, 6.73040226e-02f, -3.60675082e-02f, -2.13944882e-01f,
  -2.80102760e-01f, 5.68643138e-02f, -4.13197242e-02f, 1.42384604e-01f, 3.52642387e-02f, -1.64761379e-01f, -2.39009112e-01f, 2.04464093e-01f, 4.24463809e-01f, 1.02148928e-01f,
  -9.83192772e-03f, -1.39578562e-02f, -1.47668365e-02f, 2.28299620e-03f, -1.96579263e-01f, 1.35306627e-01f, -1.02879174e-01f, 8.27754103e-03f, -4.78653088e-02f, -2.47176707e-01f,
  1.57327484e-02f, -2.37390533e-01f, 1.24860719e-01f, -2.25831166e-01f, -3.89480777e-02f, -1.09535731e-01f, -1.12404659e-01f, -9.95063856e-02f, -1.10535160e-01f, -1.26449779e-01f,
  -1.84963375e-01f, -1.12920910e-01f, -1.47311583e-01f, -9.21431780e-02f, -1.48456782e-01f, -1.48651749e-01f, -1.75960183e-01f, -2.38779150e-02f, 2.30273101e-04f, -1.28631845e-01f,
  -2.01804444e-01f, -2.45672747e-01f, -1.25599295e-01f, -6.02753349e-02f, -1.08242646e-01f, -1.04644615e-02f, -1.02338158e-02f, -1.12276785e-01f, 4.89916205e-02f, -2.76767045e-01f,
  -1.05800331e-01f, 1.39258966e-01f, 7.47902617e-02f, 3.09750065e-02f, 9.15745571e-02f, 6.86368570e-02f, 9.83532593e-02f, 4.13431153e-02f, 2.42041852e-02f, 5.66586182e-02f,
  7.73780793e-02f, -2.38538440e-02f, 4.37394716e-02f, 1.32582625e-02f, 3.53767648e-02f, 7.32372627e-02f, 1.26453266e-01f, 1.03719132e-02f, 6.77827597e-02f, -2.43522581e-02f,
  1.10083967e-02f, 7.57164508e-02f, 1.26795303e-02f, 7.98812509e-02f, -6.43682852e-02f, 5.62959611e-02f, 1.48468763e-02f, 8.24420080e-02f, 3.56815122e-02f, -2.70866156e-02f,
  -1.35881510e-02f, 1.97171986e-01f, -1.80985644e-01f, -1.24974638e-01f, -1.33455601e-02f, -1.10424101e-01f, -9.35561359e-02f, -6.16604313e-02f, -1.08418979e-01f, -6.76978156e-02f,
  -1.10529676e-01f, -6.38973340e-02f, -1.43461332e-01f, -3.59952897e-02f, -7.05751032e-02f, 3.58231589e-02f, -1.03107460e-01f, -2.50496231e-02f, -4.46392857e-02f, -1.58967882e-01f,
  -1.55244157e-01f, -3.12022530e-02f, 8.27109367e-02f, -2.70295125e-02f, 4.08067182e-02f, 4.53767031e-02f, 4.62053940e-02f, 9.56004392e-03f, 2.07230672e-01f, -4.86693643e-02f,
  -6.83094442e-01f, -2.96682000e-01f, -8.05940479e-02f, -1.11413993e-01f, 2.11406201e-01f, 7.98922852e-02f, -3.20396364e-01f, -2.11992219e-01f, -5.69707118e-02f, -1.02365658e-01f,
  1.51412591e-01f, 2.99795508e-01f, 1.73637196e-01f, 2.03211233e-01f, -2.90429205e-01f, -3.20610434e-01f, -1.10728092e-01f, -1.74359903e-01f, 3.22224535e-02f, 9.21551287e-02f,
  2.40525901e-01f, -1.31431162e-01f, -2.99376339e-01f, -7.56490976e-02f, 1.06930606e-01f, 1.55531839e-01f, -1.23424739e-01f, 8.22354853e-02f, 1.11911625e-01f, 7.02526867e-02f,
  2.11715743e-01f, -2.85313100e-01f, 9.99185964e-02f, 1.07063286e-01f, 1.59633942e-02f, -9.16604772e-02f, 4.40310575e-02f, -9.72969979e-02f, -5.73033020e-02f, -1.21805836e-02f,
  9.45734754e-02f, 2.28055939e-02f, -6.89111874e-02f, 9.47670713e-02f, -3.54012735e-02f, 3.73047404e-02f, -6.84785172e-02f, -1.24305993e-01f, -5.16415574e-02f, -4.73903567e-02f,
  3.65171507e-02f, 2.60532815e-02f, -1.21942852e-02f, 1.30289957e-01f, -1.97648928e-02f, 1.62494630e-01f, 3.98605056e-02f, 1.03740342e-01f, 4.27726731e-02f, -1.94053411e-01f,
  -7.37310946e-02f, 2.35541631e-02f, 1.44310156e-02f, -4.58401814e-03f, -1.01251178e-03f, 1.16784181e-02f, -8.32635537e-03f, 2.18033772e-02f, -1.71356779e-02f, -1.67150777e-02f,
  4.81949449e-02f, 6.64210543e-02f, 1.71684287e-02f, -4.17496935e-02f, 8.97033140e-02f, 3.74655016e-02f, 5.97053431e-02f, -8.20214208e-03f, 7.59802982e-02f, -3.08618937e-02f,
  1.20679073e-01f, -5.83319599e-03f, 6.11295737e-02f, 3.75695564e-02f, 5.22940010e-02f, -2.32640784e-02f, 3.20684277e-02f, 4.40392531e-02f, 3.27920949e-04f, -5.87461367e-02f,
  2.48906221e-02f, 3.31673436e-02f, -3.51521634e-02f, -5.59287295e-02f, -7.41251707e-02f, -1.64237283e-02f, 9.19444337e-02f, 1.43430782e-02f, 7.67502338e-02f, -4.91682440e-02f,
  -5.32338731e-02f, -5.07523566e-02f, -7.03811869e-02f, -4.58339266e-02f, -8.58867615e-02f, 7.90483281e-02f, -3.06148399e-02f, 5.43094464e-02f, 7.07527325e-02f, -1.53369829e-02f,
  -1.40153229e-01f, -1.89483538e-01f, -1.78977326e-01f, -4.68810499e-02f, 2.12785602e-02f, 1.58440298e-03f, 2.44204123e-02f, -1.45320505e-01f, -6.19776137e-02f, -3.39393795e-01f,
  -1.48273841e-01f, 4.71757531e-01f, 1.86568834e-02f, -1.81124732e-01f, 2.04972446e-01f, -4.36469987e-02f, 2.84885079e-01f, 1.01809934e-01f, -2.22567990e-01f, 1.87178805e-01f,
  8.31324458e-02f, -4.33442369e-02f, -1.22016177e-01f, -5.48539571e-02f, -1.31871194e-01f, 1.06395688e-02f, -4.20540720e-02f, -1.67404935e-01f, -2.39244625e-01f, -4.56718281e-02f,
  9.29981396e-02f, -1.40480712e-01f, -1.71775654e-01f, -1.52917162e-01f, 9.00373384e-02f, -7.20093697e-02f, 7.02375546e-02f, 1.59000680e-01f, 9.47061107e-02f, 2.09070608e-01f,
  -5.23665845e-02f, 3.13192189e-01f, -1.80223793e-01f, -2.01609731e-02f, 4.16905694e-02f, -6.70572892e-02f, -6.23094849e-02f, 5.15825041e-02f, 1.19673023e-02f, 4.41896617e-02f,
  9.22724456e-02f, -6.32669078e-03f, 1.08980220e-02f, -2.19561625e-03f, -1.56771857e-02f, -7.49766752e-02f, -6.16098195e-02f, -6.86466619e-02f, -2.17427872e-02f, 1.04291633e-01f,
  9.90626439e-02f, 2.30758563e-01f, 5.55877946e-02f, -3.98615226e-02f, 1.48922028e-02f, -9.05925557e-02f, 8.10363889e-02f, 8.46341327e-02f, 2.84194648e-02f, 6.17503487e-02f,
  -8.46570432e-02f, 2.27127802e-02f, 1.97074413e-02f, 2.83242911e-02f, 2.28686091e-02f, 9.02898312e-02f, 6.65533468e-02f, -3.30478288e-02f, 4.50521559e-02f, -4.15000767e-02f,
  6.14096746e-02f, -1.59865096e-02f, 1.03494609e-02f, 4.89693973e-03f, -1.98605321e-02f, 4.10131887e-02f, -9.46776476e-03f, -3.07719316e-03f, 3.35337743e-02f, 1.90210566e-02f,
  -3.08165923e-02f, 1.04091279e-01f, -4.81810980e-02f, -6.81410059e-02f, 7.93485418e-02f, -3.84653285e-02f, -9.72897571e-04f, 1.09745003e-01f, -4.09753211e-02f, 1.13559313e-01f,
  -2.98944622e-01f, 8.97524133e-02f, -2.10539088e-01f, -5.80585189e-02f, -1.00450311e-02f, -1.54000940e-02f, -7.86536410e-02f, -9.41257477e-02f, -1.21714577e-01f, 8.38758517e-03f,
  5.43545522e-02f, -4.55381162e-02f, 3.10072489e-02f, -1.02129893e-03f, -1.60731435e-01f, -3.39767635e-02f, -5.71937226e-02f, -5.79207428e-02f, 5.90923009e-03f, 3.06482222e-02f,
  -6.70274571e-02f, -7.65232295e-02f, 7.82064423e-02f, -3.56360897e-02f, -4.26319912e-02f, -1.81196377e-01f, -5.72614260e-02f, -1.25123397e-01f, -1.05473600e-01f, -1.75380170e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.39615163e-01f, -5.24013452e-02f, -5.00264227e-01f, 1.61384031e-01f, 3.37792009e-01f, 1.14728130e-01f, 1.25937074e-01f, -1.58864930e-01f, 5.46797179e-02f, 6.20941296e-02f,
  1.63055211e-01f, 2.72640675e-01f, -1.59994904e-02f, 1.55009076e-01f, -1.11313507e-01f, -1.61099508e-02f, 5.72464094e-02f, -1.85170859e-01f, -7.48076513e-02f, 4.71906811e-02f,
  4.26584005e-01f, 9.09267887e-02f, -3.15962821e-01f, -1.70725048e-01f, 1.21437818e-01f, 8.56306031e-02f, -2.33246833e-01f, 3.32468227e-02f, 5.62416911e-02f, 2.70327687e-01f,
  -1.39636114e-01f, -1.82055995e-01f, -2.28869244e-02f, 1.83045059e-01f, 4.73084114e-02f, -7.98406638e-03f, -1.23305611e-01f, -2.42476463e-01f, -6.71241283e-02f, -8.83200839e-02f,
  5.55928461e-02f, 2.82583619e-03f, 2.37712190e-01f, 5.70186377e-02f, 1.69177819e-02f, -4.20394652e-02f, -1.49039760e-01f, -2.46881425e-01f, -2.65299261e-01f, -1.22575015e-01f,
  3.56088132e-01f, 1.08240537e-01f, -2.21890807e-01f, -5.58971018e-02f, -9.41677615e-02f, 4.83040977e-03f, -2.81009853e-01f, -1.94013610e-01f, -2.68238723e-01f, -2.27800101e-01f,
  -4.40298207e-02f, -1.38828056e-02f, 2.61769332e-02f, -6.09324127e-02f, -1.72376074e-02f, -6.31467998e-02f, 8.00943673e-02f, 9.26984251e-02f, 7.58686215e-02f, -6.43846020e-02f,
  -7.29953721e-02f, -2.19396483e-02f, -8.76113772e-02f, -9.20798406e-02f, -5.05224504e-02f, 2.94756535e-02f, 1.81736762e-03f, -1.38974279e-01f, -2.28298735e-02f, -1.90654602e-02f,
  -1.64714187e-01f, -5.43034030e-03f, -8.83865952e-02f, 5.25009781e-02f, -5.91276884e-02f, -1.13254771e-01f, -3.81282717e-02f, -1.10390119e-01f, -1.48067117e-01f, 9.44850594e-03f,
  -2.40333050e-01f, -3.72153558e-02f, -3.18603292e-02f, -6.86466843e-02f, -5.90087427e-03f, -6.05321713e-02f, -2.29555462e-02f, 2.73838080e-02f, -4.70052622e-02f, 3.17858420e-02f,
  -2.88321376e-02f, 2.19020806e-02f, -1.46339759e-01f, -7.70393237e-02f, 1.26047388e-01f, 1.29934391e-02f, 3.17908302e-02f, 7.88600072e-02f, -1.32943645e-01f, 7.19848275e-02f,
  2.13329047e-02f, -8.86033326e-02f, -1.34919226e-01f, -1.22362621e-01f, 7.22844899e-02f, -7.41022751e-02f, -1.12622596e-01f, -1.67113245e-01f, -2.28745461e-01f, -3.02663147e-01f,
  1.29464358e-01f, 2.38269404e-01f, -7.20335916e-02f, 1.70236275e-01f, 3.07122529e-01f, 1.53835058e-01f, 1.53738573e-01f, -1.18856147e-01f, -1.41488433e-01f, -3.11682448e-02f,
  5.03717102e-02f, 3.60503905e-02f, 1.12834141e-01f, 7.21494928e-02f, -1.00241015e-02f, -1.14133224e-01f, -3.16915996e-02f, -1.62937492e-01f, -1.31946310e-01f, -3.80721651e-02f,
  8.96119997e-02f, -1.05004124e-02f, -2.05916479e-01f, -1.62919313e-01f, 7.47674480e-02f, 6.82294485e-04f, -1.36469215e-01f, 4.55525555e-02f, 1.22727044e-01f, 6.25129268e-02f,
  1.42119065e-01f, 1.74251229e-01f, 8.48319009e-02f, 1.06444936e-02f, 4.90615144e-02f, -1.97921202e-01f, -1.27069205e-02f, -5.19376583e-02f, -2.49115806e-02f, -1.64955482e-01f,
  -4.78432216e-02f, -8.76060501e-02f, 9.56904742e-08f, 2.10261419e-02f, -1.16841428e-01f, -7.06345355e-03f, -1.08050399e-01f, -1.36731163e-01f, -1.77389812e-02f, 1.44296363e-01f,
  2.04241410e-01f, -1.48504041e-02f, 6.83376379e-03f, -7.70030916e-02f, 3.57045457e-02f, 1.36617169e-01f, 1.18475240e-02f, 2.71497238e-02f, -6.34762347e-02f, -1.15470767e-01f,
  8.80163014e-02f, -1.22786924e-01f, -1.64882958e-01f, -2.99435891e-02f, 7.16969147e-02f, 1.42292559e-01f, 5.90749979e-02f, -3.32428627e-02f, -1.10763155e-01f, -1.75012406e-02f,
  3.72477807e-02f, 1.33472562e-01f, 1.39138907e-01f, -9.86118838e-02f, 4.20844816e-02f, 2.50076324e-01f, 1.41860042e-02f, 1.60898287e-02f, 1.83825195e-01f, 8.40993226e-02f,
  6.41703699e-03f, -5.37631996e-02f, -1.30117256e-02f, 4.79303254e-03f, 5.13146929e-02f, 1.83196664e-01f, 3.00469436e-02f, 8.32152218e-02f, 8.63151401e-02f, 1.00206949e-01f,
  -1.64427027e-01f, 3.22592258e-01f, 1.81807548e-01f, 4.00195718e-02f, 3.76504846e-02f, 1.25807449e-01f, 1.06725849e-01f, 2.44090751e-01f, 2.67644882e-01f, -4.21534888e-02f,
  -3.28811705e-02f, 5.19238040e-02f, 8.23127478e-02f, -1.40528843e-01f, -1.44593015e-01f, -6.80651516e-02f, 1.05182320e-01f, 1.11982904e-01f, 1.02388196e-01f, 4.70561758e-02f,
  9.35024843e-02f, -2.03906536e-01f, -7.58159384e-02f, 4.62433025e-02f, 2.04180125e-02f, 2.25463450e-01f, 3.76555286e-02f, 6.24653734e-02f, -3.31846848e-02f, -2.02382714e-01f,
  6.26416862e-01f, 3.19773793e-01f, 4.57442701e-01f, 3.76228750e-01f, 2.73633868e-01f, 4.45957065e-01f, 4.32336509e-01f, 2.53497630e-01f, -3.74798896e-03f, 1.61111712e-01f,
  1.94589496e-01f, 5.30047007e-02f, -2.11982545e-03f, 1.62060950e-02f, 2.51475185e-01f, 1.48735210e-01f, -3.81640829e-02f, 1.67841222e-02f, 1.93450719e-01f, 1.98658913e-01f,
  -3.93670499e-02f, 4.33272198e-02f, -1.67629085e-02f, -6.99270889e-02f, 1.55850835e-02f, 4.09935787e-03f, 4.40590680e-02f, 1.62614822e-01f, 1.42706037e-01f, -1.29642591e-01f,
  1.08287141e-01f, 3.78277838e-01f, -6.71565011e-02f, -9.88453850e-02f, 3.82603221e-02f, -1.83668137e-01f, 2.47012898e-02f, -7.67605305e-02f, -2.31571477e-02f, -7.45144933e-02f,
  -4.27293889e-02f, -4.30392437e-02f, -2.20963191e-02f, -8.80070850e-02f, -3.72030586e-02f, 4.54317592e-02f, -3.94486487e-02f, 1.59569815e-01f, 8.76044109e-02f, 5.07390276e-02f,
  1.50930837e-01f, 1.87509209e-01f, 1.40558213e-01f, 2.42162608e-02f, 1.51698738e-01f, 4.05546278e-02f, 1.24303952e-01f, -1.75141431e-02f, 1.36272073e-01f, -1.04502045e-01f,
  1.27814755e-01f, -3.37768048e-02f, -9.64455903e-02f, -3.61550860e-02f, 3.17972228e-02f, -1.57941561e-02f, 2.33635660e-02f, -5.57817407e-02f, 5.79976328e-02f, -6.34877011e-02f,
  -3.64905670e-02f, 2.14113146e-01f, 6.48448244e-02f, -7.85343423e-02f, 1.24568259e-02f, 8.09523910e-02f, -6.42643869e-03f, 8.76567736e-02f, 5.06199040e-02f, -3.51209454e-02f,
  1.53002575e-01f, -2.17176508e-02f, -1.02235466e-01f, -4.83542904e-02f, 6.98137144e-03f, 8.48377198e-02f, -1.18134841e-02f, -6.16038442e-02f, -1.21089078e-01f, 3.91902626e-02f,
  -2.24215269e-01f, 2.95089781e-01f, 4.85300682e-02f, -4.46495563e-02f, -1.31834820e-01f, -2.76200920e-02f, 5.02055697e-02f, -5.49404882e-02f, -3.49978581e-02f, -1.09495901e-01f,
  8.27471167e-02f, -6.59111068e-02f, 8.60367715e-02f, 1.81788467e-02f, -4.07886021e-02f, -7.62183666e-02f, -1.59316331e-01f, 9.04371887e-02f, 5.52159250e-02f, -1.25169605e-01f,
  -6.00368390e-03f, -1.85883537e-01f, 4.31418680e-02f, -1.27161492e-03f, 4.71047685e-03f, -7.14740902e-02f, -9.89458635e-02f, -6.90698773e-02f, -1.07498942e-02f, -2.60739714e-01f,
  -5.23528397e-01f, -2.33680502e-01f, -3.12987685e-01f, -3.53180319e-01f, -2.56702393e-01f, -7.50195980e-02f, -2.45030522e-01f, -5.85002592e-04f, -1.22215874e-01f, -4.41881686e-01f,
  -1.17592901e-01f, 1.67310461e-01f, -7.04298243e-02f, 1.37189627e-01f, 1.41079631e-02f, -5.17011166e-01f, -3.95307690e-01f, -1.59052759e-01f, 1.55301720e-01f, 7.42725134e-02f,
  2.59324703e-02f, -1.33238629e-01f, 1.60582680e-02f, 1.46696374e-01f, -2.15403587e-01f, -4.30474728e-02f, -1.99310750e-01f, -1.15226105e-01f, 9.70165506e-02f, -3.67948830e-01f,
  5.13626337e-02f, -1.45325698e-02f, 1.47772521e-01f, -3.02807260e-02f, -1.72411442e-01f, -3.10506076e-02f, -5.09598851e-02f, -2.04382613e-02f, -2.61644796e-02f, -9.10042375e-02f,
  -1.01380564e-01f, 4.14861459e-03f, 3.83402072e-02f, -4.56061121e-03f, -1.82107463e-02f, -6.50996063e-03f, -5.89138567e-02f, -7.55587518e-02f, -1.16833322e-01f, -4.30909432e-02f,
  1.90061986e-01f, -9.85037684e-02f, 4.40438092e-02f, 2.47678533e-01f, 1.68467671e-01f, 5.03244624e-02f, 1.87375829e-01f, 2.02066526e-01f, 9.89485011e-02f, 1.49662197e-01f,
  -2.39227712e-03f, 8.27204362e-02f, 2.89299954e-02f, 1.26897454e-01f, -1.08662829e-01f, -2.52722502e-02f, -1.59787070e-02f, 6.38968721e-02f, 1.04951866e-01f, 7.22442493e-02f,
  2.39613336e-02f, -5.91422915e-02f, 2.29848158e-02f, -9.50394850e-03f, -1.41510991e-02f, -4.78520803e-02f, -1.90230571e-02f, 1.01937182e-01f, 8.61817878e-03f, -1.34804830e-01f,
  -1.31320651e-03f, -2.69366167e-02f, -7.34288916e-02f, 1.54825494e-01f, -6.59150109e-02f, -5.00268042e-02f, -9.17109009e-03f, 5.26014157e-02f, 3.36715430e-02f, -9.78070125e-02f,
  1.70267880e-01f, -1.12724453e-01f, -8.40233043e-02f, 1.49460673e-01f, -1.03007644e-01f, -1.56472698e-02f, -4.77941595e-02f, -1.68032069e-02f, -8.05072486e-02f, -1.16341472e-01f,
  8.51767808e-02f, 1.78816039e-02f, 1.10559098e-01f, 7.80032426e-02f, 5.49712591e-02f, 4.91855666e-02f, -8.12387615e-02f, 1.03674047e-01f, -5.37262075e-02f, -3.42759714e-02f,
  1.27520189e-01f, -6.67109191e-02f, 8.30480177e-03f, 1.72990292e-01f, 1.43647432e-01f, 3.49818803e-02f, 1.15017407e-01f, 2.03293368e-01f, 1.74260452e-01f, -2.45569665e-02f,
  4.15206216e-02f, -1.77080736e-01f, -4.08893913e-01f, 1.29111513e-01f, -2.83834964e-01f, -1.94126397e-01f, -5.32736361e-01f, 1.02471501e-01f, 2.97637105e-01f, -2.43296921e-01f,
  -6.88739643e-02f, 1.54453799e-01f, 5.43873683e-02f, 9.86123756e-02f, -6.24322928e-02f, -3.97195935e-01f, -2.73587227e-01f, -1.86210096e-01f, -8.28278810e-02f, -6.39542192e-02f,
  -4.68890890e-02f, -2.82028895e-02f, 3.06829298e-03f, 1.36838660e-01f, -1.94334611e-01f, -2.34868765e-01f, -4.03207719e-01f, -2.29393467e-01f, -3.31908494e-01f, -5.13924360e-01f,
  -2.53193587e-01f, -1.38265491e-01f, 2.15350036e-02f, 7.66640007e-02f, -6.53017089e-02f, 7.97352493e-02f, -5.13532981e-02f, 1.13561645e-01f, 1.00708492e-01f, 1.44999459e-01f,
  2.39755437e-02f, 1.17255554e-01f, 1.35926411e-01f, -3.47243622e-02f, -8.25666264e-02f, -4.27456945e-02f, 1.71647817e-01f, 2.76266709e-02f, 8.36042613e-02f, -1.76834073e-02f,
  7.00483620e-02f, -1.73913818e-02f, -6.44441396e-02f, -3.14157195e-02f, 9.98299047e-02f, -1.76227707e-02f, 1.74544065e-03f, -1.88234262e-02f, -1.00436307e-01f, -2.16441393e-01f,
  7.48354243e-03f, -3.98547016e-02f, -1.34497881e-01f, 8.23301449e-03f, 9.89816636e-02f, 7.82128610e-03f, -5.00771217e-02f, 3.90432240e-03f, 5.57077341e-02f, -5.97771257e-03f,
  -7.33875763e-03f, -8.81011877e-03f, 6.26662895e-02f, -9.71904024e-02f, -4.13699597e-02f, -5.52547798e-02f, -7.67710507e-02f, -8.05895403e-02f, 6.11603260e-02f, 3.69362608e-02f,
  8.95587951e-02f, 3.55518088e-02f, 1.46823749e-02f, 7.65542015e-02f, 3.14563550e-02f, 1.17248716e-02f, -9.32695940e-02f, 5.37179112e-02f, 6.87553808e-02f, 1.40696093e-01f,
  2.16762006e-01f, -2.19557062e-01f, 7.51043558e-02f, 1.48633897e-01f, 8.49368796e-03f, 3.15934457e-02f, 2.72564217e-02f, 5.86080663e-02f, -1.15740988e-02f, -1.19641004e-02f,
  6.21680021e-02f, -1.41506195e-02f, 3.06757223e-02f, 2.39918865e-02f, 4.37310971e-02f, 1.83803048e-02f, 1.00174196e-01f, -1.38908243e-02f, 1.60110533e-01f, 6.39686882e-02f,
  6.35732487e-02f, 2.38217726e-01f, 9.66367424e-02f, -2.16955389e-03f, 8.88695270e-02f, 6.84482278e-04f, -8.20104629e-02f, 6.45512938e-02f, -7.83237368e-02f, -6.20313622e-02f,
  -4.11928236e-01f, -5.59273846e-02f, -4.70932454e-01f, 1.23732321e-01f, 2.54964113e-01f, 3.25113833e-01f, 2.88902879e-01f, 1.14124209e-01f, 1.24460533e-01f, -3.28608565e-02f,
  -6.81390837e-02f, -1.51798250e-02f, 7.34250918e-02f, 1.13874741e-01f, 5.72783612e-02f, 1.92551285e-01f, 3.44333082e-01f, -8.58798772e-02f, -2.49605685e-01f, 7.36450404e-02f,
  2.73809940e-01f, -4.25307117e-02f, -3.41923952e-01f, -1.54598162e-01f, 7.10276961e-02f, 8.61606151e-02f, -6.19395152e-02f, -8.96532089e-02f, 3.33557022e-03f, 1.54927656e-01f,
  -4.27155435e-01f, -5.42260110e-01f, 2.83230413e-02f, -1.29484981e-01f, -2.04998970e-01f, -4.24031019e-02f, -1.09609753e-01f, -2.05542743e-01f, -5.77037334e-02f, -2.98723094e-02f,
  -3.60782770e-03f, -5.88133521e-02f, 3.76773030e-02f, -8.47331211e-02f, -1.19686686e-02f, -6.04872219e-02f, -1.19351007e-01f, -2.29329988e-01f, -2.75729954e-01f, -1.23968929e-01f,
  2.65834063e-01f, -1.39001936e-01f, -1.91427395e-01f, 7.89576247e-02f, 3.98861393e-02f, -1.73462749e-01f, -1.30326509e-01f, -1.47107974e-01f, -2.36283749e-01f, 5.48724458e-02f,
  3.93335000e-02f, 2.35297754e-02f, 6.13524765e-02f, 1.16277836e-01f, 7.55111873e-02f, 1.06142864e-01f, 1.83083338e-03f, 9.40516815e-02f, 5.72101697e-02f, 2.71590613e-02f,
  4.96338755e-02f, -1.90860108e-02f, -9.68324766e-03f, 8.54791924e-02f, -1.88012794e-02f, -1.15916200e-01f, -2.12880578e-02f, 5.02185337e-02f, -6.71631843e-02f, 1.31361214e-02f,
  2.83561535e-02f, -2.24237870e-02f, 4.67788242e-02f, 7.62969032e-02f, 3.60640474e-02f, 3.87838893e-02f, -3.29366997e-02f, -5.42133339e-02f, -8.01522285e-02f, -9.15916711e-02f,
  2.64424663e-02f, -2.00859770e-01f, 5.15017882e-02f, -2.67691687e-02f, -1.36597469e-01f, 7.16469577e-03f, 6.32540360e-02f, 3.26070562e-02f, -4.07099202e-02f, -4.67472039e-02f,
  -1.61051646e-01f, -4.43200022e-02f, 1.83592755e-02f, -3.56762931e-02f, 5.16678803e-02f, -1.16805602e-02f, 2.44770907e-02f, 1.68617621e-01f, 5.89842983e-02f, -5.14299572e-02f,
  1.49290532e-01f, 2.46090040e-01f, 1.46835178e-01f, 6.07378073e-02f, 9.62586254e-02f, 8.77202526e-02f, 2.13426072e-02f, 1.88674733e-01f, -8.42955038e-02f, 2.35040754e-01f,
  -9.49327201e-02f, 6.35557771e-02f, -1.67600468e-01f, 1.49251029e-01f, 9.09578577e-02f, -3.37184697e-01f, -4.04642105e-01f, -3.45052063e-01f, 3.13483514e-02f, 2.03853901e-02f,
  -1.32956132e-01f, 1.05297454e-01f, 1.39162928e-01f, 1.78555414e-01f, -3.47644389e-02f, 1.56287968e-01f, 3.41988146e-01f, 3.02530020e-01f, 2.73999255e-02f, 7.77963549e-02f,
  3.37024510e-01f, 2.58534253e-01f, 8.72907564e-02f, 1.11784935e-01f, 2.29679048e-01f, 1.01943307e-01f, -1.18830092e-01f, 1.37032464e-01f, 1.18092597e-01f, 6.34483457e-01f,
  -4.27679047e-02f, -8.83332361e-03f, 5.30697890e-02f, 1.52221382e-01f, 4.45836447e-02f, 5.85788209e-03f, 2.65500750e-02f, -4.69174050e-03f, 2.98742130e-02f, 5.05999699e-02f,
  1.41822234e-01f, -1.36765894e-02f, 6.84810653e-02f, 3.65844853e-02f, 6.21913448e-02f, -1.93129703e-01f, -5.22385314e-02f, -4.86482345e-02f, 2.17672009e-02f, -6.67000040e-02f,
  1.65448248e-01f, 9.89601482e-03f, -4.46389429e-02f, -2.36616209e-01f, -1.86746836e-01f, 2.13083476e-02f, -1.39995202e-01f, 2.61795949e-02f, -2.69171506e-01f, 1.44310936e-01f,
  5.83048835e-02f, 3.90852019e-02f, -8.93638097e-03f, 5.05609885e-02f, 1.30863726e-01f, 1.25222638e-01f, 1.24485530e-01f, -9.05885547e-02f, 9.21875145e-03f, 1.07294425e-01f,
  -1.64269209e-02f, 1.19035043e-01f, -1.99060757e-02f, -4.57570478e-02f, -2.98250560e-02f, 8.77680928e-02f, 1.19441800e-01f, 5.34667708e-02f, -1.30641609e-01f, -8.84083807e-02f,
  -2.35064942e-02f, 1.54883098e-02f, 9.33877379e-02f, 3.36236246e-02f, 1.67175476e-02f, 7.60200322e-02f, 1.11049131e-01f, -6.49004132e-02f, -5.29854372e-02f, 1.19793676e-02f,
  6.30569756e-02f, -6.23822119e-03f, 1.71875119e-01f, -1.45379733e-02f, -2.75213514e-02f, -5.03655933e-02f, 3.73538397e-02f, -1.10755675e-01f, 3.73157598e-02f, -2.06529558e-01f,
  3.21078859e-02f, -1.22778952e-01f, -1.24800391e-02f, -8.61479566e-02f, 7.12141097e-02f, -1.10662557e-01f, 9.07074511e-02f, 7.41060972e-02f, -1.09197170e-01f, 6.31353073e-03f,
  1.11205038e-02f, -2.77212083e-01f, -1.21346474e-01f, -1.65418014e-01f, 3.00791431e-02f, -4.30298559e-02f, -1.36829957e-01f, -4.31846194e-02f, -2.80268341e-01f, -2.29770795e-01f,
  7.95669973e-01f, -1.17091589e-01f, 6.60195649e-02f, 1.56608764e-02f, -2.29203254e-01f, -1.69967581e-02f, -1.91941969e-02f, 8.89796615e-02f, 1.67008284e-02f, -3.92653830e-02f,
  -1.50754884e-01f, -9.91741493e-02f, -8.74680206e-02f, -1.32781059e-01f, 1.07489020e-01f, -4.91525829e-02f, -1.95625886e-01f, 7.86082894e-02f, 1.11171678e-01f, 6.78283628e-03f,
  -7.60493428e-02f, -7.34631047e-02f, 1.57123834e-01f, 8.15161765e-02f, -1.23878732e-01f, -1.47836193e-01f, -1.15297176e-01f, -1.98830381e-01f, -1.73058316e-01f, -1.29341319e-01f,
  1.54884994e-01f, 2.18221396e-01f, 9.85125676e-02f, 5.12604751e-02f, 5.93554713e-02f, 1.98164344e-01f, 2.17786089e-01f, 8.37748591e-03f, 1.56809404e-01f, 1.05489068e-01f,
  1.06693313e-01f, -7.21217692e-02f, -4.07163501e-02f, 1.52919099e-01f, 1.16363540e-01f, 8.72670263e-02f, 1.56436674e-02f, 2.76998077e-02f, 1.17419669e-02f, -5.76970074e-03f,
  -1.01666942e-01f, -5.22126034e-02f, -1.46321818e-01f, -4.12788620e-04f, 3.72462869e-02f, 4.90653925e-02f, -2.08365498e-03f, 5.57310767e-02f, 8.53879750e-03f, 9.43803117e-02f,
  -4.59318794e-02f, 6.38244906e-03f, -1.31586701e-01f, 4.73421514e-02f, 2.81766318e-02f, -1.12770274e-01f, -5.19415326e-02f, 1.17537230e-01f, 8.74033421e-02f, 3.73429470e-02f,
  -1.20474577e-01f, 1.05735473e-01f, 1.93078455e-03f, 4.48029786e-02f, -4.34297323e-02f, -1.40177876e-01f, 7.30776638e-02f, 1.04975924e-02f, -3.04608699e-02f, -7.88283646e-02f,
  -5.86498752e-02f, -4.99134399e-02f, -8.07616040e-02f, -1.16311476e-01f, -1.37957066e-01f, -3.48809138e-02f, -2.05540601e-02f, 1.79919694e-02f, -1.56813189e-01f, -2.20738828e-01f,
  -4.16804897e-03f, -6.35256916e-02f, 9.63458866e-02f, -1.02130219e-01f, 2.24002488e-02f, 6.14503585e-02f, -5.12464158e-03f, -6.87000901e-02f, -8.52260888e-02f, -3.58520518e-03f,
  8.91435798e-03f, -3.42528671e-02f, 5.18906340e-02f, 2.69985348e-02f, 1.21165730e-01f, 8.09051171e-02f, 3.10274139e-02f, 5.59066460e-02f, -8.04579481e-02f, -3.40511295e-04f,
  -5.41912504e-02f, 4.44597043e-02f, 8.86010528e-02f, 2.42544425e-04f, 7.49052987e-02f, -7.17835873e-02f, -8.58025178e-02f, -1.11126518e-02f, 5.75404577e-02f, 1.60934761e-01f,
  4.14727151e-01f, -3.33575249e-01f, -3.59028757e-01f, 1.11351214e-01f, -2.12588772e-01f, 5.00722751e-02f, -2.77970582e-01f, 1.18825056e-01f, 1.60267711e-01f, -2.51997411e-01f,
  8.43248442e-02f, 3.47728580e-01f, 2.27739289e-01f, 4.60700840e-02f, 2.74828076e-01f, -4.13950741e-01f, -2.89968252e-01f, -8.36916417e-02f, 2.92605370e-01f, 1.30136997e-01f,
  3.52779999e-02f, 3.29400897e-02f, 2.65859127e-01f, 2.04158738e-01f, -2.05772683e-01f, -1.00858640e-02f, -3.50369781e-01f, -1.07199304e-01f, -1.76714137e-01f, -5.75710297e-01f,
  -2.75433153e-01f, 7.72159547e-02f, 7.35547692e-02f, 7.62856007e-02f, -5.80563284e-02f, 1.40066430e-01f, 2.69820746e-02f, -3.43885049e-02f, 8.78097862e-02f, -5.31852767e-02f,
  5.60220741e-02f, 9.60601196e-02f, 1.11162111e-01f, -8.98672715e-02f, 2.66131349e-02f, -7.32781515e-02f, -3.59476916e-02f, 2.79124454e-03f, 1.43659934e-02f, -7.75118470e-02f,
  -4.49935719e-02f, 3.90293598e-02f, -1.53341265e-02f, 2.59366892e-02f, -7.83083681e-03f, 2.13418622e-03f, -1.23219587e-01f, -1.03234828e-01f, -1.70811221e-01f, -2.92775124e-01f,
  -1.77161619e-02f, -5.65712713e-02f, -7.00428570e-03f, 1.71161797e-02f, 1.21280737e-01f, 9.34671890e-03f, -9.74963605e-03f, 3.09639075e-03f, -4.74378392e-02f, -6.23191297e-02f,
  3.49249467e-02f, -2.62336489e-02f, -2.86738873e-02f, -6.31000803e-05f, -6.33062646e-02f, 5.18587753e-02f, -4.76551093e-02f, -9.18076411e-02f, 1.48911830e-02f, -4.04324681e-02f,
  3.51976268e-02f, 5.93364239e-03f, -7.51816258e-02f, -9.35029704e-03f, 1.39774820e-02f, 3.11519555e-03f, -1.05227251e-03f, 6.34463653e-02f, 1.01332478e-02f, -3.67415906e-03f,
  1.25434577e-01f, 2.80190438e-01f, -7.01388195e-02f, 2.50451416e-02f, -1.06679223e-01f, -3.22390068e-03f, -1.11739196e-01f, -5.25646284e-02f, 2.74423975e-02f, 3.89414504e-02f,
  -2.42481604e-02f, -1.29328817e-02f, -1.10837176e-01f, -6.90566897e-02f, -2.61155851e-02f, 5.99901043e-02f, -1.11743482e-03f, -2.18391791e-02f, 8.45931470e-02f, -4.92078625e-02f,
  -1.02334619e-01f, -1.43833701e-02f, 1.17688425e-01f, 7.11860210e-02f, -1.31426507e-03f, 1.84602797e-01f, -3.94296423e-02f, -4.95429970e-02f, 1.21374793e-01f, -1.27320021e-01f,
  -3.74842167e-01f, -2.82131165e-01f, -3.40534359e-01f, -1.71284094e-01f, 1.83720514e-01f, 2.63223588e-01f, 5.18668406e-02f, 1.18066512e-01f, 2.16754302e-01f, -1.47150531e-01f,
  1.29622057e-01f, 3.44245613e-01f, 7.57642686e-02f, 1.40721276e-01f, 4.72677983e-02f, -1.93501949e-01f, -2.33543202e-01f, -8.94910097e-02f, 4.04891670e-01f, 4.30461049e-01f,
  4.61479515e-01f, 2.01574340e-01f, 9.86503065e-02f, 2.39286274e-01f, -2.27424085e-01f, 8.62493142e-02f, -2.45525941e-01f, -1.88408151e-01f, 4.20885198e-02f, -4.72358137e-01f,
  -2.56787568e-01f, -7.19024688e-02f, -1.59886088e-02f, 1.32770747e-01f, -1.64984852e-01f, -9.49383974e-02f, -2.02567786e-01f, -1.60522804e-01f, -1.32510625e-02f, 2.69448222e-03f,
  -1.68150738e-01f, 8.32611024e-02f, -1.23572327e-01f, 1.47427082e-01f, -5.58799272e-03f, 3.34361047e-02f, 4.38673906e-02f, -1.56073973e-01f, -1.49910808e-01f, 1.22219389e-02f,
  -5.05072102e-02f, 2.92303730e-02f, -3.17131400e-01f, 7.88057894e-02f, -1.72572657e-01f, -1.55853882e-01f, -7.33501762e-02f, -3.28391016e-01f, -1.99642539e-01f, -4.58541393e-01f,
  9.05311108e-03f, -3.59928980e-02f, -4.94341040e-03f, -3.61819528e-02f, -4.62951325e-02f, 2.23994106e-02f, -7.36950710e-02f, 5.48791364e-02f, 1.40454248e-01f, -1.23557523e-02f,
  9.39294323e-02f, 1.51974708e-01f, 1.05647817e-01f, -2.72471402e-02f, 3.52226235e-02f, 8.29871446e-02f, -4.23875488e-02f, 1.14371255e-01f, -4.06607129e-02f, -5.86557165e-02f,
  6.86083883e-02f, -2.26296335e-02f, -4.46863063e-02f, 6.62997141e-02f, -6.12423681e-02f, -2.16471385e-02f, 8.58261734e-02f, 6.80538565e-02f, 6.47554323e-02f, 1.41911447e-01f,
  1.03593551e-01f, 1.97674558e-01f, -1.14000782e-01f, 6.19049370e-02f, -1.01476654e-01f, 4.77068536e-02f, -2.86374073e-02f, 5.55466488e-02f, -1.27514601e-01f, 1.00461897e-02f,
  -7.55598024e-02f, -5.16639203e-02f, -8.53583664e-02f, -1.68392882e-01f, 2.05400004e-03f, 1.68127388e-01f, -1.11524411e-01f, -3.60902734e-02f, 5.01895249e-02f, 7.73998275e-02f,
  -1.41680196e-01f, 2.21112929e-02f, -1.82477519e-01f, -2.08402246e-01f, 6.58238977e-02f, -1.53814387e-02f, 3.59509103e-02f, -2.46131808e-01f, -8.58082203e-04f, -6.78294152e-02f,
  7.71660388e-01f, -5.62538862e-01f, 1.86946660e-01f, 2.86968887e-01f, 2.40243301e-01f, 3.74145210e-01f, 1.53354198e-01f, -3.29463603e-03f, 2.00980678e-01f, -6.20975420e-02f,
  -2.09567267e-02f, 1.70017436e-01f, 1.48099810e-01f, 9.54014733e-02f, 1.39114574e-01f, -1.15526719e-02f, 6.70376420e-02f, 1.74849361e-01f, 4.31910038e-01f, 1.42498136e-01f,
  -1.03928529e-01f, -2.24438041e-01f, -2.43178252e-02f, -1.14775769e-01f, -2.00271070e-01f, 6.06005825e-02f, -2.11785391e-01f, -2.34693184e-01f, -1.77857429e-01f, -3.88080984e-01f,
  1.96273759e-01f, -1.84737533e-01f, 2.66318530e-01f, -1.70027912e-01f, -8.09549987e-02f, -1.00422002e-01f, 9.63007361e-02f, -1.25332192e-01f, -1.19587563e-01f, -7.47134760e-02f,
  -9.93233845e-02f, -7.92120546e-02f, -1.48103805e-02f, -1.80356905e-01f, -1.31840795e-01f, 2.38655880e-02f, -1.74855247e-01f, 6.46317669e-04f, -9.41857249e-02f, -3.98120657e-03f,
  -1.19976342e-01f, 3.75529267e-02f, 6.27760366e-02f, 1.07030466e-01f, 1.20000809e-01f, 6.27836883e-02f, 4.16601961e-03f, -1.00146877e-02f, -4.61681634e-02f, 1.92603818e-03f,
  3.54672819e-02f, 1.38673306e-01f, -6.17803149e-02f, -4.10116790e-03f, 2.79029310e-02f, 8.02251175e-02f, 8.84694755e-02f, -2.73549724e-02f, 1.20399892e-01f, -9.46996808e-02f,
  5.91194034e-02f, 3.36736348e-03f, -3.25322859e-02f, 8.25038105e-02f, -6.18210807e-02f, -1.12939728e-02f, 4.41466756e-02f, -7.85956606e-02f, 5.46279810e-02f, 7.49483481e-02f,
  1.20102175e-01f, 5.00931777e-03f, -7.71425739e-02f, -1.28907308e-01f, -1.08794440e-02f, 7.24071115e-02f, 3.50797214e-02f, -6.35902509e-02f, -2.75606252e-02f, -2.68724449e-02f,
  -1.65120214e-01f, 1.95852846e-01f, 2.62085199e-01f, -1.86168067e-02f, -1.18994407e-01f, -7.12949485e-02f, 8.43460709e-02f, -1.71714246e-01f, -1.18122667e-01f, 8.94309673e-03f,
  1.08499788e-02f, 8.97644088e-02f, 3.93075962e-03f, -1.14483863e-01f, 1.21550299e-01f, 5.22303730e-02f, -3.59960720e-02f, 1.22232631e-01f, -2.40911637e-02f, -8.59590396e-02f,
  4.66378918e-03f, 1.67683885e-01f, 3.04068536e-01f, 1.77261144e-01f, 9.89427716e-02f, 3.48091990e-01f, 1.03039198e-01f, -2.87876837e-02f, 4.75318506e-02f, 1.53968455e-02f,
  -5.47893584e-01f, -1.02066927e-01f, 9.55921933e-02f, -3.35977525e-01f, 1.12541005e-01f, 2.95750070e-02f, 1.94177791e-01f, -5.40235639e-02f, -9.84888896e-02f, 1.48396224e-01f,
  4.34517637e-02f, -2.63731759e-02f, 6.19789921e-02f, 1.54623061e-01f, -4.25077453e-02f, 1.90652281e-01f, 3.46149951e-01f, -3.94405760e-02f, -1.82077721e-01f, -1.62088871e-01f,
  1.17069162e-01f, -5.87551743e-02f, -2.76208043e-01f, -1.72110051e-01f, -7.13290498e-02f, -8.05903450e-02f, 1.38004899e-01f, -1.24950536e-01f, -1.10302335e-02f, 1.90563723e-01f,
  -1.06821647e-02f, -2.06636339e-01f, 1.10056035e-01f, -9.78674516e-02f, 2.83299666e-02f, 1.68631095e-02f, -3.81330540e-03f, -8.69686529e-02f, -7.11553767e-02f, -6.01877980e-02f,
  -9.38106552e-02f, 4.37014662e-02f, -6.62127361e-02f, 7.59202838e-02f, -2.16670826e-01f, -1.07765295e-01f, 5.32456674e-02f, 8.83410219e-03f, -3.72217037e-02f, 3.09174061e-02f,
  1.42369315e-01f, -4.07663472e-02f, -4.29526493e-02f, 1.03026994e-01f, -6.09216429e-02f, 1.34359911e-01f, -8.01899806e-02f, -3.73428576e-02f, -6.10887669e-02f, 1.04072608e-01f,
  5.12482338e-02f, -3.09196161e-03f, 4.76507172e-02f, 9.81166512e-02f, 1.02469392e-01f, 3.12086120e-02f, -3.04268897e-02f, 9.47101682e-04f, 6.09934889e-03f, -7.85791874e-02f,
  4.62078053e-04f, 3.85102583e-04f, 3.77472527e-02f, 3.76359909e-03f, -2.32761446e-02f, -1.42918230e-04f, 8.13391467e-04f, 1.54213258e-03f, 6.57571256e-02f, -3.60167772e-02f,
  -9.95192528e-02f, -5.45957796e-02f, 1.05070569e-01f, -5.53819425e-02f, 1.08936414e-01f, -6.02454357e-02f, -6.28572330e-02f, 3.28717865e-02f, -4.72516045e-02f, 1.37890158e-02f,
  -5.73476218e-02f, 3.32828939e-01f, 2.67454199e-02f, 1.13511443e-01f, -1.13712631e-01f, -6.64811283e-02f, -1.15525946e-01f, -7.88275301e-02f, -1.96442813e-01f, -7.66212195e-02f,
  -1.03127696e-01f, -1.99310314e-02f, 3.20113525e-02f, 2.94795167e-02f, -2.41013113e-02f, 2.25131623e-02f, 1.39147177e-01f, -4.75263186e-02f, 9.31571722e-02f, -1.27032757e-01f,
  3.59423421e-02f, 1.41075179e-01f, -5.30025288e-02f, 9.26815718e-03f, -4.90998812e-02f, 1.05597246e-02f, -4.79489425e-03f, -1.15026236e-01f, -4.50571962e-02f, 8.21410045e-02f,
  -4.32982773e-01f, 2.41425517e-03f, 1.01725020e-01f, 9.00381133e-02f, 2.95183212e-01f, 8.24110657e-02f, -2.50196874e-01f, -2.09821120e-01f, 1.15745790e-01f, -2.48329751e-02f,
  1.58969238e-01f, 6.63588941e-02f, -1.42472133e-01f, -2.43163079e-01f, -5.40527165e-01f, -2.35856324e-01f, -1.08789809e-01f, -2.01660991e-01f, -3.16341221e-01f, -6.84885234e-02f,
  -4.31363136e-02f, -2.17985436e-01f, -3.33792239e-01f, -1.06665418e-01f, -6.07188530e-02f, -7.56578967e-02f, -7.51467943e-02f, -1.84904486e-01f, -9.91163328e-02f, -8.81632194e-02f,
  -9.37643796e-02f, -4.33833152e-02f, 9.88187566e-02f, -3.00509930e-01f, -1.88061036e-02f, 8.99055786e-03f, 1.35047466e-01f, -9.77447703e-02f, 2.13706940e-01f, 3.99271995e-02f,
  6.93485439e-02f, 2.66034812e-01f, -1.06403999e-01f, -4.32740338e-02f, -8.33670124e-02f, -1.07506253e-01f, -8.79759062e-03f, -4.70360331e-02f, -1.44514978e-01f, 3.40520479e-02f,
  -4.94548604e-02f, 1.09565713e-01f, -2.08456486e-01f, -2.56483167e-01f, -1.36424586e-01f, -2.42352840e-02f, -7.53818974e-02f, -1.00715086e-01f, -2.68002123e-01f, -1.89013988e-01f,
  3.64568457e-02f, 1.43193692e-01f, 2.41123233e-02f, 9.32061821e-02f, -2.79914439e-02f, 9.18898284e-02f, 7.54475147e-02f, -5.33312000e-02f, 6.87767342e-02f, 1.42598394e-02f,
  1.39047131e-01f, -6.80229887e-02f, 1.81256831e-02f, 3.75424549e-02f, -1.61011264e-01f, -6.44756109e-02f, -8.48435909e-02f, -2.75828362e-01f, -2.06840217e-01f, 4.18524332e-02f,
  -1.08313039e-01f, 1.42270833e-01f, 9.11159441e-02f, -2.91598178e-02f, -4.04851362e-02f, -1.46361321e-01f, 7.77173117e-02f, -1.64427459e-01f, -1.87722333e-02f, -4.74917069e-02f,
  -1.76699907e-01f, -7.58781731e-02f, 2.40156129e-02f, -2.44931206e-01f, -2.33235694e-02f, 6.84199929e-02f, 1.20864607e-01f, -1.49180964e-01f, 3.60368267e-02f, -6.50127158e-02f,
  -5.31171709e-02f, -2.27631360e-01f, 1.75608378e-02f, -6.46013254e-03f, -3.06406096e-02f, -1.72346145e-01f, -7.72408769e-02f, -1.81906611e-01f, -4.04320322e-02f, 7.56482333e-02f,
  -3.01293850e-01f, -2.36274749e-01f, -3.27530175e-01f, -2.35144600e-01f, 4.29972447e-02f, -1.88656837e-01f, -2.78338253e-01f, -1.93054959e-01f, -3.21769595e-01f, -5.97578108e-01f,
  -1.10951352e+00f, -1.89729422e-01f, 2.49052271e-01f, -3.93642277e-01f, 1.10567175e-01f, 2.62221664e-01f, 4.11287099e-01f, 1.16547883e-01f, -1.73221976e-01f, -3.28190066e-02f,
  -1.36680201e-01f, -1.07277073e-01f, -2.04323530e-01f, -3.92935351e-02f, -2.85803974e-02f, 2.82424271e-01f, 3.16108286e-01f, 7.58357570e-02f, 4.37392220e-02f, 1.45636693e-01f,
  1.43404514e-01f, -2.15229869e-01f, -3.47002864e-01f, -2.12114617e-01f, -5.13031296e-02f, 1.12085864e-02f, 5.70262931e-02f, -1.29908800e-01f, 2.20148973e-02f, 2.53863279e-02f,
  3.17340463e-01f, -1.31488487e-01f, 2.20631454e-02f, -2.37263039e-01f, -6.15748167e-02f, -6.96406811e-02f, 6.77778199e-02f, -9.24792588e-02f, -7.09279627e-02f, 8.53754207e-03f,
  2.60879323e-02f, 3.61139737e-02f, -1.42323419e-01f, -5.95063083e-02f, 5.37323803e-02f, -1.95002817e-02f, -6.07385375e-02f, -1.02466360e-01f, -3.53644565e-02f, 9.29062739e-02f,
  -2.97924764e-02f, -1.20293744e-01f, 8.81839395e-02f, 3.28627191e-02f, -5.09206988e-02f, -7.16107190e-02f, -2.13713129e-03f, -1.15447931e-01f, -4.41694930e-02f, -2.30080970e-02f,
  1.22383699e-01f, 8.23061466e-02f, 2.82756910e-02f, 1.07112741e-02f, -9.65719074e-02f, -3.89369093e-02f, -6.46174476e-02f, 6.50373176e-02f, 7.81282783e-02f, -3.88583094e-02f,
  -5.27769774e-02f, 3.51699330e-02f, 2.80653238e-02f, -5.06640375e-02f, -5.01367971e-02f, 3.88558884e-03f, -8.71780515e-02f, -3.69332880e-02f, -5.77085577e-02f, -1.77095518e-01f,
  -3.45366262e-02f, -4.73205820e-02f, 4.17742021e-02f, -2.30938159e-02f, -2.57736002e-03f, -1.16946086e-01f, 1.16493851e-02f, -7.72001445e-02f, 2.90759164e-03f, 6.67749494e-02f,
  3.46961945e-01f, -1.60700530e-01f, 1.28764600e-01f, -1.18645243e-02f, -1.95799284e-02f, 3.45166884e-02f, 2.90089706e-03f, 2.02319305e-02f, 6.46708384e-02f, 1.05696775e-01f,
  1.14858672e-02f, 4.50084917e-02f, -9.44597498e-02f, 1.34855747e-01f, 1.20474011e-01f, 9.80024636e-02f, -2.88705807e-02f, -2.40951814e-02f, 7.06764013e-02f, 1.84943184e-01f,
  7.38897324e-02f, 9.64791849e-02f, 2.17126474e-01f, 1.61406472e-01f, 1.27407864e-01f, 1.43156558e-01f, 2.74029225e-01f, 1.76545814e-01f, 1.14363410e-01f, 9.46636349e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.01253884e-02f, 2.02966377e-01f, 8.19132254e-02f, 5.98296300e-02f, 7.14721754e-02f, 2.24638477e-01f, -1.29432023e-01f, -9.20887515e-02f, 8.13331269e-03f, 2.76438445e-01f,
  1.95325837e-01f, 2.84322411e-01f, 3.34587336e-01f, 2.42795542e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.20533654e-01f, -5.05336449e-02f, 1.57634571e-01f, -2.46475684e-03f, -3.75472941e-02f, -5.30466549e-02f, -6.72159940e-02f, 1.29852399e-01f, -6.28399774e-02f, 5.32525964e-02f,
  9.83864069e-02f, 8.07616189e-02f, 1.23574317e-01f, -3.18799280e-02f, -2.71369249e-01f, 2.96746999e-01f, 2.80123860e-01f, 1.87456474e-01f, 7.97440037e-02f, 9.60549936e-02f,
  -2.95794997e-02f, -7.00429678e-02f, 2.95858502e-01f, -2.54341215e-01f, -1.34867236e-01f, -5.62433228e-02f, 4.27331507e-01f, 9.94376317e-02f, -9.05127078e-02f, -6.10412434e-02f,
  7.15302229e-02f, -1.65053889e-01f, 6.85850456e-02f, -4.01345454e-02f, 3.33571597e-03f, 7.13033155e-02f, 3.94577608e-02f, 1.76107660e-01f, 2.08214641e-01f, 1.85239449e-01f,
  1.28471464e-01f, -1.15281522e-01f, 7.20482245e-02f, 9.82577633e-03f, 2.10350841e-01f, 1.19688421e-01f, 2.15059936e-01f, -3.19057032e-02f, -4.48557250e-02f, -2.54957050e-01f,
  2.74166644e-01f, 1.35516956e-01f, 7.42026954e-04f, -2.02793002e-01f, -3.77749763e-02f, 1.55225191e-02f, 1.46987990e-01f, 2.36465499e-01f, 8.84831250e-02f, -2.40096101e-03f,
  9.86882076e-02f, -2.08783120e-01f, -3.57295200e-02f, -8.62552151e-02f, -1.27121970e-01f, 1.28401160e-01f, -6.44553676e-02f, -4.88893203e-02f, -1.58709716e-02f, 1.09328143e-01f,
  -1.36942610e-01f, 3.04507501e-02f, -1.50549456e-01f, -4.93976139e-02f, 2.20943838e-02f, -1.38374180e-01f, 4.73905243e-02f, 2.83829011e-02f, -1.77390128e-01f, 3.70992795e-02f,
  2.79677007e-02f, 2.32849032e-01f, 9.51670334e-02f, -6.10583350e-02f, 1.68283641e-01f, -1.40808538e-01f, -1.02941722e-01f, 2.85958767e-01f, -8.12341273e-03f, 3.47214215e-03f,
  -6.66479096e-02f, 7.43824840e-02f, -3.59383345e-01f, 2.32968211e-01f, 2.24966571e-01f, -1.96753711e-01f, 2.79689193e-01f, -1.37294054e-01f, 2.76594549e-01f, -2.26824626e-01f,
  -2.90517479e-01f, -2.74841219e-01f, -3.16024199e-02f, -1.09024785e-01f, -1.35305658e-01f, 1.59582004e-01f, -3.53579447e-02f, -1.71288818e-01f, 2.75283922e-02f, -7.64395967e-02f,
  -2.15743765e-01f, 3.78961638e-02f, 1.57541528e-01f, 4.11520571e-01f, 8.62619802e-02f, 2.12878093e-01f, 3.32842208e-02f, 1.45728141e-01f, 2.21758842e-01f, 1.61044881e-01f,
  -3.56539905e-01f, 3.05591244e-02f, 1.90609619e-02f, -8.42321962e-02f, 3.66072766e-02f, -1.50258750e-01f, 3.26803982e-01f, -1.24381967e-01f, 1.61242142e-01f, -1.20272562e-01f,
  2.15566069e-01f, 9.32130869e-03f, 3.11500784e-02f, -1.63722143e-01f, 2.52574775e-02f, 1.24958485e-01f, -7.23017976e-02f, 9.45151318e-03f, 2.75242418e-01f, -5.71333393e-02f,
  2.33590856e-01f, -1.98488981e-01f, -1.37303352e-01f, 5.15688770e-02f, 7.68214464e-02f, -2.63506353e-01f, -5.93895055e-02f, -6.15344755e-02f, 2.04942942e-01f, 1.55855760e-01f,
  -2.36998256e-02f, -5.41473329e-01f, -1.92384254e-02f, 1.40933737e-01f, 4.29368734e-01f, -1.83487255e-02f, 1.00134060e-01f, -3.35644603e-01f, 7.00549185e-02f, -3.33796412e-01f,
  3.20685469e-02f, 3.41417119e-02f, -3.50370072e-02f, -1.30843341e-01f, 2.24627301e-01f, -6.88518211e-02f, 1.56021705e-02f, -1.28260642e-01f, -6.17104620e-02f, -1.43153086e-01f,
  2.72935512e-03f, 2.98649758e-01f, -3.57102230e-02f, -6.33251145e-02f, -5.33492193e-02f, 5.20479726e-03f, 1.51423454e-01f, 1.48067549e-01f, -1.48428842e-01f, -1.89261381e-02f,
  -3.50002982e-02f, -8.88196602e-02f, -9.99958590e-02f, -2.66076952e-01f, -1.37777822e-02f, 1.44666387e-02f, -1.54281542e-01f, -1.48230657e-01f, -2.34976172e-01f, -1.25074852e-02f,
  3.30156982e-01f, -2.60021746e-01f, 1.05509505e-01f, -4.69084941e-02f, 7.31473640e-02f, 8.39792565e-02f, -7.36202393e-03f, 1.00238256e-01f, -6.91563040e-02f, -1.78547502e-01f,
  -7.64872357e-02f, -1.37413323e-01f, 6.21002400e-03f, 1.35766581e-01f, 1.95070595e-01f, -9.49249640e-02f, -8.91526118e-02f, -5.35843894e-02f, 1.51972786e-01f, -1.26420124e-03f,
  7.85721764e-02f, 1.88857570e-01f, 1.50590986e-01f, 6.65316824e-03f, -1.00927562e-01f, -5.43422461e-01f, -1.30299181e-01f, -1.27321422e-01f, 2.52634197e-01f, -2.25920320e-01f,
  1.76467851e-01f, -3.01641434e-01f, -1.17196463e-01f, -1.14012152e-01f, -1.59726143e-01f, -1.42552210e-02f, -1.95342824e-02f, -2.05663964e-02f, 5.48069850e-02f, -1.01657912e-01f,
  6.18819259e-02f, 8.00505504e-02f, -3.52684632e-02f, 9.42026228e-02f, 2.87304875e-02f, -3.69585901e-02f, -9.04181693e-03f, -3.51230018e-02f, -7.20803365e-02f, -5.13854995e-02f,
  -1.65482000e-01f, -9.39733014e-02f, -1.90087304e-01f, 3.56910601e-02f, 7.71790519e-02f, -2.41746493e-02f, 7.85828847e-03f, -2.29048267e-01f, -1.61849648e-01f, -1.51185647e-01f,
  3.22565317e-01f, -6.33964762e-02f, 5.04904687e-02f, -1.47378087e-01f, -1.80861488e-01f, -2.32363239e-01f, 2.02117804e-02f, -2.09507734e-01f, -9.16452520e-03f, 2.50234976e-02f,
  -1.99584901e-01f, -1.50496840e-01f, -4.38181087e-02f, -3.85217816e-02f, -1.09582052e-01f, -5.86489066e-02f, 1.82005629e-01f, -2.66413204e-02f, -3.65157947e-02f, -1.82066485e-01f,
  -1.19715288e-01f, 1.45591021e-01f, -6.36747032e-02f, 9.27946940e-02f, -8.95800740e-02f, -1.65301248e-01f, -1.58612743e-01f, 1.66948736e-01f, 2.78420806e-01f, -3.44260663e-01f,
  6.65551201e-02f, -3.06622218e-02f, 4.17017430e-01f, 1.23303823e-01f, 1.87993050e-02f, -2.76314348e-01f, 7.81102711e-03f, -2.42114663e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -5.38720824e-02f, 6.50458857e-02f, 8.22281167e-02f, 2.17342615e-01f, -7.29871541e-02f, 1.85394689e-01f, 9.24656540e-02f, 2.57870883e-01f, 3.69852334e-01f, -1.20991781e-01f,
  4.31581922e-02f, 2.40253925e-01f, -1.73751131e-01f, -1.02360830e-01f, 1.37800621e-02f, 2.88726777e-01f, 3.13009739e-01f, -2.07337618e-01f, 2.03344002e-01f, -9.23870951e-02f,
  -1.00612268e-01f, 2.27355391e-01f, -8.67185891e-02f, -1.32462215e-02f, 2.79787481e-01f, -2.09639817e-01f, -1.69471741e-01f, 3.14258277e-01f, -2.43551493e-01f, 4.88069236e-01f,
  3.20462763e-01f, 4.66926336e-01f, 1.93094775e-01f, -6.65457994e-02f, 1.60891324e-01f, 2.31276713e-02f, 4.77508176e-03f, -1.77560687e-01f, 6.28047138e-02f, 6.68430105e-02f,
  -1.82327613e-01f, -3.84854488e-02f, 2.16795266e-01f, 6.62079081e-02f, -1.51054844e-01f, -6.62376210e-02f, 9.44413897e-03f, -7.78449401e-02f, 1.08184248e-01f, 1.72292769e-01f,
  2.34384701e-01f, 1.70121834e-01f, 3.57758313e-01f, 9.92589351e-03f, 1.10978790e-01f, -1.58190608e-01f, -3.54285359e-01f, -6.18319586e-02f, 5.61125241e-02f, 8.55732039e-02f,
  8.25495049e-02f, -3.23835909e-01f, 5.25146961e-01f, 2.90809982e-02f, -9.97294560e-02f, 4.32964385e-01f, 4.78544161e-02f, 1.40268892e-01f, 7.14686871e-01f, 2.53560394e-01f,
  4.38430279e-01f, -2.89618690e-02f, 4.29873317e-02f, 1.72299892e-01f, 5.04349992e-02f, -2.66275972e-01f, 3.69517982e-01f, 3.06755990e-01f, 4.07309383e-01f, -4.84638929e-01f,
  -6.00070655e-01f, -5.21835648e-02f, -6.39596879e-02f, 5.12140058e-02f, 2.32196927e-01f, 6.18414208e-02f, 3.08406770e-01f, 1.66312277e-01f, -1.90029427e-01f, -1.45446971e-01f,
  -2.48424727e-02f, 1.26017362e-01f, -4.27161485e-01f, -5.22411764e-02f, 4.47252780e-01f, -4.14392114e-01f, 1.54210329e-01f, 2.87857801e-02f, -1.25619799e-01f, 4.65624593e-02f,
  8.49742070e-02f, 1.72727689e-01f, 4.57589477e-02f, 5.02592418e-03f, 2.52551675e-01f, -2.80609161e-01f, -1.73295081e-01f, 2.39273794e-02f, 1.14039958e-01f, 2.84291685e-01f,
  1.06261574e-01f, -2.34265611e-01f, -4.60685492e-01f, 2.27612838e-01f, 1.36489183e-01f, -4.58043488e-03f, 1.41215354e-01f, -4.18406665e-01f, -4.96430546e-01f, 2.16429159e-01f,
  1.41457036e-01f, -9.73635390e-02f, -5.87289274e-01f, -3.61920625e-01f, 3.46737623e-01f, -4.30849135e-01f, -4.83841002e-02f, 2.51640230e-01f, 2.42149249e-01f, 1.53281853e-01f,
  -3.30480263e-02f, 1.22776464e-01f, -2.48174980e-01f, -1.25676200e-01f, 9.96288657e-02f, 2.36697555e-01f, 1.72447264e-01f, -2.75763333e-01f, 2.26485640e-01f, 1.44158885e-01f,
  -1.09924516e-02f, 2.38853827e-01f, -3.64686316e-03f, -2.64477938e-01f, 3.57048102e-02f, 5.07161558e-01f, 3.23839635e-01f, 1.60242185e-01f, -1.69851899e-01f, 1.41076744e-01f,
  -1.64099917e-01f, 2.22389698e-01f, 7.65513107e-02f, -1.94626361e-01f, -1.74568594e-01f, -1.91513766e-02f, -1.74117923e-01f, 1.74621284e-01f, 1.53742760e-01f, 2.04835460e-01f,
  1.28708676e-01f, 1.20912462e-01f, -2.70936824e-02f, 1.73759133e-01f, 2.42535040e-01f, 3.30840021e-01f, 3.70539665e-01f, -1.16063610e-01f, 2.03620479e-01f, 3.65562648e-01f,
  3.56661417e-02f, -1.65400967e-01f, -6.94189891e-02f, -1.63023323e-01f, -3.42547357e-01f, -1.54377624e-01f, 2.33181119e-02f, -1.24519788e-01f, -4.41695563e-02f, -5.84769156e-03f,
  -5.73308766e-01f, 4.11638290e-01f, 1.94698736e-01f, 4.18487228e-02f, -2.31073335e-01f, -6.03045188e-02f, 1.13839850e-01f, 4.38191056e-01f, -2.63184220e-01f, -7.89047256e-02f,
  1.24738842e-01f, 7.85980723e-04f, 2.23867014e-01f, -7.99391344e-02f, -1.09141707e-01f, -9.63662118e-02f, 4.39052582e-01f, 2.71864265e-01f, 5.94103709e-02f, -8.33590701e-02f,
  1.74470954e-02f, 4.27921623e-01f, 2.81719774e-01f, -1.40042320e-01f, 1.26953870e-01f, -2.35564187e-01f, 2.40466088e-01f, 1.03967369e-01f, 1.01384625e-01f, -5.52162528e-01f,
  2.75437254e-02f, -1.24876752e-01f, -3.46498132e-01f, 2.63333023e-01f, 2.68452764e-01f, 8.35159793e-02f, -4.35863808e-03f, 7.86447227e-02f, 3.99284571e-01f, -3.87172848e-02f,
  -2.42283076e-01f, -1.20291650e-01f, 1.10328488e-01f, -3.04567039e-01f, -2.13221222e-01f, 2.16787770e-01f, -6.70488626e-02f, 3.48349154e-01f, -1.13801420e-01f, 2.31475458e-01f,
  2.86191314e-01f, 3.14223379e-01f, 3.71501185e-02f, -3.38345349e-01f, 2.77614266e-01f, 4.53848928e-01f, -3.39224100e-01f, -3.30647320e-01f, -2.70459533e-01f, 2.17980966e-01f,
  2.94996738e-01f, 1.98458345e-03f, -2.58601159e-01f, 2.35331714e-01f, -3.77966106e-01f, -1.18134566e-01f, -3.59745063e-02f, -4.54099804e-01f, -1.34865614e-03f, -4.08693343e-01f,
  -2.51899719e-01f, 4.36802693e-02f, -2.96422765e-02f, 3.82389218e-01f, 1.79165274e-01f, -1.99642196e-01f, 3.46219838e-01f, 1.37910500e-01f, 4.69513722e-02f, -4.07963134e-02f,
  8.91750455e-02f, 7.84654915e-02f, 1.73163652e-01f, 1.86646841e-02f, 1.68310046e-01f, 2.92982727e-01f, -2.10260689e-01f, -8.14796016e-02f, 2.39219144e-01f, 4.49060909e-02f,
  -2.94713657e-02f, 1.90745279e-01f, 1.49969429e-01f, -2.85876781e-01f, 7.04538822e-02f, -6.78589195e-02f, 1.50337160e-01f, 2.12103441e-01f, 1.25878364e-01f, 2.38589942e-01f,
  -7.44285733e-02f, -1.25248590e-02f, 4.76464510e-01f, 1.64742813e-01f, 5.26703179e-01f, -1.45727724e-01f, 3.54452096e-02f, -1.90964714e-01f, 4.77235258e-01f, 4.34679016e-02f,
  1.62112057e-01f, -6.46988302e-02f, -3.23971659e-01f, -1.07959755e-01f, 2.05370918e-01f, 6.74853325e-02f, -4.29099007e-03f, -4.45792302e-02f, -6.99501336e-02f, 1.49907619e-01f,
  -1.49087965e-01f, 3.44712168e-01f, -4.81663018e-01f, -2.53832132e-01f, 4.65346545e-01f, 1.89525917e-01f, 4.63456780e-01f, 1.40091628e-01f, -1.99245676e-01f, -7.63766393e-02f,
  9.00173709e-02f, 3.64624828e-01f, 2.29323611e-01f, -3.35656852e-01f, -7.33659565e-02f, 2.31777340e-01f, -1.43765032e-01f, 2.10668549e-01f, 2.25768715e-01f, -1.60456821e-02f,
  3.29552948e-01f, 1.18067466e-01f, 8.40676278e-02f, -8.48706290e-02f, 5.02602577e-01f, 1.01055942e-01f, 3.71528864e-02f, 1.14992484e-01f, -1.44480079e-01f, 1.84983969e-01f,
  1.93413086e-02f, -1.13577835e-01f, 4.49677818e-02f, -1.66755006e-01f, 5.46978377e-02f, -2.72680700e-01f, 5.62722906e-02f, -3.64254229e-02f, 2.02570945e-01f, 1.09373040e-01f,
  5.56860352e-03f, -3.39766708e-03f, 3.29409957e-01f, 3.61024439e-01f, 2.40489081e-01f, -8.83908570e-03f, 4.68136258e-02f, -3.80123332e-02f, -9.47315097e-02f, -3.71428765e-02f,
  1.45778209e-01f, -3.77288193e-01f, -3.89230773e-02f, 8.52383226e-02f, 3.74897197e-02f, 1.05126709e-01f, -2.63945311e-01f, -8.31170604e-02f, -5.36031239e-02f, 2.31277019e-01f,
  1.07604042e-01f, 6.90290704e-02f, -1.53524756e-01f, 7.83271641e-02f, -2.00492084e-01f, 7.55974501e-02f, -3.72422487e-01f, 2.31328830e-02f, 3.91996264e-01f, 3.55089694e-01f,
  1.79646805e-01f, 2.16950804e-01f, -3.32239956e-01f, 1.99707404e-01f, -1.47063404e-01f, 2.08646178e-01f, 1.90842241e-01f, -3.23586494e-01f, 1.06916914e-03f, 1.19086713e-01f,
  -1.03745759e-01f, 3.90552968e-01f, 3.63557786e-02f, 1.79547280e-01f, 3.11560601e-01f, -2.16348484e-01f, 3.06085587e-01f, 1.06673509e-01f, 7.11953714e-02f, 6.18772060e-02f,
  -9.75872669e-03f, 1.56910241e-01f, -2.06869617e-01f, 1.86702341e-01f, 1.87508404e-01f, -1.60892636e-01f, 2.40617022e-01f, -2.51998693e-01f, 1.65574953e-01f, -1.30140960e-01f,
  1.91129178e-01f, -5.12472317e-02f, 2.20421642e-01f, -3.98966111e-02f, 2.02858627e-01f, 2.01671366e-02f, 1.29852101e-01f, 1.94758669e-01f, -2.15797976e-01f, -1.23304557e-02f,
  4.18499053e-01f, 2.38010734e-01f, 1.95963100e-01f, -2.78874606e-01f, -5.01234978e-02f, -6.79545403e-01f, 2.23820016e-01f, 2.40597561e-01f, 6.31317794e-02f, 1.17802486e-01f,
  2.74928868e-01f, 4.78344172e-01f, 3.28336537e-01f, -1.01704426e-01f, 1.18209124e-01f, 6.83154389e-02f, -5.48259355e-02f, -3.14922124e-01f, 3.06977630e-01f, -2.23083422e-01f,
  1.94325328e-01f, 3.40001047e-01f, -8.53799582e-02f, -7.45873928e-01f, 7.69982487e-02f, -4.36469495e-01f, -3.04850161e-01f, 2.81089216e-01f, 4.71499488e-02f, 1.20153509e-01f,
  -4.72678095e-01f, -8.68116505e-03f, 5.40075600e-01f, 4.86135781e-01f, 3.99261743e-01f, 1.19633228e-01f, 9.07668620e-02f, 1.13920987e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  4.25499380e-01f, -2.63970420e-02f, 3.59569252e-01f, 3.55030954e-01f, 1.23325042e-01f, 2.58597881e-01f, 2.96921253e-01f, 2.21944675e-01f, 2.85681686e-03f, 2.14052051e-02f,
  1.05302781e-02f, 1.67473957e-01f, 4.83721718e-02f, 2.41917446e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  3.00905585e-01f, 2.63462383e-02f, -1.28874779e-01f, 9.32230055e-02f, 6.61227629e-02f, 3.21658760e-01f, 3.41564156e-02f, -1.90262608e-02f, -2.96953656e-02f, 5.78879900e-02f,
  -4.30984318e-01f, -1.66820511e-01f, -7.09329918e-02f, -1.13714375e-02f, -2.84109771e-01f, -9.12921801e-02f, -8.14337563e-03f, -1.91997573e-01f, 2.16214523e-01f, -2.21807972e-01f,
  -1.53843418e-01f, -2.47089624e-01f, 9.17016715e-02f, 1.13474675e-01f, 1.24673638e-02f, 4.47509103e-02f, -2.33359665e-01f, 7.62678385e-02f, -2.03952074e-01f, 2.02940419e-01f,
  -1.87261999e-01f, -1.67226315e-01f, 1.08626984e-01f, 1.76078856e-01f, 3.36301655e-01f, -2.19366401e-02f, 1.69404104e-01f, -3.67369056e-02f, -2.05085322e-01f, 1.20463863e-01f,
  3.96658957e-01f, 3.44200462e-01f, 2.82017104e-02f, 1.49358198e-01f, 3.06410521e-01f, 9.40793678e-02f, 4.98584718e-01f, -6.50594160e-02f, -3.06873977e-01f, 2.32516676e-01f,
  -5.20572066e-02f, 1.39277905e-01f, 3.66337240e-01f, -2.02435419e-01f, 1.53636843e-01f, -2.17255473e-01f, -1.65308997e-01f, 4.02391285e-01f, -1.82884514e-01f, -1.53502315e-01f,
  9.04692262e-02f, 8.99601951e-02f, -5.54096103e-02f, -2.55857438e-01f, 1.30668566e-01f, -2.07977323e-03f, -2.95558035e-01f, 3.65850091e-01f, -1.05282955e-01f, -2.16906115e-01f,
  -5.28271832e-02f, -1.73479930e-01f, 5.96527904e-02f, 3.04663271e-01f, -2.95313150e-01f, 1.38877168e-01f, 1.59438476e-01f, 2.35256821e-01f, 1.35361716e-01f, -4.32265162e-01f,
  3.21753711e-01f, 6.68472890e-03f, -4.68530841e-02f, 3.75897214e-02f, -2.70101819e-02f, -1.82713538e-01f, -2.18906641e-01f, 1.24857806e-01f, 2.46366054e-01f, -3.26567173e-01f,
  -2.72781886e-02f, 2.01291874e-01f, 1.16060659e-01f, -2.36808062e-01f, 2.70946115e-01f, 7.99777824e-03f, -6.79810941e-02f, -1.00891501e-01f, 4.10158128e-01f, -1.60796225e-01f,
  1.02246977e-01f, 4.00675982e-01f, -2.27437988e-01f, 1.01394810e-01f, -2.63306141e-01f, 1.74350604e-01f, 3.87629002e-01f, 4.41176355e-01f, -2.60428786e-01f, -7.48598576e-02f,
  3.15241814e-02f, 1.22928927e-02f, 9.89101976e-02f, -2.03672245e-01f, -1.25291375e-02f, -6.51030615e-02f, 3.90793979e-02f, -1.70137912e-01f, -8.11959356e-02f, -1.54298440e-01f,
  2.15977579e-02f, 1.71685815e-01f, -2.29995504e-01f, -2.11533517e-01f, 4.77375872e-02f, -1.10915393e-01f, 5.33427075e-02f, -2.24221185e-01f, 2.09147871e-01f, -4.78098877e-02f,
  -3.31165284e-01f, 5.51445857e-02f, 9.90260020e-02f, -2.78665364e-01f, -2.37922952e-01f, -7.33730868e-02f, 3.00848752e-01f, 1.42423138e-01f, -2.65770227e-01f, -8.47779289e-02f,
  4.36764121e-01f, 1.23446643e-01f, 1.48536146e-01f, 4.21958603e-02f, -1.43221855e-01f, 2.14613393e-01f, -2.50474811e-01f, 3.32129836e-01f, 3.38660151e-01f, -3.85967419e-02f,
  -2.98100173e-01f, 8.34920704e-02f, 2.68382996e-01f, -1.90494537e-01f, 4.35748138e-02f, -1.75974205e-01f, 2.20758080e-01f, -3.36818486e-01f, 2.63038367e-01f, -9.27684903e-02f,
  -2.70399898e-01f, -3.49621058e-01f, -7.80969784e-02f, 1.19609252e-01f, 9.98511165e-02f, -4.12859535e-03f, 2.50272185e-01f, -1.24559641e-01f, -2.71454334e-01f, -2.24058241e-01f,
  3.31960857e-01f, -9.66132432e-02f, -2.80128956e-01f, -8.67778435e-03f, 9.65708420e-02f, 1.32632002e-01f, -2.41888642e-01f, 1.24687552e-01f, 2.46735007e-01f, -6.62172586e-02f,
  -3.10901165e-01f, 3.48364681e-01f, 9.95259583e-02f, -9.43315029e-03f, -1.50354564e-01f, 4.97114798e-03f, -6.21832758e-02f, 2.27774918e-01f, -1.45980462e-01f, 2.12627858e-01f,
  -5.72202682e-01f, 2.51353830e-01f, 7.75168315e-02f, -4.18503247e-02f, -4.75094952e-02f, -3.17448437e-01f, -7.92200565e-02f, -2.54896492e-01f, -3.33973020e-01f, 2.32902709e-02f,
  -2.82066613e-01f, -4.75409776e-01f, -1.43007770e-01f, -8.81436914e-02f, 1.86205551e-01f, -7.94014707e-02f, -2.86207974e-01f, 2.43833423e-01f, -1.59539163e-01f, -3.60968292e-01f,
  6.17037565e-02f, -1.63324713e-03f, -7.26093054e-02f, 4.78576310e-02f, 2.17618123e-01f, -1.53364822e-01f, -4.22955573e-01f, -7.47396722e-02f, 1.64049894e-01f, 9.32203531e-02f,
  1.19812064e-01f, 9.48633775e-02f, -1.43528402e-01f, -2.85773575e-01f, -3.45130973e-02f, -2.38265451e-02f, -1.54440567e-01f, -1.77897274e-01f, 2.19349697e-01f, 2.62041413e-03f,
  2.95230478e-01f, -1.78887084e-01f, -1.25929430e-01f, -5.56681275e-01f, -1.17206275e-01f, -1.12930663e-01f, -4.37361866e-01f, -4.34528559e-01f, -2.07724005e-01f, -4.93501097e-01f,
  -3.79285306e-01f, -6.80135265e-02f, 3.31296504e-01f, -5.52995279e-02f, -7.00712055e-02f, 3.42010438e-01f, -2.18352944e-01f, 6.44589141e-02f, 8.50440562e-02f, 1.67459503e-01f,
  -1.78564489e-01f, -8.90399590e-02f, -5.12160249e-02f, -1.83184087e-01f, -4.05827641e-01f, 2.94056892e-01f, 1.20089211e-01f, 2.05446035e-01f, -1.15973890e-01f, -1.89910119e-03f,
  2.16011450e-01f, -2.00049430e-01f, -1.57920316e-01f, -8.74084532e-02f, 5.45349419e-01f, -2.14123443e-01f, 1.86145343e-02f, -2.53189147e-01f, -2.16376454e-01f, -1.47109345e-01f,
  -2.01903909e-01f, -1.97101161e-01f, 1.76121920e-01f, 7.36344419e-03f, -2.39948425e-02f, -2.89650321e-01f, 5.97859733e-03f, -2.31404621e-02f, -1.47136405e-01f, -3.49815898e-02f,
  1.56938776e-01f, -1.51469693e-01f, -4.37699407e-02f, -4.73781526e-01f, 1.14124887e-01f, -1.49792105e-01f, -1.77696005e-01f, 1.00847073e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  4.21905905e-01f, 1.27980828e-01f, 3.81342471e-01f, -3.42283621e-02f, 4.18596834e-01f, 3.06999803e-01f, 1.87147334e-01f, 1.63718671e-01f, 5.89116573e-01f, 4.20042038e-01f,
  3.64143282e-01f, 4.26869988e-01f, 2.28830561e-01f, -6.51987493e-02f, 5.15196621e-01f, 1.70509070e-01f, -1.45560190e-01f, -3.26763630e-01f, 3.85456264e-01f, 3.36167328e-02f,
  2.72055447e-01f, -2.87223160e-01f, 2.18539909e-01f, -3.22482400e-02f, 6.95201382e-02f, 5.42463720e-01f, -2.36086354e-01f, 3.53257746e-01f, 1.75956279e-01f, 1.40318975e-01f,
  6.70246929e-02f, -1.26467228e-01f, 2.46481538e-01f, 6.89634383e-02f, 2.97254443e-01f, 3.38536590e-01f, 1.04811728e-01f, 1.26112729e-01f, -9.65536386e-02f, 1.37774553e-02f,
  1.25422865e-01f, -4.95019928e-02f, 5.74821651e-01f, 3.73965837e-02f, -1.95332006e-01f, -3.00583273e-01f, -6.69423491e-02f, 5.19356318e-02f, -4.80658740e-01f, 3.02604563e-03f,
  1.56612262e-01f, -3.47494408e-02f, 2.39725426e-01f, 4.19368088e-01f, 4.09415483e-01f, -5.32589294e-02f, -1.37553617e-01f, -6.24395847e-01f, -1.53767809e-01f, 6.60345018e-01f,
  3.54001343e-01f, 2.64026880e-01f, 5.77424951e-02f, -6.53156221e-01f, 2.81812906e-01f, 1.52450696e-01f, 1.08902618e-01f, 3.78807873e-01f, 8.11988562e-02f, 4.23526578e-02f,
  -1.62850440e-01f, -1.35839134e-01f, -3.26487333e-01f, 1.83897391e-01f, 4.15955275e-01f, 1.87265333e-02f, -1.36595339e-01f, -3.88330370e-02f, 1.44852385e-01f, 5.12643158e-01f,
  -5.64216733e-01f, -2.12422878e-01f, 3.05200309e-01f, 8.64921063e-02f, 3.41584504e-01f, 6.93116561e-02f, 3.53468508e-01f, -2.84771055e-01f, -2.80336916e-01f, -2.14504778e-01f,
  -9.14096832e-02f, 7.34230578e-01f, 3.53092909e-01f, 4.99171436e-01f, 1.22437425e-01f, -4.89229977e-01f, 2.58610427e-01f, 1.91461995e-01f, -4.06591780e-02f, 3.25761855e-01f,
  2.40209118e-01f, -5.53999171e-02f, 1.54219791e-01f, 3.36194456e-01f, 1.60880223e-01f, -1.37711465e-01f, 5.26492238e-01f, 1.74648970e-01f, 9.99346655e-03f, 1.41850188e-01f,
  -4.62049454e-01f, 2.53021598e-01f, 2.66136616e-01f, -5.86773217e-01f, -1.31312624e-01f, 7.40010515e-02f, 2.57772207e-01f, 2.27752805e-01f, 3.85637224e-01f, -1.85592175e-01f,
  5.25544696e-02f, -3.26326936e-01f, 1.03750683e-01f, 1.24568790e-02f, 2.36324191e-01f, -2.24251464e-01f, 1.74637482e-01f, 1.42247900e-01f, 2.78355509e-01f, 2.06977338e-01f,
  -5.43932840e-02f, 3.99176955e-01f, -4.10474204e-02f, -3.30704868e-01f, 1.32970601e-01f, 3.68431866e-01f, -4.81686264e-01f, -2.06414983e-01f, 3.27599905e-02f, -3.14721137e-01f,
  -3.25362056e-01f, 3.71195406e-01f, -5.26240528e-01f, 6.37921035e-01f, -1.24344058e-01f, -3.29482317e-01f, 2.87987083e-01f, -2.56221563e-01f, -1.21528797e-01f, 1.02554388e-01f,
  -2.72553377e-02f, -1.07068509e-01f, 9.31356922e-02f, -3.37533951e-01f, 4.29445803e-01f, 2.51612872e-01f, -1.79208461e-02f, 1.90032065e-01f, 2.78866887e-01f, 3.86141211e-01f,
  4.06111658e-01f, 5.15006721e-01f, 2.75772303e-01f, 2.03048691e-01f, 3.10657710e-01f, 1.69096306e-01f, -3.18020023e-02f, 4.08719420e-01f, 4.03271556e-01f, -4.60350476e-02f,
  1.30773425e-01f, -1.53837547e-01f, -2.95784563e-01f, -3.61975469e-02f, -3.87798458e-01f, -6.80180714e-02f, 3.22155245e-02f, -2.29445264e-01f, -1.83926690e-02f, -2.40250573e-01f,
  2.84994572e-01f, -8.00182819e-02f, -1.68389365e-01f, 1.28835157e-01f, 9.35456455e-02f, 4.96258959e-02f, 1.83741108e-01f, -2.81850129e-01f, -3.12334690e-02f, -5.68354279e-02f,
  3.23324233e-01f, 2.34178588e-01f, 7.23698065e-02f, 1.86496619e-02f, 2.92430162e-01f, 8.80470499e-02f, -9.09927934e-02f, 2.20747478e-02f, 2.34293699e-01f, 2.87381053e-01f,
  2.06483945e-01f, 2.01559752e-01f, -4.71077293e-01f, -1.80266559e-01f, 2.02561721e-01f, -5.42678356e-01f, 1.42152989e-02f, -8.76801372e-01f, 9.69513878e-02f, 3.90414804e-01f,
  2.37929597e-01f, 2.11196929e-01f, 3.78661752e-01f, -1.39551401e-01f, 1.27541125e-01f, 5.56267619e-01f, 3.23408663e-01f, 1.42900482e-01f, 1.80376828e-01f, 7.91965052e-02f,
  2.34972253e-01f, 3.66186976e-01f, 2.31542781e-01f, 3.33994269e-01f, 2.58552074e-01f, -8.48379135e-02f, 1.88334316e-01f, -1.37226954e-01f, 1.96821168e-01f, 1.58097133e-01f,
  3.13145965e-02f, 4.00999457e-01f, -1.41196530e-02f, 3.11598152e-01f, -4.42811698e-01f, -1.40362993e-01f, -2.38697305e-02f, -5.48846185e-01f, 1.04679354e-01f, -3.60955179e-01f,
  -1.20605059e-01f, 2.52407044e-01f, 5.72372675e-01f, 1.79849751e-02f, 2.80660808e-01f, -5.73237836e-01f, 2.87995756e-01f, 5.67049146e-01f, 2.61078209e-01f, 4.87608105e-01f,
  2.65119761e-01f, 4.19203073e-01f, 4.76168701e-03f, 4.78258312e-01f, -1.20670330e-02f, 3.31252098e-01f, 3.41156811e-01f, 3.86363119e-01f, 2.38672376e-01f, 1.51121870e-01f,
  3.29772979e-01f, 5.69817007e-01f, 8.68860558e-02f, 3.61261755e-01f, 3.38051319e-01f, -1.71101481e-01f, 6.73837066e-01f, 2.07114920e-01f, -1.29996568e-01f, -1.65059432e-01f,
  -3.06181610e-01f, 3.02831549e-02f, -3.58447284e-01f, -4.33776647e-01f, -2.32496291e-01f, -1.96016580e-01f, 4.07514453e-01f, 1.29674166e-01f, 2.35307485e-01f, -2.31893420e-01f,
  -3.22427601e-01f, -2.66303569e-01f, 2.49382794e-01f, -1.91213012e-01f, 2.24561635e-02f, -1.81092083e-01f, -3.03755943e-02f, 6.56637102e-02f, 3.91624987e-01f, 2.71220684e-01f,
  -6.98809996e-02f, 2.77102590e-01f, 2.72363126e-01f, 2.08553106e-01f, 3.16546053e-01f, 2.54680961e-01f, 3.06107774e-02f, 1.30890394e-02f, 1.34155959e-01f, 1.36097431e-01f,
  -1.75124809e-01f, 3.29816639e-02f, -2.24774241e-01f, -1.24596179e-01f, 5.72073042e-01f, -4.01449621e-01f, -1.29824132e-01f, -3.01670488e-02f, 4.95836914e-01f, 3.19444388e-01f,
  -1.49212867e-01f, 1.32133573e-01f, 1.86399758e-01f, -3.16022158e-01f, 2.85369694e-01f, -2.53116697e-01f, 2.87418514e-01f, -1.32788554e-01f, 3.91306460e-01f, 3.04820567e-01f,
  7.32451901e-02f, 1.70257259e-02f, 1.35266572e-01f, 2.02165350e-01f, 1.35854091e-02f, -1.40902111e-02f, 5.84686361e-02f, -3.43497172e-02f, -2.88677961e-01f, 2.19299033e-01f,
  6.95278794e-02f, -9.74542201e-02f, 2.82481760e-02f, 3.95905077e-01f, -1.35186493e-01f, -2.44916916e-01f, 5.08953512e-01f, 1.87339231e-01f, -2.40042999e-01f, -1.40908025e-02f,
  3.16782355e-01f, -3.48506048e-02f, -2.74782300e-01f, 1.82746887e-01f, 4.26431388e-01f, -3.90686482e-01f, 2.33328268e-01f, 1.43371955e-01f, 4.14357483e-01f, -2.80493498e-01f,
  4.49194372e-01f, 2.87361771e-01f, 2.72740752e-01f, -2.77720243e-01f, 4.06411856e-01f, 8.56299326e-02f, 3.21285844e-01f, 3.30242127e-01f, 5.11113048e-01f, 6.73453286e-02f,
  3.60317588e-01f, -3.74331832e-01f, 3.06825101e-01f, -2.38605514e-01f, -5.16689718e-01f, -2.77106851e-01f, -1.87754352e-02f, -1.93371654e-01f, -6.45590127e-01f, -4.86026615e-01f,
  3.28871459e-01f, -1.78599834e-01f, 8.86784866e-02f, 1.48215853e-02f, 3.18633825e-01f, 2.51880556e-01f, -1.60140917e-01f, 3.54958802e-01f, -9.52282548e-02f, -1.51969030e-01f,
  -4.25932825e-01f, 3.19768399e-01f, -5.33940852e-01f, 2.93540299e-01f, 3.21511477e-01f, 3.92728180e-01f, 5.77822804e-01f, -1.83999121e-01f, 5.24515092e-01f, 4.52412575e-01f,
  -2.84333306e-04f, 3.78006250e-01f, 4.81320798e-01f, 3.35141048e-02f, 3.71893317e-01f, 4.40267891e-01f, -3.36309254e-01f, -1.00357004e-01f, 3.97727579e-01f, 1.01080172e-01f,
  1.16465360e-01f, -3.53235066e-01f, 1.84059694e-01f, -1.79115996e-01f, 6.05831265e-01f, -1.05086543e-01f, 2.98776589e-02f, -8.78799409e-02f, 7.26573309e-03f, 4.49823499e-01f,
  -2.90434837e-01f, -1.77615255e-01f, 1.77435458e-01f, -3.57845604e-01f, -1.92179233e-01f, -7.22892210e-02f, 2.48161837e-01f, 4.76336718e-01f, 2.20256597e-01f, -3.32303494e-02f,
  3.86781186e-01f, 2.30789557e-02f, -2.53690351e-02f, 2.52025872e-01f, 2.37647057e-01f, -4.04959857e-01f, 2.90481299e-01f, 8.12822282e-02f, -4.50866580e-01f, -1.91119999e-01f,
  -2.25768924e-01f, -3.27599078e-01f, -3.09883207e-01f, -2.68131554e-01f, 9.41144116e-03f, -6.02390409e-01f, 3.27743471e-01f, 5.98858446e-02f, 3.91102768e-02f, -7.17315823e-02f,
  -1.40103072e-01f, -2.26431191e-01f, -1.29881561e-01f, -2.59892464e-01f, -2.71933496e-01f, 1.14662554e-02f, -2.89928943e-01f, 3.92718464e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.40743911e-01f, 3.26017052e-01f, -1.55081302e-02f, 2.64755964e-01f, -5.12496792e-02f, 3.03802043e-01f, 1.65574610e-01f, 2.06917658e-01f, 3.01994979e-01f, 3.90977800e-01f,
  1.72160938e-01f, 2.81503826e-01f, 3.11814323e-02f, 1.61930099e-01f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  5.45377731e-02f, -1.34038091e-01f, -3.34972948e-01f, -3.68286401e-01f, -3.78758758e-01f, -4.56292808e-01f, 5.68640716e-02f, -5.50805092e-01f, 5.81233092e-02f, 2.83774048e-01f,
  5.52849889e-01f, -1.66785181e-01f, 4.36185151e-01f, -3.70936126e-01f, -4.04289290e-02f, -2.93823361e-01f, 7.93959275e-02f, 4.04758215e-01f, 1.74921602e-01f, -1.22771777e-01f,
  -1.94084886e-02f, 1.13288477e-01f, -1.46842137e-01f, 7.09073320e-02f, -9.19721201e-02f, 6.65867887e-03f, 1.69762135e-01f, -1.68786794e-01f, -2.09306806e-01f, 2.06520826e-01f,
  1.19088061e-01f, -4.86910008e-02f, -2.40216911e-01f, 1.75186217e-01f, -9.00607035e-02f, 9.75171030e-02f, -1.02930859e-01f, 2.34490305e-01f, 1.70725629e-01f, 1.34082362e-01f,
  1.14846028e-01f, -3.08311909e-01f, -1.94749364e-03f, 4.01940912e-01f, -2.18628839e-01f, 1.38985202e-01f, 1.46101207e-01f, -1.04480907e-01f, -8.61843228e-02f, 3.58408689e-02f,
  7.74586871e-02f, -1.80107281e-01f, -1.78806618e-01f, 3.08263805e-02f, -3.24924439e-02f, -2.69244593e-02f, 4.02582511e-02f, -3.31306875e-01f, 3.10369790e-01f, 1.72732368e-01f,
  1.84027284e-01f, 7.33341798e-02f, -9.93685052e-03f, 2.40015954e-01f, -3.84675026e-01f, -1.14651971e-01f, 2.63912976e-01f, -6.07768595e-02f, -2.58329306e-02f, -9.36757028e-03f,
  2.30707839e-01f, 6.28951341e-02f, -1.43195510e-01f, 2.98715115e-01f, -3.36319089e-01f, 7.49685690e-02f, -1.67792067e-01f, 4.53254193e-01f, -2.84709036e-01f, -5.06342471e-01f,
  3.14829163e-02f, 7.11140633e-02f, -1.60871908e-01f, 5.13211936e-02f, 3.90394479e-02f, -1.82267353e-01f, -9.86616164e-02f, 1.33897468e-01f, 1.42678306e-01f, 2.35884383e-01f,
  -1.57992214e-01f, 2.03357525e-02f, 1.53291106e-01f, -6.59196600e-02f, -3.02788883e-01f, 1.11335501e-01f, -1.30499050e-01f, 1.87201515e-01f, 4.67744097e-02f, -1.06585689e-01f,
  -1.60350755e-01f, 1.47421628e-01f, -1.86166808e-01f, 4.52832654e-02f, -4.23920602e-01f, 6.07276797e-01f, 3.67637217e-01f, -1.22855663e-01f, 2.44553372e-01f, 7.12555870e-02f,
  -1.48994522e-02f, 1.64790433e-02f, -2.28319615e-02f, -2.73625255e-01f, 2.68921465e-01f, -2.58936405e-01f, -2.06253771e-02f, 1.97931571e-04f, -1.04150191e-01f, -5.20656025e-03f,
  -4.47153971e-02f, 1.74491212e-01f, -2.76594728e-01f, -1.43673554e-01f, -3.38153213e-01f, 2.07330391e-01f, 2.54341036e-01f, 6.21427521e-02f, 1.91980734e-01f, -1.65586218e-01f,
  -2.27112904e-01f, -2.39167213e-02f, -1.55005097e-01f, 2.66634347e-03f, -9.83498320e-02f, -3.66185904e-02f, 1.35141447e-01f, 1.96049944e-01f, -1.27673432e-01f, -5.46737164e-02f,
  -4.02560011e-02f, -4.73046094e-01f, 2.09675103e-01f, 5.22642843e-02f, 3.81689072e-02f, 2.31647119e-02f, 5.80189116e-02f, 8.00242946e-02f, 3.27236146e-01f, -3.33788171e-02f,
  3.02488416e-01f, -6.79768696e-02f, -4.51736040e-02f, -5.00140786e-02f, 4.18657996e-02f, -1.75660253e-01f, -8.99156407e-02f, 2.71005899e-01f, -2.97660559e-01f, -7.85900503e-02f,
  6.36620969e-02f, 9.00026783e-02f, -1.53730348e-01f, 1.00622997e-02f, 1.08232778e-02f, -7.20908716e-02f, 9.21839848e-02f, -6.00675717e-02f, -2.44077906e-01f, 7.58125246e-01f,
  -2.05133468e-01f, -1.42175049e-01f, 2.49843784e-02f, -1.50426641e-01f, -2.57357806e-01f, 8.71291906e-02f, 7.52303377e-02f, 5.45292377e-01f, -9.77545455e-02f, 7.23679215e-02f,
  4.34406959e-02f, 4.27012853e-02f, 1.76889542e-02f, -6.15067631e-02f, 3.16965610e-01f, 1.32067934e-01f, -2.48275682e-01f, -2.48841792e-02f, -3.19314227e-02f, -2.51770113e-02f,
  -2.29836658e-01f, -2.03071296e-01f, 7.53188878e-02f, -2.95819566e-02f, 2.96342850e-01f, 2.13598147e-01f, 1.69712305e-01f, 3.11783165e-01f, -6.55744448e-02f, -1.43561453e-01f,
  -3.87318037e-03f, -3.24295998e-01f, 1.62756070e-01f, -3.30174603e-02f, 4.93562035e-02f, 2.67914593e-01f, -3.62840086e-01f, 2.04321384e-01f, -2.35437915e-01f, -4.14473355e-01f,
  1.70505777e-01f, -1.89951941e-01f, 8.42910409e-02f, -1.15419246e-01f, 3.78809241e-03f, -8.97318348e-02f, -1.34728283e-01f, -2.07058638e-01f, 7.07157627e-02f, 8.67878646e-02f,
  -1.76325515e-01f, -3.04755848e-02f, 1.51663452e-01f, -2.57634908e-01f, 3.87250870e-01f, -5.01661897e-01f, -2.08114460e-01f, 1.24987751e-01f, 2.77478918e-02f, 7.27047306e-03f,
  -2.18819186e-01f, 1.36449620e-01f, 2.21963719e-01f, 2.60037988e-01f, -3.80462334e-02f, -2.26054966e-01f, -3.35693806e-01f, -4.98587191e-02f, -2.90792286e-01f, 9.14440900e-02f,
  -3.85534376e-01f, 3.59527916e-01f, 2.68969506e-01f, -1.27284136e-02f, 4.16106343e-01f, 1.51117101e-01f, 3.98002714e-01f, -1.79709435e-01f, -5.08483537e-02f, -8.81515667e-02f,
  -1.22289941e-01f, -6.47035167e-02f, 3.67043749e-03f, 1.42231546e-02f, -3.03576738e-01f, -1.16321787e-01f, 8.60368684e-02f, 2.51523435e-01f, -2.26074606e-02f, 1.29810318e-01f,
  -4.68499325e-02f, 1.01670967e-02f, 4.36495431e-03f, 1.69521406e-01f, -2.04622358e-01f, -1.28923073e-01f, 9.68541652e-02f, -1.09346779e-02f, -1.81928068e-01f, -2.35279441e-01f,
  2.21217901e-01f, 3.02639842e-01f, 6.15104847e-02f, -2.38175228e-01f, 1.86533719e-01f, -6.69776499e-02f, 5.15176952e-02f, -3.29637043e-02f, -1.59063175e-01f, -1.59052208e-01f,
  -1.83722198e-01f, -1.01720773e-01f, 1.09514810e-01f, -2.02263072e-01f, -1.84236959e-01f, 2.44941801e-01f, 9.21023414e-02f, 1.05170526e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  3.32349509e-01f, 4.25806910e-01f, 6.02627136e-02f, 3.79752636e-01f, -2.15838496e-02f, 2.80041173e-02f, 1.20359875e-01f, 3.37293744e-01f, 4.85314548e-01f, -4.57423568e-01f,
  3.80366832e-01f, -3.54134887e-01f, 4.90892231e-01f, -4.22847420e-01f, 2.54219711e-01f, -3.90459150e-01f, 6.49879575e-01f, 2.58671522e-01f, 5.31823397e-01f, -2.32461303e-01f,
  -6.65772930e-02f, 2.54265696e-01f, -4.32868227e-02f, 3.09995949e-01f, -1.10612094e-01f, -6.71888366e-02f, 5.88421881e-01f, 2.16530427e-01f, -1.45172492e-01f, 5.22596538e-01f,
  8.96396935e-01f, 3.83179784e-01f, 9.12124589e-02f, 4.91439700e-01f, 3.44988585e-01f, 3.35791260e-01f, 3.24121922e-01f, 1.58054441e-01f, -3.29825968e-01f, 1.00887120e-01f,
  -5.58340922e-02f, -4.93761957e-01f, 4.13318872e-02f, 3.91072571e-01f, -1.70579955e-01f, 6.40370488e-01f, -4.17731553e-01f, -4.14221227e-01f, 1.54912576e-01f, -4.51183796e-01f,
  6.28914237e-02f, 1.05237342e-01f, 7.16917543e-03f, -1.81463301e-01f, -2.64224350e-01f, -2.94152126e-02f, 4.16447759e-01f, 4.04063284e-01f, 1.16607942e-01f, 2.86017686e-01f,
  1.49904966e-01f, -1.81533158e-01f, 2.79171884e-01f, 3.68360616e-02f, 1.71262458e-01f, -4.24186215e-02f, -5.05124480e-02f, 2.29306191e-01f, 3.97904754e-01f, 3.70354876e-02f,
  -4.44725573e-01f, 3.59336555e-01f, 1.46382257e-01f, -6.75027966e-01f, -4.91858184e-01f, 1.79620281e-01f, -3.46592218e-01f, 6.33197606e-01f, -1.53204814e-01f, 4.44909424e-01f,
  -1.33775517e-01f, 4.61905748e-02f, -1.38491198e-01f, 1.58437341e-01f, 2.89012074e-01f, 4.18525070e-01f, 6.75969839e-01f, 3.11646312e-01f, 6.26221672e-02f, 1.10626988e-01f,
  -4.25920561e-02f, 3.00756454e-01f, 5.70968330e-01f, -2.62480766e-01f, -2.84400254e-01f, -2.18218658e-02f, 4.88408715e-01f, 8.80186539e-03f, 1.03590101e-01f, 3.84958029e-01f,
  -7.16677904e-02f, -2.06914112e-01f, 2.77792037e-01f, -2.80647546e-01f, 3.69014263e-01f, 4.03022617e-02f, 5.35448015e-01f, 1.43998921e-01f, -1.80838294e-02f, -2.56147295e-01f,
  9.09527615e-02f, -4.45675462e-01f, 4.69381571e-01f, 3.49252999e-01f, 5.04955947e-01f, 2.31367722e-01f, -7.91855827e-02f, 1.10827267e-01f, -2.30298728e-01f, 3.85056555e-01f,
  4.46016528e-02f, -2.02018276e-01f, 4.39796805e-01f, 1.85893714e-01f, -1.52951837e-01f, 6.53750002e-01f, 8.13880861e-01f, 6.99496210e-01f, 4.40875404e-02f, -9.92029682e-02f,
  -1.09994963e-01f, -1.77822143e-01f, 1.43290803e-01f, -3.09398353e-01f, -2.35436428e-02f, -2.63821870e-01f, -6.50640726e-02f, 5.72208047e-01f, 1.05424903e-01f, -3.59082311e-01f,
  -4.75771964e-01f, -3.37888509e-01f, 2.18440279e-01f, -8.45784396e-02f, -3.21797937e-01f, -3.36529985e-02f, 4.30634409e-01f, 4.38713789e-01f, 4.99045432e-01f, 1.31874233e-01f,
  3.79718781e-01f, -3.64934921e-01f, 2.53771782e-01f, 3.26606125e-01f, -2.55969524e-01f, -1.08451374e-01f, -2.71141946e-01f, 3.03549767e-01f, -5.48262954e-01f, -2.18289733e-01f,
  8.89888555e-02f, -4.30382304e-02f, 2.94505835e-01f, 1.06230684e-01f, 1.20025337e-01f, 7.44715631e-02f, 6.79221630e-01f, -9.88767669e-02f, 1.40195355e-01f, 1.83384687e-01f,
  1.53601438e-01f, -3.82086605e-01f, -2.43549682e-02f, -1.33736670e-01f, -3.66407543e-01f, 2.46276110e-01f, -9.96805549e-01f, -4.01392639e-01f, 3.24046075e-01f, 5.18493712e-01f,
  7.82180369e-01f, 5.15874326e-01f, 1.14147663e-01f, -4.64706831e-02f, -4.26490605e-01f, -4.45730299e-01f, 4.57418203e-01f, 2.47697636e-01f, -8.59309062e-02f, 4.71461378e-02f,
  1.20551363e-01f, -1.03253946e-01f, 5.08187823e-02f, 2.09571198e-01f, 2.55420208e-01f, 4.71944541e-01f, 1.60826579e-01f, 5.24549842e-01f, -1.16854370e-01f, 3.84581745e-01f,
  1.43278152e-01f, 4.37961472e-03f, -2.42736936e-01f, 4.33982044e-01f, -3.44737053e-01f, 8.48435223e-01f, -6.65393233e-01f, -1.44604042e-01f, -1.62680492e-01f, -4.74110663e-01f,
  6.48878664e-02f, 2.92484201e-02f, -2.47928023e-01f, 9.04382393e-02f, -1.66697875e-01f, 1.90481991e-01f, 4.92597759e-01f, 2.19635412e-01f, -1.43550441e-01f, 2.92330205e-01f,
  5.49377024e-01f, -3.44909757e-01f, 3.15443836e-02f, -2.47874841e-01f, 1.50292069e-01f, 1.30892903e-01f, 2.11736858e-01f, 2.94555575e-01f, 8.99243653e-02f, 2.37512395e-01f,
  -4.63641696e-02f, -1.05869181e-01f, 1.12563379e-01f, 3.52100670e-01f, -2.52569765e-01f, -1.27839625e-01f, -5.71841467e-03f, -3.05620939e-01f, -3.22694564e-03f, -3.91854763e-01f,
  -1.28702223e-01f, -3.37157995e-01f, 3.78822774e-01f, -2.35911876e-01f, -3.21216509e-02f, -1.04228199e-01f, 1.63507357e-01f, 2.50564478e-02f, 3.78607720e-01f, 6.39621317e-01f,
  -3.21656555e-01f, -1.56459380e-02f, -1.68018982e-01f, 4.32705224e-01f, 7.37563074e-02f, -2.33913645e-01f, 2.06469268e-01f, 4.04678971e-01f, 2.10065961e-01f, 5.47241420e-02f,
  1.15424238e-01f, 5.07779002e-01f, -1.53211430e-01f, 3.93575132e-01f, -2.43286222e-01f, 2.53014535e-01f, 8.45230222e-02f, -2.70148158e-01f, -2.09054239e-02f, -3.13705653e-01f,
  1.12198917e-02f, -1.08302966e-01f, 4.78195429e-01f, -6.97733104e-01f, 3.69751394e-01f, -3.51307273e-01f, -1.38209522e-01f, -3.16722482e-01f, -4.03051376e-01f, -2.12169349e-01f,
  5.08298457e-01f, 4.55839574e-01f, -3.71172458e-01f, -2.81263918e-01f, 9.98805240e-02f, 2.37485602e-01f, 4.54896867e-01f, -4.17620391e-01f, 1.22629013e-02f, 2.29640096e-01f,
  1.24404706e-01f, 2.60646213e-02f, 7.46398419e-02f, -2.86831766e-01f, 2.03945711e-01f, 1.53377742e-01f, -5.43493740e-02f, 1.80415884e-01f, 1.11748502e-01f, -2.80548364e-01f,
  7.43763614e-03f, -1.20186485e-01f, 6.01187348e-02f, 1.89237610e-01f, -6.63192451e-01f, -3.65761012e-01f, 1.80996686e-01f, 4.86645281e-01f, 4.04635429e-01f, 1.12104088e-01f,
  2.56330669e-01f, 1.49456095e-02f, 8.60052090e-03f, -2.22494423e-01f, 3.23495418e-01f, -5.42834364e-02f, -1.05041765e-01f, 1.47113204e-01f, -1.77712560e-01f, -3.57493430e-01f,
  4.73281294e-02f, -2.86466062e-01f, 8.53308961e-02f, 2.98948050e-01f, 9.19845887e-03f, -4.42559607e-02f, -4.19354737e-02f, 1.52269110e-01f, 3.68705392e-01f, -4.07083899e-01f,
  -6.79702982e-02f, -2.19393656e-01f, -1.06636286e-01f, 4.03288543e-01f, -6.41020596e-01f, -3.24462146e-01f, -6.10642493e-01f, 5.50547428e-02f, -8.35807398e-02f, -1.56437680e-02f,
  2.49441266e-01f, 5.42500138e-01f, 6.21530235e-01f, 2.43038148e-01f, -4.03422564e-02f, -3.24344665e-01f, 3.42941433e-01f, 3.30610842e-01f, 3.59180748e-01f, -4.61202711e-01f,
  -7.89565966e-02f, -3.66935618e-02f, -6.26646429e-02f, 6.30908683e-02f, -2.34575391e-01f, -9.57972184e-02f, -1.72578037e-01f, -1.18535593e-01f, 2.95453906e-01f, 1.04958927e-02f,
  1.72294348e-01f, -4.25169855e-01f, -1.53754756e-01f, 2.12258831e-01f, -3.43625218e-01f, 1.12993911e-01f, 2.63960481e-01f, -2.41956666e-01f, 4.85762618e-02f, 7.04099596e-01f,
  -3.79925221e-01f, 2.85898089e-01f, -1.23579390e-01f, 4.84094054e-01f, 2.30814382e-01f, 4.45425302e-01f, 8.18385929e-02f, -4.64177758e-01f, 3.81036490e-01f, 3.27687830e-01f,
  -1.00932941e-02f, 7.60441199e-02f, -1.80956334e-01f, 5.47873795e-01f, 1.20184444e-01f, 5.47970891e-01f, -1.69617802e-01f, 2.33209014e-01f, -2.74142027e-01f, -1.05243541e-01f,
  3.23922992e-01f, 2.38437310e-01f, 3.24683279e-01f, 3.46474767e-01f, -8.85367393e-02f, -2.87929744e-01f, 6.36544526e-02f, -6.79282129e-01f, 6.11214340e-01f, 3.99858177e-01f,
  7.10668623e-01f, -3.99889439e-01f, 2.76814699e-01f, 4.15295631e-01f, 4.37553078e-01f, -1.71508845e-02f, -2.54802294e-02f, -4.26785409e-01f, -7.12136552e-02f, 8.12971592e-02f,
  1.64055154e-01f, -2.70593286e-01f, -3.51864725e-01f, 3.15570742e-01f, -6.39289394e-02f, 2.47788634e-02f, -4.23413843e-01f, -4.77461755e-01f, -1.47764012e-01f, 2.20114782e-01f,
  1.04154401e-01f, 2.07058653e-01f, 2.42977440e-01f, -2.72334367e-01f, 5.12827411e-02f, 9.24508832e-03f, -7.25087404e-01f, 2.06864163e-01f, -3.87504876e-01f, -5.14701605e-02f,
  2.91780829e-01f, 8.71798843e-02f, 2.11739670e-02f, 5.44681251e-01f, -5.91394842e-01f, -2.77029425e-01f, -3.98990452e-01f, 9.54026580e-02f, 8.11878264e-01f, 4.45845276e-01f,
  4.36357968e-02f, 2.54246652e-01f, 7.18788058e-02f, 3.98931295e-01f, 1.21419556e-01f, 2.65552133e-01f, -6.10637784e-01f, 2.47463524e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  1.39567211e-01f, 2.73959674e-02f, 1.76957339e-01f, 2.91893780e-01f, -6.69604912e-02f, 9.14200619e-02f, 3.21327448e-01f, 4.72547673e-02f, 3.29299808e-01f, -5.77905495e-03f,
  6.22909591e-02f, 1.37538358e-04f, 8.74569863e-02f, 6.31167963e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -2.77556241e-01f, -8.70854557e-02f, 4.62007880e-01f, 1.25431955e-01f, -1.23512767e-01f, 3.86512205e-02f, -1.05313174e-01f, -9.87549722e-02f, 1.30474120e-01f, 3.92509729e-01f,
  2.27306157e-01f, -8.10496733e-02f, -5.48229933e-01f, -1.78941041e-01f, -5.29996455e-01f, 8.91465127e-01f, -2.29597613e-01f, 2.70451933e-01f, -6.08933210e-01f, 2.33118325e-01f,
  2.26468295e-01f, -5.18117547e-01f, -1.52015239e-01f, -1.20238453e-01f, 2.71717370e-01f, 1.06125765e-01f, 1.40856475e-01f, -2.18963802e-01f, -3.74866724e-01f, -6.75610304e-01f,
  -6.19526446e-01f, 2.55731821e-01f, -2.89179236e-01f, -2.45285407e-01f, -1.04501374e-01f, 5.19253239e-02f, -3.51270065e-02f, 1.15253679e-01f, 5.34393899e-02f, 1.83940649e-01f,
  1.70697406e-01f, -1.26146702e-02f, 1.97284535e-01f, -2.17130557e-02f, 9.84811559e-02f, -2.57242382e-01f, 3.58289301e-01f, 1.40875757e-01f, 7.01801181e-01f, 6.91882148e-03f,
  -5.13200462e-01f, -7.24192783e-02f, 3.13402265e-01f, -7.74974227e-01f, -4.83419627e-01f, 1.86562285e-01f, 3.39428246e-01f, -3.93822014e-01f, -6.76798642e-01f, 1.55664593e-01f,
  2.84811705e-01f, 1.61537006e-01f, -4.15388763e-01f, 2.36433253e-01f, -3.78143638e-01f, 4.04527366e-01f, 4.86226320e-01f, -1.44988433e-01f, 4.66786116e-01f, 3.78569871e-01f,
  3.95349294e-01f, 2.97588438e-01f, 3.74392599e-01f, -7.06302933e-03f, -3.21751505e-01f, -7.50017583e-01f, 3.88672575e-02f, 1.85164809e-01f, -3.66844267e-01f, -1.38057217e-01f,
  -4.30187643e-01f, 3.52632016e-01f, 5.37145197e-01f, -1.67969763e-01f, 9.86043736e-02f, 4.77379523e-02f, -5.31562209e-01f, -5.02613485e-01f, -2.50047594e-01f, 1.32428259e-01f,
  2.96475381e-01f, -5.12190044e-01f, -2.53220469e-01f, -5.87494195e-01f, 1.63334861e-01f, -2.21010268e-01f, 1.48097634e-01f, -5.07440090e-01f, -1.48517266e-01f, -2.07029894e-01f,
  -1.60987690e-01f, -3.53435636e-01f, -5.90786934e-01f, -2.20617697e-01f, -1.01397550e-02f, 1.69563353e-01f, 3.84029672e-02f, 2.71628380e-01f, 5.93217500e-02f, 5.16902804e-01f,
  -2.61102766e-01f, -1.03645109e-01f, 1.00120276e-01f, -4.48714569e-02f, -2.62685031e-01f, -9.62718427e-02f, -8.32277656e-01f, -3.32096308e-01f, 2.74487078e-01f, -6.55618012e-01f,
  -4.74839546e-02f, 2.91691840e-01f, 3.43163699e-01f, -1.74198583e-01f, 2.62885123e-01f, -2.99311459e-01f, 4.28363889e-01f, -2.70892084e-01f, 3.28974903e-01f, 3.09722066e-01f,
  -1.37303129e-01f, 2.08256952e-02f, 1.31458715e-01f, -3.03083122e-01f, 1.56321660e-01f, 2.14300066e-01f, -3.58826458e-01f, -5.86770952e-01f, -5.56275487e-01f, 3.94150406e-01f,
  2.83815175e-01f, -2.29467764e-01f, 8.66600633e-01f, -7.63603091e-01f, -7.38336965e-02f, -3.27612013e-01f, -2.00424001e-01f, 2.59415090e-01f, -1.82995081e-01f, 4.99505587e-02f,
  -9.42998528e-02f, 1.18662305e-01f, 3.88199240e-01f, 5.13872467e-02f, 2.71323800e-01f, -1.32833511e-01f, -6.70938969e-01f, -1.98051587e-01f, -2.43676931e-01f, -3.60863060e-01f,
  -2.99516827e-01f, -2.27282867e-01f, -1.52300015e-01f, -3.62963825e-01f, -4.27290469e-01f, 2.94983476e-01f, -9.76600349e-02f, -2.00591311e-01f, -2.51665622e-01f, -5.15459239e-01f,
  2.00827211e-01f, 4.98260707e-01f, -5.07974982e-01f, 2.01208424e-02f, -3.72361958e-01f, -9.73157957e-02f, -5.93963087e-01f, -3.18266302e-01f, 2.29880542e-01f, 2.91521102e-01f,
  1.97525740e-01f, 5.10374457e-02f, -2.56278008e-01f, -4.79872972e-01f, 1.68313488e-01f, -1.56279042e-01f, -3.72261405e-01f, -2.89808869e-01f, 8.80876482e-02f, 8.84593055e-02f,
  -1.74911320e-01f, -4.70064282e-02f, -7.29897767e-02f, 1.07581140e-02f, -1.21572101e-02f, 4.74977553e-01f, 2.75973737e-01f, -2.02997532e-02f, 4.53147531e-01f, -3.82954776e-01f,
  -8.48304331e-02f, 1.46852568e-01f, 4.43627834e-01f, 5.08416235e-01f, 2.56370113e-04f, 3.50093357e-02f, -2.75666952e-01f, -2.54348308e-01f, -5.59598327e-01f, 3.10884267e-01f,
  2.94040889e-01f, -3.75828296e-01f, -4.99362320e-01f, 3.80235642e-01f, -6.78670049e-01f, 8.49844739e-02f, -5.15252426e-02f, -7.99915373e-01f, -4.24753010e-01f, -7.77375028e-02f,
  -5.79523146e-01f, 3.31621468e-01f, 2.83276409e-01f, -3.62528920e-01f, 4.02975269e-02f, -1.75808519e-01f, 1.48698196e-01f, -1.17770191e-02f, -1.78659275e-01f, 5.42805381e-02f,
  6.91802502e-02f, -4.20739688e-02f, -1.36802169e-02f, -3.25163752e-01f, -2.15895742e-01f, -1.59345955e-01f, 2.15437829e-01f, 2.76664019e-01f, 3.39262873e-01f, -7.87890423e-03f,
  2.08218783e-01f, 3.13987106e-01f, -5.98190546e-01f, -1.24394044e-01f, 3.42894137e-01f, -5.94936550e-01f, 4.41733003e-01f, 2.02316940e-01f, -3.57019514e-01f, -3.75687182e-01f,
  -4.42534983e-01f, 4.47073132e-01f, -6.33809045e-02f, -7.98935294e-02f, 2.14422107e-01f, -3.07364345e-01f, 2.83606142e-01f, -3.81999344e-01f, 1.21348880e-01f, -4.16103423e-01f,
  2.04590186e-01f, -2.37707689e-01f, -1.05125628e-01f, -2.69090980e-02f, 3.70397307e-02f, -1.48063153e-01f, 5.07838726e-02f, -5.09456277e-01f, -1.77166294e-02f, 6.48285002e-02f,
  1.10855125e-01f, -3.91652882e-01f, 2.77426869e-01f, -1.27410099e-01f, 1.70526594e-01f, -6.44337356e-01f, 2.21577913e-01f, 8.88390765e-02f, -1.21378310e-01f, -9.28157642e-02f,
  -9.02384222e-01f, -6.14980996e-01f, -3.10874544e-02f, -3.34702551e-01f, 2.46611908e-01f, 3.59785140e-01f, -3.18892211e-01f, 2.90406793e-01f, 3.70922148e-01f, 1.74192011e-01f,
  6.44257292e-02f, -1.86279774e-01f, -4.03731227e-01f, 5.87243624e-02f, 1.23103999e-01f, -1.42638013e-01f, -1.00308239e-01f, 4.32335675e-01f, -3.60885918e-01f, -6.42557204e-01f,
  3.47157866e-01f, 2.62695104e-01f, -4.49243665e-01f, 2.08864853e-01f, 7.79456735e-01f, 1.12539001e-01f, 1.26840800e-01f, -2.63177097e-01f, -2.50327528e-01f, 1.76521167e-01f,
  2.81895660e-02f, 3.03757817e-01f, -2.02504337e-01f, 5.21903448e-02f, -2.68989146e-01f, 1.13967262e-01f, -4.10539955e-01f, -4.59025651e-01f, 3.34963411e-01f, -3.06624800e-01f,
  2.98125446e-01f, 1.84818894e-01f, -1.69304281e-01f, 7.02028200e-02f, -2.81761855e-01f, -1.94248036e-01f, -3.96947801e-01f, -1.34321913e-01f, -9.57742780e-02f, 9.63413268e-02f,
  -2.89700627e-01f, 2.11809784e-01f, 4.82356101e-01f, 2.82258302e-01f, 3.05053085e-01f, -1.06756292e-01f, -4.63715419e-02f, -2.42149055e-01f, -1.29186153e-01f, -2.33487517e-01f,
  -2.10894033e-01f, 1.48155630e-01f, 2.03532204e-01f, -7.59089530e-01f, -3.22585702e-01f, 3.50610673e-01f, -2.77394205e-01f, -5.17993391e-01f, -6.43517494e-01f, -4.79371473e-02f,
  -3.15606683e-01f, 5.53317010e-01f, 2.58942515e-01f, -5.31604812e-02f, -3.28293413e-01f, -1.65729240e-01f, -3.96206588e-01f, -4.46860492e-01f, -2.15832531e-01f, 9.92031544e-02f,
  2.30300203e-02f, 3.63078713e-01f, 3.22963655e-01f, -4.88284945e-01f, 1.27917230e-01f, -3.40607166e-01f, 9.52539146e-02f, 8.15585613e-01f, -1.23267714e-03f, -1.25440657e-01f,
  1.15066007e-01f, -1.67256057e-01f, -9.86618623e-02f, 6.31832778e-02f, -4.56751764e-01f, 4.32539046e-01f, -1.23891875e-01f, -3.00152749e-01f, -3.80093455e-01f, -2.49012858e-02f,
  5.08361042e-01f, -5.02218269e-02f, -4.73199695e-01f, -7.29128420e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.08653659e-01f, 1.06137440e-01f, 9.27430764e-02f, -1.63096517e-01f, 2.70110279e-01f, -1.41002228e-02f, 1.61712661e-01f, 9.73392949e-02f, 5.26019558e-02f, -2.03467399e-01f,
  -2.20916551e-02f, -4.30838726e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    