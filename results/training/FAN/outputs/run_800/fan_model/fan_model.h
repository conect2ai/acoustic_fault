/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  9.13379192e-02f, -3.42662819e-02f, 2.01475516e-01f, 2.05252483e-01f, 1.37047172e-01f, -2.45438397e-01f, -4.15804833e-01f, -2.23027378e-01f, -1.19714113e-02f, -1.88628674e-01f,
  -5.39346319e-03f, 6.95801601e-02f, 8.01774636e-02f, 3.48370671e-02f, -2.52275728e-03f, -9.36399102e-02f, 1.81819215e-01f, 1.84757829e-01f, 1.24786384e-01f, -1.09974034e-01f,
  4.85625770e-03f, 2.38626331e-01f, 2.61650354e-01f, 7.26012439e-02f, 5.05855158e-02f, 1.53913209e-02f, 1.81232527e-01f, 2.11782351e-01f, 8.55196863e-02f, 1.76722974e-01f,
  -5.38433390e-03f, 2.44193263e-02f, 1.30463280e-02f, 1.86744314e-02f, 6.07601404e-02f, -6.61043823e-02f, -5.90293184e-02f, 9.44508612e-02f, -2.88051348e-02f, -2.14612037e-02f,
  1.55171782e-01f, 1.22895325e-02f, 4.97267954e-02f, 3.01835835e-02f, 2.36873254e-02f, -2.67363507e-02f, -3.42226326e-02f, 6.95298985e-02f, 5.34894653e-02f, -1.43604223e-02f,
  1.57788530e-01f, 1.95628464e-01f, 2.97432132e-02f, -6.61296472e-02f, -6.65378198e-02f, 7.43575320e-02f, -4.28165980e-02f, -6.42489716e-02f, 1.92866903e-02f, -1.50607318e-01f,
  -3.25615034e-02f, -6.88528940e-02f, 6.20124824e-02f, 4.86010779e-03f, -1.34295272e-02f, -4.96968776e-02f, 6.20166622e-02f, 2.34094672e-02f, 8.38024076e-03f, -1.84837915e-02f,
  1.12731577e-04f, -6.64508268e-02f, 2.06084587e-02f, 2.55099218e-02f, -1.06111998e-02f, 2.47393176e-02f, -2.30268342e-04f, -5.50222676e-03f, 1.77028347e-02f, 2.10442580e-02f,
  4.48326655e-02f, 1.20158913e-02f, 9.26941484e-02f, -5.46277966e-03f, 1.61240585e-02f, 8.11513513e-02f, -2.84790676e-02f, -1.34249190e-02f, 2.54917936e-03f, 9.79288071e-02f,
  -1.84519619e-01f, 1.46827236e-01f, -1.41569138e-01f, -1.34441182e-02f, -5.86031675e-02f, -8.48808140e-03f, 6.87983334e-02f, -2.55189487e-04f, 4.32994440e-02f, -3.01558767e-02f,
  -2.80169640e-02f, 5.34998961e-02f, -1.75233111e-02f, 3.04593388e-02f, -5.97328432e-02f, -4.16687354e-02f, -5.89204580e-02f, -6.54936209e-02f, -8.95140767e-02f, -1.04178125e-02f,
  -5.18392287e-02f, -2.14513853e-01f, -1.77625880e-01f, -9.87171456e-02f, -7.87562355e-02f, 5.38934628e-03f, -1.51829183e-01f, -2.85350019e-03f, -1.16707765e-01f, -3.21038336e-01f,
  1.07466653e-01f, -2.24666193e-01f, -1.57776162e-01f, -7.73107782e-02f, -1.77642610e-02f, 1.68279722e-01f, -2.23535046e-01f, -5.50071634e-02f, 1.65290982e-01f, -3.13552171e-02f,
  -2.54726857e-02f, 1.44099310e-01f, 1.27793834e-01f, 2.01634374e-02f, 1.51491528e-02f, -1.43009230e-01f, -1.52622506e-01f, -9.18088946e-03f, 2.05048472e-01f, -4.32324177e-03f,
  -6.86993822e-03f, -6.53976426e-02f, -2.28156019e-02f, 7.45591223e-02f, -1.44785061e-01f, 3.32834840e-01f, -1.17145784e-01f, -9.02828723e-02f, -2.41380073e-02f, -5.43493032e-01f,
  -9.88701507e-02f, -2.89712816e-01f, 3.60261351e-02f, -6.11339137e-02f, -5.50760478e-02f, 7.59620219e-02f, 2.34968290e-02f, -1.55978799e-01f, 9.26700681e-02f, 2.82331649e-02f,
  -1.15938365e-01f, 1.20988605e-03f, -6.62977397e-02f, -1.62877385e-02f, 1.41727859e-02f, 1.06869414e-01f, -2.98478305e-02f, -3.89887728e-02f, -4.07777168e-02f, -4.70843026e-03f,
  7.90863065e-04f, -1.18623853e-01f, -7.03478456e-02f, 8.33719820e-02f, -4.07943279e-02f, -7.68756866e-02f, -8.46401080e-02f, -8.44311193e-02f, -6.05020970e-02f, -8.23729262e-02f,
  5.60715087e-02f, -3.52016464e-02f, -3.51555236e-02f, 2.26652180e-03f, 3.25881154e-03f, 1.83269323e-03f, -3.70530449e-02f, 1.32498257e-02f, 7.66232163e-02f, -4.18220088e-02f,
  -1.11808321e-02f, -2.21695416e-02f, 2.32224334e-02f, 2.81494651e-02f, 2.92786472e-02f, -7.60853812e-02f, 3.10185328e-02f, 7.66121875e-03f, -4.55943644e-02f, 6.16269698e-03f,
  -1.91371399e-03f, 1.00049889e-02f, 2.52758302e-02f, -5.68341352e-02f, 5.40438574e-03f, 2.09310502e-02f, 7.31869340e-02f, 2.28201617e-02f, 3.13076898e-02f, -5.23312055e-02f,
  2.12529764e-01f, 1.11372478e-01f, -4.72323503e-03f, -3.96529064e-02f, -4.66083884e-02f, 1.26781669e-02f, 6.00979244e-03f, 8.67509171e-02f, -1.29661961e-02f, -3.96689679e-03f,
  -2.11266801e-02f, 5.24302665e-03f, 2.34883912e-02f, 1.52895190e-02f, 8.24062526e-02f, -6.45768316e-03f, -3.95904817e-02f, 7.51744434e-02f, -1.72804259e-02f, -7.82145467e-03f,
  4.47354726e-02f, 1.55131415e-01f, 1.71621531e-01f, 5.31323217e-02f, 6.76754937e-02f, 9.79626328e-02f, 1.52680546e-01f, 7.98013881e-02f, 1.31934881e-01f, 4.17026252e-01f,
  1.04015696e+00f, 1.50161296e-01f, -3.55590470e-02f, 1.83523878e-01f, -1.51043028e-01f, -9.72762406e-02f, 2.16507852e-01f, 1.18901350e-01f, 9.00957659e-02f, 1.45034343e-01f,
  -1.11532822e-01f, -9.29614976e-02f, 4.87295315e-02f, -1.54416308e-01f, 1.66528612e-01f, 7.39939958e-02f, -1.00634461e-02f, -7.29987100e-02f, 9.70727280e-02f, 1.73368692e-01f,
  -3.09232622e-03f, 4.31879349e-02f, 6.72154175e-03f, 5.89804016e-02f, 3.17138731e-02f, -1.04099050e-01f, -6.55156374e-02f, 4.09399942e-02f, -7.68118426e-02f, -1.24150187e-01f,
  -7.69520104e-02f, 2.26595610e-01f, -3.36648710e-02f, -1.31795825e-02f, -1.55873194e-01f, 1.82801820e-02f, 1.16735406e-01f, -1.01639614e-01f, -4.00937609e-02f, 6.48843870e-03f,
  -5.54715171e-02f, -2.32062861e-02f, 4.34847083e-03f, -6.12153634e-02f, 1.00508213e-01f, 5.65289631e-02f, -6.74296394e-02f, 9.59553644e-02f, 2.89022475e-02f, -2.23826915e-02f,
  -5.18513583e-02f, -8.22332725e-02f, 3.35935410e-03f, 2.90191583e-02f, 2.38425173e-02f, 1.03821494e-02f, -2.46115178e-02f, -1.65641084e-02f, -7.65045360e-02f, 5.43858856e-02f,
  1.83566529e-02f, 1.61417294e-02f, -6.58671036e-02f, 5.90982027e-02f, -9.99395549e-03f, -4.38087527e-03f, 3.01719364e-02f, -3.33498456e-02f, 3.34012741e-03f, 6.37814701e-02f,
  -5.82300127e-02f, 4.46636304e-02f, -7.77956173e-02f, 6.35828748e-02f, -9.20241401e-02f, 9.63174459e-03f, 9.48215928e-03f, -3.63934375e-02f, -2.44476255e-02f, 7.44921807e-03f,
  5.54842055e-02f, -4.13533822e-02f, -2.09603179e-02f, -7.15954602e-03f, 4.43762392e-02f, 6.01287633e-02f, -7.96222407e-03f, 3.40705514e-02f, 2.31757555e-02f, -2.92718634e-02f,
  8.58057588e-02f, -9.65780243e-02f, 9.92979407e-02f, 4.22239676e-02f, -3.78518216e-02f, -1.74701624e-02f, -7.89734647e-02f, 8.98831636e-02f, 3.76152694e-02f, 5.55720255e-02f,
  2.30034497e-02f, 6.82162354e-03f, -3.21090259e-02f, -5.39252423e-02f, 6.07650690e-02f, 6.57654777e-02f, -1.01264855e-02f, -6.40192032e-02f, -2.61178683e-03f, -4.35334444e-02f,
  4.16889228e-02f, 8.02173018e-02f, 2.20904320e-01f, 7.15181604e-02f, 6.33620918e-02f, 1.23796791e-01f, -1.31543735e-02f, 9.98223871e-02f, 7.79154301e-02f, 2.32016340e-01f,
  -1.40778124e-01f, -6.19872436e-02f, 1.48185462e-01f, -5.54050617e-02f, 3.09479795e-02f, 5.16421385e-02f, -5.42912632e-02f, 7.41150975e-03f, -1.28356367e-01f, -7.53389746e-02f,
  -2.15920201e-03f, 1.28340527e-01f, 1.15253992e-01f, 1.62367389e-01f, 7.01237842e-02f, 1.39132529e-01f, 2.38306165e-01f, 1.70261711e-01f, 2.48945504e-01f, 4.44849059e-02f,
  -5.39672896e-02f, -4.57433835e-02f, -7.22244307e-02f, 2.51188781e-02f, -1.55532017e-01f, 3.33767645e-02f, -5.34552969e-02f, -1.74645081e-01f, -9.30497572e-02f, -2.22928096e-02f,
  6.40821701e-04f, -5.08286757e-03f, 1.24234267e-01f, 4.02369201e-02f, 5.05289286e-02f, -7.14827999e-02f, 8.84537294e-04f, 3.67394672e-03f, 2.71938276e-03f, -7.35652819e-02f,
  -4.22961526e-02f, -9.74696875e-02f, 4.79408205e-02f, -8.50236639e-02f, -3.50270383e-02f, -9.77838486e-02f, -5.39571270e-02f, 1.60282962e-02f, 1.21548817e-01f, 6.62862808e-02f,
  3.05022486e-02f, 8.50603282e-02f, -2.64403727e-02f, 2.07162965e-02f, 4.95611653e-02f, 4.17928882e-02f, -9.34643820e-02f, -4.10728529e-02f, 7.87494779e-02f, -1.69651061e-01f,
  -1.31953163e-02f, 4.99391481e-02f, -6.56714290e-02f, -1.72602013e-02f, -1.18618242e-01f, -6.48256112e-03f, -4.65380773e-03f, -1.10748455e-01f, -8.20857566e-03f, -1.83058362e-02f,
  7.97232762e-02f, 1.22096119e-02f, 4.24151914e-03f, -5.99527769e-02f, 1.00763619e-01f, -2.97296066e-02f, -2.77309120e-02f, -1.59432776e-02f, 1.03568077e-01f, -2.25206725e-02f,
  -4.19983529e-02f, -3.05756573e-02f, -4.64146286e-02f, -5.22186719e-02f, -3.89661896e-03f, 2.79365946e-02f, -1.00737596e-02f, 9.95750129e-02f, 2.88153924e-02f, -2.73148734e-02f,
  -2.21775457e-01f, 3.91622901e-01f, -1.23802990e-01f, 2.35496890e-02f, 3.46924961e-02f, 2.11525634e-02f, -6.34016767e-02f, -6.15416355e-02f, -7.33210295e-02f, -4.35544290e-02f,
  8.19617882e-02f, -1.00866042e-01f, -2.66387686e-02f, -3.73405628e-02f, 1.52272627e-01f, 2.35821791e-02f, 1.76404919e-02f, 1.80840995e-02f, 7.07274377e-02f, -7.06301481e-02f,
  -6.46441504e-02f, -5.65043204e-02f, -4.35369723e-02f, -5.70059828e-02f, 6.03074729e-02f, -1.91292465e-02f, -3.30047309e-02f, -4.75134216e-02f, 6.72340095e-02f, -2.72180408e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.42643973e-01f, 1.22269295e-01f, -2.97852345e-02f, 9.37542599e-03f, -1.46023497e-01f, -1.57165349e-01f, -6.95440322e-02f, -1.52243391e-01f, 4.88038734e-03f, 1.19714208e-01f,
  5.24663031e-02f, -6.21738322e-02f, -8.90882909e-02f, -1.88981682e-01f, -8.83030742e-02f, 5.84888384e-02f, -4.37042974e-02f, -3.12499553e-01f, -4.69685078e-01f, -2.13254869e-01f,
  -2.11557463e-01f, -1.82888195e-01f, -3.51262726e-02f, -7.23279342e-02f, 8.74814019e-03f, -1.51305482e-01f, 3.52030285e-02f, 9.08313692e-02f, -9.55119431e-02f, -3.74169499e-02f,
  1.33954123e-01f, 1.12790890e-01f, -1.22590356e-01f, -4.55701798e-02f, 3.63689028e-02f, 3.58678028e-02f, 3.10214944e-02f, 2.34089252e-02f, 3.15955319e-02f, 5.14912643e-02f,
  -7.05993846e-02f, -7.28083476e-02f, -6.30957708e-02f, -6.63803890e-02f, -6.47433251e-02f, 2.15282775e-02f, -2.62948629e-02f, -5.54638691e-02f, -3.95658650e-02f, 8.45745578e-02f,
  -7.13935774e-03f, -5.83850816e-02f, 9.39693127e-04f, -3.64352725e-02f, -5.40466867e-02f, -1.22611143e-01f, -1.17922403e-01f, 2.29267217e-02f, -8.41991454e-02f, -3.05735203e-03f,
  -3.41937505e-02f, -2.15698555e-02f, -5.22206798e-02f, 4.39318269e-02f, -2.37769764e-02f, 8.43241159e-03f, -5.73999025e-02f, -2.01943098e-03f, -5.27052805e-02f, 5.54065313e-03f,
  2.60938480e-02f, 4.24283482e-02f, 6.37973519e-03f, 9.01971832e-02f, 8.86070356e-03f, -3.63734290e-02f, 7.80061632e-03f, 3.26909348e-02f, 5.72661683e-02f, 1.74473021e-02f,
  -1.12739233e-02f, 4.17512655e-03f, -5.33404164e-02f, -6.65458292e-02f, 6.73727840e-02f, 4.18678559e-02f, 5.63546978e-02f, 1.94474515e-02f, -3.34172845e-02f, -9.22913096e-05f,
  -1.79454118e-01f, 6.31078705e-02f, 6.13396289e-03f, -1.42105147e-01f, -5.52264079e-02f, 5.30612879e-02f, 4.79259081e-02f, -4.40533012e-02f, -1.05130328e-02f, -2.47621592e-02f,
  -8.86704102e-02f, -2.86597405e-02f, -3.59547371e-03f, -2.54221763e-02f, -6.49120361e-02f, -1.02399133e-01f, -1.72831267e-02f, -8.35717246e-02f, -5.74883223e-02f, 6.73351884e-02f,
  -5.48182540e-02f, -1.02980748e-01f, -2.39049911e-01f, -1.40923947e-01f, -5.85918799e-02f, -1.61270484e-01f, -1.73314184e-01f, -1.06744990e-01f, -3.20510149e-01f, -2.15024114e-01f,
  4.11899149e-01f, -2.68507630e-01f, -3.18166345e-01f, 7.24624991e-02f, -5.67647554e-02f, 3.92492488e-02f, -4.56242785e-02f, 1.65247455e-01f, 1.72619209e-01f, -1.96270883e-01f,
  8.71226862e-02f, 3.11842620e-01f, 1.41194955e-01f, 2.32054695e-01f, 1.16318084e-01f, -2.64033347e-01f, -3.54864836e-01f, -3.08352951e-02f, 1.83972552e-01f, 2.19931349e-01f,
  2.77402289e-02f, -7.36333057e-02f, 1.12407185e-01f, 6.69210926e-02f, -2.18505666e-01f, 2.08933149e-02f, -4.36045051e-01f, -1.76769644e-01f, -9.01866257e-02f, -3.63202780e-01f,
  -4.02595140e-02f, 9.01057124e-02f, 6.35609925e-02f, 4.50518802e-02f, -4.09145020e-02f, 5.24032637e-02f, 2.21057907e-02f, -6.90606534e-02f, -5.74466586e-02f, -9.17151943e-02f,
  7.09124431e-02f, -5.49331792e-02f, 7.45577365e-03f, -2.75148600e-02f, -7.28310668e-04f, -3.92765515e-02f, -3.40715609e-02f, -9.50564966e-02f, -1.12490758e-01f, -3.04009058e-02f,
  -9.20975134e-02f, -9.96023715e-02f, -3.59666348e-02f, -1.96749941e-02f, 3.61932181e-02f, -7.54461139e-02f, -1.09226182e-01f, -8.18429217e-02f, -8.91724452e-02f, -3.06144476e-01f,
  -7.02214614e-02f, -2.19839253e-02f, -4.59143594e-02f, 3.74215357e-02f, -3.10396273e-02f, -2.91790199e-02f, -5.57270870e-02f, -6.58262968e-02f, -2.77210195e-02f, 8.73116683e-03f,
  4.27133031e-02f, -1.05007943e-02f, 5.37564121e-02f, -1.57635547e-02f, -3.65346521e-02f, -1.79945379e-02f, -1.97553132e-02f, -1.03527896e-01f, 8.55307877e-02f, 4.58022906e-03f,
  3.98037918e-02f, -2.45816801e-02f, -1.03078775e-01f, 4.46977541e-02f, -5.92075884e-02f, -5.32850362e-02f, 1.49164274e-02f, 1.38017803e-01f, 4.43586484e-02f, 6.64487947e-03f,
  2.99397223e-02f, 1.10003026e-02f, 3.88325453e-02f, 2.81218812e-03f, -4.46166098e-02f, 3.84214148e-02f, 5.44296429e-02f, -5.87312505e-02f, 5.51827848e-02f, 7.29218423e-02f,
  2.81973090e-02f, 4.81009968e-02f, -7.45989755e-02f, -3.29379737e-02f, -2.90380903e-02f, 3.09804082e-02f, -3.05502675e-02f, 1.57859421e-03f, 1.99953206e-02f, 9.86041850e-04f,
  -1.47661522e-01f, 9.69184656e-03f, 9.23862457e-02f, -8.51740018e-02f, 3.04705761e-02f, 4.41987887e-02f, -2.73511056e-02f, -5.63377328e-02f, 1.53313130e-01f, -1.73662007e-01f,
  -6.52514160e-01f, 7.78340027e-02f, -4.83466648e-02f, -4.77771103e-01f, 6.23437464e-02f, 2.18315467e-01f, 1.21757947e-01f, 1.01814263e-01f, -5.07182740e-02f, -5.02165332e-02f,
  -5.23041263e-02f, -1.39375255e-01f, -2.57246614e-01f, -7.44906217e-02f, -1.12810329e-01f, -1.30591124e-01f, -2.92612880e-01f, -2.99669534e-01f, -1.61154866e-01f, 1.24033287e-01f,
  -6.77307174e-02f, -4.18742120e-01f, -2.84910649e-01f, 4.62468006e-02f, -7.02196881e-02f, -9.34497863e-02f, -2.91535351e-02f, -1.31251425e-01f, 1.52204454e-01f, -2.33986720e-01f,
  -3.13349813e-01f, 1.53150901e-01f, 1.58542451e-02f, -7.60024562e-02f, 3.53456219e-03f, 7.59309251e-03f, 2.06958037e-02f, -9.56608281e-02f, 1.25864953e-01f, 6.55202866e-02f,
  -6.87264726e-02f, 9.92652923e-02f, -9.90579799e-02f, 8.37410316e-02f, -6.26902878e-02f, 9.07015875e-02f, 1.31775990e-01f, -2.04830170e-02f, -4.61461768e-03f, 1.33709490e-01f,
  4.08114977e-02f, 1.48161173e-01f, 2.47799754e-02f, 1.66041330e-01f, 7.54421726e-02f, -1.31733529e-03f, 3.64578553e-02f, 2.35956699e-01f, 1.55209228e-01f, 2.69914772e-02f,
  8.00729170e-02f, 6.64897554e-04f, -6.87870430e-03f, 2.66004838e-02f, -2.56034192e-02f, 3.30851711e-02f, -2.94711557e-04f, -9.80050117e-03f, -2.62016617e-02f, -5.32167330e-02f,
  9.87730920e-03f, 3.09964851e-03f, -5.73693514e-02f, -4.47514132e-02f, 1.59983058e-02f, 7.75085837e-02f, -2.15519480e-02f, -1.59884356e-02f, -3.63114616e-03f, 3.65653820e-02f,
  1.59990359e-02f, 6.81921234e-03f, -6.90522864e-02f, 1.79852061e-02f, 1.08802631e-01f, -5.65615774e-04f, 2.52869613e-02f, -6.40260335e-03f, -1.01585776e-01f, 9.16830301e-02f,
  -4.12570149e-01f, 9.97148678e-02f, -2.24881798e-01f, -3.25124487e-02f, -1.29173631e-02f, 5.19229099e-02f, -4.90656793e-02f, 1.04147881e-01f, -8.17305818e-02f, 3.49727795e-02f,
  1.19141430e-01f, -9.95795876e-02f, -3.35887298e-02f, 2.41523609e-02f, -1.02373265e-01f, 5.36864586e-02f, 5.99814719e-03f, -7.30595216e-02f, -2.71272361e-02f, 1.32479191e-01f,
  -2.25379760e-03f, -5.60708009e-02f, -2.14258850e-01f, -1.75838098e-01f, 3.34038213e-02f, -1.84529126e-01f, -1.64733738e-01f, -1.14205927e-02f, -1.39206558e-01f, -3.56785417e-01f,
  -3.75917554e-01f, -3.01847458e-02f, 4.81688157e-02f, -1.10626668e-01f, 4.98926379e-02f, 1.61688164e-01f, 1.50155146e-02f, 4.22278494e-02f, 4.34875377e-02f, 2.39553954e-02f,
  1.60025433e-02f, -1.03446394e-01f, 7.16982922e-03f, -6.18098900e-02f, -8.40242952e-02f, 1.32960537e-02f, 5.88113777e-02f, -4.01169732e-02f, -1.24225996e-01f, 3.13408189e-02f,
  -4.78522405e-02f, -2.44671702e-01f, -1.07952327e-01f, 1.42926024e-02f, 5.87329119e-02f, 1.35630026e-01f, -2.19135676e-02f, -3.37410085e-02f, 1.34264991e-01f, -4.76764552e-02f,
  1.73812762e-01f, -1.37997851e-01f, -1.32777095e-02f, -7.34029636e-02f, -1.05876230e-01f, -4.05572280e-02f, 8.60266313e-02f, 1.73229836e-02f, -1.37560099e-01f, -2.00589225e-02f,
  -5.26796281e-02f, 6.02215156e-02f, -1.72936581e-02f, 1.42793870e-02f, -4.00495343e-03f, 1.44251520e-02f, -5.67053668e-02f, 1.00338515e-02f, -4.95272912e-02f, 8.60347152e-02f,
  1.52620021e-02f, 6.88112900e-02f, -4.27995324e-02f, 9.24215242e-02f, -1.04667410e-01f, -5.33674657e-02f, 1.18214823e-01f, 1.18482411e-01f, 3.65387984e-02f, 1.68579519e-01f,
  1.45227707e-03f, 5.99702522e-02f, 3.71085033e-02f, 1.30238617e-02f, 3.55023220e-02f, 3.43717448e-02f, 4.10773791e-03f, 5.97295957e-03f, -1.82603039e-02f, -9.92879122e-02f,
  5.99172823e-02f, -4.55514789e-02f, -3.72497924e-02f, 5.56948222e-02f, -2.41121612e-02f, -2.32397225e-02f, -2.12831609e-02f, 5.02220392e-02f, -2.66622882e-02f, -1.46595463e-01f,
  -5.69313094e-02f, 8.29167888e-02f, 2.03757808e-02f, -1.32994726e-02f, -2.17967620e-03f, 7.92956203e-02f, 1.01784185e-01f, -5.96823208e-02f, 6.70944527e-02f, 2.71921698e-02f,
  7.88150281e-02f, 2.17339545e-02f, -4.93261367e-02f, -1.67793296e-02f, -1.50267268e-02f, -4.57156673e-02f, -6.49267808e-02f, -8.56206790e-02f, -7.80887349e-05f, 4.18889634e-02f,
  -2.75506321e-02f, -3.40223163e-02f, 6.21592347e-03f, 1.28842831e-01f, -6.63217017e-03f, -6.55104369e-02f, -7.44489208e-02f, -5.74264005e-02f, 1.06707640e-01f, -6.19535968e-02f,
  5.83492778e-02f, 1.17343232e-01f, 1.63971409e-01f, 9.82242301e-02f, 1.29307643e-01f, 7.72806779e-02f, 6.23636469e-02f, 1.97013125e-01f, 6.12301826e-02f, 2.59498328e-01f,
  -1.11224681e-01f, -1.05050057e-01f, 1.49784610e-01f, 6.70785531e-02f, 8.91189426e-02f, -5.03633060e-02f, -4.06169817e-02f, 3.82332616e-02f, 7.14351088e-02f, 4.27983850e-02f,
  1.28324121e-01f, 5.70451207e-02f, 1.29009292e-01f, 1.72331586e-01f, -6.98113441e-02f, 5.40219061e-02f, -3.61769609e-02f, 1.13691995e-02f, 1.10704243e-01f, 4.98118959e-02f,
  -3.88074666e-02f, -1.76781490e-02f, -8.29598308e-02f, 7.27042928e-02f, -2.52686627e-02f, 1.21924385e-01f, -7.26079792e-02f, 1.40874507e-02f, 5.75510552e-04f, -2.81264223e-02f,
  1.59448862e-01f, 2.40668785e-02f, 9.58667919e-02f, 5.06092086e-02f, 1.11745866e-02f, -4.47643884e-02f, 5.28021157e-03f, -4.18867096e-02f, 3.20260823e-02f, -3.60580310e-02f,
  1.02251083e-01f, 6.31776452e-02f, 3.35566141e-02f, -1.55086974e-02f, -4.84211817e-02f, 8.02852586e-02f, -4.29370143e-02f, 4.04045656e-02f, 2.60980483e-02f, 1.38585582e-01f,
  1.98215861e-02f, 5.57975322e-02f, 2.72249170e-02f, 5.89454994e-02f, -4.82001575e-03f, 2.71385517e-02f, -1.80600844e-02f, 3.83722633e-02f, -2.56350823e-02f, -2.91248737e-03f,
  1.09583087e-01f, -6.79063722e-02f, -1.28070742e-01f, -2.70190579e-03f, 3.34236771e-02f, -3.42297219e-02f, 5.58540458e-03f, -8.12554080e-03f, 1.31744808e-02f, -1.07762821e-01f,
  5.71013838e-02f, 2.19152682e-03f, 8.31282809e-02f, 9.37510654e-02f, -1.33792479e-02f, -6.13436438e-02f, -4.99420874e-02f, -2.45478004e-02f, -4.12352085e-02f, -2.20783670e-02f,
  -6.12283219e-03f, -1.05027552e-03f, 5.46773337e-02f, 3.17306221e-02f, 9.10651013e-02f, 7.34338835e-02f, 2.94434819e-02f, -6.53182492e-02f, -3.99687812e-02f, -6.79355999e-03f,
  1.24601103e-01f, 9.84608978e-02f, 2.15428889e-01f, 2.03282274e-02f, -3.88241708e-02f, 1.13153225e-02f, 7.76465684e-02f, -7.13119805e-02f, -3.53643261e-02f, 1.05089825e-02f,
  1.00454539e-01f, -6.26893565e-02f, 3.15601602e-02f, -3.14493254e-02f, 6.82947189e-02f, 7.48552978e-02f, 4.89446521e-02f, 1.80926956e-02f, 5.56222759e-02f, 8.54323525e-03f,
  2.63319872e-02f, -4.68261056e-02f, -4.46475577e-03f, 1.11492034e-02f, 1.74899325e-02f, 1.42348617e-01f, 1.46560654e-01f, 6.36751354e-02f, 8.85997415e-02f, 6.02424555e-02f,
  -6.15885258e-01f, 3.69271412e-02f, -2.43197717e-02f, -3.75842042e-02f, 5.77599108e-02f, 2.19107911e-01f, 3.12962234e-01f, 1.91284463e-01f, 1.01562910e-01f, 3.47319804e-03f,
  -1.94401234e-01f, -1.12619177e-01f, 7.22714886e-03f, 2.22671255e-01f, 2.06409186e-01f, 2.72346973e-01f, 3.65978062e-01f, 1.49910420e-01f, -9.13401786e-03f, 1.48559930e-02f,
  1.02956168e-01f, -1.70692578e-01f, -2.99219489e-01f, 5.15202694e-02f, -6.29102290e-02f, 4.24223840e-02f, -4.37081344e-02f, -1.85838759e-01f, 7.23547190e-02f, 2.79241741e-01f,
  -2.95154095e-01f, -2.24215046e-01f, 1.23616807e-01f, -1.33405685e-01f, -7.32937157e-02f, -6.52400851e-02f, 1.98725937e-03f, -8.52195993e-02f, -3.26904375e-03f, 1.30032972e-02f,
  -1.39091954e-01f, -1.26500232e-02f, -3.79316323e-03f, 8.39883648e-03f, -1.15905009e-01f, 4.03808132e-02f, 5.71764931e-02f, 1.10555425e-01f, 2.73531787e-02f, -5.99326789e-02f,
  9.67303813e-02f, -2.22586751e-01f, -1.81941867e-01f, 7.10329413e-02f, -2.31152568e-02f, 1.06188200e-01f, -6.17032573e-02f, -5.42026386e-02f, 1.97741501e-02f, -1.35165408e-01f,
  3.15079950e-02f, -3.14432718e-02f, 3.69635671e-02f, 4.46780771e-02f, 5.29549532e-02f, -9.80939902e-03f, 6.46403804e-02f, 7.97557831e-02f, 3.39067839e-02f, -1.71237774e-02f,
  3.18106152e-02f, 6.71066111e-03f, 1.00356065e-01f, 8.63191187e-02f, -2.14406569e-02f, -9.75643843e-02f, 8.79290327e-02f, 1.07178450e-01f, -7.90672470e-03f, -2.32579950e-02f,
  -2.98722163e-02f, 1.91349685e-02f, -8.41784757e-03f, 8.02215710e-02f, 7.39744529e-02f, 8.59548599e-02f, -7.67266825e-02f, -6.95721880e-02f, -1.49596557e-01f, -7.91723579e-02f,
  -2.48713657e-01f, 1.54617682e-01f, -6.87811002e-02f, 2.36536227e-02f, -5.20533212e-02f, -1.68074633e-03f, -3.52406688e-03f, -6.15384504e-02f, -5.51732853e-02f, -1.71627104e-02f,
  -8.53181779e-02f, 2.40883920e-02f, -1.74804498e-02f, 5.64418267e-03f, -6.99897259e-02f, -5.57232499e-02f, -1.25636697e-01f, 6.23012893e-02f, -8.60584993e-03f, -8.67150426e-02f,
  3.51789370e-02f, -8.63550231e-02f, -2.35353559e-01f, 6.61620349e-02f, -1.47824034e-01f, 1.38033163e-02f, -1.34844974e-01f, -1.95138767e-01f, -8.94163996e-02f, -9.29715633e-02f,
  7.00123727e-01f, -9.69010517e-02f, 5.52523494e-01f, 8.34985226e-02f, 2.93141931e-01f, 5.32979906e-01f, 6.61664724e-01f, 3.60410333e-01f, 4.23588278e-03f, 8.07076413e-03f,
  -3.37527581e-02f, -3.74256611e-01f, -3.10372919e-01f, -2.89237291e-01f, 1.42190769e-01f, 2.01455027e-01f, 1.56966791e-01f, 6.90042749e-02f, 2.45336980e-01f, 9.74386185e-02f,
  -3.65162104e-01f, -2.84337476e-02f, -4.16749939e-02f, 6.06711023e-02f, -7.45511847e-03f, -1.87557980e-01f, 1.00447387e-01f, 7.06302896e-02f, -7.02695325e-02f, -2.59038836e-01f,
  1.20274685e-01f, 2.35402405e-01f, -1.06239840e-01f, -1.64352044e-01f, -4.53731567e-02f, -5.79521731e-02f, -3.00321598e-02f, -9.66385603e-02f, -8.66329297e-02f, -5.87616414e-02f,
  -1.46026649e-02f, -1.12080462e-01f, 3.43177374e-03f, -1.69647843e-01f, 6.37389943e-02f, -2.20446079e-03f, -6.42690286e-02f, 8.19476098e-02f, -2.99148355e-02f, -8.38706791e-02f,
  -1.47456139e-01f, 2.83629936e-03f, 2.78519154e-01f, 1.24956034e-01f, 1.65860489e-01f, 5.36373369e-02f, 1.59263499e-02f, 2.55076028e-02f, 1.29555866e-01f, -1.18859619e-01f,
  -4.83547635e-02f, 5.05512431e-02f, 1.69471186e-02f, 2.08618734e-02f, 6.04865188e-03f, -2.32290477e-02f, 3.32394838e-02f, -7.92914927e-02f, 2.04226412e-02f, 2.21535403e-04f,
  -7.69096240e-03f, 4.53327689e-03f, -3.53838541e-02f, 2.79812235e-02f, -2.84731332e-02f, 3.88910510e-02f, 3.47398184e-02f, -1.55957388e-02f, -1.06939740e-01f, -2.19449606e-02f,
  -2.68306676e-02f, 6.09454773e-02f, 8.04305747e-02f, -1.41608445e-02f, 5.96813560e-02f, -1.80892423e-02f, -8.49870816e-02f, -3.26159783e-02f, 3.36714834e-02f, -1.64069124e-02f,
  -3.17483872e-01f, 1.25893325e-01f, -1.27352908e-01f, -6.55126646e-02f, 1.36130769e-02f, -6.23637624e-02f, 9.18303709e-03f, -4.62115817e-02f, -1.42158819e-02f, 9.32710711e-03f,
  8.18418115e-02f, -1.10489912e-02f, 2.12664083e-02f, 8.38568360e-02f, 1.25250416e-02f, 3.93797457e-02f, -1.20528966e-01f, 2.10060626e-02f, -5.65884672e-02f, 3.55102867e-02f,
  -5.13272323e-02f, 7.85694048e-02f, 3.69072333e-02f, 1.03353737e-02f, -1.74454332e-03f, 3.59813794e-02f, 3.15215476e-02f, 4.71397974e-02f, 2.41574049e-01f, -1.44750491e-01f,
  2.68863559e-01f, -3.02803665e-01f, -3.92749667e-01f, -5.95206814e-03f, -1.40056595e-01f, -9.52363685e-02f, -1.51856557e-01f, -6.29640147e-02f, -7.14447200e-02f, -2.79574811e-01f,
  3.19185890e-02f, 8.53656381e-02f, 6.23227358e-02f, 8.58277082e-02f, 4.28738631e-02f, -2.53428727e-01f, -2.28125945e-01f, -1.25122771e-01f, 1.51886240e-01f, -4.89756241e-02f,
  -3.18072774e-02f, -1.07993565e-01f, 4.58304621e-02f, -5.29014021e-02f, -2.12433681e-01f, -8.01701099e-02f, -1.73229486e-01f, -7.87314400e-02f, -1.25616863e-01f, -1.48450658e-01f,
  -2.65340030e-01f, 1.26251236e-01f, -9.63122211e-03f, 6.45263270e-02f, -1.24449559e-01f, 1.81742180e-02f, 1.66899282e-02f, 3.55045982e-02f, 5.45304455e-02f, -4.50711474e-02f,
  -3.38599049e-02f, 4.20411006e-02f, 1.09389737e-01f, -2.50713155e-02f, 2.57895533e-02f, 3.08647528e-02f, -3.09838913e-02f, 1.00470074e-01f, 7.10323453e-02f, -5.30718651e-04f,
  1.13098226e-01f, 3.90769280e-02f, 1.13520287e-01f, 1.40476540e-01f, 1.69180527e-01f, 1.45809144e-01f, -1.33718243e-02f, 1.18862346e-01f, 8.62163007e-02f, -8.72498006e-02f,
  1.05108125e-02f, 1.14601552e-02f, 7.08798766e-02f, -1.85896847e-02f, 1.03740349e-01f, 9.37408954e-02f, 5.21653928e-02f, 3.78737524e-02f, 3.86668928e-02f, -5.47358207e-03f,
  -3.20035405e-02f, -2.27729678e-02f, -4.76681106e-02f, 8.36565048e-02f, -1.02072440e-01f, 4.99817096e-02f, 2.21358482e-02f, 3.85625884e-02f, 2.71680951e-02f, -1.91610549e-02f,
  -4.30126116e-02f, 5.61255105e-02f, -2.17170101e-02f, -3.41722481e-02f, -3.42254015e-03f, 3.68258879e-02f, 3.62056755e-02f, -5.80811426e-02f, -6.35647848e-02f, -5.30053535e-03f,
  -1.35546982e-01f, 1.27171010e-01f, -3.42163406e-02f, 1.51975110e-01f, 6.95181563e-02f, -9.07184705e-02f, -1.25105783e-01f, -5.48260994e-02f, -6.17391877e-02f, -1.23628773e-01f,
  1.12039652e-02f, 5.56682684e-02f, -5.78986816e-02f, 2.87369769e-02f, -3.48951705e-02f, -3.75740938e-02f, -1.92181598e-02f, 1.00840934e-01f, 1.29076093e-01f, -2.66254693e-02f,
  -5.55339605e-02f, 4.50305194e-02f, 7.27287680e-02f, 3.89596038e-02f, 4.79309671e-02f, 1.13915600e-01f, -8.22004080e-02f, 6.56535253e-02f, 5.62174246e-02f, -9.11623091e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.02619061e-01f, 2.47952357e-01f, 1.86907083e-01f, 1.09539598e-01f, -1.04093179e-01f, 2.11492792e-01f, 5.66560924e-01f, -2.67709419e-03f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.47504646e-01f, 3.15235496e-01f, -7.20925331e-02f, 1.55479833e-01f, 2.51379520e-01f, 4.46881577e-02f, -4.18481857e-01f, 5.62536456e-02f, 1.94059908e-01f, 2.08361626e-01f,
  5.73970616e-01f, -1.97254762e-01f, -1.16888434e-01f, -9.82939452e-02f, -5.93103617e-02f, -8.22728872e-02f, 1.58591364e-02f, 6.66845202e-01f, -6.70332834e-02f, 1.57142177e-01f,
  -2.21865505e-01f, 7.05062151e-01f, -3.96735184e-02f, 1.94279894e-01f, -5.62973201e-01f, 4.57978323e-02f, -7.10237259e-03f, 4.21005934e-01f, 7.42111951e-02f, 2.41735458e-01f,
  2.23526973e-02f, -9.04140547e-02f, 1.03299335e-01f, -2.91186213e-01f, 6.95921341e-03f, 1.62051931e-01f, -1.34238601e-01f, 4.10565078e-01f, -2.97295123e-01f, -9.21163484e-02f,
  -3.08362991e-01f, 4.53310847e-01f, -1.24584198e-01f, 1.05868720e-01f, -2.52735019e-01f, 3.59377295e-01f, -3.10866773e-01f, 7.76184946e-02f, -1.68644413e-01f, 4.34636652e-01f,
  -1.78326875e-01f, 8.83629322e-02f, 3.43760967e-01f, -4.69519109e-01f, 3.01264316e-01f, 4.84046608e-01f, -5.50207123e-02f, -3.53593618e-01f, 1.77854240e-01f, -1.37766838e-01f,
  1.18377529e-01f, 2.89646238e-01f, 5.72044373e-01f, -2.73121089e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -2.36749321e-01f, -2.75008827e-01f, -1.72296196e-01f, -3.13916296e-01f, 1.63126722e-01f, -1.33906022e-01f, -2.13711247e-01f, -2.46643946e-01f, -1.72884837e-01f, -1.13228112e-01f,
  -8.73477980e-02f, 6.14712015e-02f, 4.99356799e-02f, -2.58281767e-01f, -2.51833171e-01f, -2.44524851e-02f, -1.08865753e-01f, 3.57903838e-01f, 6.34446368e-02f, -1.94686890e-01f,
  -3.30384493e-01f, -4.38416377e-03f, 6.30182074e-03f, -2.48613656e-01f, 2.29570389e-01f, -1.00141419e-02f, 4.55766171e-01f, 3.06431592e-01f, -2.66184509e-01f, 7.96141699e-02f,
  9.00239050e-02f, -1.63640007e-01f, 4.85135317e-01f, -1.24798290e-01f, 2.24686280e-01f, 5.93838871e-01f, -4.28242147e-01f, -1.55810237e-01f, 9.75322127e-01f, -5.89694381e-01f,
  3.92048568e-01f, 8.66861269e-02f, -1.18338659e-01f, -3.59923482e-01f, -4.24332678e-01f, -5.75674295e-01f, 8.84476066e-01f, 2.75056362e-01f, 3.23596001e-01f, 3.68970245e-01f,
  -4.01885867e-01f, -8.27514008e-03f, -7.74024948e-02f, -2.66399592e-01f, -2.32996434e-01f, 9.42002386e-02f, 3.06165218e-01f, 4.58875388e-01f, 1.13406980e+00f, 1.17182486e-01f,
  -2.21093923e-01f, 3.42378557e-01f, -2.50707000e-01f, 1.27760425e-01f, -2.59789973e-02f, -1.99132040e-01f, -2.48801678e-01f, -1.38872927e-02f, 5.10655623e-03f, 2.18473986e-01f,
  -1.44308684e-02f, -2.90529132e-01f, 3.65011357e-02f, 1.10693127e-01f, 2.82678008e-03f, 1.78649753e-01f, -2.05227621e-02f, -2.64365524e-01f, 2.01053172e-01f, 1.46696597e-01f,
  -3.01220194e-02f, 1.56726912e-01f, -2.83022642e-01f, 1.74131751e-01f, 6.17341101e-02f, 2.01314256e-01f, -5.92497885e-02f, 4.28772539e-01f, -1.35025773e-02f, -2.48933569e-01f,
  5.03640532e-01f, 2.92826802e-01f, 1.24766186e-01f, 5.92947185e-01f, 1.63267180e-01f, 2.14938790e-01f, 6.72940016e-01f, 5.17074913e-02f, 1.02465458e-01f, 2.47136131e-01f,
  -2.80268759e-01f, 5.34354389e-01f, 2.90561229e-01f, 3.01610708e-01f, -4.64751363e-01f, 9.38348413e-01f, 2.52198488e-01f, -3.29338819e-01f, 8.11803415e-02f, -1.13182910e-01f,
  5.49511492e-01f, 6.69841647e-01f, 6.55861497e-01f, -4.85080123e-01f, 1.51343554e-01f, 5.98419189e-01f, 2.75911331e-01f, -2.65050888e-01f, 2.77189314e-01f, 3.22801948e-01f,
  -2.53534466e-01f, 4.98177409e-02f, -2.32784152e-01f, -2.39844888e-01f, -3.23664814e-01f, 8.14696789e-01f, 8.38815391e-01f, 3.58896196e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  -2.84442842e-01f, -1.41038736e-02f, 5.48106968e-01f, 7.90856406e-02f, -1.91655122e-02f, 2.40074858e-01f, -7.16087073e-02f, 4.22196239e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -4.66953605e-01f, -4.94819015e-01f, -2.32632175e-01f, -8.33304748e-02f, 4.15159669e-03f, 5.99007964e-01f, 3.84837657e-01f, -3.60689580e-01f, 1.57760054e-01f, 5.85516617e-02f,
  -6.61680520e-01f, 7.79302865e-02f, 1.87411085e-01f, 3.98995191e-01f, 6.61345541e-01f, -1.38407916e-01f, 2.94055622e-02f, 1.67313680e-01f, 3.69673729e-01f, 4.89593036e-02f,
  1.76659346e-01f, 4.64906812e-01f, 2.31465340e-01f, -1.69466212e-01f, -1.77249640e-01f, 3.94307403e-03f, -6.13871276e-01f, 3.97188187e-01f, -2.25399479e-01f, 2.33052462e-01f,
  5.83802536e-02f, -1.25387862e-01f, -3.56135339e-01f, 2.08892554e-01f, 3.25223595e-01f, 6.42365873e-01f, 7.77177140e-02f, 5.73606372e-01f, -1.61410809e-01f, 2.00955197e-01f,
  -5.90410233e-02f, 2.64991462e-01f, -3.26538831e-01f, 3.61618906e-01f, 9.26010013e-02f, 8.98473784e-02f, 6.85957447e-02f, -3.78922790e-01f, -1.31824970e-01f, -1.35631025e-01f,
  -2.52964169e-01f, -5.39358854e-02f, 5.04268646e-01f, 2.04009548e-01f, 6.37818575e-01f, -1.08202314e+00f, 1.47927329e-01f, 2.22266763e-01f, 8.31635743e-02f, -1.45806462e-01f,
  -1.00754477e-01f, -6.98757917e-02f, 5.37080884e-01f, -2.47415707e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  2.13803872e-01f, 1.96253777e-01f, -5.79548120e-01f, -9.16046917e-01f, -1.32504836e-01f, -7.30782002e-02f, -1.21977337e-01f, -2.12066099e-02f, 2.20824942e-01f, -3.43591034e-01f,
  8.89460742e-01f, 8.41278136e-02f, 2.56359488e-01f, 1.34845898e-01f, 8.46313894e-01f, 1.20556104e+00f, 3.87328446e-01f, 1.08579338e-01f, 2.15871274e-01f, 1.19898617e-01f,
  -7.82941282e-01f, -5.37780464e-01f, -1.00411379e+00f, 7.46146619e-01f, -1.71250269e-01f, 2.01236725e-01f, 1.22699726e+00f, -5.59600890e-01f, 1.03586996e-02f, -7.89070725e-02f,
  -2.72227019e-01f, 2.89214909e-01f, -7.01615334e-01f, -3.39393556e-01f, -1.94417074e-01f, 1.26014099e-01f, 1.60930544e-01f, -1.23706415e-01f, 1.93981066e-01f, 9.41679105e-02f,
  3.58030051e-02f, 3.63928825e-01f, -2.95958072e-01f, 1.26270258e+00f, -7.41011426e-02f, 3.57909441e-01f, 1.03152439e-01f, 1.24423411e-02f, -1.03082180e-01f, 1.19178519e-01f,
  3.71838689e-01f, 9.78500098e-02f, 1.97104752e-01f, 5.95621169e-01f, -3.10987085e-01f, 7.49872863e-01f, 2.15542898e-01f, 2.16389015e-01f, -3.92328888e-01f, 6.07675314e-02f,
  -8.04467127e-02f, 6.65494800e-01f, 2.15385437e-01f, 5.65654993e-01f, 4.57196862e-01f, 8.48656058e-01f, 1.93120390e-01f, 1.48226500e-01f, 3.29575181e-01f, -8.92554998e-01f,
  -4.21643704e-01f, 9.48582113e-01f, -2.68214643e-01f, -3.75937879e-01f, -2.07159862e-01f, -1.16311796e-01f, -4.27549452e-01f, 2.56130546e-02f, -7.51668930e-01f, 7.94465423e-01f,
  6.75127655e-02f, -2.68502925e-02f, -1.77410603e-01f, -5.71935236e-01f, -2.62866374e-02f, 1.58936903e-01f, 1.73332378e-01f, 1.39931664e-01f, 6.47404492e-02f, -2.95071155e-01f,
  7.23244715e-03f, 2.05223247e-01f, 9.26368982e-02f, -1.73590615e-01f, 9.04214978e-01f, 6.92931116e-02f, -3.36030155e-01f, -2.57138640e-01f, -1.00538373e-01f, 4.16984335e-02f,
  -1.18554607e-01f, -2.34148949e-01f, 1.83397442e-01f, -1.12705044e-01f, 2.15149477e-01f, 1.13378111e-02f, -2.32398733e-02f, -1.44963637e-02f, 1.42274171e-01f, 1.04747973e-02f,
  -6.33911714e-02f, 5.04176170e-02f, 2.74190426e-01f, 4.74414183e-03f, 3.96992713e-01f, -4.39321771e-02f, 1.69485006e-02f, 3.84050012e-01f, -8.68610963e-02f, 4.37669635e-01f,
  -3.01694840e-01f, -1.14828236e-01f, -2.93625385e-01f, 1.44118264e-01f, -2.59562969e-01f, 3.54151756e-01f, -1.72514066e-01f, 4.67101038e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  -1.06058650e-01f, 4.27082866e-01f, -8.94059800e-03f, 8.53315741e-03f, 7.27703333e-01f, -1.23177566e-01f, -1.81060508e-01f, -1.61219016e-03f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -7.22206652e-01f, -1.56054407e-01f, -3.64700943e-01f, -5.74823081e-01f, 5.25680482e-01f, 1.55959830e-01f, 2.67519981e-01f, 6.01197541e-01f, 3.58893663e-01f, -3.65046203e-01f,
  6.30033493e-01f, -3.14875513e-01f, -1.79788709e-01f, 6.36584044e-01f, 2.93475449e-01f, -3.57735395e-01f, 4.99334842e-01f, -4.99034859e-02f, -1.15555122e-01f, 3.13522890e-02f,
  3.67176175e-01f, -6.21376276e-01f, -6.95884168e-01f, 4.54642951e-01f, 1.02794313e+00f, -5.08838952e-01f, -5.56034207e-01f, 1.23302825e-01f, -2.94171095e-01f, 6.83352709e-01f,
  -1.42808974e-01f, 4.81544361e-02f, 4.98016000e-01f, 1.44914463e-01f, 6.90595433e-02f, 1.27798840e-01f, -9.15776014e-01f, 6.59777343e-01f, 8.08253050e-01f, -8.87105942e-01f,
  -6.96753919e-01f, -6.00330293e-01f, -2.25688651e-01f, 5.98478854e-01f, 9.16311204e-01f, -1.12765938e-01f, 9.44095924e-02f, 4.56462890e-01f, 1.03036873e-01f, -1.99182227e-01f,
  -2.27515042e-01f, -3.21195982e-02f, 7.78058767e-01f, 1.47519842e-01f, -3.88191521e-01f, -1.74487308e-01f, -4.08729255e-01f, -5.60919404e-01f, 6.78233266e-01f, 6.69404030e-01f,
  -2.73696035e-01f, -3.13747704e-01f, -6.90947101e-02f, 2.72306263e-01f, 6.63462222e-01f, 4.77458864e-01f, -1.04947364e+00f, 8.74530196e-01f, 1.46400392e-01f, 9.29183483e-01f,
  7.94905365e-01f, 3.03453624e-01f, -1.57052293e-01f, -4.82762545e-01f, 8.53756011e-01f, -2.45374933e-01f, -2.72257566e-01f, -4.40687120e-01f, 1.27052799e-01f, -3.54605496e-01f,
  8.29347372e-01f, 6.13311946e-01f, 8.21545482e-01f, 1.41258866e-01f, -1.20241439e+00f, -5.94917655e-01f, -2.03989878e-01f, 1.06965411e+00f, 5.26276648e-01f, 4.38097566e-01f,
  -4.16201383e-01f, -3.36842895e-01f, -5.42312801e-01f, 2.48800945e-02f, -1.42269149e-01f, 1.79035310e-02f, -6.70047402e-01f, -4.85045731e-01f, -5.26016116e-01f, -9.86808956e-01f,
  3.68644089e-01f, -6.32816195e-01f, -7.63085842e-01f, -1.97711974e-01f, -1.27202384e-02f, 8.43533278e-01f, -2.18728930e-01f, -2.37691298e-01f, 8.05330575e-01f, 9.77711231e-02f,
  7.88576435e-03f, 1.63370714e-01f, 1.54600814e-01f, 1.84444234e-01f, -3.08777094e-01f, -4.69889492e-01f, -1.89110413e-02f, 9.62435156e-02f, -4.72059846e-01f, -4.16133851e-01f,
  6.04447842e-01f, -5.72293997e-01f, -9.10001397e-02f, 4.36068237e-01f, 5.77896655e-01f, -4.13099788e-02f, 3.62770230e-01f, 6.03690624e-01f, -6.56041130e-02f, -9.15535331e-01f,
  9.35708582e-02f, 4.66634065e-01f, -6.64047539e-01f, -6.73005819e-01f, -1.58515111e-01f, -4.65789407e-01f, 3.82878065e-01f, 9.93062139e-01f, -2.34422326e-01f, 3.95481825e-01f,
  -9.40483868e-01f, 1.48992345e-01f, 1.02918789e-01f, 2.22674698e-01f, -7.27692068e-01f, 7.48350263e-01f, 5.02711296e-01f, -6.50498345e-02f, -5.64120591e-01f, -4.91866410e-01f,
  -2.89279222e-01f, -7.26734519e-01f, -7.22010136e-01f, 5.92099607e-01f, -2.76299626e-01f, -2.17573553e-01f, 1.15630209e+00f, -3.51490825e-01f, -1.74430385e-01f, 8.79433528e-02f,
  1.13380992e+00f, 8.78147066e-01f, 1.02065432e+00f, 3.73111576e-01f, 6.36608541e-01f, 8.35019052e-01f, 7.61584878e-01f, 1.18011963e+00f, -6.88991964e-01f, -8.24841559e-01f,
  -6.22059524e-01f, -3.51990849e-01f, -5.15574396e-01f, -2.66835317e-02f, -1.53451905e-01f, -4.75218967e-02f, -6.24966323e-01f, -6.64637864e-01f, -3.89598042e-01f, 2.43621051e-01f,
  4.48527783e-01f, 3.01182836e-01f, 3.55979383e-01f, -6.30165190e-02f, 8.18125963e-01f, 4.03680652e-01f, -2.61581779e-01f, -3.91345412e-01f, 1.91689506e-01f, 6.23005182e-02f,
  2.91613549e-01f, -3.03608060e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.39834806e-01f, -1.66786179e-01f, 3.34625244e-01f, -1.64136365e-01f, 2.04563782e-01f, 7.55681813e-01f, -2.87882596e-01f, -4.63114738e-01f, -4.96246248e-01f, 2.65649855e-01f,
  9.62521076e-01f, -5.26128292e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    