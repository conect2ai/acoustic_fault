/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.77413374e-01f, -8.66024643e-02f, 1.35725483e-01f, 4.60900441e-02f, -4.39064056e-02f, -2.56329197e-02f, 2.55886674e-01f, -6.60479590e-02f, 2.92355604e-02f, -7.63839632e-02f,
  -9.11225844e-03f, 5.29055148e-02f, 1.25413328e-01f, -9.63426009e-02f, 3.51008624e-01f, 2.82197911e-02f, -1.25936633e-02f, 1.36289578e-02f, -3.58431563e-02f, 2.84246616e-02f,
  1.81376352e-03f, -7.95058757e-02f, 1.18216038e-01f, -1.60629213e-01f, -9.55396965e-02f, -1.11161456e-01f, 4.21903990e-02f, -3.74953933e-02f, -6.87423199e-02f, 1.31814769e-02f,
  2.79842485e-02f, -1.36097800e-02f, -2.27239262e-02f, -3.97934876e-02f, 2.53830589e-02f, -4.76594307e-02f, 1.52277527e-02f, 5.95549271e-02f, 4.36373614e-02f, -1.24092363e-02f,
  -1.24245919e-02f, -1.26766488e-02f, -7.38913864e-02f, -3.89640629e-02f, -3.28319557e-02f, 2.03166250e-02f, 2.80597433e-03f, -3.57236788e-02f, -6.12169877e-03f, 6.42016605e-02f,
  -1.75115746e-02f, 7.41822086e-03f, -4.42941599e-02f, 2.06241179e-02f, 4.83675152e-02f, 2.95335446e-02f, 8.05680379e-02f, 4.62896861e-02f, -2.76542641e-02f, -6.75897449e-02f,
  -9.22329538e-03f, 6.19446076e-02f, -3.91275845e-02f, 2.00246982e-02f, 8.14109482e-03f, -1.34377275e-02f, 4.94432729e-03f, 2.45152488e-02f, 7.30845472e-03f, 3.30159292e-02f,
  -3.08526903e-02f, 2.02015471e-02f, -8.70684907e-02f, 4.44616526e-02f, -1.49694495e-02f, -5.60956858e-02f, 7.51676634e-02f, 4.69332607e-03f, -3.79043486e-04f, -1.97630487e-02f,
  1.58786941e-02f, 2.29225401e-02f, -1.34015540e-02f, -5.55037670e-02f, -7.57761998e-03f, 2.92749852e-02f, -1.58976798e-03f, -4.46080416e-02f, 4.27081063e-02f, 6.98667914e-02f,
  -1.33070931e-01f, -1.57041848e-02f, -5.81299309e-06f, -7.69731998e-02f, 3.16831865e-03f, 4.72726040e-02f, 5.83340451e-02f, -5.77123351e-02f, -3.69432531e-02f, 3.32398564e-02f,
  3.05572599e-02f, 3.94953489e-02f, 2.27131303e-02f, -1.97956301e-02f, -3.78833083e-03f, 2.81942412e-02f, 5.64011410e-02f, -2.26917733e-02f, -7.09637767e-03f, -1.70293655e-02f,
  -2.70259157e-02f, -1.13293678e-02f, 7.89553151e-02f, -2.40714625e-02f, -2.12906376e-02f, 1.50568057e-02f, -2.99087241e-02f, -5.87485395e-02f, 6.80089649e-03f, 6.37102202e-02f,
  -1.01613268e-01f, 1.63694531e-01f, -2.00100869e-01f, 2.19814137e-01f, 6.82795001e-03f, 2.33737588e-01f, 9.64820161e-02f, 1.47475809e-01f, 2.34796509e-01f, 2.01678589e-01f,
  4.63699400e-02f, -2.05102470e-02f, 1.19591445e-04f, 2.52394527e-01f, 1.24707267e-01f, 1.76831990e-01f, 2.11834088e-01f, -9.68307443e-03f, 2.94874124e-02f, 1.33409780e-02f,
  6.24140054e-02f, 1.05164751e-01f, -6.84769228e-02f, 4.47469652e-02f, 3.79234669e-03f, -1.65675953e-01f, -1.09936045e-02f, -1.37353614e-01f, 9.66582000e-02f, 1.60293039e-02f,
  -8.08752552e-02f, -5.04382364e-02f, -1.96676310e-02f, -1.01074822e-01f, -2.21214555e-02f, -1.27489761e-01f, -1.34725600e-01f, -6.03468381e-02f, 2.29256339e-02f, 2.32798848e-02f,
  -4.81040068e-02f, -3.90295014e-02f, 3.64935026e-02f, 8.23123455e-02f, 4.88188155e-02f, 3.56305353e-02f, 4.41082902e-02f, 1.17595531e-02f, 2.66375858e-02f, 2.57302541e-02f,
  4.76443842e-02f, 6.09046854e-02f, 1.40185293e-03f, 5.10738557e-03f, 3.95556018e-02f, 2.61271442e-03f, 9.11372807e-03f, -5.31691238e-02f, 5.30115440e-02f, 5.26046567e-02f,
  5.56690395e-02f, -6.09614551e-02f, -7.55838603e-02f, -2.65868269e-02f, 1.53514976e-03f, -7.77480155e-02f, 1.13322124e-01f, -8.45973045e-02f, -6.19645640e-02f, 7.41328225e-02f,
  3.30701806e-02f, 1.41045253e-03f, 3.55183966e-02f, -7.73029693e-04f, -4.24024910e-02f, -4.18299809e-03f, -3.55672166e-02f, -4.37188447e-02f, 1.29580619e-02f, 2.06730962e-02f,
  4.34603468e-02f, 2.00054590e-02f, -6.59700809e-03f, -2.54599620e-02f, 5.74506670e-02f, -5.68117667e-03f, 6.52125478e-02f, 1.07920123e-02f, 5.03562018e-03f, -1.61258895e-02f,
  1.04885168e-01f, 2.59738392e-03f, -2.84343455e-02f, 3.74576189e-02f, -1.25791833e-01f, 3.70241590e-02f, 3.39079089e-02f, 8.19736626e-03f, -1.44637274e-02f, -6.59769028e-02f,
  9.92330164e-03f, 3.14390194e-03f, -1.26344720e-02f, 1.88941229e-02f, 5.06032519e-02f, -2.60858275e-02f, -1.91198904e-02f, -9.32730269e-03f, 1.29691184e-01f, 4.18456495e-02f,
  -4.45276126e-02f, -6.43337378e-03f, 3.80627327e-02f, 1.63025744e-02f, -7.73342103e-02f, -4.92752492e-02f, -6.09006248e-02f, 3.09201120e-03f, 7.36787915e-02f, -1.05354320e-02f,
  -2.80181207e-02f, 1.42227206e-02f, -2.52876990e-02f, -5.60782962e-02f, -5.80950221e-03f, -2.91632146e-01f, -2.47193262e-01f, 3.27028669e-02f, -6.62939996e-02f, 7.17184395e-02f,
  -3.79242487e-02f, -4.66879793e-02f, 4.36431542e-02f, -1.48849234e-01f, -2.77058542e-01f, -1.32354051e-01f, -1.60489827e-01f, -2.38157995e-02f, 1.16544226e-02f, 5.36551327e-02f,
  -2.92007048e-02f, -7.79315531e-02f, 2.58623324e-02f, 5.55034094e-02f, 2.88007222e-02f, 1.40796587e-01f, 6.26527518e-02f, 1.24629408e-01f, 8.39591473e-02f, -5.49944751e-02f,
  -8.19415078e-02f, 1.21294921e-02f, -1.24828713e-02f, -5.16241938e-02f, 3.72745059e-02f, 3.83014418e-02f, 1.74742960e-03f, -5.84734753e-02f, 5.34554347e-02f, 4.95509803e-02f,
  -3.20527181e-02f, -6.04790896e-02f, -4.28267792e-02f, -5.63454442e-02f, 3.94503027e-02f, -6.81051402e-04f, -2.93283351e-02f, -1.59053933e-02f, -1.81620847e-03f, -9.88441613e-03f,
  3.94251430e-03f, 4.02570292e-02f, -4.29023057e-03f, 4.25641611e-02f, 3.91539373e-02f, 1.99289694e-02f, -1.37248100e-03f, 1.43006502e-04f, 2.11695321e-02f, -2.59885434e-02f,
  3.17180716e-02f, 1.70362677e-04f, 6.72916919e-02f, -2.60053538e-02f, 1.74293518e-02f, -1.35545507e-02f, -4.90362849e-03f, 4.39760573e-02f, 2.03192662e-02f, 1.00467131e-01f,
  -2.24336125e-02f, 6.22519664e-03f, 5.19779585e-02f, 4.83812541e-02f, -3.83155234e-02f, 9.78128426e-03f, 3.13139632e-02f, -2.91014500e-02f, 7.98066035e-02f, -4.51856526e-03f,
  1.03616668e-03f, 3.92441899e-02f, 3.30648273e-02f, 7.78518543e-02f, -9.08831805e-02f, -1.90280378e-02f, -3.02585401e-02f, 6.70350716e-03f, 2.52831378e-03f, -3.66161615e-02f,
  -4.97038998e-02f, 1.38919443e-01f, -4.87981774e-02f, -2.69669145e-02f, -2.20356677e-02f, 2.18079332e-02f, -2.09636297e-02f, 6.97480813e-02f, 6.74203932e-02f, 3.52386534e-02f,
  4.90980782e-02f, 3.61024751e-03f, 6.07133098e-02f, 1.83080286e-02f, 7.66037405e-03f, -2.17938535e-02f, 3.54691185e-02f, 3.87182310e-02f, -5.14096208e-03f, -4.58484590e-02f,
  2.30350029e-02f, -4.28879037e-02f, -1.55095998e-02f, -7.17716068e-02f, -1.42572448e-02f, -2.40851250e-02f, -2.00895462e-02f, 1.71655300e-03f, 8.49979557e-03f, 3.35130356e-02f,
  -2.20893756e-01f, -7.36453850e-03f, -1.98320046e-01f, -9.35757756e-02f, -7.09320530e-02f, -2.93937176e-01f, -7.95115158e-02f, -8.29257518e-02f, -4.80975956e-02f, 1.15505151e-01f,
  3.14740539e-02f, 7.92462453e-02f, -7.68312672e-03f, -2.11221036e-02f, -1.75482601e-01f, -1.13406800e-01f, -1.53093398e-01f, -5.57386316e-02f, -4.59340215e-02f, 5.18697314e-02f,
  -2.91662049e-02f, 1.30599663e-01f, -1.32625327e-01f, -3.50828283e-02f, -4.99151461e-02f, -7.29432795e-03f, 1.99906811e-01f, -9.98033732e-02f, 5.49676940e-02f, -7.49006588e-03f,
  -2.53140591e-02f, 9.38282907e-02f, -1.62046682e-02f, -9.27313566e-02f, 1.75731312e-02f, -3.70474905e-02f, 4.94797826e-02f, 5.80291674e-02f, -4.94690903e-04f, -4.66540083e-03f,
  -1.58300437e-02f, 2.12311372e-02f, -1.35663217e-02f, -5.53742275e-02f, 3.76213491e-02f, -1.36141498e-02f, -5.02647758e-02f, -2.74573769e-02f, 1.39310220e-02f, -7.97673315e-02f,
  -1.71605740e-02f, 1.63696352e-02f, -4.96893609e-03f, 6.37591928e-02f, -7.38370046e-02f, -6.98711053e-02f, 3.66965448e-03f, 2.38811839e-02f, 3.81833948e-02f, 8.83476529e-03f,
  7.30065405e-02f, -1.65347066e-02f, -2.09344625e-02f, -2.91424785e-02f, 1.25476485e-02f, 3.61615010e-02f, -3.34858778e-03f, 4.69213501e-02f, 9.95494146e-03f, 3.17329094e-02f,
  -7.02057928e-02f, 2.11909749e-02f, -3.51096913e-02f, 1.37664806e-02f, 3.48527543e-02f, 3.36869843e-02f, -2.55682562e-02f, 4.30825949e-02f, -7.05470890e-02f, -8.10134336e-02f,
  5.47008514e-02f, -2.02236585e-02f, -7.36337667e-03f, -1.28422724e-02f, -4.10353206e-03f, 2.34512910e-02f, 4.89309467e-02f, 2.69348118e-02f, -4.29167934e-02f, 2.17330176e-02f,
  -9.71936509e-02f, 1.13179579e-01f, -1.52136283e-02f, 2.10517123e-02f, -2.25959215e-02f, 2.50362754e-02f, -9.38223004e-02f, -2.76547633e-02f, 4.88365069e-03f, -2.08665594e-03f,
  3.87687050e-02f, -1.96059365e-02f, 4.79097553e-02f, 3.93362716e-02f, -5.29104359e-02f, -1.62465144e-02f, 1.21441782e-02f, 4.32540663e-02f, 5.26218973e-02f, -6.25545252e-03f,
  1.30046587e-02f, 2.12659240e-02f, 2.17176359e-02f, -3.71420905e-02f, 5.06831706e-02f, 7.33723491e-02f, -5.72421029e-02f, -6.20075390e-02f, 2.22686213e-02f, -1.85528817e-03f,
  8.74424055e-02f, -5.45643382e-02f, 4.87221442e-02f, -1.11973174e-01f, -4.18432653e-02f, -8.68384959e-04f, -2.58765519e-02f, -1.81445777e-01f, -7.65765160e-02f, -1.52041331e-01f,
  -7.25222901e-02f, 4.67578247e-02f, 7.05663562e-02f, -8.82584825e-02f, 2.85935849e-01f, 1.55671388e-01f, -4.99718674e-02f, -8.66310447e-02f, -3.98224592e-02f, -9.49394554e-02f,
  3.38464640e-02f, -2.83795670e-02f, 9.40883756e-02f, -1.08006679e-01f, -3.04279961e-02f, -1.19707048e-01f, -2.19557453e-02f, 4.69398275e-02f, -4.69794944e-02f, 4.70373333e-02f,
  1.95613559e-02f, -6.86587989e-02f, -1.94954034e-02f, -3.22071053e-02f, 1.36015322e-02f, 4.38136719e-02f, -2.06421483e-02f, 1.19607493e-01f, 7.76711181e-02f, -4.80713770e-02f,
  8.10032040e-02f, 1.36359064e-02f, -8.06084499e-02f, 4.83889766e-02f, -8.29045624e-02f, 2.50055082e-03f, 5.07858247e-02f, -2.00386681e-02f, -9.57285315e-02f, 5.78684770e-02f,
  6.73066601e-02f, -1.61555149e-02f, -3.77605483e-03f, 1.95325166e-02f, -5.91333658e-02f, -5.74539900e-02f, -2.51901206e-02f, 3.67498137e-02f, -7.89163485e-02f, -3.60591635e-02f,
  2.01356411e-03f, 6.26088157e-02f, 3.25211696e-02f, 3.70144621e-02f, -2.58061122e-02f, 3.03457752e-02f, 1.78572014e-02f, 2.94679459e-02f, 3.52924764e-02f, -8.82715136e-02f,
  6.98331278e-03f, -1.71875246e-02f, -9.78245772e-03f, -1.41906077e-02f, -4.33141105e-02f, -3.33733819e-02f, 8.83609280e-02f, 2.13871570e-03f, -7.01293349e-02f, -6.02459088e-02f,
  6.35359623e-03f, -5.61585724e-02f, -3.14533040e-02f, -1.38456086e-02f, 4.91631068e-02f, -1.63096189e-02f, -6.18693195e-02f, 6.32241508e-03f, -7.05260709e-02f, 6.23549335e-02f,
  -2.17534527e-02f, -8.09492767e-02f, 1.82081256e-02f, 5.50242327e-03f, -4.73035313e-02f, -4.38317806e-02f, 5.86397983e-02f, -2.43446883e-02f, -4.03201953e-02f, -6.16556359e-03f,
  -3.82974967e-02f, -1.71801932e-02f, 7.35177547e-02f, -9.83671993e-02f, 1.30490186e-02f, -1.92601327e-02f, 2.25054193e-02f, 4.77296598e-02f, 1.45934317e-02f, -9.90605727e-02f,
  -4.16997671e-02f, 1.45630380e-02f, 3.16883065e-02f, -9.18244869e-02f, -1.44791510e-02f, -6.04672097e-02f, -3.05392388e-02f, 8.69229529e-03f, 2.08485238e-02f, 1.75651927e-02f,
  -1.98524266e-01f, 1.63397685e-01f, 1.07896542e-02f, -1.42059758e-01f, -6.94065318e-02f, -2.39021719e-01f, -3.18915486e-01f, 6.62153438e-02f, 1.29309162e-01f, 1.10899583e-01f,
  -1.12976067e-01f, 3.08165513e-02f, 8.15771148e-02f, -5.01837023e-02f, -1.65016055e-01f, 1.60883851e-02f, -2.33447850e-02f, -7.84451440e-02f, 8.18976685e-02f, 7.78458128e-03f,
  6.76413924e-02f, -4.79796492e-02f, -2.77651306e-02f, 4.52985242e-02f, 1.32040465e-02f, 4.76169363e-02f, -1.37922559e-02f, -2.27169530e-03f, -5.97442053e-02f, 1.90845523e-02f,
  -2.69926433e-02f, 1.16160147e-01f, 6.43624291e-02f, -3.47916819e-02f, -7.37798959e-02f, -6.60405532e-02f, -5.06919995e-02f, -8.06767568e-02f, -3.12829483e-03f, 3.29691209e-02f,
  -1.62168648e-02f, -2.11472251e-03f, -1.20590869e-02f, -1.98066682e-02f, 1.43558970e-02f, 6.13893121e-02f, 3.46798114e-02f, -7.10204318e-02f, 5.48868719e-03f, 2.44361758e-02f,
  4.08378132e-02f, 2.40610377e-03f, -1.86238121e-02f, -2.18166839e-02f, 1.79745127e-02f, -8.60547530e-04f, -7.00765029e-02f, -1.93754882e-02f, -6.66087344e-02f, 7.66885187e-03f,
  2.48708893e-02f, 7.08671436e-02f, -9.08271223e-03f, 4.65891836e-03f, 2.35238727e-02f, 1.80635620e-02f, -3.05438824e-02f, 2.17066724e-02f, 5.30449487e-02f, 2.39314549e-02f,
  5.07688373e-02f, 2.63307746e-02f, 2.48838086e-02f, -3.77004109e-02f, -5.75909726e-02f, 6.00723177e-02f, -3.94383706e-02f, 6.01119101e-02f, -1.86901297e-02f, -5.45306653e-02f,
  6.47816807e-02f, -4.30530608e-02f, 3.21060196e-02f, -6.40494674e-02f, -1.59652419e-02f, -5.45299836e-02f, 5.30966334e-02f, 3.52583150e-03f, 2.04827096e-02f, -1.39711529e-01f,
  -1.75162090e-03f, 1.27755329e-01f, 2.77217459e-02f, 4.45862748e-02f, 1.46892352e-03f, 4.24247012e-02f, 1.29836109e-02f, -1.42849591e-02f, 2.01292541e-02f, -2.85800062e-02f,
  -2.14467364e-04f, -3.19803283e-02f, -6.87575666e-03f, -1.71015039e-04f, -9.28778723e-02f, -2.66324114e-02f, 2.90017966e-02f, -3.41708809e-02f, -8.58325064e-02f, -2.15207487e-02f,
  -5.18611334e-02f, 4.50613722e-03f, 1.16699561e-02f, -3.45970355e-02f, -1.13852426e-01f, 6.02205843e-03f, 4.47536781e-02f, -6.14556205e-03f, -7.57777086e-03f, 2.07955129e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.87782377e-01f, 2.04436243e-01f, 2.09988028e-01f, -1.78490743e-01f, -3.51643749e-02f, -1.32136434e-01f, -1.94985971e-01f, 1.05061255e-01f, -7.70154893e-02f, 1.94257483e-01f,
  -1.90893412e-01f, 4.63288277e-02f, 3.59619372e-02f, -1.95170999e-01f, -3.25080425e-01f, -1.35695577e-01f, -3.11225474e-01f, -1.50958464e-01f, -9.73480418e-02f, -4.08057161e-02f,
  -1.55038714e-01f, -3.34614009e-01f, -3.32977325e-02f, 1.54260501e-01f, -1.08553590e-02f, 1.41007945e-01f, -2.38724202e-02f, 2.60060634e-02f, 9.98115987e-02f, 4.52951752e-02f,
  -1.42039046e-01f, -1.19073810e-02f, 9.24991220e-02f, 1.28418058e-01f, 5.85710183e-02f, 9.35876742e-03f, 6.42355084e-02f, -6.71489239e-02f, -6.29568845e-02f, 6.72366172e-02f,
  9.62020904e-02f, 3.30564156e-02f, -1.26104010e-02f, 4.06713560e-02f, 8.24395195e-02f, 1.21831052e-01f, -7.03454483e-03f, 6.42386004e-02f, 1.21808454e-01f, 1.56321943e-01f,
  1.78303733e-03f, 8.82811919e-02f, -7.60682719e-03f, 1.43844392e-02f, 5.90012260e-02f, -1.45152742e-02f, -2.24472675e-02f, -3.82152088e-02f, 8.14304650e-02f, -1.72781162e-02f,
  -7.46970847e-02f, -3.74871492e-02f, -6.76751062e-02f, 5.57594299e-02f, -7.98289478e-02f, 1.02305643e-01f, 7.27110654e-02f, -3.29939239e-02f, -6.01148291e-04f, -7.37467110e-02f,
  -3.88784111e-02f, 5.97425438e-02f, -3.64382528e-02f, 4.87145148e-02f, -7.94694945e-02f, 3.90276685e-02f, 4.76913378e-02f, 1.38461560e-01f, -4.80649322e-02f, 2.68928669e-02f,
  6.46795612e-03f, -6.79103732e-02f, -5.04064262e-02f, 3.05181071e-02f, 5.59753142e-02f, 2.50912011e-02f, 7.33888969e-02f, 1.40907109e-01f, -8.69950280e-03f, -1.19436726e-01f,
  -1.32416129e-01f, -1.35033801e-01f, 5.69870733e-02f, 8.09846818e-03f, -3.14209387e-02f, -2.35738810e-02f, -1.35097839e-02f, 4.44309898e-02f, -3.39939743e-02f, 2.52836924e-02f,
  8.93949941e-02f, 6.95985034e-02f, -8.45490992e-02f, -7.79104084e-02f, -1.18669011e-02f, -7.84296468e-02f, -7.04899728e-02f, 3.82083505e-02f, -9.42987427e-02f, -1.94585007e-02f,
  3.84869091e-02f, -2.95397826e-03f, -3.56239378e-02f, 4.12822515e-02f, -8.23708065e-03f, 4.98231277e-02f, -8.86283349e-03f, 6.35300651e-02f, 3.39543819e-02f, 2.54282188e-02f,
  9.47057381e-02f, 1.22119993e-01f, 5.76055795e-02f, -6.31656647e-02f, -7.37625733e-02f, -1.77902237e-01f, -2.34436914e-01f, -2.27607861e-02f, 1.50249764e-01f, 1.81534123e-02f,
  -1.95033595e-01f, 1.93334460e-01f, 7.39962980e-02f, -1.28904907e-02f, -1.54304639e-01f, -7.05512092e-02f, -1.77660853e-01f, -9.86869112e-02f, 2.39543933e-02f, -5.10757901e-02f,
  -8.45204107e-03f, -2.68399924e-01f, 1.53351959e-03f, 4.40892428e-02f, -8.19597021e-02f, -2.23390423e-02f, -1.10615857e-01f, -1.39964849e-01f, 2.60790475e-02f, -1.00456029e-01f,
  -6.12456687e-02f, -4.40007746e-02f, 5.30184712e-03f, 6.53588027e-02f, -1.46332800e-01f, 9.13424231e-03f, -5.72162606e-02f, -1.05292954e-01f, -1.11569762e-02f, -7.14224949e-02f,
  -4.83397394e-02f, -3.62068526e-02f, 4.33478579e-02f, 6.42499402e-02f, -2.40784362e-02f, 1.48559615e-01f, 4.52894606e-02f, 4.62152921e-02f, -3.08370981e-02f, 1.00006275e-02f,
  1.67053446e-01f, 1.37303591e-01f, 5.58344908e-02f, -5.84437810e-02f, -7.01642185e-02f, -3.45932357e-02f, 1.15185417e-02f, -1.35793518e-02f, -3.02657094e-02f, 6.02324419e-02f,
  -4.80205454e-02f, 3.35107371e-02f, -3.32520306e-02f, 2.10350305e-02f, 2.55295578e-02f, -2.27435604e-02f, 8.36851522e-02f, 3.58614400e-02f, 5.10510355e-02f, 6.24210713e-03f,
  -4.50761691e-02f, 8.54836106e-02f, -3.80367860e-02f, -5.70627488e-02f, 6.85570613e-02f, 1.02815703e-01f, -6.98821098e-02f, -5.12758605e-02f, 4.44833487e-02f, -1.08183600e-01f,
  7.35091344e-02f, -1.01497866e-01f, -6.13200385e-03f, 4.39164750e-02f, -7.25316480e-02f, 6.62819594e-02f, 7.41115361e-02f, 9.67043415e-02f, -3.51305716e-02f, -1.23145357e-01f,
  -1.83496282e-01f, -2.93952703e-01f, -4.70932089e-02f, -2.57197767e-02f, 5.58372252e-02f, 4.78622504e-02f, 3.13604139e-02f, 7.31332898e-02f, -1.28408954e-01f, 3.03697661e-02f,
  2.39860415e-02f, -3.76298241e-02f, -6.96233362e-02f, -8.57013017e-02f, -6.60476983e-02f, 5.41311838e-02f, -9.67427045e-02f, -2.01931484e-02f, 1.25605473e-03f, 1.04369417e-01f,
  1.15115590e-01f, 6.13310933e-02f, 3.72249521e-02f, 4.27801646e-02f, -7.89128989e-02f, 6.99542277e-03f, 6.41086921e-02f, 7.15010986e-02f, 4.59342338e-02f, -1.56745892e-02f,
  -1.72346815e-01f, 1.80981606e-01f, 2.43588835e-01f, -9.87710655e-02f, 7.73265734e-02f, 3.37000191e-01f, 6.70030117e-02f, 2.92760432e-01f, 1.76056981e-01f, -7.73241967e-02f,
  -1.36346862e-01f, -1.36646479e-01f, 1.32501021e-01f, -7.27029964e-02f, 9.87584367e-02f, 6.61760643e-02f, -6.04280904e-02f, -4.88656387e-02f, 6.99641407e-02f, -7.34503046e-02f,
  -1.01946648e-02f, -1.98784471e-01f, -2.21350845e-02f, -7.15389475e-02f, -5.23873679e-02f, -1.34963468e-01f, -2.80026048e-01f, -3.54373194e-02f, -1.74647883e-01f, -1.00912854e-01f,
  -2.99778104e-01f, -1.41969144e-01f, -1.82593584e-01f, -8.03655162e-02f, -4.83410694e-02f, 3.68689857e-02f, -1.16906956e-01f, -4.11337875e-02f, -4.32784408e-02f, 3.44908983e-02f,
  -3.19441743e-02f, 8.10320079e-02f, -9.97445360e-02f, 8.08739290e-03f, 1.36109337e-01f, 9.35531333e-02f, -1.97651945e-02f, 1.24712484e-02f, 4.58709933e-02f, -8.12550634e-03f,
  4.50379774e-03f, 1.06852256e-01f, -8.40683579e-02f, -6.52781948e-02f, -1.60076888e-04f, 1.87128074e-02f, 1.58130620e-02f, 8.25107470e-03f, -8.35639518e-03f, 1.21567491e-02f,
  4.34720144e-02f, -2.19492316e-02f, -1.00020021e-01f, -4.02024463e-02f, -7.38271028e-02f, -1.18944701e-02f, -3.14449854e-02f, -3.15098874e-02f, 4.75786403e-02f, -8.43547136e-02f,
  -3.53404433e-02f, -1.78092122e-02f, 1.37492139e-02f, 8.26173797e-02f, -6.97059110e-02f, -9.66918543e-02f, -9.62023810e-02f, -4.33334745e-02f, -1.20669929e-02f, -1.08820073e-01f,
  1.04205599e-02f, 2.35441793e-02f, -9.46132187e-03f, -8.01754743e-02f, -1.39106028e-02f, -6.00801706e-02f, -5.28900810e-02f, 1.24195375e-01f, -8.69156793e-02f, -8.83501470e-02f,
  -2.50316054e-01f, -2.29831487e-01f, -2.66590007e-02f, -1.61358044e-01f, -5.30838408e-02f, -4.38514985e-02f, -6.28285408e-02f, -3.15675773e-02f, -9.20343995e-02f, 3.43359597e-02f,
  6.96734115e-02f, -2.98199262e-02f, -1.36590879e-02f, -6.29964517e-03f, 9.20716971e-02f, -1.07588004e-02f, -1.06845625e-01f, -3.84176597e-02f, -4.62074168e-02f, -8.81864429e-02f,
  3.59562896e-02f, -8.32878128e-02f, -4.12303880e-02f, -1.34120151e-01f, -9.59729925e-02f, -1.45574763e-01f, 8.91725123e-02f, -4.48931940e-02f, -2.34812852e-02f, 2.56371964e-03f,
  -3.87464389e-02f, 2.18194097e-01f, -5.60391769e-02f, 1.78456958e-02f, 5.85448742e-02f, -1.92913376e-02f, -8.19568783e-02f, -2.03028005e-02f, -9.52913985e-02f, 5.54164723e-02f,
  -1.98130729e-03f, 1.01411976e-01f, -1.27108186e-01f, -4.43800390e-02f, -2.07851425e-01f, -1.00880496e-01f, 1.03124015e-01f, -8.11710674e-03f, -1.39889359e-01f, 1.84350923e-01f,
  -2.64862962e-02f, 1.61311865e-01f, -1.24735199e-02f, 3.10721956e-02f, 1.00427546e-01f, 4.91948128e-02f, 1.85820371e-01f, 2.35777888e-02f, 2.35777631e-01f, -4.03527468e-02f,
  9.05969366e-03f, 2.49277893e-02f, -4.58018444e-02f, -7.32144415e-02f, 6.88078254e-02f, -3.18949344e-04f, 9.10845473e-02f, -1.55616552e-01f, -8.88259783e-02f, 6.91143982e-03f,
  2.59113405e-02f, 2.69467272e-02f, -1.35595296e-02f, -1.56013994e-02f, -1.37657719e-02f, 1.11974679e-01f, 9.87358019e-02f, 1.08206861e-01f, 3.56464125e-02f, 9.16746557e-02f,
  1.48104623e-01f, 8.18006918e-02f, 6.03054427e-02f, 9.64671895e-02f, -5.97359007e-03f, 7.73450881e-02f, 1.31093070e-01f, -5.35090826e-03f, 1.17980361e-01f, 2.69829910e-02f,
  -1.31995312e-03f, 3.34522277e-02f, -5.67787439e-02f, 1.64207350e-02f, 8.10731947e-02f, -7.16004968e-02f, -8.49064216e-02f, -1.43096074e-02f, 1.62598994e-02f, 1.85605921e-02f,
  -3.08450940e-03f, 7.05678016e-02f, 1.91286542e-02f, 1.69918202e-02f, 5.51788544e-04f, 3.18812951e-02f, 7.51231657e-03f, 1.03238476e-02f, 8.18958282e-02f, 5.50734513e-02f,
  5.16752293e-03f, 3.44779342e-02f, 7.35846683e-02f, -1.04194246e-01f, -5.00502028e-02f, 3.35870981e-02f, -5.35406545e-02f, 2.75770091e-02f, 6.96324781e-02f, -8.03066492e-02f,
  7.70414546e-02f, 2.14806318e-01f, 1.04961023e-01f, -1.13533303e-01f, -1.07451696e-02f, -1.05683841e-02f, 1.36371916e-02f, 4.32198029e-03f, 6.60105869e-02f, -5.47508486e-02f,
  1.75382778e-01f, 1.51618440e-02f, 3.28222327e-02f, 1.23876318e-01f, -6.72568902e-02f, 9.32590514e-02f, -8.64256453e-03f, 3.97289507e-02f, 1.31969243e-01f, 8.02540705e-02f,
  1.69946000e-01f, 9.39292237e-02f, -4.79895137e-02f, 3.13334353e-02f, 1.13845279e-03f, 9.99705866e-02f, 9.28492397e-02f, 9.86074209e-02f, 7.86072165e-02f, 2.76705455e-02f,
  -9.23897624e-02f, 6.04305565e-02f, -6.35104924e-02f, 1.11696199e-01f, 4.98845652e-02f, -4.44541648e-02f, -1.37888357e-01f, 1.04325665e-02f, -2.07873568e-01f, 2.07352519e-01f,
  -1.04125589e-01f, 2.62111519e-02f, -1.55106455e-01f, 3.95725435e-03f, -2.59039432e-01f, -1.29232422e-01f, 7.23630935e-02f, 7.68756941e-02f, -1.49475243e-02f, 1.83806606e-02f,
  -9.88959670e-02f, 2.28099879e-02f, -1.48802847e-01f, 8.05852190e-02f, 1.23206288e-01f, 5.95559776e-02f, 1.24786027e-01f, -6.38569742e-02f, 2.28623837e-01f, 2.92983763e-02f,
  5.27396053e-02f, 7.16475844e-02f, 6.89407485e-03f, 5.85626513e-02f, 3.62356310e-03f, 1.28226668e-01f, 1.16253383e-02f, -2.46139038e-02f, -1.20288245e-01f, -7.20328167e-02f,
  3.40375714e-02f, -1.55394450e-01f, -2.89880000e-02f, -1.15694262e-01f, 3.53216454e-02f, -5.01277372e-02f, -1.45580769e-02f, -1.06025159e-01f, 8.47526789e-02f, -2.60804966e-02f,
  2.35082004e-02f, -1.31200366e-02f, 8.85312259e-03f, 6.02431074e-02f, -2.32564844e-02f, -7.19697699e-02f, 5.23866862e-02f, 4.11415957e-02f, 3.81201655e-02f, -1.09023089e-02f,
  -3.61236408e-02f, 2.35381331e-02f, -1.81993153e-02f, -2.86096390e-02f, -7.78759792e-02f, 5.07855527e-02f, 1.88385751e-02f, -4.48380783e-03f, -5.85610978e-02f, -6.92731217e-02f,
  1.21295244e-01f, -4.20767143e-02f, 1.07424356e-01f, 9.50833485e-02f, 2.93472130e-02f, -3.87010328e-03f, 5.58322258e-02f, -3.03207841e-02f, -3.05798147e-02f, -8.11934024e-02f,
  5.42559177e-02f, -2.80989353e-02f, -4.66148816e-02f, 8.21017250e-02f, 4.65026237e-02f, -9.60714519e-02f, 1.96652096e-02f, 2.07452159e-02f, 1.25335148e-02f, 1.46124005e-01f,
  3.62138525e-02f, -1.35169376e-03f, -3.33744958e-02f, 1.70493871e-02f, -2.89092157e-02f, 1.05767123e-01f, -4.39587831e-02f, 7.11092874e-02f, 6.17317483e-02f, 3.53361554e-02f,
  1.02053612e-01f, -5.16594909e-02f, 1.09767608e-01f, -3.65096405e-02f, -1.01492954e-02f, 7.71658123e-02f, 3.08772512e-02f, -4.00424860e-02f, -2.78292913e-02f, 7.65929669e-02f,
  1.30873164e-02f, -2.48266454e-03f, 2.39048358e-02f, 2.24735215e-02f, -3.42011675e-02f, -2.89602429e-02f, -4.83904183e-02f, -4.85005416e-02f, 7.22347125e-02f, -5.46422601e-02f,
  7.02218562e-02f, -6.54760301e-02f, -1.28750339e-01f, 1.61940217e-01f, -1.26262844e-01f, -3.18042397e-01f, -2.36197665e-01f, 1.37305081e-01f, -1.38634399e-01f, -6.62165061e-02f,
  -3.24103311e-02f, -1.98190391e-01f, -1.77078649e-01f, 9.43604633e-02f, 1.16978601e-01f, -1.35577649e-01f, 1.98173616e-02f, -6.48371428e-02f, 6.96335733e-02f, 1.76222262e-03f,
  1.76931024e-01f, 2.22703278e-01f, 2.01887846e-01f, 2.00887769e-01f, -2.13880427e-02f, 1.53973237e-01f, 1.57055542e-01f, 6.33144975e-02f, 2.54245579e-01f, 7.35891378e-03f,
  -8.15488547e-02f, -4.99022640e-02f, -9.02651623e-02f, -4.98731472e-02f, -1.25260055e-02f, 3.18928175e-02f, -1.97149310e-02f, 8.91928561e-03f, 6.40019253e-02f, 1.64193418e-02f,
  -1.08607143e-01f, 7.44884983e-02f, 3.32173593e-02f, -3.46442014e-02f, 1.36536676e-02f, 4.45469096e-02f, 2.91131926e-03f, -5.03091188e-03f, -6.27158433e-02f, 6.73304722e-02f,
  -5.81078082e-02f, -1.00814539e-03f, 4.70567159e-02f, 2.35231686e-02f, 6.80322796e-02f, 4.30477560e-02f, -1.03326794e-03f, -3.86213176e-02f, -9.49460790e-02f, 5.21135665e-02f,
  3.83688509e-02f, -3.65886390e-02f, 9.71319433e-03f, 2.23703571e-02f, -5.98767512e-02f, -1.32661331e-02f, 4.27889191e-02f, 1.60268601e-02f, -6.47696033e-02f, -2.75102612e-02f,
  -1.94448978e-04f, 5.67849129e-02f, -4.09742631e-02f, 1.11233303e-02f, 5.24681434e-02f, 1.72407720e-02f, 8.90555885e-03f, -2.19475422e-02f, -2.30445098e-02f, -3.12703401e-02f,
  -3.74847092e-02f, 5.16406260e-02f, -6.45156056e-02f, 3.53199504e-02f, -2.75325887e-02f, 4.93754894e-02f, 1.00984231e-01f, 6.51781494e-03f, 1.05643598e-02f, -4.58563827e-02f,
  9.14041027e-02f, 6.94989637e-02f, 2.13650707e-02f, -1.42474324e-02f, -2.12702733e-02f, -1.32966846e-01f, -5.23291901e-02f, 4.53003794e-02f, 4.00733091e-02f, 3.66790928e-02f,
  8.27480629e-02f, 4.61630374e-02f, -9.46772657e-03f, -3.67217846e-02f, 7.38993436e-02f, -7.55555853e-02f, 2.37164423e-02f, 2.01143865e-02f, -6.26365170e-02f, 3.40639837e-02f,
  8.55847150e-02f, -1.21381573e-01f, -1.18680876e-02f, -9.13252383e-02f, 9.50336903e-02f, -4.92221005e-02f, 1.57901701e-02f, 6.15921356e-02f, 5.85936084e-02f, 1.84793733e-02f,
  -2.02596560e-01f, -9.05519258e-03f, -1.50785908e-01f, -4.93679345e-02f, -9.99405235e-02f, -1.57481879e-01f, -1.79592192e-01f, 2.07030606e-02f, -7.57038593e-02f, 8.43804255e-02f,
  1.32804781e-01f, -1.53908446e-01f, 1.64480925e-01f, 1.47412391e-02f, -1.28157154e-01f, 2.16740370e-01f, -1.61767304e-01f, -1.02642410e-01f, -6.51016310e-02f, -1.14580318e-01f,
  -1.39268041e-01f, -4.62539569e-02f, 5.76334931e-02f, -8.29476956e-03f, -2.18557224e-01f, -1.09378591e-01f, -4.30852510e-02f, 8.92309770e-02f, -1.02613300e-01f, -4.88205366e-02f,
  9.32397842e-02f, 7.81514421e-02f, -1.35509646e-03f, 1.00496039e-01f, -7.54240081e-02f, -3.08983717e-02f, -7.75832236e-02f, 8.51954669e-02f, 4.02222713e-03f, -8.77197757e-02f,
  -1.39681309e-01f, 9.54426378e-02f, -6.42651469e-02f, 9.06308591e-02f, -1.11618914e-01f, -4.90410905e-03f, 5.72201191e-03f, 2.98068598e-02f, 1.01967894e-01f, -8.75402167e-02f,
  -3.72998491e-02f, -5.29080816e-02f, 2.11573895e-02f, 5.38125746e-02f, -1.99257322e-02f, -1.90027636e-02f, -2.76441313e-02f, -4.36406657e-02f, 1.61275044e-02f, -7.58085623e-02f,
  -3.94089073e-02f, 2.06876919e-02f, 6.75120875e-02f, 9.65730399e-02f, 1.78708620e-02f, 1.07671715e-01f, 3.68311419e-03f, -8.34937021e-02f, -5.90966307e-02f, 5.06519191e-02f,
  2.06527058e-02f, -6.16102889e-02f, 4.35417108e-02f, -1.34671852e-01f, 2.53880750e-02f, -9.56707597e-02f, -4.57453579e-02f, -8.02803901e-04f, 6.87826797e-03f, -2.65318900e-02f,
  1.05206102e-01f, -4.47632447e-02f, 4.47912589e-02f, 4.76327352e-02f, -1.63621735e-02f, -1.80799868e-02f, 9.99482200e-02f, -4.40383069e-02f, 9.18553844e-02f, -8.96919370e-02f,
  -1.42956421e-01f, 5.79342581e-02f, 1.24763049e-01f, -3.35597731e-02f, 3.57736722e-02f, -6.25579730e-02f, -8.23800489e-02f, -8.96120723e-03f, -2.09699720e-02f, -1.86557882e-02f,
  -1.08005106e-01f, -7.71900937e-02f, 3.41615523e-04f, -1.23915812e-02f, 5.32677732e-02f, 1.29706813e-02f, -6.72124475e-02f, 2.34046336e-02f, 7.24321082e-02f, 7.95484930e-02f,
  4.23149671e-03f, -2.77510975e-02f, -2.67046876e-02f, 1.30451135e-02f, 5.02716973e-02f, -1.35285929e-02f, -2.03169398e-02f, 8.15912709e-03f, -2.52410118e-02f, -2.61774212e-02f,
  -2.80162007e-01f, -3.43341865e-02f, -2.82272309e-01f, -1.17608093e-01f, -2.91786697e-02f, 2.33267378e-02f, -4.04131552e-03f, -7.53358975e-02f, -1.17953360e-01f, 2.56408423e-01f,
  6.08198978e-02f, -2.43271828e-01f, 1.04570247e-01f, 7.71813607e-03f, -3.52888435e-01f, 1.15652233e-01f, -1.40828431e-01f, 4.82080393e-02f, 5.28246090e-02f, -1.10024706e-01f,
  -1.16324559e-01f, 1.13190658e-01f, -5.82218133e-02f, 1.95811361e-01f, -1.30238503e-01f, 6.34844927e-03f, 1.58204496e-01f, 6.87731951e-02f, -2.68743988e-02f, -9.00327116e-02f,
  9.01474338e-03f, -4.85044383e-02f, -1.07855447e-01f, -2.18040086e-02f, -1.18977286e-01f, 1.57193206e-02f, 5.37433960e-02f, 1.20274343e-01f, -6.89919144e-02f, -1.17397621e-01f,
  -2.42043752e-02f, -8.46227705e-02f, 7.03882203e-02f, -6.36720434e-02f, 6.25235727e-03f, -2.17871275e-02f, 4.42420542e-02f, 3.16032059e-02f, -9.57134664e-02f, -1.02884643e-01f,
  -9.08525810e-02f, 8.37069005e-02f, 4.82628942e-02f, 2.07382124e-02f, -7.27632120e-02f, 7.36638978e-02f, 1.99524090e-02f, -1.23214135e-02f, 4.56637703e-02f, -1.17508084e-01f,
  -5.07756956e-02f, -2.70813946e-02f, -2.29264554e-02f, 1.14009090e-01f, -6.84050322e-02f, 1.04257084e-01f, 1.98760983e-02f, 8.79919007e-02f, -9.66517031e-02f, 8.33679438e-02f,
  -4.81081791e-02f, -3.70950773e-02f, -1.68727115e-02f, -1.72756203e-02f, -2.30810549e-02f, -2.68809181e-02f, -1.19665638e-01f, -3.72338258e-02f, -2.13174429e-02f, -2.72584651e-02f,
  1.26529746e-02f, -6.54280782e-02f, -3.16435210e-02f, 4.68410216e-02f, -2.28344128e-02f, -4.17661667e-02f, 8.35976154e-02f, 2.44875867e-02f, 9.72387940e-03f, 4.99184877e-02f,
  7.63136819e-02f, -1.34526927e-03f, 6.53680414e-02f, 3.14865261e-02f, 3.76860145e-03f, 6.66648373e-02f, 1.29375923e-02f, -8.22745636e-02f, 3.77202518e-02f, 5.09359874e-02f,
  -2.53596678e-02f, -6.39940565e-03f, 1.34211816e-02f, -2.08810288e-02f, 2.81817392e-02f, -6.76313639e-02f, 1.02169916e-01f, -5.66241406e-02f, -7.28932023e-02f, 3.42548229e-02f,
  5.55100888e-02f, -2.80606020e-02f, -5.75322285e-02f, 9.50117037e-02f, 4.14731316e-02f, -3.86000536e-02f, -2.44155545e-02f, -2.87269475e-03f, -5.12615517e-02f, -7.80379912e-03f,
  -3.63600671e-01f, 1.95951611e-01f, -1.00344203e-01f, 4.32807915e-02f, -9.22105461e-02f, 1.13064677e-01f, 7.09021017e-02f, -9.38149020e-02f, -1.63827673e-01f, 1.79822624e-01f,
  2.12793723e-01f, -2.60928363e-01f, 1.81528240e-01f, 1.67091653e-01f, -3.96604277e-02f, 2.69877523e-01f, 5.81171140e-02f, 1.07953869e-01f, 2.87382235e-03f, -1.15057319e-01f,
  -9.21075791e-02f, -1.84346866e-02f, -1.60078667e-02f, 6.07658103e-02f, -5.82590811e-02f, -1.36439845e-01f, 8.86863172e-02f, -1.00036241e-01f, 1.28079191e-01f, 1.14339562e-02f,
  -1.86104134e-01f, -1.76728234e-01f, -1.82236880e-01f, -1.59208253e-01f, -1.70035101e-02f, -1.26785040e-01f, -9.58117843e-02f, 4.77966852e-02f, -1.45053463e-02f, 7.23459944e-02f,
  5.52452281e-02f, -4.55870852e-02f, -8.09321254e-02f, -3.56552824e-02f, -8.17389321e-03f, -3.58771980e-02f, -4.09841649e-02f, 9.10899192e-02f, 9.12263617e-02f, 5.37787564e-03f,
  -5.64969964e-02f, 3.59272398e-02f, -1.38792964e-02f, 1.73549820e-02f, -3.53959687e-02f, -7.34105520e-03f, 7.65559152e-02f, -8.85689855e-02f, -6.47826418e-02f, -1.12402206e-02f,
  -6.51663542e-02f, 6.63404241e-02f, -1.02487080e-01f, 5.10733612e-02f, -1.45953773e-02f, 1.99905615e-02f, 1.09275267e-01f, 2.64447834e-02f, -9.32799280e-03f, -1.47234257e-02f,
  -4.59205881e-02f, -4.32670526e-02f, -5.49511649e-02f, 6.08114786e-02f, 5.18566892e-02f, 3.93028744e-02f, 1.75156612e-02f, -1.26742899e-01f, 7.94523954e-02f, 5.95458262e-02f,
  4.12563495e-02f, -1.69830788e-02f, -1.11626036e-01f, -6.15658350e-02f, -5.48082665e-02f, -2.89089642e-02f, -1.27580374e-01f, -3.53499614e-02f, -3.33385495e-03f, -1.55123537e-02f,
  -5.50869294e-02f, -2.98262566e-01f, -5.89099117e-02f, -1.13686286e-01f, -5.75973727e-02f, -9.92051736e-02f, 3.22404578e-02f, -1.32105239e-02f, -3.25889774e-02f, -1.26762345e-01f,
  8.37778375e-02f, 5.44823222e-02f, -7.14802593e-02f, 1.02024727e-01f, 1.39716612e-02f, 5.38407043e-02f, 1.09433681e-01f, -2.85520144e-02f, -4.48403172e-02f, -1.02307498e-01f,
  2.17927732e-02f, -2.41768807e-02f, 3.94719392e-02f, -8.30625221e-02f, -3.38869281e-02f, 9.03558433e-02f, -1.37766637e-03f, -5.91190867e-02f, -6.17168881e-02f, -3.19962157e-03f,
  1.16641767e-01f, -3.63293588e-01f, -2.25787669e-01f, -4.49078381e-02f, 2.38683894e-01f, 1.20568708e-01f, 1.46091640e-01f, -9.75303650e-02f, -1.33690119e-01f, -6.33180588e-02f,
  9.00309011e-02f, 1.55629795e-02f, -1.36099085e-01f, 4.42958847e-02f, 2.55700201e-01f, -1.87973320e-01f, 1.34195775e-01f, -1.24188252e-02f, -1.45549878e-01f, -9.32759717e-02f,
  1.76030114e-01f, 1.73809394e-01f, 3.60422656e-02f, 1.51892498e-01f, 1.07097946e-01f, -1.44238293e-01f, 1.06263168e-01f, 3.38933691e-02f, 2.30848670e-01f, 2.46828482e-01f,
  6.40726089e-02f, -4.47128080e-02f, 2.66768504e-02f, -1.52565399e-02f, 3.82535495e-02f, -2.87409388e-02f, -4.53616679e-02f, 3.07710133e-02f, 6.82013258e-02f, -1.10239558e-01f,
  6.00226596e-03f, -1.60138234e-02f, -5.45524582e-02f, 2.97342129e-02f, -3.44544575e-02f, -3.38183269e-02f, -2.67776772e-02f, -3.99106275e-03f, -4.82373945e-02f, -5.34954071e-02f,
  -1.88217044e-01f, -3.82758714e-02f, -2.58703679e-02f, 4.88490090e-02f, -1.12462223e-01f, -7.42832199e-02f, -2.79021710e-02f, -8.75955224e-02f, -2.84267906e-02f, 3.28367874e-02f,
  -4.08697575e-02f, 7.96559383e-04f, -9.34850574e-02f, 1.22719845e-02f, -2.11028829e-02f, -6.99482188e-02f, 1.29677400e-01f, -2.71213092e-02f, 8.72607622e-03f, -8.03821459e-02f,
  -2.03734692e-02f, -7.17923492e-02f, 1.18375067e-02f, 2.66634505e-02f, 3.59757729e-02f, -1.30714532e-02f, 5.54298237e-02f, 2.76821777e-02f, -2.76083555e-02f, -3.24145406e-02f,
  5.89627326e-02f, 3.96059006e-02f, 3.34902033e-02f, -1.05150212e-02f, -1.27736283e-02f, 7.97440782e-02f, 1.04455948e-01f, -5.77405691e-02f, -2.27013566e-02f, -3.82068679e-02f,
  -3.68119404e-02f, -2.27643937e-01f, -3.26083228e-02f, 8.08843225e-02f, -8.26048031e-02f, -2.23852117e-02f, 2.38691699e-02f, -2.41743419e-02f, 4.69402876e-04f, 6.98786825e-02f,
  6.86636716e-02f, -1.31750628e-02f, -5.67223206e-02f, 3.15599404e-02f, 2.12905705e-02f, 5.46524636e-02f, -4.09638174e-02f, -7.08319154e-03f, -3.97912338e-02f, 3.86991985e-02f,
  -7.30649158e-02f, -7.15786144e-02f, 7.56065771e-02f, -8.99004564e-02f, 3.20152752e-02f, 3.13873366e-02f, 2.09066384e-02f, 4.26108986e-02f, 4.26968224e-02f, -9.25320312e-02f,
  9.75746438e-02f, -1.98396653e-01f, -1.72760338e-01f, -9.86252427e-02f, -1.71019230e-02f, -9.15002078e-02f, -1.21377289e-01f, -1.86124772e-01f, 2.51733903e-02f, -1.24656178e-01f,
  -8.65254477e-02f, 4.26120386e-02f, 1.81598097e-01f, -2.27495566e-01f, 3.50044668e-01f, 1.80902764e-01f, -1.53423935e-01f, -1.47486135e-01f, -7.04022646e-02f, -2.31518447e-01f,
  -1.21728979e-01f, -2.54908860e-01f, -4.72413376e-02f, -2.16365337e-01f, -1.17112696e-01f, -6.97660148e-02f, 1.38965249e-01f, -1.42941680e-02f, -1.45243108e-01f, 9.64432359e-02f,
  1.62839163e-02f, -1.22358687e-02f, -1.42589465e-01f, -8.74032453e-02f, 4.77235019e-02f, -9.40467324e-03f, -8.49551633e-02f, 1.51194841e-01f, -3.40361558e-02f, 7.21512362e-02f,
  7.10211694e-02f, -6.18617572e-02f, -6.06462220e-03f, 8.15388858e-02f, 1.68088917e-02f, -2.60987575e-03f, 1.07562169e-01f, 7.68043622e-02f, -4.68299873e-02f, 5.27072325e-02f,
  -5.50195463e-02f, -7.03424960e-02f, 5.12401126e-02f, -2.29697786e-02f, 9.92152914e-02f, -6.38189465e-02f, -2.97113843e-02f, 3.83771248e-02f, -9.45114344e-02f, 2.93462593e-02f,
  -4.89136028e-06f, -3.48979351e-03f, 2.85223443e-02f, -2.08253525e-02f, 3.99627462e-02f, -7.83660188e-02f, 2.40649469e-02f, -3.26713547e-02f, 1.31444871e-01f, -3.11293192e-02f,
  2.59339511e-02f, -4.26489040e-02f, 3.95196266e-02f, 2.01732870e-02f, 5.21329977e-02f, 1.74285546e-02f, -2.36540828e-02f, 4.68570292e-02f, 9.44743026e-03f, -1.75383855e-02f,
  8.29005092e-02f, -6.46781102e-02f, 7.64308572e-02f, -4.28661332e-02f, -5.48593961e-02f, 4.16795574e-02f, -1.31823374e-02f, -5.54270223e-02f, 1.07431579e-02f, 1.97111703e-02f,
  -2.62915697e-02f, -1.62562698e-01f, 8.98308828e-02f, -1.12247923e-02f, -4.02085856e-02f, -3.36302035e-02f, -1.78325400e-02f, -1.55678550e-02f, 1.49891943e-01f, 3.12019363e-02f,
  1.57201309e-02f, 9.81145650e-02f, -2.15158798e-02f, 1.35407876e-02f, -8.00413545e-03f, -7.64029920e-02f, 5.59613295e-02f, 7.07194954e-02f, 6.47759959e-02f, -9.03378054e-02f,
  2.80408654e-02f, -1.66326948e-02f, 1.95285790e-02f, -2.10300437e-03f, -6.68535531e-02f, 5.39055355e-02f, -6.12774938e-02f, -6.99504539e-02f, 1.04790656e-02f, -5.57930321e-02f,
  1.68037519e-01f, -5.82180545e-02f, -1.97328448e-01f, 2.11545695e-02f, 1.73351225e-02f, -1.33489475e-01f, -6.28942400e-02f, -3.52449119e-02f, -1.02736853e-01f, 6.70653507e-02f,
  9.66548696e-02f, 4.50619496e-03f, 4.57861694e-03f, 1.91669554e-01f, 2.42477238e-01f, -1.26969084e-01f, 2.19158858e-01f, -2.88796034e-02f, 3.08921523e-02f, 1.92510858e-01f,
  1.23254731e-01f, 2.55922019e-01f, 1.05878189e-01f, 1.99119240e-01f, 6.26545101e-02f, 6.53782040e-02f, 2.34100237e-01f, 4.37621772e-02f, 1.74876690e-01f, 8.92652422e-02f,
  3.67727913e-02f, -1.78689789e-02f, -4.02694680e-02f, 2.06320193e-02f, 1.72852855e-02f, 8.57053474e-02f, -7.93774500e-02f, 1.83782959e-03f, 3.46120670e-02f, -5.71540706e-02f,
  -8.08216855e-02f, 8.36369619e-02f, -3.25651988e-02f, -3.81623805e-02f, 7.63100013e-02f, -2.34904233e-02f, 7.07188100e-02f, -1.00215003e-01f, -7.51208514e-02f, 1.20815344e-01f,
  -9.79949459e-02f, -1.18779249e-01f, 5.37195951e-02f, -2.93787029e-02f, 4.35655490e-02f, 2.80544460e-02f, -3.48157808e-02f, -2.17806790e-02f, 7.00157741e-03f, -4.55454167e-04f,
  2.44899318e-02f, 3.98302786e-02f, -4.38575111e-02f, -6.55636117e-02f, -3.68763916e-02f, 3.28668095e-02f, -8.63460973e-02f, -3.89277972e-02f, -1.36655672e-02f, 3.70197222e-02f,
  1.12207187e-02f, -5.24233617e-02f, 2.41573397e-02f, -4.85439897e-02f, 1.78721026e-02f, 2.81359553e-02f, -5.90704270e-02f, -3.63570005e-02f, 9.79928486e-03f, -9.50832909e-04f,
  -8.14347044e-02f, 3.53269204e-02f, -2.89577395e-02f, -7.18756542e-02f, -6.44468442e-02f, -6.04100749e-02f, 5.44777885e-02f, 2.11498346e-02f, -7.34163001e-02f, 4.83674742e-02f,
  2.24852022e-02f, 1.50740415e-01f, -6.08898960e-02f, -8.29067528e-02f, 3.41519192e-02f, 1.04160763e-01f, -5.87193742e-02f, 4.72818352e-02f, 2.03197170e-03f, -3.12703126e-03f,
  1.05021074e-01f, -8.53759348e-02f, 6.36229292e-02f, 9.58394930e-02f, -8.64926446e-03f, 9.62581113e-02f, 1.10025294e-01f, -9.23055783e-02f, -7.46689271e-03f, 1.34551700e-03f,
  -4.53238897e-02f, -6.05907897e-03f, -3.75498161e-02f, 4.01986353e-02f, -2.16015689e-02f, 1.44596742e-02f, -5.47038019e-02f, -2.26186756e-02f, 7.27339974e-03f, 2.71825381e-02f,
  7.26882592e-02f, 2.79794127e-01f, 4.16292585e-02f, 1.53736725e-01f, -1.01911582e-01f, -1.57578602e-01f, -2.50025876e-02f, 1.10296465e-01f, -6.05500443e-03f, 1.08983099e-01f,
  2.76357830e-02f, 1.25813410e-01f, 8.28346014e-02f, 3.76148671e-02f, 5.21618314e-02f, -7.58940950e-02f, 2.16556415e-01f, 9.79745686e-02f, -7.78112039e-02f, 1.70701593e-01f,
  1.24333305e-02f, 1.56339318e-01f, 1.52722120e-01f, 1.16481252e-01f, 1.21177882e-02f, 3.89799774e-02f, 2.02136427e-01f, -7.12616444e-02f, 1.71225816e-02f, -1.15883335e-01f,
  -8.82669538e-02f, 3.67845385e-03f, -1.01940213e-02f, -2.37775259e-02f, -6.97369277e-02f, -8.70750025e-02f, -7.73174688e-02f, -2.33706888e-02f, -8.64895806e-02f, -4.63999212e-02f,
  9.33785550e-03f, 4.11727391e-02f, 9.22163203e-03f, 2.23804582e-02f, -4.18289416e-02f, 5.72900064e-02f, -4.76931669e-02f, -7.82416482e-03f, -6.28350303e-02f, -1.86338779e-02f,
  -3.13341990e-02f, -5.84341921e-02f, -5.26130991e-03f, -8.33016559e-02f, -5.72734475e-02f, 7.91189298e-02f, 2.38513555e-02f, -1.53638087e-02f, -8.53477803e-04f, -1.16316313e-02f,
  4.95264456e-02f, 1.39422622e-02f, -4.50095572e-02f, -3.28563862e-02f, -2.01792885e-02f, -7.55478144e-02f, 3.89952250e-02f, 1.82462130e-02f, -1.95037317e-03f, 2.09839474e-02f,
  -9.67589952e-03f, -1.37743484e-02f, 1.58495624e-02f, 7.20007792e-02f, -1.31981922e-02f, 9.33741331e-02f, -5.74349537e-02f, -1.02144517e-01f, -9.65171773e-03f, 6.44330494e-03f,
  4.78488430e-02f, 4.78912629e-02f, -2.36360747e-02f, 6.16869554e-02f, 3.94869875e-03f, -3.13902274e-02f, 7.31328204e-02f, 3.17602009e-02f, -4.93982472e-02f, -2.45582126e-02f,
  9.33454484e-02f, 2.11882144e-01f, -4.66044173e-02f, -1.56962201e-01f, -5.51304035e-02f, -9.35338554e-04f, 4.58997041e-02f, -9.95352268e-02f, 1.08315833e-01f, 2.68944483e-02f,
  -4.85504977e-02f, -6.94377869e-02f, -5.81073985e-02f, 5.99358417e-02f, -5.10640070e-02f, 2.48247087e-02f, 6.57624900e-02f, 5.45646958e-02f, 8.88353735e-02f, 5.62398694e-02f,
  1.19030491e-01f, -1.55859478e-02f, -3.43823049e-04f, -2.95959190e-02f, 2.33200360e-02f, -4.75454889e-02f, 1.90524496e-02f, 7.70927817e-02f, -7.31247365e-02f, 1.37690201e-01f,
  1.54326633e-01f, -1.79725345e-02f, -1.41362637e-01f, -9.75623876e-02f, -1.32006168e-01f, -2.69287616e-01f, -2.83260882e-01f, 2.73431484e-02f, -1.45267412e-01f, -1.37808368e-01f,
  4.92775477e-02f, -1.29909173e-01f, 2.33793799e-02f, 7.70389885e-02f, 2.08419308e-01f, 1.03412747e-01f, 1.14028864e-02f, -6.30505010e-02f, 4.31905538e-02f, 1.38389215e-01f,
  1.62682265e-01f, 8.71660113e-02f, 1.89240903e-01f, 1.91499650e-01f, 4.79740743e-03f, 4.59503569e-02f, 8.20660666e-02f, 5.06219640e-03f, 8.90720636e-02f, 1.01696044e-01f,
  8.55131596e-02f, 1.27805844e-01f, -4.50383732e-03f, -1.69747956e-02f, 9.15059671e-02f, 4.31014821e-02f, -6.12424985e-02f, -2.22715680e-02f, 3.36189903e-02f, 3.42858862e-03f,
  1.44698247e-02f, -2.90965401e-02f, 4.80538905e-02f, -5.42649627e-02f, -1.24537192e-01f, -1.00195296e-01f, -7.88240433e-02f, -6.59377724e-02f, -1.26845047e-01f, 8.97386521e-02f,
  -8.98072124e-02f, -1.12094451e-02f, -7.89776668e-02f, -8.68822560e-02f, -2.63480395e-02f, -5.14858700e-02f, 1.04275323e-03f, -8.15596581e-02f, -2.18795091e-02f, -1.20672239e-02f,
  -1.77307334e-02f, -1.47784520e-02f, 6.01937510e-02f, -4.88417335e-02f, 3.82231176e-02f, -7.41199329e-02f, 2.75070983e-04f, -1.99666135e-02f, -1.26544371e-01f, 3.62962298e-02f,
  -8.25376958e-02f, -7.22185448e-02f, -1.69662517e-02f, 2.99805813e-02f, 9.24671069e-02f, 4.33625691e-02f, 5.31235859e-02f, 1.02045998e-01f, -6.63294569e-02f, -5.89303635e-02f,
  3.84693369e-02f, 1.16978418e-02f, -6.32204860e-02f, 6.88836649e-02f, 4.81149592e-02f, 2.61949822e-02f, 1.08784541e-01f, -4.92739193e-02f, 3.47822718e-02f, -6.83040321e-02f,
  5.66155883e-03f, 2.11115390e-01f, 3.07510067e-02f, 1.00564351e-02f, 5.88695742e-02f, 7.86619261e-02f, 1.82882138e-02f, 3.26745212e-02f, 4.16017361e-02f, 6.49446696e-02f,
  -4.91033867e-02f, -5.28956987e-02f, 5.03258593e-02f, -8.22900049e-03f, -5.77876233e-02f, -8.90872851e-02f, -2.09362488e-02f, -5.03149107e-02f, -9.04662982e-02f, 1.43290334e-03f,
  8.00756216e-02f, 2.95143016e-02f, -9.77777168e-02f, -3.51794772e-02f, -8.20308574e-04f, -2.34616604e-02f, 2.58198455e-02f, 3.31007056e-02f, -2.29261741e-02f, -6.01265915e-02f,
  -5.41802704e-01f, 2.35148683e-01f, 3.11614782e-01f, -4.58970256e-02f, 3.46536632e-03f, 8.40648189e-02f, 5.91626279e-02f, 1.77104667e-01f, 1.90178022e-01f, 2.87027419e-01f,
  1.97606459e-01f, 1.37142345e-01f, 1.63234547e-01f, 7.40468428e-02f, -1.69808343e-01f, 1.62710845e-02f, -1.50085256e-01f, -6.38475493e-02f, -4.97792326e-02f, -1.34457320e-01f,
  -2.48994544e-01f, -4.58901785e-02f, 3.03316191e-02f, 2.89185084e-02f, 7.95383193e-03f, -9.63516533e-03f, -1.99389100e-01f, 2.00461686e-01f, -9.06985700e-02f, 2.19136119e-01f,
  -2.26567969e-01f, 1.39782891e-01f, -3.30541655e-02f, 5.08676544e-02f, -1.47547886e-01f, -1.02397911e-01f, -9.89111364e-02f, -4.16983999e-02f, 1.20717557e-02f, -1.97792556e-02f,
  -4.94174212e-02f, 9.55300257e-02f, 6.20213263e-02f, 4.76013832e-02f, 4.18426096e-02f, 1.00142978e-01f, 4.50064987e-02f, 5.18259034e-02f, 7.63257891e-02f, 1.29226819e-01f,
  2.27085669e-02f, -6.99415132e-02f, -2.85081323e-02f, 4.19036634e-02f, 4.30952907e-02f, 1.44849584e-01f, 1.35051524e-02f, 4.84660715e-02f, -4.79699634e-02f, -6.05374109e-04f,
  2.21980736e-02f, -1.19932227e-01f, 6.67249188e-02f, 2.50817612e-02f, 8.15458074e-02f, -5.93850538e-02f, 2.89035421e-02f, 6.97782729e-03f, -1.52840745e-02f, -6.68962002e-02f,
  -1.15819097e-01f, -3.01239304e-02f, 5.17705791e-02f, -4.21364084e-02f, -8.90722796e-02f, -2.31266394e-02f, 1.04901856e-02f, 7.33138844e-02f, -1.43576995e-01f, -2.76172981e-02f,
  2.24149898e-02f, 8.41490403e-02f, 1.32753491e-01f, -9.09023508e-02f, 3.05355377e-02f, -5.47405705e-03f, 3.75155956e-02f, 9.45166568e-04f, -4.43937927e-02f, 3.22499312e-02f,
  -3.34768921e-01f, 3.59645598e-02f, -2.87409034e-02f, 1.29711181e-01f, 4.80034836e-02f, -5.42845018e-02f, -5.56992441e-02f, -1.49977297e-01f, 2.04011947e-02f, -9.18769613e-02f,
  -6.87633734e-03f, 1.03692263e-01f, -2.05254592e-02f, 5.97617142e-02f, -2.42988858e-02f, 2.79775541e-02f, -1.28825530e-01f, -4.72867563e-02f, -2.85202190e-02f, -6.42396435e-02f,
  8.92281905e-02f, -7.80364275e-02f, 3.55244726e-02f, -8.76045227e-02f, -5.79586141e-02f, 4.84854318e-02f, -1.08797774e-01f, -2.91129630e-02f, 7.03263804e-02f, 6.93263337e-02f,
  -2.13424694e-02f, 2.35312089e-01f, 2.02565894e-01f, 1.24355406e-01f, 7.98864439e-02f, -2.09296122e-01f, -1.57011941e-01f, 5.93384020e-02f, -1.20954894e-01f, -9.73600671e-02f,
  -6.59308285e-02f, 6.19809180e-02f, -2.77873669e-02f, -1.25489712e-01f, -4.19286400e-01f, -8.54836330e-02f, -2.32058302e-01f, -7.15939701e-02f, 5.91251366e-02f, 1.09427661e-01f,
  -1.28632039e-01f, -5.06929010e-02f, 8.18712786e-02f, 2.61037797e-01f, 3.11619729e-01f, 1.67200640e-01f, -1.91013496e-02f, 1.30037755e-01f, 7.64126703e-02f, -4.26749773e-02f,
  -1.46752894e-01f, 9.62870754e-03f, -5.03594689e-02f, -5.15586920e-02f, -1.47260845e-01f, -3.49355638e-02f, -1.15937240e-01f, -5.00423200e-02f, -4.94382419e-02f, -5.31468429e-02f,
  -2.08797436e-02f, -7.92198554e-02f, 8.78562853e-02f, 8.96074995e-02f, -7.65995234e-02f, 3.41517366e-02f, 2.25630123e-02f, 4.38596271e-02f, -1.48755619e-02f, 9.67024863e-02f,
  1.05329834e-01f, -5.73896617e-02f, -8.85719210e-02f, -1.42966226e-01f, -1.71844270e-02f, -9.78751928e-02f, 3.48875970e-02f, -3.94209102e-02f, 9.71287210e-03f, -5.68547025e-02f,
  7.44841248e-02f, -1.23590097e-01f, 4.05582860e-02f, 9.62088257e-02f, 8.16949084e-03f, -5.49398474e-02f, 3.89419757e-02f, -6.96377754e-02f, -4.57492582e-02f, -3.92169729e-02f,
  -1.20820954e-01f, 1.87937189e-02f, 1.28105417e-01f, 6.62244037e-02f, 3.97117473e-02f, 4.50033247e-02f, 4.24595065e-02f, 2.48843450e-02f, -4.80234623e-02f, 8.66433233e-02f,
  -1.02027886e-01f, -4.77659702e-02f, -2.32115034e-02f, -6.37446195e-02f, -7.28440583e-02f, 4.43141796e-02f, 1.00627713e-01f, -8.35953504e-02f, 3.68344621e-03f, 8.34667124e-03f,
  -2.40980193e-01f, 6.59979973e-03f, -3.37400846e-02f, -1.12693377e-01f, -5.17800339e-02f, -1.31379023e-01f, -5.26984632e-02f, -4.16412242e-02f, -1.28609344e-01f, 2.02368889e-02f,
  -1.20133512e-01f, -1.15411030e-03f, 1.42603135e-02f, -6.15404174e-02f, -1.36248618e-01f, -1.24825425e-01f, -6.83963820e-02f, -3.67781557e-02f, -9.89772752e-02f, 6.91958591e-02f,
  1.15888370e-02f, -3.82004376e-03f, -9.95677039e-02f, 3.15340236e-02f, -4.68504503e-02f, -1.45746037e-01f, 3.17141451e-02f, -7.88532011e-03f, 7.65392929e-02f, -9.21190307e-02f,
  1.00757882e-01f, -3.86579722e-01f, -2.32649833e-01f, -1.03340102e-02f, 1.87217612e-02f, -2.35892266e-01f, -2.74259180e-01f, -9.89208594e-02f, 8.67175907e-02f, -1.92062169e-01f,
  2.95249186e-02f, -1.67495012e-01f, -1.74491227e-01f, -3.80376838e-02f, 2.39824966e-01f, 9.85151157e-03f, 4.81238216e-02f, 1.57498866e-01f, 1.78951025e-01f, -6.56069741e-02f,
  1.84093595e-01f, 1.43362343e-01f, -4.65557426e-02f, 7.24047273e-02f, -1.38742149e-01f, 6.99678659e-02f, 3.97473723e-02f, -1.18444666e-01f, 2.22306466e-03f, 6.11719862e-02f,
  -2.70703621e-02f, -3.16556394e-02f, -5.34216054e-02f, -7.66821904e-03f, -1.15372568e-01f, -1.39114305e-01f, 1.10638104e-01f, 9.52561852e-03f, 7.52209425e-02f, 3.33800726e-02f,
  -1.13151759e-01f, 2.53687315e-02f, 6.93171099e-02f, 1.21159613e-01f, 5.49946958e-03f, 6.05931357e-02f, 2.03346964e-02f, 1.58107713e-01f, 1.26572442e-03f, -1.35297865e-01f,
  -4.79936711e-02f, -3.06041334e-02f, 9.27493162e-03f, 4.90500825e-03f, 3.66660617e-02f, -2.62536760e-02f, 1.79097764e-02f, -1.62592493e-02f, 5.00208586e-02f, 2.61397511e-02f,
  -1.37276668e-02f, 7.97259435e-03f, -5.54281399e-02f, 1.84802804e-02f, -2.13928800e-02f, 9.33948383e-02f, -3.50277349e-02f, -2.60562971e-02f, 1.01056658e-01f, 6.71091303e-02f,
  5.71683273e-02f, -8.76457691e-02f, 1.04652457e-01f, 3.87799144e-02f, -2.48817708e-02f, 8.09182134e-03f, 8.46082941e-02f, -6.71919575e-03f, -3.35202739e-02f, 1.03001542e-01f,
  -6.03242815e-02f, -7.59095624e-02f, -3.69069874e-02f, 2.23459136e-02f, -1.98557470e-02f, 3.87810357e-02f, 2.16700304e-02f, 3.28414142e-02f, -2.53936229e-03f, -5.28569445e-02f,
  -1.34753073e-02f, -2.83194065e-01f, -9.39050913e-02f, -2.47241613e-02f, 6.13249764e-02f, -8.38452801e-02f, 4.59888838e-02f, 2.15715300e-02f, -4.38615233e-02f, -1.22377567e-01f,
  -4.09023762e-02f, 1.35238513e-01f, -4.71254066e-02f, 1.25279695e-01f, 1.14701889e-01f, -2.72372011e-02f, -3.96021791e-02f, 8.15286711e-02f, 7.70282745e-02f, -6.70283586e-02f,
  -9.49480981e-02f, -1.33908344e-02f, 7.98281133e-02f, -4.79507372e-02f, 4.89005446e-02f, -3.08365766e-02f, 3.29798944e-02f, -9.17105190e-03f, -5.59576415e-02f, 3.20449322e-02f,
  1.07299909e-01f, -1.68805912e-01f, -2.63837308e-01f, -2.08133250e-01f, -5.29740714e-02f, -1.32529005e-01f, -2.27126285e-01f, -1.31780908e-01f, -1.20431617e-01f, -8.46802369e-02f,
  -1.52097136e-01f, -1.36946049e-02f, 9.08003524e-02f, -2.76320815e-01f, 2.75621582e-02f, 1.46012262e-01f, -2.99973339e-01f, -1.79791719e-01f, 2.08544098e-02f, -1.27619609e-01f,
  -6.41995668e-02f, -1.83745995e-01f, -1.82196662e-01f, -1.19421389e-02f, -1.56340063e-01f, -2.50797514e-02f, 1.96004525e-01f, -6.73435479e-02f, -1.07442394e-01f, 7.68412799e-02f,
  -9.19160098e-02f, -8.78672153e-02f, -3.70226465e-02f, 4.84116860e-02f, 5.96573530e-03f, 7.46224374e-02f, 6.59892559e-02f, 1.39689511e-02f, 6.21693907e-03f, -1.03250043e-02f,
  -3.27137474e-04f, 9.96431038e-02f, -1.36439994e-01f, 3.93723212e-02f, -6.11694604e-02f, -8.66490230e-02f, -3.26744653e-02f, 4.36354205e-02f, -3.56789939e-02f, -3.14073102e-03f,
  -1.55961126e-01f, 2.75498740e-02f, 6.87545314e-02f, 3.20195816e-02f, 3.45237367e-02f, -3.71835530e-02f, -1.23886904e-03f, 8.17219615e-02f, -5.14783189e-02f, -8.50835592e-02f,
  6.51861131e-02f, -3.32820043e-02f, 5.78475464e-03f, -6.42690435e-03f, -7.71602318e-02f, 3.27196009e-02f, 6.10892847e-02f, 6.91128597e-02f, -4.87165637e-02f, -6.24533333e-02f,
  2.66412683e-02f, -1.00405768e-01f, 1.54023583e-03f, 3.94885913e-02f, 4.30369377e-02f, 1.08000590e-02f, 8.26115012e-02f, -1.86332036e-02f, -1.08411074e-01f, -1.00158148e-01f,
  8.87262374e-02f, -9.58935916e-02f, -4.11597528e-02f, 4.90789488e-02f, -2.97153797e-02f, -1.26416788e-01f, -2.91900244e-02f, -5.90035021e-02f, -6.95960247e-04f, 5.19819818e-02f,
  2.59689670e-02f, -1.05909398e-03f, -1.95081567e-03f, -1.12422585e-01f, 5.46281971e-03f, -2.90370248e-02f, 1.14670312e-02f, -1.25935882e-01f, 8.60325694e-02f, -7.62254372e-02f,
  7.73940515e-03f, 2.57199649e-02f, 1.04770936e-01f, -1.14157483e-01f, -6.40941933e-02f, -1.99970957e-02f, 4.70624231e-02f, 3.35605852e-02f, 4.14370447e-02f, 4.22194563e-02f,
  4.40509953e-02f, -1.10818923e-01f, 5.67066148e-02f, 9.94533859e-03f, 2.95798518e-02f, 1.05578728e-01f, 4.51721773e-02f, -8.32573995e-02f, 1.44888476e-01f, -2.06563100e-02f,
  -2.76696116e-01f, 2.26761073e-01f, -6.90346211e-02f, 2.31456190e-01f, -3.04636836e-01f, 2.64926434e-01f, 2.67653644e-01f, -1.05599925e-01f, 8.98455977e-02f, 2.92214066e-01f,
  -6.75840378e-02f, -6.68597082e-03f, 1.22944918e-02f, 2.46508926e-01f, -1.65700078e-01f, 1.62617326e-01f, 1.69435993e-01f, 2.14086950e-01f, -2.52709724e-02f, 3.24620530e-02f,
  1.92154516e-02f, 8.22038725e-02f, 4.53367420e-02f, -3.19742821e-02f, -9.27478001e-02f, -1.77521005e-01f, -4.24799174e-02f, -1.80598989e-01f, 1.10528164e-01f, -1.89951956e-01f,
  -1.49033576e-01f, -1.79344133e-01f, -1.57020628e-01f, -1.16197109e-01f, -6.14603981e-02f, -2.70627858e-03f, 6.39604256e-02f, -9.38540790e-03f, -1.12215959e-01f, 8.73978995e-03f,
  6.62219226e-02f, 1.41243180e-02f, -5.68918772e-02f, -2.84738708e-02f, -5.61988614e-02f, -9.57522243e-02f, 2.69866902e-02f, -8.48019719e-02f, 8.86986498e-03f, -1.21150330e-01f,
  -5.76140545e-02f, -7.29203597e-02f, 6.23157769e-02f, 1.06909081e-01f, -6.04896843e-02f, -1.00004273e-02f, 4.53473739e-02f, -3.94435227e-02f, 8.62738341e-02f, -5.82609102e-02f,
  -1.15274988e-01f, 3.84632163e-02f, -3.87187749e-02f, -1.36572659e-01f, -4.39605899e-02f, -1.09977320e-01f, 1.37480468e-01f, -8.73096809e-02f, 3.34719685e-03f, -5.27636614e-03f,
  -6.69410639e-03f, -1.26522770e-02f, -1.54192494e-02f, 1.00591823e-01f, 8.03773031e-02f, 6.91021904e-02f, -2.50122584e-02f, -6.71580583e-02f, 1.35879219e-01f, -2.51030214e-02f,
  7.37799192e-03f, 9.92889050e-03f, 4.97658141e-02f, 9.23087262e-03f, -1.55467261e-02f, 2.93970536e-02f, -1.80829391e-02f, 3.69069614e-02f, 5.82577027e-02f, -5.60467504e-02f,
  1.19587258e-01f, -5.17377593e-02f, 1.56767890e-02f, -5.65038249e-02f, -3.98505405e-02f, -5.22673726e-02f, 1.39081748e-02f, 4.18144800e-02f, 6.30321633e-03f, 2.45133266e-02f,
  -2.53000576e-03f, 1.14841089e-01f, 1.04451492e-01f, -2.02259626e-02f, 3.90819944e-02f, 6.48385193e-03f, -5.94667681e-02f, 5.06206378e-02f, 2.64169257e-02f, -3.77284363e-03f,
  -1.79591868e-02f, -1.19877150e-02f, 8.80215168e-02f, 2.41265744e-02f, -3.19771655e-02f, -4.08048518e-02f, -3.19929072e-03f, -1.08452819e-01f, -7.94804841e-02f, 9.74880718e-03f,
  1.87239617e-01f, -2.15424314e-01f, -2.14703798e-01f, 9.52450410e-02f, 2.61364877e-01f, 2.65962809e-01f, 1.07994698e-01f, -1.09004043e-01f, -8.15380588e-02f, -1.75443187e-01f,
  1.35217130e-01f, -1.12849556e-01f, -2.00062633e-01f, 1.41519025e-01f, 3.31119746e-01f, -2.14664459e-01f, 2.28253558e-01f, 9.34399143e-02f, -1.21003427e-01f, 4.86715920e-02f,
  3.04439347e-02f, 3.48546952e-01f, -1.94215223e-01f, -1.00531250e-01f, 8.42588097e-02f, -1.90515026e-01f, -2.30894107e-02f, -1.79230765e-01f, 4.62720469e-02f, 1.32053122e-02f,
  2.38704141e-02f, -4.73874658e-02f, 8.10330808e-02f, -8.67954269e-02f, -7.85764903e-02f, 5.35418279e-02f, 8.68893112e-04f, 1.66468218e-01f, 9.96653065e-02f, -1.66714210e-02f,
  -3.39394808e-02f, 6.60642833e-02f, 9.91987884e-02f, -3.37409899e-02f, 8.88877511e-02f, 9.01738554e-02f, -1.12333298e-02f, -1.29382774e-01f, -1.56065226e-01f, -1.89180300e-02f,
  -5.19751608e-02f, 3.68477367e-02f, 1.58544688e-03f, -5.27590103e-02f, 1.68301538e-02f, 2.85083652e-02f, -7.53687024e-02f, 5.06280549e-03f, -1.45413801e-02f, -5.54695874e-02f,
  3.30453403e-02f, -2.41461229e-02f, -7.67499581e-03f, -2.41815182e-03f, 7.46429861e-02f, -3.69405709e-02f, 9.11265835e-02f, 1.62959378e-02f, -3.81426774e-02f, -6.59511760e-02f,
  7.11947903e-02f, -4.54820395e-02f, -5.77051491e-02f, 1.15773179e-01f, 6.28968179e-02f, -2.41369940e-02f, 4.71876264e-02f, 7.28127286e-02f, -9.22823846e-02f, -7.86405504e-02f,
  -3.50023285e-02f, 6.06797822e-02f, 2.51764543e-02f, -1.35211751e-01f, 4.28417921e-02f, 1.17340580e-01f, 1.14750573e-02f, -1.54928712e-03f, -3.61064263e-02f, 3.83105017e-02f,
  -1.51052773e-02f, -2.01569870e-02f, -9.47644748e-03f, 9.96669531e-02f, -7.70260468e-02f, -3.33693847e-02f, -1.11056775e-01f, -3.05614644e-03f, 1.81815177e-02f, 6.91673681e-02f,
  6.44456148e-02f, 4.66456264e-03f, 1.23481378e-01f, 3.76677290e-02f, 1.02814334e-02f, 6.37831613e-02f, 3.33463997e-02f, 3.56429927e-02f, 2.23540682e-02f, 6.93151131e-02f,
  -4.72743362e-02f, -3.79131571e-03f, -1.06570639e-01f, -2.33112350e-02f, -1.27119245e-02f, -1.04163326e-01f, 1.24805560e-02f, -1.03881173e-01f, -9.25459415e-02f, -2.56401324e-03f,
  -1.78459927e-01f, 1.75301507e-01f, 8.95571932e-02f, 5.86405657e-02f, -1.46648318e-01f, 1.46869510e-01f, 1.65531427e-01f, 9.58440267e-03f, 2.44782791e-01f, 2.24644721e-01f,
  -2.43292786e-02f, 2.50800520e-01f, 1.45857304e-01f, 5.03036939e-02f, -1.43976808e-01f, 1.83334529e-01f, 7.47079402e-02f, 1.65398583e-01f, 1.20005116e-01f, 3.41087743e-03f,
  -1.52243227e-01f, 1.46427387e-02f, -1.61720455e-01f, -1.89291462e-02f, -1.17543221e-01f, -7.57758468e-02f, -2.24118024e-01f, -1.44032136e-01f, 4.95910905e-02f, -1.14632875e-01f,
  -2.22050846e-01f, -9.72729623e-02f, -8.79770238e-03f, -2.62964200e-02f, 1.08451083e-01f, -8.81887451e-02f, 8.18536207e-02f, -8.28975514e-02f, 4.73973006e-02f, 1.97556708e-03f,
  1.44984439e-01f, 6.56506792e-02f, 1.51028886e-01f, 3.60151604e-02f, 2.83809677e-02f, 6.61719739e-02f, 6.78292587e-02f, -1.68674514e-02f, -5.24500012e-02f, 6.33273600e-03f,
  -1.07170321e-01f, 5.20823412e-02f, 1.41007348e-03f, 1.16757959e-01f, -9.44986865e-02f, -9.59499180e-02f, 5.67134097e-02f, -1.13232143e-01f, -1.68784056e-02f, 1.46985641e-02f,
  8.09120014e-03f, 4.41546775e-02f, -2.89526489e-02f, -3.78298131e-03f, -2.78308559e-02f, -7.62812272e-02f, -9.30737406e-02f, -2.04038858e-01f, -8.19700882e-02f, -8.05987716e-02f,
  5.36806919e-02f, -7.55765289e-02f, 5.37059754e-02f, -3.84863317e-02f, 9.49997082e-02f, -1.01083238e-02f, -4.44335677e-02f, 1.05282873e-01f, -3.85354715e-03f, 2.16191206e-02f,
  -6.82836547e-02f, -5.09041212e-02f, -2.60535758e-02f, 1.08532803e-02f, 7.86771551e-02f, 5.01250252e-02f, 1.05763607e-01f, -3.64222638e-02f, 4.66415100e-02f, 2.95479856e-02f,
  8.60724598e-03f, 1.17735207e-01f, 1.14411451e-02f, -6.31041825e-03f, -4.85104993e-02f, 2.50767041e-02f, 5.80412410e-02f, -2.51711253e-02f, 7.83265755e-02f, 2.59822998e-02f,
  -5.33653498e-02f, 6.85579777e-02f, 1.37700932e-02f, 4.92995046e-02f, 6.33357242e-02f, -1.65092992e-03f, 7.13617802e-02f, 8.81932862e-03f, -1.78654566e-02f, 8.14629495e-02f,
  4.19249609e-02f, 4.36911844e-02f, -4.55308296e-02f, -1.11006074e-01f, -2.78602038e-02f, -1.04135938e-01f, 4.39175777e-02f, -1.15984622e-02f, 2.87108701e-02f, 2.64041480e-02f,
  2.38289952e-01f, 1.31858215e-01f, 1.23949863e-01f, 3.07149112e-01f, -2.84914263e-02f, -1.52495980e-01f, -1.60294652e-01f, 1.63896158e-02f, 2.04537347e-01f, -1.16455108e-01f,
  -5.21376841e-02f, 1.03412583e-01f, -1.70650408e-01f, 1.17539451e-01f, -2.07732692e-01f, -2.12893128e-01f, -2.58246027e-02f, -2.62988470e-02f, 2.08241418e-02f, 1.62037313e-01f,
  9.90711078e-02f, -1.03779301e-01f, -5.26953069e-03f, -1.29055798e-01f, 1.96847558e-01f, 5.02008125e-02f, -1.20471992e-01f, -1.63761124e-01f, 1.61722451e-01f, -8.21957141e-02f,
  9.93184838e-03f, 8.35097656e-02f, 9.25640389e-02f, -4.10184190e-02f, 6.74296841e-02f, 9.89835709e-04f, 4.20972332e-02f, -1.13557614e-01f, 2.41136290e-02f, 3.94542627e-02f,
  7.74933100e-02f, -2.74561886e-02f, -2.89213490e-02f, -3.62110510e-03f, 4.78839949e-02f, -1.42483227e-03f, 3.91390026e-02f, 1.40479699e-01f, 2.64970697e-02f, 1.16154417e-01f,
  2.12241843e-01f, 7.83190951e-02f, 6.30193353e-02f, -4.85882871e-02f, 1.47837818e-01f, 8.24549571e-02f, 1.14250286e-02f, 9.98531505e-02f, 4.23687994e-02f, 1.76928658e-02f,
  -2.41058171e-02f, -9.69154537e-02f, -2.72266082e-02f, -8.80206376e-02f, 2.45901849e-03f, -3.49190459e-02f, -4.90570180e-02f, -1.25399893e-02f, 5.98885901e-02f, 1.11105312e-02f,
  -9.41701531e-02f, 1.94212844e-04f, 1.43350465e-02f, -9.12460610e-02f, 7.19496682e-02f, -1.66321360e-02f, -9.81453508e-02f, -8.21617525e-03f, 4.07310538e-02f, -2.15958152e-02f,
  -4.69069555e-02f, 8.80775135e-03f, -6.55497191e-03f, -1.15164153e-01f, -1.10233136e-01f, 3.22289877e-02f, 5.97984008e-02f, -5.26560545e-02f, 1.76869221e-02f, -6.34356886e-02f,
  3.53605836e-03f, -3.92533764e-02f, 4.78569120e-02f, -2.42196731e-02f, -1.02969417e-02f, 8.06132797e-03f, -2.02920679e-02f, 8.13666955e-02f, -3.30906687e-03f, -1.13932975e-01f,
  -5.05218050e-03f, -8.09060410e-03f, -7.16075525e-02f, -9.78195369e-02f, -2.92735286e-02f, -9.71996486e-02f, 1.16334204e-02f, -7.05205195e-04f, 2.22654752e-02f, 1.70163941e-02f,
  7.68095925e-02f, -8.70224163e-02f, -3.39930914e-02f, 1.65097229e-02f, 1.52948856e-01f, -6.59259856e-02f, -4.21693660e-02f, 7.24320188e-02f, 5.75313568e-02f, -2.63908389e-03f,
  4.04675193e-02f, 1.81430429e-01f, 1.37849733e-01f, -1.79482959e-02f, -3.13680023e-01f, -1.43377751e-01f, 3.85589562e-02f, -7.83986002e-02f, 2.25178137e-01f, 1.08529672e-01f,
  -1.41876370e-01f, 2.54816175e-01f, -6.83516935e-02f, 1.65626295e-02f, 1.55616924e-02f, 9.01715234e-02f, -7.53505826e-02f, 5.87113835e-02f, 7.83254355e-02f, -6.37002736e-02f,
  -6.79577515e-02f, -3.08415264e-01f, -5.08628674e-02f, -2.39915609e-01f, -1.17381392e-02f, 4.80631776e-02f, -1.53749898e-01f, -3.86049487e-02f, 3.04426998e-02f, -5.01363911e-02f,
  7.59673119e-02f, 1.56151026e-01f, 7.99356177e-02f, 1.32406771e-01f, 8.28633308e-02f, -8.93772393e-02f, 3.83823295e-04f, 2.68633794e-02f, 6.18717894e-02f, 7.74210738e-03f,
  8.83667544e-03f, -5.02295196e-02f, 3.80350687e-02f, -4.17672144e-03f, 6.15501776e-02f, 1.76226534e-02f, 7.03067938e-03f, 2.82188747e-02f, 4.74855304e-02f, -2.39120666e-02f,
  5.44839241e-02f, 2.34855078e-02f, 3.26665528e-02f, 1.05036572e-01f, 7.78938234e-02f, 2.79360209e-02f, 5.47341555e-02f, 8.54449198e-02f, 1.09553136e-01f, -2.85801804e-03f,
  -9.33178701e-03f, -1.77820213e-02f, 8.47616140e-03f, -6.74182698e-02f, -2.40006894e-02f, -7.76690170e-02f, -3.65227014e-02f, -8.42095315e-02f, 2.88036335e-02f, -3.69739942e-02f,
  5.73245436e-02f, 5.80809824e-02f, 1.17228804e-02f, 1.00681648e-01f, -5.62569425e-02f, 4.36630920e-02f, -7.22905397e-02f, 1.00701340e-02f, 3.30542885e-02f, -2.99124699e-02f,
  -4.05639894e-02f, -6.14049025e-02f, -5.03147021e-02f, -8.29994399e-03f, -3.77380736e-02f, 7.06416965e-02f, 1.75634027e-02f, 1.53304368e-01f, -4.57815751e-02f, -1.08670652e-01f,
  1.37954816e-01f, 1.40916601e-01f, 1.03860304e-01f, 7.14118704e-02f, 1.10307612e-01f, 2.44447328e-02f, -3.90483588e-02f, 9.31787677e-03f, 9.51659977e-02f, -1.00884154e-01f,
  -1.45822346e-01f, -1.14784660e-02f, 1.47182746e-02f, -9.09776706e-03f, 5.91969118e-02f, 5.96968569e-02f, 3.34143899e-02f, 6.15989640e-02f, 3.24020050e-02f, 2.40402929e-02f,
  -1.42244279e-01f, 1.35635696e-02f, 1.00521974e-01f, 6.19638115e-02f, -5.12133017e-02f, -1.97383706e-02f, 7.83067048e-02f, 6.20811693e-02f, 7.48195103e-04f, -7.28431270e-02f,
  -1.19834743e-01f, -7.90563375e-02f, -2.76002914e-01f, 3.46202888e-02f, 1.67069122e-01f, 1.02204271e-01f, 3.30924541e-02f, 1.60046056e-01f, -1.60068229e-01f, 1.97582960e-01f,
  1.04099035e-01f, -2.09345415e-01f, -1.48755312e-01f, 3.16959471e-01f, 1.88558683e-01f, -1.56963587e-01f, 2.48083204e-01f, 5.48766218e-02f, -5.22895008e-02f, 8.13378468e-02f,
  -1.11015417e-01f, 2.67036527e-01f, -1.05946191e-01f, 1.04861006e-01f, 1.30367041e-01f, -1.48879766e-01f, 1.50763080e-01f, -1.13486774e-01f, 1.75759643e-01f, 3.09387967e-02f,
  8.78679678e-02f, -1.06006198e-01f, -9.07354504e-02f, -1.58903375e-01f, 6.61210120e-02f, -4.19475958e-02f, -4.04754169e-02f, -4.85631339e-02f, -2.13318262e-02f, -8.49512964e-02f,
  -4.98056710e-02f, 1.82067268e-02f, 2.73483712e-02f, -7.65834451e-02f, -4.00620550e-02f, 1.90781448e-02f, 2.67264415e-02f, 2.63373516e-02f, 2.81099230e-02f, 5.10472991e-02f,
  -8.78121853e-02f, 1.33375553e-02f, -2.04806067e-02f, -1.30094979e-02f, -2.92305183e-02f, 2.57949084e-02f, -4.65370826e-02f, 5.66627271e-02f, 5.69679737e-02f, 2.11315695e-02f,
  9.62207466e-02f, -2.13115439e-02f, 7.05669299e-02f, -2.28065737e-02f, 7.99066387e-03f, 8.74804035e-02f, 3.72823998e-02f, 2.03011949e-02f, -9.20096636e-02f, 6.87363073e-02f,
  1.61700267e-02f, 8.82311985e-02f, 2.30267365e-02f, 1.04356650e-03f, -5.19631803e-02f, -5.68455309e-02f, -3.78982350e-02f, 6.10120371e-02f, 3.34488675e-02f, -2.33825780e-02f,
  -6.09401148e-03f, -6.35111332e-02f, -1.88060552e-02f, 2.21184343e-02f, 1.93408411e-02f, -1.51162613e-02f, 2.14871839e-02f, -6.27886057e-02f, -1.16123334e-02f, -3.49533521e-02f,
  8.75116810e-02f, 1.84704131e-03f, 4.70706867e-03f, 4.40541133e-02f, -1.85104515e-02f, 1.03962518e-01f, 4.95586656e-02f, 2.18253140e-03f, -8.12980011e-02f, 4.09713574e-03f,
  4.33765575e-02f, -1.39731765e-02f, -1.98226999e-02f, 7.84886777e-02f, -4.04849648e-02f, 9.83086377e-02f, 2.14073081e-02f, 5.69342822e-02f, 1.97943255e-01f, 2.83796266e-02f,
  1.20116271e-01f, 4.67273444e-02f, 1.47746187e-02f, 6.01267219e-02f, 3.71757858e-02f, 1.93502363e-02f, 1.00521393e-01f, -1.01774447e-01f, 1.19923390e-01f, 7.18896240e-02f,
  -1.28961066e-02f, -1.08560413e-01f, -4.77828905e-02f, -9.16225761e-02f, -6.92127123e-02f, -2.08275363e-01f, 2.52003949e-02f, -9.28990319e-02f, -3.20843607e-02f, -2.24452317e-02f,
  7.24882931e-02f, 6.85167089e-02f, 1.61201611e-01f, -2.20272243e-01f, 1.82448566e-01f, 8.23961496e-02f, -1.82384014e-01f, -4.84123081e-02f, -6.31673560e-02f, -4.48016152e-02f,
  -7.32770786e-02f, -1.56366289e-01f, -4.42539528e-02f, -9.03148055e-02f, -1.04300402e-01f, -6.12709150e-02f, -4.21014056e-02f, 9.12779123e-02f, -1.83165625e-01f, -5.35972230e-02f,
  -1.65218085e-01f, -1.88636988e-01f, -8.91933441e-02f, -1.21466614e-01f, -1.71722099e-01f, -7.78633952e-02f, -4.12135758e-03f, 5.04324362e-02f, -2.39749085e-02f, 7.24265873e-02f,
  7.62301981e-02f, -9.44626257e-02f, 6.55945912e-02f, 4.21775728e-02f, 7.20743090e-02f, -1.28978774e-01f, 6.74659088e-02f, -4.47569415e-02f, -3.78243998e-02f, -9.78308171e-02f,
  -3.68566364e-02f, -1.16108591e-02f, -9.03742760e-02f, 6.99396059e-02f, 1.35447783e-02f, 3.62507552e-02f, 1.72977056e-02f, 1.84382349e-02f, -4.32073325e-02f, -9.03513581e-02f,
  -2.79100239e-02f, 3.04599218e-02f, -9.11826938e-02f, 7.07763433e-02f, -1.19830415e-01f, -1.10865809e-01f, 3.42923822e-03f, 6.79244578e-04f, 9.45095867e-02f, -1.20405643e-03f,
  2.51895003e-02f, 3.35415900e-02f, -8.32599178e-02f, 3.48434746e-02f, -7.83192087e-03f, -1.99017748e-02f, 9.42460969e-02f, -7.55050480e-02f, -1.21576056e-01f, 6.71334788e-02f,
  -4.76036444e-02f, 4.74450663e-02f, -1.02703488e-02f, 3.93680559e-04f, 1.86737515e-02f, 8.05971213e-03f, -9.53591019e-02f, -2.76985001e-02f, 4.61815819e-02f, 1.38758942e-01f,
  -7.17887729e-02f, -1.45081773e-01f, -7.79246762e-02f, 2.04336066e-02f, -6.32327562e-03f, -3.05886418e-02f, 7.48472661e-02f, 4.60759737e-02f, 5.01893349e-02f, -1.26565406e-02f,
  6.70363009e-02f, -7.42550800e-03f, 3.15659717e-02f, -1.56720972e-03f, 7.71118999e-02f, -9.22581851e-02f, -5.93029559e-02f, 7.97389299e-02f, -1.03228390e-02f, -9.89646912e-02f,
  3.65578756e-02f, -8.81731976e-03f, 7.68401101e-02f, -1.12119168e-01f, 3.91090773e-02f, 1.70259811e-02f, -9.54789817e-02f, -7.35316351e-02f, 5.01787663e-02f, 9.90378931e-02f,
  -9.04323012e-02f, 2.94945240e-01f, 2.67357171e-01f, 1.05798289e-01f, -1.37214214e-01f, -2.06029460e-01f, -2.14435041e-01f, 2.99887452e-02f, -5.25233857e-02f, -1.35252699e-01f,
  -2.80384868e-02f, 3.24220918e-02f, 5.74616939e-02f, -1.50708167e-03f, 2.52950996e-01f, 2.14062393e-01f, 1.16578415e-01f, 7.16530383e-02f, 2.88301557e-01f, 1.09287247e-01f,
  2.24611104e-01f, 5.07669337e-02f, 4.18326408e-01f, 2.68393844e-01f, 1.70981750e-01f, 1.09717302e-01f, 2.05959111e-01f, 1.51443094e-01f, -7.01152906e-02f, -4.19136696e-02f,
  -4.75491472e-02f, -6.00217842e-02f, 1.38054024e-02f, -6.82830811e-02f, 1.05655834e-01f, 1.39880739e-02f, 8.10186267e-02f, -1.15881905e-01f, -6.28460199e-02f, -4.43471596e-02f,
  9.11612157e-03f, 1.94266904e-02f, -4.74547669e-02f, 3.89520004e-02f, -9.51765925e-02f, 3.75586003e-02f, 1.68016806e-01f, 8.14224768e-04f, 8.58965293e-02f, 6.65638074e-02f,
  1.89584166e-01f, -1.66404918e-02f, 5.96544556e-02f, 5.63005581e-02f, 1.61187679e-01f, -1.00293443e-01f, -2.65569612e-02f, 6.14447221e-02f, 3.02923732e-02f, -5.49743064e-02f,
  -7.62213618e-02f, 8.89347643e-02f, 1.27362907e-02f, 1.04297534e-01f, -8.91957879e-02f, -7.37581328e-02f, -3.80786695e-02f, 4.88287359e-02f, -4.72867750e-02f, -1.10956887e-02f,
  4.83990237e-02f, -2.86961924e-02f, -3.83450687e-02f, -2.52274722e-02f, 2.34374721e-02f, -8.42605531e-02f, 4.23867591e-02f, 8.13105144e-03f, -1.01862676e-01f, 5.14359921e-02f,
  -3.10355835e-02f, -1.14982560e-01f, 1.01046234e-01f, 4.16699657e-03f, -1.49409354e-01f, 8.59768093e-02f, -2.69305538e-02f, 2.70993263e-02f, 1.52403926e-02f, 2.01678887e-01f,
  -1.21551491e-01f, 3.52738053e-02f, 9.28374827e-02f, -5.24745695e-03f, 4.85770106e-02f, -3.64075527e-02f, 4.43144515e-02f, 4.26867716e-02f, -1.73407067e-02f, 5.30601405e-02f,
  -2.49429047e-02f, 2.21057776e-02f, -3.90102901e-02f, -3.49537879e-02f, 8.04869831e-02f, 1.27467424e-01f, -5.17057218e-02f, -1.03944936e-03f, -2.33908687e-02f, 1.48603246e-01f,
  4.76739071e-02f, -5.72350398e-02f, 7.58899748e-02f, 1.85925160e-02f, -5.73758408e-02f, -8.54720548e-02f, -1.34434059e-01f, 2.20780782e-02f, 1.13700449e-01f, -3.62718701e-02f,
  7.76858628e-02f, 1.57384902e-01f, -5.63833565e-02f, 1.32522330e-01f, 1.29022717e-01f, 2.04388469e-01f, -6.88939691e-02f, 8.74155164e-02f, 2.54856437e-01f, 1.75621863e-02f,
  -4.91719544e-02f, 7.60123730e-02f, -3.03299218e-01f, 1.43556073e-01f, -1.09854497e-01f, -7.64088258e-02f, 2.73119450e-01f, 1.58390418e-01f, 2.13649888e-02f, 7.08643422e-02f,
  3.46587449e-02f, -4.03395146e-02f, -1.21818773e-01f, -4.08641919e-02f, 2.87180748e-02f, 4.33446132e-02f, 4.20417683e-03f, -1.33689493e-01f, 1.17018387e-01f, 6.34450614e-02f,
  -2.02805363e-02f, 6.49681091e-02f, -4.44567315e-02f, -5.99057041e-02f, 6.62733838e-02f, -5.84488884e-02f, 9.11276639e-02f, -3.98165993e-02f, -7.83103332e-02f, -1.06168855e-02f,
  9.29703414e-02f, -9.27959010e-02f, 1.26149252e-01f, -1.33555159e-01f, 1.52339190e-01f, 9.26642418e-02f, -7.35525042e-02f, -5.29163405e-02f, 7.77185708e-02f, -1.30792037e-01f,
  -6.70226589e-02f, -7.92511478e-02f, 1.10387929e-01f, 1.05636761e-01f, -2.50526965e-02f, 3.54844821e-03f, 1.26936570e-01f, -1.78139098e-02f, -3.68458554e-02f, 1.59231573e-01f,
  5.34211285e-03f, 8.61627981e-02f, 3.29932496e-02f, -6.94638714e-02f, 1.00328028e-01f, 5.58062494e-02f, 1.22446813e-01f, 6.53383508e-02f, -2.06907149e-02f, -7.86175057e-02f,
  9.84735042e-02f, 4.90284860e-02f, -2.17032358e-02f, -1.10625075e-02f, 1.44317195e-01f, -3.74902301e-02f, 3.41106802e-02f, -1.25272453e-01f, 3.83454305e-03f, 1.65602714e-02f,
  6.28884137e-02f, 7.78049678e-02f, -1.36282384e-01f, 1.88275091e-02f, 3.81828262e-03f, -1.53917447e-01f, -5.91888577e-02f, 7.67448097e-02f, -1.50959864e-01f, 1.32446930e-01f,
  4.85265926e-02f, 1.40250266e-01f, 5.75102866e-03f, 5.00585400e-02f, 1.07334144e-01f, 7.85940886e-02f, 7.01102540e-02f, 6.26305491e-02f, 5.24512306e-02f, 8.79291147e-02f,
  -8.15678686e-02f, 5.89701310e-02f, 6.66528642e-02f, -1.40579328e-01f, 3.65773104e-02f, 6.67069331e-02f, -2.24401020e-02f, 4.22073901e-02f, 2.45811585e-02f, -1.17255665e-01f,
  -1.07123524e-01f, -4.10230197e-02f, 6.96310475e-02f, 2.74837073e-02f, -4.26851101e-02f, 5.84534258e-02f, 6.30131066e-02f, -6.07733168e-02f, -6.74277544e-02f, -5.55978864e-02f,
  -4.02782738e-01f, 2.80305326e-01f, -9.39085037e-02f, -8.88311714e-02f, 7.75567964e-02f, -9.62054431e-02f, -1.10068828e-01f, 7.49039724e-02f, -1.08818077e-02f, 1.15315244e-01f,
  -1.12631228e-02f, -1.98467553e-01f, 1.26851439e-01f, -7.84578696e-02f, -2.44610861e-01f, 2.47439459e-01f, -1.20352626e-01f, -1.29001290e-01f, -2.03442592e-02f, 4.37001921e-02f,
  2.40600742e-02f, 8.72922093e-02f, 2.24395562e-02f, 1.68721795e-01f, -1.02534004e-01f, -6.65406510e-02f, -1.74517974e-01f, 1.70842722e-01f, -1.15660802e-02f, -7.73241445e-02f,
  -2.15455323e-01f, -1.73744664e-01f, -1.93699896e-01f, -9.88757312e-02f, -1.55104235e-01f, -1.09481074e-01f, -5.08821569e-02f, 1.80052370e-02f, 2.46228371e-02f, -8.68289471e-02f,
  -7.85614625e-02f, -6.22138195e-03f, 3.43001932e-02f, 4.02070843e-02f, -1.85650494e-02f, -1.04293555e-01f, -5.18468507e-02f, -1.03455171e-01f, -6.23152331e-02f, 3.48053984e-02f,
  -3.25522497e-02f, 1.23719557e-03f, -7.81272352e-02f, 1.88034307e-02f, 2.59779450e-02f, -6.76360130e-02f, 7.00512230e-02f, -5.35059795e-02f, -1.50436595e-01f, -1.14766836e-01f,
  9.39047784e-02f, 7.61529580e-02f, -7.40121603e-02f, -9.41127092e-02f, -1.46146328e-03f, -3.92557159e-02f, 6.89048395e-02f, 3.47300321e-02f, 3.52765396e-02f, 1.27632201e-01f,
  4.40870225e-02f, 2.56197285e-02f, 6.44984841e-03f, 5.19426726e-02f, -7.72761106e-02f, -2.13559549e-02f, 4.87954468e-02f, 6.69626519e-02f, -1.70372997e-03f, -1.64007768e-01f,
  -1.29592484e-02f, 4.55506593e-02f, -1.11617908e-01f, 1.02795742e-01f, 6.04240596e-02f, -3.08862291e-02f, -9.48444195e-03f, 5.87939844e-02f, -2.56861504e-02f, 3.79404910e-02f,
  -2.98781067e-01f, -1.99161336e-01f, 2.18900349e-02f, -7.62431547e-02f, -6.87275901e-02f, 4.47003469e-02f, 1.25582621e-01f, 4.21454338e-03f, -9.14439186e-02f, -1.12237215e-01f,
  -7.61706010e-03f, -5.37399622e-03f, -5.16953468e-02f, 8.39071721e-02f, 8.58452767e-02f, 5.60761951e-02f, -7.72241689e-03f, -7.26509914e-02f, -5.39543713e-03f, -6.30438104e-02f,
  -1.03857033e-01f, 8.87304768e-02f, -1.23472279e-02f, 1.01686679e-01f, 9.82260033e-02f, -1.68609202e-01f, -4.47724946e-02f, 1.16929738e-02f, -2.30578296e-02f, 2.05991194e-02f,
  -8.75920877e-02f, 2.85986900e-01f, 1.82478502e-01f, 6.12910464e-02f, 1.67422548e-01f, 2.35314175e-01f, 2.67728895e-01f, 1.50170222e-01f, 3.02275836e-01f, -5.78052439e-02f,
  -2.27483988e-01f, 1.18157290e-01f, -1.36613384e-01f, 1.03729554e-01f, -1.23714067e-01f, 1.35893494e-01f, 2.28071064e-01f, 1.41959548e-01f, 2.20773801e-01f, -6.10316135e-02f,
  3.05632073e-02f, -1.07806228e-01f, -2.54093230e-01f, -1.63467512e-01f, -1.45411432e-01f, -5.78135662e-02f, -2.65138596e-01f, 1.44917599e-03f, -2.05271170e-01f, 1.53215080e-01f,
  8.90590101e-02f, 9.10128355e-02f, -8.96930024e-02f, 1.40029848e-01f, -7.20813423e-02f, 6.11356869e-02f, -5.51382788e-02f, 3.09847873e-02f, 1.39648793e-02f, 4.70155366e-02f,
  8.90462380e-03f, -1.50874138e-01f, 1.15622826e-01f, 1.37207741e-02f, 1.42879680e-01f, 7.40394881e-03f, 2.65487079e-02f, 3.11146285e-02f, 6.27498478e-02f, -7.88695216e-02f,
  3.30079794e-02f, -3.32986638e-02f, 9.71323475e-02f, 5.15807010e-02f, -1.54897515e-02f, 2.12471455e-01f, 2.00534929e-02f, 5.40091433e-02f, 5.41398209e-03f, 2.00574607e-01f,
  -4.07603160e-02f, 1.22167088e-01f, -1.36867017e-02f, 2.35750880e-02f, -1.06275976e-01f, 1.25854760e-02f, -1.03037581e-01f, 2.71844920e-02f, 1.29084617e-01f, -8.69172800e-04f,
  7.30970576e-02f, -3.12470598e-03f, 6.64003417e-02f, 1.11984252e-03f, -4.07523923e-02f, -5.03607374e-03f, 3.49735506e-02f, -4.05076966e-02f, 1.14564551e-03f, -1.16738185e-01f,
  -2.61338428e-03f, -2.79515497e-02f, 1.54455937e-03f, 4.35835542e-03f, -4.16804431e-03f, 6.16771728e-03f, 4.81200814e-02f, -8.09294283e-02f, 7.74441808e-02f, 2.46936530e-02f,
  6.95005134e-02f, 2.62745291e-01f, 3.48294638e-02f, 8.56752023e-02f, 1.09366467e-02f, -8.19773749e-02f, 5.35050035e-02f, 1.21793561e-01f, 1.12869971e-01f, -1.11559154e-02f,
  4.12996784e-02f, -7.72160813e-02f, -1.24473618e-02f, -2.38189604e-02f, -8.47293660e-02f, -2.39350162e-02f, 1.11216754e-02f, 6.12172931e-02f, 3.02600712e-02f, -1.03767708e-01f,
  -2.50801798e-02f, 9.25835744e-02f, -1.51153672e-02f, -8.82506743e-02f, 8.12850595e-02f, 6.79606050e-02f, 9.36642140e-02f, -5.71384244e-02f, 7.33990595e-02f, 2.26900261e-02f,
  2.32766539e-01f, 3.37689519e-02f, 1.29672363e-01f, 2.37746701e-01f, 6.56643230e-03f, -1.15593463e-01f, -1.99386045e-01f, 1.50546163e-01f, 9.97514203e-02f, -1.06212370e-01f,
  9.41729173e-03f, 4.14905474e-02f, -1.19996652e-01f, 1.99147105e-01f, 1.45561602e-02f, -1.82570010e-01f, 2.62406971e-02f, 7.45018274e-02f, 1.10048093e-02f, 1.78094413e-02f,
  1.39831200e-01f, 5.67509942e-02f, 1.25998199e-01f, 3.17969918e-02f, 1.97789699e-01f, 5.99924177e-02f, 7.86803216e-02f, -1.58918783e-01f, 4.89690937e-02f, -1.57709390e-01f,
  -3.12042367e-02f, -4.89441827e-02f, -3.37918103e-02f, -1.76439043e-02f, 1.16455788e-02f, -4.32806648e-02f, 1.09621240e-02f, -1.45984679e-01f, -5.38539104e-02f, -2.32059807e-02f,
  -4.68971170e-02f, 4.14057113e-02f, 7.39798322e-02f, 8.26495290e-02f, 6.29879832e-02f, -1.81903001e-02f, -5.25349332e-03f, 2.18208041e-02f, 8.57599676e-02f, 2.50009317e-02f,
  -4.18914668e-02f, -1.29368249e-02f, -6.37591034e-02f, 2.65336204e-02f, -4.11503203e-02f, 4.40121293e-02f, 4.29895986e-03f, -1.73546616e-02f, -1.68357287e-02f, 1.67848933e-02f,
  7.72808269e-02f, -5.94904982e-02f, -3.02809551e-02f, -1.87632572e-02f, 2.36729346e-02f, 3.56105193e-02f, 1.17450114e-02f, -1.71730220e-02f, -4.75468598e-02f, -3.19355018e-02f,
  3.77462357e-02f, 6.06795512e-02f, -5.95492013e-02f, 2.49319579e-02f, 1.51786273e-02f, 1.55043351e-02f, 3.66246738e-02f, -3.51224001e-03f, 6.50608772e-03f, 3.42899449e-02f,
  4.93930168e-02f, -1.27618806e-02f, 3.95948142e-02f, 1.42932571e-02f, 3.85976024e-02f, 4.56224335e-03f, 5.23509681e-02f, 2.04605274e-02f, 5.50420657e-02f, 1.86194573e-02f,
  -3.66529003e-02f, 1.29082486e-01f, -5.96889406e-02f, 8.40875134e-03f, -1.03062719e-01f, -5.07107452e-02f, 3.88774648e-02f, 3.11854878e-03f, 2.93101799e-02f, 1.72458068e-02f,
  -3.84908058e-02f, 1.66391935e-02f, 2.01629512e-02f, -4.52600121e-02f, -2.40372010e-02f, -3.97878466e-03f, 1.72418319e-02f, 6.10322393e-02f, -1.91988319e-03f, 1.00554571e-01f,
  7.00778216e-02f, 6.51245238e-03f, -9.84548330e-02f, -7.46831968e-02f, 6.57674968e-02f, 1.24896076e-02f, -4.29883506e-03f, 2.29356345e-03f, -8.15239549e-02f, -6.79334626e-02f,
  -3.95070761e-01f, -1.03108123e-01f, -2.83847749e-01f, -2.92034566e-01f, 3.04367393e-01f, 1.31555095e-01f, -7.94477314e-02f, -3.34435701e-02f, -2.07959533e-01f, 1.58149049e-01f,
  1.05660655e-01f, -2.33306855e-01f, 1.55617073e-02f, -1.85988277e-01f, -2.13152274e-01f, -3.08332354e-01f, -2.01151580e-01f, -3.49193215e-02f, -1.54435009e-01f, -6.75481409e-02f,
  -1.58797488e-01f, 1.42647877e-01f, -1.19701773e-01f, 2.12474570e-01f, -4.55156118e-02f, 5.44223636e-02f, 1.73290461e-01f, 1.75624222e-01f, 1.23480886e-01f, 8.05863962e-02f,
  -4.13103253e-02f, -1.45198181e-01f, -6.20289370e-02f, -1.36956647e-02f, 1.64242640e-01f, 1.10267945e-01f, 7.86649808e-02f, -8.56655985e-02f, -3.87986749e-02f, 9.90557112e-03f,
  5.15715331e-02f, 4.74130586e-02f, -2.78227925e-02f, 5.23463935e-02f, 7.80991316e-02f, 9.69310999e-02f, -4.55843732e-02f, -6.88255876e-02f, 1.33833075e-02f, -4.80844490e-02f,
  -1.17169887e-01f, -7.09030181e-02f, -1.81943458e-02f, -9.65460669e-03f, 2.46946104e-02f, -4.23293449e-02f, -1.72147676e-02f, 6.99367896e-02f, -2.78209895e-02f, -4.48804274e-02f,
  9.53194201e-02f, 4.95752208e-02f, -8.30103755e-02f, -7.74044394e-02f, 2.40294244e-02f, 4.17544171e-02f, -1.11949161e-01f, 3.52128670e-02f, 6.17053472e-02f, 8.39869604e-02f,
  -1.12403999e-03f, -2.36497517e-03f, -3.59336622e-02f, -3.73616777e-02f, -3.87116857e-02f, -1.29150157e-03f, 4.81605902e-02f, -3.21006067e-02f, -4.60591353e-02f, 2.63616778e-02f,
  -8.01940560e-02f, 1.55990841e-02f, 1.20510280e-01f, -4.74378690e-02f, -5.08739315e-02f, 4.18196097e-02f, -4.50583100e-02f, -7.27788061e-02f, -1.01887956e-02f, -9.81168970e-02f,
  5.55520989e-02f, 3.16491835e-02f, 6.41544834e-02f, -3.23032588e-02f, 3.83012034e-02f, 8.61752108e-02f, -4.72018570e-02f, -2.93240249e-02f, 8.18440039e-03f, -5.99406026e-02f,
  1.40797749e-01f, -1.48257809e-02f, 8.98591802e-02f, 7.06229266e-03f, -8.46600607e-02f, 8.03022385e-02f, 3.74263786e-02f, 3.72016430e-03f, 2.95030344e-02f, 3.59890237e-02f,
  1.16751686e-01f, 1.04421310e-01f, -1.76357049e-02f, 4.24836874e-02f, 2.82969382e-02f, 1.53262109e-01f, 6.41736612e-02f, -4.51181941e-02f, -3.03157959e-02f, -2.14605089e-02f,
  -3.45048338e-01f, 1.62504852e-01f, -7.19868094e-02f, -2.27346361e-01f, -3.85655761e-02f, -1.84356384e-02f, -1.06788397e-01f, -1.44740805e-01f, -6.07761815e-02f, 6.46747723e-02f,
  2.48442721e-02f, 3.17103118e-02f, 2.00711370e-01f, -1.38342390e-02f, -1.16881520e-01f, -4.26772982e-02f, -6.68619201e-02f, -1.57961681e-01f, 1.55955300e-01f, -6.81618229e-02f,
  -5.83502389e-02f, -1.03786968e-01f, -1.01081029e-01f, 1.57708377e-01f, -5.98511882e-02f, 3.64939049e-02f, 2.13579251e-03f, 1.41910359e-01f, 1.61473304e-02f, 8.28539282e-02f,
  -8.09683055e-02f, -1.57287046e-01f, -1.25892878e-01f, -1.23485006e-01f, -1.33089736e-01f, 3.44064640e-04f, -1.28820792e-01f, -3.70042250e-02f, -1.14384457e-01f, -4.24056351e-02f,
  8.16259608e-02f, 2.24316102e-02f, -4.38731275e-02f, -1.53126530e-04f, 8.16667601e-02f, -2.85391958e-04f, 3.23901698e-02f, 2.84403516e-03f, 6.39148802e-03f, -2.08740681e-02f,
  6.36133030e-02f, 9.03494507e-02f, -1.00313999e-01f, -1.02071539e-01f, -3.14458832e-02f, 5.23074716e-02f, -1.11252151e-01f, 6.07580207e-02f, 7.14937821e-02f, -5.84782101e-03f,
  -3.97174805e-02f, -2.57355087e-02f, 5.81758004e-03f, 1.70733780e-02f, 1.09413400e-01f, 1.06086724e-01f, -1.91202611e-02f, -1.08569868e-01f, 6.31332397e-02f, 5.45195192e-02f,
  -3.57605740e-02f, -1.11759439e-01f, -8.28613639e-02f, -1.13972701e-01f, 7.70844072e-02f, 5.89555018e-02f, 5.06604230e-03f, -1.00034466e-02f, 1.99651578e-03f, 8.52127150e-02f,
  4.71472628e-02f, -1.14725821e-01f, -4.73395288e-02f, -6.32436946e-02f, 1.49957851e-01f, 9.79336724e-02f, -4.87732366e-02f, -7.49319047e-03f, -4.98706996e-02f, -6.67294189e-02f,
  -9.67735872e-02f, -3.43226165e-01f, -8.89552757e-02f, -4.03760970e-02f, -2.28587282e-03f, -4.46993411e-02f, -3.97145115e-02f, 9.45311636e-02f, -1.03451878e-01f, -7.69748688e-02f,
  -1.21901244e-01f, -5.84428646e-02f, -1.18158400e-01f, 2.77940910e-02f, 9.30505916e-02f, -1.00821249e-01f, -6.08301498e-02f, 7.32099125e-03f, -1.25435218e-01f, 7.15319216e-02f,
  7.45960325e-02f, -1.46615729e-02f, 4.36412590e-03f, -8.86809081e-02f, -1.63420051e-01f, 6.64557293e-02f, -1.53608456e-01f, 1.44023523e-01f, -8.52769613e-02f, 2.34519448e-02f,
  1.57670870e-01f, -3.22964370e-01f, 5.46545275e-02f, 9.34115201e-02f, 1.77521229e-01f, -9.32497308e-02f, 2.14339681e-02f, -9.40644220e-02f, 9.18090809e-03f, -1.71428442e-01f,
  2.45471299e-02f, 1.59456208e-01f, -1.75076634e-01f, 7.16421157e-02f, 2.37940893e-01f, 4.24536318e-02f, -1.07752956e-01f, 3.68018672e-02f, 3.32994796e-02f, -7.21390322e-02f,
  1.42502233e-01f, 1.02752395e-01f, 8.17203820e-02f, -5.88996261e-02f, 6.43343702e-02f, 4.06276919e-02f, 6.73938468e-02f, 4.94312495e-02f, 9.43200216e-02f, 1.83938414e-01f,
  -1.59022793e-01f, -9.09994021e-02f, 5.92068806e-02f, -3.83228716e-03f, -8.42397586e-02f, 1.93824433e-02f, 4.05283161e-02f, 1.70122206e-01f, 4.56646420e-02f, -3.17898989e-02f,
  3.75517234e-02f, 2.29095872e-02f, 1.07096478e-01f, 6.70140386e-02f, 1.36931865e-02f, -8.15011188e-02f, 4.83233258e-02f, 1.61183756e-02f, -1.22425230e-02f, 5.55061474e-02f,
  -1.26156500e-02f, 8.06461181e-03f, -6.22353330e-02f, 5.59177287e-02f, 3.23503301e-03f, 5.00699738e-03f, 1.41317979e-01f, -7.55600445e-03f, 3.66394990e-03f, 7.69337127e-03f,
  1.01522282e-01f, -3.89946625e-02f, 4.69251629e-03f, 1.48358634e-02f, 3.48334829e-03f, -3.20763700e-02f, -1.19299203e-01f, 9.05560926e-02f, -6.92342892e-02f, 2.14286130e-02f,
  -1.27876364e-02f, -3.62228192e-02f, -4.56385650e-02f, -2.66931187e-02f, -9.22878161e-02f, -4.58702892e-02f, 1.69016160e-02f, 1.05154447e-01f, -4.06240113e-02f, 5.30098677e-02f,
  3.98743302e-02f, 8.90404359e-02f, -2.04955004e-02f, 6.88831136e-02f, -1.99377183e-02f, 5.54028600e-02f, -7.78941512e-02f, -8.22545514e-02f, 1.23309670e-02f, 1.09954156e-01f,
  -2.34168559e-01f, -2.88426369e-01f, -6.39065206e-02f, -1.37516171e-01f, -2.14526393e-02f, -1.27152488e-01f, 6.97343424e-02f, -1.17011636e-01f, -1.43096745e-01f, 5.45107760e-02f,
  -6.47262260e-02f, 9.52742004e-04f, -8.26090425e-02f, 7.10449964e-02f, -7.13230148e-02f, -5.42048775e-02f, 2.93067489e-02f, -1.29199579e-01f, 6.08033277e-02f, -1.36686996e-01f,
  -3.05320453e-02f, -2.49205884e-02f, 1.33976862e-01f, 7.81588107e-02f, -3.73892090e-03f, 8.84132087e-02f, 2.45802104e-02f, -3.30861099e-02f, 8.01650882e-02f, -2.57396642e-02f,
  2.92580947e-02f, 5.96774817e-02f, -6.60574883e-02f, 1.22654296e-01f, -1.71555519e-01f, -7.01761544e-02f, -1.23292498e-01f, 1.75855443e-01f, 1.17546255e-02f, 4.21990864e-02f,
  -4.01576720e-02f, -1.78853907e-02f, -3.17255557e-02f, 1.97522312e-01f, 2.22678736e-01f, 1.02378689e-01f, 9.47185755e-02f, -6.36361260e-03f, 4.20607254e-02f, 1.65896669e-01f,
  2.37967759e-01f, 1.73953220e-01f, 2.02612326e-01f, 1.70251697e-01f, 4.74185310e-02f, 9.70779583e-02f, 5.79191186e-02f, -3.63589600e-02f, 1.45931661e-01f, -1.27416123e-02f,
  -2.73556598e-02f, 1.81137603e-02f, 2.38269363e-02f, -1.59268966e-04f, -2.26138588e-02f, -1.23263545e-01f, 4.09170873e-02f, -6.56529814e-02f, -4.22893949e-02f, -3.13511193e-02f,
  -5.17153889e-02f, 7.17996201e-03f, 1.05450556e-01f, 6.24286057e-03f, -1.09738857e-01f, -7.46759176e-02f, 5.65208718e-02f, -8.72354675e-03f, -3.89534459e-02f, -2.69172359e-02f,
  -7.57617727e-02f, -8.83367434e-02f, -1.77262612e-02f, 1.34970605e-01f, -4.60297503e-02f, 2.14405052e-04f, -5.67401238e-02f, -5.33341765e-02f, -3.72005105e-02f, 9.14040767e-03f,
  9.76430476e-02f, -8.66673887e-02f, -5.18947020e-02f, -4.80602458e-02f, 1.06404871e-01f, 1.32615576e-02f, -7.99908787e-02f, 1.64314955e-02f, 8.03839341e-02f, 3.46958153e-02f,
  -3.42431515e-02f, 9.29500908e-02f, -9.53078549e-03f, -4.64049838e-02f, 8.07904750e-02f, -2.89567765e-02f, -5.14856502e-02f, 1.94748063e-02f, 7.11786449e-02f, 4.39499989e-02f,
  -6.37315437e-02f, 4.37072664e-02f, -3.25701721e-02f, 3.99783477e-02f, -4.06612083e-02f, 5.24787232e-02f, 8.97572860e-02f, 4.94169854e-02f, -1.41901691e-02f, -9.53254551e-02f,
  5.26896566e-02f, 1.94924787e-01f, -2.22170763e-02f, -6.67281151e-02f, -4.92133982e-02f, -1.84223372e-02f, -4.88682054e-02f, 5.04540950e-02f, 3.38414386e-02f, -2.07131691e-02f,
  2.85597127e-02f, -6.41675293e-02f, -1.19557790e-01f, -2.04521697e-02f, -5.36990166e-02f, 2.37377735e-05f, -4.65676710e-02f, 8.84659737e-02f, -2.27047522e-02f, 1.01421021e-01f,
  -2.40102541e-02f, -2.43615173e-02f, -6.06630817e-02f, -6.69234470e-02f, -2.88101174e-02f, -8.77597108e-02f, 5.47218993e-02f, -1.14863209e-01f, -2.53382064e-02f, 4.91955020e-02f,
  -8.87999982e-02f, 1.09163597e-01f, -1.39775306e-01f, -1.42384157e-01f, -1.52509853e-01f, -2.41695732e-01f, -1.18163042e-01f, -3.13294567e-02f, 2.44018912e-01f, 9.07485038e-02f,
  4.04996844e-03f, 1.49554774e-01f, 6.87802881e-02f, -1.37406662e-01f, -6.95953891e-02f, 6.43716231e-02f, -3.04659665e-01f, -9.85891074e-02f, 1.08276606e-01f, -1.45588383e-01f,
  -1.31781086e-01f, -1.26336619e-01f, -1.89129710e-01f, -6.96892962e-02f, -1.98084503e-01f, -3.18604000e-02f, -1.01378582e-01f, -1.01763584e-01f, -1.81644782e-01f, 7.48126209e-02f,
  7.03869164e-02f, 1.08109593e-01f, 5.12622409e-02f, 5.58180138e-02f, -1.09110765e-01f, -7.91691616e-02f, 3.71416993e-02f, 7.63496384e-02f, 8.53583142e-02f, 3.58502939e-02f,
  3.50106061e-02f, -2.35270020e-02f, 6.48583025e-02f, -2.98628677e-02f, 2.04543155e-02f, -7.53157288e-02f, -5.37415370e-02f, -1.26517871e-02f, 5.49472496e-02f, 2.96356361e-02f,
  -3.47181223e-02f, 4.31828573e-03f, -3.65104526e-02f, 2.05063168e-02f, 5.48605807e-02f, 1.37953013e-01f, 5.24068810e-02f, -1.32764354e-01f, 1.79990083e-02f, -4.29694727e-02f,
  5.91833964e-02f, -8.04339908e-03f, -1.11620717e-01f, 5.08388877e-02f, 8.21129903e-02f, -2.83555221e-02f, 1.60682872e-02f, 6.09753765e-02f, -1.09944679e-01f, -6.65167049e-02f,
  -2.39960309e-02f, 9.08011347e-02f, 3.39745134e-02f, 3.35130431e-02f, -8.20615664e-02f, -1.34381941e-02f, 3.97575535e-02f, 3.12002422e-03f, -5.16739115e-03f, -1.22899421e-01f,
  5.63282892e-02f, 1.59720376e-01f, 1.04721755e-01f, -1.37033775e-01f, -1.19710177e-01f, 3.02372333e-02f, 2.83658504e-02f, -5.54310530e-02f, -4.02148291e-02f, -2.70765834e-02f,
  3.78377177e-02f, 1.36005849e-01f, 1.00846983e-01f, 3.89598459e-02f, -1.14391111e-02f, -4.51557513e-04f, 1.06263265e-01f, -6.26940057e-02f, 1.98938996e-02f, -9.26828478e-03f,
  -3.35403644e-02f, 1.36658968e-03f, -1.01176508e-01f, -7.77241960e-02f, 5.96915521e-02f, 4.00680378e-02f, -9.17269010e-03f, 3.00434958e-02f, 5.29853851e-02f, -6.17380701e-02f,
  -1.00520268e-01f, 7.06002191e-02f, 1.21128418e-01f, 8.04997683e-02f, 6.45489395e-02f, -5.91264553e-02f, 5.14753163e-02f, 1.98204890e-02f, -6.87746108e-02f, -2.11093388e-03f,
  1.09145075e-01f, -2.09442377e-01f, 2.27031663e-01f, 1.70390084e-01f, 1.73437655e-01f, -2.96478253e-02f, 9.64694992e-02f, -1.61783665e-01f, -1.05559103e-01f, -1.53003320e-01f,
  6.12085611e-02f, 1.61092520e-01f, 7.84175768e-02f, -6.47570863e-02f, 2.67843813e-01f, 1.42942397e-02f, -1.52628228e-01f, -6.64076284e-02f, 3.45549583e-02f, -2.69228290e-03f,
  2.22211629e-02f, -2.86094785e-01f, 1.00013442e-01f, -3.04101735e-01f, -4.18135524e-02f, -8.06766376e-02f, -7.30045289e-02f, 8.41077343e-02f, -1.99228421e-01f, 4.14492562e-02f,
  -1.70739777e-02f, -2.72108801e-02f, 7.03908801e-02f, -1.10130221e-01f, -3.39412200e-03f, 2.57258732e-02f, 8.45757872e-02f, -1.62070431e-02f, 8.13347008e-03f, 2.20596250e-02f,
  -6.95973188e-02f, 1.05487714e-02f, -8.43705386e-02f, -1.12030481e-03f, -3.57581154e-02f, -5.62887043e-02f, 2.92018373e-02f, -7.95861706e-02f, 5.73437698e-02f, 1.36864232e-02f,
  1.23822294e-01f, -6.22984767e-02f, 1.83128312e-01f, -9.31921750e-02f, 6.52371049e-02f, 1.27062974e-02f, 7.86224678e-02f, 3.78388539e-02f, 2.94050947e-02f, -8.68538395e-02f,
  -1.31445834e-02f, -3.39314528e-02f, 8.27601105e-02f, -7.26443306e-02f, 3.26797478e-02f, 4.37165312e-02f, -1.54456366e-02f, 7.09140003e-02f, -3.85816284e-02f, -4.04524319e-02f,
  1.97851229e-02f, 8.87167901e-02f, -5.17915152e-02f, 9.80710983e-02f, -5.14119603e-02f, 5.89654781e-02f, -5.59252724e-02f, -1.03868649e-03f, -3.47845517e-02f, 1.83630642e-02f,
  2.65915524e-02f, 5.99002838e-02f, 1.06409639e-02f, -3.82439904e-02f, 2.85883551e-03f, 8.09804443e-03f, 8.11281577e-02f, 2.05175765e-02f, -9.14216880e-03f, -4.79470454e-02f,
  -2.12605506e-01f, -3.20415348e-01f, -4.60230634e-02f, -5.25930822e-02f, -5.00452779e-02f, 4.22161482e-02f, -7.16932565e-02f, -9.50955600e-02f, 3.45041156e-02f, -7.05360696e-02f,
  4.54498231e-02f, -4.55112346e-02f, -3.99848334e-02f, -2.11597560e-03f, -1.20608822e-01f, -3.61490399e-02f, -7.90475830e-02f, -3.71183492e-02f, -6.85021430e-02f, 4.36626337e-02f,
  3.33388038e-02f, 8.50325599e-02f, 2.60540228e-02f, -1.62871573e-02f, -4.32673097e-02f, 5.83068170e-02f, 5.00499308e-02f, 2.59060934e-02f, 9.79361758e-02f, -9.35235918e-02f,
  -3.78238410e-01f, 2.12816939e-01f, -3.53131332e-02f, -1.58409327e-01f, -5.31074740e-02f, 2.80256271e-01f, 2.45133281e-01f, -1.08025782e-01f, -2.09852323e-01f, 1.57319352e-01f,
  6.51624277e-02f, -2.68409640e-01f, 1.41089574e-01f, 2.10341960e-01f, -2.58343399e-01f, 2.85307974e-01f, 2.33840138e-01f, 1.34173647e-01f, -2.24328004e-02f, -7.79212862e-02f,
  -7.06550181e-02f, 2.27387145e-01f, 8.02456215e-02f, 6.93746358e-02f, -1.24296151e-01f, -9.32218879e-02f, -4.18711938e-02f, 6.31291866e-02f, 7.42561445e-02f, -4.31396440e-02f,
  4.36578766e-02f, -9.12050605e-02f, 3.05207353e-02f, 6.78618997e-02f, 6.65829927e-02f, 9.55202952e-02f, 7.97972232e-02f, -7.70981461e-02f, -4.40320894e-02f, 6.39067218e-02f,
  -5.16861342e-02f, -9.84203815e-02f, -2.42472496e-02f, -5.92821278e-02f, -1.47146672e-01f, -2.60367822e-02f, -1.62962340e-02f, -6.36832491e-02f, -2.00577322e-02f, 4.61259708e-02f,
  5.65827675e-02f, -6.62988424e-02f, 9.00273398e-02f, 5.60055822e-02f, 6.94871973e-03f, 6.12233654e-02f, 5.75334877e-02f, -4.28276276e-03f, 2.42092684e-02f, -8.92813727e-02f,
  -6.47379756e-02f, -9.02767405e-02f, 9.84432846e-02f, 1.91087592e-02f, 7.31593892e-02f, 1.69375464e-02f, 6.30652066e-04f, 9.19435080e-03f, -1.05234891e-01f, 2.30372790e-02f,
  -3.27187292e-02f, 1.73888523e-02f, -1.50526203e-02f, 6.94371164e-02f, 1.32975942e-02f, -2.05910369e-03f, -2.21886523e-02f, 9.77484323e-03f, -8.17340612e-02f, -7.51277581e-02f,
  1.15064336e-02f, -3.75313358e-03f, 1.13192916e-01f, 1.94147918e-02f, -4.83952370e-03f, 1.35059301e-02f, 8.11019354e-03f, -3.05032060e-02f, -1.01195239e-02f, 3.29905841e-03f,
  1.52203590e-01f, -4.80393618e-02f, 3.77362780e-03f, 1.13354567e-02f, 3.50857079e-02f, 6.01894595e-03f, -2.66023315e-02f, -1.10349059e-01f, -2.99654678e-02f, -6.75221533e-02f,
  -4.85640578e-03f, -8.08072239e-02f, -1.55073581e-02f, -6.13248050e-02f, -9.01866630e-02f, 9.98909250e-02f, 2.14551203e-02f, 7.60031566e-02f, -2.40581743e-02f, 1.39321862e-02f,
  -5.14308326e-02f, -5.79455607e-02f, 6.08997904e-02f, 4.99670319e-02f, 1.58178639e-02f, 1.07257981e-02f, -6.45660236e-02f, -6.04850128e-02f, -2.82275658e-02f, 3.85611597e-03f,
  2.90832311e-01f, 1.24803502e-02f, 6.77460507e-02f, 1.70254529e-01f, 1.12623453e-01f, -5.74835539e-02f, -9.75349024e-02f, 1.25339195e-01f, 9.33321491e-02f, -1.36021435e-01f,
  2.09932271e-02f, -1.50149003e-01f, -2.72172779e-01f, 3.07259988e-02f, 4.52319384e-02f, -7.60272741e-02f, 1.90625861e-01f, -1.02169879e-01f, 5.16629405e-02f, 1.88674077e-01f,
  1.48051441e-01f, 5.40033244e-02f, -5.82503416e-02f, -6.15135841e-02f, 1.50592059e-01f, 1.84298828e-01f, 2.42941439e-01f, -5.68581820e-02f, 5.45285009e-02f, -8.15847190e-04f,
  -1.09014558e-02f, -3.45167778e-02f, -1.22840861e-02f, -1.83501989e-02f, -8.73314310e-03f, 2.43443921e-02f, -3.54999676e-02f, -3.77567969e-02f, -7.48961940e-02f, -4.96725664e-02f,
  -1.02766961e-01f, -4.38601002e-02f, 6.04372248e-02f, -4.49076332e-02f, 1.00082599e-01f, 3.71566638e-02f, 3.75554971e-02f, 6.17341064e-02f, 6.22462891e-02f, -4.99202870e-02f,
  -7.60898590e-02f, -5.24303205e-02f, 1.42051935e-01f, 6.18921146e-02f, -3.01193036e-02f, -2.38440931e-02f, 3.64963338e-02f, -7.00490400e-02f, 6.63151667e-02f, 7.98167139e-02f,
  7.54481778e-02f, -3.14459652e-02f, -1.50036113e-02f, 6.55091032e-02f, 5.60935475e-02f, 6.55628070e-02f, 5.23483902e-02f, 3.16994917e-03f, -2.53555067e-02f, 5.76603971e-02f,
  1.03087544e-01f, 3.29563953e-02f, 1.45544950e-02f, 2.84027252e-02f, 5.58520146e-02f, -7.74354953e-03f, -5.72809484e-03f, -4.38803770e-02f, 6.22589663e-02f, 7.76865184e-02f,
  -4.53797840e-02f, 6.09793235e-03f, -9.99469087e-02f, 3.21278162e-02f, 4.23521809e-02f, -5.23086339e-02f, -5.72765432e-02f, -2.94858534e-02f, 6.87853321e-02f, -2.06903163e-02f,
  -2.25163605e-02f, 1.10613793e-01f, -4.76673618e-03f, -1.23426141e-02f, 7.43444413e-02f, 7.06307366e-02f, 6.78789094e-02f, -8.11723545e-02f, 5.80471903e-02f, 8.26382861e-02f,
  -4.05100696e-02f, 1.90771800e-02f, -3.99487726e-02f, -1.45081915e-02f, 1.21156052e-02f, -6.95414608e-03f, -3.78282554e-02f, -6.34127064e-03f, 6.41339645e-02f, 2.05081236e-02f,
  3.32207456e-02f, 2.76366360e-02f, 9.06046629e-02f, 5.46697974e-02f, -1.08729787e-01f, -1.24832913e-02f, 2.94810701e-02f, -1.50267649e-02f, 5.39836427e-03f, -5.11005186e-02f,
  -1.37470558e-01f, -3.31736840e-02f, 7.91749880e-02f, -2.30796754e-01f, -9.88205802e-03f, 1.69993117e-01f, 8.65961891e-03f, -6.63125962e-02f, -1.92480460e-01f, -2.08289444e-01f,
  -9.76808593e-02f, -1.21174395e-01f, 1.66140139e-01f, -1.21755295e-01f, 3.71104926e-01f, 9.72836763e-02f, -4.56845202e-02f, 6.38312772e-02f, -4.10162611e-03f, -1.60932526e-01f,
  6.59254119e-02f, -8.35501924e-02f, 1.07702963e-01f, -1.92323960e-02f, -9.50257033e-02f, -1.98647141e-01f, 4.41898368e-02f, 6.34127334e-02f, 7.41590634e-02f, 8.29381570e-02f,
  -2.34775424e-01f, -2.75290877e-01f, -1.78744063e-01f, -1.41596079e-01f, -9.29129124e-03f, -4.82034907e-02f, 1.00912064e-01f, 1.01224817e-01f, -2.62572058e-02f, -5.48302270e-02f,
  4.11779508e-02f, -7.91286081e-02f, -3.24418880e-02f, -4.99725863e-02f, -7.84507394e-02f, 4.57452424e-02f, -2.35966290e-03f, -2.14983374e-02f, 8.61039385e-03f, 7.73899704e-02f,
  7.87787065e-02f, 8.71740058e-02f, -3.95202190e-02f, 7.40004778e-02f, 1.20156407e-02f, -3.60249989e-02f, 5.59214223e-03f, 2.09981930e-02f, 8.43823105e-02f, -4.52053882e-02f,
  -3.72296423e-02f, 6.76664338e-02f, -9.72954258e-02f, -7.78423250e-03f, -1.04993157e-01f, -3.94381024e-02f, -2.41112057e-02f, 9.87119526e-02f, -4.39767819e-03f, 3.39974873e-02f,
  -3.46869938e-02f, -2.20559398e-03f, -7.86413401e-02f, 3.88207845e-02f, -5.99747663e-03f, -9.68011022e-02f, 3.55835035e-02f, -4.69344556e-02f, 5.11701591e-02f, 2.05431990e-02f,
  -8.98763686e-02f, -2.52275206e-02f, 6.47892952e-02f, 8.06956142e-02f, -2.34586722e-03f, 7.49993622e-02f, -1.57525961e-03f, -7.79439956e-02f, 4.93813232e-02f, 6.96298555e-02f,
  -2.24443287e-01f, -3.09967726e-01f, -5.51040575e-04f, -5.90479523e-02f, -2.79631447e-02f, 5.78705519e-02f, -1.03568519e-02f, -9.35804844e-02f, 4.92768809e-02f, -6.85276985e-02f,
  2.27979552e-02f, 3.68417352e-02f, 2.57815048e-02f, -1.09007522e-01f, 4.58420301e-03f, -1.15851650e-03f, 4.70722020e-02f, -1.32864388e-02f, 2.76371697e-03f, -4.37928997e-02f,
  6.27745641e-03f, 5.83806261e-02f, 6.41546622e-02f, 1.04297273e-01f, -3.18264402e-02f, 4.70756479e-02f, 1.02141881e-02f, 5.91664985e-02f, 1.62266478e-01f, -3.10290139e-02f,
  1.22821845e-01f, -2.70438969e-01f, 1.97113916e-01f, -4.09244699e-03f, 2.45584100e-01f, 2.34662831e-01f, 2.22108737e-01f, 1.55055955e-01f, -3.52381263e-03f, -2.96353638e-01f,
  -2.91938744e-02f, -2.84194857e-01f, -1.71623394e-01f, -1.89866811e-01f, 1.17801942e-01f, 2.38429792e-02f, -6.30226359e-02f, -3.13768201e-02f, 5.90915233e-02f, 1.23007692e-01f,
  9.49004963e-02f, 1.32650090e-02f, 1.95563018e-01f, 5.15552517e-03f, 1.85303673e-01f, -1.69025771e-02f, -8.82728547e-02f, 7.24357516e-02f, -8.10565576e-02f, 9.00174677e-02f,
  1.87342521e-02f, -2.17187535e-02f, 1.59751475e-01f, -2.90350057e-02f, 3.81327905e-02f, 9.10528749e-02f, 2.59736273e-02f, -5.85703216e-02f, 1.33554205e-01f, 3.08265053e-02f,
  -1.17579319e-01f, 8.11231614e-04f, -1.14186734e-01f, 5.03279418e-02f, 6.36226386e-02f, -2.90977899e-02f, 9.44018364e-02f, 1.15509734e-01f, 8.74261484e-02f, 3.87803353e-02f,
  5.77851292e-03f, -3.58221196e-02f, 5.05859479e-02f, -1.89425945e-01f, -6.85479194e-02f, -8.88174772e-03f, -9.80256125e-02f, -1.31309181e-01f, -5.01311496e-02f, -4.30073254e-02f,
  -8.90742615e-02f, -5.86195216e-02f, 7.32053369e-02f, 2.10542809e-02f, 1.97479576e-02f, -3.50855850e-02f, -3.38599607e-02f, 2.34263949e-02f, -1.74821615e-02f, -9.28650275e-02f,
  -1.03076264e-01f, -7.24655464e-02f, -4.28875238e-02f, -5.67626208e-02f, 2.15821415e-02f, -7.21871257e-02f, -3.46988700e-02f, -9.72453952e-02f, -2.33861320e-02f, -1.76638439e-02f,
  -5.60139120e-02f, -2.14771125e-02f, -2.19647922e-02f, -2.81680580e-02f, 2.52511073e-02f, -2.52454020e-02f, -9.45261940e-02f, 6.24408340e-03f, 9.13600549e-02f, 4.47468534e-02f,
  1.80728659e-02f, -1.02266423e-01f, 3.62708308e-02f, 7.61286542e-02f, -3.83720808e-02f, 9.96704772e-02f, 7.56969899e-02f, 1.52966194e-02f, -3.34494337e-02f, 3.84555236e-02f,
  2.27196366e-02f, -9.19342041e-02f, 2.82136165e-02f, 7.57213905e-02f, 5.99836260e-02f, -3.70777622e-02f, -1.30331814e-01f, -2.56544147e-02f, -1.24218529e-02f, -4.81486060e-02f,
  -8.50811452e-02f, -8.47261176e-02f, -3.73072140e-02f, 5.01064360e-02f, -6.21041954e-02f, -3.43559608e-02f, -7.91901574e-02f, -2.83368919e-02f, -2.98638940e-02f, 5.97646050e-02f,
  -3.89490463e-02f, -1.78494513e-01f, 5.03794365e-02f, -1.47057876e-01f, 5.82864098e-02f, 8.77598375e-02f, 1.54591858e-01f, -2.35484436e-01f, -2.31782645e-01f, -9.13144350e-02f,
  -2.35282462e-02f, 3.59341763e-02f, 2.78984696e-01f, -1.96583137e-01f, 2.09935665e-01f, 8.13003555e-02f, -8.59839991e-02f, 7.85071924e-02f, -4.45074588e-03f, -1.33816987e-01f,
  2.64817737e-02f, -1.81966811e-01f, 1.93699360e-01f, -1.61224946e-01f, -1.85967460e-01f, -1.97693840e-01f, 5.15809134e-02f, 7.18286857e-02f, -1.58834472e-01f, 1.26078814e-01f,
  -8.51037577e-02f, -1.08904496e-04f, -4.76658046e-02f, 8.02608579e-02f, -1.12119153e-01f, 3.96831855e-02f, 3.97320390e-02f, 1.20634526e-01f, 5.07288203e-02f, -2.83005685e-02f,
  -1.17237801e-02f, 5.90916872e-02f, -4.32713106e-02f, 1.09893624e-02f, 4.10554595e-02f, -1.05935499e-01f, -7.54572004e-02f, 2.33347081e-02f, -6.12067096e-02f, 6.07924871e-02f,
  2.67384369e-02f, 1.08184919e-01f, 3.31478752e-02f, -2.34501138e-02f, 3.40982452e-02f, -9.63128656e-02f, 9.38414633e-02f, 1.74040616e-01f, 6.66697994e-02f, 2.84267347e-02f,
  7.30900168e-02f, 2.24836566e-03f, -3.67412828e-02f, -6.54194802e-02f, -4.67737764e-02f, -6.29923940e-02f, 3.64099368e-02f, 3.39215137e-02f, -3.54731530e-02f, 9.89742950e-02f,
  -3.55936512e-02f, -6.55501634e-02f, 6.68531135e-02f, -6.39258176e-02f, -1.18518837e-01f, 2.66332761e-03f, 8.96352902e-02f, -2.84137633e-02f, 7.19243363e-02f, 8.67518187e-02f,
  -8.59666020e-02f, 3.35321166e-02f, -6.43800497e-02f, -4.46876064e-02f, 1.77001804e-02f, 1.00872712e-02f, 6.38622418e-02f, 1.03250183e-01f, 6.34907782e-02f, 9.41596180e-03f,
  -1.62610412e-01f, -1.80598274e-01f, -7.18726814e-02f, -1.89040452e-02f, -9.89228021e-03f, 7.62173980e-02f, 5.63735366e-02f, -2.84875296e-02f, -8.08697939e-02f, -8.33119601e-02f,
  -3.43624726e-02f, -1.81823391e-02f, -7.29633570e-02f, -8.30359682e-02f, 1.88012533e-02f, -1.06949456e-01f, -5.01331761e-02f, 7.58134946e-02f, -2.49272026e-03f, -1.75236873e-02f,
  -9.92716197e-03f, 5.06291818e-03f, 8.15881565e-02f, -1.35576576e-01f, -6.29010051e-02f, 3.94874476e-02f, 3.93475965e-02f, 4.09076782e-03f, -3.09591349e-02f, -3.95499542e-02f,
  2.58628100e-01f, 4.98282351e-02f, 2.44928867e-01f, 3.17437232e-01f, 2.11733636e-02f, -2.91947126e-01f, -1.39807925e-01f, 1.29331127e-01f, 1.40816838e-01f, -1.86491892e-01f,
  1.97698991e-03f, 7.48587027e-03f, -1.69634387e-01f, 1.99676231e-01f, 1.48957931e-02f, -1.19054712e-01f, 4.52117547e-02f, 2.79162582e-02f, 6.40840530e-02f, 1.56652585e-01f,
  1.60203427e-01f, -2.82570962e-02f, 9.61619765e-02f, -9.48768407e-02f, -2.59556770e-02f, 2.16748789e-01f, 1.57869801e-01f, -1.73768285e-03f, 7.28539973e-02f, -9.83035937e-02f,
  -4.17297632e-02f, -7.89985526e-03f, 2.13791803e-02f, -3.36501263e-02f, 4.14563455e-02f, -5.57445437e-02f, -3.15839164e-02f, -4.92061712e-02f, 1.05562292e-01f, 3.36435661e-02f,
  -2.27678996e-02f, -8.31412748e-02f, -3.22477594e-02f, -3.47894765e-02f, -3.32279280e-02f, 3.62245478e-02f, 5.79026975e-02f, 4.47029173e-02f, -1.13665223e-01f, -3.04983351e-02f,
  -5.40106222e-02f, 7.72912055e-02f, 1.12401485e-01f, 7.23580876e-03f, 8.22418332e-02f, 8.73751342e-02f, -1.14316233e-01f, 1.47117138e-01f, 2.73889434e-02f, 8.79955217e-02f,
  6.76576002e-03f, -1.93143040e-02f, -3.87980677e-02f, 1.06357880e-01f, 5.38275950e-02f, -5.78629561e-02f, 4.28374968e-02f, -6.52169734e-02f, 1.17714666e-01f, 2.53753476e-02f,
  9.23415422e-02f, 1.55488953e-01f, -1.54369716e-02f, 3.08951270e-03f, 5.09044379e-02f, -1.09449677e-01f, 6.48532659e-02f, -4.44666483e-04f, 1.32824942e-01f, 1.18228393e-02f,
  -1.33139744e-01f, -4.15754244e-02f, 8.43929350e-02f, -8.72817934e-02f, -9.27026663e-03f, -2.11682413e-02f, -5.13651930e-02f, 4.26393049e-03f, -2.27933917e-02f, -1.11289039e-01f,
  2.92369723e-03f, 3.47521752e-02f, 6.24227375e-02f, -4.08238769e-02f, 5.45719154e-02f, 6.26498312e-02f, -8.51716623e-02f, -1.77703816e-02f, -4.38527577e-02f, -6.22278750e-02f,
  1.92159824e-02f, 3.96938762e-03f, 4.13729362e-02f, 2.43636183e-02f, 1.89696997e-02f, -1.19296880e-02f, 5.89345489e-03f, 4.28156182e-03f, -1.03618942e-01f, 5.36521748e-02f,
  -8.11882224e-03f, 1.56016070e-02f, 2.61802915e-02f, 1.33354291e-01f, -9.42455232e-02f, 6.21486902e-02f, 1.97454412e-02f, -3.51147763e-02f, -4.18468891e-03f, -4.02402803e-02f,
  1.78321019e-01f, -1.31320991e-02f, -1.10771611e-01f, -2.67943349e-02f, 1.26522139e-01f, 1.64468493e-02f, -1.83313079e-02f, 3.12159080e-02f, -1.62060678e-01f, 1.09237909e-01f,
  -4.03113430e-03f, -1.01730652e-01f, -1.28198266e-01f, -1.12325631e-01f, -1.82393596e-01f, -2.23174453e-01f, 1.55804351e-01f, 7.08458945e-02f, -1.24163739e-01f, 5.79250120e-02f,
  -9.28425416e-02f, 1.20790198e-01f, -2.03465432e-01f, 7.55515471e-02f, 1.35568768e-01f, 5.80482520e-02f, 1.72737300e-01f, -1.46114886e-01f, 9.94432643e-02f, 5.50888805e-03f,
  -5.67936972e-02f, -4.52876836e-02f, -4.83820885e-02f, 1.84125453e-03f, -3.08397077e-02f, -4.31684591e-03f, 1.02939252e-02f, -5.06001376e-02f, -1.22004367e-01f, -9.69066322e-02f,
  -1.03095965e-02f, 1.33887734e-02f, 1.12004444e-01f, -3.18728276e-02f, 7.83551410e-02f, -1.24996752e-01f, -1.04111865e-01f, 3.49170305e-02f, 1.95206478e-02f, -1.14750668e-01f,
  -6.99587585e-03f, 2.35072393e-02f, -3.72183099e-02f, -3.01298918e-03f, 1.76947447e-03f, -9.96173099e-02f, -8.24744701e-02f, 6.48050308e-02f, 8.70358385e-03f, 4.11949381e-02f,
  6.00642078e-02f, 9.77981389e-02f, 9.66246333e-03f, -1.04794782e-02f, -5.72759695e-02f, -9.14253742e-02f, 2.90733743e-02f, 3.42560932e-02f, -5.82431629e-02f, -7.22102746e-02f,
  -9.01337489e-02f, -3.65198553e-02f, -7.37550855e-02f, -3.82887985e-04f, 5.45358891e-03f, 6.81682229e-02f, 7.77984643e-03f, 7.32052773e-02f, 1.75643396e-02f, -3.05604953e-02f,
  -6.67615905e-02f, 3.11942641e-02f, -9.09846798e-02f, 9.70228016e-02f, 1.90629065e-02f, -5.30052977e-03f, 1.03207029e-01f, -4.61201966e-02f, -2.61340160e-02f, 3.71217169e-02f,
  4.80483472e-02f, 1.54861495e-01f, -4.48620506e-03f, 1.51375383e-02f, -1.00733824e-01f, -9.46038309e-03f, -6.72690617e-03f, 8.97186175e-02f, -7.43932426e-02f, -5.06144799e-02f,
  1.42132699e-01f, 3.37709598e-02f, 3.25005390e-02f, -2.97418088e-02f, -6.23069145e-02f, -8.05035084e-02f, -4.36448753e-02f, -1.61561766e-04f, 1.08181685e-01f, 2.54748072e-02f,
  1.30402416e-01f, 5.26946597e-02f, 2.53085420e-02f, 6.11506253e-02f, 5.56972018e-03f, 1.63028613e-02f, 6.43191114e-02f, -1.21294986e-02f, 1.02404088e-01f, -8.67225751e-02f,
  4.51571904e-02f, -1.15155987e-01f, 1.58422023e-01f, -1.60681397e-01f, 8.08158070e-02f, -1.80442125e-01f, -1.97513461e-01f, -3.06151323e-02f, 1.69006363e-01f, -9.53406394e-02f,
  1.81595720e-02f, 7.33720511e-02f, -7.43639395e-02f, -6.48493096e-02f, 5.52967340e-02f, -3.38309631e-02f, -1.73626766e-01f, -9.29652303e-02f, 1.49965063e-01f, -1.64744511e-01f,
  -3.67781403e-03f, -1.33715659e-01f, -1.06764130e-01f, 1.39047485e-03f, -4.24763709e-02f, -4.53636125e-02f, -6.31759539e-02f, 4.55418862e-02f, -3.14850323e-02f, 1.97681552e-03f,
  -1.81208238e-01f, -6.45145848e-02f, 1.02615040e-02f, 6.68351352e-02f, -3.53872105e-02f, 4.17302139e-02f, -5.67463189e-02f, 3.95491794e-02f, -5.31304977e-04f, -2.17163116e-02f,
  4.75913510e-02f, 1.19635398e-02f, 4.30412814e-02f, 1.10850208e-01f, -1.68074463e-02f, 8.81356969e-02f, 1.08855486e-01f, 3.56264748e-02f, -2.57097427e-02f, 1.12906344e-01f,
  1.04836881e-01f, -9.24924612e-02f, -6.00259267e-02f, 1.00920759e-01f, 7.73124397e-02f, -9.95400175e-03f, -5.58988266e-02f, 5.70120253e-02f, -8.48880187e-02f, 1.32200383e-02f,
  4.96565141e-02f, 7.80322179e-02f, 4.26647440e-02f, -3.83876897e-02f, -5.87035604e-02f, -1.08150821e-02f, -5.41735701e-02f, 2.34170072e-02f, -6.91364333e-02f, -7.77735934e-02f,
  -8.89347047e-02f, 9.05905217e-02f, -3.26633044e-02f, -1.56752795e-01f, -6.57781307e-03f, 4.64130789e-02f, -1.29867956e-01f, -1.04080401e-01f, -5.24925208e-03f, -6.20645806e-02f,
  1.75405424e-02f, 3.39360312e-02f, -1.78865213e-02f, 5.85291395e-03f, -4.14556600e-02f, -4.66349758e-02f, -1.04082763e-01f, 6.79425374e-02f, 7.59810656e-02f, 4.65409039e-03f,
  -4.07778829e-01f, -3.52545619e-01f, -6.22131899e-02f, -7.46187344e-02f, -1.01742558e-01f, -8.59773904e-02f, -1.10506028e-01f, 1.37147857e-02f, -1.34352461e-01f, 3.74952815e-02f,
  -6.83426484e-02f, -7.91501552e-02f, 6.36917576e-02f, 3.72503512e-03f, 4.60904688e-02f, 1.05346225e-01f, -5.43292128e-02f, -8.47715363e-02f, -1.70979530e-01f, -2.35150047e-02f,
  -4.76215743e-02f, 5.11297248e-02f, 6.03903942e-02f, -6.62928745e-02f, -5.27424328e-02f, -9.82141048e-02f, 7.02271163e-02f, -6.58793421e-03f, -4.67072576e-02f, -3.48428488e-02f,
  2.37043351e-01f, -1.19340613e-01f, 2.91136168e-02f, 1.09499976e-01f, 1.94368735e-01f, -1.99248552e-01f, -4.32299376e-02f, 1.28446952e-01f, 1.71152651e-01f, -1.17203966e-01f,
  -1.27418295e-01f, -1.81717291e-01f, -1.41609356e-01f, -1.44056976e-01f, 1.62075296e-01f, -1.38876989e-01f, 1.17381155e-01f, -1.92853257e-01f, 1.40169680e-01f, -9.52684507e-02f,
  6.16241992e-02f, 1.37599558e-01f, 1.62299007e-01f, 6.13255203e-02f, 1.39349550e-01f, 1.84192792e-01f, -1.44940661e-02f, -3.06607448e-02f, 3.81137920e-03f, 3.82435769e-02f,
  1.46826152e-02f, -1.60137601e-02f, 4.50001359e-02f, -3.17490585e-02f, -5.04101254e-03f, -4.01511900e-02f, -1.49454087e-01f, -1.53233618e-01f, -3.17922272e-02f, -1.15857817e-01f,
  -3.30758765e-02f, 5.14409281e-02f, 1.50108589e-02f, 4.25077276e-03f, 2.51558572e-02f, 5.14607765e-02f, 2.37216931e-02f, 1.30897805e-01f, 3.59256379e-02f, -8.97638649e-02f,
  -6.10421114e-02f, -5.23504019e-02f, 1.06163941e-01f, -6.66770339e-02f, -4.10797074e-03f, 6.26784414e-02f, 3.52005996e-02f, -9.48914438e-02f, 4.77515208e-03f, 8.43060687e-02f,
  -1.08615436e-01f, 1.11451343e-01f, 4.51422483e-02f, 1.66590825e-01f, 2.49058306e-02f, 3.62228677e-02f, 7.45611116e-02f, -9.92445946e-02f, -1.87161285e-02f, -1.47677690e-03f,
  4.34533656e-02f, -9.72236544e-02f, 3.25590000e-02f, -7.67593682e-02f, -1.20297626e-01f, 1.13129854e-01f, -5.92731163e-02f, -1.43443584e-01f, -3.40140499e-02f, 1.29831523e-01f,
  -5.22690080e-02f, 8.59083049e-03f, -4.85187136e-02f, 9.08623263e-02f, -7.07985088e-02f, -8.97426903e-02f, -3.24076973e-02f, 3.83173116e-02f, 7.24352747e-02f, 8.73075202e-02f,
  -2.47798692e-02f, -1.66954800e-01f, -9.63467956e-02f, 5.34319729e-02f, -4.01855819e-02f, 4.68331650e-02f, -9.92979780e-02f, -5.46837896e-02f, -8.38389993e-02f, 9.91487503e-03f,
  -4.17181924e-02f, -2.74488274e-02f, -6.50785351e-03f, -3.01165525e-02f, 5.57591692e-02f, -5.32252714e-02f, -7.82637969e-02f, -5.27551323e-02f, 1.50441853e-02f, -1.05262160e-01f,
  -6.10090084e-02f, -1.81500107e-01f, 6.55042902e-02f, 8.71595889e-02f, 3.31460312e-02f, -1.62656039e-01f, 7.90859312e-02f, -1.07443862e-01f, -2.48129647e-02f, 1.17176689e-01f,
  -6.94515780e-02f, -5.05239181e-02f, -9.17855427e-02f, 8.68220627e-02f, 3.81994881e-02f, -2.13191822e-01f, -2.31252894e-01f, 3.99960624e-03f, -4.50004153e-02f, -1.98747292e-02f,
  -2.24075481e-01f, 1.25284433e-01f, -2.46084690e-01f, 7.50103639e-03f, -2.07333982e-01f, -2.52941787e-01f, 6.87859654e-02f, 8.55663233e-03f, -3.13691422e-02f, 2.78419945e-02f,
  -1.83003005e-02f, 5.76446839e-02f, 5.44074588e-02f, 1.96717620e-01f, 7.90759549e-02f, 1.16093531e-01f, 2.27421656e-01f, -1.02961119e-02f, 2.65827537e-01f, 5.51682413e-02f,
  5.80300577e-02f, -7.34767988e-02f, 1.35610297e-01f, -1.88450124e-02f, -7.79086575e-02f, 8.95891339e-03f, 1.55623630e-02f, 4.52517308e-02f, -4.28340584e-02f, -9.07105729e-02f,
  3.66946533e-02f, 9.29052308e-02f, 1.07312284e-01f, 3.09793465e-02f, 9.05537829e-02f, 9.97366309e-02f, -7.26163713e-03f, -5.33191906e-03f, 9.77537856e-02f, -6.45459890e-02f,
  1.39350854e-02f, 5.30027151e-02f, 5.62090948e-02f, 5.34575693e-02f, 6.05804324e-02f, -2.28158882e-04f, -2.87311487e-02f, 5.46122976e-02f, -5.84387705e-02f, 9.09609944e-02f,
  -1.51568251e-02f, 9.13264044e-03f, -2.06848644e-02f, -4.08343300e-02f, -4.67299335e-02f, 2.15296689e-02f, -1.42592536e-02f, 1.20640546e-02f, 4.37260158e-02f, -8.92983079e-02f,
  4.14597131e-02f, 1.06032223e-01f, -4.85047996e-02f, 3.76666188e-02f, -6.47111535e-02f, 9.18019190e-02f, -3.19491215e-02f, -4.99756485e-02f, -1.44736748e-02f, 4.73019965e-02f,
  7.53356367e-02f, -6.47084787e-02f, -1.72187779e-02f, 4.84237894e-02f, -3.57941799e-02f, -2.80809533e-02f, -1.01387957e-02f, 4.30197679e-02f, -1.90762393e-02f, 4.53484170e-02f,
  -4.32742871e-02f, -4.47092429e-02f, -5.29730991e-02f, 9.65624377e-02f, -3.52470912e-02f, 4.12750058e-02f, 6.95674643e-02f, 7.92221501e-02f, -2.68086884e-02f, -1.42701194e-01f,
  1.07276388e-01f, -3.83971930e-02f, -8.34232792e-02f, 1.07389331e-01f, 7.21407011e-02f, -6.44605979e-02f, 3.32369879e-02f, -2.77125183e-02f, 1.18695132e-01f, 9.03089568e-02f,
  -3.22419703e-02f, -1.04996324e-01f, 4.22604494e-02f, -2.41889544e-02f, 2.27394737e-02f, -2.66533010e-02f, -4.30321582e-02f, 3.12240273e-02f, 7.99090788e-02f, 1.83974504e-02f,
  1.96030185e-01f, 9.16993096e-02f, -1.75883979e-01f, 1.62753239e-01f, -7.78451860e-02f, 5.15345410e-02f, -1.59439649e-02f, 8.97385255e-02f, -5.60403196e-03f, 4.20522131e-02f,
  1.41159654e-01f, -6.79793730e-02f, 2.06419243e-03f, 2.20456809e-01f, 2.35620990e-01f, 1.14368901e-01f, 2.63389468e-01f, 4.22713235e-02f, 7.35148191e-02f, 1.12093613e-01f,
  7.40297660e-02f, 2.23239750e-01f, -4.03044336e-02f, 2.81565953e-02f, 1.17260829e-01f, 1.28303329e-02f, -5.14752939e-02f, -1.41832352e-01f, 3.73476334e-02f, -1.17794937e-02f,
  4.00206782e-02f, 8.66544619e-02f, 3.77152190e-02f, 2.97595672e-02f, -2.59558558e-02f, 3.77788469e-02f, -2.93484014e-02f, -6.74192533e-02f, 9.84799955e-03f, 1.12519883e-01f,
  -4.67910208e-02f, 7.35473586e-03f, 9.20070931e-02f, 3.21037993e-02f, -1.46748042e-02f, -7.01260194e-03f, -1.34430408e-01f, -2.83263978e-02f, -5.69980890e-02f, -3.77710313e-02f,
  4.32136580e-02f, 3.79335172e-02f, 4.78018932e-02f, -2.39981189e-02f, -6.97985217e-02f, -8.57344046e-02f, -1.06580295e-01f, -7.24651664e-02f, 3.17426361e-02f, -3.97932120e-02f,
  9.76475626e-02f, 7.24999309e-02f, 1.14702858e-01f, 9.64010227e-03f, -2.57098265e-02f, -2.56421603e-02f, 6.25884673e-03f, 5.90850115e-02f, -4.93236165e-03f, 8.81024748e-02f,
  -4.91106436e-02f, 3.26485746e-02f, 9.83971283e-02f, -1.77635513e-02f, 9.38650146e-02f, 9.23217461e-02f, -8.05842057e-02f, 1.45778721e-02f, -4.30327170e-02f, -1.22606166e-01f,
  -3.20259929e-02f, 3.71672623e-02f, 2.59218924e-02f, -9.73650292e-02f, -4.00689840e-02f, -4.47378568e-02f, 1.50626332e-01f, 3.45058106e-02f, -1.32773817e-01f, -6.79413304e-02f,
  6.05321340e-02f, 1.07595488e-01f, -1.08623795e-01f, -1.18346624e-01f, -1.07510015e-01f, -5.00010103e-02f, -2.22198311e-02f, 1.01629116e-01f, 3.57179940e-02f, 8.02995414e-02f,
  -1.18591301e-02f, -1.81952231e-02f, 4.95953970e-02f, 3.36782709e-02f, -4.94144037e-02f, 1.71311814e-02f, 8.96939859e-02f, -3.88438180e-02f, -2.48998925e-02f, -2.97335219e-02f,
  -4.51387055e-02f, 1.13698244e-02f, 1.33649714e-03f, -8.39987695e-02f, 9.59014371e-02f, -3.88986990e-03f, -5.03230914e-02f, -3.16686109e-02f, -1.47990780e-02f, -4.26704921e-02f,
  3.84026796e-01f, -1.81485415e-01f, 2.50462979e-01f, 2.37023592e-01f, 1.78498045e-01f, 5.22254817e-02f, 2.55760014e-01f, 4.51927073e-02f, 1.91668808e-01f, -1.05783023e-01f,
  -1.59057185e-01f, 7.24791884e-02f, -1.34679943e-01f, -5.71409799e-02f, 1.01495989e-01f, -2.05317914e-01f, -2.97972225e-02f, 2.23918930e-02f, 9.51881856e-02f, 1.39133399e-02f,
  1.15049168e-01f, -1.04468517e-01f, 7.67832447e-04f, -8.30854177e-02f, 4.54034768e-02f, 7.84348920e-02f, -1.05309844e-01f, -5.12082763e-02f, -3.64529938e-02f, -5.45032509e-02f,
  -8.67299065e-02f, 5.77515848e-02f, -5.10595851e-02f, -4.46174853e-02f, -9.41921622e-02f, -5.55344336e-02f, 5.49663743e-03f, 4.53672558e-02f, -1.30261838e-01f, 2.87853926e-02f,
  -5.16912490e-02f, 3.32440846e-02f, 1.24816254e-01f, 8.11520740e-02f, -4.65044528e-02f, 1.73625164e-02f, 1.22847536e-03f, -1.03594260e-02f, 1.08555831e-01f, -3.98814827e-02f,
  1.29068822e-01f, 7.36403242e-02f, -3.25882621e-02f, 4.13868688e-02f, -2.96747722e-02f, -1.28396498e-02f, 5.99699654e-02f, -8.31801444e-02f, -8.87625962e-02f, 3.25949490e-02f,
  -3.91338058e-02f, -8.53704363e-02f, -5.90107515e-02f, -5.99116981e-02f, -1.09168133e-02f, 4.73934924e-03f, 3.02657094e-02f, -3.74460570e-03f, -3.86565588e-02f, 5.75274043e-03f,
  1.83857232e-02f, 7.13229403e-02f, 8.10481906e-02f, -1.37959225e-02f, 2.47491803e-02f, 6.56065047e-02f, -2.05298215e-02f, 9.59707424e-02f, 5.77636100e-02f, 1.38444302e-04f,
  2.47724298e-02f, -3.76015306e-02f, -4.23806049e-02f, 5.17436974e-02f, 6.70592412e-02f, 4.01696488e-02f, 2.86411550e-02f, -1.74122695e-02f, -7.37378225e-02f, -2.26510037e-02f,
  -3.61812770e-01f, -2.35081837e-01f, -6.94119707e-02f, -2.71960367e-02f, -9.42971706e-02f, -5.61517850e-02f, 9.18980986e-02f, 6.86439350e-02f, -1.32028788e-01f, -1.72875188e-02f,
  5.71557432e-02f, -1.09505765e-02f, 1.00245681e-02f, 9.35936347e-03f, -1.01454347e-01f, 3.25704403e-02f, 9.86147225e-02f, -2.16201827e-01f, -2.75301989e-02f, -8.83490890e-02f,
  -3.83824408e-02f, 9.82453395e-03f, -1.07239082e-01f, 5.50144464e-02f, -1.42926062e-02f, 4.94307168e-02f, 7.86322355e-02f, -8.93795267e-02f, -5.63310310e-02f, 1.59327351e-02f,
  1.28220990e-02f, 6.65057823e-02f, -1.47286430e-01f, 3.20003252e-03f, -2.39754930e-01f, 6.71507642e-02f, 4.00184691e-02f, -9.90923941e-02f, -9.25022364e-02f, 2.08488271e-01f,
  1.45077392e-01f, 2.10619322e-03f, 5.80452606e-02f, 2.62302786e-01f, -1.78092569e-02f, 2.73943663e-01f, 1.40918165e-01f, 1.79041579e-01f, -3.37773003e-02f, 7.82524794e-02f,
  1.31063104e-01f, 2.60465801e-01f, 9.15548280e-02f, 3.57123055e-02f, 9.20125023e-02f, -1.26866311e-01f, 1.63160592e-01f, -5.59601970e-02f, 7.43846595e-02f, -4.37294990e-02f,
  1.00054651e-01f, 1.02730356e-01f, 4.41766120e-02f, 1.62951387e-02f, -5.00915907e-02f, 4.04831916e-02f, 4.61349972e-02f, -5.57586662e-02f, -1.45499676e-01f, -3.92511394e-03f,
  2.11096667e-02f, -5.76044549e-04f, -6.30578212e-03f, -7.67774060e-02f, -3.91852818e-02f, -2.50580572e-02f, -6.73740804e-02f, -7.02948719e-02f, 8.37039109e-03f, -8.90650973e-02f,
  3.48525830e-02f, 7.77440891e-02f, -3.15257534e-02f, -1.31437299e-03f, -3.40080559e-02f, 1.27213891e-03f, 2.29176451e-02f, 6.91164285e-02f, -6.65735379e-02f, 4.52650189e-02f,
  1.06840298e-01f, -4.19861078e-02f, 9.60815698e-02f, -3.80856395e-02f, 9.76092368e-02f, 3.75063457e-02f, 3.83557789e-02f, -4.55232011e-03f, -5.82540371e-02f, 1.45433377e-02f,
  5.64203635e-02f, -7.29639083e-02f, -2.79395040e-02f, 4.59424481e-02f, 4.39066701e-02f, -2.78801825e-02f, -4.98478264e-02f, -1.58962104e-02f, -1.13449097e-01f, 1.92055702e-02f,
  -2.51567760e-03f, -6.73064496e-03f, -2.90065445e-02f, 7.84063563e-02f, -2.12807506e-02f, -1.01771310e-01f, 5.02148420e-02f, 6.20442294e-02f, -1.11662805e-01f, -5.77134751e-02f,
  1.13254070e-01f, 2.89438814e-02f, 6.17453307e-02f, -1.08591765e-01f, 3.14496853e-03f, 7.28924274e-02f, 8.23153257e-02f, 1.19334921e-01f, 7.57706165e-02f, 1.23588659e-01f,
  -5.99086285e-02f, 2.77404804e-02f, 2.14243084e-02f, -1.05085753e-01f, -3.16997468e-02f, -2.73907129e-02f, -1.30913500e-02f, -1.27413133e-02f, -9.48318318e-02f, -8.05485547e-02f,
  -8.13742802e-02f, 8.74816626e-02f, -5.12783602e-02f, 6.92252964e-02f, -7.42998943e-02f, 4.63188775e-02f, -3.26608606e-02f, -8.58422276e-03f, -3.35727297e-02f, 5.78135997e-02f,
  -2.06701905e-01f, -6.11442327e-03f, -1.41043693e-01f, -4.92722020e-02f, -2.61172280e-02f, 9.24770162e-02f, 8.27793553e-02f, -4.04088050e-02f, -2.17828944e-01f, 1.40421361e-01f,
  1.57473296e-01f, -1.30941391e-01f, 1.20394394e-01f, 4.20222402e-01f, 2.20416769e-01f, 1.98595837e-01f, 2.84604460e-01f, 1.84906483e-01f, -6.74367547e-02f, -6.88406155e-02f,
  4.81726006e-02f, 1.95575297e-01f, 2.35449344e-01f, 4.16393019e-02f, 8.36128891e-02f, -8.09486657e-02f, 3.47461812e-02f, -1.78623825e-01f, 1.55805036e-01f, 7.86724314e-02f,
  6.69512302e-02f, 2.00692024e-02f, -9.01710987e-02f, -8.68957564e-02f, 6.21107519e-02f, -1.27413109e-01f, -1.70500558e-02f, -1.04743741e-01f, -2.36009154e-02f, -1.18412925e-02f,
  -4.64736558e-02f, -4.56201695e-02f, 8.59283507e-02f, -5.19968271e-02f, -3.19859423e-02f, -8.06837007e-02f, -1.10506061e-02f, 3.33082629e-03f, 1.66172832e-02f, -2.01248880e-02f,
  -5.92545141e-03f, -5.43302372e-02f, -4.47097830e-02f, 7.52814487e-03f, -2.76392046e-02f, 7.26274922e-02f, -2.67366488e-02f, -8.76796022e-02f, 4.53720354e-02f, 2.97388360e-02f,
  -6.40727356e-02f, -4.40273527e-03f, -4.00341265e-02f, 6.51228661e-03f, -1.41332820e-02f, 2.26143505e-02f, 2.30235308e-02f, 6.07478134e-02f, -9.74987894e-02f, -1.07994191e-02f,
  3.05164922e-02f, 5.98357320e-02f, -4.09942307e-02f, 4.79528401e-03f, 4.74115275e-02f, 8.74331221e-02f, -6.51268363e-02f, 3.98653708e-02f, -4.39063311e-02f, 8.90723616e-02f,
  -5.46224825e-02f, 3.70331481e-02f, -3.09003778e-02f, -1.97222531e-02f, 9.52884555e-02f, -7.36423433e-02f, -2.30440758e-02f, 1.68338395e-03f, -8.25312138e-02f, -7.70015121e-02f,
  6.05184957e-02f, -7.86863863e-02f, -2.48484593e-02f, 4.89704385e-02f, 3.15283425e-02f, -4.45980765e-02f, -3.71894725e-02f, -2.34592371e-02f, 2.64630802e-02f, -8.59130323e-02f,
  -4.19817790e-02f, 1.56995989e-02f, 5.58453463e-02f, 4.47934680e-02f, 8.33471417e-02f, 1.78702399e-02f, 3.91627327e-02f, -9.77541357e-02f, -4.63435538e-02f, 3.56697217e-02f,
  6.24423474e-02f, 2.57968847e-02f, 5.43132238e-03f, -2.70545040e-03f, 1.36810437e-01f, -3.50749157e-02f, 4.28076275e-02f, -8.02454948e-02f, 1.53876208e-02f, 1.10840201e-02f,
  -2.94055939e-01f, 1.14290632e-01f, 8.60666409e-02f, -2.32878894e-01f, -4.66768853e-02f, 9.30626094e-02f, -1.01132683e-01f, -8.54452886e-03f, 1.85106735e-04f, 4.37894948e-02f,
  -7.84662589e-02f, 5.81540540e-03f, 2.17085913e-01f, -9.19551477e-02f, 1.42648831e-01f, 2.66809136e-01f, -8.36613402e-02f, -1.22692831e-01f, 1.75885540e-02f, -1.17650613e-01f,
  -1.16750477e-02f, 5.36955558e-02f, 1.05730153e-03f, 7.16612041e-02f, -2.51957141e-02f, -8.54588374e-02f, -5.58123626e-02f, 6.73267320e-02f, -1.14875302e-01f, -1.26987128e-02f,
  -1.05503477e-01f, -1.60550877e-01f, 4.35122065e-02f, 1.93527937e-02f, -8.42467472e-02f, 2.18106993e-03f, 3.26582901e-02f, 8.54423121e-02f, -1.73019208e-02f, -4.38240357e-02f,
  4.44614664e-02f, -2.58906744e-02f, 1.67022217e-02f, 1.82959973e-03f, 3.62385623e-02f, -5.78000993e-02f, -8.80125016e-02f, -7.66906235e-03f, 2.34166365e-02f, 9.40432176e-02f,
  -6.45837886e-03f, -7.47984424e-02f, -7.82247260e-03f, -1.77706014e-02f, 3.01443040e-03f, -8.95975381e-02f, -1.87657885e-02f, 8.99087265e-02f, -2.13212203e-02f, -6.51209950e-02f,
  -1.64766274e-02f, -4.76083420e-02f, -4.54123244e-02f, -2.41628699e-02f, -5.73958382e-02f, 2.83427676e-03f, -6.03884198e-02f, -9.73401368e-02f, -8.21732730e-02f, -1.06982887e-01f,
  -8.12477544e-02f, 4.43951264e-02f, -4.92680073e-02f, -2.94629876e-02f, -1.54540790e-02f, -3.44762690e-02f, -2.81768199e-02f, -9.46365222e-02f, -3.15316543e-02f, 2.83765234e-02f,
  1.47853484e-02f, 1.78519636e-02f, -2.62091327e-02f, 1.11124054e-01f, -3.93285453e-02f, 6.74149916e-02f, 1.07897528e-01f, -2.20113099e-02f, 1.13056123e-01f, -1.00852907e-01f,
  -2.54040092e-01f, -8.91907141e-02f, -5.52949607e-02f, -6.56165034e-02f, 9.49097052e-02f, 2.09707078e-02f, 5.00666425e-02f, 7.08435848e-02f, -9.13403276e-03f, 7.01449811e-02f,
  -1.02360040e-01f, -9.27012712e-02f, -4.84068356e-02f, 7.43887946e-02f, 3.35425362e-02f, 4.76774424e-02f, 4.04869206e-02f, 4.09338176e-02f, 3.91313992e-02f, -6.98969811e-02f,
  -1.12181805e-01f, 7.99597427e-03f, -2.53165308e-02f, 3.98604497e-02f, -8.19072202e-02f, -1.04907580e-01f, -7.41511807e-02f, 4.73343618e-02f, -2.02853605e-02f, 3.35756280e-02f,
  6.07619174e-02f, -1.63767844e-01f, 1.12887308e-01f, 6.78572729e-02f, 2.76153862e-01f, 1.07891671e-01f, 1.17288806e-01f, 1.10256091e-01f, -9.69468504e-02f, -2.36975431e-01f,
  -1.34740591e-01f, -2.02927604e-01f, -1.68643236e-01f, -1.34982467e-01f, 1.47523910e-01f, -1.30402923e-01f, 2.46783141e-02f, -5.61761223e-02f, 2.84811575e-02f, -1.28206089e-01f,
  -7.28341751e-03f, 1.90342337e-01f, 1.73746303e-01f, 2.13465914e-01f, 1.49545163e-01f, 1.00029990e-01f, -8.27563554e-02f, 1.20841287e-01f, 3.10281999e-02f, -2.90080137e-03f,
  -1.69424757e-01f, -2.05136105e-01f, -1.19478151e-01f, -7.40838125e-02f, 4.21877764e-02f, -8.41599554e-02f, -5.92204630e-02f, 8.82084146e-02f, -1.56589672e-02f, -2.53437622e-03f,
  -5.76925389e-02f, -1.32620316e-02f, 8.89882818e-02f, 9.41242557e-03f, 8.72996375e-02f, 1.07872531e-01f, -2.33276933e-02f, -3.38933952e-02f, 2.70418040e-02f, 9.98540502e-03f,
  2.53645014e-02f, -9.46704019e-03f, -4.62786779e-02f, 4.45855819e-02f, 2.41835993e-02f, -1.13099385e-02f, -2.79005971e-02f, 3.47857773e-02f, -6.72986789e-04f, -1.62310395e-02f,
  1.33181840e-01f, 5.67304669e-04f, -6.18769452e-02f, -6.80938214e-02f, -1.33252993e-01f, 6.90440610e-02f, 5.98751418e-02f, -9.08744410e-02f, -5.66054322e-03f, 9.05438736e-02f,
  5.64790443e-02f, 3.41520458e-02f, 3.92752327e-02f, 2.55629770e-03f, 3.72136720e-02f, 2.48773098e-02f, 5.24867177e-02f, -1.10528275e-01f, -7.13933557e-02f, 2.73291413e-02f,
  3.70257325e-03f, -5.68278469e-02f, -4.29644249e-02f, 7.44142085e-02f, -9.13650393e-02f, -3.71954255e-02f, -1.69075988e-02f, 1.87848955e-02f, -5.17332628e-02f, 3.11757233e-02f,
  -4.11012411e-01f, -2.57355154e-01f, -5.30879088e-02f, -8.98509845e-02f, -6.73745796e-02f, -2.65738238e-02f, -2.73683947e-02f, 2.98746601e-02f, -3.54948528e-02f, -7.43452981e-02f,
  -8.21362212e-02f, 8.97846147e-02f, -1.41838372e-01f, -2.41219606e-02f, -2.15830766e-02f, 7.01172128e-02f, -1.44952148e-01f, -9.92933959e-02f, -1.37048692e-01f, -8.01923722e-02f,
  -3.87523547e-02f, -1.73737593e-02f, 4.26823944e-02f, 1.04413934e-01f, -1.10270679e-01f, 1.38891977e-03f, -6.20465316e-02f, -4.91385497e-02f, 3.58417369e-02f, -5.21014370e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  3.04913610e-01f, 1.69884458e-01f, 2.40286589e-01f, 1.90933287e-01f, 1.41592130e-01f, 3.20855714e-03f, -2.43779756e-02f, 2.35471547e-01f, 3.98200974e-02f, 1.76734358e-01f,
  4.26760763e-02f, 1.62958294e-01f, -7.25696683e-02f, 7.83076212e-02f, 2.92365402e-01f, 2.04966918e-01f, 1.56236678e-01f, 1.66817591e-01f, 1.05698697e-01f, 1.62244573e-01f,
  2.33106762e-01f, 1.12225287e-01f, 2.15055555e-01f, 1.12233475e-01f, 3.51370275e-02f, 5.39225675e-02f, 3.05810273e-01f, 1.88003555e-01f, 2.06422791e-01f, 5.76794781e-02f,
  2.68452913e-01f, 2.06737027e-01f, 3.85581739e-02f, 1.24736242e-01f, 1.11624897e-01f, 2.87702292e-01f, 2.30586141e-01f, 1.86331093e-01f, 2.27515295e-01f, 2.11974785e-01f,
  4.27166522e-02f, 1.72988728e-01f, 7.99720287e-02f, 1.67205423e-01f, 2.96885997e-01f, 5.49815372e-02f, 2.30345294e-01f, 2.72856712e-01f, 5.53025417e-02f, 1.97783098e-01f,
  1.80311427e-01f, 2.22678348e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.79312110e-01f, 1.82728693e-02f, 3.82022224e-02f, 7.49635324e-02f, -1.32021740e-01f, 2.44265795e-02f, 1.00997098e-01f, -1.38458267e-01f, 9.16377977e-02f, 2.23311022e-01f,
  -1.11133575e-01f, -4.76377383e-02f, -7.17194751e-02f, 4.12050113e-02f, -1.78744465e-01f, 4.30904552e-02f, -5.16027436e-02f, 1.02895774e-01f, 5.18771261e-02f, 9.54753235e-02f,
  1.13772698e-01f, 8.60559344e-02f, 2.15810865e-01f, 1.77042827e-01f, 5.44175692e-02f, -1.57266520e-02f, 1.99158979e-03f, 4.57827598e-02f, 1.70197055e-01f, 1.14920996e-01f,
  -2.06723846e-02f, 1.03581935e-01f, -6.81953952e-02f, 8.32028594e-03f, -1.08565710e-01f, 2.44901389e-01f, 1.69701681e-01f, -1.44059174e-02f, -2.11603582e-01f, -5.52033558e-02f,
  -1.90900087e-01f, 9.97881964e-02f, 1.70553312e-01f, 1.61726568e-02f, 1.59105465e-01f, 2.38030795e-02f, -7.31290206e-02f, 2.01265708e-01f, 1.12329107e-02f, -3.39134857e-02f,
  1.21386625e-01f, 4.94143479e-02f, 1.59861609e-01f, 3.87384892e-02f, -7.81930611e-02f, 2.43043303e-02f, 6.34431541e-02f, 8.38382021e-02f, -1.62944421e-01f, -5.29384986e-03f,
  7.59514794e-02f, 2.07435772e-01f, 7.21636936e-02f, 2.09098607e-02f, 1.05782732e-01f, -7.82572627e-02f, -8.81440118e-02f, 1.15631372e-01f, -6.78823004e-03f, 8.88248011e-02f,
  1.98598504e-01f, 2.34352753e-01f, -1.39824867e-01f, -7.76524236e-03f, -1.70320310e-02f, -2.36564633e-02f, -2.85869211e-01f, -1.41070217e-01f, 7.18725845e-02f, -1.89949069e-02f,
  -2.14056179e-01f, -2.29224786e-01f, -1.64013177e-01f, -1.94970042e-01f, -1.73082352e-02f, -6.83401451e-02f, -3.08686476e-02f, 5.94241396e-02f, 1.73077688e-01f, 1.80067956e-01f,
  1.38871416e-01f, -8.14394951e-02f, -3.13584685e-01f, 2.33202726e-02f, 2.30134264e-01f, 7.57339969e-02f, 8.32385756e-03f, -5.40586151e-02f, -1.97851546e-02f, 3.33684310e-02f,
  -7.12496936e-02f, -8.50608572e-02f, 6.12678099e-03f, -1.19019702e-01f, 4.19769362e-02f, -2.14471370e-02f, -1.78299621e-01f, -1.03988163e-01f, -1.92305475e-01f, 4.05353010e-02f,
  -2.59558540e-02f, 2.21628677e-02f, 1.11237012e-01f, 3.24545801e-02f, 5.35629578e-02f, 9.14707035e-02f, 1.43952087e-01f, -1.20438859e-01f, 9.47352406e-03f, -1.45477846e-01f,
  -1.07810445e-01f, -2.77158141e-01f, 2.42492005e-01f, -2.01639552e-02f, 1.55016512e-01f, -3.32729816e-02f, -1.21158779e-01f, -8.66373926e-02f, -4.23889123e-02f, -2.04601306e-02f,
  9.00749639e-02f, 8.29417929e-02f, 3.45965102e-02f, 1.05337910e-02f, -7.31658414e-02f, 3.67288701e-02f, 5.04028462e-02f, -8.98737907e-02f, 3.88500281e-03f, -2.43726950e-02f,
  -3.18467617e-02f, 6.98919520e-02f, 6.98980540e-02f, -8.80585983e-03f, 8.41504615e-03f, -3.41627710e-02f, 1.70483813e-01f, 1.68757975e-01f, 1.74764410e-01f, -1.38022438e-01f,
  -1.08053446e-01f, -6.56571463e-02f, -7.84707591e-02f, -6.22766688e-02f, 9.55007449e-02f, -7.93385506e-02f, -1.55064836e-01f, -1.20430224e-01f, 1.79999605e-01f, -9.44731385e-02f,
  1.08515717e-01f, -8.40644613e-02f, 5.86932385e-03f, 7.57027641e-02f, 1.13688618e-01f, -7.95282349e-02f, 1.51583878e-02f, 1.45295516e-01f, 1.98183209e-01f, -6.24658018e-02f,
  -7.10910484e-02f, -3.40433791e-02f, -1.05039537e-01f, -1.06242485e-01f, -2.06279773e-02f, -1.49499968e-01f, 1.90781787e-01f, 6.98904097e-02f, 2.84817498e-02f, -5.16372616e-04f,
  3.86828594e-02f, -1.73120573e-01f, -1.26800269e-01f, -1.80847421e-01f, -1.89597756e-01f, -1.02786735e-01f, -1.31847307e-01f, -6.99350685e-02f, 2.21151728e-02f, 7.82514960e-02f,
  1.78949863e-01f, -8.03306103e-02f, -1.28808871e-01f, -7.31228814e-02f, -8.51596333e-03f, 1.47525355e-01f, -6.03010058e-02f, 7.52949268e-02f, 2.10496739e-01f, -6.59678355e-02f,
  -2.43324619e-02f, -1.67973310e-01f, 1.48123860e-01f, -2.41413817e-01f, -1.89214259e-01f, -2.22512975e-01f, -9.96878222e-02f, -4.94133309e-02f, -1.54317468e-01f, -1.05237678e-01f,
  -2.19616383e-01f, -4.16621342e-02f, -1.30819440e-01f, 2.64487445e-01f, -2.62818951e-02f, 1.38482274e-02f, -9.89549160e-02f, -1.14020102e-01f, 6.87841035e-04f, -1.98301837e-01f,
  -1.05614685e-01f, 5.85549287e-02f, -1.46910310e-01f, 2.99605668e-01f, -1.20843850e-01f, 5.38255740e-03f, 4.44225734e-03f, 2.14174688e-02f, 9.81598273e-02f, -1.17602795e-01f,
  -7.76661932e-03f, -2.51042753e-01f, -8.17861035e-02f, -1.03566028e-01f, 1.08963721e-01f, 6.81585968e-02f, 3.41603197e-02f, -1.38265908e-01f, -1.74075559e-01f, 1.01520360e-01f,
  -5.54501228e-02f, 5.40500954e-02f, 1.50910437e-01f, 3.19646485e-02f, 1.50786236e-01f, 5.50925592e-03f, 2.01068699e-01f, -1.47390634e-01f, 4.97320332e-02f, -3.13129611e-02f,
  1.19406590e-02f, 1.34473890e-01f, -1.36160225e-01f, -1.13258697e-01f, -1.02301538e-01f, 2.02390589e-02f, 2.05625549e-01f, 1.12637639e-01f, 5.56795709e-02f, -5.14796749e-03f,
  -3.78493848e-03f, -2.26265956e-02f, -1.38290510e-01f, 1.64181277e-01f, 7.06364587e-02f, 1.50649264e-01f, -8.58403519e-02f, 1.41566601e-02f, -9.56862047e-02f, -1.15149230e-01f,
  2.64001414e-02f, 5.59074916e-02f, -9.32215080e-02f, 7.71395303e-03f, 2.27034271e-01f, 2.11247921e-01f, 1.70405269e-01f, -2.55634598e-02f, 1.64175048e-01f, 1.36091352e-01f,
  -2.06638768e-01f, 3.54284830e-02f, 1.09288953e-01f, -2.59877439e-03f, -5.10571077e-02f, -2.79849432e-02f, -9.69532877e-02f, 1.34592503e-01f, -1.46455750e-01f, -2.51628123e-02f,
  -1.47668093e-01f, 1.89860433e-01f, 6.83435574e-02f, -9.56591740e-02f, 1.23672821e-01f, 1.76094070e-01f, 2.33944301e-02f, -4.84931357e-02f, 2.76488930e-01f, 1.11481115e-01f,
  -2.14926973e-01f, 7.07902238e-02f, 7.22852126e-02f, -1.51068181e-01f, 2.00265154e-01f, -6.22020625e-02f, -2.50564590e-02f, 3.78386788e-02f, 7.86940567e-03f, -2.45875865e-01f,
  1.52483052e-02f, 4.28091213e-02f, 2.05998076e-03f, -1.54151216e-01f, 5.31162992e-02f, -2.12622583e-01f, -6.59766495e-02f, -6.15842640e-02f, 5.36904596e-02f, 2.15453766e-02f,
  -1.06279284e-01f, -3.10840961e-02f, -1.20297812e-01f, 3.62289250e-02f, 3.34901758e-03f, -1.65440496e-02f, -3.60563584e-02f, -2.09551066e-01f, 1.15770109e-01f, 1.45939350e-01f,
  5.79162384e-04f, 1.99587286e-01f, 1.65938541e-01f, 1.52022645e-01f, -1.45129755e-01f, 1.21833764e-01f, 1.03225097e-01f, -1.42702818e-01f, 6.78631365e-02f, 5.38408831e-02f,
  -2.22732395e-01f, -5.90975843e-02f, 1.15844250e-01f, 6.25686273e-02f, -7.67304599e-02f, 2.34270319e-02f, -6.51403964e-02f, 2.14076176e-01f, -8.56480002e-02f, 1.69891015e-01f,
  -1.92451090e-01f, -1.05277650e-01f, -1.02537960e-01f, 8.81883651e-02f, -1.11961388e-03f, -1.61489323e-01f, 1.83224618e-01f, -1.67869210e-01f, 9.90594402e-02f, -8.00787583e-02f,
  -1.08718552e-01f, -3.99792641e-02f, 2.16229185e-01f, 1.19347587e-01f, 4.43897955e-02f, -7.27318004e-02f, 1.31765857e-01f, 4.33914922e-03f, -9.75445509e-02f, -1.14852861e-01f,
  8.97183716e-02f, -3.71539928e-02f, -6.19982462e-03f, -1.70597404e-01f, -1.27454184e-03f, 1.21682301e-01f, -8.52770451e-03f, 1.39571980e-01f, -2.21014619e-01f, -7.76436925e-02f,
  2.22622138e-03f, -2.39992857e-01f, 1.67411007e-02f, -1.75168082e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.97390005e-01f, 1.09773003e-01f, 1.79829702e-01f, 2.77642580e-03f, 2.67140299e-01f, 1.49440303e-01f, -7.79965669e-02f, -1.76021889e-01f, 1.92146763e-01f, 7.00651109e-02f,
  -1.31975532e-01f, -6.36744499e-02f, 2.23081514e-01f, 2.33939067e-01f, -3.40262614e-02f, 9.19138566e-02f, 1.63870528e-01f, 6.29724786e-02f, -2.54118681e-01f, -1.68857604e-01f,
  -1.71168491e-01f, -9.97445881e-02f, -8.56099278e-02f, 8.28298628e-02f, 1.04216784e-01f, -3.39967832e-02f, -1.74405351e-01f, 2.66361952e-01f, 2.05130409e-02f, 8.55615139e-02f,
  -3.79692875e-02f, -3.85861695e-02f, 1.36523023e-01f, 2.97916621e-01f, 1.72936544e-01f, 6.25054911e-02f, -4.28098813e-02f, 1.95162982e-01f, 1.89002573e-01f, -1.27124995e-01f,
  4.77289334e-02f, 1.93216011e-01f, 6.22237846e-02f, -5.60136922e-02f, 6.76544150e-03f, 8.26181248e-02f, 1.87528636e-02f, 1.79206267e-01f, -1.68281887e-02f, 2.11240083e-01f,
  -2.40137130e-01f, -1.25614330e-01f, -2.16758966e-01f, 2.92850643e-01f, 4.29384150e-02f, 7.87133351e-02f, 2.32735604e-01f, 2.19771028e-01f, -8.42458475e-03f, 1.50731895e-02f,
  2.24383026e-02f, -2.33803000e-02f, -2.26201519e-01f, -5.17882220e-02f, 1.70634657e-01f, -1.31574616e-01f, -4.97687310e-02f, 1.87188610e-01f, 1.74583465e-01f, 2.08724260e-01f,
  -2.74691969e-01f, -1.25227839e-01f, 4.23148014e-02f, 2.39336684e-01f, -2.10917264e-01f, -1.19376652e-01f, 7.97114056e-03f, -1.51614681e-01f, -2.32687399e-01f, 2.04804495e-01f,
  2.49964416e-01f, 1.00433320e-01f, 1.04328379e-01f, 3.58935416e-01f, 3.81537378e-02f, 3.73767734e-01f, -1.10986471e-01f, 8.50034431e-02f, -1.45706506e-02f, -1.20172374e-01f,
  -2.67589502e-02f, 2.88040582e-02f, 1.82902277e-01f, 9.66817662e-02f, -2.16281880e-02f, 2.96335280e-01f, -6.41205907e-03f, -1.63723230e-01f, -3.06118369e-01f, 1.73628747e-01f,
  1.66946381e-01f, -3.94813418e-01f, 9.45154727e-02f, 8.84545892e-02f, -4.95541058e-02f, -1.17538318e-01f, 2.19500586e-01f, 4.51412387e-02f, 3.89279947e-02f, -1.58900097e-01f,
  4.38461453e-02f, -1.28566056e-01f, 1.91945091e-01f, -3.94915929e-03f, 8.27494189e-02f, -1.22958794e-01f, -1.73569307e-01f, -1.67250872e-01f, 1.99449196e-01f, -2.42113266e-02f,
  -3.85783799e-02f, 2.01028213e-01f, 1.27432823e-01f, -1.94549322e-01f, 3.37234288e-02f, 1.24659687e-01f, -1.14417046e-01f, 1.59761101e-01f, 2.64816105e-01f, 3.33055735e-01f,
  2.85767615e-01f, 1.61030278e-01f, 2.67435849e-01f, 8.80024359e-02f, -8.43686610e-02f, -1.48339599e-01f, 2.55514793e-02f, 5.74292801e-02f, -1.13302931e-01f, 9.41526815e-02f,
  3.25540870e-01f, 6.31262064e-02f, 1.80698022e-01f, 2.32568700e-02f, 6.72764555e-02f, 5.89319095e-02f, 1.29219130e-01f, 1.09804653e-01f, -1.18042909e-01f, 1.76460624e-01f,
  -1.18352108e-01f, -8.41749012e-02f, -1.35390265e-02f, -6.41177297e-02f, 2.11296454e-01f, 3.65072042e-01f, 1.70392081e-01f, -2.59014994e-01f, -1.76893085e-01f, 1.14919476e-01f,
  -4.83344309e-02f, 2.03207389e-01f, 2.53840648e-02f, -1.64660901e-01f, -7.54181966e-02f, -3.13480454e-03f, 1.84506148e-01f, 6.61795512e-02f, -2.93239224e-04f, 2.57671118e-01f,
  7.81837031e-02f, 1.28487349e-01f, 8.14770833e-02f, -1.58165872e-01f, -1.92468502e-02f, 4.07223552e-02f, 3.48768942e-03f, 1.41369015e-01f, -3.86536680e-02f, 5.00224978e-02f,
  -6.29994646e-02f, 2.96766013e-01f, 2.96249706e-02f, 3.09232861e-01f, 2.07234889e-01f, 2.99308538e-01f, 2.14270223e-02f, 2.72583008e-01f, -1.80136785e-01f, -1.57230824e-01f,
  -5.04863216e-03f, 2.41678521e-01f, -2.80367937e-02f, 8.88132825e-02f, 2.37264335e-02f, -1.26569392e-02f, 1.42518073e-01f, -5.70056885e-02f, 1.72987461e-01f, -1.69501901e-02f,
  -5.65384068e-02f, 7.50557110e-02f, 7.30096176e-02f, 9.08812955e-02f, -5.84420525e-02f, -6.42426759e-02f, 1.19040921e-01f, -1.16563976e-01f, -1.51239589e-01f, -1.82943895e-01f,
  2.38880247e-01f, 9.20999572e-02f, -4.00087237e-02f, 1.38850689e-01f, 2.33585775e-01f, 1.90090872e-02f, -2.41205730e-02f, -4.52728570e-03f, 1.03916004e-01f, 1.29918903e-01f,
  -4.45621908e-02f, 1.18124716e-01f, -7.38590360e-02f, 1.77445207e-02f, 2.00942829e-01f, -1.85872048e-01f, 5.89374602e-02f, -2.23214790e-01f, 1.29948616e-01f, 7.04538748e-02f,
  -1.96838155e-01f, 1.95908949e-01f, 4.07724828e-02f, -1.37704358e-01f, 5.59651367e-02f, 1.18612155e-01f, 1.06063835e-01f, -1.79257929e-01f, 2.85931885e-01f, 2.99097896e-02f,
  1.44881727e-02f, -1.56581059e-01f, 1.70124486e-01f, 5.30313142e-02f, 2.96051204e-01f, -6.02870136e-02f, -2.41201341e-01f, 1.98840499e-01f, -1.65897697e-01f, -1.26826260e-02f,
  1.77575964e-02f, 4.40822653e-02f, -1.32964477e-01f, 1.84587575e-03f, 2.38819614e-01f, -5.24087623e-02f, -6.72955438e-02f, 1.68847129e-01f, 2.27721661e-01f, 1.14025764e-01f,
  8.54419917e-02f, 6.56960125e-04f, 2.25514807e-02f, -1.82964578e-02f, 3.05144787e-02f, 1.62066102e-01f, 1.15894333e-01f, 9.29207578e-02f, 2.63985217e-01f, 1.02625027e-01f,
  1.38352942e-02f, -3.06367557e-02f, 3.65169086e-02f, 4.62252647e-02f, 2.79473335e-01f, 1.35857970e-01f, 2.66838491e-01f, 5.98182902e-03f, 1.11406073e-01f, -9.24305022e-02f,
  -2.25748047e-01f, 7.13190138e-02f, 1.92441195e-01f, 2.24045053e-01f, 1.97467744e-01f, 7.65204057e-02f, 3.48406695e-02f, -2.53425688e-01f, 8.37984532e-02f, -2.59266436e-01f,
  1.84622958e-01f, -7.71411285e-02f, 1.25838369e-01f, 1.33795053e-01f, -1.20995797e-01f, 1.25730723e-01f, -7.27331312e-03f, -1.77179143e-01f, 1.94930866e-01f, 2.65906811e-01f,
  1.30696565e-01f, -1.94751024e-02f, 2.00761437e-01f, 1.99453488e-01f, 3.12173724e-01f, -1.99361801e-01f, 1.18581377e-01f, -5.79620013e-03f, 1.79946482e-01f, -1.87707171e-01f,
  -2.88207769e-01f, 2.31229842e-01f, -6.42349944e-02f, -1.11935534e-01f, -1.44008443e-01f, -8.96393657e-02f, 1.47801623e-01f, 1.90934569e-01f, 2.62882292e-01f, 9.86800566e-02f,
  1.64343223e-01f, -2.82618135e-01f, -1.74099997e-01f, 1.41122296e-01f, -1.21128343e-01f, 7.77934417e-02f, 2.01030243e-02f, 9.65923816e-02f, 7.94032868e-03f, 2.23713264e-01f,
  1.33486718e-01f, -1.43477991e-02f, -9.80850533e-02f, 7.65167503e-03f, -3.23743112e-02f, 5.39387912e-02f, 1.24317609e-01f, 2.21762925e-01f, 7.60849416e-02f, -3.35174762e-02f,
  -4.16931510e-02f, 1.77305993e-02f, 3.20287824e-01f, 1.68008059e-01f, 2.80095547e-01f, 1.29180118e-01f, 1.25669181e-01f, -9.51957777e-02f, -6.64080679e-02f, 7.83904567e-02f,
  -8.89589414e-02f, -2.57317955e-03f, -4.40734029e-02f, 1.47903994e-01f, -7.47830495e-02f, 1.33299798e-01f, -6.42397031e-02f, 2.09998876e-01f, 4.47550826e-02f, -1.27263620e-01f,
  -1.52772248e-01f, 1.89810917e-01f, -7.56556541e-02f, -8.78944322e-02f, -3.02786082e-01f, 9.28437561e-02f, -7.16536343e-02f, -2.25829780e-02f, 3.36014181e-02f, 2.56231248e-01f,
  -1.75634354e-01f, -3.02131530e-02f, -8.79686251e-02f, 3.77577357e-02f, 1.85670823e-01f, -2.88950354e-01f, 4.46894690e-02f, -2.79031433e-02f, 2.55362004e-01f, -3.74738008e-01f,
  1.73614733e-02f, 1.80537462e-01f, -3.09402347e-02f, -1.94831222e-01f, 1.89288899e-01f, 1.39231041e-01f, -1.33563923e-02f, 1.37125641e-01f, 1.58588126e-01f, 1.90964475e-01f,
  8.00786763e-02f, 3.09015542e-01f, -8.58154222e-02f, 5.21932244e-02f, -9.21193063e-02f, -7.56869018e-02f, -1.01606809e-02f, -1.30318459e-02f, -4.68585528e-02f, 2.15090048e-02f,
  -8.07119235e-02f, 3.75821710e-01f, -1.26674086e-01f, -1.42019004e-01f, -9.17553455e-02f, 2.47734845e-01f, -1.17334649e-02f, 2.83656001e-01f, 2.20846012e-01f, 5.71369641e-02f,
  -3.74881886e-02f, 5.84135018e-02f, 1.32151097e-01f, 6.69744164e-02f, -1.64805144e-01f, 1.00823693e-01f, 1.34833260e-02f, 1.09576806e-01f, -6.74062073e-02f, 2.07655877e-01f,
  -1.53256983e-01f, 1.27178133e-01f, 1.73832998e-01f, -1.33505389e-01f, 1.74268354e-02f, 8.66058394e-02f, 1.35505363e-01f, -2.50948220e-01f, -7.38201290e-02f, 2.85512686e-01f,
  -3.72272208e-02f, -1.03776880e-01f, -3.87069620e-02f, 2.24539891e-01f, -6.46675676e-02f, 1.17746085e-01f, -1.72825411e-01f, 1.66730180e-01f, 2.66534835e-01f, 8.69166851e-03f,
  2.08286628e-01f, 1.14785030e-01f, 7.75034279e-02f, 2.04985946e-01f, 1.58281013e-01f, 5.29601872e-02f, -3.51387560e-02f, 1.50733918e-01f, 2.47631565e-01f, 2.57213384e-01f,
  1.49902180e-01f, 1.36791855e-01f, 3.45417440e-01f, 2.82660216e-01f, 2.25156128e-01f, 1.13139875e-01f, -1.25882655e-01f, -2.67182946e-01f, -2.59090066e-02f, -1.67864114e-01f,
  4.46347855e-02f, 2.67304778e-02f, 1.60760224e-01f, -1.17458761e-01f, -1.60670191e-01f, -7.07192123e-02f, -2.50477046e-01f, -2.53472239e-01f, -1.99165344e-01f, 7.92375654e-02f,
  5.75613752e-02f, 8.93517807e-02f, -1.58282831e-01f, -4.48938236e-02f, 1.28141373e-01f, -3.33864912e-02f, 1.18345760e-01f, -2.79384285e-01f, -1.18224949e-01f, 2.54343539e-01f,
  -2.94429772e-02f, 2.68910527e-01f, 4.43765670e-02f, 3.58554646e-02f, -1.27195060e-01f, -1.23797350e-01f, 1.32041454e-01f, 1.74165275e-02f, 2.62785763e-01f, 1.00000814e-01f,
  -6.06628284e-02f, 6.95959851e-02f, 1.82765752e-01f, 7.56943598e-02f, -7.68833905e-02f, 2.75459081e-01f, -1.71564147e-01f, 1.09120138e-01f, 2.72695161e-02f, 1.95801899e-01f,
  7.71693960e-02f, 2.32832998e-01f, 8.32566023e-02f, 9.56423674e-03f, 1.19939908e-01f, 3.63190323e-02f, 5.37509173e-02f, 1.53938577e-01f, -2.43954659e-02f, 5.65224141e-02f,
  -8.94067250e-03f, 8.71048570e-02f, 2.08959445e-01f, -1.45928366e-02f, 9.49112624e-02f, 2.65700489e-01f, 8.03478062e-02f, 2.85498500e-01f, 9.52588022e-02f, 3.85128975e-01f,
  -2.24530384e-01f, -2.57101685e-01f, 5.07637896e-02f, -1.11335918e-01f, -2.16431558e-01f, 4.23233695e-02f, 2.23382592e-01f, 1.37662157e-01f, -7.88204372e-02f, -1.40736014e-01f,
  -6.34324998e-02f, 9.51944143e-02f, 2.56323218e-01f, -2.92804994e-04f, -1.46342009e-01f, 2.92732604e-02f, 1.16501138e-01f, -6.21317476e-02f, 9.67367366e-02f, -3.60714585e-01f,
  -1.41766995e-01f, -1.26918226e-01f, 2.59989470e-01f, 9.46464092e-02f, 2.75779843e-01f, -1.57356218e-01f, 1.65643901e-01f, 3.52898315e-02f, -6.48240522e-02f, -6.05417695e-03f,
  9.43095833e-02f, 1.58768818e-01f, 3.54522824e-01f, -2.07315415e-01f, -1.93851992e-01f, 4.25437577e-02f, -3.05666387e-01f, 1.01237848e-01f, -2.12528184e-02f, -3.38267863e-01f,
  2.66603768e-01f, 1.32307410e-01f, 1.54002562e-01f, -1.55848145e-01f, 9.29861814e-02f, -2.49447182e-01f, 5.58134280e-02f, -2.17509657e-01f, -1.61280215e-01f, -2.07531154e-01f,
  1.86985955e-01f, -1.30275309e-01f, 2.30242476e-01f, 8.44358653e-02f, 2.06255600e-01f, -3.04860100e-02f, 1.99903712e-01f, 1.23262212e-01f, 2.21409574e-01f, 1.74214542e-01f,
  2.79645249e-02f, 2.07658932e-01f, -1.44222543e-01f, -1.28911957e-01f, -6.66534156e-02f, 7.13807940e-02f, 1.00794986e-01f, -2.81119104e-02f, 1.86052710e-01f, 1.10792167e-01f,
  1.70897603e-01f, 2.84924917e-02f, -4.37320918e-02f, 8.70916527e-03f, 7.92190805e-02f, 2.04361185e-01f, 1.32973790e-01f, 2.36250401e-01f, 2.48672336e-01f, 4.76266928e-02f,
  -2.27515399e-01f, 2.60708660e-01f, 7.22348988e-02f, -5.46239689e-02f, 1.72403455e-01f, 2.56225377e-01f, -1.70282245e-01f, -6.44347146e-02f, -1.48160234e-01f, -2.87073225e-01f,
  -4.97848541e-02f, 2.34051779e-01f, 8.95206258e-02f, 2.51522601e-01f, -7.14648962e-02f, 1.83434337e-01f, -7.84640312e-02f, -2.42537960e-01f, 1.77665278e-01f, 1.84426352e-01f,
  8.33453611e-02f, 1.33801267e-01f, 6.43963292e-02f, 1.91293001e-01f, 2.74532378e-01f, -2.11292747e-02f, 2.37926573e-01f, 2.74194926e-01f, 2.23163038e-01f, -1.75673515e-01f,
  -1.19409367e-01f, 1.57772407e-01f, 6.94516152e-02f, 3.92868090e-03f, 7.87700862e-02f, 1.10536991e-02f, 5.60752973e-02f, 2.13434890e-01f, 1.09526888e-01f, 2.70327449e-01f,
  1.16561070e-01f, -1.86249930e-02f, 2.43649110e-02f, 2.11655512e-01f, 8.90827551e-02f, 9.95485783e-02f, -9.01931375e-02f, 7.02285990e-02f, 1.37434036e-01f, 1.70800120e-01f,
  -8.31911489e-02f, -9.41354558e-02f, 7.40057603e-02f, -1.70972958e-01f, -2.43862882e-01f, 3.09768647e-01f, 3.44520845e-02f, 3.03987503e-01f, -1.65878311e-01f, 2.62945257e-02f,
  -1.35855779e-01f, 2.73651898e-01f, 7.59930024e-03f, 3.40112954e-01f, 1.68370262e-01f, 1.50596708e-01f, -2.30572060e-01f, 3.78991216e-02f, 1.39227524e-01f, 9.61866826e-02f,
  -1.16184048e-01f, 2.88281918e-01f, 2.58256029e-02f, 2.35895757e-02f, -2.33839273e-01f, 2.85751820e-01f, -1.22967921e-01f, 4.03221250e-02f, 1.39204875e-01f, -1.85932681e-01f,
  -4.44604922e-03f, 1.22294836e-01f, 2.70655960e-01f, -1.41673401e-01f, -2.98781339e-02f, 1.12297684e-01f, 6.52832687e-02f, -1.11760102e-01f, -2.35525686e-02f, 2.12924689e-01f,
  -9.67153236e-02f, -1.31576851e-01f, -1.66537672e-01f, 1.69191852e-01f, 1.28536776e-01f, -2.01208219e-01f, 6.57315776e-02f, 1.99189886e-01f, 3.61553840e-02f, -7.30543807e-02f,
  -3.72630544e-02f, 1.74590617e-01f, -9.07136351e-02f, -1.61303848e-01f, 3.43807578e-01f, 1.27418309e-01f, 1.34009153e-01f, 3.31337422e-01f, 3.34874839e-01f, 2.97778040e-01f,
  -1.72340319e-01f, 1.51001021e-01f, -1.15742385e-02f, 1.40359268e-01f, -1.72631338e-01f, -7.46917054e-02f, 1.00137200e-02f, 1.64594427e-02f, 7.16419145e-02f, 1.76728740e-01f,
  9.23913196e-02f, -3.63848507e-02f, -1.96419224e-01f, 1.28798336e-01f, -3.22156213e-02f, 1.34025753e-01f, -1.44072428e-01f, 1.71581328e-01f, -6.18396327e-02f, -5.48720025e-02f,
  -1.15975276e-01f, 6.87338086e-03f, 1.59291878e-01f, 1.12454236e-01f, 1.23671025e-01f, 3.47882956e-01f, 1.98368579e-01f, 5.04716858e-02f, 3.50710899e-02f, 1.08970948e-01f,
  4.61532548e-02f, -3.49354684e-01f, 2.90328115e-01f, 1.83892205e-01f, 3.97313237e-01f, -1.28991529e-01f, 3.72854024e-01f, 1.83575705e-01f, 8.42655748e-02f, -1.02071919e-01f,
  2.05593914e-01f, -4.71339785e-02f, 1.43649548e-01f, 1.72553077e-01f, -6.09474666e-02f, 1.32395372e-01f, -1.14805616e-01f, 7.54610896e-02f, 2.81191558e-01f, -1.95872039e-01f,
  1.00843586e-01f, 1.30287297e-02f, 4.16119583e-02f, 4.74577844e-02f, -1.54940626e-02f, -6.31015077e-02f, 2.93173958e-02f, 8.94093513e-02f, 1.94457754e-01f, 1.95039347e-01f,
  1.87751725e-01f, 2.13824704e-01f, 2.28133611e-03f, 1.25928381e-02f, 9.90658700e-02f, -3.70479748e-02f, -8.59629586e-02f, -5.93465902e-02f, 8.98310021e-02f, -2.93530792e-01f,
  -1.39658958e-01f, 5.44272885e-02f, 5.71443252e-02f, -2.10313305e-01f, -2.53573060e-01f, -1.03640826e-02f, 4.22511548e-02f, -2.32757464e-01f, -1.22667447e-01f, 3.37599754e-01f,
  2.81746745e-01f, 2.16916636e-01f, -2.40475222e-01f, 1.76367536e-01f, 1.59362525e-01f, -2.48561785e-01f, 8.94031227e-02f, -2.49606906e-04f, -5.80386519e-02f, 3.37006897e-01f,
  5.68884192e-03f, -1.29446253e-01f, 2.23440677e-02f, 1.17433786e-01f, 2.45087773e-01f, -8.27996880e-02f, -1.16478227e-01f, -1.68886632e-01f, 1.39047906e-01f, 2.28834599e-02f,
  -1.51264668e-01f, -3.36737409e-02f, 2.17899352e-01f, 3.20276618e-02f, 2.54638344e-01f, 3.09938908e-01f, -1.23592056e-01f, 3.61058302e-02f, 1.27641737e-01f, 1.97325870e-01f,
  2.51742899e-01f, 1.01166949e-01f, -3.43484804e-02f, 1.21927634e-01f, 2.16843337e-01f, -9.58199129e-02f, 2.87746694e-02f, 2.33991981e-01f, -8.24199431e-03f, 1.10970996e-01f,
  1.83273211e-01f, 2.32467279e-01f, 7.43610859e-02f, 2.34394372e-01f, -6.25686999e-03f, 2.79769897e-01f, 1.27934337e-01f, -6.27216026e-02f, 7.90172219e-02f, -7.98492581e-02f,
  -1.87762156e-01f, -2.35189195e-03f, 3.10256779e-01f, -1.18910611e-01f, -4.58588712e-02f, 8.75537321e-02f, 7.38546029e-02f, -7.35119432e-02f, -2.31687576e-01f, -4.16091196e-02f,
  -5.52451871e-02f, -9.93231013e-02f, -1.24018565e-01f, 2.45293185e-01f, 2.75688380e-01f, 5.87782897e-02f, -2.19774619e-01f, -4.58611101e-02f, -9.46665630e-02f, -3.03090245e-01f,
  9.96811241e-02f, 1.66496232e-01f, -8.65528509e-02f, 3.57704073e-01f, -1.99738845e-01f, -1.22548111e-01f, 2.28005186e-01f, -8.56359582e-03f, 1.81451246e-01f, 3.86666171e-02f,
  -3.94347720e-02f, -1.30964622e-01f, -5.15642157e-03f, -8.64553750e-02f, -2.01191917e-01f, 1.58292323e-01f, 2.83290565e-01f, -1.29325598e-01f, 1.10517949e-01f, 1.64121360e-01f,
  -2.38796860e-01f, 1.76930010e-01f, 1.03959508e-01f, 8.22864547e-02f, 2.64179796e-01f, 1.61768794e-01f, 1.68346502e-02f, 1.66619658e-01f, 2.23826006e-01f, -6.25198111e-02f,
  1.16937451e-01f, 1.37363315e-01f, 1.17217444e-01f, 5.10351881e-02f, 8.63420367e-02f, 8.45069811e-02f, 1.67822972e-01f, -2.54993141e-03f, -2.03225482e-02f, 1.51689008e-01f,
  -7.82672539e-02f, 2.78632320e-03f, -4.94413488e-02f, -5.38940951e-02f, 1.12552047e-02f, 4.94149886e-02f, 1.59988031e-01f, 4.40737372e-03f, 1.33100357e-02f, 2.39861861e-01f,
  1.88546237e-02f, -3.09299305e-02f, -2.46897638e-02f, -3.71129476e-02f, 1.61044672e-01f, 1.11724705e-01f, 1.98069438e-01f, 5.42065129e-02f, 1.20324522e-01f, 5.19227348e-02f,
  -1.39976352e-01f, 8.67980197e-02f, 1.54061496e-01f, -3.89912613e-02f, 1.75933495e-01f, 2.55844444e-01f, 1.98858883e-02f, 5.68653345e-02f, 1.75057724e-01f, -2.39288658e-01f,
  1.13095321e-01f, 8.43146741e-02f, 1.64431557e-01f, 2.29798425e-02f, -3.88973169e-02f, 2.28762865e-01f, -1.60594329e-01f, -1.72158152e-01f, -2.53608190e-02f, 2.29735732e-01f,
  2.00466990e-01f, -7.52215413e-03f, 1.56250790e-01f, 2.09789917e-01f, 1.54249966e-01f, -7.75342882e-02f, 1.21067584e-01f, -6.02917094e-03f, 6.50885180e-02f, -2.34002262e-01f,
  -1.11412518e-01f, 2.11735532e-01f, -9.77608711e-02f, -2.44867932e-02f, -5.91957420e-02f, -1.29964322e-01f, 1.58829153e-01f, 1.29595950e-01f, 2.32187614e-01f, -1.77677959e-01f,
  -3.00665237e-02f, 2.45754883e-01f, 6.46031722e-02f, 1.19072301e-02f, -9.18560773e-02f, -1.01337321e-01f, -8.75070989e-02f, 1.60828643e-02f, 2.28605971e-01f, 1.87815607e-01f,
  -2.64420938e-02f, 3.36818606e-01f, 1.07471898e-01f, 2.46331304e-01f, 1.51012227e-01f, -8.76984820e-02f, 6.72243088e-02f, 7.67865852e-02f, 1.46577299e-01f, 8.69525820e-02f,
  1.86311096e-01f, -1.62043557e-01f, 2.66543925e-01f, 1.08476594e-01f, -1.63501844e-01f, -3.51460427e-02f, 1.97186247e-01f, 5.67908473e-02f, 1.90721601e-01f, 1.82641342e-01f,
  -2.43699357e-01f, -9.72641036e-02f, -1.93713466e-04f, -1.61579043e-01f, 5.58609776e-02f, -9.96144786e-02f, 2.09279433e-01f, -1.01334438e-01f, -1.65964812e-01f, 3.05719942e-01f,
  -1.48827815e-02f, -1.78719684e-02f, 9.98310298e-02f, 2.61465251e-01f, 1.62342668e-01f, -7.10856766e-02f, 2.69758582e-01f, -1.08850189e-02f, -5.55315949e-02f, -1.70224831e-01f,
  1.59927711e-01f, 7.81560391e-02f, 1.68599822e-02f, -6.42638877e-02f, -8.61899704e-02f, 2.45855749e-01f, 1.39912888e-01f, 4.84616235e-02f, -4.36543860e-02f, -6.22205585e-02f,
  -1.59555718e-01f, -7.94402137e-02f, 4.43024263e-02f, -6.11128062e-02f, 2.15321779e-01f, 2.99870335e-02f, 1.78668909e-02f, 9.77149531e-02f, 9.43961367e-02f, 4.71813567e-02f,
  -2.10900251e-02f, -1.85544848e-01f, 1.10466011e-01f, 3.08112293e-01f, -1.75250415e-02f, -6.33626105e-03f, 2.24915311e-01f, 1.77104130e-01f, -1.63158234e-02f, 2.87792414e-01f,
  1.16531380e-01f, 1.64194554e-01f, -5.70686162e-02f, 3.00004035e-01f, 8.42552558e-02f, 2.40277827e-01f, 1.44381687e-01f, 1.34018064e-01f, 6.24157265e-02f, 9.11104903e-02f,
  -1.80511847e-01f, -2.54741609e-02f, 2.15525538e-01f, 3.24043900e-01f, 1.03491299e-01f, 7.68057778e-02f, -7.74937421e-02f, -1.72153730e-02f, -1.94848433e-01f, 1.90673187e-01f,
  1.86722845e-01f, 1.37954637e-01f, 4.98089157e-02f, 5.69460317e-02f, -1.91401653e-02f, -1.56551898e-02f, 2.23501191e-01f, -1.72016602e-02f, 2.78151575e-02f, 1.24347068e-01f,
  -7.53480196e-02f, -4.82115075e-02f, 2.90242843e-02f, -5.29448278e-02f, 1.03414036e-01f, -3.92053686e-02f, -3.26108187e-03f, 2.76211891e-02f, 2.18163416e-01f, -1.39532715e-01f,
  6.93176612e-02f, 1.59473583e-01f, 7.62892291e-02f, -2.62928069e-01f, 7.81094208e-02f, 2.39920959e-01f, -8.16611052e-02f, -1.06027231e-01f, 2.85635423e-02f, 1.57358140e-01f,
  1.97763130e-01f, 1.19456954e-01f, 1.58312500e-01f, 2.05505699e-01f, -2.29759946e-01f, -3.34906369e-01f, 2.49240473e-01f, 8.95487145e-02f, -1.73195228e-01f, 1.85501054e-01f,
  3.93344194e-01f, 8.03701356e-02f, -4.22813110e-02f, 1.20681794e-02f, 1.06809512e-01f, -9.27506089e-02f, -1.47108346e-01f, 2.80187547e-01f, -8.62277523e-02f, -1.10124908e-02f,
  -2.26867080e-01f, -1.54899061e-01f, 3.16316087e-04f, -2.93083936e-01f, 1.66624635e-01f, 2.39658073e-01f, -2.38393992e-01f, 9.87763107e-02f, 9.09288749e-02f, -1.13551222e-01f,
  -6.69580474e-02f, 2.76032776e-01f, 7.45181972e-03f, -1.83920756e-01f, -1.11721762e-01f, 7.88057819e-02f, 1.04080498e-01f, 1.94036946e-01f, 3.40825245e-02f, -1.43340647e-01f,
  3.96783471e-01f, 2.31939584e-01f, -2.49970868e-01f, -1.83217168e-01f, 2.68587042e-02f, 1.00821413e-01f, 1.12516992e-01f, -5.36651425e-02f, -1.05901614e-01f, 1.88364461e-01f,
  -2.83876006e-02f, -3.74056622e-02f, 1.37910008e-01f, -1.30575607e-02f, 7.48165175e-02f, -1.80655047e-02f, -1.63416415e-01f, 9.97066572e-02f, -2.07986265e-01f, -2.06764892e-01f,
  6.49911910e-02f, 1.12957001e-01f, 1.76154271e-01f, 8.07186216e-02f, 6.12362139e-02f, 6.80594519e-02f, 2.85021544e-01f, 1.84017509e-01f, 2.34579176e-01f, 1.30872965e-01f,
  -1.48159832e-01f, -1.16469517e-01f, -1.26750350e-01f, 1.13492362e-01f, -1.73600823e-01f, -4.38197255e-02f, 1.81862444e-01f, 7.75907710e-02f, 1.33656235e-02f, -1.01958238e-01f,
  -2.39623770e-01f, -1.30772680e-01f, -9.61684212e-02f, -1.82498932e-01f, 7.03413561e-02f, -9.35079679e-02f, 7.82119259e-02f, -5.62292151e-02f, -1.33153722e-01f, -1.36103779e-01f,
  -1.77786157e-01f, -7.12918118e-02f, 2.20376790e-01f, -2.26550233e-02f, 1.89787641e-01f, 1.63199022e-01f, 2.63017297e-01f, -2.41551027e-01f, 8.74460265e-02f, -1.16138235e-01f,
  2.81442791e-01f, 1.91415916e-03f, 2.42854342e-01f, 3.81723903e-02f, -3.66708606e-01f, -1.87524810e-01f, -1.10689001e-02f, 2.08447665e-01f, 2.75621563e-01f, -4.06639688e-02f,
  -1.40606731e-01f, 7.83726349e-02f, -4.25343178e-02f, -2.39718363e-01f, -9.13202688e-02f, 2.20356956e-01f, 8.26005861e-02f, -2.66602576e-01f, -2.11247504e-02f, 1.60111059e-02f,
  1.50757357e-01f, 2.38296866e-01f, 5.35339788e-02f, -8.60026702e-02f, 9.65033174e-02f, -1.48063645e-01f, 1.50576517e-01f, -3.17071006e-02f, 1.46603182e-01f, 2.68976271e-01f,
  1.32900983e-01f, 2.39443690e-01f, -1.81161702e-01f, 1.12677328e-01f, -2.38185320e-02f, 3.37709673e-02f, -8.34814310e-02f, -4.49365489e-02f, -1.33809060e-01f, -1.61615625e-01f,
  -5.01531586e-02f, 1.84505045e-01f, 2.06545025e-01f, -1.55756557e-02f, 1.18355550e-01f, 3.24038923e-01f, 2.36829132e-01f, 2.51706719e-01f, 5.05985916e-02f, 5.53344972e-02f,
  6.80969609e-03f, 1.21907316e-01f, 2.42153019e-01f, -5.53131290e-02f, 9.13918763e-02f, 1.42287180e-01f, 1.45945147e-01f, 1.72090173e-01f, 1.13293022e-01f, -1.56523928e-01f,
  -2.07818478e-01f, 2.29770780e-01f, -4.71690074e-02f, -2.58529335e-01f, 6.10832907e-02f, 6.89313561e-02f, 4.97294590e-02f, -2.01209486e-01f, 1.62022114e-01f, 7.01311976e-02f,
  -2.28053674e-01f, -7.45738819e-02f, 4.61980999e-02f, -2.12343752e-01f, 1.49335623e-01f, -1.30251929e-01f, 1.11952178e-01f, -6.44848123e-02f, -1.03276424e-01f, -2.56825417e-01f,
  2.09344432e-01f, -3.04345638e-01f, -1.04718596e-01f, -2.32972279e-01f, 1.50894701e-01f, -2.47173890e-01f, 9.33309644e-02f, 2.77221203e-01f, 1.61283568e-01f, -2.14648589e-01f,
  3.40541780e-01f, -2.88061462e-02f, 2.54881173e-01f, 2.92551190e-01f, 8.70818421e-02f, 2.04200134e-01f, 9.68750492e-02f, 3.78947049e-01f, -2.34745696e-01f, -2.97495484e-01f,
  1.22269951e-01f, 6.84413388e-02f, -2.32252240e-01f, -6.08148724e-02f, 2.14276612e-01f, 1.46128638e-02f, 5.65717258e-02f, -1.45032510e-01f, 4.42383578e-03f, 1.12369701e-01f,
  2.79514462e-01f, 1.29380316e-01f, -1.71246547e-02f, 8.77723843e-02f, -5.03523089e-02f, -3.04176956e-02f, 3.77101153e-01f, -2.40985051e-01f, -1.35124430e-01f, -1.53939649e-01f,
  2.09452435e-01f, -4.63731587e-02f, 7.36875385e-02f, -1.60829410e-01f, 5.38378879e-02f, 1.02780223e-01f, 4.72448468e-02f, -6.38128221e-02f, -1.49909919e-02f, 8.78699273e-02f,
  1.93841085e-01f, -2.55236924e-01f, -3.19726542e-02f, 4.89835776e-02f, -2.42891252e-01f, 1.01491980e-01f, 3.25669944e-02f, -1.94659442e-01f, 3.97795379e-01f, -1.14971660e-02f,
  2.07010597e-01f, 1.34517848e-01f, 1.27569675e-01f, -1.40154287e-01f, 4.03791107e-02f, -2.68157393e-01f, -6.52115196e-02f, -3.30061257e-01f, 2.37855673e-01f, -1.10310383e-01f,
  2.25893289e-01f, 2.42657274e-01f, 2.20992208e-01f, 1.29451707e-01f, 2.62358874e-01f, 9.57581922e-02f, 2.04296961e-01f, 1.53507590e-01f, 1.23374879e-01f, 3.37918937e-01f,
  2.61363834e-01f, 1.57747671e-01f, 5.34148775e-02f, -1.35527313e-01f, -3.77482586e-02f, 9.33005661e-02f, 9.85961333e-02f, 1.64367288e-01f, 1.36468232e-01f, 2.91512124e-02f,
  -9.61112678e-02f, 1.93136811e-01f, -2.64222175e-01f, -2.82399446e-01f, -2.24467352e-01f, -2.75200635e-01f, 5.00025526e-02f, 1.93379536e-01f, 1.74273983e-01f, 8.29354301e-02f,
  -8.60908553e-02f, 1.06647208e-01f, -9.71565545e-02f, 6.11052848e-02f, 1.02024734e-01f, -1.50569737e-01f, 3.36901814e-01f, 1.71770751e-01f, 2.09534153e-01f, -1.28372580e-01f,
  -4.99431416e-02f, 1.57522410e-01f, 2.22874224e-01f, 6.56395778e-02f, 1.14369415e-01f, 2.18028292e-01f, -2.29163200e-01f, -8.28169733e-02f, -1.26634344e-01f, 1.79903105e-01f,
  1.60651863e-01f, 1.18395455e-01f, -2.21225664e-01f, 1.74736366e-01f, -2.27721289e-01f, 1.18230365e-01f, -9.84941795e-02f, 3.42341721e-01f, 1.01881146e-01f, -8.11019465e-02f,
  2.35721111e-01f, 8.35796669e-02f, 1.97359607e-01f, 1.24701291e-01f, -4.83591594e-02f, -7.22071156e-02f, -3.48637626e-02f, -1.50982291e-01f, 3.58715616e-02f, 1.49085730e-01f,
  2.76072472e-02f, 1.15163233e-02f, 1.19970992e-01f, 8.07313994e-02f, -2.59843349e-01f, -1.65681809e-01f, 2.54198521e-01f, 2.38892838e-01f, -1.09228082e-01f, 3.17052335e-01f,
  2.65509933e-01f, 1.92741439e-01f, 1.49584636e-01f, -7.12196529e-02f, 1.14101961e-01f, -6.76836222e-02f, 2.66690463e-01f, 3.20662558e-01f, 2.99346328e-01f, -1.61270238e-02f,
  -2.14905180e-02f, 5.50503656e-02f, -6.66701943e-02f, -9.21255350e-02f, 3.21163356e-01f, 3.77255857e-01f, 2.37308770e-01f, -1.42187392e-02f, 3.95829268e-02f, -3.60030353e-01f,
  -4.23917100e-02f, -1.34421781e-01f, 8.17164332e-02f, 1.25899360e-01f, 4.22408152e-03f, 1.24216467e-01f, -1.20002434e-01f, 1.98444754e-01f, -1.01506971e-01f, -1.82284433e-02f,
  3.51685584e-01f, 2.34868005e-01f, -1.49606124e-01f, 5.86569542e-03f, 1.70315459e-01f, -6.35938719e-02f, 3.97758096e-01f, -2.61030734e-01f, 1.65006921e-01f, -2.12755688e-02f,
  1.90567281e-02f, -5.17811142e-02f, -4.73853610e-02f, 1.94168359e-01f, 1.84032153e-02f, 3.15106064e-02f, -6.56518489e-02f, -4.29107063e-02f, 1.29034236e-01f, 2.04796940e-01f,
  3.18177104e-01f, 1.53811887e-01f, 2.58123338e-01f, 2.16199920e-01f, 3.10551465e-01f, 4.12423052e-02f, -6.46705623e-04f, 2.36926407e-01f, -1.07770748e-01f, 2.40873665e-01f,
  -1.51257053e-01f, -2.50807017e-01f, 1.58180460e-01f, 1.18708022e-01f, 1.81618497e-01f, 2.75478289e-02f, 2.39401981e-01f, 1.17294610e-01f, 6.35731295e-02f, -4.73518446e-02f,
  1.59656063e-01f, 1.43559173e-01f, 1.31264403e-01f, -1.05417445e-01f, 5.27485386e-02f, 7.48992711e-02f, -1.33916706e-01f, 5.27667552e-02f, 3.00965637e-01f, -5.19980900e-02f,
  -1.44284546e-01f, 2.15910841e-02f, 3.07924747e-01f, -2.23595262e-01f, 1.48173332e-01f, -6.71708584e-02f, 2.03434713e-02f, 3.39431316e-02f, 4.96001430e-02f, 2.11378202e-01f,
  -3.65349203e-02f, 2.19909832e-01f, 8.56358260e-02f, -1.05891764e-01f, 2.69042747e-03f, 2.81027079e-01f, -1.73034847e-01f, 1.84821472e-01f, -9.95888785e-02f, 7.50237629e-02f,
  3.01028252e-01f, -5.82151525e-02f, 2.97282904e-01f, 1.96120128e-01f, 1.50201917e-01f, -2.36501426e-01f, -3.26890677e-01f, -3.39727923e-02f, -1.60566941e-01f, -8.03871155e-02f,
  -9.00589079e-02f, -9.78084654e-02f, 2.56824493e-01f, 1.86822414e-01f, 8.88080522e-02f, -1.96061376e-02f, 2.39298642e-01f, 7.58752078e-02f, 1.72877386e-01f, 1.54224500e-01f,
  2.91439205e-01f, 2.55594581e-01f, 2.25018725e-01f, 2.85577953e-01f, -1.91516072e-01f, -3.37580323e-01f, 1.55086115e-01f, -7.58142546e-02f, -2.00650275e-01f, -6.98431432e-02f,
  1.78994894e-01f, -4.80551310e-02f, -4.27723080e-02f, 5.98110333e-02f, -1.33292109e-01f, -1.14316642e-01f, 4.98814024e-02f, 2.24106699e-01f, -3.37399244e-02f, 1.92944497e-01f,
  -3.37038040e-02f, 1.22621972e-02f, 7.60620609e-02f, -1.29354954e-01f, 2.13407874e-01f, -8.39438587e-02f, -5.79967573e-02f, 3.22954118e-01f, 9.34092328e-02f, 1.84899922e-02f,
  -1.58314053e-02f, -2.35871971e-02f, 2.48186546e-03f, -1.10115767e-01f, 2.42533892e-01f, 5.83816767e-02f, 2.89660811e-01f, 1.83239803e-01f, -1.63561732e-01f, -1.53007418e-01f,
  2.05883414e-01f, 2.31855974e-01f, 6.60558268e-02f, 4.91221808e-02f, -5.88174239e-02f, 3.50051194e-01f, -3.81503850e-02f, 2.27122232e-01f, 1.45391256e-01f, 2.32067540e-01f,
  -1.05273817e-02f, 1.26499133e-02f, 3.43464285e-01f, -6.04482107e-02f, 3.30964565e-01f, 1.64364725e-01f, 8.51287097e-02f, 8.09757039e-03f, -3.40725817e-02f, 1.25931099e-01f,
  -9.58101526e-02f, 7.76754767e-02f, 2.25215241e-01f, 2.28596792e-01f, -5.33408783e-02f, 2.17445474e-02f, 3.72423947e-01f, -2.51869410e-01f, -5.50941899e-02f, -1.43007547e-01f,
  2.30621666e-01f, -2.60985166e-01f, -2.21035525e-01f, -6.45929202e-02f, -2.36325786e-02f, -2.85843194e-01f, -1.68561712e-01f, -2.25034729e-01f, 6.61776215e-02f, -2.40242079e-01f,
  -7.36728311e-02f, 6.57531768e-02f, 3.59278649e-01f, -4.53158319e-02f, -1.88747376e-01f, -1.78157926e-01f, 3.65232602e-02f, -3.75721008e-01f, 2.29888484e-02f, 2.18986765e-01f,
  -1.61413848e-01f, 1.08892389e-01f, -6.96133962e-03f, -2.13152453e-01f, -5.20837344e-02f, -8.04714188e-02f, 3.85619074e-01f, 6.37444258e-02f, -3.16666603e-01f, -2.11985528e-01f,
  -1.67334348e-01f, -1.39410883e-01f, -1.58008248e-01f, 1.75269470e-01f, 1.87028140e-01f, -2.03369737e-01f, 8.36113095e-02f, 2.74704993e-01f, 8.12476501e-02f, -1.46306977e-01f,
  2.16072142e-01f, 1.15720900e-02f, 3.02417964e-01f, -8.26380402e-02f, -2.23591268e-01f, 3.06713507e-02f, -2.09596176e-02f, -2.48175353e-01f, -1.60423219e-01f, 3.62869576e-02f,
  -1.67315140e-01f, 4.33605574e-02f, -2.65807007e-02f, -1.50525300e-02f, 4.09928001e-02f, 2.38301501e-01f, 1.03559874e-01f, 6.13854639e-02f, 6.10725544e-02f, -3.91851813e-02f,
  1.54755920e-01f, -1.88426241e-01f, -2.42085129e-01f, -1.76991701e-01f, 1.55822530e-01f, -2.60241777e-01f, 8.22039247e-02f, 6.89511048e-03f, 7.05698282e-02f, -1.62432879e-01f,
  -4.90096509e-02f, -2.15018056e-02f, -2.43962146e-02f, 2.05201022e-02f, -6.02124771e-03f, 1.91033900e-01f, 1.80646777e-01f, 1.60519540e-01f, -1.94883063e-01f, 2.40984410e-02f,
  -1.04542159e-01f, -1.73002817e-02f, 2.04858541e-01f, 1.00840524e-01f, -1.52420804e-01f, 2.11783722e-01f, -1.24795407e-01f, 4.49924581e-02f, -1.52552098e-01f, 2.65242070e-01f,
  2.07439855e-01f, -1.38483137e-01f, 9.51919407e-02f, -9.83010978e-03f, -1.49822325e-01f, 1.15492016e-01f, 1.54530019e-01f, 8.78039747e-03f, 3.63732219e-01f, -8.65288451e-02f,
  1.45778894e-01f, 3.15125644e-01f, -1.23877246e-02f, 2.26839185e-02f, 2.45580837e-01f, 2.62208968e-01f, 7.18891397e-02f, 6.19185530e-02f, -3.47741991e-02f, 2.77381569e-01f,
  2.01038092e-01f, 2.14002788e-01f, 6.51760921e-02f, 2.12769493e-01f, 1.98613829e-03f, 1.49917696e-02f, -6.43485561e-02f, 2.82516658e-01f, 1.57801852e-01f, 3.05454940e-01f,
  1.24145605e-01f, 7.18484670e-02f, 6.47609904e-02f, 7.50702024e-02f, 9.42469835e-02f, -1.68127462e-01f, -2.14998767e-01f, -3.17576140e-01f, 7.35182455e-03f, -1.75588802e-01f,
  1.40106082e-01f, 2.38868311e-01f, 2.22315818e-01f, -3.57529223e-02f, 3.17843854e-02f, -7.94786289e-02f, -1.73694640e-01f, -1.38866350e-01f, 2.76724733e-02f, 1.32559007e-02f,
  1.72802523e-01f, -2.14470893e-01f, -2.50422329e-01f, -9.67351794e-02f, 7.62326196e-02f, 6.54212087e-02f, -2.58707181e-02f, -2.36493200e-01f, -1.16210043e-01f, 1.41509458e-01f,
  9.93694067e-02f, 2.62474328e-01f, 2.09199622e-01f, -1.40519246e-01f, 9.36116558e-03f, -1.80310477e-02f, 4.27278131e-02f, -6.76994398e-02f, 1.94049925e-01f, 7.33152851e-02f,
  -2.21181601e-01f, 3.91181149e-02f, 1.49171397e-01f, -2.76484430e-01f, 1.26538016e-02f, 3.44590962e-01f, -8.31678361e-02f, 1.51286870e-01f, 1.54470041e-01f, 1.34003937e-01f,
  4.25051525e-02f, 9.09338668e-02f, -8.93318057e-02f, 1.35289162e-01f, 2.12783948e-01f, -1.19308963e-01f, -8.28007236e-02f, 2.44017929e-01f, -1.48239315e-01f, -2.27166474e-01f,
  1.04381084e-01f, 2.12633133e-01f, 2.05730647e-01f, -6.63666567e-03f, 1.60778478e-01f, 3.10940333e-02f, 2.17250153e-01f, 2.60161936e-01f, -1.22252926e-01f, 2.68222004e-01f,
  -1.78674653e-01f, -2.69569755e-01f, 4.31641098e-03f, 3.12491581e-02f, 7.63132721e-02f, 3.42453793e-02f, 1.26295730e-01f, -7.38457292e-02f, -4.28191237e-02f, 3.04767452e-02f,
  -1.31342977e-01f, 5.56377731e-02f, -8.37879926e-02f, 1.39904708e-01f, -1.83327153e-01f, 7.28363469e-02f, -1.11038372e-01f, 1.10864803e-01f, -2.00757176e-01f, 1.80881798e-01f,
  1.84540749e-01f, -1.76625580e-01f, -2.00600065e-02f, 4.09221686e-02f, -1.19101152e-01f, 2.17110977e-01f, -9.85800698e-02f, 2.14395642e-01f, -3.09147388e-01f, 8.56235474e-02f,
  1.92053825e-01f, 8.13103616e-02f, 7.99950883e-02f, 1.96063831e-01f, 2.10763112e-01f, 1.04555748e-01f, 1.10474899e-01f, 2.26965770e-01f, 1.00021154e-01f, -8.70218277e-02f,
  -1.43918708e-01f, 2.28303611e-01f, 1.05767727e-01f, 2.13334531e-01f, -1.10000744e-01f, 1.08785264e-01f, 9.40782279e-02f, 1.06168047e-01f, 3.42921704e-01f, 9.50233787e-02f,
  3.67303863e-02f, 2.59494752e-01f, -3.45521607e-02f, -2.86896154e-02f, 9.73772183e-02f, 3.01870465e-01f, 2.31596008e-01f, 1.40720516e-01f, 3.36242244e-02f, 9.24227312e-02f,
  2.62970716e-01f, 2.02778995e-01f, -1.16041414e-01f, -1.80126932e-02f, -5.78618550e-04f, 3.32716778e-02f, -2.19489425e-01f, -1.55322641e-01f, 1.83311775e-01f, -1.94943957e-02f,
  7.09858686e-02f, 2.46601477e-01f, 1.57939658e-01f, 1.99068010e-01f, -3.16923112e-02f, 7.60919303e-02f, -6.23149462e-02f, 1.13803491e-01f, -2.02966467e-01f, 2.64826924e-01f,
  -1.95031855e-02f, 5.89303859e-02f, -1.34393811e-01f, 1.16474397e-01f, 1.68265566e-01f, 3.03387195e-02f, -2.07548048e-02f, 6.97416067e-02f, 3.30338813e-02f, 3.09819639e-01f,
  -1.36549547e-01f, 9.02734101e-02f, -2.52898723e-01f, 1.35608867e-01f, 1.24676466e-01f, -9.46731716e-02f, -2.80214101e-02f, 1.49446666e-01f, 2.14471832e-01f, -4.80423570e-02f,
  -7.41329119e-02f, 1.65293768e-01f, -1.14369482e-01f, 1.55013993e-01f, -3.80314887e-02f, 1.88367009e-01f, 2.48061996e-02f, 2.12272882e-01f, -1.14570977e-02f, 2.99202412e-01f,
  1.88840583e-01f, 1.02995165e-01f, 2.18837187e-01f, 2.58379549e-01f, 1.29648954e-01f, 2.05548018e-01f, 3.38789797e-03f, 1.77409112e-01f, -1.34962887e-01f, 1.09461904e-01f,
  1.09883785e-01f, 2.04271197e-01f, -1.29694119e-03f, 2.81682927e-02f, 2.02441350e-01f, -7.48118944e-03f, -2.47291580e-01f, -9.38488543e-02f, 2.25015476e-01f, 1.99126408e-01f,
  -1.30474538e-01f, -3.79621908e-02f, 2.31327161e-01f, 1.30497530e-01f, -8.33343342e-03f, 1.26443908e-01f, 6.12423308e-02f, 1.89864367e-01f, 9.75499451e-02f, 6.57990277e-02f,
  -6.97696432e-02f, -5.51380999e-02f, -4.38483208e-02f, 1.21069759e-01f, 7.57250860e-02f, 5.60858380e-03f, 1.91334128e-01f, 3.16510737e-01f, 4.20466699e-02f, 5.80606647e-02f,
  9.86931697e-02f, -5.28209843e-02f, 9.85968951e-03f, 2.61926889e-01f, 5.04910164e-02f, 1.71183854e-01f, -1.17785364e-01f, -4.53951210e-02f, 9.37720481e-03f, 1.17903925e-01f,
  9.65890363e-02f, 1.61344394e-01f, 9.48656499e-02f, 1.97161585e-01f, 1.61481991e-01f, 1.46489725e-01f, 1.44491391e-03f, 1.44713283e-01f, 7.07046911e-02f, 2.53074095e-02f,
  -2.66881049e-01f, -5.42736873e-02f, -1.22069791e-01f, 3.04463178e-01f, 2.38016367e-01f, 1.25049919e-01f, 1.12839416e-02f, 9.86007974e-02f, 2.48880382e-03f, 1.51821986e-01f,
  2.94146361e-04f, -8.50537196e-02f, -8.86782929e-02f, 5.10709211e-02f, -5.14050797e-02f, 8.08241442e-02f, 1.32352605e-01f, 2.11818963e-01f, 1.47323966e-01f, 2.32699700e-02f,
  2.05732241e-01f, -3.61656874e-01f, -1.90771386e-01f, -3.55973933e-03f, 1.47913471e-01f, -1.15133181e-01f, -2.18943641e-01f, -1.74499661e-01f, -7.13997558e-02f, -1.95662409e-01f,
  -1.56630769e-01f, -1.90346733e-01f, -1.29361898e-01f, -3.90851907e-02f, 9.73337814e-02f, 2.82572389e-01f, 1.71734780e-01f, 9.75292176e-02f, -1.91818088e-01f, -1.09268337e-01f,
  2.42022127e-02f, 1.24424072e-02f, 3.42017487e-02f, -1.16827115e-01f, -3.25965509e-02f, 1.22522533e-01f, -1.90204471e-01f, -9.33054686e-02f, -8.72661546e-03f, 7.94970244e-03f,
  1.19834729e-01f, 9.38001126e-02f, -3.09231341e-01f, -1.21914633e-02f, -2.21786812e-01f, -4.47523259e-02f, 1.05594911e-01f, 5.84878065e-02f, 2.28117391e-01f, -3.80850583e-02f,
  -2.04383601e-02f, 3.03889632e-01f, 9.27550998e-03f, -9.13756043e-02f, 1.71534792e-01f, 1.00863203e-01f, 3.05542678e-01f, -7.25107118e-02f, -1.16810329e-01f, -7.68542960e-02f,
  -2.04745773e-02f, -1.17849752e-01f, -4.66172211e-02f, 1.68981016e-01f, -1.32736877e-01f, -5.02108820e-02f, 1.77580100e-02f, 1.20085105e-01f, 2.08441377e-01f, 3.04432184e-01f,
  2.35181361e-01f, 4.56803925e-02f, 2.96305150e-01f, 9.19962078e-02f, 2.94902846e-02f, -6.50737360e-02f, 1.23757236e-01f, 7.03453571e-02f, -1.34289488e-01f, 7.53657222e-02f,
  2.21974522e-01f, 3.46135736e-01f, 5.96272163e-02f, 1.12056434e-01f, 2.17715785e-01f, -7.36533999e-02f, -2.22022355e-01f, -2.62669355e-01f, -6.41635284e-02f, -1.84770837e-01f,
  -1.44910710e-02f, 4.01111543e-02f, 4.12934199e-02f, -3.78151648e-02f, 1.04360230e-01f, 1.25559688e-01f, -8.60458910e-02f, -6.95895478e-02f, 2.31452152e-01f, -2.29703754e-01f,
  2.22537354e-01f, 3.02130520e-01f, 2.87916958e-01f, -2.68732280e-01f, -9.54451263e-02f, 1.47674054e-01f, 6.81096911e-02f, -8.59489292e-02f, 1.68112576e-01f, 1.26689985e-01f,
  -3.05334091e-01f, -5.70463128e-02f, -6.22288212e-02f, -5.93292341e-03f, 2.51814425e-01f, 1.35796607e-01f, -1.70501992e-01f, 1.53330892e-01f, -6.56444877e-02f, -1.55141801e-01f,
  -9.87039041e-03f, 3.34893376e-01f, 1.93586379e-01f, 1.83619887e-01f, 6.09343238e-02f, 2.05183297e-01f, -3.81235704e-02f, 1.33527324e-01f, 1.54424109e-03f, -2.23831058e-01f,
  1.32788643e-02f, -3.89088430e-02f, 2.31077239e-01f, -5.30425832e-03f, 8.97215456e-02f, 1.08222120e-01f, 1.02686234e-01f, 3.03476989e-01f, -1.19954636e-02f, 1.88745454e-01f,
  9.16580781e-02f, -1.14127144e-01f, -1.82841480e-01f, 1.47693589e-01f, 1.10324301e-01f, 2.97607090e-02f, 2.34107077e-01f, 2.25110233e-01f, -6.63729534e-02f, 9.93654877e-02f,
  -1.12742208e-01f, -2.73523986e-01f, -1.35241255e-01f, -1.19568288e-01f, -7.42369443e-02f, 1.94759801e-01f, 1.88922942e-01f, 4.95805182e-02f, -1.43482238e-01f, 1.82227045e-01f,
  -3.60639654e-02f, -3.95147502e-02f, 8.14871490e-03f, 9.18903351e-02f, 7.64611065e-02f, 2.78778464e-01f, 5.03622834e-03f, 2.25269422e-01f, -2.44525149e-02f, 2.22009107e-01f,
  1.04485944e-01f, -7.97245800e-02f, 1.46357864e-01f, 2.23533362e-01f, -1.37136742e-01f, -1.25091389e-01f, -9.04839337e-02f, 9.47974324e-02f, 3.59059647e-02f, 1.66134015e-01f,
  -4.17892300e-02f, 2.63832659e-01f, -2.44555831e-01f, 6.47333041e-02f, -1.06742956e-01f, 2.66644835e-01f, -2.11279118e-03f, 1.85888708e-02f, 2.13644132e-01f, -3.73111591e-02f,
  2.04486683e-01f, 8.70381221e-02f, 1.54165044e-01f, -2.27824841e-02f, -1.77879408e-01f, 4.41901311e-02f, -3.32745090e-02f, 8.39180574e-02f, 1.86036527e-01f, 7.49919564e-02f,
  -1.38873741e-01f, -2.27545351e-02f, -8.21476579e-02f, 6.00325130e-02f, -5.49509414e-02f, 8.46477821e-02f, 1.45310655e-01f, 3.24339777e-01f, 1.39513180e-01f, 1.30797938e-01f,
  1.65226892e-01f, -5.68279065e-02f, 1.86387617e-02f, 2.75423583e-02f, 1.58289075e-01f, 2.09065288e-01f, -3.17673348e-02f, -1.68552756e-01f, 7.81918988e-02f, -1.30467653e-01f,
  -1.85500354e-01f, 1.86886728e-01f, 2.05145836e-01f, -1.04432218e-01f, 2.11915344e-01f, 1.86665609e-01f, 3.47959204e-03f, -1.52571663e-01f, 1.80757605e-02f, -2.84910798e-01f,
  1.94423810e-01f, 1.12989642e-01f, 1.53363109e-01f, 2.24586233e-01f, -1.60407066e-01f, 1.65506437e-01f, -1.72373638e-01f, -1.60329640e-01f, -1.29319474e-01f, 1.29114091e-01f,
  -1.27458218e-02f, -5.00133634e-02f, 8.84412527e-02f, -1.13393506e-02f, 1.18891923e-02f, -1.22641556e-01f, 2.91127175e-01f, 7.87748471e-02f, 1.97790518e-01f, -1.44060239e-01f,
  -2.64649391e-01f, 2.79516250e-01f, -9.40344334e-02f, -6.04828335e-02f, -7.82654732e-02f, -5.74992504e-03f, 1.66253626e-01f, 1.93256676e-01f, 1.43487170e-01f, 6.97979257e-02f,
  1.79100052e-01f, -3.28962877e-03f, 2.68569171e-01f, 1.93221211e-01f, 8.12125206e-02f, 2.78519273e-01f, -2.55868584e-01f, 1.00778751e-01f, 2.94014104e-02f, -7.29777664e-02f,
  -2.18479127e-01f, -2.10817128e-01f, 1.41092464e-01f, -1.49838835e-01f, -4.20153663e-02f, 7.08816051e-02f, 1.96174458e-01f, 2.22747121e-02f, 2.43790969e-02f, 9.89423618e-02f,
  2.29755729e-01f, 1.94477767e-01f, -1.15343861e-01f, 7.59505332e-02f, -2.31792688e-01f, 1.17076233e-01f, -5.87963052e-02f, -1.47703998e-02f, 1.20862201e-01f, 2.66638491e-02f,
  1.24200538e-01f, 3.23654503e-01f, 2.71386616e-02f, -5.51950447e-02f, -1.79393739e-01f, 3.15213412e-01f, -1.47871733e-01f, -1.49096921e-01f, 1.89858660e-01f, 6.20023124e-02f,
  -7.96880201e-03f, -1.30303036e-02f, 3.20274711e-01f, 1.44462317e-01f, 2.28187628e-02f, -6.98651597e-02f, -2.53679484e-01f, -3.21258530e-02f, 3.21487457e-01f, 1.49930939e-01f,
  2.58484602e-01f, 2.97211111e-01f, 5.12494780e-02f, -1.32553622e-01f, 9.70947370e-02f, 1.41959148e-03f, 1.31340055e-02f, 1.19971275e-01f, 1.73286945e-02f, -9.07105431e-02f,
  1.16042830e-01f, 1.68182582e-01f, -9.31577832e-02f, 2.79521286e-01f, 6.82009533e-02f, -1.87870368e-01f, -7.89877865e-03f, 2.04131380e-01f, 2.01035459e-02f, 2.27336839e-01f,
  1.51144177e-01f, 3.51015389e-01f, -1.95148185e-01f, -1.52444690e-01f, -2.48481035e-02f, -1.60393491e-01f, -2.67860651e-01f, -4.29985765e-03f, 1.14359170e-01f, 3.42366658e-02f,
  1.35092974e-01f, 1.04981013e-01f, 1.52758837e-01f, 8.92091468e-02f, 3.04860890e-01f, 4.83013969e-03f, -3.15751471e-02f, 2.29043156e-01f, 8.95087644e-02f, 8.87442753e-02f,
  8.36334974e-02f, -2.11398005e-01f, 7.92775825e-02f, -3.65553722e-02f, 2.24957690e-01f, 7.97192901e-02f, 8.42202902e-02f, -1.52167529e-01f, 7.88118765e-02f, 2.55145460e-01f,
  8.97878930e-02f, -1.15525484e-01f, 1.26626313e-01f, -2.05982607e-02f, 1.77008986e-01f, 1.06778532e-01f, -6.96292147e-02f, 6.03001043e-02f, -9.98952165e-02f, 4.13926244e-02f,
  -1.19115092e-01f, -1.25297576e-01f, 2.90549040e-01f, -1.17826700e-01f, -9.33421105e-02f, -2.40357876e-01f, -7.60008162e-03f, -8.09221491e-02f, 8.15575272e-02f, -2.44081050e-01f,
  -1.35308489e-01f, -3.08688045e-01f, 2.69290388e-01f, -2.36651182e-01f, 2.82526135e-01f, 2.78167397e-01f, 1.49373375e-02f, -2.19319090e-01f, 2.29234800e-01f, 1.22312859e-01f,
  2.69487798e-01f, 2.21251026e-01f, 7.70030618e-02f, 1.08405970e-01f, 2.19965473e-01f, 7.00485930e-02f, -1.95976332e-01f, -2.88482755e-01f, 2.36693606e-01f, -1.76373929e-01f,
  -5.09799793e-02f, -4.87332419e-02f, 1.95398659e-01f, -1.50648341e-01f, -6.89674169e-02f, -1.43174723e-01f, 6.81892484e-02f, 2.02212166e-02f, 1.05099469e-01f, 1.81053728e-01f,
  2.01325104e-01f, -1.00672767e-01f, -7.14163929e-02f, -9.22922865e-02f, 4.75913025e-02f, 6.14285748e-03f, 2.32289284e-02f, 1.31348580e-01f, -4.94458079e-02f, 7.20887259e-02f,
  1.30034581e-01f, -8.79562870e-02f, 2.30461344e-01f, -5.12381690e-03f, 5.83013892e-02f, 1.64282188e-01f, -1.88096762e-01f, -6.58222586e-02f, 4.33052406e-02f, -1.81769446e-01f,
  -1.69691309e-01f, 1.80991694e-01f, 3.07990238e-02f, -1.35849953e-01f, 1.52193662e-02f, 1.81759536e-01f, 2.45275740e-02f, 1.79134123e-02f, 2.94444263e-01f, 2.90048510e-01f,
  2.36811355e-01f, 1.12958327e-01f, -2.34592646e-01f, 2.18762085e-01f, -5.71282161e-03f, -3.78967933e-02f, -8.37480053e-02f, 6.33089840e-02f, -6.01477884e-02f, -6.29518032e-02f,
  2.79805847e-02f, 2.45995939e-01f, 1.48018181e-01f, 1.64935634e-01f, 1.04915701e-01f, 2.04806626e-01f, 8.77711400e-02f, 1.30384088e-01f, -1.38940245e-01f, -1.00071810e-01f,
  -2.44310480e-02f, 1.05050772e-01f, -2.28947580e-01f, 1.73315644e-01f, 1.99521661e-01f, 8.27645361e-02f, -4.18405905e-02f, 8.23864564e-02f, 1.78025201e-01f, -1.00294732e-01f,
  5.37441149e-02f, 1.44999221e-01f, 2.76627779e-01f, -1.41071215e-01f, -2.36633554e-01f, -1.19743571e-01f, 1.93745688e-01f, -1.23584405e-01f, 1.47948384e-01f, 1.31696954e-01f,
  -1.31238714e-01f, -1.40400663e-01f, 3.94501209e-01f, -2.52021134e-01f, 2.49439508e-01f, 7.91814923e-02f, 2.63951153e-01f, -6.70465305e-02f, 6.44879639e-02f, -1.54601201e-01f,
  3.19362551e-01f, 1.51811436e-01f, 2.92807907e-01f, 2.24270411e-02f, -7.33571872e-03f, 6.93486035e-02f, 7.27251032e-03f, -5.71696013e-02f, 9.19055641e-02f, 6.76261773e-03f,
  1.92916065e-01f, -7.29202107e-02f, -2.41210058e-01f, -2.17150420e-01f, -7.00181574e-02f, 8.30362216e-02f, 8.75658095e-02f, -9.85497832e-02f, -1.73225433e-01f, 5.87800182e-02f,
  -4.13687825e-02f, 7.59500042e-02f, 2.13658363e-01f, 8.84809473e-04f, 4.43166457e-02f, -1.82413146e-01f, 7.25385994e-02f, 2.69525975e-01f, 7.97685906e-02f, 1.90893024e-01f,
  2.82022089e-01f, 1.19974732e-01f, 1.48843274e-01f, 1.25130340e-01f, 1.01478919e-02f, 2.83405166e-02f, -1.20592527e-01f, 1.75502617e-02f, 8.66026357e-02f, 1.85874417e-01f,
  -6.84144907e-03f, 1.74139678e-01f, 1.27401620e-01f, 2.85475224e-01f, -2.88064517e-02f, -1.76402599e-01f, -2.61248291e-01f, -5.12907393e-02f, 2.68102624e-02f, 2.11969763e-01f,
  1.73190936e-01f, -8.32224339e-02f, -1.07379511e-01f, 2.59883374e-01f, 2.33200416e-01f, -8.35288912e-02f, -7.09768087e-02f, 6.40632734e-02f, 1.20016798e-01f, 2.74705529e-01f,
  -2.42029019e-02f, 2.22878277e-01f, -1.72260940e-01f, 2.76328642e-02f, 1.49384797e-01f, -9.67483222e-02f, 8.90322998e-02f, 3.01580876e-01f, -8.44936445e-02f, -1.30036578e-01f,
  3.33008878e-02f, 1.10860661e-01f, 7.68100992e-02f, 1.40428901e-01f, -1.39744207e-01f, 2.85075635e-01f, -1.60918728e-01f, 1.38071105e-01f, -1.30207062e-01f, 2.03201219e-01f,
  -1.57205686e-02f, 1.22419760e-01f, 3.31601262e-01f, 1.49788588e-01f, 1.49819687e-01f, 1.61548853e-01f, -1.83271334e-01f, 1.30265296e-01f, -2.25586712e-01f, 1.55333087e-01f,
  2.27332547e-01f, -5.33369463e-03f, 8.34807977e-02f, 2.92107642e-01f, 2.62605518e-01f, 1.72348037e-01f, -1.57001868e-01f, 2.17750400e-01f, 1.48241624e-01f, 1.27084553e-01f,
  -7.80382613e-03f, 2.81991456e-02f, 8.30281973e-02f, 1.31879859e-02f, 5.25748990e-02f, 2.58931935e-01f, 1.72984853e-01f, -7.80889839e-02f, 2.63054576e-02f, 1.28714278e-01f,
  1.20984368e-01f, -3.89996506e-02f, -1.14409775e-01f, 2.27456212e-01f, 1.60989061e-01f, 1.47767738e-01f, 1.35997787e-01f, 1.20132059e-01f, -2.81256940e-02f, 1.45822227e-01f,
  3.08947772e-01f, 1.18303016e-01f, 2.53338575e-01f, 2.44101952e-03f, 1.64607950e-02f, 5.19901179e-02f, -3.55922952e-02f, 7.21757358e-04f, 2.11643606e-01f, 1.80218264e-01f,
  2.67901242e-01f, 3.32890339e-02f, 2.58274376e-01f, 1.93808377e-01f, -3.20432544e-01f, -9.00482107e-03f, -1.01481058e-01f, -1.87067017e-01f, 2.94654667e-01f, 3.04564070e-02f,
  -3.21861031e-03f, -1.56541988e-01f, -1.12177938e-01f, -1.00566551e-01f, 2.31793225e-01f, -2.82295763e-01f, -4.78671715e-02f, -5.48378713e-02f, 2.06816614e-01f, -2.19866246e-01f,
  2.36785024e-01f, 1.49896696e-01f, -5.91145270e-03f, -1.78928301e-01f, 8.38807002e-02f, 1.73436522e-01f, 2.53289342e-01f, 1.15810744e-01f, 2.98722461e-02f, 2.07510620e-01f,
  1.99137151e-01f, -1.15399668e-03f, -1.42396137e-01f, -2.99568325e-01f, 1.88358843e-01f, -1.65256426e-01f, -1.48714902e-02f, 4.84733796e-03f, 1.39049500e-01f, -1.91989735e-01f,
  -2.63853163e-01f, 7.08637154e-03f, 7.35252164e-03f, -2.46626034e-01f, 6.11127242e-02f, 1.14658393e-01f, 1.19610457e-02f, 1.00001790e-01f, -1.87034667e-01f, 9.41066369e-02f,
  2.01469794e-01f, -1.40847325e-01f, -1.84325308e-01f, 1.10959038e-01f, -2.65482277e-01f, -8.79030004e-02f, -5.14219552e-02f, -8.86306763e-02f, 9.03684348e-02f, -1.97421849e-01f,
  3.80234011e-02f, 2.37062022e-01f, -2.13144794e-01f, 4.12043668e-02f, -8.45132172e-02f, -1.75468147e-01f, -1.60857484e-01f, 1.44168973e-01f, 1.51320249e-01f, -3.80116925e-02f,
  1.07931988e-02f, 2.57072657e-01f, -2.19868701e-02f, 4.68952395e-02f, 3.15386206e-01f, 3.05135429e-01f, 1.56397760e-01f, -4.42736857e-02f, -2.09404528e-01f, 1.24758966e-01f,
  1.65131316e-01f, -2.36530334e-01f, -1.62090540e-01f, 1.14334486e-01f, -7.65376464e-02f, -6.44226596e-02f, 1.61374643e-01f, 1.68385282e-01f, 2.21963584e-01f, 2.82630801e-01f,
  2.64299095e-01f, 2.06766441e-01f, 1.60311833e-01f, 2.70299107e-01f, -7.17434706e-03f, 1.03960959e-02f, 3.21302265e-02f, -2.52985090e-01f, 2.37534046e-02f, 2.21801728e-01f,
  3.03091884e-01f, 2.50612885e-01f, 2.37484902e-01f, -1.12666219e-01f, -7.78956711e-02f, -2.11241484e-01f, 2.17202052e-01f, 7.15865381e-03f, 3.35281342e-02f, -1.74695656e-01f,
  -4.61572148e-02f, -1.58994421e-01f, -3.49862762e-02f, -2.54600402e-03f, 2.49886930e-01f, 2.80459642e-01f, -2.87113693e-02f, -1.70825616e-01f, -1.22519597e-01f, 3.74038843e-03f,
  2.71416366e-01f, 1.16117477e-01f, 2.59350300e-01f, -2.27270946e-01f, -8.07517543e-02f, 9.11499336e-02f, 1.08207345e-01f, 2.47206315e-01f, 2.94891685e-01f, -6.49266094e-02f,
  -8.37879702e-02f, 2.38041505e-01f, 3.19081545e-02f, -9.01513100e-02f, 9.12906528e-02f, 1.90972742e-02f, -3.16323414e-02f, 1.94493085e-01f, -1.90674700e-02f, 2.46451244e-01f,
  -2.94209216e-02f, -4.10611567e-04f, -5.61755300e-02f, 2.20680952e-01f, 1.72644705e-01f, 7.22834244e-02f, -2.24251114e-02f, 2.65404314e-01f, -5.54437935e-02f, -2.43385211e-01f,
  1.89133912e-01f, 1.16280809e-01f, -2.43827491e-03f, -3.79051431e-03f, -1.11555636e-01f, 1.56711321e-02f, -6.07107617e-02f, -3.15357782e-02f, -4.54442985e-02f, 5.13769351e-02f,
  -1.71596631e-01f, 1.00706026e-01f, -2.04673693e-01f, -3.59772034e-02f, 5.34283705e-02f, -1.33470163e-01f, -1.95201114e-01f, 6.82476088e-02f, 9.66973603e-02f, 2.55599529e-01f,
  -5.43750729e-03f, 1.71952769e-01f, 2.67573357e-01f, 3.10379267e-01f, -2.00262263e-01f, 1.08844288e-01f, -1.14861257e-01f, -1.25008821e-01f, -1.71245977e-01f, -1.62084680e-02f,
  2.99096853e-01f, 2.59786956e-02f, 9.63839889e-02f, 1.35443255e-01f, 9.02573392e-02f, -7.84147531e-02f, -1.28413677e-01f, 4.04084384e-01f, -8.77513885e-02f, -1.06486306e-01f,
  -1.57511979e-02f, -1.16189167e-01f, -2.14329705e-01f, -3.16715427e-03f, 1.66476637e-01f, -1.21266015e-01f, 3.08068395e-02f, 6.40990511e-02f, -6.05674051e-02f, -1.97118204e-02f,
  2.69824982e-01f, 1.03287660e-01f, 1.12323649e-01f, -1.11536384e-01f, 1.97186973e-02f, 2.74778176e-02f, 2.33527005e-01f, -2.52291262e-01f, 7.10140541e-02f, 8.67683962e-02f,
  -5.69294058e-02f, -1.90151855e-01f, -1.51665211e-02f, 4.02701408e-01f, -4.37595695e-02f, 9.61937532e-02f, 1.32909209e-01f, -3.37808654e-02f, 6.20456859e-02f, 2.38306865e-01f,
  2.69559268e-02f, 5.34666851e-02f, -1.46355137e-01f, -2.01725885e-01f, 1.91920161e-01f, 3.12167227e-01f, -3.84992883e-02f, 7.63955265e-02f, 5.99754527e-02f, 1.87170178e-01f,
  1.18953222e-02f, 1.31377697e-01f, 1.78759634e-01f, 3.00747842e-01f, 4.60277610e-02f, 1.84356600e-01f, 4.74660322e-02f, 1.93810940e-01f, 2.95807064e-01f, 7.55051225e-02f,
  1.09406777e-01f, 1.68259740e-02f, -2.85319775e-01f, -9.37873730e-04f, 2.76865065e-01f, 3.25038761e-01f, -1.89575404e-01f, 8.50536749e-02f, 1.05589640e-03f, 1.19340606e-01f,
  5.75891398e-02f, 2.46605232e-01f, 2.77386457e-01f, 1.65083170e-01f, -6.22032769e-02f, -8.60690325e-02f, -7.09790140e-02f, 2.20924735e-01f, 2.71957427e-01f, 5.15475273e-02f,
  1.61644205e-01f, 1.11695997e-01f, 1.25741407e-01f, 1.86953679e-01f, -1.86736524e-01f, 2.03787595e-01f, 1.63936719e-01f, -1.32861659e-01f, 1.15166999e-01f, 2.45640099e-01f,
  1.37443364e-01f, 1.36624068e-01f, 1.81574613e-01f, 1.65291458e-01f, 1.08678751e-01f, -1.34134680e-01f, 3.17663737e-02f, -1.89935192e-02f, -7.30269104e-02f, -1.22855134e-01f,
  2.17961982e-01f, 2.96522766e-01f, 1.32124633e-01f, 1.10157609e-01f, 6.60976544e-02f, 2.46795014e-01f, -1.41188905e-01f, -2.34218433e-01f, 3.64577144e-01f, 2.34033853e-01f,
  -5.38076013e-02f, 3.62637222e-01f, 3.23128998e-01f, 2.70601287e-02f, 7.79426917e-02f, -3.29922624e-02f, 1.34516060e-01f, 1.08525334e-02f, 1.27081156e-01f, 3.61832261e-01f,
  1.58484336e-02f, -4.43066396e-02f, 1.44519717e-01f, 9.63624641e-02f, -8.74962285e-02f, 7.33107403e-02f, 9.73961726e-02f, 1.39956921e-01f, 1.37713000e-01f, 1.30679294e-01f,
  -1.44919887e-01f, -1.77608699e-01f, -3.13571580e-02f, 1.28901839e-01f, 1.57004163e-01f, -6.28664345e-02f, 2.01260373e-01f, -1.12316184e-01f, 8.42215568e-02f, 2.89274782e-01f,
  9.15883929e-02f, -2.92156097e-02f, 3.43420953e-01f, 1.77199826e-01f, -1.43616706e-01f, -1.59482971e-01f, 1.80809632e-01f, 5.58009837e-03f, -1.56211983e-02f, -6.80155754e-02f,
  1.28144488e-01f, 1.04547963e-01f, -3.60992476e-02f, 3.53820547e-02f, 1.48927299e-02f, 2.50793725e-01f, 1.87889099e-01f, 8.33266675e-02f, -1.89923048e-01f, 8.50786194e-02f,
  -1.33271217e-01f, -1.94571540e-01f, 2.38370150e-01f, 5.92881208e-03f, 1.98020622e-01f, 4.25467156e-02f, 2.42382810e-01f, 2.10675269e-01f, 2.65977442e-01f, 1.09748058e-01f,
  -5.52297868e-02f, 1.57965288e-01f, -3.19430344e-02f, -7.78574403e-03f, -1.11984305e-01f, 1.81582440e-02f, 9.98143703e-02f, 1.86933756e-01f, 2.63696879e-01f, 1.22826263e-01f,
  -1.60359815e-02f, -2.68842459e-01f, -4.56804261e-02f, 1.01920120e-01f, -3.99058685e-02f, -1.83422253e-01f, -8.72305483e-02f, 2.21762843e-02f, -3.70825466e-04f, -2.31238380e-01f,
  1.97681606e-01f, 1.45676598e-01f, -2.13220209e-01f, -1.32090688e-01f, 2.12983504e-01f, 7.49185914e-03f, 3.27180654e-01f, 2.77129441e-01f, 1.87152371e-01f, -1.72253385e-01f,
  -2.11190600e-02f, -1.96279928e-01f, 2.99449265e-01f, 1.51249111e-01f, 3.00385743e-01f, 1.48024827e-01f, -1.09386966e-01f, 1.35350540e-01f, -9.90497023e-02f, 8.84371065e-03f,
  2.45178640e-01f, -2.81136427e-02f, 7.46703986e-03f, -1.04001105e-01f, -1.44076362e-01f, -1.71830699e-01f, -1.62529960e-01f, -9.19450000e-02f, -1.32152572e-01f, 1.26346529e-01f,
  -7.98470005e-02f, 2.09627688e-01f, 4.20368202e-02f, 2.25991502e-01f, 1.06477894e-01f, 4.17972915e-03f, 5.51733673e-02f, -5.25530055e-02f, -1.27101511e-01f, 1.63247257e-01f,
  3.74381132e-02f, -9.13468823e-02f, -1.04014680e-01f, -2.29109600e-01f, -2.27809563e-01f, -1.01806737e-01f, 9.54697058e-02f, 3.17895561e-01f, 1.02291912e-01f, 2.02625439e-01f,
  1.86531380e-01f, 2.06345752e-01f, -2.00112350e-02f, 2.28391346e-02f, -6.71742260e-02f, 7.61109591e-02f, 2.06712693e-01f, 7.53029957e-02f, -4.28888574e-02f, -3.33113261e-02f,
  2.28611425e-01f, 2.77566295e-02f, -1.42664522e-01f, -4.43175212e-02f, 2.52772987e-01f, 1.10633761e-01f, 1.17857642e-01f, 1.96804196e-01f, -2.70359010e-01f, -2.43679695e-02f,
  -2.90842690e-02f, -6.52192906e-02f, 9.68490243e-02f, -1.01616539e-01f, 2.96053380e-01f, -1.63098469e-01f, -2.11240146e-02f, 1.96025208e-01f, -3.08391284e-02f, 4.81298454e-02f,
  6.92903027e-02f, 2.70113945e-01f, 5.57674170e-02f, -5.22135012e-02f, 1.81076184e-01f, 6.33525997e-02f, -1.32985771e-01f, -1.29202679e-01f, 9.97303054e-02f, -1.73433349e-01f,
  4.43167984e-02f, -1.09484710e-01f, 2.44046729e-02f, 1.68027312e-01f, -4.83177379e-02f, 1.40946418e-01f, -2.09330335e-01f, 3.70932631e-02f, -3.65325771e-02f, -4.92722951e-02f,
  1.64739162e-01f, -4.01022732e-02f, 1.35448605e-01f, -1.28299356e-01f, -1.45102665e-02f, 4.56345975e-02f, 1.00660577e-01f, -7.44709745e-02f, -1.05418704e-01f, 1.77834742e-02f,
  3.81649137e-02f, -4.84401509e-02f, -1.23388795e-02f, -2.67113894e-01f, 1.15876220e-01f, -1.00648418e-01f, -5.44693619e-02f, 5.21549918e-02f, 1.50024444e-01f, 1.94525614e-01f,
  -1.59004360e-01f, 1.26132309e-01f, -6.68188184e-02f, 1.68803662e-01f, -1.92967296e-01f, -1.83140561e-02f, -9.11545530e-02f, -9.62719545e-02f, -1.51228145e-01f, 8.27840529e-03f,
  2.25770295e-01f, -6.02622405e-02f, -4.61549759e-02f, 2.57117152e-01f, -1.62042931e-01f, 3.06194723e-02f, -1.88696757e-01f, 3.48762721e-01f, -1.59741610e-01f, -2.91882575e-01f,
  1.14121161e-01f, 2.68573519e-02f, -1.85003117e-01f, 9.19404179e-02f, 2.18056887e-01f, -1.16331272e-01f, 8.93505961e-02f, -8.93264823e-03f, -9.91279483e-02f, -1.53675854e-01f,
  6.31055832e-02f, 1.13361262e-01f, 9.87181291e-02f, 1.05143905e-01f, 3.81384715e-02f, -3.61060835e-02f, 1.44581854e-01f, -4.02019992e-02f, 6.63421825e-02f, 2.62428373e-01f,
  1.24633938e-01f, -4.87732701e-02f, -5.54962978e-02f, 2.87191391e-01f, -2.12965637e-01f, 1.64207011e-01f, 1.55647650e-01f, 7.75786536e-03f, 3.98579203e-02f, 2.72579372e-01f,
  4.49576473e-04f, 2.90085375e-01f, 8.17692839e-03f, 6.41562715e-02f, 1.51509345e-01f, 1.74201950e-01f, -1.18462123e-01f, -1.75685007e-02f, -4.47675847e-02f, -1.09188989e-01f,
  -1.02730192e-01f, 2.78328329e-01f, 1.01544857e-01f, -5.71737774e-02f, -9.61036831e-02f, 2.24373534e-01f, 8.16737264e-02f, 1.76078066e-01f, 2.43043639e-02f, 2.58408457e-01f,
  1.67120174e-01f, 3.67257148e-02f, -2.06463151e-02f, -1.32004201e-01f, -7.87858814e-02f, 1.11010477e-01f, 2.58022726e-01f, 8.85993317e-02f, 7.58342966e-02f, 7.78266117e-02f,
  -2.10160911e-01f, 2.74423063e-01f, -8.78294855e-02f, -2.68060807e-02f, 1.93466432e-02f, -1.06231131e-01f, 1.56951100e-02f, -7.94033557e-02f, 1.95746064e-01f, 8.80367905e-02f,
  -3.80912155e-01f, 2.89694872e-02f, -2.36309290e-01f, -5.73105663e-02f, 2.19929725e-01f, 1.14715911e-01f, -5.47432713e-02f, -7.05426000e-03f, -3.39304060e-02f, 6.15258068e-02f,
  7.88623095e-02f, -2.01189324e-01f, -1.36886969e-01f, -1.41787216e-01f, 2.45564029e-01f, -3.76584768e-01f, 2.52681315e-01f, 1.22623354e-01f, -2.32331064e-02f, -2.69404948e-01f,
  1.31572768e-01f, 3.00154418e-01f, 3.03833246e-01f, 9.55581740e-02f, 1.21327601e-01f, 1.59830227e-01f, -1.72244161e-01f, 1.32281578e-03f, -7.93479234e-02f, -1.07202716e-01f,
  -1.15579113e-01f, 2.67856777e-01f, 1.67544007e-01f, 2.43850634e-01f, 1.99391261e-01f, -1.07290208e-01f, -1.01121597e-01f, -1.05340317e-01f, 1.95809379e-01f, 3.93420570e-02f,
  1.69495896e-01f, -8.22322592e-02f, -8.54173377e-02f, -1.17352583e-01f, -1.48145631e-01f, 2.89371870e-02f, 3.99002552e-01f, 1.23912863e-01f, 1.61977578e-02f, -9.10545662e-02f,
  2.12770566e-01f, -1.29774630e-01f, 1.61597371e-01f, 1.59143806e-01f, 2.40457892e-01f, -2.23531485e-01f, -3.84157039e-02f, 1.53045788e-01f, -8.37774202e-02f, 2.58395553e-01f,
  7.51951858e-02f, -1.51869476e-01f, -7.68405125e-02f, 2.41029322e-01f, -5.66560254e-02f, -9.01082531e-02f, 1.31183460e-01f, 1.09323226e-01f, 3.08782458e-01f, 6.00378774e-03f,
  1.23811677e-01f, 2.26462916e-01f, 4.78911810e-02f, 1.16539430e-02f, -1.07904769e-01f, 1.15554616e-01f, -2.99031306e-02f, 2.70003062e-02f, 1.56261027e-02f, 1.35635540e-01f,
  -1.12047028e-02f, -2.75617689e-02f, 2.41981089e-01f, 2.02320918e-01f, 2.85254955e-01f, 1.40032858e-01f, 2.88143784e-01f, 1.88940421e-01f, 1.55553862e-01f, 2.43954495e-01f,
  2.01677844e-01f, 8.44867080e-02f, -1.13672078e-01f, -3.01844805e-01f, 1.59142360e-01f, -1.45913154e-01f, 1.09582290e-01f, -3.34763974e-02f, 3.09793144e-01f, -7.53484219e-02f,
  -2.33135745e-01f, -1.22372396e-01f, 7.03836307e-02f, -6.70216084e-02f, -7.57347792e-02f, -1.02209985e-01f, -1.73989180e-02f, -1.75595522e-01f, -2.91285794e-02f, -3.25157493e-02f,
  8.72778222e-02f, 1.06399804e-02f, -1.29168764e-01f, -2.82092661e-01f, 9.70232189e-02f, -6.87489435e-02f, 1.60703823e-01f, 9.38045159e-02f, 1.47051007e-01f, -2.77363569e-01f,
  -1.01240367e-01f, 2.65484571e-01f, 1.15435101e-01f, 4.51846384e-02f, 2.71105468e-01f, -1.47886753e-01f, -3.79514173e-02f, 1.18123032e-01f, 2.33483333e-02f, -4.78111282e-02f,
  1.41712101e-02f, 1.89404652e-01f, 1.52739584e-01f, -6.00762330e-02f, 6.85129091e-02f, 3.41924161e-01f, 1.01889148e-01f, 9.20854062e-02f, -2.43826866e-01f, 1.97443798e-01f,
  1.37116313e-01f, -1.85944811e-01f, -3.62217948e-02f, 2.09618375e-01f, -8.49220455e-02f, 7.62625188e-02f, 1.98487088e-01f, 8.65464956e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  1.40245840e-01f, 1.82431921e-01f, 9.23347920e-02f, 1.99745357e-01f, 2.04787269e-01f, 6.20094547e-03f, 1.41899660e-01f, 2.84948438e-01f, 1.19557045e-01f, 1.33854210e-01f,
  1.67256594e-01f, 2.27105170e-01f, 1.79622665e-01f, 1.18778802e-01f, 1.31552666e-01f, -1.20085187e-03f, 1.56742737e-01f, 2.49057233e-01f, 1.27476856e-01f, 9.84738395e-02f,
  1.56021774e-01f, 1.04785033e-01f, 1.63456704e-02f, 7.63080493e-02f, 3.23338091e-01f, 1.21079264e-02f, 1.53630748e-01f, 3.02386373e-01f, 1.93143755e-01f, 2.42699355e-01f,
  1.50261670e-01f, 1.50664404e-01f, 2.20694900e-01f, 1.84070244e-01f, -3.68364677e-02f, 3.17797065e-01f, 1.10412382e-01f, 2.99907416e-01f, 3.85131314e-02f, 1.34398639e-01f,
  1.49283886e-01f, 1.94604158e-01f, 1.98062524e-01f, 9.78873763e-03f, 3.25651281e-03f, 1.28775701e-01f, 2.34049469e-01f, 2.58596577e-02f, -6.96044713e-02f, 6.74072057e-02f,
  2.27705330e-01f, 2.76218563e-01f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.61810532e-01f, -1.38346374e-01f, 3.30666602e-02f, -8.46086890e-02f, -1.01568485e-02f, 5.39279692e-02f, -9.55000892e-02f, 9.12010074e-02f, 3.56626436e-02f, -7.21970992e-03f,
  -8.01325664e-02f, 2.12994050e-02f, 8.41728300e-02f, -1.67177051e-01f, -7.02018067e-02f, 9.98870581e-02f, -3.78614962e-02f, 1.53199911e-01f, -1.94176435e-02f, -6.46681860e-02f,
  -4.13397327e-02f, -1.95080526e-02f, -5.92322312e-02f, -7.06299990e-02f, 8.58732983e-02f, 1.60546660e-01f, 4.22730856e-02f, -3.68252657e-02f, 4.86471802e-02f, -3.28301638e-02f,
  1.09525874e-01f, -5.37178945e-04f, 5.50811030e-02f, -1.33786527e-02f, 1.88149922e-02f, -3.67262177e-02f, 9.70275179e-02f, 4.11883630e-02f, -7.93688372e-02f, -1.09199742e-02f,
  -1.90462843e-01f, -1.50814801e-01f, 1.47555247e-01f, 7.27690011e-02f, 9.48266387e-02f, -6.70195892e-02f, -5.36705814e-02f, -1.97033450e-01f, 7.16657564e-02f, -5.85428514e-02f,
  2.24219739e-01f, -1.08876705e-01f, -3.35453376e-02f, -8.15748721e-02f, 1.40049756e-01f, 1.11373002e-02f, -4.50930297e-02f, -1.49937887e-02f, 1.74030751e-01f, 1.35010064e-01f,
  -4.16460782e-02f, -4.34160493e-02f, 1.28821805e-01f, 1.72798820e-02f, 7.31955841e-03f, -8.23939815e-02f, 1.29161760e-01f, -8.00901949e-02f, -5.84119447e-02f, 6.71919733e-02f,
  -2.64623389e-02f, -5.98888062e-02f, 1.52036414e-01f, 9.65628773e-02f, 1.25952754e-02f, 7.95463771e-02f, 5.90162631e-03f, 1.58469245e-01f, -6.86239302e-02f, 3.93322483e-02f,
  7.11808130e-02f, 6.36980534e-02f, -2.64361291e-03f, -4.71059904e-02f, 1.08145148e-01f, 7.09254295e-02f, -5.43636829e-02f, 9.75949839e-02f, -4.18444490e-03f, 8.05878863e-02f,
  -3.44329774e-02f, 1.12306193e-01f, 2.60541271e-02f, 6.89210221e-02f, -1.02089576e-01f, 1.54600710e-01f, 1.57101035e-01f, -8.94282311e-02f, 1.29341543e-01f, 1.45892784e-01f,
  -1.56391099e-01f, 1.99765384e-01f, 2.00864524e-01f, -1.96383651e-02f, 1.59441419e-02f, 1.42870157e-03f, -1.30800530e-01f, 8.62953812e-02f, -1.53415233e-01f, -1.08911671e-01f,
  6.05435995e-03f, 2.10501194e-01f, -3.05202864e-02f, 9.91459489e-02f, -9.01784748e-02f, -1.47419229e-01f, -1.78902261e-02f, -1.43831549e-02f, -4.84259194e-03f, 1.23593241e-01f,
  5.99922985e-02f, 3.43983360e-02f, -2.05797255e-01f, 8.19347501e-02f, 9.30457413e-02f, -1.64843425e-02f, 4.08121347e-02f, -1.65433183e-01f, 9.22576115e-02f, 1.24896869e-01f,
  -8.89246985e-02f, 1.13655426e-01f, -7.88144991e-02f, 8.61681327e-02f, -1.97851192e-02f, -1.69914607e-02f, -4.15436029e-02f, 9.78787020e-02f, -1.82226762e-01f, -1.16753742e-01f,
  1.80360243e-01f, 5.43884151e-02f, -1.10947331e-02f, -1.37667656e-01f, -1.73770249e-01f, -6.69792369e-02f, 7.11774528e-02f, 1.45119473e-01f, -2.76125111e-02f, -4.52708006e-02f,
  1.25498295e-01f, 7.09530860e-02f, 4.13587280e-02f, 1.48929045e-01f, -5.18264659e-02f, -3.45431268e-02f, 4.80046310e-02f, 4.48706513e-03f, 2.00213850e-01f, -2.69785989e-02f,
  1.05751321e-01f, 1.28681466e-01f, -1.28930703e-01f, -1.20886326e-01f, -2.58062910e-02f, 7.51167312e-02f, 3.03400401e-02f, 1.58110216e-01f, 6.53068423e-02f, 5.62909842e-02f,
  1.39141798e-01f, 1.08524878e-02f, 1.59044191e-01f, 1.18535265e-01f, -7.40778968e-02f, -1.56197995e-02f, 4.41255569e-02f, -6.53642863e-02f, -1.25322044e-01f, -8.71508792e-02f,
  -7.13644624e-02f, -2.33839378e-02f, -8.71210694e-02f, -1.53682679e-01f, 1.38998240e-01f, -2.42561428e-03f, 9.07836631e-02f, -2.75873542e-02f, -3.78855504e-02f, 1.60012674e-02f,
  -1.67354569e-02f, 1.79317649e-02f, 1.12647396e-02f, 1.63992476e-02f, -1.54024974e-01f, 3.71691026e-03f, 6.06786385e-02f, 5.22855446e-02f, -6.88890442e-02f, 1.42305613e-01f,
  7.54706860e-02f, 4.13468592e-02f, 7.09994812e-04f, -2.28703037e-01f, -8.43315125e-02f, -8.52215812e-02f, -1.84947193e-01f, 9.53545347e-02f, -1.05337285e-01f, 1.27480492e-01f,
  1.49436712e-01f, 2.41677593e-02f, 5.43758497e-02f, -2.24547703e-02f, -2.96174381e-02f, -7.87245855e-02f, -1.49071291e-01f, -7.83723667e-02f, -5.44556603e-02f, -5.53272851e-02f,
  4.71468829e-02f, -1.59381732e-01f, 2.96582393e-02f, -5.00992872e-03f, 8.73063803e-02f, 1.15468152e-01f, -3.23034748e-02f, 1.45073548e-01f, 3.41204666e-02f, 1.92571372e-01f,
  -6.95466250e-02f, -8.95801485e-02f, 3.30347829e-02f, -1.27100334e-01f, -1.24075346e-01f, -1.12439424e-01f, -7.66100064e-02f, 7.89685100e-02f, -4.90116701e-02f, -7.57840499e-02f,
  2.03599378e-01f, -8.53790492e-02f, 9.37027857e-02f, 1.45402085e-02f, 1.88449278e-01f, -8.71456712e-02f, -1.21859141e-01f, 9.11011398e-02f, -7.17363134e-02f, -5.82478531e-02f,
  1.61714792e-01f, -5.04445285e-02f, -9.45150256e-02f, 1.02231935e-01f, -9.73342285e-02f, -1.37395924e-02f, 1.14123948e-01f, 5.86132854e-02f, 3.25037390e-02f, -1.34913400e-01f,
  -1.54221933e-02f, 1.54355079e-01f, -8.71492028e-02f, 1.75351903e-01f, 7.39995688e-02f, -2.08836123e-01f, -1.30120292e-01f, 8.74869816e-04f, 1.60794631e-01f, -7.73604661e-02f,
  5.65209799e-02f, -1.86107159e-02f, 5.36609665e-02f, -8.47892538e-02f, -4.82336655e-02f, -1.03165381e-01f, 9.80324298e-02f, -9.35245957e-03f, -5.85015677e-02f, -2.33362652e-02f,
  -9.32174250e-02f, 4.04928718e-03f, -1.08423583e-01f, -8.06279927e-02f, -5.92940152e-02f, 3.51946503e-02f, -5.17203175e-02f, 1.01399593e-01f, 7.38306493e-02f, 4.58452404e-02f,
  -7.26301670e-02f, 1.32993937e-01f, -1.22864313e-01f, 1.38795719e-01f, -1.19515575e-01f, 2.33633118e-03f, 1.06818937e-01f, 9.41394269e-02f, 1.46287844e-01f, -2.34508384e-02f,
  -3.46044563e-02f, -3.93147208e-02f, -1.14173889e-01f, -5.13793640e-02f, 1.16778158e-01f, -7.85336867e-02f, 1.16803400e-01f, -8.00021067e-02f, 2.13284984e-01f, -3.86546701e-02f,
  1.27069101e-01f, -9.90406871e-02f, -5.62119111e-03f, -5.72604612e-02f, 1.04059421e-01f, -1.24721132e-01f, -2.67019104e-02f, 5.51532023e-02f, -4.94394526e-02f, 1.89994369e-02f,
  -8.54722410e-02f, 7.42115155e-02f, -7.85942078e-02f, 1.50962081e-02f, 8.70998502e-02f, -4.64461045e-03f, 1.49552539e-01f, -3.57863978e-02f, -1.19574659e-01f, 1.47850011e-02f,
  -1.29216015e-01f, -7.71013349e-02f, 1.13550290e-01f, -1.22084662e-01f, 1.54107168e-01f, -5.22440076e-02f, -9.08204466e-02f, -9.87292975e-02f, 3.97461373e-03f, 4.09850217e-02f,
  -1.27796859e-01f, 9.01526865e-03f, -1.13587387e-01f, -1.35996327e-01f, 3.74118611e-02f, 4.91823012e-04f, -6.37756586e-02f, -5.88260479e-02f, -1.11140065e-01f, 1.30250350e-01f,
  -1.87786177e-01f, -1.51392147e-01f, 8.64895061e-02f, 9.85951498e-02f, -6.34417161e-02f, -1.52699491e-02f, 1.02525135e-03f, -1.02729581e-01f, 1.11232154e-01f, 1.14089355e-01f,
  8.99844617e-02f, 9.46106613e-02f, 1.33087505e-02f, 1.65617600e-01f, 1.15242921e-01f, 2.42615994e-02f, -4.45343927e-02f, 1.09383866e-01f, -9.00434032e-02f, -2.31278688e-03f,
  -6.66702241e-02f, 4.78410535e-02f, -6.81890324e-02f, 1.63504973e-01f, -3.54292952e-02f, 1.14469476e-01f, -8.03018361e-03f, -1.64882354e-02f, 4.56565805e-02f, -8.90305713e-02f,
  8.81180167e-02f, -4.18992043e-02f, 6.81769997e-02f, 9.93485525e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  4.33612168e-02f, 7.81322569e-02f, 7.10820109e-02f, 1.61123946e-01f, -5.14288098e-02f, 1.70240015e-01f, -1.20767184e-01f, -3.25725436e-01f, 1.37163952e-01f, -2.56348670e-01f,
  1.60952926e-01f, 2.04260483e-01f, 3.09565850e-02f, 1.98427230e-01f, 2.86214828e-01f, -4.01376113e-02f, 2.86633551e-01f, -3.28072488e-01f, -1.16793953e-01f, 2.13107076e-02f,
  5.02671301e-02f, 1.74152389e-01f, -1.15377180e-01f, 2.08426163e-01f, -5.98869324e-02f, -2.73966908e-01f, 2.26474851e-02f, 3.13782133e-02f, 1.23087443e-01f, 3.43753159e-01f,
  -3.77879851e-02f, 4.75294702e-02f, 1.27593622e-01f, -5.39224036e-02f, 2.41444945e-01f, 2.17464834e-01f, -1.66678444e-01f, -2.42521480e-01f, 3.26825008e-02f, -8.69143978e-02f,
  1.63074136e-01f, 1.16445795e-01f, 4.88595925e-02f, -4.39473912e-02f, 1.82015806e-01f, -2.42143199e-01f, 6.32516807e-03f, 1.23283923e-01f, -6.32356256e-02f, 1.16215803e-01f,
  2.77226239e-01f, -1.02381974e-01f, 1.45107552e-01f, -1.35957181e-01f, 2.59547055e-01f, 1.14327364e-01f, -2.72072311e-02f, 1.83002695e-01f, 3.26018006e-01f, 4.48605157e-02f,
  -1.12550976e-02f, -7.81999528e-02f, 3.16920638e-01f, 9.36128106e-03f, 1.31080195e-01f, 5.09275943e-02f, 8.45894367e-02f, 2.17972860e-01f, 1.65271714e-01f, 1.48804545e-01f,
  -1.28002733e-01f, -6.60856580e-03f, 1.32227048e-01f, -1.68599516e-01f, 1.51743457e-01f, 1.64880589e-01f, 2.86058396e-01f, 2.32326597e-01f, -2.83391159e-02f, 4.94866781e-02f,
  -1.41054511e-01f, 1.27194539e-01f, 1.60230502e-01f, -2.68289335e-02f, 6.87612221e-02f, -1.09598592e-01f, 1.67664990e-01f, 3.21079940e-01f, -1.13600694e-01f, -2.41472900e-01f,
  -5.41874766e-02f, -1.24398321e-02f, 1.18433960e-01f, 7.65892565e-02f, 2.99145758e-01f, 2.18670756e-01f, 2.72924304e-02f, 1.69245154e-01f, -3.43534388e-02f, 3.05771735e-02f,
  -9.25488174e-02f, -2.71443844e-01f, -6.90081045e-02f, -1.69680089e-01f, -8.99229050e-02f, 1.27772421e-01f, 8.30552280e-02f, -8.93420056e-02f, 2.67437667e-01f, 2.55901128e-01f,
  -2.71562546e-01f, 1.45324558e-01f, 4.78501879e-02f, -9.58408117e-02f, 2.89878577e-01f, 4.23017330e-02f, 2.82537311e-01f, -1.67507395e-01f, -6.55007362e-02f, -1.63251638e-01f,
  1.07529044e-01f, 2.08476648e-01f, 1.78239107e-01f, -1.12584896e-01f, -1.30472615e-01f, 1.97659999e-01f, 5.42695262e-02f, -1.17613204e-01f, 1.03959002e-01f, 7.57009983e-02f,
  1.54043818e-02f, 1.01068281e-01f, -2.83275433e-02f, 6.55876324e-02f, 8.24464709e-02f, -5.29496334e-02f, -5.70003018e-02f, 2.17571452e-01f, 3.39275189e-02f, 1.53642362e-02f,
  -1.05875202e-01f, -1.73022032e-01f, -3.30280699e-02f, 2.07027689e-01f, 1.83229566e-01f, -2.76721958e-02f, -8.93166661e-02f, 1.63122728e-01f, -1.45855591e-01f, 2.16786757e-01f,
  -9.27283149e-03f, 3.55182448e-03f, 2.82697648e-01f, 2.83307225e-01f, 2.23647803e-02f, 1.11493371e-01f, -1.45571485e-01f, -1.93318099e-01f, 3.15009803e-02f, -1.06489159e-01f,
  -8.90301634e-03f, -5.15353046e-02f, 1.02421902e-02f, -5.08257225e-02f, 1.47695377e-01f, 2.60706633e-01f, 5.21878898e-02f, 2.63681918e-01f, -5.49533479e-02f, -1.28485426e-01f,
  -6.89199120e-02f, 2.01522604e-01f, 1.52768958e-02f, -8.80886987e-02f, 6.01097643e-02f, -1.54901937e-01f, -9.98942181e-02f, 2.17630073e-01f, -6.19382635e-02f, 1.41058238e-02f,
  -1.45915985e-01f, 2.21813530e-01f, 1.44010961e-01f, -2.40429163e-01f, 1.02406740e-01f, 2.56338507e-01f, -1.13450021e-01f, 1.46360189e-01f, -1.84521616e-01f, -9.32109430e-02f,
  7.73367509e-02f, 2.46956795e-01f, -1.92889536e-03f, 9.60635096e-02f, -7.00196251e-02f, 7.31455907e-02f, 2.03216314e-01f, -1.20209646e-03f, -8.55663121e-02f, 3.00781310e-01f,
  1.37511775e-01f, -2.30612695e-01f, 2.73936599e-01f, -3.09255034e-01f, 2.15950292e-02f, -1.00528775e-02f, -8.01087469e-02f, -9.90134552e-02f, -5.04977629e-02f, -5.76094375e-04f,
  2.23077193e-01f, 6.79875538e-02f, 3.25872064e-01f, -3.16243134e-02f, 2.11826459e-01f, 3.17655027e-01f, -1.00283571e-01f, -7.25275949e-02f, 3.95105444e-02f, -6.29338697e-02f,
  7.59047866e-02f, -2.76540667e-01f, 1.45315275e-01f, 2.52956957e-01f, 1.40351623e-01f, 6.26280084e-02f, 1.77335199e-02f, 1.02457881e-01f, 2.95423359e-01f, -2.24392071e-01f,
  -6.48562536e-02f, -1.87010214e-01f, 1.08130097e-01f, 1.47854149e-01f, -1.02722891e-01f, -2.45076120e-01f, -4.76308912e-02f, 1.14758402e-01f, 2.53001042e-02f, 8.20382163e-02f,
  2.56392211e-01f, 1.56421095e-01f, 8.67674649e-02f, 1.42595276e-01f, 3.01949143e-01f, 7.07883984e-02f, 1.50634155e-01f, 6.56148642e-02f, -1.42754197e-01f, -1.29404083e-01f,
  8.11558142e-02f, -2.97361106e-01f, 8.97693634e-03f, 3.08438212e-01f, 1.64750606e-01f, 1.60722360e-01f, 4.60221544e-02f, -4.00711261e-02f, 2.74011567e-02f, 2.26286668e-02f,
  1.33180078e-02f, -2.41069838e-01f, 1.44764528e-01f, -1.57835901e-01f, 9.24256593e-02f, -1.96975157e-01f, 1.79513603e-01f, 2.85116822e-01f, 7.09583908e-02f, 3.31863731e-01f,
  3.66703011e-02f, 2.69520193e-01f, 2.22355962e-01f, 3.29918899e-02f, -1.18246377e-01f, -1.91583991e-01f, -1.49801642e-01f, 2.18031406e-01f, 1.31723851e-01f, 2.33598366e-01f,
  -1.03292346e-01f, -2.56028362e-02f, 1.60963401e-01f, 2.12551579e-01f, 5.50401621e-02f, 5.42001985e-02f, 2.27796827e-02f, 1.81386709e-01f, -2.09860682e-01f, -7.21545219e-02f,
  2.98448861e-01f, 1.02440260e-01f, -2.02453688e-01f, 7.16748089e-02f, 1.59768194e-01f, -1.61355346e-01f, 6.33758632e-03f, -3.24242339e-02f, 9.74892899e-02f, 1.57588527e-01f,
  6.82817474e-02f, -2.36376196e-01f, 2.24645913e-01f, -7.79920770e-03f, -6.85223285e-03f, -1.60849392e-01f, -4.32016961e-02f, 2.17853507e-04f, -5.83328344e-02f, -1.44579694e-01f,
  8.43517035e-02f, 3.25096399e-02f, 2.05448151e-01f, 3.05304915e-01f, -5.48705384e-02f, 3.84203225e-01f, 8.95499140e-02f, -9.34927836e-02f, 6.65457472e-02f, -9.52180177e-02f,
  -5.55686653e-02f, 1.23212755e-01f, 1.53948823e-02f, 1.75119057e-01f, 2.13729013e-02f, 1.32645192e-02f, -6.95585683e-02f, 1.75699279e-01f, -1.64497629e-01f, 3.07776034e-01f,
  2.28827856e-02f, -2.78593630e-01f, 1.79838035e-02f, 1.27521411e-01f, 1.23280279e-01f, 1.31576374e-01f, -1.97765067e-01f, -4.72103767e-02f, 2.80093610e-01f, 3.36059898e-01f,
  2.03567073e-01f, -1.30133972e-01f, 1.08640395e-01f, 1.87290177e-01f, 2.35925719e-01f, 3.84851098e-01f, -1.49053797e-01f, -2.47222617e-01f, 3.02896332e-02f, -3.40484262e-01f,
  4.03359234e-01f, -1.12164915e-01f, 2.01005265e-01f, 1.82817981e-01f, -4.47358996e-01f, -6.52287826e-02f, 3.31388921e-01f, 2.96238065e-01f, 2.21119687e-01f, 1.61463410e-01f,
  9.91806388e-02f, 8.15494135e-02f, 1.70546472e-01f, 1.95461914e-01f, 1.91023022e-01f, 1.07171044e-01f, -2.44561896e-01f, 9.86656025e-02f, 1.67897165e-01f, 8.52296725e-02f,
  -1.45892844e-01f, 2.74556011e-01f, -3.71340439e-02f, 2.91088447e-02f, 1.08404562e-01f, -1.40243888e-01f, 1.53387278e-01f, -2.83977419e-01f, 3.12129734e-03f, -1.50405005e-01f,
  9.31812078e-02f, -1.17824189e-01f, -5.88915907e-02f, 3.67973521e-02f, -2.15539266e-03f, 1.83479875e-01f, 2.45770648e-01f, 1.49218976e-01f, 1.38588697e-01f, 1.04687713e-01f,
  1.52374953e-01f, -2.26274610e-01f, -2.42832862e-03f, 2.24548690e-02f, -2.18295023e-01f, 2.29469150e-01f, 5.23357205e-02f, 1.17298581e-01f, 2.71885544e-01f, 4.10426818e-02f,
  9.38934088e-02f, -3.16040128e-01f, -1.39675096e-01f, 2.50845611e-01f, -1.53586656e-01f, 1.08106084e-01f, -1.27027407e-02f, 1.25051066e-01f, 1.19175448e-03f, 1.27935797e-01f,
  -7.37981498e-02f, -2.21148250e-03f, 1.24588802e-01f, 2.51916319e-01f, 3.58472462e-03f, -1.74100414e-01f, -2.58747041e-01f, 6.74567670e-02f, 1.36520296e-01f, 1.57653689e-01f,
  3.25002931e-02f, 1.31248862e-01f, 3.05625707e-01f, 2.74763882e-01f, 1.49434209e-01f, 1.74875990e-01f, -4.41678315e-02f, 2.79810488e-01f, 2.93428540e-01f, 4.16995026e-02f,
  1.45199046e-01f, 1.44439712e-01f, -2.65760362e-01f, 2.21538559e-01f, 1.29757017e-01f, 6.44324869e-02f, -1.96863651e-01f, 2.12677181e-01f, 2.12600902e-01f, -4.74920543e-03f,
  2.06271075e-02f, 1.81076929e-01f, -5.53243905e-02f, -6.09694142e-03f, 1.55581713e-01f, -1.13944627e-01f, 2.10859388e-01f, 2.57749408e-01f, 9.19830203e-02f, -1.80696584e-02f,
  2.00468153e-01f, 2.32906625e-01f, -5.51746972e-02f, 1.43632606e-01f, 5.16289137e-02f, 2.04352033e-03f, -1.41148463e-01f, -7.89092854e-02f, 1.50744781e-01f, 1.41021371e-01f,
  2.09459737e-01f, 1.41497731e-01f, -4.69752550e-02f, -1.34308964e-01f, -1.78155988e-01f, 1.94358438e-01f, 2.47130036e-01f, 2.01151390e-02f, 1.11513130e-01f, 1.38819337e-01f,
  2.73486406e-01f, 2.47350454e-01f, -1.71302408e-01f, -9.42761153e-02f, -1.81829378e-01f, -1.55777156e-01f, 2.13820159e-01f, 1.65803492e-01f, 1.19919755e-01f, 7.95599371e-02f,
  -1.67566072e-02f, 2.41444185e-01f, -1.30607828e-01f, -9.93084013e-02f, 9.43858847e-02f, -1.14013508e-01f, -1.03922598e-01f, -1.09089956e-01f, 5.77078834e-02f, 1.20498061e-01f,
  2.13696957e-01f, -2.47171372e-01f, 8.00298247e-03f, 1.48345411e-01f, -2.77920216e-01f, 1.70527011e-01f, -1.41073754e-02f, -1.78599134e-01f, -4.10505235e-02f, 1.25103042e-01f,
  2.29237750e-01f, -1.90028489e-01f, -1.16281450e-01f, 7.21799210e-02f, 3.29986155e-01f, 1.58510327e-01f, -1.86520051e-02f, -1.22246429e-01f, -2.94017456e-02f, 2.63312757e-01f,
  -2.70772398e-01f, -2.53358871e-01f, -4.97285975e-03f, 2.13699237e-01f, 1.59077033e-01f, 5.28760925e-02f, 1.14726163e-01f, 3.16081531e-02f, -1.54360488e-01f, -2.05347836e-01f,
  2.36157537e-01f, -1.62299886e-01f, 1.80909976e-01f, 8.67026858e-03f, 3.96366194e-02f, -3.84184495e-02f, 2.87048876e-01f, 6.82925209e-02f, 2.06473738e-01f, -3.29138637e-02f,
  -4.31287177e-02f, -1.21810846e-01f, 1.41782627e-01f, 2.05698296e-01f, -2.71564901e-01f, 2.59445272e-02f, -2.08841562e-01f, -2.00914457e-01f, 2.20793094e-02f, 1.60830289e-01f,
  -3.74589376e-02f, 2.37134069e-01f, -1.64241731e-01f, 1.38268061e-03f, 1.32168010e-01f, -1.73837528e-01f, 3.44591081e-01f, 2.89420843e-01f, -6.23757299e-03f, -2.49924943e-01f,
  -6.52341470e-02f, 1.48737565e-01f, 1.80889010e-01f, -1.15847327e-02f, 1.37320474e-01f, -1.55012012e-01f, 1.13924444e-01f, 1.15874531e-02f, 2.35816747e-01f, 1.28734410e-01f,
  -3.25166211e-02f, -3.87344472e-02f, 7.48256519e-02f, -9.34923068e-02f, 6.87704384e-02f, 1.34509861e-01f, 1.80890352e-01f, -1.17325917e-01f, -2.31173828e-01f, 2.45239228e-01f,
  4.06843536e-02f, -1.79863218e-02f, -1.42026976e-01f, -8.06929320e-02f, 3.18709821e-01f, 2.37898588e-01f, 2.63046455e-02f, 3.47165158e-03f, 4.79722433e-02f, -8.38538110e-02f,
  5.04013896e-02f, -1.88411083e-02f, 2.71653175e-01f, -1.03423379e-01f, -2.10166752e-01f, -8.34063813e-03f, 1.05042487e-01f, -1.71625584e-01f, -8.77137184e-02f, 8.36297944e-02f,
  -9.47541818e-02f, -1.37617933e-02f, 2.15915769e-01f, 5.24706533e-03f, 6.58627823e-02f, 1.90678686e-01f, 1.01341315e-01f, 3.11000258e-01f, 2.02216461e-01f, 5.73787391e-02f,
  3.78642082e-01f, 3.67158026e-01f, 2.45647475e-01f, 1.08895481e-01f, 1.33275539e-01f, -2.47531101e-01f, -2.99510717e-01f, 1.47225156e-01f, 2.00028777e-01f, -2.33646303e-01f,
  -3.79674956e-02f, -5.32624200e-02f, 2.28341430e-01f, 2.98254639e-01f, 3.71340543e-01f, 1.88507438e-01f, -6.04636548e-03f, 1.16381235e-01f, -5.79368398e-02f, 1.89117610e-01f,
  -1.79603726e-01f, -1.05296902e-01f, 4.12361063e-02f, 2.52712786e-01f, 1.14864081e-01f, 2.03946501e-01f, -1.89958066e-01f, 1.06533520e-01f, 4.30080295e-02f, 1.63765460e-01f,
  -1.47006527e-01f, 3.32703024e-01f, 2.64045447e-01f, 5.18146902e-02f, -2.30201140e-01f, 1.03625737e-01f, 3.57010275e-01f, 1.10330544e-01f, -1.78494840e-03f, 5.37573211e-02f,
  2.40043774e-01f, 1.67625591e-01f, 7.61026219e-02f, -1.39796495e-01f, -9.73189473e-02f, 1.22377716e-01f, 2.76136756e-01f, -1.24883331e-01f, 1.19358879e-02f, -1.03728846e-02f,
  1.10014126e-01f, 1.49777293e-01f, -4.23741378e-02f, 2.76731551e-01f, 2.28191704e-01f, -6.78448454e-02f, 1.74604774e-01f, -2.45231822e-01f, -8.59621763e-02f, 2.22952649e-01f,
  -1.67180091e-01f, 2.02991515e-01f, -2.31853411e-01f, 1.43502802e-01f, -7.17717558e-02f, 1.09044321e-01f, -2.12375410e-02f, 2.64843125e-02f, -4.06509265e-02f, 3.82163167e-01f,
  -4.20814574e-01f, 1.85041517e-01f, 5.44984676e-02f, -2.70898759e-01f, 2.62908489e-01f, 1.28067866e-01f, -1.55387715e-01f, 4.10583429e-02f, 1.98030382e-01f, 2.59248316e-01f,
  1.16430737e-01f, 5.91851361e-02f, 2.33272403e-01f, 1.62080184e-01f, 1.89906672e-01f, -2.57055134e-01f, -5.66084944e-02f, 2.44295582e-01f, -5.96772209e-02f, 3.18195671e-02f,
  5.48746251e-02f, 9.70769376e-02f, -9.26413853e-03f, 1.10212155e-01f, 1.79103523e-01f, -4.65814322e-02f, -1.46722183e-01f, 2.12232947e-01f, -1.13189682e-01f, 7.61646405e-02f,
  1.30368516e-01f, 6.85845762e-02f, 1.51840717e-01f, 2.29822010e-01f, 7.35549927e-02f, -2.80995108e-03f, 1.64388925e-01f, 4.16448154e-02f, 1.00237153e-01f, 1.40529990e-01f,
  3.06382217e-03f, 2.76587278e-01f, 1.24312103e-01f, -3.11964303e-02f, 1.39518604e-01f, -4.51502092e-02f, -2.38395408e-01f, -2.47935057e-01f, -1.49607182e-01f, 6.68449327e-02f,
  6.88055679e-02f, -6.34489441e-03f, 1.60502285e-01f, 1.48172602e-01f, 1.09928593e-01f, 2.06927612e-01f, 6.40139207e-02f, 6.30951971e-02f, 1.13678098e-01f, 1.72159061e-01f,
  1.42911136e-01f, -8.49483609e-02f, -7.95187727e-02f, -5.29452506e-03f, 1.13915488e-01f, 1.43540263e-01f, 1.59370944e-01f, 1.06141783e-01f, -1.00952037e-01f, 2.61212707e-01f,
  1.21267609e-01f, 1.73980460e-01f, 1.57508969e-01f, 1.14314161e-01f, 1.30303025e-01f, -1.27147034e-01f, -2.73457527e-01f, 9.13965926e-02f, -2.95198429e-02f, 3.96504290e-02f,
  5.85883744e-02f, 1.57888383e-01f, 1.57690465e-01f, 1.19570918e-01f, -7.72401690e-02f, -3.87540422e-02f, 4.93523702e-02f, 2.72251993e-01f, 2.32730079e-02f, -1.79689884e-01f,
  -1.34319186e-01f, -1.23939894e-01f, 5.59449419e-02f, -2.12548092e-01f, -2.15198100e-01f, 1.35794684e-01f, 1.11075059e-01f, 2.36110479e-01f, 8.84296224e-02f, 1.28120475e-03f,
  8.42337981e-02f, 2.05738321e-01f, -2.16930117e-02f, -2.94730458e-02f, 1.08787447e-01f, -9.11198780e-02f, -2.67747521e-01f, -4.09364700e-02f, -2.34539285e-01f, 7.55398870e-02f,
  2.20006838e-01f, 5.87611161e-02f, 1.60419688e-01f, -1.18782371e-01f, -2.63124742e-02f, -1.06350854e-01f, 1.71117380e-01f, 1.16816452e-02f, -3.44830185e-01f, 5.96712343e-02f,
  4.18979861e-02f, 4.86208797e-02f, -1.50668710e-01f, -5.17927222e-02f, -2.72246748e-01f, -2.07231954e-01f, 7.63402656e-02f, 2.27396160e-01f, 1.10307835e-01f, -1.81682780e-01f,
  -3.25266927e-01f, 3.11584711e-01f, -5.52560911e-02f, -1.78454608e-01f, -2.20200028e-02f, -2.90383935e-01f, -2.24169362e-02f, 2.13572621e-01f, 4.66379225e-02f, 2.54657835e-01f,
  6.31028637e-02f, -4.38738540e-02f, 3.10964376e-01f, 2.05523491e-01f, -7.93511048e-02f, 1.58900574e-01f, -1.37987345e-01f, 7.90452287e-02f, -3.40905748e-02f, 2.14918032e-01f,
  -8.29789937e-02f, -6.04577027e-02f, 9.90616158e-02f, -2.41683964e-02f, 1.82004169e-01f, 1.96475506e-01f, -5.46669848e-02f, -2.40393132e-01f, 1.56898290e-01f, -2.91926265e-02f,
  5.10984845e-02f, 3.78123596e-02f, 5.08827195e-02f, 1.15942396e-01f, -1.43792793e-01f, -3.67215946e-02f, 6.93388805e-02f, 7.98116326e-02f, 2.30002567e-01f, 9.10997912e-02f,
  -7.25551648e-03f, -1.64355010e-01f, 2.36957759e-01f, -1.34152457e-01f, -1.58463442e-03f, 3.13738644e-01f, -7.68851042e-02f, -1.64298952e-01f, 1.13942854e-01f, 1.14320926e-01f,
  1.21433839e-01f, -1.84747353e-01f, -1.29797794e-02f, 2.75648296e-01f, 1.49002716e-01f, 1.79502934e-01f, -2.05616113e-02f, -6.97554052e-02f, 1.60911530e-02f, -4.37586568e-02f,
  1.18912973e-01f, -4.86645214e-02f, -2.70331472e-01f, 3.35244060e-01f, 4.96260226e-02f, -2.79092818e-01f, 1.52043462e-01f, 4.63079624e-02f, 1.38639539e-01f, -2.44665779e-02f,
  3.40898558e-02f, -1.63740948e-01f, -5.08666690e-03f, 2.22553417e-01f, -4.11490090e-02f, 1.15847230e-01f, -2.93298483e-01f, 1.27862588e-01f, -6.64097518e-02f, 3.51805270e-01f,
  3.13302785e-01f, -1.70102734e-02f, 1.27616912e-01f, 4.43371832e-02f, 1.15137331e-01f, -2.64382005e-01f, -2.07948819e-01f, 2.51576036e-01f, 2.18916729e-01f, -1.10734448e-01f,
  -9.28522125e-02f, -5.64447455e-02f, 2.75092781e-01f, 1.58443034e-01f, -2.72800568e-02f, -9.53555480e-02f, 6.71527311e-02f, -6.94273561e-02f, 1.26127526e-01f, 7.69965649e-02f,
  1.48860559e-01f, -9.54415649e-02f, 8.47871453e-02f, -1.59048975e-01f, 8.57423320e-02f, -3.44763249e-02f, 1.39080733e-01f, -1.11336578e-02f, 3.43079790e-02f, 2.42515504e-01f,
  4.65501361e-02f, 5.37087247e-02f, -5.02209105e-02f, -7.92615786e-02f, 5.60587309e-02f, 6.52508661e-02f, 1.14034176e-01f, -4.60978448e-02f, 2.01376885e-01f, 2.76863992e-01f,
  -1.84949994e-01f, -1.44876763e-01f, 7.16217682e-02f, 1.89381116e-03f, 1.88446760e-01f, 2.21986279e-01f, 6.64257407e-02f, 2.80332297e-01f, 1.33499980e-01f, 1.80868991e-03f,
  -3.28732058e-02f, 9.73790959e-02f, -3.78837157e-03f, -1.53002158e-01f, 8.35739896e-02f, -1.88712031e-01f, 2.00783566e-01f, 8.30576718e-02f, 2.24291772e-01f, 2.18283180e-02f,
  8.90012085e-02f, 1.20297469e-01f, -1.66854665e-01f, 3.13632041e-01f, -9.94684547e-03f, -2.87070195e-03f, 2.22589239e-01f, 2.29751304e-01f, 2.18274444e-01f, -3.57151367e-02f,
  -1.40954591e-02f, 2.16797158e-01f, 1.69479787e-01f, 1.13541186e-01f, 2.12695882e-01f, -1.87694520e-01f, 3.78108099e-02f, 2.47819796e-01f, -4.41201478e-02f, 2.66085099e-02f,
  1.29179433e-01f, 1.39129773e-01f, -9.52594802e-02f, 1.54448465e-01f, 1.78844064e-01f, 1.71798706e-01f, -8.82289186e-02f, 8.88504460e-02f, -1.18638063e-02f, -2.00802460e-01f,
  -2.78709799e-01f, 2.48307292e-03f, 1.96622506e-01f, -1.75791815e-01f, 2.36215249e-01f, -1.66549742e-01f, -1.00533282e-02f, 8.89874101e-02f, 1.41776606e-01f, 2.06935287e-01f,
  1.03441402e-02f, -3.22379798e-01f, -8.68092701e-02f, 2.17285864e-02f, -4.66565713e-02f, -1.21977963e-01f, -3.72222774e-02f, -1.52734488e-01f, -1.92233130e-01f, 6.82180375e-02f,
  3.38460147e-01f, -9.11319628e-02f, -1.78355172e-01f, 3.77497554e-01f, -1.38059452e-01f, 8.60702097e-02f, 4.36755307e-02f, -1.33719847e-01f, -6.94685876e-02f, 2.20013693e-01f,
  7.74368271e-02f, 1.72854438e-01f, 9.22393054e-02f, -2.06852615e-01f, 3.04279059e-01f, 1.27829149e-01f, 4.86489013e-03f, -1.57565579e-01f, -2.83385012e-02f, 1.99269447e-02f,
  2.26046219e-01f, 2.28724942e-01f, 1.52887087e-02f, 6.38988689e-02f, 9.14283395e-02f, -3.14631611e-01f, -4.99617830e-02f, -1.72631457e-01f, 3.30503076e-01f, -1.50811434e-01f,
  -2.99081206e-01f, -1.00676887e-01f, 1.40273362e-01f, 2.81639785e-01f, 2.27152020e-01f, 2.37740353e-01f, 2.25177720e-01f, 3.46283317e-02f, 1.03816643e-01f, 1.03582725e-01f,
  -1.84831187e-01f, -4.73497957e-02f, -1.64929722e-02f, -2.17239112e-01f, 1.06812842e-01f, -1.42856061e-01f, 9.68759209e-02f, -3.16749185e-01f, 1.52142957e-01f, -1.63638845e-01f,
  -9.60051045e-02f, -6.67372067e-03f, -5.17871864e-02f, 3.01371235e-02f, -1.00470923e-01f, 1.16910800e-01f, -1.30342528e-01f, -3.68049294e-02f, 8.44489597e-03f, -2.04006448e-01f,
  -2.33857274e-01f, -2.08391268e-02f, -2.16851234e-01f, 3.07225525e-01f, -1.23881921e-01f, -2.13826746e-02f, 1.96148768e-01f, 2.90916175e-01f, 1.91353813e-01f, 1.60738826e-01f,
  1.57982931e-01f, -1.23245701e-01f, -9.16695148e-02f, 1.27569050e-01f, 2.33848780e-01f, 1.53845116e-01f, 7.12500215e-02f, 3.31103504e-02f, 3.44873182e-02f, 2.90986806e-01f,
  -6.05612434e-02f, 1.23486653e-01f, -1.41578853e-01f, -7.99133703e-02f, -1.49231464e-01f, 1.70402035e-01f, 1.68426320e-01f, 4.29895073e-02f, 2.23286375e-01f, -1.24653287e-01f,
  -9.46915001e-02f, -4.92923111e-02f, 5.29657258e-03f, -1.11945212e-01f, -1.84505433e-01f, 1.40687451e-01f, 2.41138622e-01f, 2.36005962e-01f, -1.01404218e-02f, 1.81524366e-01f,
  7.55789354e-02f, 3.00610363e-02f, -7.92406034e-03f, 1.26054376e-01f, 1.03516489e-01f, 1.64289236e-01f, -1.18770093e-01f, 2.26250038e-01f, -1.66769251e-01f, -1.12778038e-01f,
  -1.35685056e-02f, 1.15283422e-01f, 2.06481799e-01f, 1.43860653e-01f, -8.88107121e-02f, -2.66066253e-01f, 1.01142444e-01f, 1.65586084e-01f, -2.26653680e-01f, -5.43628633e-02f,
  7.07571134e-02f, 5.97673245e-02f, 3.49239975e-01f, 3.39622647e-01f, -8.55352581e-02f, -5.26194833e-02f, -1.78301454e-01f, -1.18793927e-01f, -8.56620260e-03f, -2.60625005e-01f,
  -1.11946508e-01f, 2.77482346e-02f, -3.45030367e-01f, -2.41872564e-01f, 2.81634152e-01f, 3.38926524e-01f, 3.11561823e-01f, 1.53012261e-01f, 5.10407872e-02f, 3.16564105e-02f,
  -6.00854717e-02f, 1.56962439e-01f, -2.03897119e-01f, 5.03267869e-02f, -2.20343381e-01f, -1.81720052e-02f, -2.03137383e-01f, 2.57968992e-01f, -3.64746213e-01f, 1.65830255e-01f,
  -3.54391038e-01f, 1.60160288e-01f, -1.19748861e-01f, 6.06472753e-02f, -4.11601141e-02f, -8.19634646e-02f, -2.82756031e-01f, -4.48426306e-02f, 1.29948407e-01f, -2.21294358e-01f,
  -6.21950738e-02f, 2.94127502e-02f, 9.09503698e-02f, 1.08427458e-01f, -1.56030416e-01f, 8.92818533e-03f, -7.96408951e-02f, -1.09940618e-01f, 2.36434117e-01f, 7.08828941e-02f,
  8.52488577e-02f, -1.45138726e-01f, 2.51211911e-01f, -1.61759108e-02f, 9.69089121e-02f, 1.33895501e-01f, -2.27366045e-01f, -1.72235608e-01f, 1.23165712e-01f, 1.95344105e-01f,
  6.90988228e-02f, -3.12915027e-01f, 4.99260798e-02f, 1.75940454e-01f, 2.20134199e-01f, -2.74114702e-02f, -1.84408590e-01f, -1.07319832e-01f, 1.78460628e-01f, -5.86545430e-02f,
  2.15000540e-01f, 9.44258198e-02f, -1.57578513e-01f, 1.41190842e-01f, 1.43084377e-01f, 4.86621410e-02f, 9.57581177e-02f, 2.18840301e-01f, -1.87390745e-01f, 2.13435926e-02f,
  -8.67187008e-02f, -1.83532938e-01f, -1.16473958e-01f, 1.66061640e-01f, 7.82397389e-02f, 7.69036077e-03f, -3.42962779e-02f, 3.59371975e-02f, 5.53266555e-02f, 2.76142418e-01f,
  1.40288383e-01f, -7.78923184e-02f, 1.83829203e-01f, -8.05824846e-02f, 2.16363981e-01f, -8.32277089e-02f, -1.38663605e-01f, 3.04074973e-01f, 6.68022484e-02f, 1.43247694e-02f,
  -7.57300928e-02f, -5.85659035e-02f, -3.13284323e-02f, 2.13032186e-01f, -5.68808131e-02f, -1.63207591e-01f, -3.95751335e-02f, -3.15053910e-02f, -2.40125451e-02f, 1.07801408e-01f,
  2.33693793e-02f, 6.50504231e-02f, 9.99967456e-02f, -3.97516787e-02f, -5.71982563e-02f, -8.40276778e-02f, -8.25680152e-04f, -2.15599865e-01f, 2.04585567e-01f, -4.69896942e-02f,
  2.19173506e-01f, -1.57543242e-01f, -2.75686681e-01f, -1.66586563e-02f, 2.54277200e-01f, 1.00231208e-01f, -1.57476887e-01f, 1.16825069e-03f, 9.76886228e-02f, -3.46514694e-02f,
  1.71249688e-01f, -3.96461895e-04f, -3.38625729e-01f, -1.17510907e-01f, -7.69632906e-02f, -1.86533064e-01f, 1.35136202e-01f, -3.31429631e-01f, -2.28150591e-01f, 2.86916971e-01f,
  1.64819751e-02f, -2.92878211e-01f, 1.55305043e-01f, -3.10199317e-02f, 1.53131247e-01f, -8.56879875e-02f, 2.46022090e-01f, 2.02715546e-01f, 6.06620051e-02f, 7.87479579e-02f,
  -1.15313396e-01f, 1.15254976e-01f, -1.34746194e-01f, 3.32955346e-02f, -1.39369234e-01f, -8.86569638e-03f, -1.98712528e-01f, 1.91430837e-01f, -1.21040359e-01f, -2.03441046e-02f,
  -8.74377564e-02f, 4.60235812e-02f, 1.07317090e-01f, -1.10955924e-01f, -2.25766107e-01f, -2.15409890e-01f, 1.59661949e-01f, -1.40911326e-01f, -1.64125636e-01f, -2.83172037e-02f,
  6.85343519e-02f, 1.64609566e-01f, -8.31689909e-02f, 1.67055652e-01f, 3.72950956e-02f, 1.16970383e-01f, -9.78695899e-02f, 1.61615759e-01f, 1.10429414e-01f, -2.65258729e-01f,
  2.34607860e-01f, -1.43226728e-01f, -8.42881128e-02f, 4.63331677e-02f, -2.75093675e-01f, 9.73975286e-02f, 5.16958311e-02f, 2.56775804e-02f, -2.40724944e-02f, -1.75915748e-01f,
  4.12698239e-01f, 2.01847866e-01f, 7.87665322e-02f, 9.99252424e-02f, 1.77075386e-01f, 1.28868669e-01f, 1.58983350e-01f, 1.32302284e-01f, -1.79119203e-02f, -2.66381443e-01f,
  1.42094165e-01f, 2.10901216e-01f, 3.42652768e-01f, 7.97249824e-02f, 3.65672586e-03f, 3.02608043e-01f, 9.42495242e-02f, -1.66102853e-02f, -1.72162447e-02f, -5.10680005e-02f,
  1.39684053e-02f, -4.00586380e-03f, -2.42333978e-01f, -1.65437952e-01f, -1.04234152e-01f, 2.32274197e-02f, 2.18023270e-01f, 2.13470887e-02f, 1.94746226e-01f, 7.52721056e-02f,
  8.66657346e-02f, -1.59265861e-01f, 6.80238083e-02f, 3.54474857e-02f, 3.11466288e-02f, -9.50634629e-02f, 5.68150543e-02f, 4.47145700e-02f, 2.46171027e-01f, 4.68583219e-02f,
  8.18835688e-04f, 7.15582520e-02f, 2.04446092e-02f, -1.86348148e-02f, 1.40242487e-01f, 5.52154072e-02f, -1.02601543e-01f, -2.42468677e-02f, 1.61295637e-01f, -7.46643096e-02f,
  3.07392359e-01f, 2.88442639e-03f, -2.04994723e-01f, 1.92872286e-01f, 4.16220427e-02f, -1.25309676e-01f, -3.76329236e-02f, 3.05628657e-01f, 1.98431835e-01f, 1.15423553e-01f,
  -7.23201707e-02f, 2.51929648e-02f, 2.95473486e-01f, 1.69259965e-01f, -2.08811343e-01f, 1.97580293e-01f, 1.98607519e-01f, -7.25593325e-03f, 3.06105465e-01f, 1.72841460e-01f,
  -6.36354163e-02f, 4.39571664e-02f, 2.75615722e-01f, -1.00989662e-01f, -2.62393832e-01f, -7.65583366e-02f, -1.29852355e-01f, -5.62084578e-02f, -2.06670221e-02f, -5.86062260e-02f,
  2.95442432e-01f, 1.79801896e-01f, 2.75190771e-01f, 1.03625424e-01f, 8.91638473e-02f, 2.57506132e-01f, 6.84317052e-02f, 2.11499602e-01f, -2.39799440e-01f, 1.47645101e-01f,
  -3.37692387e-02f, 6.77985549e-02f, 6.38791472e-02f, -1.20375038e-03f, -2.19765261e-01f, 2.27569699e-01f, -1.07191078e-01f, 7.81043023e-02f, 2.24819053e-02f, 2.56279200e-01f,
  1.55407310e-01f, 1.03359312e-01f, -3.02571714e-01f, -1.24138286e-02f, 2.26536900e-01f, 1.68549642e-01f, -1.78320050e-01f, 7.21583515e-02f, 2.67439708e-02f, -9.69142374e-03f,
  -1.30366702e-02f, 3.21853846e-01f, 3.59657779e-02f, -4.56841029e-02f, -1.09021544e-01f, -1.86601326e-01f, -3.84659134e-02f, -6.52755126e-02f, 4.28488180e-02f, 5.15814088e-02f,
  2.18699679e-01f, 1.11009113e-01f, 6.13670163e-02f, -1.59932479e-01f, -1.26372099e-01f, -2.47453764e-01f, 1.68840468e-01f, 1.11947976e-01f, 8.68568346e-02f, -2.72413227e-03f,
  2.08973467e-01f, 2.74093002e-01f, 1.47125954e-02f, 1.94599122e-01f, -8.88787806e-02f, 3.44728902e-02f, 2.53361970e-01f, 1.21256210e-01f, 6.74299449e-02f, 2.15704720e-02f,
  -6.52525350e-02f, 9.62417722e-02f, -6.22251257e-02f, -7.29527771e-02f, 3.60143892e-02f, -3.48570913e-01f, 2.17276320e-01f, 1.44976571e-01f, 2.02476829e-01f, 1.20220907e-01f,
  -1.69355907e-02f, -2.15667456e-01f, -5.16128875e-02f, 5.04642501e-02f, 1.17129190e-02f, 1.99526697e-01f, -1.58096939e-01f, 9.85574909e-03f, -1.25948951e-01f, 1.59874514e-01f,
  -1.28302071e-02f, 3.52488644e-02f, 1.32377446e-01f, 3.99698652e-02f, 2.35573322e-01f, 1.45736188e-01f, 2.16941938e-01f, -9.15913060e-02f, 1.10897958e-01f, -7.17662945e-02f,
  -9.95217189e-02f, 7.75398612e-02f, -6.38430938e-02f, 2.36794129e-01f, -1.49288541e-02f, 1.01945661e-01f, 2.45303251e-02f, 1.26212418e-01f, 3.72777171e-02f, -2.54753698e-02f,
  8.94242898e-02f, -5.30496538e-02f, 7.46112391e-02f, -9.59442481e-02f, -2.40480989e-01f, -3.07640195e-01f, -5.16770743e-02f, 2.06684127e-01f, 1.48979574e-01f, -1.44813776e-01f,
  -5.93870245e-02f, 1.48069695e-01f, 3.01830590e-01f, 2.31504112e-01f, -1.59352988e-01f, -1.12328781e-02f, 2.53027737e-01f, 1.46359101e-01f, 1.83027178e-01f, 1.38894439e-01f,
  -6.14497773e-02f, -4.34125811e-02f, 4.99415807e-02f, -1.24350756e-01f, 3.29488933e-01f, -2.72186846e-03f, -5.68684898e-02f, 2.91616440e-01f, 1.14801722e-02f, 3.62119228e-01f,
  1.51200527e-02f, 1.51996151e-01f, -1.10776082e-01f, -2.89058313e-02f, -2.93359995e-01f, 2.75974840e-01f, 4.73694550e-03f, -1.39828995e-01f, 1.34983897e-01f, -4.21644226e-02f,
  1.25958016e-02f, 3.07054996e-01f, 7.04725459e-02f, -1.54671177e-01f, -1.07577041e-01f, 1.68839827e-01f, 2.01827604e-02f, -1.39638841e-01f, -7.98573419e-02f, -2.45102067e-02f,
  -1.45352170e-01f, -9.85363498e-02f, -4.92850207e-02f, -1.58672005e-01f, 5.37571087e-02f, 1.89316094e-01f, 1.29647329e-01f, -4.41609584e-02f, -1.30062941e-02f, 1.41145855e-01f,
  1.40043437e-01f, -1.23759732e-01f, -1.13538258e-01f, 3.31107974e-01f, 1.65790133e-02f, 4.72656898e-02f, 1.81304038e-01f, -2.43984267e-01f, 8.31189379e-03f, 1.58248976e-01f,
  5.40937809e-03f, -1.13858856e-01f, -2.73061365e-01f, 1.06085122e-01f, 1.25995666e-01f, 2.81299859e-01f, 2.18671098e-01f, -2.78852996e-03f, 9.84425545e-02f, 1.47833496e-01f,
  2.68035293e-01f, 1.49693072e-01f, -1.01625495e-01f, -3.92844900e-02f, -3.36028598e-02f, -2.12040856e-01f, 1.58355311e-01f, 2.13414058e-01f, 1.76256463e-01f, 1.36105239e-01f,
  -2.84712791e-01f, -1.53545737e-01f, 1.60107374e-01f, -1.54803678e-01f, 6.20291270e-02f, -1.71782300e-02f, 1.72970861e-01f, 1.32315442e-01f, -5.79408817e-02f, -1.02733821e-01f,
  -1.43294036e-01f, 1.26945570e-01f, -1.72259569e-01f, 1.91662177e-01f, 5.99595681e-02f, 2.59063765e-03f, -4.91673686e-02f, 1.25667483e-01f, 1.97139811e-02f, -6.36275485e-02f,
  -2.13979953e-03f, 2.52744332e-02f, -8.45245868e-02f, -1.83876768e-01f, 1.50199205e-01f, -2.05203131e-01f, 1.74612582e-01f, 1.07053638e-01f, -9.60979238e-02f, 1.42515779e-01f,
  -3.15894210e-03f, 1.70049682e-01f, 6.54954687e-02f, 2.50323325e-01f, 2.23381996e-01f, 2.32345834e-01f, 9.62205306e-02f, -3.73532437e-02f, 1.18887180e-03f, 1.04165308e-01f,
  2.37284943e-01f, -1.99945435e-01f, -6.40169159e-02f, 1.49881318e-01f, 7.68060386e-02f, -1.85673758e-01f, -4.59565632e-02f, -2.17192620e-01f, 2.17647940e-01f, 2.60435373e-01f,
  1.79459572e-01f, 2.00657263e-01f, 5.06720729e-02f, 2.40159124e-01f, 1.98589176e-01f, 4.97457683e-02f, 9.33861919e-03f, -1.54723406e-01f, -4.42133546e-02f, -1.95724759e-02f,
  -1.60348639e-01f, 2.03736067e-01f, 1.83254421e-01f, -1.04437806e-01f, 6.44662976e-02f, 1.73784018e-01f, 1.86610818e-01f, -2.67092884e-01f, 1.20403938e-01f, 1.44022768e-02f,
  2.09531069e-01f, 2.75321722e-01f, -3.63502130e-02f, 1.30320743e-01f, -2.14291215e-01f, 6.26110062e-02f, 4.89412025e-02f, 2.94754207e-01f, 1.00238964e-01f, 2.05564082e-01f,
  -1.83211192e-01f, 4.36290652e-02f, 1.30082190e-01f, 6.27205148e-02f, -5.94810257e-03f, 9.51346830e-02f, -5.92475981e-02f, -6.48674965e-02f, 5.45341708e-02f, -2.84961700e-01f,
  3.56349081e-01f, 1.52942371e-02f, -1.37375016e-02f, 1.21957041e-01f, 1.58227116e-01f, 1.28209427e-01f, 1.50934234e-01f, 8.39730278e-02f, 1.27248302e-01f, 9.38678812e-03f,
  1.57116026e-01f, -1.16084844e-01f, 3.75839556e-03f, 9.22453552e-02f, -2.17144907e-01f, 2.88234502e-02f, 1.71389878e-01f, -6.61688149e-02f, 2.05282286e-01f, 3.60544608e-03f,
  -5.69089912e-02f, -9.17962417e-02f, -8.34260806e-02f, 1.41524315e-01f, -9.59642529e-02f, -6.51940256e-02f, 1.87264141e-02f, -2.85316613e-02f, 1.23204820e-01f, 1.05637230e-01f,
  -1.24812685e-01f, -1.47925019e-01f, -9.95637700e-02f, 2.81471521e-01f, -5.90969995e-02f, -2.10541412e-01f, -2.06566930e-01f, 1.46522522e-01f, 2.23799981e-02f, -4.62350957e-02f,
  -1.09014377e-01f, 2.62149245e-01f, 1.04984187e-01f, 2.40734667e-01f, -1.26745924e-01f, 1.77391782e-01f, 7.15410560e-02f, 2.88093895e-01f, 1.70852929e-01f, 1.58534199e-01f,
  -1.69572204e-01f, -1.62203804e-01f, -2.44014800e-01f, 1.95500001e-01f, 2.97833011e-02f, -3.96419270e-03f, 6.72699139e-02f, 1.18720040e-01f, 1.28654003e-01f, -1.10895067e-01f,
  -2.79199351e-02f, -4.98410128e-02f, 1.76361755e-01f, -2.61109412e-01f, -1.17818154e-01f, 1.77471563e-01f, -6.05879026e-03f, 4.40088138e-02f, 2.74773426e-02f, -1.18947610e-01f,
  -1.94076210e-01f, -7.89800808e-02f, -6.31606951e-02f, -2.72978157e-01f, 1.04918927e-02f, 1.30814552e-01f, 1.95450962e-01f, -2.32915133e-01f, -8.93217549e-02f, -8.51414129e-02f,
  -7.39955828e-02f, -4.86629345e-02f, -1.15538798e-01f, 1.18532009e-01f, 1.93224654e-01f, -4.12964262e-02f, -1.29937008e-01f, -3.32977355e-01f, 1.54313967e-01f, 8.69280174e-02f,
  -1.49522439e-01f, -5.90465181e-02f, -4.89018112e-02f, 1.32254437e-01f, 2.72853702e-01f, 1.86531022e-01f, 5.97659200e-02f, -2.58166432e-01f, 1.47129148e-01f, 6.63087517e-02f,
  9.36751589e-02f, 7.50072896e-02f, 9.05416384e-02f, 1.59088045e-01f, -3.65886465e-02f, 1.62053153e-01f, -4.13385918e-03f, -1.39213994e-01f, -2.60449529e-01f, -1.77511841e-01f,
  -1.19654946e-01f, 2.04030517e-02f, 1.34423271e-01f, -1.10303592e-02f, 1.48717895e-01f, -1.28249377e-01f, 9.28476080e-02f, 1.37988031e-01f, 2.81395018e-01f, -1.38058066e-01f,
  1.40670054e-02f, -1.73974350e-01f, -1.16423070e-01f, 5.39060086e-02f, 2.04374969e-01f, 2.75642909e-02f, 1.57860488e-01f, 2.57769495e-01f, -1.27197608e-01f, 2.40643024e-02f,
  1.24692895e-01f, 1.06685482e-01f, 2.30749831e-01f, 8.59579593e-02f, 1.65515333e-01f, -1.30902128e-02f, -2.48377770e-02f, 4.35016230e-02f, 3.74638638e-03f, -1.79725632e-01f,
  1.26245692e-01f, -1.97730005e-01f, 8.62686187e-02f, 2.79219747e-01f, 1.33411614e-02f, 2.48554438e-01f, 2.50287503e-01f, -4.78344969e-02f, 1.22714676e-01f, -1.16971947e-01f,
  -2.39901215e-01f, -8.36634040e-02f, -8.38299543e-02f, 1.61871552e-01f, -6.39607534e-02f, 1.96303174e-01f, -1.82332307e-01f, -2.73283511e-01f, 1.03551276e-01f, 7.50956759e-02f,
  1.34788394e-01f, 3.66816372e-01f, -1.47267625e-01f, 1.28011569e-01f, -1.48278475e-02f, -1.29908994e-01f, 3.54308873e-01f, -1.83479860e-02f, -7.83792958e-02f, -1.51682884e-01f,
  -8.29629302e-02f, 6.97415620e-02f, -8.44296291e-02f, 1.38163954e-01f, 2.91425258e-01f, 6.05369769e-02f, 1.95307918e-02f, 6.51170537e-02f, -1.75423205e-01f, 1.28418714e-01f,
  8.40120390e-02f, -5.68411276e-02f, 1.28756657e-01f, 1.34922126e-02f, 1.57051682e-01f, -1.97208554e-01f, 1.74491525e-01f, -2.06838408e-03f, 6.03360683e-02f, 1.44498721e-01f,
  1.70523018e-01f, 2.21491694e-01f, 9.16937068e-02f, 2.59927809e-01f, 1.65821761e-02f, -7.98072219e-02f, -1.33980624e-02f, -1.27835810e-01f, -7.14936331e-02f, 6.01472743e-02f,
  -3.46899293e-02f, -1.22027591e-01f, -2.98694484e-02f, -2.03834742e-01f, -1.71604410e-01f, -2.84677655e-01f, -4.34750579e-02f, 1.26599833e-01f, 1.49817681e-02f, -2.30549037e-01f,
  2.93784112e-01f, 1.69988796e-01f, 1.44985303e-01f, 8.97919983e-02f, 1.91563904e-01f, 3.66973989e-02f, -1.02685690e-01f, 1.39998630e-01f, -1.00652650e-01f, -1.65869266e-01f,
  2.46231072e-02f, 1.03108115e-01f, 8.83201361e-02f, 1.52490169e-01f, 2.58324817e-02f, -1.27298813e-02f, 3.01690903e-02f, -3.46821807e-02f, 1.27860904e-02f, 1.76385134e-01f,
  1.31529763e-01f, 8.22446719e-02f, -7.61096552e-02f, -8.83055106e-02f, 1.79919392e-01f, 9.50909555e-02f, 2.92878211e-01f, 2.07970873e-01f, 1.46254659e-01f, -1.35690138e-01f,
  2.63067216e-01f, 2.91185617e-01f, 2.87781060e-01f, -6.02762289e-02f, -1.35070711e-01f, 1.00785745e-02f, -1.24787927e-01f, 2.71305323e-01f, -1.70893773e-01f, -6.62226155e-02f,
  1.74609169e-01f, -2.93121040e-02f, 2.00287789e-01f, 2.00977206e-01f, 4.75831702e-02f, 1.07746311e-01f, 1.30385503e-01f, -3.12373936e-01f, 2.44184434e-02f, 2.14491021e-02f,
  1.20508157e-01f, -1.99350417e-02f, -1.00982487e-02f, 1.48320898e-01f, -1.10437855e-01f, 1.03780538e-01f, -2.63988618e-02f, 8.74527469e-02f, 1.14585608e-01f, -2.34961644e-01f,
  1.54693782e-01f, -1.29103512e-01f, 1.69986919e-01f, -2.13322639e-01f, -4.72109504e-02f, -2.11739764e-01f, 1.64550040e-02f, 3.45188260e-01f, 8.12993646e-02f, -3.67673375e-02f,
  1.89486980e-01f, 9.32180658e-02f, 1.12550519e-01f, -1.42897934e-01f, -1.79613143e-01f, -3.81132439e-02f, 1.88458070e-01f, -5.38569577e-02f, 2.50277698e-01f, -1.65843621e-01f,
  -6.92391992e-02f, 2.14696616e-01f, 6.10266998e-02f, 1.36151463e-01f, 1.34611443e-01f, 1.79457560e-01f, -7.49823600e-02f, -5.41128255e-02f, -1.51531979e-01f, -9.42926016e-03f,
  -9.43595171e-02f, 1.55406684e-01f, 5.26948683e-02f, -2.21962601e-01f, 1.71132073e-01f, 2.35177830e-01f, 1.82381287e-01f, 1.24319315e-01f, 2.25921527e-01f, 1.82438865e-01f,
  -9.25777629e-02f, -1.07340276e-01f, 4.91324551e-02f, 2.13972479e-01f, -1.18878759e-01f, 1.28315255e-01f, 1.22822911e-01f, -7.28111044e-02f, 4.61676121e-02f, -1.54546544e-01f,
  -1.63184553e-01f, 3.06530803e-01f, 8.36822167e-02f, 1.94776103e-01f, 4.30242606e-02f, 6.84676915e-02f, 4.88287434e-02f, -9.10479203e-02f, 1.52630866e-01f, 5.47785610e-02f,
  1.34108350e-01f, -9.61351246e-02f, -1.62137166e-01f, -1.68663397e-01f, -1.88593313e-01f, -5.37044592e-02f, 2.77329087e-01f, -1.90102369e-01f, 1.64002836e-01f, -1.00602970e-01f,
  -7.63690323e-02f, 1.77959036e-02f, 1.57907531e-01f, 1.74133092e-01f, -1.64902896e-01f, -1.50758671e-02f, 1.37118235e-01f, -4.75415699e-02f, -4.18711454e-02f, 9.68559682e-02f,
  -1.04563637e-02f, -1.64821520e-01f, 4.06136326e-02f, -2.26134896e-01f, 5.10137491e-02f, -9.78657678e-02f, -1.66041553e-01f, 2.29215413e-01f, 1.06649682e-01f, -1.30640805e-01f,
  1.07737377e-01f, -5.73393814e-02f, -1.10353686e-01f, -5.61530776e-02f, 1.18098572e-01f, 1.92453116e-01f, 1.75328597e-01f, -1.65500015e-01f, 2.81081110e-01f, 2.39693493e-01f,
  1.59633514e-02f, -1.32196844e-01f, -5.11549860e-02f, -4.16921079e-02f, -1.47504350e-02f, 2.04085141e-01f, -1.03088982e-01f, 6.40510619e-02f, 6.92425594e-02f, 1.12796307e-01f,
  1.39022812e-01f, -1.18430905e-01f, -6.13050349e-02f, -5.58247278e-03f, -3.67684476e-02f, -3.56180444e-02f, 1.40221119e-02f, -1.07685484e-01f, 1.22567154e-01f, 1.89750031e-01f,
  2.34765988e-02f, 4.30346914e-02f, 1.22971341e-01f, 1.82363510e-01f, -2.68449664e-01f, 8.14487562e-02f, 1.65651098e-01f, -3.22101474e-01f, -4.93117934e-03f, -3.13194729e-02f,
  -1.11144476e-01f, -1.79624692e-01f, -4.30636778e-02f, -5.68212941e-03f, 1.34301513e-01f, -1.50952423e-02f, -5.20659834e-02f, -2.31649969e-02f, 8.71889442e-02f, 1.61069259e-02f,
  -4.46068589e-03f, -9.27205235e-02f, -5.49707301e-02f, -2.42642686e-01f, -3.02504320e-02f, -3.59087922e-02f, 5.33954576e-02f, -7.53962323e-02f, 1.33056909e-01f, 6.39979839e-02f,
  3.19436073e-01f, 4.54418734e-02f, 3.31561327e-01f, 3.70573044e-01f, 1.07705981e-01f, -2.40574494e-01f, -2.39688590e-01f, -1.33595467e-01f, 5.36988908e-03f, -8.13401341e-02f,
  -1.42898727e-02f, -7.79292658e-02f, 7.07302466e-02f, 2.37197895e-02f, 1.66422069e-01f, -3.68505791e-02f, 2.12902814e-01f, -2.94225980e-02f, 3.12035024e-01f, 1.02129929e-01f,
  7.51429126e-02f, 2.71252096e-02f, 1.58628851e-01f, -4.57669236e-02f, -2.97443300e-01f, 8.60831887e-02f, 1.82615370e-01f, -1.12363778e-01f, -2.57244945e-01f, -1.08625010e-01f,
  2.22921818e-01f, 2.76841342e-01f, 1.09851561e-01f, 4.30234484e-02f, 1.03348456e-01f, 9.89558920e-02f, -5.22988439e-02f, 6.72094524e-02f, -5.13555147e-02f, -4.48643155e-02f,
  -4.88712713e-02f, 9.86402854e-02f, 1.94140479e-01f, -3.94976838e-03f, 2.18693912e-01f, 2.57428944e-01f, 2.13718787e-01f, -1.30001426e-01f, -1.02669355e-02f, -1.78654000e-01f,
  4.18334380e-02f, 2.08601385e-01f, -2.01828167e-01f, -9.80328247e-02f, 5.11369221e-02f, 2.95839608e-01f, 6.72341287e-02f, 7.77443945e-02f, -6.23663813e-02f, 6.05532639e-02f,
  1.35347426e-01f, 2.33583167e-01f, 3.90111767e-02f, 2.17472032e-01f, -1.43360138e-01f, -1.66289687e-01f, -4.94451001e-02f, -2.46676251e-01f, 1.68710966e-02f, -1.64947927e-01f,
  4.79707196e-02f, 8.59136730e-02f, 1.37800649e-01f, 1.16096750e-01f, 3.23646031e-02f, -5.06253093e-02f, 1.65913641e-01f, -1.10656105e-01f, -1.82765409e-01f, 2.37466797e-01f,
  -9.87171903e-02f, -8.33614171e-02f, 2.13700905e-01f, 5.19484840e-02f, 4.69285846e-02f, -2.28727669e-01f, 1.32162236e-02f, 2.00348068e-02f, 1.01335615e-01f, 2.37808138e-01f,
  2.31705159e-01f, -4.19075927e-03f, 2.19006613e-01f, 7.23589584e-02f, -4.70922291e-02f, -1.83499888e-01f, -8.40918347e-02f, -6.38896897e-02f, 9.52483267e-02f, 7.61741325e-02f,
  -1.18511915e-02f, -1.47867319e-03f, 3.34812075e-01f, 1.43077999e-01f, -2.59792745e-01f, 1.95536658e-01f, 1.76997498e-01f, -7.02257752e-02f, 7.55429342e-02f, 2.63181120e-01f,
  -1.87812075e-01f, -8.55160430e-02f, 1.07249236e-02f, 2.66964674e-01f, 2.23459527e-01f, -1.39122931e-02f, -8.37878045e-03f, 3.55472296e-01f, 3.38499725e-01f, 2.23860934e-01f,
  2.44724497e-01f, 1.24628678e-01f, 9.30972844e-02f, -6.23911805e-02f, 1.57550931e-01f, 6.93752542e-02f, -2.45769218e-01f, 5.48258312e-02f, -8.46017245e-03f, 1.84017792e-02f,
  -2.26217002e-01f, -1.28086107e-02f, 6.59873858e-02f, 3.53447318e-01f, 1.70212150e-01f, -1.94992438e-01f, 5.00008203e-02f, 1.31329685e-01f, 1.55692235e-01f, 2.11371645e-01f,
  -6.31362945e-02f, 1.86305419e-01f, 5.14336228e-02f, 1.16750292e-01f, 9.77163464e-02f, 4.02109930e-03f, -2.07903743e-01f, 1.42060533e-01f, 1.60972059e-01f, 1.38446227e-01f,
  -1.95870772e-01f, 2.27649033e-01f, 2.49432206e-01f, 6.56827986e-02f, -1.87534958e-01f, 5.84982708e-03f, 1.28531486e-01f, 1.45121545e-01f, -1.52148888e-01f, -3.65628265e-02f,
  -5.81062473e-02f, -8.22089892e-03f, -1.43565342e-01f, -1.77768283e-02f, 8.21875036e-02f, -7.86133334e-02f, -1.10940099e-01f, -1.55346170e-01f, -1.75695151e-01f, -8.01105574e-02f,
  -1.62058100e-01f, -1.96623638e-01f, 2.51220316e-01f, -1.76696524e-01f, 1.98102608e-01f, -1.99919924e-01f, -1.51972592e-01f, -1.15998285e-02f, 7.59138837e-02f, 2.00388297e-01f,
  -1.39856130e-01f, -8.89447331e-02f, 7.11205080e-02f, 5.59524447e-02f, 6.04904406e-02f, 4.50523533e-02f, -9.90170240e-02f, -2.13896662e-01f, 7.96396062e-02f, -5.63970208e-02f,
  -1.06709125e-02f, -8.12005848e-02f, -2.61661232e-01f, 2.73182333e-01f, -1.01169318e-01f, -2.34975070e-01f, 9.44442675e-02f, -2.70948261e-01f, 1.81043297e-01f, 1.87895641e-01f,
  2.78273851e-01f, 2.73729980e-01f, 3.00348371e-01f, -1.86966747e-01f, 1.64479449e-01f, 2.65842587e-01f, -2.29137838e-01f, -1.03378728e-01f, 5.11701740e-02f, -5.44220731e-02f,
  -2.23969687e-02f, 3.06170821e-01f, -8.91840458e-02f, -2.44667269e-02f, 1.88097596e-01f, 1.43428668e-01f, 1.42025977e-01f, 5.56428023e-02f, 1.26707956e-01f, -9.87484902e-02f,
  1.11558847e-01f, -1.30779132e-01f, -1.17586367e-01f, -6.89885467e-02f, 1.85821448e-02f, 8.00094754e-02f, 1.50188968e-01f, 1.36384517e-01f, 2.10756645e-01f, -7.22053275e-02f,
  -1.71193406e-01f, -6.69894814e-02f, 4.59168255e-02f, -7.00893477e-02f, -1.52880669e-01f, -7.58705288e-02f, 4.08048220e-02f, -1.12264290e-01f, 5.35568129e-03f, 7.66268815e-04f,
  1.57692432e-02f, -1.31537870e-01f, 8.12541577e-04f, 2.04980046e-01f, 1.79689556e-01f, -1.31045893e-01f, 1.70395121e-01f, 6.78568631e-02f, -1.66010380e-01f, -2.99451724e-02f,
  -2.09929362e-01f, -1.76359624e-01f, -2.59015299e-02f, 1.85995355e-01f, 3.65560621e-01f, -4.22865823e-02f, -1.30916625e-01f, 2.57990897e-01f, 1.53391426e-02f, -1.01958260e-01f,
  4.09526601e-02f, -4.94090132e-02f, -1.66382357e-01f, 2.13040844e-01f, 3.07270028e-02f, 1.11241020e-01f, 2.73095556e-02f, -7.36321649e-03f, 2.83574849e-01f, 1.93356663e-01f,
  1.13422959e-03f, -1.50650635e-01f, -5.74473329e-02f, 1.57334786e-02f, -3.65282670e-02f, 1.79683059e-01f, 2.80290544e-02f, -9.26668048e-02f, 1.40915260e-01f, -1.70515150e-01f,
  8.73375013e-02f, 1.95878014e-01f, 1.88645750e-01f, -2.82535665e-02f, -3.28324318e-01f, 9.65907574e-02f, 1.43734306e-01f, 2.04236344e-01f, 1.35020688e-01f, 1.07428834e-01f,
  -1.25801906e-01f, -2.25975484e-01f, -3.61409746e-02f, -5.35606071e-02f, 2.21168086e-01f, -8.38905424e-02f, -7.75070116e-02f, -2.44185239e-01f, -3.08653805e-03f, 1.04581065e-01f,
  1.14706486e-01f, -4.12300885e-01f, 3.80540602e-02f, 6.77546933e-02f, 1.75879121e-01f, 2.05936894e-01f, 1.04079358e-01f, -9.90962163e-02f, -2.53917634e-01f, 3.06943476e-01f,
  1.93564311e-01f, -1.84654862e-01f, 1.46158308e-01f, 2.12771103e-01f, 1.25271469e-01f, 3.17542553e-01f, 1.13285765e-01f, -1.67919517e-01f, 6.22094162e-02f, -8.27152729e-02f,
  -1.56355709e-01f, 3.22030932e-01f, 5.75857945e-02f, 5.25820032e-02f, -3.61673832e-02f, 3.00102264e-01f, 9.00834333e-03f, 1.13336504e-01f, -1.34502828e-01f, 8.61216560e-02f,
  1.32460454e-02f, -1.41721489e-02f, 2.00293317e-01f, 1.16200730e-01f, 9.64389890e-02f, -2.03645006e-01f, -6.65788352e-02f, 6.96727186e-02f, -1.12872183e-01f, 1.14780739e-01f,
  1.61593240e-02f, 2.73723096e-01f, 1.96325079e-01f, -3.09347808e-01f, 2.95172006e-01f, 3.28526080e-01f, -2.03895077e-01f, 2.04929575e-01f, -2.36985788e-01f, 4.69153598e-02f,
  1.80937096e-01f, -2.10952535e-02f, -6.45687664e-03f, 6.97792172e-02f, -7.81648755e-02f, -6.86024651e-02f, -7.56174177e-02f, -1.77156925e-01f, 1.62715927e-01f, -8.33558366e-02f,
  7.02489540e-02f, -1.30690873e-01f, 2.26397797e-01f, 1.48109466e-01f, -3.12634297e-02f, 2.32033029e-01f, 3.23946476e-02f, 9.11954120e-02f, 7.34654441e-02f, -9.62928161e-02f,
  -2.18419150e-01f, -2.23161995e-01f, 1.47707596e-01f, 3.83487456e-02f, -5.97910173e-02f, 4.73337956e-02f, -3.02949578e-01f, -2.77943611e-01f, 6.38061464e-02f, 2.36631967e-02f,
  9.91606191e-02f, 1.35224879e-01f, -5.20406216e-02f, 2.52254218e-01f, -1.07205892e-02f, -4.21322048e-01f, 1.70631140e-01f, -1.23615554e-02f, -6.81511015e-02f, -2.68384814e-01f,
  -4.94066812e-03f, -1.20850965e-01f, -1.80717334e-01f, -2.94833165e-02f, 1.46517664e-01f, 6.48904815e-02f, -1.55365884e-01f, -3.90473232e-02f, -2.27788407e-02f, 1.76732093e-01f,
  2.14486912e-01f, -1.55631959e-01f, 2.08038002e-01f, -1.25302747e-01f, 1.42741665e-01f, -2.96055019e-01f, 1.40919015e-01f, 3.71724777e-02f, -1.07801497e-01f, 1.95166454e-01f,
  6.06784187e-02f, 8.65578875e-02f, -7.61164799e-02f, 1.12117760e-01f, 1.84103116e-01f, 5.65984137e-02f, 4.06806655e-02f, 1.51023373e-01f, 1.82624713e-01f, 1.54777333e-01f,
  3.75724398e-02f, 4.89240773e-02f, 5.23493253e-02f, 1.01902597e-01f, 2.03574777e-01f, 2.69448534e-02f, 2.50231296e-01f, -1.05963327e-01f, -1.75739661e-01f, -1.01244994e-01f,
  1.28812686e-01f, 1.30964220e-01f, 1.05095826e-01f, -1.94953587e-02f, 6.88131303e-02f, 1.53475583e-01f, -8.55392870e-03f, 2.07145363e-01f, -2.07626402e-01f, 4.14168462e-02f,
  1.89711660e-01f, 1.10797189e-01f, 5.35645448e-02f, 7.78779760e-02f, -2.80782819e-01f, 1.33121423e-02f, -9.39630792e-02f, 5.78309000e-02f, 2.21972659e-01f, -7.36409856e-04f,
  3.64266075e-02f, 3.50403413e-02f, 8.19134712e-02f, 1.95222899e-01f, 3.11045647e-02f, 6.58146366e-02f, 7.04408512e-02f, -1.26665449e-02f, 5.60618155e-02f, 6.57887384e-02f,
  -8.93059075e-02f, 1.31375194e-02f, 8.09313804e-02f, -4.80512716e-02f, -1.11525707e-01f, 1.69039220e-01f, -1.53694004e-01f, -4.90768999e-02f, -1.57497928e-01f, 2.96568930e-01f,
  1.33837983e-01f, -3.01599860e-01f, -2.50459164e-01f, 1.91995561e-01f, 9.78683829e-02f, -5.63260913e-02f, -2.19474167e-01f, -1.80456281e-01f, 1.34818852e-01f, 1.05721146e-01f,
  1.19318236e-02f, -1.21297732e-01f, 1.79158852e-01f, -1.46152511e-01f, -5.48913032e-02f, 4.14741971e-02f, 2.00865492e-01f, -1.11464955e-01f, 4.23257835e-02f, 4.94747795e-02f,
  -3.85025255e-02f, 2.77393192e-01f, 1.49221271e-01f, -1.13646708e-01f, 2.06983984e-01f, 1.09160498e-01f, 6.10052347e-02f, -1.10863850e-01f, -2.90281385e-01f, -8.88929665e-02f,
  -2.71781981e-01f, 9.56813544e-02f, -1.45344704e-01f, -9.47840419e-03f, 1.96438804e-01f, 2.51899481e-01f, 2.78657019e-01f, 1.94219813e-01f, 1.50030419e-01f, 1.65858150e-01f,
  -1.48553271e-02f, -1.77876905e-01f, -2.25603819e-01f, 6.91595534e-03f, 2.16915131e-01f, 1.16370611e-01f, -1.88508332e-01f, 1.75170317e-01f, 1.61041006e-01f, 2.56842058e-02f,
  -1.71544895e-01f, -1.11119092e-01f, 1.12031087e-01f, 2.19499543e-01f, 1.81884885e-01f, -1.96155027e-01f, 2.50405282e-01f, -3.84103172e-02f, -2.81051725e-01f, 7.42452964e-02f,
  2.20085248e-01f, 6.61835372e-02f, 8.79858285e-02f, 4.90962937e-02f, 2.24620625e-01f, -1.78639278e-01f, 1.52507231e-01f, 4.71742526e-02f, 1.94200173e-01f, 3.25613648e-01f,
  -1.40830442e-01f, -2.37069413e-01f, 6.65538013e-02f, 4.97659035e-02f, 9.09614190e-02f, 2.29485363e-01f, 1.07436545e-01f, 1.85154766e-01f, 1.11347474e-01f, 5.97002879e-02f,
  -3.07563730e-02f, 3.23210746e-01f, -4.91479896e-02f, 4.74019758e-02f, -4.62956131e-02f, -2.03404099e-01f, 2.21932322e-01f, -2.05582276e-01f, -1.72478743e-02f, 7.86763206e-02f,
  -1.04501851e-01f, 1.16061427e-01f, 1.44511461e-01f, 3.02531391e-01f, 2.04783410e-01f, 9.64761339e-03f, -2.28870548e-02f, 5.18028624e-02f, 1.68052465e-01f, -5.61427213e-02f,
  -7.21868351e-02f, -2.09201947e-01f, 5.17768450e-02f, -9.85728055e-02f, 1.94370911e-01f, -1.16275020e-01f, 2.39008591e-01f, 3.94449890e-01f, -2.17101783e-01f, 9.21258107e-02f,
  2.94498086e-01f, 1.18076921e-01f, -9.51948836e-02f, 2.89309621e-01f, -9.10437573e-03f, 7.85872042e-02f, 1.09815551e-03f, 1.09284043e-01f, 2.31609255e-01f, 3.42429727e-01f,
  -4.11007740e-02f, -4.16639121e-03f, 1.22811414e-01f, 1.48632854e-01f, 1.28095672e-01f, 1.08912751e-01f, 7.21593499e-02f, 1.24032721e-01f, 2.19123989e-01f, -3.73123437e-01f,
  -4.89705838e-02f, -4.99402098e-02f, 1.39674634e-01f, -2.76941299e-01f, -1.97922781e-01f, 1.09511986e-01f, 2.51562804e-01f, 3.67356986e-01f, 1.71661898e-01f, 2.43717358e-02f,
  3.97106297e-02f, -4.61704619e-02f, 1.44169718e-01f, 2.74962932e-02f, 1.00413308e-01f, -1.59727499e-01f, 7.98021182e-02f, 1.18674962e-02f, 7.24743828e-02f, 8.47700983e-02f,
  -2.08379418e-01f, -2.00288311e-01f, 2.74038821e-01f, 1.32619753e-01f, 2.57905811e-01f, -1.33932069e-01f, 3.60168964e-02f, 2.59119105e-02f, -2.35498607e-01f, 2.50305504e-01f,
  -2.40807250e-01f, -4.48067226e-02f, 1.91634342e-01f, 1.06131643e-01f, 6.87760785e-02f, 1.10356897e-01f, -1.82666197e-01f, -3.99196520e-03f, -3.16239864e-01f, -1.38077766e-01f,
  -1.34547248e-01f, -1.34259179e-01f, 2.39410371e-01f, 1.64404601e-01f, 1.28119648e-01f, 2.19162896e-01f, 2.05153629e-01f, 2.68506259e-01f, -3.23430784e-02f, 2.05411781e-02f,
  6.80564046e-02f, 2.45504737e-01f, 1.39931858e-01f, -1.63603917e-01f, 1.20939240e-01f, 6.29966259e-02f, -2.66571909e-01f, 2.55155176e-01f, -1.98601812e-01f, 1.17965564e-01f,
  -1.59908399e-01f, 3.13933045e-01f, 1.27507299e-01f, -2.78135091e-01f, -1.25490069e-01f, 1.80745810e-01f, 4.99725416e-02f, 2.33105838e-01f, -1.94090366e-01f, -2.55662739e-01f,
  1.86284319e-01f, 1.96382567e-01f, 1.48063675e-01f, 3.40363905e-02f, -9.00031477e-02f, -1.21043898e-01f, 5.63242510e-02f, -5.36895506e-02f, 1.02302181e-02f, 7.38266259e-02f,
  1.54461652e-01f, -7.92507976e-02f, 9.78100970e-02f, 1.05799429e-01f, 3.62959364e-03f, 1.33282125e-01f, 1.67142138e-01f, 6.56088740e-02f, 7.11168274e-02f, -1.56997144e-01f,
  -2.19674319e-01f, -1.73203453e-01f, 7.01021776e-02f, -1.17795743e-01f, -2.22117379e-01f, 1.69230297e-01f, -2.11202145e-01f, -3.91130894e-02f, 5.94318621e-02f, 1.64889097e-01f,
  -1.25203505e-01f, 1.18869424e-01f, 2.45257542e-01f, 1.91096351e-01f, 1.39012754e-01f, -7.30676055e-02f, 2.41926014e-01f, -1.34835271e-02f, -1.62095930e-02f, -9.49428380e-02f,
  -1.29262596e-01f, -3.24908993e-03f, -1.36497244e-01f, -5.13215102e-02f, 3.08209181e-01f, -1.59237236e-01f, 2.21352026e-01f, -1.19766399e-01f, 2.85291648e-03f, -1.14220092e-02f,
  2.30100881e-02f, 8.40273798e-02f, 2.17377275e-01f, 4.87474985e-02f, 1.68075815e-01f, -2.49699175e-01f, 4.84534949e-02f, -7.79154301e-02f, 2.21559908e-02f, 1.11513957e-01f,
  2.79301316e-01f, 4.29714397e-02f, -2.47051358e-01f, 5.84635558e-03f, 1.62658527e-01f, -1.32121975e-02f, 8.42342973e-02f, 1.53017804e-01f, 1.03989787e-01f, 5.33192828e-02f,
  1.15932472e-01f, 1.24396585e-01f, 4.84982207e-02f, 2.12305084e-01f, 1.11585535e-01f, 8.03082511e-02f, 9.33394358e-02f, -1.98309466e-01f, -2.17405885e-01f, 9.36303213e-02f,
  2.87727732e-02f, 1.53614983e-01f, 6.35212958e-02f, -7.93159381e-02f, 1.59206226e-01f, 6.41398057e-02f, 3.03567231e-01f, 2.37262294e-01f, 1.29667744e-01f, 9.27091986e-02f,
  1.56861782e-01f, 2.19262876e-02f, -2.20112931e-02f, -2.83965617e-01f, -6.97853863e-02f, -2.84864366e-01f, 1.92264449e-02f, 3.11683446e-01f, 4.03021753e-01f, -2.19818830e-01f,
  -1.92884490e-01f, 2.73374170e-01f, 2.47074738e-01f, 6.01398833e-02f, 2.10643858e-01f, -2.72660633e-03f, 2.00950801e-01f, 2.71685421e-02f, 6.96990564e-02f, 2.62789726e-01f,
  -2.86772341e-01f, -1.27458724e-03f, -9.74712744e-02f, 2.48480290e-01f, 1.84509471e-01f, 1.63426787e-01f, 5.12673985e-03f, -1.00648656e-01f, 8.60072747e-02f, 2.72476554e-01f,
  -1.46139497e-02f, -1.33385271e-01f, -9.81528088e-02f, -1.88159004e-01f, 1.86043531e-01f, -1.74938485e-01f, 1.82414036e-02f, 1.15703486e-01f, 1.21215343e-01f, 1.92407981e-01f,
  -1.00868447e-02f, 1.72206551e-01f, 1.98506996e-01f, 2.41817057e-01f, 4.47490104e-02f, 1.02355089e-02f, -1.58155560e-01f, -6.47968203e-02f, 6.94351345e-02f, 1.11882858e-01f,
  -6.04813509e-02f, -8.17329288e-02f, 2.69035082e-02f, -1.97523206e-01f, 2.78548244e-02f, 2.07255110e-01f, 1.37888551e-01f, -2.03082383e-01f, 7.66689777e-02f, 1.76582232e-01f,
  6.38576271e-03f, 1.76320791e-01f, -1.20068833e-01f, 7.54733160e-02f, 1.89315483e-01f, 1.43328056e-01f, 2.21303608e-02f, 1.73836946e-01f, -2.56520599e-01f, 9.02865455e-02f,
  1.51577085e-01f, -1.90183401e-01f, 1.30915851e-05f, 2.42194042e-01f, -5.26309051e-02f, 1.16912037e-01f, 1.04694232e-01f, 5.54974005e-02f, 1.10538110e-01f, 3.11204046e-01f,
  1.80994719e-01f, 1.26522249e-02f, -1.25836357e-01f, -2.44488306e-02f, 1.33357778e-01f, 8.37832540e-02f, 1.50996298e-01f, -5.60320765e-02f, -1.99957147e-01f, 2.33247578e-01f,
  -8.62523466e-02f, 1.07655115e-01f, -5.82485273e-02f, 1.70710146e-01f, 2.29454532e-01f, -3.16876978e-01f, -7.25524575e-02f, 8.60945955e-02f, 1.91112101e-01f, -8.09547007e-02f,
  -7.03593418e-02f, -2.18319923e-01f, 6.91634566e-02f, 2.65024722e-01f, -3.69868055e-02f, -1.48251764e-02f, 1.16206907e-01f, 1.97813749e-01f, 6.99442402e-02f, 1.83600634e-01f,
  -3.46506953e-01f, 5.19620888e-02f, 7.21454918e-02f, -4.87942733e-02f, -1.30183576e-02f, -2.66370147e-01f, 5.16972505e-02f, -2.37461880e-01f, 2.12992489e-01f, 3.15529890e-02f,
  -7.30084479e-02f, -3.08413625e-01f, 1.56220406e-01f, 1.26452997e-01f, 2.26486936e-01f, -1.93395153e-01f, 4.13907021e-02f, 2.39481419e-01f, 1.74744278e-02f, 1.97769310e-02f,
  -1.15028881e-01f, 1.45011218e-02f, -2.18588829e-01f, 6.67487755e-02f, 2.65162051e-01f, -2.41823509e-01f, 8.39056671e-02f, 9.62375998e-02f, -2.21272543e-01f, 1.21089950e-01f,
  2.60385036e-01f, -2.25363031e-01f, 4.15687263e-02f, 2.00375706e-01f, 1.77601114e-01f, 9.71724540e-02f, 2.48335432e-02f, -1.29495412e-01f, 3.16500604e-01f, 1.79755520e-02f,
  -1.95366308e-01f, 7.96448514e-02f, 7.80882826e-03f, 1.02986544e-01f, 1.56119158e-02f, 2.58345395e-01f, -9.58621576e-02f, -1.51829449e-02f, 2.07765073e-01f, -1.38888285e-01f,
  -2.71784157e-01f, 4.12391536e-02f, 3.26990962e-01f, -2.09281921e-01f, 7.75377499e-03f, -2.70088524e-01f, 1.13101006e-01f, 1.72571108e-01f, 1.00370951e-01f, 5.27720079e-02f,
  5.34892119e-02f, 1.84463244e-02f, 1.98231824e-02f, 8.73514339e-02f, -2.04337716e-01f, -5.47681656e-03f, 7.97890723e-02f, -2.23757550e-01f, 3.05038989e-01f, 1.61539882e-01f,
  8.63843709e-02f, 8.63003731e-02f, 1.41401649e-01f, 2.00285628e-01f, -1.19072413e-02f, 1.12778611e-01f, 1.48739427e-01f, -5.88417016e-02f, 1.40454367e-01f, 1.66719645e-01f,
  1.17678128e-01f, 3.08066100e-01f, -1.32430926e-01f, -9.74019244e-02f, 2.28232697e-01f, 2.62669116e-01f, 1.13944896e-01f, 2.77059019e-01f, 6.09579273e-02f, 2.73758978e-01f,
  2.61043876e-01f, 1.93939507e-01f, 1.32098109e-01f, 4.87346128e-02f, 1.10448003e-01f, -2.58140355e-01f, -6.80179372e-02f, -1.32432967e-01f, 8.29325616e-02f, -1.86930690e-02f,
  1.54368937e-01f, -9.96701121e-02f, -6.38128892e-02f, 1.32736012e-01f, -4.74199913e-02f, 7.45503902e-02f, -4.63713296e-02f, 2.30325516e-02f, 1.37313366e-01f, -4.09702584e-02f,
  3.07167292e-01f, -9.88666266e-02f, 2.16314897e-01f, -3.41625541e-01f, 6.61201477e-02f, 2.94729531e-01f, 2.74594754e-01f, 2.24117056e-01f, -1.10750958e-01f, 7.02195838e-02f,
  1.45442843e-01f, 1.16423823e-01f, -1.96604785e-02f, 4.33642790e-02f, -9.66884121e-02f, -3.37356515e-02f, 4.05911654e-02f, 5.24468087e-02f, 4.99706268e-02f, 2.64610738e-01f,
  2.17694327e-01f, 2.14153319e-03f, 1.10252805e-01f, -1.95824146e-01f, -1.39900029e-01f, -1.32932186e-01f, -2.43922144e-01f, 2.11309597e-01f, 1.28346533e-01f, -3.83398719e-02f,
  2.44390965e-02f, 8.72529075e-02f, 2.83826381e-01f, -4.90374863e-02f, -1.94789365e-01f, 1.65473506e-01f, 1.96519464e-01f, 1.02919728e-01f, 2.00618863e-01f, -1.71820328e-01f,
  2.82470994e-02f, -1.93871498e-01f, 2.67289579e-01f, 1.90380126e-01f, 2.20745176e-01f, 1.30370948e-02f, 6.55229688e-02f, 3.13775726e-02f, 1.57121986e-01f, 3.16583216e-01f,
  -1.28843278e-01f, 7.34946132e-02f, -2.25246802e-01f, -1.50917843e-02f, -1.30797392e-02f, 1.97106510e-01f, -5.95027171e-02f, -1.65308863e-01f, 1.64498329e-01f, 2.63880212e-02f,
  1.41781852e-01f, 1.49327993e-01f, 2.78004110e-01f, -7.21420199e-02f, 1.23831704e-01f, -5.67337200e-02f, 4.10773084e-02f, -1.26882315e-01f, -1.95713371e-01f, -7.34396651e-02f,
  1.96140513e-01f, -1.66558102e-01f, -9.68317315e-02f, 1.80430308e-01f, -3.15977447e-02f, 1.68569088e-01f, -7.04072192e-02f, 1.18883431e-01f, 1.06251063e-02f, 6.21655472e-02f,
  -2.69064438e-02f, -3.90847437e-02f, 1.73643246e-01f, -2.30739668e-01f, -2.02115536e-01f, 5.16314805e-03f, -5.92116490e-02f, 1.38563320e-01f, 1.26824945e-01f, 1.66263372e-01f,
  2.95143813e-01f, -1.02312885e-01f, 5.69869988e-02f, -9.67315510e-02f, 2.04478666e-01f, -1.96042620e-02f, -1.81282878e-01f, -6.21836558e-02f, 1.58422902e-01f, 8.86048824e-02f,
  -2.60937452e-01f, -5.74699491e-02f, -1.91264212e-01f, -1.56562608e-02f, 1.63812503e-01f, 2.13306874e-01f, 1.89474255e-01f, -1.85160100e-01f, -2.24576741e-01f, 1.92774206e-01f,
  1.29770756e-01f, -1.30465001e-01f, -7.81123564e-02f, -9.92538780e-02f, -1.36532217e-01f, -1.23265147e-01f, -1.82961691e-02f, 2.21637785e-01f, 8.84148031e-02f, 1.03872128e-01f,
  2.82307208e-01f, 2.35530853e-01f, -1.17186472e-01f, -8.53046998e-02f, -1.68171242e-01f, -1.05167173e-01f, 1.89803302e-01f, 6.86465204e-02f, 3.61208841e-02f, -3.74945179e-02f,
  -4.54695746e-02f, 3.87697220e-02f, 2.05416426e-01f, 2.07439169e-01f, -2.13054325e-02f, 1.06864609e-01f, 8.74641985e-02f, 4.34480980e-02f, -8.84600058e-02f, -9.76306051e-02f,
  -1.20519344e-02f, -1.26868293e-01f, -2.61699092e-02f, -1.14182614e-01f, 1.25195548e-01f, 1.13444090e-01f, 2.75538743e-01f, -1.90220580e-01f, 3.66878733e-02f, -2.04394221e-01f,
  1.20936580e-01f, 1.13675475e-01f, -2.29730129e-01f, -5.44044934e-02f, 1.17087729e-01f, 1.47566661e-01f, 2.33904421e-01f, 2.76668314e-02f, -2.26459488e-01f, 7.89419003e-03f,
  -8.07091743e-02f, 3.38354379e-01f, -3.14607233e-01f, -1.43308833e-01f, 1.12929799e-01f, 1.52153105e-01f, 2.53758609e-01f, 3.39443415e-01f, 3.56222875e-02f, -1.54755861e-02f,
  -3.77842456e-01f, 1.40305161e-01f, -1.58907324e-02f, -2.80721486e-01f, 2.19372243e-01f, 2.90541034e-02f, -1.41583338e-01f, 1.48947716e-01f, 2.54382044e-01f, 1.09577410e-01f,
  -1.22214630e-01f, -1.56132370e-01f, 1.12855677e-02f, 1.13306224e-01f, -4.93171513e-02f, -1.50842533e-01f, 3.30425888e-01f, 3.58962491e-02f, -2.40968809e-01f, 2.43234530e-01f,
  -7.96606764e-02f, -5.06479805e-03f, 4.23828438e-02f, 6.02037162e-02f, 3.93811837e-02f, -6.63313828e-03f, -5.62267937e-03f, 9.28009674e-02f, -2.74742488e-02f, 2.61804819e-01f,
  -2.59598970e-01f, -1.94983795e-01f, 2.58935034e-01f, 1.91967171e-02f, 1.72412023e-02f, 5.17297871e-02f, 2.13507786e-01f, -1.67886131e-02f, 1.65956631e-01f, 1.48868840e-02f,
  -2.15666831e-01f, 1.65512353e-01f, -7.13826045e-02f, 9.07425657e-02f, -2.93398071e-02f, -7.05759376e-02f, 1.25847042e-01f, -2.74789453e-01f, 1.87049627e-01f, 1.16205171e-01f,
  1.57409057e-01f, -1.83198288e-01f, -1.48860276e-01f, 1.52437106e-01f, 1.17114164e-01f, -8.48019049e-02f, -1.70480296e-01f, 1.32805362e-01f, 1.10417463e-01f, 1.95570812e-01f,
  1.01957425e-01f, 2.31051058e-01f, -2.60502815e-01f, 5.05635962e-02f, 2.81123370e-01f, -2.08700448e-01f, -7.26463124e-02f, 2.98878461e-01f, -5.04580066e-02f, 8.10820758e-02f,
  2.37186462e-01f, 1.14744723e-01f, -2.17306856e-02f, 3.23836654e-01f, -5.23087308e-02f, -1.00444674e-01f, 5.71252145e-02f, 1.51034445e-01f, 3.09733450e-01f, 1.64644480e-01f,
  5.55639621e-03f, -3.48683074e-02f, -4.97160181e-02f, 9.64798182e-02f, 2.05285415e-01f, 3.69900241e-02f, 4.08795774e-02f, 1.30870119e-01f, 2.71724343e-01f, -3.98620635e-01f,
  -2.05761418e-01f, 1.92214981e-01f, 1.93596885e-01f, 8.32664669e-02f, -3.13578695e-01f, -1.14020459e-01f, 2.75068283e-01f, 2.12848008e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  9.53283235e-02f, 1.91097513e-01f, 8.26465562e-02f, 1.27637461e-01f, -8.37690085e-02f, -3.87241307e-04f, -4.68816943e-02f, -1.67723689e-02f, 7.66530111e-02f, 1.93450674e-02f,
  -2.83419085e-03f, 1.11587182e-01f, -1.46887181e-02f, 1.38586517e-02f, 1.48536623e-01f, 1.36522412e-01f, 1.06323719e-01f, 7.42830634e-02f, -3.48549113e-02f, -8.28310177e-02f,
  1.41354889e-01f, 1.03330322e-01f, 1.82901248e-01f, 1.44501224e-01f, 9.31906924e-02f, 2.28707388e-01f, 7.72679830e-03f, 8.30018297e-02f, -2.66321450e-02f, -5.57303689e-02f,
  6.59165829e-02f, -9.23351645e-02f, 1.55430064e-01f, 2.03485236e-01f, 1.80867493e-01f, 1.57605857e-01f, 5.70131354e-02f, 1.51629010e-02f, 1.47648439e-01f, 3.64433601e-02f,
  8.22667480e-02f, 1.73347697e-01f, 1.22124694e-01f, 1.77985996e-01f, 6.34709969e-02f, -2.90320553e-02f, 9.15582851e-02f, 2.06605762e-01f, -4.42444533e-02f, 5.26374988e-02f,
  1.50313199e-01f, 1.02382585e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  1.10959269e-01f, -1.78225607e-01f, -9.05611925e-03f, -4.14864086e-02f, -1.54492140e-01f, 1.24466913e-02f, 5.29554449e-02f, 5.48346266e-02f, -1.72642440e-01f, 2.42140964e-01f,
  -2.25300286e-02f, -1.73152015e-01f, 1.17685132e-01f, -6.18714094e-02f, -2.25151852e-01f, 2.11722150e-01f, -6.37112409e-02f, -3.83264303e-01f, -2.64209926e-01f, -1.20531052e-01f,
  1.45493537e-01f, 8.19253623e-02f, 5.22230715e-02f, -2.89753936e-02f, -5.60856722e-02f, 2.04236627e-01f, 8.87862816e-02f, -1.25966206e-01f, -2.64463760e-02f, -1.84913054e-01f,
  2.70191550e-01f, 4.10657655e-03f, 1.99588582e-01f, -2.63807625e-01f, -4.76395190e-01f, -6.76542567e-03f, -7.45488629e-02f, -1.44713360e-03f, -1.36541635e-01f, 2.87483722e-01f,
  3.47719379e-02f, -2.73187220e-01f, 2.38939956e-01f, -2.04981297e-01f, 1.50695816e-01f, -1.28825426e-01f, -8.07830840e-02f, -2.06671715e-01f, -3.25124890e-01f, -2.76228786e-01f,
  2.13645011e-01f, -7.88132995e-02f, -2.89974362e-01f, -9.70767215e-02f, -1.82405904e-01f, 2.08367541e-01f, 9.99200493e-02f, -2.62571633e-01f, -1.80011541e-01f, 6.08542794e-03f,
  2.28647590e-01f, -3.92586663e-02f, -1.09810375e-01f, -1.44632101e-01f, 1.94045098e-03f, 6.57459837e-04f, 7.91955888e-02f, 9.15476158e-02f, 2.19635125e-02f, 1.30721211e-01f,
  -4.73411344e-02f, 1.86322853e-01f, 2.46313289e-01f, 2.32299864e-01f, -2.17162296e-02f, -2.45803684e-01f, -2.22274482e-01f, 1.52236760e-01f, -1.13404118e-01f, 1.34960607e-01f,
  -2.40258023e-01f, 1.91833675e-02f, -3.76531512e-01f, 2.40917429e-01f, -2.58481413e-01f, 1.33992344e-01f, -2.30696216e-01f, 7.76340365e-02f, -3.17276031e-01f, 1.84506804e-01f,
  1.20476872e-01f, -2.29703054e-01f, 2.58548297e-02f, -2.43452951e-01f, 5.94608523e-02f, -1.85207754e-01f, 1.40389442e-01f, 9.67678055e-02f, -5.46143688e-02f, -2.74424165e-01f,
  2.85129189e-01f, 1.37273535e-01f, -2.16443345e-01f, -2.61741638e-01f, -1.67084939e-03f, -6.84194937e-02f, 1.24142624e-01f, -2.12307096e-01f, -1.30828112e-01f, 7.73555860e-02f,
  2.05197662e-01f, -1.08597018e-01f, -2.81417727e-01f, 7.06416517e-02f, -9.98545736e-02f, -1.02664001e-01f, -1.35977715e-01f, 8.79902765e-02f, -2.34109312e-01f, -3.34692627e-01f,
  2.07918018e-01f, -2.12224916e-01f, -1.44152984e-01f, 1.73097432e-01f, -7.09097162e-02f, -1.94706589e-01f, -1.68515503e-01f, -3.02765936e-01f, -1.36500210e-01f, -7.88906068e-02f,
  3.91536532e-03f, -5.70393503e-02f, -1.65313289e-01f, -1.52223468e-01f, 6.10832777e-03f, 2.54186876e-02f, 1.01558700e-01f, -9.77307633e-02f, -1.50471777e-01f, 9.56275538e-02f,
  3.27057429e-02f, -8.72206241e-02f, -1.07059278e-01f, -2.45846454e-02f, 3.59653160e-02f, 2.15787575e-01f, -3.47505696e-02f, 6.67434186e-03f, -2.18293592e-01f, 2.55267441e-01f,
  -4.58729416e-02f, -1.92127690e-01f, -4.19762824e-03f, 9.65243652e-02f, 1.11883819e-01f, -1.56389996e-01f, -2.06645995e-01f, 1.76940352e-01f, -2.40228355e-01f, 2.50300199e-01f,
  -2.02431262e-01f, 2.64203310e-01f, 1.77445918e-01f, -1.67616740e-01f, 9.01951417e-02f, 1.99426174e-01f, -1.88107103e-01f, -9.87533927e-02f, -2.18420804e-01f, 1.75498232e-01f,
  -3.52209449e-01f, 8.40343684e-02f, -1.53103441e-01f, 1.16334707e-01f, 1.04430050e-01f, 1.97415054e-01f, -3.23082358e-01f, -3.19832921e-01f, -1.87187985e-01f, -1.74353436e-01f,
  -2.00668007e-01f, -2.06233740e-01f, -1.63233012e-01f, 4.25102338e-02f, 7.69191980e-02f, -1.65198311e-01f, 5.28920768e-03f, -3.13014686e-01f, -2.94701964e-01f, 7.85458311e-02f,
  -7.29158819e-02f, -3.45218152e-01f, 5.92981502e-02f, 8.99546891e-02f, -1.46922216e-01f, -3.31982672e-02f, -5.96380979e-02f, -5.02407402e-02f, 2.17936039e-01f, 4.01540659e-02f,
  -1.54413089e-01f, -1.11723602e-01f, -3.44173680e-03f, -2.00293988e-01f, 1.13598734e-01f, 4.60098423e-02f, -4.40483354e-02f, -3.82736385e-01f, 2.29581237e-01f, -1.01390690e-01f,
  -4.53842282e-02f, -1.58857033e-01f, 1.58079818e-01f, -3.29126209e-01f, 1.30527109e-01f, -1.84300855e-01f, -1.89879507e-01f, -1.14982836e-01f, 3.13800573e-02f, -8.70240331e-02f,
  -7.24000409e-02f, -5.52777797e-02f, -6.71342313e-02f, -2.86842342e-02f, -1.66225031e-01f, -2.29322523e-01f, -2.49049857e-01f, -1.74027950e-01f, 1.36702834e-02f, -3.89125288e-01f,
  -2.91651674e-02f, 3.92756164e-02f, 2.33145937e-01f, 1.05279140e-01f, -2.70899057e-01f, -1.13763154e-01f, 6.25674846e-03f, 8.24455097e-02f, -3.08389157e-01f, -1.84958443e-01f,
  -4.62124683e-02f, 7.13352393e-03f, 2.13854283e-01f, 8.29572454e-02f, 2.30656311e-01f, -4.68545079e-01f, 1.17454715e-01f, 2.84456670e-01f, -2.95354635e-01f, -7.35624060e-02f,
  -2.06354886e-01f, 2.25675002e-01f, -6.19309954e-02f, -6.36928231e-02f, 2.07443625e-01f, 1.29735887e-01f, 1.92203112e-02f, 2.57312190e-02f, 1.75445989e-01f, 1.18665799e-01f,
  1.26179263e-01f, 5.04734367e-02f, -8.23552385e-02f, 1.70320407e-01f, -2.65711576e-01f, -2.06456840e-01f, 1.89749803e-02f, 1.30086511e-01f, 1.70737371e-01f, -1.04924738e-01f,
  1.49582103e-02f, -2.72839647e-02f, -6.12598993e-02f, -4.01674777e-01f, 1.06250681e-01f, -8.89176577e-02f, 2.72454441e-01f, -3.87383550e-02f, 1.45889983e-01f, 1.78533867e-01f,
  -3.61029394e-02f, -9.36081260e-02f, -1.04598075e-01f, -4.26123589e-02f, 1.97907209e-01f, -2.07734182e-01f, -4.18297984e-02f, -9.20038745e-02f, 4.86761518e-02f, -5.15405573e-02f,
  -4.71450761e-02f, 1.29395008e-01f, -2.89720625e-01f, 1.06327377e-01f, -5.07852510e-02f, -1.51891038e-01f, -8.30643699e-02f, 1.72399983e-01f, 1.57496512e-01f, -1.00371420e-01f,
  1.26536041e-01f, -2.67302960e-01f, 2.00076606e-02f, -1.54101908e-01f, -4.08080369e-02f, -5.28144371e-03f, -9.50867236e-02f, 2.49466494e-01f, -8.09374973e-02f, 2.04023626e-03f,
  1.32840082e-01f, -9.21824425e-02f, 3.51964198e-02f, 1.43197611e-01f, -3.74859129e-03f, 6.75288215e-02f, -6.09414205e-02f, -3.23852122e-01f, 6.47026673e-02f, 5.02590463e-02f,
  1.44042857e-02f, 1.04214281e-01f, -4.14581299e-02f, 1.28653198e-01f, -9.57723558e-02f, 1.70481905e-01f, 1.72699794e-01f, -7.75881559e-02f, -4.16303612e-02f, 3.34156096e-01f,
  8.33509639e-02f, -1.46245494e-01f, 4.45329845e-02f, 1.38824433e-01f, -6.48405701e-02f, 1.97321072e-01f, -1.53486878e-01f, 1.39423177e-01f, -1.98353738e-01f, 2.16081310e-02f,
  -2.10642032e-02f, -3.29913288e-01f, -3.67966235e-01f, 1.66004613e-01f, -2.12359414e-01f, -2.80947566e-01f, 2.39028633e-02f, 1.34375736e-01f, -4.65849750e-02f, -2.89950252e-01f,
  -2.84740359e-01f, -4.83538024e-02f, 1.00953579e-01f, -3.48900437e-01f, -5.45526994e-03f, 1.13698155e-01f, 1.37909606e-01f, -9.86876432e-03f, -2.12081224e-01f, 1.13804206e-01f,
  -3.12059313e-01f, -1.70200706e-01f, -4.40362804e-02f, -1.18118839e-03f, 1.63039550e-01f, 1.94099192e-02f, -9.45316777e-02f, -9.48832557e-02f, 2.40364492e-01f, -3.81067634e-01f,
  -1.20743595e-01f, 1.52506441e-01f, -2.55305916e-01f, 2.30544403e-01f, -1.66286066e-01f, 1.12267360e-01f, 8.95276144e-02f, 7.75334463e-02f, 2.87857831e-01f, 9.96864885e-02f,
  1.58168226e-01f, 3.34322564e-02f, -3.06175381e-01f, 2.49725670e-01f, -2.58524735e-02f, 1.38311177e-01f, -1.16902694e-01f, 9.69566479e-02f, -2.50645466e-02f, 6.72828481e-02f,
  -1.10426366e-01f, -2.05147073e-01f, 6.80103824e-02f, -6.84414059e-02f, -1.50522590e-01f, 1.35970473e-01f, -2.22629711e-01f, -2.44151309e-01f, 8.53182971e-02f, -4.20943834e-02f,
  -1.15563877e-01f, 1.32641092e-01f, 2.00008899e-02f, -1.89845428e-01f, -4.43690307e-02f, -3.60831022e-02f, 3.49540375e-02f, -6.02576323e-02f, 1.28307089e-01f, -3.90167624e-01f,
  -1.22380786e-01f, 5.64180501e-02f, 1.42626628e-01f, 1.66326836e-01f, -7.98471570e-02f, 1.92519739e-01f, -2.51213998e-01f, 1.52063310e-01f, 1.85617637e-02f, -9.39734578e-02f,
  1.91104814e-01f, 3.45006995e-02f, 5.85059337e-02f, -1.44063190e-01f, -2.18644530e-01f, 1.27122864e-01f, -1.13339223e-01f, 6.25132350e-03f, -2.57416606e-01f, 7.21398592e-02f,
  -8.44800994e-02f, 1.71638936e-01f, 6.01906553e-02f, -8.03874582e-02f, -1.28255005e-03f, 1.48995608e-01f, -2.88958251e-01f, 1.81113720e-01f, 5.05644158e-02f, -1.79139599e-01f,
  -8.79960731e-02f, 1.54523283e-01f, 1.70243934e-01f, -1.07936375e-01f, -5.54962605e-02f, -1.08786561e-01f, -3.32974821e-01f, 1.37287647e-01f, -5.88634890e-03f, -5.02723083e-02f,
  -3.08064763e-02f, -5.38641624e-02f, -1.35755822e-01f, 4.31746840e-02f, 1.37615621e-01f, 1.14786066e-03f, 2.06618686e-03f, -3.26863639e-02f, -2.10518554e-01f, -1.39221102e-01f,
  -5.14529943e-02f, -1.85435608e-01f, 1.77398846e-01f, -1.65767595e-01f, 2.18103573e-01f, -1.69267967e-01f, 4.94351424e-02f, 5.91323189e-02f, -1.90463886e-02f, 2.10222393e-01f,
  -1.08661331e-01f, -2.97439266e-02f, 4.49149497e-02f, -1.20858677e-01f, -2.45474666e-01f, -1.35784656e-01f, -3.17477554e-01f, -1.64335206e-01f, 2.52714735e-02f, -9.38220695e-03f,
  1.60977542e-01f, 4.73155789e-02f, 1.32092545e-02f, 7.63454810e-02f, -8.41311440e-02f, -3.79218221e-01f, -2.19732657e-01f, 2.75332361e-01f, -2.00266346e-01f, 2.95159310e-01f,
  7.49362484e-02f, 7.35021532e-02f, -1.80223495e-01f, -1.91406220e-01f, 1.08673796e-01f, 4.60638292e-02f, -1.24794371e-01f, 2.94344276e-01f, -2.44070932e-01f, 6.94146380e-02f,
  2.11093977e-01f, -2.77519256e-01f, 1.41465738e-01f, -2.83781830e-02f, -3.29225481e-01f, 1.38273820e-01f, -1.97730303e-01f, -3.68934299e-04f, -7.40013737e-03f, -1.19507387e-02f,
  2.01311544e-01f, 6.26058951e-02f, -6.09225854e-02f, -1.78028539e-01f, -4.12381440e-02f, -5.84579036e-02f, -6.82885721e-02f, 4.34169210e-02f, -1.00924388e-01f, -2.32336640e-01f,
  1.26149291e-02f, 8.04799646e-02f, 1.38192192e-01f, 2.33663842e-01f, -2.92840809e-01f, 1.19157568e-01f, -4.15007733e-02f, 7.99791738e-02f, -4.73762304e-03f, 1.41371042e-02f,
  -1.91578671e-01f, 1.89567015e-01f, -2.63910860e-01f, -9.98418629e-02f, -2.13640779e-01f, -2.34478831e-01f, 2.07163721e-01f, 2.67856545e-03f, 7.95698091e-02f, 8.31376314e-02f,
  1.02187961e-01f, -1.28296837e-01f, 1.18511207e-01f, 1.96793377e-01f, -2.59410322e-01f, 1.58604756e-01f, -1.17243625e-01f, -9.01882946e-02f, -5.47650866e-02f, -1.18795045e-01f,
  4.86871637e-02f, 1.22655407e-01f, -8.13535601e-02f, 1.25396907e-01f, 1.88738093e-01f, 2.36618400e-01f, -4.10929024e-02f, -1.24721527e-01f, 1.08706109e-01f, 1.97071105e-01f,
  1.39112785e-01f, 3.34441930e-01f, -1.23455621e-01f, -1.54160902e-01f, -1.18282601e-01f, 2.23912403e-01f, -2.20162019e-01f, -1.71486676e-01f, -2.99122930e-01f, -2.17497453e-01f,
  -2.84408271e-01f, -3.57205234e-02f, -1.87185079e-01f, 2.49870718e-01f, -9.91267040e-02f, -1.94249660e-01f, 1.46302581e-01f, 6.54257014e-02f, -5.25529794e-02f, 1.01230890e-01f,
  6.79949075e-02f, -6.24155253e-02f, 2.97191553e-02f, 2.55114794e-01f, 1.28688458e-02f, -2.16154456e-01f, -1.93097934e-01f, 1.47708893e-01f, -2.89072752e-01f, -8.87828544e-02f,
  2.06414714e-01f, -3.47148120e-01f, -8.95288736e-02f, 1.19802497e-01f, 4.76203486e-02f, -9.89315659e-02f, -1.80900380e-01f, 2.03086749e-01f, 1.48082674e-01f, 1.60725072e-01f,
  -3.22877824e-01f, -1.86818138e-01f, -3.27306926e-01f, -2.06292376e-01f, -1.27748400e-01f, 2.56546915e-01f, -6.91383332e-02f, -8.33734721e-02f, -1.72154889e-01f, 1.45744711e-01f,
  -3.15007597e-01f, 2.19135001e-01f, -8.79276395e-02f, -5.77951372e-02f, 1.79507688e-01f, -1.32098079e-01f, -3.18343908e-01f, -1.77446008e-01f, -1.16508536e-01f, -1.56867042e-01f,
  -2.59899229e-01f, -1.97773710e-01f, 1.83747754e-01f, -2.74446368e-01f, -2.33612731e-01f, 6.09190241e-02f, -1.66984707e-01f, 2.16481581e-01f, 1.52098596e-01f, 1.37398586e-01f,
  1.47852018e-01f, -1.08511169e-02f, 1.48814186e-01f, 5.55642210e-02f, -1.71090484e-01f, -4.37548399e-01f, 1.41444713e-01f, -1.00425646e-01f, 9.01282206e-02f, 1.32880226e-01f,
  -3.15360948e-02f, 1.04824893e-01f, 8.69976655e-02f, 1.35571565e-02f, 1.93232559e-02f, 8.47518891e-02f, -1.86818153e-01f, 2.29759857e-01f, 2.93867737e-02f, -1.60672218e-01f,
  -4.79294807e-02f, -1.27744377e-01f, 1.83501825e-01f, 2.09168255e-01f, -1.67470083e-01f, -5.08222207e-02f, 1.76938057e-01f, -3.55846375e-01f, 8.55891556e-02f, 2.58350343e-01f,
  -3.36982496e-02f, -1.02518439e-01f, 1.09373175e-01f, -2.02029660e-01f, 1.93440959e-01f, 9.55292434e-02f, 2.07126901e-01f, -1.78935006e-01f, -4.95034941e-02f, -2.08569944e-01f,
  1.99049935e-01f, -1.82056248e-01f, -2.32899114e-01f, 5.49967326e-02f, 1.45644724e-01f, -2.29797453e-01f, -7.53108114e-02f, 4.10491265e-02f, 3.75314392e-02f, -2.22387165e-01f,
  2.19989732e-01f, -1.85042545e-01f, -2.16087257e-03f, -2.31895611e-01f, -2.12086409e-01f, 2.44046286e-01f, 1.12827763e-01f, -1.53556302e-01f, 1.17797285e-01f, -1.40455469e-01f,
  8.04300755e-02f, -1.83081806e-01f, -5.34236021e-02f, -2.66516119e-01f, -2.57083148e-01f, 2.22813096e-02f, -2.79505104e-01f, -2.05584630e-01f, -2.99110144e-01f, 1.45738557e-01f,
  -1.00940958e-01f, 1.38166532e-01f, -2.07450628e-01f, -2.77564079e-01f, 9.62340608e-02f, -5.46015948e-02f, -1.35307638e-02f, 9.61056799e-02f, -1.20517746e-01f, -7.19514340e-02f,
  1.44057006e-01f, -1.24196753e-01f, 1.61791414e-01f, -4.61700708e-02f, 6.85644895e-02f, 1.02258988e-01f, 1.37293771e-01f, 1.27829745e-01f, -2.95506120e-02f, -2.66841471e-01f,
  -2.50293583e-01f, -1.35015145e-01f, 1.87645882e-01f, 2.39929948e-02f, 4.67007011e-02f, -3.53794426e-01f, 9.24628228e-02f, -2.19388574e-01f, 1.45157039e-01f, -2.20977068e-01f,
  6.99474737e-02f, 2.61735916e-01f, 7.26751536e-02f, -1.70413643e-01f, -2.06727743e-01f, -2.58625746e-01f, -3.20950329e-01f, -2.24548221e-01f, -1.34021686e-02f, -2.02056780e-01f,
  -2.53217369e-01f, -2.10111991e-01f, 2.20989853e-01f, -1.02963701e-01f, 1.49610341e-01f, 1.07988030e-01f, 3.56254843e-03f, 4.70187627e-02f, -7.82096386e-02f, 1.28137052e-01f,
  -2.41288230e-01f, 1.38883904e-01f, 9.34555531e-02f, -6.77922368e-02f, -1.11112967e-01f, -2.11865500e-01f, 1.82994947e-01f, 1.13697588e-01f, -6.10576794e-02f, 1.27692789e-01f,
  -3.65887731e-01f, 3.59394662e-02f, 2.03435451e-01f, -2.46693604e-02f, -1.63162693e-01f, 7.10476786e-02f, -3.04410636e-01f, 2.08942115e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  6.62017912e-02f, 8.91165957e-02f, -1.30214348e-01f, -3.48141380e-02f, -5.41851111e-02f, -5.70711307e-02f, -3.06382403e-02f, 2.87801139e-02f, 1.91114955e-02f, -4.21882346e-02f,
  1.15588546e-01f, -8.40713605e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    