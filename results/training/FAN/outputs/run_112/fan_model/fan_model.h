/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.24931175e-01f, -7.39687458e-02f, 1.08394735e-01f, -2.79276371e-01f, -1.47289291e-01f, 1.03319786e-01f, 3.04354951e-02f, -1.13162309e-01f, -1.25292912e-01f, 3.68432030e-02f,
  -6.01584744e-03f, 5.13985269e-02f, 1.53540239e-01f, -1.28763124e-01f, -2.41813347e-01f, 1.94541276e-01f, -1.81810170e-01f, -3.57313156e-02f, 9.39013138e-02f, -1.08881056e-01f,
  -7.25177675e-02f, -1.64495766e-01f, 1.29362389e-01f, -5.49284443e-02f, -8.47564489e-02f, 4.91782464e-02f, -3.17249149e-02f, 1.33944795e-01f, -7.52467364e-02f, -4.90341336e-02f,
  -1.06891483e-01f, -1.86905757e-01f, 6.51041940e-02f, 2.83498373e-02f, 1.81596242e-02f, 8.25664327e-02f, 8.03414956e-02f, 5.52377924e-02f, 5.49031347e-02f, 2.38908399e-02f,
  9.95405316e-02f, -4.30085249e-02f, -2.78390106e-02f, 5.62300952e-03f, -2.05720942e-02f, -1.87151972e-02f, 1.06323732e-03f, 6.15148358e-02f, 2.20274515e-02f, -5.36937034e-03f,
  9.86018628e-02f, 7.03333467e-02f, 6.29211962e-02f, 1.43446615e-02f, 5.59015647e-02f, -4.54921415e-03f, 1.19982529e-02f, 4.92596254e-02f, 3.18677612e-02f, -1.69435386e-02f,
  -2.33035479e-02f, -4.30803224e-02f, 5.91374338e-02f, -8.01706016e-02f, -8.29004571e-02f, -9.15907994e-02f, 7.53261289e-03f, 4.01288383e-02f, 2.59284656e-02f, -2.88926391e-03f,
  -6.98761418e-02f, -1.54537261e-01f, -8.20908025e-02f, 5.39396778e-02f, 8.49178135e-02f, -4.58338447e-02f, 2.53022723e-02f, 2.30421554e-02f, 1.85440071e-02f, -7.70677999e-02f,
  -3.83504492e-04f, -8.46278220e-02f, -4.59151901e-02f, 1.21676691e-01f, -6.54268935e-02f, 1.19566962e-01f, 5.08856922e-02f, 3.72628756e-02f, -4.53789234e-02f, 8.59448016e-02f,
  -5.58955558e-02f, -1.99918821e-01f, -1.04646906e-02f, -9.27172080e-02f, -1.12012066e-02f, 1.81505252e-02f, -5.69651909e-02f, 8.11764300e-02f, 2.58302409e-02f, -1.71961193e-03f,
  5.53339794e-02f, -4.92506512e-02f, 7.23492950e-02f, -4.91211303e-02f, 1.23869739e-02f, -1.67663936e-02f, 7.16432407e-02f, -1.11666726e-04f, 2.66286358e-02f, -1.13379344e-01f,
  -2.32147817e-02f, 5.50724603e-02f, 1.11160532e-01f, -1.04270920e-01f, -2.54668482e-03f, 5.21519501e-03f, -1.80312976e-01f, 1.05998479e-01f, 6.03838116e-02f, 3.26282233e-02f,
  2.38719031e-01f, 1.11626154e-02f, -1.61158279e-01f, -4.23267903e-03f, 2.14582076e-03f, 1.99680999e-01f, 2.99693912e-01f, -3.16066295e-02f, 2.60026395e-01f, 1.16046548e-01f,
  9.33066830e-02f, -9.98834148e-02f, 2.04979982e-02f, 1.42563833e-02f, -2.93675780e-01f, 8.10253546e-02f, -5.04891155e-03f, -3.71733345e-02f, 4.24822718e-02f, -2.11600829e-02f,
  1.14896940e-02f, -6.69775978e-02f, -1.84925064e-01f, -7.97456782e-03f, 6.52942108e-04f, -1.18160680e-01f, -2.08662048e-01f, -1.72624532e-02f, -2.16669038e-01f, -1.36855021e-01f,
  4.17024866e-02f, 1.67308882e-01f, 4.49869372e-02f, 5.45726456e-02f, 1.12786584e-01f, 5.17544411e-02f, -6.30942434e-02f, -1.63464099e-02f, 4.59229425e-02f, 1.18180171e-01f,
  -6.02083169e-02f, -4.45358530e-02f, 4.83593382e-02f, -9.13864598e-02f, 2.22807769e-02f, 4.30830345e-02f, -1.42079350e-02f, -3.05014364e-02f, -7.44808689e-02f, 1.82973668e-02f,
  -7.67946765e-02f, -1.86541397e-02f, 5.61178736e-02f, -6.53336346e-02f, -9.49080810e-02f, 8.02676007e-02f, 4.07754742e-02f, -6.33260906e-02f, 1.77860223e-02f, 5.43378945e-03f,
  -6.19196147e-02f, 1.18762873e-01f, 1.36054575e-01f, 4.92127240e-02f, 1.06259935e-01f, -2.56132316e-02f, 1.58699099e-02f, -1.66670233e-02f, 4.31948528e-02f, 4.53754216e-02f,
  -2.41916291e-02f, -5.74787846e-03f, 4.48505804e-02f, 5.54048531e-02f, -8.28866139e-02f, 6.13098145e-02f, -8.98887217e-03f, -1.14634447e-01f, 3.50608793e-03f, -2.09158869e-03f,
  4.96124104e-02f, -4.37806994e-02f, -2.62738811e-03f, -1.17355593e-01f, 4.74986807e-02f, 5.18279942e-03f, -2.53107026e-02f, 4.80087176e-02f, 8.55134577e-02f, -6.13926314e-02f,
  -7.56557360e-02f, -1.20166972e-01f, 7.71150291e-02f, 9.46191512e-03f, -5.34858229e-03f, -6.06446452e-02f, -1.57766566e-02f, -9.04929917e-03f, -6.47008121e-02f, -3.07438578e-02f,
  -8.86581615e-02f, 6.33906573e-02f, -2.85981707e-02f, -8.44194219e-02f, -1.42263547e-01f, -2.15349663e-02f, -1.31282568e-01f, -4.75637652e-02f, -1.07923761e-01f, -1.11072809e-01f,
  -5.61104901e-02f, 5.81467934e-02f, 2.04588193e-02f, 1.73670247e-01f, -1.34092914e-02f, -3.69553454e-02f, 3.13898921e-02f, 3.88400219e-02f, -1.60653010e-01f, -5.17186783e-02f,
  1.53878704e-01f, -2.96941668e-01f, -8.26249346e-02f, -2.96004802e-01f, 1.90063551e-01f, -9.86318737e-02f, -2.15190172e-01f, -6.31763861e-02f, -9.91526153e-03f, -2.44532511e-01f,
  -4.22987752e-02f, -8.63877833e-02f, -7.93877468e-02f, -2.30060250e-01f, -1.75618932e-01f, -5.25302924e-02f, -2.44639188e-01f, -1.17225192e-01f, 1.06105745e-01f, -1.39735892e-01f,
  -3.13131511e-02f, -1.50154933e-01f, -1.12376623e-01f, -4.70935479e-02f, -6.35630563e-02f, -4.24045101e-02f, -6.13656230e-02f, 8.01170692e-02f, -1.80016190e-01f, -2.21679416e-02f,
  1.77487694e-02f, 4.75377887e-02f, 7.35321343e-02f, -2.03863252e-04f, -2.84048449e-02f, 6.86832443e-02f, 5.07043339e-02f, -3.74685600e-02f, 5.58935478e-02f, 8.84691253e-02f,
  -2.72266008e-02f, -2.57111192e-02f, -9.18977335e-02f, -3.17681581e-02f, 9.40306932e-02f, 6.93951175e-02f, 2.93964185e-02f, 3.40330899e-02f, -1.54678943e-02f, 3.73183116e-02f,
  3.13006081e-02f, -7.05074370e-02f, 3.81473005e-02f, -7.43590370e-02f, 8.53371918e-02f, 2.39529065e-03f, -7.94068426e-02f, -3.31024900e-02f, 1.43183088e-02f, -2.17784662e-02f,
  1.75992921e-02f, -1.09983869e-02f, 6.94712773e-02f, 5.52327023e-04f, -8.81180614e-02f, 4.04112861e-02f, 5.75876161e-02f, 2.75293943e-02f, 3.97033952e-02f, -6.95483107e-03f,
  2.81082243e-02f, -5.08823199e-04f, 3.39029096e-02f, -1.33155808e-01f, 1.13160787e-02f, -9.43449065e-02f, 6.08034767e-02f, 8.52846876e-02f, 1.10074803e-01f, -4.82804850e-02f,
  -8.16439167e-02f, -8.59689564e-02f, -6.90592229e-02f, 7.88976923e-02f, -1.96220372e-02f, -3.43889855e-02f, 1.74952876e-02f, 1.21201247e-01f, -5.76323904e-02f, 5.64150400e-02f,
  -2.07853034e-01f, -3.38600755e-01f, 3.25705148e-02f, 1.95320286e-02f, -3.59998532e-02f, 3.02532092e-02f, -4.77307700e-02f, 8.38303939e-03f, -4.97346111e-02f, -3.15132290e-02f,
  -1.32472545e-03f, 6.55580498e-03f, -1.83671899e-02f, 6.89662714e-03f, -6.57902285e-02f, -6.32710978e-02f, -7.67549276e-02f, -3.97377610e-02f, -8.23542401e-02f, -8.28367025e-02f,
  -5.64112961e-02f, -6.76116794e-02f, 6.43168613e-02f, -3.73735279e-02f, 5.59277646e-03f, -4.61898595e-02f, -2.58557182e-02f, 3.41500342e-02f, -5.10430411e-02f, -6.97956309e-02f,
  -3.89196098e-01f, 6.25937134e-02f, -2.52442025e-02f, -2.95280814e-01f, -1.12528699e-02f, 2.63940305e-01f, 6.69151023e-02f, 5.79483919e-02f, -1.73335329e-01f, 5.24186455e-02f,
  -3.18919942e-02f, 1.68900955e-02f, 3.35466325e-01f, -2.66915590e-01f, -1.25510514e-01f, 2.57904530e-01f, -2.62314796e-01f, -1.89075097e-02f, 4.99975719e-02f, -2.03924239e-01f,
  -5.29494025e-02f, -2.01844722e-01f, -4.17864434e-02f, 1.74948610e-02f, -1.84260681e-01f, 1.11814536e-01f, -1.49934545e-01f, 1.65243432e-01f, -1.64764389e-01f, 1.50268376e-01f,
  -4.53973636e-02f, -1.27942547e-01f, -5.39353751e-02f, 6.08493984e-02f, -6.02163672e-02f, -4.29344438e-02f, -3.66084231e-03f, 5.55021986e-02f, 5.53679243e-02f, 4.83246706e-02f,
  7.51742274e-02f, -9.85608809e-03f, 6.53958619e-02f, 4.89499234e-03f, -7.66884536e-02f, 5.81665672e-02f, -6.39313161e-02f, -1.76381115e-02f, -1.02455951e-02f, -5.78818768e-02f,
  1.93240885e-02f, 6.73389435e-03f, -1.47150055e-01f, 1.36354670e-01f, 1.30210280e-01f, -5.09411208e-02f, -6.48502335e-02f, 3.38410549e-02f, 3.53277735e-02f, -3.16791050e-02f,
  2.76126945e-03f, 3.25283210e-04f, 1.34812398e-02f, -2.24719476e-02f, -2.96180863e-02f, -2.47053038e-02f, 5.61362505e-03f, -5.83035313e-02f, -6.40242621e-02f, -6.85425252e-02f,
  -1.01797573e-01f, 5.71373664e-02f, -1.64582595e-01f, 4.49905870e-03f, -4.59540300e-02f, -1.15652382e-01f, -3.74100506e-02f, 1.54386371e-01f, -9.87296253e-02f, 3.18087302e-02f,
  -1.06218541e-02f, -1.02382496e-01f, 2.52354331e-02f, 1.51271303e-03f, -3.40265431e-03f, 4.67137992e-02f, -1.15672618e-01f, -4.95861024e-02f, 9.72971544e-02f, 6.73065111e-02f,
  5.62061183e-02f, 5.31703494e-02f, 9.62348878e-02f, 2.79664304e-02f, 7.10316375e-02f, 1.64728928e-02f, -1.23523567e-02f, -7.71599039e-02f, 1.10866040e-01f, -2.55008005e-02f,
  -1.02733605e-01f, 9.27638337e-02f, -2.35105380e-02f, -7.66662657e-02f, 7.78109282e-02f, 7.66244382e-02f, -7.44303465e-02f, 3.56010944e-02f, -6.69618100e-02f, -9.45596024e-03f,
  5.91141433e-02f, 6.17235936e-02f, 4.17068563e-02f, 2.94799786e-02f, 9.22739855e-04f, -1.67284114e-03f, -5.45195900e-02f, -3.66622508e-02f, 4.29107249e-03f, 4.03851084e-02f,
  -7.01836422e-02f, 1.67772561e-01f, 2.33763665e-01f, -4.47531156e-02f, -1.27912402e-01f, 2.47415170e-01f, 1.53057575e-01f, -1.32508516e-01f, 2.67197099e-02f, -1.68631345e-01f,
  -1.19684711e-02f, 1.45033374e-01f, 1.23931974e-01f, 6.25301450e-02f, 4.14656669e-01f, 1.35785416e-01f, 1.13289557e-01f, 6.84270188e-02f, -6.23606145e-02f, 4.98605296e-02f,
  8.17262102e-03f, -2.37231478e-02f, 7.55468681e-02f, -8.78624022e-02f, -1.05048619e-01f, -1.82850197e-01f, -2.49040782e-01f, 8.90046433e-02f, -1.50884554e-01f, 6.30587116e-02f,
  1.52574420e-01f, -7.23980963e-02f, -7.73636103e-02f, 8.71460438e-02f, 2.77547687e-02f, 1.02057587e-02f, 6.43753409e-02f, 3.48124318e-02f, 5.73256277e-02f, 6.37981063e-03f,
  -4.77127805e-02f, -5.88269085e-02f, -8.84675309e-02f, 6.05501607e-02f, -6.61276979e-03f, 1.57011487e-02f, -1.01278760e-01f, 6.37703910e-02f, -7.40595087e-02f, 5.39227389e-03f,
  5.55125736e-02f, 4.33863373e-03f, -2.94799209e-02f, 1.08611109e-02f, -4.51244451e-02f, 4.00905386e-02f, -4.49525714e-02f, 1.63413007e-02f, -1.86060742e-02f, 1.39826983e-02f,
  -5.70190549e-02f, -4.17884951e-03f, -9.24307927e-02f, -2.57491432e-02f, 7.49228224e-02f, -6.76159784e-02f, 1.18499577e-01f, -2.04855837e-02f, -2.05203835e-02f, 1.73977669e-02f,
  8.52244049e-02f, 4.10938710e-02f, 3.55015993e-02f, -2.05706991e-02f, -1.67040214e-01f, -2.53708102e-02f, 5.37969917e-02f, 6.17585424e-03f, -6.12292849e-02f, -6.90690130e-02f,
  8.73146802e-02f, 1.11118235e-01f, 4.36257124e-02f, -6.15479834e-02f, 1.17571242e-01f, 5.75026982e-02f, -6.80544227e-02f, 3.77759375e-02f, 7.55404010e-02f, 2.52667386e-02f,
  2.13162974e-01f, 1.95429921e-02f, -2.15374362e-02f, -3.86436633e-03f, 8.75153840e-02f, 2.06520092e-02f, 1.17451228e-01f, -8.27974826e-02f, 7.97008276e-02f, 4.94825728e-02f,
  -1.34611472e-01f, -9.26212221e-02f, -1.50488433e-03f, 4.23521288e-02f, 7.97282830e-02f, 8.69355202e-02f, 5.17818239e-03f, 5.87125644e-02f, -1.57756448e-01f, -1.86201129e-02f,
  -3.68973576e-02f, -1.01289945e-02f, -7.05071017e-02f, -1.42685696e-01f, -1.61429808e-01f, -1.22718783e-02f, 1.77707467e-02f, -1.23797692e-01f, -5.84357418e-02f, 4.90396880e-02f,
  4.84093353e-02f, 2.22935915e-01f, -8.85181949e-02f, 1.06591389e-01f, 3.98744307e-02f, 1.05785519e-01f, 2.62025118e-01f, 6.23436123e-02f, 2.24557206e-01f, 1.42692253e-01f,
  8.44877660e-02f, -3.28207314e-02f, -1.05112409e-02f, 1.38869181e-01f, -2.43766993e-01f, 7.65377879e-02f, -3.99108529e-02f, 9.76845250e-02f, 8.57636109e-02f, -7.70996287e-02f,
  -4.44267131e-02f, -3.87298353e-02f, -1.59927487e-01f, 1.85605492e-02f, 7.23514929e-02f, -7.37102404e-02f, -7.95615092e-02f, -4.73229121e-03f, -1.09028608e-01f, 5.16539952e-03f,
  7.25625902e-02f, 2.72529535e-02f, -2.24247426e-02f, -3.89123242e-03f, -3.66544463e-02f, -3.46860997e-02f, -6.35859221e-02f, 8.00379738e-02f, -1.74386743e-02f, 6.42096400e-02f,
  5.77430725e-02f, -1.01650909e-01f, -4.71441038e-02f, -2.52158940e-02f, 5.97711354e-02f, 6.35486469e-02f, -7.38382936e-02f, 4.50958274e-02f, 5.39851524e-02f, 7.45745152e-02f,
  -3.06981113e-02f, 1.52765876e-02f, 2.90637799e-02f, 7.50977248e-02f, -2.26921756e-02f, 5.17974645e-02f, 2.56368257e-02f, -2.39658896e-02f, 6.48304522e-02f, -3.22263725e-02f,
  -1.55642955e-02f, 1.22866020e-01f, 7.19665214e-02f, 1.98094305e-02f, 4.00921144e-03f, -1.27407571e-03f, 5.06168082e-02f, -9.43430364e-02f, -4.49923910e-02f, 8.82649198e-02f,
  -1.95933003e-02f, 8.15890282e-02f, 8.98041949e-02f, 1.49465846e-02f, 8.80791433e-03f, 1.01487458e-01f, 1.58920392e-01f, -1.76669043e-02f, 2.85388273e-03f, 3.15396301e-02f,
  1.38121396e-01f, -1.42506346e-01f, 7.16432258e-02f, -3.58037092e-02f, -3.44894230e-02f, 8.41161981e-03f, -9.90952030e-02f, 1.04642101e-01f, 4.82396036e-02f, -4.34435382e-02f,
  -1.03129059e-01f, -1.27329603e-01f, 1.37605937e-02f, -1.22282363e-01f, -7.09920377e-02f, -8.47938955e-02f, -9.95360091e-02f, 4.12160996e-03f, -8.53084624e-02f, -9.99051891e-03f,
  -4.87094969e-02f, -5.55442553e-03f, -8.76217112e-02f, -4.18313891e-02f, 1.60381366e-02f, 3.94602306e-02f, -8.89784843e-02f, -6.24069991e-03f, -4.95032128e-03f, -3.42440233e-02f,
  -7.02687949e-02f, -5.66395484e-02f, 5.24045117e-02f, 7.74464011e-02f, -5.81671633e-02f, -1.34543315e-01f, 7.63648152e-02f, 5.41719906e-02f, -1.22411914e-01f, -3.00398991e-02f,
  2.98231035e-01f, -1.50725812e-01f, -2.86069699e-02f, 3.09449375e-01f, -1.06176957e-01f, 2.17083097e-01f, 1.24243498e-01f, -1.04291432e-01f, 1.25300854e-01f, -2.84990538e-02f,
  2.73875237e-01f, -1.38799801e-01f, 1.39076114e-02f, 3.55391562e-01f, 2.94451326e-01f, 2.12841958e-01f, 3.07957888e-01f, 1.31217599e-01f, 9.85965356e-02f, 3.56080756e-02f,
  7.67985955e-02f, 4.71259840e-02f, -7.67450556e-02f, -1.64986759e-01f, -9.16147009e-02f, -2.11266473e-01f, -1.02505989e-01f, -1.79687232e-01f, 2.58518867e-02f, -1.61381364e-01f,
  1.24593496e-01f, 1.08070085e-02f, -6.26518577e-02f, -4.76753935e-02f, 8.12082738e-02f, 2.51006167e-02f, -1.52529329e-02f, -8.78524557e-02f, -3.72531042e-02f, -2.40143556e-02f,
  -7.44562298e-02f, 4.37745154e-02f, -1.98525507e-02f, -1.08246230e-01f, -2.70143934e-02f, 2.50591543e-02f, 6.74545318e-02f, -2.07972117e-02f, -7.72987232e-02f, 4.79928032e-02f,
  5.93596976e-03f, 1.86136737e-02f, 9.09145921e-02f, -3.12691517e-02f, 2.17752010e-02f, 1.13137953e-01f, 4.71309386e-02f, -1.59130991e-02f, -3.44655686e-03f, -3.04155145e-02f,
  -4.00427543e-02f, -1.52911702e-02f, -3.91869955e-02f, -2.46701445e-02f, -1.32494625e-02f, -9.32832155e-03f, -1.14374623e-01f, -8.41430873e-02f, -4.42427583e-02f, -1.92307550e-02f,
  1.07251346e-01f, -3.96526456e-02f, 7.53067285e-02f, 7.33688474e-02f, -8.52480903e-02f, -5.16897440e-02f, -3.45707536e-02f, -9.21290144e-02f, 1.74339652e-01f, -7.81277493e-02f,
  -3.76837738e-02f, 6.05645962e-03f, -6.75119534e-02f, -8.78247544e-02f, -3.14447060e-02f, 1.45474914e-02f, 5.78112751e-02f, 5.53216180e-03f, 4.19321097e-02f, 7.19800293e-02f,
  2.60580312e-02f, -1.00488909e-01f, -5.11580817e-02f, -6.84988275e-02f, -2.77454015e-02f, 8.53538364e-02f, 3.08928434e-02f, 4.62606773e-02f, -8.25830624e-02f, 3.59464325e-02f,
  2.30396073e-02f, 5.99949015e-03f, 1.28619164e-01f, 2.67855581e-02f, -6.37506172e-02f, -6.21595606e-02f, 4.21134196e-02f, 1.18689677e-02f, -7.27706403e-02f, 4.95285243e-02f,
  -6.07078411e-02f, 5.76003715e-02f, 3.89819890e-02f, 7.14882882e-03f, -1.73179563e-02f, -1.38395792e-02f, -5.84899746e-02f, 8.44919384e-02f, 1.85912549e-02f, 4.97212866e-03f,
  -2.95720130e-01f, 1.75153941e-01f, -1.09755732e-01f, 8.32307413e-02f, -3.45109493e-01f, -1.15355395e-01f, -1.25201344e-01f, -1.28443077e-01f, 8.41414556e-02f, 3.28105316e-02f,
  -6.33622259e-02f, 1.35675557e-02f, 4.58976440e-02f, 1.28700823e-01f, 1.74601618e-02f, 2.98860312e-01f, 1.83003992e-02f, 3.88676152e-02f, 1.18596323e-01f, -3.74631323e-02f,
  6.40425235e-02f, -3.33835706e-02f, -1.85868144e-01f, -4.38816436e-02f, -1.78712413e-01f, -8.84043425e-02f, -6.95850775e-02f, 1.01993538e-01f, -6.67807385e-02f, -3.83184217e-02f,
  -1.77013665e-01f, -5.43014659e-03f, -1.45490184e-01f, -3.47895883e-02f, -1.40935853e-01f, -9.50832572e-03f, -3.26901190e-02f, -4.10067625e-02f, -2.02251244e-02f, -9.08074714e-03f,
  -5.59212267e-02f, -9.37861763e-03f, 6.31632283e-02f, 1.34135768e-01f, 6.64604157e-02f, 2.70001292e-02f, 1.47611760e-02f, -1.33008324e-02f, -9.08794533e-03f, 1.69385988e-02f,
  1.51970647e-02f, 3.86099927e-02f, 1.45282999e-01f, -7.46380212e-03f, -3.53070386e-02f, -3.52097042e-02f, -2.19128933e-02f, -1.50375903e-01f, 1.03875613e-02f, -8.72218460e-02f,
  1.21668549e-02f, -3.63545003e-03f, -1.08763557e-02f, -4.02418487e-02f, 8.94625112e-03f, -1.01929098e-01f, 2.26101831e-01f, -4.93532084e-02f, -5.52827977e-02f, -1.37137435e-02f,
  -7.77907446e-02f, 2.35609263e-02f, 1.12057798e-01f, -2.75538266e-02f, -5.79703115e-02f, 8.01891312e-02f, -3.71353030e-02f, 2.56065149e-02f, -3.09526157e-02f, -9.40097496e-02f,
  1.70317203e-01f, 1.09642046e-03f, -1.03220910e-01f, 1.07450718e-02f, 1.15768813e-01f, -8.47345293e-02f, 1.01732314e-01f, 1.73919678e-01f, -7.20657706e-02f, 1.28691727e-02f,
  -5.91139607e-02f, 1.07296526e-01f, -8.56420398e-03f, -5.22621498e-02f, 5.03552258e-02f, 7.78054520e-02f, 1.15054496e-01f, 1.31414761e-03f, -1.62708312e-02f, -8.54027718e-02f,
  -1.77797735e-01f, -4.43059877e-02f, 9.84605923e-02f, -4.77766944e-03f, 1.01787090e-01f, -1.07996441e-01f, -1.73241869e-02f, -2.78516952e-02f, -1.34678066e-01f, -3.40601876e-02f,
  -1.47381321e-01f, -6.10168427e-02f, -3.93177383e-02f, -8.54760781e-02f, -5.59090152e-02f, -3.11363228e-02f, -9.41333361e-03f, -1.80282425e-02f, -2.29970366e-02f, 3.55585515e-02f,
  -1.43707141e-01f, 2.16222212e-01f, 1.52656332e-01f, 4.15494367e-02f, -1.40947133e-01f, -3.45408738e-01f, -2.58253932e-01f, 8.16249698e-02f, 1.70271844e-01f, 7.38525093e-02f,
  -1.79883555e-01f, 1.98531836e-01f, 1.91488713e-01f, -1.92199379e-01f, -2.62497067e-01f, 5.33706024e-02f, -1.52721047e-01f, -1.55330241e-01f, 6.96944594e-02f, 6.53057545e-02f,
  -5.34965210e-02f, -2.28419140e-01f, 1.16117768e-01f, 6.50491118e-02f, 1.32570326e-01f, 1.41765311e-01f, 4.55925055e-03f, 6.35285452e-02f, -1.89710185e-01f, -1.71115361e-02f,
  -1.16281629e-01f, 1.53326511e-01f, 3.58617753e-02f, -7.51956459e-03f, -2.16118470e-02f, -4.72314470e-02f, -1.20000400e-01f, -2.98765060e-02f, -1.01597376e-01f, -5.84306791e-02f,
  -5.44348620e-02f, -7.90667012e-02f, 4.44877893e-02f, -9.64735262e-03f, -9.12978128e-02f, 2.76562162e-02f, 6.92081824e-02f, -5.38398884e-02f, 7.32858926e-02f, 7.04301000e-02f,
  2.15738602e-02f, 8.34032446e-02f, 3.92544530e-02f, 3.89604606e-02f, 4.02174285e-03f, 2.14511203e-03f, 1.83961727e-02f, 7.47072846e-02f, -4.68077995e-02f, -2.58412901e-02f,
  -3.74985635e-02f, -5.01678996e-02f, -4.74237427e-02f, 4.03957926e-02f, 1.51176928e-02f, 7.63675780e-04f, -5.09845167e-02f, 6.16743602e-02f, 1.16527893e-01f, 4.81234714e-02f,
  -1.21130971e-02f, -3.19225341e-02f, 2.65464317e-02f, 2.56518996e-03f, 1.03516374e-02f, 5.05431071e-02f, -6.59983009e-02f, 4.77872901e-02f, 9.57176015e-02f, -5.09901030e-04f,
  -7.62354815e-03f, -5.79896942e-02f, 5.59781753e-02f, -2.48229001e-02f, -1.35837227e-01f, -2.72010695e-02f, -5.34462035e-02f, -6.81965947e-02f, 8.34953338e-02f, -1.13366775e-01f,
  -6.73575886e-03f, 1.22193694e-01f, 9.57151949e-02f, -1.07749783e-01f, -4.79625678e-03f, 7.20093446e-03f, -3.97094619e-03f, -1.07881213e-02f, -7.04304799e-02f, 3.85193564e-02f,
  -2.80759353e-02f, -4.94784527e-02f, 2.50504706e-02f, 2.74600610e-02f, -5.30336723e-02f, 2.22464558e-02f, -3.04363556e-02f, -4.12509516e-02f, -4.19044420e-02f, 1.63824521e-02f,
  -2.96088438e-02f, -3.09962928e-02f, 6.75339252e-02f, -2.10063830e-02f, 1.56728027e-03f, 9.27935019e-02f, -1.37500586e-02f, 5.68753704e-02f, 2.14172881e-02f, 9.06452071e-03f,
  4.68813688e-01f, 3.34641844e-01f, 1.93779290e-01f, 2.52471566e-01f, -9.12407488e-02f, -2.03381050e-02f, 5.25419377e-02f, 3.75394858e-02f, 1.85612366e-01f, -1.25643060e-01f,
  -1.42700121e-01f, 2.32710779e-01f, -1.13827296e-01f, -2.75136400e-02f, 1.56458706e-01f, -9.74018201e-02f, 1.71339899e-01f, 4.39326204e-02f, -1.03210956e-01f, 4.26931307e-02f,
  8.27265233e-02f, -2.73314238e-01f, 2.49121323e-01f, -1.44135386e-01f, 1.06869340e-01f, 1.79210976e-01f, -6.38482496e-02f, -8.45444798e-02f, -6.90940320e-02f, -1.55058160e-01f,
  1.69783249e-01f, 3.66354398e-02f, 3.75178643e-02f, 5.02757449e-03f, 2.97299633e-03f, -1.04376793e-01f, 5.44409268e-02f, -4.83449064e-02f, -8.99423733e-02f, 9.33324452e-03f,
  1.35582043e-02f, -3.99565026e-02f, -1.48434415e-01f, -7.57032558e-02f, -5.21312542e-02f, -4.24052076e-03f, 4.13361453e-02f, 6.49657696e-02f, -2.15747990e-02f, -2.15316620e-02f,
  2.60647703e-02f, -4.95559163e-02f, 1.09596744e-01f, -7.92598501e-02f, 1.35981768e-01f, 7.28421286e-02f, 8.97277966e-02f, 5.69996051e-02f, 1.20783718e-02f, -5.47461510e-02f,
  -1.11339904e-01f, -1.63951516e-02f, 5.05110361e-02f, 3.47520709e-02f, 9.44903179e-04f, 6.23822361e-02f, 5.44738136e-02f, 8.25432763e-02f, 1.26507103e-01f, 2.80538276e-02f,
  -8.26437175e-02f, 6.84958994e-02f, 2.94717047e-02f, -2.45038364e-02f, 7.88784325e-02f, 9.75908525e-03f, 2.76176594e-02f, 3.55413072e-02f, -9.06611234e-02f, 2.57067513e-02f,
  1.53053626e-02f, -2.47629751e-02f, 3.75420563e-02f, 3.90252820e-03f, -4.55122814e-02f, -5.91405109e-02f, 2.10556202e-02f, 2.26888210e-02f, 6.29040450e-02f, -1.02555558e-01f,
  1.85255855e-01f, 2.29731262e-01f, 1.59578100e-02f, -1.30704604e-02f, -3.66604663e-02f, -2.11189557e-02f, -5.86658064e-03f, 2.61973906e-02f, -6.46380112e-02f, -1.08898561e-02f,
  -3.73644866e-02f, 1.07493531e-02f, 3.97134274e-02f, 1.18159540e-02f, -7.48469532e-02f, 8.98493640e-03f, -4.23775725e-02f, 6.93285242e-02f, -5.93359908e-03f, -3.43133174e-02f,
  1.00052834e-01f, 5.70354424e-02f, -9.86598730e-02f, 4.67468947e-02f, -1.30912825e-01f, 2.29037530e-03f, 1.11875407e-01f, -2.89541502e-02f, -6.74348027e-02f, -5.07426681e-03f,
  3.20408672e-01f, 7.01074600e-02f, 1.90552622e-01f, 2.99689114e-01f, 7.17321038e-02f, -3.59154820e-01f, -8.32891911e-02f, 1.48300067e-01f, 1.54428452e-01f, -1.13311045e-01f,
  -3.62954065e-02f, 1.42245516e-01f, -1.34382814e-01f, 1.43768176e-01f, -2.92222947e-01f, -2.18885005e-01f, 7.87668526e-02f, 6.51693344e-02f, 4.30187397e-02f, 1.87415585e-01f,
  1.72616169e-02f, -1.72084495e-02f, 5.77095849e-03f, 1.53262898e-01f, 1.17793277e-01f, 1.63875580e-01f, -6.78013042e-02f, -1.68627113e-01f, 3.11029572e-02f, -1.13430321e-01f,
  -6.40669763e-02f, 9.70165282e-02f, 2.84590535e-02f, -2.82612983e-02f, -2.06346028e-02f, -8.79035294e-02f, -3.32259536e-02f, 8.65190383e-03f, -1.13120407e-01f, 4.01285999e-02f,
  -2.12285146e-02f, -2.15612222e-02f, -1.40716566e-03f, 1.31363422e-02f, -5.82504384e-02f, 5.71348183e-02f, 4.36580181e-03f, 8.18626489e-03f, 6.98755533e-02f, 1.24142714e-01f,
  1.41143724e-02f, -1.13174699e-01f, 6.05869899e-03f, 4.40738676e-03f, -3.08834817e-02f, 1.16833441e-01f, -3.82045843e-02f, 8.00479203e-02f, -1.09217525e-01f, 1.19434498e-01f,
  6.60797581e-03f, 1.47700766e-02f, 2.31760684e-02f, 7.32907876e-02f, -3.44313085e-02f, 7.41576357e-03f, 1.22575136e-02f, -2.36432105e-02f, -3.53479087e-02f, 3.81329358e-02f,
  -1.66801387e-03f, 4.56601717e-02f, 7.05563137e-03f, 7.72281513e-02f, 2.71734819e-02f, 9.64834094e-02f, 5.86291626e-02f, 2.01977026e-02f, -2.35681683e-02f, 4.32643704e-02f,
  3.56446356e-02f, 3.80308256e-02f, -5.76888165e-03f, -2.43918486e-02f, -1.32701145e-02f, -4.96787392e-02f, 5.93826957e-02f, 1.93639789e-02f, -5.23368903e-02f, -4.32912000e-02f,
  -1.85457230e-01f, 8.27585459e-02f, -8.86822492e-02f, -5.68610542e-02f, -4.69196662e-02f, -2.02727821e-02f, 1.03691690e-01f, 8.89394358e-02f, -1.14914939e-01f, 6.34292960e-02f,
  2.98936255e-02f, -7.33991265e-02f, -3.28561068e-02f, 7.76884034e-02f, -9.35246721e-02f, 6.61609992e-02f, -1.76049415e-02f, -7.63785020e-02f, -3.31992400e-03f, -4.93603535e-02f,
  -6.40034303e-02f, -7.44054168e-02f, -8.75174850e-02f, -3.51996794e-02f, -5.51485494e-02f, 4.96498682e-02f, 6.80172294e-02f, 7.84023628e-02f, 5.32528609e-02f, -6.45893216e-02f,
  -3.27280164e-01f, 4.19590950e-01f, -1.83741599e-02f, 3.58738936e-02f, -2.33222455e-01f, -2.15060651e-01f, -5.01666665e-02f, -7.05699921e-02f, -2.88722664e-01f, 2.69114822e-01f,
  -1.69143956e-02f, 4.11917157e-02f, 1.87462747e-01f, 1.18403703e-01f, -4.11293119e-01f, -1.61287971e-02f, -2.30337773e-02f, 5.38587160e-02f, 4.79802256e-03f, 1.03264816e-01f,
  -1.13053910e-01f, 1.85307674e-02f, 1.08271927e-01f, 9.14886817e-02f, 4.37035188e-02f, 2.44750991e-01f, 9.97900516e-02f, 6.41995817e-02f, 1.25013813e-01f, -1.08279526e-01f,
  -1.69435318e-03f, 1.45951942e-01f, 1.00201793e-01f, 2.91481391e-02f, 9.09378603e-02f, 1.30365878e-01f, 1.25513613e-01f, 2.32998487e-02f, -1.75195523e-02f, -8.73462707e-02f,
  -1.40356142e-02f, -7.32681975e-02f, -3.65109518e-02f, -4.99504283e-02f, -2.44094022e-02f, -1.19464807e-01f, -3.68800163e-02f, -5.30968653e-03f, 1.29633084e-01f, -4.31297012e-02f,
  -5.25372336e-03f, -5.41979223e-02f, -5.71771190e-02f, -5.59566193e-04f, -7.52541274e-02f, -8.23989362e-02f, -4.55348082e-02f, 2.39247829e-02f, -7.85071552e-02f, -1.25019506e-01f,
  -4.97563258e-02f, 1.35720596e-02f, -9.65966508e-02f, 6.23863861e-02f, 1.68174133e-02f, -1.08544687e-02f, -3.56048122e-02f, 5.98725826e-02f, -8.23430791e-02f, -5.70717920e-03f,
  -4.82152253e-02f, 6.79806899e-03f, -2.25756946e-03f, -3.30615193e-02f, -8.69639218e-02f, 2.59201098e-02f, -5.60528897e-02f, -4.63903472e-02f, 2.34137625e-02f, -1.48538053e-02f,
  2.15361360e-02f, 5.01613431e-02f, 4.77977656e-02f, 9.99155417e-02f, 1.46249533e-01f, -9.18816775e-02f, 1.92266591e-02f, -8.38022977e-02f, 1.29073441e-01f, -1.20567024e-01f,
  1.62266031e-01f, 1.64045557e-01f, 7.88068026e-02f, 1.23175815e-01f, 1.51952103e-01f, 5.53849898e-02f, 8.17977488e-02f, 1.01388544e-02f, 1.03743998e-02f, -6.17318749e-02f,
  9.48647503e-03f, 6.63557351e-02f, -2.69284248e-02f, 2.00195294e-02f, -1.24966083e-02f, 1.69976093e-02f, 1.10889554e-01f, 9.01810303e-02f, 9.82732847e-02f, 3.84248234e-02f,
  1.01553684e-03f, 1.53687457e-02f, -7.65544772e-02f, -3.93577777e-02f, 4.82010730e-02f, 1.97788160e-02f, 2.49924627e-03f, -7.49673843e-02f, -1.50992312e-02f, 2.58052169e-04f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.30337968e-02f, -2.38322299e-02f, -7.43280798e-02f, 5.66718355e-02f, -1.06120412e-03f, -3.07404816e-01f, -2.82634526e-01f, -2.02443320e-02f, 1.09467961e-01f, -1.08000012e-02f,
  1.23534806e-01f, 1.75644532e-02f, 1.73746571e-01f, -8.88498947e-02f, -1.28951162e-01f, 1.66577175e-01f, -2.01863214e-01f, -1.17296331e-01f, 1.84931338e-01f, 1.24632418e-02f,
  6.07688632e-03f, 7.96867833e-02f, 2.95393020e-02f, 1.02129221e-01f, -1.60853907e-01f, 5.03667556e-02f, 6.57316819e-02f, 2.81792376e-02f, -1.08209878e-01f, 3.38751148e-03f,
  -6.96741417e-02f, 2.24563822e-01f, -1.17288493e-01f, -9.47772898e-03f, 9.31454264e-03f, -1.42653495e-01f, -2.42859617e-01f, -3.88951004e-02f, 8.30940157e-02f, -3.44124325e-02f,
  4.48989160e-02f, 1.18303940e-01f, -1.16347827e-01f, 9.72813442e-02f, -5.22235520e-02f, 4.28829007e-02f, 3.69455144e-02f, 7.95900822e-02f, 3.72113916e-03f, -4.77738157e-02f,
  1.35598304e-02f, 1.13391113e-02f, -5.27936034e-02f, 3.83739844e-02f, 6.67864829e-02f, 5.95300794e-02f, -1.16389073e-01f, -2.54454259e-02f, 2.34377757e-03f, -8.85702483e-03f,
  3.61007079e-02f, 1.28793269e-02f, -2.11916976e-02f, 7.82135129e-02f, -3.62511389e-02f, -9.08450559e-02f, -8.03907961e-02f, -4.58441116e-02f, -4.76253890e-02f, 1.90085452e-02f,
  1.03168674e-01f, 4.91420515e-02f, -8.97768736e-02f, -7.32472017e-02f, 9.80874407e-04f, 1.38162859e-02f, 5.73031716e-02f, 6.57302961e-02f, -3.72780897e-02f, 2.73997001e-02f,
  3.83126289e-02f, -1.96863458e-01f, 6.57407120e-02f, -1.01213671e-01f, -1.30453348e-01f, 8.12196210e-02f, -2.12534908e-02f, 8.94709490e-03f, -1.03503428e-01f, 4.36960384e-02f,
  8.08952451e-02f, 2.21475929e-01f, -5.87619934e-03f, -4.66861427e-02f, -2.92811263e-02f, -1.31453305e-01f, -1.35955334e-01f, -6.29538447e-02f, 9.48729664e-02f, 2.97373571e-02f,
  4.28621843e-02f, -1.32699117e-01f, 6.14039004e-02f, -1.66464541e-02f, 2.43533105e-02f, -6.55967146e-02f, -6.82314858e-02f, 1.08610585e-01f, 1.99633446e-02f, -4.37461585e-02f,
  -2.31643952e-03f, 3.91616449e-02f, -2.47587226e-02f, -1.31500075e-02f, -2.00481340e-02f, 1.92624889e-02f, 1.60999857e-02f, 6.05916791e-02f, 1.11672282e-01f, 1.81275653e-03f,
  -1.93889573e-01f, 1.85690075e-01f, -2.37428859e-01f, 7.78473318e-02f, -2.57566720e-01f, 1.92164376e-01f, 1.81517839e-01f, -1.73582435e-01f, 3.38281482e-03f, 3.29398274e-01f,
  1.66414618e-01f, -8.52454677e-02f, 1.95820972e-01f, 2.50276446e-01f, -8.95677879e-02f, 2.31923401e-01f, 3.01819026e-01f, 1.53779134e-01f, -1.19153537e-01f, -4.31337841e-02f,
  -1.01656780e-01f, 1.95034653e-01f, 3.61757390e-02f, -7.06486553e-02f, -7.79572949e-02f, -1.89396799e-01f, 1.06843803e-02f, -2.74255723e-01f, 2.58586220e-02f, -9.76075232e-02f,
  5.04005626e-02f, -9.24081206e-02f, -5.61151914e-02f, 1.06260029e-03f, 3.32056452e-03f, -2.65115332e-02f, -4.43940535e-02f, -1.03503810e-02f, -9.18172523e-02f, -3.29941101e-02f,
  6.44818768e-02f, -1.16152270e-02f, 1.39628232e-01f, -7.05496371e-02f, -1.19477496e-01f, -9.61509813e-03f, 1.09853670e-02f, 3.80115025e-02f, 4.87163867e-04f, -7.27308095e-02f,
  -9.15316790e-02f, -7.83923715e-02f, 4.06406168e-03f, 6.57738894e-02f, -3.65311839e-02f, 9.65687726e-03f, 3.94256003e-02f, -3.98892164e-02f, 1.19564030e-02f, -3.98781784e-02f,
  -6.45388514e-02f, -1.43149495e-01f, -9.36736632e-03f, -8.07928760e-03f, 3.18007022e-02f, -3.83182280e-02f, -3.96173745e-02f, 1.10275773e-02f, 2.38322560e-02f, 8.61463472e-02f,
  1.09689198e-01f, -2.85822712e-02f, 5.70458844e-02f, 9.46213081e-02f, 3.91345983e-03f, 2.75988318e-02f, -3.01001668e-02f, -6.95873052e-02f, 1.72693193e-01f, 1.16929926e-01f,
  2.75913719e-02f, 4.54358570e-02f, 1.42548427e-01f, -3.24386433e-02f, -3.00570130e-02f, -1.39750168e-01f, -7.05697574e-03f, 2.32104715e-02f, 1.74239501e-01f, -3.59338336e-02f,
  1.03308812e-01f, -2.15577744e-02f, 4.51955646e-02f, 1.02711961e-01f, 4.72710468e-03f, 1.76659208e-02f, 1.25075271e-02f, -2.27279477e-02f, 3.22352983e-02f, -4.98921424e-02f,
  3.70467193e-02f, -7.10186316e-03f, 7.35229999e-02f, -3.43144387e-02f, -4.88385707e-02f, 1.57938585e-01f, 5.32770008e-02f, 2.61799283e-02f, 9.99315158e-02f, -9.14340019e-02f,
  -4.63643707e-02f, 7.33044418e-03f, -3.38642150e-02f, -2.16020606e-02f, -2.04825494e-02f, 8.87226686e-03f, -9.70643759e-02f, -2.25995705e-02f, 1.02651909e-01f, 2.99780499e-02f,
  1.47990212e-01f, -2.54176974e-01f, 2.34443575e-01f, 2.10875899e-01f, 1.74794033e-01f, 2.42655594e-02f, 1.75541177e-01f, -2.26770461e-01f, -2.77085364e-01f, -3.03209394e-01f,
  -3.31843980e-02f, 2.88003415e-01f, 3.28477323e-02f, 6.76784664e-02f, 2.74763972e-01f, -3.35721634e-02f, -1.15337618e-01f, 5.65819331e-02f, -1.72458626e-02f, -8.47084541e-03f,
  -1.21862544e-02f, -7.91060776e-02f, 1.48889333e-01f, -8.05039778e-02f, 7.07271695e-02f, 5.35663962e-02f, -1.13560045e-02f, 2.63570487e-01f, 5.03462479e-02f, 2.21263111e-01f,
  -5.89442030e-02f, -8.60995799e-02f, 1.65879093e-02f, -6.25465810e-02f, -7.44432732e-02f, 7.85420090e-02f, 1.47987023e-01f, 1.28971830e-01f, 5.30008860e-02f, 1.53281726e-02f,
  -7.97730312e-02f, 6.65643141e-02f, 1.37766093e-01f, 5.14539555e-02f, -6.99174032e-02f, -2.29283683e-02f, -1.08172623e-02f, -1.53955519e-01f, -4.40198220e-02f, -2.39507146e-02f,
  -5.60225584e-02f, 1.65786166e-02f, -5.53048775e-02f, 5.38563468e-02f, -2.28049066e-02f, -1.20792016e-01f, -8.15252960e-03f, 1.44530565e-01f, 4.10125554e-02f, 4.86969240e-02f,
  -5.17688468e-02f, -9.31001902e-02f, -8.86863098e-02f, -7.05052763e-02f, 4.96116318e-02f, -7.45412242e-03f, 2.07583290e-02f, 8.66814777e-02f, 1.32791521e-02f, -7.48552382e-02f,
  1.02350779e-01f, 1.89723950e-02f, 3.80943418e-02f, -1.20587996e-04f, -5.56013025e-02f, -7.87866339e-02f, 1.63095873e-02f, 1.12935476e-01f, 7.95383565e-03f, -6.63044229e-02f,
  8.38486701e-02f, 7.65904561e-02f, 1.56785157e-02f, 5.20363413e-02f, 1.50699876e-02f, 3.88550013e-03f, -1.04791872e-01f, 1.98341552e-02f, -1.06794143e-03f, 4.09522967e-04f,
  -3.74884546e-01f, -3.89267653e-01f, -8.42288658e-02f, 9.86594632e-02f, -8.12044814e-02f, 3.17069702e-02f, -6.68070791e-03f, -6.39436543e-02f, -1.33763090e-01f, -1.60193592e-02f,
  -7.66776800e-02f, 1.99900970e-01f, -5.98634034e-02f, -1.09114749e-02f, -5.94124980e-02f, -1.01228058e-01f, 4.87152822e-02f, -1.27921507e-01f, -7.35506341e-02f, -1.15441568e-01f,
  -4.13298570e-02f, 7.38319829e-02f, 7.98190981e-02f, 8.32718611e-02f, -1.38562024e-01f, -2.46752724e-02f, -1.87777653e-02f, 9.12020579e-02f, 3.68412177e-04f, -2.74960771e-02f,
  1.03931557e-02f, 2.23766461e-01f, 2.70063758e-01f, 2.79328495e-01f, -1.46994844e-01f, -3.91606212e-01f, -3.82611677e-02f, 8.62733796e-02f, 2.62756854e-01f, -1.79978997e-01f,
  -2.02442944e-01f, 1.14003532e-01f, -1.03322968e-01f, 2.13192925e-01f, 6.56484812e-02f, 8.73748660e-02f, 1.70119181e-01f, -3.51771936e-02f, 6.29170164e-02f, 1.37938306e-01f,
  1.34970874e-01f, -1.16959564e-01f, 7.33438134e-02f, -6.48462325e-02f, -1.42275207e-02f, 2.40902215e-01f, 5.95536232e-02f, 1.06955484e-01f, -5.65854786e-03f, 4.85266447e-02f,
  1.14589773e-01f, 1.43881470e-01f, 1.43530490e-02f, 1.02398880e-01f, 1.33134067e-01f, -1.45332068e-01f, 8.07726607e-02f, -6.34949803e-02f, 6.17615245e-02f, -6.38334602e-02f,
  3.83775979e-02f, -3.56958807e-02f, 4.77923453e-02f, -1.33167028e-01f, -7.12545356e-03f, 1.09838927e-02f, 8.24193731e-02f, 2.46891622e-02f, -9.48590413e-03f, 6.05007261e-02f,
  -1.11388396e-02f, 4.34792526e-02f, -9.09010042e-03f, 1.58692077e-01f, 1.96073264e-01f, 1.81021824e-01f, 6.00084774e-02f, 1.21260837e-01f, 1.00495674e-01f, 1.63461939e-01f,
  -2.74357554e-02f, -2.34208945e-02f, -2.99526826e-02f, -6.83794320e-02f, -4.99543361e-02f, 2.20090430e-02f, 5.10890931e-02f, -6.65252730e-02f, 6.79291561e-02f, -4.27871235e-02f,
  3.06550972e-02f, 6.25373870e-02f, -3.87423411e-02f, -9.70785469e-02f, -3.04854568e-02f, -1.28114507e-01f, -4.58081290e-02f, 6.14935793e-02f, 4.33069207e-02f, 2.22759694e-02f,
  -3.05302683e-02f, -5.66708297e-02f, -2.76604928e-02f, -5.27881943e-02f, -6.62102252e-02f, 1.05942329e-02f, -7.08626136e-02f, -9.36259702e-02f, -8.04395527e-02f, 5.18881995e-03f,
  1.43221036e-01f, 2.79122859e-01f, 6.51754588e-02f, 2.90690418e-02f, 1.96484942e-02f, -1.07812703e-01f, 9.10372566e-03f, 1.10168569e-01f, 2.15197042e-01f, -2.10130773e-02f,
  7.91726783e-02f, -6.76767379e-02f, -1.06483132e-01f, -1.23134792e-01f, 4.22972441e-03f, 7.04905316e-02f, 9.50868279e-02f, 1.05585501e-01f, 1.94145411e-01f, -2.37707924e-02f,
  -3.89727391e-02f, -1.02646224e-01f, 9.12378579e-02f, 2.94405706e-02f, 3.39139812e-02f, -1.25259236e-02f, -9.74619240e-02f, 1.06056266e-01f, 3.90184224e-02f, 8.02255571e-02f,
  8.83223563e-02f, 1.21680453e-01f, 1.69826463e-01f, 2.82590121e-01f, 3.26160401e-01f, 4.38042819e-01f, 3.81151140e-01f, 2.50823230e-01f, 6.55079305e-01f, 3.17940041e-02f,
  -1.31612167e-01f, 3.22805680e-02f, -5.52219190e-02f, -8.45125318e-02f, 8.34417343e-02f, 1.36567101e-01f, 2.66792268e-01f, 1.44423485e-01f, 3.10937583e-01f, -3.05853505e-02f,
  5.01431078e-02f, -2.47175153e-02f, -3.02770168e-01f, -1.69367045e-01f, -1.33070320e-01f, -1.30677760e-01f, -5.69704771e-01f, 4.20731045e-02f, -2.39626810e-01f, 1.50852278e-01f,
  3.49517800e-02f, 4.05065939e-02f, -1.52842849e-01f, -2.28056358e-03f, 8.10741261e-02f, 4.73589590e-03f, -8.97907019e-02f, 6.75275028e-02f, -1.09452168e-02f, 1.36396408e-01f,
  1.34229334e-02f, 1.23335747e-02f, 6.67193756e-02f, -3.50696295e-02f, 7.89277181e-02f, -2.99590658e-02f, 8.59496519e-02f, -1.46835018e-02f, 4.55578975e-03f, -3.24551761e-02f,
  -2.13329438e-02f, -4.64274436e-02f, 5.93376942e-02f, 1.96281970e-02f, 5.39809316e-02f, 9.27938223e-02f, 1.05776072e-01f, 4.69683073e-02f, -5.40407281e-03f, 1.38981655e-01f,
  -1.31801963e-02f, 1.30730838e-01f, -6.12663589e-02f, -3.87358433e-03f, 5.98282777e-02f, -7.63528496e-02f, -7.10704774e-02f, 3.63307111e-02f, 1.22983046e-01f, -6.93675354e-02f,
  5.41940108e-02f, -4.09909971e-02f, 1.26025993e-02f, -9.75624844e-03f, 1.30124003e-01f, -1.07443370e-01f, -1.42223984e-01f, 4.99966741e-02f, 4.16482538e-02f, -4.39713188e-02f,
  -5.06617017e-02f, 5.83637916e-02f, -7.43201971e-02f, -4.77164723e-02f, -5.38594685e-02f, 1.34355240e-02f, -3.19942683e-02f, -1.02670118e-02f, -1.14910685e-01f, 6.62589818e-02f,
  1.70826659e-01f, 2.43267074e-01f, 5.77985682e-02f, -8.09351355e-03f, 4.99142427e-03f, -2.99128667e-02f, -5.93853241e-04f, 7.27021545e-02f, 2.36817867e-01f, 9.04342383e-02f,
  -2.26768502e-03f, 6.49418458e-02f, -2.49763150e-02f, -1.36573136e-01f, 8.57375655e-03f, 1.11787440e-02f, 2.06675436e-02f, 6.01837896e-02f, -2.47018188e-02f, -1.08270101e-01f,
  -1.31406277e-01f, 1.17951319e-01f, 8.60230029e-02f, 6.08174540e-02f, 8.41723308e-02f, -3.04951072e-02f, 3.91292237e-02f, 1.29705062e-02f, 9.93793365e-03f, 7.39858076e-02f,
  -1.64049834e-01f, -7.16088787e-02f, 7.03084543e-02f, 1.51473135e-01f, -1.05328128e-01f, -2.22782090e-01f, -2.45594084e-01f, -3.94903868e-02f, -6.91802353e-02f, -2.35499814e-01f,
  -6.23765253e-02f, 6.77786916e-02f, -2.09438384e-01f, 2.93136597e-01f, 3.18991393e-01f, -1.15358926e-01f, 1.98978111e-01f, 1.22219563e-01f, 1.81878418e-01f, 1.35617584e-01f,
  1.80548877e-01f, 1.89742848e-01f, 3.08924168e-01f, 2.94062257e-01f, 1.22163244e-01f, 1.07795246e-01f, 3.72026622e-01f, 1.87479556e-01f, 2.99864292e-01f, 1.36334807e-01f,
  -7.32602924e-02f, -4.65248786e-02f, -7.15468675e-02f, -3.98571230e-02f, -8.87287259e-02f, -1.00142665e-01f, -1.71284731e-02f, -1.84369236e-02f, 1.76295955e-02f, 9.25578177e-03f,
  3.44508654e-03f, 5.05586853e-03f, -4.01510634e-02f, 3.23815830e-02f, 6.55549169e-02f, 1.09957002e-01f, -3.05887908e-02f, -4.16034870e-02f, -2.31146738e-02f, -5.08172512e-02f,
  -2.33404711e-02f, -9.89343692e-03f, 1.84383225e-02f, 5.76146245e-02f, 6.60438985e-02f, -3.47619355e-02f, -1.24227367e-02f, -1.73775591e-02f, 6.50068298e-02f, 3.01164319e-03f,
  5.25089540e-02f, -5.34662828e-02f, -2.22186614e-02f, -7.46554881e-02f, -2.88700145e-02f, -8.68200660e-02f, -2.05099024e-02f, -3.57106440e-02f, 8.17050505e-03f, 2.04550214e-02f,
  -4.51624915e-02f, -4.26887833e-02f, -9.33106150e-03f, -3.83023620e-02f, 8.26519355e-02f, -1.08425818e-01f, 2.28120033e-02f, 1.31353438e-01f, -4.20276225e-02f, 1.71343684e-02f,
  -5.25963455e-02f, 1.01416066e-01f, 1.03369929e-01f, -2.77687833e-02f, -9.40091461e-02f, 8.22550058e-02f, 2.47103777e-02f, 2.23819036e-02f, -1.14565790e-02f, -1.08667249e-02f,
  6.15297817e-02f, 7.13103265e-02f, -5.39039895e-02f, -2.68013943e-02f, -3.93712930e-02f, -5.74411266e-02f, -1.94132328e-02f, 2.51248628e-02f, 7.97445476e-02f, 3.06767281e-02f,
  1.26218107e-02f, 1.42110875e-02f, 5.13837440e-04f, -1.01396451e-02f, 1.28603682e-01f, 1.15526989e-02f, 7.37749711e-02f, 8.41037482e-02f, 5.26757389e-02f, 6.25607446e-02f,
  2.46561579e-02f, -3.55046578e-02f, 6.80264235e-02f, -2.46670227e-02f, -4.87835035e-02f, -2.17050929e-02f, -3.22031863e-02f, -1.36321224e-02f, 5.01455627e-02f, 5.30210994e-02f,
  -2.00910196e-02f, -1.46747693e-01f, 2.65307933e-01f, -3.23846459e-01f, 1.99869052e-01f, 2.55065978e-01f, 1.21171497e-01f, -2.43843645e-02f, -2.10022956e-01f, -3.12822372e-01f,
  -1.35774091e-01f, -1.19380079e-01f, 1.57579422e-01f, -2.95948207e-01f, 3.38665932e-01f, 1.28710613e-01f, -7.27820247e-02f, -1.68386459e-01f, 5.23034781e-02f, 1.75930988e-02f,
  -1.86354183e-02f, -1.83784664e-01f, 2.70574450e-01f, -8.31626579e-02f, -9.04504210e-02f, -8.09169933e-02f, -1.49895281e-01f, 7.86635652e-02f, -1.28981709e-01f, 1.21401377e-01f,
  1.25313953e-01f, -1.21546753e-01f, 1.41819075e-01f, 3.31120715e-02f, 3.99328955e-02f, -7.63182789e-02f, 5.78792654e-02f, 4.76658121e-02f, -3.08538340e-02f, -1.25278294e-01f,
  -2.17564583e-01f, -6.13977723e-02f, -1.66722864e-01f, 1.11055464e-01f, -2.93400045e-02f, -9.67250168e-02f, -2.09573209e-02f, 1.59363985e-01f, 3.03630671e-03f, 7.29825273e-02f,
  4.19695899e-02f, -1.62721366e-01f, -1.97137650e-02f, -1.55260786e-01f, 2.61564385e-02f, -9.01912451e-02f, -2.54283790e-02f, -6.69279620e-02f, -9.19401199e-02f, -1.42020091e-01f,
  -1.32173616e-02f, 8.50916281e-02f, 2.66325790e-02f, 4.06260565e-02f, -1.89195555e-02f, -9.34115669e-04f, 1.19980341e-02f, -2.86225565e-02f, -2.84731947e-02f, 1.40534937e-02f,
  -4.78781462e-02f, 3.30410302e-02f, -3.95027809e-02f, -7.63513967e-02f, -6.40263632e-02f, -3.44620720e-02f, 2.96039879e-02f, 4.75298204e-02f, -1.41642645e-01f, 1.36998549e-01f,
  -5.51486872e-02f, 5.29169803e-03f, 4.12947722e-02f, -1.09360948e-01f, 1.49795413e-02f, -1.43113444e-02f, 1.44509804e-02f, -9.70030278e-02f, 7.81157091e-02f, 1.03650689e-01f,
  -6.96782023e-03f, -2.20890567e-01f, 3.82192433e-02f, -5.60997725e-02f, 3.21515650e-02f, -2.23982837e-02f, 5.12950718e-02f, -8.01014006e-02f, -7.14927688e-02f, 5.74312685e-03f,
  -7.74238706e-02f, -5.22196665e-02f, -6.05601668e-02f, 1.11195363e-01f, -7.92871695e-03f, 9.20243040e-02f, -1.18190348e-01f, 3.31309177e-02f, -5.56951016e-02f, -1.62425134e-02f,
  -2.92248302e-03f, -1.66682452e-01f, -7.96928629e-02f, -1.25430673e-01f, -1.50577307e-01f, -8.95636827e-02f, 2.46026944e-02f, -1.06201090e-01f, 9.70387086e-03f, -1.50530666e-01f,
  -2.26547077e-01f, -4.66896370e-02f, 6.93817437e-02f, 2.96340942e-01f, 9.49345976e-02f, -2.68133819e-01f, -2.32829750e-01f, 1.04945295e-01f, 5.70996031e-02f, -3.18230152e-01f,
  -8.55950564e-02f, -1.03944294e-01f, -2.20078751e-01f, 9.27931890e-02f, 2.51142710e-01f, -5.74795790e-02f, 2.64790088e-01f, -2.05983073e-02f, 2.14018553e-01f, 7.13076666e-02f,
  3.03082943e-01f, 8.57733563e-02f, 2.27960423e-01f, 2.38354295e-01f, 2.57333219e-02f, 1.47228420e-01f, 1.42258435e-01f, 1.51317909e-01f, 1.82494611e-01f, -7.90996403e-02f,
  2.14102026e-02f, -9.12363380e-02f, -1.02890155e-03f, -4.67556762e-03f, 6.47275448e-02f, -1.29812852e-01f, 6.04208037e-02f, 1.12787638e-04f, 7.42004812e-02f, 3.93706672e-02f,
  1.66363530e-02f, 9.70940813e-02f, 4.38808836e-02f, -9.39669274e-03f, -1.68338849e-03f, 2.22252458e-01f, 4.32175621e-02f, 1.18426345e-02f, 8.44887868e-02f, 2.47672442e-02f,
  6.76922500e-02f, 5.89685375e-03f, -1.05135590e-01f, 5.18407151e-02f, 1.86785474e-01f, 4.67673428e-02f, -4.14082557e-02f, -4.44461778e-02f, 9.82850511e-03f, -4.16227654e-02f,
  -6.03478141e-02f, 4.13763002e-02f, -3.77365872e-02f, -1.26036659e-01f, -7.75832012e-02f, 1.22502409e-02f, -2.67879181e-02f, -5.24892646e-04f, 4.30049971e-02f, -3.17299478e-02f,
  1.16193689e-01f, 7.12275803e-02f, 2.37239525e-02f, 4.34076339e-02f, 6.37393743e-02f, -1.57148883e-01f, 3.49030644e-02f, -4.05632611e-03f, -3.54519226e-02f, 2.06539929e-02f,
  -1.65669713e-02f, -8.12838506e-03f, 1.21609634e-02f, 6.89561516e-02f, 8.47375765e-02f, 5.95358387e-02f, -4.37219776e-02f, 7.15887919e-02f, -5.87079450e-02f, 2.00055148e-02f,
  2.19830144e-02f, 9.37042907e-02f, 9.39709879e-03f, 3.01284157e-02f, 9.57116932e-02f, -3.87485512e-02f, 6.16188198e-02f, 6.01797141e-02f, 6.63758293e-02f, -9.28453729e-02f,
  2.36878879e-02f, 1.17297858e-01f, -5.26620634e-02f, -2.97605544e-02f, 2.26219627e-03f, 8.75565633e-02f, 1.25594456e-02f, 7.48218298e-02f, 6.10819645e-02f, 5.15016019e-02f,
  7.29796216e-02f, -1.32456161e-02f, 7.17218369e-02f, 1.56909928e-01f, 2.39106845e-02f, -1.13506816e-01f, -8.16273913e-02f, -6.83062291e-03f, 9.53095313e-03f, 3.56988758e-02f,
  -2.27789313e-01f, 1.71933681e-01f, -3.49886984e-01f, 1.09397866e-01f, 6.41844869e-02f, -4.80814315e-02f, 1.56876236e-01f, 6.39859661e-02f, 1.02472126e-01f, 3.52326691e-01f,
  2.53133535e-01f, 1.37133822e-01f, 2.63845086e-01f, 3.15801233e-01f, -2.28758633e-01f, 1.43981827e-02f, 4.45149764e-02f, 1.85319677e-01f, 6.56436086e-02f, 1.66679472e-01f,
  -1.63804948e-01f, 2.48875111e-01f, -1.87766925e-02f, 9.50280875e-02f, -6.54546870e-03f, -2.42825925e-01f, -1.98534932e-02f, 1.34505872e-02f, 7.87215587e-03f, 9.58470846e-05f,
  9.02270153e-03f, 1.67248085e-01f, -5.07855043e-02f, -1.25040159e-01f, -9.81456861e-02f, -1.34735599e-01f, -1.45425379e-01f, -6.06594197e-02f, -5.73925935e-02f, 6.41774759e-03f,
  5.87588549e-02f, -3.38847004e-02f, 9.67018008e-02f, 2.54978575e-02f, 7.63873607e-02f, -2.30128933e-02f, -1.93953440e-02f, -7.11448640e-02f, 1.71004273e-02f, -4.69332188e-02f,
  -1.79356374e-02f, 3.82620725e-03f, -5.52686341e-02f, -1.15427136e-01f, -3.90144102e-02f, -7.25856796e-03f, 1.05131753e-02f, -2.87231989e-02f, -8.99967679e-04f, -2.08952799e-02f,
  -1.01844139e-01f, -7.16653094e-02f, -2.73752660e-02f, 4.87786755e-02f, -5.89867905e-02f, 1.10853957e-02f, 9.70897749e-02f, 5.98285906e-02f, -2.52325144e-02f, 1.94575861e-02f,
  4.78630625e-02f, 3.44182067e-02f, -7.40622729e-03f, 1.62676852e-02f, 3.11241555e-03f, 2.86666676e-03f, -4.60153632e-02f, -1.66159309e-02f, 2.83710919e-02f, -5.67471012e-02f,
  -6.75902218e-02f, -3.41172367e-02f, 5.82687631e-02f, 3.93016227e-02f, 1.02941900e-01f, -2.72646584e-02f, -3.27818803e-02f, 1.40025921e-03f, -4.43635993e-02f, 1.98730230e-02f,
  9.10274386e-02f, 9.86543670e-02f, 4.32016067e-02f, 2.10819561e-02f, -2.60551162e-02f, -2.48775054e-02f, -5.09929545e-02f, -6.62973076e-02f, 3.62898521e-02f, 1.80620328e-02f,
  -8.87920335e-02f, 6.58914521e-02f, -5.06812483e-02f, -4.17887000e-03f, 3.62975569e-03f, -9.55198309e-04f, 3.97792608e-02f, -2.62906626e-02f, 3.23838741e-02f, -8.84250477e-02f,
  -2.01134607e-02f, 5.58867492e-02f, 5.37663735e-02f, -2.66637001e-02f, 3.76332775e-02f, 4.42940835e-03f, -1.12319127e-01f, -2.05306076e-02f, 2.53096297e-02f, 5.72396219e-02f,
  -5.40300071e-01f, 1.29022628e-01f, -3.22649598e-01f, -1.16502158e-02f, 7.03356415e-02f, -1.53778985e-01f, 9.54900235e-02f, 1.21085010e-02f, -2.65930984e-02f, 3.44712883e-01f,
  1.65565595e-01f, -1.01334132e-01f, 1.76061064e-01f, 1.22125693e-01f, -4.21137303e-01f, 5.96673787e-02f, -1.16609298e-01f, 6.58033937e-02f, -6.57039136e-02f, -9.82176960e-02f,
  -1.19781792e-01f, 2.09251732e-01f, -5.52379563e-02f, 3.83527614e-02f, 1.30953193e-02f, -5.45831546e-02f, 2.40743607e-01f, 1.19005352e-01f, 6.09765835e-02f, 5.16679510e-02f,
  -6.08999729e-02f, 3.47841494e-02f, 3.91491354e-02f, -7.10276067e-02f, -1.61463305e-01f, -1.23766936e-01f, -1.73324160e-02f, 2.62456961e-05f, 4.58076186e-02f, -1.76236294e-02f,
  7.98215345e-02f, 7.56352991e-02f, -2.83304900e-02f, 1.39589580e-02f, 2.45442558e-02f, 9.26925018e-02f, -2.63339877e-02f, -5.52958064e-02f, 1.64207697e-01f, -9.73193198e-02f,
  4.20966931e-02f, -3.54663059e-02f, 6.23250566e-02f, 6.01462042e-03f, -6.58219978e-02f, 5.09255826e-02f, -1.02098463e-02f, -7.79297650e-02f, 2.57296488e-02f, -6.32188842e-02f,
  -3.81374210e-02f, -1.33910924e-01f, 8.34612399e-02f, 1.52463736e-02f, -8.24733153e-02f, 2.65465900e-02f, 1.37791425e-01f, 5.40879034e-02f, 1.96714811e-02f, -8.97784811e-03f,
  -6.46760166e-02f, 3.23418714e-02f, -6.45333901e-03f, 2.14919433e-04f, -1.75043028e-02f, -6.14753999e-02f, -5.27465604e-02f, 1.72319710e-02f, -1.55219927e-01f, -1.39251929e-02f,
  1.44111559e-01f, -3.52921337e-02f, 6.69140592e-02f, 4.99405116e-02f, 1.04530863e-01f, -1.27672255e-02f, -1.29080594e-01f, 6.07606210e-02f, -5.63474521e-02f, -6.29941300e-02f,
  -5.92228957e-02f, 8.87895226e-02f, 5.80409802e-02f, 2.85712611e-02f, 5.41288331e-02f, -6.59265229e-03f, -8.31575990e-02f, -3.16006541e-02f, 9.26800743e-02f, -1.80626288e-02f,
  3.47663201e-02f, 1.33122236e-01f, 2.18125456e-03f, -3.51201892e-02f, 5.12711331e-02f, -3.63458432e-02f, 3.90708409e-02f, -4.24936600e-03f, 1.98148608e-01f, -3.10554150e-02f,
  3.01237926e-02f, 1.06872417e-01f, 1.08254971e-02f, 2.18581557e-02f, -4.06118296e-03f, 9.37607139e-02f, -2.34940089e-02f, -2.16867845e-03f, 1.44503666e-02f, 7.31783137e-02f,
  1.11866102e-01f, -2.29817346e-01f, -1.52892724e-01f, -2.38209322e-01f, -3.10103167e-02f, -1.66452661e-01f, -1.19743727e-01f, -8.77533704e-02f, -7.82372802e-02f, 1.67295098e-01f,
  -1.91769376e-02f, -1.18124314e-01f, 9.08980295e-02f, -2.35671535e-01f, -2.61640102e-01f, -5.21354601e-02f, -3.69484603e-01f, -8.05976093e-02f, 1.07610121e-01f, -1.33073226e-01f,
  -5.93541600e-02f, 2.40532286e-03f, -1.91562757e-01f, 1.13806278e-01f, -7.74742514e-02f, 5.52853644e-02f, 1.64127246e-01f, 2.44182661e-01f, -7.95571730e-02f, 1.24156522e-02f,
  -7.39396960e-02f, 1.01332344e-01f, -1.53568164e-02f, 8.89542848e-02f, 3.60347107e-02f, 1.93012983e-01f, -3.33615988e-02f, -2.01250929e-02f, -1.41610159e-02f, -3.54859307e-02f,
  -5.49927838e-02f, -1.89150013e-02f, -8.99961870e-03f, 5.21010086e-02f, 1.14569366e-02f, 5.12868837e-02f, 2.67465562e-02f, -7.97375292e-02f, -5.69703020e-02f, 4.39157076e-02f,
  -5.90558797e-02f, -2.17188764e-02f, 1.40454154e-03f, -1.04873456e-01f, -1.15622371e-01f, -1.09055908e-02f, 1.29462844e-02f, -7.13735670e-02f, -1.02026261e-01f, 5.66846831e-03f,
  6.32869378e-02f, 1.04529358e-01f, 1.01928145e-01f, 1.36050479e-02f, 3.04990243e-02f, -4.01526950e-02f, -9.05916281e-03f, -1.16479406e-02f, -4.91167093e-03f, 2.60097608e-02f,
  -4.06214260e-02f, -9.94712934e-02f, 8.55415389e-02f, 8.12577782e-04f, 4.87796441e-02f, 5.82379550e-02f, 2.71562109e-04f, -6.08435944e-02f, -8.46419334e-02f, -2.10670948e-01f,
  7.14783818e-02f, 2.79559437e-02f, -1.05416775e-02f, -6.05587922e-02f, -6.74033165e-02f, 1.12188980e-01f, 1.38073206e-01f, 1.10628298e-02f, -6.12831675e-02f, -1.01294070e-01f,
  -1.49822325e-01f, 6.23032972e-02f, -5.75586222e-02f, -6.76795468e-02f, 1.13508431e-02f, 4.43111248e-02f, -1.69123486e-02f, -9.15083736e-02f, -7.00747073e-02f, 7.83049539e-02f,
  6.05181828e-02f, -2.81805359e-02f, 3.47145870e-02f, -1.42148361e-01f, -1.38969406e-01f, -4.74354364e-02f, 5.50269485e-02f, -7.63625056e-02f, -6.88902810e-02f, -1.34637002e-02f,
  5.63347451e-02f, 5.98791540e-02f, -1.94969960e-02f, 1.92114580e-02f, -3.01739089e-02f, 1.26508698e-02f, 5.92978485e-02f, 6.38052747e-02f, -5.79075478e-02f, -1.12562247e-01f,
  4.48940210e-02f, -1.56662658e-01f, 2.83131540e-01f, -4.47536968e-02f, 2.24391073e-01f, 2.54808187e-01f, 1.96521953e-01f, -1.65216267e-01f, -2.76926905e-01f, -3.00338328e-01f,
  -4.92822826e-02f, 1.56488091e-01f, 3.10893923e-01f, -1.08707048e-01f, 2.63406426e-01f, 1.44809693e-01f, -1.49479315e-01f, -9.95970331e-03f, -6.45448193e-02f, -1.25379413e-01f,
  -2.14109756e-02f, -1.09005146e-01f, 2.36205414e-01f, -2.25977927e-01f, 3.79817411e-02f, -4.94713187e-02f, -1.94464117e-01f, 1.83313295e-01f, -9.98114944e-02f, 2.72863284e-02f,
  -1.66083057e-03f, -2.05699980e-01f, 3.83268967e-02f, -4.25478723e-03f, -6.61547184e-02f, 1.31653860e-01f, -7.29511380e-02f, 1.37197450e-01f, 3.84527929e-02f, 5.39124347e-02f,
  4.34547514e-02f, 1.15120709e-01f, -2.14898530e-02f, 8.18287805e-02f, -9.21901688e-02f, 1.34862773e-02f, 3.90118361e-02f, 8.77114907e-02f, 8.27811807e-02f, 4.06167703e-03f,
  1.12937123e-01f, 1.57506466e-01f, -2.94731697e-03f, -1.01342807e-02f, 1.24436885e-03f, -9.30657331e-03f, -2.19587013e-02f, 1.66473031e-01f, 2.00817436e-02f, 1.18674152e-02f,
  -1.50082290e-01f, 4.15612943e-02f, 1.07606519e-02f, 6.14115857e-02f, 1.22026831e-01f, -4.88477275e-02f, -1.01781093e-01f, -6.09904760e-03f, 2.86656898e-02f, 4.29109484e-03f,
  2.04259008e-02f, 1.24390041e-02f, -1.56239286e-01f, 3.70513313e-02f, 2.90846638e-02f, 5.74506484e-02f, 5.50242960e-02f, 1.07574545e-01f, 1.72826685e-02f, -4.82721329e-02f,
  2.99857482e-02f, -6.47405833e-02f, -1.59342736e-02f, 1.08484052e-01f, 2.17695180e-02f, 1.22005589e-01f, -2.32520327e-02f, 7.00141937e-02f, 4.33318950e-02f, 2.11168174e-02f,
  -1.45051762e-01f, -2.61367798e-01f, -5.70243336e-02f, -5.82264625e-02f, -6.71139657e-02f, -1.65603552e-02f, -6.84836432e-02f, -7.91502520e-02f, 1.47174792e-02f, -1.20270923e-02f,
  8.19064602e-02f, 5.56507967e-02f, 5.13537526e-02f, 3.63986306e-02f, -1.12910897e-01f, -9.87255480e-03f, 1.28875583e-01f, -8.78665969e-02f, 1.54938744e-02f, -1.79148212e-01f,
  3.98817621e-02f, 1.03966773e-01f, -3.84361707e-02f, -3.29583436e-02f, -1.60212725e-01f, -5.88373393e-02f, 1.98853165e-02f, -8.63178968e-02f, 8.22329000e-02f, 4.34815474e-02f,
  2.78931350e-01f, 1.17805868e-01f, -3.25655401e-01f, -1.29608512e-01f, -7.50736967e-02f, 2.60194659e-01f, 2.44523644e-01f, 3.18353884e-02f, -6.00005575e-02f, 3.26868087e-01f,
  1.39279425e-01f, 8.57048184e-02f, 2.93997824e-02f, 3.42127502e-01f, 3.73514532e-03f, 1.84682384e-01f, 2.56657839e-01f, 1.99220985e-01f, 5.53875528e-02f, 1.30237013e-01f,
  -3.11536714e-02f, 3.33184600e-01f, -1.16045617e-01f, -7.20058456e-02f, 2.11980090e-01f, -2.87514895e-01f, -6.05514832e-02f, -1.35527149e-01f, 1.00530721e-01f, -1.40332570e-03f,
  3.05151548e-02f, -1.65056519e-03f, -3.92926997e-03f, 3.13772038e-02f, 1.09552676e-02f, 1.16159879e-01f, -3.96564230e-02f, -3.91345136e-02f, -4.37736809e-02f, 8.54258761e-02f,
  1.07661739e-01f, -1.98295116e-02f, 5.94219528e-02f, -5.09702601e-03f, 5.43424971e-02f, -9.92588103e-02f, 4.01504412e-02f, -6.64376915e-02f, 3.63431163e-02f, 1.06200695e-01f,
  2.70413533e-02f, 7.06294253e-02f, 1.37431100e-02f, -3.09228804e-02f, -1.22722194e-01f, 3.32312752e-03f, -6.42080186e-03f, -1.10250369e-01f, -5.35650924e-03f, 3.46747562e-02f,
  6.57235458e-02f, 5.09568304e-02f, 1.36038825e-01f, 8.95428881e-02f, -1.40024172e-02f, -8.97944868e-02f, -3.76292393e-02f, -7.28107467e-02f, -6.94022477e-02f, 4.42828201e-02f,
  -1.77793037e-02f, -9.35415030e-02f, 3.25131007e-02f, 1.65869836e-02f, 1.82899192e-01f, 1.76197216e-02f, -6.05473928e-02f, 9.02144983e-02f, -3.34842652e-02f, -9.10997465e-02f,
  2.49374788e-02f, 4.86460398e-04f, 4.05380949e-02f, -5.04540578e-02f, -7.56363105e-03f, -3.66738364e-02f, 8.92635807e-02f, 1.02697715e-01f, -1.21005036e-01f, 2.28854250e-02f,
  7.03767315e-02f, 5.98002672e-02f, -5.98952249e-02f, 2.69578192e-02f, -1.07368931e-01f, 1.42166629e-01f, 4.49877717e-02f, 6.34257048e-02f, -3.37159559e-02f, 7.85407946e-02f,
  -2.66340226e-02f, 1.33595048e-02f, 8.37637391e-03f, -1.12975709e-01f, -1.27612546e-01f, 1.03947017e-02f, 1.35025769e-01f, -6.59167767e-02f, -2.55760085e-02f, -4.84435149e-02f,
  -2.84130182e-02f, 1.21126689e-01f, -2.05770247e-02f, 3.85273397e-02f, -4.00787629e-02f, 1.71201881e-02f, -7.74164796e-02f, 2.28160508e-02f, -1.16827227e-02f, 8.02935194e-03f,
  4.48542655e-01f, -1.49785832e-01f, -1.63570836e-01f, 2.36933619e-01f, 3.01344156e-01f, 2.79589385e-01f, 2.97389720e-02f, 3.24388415e-01f, 2.97660500e-01f, -1.16734773e-01f,
  1.92795753e-01f, -1.50039151e-01f, -3.09159964e-01f, 2.55717099e-01f, 1.65278181e-01f, -1.61081210e-01f, 3.44083160e-01f, 9.90418717e-02f, 1.34302065e-01f, 1.39206633e-01f,
  2.30539292e-01f, 2.77596861e-01f, -1.69051677e-01f, 7.97597840e-02f, 1.71202838e-01f, -1.22862950e-01f, -3.47841755e-02f, -2.94027597e-01f, 1.46691486e-01f, 5.95987551e-02f,
  8.90852809e-02f, 6.36795685e-02f, -7.72667304e-02f, -4.15902957e-02f, 3.44743556e-03f, 5.21915480e-02f, -9.62887108e-02f, -4.48442288e-02f, 1.56629421e-02f, 8.11399221e-02f,
  -1.02455735e-01f, 3.51253077e-02f, 1.40362814e-01f, 5.45218550e-02f, 4.91396226e-02f, 2.20819801e-01f, 1.56681553e-01f, 2.85194777e-02f, 6.81749880e-02f, -2.95281895e-02f,
  -1.63555872e-02f, 1.54791703e-03f, 3.93438302e-02f, -5.15461713e-02f, -4.30410057e-02f, 9.71782506e-02f, 8.95233080e-03f, -1.31932184e-01f, 9.93022397e-02f, 6.95079267e-02f,
  -7.57770799e-03f, -1.73158482e-01f, 2.13580932e-02f, -3.18380855e-02f, 1.11203007e-02f, -9.08126961e-03f, 3.69445942e-02f, -1.15530360e-02f, 2.29647718e-02f, 3.48002985e-02f,
  5.46316057e-02f, 8.65119472e-02f, 8.99718478e-02f, 5.89369647e-02f, 3.81010287e-02f, 1.89595111e-02f, -4.19785343e-02f, 5.71216680e-02f, 3.30676846e-02f, -5.07174209e-02f,
  -1.82043649e-02f, 5.77046126e-02f, -4.30823583e-03f, -7.42831230e-02f, 2.29023695e-02f, 5.04505113e-02f, 4.05740254e-02f, 1.05212294e-01f, -6.43487722e-02f, -1.04558822e-02f,
  -1.28247783e-01f, -2.11806506e-01f, -1.57329738e-01f, 2.03690701e-03f, -8.94432440e-02f, 1.80333525e-01f, -4.53396440e-02f, 7.39960894e-02f, -3.21060345e-02f, 8.35091025e-02f,
  -3.11991442e-02f, -6.41710013e-02f, 1.10194325e-01f, 1.52776707e-02f, -5.68686239e-02f, 5.70532642e-02f, -1.25218168e-01f, -8.04027319e-02f, -6.31941184e-02f, 8.16320628e-02f,
  -5.10683469e-02f, 9.37295556e-02f, -6.60068616e-02f, 1.12089440e-01f, 3.96063924e-02f, -5.87151907e-02f, 8.17794073e-03f, 3.37298438e-02f, -3.44008319e-02f, 1.94926001e-02f,
  -1.79132581e-01f, -6.09324034e-03f, -2.87764490e-01f, -2.38108158e-01f, 8.69393721e-02f, -2.13687837e-01f, -1.71274349e-01f, -3.21430378e-02f, -2.02726610e-02f, 1.60102278e-01f,
  -8.57246965e-02f, -9.68964100e-02f, 6.57967180e-02f, -4.81602222e-01f, -4.44869667e-01f, -9.76282358e-02f, -3.74216169e-01f, -2.25684822e-01f, -5.81630170e-02f, -1.72592029e-01f,
  -1.11961395e-01f, -1.96490869e-01f, -2.72663683e-01f, 1.29339591e-01f, -1.42314419e-01f, 6.67728335e-02f, 3.12186092e-01f, 1.25911564e-01f, -6.30594194e-02f, -5.18582538e-02f,
  -1.81627393e-01f, -1.49966493e-01f, -5.07992916e-02f, -1.98980328e-02f, -6.01799376e-02f, -1.20024672e-02f, 4.37046550e-02f, 3.98505060e-03f, -1.88085195e-02f, -4.08317894e-02f,
  6.01182086e-03f, 5.73144481e-02f, -9.69602987e-02f, 3.72969024e-02f, 7.12768063e-02f, -8.21344629e-02f, -2.24875249e-02f, 8.44519660e-02f, -2.96752248e-03f, -1.05048701e-01f,
  -8.95881355e-02f, -3.12480852e-02f, -2.12319717e-02f, -4.48530569e-04f, -7.56196752e-02f, -2.18958221e-02f, -8.54840204e-02f, 4.18318845e-02f, -5.11160418e-02f, -8.25570598e-02f,
  2.11379044e-02f, -1.98894404e-02f, 4.33694199e-02f, -6.62170127e-02f, -4.05654125e-02f, 2.32066941e-02f, -2.38929652e-02f, 1.38824349e-02f, 8.53022709e-02f, -1.80054680e-02f,
  4.28008176e-02f, -1.05037928e-01f, -3.07170451e-02f, 7.26468861e-02f, -1.16095364e-01f, -7.99595490e-02f, -7.79302567e-02f, -2.12728279e-03f, -1.66519526e-02f, -4.44335602e-02f,
  6.84685186e-02f, -2.81102322e-02f, 7.02636391e-02f, 5.27191162e-02f, -1.53623194e-01f, 7.98419639e-02f, 1.09150209e-01f, -1.23101503e-01f, 1.05346076e-01f, 9.48303845e-03f,
  -1.32499868e-02f, 9.71528608e-03f, -6.59225211e-02f, 3.27931382e-02f, -2.80190958e-03f, 1.38588725e-02f, -1.10226788e-01f, -2.17389110e-02f, -6.67402754e-03f, 6.18172809e-03f,
  -2.63940240e-03f, 2.85447259e-02f, 1.62221491e-01f, 1.01118395e-03f, -1.32352989e-02f, -2.19641645e-02f, 8.38785172e-02f, 1.08666517e-01f, 1.22439347e-01f, 9.07379985e-02f,
  1.35444358e-01f, 1.39509924e-02f, -3.65386978e-02f, 2.14840602e-02f, 2.19771899e-02f, 7.75657967e-02f, 3.57693359e-02f, 7.34266192e-02f, -7.85201266e-02f, -2.97373235e-02f,
  1.84988543e-01f, -2.02122077e-01f, -1.74987726e-02f, 9.09148008e-02f, 2.65577305e-02f, -1.62358359e-01f, -3.52348715e-01f, 3.74830998e-02f, -2.30828911e-01f, -1.54208601e-01f,
  1.72412634e-01f, 4.65849303e-02f, -3.24715734e-01f, 3.91539186e-01f, 3.45908225e-01f, -1.54604003e-01f, 2.53086746e-01f, 2.87781715e-01f, -8.61046687e-02f, 9.62441340e-02f,
  1.53251112e-01f, 2.77232051e-01f, 1.22590505e-01f, 2.54051179e-01f, 9.95989218e-02f, 9.96703953e-02f, 2.38892898e-01f, 3.71268764e-02f, 3.34839642e-01f, 2.11329505e-01f,
  4.79449593e-02f, -3.20281349e-02f, -3.01672593e-02f, 6.52055219e-02f, -1.07684195e-01f, 1.44185154e-02f, 4.73362058e-02f, 1.46959335e-01f, 1.11966245e-02f, 2.39094775e-02f,
  6.81596473e-02f, 1.22341603e-01f, 4.01839726e-02f, -4.40942571e-02f, 1.94672067e-02f, 1.09686606e-01f, -5.49048446e-02f, -8.56520683e-02f, -1.14740103e-01f, -2.50649396e-02f,
  -1.41890347e-01f, 1.55250879e-03f, 2.04340853e-02f, 1.04874305e-01f, 1.60311330e-02f, -3.28622423e-02f, -7.63339028e-02f, -7.84163177e-02f, -2.75992695e-02f, -6.76882789e-02f,
  6.57717064e-02f, -1.76155567e-01f, -1.03730578e-02f, 5.79337217e-02f, -1.78646967e-01f, -1.41672196e-03f, 2.92876754e-02f, 1.88328642e-02f, -5.08587919e-02f, -5.51307946e-03f,
  4.59039807e-02f, 9.73870861e-04f, -4.50469553e-03f, -7.04984069e-02f, 4.64375578e-02f, -1.59998611e-02f, 1.20496899e-01f, 7.82925338e-02f, -9.34491381e-02f, -3.65085863e-02f,
  -4.54486646e-02f, 7.59398043e-02f, -4.44549508e-02f, 6.04590215e-02f, 9.03027505e-02f, 2.03260798e-02f, 6.94788545e-02f, 8.29358548e-02f, -4.20454443e-02f, 9.07365382e-02f,
  -3.26857306e-02f, -4.22694348e-02f, -4.66271527e-02f, -1.45142190e-02f, -2.50813202e-03f, 1.11022079e-02f, -2.40293592e-02f, 7.66619891e-02f, 1.02292396e-01f, -1.07640937e-01f,
  2.06508517e-01f, -3.79587859e-02f, -8.02311227e-02f, 1.78290121e-02f, 1.34040520e-01f, -6.41737357e-02f, -7.68645341e-03f, -6.64885715e-02f, 5.18833324e-02f, 6.47596344e-02f,
  3.99394743e-02f, -1.42904654e-01f, 5.93743287e-02f, -4.66264859e-02f, 5.22459410e-02f, -1.77142918e-01f, -8.52803737e-02f, -2.29260121e-02f, 2.19589621e-02f, 2.22671274e-02f,
  3.34191769e-01f, 6.06131032e-02f, 8.28583464e-02f, 1.27701208e-01f, -2.21032709e-01f, 1.47832659e-04f, 2.78322071e-01f, -3.58024448e-01f, -5.25153577e-02f, -1.25623003e-01f,
  -2.44159564e-01f, 3.32234442e-01f, 3.48654874e-02f, 3.21679190e-02f, 7.64620975e-02f, 6.15597926e-02f, -7.46133402e-02f, 1.45268187e-01f, 2.24328171e-02f, 3.14895362e-02f,
  -1.13067463e-01f, -1.19446985e-01f, 3.48255364e-03f, -2.22995862e-01f, 1.53322875e-01f, -2.49426998e-02f, -6.35744855e-02f, 5.79031371e-02f, 2.51271147e-02f, 6.13605529e-02f,
  3.03776804e-02f, -6.20725157e-04f, 1.09018460e-02f, 2.17967853e-03f, -3.97925489e-02f, 5.78481928e-02f, 1.03934981e-01f, 1.68239087e-01f, 3.33982408e-02f, -2.97235232e-02f,
  5.36481850e-02f, 1.44850492e-01f, -1.08882241e-01f, 1.26778051e-01f, 2.94760242e-02f, -3.19677442e-02f, 3.87533158e-02f, 3.00171673e-02f, -3.47899869e-02f, 7.63669163e-02f,
  1.40262946e-01f, -3.90720479e-02f, -2.99165637e-04f, -5.89487776e-02f, 9.40095447e-03f, -2.10192055e-02f, 3.15275565e-02f, 1.11042112e-01f, 5.02316393e-02f, 5.09364605e-02f,
  4.61178757e-02f, 1.44208089e-01f, 1.24354102e-02f, -5.99208847e-02f, 4.69788201e-02f, 4.22604121e-02f, 8.26822296e-02f, -6.43351302e-02f, -1.44834900e-02f, 7.00375661e-02f,
  -1.47773819e-02f, -4.53780331e-02f, -4.39359322e-02f, 9.73601360e-03f, 3.49920541e-02f, -7.49926940e-02f, 6.80857450e-02f, 6.80574849e-02f, -8.23958218e-02f, -1.93527602e-02f,
  1.16432086e-01f, 1.26623288e-01f, -2.97737159e-02f, -4.68497397e-03f, 1.07929654e-01f, 9.96223688e-02f, 6.32529380e-03f, 1.10994950e-01f, -8.95771086e-02f, -4.70705098e-03f,
  -1.43438742e-01f, -1.17454894e-01f, 2.16638632e-02f, 8.54633227e-02f, 6.85460716e-02f, 8.58854223e-03f, 3.79859731e-02f, 1.97024513e-02f, 5.56362011e-02f, -7.32374564e-02f,
  -5.51725551e-02f, 1.06230110e-01f, -8.87007117e-02f, 9.75262746e-02f, 1.01973355e-01f, -1.40246563e-02f, 7.74903968e-02f, 3.18719745e-02f, -5.16214594e-02f, -6.79858550e-02f,
  8.69277418e-02f, 1.50535300e-01f, 7.53693208e-02f, -1.75886881e-02f, 1.69139709e-02f, -2.44888775e-02f, -5.13953380e-02f, -1.49765974e-02f, 1.33518102e-02f, 2.58838646e-02f,
  2.99757838e-01f, -3.38435113e-01f, -5.31436913e-02f, 2.18691304e-01f, 3.49764645e-01f, 8.20585061e-03f, 1.38512924e-01f, 2.52026841e-02f, 7.47996867e-02f, -3.53270710e-01f,
  -6.12294041e-02f, -1.05739318e-01f, -1.54142767e-01f, 4.13446352e-02f, 2.03642100e-01f, -5.89829907e-02f, 1.41467422e-01f, -1.54075012e-01f, -5.36920130e-02f, -1.02565344e-02f,
  1.67983681e-01f, 2.11359411e-01f, 1.47803232e-01f, 7.59094208e-02f, 5.72187304e-02f, -2.97313146e-02f, 2.62800958e-02f, -9.88385305e-02f, 3.98111083e-02f, 1.30209297e-01f,
  -8.76755938e-02f, 8.56071040e-02f, 5.32394797e-02f, -4.84252498e-02f, -1.10826217e-01f, -3.05308960e-02f, -2.14148834e-02f, -4.88505140e-02f, -9.79989488e-03f, -6.82647079e-02f,
  -8.55126381e-02f, 2.59082043e-03f, 1.25811875e-01f, 5.56114167e-02f, 3.29539254e-02f, 6.72741607e-02f, -8.14685374e-02f, -2.96920026e-03f, -8.05634558e-02f, -1.65171232e-02f,
  2.15815380e-02f, -5.02991639e-02f, 7.11003989e-02f, -6.91859871e-02f, 3.79596860e-03f, 3.55744734e-02f, 6.73956424e-02f, 3.98652479e-02f, -5.33845415e-03f, 6.04048856e-02f,
  1.40834078e-01f, 1.34991795e-01f, 8.29899013e-02f, -9.31001753e-02f, -8.33240449e-02f, 1.50336046e-02f, 2.12104246e-02f, -1.27837092e-01f, -9.79414582e-02f, -2.79551875e-02f,
  -2.39370484e-02f, 1.66427255e-01f, 9.85105429e-03f, 5.74208330e-04f, 2.25189310e-02f, 6.10780418e-02f, -7.23501493e-04f, -1.37600139e-01f, -2.30923221e-02f, 1.09110452e-01f,
  3.79997343e-02f, -1.05341489e-03f, -9.20390263e-02f, -5.56364283e-02f, -6.55870512e-03f, -4.99560982e-02f, -8.39571208e-02f, -5.35658002e-02f, 8.20880756e-02f, -4.81060147e-03f,
  -4.49625522e-01f, -3.99090946e-01f, -4.67926934e-02f, -6.68080226e-02f, -1.65869489e-01f, -9.05373618e-02f, 8.14445317e-02f, -7.19473734e-02f, -1.43262029e-01f, -5.94688281e-02f,
  -2.17931420e-02f, 4.90582213e-02f, -1.12820156e-01f, 6.14916831e-02f, 2.44581755e-02f, -1.39839528e-02f, -1.29058465e-01f, -3.17877717e-02f, -2.95485072e-02f, -5.99035770e-02f,
  -7.01397955e-02f, -9.23837945e-02f, 3.13587673e-02f, 5.54913208e-02f, 4.93908636e-02f, 6.20083474e-02f, 2.25818194e-02f, 8.20520893e-02f, -1.61651913e-02f, 2.42978409e-02f,
  -3.62186283e-02f, 5.23732603e-02f, -2.30615959e-01f, -2.65143842e-01f, 5.96796272e-05f, -2.92103916e-01f, -2.07449794e-01f, -3.13728265e-02f, -2.79070325e-02f, 1.18639573e-01f,
  -6.60633901e-04f, -2.59893071e-02f, 1.52771890e-01f, -1.96343094e-01f, -1.82458431e-01f, 2.12361336e-01f, -4.54917878e-01f, -2.67488599e-01f, 1.06549792e-01f, -1.91859305e-01f,
  -1.12978250e-01f, -3.46346833e-02f, -1.07338034e-01f, 7.94387981e-02f, -2.08716005e-01f, -1.29499868e-01f, 3.82547155e-02f, 1.47794306e-01f, -2.08575726e-01f, 4.33163494e-02f,
  1.22791464e-02f, 1.20339811e-01f, 2.06400622e-02f, 1.54879577e-02f, -1.15199141e-01f, -6.55233935e-02f, -1.00760676e-01f, 2.76908390e-02f, 9.92328972e-02f, -1.23599004e-02f,
  -4.15327772e-02f, 1.55978762e-02f, -3.40869613e-02f, 1.06647708e-01f, -9.33251604e-02f, -1.29865611e-03f, 3.75141986e-02f, -6.26173541e-02f, -6.15327358e-02f, 1.80854835e-02f,
  -2.86362693e-02f, -1.59537438e-02f, -1.57066613e-01f, -5.46485446e-02f, -9.70412344e-02f, -6.18140623e-02f, -1.06874458e-01f, -1.20956659e-01f, -9.29684490e-02f, -9.24377516e-02f,
  -6.52106293e-03f, -3.39910388e-02f, -1.97241604e-02f, 5.94210848e-02f, 1.90237276e-02f, -5.20653725e-02f, 3.50751802e-02f, 3.24850939e-02f, 5.18367477e-02f, 1.15169899e-03f,
  -5.31653389e-02f, -3.67699228e-02f, 3.39613073e-02f, -1.02458537e-01f, -5.88508956e-02f, 9.20656137e-03f, 1.70910899e-02f, 2.04641167e-02f, -1.12757139e-01f, -2.92676520e-02f,
  1.29746929e-01f, -1.22616336e-01f, 4.43085320e-02f, -3.29308510e-02f, -5.62778078e-02f, 5.18572107e-02f, -5.82036749e-02f, 1.17672998e-02f, -1.73148084e-02f, -6.72596022e-02f,
  -9.40593481e-02f, -2.73952689e-02f, 1.15645966e-02f, 6.13823980e-02f, 8.95731151e-03f, -4.87583168e-02f, -1.05568968e-01f, -1.22465417e-01f, -4.53771353e-02f, 2.57084463e-02f,
  -1.23409078e-01f, -1.45435274e-01f, 5.50252339e-03f, 3.09571661e-02f, -1.13374569e-01f, -1.53873652e-01f, -8.03119317e-02f, 4.49718572e-02f, -4.51268703e-02f, -8.69916156e-02f,
  -3.10374871e-02f, -3.90636502e-03f, -3.88063937e-02f, -1.69030372e-02f, -1.05227679e-01f, -2.49861293e-02f, 2.37432942e-02f, 6.96628690e-02f, -6.20671548e-02f, -4.89821620e-02f,
  -3.36797237e-01f, 5.03057726e-02f, 2.89242357e-01f, -1.99395716e-01f, 4.69112806e-02f, 1.48707405e-01f, -9.44414958e-02f, 1.93630874e-01f, -2.37292692e-01f, 2.62574367e-02f,
  -6.60902411e-02f, -1.89228460e-01f, 4.19437140e-02f, -1.58784032e-01f, -1.15559392e-01f, -2.58762211e-01f, -5.37087843e-02f, -6.11988194e-02f, -1.13735378e-01f, 1.09541818e-01f,
  -3.82796638e-02f, -2.88812369e-01f, 8.80601034e-02f, 7.23311072e-03f, -5.15051931e-03f, 1.13100134e-01f, 2.05227539e-01f, 4.74807881e-02f, 1.22442544e-01f, -1.48601696e-01f,
  8.05521533e-02f, -5.92401065e-02f, 9.03066844e-02f, 2.66404394e-02f, 1.68990374e-01f, 1.70917772e-02f, 1.11526586e-01f, -7.37304389e-02f, -1.34810396e-02f, -1.20607316e-02f,
  9.09852237e-03f, 8.78255756e-04f, -1.14055134e-01f, -3.59068774e-02f, -1.39224278e-02f, 4.30758931e-02f, 9.60178599e-02f, 7.19167143e-02f, 7.34584928e-02f, -2.91337888e-03f,
  6.07561097e-02f, 2.54658516e-02f, -4.35456559e-02f, -6.86142668e-02f, 1.51139731e-02f, -6.32163184e-03f, 1.09786773e-02f, 1.13729239e-01f, -7.49024674e-02f, -3.28094736e-02f,
  -4.59494926e-02f, -1.08451396e-01f, -2.69074067e-02f, -5.71891069e-02f, -7.30892569e-02f, 4.64940704e-02f, -9.91091430e-02f, 4.36231541e-03f, -6.85781091e-02f, 8.60939324e-02f,
  1.43880385e-03f, 1.11988612e-01f, -5.12824990e-02f, -9.71247703e-02f, -8.98053125e-02f, -3.57322954e-03f, 1.32322963e-02f, 1.00365318e-01f, 9.87729523e-03f, 9.78060961e-02f,
  -2.97782738e-02f, -2.54387669e-02f, -3.74600962e-02f, 6.00779913e-02f, 4.56189690e-03f, -1.05689548e-01f, -5.36910817e-03f, -7.24724010e-02f, 2.61447653e-02f, -4.53085527e-02f,
  8.10479745e-02f, 9.22856554e-02f, 3.20718065e-03f, -2.07400043e-02f, -3.76190916e-02f, -2.56418693e-03f, 8.10871646e-03f, 3.52928750e-02f, -6.27238825e-02f, -2.86904983e-02f,
  1.21388391e-01f, -1.42578296e-02f, 1.90676888e-03f, -6.22334741e-02f, 2.11224705e-02f, 2.30095431e-01f, 1.50650442e-02f, -1.28771327e-02f, 7.41712227e-02f, 1.56387478e-01f,
  3.02483570e-02f, 5.15972311e-03f, -2.18735367e-01f, -1.30422667e-01f, 1.66982301e-02f, 2.08478216e-02f, 1.21517204e-01f, 5.54760471e-02f, -1.07795233e-02f, -6.86590672e-02f,
  -5.05263329e-01f, 2.84422189e-01f, 9.72359180e-02f, 1.99692503e-01f, -2.32767105e-01f, 5.19734062e-02f, -1.37786579e-03f, 3.66313234e-02f, 1.04712710e-01f, 1.84998006e-01f,
  -2.20548794e-01f, 2.32163537e-02f, -6.57682046e-02f, 1.60969496e-01f, -2.78115481e-01f, 1.62837654e-01f, 1.10398419e-01f, 6.98095039e-02f, -2.91652270e-02f, -5.56452833e-02f,
  8.29615518e-02f, -8.60965177e-02f, -2.51723956e-02f, 7.20084384e-02f, -4.33301739e-02f, -1.79878641e-02f, -2.89101124e-01f, -6.93531260e-02f, -5.21674827e-02f, -1.08427927e-01f,
  -1.94732308e-01f, -9.95795876e-02f, -1.54318631e-01f, -4.74332385e-02f, -9.14765894e-03f, -9.15338993e-02f, 7.77354762e-02f, -7.28422627e-02f, -6.83750659e-02f, -2.25052610e-02f,
  8.34291149e-03f, -3.19852680e-02f, -4.48106155e-02f, -1.11647718e-01f, -3.61176357e-02f, -4.17236565e-03f, 5.09146005e-02f, 5.68628637e-03f, -7.48883560e-02f, 5.37038930e-02f,
  4.43404652e-02f, 8.15806258e-03f, 6.02076985e-02f, -4.15833630e-02f, -8.44153166e-02f, -1.31243998e-02f, 5.49110845e-02f, 6.18374944e-02f, 4.12136503e-02f, -1.21176973e-01f,
  2.82974932e-02f, 4.01987731e-02f, -2.61444896e-02f, -1.78714097e-01f, 9.42581706e-03f, 1.91358775e-02f, -2.78391875e-02f, -1.35258302e-01f, 1.45060003e-01f, -3.83065082e-02f,
  -8.06264654e-02f, 2.75633503e-02f, 2.85984669e-02f, 2.44782958e-02f, -1.56338699e-02f, -5.03712781e-02f, 1.82447862e-02f, -8.71866122e-02f, 1.06409624e-01f, -8.52627680e-02f,
  -8.60877112e-02f, 3.38286906e-02f, -1.00301675e-01f, 1.07118867e-01f, 8.89452100e-02f, -2.59117968e-02f, 4.34568967e-04f, 4.07752134e-02f, -4.86002527e-02f, -5.17112389e-02f,
  -2.81273812e-01f, -1.72532439e-01f, -1.97989687e-01f, -1.87614053e-01f, 1.41381733e-02f, 7.62978510e-04f, 8.22363719e-02f, -2.80838143e-02f, 5.65643888e-03f, 4.75496203e-02f,
  -4.87668999e-02f, -1.42678926e-02f, 1.79650709e-02f, -5.21064214e-02f, 1.37849331e-01f, 1.57756023e-02f, 2.43159123e-02f, -1.37121859e-03f, -1.58803567e-01f, -8.00875649e-02f,
  -6.89458698e-02f, 7.17390329e-02f, -9.42686722e-02f, -6.20899312e-02f, -9.09325555e-02f, -9.98671800e-02f, 8.74480605e-02f, 6.01995410e-03f, -1.24203891e-01f, -4.82181199e-02f,
  2.08049849e-01f, 1.21501341e-01f, -1.41348258e-01f, -3.07775810e-02f, 6.87545314e-02f, 2.23574066e-03f, -1.79285500e-02f, -1.33769996e-02f, -3.51277500e-01f, 9.02833417e-02f,
  1.55396953e-01f, -5.96801750e-02f, -4.96099293e-02f, 2.40157902e-01f, 2.18779370e-01f, -4.23278920e-02f, 1.09411269e-01f, 8.47152472e-02f, 6.02034740e-02f, 1.12246856e-01f,
  8.37104991e-02f, 4.15079087e-01f, 3.08299437e-02f, 2.57355928e-01f, 1.89559579e-01f, -5.29344976e-02f, 2.43604928e-01f, -2.60593742e-02f, 1.61997497e-01f, 1.00550823e-01f,
  1.46635488e-01f, 6.83526248e-02f, -5.62949330e-02f, -9.94833186e-02f, 8.52352157e-02f, 1.00238405e-01f, -2.44562458e-02f, -4.98787165e-02f, -2.29724467e-01f, 5.30420057e-02f,
  -5.39366193e-02f, -6.16703220e-02f, 4.52091172e-02f, -8.25589299e-02f, -3.67616154e-02f, -6.56885207e-02f, -6.14886023e-02f, -2.05874056e-01f, -8.33243951e-02f, 5.65291680e-02f,
  -7.53373057e-02f, -8.04366544e-02f, -1.04244404e-01f, -5.83932698e-02f, -8.95067900e-02f, -1.13492548e-01f, -1.06796108e-01f, -1.88957565e-02f, 5.56613877e-03f, 8.18580240e-02f,
  1.08674742e-01f, 9.50720534e-02f, 4.44338806e-02f, -1.01975817e-02f, 9.46535692e-02f, -5.32079563e-02f, -2.39614788e-02f, -2.03234069e-02f, -1.21477909e-01f, 7.02854246e-02f,
  -7.61065781e-02f, 2.05583367e-02f, 3.48837189e-02f, -9.15056467e-02f, 7.05956891e-02f, 1.86597824e-03f, 5.78273721e-02f, 7.25478306e-02f, -8.31724554e-02f, 6.76272735e-02f,
  -9.51069742e-02f, -3.71853113e-02f, 5.71098290e-02f, -9.68779549e-02f, 4.58586439e-02f, -5.36041893e-02f, 1.36546507e-01f, 1.79191902e-02f, -2.69985781e-03f, -9.63529758e-03f,
  1.06739253e-01f, 2.36509472e-01f, -4.10253815e-02f, -5.06386682e-02f, -1.18888207e-02f, 8.75502899e-02f, -6.94778562e-03f, 5.17866239e-02f, -6.54604882e-02f, 1.91951990e-02f,
  -2.61698812e-02f, -1.19068392e-01f, 4.63556207e-04f, -7.16536120e-02f, -1.63376436e-01f, 6.08024001e-02f, 5.74202202e-02f, -1.12421133e-01f, -1.10251024e-01f, 2.07052365e-01f,
  -3.01799811e-02f, 1.39589114e-02f, -9.55973491e-02f, 5.19584678e-03f, -8.76912624e-02f, 5.09456657e-02f, -1.25109125e-03f, 8.97288695e-03f, 3.17460522e-02f, -1.18685044e-01f,
  -2.39479658e-03f, -1.03674173e-01f, -1.49056897e-01f, -2.25440741e-01f, -1.50750771e-01f, -8.03564414e-02f, -2.27096513e-01f, 3.56490985e-02f, 1.21302955e-01f, -6.95716888e-02f,
  -2.58678526e-01f, 1.53889656e-01f, -1.04693444e-02f, -3.82695794e-01f, 3.85297269e-01f, 9.51002985e-02f, -1.48144096e-01f, -8.70301053e-02f, 6.45134551e-03f, 4.02340889e-02f,
  -4.10646014e-02f, -2.67335296e-01f, -2.24743634e-01f, -1.97903484e-01f, -3.71515661e-01f, -1.81938663e-01f, -1.59852967e-01f, -2.85969079e-01f, -4.19893563e-01f, -1.51626617e-01f,
  -1.11235335e-01f, 3.80413122e-02f, -8.55378881e-02f, 1.12567898e-02f, -2.86886841e-02f, 1.49555830e-03f, -9.28657353e-02f, -5.96241355e-02f, -1.18783629e-02f, 2.44978350e-02f,
  7.29152933e-03f, 8.06240141e-02f, 4.85986136e-02f, 9.63480249e-02f, -1.26873478e-01f, -1.90887347e-01f, -8.86743292e-02f, -3.30454148e-02f, 9.44566913e-03f, -9.72751901e-02f,
  -3.93966809e-02f, 8.39574449e-03f, -1.46462470e-01f, 3.33187841e-02f, -1.76290318e-01f, -1.15384340e-01f, 1.57082811e-01f, -7.21198916e-02f, -9.54364464e-02f, 7.53110796e-02f,
  8.24626088e-02f, 3.59911807e-02f, -1.07916534e-01f, -4.34531011e-02f, 7.11193867e-03f, 3.78417075e-02f, -3.55363004e-02f, 3.72745469e-02f, -1.13590561e-01f, -8.26710090e-02f,
  -7.12544052e-03f, -1.36986757e-02f, -3.25168744e-02f, -3.77551466e-02f, 6.61587194e-02f, 7.92123973e-02f, -4.45164256e-02f, -1.36646643e-01f, 3.48599255e-02f, 1.95316270e-01f,
  1.30277798e-01f, 1.08798832e-01f, -1.39406756e-01f, -1.16098836e-01f, 3.48242298e-02f, -1.42361782e-02f, -5.68677559e-02f, -1.50004372e-01f, 2.44550835e-02f, -7.84619525e-02f,
  1.38514508e-02f, 5.41051999e-02f, -4.29658359e-03f, -1.76900439e-02f, -1.78901665e-03f, -3.68249379e-02f, -1.88861042e-02f, -1.08731508e-01f, 7.89256617e-02f, 9.47227105e-02f,
  -3.83130759e-02f, -1.89690478e-02f, 2.16371473e-02f, 1.88681670e-02f, 1.17594823e-01f, -6.15190566e-02f, 1.31478868e-02f, 9.02797803e-02f, 5.56954741e-02f, 2.83688493e-02f,
  -4.46373975e-04f, 5.77553809e-02f, 5.82213104e-02f, -7.97720179e-02f, 5.06991632e-02f, 1.08237360e-02f, 1.95607692e-01f, -9.81530175e-02f, 6.64254418e-03f, 5.17208315e-02f,
  -2.88181096e-01f, 8.07214826e-02f, 7.66991684e-03f, -8.09079781e-02f, -2.57323027e-01f, -4.80440781e-02f, -6.50992095e-02f, 1.57690093e-01f, 2.01092601e-01f, 3.66519153e-01f,
  7.81267658e-02f, 1.62242681e-01f, 2.30567485e-01f, 3.69350240e-02f, -2.19059438e-01f, 2.45759502e-01f, -1.17069699e-01f, 1.04778670e-01f, 1.52136693e-02f, -7.99492598e-02f,
  -3.16866785e-02f, -5.82127422e-02f, -2.84849137e-01f, -7.37996399e-02f, -1.61885321e-01f, -8.00068080e-02f, -1.77221045e-01f, -9.24268812e-02f, -1.89224467e-01f, -1.91361398e-01f,
  -2.00116530e-01f, 8.92668441e-02f, 9.35220271e-02f, 5.78298047e-02f, 2.04662196e-02f, 6.80532157e-02f, 3.83835323e-02f, 1.12834026e-03f, 5.22580333e-02f, -1.56040918e-02f,
  4.26514223e-02f, 1.17748939e-02f, 8.75678062e-02f, 2.15613041e-02f, -7.35527799e-02f, 2.24541221e-02f, -2.26669777e-02f, -1.27460733e-01f, 5.36132082e-02f, -6.43878896e-03f,
  -1.02854269e-02f, -4.05658521e-02f, -1.18688419e-01f, -3.86250280e-02f, -9.01948139e-02f, 2.83980872e-02f, -8.71426240e-02f, -2.88406815e-02f, -1.20810114e-01f, -1.40078172e-01f,
  4.02235314e-02f, 1.15927123e-02f, 4.54594009e-02f, 2.33662054e-02f, -7.64198974e-02f, -1.49986342e-01f, 5.97694442e-02f, -9.98000354e-02f, 4.10137065e-02f, 2.29086615e-02f,
  -9.47313290e-03f, 4.07950394e-02f, -2.14961413e-02f, 1.74956513e-03f, -1.52131379e-01f, 5.56220822e-02f, 8.20136070e-02f, -6.37949929e-02f, -7.90887922e-02f, -9.37758461e-02f,
  -3.54038551e-03f, -1.17840660e-04f, 9.33088213e-02f, -5.19517399e-02f, 6.43217117e-02f, -1.26191586e-01f, 5.13672177e-03f, 8.22254177e-03f, 6.06637299e-02f, -8.79139900e-02f,
  -3.03884715e-01f, -2.19062567e-01f, 2.43199039e-02f, 4.32348661e-02f, -2.60244366e-02f, 2.05352530e-02f, -4.96005733e-03f, 2.02932376e-02f, -6.56082034e-02f, 4.89642005e-03f,
  -1.40134588e-01f, 9.34962481e-02f, -9.58503261e-02f, -4.72138040e-02f, 1.64578818e-02f, -1.01281248e-01f, -3.53210866e-02f, -1.01643957e-01f, -1.94754034e-01f, -6.85839355e-02f,
  -1.74244680e-02f, 4.63849679e-03f, -1.26496563e-02f, -2.17146557e-02f, 5.53034283e-02f, -3.38644050e-02f, -3.05522140e-02f, 1.27779797e-01f, -1.59042656e-01f, 4.95282859e-02f,
  1.15240186e-01f, -1.29943803e-01f, -3.22595745e-01f, 1.22059742e-02f, -8.06275681e-02f, 2.39830032e-01f, 3.87953132e-01f, -1.81715488e-01f, -2.40317643e-01f, 2.05889791e-01f,
  4.34389770e-01f, -2.02088486e-02f, 3.91937286e-01f, 4.09461498e-01f, 1.65137246e-01f, 3.32455218e-01f, 1.39700487e-01f, 1.81206614e-01f, -1.84167288e-02f, -1.35113671e-01f,
  -9.56014171e-02f, 3.17299515e-01f, 2.24981919e-01f, -2.52672076e-01f, 1.92011654e-01f, -2.17696071e-01f, 1.81318417e-01f, 6.20507449e-02f, 2.05273017e-01f, 2.59474702e-02f,
  1.37057915e-01f, 4.06382568e-02f, -2.02672724e-02f, -2.73034424e-02f, 5.48733398e-03f, 3.94442724e-03f, 6.75470605e-02f, 2.67816056e-02f, 9.32172779e-03f, 8.18343088e-02f,
  -3.25483852e-03f, -1.02348857e-01f, -1.94277521e-02f, -1.01170823e-01f, -1.07791722e-01f, -7.29110911e-02f, -1.05642855e-01f, -6.90944642e-02f, -3.37564126e-02f, 8.24891701e-02f,
  2.48125736e-02f, 1.04914606e-03f, 6.30148649e-02f, -1.00091830e-01f, 7.61205424e-03f, -5.13398685e-02f, -4.40292545e-02f, 1.61849726e-02f, -5.77758737e-02f, -6.98548555e-02f,
  -1.05180917e-02f, 9.54358801e-02f, 3.33813131e-02f, 3.51493433e-02f, 1.31213106e-02f, -1.38690183e-02f, 6.87325895e-02f, 3.91104333e-02f, -7.47302771e-02f, 4.64931242e-02f,
  -3.53384353e-02f, -6.39153048e-02f, 1.46073699e-02f, -3.79926860e-02f, 1.11782126e-01f, -8.52730032e-03f, 6.01075031e-02f, 3.80130820e-02f, -3.49849532e-03f, 4.44777030e-03f,
  3.20508704e-02f, 4.33689877e-02f, 6.56070858e-02f, 5.48145622e-02f, 2.38351971e-02f, 3.81373949e-02f, 9.91473254e-03f, 1.96830090e-02f, -3.40269133e-03f, 2.47763880e-02f,
  1.02717513e-02f, -1.94832057e-01f, -5.97766414e-02f, -4.05706316e-02f, -2.09174585e-02f, 4.28114608e-02f, -4.13251296e-02f, -1.01931125e-01f, -7.36947209e-02f, -3.90090458e-02f,
  -5.49546815e-02f, -9.01049078e-02f, 6.65846048e-03f, -1.42647982e-01f, -6.60784990e-02f, -2.73866169e-02f, 5.99838421e-02f, -1.21695116e-01f, -8.63484815e-02f, -5.92555627e-02f,
  -2.38899868e-02f, -4.07907821e-04f, -2.93041579e-02f, -4.18129414e-02f, -1.13341652e-01f, 6.52025491e-02f, -5.17419465e-02f, 3.96693731e-03f, -9.04659089e-03f, 7.85616878e-03f,
  -6.20692521e-02f, 6.30555674e-02f, 2.86100954e-01f, 2.06594288e-01f, 2.02619359e-01f, -2.31086642e-01f, -1.82228133e-01f, 2.91707397e-01f, 2.82671869e-01f, -2.84456879e-01f,
  1.65022183e-02f, -2.23244399e-01f, 4.10184562e-02f, -3.86854149e-02f, -4.39429246e-02f, 9.35606062e-02f, -1.31111711e-01f, -1.11180857e-01f, 6.11166935e-03f, 9.38988943e-03f,
  3.16406600e-02f, -1.00397624e-01f, 1.08130820e-01f, 1.47956848e-01f, 1.13177061e-01f, 1.52278125e-01f, 7.41080567e-03f, 4.00771126e-02f, -1.32990822e-01f, -5.41462153e-02f,
  8.55607614e-02f, 1.68139488e-01f, 1.01408496e-01f, 6.09517992e-02f, 1.29761741e-01f, -2.02797025e-01f, -1.38886094e-01f, -9.36402604e-02f, 7.75603205e-02f, -2.41039433e-02f,
  -7.84829259e-02f, -2.04232663e-01f, -3.76019627e-02f, 5.58363311e-02f, 5.91329969e-02f, 1.21982262e-01f, 7.79888481e-02f, 6.32998049e-02f, -6.13850867e-03f, -4.64060418e-02f,
  -6.55124150e-03f, -1.92464702e-02f, -8.08237940e-02f, -9.99302864e-02f, 9.14898366e-02f, 1.27777010e-01f, -5.58335856e-02f, -1.62278507e-02f, 9.13541857e-03f, -1.63750090e-02f,
  -5.82971387e-02f, 1.65668912e-02f, 1.25752389e-02f, 6.00810349e-02f, 4.70313244e-02f, 8.79719779e-02f, 4.16258797e-02f, -4.93399873e-02f, 9.91307050e-02f, -1.54135466e-01f,
  -4.26346995e-02f, 9.30885822e-02f, 3.06629818e-02f, -1.04797006e-01f, -1.56492651e-01f, 4.44444492e-02f, -1.18358612e-01f, 3.59332226e-02f, -6.00428097e-02f, 1.96360737e-01f,
  1.15532979e-01f, -2.18334660e-01f, -6.56675249e-02f, 7.26243109e-02f, -6.38621077e-02f, -6.35906472e-04f, -4.30196300e-02f, -6.28096238e-02f, 1.19110487e-01f, 4.42320928e-02f,
  1.16773441e-01f, 4.86562997e-02f, 1.17099993e-01f, -5.01717143e-02f, 4.81170751e-02f, -1.15376703e-01f, -7.34889507e-03f, 2.08781995e-02f, 2.40311325e-01f, -7.16008544e-02f,
  -8.23631361e-02f, -1.25877365e-01f, -9.52468589e-02f, 6.40232265e-02f, 6.29007593e-02f, 6.88446164e-02f, -1.07168242e-01f, -6.99370354e-02f, 9.39653367e-02f, -1.67268533e-02f,
  -1.03939094e-01f, -9.30635855e-02f, 2.60760710e-02f, -5.21066748e-02f, -1.41158160e-02f, -3.24504524e-02f, -2.02717399e-03f, -2.87288707e-02f, -2.44267769e-02f, -1.25318961e-02f,
  3.68651778e-01f, -4.60262626e-01f, -6.56839982e-02f, 3.46858591e-01f, 2.73937047e-01f, 3.29614244e-02f, 1.78664699e-01f, -1.10158838e-01f, 1.77782670e-01f, -3.05159926e-01f,
  1.51621401e-01f, -1.18072644e-01f, -1.10547975e-01f, -1.03571936e-01f, 2.50661671e-01f, -1.93517804e-01f, 6.12934567e-02f, -2.33889613e-02f, -7.73720909e-03f, 8.60190243e-02f,
  2.85057992e-01f, 6.22597225e-02f, 8.06951821e-02f, -1.42318517e-01f, 7.80223832e-02f, -1.86230108e-01f, 9.18902643e-03f, -3.20189893e-02f, -8.22486430e-02f, 7.33739734e-02f,
  1.10954558e-02f, -1.44438902e-02f, 1.57268178e-02f, 3.99364810e-03f, -1.03615567e-01f, -3.69318277e-02f, 6.39167940e-03f, -4.88264561e-02f, 1.63808152e-01f, -6.05578348e-02f,
  1.99003965e-02f, -5.37726283e-03f, -7.72260502e-02f, 1.07856520e-01f, 9.01966467e-02f, 6.09791093e-02f, 5.79966325e-03f, 9.26136822e-02f, -5.20059168e-02f, -2.20014304e-02f,
  4.83994409e-02f, -1.73775703e-02f, 1.34470165e-01f, -4.88986075e-02f, -3.82029675e-02f, -1.09533817e-02f, -1.32256612e-01f, -6.85351528e-03f, 5.43500446e-02f, 1.74492132e-02f,
  -1.00215606e-01f, 5.55176474e-02f, -2.01333016e-02f, -8.15538466e-02f, 1.88478231e-02f, -1.26724988e-02f, 1.05937108e-01f, -1.18025452e-01f, 6.02934044e-03f, 2.37390362e-02f,
  1.03179902e-01f, 3.70718911e-02f, -3.97522114e-02f, 1.16950147e-01f, -4.91565168e-02f, -2.63774246e-02f, 3.27066369e-02f, -1.53687686e-01f, 4.80889641e-02f, -2.27803644e-03f,
  -4.48696129e-03f, 6.88171163e-02f, -6.91441670e-02f, 1.42884636e-02f, -6.20021531e-03f, 7.84854740e-02f, -2.52298489e-02f, -2.47371644e-02f, 4.13771756e-02f, 7.59153962e-02f,
  -2.89220084e-02f, -4.32368129e-01f, 1.69772480e-03f, 1.57926325e-02f, -7.62876347e-02f, 1.76097769e-02f, 5.17434552e-02f, -7.10112453e-02f, 3.21672596e-02f, -4.99904044e-02f,
  3.85387577e-02f, 1.16591044e-01f, -3.08547169e-04f, 8.59895051e-02f, 1.49189502e-01f, -9.58080813e-02f, -7.78360516e-02f, 7.11032823e-02f, 9.22778249e-03f, -9.18357447e-02f,
  6.30722269e-02f, 2.06348840e-02f, 9.91961434e-02f, 9.08686146e-02f, -6.09932058e-02f, -1.50949964e-02f, -1.37287751e-01f, 2.77849082e-02f, -4.05430943e-02f, 1.06197789e-01f,
  1.47270530e-01f, -3.33043844e-01f, -9.68550816e-02f, -7.32985958e-02f, -1.75449010e-02f, -1.07623465e-01f, -3.60393934e-02f, -2.59793639e-01f, 1.87973022e-01f, -1.97185576e-01f,
  -1.79340944e-01f, 1.52480885e-01f, 8.09377432e-02f, -3.14196408e-01f, 3.80479634e-01f, 1.37905955e-01f, -5.44821173e-02f, 1.73698775e-02f, 1.56638883e-02f, -1.77727237e-01f,
  6.63509071e-02f, -3.24825108e-01f, -1.29204959e-01f, -1.71769232e-01f, -2.37370774e-01f, -1.30592838e-01f, 1.69816369e-03f, -2.87157372e-02f, -9.90149975e-02f, -4.14121803e-03f,
  -5.65099418e-02f, 2.25044135e-02f, -1.78506419e-01f, -7.26671517e-02f, -1.28867015e-01f, 3.46702081e-03f, 8.02935585e-02f, 4.05319296e-02f, 1.04285657e-01f, 5.54242579e-04f,
  4.93477359e-02f, 1.53856903e-01f, 3.75131182e-02f, 3.96206491e-02f, -6.66325316e-02f, 7.41637545e-03f, 3.75252627e-02f, -1.72775965e-02f, -1.20672397e-01f, -1.03268147e-01f,
  -7.68693611e-02f, 4.08443101e-02f, -1.36243492e-01f, 7.06385449e-02f, 7.16509372e-02f, -4.93073501e-02f, 7.87834749e-02f, 4.33653444e-02f, 3.77780795e-02f, 8.77708346e-02f,
  -8.93405974e-02f, 1.43496841e-01f, 2.39470527e-02f, -5.54687828e-02f, 3.60184200e-02f, -4.10631634e-02f, -3.43298018e-02f, 3.06980796e-02f, 5.12816347e-02f, -1.44024357e-01f,
  1.50241330e-02f, -1.01601318e-01f, -3.26718166e-02f, 1.45099089e-02f, -4.64922041e-02f, -5.98211132e-04f, -2.27586497e-02f, 3.90987881e-02f, -2.82740891e-02f, -1.10085331e-01f,
  -1.68722251e-03f, 9.48519409e-02f, -7.62245804e-02f, -8.62067714e-02f, -7.26538748e-02f, 3.80845964e-02f, 6.61199540e-02f, 1.75143022e-03f, -1.11838594e-01f, -1.05812214e-01f,
  -2.14233659e-02f, 3.09045538e-02f, -7.57091939e-02f, -9.40764621e-02f, 1.81636456e-02f, 1.79122447e-03f, 1.70320775e-02f, -7.71024972e-02f, 7.08857328e-02f, 2.46817954e-02f,
  7.35730678e-03f, 5.51694334e-02f, 6.70994148e-02f, 6.86887354e-02f, 9.09462292e-03f, -1.00314498e-01f, 6.44975305e-02f, 9.36294124e-02f, 4.11068201e-02f, -1.13188758e-01f,
  -6.92511126e-02f, 1.23996995e-01f, 7.36777633e-02f, 7.46148303e-02f, -6.16586395e-02f, -5.07613234e-02f, 7.92123079e-02f, -3.79343405e-02f, 5.82357608e-02f, 1.38845965e-01f,
  -5.58199346e-01f, 1.60809129e-01f, 1.32167071e-01f, -5.03907837e-02f, -2.11954311e-01f, 2.67874897e-01f, 3.99322324e-02f, 1.56193808e-01f, 1.41136125e-01f, 1.33423477e-01f,
  2.28938367e-02f, -1.76238567e-01f, 1.63793981e-01f, 1.13861375e-01f, -3.98425907e-02f, 1.87663347e-01f, 4.04864363e-02f, 3.53194699e-02f, 1.27011910e-01f, -1.65159881e-01f,
  -8.46948326e-02f, -4.30934802e-02f, -1.22205773e-02f, 8.48263502e-02f, -2.16822386e-01f, -1.00714937e-01f, -1.65509745e-01f, -3.54397930e-02f, -1.25007033e-01f, -9.66645479e-02f,
  -2.59969652e-01f, -1.14013262e-01f, -7.50756413e-02f, 6.28264546e-02f, -1.32104829e-01f, 1.15114404e-02f, 3.35489362e-02f, -8.98289215e-03f, 1.50956707e-02f, 4.70979884e-02f,
  -1.25495628e-01f, 1.03856869e-01f, -6.32321984e-02f, 1.18217021e-01f, 6.72099460e-03f, 4.19172905e-02f, 3.50608081e-02f, 1.05774519e-03f, 3.09908465e-02f, 1.13501251e-01f,
  6.03349023e-02f, 1.07220687e-01f, 7.10845292e-02f, -3.67688909e-02f, -1.29303306e-01f, 3.36488113e-02f, 6.50110468e-02f, -2.78176554e-02f, -5.21118566e-02f, -2.14123186e-02f,
  7.37015009e-02f, 1.81682274e-01f, 9.98269022e-03f, -1.24602914e-02f, -5.24238385e-02f, -1.31895080e-01f, -1.88116990e-02f, -1.17669947e-01f, 5.38790002e-02f, 4.32697274e-02f,
  -1.00461759e-01f, -9.28785466e-03f, -3.76103744e-02f, 1.19321518e-01f, -7.19441548e-02f, -3.68920788e-02f, 3.59123647e-02f, -3.26823592e-02f, 8.18471145e-03f, -4.67616804e-02f,
  -4.53519402e-03f, 6.65441230e-02f, -2.16778158e-03f, 2.57551447e-02f, -2.88074799e-02f, 2.47490332e-02f, 1.69480681e-01f, 4.17901799e-02f, -3.68781202e-02f, -1.23295337e-01f,
  -3.14520389e-01f, -1.97527975e-01f, -6.39026538e-02f, -2.39340905e-02f, 2.37843189e-02f, -8.61345790e-03f, 1.13869049e-02f, -1.57094784e-02f, 4.43356074e-02f, -4.19892184e-02f,
  -2.52195615e-02f, -1.06098307e-02f, -3.16745825e-02f, 6.59975782e-02f, 7.87047483e-03f, -2.61902157e-02f, -6.08889014e-02f, -5.50933145e-02f, -2.16433227e-01f, -5.95686324e-02f,
  -4.51206975e-02f, -1.34209543e-02f, -3.01614646e-02f, -7.67471492e-02f, -2.81342566e-02f, -1.11665828e-02f, 3.17477100e-02f, -2.49705072e-02f, -1.67246088e-02f, 4.69976515e-02f,
  -4.99949396e-01f, 4.52479690e-01f, 4.17097695e-02f, -3.21387887e-01f, 2.37790436e-01f, -5.93038090e-02f, -1.47968426e-01f, 9.67807323e-02f, -1.74386412e-01f, 3.59823219e-02f,
  -8.36244151e-02f, 1.33432940e-01f, 2.73963418e-02f, -1.06693126e-01f, -3.21360499e-01f, 2.60009943e-03f, -3.16163659e-01f, -1.93140641e-01f, -9.81168263e-03f, -4.50545587e-02f,
  -3.40381800e-03f, -2.03709695e-02f, -4.46092635e-02f, 2.23153889e-01f, 6.77393898e-02f, 6.92310557e-02f, -1.36128485e-01f, 1.94077730e-01f, -1.03930570e-01f, 1.77750170e-01f,
  -1.04375072e-01f, 4.76005040e-02f, -1.24307208e-01f, 2.75625866e-02f, -1.20593823e-01f, -2.55805254e-02f, 2.81108990e-02f, -1.55661525e-02f, 1.81582607e-02f, 1.71098001e-02f,
  -5.05577493e-03f, 8.84736478e-02f, -4.83250394e-02f, -6.47091074e-03f, 5.83271757e-02f, 4.94185872e-02f, 1.54932529e-01f, -1.17466569e-01f, 7.91890472e-02f, 1.13399141e-01f,
  5.60136847e-02f, 4.91204113e-02f, 6.72151893e-03f, 1.66285208e-05f, 6.71196952e-02f, -7.05932006e-02f, -1.06550872e-01f, -5.19085042e-02f, 2.37794481e-02f, 3.83041762e-02f,
  1.81917585e-02f, -1.30433291e-01f, 7.78602287e-02f, -2.44687516e-02f, 3.18817683e-02f, -4.00952529e-03f, 7.86546618e-02f, -5.98040922e-03f, 4.16768230e-02f, -4.31416556e-03f,
  -5.39473742e-02f, 4.15544882e-02f, 1.01970859e-01f, -5.64405322e-02f, -1.31159082e-01f, -7.95590356e-02f, 1.13165788e-01f, -7.83491656e-02f, 6.28593704e-03f, -3.47316675e-02f,
  5.35927452e-02f, 1.07324474e-01f, 4.26649824e-02f, -1.94965433e-02f, 2.82462295e-02f, 6.71922863e-02f, -1.17395110e-02f, 1.85800400e-02f, -6.52901754e-02f, -4.19441201e-02f,
  -3.09858501e-01f, -1.74026489e-01f, -1.49506554e-01f, 3.79481316e-02f, -7.69918710e-02f, -3.32078561e-02f, 4.16621156e-02f, 1.76440307e-03f, -4.43016551e-02f, -2.16866937e-02f,
  4.85966261e-03f, -5.09088188e-02f, -4.84381095e-02f, -5.63514866e-02f, -1.77755672e-02f, -1.13245547e-01f, -1.06170341e-01f, -7.19012246e-02f, -2.66692284e-02f, -1.82514172e-02f,
  -7.83983469e-02f, -4.18959595e-02f, 1.44690908e-02f, 2.31607426e-02f, -1.50889292e-01f, -6.26615584e-02f, -1.29537592e-02f, 4.21751402e-02f, -1.52488332e-02f, 1.18263304e-01f,
  1.41211763e-01f, 3.46080184e-01f, 1.49571955e-01f, 2.19804645e-02f, -2.11652398e-01f, -1.63269788e-01f, -1.77061304e-01f, 6.76883385e-02f, 2.63873339e-01f, 1.52677849e-01f,
  -1.38326690e-01f, 4.79262233e-01f, 6.40745228e-03f, -5.05055599e-02f, -1.54504374e-01f, -1.34926096e-01f, -1.44766718e-01f, -1.30406786e-02f, 1.42044589e-01f, -3.04100085e-02f,
  -6.63696453e-02f, -2.93178886e-01f, -1.79664329e-01f, -9.52692628e-02f, -1.07920721e-01f, 5.02636172e-02f, -2.61488706e-01f, -4.51365858e-02f, -4.83675860e-02f, 1.01291455e-01f,
  6.32164255e-02f, -9.17867124e-02f, 6.75612614e-02f, 5.93346171e-02f, -7.70683959e-02f, 4.13803570e-02f, -6.50983602e-02f, 3.92649993e-02f, 1.35114146e-02f, 3.62436771e-02f,
  7.07981363e-02f, -4.08758819e-02f, 1.18894458e-01f, -6.14917744e-03f, 2.26611011e-02f, 7.22306222e-02f, 1.31791225e-02f, 6.18655309e-02f, 1.36301160e-01f, 3.17425169e-02f,
  5.03303744e-02f, 8.94976705e-02f, 3.74381170e-02f, 6.23855144e-02f, -5.56172654e-02f, -6.59113973e-02f, -3.26602883e-03f, -1.37283862e-01f, 2.38380898e-02f, 6.46454915e-02f,
  -9.66295227e-02f, -8.12164396e-02f, 2.62696892e-02f, -1.38932997e-02f, 3.09650246e-02f, -2.38426812e-02f, 9.41958353e-02f, 1.36960868e-03f, 9.53489076e-03f, -4.81834859e-02f,
  -5.56152537e-02f, -5.77241462e-03f, -8.79452825e-02f, 4.73815575e-02f, -6.10846058e-02f, -3.11509259e-02f, 1.51182187e-03f, -2.07432522e-03f, -3.07203848e-02f, -3.02952100e-02f,
  -3.45028304e-02f, -8.70500579e-02f, 1.24564745e-01f, -5.66500574e-02f, 6.02271333e-02f, 1.88848563e-02f, -5.61447442e-03f, 1.04795165e-01f, 9.47165638e-02f, -6.36220872e-02f,
  -9.84657109e-02f, -2.16591880e-01f, 1.93868740e-03f, 3.11914291e-02f, -1.43044233e-01f, 7.18853921e-02f, -6.28170073e-02f, -2.22400129e-02f, 3.59062850e-02f, -5.03589027e-02f,
  -4.76425476e-02f, -1.39474615e-01f, 1.28401190e-01f, -9.15236324e-02f, 8.66235793e-02f, 7.85091892e-02f, 9.49094668e-02f, 1.23260938e-01f, -1.31524816e-01f, 4.92734052e-02f,
  -2.94918008e-02f, -6.86585680e-02f, 4.56166416e-02f, -1.24959350e-01f, -8.28479305e-02f, -1.04383796e-01f, -6.55152723e-02f, 1.08879380e-01f, -1.34475619e-01f, 2.90407352e-02f,
  -3.13880369e-02f, -1.85817406e-01f, -2.79696316e-01f, -1.46393478e-01f, 1.58914804e-01f, 2.00574428e-01f, -5.69051094e-02f, 4.84272912e-02f, -2.23075435e-01f, 1.65556788e-01f,
  1.53220072e-01f, -2.31282309e-01f, -2.62298197e-01f, -1.88723549e-01f, -2.32859418e-01f, -4.42525029e-01f, 4.92362455e-02f, 2.53580827e-02f, -1.67926475e-01f, 6.68165162e-02f,
  -7.19488412e-02f, 5.17056249e-02f, -1.87621817e-01f, 2.86594778e-01f, 2.21009910e-01f, 1.75651968e-01f, 3.48153442e-01f, 1.65706173e-01f, 2.34581649e-01f, 8.26511066e-03f,
  1.64512638e-02f, -1.41274154e-01f, -1.88935429e-01f, 3.02495807e-02f, 9.48782191e-02f, 7.45299459e-02f, 1.84758067e-01f, -3.94104272e-02f, -8.21881294e-02f, 5.98187745e-02f,
  4.10033539e-02f, -5.90839759e-02f, -3.24670002e-02f, -7.48493597e-02f, -2.03018589e-03f, -8.20634887e-03f, -1.80200458e-01f, 2.98685804e-02f, -1.18871957e-01f, -1.31274879e-01f,
  -1.38119116e-01f, -4.49353792e-02f, 2.25281976e-02f, -7.64344633e-02f, -1.28450856e-01f, 3.71890366e-02f, -5.00137769e-02f, 4.10787296e-03f, 3.53496335e-02f, -1.24930844e-01f,
  5.04111089e-02f, 1.21673554e-01f, -2.29841694e-02f, 8.30688979e-03f, -1.55494928e-01f, 5.39832860e-02f, -2.75473259e-02f, -5.93995526e-02f, -1.35561675e-01f, 5.78862280e-02f,
  -2.65886704e-03f, -1.32276624e-01f, 8.53216648e-02f, 9.66778025e-02f, -6.13755966e-03f, 2.11892929e-02f, 4.25522402e-03f, -5.94119318e-02f, 1.72903724e-02f, -1.20178342e-01f,
  5.47083691e-02f, 6.43476471e-02f, 6.79863170e-02f, 4.99940701e-02f, 4.06873506e-03f, -2.02442482e-02f, 1.17736921e-01f, 1.28955869e-02f, 8.44005421e-02f, 2.30616480e-02f,
  1.42774925e-01f, 7.01111555e-02f, -8.15822259e-02f, 4.80513871e-02f, -5.55885548e-04f, 3.31350118e-02f, -1.45677337e-02f, -6.70807362e-02f, -9.88400206e-02f, -1.10709764e-01f,
  1.01655409e-01f, 4.99244109e-02f, 2.58402616e-01f, -3.47583778e-02f, 3.46772857e-02f, 1.12614274e-01f, 1.52934656e-01f, 1.06543258e-01f, 9.16355625e-02f, 1.05015635e-01f,
  1.67247534e-01f, 8.34299326e-02f, -1.79161027e-01f, 5.36762960e-02f, -6.69633225e-02f, 1.25735655e-01f, 2.05248073e-02f, 8.50237235e-02f, -6.51839972e-02f, -8.83745402e-02f,
  -3.53449345e-01f, 2.97464341e-01f, 3.24527353e-01f, -1.89968467e-01f, 3.83571059e-01f, 4.65621687e-02f, -3.25360037e-02f, 3.11631858e-01f, 1.25243127e-01f, -8.15089792e-02f,
  5.89081086e-03f, 1.70466587e-01f, 1.67449012e-01f, -5.77617735e-02f, -2.32792065e-01f, -1.50405327e-02f, -2.34933138e-01f, -1.37825102e-01f, 1.97605088e-01f, 5.04783764e-02f,
  5.75858168e-02f, -7.65159056e-02f, 8.14477280e-02f, 2.69970566e-01f, 1.33582279e-01f, -7.91835263e-02f, -3.17327112e-01f, 1.07977450e-01f, -9.39477757e-02f, 1.89634234e-01f,
  -2.21863121e-01f, 8.53858292e-02f, -5.86463846e-02f, 9.93846059e-02f, -8.24969187e-02f, -2.01087631e-02f, 8.29193182e-03f, -3.37098017e-02f, -1.74313728e-02f, -3.99862006e-02f,
  -4.30154242e-02f, 4.09937985e-02f, -1.34695787e-02f, 4.09419201e-02f, -2.28042211e-02f, 4.45737913e-02f, 8.91044810e-02f, -1.21450855e-03f, 1.25448510e-01f, 1.09301113e-01f,
  4.48245108e-02f, 6.06534481e-02f, -3.28480592e-03f, -1.31287843e-01f, -5.73521368e-02f, -1.65014751e-02f, -3.31114531e-02f, -7.72076547e-02f, 2.03101020e-02f, 8.27108696e-02f,
  9.77688581e-02f, -8.34519342e-02f, -1.34424008e-02f, -6.38287961e-02f, 2.96396874e-02f, 5.75005263e-03f, 6.82564303e-02f, -1.12332381e-01f, 2.17261817e-02f, 8.09021946e-03f,
  -1.56973705e-01f, 7.02592358e-02f, 8.26150104e-02f, 3.43769863e-02f, -7.60412365e-02f, -6.32824702e-03f, 2.56056059e-02f, -6.39800951e-02f, 7.84073174e-02f, -7.69361556e-02f,
  8.04802850e-02f, 4.21710201e-02f, 9.03789550e-02f, -1.01420932e-01f, 5.76303788e-02f, 8.20911229e-02f, -5.36259077e-02f, 4.71159592e-02f, -2.15167161e-02f, 4.75728102e-02f,
  -4.65885460e-01f, -3.44232261e-01f, -2.48986125e-01f, -8.64965469e-02f, -1.02278903e-01f, -8.71332660e-02f, 5.04548550e-02f, 5.40135475e-03f, -2.16847155e-02f, -5.22889011e-02f,
  4.56980392e-02f, -5.83046228e-02f, -5.30786812e-02f, 1.11929663e-02f, -1.43360943e-01f, -7.14004040e-02f, -1.64045215e-01f, -7.03010857e-02f, -1.94187015e-01f, -1.19572103e-01f,
  -8.45971778e-02f, -4.90010194e-02f, -2.74057165e-02f, -3.75444293e-02f, -1.07594334e-01f, -7.48003647e-02f, -3.51648293e-02f, 1.37136355e-02f, -3.12521346e-02f, 1.99073516e-02f,
  4.11548555e-01f, 1.34785160e-01f, 2.17678443e-01f, 3.42538357e-01f, -8.54430497e-02f, -1.86417967e-01f, -4.84661199e-02f, -1.41008350e-03f, 3.29491436e-01f, 2.55887602e-02f,
  -1.21590026e-01f, 2.66275615e-01f, -2.23219693e-01f, 1.47280514e-01f, -3.16639423e-01f, -2.29872540e-01f, 1.73580851e-02f, 1.17978938e-01f, 2.22585946e-02f, -3.89779694e-02f,
  1.39291510e-01f, -2.31057212e-01f, -7.60483695e-03f, -1.69737056e-01f, 2.68096924e-01f, 1.49945781e-01f, -1.29275158e-01f, -2.03711778e-01f, 2.75950059e-02f, -1.36746243e-01f,
  8.47140998e-02f, 2.24689737e-01f, 1.20174542e-01f, -5.51935378e-03f, 7.31345415e-02f, 7.33887181e-02f, 1.31029915e-02f, -1.26353279e-01f, -8.12673848e-03f, 1.61363497e-01f,
  2.06482768e-01f, -7.23717660e-02f, -1.41323105e-01f, -2.31938064e-01f, 1.12795092e-01f, 3.81341688e-02f, 1.61044121e-01f, 1.87993795e-01f, -7.23360926e-02f, 1.69082597e-01f,
  1.26128823e-01f, 6.40918016e-02f, 8.77277926e-02f, -2.38895603e-02f, 8.45213905e-02f, 8.61976147e-02f, -2.58106925e-02f, -1.43032009e-02f, 1.58536881e-01f, 9.48553458e-02f,
  1.75774127e-01f, -1.62800342e-01f, -7.53607601e-02f, -1.54020628e-02f, -8.15019906e-02f, 8.31604823e-02f, 7.38151819e-02f, 6.86285831e-03f, 5.42660318e-02f, 2.50679664e-02f,
  -3.34068984e-02f, -3.90053578e-02f, 1.24311529e-01f, -1.38845928e-02f, 6.85522184e-02f, 1.07386656e-01f, 1.45921120e-02f, -3.92303430e-02f, 4.21514139e-02f, 4.95798476e-02f,
  -7.00555444e-02f, -1.82396010e-01f, -4.85208482e-02f, 2.52922140e-02f, -1.58187911e-01f, 6.09579720e-02f, 4.35808077e-02f, 1.28238738e-01f, -3.38163003e-02f, -2.15377524e-01f,
  -8.56453180e-02f, -1.10609904e-01f, 8.94337073e-02f, -7.80551694e-03f, 5.90479991e-04f, -7.23556504e-02f, -8.38615894e-02f, 1.44812297e-02f, -1.40718855e-02f, -7.16433674e-02f,
  3.95426452e-02f, -2.05935109e-02f, 4.69816551e-02f, -4.66229841e-02f, -2.59781368e-02f, -1.48948580e-01f, -9.78472680e-02f, -8.88622105e-02f, -1.28563412e-03f, -1.09916702e-02f,
  7.01346993e-02f, -6.46217167e-02f, -9.09615532e-02f, 7.64109567e-02f, -9.58980024e-02f, 6.29982213e-03f, 3.83768752e-02f, 8.38311836e-02f, -2.20578164e-02f, -3.18871997e-02f,
  -5.93984306e-01f, 9.70646068e-02f, 4.68900979e-01f, 1.23279570e-02f, -3.65460962e-01f, 4.18781698e-01f, 2.26782531e-01f, 9.59349945e-02f, 7.86910132e-02f, 1.56128004e-01f,
  -8.42881128e-02f, -3.07060629e-02f, 6.27450868e-02f, 1.67138666e-01f, 2.33501315e-01f, 2.20962077e-01f, 3.72698568e-02f, 4.07285355e-02f, -1.52690321e-01f, -1.87610313e-01f,
  -1.27147973e-01f, -8.25277343e-02f, 3.58213007e-01f, -1.06372528e-01f, -1.32476270e-01f, -9.65897068e-02f, -1.10563695e-01f, 9.76736192e-03f, -8.26755445e-03f, 9.49847605e-03f,
  -2.29423895e-01f, -1.61676928e-01f, -1.27395734e-01f, 6.44260049e-02f, -5.84506914e-02f, -2.71645747e-02f, 4.40903679e-02f, 8.17326177e-03f, -1.01798914e-01f, 1.74538102e-02f,
  -1.13145560e-01f, -2.49192752e-02f, -8.99082795e-02f, 2.74463035e-02f, -1.19810387e-01f, -2.62669218e-03f, 2.20082439e-02f, 8.86253268e-03f, 1.37715995e-01f, 4.31133062e-02f,
  1.56014457e-01f, 8.56958777e-02f, 1.18967563e-01f, 1.82201788e-01f, 1.62814115e-03f, 7.79153109e-02f, 1.66480854e-01f, -1.30830088e-03f, 3.64876650e-02f, 8.37255716e-02f,
  1.52379274e-02f, 4.03419286e-02f, -1.82020850e-02f, 7.78965233e-03f, -7.70723149e-02f, -5.54797985e-02f, -2.23645978e-02f, -3.59554105e-02f, 9.37002823e-02f, -7.27401450e-02f,
  -4.58156019e-02f, -2.52437443e-02f, -2.36610230e-02f, -6.84786914e-03f, -9.35080051e-02f, -3.11620291e-02f, -2.27834266e-02f, 1.66761633e-02f, -2.61590835e-02f, -1.32678254e-02f,
  -6.09592348e-02f, 7.67857805e-02f, -7.23600835e-02f, -2.47010477e-02f, 1.17495516e-02f, 8.50870833e-02f, 1.29609788e-02f, 6.05888814e-02f, -9.51177403e-02f, -1.02646165e-02f,
  -2.04333693e-01f, -1.41135573e-01f, 1.28526259e-02f, -6.27326220e-02f, -5.70291951e-02f, -7.07980767e-02f, -3.77500150e-03f, -6.72612414e-02f, -4.70884740e-02f, 1.03705693e-02f,
  -1.01380400e-01f, 4.42359189e-04f, 1.69207677e-02f, -4.72395383e-02f, -4.37792111e-03f, 5.01762554e-02f, -6.60355091e-02f, -1.45158693e-01f, -3.59634799e-03f, -1.07827939e-01f,
  -4.54168068e-03f, -4.38975431e-02f, 1.02603309e-01f, -2.41461135e-02f, -8.01465064e-02f, 6.08076192e-02f, -1.09551847e-01f, -1.60757061e-02f, -3.99986841e-02f, 5.84472753e-02f,
  -9.80593786e-02f, -1.26837015e-01f, 1.88957736e-01f, -2.01711074e-01f, 4.01530825e-02f, -3.96801271e-02f, -4.68876772e-02f, -2.00977296e-01f, -1.44591242e-01f, -1.80124640e-01f,
  -5.94404377e-02f, 8.93630832e-02f, 1.63860857e-01f, -2.30300456e-01f, 3.41078550e-01f, 1.98300049e-01f, -2.65704244e-01f, -5.43159992e-02f, -1.24638341e-01f, -1.90749407e-01f,
  -5.57010807e-02f, -1.37061656e-01f, 1.89939722e-01f, -1.82697833e-01f, -2.17864588e-01f, -8.26434791e-02f, 8.27216282e-02f, 1.14973076e-01f, -1.58518881e-01f, 9.10195857e-02f,
  -1.78493887e-01f, -2.21949995e-01f, -5.03005981e-02f, 7.42605701e-03f, -5.98013215e-02f, 6.47821054e-02f, 2.95288470e-02f, 4.96033020e-02f, -1.80733614e-02f, -9.35027450e-02f,
  -7.83692151e-02f, 1.47952512e-01f, -5.85964844e-02f, 5.70122199e-03f, -1.29888713e-01f, -8.81163254e-02f, -3.43615077e-02f, -1.55344844e-01f, 7.85116181e-02f, -1.64603051e-02f,
  1.21849803e-02f, -1.76289827e-02f, -6.51955381e-02f, 4.00473922e-02f, 7.02065304e-02f, -1.01022460e-01f, 2.21543945e-02f, 1.18539825e-01f, -2.57369112e-02f, -4.78464812e-02f,
  1.67181507e-01f, 1.10442631e-01f, -5.85194095e-04f, 3.61525863e-02f, -6.78286478e-02f, 2.53707506e-02f, -1.60767227e-01f, -1.17256986e-02f, 2.83765309e-02f, -6.57894909e-02f,
  7.66808772e-03f, 7.34764477e-03f, -3.80663313e-02f, -1.82770919e-02f, 1.01412810e-01f, 4.30053994e-02f, -1.16460258e-02f, 6.42291009e-02f, 4.96990904e-02f, 5.04997410e-02f,
  -5.35255969e-02f, -1.36361420e-01f, 4.51164041e-03f, 1.24412648e-01f, 8.39119479e-02f, 1.77803069e-01f, -8.13422352e-02f, 9.66918319e-02f, -1.42309740e-01f, 4.87661995e-02f,
  -2.29700133e-01f, -2.17012107e-01f, -6.16517477e-02f, -5.82179837e-02f, 5.75051196e-02f, 1.22391423e-02f, -8.91099311e-03f, -1.11000329e-01f, -6.14325814e-02f, -9.46847200e-02f,
  3.85550712e-03f, 3.29149179e-02f, -5.51372487e-03f, 1.56241143e-02f, -3.34054567e-02f, 6.46777591e-03f, 4.74981330e-02f, -1.80692405e-01f, 6.35563508e-02f, -1.12966456e-01f,
  -1.00709572e-01f, -5.75709082e-02f, 4.55745384e-02f, -9.28284675e-02f, 6.74362527e-03f, 5.14039025e-02f, -3.04237716e-02f, 4.81064916e-02f, -4.15793508e-02f, -4.91774082e-02f,
  -3.36248189e-01f, -2.20904499e-01f, -2.28143930e-01f, -2.71535814e-01f, 3.26891422e-01f, 3.55264485e-01f, -1.66608114e-02f, -2.25568712e-02f, -3.77262831e-01f, -1.67270347e-01f,
  -4.34789546e-02f, -5.93744777e-02f, -2.17264190e-01f, 7.12644830e-02f, 3.21383685e-01f, -4.61998284e-02f, 9.06200558e-02f, 6.94270656e-02f, -1.05937812e-02f, -2.18590856e-01f,
  -4.87648211e-02f, 2.69859970e-01f, -3.04242671e-02f, 1.06246695e-01f, -9.47126932e-03f, -8.39417800e-02f, -7.56039768e-02f, -8.23638514e-02f, 2.70692885e-01f, 1.33513302e-01f,
  -4.71521448e-03f, -2.63186306e-01f, -2.70736348e-02f, 6.04187557e-03f, 1.04378909e-02f, -1.16293088e-01f, -1.25146704e-02f, 1.35923475e-01f, 1.11721523e-01f, -1.25422589e-02f,
  4.76227095e-03f, 3.26234773e-02f, 6.10317988e-03f, 8.27827025e-03f, -1.30287465e-02f, 3.67279761e-02f, -2.12067161e-02f, 1.74581483e-01f, 5.30305803e-02f, -7.40204528e-02f,
  -3.86499465e-02f, 3.26341279e-02f, 9.70295910e-03f, 2.98488718e-02f, 2.07660161e-02f, 3.34257772e-03f, -7.15954825e-02f, -9.71321687e-02f, 1.45440266e-01f, -4.51183170e-02f,
  -9.12108794e-02f, -4.99347523e-02f, 1.12177420e-03f, 1.16173148e-01f, -3.37359458e-02f, -3.07776481e-02f, 1.58493951e-01f, 9.13906470e-02f, -3.37687954e-02f, -2.21563019e-02f,
  -2.58023757e-02f, 2.47779973e-02f, -1.30767956e-01f, -5.64192198e-02f, -3.44715789e-02f, -4.26439494e-02f, 7.46654123e-02f, -4.47401442e-02f, -1.71883732e-01f, 7.55070969e-02f,
  1.07040517e-01f, -4.84025404e-02f, -9.30237994e-02f, 5.80583140e-02f, 1.20008416e-01f, -3.76251340e-02f, 1.58497710e-02f, -2.39441283e-02f, -1.47401616e-01f, 3.54695991e-02f,
  -1.26543818e-02f, -2.21081555e-01f, -5.09047247e-02f, 1.10066131e-01f, -3.48362885e-02f, -3.98028195e-02f, 4.64799553e-02f, 6.53998107e-02f, 5.28559648e-03f, 2.45110318e-03f,
  -2.21481752e-02f, -6.86329138e-03f, -1.24906311e-02f, 3.64945014e-03f, 3.07550877e-02f, -5.96338622e-02f, -1.07177950e-01f, 2.10433714e-02f, 3.76828685e-02f, 7.15593547e-02f,
  -3.02728469e-04f, -3.33733968e-02f, 6.20732456e-02f, 6.80634752e-02f, -4.95447405e-03f, 5.16075790e-02f, -4.15745415e-02f, -1.47293955e-01f, 1.52813390e-01f, 2.40548956e-03f,
  -7.01218307e-01f, 1.73141509e-01f, -1.08765423e-01f, 1.43150643e-01f, -9.53334477e-03f, -2.30329838e-02f, -8.33620727e-02f, -1.54154137e-01f, -1.48852214e-01f, 1.13630630e-01f,
  2.28391588e-01f, -2.63406277e-01f, 5.48856407e-02f, 2.63786972e-01f, -2.68818706e-01f, 2.05629021e-01f, 1.08682059e-01f, 9.36044306e-02f, -4.35823575e-02f, -9.37626585e-02f,
  -1.30497210e-03f, 2.47314498e-01f, 1.68254584e-01f, 2.14229286e-01f, -2.39113420e-02f, -6.86187074e-02f, 4.60818335e-02f, -9.40226242e-02f, 2.61903495e-01f, -1.37029204e-03f,
  -1.53199792e-01f, -9.23206806e-02f, -1.04838520e-01f, -9.30897072e-02f, -1.28116682e-01f, -1.31387383e-01f, -7.85803720e-02f, -8.63547996e-02f, -2.46491693e-02f, -1.03346091e-02f,
  -4.29982990e-02f, 8.73114616e-02f, -7.99920559e-02f, 7.24269673e-02f, -1.09822579e-01f, -5.31881861e-03f, 5.84029891e-02f, 1.49790406e-01f, -7.18705729e-03f, 4.90173846e-02f,
  3.82545292e-02f, 3.15189846e-02f, 1.96170267e-02f, 4.20616902e-02f, 5.36121316e-02f, -2.11805385e-02f, 1.10669345e-01f, -4.14452739e-02f, -3.84003446e-02f, -1.42178550e-01f,
  -4.95310500e-02f, 9.71680731e-02f, 1.77947432e-02f, 1.20457768e-01f, 8.33151340e-02f, 1.45356521e-01f, -8.24059546e-02f, -3.71270217e-02f, 8.31426531e-02f, 1.07168131e-01f,
  9.43516493e-02f, -3.07784993e-02f, 7.17485510e-03f, 1.61866415e-02f, -3.07902955e-02f, -3.87924723e-02f, 8.76706168e-02f, 2.56115515e-02f, 1.18698902e-01f, 2.38281712e-02f,
  -7.26879165e-02f, -6.27823621e-02f, -2.48768963e-02f, -1.74724422e-02f, -1.34813339e-01f, 9.48320627e-02f, 3.46300490e-02f, -1.45490644e-02f, -7.58360997e-02f, 1.51191160e-01f,
  -3.57739359e-01f, -3.02793115e-01f, -6.36973279e-03f, -7.12401867e-02f, -6.47978485e-02f, -7.57538825e-02f, 1.01002157e-02f, 6.45105392e-02f, 3.85914184e-02f, -1.27406001e-01f,
  -2.63418034e-02f, 5.22514023e-02f, -8.38668831e-03f, 3.19963694e-02f, -8.33206717e-03f, 4.09834040e-03f, -1.16849691e-01f, -4.99845622e-03f, -1.12567052e-01f, -4.42746707e-04f,
  -2.75040194e-02f, 1.77222546e-02f, 1.69321001e-02f, 8.25390890e-02f, 9.86188650e-02f, -1.02475457e-01f, -3.31596727e-03f, 4.82658809e-03f, 9.72996578e-02f, 6.84664249e-02f,
  1.40880272e-01f, 1.40939772e-01f, 1.91829905e-01f, 8.39661211e-02f, -1.87177286e-01f, -1.52146354e-01f, -1.02329075e-01f, -1.06261589e-01f, -1.78561792e-01f, -4.99160495e-03f,
  -2.13830769e-01f, 5.08448303e-01f, -2.69138783e-01f, 1.12796210e-01f, -3.26148063e-01f, -3.25079441e-01f, 4.33825068e-02f, 1.69275582e-01f, -6.93778843e-02f, 8.88963714e-02f,
  -6.12775721e-02f, -2.02069759e-01f, -9.14644599e-02f, -1.71896666e-02f, 1.53360784e-01f, 2.90163249e-01f, -1.13896489e-01f, 4.07540463e-02f, 3.11045408e-01f, 6.41744509e-02f,
  -4.98723090e-02f, -2.64554750e-02f, 1.18115246e-01f, 2.99088098e-02f, -1.39552593e-01f, 3.42416279e-02f, 1.22347645e-01f, -2.81179193e-02f, 1.30964532e-01f, 1.20337993e-01f,
  -4.28807214e-02f, 8.08462128e-02f, 5.64251421e-03f, 6.61841631e-02f, -1.74779426e-02f, 1.15188941e-01f, 9.19199139e-02f, -1.20682288e-02f, -1.09730409e-02f, 5.17795980e-03f,
  6.71508163e-02f, 9.31288749e-02f, -4.52352986e-02f, 5.47213331e-02f, -6.02522530e-02f, -8.53572339e-02f, 8.21608007e-02f, 1.35207370e-01f, 8.61023739e-02f, 1.27189323e-01f,
  -3.91257219e-02f, -2.83055138e-02f, -1.13417823e-02f, 2.41251867e-02f, 3.45889702e-02f, -1.84264690e-01f, -3.05215791e-02f, -6.23139106e-02f, -1.07439496e-01f, 1.78445783e-02f,
  7.29862079e-02f, 1.90107450e-02f, -1.06681362e-02f, 1.29238769e-01f, -1.07745320e-01f, -5.62926866e-02f, 3.73656452e-02f, 2.99006281e-03f, -8.43864828e-02f, 8.43280628e-02f,
  4.59179655e-02f, -2.16405615e-02f, 3.86429727e-02f, -1.39583566e-03f, -1.88100263e-02f, 1.09533615e-01f, 1.26967281e-01f, 7.75801465e-02f, -9.78784710e-02f, 1.33413911e-01f,
  -2.46918738e-01f, -1.75017104e-01f, -8.44677389e-02f, -4.53323504e-04f, 3.04541644e-02f, 1.07266255e-01f, 8.32374115e-03f, -3.01647652e-02f, -3.59929502e-02f, -1.87193751e-02f,
  -4.87567000e-02f, 2.45232210e-02f, 4.12337296e-03f, 9.06801522e-02f, -7.30684772e-02f, -7.98942372e-02f, -7.58380890e-02f, 5.39352484e-02f, 1.49676176e-02f, -2.06049457e-02f,
  3.87355387e-02f, -1.28212459e-02f, -2.45142896e-02f, -1.74910370e-02f, -4.23059575e-02f, -3.30448039e-02f, 7.49005973e-02f, 9.12028179e-02f, 9.21718180e-02f, 7.00287847e-03f,
  2.63053358e-01f, -2.85297871e-01f, 1.44534349e-01f, 9.17055383e-02f, 2.40072608e-01f, -2.78836320e-04f, 1.43027231e-01f, -6.30203187e-02f, 1.82443812e-01f, -3.03906977e-01f,
  -2.82385051e-02f, 1.32343352e-01f, 1.41340002e-01f, -1.22380249e-01f, 3.60706240e-01f, 2.91656077e-01f, -1.47897393e-01f, -6.20492175e-03f, 5.11141792e-02f, -1.01546168e-01f,
  1.77580919e-02f, -1.98057309e-01f, 4.60723191e-02f, -3.22183222e-01f, -2.00375974e-01f, -1.74336508e-01f, -9.30271074e-02f, 6.71221390e-02f, -3.16041350e-01f, 2.87705567e-02f,
  -2.71976203e-01f, -1.88274145e-01f, -1.21715032e-01f, -9.90608856e-02f, -9.23715904e-02f, 6.20917976e-03f, 4.38262857e-02f, 2.10740566e-01f, -7.50448778e-02f, -5.78083657e-02f,
  -2.08750386e-02f, -5.83886392e-02f, 1.35282101e-02f, 6.70081899e-02f, -4.13354971e-02f, -8.69326666e-02f, 3.00640278e-02f, -9.74818990e-02f, 1.34619500e-03f, 3.96006778e-02f,
  -1.86778568e-02f, -5.09238802e-02f, -9.90809575e-02f, -3.95423695e-02f, 1.01879388e-02f, -3.80714163e-02f, -1.42496437e-01f, 9.10977721e-02f, -5.54867573e-02f, 1.21585932e-02f,
  4.43618856e-02f, 1.20190494e-02f, -8.26846510e-02f, -8.80121961e-02f, 2.04240400e-02f, 5.41070551e-02f, 4.50626239e-02f, 2.20622439e-02f, -1.14099585e-01f, -1.44106876e-02f,
  9.70472023e-02f, -6.86645582e-02f, -7.89672229e-03f, 5.03542647e-02f, 1.27217099e-02f, -4.78060767e-02f, -1.46437157e-02f, -3.80058847e-02f, -2.77115069e-02f, -2.30807532e-02f,
  4.43459302e-02f, 8.61176550e-02f, -4.53894138e-02f, 1.22932836e-01f, -5.21973222e-02f, 6.01984514e-03f, -3.12745012e-02f, 1.54506221e-01f, 2.31497213e-01f, 1.40230700e-01f,
  -3.19543839e-01f, -3.23647231e-01f, -8.30523148e-02f, -8.65834430e-02f, -6.23412170e-02f, -5.26686832e-02f, 2.85117775e-02f, 9.36386287e-02f, -2.10154951e-02f, 7.58170113e-02f,
  -8.69707614e-02f, -9.99988467e-02f, 2.08148863e-02f, 4.41173017e-02f, -6.57302886e-02f, -7.83282742e-02f, 6.21415116e-02f, -1.69461772e-01f, -4.12257537e-02f, -8.72729495e-02f,
  -3.59940007e-02f, 1.90515295e-02f, -5.44099323e-02f, -1.47825852e-01f, -8.99346694e-02f, -2.67266165e-02f, -4.93033603e-02f, 3.54833119e-02f, -2.89520826e-02f, -4.80849296e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.28431112e-01f, 1.21576153e-01f, 2.21180707e-01f, 5.41225299e-02f, 1.88537285e-01f, 1.47745132e-01f, 2.04397589e-01f, 1.40299246e-01f, 2.21490681e-01f, 1.75893947e-01f,
  1.39493391e-01f, 1.67783082e-01f, 1.13192111e-01f, 1.36201099e-01f, 2.61722594e-01f, 4.73245569e-02f, 2.20073223e-01f, 9.60193053e-02f, 5.38181029e-02f, 3.34362864e-01f,
  2.22473994e-01f, 1.77621529e-01f, 7.11827278e-02f, 2.21204266e-01f, 1.52556017e-01f, 1.42358094e-01f, 9.09048244e-02f, 1.97993800e-01f, 1.87316433e-01f, 1.32600695e-01f,
  1.64077550e-01f, 1.86844498e-01f, 2.40869343e-01f, 1.30159140e-01f, 1.60307392e-01f, 7.78436214e-02f, 2.50133514e-01f, 1.86681122e-01f, 1.83787987e-01f, 2.63417155e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -3.85894626e-02f, -2.71721072e-02f, 1.19128026e-01f, 6.60964102e-02f, 2.27208845e-02f, -1.13485970e-01f, 4.16175388e-02f, -2.17050552e-01f, -3.77805308e-02f, 1.42353633e-02f,
  -3.80975241e-03f, -5.57136312e-02f, -7.37466887e-02f, 1.93993509e-01f, -1.03021152e-01f, -1.22357130e-01f, 3.90590876e-02f, 8.86591524e-03f, 1.41286209e-01f, -1.28038162e-02f,
  -1.96145549e-01f, -6.75171688e-02f, -1.15783788e-01f, -1.51453152e-01f, -1.56924397e-01f, 1.60216525e-01f, -8.07729587e-02f, -9.12490040e-02f, 3.00604135e-01f, -8.67402554e-02f,
  -1.11667022e-01f, 1.18659483e-02f, 8.44896883e-02f, -6.04794025e-02f, -9.10479277e-02f, -1.78194031e-01f, 2.23243147e-01f, 2.56000400e-01f, -2.21384287e-01f, 7.80433267e-02f,
  8.82568210e-02f, 1.02291964e-01f, -7.57972673e-02f, -7.95248300e-02f, -3.48949172e-02f, 7.29837865e-02f, -7.61481449e-02f, -6.88723475e-02f, 8.25008303e-02f, -3.22907418e-02f,
  1.31888360e-01f, -7.13911727e-02f, -3.53733301e-02f, -1.70480192e-01f, -1.99981466e-01f, 1.67958084e-02f, -1.71840623e-01f, -1.30918464e-02f, 1.57018349e-01f, -1.69664472e-01f,
  6.41201362e-02f, -5.72945806e-04f, -8.99099633e-02f, 4.23361827e-03f, 6.16366901e-02f, 9.75192189e-02f, -5.29520065e-02f, 6.17170967e-02f, 1.78142302e-02f, 1.32203355e-01f,
  1.75984427e-01f, 6.71190247e-02f, 3.37645821e-02f, 1.31974369e-01f, 1.12028904e-01f, 2.77702883e-02f, 1.93691209e-01f, -6.24516867e-02f, -4.78730723e-02f, 2.53185660e-01f,
  8.66068229e-02f, -2.22145058e-02f, -7.76034594e-02f, -1.84755430e-01f, -9.36989933e-02f, 1.03244511e-02f, -1.75879374e-01f, 1.52710497e-01f, -5.59550822e-02f, 9.93409231e-02f,
  2.15253290e-02f, -1.81325942e-01f, -9.26369131e-02f, -7.39373937e-02f, 2.40754515e-01f, -9.16365758e-02f, -2.74081994e-02f, 6.62852004e-02f, 8.02500546e-02f, 2.51358181e-01f,
  5.26807420e-02f, -2.28732184e-01f, 5.19952830e-03f, -1.21266335e-01f, -4.27277610e-02f, -1.60319000e-01f, -4.14391607e-02f, 2.22329468e-01f, -2.26294715e-02f, 7.62471408e-02f,
  -4.31407318e-02f, -1.70876950e-01f, 2.64118731e-01f, -9.65296999e-02f, -3.09552792e-02f, -6.91925064e-02f, 1.50682451e-02f, 2.34657545e-02f, -4.43274379e-02f, 2.84096785e-02f,
  -3.38946730e-02f, -1.77598730e-01f, 1.98613301e-01f, 1.38393611e-01f, 1.19083852e-01f, 9.34828371e-02f, -1.67607501e-01f, 5.36717772e-02f, -9.92339551e-02f, -5.94275892e-02f,
  5.40785864e-02f, 9.25224796e-02f, 6.54965788e-02f, -6.35611638e-02f, 7.21620675e-03f, -1.40365303e-01f, -8.64807218e-02f, 1.78623125e-01f, 1.38116077e-01f, -2.31531877e-02f,
  -8.23491588e-02f, 5.29818386e-02f, -1.13402337e-01f, -1.02579400e-01f, 6.91776872e-02f, -5.12100607e-02f, 1.96514174e-01f, -1.86844885e-01f, -8.53339508e-02f, -2.97289379e-02f,
  -1.55752227e-01f, -1.28119007e-01f, -1.35765985e-01f, 4.18226495e-02f, 5.00080474e-02f, -5.16047105e-02f, 1.23809084e-01f, 4.23120037e-02f, 7.01558515e-02f, 1.52749149e-02f,
  6.44503459e-02f, -9.80395749e-02f, -5.55166751e-02f, 2.64612888e-03f, 1.88306183e-01f, 1.36155337e-01f, -1.40578657e-01f, 2.04358578e-01f, 6.89115226e-02f, 1.14306808e-01f,
  -8.88483599e-02f, -4.37422618e-02f, -6.64085448e-02f, 9.54640955e-02f, 9.07445420e-03f, -1.32521868e-01f, 1.85861290e-01f, -8.10925886e-02f, 1.12781398e-01f, 1.25304786e-02f,
  -1.07894495e-01f, -1.21170901e-01f, -1.70045912e-01f, 6.06591925e-02f, -1.74133226e-01f, -9.35149714e-02f, -1.98062994e-02f, -6.42188266e-02f, 1.30725011e-01f, -4.95942011e-02f,
  -7.02526420e-02f, 3.88414785e-02f, 8.78141522e-02f, -1.09102894e-02f, 3.54060024e-01f, -1.15599327e-01f, 4.99642827e-02f, 5.81386834e-02f, 1.01225823e-01f, 1.32391043e-02f,
  1.83541313e-01f, 7.36306906e-02f, 1.14918582e-01f, 8.54858831e-02f, 1.72682896e-01f, 2.14273240e-02f, 4.94369119e-02f, -1.33363893e-02f, 5.91515712e-02f, -1.37073100e-01f,
  -5.71662933e-02f, -2.75683030e-02f, 3.11057549e-02f, 3.16574634e-03f, -9.46353078e-02f, -9.04127210e-02f, -1.82763681e-01f, 1.24027282e-02f, 2.51159310e-01f, -5.70866875e-02f,
  1.49256047e-02f, -6.32143486e-03f, 4.31028269e-02f, 1.11226708e-01f, -2.90892243e-01f, -2.40771875e-01f, -1.41155317e-01f, 1.79730013e-01f, -1.98632583e-01f, -1.93094555e-02f,
  -3.16437110e-02f, -4.37799841e-02f, -8.06935877e-03f, 2.24848747e-01f, -2.32266113e-01f, -6.86679855e-02f, -5.17314449e-02f, -2.18483597e-01f, 1.17186815e-01f, 7.95789361e-02f,
  -8.09075534e-02f, -2.70176237e-03f, 1.11168697e-01f, 1.67648599e-01f, -4.24823314e-02f, 4.87282593e-03f, 5.19864671e-02f, -4.80591096e-02f, 4.24773768e-02f, 1.39801372e-02f,
  1.00662835e-01f, 1.64063498e-01f, 1.46927863e-01f, -1.44126341e-01f, 9.71280187e-02f, 2.88866252e-01f, 6.24621771e-02f, 4.90678884e-02f, 2.20166668e-01f, 1.28325477e-01f,
  7.21872493e-05f, 1.34945512e-01f, -5.55102453e-02f, -2.38276012e-02f, 2.16004178e-02f, 1.78433824e-02f, 3.85337621e-02f, -1.01058841e-01f, 5.65725304e-02f, 6.29557967e-02f,
  1.23985238e-01f, -2.03982979e-01f, 9.40687209e-02f, -5.49209006e-02f, 7.53074735e-02f, 1.05485283e-02f, -3.91497128e-02f, 1.44201219e-01f, 6.71388581e-03f, -3.14102322e-02f,
  -1.34036884e-01f, 1.18557870e-01f, 1.95190564e-01f, -2.14089770e-02f, 3.93272814e-04f, -8.00909549e-02f, -9.30763856e-02f, -1.24535762e-01f, -1.09624676e-01f, -1.38192236e-01f,
  -9.62690711e-02f, 1.65938258e-01f, 1.46917654e-02f, -1.32132113e-01f, -2.13912070e-01f, -8.67882222e-02f, 2.29264632e-01f, 4.19246852e-02f, -2.25059435e-01f, -1.25217527e-01f,
  1.02972545e-01f, -2.36770794e-01f, -1.04914695e-01f, 5.08042686e-02f, 7.34570697e-02f, -1.97435737e-01f, 1.35917693e-01f, 3.55114564e-02f, 3.63664590e-02f, -1.82999253e-01f,
  -1.07845729e-02f, -1.69512615e-01f, -1.17811248e-01f, 2.44394019e-01f, 1.60862222e-01f, -7.36452118e-02f, -6.48480281e-02f, 6.78058788e-02f, -2.74951826e-03f, 1.57971606e-01f,
  -6.36482537e-02f, 2.71620117e-02f, 1.59015179e-01f, 3.56706679e-02f, -9.54981297e-02f, -1.31345978e-02f, 5.59449904e-02f, -7.57296011e-02f, -1.29905969e-01f, 2.16860905e-01f,
  8.88939854e-03f, -1.19635433e-01f, 9.61477961e-03f, 2.39474624e-02f, 1.95763797e-01f, 5.66090457e-02f, -1.17719211e-01f, -1.76099241e-01f, 1.13920309e-02f, -2.78404027e-01f,
  -1.15583472e-01f, -1.03006966e-01f, -1.79839041e-02f, -2.32307062e-01f, -8.00048932e-02f, -1.34110451e-01f, 6.59890473e-02f, -2.06469283e-01f, -7.51100332e-02f, -1.02399603e-01f,
  2.22073212e-01f, -7.27387443e-02f, -1.42613724e-01f, -1.27511829e-01f, 1.28841072e-01f, 1.25492647e-01f, 4.39983755e-02f, 5.36989495e-02f, 6.14341162e-02f, 5.28944209e-02f,
  -2.59832274e-02f, 1.46864533e-01f, 6.59483969e-02f, -3.36697921e-02f, -1.43333539e-01f, 1.43357875e-05f, 1.88579410e-01f, -2.19012737e-01f, -5.82587495e-02f, -1.64097771e-01f,
  2.66210675e-01f, 2.04253599e-01f, -2.35307038e-01f, -1.54307291e-01f, -5.53412847e-02f, 2.12731227e-01f, -1.26471788e-01f, -5.32815643e-02f, -2.51511663e-01f, 1.03349008e-01f,
  1.88821986e-01f, -9.59631950e-02f, -5.62912263e-02f, 1.69252858e-01f, -8.51637647e-02f, -2.80313157e-02f, 4.10651974e-02f, -5.76158278e-02f, 8.01600739e-02f, 6.40617013e-02f,
  -8.43831003e-02f, 9.30173546e-02f, 1.14767492e-01f, -9.03510302e-02f, -1.52097261e-02f, -2.68618949e-03f, -2.65372954e-02f, -4.43850271e-02f, 2.01843027e-02f, -5.11381142e-02f,
  -2.66649332e-02f, -3.70303318e-02f, -1.33755773e-01f, -3.72916390e-03f, 2.44426489e-01f, 2.22668827e-01f, 2.73076147e-01f, 6.57716393e-02f, -2.87680235e-02f, -1.52589574e-01f,
  1.14794457e-02f, 5.47092855e-02f, -1.83655396e-02f, 1.79391485e-02f, -6.68381527e-02f, 9.10709947e-02f, -2.20765099e-02f, 5.39587885e-02f, -1.12063371e-01f, 1.39224380e-01f,
  -1.36572570e-01f, -7.13391602e-02f, -1.03375115e-01f, -5.24689108e-02f, -9.84828770e-02f, -5.06101511e-02f, -1.66259408e-01f, 6.08898699e-02f, 1.75065473e-01f, -6.74242526e-02f,
  -9.48132053e-02f, 1.10515796e-01f, -2.18235701e-01f, 5.80106936e-02f, -9.90493670e-02f, -1.45090148e-01f, 7.06924498e-02f, 1.75989285e-01f, 1.32918015e-01f, -1.61392599e-01f,
  2.95360804e-01f, 1.12710714e-01f, 7.41467103e-02f, -1.03720620e-01f, -1.63511157e-01f, 5.91061972e-02f, 5.20021841e-02f, 7.18773622e-03f, 6.68477714e-02f, 8.47851932e-02f,
  1.29328102e-01f, -3.93743552e-02f, -6.32053986e-02f, 2.37950068e-02f, 5.28701283e-02f, 2.51145642e-02f, 9.87004191e-02f, -4.22577150e-02f, -2.73309853e-02f, 1.26144681e-02f,
  1.73852533e-01f, 1.41920865e-01f, 1.53666586e-01f, 1.77229390e-01f, 9.12269726e-02f, 1.42213613e-01f, -1.45655004e-02f, -3.75268720e-02f, 7.98727050e-02f, -3.41225006e-02f,
  -3.36900912e-02f, -9.59419236e-02f, -1.11989826e-01f, -1.30220056e-01f, 1.48242012e-01f, 1.09381061e-02f, 3.26016359e-02f, -1.64726868e-01f, 9.07239243e-02f, 2.17458345e-02f,
  -1.84406757e-01f, -7.71004036e-02f, -1.51797667e-01f, 2.91673124e-01f, -5.01321107e-02f, -1.54967070e-01f, -1.45748660e-01f, -1.90827176e-01f, -1.17637012e-02f, 4.15920168e-02f,
  -1.49006754e-01f, -3.02170403e-02f, 1.15075894e-01f, -1.19613849e-01f, -7.41040930e-02f, -4.64640819e-02f, -1.25015184e-01f, 7.31722414e-02f, 5.40999956e-02f, 4.21651192e-02f,
  8.45342055e-02f, -1.15275746e-02f, 1.01801842e-01f, -8.17130785e-03f, 1.70960709e-01f, 5.64383976e-02f, 7.98230618e-02f, 8.78653675e-03f, 1.18711339e-02f, -3.47017981e-02f,
  1.36800379e-01f, 1.38401404e-01f, 7.25641400e-02f, 1.35528922e-01f, -1.37943374e-02f, 2.30186637e-02f, -9.97437816e-03f, 4.79291640e-02f, 2.83737835e-02f, 1.31251469e-01f,
  3.31131741e-02f, 1.00035137e-02f, 6.41341731e-02f, -1.82851013e-02f, 1.28073946e-01f, -5.13910726e-02f, 1.19263552e-01f, 1.40457407e-01f, -9.91053283e-02f, 1.30361289e-01f,
  -1.12904385e-01f, -5.71350043e-04f, 1.17132202e-01f, -3.41610648e-02f, -8.28082338e-02f, 5.05600087e-02f, 3.10517270e-02f, -5.46319336e-02f, -1.28424153e-01f, -1.45813137e-01f,
  -2.77497619e-01f, -2.40761321e-02f, -5.02784923e-02f, -1.53278083e-01f, -1.32827228e-02f, 1.71430469e-01f, 1.25896499e-01f, 8.30145180e-03f, -8.77976567e-02f, -1.96586683e-01f,
  1.95603639e-01f, -1.33909479e-01f, -6.80586770e-02f, -2.11844385e-01f, 8.37631449e-02f, 9.82246399e-02f, 1.39739305e-01f, -1.76190868e-01f, -5.87314628e-02f, 1.41146034e-01f,
  -6.29031286e-02f, -6.43512830e-02f, -2.25831568e-01f, -4.42959778e-02f, 9.72820446e-02f, 1.36631742e-01f, 1.80059329e-01f, -4.82118912e-02f, 1.16498247e-01f, 1.34378159e-03f,
  1.70097351e-01f, 1.33771777e-01f, 1.08175583e-01f, 1.71306059e-01f, 1.14422187e-01f, -1.91973791e-01f, 8.20392668e-02f, 8.36941693e-03f, -4.20435444e-02f, -4.57020737e-02f,
  1.15411632e-01f, -5.87702543e-02f, -1.33361563e-01f, -2.71469448e-02f, 9.03864205e-02f, -1.77552119e-01f, -1.67373684e-03f, -7.80183729e-03f, -4.56937309e-03f, 4.17688936e-02f,
  -1.26812845e-01f, 2.23526359e-03f, 1.96354818e-02f, 2.28420258e-01f, 4.80562188e-02f, 2.72961259e-01f, 4.00351966e-03f, 5.89683726e-02f, 1.38783112e-01f, 1.48049355e-01f,
  3.25657316e-02f, 9.29084048e-02f, -1.88955113e-01f, 2.41842151e-01f, 1.48817599e-01f, -8.02516267e-02f, -1.96327657e-01f, 4.02548723e-02f, 1.46015376e-01f, 9.32552740e-02f,
  -9.21434388e-02f, -1.85849562e-01f, 1.38234627e-02f, -1.75032355e-02f, 2.04807390e-02f, -1.48533300e-01f, 9.97432694e-02f, -5.47570735e-02f, 2.41930634e-02f, -9.35299993e-02f,
  1.01258129e-01f, -1.22596055e-01f, -1.47527412e-01f, 1.70446590e-01f, 5.92386874e-04f, 1.15430936e-01f, -1.54724240e-01f, -1.85907736e-01f, 1.21486403e-01f, 4.29080687e-02f,
  1.64216906e-02f, -1.92687675e-01f, 1.12688258e-01f, 3.62505130e-02f, 8.88279229e-02f, -1.45540223e-01f, -2.10117117e-01f, 1.43747330e-01f, -7.82184361e-04f, -1.82466179e-01f,
  -4.45068553e-02f, -1.60904095e-01f, 4.91444916e-02f, -4.17849645e-02f, -2.91619860e-02f, -1.01213656e-01f, -5.55840991e-02f, -8.80817771e-02f, -1.68885738e-02f, -1.41223654e-01f,
  -5.77590540e-02f, 3.19744041e-03f, -1.63539603e-01f, 5.79087529e-04f, -2.93745305e-02f, -2.45428592e-01f, -2.84650587e-02f, -1.40279368e-01f, -6.97786454e-04f, 3.89955118e-02f,
  -1.35409227e-02f, 1.47480115e-01f, 2.70531029e-01f, -1.35640018e-02f, -6.86378032e-02f, -1.88407585e-01f, 1.15073938e-02f, 2.22737163e-01f, 2.05101877e-01f, 1.17219515e-01f,
  -1.77874386e-01f, 1.32030621e-01f, -5.66005744e-02f, -2.19910443e-01f, -1.63356766e-01f, -9.73888710e-02f, 5.79588935e-02f, 2.60123074e-01f, -9.18058306e-02f, 9.35717821e-02f,
  6.78914366e-03f, 9.18674022e-02f, -6.29987046e-02f, -1.05764501e-01f, -6.33949563e-02f, 8.78134444e-02f, -1.16987385e-01f, -1.29788831e-01f, -1.99535280e-01f, 3.16613019e-02f,
  3.83685231e-02f, -1.40227407e-01f, -1.47512928e-01f, -3.05321570e-02f, 1.63578745e-02f, -2.44953670e-03f, -4.06037718e-02f, 2.15325400e-01f, -3.88201326e-02f, -1.61202490e-01f,
  -1.27668709e-01f, -1.47603750e-01f, 7.28013664e-02f, -8.31764117e-02f, -6.10817187e-02f, -8.04314017e-03f, -5.72506823e-02f, -1.14374578e-01f, 7.56574497e-02f, 6.57755008e-04f,
  -1.75162613e-01f, 2.73340605e-02f, -1.14469528e-01f, -1.46078974e-01f, -6.22652918e-02f, -1.17269546e-01f, 4.40727882e-02f, 3.12006641e-02f, -4.01243344e-02f, 7.56159425e-03f,
  -1.59695789e-01f, 1.09099083e-01f, -1.14633717e-01f, 1.29040733e-01f, 1.20319679e-01f, 2.48149186e-02f, -2.50490643e-02f, 2.12027460e-01f, -4.73537892e-02f, 2.42711857e-01f,
  -2.01726273e-01f, -2.08769768e-01f, -2.64472634e-01f, -1.18587784e-01f, -8.76986384e-02f, -1.24432348e-01f, 1.42350405e-01f, 5.92190325e-02f, 1.53913677e-01f, -2.33812645e-01f,
  9.04345214e-02f, 4.03542705e-02f, 4.01797593e-02f, -1.46533288e-02f, 4.05814983e-02f, -5.59550375e-02f, 5.68496287e-02f, -1.06228568e-01f, 1.40808851e-01f, -1.31955773e-01f,
  -1.20429739e-01f, 1.30587012e-01f, 1.39467157e-02f, -3.27314585e-02f, -1.97479963e-01f, 4.87399623e-02f, 9.94750112e-02f, -2.27568671e-02f, 1.04914621e-01f, -2.96688974e-01f,
  4.95666005e-02f, 4.86796722e-02f, -6.28132466e-03f, -1.07491063e-02f, 1.46983014e-02f, 1.96178913e-01f, -3.34257819e-02f, -1.10153973e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.53925776e-01f, 7.00790808e-02f, 5.96218556e-02f, 9.07746851e-02f, 1.82733864e-01f, 5.05882315e-02f, 5.94321489e-02f, 8.70553497e-03f, 2.52596855e-01f, 1.31696597e-01f,
  1.03391804e-01f, 1.16586886e-01f, -2.22378168e-02f, 1.88666090e-01f, -2.96558857e-01f, -1.30605429e-01f, -3.77250370e-03f, 1.62358969e-01f, 9.87310857e-02f, -1.15878537e-01f,
  1.99483670e-02f, 2.75739372e-01f, 1.25829309e-01f, 1.54969439e-01f, -2.38244738e-02f, 1.81082234e-01f, 3.88197042e-02f, 2.76520342e-01f, 3.62509668e-01f, -5.11312895e-02f,
  -7.91730359e-02f, -5.75049669e-02f, 2.10634887e-01f, -1.35937884e-01f, -1.24400156e-02f, 1.16954252e-01f, 1.81663856e-01f, 1.04078405e-01f, -9.64366645e-02f, -1.15138315e-01f,
  3.17926764e-01f, 2.35223360e-02f, -1.24034628e-01f, -7.88023323e-02f, 1.02798767e-01f, -5.52628823e-02f, -1.33122634e-02f, 2.63181869e-02f, 7.60912448e-02f, 3.17906737e-02f,
  9.13951695e-02f, -3.25022936e-02f, -1.18111039e-03f, -2.16581881e-01f, 2.25905161e-02f, 6.18202705e-03f, 5.34777879e-04f, 3.67564529e-01f, 1.07757270e-01f, -2.44044513e-01f,
  -2.61383802e-01f, -2.00824335e-01f, 7.53362253e-02f, 5.87224849e-02f, 3.00761368e-02f, -3.58693674e-02f, -3.61068174e-02f, -3.83971608e-03f, -9.39217061e-02f, 5.99981248e-02f,
  2.71227676e-02f, 1.97807670e-01f, -4.02513407e-02f, -3.35414223e-02f, -6.83237538e-02f, 4.68211323e-02f, 9.41519365e-02f, -1.03290319e-01f, 2.55863309e-01f, 9.37636197e-02f,
  7.32259378e-02f, -9.60304961e-02f, -6.24023825e-02f, 8.40098634e-02f, 1.29558384e-01f, -5.16144037e-02f, -1.31364942e-01f, -1.45933867e-01f, 2.17147529e-01f, -3.73687521e-02f,
  1.57428950e-01f, -7.91427493e-02f, -1.93313569e-01f, 7.52661675e-02f, 3.15173775e-01f, -8.51040632e-02f, -3.66494134e-02f, 1.05000272e-01f, 1.20400220e-01f, 1.96404442e-01f,
  -1.50082022e-01f, -2.85637707e-01f, 1.47041827e-01f, -5.87868392e-02f, 9.64729302e-03f, 1.33471578e-01f, 3.48057568e-01f, -1.65193304e-02f, -5.95434383e-02f, 1.24299429e-01f,
  2.01264426e-01f, 2.06971496e-01f, 8.31805021e-02f, 1.45695135e-01f, 5.64725026e-02f, 2.03499183e-01f, 1.91525891e-02f, 2.81739414e-01f, 2.57992119e-01f, -2.51774341e-01f,
  3.37159425e-01f, -2.05523014e-01f, -1.50360152e-01f, 4.29495662e-01f, 7.96409696e-03f, 3.83497588e-02f, -6.90850690e-02f, 3.09507757e-01f, -2.92312680e-03f, 1.15763649e-01f,
  1.94634899e-01f, -3.56362239e-02f, 6.67669252e-02f, -6.06657413e-04f, -1.40270039e-01f, 1.64171755e-01f, 2.91593689e-02f, -9.89006236e-02f, 1.75427310e-02f, -6.52447194e-02f,
  6.05928479e-03f, 1.30420476e-01f, 1.48827732e-01f, -6.85301498e-02f, -1.20469235e-01f, 1.46217346e-01f, -6.13912791e-02f, 1.51714087e-01f, 1.02004901e-01f, -1.00333251e-01f,
  1.14372492e-01f, 1.49694145e-01f, -1.50564499e-02f, 2.07652524e-01f, 6.17123172e-02f, -9.28862318e-02f, -8.73041898e-02f, -2.23021865e-01f, -4.29359786e-02f, -1.26967207e-01f,
  1.76470026e-01f, 2.84976006e-01f, -8.57690647e-02f, -4.61994596e-02f, -1.72068566e-01f, 1.04586773e-01f, -5.52304350e-02f, -9.41899121e-02f, 2.82772575e-02f, 2.17602193e-01f,
  1.18381053e-01f, -1.27760410e-01f, 2.52031296e-01f, -1.78613752e-01f, -1.58886805e-01f, 2.21228972e-01f, 8.41890499e-02f, 1.09574869e-01f, 4.09661978e-02f, -1.50279984e-01f,
  2.46117175e-01f, 1.76083729e-01f, 8.35633799e-02f, -2.10870698e-01f, 2.94838071e-01f, -1.51089681e-02f, 1.59675568e-01f, 9.76124499e-03f, 2.95098405e-02f, 2.73447543e-01f,
  5.41104078e-02f, -8.96682963e-02f, 1.38492659e-01f, 2.06797555e-01f, 3.67476270e-02f, 1.10868141e-01f, 1.54106230e-01f, 1.09764822e-01f, -2.94731259e-02f, 1.02916308e-01f,
  1.44097760e-01f, 2.67700046e-01f, 3.32419991e-01f, 7.19547719e-02f, -9.56435204e-02f, -1.01122752e-01f, -6.45375028e-02f, -6.29535615e-02f, -1.00744009e-01f, 1.41565865e-02f,
  -1.71663284e-01f, -1.44897044e-01f, 2.13693697e-02f, 2.46125963e-02f, -2.01183721e-01f, 1.04132302e-01f, 1.02852866e-01f, -3.64979752e-03f, -1.94557697e-01f, -2.20806152e-01f,
  -5.19099869e-02f, 4.56550531e-02f, -9.37129557e-02f, -1.48652479e-01f, 2.13014483e-02f, 1.52190194e-01f, 2.98678875e-01f, -5.05847707e-02f, 1.12049282e-01f, 7.56595135e-02f,
  4.24093604e-01f, -8.67932104e-03f, 9.81874987e-02f, -2.08673581e-01f, 9.30948555e-02f, 1.17034264e-01f, -1.79643914e-01f, 8.13856646e-02f, 1.48946404e-01f, -1.13658108e-01f,
  -9.97201353e-02f, -1.54174641e-01f, -5.92979193e-02f, 2.41583452e-01f, -1.18774429e-01f, 4.52738591e-02f, 8.33917931e-02f, 2.95756251e-01f, -1.00582510e-01f, 2.51472834e-02f,
  -2.50016421e-01f, 1.21011578e-01f, 1.05025461e-02f, -6.65052161e-02f, 8.12398270e-02f, 3.24208364e-02f, 1.15658022e-01f, -1.26570184e-02f, -1.49243206e-01f, -8.39544386e-02f,
  1.43394247e-01f, 1.65350959e-02f, 6.15940988e-02f, 1.85000420e-01f, -1.42142661e-02f, 7.47417957e-02f, 1.82234615e-01f, 1.76308706e-01f, -2.09133282e-01f, -2.15397239e-01f,
  -1.82578608e-01f, -1.37536407e-01f, 1.48897335e-01f, -1.33763477e-01f, 4.27745692e-02f, 1.44374460e-01f, 2.77788285e-02f, 1.10118240e-01f, 6.53505921e-02f, -1.23014152e-01f,
  7.96837807e-02f, -6.17438182e-02f, 1.36795808e-02f, 1.37938738e-01f, 2.53960729e-01f, 2.59511590e-01f, -1.70466468e-01f, 9.06558707e-02f, 9.90237221e-02f, -1.46039397e-01f,
  1.74443528e-01f, -1.91551581e-01f, 1.79039314e-01f, 3.06045800e-01f, 1.98589619e-02f, 3.18758726e-01f, 1.80993602e-01f, -7.83923417e-02f, 1.60474896e-01f, -1.67571634e-01f,
  8.61436874e-02f, 2.26355065e-02f, 3.25652838e-01f, 8.90201330e-02f, -2.99581498e-01f, -3.95892486e-02f, -7.84326792e-02f, 2.43648112e-01f, 7.56045729e-02f, -1.01819923e-02f,
  1.99370772e-01f, -1.42655641e-01f, 4.76984940e-02f, 1.47488832e-01f, -2.17487261e-01f, -6.38842583e-03f, -1.99388415e-02f, -1.91965312e-01f, 1.97572485e-01f, 3.09673101e-02f,
  3.91875617e-02f, 1.99247122e-01f, 2.61752814e-01f, -3.04867700e-02f, 5.55616766e-02f, 1.53259143e-01f, 1.80674680e-02f, 5.50815910e-02f, 4.99961227e-02f, -1.17463857e-01f,
  2.85200141e-02f, 1.69683561e-01f, 9.66659710e-02f, 4.97295856e-02f, 3.68036360e-01f, 1.41151741e-01f, -1.71267465e-01f, 6.36133179e-02f, -3.54999125e-01f, -2.64615901e-02f,
  1.46502078e-01f, -1.73407346e-01f, 1.16274677e-01f, -4.14196551e-02f, 4.47701924e-02f, -1.46963105e-01f, 8.84361863e-02f, -5.99686168e-02f, -7.07446635e-02f, -4.65048142e-02f,
  1.85547113e-01f, 7.94760212e-02f, -1.25483066e-01f, 7.31922090e-02f, 5.38439788e-02f, 8.10160339e-02f, -1.76684529e-01f, 1.65616706e-01f, 2.57225573e-01f, -6.57548383e-02f,
  -1.86916709e-01f, 2.80434303e-02f, 8.34850594e-02f, 2.77562916e-01f, 5.37762754e-02f, -1.08826369e-01f, -8.02591816e-02f, 5.99768162e-02f, -2.41576061e-01f, 1.86600268e-01f,
  9.44069102e-02f, -6.34353757e-02f, 1.15066439e-01f, 3.55494291e-01f, 1.71934992e-01f, 2.04234153e-01f, 2.94706434e-01f, 2.26091549e-01f, 4.34273891e-02f, 5.94022572e-02f,
  1.78703859e-01f, 2.10466757e-01f, 1.79430649e-01f, -4.17975150e-02f, -4.60422225e-02f, 3.78969684e-02f, 1.08613707e-01f, -9.10652503e-02f, 1.35631740e-01f, 8.00699145e-02f,
  2.33078957e-01f, 1.10071369e-01f, 9.94548127e-02f, 1.19660467e-01f, 2.16462046e-01f, -1.75999757e-03f, -1.32161811e-01f, 1.04342602e-01f, 9.45044979e-02f, -4.09023166e-02f,
  2.11320281e-01f, 7.19366362e-04f, 7.30920434e-02f, -1.36598244e-01f, -4.94413897e-02f, 9.28298756e-02f, 1.68293007e-02f, -3.29358429e-01f, -1.02497652e-01f, -7.75169656e-02f,
  1.78966030e-01f, -1.09368823e-02f, 2.24101648e-01f, 4.43660580e-02f, 3.30514431e-01f, 1.35145128e-01f, -4.04523015e-02f, -1.39807716e-01f, 3.60747725e-02f, 1.68254733e-01f,
  1.24596329e-02f, 2.64328539e-01f, -2.50286400e-01f, 1.40389860e-01f, -6.60532787e-02f, 3.12136889e-01f, 1.42912850e-01f, -5.03141806e-02f, -4.03014459e-02f, 2.40252301e-01f,
  6.06256872e-02f, -1.57076865e-01f, 7.89489448e-02f, 2.26978123e-01f, 2.61426151e-01f, 7.34749436e-02f, -6.75093532e-02f, 5.16984761e-02f, -5.28760552e-02f, -1.36160761e-01f,
  2.35635221e-01f, -1.04236953e-01f, 2.73838602e-02f, -4.06017452e-02f, 2.34788939e-01f, 3.01125436e-03f, -2.18346298e-01f, 1.61477789e-01f, 4.80219908e-02f, 1.46681210e-02f,
  -7.82824028e-03f, 1.23877816e-01f, 1.04107976e-01f, 1.74431309e-01f, 1.07327767e-03f, -7.87124336e-02f, -9.73657221e-02f, 9.28174779e-02f, 1.54476508e-01f, 1.71852112e-02f,
  -1.47697538e-01f, -2.05095828e-01f, -4.34813090e-02f, -1.67249650e-01f, -1.51760399e-01f, -1.92355454e-01f, -5.61895855e-02f, -1.13527790e-01f, -2.85998434e-02f, -1.20021440e-01f,
  -2.32418478e-02f, -1.01310007e-01f, 1.36668041e-01f, -1.06622346e-01f, -8.22617859e-03f, -1.59558319e-02f, -1.13654554e-01f, 3.66679668e-01f, -8.89213458e-02f, 2.39787430e-01f,
  3.69039625e-02f, 9.89708528e-02f, 2.17823818e-01f, -2.10948423e-01f, 3.60969268e-02f, 2.34058559e-01f, 2.56206393e-01f, 3.95956665e-01f, 4.24589450e-03f, 8.18397775e-02f,
  2.39251722e-02f, 1.96469963e-01f, -1.95580363e-01f, 1.80101618e-01f, 1.52880430e-01f, -2.21014634e-01f, 9.28418990e-03f, 1.83366593e-02f, 6.93115592e-02f, 1.35217041e-01f,
  -2.01302558e-01f, -1.39599264e-01f, -2.14937449e-01f, 3.65949601e-01f, -2.88581163e-01f, 1.21697234e-02f, -1.36552617e-01f, -4.14947942e-02f, 1.80391833e-01f, -1.63477787e-03f,
  1.74614741e-03f, -1.86092816e-02f, -2.85859331e-02f, -9.74959508e-02f, -2.30730362e-02f, 8.19101091e-03f, 1.26972467e-01f, 5.95203005e-02f, -1.61607698e-01f, -2.24858791e-01f,
  6.75620958e-02f, 6.20111115e-02f, 1.63137749e-01f, -1.11653460e-02f, -2.26053789e-01f, 1.95883617e-01f, -2.77871966e-01f, -3.38985890e-01f, -1.19169988e-02f, 7.17908740e-02f,
  1.15324803e-01f, 3.14436592e-02f, -2.16142461e-01f, 1.35293245e-01f, 2.15066615e-02f, 1.53316036e-02f, -2.15594824e-02f, 3.04614872e-01f, -5.73665611e-02f, 1.31395578e-01f,
  4.45336729e-01f, -2.72987578e-02f, -1.91903263e-01f, 1.64127961e-01f, 2.84520656e-01f, 5.89648411e-02f, 4.80100885e-02f, -2.35248968e-01f, 3.60558540e-01f, 4.60769892e-01f,
  -1.71203971e-01f, 1.71551660e-01f, 5.67888319e-02f, 1.08705431e-01f, -3.11866179e-02f, -1.86778784e-01f, 4.39984873e-02f, 1.12835325e-01f, -6.29371032e-02f, -2.38552243e-02f,
  2.64570177e-01f, 1.69535533e-01f, 9.91794765e-02f, -2.38287169e-02f, 2.02003401e-02f, -3.20017040e-01f, -2.36188784e-01f, 4.21725698e-02f, -1.70573711e-01f, 1.58227623e-01f,
  1.37033165e-01f, -2.40188375e-01f, -2.96163801e-02f, 1.58719167e-01f, -2.51387000e-01f, 5.05310148e-02f, 2.38192171e-01f, 1.11688003e-01f, 5.00360429e-02f, 4.37265225e-02f,
  -5.18919490e-02f, 3.73350345e-02f, 1.34985015e-01f, 5.45460079e-03f, 1.77995279e-01f, 1.51807532e-01f, -2.57361475e-02f, 1.99005991e-01f, 2.03795373e-01f, 7.51104951e-02f,
  8.99400413e-02f, 3.20320338e-01f, 8.33232552e-02f, 5.80452755e-02f, -6.20861910e-02f, 1.16433561e-01f, 2.14429330e-02f, -1.55220702e-01f, -1.43797606e-01f, -7.22091570e-02f,
  1.36402190e-01f, 2.38583386e-02f, -1.38474286e-01f, 1.50313705e-01f, 2.65132397e-01f, 1.18877860e-02f, 5.60505204e-02f, 1.28839999e-01f, -1.07348025e-01f, 5.65955490e-02f,
  1.07158460e-01f, 1.13642849e-01f, -1.34907722e-01f, -1.69957533e-01f, 2.01199412e-01f, -2.99584955e-01f, -1.22312009e-01f, -6.40807226e-02f, 1.05521068e-01f, 2.08268747e-01f,
  1.53749719e-01f, -1.41966805e-01f, 1.37496710e-01f, 2.00159729e-01f, -1.56359076e-01f, 2.16442376e-01f, -6.11420199e-02f, 2.00824067e-01f, 3.27744842e-01f, 1.05378881e-01f,
  5.94401658e-02f, 1.95960522e-01f, 1.05958730e-01f, -1.33277476e-01f, 2.51871437e-01f, 1.65173188e-01f, -9.79391858e-02f, 1.08062893e-01f, -9.21046287e-02f, 7.27215186e-02f,
  9.27986279e-02f, 1.16287746e-01f, 1.77137285e-01f, 1.27403557e-01f, 6.64760768e-02f, 1.26206398e-01f, -2.49848753e-01f, 1.92292944e-01f, 2.95274798e-02f, -3.67325768e-02f,
  -1.37535064e-02f, 1.42824894e-03f, -3.66087556e-02f, -5.97051606e-02f, 1.98848099e-01f, -1.82636991e-01f, -2.97949582e-01f, -1.33814558e-01f, -2.09812880e-01f, -1.15786940e-01f,
  1.86568975e-01f, -7.93397278e-02f, 3.21709335e-01f, 2.26212829e-01f, 1.27587259e-01f, -1.67097613e-01f, 1.77805036e-01f, 9.01999772e-02f, -1.93358675e-01f, 4.03150693e-02f,
  -1.92756251e-01f, 1.92253247e-01f, 1.25615224e-01f, 1.92704394e-01f, 6.06295727e-02f, -1.07367933e-02f, -8.60258490e-02f, 6.40649796e-02f, 2.45121419e-01f, 1.88077301e-01f,
  1.46118375e-02f, 1.86733484e-01f, -4.36949171e-02f, 1.34914249e-01f, 7.60367066e-02f, -6.12558573e-02f, -1.05772071e-01f, 7.19908252e-02f, -1.07498974e-01f, 2.69976985e-02f,
  1.36646956e-01f, -1.14113964e-01f, -6.43686205e-02f, 1.36650547e-01f, 1.84523463e-02f, 1.66069999e-01f, 1.08423881e-01f, 2.18027025e-01f, -2.15392441e-01f, -1.49999512e-02f,
  -6.27512708e-02f, 1.77365448e-02f, 3.27114284e-01f, -2.31361650e-02f, -6.29755333e-02f, 5.74768335e-02f, 9.70019996e-02f, -3.41997370e-02f, 1.73786223e-01f, 4.29469161e-02f,
  -1.47974059e-01f, -6.03935570e-02f, -1.07071288e-02f, -4.65587787e-02f, 7.35564902e-02f, -9.62131321e-02f, -1.14653870e-01f, 2.82257885e-01f, 8.28166157e-02f, -2.02436805e-01f,
  -1.66129485e-01f, 1.19628288e-01f, -1.45649062e-02f, -2.44083982e-02f, -4.69039679e-02f, -1.32341743e-01f, 2.06722543e-02f, 1.22804962e-01f, -3.85194123e-02f, 1.71947926e-01f,
  -4.19171713e-02f, -1.56245455e-01f, 2.74325386e-02f, -1.61108658e-01f, 1.88388079e-02f, -8.00309330e-03f, 2.60281861e-01f, 3.19386333e-01f, 1.73040852e-01f, -1.37146100e-01f,
  1.00449577e-01f, 2.89818972e-01f, 1.55530781e-01f, 6.50164634e-02f, -6.66215867e-02f, 1.51522562e-01f, 1.82285771e-01f, -1.55103849e-02f, -4.44734134e-02f, 6.20716587e-02f,
  -2.39164263e-01f, -7.43993074e-02f, 3.44469309e-01f, 8.99070278e-02f, 1.77496120e-01f, -1.05078109e-01f, 2.27918513e-02f, 3.44806686e-02f, -1.75750688e-01f, 7.68917724e-02f,
  7.41473213e-02f, -2.41920371e-02f, -2.59530228e-02f, -8.42131749e-02f, 8.49084705e-02f, 2.80692399e-01f, -1.97669283e-01f, 3.12920734e-02f, 1.23338988e-02f, 2.25110009e-01f,
  1.59120366e-01f, 1.05150059e-01f, 3.74585725e-02f, 9.77955908e-02f, 1.89871490e-01f, -5.91985285e-02f, 5.65830916e-02f, 1.98512971e-01f, 2.28884771e-01f, -1.80671979e-02f,
  1.20859690e-01f, 9.46731344e-02f, 2.96698641e-02f, -2.08977368e-02f, -6.08165599e-02f, 2.43776180e-02f, -1.70611620e-01f, -3.20965290e-01f, -1.19649798e-01f, 4.02270071e-03f,
  -1.85487390e-01f, -5.14002070e-02f, -2.03534529e-01f, 4.16491702e-02f, 1.89541847e-01f, -2.85576105e-01f, -2.18584448e-01f, 1.27574345e-02f, 3.06799412e-01f, -1.48939356e-01f,
  -9.34899226e-02f, -2.40747128e-02f, 5.86670004e-02f, 2.20211953e-01f, 2.52119754e-03f, 9.67117921e-02f, 4.49112989e-02f, 8.58400613e-02f, 7.56381825e-03f, 1.42047778e-01f,
  -1.21416740e-01f, 2.90490806e-01f, -3.42908874e-03f, 2.01451018e-01f, -1.56251386e-01f, -2.43004516e-01f, 2.69797385e-01f, -7.57045671e-02f, 1.14751048e-01f, -1.53421193e-01f,
  -1.73727319e-01f, 3.30838412e-02f, 7.13393744e-03f, 3.55239838e-01f, 7.31981248e-02f, 8.02860931e-02f, 2.03565791e-01f, 3.53563204e-02f, 3.84825081e-01f, 1.10118531e-01f,
  1.67823389e-01f, 5.44375293e-02f, 3.09666321e-02f, 2.51544714e-02f, -1.23170726e-01f, 3.56649347e-02f, 6.83341324e-02f, -4.45629023e-02f, 1.49366096e-01f, -1.16992526e-01f,
  3.19187082e-02f, 1.30122557e-01f, 5.47783040e-02f, 3.73552516e-02f, 2.82560121e-02f, 1.13198653e-01f, -3.27530771e-01f, 2.32520755e-02f, 2.49778479e-01f, 1.76262200e-01f,
  2.60759801e-01f, 2.34654933e-01f, -1.59701705e-01f, -1.92004372e-03f, -3.14680099e-01f, -9.14337113e-03f, 9.82145593e-02f, 2.79472977e-01f, -3.46003264e-01f, 8.90864432e-02f,
  2.88308620e-01f, -4.36773784e-02f, -4.72723395e-02f, -5.36906794e-02f, 1.96589619e-01f, -2.84852292e-02f, 1.63107947e-01f, -2.91112810e-01f, 2.27199003e-01f, 8.87022540e-02f,
  3.65918726e-02f, -7.88630918e-02f, 1.01393096e-01f, -1.95184723e-01f, 1.55147284e-01f, -1.30578443e-01f, 1.23533152e-01f, 1.97524801e-01f, 2.26682648e-01f, 1.74158856e-01f,
  4.80391346e-02f, -2.99707819e-02f, -1.43635646e-01f, 1.78607002e-01f, 2.01869011e-01f, -1.11398220e-01f, 1.69881154e-02f, -4.62351367e-02f, -1.64763018e-01f, -8.08980167e-02f,
  9.22491699e-02f, 6.29031360e-02f, 1.20852441e-02f, 5.25727943e-02f, -1.25511512e-01f, -7.68571869e-02f, 3.21426749e-01f, 5.72641827e-02f, 1.23755030e-01f, 6.58855215e-02f,
  -4.96508367e-03f, 1.41749397e-01f, 1.79595593e-02f, 4.43423018e-02f, 6.62570968e-02f, 8.62322748e-02f, -8.69799331e-02f, 3.86058204e-02f, 2.15095300e-02f, -5.83549775e-03f,
  1.48618162e-01f, -1.10940821e-01f, 2.62090750e-03f, 6.22631423e-02f, 5.96004091e-02f, -1.11918636e-01f, 4.95365001e-02f, 1.80576697e-01f, 1.87711626e-01f, -4.88648750e-02f,
  6.79354146e-02f, -8.91410932e-03f, 2.12143719e-01f, 1.39693469e-01f, 1.90184891e-01f, -1.50224283e-01f, 2.51556952e-02f, -2.08687037e-01f, -6.26920760e-02f, -2.85498142e-01f,
  -5.21406755e-02f, 2.01329783e-01f, -1.75128225e-02f, 3.03864311e-02f, 5.56284599e-02f, -2.13649914e-01f, 2.14890569e-01f, 9.14836489e-03f, -6.87127337e-02f, -1.16031684e-01f,
  5.80121428e-02f, -1.69263989e-01f, 2.06646070e-01f, 9.61488485e-02f, -5.39392084e-02f, 8.18685442e-02f, 2.06857949e-01f, 2.47375935e-01f, -5.57880662e-02f, -1.90088660e-01f,
  1.73447222e-01f, -9.23390910e-02f, -2.35719252e-02f, 3.82524431e-01f, -2.09415480e-02f, 1.09237827e-01f, -1.77722692e-01f, -2.61146069e-01f, 3.23176980e-01f, 3.86877716e-01f,
  9.97857004e-03f, -3.76604609e-02f, -1.80186182e-01f, 4.46544103e-02f, 1.31197691e-01f, 6.45479858e-02f, -7.50538185e-02f, 2.25468576e-01f, -3.17386948e-02f, -2.22747371e-01f,
  -1.94019210e-02f, -7.59620816e-02f, -9.08001661e-02f, -2.04365507e-01f, 3.21710445e-02f, -2.65136689e-01f, -1.38233423e-01f, -1.17259599e-01f, -1.53531343e-01f, 4.44698147e-02f,
  2.80275583e-01f, 3.01181376e-01f, 2.90607840e-01f, 2.94286489e-01f, 2.72799104e-01f, -1.02246717e-01f, 6.68101609e-02f, 2.03949988e-01f, -3.29176366e-01f, 1.62672743e-01f,
  -1.86644360e-01f, -3.43162194e-02f, 1.47902682e-01f, 1.69452175e-01f, 9.48409885e-02f, 5.69091551e-02f, 5.27453423e-02f, -1.43008187e-01f, 2.22662747e-01f, 1.68476507e-01f,
  3.19287837e-01f, -1.86156869e-01f, 2.49754116e-01f, -8.44822824e-03f, 9.33208987e-02f, -2.26314180e-03f, 3.82909812e-02f, 2.49695003e-01f, -7.96456169e-03f, 7.20176622e-02f,
  -1.37478083e-01f, 1.23334974e-01f, -4.43182029e-02f, 1.23007447e-01f, 3.46365482e-01f, -1.26249969e-01f, 9.35755819e-02f, 3.79545093e-01f, -2.70445257e-01f, 1.24669261e-01f,
  -2.62141019e-01f, 4.81065437e-02f, 3.54920328e-01f, 5.14589064e-02f, 7.08340183e-02f, 8.64087865e-02f, -1.04561001e-01f, 1.45129532e-01f, 2.04825938e-01f, 1.19404443e-01f,
  3.88103545e-01f, 1.20409273e-01f, 8.29714537e-02f, 1.05533659e-01f, 2.50898689e-01f, 1.10367544e-01f, 1.91296097e-02f, 1.51443249e-02f, -2.94737428e-01f, 1.95053920e-01f,
  2.94804215e-01f, 7.98871443e-02f, 2.02197984e-01f, 8.24782625e-03f, -1.24393962e-01f, 1.04566313e-01f, -3.57445359e-01f, 8.38340744e-02f, -1.36686161e-01f, 2.62595385e-01f,
  -1.45440310e-01f, -6.80116564e-02f, 1.57590225e-01f, 4.75017503e-02f, 2.01800108e-01f, -4.32132520e-02f, 8.79877955e-02f, -6.65797144e-02f, 9.20260623e-02f, 1.22484200e-01f,
  2.58873016e-01f, -1.11402638e-01f, -1.44939885e-01f, 5.06330170e-02f, 7.80492416e-03f, -1.00385956e-01f, -7.93198049e-02f, 9.18624401e-02f, -9.63274948e-03f, 1.82288572e-01f,
  -2.16345396e-02f, -5.74889369e-02f, 2.56964922e-01f, -1.00355886e-01f, -2.05727935e-01f, -9.52466950e-02f, 5.33689782e-02f, -4.31421772e-02f, -1.35596007e-01f, 3.49737369e-02f,
  1.67749804e-02f, -1.51835948e-01f, 3.05705160e-01f, 1.42220408e-02f, 1.69600844e-01f, 3.84804830e-02f, -1.25798702e-01f, -9.52177271e-02f, 2.66356766e-02f, -1.63781032e-01f,
  -1.50044337e-01f, -1.09416239e-01f, 1.84646219e-01f, 8.21564794e-02f, 1.11231647e-01f, 2.33508244e-01f, 1.37801126e-01f, 1.38082076e-02f, -2.23674309e-02f, 1.57068506e-01f,
  -1.02906667e-01f, -1.94203705e-01f, -8.93578753e-02f, 8.35688859e-02f, 1.78655341e-01f, -1.56579465e-01f, -9.32110474e-02f, 3.43730867e-01f, 1.51748464e-01f, 1.08113497e-01f,
  1.69420570e-01f, -1.42116413e-01f, 3.04518759e-01f, -6.48690015e-02f, -1.34164348e-01f, 3.13210636e-01f, 2.58766025e-01f, 3.00419778e-01f, 4.16220501e-02f, 2.94939131e-01f,
  1.61886457e-02f, -4.34528142e-02f, 1.44204348e-01f, -5.28799333e-02f, -6.61371350e-02f, 4.59317409e-04f, -6.70775175e-02f, 3.65618058e-02f, -1.44993097e-01f, -9.38408300e-02f,
  2.11333826e-01f, 8.67460482e-03f, 1.79963484e-01f, 7.82082602e-02f, 3.34446818e-01f, 1.19052678e-01f, -2.81551719e-01f, 3.46044660e-01f, -2.29496121e-01f, 1.08456396e-01f,
  1.60856962e-01f, 1.50079861e-01f, 1.48209304e-01f, -1.95819244e-01f, 2.92093456e-01f, 2.59125941e-02f, 2.97330450e-02f, 9.75023508e-02f, -1.78733349e-01f, 4.21696668e-03f,
  -2.40674004e-01f, 9.82424840e-02f, -8.54530707e-02f, 1.47991598e-01f, -5.29434532e-02f, 5.78794144e-02f, 8.67143795e-02f, 1.19031273e-01f, 2.24526867e-01f, 7.34088644e-02f,
  -6.69613406e-02f, 1.83335409e-01f, 3.33027065e-01f, -3.12565379e-02f, -2.77961165e-01f, -1.84594378e-01f, -1.61190569e-01f, -2.17710078e-01f, 1.96506709e-01f, -3.51404510e-02f,
  2.39103481e-01f, -2.17357501e-01f, -1.71014726e-01f, 1.06532589e-01f, -2.50122398e-01f, -2.44363144e-01f, -1.03035718e-01f, 2.33416427e-02f, 1.91024572e-01f, -2.05084011e-01f,
  3.50246094e-02f, 1.57901943e-01f, 1.05989046e-01f, -1.65065363e-01f, 1.82574630e-01f, -9.90769491e-02f, 6.36170655e-02f, 5.39883040e-02f, 2.29713410e-01f, 1.89653307e-01f,
  -1.64996814e-02f, 4.04737473e-01f, 2.60983109e-01f, 1.99904650e-01f, 5.71387447e-03f, -2.04088181e-01f, -2.96266466e-01f, 2.41513163e-01f, 1.80803671e-01f, -1.67213663e-01f,
  2.07542717e-01f, -2.68941611e-01f, 1.46758601e-01f, 1.49385706e-01f, -2.78708637e-01f, -7.26467818e-02f, -3.35055888e-02f, -4.04357612e-02f, -8.60159472e-02f, -9.90290493e-02f,
  -1.41354814e-01f, 2.64048040e-01f, 2.75917441e-01f, -1.39391452e-01f, 6.58085495e-02f, 2.27776259e-01f, -3.56160887e-02f, 2.67090052e-02f, 1.26307622e-01f, -1.04902342e-01f,
  1.02177300e-01f, 1.17722757e-01f, 3.69230052e-03f, 7.02146590e-02f, -2.36967839e-02f, -6.60929456e-02f, -1.50844008e-01f, -1.16933165e-02f, -7.56215975e-02f, 5.28268144e-03f,
  2.11615101e-01f, -6.57697842e-02f, -1.23009250e-01f, -1.00821674e-01f, -1.43867791e-01f, -7.88224488e-02f, 2.08347008e-01f, 4.32033725e-02f, 3.40957791e-01f, -1.10761069e-01f,
  -1.12799816e-02f, -2.17235491e-01f, 3.07292640e-01f, 8.54080543e-02f, -8.34795386e-02f, 1.50291055e-01f, 1.91381156e-01f, 1.41596332e-01f, -6.04201071e-02f, -2.86752754e-03f,
  -1.90350756e-01f, 1.93540841e-01f, -2.18658566e-01f, 1.80611610e-01f, -1.17384836e-01f, 2.28467554e-01f, -5.37950844e-02f, 2.69637883e-01f, -1.14125617e-01f, 1.30435139e-01f,
  1.61637738e-01f, -5.66064082e-02f, -1.33457333e-01f, 7.18430206e-02f, -8.95461440e-02f, 1.81867078e-01f, 2.57753283e-01f, -6.35283366e-02f, 4.92292754e-02f, 1.53845906e-01f,
  1.63979366e-01f, -3.12104132e-02f, 2.39964038e-01f, 2.76461631e-01f, 7.46586248e-02f, -5.85559942e-02f, 1.57389283e-01f, 1.73988789e-01f, 2.18135834e-01f, 5.60648218e-02f,
  -5.77543601e-02f, 4.27140631e-02f, -1.51901931e-01f, 5.65367527e-02f, 2.15243638e-01f, 1.16415080e-02f, 3.20819557e-01f, 1.64691299e-01f, 1.35611132e-01f, -2.46262513e-02f,
  1.12243831e-01f, 1.56075433e-01f, 9.61674154e-02f, 1.20535731e-01f, -2.37622380e-01f, 1.52308837e-01f, 2.34613776e-01f, 9.06443521e-02f, 7.18759075e-02f, 2.08150059e-01f,
  -6.83102310e-02f, 1.16748706e-01f, -3.76691148e-02f, 1.96710736e-01f, -9.34429374e-03f, 3.23030949e-01f, -2.76691049e-01f, 2.71738350e-01f, 1.82579726e-01f, 1.53409600e-01f,
  1.02577612e-01f, 8.57533664e-02f, 1.94609329e-01f, 8.77406895e-02f, 9.08756554e-02f, -5.77619970e-02f, 2.02548832e-01f, -4.33767140e-02f, -2.32356921e-01f, -5.10265073e-03f,
  -1.38879120e-02f, -2.09630415e-01f, 1.04327276e-01f, 7.63618350e-02f, 3.53340983e-01f, 2.75783479e-01f, 1.58594418e-02f, 2.73560762e-01f, 9.68644992e-02f, 1.56208083e-01f,
  -3.57263476e-01f, -9.72756669e-02f, 2.67532974e-01f, 2.12953031e-01f, 1.69938505e-01f, -9.69217047e-02f, 2.19536781e-01f, 4.52739373e-02f, 3.07910204e-01f, -3.91641259e-02f,
  2.08991170e-02f, 2.93779552e-01f, -4.28049117e-02f, -2.62071222e-01f, 1.04703873e-01f, 8.68761614e-02f, 1.86771695e-02f, 9.40010622e-02f, -5.76839000e-02f, 4.63553704e-02f,
  2.64327794e-01f, 8.78381059e-02f, 1.27581552e-01f, 1.86951160e-01f, 9.52742621e-02f, 7.33048469e-02f, 2.54420370e-01f, -1.47783294e-01f, -7.44690048e-03f, 2.60975152e-01f,
  1.61182880e-01f, -7.38322064e-02f, 1.87748507e-01f, 2.03795955e-01f, -2.41327826e-02f, -6.12147823e-02f, -3.60555381e-01f, -1.89572811e-01f, -3.88903134e-02f, 1.87814459e-01f,
  1.78776234e-01f, -1.88366845e-02f, -3.82269993e-02f, 9.46641117e-02f, 2.01538116e-01f, -4.75816242e-02f, -2.00724319e-01f, -7.66808689e-02f, -1.74340799e-01f, 2.38202199e-01f,
  -2.09083721e-01f, -4.40486342e-01f, -1.01736531e-01f, -1.65004939e-01f, 1.35422125e-01f, -3.11352480e-02f, -3.32760103e-02f, -3.94561701e-02f, 1.33463740e-01f, -1.57605946e-01f,
  2.80535132e-01f, 2.16019034e-01f, 1.13616072e-01f, -7.10339397e-02f, -5.61924465e-02f, 1.79832831e-01f, 2.19249457e-01f, 2.28263121e-02f, 4.00943719e-02f, -3.06207269e-01f,
  6.49760524e-03f, -2.79870898e-01f, 3.63878012e-01f, 3.49292129e-01f, 8.90953913e-02f, -1.59369130e-02f, 7.92064518e-03f, 2.21330345e-01f, 3.95362489e-02f, 1.85949609e-01f,
  4.51351851e-02f, 2.28719711e-01f, -1.51880188e-02f, 6.31427690e-02f, 2.50145435e-01f, 2.93842833e-02f, -1.92351658e-02f, 2.33734876e-01f, 2.20958427e-01f, 5.32754399e-02f,
  1.72667742e-01f, 3.34234461e-02f, -1.72913447e-01f, 2.15555221e-01f, 1.20022818e-01f, 7.85199106e-02f, 1.77580789e-01f, 1.21197328e-02f, -1.91431537e-01f, -2.34508395e-01f,
  -3.60224754e-01f, 1.00452602e-02f, -1.15284458e-01f, 2.14441806e-01f, -6.25741621e-03f, -2.30310997e-03f, 7.34785423e-02f, 1.09868303e-01f, 1.51277436e-02f, 1.49911731e-01f,
  8.83546546e-02f, 1.83520466e-01f, 8.71439725e-02f, -4.78907116e-02f, 2.17668638e-01f, -9.61838514e-02f, 6.64280578e-02f, 1.65514097e-01f, 2.89757550e-02f, -1.96972098e-02f,
  -7.22841024e-02f, 1.78892821e-01f, 1.12053804e-01f, 6.99789897e-02f, 3.40586808e-03f, 1.05371840e-01f, 2.45714724e-01f, -1.02043673e-01f, -7.39962086e-02f, -1.79702286e-02f,
  1.71745136e-01f, 3.59062031e-02f, -1.20424941e-01f, 3.22522789e-01f, -1.24134466e-01f, -2.67897248e-01f, 2.32199416e-01f, 3.45229469e-02f, 3.03921640e-01f, 1.22868940e-01f,
  6.58925027e-02f, -1.58326432e-01f, 1.07420571e-01f, 1.14733070e-01f, 8.98791477e-02f, 3.75440307e-02f, 9.23822913e-03f, 1.05872713e-01f, 1.37392849e-01f, -6.63726497e-03f,
  2.23603874e-01f, 8.30004737e-02f, 7.54196011e-03f, -4.21207063e-02f, 1.19858131e-01f, -1.75861362e-02f, 2.68614918e-01f, 1.07338339e-01f, 3.95717807e-02f, 2.84487177e-02f,
  -1.20519295e-01f, -1.52090713e-01f, 4.14673649e-02f, 2.49569714e-02f, -9.36151445e-02f, -2.34950989e-01f, 1.22305363e-01f, -7.51590729e-02f, 2.01897889e-01f, -1.00429781e-01f,
  -7.76750520e-02f, -7.60582909e-02f, 3.74851704e-01f, -9.11886618e-02f, -2.59700686e-01f, -8.93310159e-02f, 1.17893077e-01f, 3.58012617e-01f, -1.98388696e-01f, -1.63030520e-01f,
  1.38041466e-01f, -2.40314275e-01f, -6.12845197e-02f, 1.40682250e-01f, 1.15957923e-01f, 1.44634351e-01f, -1.06413029e-01f, 5.40750287e-02f, 1.40809670e-01f, -9.94631425e-02f,
  7.79395401e-02f, 1.24664865e-01f, 1.93138376e-01f, 1.46843910e-01f, -3.29860337e-02f, 6.68769553e-02f, -6.99335802e-03f, 3.00756618e-02f, 1.04234762e-01f, -7.98879638e-02f,
  9.27049369e-02f, 3.29682767e-01f, 3.31042744e-02f, -4.44104224e-02f, -2.36725137e-01f, 3.90489101e-01f, -6.25875639e-03f, 1.18830763e-01f, 1.39455393e-01f, 2.09131673e-01f,
  1.68843299e-01f, 1.07400820e-01f, -7.16404021e-02f, -4.73487162e-04f, 6.87377453e-02f, 1.62950128e-01f, 1.43697917e-01f, 6.29802421e-03f, -3.50819454e-02f, 2.01711565e-01f,
  -4.89019379e-02f, -8.65133628e-02f, -2.07648799e-01f, 2.24206552e-01f, -7.74968863e-02f, -1.14255533e-01f, -5.22034094e-02f, -2.61014886e-02f, -9.34083909e-02f, 2.07671076e-01f,
  -6.09570406e-02f, 2.62249410e-01f, -1.83942899e-01f, -1.85152769e-01f, -7.13259652e-02f, -1.04605339e-01f, 8.47062096e-03f, -5.71512692e-02f, 2.01320305e-01f, 3.28152329e-01f,
  9.81442332e-02f, -8.35636407e-02f, 1.33137420e-01f, 1.06649138e-01f, 3.70686084e-01f, -1.69207841e-01f, 4.59668925e-03f, 6.22602971e-03f, 4.89870682e-02f, 9.88385007e-02f,
  -4.45963629e-02f, -5.44631779e-02f, -2.61634409e-01f, -7.66558275e-02f, 3.03654671e-01f, 5.15940040e-03f, 7.27837086e-02f, -8.45437646e-02f, 1.74353532e-02f, 5.54731227e-02f,
  -1.98995113e-01f, 1.98531687e-01f, -6.96883071e-03f, -6.88685551e-02f, 4.88518924e-02f, -7.31634349e-02f, 1.09659247e-01f, 2.06142023e-01f, -1.81483045e-01f, -9.36451629e-02f,
  6.14750460e-02f, 8.12337622e-02f, 1.15955830e-01f, 5.47225475e-02f, -2.43818238e-02f, -8.20438787e-02f, 6.43640012e-02f, -1.63369805e-01f, -6.69586239e-03f, 1.99555084e-01f,
  -3.58720240e-03f, -2.34883931e-02f, 8.45791847e-02f, 2.06492439e-01f, -1.20083466e-02f, -3.11831408e-03f, 9.79303345e-02f, 1.36717319e-01f, 2.06561416e-01f, 2.87623866e-03f,
  -2.21018270e-01f, -1.39738381e-01f, -1.90834597e-01f, -2.64749944e-01f, -2.17551291e-02f, 1.92352206e-01f, 1.21136621e-01f, 6.23039417e-02f, 1.71750322e-01f, -3.14547718e-02f,
  2.08087340e-01f, -4.24038433e-02f, 1.70348641e-02f, -7.36396089e-02f, 8.98621380e-02f, 9.31931809e-02f, 9.16619226e-02f, 1.14425674e-01f, -1.22966066e-01f, -4.39315140e-02f,
  1.19416945e-01f, 1.98059440e-01f, 1.15090519e-01f, -8.00923407e-02f, 4.06431220e-02f, 9.67357606e-02f, 1.05551332e-01f, 1.16068097e-02f, 2.83138931e-01f, 1.35506496e-01f,
  3.17301661e-01f, 2.83539057e-01f, 2.24749697e-03f, -1.31068230e-01f, -7.03063011e-02f, 4.07504551e-02f, -6.53575584e-02f, -1.15468539e-01f, 1.49555266e-01f, 1.36312634e-01f,
  1.49791554e-01f, -2.81264400e-03f, -1.54438049e-01f, 2.93302506e-01f, 1.17920049e-01f, 6.10221662e-02f, 6.90369457e-02f, 1.19077191e-02f, 1.30234053e-03f, 1.86072215e-02f,
  -2.54376195e-02f, 1.29918516e-01f, 1.38276741e-01f, 2.12415844e-01f, 3.25233713e-02f, -2.92090010e-02f, -1.87162384e-01f, -7.52524585e-02f, -2.25945450e-02f, -1.62578329e-01f,
  7.31913149e-02f, -3.54334824e-02f, 1.21887259e-01f, -1.05668783e-01f, 2.65517011e-02f, 1.96124583e-01f, 1.31306976e-01f, -2.56841302e-01f, -1.48919439e-02f, -7.23255277e-02f,
  2.11091504e-01f, 1.06387042e-01f, 3.40816408e-01f, 1.32343799e-01f, 1.12210046e-02f, 2.04757303e-02f, -2.75931153e-02f, -2.35045105e-01f, -7.63133448e-03f, 5.97553700e-02f,
  1.57445803e-01f, 3.07099879e-01f, -3.79966348e-02f, 1.52895093e-01f, 2.24958405e-01f, 1.04786888e-01f, -2.81446557e-02f, -1.44017994e-01f, -3.82359256e-03f, 6.13325136e-03f,
  1.71432063e-01f, 5.20571470e-02f, -7.57762939e-02f, 7.86390454e-02f, 2.82580674e-01f, 2.88656801e-01f, -6.65507466e-02f, -1.99338868e-01f, 1.18196920e-01f, -1.10342324e-01f,
  1.16613032e-02f, 2.24700019e-01f, -8.41148421e-02f, 2.46124025e-02f, -8.43575373e-02f, -1.32656977e-01f, 1.67150795e-01f, 2.24894330e-01f, 2.18044631e-02f, -1.48617312e-01f,
  -4.69119241e-03f, 3.28559913e-02f, 1.30710647e-01f, -1.72038749e-03f, 1.30152171e-02f, 6.79367734e-03f, 1.02125280e-01f, -3.38077433e-02f, -2.20400855e-01f, 7.53879249e-02f,
  1.73675381e-02f, 5.25625683e-02f, -1.15098685e-01f, -4.93259542e-02f, -1.07784513e-02f, -1.11848570e-01f, 1.01479925e-01f, 7.06167296e-02f, 6.54371679e-02f, 2.02533066e-01f,
  2.58037984e-01f, 2.13699177e-01f, 1.43673196e-01f, 2.35642567e-01f, 3.30267847e-02f, 4.16542619e-01f, 7.11164623e-02f, 1.22492775e-01f, -6.37786556e-03f, 2.79417157e-01f,
  1.14990972e-01f, -6.62517035e-03f, -1.96845531e-01f, 9.72429439e-02f, -3.30858342e-02f, -1.96610436e-01f, -2.43910789e-01f, -2.28916947e-03f, 1.58165451e-02f, -4.78832647e-02f,
  -1.08412005e-01f, 1.63318023e-01f, 2.99727291e-01f, 1.96452647e-01f, 2.18548253e-03f, 1.66581661e-01f, 1.62757412e-01f, 2.80481249e-01f, -9.81434807e-02f, -9.53057557e-02f,
  1.60183638e-01f, -1.08718015e-01f, -1.64979361e-02f, -8.28121603e-02f, 7.90822506e-03f, 2.50781238e-01f, 3.64287317e-01f, -7.20370859e-02f, -2.37629518e-01f, 1.80836201e-01f,
  -7.72980228e-02f, 1.04491539e-01f, 1.83306769e-01f, -6.33662567e-02f, 1.33591473e-01f, -3.45573425e-02f, 1.90227196e-01f, 7.70105049e-02f, 1.87055305e-01f, 1.54075950e-01f,
  2.08198145e-01f, -4.29687239e-02f, -6.93664625e-02f, 1.03231549e-01f, 1.20379319e-02f, -1.16794743e-01f, -1.00590112e-02f, -7.52125531e-02f, 9.11529213e-02f, -1.68110371e-01f,
  1.58435255e-02f, 6.86649308e-02f, 1.52289018e-01f, 2.52231449e-01f, 2.07662553e-01f, -1.35755613e-01f, -3.51328892e-03f, -1.85261294e-01f, 1.95136726e-01f, 3.32286090e-01f,
  2.73762226e-01f, 1.49590343e-01f, -2.51400657e-02f, 1.44058719e-01f, -1.66100159e-01f, -3.24878126e-01f, -2.59368211e-01f, 2.00969592e-01f, -1.07586026e-01f, -3.19508836e-02f,
  -1.34909257e-01f, 6.23343401e-02f, 1.83428451e-01f, 8.08162391e-02f, -1.16788089e-01f, -4.69509251e-02f, 2.01491818e-01f, -1.80978164e-01f, 2.73829073e-01f, 2.59055883e-01f,
  -2.84693122e-01f, 1.65393248e-01f, 9.89910364e-02f, 2.39757210e-01f, 6.65726066e-02f, 2.56632571e-03f, 2.99168915e-01f, -1.99787453e-01f, 1.26045197e-01f, 4.13764894e-01f,
  1.41529635e-01f, 1.01334214e-01f, -1.86984167e-01f, -1.61594868e-01f, 3.29404593e-01f, 2.42170915e-01f, -1.47147894e-01f, 1.05612129e-01f, 3.75607386e-02f, 7.57994503e-02f,
  1.44138232e-01f, 1.04323432e-01f, -3.73522229e-02f, 6.31563291e-02f, -1.57313779e-01f, -1.24651536e-01f, 6.81341290e-02f, 4.41667438e-03f, -4.69600856e-02f, -1.17872141e-01f,
  3.90188992e-02f, -7.28104934e-02f, -2.01259091e-01f, -8.06105733e-02f, -1.58689454e-01f, 4.20441069e-02f, 2.29673292e-02f, -1.41039297e-01f, 2.54594162e-02f, 1.40078828e-01f,
  7.24535584e-02f, 5.21180145e-02f, -1.24622203e-01f, -5.87418005e-02f, -2.91122049e-01f, 2.82964587e-01f, -1.87039971e-02f, 3.17926407e-01f, 1.78494275e-01f, 3.03409666e-01f,
  1.08100221e-01f, -1.56771466e-01f, 1.35250082e-02f, 1.02065466e-01f, 1.61961362e-01f, 3.89452666e-01f, -1.78047985e-01f, 4.69711609e-02f, 1.00995086e-01f, 2.66655147e-01f,
  6.58017918e-02f, 2.21172616e-01f, -5.56491055e-02f, 2.66342144e-03f, 1.58560172e-01f, 4.09443974e-02f, -4.15221639e-02f, -2.02732921e-01f, 1.65602431e-01f, 2.08963215e-01f,
  -1.66697219e-01f, 1.77135676e-01f, 2.84058414e-03f, -1.84474081e-01f, 2.15893276e-02f, -6.97610155e-02f, 2.32585669e-01f, 3.64674747e-01f, -4.60198633e-02f, -2.84817010e-01f,
  -3.66604887e-02f, -3.41331400e-02f, 1.70213565e-01f, -1.90614045e-01f, 1.39074385e-01f, -4.54359408e-03f, -5.33234358e-01f, -1.82186607e-02f, 8.59473869e-02f, -2.02671409e-01f,
  -1.00388229e-01f, -2.84807086e-01f, -1.00505039e-01f, 2.00311393e-01f, 4.06767219e-01f, -2.38432810e-01f, -2.98034161e-01f, 1.22932278e-01f, -2.73665905e-01f, -3.12154088e-03f,
  1.54225498e-01f, 8.63987431e-02f, 3.62608582e-01f, -2.90556978e-02f, 2.95920134e-01f, -2.36398026e-01f, 1.46514222e-01f, -2.11581611e-03f, 6.42419159e-02f, -4.15746152e-01f,
  -1.84006430e-02f, -5.79669327e-02f, 8.32787082e-02f, 2.78689533e-01f, 1.81661040e-01f, -1.55085372e-02f, -1.03593059e-01f, 3.96265745e-01f, 2.66712546e-01f, -2.51149625e-01f,
  5.28314002e-02f, 3.28369379e-01f, 3.51930529e-01f, -1.37854382e-01f, -1.71363838e-02f, -1.70877308e-01f, -1.44594729e-01f, 9.16085988e-02f, -8.26308206e-02f, 3.31874520e-01f,
  3.57054412e-01f, 9.83813778e-02f, -1.79048628e-02f, 8.25488865e-02f, 1.04465656e-01f, -1.32422745e-01f, 2.20216051e-01f, 3.60679090e-01f, -3.86567175e-01f, -1.31902754e-01f,
  -3.34645778e-01f, 1.25450343e-01f, -5.80220409e-02f, 2.47002542e-01f, -5.87302865e-03f, 1.99249879e-01f, -6.65032119e-02f, 8.39046910e-02f, -1.33354599e-02f, -2.08299998e-02f,
  1.43329740e-01f, -1.52369708e-01f, -1.15962792e-02f, -3.71951163e-02f, 8.83178711e-02f, 2.00429279e-02f, 1.40115589e-01f, 8.08087289e-02f, 6.10398035e-03f, 8.49816129e-02f,
  -7.41905272e-02f, 1.92742869e-01f, -1.40779868e-01f, 2.06941977e-01f, -5.27997427e-02f, -2.06449583e-01f, -2.57911175e-01f, 1.05685167e-01f, 1.37109846e-01f, 2.13486731e-01f,
  -2.98843682e-01f, -1.34066373e-01f, -1.93045080e-01f, -1.30078811e-02f, 1.92030929e-02f, -1.04146255e-02f, 1.35078996e-01f, 2.40330800e-01f, 2.62824923e-01f, -9.49755833e-02f,
  2.20763996e-01f, -2.74672806e-02f, 2.65723288e-01f, -6.62655756e-02f, -7.69495517e-02f, -1.57880589e-01f, 2.32045367e-01f, 2.06022263e-01f, 1.14425898e-01f, 2.12536305e-01f,
  -3.04144751e-02f, 1.10688157e-01f, 2.81845421e-01f, 2.34409217e-02f, -1.74210414e-01f, 8.35282058e-02f, 1.70111343e-01f, 1.51610583e-01f, -1.70474325e-03f, 2.09464654e-01f,
  -8.02387521e-02f, -9.74235460e-02f, 1.90317348e-01f, 5.93964867e-02f, 2.17173919e-01f, 3.23232532e-01f, -2.56707370e-01f, -1.26185194e-01f, 1.12925567e-01f, 7.52524510e-02f,
  2.29099631e-01f, 1.21071815e-01f, 1.25116348e-01f, 1.77409336e-01f, -3.70523259e-02f, 1.23137139e-01f, 1.53827459e-01f, 3.74862075e-01f, 4.17957067e-01f, 7.94941559e-02f,
  -2.54236996e-01f, -8.31332207e-02f, -9.48531255e-02f, -1.95647418e-01f, -6.11251853e-02f, -6.45759031e-02f, 1.35051265e-01f, -2.41848662e-01f, -1.31223455e-01f, 1.83048230e-02f,
  -1.31804258e-01f, -2.62454003e-01f, -2.86918436e-03f, -4.42184322e-02f, 1.48612007e-01f, -7.55343661e-02f, 3.59917939e-01f, 6.20406978e-02f, 6.54228544e-03f, 9.04014707e-03f,
  2.44213436e-02f, 2.77043320e-02f, 1.32838130e-01f, -2.77186986e-02f, 9.28679854e-02f, 3.99224967e-01f, 2.43023723e-01f, 1.93719968e-01f, 2.03252405e-01f, 2.16598079e-01f,
  -1.00799337e-01f, -7.81521648e-02f, -2.52273381e-01f, -6.26400718e-03f, 2.33345807e-01f, -2.24734604e-01f, 6.01736717e-02f, -1.37255579e-01f, 3.55986118e-01f, 2.40218595e-01f,
  -1.64112374e-01f, -1.61616936e-01f, -2.46155232e-01f, 1.38844550e-01f, -2.15235904e-01f, -9.08703506e-02f, -1.94262743e-01f, -4.04388011e-02f, 6.50567934e-02f, -2.54745424e-01f,
  3.56329791e-02f, 2.83718854e-01f, -1.12077259e-02f, 1.17951185e-01f, 1.28410622e-01f, -7.72703514e-02f, -1.36594191e-01f, 6.00547753e-02f, 1.44368932e-01f, 2.32882090e-02f,
  -1.29520521e-01f, -8.74897651e-03f, -1.44635901e-01f, -3.35849449e-02f, 7.71083683e-02f, -7.69586861e-02f, 3.08626682e-01f, 1.55814543e-01f, 7.01591298e-02f, -1.04190655e-01f,
  -2.78453138e-02f, 3.21443602e-02f, -8.09819698e-02f, -2.86350429e-01f, -1.16205476e-01f, -3.91404837e-01f, -5.01858406e-02f, -1.07637525e-01f, 3.54984283e-01f, -1.44044191e-01f,
  -1.29224643e-01f, 1.70393497e-01f, 4.41660881e-01f, 1.78372681e-01f, -2.01124519e-01f, -8.29121321e-02f, -1.64890215e-01f, 2.45487511e-01f, -1.31864086e-01f, 7.61131123e-02f,
  -1.06790483e-01f, 2.39849418e-01f, -1.41157240e-01f, 3.65397573e-01f, 7.78800026e-02f, 1.14332221e-01f, -3.02836969e-02f, -1.51525894e-02f, 5.53714782e-02f, -9.71011538e-03f,
  1.05845787e-01f, 1.05881847e-01f, 2.71652639e-01f, 1.65296659e-01f, 8.87409300e-02f, 1.66165888e-01f, 9.92293507e-02f, -6.59184903e-02f, 2.04938293e-01f, -2.48757094e-01f,
  1.17207177e-01f, 3.05468678e-01f, 3.82041544e-01f, 2.08993465e-01f, -2.90538371e-03f, 1.56140432e-01f, -5.46437092e-02f, 7.61174262e-02f, 9.45396796e-02f, -1.17138229e-01f,
  1.95294380e-01f, 2.68449001e-02f, 4.51439656e-02f, 1.47983193e-01f, 8.71229172e-02f, -6.91966638e-02f, 7.40028545e-02f, 1.67848229e-01f, -6.82719350e-02f, 2.34845161e-01f,
  8.14956706e-03f, 3.13651934e-02f, 1.00344405e-01f, 2.95191526e-01f, -1.21819414e-01f, 2.15320110e-01f, 3.11929211e-02f, 1.69526204e-01f, 9.28396732e-02f, -9.16448087e-02f,
  2.82222908e-02f, -3.79989743e-02f, -8.80377293e-02f, 3.05191539e-02f, 3.84731293e-01f, -1.88496739e-01f, 1.17092907e-01f, -1.70817766e-02f, 2.57461630e-02f, -9.72459745e-03f,
  1.73916176e-01f, -3.05851698e-02f, 1.84065104e-01f, 3.19775432e-01f, -3.30082662e-02f, -1.68901399e-01f, -3.86867560e-02f, -3.57741192e-02f, 1.94979608e-01f, -2.21285280e-02f,
  1.27840936e-01f, 4.29179072e-02f, 7.64844008e-03f, 2.33242437e-01f, -2.51029193e-01f, 2.52177447e-01f, -1.32878736e-01f, 4.84010912e-02f, 2.51226693e-01f, 3.05760652e-01f,
  2.67774582e-01f, -2.28895679e-01f, 4.57747489e-01f, 1.76801383e-01f, 1.01074658e-01f, -6.80885538e-02f, 6.08498091e-03f, 9.42398831e-02f, -1.52181527e-02f, 3.50532420e-02f,
  2.60316968e-01f, 2.01964490e-02f, 1.58897072e-01f, 7.90028498e-02f, -6.47835135e-02f, 8.47101882e-02f, 1.50706964e-02f, 5.98273128e-02f, 1.60587758e-01f, 1.94512665e-01f,
  -3.39077376e-02f, 1.28718406e-01f, 3.00371796e-02f, -9.16682463e-03f, 4.27283384e-02f, 1.66258454e-01f, 1.49751723e-01f, -3.84187512e-03f, 2.09198251e-01f, 1.07263766e-01f,
  -2.51851119e-02f, 6.31690323e-02f, -1.40161393e-02f, -1.94750145e-01f, 1.23095572e-01f, 4.64346148e-02f, 1.43224657e-01f, 1.91833198e-01f, 4.22736794e-01f, -1.07975015e-02f,
  3.73752080e-02f, 8.12880769e-02f, -9.84200388e-02f, -2.92553782e-01f, -7.45397285e-02f, 1.73901513e-01f, -1.15771614e-01f, -1.19515263e-01f, -4.27860692e-02f, -1.95442483e-01f,
  2.32990354e-01f, 6.38505071e-02f, -4.19205008e-03f, -1.21101089e-01f, 8.15995038e-02f, -2.28975222e-01f, 3.44497889e-01f, 2.04014316e-01f, -4.12611030e-02f, 1.15515016e-01f,
  1.61224693e-01f, 3.43046218e-01f, 1.37011692e-01f, -2.24596128e-01f, 1.14113055e-01f, -1.66199431e-01f, 7.89983606e-04f, 7.42183402e-02f, 7.37845525e-02f, 1.44376591e-01f,
  -1.84905812e-01f, -2.81817317e-01f, 9.29423794e-02f, 2.83268958e-01f, 1.18866563e-02f, -1.49406120e-01f, -1.88264385e-01f, -8.74362439e-02f, 1.00785784e-01f, 3.18060108e-02f,
  5.57712987e-02f, 9.60013270e-02f, -2.75091734e-02f, -1.54840410e-01f, -1.65286407e-01f, 7.28383958e-02f, -9.31013282e-03f, -1.51497081e-01f, -1.19611889e-01f, 1.87136322e-01f,
  1.43094689e-01f, -1.51370302e-01f, 3.74808088e-02f, 3.38667691e-01f, 1.14028312e-01f, -1.18989773e-01f, 1.16023049e-01f, 4.28694822e-02f, 2.35307321e-01f, 1.95244998e-01f,
  -5.66915683e-02f, 3.29698831e-01f, 7.30499327e-02f, 3.42710227e-01f, -1.81818102e-02f, 4.24692869e-01f, 1.85826093e-01f, 1.18516110e-01f, -9.05704405e-03f, -9.68014970e-02f,
  -9.39298570e-02f, -1.81963101e-01f, -6.46284446e-02f, 1.07248001e-01f, -1.59819126e-01f, -4.72648218e-02f, 1.67029649e-01f, 1.72282070e-01f, 2.54582614e-01f, 8.05969536e-02f,
  1.51594669e-01f, 2.99095750e-01f, -1.97328385e-02f, 3.01129103e-01f, -1.40965715e-01f, 1.11380988e-03f, 3.96611154e-01f, 1.18402801e-01f, 7.45554790e-02f, -1.29254013e-01f,
  1.55455261e-01f, -1.28399745e-01f, 2.59068698e-01f, 8.14387649e-02f, -3.27453651e-02f, 2.77147412e-01f, -1.40714511e-01f, -1.24883123e-01f, 1.13132922e-02f, 3.09402570e-02f,
  2.46628612e-01f, 9.31707695e-02f, 5.93788549e-02f, 1.36635587e-01f, -2.83819348e-01f, 9.39926580e-02f, -3.07075754e-02f, -3.22877839e-02f, -2.93417536e-02f, 3.23124342e-02f,
  -2.48229317e-02f, -7.51202628e-02f, 3.13103259e-01f, -1.46330163e-01f, -3.17007750e-01f, -2.65060775e-02f, -2.19417572e-01f, 3.92691977e-02f, 1.31221265e-01f, -1.90197170e-01f,
  2.49910891e-01f, 1.22810230e-01f, 1.22535177e-01f, -1.18319929e-01f, 5.64847216e-02f, 2.10830607e-02f, -2.07569823e-01f, 1.13732740e-01f, -1.30800560e-01f, 1.91010788e-01f,
  -1.50180925e-02f, 3.11067104e-01f, -1.84724145e-02f, -6.83799312e-02f, -1.72233030e-01f, 2.10469767e-01f, 2.77597964e-01f, 9.88154933e-02f, -9.73826498e-02f, 6.45513311e-02f,
  5.10843731e-02f, 2.17067122e-01f, 1.05816066e-01f, 8.46426655e-03f, -1.12951137e-02f, 1.59249336e-01f, -7.31829107e-02f, 1.23415671e-01f, 1.72290847e-01f, -4.06285338e-02f,
  1.26104549e-01f, 1.60550967e-01f, 2.20463555e-02f, 1.80670545e-01f, -9.84259509e-03f, 1.90247670e-01f, -7.43061453e-02f, -5.78317977e-02f, 8.43698010e-02f, 2.16891229e-01f,
  1.62407145e-01f, 2.17956956e-02f, 1.48860916e-01f, 1.37736782e-01f, 1.71377763e-01f, 1.04436018e-01f, -1.80423576e-02f, 9.58585143e-02f, 2.29960501e-01f, 1.60795495e-01f,
  1.25335470e-01f, 1.96327001e-01f, 1.53592408e-01f, 1.71936631e-01f, 1.84146807e-01f, 8.52258205e-02f, -1.97869554e-01f, 1.03567600e-01f, 2.99531072e-01f, 1.17343925e-01f,
  1.73763260e-01f, -4.28010412e-02f, -7.88417682e-02f, 1.43987924e-01f, -2.26271182e-01f, -6.02061376e-02f, -1.60940647e-01f, 8.30174014e-02f, 1.65934727e-01f, 7.75294304e-02f,
  1.57150730e-01f, -8.75250325e-02f, 1.20829977e-01f, -1.15608841e-01f, -2.07343302e-03f, -1.44599825e-01f, -1.79450765e-01f, 2.02261582e-01f, 5.21928892e-02f, -1.56895235e-01f,
  -3.10351670e-01f, -1.19350336e-01f, 2.19983250e-01f, -8.89996532e-03f, -2.24212736e-01f, -5.53780384e-02f, 2.10015208e-01f, -2.09053084e-02f, -2.36179717e-02f, 1.75958514e-01f,
  1.12122245e-01f, -9.02392641e-02f, 2.24523582e-02f, 4.23589721e-03f, 1.36119545e-01f, 8.62401128e-02f, 2.15543881e-01f, -1.61281049e-01f, 1.44204929e-01f, 1.48672238e-01f,
  2.63923645e-01f, 9.79214814e-03f, 5.75177893e-02f, -1.38074020e-02f, 3.37231636e-01f, 5.76095432e-02f, -2.64732726e-02f, 1.98566288e-01f, -5.35143167e-03f, 9.19273049e-02f,
  1.25608161e-01f, 1.60943836e-01f, 1.63700595e-01f, 1.73174351e-01f, -5.31418063e-02f, -6.39700443e-02f, 8.22344571e-02f, 1.96476564e-01f, 1.88310534e-01f, -1.37797028e-01f,
  4.79971692e-02f, 2.26324439e-01f, 5.03976597e-03f, -8.49846527e-02f, -2.00717524e-01f, -1.56435594e-01f, 1.59978837e-01f, 7.18326569e-02f, 3.41749415e-02f, 1.81877032e-01f,
  -3.92004065e-02f, -1.81264043e-01f, 1.33840546e-01f, 7.64689001e-04f, -2.37422287e-01f, 1.58404037e-01f, 1.18335925e-01f, -2.44964305e-02f, 1.58985667e-02f, 6.88400939e-02f,
  -3.07962187e-02f, 2.37073809e-01f, -5.73780574e-02f, -1.20869391e-01f, -6.36210889e-02f, 2.18611285e-01f, 3.70056704e-02f, -9.45971683e-02f, 2.08717510e-02f, 3.29419374e-01f,
  1.67156875e-01f, 1.08096853e-01f, -1.01382419e-01f, -5.51107246e-03f, 4.47194017e-02f, -3.26382145e-02f, -1.37497693e-01f, -2.23105043e-01f, 6.42376021e-02f, 3.71083111e-01f,
  2.01737374e-01f, 5.21834791e-02f, 2.46122822e-01f, 1.55647546e-01f, 1.53746977e-01f, 9.35473107e-03f, 1.66069970e-01f, 2.66273290e-01f, 2.81760901e-01f, -7.28546232e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.34638429e-01f, 5.03558107e-02f, -6.07668124e-02f, 1.85709447e-01f, 1.38657361e-01f, 8.86847079e-02f, 1.23659521e-01f, 1.54987022e-01f, 1.30159706e-01f, 4.54227179e-02f,
  1.51163891e-01f, 5.55694923e-02f, 1.61594719e-01f, 1.61579028e-02f, 1.15160666e-01f, 3.13228406e-02f, 1.50842339e-01f, 7.10502407e-03f, 4.43678349e-02f, 4.58035357e-02f,
  1.05684854e-01f, 5.98347466e-03f, 5.36743216e-02f, 1.07191481e-01f, 1.12682775e-01f, 4.29805443e-02f, 3.59715894e-02f, 2.52643842e-02f, 3.71023826e-02f, 1.01805590e-01f,
  2.31990237e-02f, 8.90489519e-02f, 1.04578927e-01f, 7.84400292e-03f, 5.49351014e-02f, 1.33712487e-02f, 1.07001215e-01f, 1.51315525e-01f, 1.05009899e-01f, 6.94619119e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  1.22645851e-02f, -1.15260724e-02f, 1.45791680e-01f, -1.95679560e-01f, -2.60066558e-02f, -2.73160040e-01f, -2.34311409e-02f, 1.85107380e-01f, -9.56697911e-02f, -9.18839425e-02f,
  -1.80331975e-01f, -2.96871543e-01f, 3.55574161e-01f, 1.34623826e-01f, 2.25545689e-01f, -8.16248823e-04f, 3.33910108e-01f, -9.90484729e-02f, -1.49314255e-01f, -9.55857709e-02f,
  1.57876149e-01f, 1.76787302e-01f, 1.96536362e-01f, 4.26893622e-01f, 3.38426083e-02f, -4.66030955e-01f, 2.83979207e-01f, -3.44480157e-01f, -5.91078460e-01f, -3.14132154e-01f,
  -3.99135202e-01f, -1.76867232e-01f, 3.05668443e-01f, 1.08920649e-01f, -1.81230396e-01f, 1.99533552e-01f, 8.04797001e-03f, 2.53721088e-01f, -3.45942974e-01f, -2.08894998e-01f,
  1.68576837e-01f, -3.38768780e-01f, -6.19967401e-01f, -2.65427917e-01f, 3.16703886e-01f, 1.17686763e-01f, 3.00051153e-01f, -3.21132272e-01f, 3.02107245e-01f, 1.50788367e-01f,
  -5.41512668e-01f, 3.22839200e-01f, -4.01835442e-01f, 1.47124484e-01f, -1.63753942e-01f, 3.67641151e-01f, -5.49764097e-01f, -1.30437627e-01f, -1.55070901e-01f, -1.34190068e-01f,
  2.64428377e-01f, -2.57382244e-02f, 5.95340021e-02f, -8.98046121e-02f, -1.76365420e-01f, 1.56215519e-01f, -2.20783934e-01f, -1.35423029e-02f, 1.82807341e-01f, 1.66769594e-01f,
  -1.24548189e-01f, -1.48203209e-01f, 1.73894972e-01f, 1.06294833e-01f, 2.19392955e-01f, 1.86011896e-01f, 1.44567698e-01f, 2.70567298e-01f, 2.38527924e-01f, -4.08302188e-01f,
  -2.75143921e-01f, -9.68321711e-02f, -1.93254367e-01f, -1.68812945e-01f, -3.70923370e-01f, -4.31663878e-02f, -6.65360466e-02f, -1.78994089e-01f, 7.92134926e-02f, -1.03000127e-01f,
  -1.22982934e-01f, 2.19790459e-01f, 8.55481848e-02f, -4.20805156e-01f, 1.81088522e-01f, 7.60110393e-02f, 4.01161283e-01f, -3.86161596e-01f, -3.74224901e-01f, 2.34097689e-01f,
  1.32159039e-01f, 2.17018068e-01f, -3.21381748e-01f, -5.81706315e-02f, 2.81303793e-01f, -2.79334903e-01f, 5.05407929e-01f, -5.09390831e-01f, 9.94280428e-02f, -4.67191190e-01f,
  8.50722939e-02f, -8.02715123e-02f, 2.55499780e-01f, 9.63079259e-02f, 1.66495070e-02f, -2.78489739e-01f, -6.09088421e-01f, 3.07278577e-02f, -8.55765417e-02f, 8.93912092e-02f,
  2.66602069e-01f, -2.99101412e-01f, 1.92633998e-02f, -3.94340307e-01f, -3.50410730e-01f, -3.46745670e-01f, -9.44698602e-03f, -1.05694853e-01f, -1.28286466e-01f, -6.16787896e-02f,
  -1.44810453e-01f, -7.80243725e-02f, -9.77653116e-02f, -2.25359589e-01f, -7.04531595e-02f, 5.08812396e-03f, -6.93376735e-02f, -2.24567160e-01f, 2.67482121e-02f, -1.58262486e-03f,
  3.00730407e-01f, -2.31756687e-01f, 8.77491683e-02f, 2.09177792e-01f, -1.07465200e-01f, 3.27191144e-01f, -2.28629544e-01f, -2.13385597e-01f, -1.82698280e-01f, -5.18034399e-02f,
  2.10287973e-01f, -2.36967131e-02f, -5.28774321e-01f, -3.03544939e-01f, 2.06034016e-02f, -1.93905264e-01f, 1.74319014e-01f, 8.75368789e-02f, 1.68258697e-01f, 3.17626595e-01f,
  -2.52390057e-02f, -3.78671706e-01f, 1.95654750e-01f, 1.67169273e-02f, 1.69095010e-01f, -3.55213463e-01f, -4.26752299e-01f, -4.25909400e-01f, -3.34304035e-01f, -3.11656594e-01f,
  2.76654184e-01f, 2.55661577e-01f, -4.55716699e-01f, -1.96920276e-01f, 1.35520563e-01f, -4.19704586e-01f, -2.64934897e-01f, -3.81783210e-02f, 1.22006707e-01f, -3.89756113e-01f,
  -1.10419370e-01f, 2.80242026e-01f, -2.82821357e-01f, -2.87623286e-01f, 2.28048936e-01f, 4.70135033e-01f, -3.32394272e-01f, -2.90225536e-01f, -6.76555559e-02f, 2.71489501e-01f,
  -1.38883635e-01f, 1.00211706e-03f, -1.39440522e-01f, -1.17693439e-01f, -2.34893471e-01f, -1.09556943e-01f, -2.22525269e-01f, -5.11442311e-02f, -1.13936784e-02f, -3.05878688e-02f,
  -8.06064308e-02f, 3.32944505e-02f, -1.46031529e-01f, -1.25022158e-01f, 3.14796087e-03f, -1.87326908e-01f, -1.77616715e-01f, -2.44715571e-01f, -1.04242243e-01f, -3.47310066e-01f,
  1.29400834e-01f, 1.73152182e-02f, 6.99343681e-02f, 3.79208684e-01f, 9.36762523e-03f, 3.91260117e-01f, -2.35983655e-01f, 2.73390144e-01f, 3.10483515e-01f, 5.03884554e-02f,
  3.53645682e-02f, 1.62832856e-01f, -2.89837986e-01f, -3.55472416e-01f, -1.55969664e-01f, 3.63197327e-02f, 2.43181765e-01f, 2.41228402e-01f, -4.72643882e-01f, -1.05789654e-01f,
  -3.41339678e-01f, 3.27298939e-01f, -3.45281392e-01f, 1.19978108e-01f, -1.31777033e-01f, 1.45095366e-03f, 9.84994620e-02f, -2.64651388e-01f, -1.08629078e-01f, -2.30007663e-01f,
  1.53662339e-01f, -3.88575852e-01f, -3.64534318e-01f, -3.33626240e-01f, -4.82757449e-01f, 1.59729674e-01f, 6.34079099e-01f, 1.37308866e-01f, -5.08454740e-01f, -1.31064892e-01f,
  2.78327227e-01f, -2.24870577e-01f, 1.73535347e-01f, 2.04280376e-01f, -2.58045584e-01f, 5.18514961e-02f, 6.81213886e-02f, -1.15893252e-01f, 1.29004791e-01f, -1.32661402e-01f,
  2.39421010e-01f, 1.10337466e-01f, -4.25342321e-02f, 1.70279425e-02f, 1.05179675e-01f, 9.86349955e-02f, -3.19413543e-01f, 2.20844135e-01f, -4.14302677e-01f, 1.65483981e-01f,
  -1.98752806e-01f, 1.59846589e-01f, -3.40848528e-02f, -2.05947980e-02f, 1.38254821e-01f, 3.48632962e-01f, 1.89330250e-01f, -1.18022799e-01f, -1.77202746e-01f, -1.21631496e-01f,
  -2.89524615e-01f, 1.16879538e-01f, 2.28750445e-02f, -2.44735107e-01f, -1.86432093e-01f, 2.51196802e-01f, 1.99237645e-01f, -1.82982460e-01f, -5.52997828e-01f, 2.43031517e-01f,
  -3.64711940e-01f, -1.92609817e-01f, 1.63945749e-01f, -6.34483844e-02f, -3.18220913e-01f, -4.59851652e-01f, 1.74442410e-01f, 2.42773712e-01f, -4.09736902e-01f, 1.25570446e-01f,
  2.50683755e-01f, 2.18219519e-01f, 7.56895393e-02f, 2.13632956e-01f, -9.83795598e-02f, -7.26985857e-02f, -2.89317757e-01f, 5.91739407e-03f, -2.40425635e-02f, 5.16572483e-02f,
  -6.38215780e-01f, 9.42916051e-02f, -5.04129946e-01f, 3.73210877e-01f, 2.41388768e-01f, -6.15471192e-02f, 2.30189919e-01f, -1.22701056e-01f, 8.98452476e-02f, 2.44179353e-01f,
  1.77020773e-01f, -1.39271682e-02f, 2.12058693e-01f, 1.41989052e-01f, 1.41460270e-01f, 7.37049729e-02f, 1.48112729e-01f, 1.72385663e-01f, 2.31079534e-01f, 1.40023902e-01f,
  -2.96856835e-02f, -5.69712594e-02f, 3.34696889e-01f, -2.72957385e-01f, 2.47361869e-01f, 2.68559396e-01f, 2.47364148e-01f, -3.06025356e-01f, -8.39055255e-02f, 1.01896904e-01f,
  -2.67620564e-01f, 3.22913140e-01f, -4.59697433e-02f, -4.19806391e-02f, 3.29581052e-01f, -3.24941337e-01f, -8.25697035e-02f, -1.07317410e-01f, 3.66266578e-01f, -3.37314636e-01f,
  -2.11231764e-02f, -3.11647385e-01f, 1.51964411e-01f, 2.33631074e-01f, -4.30468380e-01f, -3.78009707e-01f, -5.67865968e-01f, 2.86568791e-01f, 1.28307760e-01f, -3.23477089e-01f,
  1.04331464e-01f, 3.30115467e-01f, -2.04356030e-01f, -3.93482983e-01f, 1.79391980e-01f, 1.20105371e-01f, 8.54087248e-02f, -3.63074899e-01f, -2.17653453e-01f, 3.76070552e-02f,
  1.71139508e-01f, 9.50926840e-02f, 3.28717381e-01f, -5.12907982e-01f, -4.19312835e-01f, -2.42893666e-01f, 1.23503804e-01f, -4.70173866e-01f, 2.33802900e-01f, 4.59267735e-01f,
  1.54555291e-01f, -4.45552468e-01f, 2.37739101e-01f, -4.29169118e-01f, -2.57324986e-02f, 1.81843743e-01f, 7.00961500e-02f, -1.19320795e-01f, -1.44893229e-01f, 1.01401545e-01f,
  1.49777740e-01f, 1.02511480e-01f, -2.03422010e-01f, 2.78932661e-01f, 2.70022333e-01f, 1.55859618e-02f, 2.61585265e-01f, -2.93743819e-01f, 1.87153086e-01f, 1.18473791e-01f,
  -5.08488528e-02f, 4.17011768e-01f, 4.54701334e-02f, 1.36760518e-01f, -1.17973469e-01f, -2.35547602e-01f, 1.75719425e-01f, -4.96502891e-02f, 1.92343116e-01f, -1.61982119e-01f,
  9.77856889e-02f, -4.00629014e-01f, -2.43676841e-01f, 7.82556012e-02f, 2.77307272e-01f, -1.46966636e-01f, 3.89731228e-01f, -1.04814522e-01f, 3.71547639e-02f, 3.39209944e-01f,
  -6.34694919e-02f, -2.70868510e-01f, 2.17471942e-01f, -3.92766327e-01f, -4.11406368e-01f, -6.25228807e-02f, -1.97837517e-01f, 1.81975394e-01f, -5.05046666e-01f, -4.22384232e-01f,
  -5.57087600e-01f, 1.31624058e-01f, 1.67296618e-01f, 1.76625952e-01f, 2.16360554e-01f, 9.31038857e-02f, 1.16593614e-01f, -1.80080950e-01f, 1.02736914e+00f, -1.65772513e-01f,
  1.96417660e-01f, -2.18654647e-02f, 1.28354922e-01f, 1.20374158e-01f, -3.29977244e-01f, 1.00859322e-01f, -1.61658362e-01f, -5.17252386e-01f, -1.98991194e-01f, -8.72918218e-02f,
  -2.33132299e-02f, -4.30469252e-02f, 5.23543432e-02f, -2.27211028e-01f, -6.17078245e-02f, -1.32299304e-01f, -2.13223584e-02f, -2.56028444e-01f, 1.47084501e-02f, -3.06505430e-02f,
  6.87980279e-03f, -9.20595750e-02f, -1.43135443e-01f, 1.53392345e-01f, -4.80985865e-02f, 2.04103455e-01f, -2.60045379e-01f, -9.09404531e-02f, 1.04517370e-01f, -2.26959839e-01f,
  5.32917343e-02f, 2.31592774e-01f, -4.05747533e-01f, 3.00383151e-01f, -3.99376988e-01f, 2.13532820e-01f, 2.65289962e-01f, -7.96672236e-03f, -2.18777850e-01f, 1.26905844e-01f,
  -2.27124766e-01f, 1.35844842e-01f, -9.51428562e-02f, -3.19220275e-01f, -3.05166632e-01f, 1.47432223e-01f, 2.13579744e-01f, 3.31394792e-01f, -2.61748701e-01f, 3.08555782e-01f,
  -2.21404824e-02f, -2.16855958e-01f, -1.42534927e-01f, 2.11160272e-01f, -1.93000615e-01f, 1.91654906e-01f, -3.63600194e-01f, 1.52081782e-02f, 7.35199004e-02f, -1.50530890e-01f,
  1.31123826e-01f, -1.39424533e-01f, 3.20301093e-02f, 1.15787730e-01f, -1.38713703e-01f, 6.16103522e-02f, -5.32610752e-02f, 1.97465718e-01f, 1.26903519e-01f, 2.66161282e-02f,
  -3.38505238e-01f, -2.43526593e-01f, 1.05061643e-01f, 2.90378798e-02f, 4.17038463e-02f, 8.24094266e-02f, -1.01116776e-01f, -8.62461701e-02f, -1.41201019e-02f, -2.03193933e-01f,
  -7.51497746e-02f, 1.77047387e-01f, -5.19164689e-02f, -9.87534076e-02f, -1.50595099e-01f, -6.62967637e-02f, 1.84794277e-01f, -2.59602308e-01f, -1.23552740e-01f, -2.54809231e-01f,
  3.24706316e-01f, -1.76857293e-01f, -2.39692137e-01f, 2.56715212e-02f, 2.64050961e-01f, -1.65730745e-01f, 6.46634623e-02f, -1.04086444e-01f, -2.70930827e-01f, -1.88100666e-01f,
  2.08584815e-01f, -3.31946880e-01f, 3.14944200e-02f, 1.41594648e-01f, 3.06683984e-02f, -4.04959261e-01f, 1.88681260e-01f, -2.10278392e-01f, -2.56792754e-01f, -2.84801632e-01f,
  -2.76534349e-01f, 3.58358324e-01f, -2.93883961e-02f, 3.80767167e-01f, -2.60598734e-02f, 1.83681652e-01f, 1.01969905e-01f, -2.03332931e-01f, -2.05230713e-01f, -2.69637704e-01f,
  -1.99280843e-01f, -5.07307172e-01f, 1.70124955e-02f, 4.26736444e-01f, 2.17948496e-01f, 2.34809801e-01f, -1.36447459e-01f, -3.17459494e-01f, -9.25983116e-02f, -2.40323782e-01f,
  -3.09837550e-01f, -2.08427131e-01f, 3.79649460e-01f, 9.21064392e-02f, -3.34846973e-01f, 1.45199195e-01f, 9.74129736e-02f, -7.27370307e-02f, -1.18491486e-01f, -1.99768439e-01f,
  -1.35655463e-01f, -9.51877907e-02f, -1.33631095e-01f, 7.91184828e-02f, 8.64775404e-02f, -2.65006036e-01f, -2.88536847e-01f, -2.07186967e-01f, -1.33444652e-01f, 4.06833887e-01f,
  5.24648651e-02f, 5.67274019e-02f, 4.09240961e-01f, 1.51756495e-01f, -1.68278292e-01f, 2.22021013e-01f, -1.24663718e-01f, -1.09496735e-01f, -3.07122678e-01f, -1.17161870e-01f,
  -2.44444944e-02f, 2.99358904e-01f, -4.84382436e-02f, -1.20549962e-01f, -3.63770783e-01f, -1.89716682e-01f, 1.81946546e-01f, -1.56057402e-01f, -4.88922179e-01f, -6.03507943e-02f,
  -1.82640702e-01f, -1.73831686e-01f, 1.54205337e-01f, -2.72528172e-01f, 1.82437077e-01f, -1.35599583e-01f, 3.01653035e-02f, -4.89748210e-01f, 3.20029289e-01f, -3.62388529e-02f,
  -3.81269246e-01f, 4.08720791e-01f, -1.33511890e-02f, 2.99439102e-01f, -5.24435453e-02f, 2.24875987e-01f, 1.08523346e-01f, -2.08213389e-01f, 6.68267012e-02f, -3.43784541e-01f,
  -4.45979327e-01f, -3.29103231e-01f, 1.67271063e-01f, 2.93123484e-01f, -4.75760132e-01f, 2.49836683e-01f, -3.99080127e-01f, -3.08088005e-01f, 2.21254110e-01f, -4.18055654e-02f,
  -4.05118167e-02f, 1.48602977e-01f, 1.78139880e-01f, 2.73814887e-01f, 1.68234035e-02f, 1.05708584e-01f, 1.39673620e-01f, 1.58713341e-01f, -2.76754075e-03f, 1.56263769e-01f,
  3.13857794e-02f, 1.82898864e-01f, -3.02073330e-01f, 2.83892095e-01f, -2.71590889e-01f, -2.12156519e-01f, -2.94552535e-01f, 4.23480630e-01f, -4.49573062e-02f, -1.02994479e-01f,
  4.85037059e-01f, -3.32874268e-01f, -2.60386705e-01f, -3.69519532e-01f, -6.89915866e-02f, -3.36997807e-01f, -4.64607567e-01f, 4.55651730e-01f, -1.29835039e-01f, 2.53316611e-01f,
  -5.09223700e-01f, 3.25476468e-01f, -3.57561648e-01f, 1.89852357e-01f, 2.60094851e-01f, -4.30918531e-03f, 2.86125243e-01f, -3.04811209e-01f, -9.36932638e-02f, -1.10988326e-01f,
  -3.28722107e-03f, -2.27781385e-01f, -3.98629129e-01f, -1.21083908e-01f, -2.66690552e-01f, -2.32967794e-01f, 2.36424863e-01f, 1.32981554e-01f, 3.66443843e-01f, -3.64267796e-01f,
  -3.99006754e-01f, -3.18427354e-01f, -3.05361450e-01f, 2.29225039e-01f, -1.95824623e-01f, 1.67102262e-01f, 2.13402256e-01f, -4.35619265e-01f, -3.31562340e-01f, -2.38298148e-01f,
  -2.64260501e-01f, 3.32820266e-01f, -4.18513209e-01f, 8.90690237e-02f, -7.86260217e-02f, 3.30052599e-02f, 3.23602781e-02f, 1.47108495e-01f, -3.24252248e-02f, 1.05863318e-01f,
  -1.50361523e-01f, -7.26623461e-02f, 1.12025499e-01f, 1.38047948e-01f, 2.29364857e-01f, 8.87334123e-02f, -2.92493761e-01f, -7.23639354e-02f, -2.43842527e-01f, 2.10607886e-01f,
  3.00644606e-01f, -2.89668083e-01f, 2.80447155e-01f, 2.38942370e-01f, 3.76943588e-01f, 6.91933632e-02f, 1.35077834e-01f, 1.43399805e-01f, 3.40712547e-01f, -2.54981846e-01f,
  6.28817528e-02f, -9.01849791e-02f, 4.18635570e-02f, 2.46029496e-01f, -2.20191464e-01f, -4.94517237e-01f, -4.59478945e-01f, -1.83260098e-01f, 2.34049171e-01f, -3.72024149e-01f,
  1.50114939e-01f, -3.37108880e-01f, 4.74729329e-01f, 5.22383630e-01f, -2.09549680e-01f, -2.73835868e-01f, -3.24985713e-01f, 2.98333168e-01f, 1.36497058e-02f, -3.19897562e-01f,
  -2.92842805e-01f, -2.28013083e-01f, -2.11658806e-01f, -3.32714587e-01f, 1.41097367e-01f, 9.96719748e-02f, 4.04296935e-01f, -3.74147713e-01f, 1.47504166e-01f, -2.71832854e-01f,
  -4.58337873e-01f, -3.62064600e-01f, 2.47135103e-01f, -6.99392008e-03f, -3.99565369e-01f, 7.75045305e-02f, 3.17870110e-01f, 3.03320199e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  4.03457768e-02f, 4.50198278e-02f, -4.56235483e-02f, -1.27981588e-01f, -1.12751305e-01f, 2.88655739e-02f, 4.31117192e-02f, 3.88656147e-02f, 2.98067033e-02f, 5.76830916e-02f,
  2.21346710e-02f, 9.26131681e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    