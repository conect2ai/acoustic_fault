/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.31456092e-01f, 3.61608386e-01f, -4.00072634e-02f, -6.29739687e-02f, -2.30196714e-01f, -4.84813273e-01f, -3.39160800e-01f, -2.00087428e-02f, -9.86261591e-02f, 5.38462512e-02f,
  -2.73564488e-01f, 4.27343249e-02f, 6.67617023e-02f, -2.46206105e-01f, -3.22940856e-01f, -1.14689749e-02f, -2.52150834e-01f, -6.93918616e-02f, 2.10474789e-01f, 1.12269074e-01f,
  1.14449216e-02f, -7.93521628e-02f, -6.99619725e-02f, 2.24880099e-01f, -1.06584631e-01f, 2.60059178e-01f, 9.30125862e-02f, 6.39185756e-02f, 1.44486083e-02f, -2.12884292e-01f,
  9.23053478e-04f, 2.26510406e-01f, -1.77746013e-01f, 8.62629898e-03f, -7.18000978e-02f, 2.82341503e-02f, 1.04340993e-01f, -7.30600655e-02f, 7.91949332e-02f, -6.46921769e-02f,
  4.88405600e-02f, 6.58540875e-02f, -9.61296707e-02f, -2.05075704e-02f, 1.03048503e-01f, 2.39655357e-02f, 1.51944933e-02f, -1.84444964e-01f, 8.67891386e-02f, -2.57711653e-02f,
  -1.19164370e-01f, 1.25676328e-02f, -8.72474164e-02f, 5.68178222e-02f, -4.27689925e-02f, 9.98010300e-03f, -5.33684390e-03f, -1.81927994e-01f, 6.92160577e-02f, 1.95966158e-02f,
  -5.65823400e-03f, 8.15564096e-02f, -2.05365755e-02f, 1.90197267e-02f, -1.60203632e-02f, -3.96318920e-02f, -1.47606654e-03f, -1.04123898e-01f, 3.45961675e-02f, 1.59437042e-02f,
  -7.85571188e-02f, 2.49748025e-03f, 1.48513867e-02f, -5.20372987e-02f, 3.01620532e-02f, 2.33080164e-02f, 3.67062576e-02f, -5.30502386e-03f, -8.45069811e-02f, -6.59236386e-02f,
  1.47479679e-02f, 9.29999501e-02f, -8.40522945e-02f, 3.23790424e-02f, -1.91862881e-02f, -7.72544071e-02f, 1.89818162e-02f, -5.16105480e-02f, 1.61687564e-02f, -4.95734699e-02f,
  1.72820151e-01f, 2.65981317e-01f, -7.39131272e-02f, 7.84818232e-02f, 1.21459760e-01f, -5.58550842e-02f, 3.76966447e-02f, -7.28138089e-02f, 1.26056299e-01f, 1.65341143e-02f,
  -1.50249684e-02f, -7.96550289e-02f, 7.59661347e-02f, 1.15661353e-01f, -2.74022855e-02f, -4.87287827e-02f, 1.14272676e-01f, -1.38197010e-02f, -2.69354079e-02f, 1.12257227e-01f,
  7.70796239e-02f, 9.31958333e-02f, -5.13508022e-02f, -4.64446656e-02f, -9.18270927e-03f, -3.84932272e-02f, -4.69966270e-02f, 3.63459811e-02f, 1.68720726e-02f, 5.69968596e-02f,
  -4.80071276e-01f, 5.95577359e-02f, -5.72766587e-02f, -2.01056480e-01f, -3.37782472e-01f, 1.83584690e-01f, 1.67962953e-01f, -2.10820198e-01f, -7.55672678e-02f, 1.97037846e-01f,
  4.83887568e-02f, -5.63217364e-02f, 3.61920863e-01f, -1.46780178e-01f, -4.12993699e-01f, 4.23424751e-01f, -1.90272138e-01f, 2.07041614e-02f, 4.08482086e-03f, -2.06245258e-01f,
  -1.17593311e-01f, -1.50840700e-01f, -1.16700664e-01f, 6.10638708e-02f, -2.80219167e-01f, -9.58635136e-02f, -1.02593809e-01f, 1.18733831e-01f, -1.86293468e-01f, -1.52298957e-01f,
  -1.40861496e-01f, -9.18615982e-02f, 1.93167140e-03f, 7.82527104e-02f, -3.56854871e-02f, 3.32472622e-02f, -4.38973382e-02f, 7.84208104e-02f, 5.30370139e-02f, 3.08397487e-02f,
  1.52280167e-01f, -1.64836183e-01f, 1.28173698e-02f, 1.04569837e-01f, -2.35865600e-02f, 1.94885284e-02f, -4.58636396e-02f, -2.30980087e-02f, -4.71165776e-02f, -5.30081689e-02f,
  4.43367995e-02f, 6.71575889e-02f, 5.11812372e-03f, 2.34377496e-02f, -1.33602351e-01f, 2.12451518e-02f, -7.46401250e-02f, 2.03100573e-02f, -7.10890144e-02f, -1.58947811e-01f,
  6.08550608e-02f, -5.87135516e-02f, 4.95512895e-02f, -1.66677460e-02f, 7.06259385e-02f, -8.34398344e-02f, 1.01698555e-01f, -5.23032546e-02f, 2.70911288e-02f, -1.97675638e-02f,
  -4.50117253e-02f, -8.16079825e-02f, -1.08098015e-01f, 7.58646131e-02f, 3.32791619e-02f, 2.85894088e-02f, 1.00418955e-01f, 1.79956353e-03f, -3.57147045e-02f, -9.50096622e-02f,
  4.01285151e-03f, -1.62117910e-02f, -6.46584108e-02f, -7.11672066e-04f, -1.55262155e-02f, -5.08961156e-02f, -3.88244614e-02f, -2.57717483e-02f, -6.19574869e-03f, -5.52863814e-04f,
  -1.10593781e-01f, -2.74475247e-01f, 7.57838488e-02f, -5.01338579e-02f, 3.49338502e-02f, -1.51173305e-02f, 1.64298695e-02f, -1.58105958e-02f, 6.62951916e-02f, 1.92510039e-02f,
  6.38841614e-02f, -1.54636996e-02f, -5.59126362e-02f, 2.77999565e-02f, -2.64161010e-03f, 3.86927905e-03f, 3.72914709e-02f, 2.66457838e-03f, -6.84942231e-02f, -5.80311380e-02f,
  5.79900062e-03f, -3.75152769e-04f, 9.49560925e-02f, -6.19963408e-02f, 4.70555760e-02f, -2.52745245e-02f, -8.64268839e-02f, 4.20534611e-02f, 3.90828587e-02f, 3.36410366e-02f,
  3.25715572e-01f, -3.29802394e-01f, 4.88255881e-02f, 5.46440303e-01f, 2.71099098e-02f, 2.10505992e-01f, 4.82003510e-01f, -8.71712342e-02f, 3.30924094e-01f, -1.10737033e-01f,
  3.17114383e-01f, 7.56806955e-02f, 2.17125863e-01f, 2.80687660e-01f, 3.78720164e-01f, 3.17621343e-02f, 4.68533128e-01f, 7.60042071e-02f, -1.18646160e-01f, 3.98487262e-02f,
  1.59811169e-01f, 1.47335485e-01f, 2.70329475e-01f, -3.06254238e-01f, -2.18251552e-02f, -1.86061025e-01f, 3.00648306e-02f, -2.84659024e-02f, -9.11644921e-02f, -2.50331312e-02f,
  -3.39661464e-02f, 1.21731835e-03f, 5.12646399e-02f, -9.89204571e-02f, 7.97412768e-02f, 9.15649056e-04f, 7.64083192e-02f, 5.05443439e-02f, 5.03292456e-02f, -6.68976605e-02f,
  -1.11345286e-02f, -6.75223023e-02f, -1.26199508e-02f, 1.49581879e-02f, -9.11395177e-02f, -7.68250450e-02f, -6.93699345e-02f, 6.89546615e-02f, -4.22436297e-02f, -1.94037464e-02f,
  1.03009693e-01f, -5.88293485e-02f, 6.45956248e-02f, -2.91504152e-02f, 2.67353049e-03f, 2.25633737e-02f, -3.33608054e-02f, -1.58276353e-02f, -9.91972685e-02f, 4.81324010e-02f,
  -9.39686894e-02f, 4.28707749e-02f, 5.74085154e-02f, -1.05427973e-01f, 1.09395020e-01f, -1.05517812e-01f, 5.71794286e-02f, -8.93197954e-02f, 2.20500939e-02f, -2.26541962e-02f,
  5.91102131e-02f, 3.72904018e-02f, 5.37941977e-02f, 1.17452107e-01f, 1.18484750e-01f, -6.72502909e-04f, 4.33284044e-02f, -1.07798874e-01f, 3.62925045e-02f, -7.56210275e-03f,
  6.63642958e-02f, 3.46805230e-02f, 4.71245311e-02f, -6.77754059e-02f, 3.07055600e-02f, 7.05003291e-02f, -1.95351765e-02f, -1.95369367e-02f, -9.88202468e-02f, 1.19399585e-01f,
  5.51847741e-02f, 2.58737952e-01f, 6.51119053e-02f, -7.47322589e-02f, 2.39111744e-02f, 2.74003092e-02f, -1.96740925e-02f, -1.34551257e-01f, -5.03900349e-02f, 8.15290883e-02f,
  -4.05656919e-02f, 3.74102145e-02f, -1.78864133e-02f, -2.37976909e-02f, 3.80219445e-02f, 1.04780637e-01f, 5.47358356e-02f, -8.18977971e-03f, 6.48147464e-02f, -6.52753785e-02f,
  1.91694517e-02f, 2.11505536e-02f, 5.85111529e-02f, -4.31791395e-02f, -7.93529898e-02f, 4.84995805e-02f, 1.25283534e-02f, -8.85945410e-02f, -3.05477856e-03f, -6.21304102e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.09765169e-02f, 2.02932924e-01f, -1.37453213e-01f, 3.60881537e-02f, -3.27847034e-01f, -4.02173102e-01f, -6.45251945e-02f, -2.08611324e-01f, 3.82871389e-01f, -4.31554466e-02f,
  -2.60852814e-01f, 4.14314866e-01f, 2.10214913e-01f, -4.42013711e-01f, 4.07889187e-01f, 5.45115054e-01f, -2.26528674e-01f, -1.51127338e-01f, 8.83460268e-02f, -3.99359390e-02f,
  1.28479078e-02f, -6.86751679e-02f, -7.70774633e-02f, -1.80139035e-01f, -3.63952279e-01f, -3.23795676e-02f, -6.79037720e-02f, 7.49580115e-02f, -3.83295059e-01f, 2.55549289e-02f,
  -2.98233569e-01f, 3.31545085e-01f, -9.08617526e-02f, 1.52908608e-01f, -3.98667790e-02f, -1.53414086e-01f, -7.42982328e-02f, 1.29082844e-01f, 1.81637686e-02f, 1.46164950e-02f,
  2.13348046e-01f, 1.32594138e-01f, -2.59143058e-02f, -1.25095341e-02f, -9.47834030e-02f, -1.29413351e-01f, 8.01901072e-02f, -3.26482654e-01f, 4.20397297e-02f, -2.28185371e-01f,
  -7.37960562e-02f, -9.13431793e-02f, -1.30460083e-01f, 1.01674549e-01f, 2.06248045e-01f, -3.02858725e-02f, 9.90224886e-04f, -4.85208295e-02f, -1.51781570e-02f, 4.92430665e-03f,
  1.34928629e-01f, -1.82082251e-01f, -2.40126029e-02f, -1.97240040e-01f, 1.07417487e-01f, -6.44290298e-02f, 7.88541362e-02f, -1.23236015e-01f, 1.82823583e-01f, -6.73639998e-02f,
  -1.46873310e-01f, 2.10882109e-02f, -2.21547950e-02f, -8.29393715e-02f, 1.92656815e-02f, 1.91279739e-01f, -7.31270411e-04f, 7.72734582e-02f, 6.38668314e-02f, -5.94139472e-02f,
  2.48297900e-02f, -6.30933559e-03f, 1.05427451e-01f, -4.44433466e-02f, -1.73078433e-01f, 1.07885256e-01f, 1.65053196e-02f, -1.08991815e-02f, -1.15001731e-01f, 7.27635846e-02f,
  -4.08250019e-02f, 5.29329598e-01f, 1.07216008e-01f, 1.38137504e-01f, 1.25819534e-01f, 3.00871721e-03f, 4.34118472e-02f, -1.27491787e-01f, 2.66729832e-01f, 1.18001468e-01f,
  -1.02183595e-01f, 8.42627510e-02f, -7.39612728e-02f, -1.84326857e-01f, 2.46386051e-01f, 5.77578321e-02f, 1.38004154e-01f, 1.09517604e-01f, 5.83494045e-02f, -2.18480919e-02f,
  1.90542126e-03f, 3.46929133e-02f, 2.76407421e-01f, 1.04637958e-01f, 4.38461006e-02f, -5.52387238e-02f, 1.99896959e-03f, 1.15381964e-01f, 7.49351606e-02f, -3.69480811e-02f,
  5.49395263e-01f, 7.08521664e-01f, 6.39093041e-01f, 6.90977514e-01f, -5.48572481e-01f, -6.81955814e-01f, -2.38086075e-01f, -5.71380742e-02f, -1.88972697e-01f, 1.49255479e-02f,
  -4.52136457e-01f, 8.59921694e-01f, -1.47204667e-01f, 2.72539526e-01f, 3.87992188e-02f, -1.53268471e-01f, 1.74841434e-01f, 2.38363668e-01f, -1.30025759e-01f, 1.99470520e-01f,
  1.64792687e-01f, -3.94330263e-01f, 2.97302455e-01f, -3.51549476e-01f, 2.36278340e-01f, 4.66146201e-01f, 2.20423341e-01f, 5.02228178e-02f, 4.68824953e-01f, -3.68212871e-02f,
  -2.46619284e-01f, 1.84393078e-02f, 1.25123754e-01f, 4.72801663e-02f, 1.47609450e-02f, -6.84521645e-02f, 1.36993334e-01f, -6.31830916e-02f, -9.21710432e-02f, 5.22903241e-02f,
  1.54212728e-01f, -1.09131664e-01f, 7.92850405e-02f, -5.54215210e-03f, 6.60076514e-02f, 8.34059343e-02f, 7.94838518e-02f, 9.03527960e-02f, 3.63552459e-02f, 8.76304582e-02f,
  2.71557122e-01f, 8.15508217e-02f, -1.65182184e-02f, 2.69297808e-01f, 1.37593031e-01f, -2.92118080e-02f, 2.60078143e-02f, 1.98743761e-01f, 1.88629955e-01f, 1.25934137e-02f,
  -6.58737794e-02f, -1.79797888e-01f, 2.78877039e-02f, -7.56184980e-02f, 2.52379365e-02f, -9.29632410e-02f, -3.33548300e-02f, -2.47184988e-02f, 9.59437415e-02f, -1.53540894e-02f,
  -1.18177786e-01f, -2.03659926e-02f, -1.53210923e-01f, -1.17715389e-01f, 1.45717859e-02f, 4.29553725e-02f, 5.87057089e-03f, 2.23466475e-02f, 1.00593291e-01f, -5.95351681e-02f,
  -2.87590101e-02f, -6.80757463e-02f, 2.19808854e-02f, -1.16428860e-01f, -2.33804539e-01f, 4.88499925e-02f, -4.55112308e-02f, 1.95266351e-01f, -1.90185398e-01f, -7.14249685e-02f,
  5.07576875e-02f, 2.80550063e-01f, 5.54097742e-02f, -3.13318558e-02f, 8.53716861e-03f, 1.52826868e-02f, 3.54811922e-02f, 1.55683935e-01f, 2.66808569e-01f, -1.26445264e-01f,
  5.44861704e-02f, -1.24745695e-02f, 2.05477476e-02f, -8.94289277e-03f, 5.04749268e-02f, 1.25619277e-01f, 1.46788016e-01f, 1.95469707e-01f, 1.09969564e-01f, 5.81701659e-03f,
  7.40965530e-02f, -1.64178878e-01f, -4.88565899e-02f, -1.42692715e-01f, 1.60546089e-03f, 8.48015118e-03f, 9.01433751e-02f, -2.57897866e-03f, 7.92500153e-02f, 8.92732814e-02f,
  1.01196855e-01f, 1.47396564e-01f, -5.87884128e-01f, -3.60899657e-01f, -2.84333862e-02f, -7.67581403e-01f, -4.63057190e-01f, -2.32097685e-01f, 1.98186651e-01f, 2.64317989e-01f,
  -4.02959436e-02f, 3.68126094e-01f, 3.75792801e-01f, -6.14633799e-01f, -7.97222316e-01f, -2.04856992e-01f, -5.56356370e-01f, -1.22832760e-01f, 1.09318756e-01f, -1.21257536e-01f,
  -1.80109084e-01f, -2.17915535e-01f, -6.28399730e-01f, 1.62329555e-01f, -3.43243837e-01f, 8.08787048e-02f, -3.35396454e-02f, 7.16370866e-02f, -4.79697645e-01f, -2.23295093e-01f,
  -2.23345235e-01f, 1.65939853e-01f, -3.65092494e-02f, -6.73961341e-02f, -2.04580158e-01f, -1.96555164e-03f, 1.65533684e-02f, -1.07754625e-01f, -5.84771577e-03f, -6.49451336e-04f,
  3.04703742e-01f, 9.95664001e-02f, 3.78931407e-03f, 8.30424428e-02f, 1.60497382e-01f, -1.07432105e-01f, -1.93549376e-02f, -1.42930429e-02f, 7.72447437e-02f, -1.19699098e-01f,
  2.15479173e-02f, -5.16652353e-02f, -1.06949605e-01f, 2.39599328e-02f, 6.43475726e-02f, -6.49230257e-02f, -1.97668687e-01f, 7.19403673e-04f, -6.51280582e-02f, -1.41057432e-01f,
  9.88157615e-02f, 8.23266134e-02f, -1.32541001e-01f, 4.66693938e-02f, 4.94280979e-02f, -7.53924549e-02f, 6.15033768e-02f, 3.29831196e-03f, 1.42593399e-01f, -5.33713326e-02f,
  -1.20304432e-02f, 2.21321248e-02f, 8.04647133e-02f, -7.66606182e-02f, -2.07274314e-02f, 4.74336073e-02f, 6.01132661e-02f, 1.86022952e-01f, -5.39090037e-02f, -1.49687976e-01f,
  1.29847303e-01f, -1.62220821e-01f, 7.79602155e-02f, 1.82371233e-02f, -2.10906580e-01f, 1.27293900e-01f, 1.26804486e-01f, -4.39835191e-02f, -2.79092453e-02f, -1.08445194e-02f,
  -1.85108364e-01f, 7.74618564e-03f, 1.15198590e-01f, 1.17989868e-01f, 2.23284364e-02f, -8.76853466e-02f, -1.21535927e-01f, -1.99307814e-01f, -2.73502678e-01f, -7.13417158e-02f,
  5.60499206e-02f, 1.17386825e-01f, 5.84964156e-02f, 1.31069832e-02f, -6.84286803e-02f, -2.97709614e-01f, 6.21967763e-02f, 2.07259551e-01f, -9.15136263e-02f, -1.83608495e-02f,
  1.06122851e-01f, 2.07547560e-01f, 5.26739433e-02f, 1.34912014e-01f, 1.17500901e-01f, -6.88468991e-03f, 2.00990319e-01f, -6.35080179e-03f, 7.27896243e-02f, 1.33086750e-02f,
  2.33027920e-01f, -3.23837280e-01f, -5.20015359e-01f, -6.05200052e-01f, 3.13797534e-01f, 5.16346931e-01f, -4.69402522e-02f, 1.04105495e-01f, -5.41720927e-01f, 2.93219030e-01f,
  2.39962980e-01f, -6.48022652e-01f, -2.52784491e-01f, -4.37062055e-01f, -3.44195873e-01f, -4.14617270e-01f, -4.27362835e-03f, -6.71975240e-02f, -1.81091845e-01f, 2.95388132e-01f,
  -6.72288090e-02f, 9.40421596e-02f, -4.63113785e-01f, 3.06457609e-01f, 2.99563408e-01f, 6.53306618e-02f, 5.86288273e-01f, 5.62166944e-02f, 1.56967834e-01f, -1.98031291e-01f,
  -7.37784058e-02f, -9.67444256e-02f, -1.93675179e-02f, -2.14738399e-01f, 1.97301656e-01f, 2.78958827e-01f, 1.69154853e-01f, -1.35683089e-01f, -3.34176682e-02f, -1.36957273e-01f,
  1.30138934e-01f, -2.33335942e-01f, 6.38940185e-03f, -1.36519253e-01f, 1.84161887e-01f, 3.97768542e-02f, -1.14391625e-01f, 3.81268784e-02f, -3.04043800e-01f, -9.24672633e-02f,
  -1.41290963e-01f, 4.83249500e-02f, 1.96708679e-01f, -1.58675909e-01f, 7.82671664e-03f, 3.78681272e-02f, 4.24891263e-02f, 1.05455652e-01f, 1.45102620e-01f, -6.93895891e-02f,
  1.89173236e-01f, 1.92626566e-01f, 8.10732096e-02f, -1.62452862e-01f, 1.81406122e-02f, 5.80266267e-02f, -4.81831133e-02f, -2.45447159e-02f, 5.15912995e-02f, -4.41340618e-02f,
  -1.67150702e-02f, -6.58650100e-02f, -6.25047013e-02f, 2.86091883e-02f, 3.80545445e-02f, -1.00582615e-01f, 1.01759523e-01f, -3.84564586e-02f, -5.80771528e-02f, -7.45705562e-03f,
  -1.09853759e-01f, -2.56765578e-02f, -1.21317893e-01f, -6.80722818e-02f, -8.11838210e-02f, -1.37354620e-02f, 4.05768454e-02f, -4.73539252e-03f, -5.64269945e-02f, 8.47530290e-02f,
  1.36751592e-01f, 3.98637831e-01f, -6.04747310e-02f, -1.50351062e-01f, -7.81890824e-02f, 1.52096197e-01f, -2.42507961e-02f, -8.46968889e-02f, -2.20911801e-02f, 7.91412368e-02f,
  3.01592439e-01f, 1.05390236e-01f, 3.40749770e-01f, -5.24749309e-02f, -2.16725525e-02f, 2.74918586e-01f, 6.39340132e-02f, -6.40215799e-02f, 2.01556385e-01f, 1.69306263e-01f,
  8.51112977e-02f, 2.10514680e-01f, 4.34771739e-02f, -2.50619873e-02f, 8.77662152e-02f, 2.14951187e-01f, 2.81736284e-01f, -1.42569348e-01f, 8.38865340e-02f, 1.65742394e-02f,
  -7.75508165e-01f, 3.03861171e-01f, -3.55119377e-01f, -2.01084651e-02f, -4.11029369e-01f, -8.30985069e-01f, -4.31952894e-01f, 4.70451191e-02f, 2.77099341e-01f, 3.70136887e-01f,
  2.65004128e-01f, 3.63208205e-01f, 5.51142871e-01f, 2.98667625e-02f, -3.34515452e-01f, 4.33148444e-01f, -6.44752800e-01f, -2.16270864e-01f, 2.64966220e-01f, -1.98246032e-01f,
  -7.39803314e-02f, 1.20724827e-01f, -1.64665982e-01f, 1.87923431e-01f, -3.50994200e-01f, 7.52013251e-02f, 6.48271292e-02f, 1.53949603e-01f, -4.93418723e-01f, -1.85850367e-01f,
  -4.15965199e-01f, 3.88618380e-01f, -3.00570223e-02f, -3.23789239e-01f, -4.19703037e-01f, -1.49439484e-01f, -2.79462039e-01f, 8.81937966e-02f, 7.42952824e-02f, 2.92645637e-02f,
  -1.31320089e-01f, 5.78100048e-02f, 1.01220654e-02f, 2.42153510e-01f, -1.01047024e-01f, -3.05589028e-02f, -1.59320265e-01f, -4.65114057e-01f, 2.10158855e-01f, -2.91716997e-02f,
  -6.64422065e-02f, -2.28171244e-01f, -1.95990548e-01f, -8.66080597e-02f, -1.71158552e-01f, -6.05085008e-02f, -1.94178134e-01f, -6.67291135e-02f, -2.42143616e-01f, -8.90278891e-02f,
  -5.17704338e-02f, 1.70890495e-01f, 2.56653037e-02f, 1.97590768e-01f, 6.93736598e-02f, 8.13328545e-04f, 8.03682804e-02f, 2.22674161e-02f, -3.84323113e-02f, -2.12529525e-02f,
  -1.88188508e-01f, -4.75189369e-03f, 8.47918689e-02f, -2.71244437e-01f, -3.99616472e-02f, 6.28162250e-02f, -1.43214330e-01f, -1.13784969e-01f, -2.23601744e-01f, -1.42381549e-01f,
  2.49704957e-01f, -1.37582824e-01f, 6.56039417e-02f, 4.28233966e-02f, 1.90235730e-02f, 8.85039642e-02f, 5.31448387e-02f, -9.95433982e-03f, -5.92382997e-03f, -1.51511151e-02f,
  -5.86775601e-01f, 1.56283811e-01f, 1.59052461e-01f, -1.13003790e-01f, 1.26865963e-02f, 1.19141042e-02f, 1.76271796e-01f, -7.58130103e-02f, 6.41597137e-02f, -9.91421565e-03f,
  -2.23967493e-01f, -1.45155579e-01f, -2.76194632e-01f, -3.88787538e-02f, -7.34597966e-02f, -6.32113963e-02f, -4.82405797e-02f, 2.06473675e-02f, -1.64322019e-01f, -9.48874950e-02f,
  6.92321733e-02f, 7.30415136e-02f, 3.73559780e-02f, -5.33831902e-02f, -1.18609220e-01f, -6.37875423e-02f, 2.00298168e-02f, 1.69472247e-02f, -2.04275176e-01f, 8.75742361e-03f,
  -5.15749097e-01f, 6.87465429e-01f, 6.21971190e-01f, 3.90865542e-02f, -7.28840604e-02f, 6.98075950e-01f, 2.22977564e-01f, 4.39132452e-01f, 7.07736611e-01f, 1.86487660e-01f,
  -6.60607219e-01f, 4.75525081e-01f, -1.28712445e-01f, -1.65026411e-01f, -3.70370686e-01f, -1.12898454e-01f, 3.62741724e-02f, 1.49999008e-01f, 3.90895009e-01f, -2.08868310e-02f,
  -1.17480725e-01f, -5.11681199e-01f, -4.87795353e-01f, 4.29086983e-02f, -7.42183179e-02f, 3.01272988e-01f, -6.78625405e-01f, 3.06822091e-01f, -1.11916751e-01f, 1.00138478e-01f,
  -2.67719235e-02f, 5.07105142e-02f, -1.25294194e-01f, 1.63013697e-01f, 4.05732840e-02f, 7.63898715e-02f, 5.44635812e-03f, -1.75455641e-02f, 4.22651842e-02f, 7.77826756e-02f,
  -5.90910316e-02f, 4.31816764e-02f, 1.61261097e-01f, -6.47511259e-02f, 2.19353989e-01f, 5.61878830e-02f, -4.75303717e-02f, -6.21657036e-02f, 1.65412754e-01f, 4.95787263e-02f,
  -2.29234710e-01f, 1.74545459e-02f, 3.55109423e-02f, 1.43482983e-01f, -1.27895162e-01f, 1.68689296e-01f, 2.03633413e-01f, -3.35148796e-02f, 1.12912571e-02f, 2.18546584e-01f,
  -6.93609123e-04f, 1.77602947e-01f, 1.70326103e-02f, -1.38882324e-02f, -2.75305472e-02f, 2.73516774e-02f, -5.78225553e-02f, -7.10722283e-02f, -7.50101432e-02f, -8.46166089e-02f,
  4.61120866e-02f, -3.87489162e-02f, 7.48912543e-02f, 1.92190066e-01f, -7.87521005e-02f, -3.67000862e-03f, -1.33850619e-01f, -5.19277044e-02f, -4.87455279e-02f, -1.28048509e-01f,
  -1.17697557e-02f, 3.62753458e-02f, -1.89284399e-01f, -9.44752619e-02f, 5.64188361e-02f, 9.41067263e-02f, 6.51547685e-02f, 5.64355776e-02f, -2.36103207e-01f, -7.13544264e-02f,
  2.40441576e-01f, 5.17105222e-01f, 3.15033756e-02f, -3.78586836e-02f, 1.44521788e-01f, -1.26794994e-01f, 1.13060221e-01f, 1.21639781e-01f, 9.66593474e-02f, -5.82978642e-03f,
  -2.97452826e-02f, 2.96471529e-02f, -5.85062876e-02f, -6.89530224e-02f, -5.38670309e-02f, -9.98928770e-02f, -3.97897922e-02f, 1.46185696e-01f, 7.97788054e-02f, 5.65804616e-02f,
  -2.52067417e-01f, 6.97795153e-02f, 1.89230051e-02f, -9.33114216e-02f, -7.57832676e-02f, -1.33901268e-01f, 6.52626082e-02f, 7.52301961e-02f, -1.34996027e-01f, 4.24400084e-02f,
  -1.05860770e+00f, 8.94755721e-01f, -6.35721922e-01f, -1.08726338e-01f, 1.78915054e-01f, 6.45952702e-01f, 3.86773616e-01f, 2.24902749e-01f, 2.62055546e-01f, 5.28563201e-01f,
  5.10247290e-01f, -1.52807012e-01f, 3.88585269e-01f, 6.09354377e-01f, -2.78181255e-01f, 5.73273897e-01f, 3.44151109e-01f, 1.89063072e-01f, 1.42437309e-01f, -9.69808325e-02f,
  -1.98124543e-01f, 5.58684528e-01f, -1.54433802e-01f, 2.43003339e-01f, -6.63418174e-02f, -4.85464394e-01f, -2.53871292e-01f, -1.61884055e-01f, 1.62865356e-01f, 1.79055303e-01f,
  -5.24483398e-02f, -4.61849511e-01f, -2.08270490e-01f, -2.86213100e-01f, -1.06265917e-01f, -3.28763843e-01f, -2.04280332e-01f, -1.06458411e-01f, -1.56433851e-01f, 1.21075064e-01f,
  -1.22180670e-01f, -1.31359445e-02f, 7.45922998e-02f, 6.85982173e-03f, -1.66904591e-02f, 6.07152097e-02f, 2.16728393e-02f, -4.56998503e-04f, 5.34567200e-02f, -6.73377439e-02f,
  7.43770897e-02f, 1.73683494e-01f, -3.12960222e-02f, 5.11211902e-02f, 2.32393667e-02f, 2.55744383e-02f, -1.60215273e-01f, -8.09221491e-02f, 8.38929042e-02f, 8.16377103e-02f,
  -2.03584224e-01f, -5.68498559e-02f, 4.23322842e-02f, 2.05122605e-02f, 5.47541901e-02f, 8.74976963e-02f, 7.04051629e-02f, 1.26257949e-02f, -5.46075851e-02f, 7.54034743e-02f,
  1.08534701e-01f, 3.22670601e-02f, -6.45979941e-02f, -1.10424452e-01f, -6.45262236e-03f, -9.36128199e-02f, -1.84589908e-01f, 3.97840478e-02f, 4.40178066e-02f, -2.52786446e-02f,
  -1.52847823e-02f, -6.21421486e-02f, 2.67987460e-01f, 1.05042821e-02f, 7.41634518e-02f, -9.62108895e-02f, 2.16783658e-02f, 7.99280405e-03f, -3.93753164e-02f, -7.77237639e-02f,
  3.06783557e-01f, -4.64212149e-02f, 3.35040055e-02f, 1.22679450e-01f, 5.04302010e-02f, 1.31868690e-01f, -9.61917713e-02f, -9.40989330e-02f, 1.30543299e-02f, 2.95059867e-02f,
  -2.04179868e-01f, -3.83211151e-02f, -1.51663959e-01f, -7.09694531e-03f, 7.88419992e-02f, 2.03982383e-01f, -1.01984903e-01f, 3.07142287e-02f, 1.29539296e-01f, 4.84724268e-02f,
  -1.94712244e-02f, 2.04547271e-02f, -1.57775193e-01f, 1.74371272e-01f, -6.33605048e-02f, -8.67661275e-03f, -2.36471347e-03f, -5.73141538e-02f, -4.95655984e-02f, 1.14891119e-01f,
  1.13058519e+00f, 9.48165059e-02f, 9.57593769e-02f, 6.70059264e-01f, 1.20804034e-01f, -2.19765082e-01f, 3.27270478e-02f, 2.10914239e-01f, 5.55683672e-01f, -1.68174446e-01f,
  2.00225301e-02f, 8.29399154e-02f, -4.92805570e-01f, 5.32441139e-01f, -3.51610839e-01f, -3.90290648e-01f, 3.15715075e-01f, 4.99002486e-02f, 1.90081775e-01f, 3.37360561e-01f,
  3.34862947e-01f, 1.91387050e-02f, -1.93854854e-01f, -3.49774510e-01f, 6.15630925e-01f, 1.84104472e-01f, -5.32747030e-01f, -5.47173023e-01f, -1.00688264e-01f, -2.80922532e-01f,
  1.27136484e-01f, 3.55076909e-01f, 2.49763325e-01f, -8.58485326e-02f, 1.96212992e-01f, 1.07257664e-02f, -1.40528888e-01f, -2.70335704e-01f, -2.29455754e-02f, 9.91405081e-03f,
  2.21914072e-02f, 4.56783697e-02f, 2.87345629e-02f, -1.55546278e-01f, 3.70306462e-01f, 6.43766820e-02f, 1.60971731e-01f, 1.45929903e-01f, 5.69691770e-02f, 1.90136984e-01f,
  1.19007908e-01f, 1.62379414e-01f, 2.06672609e-01f, -8.13764259e-02f, 9.19100195e-02f, 9.12001505e-02f, -1.05820395e-01f, -1.38657421e-01f, -5.33743501e-02f, 1.60750285e-01f,
  6.72775358e-02f, -5.74284829e-02f, 9.01710987e-02f, 7.27995932e-02f, 9.13424194e-02f, -3.08820177e-02f, 7.35194162e-02f, -1.29156202e-01f, 4.39321883e-02f, -8.89749303e-02f,
  2.31806934e-02f, 2.52051055e-01f, 8.77228379e-02f, 4.62903753e-02f, 1.86110482e-01f, 1.64698794e-01f, -1.90927818e-01f, -1.33125260e-01f, 1.63925365e-01f, 1.21311329e-01f,
  -1.81501746e-01f, -5.93130887e-02f, -1.99339166e-02f, 5.52730523e-02f, -1.79602012e-01f, -8.96167010e-02f, 9.18562189e-02f, 1.49397224e-01f, -5.19436486e-02f, -1.29497871e-01f,
  -1.32499367e-01f, -3.77869755e-01f, -9.65752602e-02f, -7.95954093e-02f, -2.06030726e-01f, 1.34087861e-01f, -1.31027311e-01f, 1.67130411e-01f, -1.65265784e-01f, 8.12472180e-02f,
  -7.03574792e-02f, -8.60023946e-02f, -8.58621299e-02f, 2.92705577e-02f, -2.46317834e-01f, 3.94163504e-02f, -1.40989453e-01f, -2.08616138e-01f, -1.57428175e-01f, -6.91772550e-02f,
  -1.43024221e-03f, -6.70286268e-02f, -3.78364138e-02f, 1.20663367e-01f, 4.16107289e-03f, -1.08985767e-01f, 7.08885491e-02f, 9.69786271e-02f, -3.93041037e-02f, -1.35865584e-01f,
  8.84310976e-02f, 2.83239305e-01f, -4.50341731e-01f, 1.23054944e-01f, -2.63980031e-01f, -1.10932134e-01f, 1.25700921e-01f, 8.29886943e-02f, -2.92103201e-01f, 5.33088565e-01f,
  3.35612386e-01f, -2.22310036e-01f, 4.65179265e-01f, 7.33577967e-01f, 1.58672839e-01f, 4.45734620e-01f, 4.98921365e-01f, 3.30944657e-01f, -7.50167593e-02f, 2.15754583e-01f,
  8.28376263e-02f, 7.13899493e-01f, 3.46903414e-01f, 1.68022469e-01f, 2.71167457e-01f, -3.48869354e-01f, 4.24370706e-01f, -3.98860544e-01f, 3.44980121e-01f, 1.81703568e-02f,
  1.91946343e-01f, 2.47841239e-01f, -3.54633629e-02f, -1.05603814e-01f, 8.49060565e-02f, -6.34052977e-02f, -5.02396710e-02f, -1.65093198e-01f, -1.68613672e-01f, -5.49759949e-03f,
  -1.57222345e-01f, 7.04176128e-02f, 7.35918209e-02f, -2.01440930e-01f, -9.11614150e-02f, -1.15453638e-01f, -1.70252305e-02f, -1.09935418e-01f, -4.35307883e-02f, 1.53941631e-01f,
  -1.04466178e-01f, 9.35600251e-02f, -2.82359291e-02f, 1.74140200e-01f, -7.21054599e-02f, -3.40198539e-02f, -8.61997604e-02f, -2.70938966e-02f, -7.33766779e-02f, 6.19097985e-03f,
  1.64625734e-01f, -1.39024714e-02f, 5.84692210e-02f, 7.08748102e-02f, 7.09471060e-03f, 1.01352505e-01f, 4.45136242e-02f, 6.84045628e-02f, -1.80124387e-01f, 1.66197821e-01f,
  2.91524287e-02f, -1.53390095e-01f, 6.76777661e-02f, -4.11818773e-02f, 2.03658283e-01f, 1.21755793e-03f, -2.42106114e-02f, 5.19601293e-02f, -2.54275324e-03f, -4.95016202e-02f,
  -2.64598560e-02f, -9.50426832e-02f, 1.00780278e-02f, 4.39052470e-02f, 1.37891412e-01f, 7.43518211e-03f, 5.72898611e-02f, -2.17143241e-02f, -4.56927009e-02f, -8.24642554e-02f,
  2.32452258e-01f, 2.80394405e-01f, -3.18888314e-02f, -5.17983809e-02f, 2.09379010e-02f, -4.10543894e-03f, 3.57258320e-02f, 6.40516682e-03f, 1.18244871e-01f, 4.56968583e-02f,
  5.98079003e-02f, -9.27912891e-02f, 5.72126582e-02f, -5.23709394e-02f, -7.53322169e-02f, 1.74123302e-01f, 2.41995186e-01f, -1.01504914e-01f, 6.63298443e-02f, 1.21680230e-01f,
  1.18016056e-03f, -1.62280053e-02f, 8.98365080e-02f, -1.21735461e-01f, 6.66220859e-02f, 7.69398883e-02f, -1.26274154e-01f, -8.45806226e-02f, 1.05630226e-01f, 2.67752446e-02f,
  -7.50613689e-01f, 5.37930191e-01f, 7.38903046e-01f, -2.16108989e-02f, 3.53387266e-01f, 4.02581334e-01f, 1.71945035e-01f, 3.54810983e-01f, 5.22841036e-01f, 7.73787592e-03f,
  -1.45773992e-01f, -3.10253590e-01f, 1.52585387e-01f, 2.11824328e-01f, -4.74542707e-01f, 3.01515788e-01f, 1.20786868e-01f, -2.39564572e-02f, 1.47172242e-01f, 1.53359383e-01f,
  -3.38474736e-02f, -2.11852983e-01f, 2.15304866e-01f, 1.04352631e-01f, 2.31625155e-01f, -1.14463598e-01f, -4.67829823e-01f, 1.92528948e-01f, -2.47124508e-01f, 3.13034318e-02f,
  -5.54760337e-01f, -1.85184345e-01f, -1.56588078e-01f, -1.63241699e-02f, -1.78762041e-02f, -6.43721148e-02f, -1.38047144e-01f, -6.66765198e-02f, -4.77903113e-02f, 7.20580993e-03f,
  -9.47226211e-02f, -1.59175172e-02f, -1.26317725e-01f, -1.05405040e-02f, 2.38038480e-01f, 5.50179519e-02f, 1.95977375e-01f, 1.66466340e-01f, 1.65940285e-01f, 1.88593030e-01f,
  3.49018157e-01f, 1.45723745e-01f, 1.13875024e-01f, -6.19856976e-02f, -1.11469282e-02f, 1.47320271e-01f, 9.98303145e-02f, -9.71269459e-02f, 3.18371728e-02f, 4.52175029e-02f,
  8.94796252e-02f, -1.45909920e-01f, -1.48181766e-02f, -2.03291103e-02f, 1.10725969e-01f, -1.65696640e-03f, 4.37235534e-02f, -1.39850408e-01f, 6.05724975e-02f, 2.52065919e-02f,
  -1.01598151e-01f, -1.23034403e-01f, 1.09998286e-01f, 8.15693364e-02f, 1.21385148e-02f, 8.12443718e-02f, -4.41641621e-02f, 9.38896611e-02f, 8.05241689e-02f, -9.68354661e-03f,
  -2.23898813e-02f, 8.97163749e-02f, 2.30311248e-02f, -3.79933827e-02f, 3.32954228e-02f, 8.88930485e-02f, 1.34721433e-03f, 1.98955312e-01f, -6.94871843e-02f, -1.41646907e-01f,
  -8.89979184e-01f, -5.99796116e-01f, -2.90544808e-01f, -2.16686741e-01f, -1.75386652e-01f, -9.43593159e-02f, -8.71329755e-02f, -6.13700189e-02f, -8.73791501e-02f, -1.25711218e-01f,
  1.14377111e-01f, 1.06042903e-02f, -4.06179205e-02f, -5.50526939e-02f, -1.39589831e-01f, 1.29751768e-02f, -9.08558667e-02f, -5.07483631e-02f, -3.41822505e-01f, -2.26343527e-01f,
  -1.63573742e-01f, -4.92530353e-02f, -1.23540603e-01f, -1.21325508e-01f, -1.49253443e-01f, -1.50929645e-01f, -1.79112628e-01f, -1.06219538e-02f, -1.06591016e-01f, -2.25690622e-02f,
  1.34470031e-01f, 4.45658743e-01f, 4.87748414e-01f, 4.91763890e-01f, -2.84702390e-01f, -1.76073298e-01f, 2.72098202e-02f, 3.12154502e-01f, 7.88077772e-01f, -5.31755090e-01f,
  -1.96867913e-01f, -3.03734720e-01f, -1.10298298e-01f, -6.46845251e-02f, 2.17451990e-01f, 2.74575174e-01f, 4.30221558e-01f, -1.73382550e-01f, 5.95012128e-01f, -6.80887848e-02f,
  4.86721247e-01f, -6.07667685e-01f, -6.16530478e-02f, -3.72694522e-01f, -2.27222547e-01f, 3.46016079e-01f, -4.85288501e-01f, -1.37897372e-01f, -3.67352605e-01f, -1.79257825e-01f,
  1.27896309e-01f, 1.38374433e-01f, 9.12772492e-02f, 2.40118831e-01f, 1.52276754e-01f, -1.43017694e-01f, -5.21736033e-02f, -2.23740846e-01f, 1.70308411e-01f, 8.72363076e-02f,
  -2.80942228e-02f, -1.66715294e-01f, 8.63051564e-02f, -1.18238926e-01f, -5.52085899e-02f, -2.43014544e-02f, 2.05971748e-02f, 6.57879934e-02f, -8.35597739e-02f, -1.79556042e-01f,
  3.58691514e-02f, 5.30415736e-02f, -1.88063011e-02f, 7.33086988e-02f, 5.24925739e-02f, 1.36814311e-01f, 5.15637510e-02f, -3.90257351e-02f, 1.77536570e-02f, 5.84392697e-02f,
  5.15448861e-03f, 2.39308141e-02f, -1.22747481e-01f, -8.82665366e-02f, -2.35587955e-02f, 1.13724932e-01f, -2.01618727e-02f, -1.10550128e-01f, 1.25366986e-01f, -9.97058824e-02f,
  9.71980840e-02f, 4.87007014e-02f, 1.13144055e-01f, -1.03106290e-01f, -1.15153462e-01f, -2.61091981e-02f, -9.38152745e-02f, 8.09431970e-02f, 1.20807514e-01f, -3.01187653e-02f,
  -6.80643842e-02f, 2.53959373e-02f, -6.18785098e-02f, -7.73382857e-02f, 4.93947156e-02f, -4.25387658e-02f, -5.89058995e-02f, -7.71293566e-02f, 1.48614660e-01f, -7.27744997e-02f,
  2.22022593e-01f, 3.10869187e-01f, 1.33272484e-01f, 1.98602155e-02f, 1.20177425e-01f, -1.30587921e-01f, 7.61055946e-02f, 1.04496673e-01f, 1.74639210e-01f, -2.08121967e-02f,
  -9.50902849e-02f, -2.30958853e-02f, -6.48688376e-02f, -1.59335788e-02f, 9.23215076e-02f, -5.50154969e-02f, 4.38015647e-02f, 1.99783891e-01f, 5.69742508e-02f, -2.98071224e-02f,
  -1.59255296e-01f, -1.36916623e-01f, -3.14911865e-02f, -1.29904240e-01f, -2.26248484e-02f, -1.32156730e-01f, -1.87859476e-01f, 1.11988559e-01f, -5.33890575e-02f, 5.53410426e-02f,
  4.20365304e-01f, -2.27100968e-01f, -5.28412640e-01f, -2.92247802e-01f, 3.61175209e-01f, 5.22173584e-01f, -5.03345966e-01f, 9.56700221e-02f, -4.83818591e-01f, -4.48383301e-01f,
  1.68152630e-01f, -4.47219372e-01f, -5.48160970e-01f, 6.84209228e-01f, 6.58365548e-01f, -1.19673945e-01f, 6.65488720e-01f, 2.59051830e-01f, 8.59745666e-02f, 3.98536712e-01f,
  3.51445258e-01f, 8.14847827e-01f, 2.11212814e-01f, 7.64207065e-01f, 5.48605800e-01f, -9.11234617e-02f, 1.33300275e-01f, -2.71698803e-01f, 4.07372504e-01f, 3.85857761e-01f,
  7.94430822e-02f, 9.03301165e-02f, 1.05829567e-01f, 8.26415271e-02f, 1.41439006e-01f, 4.96733114e-02f, -1.17276870e-01f, -4.35571522e-02f, -5.38714156e-02f, -1.32394865e-01f,
  -1.61037832e-01f, 3.76375616e-02f, 1.84365451e-01f, -1.74358692e-02f, 1.79226145e-01f, -6.32667840e-02f, 8.21291283e-02f, -8.56126323e-02f, -1.12222522e-01f, 1.13075323e-01f,
  -1.92818016e-01f, -1.45902425e-01f, -9.83288586e-02f, -3.90565842e-02f, -1.44930154e-01f, -2.23240197e-01f, -2.61128485e-01f, -1.11466102e-01f, 1.04453238e-02f, -6.13353215e-02f,
  2.49209389e-01f, -6.85145631e-02f, -9.06068180e-03f, 2.92740073e-02f, 5.53304441e-02f, -5.17469347e-02f, -1.42167687e-01f, -5.47545739e-02f, 2.60393750e-02f, -5.96230254e-02f,
  -1.86597466e-01f, -7.80422986e-02f, 8.97385478e-02f, -2.33277641e-02f, 8.00381973e-02f, -4.32848036e-02f, 3.42183709e-02f, 8.69164616e-02f, -3.78035456e-02f, 3.92978415e-02f,
  -1.70639351e-01f, 1.21698715e-01f, 2.00151745e-02f, -1.39347851e-01f, 5.35680652e-02f, -5.45481220e-02f, 8.49545971e-02f, 8.22077170e-02f, -3.11183501e-02f, -1.76321045e-02f,
  -1.31993974e-02f, 6.50960356e-02f, -4.57445309e-02f, -1.17869256e-02f, 6.51944503e-02f, 2.08434477e-01f, 7.20744580e-02f, 1.66230395e-01f, 4.74382341e-02f, 1.06190905e-01f,
  5.17746881e-02f, -1.55249968e-01f, 2.53898185e-03f, 2.80185007e-02f, 8.28550905e-02f, 2.15414930e-02f, -1.57177642e-01f, -1.94411770e-01f, -6.52836636e-02f, 1.68357506e-01f,
  2.34167818e-02f, 5.89948371e-02f, -1.38639748e-01f, -4.42004055e-02f, 1.14229217e-01f, -1.83549732e-01f, 7.40153342e-02f, -1.81722820e-01f, 2.98991594e-02f, -2.06075922e-01f,
  -1.09801280e+00f, 3.91428083e-01f, 3.23666722e-01f, -4.43827249e-02f, -5.59856534e-01f, 1.51410718e-02f, 2.28605255e-01f, -3.66947323e-01f, -2.00448632e-01f, 5.83959877e-01f,
  4.27085124e-02f, -3.06622475e-01f, 1.36379316e-01f, 3.67893636e-01f, -7.23571718e-01f, 3.37542117e-01f, 3.94224465e-01f, 2.29780465e-01f, -1.61820635e-01f, -3.02093625e-01f,
  -2.80241489e-01f, -3.65826130e-01f, 1.69218943e-01f, -1.91466004e-01f, -2.62308061e-01f, -2.54407176e-03f, -5.39103374e-02f, -1.94973335e-01f, 3.76943111e-01f, -2.17826858e-01f,
  -2.82933861e-01f, -3.43630165e-01f, 8.37678984e-02f, 5.56600690e-02f, 9.63052793e-04f, 1.03158265e-01f, 8.98711383e-02f, -9.47432891e-02f, -1.32227972e-01f, -1.24573484e-01f,
  -5.79284243e-02f, -7.34694377e-02f, -1.39849216e-01f, -1.72689900e-01f, -1.53916016e-01f, -4.64100353e-02f, 7.20965266e-02f, 1.12509251e-01f, 1.50919203e-02f, -4.07642946e-02f,
  8.07565730e-03f, 8.46262053e-02f, 1.67283982e-01f, 2.16581702e-01f, -9.89208147e-02f, -9.63023305e-03f, 2.78508514e-01f, 1.23853339e-02f, 6.47635460e-02f, -9.36519802e-02f,
  3.19164023e-02f, -1.19859278e-01f, 5.22083491e-02f, -1.87049940e-01f, -3.50477211e-02f, 5.94462529e-02f, 1.02615163e-01f, -7.05534518e-02f, -4.91363108e-02f, -1.49894953e-01f,
  -3.99850197e-02f, -8.08735006e-03f, -3.74433100e-02f, 8.94605666e-02f, -2.38411147e-02f, 1.62656549e-02f, 1.43465742e-01f, -1.73473909e-01f, -2.24279985e-03f, 9.20506567e-02f,
  -9.26104486e-02f, -2.29193289e-02f, -7.33613595e-02f, 1.93754435e-02f, 1.71952881e-02f, -7.78746679e-02f, 1.65927660e-04f, 1.51893154e-01f, 4.13497863e-03f, -2.32259065e-01f,
  -6.34714425e-01f, -5.11181235e-01f, 5.19183353e-02f, -1.11828521e-01f, 1.53116614e-01f, -9.12472885e-03f, 8.33223201e-03f, 6.23379052e-02f, -1.59996510e-01f, -1.26968235e-01f,
  -1.32486969e-01f, 2.04742551e-01f, 5.75947352e-02f, -4.36676815e-02f, 5.43815009e-02f, -1.40537992e-01f, -1.44891143e-01f, 1.51684303e-02f, -2.23890200e-01f, -1.54684618e-01f,
  -6.31891610e-03f, -4.27267179e-02f, 1.21873870e-01f, 9.91212130e-02f, 2.12389395e-01f, -8.15807879e-02f, -2.37360761e-01f, 4.40912880e-02f, -1.16196759e-01f, 1.00038737e-01f,
  2.49625053e-02f, 4.20837879e-01f, 5.22423744e-01f, 3.46862406e-01f, -2.60108739e-01f, -1.83953017e-01f, -1.97954714e-01f, -3.86646092e-02f, -3.95450205e-01f, 3.57308924e-01f,
  -3.17096412e-01f, 4.49220061e-01f, -2.44213387e-01f, -2.61740088e-01f, -3.54821414e-01f, -5.78738570e-01f, -4.66780625e-02f, 2.02032551e-02f, -2.36273363e-01f, 6.44311726e-01f,
  -2.65623908e-02f, -3.63266021e-01f, 5.23512326e-02f, -6.24050312e-02f, 1.99891388e-01f, 3.81738752e-01f, 1.53818846e-01f, -3.31482477e-03f, 4.03702289e-01f, -3.93953264e-01f,
  -1.48853943e-01f, 4.54610167e-03f, 2.08633170e-01f, -5.27785420e-02f, 1.56569377e-01f, 8.17814171e-02f, 8.23394433e-02f, -9.64906961e-02f, -9.86926854e-02f, -3.47327814e-02f,
  8.97422433e-03f, 4.61968482e-02f, -3.64071578e-02f, -2.70657748e-01f, -1.18971504e-02f, 7.90345892e-02f, 6.13343269e-02f, 1.15453511e-01f, -5.35392426e-02f, 5.08354604e-02f,
  2.25240797e-01f, 2.25483924e-01f, 1.06822409e-01f, 1.75698817e-01f, -2.24904227e-03f, -5.04788160e-02f, 2.06356958e-01f, 3.44098419e-01f, -7.16960174e-04f, 6.86024949e-02f,
  5.41989841e-02f, -3.64889987e-02f, -1.23668157e-01f, -1.15674406e-01f, -1.14390701e-01f, -1.07416727e-01f, -1.16218433e-01f, -2.16586757e-02f, 6.23305142e-02f, 8.15055519e-02f,
  -1.12948855e-02f, 1.21120214e-01f, -2.92559177e-01f, 1.75089687e-01f, 6.61550909e-02f, -3.14791389e-02f, -5.10511920e-02f, 1.20686755e-01f, 1.79490790e-01f, -4.87076445e-03f,
  -1.24239735e-01f, -5.91233047e-03f, 8.63636956e-02f, -5.35723567e-02f, -1.54150322e-01f, 1.23282157e-01f, 6.13625944e-02f, 8.87687653e-02f, -1.90450270e-02f, 1.40162602e-01f,
  2.12194130e-01f, 3.51666451e-01f, 4.51517142e-02f, -7.21827671e-02f, -2.45422050e-02f, 5.76589182e-02f, -1.65465623e-01f, 4.08509560e-02f, 1.79835498e-01f, -1.09388851e-01f,
  2.32622877e-01f, 5.64588942e-02f, 1.86873764e-01f, 5.03260791e-02f, -3.55342962e-02f, 1.46544322e-01f, 1.21398553e-01f, 7.87132084e-02f, 1.83747888e-01f, 3.05419296e-01f,
  2.62583166e-01f, 1.31288648e-01f, 9.40134469e-03f, 1.52642399e-01f, 4.02421318e-02f, 1.18298069e-01f, 1.94638357e-01f, 1.03894256e-01f, -4.06391919e-02f, 1.69000059e-01f,
  -2.74294108e-01f, -3.72304320e-01f, 5.52659810e-01f, -6.86735928e-01f, 9.45647359e-02f, 3.48873287e-01f, -2.31197197e-02f, -1.66698053e-01f, -3.29326361e-01f, -4.43154484e-01f,
  -2.90747613e-01f, 1.62612483e-01f, 2.45583877e-01f, -4.31693077e-01f, 1.04675007e+00f, 3.79854172e-01f, -2.87201107e-01f, -2.19477698e-01f, 3.83813493e-02f, -3.88769269e-01f,
  -4.07665223e-02f, -6.07031345e-01f, 3.65833580e-01f, -4.39829618e-01f, -2.63138771e-01f, -3.14672321e-01f, -1.25147715e-01f, 2.26788923e-01f, -2.59999663e-01f, 3.39524090e-01f,
  -3.72482836e-01f, -5.02920806e-01f, -2.54442334e-01f, 3.21541876e-02f, -1.54809251e-01f, -6.71106353e-02f, 1.85019478e-01f, 2.09551975e-01f, 7.45211612e-04f, -5.48600294e-02f,
  -7.52362460e-02f, 3.70032750e-02f, -2.31241778e-01f, 1.09423481e-01f, -1.71297789e-01f, 3.77046503e-02f, 5.44566885e-02f, -9.83714126e-03f, -5.08554615e-02f, 2.82704949e-01f,
  1.23095997e-01f, 1.34286746e-01f, 2.60631181e-02f, 2.98606586e-02f, 2.86436856e-01f, -1.12445951e-01f, 4.73434851e-02f, 2.09632844e-01f, -5.41532040e-03f, 5.52445985e-02f,
  1.14550546e-01f, 4.20010388e-02f, -3.12587689e-03f, -7.42360950e-02f, -4.04075496e-02f, -1.60254776e-01f, -9.15557053e-03f, 2.77031567e-02f, -4.27349396e-02f, -3.63605767e-02f,
  4.29774672e-02f, 2.07932405e-02f, -6.78104609e-02f, -4.03313078e-02f, -9.34133604e-02f, -1.20664343e-01f, 1.00484468e-01f, -8.90936628e-02f, -1.60814449e-02f, 1.07078431e-02f,
  -2.00106227e-03f, 7.32046217e-02f, 5.12150787e-02f, 1.72049645e-02f, -6.72992766e-02f, 7.41428807e-02f, -1.37763828e-01f, 8.84942710e-03f, -1.34687833e-02f, 1.01579413e-01f,
  -5.74288249e-01f, -5.35461068e-01f, -1.71626210e-01f, -2.08343968e-01f, -9.89464894e-02f, -3.22620347e-02f, -1.03437230e-01f, 3.56826670e-02f, -5.16903121e-03f, -5.38549684e-02f,
  -3.11453808e-02f, -6.43832237e-02f, -7.40529895e-02f, -7.21347705e-02f, 6.26376644e-02f, 2.81592589e-02f, -1.21962704e-01f, -1.29265010e-01f, 3.55079360e-02f, -7.51795918e-02f,
  -1.35527164e-01f, -7.81880692e-02f, 1.55505791e-01f, -8.52997825e-02f, -4.58838418e-02f, 2.47439947e-02f, -1.05257183e-01f, 9.34708491e-02f, 7.18666688e-02f, 2.44935267e-02f,
  -2.65872836e-01f, -4.07874763e-01f, -3.28502864e-01f, 1.33911688e-02f, 6.23227894e-01f, -2.11261243e-01f, -9.05813500e-02f, 3.87949139e-01f, 1.02093130e-01f, 2.61872299e-02f,
  -4.75776531e-02f, -7.63990283e-01f, -2.76992649e-01f, -7.36213863e-01f, -7.21711934e-01f, -7.93600023e-01f, -5.39387345e-01f, -5.40199339e-01f, -1.94437414e-01f, -3.93737033e-02f,
  -5.19963317e-02f, 1.62424132e-01f, -2.46322766e-01f, 7.19905376e-01f, 1.17711917e-01f, 4.85834807e-01f, 5.40705740e-01f, 3.68391961e-01f, 1.06235920e-02f, -4.75939028e-02f,
  -1.24038652e-01f, -9.52718705e-02f, -3.92831042e-02f, 2.18041800e-02f, 1.90220088e-01f, 2.67939419e-01f, 4.59405743e-02f, -9.43730846e-02f, -3.17743085e-02f, -1.17799118e-01f,
  -1.08818293e-01f, 4.75655484e-04f, -2.27899015e-01f, -5.72875608e-03f, 2.84742951e-01f, 6.04713261e-02f, -1.05252415e-01f, 7.66830612e-03f, -5.79177961e-02f, -3.61988842e-01f,
  -1.99219272e-01f, -1.52641535e-01f, -2.68071680e-03f, -7.90389702e-02f, -5.81304207e-02f, 2.67097466e-02f, 5.48672350e-03f, -5.43606579e-02f, 1.41772423e-02f, 1.88024680e-03f,
  1.25501856e-01f, -4.08320092e-02f, -6.35571107e-02f, -7.49712735e-02f, -5.69237620e-02f, 4.77771498e-02f, -1.64719466e-02f, -3.15534626e-03f, 1.42065035e-02f, 3.28550301e-02f,
  9.47304964e-02f, 3.42375860e-02f, -9.45345685e-03f, 7.95285255e-02f, -4.51271795e-02f, 2.37952638e-02f, 1.06948338e-01f, -1.08500786e-01f, 1.99524045e-01f, -1.17623964e-02f,
  5.53227179e-02f, 5.63273430e-02f, -9.40163359e-02f, 4.49926183e-02f, -9.03249308e-02f, 6.08751029e-02f, 7.27630127e-03f, -4.82313633e-02f, -8.15649331e-03f, 7.95423090e-02f,
  1.15522586e-01f, 4.32896651e-02f, 2.12438870e-03f, 2.86509804e-02f, -1.06282905e-01f, -3.37726772e-02f, -1.21507905e-01f, -4.07541245e-02f, 1.53410867e-01f, -4.24159952e-02f,
  1.46950677e-01f, 1.87772125e-01f, 1.66493401e-01f, -2.98132151e-02f, 3.86846289e-02f, 8.31083767e-03f, 9.40707549e-02f, 5.75602353e-02f, 3.88405859e-01f, 5.96864671e-02f,
  1.82622299e-01f, 8.56790468e-02f, 9.74388793e-02f, 2.19144911e-01f, -1.34800945e-03f, 1.47428781e-01f, 2.55157519e-02f, -4.60521877e-02f, 5.10099418e-02f, -9.16297436e-02f,
  1.44822195e-01f, 5.20021975e-01f, -2.12092996e-01f, 1.26357496e-01f, 6.26638113e-03f, 6.56073153e-01f, 1.34395614e-01f, -1.33293763e-01f, -2.56266564e-01f, 3.82493496e-01f,
  5.65428846e-02f, 1.47601366e-01f, -7.21696913e-01f, 6.10422254e-01f, 1.05542913e-02f, -3.63393813e-01f, 5.12329936e-01f, 2.84180313e-01f, -3.16300869e-01f, 1.19016118e-01f,
  -1.31335229e-01f, 5.50521731e-01f, -4.20556307e-01f, 2.48830900e-01f, 4.97902840e-01f, 1.68260738e-01f, 3.02816063e-01f, -1.60976797e-01f, 7.50359237e-01f, 3.54802430e-01f,
  1.51555389e-01f, -4.25585173e-02f, -1.36337191e-01f, -1.52985351e-02f, 3.64848375e-02f, 1.61852226e-01f, 1.27159059e-01f, 8.57833549e-02f, -1.18959822e-01f, -1.01087257e-01f,
  6.44081309e-02f, -1.55875627e-02f, 7.71416426e-02f, -4.96508479e-02f, 9.35213640e-02f, -5.30019104e-02f, -1.05746903e-01f, 6.05739653e-02f, -4.19598222e-02f, -1.19553931e-01f,
  -2.81038314e-01f, -4.27978635e-02f, 1.27938226e-01f, 1.40593335e-01f, -2.42517088e-02f, -8.34474564e-02f, 5.27461134e-02f, -5.17744310e-02f, 3.66229832e-01f, 1.59844786e-01f,
  1.26984537e-01f, 1.21313930e-01f, -9.36119109e-02f, -3.02431844e-02f, -6.13806807e-02f, -6.79468587e-02f, 6.84841648e-02f, -1.54900514e-02f, -2.36101132e-02f, -2.26866361e-02f,
  -3.55442874e-02f, 2.43318956e-02f, 1.47868514e-01f, -7.07159713e-02f, 4.07315530e-02f, 8.03993344e-02f, -8.91221315e-03f, 2.36007362e-03f, -1.57167062e-01f, -2.01681584e-01f,
  1.92198046e-02f, 1.16603777e-01f, -6.22851290e-02f, 5.61636314e-02f, -4.54720333e-02f, -1.12907410e-01f, 1.44072071e-01f, 1.91800538e-02f, -1.38021663e-01f, 9.98104177e-03f,
  2.12177888e-01f, 3.60168844e-01f, -1.62566110e-01f, -6.71381364e-03f, -8.93946812e-02f, 4.56419550e-02f, 1.25792727e-01f, 1.16550140e-01f, 6.71911463e-02f, 7.03513548e-02f,
  2.04436615e-01f, 4.32922542e-02f, 1.32901937e-01f, 2.35346705e-02f, 4.29892726e-03f, -4.81266640e-02f, -2.86945794e-02f, -8.96707922e-03f, 9.69251320e-02f, 9.47688147e-02f,
  9.35378447e-02f, -1.09170504e-01f, 7.30280131e-02f, -1.06818385e-01f, 6.27043545e-02f, -5.39926998e-02f, 2.69940682e-02f, -5.32997064e-02f, 1.38079002e-01f, 7.06741512e-02f,
  -3.66322607e-01f, -8.21963966e-01f, 6.78169012e-01f, 1.80130213e-01f, 2.13028476e-01f, -4.39491570e-02f, 2.58993655e-01f, -3.00815374e-01f, -4.68512326e-01f, -7.81728506e-01f,
  -2.76175160e-02f, -7.33181387e-02f, -6.21305816e-02f, 2.38827676e-01f, 7.60772467e-01f, 2.17896551e-01f, 6.03743941e-02f, 1.09457910e-01f, 3.13911229e-01f, 1.61254659e-01f,
  2.84673721e-01f, 2.19644517e-01f, 6.23587728e-01f, 1.68058872e-01f, 1.59257978e-01f, 9.97025296e-02f, 1.51318172e-02f, 5.31730294e-01f, 5.66659607e-02f, 2.37418607e-01f,
  -1.91947088e-01f, -3.16231623e-02f, 1.65589061e-02f, -3.29393148e-02f, -9.39057171e-02f, -1.16640791e-01f, 1.32046146e-02f, 2.70242423e-01f, 1.90727070e-01f, -1.12650968e-01f,
  -2.27949470e-02f, 5.01096882e-02f, 3.89341377e-02f, -3.99398617e-03f, -1.10934272e-01f, 1.56106977e-02f, -1.33359835e-01f, -6.27612770e-02f, -2.46730074e-02f, -2.76909899e-02f,
  1.60825357e-01f, -1.54423892e-01f, 5.26528656e-02f, -3.08653638e-02f, 1.88609689e-01f, -1.44235760e-01f, 7.30244294e-02f, 9.59959105e-02f, -1.94010511e-01f, -2.72151772e-02f,
  1.43588111e-01f, 7.00919479e-02f, -6.82950020e-02f, -9.90530383e-03f, 6.52177483e-02f, -1.06306233e-01f, 1.98355950e-02f, 8.00644159e-02f, 5.02923243e-02f, -9.19780880e-02f,
  -6.65936247e-02f, -6.60359561e-02f, -6.16467260e-02f, -1.59434095e-01f, -9.33740214e-02f, -1.67541921e-01f, 2.63723463e-01f, -9.12025105e-03f, 4.78843935e-02f, 3.43662861e-04f,
  -7.54627138e-02f, 1.17645957e-01f, 5.30039035e-02f, 1.43352732e-01f, -1.73878208e-01f, 4.39450610e-03f, -1.36488006e-01f, -7.35481456e-02f, -6.88058659e-02f, 2.43706226e-01f,
  -5.21755695e-01f, -3.52784544e-01f, 8.55675712e-02f, -1.29583865e-01f, 1.27450243e-01f, -5.08131236e-02f, 1.68649614e-01f, -1.77609786e-01f, -4.58407700e-02f, 1.36061937e-01f,
  -1.35382488e-01f, 8.15419108e-02f, -1.27469882e-01f, 4.92623374e-02f, 1.32536814e-01f, -1.55399218e-01f, 2.18593460e-02f, -1.90051392e-01f, -1.75766984e-03f, -1.93222221e-02f,
  -9.82392132e-02f, 5.21795899e-02f, 7.33752847e-02f, 3.94263603e-02f, -5.83567098e-03f, -1.00339718e-01f, 1.24681508e-02f, -9.10624117e-02f, 2.00230628e-01f, 6.15315922e-02f,
  3.65089141e-02f, 4.85201925e-01f, -5.12380302e-01f, 2.92687088e-01f, -2.34605685e-01f, 8.38668168e-01f, 6.34353578e-01f, 1.13522731e-01f, 4.29255784e-01f, 4.46821034e-01f,
  -7.96737522e-02f, 3.76678169e-01f, -1.58368185e-01f, 6.10976279e-01f, 5.22865295e-01f, 4.10396993e-01f, 6.73297286e-01f, 5.88274240e-01f, 1.01957999e-01f, 2.65502959e-01f,
  -3.73308593e-03f, 5.30198932e-01f, -3.86587441e-01f, 1.51517853e-01f, -2.04869851e-01f, -3.78581196e-01f, -4.17551965e-01f, -5.01712978e-01f, 1.41572043e-01f, 3.89273092e-02f,
  2.77273189e-02f, 7.57088512e-02f, -2.13500455e-01f, -4.49006483e-02f, -1.09887168e-01f, -6.82791024e-02f, -1.36803240e-01f, -1.12320878e-01f, -1.77682593e-01f, -2.27869675e-02f,
  8.68415534e-02f, 5.45881838e-02f, 1.63585946e-01f, 1.42849246e-02f, -3.36815417e-02f, -3.28709036e-02f, -6.27619773e-02f, -1.67463452e-01f, -1.00799948e-02f, -8.70743692e-02f,
  -9.42523777e-02f, -5.63944057e-02f, -3.16259414e-02f, 4.83633094e-02f, -1.15085855e-01f, 1.49727777e-01f, 1.23144858e-01f, -1.22390002e-01f, 9.31595787e-02f, 1.16285212e-01f,
  8.40350389e-02f, 9.65771228e-02f, 7.69485533e-03f, -1.22623384e-01f, 1.07844904e-01f, -1.75166011e-01f, 9.83319655e-02f, -1.22116432e-01f, -6.48226365e-02f, 7.62154907e-02f,
  4.36277948e-02f, -8.20815265e-02f, 3.58682461e-02f, 1.46759495e-01f, 6.39195666e-02f, 6.64451346e-02f, -1.01063944e-01f, 3.33033465e-02f, 2.55897772e-02f, -8.49847589e-03f,
  -1.40497953e-01f, 2.08752483e-01f, -9.13272146e-03f, -1.47509933e-01f, 1.11448966e-01f, -1.52025223e-01f, 3.03510595e-02f, -3.00021004e-02f, -1.09518029e-01f, -3.15488875e-02f,
  2.29224086e-01f, 5.43261349e-01f, 1.38404727e-01f, 6.88423142e-02f, 2.95704715e-02f, 1.07887782e-01f, -1.61957147e-03f, 7.27962181e-02f, 1.05437912e-01f, 1.50610611e-01f,
  -5.41841239e-02f, -1.10004265e-02f, 2.78646592e-02f, -7.25995377e-02f, 9.38546136e-02f, 1.12826049e-01f, 1.18657753e-01f, -2.38973517e-02f, 6.76641688e-02f, 5.27781844e-02f,
  -2.47982033e-02f, 1.96733698e-01f, 3.61490846e-02f, 7.53240380e-03f, 6.46052063e-02f, -1.07360497e-01f, 2.46534646e-01f, -1.16451167e-01f, -7.04250410e-02f, 5.49044125e-02f,
  1.03219831e+00f, -8.83564770e-01f, -6.55075237e-02f, 3.56634170e-01f, 5.05118608e-01f, 4.02135521e-01f, 6.47732913e-01f, -2.81249732e-01f, -2.59273648e-01f, -5.95589101e-01f,
  -4.70155440e-02f, 1.51045129e-01f, -4.92686898e-01f, 3.55765879e-01f, 8.23921919e-01f, -4.64060128e-01f, 3.49857897e-01f, 3.05853337e-01f, -8.46338943e-02f, -4.34850641e-02f,
  2.05674022e-01f, 2.45722070e-01f, -4.38752696e-02f, -4.95806068e-01f, 2.33982757e-01f, -2.20364675e-01f, -1.72468036e-01f, -1.04828522e-01f, 2.39304110e-01f, 4.14047092e-01f,
  2.35117376e-01f, -1.92105800e-01f, 1.70281723e-01f, 4.26483564e-02f, -1.57014206e-01f, 1.18415102e-01f, 2.49635383e-01f, 2.28853419e-01f, 2.82096267e-01f, -2.50770990e-02f,
  3.84648442e-02f, 1.03721768e-01f, 1.01843677e-01f, 3.57341394e-02f, 1.02099031e-01f, 2.69773435e-02f, -1.78626888e-02f, -6.44700527e-02f, -1.15724333e-01f, -6.49773553e-02f,
  -1.09317690e-01f, 2.79936362e-02f, 4.20626588e-02f, -2.59723514e-02f, -4.10288088e-02f, -9.38129425e-03f, 1.06404975e-01f, -3.61536965e-02f, -2.75972616e-05f, 8.45641792e-02f,
  -6.06815703e-02f, -5.27464077e-02f, -1.15533292e-01f, -3.51996766e-03f, 1.32489959e-02f, 1.84859961e-01f, 7.64723122e-02f, -3.02889626e-02f, 3.39040719e-03f, -6.25768825e-02f,
  1.10166706e-01f, 8.05111676e-02f, -7.21082613e-02f, 4.66746390e-02f, 1.41540235e-02f, 6.43971190e-02f, 1.06440365e-01f, -4.51336289e-03f, -5.37845269e-02f, -8.13967064e-02f,
  2.53470410e-02f, 6.43919855e-02f, -1.00497745e-01f, 4.87241261e-02f, 4.03929269e-03f, -4.22831364e-02f, -1.68278903e-01f, -4.29054163e-02f, -1.57406688e-01f, 4.78412621e-02f,
  -2.08784297e-01f, -8.86030257e-01f, -1.76645145e-01f, 7.30739459e-02f, -8.38583708e-02f, -1.05868727e-01f, -8.86525363e-02f, -3.25721055e-02f, -1.24338185e-02f, -4.66616312e-03f,
  -9.79951248e-02f, 1.01460338e-01f, -6.15792982e-02f, 6.41617253e-02f, 8.12580287e-02f, -2.52475739e-01f, -4.82761823e-02f, 8.26844797e-02f, 1.46040842e-01f, -8.83362070e-02f,
  -7.50691146e-02f, -3.22107635e-02f, 9.62542966e-02f, -2.71842871e-02f, -3.40975188e-02f, 9.16543677e-02f, -1.31526351e-01f, -1.77338999e-02f, -1.52741857e-02f, -3.75661664e-02f,
  -1.08832276e+00f, 8.96501362e-01f, 5.86219013e-01f, -5.91183603e-01f, 2.62487441e-01f, -7.17746466e-02f, -5.18221080e-01f, 5.38835645e-01f, -1.41567588e-01f, 1.79083794e-01f,
  -4.20508772e-01f, 1.83526307e-01f, 2.45659456e-01f, -3.15470606e-01f, -5.86627185e-01f, -1.70495659e-01f, -6.42077923e-01f, -5.12521803e-01f, 1.22324228e-01f, -1.24075197e-01f,
  -3.30490172e-01f, -4.96238112e-01f, 2.01369464e-01f, 4.39535975e-01f, 3.67377847e-01f, 3.70983094e-01f, -6.40048325e-01f, 6.25495136e-01f, -5.90524822e-02f, -3.87333217e-03f,
  3.94513942e-02f, 1.87114060e-01f, 3.05280894e-01f, 2.06983805e-01f, -3.13217901e-02f, -4.33242768e-02f, -1.90401554e-01f, 3.56832445e-02f, -6.34513199e-02f, 7.21813366e-02f,
  2.34372746e-02f, 1.29262999e-01f, -3.38996500e-02f, 1.04089297e-01f, 1.51067153e-01f, 2.80145764e-01f, 2.17701972e-01f, 1.53040718e-02f, 2.37701073e-01f, 1.38450712e-01f,
  1.17303602e-01f, 2.03176752e-01f, -7.10072042e-03f, -6.98825568e-02f, 4.79467027e-02f, 5.84065244e-02f, -7.97001496e-02f, 8.32207594e-03f, 6.77581280e-02f, 3.17178620e-03f,
  -7.37014785e-02f, -1.42814979e-01f, 1.47468731e-01f, 8.96187350e-02f, -7.10081756e-02f, 8.35795552e-02f, -3.91648598e-02f, -7.95688257e-02f, 7.96881597e-03f, -1.79797355e-02f,
  -5.59130162e-02f, 8.74635279e-02f, 4.76016430e-03f, -1.43603191e-01f, -2.50009656e-01f, -7.38223195e-02f, -2.85005593e-03f, 4.83269570e-03f, -1.33754924e-01f, 3.29395719e-02f,
  -5.59482053e-02f, -1.36643171e-01f, -1.31475693e-03f, -7.56259859e-02f, -7.06001837e-03f, 3.46434750e-02f, 7.00186566e-02f, 7.50814900e-02f, -8.36675540e-02f, 1.30902762e-02f,
  -3.46026421e-01f, -2.54698724e-01f, 1.52471095e-01f, 1.37522727e-01f, 1.91408843e-02f, -8.24485570e-02f, 3.86418812e-02f, 6.58511668e-02f, -4.85431366e-02f, 6.12285640e-03f,
  -4.37910892e-02f, -2.04777834e-03f, -1.35621175e-01f, 1.67128760e-02f, -1.50998980e-01f, -1.18982822e-01f, -2.45857343e-01f, -1.72228932e-01f, -1.87102437e-01f, -2.28293240e-03f,
  3.12018953e-02f, -1.63176581e-01f, -9.63056181e-03f, 1.18317753e-01f, -9.50630680e-02f, -6.73461407e-02f, -6.22489937e-02f, 1.95762277e-01f, 2.59204023e-03f, 6.18075542e-02f,
  -8.97564590e-02f, -4.42925513e-01f, -2.76806881e-03f, 5.22444487e-01f, 4.05375242e-01f, -4.77757275e-01f, -5.37164807e-01f, 2.63243556e-01f, 1.31592333e-01f, -3.98741513e-01f,
  4.05117543e-03f, -4.97913420e-01f, -7.16783404e-01f, 2.82145470e-01f, 4.21767145e-01f, -5.26828229e-01f, 6.52884364e-01f, -5.19822352e-02f, 2.08214119e-01f, 4.21569437e-01f,
  4.88665789e-01f, 4.95324105e-01f, 3.10525358e-01f, 5.25302529e-01f, 1.52009219e-01f, 3.98791879e-01f, 3.74299020e-01f, -3.50354165e-02f, 4.28358704e-01f, -5.93229532e-02f,
  -2.01148123e-01f, 1.36632830e-01f, 4.43862192e-02f, -1.44386753e-01f, 1.17301404e-01f, -9.43428874e-02f, -1.14695273e-01f, -1.69164136e-01f, 7.55416453e-02f, -3.82048450e-02f,
  -1.19358525e-01f, 1.69252917e-01f, 1.50488138e-01f, -7.02628121e-02f, 7.81718716e-02f, 2.10850865e-01f, 1.75898895e-02f, 2.71219779e-02f, 3.73772122e-02f, -2.43705232e-02f,
  6.91355616e-02f, -7.95046985e-02f, 1.67097375e-01f, 1.63306743e-01f, 1.94138676e-01f, 1.98429272e-01f, 1.19517930e-01f, -2.75406241e-02f, -2.52699852e-02f, 3.25419694e-01f,
  -6.28711805e-02f, 2.79915687e-02f, 5.47625460e-02f, -1.00492105e-01f, 6.17248528e-02f, 1.73065782e-01f, -6.41800324e-03f, -1.58217158e-02f, -5.28448708e-02f, -2.10878085e-02f,
  2.21079737e-01f, -4.48626168e-02f, 2.06976533e-02f, 6.00529835e-02f, 1.71921209e-01f, 1.02679439e-01f, -1.77423358e-01f, -6.49513304e-02f, 8.94178301e-02f, -2.87967827e-02f,
  3.07371691e-02f, -4.35279682e-03f, -1.79080516e-01f, -6.66773841e-02f, 5.94543926e-02f, -4.21319567e-02f, -5.21384701e-02f, -2.13956963e-02f, 5.62097728e-02f, -1.86825935e-02f,
  -2.05566987e-01f, 1.33814141e-01f, -3.82754579e-02f, 3.54162864e-02f, 3.98028046e-02f, 1.35085121e-01f, 1.50528476e-01f, 2.76421607e-02f, -3.71316522e-02f, -1.51148096e-01f,
  1.76313326e-01f, 3.87482867e-02f, -1.72357023e-01f, -4.52575572e-02f, 1.93142553e-03f, 5.82293570e-02f, 4.32149594e-04f, 1.33850336e-01f, 1.22878574e-01f, 3.83178741e-02f,
  8.66416022e-02f, -3.72807607e-02f, 1.98349923e-01f, 2.03556389e-01f, -4.23550792e-02f, -1.18520623e-02f, 8.01487081e-03f, 5.72653487e-02f, 3.75247635e-02f, 3.70518267e-02f,
  -4.51227397e-01f, -3.66653353e-01f, -4.93146330e-01f, 1.10498935e-01f, -2.79031754e-01f, -4.16994035e-01f, -4.46645260e-01f, 2.62630749e-02f, -2.35456780e-01f, 6.33427501e-02f,
  2.75665522e-01f, 2.31654244e-03f, 2.22004637e-01f, 3.50531638e-01f, 2.06909373e-01f, 2.03027725e-01f, 3.67593110e-01f, 2.91078478e-01f, 1.94358438e-01f, 1.51809022e-01f,
  3.32853168e-01f, 2.95355201e-01f, 3.83570701e-01f, 2.11453587e-01f, -2.61338968e-02f, 2.33576402e-01f, 6.48900449e-01f, -5.00140563e-02f, 5.87981045e-01f, 5.66904135e-02f,
  -2.88729575e-02f, -3.98079753e-02f, 1.20101888e-02f, -1.40602201e-01f, 2.39378750e-01f, 9.42480713e-02f, 1.41219780e-01f, -1.96143016e-02f, -4.30132374e-02f, 9.92036834e-02f,
  -3.24417949e-02f, -4.43753637e-02f, -1.31355658e-01f, 1.28751295e-02f, -2.53239088e-02f, -1.98108673e-01f, -1.47590965e-01f, 9.66220200e-02f, -5.21035939e-02f, -1.24033824e-01f,
  -3.73417437e-01f, 5.96255586e-02f, 1.68139525e-02f, -9.25366301e-03f, -1.93973705e-02f, -1.65058315e-01f, -1.49470465e-02f, -1.31846726e-01f, 4.45413925e-02f, -4.03325818e-02f,
  8.56100302e-03f, -7.43454397e-02f, 1.47413937e-02f, 6.67165890e-02f, -5.26226796e-02f, 1.60914689e-01f, 4.46795225e-02f, 1.80214226e-01f, 7.49554634e-02f, 7.15300664e-02f,
  5.52928708e-02f, -1.71355810e-02f, 4.10402641e-02f, -4.33353744e-02f, -9.66610163e-02f, -1.42778531e-01f, -6.64038286e-02f, -7.07312077e-02f, -8.02081302e-02f, 1.15828894e-01f,
  1.39685839e-01f, -1.83421358e-01f, -1.23348631e-01f, 1.03579499e-01f, -4.69363816e-02f, -3.11450176e-02f, 1.37109622e-01f, -1.30861223e-01f, 5.79317920e-02f, 9.12935510e-02f,
  2.56744981e-01f, 2.32660964e-01f, -1.13561355e-01f, -2.54575144e-02f, 2.98652444e-02f, 1.16207171e-02f, 3.27570587e-02f, 2.46609412e-02f, 9.94755253e-02f, -4.32696976e-02f,
  8.06141794e-02f, 9.65061262e-02f, 1.58073202e-01f, -1.03410825e-01f, 3.31019573e-02f, -7.32926354e-02f, 3.29063535e-02f, 7.93735310e-02f, 1.51438236e-01f, 1.20196782e-01f,
  -5.33914268e-02f, -6.75789863e-02f, 7.61415288e-02f, -1.87323824e-01f, -8.81735757e-02f, 1.09782755e-01f, -5.67466095e-02f, 9.15075932e-03f, 1.33371428e-01f, 9.51833948e-02f,
  6.78160906e-01f, -3.42481136e-01f, 8.82462114e-02f, 3.75225902e-01f, 3.89613658e-01f, 4.97266620e-01f, 4.47161406e-01f, 2.53328741e-01f, 9.72096980e-01f, -4.77003038e-01f,
  -4.04551685e-01f, -1.96599141e-01f, -1.47253215e-01f, -3.89711142e-01f, 5.74428022e-01f, 1.73301935e-01f, 6.50404170e-02f, 6.05249628e-02f, 2.22846955e-01f, -2.80421153e-02f,
  2.65270531e-01f, -3.53911936e-01f, -5.05795419e-01f, -4.01673287e-01f, -3.06908250e-01f, -3.70260835e-01f, -6.82144403e-01f, -2.41148591e-01f, -6.40533090e-01f, -8.83094296e-02f,
  -1.13520594e-02f, 6.06696978e-02f, -2.42062330e-01f, -1.15930296e-01f, 5.88354692e-02f, -1.06461398e-01f, -1.19098693e-01f, -5.08809984e-02f, 1.55038714e-01f, 5.84808737e-02f,
  7.77019933e-03f, -1.91196650e-02f, 9.61038843e-02f, 6.76697865e-02f, 4.88039814e-02f, -5.51539250e-02f, -6.53460026e-02f, -1.09312404e-02f, -4.87603061e-02f, 1.01627139e-02f,
  8.83710943e-03f, -3.08002736e-02f, 3.17982100e-02f, 9.91769359e-02f, -3.30770435e-03f, -9.35975313e-02f, -2.31258967e-03f, -6.31201267e-02f, -1.84073905e-03f, 1.00447141e-01f,
  -1.42742455e-01f, 1.23525053e-01f, 2.60048267e-02f, -7.52800656e-03f, 7.13076591e-02f, 4.15593013e-02f, -1.11665383e-01f, -3.54775563e-02f, 1.11018963e-01f, -1.11041866e-01f,
  6.31567016e-02f, -2.67954934e-02f, 1.56649411e-01f, -1.45770917e-02f, -1.42464219e-02f, 1.10233836e-01f, 3.49065997e-02f, 9.28324610e-02f, 6.15441538e-02f, -5.93153834e-02f,
  9.13584158e-02f, 1.05570093e-01f, -1.41980097e-01f, 1.12685524e-02f, -2.23166998e-02f, 3.29944529e-02f, -8.28656033e-02f, -3.30569129e-03f, -9.50127095e-02f, -1.23944404e-02f,
  8.29319209e-02f, 1.27831653e-01f, -1.24411024e-01f, -1.57890320e-01f, -1.32435575e-01f, -5.84988333e-02f, 1.88714951e-01f, 9.63819101e-02f, 4.60531265e-02f, 1.82629868e-01f,
  -1.08562082e-01f, -4.54090275e-02f, 5.19255139e-02f, 2.83501595e-02f, -2.27706552e-01f, -6.96334392e-02f, -1.38155743e-01f, -3.97189483e-02f, -2.00377330e-02f, -2.08256602e-01f,
  -1.56718075e-01f, 8.06530267e-02f, 5.53653836e-02f, 1.13057129e-01f, -4.03272472e-02f, -1.01645894e-01f, 6.55579418e-02f, -9.13097262e-02f, 1.48311526e-01f, -1.33313127e-02f,
  -1.16789192e-02f, 2.13040337e-02f, -2.99428642e-01f, -7.19104782e-02f, -2.97427326e-01f, 6.86698496e-01f, 8.47190440e-01f, -3.94292593e-01f, -2.48292580e-01f, 4.42538947e-01f,
  3.35759193e-01f, -7.62292892e-02f, 5.86121917e-01f, 2.76792794e-01f, 2.16700599e-01f, 5.86314738e-01f, 4.58349466e-01f, 3.62993836e-01f, -2.83994526e-01f, 1.09619483e-01f,
  -8.31029564e-02f, 4.09091890e-01f, 1.31898925e-01f, -4.68325794e-01f, 2.78756708e-01f, -3.97431701e-01f, -1.26503125e-01f, -5.49374856e-02f, -3.12573344e-01f, 3.46575789e-02f,
  5.72375953e-02f, -3.98903601e-02f, -4.26579490e-02f, 8.61038491e-02f, 7.29800835e-02f, 2.98092347e-02f, 1.59403086e-01f, 8.40367749e-02f, -8.61557424e-02f, 6.57507731e-03f,
  1.31975308e-01f, -1.39078274e-01f, -9.85393301e-02f, -1.94847152e-01f, -6.38946667e-02f, -2.43659452e-01f, -1.52702272e-01f, -7.09566846e-02f, -1.19340152e-01f, 1.06630418e-02f,
  6.67285025e-02f, -6.18940294e-02f, 2.83609424e-02f, -4.51836698e-02f, -6.32719249e-02f, -4.94334735e-02f, 1.59477651e-01f, 5.23795411e-02f, -1.50003098e-02f, -6.59694374e-02f,
  -1.23637944e-01f, 1.35516047e-01f, 1.52922049e-01f, -1.45220105e-02f, 1.04854833e-02f, -4.94234860e-02f, -8.61529484e-02f, 5.23539335e-02f, -5.98293357e-02f, 8.15640017e-02f,
  -4.93851304e-02f, -1.51449805e-02f, -3.11968569e-03f, 3.32469568e-02f, 3.39931552e-03f, -3.36962141e-04f, 7.25641325e-02f, -8.42452869e-02f, 1.87569018e-02f, -6.79572076e-02f,
  -4.05122116e-02f, -1.94300022e-02f, -1.47272283e-02f, -6.51440322e-02f, 7.35909045e-02f, -6.13259114e-02f, 1.77816022e-02f, -5.31092584e-02f, 2.51107235e-02f, 1.40058249e-01f,
  8.32087696e-02f, 1.23644322e-01f, 6.17591888e-02f, 2.26959996e-02f, 3.25877555e-02f, 5.02144769e-02f, 4.32565995e-02f, -6.73986301e-02f, -8.37428588e-03f, -1.39421653e-02f,
  -9.07336771e-02f, 1.92395717e-01f, -9.23946872e-02f, -8.02548826e-02f, -1.09936990e-01f, 8.13718364e-02f, 2.80808389e-01f, -1.60410106e-02f, 3.64644267e-02f, -2.14774191e-01f,
  9.56541747e-02f, 1.44156769e-01f, 2.17471290e-02f, 7.62791410e-02f, -1.06901072e-01f, 1.94224104e-01f, -1.33561328e-01f, -1.55755892e-01f, -6.12002239e-02f, 2.72724386e-02f,
  5.03431745e-02f, -2.20532119e-01f, -2.99982335e-02f, -7.66975284e-01f, -2.00987726e-01f, 2.62538314e-01f, -3.61529678e-01f, -3.47957373e-01f, -5.87029696e-01f, -4.23459649e-01f,
  -5.96264601e-01f, -1.02879442e-01f, 3.24084014e-01f, -6.13435984e-01f, 7.48143911e-01f, 2.91107804e-01f, -4.02238756e-01f, -2.84016430e-01f, -1.13231935e-01f, -3.74309242e-01f,
  -1.32352471e-01f, -4.53759521e-01f, 1.41783163e-01f, -2.49875307e-01f, -3.49614024e-01f, -2.55484074e-01f, 1.05585545e-01f, -6.01071641e-02f, -4.52841073e-01f, -2.45691836e-02f,
  -6.86661229e-02f, -2.47421756e-01f, -9.04801711e-02f, 6.97369352e-02f, 9.28875282e-02f, 1.31635234e-01f, -4.10821512e-02f, 1.61267251e-01f, -1.75708547e-01f, 1.70794420e-03f,
  -5.42745739e-03f, 7.10499436e-02f, -2.05132633e-01f, 9.43803340e-02f, -1.17628001e-01f, -2.91053623e-01f, 7.94638395e-02f, -8.86475481e-03f, 1.08330715e-02f, 1.66994810e-01f,
  4.59688380e-02f, 1.03277899e-01f, -9.67150927e-02f, -2.19757333e-01f, -1.64104342e-01f, -2.07365423e-01f, 1.19604133e-01f, 1.15532994e-01f, -9.91249532e-02f, 2.07586517e-03f,
  -4.28479025e-03f, 9.68061313e-02f, 1.19010016e-01f, -2.59698089e-02f, -6.14981093e-02f, -5.16741648e-02f, 2.00965814e-02f, -8.44237804e-02f, -8.65454748e-02f, 6.52127564e-02f,
  -2.16852903e-01f, -5.25039211e-02f, -1.86728239e-01f, 2.57870853e-02f, 9.27169770e-02f, 4.97239493e-02f, 7.93909058e-02f, -1.69189237e-02f, -9.98544544e-02f, 9.47768316e-02f,
  -1.66791841e-01f, -8.02723020e-02f, -1.58104450e-01f, -5.99316098e-02f, 1.73485950e-01f, 4.25533764e-02f, -1.36302873e-01f, 1.67216584e-01f, 9.32775205e-04f, 6.04268648e-02f,
  4.66046147e-02f, -6.94486946e-02f, -9.27876681e-02f, -6.49635121e-02f, 1.20106600e-01f, 1.84855938e-01f, -1.45252170e-02f, -1.30226105e-01f, -5.45974374e-02f, 9.40541364e-03f,
  -4.62812483e-02f, 5.74122928e-02f, 1.75509732e-02f, -7.34714940e-02f, -6.85951635e-02f, -2.29668375e-02f, -4.63679396e-02f, -3.27648446e-02f, 1.12838350e-01f, -4.46270891e-02f,
  6.32318668e-03f, -5.87331615e-02f, 1.19063646e-01f, -7.84223080e-02f, -9.59801003e-02f, 6.76878020e-02f, 1.30393729e-01f, -6.39629140e-02f, 3.55093069e-02f, -1.42117634e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.64366049e-01f, 6.44244850e-01f, 4.68042284e-01f, 5.76644063e-01f, 4.63422507e-01f, 5.70743501e-01f, 7.60161340e-01f, 6.55300558e-01f, 3.62245560e-01f, 7.02356517e-01f,
  7.53858864e-01f, 5.05832791e-01f, 4.82354343e-01f, 6.82312667e-01f, 6.51665568e-01f, 6.94844961e-01f, 6.89104378e-01f, 5.92169166e-01f, 5.20296574e-01f, 6.84758008e-01f,
  7.93582857e-01f, 5.40108502e-01f, 5.11103511e-01f, 8.36486161e-01f, 7.55274892e-01f, 6.64945662e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -4.67755087e-02f, -5.76174498e-01f, 1.02227844e-01f, -4.94675398e-01f, 5.32403648e-01f, 1.32054985e-01f, -6.78146064e-01f, -5.69457412e-01f, -5.04673004e-01f, -3.68705869e-01f,
  1.52526870e-01f, -6.93768978e-01f, 5.73284626e-01f, -5.65241933e-01f, 6.33568585e-01f, 2.52154678e-01f, 4.17629592e-02f, -5.37723839e-01f, 1.09034443e+00f, -3.50871354e-01f,
  -5.64335346e-01f, -4.26437527e-01f, 3.14001292e-02f, -2.35269025e-01f, 1.81404334e-02f, -6.62998974e-01f, -8.04064393e-01f, -5.69739878e-01f, 3.88658881e-01f, -8.45392942e-01f,
  7.18233943e-01f, -3.93898219e-01f, -6.26042247e-01f, 3.65593672e-01f, -1.75958604e-01f, 5.14396280e-02f, -7.41817296e-01f, -2.47385740e-01f, -5.34075022e-01f, -4.27343518e-01f,
  -2.95571238e-01f, 3.17462832e-01f, -8.42701614e-01f, -5.49304843e-01f, 7.29378760e-01f, 4.70712394e-01f, 5.08242249e-01f, -9.75464165e-01f, -1.08490169e+00f, 5.67080438e-01f,
  -1.01122510e+00f, -5.16915560e-01f, -9.05449986e-01f, -6.00195885e-01f, 5.98313510e-01f, -1.11242342e+00f, 5.79556108e-01f, 1.09305531e-01f, -5.51018834e-01f, -4.13957357e-01f,
  -7.65494034e-02f, -1.31128743e-01f, 3.95683378e-01f, 2.01049268e-01f, -7.52296597e-02f, -3.34958375e-01f, 1.61300808e-01f, -5.20993054e-01f, -2.84893930e-01f, -2.23802119e-01f,
  -6.17459834e-01f, -3.91063362e-01f, -2.94802696e-01f, -3.73361349e-01f, -6.26244068e-01f, -5.80038428e-01f, -3.70617598e-01f, -1.84142128e-01f, -2.78595328e-01f, -6.99664712e-01f,
  -5.04449368e-01f, 4.92668152e-01f, -2.32701853e-01f, -3.37130457e-01f, -2.40334272e-01f, 3.43076676e-01f, 4.14618790e-01f, 4.16508317e-01f, 4.39617597e-02f, 7.75060177e-01f,
  -4.43951786e-01f, 4.98816073e-01f, 1.94671452e-01f, -6.12091303e-01f, -8.25472772e-01f, -6.86718106e-01f, 8.27199444e-02f, -5.16319513e-01f, -2.87501603e-01f, 3.80178660e-01f,
  2.95530230e-01f, -1.44917965e-01f, 4.48521167e-01f, -5.71248472e-01f, 6.67578220e-01f, -3.82473111e-01f, 9.11844552e-01f, 2.87093818e-01f, 3.52137148e-01f, -5.58250904e-01f,
  -4.26332384e-01f, 1.25483677e-01f, -7.65008032e-01f, -3.78243059e-01f, 7.60295168e-02f, -5.09510398e-01f, -7.79047668e-01f, 1.99025467e-01f, -6.73251092e-01f, -1.87963381e-01f,
  -4.18348640e-01f, -2.77309090e-01f, 6.04474902e-01f, -1.97875991e-01f, -7.93887973e-01f, -8.76587272e-01f, -5.50148010e-01f, -6.91127598e-01f, 4.39739019e-01f, 1.01884000e-01f,
  4.79692161e-01f, -3.52276504e-01f, 4.71221715e-01f, -9.70013559e-01f, -3.85769516e-01f, -6.43536329e-01f, -8.71896982e-01f, 5.74487634e-02f, -2.88501084e-01f, 3.85507137e-01f,
  3.17689180e-01f, -6.80130124e-01f, -1.07788563e-01f, 6.77297533e-01f, 2.16976047e-01f, 5.19351959e-01f, 3.26589584e-01f, -2.45856687e-01f, 6.25535250e-01f, -7.26912439e-01f,
  -6.08556330e-01f, 4.04254228e-01f, -6.01918817e-01f, -9.80434239e-01f, 6.43927157e-01f, -2.50495337e-02f, 6.07073233e-02f, -3.14372450e-01f, -2.91885316e-01f, 6.17434740e-01f,
  5.51786602e-01f, 1.86648399e-01f, 2.19399944e-01f, -1.21413879e-01f, 4.50674623e-01f, 7.06900597e-01f, 5.33441901e-01f, 3.20008963e-01f, -8.18047002e-02f, -3.99105698e-01f,
  3.39259803e-02f, 7.52123892e-01f, 4.93459813e-02f, -1.81038365e-01f, -2.01937079e-01f, 5.60453758e-02f, 6.03726506e-01f, -5.80228925e-01f, -3.85383308e-01f, 1.33495659e-01f,
  -4.10429180e-01f, -7.04572916e-01f, 1.51746675e-01f, -4.94845450e-01f, 7.60323703e-01f, -3.62030715e-01f, -8.94478917e-01f, -2.38065973e-01f, -5.67011416e-01f, 4.27942008e-01f,
  3.09989601e-01f, -6.39035702e-02f, -1.56594604e-01f, 1.10091992e-01f, -1.42387345e-01f, -2.40872636e-01f, -6.89952314e-01f, 2.39260405e-01f, -2.96597570e-01f, -5.66662192e-01f,
  -5.87409317e-01f, -9.02809948e-02f, -2.90114492e-01f, -3.78918976e-01f, -9.78716969e-01f, 1.11754119e+00f, -5.59015036e-01f, 3.63452196e-01f, 6.50510907e-01f, -2.09734410e-01f,
  -7.09721148e-01f, -6.84959590e-01f, -2.84399122e-01f, 6.90340757e-01f, -1.24584615e+00f, -7.24345744e-02f, -1.75171167e-01f, 4.18651640e-01f, -2.45770678e-01f, 3.49884123e-01f,
  -4.85180825e-01f, 7.51241624e-01f, -2.12570399e-01f, -7.67824113e-01f, -3.81178170e-01f, 1.62427574e-02f, -3.83605570e-01f, 3.40995759e-01f, 7.52528608e-02f, -3.07786584e-01f,
  5.58828175e-01f, 2.22889885e-01f, 4.82482821e-01f, -1.52844787e-01f, 4.09588695e-01f, -3.02404314e-01f, -5.84366918e-01f, -3.82534295e-01f, -9.50678140e-02f, -5.70739448e-01f,
  2.48830393e-01f, -3.28220129e-01f, -3.03290814e-01f, -5.97619772e-01f, 5.24690151e-01f, -3.49668592e-01f, -4.93117929e-01f, -5.84567904e-01f, -5.30807436e-01f, -6.23951793e-01f,
  -4.97731358e-01f, -1.77872881e-01f, 3.79867464e-01f, 4.80132550e-01f, -6.35999084e-01f, 6.17850363e-01f, -1.50651202e-01f, -3.62636566e-01f, -2.60254920e-01f, 4.90327328e-01f,
  -3.19793314e-01f, 3.27054322e-01f, 1.99992239e-01f, 6.58683598e-01f, -6.04576588e-01f, -3.28544319e-01f, 3.76611680e-01f, -6.21843815e-01f, -1.52666047e-01f, -2.13073101e-02f,
  4.27391112e-01f, -3.32723916e-01f, 4.02838230e-01f, 6.13755211e-02f, -4.45538938e-01f, 4.54694867e-01f, -5.07248819e-01f, -9.26204324e-02f, 7.07425401e-02f, 3.93988401e-01f,
  -3.96572083e-01f, -1.08969188e+00f, -3.05857718e-01f, 5.32760262e-01f, 4.91691917e-01f, -5.62539518e-01f, -7.84818113e-01f, -5.42477846e-01f, -1.98002145e-01f, 3.54690254e-01f,
  -2.10014805e-01f, -4.83928949e-01f, -6.80783065e-03f, 6.74837351e-01f, 1.28832027e-01f, -1.26622571e-02f, -4.84435171e-01f, -3.12816739e-01f, -5.82763553e-01f, -6.66441143e-01f,
  -7.97510743e-01f, -8.65486026e-01f, -5.82959056e-01f, -8.51529315e-02f, -3.24572861e-01f, -4.34478849e-01f, -4.68819171e-01f, -2.91062087e-01f, 7.49322832e-01f, -8.73440325e-01f,
  -3.11004490e-01f, 8.25109184e-01f, -8.89742494e-01f, 7.78921425e-01f, -7.61883557e-01f, -9.90982592e-01f, -1.83544934e-01f, 2.50387669e-01f, 6.13043308e-01f, 5.16051531e-01f,
  2.17375353e-01f, 4.66503948e-01f, 1.19311258e-01f, 5.27595758e-01f, 9.36970264e-02f, -4.84768540e-01f, -5.70123315e-01f, -3.93709481e-01f, 1.86744913e-01f, 8.57144654e-01f,
  -7.79667318e-01f, -4.29787450e-02f, -3.65327150e-01f, -7.52145350e-01f, -4.02081013e-01f, -8.32128465e-01f, -4.78021234e-01f, -4.64803994e-01f, 5.09744026e-02f, 5.32000661e-01f,
  -5.05565464e-01f, 9.79756176e-01f, 2.22754061e-01f, -6.62791669e-01f, -4.84954476e-01f, -7.83771992e-01f, -4.78935279e-02f, 6.19553088e-04f, 3.49432021e-01f, -2.13763267e-01f,
  -7.98520893e-02f, -1.10275857e-01f, 1.76878020e-01f, 3.30271870e-01f, 6.33448437e-02f, 3.61592084e-01f, -1.32461205e-01f, -3.68904978e-01f, -2.68699735e-01f, 9.58051682e-01f,
  1.56402156e-01f, -3.80985945e-01f, -4.18320239e-01f, 4.24213946e-01f, -7.32474685e-01f, 9.39881742e-01f, -4.89367753e-01f, 2.38918632e-01f, 1.08034648e-01f, -5.92237353e-01f,
  3.88801843e-01f, 6.87364101e-01f, -4.39557463e-01f, -7.93386936e-01f, 2.35646605e-01f, -6.79440677e-01f, -7.00516105e-01f, -1.14636593e-01f, 3.97620767e-01f, -6.68636262e-01f,
  -5.80284774e-01f, -3.72646481e-01f, -6.18917346e-01f, -5.84432185e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.18016893e-01f, 2.51760837e-02f, -2.37329215e-01f, 2.56574657e-02f, 4.29340601e-02f, 3.28706913e-02f, -4.35039625e-02f, -4.59132493e-02f, -2.55931377e-01f, 2.65147328e-01f,
  7.70827532e-02f, 2.80307997e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    