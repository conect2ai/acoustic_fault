/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.06505734e-01f, -3.77436727e-01f, -1.87640190e-02f, -5.79536147e-02f, 1.58082843e-01f, -4.43811804e-01f, -3.33867043e-01f, 1.19950725e-02f, -6.65225685e-02f, -4.09204811e-01f,
  -5.99533729e-02f, -3.59888002e-03f, -2.11558595e-01f, -1.93237677e-01f, -8.23373124e-02f, -2.27614239e-01f, -1.20145053e-01f, -1.01989813e-01f, 1.09636948e-01f, 3.94684589e-03f,
  1.65451970e-02f, -1.60398930e-01f, 1.26534939e-01f, 1.77832916e-02f, 1.11769989e-01f, 8.73079449e-02f, 4.37956564e-02f, 6.31692782e-02f, -4.39075753e-02f, -4.17933837e-02f,
  1.58625826e-01f, 4.83393408e-02f, 1.27898216e-01f, 9.65648287e-05f, 4.51318845e-02f, -1.50084300e-02f, 9.85580590e-03f, -1.78145431e-02f, 2.96431389e-02f, 3.05352174e-02f,
  -1.73766203e-02f, 7.51237385e-03f, -2.58673988e-02f, 9.98595543e-03f, -2.38396693e-03f, -2.40411353e-03f, 8.87024701e-02f, 2.40126625e-02f, 2.11805571e-02f, 1.83359403e-02f,
  6.62603229e-02f, 7.74025992e-02f, 5.48850512e-03f, -3.53844576e-02f, 4.30948474e-02f, 1.21496385e-02f, -4.59894314e-02f, 2.65932363e-02f, 4.46576551e-02f, 1.09527158e-02f,
  -3.59775648e-02f, 3.18038859e-04f, 6.95264190e-02f, 8.50294810e-03f, -3.58109027e-02f, 4.69058268e-02f, -1.49716518e-03f, -1.29374024e-02f, -1.40384343e-02f, 6.37012348e-03f,
  4.12032455e-02f, 2.13091709e-02f, 4.52102683e-02f, 3.03776860e-02f, -1.08339749e-02f, -3.96459922e-02f, 2.84786299e-02f, 3.67279500e-02f, 4.53909151e-02f, 4.71187085e-02f,
  4.64036390e-02f, -2.54699253e-02f, -1.58765130e-02f, 1.39011014e-02f, -5.62918857e-02f, 2.02538054e-02f, -5.22731170e-02f, -3.77484523e-02f, 1.19707156e-02f, 3.54043320e-02f,
  -3.38827223e-01f, -2.74224818e-01f, -6.56132121e-03f, 6.02135882e-02f, 4.34996840e-03f, -1.68355238e-02f, 6.04812987e-02f, 2.75086059e-04f, -8.66061524e-02f, -1.55245711e-03f,
  3.81038375e-02f, 8.71131197e-03f, -2.89742090e-02f, -1.82087738e-02f, -3.50126927e-03f, -3.18913534e-02f, 9.09493584e-03f, 1.40137272e-02f, -1.57242753e-02f, 6.61123917e-02f,
  5.80217317e-02f, 2.67455447e-02f, -7.29982974e-03f, 5.13414219e-02f, -5.41487560e-02f, -7.37607032e-02f, 2.11902615e-02f, 1.83928683e-02f, 7.51627535e-02f, -1.19673293e-02f,
  5.11576712e-01f, 1.66173071e-01f, 1.46016940e-01f, 3.61524194e-01f, 4.26145159e-02f, 1.41001835e-01f, 1.07256182e-01f, 6.37088269e-02f, 1.31101713e-01f, 1.21595450e-01f,
  2.79575065e-02f, 1.92831233e-01f, -9.72867105e-03f, 3.11513036e-01f, 9.23551545e-02f, 2.03435183e-01f, 2.48980746e-01f, 1.49420232e-01f, 1.25582144e-01f, 9.45090607e-04f,
  1.75439969e-01f, 1.22104704e-01f, 1.67583823e-01f, -7.58449584e-02f, 1.11218495e-02f, -8.32155347e-02f, 1.91102328e-03f, -4.35316823e-02f, 3.04038431e-02f, 3.30693796e-02f,
  -1.34349048e-01f, -4.69985157e-02f, 5.01113422e-02f, -3.82317603e-02f, -5.86949289e-02f, 6.81556202e-03f, 2.98616942e-02f, -5.89031465e-02f, 7.74898753e-02f, 4.99355048e-02f,
  4.35224036e-03f, -5.59599604e-03f, 1.09225232e-02f, -2.23587194e-04f, 1.37095600e-02f, 4.11610119e-02f, 2.05534976e-02f, 5.72425611e-02f, -1.12420060e-02f, -2.45090742e-02f,
  5.83494455e-02f, 3.85269038e-02f, 3.42641361e-02f, 7.27460086e-02f, -3.69432680e-02f, 2.83029024e-02f, -5.93931926e-03f, -2.32215878e-02f, 4.89371419e-02f, 4.21150550e-02f,
  -4.33675051e-02f, -2.35249717e-02f, -2.51678526e-02f, -5.06328931e-03f, 2.50441767e-03f, 1.59553792e-02f, 9.73945763e-03f, -1.25065055e-02f, 4.29793037e-02f, -2.84619760e-02f,
  5.98460101e-02f, -2.74826661e-02f, 3.22096571e-02f, 7.19554797e-02f, -2.53697503e-02f, 5.70381666e-03f, 4.24750485e-02f, 2.74995752e-02f, 2.82162372e-02f, 3.49230915e-02f,
  1.43958870e-02f, 3.09746549e-03f, 8.70604068e-03f, 1.82254929e-02f, 2.72653699e-02f, -2.24730640e-04f, 3.51118520e-02f, -3.93199213e-02f, 2.35750508e-02f, 3.97328548e-02f,
  -4.27750088e-02f, -5.31916395e-02f, -2.59399181e-03f, 7.68515980e-03f, 1.67288166e-03f, -4.68970835e-03f, 4.32948731e-02f, -3.03558772e-03f, -8.99280384e-02f, -6.88734055e-02f,
  -6.84127435e-02f, -1.45172793e-02f, -6.58104718e-02f, 3.39766443e-02f, -1.32541312e-02f, 4.86328490e-02f, 4.89384532e-02f, -7.64458179e-02f, -2.84487644e-04f, 8.68195482e-03f,
  -3.37816738e-02f, -5.18466625e-03f, -6.29685121e-03f, -6.63175508e-02f, 5.27206101e-02f, -2.04813518e-02f, 1.09268725e-02f, 2.02572718e-02f, -2.39479057e-02f, -1.39280292e-03f,
  -2.56972522e-01f, -7.91328307e-03f, -4.04319912e-01f, 1.23211622e-01f, -2.05981627e-01f, -2.53646523e-01f, -2.33509943e-01f, 4.88828169e-04f, -2.14339703e-01f, 2.52568096e-01f,
  1.07699849e-01f, 1.17100067e-01f, -1.28645584e-01f, 3.17513883e-01f, -3.32068980e-01f, -1.02172218e-01f, 5.50267808e-02f, 1.17079303e-01f, -1.29206955e-01f, -1.19659193e-02f,
  -2.00865064e-02f, 2.13703945e-01f, -9.20593888e-02f, 1.00309946e-01f, 4.37423252e-02f, 2.37567574e-02f, 1.98953703e-01f, -8.69376883e-02f, 1.70456409e-01f, 8.89156908e-02f,
  6.60734549e-02f, 2.27201924e-01f, 7.73041695e-02f, -2.20299866e-02f, 1.87909650e-03f, -5.16318642e-02f, 1.03226432e-03f, -5.90931773e-02f, 1.18499920e-02f, -3.19771515e-03f,
  -1.06828716e-02f, 1.17628369e-02f, -1.25664547e-02f, 4.90016751e-02f, -2.03531049e-02f, 4.54580151e-02f, -2.16677636e-02f, 1.09948916e-02f, 8.60763073e-04f, -7.64964847e-03f,
  7.82524142e-03f, 3.40946913e-02f, 8.56978912e-03f, -1.04022911e-02f, -3.57492343e-02f, 4.18059714e-02f, -3.07138041e-02f, -5.96328303e-02f, 7.66437054e-02f, -5.64567978e-04f,
  -2.62070037e-02f, -1.99742470e-04f, 2.01937091e-02f, 2.88297385e-02f, 1.92676168e-02f, 1.04481354e-01f, 3.41060124e-02f, -2.86406707e-02f, 2.89165881e-02f, 6.30141469e-03f,
  4.35441770e-02f, -1.22607881e-02f, -1.35630965e-02f, 1.35928011e-02f, -9.77432076e-03f, 8.60315263e-02f, -4.42681126e-02f, -4.48259041e-02f, 5.03053330e-03f, 9.09134746e-03f,
  -2.42575128e-02f, -2.95022242e-02f, 1.10840062e-02f, -3.68780605e-02f, 1.33946759e-03f, -3.47006395e-02f, 1.22646522e-02f, -4.37336937e-02f, -2.44703535e-02f, -1.15496805e-02f,
  -1.34527341e-01f, -1.18908197e-01f, 3.80622596e-02f, 2.61837617e-02f, -4.64464352e-03f, 6.12627752e-02f, -2.69044433e-02f, 3.63760255e-02f, -5.33494093e-02f, -2.74158996e-02f,
  2.17879917e-02f, -2.60802712e-02f, 2.56103612e-02f, -1.32955960e-03f, -8.57966244e-02f, -3.38214375e-02f, 2.26772297e-02f, -2.45817248e-02f, 2.05329154e-02f, -7.56456330e-03f,
  -1.28241694e-02f, -2.70746835e-02f, -8.34807660e-03f, 1.12860069e-01f, 6.01802506e-02f, 3.16179544e-02f, 3.18194516e-02f, 1.71259362e-02f, -1.11917272e-01f, -3.13365385e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.24593949e-01f, 3.98921072e-01f, 4.50806826e-01f, 2.47987896e-01f, -1.76512867e-01f, -2.77844191e-01f, -1.62544996e-01f, -1.90606210e-02f, -8.00367668e-02f, -1.52746374e-02f,
  -3.22594970e-01f, 3.03030431e-01f, -6.47689356e-03f, 8.96660462e-02f, -2.78053343e-01f, -2.11524382e-01f, -1.45755038e-02f, -4.48366366e-02f, 2.76565291e-02f, 1.00150615e-01f,
  3.65148038e-02f, -2.80395180e-01f, 1.87931731e-01f, -1.22124299e-01f, 1.16225824e-01f, 2.47982889e-01f, -7.58357570e-02f, -1.78865772e-02f, 9.83178690e-02f, -1.63330436e-01f,
  -4.81107384e-02f, 2.68349517e-02f, 1.18564263e-01f, 5.21264784e-02f, 1.55577436e-02f, -3.81223634e-02f, 7.59482235e-02f, -1.20310728e-02f, -6.95266426e-02f, 1.18888821e-02f,
  2.67109424e-02f, 8.55926424e-02f, 1.34978155e-02f, -6.71175271e-02f, 2.32129283e-02f, 1.25330001e-01f, 1.27122357e-01f, 9.50077772e-02f, 6.40593842e-02f, 8.21484327e-02f,
  6.69443235e-02f, 5.68722934e-02f, 8.00656527e-03f, 4.68578609e-03f, 4.78415424e-03f, -2.38848664e-02f, 2.61576436e-02f, 9.85850021e-02f, 5.55533078e-03f, -3.77904661e-02f,
  1.12498604e-01f, -2.55801678e-02f, -5.50981760e-02f, -2.38577500e-02f, -6.50882022e-03f, -4.94193584e-02f, -6.53793663e-02f, -5.68001755e-02f, -2.83711199e-02f, -3.70188206e-02f,
  -4.35031354e-02f, 1.62335429e-02f, -1.56053957e-02f, 1.68486033e-02f, -6.53055683e-03f, -7.13778380e-03f, 4.01180983e-02f, -4.72022034e-02f, 3.84264365e-02f, -5.20066824e-03f,
  -1.99892931e-02f, -2.38742586e-02f, -2.80290656e-02f, -3.34120682e-03f, -4.53338679e-03f, 5.01778163e-02f, 1.79111026e-02f, 5.81648685e-02f, -5.02033234e-02f, -3.28505933e-02f,
  -1.23381466e-01f, -6.77252412e-02f, -5.03223650e-02f, -4.67435718e-02f, 3.86317074e-02f, -5.09543009e-02f, -4.69377823e-02f, 7.17008263e-02f, 4.45538983e-02f, -6.34371787e-02f,
  -2.32773926e-02f, -6.74730763e-02f, -6.59002438e-02f, 2.86496207e-02f, -3.17791663e-02f, -1.29457772e-01f, -3.72542702e-02f, 5.11565991e-02f, -5.09240739e-02f, 5.07430062e-02f,
  4.24269773e-03f, -4.06328999e-02f, -5.39492406e-02f, -2.97198240e-02f, 2.67276280e-02f, 2.30339970e-02f, -5.94294667e-02f, 3.52535322e-02f, 2.17088801e-03f, 6.54182583e-02f,
  -2.37877324e-01f, 3.29646915e-01f, 1.08177654e-01f, -2.16116533e-01f, -6.66664972e-04f, -2.80048512e-02f, 7.06712622e-03f, 2.18322799e-01f, -2.78379116e-02f, -5.15896603e-02f,
  5.01309037e-02f, -2.06323117e-01f, 2.46838808e-01f, -1.77971780e-01f, 7.27333948e-02f, 1.25741243e-01f, 4.20458689e-02f, -9.95637253e-02f, 8.36179852e-02f, -4.46561612e-02f,
  -1.14025339e-01f, -1.65701687e-01f, -7.96523914e-02f, 6.12307154e-02f, -1.32585630e-01f, -4.96239327e-02f, -2.42158502e-01f, 1.23937912e-01f, -1.93320036e-01f, -5.49595281e-02f,
  9.54712331e-02f, -1.19751960e-01f, 5.26522733e-02f, 8.49872269e-03f, -1.03217483e-01f, -1.13228478e-01f, -4.66010459e-02f, 6.16558380e-02f, -1.14302570e-02f, 3.01176514e-02f,
  -1.83431264e-02f, 7.79313559e-04f, -4.84366082e-02f, -1.83240452e-03f, -8.58196151e-03f, 7.43565112e-02f, -3.93872187e-02f, -1.11316945e-02f, -2.06788583e-03f, -2.37466320e-02f,
  -1.25959786e-02f, -3.47122289e-02f, -4.96989302e-02f, -9.54372361e-02f, -7.54102599e-03f, 7.07594156e-02f, -7.36629730e-03f, -1.26274794e-01f, -8.19245949e-02f, -1.11071706e-01f,
  2.26569548e-03f, 6.58239350e-02f, 1.74969789e-02f, -8.00778251e-03f, 9.11830589e-02f, 8.76072943e-02f, -5.12381271e-02f, -7.19896052e-03f, -2.05715019e-02f, -1.67209823e-02f,
  -3.71514969e-02f, -2.41960343e-02f, -1.10362777e-02f, 1.33939460e-02f, -3.01194051e-03f, 3.35103013e-02f, -3.54340039e-02f, 3.34571884e-03f, 5.37678525e-02f, 2.12158356e-02f,
  -8.28885511e-02f, -5.56419678e-02f, 2.49617677e-02f, -1.06352605e-02f, 6.14150092e-02f, -8.26677401e-03f, -4.67019677e-02f, 2.07386073e-02f, -1.26299553e-03f, -2.30019409e-02f,
  4.36731502e-02f, 1.60546042e-02f, 5.59471212e-02f, -4.95637357e-02f, 7.13992212e-03f, -1.57383643e-02f, 8.34975019e-02f, 3.54360044e-02f, 8.48774686e-02f, -2.00177170e-02f,
  -1.34884194e-01f, -9.60284565e-03f, -1.63816392e-01f, 3.06139570e-02f, 1.02654370e-02f, 2.62085274e-02f, -7.03952685e-02f, -5.54152280e-02f, -2.86976062e-02f, 4.58304174e-02f,
  -8.77365842e-02f, 5.58710471e-02f, 4.16471586e-02f, 9.54619050e-02f, -1.34979934e-02f, -1.15791179e-01f, -7.30728731e-02f, -1.04166456e-02f, -8.06429908e-02f, 1.98979937e-02f,
  2.57643640e-01f, -1.18027538e-01f, -4.34993737e-04f, -6.45964965e-02f, 2.96935458e-02f, 2.91090440e-02f, 2.86403239e-01f, -3.41755897e-01f, -3.16682130e-01f, -6.46065548e-02f,
  1.62174013e-02f, 2.18117505e-01f, 3.01202625e-01f, -1.00546338e-01f, 3.14248919e-01f, 4.32929955e-02f, -1.72541782e-01f, -1.96768809e-02f, -1.85191393e-01f, -3.86570357e-02f,
  -1.47235826e-01f, -7.86437616e-02f, 1.39755309e-01f, -2.01991931e-01f, 5.76745942e-02f, -5.54743260e-02f, 8.00560415e-02f, 7.53987804e-02f, -1.04044735e-01f, -1.05718262e-02f,
  1.53673708e-01f, 1.12032399e-01f, -3.90512124e-03f, 3.14403065e-02f, 1.10947140e-01f, -1.47480322e-02f, 7.55098090e-02f, 1.20896950e-01f, 2.38637701e-02f, 4.83240038e-02f,
  1.47441134e-01f, 9.87220649e-03f, -1.07108615e-01f, -2.98104435e-02f, -1.10932238e-01f, 3.06929299e-03f, -2.97885872e-02f, 1.20479334e-02f, 2.43888609e-03f, -1.41344750e-02f,
  3.63722257e-02f, 4.46637645e-02f, -9.53877531e-03f, -8.61926451e-02f, -6.51165023e-02f, -2.95679495e-02f, 1.62234008e-02f, 2.46316474e-02f, -2.17515156e-02f, -1.70214884e-02f,
  -7.58257834e-03f, -7.82490596e-02f, 4.25066799e-02f, 2.21507680e-02f, 8.35812837e-02f, -3.40605415e-02f, 9.54757929e-02f, -8.83332714e-02f, -1.18349902e-01f, -3.60229276e-02f,
  4.17909911e-03f, -2.02306416e-02f, -7.76308030e-02f, -5.06592058e-02f, -2.03957036e-02f, -2.61557605e-02f, 9.18168351e-02f, -4.16985266e-02f, -6.89642578e-02f, -4.43576602e-03f,
  1.67245441e-03f, -1.52544919e-02f, 6.44316850e-03f, -6.05272539e-02f, 9.91937816e-02f, 8.27298909e-02f, -6.72989562e-02f, -1.99213214e-02f, -1.28661450e-02f, 3.87727059e-02f,
  7.95943215e-02f, -6.40709177e-02f, -2.59379055e-02f, 3.46141867e-04f, 4.27809469e-02f, -1.11388430e-01f, -3.56141478e-02f, -9.26481709e-02f, -6.55158311e-02f, 2.95140743e-02f,
  -1.31354645e-01f, -2.92211175e-02f, 6.28648000e-03f, 3.29901688e-02f, 2.82402579e-02f, -1.04906298e-01f, -7.39250798e-04f, 7.55261779e-02f, -5.65874279e-02f, -7.24621757e-04f,
  3.04164775e-02f, 7.91222453e-02f, -3.98038104e-02f, 7.34255016e-02f, -1.08824149e-01f, 5.67205809e-02f, -5.44596016e-02f, 5.85453585e-02f, 6.38456792e-02f, 9.25908389e-04f,
  7.17730761e-01f, 3.92017305e-01f, 1.41497657e-01f, 1.54427111e-01f, 4.18191440e-02f, -2.03135803e-01f, -1.42410696e-01f, 2.40179718e-01f, -1.72406018e-01f, -1.64014194e-02f,
  2.94857234e-01f, -1.72544330e-01f, 1.94102302e-01f, 6.33084103e-02f, 9.21251476e-02f, 9.97510999e-02f, 7.85360634e-02f, -3.89378220e-02f, 1.42827304e-02f, 2.24031538e-01f,
  3.67017873e-02f, 2.07235083e-01f, 1.64275214e-01f, 2.22624734e-01f, 4.31756340e-02f, 1.02291197e-01f, 2.32424781e-01f, 9.02282000e-02f, 1.08163998e-01f, 2.79088356e-02f,
  -7.81471878e-02f, -5.31693641e-03f, 1.95166729e-02f, -7.23485500e-02f, 4.02194038e-02f, -7.76265096e-03f, -1.15736343e-01f, -4.89310473e-02f, -1.17461747e-02f, -5.46527607e-03f,
  -7.06053749e-02f, -2.94498857e-02f, -4.95452024e-02f, -2.53628325e-02f, -6.22200631e-02f, -8.74632001e-02f, -3.48723680e-02f, -2.40232870e-02f, -4.19698022e-02f, -1.96352415e-02f,
  -4.63914685e-02f, -4.34976667e-02f, -8.25554579e-02f, -5.52786514e-02f, 3.24430503e-02f, -5.86735345e-02f, -7.55726770e-02f, -1.51612042e-02f, -3.72255445e-02f, -4.00411785e-02f,
  1.53658418e-02f, 9.83083155e-04f, 5.95412217e-02f, -4.70165350e-02f, 5.45431636e-02f, 4.15447727e-02f, 3.44018219e-03f, 1.01273060e-02f, -5.27499169e-02f, 3.95235382e-02f,
  7.79613620e-03f, -2.01067347e-02f, 1.15231592e-02f, -1.27070889e-01f, 1.34420283e-02f, -7.01339245e-02f, -6.90701976e-02f, 1.67614818e-02f, -2.80514788e-02f, 1.83656234e-02f,
  -2.86361612e-02f, -5.83529240e-03f, 9.16173775e-03f, 4.63358387e-02f, -1.89941712e-02f, 6.21183477e-02f, 1.94843784e-02f, 4.76901941e-02f, -1.48517173e-02f, -1.01015508e-01f,
  1.40702114e-01f, 4.23657596e-01f, 4.04379554e-02f, -7.19575509e-02f, -4.93256422e-03f, -6.93249926e-02f, 8.22825655e-02f, 3.18365097e-02f, 7.54849985e-02f, 7.58345425e-02f,
  -4.53470126e-02f, -7.00741336e-02f, 5.78401089e-02f, -1.57059040e-02f, -5.09703197e-02f, 8.29743445e-02f, 6.31832331e-03f, 2.86701764e-03f, 1.61287114e-02f, 5.53782471e-02f,
  7.23954961e-02f, -1.97371859e-02f, -4.73931730e-02f, -2.37533287e-03f, -3.57290022e-02f, 8.57412145e-02f, -1.91649739e-02f, -6.91354200e-02f, 4.62657586e-03f, -3.01845428e-02f,
  -5.14437914e-01f, 2.92304695e-01f, -1.08117417e-01f, 5.47344051e-02f, -5.42518981e-02f, 1.90647934e-02f, 9.50345993e-02f, -8.01522136e-02f, 3.27812396e-02f, 1.88766986e-01f,
  1.96531549e-01f, -1.48567170e-01f, 2.39053696e-01f, 1.67888269e-01f, -4.72142324e-02f, 2.09397167e-01f, 5.06253056e-02f, 2.12018132e-01f, 4.96502817e-02f, -9.75095332e-02f,
  -5.78639358e-02f, 8.40872750e-02f, 4.09894921e-02f, -2.18291208e-02f, -1.98286157e-02f, -1.78392440e-01f, -4.38051745e-02f, 3.62222567e-02f, 3.76695246e-02f, 7.05840513e-02f,
  -8.82151797e-02f, -1.01761788e-01f, -8.24735016e-02f, -3.20904814e-02f, -1.33947238e-01f, -2.42527183e-02f, -3.53523158e-02f, -4.96690124e-02f, -8.09215978e-02f, 1.66982897e-02f,
  -2.67788582e-02f, -6.60078228e-02f, 8.93422738e-02f, -8.49810522e-03f, -4.36760820e-02f, -5.68785258e-02f, -3.99205498e-02f, 2.97393035e-02f, 4.65558469e-02f, -6.04579076e-02f,
  7.66142979e-02f, 2.61085797e-02f, -2.17514355e-02f, 5.35904057e-03f, -3.07302326e-02f, 9.41388234e-02f, -5.42460307e-02f, 3.55468802e-02f, 3.09845842e-02f, 6.62380308e-02f,
  3.43908928e-02f, 1.26154348e-02f, 1.05116092e-01f, 2.83707660e-02f, -6.66688681e-02f, 1.08080143e-02f, -8.64866190e-03f, 1.58070549e-02f, -3.40001546e-02f, -5.66642657e-02f,
  -3.28115327e-03f, -3.41561809e-02f, -7.72407204e-02f, -1.36578670e-02f, -3.71941477e-02f, -1.90758910e-02f, 1.40510276e-02f, 2.36127507e-02f, -4.53846790e-02f, 3.41152847e-02f,
  8.61008316e-02f, 2.25037150e-02f, -2.65635606e-02f, 2.69718170e-02f, -2.29718816e-03f, 8.42198543e-03f, -5.19984518e-04f, 2.18544435e-02f, 6.82932213e-02f, -1.03174960e-02f,
  -8.64441842e-02f, -1.60504594e-01f, 2.32361164e-02f, -8.01307708e-02f, 7.02720508e-02f, 4.48484682e-02f, 5.45573197e-02f, -4.31077145e-02f, 7.27758044e-03f, -5.99970296e-02f,
  4.84477682e-03f, -4.08714376e-02f, 2.30572280e-02f, -1.38313882e-02f, -2.19419785e-02f, 1.15981020e-01f, 7.50574768e-02f, 2.01672241e-02f, 5.45205548e-03f, -1.84131693e-02f,
  7.26247802e-02f, -2.47281473e-02f, -4.94682938e-02f, -4.71814200e-02f, -1.48105882e-02f, -1.23312781e-02f, -6.83507770e-02f, 4.74176602e-03f, -1.85899418e-02f, 2.32443735e-02f,
  -1.03674196e-01f, 3.83818857e-02f, -8.48916098e-02f, 1.62365198e-01f, 1.55808657e-01f, 2.16773763e-01f, 4.80776839e-02f, 1.38353705e-01f, 2.80648619e-01f, -1.14772946e-01f,
  -3.53814028e-02f, 1.54659078e-02f, -5.38124666e-02f, 1.17778905e-01f, -3.05235684e-02f, 1.67161718e-01f, 1.30151019e-01f, 7.70941228e-02f, 1.83959842e-01f, 4.06771787e-02f,
  9.96522680e-02f, 6.25678524e-02f, -1.74083695e-01f, -1.66258782e-01f, -9.67720002e-02f, -4.40652631e-02f, -1.69054449e-01f, -2.75536533e-02f, -1.76781699e-01f, -8.20798725e-02f,
  -1.10152252e-01f, 5.04635368e-03f, -6.16129227e-02f, 8.32377095e-03f, -4.25837189e-02f, -2.31431834e-02f, 5.19145571e-04f, -9.11268666e-02f, 3.83706316e-02f, -5.22247404e-02f,
  -7.76532143e-02f, -7.35234246e-02f, -2.08633058e-02f, -3.13306525e-02f, 4.10542339e-02f, -1.00112759e-01f, -1.56275555e-02f, 4.79742549e-02f, -3.60429101e-02f, 5.14738336e-02f,
  4.52767499e-02f, -6.41766712e-02f, -1.80954244e-02f, -4.07020710e-02f, 5.19179925e-02f, 1.37990201e-02f, 1.12026799e-02f, -8.99252072e-02f, -7.11724535e-02f, 1.27313346e-01f,
  6.98076338e-02f, 7.09720999e-02f, -4.67239954e-02f, 5.25787659e-02f, -8.74497294e-02f, -4.46045734e-02f, -4.65967767e-02f, 1.59286242e-02f, -1.27836538e-03f, 5.24121784e-02f,
  -4.56099324e-02f, 2.22849939e-02f, -1.22806840e-02f, -7.41008818e-02f, -8.06479529e-02f, -6.89257402e-04f, 3.60668637e-02f, -8.51043910e-02f, 1.24499816e-02f, -5.14282733e-02f,
  5.28302193e-02f, -3.83483171e-02f, -6.78322613e-02f, -1.95547678e-02f, -6.14852086e-02f, 3.42545882e-02f, -2.97318082e-02f, 4.31032628e-02f, -7.59339938e-03f, -1.36809321e-02f,
  1.01205871e-01f, -2.07441822e-02f, -3.10140196e-03f, 3.34273539e-02f, -5.57490475e-02f, 1.32710282e-02f, -1.06972642e-02f, -8.05076137e-02f, 2.58189756e-02f, 3.72151025e-02f,
  1.77767985e-02f, 6.89788535e-02f, -1.10831466e-02f, 2.01966651e-02f, 1.13133557e-01f, -2.91695464e-02f, -1.34093175e-02f, 6.95811287e-02f, 5.98801970e-02f, 2.96197552e-02f,
  -6.52276799e-02f, -8.23316053e-02f, 5.49074784e-02f, -2.45443415e-02f, -2.92582845e-04f, -9.82570648e-02f, 4.97702025e-02f, -9.61004794e-02f, 3.62144224e-02f, 8.38229582e-02f,
  -9.53889713e-02f, -8.28708038e-02f, -1.70153320e-01f, -2.48680227e-02f, -1.20872512e-01f, -3.10872018e-01f, -1.70359761e-01f, -3.31516042e-02f, 5.33590354e-02f, 3.84599604e-02f,
  -7.55589679e-02f, 1.39125079e-01f, -2.87615955e-02f, 6.47491068e-02f, -6.16593212e-02f, 1.28151119e-01f, -8.79537016e-02f, -3.86834107e-02f, -2.01930460e-02f, -1.43409818e-01f,
  -4.69166040e-02f, -1.19535476e-01f, 3.38686146e-02f, -1.19351067e-01f, -1.16405755e-01f, 1.22862654e-02f, 4.19299044e-02f, -9.21391249e-02f, -5.79832233e-02f, 1.29809584e-02f,
  -7.68231675e-02f, 2.42106482e-01f, -1.58443078e-02f, 5.89127801e-02f, -7.64543787e-02f, -3.99442166e-02f, -5.90718240e-02f, -1.09923616e-01f, 4.28236537e-02f, 4.18174043e-02f,
  5.01143336e-02f, -1.98799651e-03f, -3.32372859e-02f, 5.25495633e-02f, 4.99854609e-02f, -4.70316857e-02f, 3.83390598e-02f, -2.33245473e-02f, -9.71860811e-02f, -6.38535097e-02f,
  -1.12716407e-01f, 8.38169456e-02f, -8.77635032e-02f, 1.15583435e-01f, -3.18490639e-02f, -5.61017953e-02f, -1.03498437e-02f, -6.57739565e-02f, -3.88628207e-02f, -2.64450237e-02f,
  -4.51469459e-02f, -2.93939356e-02f, -8.75184461e-02f, 9.42803174e-03f, -3.34505141e-02f, -1.68365184e-02f, 7.74609819e-02f, 4.80789617e-02f, 2.38547362e-02f, 1.90223604e-02f,
  -3.63011807e-02f, -2.19679978e-02f, -3.92168313e-02f, -2.48371996e-02f, 3.13862115e-02f, 3.51258852e-02f, -6.64089322e-02f, 5.70099540e-02f, -3.70668364e-04f, 4.69119176e-02f,
  3.93557847e-02f, -2.78268531e-02f, 6.33768446e-04f, -1.06674209e-02f, 2.07450502e-02f, -3.57068591e-02f, 3.41079123e-02f, 8.26776959e-03f, -8.58197175e-03f, -8.69919360e-02f,
  -2.75649782e-02f, 1.16038751e-02f, -6.21194057e-02f, 5.23046553e-02f, 3.45645063e-02f, -5.90812527e-02f, -9.21542943e-02f, -2.07926240e-02f, -5.07327765e-02f, -6.69698641e-02f,
  -1.02706119e-01f, 6.43671080e-02f, -3.30621414e-02f, 4.53416370e-02f, -5.64913172e-03f, 4.90549877e-02f, 2.35527325e-02f, 1.96061078e-02f, -1.02763966e-01f, 6.30414067e-03f,
  3.94274779e-02f, -2.65943315e-02f, 5.15336432e-02f, 5.30190915e-02f, -4.84109260e-02f, 5.98239377e-02f, 2.31744498e-02f, -3.19881700e-02f, 9.83018354e-02f, 7.24866986e-02f,
  2.67562240e-01f, -2.79448539e-01f, 2.10785180e-01f, 2.05308676e-01f, 2.31602505e-01f, -1.07442001e-02f, 2.31283441e-01f, -1.17676221e-01f, 1.58033758e-01f, -3.08986485e-01f,
  -6.93949983e-02f, -3.49100791e-02f, -1.51931345e-01f, 1.69922449e-02f, 1.32790163e-01f, -1.14019841e-01f, -4.66953181e-02f, -4.64204326e-02f, -6.07410306e-03f, 1.23638082e-02f,
  1.56212926e-01f, 7.66810253e-02f, -6.56700088e-03f, -2.22219691e-01f, 4.51841652e-02f, 2.32059024e-02f, 6.86937869e-02f, 6.37771413e-02f, -4.04422916e-02f, -1.18097812e-02f,
  -4.59729508e-03f, 4.11180258e-02f, 1.78363230e-02f, -6.14926815e-02f, -2.74063088e-02f, -3.87979448e-02f, 2.75524077e-03f, 4.09506308e-03f, 6.55299658e-03f, -4.72529195e-02f,
  -6.66433647e-02f, -6.90682754e-02f, 8.63387212e-02f, 2.87440829e-02f, 6.17228560e-02f, -1.20786317e-02f, -1.00896377e-02f, 6.63016085e-03f, -5.59782460e-02f, 5.85949644e-02f,
  -4.01586890e-02f, -9.23362821e-02f, 1.54886311e-02f, -1.03954233e-01f, 6.70319870e-02f, 1.76685639e-02f, 5.03640203e-03f, -8.68407115e-02f, -3.69527526e-02f, -3.36295329e-02f,
  -5.47325015e-02f, 9.20190066e-02f, 3.02126911e-02f, 4.68859598e-02f, -4.17307131e-02f, 9.32704434e-02f, 3.75160985e-02f, 1.00913644e-02f, 3.30039151e-02f, 1.00362888e-02f,
  -4.44182642e-02f, 8.97976533e-02f, -6.00569695e-02f, -8.42577964e-02f, -1.09005924e-02f, 1.42681435e-01f, -7.32085854e-02f, -1.03829309e-01f, 2.27690078e-02f, 7.02635795e-02f,
  -5.32293357e-02f, 8.56705289e-03f, -7.37922937e-02f, 1.43587384e-02f, 2.14450695e-02f, 4.79473434e-02f, -6.40370476e-04f, -6.74734116e-02f, 1.96973775e-02f, -1.77178383e-02f,
  -1.32120997e-01f, -8.01465958e-02f, 1.36518590e-02f, -1.05233334e-01f, -5.19491397e-02f, -4.58996231e-03f, -5.06410711e-02f, -8.09464753e-02f, 2.28474718e-02f, -8.00614730e-02f,
  -5.44070117e-02f, -1.21245766e-03f, -2.30718218e-02f, -3.75158787e-02f, -7.44170249e-02f, -3.42174061e-02f, -8.46773479e-03f, -5.48345149e-02f, 8.03710520e-03f, -1.79538596e-02f,
  -5.39509840e-02f, -8.42170864e-02f, 1.62409209e-02f, 1.45455252e-03f, -4.77726795e-02f, 8.07282105e-02f, 4.14967239e-02f, -3.71900536e-02f, -1.37964472e-01f, -1.93630811e-02f,
  -2.20032811e-01f, -1.84726655e-01f, -5.92263564e-02f, -3.21291268e-01f, -1.71355411e-01f, -3.25593501e-01f, -2.74716288e-01f, -2.02046707e-01f, -6.24121986e-02f, -1.57373384e-01f,
  -1.88524798e-01f, 1.39007241e-01f, 2.82685757e-01f, -1.77459925e-01f, 1.38317108e-01f, 2.86793977e-01f, -2.61150718e-01f, -1.60001785e-01f, 1.66745394e-01f, -1.30078077e-01f,
  -7.62145668e-02f, -2.29787350e-01f, 1.25903010e-01f, -8.91050696e-02f, -2.11667046e-01f, -1.11640044e-01f, 6.54319376e-02f, -5.25060333e-02f, -1.67228833e-01f, -4.09874618e-02f,
  -1.09393187e-01f, -6.69164434e-02f, -1.36046400e-02f, 1.09345159e-02f, -9.99698266e-02f, -2.35585272e-02f, 5.22595504e-03f, 8.32308307e-02f, -3.97440221e-04f, -6.46500513e-02f,
  2.03385949e-02f, -3.99725623e-02f, -9.40839127e-02f, 3.84642072e-02f, 8.99153668e-03f, -6.89478070e-02f, 3.05495616e-02f, 3.47222574e-02f, 1.27989035e-02f, 1.49116829e-01f,
  3.05594318e-02f, -8.99913907e-02f, -6.76694363e-02f, 2.78801192e-02f, 1.58695150e-02f, -1.50381133e-01f, 5.77916577e-02f, 1.21919520e-01f, -1.41024992e-01f, -8.06775019e-02f,
  -4.17928733e-02f, 4.33634780e-02f, -3.59939411e-02f, -5.49262986e-02f, -1.13853347e-02f, -4.30218130e-02f, -8.11498165e-02f, 3.11696436e-02f, 6.50851354e-02f, -2.12921072e-02f,
  -2.01178659e-02f, -2.75057983e-02f, 6.09251820e-02f, -8.98247119e-03f, -6.98608980e-02f, -1.08447084e-02f, 5.60502969e-02f, -7.84221739e-02f, -2.63880640e-02f, -6.95456341e-02f,
  1.32466601e-02f, -1.56723568e-03f, -2.40575057e-02f, 6.41338378e-02f, -4.11862284e-02f, 1.64027318e-01f, 3.27472463e-02f, -3.39816399e-02f, -2.88782194e-02f, 6.05125502e-02f,
  -1.95403039e-01f, -2.91157782e-01f, 3.08674034e-02f, -4.41451706e-02f, 3.10377069e-02f, -8.65709782e-03f, 4.80389446e-02f, -4.40549143e-02f, -9.46043581e-02f, -2.65304781e-02f,
  -3.85189615e-02f, 4.35341522e-02f, -5.30740172e-02f, -5.78948706e-02f, 6.22429065e-02f, -4.58272286e-02f, -8.50989297e-03f, 1.10279191e-02f, -5.97204976e-02f, -9.60085168e-02f,
  -2.39378661e-02f, 4.87020649e-02f, 1.16644509e-01f, -1.10858586e-02f, 3.23794819e-02f, -1.83441751e-02f, -1.01342704e-02f, -4.65043001e-02f, 2.62291748e-02f, -1.94459334e-02f,
  2.61415422e-01f, 4.30690870e-02f, -2.62047797e-02f, -1.52626485e-01f, 3.33419949e-01f, 1.74199060e-01f, 1.04489729e-01f, 7.66990930e-02f, 2.47195717e-02f, 2.42596436e-02f,
  2.56939176e-02f, -4.60900702e-02f, -1.35976315e-01f, -7.95658678e-02f, 1.10415675e-01f, -9.65613872e-02f, 7.02933297e-02f, 4.85018194e-02f, -9.14248228e-02f, -4.46351841e-02f,
  -3.96972597e-02f, 2.63135117e-02f, -1.49989709e-01f, -1.20979147e-02f, 1.10670194e-01f, -9.29326490e-02f, 5.70367984e-02f, -7.88101926e-02f, -1.59333628e-02f, 6.93137757e-04f,
  1.64991945e-01f, -9.82427318e-03f, -2.85313185e-02f, 9.86864511e-03f, 9.67290327e-02f, 4.52864589e-03f, -2.27509774e-02f, 9.88523290e-02f, -6.61122128e-02f, 2.39343774e-02f,
  6.24651611e-02f, -1.59175061e-02f, 2.42907610e-02f, 3.44138108e-02f, -2.92753037e-02f, 1.96069777e-02f, -4.24100133e-03f, 3.44238840e-02f, -4.49482091e-02f, -6.74140602e-02f,
  -5.18305451e-02f, 1.10153779e-01f, -1.58919173e-03f, 1.92498025e-02f, -3.16292257e-03f, -1.05191814e-02f, 6.08250732e-03f, -8.37101229e-03f, -1.56060075e-02f, -6.70098290e-02f,
  -7.06187412e-02f, 6.87338114e-02f, 5.10612084e-03f, 2.04129610e-03f, 3.73626477e-03f, 5.91824129e-02f, 3.05988863e-02f, 3.73028107e-02f, -2.52670585e-03f, -6.81218877e-03f,
  7.95905590e-02f, 1.14444839e-02f, -2.67770849e-02f, 7.67392367e-02f, -1.29833240e-02f, 4.21984829e-02f, 8.73163436e-03f, 3.49131897e-02f, 5.36105819e-02f, 2.01016571e-02f,
  2.19026357e-02f, -5.71382493e-02f, 4.30736542e-02f, 2.62463205e-02f, -3.16517763e-02f, -3.38576958e-02f, -4.85771485e-02f, -4.21997793e-02f, 1.13696866e-02f, 1.07288085e-01f,
  2.03881860e-01f, -4.76079956e-02f, 2.81392294e-03f, 4.63612117e-02f, -2.46052258e-02f, 5.03268950e-02f, 6.26666890e-03f, 2.38007717e-02f, -1.08973719e-01f, -4.17748392e-02f,
  7.72325769e-02f, 9.09394305e-03f, 6.39933944e-02f, -2.25631390e-02f, 6.63956180e-02f, 2.04258021e-02f, -5.06307138e-03f, 1.10113230e-02f, 6.60222431e-05f, -3.90973315e-02f,
  -4.58834646e-03f, 5.81901111e-02f, 4.04625386e-02f, 8.96450207e-02f, -9.70132053e-02f, -1.39601137e-02f, -1.74014289e-02f, 4.34622690e-02f, 7.59253725e-02f, 2.07211403e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  -2.92380918e-02f, 8.37603658e-02f, -1.09933494e-02f, -2.47656271e-01f, 2.05990508e-01f, 1.63810760e-01f, 1.12134792e-01f, 2.27398664e-01f, 2.74425521e-02f, 5.78209721e-02f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.58972014e-02f, -3.80975127e-01f, 9.10013840e-02f, 1.60276741e-01f, -5.57969689e-01f, 6.01591349e-01f, -9.91001651e-02f, 1.46531671e-01f, -4.56928939e-01f, -2.25037992e-01f,
  1.89148471e-01f, 5.33931628e-02f, 1.37042090e-01f, -2.54099280e-01f, 4.45053354e-02f, -2.47953519e-01f, -2.05870166e-01f, 2.03849494e-01f, 9.78377908e-02f, -5.97650111e-01f,
  5.14441907e-01f, 3.52977365e-01f, -2.80939694e-02f, 8.18475038e-02f, -1.19935408e-01f, 7.03584075e-01f, 9.01903510e-02f, 3.08610886e-01f, -2.57919729e-01f, -4.39047873e-01f,
  -8.05647001e-02f, 2.97273546e-01f, 3.18260700e-01f, -1.97569251e-01f, 2.82500446e-01f, 4.54658628e-01f, -4.67833757e-01f, 3.12979400e-01f, 3.34511161e-01f, 7.04741850e-02f,
  -3.96482646e-01f, -2.03990802e-01f, -7.86505044e-02f, 1.74091101e-01f, -5.96426725e-02f, 1.19486257e-01f, -4.54925448e-01f, -2.21902370e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.27889106e-01f, 1.92762569e-01f, -6.39321506e-02f, 2.64576107e-01f, -1.59145087e-01f, 3.50584202e-02f, 3.08954399e-02f, 7.78248087e-02f, -1.84681982e-01f, -2.80189812e-02f,
  1.30193114e-01f, -1.23788938e-01f, -2.35000327e-01f, 1.77200437e-01f, 1.09735681e-02f, -2.25870237e-01f, 2.95628190e-01f, -3.46279219e-02f, -1.41220614e-01f, -1.09069690e-01f,
  1.13962471e-01f, 4.77922350e-01f, 1.74940169e-01f, 2.19223142e-01f, 2.66993165e-01f, 1.38848722e-01f, 3.18995953e-01f, 2.22971067e-01f, 4.85986263e-01f, 4.20523025e-02f,
  4.49085116e-01f, -1.55594647e-01f, 2.48052731e-01f, 5.14413118e-01f, 3.87516059e-02f, 1.67494863e-01f, 3.26668710e-01f, -6.51218653e-01f, -7.36705735e-02f, 2.88021863e-01f,
  -1.04116313e-01f, 3.57289463e-01f, -1.14074886e-01f, 4.05115068e-01f, -1.92973152e-01f, 2.72256792e-01f, -2.05276176e-01f, -1.33737206e-01f, 4.68463212e-01f, -1.85181741e-02f,
  1.18187152e-01f, 3.77859414e-01f, 1.53768957e-01f, 1.63302988e-01f, 5.63529253e-01f, -4.28945899e-01f, -3.51954728e-01f, 2.27330804e-01f, -3.75910878e-01f, 7.20888674e-02f,
  -1.38608426e-01f, 1.15474887e-01f, -4.86160159e-01f, 2.74036497e-01f, 3.54697630e-02f, 3.40171665e-01f, -4.43842672e-02f, 2.83953071e-01f, 3.27546149e-01f, 2.01842517e-01f,
  4.01238441e-01f, 5.80341816e-02f, -2.79296815e-01f, 3.15111935e-01f, -2.88034439e-01f, 2.23786980e-01f, 6.67249188e-02f, 3.40912730e-01f, -3.82149965e-01f, 6.21069111e-02f,
  -9.58093628e-02f, -2.99676638e-02f, -4.85574901e-02f, -1.56431735e-01f, -1.95254177e-01f, 1.80503607e-01f, -1.84872910e-01f, 3.73125970e-01f, -2.45083228e-01f, -2.00469181e-01f,
  6.09476924e-01f, -2.04021081e-01f, 1.52636543e-01f, -2.88283974e-01f, 5.64716816e-01f, -3.53047013e-01f, 2.12890461e-01f, 4.79785316e-02f, 1.56151369e-01f, 9.33609679e-02f,
  2.29725003e-01f, 2.65426844e-01f, 4.88270283e-01f, -2.81795830e-01f, 1.18929416e-01f, -5.59686944e-02f, -1.79270580e-01f, -2.24326849e-01f, -2.31300425e-02f, -4.90172021e-02f,
  -1.75246507e-01f, 4.07961570e-02f, -8.68915915e-02f, 2.60910898e-01f, 1.56389266e-01f, -4.43887860e-01f, 4.88491952e-01f, 1.77883714e-01f, 5.18301308e-01f, -3.24300021e-01f,
  -2.58449227e-01f, 6.01662219e-01f, 3.30614656e-01f, 1.36443555e-01f, 6.51672333e-02f, -1.95203766e-01f, -2.06932068e-01f, -1.89795122e-02f, -1.72500089e-01f, -2.48429403e-01f,
  -2.41548762e-01f, -3.38982679e-02f, -7.63705894e-02f, -1.62746236e-01f, -2.29341522e-01f, -1.83872634e-03f, 1.25943646e-01f, 5.07190749e-02f, -1.45422027e-01f, -1.35665119e-01f,
  -3.95292416e-02f, -2.28765652e-01f, -1.93071947e-01f, -1.12161659e-01f, 1.94068417e-01f, 2.46616732e-02f, 9.08707082e-02f, 3.80743183e-02f, -8.36297050e-02f, 1.67342991e-01f,
  2.29722187e-02f, -1.72129691e-01f, 1.81485549e-01f, -2.02893555e-01f, -1.37756705e-01f, -2.32926518e-01f, -1.01590246e-01f, 2.39725355e-02f, -2.64296591e-01f, 2.13968962e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  -1.59609184e-01f, 5.50554320e-02f, 6.26435220e-01f, 3.94051760e-01f, 5.07375538e-01f, 5.45788944e-01f, 1.22064814e-01f, 3.28557283e-01f, -2.19853938e-01f, -4.57291231e-02f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -6.99838251e-02f, -5.15593171e-01f, 1.17838737e-02f, -7.59515524e-01f, 3.56093377e-01f, -7.29554892e-01f, -1.42481968e-01f, -1.33003354e-01f, 4.16231453e-01f, -2.84920067e-01f,
  -1.13825202e-01f, 1.60738781e-01f, -2.38903657e-01f, 3.64525229e-01f, -2.57803053e-01f, 8.36556107e-02f, -2.35604212e-01f, 3.91643912e-01f, 1.92812070e-01f, 2.59798020e-01f,
  -3.41286421e-01f, -3.07799816e-01f, 1.83579251e-01f, 1.46689117e-01f, -6.63248152e-02f, -5.21306634e-01f, -2.27670878e-01f, 4.46525007e-01f, -2.85932571e-01f, -2.48915050e-02f,
  1.21726125e-01f, -1.05217718e-01f, 2.59374857e-01f, -2.30423495e-01f, -5.10148257e-02f, 1.14046529e-01f, 3.97116899e-01f, 2.69877881e-01f, -3.21545303e-01f, 2.69230872e-01f,
  -3.39474410e-01f, 2.80264825e-01f, 1.72568515e-01f, 1.34781793e-01f, 4.41571802e-01f, 4.89831448e-01f, -2.60804117e-01f, 2.88428873e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  8.97085741e-02f, 6.36879057e-02f, 3.48790020e-01f, -2.85054773e-01f, -5.56120388e-02f, -2.66857147e-01f, -7.86976144e-02f, -7.47105628e-02f, 1.18257925e-01f, -2.70034075e-01f,
  1.55425712e-01f, 1.15271568e-01f, -2.27989346e-01f, -2.12276131e-01f, -4.98085208e-02f, -3.05810004e-01f, 2.86459237e-01f, -1.04886547e-01f, -6.15872666e-02f, -2.58527577e-01f,
  1.43463463e-01f, 4.81559902e-01f, -1.04871377e-01f, -1.03920385e-01f, 9.19964015e-02f, 6.89003646e-01f, 5.32822073e-01f, -3.49841744e-01f, 3.63171965e-01f, 3.59948069e-01f,
  -2.24362597e-01f, 1.83086377e-02f, -2.07270995e-01f, 4.37611267e-02f, -1.07958261e-02f, 1.20329663e-01f, 1.31627053e-01f, 2.38555878e-01f, -2.20647275e-01f, 3.36845703e-02f,
  1.99757606e-01f, -2.06920162e-01f, -6.97808294e-03f, 2.67712846e-02f, 6.06347881e-02f, -1.59192964e-01f, 1.00933068e-01f, 1.68133676e-01f, 5.17811358e-01f, -2.29416817e-01f,
  2.33706012e-01f, -4.05629754e-01f, 7.20451772e-01f, -2.87290424e-01f, 6.29303381e-02f, 1.39210090e-01f, 4.34567004e-01f, 2.52147228e-01f, 4.20345724e-01f, 1.90420911e-01f,
  -4.63229306e-02f, 7.27986157e-01f, 1.01536609e-01f, -3.40033621e-01f, 8.43110457e-02f, -1.43345311e-01f, -8.49252492e-02f, -3.78998518e-02f, 9.42742452e-02f, 1.19708537e-03f,
  2.13524684e-01f, -5.02886400e-02f, -1.95479035e-01f, 2.19444977e-03f, -3.31200510e-02f, -8.55209157e-02f, -2.07223631e-02f, -6.88140541e-02f, 1.38852224e-01f, -1.27186719e-02f,
  -2.21434116e-01f, 2.89334892e-03f, 7.72629539e-03f, 6.04893029e-01f, -3.66209358e-01f, -1.61981225e-01f, -1.67616352e-01f, 6.87091112e-01f, -3.75369638e-01f, -5.62370420e-02f,
  7.49757141e-02f, 7.28373110e-01f, -2.51573086e-01f, -9.55649391e-02f, -5.31903133e-02f, 6.25877827e-02f, 5.47260225e-01f, 9.45028543e-01f, 3.94026339e-01f, 4.62564558e-01f,
  9.59381647e-03f, 7.75946677e-01f, 7.42474198e-02f, -3.71482313e-01f, 3.39506790e-02f, 4.00004685e-01f, 8.23231190e-02f, 5.42306667e-03f, -4.20894884e-02f, -2.17467606e-01f,
  -2.45361224e-01f, 1.22771293e-01f, 2.28211477e-01f, 5.52303866e-02f, -2.10071281e-01f, 7.65750781e-02f, -1.63143083e-01f, 1.87323675e-01f, 2.59039588e-02f, 7.46142343e-02f,
  1.38979927e-01f, 1.55351013e-01f, -1.25934090e-03f, 2.28812739e-01f, -1.95609941e-03f, -1.66067347e-01f, -1.22349858e-01f, 1.11090079e-01f, 1.49701208e-01f, 8.58873606e-01f,
  5.68968117e-01f, -5.40883064e-01f, -4.04318511e-01f, 3.22388738e-01f, 2.06604391e-01f, 1.52409807e-01f, 8.62980187e-01f, 3.16386104e-01f, 4.72095102e-01f, -3.10762882e-01f,
  4.79957229e-03f, -1.66598961e-01f, -3.63145620e-01f, 1.62771329e-01f, 3.99203837e-01f, 6.19505405e-01f, 4.24692750e-01f, 7.35722601e-01f, -1.84537843e-01f, 5.68900526e-01f,
  1.66164860e-01f, 2.97767401e-01f, 1.76704936e-02f, -1.10159189e-01f, 9.55480337e-02f, 4.32055861e-01f, -2.56398857e-01f, -2.28872061e-01f, -5.99768385e-02f, 1.51125178e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  3.82584929e-01f, -4.30869572e-02f, -2.67711252e-01f, 5.98825574e-01f, 1.83034256e-01f, 3.20461243e-01f, 4.48809505e-01f, -2.00668141e-01f, 3.56389642e-01f, 5.03098667e-01f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -5.33877432e-01f, 3.75741154e-01f, 3.90523791e-01f, -3.30759674e-01f, 6.09945297e-01f, -6.38589978e-01f, 1.12178609e-01f, -4.02775615e-01f, 2.57102370e-01f, -3.22305202e-01f,
  -1.93553895e-01f, 1.68229118e-01f, 7.96742737e-02f, 2.06597283e-01f, 2.97471642e-01f, 3.86879772e-01f, -2.57706493e-01f, 1.04437701e-01f, 5.78832567e-01f, -6.52834117e-01f,
  1.24632426e-01f, -1.74425974e-01f, 1.65168002e-01f, -3.87913315e-03f, 2.89419115e-01f, -5.11312902e-01f, 2.32524589e-01f, 1.17695205e-01f, 5.34272850e-01f, -2.04428658e-01f,
  1.96339503e-01f, 1.30947024e-01f, -1.44167766e-02f, -3.05012137e-01f, -2.65506148e-01f, 8.72526050e-01f, -6.40565217e-01f, -1.67975295e-02f, 9.81205702e-02f, 2.54036635e-01f,
  5.89967743e-02f, 1.44181743e-01f, -5.90679497e-02f, 1.66473240e-02f, -5.04887938e-01f, -3.19498003e-01f, 1.22520469e-01f, -4.85898972e-01f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  2.72848845e-01f, -3.57514530e-01f, -2.66291499e-01f, -2.94225931e-01f, -4.58877057e-01f, 2.01634437e-01f, -9.63784531e-02f, 5.74017346e-01f, -3.87726799e-02f, 8.21912885e-02f,
  -1.42794728e-01f, -3.92790347e-01f, 2.69345909e-01f, 1.04084089e-01f, 5.79345107e-01f, 2.41590843e-01f, 8.15854490e-01f, 7.15101123e-01f, 8.97750080e-01f, 5.59487224e-01f,
  5.50349832e-01f, -8.74779105e-01f, 5.33064663e-01f, -5.43724716e-01f, 4.74838214e-03f, 1.64651573e-01f, -9.92556140e-02f, -3.30130845e-01f, 2.18457371e-01f, 3.78095694e-02f,
  7.81918287e-01f, 2.60035157e-01f, 2.59144098e-01f, 2.23236740e-01f, 2.07139365e-02f, 2.11652413e-01f, 6.27460122e-01f, 5.25038183e-01f, 2.84462035e-01f, -3.37700278e-01f,
  -7.26712942e-02f, 7.46339619e-01f, 8.28195587e-02f, 5.14029324e-01f, 1.19704850e-01f, -1.58720285e-01f, -3.29229623e-01f, 6.58326805e-01f, 4.04143959e-01f, -1.73385188e-01f,
  -5.64340241e-02f, 2.50574827e-01f, -1.45333149e-02f, -1.26047850e-01f, 2.57062823e-01f, 5.84647804e-02f, -2.20374152e-01f, -2.04258904e-01f, -5.03742173e-02f, 3.09079736e-01f,
  -2.35650003e-01f, -9.73673165e-02f, 1.59911543e-01f, 7.50348344e-02f, -1.72512800e-01f, -2.98269689e-01f, -1.73562869e-01f, 6.01894140e-01f, -9.04923022e-01f, 2.49569684e-01f,
  -2.27704588e-02f, 5.19508660e-01f, -2.22496852e-01f, 9.87852097e-01f, -9.37241316e-02f, -5.25756836e-01f, -1.77357048e-01f, -3.31193656e-01f, 4.59282428e-01f, -4.41193521e-01f,
  -1.42486379e-01f, 5.66549420e-01f, 4.91135567e-01f, 8.58432055e-01f, -3.34323406e-01f, 4.16379780e-01f, 2.34557509e-01f, -1.99445114e-01f, 1.41928256e-01f, 5.51377594e-01f,
  5.06922789e-02f, -3.35296303e-01f, -3.20116580e-01f, -5.03606768e-03f, -1.97440386e-01f, -4.87111688e-01f, 8.48123953e-02f, -3.16200376e-01f, 1.23053126e-01f, -7.34204575e-02f,
  1.67050868e-01f, -1.75786793e-01f, -4.04685773e-02f, 2.41363272e-01f, 8.95444900e-02f, 2.05422163e-01f, -1.70172393e-01f, 2.69914269e-01f, -1.83546543e-01f, 8.58407244e-02f,
  -1.29145578e-01f, -1.15439221e-01f, 4.22116607e-01f, -1.79440692e-01f, 8.25608671e-02f, -1.96957201e-01f, 6.24644518e-01f, 2.17358366e-01f, -7.41473362e-02f, -3.31866115e-01f,
  -1.76257923e-01f, -3.97140868e-02f, 2.26441566e-02f, 7.69385338e-01f, -2.80212492e-01f, 5.06713018e-02f, -1.73001543e-01f, 3.36613774e-01f, 2.66946822e-01f, 4.49060202e-01f,
  4.92659723e-03f, -1.04346526e+00f, -6.73297107e-01f, 3.97989452e-01f, -2.81300724e-01f, 2.50802785e-01f, -1.64265245e-01f, -1.45565629e-01f, 1.09129930e-02f, -3.79479229e-01f,
  1.14295590e+00f, 2.36384243e-01f, 7.47955799e-01f, 6.46897674e-01f, 7.49216080e-01f, 3.93713325e-01f, 3.67025852e-01f, 7.40658998e-01f, 3.40347886e-01f, -5.74882805e-01f,
  1.34334594e-01f, -1.96627960e-01f, -1.02904275e-01f, -2.04798982e-01f, -1.82176054e-01f, -2.13174954e-01f, -3.74757588e-01f, -2.04962473e-02f, 7.70773172e-01f, -2.63170183e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  6.54177144e-02f, 4.71347481e-01f, 5.64276636e-01f, 2.41569206e-01f, 2.37624153e-01f, 4.83848006e-01f, -3.07791345e-02f, 6.16065323e-01f, 2.90526062e-01f, 4.59931999e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  4.52798575e-01f, -7.04325065e-02f, 9.21295226e-01f, -1.07919526e+00f, -7.05243468e-01f, 3.35090369e-01f, -2.61768103e-01f, -2.63900936e-01f, 8.86202395e-01f, -2.83655990e-02f,
  -2.07319409e-01f, 2.41633311e-01f, -1.87664386e-02f, 4.12283242e-01f, -6.38047636e-01f, 1.40361875e-01f, -5.64316690e-01f, -2.27427348e-01f, -2.65773416e-01f, -1.31622374e+00f,
  -2.54367888e-01f, 1.19792235e+00f, -2.71119118e-01f, -6.46395445e-01f, 1.73871621e-01f, 1.76548511e-01f, 7.50850618e-01f, 1.03868926e+00f, -1.53354615e-01f, 2.86402646e-04f,
  -5.82197547e-01f, -1.48090899e-01f, 1.31843555e+00f, -2.80337453e-01f, 6.86237141e-02f, 3.03841382e-01f, 3.07451010e-01f, -9.97219741e-01f, 6.06743693e-01f, -1.82402253e-01f,
  -2.34759614e-01f, -2.82957286e-01f, -2.09761187e-01f, -1.91200271e-01f, 1.28402337e-01f, -3.32024723e-01f, 8.42792094e-01f, -4.16634291e-01f, -1.17900229e+00f, -8.41333210e-01f,
  -7.84076810e-01f, 1.72655687e-01f, 3.72441173e-01f, 1.60635144e-01f, -1.04505956e-01f, -4.53264937e-02f, 5.64845085e-01f, -1.90843180e-01f, -2.23303959e-01f, -4.04173285e-01f,
  3.47521827e-02f, 6.09134674e-01f, 1.58359066e-01f, -5.69993734e-01f, -9.78863388e-02f, 1.71919409e-02f, -1.04945466e-01f, 7.47792244e-01f, 3.01766664e-01f, -1.07983577e+00f,
  7.03179538e-02f, 1.06937528e+00f, 4.02467012e-01f, 1.55018732e-01f, -7.99148321e-01f, -3.21263194e-01f, -1.45785630e-01f, -9.00678709e-02f, -1.23103812e-01f, 2.21138343e-01f,
  7.94315457e-01f, 4.84610766e-01f, 6.03317738e-01f, -3.44431341e-01f, -5.11655569e-01f, 6.22730196e-01f, -2.04711735e-01f, 4.44628388e-01f, 7.87463039e-02f, -4.40897495e-02f,
  5.59979498e-01f, 7.00192571e-01f, -5.20178536e-03f, -4.76597935e-01f, -4.35543537e-01f, 1.63906142e-01f, 7.19259560e-01f, 2.31552925e-02f, 6.20910645e-01f, 1.59750674e-02f,
  3.58632118e-01f, 1.10773973e-01f, 1.61003351e-01f, 4.62994486e-01f, -6.61151052e-01f, 1.83805510e-01f, 2.76576638e-01f, -2.63830543e-01f, 7.08814859e-02f, -1.54675514e-01f,
  2.08009109e-01f, 4.62531596e-01f, -4.88450974e-01f, 4.58402246e-01f, -5.17862618e-01f, 7.80663610e-01f, 1.66280657e-01f, -7.79483616e-01f, -2.46238455e-01f, -3.23033690e-01f,
  4.11311269e-01f, 4.28662032e-01f, -2.80538768e-01f, -4.39638078e-01f, 3.63068908e-01f, 8.74394953e-01f, -7.18406439e-01f, -1.60549000e-01f, -7.73504376e-01f, -4.98588830e-01f,
  -6.81410015e-01f, -3.31845254e-01f, -1.56111315e-01f, -6.95619732e-03f, 4.16115731e-01f, -6.41158342e-01f, -1.17680199e-01f, -2.87079792e-02f, 9.00205195e-01f, -2.11930171e-01f,
  2.78160602e-01f, -3.25236797e-01f, -4.12876099e-01f, -1.99206859e-01f, 3.71539623e-01f, 2.74341315e-01f, 6.94040418e-01f, 1.02987087e+00f, -1.60186335e-01f, 5.30947745e-01f,
  -4.09473419e-01f, 8.33793938e-01f, -4.79842395e-01f, 2.59638846e-01f, -4.50758904e-01f, 1.33550420e-01f, 1.68063298e-01f, 1.64745137e-01f, -6.76653147e-01f, 1.27740169e+00f,
  -5.48147142e-01f, -6.36762500e-01f, -9.27399457e-01f, 1.13092911e+00f, 1.73430800e-01f, -2.26783842e-01f, 4.25267443e-02f, -3.49179059e-01f, -1.15226842e-01f, -2.63693839e-01f,
  -6.63448274e-01f, -5.28975368e-01f, -5.87410433e-03f, -3.75806928e-01f, 1.10116124e+00f, -4.85487491e-01f, 7.94659927e-02f, 2.87693948e-01f, 6.28523827e-01f, -8.94130051e-01f,
  -4.87686731e-02f, -2.28750914e-01f, 7.35668182e-01f, -1.02464914e+00f, -4.71887648e-01f, 1.62484467e-01f, 3.23656619e-01f, -2.31831089e-01f, -5.91050982e-02f, 1.58703342e-01f,
  5.75331032e-01f, -2.38977253e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.76508963e-01f, -1.02273554e-01f, -1.42187104e-01f, 2.38761768e-01f, 8.15478265e-02f, -9.37693045e-02f, -3.44053060e-01f, 3.44182462e-01f, -1.65512368e-01f, -4.03930880e-02f,
  1.99874580e-01f, -1.82212368e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    