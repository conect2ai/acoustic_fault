/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.96348572e-01f, -2.62675375e-01f, 3.89399320e-01f, -2.48300537e-01f, 1.53242722e-01f, -6.71556517e-02f, -5.32779694e-02f, -4.03472818e-02f, 2.08559092e-02f, -3.81989837e-01f,
  -1.76329285e-01f, 1.61431864e-01f, -1.11270510e-01f, -1.66859806e-01f, 4.39422846e-01f, -1.19557098e-01f, -3.65298688e-02f, -1.42427325e-01f, 7.11631700e-02f, -4.54052500e-02f,
  3.24059688e-02f, -2.51571685e-01f, -8.20573606e-03f, -1.17541894e-01f, 6.04175888e-02f, 1.67677999e-02f, 9.77607723e-03f, 9.93068442e-02f, -1.56813320e-02f, 8.84070843e-02f,
  6.62497208e-02f, -1.88903026e-02f, 8.38611573e-02f, 2.55750846e-02f, 2.83085089e-02f, -9.00104083e-03f, 5.71855977e-02f, 8.99484605e-02f, -5.28547447e-03f, -5.16526261e-03f,
  5.58306687e-02f, 8.37460533e-02f, 6.71061501e-03f, 3.14800963e-02f, 4.23382781e-02f, -1.84943003e-03f, 7.09324405e-02f, -1.14008240e-01f, 5.78483902e-02f, -5.47748292e-03f,
  7.54167372e-03f, 3.55806872e-02f, -1.22106858e-02f, 1.90578643e-02f, -3.09317540e-02f, -7.34513626e-02f, -3.39290053e-02f, 1.66765407e-01f, 1.50759341e-02f, -5.57795912e-02f,
  -8.66828021e-03f, -3.85413016e-03f, 7.25231657e-04f, 4.66628745e-02f, -5.94351999e-02f, -1.34432763e-01f, -9.07488987e-02f, 4.28236797e-02f, 2.31263172e-02f, -4.22051363e-03f,
  4.63033468e-02f, 3.32887680e-03f, -1.28319459e-02f, -4.29076292e-02f, -7.95761421e-02f, -1.12426765e-01f, -6.81998059e-02f, -3.78388865e-03f, -6.18878976e-02f, -1.00954302e-01f,
  -6.05578311e-02f, -5.05518019e-02f, -5.29917516e-03f, -4.37918492e-02f, -3.50921438e-03f, 5.02529554e-02f, -7.24506825e-02f, -1.33453459e-02f, -5.72774746e-02f, -7.68664060e-03f,
  -1.49886832e-01f, -1.45240903e-01f, -1.77130643e-02f, -9.55027789e-02f, 1.06726110e-01f, 7.32023418e-02f, 2.78085247e-02f, 3.28758396e-02f, -1.34200221e-02f, -4.04206216e-02f,
  -3.58834788e-02f, -1.07015640e-01f, -4.74153273e-02f, 1.31164435e-02f, -1.43776070e-02f, -3.49214822e-02f, -7.44715407e-02f, -1.46944390e-03f, -5.60470223e-02f, 2.53267605e-02f,
  -6.56111464e-02f, -5.08301295e-02f, -3.73026468e-02f, -1.34441942e-01f, -1.90098044e-02f, -6.39386196e-03f, 1.87710579e-02f, -2.06632391e-02f, -2.88075823e-02f, -7.48368949e-02f,
  4.56480011e-02f, 1.80193260e-01f, 2.47358382e-01f, 3.16265404e-01f, -2.59297073e-01f, -2.96719503e-02f, -1.11500975e-02f, -1.08973682e-01f, 4.80735302e-02f, -4.98898141e-02f,
  -1.34482950e-01f, 1.16862960e-01f, -1.15886822e-01f, 2.05682844e-01f, 3.41370881e-01f, 1.73509374e-01f, 2.02244580e-01f, -3.40704024e-02f, 3.51720341e-02f, -3.26322056e-02f,
  5.85654303e-02f, -2.00449288e-01f, 2.22131982e-01f, -3.05836707e-01f, -2.42650602e-02f, -8.79435241e-03f, -3.70797589e-02f, -3.05155367e-01f, 1.27350092e-01f, -1.08704783e-01f,
  4.96876650e-02f, 3.30826663e-03f, 1.29459605e-01f, -1.57635659e-02f, -5.30791432e-02f, -3.00244913e-02f, -5.48146814e-02f, -5.29062413e-02f, -8.71101394e-03f, 5.42271398e-02f,
  9.75127965e-02f, 1.00695498e-01f, -3.08993901e-03f, -9.00460109e-02f, 7.38960803e-02f, 1.18194744e-02f, 1.12523861e-01f, 9.69727933e-02f, -1.71760246e-02f, 1.26167145e-02f,
  1.12982653e-01f, 6.39670715e-02f, -6.87846616e-02f, -1.90058369e-02f, 2.55585015e-02f, -3.52896824e-02f, 1.52548132e-02f, 8.92551336e-03f, 2.17259489e-02f, 8.42280984e-02f,
  7.39125311e-02f, -4.30098735e-03f, 8.05136841e-03f, 1.46597832e-01f, -1.57107171e-02f, -1.64998081e-02f, 9.72551778e-02f, -9.63380337e-02f, -5.61274998e-02f, -3.41654494e-02f,
  -7.73451552e-02f, 8.12408980e-03f, 4.51324740e-03f, -5.36390161e-03f, 2.20496412e-02f, -1.03195496e-02f, -2.23458819e-02f, -1.00040115e-01f, 3.50597803e-03f, 2.06631385e-02f,
  5.00312671e-02f, 7.38747567e-02f, -6.38769940e-02f, 5.12027629e-02f, -4.26927507e-02f, -7.71856532e-02f, 1.23182781e-01f, 4.79759835e-02f, -4.59609814e-02f, -3.64372358e-02f,
  -9.01610404e-02f, -1.44852236e-01f, -1.54110685e-01f, -1.25677332e-01f, 4.57981974e-03f, 4.98097241e-02f, 7.73686841e-02f, -2.17962358e-02f, 9.05297138e-03f, -1.11857191e-01f,
  -3.55670862e-02f, -3.97487096e-02f, -8.66011232e-02f, -5.49621247e-02f, 2.38113366e-02f, -6.83876127e-02f, 8.95499834e-05f, -1.59432907e-02f, -1.88112110e-02f, 1.16384244e-02f,
  5.82931489e-02f, -3.71573977e-02f, 3.49353999e-02f, -8.95723477e-02f, -1.26790651e-03f, -2.20648050e-02f, -9.60845724e-02f, -3.03044282e-02f, 5.32470383e-02f, -3.88012821e-04f,
  1.90537974e-01f, 9.29056406e-02f, -2.94809863e-02f, 8.74236673e-02f, 3.57253887e-02f, -9.78581756e-02f, -1.74148798e-01f, 1.32171229e-01f, -3.10869534e-02f, 4.50924151e-02f,
  -1.56035554e-02f, 2.25384664e-02f, -2.03086033e-01f, -1.20720714e-01f, -2.87710458e-01f, -3.17589432e-01f, -1.86853290e-01f, -7.89353848e-02f, -3.91740240e-02f, 1.61705419e-01f,
  -3.68963405e-02f, 1.13066509e-02f, -5.44814579e-02f, 1.05166230e-02f, 1.35522380e-01f, 1.52847514e-01f, 1.62287846e-01f, 1.12937756e-01f, 9.47617665e-02f, -1.25930727e-01f,
  -1.43865362e-01f, -6.87323287e-02f, 2.59481687e-02f, -8.88542682e-02f, -5.77285944e-04f, 1.11108288e-01f, 7.83258453e-02f, -2.45393943e-02f, 3.89683172e-02f, 1.30996695e-02f,
  2.65806112e-02f, 4.92103361e-02f, -1.97310317e-02f, -1.01684034e-02f, 2.42522247e-02f, -2.00431384e-02f, -3.73523720e-02f, -8.82116333e-02f, -4.85402234e-02f, 2.78144963e-02f,
  -4.34521809e-02f, -4.73250775e-03f, 7.76097998e-02f, -7.75113702e-02f, 5.45468070e-02f, 4.31278571e-02f, -1.66730136e-02f, 5.91092855e-02f, 6.88344426e-03f, 3.31424959e-02f,
  4.99906950e-02f, 9.30909067e-02f, -4.68514115e-03f, -1.04663193e-01f, 2.27209786e-03f, -2.40469985e-02f, -1.97140612e-02f, -4.56467979e-02f, 1.48181068e-02f, -5.33596985e-02f,
  6.04634807e-02f, -1.14726378e-02f, 2.55650338e-02f, -2.63631586e-02f, -1.81590542e-02f, 9.90174264e-02f, -4.22091149e-02f, 4.42037778e-03f, 4.63247411e-02f, -1.05871055e-02f,
  -2.27396023e-02f, -5.72466217e-02f, 1.36481682e-02f, 6.51260987e-02f, -4.34884392e-02f, 9.70593467e-03f, 4.51254062e-02f, 8.74149874e-02f, -5.71036413e-02f, 1.84185468e-02f,
  6.20346982e-03f, 1.78808630e-01f, 7.28722960e-02f, 1.54636018e-02f, -5.06291687e-02f, -5.13441116e-02f, -2.40733139e-02f, 1.14003301e-01f, -8.06421191e-02f, -3.33261825e-02f,
  6.52905181e-02f, -3.67910303e-02f, 2.68053878e-02f, -5.03438301e-02f, -6.95714280e-02f, 2.66535375e-02f, 8.34895372e-02f, 8.09745491e-02f, 8.41260850e-02f, 3.35050486e-02f,
  9.16872248e-02f, 1.72387213e-02f, -3.44278291e-03f, -4.78193257e-03f, -8.20970908e-03f, 6.69981167e-02f, -1.97464856e-03f, 2.83080153e-02f, 8.76196995e-02f, -3.68992351e-02f,
  2.84634590e-01f, 3.87138650e-02f, -7.77947903e-02f, 1.01957053e-01f, 3.52983505e-01f, -7.91239087e-03f, -1.97624788e-01f, 3.30513149e-01f, 2.39500970e-01f, -1.24576529e-02f,
  1.19563967e-01f, -4.74812612e-02f, -2.51828164e-01f, -1.71541907e-02f, -2.17550829e-01f, -2.42916048e-01f, -1.08050972e-01f, -3.86555456e-02f, 7.78196827e-02f, 7.04734102e-02f,
  6.75835684e-02f, 2.75481604e-02f, -1.86751872e-01f, 1.72233537e-01f, 8.73307958e-02f, 1.92315891e-01f, -3.20859104e-02f, 2.34785397e-02f, 3.00597195e-02f, -8.88351798e-02f,
  8.51885974e-02f, 1.90660238e-01f, 2.73746438e-02f, 2.34563481e-02f, 8.04141455e-04f, -9.79964137e-02f, 1.19778411e-02f, -1.25950232e-01f, 2.91355681e-02f, -1.45568615e-02f,
  -9.49961040e-03f, 5.38066700e-02f, -2.82398872e-02f, -5.25218658e-02f, 4.99256551e-02f, 1.01855405e-01f, -9.26018693e-03f, 1.11896610e-02f, 1.98058523e-02f, -5.23067079e-02f,
  -2.80534588e-02f, -3.49782109e-02f, 2.77868789e-02f, -3.63428108e-02f, 3.74619514e-02f, 2.24740561e-02f, -3.24759968e-02f, -4.06047404e-02f, -1.48888202e-02f, 1.32763460e-01f,
  -9.12112463e-03f, -4.58241403e-02f, -5.55911511e-02f, -9.54916980e-03f, 2.20922362e-02f, 1.62336435e-02f, -5.92707545e-02f, -2.43615657e-02f, -3.57291847e-02f, 2.72594616e-02f,
  3.59745286e-02f, 2.51006987e-02f, 5.68898721e-03f, -1.06373154e-01f, -8.13331455e-03f, 1.42289009e-02f, -4.34136167e-02f, 4.96658683e-02f, 5.92594258e-02f, -1.74117438e-03f,
  -4.39556539e-02f, -3.77747566e-02f, -4.49528452e-03f, -3.88061702e-02f, -7.06290528e-02f, -5.50884046e-02f, 6.78720698e-03f, -3.71617675e-02f, 3.41487452e-02f, -7.16649443e-02f,
  1.45198420e-01f, 1.42941833e-01f, 9.80473608e-02f, 7.01201186e-02f, -2.25619804e-02f, 5.49821965e-02f, -3.53273451e-02f, -2.99431402e-02f, 4.48452756e-02f, 1.22447005e-02f,
  2.67012953e-03f, -4.08642460e-03f, 9.65014994e-02f, -1.89899169e-02f, -3.37389968e-02f, -3.01123094e-02f, -4.20142002e-02f, 2.63721067e-02f, 7.94930682e-02f, 9.09456983e-02f,
  1.24810291e-02f, 7.22792000e-02f, -3.43995355e-02f, 1.30959436e-01f, -1.84210651e-02f, -2.19476633e-02f, 1.13924488e-01f, 5.65574057e-02f, -8.85118544e-02f, -1.04219809e-01f,
  -5.70671380e-01f, -1.96868882e-01f, -1.40969843e-01f, 1.34563502e-02f, 4.47676294e-02f, 1.07831070e-02f, 1.94261566e-01f, -3.12855840e-02f, -1.40404910e-01f, 8.43109563e-02f,
  3.23169559e-01f, 1.25324437e-02f, 1.33923665e-01f, 1.89497709e-01f, -3.84524949e-02f, -1.95847582e-02f, -1.05208412e-01f, 4.63513434e-02f, -1.33054271e-01f, -1.37073949e-01f,
  -1.24654911e-01f, 8.17612782e-02f, 2.03289092e-01f, 7.54333884e-02f, 1.43792883e-01f, -4.60619852e-02f, 1.56400174e-01f, 1.17195778e-01f, 1.00716345e-01f, 1.31357357e-01f,
  -1.65477529e-01f, -1.01440541e-01f, 7.13183731e-02f, -6.84543923e-02f, -5.75109087e-02f, 9.55066606e-02f, 8.51052776e-02f, 4.80608940e-02f, 5.49500342e-03f, -1.78158898e-02f,
  7.30459094e-02f, -3.52190100e-02f, 1.45803695e-03f, 9.42768976e-02f, -3.50470766e-02f, -2.83062868e-02f, 1.60526708e-02f, 1.50840553e-02f, -1.31076686e-02f, -8.91714299e-04f,
  -8.05483665e-03f, 2.11675856e-02f, 3.38198692e-02f, -2.75699161e-02f, 2.73974519e-02f, 2.67223306e-02f, 3.46479379e-02f, 4.93615232e-02f, 4.85681817e-02f, -7.38992319e-02f,
  2.14983691e-02f, -6.19876906e-02f, 2.02974491e-02f, -5.88042997e-02f, -3.50130834e-02f, 1.74888559e-02f, -2.46282034e-02f, 1.10283867e-01f, -1.84683930e-02f, 1.01108626e-02f,
  -3.17574188e-04f, -7.85075221e-03f, 1.45578524e-02f, 1.07310922e-03f, -1.66330598e-02f, 3.17700356e-02f, -1.21490046e-01f, 1.60381943e-02f, -5.30021079e-02f, 3.61555442e-02f,
  3.32762934e-02f, -7.36031905e-02f, -2.22347658e-02f, 6.16255365e-02f, 7.29315728e-02f, 2.60941237e-02f, 2.53990516e-02f, -8.14171359e-02f, 4.52766344e-02f, 3.24534029e-02f,
  -1.52543694e-01f, -1.56223223e-01f, 3.59910056e-02f, 6.03721477e-02f, 6.71804845e-02f, -2.24303808e-02f, 1.64319691e-03f, -3.39010777e-03f, -9.09966230e-02f, -1.29868360e-02f,
  -5.62740751e-02f, 1.00508854e-02f, -2.18752623e-02f, 2.76707225e-02f, -4.80368622e-02f, -7.11549222e-02f, 1.60573106e-02f, -5.62423579e-02f, 9.53916758e-02f, 2.41712462e-02f,
  1.00903856e-02f, -8.85546301e-03f, -3.97308059e-02f, 3.37576605e-02f, 2.95814965e-03f, 3.19676176e-02f, -3.39223295e-02f, 3.88793554e-03f, 3.13545801e-02f, 4.37581958e-03f,
  -9.82351974e-02f, -1.08688250e-01f, -1.64634749e-01f, -1.36039659e-01f, 1.62315533e-01f, 4.31546360e-01f, 3.03968817e-01f, 2.72500217e-02f, 2.43229747e-01f, 1.20479174e-01f,
  -3.90924923e-02f, 1.55212814e-02f, -6.68028668e-02f, -5.45524955e-02f, 2.74253845e-01f, -4.47489461e-03f, 2.11229593e-01f, 3.80455516e-02f, -1.07293807e-01f, 3.81192230e-02f,
  5.46823069e-02f, 1.36351943e-01f, -7.78591707e-02f, -2.92853974e-02f, -1.10165216e-01f, -1.90678018e-03f, -1.99024957e-02f, -9.96980444e-02f, -7.79980496e-02f, 4.59018658e-04f,
  -3.95173728e-02f, -7.21310405e-03f, -9.01895240e-02f, -8.26099664e-02f, 1.13000415e-01f, 1.11832492e-01f, -6.84110308e-03f, 3.84360664e-02f, 4.98559885e-02f, 2.73661893e-02f,
  -8.47364888e-02f, 7.33215213e-02f, 1.49793094e-02f, 5.01527684e-03f, 2.02673604e-03f, -8.23957846e-02f, -7.42563382e-02f, -1.41522875e-02f, -8.98031667e-02f, -5.55977188e-02f,
  -7.55454367e-03f, -2.25304589e-02f, 7.81589895e-02f, -2.84304265e-02f, 1.48589052e-02f, -1.70092117e-02f, 3.30682471e-02f, 7.10617006e-02f, 1.31286114e-01f, 1.34227246e-01f,
  3.13528031e-02f, -1.04218544e-02f, -1.40828356e-01f, -1.16643555e-01f, -3.84722129e-02f, 7.26560038e-03f, -3.86084504e-02f, -9.33682173e-03f, 3.02423872e-02f, 3.31268646e-02f,
  -8.48573446e-03f, -4.34837900e-02f, 1.60465147e-02f, -5.12271598e-02f, -5.00867851e-02f, -5.35750277e-02f, 4.85369973e-02f, -6.45076707e-02f, 2.37411074e-02f, -1.11128939e-02f,
  -1.24959618e-01f, 4.22871951e-03f, -5.62219098e-02f, 3.94439101e-02f, 3.60154398e-02f, -7.23935142e-02f, -6.39484525e-02f, -5.76705001e-02f, 1.63140381e-03f, -1.46283442e-02f,
  2.02913940e-01f, 1.73140377e-01f, 1.33405373e-01f, -1.13881426e-02f, -4.63423952e-02f, -5.08247837e-02f, 2.64461245e-03f, 8.53467062e-02f, -3.35764177e-02f, 2.13959138e-03f,
  1.43285200e-01f, 7.15363026e-02f, 5.69670610e-02f, 4.71888529e-03f, 1.74359418e-02f, 5.83348423e-02f, -4.76866886e-02f, 5.45279235e-02f, 5.56240268e-02f, 2.79288311e-02f,
  -3.87691776e-03f, 1.55344844e-01f, 4.04729508e-02f, 4.27566469e-02f, 5.97505383e-02f, 1.01354234e-01f, 1.18341625e-01f, 4.54634689e-02f, -4.40093130e-02f, -1.42620718e-02f,
  3.46536525e-02f, -1.47095874e-01f, 2.30587944e-01f, -3.38052697e-02f, 2.19429895e-01f, 2.28184268e-01f, 2.60263622e-01f, 1.41910613e-01f, -3.06735206e-02f, -1.94895595e-01f,
  -3.10359690e-02f, -3.72562930e-02f, -2.14364707e-01f, 8.65949988e-02f, -1.59838110e-01f, -1.80196673e-01f, 3.67829725e-02f, -3.06427456e-03f, 2.22485717e-02f, 1.72185168e-01f,
  1.28064662e-01f, 1.61853567e-01f, -5.41520193e-02f, 5.05668931e-02f, 2.05667853e-01f, 2.88037937e-02f, -1.37103843e-02f, 2.96056449e-01f, 1.54201865e-01f, 8.75493586e-02f,
  -1.29934633e-02f, -1.03920393e-01f, -1.19938022e-02f, -1.95209961e-03f, -5.30557483e-02f, 9.63646919e-03f, 7.66777247e-02f, 8.20681900e-02f, 1.73738033e-01f, 6.04202487e-02f,
  1.30711067e-02f, 7.05737025e-02f, -2.46185213e-02f, 4.55408208e-02f, 1.29926190e-01f, 7.12522790e-02f, 3.23561169e-02f, -3.10640559e-02f, 1.23508200e-02f, 5.18826060e-02f,
  -1.00122392e-02f, -2.68472638e-02f, 2.56528277e-02f, -4.31719758e-02f, 5.38931526e-02f, -2.00703964e-02f, -3.41133401e-02f, -2.94808298e-02f, 1.52879432e-02f, 1.54963434e-01f,
  3.53411771e-03f, -4.88883741e-02f, 2.29097325e-02f, 4.30528745e-02f, -6.46332800e-02f, 9.24281124e-03f, 3.91959585e-02f, -4.18543406e-02f, -2.02923473e-02f, -5.68164252e-02f,
  -9.26812273e-03f, -8.50255340e-02f, -6.93103373e-02f, -1.33936969e-03f, -2.60257572e-02f, -9.66624245e-02f, 2.14720778e-02f, -3.56449783e-02f, -1.14767607e-02f, -6.76641986e-02f,
  3.63407172e-02f, -7.06787861e-04f, -4.17636186e-02f, 1.19304165e-01f, 5.09312265e-02f, 3.78082469e-02f, 8.34604129e-02f, -9.80364457e-02f, -1.12452187e-01f, 3.54804881e-02f,
  2.97667067e-02f, -3.34225828e-03f, -2.21088324e-02f, -4.35920199e-03f, -6.30831644e-02f, -8.34045708e-02f, 8.61412734e-02f, -4.28952985e-02f, -3.87137234e-02f, 2.92501226e-02f,
  1.42975360e-01f, -7.62144551e-02f, 8.28647539e-02f, 6.87492713e-02f, -3.63103300e-02f, -5.93033358e-02f, 1.01933861e-03f, -1.20590702e-01f, 4.77085523e-02f, -8.02427065e-03f,
  3.46208252e-02f, 3.35017219e-02f, -2.94056647e-02f, -7.01913089e-02f, -3.00366897e-02f, -3.56975943e-02f, -6.50184602e-02f, 4.11106180e-03f, 4.43065614e-02f, 8.11766163e-02f,
  -3.31445932e-01f, 3.91544759e-01f, -1.71579063e-01f, 6.03588000e-02f, 5.39372349e-03f, 5.19382022e-02f, 8.23146105e-02f, 1.12754665e-01f, 1.53448954e-01f, 2.28133455e-01f,
  4.50604223e-02f, -3.87739614e-02f, 5.53674065e-02f, 2.31694400e-01f, 1.22114299e-02f, 7.41600245e-02f, 8.61931778e-03f, 7.10828081e-02f, 7.49829784e-02f, -1.43966926e-02f,
  -4.00784016e-02f, 7.78992251e-02f, -1.30359501e-01f, 8.05367008e-02f, -8.49025995e-02f, -1.24073356e-01f, -1.55141145e-01f, 6.31786659e-02f, -4.06000577e-02f, 9.47643667e-02f,
  -1.35220774e-02f, -2.05314577e-01f, -1.21081941e-01f, -2.31046602e-02f, -1.53783351e-01f, -1.16749227e-01f, -5.70921402e-04f, 1.12693580e-02f, -5.07732853e-02f, 6.30044416e-02f,
  -1.82942096e-02f, 2.19788775e-02f, -4.40228023e-02f, 5.94332516e-02f, 3.94027233e-02f, -1.11880451e-02f, -3.47068384e-02f, 1.99146606e-02f, 6.49755746e-02f, -7.66469389e-02f,
  6.52786344e-02f, -7.28733779e-04f, 4.80623124e-03f, 1.32087814e-02f, -6.36665896e-02f, 3.43435332e-02f, 8.04130454e-03f, -2.55593956e-02f, -2.54191831e-02f, 4.74312156e-02f,
  4.65673096e-02f, -1.38689458e-01f, 8.81345645e-02f, 7.88070709e-02f, -5.51378122e-03f, 5.47266975e-02f, 3.07271909e-03f, -2.39022225e-02f, 3.05858031e-02f, -1.71457306e-02f,
  6.57838508e-02f, 1.08306333e-02f, 8.85120314e-03f, -4.10868526e-02f, -1.72476750e-02f, 9.83935688e-03f, -3.33677530e-02f, 5.17448708e-02f, 3.27192694e-02f, -5.16918371e-05f,
  3.92532162e-02f, 3.63828540e-02f, 6.33393787e-03f, -3.79608609e-02f, 6.55834973e-02f, -1.39730796e-02f, -2.79579181e-02f, 5.67869619e-02f, -3.91511507e-02f, -9.28211883e-02f,
  8.87410715e-03f, 5.90907373e-02f, -7.28830416e-03f, -3.40508036e-02f, 7.40388334e-02f, 2.52872352e-02f, -5.80185018e-02f, 2.80068628e-02f, 1.02584511e-01f, -6.92395568e-02f,
  -8.56225267e-02f, -4.65938598e-02f, 2.61748629e-03f, -3.05305496e-02f, 4.85980399e-02f, 1.25676971e-02f, -7.12302402e-02f, 3.84693481e-02f, 3.88843715e-02f, 5.60172042e-03f,
  -1.78088266e-02f, 1.20629314e-02f, 3.43429148e-02f, -6.81931004e-02f, -2.57372055e-02f, -6.50994554e-02f, -5.10877930e-02f, 7.60089010e-02f, -2.29630340e-02f, -2.05182247e-02f,
  4.78823557e-02f, -1.10193696e-02f, 3.64070415e-01f, 5.74723743e-02f, 6.17733113e-02f, 7.91114420e-02f, 3.16721909e-02f, -4.04921025e-02f, 4.84713942e-01f, -2.99253494e-01f,
  -1.73183605e-01f, 1.17834836e-01f, 5.43979146e-02f, 8.36641178e-04f, -1.23619974e-01f, 2.21217528e-01f, -7.38786086e-02f, -5.29314205e-03f, 2.18778640e-01f, -2.19430879e-01f,
  1.00412369e-01f, -1.66534275e-01f, 1.52405292e-01f, -1.01316035e-01f, 1.27806097e-01f, -4.14391495e-02f, -3.90816987e-01f, 3.11564412e-02f, -2.65094280e-01f, -6.33738749e-03f,
  -1.93015747e-02f, 7.02175349e-02f, -6.47979528e-02f, -1.59653202e-02f, -8.00590590e-02f, 3.74171324e-02f, 4.26055491e-02f, -3.31420859e-04f, -3.79244774e-03f, 9.59030073e-03f,
  -1.47794755e-02f, 2.43592858e-02f, 6.46608546e-02f, 1.19846143e-01f, 1.14844278e-01f, 9.59618669e-03f, 1.53031960e-01f, -1.62015725e-02f, 7.93260112e-02f, 1.54848844e-01f,
  1.16419636e-01f, 9.39411148e-02f, -3.67446765e-02f, -6.06578030e-02f, 4.09281962e-02f, 1.38909416e-02f, -1.49689019e-02f, -2.88781431e-03f, 1.80330053e-02f, -2.21801810e-02f,
  -7.91368168e-03f, 1.09048657e-01f, -1.62822567e-02f, 3.27706859e-02f, -8.49423781e-02f, -6.31247610e-02f, 1.70790832e-02f, -7.44701400e-02f, 6.73387125e-02f, -7.17983618e-02f,
  -7.10813776e-02f, 4.38113045e-03f, 4.21293341e-02f, 4.99379151e-02f, 1.08244596e-02f, -4.22800034e-02f, -5.95956743e-02f, -5.51940650e-02f, -5.77018894e-02f, 6.17854930e-02f,
  4.69389372e-02f, 3.35071608e-02f, -7.02487975e-02f, 1.02766722e-01f, 4.70114360e-03f, 4.50721793e-02f, 5.81223853e-02f, 7.60959312e-02f, 5.95887378e-02f, -4.31706756e-02f,
  -6.64024651e-02f, -2.21593633e-01f, -7.09425807e-02f, -2.03257278e-02f, 2.94126868e-02f, -9.95556638e-03f, 7.14989826e-02f, -4.72916886e-02f, -2.79980134e-02f, -2.29260921e-02f,
  -3.45050655e-02f, -1.11564055e-01f, -5.94181679e-02f, 9.58536193e-02f, -5.74015193e-02f, -1.14782043e-02f, -5.57509586e-02f, -1.30987436e-01f, -9.93904993e-02f, -5.42752035e-02f,
  -1.35899499e-01f, -8.52357522e-02f, -2.14980524e-02f, -8.73346850e-02f, -5.96029870e-02f, -1.17544206e-02f, -4.41756286e-02f, -2.03953534e-02f, -1.43024586e-02f, 3.28265154e-03f,
  1.71219900e-01f, -1.70467123e-01f, -5.26504871e-03f, -2.11013611e-02f, -1.25984341e-01f, 3.95094931e-01f, 3.35627675e-01f, -9.29321051e-02f, 1.88880384e-01f, 2.01365594e-02f,
  -5.74110597e-02f, 8.51941779e-02f, -1.31790312e-02f, 2.23639771e-01f, 3.99390131e-01f, 3.56822789e-01f, 2.60744631e-01f, 1.37911826e-01f, 6.72995225e-02f, 2.08827704e-02f,
  5.80870435e-02f, 1.38726488e-01f, 4.66442704e-02f, -1.84103385e-01f, 6.46818429e-02f, -1.45566761e-01f, -2.79258847e-01f, -9.44160149e-02f, -9.10604075e-02f, 5.51341847e-02f,
  5.06289043e-02f, 5.42524345e-02f, -7.09045231e-02f, 1.51759023e-02f, -3.95197794e-02f, -7.17839599e-02f, -5.62278591e-02f, 4.37648967e-02f, 4.43365164e-02f, 6.45327792e-02f,
  6.86465278e-02f, -2.37525515e-02f, 5.60517684e-02f, -6.52844980e-02f, -1.13718873e-02f, 1.70005374e-02f, -1.53690511e-02f, 1.78413615e-02f, 4.43332940e-02f, 7.99788255e-03f,
  1.55538246e-02f, 9.78523865e-03f, -3.31726633e-02f, 2.60974206e-02f, -9.93442163e-03f, 7.51291141e-02f, 3.13154273e-02f, 9.67850536e-03f, 8.08923412e-03f, 6.34727255e-02f,
  -1.22687398e-02f, -3.78955007e-02f, 8.36769938e-02f, -2.59507429e-02f, 1.62787922e-02f, -6.85814321e-02f, -2.65439320e-02f, -7.28024170e-02f, -1.69031229e-02f, -4.06840965e-02f,
  2.41180137e-02f, 4.68708901e-03f, 4.81674857e-02f, -5.38497372e-03f, 7.53986314e-02f, 3.36839035e-02f, -6.53083399e-02f, 2.27907225e-02f, 5.83070219e-02f, -1.93085186e-02f,
  -1.93802211e-02f, 2.10117009e-02f, -2.05378290e-02f, -6.91171959e-02f, 6.01151288e-02f, -7.69437104e-02f, -3.74198668e-02f, 5.70201911e-02f, -4.71615307e-02f, 5.63196018e-02f,
  3.47167775e-02f, -8.41615424e-02f, -9.21493955e-03f, 6.97226524e-02f, -1.72731858e-02f, 1.76818650e-02f, 1.26453474e-01f, -1.05516380e-02f, -2.34237146e-02f, 4.78341132e-02f,
  -9.89079773e-02f, -3.39640081e-02f, 4.37963530e-02f, -2.63210498e-02f, -1.31002152e-02f, 9.01222322e-03f, 3.03506255e-02f, -3.39946933e-02f, 1.51718939e-02f, -3.18486542e-02f,
  -1.15060866e-01f, 8.19052383e-02f, 1.36006624e-01f, 1.00073833e-02f, -6.90820068e-02f, -6.17739595e-02f, 8.64225160e-03f, -1.02429241e-02f, 9.11750831e-03f, 5.45429066e-02f,
  1.94353312e-01f, 1.31284241e-02f, 7.52748996e-02f, 2.44390801e-01f, 6.21788651e-02f, -1.62229985e-01f, 5.39084561e-02f, 9.64009091e-02f, -1.46216780e-01f, 9.73338932e-02f,
  -5.16396575e-02f, -1.82355061e-01f, -1.61719009e-01f, -9.57555100e-02f, -3.74252886e-01f, -2.48396337e-01f, -1.24992087e-01f, 2.00518928e-02f, -9.12824348e-02f, 3.09545570e-03f,
  -2.20837854e-02f, 1.05581358e-01f, -1.04014296e-02f, 1.40571237e-01f, 1.24483265e-01f, 3.80831778e-01f, 2.01148272e-01f, 2.16568653e-02f, 1.59354225e-01f, 1.74898524e-02f,
  -4.97501232e-02f, -4.41057086e-02f, 3.31772156e-02f, 2.67372243e-02f, 1.11071341e-01f, 6.12245649e-02f, 5.52782090e-03f, -8.50330573e-03f, -2.77919639e-02f, 6.68729469e-02f,
  4.20233533e-02f, -6.64201938e-03f, 4.07129936e-02f, 8.77677426e-02f, -1.79651834e-03f, 8.41408744e-02f, 4.00534160e-02f, 2.60322392e-02f, -1.62518937e-02f, -2.62227878e-02f,
  -5.25926501e-02f, 5.60412009e-04f, 2.39162296e-02f, 5.42730056e-02f, 2.64785010e-02f, 1.75593384e-02f, 1.14032090e-01f, 2.64568534e-02f, -1.06653280e-03f, 6.91647306e-02f,
  5.96573390e-02f, -1.37529115e-03f, -3.83552187e-03f, -9.30238329e-03f, -6.24915920e-02f, 1.10153453e-02f, -2.35772356e-02f, -3.37739624e-02f, -4.59862081e-03f, -3.65495309e-02f,
  -9.15929675e-02f, 1.10870510e-01f, -1.63941216e-02f, 2.04698332e-02f, -4.05995874e-03f, 1.04219362e-01f, -6.46348745e-02f, 3.04546319e-02f, -3.05237565e-02f, -3.41161378e-02f,
  3.46154347e-02f, -9.54394117e-02f, -8.38397350e-03f, 2.92848162e-02f, -3.66935395e-02f, 3.05059031e-02f, 9.92526934e-02f, -2.98397075e-02f, -1.72901656e-02f, -1.26630247e-01f,
  -3.83741632e-02f, 7.40850866e-02f, -8.84862989e-02f, 1.12154195e-02f, -3.00339069e-02f, -2.80440506e-02f, -8.70814547e-02f, 4.76560071e-02f, -2.09633540e-02f, -8.77177939e-02f,
  7.27172121e-02f, 4.90199216e-02f, -3.16801704e-02f, -1.65475961e-02f, -1.26129845e-02f, -1.37572050e-01f, -4.03371193e-02f, 3.69053893e-02f, 4.81028371e-02f, 2.07547992e-02f,
  8.61234963e-02f, 7.68403336e-02f, -3.85041162e-02f, 1.21726200e-01f, 8.79400223e-02f, 1.57360956e-02f, 1.92479398e-02f, 4.76441272e-02f, -6.76508322e-02f, -1.07325569e-01f,
  -1.91686168e-01f, 2.16490582e-01f, -1.37107119e-01f, 3.02444436e-02f, -2.24191979e-01f, 2.17911135e-02f, -8.82011130e-02f, -4.74259518e-02f, -2.55912561e-02f, 1.59622088e-01f,
  -4.68173921e-02f, 8.59644264e-02f, 1.94691613e-01f, 1.59651130e-01f, -2.07220912e-01f, 1.19311027e-01f, -7.10454583e-03f, 1.34111136e-01f, -1.05364695e-02f, 1.67795196e-01f,
  3.88593487e-02f, 1.19526446e-01f, -1.37378633e-01f, 1.63053852e-02f, -3.37549821e-02f, -2.41921786e-02f, 1.53751420e-02f, -7.06619844e-02f, 4.26640026e-02f, -1.73883885e-01f,
  8.72937664e-02f, 3.35265398e-02f, 3.22222486e-02f, 3.35103162e-02f, -4.17683050e-02f, -8.50816164e-03f, 4.65417393e-02f, -2.12675356e-03f, -1.33068532e-01f, 1.65029671e-02f,
  1.17732324e-01f, 1.42863458e-02f, -5.04785478e-02f, -1.73471980e-02f, 4.43865843e-02f, -7.96976611e-02f, -5.13319187e-02f, -9.32715461e-02f, 3.68181169e-02f, 6.75066491e-04f,
  -4.24481817e-02f, -1.39484527e-02f, -2.74829920e-02f, -7.50772506e-02f, -1.43691227e-01f, 4.93111163e-02f, -5.41004911e-02f, -4.94367536e-03f, 3.65084931e-02f, -1.19437492e-02f,
  -1.19548388e-01f, 8.23700577e-02f, -3.17839049e-02f, 8.57018828e-02f, -2.28589419e-02f, -6.21976517e-02f, 1.79836620e-02f, 6.35426939e-02f, -4.23274115e-02f, 2.38015894e-02f,
  -5.39200827e-02f, 3.07358876e-02f, -5.83898127e-02f, 4.74997945e-02f, 4.72010821e-02f, 3.53672840e-02f, 5.64374141e-02f, 1.08955670e-02f, 1.88645609e-02f, -6.01771921e-02f,
  3.70965116e-02f, -4.18872014e-02f, -2.02820729e-02f, 6.70934692e-02f, -6.76286232e-04f, 2.21287403e-02f, 3.51888798e-02f, 2.42318418e-02f, -2.85984576e-02f, 5.85402269e-03f,
  3.25207353e-01f, 1.47517547e-01f, 7.24985823e-02f, 4.14386811e-03f, 4.11563069e-02f, 3.17650684e-03f, 4.03572805e-02f, -3.13027948e-02f, 6.62943423e-02f, 2.00534724e-02f,
  7.22446218e-02f, 1.26932368e-01f, 3.66733186e-02f, 8.75969827e-02f, -1.45554155e-01f, 1.74526833e-02f, 9.38501284e-02f, -2.14072969e-02f, -3.28302011e-02f, 5.20968856e-03f,
  5.64100640e-03f, 2.02408340e-02f, -5.96860163e-02f, -1.64185837e-02f, 2.49353256e-02f, -5.38762100e-02f, -2.76525393e-02f, -5.04133850e-02f, -4.16936576e-02f, 8.10846463e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.42559981e-01f, 1.21013246e-01f, -9.97823551e-02f, 3.23932558e-01f, 3.83624211e-02f, -5.67907393e-02f, 1.83622956e-01f, 4.00230922e-02f, 4.41122174e-01f, 7.25008100e-02f,
  -2.54800115e-02f, 2.11975917e-01f, -6.40747771e-02f, 6.73718080e-02f, -1.22524112e-01f, 7.63602629e-02f, 1.19722476e-02f, 9.64174196e-02f, 1.21712908e-01f, -9.61211175e-02f,
  -2.12602109e-01f, 3.89378220e-02f, -2.63224572e-01f, -1.16971597e-01f, -1.75072715e-01f, 2.04292871e-02f, -1.77278593e-01f, 7.45575130e-02f, 1.69999078e-02f, 2.60160744e-01f,
  -2.86140352e-01f, 2.01887950e-01f, -1.08902000e-01f, 1.14384461e-02f, -1.89003423e-01f, -7.46486112e-02f, -7.92139471e-02f, 1.36977071e-02f, 3.65413888e-03f, 4.34848666e-02f,
  1.02315946e-02f, -6.30241260e-02f, 6.17078468e-02f, -1.48284528e-02f, 3.10130250e-02f, 1.97898988e-02f, -1.02920324e-01f, -8.89661685e-02f, 4.31819186e-02f, -6.69309795e-02f,
  -4.24341261e-02f, -6.30725399e-02f, -3.07426564e-02f, 5.21704257e-02f, 7.18247518e-02f, -2.21962053e-02f, 7.01850355e-02f, 4.83289473e-02f, 2.14690398e-02f, 2.39002649e-02f,
  1.00205690e-01f, 9.83433053e-02f, -6.52744295e-03f, 9.25278105e-03f, 1.04484446e-02f, -6.76809847e-02f, 4.32178713e-02f, 6.49206787e-02f, 3.45917456e-02f, -6.48277476e-02f,
  4.42416593e-02f, 2.00956576e-02f, 6.97044879e-02f, -5.99643439e-02f, 7.25811198e-02f, 7.06917569e-02f, 9.17615518e-02f, -9.10774097e-02f, -1.34321466e-01f, -1.36973768e-01f,
  7.78166279e-02f, 8.85064304e-02f, 1.81320671e-03f, -4.79021966e-02f, 4.85186465e-02f, 1.11664329e-02f, 4.34452668e-02f, -4.48358282e-02f, -2.76220478e-02f, 6.30715047e-04f,
  2.29699254e-01f, 3.54572028e-01f, -2.10482124e-02f, -1.83248874e-02f, 5.35160303e-02f, -4.68287207e-02f, 6.55533448e-02f, -1.11705244e-01f, 7.20935687e-02f, 8.43052715e-02f,
  -4.45753857e-02f, 5.17691672e-03f, -8.27819388e-03f, 4.51985486e-02f, -4.23325114e-02f, -1.27977341e-01f, 4.99905050e-02f, 1.24311261e-01f, 1.27606615e-01f, -1.01033203e-01f,
  -4.44361828e-02f, -8.72337371e-02f, 3.23893800e-02f, -3.07895150e-03f, -3.30015086e-02f, 3.21681313e-02f, 3.83652709e-02f, -2.28556450e-02f, 1.32685438e-01f, -3.07058040e-02f,
  -1.69697613e-01f, 1.12199120e-01f, 1.38812914e-01f, -3.34896386e-01f, -2.20525134e-02f, -2.47764826e-01f, -3.95275384e-01f, -2.68099364e-02f, 6.11700304e-02f, 2.07968708e-02f,
  -1.32694468e-01f, 1.41309485e-01f, 1.71668082e-01f, -2.69478023e-01f, -1.61490232e-01f, 9.93752629e-02f, -3.97004515e-01f, -9.93321016e-02f, 5.48986606e-02f, -1.97672546e-01f,
  -8.89443904e-02f, -2.74885774e-01f, -8.27081949e-02f, 7.99365938e-02f, -1.45338863e-01f, -8.18710122e-03f, -2.31545657e-01f, 1.13126554e-01f, -1.15659647e-01f, 1.76400110e-01f,
  -1.19209610e-01f, 3.10499389e-02f, -3.51849906e-02f, 6.91418350e-02f, -1.04236886e-01f, 9.56528820e-03f, -5.75784296e-02f, 1.22031614e-01f, -5.28505631e-02f, 3.31138000e-02f,
  -5.51221427e-03f, 1.80672482e-01f, -3.88890468e-02f, 5.13233282e-02f, -1.23884110e-02f, 3.81310582e-02f, 9.55949128e-02f, 2.53144521e-02f, 1.57742634e-01f, 1.41075432e-01f,
  1.01078659e-01f, 2.22165864e-02f, -1.10900886e-01f, -2.87251584e-02f, 4.64047305e-02f, 1.23048611e-02f, -6.10571653e-02f, -4.25998168e-03f, 7.81491678e-03f, -2.34258324e-02f,
  3.25920954e-02f, -8.74664076e-03f, -2.19245236e-02f, 6.39729500e-02f, 2.23548487e-02f, 1.70125410e-01f, 2.70687826e-02f, -5.92338331e-02f, 2.35664770e-02f, -3.55784968e-02f,
  -4.27925549e-02f, 7.28214532e-02f, 5.52247278e-02f, -2.09568694e-01f, -9.98967439e-02f, -9.46149155e-02f, -2.95352042e-02f, 1.89459827e-02f, -9.38712135e-02f, -4.00925018e-02f,
  8.45874175e-02f, -3.56820226e-02f, -2.80685211e-03f, -9.79852974e-02f, 5.96623681e-02f, 5.57625815e-02f, 7.46110901e-02f, 1.17589779e-01f, 6.63739629e-03f, -3.78657551e-03f,
  -3.54440629e-01f, -3.24255198e-01f, 1.67807061e-02f, 1.11511596e-01f, -2.77864467e-02f, -5.86906970e-02f, -5.77231906e-02f, 7.91133940e-03f, -1.28482357e-01f, -1.66531820e-02f,
  -1.06134050e-01f, -8.42299014e-02f, 3.40839801e-03f, -8.69826302e-02f, 3.09127942e-02f, 1.73062999e-02f, 1.16573777e-02f, -1.18123084e-01f, -1.00356378e-01f, 1.91220623e-02f,
  9.46446043e-03f, 5.15128076e-02f, 1.02411650e-01f, -3.95304570e-03f, -2.05945782e-02f, -9.37263221e-02f, -7.83904269e-03f, 6.57854527e-02f, -7.62912165e-03f, -6.01147972e-02f,
  3.27841714e-02f, 2.97199070e-01f, 2.48429120e-01f, 2.35339612e-01f, -1.82589725e-01f, -4.07992572e-01f, -3.31785738e-01f, 1.80622235e-01f, -7.83919692e-02f, -2.49225453e-01f,
  -1.68575291e-02f, 9.16538537e-02f, -9.71169695e-02f, 2.16136590e-01f, 1.61412612e-01f, -1.57487780e-01f, 1.60946414e-01f, 1.58197712e-02f, 1.01582482e-01f, 2.28585199e-01f,
  1.93450496e-01f, 1.29396692e-01f, 3.29256386e-01f, 1.14085287e-01f, 9.02148411e-02f, 3.06140602e-01f, 2.90450454e-01f, -6.32282719e-02f, 2.78283000e-01f, -5.57263717e-02f,
  -5.57193980e-02f, 1.34427428e-01f, -1.56044005e-03f, -8.29887986e-02f, 3.04119103e-02f, -3.00270747e-02f, -8.32564235e-02f, 2.25044526e-02f, 5.56808300e-02f, 7.74070323e-02f,
  -3.60345691e-02f, 9.03548226e-02f, 6.40283599e-02f, 4.13489118e-02f, -2.89887227e-02f, 8.50827843e-02f, 3.18704434e-02f, -4.14321385e-02f, 7.55517483e-02f, 1.38199449e-01f,
  1.33699372e-01f, 2.09222063e-02f, 5.86808957e-02f, -5.37894154e-03f, 9.49998796e-02f, 4.75359969e-02f, -5.65722138e-02f, -9.04451869e-03f, 1.95447206e-02f, -5.00167347e-03f,
  7.48744234e-03f, -1.73319727e-01f, -3.71810459e-02f, -5.72898127e-02f, -2.01697256e-02f, -4.29373533e-02f, 2.45043561e-02f, -2.44149324e-02f, -6.79341257e-02f, -4.84481826e-02f,
  -4.98515926e-02f, -3.64068076e-02f, -1.09471893e-02f, -1.16152177e-02f, 3.18288766e-02f, 6.32616971e-03f, -5.73509485e-02f, -1.90972481e-02f, -7.71037564e-02f, 1.02117352e-01f,
  -4.04661186e-02f, 1.96946021e-02f, -1.52912289e-02f, -2.51216386e-02f, -2.75531039e-02f, -1.07082367e-01f, -1.13321394e-02f, -5.44462912e-02f, 6.02493063e-03f, -7.46934265e-02f,
  -4.26942222e-02f, 2.57614464e-01f, 1.74151063e-02f, 2.33751740e-02f, -5.74199995e-03f, -4.52142023e-02f, -9.81215201e-03f, 1.87970065e-02f, 3.91339809e-02f, 3.25344801e-02f,
  1.16689093e-02f, -2.41676122e-02f, -2.26074513e-02f, 3.88429053e-02f, 6.75740689e-02f, -4.16233540e-02f, -2.76279859e-02f, -2.92552691e-02f, 4.89157299e-03f, 6.03964925e-02f,
  1.12862671e-02f, -8.46736580e-02f, 2.97737550e-02f, -5.88442311e-02f, 8.96656588e-02f, -2.34988444e-02f, 8.42339545e-02f, 3.17073688e-02f, 9.41023827e-02f, 1.07509540e-02f,
  3.33098859e-01f, 2.24566132e-01f, 2.67818570e-01f, 2.14275584e-01f, -2.99579166e-02f, -2.60825723e-01f, -1.84831530e-01f, 5.37846014e-02f, 1.45275787e-01f, -2.12875661e-02f,
  -9.50751156e-02f, 4.91218895e-01f, -2.64683783e-01f, 2.71587104e-01f, -3.79496664e-01f, -2.74997711e-01f, 7.79616833e-02f, 2.65997082e-01f, 9.47570056e-03f, 4.77623269e-02f,
  5.42001277e-02f, -9.74263623e-02f, 1.31684393e-02f, -1.69691354e-01f, 2.80245811e-01f, 2.15066224e-01f, -2.70215899e-01f, -1.09035321e-01f, 9.52247232e-02f, 8.91781587e-04f,
  5.21563413e-03f, 1.22548945e-01f, 1.26958430e-01f, 1.37813404e-01f, -1.22760952e-01f, 4.11779843e-02f, 5.51827401e-02f, -2.11868659e-02f, -4.37583812e-02f, 5.11326343e-02f,
  -1.22143375e-02f, 5.41628078e-02f, 9.58464742e-02f, 6.94052828e-03f, 3.38013954e-02f, 2.74675880e-02f, 5.94168045e-02f, 9.72775891e-02f, 7.90893361e-02f, 3.62555347e-02f,
  3.34247178e-03f, 7.87679702e-02f, 2.31491635e-03f, 4.86209318e-02f, -7.84689840e-03f, 2.54650991e-02f, 1.43895522e-02f, 1.49164125e-01f, 1.14057973e-01f, 5.32872304e-02f,
  5.53412735e-02f, -1.32384926e-01f, -2.59211622e-02f, 3.53679322e-02f, 2.87286704e-04f, -7.16809696e-03f, -6.38186410e-02f, 6.48888126e-02f, 1.21684119e-04f, -7.55213052e-02f,
  -5.40264957e-02f, 9.15230215e-02f, -2.99164038e-02f, -2.78767757e-02f, -7.01583028e-02f, 4.22114804e-02f, 8.47568065e-02f, -7.06728222e-03f, -5.72591014e-02f, 4.02635261e-02f,
  -6.14768863e-02f, -6.15309812e-02f, 6.04157969e-02f, -9.43964068e-03f, -7.44539779e-04f, -1.34035517e-02f, -2.63564754e-02f, 3.97341978e-03f, 7.15209346e-04f, -6.84296116e-02f,
  -3.05368125e-01f, -2.21267149e-01f, -4.02476229e-02f, -4.92979996e-02f, -2.34956983e-02f, 4.23928946e-02f, 7.73162255e-03f, 1.37100115e-01f, -5.16440645e-02f, -1.14444137e-01f,
  3.64920162e-02f, -7.43210614e-02f, -1.29148811e-02f, 1.39840886e-01f, -3.65135409e-02f, -7.77277797e-02f, -5.71984239e-02f, -5.61611028e-03f, 1.13351971e-01f, 2.61660963e-02f,
  4.16697562e-02f, -6.64568171e-02f, 1.12613328e-02f, 1.65013913e-02f, -1.02667008e-02f, 2.70592626e-02f, -5.39852977e-02f, -2.70316992e-02f, -5.79897948e-02f, -1.77879911e-02f,
  1.45895839e-01f, -1.34055138e-01f, -4.29492652e-01f, 3.82097363e-01f, 4.52405438e-02f, 1.92414701e-01f, -1.16453849e-01f, 1.58084147e-02f, -5.81999570e-02f, 1.86254196e-02f,
  1.36388183e-01f, -6.30301535e-02f, -3.22533756e-01f, 5.48241735e-01f, 4.51603413e-01f, -1.29860193e-01f, 5.42300701e-01f, 1.12632796e-01f, -9.30124670e-02f, 1.56303719e-01f,
  2.24471956e-01f, 5.67247808e-01f, -1.16252877e-01f, 2.03662917e-01f, 1.96286008e-01f, -3.35778086e-03f, 1.58211395e-01f, -3.22347432e-01f, 3.06518167e-01f, 1.90395355e-01f,
  1.18502818e-01f, -2.75141522e-02f, -1.27331734e-01f, 5.05961664e-03f, -6.02620305e-04f, -4.80363891e-02f, -1.90915428e-02f, -5.85095724e-03f, -1.19217880e-01f, -6.01855591e-02f,
  -8.78749192e-02f, -1.08859334e-02f, 1.11366622e-01f, 8.42076242e-02f, 7.90417492e-02f, -6.98525086e-02f, 1.66814048e-02f, -8.91807303e-02f, -7.41333142e-02f, -1.62998028e-02f,
  -1.08503737e-01f, 1.10119535e-02f, -4.12829854e-02f, 5.07841120e-04f, -5.53204641e-02f, 3.59707251e-02f, -1.01463543e-02f, -4.03463244e-02f, -2.79012863e-02f, 4.81018238e-02f,
  7.39081949e-02f, -4.89825681e-02f, -6.00611269e-02f, -8.39822832e-03f, -4.99917343e-02f, -5.89706302e-02f, 2.94339489e-02f, -5.19470982e-02f, -1.37482613e-01f, 2.17429530e-02f,
  3.07804495e-02f, 3.87483090e-02f, -9.35210567e-03f, 5.30556627e-02f, 6.89531071e-03f, -8.03396255e-02f, 3.59472409e-02f, 2.91490294e-02f, -3.49616334e-02f, -7.07544833e-02f,
  2.19129422e-03f, 5.40377758e-02f, -5.53615056e-02f, 5.82774915e-03f, 1.01947218e-01f, -1.16682183e-02f, 1.63655564e-01f, 6.92072324e-03f, -1.05365127e-01f, 2.94238068e-02f,
  1.40161246e-01f, 6.20643124e-02f, -3.06940116e-02f, -1.83206405e-02f, 2.38532498e-02f, 1.17484994e-01f, 1.15525117e-02f, 1.02665015e-01f, 4.31822278e-02f, 5.17927632e-02f,
  4.79830243e-02f, -6.99271113e-02f, -1.03432322e-02f, 7.13245720e-02f, -1.73115153e-02f, 3.01825739e-02f, 1.56176500e-02f, -6.69952929e-02f, 7.29905739e-02f, 1.26421273e-01f,
  -3.97795215e-02f, -1.07711069e-02f, -4.47049225e-03f, -4.96351905e-03f, 3.61295640e-02f, -9.29303393e-02f, -5.91243431e-02f, -5.07634766e-02f, -1.62591580e-02f, -1.66474134e-02f,
  3.12766314e-01f, -7.28728116e-01f, -3.21284533e-02f, 3.99642527e-01f, 4.24544960e-01f, 1.62213445e-01f, 3.08455348e-01f, -1.15563095e-01f, 1.66510269e-02f, -3.21372360e-01f,
  2.43825495e-01f, 2.66145989e-02f, -1.51018232e-01f, 1.09997243e-02f, 2.98744887e-01f, -2.11013675e-01f, -3.43404748e-02f, 1.15771517e-01f, -7.10004568e-02f, 3.59040052e-02f,
  5.60453385e-02f, 1.32628620e-01f, 1.27753746e-02f, -2.32256785e-01f, 1.35948434e-01f, -8.08134824e-02f, 5.96743003e-02f, 5.91138825e-02f, 7.92163424e-03f, 2.89720327e-01f,
  -1.68434978e-02f, -3.34579349e-02f, 2.30405889e-02f, -1.35885507e-01f, -3.45350876e-02f, 3.62834372e-02f, 7.64989555e-02f, 1.50710359e-01f, 6.00838326e-02f, 7.46200830e-02f,
  -2.08362360e-02f, 3.13084573e-02f, -3.18102166e-02f, 3.92231792e-02f, -5.10194637e-02f, -4.58114147e-02f, 6.97422354e-03f, 4.43108603e-02f, 1.41074304e-02f, -4.35518324e-02f,
  -4.99959439e-02f, -7.76593760e-02f, 1.95078272e-02f, -1.14677891e-01f, -3.25053148e-02f, 9.77749079e-02f, 2.11357307e-02f, -5.15624732e-02f, 1.31713292e-02f, -8.53486080e-03f,
  -1.41013592e-01f, -4.53905985e-02f, -8.46568123e-03f, 8.53731409e-02f, 2.24111155e-02f, 9.04617980e-02f, 4.39885184e-02f, 6.03320971e-02f, 7.05466047e-02f, -1.07785508e-01f,
  8.35332870e-02f, 9.14648175e-02f, -2.42748503e-02f, -3.70261781e-02f, 4.71425354e-02f, 6.51389956e-02f, 4.86584790e-02f, 7.56121948e-02f, -3.15819010e-02f, 1.19743738e-02f,
  6.45581335e-02f, 8.89641494e-02f, -1.83434132e-02f, -1.27744405e-02f, 5.12235798e-02f, 9.17679369e-02f, -2.71652509e-02f, -2.35772803e-02f, 1.04142472e-01f, 5.94756305e-02f,
  -2.59761393e-01f, -5.05720079e-01f, -4.19605933e-02f, 9.11527947e-02f, -1.50070697e-01f, -1.59515396e-01f, -1.32894656e-02f, -5.62177189e-02f, -2.90734358e-02f, 1.61696896e-02f,
  -6.98731318e-02f, 1.68063909e-01f, -1.91333536e-02f, 1.10948561e-02f, 7.17935339e-02f, 1.22060813e-02f, -1.07196152e-01f, 1.22118508e-02f, 7.04667419e-02f, -5.05595133e-02f,
  3.81528810e-02f, -1.01554170e-01f, 1.61109403e-01f, 4.35084738e-02f, -2.97134072e-02f, -2.26497781e-02f, -4.92577441e-02f, -2.78503690e-02f, 5.92083447e-02f, -7.61895552e-02f,
  -5.06661870e-02f, -1.19791597e-01f, -3.19808647e-02f, -6.89476356e-02f, -1.88767947e-02f, -1.71153307e-01f, -1.12064958e-01f, -2.02186063e-01f, 6.40048534e-02f, -1.69503450e-01f,
  -4.90101464e-02f, 9.40340906e-02f, 1.92063242e-01f, -1.94017217e-01f, 3.82224679e-01f, 1.41285673e-01f, -1.91473395e-01f, -4.43899073e-02f, -9.47421864e-02f, -3.08662921e-01f,
  -2.13681292e-02f, -2.11589172e-01f, -3.35349813e-02f, -3.25291067e-01f, -1.92184955e-01f, -1.15369402e-01f, 8.84362310e-02f, -5.48999831e-02f, -1.10635228e-01f, 1.17835231e-01f,
  2.34473334e-03f, -1.45671040e-01f, -1.03538118e-01f, -9.57432836e-02f, -3.39628235e-02f, 6.70749620e-02f, 2.90581305e-02f, 4.71240059e-02f, 1.79437231e-02f, 5.09824753e-02f,
  1.37203962e-01f, 6.08125469e-03f, -5.09036556e-02f, 7.59362057e-02f, -1.15991414e-01f, -2.51570754e-02f, -7.40831643e-02f, 3.51738976e-03f, -8.24089199e-02f, 2.14151870e-02f,
  -7.87281543e-02f, 4.95574474e-02f, 1.10833742e-01f, 5.93306161e-02f, -3.42295989e-02f, 5.82606420e-02f, 1.44732371e-01f, 1.99531078e-01f, -8.49989280e-02f, 7.70433992e-02f,
  1.50515493e-02f, -9.65105146e-02f, 4.22874093e-02f, -4.44410881e-03f, -6.66898787e-02f, -5.57486415e-02f, -3.35287377e-02f, 5.24320416e-02f, -1.52258545e-01f, -2.66706664e-02f,
  3.47833298e-02f, 4.24811095e-02f, -9.87766534e-02f, -5.68590350e-02f, -1.08980924e-01f, 9.36488956e-02f, 3.45289633e-02f, 1.57026462e-02f, 5.43995239e-02f, -9.09124240e-02f,
  -5.07135577e-02f, 4.30087522e-02f, 2.50998437e-02f, 5.90758137e-02f, -1.73815396e-02f, 2.82125603e-02f, 1.44363530e-02f, 6.51726499e-02f, -1.38856051e-02f, -6.79791765e-03f,
  -1.18968345e-01f, -1.39246315e-01f, -2.35578623e-02f, -7.72657897e-03f, 7.40340129e-02f, 4.29425649e-02f, -4.16478049e-03f, -6.67660385e-02f, 3.87428375e-03f, -3.19730937e-02f,
  -8.24753195e-02f, 5.47528341e-02f, -1.12690069e-02f, 1.03448322e-02f, -7.04166144e-02f, -5.59691750e-02f, -1.15968838e-01f, -2.37689484e-02f, 7.49574527e-02f, -8.76179989e-03f,
  -1.07134163e-01f, 5.30174002e-02f, 7.78339207e-02f, -3.71578932e-02f, -1.07004670e-02f, 3.39719187e-03f, -1.50982188e-02f, -3.83352712e-02f, 1.32894665e-01f, 1.28040044e-02f,
  1.44332588e-01f, -4.36427116e-01f, -3.27993482e-01f, -7.11093545e-02f, 6.43469617e-02f, -2.45853558e-01f, -3.31131369e-01f, -1.48800835e-01f, 1.17133617e-01f, -2.43461862e-01f,
  -1.70364305e-01f, 6.24188408e-02f, -1.98075503e-01f, -1.77993298e-01f, 3.77898932e-01f, 1.11305462e-02f, -1.04442336e-01f, -2.15472043e-01f, 1.09404936e-01f, -2.51939774e-01f,
  1.13032637e-02f, -4.97326218e-02f, -6.03582636e-02f, -4.13437895e-02f, -2.50678331e-01f, -1.21287461e-02f, 1.58621371e-01f, -7.44940042e-02f, 7.60415643e-02f, 6.28148243e-02f,
  7.57620633e-02f, 3.37753296e-02f, -8.94723907e-02f, -4.21758853e-02f, -1.07631035e-01f, -4.22707014e-02f, -3.81942727e-02f, 9.09113288e-02f, 1.24119416e-01f, 3.22135575e-02f,
  5.02765551e-03f, 9.46990214e-03f, 6.31320179e-02f, 6.89259395e-02f, -1.39286071e-02f, -2.79618967e-02f, 4.39037904e-02f, 7.27521852e-02f, -1.22527316e-01f, -1.89835757e-01f,
  -2.99168713e-02f, -7.43507082e-03f, -1.15459941e-01f, 8.14153254e-02f, -6.99219704e-02f, -6.46701455e-02f, 1.74909290e-02f, -9.93848071e-02f, 2.00486425e-02f, 6.21015169e-02f,
  -1.13007106e-01f, 1.04001008e-01f, -5.66551313e-02f, -4.42306474e-02f, -1.05627999e-01f, 1.16963394e-01f, 2.72370372e-02f, -2.41873376e-02f, 8.05101320e-02f, 5.86589202e-02f,
  -7.44207576e-02f, -5.43542951e-02f, -5.09631075e-03f, 7.07466062e-03f, 1.35861589e-02f, 7.09643811e-02f, 9.63103995e-02f, -5.79780936e-02f, -3.96125689e-02f, 3.03127971e-02f,
  8.25399831e-02f, 4.90738489e-02f, -6.59537092e-02f, -2.92371232e-02f, 2.52849832e-02f, -2.72165444e-02f, -3.07449773e-02f, -5.91289736e-02f, 2.15666369e-02f, -3.72239277e-02f,
  -1.10473931e-01f, -1.65579394e-01f, 1.40641592e-02f, -3.45561355e-02f, -1.22359330e-02f, -9.30076018e-02f, 4.66329120e-02f, -1.20278873e-01f, 1.56892966e-02f, -7.62553364e-02f,
  -8.05064142e-02f, 1.02479666e-01f, 1.16473675e-01f, 6.25972524e-02f, -2.73286868e-02f, -2.45507080e-02f, 2.47884425e-03f, 1.19246364e-01f, -4.45411867e-03f, -7.29158819e-02f,
  -5.46181239e-02f, -1.97113771e-02f, 7.64151961e-02f, -5.83831035e-02f, -1.12362532e-02f, 8.96069482e-02f, -3.22525087e-03f, 1.14345709e-02f, 1.54872481e-02f, 1.72930229e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  -8.04172233e-02f, 2.39115134e-01f, -1.67638749e-01f, -4.27215770e-02f, 3.01124483e-01f, 2.27275088e-01f, -1.08356327e-01f, -1.56640168e-02f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  3.56597424e-01f, -1.66440055e-01f, 1.97574213e-01f, 2.91319937e-01f, -2.05668643e-01f, -2.51729667e-01f, -1.18146017e-01f, 2.02155247e-01f, 1.08307404e-02f, -7.75077343e-02f,
  -1.25446483e-01f, 1.26940414e-01f, 1.90932676e-01f, 4.68517654e-03f, 1.10268943e-01f, 2.29198158e-01f, -3.88841420e-01f, -1.59458086e-01f, -5.07195368e-02f, 3.88215408e-02f,
  3.82429212e-01f, 2.36433726e-02f, 3.54019850e-02f, 3.71173397e-02f, 2.51799911e-01f, 1.31158650e-01f, 4.17183936e-01f, 3.31283331e-01f, -1.10590551e-02f, -2.15435341e-01f,
  -1.62288845e-02f, 1.01605736e-01f, -4.19619791e-02f, 1.39983118e-01f, -1.43104985e-01f, -1.56351730e-01f, -1.47729710e-01f, 1.28187373e-01f, -9.97408945e-03f, -2.81070378e-02f,
  4.81841480e-03f, 1.79945797e-01f, 9.68308970e-02f, 9.77181047e-02f, -1.78720448e-02f, 1.63554356e-01f, -8.02307506e-04f, -3.02658409e-01f, -8.06507468e-02f, -2.52235383e-02f,
  1.14429139e-01f, -3.30685705e-01f, -1.78169593e-01f, -1.89975694e-01f, 4.00071219e-02f, -1.99152693e-01f, -3.68983954e-01f, -3.86717319e-02f, 1.21677266e-02f, 3.80609721e-01f,
  -7.61004090e-02f, 2.91246474e-01f, 8.78962651e-02f, 6.66169962e-03f, -8.52626935e-02f, 1.01887353e-01f, -1.52881190e-01f, 1.79970395e-02f, -3.42668712e-01f, 9.55746025e-02f,
  -1.70137018e-01f, -1.53124616e-01f, 3.31737995e-01f, 2.90406168e-01f, 1.54959783e-01f, -2.28331387e-01f, 2.15804651e-02f, -4.72229905e-03f, -1.75766885e-01f, 6.28381362e-03f,
  3.15181732e-01f, -3.12049210e-01f, -1.84444129e-01f, 8.98717046e-02f, -1.92487717e-01f, -1.73822477e-01f, -9.67170671e-02f, -1.52654082e-01f, -1.57022536e-01f, 9.32016820e-02f,
  2.96638072e-01f, 1.32742912e-01f, 4.52516884e-01f, -1.66166067e-01f, 1.66131869e-01f, 2.05725193e-01f, 1.46434560e-01f, 2.08464712e-01f, 8.31316113e-02f, 6.22840598e-02f,
  6.18553087e-02f, 5.94897941e-02f, 1.21723644e-01f, -1.61543041e-01f, 6.81677461e-02f, 9.36054662e-02f, 2.43798286e-01f, 2.40389615e-01f, -1.97732136e-01f, -4.11072746e-02f,
  -2.30904013e-01f, 2.69827936e-02f, 2.87438244e-01f, -5.70668690e-02f, -1.90146461e-01f, 5.20845950e-01f, 1.04209051e-01f, 3.53008002e-01f, -2.61575123e-03f, 7.76754245e-02f,
  3.59098613e-01f, 5.67951128e-02f, 1.53900877e-01f, -1.21603273e-01f, 2.83579409e-01f, -4.23891664e-01f, -2.21923515e-01f, 1.60706863e-01f, 9.36896726e-02f, -3.66409719e-02f,
  8.25677905e-03f, 1.01290055e-01f, 1.56818062e-01f, -6.48504123e-02f, 3.14586520e-01f, 1.05848446e-01f, -3.33494246e-01f, 1.99979264e-02f, -7.40523636e-02f, 2.00559646e-01f,
  -1.94272660e-02f, -2.78850943e-01f, -2.30635535e-02f, 3.30295414e-01f, -1.59676015e-01f, 2.21945882e-01f, 1.93503752e-01f, -1.13626502e-01f, 2.12615609e-01f, 2.18456630e-02f,
  1.34058431e-01f, -1.27290234e-01f, -9.21756178e-02f, -1.02724642e-01f, -1.53637990e-01f, 1.90744668e-01f, -2.19600741e-02f, -3.10094133e-02f, 2.82631032e-02f, -1.48119584e-01f,
  1.25453070e-01f, -1.54826999e-01f, -1.36568755e-01f, 1.56974331e-01f, 1.39118314e-01f, 4.43456210e-02f, 2.16814712e-01f, 2.21655846e-01f, -1.31221265e-01f, -2.19892502e-01f,
  1.82242095e-01f, 2.65179336e-01f, -1.80414289e-01f, -2.45727047e-01f, 1.88776717e-01f, 2.47194305e-01f, -1.39149209e-03f, -1.88531578e-01f, -2.92130969e-02f, -2.37228200e-01f,
  2.45270636e-02f, -2.07306907e-01f, 1.95761874e-01f, -2.20133867e-02f, 8.02722350e-02f, 1.90725118e-01f, 1.91848293e-01f, 3.83504294e-02f, -4.21706736e-01f, -1.23036638e-01f,
  -1.08883297e-02f, -3.22006732e-01f, -1.19161643e-01f, 2.76307434e-01f, -1.52690172e-01f, -1.71158060e-01f, -2.84165829e-01f, 2.31946886e-01f, -1.00803390e-01f, -1.33977741e-01f,
  1.31813601e-01f, 1.49843976e-01f, -8.33055228e-02f, -1.39329523e-01f, 1.01221420e-01f, -8.09046030e-02f, -2.32715487e-01f, -3.81185621e-01f, 2.58839756e-01f, -6.69084787e-02f,
  7.49389380e-02f, -2.63787985e-01f, 1.44545827e-02f, 1.17042691e-01f, -2.40648925e-01f, -2.43032381e-01f, -6.17691390e-02f, 3.82907502e-02f, -1.21353768e-01f, -3.55570436e-01f,
  9.06456783e-02f, 4.85096360e-03f, 7.65167177e-02f, 2.07587406e-01f, 2.87184000e-01f, -2.75755405e-01f, -1.52056202e-01f, 3.28185469e-01f, 1.46662116e-01f, -1.65146738e-01f,
  1.67307314e-02f, 1.96137149e-02f, -2.23920494e-01f, -2.86653880e-02f, -1.24372005e-01f, -1.63365588e-01f, -3.09863058e-03f, -3.02170306e-01f, 1.73952460e-01f, 3.21015567e-01f,
  7.31821135e-02f, -6.84005544e-02f, 3.28006409e-02f, 6.90355822e-02f, -3.99568319e-01f, -2.14948341e-01f, 2.61796713e-02f, -1.51344091e-01f, -2.92784665e-02f, -2.64298767e-01f,
  3.08551788e-01f, -4.43891287e-01f, 3.51063758e-01f, 1.52190521e-01f, -1.97627604e-01f, 9.68587026e-02f, -1.94414034e-02f, 2.36304849e-02f, -8.01142305e-02f, 1.83313370e-01f,
  -1.62207469e-01f, -1.30228549e-01f, 2.32352182e-01f, 3.00870128e-02f, -2.37999558e-01f, 6.80831522e-02f, -4.15142402e-02f, -1.78923145e-01f, 2.14728743e-01f, 3.99938405e-01f,
  2.78447777e-01f, 2.24006906e-01f, -2.16661930e-01f, -1.43001691e-01f, -1.15586847e-01f, -1.80205092e-01f, -1.20247953e-01f, 9.49303359e-02f, 2.36597061e-01f, -1.72951847e-01f,
  -2.58804232e-01f, -4.34325308e-01f, 2.51879007e-01f, 4.34517175e-01f, 9.43751112e-02f, 2.09370181e-01f, -3.40481281e-01f, -5.34221008e-02f, 2.71105468e-01f, -6.49067983e-02f,
  -1.90023631e-01f, 1.50255367e-01f, 6.60997331e-02f, 1.13574721e-01f, -1.87416840e-02f, -9.08377394e-02f, 5.10975765e-03f, 3.65081906e-01f, -9.68805254e-02f, -2.49543693e-02f,
  2.74402723e-02f, -1.30038723e-01f, 7.45698959e-02f, -7.45472237e-02f, -5.60170263e-02f, -2.30351910e-01f, 1.23028688e-01f, -3.45214605e-02f, 8.85528848e-02f, -5.10494232e-01f,
  -2.02066183e-01f, -3.63176167e-01f, -3.88750911e-01f, 3.55483204e-01f, 3.45871955e-01f, 2.96918243e-01f, -5.19848429e-02f, -2.55001783e-02f, 1.73068792e-01f, 1.27644584e-01f,
  -4.18560207e-01f, -1.50420386e-02f, -1.10112220e-01f, -3.29445928e-01f, -4.86530699e-02f, 2.79738486e-01f, 1.31110623e-01f, -2.04921544e-01f, 6.41366169e-02f, 8.75054002e-02f,
  1.48263827e-01f, 1.13922805e-01f, -1.04679808e-01f, 7.57752657e-02f, 3.50999013e-02f, -5.53750098e-01f, 5.21416485e-01f, -6.44538701e-02f, -1.21253975e-01f, -4.32481691e-02f,
  -2.07616799e-02f, -1.29333824e-01f, -1.39647901e-01f, 1.72527999e-01f, -3.18250991e-02f, 3.36789130e-03f, -2.60448843e-01f, -1.69169098e-01f, -4.29209977e-01f, 6.94167390e-02f,
  3.13022174e-02f, -3.35408181e-01f, 1.60492733e-01f, 1.72607079e-01f, 3.60765867e-02f, 7.21811205e-02f, 5.75650819e-02f, 7.20153823e-02f, -2.51887232e-01f, -4.68170792e-02f,
  1.75018348e-02f, -5.05296737e-02f, 1.28468782e-01f, 1.19325109e-01f, 9.59231108e-02f, 1.04988322e-01f, -2.43990913e-01f, -1.67939752e-01f, -4.60708648e-01f, 3.37694526e-01f,
  -1.35218296e-02f, -2.57943034e-01f, 1.50097683e-01f, 2.38444418e-01f, -2.20489189e-01f, 1.18081786e-01f, 4.03964669e-02f, -7.34933913e-02f, -4.43456732e-02f, -2.58383360e-02f,
  -1.32572517e-01f, -3.67343992e-01f, 1.93469495e-01f, 1.84634119e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -2.08036885e-01f, 3.01976860e-01f, 1.44480407e-01f, -1.25705481e-01f, 2.08780885e-01f, 4.67188448e-01f, -7.62997121e-02f, 2.11456120e-02f, 2.79735267e-01f, 1.62121519e-01f,
  9.19709876e-02f, 2.28588402e-01f, -8.43502134e-02f, 1.47864759e-01f, -3.44209731e-01f, -2.39308685e-01f, 3.31237674e-01f, 2.37207979e-01f, 1.60580009e-01f, -2.65049338e-01f,
  1.39747234e-02f, 3.18862617e-01f, -2.69633174e-01f, -3.86538953e-01f, -1.52075753e-01f, 1.04136039e-02f, -2.05563545e-01f, -6.44086152e-02f, 2.42854998e-01f, 2.64392972e-01f,
  3.41949999e-01f, 3.37869853e-01f, 2.10018292e-01f, 3.31658334e-01f, -7.55003244e-02f, -8.77239853e-02f, 1.51935637e-01f, 7.82920197e-02f, -2.08268121e-01f, 9.93601512e-03f,
  4.20332938e-01f, 5.89188933e-01f, 8.65055770e-02f, -1.53436130e-02f, -8.51057842e-02f, 1.68177143e-01f, -2.87560105e-01f, -4.66874033e-01f, 2.20004141e-01f, -2.45835334e-01f,
  6.30797297e-02f, -5.38979210e-02f, 1.36372566e-01f, -5.11933584e-03f, -6.48770481e-02f, -1.27122387e-01f, -2.42232397e-01f, 4.23178136e-01f, 5.76920295e-03f, 2.00862065e-01f,
  -2.51076221e-01f, -2.09682718e-01f, 3.44636083e-01f, 1.72202572e-01f, 3.28234494e-01f, 9.06935111e-02f, 1.11968771e-01f, 1.65921256e-01f, -3.34469974e-02f, 1.10438384e-01f,
  1.54359505e-01f, -7.25671425e-02f, -1.03022985e-01f, 3.00516039e-01f, 6.80481121e-02f, 2.41476089e-01f, 1.72661319e-01f, 1.34495839e-01f, -7.91072249e-02f, 4.80234101e-02f,
  -2.87981629e-01f, -2.04289556e-01f, -1.40637867e-02f, -1.84440389e-01f, -2.30090663e-01f, -3.19623888e-01f, 1.91181034e-01f, -5.47608398e-02f, -3.50062549e-01f, 6.13787510e-02f,
  4.80184615e-01f, 2.85080492e-01f, -9.28494893e-03f, -9.25006121e-02f, 6.12374283e-02f, 7.38389269e-02f, 1.20555528e-01f, 4.04928893e-01f, 3.40118498e-01f, -6.25244677e-02f,
  3.26989025e-01f, 1.99720696e-01f, -1.44252732e-01f, -6.06821664e-02f, -5.14456555e-02f, 3.80936384e-01f, 8.50764215e-02f, 8.28848705e-02f, 1.32898539e-01f, -9.67194736e-02f,
  -2.58220345e-01f, -9.50240195e-02f, -4.18166459e-01f, 2.61199534e-01f, 2.95040011e-01f, -7.86382928e-02f, 4.17219251e-01f, 1.33892357e-01f, -3.03260326e-01f, -3.17376316e-01f,
  1.34062931e-01f, 6.12310283e-02f, -7.03097694e-03f, -1.77384719e-01f, -2.51665562e-01f, 1.07211443e-02f, 1.57687932e-01f, 1.19568616e-01f, -1.62697211e-01f, 3.76579575e-02f,
  9.24496800e-02f, -1.04681686e-01f, 3.16456556e-02f, -1.09024331e-01f, 7.71612525e-02f, 6.54197186e-02f, 1.70879364e-02f, 8.96843523e-02f, 4.47690412e-02f, 7.53515819e-03f,
  -3.58688086e-01f, -2.24244166e-02f, 8.91014934e-02f, 6.45060558e-04f, 6.20834887e-01f, -2.82220185e-01f, -4.15683657e-01f, 3.38357270e-01f, -5.63796878e-01f, -1.65858746e-01f,
  6.39881119e-02f, 3.44172537e-01f, 5.78251705e-02f, -1.46450937e-01f, 2.25045592e-01f, -1.84718415e-01f, 5.53433955e-01f, 8.34222808e-02f, -1.94928020e-01f, 1.35559604e-01f,
  1.28917530e-01f, 3.50857764e-01f, 2.35257462e-01f, -1.15262955e-01f, 1.74448818e-01f, 1.48875713e-01f, -1.85862869e-01f, 1.61781147e-01f, 1.36680797e-01f, 3.60263497e-01f,
  -1.75321892e-01f, 5.97306527e-02f, 2.93628573e-01f, 8.51040110e-02f, -5.03708236e-02f, -1.74102941e-04f, -2.48996317e-01f, -7.06273094e-02f, 3.76470983e-02f, -3.00546676e-01f,
  3.62939090e-01f, 1.13581449e-01f, -1.41356736e-01f, -4.63242322e-01f, -3.26219469e-01f, 1.69840008e-01f, -1.57469705e-01f, 5.00928104e-01f, -2.24131905e-02f, 3.93654168e-01f,
  3.85580987e-01f, 3.28120351e-01f, 1.69017807e-01f, 1.47770554e-01f, -1.97517321e-01f, 3.29070166e-02f, 1.15954801e-01f, 1.88063875e-01f, 3.11799318e-01f, 2.80569851e-01f,
  6.07746169e-02f, -1.16513856e-01f, -1.13049567e-01f, 1.70967430e-01f, -2.30043922e-02f, 5.26978299e-02f, 1.98483273e-01f, 1.07177690e-01f, -8.19411874e-02f, 1.77584603e-01f,
  7.45389014e-02f, -4.20896858e-01f, -2.76897609e-01f, -2.66909063e-01f, 1.37122869e-01f, -2.14121714e-01f, -2.75796324e-01f, -1.21390246e-01f, 1.57712981e-01f, 2.54469931e-01f,
  1.24635585e-01f, 5.34591734e-01f, 3.06155905e-02f, -2.68760528e-02f, 1.74873933e-01f, -7.24846646e-02f, 6.42617717e-02f, 1.04802914e-01f, 1.44058093e-01f, 7.82130100e-03f,
  2.58189797e-01f, 1.58925995e-01f, 3.39059889e-01f, 2.66624629e-01f, 1.64980471e-01f, 3.01425189e-01f, -7.11331293e-02f, -1.87929079e-01f, 1.28282517e-01f, -1.30249724e-01f,
  -1.05116099e-01f, -4.34418380e-01f, 7.36952499e-02f, 3.90377752e-02f, 1.60448939e-01f, -5.48545361e-01f, 3.19858082e-02f, 6.81239879e-03f, 3.26784141e-02f, 4.95835006e-01f,
  3.70400190e-01f, 3.85978162e-01f, -1.68704376e-01f, -5.49989522e-01f, -8.12789202e-02f, -9.48983729e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  3.29902023e-01f, 2.67978430e-01f, 2.43518040e-01f, -4.95244330e-03f, 1.88272119e-01f, -7.12543726e-02f, 1.04116239e-01f, 1.56650797e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.13932125e-01f, 1.24483511e-01f, -1.01296604e-01f, 1.43015057e-01f, 4.98070978e-02f, -2.77280718e-01f, 2.42992304e-02f, -2.25222230e-01f, -1.55875325e-01f, 7.82040060e-02f,
  -1.42307356e-01f, 4.14333958e-03f, 1.33720338e-01f, 1.51742578e-01f, -4.03641723e-02f, -3.41179073e-01f, 5.73230609e-02f, 4.55736816e-01f, 1.02905817e-01f, 2.35814661e-01f,
  2.07587238e-02f, 4.28710103e-01f, 5.88769950e-02f, -3.86829786e-02f, 5.55311814e-02f, 2.67202556e-01f, 2.22449213e-01f, 2.94891953e-01f, -9.07372013e-02f, 3.04826826e-01f,
  2.48902008e-01f, 1.87994629e-01f, -8.13707560e-02f, 1.12043783e-01f, -1.18119307e-01f, -2.30179299e-02f, -2.08135113e-01f, 3.60843316e-02f, -1.57339126e-01f, 2.42683738e-02f,
  1.26354173e-01f, -2.90026702e-02f, -9.51104909e-02f, -8.33839737e-03f, -2.12357700e-01f, 1.75586864e-01f, 1.22513145e-01f, -2.54255533e-01f, -1.98782101e-01f, -2.46970460e-01f,
  4.55126286e-01f, -1.63095400e-01f, -9.66485217e-02f, -1.03811428e-01f, 2.33600274e-01f, -2.24870160e-01f, 3.45678538e-01f, 2.76316926e-02f, -2.59644955e-01f, -3.81015725e-02f,
  5.53478580e-03f, 3.37068200e-01f, 5.01098186e-02f, -5.07547259e-02f, 2.59060293e-01f, 1.40412003e-01f, 1.47357602e-02f, 6.81262314e-02f, 1.13689527e-01f, 1.32067516e-01f,
  2.57576108e-02f, -3.16900343e-01f, 2.05959976e-01f, 1.20592616e-01f, 1.03306174e-02f, 2.90646166e-01f, -6.68333992e-02f, 6.94905519e-02f, -6.19419180e-02f, -2.90285468e-01f,
  3.79205078e-01f, 2.22008482e-01f, -9.74174067e-02f, 4.53569293e-01f, 1.45131811e-01f, -9.99274012e-03f, -2.93319166e-01f, -1.34949520e-01f, 5.23809977e-02f, -2.19805107e-01f,
  2.20669672e-01f, -3.15433405e-02f, 1.27837718e-01f, 2.10677177e-01f, 4.01333928e-01f, -1.74455702e-01f, 5.82242105e-03f, -2.04873383e-02f, -1.68496370e-01f, 2.93977708e-01f,
  -9.84075218e-02f, -2.93921500e-01f, -2.36153573e-01f, -1.68808177e-01f, 3.30433220e-01f, 1.45597816e-01f, 2.26238191e-01f, 4.49344441e-02f, -3.75299811e-01f, 4.58554000e-01f,
  -3.27851713e-01f, -3.62393707e-01f, 2.09979028e-01f, 2.92311877e-01f, -1.38983369e-01f, -2.83437520e-02f, 1.17412493e-01f, 3.02991748e-01f, 4.61486816e-01f, -1.11004844e-01f,
  8.45554695e-02f, -4.81853560e-02f, -8.79149437e-02f, -2.36269325e-01f, -2.30496243e-01f, 1.92867696e-01f, 3.58742982e-01f, -1.80094019e-01f, 1.01375096e-01f, -2.17813794e-02f,
  1.24336302e-01f, 1.38749868e-01f, -2.37798855e-01f, 2.58444905e-01f, -8.37419927e-02f, 2.91423500e-01f, 8.67376551e-02f, -6.79103732e-02f, -1.85538121e-02f, -2.01130316e-01f,
  4.75379042e-02f, 1.28336236e-01f, -2.05540776e-01f, -1.91523343e-01f, 4.12916154e-01f, -1.17330387e-01f, -1.13876507e-01f, -2.91822731e-01f, 2.45989695e-01f, -8.24402571e-02f,
  -3.93848985e-01f, 4.82228905e-01f, -1.47489995e-01f, -5.05075455e-02f, 4.29625660e-02f, 3.68181020e-01f, -3.82131368e-01f, 2.92843610e-01f, -7.68043101e-02f, 8.01509246e-02f,
  1.48224398e-01f, 7.79057145e-02f, -1.92303464e-01f, 7.29245171e-02f, -6.32656366e-02f, -1.61111161e-01f, 1.97014138e-01f, -3.10648173e-01f, 1.26614058e-02f, 1.36125043e-01f,
  -2.50533283e-01f, 2.15244666e-01f, -2.04324841e-01f, 8.45669210e-02f, 8.99948329e-02f, 3.07577550e-01f, 1.81710511e-01f, -8.10447410e-02f, 1.19728716e-02f, 5.10131836e-01f,
  1.71754301e-01f, 7.66346871e-04f, -2.29907632e-01f, -3.38199079e-01f, -3.75677012e-02f, 1.31295528e-02f, 1.20629914e-01f, -1.67153955e-01f, 4.25097406e-01f, -2.18722329e-01f,
  1.86391830e-01f, -6.51938170e-02f, -9.87843052e-02f, 9.31420550e-02f, -2.12958857e-01f, 2.63655663e-01f, -6.47730380e-02f, -1.96317360e-01f, -1.01598099e-01f, -1.79844394e-01f,
  1.52364925e-01f, 9.52791497e-02f, -2.78975844e-01f, 2.43086349e-02f, 1.21856749e-01f, -6.62333444e-02f, -2.33067006e-01f, -1.09103642e-01f, 3.01620364e-01f, 1.54781669e-01f,
  -1.26684025e-01f, 4.27229881e-01f, 4.11515504e-01f, 9.05353650e-02f, -4.01742905e-01f, -2.12685704e-01f, -1.46090388e-01f, -3.89215022e-01f, 2.08034590e-01f, -1.73775345e-01f,
  -1.23145960e-01f, 1.60306767e-01f, 2.43127272e-01f, 5.31377271e-02f, -1.20400637e-01f, 7.21394420e-02f, -2.36912638e-01f, 5.22577874e-02f, 3.07995956e-02f, 5.16740829e-02f,
  3.06583438e-02f, 1.30809069e-01f, -1.27161846e-01f, -2.97945868e-02f, -1.86303362e-01f, -1.74404413e-01f, 4.87130642e-01f, 5.24852201e-02f, -4.15483510e-06f, -1.04216583e-01f,
  -1.31681412e-01f, 4.16206658e-01f, -3.11024904e-01f, 9.68406871e-02f, 2.45326966e-01f, 3.47830564e-01f, -2.55512185e-02f, 4.98475470e-02f, -2.38268211e-01f, 2.83086121e-01f,
  1.40906587e-01f, 1.20452926e-01f, -2.10963562e-01f, 3.21337551e-01f, -1.64324678e-02f, 1.56578466e-01f, -8.33314732e-02f, 1.91103056e-01f, -7.23279640e-03f, -1.64496213e-01f,
  -4.31642868e-02f, 6.93203416e-03f, 1.32235782e-02f, 2.07506910e-01f, -9.30652097e-02f, -2.18061298e-01f, 1.61148518e-01f, -3.51852700e-02f, -1.28978327e-01f, -2.60789782e-01f,
  2.97942936e-01f, 4.14162636e-01f, -2.01719254e-01f, -4.42141652e-01f, 2.16422051e-01f, 4.54833312e-03f, -1.88814998e-01f, 8.57735611e-03f, 3.50168161e-03f, -2.17946190e-02f,
  -6.40701950e-02f, 7.93764368e-02f, -1.56081831e-02f, 7.78729841e-02f, 3.14039707e-01f, -2.36530513e-01f, -4.29295629e-01f, 1.30572245e-01f, 2.32737422e-01f, 1.00184098e-01f,
  -1.12389937e-01f, -2.97140777e-01f, 4.06619161e-02f, 3.36303741e-01f, 3.08465421e-01f, -1.59195010e-02f, 2.93868780e-02f, -1.34045556e-01f, -1.63184345e-01f, -2.74598360e-01f,
  6.31321818e-02f, 8.52054916e-03f, 3.79702896e-02f, 6.53430596e-02f, -8.83364230e-02f, -5.41759372e-01f, 3.78665775e-01f, 1.20964229e-01f, -1.45835400e-01f, -1.78607360e-01f,
  -2.42104620e-01f, 3.69818002e-01f, 2.24013433e-01f, 7.89748356e-02f, -7.45750591e-02f, 1.72082454e-01f, -9.52272117e-02f, 2.00245351e-01f, -2.39605531e-01f, -3.54363352e-01f,
  -1.38125017e-01f, -1.24944620e-01f, 3.36886756e-02f, 8.47895630e-03f, 9.20914561e-02f, -5.08040972e-02f, -2.23650411e-01f, 4.52517308e-02f, 8.37211534e-02f, -1.87707275e-01f,
  3.45870703e-01f, -1.55653521e-01f, 1.50895864e-02f, 1.24361597e-01f, -1.18280753e-01f, -1.83635488e-01f, -4.09654468e-01f, -1.80991799e-01f, 2.21091717e-01f, -3.70465964e-01f,
  -3.06801289e-01f, -1.63582951e-01f, 5.70301950e-01f, 8.24341625e-02f, 1.16497958e-02f, 3.00220728e-01f, -9.57008973e-02f, 1.75467998e-01f, -2.47434512e-01f, 4.81809527e-02f,
  -1.95270613e-01f, -8.30109715e-02f, -2.03036323e-01f, 1.55581176e-01f, -1.72119457e-02f, 1.83541954e-01f, -7.19356090e-02f, -2.30758358e-03f, -2.90929526e-01f, -2.13360377e-02f,
  -4.75199521e-02f, 3.73190641e-02f, 3.63012441e-02f, 2.73070782e-01f, -3.71396720e-01f, 4.16183025e-01f, 3.19685191e-01f, -2.84543514e-01f, 4.79503907e-02f, -1.42656416e-01f,
  5.33213735e-01f, -4.58713233e-01f, 1.94508247e-02f, 4.79867876e-01f, 6.34370863e-01f, 1.80425808e-01f, 5.39751053e-02f, 2.90259808e-01f, 9.93801728e-02f, 9.04616043e-02f,
  8.31974596e-02f, 1.25494108e-01f, -4.06901445e-03f, -1.89894773e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -2.11770758e-02f, 2.18727887e-01f, -3.49114202e-02f, 2.57211983e-01f, -9.29301828e-02f, 1.75058752e-01f, 1.42433584e-01f, 3.87927778e-02f, 1.82810053e-01f, 1.57686591e-01f,
  1.68903917e-01f, 2.50765026e-01f, -3.29226851e-01f, 3.24662209e-01f, 4.48886573e-01f, -5.60698137e-02f, -1.67729050e-01f, -3.71096373e-01f, 4.44249421e-01f, -5.56062341e-01f,
  -5.20143732e-02f, 8.83166641e-02f, 6.42543375e-01f, -7.10743591e-02f, 4.28863138e-01f, 1.06697880e-01f, 8.75045806e-02f, 1.03097580e-01f, 2.00715244e-01f, 4.43723530e-01f,
  4.23571467e-01f, -1.98316619e-01f, 3.20411980e-01f, 8.14769324e-03f, 6.06701136e-01f, 2.78648958e-02f, 1.09729178e-01f, 3.38030487e-01f, 5.92800796e-01f, 3.47892940e-01f,
  2.07484975e-01f, 4.80879456e-01f, 4.31551695e-01f, 4.94978160e-01f, 8.92552063e-02f, -2.89083958e-01f, -3.44096780e-01f, 1.06398530e-01f, 2.50079930e-01f, 1.65096357e-01f,
  -2.37802073e-01f, 4.02698554e-02f, -3.11224729e-01f, -2.06134945e-01f, 1.19155154e-01f, -2.71551877e-01f, 3.51766855e-01f, -4.70493026e-02f, -1.69391572e-01f, 1.34705096e-01f,
  1.42519772e-01f, 2.13286094e-02f, 2.07287580e-01f, -1.04198359e-01f, 3.14552695e-01f, 1.75240204e-01f, 4.21410412e-01f, -1.56196401e-01f, 4.94675413e-02f, 2.39660546e-01f,
  3.29371661e-01f, 3.45490724e-01f, 8.89970064e-02f, 2.16587663e-01f, 1.14647679e-01f, -8.55175033e-02f, 3.19316328e-01f, -4.67035055e-01f, -4.55184188e-03f, 1.55259687e-02f,
  6.38225600e-02f, -2.96398968e-01f, 1.37455806e-01f, -9.73378122e-02f, -2.48684183e-01f, -1.95035607e-01f, -2.60167480e-01f, 2.35437423e-01f, 1.73102036e-01f, -1.30971208e-01f,
  -6.83332011e-02f, 4.16055530e-01f, -2.23944318e-02f, 2.00251877e-01f, 8.19509178e-02f, 4.39708726e-03f, 3.30271840e-01f, 3.05081010e-01f, 8.65400955e-02f, -1.19461253e-01f,
  1.73236728e-01f, 7.12486207e-02f, 3.87748122e-01f, -3.30129445e-01f, -2.04867393e-01f, 2.41202623e-01f, -3.94131839e-01f, 3.92830372e-01f, 1.02018334e-01f, -1.27293035e-01f,
  5.59290230e-01f, 4.51983899e-01f, -1.21183425e-01f, 1.23325735e-01f, 2.59777978e-02f, 4.94591266e-01f, 1.84839889e-01f, 3.77817690e-01f, -1.11964151e-01f, -6.38355613e-01f,
  1.14360198e-01f, -1.25264734e-01f, 3.63903552e-01f, -5.02830409e-02f, 6.40914917e-01f, 2.58129463e-02f, 1.70483142e-01f, 1.64873958e-01f, 4.64733869e-01f, 3.31291378e-01f,
  6.46859527e-01f, 2.55283833e-01f, 2.94779897e-01f, 3.07260416e-02f, 1.31571099e-01f, 5.22156298e-01f, 1.12392865e-01f, 4.83645126e-02f, 7.24588633e-01f, 2.90680230e-01f,
  1.53364584e-01f, -2.62101386e-02f, -1.10412061e-01f, -6.83224723e-02f, 2.94466913e-01f, 3.96557182e-01f, -1.58472419e-01f, -3.29736501e-01f, -5.23293138e-01f, 7.34535456e-01f,
  3.60333562e-01f, 8.28106850e-02f, 1.04618324e-02f, 6.86632216e-01f, 2.72808433e-01f, 4.93345112e-01f, -2.51611084e-01f, 4.06860620e-01f, -1.02635168e-01f, 8.44032288e-01f,
  1.40646428e-01f, 8.02147239e-02f, -2.61948053e-02f, -1.88052252e-01f, 1.36054426e-01f, 4.92220610e-01f, 3.07521641e-01f, 8.49495456e-02f, 3.64452511e-01f, -5.95888123e-03f,
  -9.72018484e-03f, 7.45589286e-02f, -1.21828720e-01f, -1.60652429e-01f, 3.39936912e-01f, 1.57134324e-01f, -1.35605097e-01f, -5.00802338e-01f, 3.25141549e-01f, -1.05519541e-01f,
  -1.00073121e-01f, -3.37610513e-01f, -3.36293370e-01f, 3.26679021e-01f, 5.04034638e-01f, 2.70766377e-01f, 3.00593257e-01f, 1.10277876e-01f, 3.34551007e-01f, 2.49103859e-01f,
  -1.24953464e-01f, -3.29361826e-01f, -3.71050477e-01f, 1.67753533e-01f, -5.49727865e-02f, 3.96574885e-02f, 2.19497874e-01f, -1.89280197e-01f, -3.40015709e-01f, -3.25194418e-01f,
  -2.88510531e-01f, -2.89564818e-01f, -1.57320812e-01f, 1.17663182e-01f, 3.29453915e-01f, 2.31916860e-01f, 4.06570613e-01f, 2.53777921e-01f, -2.27923572e-01f, 8.45928267e-02f,
  -3.44771773e-01f, -4.89382781e-02f, 4.06785727e-01f, 4.21348065e-01f, -1.95323691e-01f, -4.44086129e-03f, -2.56736845e-01f, 1.28450260e-01f, 4.65532750e-01f, -6.16251290e-01f,
  2.37058640e-01f, 5.84732369e-02f, 1.98873729e-01f, 4.81411964e-01f, 2.13023767e-01f, 6.53235987e-02f, -4.62495396e-03f, 4.67665046e-01f, 4.93426397e-02f, 2.33592018e-01f,
  -1.09248208e-02f, 2.18920857e-01f, 1.80895716e-01f, -7.74853900e-02f, -1.33324772e-01f, -2.61196494e-01f, 4.69396293e-01f, 3.82779449e-01f, 2.18414947e-01f, -2.85332441e-01f,
  2.78499782e-01f, -8.69397596e-02f, 2.00535551e-01f, -3.27267110e-01f, 1.50640875e-01f, 3.38326246e-01f, -3.26221913e-01f, 3.52159619e-01f, 4.81453955e-01f, 3.61031175e-01f,
  1.63713127e-01f, 3.49256635e-01f, -3.28721225e-01f, 7.77003050e-01f, 2.30180636e-01f, -1.22975565e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  1.72330427e-03f, 4.41747338e-01f, 3.46239418e-01f, 3.02035481e-01f, 2.36304849e-01f, 2.08441570e-01f, 9.98790413e-02f, -4.42937426e-02f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  1.94028690e-01f, 3.63955766e-01f, -5.56977242e-02f, 1.11809373e-01f, 1.10255733e-01f, 2.27948055e-01f, 1.27857849e-01f, 2.35525414e-01f, 1.52296443e-02f, 8.43787715e-02f,
  3.75936786e-03f, 1.67079166e-01f, -9.12493691e-02f, 1.22498021e-01f, -1.38604030e-01f, -7.34123727e-03f, 2.21400216e-01f, -3.17163095e-02f, 2.91863531e-01f, 2.17527911e-01f,
  2.16956884e-01f, 9.56847966e-02f, -2.51764953e-01f, -3.96327347e-01f, -3.03573936e-01f, 2.48346478e-01f, 1.20087132e-01f, -9.10609663e-02f, 7.14718252e-02f, 8.78273323e-02f,
  -1.99347332e-01f, -1.90404892e-01f, 1.04723021e-01f, -1.28812760e-01f, 2.23749593e-01f, -3.82202379e-02f, 2.07404062e-01f, 1.75085425e-01f, 8.92166421e-02f, 2.21291378e-01f,
  -2.22079903e-01f, 6.64468855e-02f, 2.04897344e-01f, -2.03785989e-02f, 3.03058505e-01f, -1.74999833e-01f, 1.04370922e-01f, 1.65368050e-01f, -1.33814707e-01f, -6.05378579e-03f,
  -4.00642902e-01f, 1.95251510e-01f, 4.37166222e-04f, 4.47042547e-02f, 1.66018084e-01f, 2.09365770e-01f, 3.62019181e-01f, -6.91051707e-02f, 1.11019365e-01f, -2.72255503e-02f,
  3.53208721e-01f, 4.12385538e-03f, -3.85644168e-01f, -1.74471498e-01f, 2.72307962e-01f, 1.63917139e-01f, 2.76429266e-01f, 1.62186936e-01f, -1.49855480e-01f, 2.66747683e-01f,
  1.06482133e-01f, 1.10691838e-01f, -1.13709390e-01f, -1.50034666e-01f, 2.17479751e-01f, 2.99134199e-02f, -2.09868997e-01f, -1.25745565e-01f, -1.32487237e-01f, -2.82996714e-01f,
  -1.16320126e-01f, 2.66892761e-01f, -1.27896994e-01f, 5.13422713e-02f, 2.34801978e-01f, 2.50022206e-02f, -2.51009107e-01f, -3.49073797e-01f, -1.64646283e-01f, 3.32409769e-01f,
  4.82761674e-02f, 1.67634428e-01f, 7.89531469e-02f, -9.09646787e-03f, -1.20079376e-01f, -2.45316982e-01f, 2.51879305e-01f, 9.83425006e-02f, 2.37689435e-01f, 6.09467253e-02f,
  1.04134707e-02f, 2.50282623e-02f, 2.91502615e-03f, -9.50384710e-04f, 3.51466596e-01f, -3.11193764e-01f, 1.14417121e-01f, 1.63389713e-01f, -3.13049197e-01f, -1.77486062e-01f,
  -2.65504092e-01f, -4.61508304e-01f, -3.08869481e-01f, 1.31675124e-01f, 8.33334699e-02f, 9.65186115e-03f, 2.83352941e-01f, -1.05628759e-01f, -3.60729694e-01f, -2.34194115e-01f,
  -7.13724643e-02f, 1.21400453e-01f, -6.43475503e-02f, 1.24503821e-01f, -7.99115077e-02f, -6.94770366e-02f, 2.19980180e-01f, -1.57851860e-01f, 6.22518770e-02f, -3.48064788e-02f,
  -1.11111039e-02f, -1.36232242e-01f, 7.27505386e-02f, 7.56955147e-02f, -1.32701248e-01f, 1.35655655e-02f, -8.59347284e-02f, 1.83710381e-01f, 8.25234652e-02f, -2.12526813e-01f,
  -1.78496808e-01f, 1.10812828e-01f, -1.12429261e-01f, 1.93198755e-01f, 2.58076102e-01f, -1.04188934e-01f, -5.76728396e-02f, -2.29436278e-01f, -2.94395477e-01f, 1.26097560e-01f,
  2.84493715e-01f, -1.85969263e-01f, 1.93366274e-01f, -4.71150577e-02f, 5.88651858e-02f, -3.08712482e-01f, 1.95719656e-02f, 1.73970014e-01f, -1.69811934e-01f, -4.56725582e-02f,
  1.26611441e-01f, 1.36217214e-02f, 4.85997051e-01f, 5.55249266e-02f, 6.16853982e-02f, 2.08216935e-01f, -1.96414083e-01f, 2.21959397e-01f, 1.70510292e-01f, 2.62243032e-01f,
  2.70644963e-01f, -2.79209502e-02f, -7.54299536e-02f, -1.42530464e-02f, -3.59248817e-01f, -4.03128803e-01f, 1.09857276e-01f, -3.16798598e-01f, -3.15591246e-01f, 6.89089764e-03f,
  1.53237775e-01f, 1.86967134e-01f, 3.46435100e-01f, -1.45819664e-01f, -1.10439613e-01f, -1.29816338e-01f, 1.87016353e-01f, -1.00134149e-01f, 1.50735974e-01f, 5.70788719e-02f,
  -3.69820386e-01f, 7.69461095e-02f, -4.76207212e-02f, 1.74232498e-01f, -3.21037710e-01f, -2.14204490e-02f, -8.50096866e-02f, 2.04860225e-01f, 9.06756744e-02f, 7.68918470e-02f,
  -2.99659967e-01f, 5.70891052e-03f, -1.05553772e-02f, 3.26900363e-01f, 3.81680787e-01f, 2.49839038e-01f, -1.43836848e-02f, 5.84853232e-01f, -1.28181279e-02f, 3.32313217e-02f,
  4.69243258e-01f, 2.41270468e-01f, -1.58927143e-01f, -2.75218427e-01f, -1.41888022e-01f, -1.07125394e-01f, 9.16300192e-02f, 1.02679819e-01f, 3.23984064e-02f, -8.20983425e-02f,
  1.97999105e-01f, -2.34283686e-01f, -2.95046449e-01f, 6.34056255e-02f, 9.14516896e-02f, -8.53809901e-03f, -2.17715949e-01f, 5.20396465e-03f, -2.02900648e-01f, -1.27953112e-01f,
  3.50688487e-01f, -6.64479509e-02f, -1.17207309e-02f, 1.19021021e-01f, 1.48507521e-01f, 2.25802228e-01f, 9.95388255e-02f, 2.57380515e-01f, 4.62930475e-04f, -2.20228419e-01f,
  -4.64070559e-01f, 3.00260156e-01f, 2.10783377e-01f, 5.46996295e-02f, 3.11886817e-01f, 1.07052632e-01f, -4.37908351e-01f, -6.62308931e-02f, -1.51493717e-02f, 5.00328243e-02f,
  1.99704945e-01f, 2.98241436e-01f, -1.03006706e-01f, -8.76710862e-02f, 1.99896619e-01f, -6.17538355e-02f, 1.57135144e-01f, 2.33944476e-01f, 2.84769922e-01f, 1.26029709e-02f,
  -1.93984658e-01f, 3.67218941e-01f, -1.95488065e-01f, 7.30901510e-02f, -1.05803125e-01f, 3.53798151e-01f, 2.57792205e-01f, 1.28421023e-01f, -9.45050716e-02f, 2.77974814e-01f,
  -4.02642041e-01f, -3.58447164e-01f, 2.43712515e-02f, -1.15205668e-01f, 2.47354686e-01f, 2.34309629e-01f, 9.49227884e-02f, 2.21508637e-01f, -9.65648815e-02f, 2.50971377e-01f,
  6.58261329e-02f, 2.35942855e-01f, 1.61436841e-01f, 3.25297527e-02f, 1.71047971e-01f, 6.17147190e-03f, -3.55660677e-01f, -2.94771552e-01f, -7.21507370e-02f, 1.76664054e-01f,
  -1.17923275e-01f, -3.11063617e-01f, 1.82757407e-01f, -2.18170345e-01f, -2.19437718e-01f, 1.93956107e-01f, 1.90762654e-01f, -2.56264091e-01f, -9.52432230e-02f, 1.95936225e-02f,
  2.45398223e-01f, -4.37357038e-01f, 2.03110084e-01f, 4.48459119e-01f, -2.13124424e-01f, -2.91014135e-01f, -1.48303166e-01f, 3.10444599e-03f, -2.05545351e-01f, -2.23403931e-01f,
  1.49996892e-01f, -1.22637868e-01f, -1.35797366e-01f, 4.16071229e-02f, -1.37125641e-01f, -6.08376898e-02f, -2.52296887e-02f, -7.59885982e-02f, 1.93634152e-01f, -8.67233723e-02f,
  1.81816667e-01f, 3.46426487e-01f, -1.72045961e-01f, 2.84645781e-02f, -6.86646625e-02f, -2.30107620e-01f, 2.26887509e-01f, -8.11135843e-02f, 1.09351486e-01f, 2.51929134e-01f,
  -2.20124036e-01f, 2.05243394e-01f, -3.47006842e-02f, 3.64416718e-01f, -1.32704481e-01f, -1.24917053e-01f, 3.49893153e-01f, 1.44691383e-02f, 8.57636109e-02f, 8.69568959e-02f,
  1.70980632e-01f, 1.58784628e-01f, -3.35122108e-01f, -2.57270366e-01f, -2.75207162e-01f, -1.85731322e-01f, 2.21660510e-01f, 1.55066075e-02f, -8.84699896e-02f, 1.94485724e-01f,
  -3.02864403e-01f, 3.56399447e-01f, -6.50738105e-02f, -1.53696626e-01f, -3.45749646e-01f, -1.59349427e-01f, -7.02003390e-02f, -2.16184512e-01f, 2.25043520e-01f, 1.40428483e-01f,
  -1.55919880e-01f, 1.65903404e-01f, -1.46349967e-01f, 2.10275784e-01f, 3.65840137e-01f, 8.57223496e-02f, 1.36117026e-01f, 2.31013417e-01f, -3.63934487e-01f, 1.70080081e-01f,
  2.36945122e-01f, 3.25441241e-01f, -7.57258460e-02f, -2.23021284e-01f, -3.64536862e-03f, -2.08806440e-01f, -1.21356659e-01f, 2.42156982e-01f, 3.22753377e-02f, 2.98513323e-01f,
  -1.22147456e-01f, -1.96512043e-01f, -1.00535110e-01f, 1.10448569e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -6.11780107e-01f, -3.88009697e-02f, -9.67638373e-01f, 4.52355407e-02f, 1.53114811e-01f, -3.56097668e-01f, 1.77981064e-01f, 6.01990372e-02f, -2.37179145e-01f, -1.75051257e-01f,
  -2.11340934e-01f, 3.73895973e-01f, 2.14203998e-01f, -1.95340097e-01f, 1.81260720e-01f, 6.89996541e-01f, -5.08533791e-03f, 2.56948918e-01f, 1.02131164e+00f, -1.43547924e-02f,
  -9.35677528e-01f, -1.32348403e-01f, -6.01612210e-01f, 3.79163563e-01f, 3.74998182e-01f, 7.44830370e-02f, -5.32507487e-02f, 3.49298745e-01f, -1.26006246e-01f, -6.93975762e-02f,
  4.92401630e-01f, 3.31359088e-01f, -3.46621990e-01f, 4.61611390e-01f, -8.60070661e-02f, 4.17681396e-01f, 3.57786864e-01f, 9.62988809e-02f, -4.02782857e-01f, 5.21840334e-01f,
  2.81748980e-01f, -3.41335952e-01f, 2.15158522e-01f, 1.80565491e-01f, 9.54528511e-01f, -3.80265683e-01f, -1.48254529e-01f, 2.04651996e-01f, -4.67256397e-01f, 1.83073461e-01f,
  6.05499029e-01f, 5.90467215e-01f, 1.92313328e-01f, -6.87630951e-01f, -1.42864630e-01f, 3.32621396e-01f, -3.20107698e-01f, 4.54898953e-01f, 6.40764553e-03f, 3.18312407e-01f,
  8.92625988e-01f, -4.89406794e-01f, 2.14289084e-01f, -2.35199824e-01f, -4.99072403e-01f, -5.17266355e-02f, -2.97004171e-02f, 3.12518895e-01f, 2.97647025e-02f, 4.94184382e-02f,
  -2.51887262e-01f, 5.65867946e-02f, 3.53112817e-02f, 4.51901168e-01f, 1.60913602e-01f, -1.21605635e-01f, 2.16640964e-01f, 5.95361233e-01f, -1.97237059e-01f, 7.56143332e-01f,
  5.98585784e-01f, 1.27434060e-01f, 4.94148076e-01f, 2.35978693e-01f, -6.73157513e-01f, 2.97379047e-01f, 9.26063731e-02f, 6.50441408e-01f, 7.46398985e-01f, 3.10400248e-01f,
  2.39976361e-01f, -7.04769939e-02f, 2.74202526e-01f, 3.87653917e-01f, 1.21402778e-02f, 8.47725749e-01f, -4.50856596e-01f, 5.58651462e-02f, 9.51303393e-02f, 3.54153991e-01f,
  -2.37379730e-01f, 1.06808990e-01f, 2.03020275e-01f, -4.41138029e-01f, -1.29864275e-01f, 1.80062130e-01f, -9.25908387e-02f, -1.91197276e-01f, 3.70923340e-01f, 2.03518897e-01f,
  3.44240338e-01f, 2.75727630e-01f, 7.12147355e-01f, -3.50569338e-01f, 9.94807631e-02f, 3.39128107e-01f, -1.56561896e-01f, -6.10906892e-02f, 9.38461944e-02f, 4.49231207e-01f,
  1.90399304e-01f, -4.06757593e-01f, -1.21793915e-02f, -1.62118942e-01f, 4.49962646e-01f, 2.05596372e-01f, 3.24297071e-01f, 6.87417805e-01f, 4.51884955e-01f, 6.05878174e-01f,
  4.18219328e-01f, -3.17383587e-01f, 5.84754169e-01f, 2.47752085e-01f, 4.77643281e-01f, 7.19395339e-01f, 7.39248812e-01f, 1.29376531e-01f, 1.45249041e-02f, 3.50340605e-02f,
  6.07444383e-02f, -7.07065940e-01f, 5.40408492e-01f, -2.31512293e-01f, 3.32115203e-01f, -3.70939732e-01f, -7.45743930e-01f, 6.80827498e-02f, -6.34982660e-02f, 2.54536748e-01f,
  4.59442213e-02f, -9.57047641e-01f, -1.87263593e-01f, 4.51546818e-01f, 5.70158243e-01f, -3.98863740e-02f, 4.69993263e-01f, 2.55180091e-01f, -1.12657428e-01f, 2.29071230e-01f,
  2.82375813e-01f, -4.63948622e-02f, -5.25031984e-01f, -2.64066905e-01f, 7.81804472e-02f, -9.45989311e-01f, 1.64089590e-01f, -4.31934863e-01f, 3.02789863e-02f, 3.87691498e-01f,
  -5.82724154e-01f, 1.70965463e-01f, -1.45923048e-01f, -1.51963104e-02f, 1.39557570e-01f, -6.60056174e-01f, -8.98722529e-01f, 1.40029669e-01f, 1.79644510e-01f, -3.10677230e-01f,
  5.14919519e-01f, 1.67770147e-01f, -1.94979273e-02f, 4.03717607e-01f, 3.48394126e-01f, 7.77418911e-02f, 1.08553313e-01f, 7.18454242e-01f, -3.97373796e-01f, 6.05149090e-01f,
  5.75837076e-01f, -3.42443138e-01f, -1.68721333e-01f, 8.34555030e-02f, 6.66485250e-01f, 4.99641597e-01f, -3.82407933e-01f, 4.26990211e-01f, 4.10903364e-01f, -7.05751359e-01f,
  5.03999949e-01f, -6.92761302e-01f, 1.19375929e-01f, -1.29371837e-01f, -2.01553717e-01f, -4.02366668e-01f, -1.71955988e-01f, -8.10363889e-01f, 1.77844107e-01f, 3.83561291e-02f,
  -1.13858402e-01f, -1.38292521e-01f, 2.79607564e-01f, -5.01263201e-01f, -3.07762861e-01f, 4.79563534e-01f, -9.57339108e-02f, -5.01165152e-01f, -1.25296935e-01f, 1.49951503e-01f,
  4.46439773e-01f, -1.47425354e-01f, 8.13356638e-01f, 4.01394695e-01f, -1.06536314e-01f, 1.66776747e-01f, 2.61769015e-02f, 1.60569157e-02f, -1.01021737e-01f, 3.16703022e-02f,
  -1.36373460e-01f, 1.02339163e-01f, -9.32871401e-02f, -1.21536002e-01f, 1.64377660e-01f, 1.78969428e-02f, 2.07589865e-02f, -1.52617469e-01f, 1.11124061e-01f, 6.47003204e-02f,
  2.68175546e-02f, 8.86000693e-02f, -8.61196667e-02f, 8.40439573e-02f, 1.68434486e-01f, -5.51035479e-02f, 6.13965793e-03f, -6.35265559e-02f, 1.25606460e-02f, -6.84623495e-02f,
  -1.07620120e-01f, -1.02486275e-01f, -1.67214990e-01f, -2.40015332e-02f, -8.83530732e-03f, 4.42281030e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  2.01146469e-01f, 3.54922533e-01f, 4.62438948e-02f, 2.24863198e-02f, 3.51560295e-01f, 2.75566131e-01f, 2.91469336e-01f, -1.63074434e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  4.00165498e-01f, -3.28119367e-01f, -1.44617334e-01f, 5.12146890e-01f, 2.81927198e-01f, 3.60006213e-01f, 1.72694877e-01f, 7.27502480e-02f, -3.79474372e-01f, -4.78281826e-01f,
  4.63617086e-01f, 1.04304492e-01f, -3.40390384e-01f, 2.74114788e-01f, 5.66266537e-01f, 1.25024393e-01f, 7.50348210e-01f, 6.12147808e-01f, -6.63525879e-01f, 6.05576515e-01f,
  -2.79272735e-01f, 6.28249049e-02f, -6.29677653e-01f, -7.74113297e-01f, -6.26425028e-01f, -5.19395411e-01f, 3.39449465e-01f, -3.12670946e-01f, -5.18271744e-01f, 3.93352091e-01f,
  -6.84604347e-01f, 1.65295601e-01f, 3.16442579e-01f, 3.61000508e-01f, -2.28565022e-01f, 2.02245727e-01f, 1.79985359e-01f, 2.62800574e-01f, 1.78407699e-01f, -5.41684747e-01f,
  1.68921486e-01f, 2.69566812e-02f, -1.79698288e-01f, 4.55898196e-02f, 4.24970269e-01f, -2.16111183e-01f, 2.09252149e-01f, 3.87654245e-01f, -4.70099300e-01f, -4.97091681e-01f,
  -3.17855448e-01f, -1.85733974e-01f, 4.72770810e-01f, -4.80124623e-01f, 5.19925773e-01f, 6.16752684e-01f, -1.19396776e-01f, -3.76098573e-01f, -4.86896068e-01f, -2.42989033e-01f,
  6.20130785e-02f, 6.68304384e-01f, -4.70130652e-01f, -5.03240302e-02f, -5.37235498e-01f, 1.76810086e-01f, -5.96602187e-02f, 1.32701084e-01f, 2.09894910e-01f, -2.30237275e-01f,
  3.23222965e-01f, -3.20457846e-01f, 2.79758871e-01f, 2.01909170e-01f, 1.70859545e-01f, -2.27787018e-01f, -2.53817111e-01f, -2.71103352e-01f, -5.26305318e-01f, -3.17119539e-01f,
  -3.39000642e-01f, -1.53403878e-01f, 2.16462746e-01f, 2.07862958e-01f, -4.72007543e-01f, -1.79757476e-01f, 1.11013003e-01f, 2.89568663e-01f, 3.86290312e-01f, -8.07486057e-01f,
  2.32713342e-01f, -1.29726112e-01f, -8.15590918e-01f, 1.70000017e-01f, -3.23130667e-01f, -3.01457848e-02f, 2.45043233e-01f, -3.01403373e-01f, -2.48697132e-01f, -3.82007211e-01f,
  -4.26666528e-01f, 4.36220109e-01f, 3.21931601e-01f, -1.86500818e-01f, -7.71248862e-02f, 4.48367208e-01f, -1.78858861e-01f, 1.75552607e-01f, 2.22750917e-01f, 1.69456359e-02f,
  -3.38273287e-01f, 3.18982750e-01f, -4.68543053e-01f, 2.29251429e-01f, 2.71682322e-01f, 3.41538459e-01f, 4.14303243e-01f, -2.39734463e-02f, -3.95658374e-01f, 3.53874177e-01f,
  -6.98081613e-01f, 3.14756840e-01f, -8.70001733e-01f, -1.78759232e-01f, 1.43570706e-01f, -5.27335405e-01f, 5.35770416e-01f, -1.02589704e-01f, 5.71970701e-01f, -2.65957713e-01f,
  5.08070886e-01f, 1.17115222e-01f, 2.50614226e-01f, -3.10776353e-01f, 1.51784822e-01f, 1.38401911e-01f, -4.07322913e-01f, -1.45609215e-01f, 2.57155806e-01f, 7.28402957e-02f,
  1.48408830e-01f, -7.50399232e-01f, 2.78901726e-01f, -7.48557866e-01f, 2.23783832e-02f, 1.61475703e-01f, 2.99659789e-01f, -3.50229144e-01f, 3.49783991e-03f, -3.42887819e-01f,
  -1.24063091e-02f, -5.07620454e-01f, -1.03015804e+00f, 1.56623378e-01f, 1.50015786e-01f, 2.72953570e-01f, -5.68314455e-03f, -5.67863345e-01f, -1.31072491e-01f, -9.67730805e-02f,
  -4.43423182e-01f, 1.17168151e-01f, -4.52126831e-01f, 4.16885763e-01f, 2.15997174e-01f, -3.25396448e-01f, 2.29564056e-01f, 2.18815103e-01f, -2.49459222e-01f, 2.30965674e-01f,
  3.43119241e-02f, 1.45816337e-02f, 3.90338600e-01f, 4.53488588e-01f, 2.12738931e-01f, 4.07364815e-01f, 4.88296539e-01f, 2.84701407e-01f, -5.06839752e-01f, -3.54734547e-02f,
  3.61391008e-01f, -3.60178053e-01f, 3.46005470e-01f, -3.60217899e-01f, -3.81435692e-01f, -6.13672376e-01f, -1.91384494e-01f, -2.99640626e-01f, 7.49295354e-01f, -4.67809618e-01f,
  -5.18505156e-01f, 1.52883098e-01f, 4.36915606e-01f, 3.11998324e-03f, 5.24463356e-01f, -4.20575023e-01f, 2.60751694e-01f, 5.19894660e-01f, -6.56897366e-01f, 2.24522516e-01f,
  -1.01231560e-01f, -1.93006650e-01f, -6.90205812e-01f, -9.15233865e-02f, 1.40617386e-01f, 6.05191290e-01f, -2.08527207e-01f, -3.30750853e-01f, 1.45301178e-01f, -1.19034790e-01f,
  -9.66925174e-02f, 6.04934216e-01f, 4.41761374e-01f, -5.63936494e-03f, 3.25262845e-01f, 7.56624520e-01f, 1.95927158e-01f, -3.86170417e-01f, 3.18993330e-01f, 1.98897541e-01f,
  -3.12224180e-01f, -6.53187752e-01f, -4.62314934e-01f, 8.88957083e-02f, -3.15050274e-01f, -2.65691221e-01f, -2.33035475e-01f, -2.51934648e-01f, -2.07987696e-01f, -4.18716729e-01f,
  2.12542489e-01f, -1.97952285e-01f, 3.57620001e-01f, -1.95310488e-01f, -4.70616788e-01f, -4.76430446e-01f, -4.45658527e-02f, 3.30174088e-01f, -1.98497713e-01f, -2.83212781e-01f,
  2.23370597e-01f, 4.77670580e-02f, -3.58300626e-01f, -2.51668483e-01f, -2.25908548e-01f, -7.45206922e-02f, 1.43521652e-01f, -2.01545179e-01f, -7.07985282e-01f, -1.16947544e+00f,
  2.00241730e-01f, 3.08867007e-01f, -2.32142061e-01f, -4.30098623e-01f, 6.30318880e-01f, -1.07578561e-02f, -2.55217940e-01f, -8.46636593e-02f, 1.67630970e-01f, -2.71656007e-01f,
  -3.39974582e-01f, -2.85956442e-01f, -2.50323623e-01f, -6.82669058e-02f, -6.64185360e-02f, 6.49351999e-02f, -6.91030361e-03f, 5.67190386e-02f, -2.65499324e-01f, -3.93529087e-01f,
  -4.77927744e-01f, 5.81863262e-02f, 3.46699327e-01f, -3.95633280e-03f, -5.19913614e-01f, 3.81286032e-02f, -2.71884859e-01f, 2.60392994e-01f, -3.05576622e-01f, 9.29472670e-02f,
  2.80887455e-01f, 4.22355300e-03f, -6.44235969e-01f, -1.14869393e-01f, -6.08817160e-01f, 3.69938970e-01f, 2.27809832e-01f, 3.46974768e-02f, -3.88269663e-01f, -2.91002225e-02f,
  -1.78685740e-01f, -3.67898017e-01f, -6.91255271e-01f, 1.09220654e-01f, -1.45106882e-01f, -2.78928757e-01f, 4.30942982e-01f, 2.27309674e-01f, 4.37719941e-01f, 5.05135834e-01f,
  -5.05976737e-01f, -6.21590018e-01f, -5.74955523e-01f, 4.25739408e-01f, 2.46737987e-01f, 4.00491178e-01f, 5.35987377e-01f, -6.00647449e-01f, -8.55013654e-02f, -3.37416589e-01f,
  -7.58671612e-02f, -2.06132531e-01f, -1.92254245e-01f, -1.09942102e+00f, 2.80589283e-01f, 2.52896786e-01f, 1.26207456e-01f, -4.32861239e-01f, -6.90911829e-01f, -1.09487988e-01f,
  8.70736390e-02f, 3.49810839e-01f, -8.93274024e-02f, 1.19229481e-01f, 1.83146268e-01f, -4.49101686e-01f, -3.64885151e-01f, 2.68748045e-01f, 3.25639755e-01f, 2.44897649e-01f,
  1.52878612e-01f, -2.95558274e-01f, 3.13868374e-01f, 3.67127508e-02f, 5.21742880e-01f, 2.26904109e-01f, -4.06563222e-01f, -4.96234775e-01f, 3.13188016e-01f, 2.72120476e-01f,
  -3.52049708e-01f, 6.49441063e-01f, -4.83083487e-01f, 2.87018687e-01f, 2.78066695e-01f, 5.04162550e-01f, -1.75134480e-01f, -6.52786553e-01f, 8.78652185e-03f, -2.72928566e-01f,
  -6.93299353e-01f, -1.01246446e-01f, 5.19271046e-02f, 3.90783042e-01f, 2.44536728e-01f, 2.98100531e-01f, -1.73483387e-01f, -1.46811783e-01f, -5.71389608e-02f, 3.09992015e-01f,
  2.61293590e-01f, 3.24249506e-01f, -4.65079844e-02f, -1.70999561e-02f, -4.53576982e-01f, -1.79593593e-01f, -3.50586414e-01f, -1.36446491e-01f, -5.06003320e-01f, -4.27095473e-01f,
  3.22530210e-01f, 7.45765492e-02f, -5.93038619e-01f, 1.89572930e-01f, -4.55788314e-01f, -4.11746085e-01f, 5.43181449e-02f, -1.41294822e-01f, -6.37982488e-02f, 2.32989699e-01f,
  -5.28370559e-01f, -5.41744947e-01f, 4.98920649e-01f, 1.29031420e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.64759353e-01f, 5.86358719e-02f, -1.56961195e-02f, 1.62034079e-01f, -9.72726122e-02f, 2.09930182e-01f, -4.26306315e-02f, -1.90555617e-01f, -5.19812293e-02f, 1.88929588e-02f,
  -5.18893152e-02f, -2.85695970e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    