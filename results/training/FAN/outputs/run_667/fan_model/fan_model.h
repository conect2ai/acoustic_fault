/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.55285347e-01f, 1.29970655e-01f, 3.69664207e-02f, 1.22118026e-01f, 2.24630430e-01f, 4.64236587e-02f, 5.12663499e-02f, 1.98715995e-03f, 6.04880415e-02f, 3.69331427e-02f,
  2.08334863e-01f, 6.20386042e-02f, 1.46649720e-03f, 7.47561455e-02f, -1.12434760e-01f, -9.18320864e-02f, -5.51196337e-02f, -3.29821110e-02f, -2.36456424e-01f, -2.52930187e-02f,
  5.28829470e-02f, 9.74739343e-02f, -1.01444826e-01f, 3.53916772e-02f, -1.39405420e-02f, -1.15682349e-01f, 1.11101627e-01f, 2.59908494e-02f, -3.16460580e-02f, -7.05322772e-02f,
  -2.21498236e-01f, 1.09063581e-01f, 4.93034609e-02f, -9.39550065e-03f, 1.31494939e-01f, -8.57726038e-02f, -2.67179515e-02f, 6.77049980e-02f, 1.28595814e-01f, -8.29981174e-03f,
  -1.33816653e-03f, 5.93432114e-02f, 2.83828042e-02f, 9.76238400e-02f, 4.29541208e-02f, -9.03467834e-03f, 1.29050165e-01f, 7.80903026e-02f, -1.92984939e-02f, -1.39610963e-02f,
  8.21600407e-02f, 1.22594744e-01f, -6.98660687e-02f, 6.06778823e-02f, 5.11807390e-02f, -1.04668848e-01f, 5.14549948e-02f, -1.20652772e-01f, -1.18934527e-01f, -1.75523236e-01f,
  1.09985313e-05f, -1.38167683e-02f, -3.14853042e-02f, 2.85612326e-02f, 5.20762280e-02f, 7.63059687e-03f, -2.95552816e-02f, 2.10920029e-04f, 7.87329767e-03f, -1.46399051e-01f,
  5.36323600e-02f, -5.64764254e-02f, 2.71889661e-03f, -7.78200254e-02f, -6.32875040e-02f, -5.37390225e-02f, -7.70522421e-03f, -6.98514506e-02f, 5.09353988e-02f, 1.75473175e-03f,
  4.53380868e-03f, -4.88676690e-02f, 6.47953227e-02f, -1.45527069e-02f, -8.32463950e-02f, -6.67520314e-02f, -4.60524261e-02f, -9.01524797e-02f, -1.08690538e-01f, -4.77264151e-02f,
  -1.94451854e-01f, 2.78782487e-01f, -1.64465114e-01f, -9.69386324e-02f, -5.28732352e-02f, 3.56643237e-02f, 2.48123538e-02f, 8.88408944e-02f, 2.15341710e-02f, 5.86601421e-02f,
  2.38536857e-02f, 3.53422873e-02f, -6.56492189e-02f, 2.56506596e-02f, 4.58794646e-02f, -1.31287932e-01f, -6.46483302e-02f, -5.66458702e-02f, 4.36872244e-02f, 2.76218224e-02f,
  -2.68648677e-02f, -2.36483961e-02f, -3.05129439e-01f, -1.09853990e-01f, -7.04868585e-02f, -1.11462057e-01f, -7.68871382e-02f, -1.86620355e-01f, -2.06247941e-01f, -3.53460640e-01f,
  -2.91970760e-01f, 5.45752235e-02f, -4.61334661e-02f, 3.77120264e-02f, 1.46011323e-01f, 1.25353053e-01f, -1.06910244e-01f, 1.85854938e-02f, 5.33408895e-02f, -1.72346324e-01f,
  1.59091458e-01f, 2.88161486e-01f, 1.93964407e-01f, 3.16734016e-01f, 9.00702700e-02f, -1.90106526e-01f, -5.20577207e-02f, 6.42115921e-02f, 1.51153296e-01f, 2.09490702e-01f,
  2.65817821e-01f, 6.78498223e-02f, 4.22952138e-02f, 3.74811590e-02f, -1.25241950e-01f, 9.17487405e-03f, -1.47168308e-01f, -1.85421351e-02f, -5.34332395e-02f, -2.23854005e-01f,
  -6.42770231e-02f, -1.42730534e-01f, 8.67889151e-02f, 5.91813996e-02f, 1.31002277e-01f, -9.34926141e-03f, 3.35941426e-02f, -6.03626668e-02f, 7.65236542e-02f, 3.31450813e-02f,
  7.78168514e-02f, 1.51926741e-01f, 9.82728004e-02f, 2.03671195e-02f, -5.76000661e-03f, 5.97537681e-03f, 8.70134905e-02f, -1.87934330e-03f, 7.37196133e-02f, -2.89037055e-03f,
  1.29351228e-01f, 1.91235207e-02f, -6.98677376e-02f, 4.27499264e-02f, 1.03910215e-01f, 1.14325963e-01f, -2.05210801e-02f, -8.01388249e-02f, -3.22192088e-02f, -1.79447725e-01f,
  -5.50337434e-02f, 2.13075597e-02f, 6.84901550e-02f, -5.38274013e-02f, -7.20177218e-02f, -5.39386123e-02f, 2.81931348e-02f, -2.96022068e-03f, 1.17181696e-01f, -8.35975036e-02f,
  1.15964085e-01f, -1.35780305e-01f, 7.33044297e-02f, -7.25043789e-02f, 1.98225714e-02f, 6.26658648e-02f, -3.66617069e-02f, 5.57208247e-02f, -5.82120032e-04f, -2.43630465e-02f,
  4.40550372e-02f, -2.97679491e-02f, 7.91547373e-02f, -1.27337724e-02f, -3.05348705e-03f, 1.50936339e-02f, 3.79422903e-02f, 2.32440419e-02f, -8.97587538e-02f, -7.10338238e-04f,
  1.18619718e-01f, 2.63787419e-01f, 3.04050799e-02f, 7.38132745e-02f, 3.91509011e-02f, 7.99261853e-02f, 1.59812104e-02f, 5.38146533e-02f, -3.67302522e-02f, -1.26552917e-02f,
  6.82579027e-03f, -1.82721894e-02f, 4.94653769e-02f, 5.08277565e-02f, 2.76509337e-02f, -5.86435571e-02f, 6.94358498e-02f, 2.82464270e-02f, 8.58649537e-02f, 1.09175973e-01f,
  5.57636060e-02f, -2.60665491e-02f, 1.82471201e-02f, -6.73106760e-02f, -3.69508266e-02f, -3.00397053e-02f, -8.11513141e-02f, -2.67088041e-02f, -7.63675198e-02f, -3.16308171e-01f,
  2.18400941e-03f, 1.77033722e-01f, 9.05841440e-02f, -1.05953768e-01f, -1.54597983e-01f, -1.50056541e-01f, -8.94078538e-02f, -1.77697107e-01f, -6.76357001e-02f, -1.78243686e-02f,
  7.63220638e-02f, -1.16741940e-01f, 2.39607152e-02f, -4.38865013e-02f, -1.17372029e-01f, 1.10602766e-01f, 1.38552621e-01f, -4.37773690e-02f, -3.21781844e-01f, -3.34533453e-01f,
  -1.45006940e-01f, -1.17182836e-03f, 8.21679540e-04f, -7.28544518e-02f, 8.01196620e-02f, -2.21877217e-01f, 2.44373962e-01f, 1.98238254e-01f, 1.96890816e-01f, 4.99095291e-01f,
  2.56465703e-01f, 1.59036964e-01f, -1.02429554e-01f, -4.36031930e-02f, 9.58634615e-02f, -5.23944087e-02f, -1.47384088e-02f, -1.25155295e-03f, 3.84808853e-02f, 6.07536547e-02f,
  -2.67978068e-02f, -8.83763731e-02f, 6.85819387e-02f, 2.57574860e-03f, 7.77978823e-02f, -3.65502723e-02f, 1.95666075e-01f, 1.01492450e-01f, -4.34068218e-02f, 1.66399553e-02f,
  4.28585410e-02f, 4.40853387e-02f, 7.81232715e-02f, 9.84144658e-02f, 9.25878659e-02f, 3.89795378e-02f, 9.20677632e-02f, 9.57080256e-03f, 9.05894861e-02f, 8.99034068e-02f,
  -3.79200689e-02f, 1.99868735e-02f, 9.20466334e-02f, 6.78205714e-02f, 6.51060895e-04f, 4.06956598e-02f, -1.59071404e-02f, 1.87424123e-02f, -8.12417455e-03f, 1.25032794e-02f,
  6.66197762e-02f, -4.35337797e-03f, -4.63274214e-03f, 6.00289553e-02f, 2.12754495e-02f, 6.76277280e-02f, -4.72166799e-02f, 8.58038589e-02f, 6.34718165e-02f, 9.16658193e-02f,
  -3.61539945e-02f, 3.59703042e-02f, -7.87907466e-03f, 2.30981335e-02f, 8.06961507e-02f, 6.96016923e-02f, 8.06549564e-02f, 2.67755997e-04f, -4.90176640e-02f, -2.55737710e-03f,
  -1.43772215e-01f, -1.03431746e-01f, -1.79097969e-02f, -6.71760291e-02f, 8.92499555e-03f, -3.34544852e-02f, 7.08223358e-02f, -4.82118651e-02f, -7.19067501e-03f, -9.18343663e-02f,
  -1.16478845e-01f, -9.45205465e-02f, 8.34155977e-02f, 4.51655164e-02f, -9.33511481e-02f, -5.47271706e-02f, 3.35066505e-02f, -9.92139429e-02f, -1.20136432e-01f, -1.56139918e-02f,
  -1.55991949e-02f, -1.21835344e-01f, -1.94954410e-01f, -1.16159871e-01f, -1.75913330e-02f, -1.81626022e-01f, -1.52340725e-01f, -1.09368451e-01f, -1.54334053e-01f, -2.33620137e-01f,
  -7.86656439e-01f, 3.60853732e-01f, -5.21863848e-02f, -2.23614290e-01f, 1.80883393e-01f, 2.52818555e-01f, 2.00896502e-01f, 3.70061919e-02f, -1.73769638e-01f, 7.25816339e-02f,
  2.72163719e-01f, 1.81763500e-01f, 1.10905275e-01f, 3.63082737e-02f, 3.08702476e-02f, -2.72982996e-02f, -1.29722506e-01f, -3.18977296e-01f, -1.61297619e-01f, -4.60633263e-02f,
  4.47782464e-02f, -1.00947641e-01f, -3.78359228e-01f, -1.11481510e-01f, 5.42226583e-02f, 1.36130765e-01f, -1.29151912e-02f, 7.16381371e-02f, 1.49487108e-01f, -8.73751119e-02f,
  -5.90448454e-02f, -5.98675683e-02f, -1.74697526e-02f, -4.78645638e-02f, 9.95237380e-02f, -1.15683869e-01f, -2.57204417e-02f, -1.15923747e-01f, 7.77902976e-02f, 4.53484878e-02f,
  4.47782315e-02f, -2.48737764e-02f, 9.09642503e-02f, 4.75930609e-02f, 4.08990942e-02f, -5.45121469e-02f, -5.36288023e-02f, -9.71018821e-02f, -1.28490075e-01f, 1.37652177e-03f,
  1.70337528e-01f, 7.59416223e-02f, 1.09069362e-01f, 8.92537758e-02f, -7.56423827e-03f, -1.18382480e-02f, 7.43914694e-02f, 5.91225997e-02f, -1.97762884e-02f, -1.74090475e-01f,
  8.09530355e-03f, -8.26859847e-02f, 4.85007912e-02f, -8.66578817e-02f, -5.36316223e-02f, 4.52445541e-03f, -4.47547212e-02f, 2.66623162e-02f, -4.57424903e-03f, 1.43941483e-02f,
  2.41413787e-02f, -3.66372317e-02f, -7.55956918e-02f, -1.70901977e-02f, 2.23062020e-02f, 2.75206789e-02f, 6.08121641e-02f, -4.26487625e-02f, 6.09186143e-02f, 1.33985337e-02f,
  2.54480075e-02f, 2.90590227e-02f, -5.02586477e-02f, 4.76592965e-02f, 1.77553929e-02f, -7.17590526e-02f, 2.71453690e-02f, -5.34928113e-04f, 4.75955755e-02f, 4.81666736e-02f,
  1.09058641e-01f, 1.78140983e-01f, -1.71008110e-01f, 5.79295978e-02f, -6.19372204e-02f, 1.65882464e-02f, 5.79664782e-02f, 3.93293761e-02f, 2.74539707e-05f, -5.93974665e-02f,
  -4.65675956e-03f, -8.67943466e-02f, 3.80306207e-02f, -8.11229125e-02f, -1.05543949e-01f, -3.10003143e-02f, 3.15166923e-04f, -3.78992446e-02f, -5.98445050e-02f, -4.52261269e-02f,
  -5.88774681e-02f, -1.58303618e-01f, -9.09604803e-02f, -1.04282767e-01f, 1.05516957e-02f, -7.68142566e-02f, -5.35394065e-02f, -6.01387816e-04f, -6.85482025e-02f, -1.60600647e-01f,
  -3.93557176e-02f, 2.25233033e-01f, 1.31751478e-01f, 1.94783524e-01f, 4.93241459e-01f, 2.13749141e-01f, 4.00987923e-01f, 1.21745607e-02f, -5.57183586e-02f, 1.49182484e-01f,
  5.19274920e-02f, -2.16660649e-01f, -2.31557056e-01f, -2.00207338e-01f, -2.17790306e-01f, 2.06528008e-01f, 2.48707116e-01f, -2.16000795e-01f, -1.95683435e-01f, -1.41246483e-01f,
  4.33580652e-02f, 3.54221277e-02f, -1.09739654e-01f, -1.16647251e-01f, -3.81202921e-02f, -1.26372039e-01f, 1.26786595e-02f, 4.91217859e-02f, 4.88143414e-02f, 1.12865709e-01f,
  -1.65860355e-01f, 1.08418822e-01f, 2.05605198e-02f, -7.15649948e-02f, -1.37644482e-03f, -2.74532288e-02f, -3.44377309e-02f, 2.04213597e-02f, 4.50095087e-02f, 2.78421887e-03f,
  1.38622180e-01f, 3.74564598e-03f, -7.03564584e-02f, -8.35863650e-02f, 2.02070363e-02f, -4.65325266e-02f, 8.16020742e-03f, -2.92923898e-02f, 7.80946715e-03f, -8.20115656e-02f,
  9.01805237e-02f, 1.93416223e-01f, 1.36722952e-01f, 3.79831605e-02f, -5.95185384e-02f, -4.25944626e-02f, 4.40031774e-02f, 5.88968135e-02f, -4.38115224e-02f, -2.04719473e-02f,
  3.40297520e-02f, 3.35439630e-02f, 8.55986960e-03f, 8.28294158e-02f, -3.15599293e-02f, 3.31872748e-03f, -1.44567592e-02f, -5.68940490e-02f, -5.52252196e-02f, -4.02998216e-02f,
  1.14888482e-01f, 5.01851784e-03f, 7.16278329e-02f, 5.00103496e-02f, -7.22749671e-03f, 5.35839163e-02f, 1.37912398e-02f, -4.47057821e-02f, 9.02997982e-03f, -7.62268603e-02f,
  -1.14158601e-01f, -4.08776244e-03f, -4.45438782e-03f, -1.28185615e-01f, 2.58069169e-02f, -6.36566058e-02f, 4.24046852e-02f, 1.46326674e-02f, 8.16173926e-02f, 1.19369239e-01f,
  -1.11118935e-01f, 1.92678183e-01f, 2.24058386e-02f, 9.03903134e-03f, -3.10422983e-02f, -1.35542557e-01f, 4.66436846e-03f, 6.44250959e-02f, -1.61727145e-02f, -6.96668774e-02f,
  1.20405257e-02f, -1.18992493e-01f, -2.77147330e-02f, 2.77498998e-02f, 1.19365789e-02f, -1.19477008e-04f, 4.47611138e-02f, 6.73727924e-03f, -4.98835370e-02f, -3.91547233e-02f,
  2.78998911e-02f, 3.94596830e-02f, 4.08340283e-02f, -4.22517806e-02f, -5.92949167e-02f, -7.30658621e-02f, 9.39659541e-04f, 1.04873598e-01f, -1.20189585e-01f, 3.55337150e-02f,
  -3.95501405e-01f, -1.43682733e-01f, 3.10064733e-01f, -1.64482836e-02f, 2.93093413e-01f, 1.08675912e-01f, -2.06132792e-02f, -8.79830420e-02f, 2.90450435e-02f, -1.21247381e-01f,
  1.08896688e-01f, 1.94009006e-01f, 1.12139523e-01f, 5.73916025e-02f, 1.89103168e-02f, -8.45072865e-02f, 1.18436795e-02f, 1.61808193e-01f, 2.59480417e-01f, 6.14325181e-02f,
  7.63858343e-03f, -7.95670077e-02f, 1.21211242e-02f, 1.30894110e-01f, -3.05901784e-02f, -4.18949462e-02f, -4.64474075e-02f, -3.90265584e-02f, 2.33813860e-02f, -8.74961689e-02f,
  1.17072612e-01f, 2.88933106e-02f, 1.43336624e-01f, -8.41088500e-03f, 9.49390382e-02f, -3.28967832e-02f, 3.31785828e-02f, 3.45096998e-02f, 2.65372340e-02f, 5.39376736e-02f,
  1.66595161e-01f, 6.51437715e-02f, 2.09877446e-01f, -5.14383661e-03f, -2.82805040e-02f, 2.01191697e-02f, 5.96499722e-03f, 2.84896437e-02f, 5.94767444e-02f, -4.98079509e-02f,
  3.04408111e-02f, 2.19685957e-01f, 1.12550981e-01f, 1.03771247e-01f, 7.45475069e-02f, 2.58284718e-01f, 8.84001255e-02f, 4.39976826e-02f, 1.75119698e-01f, -2.15598449e-01f,
  -1.40014328e-02f, -3.70283574e-02f, -2.96330377e-02f, -1.09975589e-02f, -1.16301186e-01f, -1.46159166e-02f, 6.75438941e-02f, -3.94598581e-02f, -8.67023543e-02f, -8.01963434e-02f,
  7.43755102e-02f, -1.31894285e-02f, -3.88254598e-02f, -2.82931197e-02f, -4.44564084e-03f, -2.10498292e-02f, -2.61158403e-03f, -1.05919562e-01f, -1.44049469e-02f, -2.97589321e-02f,
  -1.93883739e-02f, 5.05258068e-02f, -4.72706594e-02f, 1.45878932e-02f, -3.91502492e-02f, 2.63941307e-02f, -4.98808436e-02f, -3.40238996e-02f, 3.28742452e-02f, 1.36900442e-02f,
  -2.07140997e-01f, 1.58179060e-01f, -2.12459601e-02f, 2.93768402e-02f, -5.12954891e-02f, 5.11057563e-02f, -1.24912113e-02f, -3.51859182e-02f, 4.44426611e-02f, 6.05538450e-02f,
  5.69217699e-03f, -2.78159231e-02f, 1.04849517e-01f, 4.90618811e-04f, 1.00574285e-01f, 2.58023646e-02f, 2.28775442e-02f, 2.61146594e-02f, -2.47589778e-02f, -4.59555201e-02f,
  1.70646328e-02f, -1.14182837e-01f, 2.85645686e-02f, -7.77455345e-02f, 7.33549222e-02f, -2.80976691e-03f, -1.02560513e-01f, -8.11728537e-02f, -1.28333475e-02f, -2.79870003e-01f,
  -3.03828180e-01f, -4.96350825e-02f, -4.90074381e-02f, -2.23456040e-01f, -1.32027373e-01f, -9.02599096e-03f, 1.18594900e-01f, -5.35766594e-02f, -1.12340346e-01f, 8.69908929e-02f,
  1.73247848e-02f, 6.17654920e-02f, 1.46927044e-01f, 2.53351741e-02f, 2.15285067e-02f, 1.01500742e-01f, 8.99474509e-03f, -8.61870050e-02f, -2.74267703e-01f, -1.61841616e-01f,
  -4.95152697e-02f, -2.43905380e-01f, -2.60611594e-01f, -8.85525793e-02f, -1.62292823e-01f, 8.74984637e-02f, 1.52726993e-01f, -1.44466817e-01f, -8.88794735e-02f, -9.23850387e-02f,
  3.78753334e-01f, -1.89469665e-01f, -7.86306038e-02f, -1.73470899e-01f, -3.75007503e-02f, -6.42991737e-02f, -6.71565486e-03f, -5.20907603e-02f, -1.08189344e-01f, -9.29944292e-02f,
  -4.12704013e-02f, -7.10927770e-02f, -1.84876174e-01f, -5.70912510e-02f, -1.20071165e-01f, -1.22559138e-01f, -2.32727844e-02f, -1.22733504e-01f, -2.59072427e-02f, 2.24357676e-02f,
  -5.97502962e-02f, -1.82029545e-01f, -2.54867017e-01f, -1.40749933e-02f, -4.99996245e-02f, -1.53447822e-01f, -5.91758126e-03f, -1.27942756e-01f, -8.21795389e-02f, 1.03308551e-01f,
  -2.83218548e-02f, 7.66319484e-02f, 4.18259315e-02f, 5.77794388e-02f, 1.01288587e-01f, 5.82531020e-02f, 3.26061659e-02f, 8.42912495e-02f, 8.56929198e-02f, -2.00534500e-02f,
  -7.92394727e-02f, -1.56098502e-02f, 9.31869540e-03f, -2.35466808e-02f, 9.72744375e-02f, 8.26969370e-02f, 7.11606517e-02f, 1.55225277e-01f, 4.47674021e-02f, 2.50350535e-02f,
  -5.69952012e-04f, 8.22595209e-02f, 2.27908306e-02f, 3.94805335e-02f, 3.91434729e-02f, 7.24689215e-02f, 8.17709118e-02f, 5.85765243e-02f, 1.96130350e-02f, 1.89880803e-02f,
  1.25597447e-01f, -1.07028976e-01f, 4.47805226e-02f, -1.44293881e-03f, -1.85254440e-02f, 4.53132242e-02f, 4.02663238e-02f, -1.01222448e-01f, -3.95600945e-02f, -1.97607819e-02f,
  -1.67302743e-01f, -9.06939879e-02f, 4.71392367e-03f, -8.32451209e-02f, -1.21211678e-01f, -4.06450294e-02f, -5.68845309e-02f, -3.42538953e-02f, -6.49113730e-02f, -5.44438809e-02f,
  4.46585901e-02f, -6.16290607e-02f, -2.20204284e-03f, -6.44180104e-02f, -6.28319383e-02f, -3.01461923e-03f, -3.09683420e-02f, -1.73311997e-02f, 3.55295860e-03f, 9.73240435e-02f,
  -4.59873974e-01f, 2.43708029e-01f, 3.15985590e-01f, -2.58940220e-01f, 2.88437456e-01f, 3.41527522e-01f, 5.56719184e-01f, 2.48579830e-02f, -2.63137907e-01f, 6.92991763e-02f,
  -2.64362879e-02f, -2.97928125e-01f, -2.60800093e-01f, -1.73671812e-01f, 8.70180652e-02f, 2.09584594e-01f, 2.24197373e-01f, 1.25199892e-02f, -7.02460036e-02f, 2.57767066e-02f,
  6.87685853e-04f, -6.32466341e-04f, -2.44833678e-01f, -1.38637021e-01f, -7.60290399e-02f, -2.51060307e-01f, 5.25899455e-02f, -6.39475649e-03f, 6.96302876e-02f, -1.13213345e-01f,
  -9.52863693e-02f, -1.93752646e-02f, -1.29458189e-01f, -1.10444926e-01f, -3.99128497e-02f, -4.54454273e-02f, -2.48001479e-02f, -8.76467973e-02f, -4.51898798e-02f, 3.66755351e-02f,
  9.13873501e-03f, -5.83747514e-02f, -7.28981849e-03f, 3.85573953e-02f, 1.01595856e-01f, -2.44769407e-03f, -5.36886118e-02f, -1.30635381e-01f, -2.90846010e-03f, 3.16714942e-02f,
  3.84061672e-02f, 1.03176825e-01f, 2.13817433e-01f, 7.92673752e-02f, 4.18988504e-02f, -4.00713924e-03f, 2.22751107e-02f, -4.53587845e-02f, 8.68745670e-02f, -1.34451121e-01f,
  -4.53076214e-02f, 4.82772365e-02f, 9.62498859e-02f, 1.84866358e-02f, -2.28101518e-02f, 7.08057731e-02f, 2.50319019e-02f, 4.85031120e-02f, 1.84604991e-02f, -5.64808771e-03f,
  -4.44325469e-02f, -2.21669916e-02f, -2.03563925e-02f, 3.90127376e-02f, -3.73952202e-02f, 7.57909566e-02f, 4.53654192e-02f, 1.61698926e-02f, -1.46711012e-04f, -6.53464254e-03f,
  -5.20382077e-02f, -2.23568082e-02f, -1.06686972e-01f, 2.76955292e-02f, -3.66387591e-02f, -4.78632003e-02f, -4.05676030e-02f, -2.32723225e-02f, -2.00581551e-02f, -2.88947974e-03f,
  -2.64685247e-02f, 4.33651283e-02f, -2.26392373e-01f, -1.18195720e-01f, 8.65947604e-02f, -8.20092559e-02f, 1.89028066e-02f, 3.12452279e-02f, -2.85628960e-02f, -6.25864193e-02f,
  -2.21010856e-02f, -6.49999604e-02f, 5.56698628e-02f, 2.45270189e-02f, -3.95738110e-02f, 1.32021448e-02f, 2.86625829e-02f, -7.04447553e-03f, 8.92342255e-03f, -8.69989917e-02f,
  -4.76169446e-03f, 3.14352252e-02f, 5.05822804e-03f, 6.76984563e-02f, -2.72771418e-02f, -8.53059515e-02f, 4.36926037e-02f, -5.79927349e-04f, 3.51394489e-02f, -6.01709355e-03f,
  1.56156540e-01f, -6.25451282e-02f, 3.02901208e-01f, 9.57155898e-02f, 5.26217781e-02f, 4.15508375e-02f, -5.83161637e-02f, -7.37299770e-02f, -1.00275107e-01f, -1.84973329e-01f,
  -1.84406072e-01f, -8.74198005e-02f, -5.24721444e-02f, 4.17333432e-02f, -2.03427505e-02f, -3.63797415e-03f, 1.31724939e-01f, 2.95041978e-01f, 3.60800147e-01f, 4.53219973e-02f,
  6.72617629e-02f, 2.13228077e-01f, 1.64832950e-01f, -1.08277844e-02f, -2.68660244e-02f, 5.34904450e-02f, -3.45923863e-02f, -2.64826398e-02f, 2.85705440e-02f, 1.73222616e-01f,
  9.48376134e-02f, 3.79864089e-02f, 1.10724069e-01f, 2.01452821e-02f, -1.80809107e-02f, -7.27707744e-02f, 2.70405561e-02f, 1.66020580e-02f, -1.00883394e-01f, -3.91220786e-02f,
  -1.52130770e-02f, -1.18943311e-01f, 8.88354052e-03f, 6.52669966e-02f, 4.45608348e-02f, -7.89033249e-03f, 4.67649195e-03f, 5.74405976e-02f, 2.88534146e-02f, -9.24219638e-02f,
  -1.10569708e-02f, 8.12254474e-02f, 9.26946476e-02f, -3.40684839e-02f, -3.30710113e-02f, 7.54730850e-02f, -1.04320347e-01f, -9.96037051e-02f, -1.09988861e-01f, -6.33648261e-02f,
  -1.46709355e-02f, -7.91919604e-02f, 1.47363031e-02f, 4.08116356e-03f, 2.89302766e-02f, -5.04799858e-02f, 7.72312880e-02f, 7.85209611e-03f, 7.41583481e-02f, 2.19669137e-02f,
  4.81002256e-02f, 4.94808815e-02f, 5.95508069e-02f, 6.82418868e-02f, 6.43749237e-02f, 8.38989839e-02f, 2.33344827e-02f, 1.23414785e-01f, 3.51557583e-02f, 6.81251884e-02f,
  6.64101020e-02f, 2.40384638e-02f, 1.05560422e-01f, 4.56386153e-03f, 8.17345232e-02f, 4.06670682e-02f, 1.76323175e-01f, 1.57456607e-01f, 1.55342715e-02f, 1.30085573e-01f,
  -6.70968443e-02f, 4.09061611e-02f, -3.95409688e-02f, 2.07462683e-02f, -5.30373082e-02f, 2.86317547e-03f, -2.90331505e-02f, -1.02866739e-01f, -1.09887468e-02f, -1.79034881e-02f,
  6.63567986e-03f, 6.18140511e-02f, -4.18947674e-02f, -6.60479814e-02f, 5.32903709e-02f, -5.12666628e-03f, -8.01679119e-02f, 6.48734644e-02f, -5.18024676e-02f, -1.03640974e-01f,
  -3.41347307e-02f, -9.32889804e-03f, -3.10668629e-02f, -5.17844036e-02f, 4.61162925e-02f, 1.15247622e-01f, 2.95554549e-02f, 1.58327725e-02f, 1.24564837e-03f, -9.46831480e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.59225380e-01f, -7.38694847e-01f, 1.57167330e-01f, 1.08117893e-01f, 5.75864241e-02f, 1.00559771e-01f, -2.65456617e-01f, -6.19040765e-02f, -1.93907041e-02f, -1.09555309e-04f,
  6.75411895e-02f, 2.69114435e-01f, 3.60590905e-01f, 2.41006747e-01f, 2.38107488e-01f, -6.09568357e-02f, -5.40853180e-02f, 4.35686469e-01f, 5.79159260e-01f, 1.26740068e-01f,
  2.22666487e-02f, -1.87964395e-01f, 5.88910207e-02f, 8.11226889e-02f, -2.47052819e-01f, 8.33578631e-02f, -1.30304098e-01f, -1.62900761e-01f, -1.32867843e-01f, -3.51776570e-01f,
  -2.07138836e-01f, -2.12105811e-01f, 2.44306788e-01f, -7.27708712e-02f, -1.28545791e-01f, -6.48570657e-02f, 1.95420515e-02f, 6.56536072e-02f, -3.29182893e-02f, 4.67882976e-02f,
  -7.52555653e-02f, -9.84449461e-02f, -8.12246725e-02f, -3.30474153e-02f, -8.19360185e-03f, -9.63981375e-02f, 1.69773772e-02f, 1.53989315e-01f, 1.89352453e-01f, -1.18932493e-01f,
  -1.17765285e-01f, -8.71782377e-02f, 1.68512225e-01f, 2.03908175e-01f, 7.10334033e-02f, 1.56756654e-01f, -6.84655607e-02f, 1.28574325e-02f, 2.02377573e-01f, 5.56689054e-02f,
  -2.52442751e-02f, 1.65915251e-01f, -2.84283645e-02f, 1.12128325e-01f, 8.00563768e-02f, 5.11438698e-02f, 8.41469020e-02f, 1.02935649e-01f, 1.39922649e-01f, -9.01043862e-02f,
  -6.58345446e-02f, 1.73249766e-01f, 1.89615741e-01f, 1.21570535e-01f, -1.10085547e-01f, -8.50985274e-02f, -6.42941520e-02f, -1.18636549e-01f, 2.67627370e-02f, -7.06934929e-02f,
  1.21378703e-02f, -4.75774296e-02f, -1.01245940e-01f, -1.08630307e-01f, -1.15936756e-01f, 7.33664483e-02f, -6.62628678e-04f, 8.33304599e-02f, -1.24613248e-01f, -9.15285870e-02f,
  -2.26032749e-01f, 2.71488428e-01f, 1.13095045e-01f, 6.12398237e-02f, -1.90014597e-02f, -1.93039685e-01f, 9.49037448e-02f, -6.41070902e-02f, -2.46389493e-01f, -8.71096626e-02f,
  5.77215618e-03f, 1.63292754e-02f, -8.14973190e-02f, -5.47761358e-02f, 7.95890167e-02f, -5.09578772e-02f, -1.04400784e-01f, 1.82247162e-01f, -9.30808708e-02f, -2.08093151e-01f,
  -1.44960985e-01f, 1.24275528e-01f, 1.57235026e-01f, 1.82920128e-01f, 4.49100100e-02f, 1.38707995e-01f, -5.61200678e-02f, -9.51237306e-02f, -2.79473364e-02f, -4.82816771e-02f,
  1.62337750e-01f, 1.33408934e-01f, 2.02062994e-01f, 3.20246905e-01f, 1.73962682e-01f, 7.73396948e-03f, 2.56289076e-02f, 5.31047471e-02f, 1.44232213e-01f, 1.23972565e-01f,
  2.36228541e-01f, 2.35240683e-01f, 2.82515176e-02f, 4.37366664e-02f, 3.07836439e-02f, 9.95849520e-02f, 2.69030705e-02f, 7.13022947e-02f, 1.18111089e-01f, -2.02767011e-02f,
  -4.96316925e-02f, 4.98187728e-03f, 3.00340522e-02f, 1.48309683e-02f, 7.39639252e-02f, 5.73819317e-02f, -4.11442295e-02f, -1.11335360e-01f, 3.14110480e-02f, 2.56439894e-01f,
  9.50436071e-02f, -7.18558133e-02f, 1.61365509e-01f, 5.90020008e-02f, 8.27151313e-02f, -6.78758249e-02f, 1.06517874e-01f, 1.31467775e-01f, 4.39970046e-02f, 1.19340040e-01f,
  1.08387336e-01f, -2.23785937e-02f, -6.75866455e-02f, 1.37795405e-02f, -2.21476126e-02f, -4.66816351e-02f, -9.79440957e-02f, 1.36683151e-01f, 1.53473303e-01f, 3.72859463e-02f,
  1.66909546e-01f, 1.58316702e-01f, 1.66515976e-01f, 5.34008779e-02f, -4.95145395e-02f, 1.44961283e-01f, 1.42270461e-01f, -5.15406989e-02f, 7.71380216e-02f, 7.86086321e-02f,
  -5.14444746e-02f, 9.58024710e-02f, 6.59916252e-02f, 7.64461607e-02f, -4.87497263e-02f, -2.07824543e-01f, -2.71063335e-02f, 1.04194703e-02f, 2.76595615e-02f, -1.26662716e-01f,
  -5.67606986e-02f, 2.30258733e-01f, 3.96147110e-02f, 4.31206413e-02f, 1.08052269e-01f, 1.30995676e-01f, 8.08056071e-02f, -1.35611079e-03f, -4.66339029e-02f, 1.06157929e-01f,
  7.26064593e-02f, -9.37281251e-02f, -1.05763197e-01f, 6.22076243e-02f, 5.65987639e-02f, 6.63013607e-02f, 9.44970101e-02f, 4.11703810e-02f, -1.62018836e-01f, 4.84447069e-02f,
  3.10382694e-01f, 8.91656429e-02f, -7.26273805e-02f, 1.32839277e-01f, 7.50589073e-02f, -4.80585266e-03f, 8.82814303e-02f, 8.19369778e-02f, 6.08620420e-02f, 8.62973854e-02f,
  3.62073607e-03f, -6.40797168e-02f, -9.07845125e-02f, 2.47861171e-04f, 2.25380473e-02f, 4.91550267e-02f, 3.54007222e-02f, 2.23804325e-01f, 1.29936278e-01f, 1.81961119e-01f,
  1.06382102e-01f, 1.38174430e-01f, 1.63262233e-01f, -4.69346391e-03f, -7.58303553e-02f, 2.33100448e-02f, 2.49903998e-03f, 7.59001374e-02f, 3.79359834e-02f, -2.25473210e-01f,
  -2.05400169e-01f, -5.74546814e-01f, 1.55296430e-01f, -1.45461252e-02f, 1.12614766e-01f, 2.38284230e-01f, 1.05862945e-01f, -1.15485899e-01f, -2.46630758e-02f, -1.45786494e-01f,
  -2.30685666e-01f, 8.91180057e-03f, -3.72330919e-02f, -9.98520944e-03f, 1.03827640e-01f, 2.11700592e-02f, 1.98203444e-01f, 3.15865427e-01f, 2.79404551e-01f, 1.33921579e-01f,
  -5.26366904e-02f, -1.31984740e-01f, -3.38861160e-02f, -2.66946647e-02f, -3.03244799e-01f, 3.93392099e-03f, 1.10920146e-02f, 2.04389077e-02f, -4.42498438e-02f, -1.65946782e-01f,
  3.51638377e-01f, -1.91492736e-01f, 1.20415375e-01f, -1.77074879e-01f, -9.73229855e-02f, -2.30312884e-01f, 2.13430710e-02f, -6.96779639e-02f, -1.23802409e-01f, 7.15802833e-02f,
  1.38674518e-02f, -4.40024883e-02f, 2.82696113e-02f, -1.64438739e-01f, -8.64005014e-02f, -9.64947119e-02f, -2.09353611e-01f, -6.55349763e-03f, 7.76644144e-03f, -2.89324834e-03f,
  -9.08405334e-02f, 5.61350174e-02f, 2.47449011e-01f, 1.04258604e-01f, 5.03145717e-02f, 8.63459557e-02f, -2.18341779e-02f, -7.81929046e-02f, -9.65229236e-03f, -7.31984675e-02f,
  6.27665743e-02f, 4.21203859e-02f, -6.75474629e-02f, 1.73422992e-02f, 7.29297325e-02f, 1.25747830e-01f, 1.05261475e-01f, 5.18438593e-02f, -1.09799989e-02f, -1.12073913e-01f,
  -5.76680489e-02f, 2.55262386e-02f, 5.78246564e-02f, -5.97583242e-02f, 3.14356424e-02f, 1.18210874e-02f, 7.70163089e-02f, 2.90294960e-02f, 9.00124460e-02f, -7.88347200e-02f,
  -6.39149621e-02f, 1.30818009e-01f, -8.89569223e-02f, 1.44710513e-02f, -1.23674892e-01f, 7.62150660e-02f, 3.82994302e-02f, -5.27590215e-02f, -9.73998755e-02f, 1.30807534e-02f,
  2.80255049e-01f, 2.07059696e-01f, 1.74059600e-01f, -1.48387045e-01f, 4.34420668e-02f, -2.39675224e-01f, -4.44318764e-02f, 7.11641312e-02f, 1.56677917e-01f, 7.02342018e-02f,
  2.74413899e-02f, -8.13154317e-03f, 8.08608159e-02f, -1.22944474e-01f, -7.13185221e-02f, -8.88296887e-02f, -1.36446059e-01f, 5.25472723e-02f, 1.78835928e-01f, 5.10537513e-02f,
  -3.64756845e-02f, 2.37453222e-01f, 3.38142037e-01f, 2.01501250e-01f, 5.73609509e-02f, 2.31481656e-01f, 1.95278943e-01f, 9.21060517e-02f, 1.96730405e-01f, -3.92227061e-02f,
  -6.16436601e-01f, -2.15017140e-01f, -4.64498177e-02f, -5.98454595e-01f, -1.43799141e-01f, -5.97778149e-02f, -2.81256258e-01f, -5.34872375e-02f, -8.29826891e-02f, -4.81357992e-01f,
  -8.14684629e-02f, 2.93003857e-01f, -1.36950025e-02f, 9.15255845e-02f, -2.33475789e-02f, -4.69278753e-01f, -4.17758286e-01f, 1.17000490e-01f, 4.30493176e-01f, 2.74400890e-01f,
  -2.00952441e-02f, -1.45003421e-03f, 1.62946120e-01f, 2.13933170e-01f, -8.18491578e-02f, 8.91974568e-02f, -1.67192549e-01f, 1.85056236e-02f, 1.53972790e-01f, -3.86187345e-01f,
  -1.12784363e-01f, -7.88410455e-02f, 8.82276595e-02f, -1.72020551e-02f, -1.24953300e-01f, -4.33630962e-03f, -5.07039838e-02f, 4.48477492e-02f, 3.91312987e-02f, -4.94134389e-02f,
  -3.18808220e-02f, -3.14682499e-02f, 2.13894378e-02f, 7.71845579e-02f, 7.51435291e-03f, -1.12344630e-01f, -7.22916722e-02f, 7.45658726e-02f, -8.47392008e-02f, -7.96106905e-02f,
  -1.52568251e-01f, 1.31476270e-02f, 1.27925098e-01f, 1.11430898e-01f, 1.36789143e-01f, 5.39534502e-02f, 2.22410813e-01f, 1.93506673e-01f, 2.36766160e-01f, -9.32821110e-02f,
  -5.72171155e-03f, 3.60260308e-02f, 5.86030819e-02f, -3.00777685e-02f, -3.05906329e-02f, 5.80787770e-02f, -8.74891281e-02f, -7.92279392e-02f, 6.35651201e-02f, 8.75178277e-02f,
  -1.36438329e-02f, -9.35003832e-02f, -4.63989787e-02f, -5.21701761e-02f, -7.50504388e-03f, -5.42644830e-03f, -3.67143974e-02f, -3.13683078e-02f, -9.52184293e-03f, -1.38416653e-02f,
  1.18462868e-01f, 9.04042795e-02f, 5.16891852e-02f, 2.63998136e-02f, 8.57970715e-02f, -8.21662620e-02f, 5.26703894e-02f, 1.38163462e-01f, 7.31714815e-02f, 8.03199708e-02f,
  -1.45532608e-01f, 1.32538587e-01f, -3.17973167e-01f, 9.33157504e-02f, 9.20730736e-03f, 4.07051966e-02f, -7.78900012e-02f, -3.73507068e-02f, -8.59474484e-03f, -6.38685748e-02f,
  9.22353417e-02f, -8.67519155e-02f, -7.87703618e-02f, 2.95364931e-02f, -6.37794957e-02f, -1.19305417e-01f, -1.47195831e-01f, 5.17685972e-02f, 1.61915138e-01f, -1.34027272e-01f,
  -1.96770012e-01f, -4.34871614e-02f, -1.01592563e-01f, -8.49854946e-02f, -8.45503807e-02f, -7.84882754e-02f, 1.33205101e-01f, 9.29538682e-02f, 8.31065923e-02f, -1.93893135e-01f,
  -8.76693428e-01f, -1.50969639e-01f, -5.26759684e-01f, -3.33206445e-01f, 3.11425179e-01f, 1.82426870e-01f, 1.73179358e-01f, 8.44106972e-02f, 1.03680670e-01f, 1.42959710e-02f,
  -4.87057008e-02f, -1.74273439e-02f, 1.27378523e-01f, 3.37608993e-01f, 2.01738477e-01f, 2.93967247e-01f, 4.06867087e-01f, 3.26896384e-02f, -1.09804213e-01f, -4.76282276e-02f,
  2.49804139e-01f, -1.33442983e-01f, -4.30136889e-01f, 4.80401665e-02f, -2.33799834e-02f, 1.84511151e-02f, 1.93884335e-02f, -1.95187051e-02f, 1.94082633e-01f, 7.56205916e-02f,
  -4.40583676e-01f, -3.22567523e-01f, 8.92214477e-02f, 3.79201286e-02f, -1.80340946e-01f, -2.78272748e-01f, 1.38545374e-03f, -5.85609861e-02f, -1.83881134e-01f, 2.60147676e-02f,
  -1.51046023e-01f, -3.18226009e-03f, -4.31357250e-02f, 2.15483438e-02f, -5.08633852e-02f, -2.06465553e-02f, 2.70179790e-02f, -1.25143409e-01f, -1.96518287e-01f, -6.65249601e-02f,
  3.28935981e-01f, 7.86398817e-03f, -2.29968712e-01f, 1.11021258e-01f, -6.77219331e-02f, -6.13918230e-02f, -7.22205639e-02f, -1.05782002e-02f, -8.67832676e-02f, -5.35330959e-02f,
  8.78279433e-02f, -8.30135122e-03f, 8.12222250e-03f, 1.11928925e-01f, -2.82804556e-02f, 3.27899680e-02f, 2.16638278e-02f, 2.13012904e-01f, 8.96392241e-02f, -3.48284245e-02f,
  8.03764444e-03f, 7.92098269e-02f, 1.67339653e-01f, -2.06613373e-02f, 4.50111814e-02f, -4.37167175e-02f, -2.89449692e-02f, 1.25719076e-02f, -2.20403895e-02f, -5.93056669e-03f,
  -5.71610108e-02f, 1.66606288e-02f, 5.25859930e-02f, 4.84312512e-02f, 1.65783197e-01f, 9.33015496e-02f, -1.34984985e-01f, -2.95584891e-02f, -1.72522739e-01f, -5.18819056e-02f,
  -3.23522747e-01f, 9.05458108e-02f, -8.53646994e-02f, 6.26235530e-02f, -1.13390647e-01f, 5.90550341e-03f, 3.04910238e-03f, -1.40516711e-02f, -2.45460775e-02f, -1.56655446e-01f,
  1.51622563e-03f, 3.31449509e-02f, -1.44902304e-01f, 7.89629966e-02f, -1.28606513e-01f, 1.14850290e-02f, 3.68707627e-02f, 9.56833828e-03f, 4.08693366e-02f, -9.32574868e-02f,
  6.59048259e-02f, 7.76187703e-02f, -1.91794679e-01f, 3.04306503e-02f, 1.95647985e-01f, 5.48383482e-02f, 4.38083746e-02f, -9.40076485e-02f, -9.69704762e-02f, -9.13034081e-02f,
  -5.69032371e-01f, 7.70564005e-02f, -3.83496016e-01f, -1.64503738e-01f, -3.95328730e-01f, -1.60058051e-01f, -1.46138296e-01f, -2.71933936e-02f, 4.02192324e-02f, -8.11851993e-02f,
  -1.84784010e-02f, -7.08664954e-02f, -1.96432859e-01f, -1.04696341e-01f, 7.53075071e-03f, -1.76544040e-01f, -2.55035192e-01f, -2.93606371e-01f, -1.23281591e-01f, 4.07184809e-02f,
  -1.40061364e-01f, -4.19132888e-01f, -3.44339103e-01f, -1.84259847e-01f, -1.12637021e-01f, -2.26435944e-01f, -5.14195442e-01f, -5.73076129e-01f, -3.53191078e-01f, -5.24038434e-01f,
  -1.77302793e-01f, -2.51852795e-02f, -1.81130692e-01f, -3.91003974e-02f, -3.04028206e-02f, 4.99109551e-03f, 6.21353425e-02f, -1.57566667e-02f, 1.29710898e-01f, 9.28446203e-02f,
  -8.47479776e-02f, 6.73267692e-02f, -9.13587492e-03f, -9.13332477e-02f, -6.17239289e-02f, 7.17347488e-02f, -1.46242790e-02f, -2.19179951e-02f, 2.00538095e-02f, 1.34346485e-01f,
  -3.63349356e-02f, -2.31378283e-02f, 1.40225172e-01f, 6.19128272e-02f, 4.23534028e-02f, -7.21489266e-02f, -8.51640999e-02f, -4.54380326e-02f, -1.14069708e-01f, -1.90157726e-01f,
  1.78878813e-03f, 1.37606114e-01f, 7.61589780e-03f, -1.17760105e-02f, 1.24357408e-02f, -1.95987560e-02f, -2.60184668e-02f, 1.49472579e-02f, 6.04436733e-02f, 1.41058234e-03f,
  -1.17251109e-02f, -3.54853161e-02f, -3.80807035e-02f, -2.17056572e-02f, -2.64712069e-02f, -1.35970246e-02f, -8.34264327e-03f, 6.36101067e-02f, 5.40961809e-02f, 6.15021102e-02f,
  2.58730110e-02f, -6.25245348e-02f, -9.76042300e-02f, 8.93311203e-02f, 4.41758744e-02f, 8.16485435e-02f, 2.59280056e-02f, 1.25526130e-01f, 5.08462195e-04f, 1.02516599e-01f,
  -3.63168743e-04f, -5.52319251e-02f, 9.12901461e-02f, 1.00201994e-01f, 1.56159012e-03f, 1.19309714e-02f, 8.33026469e-02f, 1.29968271e-01f, 1.14926226e-01f, 1.33489460e-01f,
  2.00887978e-01f, 8.34820420e-03f, -1.93720497e-02f, -4.33559529e-02f, 1.20020226e-01f, 4.92714085e-02f, 1.34909928e-01f, -8.69250819e-02f, 5.60878776e-02f, 2.89001107e-01f,
  1.78410560e-01f, 2.15426877e-01f, 2.40914568e-01f, 1.19507700e-01f, 8.57118666e-02f, -6.50383011e-02f, 7.01948479e-02f, 6.78156018e-02f, 4.71060053e-02f, 1.29394624e-02f,
  -3.20617080e-01f, -4.01173025e-01f, 2.74159629e-02f, -5.20236418e-02f, -1.89072769e-02f, -5.04063554e-02f, -5.17357111e-01f, -1.20984316e-02f, 6.96534216e-02f, -3.47973466e-01f,
  -2.89549846e-02f, 2.65112370e-01f, -9.72527042e-02f, 4.54403535e-02f, -2.58639127e-01f, -5.12938380e-01f, -3.39297533e-01f, -1.02461586e-02f, 3.12682956e-01f, 2.19142839e-01f,
  1.77453682e-02f, 6.63872063e-02f, 1.38859108e-01f, 9.16486159e-02f, -1.87699199e-01f, -1.32075883e-02f, -2.40256310e-01f, -2.10423712e-02f, -1.78047255e-01f, -3.79838109e-01f,
  -2.40960702e-01f, -2.90768176e-01f, 7.19278902e-02f, -7.15425387e-02f, -6.47041127e-02f, -1.00543022e-01f, -7.29016066e-02f, 3.52833420e-02f, 1.19580202e-01f, -5.39262518e-02f,
  1.62664488e-01f, 8.59403908e-02f, 5.55378087e-02f, 1.40653476e-01f, 1.40625089e-01f, 5.19105420e-02f, 1.13462813e-01f, 6.60749972e-02f, -1.05065823e-01f, -2.13797033e-01f,
  4.53870781e-02f, 8.34036022e-02f, 1.38807073e-01f, 7.23618641e-02f, -1.00577883e-01f, 1.09930106e-01f, -1.36666978e-02f, 6.39326349e-02f, -8.50838050e-02f, -4.28400069e-01f,
  5.23166135e-02f, -2.99471784e-02f, 2.63323691e-02f, 4.82181385e-02f, 5.63113801e-02f, 5.10657281e-02f, 9.60155800e-02f, -1.68852478e-01f, -5.25529273e-02f, -4.07689959e-02f,
  9.49108154e-02f, -5.38888294e-03f, 6.38080835e-02f, -1.36547133e-01f, 3.11873555e-02f, -1.89634750e-03f, -6.25119582e-02f, -2.46715993e-02f, 6.02691248e-02f, 1.55020785e-02f,
  3.39676924e-02f, 1.55656319e-03f, -2.40360107e-02f, 2.65426002e-02f, -1.74056917e-01f, -1.36400118e-01f, 1.32860057e-02f, -1.26644075e-02f, 4.86318691e-04f, -5.16976304e-02f,
  -1.34782135e-01f, 1.59482479e-01f, -2.08201215e-01f, -1.11586154e-01f, 9.28666294e-02f, 5.33579700e-02f, -1.54582471e-01f, -4.65629101e-02f, 4.22495380e-02f, 6.19975058e-03f,
  -1.15414023e-01f, -1.84171870e-02f, -2.09430978e-02f, -5.43217920e-03f, 2.29433589e-02f, -3.46794836e-02f, -5.25228232e-02f, 9.48944315e-03f, 6.78820685e-02f, 6.72678053e-02f,
  -9.49598029e-02f, -9.73779708e-02f, -3.47786322e-02f, -1.69314191e-01f, -1.77732617e-01f, -1.60078168e-01f, -1.23349749e-01f, -1.49447158e-01f, -2.70548433e-01f, -5.05149543e-01f,
  -3.90476346e-01f, -1.79786727e-01f, -1.66032284e-01f, -2.28867024e-01f, -8.38499814e-02f, 7.82296583e-02f, -1.40678555e-01f, 2.24651635e-01f, 6.29529208e-02f, -3.46521258e-01f,
  -1.95728123e-01f, -3.18082310e-02f, -1.66120321e-01f, -7.75515810e-02f, -2.06819922e-01f, -5.30004859e-01f, -4.08400983e-01f, -2.05447435e-01f, 2.50329256e-01f, 2.01303542e-01f,
  4.08603065e-03f, -2.95733303e-01f, -1.04029113e-02f, 5.67342564e-02f, -1.52671978e-01f, 4.45668958e-02f, -2.50839680e-01f, -1.38517633e-01f, 8.57643560e-02f, -3.67060989e-01f,
  -1.75013766e-01f, 2.75980741e-01f, -3.33160050e-02f, 7.17120245e-02f, -5.08854352e-02f, 8.28864798e-02f, 3.60142961e-02f, -7.03528756e-03f, -4.25814614e-02f, -5.74510284e-02f,
  -5.01598902e-02f, 6.52639717e-02f, -3.55273746e-02f, 2.46296711e-02f, 3.05246878e-02f, -6.34820983e-02f, 1.22462109e-01f, -3.89522221e-03f, -4.65711989e-02f, 9.78794545e-02f,
  9.21031684e-02f, 2.00276226e-02f, 9.51641798e-02f, 1.78628922e-01f, 1.81632161e-01f, 1.00906692e-01f, 2.01449886e-01f, 3.93741906e-01f, 3.81166786e-01f, 1.62348643e-01f,
  -5.81539758e-02f, -1.72812954e-01f, 9.43923891e-02f, -2.76087020e-02f, -8.58523473e-02f, -2.79295840e-03f, 4.68130736e-03f, -3.00514214e-02f, -2.56216861e-02f, -7.44448975e-02f,
  -5.53337187e-02f, -1.64430682e-02f, 4.09943089e-02f, -1.60621077e-01f, -5.66509813e-02f, 3.48679423e-02f, 7.18503594e-02f, 2.77878009e-02f, 4.80540991e-02f, -6.09359629e-02f,
  6.21021912e-02f, 3.23105715e-02f, -3.84656638e-02f, -5.25910631e-02f, -6.33229017e-02f, 3.30927558e-02f, 1.22683577e-01f, 4.68814299e-02f, -1.24266252e-01f, 2.01783143e-03f,
  -8.42357427e-02f, 4.25269231e-02f, -3.12314957e-01f, 1.17175311e-01f, 7.98403099e-03f, 1.57275289e-01f, 2.41985302e-02f, 5.84185869e-02f, -4.60486002e-02f, 4.79587503e-02f,
  1.16779260e-01f, -2.99077369e-02f, -2.52577633e-01f, -7.43858591e-02f, -8.10847878e-02f, 4.48608249e-02f, 4.37762737e-02f, 6.41451925e-02f, -4.23806496e-02f, 9.30786058e-02f,
  4.57888655e-02f, 4.24493453e-04f, -1.24057569e-01f, -3.87030724e-03f, 5.39983399e-02f, -1.59945250e-01f, -2.25080699e-01f, -3.24957669e-02f, -1.25696421e-01f, -1.77866429e-01f,
  1.76725924e-01f, 3.89156878e-01f, 3.33100826e-01f, -1.26352042e-01f, 3.85290645e-02f, -2.38013506e-01f, 4.66911271e-02f, -1.90064460e-01f, -2.75574505e-01f, 3.05755809e-02f,
  4.48165052e-02f, -2.51424313e-01f, 8.56882408e-02f, -7.34897405e-02f, 1.26986563e-01f, 1.14320643e-01f, 1.49255946e-01f, 1.44831061e-01f, -2.98870385e-01f, -2.88808107e-01f,
  -1.01095147e-01f, 7.06175864e-02f, -3.69578712e-02f, -3.60021517e-02f, 8.89806077e-02f, -3.96293759e-01f, 1.20104745e-01f, 3.67847443e-01f, 9.66322646e-02f, 4.90427732e-01f,
  1.48140863e-01f, 2.55835652e-01f, -3.97713602e-01f, 3.87880653e-02f, 1.01012126e-01f, -4.49872911e-02f, -1.34575978e-01f, -2.47313678e-02f, 1.03347197e-01f, 5.21290936e-02f,
  5.17690554e-02f, 1.37546867e-01f, 3.36850137e-02f, -9.24231037e-02f, -5.07042371e-02f, -1.21964835e-01f, -4.51076739e-02f, 1.73634946e-01f, 2.59252936e-02f, 7.00489208e-02f,
  -6.78492114e-02f, 8.46301615e-02f, 1.15196317e-01f, -4.65642810e-02f, 5.97752631e-02f, -6.46079406e-02f, -2.10980680e-02f, 1.95173081e-02f, -2.01144248e-01f, -1.54634500e-02f,
  -8.02864879e-02f, 8.00878704e-02f, 1.01486526e-01f, 3.02890949e-02f, 2.09281184e-02f, -6.63729087e-02f, 9.97560024e-02f, 2.43265592e-02f, -1.08412858e-02f, 1.02063641e-01f,
  -1.77291453e-01f, -1.06372148e-01f, -1.46152619e-02f, -7.25554004e-02f, -1.22697785e-01f, 1.07912486e-02f, -1.61301836e-01f, -3.65016572e-02f, 8.57281405e-03f, -6.19539581e-02f,
  2.91860476e-02f, -1.63368005e-02f, -5.61569333e-02f, -3.12804952e-02f, -7.21494183e-02f, -1.57062411e-01f, -1.14317290e-01f, -6.54172003e-02f, -5.54299057e-02f, 2.91286595e-02f,
  -1.53325960e-01f, -2.70905532e-02f, -2.14946076e-01f, 5.41547760e-02f, 1.65045843e-01f, 1.45321876e-01f, 1.48687661e-01f, -9.31233168e-02f, 6.18158020e-02f, -3.94779816e-02f,
  6.00918531e-02f, -1.02148794e-01f, 2.70644724e-02f, 5.27394451e-02f, -1.73176602e-01f, 3.31941806e-02f, -7.39254430e-02f, -1.87463537e-02f, -5.91604598e-02f, -1.59586854e-02f,
  -3.37200612e-02f, -2.73536593e-01f, -2.40844950e-01f, -8.61921608e-02f, -3.24992925e-01f, -4.98040110e-01f, -2.13458866e-01f, -2.25566819e-01f, -2.36911282e-01f, -2.87945479e-01f,
  -3.59953046e-02f, -3.37879449e-01f, -7.89481774e-02f, 3.04452986e-01f, -3.33748236e-02f, -4.89909291e-01f, -8.29681039e-01f, -4.43989247e-01f, 2.15471387e-01f, -3.54678892e-02f,
  2.94601638e-02f, 2.36361921e-01f, 8.43781084e-02f, 8.29604045e-02f, -3.72903734e-01f, -3.04792285e-01f, -5.29256985e-02f, 2.01746877e-02f, -1.88575149e-01f, -4.97130537e-03f,
  1.77191570e-02f, 1.61525190e-01f, 7.32465163e-02f, -2.95471866e-02f, 2.96458215e-01f, 1.46994203e-01f, 9.43800732e-02f, 3.14436048e-01f, 1.54924661e-01f, 5.65154552e-01f,
  2.84744203e-01f, 1.85719691e-02f, 3.05741653e-02f, 1.60051942e-01f, 4.27879654e-02f, -1.56685784e-01f, -5.77085167e-02f, 1.07396536e-01f, 7.70737976e-02f, 6.44818768e-02f,
  9.73238498e-02f, 1.25651956e-01f, 9.81711000e-02f, -1.81785114e-02f, -1.17388815e-01f, -2.51229197e-01f, -8.97749662e-02f, -1.60661504e-01f, -2.39765108e-01f, 2.36663278e-02f,
  -1.24276862e-01f, 3.92946936e-02f, -1.38398275e-01f, -1.49060667e-01f, -1.25957549e-01f, 1.39198095e-01f, 3.02489009e-02f, -5.84259368e-02f, -7.61563778e-02f, 1.05682947e-01f,
  4.04935479e-02f, 4.58530262e-02f, 9.62232873e-02f, -8.90256185e-03f, -1.14013955e-01f, 1.79647710e-02f, 1.56547621e-01f, 1.33552328e-01f, -5.93054742e-02f, -1.02977417e-02f,
  -1.31938785e-01f, 1.45282283e-01f, 1.65591799e-02f, -3.70469168e-02f, 2.98606176e-02f, 1.22810408e-01f, -2.58720443e-02f, -4.52338792e-02f, 4.12278101e-02f, 2.56374441e-02f,
  -4.01137508e-02f, -7.69510418e-02f, -2.56061088e-02f, -7.17754364e-02f, 4.74696234e-03f, -9.19106766e-04f, 1.67063773e-01f, -7.50551447e-02f, -1.62480865e-02f, 7.70732909e-02f,
  2.73580216e-02f, -1.99864149e-01f, 8.36977884e-02f, -7.80668706e-02f, 3.73932682e-02f, 5.84436320e-02f, 9.07060653e-02f, -5.52588776e-02f, -4.31878008e-02f, -2.10796386e-01f,
  -6.88684657e-02f, -2.90093143e-02f, -6.79761404e-03f, 1.09006604e-02f, -1.16418861e-02f, 1.31161148e-02f, -1.42342327e-02f, -9.48833898e-02f, -6.09915815e-02f, -1.56256333e-01f,
  -1.18025847e-01f, -2.60434538e-01f, -1.49013594e-01f, -2.70265698e-01f, 6.65215328e-02f, -2.09187925e-01f, -1.56471968e-01f, -3.54461186e-02f, -2.56671160e-01f, -3.21849465e-01f,
  5.90278804e-01f, 1.17801905e-01f, 2.55006105e-01f, -1.24382764e-01f, -2.26437598e-01f, -1.17823936e-01f, -6.33630678e-02f, -5.01419716e-02f, -1.15981609e-01f, -7.03350734e-03f,
  1.40654981e-01f, 7.59499371e-02f, 1.52605206e-01f, 1.58112198e-02f, 2.68186778e-01f, -1.59780577e-01f, -1.37273520e-01f, 2.12531015e-01f, 1.40713379e-01f, -2.02638581e-01f,
  -2.83897340e-01f, -9.45366248e-02f, 1.30210817e-01f, 1.92309693e-02f, -1.83961958e-01f, -4.11502495e-02f, -2.51765382e-02f, 9.11514461e-02f, 1.93165485e-02f, -2.45791540e-01f,
  1.41128153e-01f, 5.16070068e-01f, -1.13085039e-01f, -6.53353333e-02f, 1.84777714e-02f, -4.87017259e-03f, 4.39578434e-03f, 1.51815981e-01f, -1.98034868e-02f, -3.25663835e-02f,
  -1.57699753e-02f, 1.84998661e-02f, 1.56927302e-01f, 2.38094050e-02f, 1.67134285e-01f, -3.03739067e-02f, 1.41744986e-01f, 1.51182920e-01f, 6.88830242e-02f, 4.81049418e-02f,
  -1.06963061e-01f, 7.07630515e-02f, 7.92152882e-02f, 7.15098530e-02f, 1.11960411e-01f, 1.59144133e-01f, 3.01527008e-02f, 4.64158468e-02f, 1.49601042e-01f, -3.49738412e-02f,
  -2.12159559e-01f, -1.19514717e-02f, 1.12546727e-01f, -6.55012801e-02f, -9.65941474e-02f, -2.20210198e-02f, -5.40417023e-02f, -1.17038280e-01f, -1.29724434e-02f, -6.42439350e-02f,
  1.20122060e-01f, 2.04954848e-01f, -1.67726201e-03f, 8.56138319e-02f, 1.70288414e-01f, 1.44230664e-01f, 3.40879075e-02f, 1.20554648e-01f, 2.41120398e-01f, 6.81615695e-02f,
  1.75063357e-01f, -2.97456179e-02f, 1.54834658e-01f, 2.43299693e-01f, 1.90849081e-01f, 2.75690943e-01f, 1.21251121e-01f, -3.56063470e-02f, 1.83623144e-03f, -1.87147055e-02f,
  -2.57851064e-01f, 5.48895240e-01f, -9.51625109e-02f, -1.05663587e-03f, 4.39141616e-02f, 1.09800942e-01f, 1.20112464e-01f, 4.54022102e-02f, 7.12774843e-02f, 1.30979866e-01f,
  3.43988128e-02f, 9.55635309e-02f, 4.70950194e-02f, 1.66005883e-02f, -2.52469201e-02f, -5.61210103e-02f, 2.21217629e-02f, -1.35948837e-01f, -5.12155667e-02f, -1.30820662e-01f,
  -1.43618956e-01f, -2.41283238e-01f, -1.00084007e-01f, -1.57843828e-01f, -9.57594886e-02f, -1.39774114e-01f, -3.39309275e-02f, 1.43176075e-02f, 1.13560230e-01f, -2.17375055e-01f,
  6.04899764e-01f, 2.29510352e-01f, -9.31450069e-01f, 2.04856411e-01f, -4.42696184e-01f, -2.24906445e-01f, -4.21564206e-02f, 2.65876532e-01f, 1.64051533e-01f, -1.64794445e-01f,
  1.19625367e-02f, 1.86733305e-01f, -9.28811263e-03f, -1.27531318e-02f, 1.23271495e-01f, -3.54538441e-01f, -2.99771100e-01f, -2.61372566e-01f, -1.19857632e-01f, -7.68235326e-02f,
  4.23297696e-02f, 8.12362060e-02f, 2.48513266e-01f, 8.98041651e-02f, -1.58830115e-03f, 8.12688544e-02f, -2.69242562e-02f, -9.52978432e-02f, -1.85942769e-01f, -2.83067137e-01f,
  -5.02177060e-01f, -7.80895203e-02f, -1.25233978e-01f, 1.06458984e-01f, -7.60145783e-02f, 1.58657625e-01f, 2.34578922e-02f, 2.37405412e-02f, 1.47221848e-01f, 3.42287421e-02f,
  -3.88839468e-02f, -1.07221464e-02f, 1.12938009e-01f, 1.50243221e-02f, 1.04394771e-01f, 8.39100927e-02f, 3.25878188e-02f, 3.05425525e-02f, 5.86185977e-03f, -1.25699684e-01f,
  -2.34437585e-02f, -1.42362416e-01f, -1.65360570e-01f, -4.72156964e-02f, -2.78146621e-02f, -1.86214283e-01f, -9.45183486e-02f, -1.64871722e-01f, -3.20705101e-02f, 1.44490942e-01f,
  -1.27889007e-01f, -3.40619013e-02f, -1.04190052e-01f, 3.45304534e-02f, 1.02906600e-01f, 5.22140823e-02f, 3.20230946e-02f, -5.99714834e-03f, -2.57796701e-02f, 2.46853344e-02f,
  -2.64650285e-02f, -3.58172767e-02f, -2.56014289e-03f, 9.26955119e-02f, -6.47016019e-02f, -1.09474892e-02f, -6.41800091e-02f, -4.45270166e-02f, -9.84243210e-03f, 1.09246790e-01f,
  -4.53854725e-02f, -6.93058372e-02f, -5.62556945e-02f, 6.18830957e-02f, -1.09141491e-01f, -4.35504764e-02f, -1.65480226e-01f, 7.18767270e-02f, 2.74667758e-02f, 6.50960766e-03f,
  4.20208216e-01f, -5.50323501e-02f, -8.52956399e-02f, 4.90122149e-03f, -5.60192317e-02f, -2.08257399e-02f, -8.18223879e-02f, -4.65031154e-02f, 2.71215867e-02f, -1.05727486e-01f,
  -8.39395449e-02f, -2.98072584e-02f, -2.72156615e-02f, 2.69107963e-03f, -7.67920986e-02f, -1.01716988e-01f, 6.45124316e-02f, -8.26477855e-02f, -1.41937314e-02f, -4.35184985e-02f,
  1.04841560e-01f, 1.39393449e-01f, 2.01237097e-01f, 1.00799408e-02f, 4.18676436e-02f, -2.03794483e-02f, 7.90226310e-02f, 8.49084929e-03f, -8.23106840e-02f, 3.07514012e-01f,
  -5.88748515e-01f, -2.25237653e-01f, 7.01731890e-02f, -7.11986959e-01f, -4.38742161e-01f, -2.15579987e-01f, -2.77238727e-01f, -2.41989285e-01f, -3.37863594e-01f, -2.66491741e-01f,
  1.65362537e-01f, 4.14231271e-01f, 4.44874823e-01f, 5.32315731e-01f, 4.05924350e-01f, -2.56210268e-01f, -4.03044254e-01f, 1.65102825e-01f, 5.71136236e-01f, 1.37340978e-01f,
  -2.76122671e-02f, -1.00797750e-01f, -8.10051858e-02f, -8.18136185e-02f, -3.76519948e-01f, 6.41717091e-02f, -1.99213207e-01f, -1.52092576e-01f, 2.76403502e-02f, -3.47637355e-01f,
  3.02513182e-01f, -3.20539206e-01f, 3.85882705e-02f, -1.07228206e-02f, -1.68748587e-01f, -5.22408932e-02f, 1.98576469e-02f, -5.77584952e-02f, 5.14652487e-03f, -1.51605206e-02f,
  -9.58080068e-02f, 7.77596235e-02f, 6.38691410e-02f, 2.65552234e-02f, 1.75182316e-02f, -7.42978454e-02f, -3.79047208e-02f, 8.98959637e-02f, -9.97963641e-03f, 5.67095354e-02f,
  2.16526370e-02f, 8.47249478e-03f, 6.15007989e-02f, -1.64249111e-02f, -9.47579369e-03f, 1.32794961e-01f, 1.26396924e-01f, 8.38452671e-03f, -7.62030901e-03f, -2.27746323e-01f,
  4.05572020e-02f, -2.74254978e-02f, 1.56364646e-02f, -1.18695006e-01f, -6.62333220e-02f, 2.59445403e-02f, -3.54195572e-02f, 1.29926115e-01f, 7.36171231e-02f, 4.49064262e-02f,
  -1.58984866e-02f, 1.53128844e-04f, 1.91146811e-03f, 1.53998798e-02f, 4.74579707e-02f, -1.43844739e-01f, -8.58452618e-02f, -1.68963056e-02f, -6.89078718e-02f, -1.21821545e-01f,
  9.01729912e-02f, -1.02642044e-01f, -1.91809551e-03f, 4.61468697e-02f, -1.38930857e-01f, -4.65871915e-02f, 4.62279795e-03f, 4.72930484e-02f, 3.98338325e-02f, -1.04674175e-01f,
  2.03283176e-01f, 4.81692143e-03f, -2.35708319e-02f, 3.22421566e-02f, -1.31613657e-01f, -8.47157836e-02f, -2.90241446e-02f, 2.38053314e-02f, -8.89464617e-02f, -1.30883884e-02f,
  -2.22282354e-02f, 9.69934314e-02f, 2.58398987e-02f, 4.22874354e-02f, -9.16763116e-03f, 7.86317959e-02f, 1.22956224e-02f, 1.78355332e-02f, -9.15186405e-02f, -4.41131629e-02f,
  -2.41380241e-02f, -4.67553549e-02f, 1.45506993e-01f, -6.66975826e-02f, 1.24322046e-02f, 1.33057952e-01f, 2.54454315e-01f, -5.82994260e-02f, 2.26117466e-02f, -1.71070784e-01f,
  6.23058021e-01f, 2.31414616e-01f, 4.74076301e-01f, 1.55680701e-01f, 2.37595156e-01f, 3.60354930e-01f, 4.42577839e-01f, 3.49008530e-01f, 8.97285864e-02f, 9.04237330e-02f,
  -3.76432762e-03f, -2.74196323e-02f, 4.42320760e-03f, -6.78119734e-02f, 1.24718018e-01f, 2.20464602e-01f, 9.57300290e-02f, 2.59579360e-01f, 3.01529229e-01f, 1.77380830e-01f,
  -5.17064370e-02f, 2.32066587e-02f, 1.83279082e-01f, 1.70422032e-01f, 8.69541243e-02f, 3.84889171e-02f, 5.57134561e-02f, 4.13152315e-02f, 1.67392030e-01f, 5.96210137e-02f,
  9.69801545e-02f, 2.48094395e-01f, -1.18335888e-01f, -1.62663892e-01f, -1.59704074e-01f, -1.33295029e-01f, -4.56001461e-02f, -6.85363337e-02f, -1.71871990e-01f, -1.60379820e-02f,
  -7.30852783e-02f, 9.10406001e-03f, -4.61821966e-02f, 2.35932879e-02f, 6.85667619e-02f, 8.96871835e-02f, 3.51499543e-02f, 8.88957605e-02f, 9.64404345e-02f, 5.80134019e-02f,
  -8.25525746e-02f, -5.45890478e-04f, 3.02857757e-01f, 1.98468074e-01f, 8.76546204e-02f, -2.70562284e-02f, 1.01467721e-01f, 5.07679656e-02f, 2.38808915e-02f, 8.79785269e-02f,
  8.44881758e-02f, 9.01922137e-02f, 1.17704786e-01f, -7.87834357e-03f, -1.02909826e-01f, -8.80245715e-02f, -1.19779065e-01f, 2.74193790e-02f, 1.73922956e-01f, -4.28083315e-02f,
  -8.19822326e-02f, 1.13607287e-01f, 1.60885062e-02f, 3.64676155e-02f, -1.64363701e-02f, 1.00769095e-01f, -6.80756047e-02f, -4.42059822e-02f, -3.55770178e-02f, 8.26817080e-02f,
  7.19048008e-02f, 1.52668148e-01f, 9.82369781e-02f, 3.29343192e-02f, 4.23770696e-02f, 9.25116912e-02f, 1.11753143e-01f, -3.67235728e-02f, 4.07288224e-02f, 2.81665400e-02f,
  -3.35758418e-01f, 2.29413388e-03f, -3.01466007e-02f, -1.39883325e-01f, 3.90218124e-02f, -9.13632289e-02f, 2.13522892e-02f, -1.07639320e-01f, -2.04816133e-01f, -5.63855655e-02f,
  -1.18216770e-02f, 4.76919208e-03f, 3.27001549e-02f, -4.86878911e-03f, 9.17781666e-02f, -4.17595208e-02f, -1.74015075e-01f, -4.71260920e-02f, -9.21782777e-02f, -5.50205298e-02f,
  -1.73974991e-01f, 4.45686318e-02f, 5.45993485e-02f, -2.98453439e-02f, -6.25567436e-02f, -2.22639740e-01f, -2.90107131e-02f, 4.82466333e-02f, -9.99246724e-03f, -1.41499147e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.21254063e-01f, -2.80894667e-01f, 2.94080436e-01f, 3.82565349e-01f, 1.73773304e-01f, 1.07847862e-01f, 2.64137328e-01f, -9.33772549e-02f, 3.38411868e-01f, 2.24877611e-01f,
  5.70427716e-01f, 7.08010420e-02f, 2.55071729e-01f, 2.15456188e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  5.23755364e-02f, -9.21489820e-02f, -1.67225599e-01f, 9.79746208e-02f, 7.82847255e-02f, -2.34102398e-01f, -1.59832582e-01f, 2.73926824e-01f, -1.73093617e-01f, 4.89290431e-02f,
  -2.12728053e-01f, 2.16049194e-01f, 1.89204127e-01f, 9.80975479e-02f, -2.30360582e-01f, 1.88268468e-01f, -2.68204331e-01f, -2.34660521e-01f, -3.50009471e-01f, 1.01897463e-01f,
  -2.69020259e-01f, -4.18043494e-01f, -3.83253485e-01f, 1.66541487e-02f, -1.82970464e-01f, -1.75067380e-01f, 2.65374184e-01f, 4.39362466e-01f, 1.64382365e-02f, 2.94261068e-01f,
  -2.52372980e-01f, 4.24163528e-02f, -1.24421187e-01f, -1.96081534e-01f, 5.66866435e-03f, 5.97888492e-02f, -6.62288349e-03f, -1.69508383e-01f, 8.69190767e-02f, -1.32118523e-01f,
  -5.82918972e-02f, 1.66089192e-01f, 1.56619906e-01f, 4.00399789e-02f, 2.64048845e-01f, 2.78673531e-03f, 2.23661344e-02f, -7.16906562e-02f, -1.99461222e-01f, 7.20213354e-02f,
  -9.91772264e-02f, 1.70393601e-01f, -2.10425436e-01f, 9.30296555e-02f, 3.97738934e-01f, -6.64513484e-02f, 2.05315858e-01f, 1.82670772e-01f, -2.76330501e-01f, 3.01837087e-01f,
  -3.16285014e-01f, 3.24070943e-03f, -2.97839612e-01f, -3.02221507e-01f, 2.83071138e-02f, -2.94619817e-02f, 1.35745287e-01f, 1.44729123e-01f, 3.46708186e-02f, -2.96362564e-02f,
  2.92541292e-02f, -8.57520029e-02f, -7.52495304e-02f, 8.29164088e-02f, -1.06530108e-01f, 1.45651162e-01f, 2.51756310e-01f, -5.52828908e-02f, 9.23310146e-02f, 5.09178601e-02f,
  1.44537613e-01f, -4.00985107e-02f, -1.21240862e-01f, 1.05871603e-01f, 2.04048857e-01f, 2.20122933e-01f, 4.59968686e-01f, 1.82854254e-02f, 3.02425086e-01f, -9.53159407e-02f,
  1.06981814e-01f, 3.92817706e-01f, -8.13268777e-03f, -4.50730503e-01f, 1.91983417e-01f, -1.29925579e-01f, 3.41621675e-02f, -2.87717357e-02f, 1.96327001e-01f, -1.71335582e-02f,
  1.74181730e-01f, -6.18353523e-02f, 1.85258344e-01f, 1.03706434e-01f, 9.84714925e-03f, 1.78822502e-02f, 2.42782146e-01f, -3.25630568e-02f, 1.75755858e-01f, 2.49453299e-02f,
  4.58560064e-02f, -7.72921648e-03f, 1.36927599e-02f, 1.16109088e-01f, -3.88665013e-02f, -1.72967210e-01f, -1.89272061e-01f, 5.26062511e-02f, 6.96934283e-01f, 1.04910813e-01f,
  -4.08111885e-02f, 3.01987261e-01f, 6.64789379e-02f, 1.94080751e-02f, -3.11154336e-01f, 7.06401514e-03f, -1.86519235e-01f, -1.93091646e-01f, -6.62058219e-03f, 4.49244529e-02f,
  -9.04605463e-02f, 2.18159836e-02f, -6.24436252e-02f, 1.38835236e-01f, 1.78062469e-01f, -4.51695397e-02f, -4.00131978e-02f, -8.09831023e-02f, 1.51864365e-02f, -1.38498515e-01f,
  -3.84516358e-01f, -2.05527991e-01f, 1.52740762e-01f, 8.85324180e-02f, -2.24170804e-01f, -2.08907761e-02f, 1.64439470e-01f, 8.61251354e-02f, 2.47154653e-01f, 2.77497768e-01f,
  -2.70331025e-01f, -2.17538282e-01f, 1.84852108e-01f, -2.02313438e-02f, -1.34985298e-01f, -1.25029400e-01f, 1.38750048e-02f, -6.69873953e-02f, 8.43564421e-02f, -1.60987824e-01f,
  1.02330968e-02f, 1.96378841e-03f, -2.68670870e-03f, -3.32128406e-01f, 7.70919770e-02f, 8.12832415e-02f, 4.42979820e-02f, -1.18762953e-02f, -1.96050722e-02f, 1.74401570e-02f,
  -1.55121073e-01f, 1.17241561e-01f, -8.36200267e-02f, 1.85597520e-02f, 5.10515347e-02f, -2.00232595e-01f, 1.98410433e-02f, 1.02520108e-01f, -9.55908895e-02f, 2.59270400e-01f,
  1.04481764e-01f, -9.09736603e-02f, 9.31610242e-02f, -1.46110311e-01f, -1.27806202e-01f, 1.97292715e-02f, 1.23621546e-01f, 1.12683207e-01f, -1.29350096e-01f, -1.86202541e-01f,
  1.39739379e-01f, 2.64904741e-02f, 7.98356980e-02f, 1.64589196e-01f, 1.01690032e-01f, 1.38584254e-02f, -7.24149030e-03f, -9.61611047e-02f, 5.01207225e-02f, 2.11814418e-01f,
  9.44517553e-02f, -8.17536414e-02f, -1.07194535e-01f, -1.85079530e-01f, -2.62814343e-01f, -1.33660927e-01f, -1.26215935e-01f, 3.18088755e-03f, -1.64862070e-02f, 4.88578193e-02f,
  2.20557481e-01f, 9.56332013e-02f, -2.93776626e-03f, -2.54774749e-01f, 1.47779390e-01f, 7.51003325e-02f, -2.43394271e-01f, -1.58176139e-01f, -3.44813854e-01f, -1.46503687e-01f,
  -1.67134255e-01f, 4.72020417e-01f, -1.82356924e-01f, -2.09488980e-02f, 4.58601676e-03f, 9.08906572e-03f, -4.78339754e-02f, 1.39927268e-01f, 1.80707816e-02f, -7.35317245e-02f,
  2.22520418e-02f, 3.13259521e-03f, -1.95290729e-01f, -1.96389877e-03f, 1.28148884e-01f, -1.72590852e-01f, 1.67050604e-02f, -1.22516174e-02f, -9.90364142e-03f, 8.23875666e-02f,
  -3.28539401e-01f, -9.56930667e-02f, 6.44262955e-02f, 9.30541307e-02f, 7.65737891e-02f, 3.12791318e-02f, -1.73269957e-01f, 5.60272075e-02f, 5.66023737e-02f, 8.21866542e-02f,
  -3.59124035e-01f, -4.04326711e-03f, -1.16950661e-01f, 4.09919888e-01f, -1.64619252e-01f, 1.01314560e-01f, -8.94375145e-02f, -1.99499279e-02f, -1.68819372e-02f, -4.47375290e-02f,
  -4.85965274e-02f, 1.62141770e-01f, 1.63060710e-01f, -1.86235324e-01f, 5.19349612e-02f, 5.99674508e-03f, 2.29843348e-01f, 5.27391955e-02f, -2.27983162e-01f, -1.13349892e-01f,
  2.59533972e-01f, -6.91241100e-02f, 2.24980384e-01f, 2.92744458e-01f, 1.36636332e-01f, -1.10401325e-01f, -2.31100656e-02f, 1.55420929e-01f, 6.13177717e-02f, -1.56346291e-01f,
  9.61799473e-02f, -4.90015559e-02f, 1.08118728e-01f, -5.05180717e-01f, 3.56938504e-02f, -1.47758558e-01f, 2.46394083e-01f, 2.07862053e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.71756953e-01f, 2.32926682e-02f, 2.01491043e-01f, 2.91712582e-01f, -6.16460778e-02f, -1.14540935e-01f, -7.63574094e-02f, -4.16657925e-02f, 4.76804189e-02f, -2.05572844e-01f,
  2.11116046e-01f, -4.64905769e-01f, 6.97391331e-02f, -1.44512996e-01f, -2.35967770e-01f, 1.98846474e-01f, -3.80376488e-01f, -1.14752583e-01f, 6.28517568e-02f, -1.24960341e-01f,
  -1.25250325e-01f, -1.10622965e-01f, -6.03227876e-02f, 1.60431236e-01f, -1.46545351e-01f, -1.12992913e-01f, -4.40261722e-01f, -2.51567096e-01f, -1.27390577e-02f, 5.78775227e-01f,
  2.78291523e-01f, 4.32696342e-02f, -3.34557742e-02f, 1.41298026e-01f, -4.21671644e-02f, 1.82711095e-01f, 2.28995197e-02f, 1.42786264e-01f, 9.79136750e-02f, 2.28303030e-01f,
  -8.58843252e-02f, -1.77877501e-01f, -1.49930358e-01f, -3.27052027e-01f, -9.37078819e-02f, -1.40035190e-02f, -2.71042079e-01f, 4.84455265e-02f, 1.74072415e-01f, 1.82008341e-01f,
  1.49883047e-01f, -1.40842125e-01f, 3.40143412e-01f, -1.14922151e-01f, -1.69268727e-01f, 1.02156669e-01f, -3.68382335e-01f, -1.11607492e-01f, -2.89610833e-01f, -5.46338111e-02f,
  -3.91478986e-01f, 7.59002194e-02f, 1.56104818e-01f, -4.37936597e-02f, -6.76811114e-02f, 2.04758331e-01f, 1.72417879e-01f, 8.10992047e-02f, -2.36359298e-01f, 7.55217522e-02f,
  -2.23943479e-02f, -4.82887030e-02f, 2.53473431e-01f, -2.64854971e-02f, 1.55566379e-01f, -4.73630661e-03f, 2.45833367e-01f, 5.11707738e-02f, 6.17275760e-02f, 1.87182501e-02f,
  7.18734443e-01f, -1.21730871e-01f, 9.52762812e-02f, -2.03793421e-01f, 7.51079619e-02f, 2.41149843e-01f, 2.34332815e-01f, -6.17663935e-02f, 1.59842446e-02f, 1.50313541e-01f,
  -1.72946975e-02f, -4.99994516e-01f, 2.05997154e-01f, -2.56196797e-01f, 5.03920496e-01f, 1.74331501e-01f, -9.06049088e-02f, 1.98676541e-01f, 2.47387275e-01f, -6.48918003e-03f,
  -1.77944247e-02f, 1.86790824e-01f, 2.03294888e-01f, -1.58873051e-01f, 1.69907153e-01f, 8.10441002e-02f, 9.51755866e-02f, 2.16927692e-01f, -1.00950405e-01f, 3.92058538e-03f,
  2.75166124e-01f, -1.22966155e-01f, 2.96637267e-02f, 2.34181777e-01f, 1.64154023e-01f, 1.61103696e-01f, 1.33669630e-01f, -1.30473599e-01f, -1.01920001e-01f, -5.46923995e-01f,
  4.24230784e-01f, -3.47155273e-01f, 3.39595288e-01f, 1.75863683e-01f, 2.58487582e-01f, -4.26001757e-01f, -1.94591567e-01f, 2.64694840e-01f, 8.15551057e-02f, -5.59041882e-03f,
  3.05059552e-01f, 1.78900942e-01f, 1.48036525e-01f, 2.52926528e-01f, 4.36747342e-01f, 2.44954169e-01f, 1.85705587e-01f, 2.36653253e-01f, 2.89629608e-01f, -3.46503049e-01f,
  3.66494119e-01f, -1.87587678e-01f, -2.97918860e-02f, 6.55686185e-02f, 4.84524742e-02f, 9.39713120e-02f, 1.09444365e-01f, -2.72670835e-01f, -8.32881555e-02f, 3.69673908e-01f,
  5.37644982e-01f, 2.17921525e-01f, 3.30592364e-01f, 2.93547750e-01f, 5.59924915e-02f, -3.66513245e-02f, 4.09661680e-02f, -6.53045159e-03f, 3.37560534e-01f, -7.48282894e-02f,
  5.03509268e-02f, 3.28436755e-02f, 9.06377584e-02f, 3.54134947e-01f, 1.55798525e-01f, 1.51629969e-01f, 2.65227437e-01f, 3.08718923e-02f, -3.71052586e-02f, 2.21133828e-01f,
  2.11988226e-01f, -9.14092883e-02f, 1.83051467e-01f, -2.10267663e-01f, 4.08373475e-02f, 7.88056850e-02f, -2.24945173e-01f, -1.81689993e-01f, 1.94822490e-01f, -7.43400007e-02f,
  -1.24485018e-02f, 3.57395172e-01f, -1.51962429e-01f, 1.10427447e-01f, 4.23753053e-01f, 3.44415873e-01f, -4.46500443e-02f, 3.85066956e-01f, 2.76679486e-01f, 1.99154794e-01f,
  1.03991237e-02f, -9.11012068e-02f, -1.98895577e-02f, 2.48259157e-01f, -1.72116056e-01f, 1.56159848e-01f, -7.15533867e-02f, 2.26947486e-01f, 9.74363610e-02f, 2.75906682e-01f,
  -8.71915743e-03f, -3.14456910e-01f, 8.74795839e-02f, -2.63972551e-01f, 3.79291654e-01f, -9.48698968e-02f, -1.51378870e-01f, 1.94618270e-01f, -3.19386125e-01f, -2.17566833e-01f,
  4.18779224e-01f, -1.81054592e-01f, 3.70900333e-02f, 1.38162032e-01f, -2.43564099e-01f, 1.30588755e-01f, 2.77239606e-02f, 7.03552291e-02f, -5.19659042e-01f, -2.12780237e-01f,
  -8.72385055e-02f, 1.08291231e-01f, 4.71871108e-01f, 3.38823259e-01f, -1.69063464e-01f, -5.28722210e-03f, 3.69793549e-02f, -2.03805059e-01f, -1.84205491e-02f, 1.16873302e-01f,
  3.65922600e-01f, 9.56424773e-02f, -9.42668766e-02f, 1.53917074e-01f, 4.04468440e-02f, -3.92405987e-01f, 2.28568278e-02f, 2.10934177e-01f, -1.32225245e-01f, -2.19926029e-01f,
  2.51347303e-01f, 5.61639294e-02f, 8.56983587e-02f, 1.26265816e-03f, 3.05384755e-01f, -1.20290644e-01f, 3.87947738e-01f, -2.54815012e-01f, -3.18096966e-01f, -1.80122018e-01f,
  -2.00343981e-01f, -8.82178545e-03f, -2.91311026e-01f, -9.16045904e-02f, -6.15287304e-01f, -5.42410575e-02f, 1.58412620e-01f, 3.15335780e-01f, 2.59307235e-01f, 5.57200648e-02f,
  7.53157632e-03f, 1.62698016e-01f, 1.53816640e-01f, 1.28827795e-01f, 1.57521561e-01f, 1.03732981e-01f, -2.00084731e-01f, 2.01008379e-01f, -4.35388535e-01f, 2.95632388e-02f,
  1.46705896e-01f, -3.92654210e-01f, 2.01443061e-01f, 3.10605198e-01f, -2.62427360e-01f, -9.36947241e-02f, 1.13241829e-01f, -4.28781249e-02f, 1.14286803e-01f, -4.91200805e-01f,
  3.22673842e-02f, -2.43790627e-01f, 4.54952270e-01f, 1.96265072e-01f, 2.77600646e-01f, -3.58470142e-01f, -2.57323563e-01f, 1.17929995e-01f, 6.05378300e-02f, -2.60733943e-02f,
  6.35337159e-02f, 8.97383094e-02f, 2.54224725e-02f, 1.04820654e-01f, 1.78256750e-01f, 1.11465640e-02f, -3.34399566e-02f, 1.95563436e-01f, -5.28032556e-02f, -1.20808929e-01f,
  1.75939471e-01f, 6.75407946e-02f, 7.73963034e-02f, 3.37170027e-02f, 1.39561057e-01f, 1.31791130e-01f, -8.10116157e-02f, 4.80293743e-02f, 1.34196833e-01f, 2.92922378e-01f,
  4.54823017e-01f, 2.65893966e-01f, 3.90021712e-01f, 3.03554088e-01f, -1.80399597e-01f, 1.18973352e-01f, 1.75866693e-01f, 1.78080738e-01f, 1.97833940e-01f, -7.63907358e-02f,
  3.44976448e-02f, 1.14882439e-01f, 1.44435048e-01f, -1.83355108e-01f, 1.19698025e-01f, 1.48670629e-01f, 1.72987431e-01f, 3.43579203e-02f, 5.06757125e-02f, -3.55580330e-01f,
  -9.46426764e-02f, -3.25871930e-02f, -6.21301889e-01f, -2.44997263e-01f, -2.92314947e-01f, 1.65385678e-02f, -2.42522389e-01f, -7.76545107e-02f, -8.80537629e-02f, -3.11500669e-01f,
  1.31739244e-01f, -1.57393962e-01f, 2.13941038e-01f, 1.36682108e-01f, -2.84201860e-01f, -2.56552905e-01f, 2.00855210e-01f, -1.78227678e-01f, 6.54852241e-02f, 2.19161734e-01f,
  -1.28901154e-01f, 1.23430349e-01f, -5.81018031e-02f, 4.82071117e-02f, -1.63207725e-01f, -1.95554912e-01f, -1.70973148e-02f, 2.19807312e-01f, 3.04619092e-02f, -2.54552606e-02f,
  5.10847904e-02f, -1.03041241e-02f, -1.57153219e-01f, -5.66701181e-02f, -2.81141419e-02f, -2.12637424e-01f, -1.12577364e-01f, 9.30354521e-02f, 1.15068536e-02f, 9.66249928e-02f,
  5.00563800e-01f, 3.15037854e-02f, 1.17522210e-01f, 5.68172336e-02f, -5.19508779e-01f, -3.82748805e-02f, -2.45243311e-01f, -4.96920869e-02f, -5.84834963e-02f, -1.35552332e-01f,
  -3.36394422e-02f, 3.58555578e-02f, 1.23609141e-01f, 4.00600374e-01f, -5.72695881e-02f, -1.32873014e-01f, -2.75437143e-02f, -6.66052476e-02f, -9.76726040e-02f, 1.07637860e-01f,
  1.03223391e-01f, 4.00580056e-02f, 1.19676692e-02f, -1.15296274e-01f, 1.94510594e-01f, -3.96637142e-01f, -1.83246329e-01f, 1.56150788e-01f, -6.99239150e-02f, -2.00738057e-01f,
  -2.25045055e-01f, 2.85227075e-02f, 5.11882782e-01f, 1.89811245e-01f, 1.83165222e-01f, 1.33584395e-01f, -1.52727991e-01f, -9.04329717e-02f, 3.56949866e-01f, 3.19593102e-01f,
  -3.44651908e-01f, -7.69641399e-02f, -1.73490644e-01f, 1.05780870e-01f, 6.70442134e-02f, 1.44882172e-01f, 2.67396390e-01f, 2.64556050e-01f, 4.08744961e-02f, 2.46255860e-01f,
  3.66716146e-01f, 2.70009816e-01f, 3.89974564e-01f, 2.82926112e-01f, 1.61764190e-01f, 1.68154418e-01f, 4.68165018e-02f, 2.90406197e-01f, -4.11092013e-01f, -2.21977770e-01f,
  1.22875445e-01f, -3.05365115e-01f, -7.43872881e-01f, 7.27449432e-02f, 3.79420549e-01f, -1.17066592e-01f, -1.59895316e-01f, -1.32370323e-01f, -2.65202314e-01f, 1.08154818e-01f,
  4.51267242e-01f, -9.25272927e-02f, 2.00135902e-01f, 6.17243946e-01f, 1.01633377e-01f, 5.26947081e-01f, -5.13822287e-02f, 2.92756855e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.06482843e-01f, 1.82097003e-01f, 2.37039983e-01f, 2.92877197e-01f, 2.15225995e-01f, -7.82800764e-02f, 1.02483943e-01f, 1.38025984e-01f, 1.20840617e-01f, 5.66616729e-02f,
  9.01365355e-02f, 1.36334643e-01f, -1.00763487e-02f, -1.10943662e-02f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.90556780e-01f, 2.28785262e-01f, -1.25840664e-01f, -2.75396794e-01f, -4.61686291e-02f, 2.48130277e-01f, 2.44873366e-03f, -8.24214891e-02f, -4.33158688e-02f, -6.76686466e-02f,
  -1.37223661e-01f, -1.51451351e-02f, 2.29631707e-01f, 9.41713750e-02f, -3.78995717e-01f, -5.78545928e-02f, -6.22519255e-02f, -3.06911971e-02f, 2.21803263e-01f, -5.58972716e-01f,
  -1.36080369e-01f, 1.61937773e-01f, 1.65917009e-01f, 4.02107202e-02f, 7.89690912e-02f, -3.10803473e-01f, -1.99077561e-01f, 2.05663107e-02f, -2.15795785e-01f, 1.00433715e-01f,
  2.12294728e-01f, 2.22201303e-01f, -1.27469957e-01f, 2.00651348e-01f, -3.85796070e-01f, 5.56010194e-02f, 2.55934507e-01f, -1.03776023e-01f, -4.18760300e-01f, -3.63472328e-02f,
  3.66212763e-02f, 2.48549744e-01f, 2.15451777e-01f, -7.76257962e-02f, 3.98496449e-01f, -3.73631597e-01f, 1.28686875e-01f, 3.70808154e-01f, -9.40174889e-03f, -2.65849195e-02f,
  1.49368241e-01f, 1.84317201e-01f, -2.01293845e-02f, -1.45809948e-01f, -1.68649286e-01f, -1.89685926e-01f, -2.85599053e-01f, 5.99112928e-01f, 5.96797979e-03f, 1.45436347e-01f,
  7.58855417e-02f, 4.48173704e-03f, -1.56463355e-01f, -2.20614284e-01f, -1.45456046e-01f, -2.22373843e-01f, -8.56179297e-02f, -2.32101306e-01f, -4.76552635e-01f, 1.14259087e-02f,
  3.30284834e-01f, -3.04101616e-01f, 1.63888812e-01f, -4.74327177e-01f, -1.63337797e-01f, 2.40415528e-01f, -3.40259401e-04f, 2.91232318e-01f, -2.34751478e-01f, -2.22515538e-01f,
  1.65638432e-01f, 3.79845560e-01f, -2.11871803e-01f, 7.69208968e-02f, 3.84672314e-01f, -1.77264807e-03f, 9.42419767e-02f, 6.13269508e-02f, -2.13066891e-01f, -2.33787656e-01f,
  1.03227712e-01f, 3.02557319e-01f, -8.98971558e-02f, -1.08892493e-01f, -1.28085494e-01f, -2.91822910e-01f, -1.42046794e-01f, -1.68005034e-01f, -5.30009493e-02f, -4.19006854e-01f,
  -1.19790249e-01f, -1.03396758e-01f, -1.97358996e-01f, -7.91862458e-02f, 2.16017030e-02f, -2.52683967e-01f, -3.89302194e-01f, 1.35688270e-02f, 1.51652664e-01f, -1.16948098e-01f,
  1.37192924e-02f, -2.06614792e-01f, -4.23467577e-01f, 2.17594150e-02f, -1.84014797e-01f, 1.79976150e-02f, 1.83076859e-01f, 1.59509078e-01f, 3.46673350e-03f, -1.45802706e-01f,
  5.17826565e-02f, 1.24024779e-01f, -1.99326407e-02f, -1.07097777e-03f, -2.56011933e-01f, 2.72147506e-01f, -2.62524132e-02f, -4.59997088e-01f, -7.10127456e-03f, -3.27279836e-01f,
  2.74560034e-01f, 2.03440458e-01f, 1.37284979e-01f, -1.54469892e-01f, 1.55414818e-02f, 3.87555026e-02f, 2.24890038e-01f, 8.68028626e-02f, -2.71526068e-01f, -2.15847403e-01f,
  -4.20646131e-01f, 2.58242816e-01f, 1.80820599e-01f, 2.98914194e-01f, 1.75921321e-01f, -2.55800366e-01f, 6.80823401e-02f, 4.69713748e-01f, 1.10375732e-01f, -2.59082943e-01f,
  -2.51055717e-01f, 4.90643457e-03f, 2.05302805e-01f, -2.88394123e-01f, 5.08513562e-02f, -2.11644903e-01f, 3.33093941e-01f, 2.34130666e-01f, -1.10767037e-01f, 1.03821613e-01f,
  -7.10059553e-02f, 3.48761231e-02f, -2.98043758e-01f, 1.43726408e-01f, -2.02989101e-01f, -1.94450364e-01f, -2.13735566e-01f, -3.41417193e-02f, -4.80896644e-02f, 3.25005233e-01f,
  2.06117287e-01f, 1.26169518e-01f, 1.23633422e-01f, -2.36070916e-01f, 1.50262013e-01f, -2.07914576e-01f, -2.54027903e-01f, 7.26720914e-02f, -4.67432261e-01f, 8.52133799e-03f,
  1.89656883e-01f, 2.64218807e-01f, -1.34977475e-01f, -5.56502193e-02f, -2.21051052e-01f, -3.99535261e-02f, 1.79904178e-01f, 8.00174028e-02f, -9.08677354e-02f, 4.58352976e-02f,
  6.60088956e-02f, -1.97537690e-02f, -3.39886099e-02f, 5.04246168e-02f, 7.98935220e-02f, -1.10444330e-01f, -9.02813748e-02f, -2.30343863e-01f, -1.60061046e-01f, -2.79352397e-01f,
  -1.46505116e-02f, -2.63124436e-01f, 2.04861134e-01f, -1.16450615e-01f, 1.85877204e-01f, 2.55461931e-01f, -1.12919115e-01f, 4.52588737e-01f, 1.79328337e-01f, 3.21858346e-01f,
  3.50833833e-01f, -3.46350074e-02f, -9.77249295e-02f, -7.24512637e-02f, -9.12507623e-03f, -7.85107613e-02f, 2.45245591e-01f, 3.18934619e-01f, -1.76075876e-01f, 2.11938061e-02f,
  6.24691769e-02f, 1.55883515e-03f, 2.11598575e-01f, 6.07339153e-03f, 9.91739780e-02f, 2.55561113e-01f, 3.44289420e-03f, -1.61900580e-01f, -1.27352417e-01f, -2.63278514e-01f,
  2.13696510e-01f, -1.49683237e-01f, -7.85725489e-02f, 1.07610291e-02f, 7.06275553e-02f, -1.10355288e-01f, 1.62466764e-01f, 3.02142918e-01f, -4.22644705e-01f, 2.17469409e-01f,
  1.99516609e-01f, 1.98597252e-01f, 1.76347084e-02f, -3.31062704e-01f, -3.19013208e-01f, 1.22564226e-01f, 7.48641267e-02f, 1.26733750e-01f, -1.15693234e-01f, -2.62581259e-01f,
  6.07287511e-03f, 9.44626331e-02f, 1.96287453e-01f, 5.84631935e-02f, 2.14405730e-01f, 2.52558917e-01f, 8.37550983e-02f, 1.22741774e-01f, -1.17940426e-01f, 1.75129384e-01f,
  -2.73704976e-01f, 1.44052625e-01f, -7.79160634e-02f, -1.62715942e-01f, 1.22235537e-01f, -3.20008814e-01f, -1.07427143e-01f, 7.65797943e-02f, -2.81149715e-01f, -1.17678018e-02f,
  6.25018403e-02f, 1.57629967e-01f, -2.26240233e-01f, 1.88216716e-01f, -2.25793391e-01f, 5.03215492e-01f, 1.53252363e-01f, 9.15548801e-02f, -2.42214929e-03f, -2.28399351e-01f,
  1.41433463e-01f, 3.37221205e-01f, -2.80901436e-02f, -2.39583492e-01f, 1.53654991e-02f, -7.18139112e-02f, -2.71740496e-01f, -1.77694067e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.62632130e-02f, 4.45315063e-01f, -1.33064181e-01f, -1.71535552e-01f, -1.61409438e-01f, -7.64379948e-02f, 1.79419026e-01f, -1.32863760e-01f, 1.60805166e-01f, -6.47121221e-02f,
  -1.03744946e-01f, 1.71287462e-01f, -1.84315547e-01f, -2.60869390e-04f, -3.79029453e-01f, 1.41050592e-01f, 2.71919519e-01f, -1.96215868e-01f, -1.88821733e-01f, 1.19250767e-01f,
  2.78223045e-02f, 1.40415831e-02f, -1.48916915e-01f, -1.07955866e-01f, -8.76166299e-02f, 1.26711354e-01f, 1.04392044e-01f, -3.65637243e-02f, 1.16953999e-01f, 3.19986069e-03f,
  2.90711410e-04f, -9.78100821e-02f, -3.38764906e-01f, -2.05534607e-01f, 4.47486848e-01f, 2.65485011e-02f, -8.63458589e-02f, -2.67357435e-02f, 3.32367718e-01f, -8.60238224e-02f,
  5.24839342e-01f, -5.43180406e-01f, -5.02612293e-01f, -2.94288903e-01f, -5.81938624e-01f, 6.29379749e-01f, 4.25567590e-02f, 8.09052140e-02f, 6.27728403e-02f, 6.28631830e-01f,
  2.54819870e-01f, 2.68505603e-01f, 3.11596930e-01f, 2.36020293e-02f, 1.47512939e-03f, 3.45569029e-02f, 4.37248975e-01f, 3.48502249e-01f, 3.01987886e-01f, -1.32851794e-01f,
  4.25301909e-01f, 1.39267877e-01f, 3.97729035e-03f, 3.32377516e-02f, 4.21367854e-01f, 5.44115901e-01f, 8.87849461e-03f, 2.18273401e-01f, 3.84568930e-01f, 4.86602277e-01f,
  -2.09914148e-01f, 4.05873239e-01f, 2.07254529e-01f, 9.03863668e-01f, -4.19985026e-01f, -2.55330354e-01f, 4.73331928e-01f, -5.01060307e-01f, -4.64232057e-01f, 4.15387601e-01f,
  3.05252254e-01f, -5.12468517e-01f, 2.37622485e-01f, 2.81501919e-01f, 1.15691423e-02f, -2.65808493e-01f, 8.29427876e-03f, 5.57231018e-03f, 1.38179213e-01f, -1.75455883e-01f,
  -3.22752893e-01f, 1.88413337e-01f, 3.66675586e-01f, -1.21125348e-01f, -4.81669486e-01f, 9.85728130e-02f, 1.19406097e-01f, -2.09015980e-01f, 5.46009898e-01f, 7.86627382e-02f,
  1.77936926e-01f, 9.64003280e-02f, 2.14347377e-01f, -8.42092782e-02f, 4.44282621e-01f, -3.80848914e-01f, -1.12389117e-01f, -4.09489810e-01f, -4.24235821e-01f, 4.26253796e-01f,
  -9.46960598e-02f, 1.75865278e-01f, 1.64640084e-01f, 9.79410950e-03f, 3.95415455e-01f, -5.98399825e-02f, 2.96029776e-01f, -7.19156265e-02f, 4.86399792e-02f, 3.31515521e-01f,
  3.25670242e-01f, -3.46121907e-01f, -1.50023043e-01f, 2.47403495e-02f, 3.97894353e-01f, 1.89534754e-01f, 2.26539731e-01f, 4.24538761e-01f, 1.32411942e-01f, 5.72729528e-01f,
  -4.36723650e-01f, 8.92697647e-02f, 5.48663363e-02f, 7.59070292e-02f, 1.40491992e-01f, 2.65447468e-01f, -7.63399452e-02f, 2.04431452e-02f, 2.17357770e-01f, 3.37682217e-01f,
  4.95933473e-01f, -2.96594709e-01f, -1.89019948e-01f, 1.24970842e-02f, 2.57284105e-01f, -2.69102722e-01f, -2.60555208e-01f, -2.98923016e-01f, -2.00297907e-01f, -1.87213331e-01f,
  4.69756305e-01f, 2.52994657e-01f, 4.57318462e-02f, -2.94843554e-01f, -1.66647956e-01f, 2.19812915e-01f, -2.01176122e-01f, -2.25377187e-01f, 3.40238810e-02f, 3.74020815e-01f,
  1.01234652e-01f, 3.46174240e-02f, -1.25666233e-02f, 1.81213677e-01f, 2.74779767e-01f, 1.91140085e-01f, -5.47240004e-02f, -2.11622119e-01f, -1.53929666e-01f, -4.14152384e-01f,
  1.62632883e-01f, 1.94136485e-01f, 2.64886916e-01f, 5.55883907e-03f, -4.46819454e-01f, -4.14589703e-01f, 1.72656804e-01f, -2.29789391e-02f, 8.95760283e-02f, 6.62074089e-02f,
  2.39058793e-01f, -4.39660512e-02f, 3.31327707e-01f, 4.39141482e-01f, 5.26062548e-01f, -6.59903884e-01f, -1.88075751e-01f, 4.06281918e-01f, -4.67763454e-01f, -8.07400942e-02f,
  -8.19459558e-02f, 2.49903440e-01f, -2.51383126e-01f, -1.53093204e-01f, -1.51511088e-01f, 9.46235731e-02f, -4.26397994e-02f, -8.13563645e-04f, 3.16428363e-01f, 6.23435862e-02f,
  2.00233117e-01f, -5.87392211e-01f, 6.73748776e-02f, 3.48857641e-01f, 5.61319292e-01f, -1.86944958e-02f, -1.29035681e-01f, -2.01671958e-01f, -1.55077562e-01f, 2.97219723e-01f,
  9.25807282e-02f, 1.61699429e-01f, 2.21272707e-01f, -1.20596565e-01f, 3.71959716e-01f, 8.34522471e-02f, 7.53044989e-03f, 8.97055045e-02f, 1.78504691e-01f, 1.60822108e-01f,
  -5.41977137e-02f, -2.23923638e-01f, -6.14714585e-02f, -1.41209483e-01f, 1.21444747e-01f, -1.27940103e-01f, -1.03122532e-01f, 9.09555629e-02f, 3.06839794e-01f, 5.99423647e-01f,
  7.50709996e-02f, 6.77757442e-01f, 4.88566220e-01f, 4.45435554e-01f, -1.88968912e-01f, 4.25760895e-01f, -3.16708833e-01f, -3.78765881e-01f, 3.73738140e-01f, -6.77581251e-01f,
  -4.26328212e-01f, 1.55360833e-01f, -2.31260151e-01f, -8.66145939e-02f, 4.15126681e-01f, 1.71760648e-01f, 2.82764256e-01f, 2.17582494e-01f, -1.52516171e-01f, -1.01423442e-01f,
  4.28515762e-01f, -1.27034888e-01f, 1.71600476e-01f, -2.18483359e-01f, -4.96168852e-01f, 1.74789791e-04f, 3.36616665e-01f, 1.01204216e-01f, -1.19033828e-01f, -9.82249249e-03f,
  -2.82899529e-01f, 1.90725043e-01f, 1.36353582e-01f, 3.52629721e-01f, 5.29108755e-02f, -9.96788517e-02f, -4.12347466e-02f, 5.16939342e-01f, 2.32207566e-01f, -1.73610002e-01f,
  6.32694215e-02f, -1.17359236e-01f, -2.36409172e-01f, 2.54648983e-01f, -5.38409710e-01f, -2.09204659e-01f, -4.05230485e-02f, 3.77409399e-01f, 1.04202069e-01f, 1.17569296e-02f,
  -2.37903729e-01f, 2.20304757e-01f, 5.04117489e-01f, 3.29498574e-03f, 1.52031064e-01f, 3.16906683e-02f, -1.05077274e-01f, 2.60870606e-01f, -2.75641114e-01f, 3.06634694e-01f,
  -5.46892047e-01f, -7.66887814e-02f, -3.00375819e-01f, 1.18757682e-02f, 1.78428978e-01f, 1.47771388e-01f, 1.29050374e-01f, -3.83632928e-01f, -2.23814398e-01f, 1.53674722e-01f,
  5.33742249e-01f, -3.82379740e-01f, -3.83517295e-02f, 1.12569898e-01f, -3.01791936e-01f, 2.60160983e-01f, 7.93587044e-02f, 1.15121752e-01f, 2.78655171e-01f, 4.56306115e-02f,
  3.40603977e-01f, -1.74711019e-01f, 2.99489126e-02f, 3.32666159e-01f, 8.96749198e-02f, 1.64031163e-01f, 1.86879337e-01f, -1.90429967e-02f, -3.60021181e-02f, -4.37804490e-01f,
  -2.49706775e-01f, 2.07847551e-01f, 2.58764744e-01f, -3.20859961e-02f, 7.02686831e-02f, 1.12588204e-01f, 2.79377520e-01f, 3.22269127e-02f, 2.15524673e-01f, -5.40015519e-01f,
  -3.53303224e-01f, 1.38615921e-01f, 1.63582504e-01f, 5.68050258e-02f, -3.94768059e-01f, -5.04394285e-02f, 5.80448564e-03f, 5.20021141e-01f, 4.04729605e-01f, 2.45457307e-01f,
  3.30672354e-01f, 3.76229957e-02f, 3.64292026e-01f, -3.43644507e-02f, 2.25889504e-01f, 1.23359255e-01f, -4.03349362e-02f, 1.78001553e-01f, 2.53102630e-01f, 1.70447499e-01f,
  8.43167901e-02f, -2.94542518e-02f, 1.75249383e-01f, -4.36774828e-02f, 2.48875141e-01f, 1.57319263e-01f, -4.42885747e-03f, 1.72418635e-02f, 1.09645151e-01f, 3.11332494e-01f,
  2.78062791e-01f, 3.46567303e-01f, -7.05386028e-02f, -1.54508963e-01f, -3.06526273e-01f, 2.10925296e-01f, 2.85959482e-01f, -1.15509750e-02f, -3.24584655e-02f, -2.82593481e-02f,
  -1.84915110e-01f, 4.55310866e-02f, -2.26550087e-01f, 4.09027636e-01f, -2.11664349e-01f, 1.83739260e-01f, -1.48255154e-01f, -1.89542398e-01f, 3.73799950e-01f, -5.28027788e-02f,
  2.75229245e-01f, 2.01678008e-01f, 6.54761270e-02f, 5.64791083e-01f, -1.02791689e-01f, -2.16430098e-01f, -4.15391982e-01f, 3.09269905e-01f, -1.31699637e-01f, 3.51995230e-01f,
  -2.34191850e-01f, 8.03696588e-02f, -3.45450640e-01f, -1.20521635e-01f, 2.07469910e-01f, 1.25070084e-02f, -1.04222320e-01f, -3.20344605e-02f, 2.16781631e-01f, 8.98354501e-02f,
  -4.23380673e-01f, -7.16346130e-02f, -5.47354482e-02f, 1.78696379e-01f, -1.97000638e-01f, 8.99632573e-02f, -1.68926492e-01f, -1.25193089e-01f, -1.96150124e-01f, 6.39397725e-02f,
  -1.53297558e-01f, 9.13110971e-02f, 9.50435624e-02f, 1.14508219e-01f, 2.87298441e-01f, -4.24254477e-01f, -7.87062384e-03f, -3.74907553e-01f, 2.35744432e-01f, 2.46450514e-01f,
  -2.44267419e-01f, -1.22824080e-01f, -4.19175886e-02f, -3.65603983e-01f, 1.07629940e-01f, -5.79704225e-01f, -3.57405022e-02f, 9.94787291e-02f, -2.54502058e-01f, 2.70137638e-01f,
  -2.36635208e-01f, 1.64600667e-02f, 1.94996074e-02f, 4.06836480e-01f, 1.37789212e-02f, -7.70228133e-02f, 2.73423940e-01f, 2.27489218e-01f, 7.08822757e-02f, 8.58121067e-02f,
  2.19247907e-01f, 3.73084843e-02f, 8.91189426e-02f, 2.84266584e-02f, -2.38976717e-01f, 1.28328100e-01f, 1.72307089e-01f, -5.32697886e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  7.57579692e-03f, 1.31699324e-01f, 3.84081125e-01f, 2.59728789e-01f, -6.82051703e-02f, 1.59982920e-01f, 1.21699013e-02f, 1.75678030e-01f, 2.33721301e-01f, 9.19128284e-02f,
  1.55785322e-01f, 1.69176519e-01f, 1.22121982e-01f, 2.48758662e-02f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  1.96329445e-01f, 3.75274390e-01f, -2.09678054e-01f, 1.58396676e-01f, 1.47837833e-01f, -3.03461105e-02f, -2.16614097e-01f, 2.68734664e-01f, -7.03836326e-03f, 8.68603401e-03f,
  2.43858337e-01f, 5.06574139e-02f, 3.78756106e-01f, 1.76673278e-01f, -2.37832695e-01f, 4.20414627e-01f, -2.77263820e-01f, 3.39979976e-01f, 1.02905519e-01f, 2.33404875e-01f,
  3.33188176e-01f, -5.81687093e-02f, -1.83632523e-01f, -1.65010393e-01f, -9.15527716e-02f, 9.39827040e-02f, -1.16750151e-01f, 1.78029925e-01f, 5.01720160e-02f, -1.85182512e-01f,
  -6.43865438e-03f, -6.75011799e-02f, 4.25528795e-01f, 1.52484849e-01f, -1.65269122e-01f, 1.04191482e-01f, 6.96934164e-02f, 2.66128868e-01f, 2.12489828e-01f, 1.48804769e-01f,
  -2.09860653e-02f, -4.61126059e-01f, -1.67015478e-01f, -2.52896011e-01f, -5.33713043e-01f, 3.40572178e-01f, -3.19424421e-01f, 2.69648045e-01f, -1.22926794e-01f, 2.40062043e-01f,
  1.93950906e-01f, 6.69313669e-02f, 1.52853400e-01f, 1.80152461e-01f, -1.13047689e-01f, -3.08040027e-02f, -2.91682690e-01f, 1.42550534e-02f, -1.51148522e-02f, -8.32824036e-02f,
  -1.34157583e-01f, 1.56123221e-01f, -1.94771528e-01f, -2.50575900e-01f, 3.24129522e-01f, -7.38637894e-02f, 1.47451326e-01f, -3.66444439e-02f, -6.64866641e-02f, -8.11902732e-02f,
  7.65712932e-02f, 3.54526013e-01f, 7.11397035e-03f, -1.15645118e-01f, 1.68525696e-01f, 4.95777354e-02f, 2.93839514e-01f, -1.79935724e-01f, -2.46611223e-01f, -1.56430811e-01f,
  -9.99976546e-02f, 1.10044636e-01f, 2.47965893e-03f, -2.00380515e-02f, -4.05360200e-03f, -2.33547121e-01f, 2.12092772e-01f, 1.23301342e-01f, 2.16607824e-01f, 2.20252082e-01f,
  -1.92831457e-01f, 2.85257772e-03f, -3.48250940e-02f, -3.33514512e-01f, -1.61322832e-01f, 4.40620817e-02f, -2.76953548e-01f, 3.24583463e-02f, -2.88852096e-01f, 7.75224715e-02f,
  -2.29781643e-01f, 1.13134131e-01f, 9.03829411e-02f, -2.35424384e-01f, 3.33172902e-02f, -5.64840771e-02f, -8.78731161e-02f, -1.31048635e-01f, -1.11783862e-01f, 3.17840368e-01f,
  3.05615906e-02f, 1.50737941e-01f, 2.17656597e-01f, -3.77097696e-01f, 1.90215737e-01f, 1.30757943e-01f, 1.58629976e-02f, -1.44840330e-01f, -6.00606129e-02f, -1.83298409e-01f,
  -2.70086288e-01f, -6.60317242e-02f, -1.61269624e-02f, 2.54622232e-02f, -6.75785616e-02f, 3.57729495e-01f, 2.25405529e-01f, 1.06660023e-01f, 5.07503226e-02f, 2.62131691e-01f,
  -3.38979572e-01f, -1.94727972e-01f, -4.77137387e-01f, 1.05138972e-01f, 5.28180040e-02f, 2.59520803e-02f, -9.35136527e-03f, 1.14347786e-02f, 2.40587279e-01f, -1.50734022e-01f,
  -5.87248683e-01f, 1.85062230e-01f, 3.07219654e-01f, 2.67815620e-01f, 5.12372971e-01f, -7.43249133e-02f, -5.47693521e-02f, -2.24156126e-01f, 1.45982497e-03f, -8.65039229e-02f,
  3.35410416e-01f, -2.01296695e-02f, 5.20302122e-03f, -8.25336389e-03f, 1.15922697e-01f, 2.68360585e-01f, -1.39283566e-02f, 1.21350311e-01f, 3.87428463e-01f, -6.08157702e-02f,
  2.56299108e-01f, -3.52841656e-04f, 2.32164249e-01f, -5.21198995e-02f, -3.78610119e-02f, -2.44689137e-02f, 2.57000625e-01f, 5.30753955e-02f, 2.66206652e-01f, 1.57430187e-01f,
  2.77556986e-01f, -5.25847897e-02f, 1.36011764e-01f, -3.12956601e-01f, 1.87677264e-01f, -4.36358690e-01f, -2.69816279e-01f, 1.21428922e-01f, 1.33026019e-01f, -1.43086970e-01f,
  -3.69917490e-02f, -1.55533925e-01f, 1.13212444e-01f, 1.94446027e-01f, 2.34856069e-01f, 2.12677196e-02f, -1.32704312e-02f, 1.29385898e-02f, 3.75481229e-03f, -3.00993145e-01f,
  -2.36501411e-01f, 9.71377939e-02f, -4.74036932e-02f, 8.36476311e-02f, -4.11661640e-02f, 2.18964573e-02f, -1.06999837e-01f, 2.99586542e-02f, -2.18421802e-01f, -2.42798515e-02f,
  -3.34348083e-02f, 1.05284378e-01f, 1.91836525e-02f, 2.23368369e-02f, -5.64948678e-01f, 2.44295508e-01f, -1.65334463e-01f, 3.83149944e-02f, 5.29953428e-02f, -1.39907494e-01f,
  3.48858461e-02f, 1.79850653e-01f, 2.80811582e-02f, 5.66933602e-02f, 1.57905191e-01f, 1.69647112e-01f, 2.11946532e-01f, -3.68111506e-02f, -3.16371769e-01f, -2.65249521e-01f,
  1.17027864e-01f, -1.63851812e-01f, -1.47583440e-01f, -2.29272917e-01f, 1.14771150e-01f, -2.32728779e-01f, 3.53608817e-01f, -2.10979223e-01f, 1.01326533e-01f, 9.97123271e-02f,
  -3.57094631e-02f, -1.10024609e-01f, -2.02367947e-01f, -1.51951313e-01f, -1.40942678e-01f, -1.29455954e-01f, 9.23443809e-02f, -3.10113788e-01f, 2.15587035e-01f, -2.34710500e-01f,
  2.21335310e-02f, -1.67268351e-01f, -1.28657266e-01f, -2.60096312e-01f, -2.24029213e-01f, -1.01851784e-01f, 2.03278303e-01f, 3.61920930e-02f, 2.92352568e-02f, 8.75247791e-02f,
  2.45784461e-01f, -2.05062494e-01f, -8.77659544e-02f, 9.78135318e-02f, 7.55200312e-02f, 1.62608922e-01f, 1.44654155e-01f, -1.05505235e-01f, 3.47932160e-01f, 3.28445762e-01f,
  -2.70657148e-02f, 3.47181350e-01f, -4.14805450e-02f, 1.13786474e-01f, 5.97788617e-02f, -1.11149758e-01f, -1.33157209e-01f, 3.22882384e-01f, 2.70333588e-01f, 1.68370292e-01f,
  4.25108582e-01f, 6.23784289e-02f, -1.68130457e-01f, 1.16395764e-01f, -9.70492736e-02f, 1.32376313e-01f, -2.44340166e-01f, 2.20072716e-01f, -1.79580331e-01f, -1.03108697e-01f,
  6.26949072e-02f, 1.12425406e-02f, 1.19896173e-01f, 3.34957391e-01f, 6.10761940e-02f, 1.95324118e-03f, 1.75324038e-01f, 2.63785720e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  5.27681172e-01f, 1.41843349e-01f, -1.05806552e-01f, 1.40634060e-01f, -5.61932266e-01f, 3.14712465e-01f, 7.98222721e-02f, 5.31841099e-01f, 2.50131905e-01f, -6.66741312e-01f,
  5.20303398e-02f, -5.62687874e-01f, -4.62170929e-01f, 4.61954296e-01f, -4.25173640e-02f, 2.88401842e-01f, 2.09038377e-01f, 1.71340510e-01f, -1.39438203e-02f, 2.66203642e-01f,
  -1.47408769e-01f, -7.41286948e-02f, -3.42898279e-01f, -8.62890005e-01f, -8.56281538e-03f, 1.78213231e-02f, 3.25414449e-01f, 3.15829962e-01f, 1.78025931e-01f, 3.87916714e-01f,
  1.92517355e-01f, 2.89261602e-02f, 1.56556547e-01f, -2.39202902e-02f, 7.37575829e-01f, 1.34534031e-01f, 4.19154525e-01f, 7.79405832e-01f, 1.36831716e-01f, 1.70036018e-01f,
  -1.35245472e-01f, 6.78751245e-02f, -3.20180744e-01f, -7.90339187e-02f, 1.00390278e-02f, 1.49420202e-01f, -1.26282826e-01f, -2.86617190e-01f, 2.97283947e-01f, -1.09351344e-01f,
  8.20082088e-04f, 4.17600513e-01f, -1.83598161e-01f, 3.13636333e-01f, -4.44026291e-02f, -3.89202237e-02f, -1.78707168e-01f, 3.76825780e-01f, 2.92841434e-01f, -4.67000782e-01f,
  -7.54404068e-02f, 5.46248376e-01f, -2.19636202e-01f, 1.37731329e-01f, -4.60535616e-01f, 2.23671533e-02f, -3.92050803e-01f, -3.25125754e-01f, 1.37343869e-01f, -7.20920742e-01f,
  -5.72009265e-01f, -2.07498670e-01f, 3.69949967e-01f, 2.91138172e-01f, 7.55181387e-02f, -5.22684991e-01f, 3.62267941e-02f, 3.09241623e-01f, 3.50845307e-01f, 3.00092071e-01f,
  2.44712755e-01f, -2.10023180e-01f, 9.69494283e-02f, 3.69688720e-01f, 3.47578555e-01f, 3.81763637e-01f, -1.24750353e-01f, -1.97754940e-03f, -1.26954094e-01f, -4.30331051e-01f,
  -6.45647794e-02f, -1.14600055e-01f, 1.89442843e-01f, 1.24300748e-01f, 6.55154660e-02f, 1.89369217e-01f, -1.69928484e-02f, 1.94433525e-01f, -4.74319011e-02f, -1.98176578e-01f,
  3.24947596e-01f, 1.60706341e-01f, 1.27938017e-01f, 1.54262885e-01f, 5.69570214e-02f, 5.63842177e-01f, -2.89491937e-02f, -2.55084604e-01f, -3.91850382e-01f, -4.94685113e-01f,
  -1.53248832e-01f, -4.25531000e-01f, 6.37737572e-01f, -8.74670804e-01f, -7.09466264e-02f, -2.10066155e-01f, 4.02574539e-01f, -4.89436090e-02f, 3.53758335e-01f, 9.97584239e-02f,
  -3.97033766e-02f, 5.79976857e-01f, 3.89829189e-01f, 2.28377044e-01f, -5.00582829e-02f, 2.97334462e-01f, 5.79513088e-02f, -1.71477631e-01f, -2.17050672e-01f, -9.08858515e-03f,
  9.31112692e-02f, -8.45682800e-01f, 2.91087300e-01f, -2.88904518e-01f, -1.08853199e-01f, -5.36023319e-01f, -4.01636004e-01f, -2.59034187e-01f, -2.23375842e-01f, -2.22451672e-01f,
  4.18932699e-02f, -5.17051935e-01f, -4.29683745e-01f, 2.08935618e-01f, 3.29476058e-01f, 1.75055638e-02f, -2.24494021e-02f, -3.03416669e-01f, 4.13682967e-01f, 2.02985615e-01f,
  3.75485748e-01f, 2.26414070e-01f, -1.05643317e-01f, -1.58846736e-01f, 1.87394947e-01f, -3.74825597e-01f, 8.49433430e-03f, 1.17026895e-01f, 2.31734678e-01f, 9.65254158e-02f,
  -6.07006967e-01f, 1.67982906e-01f, 1.06406920e-01f, -3.03403199e-01f, 4.22834828e-02f, 1.11809060e-01f, -1.17283419e-01f, -2.42495880e-01f, -1.56710282e-01f, 3.56219441e-01f,
  5.36074303e-02f, 1.39672700e-02f, -1.68735355e-01f, -4.24129218e-01f, -1.62059620e-01f, 1.20812155e-01f, 2.16931745e-01f, -4.96045023e-01f, 4.87954728e-02f, -1.16320208e-01f,
  1.29765600e-01f, 9.11293477e-02f, 6.38370156e-01f, 5.68126857e-01f, 2.06049964e-01f, -2.13003140e-02f, 4.81790341e-02f, -4.62088883e-02f, 1.93945676e-01f, 5.58764227e-02f,
  2.02157367e-02f, 6.93945074e-03f, -1.04638271e-01f, 3.33754927e-01f, -1.22674644e-01f, 4.80954982e-02f, -3.56337547e-01f, -4.26915616e-01f, -5.95149361e-02f, 4.51616079e-01f,
  1.73155099e-01f, 7.42031410e-02f, -2.18054801e-01f, -3.21734548e-01f, -1.40183657e-01f, 3.53264570e-01f, -7.26158172e-02f, 5.60455203e-01f, -7.00090602e-02f, 3.47724557e-01f,
  -1.54915020e-01f, 3.25702846e-01f, 4.46580768e-01f, 3.86504441e-01f, 3.34932178e-01f, 3.56629044e-01f, 1.87476024e-01f, -6.25888109e-01f, -3.29361111e-01f, 3.72767359e-01f,
  1.96953982e-01f, -1.77854225e-01f, 7.44952261e-02f, 3.17316353e-01f, -6.70671761e-01f, -5.47930658e-01f, 2.95459330e-01f, -5.06439447e-01f, 3.93924147e-01f, -4.16699313e-02f,
  -1.97076425e-01f, -7.74406672e-01f, 1.15887269e-01f, 2.77678639e-01f, 2.48094320e-01f, -3.24056178e-01f, -3.56530070e-01f, 2.37383340e-02f, 1.93226159e-01f, -4.00125802e-01f,
  4.59438711e-01f, -5.02902508e-01f, 1.43590569e-01f, 3.09971422e-01f, -1.69521406e-01f, 2.39842191e-01f, 1.60242289e-01f, -4.71155904e-02f, -1.82642028e-01f, -6.99103326e-02f,
  1.21827208e-01f, -2.89013118e-01f, 2.95954384e-02f, -3.17314602e-02f, -2.19303295e-01f, 2.38255009e-01f, 3.49430770e-01f, 2.58937061e-01f, 1.81541577e-01f, 4.08695549e-01f,
  -4.00964767e-01f, 2.41413817e-01f, 1.94547832e-01f, 5.10223091e-01f, 3.17729563e-01f, -2.95869052e-01f, 5.41161478e-01f, -3.64260264e-02f, -2.45301530e-01f, -9.06754434e-02f,
  7.08333403e-03f, 5.42684019e-01f, 6.40392005e-02f, 9.32450369e-02f, 2.72077203e-01f, 1.41814113e-01f, -1.50821665e-02f, -1.06883250e-01f, 2.64962614e-01f, -4.09899414e-01f,
  2.77478307e-01f, -1.52787184e-02f, 9.44588929e-02f, 4.35598731e-01f, 6.12394921e-02f, -1.12192847e-01f, -1.31353736e-01f, -5.46757616e-02f, 1.09817974e-01f, -2.03718662e-01f,
  5.08532405e-01f, -1.95234358e-01f, 4.93161678e-02f, -1.23425692e-01f, 1.67622697e-02f, 1.68644592e-01f, 2.86396388e-02f, -1.62410229e-01f, -3.43136668e-01f, -3.83556843e-01f,
  2.56787956e-01f, 3.13494682e-01f, -4.22413260e-01f, 2.75411867e-02f, -3.46053749e-01f, 6.19086325e-01f, -3.12190922e-03f, 5.96007288e-01f, -6.45499229e-02f, 2.85493433e-01f,
  -2.07437262e-01f, 2.67640680e-01f, -1.14979252e-01f, -1.21858738e-01f, -1.54335245e-01f, -3.38084877e-01f, 2.61094421e-01f, 1.42687559e-01f, -5.11398725e-02f, 3.98749828e-01f,
  -1.33065596e-01f, 4.36340898e-01f, -5.51981986e-01f, -2.67069668e-01f, -2.26183116e-01f, 2.60206610e-01f, 1.60290688e-01f, 2.17633829e-01f, 5.10840178e-01f, 6.61478400e-01f,
  4.13318649e-02f, -4.33884673e-02f, -4.66425031e-01f, -1.70859009e-01f, -3.77447456e-01f, 1.09333180e-01f, 4.13045555e-01f, -5.55722892e-01f, -2.12547541e-01f, -5.49679287e-02f,
  3.56833547e-01f, 5.82840107e-02f, 6.42345399e-02f, 1.70753263e-02f, 8.26135799e-02f, 1.80397287e-01f, -7.34231109e-03f, 1.21147014e-01f, 1.84943024e-02f, 8.52922630e-03f,
  1.73005372e-01f, -1.49214461e-01f, 5.32670738e-03f, -3.36596996e-01f, 6.36628747e-01f, 3.31536471e-03f, -4.96897459e-01f, -1.46681130e-01f, 2.03801095e-01f, -3.68139595e-01f,
  -3.27388406e-01f, -5.61455727e-01f, -6.08163960e-02f, 7.03421593e-01f, -4.17062342e-02f, -3.39579850e-01f, -2.97406316e-01f, 7.99577981e-02f, -5.04009426e-01f, 5.29136896e-01f,
  1.07848547e-01f, 1.18736383e-02f, -2.58941889e-01f, 1.16578132e-01f, 2.31520012e-01f, 4.41678822e-01f, 5.09055376e-01f, 1.62958875e-01f, 2.50752002e-01f, 2.74736136e-01f,
  2.67562062e-01f, -1.84268177e-01f, 5.73523603e-02f, 3.09284180e-01f, 2.98547536e-01f, -8.21837857e-02f, 2.25646377e-01f, 4.78860736e-01f, -3.27776484e-02f, -2.39490882e-01f,
  -1.55489281e-01f, -1.87727123e-01f, 3.07023287e-01f, -2.56402433e-01f, 1.87263533e-01f, 7.59766519e-01f, 3.10694963e-01f, -3.88950594e-02f, 7.31128335e-01f, -3.42393428e-01f,
  -4.23121065e-01f, 2.41686344e-01f, 1.71017766e-01f, 4.35723096e-01f, -4.70784217e-01f, 3.80233824e-02f, -2.70614386e-01f, 1.47709027e-01f, 4.28526849e-01f, 5.63623726e-01f,
  3.91458720e-01f, 4.12338465e-01f, 3.63279164e-01f, 1.43450528e-01f, -1.99394301e-01f, 3.60030159e-02f, 4.51843917e-01f, 4.45085377e-01f, -3.55313987e-01f, 3.21732908e-01f,
  5.66719234e-01f, -2.47579142e-01f, 3.60163510e-01f, 5.67755818e-01f, -4.09690924e-02f, 3.34781110e-01f, -8.86458576e-01f, -3.35540622e-01f, 3.15192848e-01f, 2.91468948e-01f,
  -8.47655311e-02f, -2.66517937e-01f, -2.23436090e-03f, -1.79778427e-01f, -2.08485588e-01f, -7.23147169e-02f, 8.54293704e-01f, 9.88611057e-02f, -5.90677955e-05f, 1.03978045e-01f,
  -8.74325708e-02f, 5.88211477e-01f, -2.07693368e-01f, -1.69909541e-02f, 7.27325678e-03f, 3.86299156e-02f, -2.37142041e-01f, -3.11664999e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  2.23265827e-01f, 3.08860391e-01f, -1.17906250e-01f, 3.70098948e-01f, 1.22303881e-01f, -6.34429753e-02f, 1.26422167e-01f, 1.89413480e-03f, 9.73690599e-02f, 2.27351248e-01f,
  -7.55159371e-03f, 1.21111900e-03f, 1.85901016e-01f, 3.12346131e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -2.91748077e-01f, -1.23637594e-01f, -4.34533209e-01f, 1.73672080e-01f, -1.05603792e-01f, -2.82751232e-01f, 1.75334930e-01f, 2.83659399e-01f, 2.53062546e-01f, -1.17929958e-01f,
  9.88826528e-03f, -4.14565094e-02f, 7.01526105e-01f, 1.88771605e-01f, -9.23459232e-02f, -4.97570634e-01f, 2.68929422e-01f, -1.82767704e-01f, -3.60094398e-01f, -6.75804675e-01f,
  -1.36247158e-01f, -2.60547489e-01f, 1.44223675e-01f, 8.55961367e-02f, 2.86872417e-01f, -3.16831231e-01f, -7.13271201e-01f, 1.20832352e-02f, -3.01819205e-01f, 2.55805880e-01f,
  -1.59963265e-01f, -3.42171252e-01f, 2.66177773e-01f, 3.04649889e-01f, -1.38502732e-01f, 2.14138534e-02f, 1.16160559e-02f, -1.65785819e-01f, -1.82733163e-02f, -1.12179564e-02f,
  -4.20443237e-01f, -3.88285935e-01f, -8.80103093e-03f, 3.84928994e-02f, -3.40439469e-01f, -5.78171909e-01f, -4.99739572e-02f, -2.67297626e-01f, -3.55300426e-01f, 2.99294472e-01f,
  -2.43278265e-01f, -1.55183263e-02f, 3.20171952e-01f, -2.28418306e-01f, -1.75553724e-01f, -9.51740611e-03f, 1.89171627e-01f, 5.40504336e-01f, -4.06428456e-01f, 2.04393923e-01f,
  -1.32127345e-01f, -3.56585413e-01f, -1.26905590e-01f, -3.39394450e-01f, -9.28368419e-02f, -5.03549390e-02f, 4.29815322e-01f, 2.92147428e-01f, 1.47213310e-01f, 3.76221031e-01f,
  2.70301938e-01f, -1.27028257e-01f, -1.93221763e-01f, -1.44009665e-01f, -4.37713176e-01f, -2.43939653e-01f, -1.79277003e-01f, 2.59390593e-01f, 7.45149180e-02f, 4.09900934e-01f,
  3.06567401e-01f, 4.83033180e-01f, -5.40475488e-01f, 3.60030420e-02f, -2.08443046e-01f, 1.03692591e-01f, -1.59843057e-01f, 1.43078685e-01f, -4.15208101e-01f, 1.23328812e-01f,
  -7.49159098e-01f, -1.93129703e-01f, 1.42754197e-01f, 1.90544799e-01f, 1.64831281e-01f, -8.64598870e-01f, 2.91327327e-01f, -5.89062333e-01f, -3.16621989e-01f, -4.18724507e-01f,
  -1.74044594e-01f, -2.67250150e-01f, -8.42355415e-02f, 4.46334109e-02f, 1.18359253e-01f, -1.66057438e-01f, -1.61208436e-01f, 3.47330898e-01f, -1.87530383e-01f, 9.00559500e-02f,
  7.96657205e-02f, 1.50428534e-01f, -6.38579130e-01f, 4.31584060e-01f, -9.54294920e-01f, -1.07553542e+00f, -4.52522099e-01f, 2.01814249e-01f, -6.36698842e-01f, 9.38399807e-02f,
  2.42035523e-01f, -6.48759484e-01f, 8.59385282e-02f, -4.24368292e-01f, 3.18364084e-01f, -1.04436129e-01f, 7.33097270e-02f, 2.07295090e-01f, -3.21312666e-01f, 2.47313067e-01f,
  1.41739860e-01f, -2.88401455e-01f, -1.03680193e-01f, -2.29770541e-02f, -2.81855941e-01f, -1.13253482e-01f, 1.53932035e-01f, -1.90083757e-01f, -1.96621299e-01f, 7.05597579e-01f,
  -7.75723517e-01f, 3.22553873e-01f, 7.24067569e-01f, 6.53828502e-01f, 1.96048662e-01f, -6.14930511e-01f, 7.75843188e-02f, -1.34245709e-01f, -4.36663449e-01f, 2.43964449e-01f,
  2.93327123e-01f, 1.23378463e-01f, -1.12604603e-01f, -5.98972663e-02f, -2.66843557e-01f, -6.26078388e-03f, 1.21492885e-01f, -4.19207886e-02f, -7.59824991e-01f, 1.78387225e-01f,
  1.84561938e-01f, -3.07524145e-01f, 1.70875285e-02f, 1.49051338e-01f, 1.69722170e-01f, -7.80725330e-02f, -3.02674234e-01f, -1.27454072e-01f, 3.22909623e-01f, 3.83472413e-01f,
  3.60406727e-01f, -5.03827035e-01f, 1.88354388e-01f, 1.70163497e-01f, -4.35520947e-01f, 3.64755571e-01f, -3.80124927e-01f, -2.36455813e-01f, 2.83087902e-02f, -3.40357840e-01f,
  3.33201945e-01f, 6.60731792e-02f, 1.01365417e-01f, -3.30925733e-02f, 2.19750479e-01f, -2.29739800e-01f, -2.89768558e-02f, -8.57169703e-02f, 3.22785228e-01f, -7.89877892e-01f,
  -5.16504109e-01f, 4.54337627e-01f, -9.45784673e-02f, -5.89628577e-01f, -3.24221998e-01f, -5.51624179e-01f, 3.08174500e-03f, -2.57549345e-01f, 9.28242579e-02f, 2.38496944e-01f,
  7.91884586e-02f, -5.73999226e-01f, 2.81349748e-01f, 6.35743886e-03f, 4.09084916e-01f, 6.65793836e-01f, -8.98913667e-02f, -1.46243766e-01f, 4.62750345e-01f, 5.20793855e-01f,
  4.74408478e-01f, 1.70505807e-01f, -2.33547986e-01f, 1.50728598e-01f, -5.23318172e-01f, -5.17055333e-01f, -2.48870611e-01f, -7.69184306e-02f, -2.18979612e-01f, -2.59628385e-01f,
  -4.35902849e-02f, -9.44474399e-01f, 2.57718675e-02f, 2.95821130e-01f, -8.34301040e-02f, 2.00450823e-01f, -1.29215211e-01f, -2.48895839e-01f, 2.10885227e-01f, 1.18303210e-01f,
  -3.35482299e-01f, 1.17212303e-01f, -5.94247133e-02f, 4.04103816e-01f, -3.55898917e-01f, 5.18356085e-01f, -3.23409468e-01f, 5.02083838e-01f, 3.52151036e-01f, -1.18268065e-01f,
  6.62629306e-02f, -9.89066362e-02f, 3.07977557e-01f, -5.00754476e-01f, 1.05311766e-01f, 4.04256210e-03f, -2.98818923e-03f, -3.34119916e-01f, -2.72569150e-01f, -1.78449210e-02f,
  5.66385984e-01f, -2.23908946e-01f, -3.26601356e-01f, 1.12494320e-01f, 3.35814357e-01f, -5.93788683e-01f, -1.67704523e-01f, -2.07572222e-01f, 1.84536427e-01f, 3.88320416e-01f,
  -1.01749659e-01f, -1.85573757e-01f, 5.87813258e-01f, -3.81694287e-01f, -1.55227393e-01f, 7.87769318e-01f, 5.01090109e-01f, -4.19434458e-01f, 3.76649112e-01f, -2.82983333e-01f,
  -2.73697916e-02f, -8.23962763e-02f, -5.28667986e-01f, -2.07869366e-01f, 5.39389193e-01f, 2.25744233e-01f, -2.71090597e-01f, -5.12448132e-01f, -6.07782781e-01f, -5.42129934e-01f,
  4.44367193e-02f, -6.61076665e-01f, 3.01255763e-01f, 2.69072354e-01f, -3.88769239e-01f, -1.58431843e-01f, -4.83244732e-02f, -3.66095603e-01f, -1.85998194e-02f, 6.86770678e-01f,
  -1.00793004e-01f, 2.73869962e-01f, 8.61875415e-02f, 6.75318018e-02f, 7.44053647e-02f, -3.95179957e-01f, 4.09310967e-01f, -1.21913560e-01f, 2.13293165e-01f, -6.13355875e-01f,
  8.25758278e-01f, 2.36745954e-01f, -5.07558763e-01f, -6.87888622e-01f, -1.00647444e-02f, -2.58592069e-01f, -4.42720085e-01f, -2.56073084e-02f, -6.84866667e-01f, 4.53128725e-01f,
  3.08865979e-02f, 1.42525911e-01f, -7.51063585e-01f, 1.37941223e-02f, -1.39451265e-01f, -7.51873314e-01f, -3.64603959e-02f, -7.85357773e-01f, -6.65049180e-02f, 2.62253016e-01f,
  -4.64358956e-01f, 2.43841335e-01f, 2.83501983e-01f, -3.63870591e-01f, -2.22856268e-01f, 2.93546081e-01f, -1.40431777e-01f, -2.77366847e-01f, -1.79114655e-01f, 3.85112017e-01f,
  1.02196030e-01f, 8.02712798e-01f, -2.52188742e-01f, -6.07279420e-01f, 5.56312799e-01f, 6.22842431e-01f, -2.26937830e-01f, 1.20796986e-01f, -8.05633128e-01f, -3.96915525e-01f,
  -3.22509587e-01f, -5.91413140e-01f, -1.03064644e+00f, -2.03850210e-01f, 1.75302535e-01f, -4.60641593e-01f, -4.45022792e-01f, 4.09940541e-01f, -3.08470696e-01f, 2.90408999e-01f,
  1.73491552e-01f, 4.45705324e-01f, 3.39973897e-01f, 3.87371838e-01f, 2.26335555e-01f, 6.13550484e-01f, 3.33823822e-02f, 3.85240704e-01f, -2.87581176e-01f, 3.18048447e-02f,
  -3.87577176e-01f, 2.78008819e-01f, 4.48330902e-02f, -3.32251400e-01f, 1.08439252e-01f, -1.13075328e+00f, -6.06498361e-01f, -1.57136157e-01f, 5.46202898e-01f, -6.87462389e-02f,
  -2.34890252e-01f, 2.77525395e-01f, -4.95717496e-01f, -4.73293662e-02f, -3.42858791e-01f, -4.88537222e-01f, -7.50455678e-01f, -4.97703016e-01f, -8.72051418e-01f, 2.26350259e-02f,
  -4.18238819e-01f, -5.63650019e-02f, 4.04107392e-01f, 4.26096976e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.57914177e-01f, -2.31667176e-01f, 1.06717072e-01f, 8.55715349e-02f, 1.03636965e-01f, 1.21464558e-01f, -1.29684240e-01f, 2.21178923e-02f, 6.14646636e-02f, 4.43385430e-02f,
  -8.09143856e-02f, -3.90457176e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    