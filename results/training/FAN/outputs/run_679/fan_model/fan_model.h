/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.49539088e-02f, -2.19200820e-01f, 3.53467129e-02f, -2.59183884e-01f, 3.16935368e-02f, 2.56081104e-01f, 1.41079813e-01f, -7.71889836e-02f, -2.04777233e-02f, 4.11419645e-02f,
  2.41210550e-01f, 1.75286293e-01f, 8.23987275e-02f, 1.32733837e-01f, 4.18181997e-03f, -6.75151423e-02f, -1.96451500e-01f, -6.52260557e-02f, 1.41905025e-01f, 1.53512180e-01f,
  -1.11221880e-01f, -2.93327332e-01f, -1.76144361e-01f, -1.52062997e-01f, -2.38817737e-01f, -7.26499483e-02f, -1.71251386e-01f, -9.82782692e-02f, -3.83629240e-02f, -2.92293787e-01f,
  4.06215400e-01f, 1.68502510e-01f, 1.10911444e-01f, 7.08555430e-02f, 1.41690448e-01f, -7.10949600e-02f, -8.67807399e-03f, -6.79936111e-02f, -1.41324038e-02f, -3.28602791e-02f,
  1.06212780e-01f, -3.78318429e-02f, 8.14253911e-02f, 4.05032784e-02f, 2.39560334e-03f, -4.37703282e-02f, -1.28805026e-01f, 3.60884927e-02f, 1.98705010e-02f, 6.70516789e-02f,
  1.11741731e-02f, 1.94485281e-02f, 2.27376431e-01f, 2.63681784e-02f, 7.98032135e-02f, 7.85724744e-02f, 1.04649790e-01f, 7.86266997e-02f, 1.01912409e-01f, -1.39199793e-01f,
  -7.59108290e-02f, 2.56835259e-02f, -2.64635589e-02f, -6.74122497e-02f, -4.27632630e-02f, -4.03305190e-03f, -9.23291370e-02f, -1.12325279e-02f, -3.73147763e-02f, -4.83982526e-02f,
  9.47197434e-03f, 3.35168024e-03f, 2.06051730e-02f, -1.02358632e-01f, -4.11294401e-02f, -5.66430874e-02f, -6.02952437e-03f, -1.44331679e-01f, -2.28842068e-02f, -2.83470587e-03f,
  3.37114669e-02f, 8.33698511e-02f, -1.95826241e-03f, -2.05346160e-02f, 3.09690200e-02f, 3.88725870e-03f, -2.19259337e-02f, -2.22931467e-02f, 4.85611595e-02f, 1.56382266e-02f,
  -7.47378245e-02f, 1.00709535e-01f, -1.56262573e-02f, 3.64600904e-02f, 5.31291105e-02f, 2.33603157e-02f, 8.15972835e-02f, -5.62596582e-02f, -1.53219309e-02f, 4.16971510e-03f,
  8.39986801e-02f, 1.76166929e-02f, -6.98001182e-04f, -5.60494550e-02f, 9.50575843e-02f, 7.12431502e-03f, -1.29325837e-02f, 2.30309162e-02f, -3.29691842e-02f, 9.91051495e-02f,
  -1.23823032e-01f, 2.79717725e-02f, 6.92972317e-02f, 5.57686016e-03f, 5.39364107e-02f, 5.67721389e-02f, 3.92076261e-02f, 9.08506289e-02f, 3.75607908e-02f, -1.67244717e-01f,
  -1.57019168e-01f, -2.36819908e-01f, -1.81068957e-01f, 1.68545976e-01f, -2.05335006e-01f, -2.71993876e-01f, -3.77896577e-01f, -1.28934532e-01f, 3.89931798e-02f, -1.53744146e-01f,
  3.86950597e-02f, 4.18532342e-01f, 2.49609441e-01f, 2.81395614e-01f, 1.58895701e-01f, -1.17754877e-01f, -9.88405421e-02f, 1.36564553e-01f, 1.09659277e-01f, 7.33554810e-02f,
  1.94868401e-01f, 1.97781786e-01f, 2.16119543e-01f, 1.40350804e-01f, 4.96318750e-02f, 2.68238366e-01f, -1.16278581e-01f, -4.58052121e-02f, 4.82791336e-03f, 1.00962162e-01f,
  1.73073113e-01f, -1.72370329e-01f, 1.79383159e-01f, 1.82534322e-01f, 3.77216414e-02f, 9.65802372e-02f, -5.54683735e-04f, 2.23282836e-02f, 4.76829223e-02f, 1.80650912e-02f,
  2.73509286e-02f, 1.32553011e-01f, 1.50849760e-01f, 1.17729709e-01f, -1.02821089e-01f, 5.35934456e-02f, 9.39268917e-02f, 4.21373621e-02f, 1.25781288e-02f, 2.15865821e-02f,
  1.15026377e-01f, -8.99764523e-02f, -7.12384731e-02f, -7.66470656e-02f, 3.54220457e-02f, 1.71970338e-01f, -3.09246629e-02f, -4.33089323e-02f, -8.01086277e-02f, 2.76022367e-02f,
  1.30085507e-02f, -1.71204004e-02f, -5.10810576e-02f, 8.98917671e-03f, -1.04592810e-03f, 1.79971326e-02f, -7.08987517e-03f, -7.23903626e-03f, 7.08256811e-02f, -4.70494181e-02f,
  -7.77049595e-03f, 4.11697989e-03f, -7.05383271e-02f, -1.16428122e-01f, 1.62043661e-01f, -1.07520334e-01f, -6.65098727e-02f, 3.47044505e-02f, -1.91752668e-02f, -8.75996649e-02f,
  4.02523279e-02f, 7.04351887e-02f, 1.43956570e-02f, 7.85665065e-02f, -6.52818382e-02f, 5.89762442e-02f, -2.11278759e-02f, -2.29861550e-02f, 2.16783620e-02f, -1.30508646e-01f,
  3.63439679e-01f, -8.89207870e-02f, 1.16615891e-01f, 1.80337101e-01f, -1.32613286e-01f, 1.13563508e-01f, 7.38636777e-02f, 1.10016704e-01f, 6.51364997e-02f, 1.03689931e-01f,
  6.56536147e-02f, 1.47323623e-01f, 3.87198441e-02f, 7.41157606e-02f, 8.10917318e-02f, 2.75731366e-02f, 4.16339040e-02f, 5.98695092e-02f, -1.18462667e-02f, -1.56955998e-02f,
  1.03412360e-01f, -6.14627302e-02f, -9.10013318e-02f, 9.35315713e-02f, 8.00367221e-02f, 9.76795405e-02f, 5.24662212e-02f, 3.15578170e-02f, -1.11862138e-01f, -7.17917234e-02f,
  4.59937900e-01f, -7.38758966e-02f, -8.17357898e-02f, 1.27233192e-01f, -1.42184436e-01f, -2.69877389e-02f, -1.16694480e-01f, 1.03802301e-01f, 2.21541122e-01f, 7.28750676e-02f,
  2.19009474e-01f, 1.43203452e-01f, 2.17926875e-01f, 2.25717947e-01f, 1.62414089e-01f, -4.14781496e-02f, -1.20512351e-01f, 6.14654012e-02f, 9.01973471e-02f, 1.03405535e-01f,
  -2.58302782e-02f, 6.79839477e-02f, 2.58103997e-01f, 1.07331976e-01f, -1.46007523e-01f, -9.23365280e-02f, -8.57781023e-02f, -9.15475562e-03f, -1.77089214e-01f, -2.22793788e-01f,
  2.01997720e-02f, 2.45037317e-01f, 6.94462284e-02f, 1.27288103e-01f, 5.70438989e-02f, 1.41771004e-01f, 1.20721467e-01f, 1.37551814e-01f, 9.00312439e-02f, 1.47008792e-01f,
  5.45916855e-02f, 1.41393110e-01f, 5.58086745e-02f, 1.03949472e-01f, 1.41786292e-01f, 6.04463741e-02f, 2.15424672e-01f, 8.67719427e-02f, 1.23716213e-01f, 4.08651829e-02f,
  4.95833270e-02f, -9.05652717e-03f, 5.21498919e-02f, -2.63177585e-02f, 3.86104695e-02f, 1.00326478e-01f, -4.22090329e-02f, 1.13014154e-01f, 9.37153473e-02f, -1.46441869e-02f,
  -1.14998654e-01f, -3.49899046e-02f, -9.24048014e-03f, -1.95473172e-02f, -2.77406238e-02f, -9.51235965e-02f, -1.04134798e-01f, -6.15820661e-02f, -9.81539562e-02f, -1.09286942e-01f,
  -5.02790324e-02f, -7.90593997e-02f, -4.89107370e-02f, -7.75926858e-02f, -5.36643863e-02f, -1.11913323e-01f, -2.60671950e-03f, -8.88452008e-02f, -1.23571374e-01f, -1.87694523e-02f,
  -5.47591299e-02f, -5.91320284e-02f, -6.53673289e-03f, -5.18210344e-02f, -4.01377715e-02f, 4.83082570e-02f, -3.85915935e-02f, 6.52756691e-02f, -2.81080697e-02f, 1.93640646e-02f,
  1.07770465e-01f, 2.37980783e-01f, 1.37395158e-01f, 9.10869986e-02f, 5.61001338e-02f, 1.36920154e-01f, 1.35431886e-01f, 1.33207530e-01f, 1.68919444e-01f, 5.70564233e-02f,
  1.41652614e-01f, 1.05918795e-01f, 1.11962005e-01f, 1.01080820e-01f, 9.41999331e-02f, 2.95186713e-02f, 3.77884097e-02f, 3.40951458e-02f, 1.12580486e-01f, 1.37691155e-01f,
  7.41302073e-02f, 1.43356975e-02f, -3.04370187e-02f, 1.03477009e-01f, -1.57670006e-02f, 8.27938393e-02f, 5.37814163e-02f, -6.59198761e-02f, 3.75082454e-04f, 4.40411419e-02f,
  -3.86812985e-01f, -2.76824772e-01f, -2.98805445e-01f, -3.37383747e-01f, 8.33607912e-02f, 3.54362130e-01f, 3.63405913e-01f, 3.42898250e-01f, -6.48001358e-02f, -3.63168083e-02f,
  -2.20108300e-01f, -2.43646428e-01f, -3.10935467e-01f, -1.17216714e-01f, 9.69112664e-02f, 1.91538677e-01f, 4.35307994e-02f, 2.70715132e-02f, 2.57505029e-01f, 4.47192669e-01f,
  1.22773394e-01f, -1.62457719e-01f, -1.54892951e-01f, -7.15236068e-02f, -2.05230594e-01f, -1.23505900e-02f, -1.72094196e-01f, -2.18739316e-01f, -6.40655905e-02f, -1.64675534e-01f,
  -2.46593222e-01f, -1.88959569e-01f, 1.55000344e-01f, -9.06142816e-02f, -4.32630964e-02f, 1.07883578e-02f, 8.76435414e-02f, -9.99844149e-02f, 2.57774093e-03f, -1.96892489e-02f,
  -1.47203848e-01f, -7.07818493e-02f, -1.68819577e-01f, 3.84740196e-02f, 3.53539959e-02f, 7.92723745e-02f, 4.47257385e-02f, -1.26484688e-02f, 3.29903662e-02f, -4.71794158e-02f,
  -3.34436335e-02f, -2.54603871e-03f, -6.89834915e-03f, 1.31243825e-01f, 8.18490610e-02f, -1.23909719e-01f, -9.44335014e-02f, 7.60428607e-02f, 1.29121691e-01f, -5.48024941e-03f,
  1.44255176e-01f, -9.84015018e-02f, -6.56007826e-02f, -8.44120234e-02f, -8.53254572e-02f, -9.31739882e-02f, -6.75927475e-02f, -5.71854338e-02f, 2.47874316e-02f, -8.66092071e-02f,
  -8.31743702e-03f, -6.36635944e-02f, -4.98607494e-02f, -4.53881398e-02f, -6.26812428e-02f, -1.21421829e-01f, -3.43392864e-02f, -3.30207162e-02f, -1.01353109e-01f, -4.85180207e-02f,
  2.47380268e-02f, -3.15030590e-02f, -1.31190643e-01f, -1.06255971e-02f, -2.45516151e-02f, -1.48874354e-02f, -4.66619618e-02f, -4.63618524e-03f, -7.17070997e-02f, -1.41360790e-01f,
  -8.76256749e-02f, 1.13768250e-01f, -1.82441901e-02f, 1.04910076e-01f, -4.42047976e-02f, 6.05002344e-02f, -8.73053893e-02f, 8.40798914e-02f, -9.01734903e-02f, 4.55035120e-02f,
  3.14708687e-02f, -1.23981899e-02f, -1.20775737e-01f, 6.06071949e-02f, 7.57193044e-02f, 1.18964531e-01f, -4.33758199e-02f, -3.84007916e-02f, 1.04127638e-01f, -1.86816603e-02f,
  8.52824189e-03f, 2.64805913e-01f, 6.64904639e-02f, 1.27503663e-01f, 2.41570454e-02f, 1.42463669e-01f, 1.00892849e-01f, 2.32060373e-01f, 1.59507260e-01f, 1.54619485e-01f,
  -2.03132302e-01f, -1.95982773e-02f, 2.51973361e-01f, -1.41474739e-01f, -1.46970507e-02f, 6.58211410e-02f, -1.76935762e-01f, -1.76144943e-01f, 3.85833643e-02f, 1.59032643e-01f,
  1.08567350e-01f, 5.82310893e-02f, 1.32614270e-01f, -1.39803533e-02f, -2.08423883e-02f, 3.59434113e-02f, -2.17608828e-02f, -7.53377452e-02f, -1.66165560e-01f, -1.79243162e-01f,
  -3.07634156e-02f, -7.90512860e-02f, -2.47240141e-01f, -5.78890964e-02f, -6.94423541e-02f, 8.80830586e-02f, 1.17198400e-01f, -5.44724539e-02f, 9.23996270e-02f, 1.65465176e-01f,
  2.64310837e-01f, -1.99878544e-01f, -1.62365511e-02f, -3.99015248e-02f, -2.28361003e-02f, -7.98220262e-02f, 3.18126827e-02f, -1.14613704e-01f, 4.64092828e-02f, 1.20592071e-02f,
  -6.33445308e-02f, -7.23525509e-02f, -1.00332767e-01f, -4.69999574e-03f, -1.36965930e-01f, -7.64129981e-02f, -1.78381771e-01f, -1.30683959e-01f, -1.18953638e-01f, -9.16201621e-02f,
  -1.45372991e-02f, 6.14625067e-02f, -1.63196102e-02f, 5.67873418e-02f, -1.58469960e-01f, -3.16611268e-02f, 3.67551041e-03f, -9.98183414e-02f, 6.67112023e-02f, 2.99046040e-02f,
  3.58096734e-02f, 1.34260461e-01f, 9.37825739e-02f, 2.24309228e-02f, 7.86998868e-02f, 1.86023265e-01f, 1.05871327e-01f, 1.48578763e-01f, 4.62151542e-02f, 1.14451364e-01f,
  9.42416787e-02f, 2.01834634e-01f, 2.69207302e-02f, 1.56220272e-01f, 2.40586445e-01f, 1.80261627e-01f, 1.67044476e-01f, 2.03454614e-01f, 1.24939203e-01f, 4.52882871e-02f,
  1.63840756e-01f, 1.24398991e-01f, 1.21371008e-01f, 1.16599753e-01f, 1.67273983e-01f, 5.02955429e-02f, 1.29897699e-01f, 5.14659062e-02f, 7.26068988e-02f, 9.09337848e-02f,
  1.54108956e-01f, -1.45082861e-01f, 1.88386440e-01f, -1.30983308e-01f, 1.40989861e-02f, -5.45233414e-02f, -7.07270056e-02f, 3.31579521e-02f, 9.74272378e-03f, -6.13602288e-02f,
  -8.40768404e-03f, -1.36168316e-01f, 3.01570538e-03f, -5.69810420e-02f, -7.12898374e-02f, -8.53729260e-04f, -1.06523940e-02f, -1.12256426e-02f, -4.52068783e-02f, -3.61556448e-02f,
  1.15762409e-02f, 1.60919335e-02f, 4.05768417e-02f, 1.18797280e-01f, -6.31413460e-02f, 1.15959635e-02f, 5.35004213e-03f, 5.82597032e-02f, 7.31153190e-02f, 4.90564071e-02f,
  5.65749526e-01f, 3.28157783e-01f, 3.22138429e-01f, 2.22337857e-01f, -2.32857972e-01f, 2.89935246e-02f, 2.31910229e-01f, 1.51723132e-01f, 5.37656769e-02f, 8.16729292e-02f,
  -7.99246579e-02f, -1.60346240e-01f, -4.07192372e-02f, -4.27966490e-02f, 1.15046846e-02f, 1.97473422e-01f, 1.08297564e-01f, 3.08194906e-02f, -2.08443925e-01f, -2.83569127e-01f,
  -3.51820469e-01f, -6.30480126e-02f, 6.33213844e-04f, -9.03018098e-03f, -1.35467514e-01f, -1.22548923e-01f, 2.24407688e-01f, -3.26754488e-02f, -6.81968108e-02f, -5.58146425e-02f,
  -4.58597988e-02f, 1.75719559e-01f, -9.34085101e-02f, -1.64718062e-01f, -1.23176083e-01f, 1.10208783e-02f, -8.81821215e-02f, -6.22175746e-02f, -1.92957148e-02f, 5.92716523e-02f,
  -5.89698441e-02f, -2.31671073e-02f, -1.59340024e-01f, -8.78727287e-02f, 1.64759997e-02f, 1.24559244e-02f, -1.59951635e-02f, 2.44201105e-02f, 6.47532120e-02f, -1.07894853e-01f,
  -2.41438642e-01f, -1.95309192e-01f, -2.75000260e-04f, 8.76030102e-02f, -8.75097979e-03f, -1.39729977e-01f, 5.61924949e-02f, -1.16173744e-01f, 1.18591644e-01f, 9.45005938e-02f,
  2.20296765e-03f, 5.60785048e-02f, 2.73439139e-02f, 1.53861254e-01f, 5.17824218e-02f, 5.14910780e-02f, 1.63486958e-01f, 5.84728718e-02f, 7.81289116e-02f, 1.44940224e-02f,
  6.04138300e-02f, 6.54292628e-02f, 3.05863731e-02f, 1.71543926e-01f, 5.93400598e-02f, 1.09595962e-01f, 8.75671208e-02f, 4.00734432e-02f, 7.28934705e-02f, 1.38668239e-01f,
  6.15286045e-02f, 1.08036056e-01f, 5.06456792e-02f, 8.61727893e-02f, 8.48549679e-02f, 9.47369188e-02f, 1.34535819e-01f, 8.71888995e-02f, 1.09875023e-01f, 1.19649448e-01f,
  1.67344719e-01f, -1.13156550e-01f, 2.83159688e-02f, -8.65241066e-02f, -1.56498831e-02f, -4.53799441e-02f, -9.22651663e-02f, -5.44417091e-02f, 6.07378595e-03f, -1.65049285e-02f,
  -1.83051050e-01f, 6.29460812e-02f, -5.10677323e-02f, -1.63670704e-01f, -1.20923787e-01f, -7.95727372e-02f, -1.68485139e-02f, -4.21795584e-02f, -3.70617174e-02f, -1.69582088e-02f,
  -1.13420233e-01f, 1.67192649e-02f, 1.71853244e-01f, 8.11156258e-02f, -5.43812737e-02f, 3.23497541e-02f, 1.08243160e-01f, 7.30765760e-02f, 1.27246916e-01f, 6.46865219e-02f,
  5.08147359e-01f, -4.53823544e-02f, -2.20281899e-01f, 1.68334812e-01f, 1.77699607e-02f, -2.06761267e-02f, 2.04476193e-02f, 1.12508796e-01f, 5.56717813e-02f, 1.27609700e-01f,
  1.18764281e-01f, 2.29844227e-01f, 1.76121607e-01f, 1.43872350e-01f, 7.21953213e-02f, -2.28942826e-01f, -2.61622131e-01f, 8.21177661e-02f, 3.44592333e-01f, 3.36864442e-01f,
  2.14434415e-01f, 1.86501577e-01f, 2.29462191e-01f, 8.33698213e-02f, -7.15465620e-02f, -8.97862669e-03f, -1.69478804e-01f, -1.02664448e-01f, -1.43530026e-01f, -1.94617644e-01f,
  2.68476367e-01f, 3.40112329e-01f, 2.68162191e-01f, 2.88867384e-01f, 1.84130907e-01f, 2.35814035e-01f, 2.42336482e-01f, 1.13834575e-01f, 2.16513902e-01f, 1.26059175e-01f,
  1.87669337e-01f, 2.55027652e-01f, 1.05404504e-01f, 2.25479752e-01f, 1.50934711e-01f, 2.10263550e-01f, 7.15658069e-02f, 7.24477097e-02f, 6.74894527e-02f, 1.35733530e-01f,
  2.11143613e-01f, 2.95179486e-01f, 1.67596951e-01f, 1.80427864e-01f, 1.80196702e-01f, 2.64303535e-01f, 7.95620382e-02f, 1.10793129e-01f, 1.70193538e-01f, 1.88627005e-01f,
  -7.21989758e-03f, -1.75639182e-01f, -7.00279698e-02f, -1.80419847e-01f, -1.30670175e-01f, -9.03639570e-02f, -2.20963478e-01f, -7.55287334e-02f, -2.41743419e-02f, -1.69735253e-01f,
  -1.77209955e-02f, -6.01981953e-02f, -1.02742538e-01f, -8.16318542e-02f, -3.59420199e-03f, -7.32313916e-02f, -4.05829027e-02f, -1.75344199e-01f, -1.45923316e-01f, -7.21830800e-02f,
  -1.18797779e-01f, -1.20641410e-01f, -4.21727151e-02f, -1.35898843e-01f, -1.16557702e-01f, -1.59790158e-01f, -9.55280438e-02f, -8.70474651e-02f, -5.47389463e-02f, -1.48541480e-01f,
  2.89935976e-01f, 6.47043288e-02f, 1.05189495e-01f, 1.39675304e-01f, 1.23456232e-01f, 1.09395377e-01f, 1.39087006e-01f, 1.52397826e-01f, 1.62450656e-01f, 1.36701196e-01f,
  2.23745555e-01f, 2.14251339e-01f, 1.44174263e-01f, 1.64195895e-01f, 2.80855477e-01f, 1.81494310e-01f, 8.49512145e-02f, 1.38253257e-01f, 9.74707156e-02f, 1.92277089e-01f,
  1.85087159e-01f, 2.89066255e-01f, 3.23196799e-01f, 2.23737970e-01f, 9.80201811e-02f, 2.94204563e-01f, 1.25657156e-01f, 2.41452187e-01f, 2.51572579e-01f, 2.53349125e-01f,
  -1.55770361e-01f, -2.73566425e-01f, -2.61206239e-01f, -3.19688022e-01f, -8.17371458e-02f, 1.75438330e-01f, -1.43297501e-02f, 8.58656317e-02f, 9.26442258e-03f, -1.78675815e-01f,
  8.64785984e-02f, 2.88635939e-01f, 2.57870317e-01f, 2.63218045e-01f, 2.83080041e-01f, -1.10452875e-01f, -1.19969405e-01f, 1.10342428e-01f, 3.43291968e-01f, 1.35342270e-01f,
  1.36024162e-01f, -7.52142584e-03f, -5.64262718e-02f, 3.29217240e-02f, -2.24497825e-01f, 1.02717414e-01f, -2.67665714e-01f, -1.83689937e-01f, 3.22671905e-02f, -3.85094553e-01f,
  -2.63000309e-01f, -2.29008466e-01f, 2.57649392e-01f, 1.40721157e-01f, 7.03293225e-03f, 1.00204006e-01f, 1.21420711e-01f, 1.86070614e-03f, 8.49861801e-02f, -1.52064776e-02f,
  3.59326601e-02f, 8.83789137e-02f, 1.16353422e-01f, 8.23989585e-02f, 5.81061803e-02f, 8.22952017e-02f, 4.24096137e-02f, 5.90063110e-02f, 1.38698861e-01f, -9.12868530e-02f,
  6.21372834e-02f, -5.45349205e-03f, 5.74398935e-02f, 1.51437253e-01f, 1.29794136e-01f, 2.14238167e-01f, 4.41214032e-02f, -4.73338589e-02f, 1.05082966e-01f, -9.52874050e-02f,
  6.83840737e-02f, 4.82993908e-02f, -8.28723516e-03f, -2.01525055e-02f, -5.59761338e-02f, -1.07996561e-01f, -9.61210132e-02f, 3.36672105e-02f, -5.27058095e-02f, -1.32098813e-02f,
  -8.79672542e-02f, -1.35354046e-02f, 1.82849206e-02f, -1.03472993e-01f, 3.14166434e-02f, -9.76309255e-02f, 3.47402766e-02f, -7.96329379e-02f, -2.36340184e-02f, -3.82107981e-02f,
  -7.21066073e-02f, -3.93772461e-02f, -9.58434865e-02f, -4.72908989e-02f, -2.76223253e-02f, -3.36509347e-02f, -6.86708465e-02f, 1.07241265e-01f, -4.91197444e-02f, -9.40725356e-02f,
  1.95416152e-01f, 3.81755888e-01f, -1.16086073e-01f, 4.70153019e-02f, 2.19470337e-02f, 2.51456886e-03f, 4.05926071e-02f, -2.68543661e-02f, 2.21197065e-02f, 5.39488494e-02f,
  1.48103721e-02f, 9.53947306e-02f, 2.64760330e-02f, 5.81716485e-02f, 1.16666006e-02f, 5.96557595e-02f, 7.69817755e-02f, 5.17995842e-02f, 1.34916738e-01f, 9.45479330e-03f,
  6.36072084e-03f, 7.79408738e-02f, 1.81554690e-01f, 9.20207947e-02f, 1.45098045e-01f, 1.55239552e-01f, 6.08522370e-02f, 1.94471091e-01f, 2.71575898e-01f, 4.68461215e-02f,
  -5.16267180e-01f, -2.44117558e-01f, -5.13577521e-01f, -5.10958284e-02f, 2.33835191e-01f, 7.31111988e-02f, -9.31002796e-02f, 5.18963672e-02f, 8.35550725e-02f, -1.09108388e-01f,
  -2.87070684e-02f, 8.78831670e-02f, -1.25967145e-01f, -1.17552377e-01f, -2.18344837e-01f, -1.17773958e-01f, -1.33200422e-01f, -2.71423638e-01f, -1.02347262e-01f, 1.04751408e-01f,
  1.99843466e-01f, -1.14492394e-01f, -2.69758254e-01f, -1.77278444e-01f, 3.94847952e-02f, 9.19035748e-02f, -8.76147896e-02f, -1.91823915e-02f, -2.78650895e-02f, 1.16788380e-01f,
  -3.96973968e-01f, -2.33240187e-01f, -2.42975540e-02f, -1.11198507e-01f, -1.21877305e-01f, -2.66735345e-01f, -2.04765767e-01f, -1.67080685e-01f, -1.13012634e-01f, -1.07405014e-01f,
  -1.24771968e-01f, -6.82507455e-02f, -9.62180644e-02f, -1.17835514e-01f, -1.55099273e-01f, -1.11743420e-01f, -2.92212576e-01f, -3.57534647e-01f, -2.11543947e-01f, -2.55932391e-01f,
  3.22428457e-02f, -1.84688359e-01f, -4.22958523e-01f, -2.77273506e-01f, -2.77128190e-01f, -6.29612207e-02f, -1.83122650e-01f, -1.70566678e-01f, -2.44640186e-01f, -1.98609099e-01f,
  5.81892394e-02f, 8.62127319e-02f, 6.39197379e-02f, 1.77386358e-01f, 1.58122599e-01f, 2.42376506e-01f, 9.63842943e-02f, 1.33890033e-01f, 1.48396999e-01f, 9.40210223e-02f,
  2.01781988e-01f, 1.33076206e-01f, 1.88299552e-01f, 1.63587049e-01f, 2.00808704e-01f, -3.53445625e-03f, 1.02009691e-01f, 1.19760998e-01f, 9.10049602e-02f, 1.40831143e-01f,
  1.80323884e-01f, 9.21100900e-02f, 1.02018833e-01f, 1.82829380e-01f, 6.49516433e-02f, 9.32995975e-02f, 2.88595967e-02f, 1.85992122e-01f, 7.80622810e-02f, 1.65887639e-01f,
  -1.47375330e-01f, -1.07254736e-01f, -1.69856057e-01f, -1.37652650e-01f, -1.05183557e-01f, -3.84991542e-02f, -1.37035415e-01f, -1.00234583e-01f, -7.97642171e-02f, -2.38920853e-01f,
  -8.02261755e-02f, -1.30871043e-01f, -1.24941230e-01f, -1.69030696e-01f, -2.23401003e-02f, -1.55203804e-01f, -1.60989463e-01f, -1.53639749e-01f, -8.83867815e-02f, -1.36467308e-01f,
  -2.46802703e-01f, -2.07186759e-01f, -2.39184052e-01f, -1.95512235e-01f, -2.11574033e-01f, -1.43979818e-01f, -1.99224889e-01f, -2.71315008e-01f, -3.22934568e-01f, -2.47266144e-01f,
  3.28307360e-01f, -1.61954779e-02f, -2.87215486e-02f, 3.12279493e-01f, 1.33208007e-01f, -1.90288469e-01f, -2.50385284e-01f, -1.16271190e-01f, 1.61111727e-01f, -2.17667893e-02f,
  2.65275657e-01f, 1.76380143e-01f, 1.27035171e-01f, -1.16349831e-01f, -2.41472587e-01f, -2.57426471e-01f, -2.81939119e-01f, -1.51445985e-01f, -1.67020008e-01f, -1.55954257e-01f,
  -4.93696220e-02f, 9.01104659e-02f, 4.21623774e-02f, -2.43863501e-02f, 3.71385254e-02f, 2.22209822e-02f, 2.82174051e-02f, 7.42554218e-02f, -1.39927015e-01f, -1.85822412e-01f,
  -1.13269061e-01f, -2.93010827e-02f, 2.82839853e-02f, 7.06746057e-02f, 9.63357687e-02f, -5.12194559e-02f, 3.26660946e-02f, 1.18020833e-01f, 1.99930876e-01f, 2.93827541e-02f,
  2.26331443e-01f, 7.98812285e-02f, 2.86481548e-02f, 2.73089744e-02f, 9.97146592e-02f, -1.34896236e-02f, 4.42220308e-02f, -3.44281495e-02f, 4.54964638e-02f, 3.30869332e-02f,
  3.20894755e-02f, 9.69576910e-02f, 1.65551350e-01f, 6.24569505e-02f, -2.67656501e-02f, 6.63110614e-02f, 1.45046324e-01f, 8.72390158e-03f, 1.63789410e-02f, 5.74121773e-02f,
  -2.07001612e-01f, -6.06333055e-02f, -7.30663836e-02f, -3.73406298e-02f, -3.52950543e-02f, -1.11460403e-01f, -1.61737218e-01f, -8.45225081e-02f, -1.11992888e-01f, -1.40913188e-01f,
  -8.54776874e-02f, -1.65396407e-01f, -1.25977412e-01f, -1.99546337e-01f, -1.53075039e-01f, -1.36386812e-01f, -1.06544711e-01f, -1.41029000e-01f, -1.78192407e-01f, -1.65144429e-01f,
  -1.06305569e-01f, -4.38092127e-02f, -6.76507279e-02f, -1.94908336e-01f, -1.26658559e-01f, -1.62781492e-01f, -4.05539721e-02f, -1.27885833e-01f, -1.08467408e-01f, -1.66608483e-01f,
  5.34008920e-01f, 5.71841076e-02f, -1.61607098e-02f, -8.16536024e-02f, 8.68928581e-02f, 7.41874129e-02f, 6.35789707e-02f, -6.06853664e-02f, 5.95253482e-02f, 5.50489053e-02f,
  -7.79293329e-02f, 8.79003033e-02f, 1.47474423e-01f, -2.21139602e-02f, 4.51725200e-02f, 4.10167836e-02f, 7.74222612e-02f, 1.30673125e-01f, -2.29995511e-02f, 1.14458986e-01f,
  8.09638053e-02f, 1.58195570e-01f, 1.44175455e-01f, 2.08943143e-01f, 2.19627209e-02f, 1.38633817e-01f, 1.68179069e-02f, 8.47382545e-02f, 1.30820379e-01f, 1.32084444e-01f,
  -4.65231925e-01f, -2.33740643e-01f, 2.40118206e-01f, -1.96496826e-02f, 9.08502340e-02f, 1.59300134e-01f, 1.94999829e-01f, -8.29882324e-02f, -1.40161917e-01f, -1.06291242e-01f,
  -1.29823163e-01f, -1.20488279e-01f, -6.18563779e-02f, -1.00841999e-01f, 3.08193751e-02f, 8.90589580e-02f, 1.21345416e-01f, 1.84808135e-01f, 1.58463806e-01f, 1.11337073e-01f,
  6.28283247e-02f, 1.71180815e-02f, -8.39167014e-02f, -4.56133559e-02f, -9.89561453e-02f, 9.42960158e-02f, 9.71987844e-02f, 7.24612251e-02f, 3.01110577e-02f, 1.19684234e-01f,
  6.89465478e-02f, -2.61889130e-01f, -5.89652285e-02f, -2.51115002e-02f, -4.79635410e-02f, -1.99514762e-01f, -1.23280905e-01f, -1.25831932e-01f, -1.67158008e-01f, -1.17041603e-01f,
  -9.53350291e-02f, -9.28880721e-02f, -5.90355732e-02f, 2.42405478e-02f, 4.67095748e-02f, 4.83614393e-03f, -6.73459247e-02f, -8.30110908e-02f, 4.16724477e-03f, -1.26296058e-01f,
  -6.25792295e-02f, 9.49404761e-02f, 1.13684051e-02f, -1.17114834e-01f, -8.42288211e-02f, -3.68269184e-03f, 3.37643772e-02f, 2.38633379e-02f, 9.22617912e-02f, -1.06712326e-01f,
  1.06451958e-01f, 2.44410858e-02f, 7.22687244e-02f, 1.21898808e-01f, 2.43762415e-03f, 3.71497497e-02f, 3.32130231e-02f, 6.94476590e-02f, 7.32799396e-02f, 2.99317092e-02f,
  5.07411100e-02f, 7.11066835e-03f, 5.73279895e-02f, 2.44692583e-02f, 1.81957603e-01f, 1.10004358e-01f, 7.83413500e-02f, 5.50538749e-02f, 1.21123642e-01f, -2.64632795e-02f,
  2.45440919e-02f, 9.80062336e-02f, 8.02949741e-02f, 1.08435981e-01f, 9.31470394e-02f, 1.29866585e-01f, 3.91566195e-02f, -3.14132236e-02f, 1.11707542e-02f, -2.53004599e-02f,
  -3.83540779e-01f, 1.33879617e-01f, -2.10077181e-01f, -1.47582024e-01f, 6.31377334e-03f, -8.04350004e-02f, -7.48689845e-02f, -2.77835317e-02f, -9.47644562e-02f, -7.02413321e-02f,
  -1.09742098e-02f, -9.29467380e-02f, -7.11150840e-02f, -1.08161680e-01f, -2.44016573e-02f, -4.39797826e-02f, -2.52947751e-02f, 6.11437345e-03f, -1.27112102e-02f, -1.02444151e-02f,
  -1.14959486e-01f, 3.50976996e-02f, 1.91378081e-03f, 2.31276564e-02f, 2.09656041e-02f, -5.75800650e-02f, -1.16256587e-02f, -3.83355767e-02f, 1.32384915e-02f, -6.12602755e-02f,
  -4.77018267e-01f, 2.78427809e-01f, -2.06566334e-01f, 1.07035629e-01f, 2.02052265e-01f, -1.32983133e-01f, -2.47658212e-02f, -1.42770901e-01f, -3.28289196e-02f, 6.26574308e-02f,
  2.56696314e-01f, 1.42751694e-01f, 1.45546779e-01f, 2.69414168e-02f, -1.54679343e-01f, 1.72318406e-02f, -1.03227898e-01f, -3.67859036e-01f, -4.07492548e-01f, -1.26554981e-01f,
  3.38629514e-01f, -2.88809417e-03f, -2.71726429e-01f, -1.05768964e-01f, 9.95538309e-02f, 1.77774370e-01f, -9.43747014e-02f, -6.31317049e-02f, -6.38534576e-02f, 3.82087901e-02f,
  9.22035575e-02f, -3.02725375e-01f, -7.41041973e-02f, 1.35942921e-01f, 8.22163746e-02f, -7.55202025e-02f, -5.44050522e-03f, -4.01393138e-02f, 9.18889791e-02f, -1.30466148e-02f,
  2.76378263e-02f, 2.35235635e-02f, -1.30175259e-02f, 3.18848751e-02f, -1.48330694e-02f, 3.79867442e-02f, -2.63785459e-02f, -1.58642739e-01f, -1.44498393e-01f, -1.17789358e-02f,
  2.58686036e-01f, 1.52787725e-02f, -1.54740050e-01f, -8.46972689e-02f, -7.37347528e-02f, -6.80926889e-02f, -7.56346881e-02f, -1.60285905e-01f, -2.62961745e-01f, -1.79356426e-01f,
  -4.24457751e-02f, -3.23312497e-03f, 6.81420462e-03f, -1.56345423e-02f, 9.77977272e-03f, 1.16074346e-02f, 3.69516499e-02f, -8.02660827e-03f, -1.36388643e-02f, 5.37968017e-02f,
  -9.58991703e-03f, -7.74801224e-02f, 4.78320047e-02f, -5.35310209e-02f, 7.09134340e-02f, 2.29047779e-02f, 2.65479297e-03f, 1.05795257e-01f, 8.74665007e-02f, -3.95264626e-02f,
  3.96236442e-02f, -1.14922680e-01f, 7.67645165e-02f, -9.70309451e-02f, -4.26279418e-02f, 2.24237703e-02f, 4.89661917e-02f, 9.79846716e-02f, -8.78344756e-03f, -4.47798781e-02f,
  2.44986042e-01f, -1.10855050e-01f, 2.69864816e-02f, -4.55432795e-02f, 3.68858539e-02f, 1.70265771e-02f, 4.11689840e-02f, 6.99848169e-03f, 6.98524341e-02f, -7.41831288e-02f,
  -2.91355383e-02f, -7.21068755e-02f, 9.05309767e-02f, 8.75438079e-02f, -3.38934734e-02f, 3.16455513e-02f, 1.46526679e-01f, -2.80275811e-02f, -5.12801372e-02f, -6.06069341e-02f,
  9.75037366e-02f, -2.51153037e-02f, 5.36161009e-04f, 6.01365641e-02f, 5.78913912e-02f, -2.55061388e-02f, -5.15695103e-02f, -2.26607341e-02f, -1.05050884e-01f, -2.74996907e-02f,
  1.72637433e-01f, 6.49208277e-02f, -3.20115864e-01f, 2.01526552e-01f, 1.79900065e-01f, 1.06987275e-01f, 1.45509571e-01f, 1.63983703e-01f, 2.05240041e-01f, 7.12390020e-02f,
  1.19731449e-01f, 1.65624365e-01f, -9.48970690e-02f, -2.41437480e-02f, -1.77664861e-01f, -1.47844493e-01f, -1.39551923e-01f, -3.16995054e-01f, -5.40483110e-02f, 8.10423493e-02f,
  2.04405904e-01f, 6.85051009e-02f, -6.53376654e-02f, -3.76974232e-02f, -1.56041056e-01f, -1.38952956e-01f, -1.66411281e-01f, -1.97121456e-01f, -5.95834292e-02f, -1.43873230e-01f,
  -2.83414871e-01f, -3.67494747e-02f, -1.36726171e-01f, -5.59488311e-02f, -1.25982836e-01f, -6.63613155e-02f, -9.26741958e-02f, -1.65810913e-01f, -5.55410795e-02f, -3.91329303e-02f,
  -8.27432871e-02f, -3.80694605e-02f, -4.90011871e-02f, -4.29576151e-02f, -1.17679253e-01f, 4.01818287e-03f, -7.07714260e-02f, -1.92799717e-01f, -9.54915360e-02f, -2.89084278e-02f,
  -6.77553995e-04f, -9.58659220e-03f, -2.80964255e-01f, -1.81757316e-01f, -2.86160767e-01f, -2.44414315e-01f, -2.71123409e-01f, -2.72108823e-01f, -3.41001213e-01f, -1.43224910e-01f,
  -1.38209566e-01f, 7.49788433e-02f, 1.27027437e-01f, 6.45783767e-02f, 1.73942316e-02f, 7.48257637e-02f, 6.56234100e-02f, 2.54656263e-02f, 1.04739308e-01f, 2.36619730e-02f,
  1.50047038e-02f, -1.22893928e-03f, 6.17590435e-02f, 2.91472673e-02f, 4.04942483e-02f, 8.05871710e-02f, 1.11485288e-01f, -1.18915839e-02f, -8.34398568e-02f, 3.78451571e-02f,
  1.24536706e-02f, 1.80884562e-02f, 8.53822380e-02f, -1.80813903e-03f, 5.57317697e-02f, 5.13828397e-02f, 3.86602171e-02f, 7.54236579e-02f, 1.85954079e-01f, 1.95717111e-01f,
  -6.87656477e-02f, -2.49158531e-01f, -1.00881822e-01f, -9.97033566e-02f, 1.15550058e-02f, -1.32305771e-01f, -1.62314959e-02f, 4.13163844e-03f, -1.01134572e-02f, -1.31801650e-01f,
  -5.20772785e-02f, -1.23804852e-01f, -1.83657542e-01f, -3.38039212e-02f, -6.41072914e-02f, 7.82654248e-03f, 4.97884154e-02f, -8.57166480e-03f, -1.28217325e-01f, -1.70961544e-02f,
  -7.88599476e-02f, -7.13580325e-02f, -8.58254060e-02f, -1.10120133e-01f, -1.82228401e-01f, -1.29796401e-01f, -2.64040142e-01f, -2.34141245e-01f, -2.82882094e-01f, -2.06739396e-01f,
  1.25701666e-01f, 1.87829703e-01f, -2.26217255e-01f, 1.24828681e-01f, 2.90450696e-02f, -2.13625401e-01f, -1.64549753e-01f, -1.19345430e-02f, 1.11988597e-01f, 1.27907634e-01f,
  6.69162720e-02f, -1.87096715e-01f, -2.92742461e-01f, -3.28237861e-01f, -3.22780401e-01f, -1.65884346e-01f, -1.80625588e-01f, -3.99266571e-01f, -4.39929694e-01f, 1.13748452e-02f,
  1.13841198e-01f, 2.62013853e-01f, 4.15690094e-02f, -5.23818992e-02f, 1.99989036e-01f, -4.89802919e-02f, 8.91403109e-02f, 2.51279861e-01f, -4.85805497e-02f, 2.57125258e-01f,
  4.24492965e-03f, 3.04030150e-01f, -1.92578673e-01f, 5.48463389e-02f, 6.18534796e-02f, 4.57297824e-02f, 1.02867074e-02f, 2.23121103e-02f, -1.20743364e-02f, 5.94747178e-02f,
  3.61096822e-02f, -2.25152057e-02f, 4.16080700e-03f, 5.03200293e-02f, 5.00634201e-02f, 1.41774546e-02f, 9.52755660e-02f, -1.09162621e-01f, -7.93571100e-02f, 4.80212970e-03f,
  2.37779897e-02f, 1.76193386e-01f, -5.35430200e-02f, -3.91062796e-02f, -5.82654476e-02f, -4.50649075e-02f, 7.03500258e-03f, 6.27448633e-02f, -1.17020525e-01f, 2.16123253e-01f,
  5.40190786e-02f, 2.22330843e-03f, -2.36373581e-03f, 1.51914045e-01f, 7.87918866e-02f, -5.34411869e-04f, 1.02643454e-02f, 9.12151299e-03f, -1.65672023e-02f, 1.77284658e-01f,
  -8.78982916e-02f, -3.38084809e-02f, 9.23873857e-02f, -3.71347815e-02f, 1.38419783e-02f, -3.33268829e-02f, -1.72238927e-02f, 6.54184371e-02f, 5.60652614e-02f, 6.26014993e-02f,
  7.33657777e-02f, 5.30819558e-02f, 1.11454628e-01f, -1.17349122e-02f, 1.79039817e-02f, -7.33491555e-02f, 6.96137622e-02f, 7.53857642e-02f, 6.61038309e-02f, 2.66415142e-02f,
  5.16205728e-02f, -2.68514335e-01f, -1.04142196e-01f, -3.75138633e-02f, -4.37254161e-02f, -1.10650174e-02f, -6.13926649e-02f, 1.17855528e-02f, 3.96100506e-02f, -3.94683890e-02f,
  1.62403323e-02f, -8.38743746e-02f, 4.05420957e-04f, 5.07992692e-02f, -4.88490686e-02f, 1.54754659e-02f, 7.60961976e-03f, -1.24181442e-01f, -1.09956913e-01f, 5.11385128e-02f,
  -7.25159720e-02f, -9.09227580e-02f, -1.89234182e-01f, -2.16846421e-01f, 3.67129296e-02f, -2.62982011e-01f, -1.90221071e-01f, -8.53686258e-02f, -2.41964594e-01f, -2.60443520e-02f,
  6.68690503e-01f, -3.01878989e-01f, 6.16903491e-02f, 1.49555251e-01f, -2.84588307e-01f, -2.07847983e-01f, -1.62386701e-01f, 1.00508593e-01f, 1.39734730e-01f, -2.37752069e-02f,
  -2.60636955e-01f, -9.18483660e-02f, -1.90243311e-02f, 2.75333337e-02f, 1.00770459e-01f, -9.97916535e-02f, 8.94780550e-03f, 2.11798549e-01f, 2.26863861e-01f, 1.47794127e-01f,
  -2.35748980e-02f, 1.69485837e-01f, 2.43217409e-01f, 8.42855796e-02f, -6.25973418e-02f, -9.34344903e-02f, -6.76807910e-02f, -9.79300961e-02f, -2.68775344e-01f, -6.87179789e-02f,
  -1.34247586e-01f, 8.62102397e-03f, 8.13374817e-02f, 4.17766869e-02f, -1.86864406e-01f, 6.35004044e-02f, -7.73174688e-03f, 8.43747854e-02f, -2.41097454e-02f, 4.68318425e-02f,
  -1.58276588e-01f, 6.21291250e-02f, -7.74195194e-02f, -4.36868928e-02f, 6.55384660e-02f, -5.99433370e-02f, 3.35209034e-02f, 1.74824938e-01f, 7.72970617e-02f, -1.11118011e-01f,
  -2.35306665e-01f, -1.03387803e-01f, 5.73401302e-02f, -9.06255096e-02f, -1.35877449e-02f, 3.29755656e-02f, -5.02647050e-02f, -5.33793680e-02f, -3.88664529e-02f, 1.27393063e-02f,
  3.22340131e-02f, -1.35057205e-02f, -7.29668187e-03f, -1.89311116e-03f, -4.57108915e-02f, -1.56933703e-02f, -2.28359587e-02f, -7.86621403e-03f, 1.38650574e-02f, -1.15250451e-02f,
  1.01721624e-03f, -4.89970371e-02f, 4.29078415e-02f, 6.02714047e-02f, -3.46474051e-02f, -6.32774085e-02f, 4.67322767e-02f, 3.80285233e-02f, -3.18826288e-02f, -9.27196816e-03f,
  -5.58495149e-03f, 1.31549723e-02f, -9.37426165e-02f, -7.41459522e-03f, 2.47105453e-02f, 7.64520001e-03f, 1.01709016e-01f, -7.91028142e-03f, -5.30009642e-02f, -2.42839288e-02f,
  6.32853210e-02f, -1.20766595e-01f, 1.43314106e-02f, -4.89043212e-03f, -2.55969930e-02f, 1.49361379e-02f, -2.28774976e-02f, -1.72818676e-02f, -3.65316756e-02f, 5.80237135e-02f,
  -8.62376988e-02f, 7.72383437e-02f, -9.12741274e-02f, 6.36456162e-03f, -6.81950850e-03f, 1.32180192e-02f, -1.09147444e-01f, 5.50539382e-02f, -2.09523086e-02f, -9.85367894e-02f,
  -4.92877848e-02f, 1.28574550e-01f, 1.17012963e-01f, 1.19090714e-01f, -2.19622608e-02f, 8.70104134e-02f, 9.44204722e-03f, -1.33606037e-02f, 9.87316594e-02f, 1.44693211e-01f,
  -4.21086907e-01f, -2.86287606e-01f, -1.90196022e-01f, -2.40766183e-01f, -1.03951402e-01f, -3.93399373e-02f, -2.24977657e-01f, -1.44920826e-01f, 1.38395028e-02f, -1.50993586e-01f,
  1.29588857e-01f, 3.49231064e-01f, 2.75286824e-01f, 1.90306380e-01f, 1.14951909e-01f, -2.08154351e-01f, -1.51641518e-01f, 8.75793695e-02f, 2.58811265e-01f, 2.27841824e-01f,
  3.20689380e-02f, -1.90479875e-01f, -2.24411897e-02f, -3.59921679e-02f, -5.40588908e-02f, 9.87220854e-02f, -9.44037512e-02f, -1.92016214e-02f, 3.72461304e-02f, -6.47067726e-02f,
  2.07901910e-01f, -9.64280441e-02f, 1.10387266e-01f, 1.11148600e-02f, 4.85660322e-02f, 3.68448091e-03f, -3.56671549e-02f, -1.84182555e-03f, 9.45379287e-02f, -1.05085000e-01f,
  1.00838318e-01f, 1.17891863e-01f, -3.40139158e-02f, 2.52333153e-02f, 1.68257975e-03f, 1.03864297e-02f, -2.14969460e-03f, 6.22456372e-02f, -3.95272523e-02f, 1.13503821e-01f,
  3.25878225e-02f, 1.86766833e-02f, -1.12659566e-01f, 4.58114371e-02f, 7.14504048e-02f, 1.66462481e-01f, 7.65912235e-02f, 3.21555920e-02f, 5.81328236e-02f, 3.26741636e-02f,
  7.23297819e-02f, 2.65769213e-02f, -3.10571399e-02f, -1.48991793e-01f, 7.21835718e-02f, -1.28603568e-02f, -2.92381141e-02f, -7.62416646e-02f, 1.93836931e-02f, -2.47966293e-02f,
  7.55552724e-02f, -2.02509779e-02f, 2.28937510e-02f, -4.50538658e-02f, 3.18631530e-02f, -1.17900735e-02f, -9.96489376e-02f, 4.20475379e-02f, 5.04969023e-02f, -1.01323090e-01f,
  3.20755057e-02f, 9.48230922e-03f, -4.19713818e-02f, -5.95397130e-03f, 5.58019336e-03f, 3.18120569e-02f, -1.06830178e-02f, 3.61658707e-02f, -2.50178855e-02f, -1.03449859e-02f,
  8.05685520e-02f, -6.08958639e-02f, -4.41842079e-02f, 8.87812153e-02f, -1.47310048e-02f, 3.51836942e-02f, 4.17525414e-03f, 1.00381680e-01f, -9.77930333e-03f, -2.26503275e-02f,
  8.61178190e-02f, 2.43771393e-02f, 1.86151247e-02f, -4.32492886e-03f, 1.17184604e-02f, 6.79876655e-02f, -1.82649009e-02f, -3.79209183e-02f, 6.46856204e-02f, 3.57182510e-02f,
  -8.94317552e-02f, -5.55643998e-02f, -1.45929322e-01f, -3.47065851e-02f, 1.64139469e-03f, 3.90583538e-02f, 6.65507317e-02f, -4.63002697e-02f, 5.15872538e-02f, -1.20643504e-01f,
  4.75064933e-01f, -4.07925844e-02f, 1.76697508e-01f, 7.32363090e-02f, 9.85617191e-02f, 2.45897740e-01f, 2.35499099e-01f, 1.68743104e-01f, 1.60531878e-01f, 1.47429585e-01f,
  4.51354422e-02f, 4.73981649e-02f, 1.40854716e-01f, 1.00945048e-01f, 3.66139323e-01f, 1.45125121e-01f, 1.68203950e-01f, 3.46966594e-01f, 2.98498183e-01f, 3.40493284e-02f,
  -1.31676774e-02f, 1.57134056e-01f, 2.67861575e-01f, 4.91080098e-02f, -1.42005861e-01f, 3.84228081e-02f, 2.70908661e-02f, 1.62322611e-01f, 1.15503827e-02f, -1.37229264e-01f,
  -3.84243615e-02f, 2.86385804e-01f, 2.30307341e-01f, 6.43488988e-02f, 3.81813943e-02f, 1.85948744e-01f, 1.23712152e-01f, 1.24651156e-01f, 8.42150524e-02f, 1.41275227e-01f,
  1.67412370e-01f, 7.99465254e-02f, 2.13291615e-01f, 1.37365445e-01f, 1.18581071e-01f, 1.87145397e-01f, 2.70333320e-01f, 2.04424709e-01f, 2.23716080e-01f, 4.50514369e-02f,
  2.80411970e-02f, 1.56983539e-01f, 3.22151721e-01f, 1.60421193e-01f, 8.34944248e-02f, 2.17385411e-01f, 1.41824260e-01f, 7.96198547e-02f, 1.49730936e-01f, 1.80614948e-01f,
  -1.72537670e-01f, -6.89096600e-02f, -8.48506540e-02f, -1.05856098e-01f, 2.42763311e-02f, -4.07583304e-02f, -5.70281073e-02f, -1.04782052e-01f, -4.20367047e-02f, -8.57782736e-02f,
  6.05652928e-02f, -2.74947081e-02f, 3.35553358e-03f, 3.17792632e-02f, -8.26044902e-02f, -7.10559338e-02f, -8.58360156e-02f, -5.68470284e-02f, 4.11519036e-03f, -7.22047240e-02f,
  -1.07174460e-02f, -1.54858353e-02f, -1.74031705e-02f, -1.10437065e-01f, -1.37854610e-02f, 1.80519447e-02f, -1.12975776e-01f, -5.71999736e-02f, -8.11748579e-02f, 1.01459101e-02f,
  1.24215558e-01f, 4.22684252e-01f, 1.13202572e-01f, 1.92264676e-01f, 3.77379395e-02f, 1.34877235e-01f, 1.34513512e-01f, 1.36566430e-01f, 2.15084106e-01f, 1.75696403e-01f,
  5.43553643e-02f, 2.07623005e-01f, 9.70544815e-02f, 5.54310568e-02f, 1.80519298e-01f, 1.13723122e-01f, 1.03638329e-01f, 2.13123605e-01f, 8.09668005e-02f, 4.73371148e-02f,
  3.63444127e-02f, 1.33105278e-01f, 2.34708756e-01f, 1.66650191e-01f, 5.98683245e-02f, 3.36893171e-01f, 1.32810488e-01f, 1.29757628e-01f, 2.14866385e-01f, 2.75148153e-01f,
  2.48222709e-01f, -9.45293009e-02f, -3.21311563e-01f, -6.99919313e-02f, -9.09072235e-02f, 1.00577567e-02f, -6.33323640e-02f, 1.79520190e-01f, 9.12732258e-02f, 1.95501056e-02f,
  1.87604219e-01f, 2.87195027e-01f, 1.92091674e-01f, 1.64253995e-01f, 1.51608363e-01f, -1.86854988e-01f, -1.23889990e-01f, -3.58013958e-02f, 2.20371976e-01f, 2.78665900e-01f,
  9.09559056e-02f, 8.49194303e-02f, 2.47364596e-01f, 1.53863505e-01f, 8.71037308e-04f, 6.80795833e-02f, -1.43849015e-01f, -2.45284103e-02f, 1.03776321e-01f, -2.37634361e-01f,
  -2.49642268e-01f, 8.45822319e-02f, 1.12927064e-01f, 2.62407243e-01f, 6.90689683e-02f, 1.75159015e-02f, -1.09699033e-02f, 1.61307469e-01f, 1.51783302e-01f, 1.22854471e-01f,
  9.92942750e-02f, 1.73925340e-01f, 1.11015633e-01f, 6.67850822e-02f, 1.15327723e-01f, 1.28336564e-01f, 6.96555153e-02f, 5.16973250e-02f, 1.35913208e-01f, 1.37882799e-01f,
  3.94073725e-02f, -6.67002052e-02f, -1.50772342e-02f, -3.06581631e-02f, 1.93459075e-02f, 4.40215319e-02f, 5.80453314e-03f, -3.11739594e-02f, -1.64625328e-02f, 5.81251495e-02f,
  -1.50485605e-01f, -5.73488437e-02f, -9.66867525e-03f, 7.43967295e-03f, 1.30822901e-02f, -1.50580881e-02f, -9.76311937e-02f, 1.04323067e-02f, 4.54822928e-03f, -9.84714851e-02f,
  3.14082094e-02f, -3.96143980e-02f, -4.95219789e-02f, -3.03401109e-02f, -1.36087373e-01f, -1.09954089e-01f, -8.72432888e-02f, -8.09840783e-02f, -4.37537543e-02f, -1.72704943e-02f,
  -6.86772093e-02f, -2.49947254e-02f, -1.80345848e-02f, -5.44877648e-02f, -4.89035174e-02f, -1.20558754e-01f, 4.47551310e-02f, -1.62679274e-02f, 4.77003418e-02f, 7.84511566e-02f,
  1.55654833e-01f, 2.39735901e-01f, 5.05722351e-02f, 6.39954060e-02f, 4.74843420e-02f, 6.52386099e-02f, 9.69554763e-03f, 1.00256495e-01f, 1.60566658e-01f, 4.65630926e-02f,
  1.74518153e-01f, 8.65215808e-02f, 4.21593077e-02f, 1.40515849e-01f, 1.18147098e-02f, 6.17920309e-02f, 5.48042692e-02f, 7.59413689e-02f, 6.95787221e-02f, 1.88321469e-03f,
  5.35577014e-02f, 1.63068846e-02f, 9.94372368e-02f, -4.82067512e-03f, 9.63014141e-02f, 1.56980693e-01f, -1.41409868e-02f, 2.23534107e-02f, 1.32348210e-01f, -7.90392887e-03f,
  -6.22630343e-02f, 6.94284067e-02f, 2.32362151e-01f, -4.23214585e-01f, -1.91698492e-01f, 2.33541101e-01f, 5.03167152e-01f, 3.44594359e-01f, -1.87146202e-01f, -6.64012926e-03f,
  -2.40677550e-01f, -3.53973269e-01f, -3.64620984e-01f, -1.41551301e-01f, 2.54348814e-01f, 2.57579774e-01f, -7.00763799e-03f, 1.53410181e-01f, 2.95290023e-01f, 1.88805938e-01f,
  -7.99712911e-02f, -1.18249275e-01f, 1.77151352e-01f, 1.80409029e-02f, -2.92767286e-01f, -3.41866612e-01f, -4.92870174e-02f, -1.23232342e-01f, 1.79407135e-01f, -1.54393345e-01f,
  -6.91221356e-02f, 1.92869812e-01f, 9.91837457e-02f, -3.27475034e-02f, 1.81288067e-02f, 1.30190596e-01f, 7.06565678e-02f, -2.35301126e-02f, 4.43163002e-03f, -5.12200361e-03f,
  -5.12902811e-02f, -2.98633636e-03f, -5.76867647e-02f, -7.55150765e-02f, -2.32332274e-02f, 7.48339444e-02f, 1.38918504e-01f, 1.25891730e-01f, 3.04735079e-02f, 8.14992711e-02f,
  -1.06320336e-01f, -5.40982299e-02f, 1.05088949e-02f, 1.21977232e-01f, 2.62896657e-01f, -5.52616417e-02f, 1.80659369e-02f, 7.24524409e-02f, 2.55962402e-01f, 2.09021233e-02f,
  9.51172709e-02f, -8.44783708e-03f, 6.50255606e-02f, -1.04994066e-02f, 3.77276726e-02f, -6.02788106e-02f, -7.95169324e-02f, -3.62741277e-02f, -2.35935263e-02f, -9.67241637e-03f,
  2.55619977e-02f, -2.78980602e-02f, 1.37369772e-02f, -4.21696939e-02f, -1.13701276e-01f, 1.24059673e-02f, 7.65429204e-03f, 4.92506400e-02f, -3.96898501e-02f, 7.79499579e-03f,
  -6.62125722e-02f, 8.83501694e-02f, -6.55681714e-02f, 3.77390049e-02f, 3.10342629e-02f, 4.74641733e-02f, -1.43303489e-03f, -6.66551515e-02f, 3.80276665e-02f, 2.49123143e-04f,
  -2.62739092e-01f, 1.44878522e-01f, -1.36355683e-01f, -3.37970480e-02f, -9.77287441e-02f, 7.11090490e-02f, -1.64106369e-01f, 5.45517057e-02f, -1.78015843e-01f, -3.95240970e-02f,
  6.78666160e-02f, 3.07969581e-02f, -6.02870025e-02f, 8.18270147e-02f, -6.15714118e-02f, -3.06186154e-02f, -6.05587102e-02f, -1.22045942e-01f, -1.53537579e-02f, 7.70846903e-02f,
  2.31013261e-02f, 6.41261935e-02f, -1.21792324e-01f, -8.76134336e-02f, -5.08820973e-02f, -2.12531492e-01f, -8.18703696e-02f, 3.90034243e-02f, 6.93940045e-03f, 1.08142681e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.14780957e-01f, 1.53590590e-01f, -8.29692543e-01f, 3.60757232e-01f, 2.83924222e-01f, -3.09251726e-01f, -4.00109142e-01f, -2.73643821e-01f, 4.50534075e-01f, 3.59050483e-01f,
  4.80349392e-01f, 8.95601511e-02f, -3.72872859e-01f, -4.78265405e-01f, -1.02823663e+00f, -5.04518926e-01f, -5.03289580e-01f, -9.34053957e-01f, -8.96820724e-01f, -8.99197310e-02f,
  4.88800317e-01f, 1.12638243e-01f, -3.43135893e-01f, -2.80979365e-01f, 2.33472243e-01f, -1.61083996e-01f, -1.47274449e-01f, -9.91854295e-02f, -3.03751260e-01f, -1.56319872e-01f,
  -2.43653253e-01f, -1.24314785e-01f, -9.46930274e-02f, 1.94878727e-02f, 1.79326937e-01f, -7.41908252e-02f, -1.48089007e-01f, -1.57724053e-01f, 1.62736267e-01f, -3.14279161e-02f,
  3.51186171e-02f, 1.92677125e-01f, 1.08783588e-01f, -6.54750466e-02f, -2.76991665e-01f, -2.07082793e-01f, -1.74359769e-01f, -2.66884059e-01f, -3.64535004e-01f, -1.72731310e-01f,
  2.47155100e-01f, -9.90944058e-02f, -7.41258979e-01f, -2.68114835e-01f, -5.90919495e-01f, -4.00116563e-01f, -3.00584823e-01f, -3.14884365e-01f, -7.34101951e-01f, -4.19290699e-02f,
  9.18409973e-02f, -8.81280378e-02f, 1.52719691e-01f, 2.26370320e-02f, 4.81259748e-02f, 2.34552503e-01f, -1.05777912e-01f, 4.19025868e-02f, -1.36592723e-02f, 5.10822516e-03f,
  -8.63197967e-02f, 1.93766728e-02f, -1.24813791e-03f, -1.29226431e-01f, -1.05677359e-01f, -2.52251774e-02f, 8.24820697e-02f, -1.41042829e-01f, -6.56253695e-02f, 1.44417495e-01f,
  -1.66563287e-01f, -3.89786350e-04f, 1.87238768e-01f, -1.30507499e-01f, 8.19323957e-02f, -1.75155908e-01f, 8.26224685e-03f, 3.21201012e-02f, -1.75584838e-01f, 1.00888699e-01f,
  5.03546931e-03f, -1.56569734e-01f, 1.15490705e-01f, -5.16749799e-01f, 9.41142216e-02f, 1.98017120e-01f, 2.20175162e-01f, 6.42762110e-02f, 6.46054223e-02f, 6.10549115e-02f,
  -2.31734678e-01f, 6.22868203e-02f, 1.89243779e-01f, 1.02806762e-01f, 7.10239038e-02f, -8.23839158e-02f, 8.62951875e-02f, 1.04668893e-01f, -2.22180173e-01f, 2.58638769e-01f,
  3.49416211e-02f, -2.80663788e-01f, -2.99697399e-01f, -1.52557135e-01f, -6.20555319e-02f, -2.27048263e-01f, -2.89530784e-01f, -1.07953519e-01f, -5.00477850e-01f, 4.24599610e-02f,
  -1.36465117e-01f, -7.39533842e-01f, -4.71920483e-02f, -3.20523143e-01f, -1.75643474e-01f, -2.02820033e-01f, -8.12908232e-01f, -2.55264759e-01f, 8.78107026e-02f, -7.93707490e-01f,
  -3.82150620e-01f, 2.89696664e-01f, 4.63047773e-02f, 9.09954533e-02f, -1.49702951e-01f, -1.12784767e+00f, -6.37111068e-01f, 1.35389075e-01f, 7.27159500e-01f, 1.74827889e-01f,
  -2.02973187e-01f, 1.29349332e-03f, 4.10365850e-01f, 2.28254616e-01f, -2.31585577e-01f, 1.74316183e-01f, -2.04283103e-01f, -7.30577335e-02f, -4.25743282e-01f, -5.82733810e-01f,
  -4.74981010e-01f, 3.79483122e-03f, 1.92242101e-01f, 2.55619735e-01f, -2.00515732e-01f, -6.93772733e-02f, -1.76688880e-01f, 5.71996011e-02f, 2.03264635e-02f, -1.81982741e-01f,
  3.32940929e-02f, 3.63909006e-02f, 1.66806713e-01f, -3.32539193e-02f, -1.99920172e-03f, -1.90087389e-02f, 8.90259072e-02f, 2.06534982e-01f, -8.16470571e-03f, -7.67488033e-02f,
  -9.43122208e-02f, -3.67786400e-02f, -5.53488173e-02f, 4.51383367e-02f, -6.63170964e-02f, 6.24076426e-02f, 1.75427437e-01f, 4.91370559e-01f, 2.29955405e-01f, -2.44018331e-01f,
  -1.74382821e-01f, -5.39433435e-02f, 5.05637415e-02f, 7.98387900e-02f, 4.89600785e-02f, 1.29831079e-02f, -1.32060394e-01f, -7.01595619e-02f, 1.93240941e-01f, 6.36596680e-02f,
  5.81931788e-03f, -4.65008579e-02f, 3.50857452e-02f, -1.73876151e-01f, 9.18623433e-02f, -1.90682765e-02f, -4.01808135e-02f, -1.43820569e-02f, 3.53930444e-02f, -1.99650936e-02f,
  1.63066968e-01f, -2.74503846e-02f, 2.56825564e-03f, 8.93069208e-02f, -4.77505438e-02f, -8.97073224e-02f, -5.79280406e-02f, 2.58456349e-01f, 5.29157408e-02f, -1.07141130e-01f,
  -1.18548021e-01f, 2.64412016e-01f, -4.27824527e-01f, 1.16872795e-01f, -2.46235266e-01f, 1.64906159e-01f, 2.83212606e-02f, -1.61671322e-02f, 8.21299329e-02f, -4.37284000e-02f,
  1.32282853e-01f, -1.06588989e-01f, -1.06373854e-01f, 5.69934919e-02f, -2.83898041e-02f, 1.58265963e-01f, -4.06197518e-01f, 1.70406289e-02f, 7.97580779e-02f, -3.69492266e-03f,
  -1.87584758e-01f, -2.69349873e-01f, -4.14690793e-01f, -2.10514441e-01f, -8.11591744e-02f, -1.14736609e-01f, -1.62600935e-01f, 3.90640795e-02f, -8.87975022e-02f, -8.23533356e-01f,
  8.54354084e-01f, 4.34621602e-01f, 2.43672609e-01f, 2.48337731e-01f, 1.38129210e-02f, -1.29916174e-02f, 7.18075931e-02f, -1.57928601e-01f, 3.32029238e-02f, 2.94102520e-01f,
  1.81022301e-01f, 1.78140849e-01f, 4.54161502e-03f, 1.03222772e-01f, 2.05834121e-01f, 1.82307228e-01f, 1.24883421e-01f, 2.24092439e-01f, 1.38221532e-01f, 3.16953331e-01f,
  3.18445176e-01f, 1.96580589e-01f, 1.80978209e-01f, 1.92578942e-01f, 2.61290044e-01f, 9.19070169e-02f, 1.14184551e-01f, 2.54320621e-01f, 3.50044936e-01f, 5.09467304e-01f,
  5.50577700e-01f, 3.29438001e-01f, -3.81705225e-01f, -1.81443840e-01f, -2.51897573e-02f, -9.90369692e-02f, -2.96726692e-02f, -6.28743544e-02f, 1.85595900e-02f, -4.31768317e-03f,
  -8.51880386e-02f, 1.03120521e-01f, 6.75639212e-02f, -2.97546778e-02f, -2.51009557e-02f, -5.57229109e-02f, 2.12926902e-02f, 7.62741268e-02f, -3.85648794e-02f, 1.27128765e-01f,
  1.41057611e-01f, 8.13075453e-02f, -1.45872638e-01f, -1.87882453e-01f, 1.35079548e-01f, -9.22705308e-02f, -1.65832993e-02f, 8.50744024e-02f, -7.27661550e-02f, 1.38377056e-01f,
  5.97812980e-02f, 2.07007930e-01f, 2.63235480e-01f, 1.94942906e-01f, 1.36761114e-01f, -1.53619973e-02f, 2.30076518e-02f, 7.13079572e-02f, 7.89976716e-02f, -3.70689593e-02f,
  -1.23463228e-01f, -4.12782729e-02f, -2.93030560e-01f, -5.02229705e-02f, 1.13318432e-02f, 6.05008565e-02f, 7.09740969e-04f, -2.46006995e-02f, -4.10112888e-02f, -1.93393677e-01f,
  7.83703625e-02f, -1.31615654e-01f, -1.08539931e-01f, -7.73268417e-02f, -2.82344759e-01f, -1.17716596e-01f, 2.42713057e-02f, 1.54188713e-02f, 5.86318187e-02f, 2.39008609e-02f,
  -4.85720277e-01f, -2.65541643e-01f, 2.29720175e-02f, -1.24910682e-01f, -1.40261864e-02f, -6.15485311e-02f, 4.03194055e-02f, -1.23983145e-01f, -2.05344730e-03f, -1.29402712e-01f,
  1.40298288e-02f, -3.75992917e-02f, -2.07280051e-02f, -1.20815940e-01f, -1.01912729e-01f, -1.16717964e-01f, -1.14693046e-01f, -6.53027669e-02f, -1.35872185e-01f, -1.30270451e-01f,
  -1.38280615e-01f, -3.46748590e-01f, -1.87556982e-01f, -3.13123822e-01f, -1.89669430e-01f, -2.60153890e-01f, -2.30669245e-01f, -1.95573419e-01f, -2.96869695e-01f, -1.83677703e-01f,
  -1.14028490e+00f, -6.30028665e-01f, 8.63370657e-01f, -6.96619749e-01f, -1.34477645e-01f, 1.48579657e-01f, 8.00454170e-02f, -4.65855837e-01f, -4.37757701e-01f, -1.58196688e-02f,
  -1.16482906e-01f, -4.54360396e-01f, -1.58735663e-01f, -1.53602093e-01f, -4.72870290e-01f, 7.07799718e-02f, 4.89828661e-02f, -2.12806448e-01f, -2.23480776e-01f, -1.78130329e-01f,
  -4.69088614e-01f, -6.13277614e-01f, -6.47427261e-01f, -2.80330300e-01f, 2.62620617e-02f, -1.87260598e-01f, 3.38960662e-02f, -2.85385907e-01f, -6.00286108e-03f, -1.77706987e-01f,
  7.00622022e-01f, -3.62240881e-01f, -4.88435710e-03f, -4.04942900e-01f, -1.59296934e-02f, -8.14590082e-02f, 6.59508854e-02f, -1.14325725e-01f, -7.36493841e-02f, 1.06673099e-01f,
  -1.95582375e-01f, -1.44296706e-01f, 3.06371208e-02f, 3.82186435e-02f, -9.50806588e-02f, -3.27388421e-02f, -1.44291818e-01f, -2.89407253e-01f, -6.59741983e-02f, 2.71421373e-01f,
  1.52449861e-01f, -1.49468869e-01f, 6.61677197e-02f, 2.43898094e-01f, -6.86781406e-02f, -9.36337560e-02f, 2.29167253e-01f, -3.16423438e-02f, 7.29308948e-02f, 6.41649589e-02f,
  5.06339110e-02f, 2.62055844e-01f, -3.04939393e-02f, 3.37337591e-02f, 3.77214663e-02f, 1.53624453e-02f, 2.60531511e-02f, 1.14120819e-01f, -6.24858476e-02f, -1.32311687e-01f,
  -2.00862348e-01f, -9.88027900e-02f, -1.00400321e-01f, -1.43404096e-01f, 4.21541035e-02f, -1.88405946e-01f, 1.42952288e-02f, 2.04190146e-02f, 5.04736006e-02f, -1.46799207e-01f,
  -2.74607807e-01f, 2.63336543e-02f, -6.76574931e-02f, 3.13077457e-02f, -1.14911668e-01f, -1.36889398e-01f, 2.64884774e-02f, -9.28618480e-03f, -7.79785514e-02f, -9.44905579e-02f,
  1.19155534e-01f, -3.20934087e-01f, -1.84306167e-02f, -1.77417472e-01f, 1.23337936e-02f, -6.31937310e-02f, 1.96764588e-01f, -5.35841472e-02f, 2.91915033e-02f, 1.89514697e-01f,
  6.41804338e-02f, 7.08544627e-02f, 7.14101642e-02f, 1.24016657e-01f, 8.83596614e-02f, 9.30739418e-02f, -1.44460678e-01f, -1.05606660e-01f, 5.16719557e-03f, 1.82912156e-01f,
  3.16120796e-02f, 5.16586117e-02f, 4.36402895e-02f, 2.65269399e-01f, 1.19623981e-01f, 1.13564670e-01f, 2.99619883e-01f, 2.82145977e-01f, 1.71007559e-01f, 1.10710770e-01f,
  -5.02084434e-01f, 3.81925970e-01f, -3.47595774e-02f, 1.09910883e-01f, 2.10466012e-01f, 3.31391215e-01f, 3.23427677e-01f, 3.17912430e-01f, 2.06276566e-01f, 2.21332431e-01f,
  4.31856126e-01f, 5.98278642e-01f, 5.10372460e-01f, 4.10937071e-01f, 2.76068479e-01f, 3.06335479e-01f, 9.27377567e-02f, -3.13862525e-02f, 1.13038711e-01f, 1.87346384e-01f,
  1.82460532e-01f, -6.62355945e-02f, -2.05705076e-01f, -1.85016692e-02f, 1.81293741e-01f, 2.25071430e-01f, 7.26957098e-02f, 1.13803431e-01f, 5.13265990e-02f, -7.39988610e-02f,
  3.60074759e-01f, -1.55615240e-01f, -5.40760253e-03f, -4.21976224e-02f, -6.99603483e-02f, -2.57511944e-01f, 3.88397719e-03f, -1.89348385e-01f, -2.05345050e-01f, -1.39753282e-01f,
  -4.35032733e-02f, -8.05918649e-02f, 1.01341009e-02f, 3.91752161e-02f, -2.10468516e-01f, -5.25961965e-02f, -7.36015067e-02f, 1.45264640e-01f, 1.81373611e-01f, 1.60384133e-01f,
  9.40288678e-02f, -6.19968995e-02f, 1.09848745e-01f, 9.67131630e-02f, 8.59855264e-02f, 4.80300635e-02f, 1.54851694e-02f, 3.02419346e-02f, -4.22304571e-02f, -1.18049428e-01f,
  2.90764093e-01f, 7.19355941e-02f, 1.74037501e-01f, 1.60979584e-01f, 8.85874107e-02f, -1.77475053e-03f, 1.41607905e-02f, 1.51262835e-01f, 7.76741877e-02f, -2.68244408e-02f,
  4.34856154e-02f, 1.78286195e-01f, 4.02026884e-02f, -4.75940891e-02f, 5.32587096e-02f, 4.31655832e-02f, -8.73286575e-02f, 4.40142415e-02f, -4.27620523e-02f, -4.55658995e-02f,
  -1.44931572e-02f, -1.68412849e-01f, -1.29853055e-01f, -4.73500006e-02f, -1.08323865e-01f, 5.33668026e-02f, -1.14282452e-01f, 6.81586638e-02f, -2.88418569e-02f, -2.11405396e-01f,
  6.12807572e-01f, 2.09744588e-01f, -3.13351378e-02f, -7.26519972e-02f, -2.62177944e-01f, -2.23316282e-01f, 2.20258790e-03f, -2.06708789e-01f, -1.51893809e-01f, -1.34921387e-01f,
  -1.46273345e-01f, -1.16102479e-01f, -4.54870053e-02f, -5.34051284e-02f, -1.28146335e-01f, -3.73822823e-02f, -9.40258577e-02f, 7.59410411e-02f, 9.25997421e-02f, -4.81806099e-02f,
  -5.68021201e-02f, -1.91251095e-02f, 6.63179904e-02f, 1.02906674e-01f, -1.61057357e-02f, 8.93475674e-03f, 3.39561366e-02f, -8.56234506e-02f, 7.37891793e-02f, 2.32344978e-02f,
  9.55249190e-01f, -3.89344245e-01f, 2.42638797e-01f, 1.12768918e-01f, -2.91504443e-01f, -2.94698387e-01f, -5.02293229e-01f, -1.57996565e-01f, 4.27325964e-02f, 1.06175719e-02f,
  -8.43862742e-02f, 2.09323853e-01f, 2.53838360e-01f, 2.30244830e-01f, 2.19833136e-01f, -6.93575421e-05f, 1.04156639e-02f, 4.53643113e-01f, 4.59059030e-01f, 1.19722150e-01f,
  -1.13490351e-01f, 4.01749648e-02f, 3.49913895e-01f, 3.58515978e-02f, -7.42567331e-02f, 1.71994060e-01f, 1.64381322e-02f, -8.33466053e-02f, 4.68798243e-02f, 3.10049862e-01f,
  3.80673856e-01f, -2.54836604e-02f, 1.94574073e-01f, 7.97271580e-02f, -5.53116687e-02f, 1.58140878e-03f, -2.80479863e-02f, 8.10590759e-02f, -1.06927149e-01f, -7.78851658e-02f,
  -1.49134159e-01f, 1.65368654e-02f, -3.05409525e-02f, -1.47028536e-01f, -1.53539479e-01f, -5.17108068e-02f, 2.91968491e-02f, 1.65061772e-01f, -6.54058298e-03f, -5.46805263e-02f,
  -9.86100957e-02f, -8.54181126e-02f, -1.15265958e-01f, -1.12877086e-01f, -1.11815436e-02f, 1.99588105e-01f, -6.77868277e-02f, -1.73176117e-02f, -2.62217913e-02f, 7.42573142e-02f,
  1.61620110e-01f, 1.31436422e-01f, 9.33411121e-02f, -3.47346514e-02f, 1.32025927e-01f, 1.15715817e-01f, 1.89678371e-02f, -4.70285155e-02f, 1.49496838e-01f, 1.02560502e-02f,
  4.38883388e-03f, 1.22378118e-01f, -1.59702525e-01f, -2.07225889e-01f, 8.43836889e-02f, 6.52475283e-02f, 6.38058688e-03f, -1.94402546e-01f, -1.72876026e-02f, -2.96153892e-02f,
  1.01043358e-01f, 2.82661915e-02f, 1.92697361e-01f, -4.53477688e-02f, 5.65299913e-02f, 8.45728517e-02f, 1.00498334e-01f, 2.19182633e-02f, 4.57646511e-02f, -1.24627404e-01f,
  -4.68007356e-01f, 2.12435976e-01f, 2.25081638e-01f, -5.74960224e-02f, -5.66744246e-02f, -7.89765716e-02f, 9.69663262e-02f, -2.32687704e-02f, -2.00151145e-01f, -9.91217345e-02f,
  -5.01309261e-02f, 1.40727878e-01f, -1.18400671e-01f, 6.59618378e-02f, 8.78495276e-02f, -7.01504722e-02f, 6.73033996e-03f, -8.75614062e-02f, -5.91918714e-02f, -1.26217589e-01f,
  -1.10757731e-01f, -6.51153028e-02f, -1.38419941e-02f, -1.04490034e-01f, -1.11006379e-01f, 1.62656263e-01f, -3.12611721e-02f, 1.10097940e-03f, -1.24422135e-02f, 2.03969199e-02f,
  -8.55380774e-01f, 5.23287833e-01f, 8.50150645e-01f, -5.28370798e-01f, 1.81944877e-01f, 4.07181650e-01f, 4.45736051e-01f, 2.27011517e-01f, -2.81865168e-02f, 9.98848751e-02f,
  1.58904213e-02f, -2.98895359e-01f, 6.79637566e-02f, -7.47498795e-02f, -8.36527720e-02f, 4.98018116e-01f, 4.17905152e-01f, -1.24865010e-01f, -5.52287340e-01f, -6.94347143e-01f,
  -2.32007980e-01f, -4.85958040e-01f, -5.81061661e-01f, -2.29835838e-01f, -1.54449018e-02f, -1.17484100e-01f, 4.54701751e-01f, -5.83865121e-02f, 9.36601982e-02f, -8.61627683e-02f,
  -4.80757385e-01f, 1.75961815e-02f, 1.55338272e-01f, -2.24048272e-01f, 1.47621557e-01f, -2.88465708e-01f, 5.62821142e-02f, 7.88563043e-02f, 2.61469465e-02f, -3.05068586e-02f,
  -2.90065110e-02f, 9.53828767e-02f, 1.56046540e-01f, -2.82242093e-02f, -1.23288743e-02f, -1.89090177e-01f, -1.05584813e-02f, -1.14115231e-01f, -1.28872320e-01f, -8.65963846e-02f,
  -1.27731413e-01f, -4.52889651e-01f, -5.61075844e-03f, 2.84825504e-01f, 2.20025837e-01f, -1.77468807e-01f, 8.39961022e-02f, -3.18809718e-01f, -6.79309219e-02f, -2.60072440e-01f,
  -2.07015127e-02f, 1.43803209e-01f, 1.40090004e-01f, 1.75838038e-01f, -6.74347728e-02f, 4.16034721e-02f, 1.34644046e-01f, -1.28762528e-01f, -4.13467037e-03f, -2.16004893e-01f,
  2.19075233e-01f, -2.44982977e-04f, 1.14272833e-01f, 2.58639697e-02f, -8.36810991e-02f, -1.16851721e-02f, -1.16124630e-01f, -1.29596293e-01f, -8.48367959e-02f, -3.56866792e-02f,
  -6.14696294e-02f, 1.27831146e-01f, 5.56939952e-02f, -9.99155790e-02f, 1.82518154e-01f, -1.59010962e-02f, -1.91734985e-01f, -8.17597881e-02f, -1.47100966e-02f, 7.82565922e-02f,
  -4.36436683e-01f, -1.08994402e-01f, -5.22733070e-02f, -1.86395273e-03f, -1.74574450e-01f, -1.29626125e-01f, 6.88109696e-02f, 7.34562203e-02f, 1.82657897e-01f, -2.31778413e-01f,
  3.17150913e-03f, 5.08127734e-02f, 2.71589607e-01f, 1.68709084e-01f, -1.68670282e-01f, 1.52589818e-02f, -3.49092394e-01f, -1.11007743e-01f, -1.51362956e-01f, -2.35199511e-01f,
  9.29475054e-02f, -4.55152333e-01f, -6.42440438e-01f, -4.27052155e-02f, -2.70702273e-01f, -5.10725200e-01f, -1.38843879e-01f, -3.86803478e-01f, -2.58031160e-01f, -4.73079145e-01f,
  -5.14847398e-01f, -5.77734292e-01f, 7.15040788e-02f, 5.53409278e-01f, 6.04185820e-01f, 5.23200631e-01f, 3.58458757e-01f, 2.48736978e-01f, 3.85990232e-01f, 1.01605147e-01f,
  -2.49781966e-01f, -7.47372434e-02f, -1.02331176e-01f, -6.28906637e-02f, 3.19058001e-02f, 3.52619112e-01f, 5.23529649e-01f, 2.46878937e-01f, 2.21056387e-01f, 2.87198991e-01f,
  2.91014254e-01f, 2.97559857e-01f, -1.49777129e-01f, 1.38456076e-01f, 6.40020743e-02f, 3.38992834e-01f, 1.60795674e-01f, 1.19199872e-01f, 1.02826647e-01f, 2.32566595e-01f,
  -1.80557951e-01f, -3.54277194e-01f, 2.83679068e-01f, -5.98803833e-02f, -1.89994529e-01f, -3.38140368e-01f, -6.77741915e-02f, -1.71675459e-01f, -5.31085469e-02f, 5.57094328e-02f,
  -7.05254599e-02f, -1.63679928e-01f, -1.36190757e-01f, -1.81808755e-01f, -1.08186584e-02f, -6.44634217e-02f, -2.88127989e-01f, -2.01126426e-01f, -8.47346634e-02f, -1.52974665e-01f,
  -4.34300639e-02f, 1.60699815e-03f, 1.38970405e-01f, 1.86422408e-01f, -1.08316951e-01f, 8.88916850e-03f, -2.83584505e-01f, -9.91212130e-02f, -1.31620452e-01f, -1.15439452e-01f,
  1.76407650e-01f, -5.69479577e-02f, -1.16915725e-01f, -2.47689569e-03f, -1.10118035e-02f, -5.19445278e-02f, 9.18554794e-03f, 1.21609576e-01f, 6.86082467e-02f, 9.44136828e-02f,
  3.57742198e-02f, 8.36648643e-02f, -9.34875235e-02f, 6.16000630e-02f, -3.35666053e-02f, 5.20636998e-02f, -2.53254212e-02f, -8.51206779e-02f, -1.46902790e-02f, 1.19961441e-01f,
  1.64342657e-01f, 2.51340140e-02f, -1.76839858e-01f, -1.90517325e-02f, 9.64838453e-03f, 7.96835274e-02f, 2.09661901e-01f, 6.56021535e-02f, 1.01389870e-01f, 1.02621980e-01f,
  3.93017411e-01f, 5.30773997e-02f, 1.17291354e-01f, -8.97313058e-02f, -3.24997567e-02f, -1.59908101e-01f, 5.43677583e-02f, -1.12979755e-01f, -3.73967215e-02f, 7.04166591e-02f,
  -3.90589498e-02f, -1.85882211e-01f, -9.01560113e-02f, 2.89272964e-02f, 1.35326773e-01f, 1.32300958e-01f, -5.46649583e-02f, 3.27728726e-02f, 2.32857820e-02f, -2.97796689e-02f,
  3.34415697e-02f, 2.64316976e-01f, 2.09756106e-01f, 2.05623671e-01f, 1.95462748e-01f, 2.60906368e-01f, -1.35543733e-05f, 6.37807623e-02f, 1.38570264e-01f, 2.14449033e-01f,
  2.48316303e-02f, -7.74117529e-01f, -2.47574374e-01f, -4.26453203e-01f, -4.65258300e-01f, -1.47496670e-01f, -4.63986307e-01f, -2.91792564e-02f, -6.40442371e-02f, -4.39734459e-01f,
  -5.46662845e-02f, 3.81841302e-01f, 1.21795386e-01f, 2.52307981e-01f, 1.14760943e-01f, -4.50101733e-01f, -3.53588015e-01f, 1.81391433e-01f, 5.57541728e-01f, 1.52973756e-01f,
  -7.42395669e-02f, -1.74204424e-01f, 1.02175862e-01f, 1.05923139e-01f, -3.54241580e-01f, -1.10331111e-01f, -3.19173783e-01f, -1.16529316e-01f, -1.36860907e-01f, -5.23630500e-01f,
  1.47345930e-01f, 4.40467447e-01f, 1.74974933e-01f, 1.92756474e-01f, -2.40482893e-02f, 1.33169279e-01f, 9.38267820e-03f, -1.72612686e-02f, -4.25222889e-02f, -1.09746553e-01f,
  7.10506886e-02f, 1.31213795e-02f, 1.02821730e-01f, 1.03706263e-01f, 6.17423765e-02f, 8.41729492e-02f, 1.08453602e-01f, 1.42599726e-02f, 3.40052648e-03f, -8.04953650e-02f,
  -1.64414290e-02f, 1.06801793e-01f, 1.29753128e-01f, 2.27892101e-01f, 2.38746867e-01f, 3.55272770e-01f, 8.95388052e-02f, 1.87886313e-01f, 2.74323344e-01f, -1.13747887e-01f,
  2.73365080e-02f, -1.00536421e-01f, 2.15240911e-01f, 3.84645313e-02f, 6.84708208e-02f, -3.51988375e-02f, -7.99349323e-02f, -7.16498345e-02f, 1.97834134e-01f, 4.25960161e-02f,
  -1.36339560e-01f, -3.69953662e-02f, 7.97046795e-02f, -1.51315164e-02f, 5.47569878e-02f, 4.11739759e-03f, -6.92992136e-02f, 9.97382253e-02f, 2.11756557e-01f, -7.85765573e-02f,
  1.22860208e-01f, -4.06489782e-02f, -8.27600956e-02f, 2.41251644e-02f, 7.80905113e-02f, 5.26703335e-02f, 1.79190204e-01f, 1.49908364e-01f, 6.17654137e-02f, -5.69764152e-02f,
  3.36263701e-02f, 5.50294459e-01f, -1.55563876e-01f, 6.97666313e-03f, -1.31332442e-01f, -1.20155595e-01f, 3.06013953e-02f, -3.86379436e-02f, -9.62772220e-02f, -4.97649945e-02f,
  1.27662733e-01f, 1.29013672e-01f, -2.27417480e-02f, -2.97104567e-02f, 7.45351892e-04f, 1.66413784e-01f, -1.12433285e-02f, -6.12543672e-02f, -2.20029093e-02f, -1.65148348e-01f,
  -1.58947691e-01f, 1.07506830e-02f, 5.39450385e-02f, -4.46728291e-03f, 4.57581580e-02f, 1.71879396e-01f, 8.24985579e-02f, 7.25493878e-02f, 8.15745667e-02f, -4.20642912e-01f,
  -1.17351389e+00f, -6.36561811e-01f, 4.77202356e-01f, -1.48568228e-01f, 3.58959019e-01f, 2.07855493e-01f, -7.61256665e-02f, 7.04213902e-02f, -6.38823509e-02f, -4.00489777e-01f,
  -4.19666231e-01f, -3.44965756e-01f, -2.11441487e-01f, 2.59451829e-02f, -6.54430017e-02f, 1.35645971e-01f, 6.17187560e-01f, 3.06458443e-01f, 2.59532988e-01f, 1.08866217e-02f,
  3.23635414e-02f, -4.55848277e-02f, -8.36710408e-02f, 1.60367146e-01f, -2.52780557e-01f, 1.07207596e-01f, 2.93105394e-01f, -5.41292913e-02f, -1.97355673e-01f, -3.41757089e-01f,
  -6.84166968e-01f, -5.95253766e-01f, 5.37958205e-01f, -1.54505968e-01f, 1.76122441e-04f, -1.21640079e-01f, -1.87755480e-01f, 1.80562325e-02f, -3.84193361e-02f, -5.47763221e-02f,
  -7.09550977e-02f, -9.36868265e-02f, -2.07746491e-01f, -5.27750589e-02f, -6.47293776e-02f, -1.82256848e-03f, 3.83449078e-01f, 2.12588161e-01f, 1.51762664e-01f, -5.63884228e-02f,
  1.28410995e-01f, -2.00118706e-01f, -2.34754175e-01f, 3.09747726e-01f, 9.50219184e-02f, 1.03263192e-01f, -1.14471450e-01f, -2.34368324e-01f, -1.13635538e-02f, -5.42397439e-01f,
  -4.22957167e-02f, 4.66766208e-02f, 1.17508538e-01f, -1.41266799e-02f, 4.76046577e-02f, 2.83430815e-02f, 2.18839005e-01f, -2.09254175e-02f, -6.60700053e-02f, 1.51073085e-02f,
  -5.53454980e-02f, -9.88890231e-02f, -1.17370626e-02f, -6.53059930e-02f, -9.26490724e-02f, -7.59245530e-02f, -1.02281138e-01f, 7.75075480e-02f, 1.78728569e-02f, -2.76623890e-02f,
  -6.08716197e-02f, -1.98673876e-03f, 2.26021752e-01f, 5.23105189e-02f, 5.38665056e-02f, 2.61880457e-01f, -4.04201299e-02f, -8.75837822e-03f, -2.50666142e-02f, -1.76151678e-01f,
  -2.43224934e-01f, 4.84317660e-01f, -4.50037122e-01f, -9.89994314e-03f, -1.52542755e-01f, 2.83805549e-01f, -1.63781092e-01f, -9.14585516e-02f, -1.48267180e-01f, -1.72604188e-01f,
  -8.72920752e-02f, -2.01034054e-01f, -1.48538515e-01f, 1.47491500e-01f, -8.58062226e-03f, 1.90301589e-03f, 3.04318033e-02f, -6.09312654e-02f, 1.77488163e-01f, -7.58186057e-02f,
  3.37770641e-01f, -1.64130956e-01f, -5.01748502e-01f, -1.09216571e-01f, -1.38793573e-01f, -2.31402725e-01f, -3.04690957e-01f, -1.15383975e-01f, -3.63036782e-01f, -5.97560465e-01f,
  -5.21245241e-01f, -1.35805383e-01f, 3.53903025e-02f, -5.72212398e-01f, -4.05063480e-01f, -2.35870957e-01f, -2.33297661e-01f, -2.83561826e-01f, -5.02103716e-02f, 8.14806968e-02f,
  1.90312549e-01f, -1.42835617e-01f, 4.05814201e-02f, -1.38774052e-01f, -1.97035372e-01f, 2.30380848e-01f, 1.13957331e-01f, -2.31530637e-01f, -6.89148426e-01f, -6.89339578e-01f,
  -4.32514131e-01f, -7.45916903e-01f, -6.45033658e-01f, -4.07982469e-01f, -1.65743947e-01f, -1.99271604e-01f, 9.41025019e-02f, -2.11928040e-01f, 9.68832150e-02f, 1.36832714e-01f,
  -1.49595052e-01f, -5.08244485e-02f, -1.48568854e-01f, -8.77651647e-02f, -2.61955082e-01f, 4.29683030e-02f, -2.24560171e-01f, -8.07132423e-02f, 8.27310905e-02f, 3.39625031e-02f,
  5.50240949e-02f, -4.85238954e-02f, -9.44158435e-02f, -1.39219865e-01f, -2.72559851e-01f, -3.75212468e-02f, 7.25787953e-02f, 1.81254782e-02f, 1.66137248e-01f, 2.20905721e-01f,
  2.45962381e-01f, 2.56091684e-01f, 2.22332150e-01f, 8.15676227e-02f, 6.01869710e-02f, 4.90079410e-02f, 9.10210833e-02f, 1.49406746e-01f, 1.51812568e-01f, -3.94399241e-02f,
  -2.20563293e-01f, 8.24274570e-02f, -3.23293023e-02f, -1.01952374e-01f, 6.25380203e-02f, 1.73757717e-01f, 6.67587295e-02f, 1.26982974e-02f, -9.05646477e-03f, -8.39065239e-02f,
  -8.43739063e-02f, 1.30244538e-01f, -6.25459105e-02f, 2.47099623e-02f, 3.56062055e-02f, 7.52351582e-02f, 1.02453232e-01f, -9.46167707e-02f, 1.91244006e-01f, 1.15302451e-01f,
  9.72796977e-02f, 2.40777597e-01f, 8.72244686e-02f, -6.77527338e-02f, 1.05254184e-02f, -6.01054765e-02f, 1.12617359e-01f, -8.71926825e-03f, -6.26614094e-02f, 1.60436705e-01f,
  -8.13195884e-01f, 1.85111135e-01f, -7.05093592e-02f, 6.50303066e-02f, -2.56373137e-02f, 1.22108385e-01f, -8.20458233e-02f, 1.17586292e-02f, -6.09857477e-02f, -8.02672133e-02f,
  5.82671277e-02f, -3.99440825e-02f, -1.13991564e-02f, 4.53873463e-02f, -1.97048113e-01f, -3.43367197e-02f, 2.47147586e-02f, -4.68834341e-02f, 2.04119518e-01f, 5.41450717e-02f,
  2.65281111e-01f, 2.23011464e-01f, 7.44974017e-02f, 1.63736582e-01f, 6.58998936e-02f, 5.39769754e-02f, 5.04720472e-02f, 5.96686378e-02f, 1.57333896e-01f, -1.12612940e-01f,
  -1.42997608e-01f, -7.61846304e-01f, -4.42076802e-01f, -7.95477211e-01f, -4.25042778e-01f, -1.68758988e-01f, -5.60049295e-01f, -2.14748204e-01f, -1.72186255e-01f, -6.76432431e-01f,
  -1.41076669e-01f, 4.04374272e-01f, 1.35943040e-01f, 2.93539912e-01f, 3.62794876e-01f, -6.83512270e-01f, -5.71312428e-01f, 2.18084231e-01f, 6.52881563e-01f, 8.31430107e-02f,
  -3.73608559e-01f, -2.37929195e-01f, 5.03470525e-02f, -7.86585286e-02f, -8.55373681e-01f, -2.39466220e-01f, -6.40484393e-01f, -4.92896944e-01f, -3.45232904e-01f, -7.24606514e-01f,
  -3.80329370e-01f, -1.22432739e-01f, 3.50245118e-01f, 3.40528518e-01f, -2.67997861e-01f, 2.87299901e-01f, -1.11159205e-01f, -1.65628809e-02f, 1.66488290e-01f, -1.95081726e-01f,
  1.08495401e-02f, 2.20811248e-01f, 1.30331755e-01f, 1.22244254e-01f, -2.67976880e-01f, -8.70035440e-02f, -4.62117717e-02f, 1.89017385e-01f, 4.28202488e-02f, 4.25741374e-02f,
  -9.68391448e-02f, -6.64654672e-02f, 1.75141320e-02f, -7.11979941e-02f, 1.33981079e-01f, 2.85368860e-01f, -1.59508035e-01f, 2.44660545e-02f, 1.84710890e-01f, -7.66535163e-01f,
  -7.00764433e-02f, -5.19307964e-02f, -1.67217001e-01f, -9.37601849e-02f, 4.99849506e-02f, -7.10752606e-03f, 5.88166453e-02f, 8.45014602e-02f, 1.22578390e-01f, -8.01316127e-02f,
  -1.94396526e-02f, -2.90783104e-02f, 2.21216008e-01f, 2.21302640e-02f, 5.24990894e-02f, -1.13835178e-01f, -5.75345103e-03f, -8.69521126e-02f, -4.52173762e-02f, 1.28972614e-02f,
  1.04685731e-01f, -1.45005528e-02f, -1.94025576e-01f, 7.37520456e-02f, 2.16558930e-02f, 8.23662058e-02f, -1.59307532e-02f, 2.53921486e-02f, -1.31042838e-01f, 4.75765988e-02f,
  -1.66866973e-01f, 4.54423517e-01f, -3.99901003e-01f, 5.28097264e-02f, -1.94535807e-01f, -1.18373968e-01f, -1.21695556e-01f, 1.06418476e-01f, 2.01309696e-01f, -6.89895824e-02f,
  -1.49638712e-01f, 4.51413654e-02f, -1.36724383e-01f, 2.72082780e-02f, 1.23724878e-01f, 5.86387888e-02f, -1.92740336e-01f, -1.49638906e-01f, 8.74904245e-02f, -1.23931892e-01f,
  -3.89009237e-01f, -2.40463130e-02f, 5.79250343e-02f, -2.53597796e-02f, -3.13070834e-01f, 2.10437581e-01f, -2.34266669e-01f, -2.05180645e-01f, 1.57807142e-01f, -8.15272212e-01f,
  -1.55730680e-01f, 1.78294145e-02f, -4.96877432e-01f, 1.64944634e-01f, -3.76578599e-01f, -3.97130787e-01f, -3.09523702e-01f, -1.34044200e-01f, -1.29212454e-01f, -2.84468293e-01f,
  -3.36112112e-01f, -8.51145312e-02f, -4.15265560e-03f, -5.96120674e-03f, 1.94989234e-01f, 1.20331403e-02f, 2.26628363e-01f, 1.93655521e-01f, 3.20841342e-01f, 3.91963333e-01f,
  4.11889613e-01f, 5.53455770e-01f, 4.53861505e-01f, 3.92654240e-01f, 2.68829107e-01f, 8.95189121e-02f, -9.64047238e-02f, 9.65277478e-02f, 3.34181152e-02f, 2.31608659e-01f,
  -6.99595451e-01f, -2.93110102e-01f, -1.07014105e-01f, 2.24489480e-01f, 9.31822732e-02f, 4.09624994e-01f, 3.47489148e-01f, 4.09530669e-01f, 1.54851899e-01f, 2.36353770e-01f,
  -1.48701817e-02f, 2.29493603e-01f, 1.05998881e-01f, 2.74937898e-01f, 1.81099743e-01f, -8.72869194e-02f, 2.37948805e-01f, 1.31339610e-01f, -3.61240916e-02f, -8.02804679e-02f,
  3.44738692e-01f, -1.05372794e-01f, -5.16308129e-01f, -2.46549383e-01f, -2.52190232e-01f, -2.30061889e-01f, -2.35958487e-01f, -1.28483638e-01f, -1.86524227e-01f, 7.23205134e-02f,
  -1.17827803e-01f, 7.70232361e-03f, -1.23851905e-02f, -4.61575873e-02f, 9.49148238e-02f, 2.64563877e-02f, 4.76362891e-02f, -1.10360920e-01f, -5.18656522e-02f, 2.48237029e-02f,
  -2.15934291e-01f, -1.31730288e-01f, 5.92739284e-02f, 1.58780858e-01f, 1.13625698e-01f, 2.60750633e-02f, 2.49956232e-02f, 1.02613874e-01f, -3.41245569e-02f, 7.88809359e-02f,
  -1.01861835e-01f, -1.00332342e-01f, 1.21790268e-01f, 1.60686195e-01f, -7.98909292e-02f, -1.07861701e-02f, 1.04092479e-01f, 9.30965841e-02f, 1.72591582e-01f, 5.34469895e-02f,
  -4.20501009e-02f, 6.92373961e-02f, -2.09152684e-01f, 1.64638415e-01f, -2.62042098e-02f, 3.58743072e-02f, -4.48803976e-02f, 2.01528333e-03f, -9.01811570e-02f, 2.15780914e-01f,
  -1.60563424e-01f, 7.94733465e-02f, 1.36670927e-02f, 3.12432557e-01f, -4.99556325e-02f, -1.90243885e-01f, -3.42992134e-02f, -2.85854727e-01f, -6.19383492e-02f, -3.63850296e-02f,
  1.57232173e-02f, -2.27312967e-01f, -5.99344432e-01f, -4.93611306e-01f, -1.30095601e-01f, -2.86784053e-01f, -2.12823525e-01f, -2.77957439e-01f, -4.48729932e-01f, -6.05982915e-02f,
  -5.79690397e-01f, 6.29680634e-01f, -6.89940751e-01f, -5.10604143e-01f, -4.16357964e-01f, 9.75200813e-03f, 6.28697157e-01f, 2.30174273e-01f, -2.08265781e-01f, 2.12844998e-01f,
  1.82985827e-01f, 1.03659779e-01f, 1.40641421e-01f, 3.11911553e-01f, 4.46405619e-01f, 5.56928217e-01f, -2.34140065e-02f, -2.49524981e-01f, -2.42798179e-01f, 1.10787533e-01f,
  3.88543189e-01f, -2.53599696e-02f, -1.91528231e-01f, -1.07942790e-01f, -1.91545516e-01f, -9.95543823e-02f, -7.54586086e-02f, -2.98493713e-01f, 1.69981539e-01f, -5.05495928e-02f,
  -4.85142544e-02f, -5.11529744e-01f, -5.50688580e-02f, -1.96693227e-01f, -2.46005654e-01f, -3.88395004e-02f, 8.35177302e-03f, -2.63595283e-01f, -1.00111589e-01f, -5.46900034e-02f,
  -3.22514445e-01f, -1.85889795e-01f, -1.35828376e-01f, -1.98867172e-03f, -1.41958281e-01f, -8.53281915e-02f, -5.21399081e-02f, 1.85105123e-03f, -5.83334034e-03f, 3.15902159e-02f,
  2.37842202e-01f, -2.70974874e-01f, -3.49795431e-01f, -5.63402027e-02f, -1.09737828e-01f, -1.87883437e-01f, -1.61254272e-01f, -2.72357076e-01f, -1.41548142e-01f, 1.02801591e-01f,
  -7.23282853e-03f, -5.42976428e-03f, -1.96626261e-02f, 2.50902236e-03f, 8.07390139e-02f, 6.05097637e-02f, -4.68662083e-02f, -1.67809092e-02f, 9.50666741e-02f, -4.94940281e-02f,
  -5.74426576e-02f, -5.74089214e-03f, 1.60821863e-02f, 1.54961109e-01f, 8.62929747e-02f, -1.37741446e-01f, -5.19744381e-02f, 1.97574407e-01f, 4.22973782e-02f, 2.04522144e-02f,
  -7.98785314e-02f, -8.96967128e-02f, -1.10089898e-01f, 2.08789092e-02f, 5.67287840e-02f, -1.65467948e-01f, -1.44114550e-02f, 1.58900574e-01f, 9.03058127e-02f, 3.81695740e-02f,
  5.36494017e-01f, 6.06247857e-02f, 1.24240004e-01f, -7.33624101e-02f, -1.17918029e-01f, -7.71927387e-02f, -5.59060872e-02f, -8.11793730e-02f, -3.47229727e-02f, 1.05465762e-01f,
  -1.50431961e-01f, -3.05263512e-02f, 8.30604360e-02f, 8.75113755e-02f, -2.48461347e-02f, -1.49556743e-02f, 1.70565337e-01f, 1.18249021e-01f, 1.58491135e-01f, -1.12416081e-01f,
  2.43274197e-01f, 2.28175923e-01f, 2.47832045e-01f, 2.73821801e-01f, 1.79813445e-01f, 1.38911024e-01f, 1.71412304e-01f, 1.28911734e-01f, 1.90604910e-01f, 5.34686565e-01f,
  -7.22579360e-01f, -7.51531422e-01f, 2.38173127e-01f, -4.44616407e-01f, 3.80480587e-01f, 6.29838109e-01f, 5.21289408e-01f, 3.03586781e-01f, -2.63397932e-01f, -8.53543356e-02f,
  -3.95964921e-01f, -5.07467985e-01f, -5.94708622e-01f, -1.86381668e-01f, -1.72405183e-01f, 5.91228083e-02f, -2.48574037e-02f, 1.56286255e-01f, 5.32382607e-01f, 5.72010338e-01f,
  1.94314227e-01f, 1.44914672e-01f, -1.66595250e-01f, -2.11576566e-01f, -2.65004128e-01f, -1.83104843e-01f, -2.87325889e-01f, -1.27020821e-01f, -9.98771563e-02f, -5.37076652e-01f,
  1.88995957e-01f, -2.69647837e-01f, 6.61695972e-02f, -2.89094895e-01f, -2.78751329e-02f, -2.75875181e-01f, -6.29021525e-02f, -1.03333272e-01f, -2.39250183e-01f, -9.43963379e-02f,
  -1.00658141e-01f, -7.18611851e-02f, -1.08143181e-01f, -2.45022285e-03f, 3.92653793e-02f, 2.58976053e-02f, -2.00693473e-01f, -1.76114887e-01f, -1.20240718e-01f, -5.76097816e-02f,
  -1.72410443e-01f, 6.18074462e-03f, 5.31425029e-02f, 4.16516978e-03f, -2.11422145e-02f, 1.19384974e-02f, -3.72001305e-02f, 6.27866983e-02f, -4.80731390e-02f, -6.39183894e-02f,
  1.31720513e-01f, 1.37024038e-02f, 9.24996957e-02f, 1.04855061e-01f, -4.86089438e-02f, 3.02282758e-02f, 4.40844856e-02f, -7.07712397e-02f, -2.23142114e-02f, 7.80833960e-02f,
  -5.13027087e-02f, 2.06508450e-02f, 1.08255096e-01f, -1.74305245e-01f, -9.57756788e-02f, -1.19148746e-01f, 1.85821261e-02f, -1.45732760e-01f, -1.37530640e-02f, -1.39804795e-01f,
  -6.26107901e-02f, -4.66720294e-03f, -1.71235166e-04f, 5.64814406e-03f, -4.45455462e-02f, -8.98146406e-02f, 3.67641822e-02f, -9.85670015e-02f, 1.29598426e-02f, -1.63599234e-02f,
  -7.81403556e-02f, -9.22087803e-02f, -1.43101767e-01f, -1.03142567e-01f, -8.29870328e-02f, -2.11135909e-01f, -1.95988894e-01f, -6.72139674e-02f, -2.01815769e-01f, 4.57582772e-02f,
  -1.00705987e-02f, 5.92714623e-02f, -1.09849438e-01f, 5.17047755e-02f, 2.85061240e-01f, 6.27778396e-02f, -1.52791932e-01f, -4.84803356e-02f, -5.75344600e-02f, 1.44475847e-01f,
  -1.40701327e-03f, 1.16861597e-01f, 2.18130320e-01f, 2.11326536e-02f, 1.33132488e-01f, 1.51746705e-01f, 2.46690735e-01f, 1.43318236e-01f, 9.22794938e-02f, 3.89198333e-01f,
  -2.43618429e-01f, 4.01531637e-01f, -9.68427658e-01f, -1.76155746e-01f, -4.98839378e-01f, -5.79462826e-01f, 1.42901927e-01f, 3.29392672e-01f, 1.15174815e-01f, 3.66181850e-01f,
  1.73314095e-01f, -4.12475139e-01f, -4.65871513e-01f, -3.24866027e-01f, -1.04077064e-01f, -1.41503932e-02f, -4.56574380e-01f, -8.24098349e-01f, -7.34316766e-01f, 2.80206371e-02f,
  1.36467978e-01f, 5.52978441e-02f, -1.85545862e-01f, -1.07601166e-01f, 3.23452230e-04f, -2.49086425e-01f, -2.60228962e-01f, -3.60480368e-01f, -2.26191744e-01f, -4.35729623e-01f,
  -3.39820534e-01f, -1.32714152e-01f, -2.11144075e-01f, 1.13032334e-01f, 9.92504209e-02f, -6.32042065e-02f, -9.60922763e-02f, -2.34631766e-02f, 6.43097162e-02f, -4.24807519e-03f,
  -2.09086835e-01f, 1.55443745e-02f, -2.42165625e-01f, -2.17894882e-01f, -4.38238271e-02f, 6.48376718e-02f, -1.41017660e-01f, -2.38770708e-01f, -1.16631731e-01f, 3.00655290e-02f,
  -1.72611251e-01f, -5.62563002e-01f, -4.99225438e-01f, -7.31056109e-02f, -1.21871576e-01f, -5.40261030e-01f, 6.87635019e-02f, -1.33405119e-01f, -3.20321679e-01f, 4.83200192e-01f,
  1.29682317e-01f, 8.33356455e-02f, -4.85362113e-02f, 1.06958382e-01f, 2.23885238e-01f, -1.82983428e-02f, -8.30152910e-03f, 1.11269109e-01f, -2.34262235e-02f, 1.23532586e-01f,
  5.32066636e-02f, 1.26611754e-01f, -4.78540435e-02f, -2.43390705e-02f, -5.91095462e-02f, 7.74167594e-04f, 5.63968644e-02f, 9.36351642e-02f, -1.40423805e-01f, 5.09217456e-02f,
  -1.17776737e-01f, 1.73050240e-02f, -1.14111807e-02f, 5.94703928e-02f, 2.63266787e-02f, 7.40336627e-02f, -9.11407359e-03f, 1.83070734e-01f, -3.54503561e-03f, -1.01075754e-01f,
  3.30665380e-01f, -2.11841792e-01f, 2.14052722e-01f, 1.47283301e-01f, -8.02912936e-02f, -3.27988006e-02f, 7.77897239e-02f, 1.50147751e-01f, -8.10402408e-02f, 1.08730663e-02f,
  -3.41823585e-02f, 5.75787537e-02f, -1.18342362e-01f, 6.32934496e-02f, 1.32270148e-02f, -5.89576736e-02f, 1.65037096e-01f, -2.37856999e-01f, -1.51866311e-02f, 9.52632725e-02f,
  1.24812171e-01f, 4.16604578e-02f, 3.65918279e-02f, 1.56168789e-01f, 1.34210393e-01f, -1.32229999e-01f, 2.50737995e-01f, 1.74783349e-01f, -1.02020137e-01f, 8.51209521e-01f,
  1.07705569e+00f, -6.00370646e-01f, -1.58974648e-01f, 1.91356629e-01f, -7.83813559e-03f, 2.71193478e-02f, -1.63091823e-01f, -1.47098629e-02f, 1.38560668e-01f, -5.63371815e-02f,
  -1.33644357e-01f, 1.12815395e-01f, 1.33880481e-01f, 1.76337898e-01f, 2.17492208e-01f, -3.18687111e-02f, -3.50078121e-02f, 2.40735859e-01f, 3.42422515e-01f, -5.90949543e-02f,
  -2.00704746e-02f, 5.51143996e-02f, 1.58523127e-01f, 1.35773659e-01f, -1.83845580e-01f, 1.21512255e-02f, -1.60196945e-01f, -2.85891682e-01f, -2.23965466e-01f, -2.41571292e-01f,
  -4.88372415e-01f, -6.53845146e-02f, 1.25510886e-01f, -2.22117594e-03f, -1.41067281e-01f, -3.56289074e-02f, 1.29023656e-01f, -6.21288083e-02f, -1.75339982e-01f, -2.04536706e-01f,
  1.86516214e-02f, -1.86786875e-02f, -7.15927556e-02f, -1.42801523e-01f, -1.19629361e-01f, -2.86893416e-02f, -8.70878622e-02f, -4.59432527e-02f, -1.08810596e-01f, -1.28996298e-01f,
  -7.56135806e-02f, -1.10548437e-01f, -1.64729744e-01f, -3.52522582e-02f, 1.47277862e-01f, 8.98957774e-02f, -2.76377052e-02f, 7.58062489e-03f, -8.25834647e-03f, 7.12488443e-02f,
  -1.68594509e-01f, 6.85406430e-03f, 1.52060669e-03f, -8.96484405e-02f, 6.72480538e-02f, -9.93226096e-02f, -1.66164071e-03f, -8.29341263e-02f, 1.15235180e-01f, -5.88768162e-02f,
  -2.05043629e-01f, 1.46597456e-02f, 3.02131791e-02f, -3.77008133e-02f, 1.11818247e-01f, -4.13558148e-02f, -4.80299033e-02f, -1.14801347e-01f, -7.29844347e-02f, -8.42393562e-03f,
  1.32882940e-02f, -1.12878434e-01f, -8.44991803e-02f, -2.51897752e-01f, -1.84157938e-01f, -1.35880068e-01f, -2.74173189e-02f, -3.88220735e-02f, -2.24571815e-03f, -7.37994239e-02f,
  -4.35782611e-01f, 1.61188439e-01f, 2.52759665e-01f, 9.49531719e-02f, 5.70656396e-02f, -7.64052272e-02f, 6.52234182e-02f, -5.17617241e-02f, -1.84266552e-01f, -1.03644729e-01f,
  -5.55892102e-02f, 9.71416831e-02f, -6.25033900e-02f, -8.24547559e-02f, 7.71225318e-02f, 3.06968968e-02f, 1.86598506e-02f, 8.46627131e-02f, -1.18049644e-02f, -2.59585887e-01f,
  -1.43537357e-01f, 1.96918190e-01f, 1.03253610e-01f, 2.22956195e-01f, 1.93945378e-01f, 2.60382801e-01f, -2.21498255e-02f, 3.52521688e-02f, 1.07163712e-01f, 1.04835935e-01f,
  7.69939065e-01f, -1.76650763e-01f, -1.06190395e+00f, 4.77547616e-01f, -2.32324034e-01f, -5.53500950e-01f, -7.22255290e-01f, -2.68768473e-03f, 4.97917920e-01f, -5.35938382e-01f,
  -5.06508648e-01f, 2.36775558e-02f, -9.68284458e-02f, -2.73715258e-01f, -6.91375256e-01f, -8.91319454e-01f, -7.34974265e-01f, -5.62351823e-01f, -2.34593809e-01f, -2.74872147e-02f,
  1.66896656e-01f, 3.56585801e-01f, 9.83576626e-02f, 6.12569824e-02f, 3.28652412e-01f, 1.34644806e-01f, -3.23569298e-01f, -8.82118791e-02f, -5.03988802e-01f, -3.11132342e-01f,
  -3.86685818e-01f, -8.64679664e-02f, -2.80498981e-01f, 9.58783552e-02f, 6.26059547e-02f, 2.63476409e-02f, -1.58806905e-01f, -2.95223724e-02f, 1.06061995e-01f, -7.32610300e-02f,
  1.12268925e-01f, 1.70957092e-02f, 1.55492991e-01f, -1.89297229e-01f, 5.71677834e-02f, 6.30171821e-02f, 2.91204941e-03f, -2.72106260e-01f, -3.76579240e-02f, -1.04434125e-01f,
  -1.16994917e-01f, -2.26462081e-01f, -1.52569592e-01f, -2.03231350e-01f, -1.91612154e-01f, -6.77937642e-02f, -1.19605415e-01f, -1.07034938e-02f, -3.64681721e-01f, 2.08027944e-01f,
  -1.84300810e-01f, 1.05794864e-02f, -6.70588762e-02f, 7.47630075e-02f, 6.66629225e-02f, -3.28224301e-02f, -2.25817487e-02f, 3.63186449e-02f, -3.33386250e-02f, 9.77874547e-02f,
  -9.08861384e-02f, -1.46523342e-01f, 4.05963324e-02f, -4.56921309e-02f, 3.83090191e-02f, -1.46757364e-02f, -1.15343593e-01f, -8.17694962e-02f, -4.89154309e-02f, -6.85172528e-02f,
  -5.04719559e-03f, 1.26426518e-02f, 2.43515223e-01f, 1.82227075e-01f, -3.61407548e-01f, -1.61758304e-01f, -2.76826229e-02f, -2.67621526e-03f, 6.82250634e-02f, -1.13695696e-01f,
  6.92629874e-01f, -4.74386364e-01f, 1.37978673e-01f, 8.64670724e-02f, 4.45667980e-03f, -9.72272903e-02f, -1.24684408e-01f, -1.06385253e-01f, 7.84702748e-02f, -5.19121997e-02f,
  -2.13934034e-01f, -3.49725783e-02f, -3.19721252e-02f, 3.32624326e-03f, -5.69852553e-02f, -1.29111707e-01f, -3.84793729e-02f, -1.59222022e-01f, -8.76675993e-02f, 1.09303959e-01f,
  1.01870812e-01f, 1.51789203e-01f, 2.09632963e-01f, 9.40207988e-02f, 1.22855052e-01f, 1.08555265e-01f, 1.20655157e-01f, 1.41694145e-02f, -1.04103737e-01f, 4.13237780e-01f,
  9.65907931e-01f, 1.13088422e-01f, 5.27364373e-01f, 2.73926377e-01f, 2.72198468e-01f, 4.15795267e-01f, 4.52000409e-01f, 2.05059528e-01f, -5.44952080e-02f, 9.10629109e-02f,
  -1.55595213e-01f, -3.38186443e-01f, -2.15946510e-01f, -1.97859436e-01f, 2.86034718e-02f, 1.34293839e-01f, 1.15162499e-01f, 3.56564254e-01f, 4.05153602e-01f, 1.47533074e-01f,
  -2.48886570e-01f, 6.15567574e-03f, 2.55200773e-01f, 9.94192436e-02f, -2.10096594e-02f, -2.20884636e-01f, -1.58341881e-02f, 1.03642397e-01f, 2.44116560e-02f, -1.13768708e-02f,
  4.09781486e-01f, 3.47627342e-01f, -2.33661503e-01f, -4.11049813e-01f, -2.54914463e-02f, -5.17749637e-02f, 3.11838128e-02f, 7.26852790e-02f, -7.09918588e-02f, -1.64458171e-01f,
  -1.16497114e-01f, 8.69234931e-03f, 5.38527183e-02f, 1.98698044e-02f, 1.46163523e-01f, 7.92827755e-02f, 8.56003463e-02f, 1.72057718e-01f, 6.12938069e-02f, -3.48697416e-02f,
  -1.16763763e-01f, 1.05129503e-01f, 3.17343295e-01f, -7.16722980e-02f, 1.46394446e-01f, 6.85219700e-03f, -5.57202622e-02f, 5.23393527e-02f, 7.21582174e-02f, 2.66573336e-02f,
  4.66409810e-02f, -1.74873613e-03f, 5.17907813e-02f, 1.45581320e-01f, 1.87324598e-01f, 7.32778236e-02f, 8.48481134e-02f, 9.74647477e-02f, -8.14134441e-03f, 3.38886529e-01f,
  1.96595997e-01f, 1.12544201e-01f, 1.09458193e-01f, 5.28428294e-02f, -2.23716795e-02f, 1.09713145e-01f, 2.68528759e-01f, -1.15040183e-01f, -9.10892803e-03f, 6.08428032e-04f,
  1.51643366e-01f, 1.60572842e-01f, 1.55322000e-01f, 2.39892974e-01f, 8.94850194e-02f, 7.91037008e-02f, -1.27149485e-02f, 2.48852163e-03f, 1.14177860e-01f, 1.07699245e-01f,
  -5.00890136e-01f, -7.55395815e-02f, -8.51240084e-02f, -9.90013257e-02f, 5.66597879e-02f, -8.20478201e-02f, -1.67154402e-01f, -7.55296871e-02f, -1.40565082e-01f, -1.55211762e-01f,
  -5.53698428e-02f, 7.94939846e-02f, 7.27807507e-02f, 1.69567034e-01f, 1.60730302e-01f, -1.31228223e-01f, -5.35621308e-02f, 5.35866283e-02f, -1.32312819e-01f, -6.36801422e-02f,
  -9.19486061e-02f, 7.34830333e-04f, 1.60673410e-01f, -8.16941857e-02f, -1.13765121e-01f, -7.17353076e-02f, -6.00177795e-02f, -1.17678838e-02f, 1.86469909e-02f, -2.64878869e-02f,
  8.86152565e-01f, -5.57658672e-01f, -7.67228246e-01f, 1.63773485e-02f, -1.62654459e-01f, 8.73784721e-02f, 4.63179462e-02f, 1.98331609e-01f, 2.12155636e-02f, -1.27627194e-01f,
  -7.12001845e-02f, 4.54446793e-01f, 1.10028923e-01f, 1.91486150e-01f, 4.07614887e-01f, -2.82520115e-01f, -3.69381905e-01f, 1.81243330e-01f, 4.99339849e-01f, 4.73810911e-01f,
  7.65165985e-02f, 5.78818694e-02f, 1.91029415e-01f, -4.36535887e-02f, -4.78530884e-01f, -6.69110566e-03f, -4.67731684e-01f, -4.20989335e-01f, -4.19771105e-01f, -6.47132397e-01f,
  9.84541848e-02f, -3.32839698e-01f, 1.11115503e-03f, 5.26721915e-03f, -1.25528410e-01f, 2.20074952e-02f, 7.20706135e-02f, -1.56911194e-01f, -1.77103020e-02f, -1.81259830e-02f,
  -6.69628158e-02f, -4.44380678e-02f, 4.13558558e-02f, -1.16391420e-01f, 3.35575044e-02f, -8.83554146e-02f, -1.76523864e-01f, -1.02065377e-01f, -4.22542058e-02f, -1.07696064e-01f,
  -2.58612663e-01f, -7.56540149e-02f, -7.91754648e-02f, -1.55788809e-02f, -1.67275056e-01f, -4.05328721e-02f, -8.51533338e-02f, -1.68644622e-01f, -1.91595759e-02f, -1.21260330e-03f,
  -1.40081927e-01f, -2.38694623e-02f, -9.29271895e-03f, -5.05820885e-02f, 1.80267870e-01f, 8.04124996e-02f, 1.18193641e-01f, 5.82384057e-02f, 9.21395794e-02f, -1.35667160e-01f,
  -6.01027496e-02f, -3.29090195e-04f, -1.41699018e-03f, 7.79787730e-03f, -5.26114851e-02f, 5.69898523e-02f, 3.63099761e-02f, 9.35864262e-03f, -1.34507746e-01f, 2.25864634e-01f,
  1.38612520e-02f, -6.10070154e-02f, -5.03840894e-02f, -7.20877647e-02f, -1.17959447e-01f, -6.89441562e-02f, -1.56754091e-01f, 5.09192683e-02f, 7.18566030e-02f, -4.06310037e-02f,
  4.71432358e-01f, -7.30452612e-02f, 1.02287069e-01f, 1.61353610e-02f, -1.70620769e-01f, -1.18630573e-01f, -1.04683258e-01f, -9.49998945e-02f, 7.83075616e-02f, 6.03596866e-02f,
  -1.97725128e-02f, 1.13082513e-01f, -1.43475741e-01f, -4.34952565e-02f, 1.20178632e-01f, 1.16783962e-01f, -6.76268991e-03f, 9.14187208e-02f, -2.75119469e-02f, -9.75493621e-03f,
  -1.67500407e-01f, 2.83968061e-01f, 4.37482506e-01f, 2.15117037e-01f, 1.22182549e-03f, 3.15081537e-01f, 4.33363058e-02f, 1.29377171e-01f, 1.52954206e-01f, 3.36807281e-01f,
  5.37394226e-01f, -6.91023422e-03f, -1.19692162e-01f, 3.03520530e-01f, 3.57244045e-01f, 1.37677610e-01f, -8.07786286e-02f, -6.44985512e-02f, 1.79422587e-01f, 1.87051132e-01f,
  4.39241707e-01f, 4.26503837e-01f, 2.44060338e-01f, 9.20571387e-02f, 4.30215821e-02f, -1.00235112e-01f, -1.12918027e-01f, -2.85237450e-02f, 5.79715818e-02f, 9.71445143e-02f,
  1.79413572e-01f, 5.20150512e-02f, 5.38760722e-02f, 8.24433193e-02f, 3.41728404e-02f, 1.04862794e-01f, 1.97616577e-01f, 9.41879824e-02f, -3.84476818e-02f, -2.78089941e-01f,
  -3.45047235e-01f, 1.72028206e-02f, 2.18349904e-01f, 1.66369751e-01f, 1.25757605e-01f, -7.12604523e-02f, 5.82995638e-02f, 4.47683372e-02f, 2.84009241e-02f, -1.86436623e-01f,
  -9.67171267e-02f, 5.59720062e-02f, 1.64472878e-01f, 2.54360959e-02f, 4.34712395e-02f, 6.33404776e-02f, -5.95214665e-02f, -1.65281445e-01f, -1.28235608e-01f, -5.37782945e-02f,
  1.18371397e-01f, 5.30859530e-02f, 9.49904136e-03f, -7.72442594e-02f, -9.10702869e-02f, 5.73112182e-02f, -6.15225621e-02f, -2.78181471e-02f, 5.39496057e-02f, -6.70205802e-02f,
  4.25120711e-01f, 3.85741323e-01f, 1.57296702e-01f, -2.42874902e-02f, -2.37555914e-02f, 8.45418423e-02f, -1.36646908e-02f, -6.65950924e-02f, -1.46647738e-02f, 1.38820648e-01f,
  -4.76085246e-02f, -6.04277737e-02f, -3.95709574e-02f, 1.21392965e-01f, 3.24557334e-01f, 1.11915782e-01f, -1.17445020e-02f, 1.43629676e-02f, 6.33030385e-02f, 8.52319822e-02f,
  4.05790359e-02f, -5.13779260e-02f, 7.25404471e-02f, -1.75663918e-01f, -2.52442807e-02f, 1.07379921e-01f, 8.83119404e-02f, 2.50111431e-01f, 2.78410763e-01f, 1.25599891e-01f,
  -1.59583122e-01f, 3.61279160e-01f, -1.08782187e-01f, -1.62503734e-01f, -1.12073593e-01f, 6.86371550e-02f, 9.86581817e-02f, -9.11808573e-03f, -1.25385180e-01f, -2.13911369e-01f,
  -6.58032894e-02f, -9.67884287e-02f, 8.27670097e-02f, -9.75786075e-02f, -5.08680046e-02f, -2.44829282e-02f, 1.54642418e-01f, -4.04489934e-02f, -1.37615293e-01f, -1.71409383e-01f,
  -6.11012653e-02f, 7.64963478e-02f, 1.04060248e-01f, -3.67139466e-02f, -4.79004346e-02f, 2.76934683e-01f, -9.75170806e-02f, -9.74134132e-02f, 7.64724836e-02f, 4.80003357e-02f,
  6.41525686e-02f, 1.59450069e-01f, 4.37622130e-01f, 1.11903474e-01f, -9.01040137e-02f, -6.02098644e-01f, -1.09183490e+00f, -5.84921360e-01f, 9.13122073e-02f, -2.62965877e-02f,
  7.15904012e-02f, -1.36222929e-01f, 1.16910383e-01f, -2.60540247e-01f, -6.64563894e-01f, -2.03597397e-01f, 1.55022576e-01f, -7.62272105e-02f, -5.38228571e-01f, -7.11457491e-01f,
  -2.63429850e-01f, 6.89352825e-02f, 2.67964423e-01f, 2.90657990e-02f, 5.96698403e-01f, 3.97954792e-01f, 7.31962979e-01f, 5.96064568e-01f, 2.86416501e-01f, 7.92269886e-01f,
  6.99497759e-01f, 4.46128458e-01f, -5.88992476e-01f, 5.04696220e-02f, 2.30485812e-01f, -1.03409603e-01f, -2.36550510e-01f, 2.99293697e-01f, -1.12210125e-01f, 1.14563778e-01f,
  1.95015505e-01f, 4.41295207e-02f, 6.66447580e-02f, -4.15741168e-02f, -1.13317057e-01f, -4.29043263e-01f, 9.31418389e-02f, -3.64673197e-01f, -3.01911458e-02f, 9.01776329e-02f,
  -3.82968217e-01f, -7.81580731e-02f, 5.11566997e-02f, -3.36319983e-01f, -5.07175885e-02f, -1.26599163e-01f, -2.58198269e-02f, -2.19742358e-02f, -1.56935051e-01f, 3.09132338e-01f,
  -2.36402601e-02f, 9.28487778e-02f, -5.14268130e-02f, 1.20523646e-01f, -2.83843845e-01f, 8.94710720e-02f, 1.37263283e-01f, -3.25051807e-02f, 2.17529908e-02f, -6.50893673e-02f,
  -1.04937397e-01f, 4.23013745e-03f, 1.19261689e-01f, -5.53417727e-02f, 1.96665209e-02f, 5.99822477e-02f, -6.52271509e-02f, -2.90745109e-01f, -3.13107856e-02f, 8.40343088e-02f,
  -1.44113362e-01f, -5.32897376e-02f, 1.93499893e-01f, -1.81168616e-01f, -2.04654620e-03f, -8.65750760e-02f, 4.86058928e-02f, -5.47048934e-02f, 2.83379033e-02f, 9.57029983e-02f,
  2.21885964e-01f, -5.72050452e-01f, 7.04141185e-02f, -8.96558166e-02f, 2.09209174e-01f, 4.60194200e-02f, 9.90772694e-02f, -1.61588877e-01f, 6.23164773e-02f, -9.81220081e-02f,
  -2.56994575e-01f, -2.00758845e-01f, 2.17424959e-01f, -8.93357620e-02f, -2.58652031e-01f, -1.20411992e-01f, -1.66515023e-01f, -2.71519721e-01f, -2.11714908e-01f, 1.55921847e-01f,
  -1.00457862e-01f, -6.15887463e-01f, -5.51917791e-01f, -5.81035376e-01f, -3.56521346e-02f, -6.17802262e-01f, -1.02648459e-01f, -1.67002738e-01f, -5.01624286e-01f, -4.89769131e-01f,
  6.80427253e-01f, 1.41878843e-01f, -6.16284609e-01f, 2.18697816e-01f, 1.22674271e-01f, 1.22108825e-01f, 4.18831974e-01f, 4.36557293e-01f, 2.57143646e-01f, 9.90068465e-02f,
  -4.58486639e-02f, -2.40072981e-01f, -3.18185449e-01f, -3.50845516e-01f, -9.17015299e-02f, -3.11872900e-01f, -3.91078621e-01f, -3.53663862e-01f, -2.53605902e-01f, 9.72735509e-02f,
  6.23010509e-02f, 2.05212116e-01f, 3.29070389e-02f, -1.61447451e-01f, -1.34834498e-01f, -1.84785649e-01f, -2.72459120e-01f, -3.09121963e-02f, -2.18728811e-01f, -5.27492106e-01f,
  -6.89446986e-01f, 6.95623234e-02f, -1.14785329e-01f, -4.47048992e-02f, -6.37503192e-02f, 1.12686947e-01f, -1.22036017e-01f, 1.69896632e-01f, 2.76371181e-01f, 1.26786143e-01f,
  -1.25365019e-01f, -8.97099227e-02f, -6.36153966e-02f, 5.60315251e-02f, 1.52198359e-01f, 1.01894483e-01f, 1.38385057e-01f, 6.84752315e-02f, 2.03959621e-03f, -9.52435806e-02f,
  -9.44792703e-02f, 1.65645838e-01f, 2.33583733e-01f, 2.11471304e-01f, -9.46881529e-03f, -9.95261688e-03f, 1.13788456e-01f, -7.23988786e-02f, 8.31990391e-02f, 1.35730848e-01f,
  -3.29031944e-02f, 4.57464382e-02f, -1.05526634e-01f, -1.36908460e-02f, 1.80640265e-01f, 1.42040998e-01f, 1.26954213e-01f, 1.93851162e-02f, -1.28484113e-04f, 9.21156108e-02f,
  1.89742804e-01f, -1.95879236e-01f, 1.57267731e-02f, 1.11384578e-02f, -2.94826776e-01f, -7.30312988e-02f, -3.41245718e-02f, 3.28873992e-02f, -1.15391470e-01f, 1.36241494e-02f,
  -1.23426519e-01f, 1.09657198e-01f, 4.41878773e-02f, 9.01152613e-04f, -6.54437318e-02f, 6.82572946e-02f, -9.04357284e-02f, -6.70190230e-02f, -4.54366906e-03f, -1.71313081e-02f,
  -8.89838785e-02f, -3.79931122e-01f, -2.51634717e-01f, -3.25335115e-02f, 3.36483419e-02f, 8.40000995e-03f, -2.80654013e-01f, -1.02238998e-01f, 1.26798926e-02f, -8.29919204e-02f,
  -4.94417064e-02f, -1.25924349e-01f, -1.52646508e-02f, 9.11826864e-02f, 1.35255650e-01f, -3.21710259e-02f, 2.05010802e-01f, 4.30881865e-02f, -1.11363001e-01f, -1.56765748e-02f,
  1.80367053e-01f, 1.42192841e-01f, 1.86746508e-01f, 1.78028047e-01f, 1.07978068e-01f, -7.59309009e-02f, 4.93869521e-02f, 7.95108080e-02f, -3.54897045e-03f, 3.63071948e-01f,
  5.73743045e-01f, 4.35126662e-01f, 2.78869241e-01f, 3.83424819e-01f, 9.29897428e-02f, 1.02304548e-01f, 2.54449308e-01f, 4.08672750e-01f, 3.07646573e-01f, 2.03911513e-01f,
  2.28805393e-01f, 4.01798993e-01f, 2.94594407e-01f, 3.58488560e-01f, 3.79056126e-01f, 3.34792107e-01f, 3.73827159e-01f, 1.89777642e-01f, 2.24737823e-01f, 9.57168490e-02f,
  1.60683170e-01f, 1.46564290e-01f, 2.32148513e-01f, 1.64944410e-01f, 1.52569234e-01f, 1.29284456e-01f, 8.74395818e-02f, -4.80092093e-02f, 2.98922397e-02f, 2.00351551e-01f,
  -3.85009021e-01f, -6.02619275e-02f, 1.11743122e-01f, 7.38734230e-02f, -3.41363885e-02f, 7.22402558e-02f, -1.96298771e-02f, -8.89976695e-02f, 7.47973612e-03f, -9.66092721e-02f,
  3.38071659e-02f, -1.85309630e-02f, -9.20923576e-02f, -1.11525550e-01f, -1.38680175e-01f, -1.00486137e-01f, -9.47361290e-02f, 6.93973005e-02f, 2.31592134e-02f, -4.98069897e-02f,
  2.68782116e-02f, -2.48174503e-01f, -2.01843306e-01f, 7.83243857e-04f, 9.09602083e-03f, 6.90134242e-02f, -1.37671545e-01f, -1.21455893e-01f, -6.62611192e-03f, -1.59967858e-02f,
  2.98039377e-01f, 2.21101329e-01f, -1.05969600e-01f, -5.12047671e-02f, -1.17694996e-01f, -1.93000302e-01f, -2.20575228e-01f, 3.58143821e-02f, 1.25092104e-01f, -9.36202239e-03f,
  -1.55540392e-01f, -5.93661144e-02f, -7.28485510e-02f, -1.26085982e-01f, 9.05737106e-04f, 5.34126125e-02f, -9.83127877e-02f, -1.51989594e-01f, -1.88192174e-01f, -6.86146319e-02f,
  -1.14319742e-01f, -4.85026017e-02f, -1.76749200e-01f, -5.72792664e-02f, -9.95293111e-02f, -1.22143954e-01f, -3.30964588e-02f, -7.19144046e-02f, -2.75245332e-03f, 9.15125310e-02f,
  -6.26318604e-02f, -7.92487264e-02f, 7.13098422e-02f, 2.70357579e-01f, -7.03074411e-02f, 5.23816282e-03f, 1.24637730e-01f, -9.78819653e-02f, -1.34640574e-01f, -1.24200404e-01f,
  -3.39980908e-02f, -1.73881687e-02f, -5.32962556e-04f, -4.48023453e-02f, -2.44251236e-01f, -1.66917771e-01f, 2.30068006e-02f, 5.33057898e-02f, -1.71532352e-02f, -3.03809601e-03f,
  -5.41807599e-02f, -1.57702062e-02f, -1.13454014e-01f, -3.82289942e-03f, 5.18224947e-02f, -8.85369629e-02f, -2.22254157e-01f, -1.47403643e-01f, -5.32101579e-02f, -1.48656145e-01f,
  -2.27321222e-01f, 7.68068671e-01f, 4.35323060e-01f, -5.39742112e-01f, 3.30000460e-01f, 5.89723468e-01f, 9.41925883e-01f, 1.51349232e-01f, -3.91493469e-01f, 3.56852084e-01f,
  4.60446447e-01f, -4.52407330e-01f, -3.30267102e-01f, -2.61608154e-01f, 1.39746532e-01f, 4.72882390e-01f, 1.45873368e-01f, -3.53663146e-01f, -5.01668036e-01f, -1.63134977e-01f,
  -2.63938248e-01f, -2.61146188e-01f, -3.22113961e-01f, -3.86973321e-01f, -2.68214256e-01f, -5.12743473e-01f, 2.00307742e-01f, 2.68608421e-01f, 4.31682348e-01f, -4.00944263e-01f,
  1.31904870e-01f, 6.51750803e-01f, -5.69021106e-01f, -2.05398202e-01f, 2.18125597e-01f, -2.19427675e-01f, -4.53185365e-02f, -1.53874397e-01f, 3.23139429e-02f, -3.63346338e-02f,
  1.26165986e-01f, 1.11394316e-01f, 7.57489800e-02f, 2.47415826e-02f, 1.79222584e-01f, 4.63611186e-02f, 3.24176289e-02f, -1.39164850e-01f, -6.03287295e-02f, 2.27110624e-01f,
  -8.32742751e-02f, 3.12353253e-01f, 3.87120664e-01f, 1.77124307e-01f, 1.63853258e-01f, -2.14850262e-01f, 3.41976523e-01f, -8.16094577e-02f, 1.84218705e-01f, -3.37163746e-01f,
  -3.58105004e-01f, 8.04631487e-02f, 1.66894555e-01f, -8.18985477e-02f, 2.05666982e-02f, -1.09518632e-01f, -9.60494131e-02f, 1.07771926e-01f, 1.26962602e-01f, -1.04649596e-01f,
  -4.88006175e-02f, -3.91639471e-02f, -3.11547401e-03f, -4.53723706e-02f, -2.18941972e-01f, 5.79724126e-02f, 7.95797780e-02f, -4.09454070e-02f, 1.17795974e-01f, 1.05144411e-01f,
  -1.11383118e-01f, 1.95902009e-02f, 5.60404127e-03f, -1.06102377e-02f, 4.02667671e-02f, -1.66759565e-02f, -2.25198880e-01f, 2.62738243e-02f, -2.10885331e-01f, -3.75823788e-02f,
  -4.56179738e-01f, 5.43113053e-01f, -2.98916787e-01f, -2.16943137e-02f, 2.88456887e-01f, 1.23398148e-01f, -3.78078669e-02f, 5.58446124e-02f, 1.37746081e-01f, -2.68185139e-02f,
  1.63701355e-01f, -3.11591960e-02f, 2.35920250e-01f, -6.63539767e-02f, -1.41248345e-01f, -5.81928380e-02f, 6.82601407e-02f, -2.10193306e-01f, -1.17065512e-01f, -2.60359980e-02f,
  -1.07179590e-01f, -1.94713354e-01f, -4.99141783e-01f, -3.98178577e-01f, -3.12135994e-01f, -7.21979678e-01f, -1.22668043e-01f, -2.07177624e-01f, 1.01130202e-01f, -3.08207840e-01f,
  -7.29228377e-01f, 5.10365143e-02f, -4.01936322e-01f, -1.65778473e-01f, 6.65057957e-01f, 3.94683510e-01f, 2.80756027e-01f, -2.11356103e-01f, -5.07142901e-01f, -2.63021678e-01f,
  2.80548632e-01f, 1.73666373e-01f, -1.95315301e-01f, 1.65420994e-01f, 9.23588127e-02f, 8.58390033e-02f, 8.65349844e-02f, -8.19138736e-02f, 8.59488919e-02f, 6.11439586e-01f,
  4.25509244e-01f, -7.45950080e-03f, -3.05566251e-01f, -6.27139583e-02f, 1.30738877e-02f, -1.20360129e-01f, -2.72217810e-01f, 1.65154666e-01f, 3.38093698e-01f, 1.87278405e-01f,
  -2.17167780e-01f, -5.02381444e-01f, 2.24944279e-01f, 2.62604415e-01f, 1.32490039e-01f, -4.09143686e-01f, -1.74175844e-01f, -2.91531682e-01f, -3.03258508e-01f, 1.38395897e-03f,
  3.61843556e-01f, -4.12097573e-02f, 9.93959382e-02f, 1.18542701e-01f, -1.39486492e-01f, -2.63167679e-01f, -1.28443152e-01f, -4.03841704e-01f, -2.40185305e-01f, -4.49897796e-02f,
  7.48503566e-01f, 5.14502823e-01f, 4.05894890e-02f, -5.71077736e-03f, -1.97281554e-01f, 6.65892661e-02f, -1.02959886e-01f, 2.60006711e-02f, -3.78467470e-01f, -4.04936373e-01f,
  -1.58017389e-02f, 1.32300586e-01f, 6.00419790e-02f, -6.21269867e-02f, 1.50910139e-01f, -8.99626762e-02f, 6.98414119e-03f, 2.59000123e-01f, 1.90408334e-01f, -1.24199718e-01f,
  1.61101054e-02f, -1.91082694e-02f, -3.14395726e-02f, -2.55254477e-01f, -1.47983298e-01f, 6.36591986e-02f, 2.92014390e-01f, -9.67642739e-02f, -3.41314524e-02f, -1.41137585e-01f,
  7.95550346e-02f, -2.47467980e-02f, -1.04962483e-01f, 3.68308239e-02f, -1.24240898e-01f, -2.10754156e-01f, -1.20117359e-01f, 1.06449723e-01f, -2.69142359e-01f, -7.25289285e-02f,
  -6.31882846e-01f, 2.85074711e-01f, -3.47162515e-01f, 1.14314489e-01f, -4.81597371e-02f, 6.26137946e-04f, -2.52088439e-02f, -3.65688019e-02f, -2.21545607e-01f, -2.13072956e-01f,
  1.74839363e-01f, -1.55522600e-01f, -1.91506192e-01f, -6.27859263e-03f, -5.69255501e-02f, -2.79611290e-01f, 1.09898873e-01f, -1.66985348e-01f, 1.24070279e-01f, 2.74323002e-02f,
  -7.89333060e-02f, 7.89875314e-02f, -2.08905190e-01f, -2.54780263e-01f, -4.97013070e-02f, -1.65637136e-01f, -2.60525972e-01f, -3.18911016e-01f, -4.56207633e-01f, -6.07128799e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  6.41905963e-01f, 2.28452191e-01f, 4.92216021e-01f, 5.85435808e-01f, 5.38004875e-01f, 8.58714879e-01f, 4.45805341e-01f, 5.15406191e-01f, -1.92372933e-01f, 9.58131909e-01f,
  4.73603636e-01f, 4.19190615e-01f, 5.58393359e-01f, 8.81814718e-01f, 1.04377162e+00f, 7.62964129e-01f, 8.40934455e-01f, 2.31305137e-01f, 5.80560923e-01f, 7.62913585e-01f,
  5.04424632e-01f, 5.74240148e-01f, 5.75430512e-01f, 1.27829269e-01f, 5.33050120e-01f, 5.45715034e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -2.85063952e-01f, -1.83347613e-01f, 1.73853263e-02f, -1.90004244e-01f, -6.22102665e-03f, -4.34700221e-01f, 1.97608948e-01f, -3.39985013e-01f, -2.88860142e-01f, 4.04621847e-02f,
  -1.80311769e-01f, 9.18705910e-02f, -2.28942439e-01f, -8.23476259e-03f, -5.17565794e-02f, -4.22929317e-01f, -8.60979706e-02f, -2.36474290e-01f, 6.74799504e-03f, 1.57279477e-01f,
  2.30176419e-01f, 3.25086601e-02f, 2.53755033e-01f, -2.48903677e-01f, -1.92176715e-01f, 2.20049858e-01f, 4.34034348e-01f, 5.31874001e-02f, 1.25165284e-01f, -3.25635634e-02f,
  1.16555989e-01f, -1.90961421e-01f, -1.86494309e-02f, 1.16473816e-01f, 1.31380394e-01f, 4.30844240e-02f, 2.20787376e-02f, 3.46815079e-01f, 2.09593639e-01f, 6.79463983e-01f,
  -2.25131750e-01f, -5.05247831e-01f, -2.99861073e-01f, -6.96003497e-01f, -3.76708448e-01f, -6.08937979e-01f, 4.41555411e-01f, 1.65618628e-01f, -4.87350792e-01f, 4.03140604e-01f,
  2.37642363e-01f, -5.85198641e-01f, 1.10541768e-01f, 1.71458393e-01f, -3.87909174e-01f, 2.08187148e-01f, -2.78957993e-01f, 1.03549868e-01f, -5.03254652e-01f, -6.98013008e-01f,
  3.27548325e-01f, -3.78206611e-01f, -6.60646737e-01f, 4.05543089e-01f, 8.20215121e-02f, 1.40133142e-01f, -1.05122253e-01f, 9.04903263e-02f, 7.78533518e-02f, 1.03725061e-01f,
  -6.11054190e-02f, -3.29578400e-01f, -3.75216827e-02f, -7.55505413e-02f, -1.12601034e-01f, 5.18304072e-02f, 6.76908270e-02f, -6.90678060e-02f, 1.33199636e-02f, 2.12083116e-01f,
  -1.49950072e-01f, -1.38277516e-01f, 5.71337044e-02f, 3.00352335e-01f, 3.76382053e-01f, 2.87882507e-01f, -1.62658706e-01f, 2.49087643e-02f, 1.42366037e-01f, 1.71272755e-01f,
  2.03016758e-01f, -1.56223312e-01f, 3.00288275e-02f, -1.98844478e-01f, -1.08107246e-01f, 3.84631800e-03f, -3.96721214e-01f, 2.17473611e-01f, 1.26329497e-01f, 2.55491555e-01f,
  2.30529010e-01f, -2.04049975e-01f, -6.88687325e-01f, 4.23189044e-01f, 2.81541109e-01f, -6.46632731e-01f, 1.07209899e-01f, 7.66327858e-01f, -7.25933731e-01f, -6.65236712e-02f,
  2.30350256e-01f, -1.18914759e+00f, 1.53434783e-01f, 1.05440497e+00f, -7.77983785e-01f, -1.67985976e-01f, -7.59605587e-01f, -4.33209598e-01f, 4.28271919e-01f, 2.58004636e-01f,
  5.52024283e-02f, 5.82165420e-01f, 2.33097211e-01f, -1.30685711e+00f, 3.74812586e-03f, 3.04086208e-02f, -6.69181168e-01f, -7.30550826e-01f, 1.23976134e-02f, -3.88643928e-02f,
  1.02427319e-01f, 1.61500156e-01f, -2.35350896e-02f, 1.09574303e-01f, -1.51655702e-02f, 1.54496655e-01f, 1.37809768e-01f, 1.43177554e-01f, 1.61657706e-01f, -9.22413636e-03f,
  1.90728113e-01f, 1.03773829e-02f, 1.54077604e-01f, 4.78168428e-02f, -5.61083220e-02f, 1.55143723e-01f, -8.55915919e-02f, -2.07390279e-01f, 4.05010700e-01f, 1.02944754e-01f,
  -3.04224640e-01f, -1.02336854e-01f, -1.77604735e-01f, -1.33613452e-01f, 4.38527942e-01f, -5.40744588e-02f, 1.07570879e-01f, 4.54714477e-01f, -3.70254666e-01f, -1.80663705e-01f,
  -3.78773481e-01f, 1.74102321e-01f, 2.94251382e-01f, 1.33799305e-02f, 1.45393878e-01f, 2.48731092e-01f, -8.28437150e-01f, 7.40139604e-01f, -6.55421078e-01f, -1.14516437e-01f,
  -2.68162310e-01f, 4.32450145e-01f, 2.37506405e-01f, -5.04060328e-01f, 5.45246124e-01f, 9.74168420e-01f, -5.70488214e-01f, 2.74638146e-01f, 1.73277900e-01f, -5.39276421e-01f,
  4.25596908e-02f, -8.11828911e-01f, 1.37837321e-01f, -6.80715203e-01f, -3.27539295e-01f, -3.06787252e-01f, 3.78435440e-02f, 3.62829268e-01f, -3.80382210e-01f, -1.75984874e-01f,
  -4.80725616e-01f, -1.29343107e-01f, -2.18972698e-01f, -4.91054691e-02f, -6.83868602e-02f, -5.02234221e-01f, -9.75867808e-02f, 4.41729501e-02f, -1.91421628e-01f, -9.27795768e-02f,
  -1.82287201e-01f, -1.67004377e-01f, 1.34922877e-01f, -1.54270187e-01f, -4.50734831e-02f, 9.18549821e-02f, -3.36209476e-01f, 2.98235491e-02f, 8.31751600e-02f, 4.90243873e-03f,
  -7.45719969e-01f, 2.21584663e-01f, -5.86109340e-01f, 2.04215914e-01f, 4.66851473e-01f, 3.05449218e-01f, -2.46794015e-01f, -1.49998128e-01f, 3.41815442e-01f, 2.66301066e-01f,
  -4.31689620e-01f, 2.18245402e-01f, -3.27101126e-02f, -2.34742388e-02f, -4.52105731e-01f, -1.97787821e-01f, 3.10063154e-01f, 6.63868850e-03f, 1.05530471e-01f, 7.63066411e-01f,
  3.33221629e-02f, -3.59316707e-01f, -2.33906999e-01f, 1.37705460e-01f, -3.90936106e-01f, -1.96259290e-01f, 5.66199362e-01f, -2.13603526e-01f, -3.18831921e-01f, 3.25339526e-01f,
  4.80169952e-01f, 2.53548175e-01f, -3.46496791e-01f, 6.69127703e-01f, 4.00984228e-01f, 1.22672141e-01f, -7.33977139e-01f, -1.33853137e+00f, -5.45070469e-01f, -8.26053202e-01f,
  -2.74263471e-01f, -5.64360738e-01f, -6.07187510e-01f, -6.47242248e-01f, 7.51429558e-01f, 3.25252622e-01f, 1.10506780e-01f, -1.46324635e-01f, -2.46315613e-01f, 3.60158592e-01f,
  -1.70501560e-01f, 1.60714135e-01f, -1.97066963e-01f, 2.43002146e-01f, -7.93126747e-02f, -2.61084344e-02f, -2.39163458e-01f, -2.70124257e-01f, -2.24047497e-01f, -7.59037808e-02f,
  2.52852216e-03f, 5.78961857e-02f, -2.47084737e-01f, 3.44925048e-03f, 1.45944074e-01f, 5.02257161e-02f, -1.11478440e-01f, 1.53984696e-01f, -3.72561485e-01f, 2.38731742e-01f,
  1.30871370e-01f, -2.26280436e-01f, -3.60549062e-01f, 1.64753050e-01f, 2.03816757e-01f, -2.44047895e-01f, 2.93220520e-01f, 3.10597628e-01f, 2.14093447e-01f, -3.17842633e-01f,
  1.57665342e-01f, -4.03981060e-02f, 1.64318964e-01f, -4.58354205e-01f, 2.51092881e-01f, -8.62904489e-02f, -7.35450208e-01f, 4.25582647e-01f, 2.77755857e-01f, -5.14579952e-01f,
  4.55273181e-01f, -6.03518449e-02f, -2.38499910e-01f, 1.27714097e-01f, 6.10801041e-01f, -2.01735809e-01f, -7.54730582e-01f, -8.48391771e-01f, -1.00392139e+00f, 3.54465917e-02f,
  -6.05293155e-01f, 1.11939490e-01f, -1.97247285e-02f, -9.85616386e-01f, 1.38260573e-01f, 8.33210886e-01f, -3.30668787e-04f, 2.05691859e-01f, -1.39545470e-01f, -9.34643686e-01f,
  1.04597986e-01f, 7.35774264e-02f, 1.52867049e-01f, 2.74207652e-01f, -4.33858074e-02f, 1.29434422e-01f, 2.18065619e-01f, 3.23528111e-01f, 2.49860793e-01f, -4.85208295e-02f,
  8.67263414e-03f, 1.49455369e-01f, 1.20023653e-01f, 3.55229348e-01f, -4.70042005e-02f, 1.22182287e-01f, 1.52681768e-01f, 2.38415584e-01f, -5.91234118e-02f, -5.12748957e-01f,
  3.97183709e-02f, 1.25589147e-01f, -2.61368509e-03f, -9.49128121e-02f, 2.08305672e-01f, 1.25646830e-01f, 6.49906695e-02f, 2.96587586e-01f, 2.61120707e-01f, -2.82603502e-01f,
  3.49256843e-01f, 2.55713403e-01f, 2.98481673e-01f, 3.28192681e-01f, -2.74383277e-01f, 3.39219421e-01f, 2.48564601e-01f, 1.05279937e-01f, 4.82477158e-01f, -1.27181923e+00f,
  6.69222027e-02f, -4.62941200e-01f, -1.33856371e-01f, -4.50352103e-01f, -9.84006763e-01f, -5.21502160e-02f, -6.36742234e-01f, -4.48456228e-01f, -1.04821995e-01f, -5.81715703e-01f,
  6.13197863e-01f, 6.66192353e-01f, -3.69653344e-01f, 8.08712065e-01f, -1.85996424e-02f, 6.03115380e-01f, -4.86519784e-01f, 3.31624061e-01f, 1.66401178e-01f, -3.79614592e-01f,
  6.72364175e-01f, 5.39491139e-02f, -7.89538860e-01f, -5.41038573e-01f, -2.31195673e-01f, 4.63359177e-01f, 1.66132748e-01f, -1.15126207e-01f, 8.95555913e-02f, 1.29157394e-01f,
  5.84550984e-02f, -3.68232578e-01f, 2.61440873e-01f, -1.79125965e-01f, 2.48015389e-01f, 7.39285164e-03f, 1.51289538e-01f, -9.13641602e-02f, -1.00113653e-01f, 8.69834796e-02f,
  3.10476691e-01f, -2.18151454e-02f, 4.11622763e-01f, -2.72323966e-01f, 1.14393093e-01f, 9.59979661e-04f, -2.85134047e-01f, -1.27433956e-01f, 4.91985887e-01f, -8.24322924e-02f,
  -2.39591628e-01f, -4.37617868e-01f, -3.69934559e-01f, -1.51184455e-01f, -7.41051793e-01f, -1.54509008e-01f, 2.88441658e-01f, 5.43298781e-01f, -2.91140884e-01f, 2.49032322e-02f,
  -1.27141580e-01f, 2.41852924e-01f, -1.23489559e+00f, -3.05941254e-01f, 4.57341701e-01f, -1.78754926e-01f, -6.23098850e-01f, 4.93604362e-01f, -4.29197907e-01f, -1.11595058e+00f,
  -3.99203122e-01f, -8.46669197e-01f, -4.73790079e-01f, -4.35700268e-01f, 5.04101396e-01f, 4.63468907e-03f, -4.53721881e-01f, -3.37841749e-01f, 4.03220683e-01f, -5.55045247e-01f,
  5.31729519e-01f, -3.61567229e-01f, -8.34277213e-01f, 4.39546794e-01f, -5.64408422e-01f, 3.72455537e-01f, -5.17421722e-01f, -7.13839114e-01f, -4.20789450e-01f, 5.51103875e-02f,
  -2.49762878e-01f, -4.79257889e-02f, -2.90864334e-02f, -2.14962110e-01f, -2.53925711e-01f, -2.35596951e-02f, -3.12987953e-01f, -2.88342714e-01f, -2.26183191e-01f, -3.50766063e-01f,
  2.79829223e-02f, -1.02418847e-01f, -2.49186710e-01f, -1.09547757e-01f, -1.47524923e-01f, -3.12571377e-01f, 1.03047974e-02f, -2.47093439e-01f, 1.19582258e-01f, -1.89375073e-01f,
  8.07188172e-03f, -1.80536106e-01f, -7.29963332e-02f, -1.10697836e-01f, -1.56011403e-01f, 7.54789338e-02f, -8.26101676e-02f, 2.27493662e-02f, 2.87445486e-01f, -4.50496301e-02f,
  -8.89312103e-02f, -1.93312421e-01f, -1.06289953e-01f, -2.90043652e-01f, -2.26497322e-01f, -1.48798317e-01f, -2.87755489e-01f, -3.02172184e-01f, -2.35054672e-01f, -3.38364184e-01f,
  3.28184366e-01f, -6.67624056e-01f, 7.11664915e-01f, 3.54312539e-01f, -9.79646668e-02f, 5.45474172e-01f, -5.10104656e-01f, -5.16734421e-01f, 6.15302585e-02f, 3.73529315e-01f,
  9.73576680e-03f, -7.03488946e-01f, -5.15137196e-01f, -1.64081827e-01f, -5.37362933e-01f, -4.22804505e-01f, -2.31309578e-01f, -6.91344142e-01f, -7.52010643e-01f, 1.14710636e-01f,
  -2.01460540e-01f, 6.61143959e-01f, 1.12599894e-01f, -1.03264131e-01f, -8.74677449e-02f, -7.65470490e-02f, 1.58323690e-01f, 3.07856519e-02f, 1.48290470e-01f, 1.60605922e-01f,
  -7.43727200e-03f, 1.23518407e-02f, 1.67840734e-01f, -1.45027488e-01f, 1.74273197e-02f, 9.47078317e-02f, 1.24798708e-01f, 3.15438248e-02f, -6.05014041e-02f, 6.47374317e-02f,
  2.45071456e-01f, 1.33523151e-01f, -5.80056310e-01f, -1.97462663e-01f, 4.45847958e-01f, 1.13233052e-01f, 2.36886874e-01f, 4.67050187e-02f, 1.59203485e-02f, -1.29695877e-01f,
  4.99692149e-02f, 3.37042809e-01f, -5.21659553e-01f, -2.35630602e-01f, -2.42297783e-01f, 4.57605183e-01f, -2.90858001e-01f, 1.13740638e-01f, -1.85729280e-01f, 1.59659460e-01f,
  -4.08394039e-01f, -4.53194439e-01f, -5.33435106e-01f, 1.14966393e-01f, -3.76242697e-01f, 1.36328265e-01f, -1.35476917e-01f, 6.77441239e-01f, -5.63290179e-01f, 1.83572203e-01f,
  -6.95356429e-01f, -6.44188344e-01f, -2.33722895e-01f, -4.60897028e-01f, 1.00204396e+00f, -9.52356398e-01f, 2.46021643e-01f, -8.33964348e-02f, 3.95897359e-01f, 7.44270265e-01f,
  -4.33240607e-02f, -4.72969443e-01f, 4.36240658e-02f, -3.57690096e-01f, -5.86948335e-01f, 9.40538198e-02f, 3.36282045e-01f, -1.32304624e-01f, 1.06469207e-01f, -5.10722876e-01f,
  4.41886187e-02f, -3.47427338e-01f, 1.57954171e-01f, 2.14885876e-01f, -1.25401571e-01f, 7.24916607e-02f, -9.81882960e-02f, 3.68023604e-01f, 3.13515849e-02f, -4.74376261e-01f,
  1.01118252e-01f, 8.81768540e-02f, -1.46011606e-01f, -4.59134616e-02f, -5.51494479e-01f, -1.28500909e-01f, 4.55281675e-01f, 7.25483075e-02f, -3.09662461e-01f, 3.34848911e-01f,
  -8.20965469e-01f, 4.09441069e-02f, -4.23271596e-01f, 5.33611059e-01f, 4.85900462e-01f, 2.77063400e-02f, 7.44336665e-01f, 1.54161185e-01f, 4.03565288e-01f, -5.63568473e-01f,
  3.54383230e-01f, -5.96720994e-01f, 5.61817214e-02f, -8.90301049e-01f, 1.01558864e+00f, -3.86117399e-01f, 7.69129246e-02f, -4.73664463e-01f, -1.96009278e-01f, 1.81553409e-01f,
  -1.09275281e+00f, -6.55990094e-02f, -1.21684270e-02f, -8.11783850e-01f, -1.46567836e-01f, -4.13353443e-01f, 7.01810718e-02f, -8.57058823e-01f, -5.19945860e-01f, -6.48779511e-01f,
  1.65728673e-01f, 1.88154027e-01f, -1.71697885e-01f, -6.70478880e-01f, 4.35188740e-01f, 6.06293261e-01f, -3.12922299e-01f, -2.73202121e-01f, -7.37671971e-01f, 7.35982537e-01f,
  -1.63494766e-01f, 9.99659970e-02f, 1.17218561e-01f, 1.87873676e-01f, -2.21609667e-01f, 1.59657285e-01f, 4.07600030e-02f, 1.60640806e-01f, 7.10707083e-02f, 3.83008085e-02f,
  2.22656533e-01f, 1.02117032e-01f, 9.80906263e-02f, -2.80862246e-02f, 2.35895798e-01f, -1.81311876e-01f, 1.08808152e-01f, 1.37424991e-01f, 2.40192667e-01f, 4.12103742e-01f,
  4.31121349e-01f, -2.26761013e-01f, 2.58042701e-02f, 2.19910562e-01f, 7.00341016e-02f, 3.05677615e-02f, 3.05924028e-01f, -6.11586682e-02f, 8.12079161e-02f, 5.43927625e-02f,
  4.95823562e-01f, -1.42811611e-01f, -4.60774302e-01f, -4.91089642e-01f, 3.27405930e-01f, -1.26324490e-01f, -8.97355750e-02f, -4.37927485e-01f, -8.48769903e-01f, -5.26743054e-01f,
  -1.79930538e-01f, 7.75354624e-01f, 5.49439847e-01f, -3.62977684e-01f, -1.19565316e-01f, -5.48324287e-01f, -1.78699046e-01f, -4.10678625e-01f, -5.70936143e-01f, -5.33126175e-01f,
  -3.74866128e-01f, 7.57220566e-01f, 5.39640665e-01f, 3.26123178e-01f, -6.68337762e-01f, -1.01743266e-01f, -2.21083760e-01f, 3.86124700e-01f, -4.33446378e-01f, -2.79914111e-01f,
  -9.56266105e-01f, -6.83629870e-01f, -5.34947753e-01f, -4.63634878e-01f, 3.33645254e-01f, -4.23501641e-01f, 3.60643081e-02f, 1.61541790e-01f, -4.25578356e-02f, -3.96778062e-02f,
  8.06387365e-02f, -1.13864578e-01f, 1.46591477e-02f, 1.08057387e-01f, 5.66486567e-02f, 6.34456351e-02f, 1.91319548e-02f, 1.77627787e-01f, 1.29397705e-01f, -2.11956471e-01f,
  9.92592722e-02f, 1.25776604e-01f, 1.06189936e-01f, 4.56205338e-01f, -5.10774016e-01f, 2.37531886e-01f, -1.93570524e-01f, -2.21783355e-01f, 3.88348639e-01f, -3.07499133e-02f,
  -2.53489763e-01f, -1.57021299e-01f, 2.09313899e-01f, 1.01228729e-01f, -4.17634517e-01f, -7.17963325e-03f, 1.52362257e-01f, -3.13711166e-01f, -3.67703676e-01f, 3.84848565e-01f,
  -1.02743775e-01f, 5.58352411e-01f, -4.74632382e-01f, -1.68687776e-01f, 2.37505585e-01f, -4.04922754e-01f, 5.19671142e-02f, -6.16569579e-01f, 3.44468594e-01f, -5.69141567e-01f,
  -1.86062396e-01f, -7.28712380e-01f, -1.33583069e-01f, -1.47766665e-01f, -5.23066223e-01f, -4.61322039e-01f, -9.30928290e-02f, -4.56321329e-01f, -5.94976902e-01f, -2.87965387e-01f,
  6.39677525e-01f, -1.46706894e-01f, 8.96745622e-02f, -2.09513530e-01f, 2.61245579e-01f, -1.76602393e-01f, 1.18747473e+00f, 2.48713225e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.80410075e-01f, -2.24530026e-01f, 2.77424484e-01f, -3.49013895e-01f, 3.58530395e-02f, 8.24050829e-02f, 3.93230826e-01f, -4.96147387e-02f, -1.52454108e-01f, 4.97835755e-01f,
  1.13514379e-01f, 1.48400307e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    