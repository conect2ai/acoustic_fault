/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.77998018e-01f, 2.42288813e-01f, -4.31484133e-01f, 1.13840580e-01f, -1.55431151e-01f, -2.77117819e-01f, -1.65798441e-01f, -1.24722682e-01f, 6.04165494e-02f, 1.84055120e-01f,
  5.63063808e-02f, 1.50847703e-01f, 1.66209877e-01f, 2.49119047e-02f, -1.04049355e-01f, 8.64883512e-02f, -1.28001161e-02f, -2.04112485e-01f, -2.62368262e-01f, -2.45382637e-02f,
  1.07531868e-01f, 1.71022728e-01f, 1.07032053e-01f, 3.44421603e-02f, 3.65281850e-01f, 2.45812610e-01f, 1.98087409e-01f, 4.57148477e-02f, 1.72071859e-01f, 4.86994952e-01f,
  9.26279649e-02f, -7.16698989e-02f, -2.22785268e-02f, 1.34831667e-01f, 4.73553352e-02f, 7.73750767e-02f, 9.10079926e-02f, 1.10544682e-01f, 2.47893240e-02f, 3.69248800e-02f,
  5.84112406e-02f, 8.09964016e-02f, 2.72882022e-02f, 8.72925892e-02f, 5.98655380e-02f, 1.02361925e-02f, -3.01563274e-02f, -1.00794129e-01f, 4.33538966e-02f, 9.50457156e-03f,
  5.30955307e-02f, -9.33797657e-03f, -7.07692355e-02f, 1.25913573e-02f, -9.86265987e-02f, -1.74881816e-02f, 1.27149969e-01f, 1.26682416e-01f, 5.46690263e-02f, 3.11490148e-01f,
  8.07974935e-02f, 2.86600720e-02f, -6.43704161e-02f, 8.70528631e-03f, 9.71787870e-02f, -8.17889422e-02f, 1.86204668e-02f, -1.82678793e-02f, -5.21488674e-03f, -3.87133611e-03f,
  -7.80042335e-02f, -8.46387967e-02f, 4.11218479e-02f, 2.90513188e-02f, 4.58221398e-02f, -5.55339344e-02f, -9.59420726e-02f, 4.79475595e-02f, -7.90495332e-03f, 1.79370660e-02f,
  9.78949573e-03f, -6.42102864e-03f, -9.09687653e-02f, -8.96740588e-04f, -9.88026932e-02f, -7.05700219e-02f, -9.19367447e-02f, -6.37487993e-02f, -7.91201144e-02f, -8.25883895e-02f,
  2.22523153e-01f, -2.27990061e-01f, 1.42007768e-01f, -6.66653458e-03f, 6.31147698e-02f, 9.81724239e-04f, 7.71649033e-02f, -1.53019791e-02f, 2.74706483e-02f, 2.54702698e-02f,
  -3.16229686e-02f, 8.53733942e-02f, 5.29366061e-02f, 7.52752367e-03f, 3.18454765e-02f, 6.55091600e-03f, 6.94838762e-02f, 2.68443134e-02f, -5.57282865e-02f, 6.15987070e-02f,
  7.81193525e-02f, 1.30276233e-01f, 1.06690362e-01f, 5.85439950e-02f, 7.32790604e-02f, 1.40197903e-01f, 1.11259252e-01f, 1.76970616e-01f, -7.67785450e-03f, 3.72119963e-01f,
  -6.22885562e-02f, 2.28555143e-01f, 3.29570681e-01f, -1.28279939e-01f, -3.63283567e-02f, -1.72338840e-02f, 3.90374139e-02f, 1.23209106e-02f, -6.42365217e-02f, -2.91407555e-02f,
  -1.43705785e-01f, -3.34890664e-01f, -2.87428200e-01f, -2.90194303e-01f, -1.87173605e-01f, 1.61436304e-01f, 2.34355122e-01f, -6.55576810e-02f, -2.80368537e-01f, -2.09339797e-01f,
  -1.63224652e-01f, -1.31181151e-01f, -2.29935758e-02f, 3.32951434e-02f, 1.68135762e-01f, -1.13283031e-01f, 1.64306864e-01f, 1.87465668e-01f, 1.58874750e-01f, 2.37066910e-01f,
  1.19364642e-01f, 3.00929338e-01f, -1.96161330e-01f, -8.25707987e-02f, -6.34570187e-03f, -5.38154207e-02f, -3.33540551e-02f, 5.55965267e-02f, 1.02710689e-03f, -4.28899527e-02f,
  -1.15933135e-01f, 1.42480703e-02f, 3.11664701e-03f, 5.66399954e-02f, -9.07131061e-02f, -9.82592031e-02f, 1.68584306e-02f, 4.05052230e-02f, -9.96602103e-02f, 1.31016020e-02f,
  -7.29530752e-02f, 4.24275249e-02f, -3.72474291e-03f, -1.17693685e-01f, 9.55222473e-02f, -1.98885679e-01f, 5.74892797e-02f, 8.96281376e-02f, -3.19995508e-02f, 1.32450610e-01f,
  -2.84342654e-03f, 8.64507332e-02f, -6.84598461e-03f, 9.02752057e-02f, 3.05562839e-02f, -1.56244505e-02f, 5.50479852e-02f, 9.47043393e-03f, -1.56612322e-02f, 7.30452389e-02f,
  4.60279509e-02f, -4.64166142e-03f, 7.79971108e-03f, 4.03250428e-03f, -5.60401455e-02f, 8.04185942e-02f, -5.29504046e-02f, 8.27947780e-02f, 3.28294523e-02f, 5.79511933e-02f,
  -4.32841443e-02f, 6.71632588e-02f, -2.90359948e-02f, 1.74099132e-02f, 1.11056946e-01f, 2.05410477e-02f, -1.39217768e-02f, 4.38543297e-02f, 4.61119004e-02f, 2.48422138e-02f,
  -2.70195395e-01f, -1.72203764e-01f, -2.90694516e-02f, -3.08222827e-02f, -6.03439473e-02f, -3.71886641e-02f, 1.38579672e-02f, -9.68950465e-02f, -4.08866890e-02f, -7.73962587e-02f,
  8.47532228e-03f, -4.83832583e-02f, -6.16390593e-02f, -9.90660638e-02f, -2.02796221e-01f, -8.03091079e-02f, -8.80948305e-02f, -8.56797546e-02f, -1.09907970e-01f, 1.12487022e-02f,
  -7.81347901e-02f, -1.82683572e-01f, -2.76213080e-01f, -2.70261526e-01f, -9.34594423e-02f, -2.82081753e-01f, -9.20537561e-02f, -1.72709391e-01f, -1.95765421e-01f, -1.25531927e-01f,
  5.26370257e-02f, -3.00523371e-01f, 9.88027230e-02f, 1.00879796e-01f, 2.76706163e-02f, -8.79623592e-02f, -1.86141774e-01f, -8.53926241e-02f, 1.18309883e-02f, 1.10731781e-01f,
  1.94219992e-01f, 3.22363913e-01f, 2.72777110e-01f, 1.28154710e-01f, -5.34239365e-03f, 6.50461167e-02f, 1.16192608e-03f, 9.93064493e-02f, 1.08725592e-01f, 2.04355083e-02f,
  -3.54874693e-02f, -6.49607256e-02f, 5.43788224e-02f, 8.22363645e-02f, 8.07483941e-02f, 1.70246795e-01f, 8.85430798e-02f, 1.32750735e-01f, 6.00133166e-02f, 3.18846434e-01f,
  5.38137257e-01f, 8.69124457e-02f, 1.76797152e-01f, 1.73580870e-01f, 1.29828304e-01f, 5.22284918e-02f, 9.62379351e-02f, 9.88147184e-02f, 8.59727859e-02f, -7.41316588e-04f,
  8.99441987e-02f, 3.52059379e-02f, 1.14837810e-01f, 1.77190721e-01f, 5.86334579e-02f, 7.63012841e-02f, -1.08207548e-02f, 7.33971000e-02f, 5.76413050e-02f, 1.10327959e-01f,
  1.23888515e-01f, 2.19076559e-01f, 1.76763922e-01f, 8.50418881e-02f, 1.69562474e-01f, 2.66083688e-01f, 2.30126247e-01f, 2.46478766e-01f, 2.17777491e-01f, 2.09183231e-01f,
  2.51238570e-02f, -6.64329901e-02f, -7.18054399e-02f, -1.83237433e-01f, -2.31384367e-01f, -8.54576752e-02f, -2.67722141e-02f, -1.02830203e-02f, -1.65109694e-01f, -9.48900357e-02f,
  -1.09131664e-01f, -1.56375229e-01f, -1.95532188e-01f, -1.21498279e-01f, -1.43903002e-01f, -1.18283875e-01f, -8.02150965e-02f, -8.89723375e-03f, -3.17284390e-02f, -1.84696257e-01f,
  2.01674327e-02f, 7.39943385e-02f, -7.92510808e-02f, -4.21061665e-02f, -1.42550662e-01f, -7.64560103e-02f, -5.53243868e-02f, -1.09357461e-01f, -4.64508682e-02f, -1.44517988e-01f,
  1.23037070e-01f, -1.48693910e-02f, 2.16370821e-01f, 2.50552118e-01f, 1.25292748e-01f, 2.15476930e-01f, 8.89495537e-02f, 1.26226917e-01f, 1.67971715e-01f, 8.93838629e-02f,
  1.70637637e-01f, 5.06973453e-02f, 1.39041334e-01f, 1.35862837e-02f, 6.76594898e-02f, 7.91192800e-02f, 1.46165546e-02f, 9.58852768e-02f, 1.58024609e-01f, 1.17989741e-02f,
  8.43761489e-02f, 1.13270760e-01f, 2.05689967e-01f, 1.66790575e-01f, 1.46474138e-01f, 1.44686952e-01f, 9.33846310e-02f, 1.57537103e-01f, 2.59769320e-01f, -1.71052106e-02f,
  -1.85213909e-01f, -2.09108666e-02f, 1.61268711e-01f, -4.12526309e-01f, 5.29602868e-03f, 3.02148789e-01f, 3.62171292e-01f, 7.00570792e-02f, -2.43172660e-01f, -3.56068313e-02f,
  -9.46646482e-02f, -1.05536103e-01f, 2.93423552e-02f, 1.19505838e-01f, 2.06741348e-01f, 2.49960884e-01f, 1.79264307e-01f, 1.51252300e-01f, 1.94791660e-01f, 9.45486501e-02f,
  1.89519171e-02f, -1.18865699e-01f, -2.05021381e-01f, -7.21113682e-02f, -3.76462817e-01f, -1.48954377e-01f, -1.37795210e-01f, -2.30786160e-01f, -4.41933051e-02f, -2.16110140e-01f,
  -6.22651242e-02f, -1.65266827e-01f, 9.65980142e-02f, -1.49386778e-01f, -1.80374816e-01f, -3.34602669e-02f, -4.87518348e-02f, -1.22790709e-01f, -1.13938190e-01f, -3.28437611e-02f,
  -1.46832123e-01f, -1.15922347e-01f, -8.88010412e-02f, -1.24906786e-01f, -2.22756974e-02f, 2.13290770e-02f, -9.30270627e-02f, -9.32273492e-02f, -1.00215562e-01f, -9.12178159e-02f,
  -1.10558592e-01f, 3.12349033e-02f, 3.56135098e-03f, 1.24069855e-01f, -1.29772782e-01f, -2.48318957e-03f, 8.31768382e-03f, -4.34815586e-02f, -4.74344455e-02f, -2.09878922e-01f,
  3.51128802e-02f, 2.71057878e-02f, 6.37512058e-02f, 7.11944178e-02f, 9.65322331e-02f, 8.81767869e-02f, 7.02401549e-02f, 7.57626444e-02f, 2.91497074e-02f, 8.71672109e-02f,
  6.85462207e-02f, 2.66908091e-02f, 4.05496918e-02f, 3.48014757e-02f, 8.62794220e-02f, -9.27070435e-03f, 8.33672285e-02f, 3.47112082e-02f, 7.11802095e-02f, -6.82191597e-03f,
  1.11947872e-01f, 9.70042646e-02f, 1.80252688e-03f, 4.74048369e-02f, 5.86089678e-02f, 3.73507626e-02f, 3.77823748e-02f, -2.27588229e-03f, 3.06918435e-02f, -4.12182737e-04f,
  -1.52479306e-01f, 1.70574516e-01f, -1.09298833e-01f, -3.74233536e-02f, -1.70862265e-02f, -1.45903066e-01f, -3.00094262e-02f, -8.80499557e-02f, -1.04737408e-01f, 7.38253724e-03f,
  -5.86737087e-03f, -4.64021787e-02f, -2.53860690e-02f, -4.35319394e-02f, -3.14102396e-02f, -5.63823693e-02f, 2.45478190e-02f, 4.18450357e-03f, 2.85262093e-02f, -9.60265175e-02f,
  1.28408503e-02f, 4.75071482e-02f, 1.29844472e-01f, 1.51565708e-02f, -9.66123343e-02f, -8.05021636e-03f, 1.97175927e-02f, -7.02007255e-03f, 1.58942223e-01f, 1.08948223e-01f,
  4.49662209e-01f, 2.06314743e-01f, 3.58894140e-01f, 1.80294454e-01f, -4.30695750e-02f, 2.08549798e-02f, 2.60143638e-01f, 8.89146850e-02f, -4.40940671e-02f, 8.94533321e-02f,
  -1.93416730e-01f, -3.53165835e-01f, -1.24907859e-01f, -2.24228054e-01f, 9.49247479e-02f, 1.94996670e-01f, 1.19644381e-01f, 1.86331943e-01f, 7.63345659e-02f, -1.14122309e-01f,
  -1.57203346e-01f, 9.62614827e-03f, 1.81980193e-01f, 7.54896030e-02f, -1.71853513e-01f, -7.08342642e-02f, 1.13229722e-01f, 1.49971228e-02f, -1.03302293e-01f, -1.50183380e-01f,
  -1.85200155e-01f, 2.54469335e-01f, -6.62117824e-02f, -4.09361906e-02f, -7.75204226e-02f, -8.99628084e-03f, -5.43376766e-02f, 4.82116416e-02f, 1.51880421e-02f, -1.28762955e-02f,
  -3.81245427e-02f, -1.02843471e-01f, -1.21779151e-01f, -1.12249605e-01f, 7.56946132e-02f, -1.99737679e-02f, 7.48841316e-02f, 9.07504335e-02f, -6.75930455e-02f, -4.33624908e-02f,
  -1.69066608e-01f, -3.33387963e-02f, 1.39433667e-01f, -3.08937896e-02f, -4.11501788e-02f, 3.24673392e-02f, -7.88429826e-02f, -4.68679368e-02f, 5.58520369e-02f, 2.17353813e-02f,
  -1.07172810e-01f, -1.20594211e-01f, 1.35759870e-02f, 2.65934411e-02f, 2.47620344e-02f, -3.62885781e-02f, -4.63454984e-02f, -7.08270371e-02f, -1.18014356e-02f, 3.68481688e-02f,
  2.06485204e-02f, 1.01449573e-02f, -3.16962302e-02f, 4.87029999e-02f, -1.59598202e-01f, -4.00583781e-02f, 8.87496956e-03f, 5.69514290e-04f, 1.56700686e-02f, 7.89230391e-02f,
  4.08167243e-02f, -4.49151965e-03f, 4.56437394e-02f, -1.69857871e-02f, -1.12399682e-02f, 2.80235196e-03f, -4.51265275e-02f, -8.63524601e-02f, -3.96393165e-02f, 3.73482741e-02f,
  -1.31995708e-01f, 1.66776106e-01f, -4.36459482e-02f, 7.98539259e-03f, -3.48527078e-03f, -5.71083240e-02f, -3.48328836e-02f, 8.39356855e-02f, -8.01533461e-03f, -8.04465637e-03f,
  -7.01039582e-02f, 2.69174743e-02f, -1.25348829e-02f, -3.69334146e-02f, -5.42727783e-02f, 2.45989114e-02f, 5.63748740e-03f, 3.42325494e-02f, -4.67628725e-02f, -8.73569697e-02f,
  1.06756233e-01f, 2.05812439e-01f, 1.49352863e-01f, 1.38514340e-01f, 5.69419451e-02f, 9.66964811e-02f, -3.75650711e-02f, 1.19081484e-02f, 1.50023192e-01f, 1.03827670e-01f,
  4.68189150e-01f, 1.03560090e-01f, 2.29754582e-01f, -8.00906196e-02f, -3.58719587e-01f, -2.24830166e-01f, -7.53542706e-02f, -1.14839017e-01f, -1.14777438e-01f, -1.43636197e-01f,
  -1.09021083e-01f, -5.69627807e-02f, 6.46083578e-02f, 1.07605316e-01f, 1.80698827e-01f, -1.25737280e-01f, -9.56739634e-02f, 3.14419031e-01f, 2.00106740e-01f, -1.28973737e-01f,
  -2.93631703e-01f, -4.33687009e-02f, 3.42252105e-01f, 2.75154002e-02f, -2.53285497e-01f, -1.50310382e-01f, 3.83909605e-02f, 3.06721684e-02f, -3.73419784e-02f, -2.38502726e-01f,
  1.28832623e-01f, 1.89681455e-01f, 1.72243384e-03f, -1.15180248e-02f, -4.51910729e-03f, 7.19412640e-02f, -2.35332064e-02f, 1.12658568e-01f, -1.47255128e-02f, 2.00440711e-03f,
  -8.01597983e-02f, -3.05733159e-02f, 5.29580005e-02f, -2.03479808e-02f, 9.49494634e-03f, 1.22986296e-02f, 6.71987087e-02f, 1.46861926e-01f, 9.59720239e-02f, 7.49526992e-02f,
  -8.03838745e-02f, 4.36944999e-02f, 1.28886744e-01f, 5.40577173e-02f, 6.63860217e-02f, -2.18180548e-02f, 1.12349831e-01f, 6.13739677e-02f, 1.71902135e-01f, 7.36330263e-03f,
  1.12889502e-02f, -6.21698909e-02f, 3.97003070e-03f, 1.09218314e-01f, -5.38885444e-02f, -2.85291541e-02f, -9.65653080e-03f, -2.31218133e-02f, -3.43427025e-02f, -3.98845114e-02f,
  5.91557175e-02f, -5.72193377e-02f, 1.01461023e-01f, -5.82462512e-02f, -7.25912228e-02f, 4.97794934e-02f, -2.50068530e-02f, 2.19733957e-02f, 1.08985327e-01f, -2.69734170e-02f,
  3.02036610e-02f, 6.91649597e-03f, -4.19967398e-02f, 6.93986490e-02f, 1.81042403e-03f, -3.29083055e-02f, 3.33656892e-02f, -7.73038864e-02f, -3.43919471e-02f, -9.06973034e-02f,
  -8.30310583e-02f, 3.03645730e-01f, -1.04978181e-01f, 1.00571960e-02f, 1.25293499e-02f, -9.07927193e-03f, -7.05489293e-02f, 7.32670873e-02f, 7.73668215e-02f, 8.86372402e-02f,
  -2.64565437e-03f, 8.71547163e-02f, 3.24847549e-02f, 1.22608114e-02f, -7.36388788e-02f, -9.73950550e-02f, 4.25792328e-04f, -8.58462229e-03f, 4.12757695e-02f, -2.46976018e-02f,
  7.08606886e-03f, 7.69006647e-03f, 4.30200845e-02f, 2.13508750e-03f, -2.87473388e-02f, -1.91580819e-03f, -8.28883275e-02f, -1.10499002e-01f, -1.88802797e-02f, -1.88331261e-01f,
  -2.99375445e-01f, 2.77893752e-01f, 2.06640065e-01f, 1.79912835e-01f, 4.16762978e-01f, 2.08058491e-01f, 1.82619303e-01f, 1.78301726e-02f, 1.36148944e-01f, 1.74263984e-01f,
  2.86090225e-01f, -1.67918317e-02f, 8.48704726e-02f, -4.96576466e-02f, -4.53270450e-02f, 1.75679922e-01f, 2.13116884e-01f, -1.31648958e-01f, -1.81510910e-01f, -5.79096898e-02f,
  8.65737647e-02f, 5.99194691e-02f, -1.49572387e-01f, -1.01384344e-02f, 2.57917643e-01f, 1.44429997e-01f, 2.74672747e-01f, 3.29892784e-01f, 1.95256889e-01f, 3.22529554e-01f,
  1.84107319e-01f, 2.44422078e-01f, 2.67034788e-02f, 1.70089871e-01f, 2.25090712e-01f, 8.52681771e-02f, 9.16279629e-02f, 1.70906797e-01f, 1.78779706e-01f, 9.82647613e-02f,
  2.26948932e-01f, 2.17464015e-01f, 1.98354483e-01f, 2.56230742e-01f, 1.63221821e-01f, 1.18055537e-01f, 1.46083981e-01f, 7.65497759e-02f, 3.77534963e-02f, 1.99074373e-01f,
  2.68635839e-01f, 1.96336851e-01f, 1.05574213e-01f, 9.46669877e-02f, 2.26694152e-01f, 1.85001031e-01f, 2.16832027e-01f, 1.24613643e-01f, 1.31602228e-01f, 1.17550217e-01f,
  -1.22416824e-01f, -1.24077037e-01f, -1.16300561e-01f, -1.54374480e-01f, -1.07880779e-01f, -6.37450069e-02f, -1.32340312e-01f, -9.57635641e-02f, -9.99454334e-02f, -1.23637162e-01f,
  -1.23430513e-01f, -1.66019067e-01f, -1.64613649e-01f, -1.62146285e-01f, -1.18451402e-01f, -8.72597173e-02f, -1.15150623e-01f, -1.68616563e-01f, -9.55033749e-02f, -1.66903600e-01f,
  -1.14254035e-01f, -1.84011206e-01f, -1.25264928e-01f, -1.70331836e-01f, -1.43395022e-01f, -1.32535011e-01f, -1.59076437e-01f, -2.22554997e-01f, -1.82585686e-01f, -1.21030085e-01f,
  -1.10762604e-01f, 6.40105754e-02f, 7.44486004e-02f, 6.57291412e-02f, 1.68683633e-01f, 1.50516912e-01f, 1.66658431e-01f, 1.54195085e-01f, 2.18655586e-01f, 1.25913396e-01f,
  1.80611432e-01f, 1.14215046e-01f, 1.33205101e-01f, 1.06973886e-01f, 8.33495781e-02f, 1.02265030e-01f, 2.18104959e-01f, 1.39287487e-01f, 5.85310683e-02f, 1.61322907e-01f,
  1.84980094e-01f, -4.01063561e-02f, -9.15690046e-03f, 3.44905518e-02f, 1.15715042e-01f, -5.04902489e-02f, 1.17532432e-01f, 7.31395334e-02f, 3.06172594e-02f, -8.29570591e-02f,
  -4.29660290e-01f, 2.96153247e-01f, 7.28449523e-02f, -6.38062283e-02f, -1.11266479e-01f, -6.82748202e-03f, -4.47693989e-02f, -8.39815438e-02f, -1.40622752e-02f, 1.12888306e-01f,
  -9.07363892e-02f, -1.77928507e-01f, -6.02280311e-02f, -7.68575817e-02f, -6.80667982e-02f, 3.21872711e-01f, 3.55224103e-01f, -9.06489883e-03f, -3.14327866e-01f, -1.76838681e-01f,
  7.85575621e-03f, 3.87194604e-02f, -4.46085297e-02f, -2.40633953e-02f, 2.22158179e-01f, -4.81822938e-02f, 2.70005435e-01f, 1.42709687e-01f, 1.03041016e-01f, 3.55241299e-01f,
  -2.16082796e-01f, -1.29272342e-01f, -1.63354054e-01f, -1.00146145e-01f, -8.80326480e-02f, -7.20070973e-02f, -7.99026191e-02f, -3.41289700e-03f, 4.11073864e-03f, 8.68394971e-03f,
  -3.05154119e-02f, -2.87094936e-02f, -6.33945987e-02f, -6.86056120e-03f, -1.33119538e-01f, -8.58426616e-02f, 1.15373004e-02f, 1.15102967e-02f, -4.63205315e-02f, -4.51100767e-02f,
  -2.35498864e-02f, -1.14248067e-01f, -1.18932329e-01f, -9.46960039e-03f, -7.70505965e-02f, -1.22092672e-01f, -1.27982765e-01f, -5.79133183e-02f, -1.49679735e-01f, -2.79188305e-02f,
  1.67453452e-03f, 2.37304866e-02f, 3.68325040e-02f, 8.47395286e-02f, 5.65077625e-02f, 1.04084797e-01f, 7.35220462e-02f, 1.44090923e-02f, -1.41115338e-02f, 3.45201790e-02f,
  -1.60469078e-02f, 1.51115647e-02f, -5.18014003e-03f, 2.65258700e-02f, 8.65264833e-02f, 4.08243202e-02f, 5.94050027e-02f, 8.96141529e-02f, 7.44979009e-02f, 3.45678665e-02f,
  -5.53520732e-02f, -4.33397777e-02f, 4.18194346e-02f, 6.97122961e-02f, 7.66875669e-02f, 5.16058616e-02f, 4.25048582e-02f, 3.15270536e-02f, 1.40109779e-02f, 6.48398278e-03f,
  -1.25194654e-01f, -9.29969624e-02f, -1.93745755e-02f, -1.51084274e-01f, -4.59617376e-02f, 4.86972816e-02f, -9.56344511e-03f, -4.50795777e-02f, -7.90509209e-02f, -6.32199412e-03f,
  -1.17729940e-01f, -8.23807046e-02f, 1.09264217e-01f, -7.92688504e-03f, -1.40987068e-01f, -7.52573386e-02f, 1.92092042e-02f, -1.72571391e-02f, 1.05409687e-02f, -7.73914382e-02f,
  1.57781169e-01f, -1.11850239e-01f, -1.26572043e-01f, -1.19924940e-01f, -4.50926721e-02f, -1.18333735e-01f, -9.09101442e-02f, -1.06008969e-01f, -1.18625522e-01f, 1.31839896e-02f,
  1.59967884e-01f, -2.56995976e-01f, -1.07262567e-01f, 8.66098981e-03f, 3.26420516e-02f, -8.95768106e-02f, -3.08649421e-01f, -1.38525844e-01f, 3.85211743e-02f, 8.10187384e-02f,
  1.79240420e-01f, 3.26684982e-01f, 2.56872326e-01f, 2.75407046e-01f, 8.90359730e-02f, -2.41717771e-01f, -2.25158408e-01f, 1.10375002e-01f, 4.69260179e-02f, 9.53290910e-02f,
  1.37461409e-01f, 9.11283940e-02f, 1.09709064e-02f, 7.30998144e-02f, -1.32842779e-01f, 6.86526448e-02f, -1.46427304e-01f, -8.43622386e-02f, -4.63784561e-02f, -6.14721403e-02f,
  9.88714993e-02f, -3.92164066e-02f, 2.42817447e-01f, 2.19528973e-01f, 2.27439016e-01f, 1.62343577e-01f, 4.23201993e-02f, 1.99129239e-01f, 2.10899606e-01f, 7.88784772e-02f,
  1.78478181e-01f, 1.63071066e-01f, 1.91623047e-01f, 2.03991830e-01f, 3.42416987e-02f, 1.51586801e-01f, 5.04756607e-02f, 5.35730310e-02f, 3.53090540e-02f, 1.41775101e-01f,
  1.59691557e-01f, 1.38405368e-01f, 1.20740347e-01f, 8.71163979e-02f, 3.52115706e-02f, 2.75672197e-01f, 8.29951018e-02f, 1.17349893e-01f, 1.66906342e-02f, -1.44173175e-01f,
  -2.15468537e-02f, 4.24330644e-02f, 2.75457185e-02f, -1.04355507e-01f, -7.30024651e-02f, -6.82887957e-02f, -8.00901502e-02f, -3.34280021e-02f, -8.46905708e-02f, -5.23366518e-02f,
  -1.11478884e-02f, -7.34782368e-02f, -3.17687392e-02f, -9.32955518e-02f, -5.63156232e-02f, -6.13564998e-02f, -4.76941280e-02f, -7.14580044e-02f, -1.37215694e-02f, -7.21367821e-02f,
  5.41539341e-02f, -3.54092531e-02f, -1.08956367e-01f, -3.23974192e-02f, -9.78214517e-02f, 5.04711131e-03f, 8.71649198e-03f, 5.53957671e-02f, -2.42404193e-02f, -7.57422894e-02f,
  7.85785764e-02f, 2.38439664e-01f, 4.16955575e-02f, 1.06814913e-01f, 1.45149320e-01f, 9.97454152e-02f, 1.45691738e-01f, 1.03367329e-01f, 1.43794134e-01f, -3.26095261e-02f,
  1.52728572e-01f, 1.07145600e-01f, 9.86202527e-03f, 9.34946090e-02f, 1.27679884e-01f, 9.64872018e-02f, 8.64842162e-02f, 5.52287176e-02f, 1.67759702e-01f, 5.60456067e-02f,
  9.63619649e-02f, 2.91754864e-02f, 3.87461782e-02f, -9.43051837e-03f, 5.61009645e-02f, 1.61968842e-01f, -2.44876221e-02f, 9.95406061e-02f, -1.06276032e-02f, -1.03376761e-01f,
  -2.90705472e-01f, 1.19697846e-01f, 2.14047022e-02f, 2.03817248e-01f, 1.58326268e-01f, -1.91467136e-01f, -5.02025671e-02f, 2.46608742e-02f, 1.35812797e-02f, 9.69584882e-02f,
  2.16705631e-02f, -7.92709664e-02f, -9.50858593e-02f, -1.08270250e-01f, -2.16941535e-01f, 9.52804554e-03f, 1.57949552e-01f, -2.29137227e-01f, -3.52643073e-01f, -4.95012254e-02f,
  2.98488904e-02f, 1.30903810e-01f, -1.33562490e-01f, 4.40887362e-02f, 2.72535443e-01f, 7.58167133e-02f, 1.36559665e-01f, 8.38692114e-02f, 7.87826255e-02f, 3.35227460e-01f,
  2.53413804e-02f, 1.10767938e-01f, -1.54862642e-01f, -1.25966281e-01f, -7.52799539e-03f, -9.67674926e-02f, -1.21317662e-01f, 3.95107865e-02f, -7.77053759e-02f, -1.41704371e-02f,
  -2.66597071e-03f, -2.75802296e-02f, 8.78365412e-02f, 6.44939169e-02f, 2.30410248e-02f, -5.70943803e-02f, 7.40939006e-02f, 7.18452632e-02f, -1.20372601e-01f, -5.08599877e-02f,
  3.91288809e-02f, -2.40097251e-02f, -8.71120095e-02f, -3.28952223e-02f, -8.53678808e-02f, -2.85934415e-02f, -2.57284027e-02f, -6.60618097e-02f, -1.82757661e-01f, 1.19832987e-02f,
  -1.36149555e-01f, 4.72800015e-03f, 3.73221142e-03f, 1.04504153e-01f, 2.83316504e-02f, 8.30219984e-02f, 9.54838842e-02f, 5.17749153e-02f, -4.11484241e-02f, 1.46389171e-01f,
  6.84778914e-02f, 3.41004580e-02f, -2.83032116e-02f, 7.01228753e-02f, 9.58756879e-02f, 1.21818110e-01f, 3.44128385e-02f, 8.87143984e-02f, 6.04179054e-02f, 1.76226243e-01f,
  6.84301853e-02f, -1.10493386e-02f, 7.02076033e-02f, 6.51052967e-02f, 7.39194006e-02f, 3.48647125e-02f, 1.11923523e-01f, 8.25394643e-04f, 9.80039984e-02f, 5.76309562e-02f,
  -1.82897523e-01f, -2.83053905e-01f, 4.66957800e-02f, -3.15622799e-02f, -2.32753865e-02f, -3.82833295e-02f, -2.92599183e-02f, -2.41448823e-02f, -5.98648302e-02f, -6.53028563e-02f,
  -1.33537814e-01f, -6.86057284e-02f, -6.97893351e-02f, -4.04356867e-02f, -8.15748796e-02f, -4.08274233e-02f, -6.09712489e-02f, -6.63566515e-02f, -3.85998078e-02f, 1.85099412e-02f,
  -8.02985802e-02f, -1.60289705e-01f, -1.90232471e-01f, -1.19754538e-01f, -6.84230849e-02f, -3.10399294e-01f, -1.72668487e-01f, -8.88843089e-02f, -3.39736879e-01f, -9.33592096e-02f,
  -2.69725323e-01f, 3.54147464e-01f, -2.61189397e-02f, 6.66946471e-02f, 2.92510122e-01f, 3.36295605e-01f, 3.16631228e-01f, 2.47164667e-01f, 8.34842548e-02f, 8.93583223e-02f,
  1.96823478e-01f, -4.93591744e-03f, -1.03311822e-01f, -1.47885665e-01f, -7.88762942e-02f, 2.72404905e-02f, 1.00131646e-01f, -3.29057604e-01f, -2.11839005e-01f, 8.96140561e-02f,
  1.78832076e-02f, 7.11806715e-02f, -1.78376094e-01f, -1.15728021e-01f, 3.11079919e-02f, -1.68283194e-01f, -3.47606055e-02f, -1.87249091e-02f, -3.49825099e-02f, -1.58684984e-01f,
  -2.32698739e-01f, 7.13871792e-02f, -5.15137203e-02f, 4.96287830e-02f, 6.35613576e-02f, -8.99383947e-02f, 1.78954825e-02f, -2.42683827e-03f, 4.10934128e-02f, 9.05584693e-02f,
  2.78955121e-02f, 4.90037836e-02f, 1.01876315e-02f, 8.78471509e-03f, 1.16926618e-01f, 3.21661532e-02f, -2.06675436e-02f, -3.25394198e-02f, -7.32135624e-02f, -3.47455814e-02f,
  8.27807114e-02f, 4.33217697e-02f, 4.55089658e-02f, 7.62451142e-02f, 3.20897251e-02f, 2.47299038e-02f, 1.83790736e-02f, -1.34475604e-01f, -1.08430358e-02f, -5.04435673e-02f,
  -8.26234892e-02f, 1.35859484e-02f, -4.94434461e-02f, 9.13596004e-02f, -5.10771945e-02f, -2.79849675e-02f, -3.01399436e-02f, -1.41219068e-02f, -9.66621116e-02f, -2.05937438e-02f,
  -2.65742224e-02f, -2.22325195e-02f, -3.35682109e-02f, -1.02302581e-01f, -1.11266643e-01f, -3.49416956e-02f, -1.35378260e-02f, -8.46205950e-02f, -9.50536579e-02f, -2.21983213e-02f,
  -1.19423561e-01f, -1.88059546e-02f, -8.46458077e-02f, -1.33637443e-01f, -8.15654080e-03f, -6.88586682e-02f, -1.49142640e-02f, -2.76669562e-02f, -5.91575429e-02f, 9.12391767e-02f,
  -1.17334291e-01f, 2.15215951e-01f, -7.09177032e-02f, -1.39287889e-01f, 2.36356072e-02f, -8.32840279e-02f, 6.50846735e-02f, -2.75394749e-02f, 8.16690922e-02f, 1.46831628e-02f,
  7.47414157e-02f, -1.75597100e-03f, -2.67389268e-02f, 3.38857844e-02f, 5.45523949e-02f, 9.97606516e-02f, 6.35163067e-03f, -5.99803738e-02f, 3.44038308e-02f, 1.11530147e-01f,
  1.02499448e-01f, 6.63972553e-03f, -1.39318705e-01f, 1.58897217e-03f, 4.09395099e-02f, -9.05987993e-02f, -1.71910450e-02f, -2.58627012e-02f, -6.07984886e-02f, -5.46589345e-02f,
  -8.46968666e-02f, -3.93582195e-01f, -1.23283438e-01f, 1.17087804e-01f, -1.01687305e-01f, -2.16845311e-02f, -4.99761179e-02f, 1.18266799e-01f, 2.90068060e-01f, -2.99656447e-02f,
  -4.41543967e-01f, -3.19520473e-01f, -7.01002106e-02f, -8.49220827e-02f, 1.00585513e-01f, 2.00087205e-01f, 2.47322515e-01f, 2.37562463e-01f, 1.18277758e-01f, 6.53684419e-03f,
  8.60752463e-02f, 1.01895414e-01f, 2.12731302e-01f, 1.75894290e-01f, 5.79369217e-02f, 4.86391224e-03f, 8.20753872e-02f, -1.42438114e-01f, -1.34103954e-01f, 9.48069170e-02f,
  -4.22557026e-01f, -3.68936837e-01f, 1.05037220e-01f, -7.17544481e-02f, -1.11965097e-01f, 8.62411559e-02f, -1.08122498e-01f, 2.68311501e-02f, -3.09797041e-02f, 6.89415932e-02f,
  -1.32643804e-01f, -8.36953595e-02f, -5.62562644e-02f, -6.18772432e-02f, 3.46938968e-02f, -2.90226918e-02f, 1.25062138e-01f, 3.81462909e-02f, 2.01160032e-02f, -1.05231375e-01f,
  -1.24085806e-01f, -2.95993268e-01f, -1.75954282e-01f, 7.02514453e-03f, -6.49001002e-02f, -1.57751478e-02f, -1.05698198e-01f, -2.11133938e-02f, 2.65037897e-03f, 9.94915068e-02f,
  1.28172862e-04f, 4.95966291e-03f, 4.78259064e-02f, -2.11830586e-02f, 1.02657892e-01f, 7.57693425e-02f, 3.17975692e-02f, 1.04449438e-02f, 9.25618932e-02f, 7.21133128e-02f,
  7.76338810e-03f, 2.85500996e-02f, 4.00657989e-02f, 6.40391409e-02f, 3.80037166e-02f, -3.48991826e-02f, -4.19549346e-02f, 4.47306670e-02f, 2.29527336e-02f, 3.82221825e-02f,
  -1.23845041e-01f, 7.62313977e-02f, 3.94235067e-02f, 4.20504846e-02f, -6.25420734e-02f, 4.47027199e-02f, -3.66955204e-03f, -3.45198624e-02f, 5.14240609e-03f, -4.14537825e-02f,
  1.42607152e-01f, -1.36681750e-01f, -8.39896128e-02f, 5.58112822e-02f, 4.99163801e-03f, -1.37044936e-02f, -9.05457735e-02f, -3.55997831e-02f, -7.90150389e-02f, -8.94687995e-02f,
  -8.76266360e-02f, 4.38155942e-02f, -1.61006283e-02f, 9.42499489e-02f, 4.42161039e-02f, 4.55389963e-03f, 2.17586197e-02f, -4.68713008e-02f, 6.30568936e-02f, 4.65004630e-02f,
  1.36875540e-01f, 2.25320389e-03f, -2.37688050e-02f, 2.79486459e-02f, 1.14536090e-02f, 3.08705512e-02f, -2.90144626e-02f, -1.39725851e-02f, -8.91399309e-02f, 2.11643040e-01f,
  -6.75779879e-02f, 1.98671624e-01f, 4.81294602e-01f, 1.04136914e-01f, -1.93725824e-02f, -6.59071282e-02f, -5.76526634e-02f, -1.48763672e-01f, 1.53111457e-03f, 6.55878410e-02f,
  6.05221577e-02f, -1.48559138e-01f, 2.12976560e-01f, 1.44930050e-01f, 1.50021866e-01f, 2.72008121e-01f, 4.92247403e-01f, 3.97987753e-01f, 3.55143957e-02f, -2.14636534e-01f,
  -1.52149484e-01f, 2.35578846e-02f, 1.13000348e-01f, 8.18166956e-02f, 5.59379943e-02f, -3.29401903e-02f, 2.18567908e-01f, 1.42518550e-01f, 1.68999866e-01f, 3.46822798e-01f,
  2.57820457e-01f, -3.73143591e-02f, -1.75524577e-01f, -1.10965282e-01f, 7.28525082e-03f, -2.05423962e-02f, -1.36525556e-01f, -1.03666270e-02f, -9.30727497e-02f, -3.38963382e-02f,
  2.83474848e-02f, -4.40801606e-02f, -3.50731462e-02f, 1.55974412e-02f, -8.53665695e-02f, -7.66342133e-02f, 1.76901254e-03f, 1.15021326e-01f, 1.12671650e-03f, 5.45830503e-02f,
  -6.34343624e-02f, 5.37064997e-03f, -5.02483323e-02f, -7.01322556e-02f, 7.49816969e-02f, 3.46796289e-02f, -1.09936610e-01f, -2.60756090e-02f, 3.27694491e-02f, -1.01079620e-01f,
  -7.83094838e-02f, 5.01256250e-02f, 6.34514764e-02f, 1.32311163e-02f, -3.66322957e-02f, -3.96228805e-02f, 3.09685003e-02f, -1.50104097e-04f, 8.48727580e-03f, -1.57327428e-02f,
  -6.03352673e-02f, 3.39282490e-02f, -1.20055592e-02f, 2.35485863e-02f, -1.39944702e-02f, 5.84802851e-02f, -1.39635146e-01f, 7.21698925e-02f, -4.08366043e-03f, -1.74792670e-02f,
  -1.17076449e-02f, 3.73581313e-02f, -2.26679444e-02f, -1.17196500e-01f, 6.03637733e-02f, 3.59640308e-02f, 8.19546580e-02f, -3.23167555e-02f, 1.21612102e-02f, 6.93362951e-02f,
  -3.90703648e-01f, -4.20041978e-02f, -1.68762002e-02f, -8.97816122e-02f, -7.42128044e-02f, -2.12841313e-02f, -7.67237097e-02f, -9.68458056e-02f, -1.26297385e-01f, -8.41220543e-02f,
  -1.13469429e-01f, -9.04084146e-02f, -1.48608079e-02f, -3.70835103e-02f, -1.62856683e-01f, -7.05631003e-02f, -7.50116184e-02f, 4.81406935e-02f, -2.42830627e-02f, -6.09579235e-02f,
  -3.78373154e-02f, -9.13817883e-02f, -8.63823518e-02f, -5.02707958e-02f, -1.87065631e-01f, -1.46209151e-01f, -1.52471796e-01f, -2.07898900e-01f, -8.33732709e-02f, -2.48477101e-01f,
  1.40540153e-01f, -2.37213463e-01f, -4.42176789e-01f, 1.60308167e-01f, -4.22191918e-02f, -1.97121724e-01f, -3.95681351e-01f, -6.47391155e-02f, 1.59369618e-01f, -1.88491747e-01f,
  5.01330569e-02f, 3.37319732e-01f, 9.12939832e-02f, 3.54130454e-02f, -7.86866695e-02f, -2.97388971e-01f, -3.53212833e-01f, -2.57411659e-01f, 4.05872352e-02f, 1.90483987e-01f,
  1.68722808e-01f, 1.93935975e-01f, 1.74763590e-01f, 8.41151476e-02f, -8.03456008e-02f, 8.08293149e-02f, -2.53097564e-01f, -4.77573574e-02f, -1.12812310e-01f, -2.54084051e-01f,
  -3.15139294e-01f, -3.89619134e-02f, 2.21366137e-02f, 2.56178588e-01f, 2.57997913e-03f, 7.13604093e-02f, -1.00255841e-02f, 1.28318584e-02f, 3.42187434e-02f, -7.12196231e-02f,
  2.32952964e-02f, 5.41324802e-02f, -1.18131004e-02f, 7.20529258e-02f, -4.40437309e-02f, 1.84893906e-02f, 7.65627017e-03f, -1.15250014e-01f, -5.70715107e-02f, -3.37109417e-02f,
  3.21769826e-02f, -3.79453525e-02f, -1.31883755e-01f, -8.75423178e-02f, -8.60505365e-03f, 1.71030182e-02f, -1.79159611e-01f, 2.38864180e-02f, -1.57098830e-01f, -5.15269153e-02f,
  3.42580974e-02f, 3.24784815e-02f, 4.79063801e-02f, 4.46058623e-02f, -4.15750444e-02f, 7.53967557e-03f, -5.94486073e-02f, 7.54911732e-03f, 1.80626493e-02f, -1.00298750e-03f,
  -5.09995110e-02f, 8.12914874e-03f, -1.74385365e-02f, -2.37941276e-03f, 5.85477240e-02f, -2.62633767e-02f, -2.46034805e-02f, 3.62230800e-02f, 4.22988050e-02f, 1.80596877e-02f,
  -1.96893364e-02f, -1.62718613e-02f, 1.93622541e-02f, -1.48604019e-02f, -2.54631694e-02f, -9.87559482e-02f, -3.23147490e-03f, -2.28205211e-02f, 1.25162929e-01f, 2.02522185e-02f,
  1.09304689e-01f, 5.03830984e-03f, 2.96396832e-03f, -5.78975724e-03f, 2.22133100e-02f, 9.55379233e-02f, 1.10522322e-02f, 4.94353026e-02f, -6.02997746e-03f, 9.09368601e-03f,
  -4.70191706e-03f, -3.41590270e-02f, -5.80002591e-02f, -3.51273306e-02f, 1.01847127e-02f, 4.11448143e-02f, 1.89548377e-02f, -7.42948381e-03f, 2.17588563e-02f, 8.18327293e-02f,
  7.33048022e-02f, -7.68379942e-02f, -8.41351971e-02f, -8.24855268e-02f, -2.99798343e-02f, 9.02156811e-03f, -7.66128972e-02f, -7.53369108e-02f, -8.83049890e-02f, -1.39179006e-01f,
  4.46194410e-01f, -3.30191106e-01f, 4.10148680e-01f, -1.33118359e-02f, -1.78934962e-01f, 6.83868900e-02f, 6.80500716e-02f, 1.43594041e-01f, -6.27415180e-02f, -2.86677498e-02f,
  -2.08256409e-01f, -1.39480039e-01f, -2.37900838e-02f, 1.06619991e-01f, 2.56097198e-01f, 2.19950035e-01f, 1.75265938e-01f, 4.58127320e-01f, 3.19003940e-01f, 1.49200559e-01f,
  -1.99100450e-01f, -3.50830667e-02f, 2.11751565e-01f, 1.48888022e-01f, -2.08691344e-01f, -2.32134447e-01f, -3.26017030e-02f, -1.32996455e-01f, -5.03345653e-02f, -1.01164006e-01f,
  5.18724434e-02f, 2.10546583e-01f, 5.12088612e-02f, 2.17744075e-02f, -5.74332923e-02f, 1.30154610e-01f, 4.04260382e-02f, 1.12567998e-01f, 4.31639738e-02f, 7.60260820e-02f,
  -2.73038149e-02f, 9.82186571e-02f, -1.17878811e-02f, -1.85252856e-02f, 8.89892280e-02f, 6.71066344e-02f, 3.02522443e-02f, 2.04750136e-01f, 2.11257964e-01f, 5.87347485e-02f,
  -1.60616711e-01f, 1.18190214e-01f, 2.52308458e-01f, 3.07478458e-02f, 3.99221219e-02f, 1.38391942e-01f, 4.04246971e-02f, 9.32355151e-02f, 7.55982175e-02f, 6.52114227e-02f,
  -1.09006509e-01f, -2.44250009e-03f, -1.55426480e-03f, -3.81467789e-02f, -8.10655430e-02f, -5.94860688e-02f, 4.79542837e-02f, -1.14811108e-01f, 3.14356014e-02f, -2.92807017e-02f,
  2.67848093e-02f, -9.17751808e-03f, 4.70523201e-02f, 5.45332618e-02f, 1.63767906e-03f, 1.43333925e-02f, 7.58317560e-02f, -4.61147516e-04f, 4.41619977e-02f, 1.50264511e-02f,
  5.69963083e-02f, -2.20251922e-02f, -6.04064297e-03f, -3.14492323e-02f, 5.37769459e-02f, 1.11688688e-01f, -2.53969952e-02f, -1.00110389e-01f, -8.57651234e-02f, 6.36358336e-02f,
  -1.47986233e-01f, 1.75464392e-01f, -1.79253276e-02f, -6.52262121e-02f, -1.93404723e-02f, 1.57079473e-02f, -5.70656434e-02f, 1.51858488e-02f, -3.56735960e-02f, 5.18841222e-02f,
  -6.37341142e-02f, 6.02068156e-02f, 6.77251890e-02f, -6.29363675e-03f, 6.04119226e-02f, 3.09111811e-02f, 1.64687727e-02f, -9.37434938e-03f, 2.59855669e-02f, -2.88458727e-02f,
  -6.12429306e-02f, 4.88759093e-02f, 8.71925056e-02f, 6.85514361e-02f, -4.03841734e-02f, 1.40586495e-01f, 5.32843433e-02f, -1.35142962e-03f, 1.92046821e-01f, -8.81506279e-02f,
  2.32039452e-01f, 1.49078459e-01f, 1.45035416e-01f, 1.65348202e-01f, 1.81181982e-01f, 2.94940472e-01f, 3.94839138e-01f, 1.06578454e-01f, 1.43695712e-01f, 5.04850261e-02f,
  2.98897345e-02f, -1.14911646e-01f, 1.19456006e-02f, 5.49329259e-02f, 1.48645788e-01f, 1.99766517e-01f, 2.22517118e-01f, 7.08971173e-02f, 1.06619924e-01f, 9.21303257e-02f,
  6.41361922e-02f, 1.05523422e-01f, -2.93517206e-02f, -3.23746614e-02f, -8.84449109e-02f, -6.08364753e-02f, 1.92330368e-02f, -1.46882668e-01f, -8.49313512e-02f, -1.04583308e-01f,
  -1.99426979e-01f, -1.23929098e-01f, 7.17076808e-02f, 1.15301684e-01f, -3.55743393e-02f, 2.29246784e-02f, 8.71183202e-02f, 2.17094813e-02f, 2.72226948e-02f, 9.59693789e-02f,
  -9.38301720e-03f, -2.25849077e-03f, 6.84221014e-02f, 7.00071231e-02f, 8.49293545e-02f, -2.20082072e-03f, 8.65062922e-02f, 5.03542721e-02f, 1.05643757e-01f, -7.69503713e-02f,
  1.71734384e-04f, 6.91742525e-02f, 1.38863981e-01f, 3.53364111e-03f, -5.46483099e-02f, 1.20357871e-01f, 2.98716221e-02f, -6.74605891e-02f, 4.50849812e-03f, 8.98333192e-02f,
  -1.33614048e-01f, 4.43982892e-03f, 4.78461273e-02f, 6.18341155e-02f, 5.29083237e-02f, -4.25376967e-02f, 3.12903449e-02f, -3.03521380e-03f, 1.79150663e-02f, -6.46575019e-02f,
  1.30699240e-02f, -1.04420520e-01f, -6.43285215e-02f, 7.06631970e-03f, -7.62279481e-02f, -2.31940001e-02f, -8.58032703e-03f, -2.63299178e-02f, -4.65572961e-02f, 1.90861709e-03f,
  -7.00643882e-02f, 2.33259145e-02f, -5.33072315e-02f, -5.56511395e-02f, -4.75286879e-02f, -4.26866189e-02f, 5.38265929e-02f, -1.85045339e-02f, -6.32740259e-02f, 1.18697081e-02f,
  6.14235103e-02f, 2.21309543e-01f, 1.42525539e-01f, 1.06458724e-01f, 7.19536617e-02f, 4.84426953e-02f, 3.00106760e-02f, 1.23921394e-01f, 5.79723157e-02f, 1.23387109e-03f,
  1.93190519e-02f, 1.26522735e-01f, 3.52201164e-02f, 1.57937277e-02f, 8.17455500e-02f, 5.06600440e-02f, 2.22059190e-01f, 1.60118431e-01f, 9.27372500e-02f, 8.82587358e-02f,
  1.74782887e-01f, 2.80137181e-01f, 1.87110648e-01f, 1.80256128e-01f, 1.15707330e-01f, 1.45115852e-01f, 1.56343088e-01f, 2.87833456e-02f, 1.54005930e-01f, 3.10426235e-01f,
  -3.43720049e-01f, -1.52231574e-01f, 4.52403724e-01f, 1.74074113e-01f, 1.82601482e-01f, 3.04892492e-02f, -1.85675234e-01f, -4.03682515e-02f, 1.76264092e-01f, 1.78789292e-02f,
  -1.10029094e-01f, -1.04973637e-01f, -5.36723919e-02f, -9.49712694e-02f, -1.41630501e-01f, 5.17648831e-02f, 2.58811563e-01f, 8.01382363e-02f, -1.43376276e-01f, -2.68214315e-01f,
  -9.79331061e-02f, -2.17613894e-02f, -7.90967271e-02f, 1.65765341e-02f, 1.72161430e-01f, 1.07248902e-01f, 2.31974825e-01f, 3.35491151e-02f, -8.54734853e-02f, 8.44532177e-02f,
  5.80253042e-02f, -1.57578349e-01f, 8.77102539e-02f, -1.30231082e-01f, 2.78786495e-02f, -3.35834660e-02f, -3.99254728e-03f, 2.24255212e-02f, 1.13080293e-02f, 5.75742126e-02f,
  7.57679865e-02f, -5.38532026e-02f, -4.12047580e-02f, -7.29720108e-03f, -5.10577485e-03f, -3.08175329e-02f, -2.14874372e-03f, 1.05072208e-01f, 1.17728077e-01f, -3.67642567e-02f,
  -1.13150001e-01f, 2.21747309e-02f, 2.63779163e-02f, 1.27690896e-01f, -2.33268756e-02f, 7.73098245e-02f, -2.85936762e-02f, -6.60042092e-02f, 4.80292700e-02f, 1.29352555e-01f,
  2.30981559e-02f, -1.92149170e-03f, 1.32285962e-02f, 1.56922825e-02f, -6.51967824e-02f, 5.46743348e-02f, 1.05443960e-02f, -6.53227046e-02f, -8.19771271e-03f, -2.39111148e-02f,
  -5.03573269e-02f, 1.32223610e-02f, 4.99363132e-02f, -1.34715378e-01f, -1.99684221e-02f, -4.01900448e-02f, -5.93480133e-02f, -7.21391737e-02f, 3.42702493e-02f, -3.65700908e-02f,
  4.67062369e-03f, 7.54996166e-02f, 3.54819708e-02f, -7.21300778e-04f, -1.31782442e-01f, 6.63286969e-02f, -6.97722659e-02f, -8.68321657e-02f, 1.27638935e-03f, -4.87498306e-02f,
  1.04463831e-01f, -3.31957415e-02f, 8.08544178e-03f, -1.65122375e-02f, 6.96900720e-03f, 3.55579108e-02f, 6.92126602e-02f, 7.20190182e-02f, 3.35428305e-02f, -1.74936000e-02f,
  -9.43106711e-02f, -4.21339273e-02f, 3.95130329e-02f, -6.39506206e-02f, 4.91410643e-02f, 4.25790995e-02f, 6.02062000e-03f, 1.23521402e-01f, 2.32069418e-02f, 8.82176533e-02f,
  1.06884062e-01f, 7.83981010e-02f, -5.03462963e-02f, 1.65705666e-01f, 3.82555127e-02f, -3.72916609e-02f, 2.37377398e-02f, 1.30523488e-01f, 6.73542097e-02f, 2.49431562e-02f,
  -8.68630130e-03f, -1.36297837e-01f, -2.27485821e-01f, -4.19062302e-02f, 7.27998000e-03f, 1.15426376e-01f, 1.58566758e-02f, -3.88362892e-02f, 5.44429459e-02f, -1.15216494e-01f,
  -2.62649031e-03f, -1.07443631e-01f, -1.66830987e-01f, -1.23481095e-01f, -1.27317116e-01f, -4.53840643e-02f, -1.41293228e-01f, -2.04910994e-01f, -3.27848941e-02f, 6.84531825e-03f,
  2.67659388e-02f, -6.44095242e-02f, -8.92990828e-02f, 6.94097877e-02f, 7.62550086e-02f, 4.43021730e-02f, 1.92812737e-02f, 1.22240409e-01f, 5.64031899e-02f, 1.60454176e-02f,
  -1.16087824e-01f, 1.07911870e-01f, 1.05046839e-01f, 9.48778819e-03f, -3.31666097e-02f, 1.28979608e-01f, -1.89594384e-02f, 1.34002998e-01f, 7.55050406e-02f, 1.70681458e-02f,
  1.25451414e-02f, -4.55978513e-02f, 4.03490141e-02f, 5.26311919e-02f, -8.89888499e-04f, 1.21716991e-01f, -3.90124545e-02f, 7.89672062e-02f, -1.36723351e-02f, 7.52306283e-02f,
  7.01655075e-02f, 1.05080776e-01f, 1.40976608e-01f, -1.64535251e-02f, 1.24564596e-01f, 8.69577676e-02f, 1.97134614e-02f, 1.88649267e-01f, 8.41917247e-02f, 9.97030362e-02f,
  -1.00838132e-01f, -7.97100216e-02f, -5.06953262e-02f, -6.34611677e-03f, 7.15876929e-03f, 5.97779006e-02f, -6.05355464e-02f, -4.12475392e-02f, 3.77673693e-02f, -2.21096706e-02f,
  -1.16857246e-01f, -1.23459518e-01f, -1.16068147e-01f, 2.82178111e-02f, -1.42388836e-01f, 1.14456099e-02f, 4.99571376e-02f, -1.11780278e-01f, -6.10019341e-02f, 7.63227195e-02f,
  -5.32428212e-02f, -2.02373601e-03f, -6.64721876e-02f, -8.23245198e-02f, -6.00658730e-02f, -5.12236096e-02f, 9.64207854e-03f, -4.89521734e-02f, -5.62118143e-02f, -6.01735637e-02f,
  -1.30204916e-01f, 3.09188832e-02f, 4.55838926e-02f, 3.57332528e-02f, 1.26327783e-01f, 1.24533013e-01f, 8.56916010e-02f, 9.65075567e-02f, 1.34861380e-01f, 4.99309180e-03f,
  1.54367909e-01f, -4.01187800e-02f, -9.08398554e-02f, 1.27667384e-02f, -1.88850574e-02f, 1.66436344e-01f, -3.46175171e-02f, -1.32690510e-02f, 5.36789335e-02f, 1.29156187e-02f,
  7.30696619e-02f, 5.07597923e-02f, 1.80885512e-02f, 3.59861515e-02f, 5.85181490e-02f, -3.09778862e-02f, -4.75132652e-02f, 8.46240297e-02f, -5.97667089e-03f, 5.56797460e-02f,
  -3.47817279e-02f, 1.14276744e-01f, 1.96929678e-01f, -3.49313408e-01f, -2.99465001e-01f, 1.25819847e-01f, 3.07444066e-01f, 2.45801583e-01f, -1.21699147e-01f, -2.93484647e-02f,
  -1.96884960e-01f, -2.39862546e-01f, -8.00770894e-02f, 3.36675998e-03f, 3.62283647e-01f, 2.21612379e-01f, -5.24395369e-02f, 1.16641544e-01f, 2.21130356e-01f, 3.58238146e-02f,
  -1.69697419e-01f, -1.40619472e-01f, -6.87804967e-02f, -6.48305193e-02f, -2.38542646e-01f, -2.65124857e-01f, -1.28180891e-01f, -1.68062106e-01f, -2.96418667e-02f, -2.83474624e-01f,
  1.63446039e-01f, -3.80721763e-02f, 3.15020932e-03f, -1.35932937e-01f, -1.59316301e-01f, 1.24291675e-02f, 3.32515351e-02f, 3.77449021e-03f, 2.06940509e-02f, -2.42721066e-02f,
  -1.04897097e-01f, 4.81647514e-02f, -1.38439536e-01f, -6.10870570e-02f, -4.68211435e-02f, 7.82606974e-02f, 1.25453584e-02f, 7.82957822e-02f, 1.06065772e-01f, -3.56686476e-04f,
  -1.37030125e-01f, -1.99021250e-01f, 4.08893488e-02f, 4.52305041e-02f, 3.75214927e-02f, -1.75599515e-01f, -4.91949022e-02f, -5.80186173e-02f, 1.86014056e-01f, 2.23966446e-02f,
  -7.33633265e-02f, -4.45954911e-02f, -3.42122205e-02f, -7.00035924e-03f, 6.04205243e-02f, -1.00690953e-01f, -1.56305227e-02f, 4.80190180e-02f, -9.07927006e-02f, 8.25799033e-02f,
  2.32013036e-02f, 6.57445341e-02f, -2.32650861e-02f, 2.11533718e-02f, -5.65930689e-03f, -2.96168923e-02f, 9.70127713e-03f, 1.00274803e-02f, 4.76209931e-02f, 1.51457079e-02f,
  2.31254175e-02f, -9.97800939e-03f, -7.29699358e-02f, 1.15842588e-01f, -4.36121076e-02f, -6.19012862e-04f, -4.95420843e-02f, -1.63748097e-02f, -3.92401684e-03f, -1.07106000e-01f,
  1.02391616e-02f, -1.40345106e-02f, -1.56434402e-02f, 6.29521012e-02f, 3.04799881e-02f, 2.00425535e-02f, -1.07693642e-01f, 4.90090959e-02f, -1.70002338e-02f, 1.12823188e-01f,
  -4.73307259e-03f, -1.59534272e-02f, -8.27437639e-02f, 3.90599258e-02f, 3.85828502e-02f, 3.47343050e-02f, 7.90818483e-02f, 1.35717392e-02f, -2.39041764e-02f, -5.97459218e-03f,
  -8.77991319e-02f, 1.18526518e-01f, 1.62546441e-01f, 1.07879572e-01f, 2.44244142e-03f, 5.88698871e-03f, 1.64035380e-01f, 1.09340124e-01f, 1.64877310e-01f, 2.23258436e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.56709957e-01f, 1.63269386e-01f, -6.61212146e-01f, -6.71167552e-01f, 6.67561963e-02f, 4.50649977e-01f, 8.17854345e-01f, 3.95304292e-01f, -1.01303339e-01f, 1.08619303e-01f,
  2.29041688e-02f, -1.20811433e-01f, -1.18445881e-01f, 1.82174221e-01f, 4.20013219e-01f, 4.62313235e-01f, 1.79457217e-01f, -2.19999477e-01f, 1.09723024e-01f, 3.49674493e-01f,
  4.20331687e-01f, -2.16206595e-01f, -5.45154572e-01f, -2.27891758e-01f, -3.08897525e-01f, -3.82401161e-02f, -3.82921726e-01f, -2.30729043e-01f, 2.65872896e-01f, -1.28020227e-01f,
  -2.19121322e-01f, -6.21203542e-01f, 1.49144098e-01f, -1.82676941e-01f, -1.50950715e-01f, -9.76697281e-02f, 4.72930856e-02f, -2.99172223e-01f, -9.33217108e-02f, -1.39346197e-01f,
  -3.48836303e-01f, -1.35958120e-01f, -1.32180214e-01f, 4.31819409e-02f, -1.08440533e-01f, -2.10219815e-01f, -2.24450260e-01f, 5.00798598e-03f, -5.46938665e-02f, 8.40781257e-03f,
  4.14452165e-01f, -3.07407975e-02f, -2.62952387e-01f, 1.43898740e-01f, 7.88367987e-02f, -1.40702784e-01f, -2.15760022e-01f, -1.31059834e-03f, 7.49408267e-03f, -1.90842763e-01f,
  1.05754092e-01f, 8.87800977e-02f, 6.31141197e-03f, 8.18186924e-02f, 1.41529173e-01f, -4.90535609e-02f, 7.22379088e-02f, 1.13192417e-01f, 4.45359312e-02f, -1.79512143e-01f,
  -4.77973036e-02f, 6.14049621e-02f, 2.88216099e-02f, -6.78060129e-02f, -1.12625875e-01f, -7.82905743e-02f, 2.09057033e-01f, 4.83819954e-02f, 5.25010983e-03f, -5.73099852e-02f,
  1.95273887e-02f, -3.37700322e-02f, -1.96358427e-01f, 1.08055793e-01f, 5.01416139e-02f, -4.16987650e-02f, -9.79816690e-02f, 8.55598524e-02f, -1.18365519e-01f, 2.56592371e-02f,
  6.09748401e-02f, 1.51616737e-01f, 7.40191620e-03f, 4.58541512e-02f, -1.70120656e-01f, -1.23565458e-01f, -1.55817837e-01f, 2.30196547e-02f, -1.54697567e-01f, 4.77195047e-02f,
  7.93583542e-02f, -3.48882899e-02f, -6.19860813e-02f, 1.28717825e-01f, -2.61213090e-02f, -6.24482185e-02f, 1.78541049e-01f, 1.02095678e-01f, 1.88204557e-01f, -6.56924024e-02f,
  2.39154220e-01f, 2.28255123e-01f, 4.27502282e-02f, 1.70790255e-01f, 1.08331658e-01f, 2.89697144e-02f, -3.74181233e-02f, 2.31053561e-01f, 2.68019527e-01f, 3.28979224e-01f,
  -6.01141512e-01f, -2.37666339e-01f, 2.17983067e-01f, 1.43904164e-01f, 4.41571891e-01f, 3.36829484e-01f, 3.31021160e-01f, 9.93653089e-02f, 1.04675166e-01f, 6.53078258e-02f,
  1.29465520e-01f, 3.10745537e-01f, 3.91181409e-01f, 2.00995341e-01f, 1.96540177e-01f, 3.49965423e-01f, 3.87506872e-01f, 8.35192278e-02f, 1.90100685e-01f, 2.26824954e-01f,
  2.08657131e-01f, -1.70956016e-01f, -3.39972794e-01f, -1.08887672e-01f, 2.45428294e-01f, 4.23455983e-01f, 1.54718503e-01f, 1.35076687e-01f, 8.73175114e-02f, 2.17115447e-01f,
  3.44552428e-01f, -2.50201523e-01f, 1.17283575e-01f, -8.61910805e-02f, -1.67370617e-01f, -2.62372404e-01f, -4.24818657e-02f, -1.69564933e-01f, -7.13344291e-02f, -4.66191769e-02f,
  -6.24552928e-02f, -1.16365388e-01f, -9.57831740e-02f, -6.33891448e-02f, -6.19194172e-02f, -5.30148372e-02f, -2.27054074e-01f, -1.24923542e-01f, 6.76790178e-02f, 9.98368580e-03f,
  1.77065488e-02f, 3.18014510e-02f, 2.03805059e-01f, 1.09606028e-01f, 1.48863799e-03f, 6.61086291e-02f, 2.83249523e-02f, -6.23479038e-02f, 1.28545180e-01f, 4.84995320e-02f,
  3.21749777e-01f, 7.07455277e-02f, 7.01445853e-03f, 9.93989184e-02f, 1.79378372e-02f, -4.31215018e-02f, 1.22442573e-01f, 1.41977504e-01f, 8.39042813e-02f, 2.33361255e-02f,
  7.63252228e-02f, 1.60630494e-01f, 1.74776837e-02f, 3.57295200e-02f, 8.57198462e-02f, 5.60906157e-02f, 1.61360571e-04f, 2.41769981e-02f, 1.68711729e-02f, -2.52888259e-02f,
  2.23881248e-02f, 9.03118774e-02f, -1.13838471e-01f, 3.20810713e-02f, -1.37208495e-02f, 1.46023678e-02f, 6.73429891e-02f, 5.47425039e-02f, -6.61389716e-03f, -1.30024716e-01f,
  3.90607238e-01f, -6.26772195e-02f, 8.57518166e-02f, 3.74434167e-03f, -9.38737616e-02f, -2.10347027e-01f, -6.02953881e-02f, -1.59579977e-01f, -1.69950709e-01f, 5.29915653e-02f,
  2.32150443e-02f, -1.44921109e-01f, -1.96680710e-01f, -7.32991546e-02f, -2.65404675e-02f, 7.72053823e-02f, -1.13681287e-01f, 9.16742533e-02f, 7.82632977e-02f, 4.53815088e-02f,
  -4.50233258e-02f, 2.40918294e-01f, 2.51395762e-01f, 1.76139414e-01f, 9.63793173e-02f, 1.61638647e-01f, 9.15060490e-02f, 1.15657687e-01f, 6.42917007e-02f, 3.46817896e-02f,
  6.04591072e-01f, -5.96451908e-02f, 5.08989990e-02f, 2.32260421e-01f, -2.73531735e-01f, -4.76332903e-01f, -6.17215514e-01f, -2.00337544e-01f, 1.85098752e-01f, 4.35247459e-02f,
  2.31405646e-01f, 2.88406432e-01f, 2.49315679e-01f, 2.23207787e-01f, 5.88851459e-02f, -2.08085760e-01f, -3.21559124e-02f, 1.40501112e-01f, 1.95201069e-01f, -4.49714325e-02f,
  7.85071105e-02f, 1.82661965e-01f, 3.05824071e-01f, 2.59950221e-01f, 1.35362223e-01f, 1.84490159e-01f, -3.29758003e-02f, -1.71841756e-01f, -1.74316727e-02f, 1.02983773e-01f,
  -1.23626627e-01f, -4.40438539e-02f, 2.39761129e-01f, 3.21398944e-01f, 4.04545031e-02f, 2.34379098e-01f, 9.88604948e-02f, 1.61378309e-01f, 7.57187083e-02f, 4.97057242e-03f,
  1.00227594e-01f, 6.46110550e-02f, 5.76356314e-02f, 9.33451764e-03f, -2.29381137e-02f, -4.44470730e-04f, 9.92897749e-02f, 9.47690755e-02f, -2.09657662e-02f, -3.96886431e-02f,
  7.47746229e-02f, -1.50371566e-01f, -1.94650933e-01f, -1.02882059e-02f, -4.66119014e-02f, 1.45603076e-01f, 4.04833965e-02f, 3.53537649e-02f, -2.58168913e-02f, 1.04267634e-01f,
  -1.15632713e-01f, 5.95985278e-02f, 1.34740397e-01f, 2.74743773e-02f, -8.15608129e-02f, -5.07145897e-02f, -1.23069406e-01f, -1.80022657e-01f, -9.87259820e-02f, -8.49889070e-02f,
  -1.37222573e-01f, -4.36281636e-02f, -3.37620974e-02f, -1.00571990e-01f, 2.50675261e-01f, -8.22131038e-02f, -1.49917901e-01f, -3.18069011e-02f, 1.36671653e-02f, 6.06881268e-02f,
  1.38740370e-03f, -1.06253199e-01f, 1.56255101e-03f, -9.08694118e-02f, -1.90961976e-02f, 1.06238425e-01f, -3.08161899e-02f, 6.02636039e-02f, 3.74233685e-02f, -1.17199980e-01f,
  2.98975240e-02f, 1.36435822e-01f, 6.81386217e-02f, 5.29459864e-02f, -8.09036419e-02f, 1.27859145e-01f, 1.88476201e-02f, -3.48846498e-03f, -1.35741368e-01f, -1.98471267e-02f,
  4.68531474e-02f, 1.70368791e-01f, 4.17265818e-02f, 1.15570299e-01f, 2.26751417e-02f, 9.75883082e-02f, 2.06210464e-01f, 8.35856870e-02f, 9.91354957e-02f, 9.22396928e-02f,
  2.04560846e-01f, -4.33235690e-02f, -6.63650036e-02f, 8.52669030e-02f, 1.01458929e-01f, 8.30777064e-02f, 5.30532226e-02f, -4.65549827e-02f, 1.09772850e-02f, 1.24923736e-01f,
  -2.77486295e-01f, 8.54240581e-02f, -4.32264298e-01f, -2.42908314e-01f, -7.57443234e-02f, -3.19573171e-02f, -2.74030268e-01f, -1.29559010e-01f, 2.14406610e-01f, 1.65590540e-01f,
  6.76997155e-02f, -8.65372047e-02f, -1.94049820e-01f, -3.71624589e-01f, -5.93566120e-01f, -2.41130173e-01f, -2.77968049e-01f, -6.69497013e-01f, -7.70084441e-01f, -3.39444131e-01f,
  -2.15889394e-01f, -4.14378524e-01f, -4.41769361e-01f, -2.11037785e-01f, 1.54978022e-01f, -8.82172287e-02f, 1.82590801e-02f, -1.70306608e-01f, 8.27126428e-02f, 8.89250562e-02f,
  -1.94578633e-01f, 9.69209671e-02f, -2.24615663e-01f, -4.67988737e-02f, 1.26884868e-02f, 1.43726617e-01f, -1.48816302e-01f, -1.05322465e-01f, 2.08334014e-01f, 4.97836880e-02f,
  -7.72132203e-02f, 1.18033931e-01f, -1.44985318e-01f, -6.53956607e-02f, -2.44956180e-01f, -6.19311407e-02f, -1.72650069e-01f, -1.81569442e-01f, 4.03163582e-02f, 1.84187680e-01f,
  1.46523789e-01f, 8.39447603e-02f, -9.41791385e-02f, 1.55140668e-01f, 1.66177526e-01f, 3.26489098e-02f, 5.89300320e-03f, 2.49417201e-01f, 1.98711365e-01f, 1.00038387e-01f,
  8.38093981e-02f, 6.13835044e-02f, 3.62888239e-02f, -2.55998820e-02f, -1.11000277e-01f, 6.91449940e-02f, -8.61593783e-02f, -8.96117687e-02f, -3.68276685e-02f, -1.39178291e-01f,
  -9.37911719e-02f, 1.11219913e-01f, -6.11444283e-03f, -7.05236271e-02f, -8.53706673e-02f, -1.04204372e-01f, -4.90300357e-02f, -3.12488414e-02f, 3.29826437e-02f, -5.32070324e-02f,
  -1.90800101e-01f, -5.98619357e-02f, -2.50861347e-02f, 4.19267677e-02f, 8.44525471e-02f, -1.75587344e-03f, 1.95606753e-01f, -5.04927593e-04f, -2.03265622e-01f, 3.41082141e-02f,
  -4.46485490e-01f, -1.21580631e-01f, -3.87667269e-02f, -1.81524917e-01f, 2.72443909e-02f, 1.58804923e-01f, -5.79068325e-02f, 9.39700678e-02f, 8.41107741e-02f, -8.08536485e-02f,
  -6.65779486e-02f, -1.05290465e-01f, -1.04185551e-01f, 8.66164640e-02f, -1.29956737e-01f, -5.98372072e-02f, 6.50050417e-02f, -1.58008546e-01f, 6.60767555e-02f, 2.24882185e-01f,
  9.35410857e-02f, -5.83993755e-02f, -3.27523887e-01f, -1.86272725e-01f, 1.44381702e-01f, -2.57210195e-01f, -3.83383632e-01f, -1.52646586e-01f, -1.19424842e-01f, -2.40635723e-01f,
  -1.18385100e+00f, 1.37494028e-01f, 6.55315101e-01f, -6.54924750e-01f, -8.90559629e-02f, 4.42729555e-02f, 2.55910158e-02f, -2.34207939e-02f, 1.38015384e-02f, 2.77874529e-01f,
  2.87821978e-01f, -2.74352059e-02f, 1.06140599e-01f, 8.92358180e-03f, -3.10988635e-01f, 4.37653624e-02f, -2.11764932e-01f, -4.65131372e-01f, -6.38841987e-01f, -4.34468299e-01f,
  -4.46668625e-01f, -6.37329221e-01f, -6.37857437e-01f, -3.67884099e-01f, 1.45833269e-01f, -2.23429814e-01f, 1.97266757e-01f, -1.80920452e-01f, -4.08376008e-03f, -2.44023763e-02f,
  5.91377735e-01f, -8.25750455e-02f, -4.11841422e-02f, -2.92337179e-01f, 9.64153633e-02f, -9.77375433e-02f, 3.89673896e-02f, 1.15648173e-01f, -5.34819476e-02f, 8.35492387e-02f,
  -5.64661659e-02f, 7.83762429e-03f, -3.86829525e-02f, 1.15552984e-01f, -7.58925676e-02f, 5.87310717e-02f, 1.22455016e-01f, -1.74560130e-01f, 9.67347249e-02f, 4.43317741e-01f,
  1.28300309e-01f, -2.17554212e-01f, 6.36612065e-03f, 2.02994555e-01f, 2.22919494e-01f, -4.11576591e-02f, 3.13907653e-01f, 7.23057687e-02f, 9.16348100e-02f, 5.38902469e-02f,
  -2.48223320e-02f, 1.90609396e-02f, 5.49664944e-02f, -2.61778161e-02f, -7.15266839e-02f, 5.87740205e-02f, 4.69110645e-02f, 1.19411778e-02f, -9.42690149e-02f, -7.46825784e-02f,
  1.58204526e-01f, 1.12483598e-01f, 3.23702544e-02f, -1.25353947e-01f, 4.13409099e-02f, 3.79486047e-02f, -3.38196792e-02f, -8.62734318e-02f, -1.88643094e-02f, -6.94189742e-02f,
  -1.37533665e-01f, 1.71030536e-02f, 6.01110794e-02f, -3.26213390e-02f, 1.77913364e-02f, 1.65635869e-02f, 1.88851301e-02f, 4.64863740e-02f, 1.27686441e-01f, -6.10526949e-02f,
  1.96664706e-01f, -1.63668260e-01f, -1.07255317e-01f, -1.41121060e-01f, -5.92626119e-03f, 1.68886095e-01f, 5.88118173e-02f, -3.13198082e-02f, -4.73590568e-02f, -4.40570787e-02f,
  1.19406961e-01f, -2.06534173e-02f, 7.41291568e-02f, 2.05837831e-01f, -7.08434954e-02f, 2.76016705e-02f, -1.03529677e-01f, -1.43225700e-01f, -1.83638483e-02f, 2.37000108e-01f,
  8.05490315e-02f, -2.25757882e-01f, -2.77278185e-01f, 1.10242508e-01f, 6.08443357e-02f, -3.32338512e-01f, 3.16078365e-02f, 1.38698235e-01f, -1.03652284e-01f, -2.35791057e-01f,
  6.33631825e-01f, 3.26710306e-02f, -1.13258350e+00f, 3.25330079e-01f, -4.68717188e-01f, -5.20701051e-01f, -1.79191932e-01f, 2.85395652e-01f, 3.67974162e-01f, 3.94097716e-02f,
  -6.13753982e-02f, 7.29825255e-03f, -2.47289717e-01f, -1.64183781e-01f, -3.68376374e-01f, -4.00453895e-01f, -5.30609250e-01f, -7.41623342e-01f, -4.94800091e-01f, 2.04167992e-01f,
  3.58776212e-01f, 3.48984927e-01f, 1.07969753e-01f, -7.68784806e-02f, 7.43611902e-02f, -9.92646888e-02f, -3.82594734e-01f, -1.91200107e-01f, -3.15312058e-01f, -4.34055597e-01f,
  -6.79663002e-01f, -2.98602015e-01f, -2.22036228e-01f, 1.30357176e-01f, -1.17474563e-01f, 3.46239731e-02f, 1.26864323e-02f, -1.75229043e-01f, 3.02622635e-02f, -8.81469697e-02f,
  -8.58195052e-02f, 5.16534373e-02f, -9.56273973e-02f, -1.21929847e-01f, 1.05854891e-01f, -5.36045916e-02f, 8.03334564e-02f, -2.05331132e-01f, -2.40109310e-01f, -1.84590042e-01f,
  -1.34144370e-02f, -3.94468606e-01f, -5.53430676e-01f, -2.51908660e-01f, -3.07474375e-01f, -4.34430391e-01f, -3.07292163e-01f, -2.60734499e-01f, -5.22169054e-01f, 7.03081191e-02f,
  3.21801305e-02f, 2.97882017e-02f, 5.92399649e-02f, 1.11955285e-01f, 2.83212334e-01f, -1.34745002e-01f, -6.47759959e-02f, 2.71466328e-03f, -2.85158632e-03f, 5.93850166e-02f,
  -3.38787735e-02f, -8.18580166e-02f, -3.26396190e-02f, -4.48662862e-02f, -1.58007100e-01f, -1.20397307e-01f, -1.50824845e-01f, 6.84395954e-02f, -4.64644097e-02f, 5.92783876e-02f,
  4.89937887e-02f, -3.51227485e-02f, -6.74455538e-02f, 5.45655005e-02f, -2.01003239e-01f, -1.79576352e-01f, -9.16009620e-02f, 1.84161335e-01f, 4.63193543e-02f, 7.39734545e-02f,
  4.95905042e-01f, -5.50286710e-01f, 6.60479069e-02f, 7.86774680e-02f, -2.18181759e-01f, -1.97801009e-01f, 5.93720563e-02f, 9.74936560e-02f, -1.52249157e-01f, -4.92062718e-02f,
  -2.87129879e-01f, 1.24873757e-01f, -1.37660623e-01f, 2.30632536e-03f, 3.83060500e-02f, -2.09416263e-02f, 2.22530499e-01f, -2.35997766e-01f, -2.94450950e-02f, 4.37382236e-02f,
  2.65681267e-01f, 6.66871741e-02f, 1.71486050e-01f, 1.20242476e-01f, 8.43873248e-02f, 1.16435066e-02f, -8.52774084e-02f, 5.15016317e-02f, -2.05145150e-01f, 5.29712915e-01f,
  6.29138052e-01f, 7.22605705e-01f, 2.29396164e-01f, 2.35774755e-01f, 2.96596497e-01f, 5.09684682e-01f, 7.08133161e-01f, 6.24167025e-01f, 1.96674362e-01f, 2.45968968e-01f,
  1.05505273e-01f, -5.45201190e-02f, 6.69171065e-02f, 1.33623838e-01f, 2.56924927e-01f, 3.15151095e-01f, 2.15361074e-01f, 6.96054474e-03f, -1.73105095e-02f, 1.34156674e-01f,
  1.94990501e-01f, 3.17361802e-01f, 1.78870186e-01f, 1.55855298e-01f, 1.45845041e-01f, -4.04970907e-02f, 2.08518997e-01f, 2.65086859e-01f, 1.57617673e-01f, 1.44895464e-02f,
  -4.45673019e-01f, 1.33442298e-01f, -1.22068815e-01f, -1.75021961e-01f, -8.74507427e-02f, -1.67127728e-01f, -1.04295924e-01f, -5.67547716e-02f, -3.59371863e-02f, -4.35346067e-02f,
  4.74183895e-02f, -1.51518196e-01f, -1.28802761e-01f, -1.14588901e-01f, -2.44931765e-02f, -1.35367066e-01f, -6.90086037e-02f, 2.70634107e-02f, 3.72245908e-02f, -1.64949000e-01f,
  -4.56475578e-02f, 1.74499284e-02f, 6.15794919e-02f, -2.92530376e-02f, 5.27876765e-02f, -1.58589318e-01f, -1.04949154e-01f, -2.32763048e-02f, -4.06000689e-02f, -2.16548778e-02f,
  -2.76780814e-01f, 1.01105183e-01f, -8.21605772e-02f, -1.26479551e-01f, -6.19911077e-03f, -3.60491313e-02f, -4.19837460e-02f, 5.67662641e-02f, -1.06628826e-02f, 4.36174273e-02f,
  2.27859486e-02f, -1.23573065e-01f, 1.64052211e-02f, -2.14971125e-01f, -2.76044428e-01f, 1.15831653e-02f, 3.96335609e-02f, -1.73399106e-01f, -2.65378743e-01f, -6.63535763e-03f,
  -1.26105070e-01f, -3.74249555e-02f, -1.82209983e-01f, -1.37036443e-01f, -1.33566812e-01f, -1.69508591e-01f, -1.52630970e-01f, -1.40291676e-01f, 6.37336373e-02f, 4.00658250e-02f,
  -2.72062179e-02f, -1.21616460e-01f, -1.38280377e-01f, 1.20002463e-01f, 3.54340374e-02f, -9.15732384e-02f, -6.08691759e-02f, -1.42664865e-01f, 3.21367197e-02f, 2.64245868e-02f,
  1.06545769e-01f, -9.24953222e-02f, -2.21337397e-02f, 6.97291195e-02f, -1.05907246e-01f, -2.88104583e-02f, 4.70665358e-02f, 4.77655120e-02f, 5.51785715e-03f, 3.80542353e-02f,
  5.06991404e-04f, 1.65765304e-02f, -1.20940385e-02f, -1.57593191e-02f, -2.25864761e-02f, -8.23958889e-02f, -1.85276091e-01f, 1.12495548e-03f, -1.40340969e-01f, -5.72166555e-02f,
  9.06066060e-01f, -1.30426154e-01f, 2.63167977e-01f, 2.30275512e-01f, -3.56099784e-01f, -4.36636955e-01f, -5.60493410e-01f, -3.62136602e-01f, -1.88112170e-01f, 1.10397801e-01f,
  7.55732581e-02f, 2.57889301e-01f, 9.26487520e-02f, 3.20509225e-02f, -2.96555664e-02f, -3.08022695e-03f, 6.95383921e-02f, 4.74068791e-01f, 4.26735669e-01f, 2.73728162e-01f,
  -4.74703731e-03f, 1.60434037e-01f, 4.19259250e-01f, 7.81144798e-02f, 2.07136825e-01f, 1.16772331e-01f, 3.81803215e-02f, 1.25697464e-01f, 8.29778835e-02f, 5.36030352e-01f,
  6.03713512e-01f, 3.60306233e-01f, -1.37279257e-01f, -5.70396893e-02f, 9.92106870e-02f, 3.77590731e-02f, 1.83945429e-02f, -1.58169232e-02f, -3.53465006e-02f, -7.51661956e-02f,
  -8.71247519e-03f, 1.06303811e-01f, -1.79448165e-02f, -2.27297414e-02f, -1.12018429e-01f, -1.87702887e-02f, 1.11174382e-01f, 1.14648856e-01f, 9.75081790e-03f, 1.06119640e-01f,
  3.74347121e-02f, 5.12873046e-02f, -9.15166456e-03f, -2.77210623e-01f, -5.40114520e-03f, -7.58841867e-04f, -8.29167366e-02f, 6.28759935e-02f, -1.67285949e-02f, 2.12877929e-01f,
  1.42606258e-01f, -3.17299447e-04f, 9.61561203e-02f, 1.35204732e-01f, 1.90504625e-01f, 1.15816087e-01f, 2.67810281e-02f, 2.75457464e-03f, 1.67145543e-02f, 1.85688764e-01f,
  1.76534668e-01f, 1.29814029e-01f, -2.74046091e-03f, 5.56837320e-02f, 4.27659601e-02f, 1.01814255e-01f, 1.29058123e-01f, -7.88502619e-02f, -2.35463828e-02f, -6.21063225e-02f,
  9.17258039e-02f, 9.03165191e-02f, -1.00406343e-02f, 7.13623092e-02f, 8.76095146e-03f, -3.78664932e-03f, 1.28224105e-01f, -6.56030029e-02f, -4.04891782e-02f, 4.66428371e-03f,
  -5.47016323e-01f, -4.23530847e-01f, 3.55086386e-01f, 6.44663870e-02f, -2.67062448e-02f, -6.79761618e-02f, 1.15277998e-01f, -5.05010085e-03f, -2.12630704e-01f, -6.17886074e-02f,
  -7.94457644e-03f, 9.54862460e-02f, -1.76192492e-01f, -1.58069015e-01f, 1.28732417e-02f, -1.27323300e-01f, -2.78141275e-02f, -2.30513979e-02f, -1.84405208e-01f, 1.10831462e-01f,
  -1.19137004e-01f, -9.86075252e-02f, -7.84393251e-02f, -2.43613526e-01f, -1.79062560e-01f, 4.88292146e-03f, 4.46842844e-03f, -3.36585604e-02f, -1.11628145e-01f, -5.57998382e-02f,
  -1.88558578e-01f, 5.78605831e-01f, -1.11465506e-01f, 3.53034914e-01f, 7.49074340e-01f, 3.00681591e-01f, 3.15686077e-01f, -1.07599586e-01f, 5.24249626e-03f, 8.01037997e-02f,
  3.34596038e-01f, 2.22558975e-01f, -7.79455435e-03f, -4.47928347e-02f, -2.73871481e-01f, -4.86389399e-02f, -7.79978745e-03f, -3.07511240e-01f, -3.22550029e-01f, -4.18317989e-02f,
  3.44559938e-01f, 1.51689366e-01f, -2.65403152e-01f, -1.99159220e-01f, 2.04472005e-01f, -2.57526264e-02f, 2.61073131e-02f, 3.02723885e-01f, 8.46738294e-02f, 1.13529213e-01f,
  -2.09507793e-01f, 7.24734366e-02f, -2.14804649e-01f, 1.39457211e-01f, 2.09324852e-01f, -3.91103864e-01f, -2.92817444e-01f, -3.18646938e-01f, -3.71245444e-02f, -2.52275735e-01f,
  1.95562318e-01f, 3.45860329e-03f, 3.40872079e-01f, 1.09733781e-03f, 9.37115476e-02f, -2.18068875e-04f, -1.81497574e-01f, -2.27916449e-01f, -2.89560556e-01f, -8.33087880e-03f,
  2.45879710e-01f, 3.25476676e-01f, 2.22165465e-01f, 5.59633002e-02f, -8.67411345e-02f, -9.77401622e-03f, 4.14879844e-02f, -1.71833441e-01f, -3.62718403e-01f, -1.80010155e-01f,
  -1.83556855e-01f, -7.80004710e-02f, 1.33678839e-01f, 1.47803212e-02f, 2.47422811e-02f, -1.38782129e-01f, 5.64963184e-02f, 1.00979902e-01f, 1.20865572e-02f, -2.39400901e-02f,
  -4.71738875e-02f, -6.37291521e-02f, -1.18051916e-01f, -4.27031368e-02f, -2.24876717e-01f, 7.78743178e-02f, -1.12722151e-01f, -1.83430329e-01f, -7.43090585e-02f, -1.23540394e-01f,
  1.05634913e-01f, -4.18364108e-02f, -6.60136566e-02f, -4.81596701e-02f, -1.19823307e-01f, -7.70347789e-02f, -2.15635732e-01f, -5.73902242e-02f, -2.11066045e-02f, -2.29138955e-02f,
  -2.35968366e-01f, -1.78961292e-01f, -1.53386250e-01f, -1.83807671e-01f, 9.78675410e-02f, -5.48587516e-02f, -4.19013314e-02f, 1.93918915e-03f, 2.69671619e-01f, -1.18903309e-01f,
  -7.62268454e-02f, -2.09004223e-01f, 2.31361785e-03f, -2.20866129e-01f, -1.00849554e-01f, -2.28859503e-02f, -6.99370354e-02f, 1.32072628e-01f, -1.85746446e-01f, 1.33057311e-01f,
  -9.73653123e-02f, -1.98648438e-01f, -7.56880268e-02f, -1.69886485e-01f, -8.42882842e-02f, -2.09908977e-01f, -2.87993610e-01f, -2.60797501e-01f, -3.48396748e-01f, -3.88292074e-01f,
  6.36915445e-01f, 7.01945052e-02f, -4.65817228e-02f, 4.31254506e-01f, -1.32567272e-01f, -3.31769675e-01f, -4.88236785e-01f, -2.06422955e-01f, 1.70382217e-01f, 3.51269186e-01f,
  6.08888753e-02f, 4.20986116e-01f, 2.91322678e-01f, 2.73161888e-01f, 1.06619477e-01f, 7.96325728e-02f, 1.66193768e-01f, 3.69724035e-01f, 1.72944620e-01f, 2.25400805e-01f,
  4.65631753e-01f, 2.46613696e-01f, 2.97399580e-01f, 1.42507374e-01f, 2.52477586e-01f, 2.31480584e-01f, 4.45853993e-02f, 1.35988787e-01f, 1.70255795e-01f, 5.52941799e-01f,
  3.39217335e-01f, -7.53692910e-02f, -1.82406411e-01f, 2.34435629e-02f, -1.56759381e-01f, 1.57935068e-01f, 4.92354967e-02f, -1.23775192e-02f, 4.56530713e-02f, 1.08185865e-01f,
  -4.77510355e-02f, -8.16854555e-03f, 7.18865097e-02f, -5.31122014e-02f, -1.75981205e-02f, -1.43011004e-01f, -6.56084344e-02f, -1.61257517e-02f, -6.29074126e-02f, -2.13283133e-02f,
  9.73146632e-02f, -1.08860768e-01f, -3.56720865e-01f, -2.66197711e-01f, -3.00593823e-02f, 3.85260545e-02f, -2.30028287e-01f, 7.97924548e-02f, -1.17924862e-01f, 1.12147398e-01f,
  1.30247489e-01f, 2.24473551e-02f, -3.21866572e-02f, 1.19279616e-01f, 1.90793097e-01f, -3.37227434e-02f, 3.27891596e-02f, -3.49674076e-02f, 7.16306865e-02f, -8.14206153e-03f,
  -8.14585462e-02f, -4.71540205e-02f, -3.11228074e-02f, 2.51804646e-02f, 1.81096524e-01f, 1.04441397e-01f, 3.27304490e-02f, -1.41579695e-02f, 1.65670663e-02f, -5.49883544e-02f,
  4.98060770e-02f, -6.87836111e-02f, 3.59890312e-02f, 2.22598985e-02f, -6.86600283e-02f, 5.63904084e-02f, 1.87459409e-01f, 7.84469023e-02f, 9.36164409e-02f, -6.91158511e-03f,
  -6.67973533e-02f, -3.10629815e-01f, 2.54684299e-01f, -2.05501691e-02f, -1.28553748e-01f, -4.36502099e-02f, -1.97067088e-03f, -1.21483430e-01f, -6.22051246e-02f, 7.69586712e-02f,
  -1.34154379e-01f, 2.70466805e-02f, -8.87715518e-02f, -6.92313723e-03f, -6.00971580e-02f, -6.79402575e-02f, 2.47292630e-02f, 5.07941432e-02f, -3.45761217e-02f, -1.79974660e-01f,
  -7.05864206e-02f, -1.15845419e-01f, -1.96404666e-01f, -2.99844235e-01f, -7.01097474e-02f, -7.93939158e-02f, -1.33329630e-01f, -1.49169624e-01f, -2.53098637e-01f, -1.65498763e-01f,
  4.29305881e-01f, -3.99271965e-01f, 8.09511542e-02f, 2.94598304e-02f, 1.50903612e-01f, 1.38329491e-01f, 1.51590347e-01f, 2.21001998e-01f, 7.26401359e-02f, -2.34716628e-02f,
  -6.04205370e-01f, -7.04423368e-01f, -6.69926584e-01f, -4.22298223e-01f, -3.55861664e-01f, 6.17778897e-02f, 2.30873093e-01f, 3.10214907e-01f, 3.38088930e-01f, 2.45679393e-01f,
  6.20691292e-02f, 5.29723525e-01f, 5.50764859e-01f, 2.39559054e-01f, 1.22371383e-01f, -8.88164565e-02f, 1.17203973e-01f, 1.15449429e-01f, -1.83964238e-01f, -1.31598130e-01f,
  -3.15510124e-01f, -1.94676399e-01f, 1.31878942e-01f, -3.97977531e-02f, -1.48720220e-01f, 4.27197181e-02f, -1.33158397e-02f, 8.18434283e-02f, -2.81973686e-02f, 2.15003043e-02f,
  -1.72246039e-01f, 5.11364117e-02f, -2.56092995e-01f, -4.53563184e-02f, 2.70324331e-02f, 1.61778361e-01f, 5.68071976e-02f, 9.42710340e-02f, -1.81243479e-01f, -2.47131307e-02f,
  -2.51196563e-01f, 7.82497004e-02f, 1.45548180e-01f, -9.39012393e-02f, -1.22301362e-01f, -1.05693424e-03f, -7.11246133e-02f, -1.15257554e-01f, -1.22983586e-02f, 5.40582463e-02f,
  1.39777660e-02f, -2.78174076e-02f, -4.53998558e-02f, 7.54244998e-03f, -3.09643969e-02f, -1.34128630e-01f, -1.35348544e-01f, -4.52557094e-02f, -6.68130117e-04f, 2.47997362e-02f,
  -7.33323544e-02f, -1.67564720e-01f, -1.75567791e-01f, 7.65351877e-02f, -1.12482056e-01f, -1.15088969e-02f, -3.02480217e-02f, -1.02126308e-01f, -5.87911643e-02f, -6.98119253e-02f,
  -9.40264296e-03f, -1.05414987e-02f, 1.11150846e-01f, -3.97306047e-02f, 5.20144291e-02f, 3.66789326e-02f, 7.80053958e-02f, -1.10210888e-01f, 1.00469038e-01f, -2.96457787e-03f,
  9.93971974e-02f, -2.15847552e-01f, -3.04726548e-02f, -6.16378225e-02f, 6.20175526e-02f, -6.43484294e-02f, -3.08165908e-01f, -4.15402167e-02f, -2.52841830e-01f, 2.96473503e-02f,
  -6.10317253e-02f, -1.30110130e-01f, -1.06146351e-01f, 2.54540462e-02f, 1.53685361e-01f, 1.14079341e-01f, -1.20548094e-02f, -6.27649426e-02f, -4.41491529e-02f, 5.83850108e-02f,
  8.88021141e-02f, 2.26307213e-01f, -6.41881907e-03f, -5.52446581e-02f, -1.11077651e-01f, 6.62519410e-02f, 2.63068303e-02f, 1.80935517e-01f, 1.21011078e-01f, 3.55782896e-01f,
  6.42354250e-01f, 2.04824135e-01f, 2.32186154e-01f, 1.98489949e-01f, 3.61219376e-01f, 4.01893616e-01f, 4.14660811e-01f, 2.49526173e-01f, 4.44658138e-02f, 1.98541507e-01f,
  3.26080680e-01f, -7.28346631e-02f, -1.46029472e-01f, -1.84370935e-01f, -8.73826742e-02f, -2.07988173e-01f, -1.69283539e-01f, -1.15938559e-01f, -7.96829443e-03f, 1.05444677e-01f,
  -1.53653473e-01f, 2.63296336e-01f, 2.99444139e-01f, -1.87534224e-02f, -8.71197358e-02f, -1.13727920e-01f, 2.30401248e-01f, 2.64911294e-01f, -8.78848508e-03f, -3.49799305e-01f,
  1.16660574e-03f, 3.66509885e-01f, -3.21796924e-01f, -2.08280683e-01f, -1.85472611e-02f, 9.66727510e-02f, 1.00457735e-01f, -1.62984675e-03f, 7.36438036e-02f, 2.77048368e-02f,
  2.83393413e-02f, 1.39623046e-01f, 6.74639866e-02f, 8.48034024e-02f, 2.21435085e-01f, 3.94687988e-02f, 1.64210573e-01f, -8.52359608e-02f, -1.29810125e-01f, -2.53749657e-02f,
  5.06669134e-02f, 2.96412975e-01f, 1.68403193e-01f, -1.03839509e-01f, -4.00573984e-02f, 5.29638492e-03f, 1.92118939e-02f, -9.42927450e-02f, 7.24561587e-02f, -1.58019457e-02f,
  1.54224992e-01f, 2.93543369e-01f, 1.80664316e-01f, 8.19959864e-02f, -4.60457653e-02f, 3.02863549e-02f, 1.11927234e-01f, 1.23310629e-02f, 1.67013705e-01f, 1.59357056e-01f,
  -1.42869309e-01f, 3.86205912e-02f, 3.33144158e-01f, 2.62732834e-01f, 2.04486310e-01f, 4.80634600e-01f, 1.25182986e-01f, 9.47446600e-02f, 2.20281363e-01f, 3.04861903e-01f,
  -3.62966545e-02f, 1.39025465e-01f, 2.23738447e-01f, 2.89977156e-02f, 1.17017113e-01f, 1.61815479e-01f, 5.48508391e-02f, 2.95295775e-01f, 2.50332355e-01f, 3.75440896e-01f,
  1.06438883e-02f, 2.40764022e-01f, -2.05924645e-01f, -1.70419097e-01f, 1.49930447e-01f, 1.16374575e-01f, 2.67297942e-02f, -1.73823848e-01f, -9.62902382e-02f, -8.61946866e-02f,
  4.22624797e-02f, 1.30044535e-01f, 2.41322085e-01f, 2.63012778e-02f, 1.71095133e-01f, 1.16106514e-02f, 9.55796149e-03f, 2.46369448e-02f, -2.29740173e-01f, -1.45387501e-01f,
  -1.73153579e-01f, 8.76682401e-02f, 7.03209266e-03f, -1.65231317e-01f, -9.36210006e-02f, -1.59015939e-01f, -2.78397538e-02f, -2.40678694e-02f, -9.15907994e-02f, 8.10642075e-03f,
  -7.24168420e-01f, -2.96173394e-01f, -5.53640306e-01f, -7.62414575e-01f, -3.68909329e-01f, 5.27975410e-02f, 1.52991593e-01f, 1.03724323e-01f, -1.96933016e-01f, -2.96500832e-01f,
  1.90810058e-02f, -6.60807192e-02f, -4.00827616e-01f, -1.27483398e-01f, 6.29836768e-02f, -2.46865958e-01f, -4.36514050e-01f, -3.03932935e-01f, 2.04831846e-02f, 2.03455701e-01f,
  1.88983206e-04f, -2.64139622e-01f, -3.09171557e-01f, -9.60325599e-02f, -3.61228913e-01f, -3.36964041e-01f, -5.36173642e-01f, -4.06288683e-01f, -1.04176581e-01f, -5.55463791e-01f,
  -2.08288223e-01f, -3.44383158e-02f, 3.63497883e-02f, -1.17670625e-01f, -1.44557267e-01f, 1.90818422e-02f, 1.80631839e-02f, -1.74898118e-01f, 1.33577064e-01f, -4.27354127e-02f,
  -8.77114534e-02f, 1.38317138e-01f, -9.10522863e-02f, -1.30162733e-02f, -1.62260354e-01f, 2.26854369e-01f, -1.15363643e-01f, -5.79084456e-02f, -1.35845900e-01f, 1.50513127e-01f,
  7.89905190e-02f, 3.17674428e-02f, -1.80273857e-02f, 2.27248281e-01f, 2.10785583e-01f, 2.26623453e-02f, 1.40308887e-01f, 1.90562889e-01f, 5.19849472e-02f, -2.66115904e-01f,
  -3.22529860e-03f, -7.67809674e-02f, 6.57026395e-02f, -7.15271607e-02f, 7.34275207e-02f, 3.58756967e-02f, -1.55275077e-01f, -6.54814541e-02f, 1.09920129e-01f, 6.95633888e-03f,
  -6.26529455e-02f, 2.82895658e-02f, 5.82283959e-02f, -1.05265066e-01f, -4.22207043e-02f, -1.16746336e-01f, 6.70276359e-02f, -4.99592014e-02f, -5.27972467e-02f, -9.73824486e-02f,
  -1.30320136e-02f, 2.66273376e-02f, -7.66419843e-02f, 3.21503803e-02f, 1.45045385e-01f, -1.03465661e-01f, 4.18131761e-02f, 1.20146833e-01f, 3.21410671e-02f, 1.17707051e-01f,
  -4.03362125e-01f, 1.81845993e-01f, -2.42481187e-01f, -3.81712839e-02f, -7.10317791e-02f, 2.95946337e-02f, -2.28226408e-01f, 1.05541043e-01f, -2.82663107e-02f, 9.60076414e-03f,
  1.65309846e-01f, -6.80734217e-02f, -1.27444908e-01f, 1.87096447e-02f, 1.60125196e-02f, 2.42040724e-01f, 4.69368882e-02f, -2.47052893e-01f, -5.25765792e-02f, -3.51730585e-02f,
  -9.98023897e-02f, 2.31108099e-01f, 7.81299546e-02f, -7.90954009e-02f, 7.12800771e-02f, -1.78373326e-02f, -1.04893586e-02f, 7.83910751e-02f, 5.33400178e-02f, -1.82751119e-01f,
  1.05164015e+00f, 7.07764685e-01f, 3.20766836e-01f, -1.07690342e-01f, 1.82389095e-02f, 1.86130613e-01f, 4.09215808e-01f, 3.05650949e-01f, -1.25271186e-01f, 2.03557521e-01f,
  3.63564879e-01f, 6.78520501e-02f, 1.39759377e-01f, 1.71882123e-01f, 3.11414719e-01f, 2.76197214e-02f, -2.37727299e-01f, 2.37181429e-02f, 1.51132708e-02f, 9.40663293e-02f,
  -1.85692146e-01f, -1.59775674e-01f, 1.29980206e-01f, 6.67159408e-02f, -9.36068743e-02f, -2.24362165e-01f, -3.21998857e-02f, 7.69094080e-02f, 1.64989620e-01f, -2.07928196e-01f,
  3.01606916e-02f, 4.96695668e-01f, -3.96079838e-01f, -1.58974066e-01f, -2.30538901e-02f, 9.56626718e-06f, 8.64791218e-03f, -5.74096292e-02f, -5.00802398e-02f, -1.61095724e-01f,
  -1.62665397e-01f, -1.45019786e-02f, -2.67939698e-02f, -7.32174516e-03f, 4.64989478e-03f, -1.19153569e-02f, 4.95524332e-02f, 4.79040667e-02f, 8.90151858e-02f, 1.29818007e-01f,
  -1.05011836e-01f, 3.50113325e-02f, 8.95576850e-02f, -9.18314792e-03f, 1.00201778e-01f, -5.37156090e-02f, 8.60051364e-02f, 8.83766189e-02f, 1.61485910e-01f, 1.38633117e-01f,
  -7.05446452e-02f, 1.92310020e-01f, 1.44944772e-01f, 5.13752289e-02f, 4.39687632e-02f, -2.03520712e-02f, -4.65059578e-02f, -2.20438633e-02f, 5.73069081e-02f, 5.46887442e-02f,
  -1.27862588e-01f, 9.36423466e-02f, 1.10251650e-01f, -4.82728370e-02f, -7.88717493e-02f, -1.33011136e-02f, 6.65468955e-03f, 7.70547912e-02f, 9.22936276e-02f, 4.26154658e-02f,
  5.81293227e-03f, -2.38151811e-02f, 1.00445308e-01f, 3.21251899e-02f, -4.44668345e-02f, 3.50052156e-02f, -8.31161812e-02f, -6.73071947e-03f, -1.85438581e-02f, -1.09700397e-01f,
  -5.53601682e-01f, 1.84128255e-01f, -2.72661466e-02f, -3.39716934e-02f, -2.78400350e-02f, -4.87315208e-02f, -3.57806636e-03f, -6.79538175e-02f, -1.93801433e-01f, -1.63422152e-01f,
  -3.40965167e-02f, 4.71598692e-02f, 1.31890729e-01f, -4.70026070e-03f, -1.07404977e-01f, -1.78011522e-01f, -1.35015259e-02f, -1.82870068e-02f, -8.31310637e-03f, -7.53631741e-02f,
  -1.06322430e-01f, -1.57534614e-01f, -8.60078707e-02f, -4.02696505e-02f, -1.38413072e-01f, -2.06768185e-01f, 2.23553441e-02f, -4.48365957e-02f, 6.61969371e-03f, -9.21804383e-02f,
  -1.15226912e+00f, -3.73566419e-01f, 3.89295250e-01f, -5.70075035e-01f, 9.99981463e-02f, 1.35304302e-01f, -3.03201884e-01f, -7.81758800e-02f, -2.13250816e-01f, -4.26220834e-01f,
  -1.71658710e-01f, -8.01625475e-02f, -2.35976368e-01f, -1.69609841e-02f, -2.47672841e-01f, -4.04776156e-01f, 1.07072584e-01f, 1.25202015e-01f, 2.30948403e-01f, 2.16104135e-01f,
  7.50675276e-02f, -2.03305140e-01f, -5.10491915e-02f, 1.63221255e-01f, -2.38067865e-01f, -1.54661059e-01f, 1.07082069e-01f, -1.87868223e-01f, 2.02707201e-02f, -3.48679036e-01f,
  -4.82941806e-01f, -1.47981182e-01f, 4.37132716e-01f, -2.86540315e-02f, 1.56960249e-01f, -3.06089729e-01f, -6.20847158e-02f, 6.54892772e-02f, 1.99764132e-01f, 2.90806182e-02f,
  6.49964586e-02f, 2.41026044e-01f, -1.97128966e-01f, 5.37901931e-03f, -1.05183214e-01f, -2.97260266e-02f, 1.48418173e-01f, 1.95280060e-01f, -3.41867097e-02f, 1.26177013e-01f,
  -6.09803833e-02f, -2.93257833e-01f, -2.54114896e-01f, 1.80504724e-01f, 1.40379503e-01f, 1.02055781e-01f, 3.07092071e-01f, 2.83240914e-01f, 1.48393080e-01f, -5.78365982e-01f,
  7.67696127e-02f, 3.51092853e-02f, 9.51184183e-02f, -2.29886286e-02f, -9.19612274e-02f, -8.65965188e-02f, 3.78815643e-02f, -9.05226022e-02f, 1.79712370e-01f, -1.92381531e-01f,
  1.16176218e-01f, 1.23365512e-02f, 1.49363562e-01f, 3.37972902e-02f, -5.13984915e-03f, -2.06518725e-01f, -2.94123148e-03f, 7.63581768e-02f, -8.87240171e-02f, 3.54955867e-02f,
  -8.95035118e-02f, 1.57901626e-02f, 4.94047180e-02f, 7.56638497e-03f, 1.12630919e-01f, 2.05763623e-01f, 2.84498241e-02f, 2.07348503e-02f, -6.40164465e-02f, -1.21288598e-01f,
  -4.65727150e-01f, 3.56954992e-01f, -5.44524789e-01f, -9.93123874e-02f, -6.07971847e-02f, 2.10808516e-01f, 2.88718697e-02f, 7.73176551e-02f, 8.18069950e-02f, -6.23085052e-02f,
  1.94311485e-01f, -1.79637089e-01f, -2.36763254e-01f, 1.48895383e-01f, -2.60253698e-01f, -1.45990640e-01f, -3.60182375e-01f, -1.48507044e-01f, -1.04518600e-01f, -1.57832697e-01f,
  -2.19853580e-01f, -6.55287564e-01f, -8.75437260e-01f, -5.80319941e-01f, -2.68732190e-01f, -4.31151330e-01f, -2.18701065e-01f, -1.26237810e-01f, -5.27722359e-01f, -1.02179408e+00f,
  7.76290894e-01f, -7.26966739e-01f, -4.20706391e-01f, 1.78270966e-01f, -2.01637968e-01f, -3.66863489e-01f, -9.77987111e-01f, -2.04789177e-01f, 2.00003132e-01f, -6.53397441e-01f,
  -3.81190211e-01f, 2.94184089e-01f, 2.39447892e-01f, 2.74357051e-02f, -1.39452949e-01f, -8.71817112e-01f, -6.17835760e-01f, -4.27352078e-02f, 1.66748360e-01f, -2.93510914e-01f,
  -3.94726813e-01f, -8.99581686e-02f, 2.08179846e-01f, 5.16542867e-02f, -1.87218040e-01f, 2.29494378e-01f, -3.12409192e-01f, 1.24325301e-03f, -2.49923304e-01f, -3.19394141e-01f,
  -4.06905204e-01f, 1.93744332e-01f, -2.70234477e-02f, 9.88755673e-02f, -1.84396431e-01f, 4.43821512e-02f, -2.58790366e-02f, 7.36204013e-02f, 4.87926379e-02f, 9.94683802e-03f,
  4.02690135e-02f, -2.27875374e-02f, 1.01616092e-01f, -2.36478467e-02f, -8.94720256e-02f, 2.39487477e-02f, -3.24198678e-02f, -6.34747818e-02f, -1.86474899e-05f, -1.87415168e-01f,
  -1.61339849e-01f, 7.31448382e-02f, 8.00871626e-02f, 4.70838174e-02f, 7.34216571e-02f, 1.84482083e-01f, 4.31329384e-03f, 9.50229764e-02f, 2.18700901e-01f, -1.07872009e-01f,
  -9.96954516e-02f, 2.05434281e-02f, -5.42111287e-04f, 1.81607921e-02f, -2.95577198e-02f, 1.33567795e-01f, 3.96639295e-02f, 3.68305147e-02f, 2.12458670e-02f, 3.36391293e-02f,
  -9.17719677e-02f, -1.52836725e-01f, -2.80152969e-02f, -1.11140246e-02f, 1.53133692e-02f, 1.08774640e-01f, 2.60883365e-02f, -1.40877560e-01f, 3.29615697e-02f, 6.96817711e-02f,
  -3.29678915e-02f, 4.21555303e-02f, 1.06913550e-02f, -5.47104292e-02f, -1.31404877e-01f, 5.03635295e-02f, 9.14798677e-02f, 8.59123319e-02f, 1.01904273e-01f, -6.12949207e-02f,
  9.75072682e-02f, 2.64780410e-02f, 3.73751819e-02f, -6.30036276e-03f, -3.15763727e-02f, -4.68353853e-02f, -8.27641934e-02f, 1.69451647e-02f, 9.33706015e-02f, -4.07470316e-02f,
  -1.49888441e-01f, -3.47904451e-02f, 1.65654644e-02f, -4.96533588e-02f, -6.54236898e-02f, 3.89623083e-02f, -2.04813868e-01f, -4.44709696e-02f, 2.89786272e-02f, -1.49531394e-01f,
  -1.51978850e-01f, -8.94709751e-02f, 1.23112477e-01f, 4.01327424e-02f, 1.18162431e-01f, 1.45039782e-01f, -1.22500136e-01f, -1.98813789e-02f, 1.13408573e-01f, -2.76749998e-01f,
  5.86690903e-01f, -6.39950812e-01f, -5.60724437e-01f, -1.49356365e-01f, -2.19457597e-01f, -3.80352885e-02f, -4.12269711e-01f, 1.45032868e-01f, 1.63945064e-01f, -5.13245404e-01f,
  2.09877230e-02f, 7.03057408e-01f, 3.05179834e-01f, 3.82557869e-01f, 4.54189658e-01f, -5.86365759e-01f, -4.84481812e-01f, 2.72474319e-01f, 7.99544156e-01f, 5.12893498e-01f,
  1.49270132e-01f, 1.66439235e-01f, 5.07755756e-01f, 2.04868287e-01f, -3.67985129e-01f, 1.49941698e-01f, -5.90187788e-01f, -1.99208483e-01f, -3.49248469e-01f, -7.28444099e-01f,
  -2.68403560e-01f, -2.68387944e-01f, 3.82929951e-01f, 2.41197139e-01f, -4.80245389e-02f, -9.61550400e-02f, -1.31637663e-01f, -9.20090005e-02f, -6.72567338e-02f, -1.87575072e-01f,
  -5.60145602e-02f, 2.76928023e-02f, 9.83280092e-02f, -7.24955574e-02f, 1.86717100e-02f, 3.18938233e-02f, 9.49430838e-02f, -3.58533463e-03f, -6.45809947e-03f, -6.54951632e-02f,
  -1.31092295e-01f, -1.53405979e-01f, -1.94341645e-01f, -1.40989780e-01f, 1.22688822e-02f, 2.10353106e-01f, -1.51724905e-01f, 1.51224376e-03f, 2.15912879e-01f, -5.10555744e-01f,
  1.21021740e-01f, -1.17692143e-01f, -8.56226310e-02f, 2.54347152e-03f, 1.11970119e-01f, -1.08210891e-01f, -1.31605193e-01f, 4.14037518e-02f, 5.66953495e-02f, -8.53151456e-02f,
  -3.43058221e-02f, 1.61621291e-02f, 1.04153290e-01f, -1.64654180e-01f, -6.05398677e-02f, -5.51896356e-02f, -1.05888754e-01f, -7.05554560e-02f, 9.64580774e-02f, 3.30576636e-02f,
  5.33777177e-02f, -6.80435300e-02f, -8.51710364e-02f, 8.61907452e-02f, -5.54287098e-02f, 8.56858715e-02f, -8.58951360e-02f, 2.31306314e-01f, 2.46444345e-01f, -1.63895637e-01f,
  8.40688050e-02f, 3.02880675e-01f, -7.75538832e-02f, 1.87374979e-01f, -1.33191735e-01f, 1.13648558e-02f, -1.93762302e-01f, 1.22311577e-01f, -4.90066670e-02f, 1.52266979e-01f,
  5.03151156e-02f, -2.55499315e-03f, -2.10756704e-01f, -9.20629576e-02f, 1.81367636e-01f, 2.33127456e-02f, -5.24784550e-02f, 1.22591883e-01f, 1.23462617e-01f, -3.95991504e-02f,
  -1.22358963e-01f, 5.62709160e-02f, 2.96052098e-01f, -7.18286335e-02f, 3.52091268e-02f, 1.34884447e-01f, -2.91566819e-01f, -1.23251908e-01f, 2.72396207e-01f, -2.90896654e-01f,
  5.66884100e-01f, -7.44647086e-01f, 6.63951576e-01f, 3.37898917e-02f, -1.21243596e-01f, -1.06672511e-01f, -1.79145887e-01f, -1.96833268e-01f, -4.60552983e-02f, -1.22850232e-01f,
  -3.90168428e-01f, -3.77231538e-01f, 2.87374705e-02f, -9.29042324e-02f, -6.35528117e-02f, 2.41890341e-01f, 4.44505721e-01f, 4.75074023e-01f, 2.81297565e-01f, -1.99777380e-01f,
  -4.76406902e-01f, -1.25902131e-01f, 1.27484918e-01f, 3.24433297e-02f, -1.75174728e-01f, -9.85097811e-02f, 1.55124307e-01f, -1.62058726e-01f, -1.51071876e-01f, 1.92230791e-01f,
  3.77645135e-01f, -2.50740886e-01f, 1.59729883e-01f, -1.89244315e-01f, -6.58491775e-02f, 5.87027483e-02f, 1.86483972e-02f, -4.71198261e-02f, -5.49006909e-02f, -2.88761314e-02f,
  -1.07060991e-01f, -1.08129509e-01f, -1.35742486e-01f, -2.03431826e-02f, -6.45236224e-02f, 3.73318829e-02f, -1.23845503e-01f, -7.72273839e-02f, -1.03041500e-01f, -1.71995506e-01f,
  -2.50615805e-01f, -1.24299087e-01f, 1.41202465e-01f, -6.86550736e-02f, -4.16999087e-02f, 4.90755551e-02f, -4.60663773e-02f, -5.35095520e-02f, -9.93381813e-02f, 6.32146746e-02f,
  8.91107991e-02f, 1.06789924e-01f, -1.11025162e-01f, 3.98554699e-03f, -1.56307608e-01f, 4.22423184e-02f, -5.70515431e-02f, -7.24880099e-02f, -7.51709938e-02f, -6.36813417e-02f,
  -2.34781951e-01f, -4.66520153e-02f, 1.18188495e-02f, -2.51405668e-02f, 2.40673441e-02f, -5.99553920e-02f, 5.00772439e-04f, -1.23349324e-01f, -3.41821536e-02f, -9.84902978e-02f,
  -1.04119852e-01f, -4.96941656e-02f, -8.38505998e-02f, -1.86557677e-02f, -7.32364058e-02f, -8.78532454e-02f, -5.18626757e-02f, -1.24547273e-01f, 8.76492634e-02f, -3.37721128e-03f,
  -1.56943575e-01f, -9.65608135e-02f, 2.42108434e-01f, 8.13587010e-02f, 5.44484258e-02f, -1.08845457e-01f, 3.69584337e-02f, -6.01402484e-02f, 7.12008998e-02f, 4.84016314e-02f,
  -1.11684337e-01f, -4.49627116e-02f, -5.61848991e-02f, -7.51399621e-02f, 8.50452408e-02f, 1.59834683e-01f, -1.33510157e-01f, 8.25641230e-02f, -6.84849219e-03f, -2.24749789e-01f,
  -1.44417942e-01f, 1.27639130e-01f, 1.74303621e-01f, 1.26448244e-01f, 6.88212970e-03f, 2.39010096e-01f, 1.88142687e-01f, 3.60162966e-02f, 1.59663692e-01f, 2.54563987e-01f,
  -1.55640801e-03f, -4.26523209e-01f, 2.26600200e-01f, 4.31238800e-01f, 4.48522717e-01f, 3.40142012e-01f, 3.10199350e-01f, 2.42555723e-01f, 1.55677795e-01f, -1.25135770e-02f,
  1.08200675e-02f, 1.88119844e-01f, 1.46029815e-01f, 7.55328164e-02f, 1.22341849e-01f, 1.72679558e-01f, 3.18316728e-01f, 2.47689694e-01f, 1.42641723e-01f, 1.70811772e-01f,
  1.10830590e-01f, -8.01887959e-02f, -1.95238695e-01f, 5.05356155e-02f, 9.19607133e-02f, 2.15895683e-01f, -5.02414163e-03f, -1.15389220e-01f, 6.62671495e-03f, -5.85123757e-03f,
  -3.53181779e-01f, -5.11849895e-02f, 2.21882194e-01f, -6.53236210e-02f, -1.79922998e-01f, -9.65322331e-02f, 3.80705744e-02f, -1.22063555e-01f, -1.65638492e-01f, -7.43455589e-02f,
  -8.41117874e-02f, -1.20541982e-01f, -4.96847257e-02f, -3.39627638e-02f, -7.72911087e-02f, -4.93934639e-02f, -1.83133617e-01f, 3.58533822e-02f, 8.60445723e-02f, -1.15895376e-01f,
  -2.82644704e-02f, 1.30853383e-02f, 2.02975348e-01f, 1.89141944e-01f, 1.13288045e-01f, 2.00859487e-01f, -7.09452480e-02f, 8.90373543e-04f, -2.10742233e-03f, -1.07467040e-01f,
  1.56778619e-01f, 1.52498275e-01f, 1.50987998e-01f, 4.02523614e-02f, 1.20122075e-01f, 6.56726509e-02f, 5.40642031e-02f, 3.98234203e-02f, 6.67385235e-02f, 6.06782362e-02f,
  9.70972478e-02f, 9.92770493e-02f, 1.19629689e-01f, 7.94387087e-02f, 4.07179520e-02f, 6.38478547e-02f, -4.81370836e-02f, -1.63927115e-02f, 7.39722252e-02f, 6.61970228e-02f,
  1.97329596e-01f, 6.66245893e-02f, -1.46193877e-01f, 2.87943874e-02f, 1.99003555e-02f, 1.34949952e-01f, 1.22684194e-02f, -8.71577561e-02f, -2.95943692e-02f, -2.21614204e-02f,
  -2.61211544e-01f, 3.43908250e-01f, 1.98110506e-01f, 6.64180219e-02f, -2.96946969e-02f, -1.91661522e-01f, 8.05990025e-02f, -1.09184153e-01f, -1.65827647e-01f, -2.99280155e-02f,
  -1.19337805e-01f, -9.14996117e-02f, -1.90273598e-02f, -2.08208039e-02f, -2.56104190e-02f, -2.35732887e-02f, -1.68647856e-01f, 8.75386447e-02f, -1.10561671e-02f, -1.47717685e-01f,
  -1.27961040e-01f, 1.68623701e-01f, 2.75989234e-01f, 1.98888198e-01f, 3.63414660e-02f, 2.84432948e-01f, 3.44258212e-02f, 8.47342685e-02f, 1.55862942e-01f, 1.51218260e-02f,
  4.27307993e-01f, 6.08724356e-01f, -2.44238853e-01f, 4.65344578e-01f, -9.00075063e-02f, -4.85237390e-01f, 8.87410939e-02f, -8.60974789e-02f, 2.69050479e-01f, 5.17930746e-01f,
  1.65974572e-01f, -4.84177053e-01f, -5.28082103e-02f, -5.36289275e-01f, -5.76421022e-01f, 8.62928480e-02f, 7.76262488e-04f, -6.30367935e-01f, -1.06960046e+00f, -6.77754343e-01f,
  -2.45095924e-01f, 5.53688034e-02f, -1.94238737e-01f, -2.35740677e-01f, 2.66482413e-01f, -2.98611015e-01f, 4.53998178e-01f, 1.71746999e-01f, -1.19962960e-01f, 1.43042400e-01f,
  -7.73474276e-02f, 2.73856997e-01f, -1.82988584e-01f, -9.26210731e-02f, 2.00591519e-01f, -6.57559186e-02f, -2.21320659e-01f, 1.49062062e-02f, 1.11220293e-01f, 6.73801750e-02f,
  -3.45886834e-02f, -2.96920389e-01f, -1.56428516e-02f, -1.58553481e-01f, -1.94245219e-01f, -3.61496598e-01f, 7.72613436e-02f, -2.87579924e-01f, 4.20774333e-03f, -1.00418337e-01f,
  -1.07669786e-01f, -1.61732614e-01f, -1.91214643e-02f, -8.22390169e-02f, -1.81625560e-01f, -3.71831656e-01f, 3.92675139e-02f, -3.88954341e-01f, -3.27104837e-01f, 4.49090630e-01f,
  3.91340023e-03f, -1.84308067e-02f, -4.41555381e-02f, 1.29449770e-01f, 9.08268243e-02f, 1.01263449e-01f, 6.43377900e-02f, -1.06641203e-01f, -1.45666689e-01f, 1.12050446e-02f,
  -4.68365960e-02f, 1.25626653e-01f, -5.84863387e-02f, 4.64718305e-02f, -1.27137359e-02f, -7.13108927e-02f, 2.43344661e-02f, 2.06795663e-01f, 4.31769937e-02f, 4.33556102e-02f,
  -1.15400843e-01f, -2.14384161e-02f, 6.08110018e-02f, 2.05100644e-02f, 6.02767849e-03f, 2.64514629e-02f, 8.77004042e-02f, -1.20741315e-01f, -4.86931168e-02f, 4.83578965e-02f,
  3.72704685e-01f, -1.00177415e-01f, 4.38965112e-01f, -1.44307852e-01f, 9.49842110e-02f, -1.86106302e-02f, 1.14781350e-01f, 6.27566725e-02f, 1.44328445e-01f, -4.77739125e-02f,
  -2.35568643e-01f, -4.55357730e-02f, 1.85240507e-01f, -8.71667266e-02f, -2.43796676e-01f, -1.28976107e-01f, 1.39358953e-01f, -1.06380329e-01f, -1.26769036e-01f, 5.93504272e-02f,
  3.57681602e-01f, -4.65769060e-02f, -3.16477083e-02f, 1.62904292e-01f, 1.15463391e-01f, -8.28743130e-02f, 6.81054220e-02f, -5.52691370e-02f, -1.98191032e-01f, 5.57006419e-01f,
  8.17327738e-01f, -4.96398568e-01f, -2.21233904e-01f, 3.21254373e-01f, 9.44471508e-02f, 2.92272687e-01f, 1.38703316e-01f, 1.57909423e-01f, 3.09879005e-01f, -2.19409913e-02f,
  -1.02301709e-01f, -4.87365685e-02f, 7.10145512e-04f, -7.37693757e-02f, 1.22884266e-01f, -7.31015056e-02f, 1.06435075e-01f, 1.30858347e-01f, 1.10375099e-01f, 8.40334296e-02f,
  6.33482561e-02f, 1.59215719e-01f, 6.52272254e-02f, -4.67047915e-02f, -3.85902852e-01f, -1.08087584e-01f, -2.86099225e-01f, -2.52535701e-01f, -4.32224452e-01f, -5.54680109e-01f,
  -3.80521059e-01f, -3.41058165e-01f, 1.66284479e-02f, -1.08169660e-01f, -7.46656060e-02f, 8.53964128e-03f, 5.92365451e-02f, -1.27940416e-01f, 4.13339809e-02f, 8.52314848e-03f,
  -3.64261046e-02f, -6.50380319e-03f, -6.19425215e-02f, -1.37166202e-01f, 4.25817408e-02f, 5.59467189e-02f, -1.05574407e-01f, -1.60531979e-02f, -1.76837429e-01f, -1.91161498e-01f,
  -1.10410333e-01f, -8.00188538e-03f, 6.17126301e-02f, -7.86487907e-02f, 8.32131952e-02f, 1.11959428e-02f, -9.56395194e-02f, -6.84144124e-02f, 1.14356466e-02f, 1.23375982e-01f,
  4.10797894e-02f, -8.17449689e-02f, -1.68902099e-01f, 6.15455676e-03f, 1.62867770e-01f, 3.76283862e-02f, 8.88949782e-02f, 8.48073959e-02f, 9.31157842e-02f, 2.36172378e-02f,
  -5.31305699e-03f, 1.99913960e-02f, -9.72455740e-02f, 6.20127246e-02f, -2.17576865e-02f, -4.59398478e-02f, -8.40295032e-02f, -1.02954753e-01f, -5.82811683e-02f, -2.27078889e-02f,
  -7.27803558e-02f, -2.15570126e-02f, -1.19336426e-01f, -1.50908574e-01f, -2.01717496e-01f, -5.89690953e-02f, 7.67063489e-03f, -3.86973582e-02f, -3.90206017e-02f, 1.03964664e-01f,
  -2.17947930e-01f, 3.29192393e-02f, 1.28934085e-01f, -9.56304595e-02f, -1.19525775e-01f, -1.54079393e-01f, -4.37762355e-03f, -6.14540540e-02f, -3.66722085e-02f, -3.24246250e-02f,
  -3.23569700e-02f, 5.70300072e-02f, -1.46948829e-01f, -5.80388792e-02f, 2.29970872e-01f, 1.95150375e-01f, 7.02126026e-02f, -4.99035120e-02f, -1.53696015e-01f, -5.31153008e-02f,
  -8.84971991e-02f, 1.29982129e-01f, 2.70286024e-01f, 1.78180292e-01f, 1.63957834e-01f, 2.95102090e-01f, 4.51333076e-02f, 1.21180043e-01f, 2.55613446e-01f, 4.41939920e-01f,
  -6.14580736e-02f, -3.28682393e-01f, 3.40717793e-01f, -4.58396167e-01f, -1.44520134e-01f, 2.37497061e-01f, 1.65094316e-01f, -1.02861412e-01f, -2.26522595e-01f, -9.72347260e-02f,
  -8.68746173e-03f, 4.16716300e-02f, -2.30649337e-02f, 1.02674834e-01f, 2.16142043e-01f, 2.79331468e-02f, -8.19061622e-02f, 2.67849952e-01f, 2.61282533e-01f, 3.04372478e-02f,
  -1.96915060e-01f, -3.57040256e-01f, -4.81301211e-02f, -1.62916049e-01f, -4.55106109e-01f, -1.11306958e-01f, -1.30337298e-01f, -1.25309527e-01f, 4.66137789e-02f, -3.53440732e-01f,
  -2.44009886e-02f, 2.21696988e-01f, 5.28912023e-02f, 3.93145494e-02f, 3.86384986e-02f, 1.65229384e-02f, 5.44158854e-02f, -1.13307230e-01f, -8.33933577e-02f, -9.59792733e-02f,
  -1.92924775e-02f, -1.08454237e-02f, -8.81017093e-03f, 7.64283875e-04f, -8.32874179e-02f, 6.10283501e-02f, 7.23340437e-02f, 7.58346617e-02f, 5.25042079e-02f, 1.17706172e-01f,
  3.74928042e-02f, 1.00335628e-01f, 7.52149969e-02f, 1.13686137e-01f, 2.24580079e-01f, 8.39810371e-02f, 1.07509205e-02f, 7.30085969e-02f, 2.11167991e-01f, -3.79675068e-02f,
  4.86126496e-03f, -3.56407426e-02f, 1.71962067e-01f, -2.98719797e-02f, 1.54518157e-01f, -2.17425660e-03f, -1.72921102e-02f, -5.42680137e-02f, 1.58907339e-01f, -5.89154698e-02f,
  -1.23697184e-01f, 1.01040885e-01f, 1.51587903e-01f, -5.49436286e-02f, 4.53873761e-02f, -1.14659481e-02f, -2.40436923e-02f, -9.51013938e-02f, 1.61547184e-01f, 5.57742193e-02f,
  -3.03510297e-03f, 1.13874930e-03f, -1.20520808e-01f, 5.43472450e-03f, 2.70200502e-02f, -6.90796971e-02f, 8.41428153e-03f, -1.62358917e-02f, -2.03753337e-01f, -7.56851137e-02f,
  -5.73822558e-01f, 6.94657445e-01f, -6.80911094e-02f, -6.16927482e-02f, -6.78094774e-02f, -1.01757318e-01f, 1.14003561e-01f, -5.92291057e-02f, -2.34394237e-01f, -3.44592221e-02f,
  9.05335769e-02f, 2.72013582e-02f, -6.74893782e-02f, -7.67269060e-02f, 3.48299518e-02f, 7.05198124e-02f, -6.30466864e-02f, -1.87407136e-01f, 6.77648885e-03f, -7.79484585e-02f,
  -3.52948830e-02f, -2.54235842e-04f, -1.39264567e-02f, 7.82534480e-02f, 8.23299289e-02f, 1.68732926e-01f, 9.82686207e-02f, 4.14712168e-02f, 1.71725303e-01f, -1.82301074e-01f,
  -7.91651607e-02f, 3.09306800e-01f, -2.65195698e-01f, -3.52719516e-01f, -4.78917837e-01f, -4.73415136e-01f, -5.38511202e-02f, -1.44380853e-01f, -2.03626275e-01f, 3.20692688e-01f,
  2.00806022e-01f, 1.36144564e-01f, 2.43109435e-01f, 3.43440264e-03f, -7.46273100e-02f, 1.40449896e-01f, -1.80769712e-01f, -4.93336618e-01f, -6.31279230e-01f, -4.90631878e-01f,
  -2.69161850e-01f, -3.81090492e-01f, -4.34143752e-01f, -3.37419689e-01f, -2.58019753e-02f, -9.73448604e-02f, 6.62752315e-02f, -3.01942676e-01f, -2.85817444e-01f, 2.04768330e-02f,
  1.06406599e-01f, -1.54482260e-01f, -9.91775319e-02f, -5.69752418e-03f, 2.60616373e-02f, 1.48425594e-01f, 2.41797194e-02f, 8.60585272e-02f, 1.39489830e-01f, 7.63789117e-02f,
  -4.32058759e-02f, 5.63709885e-02f, -6.60778135e-02f, 2.44162381e-02f, -1.47248387e-01f, -1.09629750e-01f, 2.84636114e-02f, -2.38880608e-03f, -2.30755825e-02f, 1.47304192e-01f,
  1.59178913e-01f, 1.52955027e-02f, 1.72940806e-01f, 1.37646943e-01f, 4.64296900e-02f, -2.32005846e-02f, -1.52350822e-02f, -1.55198751e-02f, 1.66817885e-02f, 1.70048907e-01f,
  -7.04415739e-02f, 1.41320884e-01f, 3.12057100e-02f, -6.00937195e-02f, 1.69083104e-01f, 6.69768304e-02f, -4.52117296e-03f, 1.76545948e-01f, -2.38579474e-02f, 3.32803428e-02f,
  1.45567954e-01f, 9.02139992e-02f, 2.38581188e-02f, 1.85107216e-02f, -3.82620841e-02f, 6.98097348e-02f, -7.15127438e-02f, 1.31834641e-01f, 7.71820396e-02f, 1.62093744e-01f,
  3.07731517e-02f, 1.87263340e-02f, -3.35853957e-02f, -8.80306363e-02f, 1.58599690e-02f, 6.11862727e-03f, -1.05772354e-01f, 6.15216559e-03f, -5.03261238e-02f, -1.04723819e-01f,
  1.61277801e-01f, -1.02181040e-01f, 1.75832212e-01f, -4.53582667e-02f, -2.79564876e-02f, -1.67569127e-02f, 4.05434072e-02f, -4.94635515e-02f, -8.66647065e-02f, -6.60493374e-02f,
  -9.42002013e-02f, 2.96434015e-02f, 4.19778749e-02f, 1.78017244e-02f, -7.01060817e-02f, -2.34410688e-02f, 8.10773075e-02f, 8.42417777e-02f, -4.89534177e-02f, 5.16912527e-02f,
  1.47150487e-01f, 1.71556979e-01f, 2.08010808e-01f, 1.57750085e-01f, -1.05163930e-02f, -2.03800257e-02f, 1.37590900e-01f, 8.85768309e-02f, 6.51982650e-02f, 3.70407909e-01f,
  -9.41970468e-01f, 9.63333473e-02f, 1.28184795e-01f, -2.58607835e-01f, 6.55103505e-01f, 1.79135233e-01f, -1.74088344e-01f, -7.38225222e-01f, -4.86109912e-01f, 3.99032161e-02f,
  4.12470549e-01f, 1.57574683e-01f, -6.09866530e-02f, 1.40379518e-01f, -2.61337608e-01f, 1.92859948e-01f, 3.73622209e-01f, 5.43291271e-02f, -1.88746288e-01f, 2.68441178e-02f,
  3.01633149e-01f, -5.48434556e-02f, -3.49840790e-01f, -2.22144663e-01f, -7.74423033e-02f, 2.76750382e-02f, 1.28022611e-01f, 2.07712203e-01f, 3.32062393e-01f, 5.56168854e-01f,
  -3.57329920e-02f, -5.58725178e-01f, 1.52219534e-01f, 9.02166814e-02f, 2.58153081e-01f, -3.16011339e-01f, -2.07628965e-01f, -1.96728632e-01f, 3.77533399e-02f, -1.61932856e-01f,
  2.96064258e-01f, -3.75550687e-02f, 1.62404180e-01f, 4.19704653e-02f, -1.46221340e-01f, -2.65631825e-01f, -2.69698620e-01f, -4.04380322e-01f, -3.60404581e-01f, -2.42595911e-01f,
  6.30847752e-01f, 4.23848957e-01f, -1.30076408e-01f, -1.20592564e-01f, -5.09760678e-01f, 2.32708260e-01f, -9.55681354e-02f, -2.12438405e-01f, -4.80050266e-01f, -4.89593297e-01f,
  -7.99294934e-02f, 1.16131879e-01f, 1.73878204e-02f, -1.22955590e-01f, -4.39892635e-02f, 1.58746362e-01f, 4.44036126e-02f, 6.86254799e-02f, -2.97892429e-02f, -5.12049869e-02f,
  -2.80136410e-02f, 1.08493147e-02f, -1.42444894e-01f, -2.50606567e-01f, -3.46589126e-02f, 9.76253748e-02f, 5.91540374e-02f, 2.11216155e-02f, 7.19517991e-02f, -6.84365397e-04f,
  9.99623444e-03f, 1.44859292e-02f, 2.06737429e-01f, -1.67255268e-01f, 1.61012217e-01f, -2.46200282e-02f, 9.27006546e-03f, 3.72451879e-02f, -6.00359477e-02f, 3.17903347e-02f,
  -3.98957282e-01f, 4.91119772e-01f, -2.42946863e-01f, -1.68180123e-01f, -4.06792313e-02f, 1.24230169e-01f, -1.36084878e-03f, 1.35222852e-01f, 5.36759058e-03f, -2.12251112e-01f,
  -9.22616646e-02f, -8.07746351e-02f, -1.66711267e-02f, 6.36054156e-03f, -1.53046306e-02f, -1.98387913e-02f, 2.57385612e-01f, 1.19298585e-01f, -1.40317678e-01f, -1.29378738e-03f,
  5.52520109e-03f, -1.24526486e-01f, -2.12862387e-01f, -8.09300393e-02f, -2.35364497e-01f, -8.74518156e-02f, -1.47857308e-01f, -2.69382179e-01f, -3.01416069e-01f, -5.45107782e-01f,
  -8.03934991e-01f, 1.14102788e-01f, 4.48641181e-01f, -2.90401757e-01f, -7.47171938e-02f, -3.24438095e-01f, -2.74038762e-01f, -4.06853735e-01f, -3.77178580e-01f, -1.24925889e-01f,
  1.15617454e-01f, 1.71699688e-01f, 1.28274038e-01f, 1.08078361e-01f, -2.01731786e-01f, -2.23375261e-01f, -2.45957211e-01f, -1.45938352e-01f, -1.24903759e-02f, 2.92216167e-02f,
  1.21122174e-01f, 8.87784336e-05f, -1.29999101e-01f, -1.14247404e-01f, 2.62945771e-01f, 1.91839367e-01f, 2.54138798e-01f, 1.40381813e-01f, 6.29520491e-02f, 2.01634631e-01f,
  6.67813659e-01f, -1.68961525e-01f, -8.32795575e-02f, -1.85468078e-01f, -3.92609946e-02f, -1.64929122e-01f, -5.92373200e-02f, -5.07077016e-02f, -2.06045210e-01f, -5.69649823e-02f,
  -1.91868395e-02f, 2.51841899e-02f, 4.89387773e-02f, 7.78935030e-02f, -4.25460078e-02f, -7.02411979e-02f, -9.61160138e-02f, -4.49124537e-02f, -9.82924644e-03f, -3.77040580e-02f,
  4.95420508e-02f, -1.72228664e-01f, -5.79141919e-03f, -1.86559215e-01f, -1.41065136e-01f, -5.69523647e-02f, 6.11461550e-02f, -1.52946144e-01f, -1.36355862e-01f, -3.88198458e-02f,
  -1.22668035e-01f, -1.48266137e-01f, -1.18291698e-01f, -1.90687587e-03f, -2.89251376e-02f, -8.29400346e-02f, -7.89182559e-02f, -4.39054705e-02f, -6.14382438e-02f, 2.99263354e-02f,
  -1.11055531e-01f, -3.27893011e-02f, -3.32502723e-02f, -2.13799672e-03f, 2.90214345e-02f, -1.18925512e-01f, -1.59655526e-01f, -1.78157203e-02f, 1.55752327e-03f, -1.27497211e-01f,
  -1.31852150e-01f, -1.08641863e-01f, 9.51517299e-02f, -1.54663688e-02f, 5.21432562e-03f, -4.76577915e-02f, -9.56574902e-02f, -7.08955303e-02f, -5.62732406e-02f, -9.02972892e-02f,
  3.71794999e-01f, -2.28548318e-01f, 8.35221484e-02f, -1.03865854e-01f, -7.98514404e-04f, 1.36525985e-02f, 7.28820860e-02f, 3.88060622e-02f, -6.47118464e-02f, 3.57492603e-02f,
  -3.38869132e-02f, 6.27592430e-02f, 9.46967751e-02f, 1.20781317e-01f, 8.55252817e-02f, 1.17108986e-01f, -1.58888012e-01f, -8.35768599e-03f, -1.05097994e-01f, 7.82185607e-03f,
  -1.12448640e-01f, -1.35526031e-01f, 1.33705810e-01f, 1.37270242e-01f, -1.32398233e-01f, 1.18137963e-01f, 4.15918976e-01f, 1.45664245e-01f, 1.71102613e-01f, 1.71680436e-01f,
  6.09663486e-01f, -7.65947342e-01f, -1.74970493e-01f, 8.00720230e-02f, -2.10425600e-01f, -4.73420054e-01f, -1.12742960e+00f, -3.76170725e-01f, 4.61869501e-02f, -6.65549695e-01f,
  -1.66249514e-01f, 8.03294480e-01f, 3.69715601e-01f, 2.76013404e-01f, 9.54960063e-02f, -8.74531031e-01f, -6.87142432e-01f, 3.29315662e-01f, 6.19671941e-01f, 1.75024550e-02f,
  -1.54373825e-01f, 1.96706980e-01f, 3.82550478e-01f, 1.89583644e-01f, -4.56049174e-01f, 1.78321004e-01f, -5.18898547e-01f, -1.56882748e-01f, -3.81428570e-01f, -5.87961376e-01f,
  -8.94395411e-02f, -4.03621286e-01f, 1.75047204e-01f, 1.25339702e-01f, -5.18949702e-03f, 1.37009040e-01f, 6.63765520e-03f, -1.25295252e-01f, 4.69370484e-02f, -1.98504925e-01f,
  1.46591678e-01f, 2.36914456e-02f, 2.42675409e-01f, 5.17309681e-02f, -1.83614120e-01f, -4.06700856e-05f, -9.13162827e-02f, 1.91639159e-02f, -9.45458114e-02f, -2.06378803e-01f,
  -1.66749299e-01f, -2.07563210e-02f, 4.46761511e-02f, -2.15893939e-01f, -6.51433617e-02f, 3.59116971e-01f, -1.86388656e-01f, -5.45689778e-04f, 2.48464402e-02f, -5.23061156e-01f,
  -1.10218458e-01f, 9.51925069e-02f, -1.26963025e-02f, -4.72457800e-03f, 2.64574941e-02f, 9.30883437e-02f, -1.56997107e-02f, -1.77198187e-01f, -2.80264970e-02f, 4.04971205e-02f,
  -2.98407730e-02f, 7.05296621e-02f, 1.07520118e-01f, -2.25253820e-01f, 1.53331310e-01f, 4.91522662e-02f, -3.72087136e-02f, -1.05315231e-01f, -4.26203236e-02f, -3.89775378e-03f,
  1.55934423e-01f, 2.31834259e-02f, 1.04166225e-01f, 4.95176353e-02f, -8.33942145e-02f, 1.11395851e-01f, 1.13833748e-01f, 4.97495644e-02f, 1.01310827e-01f, -1.59778059e-01f,
  3.61558169e-01f, 1.90366283e-01f, -1.43337786e-01f, -3.92353088e-02f, -2.69580990e-01f, -6.60422072e-02f, -1.65232465e-01f, -1.43386319e-01f, 5.97853959e-02f, -1.19930565e-01f,
  -1.46166921e-01f, -1.66942775e-02f, -7.53664821e-02f, -6.88544884e-02f, -1.32827178e-01f, -7.13269189e-02f, -2.58202076e-01f, 5.95951602e-02f, 2.00845413e-02f, -7.28412792e-02f,
  -1.48631567e-02f, -2.26837084e-01f, 1.55533984e-01f, -2.06788089e-02f, -3.67438048e-02f, 3.32691342e-01f, -1.23186670e-01f, -1.52408734e-01f, 2.66963750e-01f, -4.37403738e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  7.15205252e-01f, 5.74161470e-01f, 6.10822022e-01f, 4.89807069e-01f, 5.91077447e-01f, 5.59341550e-01f, 5.48166752e-01f, 5.42007804e-01f, 2.77679175e-01f, 5.03608763e-01f,
  9.65888858e-01f, 6.04732394e-01f, 1.39923021e-01f, 5.27370095e-01f, 6.50891185e-01f, -6.64531365e-02f, 2.58603811e-01f, 9.88735914e-01f, 3.41110051e-01f, 6.49185419e-01f,
  8.15787613e-01f, 7.79774249e-01f, 7.30521262e-01f, 7.03749299e-01f, 4.75121289e-01f, 4.20457155e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -2.78746545e-01f, 2.14143291e-01f, -2.07213104e-01f, -1.34804428e-01f, -2.66650349e-01f, 1.64622329e-02f, -1.50854066e-02f, -3.65566492e-01f, -1.80976987e-01f, -4.44138087e-02f,
  -1.38976663e-01f, -3.97381783e-01f, -6.57896817e-01f, -7.00631380e-01f, -1.08317271e-01f, -1.76155508e-01f, -1.06670395e-01f, -3.54978800e-01f, -1.36690915e-01f, -2.62804180e-01f,
  -3.04855317e-01f, -1.33845165e-01f, -2.14028314e-01f, -2.48823643e-01f, -1.57893017e-01f, -6.86715469e-02f, -5.75484455e-01f, -5.98188341e-02f, -1.92199603e-01f, 2.18624458e-01f,
  -2.65163407e-02f, 1.76098049e-01f, -9.64122042e-02f, -7.47000277e-02f, -4.32625115e-02f, -3.41483086e-01f, 1.81149930e-01f, -1.29691035e-01f, 1.67722628e-01f, -6.52343154e-01f,
  2.24849656e-01f, 7.70995766e-02f, -1.67541593e-01f, 4.17476892e-01f, -2.63219267e-01f, -4.21685457e-01f, -4.53816205e-01f, -2.55602539e-01f, -3.27133089e-02f, -5.21124184e-01f,
  3.90457004e-01f, -6.83536530e-02f, 2.42712393e-01f, 3.20628315e-01f, 7.10240364e-01f, -1.19766152e+00f, -3.62541527e-01f, -6.44934118e-01f, -2.26011232e-01f, 2.15034649e-01f,
  -2.19290793e-01f, -7.00670302e-01f, -2.31774166e-01f, 4.09086883e-01f, 2.13003427e-01f, -2.87234336e-01f, -5.48241511e-02f, 8.55366811e-02f, 2.17165217e-01f, -1.51208892e-01f,
  -2.28990793e-01f, -2.24905327e-01f, -9.26999748e-02f, -4.02126700e-01f, -1.07744172e-01f, 3.84150855e-02f, 1.14710033e-01f, -2.90874988e-02f, 4.54716124e-02f, 1.27529964e-01f,
  -1.91993549e-01f, -2.93364406e-01f, 3.44754718e-02f, -1.11708894e-01f, -4.46772903e-01f, 1.93358123e-01f, 2.87045479e-01f, 2.56748706e-01f, 2.69853383e-01f, -9.88106355e-02f,
  -4.38005239e-01f, 4.21811491e-01f, -2.78373629e-01f, -2.92604059e-01f, -1.80575356e-01f, -7.31291696e-02f, 2.81482756e-01f, 3.74532878e-01f, 3.15262020e-01f, -2.21364811e-01f,
  -5.89919314e-02f, 1.08991556e-01f, -1.90052241e-01f, -4.52109128e-02f, 6.98710456e-02f, -1.97101861e-01f, -1.02048504e+00f, -1.00057185e-01f, -1.94859989e-02f, 1.30577654e-01f,
  -2.34639794e-01f, 1.36415631e-01f, -9.68051851e-01f, -9.95584279e-02f, 2.06186116e-01f, 4.53596443e-01f, -1.30100858e+00f, 7.64100254e-01f, 8.79809380e-01f, -2.11737528e-02f,
  2.16152728e-01f, -7.03510523e-01f, 3.75880271e-01f, 2.13823289e-01f, 1.11902058e-02f, -1.21450877e+00f, -3.47408772e-01f, 9.97604549e-01f, 7.16161281e-02f, 1.58755630e-01f,
  1.81507599e-02f, 2.52917856e-01f, 2.21157059e-01f, 5.04199229e-02f, 1.55855358e-01f, 2.00092211e-01f, 1.11607149e-01f, 1.02913238e-01f, 1.58902138e-01f, 1.45496994e-01f,
  2.91849170e-02f, 1.93872064e-01f, 6.56191781e-02f, 1.77824751e-01f, 3.27772833e-03f, 1.26134977e-01f, 2.53635138e-01f, -4.33522969e-01f, -7.94620067e-02f, -2.69279331e-02f,
  -8.40594321e-02f, 9.48842317e-02f, 4.57128018e-01f, -1.72265008e-01f, 2.81367183e-01f, 2.12515429e-01f, -1.60271034e-01f, -2.86377013e-01f, 6.32377982e-01f, 3.96997422e-01f,
  2.49903575e-01f, 3.53752643e-01f, -1.71060398e-01f, 3.66393358e-01f, -2.98120409e-01f, -3.43162626e-01f, -4.37803060e-01f, -2.71963418e-01f, 1.99199244e-01f, -7.68800318e-01f,
  -1.51400194e-01f, -7.97666550e-01f, -6.38367593e-01f, -1.55268356e-01f, -6.05484486e-01f, -3.53234351e-01f, 1.35104448e-01f, -1.52480468e-01f, -7.32008219e-01f, -4.70366180e-01f,
  8.16941261e-01f, 2.10161358e-02f, 5.22016168e-01f, 1.55948460e-01f, 1.52329534e-01f, -5.99080026e-01f, -1.29249975e-01f, 1.55277148e-01f, -5.15787840e-01f, 4.66331542e-01f,
  -4.90790121e-02f, 6.89668000e-01f, -3.18588942e-01f, -2.00593635e-01f, -8.30750763e-02f, 3.38596366e-02f, -4.12785299e-02f, -2.96407025e-02f, 1.58018433e-02f, -6.98358864e-02f,
  -2.24157140e-01f, -6.30104914e-02f, -3.02432925e-01f, -1.54738039e-01f, 2.16569766e-01f, 3.64401311e-01f, 5.77675849e-02f, 5.43514118e-02f, -7.60981664e-02f, -2.05607086e-01f,
  -2.91572034e-01f, -1.63009390e-02f, 1.02143355e-01f, -4.06238064e-02f, 3.90697956e-01f, -4.75467034e-02f, -2.11308375e-01f, 2.35791415e-01f, 2.92089999e-01f, 7.46812671e-02f,
  -2.81763345e-01f, 2.81039536e-01f, -3.15165013e-01f, -7.93249533e-02f, -2.45201103e-02f, 1.22104004e-01f, -1.43307135e-01f, -2.59932876e-01f, 1.44872472e-01f, 5.87847292e-01f,
  1.04372072e+00f, -2.83039600e-01f, -5.25904536e-01f, 2.85071522e-01f, 3.06546688e-01f, -3.34046274e-01f, -4.90839332e-01f, -3.90176207e-01f, -5.96789718e-01f, -3.36218536e-01f,
  -9.64627340e-02f, -5.64480066e-01f, 4.77220595e-01f, 9.23194438e-02f, 4.54575747e-01f, -9.67157364e-01f, -4.77641791e-01f, -3.17555875e-01f, -1.18666612e-01f, -3.20000708e-01f,
  -4.22696501e-01f, 8.97843361e-01f, 1.01817280e-01f, 6.90392137e-01f, -3.34075451e-01f, -1.21688771e+00f, 8.40881020e-02f, -1.84623227e-01f, -1.52477041e-01f, -2.23707259e-01f,
  7.68100768e-02f, 2.07526255e-02f, 1.39544755e-01f, 2.36508045e-02f, 2.81834952e-03f, -1.99380457e-01f, -8.28371868e-02f, 6.04488365e-02f, 5.81135571e-01f, 1.97374374e-01f,
  -3.06445688e-01f, -4.25708711e-01f, -1.38341375e-02f, -9.32694450e-02f, 3.71478736e-01f, -6.12624407e-01f, 3.29239100e-01f, 6.68223714e-03f, -5.33557057e-01f, -2.22859859e-01f,
  -1.79410473e-01f, 2.30425090e-01f, 2.95796275e-01f, 1.97272018e-01f, 4.38633114e-01f, 1.58743843e-01f, -1.15590304e-01f, -4.04949635e-01f, 3.35515618e-01f, -3.07582945e-01f,
  -1.33824006e-01f, 5.16367018e-01f, 1.37883469e-01f, -5.53329945e-01f, -1.43378842e+00f, 1.90684855e-01f, 6.09885901e-02f, 3.34710032e-01f, 5.67034423e-01f, 2.15665195e-02f,
  1.50872499e-01f, -3.26451421e-01f, 1.17090382e-01f, -7.16448843e-01f, -8.89914036e-01f, -2.26856899e-02f, -1.87646702e-01f, 1.06653407e-01f, 1.67728677e-01f, 1.15970224e-01f,
  -8.19801211e-01f, -1.03499100e-01f, 5.08665629e-02f, 6.19192064e-01f, -7.92606533e-01f, -4.20876592e-01f, 3.18563789e-01f, -2.55575746e-01f, -2.94242240e-02f, -2.69535571e-01f,
  -8.28081518e-02f, 3.68745446e-01f, -2.18266854e-03f, 2.68557340e-01f, 2.14607939e-02f, 2.16565549e-01f, 5.90705313e-02f, 4.57177013e-01f, 1.39777645e-01f, 3.74739170e-01f,
  4.61604476e-01f, 1.97198123e-01f, -1.05770305e-01f, 5.86810075e-02f, 2.40520149e-01f, 8.79108608e-02f, 1.16562612e-01f, -3.28107784e-03f, 3.93224321e-02f, 6.12384200e-01f,
  -3.71772617e-01f, -2.79382855e-01f, -9.85640362e-02f, 7.82544687e-02f, -3.30064178e-01f, -2.95929611e-01f, 1.96888149e-01f, -3.72940630e-01f, -2.07962409e-01f, 5.77380098e-02f,
  4.92047220e-01f, -3.20319265e-01f, 4.81634080e-01f, -4.18440789e-01f, 3.30634594e-01f, -2.45955601e-01f, -1.47810295e-01f, -3.67833823e-02f, 1.92962512e-01f, -1.82478845e-01f,
  1.00060582e-01f, 4.86959657e-03f, -6.16249859e-01f, 8.27292740e-01f, 1.97199598e-01f, -9.55690861e-01f, -3.99329275e-01f, 3.03203076e-01f, 3.61190438e-01f, 3.14505517e-01f,
  -1.78812847e-01f, -3.79844844e-01f, -1.27851951e+00f, -2.06114233e-01f, -1.92813337e-01f, -3.45486283e-01f, -3.83660436e-01f, 9.32518661e-01f, 3.44354898e-01f, -7.55216837e-01f,
  5.10040343e-01f, -6.84071720e-01f, -3.22703451e-01f, -3.94814700e-01f, 3.85211967e-02f, -4.70202059e-01f, 8.96874815e-02f, -6.05535097e-02f, 1.67153537e-01f, 5.14757745e-02f,
  1.34881493e-02f, -8.81016906e-03f, 8.94887075e-02f, -6.71073571e-02f, 1.62098229e-01f, 2.25628033e-01f, -5.32960773e-01f, 2.14755699e-01f, 6.56145290e-02f, 1.93112969e-01f,
  1.74452469e-01f, 3.00601739e-02f, 4.81233835e-01f, 3.51196885e-01f, 3.40059876e-01f, 5.26465997e-02f, -3.25028390e-01f, 4.43334609e-01f, 6.01230979e-01f, -2.82938965e-02f,
  2.27546155e-01f, -2.78199255e-01f, 3.62394214e-01f, -5.71008205e-01f, 2.79995888e-01f, 6.44466504e-02f, -4.39402699e-01f, 5.52296996e-01f, -2.09671050e-01f, -3.00408006e-01f,
  -1.76589370e-01f, -3.54061902e-01f, -2.91466773e-01f, -8.92431855e-01f, 1.88002869e-01f, -5.78565240e-01f, -3.69268030e-01f, -5.97423017e-01f, 2.44402647e-01f, 7.33875453e-01f,
  -6.08461261e-01f, 5.56677163e-01f, 3.32669705e-01f, -1.89177513e-01f, -1.47490278e-01f, 2.74261117e-01f, -2.44418234e-01f, -2.47031748e-01f, -9.32724416e-01f, 3.15246493e-01f,
  -7.34049439e-01f, -2.77117938e-01f, -5.67678034e-01f, -5.51008761e-01f, -4.59393919e-01f, -1.10214412e+00f, -1.53532028e-01f, -9.21649516e-01f, -9.11064297e-02f, -3.65306158e-03f,
  1.09001040e-01f, 2.66177999e-03f, 1.72891002e-02f, -3.31751913e-01f, -2.35181734e-01f, -5.03934443e-01f, -2.37568617e-01f, -4.91451979e-01f, -1.29566893e-01f, -4.06944573e-01f,
  -7.72633329e-02f, -1.51605919e-01f, -1.59545481e-01f, 1.12216294e-01f, -7.52998143e-03f, -2.54170924e-01f, -1.57502607e-01f, -6.65211156e-02f, 6.83656782e-02f, -9.64786783e-02f,
  2.40544647e-01f, -2.57668067e-02f, -2.08819702e-01f, 3.12632382e-01f, 1.25571653e-01f, -3.29238266e-01f, 2.07476526e-01f, 4.09353793e-01f, 3.37668955e-01f, 1.20020650e-01f,
  -8.06932598e-02f, -2.15308040e-01f, 2.04121515e-01f, 1.70759663e-01f, -2.17708483e-01f, -8.91425535e-02f, 6.58749223e-01f, 4.35847104e-01f, -1.24803156e-01f, -4.99826223e-01f,
  -3.23629737e-01f, -3.50617766e-02f, 1.26347825e-01f, -7.83430994e-01f, 6.16842806e-01f, -1.32514194e-01f, -5.92793107e-01f, -4.81937438e-01f, -5.32110155e-01f, -4.27931935e-01f,
  1.74917966e-01f, -5.06471619e-02f, -9.48711157e-01f, -4.16553468e-01f, 3.72611612e-01f, -1.07997775e-01f, -4.81791466e-01f, 5.23684453e-03f, -3.64273012e-01f, 8.05136681e-01f,
  -1.67669863e-01f, -2.36312091e-01f, 3.00712496e-01f, 1.70658588e-01f, 1.74952969e-01f, 4.96573076e-02f, -1.32989943e-01f, 1.34376794e-01f, -3.46154161e-02f, 1.23142064e-01f,
  7.16350321e-03f, 2.79360656e-02f, 2.25662485e-01f, 7.17837512e-02f, -4.87212613e-02f, -1.14992231e-01f, -3.29998612e-01f, -2.28594601e-01f, 4.95005660e-02f, 2.27900341e-01f,
  7.65303895e-02f, -6.11057468e-02f, -2.08061740e-01f, 9.31621790e-02f, 4.59214300e-01f, 2.95860857e-01f, -4.15920526e-01f, -1.44335598e-01f, -2.25386411e-01f, -2.10124895e-01f,
  -2.11283281e-01f, 5.24723623e-03f, 6.22414112e-01f, -3.24421525e-01f, -4.95885193e-01f, 4.18616295e-01f, 2.97491103e-01f, 5.86217821e-01f, 3.77408750e-02f, 2.57241011e-01f,
  -1.54161915e-01f, 1.52420387e-01f, -3.59314591e-01f, -3.08151066e-01f, -3.97392094e-01f, -6.60986602e-01f, -1.44540787e-01f, -8.08798969e-02f, -3.38731974e-01f, -4.30189222e-01f,
  9.14697707e-01f, 1.76245794e-01f, -4.50876564e-01f, -7.19299376e-01f, -4.78041321e-01f, -8.74744728e-02f, -6.25627697e-01f, 7.58046985e-01f, 3.78732979e-01f, -4.36757326e-01f,
  6.43442512e-01f, 2.30851788e-02f, -7.09628999e-01f, 9.05338079e-02f, -2.03216448e-01f, -2.74643958e-01f, 2.42608748e-02f, 3.70941341e-01f, 5.90927079e-02f, -2.88825750e-01f,
  2.00002976e-02f, 2.35584989e-01f, -2.10825026e-01f, 1.74201995e-01f, 1.80318147e-01f, -1.65909454e-01f, 9.96394828e-02f, -6.04870506e-02f, 3.60352099e-01f, -7.63391107e-02f,
  -5.54428473e-02f, -7.67552406e-02f, 1.71295684e-02f, 3.30791622e-02f, -7.80198276e-01f, 5.82207382e-01f, 2.63902605e-01f, 3.03844571e-01f, -4.38316852e-01f, -5.43850303e-01f,
  -4.35028255e-01f, 1.28575772e-01f, 2.29326844e-01f, 3.47832531e-01f, 3.83693874e-01f, -5.22369370e-02f, -7.96614528e-01f, 1.98780328e-01f, 5.30926943e-01f, -7.10944831e-01f,
  -3.77186865e-01f, -1.30590707e-01f, 2.61116117e-01f, -6.87441900e-02f, -9.23714817e-01f, -5.77142797e-02f, 2.11652547e-01f, 1.77878112e-01f, -7.53105164e-01f, 1.69465035e-01f,
  -4.23594058e-01f, 5.62879562e-01f, 6.37627959e-01f, 2.90928632e-01f, -5.13964355e-01f, 6.89043924e-02f, -5.95896006e-01f, -7.46252000e-01f, -3.03048968e-01f, -1.35702550e-01f,
  -3.10424984e-01f, -1.56104237e-01f, -3.04411739e-01f, 1.25507385e-01f, -5.88332295e-01f, -5.59715271e-01f, -2.44138181e-01f, 9.88492787e-01f, 3.75660658e-01f, -2.78141573e-02f,
  7.32591897e-02f, -4.80233766e-02f, 1.31449208e-01f, -1.59903556e-01f, -2.28383373e-02f, 9.91124660e-02f, -3.27912308e-02f, 3.69461402e-02f, 2.00061247e-01f, 6.68950900e-02f,
  -1.17097586e-01f, -2.71247141e-02f, -1.00917406e-01f, 1.09382853e-01f, 1.33238062e-01f, 1.09273441e-01f, 2.25185022e-01f, 2.37701073e-01f, -2.79638708e-01f, 3.49784166e-01f,
  -3.86340737e-01f, 1.42345145e-01f, 4.96896088e-01f, -3.68418783e-01f, -3.09894145e-01f, -3.19017738e-01f, -1.20245509e-01f, -1.21849410e-01f, -1.84379384e-01f, -2.58048981e-01f,
  -2.34289840e-01f, -1.80654034e-01f, -4.62229103e-01f, -3.28063965e-01f, -1.06197298e-01f, 7.54826516e-02f, -3.66463184e-01f, 4.08523560e-01f, 4.94871467e-01f, 4.81879354e-01f,
  -5.46316385e-01f, -1.01888013e+00f, 5.34153581e-01f, -1.43989295e-01f, -4.01826262e-01f, -1.60471007e-01f, -3.31297815e-01f, -3.38718414e-01f, -5.48769176e-01f, -5.40548146e-01f,
  -1.27071962e-01f, -1.87760979e-01f, -7.10129321e-01f, -5.54901838e-01f, -1.31081164e-01f, 3.48922819e-01f, -3.71641010e-01f, -3.32889222e-02f, -4.15268540e-01f, -1.45267740e-01f,
  4.65688556e-01f, -1.51685476e-01f, 9.31260288e-01f, -8.12701657e-02f, 1.07943781e-01f, 5.12602106e-02f, 5.77608049e-02f, 1.36100963e-01f, -1.81447998e-01f, 3.18004750e-02f,
  5.98144904e-02f, 8.90998021e-02f, -1.17029086e-01f, 2.02814460e-01f, -1.46043360e-01f, -3.00127655e-01f, 1.75491780e-01f, -1.11381806e-01f, 1.64724961e-01f, 1.87976003e-01f,
  -6.27553388e-02f, 1.66784719e-01f, 3.12040895e-01f, -4.37332958e-01f, 2.84698814e-01f, -1.69310674e-01f, 1.77531287e-01f, 4.17079151e-01f, 4.65135217e-01f, 2.52385020e-01f,
  -2.53578573e-01f, -1.59829304e-01f, -1.86211504e-02f, 5.31335652e-01f, -7.54827976e-01f, 1.93890691e-01f, -5.30037463e-01f, 3.49214673e-01f, 2.34430224e-01f, -3.00847381e-01f,
  1.47005007e-01f, 1.05201714e-01f, -5.83394647e-01f, -4.97422308e-01f, -5.84038377e-01f, -1.57946676e-01f, 3.72384191e-02f, -6.27913296e-01f, 5.39625168e-01f, -4.51304406e-01f,
  5.71495295e-01f, -7.25660503e-01f, 2.65195463e-02f, 7.44846761e-01f, -3.66134882e-01f, 8.79612327e-01f, -1.24300174e-01f, -2.26782426e-01f, -4.75149751e-01f, -6.51134133e-01f,
  -3.42607111e-01f, 5.05585372e-01f, -4.39739197e-01f, 4.05488938e-01f, -1.06799617e-01f, -2.70439446e-01f, -1.28070444e-01f, -4.55664665e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.06079513e-01f, -1.50847733e-01f, 1.15790337e-01f, -2.54285067e-01f, 7.12466612e-02f, 3.52859013e-02f, 1.06242396e-01f, -6.05108216e-02f, -3.46237756e-02f, 1.42311096e-01f,
  6.18072934e-02f, 3.57008688e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    