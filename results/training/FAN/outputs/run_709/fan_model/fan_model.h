/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.55439317e-01f, -6.77207485e-02f, 2.02234998e-01f, 6.68051392e-02f, 1.03815019e-01f, 5.40698953e-02f, -1.66047439e-01f, -4.82226089e-02f, 2.98529379e-02f, -7.60301575e-02f,
  1.77991600e-03f, -2.94332225e-02f, -5.16654328e-02f, -9.42872539e-02f, -1.50027454e-01f, -9.20184031e-02f, -2.38482617e-02f, -2.25719791e-02f, -1.41354539e-02f, -1.48411751e-01f,
  -1.25210613e-01f, 7.02802166e-02f, 2.83378586e-02f, 9.25803557e-03f, 7.66135231e-02f, -7.79853985e-02f, 1.22042336e-01f, 1.17790461e-01f, -4.21409048e-02f, -2.42529660e-02f,
  9.95655209e-02f, 1.48905829e-01f, -3.79184708e-02f, -1.44351441e-02f, -2.97281630e-02f, -6.44301623e-02f, -7.92133063e-02f, -3.00751328e-02f, 6.85416833e-02f, -6.46249726e-02f,
  5.68913156e-03f, 8.46396163e-02f, 5.96689433e-02f, -2.37544794e-02f, 3.77367921e-02f, 9.97572318e-02f, 2.27525849e-02f, 1.64470226e-02f, 5.51655516e-02f, 7.16810897e-02f,
  3.06927953e-02f, 1.88465938e-01f, 1.13873743e-01f, 1.11496588e-02f, 1.30733117e-01f, 3.96740697e-02f, -9.75081883e-03f, 1.14462525e-01f, 6.00794293e-02f, -3.18752453e-02f,
  5.46967685e-02f, -3.99952605e-02f, -9.13966149e-02f, 1.08102830e-02f, 3.93213406e-02f, -3.36597092e-03f, 1.01546325e-01f, -4.71984781e-02f, 3.66682187e-02f, -5.50104007e-02f,
  9.11935121e-02f, 5.70000224e-02f, 2.17836797e-02f, 7.38837430e-03f, -2.44573075e-02f, 1.21574581e-01f, 8.26101284e-03f, 5.52611472e-03f, 5.99938445e-02f, 4.52346131e-02f,
  8.96556117e-03f, 1.03082560e-01f, -3.51562165e-02f, -7.63733461e-02f, 1.04681365e-01f, 4.81594726e-02f, 5.22249341e-02f, 5.46438880e-02f, -1.67977978e-02f, 1.56642169e-01f,
  -1.78525880e-01f, -7.52253830e-02f, -1.63977910e-02f, -2.52863243e-02f, 4.27196175e-03f, -5.35524962e-03f, 4.54199724e-02f, -1.04966447e-01f, -5.89258485e-02f, -7.19290823e-02f,
  1.30432934e-01f, 7.51611814e-02f, -2.09620632e-02f, 1.44000119e-02f, -1.20721385e-02f, -5.15553802e-02f, -3.55634019e-02f, -3.46824005e-02f, 1.51437428e-02f, 7.64825847e-03f,
  -4.32821773e-02f, 5.35019152e-02f, 2.14156657e-02f, -3.78254279e-02f, 9.47021693e-03f, -2.90959459e-02f, -2.82864552e-02f, -1.23148873e-01f, -8.39417204e-02f, -1.63873807e-01f,
  2.09933370e-01f, -9.77288932e-02f, 1.01281419e-01f, 8.91122073e-02f, -1.02691755e-01f, -2.27494448e-01f, -2.92485148e-01f, -1.94565013e-01f, 3.14273052e-02f, -3.28510744e-03f,
  -2.03532994e-01f, -2.60040388e-02f, 2.90656332e-02f, 7.92457536e-02f, -1.28949210e-01f, 2.18143780e-02f, 1.92819893e-01f, 1.42698929e-01f, -6.67975172e-02f, -2.20315605e-01f,
  -7.43314847e-02f, 1.97721615e-01f, 1.34813309e-01f, 1.14141643e-01f, 1.74879000e-01f, 3.17897014e-02f, 2.22378686e-01f, 1.59098700e-01f, -9.96171683e-03f, 2.64992326e-01f,
  2.11232081e-01f, 9.39865261e-02f, 1.55516878e-01f, 2.87698563e-02f, 1.25834018e-01f, 6.49781376e-02f, 8.52760486e-03f, 2.56434113e-01f, 5.51908500e-02f, 9.96634439e-02f,
  8.46907496e-03f, -9.67109855e-03f, -1.57558993e-02f, 1.04633331e-01f, 6.55855834e-02f, 1.45210385e-01f, 9.47473273e-02f, 2.57081121e-01f, 2.39716992e-02f, 1.68183427e-02f,
  -1.18664779e-01f, -4.31898013e-02f, -3.19376886e-02f, -6.13001660e-02f, -1.09372344e-02f, 6.00046702e-02f, 5.25765270e-02f, 5.74556291e-02f, 5.63266315e-02f, 2.50935227e-01f,
  -7.37967044e-02f, -5.96791171e-02f, -7.79445991e-02f, -5.19642187e-03f, -1.10231504e-01f, -5.54450825e-02f, -1.13645509e-01f, -4.79748137e-02f, -8.22618082e-02f, -5.48108593e-02f,
  -2.16357578e-02f, 3.03787068e-02f, -1.27563462e-01f, -7.90544320e-03f, -9.37485173e-02f, -4.99972478e-02f, -9.61878300e-02f, 3.22569208e-03f, 1.32554360e-02f, -3.01368884e-03f,
  -5.41376024e-02f, -9.11800750e-03f, -5.99371940e-02f, -5.57509847e-02f, -7.43928477e-02f, -7.13566318e-02f, -8.17645788e-02f, -1.52118132e-01f, -1.10618606e-01f, -1.06734067e-01f,
  2.88151085e-01f, 7.43069798e-02f, 3.36612344e-01f, 1.38433680e-01f, 4.48127128e-02f, 1.39500245e-01f, 1.21142417e-01f, 1.27324760e-01f, 1.32128119e-01f, -6.08290872e-03f,
  -1.32039702e-02f, 1.16381980e-02f, 1.07410990e-01f, 1.63183048e-01f, 1.08449392e-01f, 1.06378116e-01f, 1.75003409e-02f, 1.16695456e-01f, 1.49914309e-01f, 2.69085150e-02f,
  8.32398012e-02f, 3.66930068e-02f, 1.48633629e-01f, 2.05148578e-01f, 4.69673537e-02f, 3.89422104e-02f, 1.18954785e-01f, 1.02347903e-01f, -1.36071602e-02f, 2.44960546e-01f,
  1.17832579e-01f, -4.11298349e-02f, 1.55091345e-01f, -5.93350194e-02f, -2.96558756e-02f, -1.96500286e-01f, -2.25787848e-01f, -6.04647473e-02f, 3.08306888e-02f, -8.34844261e-02f,
  1.27844378e-01f, 8.08877870e-03f, -7.17732608e-02f, 3.10127549e-02f, -8.76993760e-02f, 6.97247833e-02f, 1.63838491e-01f, 1.01188548e-01f, -1.47360340e-01f, -1.58214048e-01f,
  -1.03153005e-01f, -5.93872778e-02f, 1.51634738e-01f, -3.13645341e-02f, -8.38865712e-02f, -4.94854525e-03f, 1.00225538e-01f, 1.10624962e-01f, 8.04389939e-02f, 1.49968222e-01f,
  5.54707944e-02f, 7.29582757e-02f, -5.34807630e-02f, 1.28656905e-02f, 8.43495280e-02f, 5.79945892e-02f, 8.91837776e-02f, 1.00666031e-01f, 7.98371527e-03f, 2.24833116e-02f,
  7.56191984e-02f, 9.90654752e-02f, 9.36804190e-02f, 4.26471978e-02f, 3.66004147e-02f, -5.23457900e-02f, 9.60389674e-02f, 8.96751061e-02f, 6.80843964e-02f, 4.53739166e-02f,
  2.97783781e-02f, 4.37137634e-02f, 4.33048680e-02f, -5.93007170e-02f, 7.38317668e-02f, 1.31816760e-01f, 7.72641525e-02f, 9.94205624e-02f, 3.48522365e-02f, 2.12523006e-02f,
  -2.73229014e-02f, -1.18629113e-01f, -7.66402259e-02f, -1.35949910e-01f, -1.08296871e-01f, -9.63585153e-02f, 1.07572768e-02f, -7.35475123e-02f, -1.85050279e-01f, -8.67553949e-02f,
  -1.23626038e-01f, -8.15864429e-02f, -9.59476233e-02f, -4.14695367e-02f, -4.15458530e-02f, -3.40339243e-02f, -4.67805825e-02f, -1.40182793e-01f, -2.04276480e-02f, -1.84148550e-02f,
  -7.23626763e-02f, -1.00016475e-01f, -1.08562328e-01f, -1.52261764e-01f, -1.53260510e-02f, -7.30986819e-02f, -5.54570518e-02f, -1.45830726e-03f, -9.20408070e-02f, -3.38000692e-02f,
  -2.67050713e-01f, 1.16861388e-01f, -6.12947941e-02f, -1.10505648e-01f, -5.54946950e-03f, 8.07411745e-02f, -2.76523130e-03f, 6.53109401e-02f, 4.75942716e-02f, 4.56854850e-02f,
  1.82297025e-02f, 1.20538361e-02f, 7.78332576e-02f, -3.30126695e-02f, -3.80336456e-02f, 8.30521137e-02f, -3.69899347e-02f, 6.45931736e-02f, -2.64018513e-02f, -6.70060590e-02f,
  2.89736744e-02f, -1.15903020e-01f, -9.38466191e-02f, -8.29717219e-02f, 7.78284948e-03f, -4.00980711e-02f, -4.90591899e-02f, -1.74207911e-01f, -6.76038191e-02f, -2.26827025e-01f,
  -1.68954805e-01f, -2.67941505e-01f, -1.03028312e-01f, 6.43983930e-02f, 2.95950383e-01f, 1.14305414e-01f, -1.90866161e-02f, 1.53992679e-02f, -2.27133948e-02f, -3.81285883e-02f,
  -9.18605775e-02f, 3.03234607e-02f, -2.13288799e-01f, -2.30622187e-01f, -2.89179534e-01f, -4.66010012e-02f, 1.04933523e-01f, -1.40971228e-01f, 2.74335183e-02f, 1.23946957e-01f,
  2.13042334e-01f, 1.40774250e-01f, -1.56639457e-01f, -6.08241884e-03f, 1.36890009e-01f, -5.25667593e-02f, -1.10780559e-01f, 2.24255025e-02f, -1.50682330e-01f, 4.37123366e-02f,
  -2.92293280e-01f, -1.65677413e-01f, -2.29338072e-02f, -6.38984516e-02f, 2.68291682e-02f, -5.43855950e-02f, -7.61520267e-02f, -1.65738031e-01f, -8.09565037e-02f, -1.33509904e-01f,
  -1.02927469e-01f, -1.66033223e-01f, 2.21270472e-02f, -4.72919866e-02f, -1.06454603e-01f, -1.34643108e-01f, -5.23408055e-02f, -1.65246561e-01f, -2.05963299e-01f, -1.26371980e-01f,
  -2.96189971e-02f, -4.80592018e-03f, 2.79315524e-02f, -1.52505726e-01f, -1.45270199e-01f, -1.32039681e-01f, -8.84889737e-02f, -7.44765177e-02f, -2.31406599e-01f, -5.23318574e-02f,
  -2.29807645e-02f, 8.52034613e-02f, -2.44597197e-02f, 6.87057376e-02f, 7.21531287e-02f, -6.37924522e-02f, 1.11936301e-03f, 3.84079963e-02f, 1.09182186e-01f, 6.54026924e-04f,
  -3.68874031e-03f, 5.26029766e-02f, -3.84617709e-02f, 1.86481141e-02f, 8.90608318e-03f, -6.62347004e-02f, -1.21375090e-02f, 1.05957398e-02f, -2.13369094e-02f, -1.04099289e-02f,
  -1.88628174e-02f, -1.97632685e-02f, 3.68015724e-03f, -6.34509027e-02f, 6.22930191e-03f, 2.18310598e-02f, -8.86979848e-02f, 3.36424145e-03f, 8.51818174e-02f, 4.77464125e-02f,
  2.53707245e-02f, -7.99020827e-02f, 9.50917881e-03f, -8.55412856e-02f, -6.56754803e-03f, -3.23258899e-02f, -3.36380228e-02f, -2.55360920e-02f, -3.67153995e-02f, 5.01521416e-02f,
  1.09385382e-02f, -2.30170786e-02f, -1.51374996e-01f, -1.77039336e-02f, 8.63199960e-03f, -6.33213073e-02f, -1.32268062e-02f, 9.48200896e-02f, -5.91024905e-02f, 3.92714934e-03f,
  -4.52717766e-02f, 7.39302114e-02f, 2.37543862e-02f, -9.09754857e-02f, 1.04166679e-01f, 6.47023618e-02f, -1.81123754e-03f, -2.50922944e-02f, -3.88356484e-02f, 4.92532663e-02f,
  -4.89831209e-01f, -8.77503380e-02f, -1.26686245e-01f, 4.85567711e-02f, 3.56576703e-02f, 7.30268657e-02f, -1.64926965e-02f, 1.43084722e-02f, 1.27428055e-01f, -5.44404685e-02f,
  1.58986360e-01f, 2.22667173e-01f, 2.54918694e-01f, 2.41525903e-01f, 6.08976558e-02f, -8.17334577e-02f, 1.17333904e-01f, 1.20531619e-02f, 4.20322195e-02f, 2.42468759e-01f,
  2.05882773e-01f, -4.05046642e-02f, -8.27542543e-02f, -3.04687377e-02f, -1.43805087e-01f, -4.83361296e-02f, -9.44540799e-02f, -2.58718073e-01f, -9.34643298e-02f, -1.35618433e-01f,
  -1.06083564e-01f, -2.77536094e-01f, 3.73578891e-02f, 2.01866347e-02f, -4.84218113e-02f, -1.20719103e-02f, -2.03873049e-02f, -1.55513197e-01f, -3.65349511e-03f, -1.00181177e-02f,
  -8.55501294e-02f, 3.69695760e-02f, -2.53300853e-02f, 1.83806643e-02f, -7.01300353e-02f, -5.70823299e-03f, -9.39961821e-02f, -1.56916469e-01f, -2.26944163e-02f, -3.18487361e-02f,
  5.69640100e-02f, -2.70359088e-02f, -1.19512558e-01f, -1.11527443e-01f, -1.27487868e-01f, -1.38528138e-01f, -2.36802310e-01f, -1.29689649e-01f, -2.77317703e-01f, -3.04294050e-01f,
  1.33964568e-02f, -4.70410064e-02f, -2.34439895e-02f, -3.19906399e-02f, -4.95570991e-03f, 8.85715242e-03f, -1.71163101e-02f, -1.51024479e-02f, -2.33361479e-02f, 5.11186803e-03f,
  2.22442038e-02f, 1.01279460e-01f, -3.01193446e-02f, -1.92593469e-03f, 7.97517300e-02f, 1.75240450e-02f, -5.23064770e-02f, -6.47712722e-02f, 7.37654120e-02f, -2.48233713e-02f,
  2.70304736e-02f, 3.81347910e-02f, 5.30238934e-02f, 9.04724449e-02f, -1.68175921e-02f, -4.29524109e-02f, 5.34489825e-02f, 8.51258263e-02f, 1.12493373e-02f, -1.04119498e-02f,
  8.65090564e-02f, 1.00763835e-01f, -1.24952443e-01f, -2.84680780e-02f, -1.16712332e-01f, -1.81955062e-02f, -1.21522527e-02f, -3.23113762e-02f, -6.59970641e-02f, -3.73323448e-02f,
  -6.07416295e-02f, -8.32558796e-02f, -6.83535114e-02f, -5.19482344e-02f, -3.11295893e-02f, -4.19256352e-02f, 5.71076646e-02f, -4.92928065e-02f, -5.13789803e-02f, 6.79936213e-03f,
  5.22493906e-02f, 5.11787683e-02f, 4.15276699e-02f, 3.22765224e-02f, -1.52311325e-01f, 1.99241899e-02f, -1.10579289e-01f, -9.69063863e-02f, -1.62641644e-01f, 8.76738783e-03f,
  5.48557043e-02f, 2.14716539e-01f, 3.22856545e-01f, -1.57289028e-01f, -6.31841272e-02f, -1.54760674e-01f, -1.20194003e-01f, -4.47100960e-02f, 1.32935913e-02f, -4.28244360e-02f,
  -7.71518648e-02f, -1.67272046e-01f, -1.24552259e-02f, 1.66913997e-02f, -1.04113683e-01f, 1.18375093e-01f, 7.76294339e-03f, 8.89585540e-02f, -1.31372705e-01f, -2.08261117e-01f,
  -1.62813962e-01f, 5.22138402e-02f, 7.69066289e-02f, 3.99619825e-02f, 8.94632787e-02f, -1.85313687e-01f, 2.49536902e-01f, 1.65012300e-01f, 1.11559682e-01f, 3.22690696e-01f,
  2.17812717e-01f, 2.21886814e-01f, -8.76076892e-02f, 2.00953763e-02f, 9.57137123e-02f, 5.93858771e-02f, -2.87082624e-02f, 3.31616588e-02f, 1.39384354e-02f, 1.07012950e-01f,
  7.92024955e-02f, 6.65156990e-02f, -2.87988018e-02f, 6.36295974e-03f, 6.59798086e-03f, 1.74396951e-02f, 9.97191146e-02f, 7.00975284e-02f, 1.05074733e-01f, 1.11430347e-01f,
  -5.42865396e-02f, 7.49960840e-02f, 1.75719485e-01f, 4.24012616e-02f, 7.29578137e-02f, 5.36938235e-02f, 1.15442850e-01f, 7.09491968e-02f, 1.33624837e-01f, 1.01361863e-01f,
  -1.19372904e-01f, -2.75652502e-02f, -7.16558425e-04f, -2.30226945e-03f, -4.45728078e-02f, -2.32177489e-02f, -1.58892572e-02f, 3.23900320e-02f, -9.65641662e-02f, -1.37032932e-02f,
  4.17507701e-02f, 6.49748072e-02f, 4.72838283e-02f, -7.30631221e-03f, 4.23024260e-02f, 3.03245112e-02f, 7.34257996e-02f, -4.68137972e-02f, 9.58886668e-02f, 4.74593118e-02f,
  3.21848430e-02f, 6.61341399e-02f, -2.09248718e-03f, 3.68370302e-02f, 6.68552890e-02f, -3.98703478e-03f, -3.50240655e-02f, 2.50408482e-02f, -7.22358897e-02f, 1.50429960e-02f,
  -2.05929279e-01f, 5.87123707e-02f, 3.09660137e-02f, 6.43846467e-02f, 6.05786815e-02f, 1.10409960e-01f, 2.16968432e-02f, 7.48170316e-02f, 9.81975496e-02f, -6.43926188e-02f,
  2.81242002e-02f, 3.18604661e-03f, 1.21914841e-01f, 3.02999038e-02f, -5.46585908e-03f, 7.41168344e-03f, 3.36973257e-02f, 6.45784140e-02f, -2.35477593e-02f, 7.97415227e-02f,
  1.19811818e-01f, -6.32657260e-02f, -5.62116727e-02f, -9.69747454e-02f, 2.32929792e-02f, -6.23179860e-02f, 1.15730707e-02f, 5.59058785e-02f, -1.11754604e-01f, -2.09826753e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.78554976e-01f, 3.48585099e-01f, -1.80396020e-01f, 1.50796071e-01f, -5.79856802e-04f, -2.18877196e-01f, -1.05999596e-01f, 1.48437098e-01f, 1.85705915e-01f, 2.24470168e-01f,
  1.44755378e-01f, -8.98720846e-02f, -1.27692148e-01f, -1.15152232e-01f, -1.73532531e-01f, 2.46468820e-02f, -1.25269607e-01f, -4.72294927e-01f, -5.74216068e-01f, -3.32143784e-01f,
  -1.84542373e-01f, -3.19483578e-01f, -3.61368150e-01f, -7.20276684e-02f, 2.34675437e-01f, -2.25004494e-01f, -5.48247434e-03f, -2.54615366e-01f, -3.41038048e-01f, -1.03380211e-01f,
  -2.34661788e-01f, -1.45440325e-01f, 6.78811967e-03f, -9.45293307e-02f, 4.72472385e-02f, 2.41648443e-02f, -3.48330177e-02f, -3.62091698e-02f, 5.80786318e-02f, 6.69735596e-02f,
  -5.52975088e-02f, -3.04905116e-03f, -7.01627508e-02f, 4.01620641e-02f, -7.51795545e-02f, 2.64898278e-02f, 1.36009172e-01f, -3.60896476e-02f, 4.23823632e-02f, 1.89422995e-01f,
  4.56484295e-02f, -1.89669013e-01f, -1.57783087e-02f, 4.19074204e-03f, -1.06674656e-01f, -1.84827954e-01f, 9.90187824e-02f, -3.28054503e-02f, -1.89899370e-01f, 1.93523183e-01f,
  4.71259886e-03f, 1.36337459e-01f, 1.29035562e-01f, -2.03272086e-02f, -2.03525159e-03f, -1.19492868e-02f, 2.09688749e-02f, -1.03747630e-02f, -1.19237769e-02f, 8.84554386e-02f,
  1.80202834e-02f, -5.95530644e-02f, 1.08780563e-02f, -1.28389716e-01f, -5.25618717e-02f, 5.76793067e-02f, 6.14685472e-03f, 7.70490840e-02f, -1.24822166e-02f, 1.18647248e-01f,
  2.29774714e-02f, -4.52062814e-03f, -2.93463841e-02f, -3.96526270e-02f, -1.32800296e-01f, 6.64923191e-02f, 1.13337211e-01f, 3.53886443e-03f, 4.58235480e-02f, 7.90892169e-02f,
  -2.12630238e-02f, -2.55704433e-01f, 1.53837457e-01f, 5.18029779e-02f, 5.20264097e-02f, 1.77512020e-01f, -4.51348387e-02f, 1.11205615e-01f, -6.82314625e-03f, -4.00209986e-02f,
  -5.41449301e-02f, -4.55269851e-02f, -3.61158908e-03f, 1.04021072e-01f, -9.52010974e-03f, -3.80678996e-02f, 1.05842978e-01f, 3.77994291e-02f, -6.74050227e-02f, 3.02553356e-01f,
  2.44959339e-01f, 1.30495414e-01f, 7.79575184e-02f, 3.29899564e-02f, -5.28423451e-02f, -1.02003872e-01f, -5.41652814e-02f, 1.59465402e-01f, -1.92292914e-01f, 3.24192345e-01f,
  2.12912142e-01f, 2.68905461e-01f, 8.75645652e-02f, 7.44688958e-02f, 2.35203072e-01f, 2.22446932e-03f, 1.63151529e-02f, -1.64367586e-01f, 1.16582617e-01f, 1.17068551e-01f,
  3.80700044e-02f, 4.60011475e-02f, 1.38473194e-02f, -3.31403594e-03f, -1.96392730e-01f, -4.84697223e-02f, 1.56871244e-01f, -8.24759342e-03f, -2.66837537e-01f, -2.79099494e-01f,
  -4.39330861e-02f, -4.94604148e-02f, -8.55572596e-02f, -1.51759177e-01f, 1.55044407e-01f, -1.70825526e-01f, 4.51302193e-02f, 3.69483158e-02f, 8.06223154e-02f, 2.76777804e-01f,
  1.16333701e-01f, 9.99789312e-02f, -3.80962670e-01f, -7.77975703e-03f, 1.03269562e-01f, -3.71283516e-02f, -8.34410563e-02f, 1.18850537e-01f, -7.21160918e-02f, -4.88027446e-02f,
  6.68301880e-02f, 1.25375807e-01f, 4.34940197e-02f, -4.14114594e-02f, 1.02040069e-02f, 5.79034584e-03f, 1.07041582e-01f, -7.90765584e-02f, -1.42223567e-01f, -1.74185932e-02f,
  1.94454983e-01f, 8.72168764e-02f, 6.30714893e-02f, -7.87736699e-02f, 2.91632339e-02f, -8.91110078e-02f, -1.24220565e-01f, -1.08929925e-01f, -1.46918446e-01f, -7.56953806e-02f,
  -8.19527507e-02f, 5.86052835e-02f, -3.51707712e-02f, 5.04401810e-02f, -1.54442084e-03f, -8.32870975e-02f, 5.20350747e-02f, 2.76604928e-02f, -1.70181736e-01f, 8.92155692e-02f,
  1.26037538e-01f, 1.15128905e-01f, 2.23254524e-02f, -5.92337595e-03f, 5.15930913e-02f, 2.60488037e-02f, 1.07913122e-01f, 6.20799735e-02f, 2.31394731e-02f, 2.58520450e-02f,
  -1.24269284e-01f, -5.63367046e-02f, 2.83479262e-02f, -1.40702520e-02f, -1.43853888e-01f, 6.67898059e-02f, 9.06293914e-02f, -2.86422074e-02f, -7.62033090e-02f, 2.89481785e-02f,
  -8.18154663e-02f, -1.78986222e-01f, -7.36326128e-02f, -4.50911410e-02f, 3.10084857e-02f, 8.83919224e-02f, -6.36400282e-02f, 1.16315491e-01f, -3.45163792e-02f, -7.32757524e-02f,
  -8.63768458e-02f, 9.86182392e-02f, -5.12614250e-02f, -5.16912267e-02f, -1.41065001e-01f, -6.10028207e-03f, 9.60669816e-02f, 5.81651703e-02f, -1.95645377e-01f, 8.20738226e-02f,
  -3.90039571e-02f, -1.91672504e-01f, -9.34701860e-02f, 3.01551763e-02f, 4.34990972e-03f, -1.03386715e-01f, -1.28353015e-01f, -1.23022541e-01f, -1.76011622e-01f, -3.61624271e-01f,
  3.75743866e-01f, 9.64444131e-02f, 3.72252494e-01f, 1.36010900e-01f, 1.38668418e-01f, 3.64725232e-01f, 4.20240641e-01f, 1.10209495e-01f, -9.86368284e-02f, 3.51911597e-02f,
  -4.00767736e-02f, -2.87912637e-01f, -2.06520468e-01f, -1.76005900e-01f, -5.87499924e-02f, 6.73125312e-02f, -5.27377939e-03f, 1.04444586e-01f, 9.75277051e-02f, 1.51922926e-01f,
  -9.95087326e-02f, 9.33352858e-03f, 8.33400115e-02f, -4.51263636e-02f, -6.83593228e-02f, -1.14861980e-01f, -2.85033341e-02f, 4.45803888e-02f, -7.13627562e-02f, -1.69123352e-01f,
  2.10542157e-02f, 1.15180798e-01f, -1.29188240e-01f, -1.23163335e-01f, 2.32461132e-02f, -9.44584459e-02f, 4.05516028e-02f, -1.37768029e-05f, -1.42538160e-01f, -4.37193364e-02f,
  2.66349874e-02f, -3.12755909e-03f, 9.97369364e-02f, -4.10974026e-02f, 1.21016979e-01f, -8.10065586e-03f, -3.36559303e-02f, 4.14029770e-02f, 3.08742579e-02f, -1.06859833e-01f,
  -1.85985882e-02f, 1.32937476e-01f, 1.64613619e-01f, 1.09701931e-01f, 9.96432081e-02f, -9.23019946e-02f, 7.48858303e-02f, 9.31786001e-02f, 1.43342212e-01f, -2.68822424e-02f,
  8.29971060e-02f, -1.46638341e-02f, 5.44765852e-02f, 7.00190961e-02f, -3.96814756e-02f, 5.62458560e-02f, 3.72644253e-02f, 3.48240249e-02f, 6.47855848e-02f, 1.69980913e-01f,
  1.03377208e-01f, 7.75338337e-02f, 6.05922239e-03f, 8.91886950e-02f, -3.35080526e-03f, 5.78794368e-02f, 4.55841199e-02f, -7.27050006e-02f, 5.25332019e-02f, 2.36354470e-02f,
  8.89559090e-02f, 1.54008940e-01f, 1.10580280e-01f, 3.67757790e-02f, 7.52992928e-02f, 2.45816400e-03f, 1.31274834e-01f, -5.46427295e-02f, 6.99370801e-02f, 1.85541511e-01f,
  -2.42324680e-01f, 8.57015550e-02f, -4.54761162e-02f, -8.77410471e-02f, -2.14191340e-02f, -7.41487183e-03f, -6.86850995e-02f, -1.65749758e-01f, -1.76729828e-01f, -1.11935347e-01f,
  -9.35455933e-02f, 7.94836208e-02f, 1.84168667e-01f, 1.18196249e-01f, 7.10152388e-02f, 2.94664335e-02f, -1.31017014e-01f, -2.75771059e-02f, -1.84476063e-01f, -2.45150581e-01f,
  -4.00497429e-02f, -1.86483245e-02f, 4.49132826e-03f, 4.65022027e-02f, -2.21071206e-02f, 3.93345533e-03f, -3.32115814e-02f, 2.00823024e-02f, 1.16677796e-02f, 3.53845134e-02f,
  5.24918616e-01f, -1.67876497e-01f, -3.77172351e-01f, 1.36478946e-01f, -1.90563872e-01f, -1.66726578e-02f, -1.62927687e-01f, 5.17036999e-03f, 1.15444250e-01f, -3.03412378e-01f,
  -2.11733162e-01f, 9.30166841e-02f, -4.62009721e-02f, -3.20905745e-02f, 6.19579703e-02f, -1.88591406e-01f, -1.06438749e-01f, -2.15603616e-02f, 7.09403381e-02f, 1.37851238e-01f,
  -7.66503662e-02f, 9.37780440e-02f, 2.30877206e-01f, 1.13945268e-01f, -9.32370722e-02f, -6.37740493e-02f, -2.85205692e-01f, -4.47764620e-02f, -7.15730786e-02f, -3.00188243e-01f,
  -1.31306499e-01f, -1.35829464e-01f, 2.25270335e-02f, 1.02249011e-01f, -1.28842175e-01f, 3.37410951e-03f, -7.47580528e-02f, -7.71228373e-02f, 4.46932800e-02f, 8.83768871e-03f,
  -3.12080681e-02f, -5.22770584e-02f, 7.84244388e-02f, -3.88140865e-02f, -4.37023342e-02f, -1.02080025e-01f, -4.56226245e-03f, -1.57931615e-02f, -9.37159136e-02f, -1.04769513e-01f,
  -1.00326717e-01f, 3.95230204e-02f, 1.06545508e-01f, 6.75615272e-04f, -9.66435820e-02f, -2.86547169e-02f, -2.27727041e-01f, -7.03281835e-02f, -5.43474592e-02f, 2.19928324e-02f,
  9.33235437e-02f, -4.32868637e-02f, 2.93225814e-02f, 2.84969574e-03f, 7.29811704e-03f, 8.58139172e-02f, 4.12836336e-02f, -1.27119655e-02f, -4.17606607e-02f, -2.37458479e-03f,
  4.78193425e-02f, -1.72790334e-01f, 2.58411355e-02f, 9.82125290e-03f, -1.78593710e-01f, -2.72691087e-03f, 1.17075346e-01f, -9.17012396e-04f, 1.94661692e-03f, 1.29511118e-01f,
  -4.52203453e-02f, 4.30293195e-02f, -4.58642021e-02f, 5.85215650e-02f, -1.07255124e-01f, -6.71590343e-02f, 1.07185915e-03f, -8.84284973e-02f, 9.33800414e-02f, 3.75202708e-02f,
  3.00723985e-02f, -2.93445457e-02f, 1.54838517e-01f, 8.62860233e-02f, -1.67887118e-02f, -1.22223711e-02f, -8.63347873e-02f, 7.60700628e-02f, 4.41427790e-02f, 1.75901446e-02f,
  -1.31068781e-01f, 7.29959756e-02f, -3.08317877e-02f, -7.38582462e-02f, -5.91931343e-02f, 7.56853307e-03f, -8.25214610e-02f, 5.35440780e-02f, -4.87549566e-02f, 6.04435168e-02f,
  -8.73403400e-02f, 1.28991991e-01f, 1.21470466e-01f, 1.18902378e-01f, 9.57828462e-02f, 5.69581576e-02f, 2.01000683e-02f, 9.53430906e-02f, 7.26084411e-03f, 1.33882701e-01f,
  1.65147215e-01f, -2.98158020e-01f, -1.12308003e-01f, 2.26221055e-01f, -1.58399455e-02f, 7.32941031e-02f, -3.22095484e-01f, 4.81177382e-02f, 1.31292850e-01f, -2.03961655e-01f,
  -1.30508855e-01f, 1.75523952e-01f, 9.22857821e-02f, 7.41360262e-02f, -9.52544808e-02f, -4.48913217e-01f, -1.68302268e-01f, 6.84378594e-02f, 1.62777603e-01f, 1.19896173e-01f,
  7.51901269e-02f, 1.24721318e-01f, 2.58017451e-01f, 1.80198625e-01f, 1.52483592e-02f, 1.10603660e-01f, -8.96617770e-02f, -1.44057376e-02f, -2.47170791e-01f, -3.19101721e-01f,
  -1.67977720e-01f, -2.26856157e-01f, 4.62625213e-02f, 9.97331217e-02f, -8.41705799e-02f, 9.01653245e-02f, 1.06730066e-01f, -4.13972586e-02f, -3.96394245e-02f, -1.71484575e-02f,
  6.35329708e-02f, -1.32487297e-01f, -7.61216581e-02f, 4.41048900e-03f, 1.18961997e-01f, 1.30178168e-01f, 3.82647514e-02f, -2.80791800e-02f, 3.47073711e-02f, 4.30441722e-02f,
  -1.20463461e-01f, -1.50661319e-01f, -2.26905167e-01f, -2.07838118e-01f, -3.68617289e-02f, 9.08688381e-02f, -7.04733282e-02f, -9.34254453e-02f, -1.12305418e-01f, -3.94396782e-01f,
  -3.50079462e-02f, -1.33394673e-01f, 3.49805132e-02f, 9.66121256e-02f, 1.09343771e-02f, -6.25944585e-02f, 2.36495323e-02f, -9.96595621e-02f, -1.04480144e-03f, -1.26756718e-02f,
  1.62668824e-01f, -5.13933934e-02f, 1.56681575e-02f, 2.78615076e-02f, 4.25661318e-02f, -9.89962071e-02f, -1.09920301e-01f, -6.03296310e-02f, -4.81691249e-02f, -2.56270692e-02f,
  6.96009099e-02f, 5.70591725e-02f, 9.40180272e-02f, 7.65542537e-02f, -9.92276520e-02f, -6.34899363e-02f, -8.58947709e-02f, 6.42403204e-04f, 2.15874985e-01f, -1.45931700e-02f,
  3.68589461e-01f, -1.56025320e-01f, -2.21136540e-01f, 1.80122908e-03f, 1.56964231e-02f, 4.55929339e-02f, -3.69582996e-02f, 1.61054969e-01f, -2.74830796e-02f, 8.19859579e-02f,
  -6.36220053e-02f, 5.72199933e-02f, -2.00580526e-02f, -7.23055378e-02f, 1.69751123e-01f, 3.36729251e-02f, 6.64693788e-02f, 2.50227097e-02f, -4.42123134e-03f, 1.17710195e-01f,
  -1.37952948e-02f, -9.49314758e-02f, 1.21339355e-02f, -1.70314327e-01f, -5.52790146e-03f, -9.85141397e-02f, 1.16796857e-02f, -1.36758983e-01f, -1.89542353e-01f, -1.74001351e-01f,
  -2.65780151e-01f, -1.86618596e-01f, 2.93970406e-01f, -1.15603358e-02f, 4.70029041e-02f, 1.76342964e-01f, 3.87689590e-01f, 8.86743441e-02f, -2.09123269e-01f, 1.06687188e-01f,
  -1.06622286e-01f, -2.24681854e-01f, -2.10134149e-01f, -1.24424778e-01f, 6.90884069e-02f, 3.10285479e-01f, 1.37613982e-01f, 1.44158140e-01f, 1.09877884e-01f, -3.37078492e-03f,
  8.86407122e-02f, -2.36549899e-02f, -2.44258240e-01f, -8.71733949e-02f, 3.26115526e-02f, -6.84868619e-02f, 9.85772163e-02f, -1.54556558e-01f, -1.46145463e-01f, -8.88153911e-02f,
  1.00217871e-01f, -2.40235820e-01f, 1.16286628e-01f, -3.91548365e-01f, -1.69307217e-02f, 5.45296371e-02f, 1.60674930e-01f, 1.91167206e-01f, -8.42966735e-02f, -7.94527307e-02f,
  -5.67167886e-02f, -4.74555194e-02f, -1.50076017e-01f, -6.43084869e-02f, -9.50892568e-02f, -1.58173800e-01f, 5.41800559e-02f, -1.39968365e-01f, -1.51469320e-01f, -2.11228490e-01f,
  -1.59208044e-01f, -1.96682796e-01f, -7.58361071e-02f, 2.30845716e-03f, -5.34191579e-02f, 1.18323946e-02f, -2.09915973e-02f, -7.75703341e-02f, -5.20309396e-02f, -9.65104476e-02f,
  -2.40539555e-02f, -1.42547786e-01f, 2.48570871e-02f, 4.16061319e-02f, 7.26741329e-02f, 1.22197576e-01f, 1.04462609e-01f, 9.55426246e-02f, -4.63154353e-03f, -4.04645614e-02f,
  -9.52833369e-02f, 4.52821031e-02f, -2.37769540e-02f, -2.56764013e-02f, 3.53580266e-02f, -1.26613513e-01f, -1.76989287e-02f, -7.75086060e-02f, 4.82960865e-02f, 1.19270161e-01f,
  5.42172743e-03f, 4.80737574e-02f, 4.09576343e-03f, 1.98367417e-01f, -2.16336418e-02f, 5.09218946e-02f, -4.73522507e-02f, -4.93988954e-02f, -1.11684412e-01f, -1.24478586e-01f,
  3.43992822e-02f, -2.19993517e-01f, 7.52916336e-02f, 5.03969491e-02f, 1.08303100e-01f, -5.00468425e-02f, 1.39705971e-01f, -4.92555276e-02f, -9.40906033e-02f, -4.32243608e-02f,
  -1.25510365e-01f, -3.05948518e-02f, 3.40649262e-02f, -3.37249902e-03f, 6.18302636e-02f, -4.88256626e-02f, 3.24439295e-02f, -3.71811017e-02f, 1.50403082e-01f, -3.92842107e-02f,
  -1.02586634e-01f, 1.36917964e-01f, 2.60126948e-01f, 1.28883675e-01f, 1.06040044e-02f, 2.20983520e-01f, 6.88543916e-02f, 4.12504748e-02f, 1.64041102e-01f, 1.34812430e-01f,
  -5.62158823e-01f, 1.87709808e-01f, 7.35190734e-02f, -2.52553016e-01f, -5.09392433e-02f, -7.85593390e-02f, -5.10005541e-02f, -2.51170665e-01f, -2.47944385e-01f, 1.29745662e-01f,
  2.55739652e-02f, 5.16311042e-02f, 3.68618816e-02f, -1.28767654e-01f, -3.46959144e-01f, 3.08168009e-02f, -1.52414247e-01f, -3.18487853e-01f, -4.25518602e-01f, -3.25074017e-01f,
  -3.24586174e-04f, -1.10007159e-01f, -3.94657731e-01f, -2.06591755e-01f, 2.16997892e-01f, -1.37691563e-02f, 2.11648554e-01f, -8.04727525e-02f, 1.30371913e-01f, 3.38922709e-01f,
  2.17163578e-01f, -6.08979575e-02f, -2.19571233e-01f, -9.91674587e-02f, 9.71159190e-02f, -8.10155645e-03f, -1.48483533e-02f, 6.91787200e-03f, -1.54470414e-01f, 1.35969799e-02f,
  -5.92567027e-02f, -3.43344081e-03f, -7.42261559e-02f, -9.60743874e-02f, -8.97138789e-02f, -5.35566695e-02f, -1.29880175e-01f, -1.60958633e-01f, 1.22819573e-01f, 1.95029184e-01f,
  1.96830347e-01f, 2.23868508e-02f, -1.52620301e-02f, -7.93508440e-02f, -2.37247385e-02f, -4.56403270e-02f, 6.20735735e-02f, 1.14556715e-01f, -1.12630194e-02f, 2.61572808e-01f,
  2.69406885e-02f, 7.01564318e-03f, 7.95942247e-02f, -2.17429851e-03f, -9.63130966e-02f, 8.04639142e-03f, 2.68400609e-02f, 6.09214010e-04f, -5.01895510e-02f, -1.03446707e-01f,
  -2.07790025e-02f, 3.03662140e-02f, 7.85541683e-02f, 4.99726459e-02f, -5.24570309e-02f, -1.15584567e-01f, -6.07261918e-02f, -1.57457814e-02f, -7.91649800e-03f, -9.29731131e-02f,
  -3.76294740e-02f, -9.42244846e-03f, 9.42203477e-02f, -6.17416240e-02f, 2.82351673e-02f, 2.53455658e-02f, 3.83612104e-02f, 1.55103039e-02f, -1.00998305e-01f, 2.27967184e-02f,
  1.86515618e-02f, -2.44290188e-01f, 2.52628140e-02f, 5.82917407e-02f, -5.28409667e-02f, 3.98531854e-02f, 1.13846049e-01f, 1.11318696e-02f, 2.03940589e-02f, -7.09351003e-02f,
  -3.69027741e-02f, 1.14319891e-01f, 8.20378400e-03f, 6.57317787e-02f, -1.46684334e-01f, -1.59359425e-01f, -8.91097039e-02f, 9.61288661e-02f, -1.52838854e-02f, 4.28631119e-02f,
  4.38084751e-02f, -1.57742307e-01f, -1.22151181e-01f, 1.02071606e-01f, 8.91306102e-02f, -7.28560239e-02f, -1.90739147e-02f, 2.12933242e-01f, -7.96787217e-02f, 2.73959283e-02f,
  5.92592239e-01f, -2.15119839e-01f, 3.48350853e-02f, 4.43370044e-02f, -1.76056415e-01f, -1.09241292e-01f, -2.78284043e-01f, 7.21884752e-03f, 8.65024924e-02f, 5.89627437e-02f,
  8.85412022e-02f, 3.02411705e-01f, 2.50841111e-01f, 1.43020943e-01f, 9.65510011e-02f, -1.39707729e-01f, -6.85216114e-02f, 1.60004899e-01f, 1.68385848e-01f, -7.64736980e-02f,
  -1.73727229e-01f, -1.61901116e-01f, 1.23190172e-01f, -1.74945667e-02f, -1.33507729e-01f, 6.84220903e-03f, -1.20074548e-01f, -8.73608515e-02f, -1.12753011e-01f, -1.76183850e-01f,
  3.47367264e-02f, -2.26638466e-03f, 1.31955251e-01f, 6.57800660e-02f, 7.53885731e-02f, 1.94039643e-02f, -9.99073125e-03f, -1.58549044e-02f, 9.00673121e-03f, -1.00638494e-01f,
  -2.30312031e-02f, -2.92126648e-02f, -1.03765875e-01f, -3.04158982e-02f, 1.81895569e-02f, 6.79380968e-02f, 1.02837972e-01f, 5.10669947e-02f, -4.67147958e-03f, -1.96281485e-02f,
  3.77133526e-02f, -1.68305379e-03f, 8.89538899e-02f, 1.65481582e-01f, 4.58139405e-02f, 2.21507877e-01f, 5.09882495e-02f, 1.28887653e-01f, 1.39732599e-01f, 1.92168117e-01f,
  1.26209930e-01f, -4.84567229e-03f, 1.61774367e-01f, 1.47373348e-01f, 9.01969671e-02f, 5.71997277e-02f, 5.02353646e-02f, 6.30043373e-02f, 8.05314407e-02f, 1.63661782e-02f,
  -1.06076479e-01f, 1.46246776e-01f, 1.57242745e-01f, -8.51950422e-02f, 4.57104109e-02f, 8.67886934e-03f, -9.43591818e-02f, 5.61904302e-03f, 5.39274886e-02f, 1.81792444e-03f,
  1.29331993e-02f, -5.42852581e-02f, -9.57585350e-02f, -1.04198828e-01f, 7.95067027e-02f, 9.49335024e-02f, -8.03199504e-03f, 8.14319849e-02f, -4.48119268e-02f, -3.99575904e-02f,
  -1.20149165e-01f, 1.99992627e-01f, -1.82970073e-02f, 3.50773484e-02f, -4.42476310e-02f, -3.06068975e-02f, 1.37378320e-01f, -1.39678299e-01f, -2.50968844e-01f, -1.02494374e-01f,
  -3.22391838e-02f, 6.79343343e-02f, 1.98222995e-02f, 4.38426472e-02f, -4.12868261e-02f, 2.16969289e-02f, 5.57145327e-02f, 2.07238700e-02f, -3.42588243e-03f, -1.83754459e-01f,
  -3.14480364e-02f, 1.60826385e-01f, 6.42741248e-02f, 1.19668394e-01f, 1.11622386e-01f, 6.70765564e-02f, 4.55682278e-02f, 9.03026238e-02f, 1.15238786e-01f, 1.30751833e-01f,
  -8.76407176e-02f, 1.54513329e-01f, -2.33739093e-01f, 2.76759624e-01f, 2.27717504e-01f, 1.07431216e-02f, 2.39797294e-01f, 1.00778565e-01f, 8.18034261e-02f, -3.91728710e-04f,
  6.10961998e-03f, 2.38088444e-02f, -1.08670391e-01f, -1.20346487e-01f, -1.66413158e-01f, 1.34720221e-01f, 1.94092408e-01f, -1.72782782e-02f, -2.53373176e-01f, -8.11513588e-02f,
  1.48513705e-01f, 5.08875884e-02f, -9.26240236e-02f, 1.03413453e-02f, 2.85368804e-02f, 8.61899927e-02f, -9.55539048e-02f, -4.11625765e-02f, -1.57947596e-02f, 1.19924307e-01f,
  -4.01259601e-01f, -2.19106123e-01f, -2.52742860e-02f, 3.54447253e-02f, -1.60046577e-01f, -2.38922521e-01f, -6.56469315e-02f, -6.10524639e-02f, -4.08992134e-02f, -5.17654270e-02f,
  1.09559651e-02f, -5.76983765e-02f, -8.38185549e-02f, -8.00267681e-02f, 1.60875283e-02f, -2.30879355e-02f, 3.33582535e-02f, -1.08804867e-01f, -1.48567140e-01f, -1.59155190e-01f,
  1.12792425e-01f, -2.87649129e-02f, -5.68080656e-02f, 8.25156197e-02f, -1.28371939e-01f, -8.06093514e-02f, -1.05264224e-01f, -4.27916134e-03f, -2.70733535e-01f, -1.97949796e-03f,
  1.52525917e-01f, -1.02775414e-02f, 8.98092464e-02f, 1.16608106e-01f, 1.65002599e-01f, 4.18049172e-02f, -8.04955587e-02f, 7.24629359e-03f, -2.63159182e-02f, -5.69440499e-02f,
  -1.13060892e-01f, -1.05197318e-01f, -1.62365124e-01f, -2.43371818e-02f, 3.56310792e-02f, 1.16851471e-01f, 3.56671885e-02f, 6.50123581e-02f, 5.25342254e-03f, 2.64099762e-02f,
  7.15644211e-02f, 1.27785131e-01f, 5.92102259e-02f, 7.26396218e-02f, 5.64010032e-02f, -5.15756235e-02f, 1.28051013e-01f, 2.43374221e-02f, 6.07273802e-02f, 1.00617513e-01f,
  -1.51226431e-01f, 2.25410401e-03f, 4.19243164e-02f, 6.25151694e-02f, -2.94087566e-02f, -1.37888446e-01f, 2.27561351e-02f, -4.95601632e-02f, 4.89366725e-02f, -5.26627898e-03f,
  -7.00959042e-02f, -7.34957308e-02f, -4.21688147e-02f, -7.72715360e-02f, -3.06005143e-02f, -6.78478181e-02f, 1.59246475e-01f, 1.88479230e-01f, -5.48462011e-02f, -1.08002871e-01f,
  1.59690708e-01f, 1.05167925e-01f, 1.88001424e-01f, 6.19743690e-02f, 4.75228168e-02f, 8.22516996e-03f, -2.65785102e-02f, 9.97221768e-02f, -1.56134297e-03f, 1.40156373e-01f,
  3.63598555e-01f, -2.45197937e-01f, -4.62954998e-01f, 2.01521832e-02f, -2.56859571e-01f, -1.50563434e-01f, -2.08978251e-01f, -8.00929591e-02f, 1.17943622e-01f, -1.60221145e-01f,
  -1.07548214e-01f, 1.72267005e-01f, -1.05828755e-01f, -1.01907276e-01f, -2.53132224e-01f, -2.56529808e-01f, -2.48749599e-01f, -2.47797966e-01f, -2.01229647e-01f, -8.25893208e-02f,
  -2.17092097e-01f, -7.86306486e-02f, -2.77033672e-02f, -2.33068317e-02f, -2.80339345e-02f, 2.33333535e-03f, -2.16522604e-01f, -6.32434860e-02f, -1.64967954e-01f, -2.41857186e-01f,
  -3.16951424e-01f, -1.98080223e-02f, 7.48811886e-02f, -8.53688642e-03f, 4.09638546e-02f, 8.39022100e-02f, -9.22121108e-02f, 1.13269180e-01f, 1.13237984e-01f, 3.88960950e-02f,
  -3.46642849e-03f, -1.35324979e-02f, -9.12767462e-03f, 1.28655240e-01f, -3.29881012e-02f, 6.41235039e-02f, 2.13772938e-01f, 4.41021994e-02f, -7.16106445e-02f, -8.14343244e-02f,
  5.03186770e-02f, -1.23411203e-02f, 1.47542641e-01f, 2.15068743e-01f, 1.47889212e-01f, 2.71141175e-02f, -1.88940931e-02f, 2.05649272e-01f, 1.26654521e-01f, 2.33569428e-01f,
  -2.51443982e-01f, 4.17619571e-02f, 6.23728111e-02f, 5.94597980e-02f, 4.27704901e-02f, 1.60646856e-01f, 5.29292487e-02f, 9.19092819e-02f, -1.15660140e-02f, -3.13930437e-02f,
  1.03707559e-01f, -5.56913391e-02f, -5.50762527e-02f, -1.25738382e-01f, -5.56472987e-02f, -8.75771791e-02f, -3.40466239e-02f, -2.87356377e-02f, -4.12739394e-03f, 7.22339600e-02f,
  4.37815003e-02f, -7.95553029e-02f, -2.40923595e-02f, -1.66736487e-02f, -1.52376786e-01f, -4.58555929e-02f, -1.00155413e-01f, -1.41523182e-01f, -1.18898079e-01f, -4.23037224e-02f,
  4.79858592e-02f, -2.75159240e-01f, -6.51757196e-02f, 3.48950699e-02f, 9.50914174e-02f, -2.12602466e-02f, -1.94496196e-03f, -9.41384062e-02f, -3.59424613e-02f, 3.10850013e-02f,
  -2.22562626e-02f, 5.89339361e-02f, 2.91955820e-03f, 1.16478406e-01f, 7.06704929e-02f, -2.08578371e-02f, 3.82867903e-02f, 1.32410422e-01f, -1.63890466e-01f, -2.70508882e-02f,
  -6.18247576e-02f, 1.04307950e-01f, 7.52986372e-02f, 5.88414967e-02f, 4.52105738e-02f, -8.18136800e-03f, -6.42511062e-03f, -7.06586847e-03f, -3.54966298e-02f, 6.69202656e-02f,
  3.61609697e-01f, -4.24337804e-01f, 5.25649115e-02f, 1.19417712e-01f, -1.67575583e-01f, -1.03846909e-02f, -2.56041437e-01f, -4.52082194e-02f, 9.90555435e-03f, -1.83612570e-01f,
  9.99720860e-03f, 1.65967494e-01f, 2.61817664e-01f, 1.42148733e-01f, 2.61518210e-01f, -1.49679124e-01f, -3.99018005e-02f, 2.15843469e-01f, 4.03528690e-01f, 1.16318829e-01f,
  -1.45272255e-01f, -1.01173408e-01f, 2.91426361e-01f, 8.45602751e-02f, -3.30944359e-01f, 4.68551405e-02f, -1.93484724e-01f, -1.69377163e-01f, -6.27719238e-02f, -3.95306557e-01f,
  7.50182942e-03f, -4.74935807e-02f, 1.33217454e-01f, 2.21632585e-01f, 1.16615323e-02f, -1.70891788e-02f, -1.48694376e-02f, -1.89220253e-02f, -1.03419669e-01f, -1.04505010e-01f,
  5.39105050e-02f, -7.61623159e-02f, -8.66921712e-03f, -7.25854263e-02f, -7.47074783e-02f, -5.56102209e-03f, 5.81715070e-02f, 1.61140963e-01f, 2.00162470e-01f, -1.89840049e-01f,
  -1.75733522e-01f, 1.32135558e-03f, -3.05454060e-02f, -3.34084295e-02f, 3.17630329e-05f, 5.53116836e-02f, -2.64301598e-01f, -1.51703462e-01f, 1.35027826e-01f, -4.78369087e-01f,
  -3.66637707e-02f, -1.55531205e-02f, 8.51452425e-02f, -8.42980742e-02f, -4.60198745e-02f, -8.80033970e-02f, 9.85242426e-03f, 2.18578614e-02f, -2.97038499e-02f, -1.36539921e-01f,
  -1.66673400e-02f, 1.06408703e-03f, 6.13497645e-02f, 3.56740840e-02f, 4.74090613e-02f, 7.28050992e-02f, -7.45602883e-03f, 5.12917265e-02f, 5.03632165e-02f, 7.04285428e-02f,
  3.71112153e-02f, -8.01469106e-03f, 1.30212773e-02f, 2.33837906e-02f, 4.99239117e-02f, 2.78922804e-02f, 8.98772627e-02f, 2.85452735e-02f, 4.57830392e-02f, -5.33413179e-02f,
  5.83190136e-02f, 3.51353317e-01f, -1.10582568e-01f, 2.20891982e-02f, -1.00464270e-01f, -4.50704247e-02f, -9.47906300e-02f, 1.12164572e-01f, -1.67705826e-02f, -6.90937340e-02f,
  3.39697413e-02f, -4.94008400e-02f, -3.04340553e-02f, 6.90919608e-02f, 2.28941115e-03f, -7.70059228e-02f, -5.20888790e-02f, 4.69121076e-02f, 1.00334875e-01f, -1.89927027e-01f,
  -8.61834660e-02f, -1.50395706e-02f, 9.11543071e-02f, 6.77770674e-02f, -1.60012543e-01f, 7.67896250e-02f, -1.02689072e-01f, -5.13016954e-02f, 1.12589367e-01f, -2.29262650e-01f,
  -2.03488231e-01f, -4.65641506e-02f, -2.47720238e-02f, -2.45745912e-01f, 2.16785744e-02f, 2.30670348e-01f, 3.04001272e-01f, -4.61637182e-03f, -1.40614361e-01f, 8.64886716e-02f,
  -5.89244440e-02f, -6.50464743e-02f, -3.15223306e-01f, 6.90560648e-03f, 2.62100603e-02f, 6.22776970e-02f, -3.00765224e-02f, -9.58420336e-02f, 9.30308327e-02f, 3.28131676e-01f,
  1.20618574e-01f, -1.30640268e-01f, -3.57767269e-02f, -4.75616939e-02f, -1.46107271e-01f, -2.21644297e-01f, -8.05820376e-02f, -4.88904938e-02f, 4.33519445e-02f, -3.20480257e-01f,
  -1.85718760e-01f, -1.41757652e-01f, 1.03291161e-01f, 3.23765054e-02f, -6.77208509e-03f, -4.18310463e-02f, -2.06091441e-03f, -3.20227742e-01f, -1.09716766e-01f, -5.58252409e-02f,
  -5.12943640e-02f, 3.98743190e-02f, -5.44122010e-02f, -9.29908175e-03f, -1.46722347e-01f, 9.11308452e-02f, -7.03147948e-02f, -5.29529378e-02f, 1.02700926e-02f, -8.84990692e-02f,
  1.46983922e-01f, 6.05771206e-02f, 3.31140868e-02f, 4.63304967e-02f, -3.39512527e-02f, -8.77634510e-02f, 3.43856844e-03f, 3.18073817e-02f, 1.12983853e-01f, -1.33380160e-01f,
  5.84846968e-03f, -4.34549078e-02f, -9.73047316e-02f, 6.83923587e-02f, -1.77199841e-02f, -8.83157775e-02f, -1.16895877e-01f, -1.41703531e-01f, 7.62107521e-02f, -3.67653370e-02f,
  9.51114483e-03f, -6.47566048e-05f, 3.42261232e-02f, -3.54611091e-02f, -1.23326920e-01f, -1.25754690e-02f, -3.70192640e-02f, -1.57003924e-01f, -1.52909905e-02f, 6.70156032e-02f,
  1.19941108e-01f, 8.50021169e-02f, 7.65631348e-02f, 1.56726673e-01f, 5.53229973e-02f, -2.32345667e-02f, -8.87020826e-02f, 7.67839998e-02f, 5.80769926e-02f, -2.45292336e-02f,
  -2.81175882e-01f, 3.45479101e-02f, -2.31822357e-01f, 8.75930041e-02f, 3.36212702e-02f, -1.19467169e-01f, -1.27184004e-01f, -3.49435247e-02f, -1.25749707e-01f, 2.27287021e-02f,
  -4.49351557e-02f, 2.34217793e-02f, 1.79239234e-03f, 1.29802406e-01f, 3.95114310e-02f, 8.72715339e-02f, 1.57807678e-01f, 2.62263976e-02f, 8.25240370e-03f, 1.92716047e-02f,
  9.89482626e-02f, 2.52026971e-02f, 7.94381425e-02f, -7.40683824e-02f, -4.35227007e-02f, 1.11072078e-01f, 6.95153847e-02f, -8.32241494e-03f, 4.42634784e-02f, 5.03159240e-02f,
  1.25511512e-01f, 1.51776969e-01f, -9.11897048e-02f, 1.05010986e-01f, -3.94265614e-02f, -2.12786987e-01f, -1.15439646e-01f, -5.84081113e-02f, -4.11918163e-02f, -6.79534152e-02f,
  -1.25694290e-01f, 1.04104266e-01f, 1.14177234e-01f, 8.37117434e-02f, -4.01066570e-03f, 2.65696719e-02f, 7.80961737e-02f, -6.83952542e-03f, -1.53747723e-01f, 3.13652568e-02f,
  5.97564764e-02f, 7.97748119e-02f, -8.62516388e-02f, -1.32183075e-01f, 1.43634498e-01f, -3.21002975e-02f, -1.15391076e-01f, 6.57092631e-02f, -1.78032219e-02f, 3.07124317e-01f,
  -1.86798036e-01f, 4.35181409e-02f, -1.34541526e-01f, -2.56301835e-02f, -2.18306929e-01f, -1.33951262e-01f, -7.52860233e-02f, -3.14580686e-02f, -2.24416833e-02f, -5.61430827e-02f,
  -2.24151611e-02f, 3.82635668e-02f, 7.79523030e-02f, 7.55938664e-02f, 1.44251123e-01f, -5.90459481e-02f, -2.57722680e-02f, -2.14463323e-02f, 3.15903947e-02f, 8.79863044e-04f,
  6.21944629e-02f, -1.96457189e-02f, -4.38748673e-02f, -1.07797593e-01f, -3.17367166e-02f, 9.35229510e-02f, -4.70549762e-02f, 7.96969533e-02f, -1.83455124e-01f, 1.43621147e-01f,
  7.13070929e-02f, -3.33957709e-02f, 4.40005697e-02f, 1.95798755e-01f, 6.34502769e-02f, 1.27565473e-01f, -4.82622050e-02f, 2.54161768e-02f, 4.81623225e-02f, 6.89066425e-02f,
  -5.27385883e-02f, -7.34113306e-02f, 3.81333008e-02f, -7.76287541e-02f, -3.37356366e-02f, 8.88997763e-02f, 9.29738209e-02f, 4.19978872e-02f, -7.99438208e-02f, 5.85457683e-02f,
  1.31034642e-01f, -1.38080223e-02f, -9.51455906e-02f, 7.86200613e-02f, 5.92282526e-02f, 8.34650397e-02f, 1.20331328e-02f, 2.25412473e-02f, 4.21236455e-02f, 1.36041403e-01f,
  -1.36524782e-01f, -1.93238139e-01f, 9.45556611e-02f, 1.72265079e-02f, -6.75394237e-02f, -1.35673642e-01f, 7.43640214e-02f, 5.19683817e-03f, 9.94613096e-02f, 2.41896193e-02f,
  1.21756420e-01f, -7.03716502e-02f, 3.84544837e-04f, -5.41935526e-02f, -7.51578808e-02f, -1.09791726e-01f, 4.87148128e-02f, 2.82743145e-02f, -1.12015299e-01f, 4.73358706e-02f,
  -4.61084992e-02f, 3.93181220e-02f, -3.80891897e-02f, 1.44565869e-02f, -3.89929190e-02f, -2.61850134e-02f, -4.74112183e-02f, -1.18016049e-01f, -1.21244527e-01f, -1.16704300e-01f,
  4.30321932e-01f, 2.41692469e-01f, 3.82196575e-01f, -2.81531154e-03f, 8.03931504e-02f, 3.32469016e-01f, 4.13528740e-01f, 1.92931011e-01f, -1.50347605e-01f, 1.93599865e-01f,
  1.67581707e-01f, -1.60656109e-01f, -2.02627555e-01f, -1.90325856e-01f, 1.46917090e-01f, 2.98989359e-02f, -8.35139602e-02f, -1.24574296e-01f, -7.00450912e-02f, 9.67065915e-02f,
  -2.45101094e-01f, -4.77437600e-02f, 3.99265811e-02f, -3.91173235e-04f, -7.56440461e-02f, -1.81989104e-01f, -1.03286514e-02f, 2.00275928e-01f, 7.63446689e-02f, -2.44001269e-01f,
  9.93300006e-02f, 2.44211629e-01f, -2.42314920e-01f, -1.01328403e-01f, 1.81839280e-02f, -1.39896020e-01f, -1.70011297e-01f, -1.02071263e-01f, -1.40517846e-01f, -6.85799122e-02f,
  5.23617305e-02f, -1.02705121e-01f, 4.21502367e-02f, 9.10655856e-02f, 3.08794547e-02f, 6.85354546e-02f, 6.34623226e-03f, 8.42279494e-02f, 8.75579566e-03f, 1.03446186e-01f,
  -4.37384509e-02f, 2.06084207e-01f, 3.52916032e-01f, 1.34950459e-01f, 6.09458573e-02f, 1.90391019e-02f, 2.14776903e-01f, 1.02820747e-01f, 6.86123446e-02f, -5.37993163e-02f,
  -1.53294638e-01f, -1.18875708e-02f, -9.71057173e-03f, -1.16797782e-01f, 9.06844735e-02f, -8.06110352e-03f, 4.11465280e-02f, 9.82030407e-02f, 6.32039458e-02f, 1.31683704e-02f,
  -2.96022706e-02f, -8.15956444e-02f, -1.13638770e-03f, 1.12514846e-01f, -8.76507089e-02f, 8.95272568e-02f, 1.68079183e-01f, 1.39399797e-01f, 1.96999274e-02f, 8.26557279e-02f,
  1.81863252e-02f, -3.83822694e-02f, -6.79249689e-02f, 4.88118455e-02f, -1.01822212e-01f, -6.54358268e-02f, 2.00320948e-02f, -4.61962214e-03f, -7.73992091e-02f, -1.61368534e-01f,
  -8.50847811e-02f, 1.40227422e-01f, -9.18488353e-02f, -3.07244621e-02f, 8.45508557e-03f, -4.81243506e-02f, 1.07064098e-01f, -1.11016393e-01f, -1.58468056e-02f, -1.83299333e-02f,
  5.79553209e-02f, -3.44592221e-02f, 1.84035543e-02f, 3.97925600e-02f, -1.48055598e-01f, -1.35842815e-01f, -5.36075234e-02f, -3.52281854e-02f, -1.49087057e-01f, -2.34859437e-03f,
  -3.79059538e-02f, -9.75978449e-02f, -2.68149134e-02f, -7.54173324e-02f, -2.02802107e-01f, -3.20352644e-01f, -1.66689277e-01f, -1.83952242e-01f, -9.81596392e-03f, -1.87396109e-01f,
  -6.26345873e-01f, -2.47258931e-01f, 9.52142030e-02f, 8.90910551e-02f, 1.80743575e-01f, 1.74747258e-01f, 5.03700078e-02f, 3.97359170e-02f, 1.40640602e-01f, -8.35603550e-02f,
  -1.26000300e-01f, -3.65214311e-02f, -1.16159439e-01f, -6.96464479e-02f, 7.98184574e-02f, 1.61738098e-01f, 2.82550275e-01f, 1.34476781e-01f, -2.62963269e-02f, 1.04107499e-01f,
  1.78527057e-01f, 1.09210774e-01f, -1.91790551e-01f, 4.04562019e-02f, 4.01419997e-02f, 9.75464731e-02f, 8.41220021e-02f, 5.54063246e-02f, 1.16499566e-01f, 1.45143926e-01f,
  1.31649613e-01f, -7.58632943e-02f, 7.65686110e-02f, -1.57011151e-01f, -8.90149325e-02f, -1.89547837e-01f, 1.03334546e-01f, -3.52152996e-02f, -5.12625873e-02f, 1.08187437e-01f,
  -8.68695304e-02f, -1.02801897e-01f, -5.88493645e-02f, -1.14474654e-01f, 2.13736743e-02f, -1.84464335e-01f, -1.55245349e-01f, -3.92669104e-02f, -8.21891278e-02f, -5.05038910e-02f,
  2.32814979e-02f, 1.20046251e-02f, 7.66684487e-02f, -4.65495214e-02f, 7.48128518e-02f, -1.57903340e-02f, 2.79949438e-02f, 3.44603807e-02f, -1.75286323e-01f, -7.88288191e-02f,
  -5.86928874e-02f, 3.69547121e-02f, -6.64345408e-03f, 1.62005834e-02f, -9.00379717e-02f, -1.21744722e-01f, 1.19691603e-01f, 2.15076238e-01f, 1.42297730e-01f, -7.14628445e-03f,
  1.03069246e-01f, 1.78595185e-01f, 1.23658039e-01f, -4.59075831e-02f, 1.92616433e-02f, 8.79536197e-03f, 4.61559743e-02f, -1.18403383e-01f, 3.49673927e-02f, 1.76787421e-01f,
  1.92524478e-01f, 1.22066937e-01f, 1.85804069e-02f, 1.22712746e-01f, -5.20969667e-02f, -4.89157811e-02f, 1.58345163e-01f, 9.23610628e-02f, -2.05183998e-02f, 5.01149893e-02f,
  2.53499329e-01f, -1.98363885e-02f, 2.13243648e-01f, 4.69648540e-02f, -2.75285169e-02f, -1.33704662e-01f, 1.73063815e-01f, 1.31256329e-02f, 1.58848152e-01f, 9.97125357e-02f,
  -6.63420185e-02f, -1.71790291e-02f, -2.88544893e-02f, 8.59273747e-02f, 8.60172659e-02f, 1.26094650e-03f, -1.60480350e-01f, -8.13015252e-02f, 2.30961889e-02f, 6.95389658e-02f,
  4.51536328e-02f, 6.20690510e-02f, 1.73504621e-01f, 2.89343763e-02f, 1.01569377e-01f, 6.00453950e-02f, 5.36029972e-02f, 3.63410078e-02f, 7.01860785e-02f, -9.27088875e-03f,
  -3.31991553e-01f, -1.59746170e-01f, -1.39547363e-01f, 7.58827701e-02f, 3.27105194e-01f, -3.22884647e-03f, -2.80748367e-01f, -2.71485388e-01f, -1.28796756e-01f, -1.07958682e-01f,
  6.01200908e-02f, 2.35106871e-01f, 8.88702422e-02f, -4.75105718e-02f, -8.96703079e-02f, -1.39638111e-01f, 1.82714969e-01f, 7.51092136e-02f, -2.28764992e-02f, 6.96608350e-02f,
  1.47290409e-01f, 1.59048527e-01f, -2.69311084e-03f, 5.48673831e-02f, 1.95063800e-01f, 7.64012635e-02f, 5.60456403e-02f, 2.16583878e-01f, 1.19959906e-01f, 1.77217156e-01f,
  2.51173717e-03f, -3.89511734e-01f, -1.54589176e-01f, 9.71046016e-02f, 2.68969625e-01f, -2.15023279e-01f, -1.55813381e-01f, -5.53722456e-02f, -1.08292932e-02f, -1.20484583e-01f,
  1.87264726e-01f, -1.14231311e-01f, 8.75794664e-02f, 6.63483590e-02f, -1.03123970e-02f, -6.58592880e-02f, -1.42636538e-01f, -1.79731771e-01f, -2.02102885e-01f, -5.69848418e-02f,
  2.85484105e-01f, 2.94807374e-01f, -6.92842826e-02f, -7.83490911e-02f, -7.58082569e-02f, 1.05814636e-01f, -4.83414605e-02f, -5.16999774e-02f, -2.33053580e-01f, -3.05517048e-01f,
  5.49899749e-02f, 1.05577148e-01f, -3.93712893e-02f, -6.77189305e-02f, -6.89755753e-02f, -1.00176479e-03f, 6.42697737e-02f, -4.37940694e-02f, 5.04839569e-02f, -2.65199505e-02f,
  1.73236690e-02f, -1.08841248e-01f, -2.87831947e-02f, 2.24619731e-03f, 1.18298329e-01f, 2.54647769e-02f, -1.24435700e-01f, -5.29328994e-02f, 1.34976164e-01f, 3.35911773e-02f,
  9.54886898e-02f, -3.74174975e-02f, -1.70991756e-02f, 3.64549272e-02f, -9.53616872e-02f, -7.24813715e-02f, -1.29061475e-01f, -1.36726409e-01f, -1.14644282e-01f, -2.63535865e-02f,
  -2.37189662e-02f, 1.91998392e-01f, 5.39058521e-02f, -1.10315286e-01f, 1.34903789e-01f, 8.14968199e-02f, 3.37626599e-02f, 3.87116224e-02f, -4.60049324e-02f, -1.21255703e-01f,
  6.03051484e-02f, -1.22387178e-01f, -6.84234593e-03f, -8.60877261e-02f, 1.22242169e-02f, -6.35391921e-02f, 1.69233456e-02f, 1.75019745e-02f, 1.65790587e-03f, 3.28484848e-02f,
  -1.67391654e-02f, -1.01096153e-01f, -4.16391231e-02f, -2.01578394e-01f, 5.72884548e-03f, 6.16588593e-02f, -1.40345261e-01f, -1.27301082e-01f, -9.96300206e-02f, -3.08197469e-01f,
  -5.14213204e-01f, 2.49956936e-01f, 5.84173910e-02f, -1.47920266e-01f, -9.03946757e-02f, -1.36964127e-01f, 2.05741569e-01f, -7.52221495e-02f, -2.74202257e-01f, -3.67010310e-02f,
  -9.33850035e-02f, -7.43475184e-02f, -7.55170966e-03f, 2.61763874e-02f, 1.63028929e-02f, 1.44807115e-01f, 1.80244878e-01f, 5.28652826e-03f, -7.45121166e-02f, -2.46255137e-02f,
  1.85539290e-01f, 1.26994625e-01f, -1.81511760e-01f, -6.84155971e-02f, 1.32572919e-01f, 8.69701877e-02f, 1.14475824e-01f, -8.20060223e-02f, 2.47304719e-02f, 9.23122987e-02f,
  4.47589457e-02f, -6.41539618e-02f, 3.46573852e-02f, -1.32983048e-02f, -1.63088236e-02f, -1.05075233e-01f, -3.73046733e-02f, -8.92103314e-02f, -1.36653647e-01f, -5.76382428e-02f,
  -6.17622491e-03f, -8.77201334e-02f, -1.07339144e-01f, 2.20778678e-02f, -4.42401804e-02f, -9.53683853e-02f, -1.43819362e-01f, 2.14537568e-02f, -1.23220176e-01f, 1.04057267e-01f,
  7.81227425e-02f, -1.03683233e-01f, -5.55455871e-02f, -1.17935099e-01f, -8.76869485e-02f, -3.58708464e-02f, -2.71692164e-02f, -1.66040733e-01f, -9.50951129e-02f, -1.74374543e-02f,
  -1.03136580e-02f, -3.09015252e-02f, -9.27823409e-02f, 5.42112291e-02f, 9.27380174e-02f, 1.58336431e-01f, 3.89882587e-02f, 8.28779638e-02f, 8.07943419e-02f, 1.47434920e-01f,
  1.14511691e-01f, 1.94209129e-01f, 1.37486771e-01f, 3.73433679e-02f, 9.67003480e-02f, 8.81692618e-02f, 8.91757011e-02f, -1.97871625e-02f, -2.14809049e-02f, -9.60236862e-02f,
  -1.65173840e-02f, -3.75568010e-02f, 1.80114701e-01f, -4.88951616e-02f, 3.13941576e-02f, -2.90709212e-02f, 4.67548743e-02f, 3.32844406e-02f, 1.74540933e-02f, -6.12060279e-02f,
  1.97757438e-01f, -1.52443483e-01f, 1.96989551e-01f, 1.45066842e-01f, 1.02332972e-01f, -6.49909452e-02f, -2.43304693e-03f, -6.64840788e-02f, 1.07042305e-01f, 1.52628317e-01f,
  1.70390233e-02f, -1.08338654e-01f, 3.83449495e-02f, -3.75548378e-02f, -8.84388536e-02f, -1.06886901e-01f, 5.65959401e-02f, -2.41049230e-02f, 9.30046141e-02f, 8.35809261e-02f,
  -3.01330630e-02f, -2.39598248e-02f, -8.29480514e-02f, 6.49960712e-02f, -1.05621904e-01f, -4.88670208e-02f, 3.91603969e-02f, -9.91626382e-02f, 7.72213563e-02f, 2.16121793e-01f,
  3.07978806e-03f, 2.00036421e-01f, -4.63939160e-02f, 1.69534490e-01f, 1.84568018e-01f, -2.22022563e-01f, -1.56755835e-01f, -4.68518548e-02f, 1.42150328e-01f, 4.86530475e-02f,
  -2.31780149e-02f, 3.79494652e-02f, 2.75180459e-01f, -7.71113411e-02f, -2.05841571e-01f, 1.99184995e-02f, 1.31231770e-01f, -2.14271724e-01f, -3.42375845e-01f, -3.04695249e-01f,
  2.31183708e-01f, 1.03577174e-01f, -1.09535389e-01f, -1.32268801e-01f, 1.70573264e-01f, 7.64920861e-02f, 1.66241392e-01f, 5.16961105e-02f, -1.48696229e-02f, 1.92396715e-01f,
  -2.22557411e-02f, -8.04923326e-02f, -1.24930106e-01f, -6.43761903e-02f, -9.24079195e-02f, -1.08492881e-01f, -1.94800943e-01f, -5.11682406e-02f, -9.91421118e-02f, -1.25782043e-01f,
  -9.15486738e-03f, -1.11546889e-01f, -3.19670774e-02f, -5.32961711e-02f, -1.48709938e-01f, -1.09025821e-01f, 2.09413152e-02f, -6.73301890e-02f, -4.52578664e-02f, -2.13021398e-01f,
  -2.88413055e-02f, -7.78238848e-02f, -8.58336017e-02f, 5.16392011e-03f, -2.95484304e-01f, -1.11688785e-01f, 2.13993359e-02f, -1.18409410e-01f, -1.92440242e-01f, 1.26359507e-01f,
  -1.44628614e-01f, -7.59094879e-02f, -4.62828949e-03f, 2.78940015e-02f, -2.27952581e-02f, 6.08603545e-02f, -1.37218997e-01f, -4.56099398e-02f, -1.45371258e-01f, -6.66241795e-02f,
  -2.19815634e-02f, -7.96185508e-02f, 3.85241136e-02f, 6.00444637e-02f, 2.99256016e-02f, 6.27847388e-02f, -2.39565000e-01f, 7.22086756e-03f, 2.89901365e-02f, -5.50898388e-02f,
  9.79650244e-02f, -1.60729483e-01f, 3.81529666e-02f, -2.96703111e-02f, -2.25749873e-02f, -1.43139526e-01f, -6.99867755e-02f, -1.10232100e-01f, 9.53600854e-02f, -5.98144010e-02f,
  2.51316249e-01f, -1.17147557e-01f, -4.44539711e-02f, 1.31114544e-02f, -8.66801012e-03f, -1.41319353e-02f, -8.11676010e-02f, 2.66496325e-04f, -8.14762563e-02f, -1.00966305e-01f,
  -1.03517503e-01f, -7.29837939e-02f, 2.30675161e-01f, 9.15741101e-02f, -1.64078400e-01f, -1.08384997e-01f, 6.42347150e-03f, 2.61450466e-02f, -4.92053516e-02f, -9.24980119e-02f,
  1.94007792e-02f, -5.30104414e-02f, 1.02004454e-01f, 2.11108834e-01f, 1.98987529e-01f, -1.06541067e-01f, 2.28701204e-01f, 5.91442659e-02f, -1.26590565e-01f, 2.37723708e-01f,
  2.50998497e-01f, -2.52445647e-03f, 3.93884838e-01f, -3.76664214e-02f, -2.46318996e-01f, -1.55619636e-01f, -3.12244505e-01f, -1.51858687e-01f, -6.29528090e-02f, 1.06255594e-03f,
  -3.74260582e-02f, -1.33016363e-01f, 1.90420896e-02f, 4.20037424e-03f, 1.41134381e-01f, -2.02147057e-03f, 8.03168491e-02f, 2.55586654e-01f, 6.19800463e-02f, -1.76035166e-01f,
  -3.46840173e-01f, -3.60555723e-02f, 1.53414428e-01f, 3.08811292e-02f, 3.93005013e-02f, -2.13656455e-01f, 1.82550222e-01f, 1.06747702e-01f, -4.06272858e-02f, 2.44810320e-02f,
  6.20046183e-02f, 2.04312742e-01f, -9.03284028e-02f, -1.18172772e-01f, -6.43063430e-03f, -1.15665898e-01f, -6.50689080e-02f, 1.37897998e-01f, 6.91778585e-02f, 2.74491273e-02f,
  -1.13509297e-01f, -6.13394640e-02f, -1.17631331e-01f, -1.75996751e-01f, -8.11321363e-02f, -5.36190681e-02f, 1.88679859e-01f, 3.34900558e-01f, 9.23913047e-02f, 4.09710333e-02f,
  -2.61312842e-01f, -3.17619257e-02f, 1.50227189e-01f, -2.49876007e-02f, 1.95992783e-01f, 2.03834828e-02f, 1.55460343e-01f, 5.54485573e-03f, 1.86158027e-02f, 5.15324436e-02f,
  -1.97349079e-02f, 1.29141003e-01f, 1.28413841e-01f, 5.62885366e-02f, 4.92547974e-02f, -9.94270369e-02f, -4.93752137e-02f, -2.06314772e-02f, -3.21783163e-02f, 3.75775732e-02f,
  6.24770820e-02f, -1.02094226e-01f, -1.27686992e-01f, -1.09330721e-01f, -2.65421961e-02f, -2.09326465e-02f, -7.28000095e-03f, 6.51211068e-02f, -5.66306263e-02f, 3.72237414e-02f,
  9.78875980e-02f, -3.71693843e-03f, -2.74969079e-02f, 2.39001848e-02f, 5.43364622e-02f, 1.04058504e-01f, 4.29289117e-02f, -9.91896242e-02f, 1.14024051e-01f, 2.33827922e-02f,
  -4.81296284e-03f, 4.01162729e-02f, -1.16263472e-01f, 2.33118329e-03f, -6.71275333e-02f, -6.06159978e-02f, -1.04779854e-01f, 2.23813467e-02f, 2.89557967e-02f, -8.11155513e-02f,
  -5.58627173e-02f, 2.73956619e-02f, -1.42056912e-01f, -4.23476920e-02f, -2.28909388e-01f, -1.68432206e-01f, -1.16323642e-01f, -6.77489564e-02f, -1.04254402e-01f, -1.11926638e-01f,
  -5.61277457e-02f, -1.32624909e-01f, -2.32981429e-01f, -1.27928659e-01f, -1.77732706e-01f, -2.72844315e-01f, -2.40756333e-01f, -1.41214728e-01f, -1.92054093e-01f, -1.56464994e-01f,
  -1.03069079e+00f, 2.31670365e-02f, 2.45364942e-02f, -1.86723009e-01f, -5.73755614e-02f, 1.38703948e-02f, 2.85991639e-01f, 5.38658835e-02f, -1.78760052e-01f, 8.29483718e-02f,
  1.15002446e-01f, -4.01423313e-03f, -7.05469996e-02f, -5.08987717e-03f, 1.53995063e-02f, 1.94658756e-01f, 4.82619889e-02f, -1.94684207e-01f, -2.34030247e-01f, 8.36982131e-02f,
  1.78086553e-02f, -2.24846497e-01f, -2.77425289e-01f, -1.44186363e-01f, 8.18829313e-02f, 4.19745743e-02f, -1.63014065e-02f, -9.74308513e-03f, 7.83251077e-02f, 1.36234313e-01f,
  4.69426066e-01f, -4.76860367e-02f, -6.09339681e-03f, -2.42496636e-02f, 6.02959320e-02f, -2.03018084e-01f, 3.81820579e-03f, 5.13225608e-02f, -4.96471189e-02f, 1.80580199e-01f,
  -8.44528973e-02f, -3.12832743e-02f, -5.00936769e-02f, -4.16731499e-02f, 2.58488897e-02f, -2.43181791e-02f, 1.22699745e-01f, 1.17676876e-01f, 2.42556378e-01f, 1.76956505e-01f,
  1.01173319e-01f, 1.20492242e-01f, 2.11301729e-01f, 1.60620525e-01f, -1.83006339e-02f, 1.46063967e-02f, 2.46679019e-02f, 1.63481999e-02f, 3.36303413e-02f, 1.43983930e-01f,
  -1.24225706e-01f, 7.06221014e-02f, 7.45201260e-02f, 4.91392910e-02f, -2.88143139e-02f, -3.17571200e-02f, 3.23893391e-02f, 1.02245398e-02f, -3.03537231e-02f, -2.06112683e-01f,
  6.71996772e-02f, 1.45468473e-01f, 7.29753599e-02f, 1.12244844e-01f, 2.23150942e-02f, 7.16775358e-02f, -1.60442024e-01f, 7.32231066e-02f, 6.26949966e-02f, -5.27592050e-03f,
  -2.37695687e-02f, 8.58982876e-02f, 8.97589400e-02f, 1.54219344e-01f, 1.38437420e-01f, 1.59691378e-01f, -1.40682738e-02f, -3.34472954e-02f, -1.59368873e-01f, -5.74802905e-02f,
  4.02610451e-01f, -5.88769428e-02f, -8.18538964e-02f, -9.77110118e-02f, -1.58132389e-02f, -1.07688405e-01f, -9.83845443e-02f, 3.43878604e-02f, 2.06501354e-02f, 2.06930935e-02f,
  -5.00684641e-02f, -1.26295403e-01f, -1.37327746e-01f, -7.59021565e-03f, -1.27486229e-01f, -6.29232973e-02f, 5.28411381e-02f, 1.56977177e-02f, 1.58378422e-01f, 5.97760677e-02f,
  -9.14992467e-02f, 1.21158704e-01f, 2.60966178e-02f, 3.71869877e-02f, -7.96603486e-02f, -5.00695780e-02f, 4.30651046e-02f, 1.03908613e-01f, 4.13845815e-02f, 5.22987358e-02f,
  -3.49908173e-01f, 1.64965112e-02f, 3.81990778e-03f, -5.41222319e-02f, 1.22531064e-01f, -8.18736851e-02f, -7.89679587e-02f, -1.04031242e-01f, 7.64733255e-02f, -6.52477965e-02f,
  5.80731668e-02f, 4.50406829e-03f, 1.69710830e-01f, 4.12972420e-02f, -1.85444385e-01f, 1.24326639e-01f, 1.66675404e-01f, -3.04851104e-02f, -1.45983264e-01f, -1.77993298e-01f,
  9.16815549e-02f, 3.01271509e-02f, -1.30698070e-01f, -1.36371970e-01f, 6.20282590e-02f, -5.33472821e-02f, 1.57997087e-01f, 9.07246489e-03f, 1.12521850e-01f, 2.87488461e-01f,
  3.97167318e-02f, -1.11252397e-01f, 1.18100405e-01f, 8.02449211e-02f, 7.07037598e-02f, -2.02571228e-01f, -1.90318227e-01f, 1.06723189e-01f, 6.02889434e-02f, -5.85070252e-02f,
  7.08687305e-02f, -7.61263371e-02f, 7.88260624e-02f, 7.64135197e-02f, -4.09287326e-02f, -1.90256596e-01f, -7.83213601e-02f, -1.57506064e-01f, -1.26590598e-02f, -1.68604597e-01f,
  1.05273150e-01f, 4.87678610e-02f, -1.07857265e-01f, -1.13984667e-01f, -2.18020201e-01f, 4.87348344e-03f, -4.21219058e-02f, -3.36646736e-02f, -1.73824281e-01f, -1.53582379e-01f,
  -3.30914184e-02f, 1.12486996e-01f, 6.59797266e-02f, 5.08249924e-02f, 1.90485381e-02f, 1.72710530e-02f, 1.36946708e-01f, 6.87432662e-02f, -1.16810881e-01f, -4.39328030e-02f,
  -4.23950553e-02f, -7.15938434e-02f, 5.12034819e-02f, 5.84974959e-02f, 6.93545491e-02f, 5.85539415e-02f, 9.38232429e-03f, -3.42692994e-02f, 1.06083173e-02f, -1.43383089e-02f,
  2.26900056e-02f, -7.33552054e-02f, 1.29025588e-02f, 1.70046985e-02f, 7.86857456e-02f, -5.60872890e-02f, 2.84030586e-02f, -1.26414120e-01f, -1.19633123e-01f, -8.16087937e-04f,
  -7.26674423e-02f, 2.21728161e-01f, 1.13484852e-01f, -6.30964413e-02f, 7.76049644e-02f, 8.09384286e-02f, -6.07690252e-02f, 6.31553587e-03f, 3.08550186e-02f, -1.36272281e-01f,
  -8.32584053e-02f, -1.78958122e-02f, 1.05992876e-01f, 8.36130232e-02f, -9.98077616e-02f, -6.65149838e-02f, -1.54650286e-01f, 5.39770611e-02f, -8.12564120e-02f, -1.18387036e-01f,
  -1.66002795e-01f, -1.76018789e-01f, -2.17165843e-01f, -1.27983481e-01f, 1.14128087e-03f, -1.60972979e-02f, 4.54886928e-02f, -1.26028001e-01f, -1.90287903e-01f, -3.81487459e-01f,
  -3.90891492e-01f, -2.14318618e-01f, -1.91277161e-01f, -3.11181873e-01f, -9.31619704e-02f, 3.38718295e-02f, -1.96299538e-01f, 1.34775862e-01f, 2.33795289e-02f, -3.16745639e-01f,
  -1.48364201e-01f, 2.80322134e-02f, -5.18089458e-02f, 4.34877053e-02f, -6.13322891e-02f, -3.61970693e-01f, -2.04249233e-01f, -9.86882150e-02f, 8.06206465e-02f, 4.76997644e-02f,
  -1.76504970e-01f, -2.64955580e-01f, 3.87467295e-02f, 5.01954705e-02f, -1.72508433e-01f, -3.09456941e-02f, -2.36872494e-01f, 1.90786831e-02f, -2.26253271e-02f, -2.37120703e-01f,
  -2.23343611e-01f, -3.06524634e-02f, 6.33239374e-02f, -7.94551298e-02f, -1.28696576e-01f, 9.06205773e-02f, -7.33492002e-02f, -1.75492272e-01f, 3.75091285e-02f, -9.89002660e-02f,
  -2.04615593e-02f, 5.85109591e-02f, 2.34952923e-02f, 1.82675477e-02f, -8.08894187e-02f, -4.22349013e-02f, -9.34965089e-02f, -7.75170997e-02f, -6.82880506e-02f, -3.48875448e-02f,
  2.11828444e-02f, 5.49295396e-02f, -8.22262987e-02f, 6.97593242e-02f, 1.62276983e-01f, 3.93669074e-03f, 8.41734782e-02f, 1.64398164e-01f, 2.26910457e-01f, -1.79621935e-01f,
  -1.54794842e-01f, -1.25243723e-01f, -1.16759717e-01f, 6.34688437e-02f, 1.62196178e-02f, -1.97098665e-02f, -7.02147856e-02f, 3.80581729e-02f, -2.65399758e-02f, -5.76919541e-02f,
  -4.94040139e-02f, 5.52775301e-02f, -2.38672979e-02f, -7.48821646e-02f, -5.20907417e-02f, -1.14418648e-03f, -2.44520307e-02f, -3.35099399e-02f, -2.70980485e-02f, -7.97018632e-02f,
  -3.40574235e-02f, 5.52093983e-02f, -1.17873155e-01f, 2.89324578e-02f, -8.09495896e-03f, 3.50265913e-02f, 6.06758334e-02f, 5.32999001e-02f, 6.68264031e-02f, 9.31756571e-02f,
  -2.29679510e-01f, 1.66341811e-01f, -5.09815775e-02f, 5.48586473e-02f, -8.94646421e-02f, -1.16538994e-01f, -1.41057149e-01f, -3.48052308e-02f, 7.68561736e-02f, -6.79173097e-02f,
  2.86174864e-02f, -2.98793148e-02f, -1.11309454e-01f, -1.38450721e-02f, -7.73293599e-02f, -1.23958765e-02f, -7.76925832e-02f, -2.68835966e-02f, 7.26786405e-02f, -2.08152793e-02f,
  4.28854488e-02f, 9.42322984e-02f, -5.80872409e-02f, -2.94294115e-02f, 7.92123452e-02f, 8.22579563e-02f, -6.65873587e-02f, 8.94696563e-02f, -1.01923877e-02f, -2.20170036e-01f,
  -3.83990139e-01f, -2.79558271e-01f, -6.03267886e-02f, -8.78089890e-02f, -3.40785123e-02f, 9.87907946e-02f, -3.54406647e-02f, 1.00568108e-01f, 3.27237286e-02f, -2.42699668e-01f,
  -1.01023898e-01f, 7.00089410e-02f, -5.06002735e-03f, -3.27041596e-02f, -6.58247098e-02f, -1.60434410e-01f, -1.86735705e-01f, -3.29271778e-02f, 2.14668572e-01f, 2.39057854e-01f,
  8.60530064e-02f, 4.13955078e-02f, 6.42907014e-03f, 1.91329375e-01f, -1.13994777e-01f, -5.13587222e-02f, -1.01396851e-01f, -8.15481395e-02f, -1.22931115e-02f, -2.94569939e-01f,
  -1.60677940e-01f, -1.40866995e-01f, 1.82779834e-01f, 1.64512508e-02f, -1.41341642e-01f, -1.56550124e-01f, -9.97689590e-02f, 1.30021675e-02f, 7.94083700e-02f, 1.56592056e-02f,
  7.14274645e-02f, 1.29451066e-01f, -1.23291239e-01f, 8.93716048e-03f, 2.20974796e-02f, 1.55127451e-01f, 6.61654770e-02f, 8.23288336e-02f, -2.58124061e-02f, 4.64596152e-02f,
  2.89383791e-02f, -7.77922720e-02f, -1.75518282e-02f, 4.25373204e-02f, -1.12583905e-01f, -8.39469954e-02f, -8.56042728e-02f, -1.05718590e-01f, -6.80889189e-02f, -2.88588345e-01f,
  1.29105061e-01f, -1.15762660e-02f, 6.99483082e-02f, -5.54280691e-02f, 2.01417357e-02f, 1.04174539e-01f, 1.25174755e-02f, -5.56292012e-02f, 1.22373894e-01f, 1.46391541e-02f,
  1.16894163e-01f, 1.49215311e-01f, 1.53051704e-01f, 5.42468093e-02f, 9.44736078e-02f, -1.54838767e-02f, 1.53545171e-01f, -3.23622562e-02f, 2.45116446e-02f, -1.51163228e-02f,
  -1.11505531e-01f, -1.17861241e-01f, 5.86731210e-02f, 1.19136855e-01f, -6.16624653e-02f, -5.29554207e-03f, -9.00116935e-02f, -4.27681729e-02f, -3.57305110e-02f, 4.93225455e-02f,
  -9.33336690e-02f, -9.48063731e-02f, -2.63110679e-02f, 1.84674725e-01f, -1.64046790e-02f, 9.29681733e-02f, -1.88880526e-02f, 3.45094837e-02f, -1.30687520e-01f, -1.40949354e-01f,
  3.65689173e-02f, -7.70194689e-03f, -1.75741524e-01f, 5.62704019e-02f, -1.89532377e-02f, 1.16199903e-01f, -3.43061760e-02f, -4.64003161e-02f, -6.67755306e-02f, 2.95012631e-02f,
  3.85183766e-02f, -8.25728551e-02f, -6.79177791e-02f, -1.90484703e-01f, -1.45760402e-01f, -8.53625387e-02f, -1.59004241e-01f, -7.07069337e-02f, -2.30774254e-01f, -4.14537400e-01f,
  -3.60983193e-01f, 1.90297201e-01f, -1.94784641e-01f, -5.36638424e-02f, 2.85421938e-01f, 3.08095396e-01f, 2.97451168e-01f, 5.57753146e-02f, -8.06257576e-02f, 9.92720276e-02f,
  1.11732900e-01f, 1.59004852e-01f, -3.06393579e-02f, 1.21149160e-01f, 9.66658145e-02f, 8.93923640e-02f, 9.38947797e-02f, -1.54970407e-01f, -2.06355631e-01f, 1.61780771e-02f,
  1.00193294e-02f, -1.04470998e-01f, -2.64227241e-01f, -6.88438714e-02f, -2.81305183e-02f, 2.01522931e-02f, -2.26849262e-02f, -3.63838747e-02f, 4.75371554e-02f, -1.68958634e-01f,
  -1.19702958e-01f, 2.98591070e-02f, -1.21461347e-01f, -2.07558498e-01f, -6.25478625e-02f, -2.20285922e-01f, -4.66542840e-02f, -1.40386075e-01f, -1.48073435e-02f, 4.38138209e-02f,
  -1.62207618e-01f, -6.94485456e-02f, 5.56160638e-04f, -9.01168808e-02f, 1.55261994e-04f, -3.42031121e-02f, -3.57499570e-02f, -7.55086318e-02f, -5.32400943e-02f, 3.67052816e-02f,
  1.11049674e-01f, -2.65422985e-02f, -1.53166935e-01f, -4.12002020e-02f, -2.22154185e-02f, -2.21542502e-03f, -2.33111773e-02f, -1.65377662e-01f, -1.13358662e-01f, -2.38782510e-01f,
  1.45470783e-01f, -3.59541699e-02f, -8.02074671e-02f, 1.74728166e-02f, 7.28085861e-02f, 1.00204840e-01f, -6.54251082e-03f, -2.79686041e-02f, 1.82752702e-02f, -1.02915749e-01f,
  -6.23941049e-02f, 1.21474750e-02f, 6.81551844e-02f, -4.81248908e-02f, 5.26578538e-02f, 3.99098825e-03f, -3.89269255e-02f, 2.32058819e-02f, 3.65352444e-02f, 8.62335712e-02f,
  3.24114114e-02f, -1.46640046e-02f, 2.56161280e-02f, 3.55647854e-03f, 1.07785732e-01f, 6.44097105e-02f, -9.96721014e-02f, 8.84361938e-02f, -4.03255373e-02f, 1.73896044e-01f,
  -1.69202283e-01f, 2.57757187e-01f, -1.18795753e-01f, 2.40517929e-02f, -1.74534425e-01f, 8.78289416e-02f, -1.64577942e-02f, 1.86064541e-01f, 4.02809940e-02f, 1.71785861e-01f,
  -2.40325835e-02f, -1.21603049e-01f, 5.69716543e-02f, 1.00478373e-01f, 6.53187633e-02f, 2.78264638e-02f, 2.09497526e-01f, 7.99915716e-02f, 6.56876266e-02f, -5.73944524e-02f,
  -6.72016516e-02f, -9.09079984e-02f, -2.79671699e-01f, -6.35947585e-02f, 1.21176288e-01f, -1.21888826e-02f, -8.69367495e-02f, -1.37033850e-01f, -8.42718557e-02f, -2.37585187e-01f,
  2.95748055e-01f, 1.56718809e-02f, -1.48133636e-01f, 1.75056741e-01f, -2.35178366e-01f, -1.05864242e-01f, 9.71301198e-02f, -1.04495905e-01f, -1.22000724e-01f, 1.15592606e-01f,
  -6.95968494e-02f, -1.04883090e-01f, -2.26363763e-02f, 3.17009315e-02f, 4.61301953e-03f, 2.27189094e-01f, 1.09350584e-01f, 1.23503149e-01f, -1.96620107e-01f, -1.68554410e-01f,
  -5.14805764e-02f, 1.65064543e-01f, 1.93594974e-02f, -6.68500662e-02f, 1.58269107e-02f, -2.70158760e-02f, 2.18303595e-02f, -4.83496301e-02f, -1.91805094e-01f, 6.63154051e-02f,
  2.38776445e-01f, -1.56262487e-01f, -2.07022801e-01f, -1.61468253e-01f, 5.47846146e-02f, 2.22953279e-02f, 1.55417100e-01f, 1.54886274e-02f, -1.30983740e-01f, 6.27699494e-02f,
  -3.77452895e-02f, -1.73229259e-02f, 2.19511781e-02f, 6.91401139e-02f, 8.79664421e-02f, 8.81758779e-02f, 9.78698954e-02f, -1.94084533e-02f, 1.72052588e-02f, 4.78333160e-02f,
  -3.49074998e-03f, -8.77017602e-02f, 8.27154610e-03f, -8.60635191e-02f, -5.80727942e-02f, -9.03266072e-02f, -1.24241427e-01f, -6.46522120e-02f, -1.05526939e-01f, 1.69148687e-02f,
  3.27304192e-02f, -6.50894269e-02f, 5.45961708e-02f, 1.01995237e-01f, 4.36568856e-02f, -6.76015094e-02f, 1.84968084e-01f, 1.12057654e-02f, 9.37614888e-02f, -1.32384850e-02f,
  2.18949262e-02f, -1.15455031e-01f, 3.58794164e-03f, -4.66271210e-03f, 1.08990215e-01f, -7.19869928e-03f, 6.20341562e-02f, 1.84255168e-01f, -2.39165220e-02f, 4.83836532e-02f,
  3.13554034e-02f, 8.64154398e-02f, 6.59471005e-02f, 1.42953098e-01f, -8.90429989e-02f, -2.65434794e-02f, 1.39774540e-02f, -1.19179599e-01f, 2.50216164e-02f, 5.85197359e-02f,
  1.64527565e-01f, -1.82416126e-01f, 1.08569592e-01f, -7.50591010e-02f, -1.10840969e-01f, -6.30157590e-02f, -3.10337916e-02f, -1.59084909e-02f, -7.90070295e-02f, 3.00592035e-02f,
  -1.73512474e-01f, -9.64329317e-02f, 1.74520507e-01f, 5.63275851e-02f, -1.59277041e-02f, -2.73477994e-02f, 9.43766683e-02f, 4.65749688e-02f, -2.65592579e-02f, 3.51143405e-02f,
  1.38768122e-01f, -5.96155003e-02f, 1.25114039e-01f, -2.81917071e-03f, -2.61809882e-02f, 8.73917639e-02f, 9.89717841e-02f, 3.14479657e-02f, 5.71729802e-02f, 3.42271596e-01f,
  2.50734687e-01f, 1.28169239e-01f, 1.02228895e-01f, 2.19525397e-01f, -3.01378310e-01f, -5.05924761e-01f, -4.73781437e-01f, -1.27511546e-01f, 1.08518615e-01f, 7.28078932e-02f,
  -7.28713199e-02f, -7.28396103e-02f, 8.50296170e-02f, -3.37672904e-02f, -2.55317509e-01f, -1.23065829e-01f, 1.04868338e-01f, -1.64528713e-02f, -1.80815846e-01f, -3.72567683e-01f,
  -1.14615053e-01f, 5.34506589e-02f, 5.75428270e-02f, 1.03640335e-03f, 1.65928468e-01f, -6.75236806e-02f, 6.06678464e-02f, 1.18338384e-01f, 2.70858407e-02f, 3.68349671e-01f,
  1.91193178e-01f, 8.90823379e-02f, -3.24856967e-01f, -1.33179173e-01f, -1.36137933e-01f, 1.11821637e-01f, -9.76613760e-02f, 1.50210679e-01f, 7.65499696e-02f, -5.70310373e-03f,
  -4.12415639e-02f, -8.40684474e-02f, 2.26279907e-02f, -4.39745449e-02f, -1.39880329e-01f, -1.51650146e-01f, -3.55276465e-02f, 2.35041499e-01f, 9.68738869e-02f, 1.00225434e-01f,
  -8.77537392e-03f, -2.17596330e-02f, 1.91257894e-03f, -9.12430286e-02f, 3.91617939e-02f, 3.26997824e-02f, -1.47324935e-01f, 7.15412498e-02f, -1.18798122e-01f, 1.93222180e-01f,
  -1.58125386e-02f, 1.61977038e-02f, -6.74629658e-02f, 3.13272551e-02f, 1.39772207e-01f, 2.05220329e-03f, 4.79708202e-02f, 2.93444619e-02f, -3.48274074e-02f, -1.93439405e-02f,
  2.64891144e-03f, 2.00982187e-02f, -3.25242206e-02f, 6.57401979e-02f, 1.04707852e-01f, -7.46551435e-03f, -5.56485355e-02f, -1.12719275e-02f, -2.06815321e-02f, 9.04618278e-02f,
  5.13768464e-05f, 2.05355957e-02f, -3.81852984e-02f, 2.51057092e-02f, -2.40593646e-02f, 5.56130372e-02f, -2.32853834e-02f, -1.06291540e-01f, 1.16282441e-01f, 4.33391780e-02f,
  -2.99101546e-02f, -2.95271814e-01f, -5.07972352e-02f, -1.87770128e-01f, -1.18789233e-01f, -3.29115950e-02f, 5.71327880e-02f, -2.76058055e-02f, 5.09776473e-02f, 2.21825932e-04f,
  -1.26355499e-01f, 4.82843406e-02f, 8.86355899e-03f, -5.22348881e-02f, -9.91760939e-02f, -2.57947631e-02f, -1.75713692e-02f, -8.98168609e-02f, -1.22368112e-01f, 2.28985641e-02f,
  -5.74269742e-02f, 1.49425110e-02f, -8.06502476e-02f, 5.62793314e-02f, 1.29035234e-01f, -2.04673767e-01f, -1.58752352e-01f, 2.01553516e-02f, -3.12349141e-01f, -1.30447090e-01f,
  -2.04145253e-01f, 1.75251752e-01f, -1.64646387e-01f, 1.96445122e-01f, 8.77400339e-02f, -2.53194645e-02f, -1.07871462e-02f, -8.51344466e-02f, 1.74769849e-01f, 9.64736938e-02f,
  -8.21917579e-02f, 4.02443409e-02f, 1.45774990e-01f, 2.46551335e-02f, -2.21179761e-02f, 9.72438231e-02f, 1.54969916e-01f, -1.51449621e-01f, -1.93751097e-01f, -1.50068417e-01f,
  1.89644843e-01f, 1.78677142e-01f, -1.37327701e-01f, -8.35890707e-04f, 1.43315256e-01f, 1.66796967e-01f, 1.88111281e-03f, 7.77476132e-02f, -4.36601322e-03f, 2.11508915e-01f,
  -1.00248225e-01f, -6.48146449e-03f, -2.62591634e-02f, 8.19622576e-02f, -1.91088468e-01f, -9.44641456e-02f, -6.42252192e-02f, -1.20461620e-01f, 1.86512712e-02f, 1.97737098e-01f,
  -1.16948515e-01f, -2.22163852e-02f, 1.12423621e-01f, 5.99919213e-03f, -5.90169989e-02f, -2.23396167e-01f, -1.05732366e-01f, -3.37341875e-01f, -2.61230588e-01f, -1.05971836e-01f,
  1.53166540e-02f, -5.11242412e-02f, -2.76363641e-01f, -7.99237639e-02f, -2.48175323e-01f, -1.86543092e-02f, -2.05735013e-01f, -1.68890670e-01f, -2.21389160e-01f, -2.03438122e-02f,
  -1.76954240e-01f, -3.15319419e-01f, 5.30846380e-02f, 1.07450396e-01f, 5.19011542e-02f, -2.96770670e-02f, 4.16985117e-02f, 7.31652752e-02f, 1.61510989e-01f, -1.34658143e-02f,
  6.04114905e-02f, -2.80283000e-02f, 1.28458977e-01f, -6.36037439e-03f, 4.91475277e-02f, -1.36137800e-02f, 9.38328728e-03f, -1.80713162e-02f, 2.09018216e-02f, 1.99531596e-02f,
  7.63994828e-02f, -1.52855497e-02f, -4.99481335e-02f, -8.81396979e-03f, 1.02190897e-01f, -6.35940731e-02f, 1.98062137e-03f, -1.19037535e-02f, 1.16325147e-01f, -4.20073830e-02f,
  2.08756462e-01f, 5.94650209e-02f, 5.83068803e-02f, -4.52193171e-02f, -3.52867879e-02f, 4.42833193e-02f, 4.51057442e-02f, 8.26670751e-02f, 1.26924083e-01f, -8.70059133e-02f,
  -7.07089305e-02f, -2.36521214e-02f, 1.73352748e-01f, 1.88150443e-02f, 7.02175796e-02f, -7.67351910e-02f, 4.82806228e-02f, -9.70525220e-02f, -9.16090235e-03f, -1.15859933e-01f,
  1.47053540e-01f, 3.84369045e-02f, -9.36952885e-03f, 6.38036355e-02f, -2.62587368e-02f, 1.71605304e-01f, 5.20120189e-02f, 2.13048503e-01f, -1.33409366e-01f, 1.07148699e-01f,
  1.31191179e-01f, -3.54602844e-01f, -1.68988839e-01f, 1.20079573e-02f, -3.20001304e-01f, -2.80168086e-01f, -4.91196483e-01f, -1.94960961e-03f, -5.91542292e-03f, -4.08427536e-01f,
  -2.37280220e-01f, 4.52564023e-02f, 1.24997757e-01f, 1.37972012e-01f, 1.66778535e-01f, -1.87045738e-01f, -6.02429882e-02f, 2.42689595e-01f, 3.38773429e-01f, -1.28677160e-01f,
  -1.16026223e-01f, 7.22684562e-02f, 2.19230503e-01f, 4.52733748e-02f, -2.02133745e-01f, 1.19773991e-01f, -7.80054256e-02f, -9.80345085e-02f, -1.67737126e-01f, -2.31254920e-01f,
  -1.48511186e-01f, -2.37352535e-01f, 1.38906464e-01f, 5.02098873e-02f, -1.46415904e-01f, 6.68929890e-02f, 5.05963489e-02f, 1.17867090e-01f, 8.58013183e-02f, -9.33547169e-02f,
  -5.29706068e-02f, -2.89364695e-03f, -4.95451763e-02f, -8.30528587e-02f, -8.85639638e-02f, -9.53900814e-02f, -1.03791365e-02f, 1.07895494e-01f, -4.58026864e-03f, -1.46038532e-01f,
  -2.69001871e-02f, -7.34558702e-02f, -1.70077588e-02f, -1.88916195e-02f, 1.93590105e-01f, -4.48031239e-02f, -9.16314498e-02f, -1.36796236e-01f, -8.00689757e-02f, -1.56360641e-01f,
  -1.02514952e-01f, -1.32169137e-02f, -1.58959776e-02f, 1.11657709e-01f, 1.43415093e-01f, 6.71315715e-02f, 5.98597154e-02f, -7.87730142e-03f, 1.00408226e-01f, -1.68002564e-02f,
  -2.63663847e-03f, 5.21591716e-02f, 5.70965670e-02f, -1.32132709e-01f, -7.95533694e-03f, -2.61936877e-02f, 7.00042024e-02f, -2.33749188e-02f, -8.82158503e-02f, -1.23918774e-02f,
  -1.09058684e-02f, -9.92297977e-02f, 1.63221993e-02f, 2.63190307e-02f, -7.22906068e-02f, 6.39860183e-02f, -3.02892104e-02f, -3.37860659e-02f, -6.86476156e-02f, -1.47154316e-01f,
  1.32833615e-01f, -4.01904769e-02f, -1.12780869e-01f, 5.42256497e-02f, 4.26521562e-02f, -1.33951485e-01f, -1.23303659e-01f, 8.98536220e-02f, 1.91069106e-04f, -1.21335819e-01f,
  1.68951638e-02f, -4.11012536e-03f, -1.23668313e-01f, -6.09904900e-02f, 1.09674305e-01f, 9.56099555e-02f, 9.77330953e-02f, -1.06022805e-02f, -1.28668994e-02f, -3.06876730e-02f,
  1.00847542e-01f, -1.23171695e-02f, 1.38320383e-02f, -2.22976431e-02f, 3.85804251e-02f, 3.91416848e-02f, -2.83822771e-02f, 2.70160232e-02f, 6.55600429e-02f, -1.73383147e-01f,
  -2.45756790e-01f, -2.05514416e-01f, 5.20447902e-02f, -3.70936021e-02f, -6.46291673e-02f, -9.06558037e-02f, -2.84041435e-01f, -7.00025409e-02f, 1.98493004e-02f, -4.70998764e-01f,
  -3.26948971e-01f, 6.12081029e-02f, 6.85358271e-02f, 2.74072196e-02f, -7.63241127e-02f, -3.64895076e-01f, -2.44060799e-01f, 4.39499319e-02f, 5.11361696e-02f, -1.02157362e-01f,
  -1.78777844e-01f, -6.33047074e-02f, 9.30147246e-02f, 1.23956449e-01f, -3.73774371e-03f, 5.21535464e-02f, 1.62260607e-01f, -9.25373752e-03f, 1.55012965e-01f, -3.52802081e-03f,
  -9.47073922e-02f, -9.47178602e-02f, 1.25874475e-01f, -7.30445907e-02f, -9.53836665e-02f, -4.54235785e-02f, -1.52391776e-01f, 1.56863257e-01f, 5.63910380e-02f, -3.23121287e-02f,
  -8.78275111e-02f, -3.45191322e-02f, -1.02109537e-02f, -4.14600037e-02f, -3.92313041e-02f, -1.73756644e-01f, -3.82575318e-02f, -1.34859353e-01f, -1.43582940e-01f, -9.95985717e-02f,
  -2.80630976e-01f, -1.38603717e-01f, -7.73353502e-02f, 8.02559555e-02f, -2.33062599e-02f, -7.20717534e-02f, 9.41291079e-02f, 1.55460939e-01f, 2.13685721e-01f, 8.61798823e-02f,
  -1.75830573e-02f, 4.28788364e-04f, 6.85630832e-03f, -2.07223929e-02f, -9.98091884e-03f, -4.11130860e-03f, -3.73388343e-02f, 1.31212790e-02f, -7.24775419e-02f, 4.69393469e-02f,
  -3.78778651e-02f, -6.63004443e-02f, -9.45302248e-02f, -3.89694571e-02f, 7.38027394e-02f, -6.87067881e-02f, 1.01295061e-01f, -7.59343356e-02f, 8.94384502e-05f, -5.89142852e-02f,
  3.86756919e-02f, -1.74512770e-02f, 7.51178339e-03f, 7.18407333e-02f, -4.80722487e-02f, -3.69147323e-02f, 5.31205051e-02f, 2.66796723e-02f, 2.55487654e-02f, -7.73320794e-02f,
  7.74054602e-02f, 1.04848593e-01f, -9.71721262e-02f, 2.29638023e-03f, 3.69708501e-02f, -1.03835613e-02f, -4.87385727e-02f, 1.02828816e-01f, 4.18933928e-02f, -1.04819223e-01f,
  -1.56761006e-01f, -1.48598813e-02f, -1.76159203e-01f, -8.48415866e-02f, -3.79259810e-02f, 1.99948400e-02f, -2.13929370e-01f, 9.73934829e-02f, 6.82634190e-02f, -1.55566052e-01f,
  -1.22342467e-01f, -1.73342749e-01f, -6.08367287e-02f, -9.79259145e-04f, 4.95152511e-02f, -5.39557114e-02f, 1.96858197e-02f, 3.28599662e-02f, 5.36794811e-02f, 4.25752252e-02f,
  2.48150975e-01f, -1.73432454e-01f, 4.00120497e-01f, 1.02426536e-01f, 2.92438507e-01f, 3.82693797e-01f, 4.19923991e-01f, 1.80441529e-01f, -2.02673916e-02f, -4.19384241e-03f,
  -1.99364424e-01f, -4.44685191e-01f, -4.40218866e-01f, -2.52396107e-01f, -9.82231274e-02f, 1.58612952e-01f, 9.51085240e-02f, 1.08381286e-01f, 2.09418580e-01f, 8.10313225e-02f,
  -1.30619541e-01f, 6.16012998e-02f, 2.71913111e-02f, -1.76848695e-02f, -4.32140864e-02f, -9.28016230e-02f, 1.16488017e-01f, 4.04690690e-02f, -6.96486011e-02f, -8.90712738e-02f,
  -5.27715236e-02f, 1.16023347e-01f, -3.03883664e-02f, -1.94429010e-01f, -8.15850198e-02f, -1.70626849e-01f, -5.15139811e-02f, -7.70768896e-02f, -8.87553766e-02f, 7.89339840e-02f,
  -7.54276291e-02f, -1.89885392e-03f, -8.09127763e-02f, -6.74655363e-02f, 2.32884698e-02f, 3.41962799e-02f, -8.17319006e-02f, -1.35135606e-01f, -6.82801381e-02f, -2.41982993e-02f,
  -1.69091478e-01f, 6.27592057e-02f, 1.71176329e-01f, 7.86229223e-02f, 1.13001661e-04f, 2.81541352e-03f, 4.36137803e-02f, 1.02500252e-01f, 3.25704482e-03f, -4.17262688e-02f,
  -5.38022742e-02f, -6.45785630e-02f, -1.82109920e-03f, 7.91424140e-03f, 6.10963032e-02f, 1.44156247e-01f, 5.13364039e-02f, -8.78669787e-03f, -6.95389882e-02f, 1.30109303e-02f,
  -1.55852944e-01f, -8.99919048e-02f, -3.50618251e-02f, 5.48635460e-02f, -6.06483556e-02f, 4.59139831e-02f, -2.84459163e-02f, -4.40749153e-02f, -4.53102998e-02f, 3.74892801e-02f,
  -1.05561942e-01f, -3.88584696e-02f, 7.87629187e-03f, -3.27062607e-02f, -4.71276864e-02f, -9.48765129e-02f, -4.33856100e-02f, -1.77090615e-01f, -5.06568998e-02f, 1.55266905e-02f,
  -3.43083888e-01f, 1.66853741e-02f, -9.06298161e-02f, -1.12538077e-01f, 4.63343449e-02f, -1.46689013e-01f, -2.73201391e-02f, 1.73185077e-02f, 6.40645623e-02f, 6.03858568e-02f,
  5.23514189e-02f, -2.50513330e-02f, -8.54265019e-02f, -6.13014400e-03f, 8.26787055e-02f, -1.01136044e-01f, -4.54182066e-02f, 2.14798539e-03f, -1.50016159e-01f, -1.94874275e-02f,
  2.72383168e-02f, 4.43716012e-02f, 1.06845990e-01f, -2.83445120e-02f, -2.90306062e-02f, -7.35734450e-03f, 1.16612211e-01f, 4.45106253e-02f, 1.59149230e-01f, -3.79565801e-03f,
  5.95518231e-01f, 1.86352164e-01f, 3.45983744e-01f, 5.09365164e-02f, 1.16306081e-01f, 1.11918300e-01f, 2.23359063e-01f, 1.37792990e-01f, 6.93309084e-02f, 1.18512645e-01f,
  2.64180392e-01f, 7.83412308e-02f, 6.84469938e-02f, -2.83171963e-02f, 2.27088109e-01f, 5.72404824e-02f, -8.64446759e-02f, 1.30920365e-01f, 9.28872898e-02f, 1.00001946e-01f,
  -1.31197602e-01f, 1.93043444e-02f, 1.25185400e-01f, 7.09632859e-02f, -1.94807619e-01f, 3.63048725e-02f, -6.77678660e-02f, 4.63837944e-02f, 4.10828479e-02f, -2.58605093e-01f,
  8.45496058e-02f, 1.98683500e-01f, -8.49205703e-02f, -5.74660711e-02f, -5.56366779e-02f, 2.36766841e-02f, -5.70642762e-02f, -5.06225973e-02f, -2.74510309e-02f, -6.54205456e-02f,
  -7.82240108e-02f, -5.93759157e-02f, -1.18036814e-01f, -1.74843624e-01f, -1.65812433e-01f, -1.60070941e-01f, -6.86719418e-02f, -5.14191464e-02f, 8.91767889e-02f, 2.02557687e-02f,
  -1.84104681e-01f, -8.15635398e-02f, -4.25128564e-02f, 5.82479723e-02f, 1.39451474e-01f, 2.29219534e-02f, 8.13566819e-02f, -1.00147486e-01f, 1.30628914e-01f, -1.86795741e-02f,
  -7.89837316e-02f, 7.78417066e-02f, 8.79107881e-03f, 4.81320545e-02f, 1.08410269e-01f, -7.56645352e-02f, 1.61432996e-02f, -5.03612272e-02f, 1.32508814e-01f, -7.94586092e-02f,
  -1.62882343e-01f, 1.80093627e-02f, 5.55589655e-03f, 4.31989729e-02f, -3.02129649e-02f, -5.08363917e-02f, -4.19922508e-02f, -4.58077751e-02f, -3.85364369e-02f, 1.01481816e-02f,
  -2.38487609e-02f, -7.69171268e-02f, 2.13433299e-02f, -8.28280747e-02f, 5.99719994e-02f, 9.09648016e-02f, 7.97021203e-03f, -8.13417956e-02f, -1.00536775e-02f, -1.58347115e-01f,
  -3.71163368e-01f, 2.01768070e-01f, -2.23352504e-03f, -1.29698157e-01f, -1.68477565e-01f, 8.90497491e-02f, 1.43470287e-01f, -2.17820778e-02f, 3.71901393e-02f, -2.54154019e-02f,
  5.01001030e-02f, 3.04074530e-02f, -1.07038785e-02f, -5.00975288e-02f, 3.62127759e-02f, -1.45651400e-01f, -1.43096643e-02f, -1.27637689e-03f, -8.90555009e-02f, -9.96307880e-02f,
  -2.21547365e-01f, -1.33986086e-01f, -1.34555355e-01f, -6.43538833e-02f, -7.23642036e-02f, 3.21926065e-02f, -1.73445344e-01f, -1.34059429e-01f, 9.54702571e-02f, 3.08507476e-02f,
  1.69835761e-01f, 2.82804854e-02f, 5.96973114e-02f, 1.55512229e-01f, -5.58857024e-02f, -2.43185207e-01f, -3.84987235e-01f, -2.60194212e-01f, -7.73657858e-02f, 3.99359800e-02f,
  -7.36148134e-02f, 6.90533817e-02f, 2.55404860e-02f, 8.49000663e-02f, -2.02537149e-01f, 2.41459757e-02f, 9.90477651e-02f, 5.96228428e-02f, -1.57226562e-01f, -1.86139449e-01f,
  1.28241882e-01f, 9.65128615e-02f, 2.56093368e-02f, -9.71314237e-02f, 1.90867841e-01f, 2.16629356e-02f, -1.46208284e-02f, 1.04186520e-01f, 8.42634514e-02f, 4.49345052e-01f,
  3.23800057e-01f, -8.56375918e-02f, -9.74361673e-02f, 8.79213661e-02f, 1.20047979e-01f, 7.41865337e-02f, 1.46789804e-01f, 6.69769347e-02f, -3.37454081e-02f, 1.28468812e-01f,
  2.00738624e-01f, 9.13864374e-02f, -4.72837985e-02f, 6.69032261e-02f, -6.47108257e-02f, -3.02466583e-02f, 2.58709333e-04f, 7.54364803e-02f, -4.07648180e-03f, 2.76566800e-02f,
  4.57021073e-02f, 6.52027503e-02f, -9.29163620e-02f, -1.74612358e-01f, -1.94037762e-02f, 1.12172030e-01f, -8.90882537e-02f, 9.04845167e-03f, -2.86301047e-01f, 7.22366050e-02f,
  -7.02057928e-02f, 7.67451599e-02f, 9.25631523e-02f, 1.14886358e-01f, 2.85321400e-02f, 9.32346955e-02f, 1.73336551e-01f, 7.46533349e-02f, -5.10384142e-02f, 1.31234333e-01f,
  7.39112720e-02f, -4.89276014e-02f, 6.54697269e-02f, 2.74909977e-02f, 7.28222951e-02f, 4.96157585e-03f, 2.12843325e-02f, -1.01789106e-02f, -2.47523095e-02f, 1.21360913e-01f,
  5.60046174e-02f, -5.69917075e-02f, 8.64292160e-02f, 1.40804406e-02f, -2.06822380e-02f, 9.39372927e-02f, 7.78497159e-02f, -1.20172808e-02f, 5.38672972e-03f, 1.03693269e-01f,
  -1.49733633e-01f, -2.16935799e-01f, 1.64615437e-01f, -5.30703738e-02f, 1.01259738e-01f, 6.77327886e-02f, 5.67792431e-02f, -1.42934723e-02f, 1.63321961e-02f, 1.35029584e-01f,
  4.93983217e-02f, 9.91236791e-02f, -3.32785733e-02f, -1.32674143e-01f, 5.47453612e-02f, 3.07429954e-02f, 1.29563555e-01f, -6.96918890e-02f, -1.64094269e-01f, 1.32700861e-01f,
  -1.83058605e-02f, -2.32192993e-01f, -1.70656607e-01f, -6.53083473e-02f, 8.95235315e-02f, -4.08500582e-02f, -1.04246981e-01f, -4.18125242e-02f, -1.70470789e-01f, -1.35853574e-01f,
  -3.19354057e-01f, 2.04983622e-01f, 1.76170111e-01f, -1.09106004e-01f, 1.67399971e-03f, 6.43453225e-02f, 1.04146488e-01f, 1.47376090e-01f, 3.56013142e-02f, -2.16455348e-02f,
  5.44706732e-02f, 4.76845950e-02f, -6.16778024e-02f, 3.47464159e-02f, 3.69754583e-02f, -1.03196338e-01f, -1.83932230e-01f, -1.22637108e-01f, 7.08921999e-02f, 2.43885115e-01f,
  6.21005297e-02f, -1.61122799e-01f, -8.54604840e-02f, -7.00913072e-02f, -2.65178680e-01f, -2.00689197e-01f, -2.02308655e-01f, -1.73442379e-01f, -9.55422893e-02f, -4.87135768e-01f,
  -3.09409976e-01f, -8.78073722e-02f, 1.01990029e-01f, -8.95800367e-02f, -2.48605683e-02f, 8.40079486e-02f, 1.61948904e-01f, 6.28717616e-02f, 7.09651560e-02f, 1.70440465e-01f,
  -1.20262668e-01f, 1.87316135e-01f, 3.41274291e-02f, -4.30189036e-02f, 2.54369136e-02f, -2.03586016e-02f, 2.54717236e-03f, 1.32579535e-01f, -5.99268936e-02f, 2.03228459e-01f,
  6.17808923e-02f, 1.25838503e-01f, -1.14258446e-01f, 1.45194039e-01f, 1.40684620e-01f, -1.05199024e-01f, -4.61328328e-02f, -1.58728380e-02f, 6.42306432e-02f, -1.43848866e-01f,
  1.69799864e-01f, 4.96303886e-02f, 3.20707820e-02f, 5.19251451e-02f, 2.17826311e-02f, -1.25523796e-03f, -1.74501032e-01f, -7.35085905e-02f, -9.92955714e-02f, 4.17339951e-02f,
  4.84393612e-02f, 1.47406524e-02f, -5.77336773e-02f, -7.79436231e-02f, -7.15297908e-02f, -4.17524576e-02f, -1.30804956e-01f, -1.04405776e-01f, -4.40551452e-02f, -9.09589306e-02f,
  -8.66375789e-02f, -2.89089996e-02f, -4.34484296e-02f, -5.69349863e-02f, 5.69801293e-02f, 6.95150928e-04f, 4.74535599e-02f, 2.85322554e-02f, 4.00463454e-02f, 6.82156533e-02f,
  -1.88635632e-01f, 2.92282067e-02f, -1.59415543e-01f, -3.43946926e-02f, -2.05639273e-01f, 1.05339527e-01f, -8.32800101e-03f, -1.11652710e-01f, -2.19382003e-01f, -2.36779004e-02f,
  -2.94215549e-02f, -1.50132999e-01f, -1.61996827e-01f, -8.05699080e-03f, 5.03080245e-03f, -4.54757735e-03f, -1.82755873e-01f, -1.97286114e-01f, -1.43097058e-01f, 5.76684251e-02f,
  2.75335871e-02f, -1.21307373e-01f, -1.99645206e-01f, -8.20399597e-02f, -1.11088313e-01f, -1.31558105e-01f, -9.93458852e-02f, -8.13739970e-02f, 1.18377917e-02f, -9.57110152e-02f,
  -2.87820399e-01f, 1.89296111e-01f, -3.00338298e-01f, 1.48630172e-01f, 3.32601845e-01f, 1.61157012e-01f, 1.61135584e-01f, -1.97291542e-02f, -8.49361643e-02f, 9.93516520e-02f,
  6.48743585e-02f, -9.45441704e-03f, 8.51834640e-02f, 5.83790019e-02f, -1.21635877e-01f, 1.36155963e-01f, 1.10194735e-01f, -4.31893244e-02f, -2.13667139e-01f, 9.61951315e-02f,
  1.68101937e-01f, 5.34310192e-02f, -2.76687324e-01f, -9.01180655e-02f, 2.19626278e-01f, 1.63986519e-01f, -7.45878890e-02f, 1.29235610e-01f, 1.77096263e-01f, 1.89628169e-01f,
  -3.48420650e-01f, -1.93847805e-01f, 1.12018786e-01f, 2.44008332e-01f, 6.98705688e-02f, -1.46561235e-01f, -1.80235617e-02f, -1.67416379e-01f, -4.64645363e-02f, -1.20235823e-01f,
  1.48687169e-01f, -1.50414616e-01f, 7.47205764e-02f, 1.01215132e-01f, -5.21061458e-02f, -3.49519216e-02f, 6.84959218e-02f, -9.33875218e-02f, -1.55952975e-01f, -3.01339626e-02f,
  4.88815874e-01f, 2.52844065e-01f, -4.06514518e-02f, -7.33999908e-02f, -2.68565081e-02f, -9.59102064e-03f, -1.27899736e-01f, -2.27452889e-01f, -3.28885645e-01f, -2.38896966e-01f,
  6.63787201e-02f, 1.46575168e-01f, 3.89769860e-02f, 3.14703137e-02f, -1.32228518e-02f, 4.21641432e-02f, 3.24024260e-02f, -1.84323490e-02f, 4.85950783e-02f, 7.32420385e-02f,
  -6.59981882e-03f, -2.22875640e-01f, -7.80633390e-02f, -9.48722214e-02f, -1.00595750e-01f, -2.42802706e-02f, 4.13034745e-02f, -5.17000109e-02f, -9.48801935e-02f, -9.87514853e-02f,
  -5.06539345e-02f, -6.36610314e-02f, -1.44237921e-01f, 3.43141370e-02f, -2.19218489e-02f, -1.02279089e-01f, 1.22079663e-02f, -1.64324883e-03f, 3.34420279e-02f, 1.29417032e-01f,
  -9.05968696e-02f, 9.40498412e-02f, -5.61147258e-02f, 7.87159428e-02f, -1.46792561e-01f, 1.52037768e-02f, -4.64801192e-02f, -1.29840285e-01f, -2.12329969e-01f, -1.31642029e-01f,
  -1.65368915e-01f, -2.12890401e-01f, 6.86887056e-02f, 4.88399640e-02f, -1.42921321e-02f, -5.74213415e-02f, 6.93507344e-02f, -2.65931375e-02f, -1.10486940e-01f, -4.36239466e-02f,
  -1.48102865e-02f, 5.47314174e-02f, -1.90726889e-03f, -1.11975200e-01f, 2.27593891e-02f, 1.04900420e-01f, -9.23351422e-02f, -4.33628745e-02f, -1.78230375e-01f, -1.04953818e-01f,
  2.59846337e-02f, 1.48908228e-01f, 8.12766403e-02f, 2.02885911e-01f, -5.29387500e-03f, -1.83876812e-01f, -1.17325475e-02f, 1.59456104e-01f, 1.68686718e-01f, 1.69751450e-01f,
  -1.50066584e-01f, -7.44073316e-02f, -1.26521196e-02f, -1.57819182e-01f, -1.61105826e-01f, 1.10809915e-02f, -7.67392740e-02f, -9.10501033e-02f, -2.88049519e-01f, -2.43719131e-01f,
  -5.99385574e-02f, 4.95931655e-02f, -7.93464780e-02f, -1.91104431e-02f, 2.74785515e-02f, 4.20655906e-02f, 9.14911553e-02f, -5.10402303e-03f, -1.57894805e-01f, -4.60034609e-03f,
  1.23162717e-02f, -1.20318662e-02f, -7.50614330e-02f, -1.15195528e-01f, -7.36288950e-02f, -5.80113567e-03f, 7.23976567e-02f, 5.65018393e-02f, -2.22587623e-02f, 3.67180370e-02f,
  -1.93089291e-01f, -1.14960186e-01f, -1.37525514e-01f, 8.09626207e-02f, -6.68436335e-03f, -1.00785613e-01f, -7.09999055e-02f, -1.04558453e-01f, -7.16141760e-02f, -4.29021902e-02f,
  -1.95913211e-01f, -2.16622442e-01f, -1.66735813e-01f, -2.46604942e-02f, -1.92777783e-01f, -4.80218977e-02f, -9.59044993e-02f, -1.61523893e-01f, -1.76501408e-01f, 2.71846682e-01f,
  5.68604581e-02f, -7.88316652e-02f, 1.32876912e-05f, 5.70176281e-02f, 1.35213314e-02f, -7.37273321e-02f, 7.81653624e-04f, 4.59616557e-02f, -2.40912773e-02f, 7.08922520e-02f,
  -3.38388756e-02f, -6.93276227e-02f, 5.92957251e-02f, 4.69570234e-02f, -4.57001338e-03f, 2.50326712e-02f, -2.12512854e-02f, -5.39389886e-02f, -1.02155535e-02f, 2.58754361e-02f,
  -6.35547563e-02f, 2.76682433e-02f, 7.67068490e-02f, -1.65470280e-02f, 1.36140613e-02f, 5.36909290e-02f, 2.43084468e-02f, 1.32659562e-02f, 1.19683351e-02f, 8.38463679e-02f,
  2.85999656e-01f, -7.38862753e-02f, 1.14833914e-01f, -1.05306216e-01f, 1.05430089e-01f, -6.02956675e-03f, -1.08465672e-01f, -3.31092775e-02f, -1.02189176e-01f, 1.11714728e-01f,
  -7.41637871e-02f, -6.27691671e-02f, 5.56090921e-02f, 1.57818664e-02f, -9.84742939e-02f, 8.31621215e-02f, -8.76730755e-02f, -2.71500014e-02f, -1.19230989e-02f, 1.35227770e-01f,
  7.45293871e-02f, 9.74155068e-02f, 1.71448439e-01f, 1.06179863e-01f, 2.46192068e-02f, 1.22835664e-02f, 1.44381329e-01f, 8.94111022e-02f, 6.89100176e-02f, 4.16495055e-01f,
  -7.36397624e-01f, -2.36111149e-01f, 6.64871186e-02f, 6.76575005e-02f, 2.58116961e-01f, 1.28250077e-01f, 3.16296995e-01f, -3.68210226e-02f, -6.86988756e-02f, -7.41409361e-02f,
  -9.81588289e-02f, -1.09059013e-01f, -3.27877440e-02f, 5.35726547e-02f, 4.10932153e-02f, 2.35802382e-01f, 1.75483033e-01f, 1.01608872e-01f, 2.89021432e-01f, 2.59634167e-01f,
  9.72741544e-02f, 1.32469893e-01f, -1.57798663e-01f, -2.08631642e-02f, -4.46446054e-02f, 1.47836283e-01f, 1.15324572e-01f, 6.27605394e-02f, -9.04560015e-02f, -6.06541475e-03f,
  2.52632737e-01f, -2.38595456e-01f, -5.55433985e-03f, -2.62345850e-01f, -1.64892599e-01f, -1.56037822e-01f, -9.46506411e-02f, -1.49466783e-01f, -1.30356774e-01f, 5.44172153e-02f,
  -4.32220250e-02f, -1.31881267e-01f, -7.16942251e-02f, -1.77918244e-02f, 9.24741328e-02f, 9.87340603e-03f, -1.72507659e-01f, 8.77956524e-02f, 6.77836463e-02f, -2.65022274e-02f,
  2.95504257e-02f, -1.55186519e-01f, 3.55516523e-02f, 1.06765687e-01f, -3.75663005e-02f, -5.99091500e-03f, 3.37726995e-02f, -3.15808021e-02f, -1.51380122e-01f, -6.77829534e-02f,
  8.09906647e-02f, 9.14768651e-02f, 1.61694754e-02f, 4.27534245e-02f, -2.04312336e-02f, 9.28810537e-02f, 7.39556700e-02f, 9.36213136e-02f, 1.36606216e-01f, -4.68506180e-02f,
  1.35783516e-02f, 2.78308149e-02f, -8.05280432e-02f, 7.33809769e-02f, -1.08184502e-01f, -9.48954150e-02f, -7.03132572e-03f, -9.03162137e-02f, -1.23698436e-01f, -1.87174469e-01f,
  -1.07165746e-01f, 6.75212368e-02f, 7.28334561e-02f, -2.03553587e-02f, -2.80479118e-02f, -8.38085487e-02f, 7.10969837e-03f, -1.21076718e-01f, 2.97378339e-02f, 8.19771737e-02f,
  2.12431192e-01f, -9.89611596e-02f, 1.33123389e-02f, -2.60292515e-02f, -5.55721521e-02f, -1.51354849e-01f, -1.16979286e-01f, -3.56027372e-02f, -1.22110089e-02f, 1.05641574e-01f,
  -1.28154419e-02f, 9.06191990e-02f, 1.25194956e-02f, 1.36209745e-03f, 1.39719859e-01f, -5.48393838e-02f, -2.05024049e-01f, 1.57945290e-01f, 1.99430902e-03f, 1.12420566e-01f,
  -7.86937494e-03f, 7.33807907e-02f, 1.65849328e-01f, 2.01891258e-01f, 6.99865147e-02f, 1.12850234e-01f, 2.31412590e-01f, 1.51871860e-01f, 9.87918079e-02f, 1.10952646e-01f,
  -4.24193501e-01f, 3.60929549e-01f, 1.27322108e-01f, -2.37600192e-01f, 1.22650556e-01f, 2.48199657e-01f, 3.61592472e-01f, -6.09120093e-02f, -1.28229847e-02f, 1.52562290e-01f,
  1.64235443e-01f, 1.60839986e-02f, -1.27001166e-01f, -1.24068456e-02f, 6.99764788e-02f, 1.64494082e-01f, 1.73017234e-01f, -3.57590779e-03f, -2.66074687e-01f, -1.83661759e-01f,
  -1.52837671e-03f, -1.38158947e-01f, -1.60635978e-01f, -1.17312223e-01f, -5.05562834e-02f, -1.14776239e-01f, -8.89219046e-02f, 7.47961272e-03f, 1.12257876e-01f, 5.65196835e-02f,
  -1.06074683e-01f, 3.27772200e-02f, -2.13438377e-01f, -1.80403560e-01f, 1.14326037e-01f, -8.66158977e-02f, -8.01361576e-02f, -1.64581221e-02f, -9.44169164e-02f, -7.48825148e-02f,
  -1.04376063e-01f, -3.30494307e-02f, 4.77709286e-02f, -4.58962247e-02f, -5.64826690e-02f, -3.40579078e-02f, -1.22969694e-01f, -2.79775262e-01f, -1.66278049e-01f, -1.47336259e-01f,
  1.36722207e-01f, -7.27016712e-03f, -4.29231077e-02f, 8.15950856e-02f, 4.48913686e-02f, -1.06375329e-01f, -1.08688079e-01f, -8.22753981e-02f, 1.05229318e-02f, -1.61638990e-01f,
  2.77266707e-02f, 6.07433878e-02f, 9.68275219e-02f, 5.23460284e-02f, 3.86784598e-02f, 7.55763426e-02f, 1.30625460e-02f, -5.52051887e-02f, -2.37470847e-02f, -3.33179608e-02f,
  5.14282659e-02f, 2.70770155e-02f, -1.37084961e-01f, -3.75530384e-02f, 1.88223496e-02f, 1.26139224e-01f, 8.50896016e-02f, -8.19482431e-02f, -5.09677939e-02f, -6.39553042e-03f,
  -9.09060519e-03f, -2.34124307e-02f, -2.34620385e-02f, -7.26333866e-03f, 1.66260615e-01f, 7.53621981e-02f, -1.22568503e-01f, -8.78488272e-02f, -8.99149403e-02f, 5.50229065e-02f,
  -3.36190253e-01f, 2.13447988e-01f, -1.41923055e-01f, 4.44838665e-02f, 1.20242301e-03f, -2.43859682e-02f, 5.28551601e-02f, 9.05809850e-02f, 7.33278021e-02f, 1.01813199e-02f,
  7.19669927e-03f, 3.73112820e-02f, -1.00794546e-01f, -1.29250973e-01f, -1.50917679e-01f, 3.00964769e-02f, 1.01146080e-01f, -3.98268141e-02f, 4.13504988e-02f, -8.15754160e-02f,
  4.59255464e-03f, -1.48629144e-01f, -2.50024527e-01f, 5.73369563e-02f, -2.27303319e-02f, -2.30025917e-01f, -6.72434568e-02f, -2.61973083e-01f, -6.22094944e-02f, -2.28327751e-01f,
  2.34752417e-01f, -2.61914968e-01f, -3.93834621e-01f, 8.85218754e-02f, -2.09625512e-01f, -1.65424347e-01f, -4.30956811e-01f, -6.05560951e-02f, 2.20574792e-02f, -2.81476110e-01f,
  -2.02527970e-01f, 1.38983831e-01f, -3.14056836e-02f, 3.19807325e-03f, -3.71977910e-02f, -2.74078757e-01f, -2.93517679e-01f, -6.36560395e-02f, 1.67351797e-01f, -1.45555148e-03f,
  -3.55912112e-02f, 2.33714189e-02f, 8.26519281e-02f, -1.33610107e-02f, 1.57444905e-02f, 3.55760939e-02f, -1.92687854e-01f, -9.87932235e-02f, -1.26044050e-01f, -3.06485116e-01f,
  -6.90445378e-02f, -1.23195678e-01f, -7.34068900e-02f, 1.95574574e-02f, -6.22808896e-02f, 9.33410134e-03f, -4.92511690e-02f, -1.89047903e-02f, 2.45797858e-02f, 3.22536081e-02f,
  5.68411574e-02f, -9.75881424e-03f, 4.76528294e-02f, -4.07971954e-03f, 5.60295619e-02f, -7.07516521e-02f, -9.42984670e-02f, 1.87315904e-02f, 7.47807920e-02f, 6.95036128e-02f,
  -1.34683281e-01f, 4.51015979e-02f, 7.95548484e-02f, -1.01819478e-01f, 2.01049931e-02f, 2.32978649e-02f, -2.48547401e-02f, 5.89260347e-02f, 3.07186376e-02f, 3.42341959e-02f,
  -1.21285141e-01f, -1.41135380e-01f, 1.08399510e-01f, 5.55705912e-02f, 1.13593042e-02f, 4.28609960e-02f, 6.23432137e-02f, 1.67030290e-01f, 7.76176229e-02f, -2.75041740e-02f,
  -6.54270221e-03f, -1.62010435e-02f, 2.80249286e-02f, -4.94327545e-02f, -3.58108222e-03f, -1.90191492e-02f, -7.44829997e-02f, 1.09003969e-01f, 1.08577132e-01f, -2.86890343e-02f,
  5.35718836e-02f, 2.49962639e-02f, 4.98287845e-03f, 1.30170465e-01f, -1.71454810e-03f, 1.45485559e-02f, -1.72261298e-01f, -6.14384077e-02f, 5.78282699e-02f, -1.59985393e-01f,
  1.96805090e-01f, -3.15774918e-01f, -2.58280407e-03f, -8.20383709e-03f, -5.58525547e-02f, -1.40450075e-01f, -1.72699854e-01f, 9.23556164e-02f, 1.74275599e-02f, -4.53853607e-03f,
  -9.54934359e-02f, 4.59547564e-02f, -9.98172536e-03f, -1.93039715e-01f, 1.68517940e-02f, -8.48445203e-03f, 2.42655142e-03f, 4.19123210e-02f, 2.39772126e-02f, 3.70487501e-03f,
  -1.18155465e-01f, 5.86311594e-02f, 1.04390949e-01f, 6.55391812e-02f, 1.33076072e-01f, 2.37561986e-02f, -4.18691710e-02f, 2.31427196e-02f, 1.25709191e-01f, 1.43923149e-01f,
  2.74896890e-01f, 4.04584706e-01f, 2.65934438e-01f, 7.09429607e-02f, -1.15761273e-01f, 9.24847201e-02f, 2.82953173e-01f, 3.12275052e-01f, 3.54567729e-02f, 9.27307904e-02f,
  6.45390153e-02f, -1.06335700e-01f, 8.01560804e-02f, 4.64026742e-02f, 2.83660620e-01f, 3.43132108e-01f, 1.87477186e-01f, 1.79941177e-01f, 5.97570501e-02f, -4.18104380e-02f,
  4.55538668e-02f, -4.38687876e-02f, 7.86662623e-02f, 1.26164034e-01f, 1.72371373e-01f, 3.84412259e-02f, 1.17281228e-01f, 1.32255405e-01f, 1.07051685e-01f, 2.43870944e-01f,
  1.13199122e-01f, 1.52910501e-01f, -1.07808173e-01f, 4.32022139e-02f, -7.84242898e-02f, -8.96778926e-02f, -1.02266587e-01f, 2.23604012e-02f, -1.12967655e-01f, -1.36791151e-02f,
  -9.04203951e-02f, -1.30853597e-02f, -7.03342929e-02f, -6.17670119e-02f, -1.25147805e-01f, -6.21353909e-02f, -5.72590902e-02f, 1.40738413e-01f, 1.45473644e-01f, 7.39965364e-02f,
  -8.78551379e-02f, -4.05626670e-02f, -1.41242323e-02f, -1.05129510e-01f, 3.48337218e-02f, -1.27844393e-01f, -1.13179773e-01f, 1.48220602e-02f, -1.26624340e-02f, -4.29718755e-02f,
  -1.14470467e-01f, 4.90201451e-02f, -7.64144808e-02f, -1.84654087e-01f, -1.16145544e-01f, -1.73777118e-01f, -1.34362936e-01f, 8.64189267e-02f, 6.92603597e-03f, -1.08593643e-01f,
  -1.73148707e-01f, -1.28624518e-03f, -4.22847867e-02f, -1.68160155e-01f, 4.35998663e-02f, -3.64735513e-03f, 5.05810454e-02f, -6.59701973e-02f, -1.56085109e-02f, -4.81365994e-02f,
  -1.29049882e-01f, 5.67602329e-02f, 6.77543581e-02f, -3.94049939e-03f, -6.91741146e-03f, -4.75631356e-02f, -7.62578249e-02f, -8.08028653e-02f, -2.43479498e-02f, 2.02512834e-02f,
  -8.46125856e-02f, -2.54898280e-01f, 8.06690976e-02f, 1.66738167e-01f, 1.08387828e-01f, -2.98057366e-02f, 1.18310712e-01f, 1.88210998e-02f, -5.44043444e-02f, 5.19845001e-02f,
  6.41212687e-02f, 3.87263559e-02f, 2.18825489e-02f, -6.53269887e-02f, -2.25026846e-01f, -1.74182415e-01f, -2.93107294e-02f, 6.78712353e-02f, 1.30737275e-01f, -2.48158467e-03f,
  -9.05570947e-03f, -2.50219740e-02f, -7.01947436e-02f, -1.20533533e-01f, -8.38817935e-03f, -2.20064938e-01f, -9.02879760e-02f, -3.05900276e-02f, -1.17946923e-01f, -1.03925250e-01f,
  -2.07076684e-01f, 3.23238559e-02f, -2.33031474e-02f, 7.65767600e-03f, 7.91033730e-02f, -7.90733472e-02f, -3.01347405e-01f, -2.78090984e-01f, -3.52716707e-02f, -1.19829260e-01f,
  1.51152117e-02f, -1.95815191e-02f, 2.82971263e-02f, 1.78159047e-02f, -1.46309305e-02f, -5.06961830e-02f, 1.67276740e-01f, 1.83858052e-01f, -5.03070606e-03f, -1.29318774e-01f,
  1.61181808e-01f, 4.01456375e-03f, -3.34410444e-02f, 6.16616495e-02f, 1.91324413e-01f, -5.56351878e-02f, 8.87814015e-02f, 1.71723723e-01f, 1.37539998e-01f, 3.66218626e-01f,
  3.01179532e-02f, 1.01653917e-03f, -1.29606590e-01f, 7.85230249e-02f, 1.62789330e-01f, -1.24184163e-02f, 3.54902484e-02f, -5.82349822e-02f, 4.71946262e-02f, -1.10474437e-01f,
  4.64759842e-02f, 1.67365447e-01f, 8.72147307e-02f, -3.25425901e-02f, 2.16270727e-03f, -8.04027990e-02f, 3.92233804e-02f, -1.88742410e-02f, -2.23456584e-02f, -1.86742749e-02f,
  1.27649873e-01f, 2.83284020e-02f, -1.63167998e-01f, -1.41949922e-01f, -3.71799991e-02f, 1.67801991e-01f, -7.64303133e-02f, -7.98925236e-02f, -1.96116403e-01f, -2.26921905e-02f,
  -3.28254998e-02f, -6.68004379e-02f, 9.35893357e-02f, 3.49456146e-02f, -6.08085729e-02f, 9.09481943e-02f, -2.84163263e-02f, 1.68373156e-02f, -2.65977792e-02f, 4.83542010e-02f,
  -5.36709977e-03f, 1.34053556e-02f, 1.29216254e-01f, -1.28970087e-01f, -6.03495426e-02f, 3.74641120e-02f, 1.16470993e-01f, -5.51172085e-02f, -1.17519744e-01f, 9.63846128e-03f,
  3.41425799e-02f, 9.27896649e-02f, 2.30656583e-02f, -4.68899533e-02f, 3.46570723e-02f, -4.64756936e-02f, 1.95089933e-02f, 7.54141575e-03f, 9.94308144e-02f, 1.15790404e-01f,
  -2.89478265e-02f, -5.19357510e-02f, 6.14486709e-02f, -4.06731255e-02f, 5.92708550e-02f, -5.75631373e-02f, 7.28960708e-03f, -3.40047944e-03f, -5.01879342e-02f, -1.38829574e-01f,
  -5.38680749e-03f, 2.02371497e-02f, 1.01514049e-02f, -5.35737462e-02f, -1.78988967e-02f, -5.83689287e-02f, 4.20124978e-02f, 6.95149973e-02f, -8.40136260e-02f, -6.36513159e-02f,
  -8.06710422e-02f, -2.00323954e-01f, -1.00793265e-01f, -1.50740325e-01f, 1.93421468e-02f, -9.10536721e-02f, -2.18414180e-02f, -3.42057161e-02f, -1.28604114e-01f, -2.66798466e-01f,
  5.22738576e-01f, 1.25988916e-01f, 1.27381310e-01f, 1.49182484e-01f, -1.95451647e-01f, -5.04770316e-02f, -5.69689553e-03f, 1.73819229e-01f, 1.86085477e-01f, 5.74085228e-02f,
  4.29046266e-02f, 1.78642347e-01f, 1.64086699e-01f, 2.37822160e-01f, 2.37765238e-01f, 1.17768675e-01f, 1.01356775e-01f, 2.11189017e-01f, 3.16471189e-01f, 1.37779981e-01f,
  1.43011212e-01f, 1.11474089e-01f, 1.35101125e-01f, 1.99004248e-01f, 1.59691229e-01f, 5.49350157e-02f, 5.62556796e-02f, 4.02970985e-02f, 6.68120235e-02f, 1.56979755e-01f,
  -1.90797254e-01f, 1.59420297e-01f, 1.14929266e-01f, -1.04721807e-01f, -7.15278760e-02f, 4.82336171e-02f, 1.06503390e-01f, 5.60419224e-02f, -1.25828534e-01f, -4.95090224e-02f,
  -1.85693264e-01f, -4.58991304e-02f, -2.39767395e-02f, 3.31267901e-02f, -3.59846577e-02f, -5.82811609e-02f, 4.57445532e-02f, 1.58799827e-01f, -1.96786914e-02f, 5.99903651e-02f,
  7.73846125e-03f, -1.41671523e-01f, -1.10463418e-01f, -9.67307761e-03f, 6.60870373e-02f, -1.89002931e-01f, 4.81527746e-02f, -3.67955938e-02f, 9.02471468e-02f, 1.42846823e-01f,
  1.50151417e-01f, -1.04427643e-01f, -4.53545600e-02f, 1.16991818e-01f, 2.04393893e-01f, 1.03418723e-01f, 5.68179935e-02f, 3.56503464e-02f, -3.89420986e-02f, 4.21779566e-02f,
  9.44157243e-02f, 6.82408586e-02f, 4.79635783e-02f, 1.34131029e-01f, 4.62155677e-02f, -1.02439404e-01f, -1.05774127e-01f, 9.49300360e-03f, -1.43130392e-01f, -1.76913291e-02f,
  -5.01718484e-02f, -3.50921825e-02f, -8.31311643e-02f, 9.25176293e-02f, 1.52858108e-01f, 1.07802702e-02f, 1.05514184e-01f, -7.68783987e-02f, -9.11974162e-02f, 2.53775809e-02f,
  -3.31409752e-01f, -9.12403911e-02f, 2.64997840e-01f, 1.02782175e-01f, -5.86017668e-02f, -4.03573923e-02f, -1.04411840e-01f, -1.20167702e-01f, -1.89849779e-01f, -4.08191048e-02f,
  -7.32095242e-02f, 9.31699015e-03f, 6.29022419e-02f, -1.08735651e-01f, -2.21272446e-02f, -1.13239408e-01f, -1.01900019e-01f, -8.99855196e-02f, -1.53302312e-01f, -2.16703072e-01f,
  -1.81497578e-02f, -5.14795370e-02f, -6.67233914e-02f, -4.34200130e-02f, -1.53263673e-01f, -1.51455879e-01f, -1.35609418e-01f, -1.54421911e-01f, -9.97119304e-03f, 2.42491122e-02f,
  7.15334177e-01f, -7.39352107e-02f, -3.19566429e-01f, 2.18287587e-01f, -1.58426523e-01f, -5.57303652e-02f, -5.39164692e-02f, 5.03210016e-02f, 1.97307333e-01f, -1.90948382e-01f,
  -2.74314642e-01f, -3.65295187e-02f, -7.18236938e-02f, -4.92355786e-02f, -8.41671750e-02f, -3.05823609e-02f, -2.24259477e-02f, -8.80113337e-03f, 6.00237586e-02f, 3.37595306e-02f,
  5.79153299e-02f, 8.77829939e-02f, 2.15979561e-01f, 2.40072906e-02f, -3.54182236e-02f, 5.27886041e-02f, -1.31069496e-01f, -9.24640149e-02f, -5.04414812e-02f, -1.59141764e-01f,
  -2.85693258e-01f, -1.64427370e-01f, -7.51322508e-02f, 6.82154670e-02f, -7.88870547e-03f, 1.28581330e-01f, -6.19243905e-02f, -8.54238272e-02f, -9.23946053e-02f, -1.19111180e-01f,
  -9.87700820e-02f, -8.37880597e-02f, -1.49212524e-01f, -6.99779019e-02f, -8.08748826e-02f, -7.65435491e-03f, -1.09188586e-01f, -1.65985711e-02f, 5.76440655e-02f, -1.15384571e-02f,
  -6.59337640e-02f, -1.56690896e-01f, -1.65174842e-01f, -1.80419624e-01f, -2.13288590e-01f, -1.11664541e-01f, -2.31501654e-01f, -8.44248608e-02f, -1.39471993e-01f, -3.99275776e-03f,
  5.59908301e-02f, -9.91492998e-03f, 1.17546223e-01f, -4.77834307e-02f, -1.59161687e-02f, 9.10856854e-03f, -6.46468177e-02f, -4.08347212e-02f, -1.09888621e-01f, 1.66646601e-03f,
  -6.09138869e-02f, -4.95459475e-02f, -3.08239851e-02f, -5.89900091e-03f, -4.13347594e-02f, -8.48090947e-02f, 1.90807250e-03f, 1.16072409e-02f, -9.85335931e-03f, 7.17147663e-02f,
  4.16766070e-02f, -2.09758300e-02f, 1.67843699e-02f, 4.95770462e-02f, -1.60581328e-03f, 7.97500759e-02f, 5.48307039e-02f, -1.03284039e-01f, -2.50904448e-02f, 5.07951938e-02f,
  1.67835951e-01f, -1.02180429e-01f, -8.12919661e-02f, -1.66767433e-01f, 1.39349967e-01f, 1.11760415e-01f, 3.46871577e-02f, -6.74757510e-02f, -9.26460251e-02f, 1.91828962e-02f,
  -1.32098258e-01f, 6.46734284e-03f, -1.55972496e-01f, 5.08590154e-02f, -4.22379524e-02f, 3.19037475e-02f, 6.83632493e-02f, 6.81420672e-04f, -4.66807522e-02f, 1.21380895e-01f,
  7.77558163e-02f, 5.83757684e-02f, 2.04548433e-01f, 3.86539027e-02f, -2.65035462e-02f, 5.84892444e-02f, 1.74399447e-02f, -1.80395134e-02f, 1.17740281e-01f, 3.10707033e-01f,
  1.69599563e-01f, -2.23907386e-03f, 2.94986874e-01f, 1.75363660e-01f, 2.35105187e-01f, 3.65379035e-01f, 3.58474225e-01f, 2.93592494e-02f, -6.45764023e-02f, 4.65688892e-02f,
  1.49926826e-01f, 2.93392502e-02f, 4.07846458e-02f, -1.67366579e-01f, 6.91310093e-02f, 3.04788612e-02f, -9.62797552e-02f, 1.52017120e-02f, -5.10708010e-03f, 1.22733511e-01f,
  -5.24222627e-02f, -4.65291217e-02f, 2.54576784e-02f, -1.50240019e-01f, -9.62920114e-02f, -6.91980915e-03f, 3.23728621e-02f, 1.27643282e-02f, -1.58488322e-02f, -1.49075836e-01f,
  3.44512090e-02f, 2.13634409e-02f, -1.12779580e-01f, -1.62194327e-01f, 2.47239098e-02f, -8.22735354e-02f, -1.77786732e-03f, -1.15811042e-01f, -8.03087130e-02f, 1.04223629e-02f,
  1.82103496e-02f, -2.18308978e-02f, -2.91666575e-02f, -5.89961298e-02f, 4.60654385e-02f, 3.66219766e-02f, -1.72566012e-01f, 4.44997288e-03f, 5.56124412e-02f, 1.60216037e-02f,
  -1.90990809e-02f, 7.32329860e-02f, 2.18043685e-01f, 1.81180283e-01f, 1.17110610e-01f, 6.44033253e-02f, 1.27548620e-01f, 1.54277133e-02f, 1.97534099e-01f, 4.43030931e-02f,
  1.04236506e-01f, 2.53460377e-01f, 1.28335163e-01f, -3.62740606e-02f, 7.98952505e-02f, 2.57562567e-02f, 4.52795625e-02f, -4.43091765e-02f, 3.33013125e-02f, -5.80709912e-02f,
  2.30529178e-02f, 7.23441020e-02f, 6.85064644e-02f, 1.11273579e-01f, 1.51948109e-01f, 5.31297624e-02f, 3.77360694e-02f, 1.27273485e-01f, 4.58764471e-02f, 3.04036331e-03f,
  1.67386845e-01f, 2.35263798e-02f, -9.26022977e-02f, -2.93471720e-02f, 6.97138309e-02f, 5.83055690e-02f, 4.14954722e-02f, 3.52714770e-02f, 9.54875839e-04f, 9.77959111e-02f,
  2.98397671e-02f, 2.66272485e-01f, -1.88198432e-01f, -7.69893453e-02f, -2.96017770e-02f, -7.44172558e-02f, 7.36337504e-04f, -1.59092858e-01f, -1.45337224e-01f, -1.58038095e-01f,
  1.26417186e-02f, -1.12157285e-01f, 1.11368097e-01f, -4.92665805e-02f, -2.61036679e-02f, -1.22776724e-01f, -1.15146279e-01f, 1.48962289e-01f, -4.34057675e-02f, -5.95988296e-02f,
  -8.53908062e-02f, 1.17144268e-02f, 8.19921270e-02f, 7.23157153e-02f, 8.37336853e-02f, -2.90181115e-02f, -5.38503006e-02f, -7.77708367e-02f, -8.34622700e-03f, -9.36044827e-02f,
  -2.54165918e-01f, -2.01501206e-01f, 6.36959523e-02f, 9.11156908e-02f, 2.73816854e-01f, -3.09306029e-02f, -4.05639917e-01f, -3.64172101e-01f, 3.98596153e-02f, -3.20960581e-03f,
  1.17511287e-01f, 1.52292594e-01f, 2.03302577e-01f, 1.48116648e-01f, -1.35834292e-01f, -8.15172568e-02f, 5.91128767e-02f, -6.82616048e-03f, 3.09636188e-03f, -5.79948872e-02f,
  -2.09928527e-02f, -2.64854375e-02f, -7.29295537e-02f, -5.64980730e-02f, 2.03811307e-03f, -3.88997942e-02f, 6.75978884e-02f, 1.31328106e-01f, 6.59362674e-02f, 1.43567428e-01f,
  4.20838259e-02f, -9.00965258e-02f, 7.93252513e-02f, 5.44958301e-02f, 1.15374759e-01f, -1.24911726e-01f, -1.54246733e-01f, 3.57813314e-02f, 7.39088356e-02f, -6.00418635e-02f,
  7.98632298e-03f, -1.57872528e-01f, 1.43181533e-01f, -5.90074770e-02f, 6.87751845e-02f, -1.64184898e-01f, 4.93051894e-02f, -8.10433924e-02f, 3.27625312e-02f, 1.28354412e-03f,
  1.26333639e-01f, 1.90237030e-01f, -1.32849449e-02f, -1.79973617e-01f, -1.65032849e-01f, 9.09095109e-02f, -1.76973790e-01f, -4.92051132e-02f, -1.44018561e-01f, -3.60469848e-01f,
  1.94017235e-02f, 1.33483186e-01f, 3.24238986e-02f, -3.53703126e-02f, -4.78682928e-02f, 3.82056348e-02f, 1.60581827e-01f, 2.78551448e-02f, -2.79189292e-02f, 9.77830030e-03f,
  2.55307276e-02f, -4.73214909e-02f, -2.19641700e-02f, 3.93883474e-02f, 6.62162527e-02f, 1.30040228e-01f, -8.95347819e-02f, -6.97371289e-02f, -3.68780419e-02f, -3.57824005e-02f,
  -4.10599932e-02f, 3.34451161e-02f, 1.20933682e-01f, -9.13416073e-02f, -1.26900673e-01f, -6.53340435e-03f, -5.84109984e-02f, -1.21300273e-01f, -1.32261319e-02f, 7.67348930e-02f,
  7.09221438e-02f, 1.86826155e-01f, -2.69457866e-02f, 5.45931831e-02f, -2.20006108e-02f, -6.08632923e-04f, -4.65844125e-02f, 1.97869260e-03f, 2.44007651e-02f, -1.63733006e-01f,
  -1.21337004e-01f, -1.45284683e-01f, -1.66238006e-02f, 2.25110352e-02f, -1.37917921e-01f, -1.62347704e-01f, -6.28167689e-02f, 6.88308328e-02f, -2.16666749e-03f, 5.73602021e-02f,
  -2.15578482e-01f, -1.78036734e-01f, -2.25504994e-01f, -2.53760725e-01f, -7.45783970e-02f, -1.00255653e-01f, -1.40068278e-01f, -1.11486644e-01f, -2.60937452e-01f, -4.24980730e-01f,
  4.71050829e-01f, -1.23267971e-01f, 1.61157787e-01f, 2.27639645e-01f, 1.74702704e-01f, 2.13014305e-01f, 6.71999678e-02f, 1.61044318e-02f, 1.24616846e-01f, 3.88661548e-02f,
  2.40681127e-01f, 1.95247054e-01f, 2.58955121e-01f, 7.42408633e-02f, 1.15745321e-01f, -7.09939077e-02f, -1.38048068e-01f, 7.89578035e-02f, 1.59333676e-01f, 2.18991302e-02f,
  -3.44285332e-02f, 1.20896557e-02f, 9.52313468e-03f, 4.14038375e-02f, -2.89009251e-02f, 1.42254621e-01f, -1.39055178e-01f, -1.38962016e-01f, -4.79695797e-02f, -1.71462193e-01f,
  -1.66153703e-02f, -6.01044446e-02f, 3.19843143e-02f, -1.07610404e-01f, -1.65977687e-01f, -1.44010475e-02f, 6.57120794e-02f, -4.71994095e-02f, -1.34783298e-01f, -1.88325718e-01f,
  -1.82347056e-02f, -7.86246210e-02f, -3.93029861e-02f, -1.26585990e-01f, -3.55037339e-02f, -1.42609760e-01f, -6.02252148e-02f, 8.93019140e-02f, -2.49595325e-02f, -4.36821841e-02f,
  -1.32096723e-01f, 9.79708508e-02f, -1.55382892e-02f, -4.83486183e-05f, 1.65569946e-01f, 1.14405692e-01f, 3.85303795e-02f, 2.48351991e-02f, 8.41720998e-02f, -5.62281571e-02f,
  2.01976568e-01f, 1.28520399e-01f, 1.46469817e-01f, 2.63772219e-01f, 1.68003306e-01f, 1.02228664e-01f, 5.82672060e-02f, 5.04392534e-02f, 1.35951594e-01f, 5.14511764e-02f,
  -1.23385355e-01f, 1.03590377e-01f, 2.93794535e-02f, 2.43815854e-02f, 1.44712642e-01f, 2.72253715e-02f, -2.11186856e-02f, -8.52931514e-02f, -6.39893040e-02f, -6.88613355e-02f,
  -3.05464882e-02f, -1.52794048e-01f, -6.83128536e-02f, -1.70689777e-01f, -6.66848719e-02f, -3.37568782e-02f, 7.02300891e-02f, 3.91882882e-02f, -5.06529063e-02f, -6.58158436e-02f,
  -1.00028388e-01f, 3.09274018e-01f, 1.18191585e-01f, -1.32200599e-01f, -1.18317612e-01f, -1.65972114e-01f, 1.79844573e-01f, -3.43937241e-02f, -2.00605959e-01f, -1.22808382e-01f,
  -8.95030331e-03f, 2.56929230e-02f, -6.42893687e-02f, -7.29559595e-03f, 4.62586470e-02f, 3.00098602e-02f, 1.80752464e-02f, 3.94419730e-02f, 5.10157309e-02f, -1.34693995e-01f,
  -2.20735818e-02f, 5.72731569e-02f, 1.01343177e-01f, 1.48124859e-01f, 1.04608722e-01f, 1.67612657e-01f, 5.09980768e-02f, 1.50901265e-02f, 1.19700067e-01f, 1.27921879e-01f,
  5.04475296e-01f, -2.10973844e-01f, -4.58449036e-01f, 9.77750402e-03f, -2.67748237e-01f, -1.21511959e-01f, -1.83427528e-01f, 4.15793881e-02f, 6.57646805e-02f, -1.38517320e-01f,
  6.61671162e-02f, 2.65508652e-01f, 2.56456167e-01f, 1.80556476e-01f, 2.37401351e-01f, -1.41691223e-01f, -6.47314712e-02f, 1.19958967e-02f, 1.52700827e-01f, -4.43603247e-02f,
  -1.39194220e-01f, 3.29116285e-02f, 1.92105323e-01f, 1.97540801e-02f, -2.29302749e-01f, 9.97024179e-02f, -2.45191485e-01f, -1.54256329e-01f, -1.52348325e-01f, -3.51509690e-01f,
  3.25884484e-02f, -2.00168163e-01f, 9.40738097e-02f, 5.85961156e-02f, -1.41872048e-01f, 1.72027022e-01f, -1.48417369e-01f, -2.06211761e-01f, -8.56872201e-02f, -1.59046650e-02f,
  -5.38935922e-02f, 4.65616497e-04f, 7.91765451e-02f, -1.23646401e-01f, 3.02958507e-02f, -9.61269066e-02f, -1.68895006e-01f, -9.24370587e-02f, 1.16349924e-02f, -8.66066217e-02f,
  -2.23008655e-02f, -9.66328979e-02f, 3.37622985e-02f, -1.30893320e-01f, -7.38178892e-03f, 3.34720388e-02f, -1.66268378e-01f, -1.16460085e-01f, -1.53772146e-01f, -1.70377061e-01f,
  7.30739012e-02f, -1.20957993e-01f, -7.45862871e-02f, -9.65323225e-02f, -3.50955613e-02f, -6.86138496e-02f, 4.17080410e-02f, 7.64263123e-02f, 1.67741615e-03f, 7.37557933e-02f,
  6.42091688e-03f, -3.09040248e-02f, 4.41333055e-02f, -1.06183812e-02f, 7.18239397e-02f, 5.14321104e-02f, 6.70270436e-03f, -3.84866782e-02f, -4.84616496e-02f, 5.84841482e-02f,
  1.14263237e-01f, -2.63925735e-02f, -2.02328991e-02f, 8.39536339e-02f, 1.05727073e-02f, -4.16418649e-02f, -1.23849511e-02f, 5.26711941e-02f, 1.35368481e-01f, 8.99540633e-02f,
  3.66001457e-01f, -4.06202162e-03f, 1.77446604e-01f, -2.99351607e-02f, -1.30964098e-02f, 5.48420055e-03f, -1.21699199e-02f, -4.68373112e-02f, 9.91502404e-03f, 5.17625064e-02f,
  -1.04115857e-02f, 9.90270227e-02f, -7.65912458e-02f, -1.11086816e-01f, -3.65216210e-02f, -9.19923335e-02f, -3.08572203e-02f, 1.76959515e-01f, 7.49683157e-02f, 3.51328216e-02f,
  1.25436693e-01f, 1.18603468e-01f, 1.02313139e-01f, 1.00256629e-01f, 4.18683626e-02f, 2.12342232e-01f, 4.04381827e-02f, 1.59903187e-02f, 1.56728968e-01f, 1.03374623e-01f,
  -1.31509528e-01f, -2.89012581e-01f, -3.67036402e-01f, -5.82683869e-02f, -6.91752359e-02f, -5.33402190e-02f, -9.57110524e-02f, 1.32508865e-02f, 8.76511261e-02f, -3.19758952e-01f,
  -1.61922008e-01f, 1.69673458e-01f, -5.40744253e-02f, 1.01312630e-01f, 7.45511129e-02f, -3.56406569e-01f, -3.18614423e-01f, -1.69853747e-01f, 1.18475936e-01f, 1.10023841e-01f,
  -3.59019972e-02f, -1.53917626e-01f, 3.38152312e-02f, 9.08425599e-02f, -2.56302161e-03f, 4.89014164e-02f, -1.42607480e-01f, -2.65448783e-02f, -7.32655525e-02f, -1.90407127e-01f,
  -1.71306685e-01f, 1.21941842e-01f, 1.56956300e-01f, -3.01397424e-02f, -1.03891775e-01f, 1.53397009e-01f, 9.26459059e-02f, -1.11895591e-01f, -1.13823496e-01f, -9.75343212e-02f,
  4.34752703e-02f, 7.29904473e-02f, 1.00597233e-01f, 8.93857256e-02f, 7.08748549e-02f, -1.09409615e-01f, -8.71969163e-02f, 8.52730684e-03f, -1.37829378e-01f, 1.16502575e-03f,
  -1.21108897e-01f, -1.40404387e-03f, -1.02047309e-01f, 7.24722520e-02f, 1.45178422e-01f, -6.80544879e-04f, 2.98605021e-02f, 1.22451305e-01f, 7.13846311e-02f, -8.10178816e-02f,
  -5.42015247e-02f, -2.83057205e-02f, -1.06957190e-01f, 1.15104124e-01f, 6.06260188e-02f, -3.38841863e-02f, -7.32560083e-02f, 9.28378627e-02f, -4.59970459e-02f, 6.29993826e-02f,
  8.15715455e-03f, -2.84020416e-02f, -3.29972617e-02f, -6.88592717e-02f, -1.78673044e-01f, -8.61237049e-02f, -8.09149295e-02f, 6.41308129e-02f, -3.36536355e-02f, 3.50299664e-02f,
  -1.75034732e-03f, 9.28234961e-03f, -1.07846290e-01f, 1.33085579e-01f, 7.41016567e-02f, -6.35479316e-02f, -2.34274212e-02f, -2.53815055e-02f, 1.49302604e-02f, -7.85917565e-02f,
  -5.10860570e-02f, 2.50011683e-02f, 1.35990977e-02f, -3.15983333e-02f, 9.77127105e-02f, -9.55183133e-02f, 1.23794191e-01f, -4.48101722e-02f, 3.13907862e-03f, -2.36201398e-02f,
  6.91568553e-02f, 1.96626857e-02f, -1.47471040e-01f, -3.82362828e-02f, 7.96530992e-02f, 1.36783468e-02f, -1.34936735e-01f, -8.46562791e-04f, 3.50224078e-02f, -1.31599292e-01f,
  -2.47392267e-01f, -5.07814102e-02f, 1.98973715e-02f, -9.01028067e-02f, 8.74516368e-02f, 7.69839287e-02f, -2.72631180e-02f, -6.41026050e-02f, -4.23957109e-02f, -1.06476523e-01f,
  5.03281713e-01f, 1.88467689e-02f, -4.78152961e-01f, 2.95638412e-01f, -1.16288252e-01f, -1.89359158e-01f, -2.75136143e-01f, 6.84848055e-02f, 1.86283380e-01f, -1.84757486e-02f,
  -5.59121231e-03f, 2.63099372e-01f, 6.90319315e-02f, -9.45720524e-02f, -5.63721657e-02f, -2.99829274e-01f, -2.55245328e-01f, -1.30326360e-01f, -1.93784043e-01f, -5.01239821e-02f,
  2.98168398e-02f, 7.04196543e-02f, 1.17766978e-02f, 7.70920068e-02f, -2.51635350e-02f, -1.38281118e-02f, -1.97485179e-01f, -1.42934814e-01f, -1.85061544e-01f, -2.45140687e-01f,
  -3.73058379e-01f, -1.26151398e-01f, -3.15145403e-02f, 4.51526269e-02f, -1.08757809e-01f, 1.10140257e-01f, 1.33035230e-02f, 4.98676412e-02f, 1.76057130e-01f, 7.19459802e-02f,
  5.18323965e-02f, -5.25342003e-02f, 7.55427480e-02f, -5.07907532e-02f, -1.05338149e-01f, 5.42154647e-02f, -7.55447224e-02f, -8.42605233e-02f, 1.27757013e-01f, 3.28520238e-02f,
  -9.96450409e-02f, -1.77689180e-01f, -1.80842742e-01f, -9.67772901e-02f, -1.06295832e-01f, -1.28720954e-01f, -1.46624908e-01f, -1.29212424e-01f, -7.94319361e-02f, -4.37380075e-02f,
  -4.13026474e-02f, 2.82470156e-02f, 1.32229021e-02f, 6.14348194e-03f, 1.54256731e-01f, 3.04563176e-02f, -6.85987528e-03f, 2.24500652e-02f, 5.72430678e-02f, 4.10383828e-02f,
  1.02498494e-01f, -2.26087496e-02f, -5.13145141e-02f, 2.95655224e-02f, -7.97217991e-03f, -1.10446341e-01f, 4.74907085e-02f, -9.08704400e-02f, 5.28430231e-02f, 1.40738949e-01f,
  6.55519068e-02f, -8.03380180e-03f, 7.26106167e-02f, 4.85064015e-02f, -8.11604783e-02f, -7.12467916e-03f, -4.21856903e-02f, 5.36181740e-02f, 2.55743098e-02f, 5.55801252e-03f,
  2.80841112e-01f, -1.22868478e-01f, 5.53609319e-02f, -5.73535748e-02f, -1.00492492e-01f, 1.21668242e-01f, -8.07111897e-03f, 1.45630110e-02f, 5.06478287e-02f, -7.58935958e-02f,
  1.08014476e-02f, 7.09173679e-02f, 5.61309755e-02f, 6.40789196e-02f, 1.85522094e-01f, 7.09850639e-02f, 4.41380776e-02f, -1.73443090e-02f, 9.03483704e-02f, 4.35975231e-02f,
  1.14990883e-01f, 1.08804092e-01f, 3.46509814e-02f, 2.13769432e-02f, 5.71432263e-02f, 1.81580316e-02f, -5.74648455e-02f, -5.77636659e-02f, -9.54447463e-02f, 2.46440083e-01f,
  -5.48525274e-01f, 2.57843822e-01f, 6.00867607e-02f, -3.58525187e-01f, -8.72917324e-02f, -7.16240853e-02f, 2.67384976e-01f, -6.94682170e-03f, -1.34747639e-01f, 2.11109713e-01f,
  1.01071976e-01f, -1.27360135e-01f, -1.74052820e-01f, 3.55465710e-02f, -9.02636498e-02f, 1.05468430e-01f, 1.72460359e-02f, -1.51767462e-01f, -2.35558420e-01f, -1.67508982e-02f,
  1.89616950e-03f, -1.45527899e-01f, -2.12688729e-01f, -1.04949921e-01f, 2.25723684e-02f, 3.39293256e-02f, 5.61164785e-03f, -1.79174334e-01f, 8.08147490e-02f, 2.42878422e-02f,
  -1.14830229e-02f, -2.40941811e-03f, -1.19644115e-02f, -3.08412313e-02f, 8.94571841e-02f, -3.59220281e-02f, -3.35565247e-02f, 1.32995760e-02f, -2.06630901e-01f, -8.99065956e-02f,
  -1.69845536e-01f, 4.15182449e-02f, -1.70268491e-01f, -9.51811224e-02f, -7.03571439e-02f, 5.59024960e-02f, -8.01904798e-02f, -1.02962062e-01f, -1.92620829e-01f, -4.05920371e-02f,
  -1.59353793e-01f, -1.80723697e-01f, -6.55017123e-02f, 3.35929953e-02f, -1.01337716e-01f, -1.55219242e-01f, -3.01520363e-03f, -2.25142501e-02f, -1.61736589e-02f, 1.81625172e-01f,
  7.58702010e-02f, 1.82154194e-01f, -1.49770200e-01f, -1.79244895e-02f, 6.45842031e-02f, -4.90027927e-02f, 5.84074296e-02f, 7.78964087e-02f, 1.30792528e-01f, 3.18851173e-02f,
  -4.57157902e-02f, 1.82852373e-01f, 1.38749644e-01f, -8.16101134e-02f, 6.87969923e-02f, -6.30369484e-02f, 1.28426716e-01f, 1.49462894e-01f, 1.41095591e-03f, -3.36652473e-02f,
  -6.83417022e-02f, 1.18867746e-02f, 3.42265889e-02f, 2.95768790e-02f, -3.56237777e-02f, -1.06581375e-02f, -1.05929628e-01f, -3.85120977e-03f, -1.15251720e-01f, -2.07945898e-01f,
  8.24734494e-02f, -6.33070841e-02f, 1.66891515e-02f, 5.23528270e-02f, 1.11370854e-01f, 3.65665089e-03f, -2.96858214e-02f, 8.86732563e-02f, -5.65295331e-02f, 1.25988707e-01f,
  -6.63711056e-02f, 1.47475570e-01f, 9.45377946e-02f, 2.35125832e-02f, -1.17904708e-01f, -3.50461304e-02f, 2.23364085e-01f, 6.09534495e-02f, -1.22970171e-01f, -5.04188798e-02f,
  6.23249076e-02f, 4.56037112e-02f, -7.65897110e-02f, 7.74368197e-02f, -3.27053480e-02f, -4.30849334e-03f, 7.37510622e-03f, 7.81187490e-02f, -4.82664704e-02f, 2.76968360e-01f,
  1.19603155e-02f, 1.04875758e-01f, 4.03049812e-02f, 1.22030027e-01f, 8.65586028e-02f, 4.17140089e-02f, 9.55461189e-02f, 2.12765858e-01f, 1.47659793e-01f, 2.21323460e-01f,
  5.05715646e-02f, 2.53714144e-01f, 2.37478837e-01f, 1.17653072e-01f, 2.07380027e-01f, 2.56278753e-01f, 1.99600697e-01f, 1.42624140e-01f, 6.81609288e-02f, 4.76287603e-02f,
  5.94362877e-02f, 1.07212268e-01f, 1.35592278e-02f, 1.32040188e-01f, 2.44945940e-02f, 1.67125240e-01f, 2.81922892e-02f, -1.59974722e-03f, 1.38140336e-01f, 3.24978232e-01f,
  2.68456284e-02f, 1.74405370e-02f, 1.57685857e-02f, -7.74743706e-02f, -1.79311663e-01f, -2.23543718e-02f, 4.16304134e-02f, 6.39043003e-02f, -9.04201865e-02f, 9.48305055e-02f,
  -1.05968244e-01f, -7.36318976e-02f, -1.80430096e-02f, -6.61045015e-02f, -6.43284842e-02f, -9.11273733e-02f, -1.09582134e-01f, 1.07969001e-01f, 2.26132482e-01f, 3.45093757e-02f,
  7.50117302e-02f, -2.36340687e-02f, 2.81710381e-04f, -6.78968616e-03f, 3.89934480e-02f, 3.42495963e-02f, -1.15641557e-01f, -9.14870650e-02f, -8.95429682e-03f, 1.16571009e-01f,
  1.50304511e-01f, 9.53665078e-02f, -1.23339392e-01f, -1.03806756e-01f, -8.72906595e-02f, -1.27707303e-01f, 6.95557240e-03f, 1.15271099e-02f, -2.71957088e-02f, -1.53960600e-01f,
  -2.85166744e-02f, 9.14193317e-02f, 2.80431006e-02f, 1.67759247e-02f, 1.88520029e-02f, 9.20345858e-02f, 7.87451416e-02f, -4.30515558e-02f, -2.33732805e-01f, -4.67022657e-02f,
  -1.35694206e-01f, -5.13973348e-02f, -3.41320783e-02f, -1.37969842e-02f, 7.73506463e-02f, 1.54770106e-01f, 1.14268642e-02f, 3.57584506e-02f, -1.48270670e-02f, 2.25442462e-02f,
  2.65036434e-01f, -1.79328501e-01f, -5.63193718e-03f, 1.71746641e-01f, -1.37162432e-01f, -6.77972659e-02f, -1.72076635e-02f, -1.21167963e-02f, -1.59390494e-01f, 4.19782586e-02f,
  4.26890142e-03f, -1.22672036e-01f, -1.19836062e-01f, -7.48572275e-02f, -1.91763431e-01f, -7.07267076e-02f, -2.41818707e-02f, 2.23228931e-01f, 3.52439098e-02f, 5.64210713e-02f,
  -5.77623546e-02f, 2.43253205e-02f, 4.74386290e-02f, -7.39508793e-02f, -2.95212828e-02f, -3.63920964e-02f, -8.62451568e-02f, -1.19564487e-02f, -1.23364881e-01f, -4.22891676e-02f,
  -6.06752336e-01f, -3.90352547e-01f, 6.33762125e-03f, -5.02825499e-01f, -1.25451118e-01f, -2.11084802e-02f, -2.14774802e-01f, -8.16638544e-02f, -3.60383503e-02f, -2.78633356e-01f,
  -2.12310478e-01f, -6.40722290e-02f, -1.37578547e-01f, 2.43850760e-02f, 1.49166822e-01f, -2.38397166e-01f, 4.19643819e-02f, 4.30616215e-02f, 1.49295300e-01f, 6.27029091e-02f,
  -7.74101028e-03f, -2.83268899e-01f, 2.13663969e-02f, 1.25659466e-01f, -1.43613219e-01f, -5.75600006e-02f, -6.04867972e-02f, -2.02821614e-03f, 1.23623475e-01f, -2.86216766e-01f,
  -2.85600454e-01f, -2.37307727e-01f, 1.19597629e-01f, -2.46546348e-03f, -1.43610910e-01f, -4.06993106e-02f, -5.90761043e-02f, -1.24144860e-01f, 3.28728333e-02f, 7.23553821e-03f,
  -8.19769576e-02f, -1.16113313e-02f, -1.11076079e-01f, -4.77498658e-02f, -7.69206509e-02f, -6.16332479e-02f, 7.29938075e-02f, 8.74142721e-02f, 7.96894655e-02f, 1.07607096e-01f,
  -6.78059319e-03f, -2.04801653e-02f, 1.44220769e-01f, 2.31543601e-01f, 1.09658249e-01f, 2.94938982e-02f, 1.56836689e-01f, 1.16759077e-01f, 2.67450720e-01f, -9.42907184e-02f,
  6.27158210e-03f, 9.50324256e-03f, 2.27086004e-02f, 6.16578832e-02f, -6.26627728e-02f, 8.07564557e-02f, -6.51598945e-02f, 7.99290650e-03f, -6.96598366e-02f, 3.26781720e-02f,
  1.45639237e-02f, -1.41396355e-02f, -7.50847310e-02f, -3.44958864e-02f, 4.09560427e-02f, 4.89178440e-03f, -1.56451538e-02f, -4.15270729e-03f, -1.55127477e-02f, 1.41161894e-02f,
  2.15567779e-02f, 1.57401934e-01f, 2.40162183e-02f, 7.90570304e-02f, 4.67136241e-02f, -8.27885345e-02f, -4.39200737e-03f, 4.90771532e-02f, 4.52182852e-02f, 2.92507578e-02f,
  -4.37469929e-01f, 2.54940301e-01f, -1.74155071e-01f, 8.27505905e-03f, 1.31086120e-02f, 4.21492532e-02f, -6.40438125e-03f, -2.30808891e-02f, -5.77033348e-02f, -6.95692971e-02f,
  9.83990431e-02f, 5.39149856e-03f, -4.35890108e-02f, 7.97679722e-02f, -1.18771456e-01f, -2.11519226e-02f, -1.81505308e-02f, -1.00072034e-01f, 1.99735463e-01f, -2.78310059e-03f,
  1.62502795e-01f, -1.05934478e-02f, -3.20738852e-02f, 6.39070123e-02f, 4.59288843e-02f, -2.68692244e-02f, -1.62986033e-02f, 3.36707011e-02f, 4.59450446e-02f, -1.54656276e-01f,
  -5.95117450e-01f, 9.27695557e-02f, 9.56534743e-02f, -6.03320479e-01f, 2.62665953e-02f, 2.08480522e-01f, 3.47561359e-01f, -1.10706463e-02f, -2.91500300e-01f, 5.24240024e-02f,
  1.16663046e-01f, -6.71806857e-02f, -1.93057403e-01f, 1.16612472e-01f, 7.37112835e-02f, 1.19833879e-01f, -8.13958272e-02f, -1.34633660e-01f, 1.82751834e-01f, 2.47855410e-01f,
  6.38302788e-02f, -2.34102920e-01f, -2.71991521e-01f, -1.08151749e-01f, -2.44484678e-01f, -6.88770935e-02f, -6.81184009e-02f, -2.22129047e-01f, 7.57938176e-02f, -2.82787830e-01f,
  2.04869792e-01f, -1.73415557e-01f, 1.46211922e-01f, -1.89991593e-01f, -1.22780226e-01f, 6.00204580e-02f, -5.65292267e-03f, -2.30487049e-01f, -4.82279509e-02f, -1.49998562e-02f,
  -2.36020282e-01f, 1.01070635e-01f, -5.69143407e-02f, -3.22449692e-02f, 9.68528446e-03f, 2.28003953e-02f, 5.71182463e-03f, -8.76902565e-02f, -1.87429022e-02f, 1.52960256e-01f,
  8.94452855e-02f, 6.72132447e-02f, 4.43152785e-02f, 1.76205665e-01f, 1.20492406e-01f, -6.43248782e-02f, 2.48613030e-01f, 8.72642323e-02f, 2.12423176e-01f, -1.46810234e-01f,
  2.19833702e-02f, 6.62254542e-02f, -2.55351663e-02f, -1.00704111e-01f, 3.79889347e-02f, 2.90347151e-02f, -8.89207870e-02f, 1.58048123e-02f, -1.61982607e-02f, 3.79324816e-02f,
  -8.49226862e-03f, 6.26547188e-02f, 5.69830388e-02f, -5.13461642e-02f, -1.27575994e-01f, 1.86125413e-02f, 5.14737107e-02f, -2.66156346e-02f, 7.76874870e-02f, 8.97601098e-02f,
  -1.19696669e-02f, -6.50250092e-02f, -2.03987882e-01f, -3.45020220e-02f, -3.49287167e-02f, -2.86478512e-02f, 9.00572017e-02f, 5.62405176e-02f, 3.59953269e-02f, -1.05042886e-02f,
  -2.07126081e-01f, 9.78903398e-02f, -8.42902884e-02f, 3.52505855e-02f, -1.07977025e-01f, 3.07664890e-02f, -7.39272982e-02f, -1.05829174e-02f, 3.73896696e-02f, -9.19265822e-02f,
  4.64005284e-02f, -4.46878113e-02f, -4.45862040e-02f, 1.12344056e-01f, 1.08387969e-01f, -1.02671720e-01f, -1.81678925e-02f, 3.39925885e-02f, 1.02988638e-01f, 6.53986111e-02f,
  -5.74513339e-02f, 7.10716620e-02f, -1.37879238e-01f, -2.53160857e-02f, -7.78133646e-02f, -1.57073066e-01f, 9.49627832e-02f, -8.13316703e-02f, 1.76342413e-01f, -6.81181550e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.80252299e-01f, -5.24059609e-02f, 9.86254737e-02f, 5.07224947e-02f, 1.92280151e-02f, 1.47097632e-01f, 1.74314663e-01f, -1.09671161e-01f, 3.50227840e-02f, -7.43529648e-02f,
  1.70317069e-01f, 1.56813771e-01f, -9.18898582e-02f, -4.25851382e-02f, 1.18124649e-01f, -6.09305268e-03f, 1.35086134e-01f, 5.44279057e-04f, 1.42359778e-01f, 1.30660251e-01f,
  1.05125725e-01f, -5.87741248e-02f, -8.89409706e-03f, 1.27314597e-01f, -5.89251891e-02f, 9.80131701e-02f, 1.13843918e-01f, -2.26386748e-02f, 3.93388681e-02f, 2.11264361e-02f,
  2.92332415e-02f, -4.86474298e-02f, 1.02586895e-01f, 1.05096802e-01f, 1.98594198e-01f, -2.17960738e-02f, 8.25466365e-02f, 9.45797414e-02f, -4.38331254e-02f, -2.52918452e-02f,
  -1.68954358e-02f, 1.57000989e-01f, 3.39860208e-02f, 3.83931398e-02f, 8.08496848e-02f, 4.51618731e-02f, -1.62791330e-02f, 1.52920052e-01f, 1.15966737e-01f, -1.90209985e-01f,
  1.62872657e-01f, 1.56893551e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -9.64393988e-02f, -1.92911755e-02f, -1.30973443e-01f, -1.69022456e-02f, 9.33622662e-03f, -2.34575868e-02f, -6.43890873e-02f, 1.09835155e-01f, -5.82094677e-03f, 1.19927796e-02f,
  1.35312937e-02f, 2.30143562e-01f, 1.40484929e-01f, 6.79351836e-02f, -2.08727807e-01f, -2.13335484e-01f, -2.80665725e-01f, 5.59424087e-02f, 1.81471273e-01f, 7.59124830e-02f,
  1.52784079e-01f, 1.11244544e-01f, -2.49768212e-01f, -1.30484194e-01f, 1.44521803e-01f, -2.22638711e-01f, -2.09160253e-01f, -1.91327944e-01f, 1.65581152e-01f, 3.42957020e-01f,
  9.41961929e-02f, 2.59218246e-01f, 1.09461226e-01f, -2.20109187e-02f, 9.02589876e-03f, 1.87698137e-02f, 6.41422570e-02f, 2.18876913e-01f, 2.12388307e-01f, -2.22623020e-01f,
  -8.00663531e-02f, -1.11472756e-01f, -1.92289084e-01f, 2.02708259e-01f, -5.70089445e-02f, 7.61475563e-02f, 2.01769337e-01f, 3.89104635e-02f, 1.14586785e-01f, -2.55171180e-01f,
  4.92842449e-03f, 1.17438734e-01f, 2.36151397e-01f, -3.33631150e-02f, -1.65706441e-01f, -4.88605015e-02f, -9.36427861e-02f, -1.99644685e-01f, -2.65807539e-01f, 3.69393341e-02f,
  1.62914217e-01f, 7.08606243e-02f, -1.62743628e-01f, 2.43543717e-03f, 3.58388051e-02f, -6.81962445e-02f, 6.49479628e-02f, -1.45984352e-01f, -3.77711020e-02f, 8.24307352e-02f,
  -2.91227531e-02f, -6.12128489e-02f, -3.08791418e-02f, 2.19897836e-01f, -1.13907218e-01f, -2.44085386e-01f, -9.84032452e-02f, -3.10101584e-02f, 1.50469035e-01f, 4.80719469e-02f,
  6.47197664e-02f, -1.15569141e-02f, -1.58879861e-01f, -1.15513302e-01f, 2.20289484e-01f, -2.35437285e-02f, -3.54447812e-01f, 2.22506281e-02f, 7.44289234e-02f, -2.53408290e-02f,
  -4.60146107e-02f, 2.25858703e-01f, -5.03655709e-02f, 5.48721850e-03f, -2.28119403e-01f, 5.84282577e-02f, 1.18307754e-01f, -2.01735750e-01f, -8.34584907e-02f, -2.13957224e-02f,
  2.49282531e-02f, 1.28198326e-01f, 6.06594943e-02f, 3.48260663e-02f, -1.15062460e-01f, 1.58793405e-01f, -2.37547785e-01f, 7.05853775e-02f, -2.32000858e-01f, 2.45883703e-01f,
  3.70192043e-02f, 1.56719655e-01f, -8.41737241e-02f, 1.45866489e-02f, -3.80417565e-03f, 1.36625260e-01f, 7.31831491e-02f, 2.50250310e-01f, -1.40581787e-01f, -6.03562742e-02f,
  -1.26624536e-02f, -1.13486476e-01f, -1.46015376e-01f, 9.35520753e-02f, -6.59170970e-02f, -1.21977657e-01f, -2.98687994e-01f, -3.10346782e-01f, 5.92685044e-02f, -7.08873123e-02f,
  1.75028369e-02f, 4.93151024e-02f, -5.20413741e-02f, 3.43327671e-02f, -1.44317105e-01f, 5.89185394e-02f, 3.43352780e-02f, 1.03414180e-02f, 7.06409588e-02f, -7.69385993e-02f,
  -1.21715933e-01f, 1.86534762e-01f, -3.01352553e-02f, 1.31147161e-01f, -1.65641680e-02f, 7.06907585e-02f, -2.52817899e-01f, 4.41411175e-02f, 1.12838477e-01f, 1.32280022e-01f,
  1.33122340e-01f, -1.53402954e-01f, 2.22871453e-02f, 1.19483069e-01f, 4.24274839e-02f, 1.47773763e-02f, -2.44753342e-02f, 1.75227858e-02f, -3.51006798e-02f, 6.36228472e-02f,
  -1.52447000e-02f, -7.96481222e-02f, -1.69450074e-01f, 3.19040678e-02f, 1.85455441e-01f, 6.21942542e-02f, 4.38029096e-02f, 6.76926970e-02f, -1.25447184e-01f, 1.70302346e-01f,
  -1.25478491e-01f, 3.38507853e-02f, -2.64782846e-01f, 1.03255592e-01f, -4.34884019e-02f, -1.14140958e-01f, 1.03934728e-01f, 6.47456869e-02f, 1.61666349e-01f, -6.25636205e-02f,
  7.58121088e-02f, 7.26436824e-02f, -4.52896990e-02f, 8.50426033e-02f, -8.83428007e-02f, 1.85969487e-01f, -1.32833779e-01f, -1.07404262e-01f, -1.11312956e-01f, 1.01794191e-01f,
  -1.70031533e-01f, -2.41151169e-01f, 9.82842669e-02f, 1.86598245e-02f, 4.97613661e-02f, -3.16311009e-02f, -9.95406508e-02f, -5.25771677e-02f, 8.52837414e-03f, -7.30476752e-02f,
  -9.66937318e-02f, -1.03015542e-01f, 2.41136625e-01f, -1.66347057e-01f, -1.36766932e-03f, -1.52651295e-01f, -4.31005843e-02f, -3.41173448e-02f, 8.23566765e-02f, -1.77089885e-01f,
  3.42291631e-02f, 1.96330041e-01f, -9.72466096e-02f, 1.28358185e-01f, 2.85924584e-01f, 3.96851525e-02f, -1.55921346e-02f, -7.41709247e-02f, -1.05927929e-01f, -8.93320069e-02f,
  -1.85514688e-01f, -1.22683361e-01f, 1.22271232e-01f, -1.19694293e-01f, -9.03414637e-02f, 1.87440455e-01f, 1.91131160e-01f, -6.88040555e-02f, -3.37120481e-02f, 8.63082707e-02f,
  5.80984503e-02f, 2.03120843e-01f, 1.11542746e-01f, -1.74044847e-01f, 1.28013551e-01f, -5.19987568e-02f, 3.67844105e-02f, -2.29054391e-01f, -2.10648812e-02f, -1.79742694e-01f,
  -1.62743419e-01f, 2.51241419e-02f, -5.65740699e-03f, -2.21753563e-03f, 1.43461913e-01f, -1.27673000e-01f, -8.84275942e-04f, -9.34651121e-02f, 1.82475001e-01f, 2.47070283e-01f,
  1.25964165e-01f, 1.91412926e-01f, -1.89170495e-01f, -3.53013687e-02f, 7.50933141e-02f, -1.33247927e-01f, -5.25178527e-03f, -6.76007792e-02f, 8.21674690e-02f, -3.97196114e-02f,
  3.74516792e-04f, 1.80538446e-02f, 1.14481129e-01f, -1.27854586e-01f, 9.12806839e-02f, -4.01791222e-02f, -1.00311823e-01f, 3.07739334e-04f, 1.90387577e-01f, 6.74467310e-02f,
  1.97373684e-02f, -8.43637958e-02f, 1.30388662e-01f, 3.12852003e-02f, -1.94260851e-02f, -2.06102893e-01f, -1.17177643e-01f, -6.24770075e-02f, -6.33921623e-02f, 7.54215047e-02f,
  -5.04865386e-02f, 1.58732176e-01f, -9.01771486e-02f, 1.15586042e-01f, -2.67846268e-02f, -1.95924744e-01f, 9.72749516e-02f, -6.35041967e-02f, -7.74420723e-02f, 8.16249549e-02f,
  2.66472846e-01f, -9.62193236e-02f, -1.57699600e-01f, -9.19763371e-02f, -9.79480892e-02f, 1.40087768e-01f, -8.70516598e-02f, 1.00948893e-01f, 7.37295374e-02f, -1.62147135e-01f,
  2.21610531e-01f, -1.45983517e-01f, -6.62612244e-02f, -2.28616521e-01f, -1.66881960e-02f, 3.07274964e-02f, 6.95223734e-03f, 3.35662626e-02f, -9.09400806e-02f, -2.04085007e-01f,
  -2.74584927e-02f, 7.96519220e-03f, -2.71640662e-02f, -2.86259919e-01f, 1.30330667e-01f, -4.49895076e-02f, 1.44589990e-01f, -7.78048187e-02f, 6.77433312e-02f, 2.78784335e-01f,
  8.91223177e-03f, 4.12802324e-02f, 1.48693174e-01f, -1.10557526e-01f, -1.56111950e-02f, -5.82866296e-02f, 1.33295199e-02f, -3.62817012e-03f, 7.07199425e-02f, 1.06549501e-01f,
  -1.08237363e-01f, 8.15244857e-04f, -3.15968782e-01f, -5.07524870e-02f, 9.78519320e-02f, 1.29517540e-01f, 1.87649041e-01f, -6.30859807e-02f, -3.13710093e-01f, 1.61370769e-01f,
  -1.88558504e-01f, 7.77211860e-02f, 4.33858633e-01f, -6.30596206e-02f, -9.39267650e-02f, 1.88436866e-01f, -3.96133102e-02f, 1.40155345e-01f, -5.88878617e-02f, -2.10957840e-01f,
  4.82174754e-02f, -8.57902765e-02f, -1.64204746e-01f, 2.05620360e-02f, 1.77219257e-01f, 1.27428666e-01f, -1.43144801e-01f, -1.44072235e-01f, -1.97919890e-01f, 2.20739737e-01f,
  6.59390837e-02f, -1.60663351e-02f, 2.42208794e-01f, -6.34972900e-02f, 4.05919664e-02f, -8.83567110e-02f, -9.61516276e-02f, -1.57332614e-01f, -1.64869353e-01f, 1.71394482e-01f,
  -1.15885340e-01f, -6.57170340e-02f, -6.86645880e-02f, 8.17186683e-02f, 2.06944034e-01f, 1.34118229e-01f, 1.48744285e-01f, 1.18648373e-01f, 1.15773998e-01f, -2.82366201e-02f,
  -2.16276661e-01f, -1.23233415e-01f, 1.61732212e-01f, -4.47943024e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.77220792e-01f, 2.57047545e-02f, 8.10514614e-02f, 2.05385331e-02f, 1.55943502e-02f, 6.62603974e-02f, 1.10286372e-02f, -9.63361338e-02f, 3.56484135e-03f, 2.74101943e-02f,
  -1.61412451e-02f, -9.03545767e-02f, 2.11293370e-01f, -1.60926431e-01f, -6.72910213e-02f, 3.62190679e-02f, 1.96926385e-01f, -2.09913105e-01f, 7.44082034e-03f, 1.91612747e-02f,
  1.26462489e-01f, 4.83984165e-02f, -1.56091079e-01f, -1.22038508e-02f, -9.43721831e-02f, -1.49943680e-01f, -8.07743967e-02f, -1.01709865e-01f, -8.03200528e-02f, 8.79224762e-02f,
  -1.62568614e-01f, 1.70114160e-01f, 1.06336158e-02f, 2.93845329e-02f, 2.11222380e-01f, 1.76434994e-01f, 9.22926702e-03f, -1.07121095e-01f, 2.85262406e-01f, -1.68024763e-01f,
  1.17298223e-01f, -8.57563689e-02f, 1.24776155e-01f, -2.74536192e-01f, 2.92989045e-01f, -3.89002380e-03f, 1.14321172e-01f, 1.05706207e-01f, -1.39417097e-01f, 1.31984264e-01f,
  -3.40366848e-02f, -1.97558030e-01f, 1.23698361e-01f, -8.06972831e-02f, -8.59501883e-02f, -6.98163807e-02f, -5.39662652e-02f, 1.20826080e-01f, 8.39777067e-02f, 1.22409247e-01f,
  2.30609715e-01f, 4.99072857e-02f, 5.73260374e-02f, 1.50894761e-01f, 1.52767867e-01f, -5.23348227e-02f, -3.33742239e-02f, 5.16996905e-02f, -3.13994773e-02f, 1.01850756e-01f,
  2.55920254e-02f, 1.64558783e-01f, 9.76548195e-02f, 6.64014230e-03f, 3.68337333e-02f, -6.59418255e-02f, -1.66899469e-02f, -1.08492918e-01f, 2.78365195e-01f, 1.01646006e-01f,
  1.61233783e-01f, -2.63484870e-03f, -2.97817379e-01f, -1.26137398e-03f, 2.87538115e-02f, 1.04908302e-01f, 1.34509489e-01f, 1.14847668e-01f, -1.17529593e-01f, -3.10162790e-02f,
  6.81562396e-03f, 1.12434559e-01f, -7.63191730e-02f, -1.79449350e-01f, -1.09268256e-01f, -2.67520964e-01f, -1.61761984e-01f, -6.34872466e-02f, 7.89447650e-02f, 2.84462627e-02f,
  -1.12081133e-01f, -8.15819278e-02f, -4.85452935e-02f, 1.03079811e-01f, -5.07599721e-03f, 1.66852176e-01f, 1.30296737e-01f, -4.28583138e-02f, 1.12979926e-01f, 2.42440812e-02f,
  6.12343773e-02f, 1.67965487e-01f, -2.08664939e-01f, 1.54303074e-01f, 3.47231552e-02f, -9.09257738e-04f, 1.22506313e-01f, 3.75085801e-01f, 1.34666696e-01f, -4.04266454e-03f,
  -4.21506390e-02f, 1.22044541e-01f, -4.08333130e-02f, 3.22546586e-02f, -1.84660684e-03f, -6.41082823e-02f, -5.71356714e-02f, -4.51322459e-02f, 1.66954786e-01f, 7.63809234e-02f,
  1.17122326e-02f, -4.06250134e-02f, -7.15425014e-02f, 6.69436902e-02f, 1.03195729e-02f, 1.48774639e-01f, -1.13144711e-01f, -3.00245106e-01f, -1.85657576e-01f, 4.89163734e-02f,
  -6.96887597e-02f, 1.03561662e-01f, 2.78391063e-01f, 1.90091893e-01f, -2.33433113e-01f, 1.27219215e-01f, -2.05156326e-01f, -9.39877033e-02f, 4.06032540e-02f, -6.32114932e-02f,
  2.09075719e-01f, -1.31534506e-02f, 8.96442831e-02f, 2.87539452e-01f, 4.67701219e-02f, -2.34192863e-01f, -4.72967401e-02f, -9.92463306e-02f, 2.30615675e-01f, -1.58916175e-01f,
  -2.37486094e-01f, 7.72225186e-02f, -1.53233990e-01f, -1.07479088e-01f, -6.34647487e-03f, -3.12524438e-02f, 2.45490354e-02f, 1.47081956e-01f, -1.11844223e-02f, 1.89578131e-01f,
  2.31135875e-01f, -8.16455390e-03f, -5.33426553e-02f, -1.08048744e-01f, -1.09218210e-01f, -7.73749799e-02f, 1.78233758e-01f, -4.62109111e-02f, 1.60628915e-01f, -4.24206778e-02f,
  2.15624318e-01f, 2.18209714e-01f, 5.34802899e-02f, -2.69249082e-01f, -2.55652498e-02f, 2.98429787e-01f, 1.31136298e-01f, -1.36843801e-01f, -2.31300145e-01f, -7.87976235e-02f,
  6.47383556e-02f, -1.90250073e-02f, 2.74409670e-02f, 1.26085520e-01f, -4.78373580e-02f, 1.81965068e-01f, 9.91276503e-02f, 5.92050813e-02f, 1.83243886e-01f, 2.33011544e-01f,
  1.30839378e-01f, 4.03769920e-03f, 7.70792644e-03f, 3.36562097e-01f, 1.03274696e-01f, 2.79236138e-02f, -9.78753194e-02f, -1.13586662e-02f, 7.87756145e-02f, -1.69661775e-01f,
  1.77096650e-01f, -2.42900457e-02f, -7.07724243e-02f, 3.00968997e-02f, 1.05421357e-01f, -3.19489062e-01f, -3.73286866e-02f, -1.07274927e-01f, 1.29500357e-02f, 4.55409363e-02f,
  -6.07122295e-02f, 1.02933623e-01f, 2.49609128e-01f, -3.77383560e-01f, 4.64537833e-03f, -9.36185867e-02f, -6.90771174e-03f, -4.19517867e-02f, 6.95348307e-02f, 4.65538323e-01f,
  -6.06298707e-02f, 4.96662557e-02f, 1.73670307e-01f, -1.15855485e-01f, 2.51097530e-02f, 9.19455737e-02f, -5.98239154e-02f, -2.44941846e-01f, 6.63073733e-02f, -1.43064216e-01f,
  -2.91284006e-02f, -3.38147618e-02f, 1.53507859e-01f, 1.64091364e-01f, 1.28081471e-01f, -8.19780454e-02f, -1.39113918e-01f, 1.49584170e-02f, -1.43493876e-01f, -1.48198619e-01f,
  -1.63766071e-01f, 3.40187699e-02f, -4.27020825e-02f, 1.66852295e-01f, 5.22615563e-04f, -1.69831768e-01f, 1.71070136e-02f, -1.62082743e-02f, 1.04252368e-01f, -1.45460322e-01f,
  -4.07986976e-02f, -6.13139151e-03f, 2.20893580e-03f, -7.64308497e-02f, -3.23186032e-02f, 1.66966841e-01f, 2.48153403e-01f, -9.25188586e-02f, -4.54369970e-02f, 1.66923240e-01f,
  -1.65560752e-01f, 5.05871065e-02f, -3.15443166e-02f, -2.51580685e-01f, 2.46729925e-01f, -1.35868251e-01f, 4.14378531e-02f, -4.34123687e-02f, -5.24075143e-02f, -9.16367993e-02f,
  1.59614339e-01f, -1.03429362e-01f, 2.16946483e-01f, 3.83904845e-01f, -1.53844148e-01f, 2.51004338e-01f, -3.90987732e-02f, -2.84571081e-01f, 1.03626117e-01f, -7.34923184e-02f,
  -1.89628303e-02f, 7.21625015e-02f, -3.14905733e-01f, -6.35477006e-02f, -1.26729952e-02f, -2.11164877e-01f, -1.44029737e-01f, -1.78304344e-01f, -8.92626420e-02f, 1.99794263e-01f,
  -2.07663074e-01f, 3.21067959e-01f, -6.50578067e-02f, -2.42903456e-02f, 9.91027206e-02f, -9.97033808e-03f, -1.49119899e-01f, 1.79367229e-01f, -1.35911793e-01f, -6.64501823e-03f,
  8.99857581e-02f, 2.08307862e-01f, 1.18113078e-01f, -1.29037231e-01f, 2.46862974e-02f, 1.61303833e-01f, -1.83346197e-01f, -7.16570467e-02f, -3.71122330e-01f, -2.52004084e-03f,
  7.83577040e-02f, 2.32577920e-01f, 1.60356238e-01f, 1.04746155e-01f, 1.66044682e-01f, 6.50931001e-02f, -1.30833909e-01f, 1.31526783e-01f, -5.48211373e-02f, -2.52243206e-02f,
  9.90360603e-02f, -2.50456691e-01f, -3.00574936e-02f, -2.49677926e-01f, 2.22757012e-01f, 3.02793924e-02f, 1.35347275e-02f, 6.01359420e-02f, -2.67494470e-01f, 8.30108672e-02f,
  1.29864112e-01f, 1.04458630e-01f, 1.57211885e-01f, 7.70660490e-02f, -2.06426363e-02f, -9.66362953e-02f, 1.58007264e-01f, 1.10412501e-01f, -7.86006227e-02f, -1.54038174e-02f,
  -1.78361952e-01f, -1.14749074e-01f, -1.37587249e-01f, -1.20363146e-01f, -4.03896254e-03f, -1.29014011e-02f, 6.37486652e-02f, -1.60090670e-01f, 1.94951430e-01f, 1.82224274e-01f,
  9.64187309e-02f, 1.55248851e-01f, 6.67382479e-02f, -1.57960236e-01f, -1.15174435e-01f, 2.81355958e-02f, 1.38168082e-01f, 1.00360967e-01f, -3.60226244e-01f, 1.66925728e-01f,
  -1.92283347e-01f, -1.77486375e-01f, 3.46038118e-02f, 3.55478436e-01f, -3.51630598e-02f, -1.33167595e-01f, 1.78131327e-01f, 2.46429414e-01f, 4.88180928e-02f, 2.00733081e-01f,
  4.45321165e-02f, -1.35299221e-01f, -1.34082898e-01f, -5.40271252e-02f, 2.28439495e-02f, 1.65982038e-01f, 1.24536172e-01f, 2.14801341e-01f, 8.40754211e-02f, -4.10837121e-03f,
  -1.54356539e-01f, 2.07157940e-01f, 1.20515965e-01f, 1.38921838e-04f, -4.57557803e-03f, 7.92566091e-02f, 8.80479738e-02f, -1.07353434e-01f, 1.28070777e-03f, -1.77484397e-02f,
  -5.54425933e-04f, -1.45408139e-01f, 5.80228977e-02f, 6.70373142e-02f, -3.46620791e-02f, -1.97205842e-02f, 2.91431189e-01f, -1.21675171e-01f, 1.06458932e-01f, -2.48458713e-01f,
  -6.79568052e-02f, -7.32930750e-02f, 3.19827348e-02f, 3.07201818e-02f, 2.98788995e-01f, -1.52699783e-01f, -4.36077192e-02f, -8.90174955e-02f, -1.33560598e-02f, -2.01935098e-01f,
  5.09741530e-03f, 8.07782039e-02f, -4.63954508e-02f, 2.26408809e-01f, 1.94361642e-01f, -2.43238762e-01f, 3.50460447e-02f, 2.60595959e-02f, -8.93428400e-02f, -2.44921237e-01f,
  5.55231683e-02f, -6.40591234e-02f, -2.31850818e-01f, -3.13045904e-02f, 9.58088338e-02f, 2.43921503e-02f, 2.43548244e-01f, -5.66725023e-02f, -1.07217319e-01f, -7.73095414e-02f,
  1.96533814e-01f, 1.09789781e-01f, -1.57308564e-01f, -5.69712594e-02f, 1.28113106e-01f, -1.08014256e-01f, 6.38944507e-02f, 1.45794377e-02f, 4.60065827e-02f, -1.90905377e-03f,
  1.32965609e-01f, 1.02625992e-02f, 2.31840640e-01f, -2.23024823e-02f, -1.63489562e-02f, 6.79607689e-02f, -2.31692549e-02f, 1.72876447e-01f, 1.59472991e-02f, 7.96845835e-03f,
  3.63795727e-01f, 1.16843291e-01f, -1.32479951e-01f, 1.63826093e-01f, 2.55919814e-01f, -3.61961782e-01f, 8.46203864e-02f, 9.87156946e-03f, 7.23806992e-02f, 1.42295152e-01f,
  4.53388840e-02f, -1.63075134e-01f, 2.65996426e-01f, -1.74226314e-01f, 2.22471841e-02f, 5.89012913e-02f, -2.68133223e-01f, 3.60895216e-01f, 1.24883994e-01f, -2.60286331e-01f,
  -4.82965596e-02f, 2.04362702e-02f, 9.23659503e-02f, -5.71799725e-02f, 3.63032706e-02f, 3.79881740e-01f, 2.61762589e-01f, 1.05613306e-01f, 2.70837303e-02f, -7.46213198e-02f,
  8.34944844e-02f, 3.30361605e-01f, 6.23253034e-03f, 8.40210728e-03f, 2.10291430e-01f, -4.30381984e-01f, -2.19924569e-01f, 1.26968682e-01f, -4.05151956e-02f, 1.33397207e-01f,
  3.42769980e-01f, 3.93333316e-01f, 1.41145483e-01f, 8.21270570e-02f, 1.77770793e-01f, 1.30149946e-01f, 1.18551627e-01f, 3.69765610e-01f, -1.63111851e-01f, 6.01640753e-02f,
  -2.17772424e-01f, -3.14023435e-01f, -2.83659026e-02f, 1.39188632e-01f, 1.50393650e-01f, -5.46371117e-02f, -1.85364723e-01f, 1.64318010e-01f, 4.51791473e-02f, -2.38412961e-01f,
  -9.15080681e-02f, -6.50690123e-02f, -1.29532907e-02f, -2.02763170e-01f, -9.71877351e-02f, -4.97331545e-02f, 6.89983517e-02f, -2.82972539e-03f, 2.72100437e-02f, -1.98458239e-01f,
  -1.07649885e-01f, -1.19467363e-01f, -9.53056440e-02f, -5.51795587e-02f, 9.70282927e-02f, 8.35946202e-02f, -2.32633232e-04f, 3.47205609e-01f, -9.97148305e-02f, -3.58660519e-02f,
  -2.23153114e-01f, -1.74253613e-01f, -4.32000495e-02f, -2.71312863e-01f, -1.78843826e-01f, 5.57250381e-02f, 1.78517833e-01f, 2.54071474e-01f, -1.71237037e-01f, -3.29222143e-01f,
  -5.37920631e-02f, -9.56656411e-03f, -3.94901186e-02f, -1.24847805e-02f, 3.02052706e-01f, -3.87610883e-01f, 3.80140580e-02f, 2.35825703e-01f, -1.88077211e-01f, -6.91077439e-03f,
  1.19512238e-01f, 1.95063740e-01f, -6.30507842e-02f, -2.63155550e-01f, -2.02372875e-02f, -9.80358869e-02f, 1.14114605e-01f, 9.04603526e-02f, 2.01893717e-01f, 1.51274279e-01f,
  1.78520173e-01f, 1.67591751e-01f, 5.88887818e-02f, 8.24293308e-03f, 7.97740221e-02f, 2.64344871e-01f, -4.20422629e-02f, 2.54359283e-02f, 2.69859955e-02f, -5.70171885e-02f,
  9.34072658e-02f, 1.60437554e-01f, -4.70620953e-02f, 1.10727794e-01f, -5.29139042e-02f, -2.84272134e-02f, -1.19013563e-02f, -1.85458884e-01f, -4.60485974e-03f, -2.10658282e-01f,
  -5.68727218e-02f, 1.43976882e-01f, -1.21564688e-02f, 1.31564781e-01f, -1.46446582e-02f, -9.93753001e-02f, 1.53923064e-01f, 6.08973159e-03f, 1.14984829e-02f, 4.15271930e-02f,
  -7.82983750e-02f, -1.94712877e-01f, 8.94339308e-02f, -1.10155724e-01f, 1.44770741e-01f, 1.25124574e-01f, -3.55113149e-01f, 5.44669740e-02f, -2.50663191e-01f, -4.31994162e-02f,
  -1.66973084e-01f, 2.35109460e-02f, 1.41676575e-01f, -2.30793864e-01f, 1.55424476e-01f, 1.44976079e-01f, -1.27655879e-01f, 7.91631788e-02f, 9.85069498e-02f, -1.94877222e-01f,
  6.12895004e-02f, 1.54650927e-01f, 1.10008061e-01f, 2.40415365e-01f, -2.71380872e-01f, 1.22207686e-01f, -9.13427174e-02f, -1.09237030e-01f, 1.25075519e-01f, 2.51922160e-01f,
  1.00506939e-01f, -1.81991130e-01f, 2.07043350e-01f, 2.78273195e-01f, 1.91016309e-02f, -1.66919678e-02f, 8.92691761e-02f, 5.35333529e-02f, -1.70742497e-01f, -3.49757145e-03f,
  8.69336128e-02f, 1.26947388e-01f, -1.91521123e-02f, 8.23187605e-02f, 8.31654891e-02f, 2.02463821e-01f, -7.96632394e-02f, -8.94999802e-02f, -6.91480041e-02f, -4.32349481e-02f,
  3.03210597e-02f, 8.83933157e-02f, 1.22367963e-01f, 6.12698682e-02f, 5.86132407e-02f, -4.64109667e-02f, -1.79851949e-01f, 1.93324149e-01f, 2.89052606e-01f, -2.78535217e-01f,
  1.38331980e-01f, 1.10828184e-01f, -3.49460065e-01f, -7.63781741e-02f, 1.05060562e-01f, -2.77097881e-01f, 1.00033641e-01f, 2.48458311e-01f, 2.32954428e-01f, 2.43287370e-01f,
  -1.59607023e-01f, 2.32973024e-01f, 3.60355638e-02f, -4.66632172e-02f, -8.58680829e-02f, -2.30515953e-02f, 1.23371542e-01f, 1.08592771e-01f, 1.90434262e-01f, -1.71198249e-01f,
  -1.59765966e-02f, -5.51441535e-02f, -4.24010418e-02f, 8.43369439e-02f, -1.72515497e-01f, 2.42707640e-01f, 1.06498815e-01f, 1.32887617e-01f, 1.56852111e-01f, 6.93501979e-02f,
  -5.28330132e-02f, 4.21627276e-02f, -3.51818800e-02f, 6.07990101e-02f, -2.84588616e-02f, 8.53460282e-02f, -3.80786955e-02f, -8.27269778e-02f, -9.57853645e-02f, -4.08036076e-02f,
  7.27400556e-02f, -1.00044176e-01f, -1.10892102e-01f, -1.76760263e-03f, 2.95737870e-02f, -3.24488804e-02f, 5.36256842e-02f, 9.50037763e-02f, 2.54012719e-02f, 4.64020148e-02f,
  1.08420840e-02f, -1.12917155e-01f, 1.18099146e-01f, -1.07415579e-01f, -1.99733853e-01f, 1.43447787e-01f, -2.94434309e-01f, -6.67509660e-02f, 1.20778613e-01f, 6.43313751e-02f,
  1.10711001e-01f, 1.56519830e-01f, -3.36422861e-01f, 8.86221081e-02f, -9.50588733e-02f, 1.59576256e-02f, 5.17918348e-01f, -1.97132081e-01f, -9.22879651e-02f, 2.88570166e-01f,
  -2.07587853e-01f, -3.97954732e-02f, -4.01653536e-02f, -1.71628684e-01f, 2.71069318e-01f, 2.67292894e-02f, 6.54310510e-02f, 1.24620609e-01f, 2.18210489e-01f, -7.00055882e-02f,
  -1.85670719e-01f, -6.88226596e-02f, -1.22676067e-01f, 1.84946388e-01f, 2.11642742e-01f, 6.30615950e-02f, 1.08746193e-01f, -3.37057598e-02f, 1.08967811e-01f, 1.09890979e-02f,
  6.55839443e-02f, -3.18401605e-01f, 2.20676929e-01f, 8.56510177e-02f, -7.24990442e-02f, -8.23307186e-02f, -5.22142723e-02f, -2.01558605e-01f, 2.11272642e-01f, 2.04932764e-01f,
  -1.43505067e-01f, 1.20507024e-01f, 1.68981269e-01f, -5.17015867e-02f, -1.70025542e-01f, -2.80736089e-01f, 2.36385345e-01f, 6.81236833e-02f, 7.31931105e-02f, -3.76238115e-02f,
  -8.41349959e-02f, 2.24416945e-02f, 1.83762848e-01f, 4.27690558e-02f, -9.29106846e-02f, 4.63416800e-02f, 7.13262111e-02f, 5.62662035e-02f, 1.71973780e-01f, -1.33274108e-01f,
  1.31502897e-01f, 7.02687874e-02f, -1.59506813e-01f, -2.48417817e-02f, -5.05588688e-02f, 6.69742599e-02f, 9.58558545e-02f, -1.46413103e-01f, 4.05023247e-02f, -6.61248788e-02f,
  -3.21356148e-01f, -4.73735258e-02f, 1.99687257e-01f, -1.38617203e-01f, 1.68585986e-01f, 9.21455994e-02f, 2.30081901e-01f, 2.83940732e-01f, -2.48967960e-01f, 2.62251198e-01f,
  1.95032388e-01f, -1.58601135e-01f, -2.22772196e-01f, 1.40043840e-01f, 1.15660645e-01f, 4.13449481e-02f, 2.08921805e-01f, -5.54979853e-02f, -4.03559022e-02f, -6.71206191e-02f,
  -1.74399972e-01f, -2.08893772e-02f, 5.07582836e-02f, 2.33884394e-01f, 2.11321469e-03f, 1.57077387e-01f, 2.35567719e-01f, -5.73929138e-02f, -2.98607573e-02f, 1.45880431e-01f,
  -4.52936478e-02f, 4.70378296e-03f, 6.03169762e-02f, 1.64732710e-02f, -4.06519547e-02f, -1.31843602e-02f, -9.83235314e-02f, 8.68773684e-02f, 1.15506589e-01f, 1.18730329e-01f,
  -5.60135208e-02f, 1.62417412e-01f, 8.00121278e-02f, -3.54316719e-02f, 2.79661808e-02f, -6.94625974e-02f, 1.89814582e-01f, -6.84486178e-04f, -2.50858031e-02f, -6.34420514e-02f,
  -1.24641940e-01f, 2.74311900e-02f, 7.34636188e-02f, -2.70873308e-01f, -7.37135857e-02f, -1.49730176e-01f, 2.10427463e-01f, 2.01665312e-01f, 1.28187194e-01f, -5.28393686e-02f,
  -2.78689653e-01f, -1.80679020e-02f, -3.68063226e-02f, 2.09720910e-01f, 2.17422783e-01f, -1.66330114e-02f, -1.53550670e-01f, 6.48040622e-02f, 1.16110437e-01f, -1.00709043e-01f,
  -1.77436814e-01f, -1.68408990e-01f, -3.13421547e-01f, -3.08986187e-01f, -1.62764668e-01f, 1.69601649e-01f, 7.52885034e-03f, 2.51250025e-02f, 3.71377654e-02f, -2.27764264e-01f,
  7.49268709e-03f, 4.66557071e-02f, 5.60902171e-02f, 1.31824762e-01f, 5.24798445e-02f, -1.45830482e-01f, 1.20207191e-01f, 1.75162464e-01f, -1.00660875e-01f, -1.41685009e-01f,
  -3.79604697e-01f, 2.47199222e-01f, -3.47909657e-03f, -6.72532693e-02f, 1.58458978e-01f, 3.32892030e-01f, 5.75903757e-03f, -1.16304860e-01f, 1.17546566e-01f, 3.45972806e-01f,
  2.58612990e-01f, 1.50272042e-01f, -8.30267593e-02f, -3.62521149e-02f, -1.82018243e-02f, -1.14558034e-01f, -3.67187709e-02f, -4.20943834e-02f, 7.62778372e-02f, 6.93346262e-02f,
  1.05490543e-01f, 3.47335124e-03f, 7.07504600e-02f, -5.54473288e-02f, -9.73872691e-02f, -1.24913909e-01f, -1.22361824e-01f, -1.32089276e-02f, 1.46377105e-02f, 1.43422171e-01f,
  9.29365531e-02f, 2.08298564e-01f, 4.02300470e-02f, -1.71876088e-01f, -2.33340263e-01f, -6.59554824e-02f, 5.39751723e-02f, 1.83857724e-01f, 1.50120348e-01f, 3.27376388e-02f,
  1.10105149e-01f, 3.57337207e-01f, -2.78754145e-01f, -3.02718163e-01f, -3.49463597e-02f, -1.06538773e-01f, 1.59668159e-02f, -1.93704545e-01f, -3.27779710e-01f, 1.20892189e-01f,
  -6.78104237e-02f, 2.27056846e-01f, 3.62364575e-02f, -4.09609936e-02f, 4.63436171e-02f, 1.52444363e-01f, 1.32718891e-01f, -1.99666843e-02f, 2.46220291e-01f, -8.77273921e-03f,
  1.89089984e-01f, -2.66789068e-02f, 3.89887914e-02f, -4.48815018e-01f, -5.96640594e-02f, 1.54060408e-01f, 1.16902724e-01f, -2.58317351e-01f, 2.24839553e-01f, 4.44963574e-02f,
  5.75728528e-02f, -2.18322322e-01f, 1.67197630e-01f, 3.65578622e-01f, 4.71437015e-02f, 1.72398612e-01f, -1.24850787e-01f, 6.61004558e-02f, 3.92547064e-02f, 6.62605017e-02f,
  1.05655670e-01f, 4.53746086e-03f, 3.90481241e-02f, -5.46027943e-02f, 8.07694569e-02f, -1.64601114e-02f, 1.16396293e-01f, -4.95015085e-02f, 1.02973301e-02f, 2.11290065e-02f,
  -2.28166819e-01f, -1.08654514e-01f, -2.46684119e-01f, 2.45830938e-01f, 3.20130706e-01f, 3.95420380e-02f, -2.35682353e-01f, 2.41280440e-02f, -9.68725979e-02f, -1.36406735e-01f,
  1.79842651e-01f, 2.90525127e-02f, -1.69565246e-01f, -4.28881915e-03f, -1.35361319e-02f, 2.86019862e-01f, 1.20612785e-01f, -1.29938543e-01f, 4.11133282e-02f, -3.56270857e-02f,
  -3.63888107e-02f, 5.78886941e-02f, 7.71454442e-03f, -1.98352486e-01f, -1.21371679e-01f, 2.01692119e-01f, 1.26709612e-02f, 1.32692277e-01f, 7.04334304e-02f, -8.42254683e-02f,
  -2.05737174e-01f, 2.61354417e-01f, -6.20216429e-02f, 5.01534622e-03f, -4.82473336e-02f, 1.42329484e-01f, -4.34746407e-02f, 8.21583867e-02f, 1.52343720e-01f, -6.71654823e-04f,
  -9.77736637e-02f, 4.89991754e-02f, 5.09226136e-02f, 3.39037292e-02f, 1.32411625e-02f, 2.42092814e-02f, -1.42307118e-01f, -1.28332451e-01f, -7.07338825e-02f, -2.05766037e-01f,
  -1.44029975e-01f, -1.07134692e-01f, -2.19120160e-01f, -1.56215519e-01f, 2.31391862e-01f, -1.17904946e-01f, 1.76567763e-01f, 1.44930631e-02f, 2.77297109e-01f, -4.28146347e-02f,
  -9.39658731e-02f, 1.03548162e-01f, -8.85973275e-02f, 7.76774883e-02f, -2.36344382e-01f, -8.55907202e-02f, 9.54729170e-02f, -9.62683558e-03f, 3.02467123e-02f, 1.10881761e-01f,
  7.27262124e-02f, -3.31216045e-02f, -1.98810816e-01f, -8.40651765e-02f, 1.67955488e-01f, -1.50078023e-02f, -2.64479786e-01f, 3.83211114e-02f, 7.87868202e-02f, -1.55087739e-01f,
  -6.16488419e-03f, -2.44696006e-01f, 8.02033171e-02f, 1.72124788e-01f, -3.33198756e-02f, -2.64922470e-01f, -5.41445203e-02f, -6.07850626e-02f, -2.03679234e-01f, 1.07523806e-01f,
  5.51469214e-02f, 2.23593757e-01f, 2.13475868e-01f, -8.88317265e-03f, -2.23275930e-01f, 5.20391949e-02f, -3.25548798e-02f, 1.93439677e-01f, -1.00678839e-01f, 2.45078921e-01f,
  8.25846568e-02f, 1.90167129e-01f, -1.06006458e-01f, 7.65231624e-03f, 2.44896293e-01f, 3.63037586e-02f, 1.62126079e-01f, 2.73035020e-01f, -1.04571395e-01f, -5.24243191e-02f,
  -1.13574386e-01f, 1.11086585e-01f, 2.28799749e-02f, 2.71628708e-01f, 8.25106949e-02f, 4.87847179e-02f, -1.30988181e-01f, -1.64549679e-01f, 1.84814140e-01f, 1.89632669e-01f,
  1.69509113e-01f, 1.35392770e-01f, 3.62471044e-01f, 1.26830235e-01f, 3.17572393e-02f, 3.14469367e-01f, 6.46065325e-02f, 1.33992895e-01f, -1.87627330e-01f, 2.76496913e-03f,
  2.39574462e-01f, 1.73125044e-01f, -1.63680866e-01f, 1.77160218e-01f, 4.91122715e-02f, -1.06784180e-01f, -1.36117280e-01f, -1.51200011e-01f, 1.57151133e-01f, 1.91289447e-02f,
  1.76213682e-02f, -9.01150629e-02f, -9.72483009e-02f, -2.01862324e-02f, -9.60718095e-02f, -1.46710962e-01f, -6.64876252e-02f, 2.49862835e-01f, 2.38931272e-02f, -1.18943818e-01f,
  -1.38361588e-01f, -2.25794435e-01f, -1.93851322e-01f, 7.07517266e-02f, 5.99565320e-02f, 2.22844481e-01f, 9.41444933e-02f, 3.76249626e-02f, 1.52609507e-02f, -6.55082613e-02f,
  1.54644931e-02f, 1.89157441e-01f, 6.90292045e-02f, -3.73987593e-02f, 1.97212502e-01f, -2.76763618e-01f, -1.92497075e-01f, 1.50468111e-01f, -1.31048456e-01f, -1.25349954e-01f,
  1.14390753e-01f, 3.71951401e-01f, -6.12468086e-02f, -1.18547708e-01f, -9.97194126e-02f, 4.47618552e-02f, -5.27241603e-02f, 2.19992399e-01f, -2.37250440e-02f, 5.75574338e-02f,
  -2.24520147e-01f, -2.38049090e-01f, 1.13134123e-01f, -5.83691802e-03f, 3.92308459e-02f, -3.43742594e-02f, 2.56942324e-02f, 5.74796833e-02f, 1.11169174e-01f, 6.88978061e-02f,
  1.28325179e-01f, 1.95247576e-01f, 9.99832079e-02f, 1.90190896e-01f, 1.80316091e-01f, 1.05274908e-01f, -1.23690635e-01f, -1.93108786e-02f, 1.55652925e-01f, -3.62082452e-01f,
  1.02424897e-01f, -6.26933798e-02f, 9.12297219e-02f, 1.05070658e-01f, -5.20351045e-02f, 1.89264584e-02f, 1.96052283e-01f, -1.82246834e-01f, 1.21298566e-01f, 1.55059278e-01f,
  -1.38000637e-01f, 1.46117553e-01f, 7.67510682e-02f, 1.49845690e-01f, 2.12813571e-01f, -6.39046505e-02f, 2.24982917e-01f, 3.59579623e-02f, -2.35336706e-01f, 1.27790302e-01f,
  3.56242880e-02f, -7.88813923e-03f, 1.32098138e-01f, -2.32164085e-01f, -2.28876337e-01f, 1.09068669e-01f, -9.07817855e-03f, 4.17990573e-02f, -8.21805075e-02f, -4.37132530e-02f,
  -3.36937197e-02f, -5.46075888e-02f, -1.56537816e-01f, 1.79373935e-01f, 9.57684293e-02f, 3.13509293e-02f, -1.61309704e-01f, 2.33181372e-01f, -6.06068484e-02f, -1.41140327e-01f,
  6.17817491e-02f, 1.45242825e-01f, -3.83965299e-02f, -1.95472147e-02f, 2.06865021e-03f, -5.02847135e-02f, 1.81902826e-01f, 2.66304649e-02f, 7.07493499e-02f, 8.08754936e-02f,
  1.10065661e-01f, 1.62630510e-02f, 7.56966472e-02f, 2.29327589e-01f, 8.72496865e-04f, 2.11420476e-01f, 6.86317086e-02f, 9.44198146e-02f, 1.58041805e-01f, 6.40804842e-02f,
  -8.50351378e-02f, -5.99161610e-02f, 1.54409543e-01f, -1.50519878e-01f, 1.25645712e-01f, 1.50098994e-01f, -1.00111052e-01f, 4.99559417e-02f, -5.20771742e-02f, 1.61707029e-01f,
  -4.25704531e-02f, -9.69901010e-02f, -2.56178360e-02f, 1.55119255e-01f, -1.66982725e-01f, 1.56386465e-01f, 2.23434225e-01f, 2.70883590e-01f, 1.59668073e-01f, 1.57315254e-01f,
  1.34012148e-01f, -9.12743900e-03f, -2.09731802e-01f, 2.36416072e-01f, -1.45988449e-01f, 1.20352127e-01f, 1.18402168e-01f, -1.43900901e-01f, -1.64350107e-01f, -9.30546448e-02f,
  1.18566334e-01f, -1.13571696e-01f, 1.28763705e-01f, -9.88820344e-02f, 7.74059910e-03f, -9.50593725e-02f, -1.66565076e-01f, 6.50960533e-03f, -1.47007599e-01f, -7.93675929e-02f,
  -1.50318012e-01f, 2.36288309e-01f, -1.86378121e-01f, -1.77747652e-01f, 3.57450917e-02f, -1.12586498e-01f, 4.18693200e-03f, -2.42000788e-01f, 1.99691311e-01f, -3.00683547e-02f,
  9.55890771e-03f, -3.98583859e-02f, 9.53683779e-02f, -4.37335819e-02f, -3.60017717e-02f, -1.49610238e-02f, 1.35159075e-01f, -1.44687220e-01f, 9.57851857e-02f, 1.52765036e-01f,
  1.89678326e-01f, -2.17866436e-01f, -1.47626951e-01f, 1.04768895e-01f, -1.21082112e-01f, -8.89570192e-02f, -1.52993172e-01f, 2.06004996e-02f, -6.35386482e-02f, -8.34411010e-02f,
  1.45943359e-01f, -1.62793025e-01f, -3.14383060e-01f, -2.02775113e-02f, 1.04180843e-01f, -8.92910138e-02f, 1.62381440e-01f, 2.48486340e-01f, 5.03297336e-02f, 1.04821593e-01f,
  -1.14361599e-01f, 7.05083907e-02f, 1.75772443e-01f, -1.05984904e-01f, -1.66649576e-02f, 1.03144705e-01f, -2.18131825e-01f, -7.78829232e-02f, 2.17884779e-01f, -2.69728690e-01f,
  3.88887823e-02f, -3.17548215e-02f, -1.78549051e-01f, 1.49066195e-01f, -2.41127610e-01f, 3.52167368e-01f, -1.16203137e-01f, 9.62693095e-02f, 2.07624540e-01f, -1.40537191e-02f,
  -5.58267124e-02f, 1.34276375e-01f, -2.90276948e-02f, -4.15268028e-03f, 5.62348887e-02f, 3.99360582e-02f, -6.35442585e-02f, -2.76439965e-01f, 1.47110656e-01f, -6.54837415e-02f,
  -1.52856037e-01f, -6.96525648e-02f, -1.60793275e-01f, 1.14061367e-02f, 1.50492147e-01f, 2.30451822e-01f, 9.93419513e-02f, 1.62753195e-01f, 8.24476928e-02f, 1.05389871e-01f,
  4.52721678e-02f, 7.45207965e-02f, 5.96740171e-02f, -2.94911936e-02f, 2.36021057e-01f, -7.11687133e-02f, -6.90314323e-02f, -2.00138316e-01f, -1.58706874e-01f, -5.65156080e-02f,
  7.65541643e-02f, 7.87119716e-02f, 1.12905212e-01f, -1.23114616e-01f, -1.47432581e-01f, 1.11358605e-01f, 3.80486846e-01f, -4.78126369e-02f, -9.79505926e-02f, -8.31857249e-02f,
  -6.60801455e-02f, 1.59176961e-01f, 2.14433949e-02f, 2.25406792e-02f, 1.35185141e-02f, -1.07271068e-01f, -1.43311676e-02f, -1.16633512e-01f, 6.50403053e-02f, -2.07924526e-02f,
  7.12778792e-02f, -8.95022526e-02f, 1.45616040e-01f, 1.47748157e-01f, 1.03980444e-01f, -8.96314457e-02f, 1.43531635e-01f, -1.51276514e-01f, 9.77586061e-02f, 3.60744409e-02f,
  -7.06458557e-03f, -1.74293723e-02f, -1.23771146e-01f, 6.83734491e-02f, -1.31604493e-01f, 1.00490868e-01f, 1.08328506e-01f, -7.80412406e-02f, 8.26432034e-02f, 5.84602216e-03f,
  -4.87525389e-02f, 1.86644584e-01f, -5.14189899e-02f, 4.50036675e-02f, 1.36131212e-01f, -5.48472591e-02f, 6.99854195e-02f, 1.63717166e-01f, 7.08476827e-02f, 2.07168996e-01f,
  1.95326209e-01f, 2.58947819e-01f, 1.33385003e-01f, 2.51395881e-01f, 1.38985906e-02f, 3.40289287e-02f, 1.92682818e-01f, -1.78544387e-01f, 1.09109022e-01f, 3.02260548e-01f,
  -3.23217548e-02f, 1.81616008e-01f, 1.16300374e-01f, -2.92825550e-01f, 2.62095593e-02f, 3.71454582e-02f, 8.02316740e-02f, 1.11707039e-01f, -1.14099890e-01f, -1.64894432e-01f,
  2.54587084e-01f, -6.98537678e-02f, -1.71192437e-02f, 1.44873038e-02f, 5.01421876e-02f, 8.98184925e-02f, 8.09751973e-02f, -3.51755670e-03f, 3.79208118e-01f, -3.70756127e-02f,
  1.77344844e-01f, 6.98134229e-02f, -4.27648723e-02f, -1.65681764e-02f, 3.86120602e-02f, 1.61256865e-01f, -6.26202822e-02f, -3.41885239e-02f, 7.15316907e-02f, 3.68965156e-02f,
  8.00339282e-02f, 2.03240573e-01f, 2.54151076e-01f, -1.57495275e-01f, -6.78313524e-02f, -2.64060885e-01f, 1.24647692e-01f, -2.28903487e-01f, -1.55346394e-01f, 1.56268105e-01f,
  6.78254515e-02f, -2.40191847e-01f, -8.61588567e-02f, 1.96399286e-01f, -5.45182005e-02f, -2.59553701e-01f, -5.58460839e-02f, -5.48938774e-02f, 8.21743086e-02f, -1.80857405e-01f,
  9.71863344e-02f, 1.30196795e-01f, 2.02607557e-01f, 1.39845079e-02f, 1.07985690e-01f, 1.25281960e-01f, 1.44237369e-01f, 8.04798380e-02f, -2.42683422e-02f, 1.01106241e-01f,
  -9.22296289e-03f, -1.19559467e-01f, 2.08821684e-01f, -8.91914070e-02f, 1.61800578e-01f, 8.39899480e-02f, -1.57757625e-01f, 1.41066447e-01f, 2.58700073e-01f, 5.06026857e-02f,
  2.28999749e-01f, -2.23934710e-01f, -7.29498938e-02f, 6.13695867e-02f, 1.88757613e-01f, 2.57578399e-02f, -8.41996744e-02f, -2.07182914e-01f, 7.27948025e-02f, 2.21111462e-01f,
  1.73655704e-01f, 6.94359019e-02f, 5.37453278e-04f, 3.88843231e-02f, 9.52187777e-02f, 8.48676935e-02f, 2.08133608e-01f, 1.08626902e-01f, 1.10259578e-01f, -1.16375484e-01f,
  1.53333366e-01f, 1.36068001e-01f, 2.20365047e-01f, -1.69817626e-01f, 1.59109697e-01f, -2.88514718e-02f, -1.87281352e-02f, -1.92455743e-02f, 9.21251774e-02f, 5.07849269e-02f,
  -1.93373770e-01f, 2.95620948e-01f, -1.51180759e-01f, -5.58001809e-02f, -8.78952593e-02f, 1.62652358e-01f, 7.48608783e-02f, 1.14926584e-01f, -6.62640780e-02f, 3.09228808e-01f,
  4.26162221e-03f, 2.34826207e-01f, 6.37939647e-02f, -3.32348235e-02f, 1.72208771e-01f, 1.12598412e-01f, -5.39184101e-02f, -2.65610553e-02f, 1.12272106e-01f, -1.53761953e-01f,
  1.09252147e-01f, 4.50609364e-02f, 1.74886867e-01f, -2.31359787e-02f, -1.04041874e-01f, -5.50071262e-02f, 5.31635359e-02f, -5.50877415e-02f, 1.13028243e-01f, 1.59849778e-01f,
  -6.35036919e-03f, 8.09984058e-02f, 1.15265377e-01f, -2.01895699e-01f, -1.18512459e-01f, -5.26023172e-02f, 3.03415265e-02f, 3.08928825e-02f, 3.41195971e-01f, 6.83681900e-03f,
  1.20980879e-02f, 2.65975088e-01f, -2.80256886e-02f, 1.64185479e-01f, -2.38808423e-01f, 5.04340194e-02f, 1.02697022e-01f, -5.58281653e-02f, 1.76937822e-02f, 1.88704103e-01f,
  1.28142446e-01f, 4.00709957e-02f, 7.90796205e-02f, -5.75038493e-02f, -1.04170777e-01f, 1.19502708e-01f, 1.55909508e-01f, -2.13807330e-01f, 1.43760415e-02f, 3.72386128e-02f,
  -6.29657730e-02f, -1.96751758e-01f, 6.53248727e-02f, -3.33880752e-01f, 7.42844446e-03f, 4.47802432e-02f, 1.16815381e-01f, -5.75061031e-02f, -6.21360168e-02f, -4.95323017e-02f,
  1.08293749e-01f, 2.44037017e-01f, -6.67525753e-02f, 1.62778750e-01f, 8.74073952e-02f, 3.89309786e-02f, -1.08377844e-01f, 6.82909191e-02f, 1.25803292e-01f, 8.25718567e-02f,
  7.49540254e-02f, -1.09728307e-01f, 1.42455086e-01f, 3.31449211e-02f, -5.63913248e-02f, 7.48334676e-02f, 3.38204689e-02f, -7.40484446e-02f, -1.15525588e-01f, -1.45263234e-02f,
  -7.54593592e-03f, -1.52719185e-01f, 2.56631318e-02f, 1.06911160e-01f, -5.23184799e-02f, -5.55109344e-02f, -1.62373409e-01f, -1.89410578e-02f, -6.00755811e-02f, 4.26895693e-02f,
  1.67032734e-01f, -7.21900165e-02f, -1.87901501e-02f, 7.43797868e-02f, 1.48372263e-01f, 2.36524925e-01f, -5.89191988e-02f, 4.70292158e-02f, 3.67245451e-02f, -8.78631920e-02f,
  -1.74754649e-01f, -1.07167527e-01f, 4.29154597e-02f, 1.23652175e-01f, 9.83951800e-03f, 1.73389390e-01f, -8.81398246e-02f, -2.68296570e-01f, 6.87005818e-02f, -1.37488917e-01f,
  -4.54961471e-02f, -9.93530303e-02f, 7.14196786e-02f, 6.61883950e-02f, -9.58824977e-02f, 1.26908228e-01f, -6.44105822e-02f, -1.30777389e-01f, 1.39662132e-01f, -1.40279010e-01f,
  6.84840009e-02f, -8.00668970e-02f, 6.85825646e-02f, -2.46592864e-01f, 1.04282178e-01f, -9.65479016e-02f, 4.08543423e-02f, 2.75375377e-02f, 9.56013352e-02f, -1.45297736e-01f,
  -1.57428451e-03f, -7.00893328e-02f, 2.36619040e-01f, 1.61593586e-01f, 4.87822480e-02f, 5.73685803e-02f, -1.61621660e-01f, 2.10450753e-03f, 1.03442393e-01f, 3.67647298e-02f,
  -8.43224972e-02f, 5.67861414e-03f, 5.58952317e-02f, -2.38604724e-01f, 7.49545544e-02f, -2.51600752e-03f, 5.80020621e-03f, -2.24389359e-01f, -7.84039125e-03f, -1.68837920e-01f,
  -2.80876607e-01f, 4.66238469e-01f, -4.96140681e-02f, 3.41749042e-02f, 1.50949553e-01f, -3.23464632e-01f, 9.98488218e-02f, 5.96424527e-02f, 8.96352977e-02f, -1.27874866e-01f,
  2.05633208e-01f, -1.37407124e-01f, 2.41322026e-01f, 4.59498689e-02f, 1.99249126e-02f, 1.74122900e-01f, 7.14647770e-02f, -7.51379654e-02f, -1.37454897e-01f, 1.06874697e-01f,
  1.58291422e-02f, -1.47238135e-01f, 1.62156165e-01f, -1.62626058e-02f, -1.19340613e-01f, 2.78488770e-02f, 3.69216949e-02f, -1.59712866e-01f, 2.40471009e-02f, 2.20884234e-02f,
  6.75849169e-02f, 3.31443965e-01f, 1.77810609e-01f, 1.89522058e-02f, 1.00668967e-01f, -7.67134428e-02f, 1.19398437e-01f, -5.32937013e-02f, 1.21088192e-01f, -7.29111433e-02f,
  3.33802402e-01f, 1.46923959e-01f, 2.00616792e-01f, -1.02081046e-01f, 2.22566947e-01f, 2.52281785e-01f, 1.53855324e-01f, 3.25231612e-01f, 1.35322109e-01f, 1.08900391e-01f,
  -1.35277748e-01f, 8.40298384e-02f, 8.35982338e-02f, -1.92553420e-02f, 4.61157858e-02f, 9.27409679e-02f, 1.14169128e-01f, -3.46233174e-02f, 1.52903982e-02f, 2.05225468e-01f,
  8.92992243e-02f, 1.37235731e-01f, -2.23939046e-02f, -1.51508227e-01f, -1.04192354e-01f, -5.09759337e-02f, 1.01054244e-01f, 1.13338754e-01f, -5.47346193e-03f, -9.57194716e-03f,
  1.58752814e-01f, -2.42920360e-03f, 1.57042712e-01f, -3.91149148e-02f, -7.42219910e-02f, 7.23885372e-02f, 5.96880689e-02f, 3.37891430e-02f, 4.22649652e-01f, -1.52165800e-01f,
  1.12176359e-01f, -5.42290844e-02f, 4.90001030e-02f, -8.18391517e-02f, 5.94086014e-02f, 3.44390273e-01f, -1.19019086e-02f, 1.06030069e-01f, 1.47045821e-01f, -2.47147337e-01f,
  8.88928920e-02f, 2.16772676e-01f, 1.60096716e-02f, -2.55351305e-01f, -2.00042054e-02f, -2.97819495e-01f, -1.00004867e-01f, -1.34070469e-02f, 8.26375261e-02f, 2.35833943e-01f,
  1.00012422e-01f, -1.13466494e-01f, 8.61102045e-02f, 1.21021047e-01f, 8.57780054e-02f, 1.05774656e-01f, -1.15511179e-01f, -2.86689792e-02f, -1.07312441e-01f, 1.68582648e-01f,
  -4.48462926e-02f, -1.44044623e-01f, -4.37868945e-02f, 3.79513465e-02f, 2.44318005e-02f, 1.01634495e-01f, -4.00386471e-03f, 1.09577246e-01f, 2.56928988e-02f, -4.34029941e-03f,
  1.78984508e-01f, -7.22746551e-02f, 1.14714779e-01f, -8.10532346e-02f, 7.10978210e-02f, -1.91843919e-02f, -6.44398257e-02f, -1.01724543e-01f, 9.86968130e-02f, 3.41407359e-02f,
  2.49963149e-01f, 2.17735972e-02f, -3.74516919e-02f, 1.96930990e-01f, 1.36018783e-01f, 2.04161108e-01f, -1.05263464e-01f, -7.78138116e-02f, -8.71261060e-02f, 2.43184671e-01f,
  9.76637602e-02f, 1.40258923e-01f, -8.41475949e-02f, 1.63591981e-01f, 9.63625312e-02f, 2.15723470e-01f, 6.59690425e-02f, 2.56043971e-01f, -4.70983274e-02f, -1.28690926e-02f,
  2.18803287e-01f, 4.48060632e-02f, 1.90520436e-01f, -3.62776220e-02f, 1.97145879e-01f, -9.57109928e-02f, 2.45433673e-01f, 2.28544578e-01f, 1.16099454e-01f, -2.00299412e-01f,
  2.03522116e-01f, -1.94340348e-02f, -1.87817499e-01f, -5.68225719e-02f, -1.26641504e-02f, -9.25316513e-02f, -9.33812261e-02f, 2.08381236e-01f, -1.16478257e-01f, -8.95143822e-02f,
  3.20064835e-02f, 1.75260678e-01f, 2.90236086e-01f, -8.08546618e-02f, 2.84275502e-01f, 1.37386963e-01f, -8.87344554e-02f, -7.32621411e-03f, -2.54498720e-02f, 4.00231294e-02f,
  1.73963368e-01f, 1.16289474e-01f, -2.32738666e-02f, 3.99380103e-02f, 4.00714763e-03f, -9.43335295e-02f, -7.64640234e-03f, -1.60386398e-01f, -1.17866509e-01f, -2.27658689e-01f,
  -3.61288600e-02f, 6.68042675e-02f, 1.78079918e-01f, -2.41330594e-01f, -3.53401937e-02f, 1.54915527e-01f, 6.77821040e-02f, -9.55324098e-02f, 3.49613994e-01f, 3.10157705e-02f,
  -4.60716337e-02f, -5.17651364e-02f, -1.73438817e-01f, -4.18049395e-02f, -6.43084943e-02f, -1.47743896e-01f, -2.54923552e-01f, -1.93674445e-01f, -1.20248884e-01f, 2.43906945e-01f,
  5.33058718e-02f, 2.38272846e-02f, -2.43140757e-02f, -2.36503005e-01f, 1.65564060e-01f, 3.54135484e-02f, -6.56225979e-02f, -2.13592604e-01f, 1.98240727e-01f, -2.84005910e-01f,
  -7.43691251e-02f, -2.21606404e-01f, -1.70061752e-01f, -1.32329211e-01f, -2.32945397e-01f, 1.44576520e-01f, -5.56642264e-02f, 1.55566521e-02f, 1.16532035e-01f, 2.83227321e-02f,
  1.45304233e-01f, -8.32956359e-02f, 2.65923768e-01f, 3.58155221e-01f, 1.44332677e-01f, 8.81102234e-02f, -1.21433279e-02f, 9.84504297e-02f, 2.07413569e-01f, -3.89168561e-02f,
  -2.05731932e-02f, 1.66060790e-01f, -6.37296448e-03f, 5.11200242e-02f, 2.15237841e-01f, 2.42155656e-01f, 1.31671444e-01f, 7.57360272e-03f, 1.46656394e-01f, 4.60549723e-03f,
  -1.83883131e-01f, 7.89560378e-02f, -7.80262202e-02f, 1.23736046e-01f, 1.42882854e-01f, -1.68108746e-01f, -8.35836083e-02f, 2.09784717e-03f, -1.85166728e-02f, -1.63622722e-01f,
  1.67908743e-01f, 2.22811066e-02f, -1.97205842e-01f, -8.44688527e-03f, 2.57685632e-02f, 1.47479758e-01f, -7.23178238e-02f, 1.28609031e-01f, -1.80422798e-01f, 3.44607830e-02f,
  -2.52093468e-02f, -1.56767622e-01f, 1.40684135e-02f, -4.28850800e-02f, 1.31170927e-02f, -3.92953046e-02f, 4.43972498e-02f, 3.32841575e-02f, 4.75977585e-02f, 6.33829087e-02f,
  -1.04945362e-01f, 1.74096912e-01f, -1.23089582e-01f, 2.09244192e-02f, -2.98901014e-02f, 1.68950781e-01f, 1.15488889e-02f, -6.16216585e-02f, 1.69418097e-01f, 1.09265773e-02f,
  2.11408615e-01f, 2.13951871e-01f, -1.07198276e-01f, -4.91378382e-02f, -1.66571558e-01f, 2.32436564e-02f, -1.43521652e-01f, -1.00548498e-01f, -8.80575329e-02f, 4.15390804e-02f,
  -2.42157206e-01f, -3.28701474e-02f, -1.42263904e-01f, -1.19273536e-01f, -1.49511406e-02f, 2.52666861e-01f, -4.57974747e-02f, 5.08852340e-02f, 9.59014744e-02f, 1.56418204e-01f,
  -6.05100542e-02f, 1.77156329e-01f, -8.54577795e-02f, -8.96408111e-02f, -1.73346445e-01f, -2.49804065e-01f, 1.10870516e-02f, -3.12767208e-01f, 8.62818956e-02f, 4.41813022e-02f,
  1.41582102e-01f, 3.14315587e-01f, 9.63693336e-02f, -1.31624982e-01f, 1.79891929e-01f, 8.18278491e-02f, -2.02157736e-01f, 1.50966361e-01f, 2.33429819e-02f, 3.63404043e-02f,
  1.87013090e-01f, 3.82399596e-02f, 1.93530396e-01f, 1.22365348e-01f, -2.37361625e-01f, -8.68775845e-02f, -1.49305016e-01f, -2.82362223e-01f, -1.28083423e-01f, -1.86685294e-01f,
  9.71275941e-02f, -9.58588272e-02f, 1.64286956e-01f, -5.11092730e-02f, -1.37610868e-01f, 3.30580026e-01f, 8.06034878e-02f, -2.04196014e-02f, 3.22097205e-02f, 1.65712655e-01f,
  2.07331300e-01f, 2.05736294e-01f, -2.68100560e-01f, 2.50907373e-02f, -2.03491613e-01f, -4.06635851e-02f, -1.58220395e-01f, 1.02607444e-01f, 9.22535062e-02f, -2.56855786e-01f,
  -7.74851963e-02f, 4.39225370e-03f, -2.24107683e-01f, -4.85203378e-02f, 2.77927935e-01f, -2.37207308e-01f, -1.60716906e-01f, 1.49026752e-01f, 6.03700336e-03f, 5.97962253e-02f,
  -6.06051013e-02f, 1.11733777e-02f, -3.16611901e-02f, 3.25110890e-02f, -4.63073440e-02f, 1.69379711e-01f, 4.42686975e-02f, 1.43071160e-01f, 1.08513888e-02f, 2.72114366e-01f,
  -1.40093118e-01f, -5.67825623e-02f, 6.01127036e-02f, 6.44059479e-02f, 1.83514193e-01f, -1.53428063e-01f, -6.83477446e-02f, 2.01921970e-01f, -1.05362199e-01f, 1.29001305e-01f,
  2.41102740e-01f, 8.03417247e-03f, 9.87597704e-02f, 1.93265811e-01f, -2.09291160e-01f, -6.57991916e-02f, -1.14663415e-01f, -4.46004830e-02f, 1.96031645e-01f, -8.51146728e-02f,
  1.71947870e-02f, 2.10101709e-01f, 5.63276038e-02f, 3.95829119e-02f, -1.18824244e-02f, 2.55402505e-01f, -6.32942691e-02f, 4.61687148e-02f, 9.91837680e-02f, -1.22573808e-01f,
  1.71884269e-01f, -7.11891055e-02f, -8.94562379e-02f, -1.92747295e-01f, -2.49165744e-02f, 3.42031568e-02f, -1.53024703e-01f, 2.25432273e-02f, -8.55671093e-02f, -6.80817366e-02f,
  2.53710747e-01f, 8.04762989e-02f, 5.92641048e-02f, 1.08110651e-01f, 1.72081932e-01f, 1.31773531e-01f, 9.32395756e-02f, 3.35680172e-02f, -1.46511942e-01f, 5.12464019e-03f,
  7.92909265e-02f, -1.73121452e-01f, 2.65617929e-02f, -7.46958479e-02f, 1.09175660e-01f, 1.16466276e-01f, -1.19431928e-01f, 1.50996685e-01f, 2.54512709e-02f, -4.74228673e-02f,
  -9.60248560e-02f, -2.02264078e-02f, 4.19248231e-02f, -2.92534996e-02f, -4.69583422e-02f, 1.39928356e-01f, 1.36175424e-01f, -2.27293670e-01f, 8.48154798e-02f, -9.14331153e-02f,
  -3.24224494e-02f, -2.36220464e-01f, 3.20329964e-02f, -2.03183845e-01f, 1.19908348e-01f, 3.22707385e-01f, -4.25253138e-02f, 3.43155503e-01f, -1.84072673e-01f, 1.31477052e-02f,
  2.99218949e-02f, -1.90837622e-01f, 1.53821200e-01f, 1.61500826e-01f, -1.89040303e-02f, 3.60965282e-02f, 5.18871695e-02f, 2.21622154e-01f, -1.29776895e-01f, -2.61038482e-01f,
  -1.43878251e-01f, 2.00224966e-01f, 7.32002333e-02f, 5.28852493e-02f, 2.09741950e-01f, -3.68517548e-01f, 1.63164541e-01f, 5.65087572e-02f, -1.60679474e-01f, -1.74984038e-01f,
  3.29054624e-01f, -1.86331838e-01f, 8.71188194e-03f, -2.03643143e-02f, -1.50943428e-01f, -1.87381998e-01f, 1.90306395e-01f, -5.43207973e-02f, -1.47738025e-01f, -3.03192973e-01f,
  2.42174808e-02f, -8.14012662e-02f, 7.93609694e-02f, -2.36055881e-01f, 2.23153532e-01f, 2.29658350e-01f, 1.14470825e-01f, 2.44450524e-01f, 2.62281671e-02f, 9.34307575e-02f,
  1.38893127e-01f, 1.71521321e-01f, 2.06674397e-01f, 1.38129324e-01f, 1.95320070e-01f, 5.18599972e-02f, 8.01923722e-02f, 3.23958278e-01f, -6.32347390e-02f, 8.06937590e-02f,
  7.85972103e-02f, -4.58756760e-02f, 1.28432468e-01f, -1.44932002e-01f, 1.16478764e-01f, 1.65424701e-02f, -1.10037982e-01f, -1.71875820e-01f, 1.22013666e-01f, -5.63383363e-02f,
  -4.14270498e-02f, -1.15680844e-01f, 1.22626154e-02f, 3.33240926e-01f, -8.28251317e-02f, 4.31130379e-02f, 3.18896979e-01f, -2.44586661e-01f, 2.59185404e-01f, 2.71171257e-02f,
  1.42093292e-02f, -3.32185179e-02f, 1.31279444e-02f, 2.87304431e-01f, -6.95630535e-02f, -2.67754011e-02f, 1.29917279e-01f, -3.52326110e-02f, 1.21518569e-02f, 3.99886996e-01f,
  -5.10248244e-02f, -8.50788951e-02f, 4.83764000e-02f, -2.52849221e-01f, -2.65095755e-02f, -2.49670427e-02f, -1.56382620e-01f, 1.72337130e-01f, -7.50401020e-02f, -5.95206693e-02f,
  1.03336431e-01f, 3.42126638e-01f, -3.00614126e-02f, -1.72467649e-01f, -5.07166795e-03f, -9.90337580e-02f, 3.14657320e-03f, -8.91297385e-02f, 6.95326999e-02f, 6.62432462e-02f,
  -5.99209405e-03f, -4.60336991e-02f, 5.77534214e-02f, -8.12399611e-02f, 1.45965647e-02f, 3.08874156e-02f, -7.52721578e-02f, -6.64202794e-02f, -1.20946527e-01f, 1.16321579e-01f,
  -1.37365162e-02f, 3.77829075e-02f, 3.14565480e-01f, 2.09620774e-01f, -1.85088590e-01f, -1.05642127e-02f, 1.15342058e-01f, -2.01451138e-01f, 4.00050461e-01f, -2.44409710e-01f,
  2.54336111e-02f, -3.31477076e-02f, -2.32757673e-01f, -5.17271757e-02f, -5.30877635e-02f, -1.82236761e-01f, 3.95372584e-02f, 1.37783706e-01f, 6.77260943e-03f, 2.94426501e-01f,
  -2.11771533e-01f, 1.83201373e-01f, 2.68323660e-01f, 4.95599620e-02f, 9.83083025e-02f, 1.65533617e-01f, -1.13872513e-01f, 1.03161084e-02f, 2.15970635e-01f, -1.83368236e-01f,
  6.79347143e-02f, -1.49666473e-01f, -6.95278570e-02f, 5.72524294e-02f, 2.19351456e-01f, 2.62812227e-01f, 2.26481706e-01f, 4.19582315e-02f, 8.76031294e-02f, 1.09093189e-01f,
  -3.56825404e-02f, -3.32479924e-02f, -1.27388060e-01f, -6.23518229e-02f, -5.05647482e-03f, 2.28767723e-01f, 1.08600147e-01f, -1.10999025e-01f, 5.95796742e-02f, 1.90250605e-01f,
  2.09085971e-01f, -8.96247197e-03f, -1.42793551e-01f, -5.42775951e-02f, 1.29825681e-01f, 1.44188553e-01f, -6.14091530e-02f, 3.02287221e-01f, 1.78251699e-01f, 2.90835649e-01f,
  1.66643634e-01f, 9.35270712e-02f, 1.62403017e-01f, 5.44890622e-03f, -1.37998492e-01f, -2.92046051e-02f, -3.93669873e-01f, 4.09089737e-02f, 2.97936112e-01f, 8.65801200e-02f,
  7.38985613e-02f, 3.08436722e-01f, -2.71651715e-01f, -8.54991302e-02f, -8.25491995e-02f, -1.81210175e-01f, 1.55828103e-01f, 8.17898363e-02f, -6.89777918e-03f, 3.11521769e-01f,
  2.05335408e-01f, 1.77435696e-01f, -1.08914539e-01f, -2.12719485e-01f, 2.74437815e-01f, 1.65153667e-02f, 6.43488243e-02f, -1.48309529e-01f, -4.73971739e-02f, -1.32563755e-01f,
  -9.74620208e-02f, 1.42247034e-02f, -1.41204044e-01f, 1.01760276e-01f, -2.71894783e-02f, 3.29157591e-01f, -8.34258869e-02f, 1.66861027e-01f, -8.98613222e-03f, 6.42701015e-02f,
  -6.36546165e-02f, 8.19080546e-02f, 8.36803392e-02f, -1.40872747e-02f, -1.32903174e-01f, 2.16449022e-01f, -7.67466202e-02f, 1.00251168e-01f, 1.39398918e-01f, 6.20564520e-02f,
  3.69749106e-02f, -2.05785349e-01f, -1.78266183e-01f, -4.29639697e-01f, -1.09407075e-01f, -2.68775523e-01f, 1.20484792e-01f, 6.11814857e-02f, 1.21330462e-01f, 2.33941358e-02f,
  4.45048176e-02f, -6.13405742e-02f, -1.86475646e-03f, 5.32057583e-02f, 1.03087224e-01f, 1.84979811e-01f, 1.31946281e-01f, -1.04652666e-01f, -9.18326676e-02f, 1.84199914e-01f,
  -1.72494963e-01f, 9.70311314e-02f, 1.03923112e-01f, -8.86483341e-02f, -1.03767626e-01f, 1.55129999e-01f, -2.16827929e-01f, -8.29918832e-02f, 8.55322033e-02f, -1.13605835e-01f,
  1.28102288e-01f, 1.16142847e-01f, 1.70348614e-01f, 1.14878520e-01f, -5.33591316e-04f, 2.71957904e-01f, 5.30938692e-02f, -1.21942610e-01f, 6.27640858e-02f, 7.19594434e-02f,
  8.26571137e-02f, -8.86528566e-02f, 9.52141285e-02f, 4.46243510e-02f, -2.20952034e-01f, 1.94773480e-01f, 1.00490414e-01f, 5.25656678e-02f, -7.23028705e-02f, 9.49706882e-02f,
  -9.83866826e-02f, 1.46765023e-01f, -1.46351203e-01f, 3.13252389e-01f, -9.31963846e-02f, 2.18644086e-02f, 2.26103976e-01f, 5.25502041e-02f, -3.05054989e-02f, 4.95161638e-02f,
  -3.23769287e-03f, 1.26942068e-01f, 7.08075911e-02f, 2.17716411e-01f, -2.09608242e-01f, -1.53086618e-01f, -9.61293876e-02f, -1.99074447e-01f, -1.28761932e-01f, -8.14975873e-02f,
  -8.05032998e-02f, -2.24457875e-01f, 8.96794721e-02f, 1.73941284e-01f, -3.87537293e-02f, -2.78421994e-02f, 1.56855211e-01f, 1.31823853e-01f, -1.26194373e-01f, 1.02159254e-01f,
  -8.70193765e-02f, 4.16825116e-02f, -1.06243864e-01f, -1.93670258e-01f, -5.75783476e-02f, -1.82801038e-01f, 4.60682660e-02f, -9.83002875e-03f, 1.35266036e-01f, -1.75360069e-02f,
  5.38999327e-02f, -1.38765022e-01f, 6.30618678e-03f, 1.84648484e-01f, 3.74960639e-02f, 5.13174124e-02f, -2.69248262e-02f, -7.81397596e-02f, 1.48509875e-01f, 7.24853110e-03f,
  4.55407016e-02f, -9.35381372e-03f, -6.45247847e-02f, -6.65262640e-02f, -1.55717447e-01f, -1.42071337e-01f, -3.40613350e-02f, -8.38133544e-02f, 6.70566931e-02f, 2.39657518e-02f,
  2.32840911e-01f, 1.84310488e-02f, -2.16838699e-02f, 1.95719287e-01f, -1.63993407e-02f, -1.22403964e-01f, -3.26928385e-02f, 2.15654224e-02f, 1.47378236e-01f, 9.37029198e-02f,
  -2.39581406e-01f, -8.07482190e-03f, -1.00853182e-01f, 2.32139360e-02f, -9.58887041e-02f, 2.68174261e-01f, 5.13655432e-02f, -1.29824653e-01f, -3.76482680e-03f, 2.29849339e-01f,
  -1.25234395e-01f, 2.21839041e-01f, 1.34273797e-01f, -1.13887459e-01f, -1.68177560e-01f, 1.49985757e-02f, -5.73715055e-03f, 6.38977066e-02f, -4.34056446e-02f, 2.54725039e-01f,
  3.61974537e-01f, 1.05707660e-01f, 4.84720425e-04f, 1.06041297e-01f, 1.56668127e-01f, -6.85405284e-02f, -2.65944935e-02f, 2.06825882e-01f, 5.57706575e-04f, 2.29380623e-01f,
  -2.82296926e-01f, -1.44837797e-01f, -2.93363482e-02f, 1.31991670e-01f, 9.64624211e-02f, -6.94442391e-02f, -1.17130749e-01f, -1.23950757e-01f, 9.95109156e-02f, -1.79517686e-01f,
  1.46134064e-01f, -1.09796748e-01f, 1.01224087e-01f, 5.26905507e-02f, 2.34591633e-01f, 2.90541172e-01f, 1.84659421e-01f, -1.34931341e-01f, 1.48355603e-01f, -1.43883422e-01f,
  -2.81958506e-02f, -2.21594870e-01f, 2.47475952e-01f, 3.32565367e-01f, -3.32736373e-02f, 9.07617360e-02f, -6.43608049e-02f, -2.41120532e-01f, -4.28315997e-02f, 3.23411912e-01f,
  8.63168314e-02f, -3.44428606e-02f, 1.40828341e-01f, 9.17504579e-02f, -8.86011124e-02f, -7.90685322e-03f, 3.42462622e-02f, 1.84803486e-01f, 1.07806802e-01f, -1.79885179e-01f,
  -2.47289553e-01f, 7.49215260e-02f, -2.32568204e-01f, 5.72278872e-02f, 6.15101382e-02f, -8.90757665e-02f, 1.33976936e-01f, 6.20430484e-02f, -2.84943711e-02f, 3.33713852e-02f,
  1.58322155e-01f, -7.32915774e-02f, 1.19273581e-01f, -4.12688218e-02f, -1.40441909e-01f, 3.65095586e-02f, -6.71636686e-02f, -1.37572676e-01f, -1.43549547e-01f, -4.09472026e-02f,
  6.27390295e-02f, -3.04640025e-01f, 8.24237391e-02f, -2.44472429e-01f, -1.25259683e-01f, -4.13916074e-02f, -1.60443202e-01f, 1.93005502e-02f, 6.45414889e-02f, -1.58220738e-01f,
  5.48147112e-02f, -1.60022587e-01f, -2.54189730e-01f, 2.59978861e-01f, 4.94256662e-03f, -7.07372557e-04f, 1.88565291e-02f, -4.45045270e-02f, 2.15219483e-01f, -9.96938571e-02f,
  -3.53907555e-01f, 2.60405354e-02f, 1.70348257e-01f, 1.39204174e-01f, 9.97346118e-02f, 1.59916624e-01f, -6.44422844e-02f, -2.32419804e-01f, 9.90589038e-02f, -6.07517585e-02f,
  -6.42990470e-02f, -1.03373833e-01f, -2.63707265e-02f, -2.53318697e-01f, 2.11812660e-01f, 2.98898339e-01f, -6.32552132e-02f, 7.72686861e-03f, 8.19365904e-02f, -1.57983094e-01f,
  -1.28384665e-01f, 6.13238253e-02f, 9.41379294e-02f, -3.21028382e-02f, 4.55691433e-03f, -7.30978698e-02f, -1.40378937e-01f, -4.69489917e-02f, -6.40145168e-02f, -5.89279123e-02f,
  1.00650005e-01f, 1.14186719e-01f, 1.81761920e-01f, 1.60798192e-01f, 2.13813204e-02f, -5.30114993e-02f, 5.87228127e-02f, 5.08056208e-03f, 2.17432734e-02f, 1.09211281e-01f,
  1.05370106e-02f, -1.25277676e-02f, 8.20216984e-02f, -2.30680123e-01f, 1.16880462e-01f, -5.11225984e-02f, 4.94202657e-04f, -1.90824550e-03f, 7.68490732e-02f, -3.93337965e-01f,
  -7.81596527e-02f, -1.56357855e-01f, -2.18958154e-01f, 3.23349275e-02f, 5.46265915e-02f, -2.97296703e-01f, 9.68621150e-02f, 1.80784866e-01f, 7.26341456e-02f, 3.58857393e-01f,
  8.87676515e-03f, 1.11318491e-02f, 1.13687262e-01f, -6.76071197e-02f, 1.31385282e-01f, 1.50481582e-01f, 1.25834793e-01f, 6.12154752e-02f, 1.86933875e-01f, 1.24184854e-01f,
  -6.29792884e-02f, -1.73165157e-01f, -7.83775821e-02f, -1.56185059e-02f, -1.90554513e-03f, 2.48135757e-02f, 1.96437165e-01f, -2.00745766e-04f, 6.84964880e-02f, 5.23351319e-03f,
  -4.66291420e-02f, -2.03185137e-02f, 3.01498294e-01f, -3.14397961e-01f, 6.21496290e-02f, 2.02294551e-02f, -1.44654065e-01f, -1.63704202e-01f, 1.74772114e-01f, -2.39764005e-02f,
  1.36018679e-01f, -3.15991849e-01f, -1.21130824e-01f, -2.51388252e-01f, 1.19200237e-01f, 7.05191819e-03f, 3.76847148e-01f, 2.01973319e-01f, 5.41035235e-02f, -3.88374701e-02f,
  4.61640209e-02f, 4.00576964e-02f, -1.55308843e-03f, -2.24992633e-03f, 1.31939664e-01f, -1.29939578e-02f, -3.88717391e-02f, -9.62471142e-02f, -4.13793176e-01f, 2.85469025e-01f,
  -1.61834404e-01f, 2.01263964e-01f, 1.07751258e-01f, -9.59015265e-02f, 6.38881028e-02f, -1.82552785e-01f, -1.59224197e-01f, -2.77883351e-01f, -6.84815794e-02f, -9.40125212e-02f,
  -3.38917449e-02f, -1.98454075e-02f, 7.22228959e-02f, 4.50787306e-01f, -1.87513381e-01f, -1.77000403e-01f, 1.24628179e-01f, -6.65216148e-02f, 1.08554132e-01f, -1.52754098e-01f,
  1.93594266e-02f, -6.64906651e-02f, 9.41808224e-02f, 2.05290075e-02f, 1.20404236e-01f, 3.01819772e-01f, -1.13885239e-01f, -9.29317623e-03f, -2.56807923e-01f, 8.69919639e-03f,
  1.56625420e-01f, 4.15759720e-02f, -2.63094187e-01f, 1.32782519e-01f, -8.99808183e-02f, -2.45469779e-01f, 3.67006958e-02f, -7.10518435e-02f, 1.07737623e-01f, 1.30034164e-01f,
  1.36146381e-01f, -2.18485482e-02f, -1.45173848e-01f, -2.75645610e-02f, -2.61101842e-01f, -1.08882248e-01f, 1.26388269e-02f, -6.61095902e-02f, -1.12229645e-01f, -2.52174530e-02f,
  -2.28159904e-01f, -1.30571082e-01f, -6.59886524e-02f, -4.83029801e-03f, 2.24680573e-01f, 4.09535579e-02f, -8.69566947e-02f, 2.39391714e-01f, -4.50608134e-02f, -1.17015883e-01f,
  7.72856548e-02f, -1.06569357e-01f, 1.86079606e-01f, -1.56418025e-01f, -1.22550083e-02f, -3.42642469e-03f, -7.10741617e-03f, -1.66903779e-01f, -3.87449771e-01f, 3.98995029e-03f,
  -5.40982708e-02f, -4.93634418e-02f, 1.99331909e-01f, -3.67666185e-01f, -1.50740445e-01f, 2.70395607e-01f, 2.72431727e-02f, 2.52085567e-01f, 1.48363123e-02f, 8.31097215e-02f,
  4.83617634e-02f, -1.04515947e-01f, -8.06913972e-02f, 1.92342624e-01f, 1.69852614e-01f, 9.06093419e-03f, 6.19590133e-02f, 2.44433478e-01f, 2.13206075e-02f, -2.26170123e-01f,
  4.15788293e-02f, -2.70529538e-01f, -1.22062907e-01f, -3.36405411e-02f, -1.38968006e-01f, -1.07959360e-01f, -6.92927092e-02f, 8.36413577e-02f, -1.61640421e-01f, 2.41727047e-02f,
  4.20591801e-01f, -3.63729358e-01f, 2.80629359e-02f, 8.22666362e-02f, -6.06190562e-02f, -3.14382941e-01f, 1.70724213e-01f, 6.97313696e-02f, -9.76177156e-02f, -2.44199976e-01f,
  -4.14754897e-02f, -1.27865434e-01f, 1.45952046e-01f, 1.49029434e-01f, 2.32454225e-01f, 1.95114091e-01f, -2.37879623e-03f, 2.79962510e-01f, -1.07121952e-01f, 8.76288339e-02f,
  1.12638861e-01f, 7.82779679e-02f, 1.48421442e-02f, 9.29420292e-02f, -1.06404670e-01f, -1.77636519e-01f, -5.83155975e-02f, -8.53266120e-02f, 2.05723271e-02f, -1.52765006e-01f,
  1.95698559e-01f, 6.97350204e-02f, 1.59790918e-01f, 2.43029475e-01f, -3.50567773e-02f, -4.28152978e-02f, -2.37491466e-02f, -2.59250253e-02f, -6.81082830e-02f, -1.84297806e-03f,
  -5.47970869e-02f, -1.51286587e-01f, 9.59829614e-02f, -2.03937069e-01f, 1.25198424e-01f, 1.41115040e-01f, -8.45920444e-02f, -1.56561539e-01f, -1.83909804e-01f, -1.34864539e-01f,
  -1.27305493e-01f, -3.62401977e-02f, 4.79370728e-02f, 1.34050891e-01f, 4.89279591e-02f, 8.17382783e-02f, -9.03787464e-02f, 1.99805692e-01f, 1.83811381e-01f, 1.16741709e-01f,
  2.24228591e-01f, 5.77551350e-02f, 3.11802346e-02f, 3.22303474e-02f, -2.30204344e-01f, 2.01454058e-01f, -9.35952440e-02f, -1.36941047e-02f, 5.34153096e-02f, 2.61235476e-01f,
  9.52868685e-02f, -2.51432449e-01f, 1.36320665e-01f, 1.65060833e-01f, -1.46189898e-01f, 3.70660834e-02f, 1.13837473e-01f, 6.23035654e-02f, -1.12490475e-01f, -8.36764127e-02f,
  -1.29691899e-01f, -2.26713732e-01f, -1.02849446e-01f, -1.51000351e-01f, -3.03223342e-01f, 3.73925045e-02f, -1.38569653e-01f, 5.99804800e-03f, -1.67951122e-01f, 1.38095498e-01f,
  1.35698825e-01f, -3.90453227e-02f, -1.18279301e-01f, 3.75326760e-02f, -1.80705622e-01f, -1.22665942e-01f, 3.04037426e-02f, -1.72250103e-02f, -2.66409874e-01f, -1.18102193e-01f,
  7.08012059e-02f, -1.41977087e-01f, 6.72204345e-02f, 1.27237132e-02f, -3.06205451e-03f, 1.03260599e-01f, 1.40103400e-01f, -6.36308119e-02f, 1.53257504e-01f, -2.38893777e-02f,
  8.71937871e-02f, 1.71583027e-01f, 5.66603094e-02f, -3.17990854e-02f, 2.62408033e-02f, 8.82544965e-02f, -4.86379564e-02f, 2.11507715e-02f, -7.99407512e-02f, -5.59724495e-02f,
  -7.70909339e-02f, -5.96686713e-02f, -2.33763475e-02f, -1.32413179e-01f, -1.25279441e-01f, 4.77118269e-02f, -1.07878819e-01f, 6.13438822e-02f, 9.92879122e-02f, -1.56094342e-01f,
  -5.39871748e-04f, -3.18070911e-02f, 1.14314795e-01f, -1.41254887e-02f, 2.62682550e-02f, 8.12190026e-02f, -5.52887609e-03f, -6.17348030e-02f, 2.37863529e-02f, -3.32625546e-02f,
  -1.38486862e-01f, -1.10878907e-04f, -1.35997549e-01f, -2.62100101e-01f, -6.22766204e-02f, 9.58922505e-02f, 1.18423991e-01f, -4.46037054e-02f, 8.40476602e-02f, 1.31003439e-01f,
  5.29535934e-02f, -6.93521053e-02f, -5.59880137e-02f, 1.89786643e-01f, 3.93047705e-02f, -1.09787673e-01f, 2.59184897e-01f, 2.06667203e-02f, -2.35214412e-01f, -2.64700577e-02f,
  -1.08670937e-02f, -1.74789459e-01f, 2.37398803e-01f, -1.11258850e-01f, 1.88306153e-01f, -1.14129223e-01f, -3.15242887e-01f, -2.12333761e-02f, 9.33721066e-02f, -2.63304263e-01f,
  1.21126272e-01f, 5.36935553e-02f, 1.90391004e-01f, 2.31281176e-01f, -9.45709944e-02f, -3.63302864e-02f, 7.23539293e-02f, -8.35592225e-02f, 8.30033980e-03f, 1.57318681e-01f,
  5.73694706e-02f, 6.39542267e-02f, 2.06753820e-01f, -1.90477073e-01f, 9.32119563e-02f, -1.31191313e-01f, -2.01970249e-01f, 1.94945768e-01f, 1.66973069e-01f, 2.97008216e-01f,
  7.57457241e-02f, -4.81105335e-02f, 7.81770870e-02f, 8.38418007e-02f, -1.02764271e-01f, 6.35539070e-02f, -6.29027486e-02f, -7.95577392e-02f, 4.49587964e-02f, 2.33195513e-01f,
  -5.09691313e-02f, -1.07889682e-01f, 4.00515608e-02f, 1.38892263e-01f, 1.06267974e-01f, 1.34922519e-01f, -1.55228004e-01f, -7.60982558e-02f, 1.22976907e-01f, 5.73579445e-02f,
  6.85261041e-02f, -5.85085489e-02f, -5.58265336e-02f, 2.68886667e-02f, -6.76231980e-02f, 1.36924952e-01f, -4.48196344e-02f, 6.41834587e-02f, 6.77593201e-02f, -5.79203814e-02f,
  1.48377297e-02f, -1.29202142e-01f, 1.70389488e-01f, 1.12872228e-01f, 1.90491993e-02f, 7.36354440e-02f, -3.68542075e-01f, 3.92839015e-02f, -2.30463352e-02f, 7.25768432e-02f,
  9.79561657e-02f, 1.77765731e-02f, -1.03160106e-01f, 3.25365849e-02f, 9.90202799e-02f, -5.15686832e-02f, -1.75774917e-01f, -5.92047721e-02f, -4.65370938e-02f, -1.01213194e-01f,
  -3.33329327e-02f, -3.72362323e-02f, 1.51688591e-01f, -2.12487881e-03f, 5.20726256e-02f, 3.13988514e-02f, -4.21115048e-02f, 4.25618403e-02f, -7.77803063e-02f, 5.55540062e-02f,
  9.40597728e-02f, -5.03023230e-02f, 4.20682020e-02f, 1.55668050e-01f, -6.41183257e-02f, 1.10113539e-01f, -1.31437406e-01f, -2.11106986e-02f, -1.39737904e-01f, -1.39309168e-01f,
  -3.23439986e-02f, 3.30615401e-01f, 3.16983797e-02f, -6.55944049e-02f, 1.05355226e-01f, 1.23715185e-01f, 6.93520233e-02f, 1.14391685e-01f, -5.04391007e-02f, -1.37301013e-02f,
  -3.44762094e-02f, -1.36162937e-01f, -2.39123404e-01f, -2.55832467e-02f, -1.38981059e-01f, -2.40705207e-01f, -2.09505826e-01f, -6.64392412e-02f, 8.39955285e-02f, 3.67507823e-02f,
  -5.75328432e-03f, 4.25233170e-02f, 6.31788149e-02f, -4.20882404e-02f, -5.92288449e-02f, -1.85440227e-01f, -4.50512161e-03f, -2.60516978e-03f, 1.73834205e-01f, -6.04463480e-02f,
  -6.25351211e-04f, 6.87239096e-02f, 1.15833640e-01f, -1.36942908e-01f, -5.38141541e-02f, -1.06017128e-01f, 5.11480533e-02f, 3.07255634e-03f, -1.01481900e-02f, -4.07011732e-02f,
  4.28064577e-02f, 5.39226420e-02f, -3.31615776e-01f, -2.32667089e-01f, 6.58901632e-02f, 1.07409701e-01f, 2.54277140e-01f, 2.02818960e-02f, 1.48468958e-02f, -1.52965030e-02f,
  1.75637268e-02f, -5.59947304e-02f, 1.42577693e-01f, -1.24899812e-01f, 3.05785872e-02f, 2.60730535e-02f, 9.72107425e-02f, 1.72535218e-02f, 6.94664847e-03f, 5.97592816e-02f,
  -1.68612510e-01f, -1.45403385e-01f, 1.81701984e-02f, -1.26139507e-01f, 2.17922315e-01f, 1.22066826e-01f, 7.93251619e-02f, -1.53950989e-01f, 2.69791871e-01f, 1.61711857e-01f,
  1.04481414e-01f, -3.41859902e-03f, 5.12273284e-03f, -3.25283408e-02f, 2.40092352e-02f, 1.10532725e-02f, -4.14996557e-02f, 7.97841325e-02f, 1.61536425e-01f, -6.04181667e-04f,
  1.21421099e-01f, 1.51123881e-01f, 8.10956806e-02f, -1.13999657e-01f, 3.16108055e-02f, -1.19827971e-01f, -1.29216999e-01f, 1.27665445e-01f, -9.88402031e-03f, 1.42636061e-01f,
  -2.24370509e-01f, 1.12645235e-02f, -1.81617871e-01f, 3.97289097e-02f, -2.62653172e-01f, 7.79353827e-02f, 7.85131976e-02f, -1.22692965e-01f, 1.07805304e-01f, 9.34150128e-04f,
  1.11700378e-01f, -9.59659815e-02f, -2.47479603e-02f, -2.09589064e-01f, 2.71362551e-02f, 1.29930243e-01f, 2.80374616e-01f, -7.99590498e-02f, 3.34486216e-02f, 1.30956516e-01f,
  -3.79191269e-03f, 1.75203513e-02f, 7.33522605e-03f, 1.30590603e-01f, 1.12149753e-01f, 7.26283193e-02f, -9.09320340e-02f, -2.28212886e-02f, -5.29955095e-03f, 1.12288252e-01f,
  -2.57776201e-01f, -7.39977509e-02f, 1.40623609e-02f, 1.41429752e-01f, 1.05174176e-01f, 4.52820361e-02f, 2.03799874e-01f, 5.60000725e-02f, 2.17963219e-01f, -1.46463215e-02f,
  -2.04315796e-01f, 3.89086716e-02f, 4.55784127e-02f, 1.83332101e-01f, 5.59203811e-02f, 7.16363713e-02f, -1.96829382e-02f, 1.78812951e-01f, -8.88119414e-02f, -2.74263233e-01f,
  8.54845643e-02f, 6.51823124e-03f, 1.36506155e-01f, -1.03568688e-01f, -1.18694313e-01f, 1.54599518e-01f, 3.54650654e-02f, -1.62420735e-01f, -5.73400408e-02f, 9.29370373e-02f,
  1.12708464e-01f, -1.39279097e-01f, 1.61359891e-01f, 1.49152577e-01f, -2.04697531e-02f, -1.32419914e-01f, 4.86779213e-02f, 7.21931159e-02f, 6.36973605e-02f, -1.48258120e-01f,
  9.43401456e-02f, -6.40840679e-02f, 9.74293202e-02f, 1.31547853e-01f, 4.67637368e-02f, -9.50937569e-02f, 9.31165963e-02f, 1.64955646e-01f, 2.43387949e-02f, 3.03586554e-02f,
  -8.06149915e-02f, 6.25824779e-02f, 2.87060976e-01f, 1.37933493e-01f, 1.70462355e-01f, 1.57377601e-01f, -3.18524182e-01f, -2.00791821e-01f, 4.50242124e-02f, -1.02858409e-01f,
  -3.49681899e-02f, 2.63150409e-02f, -2.40703046e-01f, -1.89198628e-02f, 2.97103096e-02f, 9.91885439e-02f, -8.70752186e-02f, -9.20401514e-03f, 1.66016117e-01f, -1.00574709e-01f,
  -1.03180744e-02f, 1.90883577e-01f, 4.51459251e-02f, -2.57946253e-01f, -7.83463344e-02f, 1.16935208e-01f, -9.41244736e-02f, -1.41131833e-01f, 5.87838702e-02f, -7.53990263e-02f,
  1.51472703e-01f, -1.40570149e-01f, 1.90565020e-01f, 1.37893409e-01f, -8.04757029e-02f, 4.71136086e-02f, -8.63653198e-02f, -4.53885645e-02f, 4.61802930e-02f, -3.65460874e-04f,
  1.00817895e-02f, 2.42310718e-01f, -3.84277217e-02f, 1.22662574e-01f, 2.88385246e-02f, -1.17998086e-01f, -2.36766875e-01f, -8.19759145e-02f, -1.21012516e-01f, -2.07751002e-02f,
  1.48294298e-02f, -1.89845651e-01f, -5.57556674e-02f, 1.74650520e-01f, 5.62235862e-02f, 6.14432991e-02f, -2.29383446e-02f, 1.26773894e-01f, 1.31620010e-02f, -1.02658376e-01f,
  6.31186292e-02f, -1.24720968e-01f, -5.85358515e-02f, -3.33167799e-02f, -4.12170775e-03f, 9.76101160e-02f, -5.53556681e-02f, 4.85292822e-02f, -5.89235802e-04f, 3.69547158e-02f,
  -1.76680818e-01f, -2.73007732e-02f, 9.30660442e-02f, -1.94940656e-01f, -3.04039344e-02f, 7.10725710e-02f, 4.70185839e-02f, 5.92231657e-03f, -9.42454562e-02f, -1.68602899e-01f,
  -1.13419257e-01f, 6.50223866e-02f, -3.31705920e-02f, -1.09705083e-01f, 1.49237901e-01f, -6.94812015e-02f, -1.85899332e-01f, -1.58527255e-01f, 5.12868762e-02f, -3.23006734e-02f,
  4.13927995e-02f, -1.82136819e-01f, -6.84734508e-02f, -1.51125863e-01f, -5.89762926e-02f, 8.26576054e-02f, -1.50398225e-01f, -1.57347172e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  -9.83365029e-02f, 1.08857572e-01f, 2.52004620e-02f, 2.44614556e-02f, -6.03033081e-02f, -6.22666180e-02f, 1.59356982e-01f, 1.31106436e-01f, -5.90406992e-02f, -2.42202822e-02f,
  1.42403975e-01f, 3.28544304e-02f, 1.07648201e-01f, 1.61042474e-02f, -6.15964904e-02f, 7.81132281e-02f, 3.62848006e-02f, -3.92033253e-03f, 1.91466764e-01f, 6.16324991e-02f,
  -9.95117873e-02f, -7.08382279e-02f, 2.55727202e-01f, 3.15964967e-02f, -2.07358561e-02f, 3.59922685e-02f, -1.27056658e-01f, 1.31726954e-02f, 1.50291696e-01f, -4.59742136e-02f,
  1.58208832e-01f, 2.12022036e-01f, 6.19187318e-02f, 2.31634025e-02f, 3.67865451e-02f, 1.00836240e-01f, 1.05560832e-01f, -3.23038101e-02f, -5.16880397e-03f, 2.23077759e-02f,
  -4.29495312e-02f, 6.99136779e-02f, 1.53338090e-01f, -1.04827061e-02f, -6.93179391e-05f, 6.66979998e-02f, 5.35819344e-02f, 5.29549420e-02f, -1.96454898e-01f, -2.91379485e-02f,
  1.99509468e-02f, -2.02205375e-01f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -2.38563821e-01f, -2.28263319e-01f, -2.33892798e-01f, -1.59140706e-01f, -1.39034614e-01f, -1.42859221e-01f, -6.38525411e-02f, -1.03928708e-01f, -1.61139175e-01f, 2.11815059e-01f,
  9.33079273e-02f, -7.57423416e-02f, 1.72471881e-01f, -9.45981666e-02f, 2.05915533e-02f, -1.20010540e-01f, 1.21525517e-02f, -2.90603321e-02f, -2.07978860e-02f, 1.82154670e-01f,
  1.74380988e-01f, -5.47544211e-02f, -1.04002737e-01f, -1.13649882e-01f, 5.45572303e-02f, 1.11101136e-01f, 2.21473813e-01f, -8.73993523e-03f, -1.15964999e-02f, 5.57970256e-02f,
  1.22364841e-01f, 1.54840406e-02f, -1.32530159e-03f, 8.67448822e-02f, -2.28810325e-01f, 8.68957713e-02f, 3.61368060e-02f, 1.71860442e-01f, -8.80365819e-03f, 2.92987935e-02f,
  1.85937241e-01f, 3.25422347e-01f, -2.51949020e-02f, -2.63814241e-01f, -7.62625933e-02f, -2.02112153e-01f, -3.00549895e-01f, 8.02431405e-02f, -3.25154305e-01f, -2.51194715e-01f,
  2.08981596e-02f, -1.52603254e-01f, 8.79611075e-02f, 5.64908087e-02f, -2.43191406e-01f, 1.35062203e-01f, -5.30562326e-02f, -1.22472696e-01f, 5.27123734e-02f, 1.54224867e-02f,
  -1.05773546e-02f, -4.87197265e-02f, -4.38928865e-02f, 5.20896316e-02f, 5.82245439e-02f, -6.83478080e-03f, 1.04928628e-01f, -1.01907626e-01f, 1.08517878e-01f, -2.85053323e-03f,
  -8.22510421e-02f, -9.12941061e-03f, 1.16225205e-01f, 8.66634548e-02f, -1.18842810e-01f, -6.72813058e-02f, -5.92528507e-02f, -1.36933416e-01f, 5.65864556e-02f, -3.47420722e-02f,
  -6.30773196e-04f, 1.28662363e-01f, 7.12190717e-02f, 4.89423387e-02f, 5.56413569e-02f, 2.46688381e-01f, -7.19594210e-02f, -7.49108642e-02f, 1.41016126e-01f, -5.53709082e-02f,
  1.01422586e-01f, 1.53330877e-01f, 3.65147665e-02f, 1.77742429e-02f, -9.51709375e-02f, -2.04374120e-01f, 1.30860895e-01f, 1.22509420e-01f, -1.82674736e-01f, 4.49665040e-02f,
  -5.32642081e-02f, 1.33227641e-02f, 2.73906201e-01f, 8.86234343e-02f, -9.80797336e-02f, 2.27112874e-01f, -1.23258747e-01f, -3.75402607e-02f, 1.68159194e-02f, -9.19880643e-02f,
  -1.33180216e-01f, -5.11508100e-02f, 1.29753202e-02f, 1.12129562e-01f, -1.14069909e-01f, 3.09917741e-02f, -4.07200083e-02f, 1.43844843e-01f, 2.89067011e-02f, 1.26411580e-02f,
  8.20871349e-03f, -2.02228427e-02f, -3.51887122e-02f, -7.09263459e-02f, -4.33140397e-02f, 2.20433667e-01f, -7.54385367e-02f, -3.55457352e-03f, -3.32118571e-01f, -1.85447112e-02f,
  -1.86624929e-01f, -5.66628724e-02f, -1.32717758e-01f, -3.05532306e-01f, -3.79537970e-01f, 7.92356357e-02f, -8.06644335e-02f, -1.69219241e-01f, 1.69467241e-01f, 1.99714616e-01f,
  6.87269345e-02f, 8.39813892e-03f, -6.91151395e-02f, -1.36771545e-01f, 1.07907802e-01f, 3.85509059e-02f, -1.00563943e-01f, -1.72273830e-01f, 6.02839813e-02f, -4.02282178e-02f,
  -1.58261225e-01f, 7.17131644e-02f, 2.65742093e-03f, 3.44850384e-02f, -9.27159339e-02f, 8.46137851e-03f, -1.72598287e-02f, 8.83640838e-04f, 8.65437463e-03f, -1.53538156e-02f,
  2.34666780e-01f, -9.04840045e-03f, -1.20279200e-01f, 6.45582527e-02f, 1.04542665e-01f, -4.98457924e-02f, 1.21549122e-01f, 5.04003577e-02f, -6.08810857e-02f, 7.20550269e-02f,
  -1.71573553e-02f, -2.77287334e-01f, 1.09029422e-02f, 1.59935102e-01f, -2.98278257e-02f, -2.52501927e-02f, 1.52510358e-02f, 1.74456969e-01f, 4.69366722e-02f, -1.78063899e-01f,
  1.92613993e-02f, 7.35738650e-02f, 1.06351510e-01f, 2.60577053e-01f, -1.03458174e-01f, 3.23210470e-02f, -1.03415027e-01f, 7.93225914e-02f, -2.00695947e-01f, 2.03030661e-01f,
  8.23004078e-03f, 2.28509858e-01f, -7.70430267e-02f, -3.19712050e-02f, 7.00633302e-02f, 2.04243109e-01f, -5.79171777e-02f, -4.33761552e-02f, 4.42878343e-02f, 1.11378450e-02f,
  -1.56118900e-01f, -1.36258617e-01f, 2.35939637e-01f, 1.47246808e-01f, 3.13259289e-02f, 1.06835991e-01f, -2.63642743e-02f, -1.16880812e-01f, 1.71965331e-01f, -1.93490967e-01f,
  2.82582278e-05f, -8.69347155e-03f, 2.15831026e-01f, -1.44169703e-01f, 7.31140375e-02f, 1.16487090e-02f, 4.13714834e-02f, -1.80990204e-01f, 2.69765835e-02f, 4.52451669e-02f,
  7.44455829e-02f, -1.70527454e-02f, 1.24860264e-01f, 1.89848959e-01f, -6.13237731e-02f, -1.46405593e-01f, 7.79662728e-02f, 5.96056543e-02f, 9.47922934e-03f, 9.94626433e-02f,
  -9.38513950e-02f, -2.09134549e-01f, -1.68984930e-03f, -1.08657070e-01f, -2.44103782e-02f, 8.31235722e-02f, -1.78975374e-01f, 2.40218416e-01f, 1.23796940e-01f, 2.05315292e-01f,
  2.33944748e-02f, -8.15675557e-02f, -6.89502480e-03f, 5.84364170e-03f, -4.34220769e-02f, 7.16323638e-03f, -4.39592414e-02f, -5.02294973e-02f, -8.42658579e-02f, 1.31209803e-04f,
  9.71257761e-02f, -1.14842154e-01f, -9.19093098e-03f, 7.54991025e-02f, 2.44373977e-01f, -1.16235919e-01f, -1.34100497e-01f, -6.40259609e-02f, -1.39240861e-01f, -5.77395372e-02f,
  2.06817523e-01f, 8.95834938e-02f, -1.05750427e-01f, -2.11645126e-01f, 9.70971063e-02f, -3.80036584e-03f, 4.46308702e-02f, 7.26571530e-02f, -1.51499093e-01f, 1.04779983e-02f,
  1.84349015e-01f, 2.71568932e-02f, -1.32650852e-01f, -3.30083780e-02f, 4.69171181e-02f, -1.41723141e-01f, -1.81131110e-01f, 2.74215210e-02f, -4.24634926e-02f, 1.44286782e-01f,
  -9.15942937e-02f, 1.10259846e-01f, 1.77048147e-01f, 1.00414932e-01f, 1.00791128e-02f, 2.87662633e-02f, -1.15060307e-01f, -1.00827746e-01f, -1.55463353e-01f, 1.20947976e-02f,
  1.11166187e-01f, -3.11785061e-02f, -1.55339679e-02f, 8.75565410e-02f, 1.40340820e-01f, 9.69625413e-02f, -1.07123628e-01f, 1.79159194e-01f, -1.09233454e-01f, -2.13385895e-01f,
  1.30799294e-01f, -1.02007724e-01f, -1.14282288e-01f, -3.50328922e-01f, 1.05517939e-01f, 5.39303273e-02f, -8.73536617e-03f, 1.39601380e-01f, -1.18003510e-01f, 2.32548192e-01f,
  1.90395474e-01f, 7.81937614e-02f, -7.17457160e-02f, -3.23224142e-02f, -3.01918954e-01f, -7.83694461e-02f, -1.50497276e-02f, 9.20695253e-03f, -3.13272960e-02f, -2.57056374e-02f,
  -1.17825352e-01f, 8.64078403e-02f, -1.68574244e-01f, 1.57747939e-01f, 7.64457807e-02f, 3.00600499e-01f, -2.23112538e-01f, 4.53680614e-03f, 8.46371427e-02f, 1.25266448e-01f,
  -1.22728728e-01f, 1.24046065e-01f, -5.38557209e-03f, 2.14036614e-01f, 1.15223423e-01f, 1.62743460e-02f, 7.46524474e-03f, 8.95752758e-02f, -2.52465941e-02f, 5.46211079e-02f,
  1.09790519e-01f, 9.49218869e-02f, -1.26534581e-01f, -6.74934089e-02f, -1.44927189e-01f, 1.94888860e-01f, 2.50883520e-01f, 5.43685667e-02f, 7.54402727e-02f, 1.03978887e-01f,
  4.38024774e-02f, 3.74485068e-02f, -8.10937732e-02f, 9.67703164e-02f, -1.55507147e-01f, -5.39722219e-02f, 1.71551749e-01f, -1.37166500e-01f, -6.74573183e-02f, 1.03451125e-01f,
  -1.40696019e-01f, 4.41195183e-02f, -3.91138270e-02f, -4.54836451e-02f, 1.51130185e-01f, -9.16302651e-02f, 4.65646014e-03f, 1.31367671e-03f, 6.88735256e-03f, -1.11832097e-01f,
  6.86991364e-02f, -5.00152335e-02f, 5.19718081e-02f, 9.46765617e-02f, -8.04957151e-02f, 1.30687684e-01f, 1.45990282e-01f, 1.91117031e-03f, -6.98922351e-02f, 2.08807096e-01f,
  -7.18614683e-02f, 9.89081413e-02f, -1.93763748e-01f, 2.16776103e-01f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -1.12292804e-01f, -2.03545596e-02f, -2.05587640e-01f, -5.45835868e-02f, -1.03113316e-01f, -1.38124704e-01f, -1.21735111e-02f, 7.16755390e-02f, 1.24705266e-02f, 1.21874869e-01f,
  3.08215708e-01f, -1.62898168e-01f, 8.46483260e-02f, 4.78450358e-02f, 1.78100824e-01f, 1.12476766e-01f, -3.20710778e-01f, -1.16393387e-01f, 1.35358348e-01f, -3.63102444e-02f,
  -9.91863851e-03f, 2.87842341e-02f, 4.81758900e-02f, -5.03475666e-02f, 7.21561983e-02f, -1.28553882e-01f, 2.70158619e-01f, 1.08834848e-01f, 2.66177565e-01f, -4.94156666e-02f,
  -9.47363228e-02f, -3.12519372e-01f, -1.31960630e-01f, -1.85482576e-01f, 6.72869533e-02f, -3.26640546e-01f, 1.07206374e-01f, 9.77928191e-02f, 2.41663277e-01f, 1.48204952e-01f,
  -4.36215639e-01f, 3.71384583e-02f, 8.24928582e-02f, -6.76228255e-02f, 1.51067719e-01f, -1.35600954e-01f, -1.04206324e-01f, -2.11478576e-01f, 4.08920944e-02f, -3.39384601e-02f,
  -1.86162472e-01f, 1.56503558e-01f, -2.94924825e-02f, -4.28229943e-03f, 7.33409449e-02f, 4.29260544e-03f, -2.68415734e-03f, -6.57042637e-02f, -7.82897100e-02f, -1.70275588e-02f,
  1.11647390e-01f, 1.41762763e-01f, -2.28304788e-01f, 1.69066846e-01f, 3.94215211e-02f, 2.52816528e-01f, -1.92245108e-03f, -3.62362303e-02f, 1.49801582e-01f, -3.94012295e-02f,
  3.77128273e-02f, -3.37647587e-01f, 1.89265907e-01f, 1.26881793e-01f, 7.62306154e-02f, 3.47176641e-01f, -1.00098915e-01f, 1.34802148e-01f, 1.20790996e-01f, 2.11183533e-01f,
  -2.05554336e-01f, 4.43955362e-02f, 2.92067349e-01f, 2.78220475e-01f, 1.15749754e-01f, -9.00909528e-02f, -1.28235966e-01f, 1.81454182e-01f, -1.90149754e-01f, 1.12628512e-01f,
  7.24405423e-02f, -4.00251485e-02f, 2.57927626e-02f, 1.45372376e-01f, 5.11832312e-02f, 1.99424058e-01f, -7.45247379e-02f, 5.97825237e-02f, 2.83863515e-01f, 1.21461689e-01f,
  1.56964660e-01f, 1.07221492e-01f, -4.76984028e-03f, 1.13670208e-01f, -3.27683240e-02f, 1.88744411e-01f, 1.97913516e-02f, -2.82547802e-01f, 2.27613464e-01f, 2.72117499e-02f,
  7.65363649e-02f, -1.84786439e-01f, 9.34350565e-02f, -2.83202976e-02f, 1.93559509e-02f, 2.18297355e-02f, -2.20342994e-01f, 9.91034135e-02f, -3.70872067e-03f, -1.90232366e-01f,
  4.34665605e-02f, -2.66516977e-03f, -1.97133139e-01f, 8.51955488e-02f, -8.02494027e-03f, 1.70250729e-01f, -2.01376989e-01f, -4.72041173e-03f, -6.94783777e-02f, -8.57624039e-02f,
  2.24899184e-02f, -3.77634428e-02f, -4.77807261e-02f, -1.19303018e-01f, -1.24294661e-01f, -4.24642628e-03f, -9.92180035e-02f, 1.14371488e-02f, 1.11353636e-01f, 9.09694061e-02f,
  -2.56066676e-02f, 1.08560929e-02f, -1.83490606e-03f, -2.77119037e-02f, -1.99942470e-01f, -1.68590341e-02f, 2.87763439e-02f, -3.46118286e-02f, 2.94572599e-02f, -6.39996901e-02f,
  -2.23346706e-02f, 2.02091075e-02f, -1.15442738e-01f, 1.94486827e-02f, -9.19662118e-02f, -1.02036506e-01f, -8.64614621e-02f, -3.15253325e-02f, 5.15687503e-02f, 4.32232469e-02f,
  -1.21069714e-01f, 3.06875166e-02f, 1.33353636e-01f, 1.11185208e-01f, -1.10021431e-03f, -5.44829154e-03f, -4.80628535e-02f, 4.01006313e-03f, 4.38734367e-02f, -6.07518591e-02f,
  -1.24419637e-01f, -1.02469064e-02f, -1.10283429e-02f, 1.92013964e-01f, 6.14795983e-02f, 1.45859078e-01f, 6.57218173e-02f, -8.19732323e-02f, -2.46756319e-02f, 6.77596033e-02f,
  1.18253574e-01f, -6.42442405e-02f, 1.52531648e-02f, -8.43102857e-02f, -1.27579778e-01f, -8.73294249e-02f, 8.57579485e-02f, 2.89541129e-02f, -3.80655117e-02f, -8.67815316e-02f,
  1.36242926e-01f, -2.11572759e-02f, -1.86507851e-01f, -7.99240917e-02f, -2.05654114e-01f, -1.83455646e-01f, -8.68639573e-02f, -8.04427490e-02f, -2.26169705e-01f, 2.41046011e-01f,
  -1.77506894e-01f, -1.58224311e-02f, 2.43745044e-01f, -1.47741407e-01f, 1.09895065e-01f, 2.72185244e-02f, -9.60626528e-02f, -1.61671806e-02f, 1.29401326e-01f, 5.60771674e-02f,
  -6.93352818e-02f, -1.20817415e-01f, -2.45431834e-03f, 1.45808067e-02f, 4.53101918e-02f, -9.81452838e-02f, 1.80587232e-01f, -1.70067385e-01f, -2.12930664e-01f, 3.01726796e-02f,
  -4.72602174e-02f, -6.27205148e-02f, -4.61435579e-02f, 8.28735158e-02f, 2.03326955e-01f, -1.77246675e-01f, -1.55476615e-01f, -8.94958973e-02f, 8.39203876e-03f, -6.45367950e-02f,
  -5.25270589e-02f, 7.02919066e-02f, 2.73161270e-02f, -1.28716439e-01f, -1.84117467e-04f, -2.96945348e-02f, 1.79309353e-01f, -3.22699137e-02f, 6.63555041e-03f, -3.38475667e-02f,
  -1.78178996e-01f, 6.05953000e-02f, -8.10933262e-02f, 3.23074870e-02f, -2.10342314e-02f, -4.87209186e-02f, 4.42121029e-02f, 2.76331678e-02f, -3.59981917e-02f, 7.70507753e-02f,
  4.96508256e-02f, 4.64923345e-02f, -8.48082006e-02f, 9.73941088e-02f, 2.15073377e-02f, 2.16310874e-01f, 2.39912421e-01f, 2.10065857e-01f, 9.43250060e-02f, 2.97071159e-01f,
  1.83182061e-01f, 9.56270322e-02f, -4.30565104e-02f, 1.25054270e-01f, 4.40729521e-02f, -6.02138638e-02f, -2.42089838e-01f, -2.77428836e-01f, -2.05679476e-01f, -6.10098690e-02f,
  3.72908041e-02f, 1.30368903e-01f, 1.51824102e-01f, -1.63933001e-02f, -6.56559318e-03f, -8.99355635e-02f, -8.68926346e-02f, -6.53190762e-02f, 1.44482568e-01f, 2.20858734e-02f,
  1.03809416e-01f, -1.42169431e-01f, 6.17465843e-03f, 9.36987326e-02f, 9.56165940e-02f, 1.18560018e-02f, -1.67286675e-03f, -2.43167542e-02f, 7.55193681e-02f, 4.78022806e-02f,
  1.09042883e-01f, 1.01136062e-02f, 6.19481802e-02f, -6.58084229e-02f, -1.04561351e-01f, 7.00080693e-02f, -7.21008927e-02f, -2.54018813e-01f, 1.67768911e-01f, 1.67651847e-01f,
  -7.82477558e-02f, -4.03751470e-02f, 1.18234545e-01f, 2.61880364e-02f, 3.28552842e-01f, 5.16821444e-02f, -1.09955827e-02f, 2.26112485e-01f, -1.73227012e-01f, -9.54782292e-02f,
  1.89203069e-01f, -1.21022955e-01f, 8.53040162e-03f, 4.06339727e-02f, 8.86955205e-03f, 6.14883676e-02f, -1.05612785e-01f, 3.21182348e-02f, 7.68538145e-03f, -1.00482486e-01f,
  7.50076771e-02f, 6.79790899e-02f, 9.87002552e-02f, 3.82524990e-02f, -1.56548992e-02f, -7.83260539e-02f, 3.97531502e-02f, -3.37546207e-02f, 1.28103778e-01f, -4.63839620e-02f,
  -1.86573610e-01f, -4.58118245e-02f, 1.45704657e-01f, 2.33023301e-01f, 2.11185947e-01f, 4.91437018e-02f, -1.97113588e-01f, 1.07010312e-01f, 5.57086021e-02f, 1.79899484e-01f,
  -1.10378182e-02f, 1.67361557e-01f, 1.06820455e-02f, -1.01373874e-01f, -9.86707583e-02f, 2.88068563e-01f, 1.71784341e-01f, 1.28470719e-01f, 1.85720190e-01f, 1.41590908e-01f,
  -1.04995847e-01f, -1.06879264e-01f, -7.92061538e-02f, 1.08071029e-01f, -2.09616631e-01f, -6.09846227e-02f, -3.74028608e-02f, -8.84894878e-02f, -5.89609332e-02f, 9.97063816e-02f,
  7.37891940e-04f, 7.58311301e-02f, 2.19014753e-02f, 6.78835809e-02f, 8.58170614e-02f, -3.15014452e-01f, -2.71294087e-01f, -4.35305610e-02f, -3.76284458e-02f, -6.39508218e-02f,
  1.11840501e-01f, -8.10955018e-02f, 9.42764208e-02f, -1.39018655e-01f, -6.59151226e-02f, -2.24792629e-01f, 6.97038621e-02f, 6.25810251e-02f, -6.58282265e-02f, -1.45015180e-01f,
  6.87546507e-02f, 1.57994613e-01f, -8.25237185e-02f, 8.29855576e-02f, -3.84375824e-07f, -1.50426627e-06f, 4.70501163e-07f, 2.83423134e-07f, 1.31368381e-06f, -4.55574735e-07f,
  -2.65260996e-06f, 5.45962337e-07f, -1.41358214e-06f, -2.33414426e-06f, 4.88581861e-07f, -1.80610948e-06f, 1.10842106e-04f, -5.21740913e-06f, -1.79090674e-24f, -1.33605639e-07f,
  1.44307006e-24f, -2.00164777e-05f, 6.89016815e-05f, 6.39866703e-05f, -3.38237194e-09f, -1.59616975e-04f, -1.42681472e-07f, -6.29511924e-05f, -1.83750293e-04f, -1.77702653e-08f,
  -7.87823140e-08f, -4.39829551e-18f, -2.61047844e-05f, -9.96433573e-06f, -7.84006843e-05f, -8.84219480e-06f, 1.74786123e-07f, -2.95458944e-04f, 4.00233611e-13f, -9.56244068e-04f,
  -6.31523362e-05f, -9.99947815e-07f, -4.59217839e-03f, -4.99886519e-04f, -6.00610336e-04f, -3.75259551e-04f, 8.91753143e-13f, -6.44850839e-12f, 6.03462977e-04f, -2.21227889e-28f,
  1.06858398e-08f, -7.28922605e-05f, 2.30116481e-37f, 4.90926700e-40f, -7.07298896e-05f, -1.20081749e-08f, -3.23751239e-14f, -7.10512508e-12f, -4.91272821e-40f, -2.56865809e-04f,
  -8.32822479e-07f, 4.92493352e-40f, 7.53549512e-06f, -7.37787632e-04f, -4.94825112e-40f, -2.32501212e-03f, -3.72877480e-08f, -2.25435651e-04f, 1.55322328e-01f, -1.08355708e-01f,
  2.46300116e-01f, 1.79647684e-01f, 2.91381508e-01f, -7.50529766e-02f, -1.87251732e-01f, 1.16185114e-01f, -1.87137425e-01f, -3.13774437e-01f, -2.93120891e-01f, -2.14790836e-01f,
  3.49719785e-02f, 1.14718080e-01f, 9.60486904e-02f, -6.55152798e-02f, 9.48975235e-02f, 2.69801110e-01f, -1.17009513e-01f, -1.12916201e-01f, -6.14429042e-02f, 1.12580575e-01f,
  1.74638942e-01f, -3.44721764e-01f, 2.08689928e-01f, -5.09393122e-03f, -2.16227129e-01f, 1.05779551e-01f, 6.05563670e-02f, 1.55066684e-01f, -9.17853266e-02f, -1.79779932e-01f,
  8.36471543e-02f, 8.53164704e-04f, -3.49220395e-01f, 1.17794849e-01f, -2.12328956e-01f, 3.73116098e-02f, 1.82994351e-01f, -2.05926776e-01f, -4.00821827e-02f, -3.60766724e-02f,
  1.17552981e-01f, 3.47786933e-01f, -2.57879227e-01f, -2.61537760e-01f, -1.94359064e-01f, 8.77170041e-02f, 2.10232019e-01f, 9.15174112e-02f, -1.48520013e-02f, 1.45203263e-01f,
  9.93801355e-02f, -8.58021677e-02f, -8.07793289e-02f, 8.48231018e-02f, 2.35113710e-01f, -1.13807708e-01f, 1.16769612e-01f, 1.24768987e-01f, -4.37206738e-02f, -2.52800565e-02f,
  -1.37436494e-01f, 4.87035047e-03f, 1.69986531e-01f, 2.27959320e-01f, -5.25677169e-04f, -1.10200113e-02f, 2.74211824e-01f, -4.06186394e-02f, -1.20326795e-01f, -1.89621106e-01f,
  2.57928908e-01f, 2.31738627e-01f, -7.94767141e-02f, 5.25723882e-02f, -9.56415758e-02f, -3.75028625e-02f, 1.37149453e-01f, 1.60645157e-01f, -3.14993441e-01f, 3.90063375e-02f,
  2.17296958e-01f, -2.69426182e-02f, 2.73170546e-02f, -1.92229718e-01f, -2.07039475e-01f, 2.83342332e-01f, -1.36945128e-01f, -1.17132487e-02f, 1.94590971e-01f, 1.65836379e-01f,
  -9.59608704e-03f, 8.73698369e-02f, -2.70608142e-02f, -8.83351713e-02f, -2.77703047e-01f, -3.51032726e-02f, 2.41016611e-01f, -4.98652942e-02f, 1.57419145e-01f, 1.90010950e-01f,
  -1.35409415e-01f, 1.22453101e-01f, -1.61675140e-01f, 1.01814099e-01f, 1.66157246e-01f, -2.68131584e-01f, -5.13652451e-02f, 3.58045191e-01f, 6.46334440e-02f, -2.46311009e-01f,
  2.71759480e-01f, 1.69146895e-01f, -1.50129944e-01f, 1.07963160e-01f, -5.26021086e-02f, 9.38269049e-02f, 3.41432035e-01f, 3.35922725e-02f, -7.65229464e-02f, 3.27320322e-02f,
  -2.10194290e-01f, -5.20708896e-02f, 1.63580906e-02f, 2.03866698e-03f, -7.72114620e-02f, 7.03456625e-03f, -2.31280804e-01f, 8.34490880e-02f, 1.03633441e-01f, -9.16091576e-02f,
  -5.08526936e-02f, 1.03988267e-01f, -2.13856906e-01f, -1.55446559e-01f, -1.58331484e-01f, 9.14511755e-02f, 2.05812931e-01f, 3.13201696e-01f, 1.20926991e-01f, 2.89698504e-02f,
  -1.35544492e-02f, 4.47305143e-02f, -6.60820752e-02f, 2.20355958e-01f, 1.64085120e-01f, 6.91417605e-02f, 1.40140399e-01f, 1.96004566e-02f, -1.72240347e-01f, 8.69859830e-02f,
  -5.80566786e-02f, 8.89467746e-02f, 1.45727284e-02f, -7.08292350e-02f, -1.16616953e-02f, 1.18080191e-01f, 8.88151452e-02f, 2.15708897e-01f, 6.43114443e-04f, 2.29038950e-02f,
  -1.38001233e-01f, 2.06547365e-01f, 1.46202398e-02f, 2.38119178e-02f, 4.10629213e-02f, 1.62814707e-01f, 7.91846588e-02f, 9.91237462e-02f, -1.84818968e-01f, -1.45294532e-01f,
  9.16567221e-02f, -3.63741517e-01f, 1.79582871e-02f, 3.35186571e-02f, -1.60824060e-01f, -1.64011866e-01f, 4.73414287e-02f, -3.11931744e-02f, -2.98597515e-01f, -1.09439731e-01f,
  -3.27156991e-01f, -5.92091233e-02f, 3.66874645e-03f, -8.26865062e-02f, 6.17405660e-02f, -1.09321112e-02f, 1.15168490e-01f, 1.12737246e-01f, -3.93997505e-02f, 5.67648895e-02f,
  1.80455253e-01f, 1.90331131e-01f, -1.32671362e-02f, 1.91201586e-02f, -1.77181110e-01f, 4.47202362e-02f, 2.48321623e-01f, 1.05478562e-01f, 2.86991417e-01f, -1.07683741e-01f,
  -3.97672325e-01f, -1.82281345e-01f, -1.63760722e-01f, -4.12903167e-02f, 3.95483933e-02f, -8.11314806e-02f, 3.92626345e-01f, -2.34866604e-01f, -1.62098497e-01f, 1.81938261e-01f,
  -8.87026042e-02f, -1.67458043e-01f, 1.25894561e-01f, -1.36414841e-01f, 2.23037660e-01f, -8.49339515e-02f, -1.23808138e-01f, 1.68071000e-03f, 9.81620103e-02f, 8.46248027e-03f,
  2.22313732e-01f, -1.92678899e-01f, 4.06133890e-01f, -2.27482259e-01f, -1.67626321e-01f, -2.33248115e-01f, 3.10511403e-02f, 8.37527439e-02f, -8.07805359e-02f, 5.42958044e-02f,
  -3.58068012e-02f, -4.25994173e-02f, 1.39713854e-01f, -3.43851119e-01f, -7.60471076e-02f, -1.49196088e-01f, -3.72756310e-02f, 1.63973436e-01f, 6.01596534e-02f, 2.17129886e-01f,
  -2.59054273e-01f, -1.11993393e-02f, 6.62091225e-02f, -2.11871326e-01f, -4.60403562e-02f, 1.69357389e-01f, -8.24713036e-02f, 2.67688751e-01f, 1.48492664e-01f, 3.89946513e-02f,
  5.24773411e-02f, 1.41060084e-01f, 5.17407842e-02f, 9.42682475e-02f, 6.22331351e-02f, 2.11607851e-02f, 2.82574873e-02f, 2.36351192e-01f, 1.36275301e-02f, 1.75741613e-01f,
  -2.65330616e-02f, -1.66663244e-01f, -2.63662875e-01f, 1.96599379e-01f, 1.80811644e-01f, -7.63757899e-02f, 2.02168763e-01f, -9.64528397e-02f, -1.65760785e-01f, -6.71147257e-02f,
  5.73495030e-02f, -2.12240398e-01f, 1.25986531e-01f, -1.88555911e-01f, 5.20074368e-02f, 1.03606964e-02f, 1.12208202e-01f, 9.94420275e-02f, 9.99842659e-02f, -2.82385588e-01f,
  -1.05436653e-01f, -1.55569255e-01f, -2.62861997e-01f, -6.52669147e-02f, 1.66766435e-01f, 2.33215362e-01f, -1.11999577e-02f, 1.83807403e-01f, 2.17960060e-01f, 2.55076021e-01f,
  -3.77485193e-02f, 4.57921475e-02f, 7.20697790e-02f, 4.42630276e-02f, 2.03029856e-01f, -4.25810404e-02f, -1.32025912e-01f, 1.13563135e-01f, 1.73723362e-02f, 1.75625950e-01f,
  7.47602805e-02f, 2.69762754e-01f, -1.86546445e-02f, 9.55855548e-02f, -5.98803200e-02f, 1.41302437e-01f, 2.53753930e-01f, 6.68825656e-02f, 2.45416816e-02f, 9.42679048e-02f,
  -8.99719447e-02f, -1.36239557e-02f, 8.35629031e-02f, -6.62560761e-02f, -1.59759089e-01f, 6.75426275e-02f, 2.01675504e-01f, -4.74179573e-02f, 2.21314028e-01f, 1.16698287e-01f,
  1.69153497e-01f, 4.68902364e-02f, 9.85385627e-02f, 7.92635605e-02f, 1.56599641e-01f, 2.41611421e-01f, 5.79959005e-02f, 7.68197402e-02f, -2.14140560e-03f, -1.80971935e-01f,
  2.22021900e-02f, 2.21431367e-02f, -2.45070040e-01f, -2.32567251e-01f, 5.15478075e-01f, -6.95509464e-02f, -1.38813645e-01f, 2.04433247e-01f, 2.90645449e-03f, 1.25590801e-01f,
  8.10406283e-02f, -3.09995711e-01f, 1.76436692e-01f, -2.18400694e-02f, -1.93621963e-03f, 1.31299570e-01f, 2.62002915e-01f, 1.61337763e-01f, -3.72385532e-02f, -1.11147821e-01f,
  2.87974328e-01f, -1.19234500e-02f, -3.71587366e-01f, 1.11747220e-01f, -1.02502212e-01f, -7.75761604e-02f, -5.88453654e-03f, 2.64461059e-02f, 6.57939538e-02f, -2.19074711e-02f,
  1.72020886e-02f, 9.38911736e-02f, -8.47675949e-02f, -3.15057993e-01f, -2.01864839e-01f, 2.52612203e-01f, -1.92224666e-01f, 2.59027667e-02f, 5.90543151e-02f, 1.30324453e-01f,
  2.35195488e-01f, -2.75594760e-02f, -2.27685776e-02f, 5.67493550e-02f, 1.00023717e-01f, 4.36454751e-02f, 2.89031982e-01f, 5.04619293e-02f, 4.91266027e-02f, 6.44891039e-02f,
  1.98814142e-02f, -1.33275121e-01f, -4.57039356e-01f, -1.16494223e-01f, -3.81356061e-01f, -1.58193097e-01f, -3.88434678e-01f, -3.24316561e-01f, -2.84239113e-01f, 2.95476746e-02f,
  -7.51669630e-02f, -1.64163515e-01f, 1.72425941e-01f, 2.88248956e-01f, 1.69812199e-02f, 6.63134605e-02f, -9.02698375e-03f, -1.82911500e-01f, -1.50891572e-01f, 2.13153362e-02f,
  -2.31627524e-02f, -2.45237090e-02f, 3.73386331e-02f, 6.38297107e-03f, -6.71400577e-02f, 9.71984491e-02f, -9.24945772e-02f, 2.17619121e-01f, 7.40353540e-02f, 1.78757943e-02f,
  -6.34445399e-02f, -6.68449998e-02f, 7.14116618e-02f, 1.63033620e-01f, -1.96477640e-02f, 2.92416047e-02f, -2.66965747e-01f, 1.06388062e-01f, -2.08647531e-02f, 9.75893904e-03f,
  -1.52610347e-01f, -2.64193922e-01f, 8.54486004e-02f, 1.06289871e-01f, -2.52454847e-01f, -5.41176684e-02f, 1.53891206e-01f, -5.81238139e-03f, -1.98074266e-01f, -1.99352782e-02f,
  -1.24098837e-01f, -1.04370728e-01f, 3.48722413e-02f, -3.16860080e-01f, 2.30871975e-01f, -5.70168756e-02f, -6.50174692e-02f, 7.61753917e-02f, 2.28571370e-02f, 4.13475707e-02f,
  -8.40272475e-03f, -5.24402075e-02f, 1.77573249e-01f, -2.06877679e-01f, 1.27878711e-01f, 1.09782510e-01f, -2.87633063e-03f, -4.25447215e-04f, 1.46802806e-03f, -2.37925653e-03f,
  -1.54836709e-03f, -1.19186472e-03f, -2.30997670e-04f, -1.75396539e-03f, -2.91088305e-04f, -1.92415828e-04f, 1.65229867e-04f, 8.86925671e-04f, -1.64947740e-03f, -3.56744090e-03f,
  -3.11777182e-03f, 4.18002624e-03f, 2.02689807e-06f, -7.10826020e-09f, -2.87917850e-04f, 1.39877942e-04f, 7.20377120e-19f, -3.21621883e-05f, -6.18031845e-06f, -2.90831847e-09f,
  7.48678693e-04f, -9.43137638e-06f, 4.08866355e-04f, -8.83216619e-19f, -7.53184594e-03f, -6.08207174e-08f, -6.61717559e-06f, -7.00542341e-06f, 5.09182712e-07f, -2.55283248e-06f,
  -6.52275003e-06f, -6.44145939e-06f, 3.82350445e-05f, 9.91671527e-07f, -1.64461154e-02f, -1.00095535e-03f, -1.04336559e-05f, -6.39502367e-04f, -3.21744848e-03f, -2.25780011e-40f,
  -8.65435693e-03f, 3.44194496e-39f, -1.06325706e-05f, -7.53560380e-06f, -4.95953158e-40f, -3.44308367e-11f, -4.64806665e-12f, -7.80043138e-06f, -5.03919539e-40f, -3.68312811e-08f,
  -5.49763019e-40f, -5.17093576e-04f, -6.05108596e-07f, 2.71230365e-11f, -3.73387775e-06f, -9.77955759e-04f, 3.43291229e-11f, -9.96781886e-03f, -3.29181307e-06f, 5.54240542e-04f,
  -8.80323946e-02f, 1.52847499e-01f, 1.97910234e-01f, 2.17993259e-01f, 1.92423329e-01f, -4.02720198e-02f, -3.24528188e-01f, 1.83767676e-02f, -1.71606690e-01f, -9.63804349e-02f,
  8.92144665e-02f, 4.13480625e-02f, 9.08648446e-02f, 1.39413863e-01f, -8.28609690e-02f, -6.28688931e-03f, 1.26625016e-01f, 2.45976165e-01f, 1.49303451e-02f, -1.28761396e-01f,
  1.18954703e-01f, 2.06499770e-01f, -1.84269585e-02f, 9.05642435e-02f, 1.36747256e-01f, -6.33510714e-03f, -2.09471449e-01f, -9.49564651e-02f, 4.42861021e-02f, 3.03902179e-02f,
  5.41506782e-02f, -4.78924476e-02f, 1.63367376e-01f, 1.71078622e-01f, -1.07427821e-01f, 8.71074423e-02f, -1.13282301e-01f, -1.39050977e-02f, 1.33863389e-01f, -1.48224935e-01f,
  -5.92686199e-02f, -1.05579376e-01f, 2.90153660e-02f, 2.92713374e-01f, -1.28098270e-02f, -1.11554526e-01f, -8.98583513e-03f, 1.44979339e-02f, 2.40094572e-01f, 1.22036166e-01f,
  9.78429019e-02f, -4.33785515e-03f, -1.28658161e-01f, -1.48244321e-01f, -2.28789881e-01f, -1.13911711e-01f, 2.09910929e-01f, -2.57894039e-01f, -7.69884139e-02f, -5.10938726e-02f,
  -2.64787793e-01f, 7.97559693e-02f, -4.48569469e-02f, 1.48453623e-01f, 2.65371352e-02f, 6.49432316e-02f, 1.79029986e-01f, 3.00310612e-01f, 2.74488568e-01f, 2.05907822e-01f,
  -3.96637440e-01f, 3.25922742e-02f, 4.40879576e-02f, 7.83836618e-02f, -2.49341458e-01f, 5.69669809e-03f, 1.42240122e-01f, 8.39772597e-02f, 1.51533857e-01f, 3.60486433e-02f,
  -1.24719061e-01f, 1.45741075e-01f, -3.68182845e-02f, -7.76545750e-03f, 3.37145597e-01f, 1.15362696e-01f, -4.37887050e-02f, 8.57717264e-03f, 2.06689164e-02f, 3.14621598e-01f,
  2.50663370e-01f, 1.31660491e-01f, 2.08452135e-01f, 1.11232206e-01f, -1.19041085e-01f, -1.95367709e-01f, -2.06856169e-02f, 3.69556509e-02f, -4.41585816e-02f, 1.21791266e-01f,
  3.87640693e-03f, 6.33445084e-02f, -6.26079589e-02f, -2.52995670e-01f, 5.08005098e-02f, -2.84584053e-03f, 1.28056273e-01f, 8.76881927e-02f, -2.22163782e-01f, 1.69575900e-01f,
  -1.80512816e-01f, -9.88721326e-02f, 1.72117695e-01f, -2.35909168e-02f, 1.86683461e-01f, 3.26277800e-02f, 2.64919043e-01f, 6.35482743e-02f, 1.56219870e-01f, 1.40505880e-01f,
  7.30504915e-02f, 4.03795131e-02f, 1.61222182e-02f, -3.23761739e-02f, -1.10226668e-01f, -2.06131384e-01f, -7.58706033e-02f, -1.69081628e-01f, 2.25812554e-01f, 5.70708551e-02f,
  -1.12405177e-02f, 3.80366325e-01f, 2.85033047e-01f, 1.39167279e-01f, 3.51942599e-01f, -1.74585909e-01f, -1.13771372e-01f, 1.93082944e-01f, -1.06204674e-01f, -4.71667647e-01f,
  -1.54409960e-01f, -3.63513470e-01f, 1.02768108e-01f, 3.20629507e-01f, -1.07713062e-02f, -2.79904664e-01f, -5.97150847e-02f, 1.81070998e-01f, -1.36911720e-01f, -1.93463385e-01f,
  9.41003412e-02f, 8.19851607e-02f, -5.51501065e-02f, -3.33782613e-01f, 6.89199343e-02f, 1.08869821e-01f, 9.98068228e-02f, 4.73070554e-02f, 2.11687788e-01f, 7.05794618e-02f,
  -1.89940240e-02f, 1.61457267e-02f, 1.36375383e-01f, -1.29007488e-01f, 1.80772901e-01f, 3.85879017e-02f, -1.81556001e-01f, 1.59267724e-01f, -8.38792771e-02f, -1.64254576e-01f,
  4.55338769e-02f, -2.35126629e-01f, 9.68305767e-02f, -8.45745280e-02f, 2.52216458e-01f, 1.67594224e-01f, 1.61071252e-02f, 6.56884238e-02f, -1.04333900e-01f, 9.70593691e-02f,
  -3.35197091e-01f, -1.37945160e-01f, 1.08257897e-01f, -2.45415762e-01f, -1.17955424e-01f, 7.60120864e-04f, 4.61311638e-02f, -2.07349181e-01f, -4.43557836e-02f, 6.25239164e-02f,
  1.25320964e-02f, -1.69837385e-01f, 1.07428402e-01f, -8.97484422e-02f, -1.00635305e-01f, 1.66589409e-01f, -1.92481056e-01f, -4.86751758e-02f, 2.31076460e-02f, 2.05847263e-01f,
  7.60667846e-02f, -1.51768818e-01f, -2.73841500e-01f, 1.00348413e-03f, -8.11478216e-03f, -1.87206030e-01f, 2.27770969e-01f, -2.66187578e-01f, -2.58121956e-02f, -5.24144173e-02f,
  -2.40423873e-01f, -3.79357249e-01f, 1.39568344e-01f, 1.29621774e-01f, 2.39127010e-01f, -2.21181419e-02f, 2.84765631e-01f, -2.07739636e-01f, -1.16976708e-01f, 2.12012991e-01f,
  -4.04586038e-03f, -1.34082124e-01f, -1.05384085e-02f, -7.43480325e-02f, 2.34656036e-01f, -4.07638028e-02f, 4.10547070e-02f, -7.67311379e-02f, -1.00336259e-03f, 2.04358503e-01f,
  3.80249806e-02f, -6.96137100e-02f, 1.42007381e-01f, -5.06740734e-02f, 7.73820430e-02f, 4.33793277e-01f, -2.82022327e-01f, 3.24566543e-01f, -6.39517009e-02f, 1.33558456e-02f,
  2.92785287e-01f, 5.76385483e-02f, -4.64272574e-02f, -5.84056452e-02f, 2.33438522e-01f, 1.74855709e-01f, 2.57016897e-01f, 3.11699212e-01f, -9.35313702e-02f, 5.38206510e-02f,
  5.04956543e-02f, 6.33862689e-02f, -1.57197252e-01f, 8.97862948e-03f, 1.59138575e-01f, -1.10913999e-01f, -8.52895752e-02f, 6.04459792e-02f, 1.19624391e-01f, -8.32586288e-02f,
  1.31875560e-01f, 1.21190377e-01f, -7.35714287e-02f, -1.06654376e-01f, -7.97055140e-02f, 7.13633671e-02f, 2.41539776e-02f, -1.32263571e-01f, 2.09560975e-01f, -3.71276103e-02f,
  -3.25110778e-02f, 1.89106435e-01f, -1.27486065e-01f, 6.67157397e-02f, -5.28640226e-02f, 3.72686952e-01f, 8.60407352e-02f, -6.72235638e-02f, -1.34362802e-01f, 1.54958501e-01f,
  -1.10070996e-01f, 3.67578626e-01f, 4.30526972e-01f, -1.05952047e-01f, 1.35508940e-01f, 2.44550616e-01f, 1.78564042e-01f, 1.01804458e-01f, -5.33111058e-02f, -6.81398362e-02f,
  -2.77538151e-01f, 1.70615181e-01f, 1.47027373e-01f, -3.96519601e-02f, -3.71347904e-01f, -2.07100004e-01f, 1.56008810e-01f, 1.17200390e-01f, -8.55596662e-02f, -2.00253371e-02f,
  -1.53008983e-01f, -1.10073075e-01f, -1.52537987e-01f, 2.54932374e-01f, -6.12229228e-01f, -3.89053106e-01f, 9.27145407e-02f, -8.71152803e-02f, 9.28970352e-02f, -3.99503022e-01f,
  -2.60520011e-01f, -2.85374492e-01f, 6.93886280e-02f, 1.13553040e-01f, -1.53224887e-02f, 8.96988660e-02f, 8.40072632e-02f, -1.32562026e-01f, -1.39979810e-01f, -2.24845186e-01f,
  1.01157784e-01f, 8.27328637e-02f, 2.04731271e-01f, 1.23655163e-01f, -9.63077247e-02f, 2.64909178e-01f, -1.54354885e-01f, -7.27711320e-02f, -1.52794197e-01f, 5.61668389e-02f,
  2.62215137e-02f, 2.35967606e-01f, -3.76366153e-02f, 6.27882928e-02f, -2.93766439e-01f, -8.18527415e-02f, 2.64663160e-01f, 2.79766880e-03f, 1.51290789e-01f, 1.30162582e-01f,
  3.32457185e-01f, 4.37750779e-02f, 5.95122613e-02f, 1.68600045e-02f, 8.06590617e-02f, 4.40539233e-02f, -1.17643036e-01f, -1.94945946e-01f, -1.48497149e-01f, -1.53249782e-02f,
  1.67487815e-01f, 1.98154017e-01f, -6.05801120e-02f, 2.01295003e-01f, 1.60091415e-01f, 2.87471861e-01f, 2.16686606e-01f, 6.80617616e-02f, -6.01539798e-02f, 8.95831175e-03f,
  1.75489947e-01f, 4.36507212e-03f, -7.28535205e-02f, 3.31311598e-02f, 2.57633179e-02f, 6.59408942e-02f, 5.56354634e-02f, 2.34608501e-01f, 4.85216603e-02f, 1.16520682e-02f,
  9.07003284e-02f, 4.01676707e-02f, 6.12292588e-02f, 1.24934018e-01f, -1.17365338e-01f, -7.50166643e-03f, -4.99135144e-02f, 8.87402073e-02f, 1.80176169e-01f, -7.73509294e-02f,
  -1.09543093e-01f, -2.40721032e-01f, 2.66820908e-01f, 3.44823226e-02f, 1.78854078e-01f, 1.03371978e-01f, 4.97833267e-02f, 1.95826232e-01f, 1.59171358e-01f, 1.44055903e-01f,
  -2.37180933e-01f, 1.94445461e-01f, 1.57441154e-01f, -2.03635782e-01f, -3.83603990e-01f, -1.82564594e-02f, 1.00261010e-01f, 5.13760969e-02f, -8.08377564e-02f, -1.40349343e-01f,
  3.76738906e-01f, 1.66399211e-01f, -3.18783745e-02f, -1.02836318e-01f, -3.20419818e-02f, 1.53597265e-01f, 1.44914076e-01f, -9.42314938e-02f, 1.07036144e-01f, 1.22963980e-01f,
  -2.22977817e-01f, 9.09276828e-02f, 7.88305625e-02f, 8.18169117e-03f, 8.39584470e-02f, -1.11808948e-01f, 2.91848570e-01f, 1.73273295e-01f, -3.63429002e-02f, 7.85639361e-02f,
  -1.87640205e-01f, -1.12957858e-01f, 4.48028259e-02f, -1.36815146e-01f, 1.68111976e-02f, -1.07019939e-01f, 6.87376037e-02f, 4.43100870e-01f, -2.97605872e-01f, 5.12903519e-02f,
  -5.62262647e-02f, -3.99362221e-02f, 2.95944303e-01f, 2.19893843e-01f, 1.79330885e-01f, -2.00844873e-02f, 1.60754830e-01f, 6.85864389e-02f, -4.19178717e-02f, 6.49672225e-02f,
  8.41406360e-02f, -3.82589437e-02f, 1.84760407e-01f, -8.27834662e-03f, -2.89374530e-01f, -1.52314886e-01f, 1.29574701e-01f, -2.52747625e-01f, 7.29117095e-02f, 3.81500602e-01f,
  8.37497041e-02f, 3.20533544e-01f, 1.18848585e-01f, 1.33868396e-01f, -8.10548589e-02f, 3.35281312e-01f, 2.36551404e-01f, -9.95791107e-02f, -1.55093297e-01f, 3.15019637e-02f,
  -2.97717005e-01f, 9.63024348e-02f, -4.62661013e-02f, 7.42564946e-02f, 2.65730411e-01f, 5.60675077e-02f, -1.54363243e-02f, -6.63252026e-02f, -1.02691695e-01f, -2.93186009e-02f,
  2.67293639e-02f, 1.37499318e-01f, -1.38907582e-02f, -4.55035754e-02f, -6.51263520e-02f, 1.29763827e-01f, -5.84052578e-02f, 1.20359987e-01f, 1.13352455e-01f, 1.32603452e-01f,
  -3.69598791e-02f, -3.13349180e-02f, 1.29639462e-01f, -4.20481451e-02f, 3.66139673e-02f, -1.56803299e-02f, -1.18106112e-01f, 2.83353776e-02f, -1.68171719e-01f, -2.23762348e-01f,
  7.43334889e-02f, 9.19005275e-02f, -3.46774831e-02f, 1.49524868e-01f, 2.00414330e-01f, -2.68395931e-01f, 3.62029552e-01f, 1.75067097e-01f, -1.86707318e-01f, 1.01966783e-02f,
  -1.69197708e-01f, 8.18572715e-02f, 7.32108057e-02f, -1.31992176e-02f, 1.87846683e-02f, 4.20741215e-02f, 7.07096756e-02f, 7.05277696e-02f, -1.79055214e-01f, 1.31989587e-02f,
  5.21700531e-02f, -5.24411537e-02f, 1.60305768e-01f, -3.42821442e-02f, 6.41188547e-02f, 2.07443595e-01f, -1.84788033e-01f, 4.01282981e-02f, 2.49526083e-01f, 1.07124560e-01f,
  -6.70590177e-02f, 1.61694244e-01f, -8.82868934e-03f, -3.24661642e-01f, 4.24380824e-02f, -1.31855756e-01f, -1.76747859e-01f, -2.06652731e-01f, 3.86545926e-01f, -8.27958793e-05f,
  -5.89764975e-02f, 1.09350972e-01f, -1.67854130e-02f, 1.12923265e-01f, 2.40900576e-01f, -1.32126093e-01f, 2.17144296e-01f, -1.96591511e-01f, 4.75283992e-03f, 6.70577539e-03f,
  5.98811358e-02f, 3.71407606e-02f, 1.32803142e-01f, -9.12592560e-02f, 2.30573237e-01f, 4.24129702e-03f, -2.59656999e-02f, 1.09851189e-01f, -3.91968228e-02f, 1.49921596e-01f,
  1.76499128e-01f, 4.56109419e-02f, -5.70909791e-02f, -1.83969408e-01f, -8.10611341e-03f, 1.23664662e-02f, -3.75931226e-02f, -8.01626742e-02f, -8.68719295e-02f, 7.51800537e-02f,
  -2.02598512e-01f, 1.02646463e-01f, 9.07279477e-02f, 3.69380079e-02f, 1.04188330e-01f, 1.25466706e-02f, -1.55812606e-01f, 4.28066216e-02f, 1.17748864e-02f, 4.02668528e-02f,
  1.47963420e-01f, -4.37032953e-02f, -6.97371215e-02f, 1.56766117e-01f, -1.14628794e-02f, -4.90268432e-02f, -5.31065613e-02f, -4.82962243e-02f, 1.33947939e-01f, 1.74251005e-01f,
  8.06100965e-02f, 2.36172393e-01f, -2.45305985e-01f, -2.38792539e-01f, -1.06452852e-01f, 1.24832086e-01f, 1.47665262e-01f, 3.27048481e-01f, -7.17905238e-02f, 3.19484621e-02f,
  -5.60982712e-02f, -9.62169915e-02f, -1.72541842e-01f, 9.76408198e-02f, 4.65688109e-02f, -7.77082667e-02f, 2.33864218e-01f, 6.18991093e-04f, -9.85803977e-02f, 3.22395526e-02f,
  -1.32082189e-02f, -1.94180191e-01f, 1.03240907e-01f, 2.59330980e-02f, -2.23021820e-01f, 9.46223661e-02f, -2.62326654e-02f, 2.05959044e-02f, -9.23290849e-02f, 3.87426876e-02f,
  1.74916223e-01f, 1.07373387e-01f, 1.11005895e-01f, -2.69311573e-03f, 1.69564813e-01f, -4.72825430e-02f, 1.00744203e-01f, -3.01712044e-02f, 1.47047350e-02f, -1.10782236e-01f,
  1.22584686e-01f, 9.34474394e-02f, 8.87048542e-02f, -1.30400714e-02f, -1.59215126e-02f, -9.25710052e-02f, -9.40389633e-02f, -1.44708097e-01f, -1.81256577e-01f, 3.12532783e-01f,
  -1.12588786e-01f, 1.29335269e-01f, -6.51564226e-02f, 8.39804485e-02f, -5.91813587e-02f, 8.23461935e-02f, 1.47284731e-01f, -2.89520100e-02f, 3.20182480e-02f, 2.53716926e-03f,
  -3.45059067e-01f, -2.90101826e-01f, -2.00232655e-01f, -1.99965537e-01f, -1.93385199e-01f, -2.09577516e-01f, -1.40216380e-01f, 6.52194768e-02f, 1.61046628e-02f, -9.67498273e-02f,
  4.99679195e-03f, -1.26716299e-02f, 9.09121186e-02f, -1.82448342e-01f, -3.50024812e-02f, -3.56107116e-01f, -3.51011311e-03f, -5.20996656e-03f, -3.21388207e-02f, -2.13776514e-01f,
  8.85884017e-02f, -9.94184054e-03f, -5.80860823e-02f, -1.18240401e-01f, 1.69248790e-01f, -1.25458658e-01f, -8.62293839e-02f, -1.01185916e-02f, -1.10563241e-01f, -1.60258994e-01f,
  -5.75134307e-02f, -1.12184677e-02f, 1.27472252e-01f, 4.29795198e-02f, -7.55673200e-02f, 4.15105149e-02f, -4.15324904e-02f, 5.59961647e-02f, 2.04572827e-01f, -5.31387925e-02f,
  4.43436988e-02f, 5.88717870e-02f, -9.78589281e-02f, -1.26296341e-01f, 1.07139587e-01f, 3.02328505e-02f, -2.12344781e-01f, 1.45198712e-02f, -7.62322247e-02f, 5.50334640e-02f,
  -1.01759113e-01f, -1.35031924e-01f, 1.73740417e-01f, 1.57913759e-01f, -9.62416306e-02f, 1.24344058e-01f, -1.12314699e-02f, 9.92061868e-02f, -2.52178404e-03f, 6.29203767e-03f,
  4.04665098e-02f, -2.03558765e-02f, 1.35133535e-01f, -4.37694043e-02f, 1.77817810e-02f, -2.43338794e-02f, 5.09876385e-02f, 2.00863302e-01f, -1.11895077e-01f, 2.70916700e-01f,
  -1.83258653e-01f, -1.50618674e-02f, -1.50714621e-01f, 2.66472101e-01f, 3.34355265e-01f, -7.30836168e-02f, 1.30417928e-01f, -1.62418857e-02f, -7.46947676e-02f, 1.24216437e-01f,
  -3.12795006e-02f, 9.43474192e-03f, 4.60207239e-02f, 1.16334282e-01f, 9.78446081e-02f, -9.29543003e-02f, -2.14609969e-02f, 6.93966076e-02f, 4.60230298e-02f, -4.64659259e-02f,
  6.76221699e-02f, -1.43266320e-01f, -4.17687139e-03f, 1.63675323e-01f, 1.25185892e-01f, 1.40845776e-01f, -1.55805439e-01f, 3.91266756e-02f, 1.16161242e-01f, 1.03677645e-01f,
  9.27068889e-02f, 1.26515567e-01f, -1.38747603e-01f, 1.40813649e-01f, 1.17664732e-01f, 1.70535684e-01f, -2.04967245e-01f, -9.37280655e-02f, 1.50289834e-01f, -2.14492500e-01f,
  5.01331240e-02f, 1.02414317e-01f, -1.43092021e-01f, -6.32260069e-02f, -8.41345545e-03f, -5.49715608e-02f, 9.83762443e-02f, 1.02707809e-02f, -1.82635903e-01f, -1.12914406e-02f,
  -2.68002991e-02f, -5.01724705e-02f, 9.12921317e-03f, 1.29506793e-02f, -3.92234437e-02f, 3.59052978e-02f, 9.20584425e-02f, 3.76822390e-02f, 8.75272006e-02f, 2.20454112e-01f,
  7.81612694e-02f, 1.35114938e-01f, 1.95846707e-01f, 3.07288975e-01f, 1.83838889e-01f, -8.57175812e-02f, -1.17656114e-02f, 2.60860860e-01f, 2.65276879e-01f, -1.83809280e-01f,
  1.61744013e-01f, 8.08764249e-02f, -1.14622079e-01f, 3.30741853e-01f, 1.86306179e-01f, -7.39961118e-02f, 1.83179826e-01f, 3.37141156e-01f, -2.43498310e-02f, 5.80710769e-02f,
  3.16635817e-02f, -1.71295613e-01f, -1.91024840e-02f, 2.40393262e-02f, 2.97698099e-02f, -1.53022915e-01f, 3.07820529e-01f, 2.73333818e-01f, 9.73063856e-02f, -3.61439139e-02f,
  -7.78576732e-02f, 1.20307673e-02f, -8.53075236e-02f, 7.47627094e-02f, 1.23907343e-01f, 6.30932068e-03f, -1.97924245e-02f, 1.16077870e-01f, -6.62305728e-02f, 1.98545456e-02f,
  -4.56156284e-02f, -5.22084758e-02f, 1.60747871e-01f, -2.98072785e-01f, -3.66674624e-02f, 1.42538771e-01f, -3.12813967e-01f, -1.63462579e-01f, -6.05326630e-02f, 8.59991014e-02f,
  -1.50945365e-01f, -8.10054839e-02f, -1.72782496e-01f, -3.00388068e-01f, 8.07152241e-02f, -1.38231888e-01f, 1.69431388e-01f, 2.84557529e-02f, 1.04662225e-01f, 7.41691068e-02f,
  -2.17518732e-01f, 4.49806685e-03f, 2.65113622e-01f, 2.27477681e-02f, 1.06084105e-02f, -6.09953478e-02f, -1.43172607e-01f, -1.10709548e-01f, 3.21977913e-01f, 6.90653622e-02f,
  1.78059489e-01f, 2.99281806e-01f, -8.92611668e-02f, -3.10431749e-01f, 4.05420884e-02f, -2.21954584e-01f, -5.05168457e-03f, 1.03518032e-01f, -1.04491562e-01f, -2.07958043e-01f,
  -8.51825401e-02f, 1.15273751e-01f, -1.49604768e-01f, 2.12945770e-02f, 5.43669797e-02f, 4.05302644e-02f, -4.31951601e-03f, -1.86884791e-01f, -2.81250977e-04f, 4.09721350e-03f,
  9.40785408e-02f, -5.22997417e-02f, 6.02217168e-02f, 1.18162390e-02f, 6.76143691e-02f, -9.48506817e-02f, 1.77443340e-01f, -2.24351123e-01f, 8.46106112e-02f, 1.16378799e-01f,
  1.46201804e-01f, -4.33955528e-02f, -7.82524347e-02f, 8.06212518e-03f, 5.16490117e-02f, -2.77667314e-01f, -8.04333016e-02f, -4.45242338e-02f, -1.80260949e-02f, 3.75279002e-02f,
  -1.49230480e-01f, 1.66161790e-01f, -6.31050542e-02f, 7.99712911e-02f, 8.89774859e-02f, -1.09205902e-01f, 1.64028659e-01f, 1.42707735e-01f, 3.15269898e-03f, 2.46200979e-01f,
  1.63433507e-01f, -2.07158644e-02f, -9.06868950e-02f, 1.25769526e-01f, 1.29809737e-01f, 7.78184906e-02f, 1.08901091e-01f, -2.05396846e-01f, -6.73010349e-02f, 1.53619096e-01f,
  5.93028963e-02f, 9.09935385e-02f, 1.30036294e-01f, -1.96353778e-01f, -3.06119949e-01f, 1.38251036e-01f, 6.31154999e-02f, -3.14169168e-01f, -5.74720511e-03f, -1.55095577e-01f,
  -1.45398274e-01f, -3.45154963e-02f, -4.34670299e-02f, -4.00050342e-01f, 2.28000190e-02f, -1.67090312e-01f, -9.75629687e-02f, -3.86508629e-02f, 2.77717978e-01f, -2.72521172e-02f,
  2.96768218e-01f, -3.49036574e-01f, -2.21581370e-01f, -1.02682039e-01f, -2.77965695e-01f, -1.36372119e-01f, -2.85548940e-02f, 5.29275537e-02f, -1.58766761e-01f, 1.44901380e-01f,
  2.94225454e-01f, 9.29184854e-02f, -4.34672758e-02f, -1.33243222e-02f, 2.68119186e-01f, 6.95366785e-02f, 1.80344582e-01f, -6.91166073e-02f, -1.03034708e-03f, 2.30348349e-01f,
  -1.69406623e-01f, 1.06044218e-01f, -7.33128889e-03f, 1.72288939e-01f, -8.66022706e-02f, -3.99362743e-02f, 2.64952481e-02f, 2.68771678e-01f, 2.12447494e-01f, 1.47506103e-01f,
  -4.77837138e-02f, 2.51897991e-01f, -2.15023267e-03f, 4.93666865e-02f, 7.92606547e-02f, -2.15752900e-01f, -1.69393733e-01f, 2.40456108e-02f, 1.22924477e-01f, 6.19804673e-02f,
  -2.02935636e-01f, 9.97216180e-02f, 1.01105101e-01f, -2.54646659e-01f, 3.36630717e-02f, 8.21614191e-02f, -2.14445248e-01f, -2.78863639e-01f, 3.53987478e-02f, 1.20137081e-01f,
  1.29020691e-01f, 5.31270623e-01f, -9.21020731e-02f, 7.24228546e-02f, 1.30858988e-01f, 3.69074405e-03f, -2.75325447e-01f, 1.51666045e-01f, 9.84483808e-02f, -6.05300516e-02f,
  3.72615270e-02f, 6.67958334e-02f, -3.16939175e-01f, 1.91741243e-01f, -9.68150496e-02f, 2.16846675e-01f, 1.66553542e-01f, -1.66734010e-01f, -1.07963450e-01f, -1.53240934e-01f,
  -4.66313288e-02f, 1.99600831e-01f, -1.63675949e-01f, 1.55567676e-01f, 1.16481438e-01f, 1.46384344e-01f, 3.91072175e-03f, 7.22975377e-03f, 8.90829191e-02f, 9.07559320e-02f,
  1.53629526e-01f, 2.14375749e-01f, -1.22284859e-01f, -2.18067810e-01f, 1.82610288e-01f, 1.32010326e-01f, -9.09470990e-02f, -1.69908583e-01f, -3.48078855e-03f, 5.02538383e-02f,
  1.57193407e-01f, -5.42747565e-02f, -1.52917832e-01f, 1.21101432e-01f, -5.99329025e-02f, 1.08353123e-01f, 4.95878570e-02f, 3.03997984e-03f, -2.02481344e-01f, 9.20559764e-02f,
  2.08426565e-01f, 3.07901800e-02f, -1.42421275e-01f, -7.68226162e-02f, -1.93759292e-01f, 1.29055113e-01f, 7.70423859e-02f, -3.86182293e-02f, -3.15926075e-01f, -9.44918916e-02f,
  -2.61725217e-01f, -1.18385620e-01f, -4.33523655e-02f, -3.68786715e-02f, 2.13631764e-01f, 3.25538456e-01f, 9.22505632e-02f, -2.09270176e-02f, -1.32874131e-01f, -7.05955271e-03f,
  1.07457377e-01f, 2.75581498e-02f, 6.36648983e-02f, 3.01131196e-02f, 6.55982792e-02f, -9.93827283e-02f, -7.07092732e-02f, 8.84744674e-02f, -1.20137356e-01f, 7.51407221e-02f,
  -6.71083555e-02f, -1.67796567e-01f, -1.79682776e-01f, -1.40122443e-01f, 9.41654667e-02f, 1.91755772e-01f, -4.64764647e-02f, -3.81996110e-02f, 1.25175595e-01f, 7.64280632e-02f,
  1.37786165e-01f, 8.28305818e-03f, -1.87470406e-01f, -4.26569581e-02f, 1.28426507e-01f, -1.34928040e-02f, -1.04287095e-01f, -8.94768238e-02f, 5.77711910e-02f, -1.28915142e-02f,
  1.51479363e-01f, -4.10995372e-02f, 7.38514438e-02f, -4.36871164e-02f, 2.19409000e-02f, -1.24971569e-01f, -1.59179285e-01f, -4.96144183e-02f, -1.59491643e-01f, -6.41345531e-02f,
  -6.68993872e-03f, 1.54685089e-02f, 6.76589757e-02f, 6.84535727e-02f, -4.49404381e-02f, -1.15052588e-01f, 1.11765057e-01f, 6.98169470e-02f, 2.24402632e-11f, -1.92739297e-10f,
  4.44977909e-11f, -7.02931257e-13f, -1.79938373e-11f, -3.32553915e-11f, -3.96863532e-13f, -1.52208026e-13f, -1.54893210e-12f, 1.21928171e-11f, -2.51602623e-12f, 7.60502078e-12f,
  -6.49936283e-08f, -1.66471955e-06f, 3.20540461e-09f, 2.95433491e-12f, 5.04756115e-40f, -1.83929819e-06f, -7.26917733e-06f, -1.93611868e-05f, -2.11492263e-20f, -3.00463040e-12f,
  -2.91568434e-16f, -3.30473005e-09f, -4.91913214e-40f, -6.93375088e-12f, -4.12180901e-10f, -3.12905002e-13f, 3.80619554e-06f, 9.83049659e-08f, 1.21957934e-12f, -1.93389178e-06f,
  -4.94107648e-40f, -1.05890490e-15f, -1.00759236e-11f, -1.05747235e-14f, -6.28895123e-08f, -1.19401008e-11f, -2.34204017e-05f, -6.80919329e-05f, -1.11370916e-07f, -2.92411890e-08f,
  3.11602896e-11f, 4.93736304e-40f, 4.08251162e-06f, -4.94511222e-40f, -1.14473630e-06f, -1.28563618e-29f, -3.91987136e-08f, -1.08798938e-32f, -2.48950180e-18f, 1.84768230e-27f,
  4.97982238e-40f, -2.13072546e-08f, -4.90998166e-40f, -6.28550412e-09f, -7.84423992e-06f, 4.90723512e-40f, -2.68137650e-16f, -6.46297412e-05f, 4.91967865e-40f, -5.49476208e-05f,
  -4.91295242e-40f, -6.42968644e-06f, -2.18346462e-01f, 1.42301917e-01f, 1.49254963e-01f, -3.85197327e-02f, -1.02140538e-01f, 4.48003598e-02f, -1.46648988e-01f, -3.34816694e-01f,
  -3.39842662e-02f, 2.16603816e-01f, 1.65161163e-01f, 4.06526893e-01f, 5.76016121e-02f, 4.85928133e-02f, 1.48762703e-01f, 4.43164781e-02f, -1.43655315e-01f, -1.77902915e-02f,
  1.13745332e-01f, 1.34172380e-01f, 1.76407456e-01f, 1.30090509e-02f, -1.06392339e-01f, 9.57317278e-02f, 3.31717320e-02f, 1.04280412e-01f, 1.25331968e-01f, -1.95554039e-03f,
  -1.34511441e-01f, 1.72443017e-01f, 1.66989975e-02f, 2.05068499e-01f, -2.26637740e-02f, 1.23259768e-01f, 1.42725527e-01f, 2.02147719e-02f, 6.25088885e-02f, 1.78804755e-01f,
  -3.22716609e-02f, -3.73070166e-02f, -2.76431832e-02f, 2.07438827e-01f, -5.67591935e-02f, -2.04379186e-01f, 1.19934499e-01f, 8.64354372e-02f, 3.74020226e-02f, -1.13867288e-02f,
  -7.68877119e-02f, -4.00841199e-02f, 1.17008254e-01f, -1.95727125e-01f, -6.99523836e-02f, 8.46100971e-02f, -2.01316237e-01f, 4.13093977e-02f, 1.09891929e-02f, 2.11043447e-01f,
  -4.18231823e-02f, -3.07918563e-02f, 2.06767261e-01f, -1.52289271e-01f, 7.06245974e-02f, -1.37744486e-01f, 1.69193983e-01f, -5.61188199e-02f, 1.70926154e-01f, 1.90550443e-02f,
  -1.00320905e-01f, 1.56502217e-01f, 1.51285589e-01f, 2.33771592e-01f, -7.95652568e-02f, -2.26758476e-02f, -1.38162896e-01f, -2.91676730e-01f, 9.26321000e-03f, -2.32513919e-01f,
  -1.18188158e-01f, 3.89368720e-02f, 4.63929117e-01f, -1.37116715e-01f, 5.17766215e-02f, 1.75086632e-01f, -1.42309383e-01f, -2.55520679e-02f, 2.98871219e-01f, -1.45918801e-01f,
  1.29650667e-01f, -8.90332833e-02f, -1.95624396e-01f, 6.56720996e-02f, 3.81370522e-02f, 1.55252665e-01f, 7.98913836e-02f, 1.40699640e-01f, 2.51398116e-01f, -1.18924551e-01f,
  -3.98729853e-02f, 7.46181980e-02f, 4.13823463e-02f, 1.41410485e-01f, -5.52595071e-02f, -5.63670769e-02f, -1.81499440e-02f, -2.92447470e-02f, 1.82359964e-01f, 2.49060206e-02f,
  -2.02873603e-01f, -8.47489685e-02f, 1.84990451e-01f, 3.80642079e-02f, 6.73791021e-02f, 1.51327640e-01f, 1.24377226e-02f, 1.52192175e-01f, -1.34781599e-01f, -3.73263843e-02f,
  -9.85992327e-02f, 1.44242004e-01f, -1.08074963e-01f, 7.46183917e-02f, 2.25024506e-01f, -1.32064685e-01f, -1.07095540e-01f, -9.00622755e-02f, 1.19809896e-01f, -1.07171364e-01f,
  9.52841714e-02f, 2.86284596e-01f, 9.69328433e-02f, 2.62710482e-01f, 8.55830461e-02f, 1.21097714e-01f, 1.44215509e-01f, -4.43578523e-04f, 3.92714322e-01f, 3.71891141e-01f,
  -3.72086167e-01f, 1.06763981e-01f, -1.37021795e-01f, 9.36701223e-02f, 1.46907568e-01f, 8.49774033e-02f, 1.95614979e-01f, 1.56788021e-01f, -1.02409031e-02f, 1.18080407e-01f,
  -1.45535052e-01f, -1.09100737e-01f, -1.70714989e-01f, 2.35810261e-02f, -4.07840684e-03f, 1.36004925e-01f, -1.51103735e-01f, 3.57924961e-02f, 1.65453274e-02f, 4.75514606e-02f,
  6.47078976e-02f, 1.41605049e-01f, -9.11855549e-02f, 1.63280457e-01f, 2.56239325e-01f, -2.22576156e-01f, 6.02122657e-02f, 3.79027277e-02f, -1.45506382e-01f, 5.39958775e-02f,
  -4.71880706e-03f, 4.78988700e-02f, 9.20315310e-02f, -3.63168232e-02f, 1.74904972e-01f, 1.23389261e-02f, 2.11045682e-01f, -7.68263713e-02f, 3.40057760e-01f, 2.42887422e-01f,
  -8.15813318e-02f, 1.68205902e-01f, -9.71771404e-02f, -5.60665987e-02f, 1.03780754e-01f, -1.55660864e-02f, -5.24147861e-02f, 1.32542327e-01f, -1.09919205e-01f, 3.74396034e-02f,
  -5.40588796e-02f, -6.78408816e-02f, -9.10707861e-02f, -3.60169485e-02f, -3.38485241e-01f, -1.84430555e-01f, -7.46168792e-02f, -9.69776958e-02f, -2.70492971e-01f, -1.54866055e-01f,
  -4.51854110e-01f, 7.30476081e-02f, -3.38811725e-02f, -6.04388565e-02f, 1.51959270e-01f, 3.39452058e-01f, 6.29906952e-02f, -1.37806058e-01f, 1.12046026e-01f, -3.66645962e-01f,
  2.16216236e-01f, -2.44659055e-02f, -1.00172155e-01f, -4.15836647e-02f, 3.56966853e-01f, 1.06485926e-01f, 1.81498937e-02f, 4.80345227e-02f, 1.05764993e-01f, 1.14359073e-02f,
  2.45197371e-01f, 1.25995902e-02f, 3.00089829e-03f, -5.04472069e-02f, 1.24056362e-01f, 2.70571839e-02f, 3.14072967e-01f, 2.36906186e-02f, -1.18993014e-01f, -7.75377033e-03f,
  1.68598026e-01f, 1.96451217e-01f, 1.27312541e-01f, 8.77578855e-02f, 6.91412017e-02f, 1.07801929e-01f, 2.35742307e-03f, -3.59129906e-01f, 1.79604273e-02f, 1.92093775e-01f,
  -8.75090063e-02f, 1.08330697e-01f, -1.21904619e-01f, 2.85875294e-02f, -8.77921954e-02f, -3.58526140e-01f, 1.27223045e-01f, 2.98425436e-01f, 8.63669142e-02f, 1.74935982e-01f,
  3.34901288e-02f, 1.54508039e-01f, 1.02710873e-01f, -1.12499278e-02f, 2.29620650e-01f, -9.67226736e-03f, 2.13377267e-01f, 1.54952155e-02f, 4.90461469e-40f, 4.92344814e-40f,
  4.91155112e-40f, 4.90951923e-40f, 4.94152489e-40f, -4.94581286e-40f, 4.94317842e-40f, -4.93645219e-40f, -5.09112752e-40f, 4.93697067e-40f, -4.95050721e-40f, -4.94532241e-40f,
  -2.25033387e-16f, 4.92803039e-40f, -2.60358958e-34f, 4.92475135e-40f, 4.92088377e-40f, 3.03194745e-40f, -1.34410863e-18f, 1.16921214e-18f, -9.05542844e-30f, -1.25500082e-32f,
  4.94613516e-40f, -4.65952759e-40f, 4.94330454e-40f, 4.93859618e-40f, -3.30072252e-22f, -4.94561668e-40f, -4.03993688e-29f, -6.09640674e-21f, 5.72859894e-21f, -7.95231671e-30f,
  -4.92333604e-40f, -2.07842020e-16f, -4.93283684e-40f, -1.28023148e-13f, -1.98645584e-18f, -3.46998519e-19f, -1.01572337e-15f, -1.60282891e-18f, -2.25294593e-18f, -2.29409523e-23f,
  -4.93653627e-40f, 4.91072435e-40f, -2.91187900e-20f, -4.92070160e-40f, 4.94711607e-40f, -1.80625698e-31f, -4.92504562e-40f, -4.92015509e-40f, -1.81957698e-19f, 4.94172107e-40f,
  4.92941767e-40f, 7.06073596e-35f, 6.19493032e-40f, 3.88853607e-26f, 4.91390530e-40f, -4.94770462e-40f, 1.92728187e-38f, 1.07548901e-35f, 4.95050721e-40f, -3.15717945e-18f,
  -4.94913394e-40f, 4.94792883e-40f, 1.22369456e-04f, -1.86491990e-03f, 3.88082955e-03f, -5.75369364e-03f, 1.45558137e-04f, 1.14403327e-03f, 5.47801144e-03f, -4.10882523e-03f,
  -2.20496044e-03f, -4.46847000e-04f, -5.46689983e-03f, 4.73614316e-03f, -1.13818089e-04f, -2.30007432e-02f, -1.88411009e-02f, -1.66853389e-03f, -4.93800763e-40f, -7.99928326e-03f,
  -1.15749280e-07f, -5.77086515e-28f, -1.11145458e-21f, -1.70104913e-02f, -1.46950388e-05f, -2.28133637e-14f, -8.87632177e-06f, -1.19236242e-02f, -4.04996208e-05f, -4.94521031e-40f,
  -2.36864220e-02f, 3.35503850e-25f, -6.48741416e-09f, -7.08974994e-06f, -8.53387361e-25f, -7.52633753e-07f, -4.51239089e-12f, 1.50119577e-05f, -2.03760351e-06f, -2.42175187e-08f,
  -7.07896845e-03f, -7.89827682e-05f, 1.29006046e-04f, -1.81131998e-08f, -2.15498116e-02f, 3.69914264e-14f, -1.11494800e-02f, -2.11613177e-21f, -1.64148859e-13f, 5.65475830e-06f,
  -4.04637447e-03f, -5.80621012e-40f, -2.74889861e-10f, 4.80356319e-20f, -1.30534919e-13f, -1.85619611e-02f, -4.94588293e-40f, -2.63609365e-03f, -1.49544207e-02f, -4.91440977e-40f,
  -8.80520223e-12f, -8.50213168e-04f, -4.94721416e-40f, -3.12365722e-02f, 3.75393199e-07f, -3.10587361e-02f, -1.73118308e-01f, 1.78125694e-01f, 2.25953922e-01f, -1.33476164e-02f,
  2.51102656e-01f, -9.92982164e-02f, -2.19274193e-01f, 7.42326723e-04f, 1.61696076e-01f, 4.80635613e-02f, -2.35507876e-01f, 1.34793118e-01f, -5.16244546e-02f, 6.19475357e-02f,
  2.35512063e-01f, -5.10756254e-05f, 2.07536835e-02f, 2.67701179e-01f, 5.00157624e-02f, 3.09744626e-01f, -3.50023136e-02f, 1.52679980e-01f, -6.85302615e-02f, -5.56941554e-02f,
  -7.89382234e-02f, 1.31277174e-01f, 1.94357887e-01f, 1.50292933e-01f, 1.81271002e-01f, 1.87233627e-01f, -9.02463719e-02f, -5.98563105e-02f, 1.23411514e-01f, 7.69354850e-02f,
  -2.29861274e-01f, 8.98722187e-02f, -2.88625453e-02f, 2.50111632e-02f, 1.05870873e-01f, -5.86782135e-02f, -1.07266203e-01f, 2.38915309e-01f, -8.19242150e-02f, -5.13515025e-02f,
  9.01604518e-02f, -2.89636582e-01f, -2.58214235e-01f, -1.75251499e-01f, 2.99108797e-03f, 2.70804553e-03f, 1.89516246e-01f, -6.56823218e-02f, 6.82417257e-03f, -1.27021661e-02f,
  -4.10396345e-02f, 1.71250030e-02f, -1.58330053e-03f, -1.44831669e-02f, -4.21052873e-02f, 1.27655119e-01f, 1.49426222e-01f, 1.22025356e-01f, -2.64671773e-01f, -9.28885937e-02f,
  3.72471958e-01f, 2.41795257e-01f, 4.75662798e-02f, 5.67703359e-02f, 8.88380408e-02f, 2.34310851e-01f, 3.20432216e-01f, 1.25856757e-01f, 1.10355355e-01f, 3.53385359e-01f,
  -1.90983877e-01f, -3.71286571e-01f, -6.23894222e-02f, -2.43302241e-01f, -4.11567045e-03f, 1.85699925e-01f, 1.85853168e-01f, -2.15283558e-01f, 1.25941858e-01f, 2.45085716e-01f,
  -1.97943881e-01f, -1.87044054e-01f, -4.73834909e-02f, 5.42124845e-02f, 5.69210574e-02f, -2.95323879e-01f, -4.93709557e-02f, -1.50887534e-01f, 1.12326480e-01f, 1.22562513e-01f,
  4.61889207e-02f, 5.29442132e-02f, 7.90398568e-02f, -7.87069201e-02f, 1.77408546e-01f, 9.18032322e-03f, 5.52943349e-02f, 2.46253237e-02f, -1.71685353e-01f, 1.25870809e-01f,
  -5.79785742e-02f, -5.21574132e-02f, 1.12527631e-01f, -2.42794678e-01f, -6.59957230e-02f, -2.16380909e-01f, 2.36579224e-01f, 1.38591398e-02f, -9.58999768e-02f, -5.29454164e-02f,
  -1.68525845e-01f, 2.52844244e-01f, -4.43347879e-02f, -2.02545792e-01f, 1.00372255e-01f, -8.13420787e-02f, 6.88223122e-03f, -2.84108939e-03f, 1.20773889e-01f, -7.55461901e-02f,
  -5.62298112e-02f, 1.68612376e-01f, 3.04111168e-02f, 1.11200176e-02f, -1.26627505e-01f, 1.50519088e-01f, 6.51155636e-02f, 8.59919637e-02f, 1.48937657e-01f, -5.11487648e-02f,
  -3.05698216e-01f, -1.09601811e-01f, -1.08045980e-01f, -7.38010779e-02f, 4.57179517e-01f, 2.86346167e-01f, 6.49913540e-03f, -1.29546985e-01f, -7.83880204e-02f, 6.37267763e-03f,
  -8.44211951e-02f, -1.32725969e-01f, 1.39191542e-02f, -1.88727349e-01f, 2.97182202e-01f, -2.45548859e-01f, -6.31703585e-02f, 2.71249831e-01f, -1.54304549e-01f, -1.34949952e-01f,
  -2.57670116e-02f, -9.53228399e-02f, -1.90500878e-02f, -1.22283272e-01f, -2.19660997e-02f, 1.73351973e-01f, -1.83190167e-01f, 6.44439086e-02f, 3.33737105e-01f, 4.29511182e-02f,
  2.27836072e-01f, 1.52392924e-01f, -2.44826645e-01f, -1.07124373e-01f, 2.22471640e-01f, 3.79242636e-02f, 1.52545482e-01f, -3.35789412e-01f, -5.00283316e-02f, 5.64573586e-01f,
  2.49517888e-01f, 1.54749557e-01f, 3.12503099e-01f, 1.79705105e-03f, -1.05735753e-02f, -2.94201821e-03f, -7.89120868e-02f, 4.19249117e-01f, 9.19849724e-02f, 2.73646206e-01f,
  -1.94924578e-01f, 7.66009539e-02f, 4.74972501e-02f, -3.19255074e-03f, -1.23871854e-02f, -4.35731150e-02f, 2.00868189e-01f, -1.24547377e-01f, 1.75411224e-01f, -3.53952125e-02f,
  3.09239149e-01f, 1.16824470e-01f, 2.65623808e-01f, 2.31890872e-01f, -8.77531543e-02f, -4.16378468e-01f, -2.74496108e-01f, 1.80368423e-01f, 1.00420289e-01f, 9.44608152e-02f,
  1.70796931e-01f, -1.58705473e-01f, -1.33363083e-01f, 1.11447968e-01f, -1.05265923e-01f, 7.75167942e-02f, 1.27653718e-01f, 2.59086281e-01f, 1.44852087e-01f, 3.04793697e-02f,
  2.14268435e-02f, 4.95450497e-02f, -8.24072212e-02f, 2.64674071e-02f, 8.21430683e-02f, -2.81314313e-01f, -8.24012086e-02f, 2.42925391e-01f, 1.61271125e-01f, 1.78931579e-01f,
  -1.32258952e-01f, 7.51524419e-02f, 9.59491581e-02f, 2.74101347e-01f, 8.55998918e-02f, -5.10719903e-02f, -1.55220985e-01f, 1.38454745e-02f, 2.42491052e-01f, -6.53389022e-02f,
  -1.34435028e-01f, 6.33426309e-02f, -6.03463240e-02f, -3.94877195e-02f, 8.50108862e-02f, 1.72353938e-01f, -3.27728152e-01f, -2.46049225e-01f, 1.65346980e-01f, 1.49784759e-01f,
  -1.06416740e-01f, -1.79530736e-02f, -2.65444189e-01f, -1.74171880e-01f, 1.87394954e-02f, -1.53934564e-02f, 1.70431569e-01f, -1.07344680e-01f, -5.51912040e-02f, -1.79783329e-01f,
  -4.54046726e-02f, -1.49077699e-01f, -3.31274748e-01f, 1.86000183e-01f, 2.31889069e-01f, -4.95259166e-02f, 9.94955376e-02f, -3.65937985e-02f, -3.10117424e-01f, 1.44436106e-01f,
  2.02226695e-02f, -1.20478459e-01f, -1.05192356e-01f, 2.22408399e-01f, -4.68320623e-02f, 1.33402020e-01f, 2.96629936e-01f, -2.07140163e-01f, -4.75264504e-04f, 2.86895335e-01f,
  3.64031084e-02f, 1.85026750e-01f, 2.97187358e-01f, 1.98301077e-01f, -1.16586715e-01f, 1.69723228e-01f, 1.02134235e-02f, 3.31846982e-01f, 2.62902528e-01f, 1.70127556e-01f,
  1.53943330e-01f, 6.26349375e-02f, -1.58798590e-01f, -4.96748053e-02f, 2.81328470e-01f, -6.90163299e-02f, -2.67872334e-01f, 1.97382625e-02f, 1.43602341e-01f, 9.49731544e-02f,
  1.07390366e-01f, -7.48358443e-02f, 8.72471333e-02f, -2.78313439e-02f, 5.26266731e-02f, 9.73545387e-02f, 9.22384784e-02f, 5.92692429e-03f, -1.06459513e-01f, -1.77670009e-02f,
  2.18678668e-01f, 8.72285590e-02f, -1.78308189e-02f, -2.40626380e-01f, -4.06140871e-02f, 7.95789883e-02f, 3.78006771e-02f, 3.45758274e-02f, 2.31550276e-01f, 1.21404603e-01f,
  -1.13767251e-01f, 8.76385644e-02f, 1.99255943e-01f, 1.38537586e-03f, -2.96046976e-02f, -1.42565027e-01f, 2.61326674e-02f, -3.10765989e-02f, -1.69914383e-02f, 1.76560581e-01f,
  -2.10765168e-01f, 1.85477853e-01f, -1.82468385e-01f, 1.40576497e-01f, 3.19151022e-02f, 2.34880865e-01f, 1.45340323e-01f, 1.18423194e-01f, 5.43714799e-02f, -8.45543202e-03f,
  -1.75097704e-01f, 8.74091685e-02f, 4.10033047e-01f, 2.53230501e-02f, -1.87224165e-01f, 1.90574765e-01f, 2.66759664e-01f, -1.91305861e-01f, 9.37649235e-02f, -8.91199484e-02f,
  1.03856973e-01f, -5.17044626e-02f, -2.71107368e-02f, -1.09914564e-01f, -6.55071065e-02f, 2.12368388e-02f, 2.28792146e-01f, 2.22210243e-01f, 3.48543137e-01f, -9.09578986e-03f,
  8.38392824e-02f, 7.61513710e-02f, 2.49316335e-01f, 7.46629834e-02f, -2.04619601e-01f, -1.20666176e-01f, 8.90778452e-02f, -1.91984817e-01f, 5.10406122e-02f, -1.39908612e-01f,
  3.11103812e-03f, 1.15660327e-02f, 2.64834344e-01f, 2.27982134e-01f, -2.13361848e-02f, 1.59963313e-02f, 3.30743231e-02f, 1.63157806e-02f, 8.25372115e-02f, -1.14646681e-01f,
  -2.33533725e-01f, 1.01897508e-01f, -1.56634692e-02f, 1.34256303e-01f, 3.03158671e-01f, 9.44491699e-02f, 6.80906475e-02f, -1.84404492e-01f, 2.42145702e-01f, 5.96356243e-02f,
  2.03919977e-01f, 1.24016203e-01f, -2.46068207e-03f, 2.42581740e-02f, 7.22683594e-02f, 7.44336322e-02f, 3.70103978e-02f, -9.56520289e-02f, 3.16391766e-01f, 2.61270106e-01f,
  -3.08315814e-01f, -3.75866294e-02f, -1.60283167e-02f, -3.58558423e-03f, 1.60521626e-01f, 2.04270646e-01f, -1.69656575e-01f, -1.50087960e-02f, 1.34493232e-01f, 9.37573463e-02f,
  -1.16258159e-01f, -1.24507323e-01f, -1.64385960e-01f, 1.18513964e-01f, -1.25448525e-01f, 7.51516372e-02f, 2.75259633e-02f, 3.87417339e-02f, 4.65556793e-02f, 5.00090681e-02f,
  -4.67109159e-02f, 2.16463134e-02f, -1.16441429e-01f, 8.13259333e-02f, 2.79233336e-01f, -1.03957400e-01f, 1.55454740e-01f, 1.85473207e-02f, 3.27511765e-02f, 1.58318132e-01f,
  -7.73127526e-02f, 4.43138368e-02f, 1.65563181e-01f, -1.43900618e-01f, -1.59526505e-02f, -1.24195404e-02f, 2.11830512e-01f, -1.03129432e-01f, 1.58271730e-01f, 7.63375163e-02f,
  -6.95963949e-02f, 2.25111797e-01f, -1.75870925e-01f, -1.16446137e-01f, 2.56570607e-01f, -1.62173465e-01f, -4.65319417e-02f, 5.67299277e-02f, -1.87075302e-01f, -6.16676658e-02f,
  -7.60111436e-02f, 1.50664181e-01f, 3.59089263e-02f, 1.11182425e-02f, 4.35187608e-01f, 2.07912803e-01f, 2.32754126e-01f, 3.01992029e-01f, 2.82779336e-01f, 4.47836578e-01f,
  3.13618600e-01f, 2.28115782e-01f, 3.76547351e-02f, -9.10441205e-02f, -4.54746723e-01f, -2.64387012e-01f, -1.17198877e-01f, 2.63379458e-02f, -5.50592765e-02f, 1.42169073e-01f,
  2.99729645e-01f, 3.38474028e-02f, 1.18453398e-01f, 1.64461717e-01f, -2.21877471e-01f, 1.00554014e-02f, 2.30287716e-01f, -2.08823830e-01f, 1.07224680e-01f, -1.31041050e-01f,
  -5.37942462e-02f, -1.40311986e-01f, -4.55564214e-03f, 3.03406846e-02f, 8.59035626e-02f, -8.32294375e-02f, -1.14641920e-01f, 1.20645493e-01f, 6.00354075e-02f, -6.18978329e-02f,
  -1.11841463e-01f, -8.39746371e-03f, -6.67384565e-02f, 3.61629613e-02f, -8.20007026e-02f, -1.77784234e-01f, -2.03427076e-02f, 2.43797094e-01f, -8.30132589e-02f, -3.03756714e-01f,
  2.02389613e-01f, 1.83105454e-01f, 2.05127642e-01f, -1.80619080e-02f, 1.68206289e-01f, 1.53062269e-01f, -7.32372925e-02f, -3.48644435e-01f, 1.07562862e-01f, -1.70671284e-01f,
  1.27556697e-01f, -1.82110772e-01f, 1.49481833e-01f, -5.86026348e-02f, -6.95747212e-02f, -1.22275837e-01f, -7.24739954e-02f, -3.40438575e-01f, 3.49455237e-01f, 1.57181352e-01f,
  8.61693621e-02f, 6.93596601e-02f, 1.66126877e-01f, 5.55411130e-02f, 2.27974564e-01f, 7.34622851e-02f, 2.76490718e-01f, 1.59179688e-01f, -4.66240227e-01f, -3.49822938e-01f,
  -3.93862724e-02f, -9.37706977e-02f, 8.81987065e-02f, -3.11888233e-02f, 1.02075569e-01f, 1.76173314e-01f, 9.22128037e-02f, -1.46654835e-02f, -4.52596955e-02f, 2.67647090e-03f,
  2.97241355e-03f, -2.60754824e-01f, 1.82377800e-01f, 1.31145030e-01f, -1.36792357e-03f, 6.72564879e-02f, 3.00937206e-01f, 2.57980913e-01f, 1.15399010e-01f, -2.89892524e-01f,
  5.05625755e-02f, -1.35705918e-01f, -7.06681088e-02f, 3.97289125e-03f, 2.00375244e-02f, -9.61120054e-03f, 1.00677773e-01f, -4.85832095e-02f, -8.58401135e-02f, -6.05472028e-02f,
  4.13776077e-02f, 5.57154678e-02f, -7.93932453e-02f, -1.60708785e-01f, -1.89849973e-01f, -5.11646122e-02f, 4.16272469e-02f, 3.30448560e-02f, 6.79834709e-02f, 7.98548609e-02f,
  1.26257986e-01f, -7.87770823e-02f, 1.97807655e-01f, -1.41685419e-02f, 6.55020550e-02f, 1.27714783e-01f, 1.05626673e-01f, 7.67244399e-02f, 6.16186596e-02f, 2.28201404e-01f,
  -4.82212268e-02f, -1.67078570e-01f, -1.68290641e-02f, 1.06222771e-01f, -1.81172658e-02f, 4.58170772e-02f, -7.42458180e-02f, -1.89243499e-02f, -4.94866446e-02f, 2.37635583e-01f,
  2.25098729e-01f, -8.57585520e-02f, -2.93964952e-01f, -6.18710630e-02f, -8.08907449e-02f, -1.25745729e-01f, 1.80913687e-01f, -2.44341642e-01f, 1.92056373e-01f, -8.34637210e-02f,
  -2.52086133e-01f, -8.47797692e-02f, 1.45958707e-01f, -6.50963783e-02f, 9.29188579e-02f, -6.36971667e-02f, 2.63878435e-01f, -1.63296647e-02f, 1.28908947e-01f, 2.00262979e-01f,
  -7.99925774e-02f, -8.53898749e-02f, -1.02602884e-01f, -1.38982713e-01f, 3.24835360e-01f, -1.79858372e-01f, 1.71114672e-02f, -2.56550610e-01f, 3.42898220e-02f, 1.51008099e-01f,
  9.46871117e-02f, -5.20429276e-02f, 8.02873522e-02f, -2.48413086e-01f, 1.72757223e-01f, -1.18708991e-01f, -1.78546995e-01f, 4.63290304e-01f, -4.19118702e-02f, 6.62664771e-02f,
  1.67830866e-02f, 2.43623286e-01f, -1.27782017e-01f, -1.36162177e-01f, 1.78086683e-01f, 2.67084450e-01f, 1.80479422e-01f, 3.19084167e-01f, -1.96834937e-01f, 2.42306381e-01f,
  1.08092502e-01f, -1.14988528e-01f, -6.66029099e-03f, 9.36978161e-02f, 2.69578546e-01f, -6.34452328e-02f, 9.13394839e-02f, 1.48677230e-01f, 1.80029441e-02f, 6.18810020e-02f,
  2.61710823e-01f, 7.39643499e-02f, -4.33277607e-01f, -5.76269068e-02f, 1.80706203e-01f, -1.75704509e-01f, -9.61118862e-02f, 1.11906953e-01f, -1.60776988e-01f, 8.54079723e-02f,
  1.84891716e-01f, -4.81887534e-02f, -9.08052549e-02f, 8.92177504e-03f, -4.99462970e-02f, 6.19822927e-02f, 1.91456988e-01f, -9.01216939e-02f, -1.56940948e-02f, 2.78775513e-01f,
  -4.11047861e-02f, 1.52797043e-01f, 2.31348217e-01f, 1.65778667e-01f, 9.89597812e-02f, 2.01917976e-01f, -1.28579840e-01f, -1.55882761e-01f, -4.68051396e-02f, -2.57193167e-02f,
  5.81969656e-02f, -2.35246513e-02f, -7.76317194e-02f, 1.14661291e-01f, -8.47006813e-02f, -1.18530594e-01f, -1.18951187e-01f, -2.31792659e-01f, 2.25936189e-01f, 9.77422446e-02f,
  -1.04039088e-02f, 3.52852851e-01f, 1.33611992e-01f, -1.87761873e-01f, 3.42178017e-01f, 1.30177841e-01f, 1.71005756e-01f, 5.85252047e-02f, 2.85206623e-02f, 8.03840160e-02f,
  2.93824583e-01f, -1.03595085e-01f, 1.89009324e-01f, 7.17523471e-02f, -2.10794330e-01f, 1.20696492e-01f, -1.82770878e-01f, -1.39449343e-01f, -1.52319267e-01f, -9.78930444e-02f,
  2.87958831e-01f, 1.01204842e-01f, 9.65644047e-02f, 3.63373160e-02f, 2.41915852e-01f, 1.37356654e-01f, -1.24479115e-01f, -1.15578607e-01f, 1.08952433e-01f, 2.05208510e-01f,
  3.02054659e-02f, 2.41877828e-02f, -1.46894529e-01f, -6.87607452e-02f, 9.70746055e-02f, -1.79348756e-02f, -1.35141194e-01f, -1.04351446e-01f, 9.03346315e-02f, -9.39769968e-02f,
  4.68879752e-02f, -2.50794977e-01f, 2.01523080e-02f, 1.69861749e-01f, -9.04211998e-02f, -1.38992414e-01f, 9.61051881e-02f, 1.50080234e-01f, -2.77846493e-02f, -1.81533247e-02f,
  8.60818550e-02f, 1.84511468e-01f, -1.59346431e-01f, 5.46757504e-02f, 1.60874948e-01f, -1.12726033e-01f, 1.02894835e-01f, 2.37364341e-02f, -1.12395234e-01f, 1.05759911e-01f,
  -5.03717251e-02f, 1.04208797e-01f, 1.88983917e-01f, -1.19410694e-01f, -3.44027393e-02f, 2.56047398e-01f, 2.57955253e-01f, -5.92131093e-02f, 1.60949230e-01f, 7.64372721e-02f,
  -1.66895121e-01f, 2.71616317e-02f, -2.66892016e-02f, 1.44283250e-01f, 2.75016904e-01f, 2.44329825e-01f, -9.19128135e-02f, 6.77805021e-02f, 3.47411656e-03f, 1.04380563e-01f,
  -6.27628565e-02f, 3.88889201e-02f, 6.68563023e-02f, 1.64077431e-03f, 3.07935655e-01f, 1.98662989e-02f, 2.22228095e-01f, 2.73523659e-01f, 2.72025853e-01f, 3.44012260e-01f,
  1.39406413e-01f, 1.22319818e-01f, -8.74389634e-02f, 4.90701466e-04f, -1.67763636e-01f, -2.02841848e-01f, 1.39029501e-02f, 8.03788453e-02f, -7.56996498e-02f, -8.57412163e-03f,
  2.97970444e-01f, 1.08056985e-01f, -1.01780156e-02f, 1.27416670e-01f, -5.96813858e-02f, 7.36525208e-02f, 1.91253290e-01f, -2.41326436e-01f, 1.53172806e-01f, -4.60286699e-02f,
  -1.04330912e-01f, -3.15698609e-02f, 5.97011065e-03f, 8.92481133e-02f, -1.58877615e-02f, 2.73890197e-02f, -1.45967752e-02f, -3.51449102e-02f, -1.78713407e-02f, 1.08753122e-01f,
  -8.06631222e-02f, -9.60042328e-02f, -1.28335685e-01f, -4.44327742e-02f, 9.05482695e-02f, -1.50798559e-01f, -7.33574340e-03f, 2.87478924e-01f, -1.24010272e-01f, -1.56588852e-01f,
  -2.21726261e-02f, 1.34012833e-01f, 7.76794180e-02f, 6.52542710e-02f, 1.02142923e-01f, 1.54685274e-01f, 8.74659792e-02f, -5.98630346e-02f, -9.83038917e-02f, -1.14675291e-01f,
  6.84859529e-02f, -1.16808280e-01f, 2.27573097e-01f, 5.54068051e-02f, -2.47775707e-02f, -2.08513677e-01f, -6.56847283e-02f, -2.70321608e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  9.88954306e-02f, 7.05350339e-02f, -5.71881495e-02f, -8.82497989e-03f, 4.33064736e-02f, -3.48862745e-02f, -1.43033121e-05f, 1.40588731e-02f, 3.77304852e-02f, 7.00674057e-02f,
  -2.33822372e-02f, 1.89069033e-01f, 5.01799583e-02f, 1.30071416e-02f, -6.04514265e-03f, -5.12536690e-02f, -4.75522839e-02f, 1.28689647e-01f, 1.53099060e-01f, -1.39892399e-01f,
  1.50912315e-01f, 1.72828257e-01f, 3.65282595e-02f, 4.89319898e-02f, -1.01510368e-01f, 3.72643806e-02f, -2.47359164e-02f, 7.50259236e-02f, -7.10990746e-03f, 1.39453337e-01f,
  -3.75241525e-02f, -6.50266036e-02f, -7.42571560e-09f, 1.71867646e-02f, 1.85311079e-01f, 2.91054577e-01f, -4.03458439e-03f, 4.91239190e-40f, -6.45154389e-03f, -8.83930251e-02f,
  2.22885143e-02f, 7.29165524e-02f, 2.93901376e-02f, 6.95862174e-02f, 5.12355231e-02f, 1.53422579e-01f, 1.32863194e-01f, 1.51328757e-01f, 1.27541916e-02f, 7.04143196e-02f,
  9.37451124e-02f, 1.22842342e-02f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -1.45382807e-01f, -6.81612715e-02f, 5.80808409e-02f, -2.93360893e-02f, -1.11191884e-01f, 1.34766117e-01f, 7.66845047e-02f, -1.30274639e-01f, 1.30753100e-01f, 1.75913915e-01f,
  1.47410199e-01f, 8.25783610e-02f, 6.23054728e-02f, 1.58458680e-01f, 6.30149618e-03f, 6.85311183e-02f, -1.24146961e-01f, -7.16651604e-02f, -8.58864678e-06f, -4.06830460e-02f,
  4.63953204e-02f, 5.15708588e-02f, -5.83620295e-02f, 1.06729731e-01f, 4.99163307e-02f, 1.25183493e-01f, 6.47731172e-03f, 1.67252347e-01f, 2.46312097e-01f, -6.26087710e-02f,
  9.49339047e-02f, 2.39734456e-01f, 2.82856911e-01f, 7.16777220e-02f, -1.27120569e-01f, 1.56286553e-01f, 1.72337234e-01f, 2.15013549e-02f, 1.50973499e-01f, -3.67254997e-03f,
  9.36029181e-02f, -2.58052088e-02f, 1.11878432e-01f, 5.48922084e-02f, 3.41234440e-14f, 1.61751851e-01f, 6.07917225e-03f, -6.21326640e-02f, 4.61819321e-02f, 9.11231767e-12f,
  -1.26122322e-04f, 9.37493369e-02f, -6.79290295e-02f, 2.92404562e-01f, 1.76955596e-01f, 2.20568419e-01f, 2.25588694e-01f, -4.88953292e-02f, -1.63551688e-01f, 3.96686643e-02f,
  1.28149033e-01f, 1.96245551e-01f, -3.71072330e-02f, 5.51144443e-02f, 7.77878165e-02f, -1.48527488e-01f, 9.30000171e-02f, 2.92291604e-02f, -1.41934566e-02f, 4.25279774e-02f,
  3.80071588e-02f, 7.05268187e-03f, 8.93952847e-02f, -9.98971537e-02f, -2.55383372e-01f, 1.21972272e-02f, -2.11158678e-01f, 5.85426986e-02f, 2.26420667e-02f, -7.53051043e-02f,
  6.06853189e-03f, -4.58614677e-02f, 2.61091657e-07f, 1.20968692e-01f, 6.73276633e-02f, -1.40639678e-01f, 1.16649687e-01f, -1.11685321e-01f, -8.09734538e-02f, 1.56543795e-02f,
  -4.98857442e-03f, -1.39806464e-01f, -3.41046415e-02f, 1.43400639e-01f, -1.43918529e-01f, -3.81866144e-03f, 1.64732020e-02f, 8.25860128e-02f, 1.01559609e-01f, -4.94969487e-02f,
  3.25065628e-02f, -2.27948781e-02f, -9.11111310e-02f, -1.85033455e-02f, 8.02541077e-02f, -1.34520037e-02f, 3.66179086e-02f, 1.08864130e-02f, -7.65962641e-11f, -1.58067904e-02f,
  9.83611643e-02f, 3.73296179e-02f, -9.10555497e-02f, -5.16277000e-15f, 5.61048773e-06f, -6.03270121e-02f, 1.49277404e-01f, -4.05706316e-02f, -1.26903132e-01f, -1.83869213e-01f,
  5.38715022e-03f, 1.69366956e-01f, 4.27515619e-02f, 4.44914475e-02f, -2.29044929e-02f, -1.16297305e-01f, 6.90440387e-02f, 1.88222956e-02f, -8.35271031e-02f, -8.00485015e-02f,
  2.49451455e-02f, -1.49736866e-01f, -2.86578536e-02f, -5.27217090e-02f, 3.43500562e-02f, -6.18779473e-02f, 1.58633918e-01f, 1.53453052e-01f, 4.81626280e-02f, -7.52488822e-02f,
  -1.09014243e-01f, -1.06153846e-01f, 9.21626091e-02f, -4.33701426e-02f, -1.63465798e-01f, 8.15332960e-03f, 1.12390524e-07f, -3.84121388e-02f, 1.56698719e-01f, 8.55831057e-02f,
  -4.59508188e-02f, -5.38744079e-03f, -8.61111358e-02f, 2.14039505e-01f, -4.93474770e-04f, -4.73380201e-02f, 1.06789976e-01f, -1.34985551e-01f, 6.25271723e-02f, -2.39648633e-02f,
  3.98881286e-02f, 7.38302320e-02f, -7.27788955e-02f, -2.06284642e-01f, 1.47361280e-02f, 3.26378904e-02f, 3.61524262e-02f, -8.42690021e-02f, -8.63035247e-02f, 3.93004864e-02f,
  -8.62137973e-02f, -1.78709794e-02f, 1.25430195e-20f, 1.53771946e-02f, -5.84744066e-02f, -1.31220922e-01f, -3.71315284e-03f, 1.35810525e-26f, 1.45045931e-06f, -1.35119423e-01f,
  -3.29663530e-02f, 1.15892999e-01f, 9.79368463e-02f, 6.63382187e-02f, -1.27305299e-01f, -1.10706985e-01f, -1.47346213e-01f, -7.36651868e-02f, -4.73435745e-02f, -6.86474890e-03f,
  1.17943764e-01f, -3.97972986e-02f, -6.29655942e-02f, -4.48518768e-02f, 5.20326309e-02f, 8.07344466e-02f, 5.12099452e-02f, 1.43746555e-01f, -9.45403427e-03f, -2.42587864e-01f,
  -5.66667542e-02f, 6.95730969e-02f, 1.33498788e-01f, 8.77641141e-02f, 1.42385662e-01f, 6.96787834e-02f, -3.96260852e-03f, 1.88564852e-01f, -6.22290559e-02f, -3.48808914e-02f,
  -3.14980389e-06f, -1.07818931e-01f, -1.64999105e-02f, -1.88005865e-02f, 7.60204857e-03f, 5.88002848e-03f, 3.10595380e-03f, 1.76278293e-01f, -3.20943794e-03f, 4.47849855e-02f,
  1.49110541e-01f, -1.36361703e-01f, 5.56343123e-02f, -5.07953800e-02f, 4.72286157e-03f, -8.35891739e-02f, 8.41446072e-02f, -1.83503442e-02f, 1.31346568e-01f, 9.54581499e-02f,
  3.88391726e-02f, 6.96361288e-02f, 3.77524905e-02f, -6.60682768e-02f, 1.70814127e-01f, 8.93016234e-02f, 1.75466058e-10f, -4.74646091e-02f, 8.81780013e-02f, -1.53848141e-01f,
  2.06276208e-01f, -2.29899168e-16f, -1.09087075e-07f, 1.41143138e-02f, -1.46296337e-01f, -2.88222935e-02f, -3.38221155e-02f, 7.63913095e-02f, -6.56949729e-02f, 3.45426314e-02f,
  -1.33374855e-01f, -6.43530414e-02f, 1.48483992e-01f, -5.70436716e-02f, -1.24742473e-02f, 4.56759334e-03f, -3.02329898e-01f, -1.50743857e-01f, 6.19065985e-02f, 1.24099299e-01f,
  -1.17046408e-01f, -9.63950008e-02f, -1.79963186e-01f, 2.56749332e-01f, 1.23192824e-01f, 1.15026787e-01f, 2.32014984e-01f, -2.02895015e-01f, 1.78873911e-01f, -6.91878945e-02f,
  -4.87444215e-02f, 1.99442841e-02f, -4.87977564e-02f, 1.08895503e-01f, -1.77243351e-07f, 6.86902180e-03f, 8.01242292e-02f, -1.47394300e-01f, 5.96524179e-02f, -1.89743452e-02f,
  -7.52908513e-02f, -2.90097538e-02f, 1.05170580e-03f, -9.98825654e-02f, 9.71892700e-02f, 1.72536355e-02f, 2.03447506e-01f, 3.74590163e-03f, -1.01162121e-01f, -3.35244834e-02f,
  4.25053621e-03f, -6.43856684e-03f, -6.79198876e-02f, 1.04628280e-01f, -6.40198365e-02f, -1.32534891e-01f, -2.57128533e-02f, 1.98003724e-01f, -1.52501434e-01f, -4.29520421e-02f,
  3.96071578e-11f, 7.08954409e-03f, -1.72030166e-01f, -2.02690676e-01f, -1.53228464e-02f, 1.99082413e-23f, 2.04292905e-06f, -9.49972793e-02f, -1.40611187e-01f, 4.43270579e-02f,
  3.37793492e-02f, 4.12225947e-02f, -1.30817205e-01f, 8.81151482e-02f, -2.06217363e-01f, -7.79552609e-02f, 1.33165747e-01f, -2.54043248e-02f, -2.65789386e-02f, -1.12317950e-01f,
  -9.04285461e-02f, 1.40687361e-01f, 9.14080665e-02f, -1.16771080e-01f, -3.28258634e-01f, -6.72918260e-02f, -1.17720179e-01f, 3.90532129e-02f, -2.80485690e-01f, -2.07050834e-02f,
  2.03572750e-01f, 1.74205229e-02f, 1.10968530e-01f, 2.18470562e-02f, -4.45386618e-02f, 1.56246379e-01f, 5.87601960e-02f, 4.61309962e-02f, 3.49270124e-07f, 8.20754990e-02f,
  2.43755840e-02f, 1.01030044e-01f, -1.35775313e-01f, -7.88438544e-02f, 1.47694364e-01f, -4.44495007e-02f, 1.76520017e-03f, 1.94005162e-01f, 2.21703514e-01f, 1.80329736e-02f,
  7.98017439e-03f, 1.27323627e-01f, 1.28852040e-01f, 6.55404925e-02f, 4.83251177e-02f, 9.06390175e-02f, 9.38000157e-02f, 2.07779538e-02f, -1.04455955e-01f, 1.48653090e-02f,
  -5.85669167e-02f, 2.94661261e-02f, 1.81048587e-01f, -6.76210821e-02f, 1.40060073e-11f, -3.54135176e-03f, -1.75890028e-02f, -3.07021160e-02f, 3.23901847e-02f, -3.57346624e-17f,
  -3.16659197e-07f, 7.28858784e-02f, 8.55162963e-02f, 7.74039188e-03f, 1.66621476e-01f, 1.97132483e-01f, -7.93138891e-02f, -5.10301068e-02f, 1.68343894e-02f, 2.42174268e-02f,
  3.51657718e-02f, 2.50452846e-01f, -1.78019493e-03f, 7.97880515e-02f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -1.72708705e-01f, -5.92999756e-02f, 1.75086856e-01f, -8.61720145e-02f, -5.99236898e-02f, -1.54979929e-01f, -1.82788838e-02f, -4.36291434e-02f, 1.47207379e-01f, 6.79053143e-02f,
  2.07664624e-01f, -7.13925362e-02f, 3.61426845e-02f, -7.09464848e-02f, -6.07841276e-02f, -3.75433005e-02f, 1.34067470e-03f, 3.58589217e-02f, -2.78551471e-09f, 2.24648461e-01f,
  3.31586506e-03f, 4.55492698e-02f, 1.53359741e-01f, -5.09746000e-02f, -7.91698620e-02f, 5.75108491e-02f, -3.26627815e-05f, 8.23581442e-02f, 1.16203867e-01f, -1.24934569e-01f,
  1.33859515e-01f, -1.47020072e-01f, -5.38817681e-02f, -4.29361574e-02f, 1.53880287e-02f, 8.10165703e-02f, 1.35665402e-01f, 1.75327763e-01f, -1.19991980e-01f, -1.73587143e-01f,
  -9.46022868e-02f, -1.54004805e-02f, 1.69901513e-02f, 5.34375906e-02f, 8.07986581e-17f, 1.21093281e-01f, 1.55799225e-01f, -2.85447203e-03f, 1.15764543e-01f, 5.48351316e-21f,
  -1.06137040e-05f, 2.48264179e-01f, -2.12486804e-01f, -1.33886158e-01f, -2.20470384e-01f, 2.65633076e-01f, 7.81842880e-03f, 4.93562892e-02f, -2.08838165e-01f, 1.16215244e-01f,
  2.04711646e-01f, 6.10979348e-02f, 6.17148131e-02f, -1.39441386e-01f, -6.89883307e-02f, 1.12919584e-01f, 9.48651345e-04f, -1.27875462e-01f, 1.73262861e-02f, 2.17563808e-01f,
  1.52603850e-01f, 1.25804469e-01f, 9.94161703e-03f, 1.85929257e-02f, 6.96318448e-02f, 6.17974997e-02f, 7.61445090e-02f, 1.05355769e-01f, 3.52038108e-02f, 1.24865267e-02f,
  1.72169581e-01f, -1.36720002e-01f, 1.95031169e-09f, -1.39962330e-01f, 1.57182410e-01f, -4.99632172e-02f, -9.17996168e-02f, 1.47504807e-01f, -1.33724660e-01f, -2.46408731e-01f,
  1.13515370e-03f, 1.52482151e-03f, -1.40994653e-01f, 8.30343068e-02f, 6.95626885e-02f, -1.36675984e-01f, 6.10695891e-02f, 3.21160145e-02f, 2.80442666e-02f, -4.88951318e-02f,
  -4.56312820e-02f, -4.49660793e-02f, -3.71322688e-03f, 1.74676180e-02f, 2.12241009e-01f, 1.61465794e-01f, -7.00985119e-02f, 6.64792676e-03f, -1.67794453e-15f, 1.23622129e-02f,
  1.21911570e-01f, 2.93299593e-02f, 3.22779268e-02f, -4.91057021e-40f, 3.35381589e-09f, -2.46465236e-01f, 1.06456883e-01f, 1.46312803e-01f, 1.72199290e-02f, -2.00513169e-01f,
  1.05792247e-01f, 1.78534657e-01f, -2.92685237e-02f, 2.22970806e-02f, 1.15189649e-01f, -9.53439027e-02f, 1.68349773e-01f, -6.91846535e-02f, -1.63300447e-02f, 7.76705220e-02f,
  5.92764653e-02f, -1.57948956e-02f, -2.04531383e-02f, 1.23291336e-01f, -7.59207979e-02f, -9.09146667e-02f, 4.74221446e-02f, 2.41501495e-01f, 9.20120999e-02f, 3.41322571e-02f,
  -1.20752133e-01f, 1.58746704e-01f, 1.12265766e-01f, -1.76323906e-01f, 1.22431383e-01f, -2.86301345e-01f, -2.50334491e-08f, -4.48237717e-01f, 3.17259669e-01f, -1.73794210e-01f,
  1.18933618e-01f, -5.21482415e-02f, -6.95970207e-02f, -2.23482549e-01f, 1.27932755e-03f, -1.04277112e-01f, 7.94927999e-02f, 3.19667906e-01f, 9.32462588e-02f, -1.48202404e-01f,
  9.55552980e-02f, -1.53351381e-01f, 8.74367431e-02f, -5.36936447e-02f, 2.03653686e-02f, 8.83312244e-03f, 9.06064212e-02f, 9.38617438e-03f, 1.05336539e-01f, 7.97608346e-02f,
  -4.03206423e-03f, 4.51972075e-02f, 8.49792572e-22f, -6.75718561e-02f, 1.11962877e-01f, 1.20637022e-01f, -1.13385998e-01f, -1.45401794e-26f, -9.35815592e-11f, -1.90541372e-01f,
  2.52897918e-01f, 2.12939113e-01f, -4.77677062e-02f, -1.77639097e-01f, 1.08037077e-01f, 8.24959353e-02f, 1.82552904e-01f, 1.12871207e-01f, 6.63265213e-02f, 1.81622744e-01f,
  2.85350740e-01f, -4.99197505e-02f, -8.14262331e-02f, -7.79911056e-02f, -4.83970530e-02f, -7.18004853e-02f, 4.44930829e-02f, 7.74365244e-03f, 3.35104018e-01f, -2.44474977e-01f,
  7.72694200e-02f, -9.27642733e-02f, -5.06182984e-02f, -6.04539476e-02f, -5.54808900e-02f, 1.75216123e-01f, 9.44586620e-02f, 2.30391859e-03f, -6.60035610e-02f, 8.95712748e-02f,
  -3.25987014e-34f, -5.43222129e-02f, 3.27536464e-03f, 1.43435344e-01f, -2.93020576e-01f, 3.41807716e-02f, -1.41168222e-01f, 6.30069375e-02f, -8.02655359e-06f, -1.49688488e-02f,
  9.00379866e-02f, -2.85534728e-02f, -1.28721163e-01f, 1.02381997e-01f, 1.12592682e-01f, 6.10664822e-02f, -1.16940044e-01f, -5.37211597e-02f, 1.30548179e-01f, 2.63517164e-02f,
  6.67598546e-02f, 2.63796058e-02f, -7.45016709e-02f, 3.04436237e-02f, 6.04813658e-02f, 9.80779082e-02f, -4.93223428e-40f, 1.83771655e-01f, -1.68221351e-02f, -4.68429513e-02f,
  1.34191573e-01f, -4.93191198e-40f, -2.52028089e-15f, -1.10948347e-02f, -4.99332771e-02f, 1.35217696e-01f, 2.12893873e-01f, -4.87319045e-02f, 3.70870791e-02f, -5.28985001e-02f,
  -1.33748636e-01f, -6.21904358e-02f, -1.93210587e-01f, -1.34914607e-01f, 1.08329780e-01f, 4.84200902e-02f, 3.95326726e-02f, -7.87147284e-02f, -2.07065381e-02f, 7.09886700e-02f,
  7.18808100e-02f, 3.46509814e-02f, 2.55989153e-02f, 6.87719062e-02f, -1.03486001e-01f, -2.67995656e-01f, -1.35210469e-01f, 2.62943469e-02f, -1.63437262e-01f, -1.00108154e-01f,
  -1.09925449e-01f, -3.18423659e-02f, 5.35621718e-02f, 7.94512704e-02f, -1.20324941e-07f, 9.97126251e-02f, -5.11954203e-02f, -9.51261222e-02f, 2.74446517e-01f, -1.03866860e-01f,
  1.47531241e-01f, -3.43622081e-02f, -6.02673254e-08f, -8.49941671e-02f, 1.20047424e-02f, 1.22409992e-01f, 1.16295993e-01f, 5.00296503e-02f, -9.22591425e-03f, 1.90773249e-01f,
  1.06769241e-01f, 1.08008198e-01f, -1.74369365e-01f, -8.68567228e-02f, -3.06023397e-02f, -7.92831369e-03f, 1.32164478e-01f, -2.14083612e-01f, -2.34219357e-01f, -1.23619221e-01f,
  -3.38982918e-24f, 4.24688309e-02f, 2.04333425e-01f, 1.18582696e-01f, -4.26117294e-02f, -8.10319058e-23f, -3.91418954e-16f, 8.65387544e-02f, 1.19101912e-01f, -2.56996393e-01f,
  2.54724361e-02f, 3.75460759e-02f, 1.01192161e-01f, 1.48943504e-02f, 1.84920087e-01f, 1.56993642e-01f, 1.48232281e-01f, 4.09002826e-02f, -1.22219715e-02f, 1.47340164e-01f,
  5.99434860e-02f, -4.62878942e-02f, 4.18689549e-02f, 2.50865705e-02f, 8.84938426e-03f, -1.14485219e-01f, 1.02531619e-01f, -4.88461889e-02f, 4.79870319e-01f, 2.23592013e-01f,
  -6.76487982e-02f, -4.92446683e-03f, -7.77803287e-02f, -2.62676943e-02f, 8.41653422e-02f, -1.04846232e-01f, -3.39758769e-02f, -3.85809550e-03f, -1.71519240e-11f, -2.51345426e-01f,
  3.52086872e-02f, 9.79099870e-02f, -4.42738645e-02f, 7.44316876e-02f, -3.52296531e-02f, 3.04084778e-01f, -1.24240865e-03f, -1.40695527e-01f, 8.19317400e-02f, -1.08028449e-01f,
  6.81471825e-02f, 1.82696190e-02f, 2.95095183e-02f, -7.47932270e-02f, -9.87513289e-02f, -1.15520433e-01f, 1.60200931e-02f, 2.56563108e-02f, 1.58891648e-01f, -9.91077200e-02f,
  -8.37762058e-02f, -1.23873308e-01f, 1.64223909e-01f, 1.88819468e-01f, 2.76423578e-14f, 1.68020487e-01f, -4.71958751e-03f, -4.42168452e-02f, 2.25438833e-01f, 6.22503090e-21f,
  -2.37414170e-05f, 6.97775260e-02f, -1.26053998e-02f, 1.83322176e-01f, 9.21801329e-02f, 9.41048712e-02f, 1.15238704e-01f, -3.36217284e-02f, -2.49368593e-01f, -5.99318780e-02f,
  5.45613319e-02f, 1.00295037e-01f, 1.53013051e-01f, -2.26450637e-01f, -8.05098414e-02f, -3.39249223e-02f, -2.35255212e-01f, -6.81637153e-02f, -1.98113546e-01f, 2.69975103e-02f,
  1.74047604e-01f, 1.20700665e-01f, 4.24229093e-02f, -1.44222751e-01f, 1.97389379e-01f, 2.05162704e-01f, 3.75529587e-01f, 1.02608114e-01f, 9.36316997e-02f, 1.88516602e-01f,
  7.31000081e-02f, 1.01598583e-01f, -3.49410674e-24f, -1.61321938e-01f, 7.28051588e-02f, -6.45922944e-02f, 2.86788404e-01f, -1.42899215e-01f, 2.39210591e-01f, 3.79907638e-02f,
  1.49132378e-04f, -7.00045824e-02f, 1.26688361e-01f, 2.21843511e-01f, 4.43331851e-03f, 2.08425134e-01f, -3.27487513e-02f, -1.12168603e-01f, 6.92510456e-02f, 1.39211610e-01f,
  -1.27193168e-01f, 1.13021344e-01f, 2.32103895e-02f, 9.01265740e-02f, 1.94632784e-01f, -1.36593565e-01f, -9.69766378e-02f, -2.28520364e-01f, 5.61702114e-33f, 3.57593894e-02f,
  1.24973245e-01f, 2.40563471e-02f, 5.83698824e-02f, 4.93556937e-40f, 1.24360212e-13f, 1.16567902e-01f, 1.80730671e-01f, -1.48538038e-01f, -5.14072441e-02f, 1.88654959e-02f,
  -1.32988822e-02f, 6.12939596e-02f, 9.10507366e-02f, 2.39725322e-01f, 5.37952185e-02f, 9.43179354e-02f, -4.50955558e-04f, 3.34463693e-04f, 2.48439208e-01f, 2.51997948e-01f,
  1.20617405e-01f, 8.79789367e-02f, 1.96139097e-01f, 1.44707769e-01f, 1.22528322e-01f, 5.99799193e-02f, -3.72553051e-01f, 9.72291604e-02f, -2.70944953e-01f, -1.64948273e-02f,
  -2.52370715e-01f, 2.41918862e-02f, 6.60436377e-02f, -9.12250280e-02f, 2.55882084e-01f, -6.94396272e-02f, 5.29622866e-07f, -1.11615829e-01f, 5.08409254e-02f, -6.85969815e-02f,
  1.28785834e-01f, 7.64727294e-02f, -6.99077472e-02f, -1.95116282e-01f, 5.67511609e-03f, -5.99150211e-02f, 5.55054061e-02f, 3.95473808e-01f, -2.30714262e-01f, -5.42518571e-02f,
  1.17941014e-01f, -5.34986239e-03f, 1.43507972e-01f, 1.36974230e-01f, 9.90918800e-02f, -2.51894116e-01f, 6.58634081e-02f, 2.38278419e-01f, 1.79324821e-02f, 1.09136738e-01f,
  -2.26643253e-02f, 8.75821933e-02f, -3.18227367e-16f, 5.28353974e-02f, 1.69122100e-01f, 2.52159148e-01f, -2.93054253e-01f, -5.83690785e-15f, -4.91698816e-40f, -2.36279577e-01f,
  3.79218370e-01f, -1.68683939e-02f, -1.42180908e-03f, -1.80591449e-01f, 4.99989018e-02f, 2.14643463e-01f, 4.18903857e-01f, 1.65504634e-01f, -1.68949306e-01f, -5.22827823e-03f,
  7.44851604e-02f, 2.60880470e-01f, 4.92077991e-02f, 2.27046236e-01f, 1.60563380e-01f, 1.55091628e-01f, 2.42714077e-01f, 7.26593137e-02f, -1.69447407e-01f, 5.68092652e-02f,
  7.22357305e-03f, -7.20501840e-02f, 2.34480262e-01f, 1.89951062e-01f, -5.60623221e-02f, 1.44570157e-01f, 4.46846709e-02f, 3.43807265e-02f, 1.38909921e-01f, -1.32122040e-01f,
  1.68885576e-13f, -1.80404067e-01f, 2.91715980e-01f, -2.34395638e-01f, 1.81878775e-01f, 2.10420578e-03f, -1.16921350e-01f, -8.78188908e-02f, -2.48604720e-05f, -5.23203388e-02f,
  -7.25560822e-03f, 6.28649294e-02f, 2.31885180e-01f, -3.81619900e-01f, -4.07563373e-02f, 6.73625246e-02f, 2.23100170e-01f, -7.76983574e-02f, 1.92161475e-03f, -8.44506323e-02f,
  -4.30022739e-02f, -8.21931288e-02f, 1.82860255e-01f, -9.50296670e-02f, -6.81055188e-02f, -1.97955836e-02f, 1.73368427e-13f, 7.01402202e-02f, 1.45069778e-01f, 2.70435065e-01f,
  4.03690664e-03f, 4.91111671e-40f, -2.22598061e-07f, -2.69847084e-02f, 6.89344630e-02f, 2.54428446e-01f, -2.25921258e-01f, 5.44330887e-02f, 1.06591836e-01f, 9.76600125e-02f,
  8.78888294e-02f, 2.76382640e-02f, 2.08504364e-01f, 2.09042773e-01f, 1.64273471e-01f, -4.32183668e-02f, 7.22173229e-02f, 1.70842841e-01f, 1.41602278e-01f, 1.43910786e-02f,
  2.26880133e-01f, 1.47322267e-01f, -1.50874108e-01f, 2.71113161e-02f, 4.27924454e-01f, 2.68926322e-02f, 1.37595564e-01f, -2.58848984e-02f, -1.19809456e-01f, -1.92905590e-02f,
  6.81924373e-02f, -1.40359014e-01f, 1.52354807e-01f, -2.45795503e-01f, -2.02119192e-08f, -2.86825001e-01f, 2.25119680e-01f, -1.96706742e-01f, 1.58700794e-01f, 1.33956358e-01f,
  -1.50793348e-03f, -1.47750586e-01f, 1.49119307e-06f, -8.88682604e-02f, 1.30714342e-01f, 1.27456998e-02f, 2.67209768e-01f, -1.22831479e-01f, -1.49490973e-02f, 8.70825574e-02f,
  2.03532621e-01f, 9.27439705e-02f, 9.24410895e-02f, -1.02189757e-01f, 3.28888744e-02f, -2.72957295e-01f, 1.94498226e-01f, 1.65428162e-01f, -3.31620201e-02f, -3.56270932e-02f,
  -3.59879227e-15f, 1.65933847e-01f, 1.30751282e-01f, 1.68759510e-01f, 3.57513987e-02f, -2.48417512e-19f, 8.67932286e-08f, -2.03357324e-01f, 1.17843263e-01f, 2.62104601e-01f,
  -1.46178622e-02f, -1.13010637e-01f, 5.82021102e-02f, 5.55117503e-02f, -2.19580173e-01f, 9.80889797e-02f, 2.73538888e-01f, 9.65403020e-02f, 2.08350778e-01f, -9.58433375e-02f,
  2.91838199e-01f, 1.64493732e-02f, -5.24915047e-02f, 1.70049042e-01f, 3.48782949e-02f, 4.86709327e-02f, -3.36164713e-01f, -1.10193849e-01f, -1.08785331e-01f, 2.88949758e-01f,
  -5.14416814e-01f, 6.46629855e-02f, -2.38437623e-01f, -6.05977140e-02f, 6.36347532e-02f, -1.04853958e-01f, 1.63727291e-02f, -1.42043158e-01f, -2.84671664e-09f, -9.71695110e-02f,
  -5.34873866e-02f, -1.59935076e-02f, 3.35020646e-02f, -3.80985737e-02f, 1.56819835e-01f, -8.14259574e-02f, 8.50291472e-05f, -7.15340823e-02f, 1.41201317e-01f, -1.18585918e-02f,
  -1.37058780e-01f, -1.56789329e-02f, 1.47729397e-01f, 8.41489062e-02f, 1.37038395e-01f, -1.58339683e-02f, 7.45956302e-02f, -6.54993504e-02f, 1.09706156e-01f, 1.50935397e-01f,
  -9.28418860e-02f, -1.11132070e-01f, -1.43018827e-01f, 1.35377627e-02f, 4.93044062e-40f, -6.26686439e-02f, 1.89161867e-01f, -6.01556338e-02f, 1.14455037e-01f, -2.73141807e-25f,
  -1.43139283e-21f, -6.11586682e-02f, 4.70611677e-02f, 1.01151332e-01f, 4.81161401e-02f, -2.07133107e-02f, 1.83077127e-01f, -7.78582767e-02f, 1.75016046e-01f, -6.91801533e-02f,
  6.85852915e-02f, -4.07521352e-02f, -9.20493677e-02f, 7.85549283e-02f, -2.07693949e-01f, -1.54495269e-01f, -2.06067950e-01f, -8.67689401e-02f, -1.05356097e-01f, 2.33828984e-02f,
  1.83610812e-01f, -1.04180723e-01f, 7.63244852e-02f, -5.77888861e-02f, -2.07917035e-01f, -5.72808273e-02f, 4.21532020e-02f, -1.65415660e-01f, 6.09241761e-02f, 1.24577634e-01f,
  -1.42256647e-01f, -1.44398749e-01f, 7.00816627e-10f, -9.40750092e-02f, -3.18396986e-01f, 7.38901347e-02f, 3.43460031e-02f, 1.92207679e-01f, 8.63520727e-02f, 2.06536964e-01f,
  2.20453302e-07f, -3.36392038e-02f, -4.39777002e-02f, -5.11647686e-02f, 1.98478520e-01f, 1.80956438e-01f, 6.22398369e-02f, -6.18258640e-02f, -1.67410538e-01f, 5.17828465e-02f,
  9.95440558e-02f, 2.24423543e-01f, 1.18910752e-01f, 1.04335938e-02f, 1.27206624e-01f, 2.01597199e-01f, -4.33763489e-03f, 9.71761346e-02f, 2.23339732e-11f, 7.67897889e-02f,
  2.75896955e-02f, -3.09761345e-01f, 2.62036651e-01f, 1.55107510e-22f, 4.31698322e-09f, -1.40402764e-01f, -1.29507765e-01f, 1.47374645e-01f, 6.28628433e-02f, -8.02257806e-02f,
  1.78742498e-01f, -1.80040568e-01f, -2.06952661e-01f, -6.86203986e-02f, 1.60583392e-01f, -2.25047216e-01f, 2.60881428e-02f, 1.94507055e-02f, 4.55518905e-03f, 3.06893582e-03f,
  -1.63346678e-02f, -1.28412293e-02f, -3.03858705e-03f, 6.28020195e-03f, -1.84384976e-02f, -1.52078150e-02f, 5.95765701e-03f, -1.12714395e-02f, -1.37235327e-02f, -6.41065650e-03f,
  -1.74992532e-02f, -3.99465673e-02f, 6.00274223e-40f, -1.98050984e-03f, -2.38658339e-02f, -4.07839417e-02f, -4.91579705e-40f, 3.33517268e-02f, -1.99068710e-02f, -1.93308108e-02f,
  1.12557609e-04f, -2.70787142e-02f, -4.03708033e-02f, -1.29176414e-09f, -4.94415933e-40f, -3.13901417e-02f, -2.71863192e-02f, -7.82196494e-08f, -3.97657230e-02f, -3.32121141e-02f,
  -3.32987532e-02f, 2.35401187e-02f, -9.00360569e-03f, -2.46208068e-02f, -3.56168561e-02f, -6.16066623e-03f, -1.93737783e-02f, -3.44583653e-02f, -1.21126557e-03f, -1.83101296e-02f,
  -6.46803901e-02f, -2.08731890e-07f, -4.93492478e-40f, -8.01493507e-03f, -1.18994445e-03f, -2.12695543e-02f, -5.16158566e-02f, -5.00384063e-40f, 5.87621899e-40f, -5.73267303e-02f,
  -6.42064720e-07f, -2.03148685e-02f, -1.64291039e-02f, -5.05136140e-02f, -1.51877375e-02f, -5.31794457e-03f, -5.52855385e-03f, -3.88150848e-02f, -3.29682343e-02f, -9.70748812e-03f,
  -2.30950266e-02f, 1.84115507e-02f, 2.14309216e-01f, 2.11282521e-01f, 2.45236024e-01f, 1.27085939e-01f, 2.49711618e-01f, -2.74781343e-02f, -3.65685731e-01f, 1.73647061e-01f,
  -6.94931448e-02f, 1.15337506e-01f, -1.36041820e-01f, -1.38593093e-01f, -2.88969606e-01f, 4.32755277e-02f, 6.70891479e-02f, 1.55009013e-02f, 1.65603057e-01f, -6.10109977e-02f,
  1.38619879e-10f, 3.09616178e-01f, -3.30885202e-02f, 9.61622372e-02f, -2.97975093e-01f, 1.96016237e-01f, -1.27820313e-01f, 1.05080254e-01f, 3.42720696e-08f, 2.52150416e-01f,
  -3.42613598e-03f, -1.45340413e-01f, -3.72535177e-02f, -2.45602369e-01f, 5.02496436e-02f, 2.38388717e-01f, 1.03952419e-02f, -3.45943905e-02f, 6.71486780e-02f, 1.45161459e-02f,
  5.43180555e-02f, 2.33842954e-02f, -3.20628166e-01f, 1.75427809e-01f, 9.07281712e-02f, 1.95018500e-02f, -1.97205614e-21f, -8.91248975e-03f, -4.58461829e-02f, -1.19662890e-02f,
  -2.25305408e-01f, -4.91726842e-40f, -2.98751331e-07f, 4.96182442e-02f, -1.48231506e-01f, 1.10095561e-01f, -9.45470333e-02f, -1.78427305e-02f, -1.69920713e-01f, 9.70622823e-02f,
  1.17908962e-01f, 1.25854807e-02f, -1.18383877e-01f, 7.04871640e-02f, -6.61669597e-02f, 1.40433624e-01f, -3.84343602e-02f, -1.49850264e-01f, -2.86156754e-03f, -9.94143337e-02f,
  -4.05840650e-02f, -4.85406294e-02f, -6.73528463e-02f, -2.42413267e-01f, 3.58960629e-01f, 1.50841191e-01f, -6.03648275e-02f, -9.77675617e-02f, -1.11843839e-01f, 1.62304059e-01f,
  5.32881878e-02f, -8.28034878e-02f, -1.47758657e-02f, -1.38417827e-02f, 3.23408123e-09f, -1.84039474e-01f, -1.36778671e-02f, 1.71504363e-01f, 1.19197883e-01f, -4.47911657e-02f,
  1.28940299e-01f, 2.11275950e-01f, -2.03702576e-03f, -3.14876512e-02f, -1.09860888e-02f, 3.67650092e-02f, 3.30405496e-02f, 1.58060655e-01f, 1.75844088e-01f, 7.73007572e-02f,
  -1.80601683e-02f, 5.43096811e-02f, 1.35035768e-01f, 3.75057086e-02f, 8.68937522e-02f, 1.19853109e-01f, 3.34451819e-04f, -1.45665273e-01f, -1.47289038e-02f, 9.86519903e-02f,
  4.71405888e-19f, 2.29907855e-01f, 6.16018213e-02f, 5.24834841e-02f, 2.78862357e-01f, 6.39309896e-17f, -4.21901905e-06f, 9.70191434e-02f, -4.88705598e-02f, 1.84792712e-01f,
  1.10784993e-02f, 7.61937350e-02f, 1.05584480e-01f, -1.11000128e-01f, -2.08584070e-01f, -8.18782747e-02f, 1.69962361e-01f, 4.71978821e-02f, 4.46320325e-02f, -2.92812083e-02f,
  -2.05460131e-01f, -2.78855324e-01f, -2.12558419e-01f, -1.62337767e-03f, -3.03429682e-02f, 3.72060910e-02f, 3.07541907e-01f, -5.00760153e-02f, -3.78184468e-01f, -2.44782627e-01f,
  1.95315648e-02f, -1.89409442e-02f, 1.64408937e-01f, 1.36944100e-01f, 6.46373630e-02f, -1.40201570e-02f, 1.46432510e-02f, 5.15826084e-02f, 1.51914855e-06f, -2.07546670e-02f,
  -7.90790617e-02f, 1.06821947e-01f, -1.71976432e-01f, 5.38893603e-03f, -1.08903095e-01f, -3.06367874e-01f, 4.00319113e-04f, -8.85859970e-03f, -1.03274085e-01f, 1.90618873e-01f,
  -1.13710105e-01f, 6.02772944e-02f, -4.10853922e-02f, 3.68665112e-03f, -5.50376065e-02f, -7.58083165e-02f, 1.87745579e-02f, -5.37158102e-02f, 5.34767471e-03f, 1.32386878e-01f,
  -7.50574172e-02f, 1.23942964e-01f, 2.39122044e-02f, -8.94586369e-02f, -6.31202772e-13f, 4.59436402e-02f, -5.72296008e-02f, 3.76510881e-02f, -6.09274283e-02f, -1.01046626e-18f,
  2.09833842e-18f, 9.83355269e-02f, 9.25314426e-03f, 6.09836653e-02f, 1.16051942e-01f, -1.71329707e-01f, -2.84934267e-02f, 1.18727833e-01f, 1.29665315e-01f, 4.02966440e-02f,
  -7.50677958e-02f, -5.47314584e-02f, 1.20830163e-03f, 1.01945579e-01f, 1.54279828e-01f, -1.51678830e-01f, 1.83423907e-01f, -1.21053241e-01f, 3.32152583e-02f, 3.90440077e-02f,
  -4.22580034e-01f, -6.87709078e-02f, -1.76610202e-01f, -3.51297334e-02f, -2.08407819e-01f, -4.34675634e-01f, -1.42931208e-01f, -1.10148422e-01f, 1.14946544e-01f, -1.20135762e-01f,
  2.69512177e-01f, -2.18184814e-01f, -6.61553202e-07f, 1.94130257e-01f, -6.38912991e-02f, 1.04320468e-02f, 2.90658325e-01f, 6.81023896e-02f, 5.69219105e-02f, -1.37103781e-01f,
  -2.18810392e-08f, 1.09021932e-01f, -6.76021427e-02f, 1.90644488e-01f, 2.32862487e-01f, -1.98267847e-01f, 1.04150683e-01f, 1.96111172e-01f, 1.44346654e-01f, 2.18795627e-01f,
  -1.21080816e-01f, -6.58705905e-02f, -9.37662497e-02f, 4.41062264e-02f, -7.98070151e-03f, 8.15397948e-02f, -1.72363728e-01f, 1.51310926e-02f, -9.93074842e-23f, 2.97607984e-02f,
  3.36503208e-01f, 4.79594395e-02f, -1.09311640e-01f, 3.47665522e-27f, 1.85411083e-12f, -2.27513045e-01f, 2.36293823e-01f, -1.23670809e-02f, 5.91528863e-02f, -9.46512744e-02f,
  1.23113185e-01f, 5.57357743e-02f, 1.98541284e-01f, 6.39529303e-02f, -1.81314964e-02f, -6.66129366e-02f, 8.53059515e-02f, 1.42822713e-01f, -1.38362557e-01f, 3.35046425e-02f,
  3.07916015e-01f, -4.39182818e-02f, 1.99424624e-01f, -1.47784259e-02f, -2.55206317e-01f, 6.69287369e-02f, -5.17020784e-02f, -2.93522656e-01f, 5.12882173e-01f, 1.22209340e-01f,
  -8.48696157e-02f, 3.33474934e-01f, -4.38596006e-04f, -6.97236285e-02f, 2.20089138e-01f, 1.08109124e-01f, 4.44439166e-07f, 7.21007818e-04f, 4.02963012e-01f, -3.86395752e-02f,
  -6.05372600e-02f, -2.95930445e-01f, -1.89204186e-01f, 9.98131260e-02f, -6.04575872e-03f, 4.21964154e-02f, 1.52136594e-01f, 2.46803895e-01f, 5.54115549e-02f, -8.29540491e-02f,
  -1.26262054e-01f, 2.07782000e-01f, 2.58003026e-01f, -2.48249650e-01f, 4.72773388e-02f, -1.18449979e-01f, -6.46314472e-02f, -8.31088275e-02f, -1.77466869e-02f, -2.26564243e-01f,
  1.99761614e-01f, 4.92901690e-02f, -3.14595363e-15f, 7.37670138e-02f, -1.75565660e-01f, 3.80360574e-01f, -2.07827345e-01f, -6.70261605e-17f, -1.44749874e-05f, 2.09716886e-01f,
  1.30105942e-01f, 4.98996973e-02f, -1.12056129e-01f, 2.09077418e-01f, -2.46567607e-01f, 2.62118548e-01f, 1.21178851e-01f, 1.87578931e-01f, 7.78212585e-03f, 2.18965828e-01f,
  2.22782731e-01f, -1.25388384e-01f, -1.87341645e-02f, -1.12962998e-01f, -4.45694849e-03f, -1.66385233e-01f, -2.23648071e-01f, -1.37574941e-01f, 2.63927788e-01f, 9.92604569e-02f,
  9.65349078e-02f, -1.97540358e-01f, 2.46978804e-01f, -3.23461778e-02f, 1.01473853e-01f, -5.40115461e-02f, -4.24465537e-02f, 5.87061979e-02f, -1.38442004e-02f, -7.36468956e-02f,
  6.53583010e-09f, 3.28942351e-02f, 2.35083461e-01f, -1.12039298e-01f, 1.21197075e-01f, -2.59368628e-01f, 1.08093925e-01f, -2.57751700e-02f, -2.95391399e-03f, -9.66266319e-02f,
  1.32361837e-02f, 1.36316359e-01f, 1.43669963e-01f, -3.38601410e-01f, -3.41627717e-01f, 1.15786918e-01f, 2.79277656e-03f, 1.02505311e-01f, 2.45134845e-01f, 6.38188422e-02f,
  -1.54059663e-01f, -8.30083340e-02f, 5.77672347e-02f, -1.03984689e-02f, 1.45044485e-02f, -1.72239706e-01f, 1.56377349e-15f, -1.01314792e-02f, 1.30451459e-03f, -1.29242083e-02f,
  3.38892698e-01f, 2.45669322e-29f, -7.36033101e-08f, 8.60940441e-02f, 7.02678040e-02f, 1.02324924e-02f, -4.27377552e-01f, 2.79828221e-01f, 1.06182985e-01f, 8.99298564e-02f,
  -1.34885997e-01f, 2.04048410e-01f, 2.51127958e-01f, 2.72873014e-01f, 1.40822932e-01f, -1.61513224e-01f, 2.55496591e-01f, 1.63035646e-01f, 6.74563572e-02f, 3.34137529e-01f,
  2.22762510e-01f, 4.87610623e-02f, -1.99833438e-01f, 2.25782663e-01f, -1.26386836e-01f, -3.10156378e-03f, -3.40127826e-01f, 2.07690388e-01f, -9.13726017e-02f, -1.02896422e-01f,
  2.36508064e-02f, 7.77526721e-02f, 1.82422027e-02f, 1.54308334e-01f, -2.76618522e-07f, 3.85927439e-01f, -1.45100489e-01f, 1.85281485e-02f, 6.79161474e-02f, 5.62845590e-03f,
  2.68666893e-01f, -2.67114013e-01f, 4.63751530e-05f, 2.36603305e-01f, 1.02254070e-01f, -1.64372012e-01f, 1.48294240e-01f, -1.07738711e-01f, 1.12994246e-01f, 2.38157839e-01f,
  -1.32855363e-02f, 1.76324159e-01f, 4.38737608e-02f, 1.81858074e-02f, -4.50094193e-02f, -8.36306810e-03f, 2.24966276e-02f, 4.09895964e-02f, -4.45253551e-02f, -1.27619684e-01f,
  -1.68837258e-17f, -1.19245172e-01f, -8.07830505e-03f, 1.06143743e-01f, -8.30093920e-02f, 6.99453677e-15f, 6.25074290e-06f, 1.60738200e-01f, -4.54334170e-02f, -2.08733484e-01f,
  3.63898985e-02f, 1.26806855e-01f, 1.25570456e-02f, -1.50531472e-04f, 1.46636620e-01f, 2.32398540e-01f, 1.20731972e-01f, -7.03247488e-02f, -6.57745600e-02f, 2.25270525e-01f,
  -3.26841660e-02f, -2.36836597e-02f, -4.04556617e-02f, -1.53673902e-01f, -1.44256085e-01f, -4.40390557e-02f, 5.66327944e-02f, -1.28227398e-01f, 4.19888385e-02f, 4.15037982e-02f,
  -9.21041414e-04f, -3.55778635e-02f, 3.60668153e-02f, 2.60178745e-02f, -4.16274704e-02f, -1.73112564e-02f, -1.06998004e-01f, 1.05611337e-02f, 8.46093475e-38f, -3.02257091e-02f,
  1.11333460e-01f, 1.27219437e-02f, 8.10594670e-03f, -5.89646325e-02f, -7.77696818e-02f, 4.63708490e-02f, 4.95600030e-40f, -3.25212292e-02f, 4.67315428e-02f, -6.32364526e-02f,
  -9.54373181e-02f, -3.83410119e-02f, -4.44319360e-02f, -1.00187100e-01f, -1.13689741e-02f, -4.74411575e-03f, 7.94389546e-02f, 4.87276912e-02f, -2.36663111e-02f, 1.34180849e-02f,
  -7.41841178e-03f, -1.05142510e-02f, 6.51651546e-02f, -2.86016669e-02f, -4.93765731e-40f, 5.38731329e-02f, -1.18855931e-01f, 5.42772114e-02f, 4.16727513e-02f, 4.92749789e-40f,
  -5.03982598e-40f, 7.67509416e-02f, -1.44233489e-02f, -4.92883697e-02f, -5.25705330e-02f, 5.27773872e-02f, -7.67831355e-02f, -1.34775834e-02f, -1.34273678e-01f, -1.73185708e-03f,
  -9.39482525e-02f, 1.63842142e-02f, 1.32110670e-01f, -1.28258750e-01f, 3.47892419e-05f, -2.20966867e-05f, -1.78861610e-05f, -1.47782048e-05f, 3.38154155e-06f, 2.14765441e-06f,
  -2.50124543e-09f, -9.95548461e-08f, 4.66571812e-08f, 8.72912437e-11f, -8.10226481e-08f, -3.39051276e-09f, -3.05865178e-05f, 4.74407134e-04f, 5.21023789e-40f, -4.19545891e-08f,
  -5.83556830e-05f, -2.74676768e-06f, -5.26909242e-40f, -3.29029364e-39f, -8.25100869e-06f, -1.38753478e-03f, 3.65697195e-11f, -4.53661801e-03f, -3.44436790e-04f, 9.63421232e-10f,
  4.94624727e-40f, -4.96067742e-07f, -1.13919159e-05f, -7.15932547e-05f, -3.57618177e-07f, -1.22602226e-03f, -8.86241673e-04f, -4.10897541e-04f, -4.31746003e-06f, -1.34565824e-04f,
  -6.91893438e-05f, -3.28900995e-07f, -2.70900666e-03f, -1.08948955e-03f, -1.85458302e-05f, -7.34023401e-04f, -8.09033576e-04f, 6.01894244e-05f, -4.91404543e-40f, -3.41189094e-04f,
  -1.00260993e-04f, -1.17606796e-04f, -5.58816537e-05f, 4.99425575e-40f, -4.93513497e-40f, -1.38561118e-05f, -1.62880286e-04f, -5.34646155e-04f, 5.49541181e-03f, -2.83346526e-06f,
  -1.44579529e-03f, -2.03177566e-04f, -1.96550664e-05f, -4.12612790e-05f, -9.29613907e-06f, -8.34828097e-05f, -2.51255260e-05f, -4.84287884e-05f, -1.17775813e-01f, -3.62753086e-02f,
  -5.60982265e-02f, -6.95786178e-02f, -1.21391937e-01f, 4.57795672e-02f, -7.39931986e-02f, -4.81418297e-02f, -4.49193567e-02f, 5.88624403e-02f, 4.40050922e-02f, -5.76127693e-02f,
  -7.69154951e-02f, 3.13783530e-03f, 1.21584639e-01f, -4.74269837e-02f, -5.11161536e-02f, 2.77124513e-02f, -4.94537846e-40f, -6.94734454e-02f, 3.70753594e-02f, -4.02635382e-03f,
  -2.20317654e-02f, -7.74138197e-02f, -2.61332337e-02f, 6.47105603e-03f, 5.99144777e-40f, -1.69093031e-02f, 3.59023772e-02f, -3.10758390e-02f, -7.10557327e-02f, 5.08703478e-02f,
  -9.08647105e-03f, -1.75215621e-02f, -5.53004891e-02f, -5.74640632e-02f, -4.67199869e-02f, 8.83525517e-03f, -1.49952183e-02f, -8.86591338e-03f, -5.29901125e-02f, -4.90242802e-02f,
  -5.81330527e-03f, -8.91570654e-03f, -4.95640668e-40f, 1.91540457e-02f, -2.56587826e-02f, -2.50169411e-02f, -3.62243317e-02f, 4.91687605e-40f, 5.05655748e-40f, 3.19366418e-02f,
  -4.32473011e-02f, -7.35132694e-02f, 1.96774341e-02f, 7.73890968e-03f, -4.89478633e-02f, -2.10195649e-02f, -2.21086349e-02f, -4.57914323e-02f, -7.52100199e-02f, 3.74207422e-02f,
  -5.41571565e-02f, -1.12365838e-02f, 1.04162253e-01f, 5.85642569e-02f, 2.89009511e-02f, 7.12668747e-02f, 1.41309768e-01f, 8.05972666e-02f, -4.42569256e-02f, -1.58143476e-01f,
  3.61032665e-01f, -1.58956107e-02f, 1.17810965e-01f, 7.14987144e-02f, -9.50991958e-02f, 2.63807803e-01f, 4.09554690e-02f, -1.16196424e-02f, -5.36726974e-02f, 5.23524173e-02f,
  4.82734244e-08f, -3.50900833e-03f, 1.17687225e-01f, 1.78498268e-01f, -4.34821807e-02f, 6.45515025e-02f, -1.25785097e-02f, 2.95612842e-01f, -2.37452262e-03f, 1.27664983e-01f,
  5.49288727e-02f, -2.08140731e-01f, -2.90583540e-03f, 1.54542908e-01f, 2.05084622e-01f, 4.99553457e-02f, 2.65441369e-02f, 4.77683246e-02f, 1.29278198e-01f, 6.75818995e-02f,
  -4.34301546e-05f, 6.53325766e-02f, -6.74534142e-02f, -1.45749897e-01f, 2.05955192e-01f, 1.16824992e-01f, -7.00213013e-11f, 1.83877066e-01f, -2.08792478e-01f, -5.47319241e-02f,
  1.54209554e-01f, 1.19396252e-23f, -3.87637193e-08f, 7.97125399e-02f, -5.27043492e-02f, 1.82529896e-01f, 1.77438259e-01f, 1.06127933e-01f, 3.47143486e-02f, -5.93614765e-02f,
  -7.72626027e-02f, -3.73275466e-02f, 2.91344710e-02f, -7.73130823e-03f, -1.69556551e-02f, -8.71948898e-02f, -1.41426474e-01f, -2.04567239e-01f, -1.42301414e-02f, -2.46194586e-01f,
  -2.57485539e-01f, -9.53628942e-02f, 6.15377203e-02f, -2.70997465e-01f, 5.36111519e-02f, -6.35143816e-02f, 2.95631588e-01f, -2.24543557e-01f, -5.09457625e-02f, 1.66261405e-01f,
  3.85267027e-02f, -4.46205623e-02f, -9.23928395e-02f, 8.47899467e-02f, 3.33745106e-07f, -1.86662003e-01f, 2.62034051e-02f, 1.01802468e-01f, -1.12218104e-01f, 4.38246429e-02f,
  -1.70536920e-01f, 3.45446378e-01f, -4.84442664e-03f, 3.44628245e-02f, -6.03771359e-02f, 1.64653003e-01f, -2.71032333e-01f, 8.96844119e-02f, 9.44693312e-02f, -1.25603110e-01f,
  -1.00938372e-01f, -5.29976338e-02f, 1.22548498e-01f, 8.17039162e-02f, 1.33767903e-01f, -2.53898259e-02f, 2.52512079e-02f, 1.67928811e-04f, 1.47832930e-01f, 2.11680144e-01f,
  -4.61670967e-16f, 1.85883090e-01f, -5.38973026e-02f, -9.53764189e-03f, 1.16956070e-01f, 1.89095273e-37f, -1.72712826e-05f, -2.02879999e-02f, 2.27097347e-02f, 9.71867889e-02f,
  1.33970886e-01f, 1.00643737e-02f, 2.40205247e-02f, 1.69671044e-01f, -1.27795875e-01f, -9.05689374e-02f, -2.70896167e-01f, -4.21001166e-02f, 1.65411726e-01f, -1.30835399e-01f,
  1.01121657e-01f, -3.57508995e-02f, -2.01361477e-01f, -6.29229378e-03f, 6.65436313e-02f, -2.53286082e-02f, 1.48977429e-01f, -3.23651880e-01f, -3.84033881e-02f, 2.37898260e-01f,
  -2.37901136e-01f, -8.61396641e-02f, -3.76481633e-03f, 3.06411944e-02f, 2.14707013e-02f, 1.47380561e-01f, 6.04338013e-03f, -1.86228395e-01f, 8.21081744e-11f, -1.37845099e-01f,
  -7.79404491e-02f, 1.31784305e-01f, -1.72679890e-02f, 2.66163021e-01f, 1.58178106e-01f, -2.82927573e-01f, -8.86468310e-03f, 1.13784812e-01f, -9.41532180e-02f, 1.06099419e-01f,
  -1.00446612e-01f, 9.11693275e-02f, 2.15913765e-02f, -9.64792296e-02f, -7.84355626e-02f, 1.91410169e-01f, 2.15840071e-01f, -2.61986461e-02f, 1.65145263e-01f, 9.69607010e-02f,
  -3.82029079e-02f, 1.29107326e-01f, -6.55235127e-02f, 3.74240591e-03f, 5.00218395e-27f, -4.19700705e-02f, 2.26419970e-01f, -1.10144518e-01f, 2.11883590e-01f, 3.39703205e-18f,
  -1.25216482e-12f, -5.97861372e-02f, -5.38606755e-02f, 2.20613778e-01f, 1.46827787e-01f, -2.18741745e-02f, 2.51322955e-01f, -1.21733792e-01f, 6.95602223e-03f, -3.71256731e-02f,
  -4.57275733e-02f, -2.16321960e-01f, 9.20688659e-02f, 1.24004178e-01f, 2.57358015e-01f, 2.30351821e-01f, 1.09994702e-01f, 2.09338710e-01f, 1.65019155e-01f, -3.62012126e-02f,
  -5.00276625e-01f, 4.04381789e-02f, 1.42118912e-02f, 1.90644652e-01f, -3.43010336e-01f, 1.29592031e-01f, -2.51781583e-01f, -5.43316193e-02f, 7.88371414e-02f, 5.21663763e-02f,
  1.92794185e-02f, -1.28309041e-01f, 1.06519252e-07f, 9.54851210e-02f, 1.48452297e-02f, -8.02303571e-03f, -1.01797730e-01f, 1.29990131e-01f, 4.76048142e-02f, 2.21202731e-01f,
  1.18943410e-06f, 1.94410220e-01f, 4.55466583e-02f, -6.36938736e-02f, 2.08364785e-01f, -1.26610860e-01f, 1.18116565e-01f, 1.81857318e-01f, 2.63006210e-01f, 3.48271765e-02f,
  1.02717154e-01f, 9.78143513e-02f, -5.86682670e-02f, -1.18252672e-01f, -2.05371171e-01f, 4.95735481e-02f, 5.18581681e-02f, 9.76684466e-02f, 4.90958930e-40f, -2.28140112e-02f,
  8.12249482e-02f, 1.00343704e-01f, -2.12031156e-02f, -2.79929407e-39f, -6.97771539e-13f, -7.83352256e-02f, -8.38187411e-02f, 1.86385959e-01f, -8.69139004e-03f, 1.05155602e-01f,
  3.43428031e-02f, 1.19129405e-03f, 9.11543965e-02f, 3.52794193e-02f, -3.55135389e-02f, 2.36333519e-01f, 1.15268700e-01f, 7.20904171e-02f, 9.70268250e-02f, 2.07522467e-01f,
  5.45372963e-02f, 3.71696264e-01f, 6.19612299e-02f, -5.97930849e-02f, 3.34872343e-02f, 3.71297777e-01f, -1.18654668e-01f, -2.15946555e-01f, -1.31918848e-01f, 1.59227967e-01f,
  8.89533013e-03f, -8.38099867e-02f, -8.63615423e-03f, -5.38235158e-02f, 1.20193949e-02f, 2.16973335e-01f, -2.40369474e-07f, 2.84203053e-01f, -1.91767633e-01f, 1.10532288e-02f,
  2.07128182e-01f, -1.51255906e-01f, 2.77615875e-01f, -1.88208640e-01f, 3.87246883e-03f, 1.66828305e-01f, 1.85997948e-01f, -2.43848592e-01f, 1.44892302e-03f, -7.30741471e-02f,
  -9.59932804e-02f, 2.33976111e-01f, -3.11372094e-02f, 2.43152305e-01f, -1.08400010e-01f, -2.26400346e-02f, -1.44700333e-02f, 6.18518628e-02f, 2.65763775e-02f, 9.75925401e-02f,
  -9.36728716e-02f, -1.28643379e-01f, 1.58922508e-09f, -6.60718009e-02f, 1.69596523e-01f, -8.25011230e-04f, 8.46119300e-02f, -6.48140082e-17f, 8.38679807e-06f, 5.76271228e-02f,
  6.51883185e-02f, -2.10900992e-01f, 1.12020196e-02f, -3.68982330e-02f, -8.78066421e-02f, -1.55446902e-02f, 2.08811045e-01f, 2.56402194e-01f, 7.55023882e-02f, 7.59815499e-02f,
  -2.90949374e-01f, 1.36771724e-01f, 1.31666437e-01f, 7.97837216e-04f, 8.83749872e-02f, 1.80846095e-01f, -1.14773631e-01f, -2.04481542e-01f, 2.75597036e-01f, 2.28038311e-01f,
  -3.23152542e-01f, 1.24750078e-01f, -4.33464885e-01f, -2.34573171e-01f, -2.49728397e-01f, -5.38891070e-02f, 1.53172955e-01f, -3.65499914e-01f, 1.50440514e-01f, 1.37693807e-02f,
  -2.90998454e-13f, 2.14242443e-01f, -2.92606175e-01f, 5.58436774e-02f, -3.12249690e-01f, 2.26065129e-01f, 1.80324048e-01f, -2.15836033e-01f, 3.08299406e-07f, 2.43959410e-04f,
  6.14155643e-02f, 6.02822974e-02f, 2.82466188e-02f, 2.16722488e-01f, 1.94860101e-01f, 5.35953492e-02f, -2.72039086e-01f, 1.08784743e-01f, 1.36655152e-01f, -2.29795694e-01f,
  -6.28299713e-02f, 1.16749160e-01f, -9.93372947e-02f, 3.20869774e-01f, -7.58360848e-02f, -1.01585798e-02f, -4.92553608e-40f, 1.47769004e-01f, 1.13731563e-01f, -2.50574589e-01f,
  -1.14002265e-01f, -4.95146010e-40f, 1.47245727e-08f, -1.07058920e-02f, -9.37403589e-02f, -1.02163993e-01f, 2.16620356e-01f, -1.58045739e-01f, -5.96005879e-02f, -1.28656983e-01f,
  2.29409620e-01f, 1.02553137e-01f, -1.93720698e-01f, -1.67700589e-01f, -2.15103120e-01f, 2.10601360e-01f, -4.52195959e-14f, -3.85086754e-17f, 1.85260320e-19f, 2.64325350e-17f,
  -3.41089678e-13f, 6.35861662e-15f, -2.90125431e-19f, -4.04670160e-15f, -7.82354663e-14f, 1.54179912e-15f, 3.96753508e-17f, 2.08035252e-15f, 2.50503209e-08f, -2.27678879e-06f,
  -3.00398157e-29f, -4.07820919e-14f, -3.10558505e-07f, -1.86037947e-12f, -4.91258808e-40f, -1.07347389e-17f, -1.60026428e-08f, -1.39355876e-07f, -1.36705869e-10f, -7.26584744e-07f,
  -1.72994390e-07f, -2.28844352e-29f, -4.97538026e-40f, -1.80832482e-09f, -3.28119512e-07f, -4.62220100e-07f, -3.08765777e-07f, -1.20194670e-11f, -2.03082422e-07f, -8.97128302e-07f,
  -3.46380027e-08f, -8.06982484e-07f, -9.19885167e-07f, -5.35041636e-07f, -4.16233115e-06f, -1.65160873e-06f, -3.28579972e-07f, -1.00278191e-06f, -8.81686830e-08f, -2.06755343e-15f,
  -5.04641208e-40f, -3.30956595e-07f, -1.21665579e-07f, -3.88857700e-07f, -3.43642660e-06f, 5.18783112e-40f, -4.91198552e-40f, -1.79573959e-07f, -1.57199815e-06f, -2.03591508e-08f,
  -5.14054022e-07f, -1.16066371e-06f, -2.34944508e-07f, -2.83114377e-06f, -6.25418508e-08f, -9.63777347e-06f, -3.55020347e-06f, -9.46033936e-07f, -1.99207079e-07f, -1.43994469e-10f,
  -7.40569260e-04f, 2.64928360e-07f, 3.07197370e-05f, -7.33795576e-04f, -1.08079286e-03f, 2.93335120e-06f, 2.47044809e-05f, -1.33823126e-03f, 1.16896792e-03f, 2.14407647e-09f,
  -7.00776945e-06f, -4.69319319e-04f, -1.97784607e-06f, -1.83350276e-02f, -2.83857924e-03f, 1.63694098e-14f, -1.59332361e-02f, -5.31171449e-03f, 4.97794464e-40f, -1.23298810e-06f,
  -1.00056715e-02f, -4.17982414e-03f, -8.14931374e-03f, -4.26103798e-04f, -9.49492399e-03f, 1.56876274e-32f, 4.92709152e-40f, -7.05583761e-06f, -4.13878588e-03f, -1.70589369e-02f,
  1.28049726e-09f, -1.26994811e-02f, -1.32161519e-02f, -1.08931024e-04f, -1.30879600e-02f, -8.01239721e-03f, -2.61250882e-10f, 7.43424933e-10f, -1.33539811e-02f, -2.02423520e-02f,
  -8.70955829e-03f, -2.74126396e-05f, 1.56789952e-07f, -2.60106797e-11f, 5.73981660e-40f, -2.88228272e-03f, -1.55480318e-02f, -1.63892377e-02f, -6.51698429e-08f, -5.01769948e-40f,
  -4.95189450e-40f, -7.58442516e-03f, -1.80861782e-02f, -8.82991513e-10f, -1.67881232e-02f, -4.52664634e-03f, -1.39499661e-02f, -1.63257513e-02f, -1.75116602e-02f, -1.56616960e-02f,
  5.87992599e-10f, -9.09540616e-03f, -6.98908884e-03f, -1.38803739e-02f, 1.45350983e-02f, 2.92110443e-02f, -1.64082021e-01f, 1.98521361e-01f, -2.55725551e-02f, -1.20166078e-01f,
  1.55459732e-01f, -1.29568085e-01f, 1.16583714e-02f, -5.46967089e-02f, -3.66510242e-01f, -5.23981862e-02f, -1.18849345e-01f, -1.68436527e-01f, 8.68476331e-02f, -2.10233405e-02f,
  -1.21743992e-01f, -5.36793331e-03f, -8.58754134e-09f, -4.10131086e-03f, -2.13468254e-01f, 8.90161842e-02f, -1.70429438e-01f, 2.39656255e-01f, 6.14671782e-02f, 2.41315052e-01f,
  1.23573642e-07f, -8.50520376e-03f, 1.66579768e-01f, -1.91686139e-01f, 1.65453479e-01f, 1.88786402e-01f, 1.98202327e-01f, 1.06639281e-01f, -1.13729484e-01f, 2.74563674e-03f,
  -4.80945455e-03f, 6.04223534e-02f, 1.14591137e-01f, 3.99750769e-02f, -1.75399944e-01f, 1.19292475e-01f, 2.52493601e-02f, 7.03260601e-02f, -4.90518922e-40f, 8.99225548e-02f,
  -5.63925207e-02f, -2.52617270e-01f, 1.45666659e-01f, -1.04721853e-31f, -6.54936256e-18f, -4.52604331e-02f, -2.07223296e-01f, 4.90693077e-02f, 1.09429970e-01f, -6.42498657e-02f,
  -1.45939104e-02f, -2.15296358e-01f, 9.81297567e-02f, -8.65172297e-02f, -1.95212997e-02f, -2.85643309e-01f, -2.07130954e-01f, 1.35607392e-01f, -1.73152938e-01f, 3.04946065e-01f,
  8.47915411e-02f, 2.67610312e-01f, 1.40588135e-01f, -2.95507368e-02f, 2.21571788e-01f, 2.64874011e-01f, -9.72723588e-02f, -1.35871053e-01f, 2.70958245e-02f, 2.52726108e-01f,
  -6.85036704e-02f, -6.29036129e-02f, 1.10612214e-01f, -1.16099551e-01f, 3.48766856e-02f, 1.00372784e-01f, -2.02940460e-37f, 1.48503900e-01f, 1.84636578e-01f, -6.98780939e-02f,
  -1.60320148e-01f, 6.57688603e-02f, -3.11308298e-02f, -1.75389573e-01f, -3.70837711e-07f, -6.21994287e-02f, 3.08131903e-01f, -1.45404220e-01f, -5.79109741e-03f, 5.46454638e-02f,
  -6.50920644e-02f, 1.76384430e-02f, 1.90169573e-01f, -2.04311255e-02f, 6.77823797e-02f, -1.36399552e-01f, -1.11518567e-02f, -1.16511270e-01f, -1.80553809e-01f, -6.80821016e-02f,
  -2.76058391e-02f, -1.04334421e-01f, 4.93771336e-40f, 7.06444085e-02f, -1.20632373e-01f, 1.23411790e-01f, -1.13626212e-01f, 7.99378503e-16f, -1.49945807e-34f, 4.55030724e-02f,
  -5.88443764e-02f, 8.00320134e-02f, -8.79074540e-03f, 6.57854006e-02f, -1.23067722e-01f, -6.54399395e-02f, 8.21839944e-02f, 6.12104908e-02f, 1.35603413e-01f, 2.86000103e-01f,
  1.54892862e-01f, 9.32920799e-02f, 7.17061460e-02f, 7.45766088e-02f, -4.09919731e-02f, 6.59802109e-02f, 9.03430730e-02f, -4.85409647e-02f, -1.76469143e-02f, -3.62564139e-02f,
  -4.33138944e-03f, 2.82872212e-03f, 2.07428113e-02f, 6.85899630e-02f, -5.40199084e-03f, -6.71043480e-03f, 2.38292459e-02f, 4.49704826e-02f, -2.90390532e-02f, 1.60377976e-02f,
  2.26112220e-37f, -7.07159424e-03f, -3.79257798e-02f, 1.65805686e-02f, 9.05738585e-03f, -2.07697153e-02f, 1.67765450e-02f, 6.26102686e-02f, 5.85405045e-40f, -4.37445706e-03f,
  3.09905559e-02f, -5.30349016e-02f, -4.75657284e-02f, 4.52202372e-02f, 8.46282765e-03f, -2.05094926e-02f, -3.59220691e-02f, -2.09918842e-02f, -1.77013408e-02f, -1.17679108e-02f,
  1.32021327e-02f, 1.27081508e-02f, -3.26483510e-02f, -6.55126199e-02f, -2.97385501e-03f, 2.99680866e-02f, 4.94679377e-40f, 2.30141710e-02f, -2.87612565e-02f, 3.53482412e-03f,
  -2.26399228e-02f, -5.07669414e-40f, 5.39055697e-40f, 2.77241860e-02f, -1.11507699e-02f, -2.36572828e-02f, 1.61278453e-02f, 7.43528223e-03f, 6.21050736e-03f, -5.92428446e-03f,
  1.06007755e-02f, 8.26995261e-03f, -2.71297880e-02f, -2.09245663e-02f, -5.62007949e-02f, -1.01499399e-02f, -1.92486390e-01f, -2.00948268e-01f, -3.51887763e-01f, -3.24033409e-01f,
  -1.58917159e-01f, -1.25920981e-01f, 1.43300220e-01f, 1.95678715e-02f, -3.75858285e-02f, -1.62494585e-01f, 1.27154753e-01f, -2.53678132e-02f, 1.64951995e-01f, -1.12088777e-01f,
  -9.64031741e-02f, 2.90658504e-01f, -3.32185812e-02f, -3.38997729e-02f, -2.57455433e-17f, 2.50464261e-01f, -2.21253887e-01f, 8.51214156e-02f, 4.65710647e-02f, -6.03686646e-02f,
  1.20318107e-01f, -1.33716026e-02f, -1.21820385e-05f, 9.78828520e-02f, 1.79834329e-02f, -2.24356934e-01f, 9.93061289e-02f, -1.22933574e-01f, -1.86231896e-01f, -3.36669269e-03f,
  -3.61014083e-02f, 1.51319981e-01f, -5.00095971e-02f, 2.76893258e-01f, -6.45982623e-02f, -3.18241715e-02f, 6.84089810e-02f, -3.12107634e-02f, 1.91277433e-02f, -5.92509471e-02f,
  -4.92728770e-40f, -1.56614542e-01f, 2.02225819e-02f, -5.16380444e-02f, 1.83995977e-01f, -4.92332202e-40f, -2.05227437e-12f, -3.37873697e-02f, -4.66720872e-02f, -3.47628206e-01f,
  -3.12418222e-01f, 1.20648265e-01f, -3.39101441e-02f, -1.64584946e-02f, -1.15407385e-01f, 1.14665188e-01f, 1.61958355e-02f, -9.05498639e-02f, -1.36995912e-01f, 1.07147768e-02f,
  -3.63084152e-02f, 1.04740240e-01f, -6.61709695e-04f, 6.19713552e-02f, 1.18751256e-02f, 9.54284742e-02f, 2.47117743e-01f, 9.63943228e-02f, -6.94221705e-02f, -3.88413593e-02f,
  1.94699124e-01f, 4.04364258e-01f, 1.95293918e-01f, 3.11666787e-01f, 1.03035472e-01f, 1.86485589e-01f, 3.52656655e-02f, 3.17361414e-01f, 4.30640448e-08f, -1.24659054e-01f,
  1.61343843e-01f, 7.83906877e-02f, -2.42497697e-02f, -1.14247903e-01f, 5.92336282e-02f, 1.97796598e-02f, -2.65497401e-05f, -7.54185207e-03f, 2.83014238e-01f, 1.28874540e-01f,
  -2.38366976e-01f, 3.01471800e-01f, 7.79545978e-02f, -2.75651142e-02f, 5.72415106e-02f, -2.86320448e-02f, 3.72503884e-02f, -4.54771779e-02f, 2.32642725e-01f, 2.90428102e-01f,
  6.31857589e-02f, -1.62791878e-01f, 1.36527330e-01f, 5.19468682e-03f, -5.89793769e-10f, 2.12355241e-01f, -1.17447406e-01f, 1.99739873e-01f, -1.06953770e-01f, 2.31774763e-28f,
  1.59105380e-20f, 5.49853221e-02f, 7.58125558e-02f, -4.21939380e-02f, 2.28855520e-01f, 1.11498781e-01f, 3.53981704e-02f, 2.28085130e-01f, -2.46138256e-02f, 5.07158749e-02f,
  -1.35492519e-01f, 2.58591354e-01f, 9.87922177e-02f, 3.50729749e-02f, 2.59760976e-01f, 6.66194931e-02f, 9.09107551e-02f, 5.89398406e-02f, 1.70336574e-01f, 6.84415549e-02f,
  5.64403534e-02f, -3.64680998e-02f, -7.93975517e-02f, 1.15069121e-01f, -5.98521382e-02f, -9.10660326e-02f, -1.55871049e-01f, 3.51144820e-02f, 6.78744391e-02f, 3.14589730e-03f,
  -7.83929415e-03f, -6.60026968e-02f, 7.53360307e-09f, 9.73989367e-02f, 3.30542177e-02f, -2.17890143e-02f, 2.12205225e-03f, 1.50688320e-01f, 9.19938553e-03f, 1.06095579e-02f,
  2.37639197e-05f, -2.08216370e-03f, -9.51750800e-02f, 1.72774255e-01f, 1.59696817e-01f, -1.43279195e-01f, 9.94368941e-02f, 5.72747141e-02f, 9.36300755e-02f, 1.02456555e-01f,
  1.42171038e-02f, 9.61573720e-02f, 1.45007432e-01f, -9.84566137e-02f, 7.13982955e-02f, 2.86117435e-01f, 1.19688205e-01f, 1.99697074e-02f, 7.85314739e-15f, 6.01834916e-02f,
  1.99154601e-01f, 1.31070063e-01f, 4.46936116e-02f, -5.48786393e-17f, -6.90175501e-37f, -2.93206833e-02f, 1.63774386e-01f, 6.03756569e-02f, 1.19864792e-01f, -2.41262108e-01f,
  -3.18946876e-02f, 8.41025114e-02f, 2.14075536e-01f, 5.26682064e-02f, -8.44908059e-02f, -2.11311504e-01f, 5.25188819e-02f, 9.73895639e-02f, 1.68569073e-01f, 1.22122630e-01f,
  6.76302016e-02f, -5.74579574e-02f, 2.37280533e-01f, 7.71269901e-03f, -8.07964057e-02f, -2.72380263e-01f, 4.28480022e-02f, 3.08609474e-02f, -1.90043867e-01f, -6.01998046e-02f,
  -2.13453233e-01f, 1.49764165e-01f, 4.17651944e-02f, 2.72158030e-02f, -1.58473015e-01f, -8.45027640e-02f, -2.68067894e-11f, -7.17106164e-02f, -5.94713055e-02f, 2.31510833e-01f,
  -9.03429314e-02f, 8.86490643e-02f, -9.13922414e-02f, 1.13491401e-01f, -1.27659610e-03f, -1.22542586e-02f, -5.32626808e-02f, -1.37035903e-02f, -1.71339199e-01f, 5.62080182e-02f,
  1.60756901e-01f, -2.36494169e-02f, -2.53187679e-02f, 3.26762982e-02f, 4.24174927e-02f, 2.18461864e-02f, 1.64565161e-01f, 2.08662376e-01f, -1.36663362e-01f, 6.53367937e-02f,
  1.42374128e-01f, 1.81652278e-01f, -6.44101482e-12f, 1.58480421e-01f, 1.35922739e-02f, 1.18978977e-01f, -1.76675525e-02f, 4.32065744e-24f, -2.43423748e-09f, -3.75154149e-03f,
  1.25292242e-01f, 1.40475541e-01f, 2.41402850e-01f, 8.97906199e-02f, 2.24328637e-01f, 9.04530939e-03f, -1.03316836e-01f, -1.98531017e-01f, -1.29519224e-01f, -2.58407265e-01f,
  3.50980014e-02f, 2.89323498e-02f, -8.19941796e-03f, 9.96627882e-02f, -1.30938172e-01f, 2.01213181e-01f, 1.02352552e-01f, -2.99017072e-01f, -1.96105793e-01f, 6.02906868e-02f,
  6.11186624e-01f, -6.82089329e-02f, -6.99010342e-02f, -6.05312102e-02f, -1.33850738e-01f, -2.39218503e-01f, 1.21071316e-01f, -1.99139514e-03f, -1.18315257e-01f, -6.84884787e-02f,
  -2.31703871e-05f, 5.45569919e-02f, 5.02102003e-02f, -1.00817112e-02f, -1.24481879e-02f, 1.01043127e-01f, -5.43869957e-02f, 3.27329934e-01f, 2.54350846e-10f, -9.64382291e-02f,
  1.82291910e-01f, -1.81375667e-01f, 3.21549922e-01f, -6.95563480e-02f, 1.29867122e-01f, 1.13268912e-01f, -5.74546270e-02f, 5.75160235e-02f, -6.98012635e-02f, 2.38117710e-01f,
  8.83201659e-02f, -1.48643255e-01f, -5.08178882e-02f, 4.22582477e-02f, 1.48944538e-02f, 4.23897617e-02f, 1.98045166e-13f, -4.76069860e-02f, 3.87235582e-02f, -1.30650342e-01f,
  1.80088386e-01f, -9.82067469e-17f, -2.36822428e-09f, -1.52010575e-01f, -1.65258557e-01f, 1.15434006e-01f, -1.23880051e-01f, 1.29269809e-01f, 8.87951553e-02f, -1.99173585e-01f,
  -1.72704369e-01f, -1.44742534e-01f, 3.27861398e-01f, -7.91251287e-02f, -2.72749774e-02f, -3.60567458e-02f, -2.72135958e-02f, -2.81085104e-01f, -3.04908417e-02f, 7.86717143e-03f,
  -2.05527216e-01f, -3.43542658e-02f, 3.09648007e-01f, 1.66637003e-01f, -2.63090521e-01f, -3.18488061e-01f, 1.36116445e-01f, -1.95023924e-01f, 2.96550512e-01f, 8.27672407e-02f,
  1.54431865e-01f, -7.43921027e-02f, -4.73112985e-02f, -3.75306979e-02f, 1.40232203e-06f, 1.16553389e-01f, 1.66563205e-02f, 7.87555352e-02f, 1.95258543e-01f, -4.65824232e-02f,
  1.68317273e-01f, -2.58751839e-01f, 9.58336022e-05f, -1.20337881e-01f, -3.67013626e-02f, 2.60025293e-01f, -2.08578616e-01f, 9.23083127e-02f, -1.22498661e-01f, -9.46233943e-02f,
  8.22686404e-03f, 2.43830130e-01f, -8.41026157e-02f, 8.74502361e-02f, 1.06874317e-01f, 2.45536834e-01f, 2.62182891e-01f, 1.13598974e-02f, -4.69713286e-02f, -1.31192267e-01f,
  4.17251183e-16f, -1.11288399e-01f, 1.51871331e-02f, -3.68089341e-02f, -1.66446745e-01f, -5.34689853e-14f, 5.32874078e-10f, 9.72663239e-02f, 2.68765152e-01f, -2.87048370e-01f,
  6.96375743e-02f, -9.70668942e-02f, -1.52117863e-01f, 8.60704929e-02f, 2.08524570e-01f, 2.85527170e-01f, 2.80059688e-03f, 1.62525009e-02f, -5.52653801e-04f, -6.41232496e-03f,
  1.84254736e-01f, -5.82104735e-02f, -8.76168385e-02f, -2.15413243e-01f, -5.59822246e-02f, -4.18166071e-02f, 2.02559412e-01f, -1.28066704e-01f, 1.27885818e-01f, -3.98719907e-02f,
  7.65576512e-02f, -2.96593964e-01f, 1.31376714e-01f, -7.60725364e-02f, 5.05162701e-02f, 6.67849481e-02f, 5.71626350e-02f, -3.12726721e-02f, 5.20945231e-10f, 1.98832955e-02f,
  -1.04684912e-01f, 1.73873886e-01f, 5.54481074e-02f, 2.83234894e-01f, 1.16477735e-01f, -1.12016998e-01f, -8.02278926e-04f, 9.88854915e-02f, -1.23374723e-01f, 1.03672119e-02f,
  7.48304352e-02f, -9.10689682e-02f, 1.48224175e-01f, 5.25410846e-02f, -1.45820245e-01f, 1.41051516e-01f, 2.09531277e-01f, 2.22381622e-01f, 2.12683767e-01f, -5.56462258e-02f,
  2.12747619e-01f, 4.08645719e-01f, 2.53960639e-01f, 7.76870027e-02f, 5.80897642e-21f, 1.65297806e-01f, 8.11121091e-02f, -1.39856404e-02f, 6.41341656e-02f, -2.78196343e-28f,
  -1.80020304e-10f, -7.23944604e-02f, 7.27885589e-02f, 7.20591322e-02f, 1.06545493e-01f, -9.95563790e-02f, -1.80117916e-02f, -3.56271677e-02f, 2.33893339e-02f, 8.84496644e-02f,
  -6.32778257e-02f, -1.54408827e-01f, 3.48496735e-02f, -6.04722723e-02f, -3.47042531e-02f, 5.02727255e-02f, -1.57676358e-02f, 3.92155826e-01f, 2.16836911e-02f, 4.50075120e-02f,
  -1.12658311e-02f, 2.76955843e-01f, -2.50008851e-01f, -6.65325485e-03f, -4.31576341e-01f, 3.79658043e-02f, -2.60188460e-01f, -2.03094810e-01f, -7.35061392e-02f, -1.97080925e-01f,
  2.57867932e-01f, 5.86159453e-02f, -2.37623088e-10f, 1.95382550e-01f, -5.02368100e-02f, -1.02300823e-01f, 3.13184232e-01f, -1.75475463e-01f, 1.96010411e-01f, -2.59904772e-01f,
  -9.45003599e-19f, 1.16444938e-01f, 2.19676912e-01f, -9.47720185e-02f, 1.16831861e-01f, 7.79635012e-02f, -1.45890400e-01f, 2.87695646e-01f, 2.47981355e-01f, 8.42950027e-03f,
  -7.17936233e-02f, -2.01875448e-01f, 4.96841781e-03f, 8.21771622e-02f, -5.57054356e-02f, -1.18619658e-01f, -1.70256332e-01f, -1.75075635e-01f, -1.75937803e-27f, -3.73340882e-02f,
  2.52531737e-01f, 4.60464992e-02f, -5.08156940e-02f, 3.55420890e-22f, 2.88813027e-07f, -2.10564844e-02f, 8.62509478e-03f, -1.64121196e-01f, -2.49374025e-02f, 1.09960496e-01f,
  -5.05107976e-02f, -1.58003867e-02f, 3.32039535e-01f, 1.21091507e-01f, 1.69251680e-01f, 1.52620748e-01f, -9.00400206e-02f, 1.51625723e-01f, 1.67535186e-01f, -3.70006040e-02f,
  -2.10993752e-01f, 3.23800981e-01f, -6.20330684e-03f, -7.50949904e-02f, 1.50278479e-01f, 1.73643827e-01f, -7.21815228e-02f, -1.87819868e-01f, 2.39793323e-02f, 5.00068843e-01f,
  1.41291767e-01f, 2.80320924e-02f, 7.88289830e-02f, 2.58734614e-01f, 5.59507795e-02f, 2.17346087e-01f, 2.16325290e-07f, 2.25812942e-01f, -2.25014091e-02f, 2.71551069e-02f,
  -6.47266880e-02f, -2.31839176e-02f, 1.03344411e-01f, 1.40169829e-01f, 4.00051614e-03f, 1.74984246e-01f, 1.95261583e-01f, -1.06927603e-01f, -1.25042930e-01f, 2.20410764e-01f,
  -6.71446472e-02f, 1.32795110e-01f, 8.81947111e-03f, -3.36644500e-02f, -6.45990074e-02f, -4.72975671e-02f, 1.34168297e-01f, 1.96232125e-01f, -3.73799987e-02f, -2.53139198e-01f,
  -4.14524600e-02f, 8.95478297e-03f, 3.41867160e-11f, 1.73175242e-02f, -1.59153208e-01f, -4.63370234e-02f, -1.51006714e-01f, -3.25820369e-20f, 3.52366442e-07f, 1.95654050e-01f,
  1.48698092e-01f, -1.56126991e-01f, 5.51624112e-02f, 1.05438896e-01f, 1.21453919e-01f, 1.37311099e-02f, 1.24471314e-01f, 1.52179569e-01f, -2.62713552e-01f, -4.22427133e-02f,
  -7.23836869e-02f, 5.26742786e-02f, -9.45958868e-02f, -1.33859172e-01f, -1.63787916e-01f, -4.47947904e-02f, -9.81778726e-02f, -2.02832147e-01f, 2.57106841e-01f, 2.58565955e-02f,
  -1.12742163e-01f, 1.54198185e-02f, -2.45512426e-01f, -2.76084900e-01f, -1.57120004e-01f, -9.31504220e-02f, 1.50372654e-01f, -5.84959686e-02f, 3.75876063e-03f, 1.27614021e-01f,
  9.56381784e-14f, 9.72676575e-02f, -1.40502080e-01f, 1.72975461e-03f, -5.29692024e-02f, 2.49234773e-02f, 1.94663391e-01f, -2.09669307e-01f, -7.04012485e-03f, 4.33767512e-02f,
  -4.71882448e-02f, 1.42024666e-01f, -1.76087573e-01f, 1.98804393e-01f, 8.78496468e-02f, 7.51201957e-02f, -1.04408592e-01f, -5.83982915e-02f, 7.49177625e-03f, -1.01401985e-01f,
  1.23191297e-01f, 6.90889359e-02f, -9.15784910e-02f, 2.04575248e-02f, 5.91096468e-02f, -8.56079347e-03f, -4.93811974e-40f, 3.34857479e-02f, 7.91380778e-02f, -1.35103524e-01f,
  8.03492442e-02f, -4.94676575e-40f, 5.11059906e-09f, -9.70481113e-02f, 9.60327759e-02f, -6.62389547e-02f, 2.00528949e-01f, -1.72783196e-01f, 8.13187286e-02f, -1.28318578e-01f,
  8.95342678e-02f, -1.26583233e-01f, -1.41849101e-01f, -1.20655321e-01f, -1.36645809e-01f, 1.36264160e-01f, 1.89901859e-01f, -1.70435771e-01f, -1.55923292e-01f, 2.46375069e-01f,
  3.06151621e-02f, 7.91387111e-02f, 2.99842447e-01f, 1.56151429e-01f, 2.37635300e-01f, -3.41937989e-02f, -1.44289762e-01f, 9.19957682e-02f, 1.68816913e-02f, -8.13414082e-02f,
  -4.91483994e-02f, -4.27400954e-02f, -1.44756287e-01f, 1.01711620e-02f, -3.59304098e-09f, -5.81150874e-02f, -7.73112699e-02f, -8.73065516e-02f, 2.69744664e-01f, 6.15265630e-02f,
  2.06369981e-01f, -3.14064473e-01f, 3.35268280e-03f, -7.67718256e-02f, -1.84056684e-02f, -3.21026929e-02f, -6.15013465e-02f, 1.17125183e-01f, 8.72136727e-02f, 5.01620919e-02f,
  -1.85115391e-03f, 2.13665605e-01f, -6.96634278e-02f, 1.61480725e-01f, -2.15043295e-02f, 1.77495673e-01f, 2.85598636e-01f, 1.01841196e-01f, -1.65933631e-02f, -2.00600550e-01f,
  3.62536417e-13f, 6.06099656e-03f, 1.16861992e-01f, 5.12529016e-02f, 9.19539779e-02f, -5.35570114e-22f, 2.55137365e-07f, 2.93048136e-02f, 1.46541208e-01f, -1.71532229e-01f,
  4.80790548e-02f, 5.86382672e-02f, 8.90761241e-02f, 6.20167144e-02f, -8.64694118e-02f, 9.94537398e-02f, 1.15314521e-01f, -2.17173383e-01f, -8.70361254e-02f, 7.58141056e-02f,
  3.37340459e-02f, -4.20023166e-02f, 1.56504899e-01f, 1.78580761e-01f, -2.52081431e-03f, 4.00235914e-02f, 9.28369835e-02f, 2.84915149e-01f, 3.84677574e-02f, -2.84750551e-01f,
  3.55618745e-01f, 2.15855330e-01f, -4.81808446e-02f, 1.03986219e-01f, 8.53870288e-02f, -1.14005767e-01f, 6.78926483e-02f, 1.45805508e-01f, 2.50528700e-08f, 2.74795532e-01f,
  1.73978448e-01f, -5.24426401e-02f, 4.68477011e-02f, -5.34456186e-02f, 1.02070205e-01f, -1.12944856e-01f, -2.16292869e-06f, 1.45156612e-03f, 1.88539401e-01f, -1.26314000e-03f,
  1.31982148e-01f, -1.19596027e-01f, -1.03099965e-01f, -3.93707827e-02f, 6.72244430e-02f, 4.68226559e-02f, 4.59691808e-02f, -7.77392462e-02f, -7.17797503e-02f, 1.13061182e-01f,
  1.50782643e-02f, -1.09898530e-01f, 1.02051832e-01f, -1.34923294e-01f, -4.92378445e-40f, -7.91844912e-03f, -2.81979796e-02f, 2.10406110e-02f, -5.28036095e-02f, 1.02898961e-19f,
  -2.79473924e-20f, 1.47426158e-01f, 2.44696834e-03f, -6.40963838e-02f, 6.51029274e-02f, 1.88803643e-01f, -1.22589305e-01f, 2.20376939e-01f, -5.34855872e-02f, 3.15981507e-02f,
  3.43724862e-02f, 1.46043405e-01f, 7.00940052e-03f, 6.59525692e-02f, 1.96131453e-01f, 1.51103605e-02f, 1.04756832e-01f, 1.11729212e-01f, 2.05464169e-01f, 1.11236542e-01f,
  -1.98008314e-01f, 1.16342120e-01f, 3.85750949e-01f, -2.05084179e-02f, 1.84986874e-01f, 3.52977395e-01f, -1.14072442e-01f, 2.79180259e-01f, -3.14003937e-02f, 1.22507043e-01f,
  -2.39906058e-01f, 2.33990356e-01f, -2.68001600e-06f, -1.95255125e-04f, 5.35648875e-02f, 2.16442242e-01f, -1.23318501e-01f, -1.03900611e-01f, 1.19477063e-01f, 3.54046762e-01f,
  -2.75173364e-03f, 1.11735351e-01f, 2.72754908e-01f, -2.89743394e-01f, -7.60444850e-02f, 1.94800556e-01f, 1.82608709e-01f, 1.06033646e-01f, 9.80724916e-02f, -1.36805037e-02f,
  -1.69255841e-03f, -8.45149830e-02f, -2.73659099e-02f, 2.23655611e-01f, -9.94808599e-02f, -3.34629208e-01f, 2.05793455e-01f, 1.28984764e-01f, 2.96441829e-11f, 1.10962860e-01f,
  -1.07822493e-01f, 2.23690197e-01f, 1.73097506e-01f, 4.39824251e-21f, -1.02072136e-07f, 2.65463233e-01f, -1.99995026e-01f, 6.16113842e-03f, -4.75675352e-02f, 2.62043834e-01f,
  -3.13878432e-02f, 6.92217872e-02f, -1.30121961e-01f, 1.55468076e-01f, -2.19822414e-02f, 1.13984965e-01f, -1.91871047e-01f, 5.32203028e-03f, -2.75888920e-01f, 6.55298233e-02f,
  4.49965857e-02f, -2.73222066e-02f, -1.59648091e-01f, -7.33566880e-02f, -5.97237423e-02f, 1.78255409e-01f, -1.04125619e-01f, -8.02517012e-02f, 3.14336628e-01f, 5.41127287e-02f,
  2.52191484e-01f, 3.59183401e-02f, 1.38855457e-01f, -2.77573735e-01f, 8.41140822e-02f, 1.20414779e-01f, -3.21653628e-26f, -4.95733060e-02f, 3.37440848e-01f, -2.20297799e-01f,
  -6.30770698e-02f, -5.36861122e-01f, -1.09737001e-01f, -7.91531950e-02f, 3.08666844e-03f, -1.98574588e-01f, 1.71072707e-01f, 8.69810879e-02f, -4.87969443e-02f, -8.46136957e-02f,
  -3.62130165e-01f, -3.68162990e-02f, 5.22600673e-02f, -8.28490332e-02f, 2.30344199e-02f, -9.50377658e-02f, -3.75395678e-02f, -3.54017913e-02f, 4.69093360e-02f, -3.71982485e-01f,
  1.32143542e-01f, -3.53724420e-01f, 1.38621756e-22f, -4.92705926e-02f, -6.75715208e-02f, 1.15515597e-01f, -2.43487582e-02f, -7.93193960e-22f, -2.68872213e-06f, 6.61411211e-02f,
  5.38356695e-03f, 3.53674218e-02f, -2.46914938e-01f, 1.76845342e-01f, -2.52681077e-01f, 2.03486934e-01f, 1.76761430e-02f, 1.26755461e-01f, 8.68980587e-02f, 1.93329915e-01f,
  1.26675040e-01f, -1.93929598e-01f, 1.79260287e-08f, -1.24334383e-08f, -9.88860815e-09f, -3.98445816e-12f, -1.58169658e-10f, 2.18626695e-09f, -2.50779080e-13f, -4.60066846e-11f,
  -7.43510808e-10f, 1.45148382e-08f, -1.27022339e-08f, -8.28632774e-10f, 1.37662505e-13f, -4.26172155e-05f, 5.67881808e-40f, 4.94439755e-40f, 3.01467251e-09f, -9.94129650e-08f,
  -5.33851275e-40f, 1.56378504e-11f, 4.92887117e-40f, -1.21430076e-05f, -4.78295874e-08f, 3.64311852e-14f, 1.61983365e-07f, -3.84682551e-07f, -4.93038457e-40f, -4.30343894e-09f,
  -5.74724224e-09f, -3.97307961e-15f, 4.19681824e-12f, -3.63732875e-06f, -8.05212210e-07f, 9.63503322e-12f, 1.31905367e-07f, 1.41107890e-08f, -5.58252472e-11f, -4.94602306e-40f,
  -7.24385870e-07f, -1.95363668e-06f, 6.40517825e-08f, -1.04035280e-14f, -1.81219395e-04f, -2.98753548e-07f, -4.91708625e-40f, -1.19151196e-06f, 1.81401172e-12f, -3.23988104e-07f,
  -4.91615137e-05f, -5.68784244e-40f, -5.00634896e-40f, -1.45543636e-05f, -9.41318046e-09f, -3.75329362e-15f, -7.53427639e-06f, 1.74283159e-05f, -1.43797785e-09f, -3.57034810e-06f,
  -2.33659225e-08f, -1.42376430e-05f, 1.50230017e-06f, -6.04762490e-11f, -4.95057151e-08f, 6.32714801e-12f, -6.03084043e-02f, -1.06360065e-02f, 2.46627957e-01f, 8.56524557e-02f,
  -2.87955869e-02f, 1.51932538e-02f, -3.24465722e-01f, 1.69579700e-01f, 1.22475505e-01f, 8.82185027e-02f, -1.47642465e-02f, -1.87909096e-01f, 1.51979299e-02f, -1.45391494e-01f,
  7.89668262e-02f, -5.76793142e-02f, 1.27672434e-01f, -1.44530535e-02f, 4.94477590e-40f, 2.49923587e-01f, 1.13479532e-01f, -1.52603328e-01f, -1.13540232e-01f, 9.79026556e-02f,
  -2.99117286e-02f, 7.22278878e-02f, -3.87704582e-16f, 1.00986458e-01f, 1.38281152e-01f, -1.61513567e-01f, 3.17869276e-01f, -2.67299473e-01f, 1.58108678e-03f, 1.72648922e-01f,
  1.06151007e-01f, 2.07730979e-02f, 5.33760041e-02f, 4.14143950e-02f, -1.13365613e-01f, -2.47817323e-01f, -2.14506555e-02f, 2.01396391e-01f, -5.40104546e-02f, -4.43294086e-02f,
  5.95429934e-40f, -3.61763723e-02f, 5.79187535e-02f, -3.87079641e-02f, 5.64932525e-02f, 5.00828275e-40f, 5.23068296e-22f, -2.44905781e-02f, -2.51038998e-01f, 2.02501073e-01f,
  -9.96787921e-02f, 3.48892510e-02f, -3.99404131e-02f, -5.45934588e-02f, -3.16573493e-02f, -1.66520372e-03f, 1.41570926e-01f, 1.11542523e-01f, 4.93955687e-02f, 7.70936608e-02f,
  -8.82079624e-16f, 3.62676875e-13f, -4.22269482e-16f, 1.05085905e-12f, -3.81677943e-17f, 1.25625638e-13f, 1.07073537e-14f, -4.93877835e-40f, -2.37123824e-14f, 2.80269536e-20f,
  -2.37046253e-14f, -3.06645283e-17f, -8.09242465e-06f, -7.47153070e-04f, -4.98349378e-40f, -1.23979549e-10f, 4.92800236e-40f, -5.14599196e-06f, 5.08211717e-40f, 4.93488274e-40f,
  -1.65274894e-28f, -8.28333505e-05f, 4.95518755e-40f, 4.96835976e-40f, 4.92423287e-40f, -1.45829681e-12f, -5.05850529e-40f, -7.12360725e-06f, -4.92297170e-40f, 5.07604954e-40f,
  4.95556590e-40f, -1.82014031e-14f, -5.00344453e-11f, 4.94061405e-40f, -4.95169832e-40f, -4.90958930e-40f, -2.96697813e-08f, 4.98773971e-40f, -1.41034934e-05f, -1.98418638e-04f,
  5.12799568e-40f, -5.01329940e-40f, -4.78773669e-04f, -4.67571803e-09f, -5.57330030e-40f, -8.96812011e-08f, 4.95035307e-40f, -3.14759309e-05f, -1.00907714e-21f, -4.92143027e-40f,
  5.97676216e-40f, -3.96991782e-05f, -4.98643651e-40f, 4.94239370e-40f, -1.84630143e-15f, -4.33195928e-05f, -3.52998295e-24f, -1.47062956e-05f, -4.90873451e-40f, -7.19059517e-06f,
  4.93973123e-40f, 4.91052817e-40f, -1.17904106e-26f, -5.13969652e-40f, 3.86410385e-01f, 1.62608460e-01f, 1.00787513e-01f, 1.22816294e-01f, -1.48133282e-02f, 2.53469557e-01f,
  -2.02283874e-01f, -1.28981516e-01f, 7.00532198e-02f, 3.00971270e-01f, -2.34116599e-01f, 1.50676399e-01f, -2.59484053e-01f, 1.22396328e-01f, 6.83663189e-02f, 1.66273728e-01f,
  2.02306360e-01f, -6.04972802e-02f, -2.16844960e-08f, -2.77252018e-01f, -6.83938041e-02f, 8.37104023e-02f, 1.66532934e-01f, -2.60467269e-02f, 8.00677016e-02f, 5.10662794e-02f,
  5.76075990e-06f, -3.23504843e-02f, -7.16160908e-02f, 3.06413502e-01f, -1.89134225e-01f, 5.21355532e-02f, 1.24336980e-01f, -1.18928410e-01f, 2.27859586e-01f, 6.45402027e-03f,
  -9.32419524e-02f, -3.30534905e-01f, 1.00129999e-01f, 1.06515951e-01f, -6.08304776e-02f, -1.92136675e-01f, -1.42420024e-01f, 1.70406029e-01f, -1.52055177e-39f, 2.39666551e-02f,
  1.38611123e-01f, 2.44987667e-01f, -6.45531565e-02f, 1.45634772e-32f, -2.63734229e-10f, -1.92169666e-01f, 4.41567898e-02f, 1.87878057e-01f, 1.09465696e-01f, -8.45347345e-02f,
  1.42946392e-01f, -7.13243186e-02f, 2.04093099e-01f, -1.15213558e-01f, 1.96434930e-01f, 6.39980733e-02f, 2.11372972e-01f, 1.85818803e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  -6.56592520e-03f, 5.57370298e-02f, 7.95668811e-02f, 9.75025147e-02f, 2.57419646e-02f, -4.48643975e-02f, -3.42423990e-02f, 1.86704546e-01f, 1.88696533e-02f, -6.96390495e-02f,
  5.13249189e-02f, -6.30849525e-02f, -3.12352385e-02f, 4.95321602e-02f, 2.88696382e-02f, 4.95034680e-02f, 6.62394240e-02f, 1.62282228e-01f, 9.87673253e-02f, 5.71532641e-03f,
  -7.87940994e-03f, -2.07336161e-05f, -6.78597614e-02f, -3.30553725e-02f, -2.11099051e-02f, -4.67604175e-02f, 6.35448247e-02f, 1.25751004e-01f, 9.28128958e-02f, -1.41972016e-11f,
  -1.61195197e-03f, -9.37451273e-02f, 5.22116125e-02f, -3.58934216e-02f, 2.42444202e-02f, 1.58627585e-01f, 1.26829026e-02f, 8.83185938e-02f, -5.99367954e-02f, -6.05460964e-02f,
  -3.36865820e-02f, 1.48029491e-01f, 1.05789572e-01f, -6.75675496e-02f, 3.72126661e-02f, 1.68974802e-01f, -9.66296047e-02f, 2.65924353e-02f, -4.25294559e-07f, 4.35135178e-02f,
  -7.03797021e-11f, 5.22647090e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  1.07722029e-01f, -1.71441227e-01f, 4.87751625e-02f, -2.50615269e-01f, -4.31322232e-02f, 1.17429830e-01f, -1.42674744e-01f, -4.46447097e-02f, 9.17513110e-03f, -5.29992953e-03f,
  1.80000067e-01f, -4.45251167e-02f, -3.46651822e-01f, -8.22396353e-02f, -3.29559863e-01f, 2.63530519e-02f, -3.37180942e-01f, 1.23233974e-01f, -4.39143509e-01f, -2.52480239e-01f,
  -1.71951339e-01f, -3.73578966e-01f, 7.35163093e-02f, 4.41044271e-02f, -8.97506791e-11f, -3.12009174e-02f, 1.16835274e-01f, -1.32104889e-01f, -4.35908347e-01f, -3.32628518e-01f,
  -4.01090831e-01f, -2.14984253e-01f, -9.22590401e-03f, -9.79373217e-05f, -8.96604825e-03f, 1.34101033e-01f, 7.97885358e-02f, 3.71562131e-02f, 6.44357726e-02f, -1.41021192e-01f,
  -6.93080649e-02f, -1.44099118e-03f, -1.66883110e-18f, 1.47066996e-01f, -3.51221532e-01f, 6.77261502e-02f, -2.65892893e-01f, 1.09826930e-01f, -9.05774906e-02f, 1.43113464e-01f,
  8.90766755e-02f, -3.00304085e-01f, 5.96504547e-02f, -2.92949796e-01f, 8.67433399e-02f, 2.20023729e-02f, -1.21783450e-01f, -3.49317431e-01f, 1.18078984e-01f, -1.39596358e-01f,
  -3.30339708e-06f, -3.50484222e-01f, 1.02035161e-13f, 1.22484036e-01f, -1.37489825e-01f, -2.44419836e-02f, -7.84818530e-02f, -2.70735979e-01f, 3.39896753e-02f, -7.89434090e-02f,
  -3.47721763e-02f, 3.75890583e-02f, -1.27816781e-01f, 1.14870429e-01f, -1.78920314e-01f, 1.71982363e-01f, 7.50224441e-02f, -1.23950042e-01f, -7.28855431e-02f, 4.48028147e-02f,
  -2.90641397e-01f, 1.20010935e-01f, -3.53178531e-02f, -2.91938901e-01f, -1.53864533e-01f, -1.73177928e-01f, -4.06501472e-01f, -2.68996239e-01f, -1.35792857e-02f, -1.17543489e-01f,
  1.41408429e-01f, 6.01141267e-02f, -1.69799641e-01f, 1.04950748e-01f, 4.81125526e-02f, -5.71252294e-02f, 1.41901076e-02f, -3.08332383e-03f, 5.76406009e-02f, 1.59164354e-01f,
  1.12660736e-01f, -1.78504527e-01f, -3.76900047e-01f, -4.96675521e-02f, -2.76293218e-01f, -8.92665703e-03f, 3.11731545e-15f, -6.94463402e-03f, -1.49044851e-02f, -1.67812016e-02f,
  6.24735141e-03f, 1.53547749e-01f, -2.32497156e-01f, 8.03248286e-02f, -2.05194220e-01f, 1.31710261e-01f, 1.67814195e-02f, -3.13108593e-01f, 3.69648375e-02f, -1.56160504e-01f,
  -4.59890775e-02f, 7.36477748e-02f, 2.24603772e-01f, 2.12871097e-02f, -2.93980393e-05f, -1.72569424e-01f, -8.34275130e-03f, -2.09841296e-01f, 1.94392517e-01f, 1.36260062e-01f,
  -7.70162120e-02f, 2.55165011e-01f, -1.99612290e-01f, 6.67384034e-03f, 1.44481003e-01f, 8.89105499e-02f, -2.35537857e-01f, 1.07828721e-01f, -2.84291953e-01f, -5.56610599e-02f,
  -2.46234268e-01f, 1.30760685e-01f, 1.29304752e-01f, -2.44415719e-02f, -2.94649005e-01f, 7.55459443e-02f, -4.04127985e-01f, 1.18754700e-01f, 1.39280602e-01f, 1.76909879e-01f,
  6.85533285e-02f, -3.91926855e-01f, -1.67372881e-03f, 1.50515690e-01f, -1.45606492e-02f, -1.47252474e-02f, -3.35645936e-02f, 2.08817512e-01f, -5.15083134e-01f, -1.00799501e-01f,
  1.54086472e-02f, -1.44086243e-03f, -8.66815299e-02f, 8.30102712e-02f, -5.49555346e-02f, -2.58798972e-02f, 1.66001394e-01f, -2.94340730e-01f, -4.21606749e-01f, 6.81238773e-04f,
  -1.49664982e-39f, -2.73332179e-01f, -5.53020742e-03f, 2.91205314e-03f, -2.72036493e-01f, 1.10347971e-01f, 1.28316894e-01f, 1.89241499e-01f, -4.08454686e-01f, -2.73713470e-01f,
  6.96197972e-02f, -3.30620408e-01f, -1.07772529e-01f, -2.73945242e-01f, -1.95458978e-01f, 5.68390749e-02f, 6.74712509e-02f, -4.13096666e-01f, -2.01854924e-08f, -1.78138345e-01f,
  5.79766184e-03f, 1.08898759e-01f, -1.39141679e-01f, 1.20394669e-01f, 5.02756573e-02f, 6.72031119e-02f, 5.21999821e-02f, -1.13017336e-01f, 9.99346748e-02f, -1.46537483e-01f,
  2.74046063e-01f, 1.32957950e-01f, 3.25699180e-01f, 4.09974381e-02f, -1.10008903e-01f, 5.33132665e-02f, -4.22164239e-02f, -3.21055599e-03f, -1.33907691e-01f, 5.25264591e-02f,
  -4.78887171e-01f, -9.19161141e-02f, -4.87515926e-02f, 9.16737914e-02f, -3.00022885e-02f, 1.44161791e-01f, -2.13540925e-12f, -9.85567868e-02f, -7.77265662e-03f, -1.52517082e-02f,
  -8.37014243e-02f, -2.02008948e-01f, -3.22826773e-01f, -1.56219780e-01f, -1.50963634e-01f, -1.30153978e-06f, 6.74469909e-03f, 8.83729197e-03f, -5.86177111e-02f, 2.02237740e-02f,
  1.04186587e-01f, -1.28645882e-01f, -3.40397307e-03f, -7.71135547e-06f, 2.41848275e-09f, 1.75289571e-01f, -8.89236555e-02f, -2.38059182e-02f, -4.21943039e-01f, -3.26993614e-01f,
  1.38138622e-01f, 7.79188052e-02f, 3.49914581e-01f, -2.34116048e-01f, 1.48558602e-01f, -2.99623460e-01f, -3.18087786e-01f, -7.92723745e-02f, -1.14531768e-02f, -2.46043071e-01f,
  -3.53201598e-01f, -9.48429666e-03f, -4.29204326e-16f, 1.18047066e-01f, -4.93925479e-40f, -1.88671649e-01f, -1.57679483e-01f, -1.40305340e-01f, -7.21958503e-02f, 4.10774862e-03f,
  -4.07748371e-02f, -1.19470961e-01f, 1.40041396e-01f, -1.68930143e-01f, -1.27561882e-01f, -9.46383104e-02f, -2.16767062e-02f, -8.24158937e-02f, -3.07475198e-02f, 8.95565301e-02f,
  3.70218884e-03f, 2.66608596e-02f, -8.57681558e-02f, -1.77169181e-02f, -3.50542776e-02f, 1.42303601e-01f, -1.95146590e-01f, -9.04323608e-02f, -1.14553599e-02f, 7.07561448e-02f,
  -7.78538547e-03f, -8.85571316e-02f, 3.05090919e-02f, 1.70777172e-01f, 2.39899028e-02f, -3.42978269e-01f, 1.37904838e-01f, -2.75529861e-01f, -1.79418810e-02f, 1.27726770e-03f,
  -1.45410737e-02f, -5.15263192e-02f, 4.10737172e-02f, 1.62007377e-01f, -9.11875069e-02f, -1.47180438e-01f, 1.13226816e-01f, -6.67703163e-04f, 1.77764334e-02f, -1.58546586e-02f,
  -3.05029720e-01f, -3.77222113e-02f, 1.39532954e-01f, 6.52749389e-02f, 1.75492000e-02f, 1.32912397e-01f, -2.46198326e-01f, 1.03985064e-01f, 1.69507146e-01f, -2.44101822e-01f,
  -1.47048563e-01f, 1.34530202e-01f, -2.39013582e-02f, -1.62506431e-01f, -3.08377743e-01f, -5.20123616e-02f, -1.25318094e-08f, -2.90347844e-01f, -7.85367477e-36f, 1.25915155e-01f,
  2.28911519e-01f, 9.44500603e-03f, -3.51311117e-02f, 4.30527702e-02f, -1.37143368e-02f, 2.28229299e-01f, 1.78843468e-01f, -2.51527071e-01f, 8.63486007e-02f, 1.64262399e-01f,
  9.60978791e-02f, 2.84702122e-01f, -2.13980034e-01f, -2.41642371e-02f, -1.15977868e-01f, -2.69938130e-02f, -2.19508857e-02f, -6.11218587e-02f, 7.31457621e-02f, 1.88435446e-02f,
  -1.38712972e-01f, -1.10745527e-01f, 3.66569348e-02f, -1.32679015e-01f, -1.74707137e-02f, -1.23074442e-01f, -4.98304926e-02f, 1.03599191e-01f, -3.20315450e-01f, -2.33389184e-01f,
  -1.25835449e-01f, 1.68321475e-01f, -1.23795398e-01f, 1.05757667e-02f, -5.63806333e-02f, 2.22835578e-02f, -2.29009584e-01f, -2.98656225e-02f, -1.18507050e-01f, 2.13756964e-01f,
  1.36825159e-01f, 8.29412777e-04f, -2.14923620e-02f, 1.17933229e-01f, 1.16431817e-01f, -3.39569747e-02f, -8.08202475e-02f, 1.87945843e-01f, -1.27213717e-01f, 1.39355185e-02f,
  -1.41146109e-01f, 1.56836376e-01f, -2.79864073e-02f, 1.10368200e-01f, 2.50925899e-01f, 4.28697392e-02f, 1.42780170e-01f, 7.14194104e-02f, 7.05770552e-02f, -2.73182511e-01f,
  -4.05527861e-10f, -3.62216175e-01f, 2.21220267e-04f, -8.65102410e-02f, 9.10606310e-02f, -1.98295675e-02f, 1.02117471e-01f, 2.36202497e-02f, -6.85443655e-02f, 1.42031252e-01f,
  -3.20130259e-01f, 1.72047153e-01f, -4.15653102e-02f, -2.26345330e-01f, -4.26190011e-02f, -2.44540554e-02f, -2.36206383e-01f, 1.02360316e-01f, 1.49017751e-01f, -6.28444701e-02f,
  3.13311368e-02f, -1.60414115e-01f, 1.34933427e-01f, 2.07430407e-01f, 1.62006110e-01f, 3.86116258e-03f, -2.72194237e-01f, -8.54234621e-02f, 1.13390320e-06f, -4.38224792e-01f,
  -4.47046876e-01f, 4.72274348e-02f, -2.69729085e-02f, 2.42622808e-01f, 3.92014086e-02f, -2.91037887e-01f, -1.05276257e-01f, 2.05457513e-03f, 3.19079757e-02f, -3.35323811e-01f,
  2.06529293e-02f, -4.94056106e-01f, -2.35667422e-01f, -4.20923643e-02f, -1.56893834e-01f, -2.60812975e-03f, -2.02963836e-02f, -8.88718516e-02f, -1.84714643e-03f, -1.45955626e-02f,
  -1.22297667e-01f, 1.34693444e-01f, -3.62173431e-02f, -2.44408056e-01f, -4.90332842e-02f, 2.61457950e-01f, -2.30646119e-01f, 2.23992281e-02f, 8.75877514e-02f, -3.54769677e-01f,
  -9.21026915e-02f, 6.26056641e-02f, -1.75280556e-01f, 2.08710253e-01f, -2.29837351e-12f, -2.29946390e-01f, 4.92885715e-40f, -1.53420568e-02f, -5.84414713e-02f, -8.70302022e-02f,
  6.71883300e-02f, 3.52923311e-02f, -8.50014202e-03f, 1.26154304e-01f, -7.46016502e-02f, 1.09729923e-01f, -9.68902931e-02f, -8.85243192e-02f, 1.25710294e-01f, -3.64655286e-01f,
  1.91593155e-01f, 3.54349986e-02f, -9.45033655e-02f, -3.13257247e-01f, 1.43804401e-01f, -1.49930897e-03f, -1.17594600e-02f, -2.49017477e-01f, 4.17870544e-02f, 1.34550452e-01f,
  -8.58181790e-02f, 5.55764250e-02f, -2.21140869e-03f, -3.72790426e-01f, 3.69314738e-02f, -1.36058658e-01f, 1.41868502e-01f, -1.57841951e-01f, 2.11702362e-01f, 2.92898770e-02f,
  -1.12797864e-01f, 1.61979897e-05f, -3.17034754e-03f, -1.36901438e-01f, -1.03310518e-01f, -8.76913685e-03f, -1.60131142e-01f, 1.76873311e-01f, -2.10125387e-01f, -1.00456213e-03f,
  -7.79786386e-27f, -2.13917881e-01f, -3.09768707e-01f, -7.47850686e-02f, 3.15097906e-02f, -2.35351130e-01f, -2.60601062e-02f, -1.36244178e-01f, 6.60845488e-02f, 4.09296416e-02f,
  1.48070425e-01f, 1.76518500e-01f, -1.49264127e-01f, 1.18540250e-01f, 1.69776231e-01f, 6.84105828e-02f, -1.48801312e-01f, -1.53947935e-01f, -3.07621401e-10f, -2.42642909e-02f,
  6.22314683e-15f, -1.15056552e-01f, -5.08213304e-02f, -2.09920779e-02f, 1.62240304e-02f, 1.00739181e-01f, 9.06692967e-02f, 4.51216325e-02f, -8.05875137e-02f, -8.22745562e-02f,
  -1.49200439e-01f, 4.09972534e-04f, -1.14687353e-01f, 3.45370583e-02f, 1.73843801e-01f, -4.03640002e-01f, -2.79954046e-01f, -3.64407629e-01f, 1.05104581e-01f, -3.47993284e-01f,
  -1.34043902e-01f, -1.45257860e-01f, -4.60337522e-03f, -2.57124215e-01f, -6.55310005e-02f, -2.23872811e-01f, 7.57870777e-03f, 7.21189752e-02f, -2.61096090e-01f, -4.81272712e-02f,
  1.30411997e-01f, 1.95559293e-01f, 5.59078483e-03f, 1.99639440e-01f, -2.79992819e-02f, 8.91009488e-10f, -2.05682591e-02f, -9.25472677e-02f, -3.57684255e-01f, -4.12130266e-01f,
  2.54883558e-01f, 1.93187952e-01f, -2.44046018e-01f, 4.50269738e-03f, -1.15837093e-34f, -2.33309656e-01f, 7.09062666e-02f, -3.86357196e-02f, 7.41554750e-03f, -5.26719689e-02f,
  -2.36920103e-01f, -2.48306185e-01f, -6.38510659e-02f, -1.90916464e-01f, -3.92823130e-01f, 2.26087019e-01f, 1.02310918e-01f, -3.98044556e-01f, -3.89522582e-01f, 6.06017374e-02f,
  3.37041654e-02f, -1.54928081e-02f, 2.48375565e-09f, 1.71514615e-01f, -2.35480784e-14f, -1.38826996e-01f, -8.23440030e-02f, -6.67057484e-02f, -1.09946832e-01f, -4.21566591e-02f,
  4.00773771e-02f, 1.54948026e-01f, -1.52070984e-01f, 8.51528868e-02f, -1.28281742e-01f, -6.11273833e-02f, -2.07473010e-01f, -2.26185188e-01f, -1.22043349e-01f, 2.75511481e-02f,
  1.68903947e-01f, -4.64633822e-01f, 1.57118261e-01f, 3.11853029e-02f, 4.44285944e-02f, 2.67058253e-01f, 1.32447451e-01f, 1.09484933e-01f, 2.43999466e-01f, -3.61748695e-01f,
  3.58772278e-03f, -9.38920677e-02f, -2.98899077e-02f, -4.65542898e-02f, 1.89006835e-01f, 1.01337489e-02f, -1.18480451e-01f, 7.46527091e-02f, -2.18597233e-01f, -2.25497177e-03f,
  1.07803685e-03f, -2.38245279e-01f, -4.03869122e-01f, -5.19738086e-02f, 1.73802391e-01f, -3.12844701e-02f, -1.58680826e-01f, 2.01679044e-03f, 2.22522877e-02f, -3.89487833e-01f,
  -1.28745034e-01f, 1.23903863e-02f, -6.77754104e-01f, -1.19557165e-01f, 1.28978938e-01f, 6.62632361e-02f, -3.21304649e-01f, 7.72198811e-02f, -8.41260031e-02f, 9.93318334e-02f,
  -6.33152276e-02f, -9.05185193e-02f, 7.68819973e-02f, -6.89591616e-02f, -9.00628641e-02f, -3.27849239e-01f, -1.12418053e-09f, -1.06218629e-01f, 2.98568154e-19f, 2.16719866e-01f,
  1.78551499e-03f, -3.85176800e-02f, 5.41648269e-02f, 1.43720195e-01f, 7.77626112e-02f, -2.08056793e-01f, -1.67915359e-01f, -7.16164857e-02f, -1.30496239e-02f, -2.64448673e-01f,
  2.90890217e-01f, -6.78272247e-02f, -2.02136040e-01f, -1.00037098e-01f, -2.63298929e-01f, -1.62001878e-01f, -1.60966083e-01f, -3.57656538e-01f, -5.05549610e-01f, -1.62428878e-02f,
  -3.09742838e-01f, -1.80905014e-01f, -9.15591419e-02f, -1.16885312e-01f, 9.25454218e-03f, 2.28709817e-01f, -3.45742524e-01f, -4.83799130e-02f, 1.37639612e-01f, -2.88545698e-01f,
  -4.49480027e-01f, 1.38732731e-01f, -8.08518787e-04f, -4.95025498e-40f, -3.26058716e-02f, -1.44679472e-01f, -3.30624133e-01f, -1.44984620e-02f, 1.95240155e-01f, 1.73229963e-01f,
  2.89032727e-01f, 7.95898885e-08f, 5.16134658e-40f, 2.06661701e-01f, -1.46259423e-02f, 3.81526649e-02f, -2.74399608e-01f, -4.87211972e-01f, 1.47061914e-01f, -1.68346599e-01f,
  -9.10597965e-02f, -1.99192408e-02f, 1.55279726e-01f, 1.64685994e-01f, -1.15140110e-01f, 1.61524653e-01f, -8.08685869e-02f, -5.57852583e-03f, -3.37755233e-01f, -1.66132972e-02f,
  -9.74549122e-11f, 1.76657066e-01f, -4.91138296e-40f, -3.73692065e-01f, -2.27781281e-01f, -4.69788164e-02f, -1.30144889e-02f, -5.40319420e-02f, -4.32606554e-03f, -7.04696104e-02f,
  2.11230010e-01f, 7.01220185e-02f, -1.68899760e-01f, 1.66519493e-01f, 3.49433810e-01f, -6.57863095e-02f, 3.11638750e-02f, 5.04476391e-02f, 1.58656821e-01f, -2.32337251e-01f,
  -1.82627797e-01f, 1.82509586e-01f, -6.00135401e-02f, -1.37695432e-01f, 2.04045057e-01f, 2.32396379e-01f, -1.43284604e-01f, -2.37665743e-01f, 2.67218389e-02f, -2.43078351e-01f,
  2.97250580e-02f, -2.53079414e-01f, -1.77646324e-01f, 1.60213217e-01f, 1.68217972e-01f, -2.35247940e-01f, -1.84466094e-02f, 3.78366640e-05f, 2.95837391e-02f, -5.91766126e-02f,
  -3.63648117e-01f, -1.99465841e-01f, 1.19792782e-01f, -2.52345890e-01f, -6.49670660e-02f, 1.47058931e-03f, 5.60331612e-40f, -1.31054148e-01f, 2.33907461e-01f, -7.42196962e-02f,
  -2.73059368e-01f, 6.48366287e-02f, -3.12031090e-01f, -2.95436859e-01f, 1.10761553e-01f, -2.94643164e-01f, -3.52370650e-01f, -6.22378942e-03f, -3.53180677e-01f, -3.42934616e-02f,
  -2.04922944e-01f, 1.15807533e-01f, -1.14617925e-02f, 1.23651475e-01f, -1.78452766e-10f, 1.80276379e-01f, -5.48673020e-27f, 8.36593434e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.17711717e-01f, 5.32429926e-02f, -3.58239226e-02f, -5.96858971e-02f, 9.53733549e-02f, 1.15251452e-01f, -7.98059031e-02f, -7.86990374e-02f, 2.32986435e-02f, 1.10694453e-01f,
  -2.97308322e-02f, 6.48942217e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    