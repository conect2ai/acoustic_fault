/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.36628100e-01f, 1.60208315e-01f, 5.98798133e-02f, -1.62320957e-01f, -4.43221955e-03f, -1.78147599e-01f, -2.16820836e-01f, 2.47144669e-01f, 1.82365313e-01f, 7.28689730e-02f,
  -2.58891106e-01f, 7.25410283e-02f, -3.74339260e-02f, -3.17813367e-01f, -3.72480631e-01f, -3.01960502e-02f, -1.86626554e-01f, -2.00184494e-01f, 9.94780958e-02f, 9.50937532e-03f,
  -9.52299088e-02f, -7.38986656e-02f, -4.31938395e-02f, 2.13707522e-01f, 4.95233852e-03f, 1.48637310e-01f, -4.31005135e-02f, 7.50055239e-02f, -4.51727882e-02f, -6.95346370e-02f,
  -6.94182515e-02f, -1.17423311e-01f, 6.65735640e-03f, 2.80017629e-02f, 4.29301448e-02f, 3.43869324e-03f, -7.00104535e-02f, -7.16437772e-02f, -2.98792943e-02f, 5.10154143e-02f,
  -4.55041155e-02f, 5.49115054e-02f, 2.02088384e-03f, 1.11631244e-01f, 9.66013744e-02f, 1.22219242e-01f, -5.99206192e-03f, 5.18099144e-02f, -1.82146812e-03f, 4.04773913e-02f,
  1.27710961e-02f, -3.49389017e-02f, -4.70638983e-02f, 4.70102020e-02f, 4.86211292e-02f, -1.86262000e-02f, -3.29466276e-02f, -2.07242579e-03f, 5.93993580e-03f, -4.97758687e-02f,
  1.45849036e-02f, 7.53694549e-02f, 2.93345861e-02f, 2.93542054e-02f, -8.44527909e-04f, -6.45016804e-02f, 3.81677900e-03f, -1.19884789e-01f, -1.67603530e-02f, -2.43656803e-02f,
  -3.53426859e-02f, -6.20800219e-02f, -2.89400620e-03f, -9.90024023e-03f, -3.32924798e-02f, 3.78772281e-02f, -4.58208770e-02f, -3.92393991e-02f, -2.21877731e-02f, 3.75942104e-02f,
  2.74720620e-02f, -2.82690916e-02f, 3.29758003e-02f, -5.83127029e-02f, -3.59320268e-02f, 3.87064330e-02f, 6.30787611e-02f, -1.82147268e-02f, -2.87534706e-02f, 3.09182853e-02f,
  -2.82637998e-02f, 4.83220555e-02f, 9.10094380e-02f, 4.66484204e-03f, 1.59743689e-02f, 2.74615064e-02f, -2.47143861e-02f, 8.58391374e-02f, 7.31634349e-02f, 2.56875865e-02f,
  9.06377211e-02f, -7.52505884e-02f, 1.61578245e-02f, -3.64222527e-02f, 6.91278204e-02f, -2.18098667e-02f, -1.87242161e-02f, -3.48311514e-02f, -1.03137903e-02f, 5.99922352e-02f,
  -9.46235582e-02f, -7.07597286e-02f, -5.19348169e-03f, 2.22590100e-02f, -1.34143857e-02f, 6.18262440e-02f, 8.28483421e-03f, 6.26400188e-02f, -6.30128607e-02f, 2.01448984e-02f,
  -2.71684498e-01f, 2.36332372e-01f, -1.92777991e-01f, 4.26178575e-01f, -1.38561964e-01f, -1.51124716e-01f, -1.53328449e-01f, 3.43571566e-02f, 8.83061439e-02f, 1.40229359e-01f,
  2.05735005e-02f, -2.07897410e-01f, -5.78494743e-02f, 2.66341805e-01f, -3.89978230e-01f, 4.46754806e-02f, 1.80484012e-01f, 5.22256792e-02f, 2.45947465e-02f, 1.47906303e-01f,
  2.18761712e-02f, 1.81309693e-02f, -9.97037534e-03f, -1.91263054e-02f, -8.17677528e-02f, 2.28867754e-02f, -7.22901598e-02f, 3.48970033e-02f, 2.92154383e-02f, -7.11971447e-02f,
  -1.09151915e-01f, 4.48552072e-02f, -1.75230056e-02f, 4.60719541e-02f, -9.18074921e-02f, -1.21853963e-01f, -5.14260270e-02f, -6.87857270e-02f, -1.00652529e-02f, 5.14007593e-03f,
  -9.10811350e-02f, -4.35231328e-02f, 2.34502461e-02f, 6.68346286e-02f, 2.55947616e-02f, -1.75696146e-02f, 4.60795090e-02f, -2.52772346e-02f, 6.87516406e-02f, -3.50898989e-02f,
  5.02927043e-03f, -1.82567630e-02f, 4.08013500e-02f, 1.03920974e-01f, 2.29811240e-02f, 3.34552936e-02f, 3.80323455e-02f, -1.02511324e-01f, -3.01084090e-02f, -2.41815508e-03f,
  -3.34789716e-02f, 5.51641583e-02f, 2.86397785e-02f, -4.81545785e-03f, -3.24788317e-02f, 1.84905659e-02f, 7.19831437e-02f, -3.85672189e-02f, 3.13832574e-02f, 2.37605092e-03f,
  3.91279086e-02f, -2.52929945e-02f, 6.15702607e-02f, 3.80501896e-02f, -1.16766552e-02f, -2.57691629e-02f, -2.33855844e-03f, -7.41101727e-02f, -2.49214424e-03f, -9.29125845e-02f,
  -5.19273467e-02f, 9.54955295e-02f, 8.69369507e-03f, 1.39411632e-03f, -5.19080721e-02f, 2.06030514e-02f, 6.78300485e-02f, 8.63353312e-02f, -2.61496138e-02f, -7.78988451e-02f,
  -6.68418854e-02f, -1.14964917e-02f, 5.87081127e-02f, -9.34243500e-02f, -7.86491260e-02f, 3.01086139e-02f, 4.33940552e-02f, -1.47810439e-02f, 1.76468901e-02f, -2.59533692e-02f,
  3.35585047e-03f, -7.67862145e-03f, -1.23871975e-01f, 4.78299931e-02f, 5.94169870e-02f, 6.62099868e-02f, -1.10582002e-02f, 6.04090914e-02f, -3.68699580e-02f, -1.06736057e-01f,
  -2.03600042e-02f, -7.09178522e-02f, -1.50274923e-02f, -9.65906754e-02f, 3.67802382e-02f, 3.36716473e-02f, 5.94575591e-02f, -8.05217307e-03f, -1.51200630e-02f, 1.30347945e-02f,
  -1.72956720e-01f, 2.02110559e-01f, 9.41879079e-02f, -1.36612564e-01f, -3.38225961e-02f, 1.76885322e-01f, 1.20137155e-01f, -1.22190997e-01f, 6.95688203e-02f, 1.15848111e-03f,
  -1.80018082e-01f, 1.85726076e-01f, 1.49453402e-01f, -2.72086620e-01f, -7.92782158e-02f, 1.93184808e-01f, -1.71897821e-02f, -2.22677962e-04f, 1.00666836e-01f, -1.59032717e-01f,
  1.72525663e-02f, -3.77125502e-01f, -1.04333051e-01f, -1.31846055e-01f, -5.67582995e-02f, -3.51989781e-03f, -3.06792080e-01f, 9.14761946e-02f, -1.85347885e-01f, -8.67289230e-02f,
  -9.77392644e-02f, 8.21771845e-03f, -1.58301927e-02f, -1.77395791e-02f, 4.82309274e-02f, 4.26765084e-02f, 5.41929007e-02f, -3.27567831e-02f, -2.70749349e-02f, -1.62625059e-01f,
  1.33084089e-01f, 6.40499592e-03f, 3.98536250e-02f, 1.59824952e-01f, 9.23248902e-02f, 7.96341226e-02f, 4.23062705e-02f, 9.21406671e-02f, 6.68419600e-02f, 7.31845349e-02f,
  1.30451381e-01f, 3.63647006e-02f, 1.15752682e-01f, 1.62050754e-01f, 4.16770764e-02f, -4.38968316e-02f, 4.66249092e-03f, 8.23880062e-02f, -4.92866747e-02f, 6.84916601e-02f,
  -8.19246750e-03f, -2.03192066e-02f, -1.19534835e-01f, -2.11964846e-01f, -8.34552795e-02f, -1.24529511e-01f, 5.32451980e-02f, -7.71578262e-03f, 7.39536732e-02f, 2.65911911e-02f,
  -5.40075004e-02f, -2.66377032e-02f, 6.09772392e-02f, -5.80467470e-02f, -1.18223004e-01f, 2.62991171e-02f, -2.50819065e-02f, 1.00315604e-02f, -1.01792291e-02f, -8.37492719e-02f,
  9.83784720e-03f, -1.77930128e-02f, -6.43304810e-02f, -3.63225676e-02f, -1.92652903e-02f, -5.56644350e-02f, -6.13982119e-02f, 4.81575951e-02f, -1.37184095e-02f, 9.51112211e-02f,
  2.56090965e-02f, -1.32650770e-02f, 1.56784002e-02f, -5.19718230e-02f, -3.41590643e-02f, -4.95095700e-02f, 1.51816294e-01f, -8.20254758e-02f, -5.51255792e-02f, -7.96681643e-02f,
  7.21560419e-02f, 7.21374527e-02f, 3.56146768e-02f, 3.94852050e-02f, 7.54717439e-02f, -5.56307398e-02f, 1.98750161e-02f, -6.04938120e-02f, -3.09159998e-02f, -1.19840421e-01f,
  -1.90347344e-01f, -7.38479719e-02f, -4.12752442e-02f, -9.78807136e-02f, -3.38935815e-02f, 1.35656625e-01f, -7.29456618e-02f, 6.52174279e-02f, 3.56366597e-02f, 7.07497671e-02f,
  -3.93584818e-01f, -1.77100912e-01f, -1.50148660e-01f, -2.72814274e-01f, -1.16103977e-01f, 2.86726952e-02f, -4.13835002e-03f, -1.48857072e-01f, -2.00283095e-01f, 7.01560155e-02f,
  -9.55279991e-02f, -1.11218818e-01f, 2.43985638e-01f, -1.24121428e-01f, -7.44864403e-04f, 2.15869725e-01f, -2.11759776e-01f, -7.05823079e-02f, -2.14032587e-02f, -1.50442198e-01f,
  -4.96947095e-02f, -4.76044342e-02f, -1.73209272e-02f, 8.57504234e-02f, -1.24502636e-01f, -1.34216890e-01f, 6.78226352e-02f, 9.94316936e-02f, -8.65860470e-03f, -8.53104815e-02f,
  -1.20434076e-01f, -1.78972811e-01f, 4.86429110e-02f, 4.82563674e-02f, -6.31839558e-02f, -3.69288325e-02f, 3.86290476e-02f, 1.20671429e-01f, 5.63928895e-02f, -2.81300079e-02f,
  1.34456828e-02f, -2.84151938e-02f, -2.41191424e-02f, 1.08337164e-01f, 8.94601718e-02f, -3.29331793e-02f, -1.08008776e-02f, -2.53311098e-02f, 6.66779280e-02f, 4.07484062e-02f,
  -6.21291101e-02f, -4.77845483e-02f, 4.85621877e-02f, -5.31957112e-03f, 1.29861683e-02f, -3.40890745e-03f, 2.12769564e-02f, 3.20951417e-02f, -1.36251479e-01f, -3.68769541e-02f,
  2.23026089e-02f, 5.28644361e-02f, 2.67163664e-02f, -2.39073974e-03f, -8.06036592e-03f, -8.34394991e-02f, -9.07548517e-03f, -3.00080311e-02f, 7.38652330e-03f, -5.54939285e-02f,
  -3.28927413e-02f, -7.53775537e-02f, -7.07868636e-02f, 7.64376670e-02f, -1.94478314e-02f, -5.26910946e-02f, 5.82924187e-02f, -1.09460309e-01f, -4.52588275e-02f, -8.30981582e-02f,
  -9.00682807e-03f, 1.63610112e-02f, -3.98854390e-02f, -7.13988440e-03f, -8.41075182e-02f, 7.57782385e-02f, 4.91495579e-02f, -1.59621947e-02f, -3.08553725e-02f, 3.06629547e-04f,
  -4.02204916e-02f, -3.38089734e-01f, -2.07760818e-02f, -5.26012778e-02f, -4.86479849e-02f, -2.22996492e-02f, 5.13632633e-02f, -5.86478896e-02f, -2.73034610e-02f, -1.60982701e-04f,
  -2.81527992e-02f, 1.26944156e-02f, -5.77143431e-02f, 2.44897585e-02f, 1.83069967e-02f, -8.22596624e-02f, 6.16626581e-03f, -6.31333841e-03f, -5.79384193e-02f, -1.13023184e-01f,
  2.20352132e-03f, 2.68557109e-02f, 3.95841040e-02f, -5.83392195e-02f, 1.95333250e-02f, -9.18711815e-03f, -3.04157054e-03f, -3.31075266e-02f, 2.15786751e-02f, 2.69201049e-03f,
  -5.17960489e-01f, 2.08436742e-01f, -1.80375665e-01f, 1.08053759e-01f, -1.17028862e-01f, -5.71828559e-02f, 1.30475700e-01f, 8.86076912e-02f, -2.78405517e-01f, 1.81591541e-01f,
  6.38034120e-02f, -3.22126821e-02f, 1.83662288e-02f, 2.86111146e-01f, -3.30581591e-02f, -5.20842709e-03f, 1.45538330e-01f, 1.19587988e-01f, -1.64991878e-02f, 1.66917279e-01f,
  -1.09505691e-01f, 2.19597220e-01f, 6.32702466e-03f, 2.47153372e-01f, 5.58409169e-02f, 4.82026488e-02f, 1.12748004e-01f, 7.79781211e-03f, 8.57900307e-02f, 1.74259037e-01f,
  1.82734337e-02f, 1.85504090e-02f, 4.38028090e-02f, -1.95014831e-02f, 4.02284004e-02f, 1.20602865e-02f, -3.76073457e-02f, -6.92270696e-02f, -2.70345230e-02f, -1.53802941e-02f,
  3.72925848e-02f, -4.88929972e-02f, -2.62248125e-02f, -5.06568439e-02f, -4.78043258e-02f, -2.92851664e-02f, -3.91291156e-02f, -7.52667617e-03f, 2.41061840e-02f, 1.00296941e-02f,
  -2.92067248e-02f, -9.10197869e-02f, -1.40467575e-02f, -8.48234864e-04f, -8.73030573e-02f, -3.07232141e-02f, -8.58499669e-03f, -2.14236956e-02f, -1.02134198e-02f, -1.19255073e-01f,
  3.84858483e-03f, -6.96744770e-03f, 4.05073874e-02f, 7.51436651e-02f, 6.06436618e-02f, 2.50928178e-02f, -2.11078525e-02f, 3.23863551e-02f, -1.44789694e-02f, -3.15348692e-02f,
  2.27439273e-02f, 5.26240235e-03f, 5.10247387e-02f, -8.05548504e-02f, 6.44178092e-02f, -4.36442122e-02f, 3.30848545e-02f, 1.58950537e-02f, -4.83874343e-02f, -6.57405555e-02f,
  -4.42080051e-02f, 4.30648848e-02f, 3.70596796e-02f, -2.63012033e-02f, 3.88830714e-02f, 4.93042208e-02f, -2.42097583e-02f, 4.24458310e-02f, 4.94122840e-02f, 8.03258568e-02f,
  -3.98097485e-02f, 3.15696336e-02f, 7.61768371e-02f, 8.11488703e-02f, -4.20414098e-02f, -4.73270006e-02f, 3.23907100e-02f, 1.02567486e-01f, -1.54650155e-02f, 4.45580333e-02f,
  -4.71070483e-02f, -4.64989059e-02f, -2.03440860e-02f, 2.43044607e-02f, -5.33896983e-02f, 6.24885000e-02f, 7.71849826e-02f, -1.58607855e-03f, -3.40758413e-02f, -3.06840744e-02f,
  4.29208055e-02f, -7.12812096e-02f, 3.09658907e-02f, 2.27233563e-02f, 8.80495682e-02f, -8.54639560e-02f, -6.91131130e-02f, -3.57744209e-02f, -4.08950001e-02f, 2.20875768e-03f,
  -3.53159964e-01f, 3.57975140e-02f, -2.10987136e-01f, -1.98295251e-01f, -4.60000858e-02f, 2.31221169e-01f, 2.98446745e-01f, 3.11157741e-02f, 1.90849900e-01f, 3.39732051e-01f,
  1.41411275e-01f, 2.01269716e-01f, 3.03792447e-01f, 1.43093571e-01f, -1.14196919e-01f, 9.42465067e-02f, -3.46515775e-02f, 1.07861228e-01f, -3.46045569e-02f, -9.00831446e-02f,
  -1.86543107e-01f, 6.81206435e-02f, -1.27584532e-01f, -1.83806673e-01f, -2.02331156e-01f, -1.88332438e-01f, -1.32251814e-01f, -5.92574105e-02f, -1.45084932e-01f, -4.91878353e-02f,
  4.50998321e-02f, -1.17734391e-02f, -3.42702866e-02f, -4.76787277e-02f, 1.73317529e-02f, -5.99449463e-02f, 4.78527993e-02f, 1.48252603e-02f, 4.79105264e-02f, 6.95234016e-02f,
  2.41510794e-02f, -6.71017170e-02f, -2.97183543e-02f, -2.59925500e-02f, -5.64368218e-02f, 3.48127587e-03f, 1.69663802e-02f, 8.44619330e-03f, 1.25909984e-01f, -6.04349859e-02f,
  3.92561443e-02f, 7.36878533e-03f, -6.75897002e-02f, -1.25443876e-01f, -7.27583766e-02f, 7.31437281e-02f, 1.10838100e-01f, -4.39672843e-02f, -5.29884845e-02f, 5.99655546e-02f,
  -6.86006024e-02f, 5.35584539e-02f, 3.48805748e-02f, 3.47431609e-03f, -5.67003638e-02f, -3.34718525e-02f, -3.82801518e-04f, 9.95973498e-03f, -1.42909124e-01f, 5.38436212e-02f,
  -2.05232091e-02f, 8.08509719e-03f, -7.04579055e-02f, 5.99173270e-02f, 3.11783347e-02f, 9.17958617e-02f, 8.24089814e-03f, 2.26862561e-02f, -4.54260036e-02f, 4.69752662e-02f,
  3.32584977e-02f, -7.29079917e-02f, 1.46129699e-02f, -1.11393910e-02f, 1.35216311e-01f, -5.90212680e-02f, -7.00846035e-03f, -5.53039238e-02f, 1.44528109e-04f, -3.58185768e-02f,
  1.17244847e-01f, 3.87289301e-02f, 1.54690951e-01f, -5.04689943e-03f, -1.78696234e-02f, -8.62629712e-02f, -2.13565733e-02f, -5.78364246e-02f, -1.03498496e-01f, -1.73317157e-02f,
  -6.29085675e-02f, 2.46020239e-02f, -2.24991590e-02f, -5.56645133e-02f, 1.39694046e-02f, -5.03651500e-02f, 6.01898469e-02f, -1.15653276e-01f, -4.37818542e-02f, 5.24457060e-02f,
  -3.39989853e-03f, -3.07225082e-02f, 1.18463878e-02f, -4.75052893e-02f, 2.89980136e-02f, 6.29231557e-02f, -3.55354883e-02f, -1.83818806e-02f, -3.73451747e-02f, 2.35127695e-02f,
  1.18059814e-01f, 8.94487128e-02f, -7.78016001e-02f, 2.79767096e-01f, -2.43703499e-01f, 5.24911694e-02f, 2.31731117e-01f, -1.39354005e-01f, -1.08362466e-01f, 1.91378802e-01f,
  1.08796954e-02f, 2.57907039e-03f, 4.58788052e-02f, 2.67390043e-01f, 3.13990414e-01f, 1.34636253e-01f, 2.46578991e-01f, 1.20935850e-01f, -1.16868354e-01f, 2.35967245e-03f,
  -2.47479416e-02f, 2.98140258e-01f, 3.19748558e-02f, -6.54308572e-02f, -5.62152490e-02f, -5.94818965e-02f, 2.49447957e-01f, -2.14607000e-01f, 8.58437493e-02f, 1.07720070e-01f,
  -2.10625269e-02f, 1.74080312e-01f, -6.79486841e-02f, -3.84556837e-02f, -4.00509201e-02f, -1.15805343e-02f, 2.21186820e-02f, -1.96324904e-02f, -7.00799078e-02f, -3.75848450e-02f,
  3.53546301e-03f, -8.71960074e-02f, 3.54805402e-03f, -5.17127402e-02f, -2.84150671e-02f, -1.86123978e-02f, -2.30936129e-02f, -1.02160469e-01f, -4.33240198e-02f, -3.96632124e-03f,
  -4.95292768e-02f, -4.22547571e-02f, 3.61326449e-02f, 7.96065480e-02f, 7.98368547e-03f, 7.55618885e-02f, -1.88040417e-02f, 4.21086736e-02f, 3.22069526e-02f, 1.21192560e-01f,
  5.84460050e-02f, 7.27073639e-04f, -7.45303882e-03f, 1.36434948e-02f, 2.00752392e-02f, 5.94985411e-02f, 1.34932185e-02f, 6.16641948e-03f, -3.90480980e-02f, 1.59087200e-02f,
  2.90294122e-02f, 2.06135004e-03f, 6.01877132e-03f, 2.21950375e-02f, 2.39410326e-02f, 5.62092252e-02f, 8.85848552e-02f, -5.39876055e-03f, -8.97491053e-02f, -4.43941839e-02f,
  1.07822753e-01f, 1.89310673e-03f, -4.94155241e-03f, -2.38326583e-02f, -4.38651890e-02f, 1.46125276e-02f, -8.93069245e-03f, -9.18540135e-02f, -3.36553082e-02f, 2.57322993e-02f,
  3.89036760e-02f, 3.68943721e-01f, 2.12456863e-02f, 1.10216541e-02f, 1.25187319e-02f, -5.68212606e-02f, -1.04468521e-02f, -8.07270110e-02f, 1.26460209e-01f, 3.88205759e-02f,
  -2.65451465e-02f, -9.54020303e-03f, 4.54811379e-02f, 6.38658507e-03f, 9.05883219e-03f, 5.85379303e-02f, 1.58979356e-01f, 1.52773902e-01f, 9.80158076e-02f, -5.83327040e-02f,
  4.45431359e-02f, 9.71859917e-02f, -3.87648679e-02f, -6.48779944e-02f, 1.26932180e-02f, -1.23755364e-02f, -2.50307694e-02f, -2.49353647e-02f, 2.91395187e-02f, 1.66691723e-03f,
  4.48348559e-02f, 5.51176488e-01f, 2.18817785e-01f, -1.68223120e-02f, -3.49471807e-01f, -3.91477138e-01f, -1.89429849e-01f, -7.11875036e-02f, -2.94699132e-01f, 2.55768150e-01f,
  -1.39782295e-01f, 1.53768137e-01f, 1.91118076e-01f, 6.17706478e-02f, -1.24242164e-01f, -1.89013984e-02f, -1.14018194e-01f, -6.92431703e-02f, -2.34666839e-02f, 5.31523935e-02f,
  -8.81860480e-02f, -1.75968662e-01f, 7.63978139e-02f, 4.52705435e-02f, -4.17870991e-02f, 9.24837738e-02f, 7.69500583e-02f, 1.58403739e-01f, 1.01279601e-01f, -7.80403838e-02f,
  -9.95952636e-02f, 1.42279919e-02f, -1.80854425e-02f, 7.64569268e-02f, -1.14597566e-02f, -1.03239743e-02f, 2.21348554e-03f, -2.44818092e-03f, -5.77497147e-02f, -1.27295321e-02f,
  4.99485545e-02f, -7.94644430e-02f, -1.89433366e-01f, -1.23641863e-01f, 1.78087484e-02f, 3.17971036e-02f, -4.03407328e-02f, -2.55274251e-02f, 3.86416689e-02f, 1.47555783e-01f,
  2.65676733e-02f, 2.52866391e-02f, 1.88992042e-02f, 3.21504921e-02f, 3.54176834e-02f, -6.04119301e-02f, -4.07543220e-02f, -4.46098763e-03f, -6.61511123e-02f, -5.86240962e-02f,
  8.12320784e-02f, 1.60437375e-02f, 5.94066419e-02f, 3.16259898e-02f, 9.94892512e-03f, -1.27672881e-01f, 7.50363665e-03f, 1.07045295e-02f, -6.63250312e-02f, -1.08972127e-02f,
  -8.49894900e-03f, -2.44281068e-02f, -1.46768624e-02f, -1.02841519e-01f, 1.40462699e-03f, 5.74293034e-03f, 1.48451775e-02f, -6.60419390e-02f, 1.65738314e-02f, 1.08570300e-01f,
  -4.90739476e-03f, -8.60737115e-02f, 1.78238172e-02f, -1.80353764e-02f, 6.39946982e-02f, -8.19120854e-02f, -3.52131017e-02f, -2.88585797e-02f, 5.71073182e-02f, -1.24503961e-02f,
  1.10406131e-01f, 1.16241656e-01f, -2.28896439e-02f, -4.90372106e-02f, 2.48463452e-02f, -2.88237240e-02f, 2.00512502e-02f, -1.75497681e-03f, 1.19449973e-01f, -1.32641681e-02f,
  1.21921375e-02f, -4.09705676e-02f, 1.38057964e-02f, 3.56655791e-02f, -2.09683143e-02f, 1.91715769e-02f, 1.72997862e-02f, -3.46376859e-02f, -3.96279339e-03f, -1.61165949e-02f,
  7.83337653e-02f, 5.66451550e-02f, -8.87078885e-03f, -1.42144546e-01f, -2.16397792e-02f, -3.51292416e-02f, -1.37613658e-02f, -5.63757904e-02f, 3.98637122e-03f, -5.69921210e-02f,
  9.05529335e-02f, -1.77551195e-01f, 3.01983133e-02f, -6.94394484e-02f, -7.27515444e-02f, 3.86042953e-01f, 3.09417635e-01f, 8.74569081e-03f, -1.23481296e-01f, 1.90332860e-01f,
  6.38148114e-02f, -2.34558612e-01f, -1.87268201e-02f, 4.97132912e-02f, 3.60762663e-02f, -1.22087128e-01f, 3.46857876e-01f, 1.27352461e-01f, -1.59210682e-01f, -2.75610536e-02f,
  9.67728943e-02f, 4.67676185e-02f, 8.44379887e-02f, -1.37903094e-01f, 5.58914132e-02f, -1.17612831e-01f, 3.20967734e-02f, -1.95062861e-01f, 9.94626880e-02f, -1.10271581e-01f,
  5.04401838e-03f, -2.06894726e-01f, 3.68907340e-02f, -1.35524860e-02f, 1.26525104e-01f, 3.27246301e-02f, 5.96809797e-02f, -6.40741084e-03f, -4.98250686e-02f, -5.40395714e-02f,
  -9.09898132e-02f, -1.60370186e-01f, -7.22139254e-02f, -4.88403663e-02f, 6.00247085e-03f, 2.53309440e-02f, -4.58537554e-03f, 2.52553280e-02f, -1.46006048e-02f, 1.48330713e-02f,
  -7.12975487e-02f, -2.82454621e-02f, 6.12350591e-02f, -3.46298963e-02f, 2.00891793e-02f, -7.49143884e-02f, 3.65802720e-02f, -3.10655553e-02f, 2.33834051e-02f, -8.07795022e-03f,
  2.42539141e-02f, 5.54799661e-02f, 5.79680391e-02f, 1.19710669e-01f, 1.25827007e-02f, 6.20543137e-02f, 1.54839931e-02f, 5.81984781e-02f, 1.57074798e-02f, 6.79356679e-02f,
  7.28502274e-02f, 6.31111041e-02f, -6.50630519e-02f, 5.81092685e-02f, 1.20352447e-01f, -3.33322473e-02f, -2.63627954e-02f, -6.63298219e-02f, 1.62119120e-01f, 6.20273314e-02f,
  -5.20110168e-02f, -1.28165737e-01f, 1.52850524e-02f, 3.79370563e-02f, -3.75311775e-03f, -4.78547961e-02f, 1.90676209e-02f, 2.22164523e-02f, 1.68613017e-01f, -1.49380034e-02f,
  -7.12645873e-02f, -5.70501275e-02f, 2.47636214e-02f, -2.97405720e-02f, 2.44293120e-02f, -8.39725323e-03f, -5.22786342e-02f, 3.34560615e-03f, -4.19441164e-02f, -1.70424730e-02f,
  -1.24435797e-02f, -1.70077682e-02f, -8.81549064e-03f, 6.31597824e-03f, 1.23942224e-02f, 2.65872367e-02f, -1.90344639e-02f, -4.32599932e-02f, 5.00471629e-02f, 1.19992122e-01f,
  3.93998623e-02f, 4.29616496e-02f, 5.23387222e-03f, 6.25473335e-02f, 1.20466352e-01f, 2.69878265e-02f, 2.10721251e-02f, 4.24085781e-02f, -8.85846317e-02f, -1.09515235e-01f,
  2.99773395e-01f, -1.33872792e-01f, 1.03303276e-01f, 1.05903462e-01f, 9.23354551e-02f, 1.94028631e-01f, 1.35620669e-01f, 1.65313646e-01f, 1.37639657e-01f, -1.11530453e-01f,
  6.38055429e-02f, 4.58633974e-02f, -8.54567736e-02f, 3.73129686e-03f, 2.92990625e-01f, -2.14899480e-01f, 1.79368928e-01f, 5.11640869e-02f, -5.74960597e-02f, 6.97093904e-02f,
  4.70783189e-02f, -8.92596319e-02f, -7.21963644e-02f, -1.11354589e-01f, -7.98183531e-02f, -3.97395082e-02f, 4.33128364e-02f, -3.80446501e-02f, 8.29757676e-02f, -7.80407935e-02f,
  -5.37785999e-02f, -4.13465388e-02f, 1.44032180e-01f, 2.37721466e-02f, 1.98370680e-01f, 2.01453380e-02f, 1.85204484e-02f, -3.80933806e-02f, 6.77550305e-03f, 1.05593540e-01f,
  8.52804780e-02f, -1.12473434e-02f, 8.01898465e-02f, 1.54419869e-01f, 6.86576292e-02f, -7.18916126e-04f, -1.85647719e-02f, -1.26098888e-03f, -8.57067183e-02f, 4.76465151e-02f,
  4.54249457e-02f, 7.57866502e-02f, -2.79411506e-02f, -3.47951278e-02f, 7.01897740e-02f, 2.86515243e-02f, -3.57756242e-02f, 5.72091639e-02f, 2.54106731e-03f, 1.31654307e-01f,
  1.38089750e-02f, -1.08725362e-01f, -4.19579819e-02f, -5.07376827e-02f, -5.71247600e-02f, -3.47449146e-02f, -6.01684162e-03f, -4.64288816e-02f, -9.84486192e-02f, -5.92752993e-02f,
  -5.20376191e-02f, -5.20489886e-02f, 2.99478658e-02f, 4.24787030e-02f, -7.30624273e-02f, 7.34132305e-02f, 2.31252052e-02f, -6.52256608e-02f, -4.73527383e-04f, -3.38891149e-02f,
  -9.58894268e-02f, 3.58182788e-02f, -5.73159941e-02f, -4.64843679e-03f, -7.32617751e-02f, -2.30490300e-03f, -1.86839961e-02f, -4.14857492e-02f, -3.79433557e-02f, 8.37606117e-02f,
  -7.74769560e-02f, 1.44967036e-02f, -1.22171849e-01f, 7.13973269e-02f, -1.42759681e-02f, 5.68431765e-02f, 4.16947193e-02f, 1.80343520e-02f, 5.65518215e-02f, 6.13100156e-02f,
  2.13206798e-01f, -4.29342724e-02f, -3.54216285e-02f, 4.61041182e-02f, 4.48964611e-02f, -2.85406504e-02f, -9.77489278e-02f, 7.81567544e-02f, 1.18960343e-01f, -6.04407601e-02f,
  -6.50184304e-02f, -2.56644767e-02f, 1.61165427e-02f, -6.59845397e-02f, 3.89807262e-02f, -8.33567902e-02f, 2.54033934e-02f, -2.79046572e-03f, 1.06015868e-01f, 8.80121812e-02f,
  3.91481817e-01f, -4.01264489e-01f, 2.39558250e-01f, -3.20141912e-01f, 1.34259701e-01f, -9.55901518e-02f, 2.59016035e-03f, -1.72750711e-01f, -1.29840866e-01f, -3.00519526e-01f,
  -5.91201857e-02f, 3.94128030e-03f, -4.74230908e-02f, -2.93658882e-01f, 1.34327173e-01f, -1.25244886e-01f, -1.55839682e-01f, -9.94012505e-03f, -8.06583650e-03f, 3.65628395e-03f,
  3.79250497e-02f, -2.40726322e-01f, 1.07431114e-01f, -7.35652149e-02f, 8.75659212e-02f, 8.05272758e-02f, 3.33099603e-03f, 1.64796814e-01f, -2.74306145e-02f, 2.39368211e-02f,
  -6.16369769e-03f, 1.26150378e-03f, 1.18510872e-01f, 3.55688739e-03f, -2.91869193e-02f, -3.01648472e-02f, -1.22208549e-02f, 1.72052514e-02f, 1.04731590e-01f, -1.12581411e-02f,
  1.20144086e-02f, 1.38647938e-02f, -6.19697897e-03f, 9.54016969e-02f, -1.13740265e-02f, 6.28524506e-03f, 5.87971248e-02f, -2.74432003e-02f, -4.89576813e-03f, -1.81469508e-02f,
  -8.08817986e-03f, -4.88197766e-02f, 1.87590476e-02f, 4.55241427e-02f, 5.93709908e-02f, -3.34328860e-02f, -2.01438125e-02f, 3.13720703e-02f, -6.01719692e-02f, -3.79681736e-02f,
  2.54443679e-02f, 8.95743445e-02f, 1.46061676e-02f, -2.57395785e-02f, -2.59932666e-03f, 4.02658619e-02f, -1.82393342e-02f, -6.56103417e-02f, 1.22014303e-02f, -1.25399232e-01f,
  -3.66096124e-02f, -3.94978076e-02f, -1.30611565e-03f, -2.06970591e-02f, -8.75125080e-02f, -1.14298865e-01f, -3.63431945e-02f, 5.22386050e-03f, 4.53503476e-03f, -4.33300771e-02f,
  -1.46041755e-02f, 2.98412014e-02f, 3.05588897e-02f, -1.70745775e-02f, -6.47624061e-02f, -7.03537557e-03f, -7.70563260e-02f, 5.16035333e-02f, 1.66944806e-02f, 1.15180854e-02f,
  -1.23645715e-01f, -2.42463395e-01f, 1.73433870e-02f, -1.61375124e-02f, -7.51568973e-02f, 3.01835015e-02f, 6.57820085e-04f, -5.77747114e-02f, -1.03564225e-01f, -7.15828240e-02f,
  6.35921285e-02f, 6.00105710e-02f, 2.78897714e-02f, 2.95828911e-03f, -1.00528412e-02f, -7.26626441e-02f, -5.52939735e-02f, -1.56745873e-02f, 9.16367117e-03f, -8.73557031e-02f,
  -7.52275670e-03f, 1.98699702e-02f, 1.19149446e-01f, 4.12656516e-02f, 6.20852709e-02f, 1.03280051e-02f, 6.05915450e-02f, -2.50816047e-02f, 1.03699611e-02f, -5.53310569e-03f,
  5.09757161e-01f, -3.35090637e-01f, -1.24096960e-01f, 8.24166834e-02f, 3.20755631e-01f, 1.07869692e-01f, 1.97844043e-01f, -9.24188346e-02f, -8.05616081e-02f, -7.47853890e-02f,
  8.19088966e-02f, 8.61938223e-02f, 6.15828484e-03f, -1.11002871e-03f, 3.15436721e-01f, -3.18666160e-01f, 7.55925253e-02f, 1.19838333e-02f, -6.91670403e-02f, 1.57678798e-01f,
  8.45627952e-03f, 1.87722370e-01f, -9.50152650e-02f, 2.82015800e-02f, 1.74773544e-01f, -4.01492752e-02f, 7.60383308e-02f, 7.17036352e-02f, -3.36753950e-02f, 8.41479823e-02f,
  7.76614994e-03f, -4.95811924e-02f, -1.15075372e-02f, -6.48686662e-02f, -3.88305016e-05f, -2.48991717e-02f, 2.74418090e-02f, 4.48299982e-02f, 2.36176606e-03f, -6.72959611e-02f,
  -7.67032476e-03f, 3.41275781e-02f, -3.19226794e-02f, 3.73953842e-02f, 7.84793273e-02f, -7.12102419e-03f, -3.85057479e-02f, 3.19349766e-02f, -2.97362823e-02f, 1.59650389e-02f,
  -7.14771226e-02f, -8.29122588e-02f, 5.83749497e-03f, -2.65080724e-02f, 4.66088727e-02f, -4.24213894e-02f, -6.23368844e-02f, 3.49848010e-02f, -9.53758508e-03f, 3.17150839e-02f,
  3.47928405e-02f, -5.60957864e-02f, -2.73361802e-03f, -2.05104686e-02f, -3.51233929e-02f, -3.40492390e-02f, -1.12362094e-02f, -6.17862083e-02f, 1.74192023e-02f, -7.80328289e-02f,
  -3.49658430e-02f, -9.09933168e-03f, -1.76892001e-02f, -4.67584841e-02f, 2.13475861e-02f, -1.82430129e-02f, -2.60609612e-02f, -5.94710149e-02f, -2.90647764e-02f, -4.99849468e-02f,
  -4.35756333e-02f, 1.72747131e-02f, -2.33802795e-02f, -6.70711026e-02f, -1.32572651e-03f, 4.97519299e-02f, -8.52930825e-03f, -3.84507254e-02f, -1.53263947e-02f, -2.02936004e-03f,
  2.30643842e-02f, -7.67281577e-02f, -3.54640521e-02f, 3.20101902e-02f, -1.40001997e-01f, -6.76130760e-04f, 2.30479371e-02f, 9.76874959e-03f, 6.62741903e-03f, 8.58208351e-03f,
  7.86422119e-02f, -7.75090307e-02f, 3.84479724e-02f, 3.56663987e-02f, -2.04991978e-02f, -1.33485217e-02f, -2.56773327e-02f, -3.59727517e-02f, -4.13616560e-02f, -6.35743216e-02f,
  9.06449556e-02f, 3.58397141e-02f, -1.16645321e-02f, -3.77618782e-02f, 3.84405926e-02f, 9.28249490e-03f, 1.11120746e-01f, 4.53028865e-02f, -7.94365630e-03f, -6.73146173e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.08620539e-01f, 5.46486266e-02f, -3.30916911e-01f, 2.44198993e-01f, -1.19355768e-01f, -2.20700018e-02f, -1.98897392e-01f, 6.40235096e-02f, -2.36287355e-01f, 1.88984707e-01f,
  2.54183441e-01f, -2.22739601e-03f, -5.56852669e-02f, 5.07527173e-01f, 1.76183820e-01f, -7.52536431e-02f, 1.18461773e-01f, 1.58019394e-01f, -3.38440128e-02f, 7.67852142e-02f,
  1.91361651e-01f, 4.15315449e-01f, 3.36758755e-02f, 1.79520115e-01f, 2.03957006e-01f, 9.75490957e-02f, 1.77858949e-01f, -1.85845673e-01f, 3.18401545e-01f, 8.02437067e-02f,
  7.62811955e-03f, -2.63990462e-02f, -4.34231237e-02f, -4.37835120e-02f, -2.39514504e-02f, 6.12402754e-03f, -3.78919020e-02f, -7.22698420e-02f, -5.74684925e-02f, -5.51162362e-02f,
  -3.36353071e-02f, 3.36795710e-02f, 1.59344599e-01f, 3.13262343e-02f, 2.74021942e-02f, -5.02640717e-02f, 4.93029617e-02f, -3.46739255e-02f, -2.93063726e-02f, -4.28142771e-02f,
  -1.45673722e-01f, 4.07638215e-02f, 4.47367169e-02f, 1.53785571e-02f, -4.00236547e-02f, 2.55192034e-02f, -6.15992174e-02f, -4.71956581e-02f, -5.43486215e-02f, -9.21380986e-03f,
  -8.74042958e-02f, 1.30276177e-02f, -2.41403505e-02f, 7.39483237e-02f, -5.36266640e-02f, -3.04025579e-02f, 5.29111996e-02f, 1.62906840e-03f, -8.72685835e-02f, 5.14076054e-02f,
  4.68421765e-02f, -4.75227572e-02f, -3.40799475e-03f, -1.31124482e-02f, 4.58012242e-03f, -4.66199256e-02f, 5.28869107e-02f, -1.98892895e-02f, -7.75696933e-02f, -4.74526605e-05f,
  -4.56182845e-02f, -6.64223060e-02f, 1.86316334e-02f, -2.35910639e-02f, 1.02967694e-01f, -8.20495933e-02f, 5.76853454e-02f, -2.82975342e-02f, -3.03370203e-03f, -5.80297299e-02f,
  1.17427751e-01f, -2.67607737e-02f, -2.47404259e-02f, 4.57537100e-02f, -6.75252751e-02f, -5.84488688e-03f, 2.48840470e-02f, 4.13171276e-02f, -3.96514088e-02f, -6.99918568e-02f,
  -5.09106778e-02f, 8.54282349e-04f, 1.58242639e-02f, 2.63745356e-02f, 7.11122677e-02f, -8.35851729e-02f, 3.15547585e-02f, 9.81305540e-03f, 6.99929819e-02f, 7.53461719e-02f,
  -4.06999327e-02f, -1.83465388e-02f, -4.56976406e-02f, -9.36773717e-02f, 9.12847742e-02f, -6.82588527e-03f, -1.96277276e-02f, -8.34247991e-02f, 4.59360443e-02f, -1.59266852e-02f,
  3.01303595e-01f, 2.07594812e-01f, 3.66996765e-01f, 5.45225799e-01f, -3.10396012e-02f, -3.68810266e-01f, -1.72830656e-01f, 1.87173918e-01f, 9.73659158e-02f, 1.14260279e-01f,
  -1.47051752e-01f, 3.59824032e-01f, -2.33662084e-01f, 1.89223155e-01f, -2.71278918e-01f, -1.27490774e-01f, 2.80050859e-02f, 8.89081210e-02f, 9.89700556e-02f, 2.32710794e-01f,
  9.63546410e-02f, -1.59262344e-01f, 1.43771559e-01f, -1.25699177e-01f, 8.40946808e-02f, 3.10345352e-01f, 2.21510455e-02f, -9.34887752e-02f, 2.06559196e-01f, -2.63040394e-01f,
  -3.01303230e-02f, 1.02028728e-01f, 1.85007989e-01f, -7.28553813e-03f, 8.25822502e-02f, 3.11765950e-02f, -2.37477925e-02f, -1.10740766e-01f, 2.60761455e-02f, -1.55423610e-02f,
  -1.40053942e-03f, -9.35912207e-02f, -4.95407693e-02f, -9.55833048e-02f, -5.44101782e-02f, 3.09892632e-02f, 6.49038628e-02f, 1.30131438e-01f, 1.00935502e-02f, 3.40531990e-02f,
  4.74213697e-02f, 4.37451787e-02f, 4.60492596e-02f, 4.18272391e-02f, 8.32775384e-02f, 6.56311810e-02f, -8.19770843e-02f, 1.06641799e-01f, 7.39676431e-02f, 2.94284150e-02f,
  -3.01356316e-02f, -3.43915410e-02f, -3.04448958e-02f, 2.02730577e-02f, -8.49639475e-02f, 1.73265580e-02f, -1.21979803e-01f, 7.98929133e-04f, -1.44224912e-01f, -6.98462501e-02f,
  -2.04282645e-02f, 1.17553314e-02f, -1.00590199e-01f, -3.03075574e-02f, 6.92571849e-02f, 5.10021336e-02f, 1.19550657e-02f, -6.66895360e-02f, 4.48172428e-02f, 4.30135205e-02f,
  1.15756551e-02f, -2.64849588e-02f, -2.93386187e-02f, 2.56138039e-03f, -1.12714596e-01f, 8.46519396e-02f, 7.65781477e-02f, 2.66231373e-02f, -5.71118435e-03f, -6.79705059e-03f,
  -4.69366349e-02f, 7.13396147e-02f, 6.66920766e-02f, -1.85263809e-02f, -1.09397266e-02f, -1.42633943e-02f, 1.71089116e-02f, 9.58990306e-02f, -2.76083928e-02f, -1.04592487e-01f,
  4.81440052e-02f, 6.11843402e-03f, -5.35159409e-02f, 3.37067246e-02f, -3.81002575e-02f, -7.20517710e-03f, 1.21905580e-02f, -2.62819976e-02f, -4.70623560e-03f, 4.76729088e-02f,
  5.24100550e-02f, -1.23441964e-01f, -2.95940451e-02f, 7.39714652e-02f, -4.08041663e-02f, 1.62050463e-02f, 1.06473630e-02f, 1.00624897e-02f, -9.61956456e-02f, -3.97226810e-02f,
  9.27130282e-02f, -2.10272044e-01f, -5.93165569e-02f, 2.00204268e-01f, -8.99496302e-02f, -2.94541061e-01f, -2.11056396e-01f, 1.63513750e-01f, -1.23306699e-01f, -1.01100147e-01f,
  -3.84539887e-02f, -9.82520804e-02f, -3.25574428e-01f, -2.53626406e-02f, 7.99652562e-02f, -3.24368596e-01f, 1.87457412e-01f, -6.96953386e-02f, -7.03591183e-02f, -6.10729009e-02f,
  1.44052386e-01f, 1.09805182e-01f, 1.63447514e-01f, 3.80410761e-01f, 8.17442834e-02f, 3.15843493e-01f, 2.77283400e-01f, 7.70438462e-02f, 2.75101513e-01f, 1.00231014e-01f,
  -6.69144839e-02f, -1.33739740e-01f, 5.59130311e-02f, -3.71883251e-02f, 8.46199393e-02f, 1.73714627e-02f, 1.28555223e-02f, 4.72130068e-02f, 4.95967530e-02f, -6.01743646e-02f,
  -6.67557418e-02f, 1.14597259e-02f, -6.65128604e-03f, -8.77257623e-03f, 1.06400430e-01f, 1.79316953e-01f, -2.88628917e-02f, -3.22694518e-02f, -2.09317282e-02f, -6.46643862e-02f,
  -1.42179832e-01f, -3.24211791e-02f, -1.27468379e-02f, 5.25949150e-02f, 1.80348158e-02f, 2.99504492e-02f, -3.36686298e-02f, -2.15679649e-02f, -2.33347341e-03f, 4.74915989e-02f,
  7.35564753e-02f, -1.57653168e-02f, 2.86736637e-02f, 6.56631589e-02f, 8.65455642e-02f, 1.25837149e-02f, 6.23245798e-02f, -1.47890104e-02f, -1.56515598e-04f, 5.53283952e-02f,
  1.42794207e-01f, 8.47597644e-02f, 2.38937978e-02f, -1.71493720e-02f, -7.21475631e-02f, -8.07015821e-02f, 3.84623231e-03f, 1.50949284e-02f, 2.64607482e-02f, -7.08631892e-03f,
  -4.87530716e-02f, 3.76373343e-02f, -6.99993921e-04f, 4.12894115e-02f, -5.76499403e-02f, -2.53957044e-02f, 1.65012255e-02f, -2.30207071e-02f, 3.29058804e-02f, -1.45080099e-02f,
  -9.78965405e-03f, -9.50639918e-02f, 2.60893069e-02f, 6.10841904e-03f, -1.23871816e-02f, -7.56829306e-02f, 6.19214680e-03f, -1.62472147e-02f, 9.86807644e-02f, 2.66776830e-02f,
  9.02867168e-02f, 1.10392891e-01f, -7.87555650e-02f, 1.27078310e-01f, 6.78238273e-02f, -4.54516709e-02f, -3.43217538e-03f, 1.02087863e-01f, 1.22635908e-01f, -1.12063468e-01f,
  -3.96967083e-02f, -7.86177740e-02f, 2.36554649e-02f, -4.79562320e-02f, -3.66449840e-02f, 6.51900936e-03f, 1.74913406e-02f, 4.19347407e-03f, -2.47952938e-02f, 3.95701006e-02f,
  -1.82616070e-01f, -1.76698640e-02f, -1.24133669e-01f, -2.62536913e-01f, 1.69851761e-02f, -5.59726581e-02f, -2.27792263e-01f, -1.13063138e-02f, -4.10110727e-02f, 2.34860852e-01f,
  -1.36008691e-02f, -6.46770373e-02f, -5.51019944e-02f, -2.84168541e-01f, -2.95894206e-01f, -2.59587497e-01f, -3.18233669e-01f, -4.05538119e-02f, -1.20995648e-01f, -1.21997394e-01f,
  -1.22357428e-01f, -2.43265793e-01f, -2.70797014e-01f, 3.88053805e-02f, -5.00615202e-02f, 1.02927499e-01f, 2.14097917e-01f, 1.36059290e-02f, -4.17621620e-02f, -7.55845085e-02f,
  2.56081019e-02f, -3.36876251e-02f, 6.34798482e-02f, -4.26135249e-02f, -7.24706938e-03f, 2.84225475e-02f, 2.23659165e-02f, 6.18020371e-02f, 6.52290061e-02f, 2.00820770e-02f,
  9.47572850e-03f, 1.25352750e-02f, -8.66805315e-02f, 2.42711306e-02f, -1.26512527e-01f, 1.35784969e-02f, 4.45014015e-02f, 9.23917592e-02f, 7.94902537e-03f, -1.32258788e-01f,
  -1.07611355e-03f, 6.22806959e-02f, -1.17747337e-02f, 1.50037592e-03f, -8.62139687e-02f, 9.33395326e-03f, -9.22110379e-02f, 2.10223701e-02f, 5.26254065e-02f, 7.66842216e-02f,
  -5.59446476e-02f, 1.24939308e-02f, 7.73592442e-02f, 1.11246640e-02f, 6.80223899e-03f, 1.90172046e-02f, -3.83037445e-03f, 4.16379794e-02f, 1.92479752e-02f, 1.81571152e-02f,
  6.92277774e-02f, 6.79513393e-03f, -2.94665974e-02f, 2.02490482e-02f, -9.66716483e-02f, 2.88797822e-03f, -5.42623550e-02f, -2.68490110e-02f, 4.83048568e-03f, 2.14985386e-02f,
  2.44620703e-02f, -9.06320140e-02f, -8.55193660e-02f, -2.08597891e-02f, 9.53394920e-03f, -3.56584564e-02f, 1.53768975e-02f, 2.18425244e-02f, -4.60115932e-02f, -8.92532542e-02f,
  -1.04994707e-01f, 4.56659384e-02f, 2.32121684e-02f, -7.61377141e-02f, 6.67285128e-03f, 5.89727126e-02f, -3.65701988e-02f, -1.13578446e-01f, 1.99451894e-02f, 2.67274287e-02f,
  6.93836436e-02f, -2.87194643e-02f, 1.32391945e-01f, -7.66127780e-02f, -1.34410448e-02f, 1.15419827e-01f, 7.07595646e-02f, 3.46180312e-02f, 1.08057395e-01f, 1.36973429e-02f,
  7.41783455e-02f, 1.55583145e-02f, -5.60482778e-02f, -3.87873687e-02f, 1.14748850e-01f, -2.65058652e-02f, 1.39552578e-01f, 4.40661460e-02f, 1.06019829e-03f, -6.04861882e-03f,
  3.11551709e-02f, -2.68511415e-01f, -2.31219321e-01f, -1.37541682e-01f, -1.54728726e-01f, -4.30836171e-01f, -2.84902573e-01f, -2.60230154e-01f, 3.10045294e-02f, 5.52653112e-02f,
  -4.96393256e-02f, -9.38492045e-02f, 2.01375887e-01f, -2.24933550e-01f, 2.04055697e-01f, 1.79665431e-01f, -2.06773028e-01f, -4.51862328e-02f, -2.40297560e-02f, -1.84646621e-01f,
  1.86042872e-03f, -1.95182666e-01f, -1.39917195e-01f, -1.56516612e-01f, -3.01301956e-01f, -4.65551279e-02f, 1.57499999e-01f, -1.26584619e-01f, -1.20715462e-01f, -3.76075804e-02f,
  -2.92158443e-02f, 1.15448937e-01f, 3.01847849e-02f, 5.31347729e-02f, -1.32561382e-02f, -1.17804352e-02f, -8.65978524e-02f, -6.18199632e-02f, 7.40575269e-02f, -8.48810673e-02f,
  -5.92779852e-02f, -1.96344912e-01f, -9.96579081e-02f, 1.17779672e-01f, 3.32263224e-02f, 3.65102589e-02f, -5.78106828e-02f, -2.17662775e-04f, -8.79740790e-02f, 1.55918207e-02f,
  -4.96341400e-02f, 5.67834713e-02f, -6.31278679e-02f, 1.29079312e-01f, -1.14884369e-01f, 1.52779203e-02f, -6.24321178e-02f, 1.14867702e-01f, -1.52764440e-01f, -1.68686900e-02f,
  4.60334234e-02f, -8.93021375e-02f, -4.26854827e-02f, -3.89935523e-02f, 6.39185905e-02f, -3.31122801e-02f, 1.37111926e-02f, 7.40892962e-02f, -4.84863520e-02f, -9.17522684e-02f,
  -8.00681021e-03f, -4.42704335e-02f, 4.96884845e-02f, -4.90206294e-02f, -1.13302641e-01f, 2.30102614e-02f, 1.91494115e-02f, -2.50972807e-02f, -4.61178683e-02f, -2.60436293e-02f,
  1.04532510e-01f, -7.24369735e-02f, -8.46804529e-02f, 2.33699065e-02f, 5.15142232e-02f, 1.87315583e-01f, -1.04750618e-02f, 1.06886938e-01f, -1.36097828e-02f, -6.79427907e-02f,
  -4.30524498e-02f, -6.75810948e-02f, 9.72538721e-03f, -4.19542268e-02f, 9.30375159e-02f, 2.26145685e-02f, -1.24084176e-02f, -1.58717096e-01f, -8.43084790e-03f, -7.63440132e-02f,
  -5.78025244e-02f, 1.15407463e-02f, 3.32809724e-02f, 1.09053716e-01f, 2.17194762e-02f, -1.17478400e-01f, 8.61556735e-03f, 6.78332569e-03f, -5.11005372e-02f, 3.21329944e-02f,
  -8.92947540e-02f, 2.60091014e-02f, 5.90125211e-02f, -4.53434922e-02f, -1.09914765e-01f, -6.23186789e-02f, -3.04637756e-02f, 9.25503150e-02f, -6.70788363e-02f, -6.66307956e-02f,
  -4.02842849e-01f, 1.79516345e-01f, -2.03934923e-01f, 8.11256617e-02f, -8.85217264e-02f, 2.62199521e-01f, 4.13323760e-01f, -8.46801847e-02f, 1.09893188e-01f, 3.47531676e-01f,
  3.12928557e-01f, 1.99013650e-02f, 1.83922797e-01f, 2.35915512e-01f, -6.30374700e-02f, 2.02913254e-01f, 6.97050989e-03f, 5.80965951e-02f, -2.43610889e-02f, 1.22413328e-02f,
  -2.06024960e-01f, 2.54986703e-01f, -2.07127612e-02f, -7.06359670e-02f, 9.82400998e-02f, -5.58920857e-03f, 1.71087578e-01f, 9.25909914e-03f, 1.73996076e-01f, 1.13329746e-01f,
  1.67742558e-02f, -1.65897354e-01f, -2.89863553e-02f, 1.57273766e-02f, -1.63240489e-02f, -5.22905774e-03f, 6.43313862e-03f, -3.36553110e-03f, 2.56929360e-02f, 6.62172735e-02f,
  -1.05242513e-03f, -6.05303980e-02f, 9.65331048e-02f, 1.26597703e-01f, -3.70608531e-02f, -2.84282006e-02f, -4.36242633e-02f, 3.47112119e-02f, -9.61583331e-02f, -5.79906302e-03f,
  -7.82366656e-03f, 3.12865302e-02f, -4.40619029e-02f, 5.93399666e-02f, -5.45601659e-02f, 1.23286098e-01f, 6.04348145e-02f, 1.06945951e-02f, -3.36247161e-02f, -4.53597456e-02f,
  1.87291875e-01f, -7.22385123e-02f, 2.25988477e-02f, 7.55880354e-03f, -7.91549608e-02f, 2.33737491e-02f, 3.76890823e-02f, -1.01952456e-01f, -6.46123588e-02f, -1.11761414e-01f,
  -4.99341190e-02f, -3.35706435e-02f, -3.65193598e-02f, -6.80713588e-03f, -2.66369376e-02f, 6.71779141e-02f, 7.45249614e-02f, -2.29443833e-02f, 2.23935936e-02f, 6.99445745e-03f,
  9.91336852e-02f, 3.84024642e-02f, -4.49592294e-03f, 2.29330882e-02f, -9.36634000e-03f, 2.38860883e-02f, 4.62058559e-02f, -2.49587242e-02f, -1.99418068e-02f, 5.18617313e-03f,
  2.72928596e-01f, -6.97007850e-02f, 7.28650689e-02f, -8.79263785e-03f, -7.94936344e-02f, 4.06775512e-02f, 2.63540796e-03f, -2.26689596e-02f, -3.43345404e-02f, -1.96389528e-03f,
  6.99100420e-02f, 4.37089689e-02f, -8.42443556e-02f, 4.54400368e-02f, -2.84861960e-02f, 1.07008934e-01f, 2.54961941e-03f, 2.95534674e-02f, 1.23734970e-03f, -1.38624767e-02f,
  4.30522574e-04f, -6.59769401e-02f, 8.16852599e-02f, -2.44838577e-02f, 1.00768893e-03f, 1.84637848e-02f, -8.54618996e-02f, 2.85435580e-02f, -2.29211077e-02f, 9.33728591e-02f,
  1.92740057e-02f, 2.67963290e-01f, -1.77129600e-02f, -1.88689992e-01f, -1.12460360e-01f, -2.52918571e-01f, -3.50257844e-01f, -2.46106014e-02f, 5.99547513e-02f, 3.29437689e-03f,
  -2.65402377e-01f, 4.11363810e-01f, -9.63987038e-02f, -1.07291609e-01f, -3.07609051e-01f, -9.21420380e-02f, -1.88248411e-01f, -1.36048019e-01f, -3.88517082e-02f, -2.41655886e-01f,
  -6.95731044e-02f, -4.68675554e-01f, -4.78624515e-02f, 1.10460492e-02f, -1.65741012e-01f, 3.05065829e-02f, -3.50526534e-02f, -1.72541797e-01f, 3.40841487e-02f, 6.73637539e-02f,
  3.81930405e-03f, -3.27990986e-02f, 1.03578642e-01f, 4.08867784e-02f, -1.27893239e-01f, 3.73730995e-02f, -1.58927254e-02f, -2.65769977e-02f, 2.58511845e-02f, 4.00739163e-03f,
  1.45952642e-01f, 9.48553085e-02f, 2.78972052e-02f, 7.53987161e-03f, -5.19617423e-02f, 7.26159513e-02f, 1.21879749e-01f, 1.18381910e-01f, -1.83921563e-03f, -3.95264626e-02f,
  1.48768291e-01f, 6.60123676e-02f, 1.95287932e-02f, -2.55833194e-02f, 4.47303466e-02f, -1.87667422e-02f, 5.16618304e-02f, 5.72914863e-03f, 1.09360389e-01f, 1.81770474e-01f,
  -7.07656890e-02f, -1.43867150e-01f, -8.67320970e-02f, 1.06029309e-01f, -1.24652376e-02f, 9.98440310e-02f, 1.73968915e-02f, 1.00259185e-02f, 2.85767112e-02f, -8.81527141e-02f,
  -3.83701315e-03f, 7.84194004e-03f, -3.45936529e-02f, -5.32098822e-02f, -6.15986846e-02f, 4.55505252e-02f, -5.54830208e-02f, 2.69417465e-02f, -1.97580140e-02f, 2.75688502e-03f,
  3.98619696e-02f, -2.63109747e-02f, 7.20770732e-02f, 1.41993463e-01f, -7.07476959e-02f, -5.01619205e-02f, 4.29364620e-03f, 7.26335272e-02f, 2.56897714e-02f, -1.22990966e-01f,
  -1.71986222e-01f, -2.52707213e-01f, -4.23097163e-02f, -4.63669971e-02f, 9.51736495e-02f, -5.06991893e-02f, -5.19231427e-03f, 1.23015173e-01f, -1.11762650e-01f, 6.65130047e-03f,
  -1.92195282e-03f, -2.56317761e-02f, 7.31229782e-02f, 6.28104946e-03f, 8.20935611e-03f, -4.24426533e-02f, -1.02119200e-01f, -2.53693033e-02f, -4.39877715e-03f, -9.25949067e-02f,
  3.92641425e-02f, -1.07328534e-01f, 1.98486224e-02f, -6.08586408e-02f, 2.00231504e-02f, -5.51081598e-02f, 6.17867634e-02f, 6.81659207e-02f, -1.58953834e-02f, -1.01988707e-02f,
  -4.07716513e-01f, -1.02719501e-01f, -2.86176980e-01f, -2.85747945e-01f, 4.25613374e-02f, -6.37680516e-02f, -1.96987376e-01f, 1.20421812e-01f, -1.60000250e-01f, 3.00683558e-01f,
  2.42073685e-01f, -2.39952937e-01f, 7.00929165e-02f, -3.39459598e-01f, -6.28713310e-01f, -2.57814109e-01f, -3.03353339e-01f, -1.40652712e-02f, -9.07460377e-02f, 3.05697545e-02f,
  -2.62791276e-01f, -2.72584651e-02f, -2.98890352e-01f, 3.20388347e-01f, -3.79901603e-02f, 1.70783445e-01f, 3.53817850e-01f, 1.61504939e-01f, 1.21608175e-01f, -5.07497787e-02f,
  -5.74979559e-02f, 1.24267731e-02f, 4.72503267e-02f, -3.06660458e-02f, 4.44362499e-02f, 5.38519323e-02f, -1.11121219e-03f, 9.99454409e-02f, 6.81329519e-03f, -7.68161565e-02f,
  -5.80155440e-02f, 1.23440986e-02f, -1.01337299e-01f, 7.49392956e-02f, 3.84032447e-03f, -5.11219203e-02f, -1.26118481e-01f, -2.52450220e-02f, 1.28676575e-02f, -6.88379332e-02f,
  -2.29578719e-01f, -3.84085365e-02f, 4.63974886e-02f, -1.00778546e-02f, -5.63361384e-02f, 5.87218255e-02f, -5.31848781e-02f, 1.08883634e-01f, 6.51211757e-03f, -8.08412582e-02f,
  -1.68636106e-02f, -1.18292766e-02f, -6.40644580e-02f, -1.49559639e-02f, 3.57107930e-02f, 9.66822729e-02f, -7.25819590e-03f, -2.56255269e-02f, -9.16738361e-02f, 9.61647108e-02f,
  1.36354342e-02f, -5.09492978e-02f, -8.62442888e-03f, -1.16544021e-02f, 1.77131500e-02f, 7.82205015e-02f, -9.26689617e-03f, 7.35955015e-02f, -9.06635448e-02f, 4.29725386e-02f,
  6.82679862e-02f, -7.35482574e-02f, 2.59665656e-03f, -1.37819825e-02f, 8.97149146e-02f, -2.06810813e-02f, -4.76789400e-02f, -4.24157716e-02f, 1.25433162e-01f, 8.20444152e-02f,
  4.90189940e-02f, 1.74312562e-01f, -4.23964150e-02f, 6.58597499e-02f, 2.90183332e-02f, 4.78890017e-02f, -1.15850553e-01f, -1.23275094e-01f, -1.19370464e-02f, -3.07966061e-02f,
  5.38200103e-02f, 2.57716607e-02f, -3.04296589e-03f, -4.66269031e-02f, 5.44978911e-03f, 3.71527039e-02f, 1.27104716e-02f, 1.44886702e-01f, -6.74165413e-02f, 1.33128881e-01f,
  5.60561866e-02f, 7.51804560e-02f, 2.15627234e-02f, 5.00994809e-02f, 3.09317000e-02f, 1.27478734e-01f, 6.30829530e-03f, -1.15280949e-01f, 6.72149565e-03f, -4.19126544e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  -1.16905592e-01f, 1.74010824e-02f, -8.19986612e-02f, 1.24132849e-01f, -2.07366064e-01f, -8.35051108e-03f, 3.87107879e-02f, -1.05191983e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.61860868e-01f, 1.34941012e-01f, 1.19897656e-01f, -1.93705231e-01f, -1.87315270e-02f, -7.31627718e-02f, -1.57807410e-01f, 2.74422299e-02f, -1.64427757e-01f, -6.27705082e-02f,
  6.42849803e-02f, 4.14015613e-02f, 1.49788097e-01f, 2.73059636e-01f, 1.60014667e-02f, 1.38694018e-01f, 2.28865921e-01f, 2.99364310e-02f, 1.07311327e-02f, 2.63650775e-01f,
  -7.13445097e-02f, -9.11306664e-02f, -1.51027888e-01f, -4.22315031e-01f, -1.20317750e-02f, 1.45218506e-01f, -1.18009999e-01f, -8.45990032e-02f, -1.68165386e-01f, 8.61962959e-02f,
  2.02678200e-02f, 4.37407866e-02f, 8.22114572e-02f, 2.30005980e-01f, -9.96110886e-02f, 6.20595165e-05f, -5.76832741e-02f, 2.61364222e-01f, 1.58305243e-01f, 8.52315798e-02f,
  2.78904349e-01f, 8.01060162e-03f, 9.90737006e-02f, -2.33727042e-02f, 9.60442349e-02f, -2.63960272e-01f, 1.32778451e-01f, 1.65327057e-01f, -2.66505688e-01f, -5.77124916e-02f,
  -2.29596093e-01f, 5.40091880e-02f, 1.75720602e-01f, 7.49934688e-02f, 2.11599082e-01f, 2.05016762e-01f, -2.69692630e-01f, -1.08076092e-02f, -5.83381467e-02f, -2.86445692e-02f,
  -6.11590594e-02f, -1.63557440e-01f, -1.75381433e-02f, -6.07125498e-02f, -1.10742144e-01f, -3.16243097e-02f, 1.58356532e-01f, 1.02162838e-01f, 1.87715992e-01f, 2.78926879e-01f,
  -9.19183269e-02f, -6.80978447e-02f, 2.07246616e-01f, -7.28739649e-02f, 1.71112165e-01f, 3.11806845e-03f, 2.66818628e-02f, -5.41870892e-02f, 1.29732445e-01f, 8.90583768e-02f,
  -9.69404578e-02f, -2.60377657e-02f, -1.93945706e-01f, -1.37529392e-02f, -8.75659361e-02f, -2.57362099e-03f, -9.35462192e-02f, -4.50247638e-02f, -4.08445597e-01f, 1.46948293e-01f,
  -1.51228875e-01f, 1.70611173e-01f, -1.52443245e-01f, -7.17255324e-02f, 1.30425796e-01f, 3.52708369e-01f, -8.91525000e-02f, 2.13735580e-01f, 1.63016111e-01f, 1.37697754e-03f,
  4.22905385e-02f, 9.60059389e-02f, -9.68697816e-02f, -2.90812731e-01f, -2.44957030e-01f, -2.75706351e-01f, 1.04720481e-01f, -3.08870338e-02f, 1.14381865e-01f, 8.78641978e-02f,
  -1.13067657e-01f, -5.73859289e-02f, 2.39953279e-01f, -5.55722900e-02f, -1.84166759e-01f, 6.32869378e-02f, -1.01955183e-01f, -1.79378629e-01f, 6.48849308e-02f, 8.49660859e-02f,
  -2.71997273e-01f, 3.70720029e-02f, -1.94860622e-01f, 1.91249087e-01f, -5.17339110e-02f, -1.80684522e-01f, 9.90101993e-02f, 4.37189132e-01f, 3.85982879e-02f, 2.34855577e-01f,
  -8.17325804e-03f, 1.31549716e-01f, -6.61804825e-02f, 1.11596197e-01f, 1.77245289e-01f, -2.23104239e-01f, 2.34816119e-01f, 1.59193337e-01f, 1.14767447e-01f, 2.08892673e-01f,
  -1.92667451e-02f, 1.53161779e-01f, -2.84149468e-01f, -4.32355165e-01f, -9.06444490e-02f, -6.19160905e-02f, -5.21704294e-02f, 1.77589580e-01f, 1.89051688e-01f, 1.40724391e-01f,
  8.66844580e-02f, 1.47089869e-01f, 1.38388813e-01f, 3.57416362e-01f, 2.42380008e-01f, -3.31808031e-02f, -3.44510376e-01f, -2.75559932e-01f, 3.94368246e-02f, -1.05976686e-01f,
  -6.59325793e-02f, -2.28093073e-01f, -2.14893550e-01f, -1.38454422e-01f, -1.12284698e-01f, -3.78885865e-01f, -1.27557740e-01f, -3.07600051e-02f, -2.08872646e-01f, -6.12008981e-02f,
  -2.12422401e-01f, -3.28274935e-01f, -3.15799624e-01f, 1.19186640e-01f, -2.51111805e-01f, -1.79069549e-01f, 3.93274486e-01f, 1.32414758e-01f, 4.65430707e-01f, 2.24712998e-01f,
  -2.14292169e-01f, 6.57538921e-02f, -3.55949253e-01f, -1.08431932e-02f, 4.01381463e-01f, -7.05409423e-02f, 1.94001049e-01f, -1.74994126e-01f, -1.38439059e-01f, 1.64491817e-01f,
  -5.28982520e-01f, 1.64788030e-02f, -4.77824599e-01f, -1.11761600e-01f, -1.41662732e-01f, 1.51282862e-01f, -1.41532898e-01f, 4.67975996e-03f, 7.89256990e-02f, -2.40893722e-01f,
  -8.38875324e-02f, -1.86009005e-01f, -2.59800982e-02f, -2.07581222e-01f, -2.50073850e-01f, -3.99876088e-01f, -2.95133412e-01f, -8.42623711e-02f, -3.30575585e-01f, -1.25283703e-01f,
  -1.53270781e-01f, -2.62999564e-01f, 2.73612082e-01f, 4.85867448e-02f, 5.41271091e-01f, 6.57956243e-01f, -7.99848065e-02f, -2.83816606e-01f, 1.92140162e-01f, 1.28852382e-01f,
  5.96624874e-02f, 2.93784272e-02f, -4.75185275e-01f, 1.90920636e-01f, 3.31419744e-02f, -2.86297292e-01f, 1.06584333e-01f, -5.36483191e-02f, -1.29839107e-01f, -1.01922490e-02f,
  -1.21029750e-01f, 2.22430259e-01f, -2.34009311e-01f, -1.03512429e-01f, -2.15771288e-01f, -2.66798493e-02f, -2.58031398e-01f, -2.26601765e-01f, 1.13546401e-01f, 3.47702682e-01f,
  2.05725253e-01f, 1.16175897e-01f, 1.25498265e-01f, 8.37149173e-02f, -1.79467976e-01f, -2.15506747e-01f, -5.44599220e-02f, -1.51620850e-01f, 6.33692518e-02f, -3.63363296e-01f,
  -4.24728632e-01f, 6.95245340e-02f, 4.11139667e-01f, 3.90974700e-01f, -5.42693771e-02f, -5.34335896e-02f, -1.50650039e-01f, 1.34629771e-01f, 1.58424154e-02f, -3.08619082e-01f,
  -3.64163786e-01f, -1.16441116e-01f, 2.54153013e-01f, -1.72923759e-01f, 2.02845223e-02f, -3.81211750e-02f, 2.52429903e-01f, 2.61636198e-01f, 1.67904973e-01f, 8.32690746e-02f,
  -1.93240240e-01f, -2.18655825e-01f, -8.82527679e-02f, -1.30608380e-01f, -5.65839671e-02f, 8.52885246e-02f, -2.21315339e-01f, -3.95217724e-02f, 1.39374182e-01f, -1.88785255e-01f,
  -9.61249173e-02f, 4.48182821e-01f, 1.43061459e-01f, -8.25300291e-02f, 2.97093511e-01f, -3.53827983e-01f, 9.69884545e-02f, 4.21990454e-02f, 1.72808338e-02f, -2.17904240e-01f,
  1.41004905e-01f, -4.74015363e-02f, 1.67652488e-01f, 1.49684563e-01f, -1.24996752e-01f, 1.80712715e-01f, -1.74991071e-01f, 1.55887038e-01f, -1.86376974e-01f, 3.69855831e-03f,
  1.11456439e-01f, -1.87779844e-01f, -8.63757282e-02f, 5.19529991e-02f, 1.31781191e-01f, 3.07803578e-03f, -1.36738673e-01f, 1.47093669e-01f, 4.90357503e-02f, -1.89494476e-01f,
  -2.30730642e-02f, -9.44100395e-02f, -6.34547174e-02f, -1.23254716e-01f, -3.31189126e-01f, 5.35302870e-02f, -5.49742654e-02f, 2.20116526e-01f, 1.57501996e-01f, 1.52915642e-01f,
  2.59573072e-01f, 2.52409637e-01f, -1.01384357e-01f, -1.04390644e-02f, 2.37537688e-03f, 3.18265259e-02f, -1.55796319e-01f, -2.68267453e-01f, 2.11890325e-01f, 9.94478911e-02f,
  1.61086187e-01f, -1.30000897e-02f, 2.64031906e-02f, 1.25074267e-01f, 7.06250872e-03f, -5.44424951e-01f, -1.17221847e-01f, -1.59261361e-01f, 1.77930053e-02f, 2.06097305e-01f,
  3.13164778e-02f, 3.25587779e-01f, -1.57261968e-01f, 2.59560257e-01f, 1.42447233e-01f, 1.94259256e-01f, 2.34051734e-01f, -1.38678491e-01f, -1.22074708e-01f, -1.84348114e-02f,
  -4.21321727e-02f, -4.68686730e-01f, 1.18934639e-01f, 2.58796781e-01f, -1.33310348e-01f, -8.82427469e-02f, -1.95802644e-01f, -1.13600023e-01f, -1.36720613e-01f, -1.26357481e-01f,
  1.92005381e-01f, 5.52214086e-02f, 1.09670557e-01f, 1.23262145e-02f, 2.63849765e-01f, 6.20986661e-03f, -5.61977662e-02f, -1.63846567e-01f, -4.45929505e-02f, -1.44510925e-01f,
  -3.33698392e-01f, 1.39098391e-01f, 3.46428230e-02f, 1.67527527e-01f, 3.43755186e-01f, 1.98836893e-01f, -4.83875722e-02f, 2.06916094e-01f, 2.99367383e-02f, -1.02334201e-01f,
  3.10501531e-02f, -2.82486081e-01f, 6.71698749e-02f, -4.22146678e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.71076670e-01f, 1.43527344e-01f, 1.22202843e-01f, -1.27260312e-01f, -5.69539964e-02f, 3.83402973e-01f, 4.97962988e-04f, 2.40925789e-01f, -4.10146229e-02f, -3.03721912e-02f,
  1.24570131e-02f, 2.97023892e-01f, 2.55925864e-01f, 1.47397378e-02f, -1.49452552e-01f, 3.24903101e-01f, 1.01146862e-01f, -2.89303124e-01f, -2.01844558e-01f, 1.01051278e-01f,
  -1.71395198e-01f, -1.59981340e-01f, 1.04194790e-01f, -1.45085707e-01f, -1.88271046e-01f, 1.45065039e-01f, -1.74953997e-01f, 2.44430900e-01f, 1.74029365e-01f, -1.83987424e-01f,
  4.09368932e-01f, 2.88007885e-01f, 1.31449342e-01f, 9.31482390e-02f, 1.64176837e-01f, -1.48320654e-02f, 3.40384185e-01f, 1.93394676e-01f, 1.56012699e-01f, 2.18470171e-01f,
  1.66557938e-01f, 1.33136837e-02f, -6.24273680e-02f, 2.12652773e-01f, 9.78145674e-02f, 4.32733782e-02f, 1.86408669e-01f, 1.10215284e-01f, -6.24986663e-02f, -1.60368040e-01f,
  -2.04805329e-01f, -1.02674372e-01f, 4.54019234e-02f, -1.10301428e-01f, -1.46078944e-01f, -5.66374660e-02f, -4.68767375e-01f, -1.86193228e-01f, 9.76856947e-02f, 2.37131447e-01f,
  -3.32175106e-01f, -9.02695805e-02f, -1.88992381e-01f, 6.54919207e-01f, 1.23072997e-01f, 2.74081320e-01f, 2.66282529e-01f, -5.24335317e-02f, -3.29793423e-01f, 2.57382929e-01f,
  3.08490433e-02f, -1.79365941e-03f, -6.67065978e-02f, 1.91162959e-01f, 3.00074071e-01f, 3.31525683e-01f, 2.84195483e-01f, 1.32725528e-02f, -3.22744921e-02f, -1.26817092e-01f,
  -3.46930325e-02f, -1.38411179e-01f, -2.69346625e-01f, 2.67378479e-01f, -6.14113659e-02f, -1.39984518e-01f, 2.76504457e-01f, -2.76078526e-02f, -1.73400015e-01f, 5.60800195e-01f,
  -1.28595620e-01f, 2.49420434e-01f, 3.41420501e-01f, -3.75984721e-02f, 3.60950351e-01f, -1.73122007e-02f, 7.17591196e-02f, 1.83171079e-01f, -7.08352998e-02f, 6.47311509e-02f,
  2.55405810e-02f, 8.30598846e-02f, -9.48923528e-02f, 1.76073328e-01f, 3.77716050e-02f, 6.82221875e-02f, 3.74951512e-02f, 2.81689167e-01f, 2.79037118e-01f, 1.51797906e-01f,
  5.83053678e-02f, 2.12531120e-01f, 1.47798002e-01f, 3.64821590e-02f, 3.78936045e-02f, -2.80161966e-02f, -5.56237809e-02f, -9.02825892e-02f, 1.50687508e-02f, -3.51293892e-01f,
  -7.93127641e-02f, 5.25800884e-02f, -8.20875838e-02f, 2.83774137e-01f, 1.26988515e-01f, -2.46111816e-03f, 2.80797094e-01f, 3.02078903e-01f, -2.36160792e-02f, 1.83130562e-01f,
  8.25199112e-02f, 2.58063644e-01f, -1.26785934e-01f, 3.68502885e-01f, 2.71557838e-01f, -5.17616421e-03f, 3.30986768e-01f, 3.56486857e-01f, 9.71288085e-02f, 2.28701547e-01f,
  -1.80361137e-01f, -4.22770053e-01f, -2.71933317e-01f, -2.32406221e-02f, -1.01874903e-01f, -2.67040461e-01f, 1.16993882e-01f, 2.62285154e-02f, 3.69694501e-01f, -1.22855948e-02f,
  4.80544060e-01f, 5.60902238e-01f, -7.53902048e-02f, 6.19402081e-02f, 2.11682886e-01f, 9.64301303e-02f, 3.33296746e-01f, -1.30799681e-01f, -1.50921643e-01f, 2.30599523e-01f,
  1.19596506e-02f, -9.51684937e-02f, -1.74262319e-02f, -6.43258616e-02f, -6.30170330e-02f, -1.22881249e-01f, 1.67971671e-01f, -1.23187996e-01f, -1.02036923e-01f, 1.87402044e-03f,
  1.09188274e-01f, 1.03352413e-01f, -1.24621108e-01f, 1.85744271e-01f, 5.56691252e-02f, 2.56639600e-01f, -1.16735268e-02f, -1.28660873e-02f, 1.65896952e-01f, -4.29664291e-02f,
  1.68037936e-01f, 4.02462073e-02f, -1.26630485e-01f, -4.20851976e-01f, 3.81498062e-03f, -3.10144294e-02f, -1.61449730e-01f, -2.21403018e-01f, -5.15813418e-02f, 1.93626389e-01f,
  -1.69540301e-01f, -1.27944127e-01f, 1.76567619e-03f, 3.88782769e-01f, -4.79046740e-02f, 2.60326475e-01f, 3.59256864e-01f, 3.01308602e-01f, 3.32083404e-01f, -6.07044138e-02f,
  2.61333019e-01f, 2.63684988e-01f, 1.34870350e-01f, 7.85659242e-04f, 1.80204585e-01f, 8.70123059e-02f, 9.68084484e-02f, -2.14331046e-01f, -4.90640014e-01f, -1.89013064e-01f,
  -1.83359429e-01f, -4.08556908e-01f, 4.55812603e-01f, 3.09427857e-01f, 2.19276905e-01f, 2.08089218e-01f, -3.69535863e-01f, 3.42317373e-01f, 5.24409004e-02f, 8.26276690e-02f,
  -2.61818349e-01f, 5.67967258e-02f, -1.27074297e-03f, 2.50289273e-02f, 5.33604994e-02f, 3.02337885e-01f, 1.04965255e-01f, 2.86747515e-01f, 3.46169829e-01f, 9.93526056e-02f,
  2.24477425e-01f, 3.53222489e-02f, 2.59399027e-01f, 1.51686326e-01f, 6.88365176e-02f, -1.99847683e-01f, -4.51307036e-02f, -1.29995570e-01f, 6.95767924e-02f, -4.41726327e-01f,
  -2.00733677e-01f, 8.91882926e-02f, 4.52299565e-02f, -4.44167942e-01f, 3.00990373e-01f, 2.61590779e-01f, 2.64618080e-02f, 3.67286384e-01f, 2.27542341e-01f, 6.37300983e-02f,
  4.85945255e-01f, 8.69170204e-02f, -1.23225138e-01f, -1.65388342e-02f, 1.49903055e-02f, 1.12432867e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  -4.61288616e-02f, 2.07939401e-01f, 1.52669132e-01f, 1.10943414e-01f, 9.37911123e-03f, -1.80642441e-01f, 1.25823840e-01f, 3.52780789e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  4.13273647e-02f, 1.96115971e-01f, 1.00836933e-01f, 1.47105798e-01f, 1.24833316e-01f, -1.46193132e-01f, 1.59690678e-01f, 3.99183512e-01f, -4.28592339e-02f, 1.88516259e-01f,
  1.38313755e-01f, 2.08108008e-01f, 7.20675895e-03f, -3.43732417e-01f, -1.83605641e-01f, -1.81426957e-01f, -1.37741059e-01f, 3.62754822e-01f, -3.59421164e-01f, 1.91123292e-01f,
  -1.06602013e-01f, 8.94378722e-02f, 1.15818493e-01f, -1.18295439e-01f, -8.16580579e-02f, -1.78592965e-01f, 7.18927830e-02f, 5.01838699e-02f, 5.04674613e-02f, -1.09162569e-01f,
  -3.32834184e-01f, -4.74863723e-02f, 5.78808375e-02f, -8.13587904e-02f, 1.74245179e-01f, 1.79237783e-01f, 7.12609366e-02f, 1.39095411e-01f, -8.70023891e-02f, 4.55152132e-02f,
  2.48414591e-01f, 9.53001156e-03f, 1.82724297e-01f, -1.00564502e-01f, -3.18128988e-02f, -1.18927352e-01f, -1.34297684e-01f, -3.16030830e-01f, -7.02130347e-02f, 1.19037695e-01f,
  1.64640754e-01f, 2.20633090e-01f, -3.17380190e-01f, -5.89950718e-02f, 1.01365767e-01f, -1.30345896e-01f, -3.56716484e-01f, -1.20278411e-01f, -1.27103135e-01f, -8.89373273e-02f,
  -2.23313645e-01f, 5.26138321e-02f, 2.52035260e-01f, 2.08129108e-01f, 1.50733426e-01f, 1.60734341e-01f, 5.98467439e-02f, 1.21613845e-01f, -1.27895132e-01f, 1.19747594e-01f,
  5.85409626e-03f, 1.91314500e-02f, 8.19276944e-02f, -2.00467780e-01f, -1.67137116e-01f, 1.25021124e-02f, 3.81621160e-02f, -2.91379452e-01f, -3.93681556e-01f, -3.10943544e-01f,
  -8.23987201e-02f, 3.57356727e-01f, -4.38551635e-01f, 1.25176653e-01f, 3.50821810e-03f, -1.33721575e-01f, 3.86804760e-01f, -1.17032431e-01f, -1.64196894e-01f, 1.21453544e-02f,
  -1.23200044e-01f, -5.01074046e-02f, -1.30863294e-01f, -5.87314032e-02f, -2.82597214e-01f, 8.93971696e-02f, 9.38138738e-03f, -1.02395162e-01f, -1.91442832e-01f, -1.31347835e-01f,
  -1.52974352e-01f, 3.72246578e-02f, -6.44570887e-02f, 2.13991076e-01f, 1.41231135e-01f, -1.96297184e-01f, -4.56454232e-02f, 7.37747252e-02f, 1.44909127e-02f, 1.26998648e-01f,
  3.20211083e-01f, 4.54404920e-01f, 1.93761349e-01f, -3.89024824e-01f, -2.06595987e-01f, -1.73267856e-01f, 1.51950493e-01f, 9.57480296e-02f, -3.31903249e-02f, -1.66190818e-01f,
  2.54283130e-01f, 2.02489242e-01f, 1.74192972e-02f, 1.92182437e-01f, -1.12029150e-01f, -5.14101759e-02f, 2.31827125e-01f, 2.27810182e-02f, -1.40507206e-01f, -1.04394950e-01f,
  -8.51243883e-02f, 1.57020271e-01f, -3.75273675e-01f, -2.64359295e-01f, 3.20582502e-02f, -4.18399066e-01f, -2.80137569e-01f, -1.61176726e-01f, -4.64014485e-02f, 1.90360785e-01f,
  -2.64434159e-01f, -8.29182267e-02f, -2.76840836e-01f, -3.57810371e-02f, 2.47769237e-01f, 4.13037777e-01f, 3.06414008e-01f, -2.44375393e-01f, 3.33822995e-01f, -1.89270794e-01f,
  4.24335241e-01f, 4.28704321e-01f, -1.14443094e-01f, -4.38909650e-01f, 1.84445009e-01f, -2.80290954e-02f, -8.10596421e-02f, -2.21799359e-01f, -7.80509561e-02f, 1.79423038e-02f,
  1.29463226e-01f, 2.29744744e-02f, 4.52663749e-02f, 1.75509840e-01f, 2.74065107e-01f, -5.77914342e-02f, -1.98258143e-02f, 4.54886824e-01f, 6.92495927e-02f, 1.16824739e-01f,
  3.02025348e-01f, 2.91241795e-01f, -3.07547152e-02f, 1.72620118e-01f, 7.52245411e-02f, -2.23697498e-01f, -2.06539840e-01f, 6.76724091e-02f, 1.83709085e-01f, 9.33937822e-03f,
  -3.37819546e-01f, 9.87411290e-02f, 2.49495283e-01f, -7.64195621e-02f, -2.70744592e-01f, 3.50321010e-02f, -2.56989539e-01f, -2.47654617e-02f, -2.45620281e-01f, -3.43401581e-01f,
  -1.29048660e-01f, 1.29725590e-01f, -8.29545334e-02f, -9.48145241e-02f, -1.12088293e-01f, -9.97025371e-02f, 6.35223910e-02f, -3.18819731e-02f, 1.13755010e-01f, -8.27216059e-02f,
  -9.66241509e-02f, 1.05397545e-01f, 1.41738892e-01f, -4.87989187e-02f, -1.72489822e-01f, 4.73622754e-02f, 1.47277117e-01f, 1.54739037e-01f, 2.79244073e-02f, -1.81645676e-01f,
  4.59303975e-01f, -1.24814617e-03f, 3.10965218e-02f, 8.95985141e-02f, -3.36391360e-01f, -9.03639272e-02f, 1.88107803e-01f, -4.39811721e-02f, 1.16131656e-01f, 1.64428987e-02f,
  3.09185714e-01f, -3.97218689e-02f, 1.18465737e-01f, 4.97527756e-02f, -1.00369751e-01f, -8.11498016e-02f, 2.65220314e-01f, 2.13375345e-01f, -1.54329896e-01f, -3.40518445e-01f,
  -5.80387786e-02f, -3.98605876e-03f, -3.53027314e-01f, 1.54797718e-01f, -8.37627612e-03f, -9.73246172e-02f, 5.36288917e-02f, -1.21983260e-01f, -2.96625972e-01f, -1.60086006e-01f,
  -1.93148553e-01f, 3.55489820e-01f, -3.67764235e-01f, 1.96490839e-01f, 9.05206949e-02f, 2.07548618e-01f, 1.94337919e-01f, 1.67052388e-01f, 2.79271416e-02f, -2.72501349e-01f,
  7.59533271e-02f, 3.19564454e-02f, -7.29964226e-02f, 1.12348519e-01f, -1.72199070e-01f, -2.89993286e-01f, -1.60437062e-01f, -1.35038659e-01f, -3.06706931e-02f, 8.88249427e-02f,
  1.67785063e-01f, -4.05620337e-02f, -8.56459290e-02f, 3.56772654e-02f, 2.34489664e-02f, -1.78062141e-01f, -6.47014678e-02f, 2.85865843e-01f, -3.03057075e-01f, 3.04000139e-01f,
  -7.45505386e-04f, -3.10076952e-01f, -2.92592764e-01f, -2.20321491e-01f, 4.62359875e-01f, 8.53187218e-02f, -3.05564492e-03f, 2.31152903e-02f, 2.20072716e-01f, 3.92956495e-01f,
  -1.22762300e-01f, -3.11095536e-01f, -1.75887212e-01f, -2.33701870e-01f, -9.66482386e-02f, -2.14137822e-01f, 2.04849601e-01f, -4.75277826e-02f, -1.42270401e-02f, -1.52755246e-01f,
  1.13135897e-01f, 8.78985673e-02f, 1.48082832e-02f, -2.58550555e-01f, 5.67465648e-02f, -1.16221607e-01f, -2.54488617e-01f, 1.57447755e-01f, 2.18323037e-01f, -8.22414383e-02f,
  -2.72788078e-01f, 4.46687400e-01f, 7.29267001e-02f, -2.82436721e-02f, 6.54857978e-02f, -3.17392945e-01f, 5.31997323e-01f, 1.55782327e-01f, 5.42451907e-03f, 4.94760908e-02f,
  -2.82886356e-01f, 2.18160197e-01f, 2.20806867e-01f, -1.57099828e-01f, 1.02369137e-01f, -9.01499018e-02f, 8.86791348e-02f, -1.14443757e-01f, 9.56654996e-02f, -2.12974250e-01f,
  -3.25818248e-02f, -1.08742394e-01f, -5.70885390e-02f, -1.93255648e-01f, -1.90822646e-01f, -7.70562515e-02f, -1.34357214e-02f, -1.55449256e-01f, -1.76073700e-01f, 1.24974810e-02f,
  -2.09573358e-01f, -2.65645921e-01f, -1.06450543e-01f, -1.49227483e-02f, 9.16174240e-03f, 2.03105122e-01f, -1.28856406e-01f, -1.05191223e-01f, 1.30292336e-02f, 1.73196509e-01f,
  1.44940987e-01f, -7.08167776e-02f, -2.56682336e-01f, 2.39024386e-02f, 2.26267412e-01f, -1.35841489e-01f, 2.11715057e-01f, 8.35955814e-02f, 2.12442830e-01f, 9.93675217e-02f,
  -2.11667255e-01f, -1.94707528e-01f, 2.88627129e-02f, -2.02268660e-01f, 9.88778844e-02f, -1.48231853e-02f, -3.05169940e-01f, -1.49326369e-01f, 9.00475979e-02f, -2.69710422e-01f,
  -2.69942015e-01f, 1.15112578e-02f, -2.10419446e-01f, 4.11013626e-02f, 2.46581919e-02f, -1.02394946e-01f, -3.14323813e-01f, 1.46455993e-03f, 1.92569137e-01f, 4.22229707e-01f,
  2.84336060e-01f, 1.10426754e-01f, 2.27941334e-01f, -1.64442696e-02f, -1.33197019e-02f, 9.62469578e-02f, -2.03710590e-02f, -2.63996899e-01f, 1.87141716e-01f, -1.78490952e-01f,
  1.54954240e-01f, -2.75283694e-01f, -1.52703956e-01f, 1.40804723e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.90618509e-01f, 8.74604881e-02f, 1.95677355e-01f, 4.12843376e-01f, 1.98597848e-01f, -2.04691872e-01f, 2.22138092e-02f, 7.31771514e-02f, 2.29474455e-01f, 7.64195025e-02f,
  4.29622203e-01f, 3.33315462e-01f, -2.04266325e-01f, 1.74437210e-01f, 2.64126450e-01f, -8.22774768e-02f, 3.94990593e-01f, -1.25162303e-01f, 1.45392686e-01f, -2.16103375e-01f,
  -1.36309579e-01f, -9.67045352e-02f, 1.72036469e-01f, 2.14010835e-01f, -5.15760891e-02f, 1.63037792e-01f, 2.48323068e-01f, -5.89812063e-02f, 2.68604547e-01f, -2.31231153e-01f,
  5.28336942e-01f, 2.30956674e-01f, -1.07006028e-01f, 1.26985326e-01f, -5.33873588e-02f, 1.37460396e-01f, 4.12234455e-01f, 3.09845917e-02f, 3.46952409e-01f, 3.78118366e-01f,
  1.06662728e-01f, 2.07006484e-01f, 4.25502598e-01f, 4.01519924e-01f, -4.34718668e-01f, 5.46924055e-01f, 2.20084086e-01f, -2.43429109e-01f, 2.78017342e-01f, -4.56269294e-01f,
  5.94072580e-01f, -1.30751684e-01f, -3.39780211e-01f, -8.16141441e-02f, -2.05773279e-01f, -2.27078333e-01f, -8.38523284e-02f, 4.14737612e-01f, -8.71370733e-02f, 1.15446173e-01f,
  6.22356534e-01f, -2.04444975e-01f, 3.78309757e-01f, 5.28761446e-01f, 3.45383316e-01f, 1.78026363e-01f, 4.71192300e-01f, 1.49957165e-01f, 3.40998113e-01f, -1.26372516e-01f,
  -1.92962196e-02f, 2.81278014e-01f, 6.43421933e-02f, 4.14131969e-01f, -8.70936587e-02f, 1.12391621e-01f, -6.03348613e-02f, -5.39658368e-02f, 1.06968313e-01f, -2.55821407e-01f,
  -3.23526174e-01f, 1.24926204e-02f, -4.87377554e-01f, 3.60839903e-01f, -2.17221640e-02f, 1.75660029e-01f, -1.27981544e-01f, 1.83544904e-02f, 5.04310548e-01f, -2.58529256e-03f,
  5.16018510e-01f, 3.89338464e-01f, 1.69964746e-01f, 3.41103584e-01f, -2.92780157e-02f, -4.92999442e-02f, 1.31127194e-01f, 6.52927086e-02f, -9.38492566e-02f, -4.36126022e-03f,
  2.54174292e-01f, -1.92564115e-01f, -1.05599642e-01f, 1.54236391e-01f, 3.30574006e-01f, 3.54312547e-02f, 8.13353434e-02f, -7.18574449e-02f, 2.37471893e-01f, 3.20857495e-01f,
  6.01320446e-01f, 4.76441652e-01f, 9.59607288e-02f, -6.58635557e-01f, -1.15258686e-01f, -2.72223562e-01f, -7.30642602e-02f, 1.27582505e-01f, -2.46788859e-01f, -2.09305100e-02f,
  5.98547101e-01f, 5.64770639e-01f, 1.74959287e-01f, 4.66846943e-01f, -2.72393078e-02f, 2.08380483e-02f, 2.69652039e-01f, 1.18921824e-01f, 1.68185815e-01f, -4.73660268e-02f,
  1.26971394e-01f, 4.92083048e-03f, -6.51832700e-01f, 1.39473975e-02f, -2.61413574e-01f, -6.11740351e-01f, -7.49881417e-02f, -3.92690897e-01f, -2.03768089e-02f, 2.63729662e-01f,
  -4.63474588e-03f, -1.73013926e-01f, -1.91578995e-02f, -5.59843797e-03f, 4.02158767e-01f, 1.37042433e-01f, -2.43714213e-01f, -6.98188424e-01f, 2.79465586e-01f, -4.89409089e-01f,
  4.82310623e-01f, 4.31613922e-01f, -1.23753190e-01f, -3.13300788e-02f, 1.63028061e-01f, -1.17050923e-01f, 2.31147688e-02f, 1.27405375e-01f, 1.87603056e-01f, 1.97367296e-01f,
  1.58880308e-01f, 1.77319258e-01f, 9.62238833e-02f, -6.77530468e-02f, -3.98861856e-04f, 3.28819513e-01f, 1.50669739e-01f, -2.25794017e-01f, 3.67099456e-02f, -9.15177241e-02f,
  1.48374200e-01f, 2.25020155e-01f, -1.97531179e-01f, -9.99898762e-02f, -3.69873106e-01f, -3.68895501e-01f, 1.83854148e-01f, 2.75518239e-01f, 1.05467588e-01f, -1.75204560e-01f,
  1.73166260e-01f, -2.78686315e-01f, 4.10848558e-01f, -1.97039787e-02f, -2.82101303e-01f, 1.03487514e-01f, -1.74417064e-01f, -6.60630390e-02f, 3.77824083e-02f, -1.56350378e-02f,
  1.55258194e-01f, 3.02868307e-01f, 3.37010831e-01f, 1.30908072e-01f, 2.38623023e-01f, 3.48813325e-01f, -1.79864138e-01f, -2.10677728e-01f, -4.63414639e-02f, -2.40760282e-01f,
  2.11441368e-01f, 1.56533852e-01f, 1.75509468e-01f, 1.09844767e-01f, 4.30388413e-02f, 1.89445645e-01f, 2.62779564e-01f, 1.86359614e-01f, 3.48488241e-01f, 4.99523841e-02f,
  -3.82010490e-01f, -5.45938015e-01f, 2.54575223e-01f, -2.93504357e-01f, 4.04834062e-01f, 3.49364400e-01f, 1.05364166e-01f, 1.13408165e-02f, 3.54358286e-01f, 1.88737631e-01f,
  2.57427990e-02f, -3.06883566e-02f, 3.61612767e-01f, 2.18965322e-01f, 1.83384374e-01f, 9.02004540e-02f, 3.59743983e-01f, 2.13239059e-01f, 1.20577440e-01f, 3.57590258e-01f,
  4.07087237e-01f, 2.39666179e-02f, -5.60412370e-03f, 1.32871345e-01f, 2.33644873e-01f, 1.78612724e-01f, -4.25466001e-01f, 4.04912658e-04f, -4.18794066e-01f, -6.33149505e-01f,
  2.74316013e-01f, 2.96619177e-01f, 5.85076511e-01f, 2.03931272e-01f, -1.88460857e-01f, -2.40352511e-01f, 4.29741204e-01f, -2.10312709e-01f, -1.78791568e-01f, -2.52196252e-01f,
  -3.83310094e-02f, -3.26834559e-01f, 2.65865773e-01f, -1.76089540e-01f, 1.36653364e-01f, 4.59505796e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  1.55409694e-01f, 1.77336678e-01f, 4.30460960e-01f, 1.28239587e-01f, 2.33545125e-01f, 2.61154503e-01f, 1.18383214e-01f, 1.17566809e-01f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  9.08154156e-03f, 1.37317022e-02f, -1.21331044e-01f, 1.65857837e-01f, 1.03806637e-01f, -2.20175281e-01f, -2.86528796e-01f, -9.29077938e-02f, -1.31466642e-01f, 6.97833598e-02f,
  -5.85264489e-02f, 3.12427804e-02f, -9.01750699e-02f, -1.51154948e-02f, -1.63529336e-01f, 1.45801991e-01f, -1.12348691e-01f, 7.55476505e-02f, 1.39760196e-01f, 2.27198422e-01f,
  -6.11382723e-03f, 2.70309448e-01f, 7.04327691e-03f, 2.10798103e-02f, 1.60660282e-01f, 3.21736217e-01f, 4.22569737e-02f, 5.07494137e-02f, -2.96022564e-01f, -2.82352924e-01f,
  6.21677600e-02f, -2.27133512e-01f, 3.42366219e-01f, 1.41945556e-01f, 2.26122305e-01f, 2.95966089e-01f, -3.46418172e-01f, 1.51063889e-01f, 6.96355328e-02f, 1.26110211e-01f,
  3.25095952e-01f, 9.66095924e-02f, -2.06863448e-01f, -3.51203054e-01f, -5.00761457e-02f, 9.33868736e-02f, 8.67187232e-02f, 1.45561239e-02f, -4.17239666e-01f, 3.47256899e-01f,
  -2.44424701e-01f, -4.56473291e-01f, -9.08852518e-02f, -1.23030692e-01f, -2.50157602e-02f, -2.45046407e-01f, -6.47539943e-02f, 1.73979290e-02f, 2.24795509e-02f, -1.49916792e-02f,
  -7.41716847e-03f, 1.43334702e-01f, -1.29878983e-01f, -5.70071340e-02f, 3.50577608e-02f, 1.67389959e-01f, -2.67399102e-01f, 6.36973679e-02f, -2.04842344e-01f, -1.24217771e-01f,
  5.58063947e-02f, 2.15309203e-01f, 1.82324663e-01f, -6.00721873e-02f, 2.58086234e-01f, -1.14407957e-01f, -2.07525194e-01f, -3.23941052e-01f, -2.26798370e-01f, 2.74604529e-01f,
  3.34400497e-02f, 1.65206119e-01f, -1.52879171e-02f, -2.27990627e-01f, -1.01853997e-01f, 3.17371599e-02f, 7.19027743e-02f, -3.14870119e-01f, 1.79444507e-01f, 2.21001714e-01f,
  1.85925178e-02f, 1.31070524e-01f, -2.01546296e-01f, -2.05615178e-01f, 1.81537960e-02f, -1.87245414e-01f, 7.62880817e-02f, -1.15381315e-01f, 1.57120541e-01f, 1.99697152e-01f,
  3.12198363e-02f, -8.42329711e-02f, -1.21056199e-01f, -4.18241462e-03f, -3.17205228e-02f, -2.49862865e-01f, -2.18055218e-01f, 3.12757820e-01f, 1.07134268e-01f, 5.44191189e-02f,
  -1.44120872e-01f, -3.13292742e-01f, -4.04649585e-01f, 2.88203619e-02f, 1.80994019e-01f, 3.03175475e-04f, 5.85554726e-02f, -2.08129704e-01f, 3.71358842e-01f, 1.07754774e-01f,
  -1.92957759e-01f, 2.00451866e-01f, 2.73896366e-01f, -3.54559720e-02f, -1.85019240e-01f, -5.93727194e-02f, -3.23480636e-01f, 2.91539192e-01f, 1.26594812e-01f, 9.52607989e-02f,
  2.79111654e-01f, 7.29016438e-02f, -5.48586994e-02f, 2.35493369e-02f, 3.19040775e-01f, 1.48689672e-01f, 4.82005551e-02f, 1.12138860e-01f, -1.15662463e-01f, -8.38404968e-02f,
  3.67335886e-01f, 1.63486883e-01f, 9.55759287e-02f, -5.43228611e-02f, -3.32436770e-01f, 5.44441342e-02f, -4.91023809e-02f, -2.03463867e-01f, -2.21483007e-01f, -1.88094676e-01f,
  -1.15218181e-02f, -1.45669699e-01f, -1.45879626e-01f, 1.38631552e-01f, 3.96543503e-01f, -2.85290368e-02f, -2.70786524e-01f, 1.67184100e-02f, -2.22903475e-01f, -3.23540680e-02f,
  -5.97177111e-02f, 2.55735368e-02f, 3.54170561e-01f, -1.06045023e-01f, 2.77635902e-01f, -1.07925393e-01f, 1.23871908e-01f, 3.06234449e-01f, 4.23753448e-02f, 4.78141531e-02f,
  -9.29950550e-02f, -3.91677432e-02f, 1.98642313e-01f, -3.11236650e-01f, -2.88167834e-01f, 4.52612460e-01f, 6.64983392e-02f, -1.13499574e-01f, 7.98433125e-02f, -2.77919676e-02f,
  -2.32354566e-01f, 2.33981267e-01f, 1.84073523e-01f, -1.02224469e-01f, -3.79361361e-02f, -2.08595350e-01f, 1.85696781e-01f, -1.49631714e-02f, -8.03958029e-02f, -8.15295335e-03f,
  1.40640169e-01f, -1.51871726e-01f, -2.02588826e-01f, -2.83953510e-02f, -1.40313536e-01f, -4.16386239e-02f, 4.42275375e-01f, -2.79301286e-01f, -2.72873998e-01f, 9.11138356e-02f,
  -1.71899068e-04f, -1.46860465e-01f, -1.01407945e-01f, 2.59426802e-01f, -1.16144456e-02f, 5.04797325e-02f, -6.16399525e-03f, -4.89751369e-01f, 3.13436896e-01f, -1.56628743e-01f,
  3.25049944e-02f, 1.64846405e-01f, 2.15390682e-01f, 1.56877831e-01f, 3.82077210e-02f, 3.69872481e-01f, 1.10059738e-01f, -4.84573990e-02f, -1.51542038e-01f, -6.76136464e-02f,
  8.42231438e-02f, 1.65105253e-01f, -2.38972809e-02f, 3.50716472e-01f, 1.20180584e-01f, 3.64295274e-01f, 1.48420438e-01f, 3.94930178e-03f, -9.29612592e-02f, -5.93748502e-02f,
  1.03060707e-01f, 2.47598693e-01f, 3.64032954e-01f, -2.40555387e-02f, 1.12623036e-01f, 2.98470724e-02f, 2.82270223e-01f, 2.53614455e-01f, -8.44096392e-02f, -1.84976593e-01f,
  -2.28786126e-01f, 4.04731691e-01f, -9.44736227e-03f, -5.82814872e-01f, -1.48296162e-01f, -5.67332990e-02f, -4.07180697e-01f, -1.97056487e-01f, 2.36264870e-01f, 5.22399880e-02f,
  -2.48817820e-02f, 8.80541131e-02f, -3.08129221e-01f, -1.79970125e-03f, -1.89450413e-01f, 1.82228506e-01f, 2.56004095e-01f, -2.01788284e-02f, -7.62663260e-02f, 1.31449610e-01f,
  2.67954022e-01f, -8.44897702e-02f, -1.03262216e-01f, 1.25401452e-01f, 1.51309028e-01f, 1.71762856e-03f, -8.08699280e-02f, 9.33025405e-02f, -2.09404364e-01f, 3.11476062e-03f,
  -7.29584545e-02f, -2.74804205e-01f, 1.30036116e-01f, 2.81169236e-01f, 1.41294286e-01f, 2.23910306e-02f, 8.50043967e-02f, 2.64293462e-01f, 7.09216073e-02f, 5.27937353e-01f,
  2.26556137e-01f, -1.18734747e-01f, 8.99691731e-02f, -2.99132079e-01f, 2.34308243e-01f, 6.32072091e-02f, 9.70147178e-02f, 2.51496524e-01f, -2.93033719e-01f, -5.14139459e-02f,
  -1.07209764e-01f, -4.14846055e-02f, 3.07133067e-02f, -3.57238464e-02f, -2.56284267e-01f, -8.34597126e-02f, 1.82567015e-01f, -2.03026429e-01f, -2.50880606e-02f, -5.36613613e-02f,
  -1.30964294e-01f, 5.43898046e-02f, -4.07714806e-02f, -2.07065374e-01f, 3.80275138e-02f, 1.59057468e-01f, 1.43796176e-01f, -1.53056011e-01f, 1.81843251e-01f, 3.10578309e-02f,
  -1.05105817e-01f, 3.25082958e-01f, 2.23668158e-01f, 2.60653019e-01f, -2.62013435e-01f, 1.56995282e-02f, -1.82131797e-01f, 5.90440109e-02f, -5.79903424e-02f, 1.64006248e-01f,
  -1.26797020e-01f, -2.30773222e-02f, -2.25859880e-01f, 1.15733720e-01f, -8.09767693e-02f, 1.09992027e-02f, -1.52099460e-01f, -1.00929506e-01f, -1.88829929e-01f, -5.69618121e-02f,
  3.37773864e-03f, -6.91848546e-02f, -5.07453978e-02f, -1.83869451e-01f, -2.20896214e-01f, 1.53767198e-01f, -1.13812141e-01f, -9.83182043e-02f, 1.13681272e-01f, 8.18981677e-02f,
  1.11517318e-01f, 1.39062151e-01f, 1.47175193e-01f, -1.18706375e-01f, -1.74213365e-01f, 2.43575703e-02f, 1.75786570e-01f, 3.06167871e-01f, -7.24009424e-02f, -1.67445570e-01f,
  -7.95048773e-02f, -1.96428537e-01f, -2.36173689e-01f, 5.48117049e-02f, -2.79768318e-01f, -1.71313107e-01f, 9.25358161e-02f, 1.32584453e-01f, -1.14481680e-01f, -2.97599405e-01f,
  -9.80834588e-02f, 1.18664220e-01f, 3.31312567e-02f, -1.33635495e-02f, -2.37895831e-01f, 6.01540832e-03f, 1.53662249e-01f, 2.83441376e-02f, 4.11367059e-01f, -7.03856796e-02f,
  2.60714460e-02f, 9.27326530e-02f, 1.30677298e-01f, 3.76154445e-02f, -2.32585594e-01f, 1.83215272e-02f, 1.69687316e-01f, 1.02549620e-01f, -3.16006511e-01f, -1.68491472e-02f,
  1.22210421e-01f, 1.28692985e-01f, 2.96367675e-01f, -4.84537669e-02f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  1.60638288e-01f, 2.03347370e-01f, 3.02158654e-01f, 5.44638336e-01f, -4.31446079e-03f, -1.69126377e-01f, 4.02669996e-01f, 1.75741583e-01f, 1.43169180e-01f, 2.66569316e-01f,
  -1.10264264e-01f, 2.23595664e-01f, 8.31140161e-01f, 6.18875206e-01f, 3.75943542e-01f, 2.11398557e-01f, -7.92763591e-01f, 8.00751448e-01f, -3.23114783e-01f, 1.83691576e-01f,
  -7.78492570e-01f, -8.98268968e-02f, -5.34470975e-01f, -1.10914119e-01f, 1.87299147e-01f, 8.22168067e-02f, 5.53082645e-01f, -6.64782003e-02f, -5.99851131e-01f, -4.41177897e-02f,
  7.22887516e-02f, 1.76791161e-01f, 2.68648803e-01f, 4.40315843e-01f, 1.26233995e-01f, 4.34532136e-01f, -2.88232476e-01f, -8.30702670e-03f, 2.20059484e-01f, -2.66341001e-01f,
  5.55955589e-01f, 2.54228741e-01f, -1.13406219e-01f, -2.12107841e-02f, -2.40810052e-01f, 4.28095043e-01f, -2.49339312e-01f, 1.26366466e-01f, -3.30553085e-01f, 6.06497288e-01f,
  2.08157584e-01f, -6.07608080e-01f, 1.01108722e-01f, 3.33201230e-01f, -3.65098387e-01f, -2.93978333e-01f, 4.11226243e-01f, 6.85501873e-01f, -1.31931946e-01f, -4.01612744e-03f,
  -4.33870554e-01f, 3.22467983e-01f, 1.64893791e-01f, 5.04948556e-01f, -1.47787035e-01f, 5.56063689e-02f, 7.07260072e-02f, 4.80138510e-01f, 6.67048573e-01f, -3.70379686e-01f,
  6.56011775e-02f, 1.51170298e-01f, 3.41053188e-01f, -1.04828402e-01f, -3.22400838e-01f, 2.64767140e-01f, 6.02947176e-03f, 3.54228824e-01f, -2.10903764e-01f, 2.70311475e-01f,
  -2.34548226e-01f, 3.41604054e-01f, 2.97338188e-01f, 6.03360648e-04f, 2.72039622e-02f, 5.39601564e-01f, -3.27417664e-02f, 4.41701919e-01f, 4.36356694e-01f, 3.00846696e-01f,
  3.22361469e-01f, -6.88162223e-02f, -2.50000000e-01f, 1.30416021e-01f, 4.68977392e-01f, 5.21684527e-01f, 7.08649978e-02f, 3.95278670e-02f, -4.97682840e-01f, -3.76382142e-01f,
  6.55503348e-02f, 1.33720368e-01f, 1.98059045e-02f, 1.42703876e-01f, -3.51487756e-01f, 2.18621269e-01f, 4.31359440e-01f, 1.03643596e-01f, -5.17654419e-01f, -6.08295321e-01f,
  -4.82051432e-01f, 5.18268406e-01f, 2.28080690e-01f, -4.85775173e-01f, 5.21281481e-01f, -5.43995723e-02f, -1.60953462e-01f, 5.10913789e-01f, 2.31349453e-01f, -3.56497675e-01f,
  4.38065886e-01f, 4.54500020e-01f, 6.49966180e-01f, 8.49051237e-01f, 5.12785129e-02f, -3.50233376e-01f, 6.02344453e-01f, -3.81572336e-01f, -7.70993829e-02f, -2.20655695e-01f,
  -1.19330831e-01f, -8.77092779e-02f, -5.96073717e-02f, -6.08313736e-03f, -3.02470356e-01f, -8.26552987e-01f, -3.87688652e-02f, 7.60833845e-02f, 1.92706436e-02f, 4.24434990e-02f,
  -4.45557415e-01f, 4.72643763e-01f, 9.96725261e-02f, -5.91716409e-01f, 1.17146611e-01f, 1.67698920e-01f, 1.79945573e-01f, -3.54911434e-03f, 8.30354393e-01f, -6.03927374e-02f,
  -1.58875585e-01f, 1.97517455e-01f, 2.50898570e-01f, 6.10373318e-01f, -5.65703996e-02f, 3.53740454e-02f, -5.02506495e-02f, 5.02699554e-01f, -2.40750462e-02f, 5.10393858e-01f,
  2.01445326e-01f, -9.21324939e-02f, 3.89602602e-01f, 2.61723280e-01f, -2.83590227e-01f, -4.23713364e-02f, 2.29665503e-01f, -5.22106923e-02f, 2.38640919e-01f, 1.08291112e-01f,
  -3.61835897e-01f, -1.88233182e-01f, -1.59463763e-01f, 1.16104431e-01f, 3.00194889e-01f, 3.33736449e-01f, 1.91080391e-01f, -1.41612947e-01f, -4.31232214e-01f, -3.44082862e-01f,
  -2.54765123e-01f, -4.64499086e-01f, -9.92915854e-02f, -1.03485743e-02f, 2.91918755e-01f, -1.89606696e-01f, -1.92683786e-01f, -6.65113404e-02f, 1.02247918e+00f, 2.97227830e-01f,
  6.99858427e-01f, 1.89433265e-02f, 7.27463812e-02f, 2.30203107e-01f, 2.75029361e-01f, -1.13162706e-02f, 4.80145007e-01f, 4.66449171e-01f, 5.23396969e-01f, 5.23079753e-01f,
  2.02810258e-01f, 3.68753433e-01f, 1.66238189e-01f, 1.73331052e-01f, 4.02687639e-01f, 1.22870162e-01f, 5.38791537e-01f, -5.14854491e-01f, 3.86661053e-01f, -1.77224562e-01f,
  -3.23911607e-01f, 1.42034844e-01f, -4.43870127e-01f, -4.69137251e-01f, -6.29661456e-02f, 6.84568942e-01f, 1.15254901e-01f, -1.54013813e-01f, 3.44301373e-01f, -3.23317587e-01f,
  8.36548626e-01f, 5.03909826e-01f, 4.60299283e-01f, 4.64708418e-01f, 6.64884567e-01f, -5.49179614e-02f, 4.83872920e-01f, -5.93536124e-02f, -9.88905430e-01f, 3.93021882e-01f,
  3.89677316e-01f, -7.07016140e-02f, -6.23658523e-02f, 3.22909206e-01f, 1.00130133e-01f, -4.77073938e-01f, -5.17851338e-02f, 1.71335433e-02f, 1.69597998e-01f, -1.74874607e-02f,
  -1.46139495e-03f, 7.79925212e-02f, -3.36190611e-01f, -2.64985383e-01f, -3.03288192e-01f, -5.98673344e-01f, 8.29542801e-02f, -6.77298665e-01f, -1.38182089e-01f, -1.18295163e-01f,
  2.12185234e-01f, 3.33379149e-01f, 4.56782937e-01f, 1.27549604e-01f, -1.47677129e-02f, -1.42172664e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  2.91738510e-01f, 1.97503492e-01f, 6.26879483e-02f, 3.12344313e-01f, 4.65966249e-03f, -5.02832867e-02f, 3.40884507e-01f, 1.75658122e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  2.69856304e-01f, 1.12024739e-01f, 2.28824869e-01f, 1.60765082e-01f, -3.08574378e-01f, 4.93202582e-02f, 1.74614862e-01f, 2.68670321e-01f, 3.34215581e-01f, -1.13649830e-01f,
  3.24153543e-01f, 9.85486433e-02f, -4.95683491e-01f, 3.72370869e-01f, -5.91890275e-01f, 5.24229527e-01f, 3.17626894e-01f, -3.99088800e-01f, -4.63147521e-01f, 3.29973727e-01f,
  -2.96938449e-01f, -4.26288038e-01f, -1.85733855e-01f, -4.56204414e-01f, 4.42589819e-01f, -5.99181890e-01f, -3.85739982e-01f, -4.76152778e-01f, -6.60837352e-01f, -8.93730104e-01f,
  1.97491825e-01f, 7.12087035e-01f, 1.13283284e-01f, 1.38472781e-01f, 1.23154685e-01f, 1.48277044e-01f, 1.52740806e-01f, 3.55733000e-02f, -2.25887924e-01f, -3.43999177e-01f,
  -3.95662040e-01f, 8.47974420e-02f, -3.11678827e-01f, 3.16918433e-01f, -3.84268701e-01f, 3.83314155e-02f, -5.01819372e-01f, 3.81709188e-01f, 4.23650563e-01f, -1.20788239e-01f,
  6.62726521e-01f, 1.14928514e-01f, 4.55265939e-01f, 3.93335789e-01f, -2.03250013e-02f, 1.04201317e-01f, 2.40844905e-01f, 6.65747821e-02f, 2.11117268e-01f, -8.11222911e-01f,
  -5.65046333e-02f, -5.46749771e-01f, 3.03248048e-01f, -9.36725497e-01f, -6.17689602e-02f, -8.81035551e-02f, -1.74576305e-02f, -2.38685459e-02f, -1.20271139e-01f, -4.03890133e-01f,
  -6.43596500e-02f, 5.95938861e-02f, 2.53964197e-02f, -1.36831477e-01f, -2.26417944e-01f, -3.06067228e-01f, -2.90834337e-01f, 5.26587144e-02f, -4.75386411e-01f, -3.18425059e-01f,
  -3.95150393e-01f, 1.06180660e-01f, 1.19013898e-01f, 1.92289338e-01f, -3.87950838e-01f, 9.18182433e-02f, 4.36705381e-01f, -4.59446199e-02f, -7.00652063e-01f, 2.25981250e-01f,
  -1.60210043e-01f, -8.83933604e-01f, 3.66873056e-01f, 2.53545105e-01f, 2.17670500e-02f, 2.28526250e-01f, 3.41026723e-01f, 4.38634992e-01f, -1.43910527e-01f, 2.04321727e-01f,
  -1.44147724e-01f, -2.74200082e-01f, -2.11798921e-01f, 5.46821356e-01f, -2.76336759e-01f, -1.87355176e-01f, -3.58211547e-01f, -2.91498184e-01f, 2.23490104e-01f, 2.02918187e-01f,
  4.85037595e-01f, 4.22407538e-01f, 4.92469937e-01f, 4.76584077e-01f, -2.78376400e-01f, -7.49739483e-02f, -4.64199036e-01f, -3.74483258e-01f, 1.69651553e-01f, -4.68417406e-01f,
  -1.01732695e+00f, -8.16348255e-01f, -5.81184626e-01f, 3.31281096e-01f, -5.58052003e-01f, -6.83541656e-01f, -5.95184863e-01f, 6.60480738e-01f, -2.75941730e-01f, 6.85800314e-02f,
  -2.44101584e-01f, -4.23497781e-02f, 4.98105921e-02f, 1.16963454e-01f, -2.67417461e-01f, -4.16193247e-01f, 3.03270966e-01f, 2.87514657e-01f, -1.38958655e-02f, 2.45590642e-01f,
  3.43120933e-01f, 7.31314003e-01f, -2.56220132e-01f, -4.08333898e-01f, 3.64443004e-01f, 6.51242614e-01f, 1.21647902e-01f, 2.61588335e-01f, -5.44943035e-01f, -3.50515880e-02f,
  6.49356842e-01f, -2.51047224e-01f, 2.26287171e-02f, 2.60251760e-01f, -2.47231703e-02f, 1.22260898e-01f, -6.92844212e-01f, -4.35663342e-01f, -5.60786963e-01f, 2.79080182e-01f,
  5.10665953e-01f, -5.56171477e-01f, 3.33234280e-01f, 3.40761095e-01f, 9.71172843e-03f, 4.73112583e-01f, 6.59168586e-02f, -2.41978899e-01f, 3.84086788e-01f, 4.33015794e-01f,
  1.72946662e-01f, 3.35240066e-02f, 2.28568658e-01f, 3.34745318e-01f, 6.55034661e-01f, 3.01376283e-01f, 1.42389715e-01f, -2.23331824e-01f, -6.06578290e-01f, 8.73996969e-03f,
  1.17449805e-01f, 1.53130233e-01f, -3.71062964e-01f, -1.35898277e-01f, 1.41125485e-01f, 3.00700486e-01f, 7.17081577e-02f, -4.56072658e-01f, -3.25617492e-01f, 3.69801939e-01f,
  -2.86840439e-01f, 2.44385526e-01f, 3.45101625e-01f, -1.36064515e-01f, 2.17700377e-01f, -1.90130740e-01f, -3.75422031e-01f, 1.41089022e-01f, -1.63977370e-01f, 1.22110263e-01f,
  -3.02531272e-01f, -2.21667245e-01f, -3.90545391e-02f, -5.00627220e-01f, 3.31997752e-01f, -5.01290619e-01f, 3.85042310e-01f, -5.58969319e-01f, -1.17201112e-01f, -4.11253303e-01f,
  3.75959963e-01f, 3.10392737e-01f, 3.86210158e-02f, 2.71096855e-01f, -3.09964359e-01f, -2.78604805e-01f, -6.73181057e-01f, 1.15202382e-01f, 2.00764984e-01f, -8.49277228e-02f,
  -3.55009070e-05f, 2.53195912e-01f, -1.39290929e-01f, -9.89822149e-01f, -3.71139795e-01f, -1.60321280e-01f, 3.93014818e-01f, 1.47708833e-01f, 4.83778343e-02f, -4.57139969e-01f,
  2.56273597e-01f, -1.46683335e-01f, 1.65892780e-01f, -2.05823675e-01f, -2.67241836e-01f, -1.05440423e-01f, 7.85182863e-02f, -5.90845585e-01f, 1.07914738e-01f, 5.23609936e-01f,
  2.30709389e-01f, 1.84421510e-01f, -3.46646935e-01f, -6.04486406e-01f, 1.80109009e-01f, -4.26013678e-01f, 2.18867421e-01f, -4.15468872e-01f, 3.58505815e-01f, -7.27602482e-01f,
  4.19821590e-01f, 1.31193966e-01f, -4.67674822e-01f, -5.40680587e-01f, -3.10956776e-01f, -5.47188997e-01f, -2.10018709e-01f, 6.01421669e-02f, 2.45448723e-01f, -1.38694286e-01f,
  1.57849550e-01f, 4.70310226e-02f, 2.43927553e-01f, 1.94446221e-01f, -2.85606474e-01f, 1.65463671e-01f, -2.95555770e-01f, 4.96329814e-02f, -3.32186699e-01f, 1.66234031e-01f,
  -2.77445316e-01f, -4.34965730e-01f, -3.95113796e-01f, -7.16523528e-02f, 3.45179170e-01f, -2.16792390e-01f, 1.52539045e-01f, -4.55863953e-01f, -3.79363030e-01f, 3.59753758e-01f,
  -2.94744343e-01f, -5.85659623e-01f, -3.72069955e-01f, -3.08231354e-01f, -5.93397260e-01f, 4.70443279e-01f, 4.66636747e-01f, 3.32991242e-01f, -1.69383511e-01f, 1.03221364e-01f,
  -2.31693551e-01f, -7.13108480e-02f, 1.79842547e-01f, -3.08630198e-01f, 1.48293987e-01f, -3.66555870e-01f, -6.60503358e-02f, -1.13080665e-01f, 2.57123172e-01f, 1.34842813e-01f,
  4.72243130e-02f, 1.47026420e-01f, 2.59835660e-01f, 5.18452823e-01f, -4.28164214e-01f, -7.40881488e-02f, 2.32655585e-01f, -2.71619886e-01f, 2.70088941e-01f, 6.89089522e-02f,
  -1.30500808e-01f, 3.00145894e-01f, 5.39653078e-02f, 3.05257618e-01f, 1.10837258e-01f, -1.58177316e-01f, 2.79095381e-01f, -7.65107453e-01f, -8.78842592e-01f, -6.59142435e-01f,
  1.99882463e-02f, 1.01102941e-01f, -2.19164103e-01f, -2.38396525e-02f, 5.03460281e-02f, 4.06126469e-01f, -6.19056150e-02f, 3.09464127e-01f, -2.74996281e-01f, -6.35831729e-02f,
  -2.39160713e-02f, -1.24677449e-01f, -3.35696280e-01f, -6.33851588e-01f, -1.83276027e-01f, -1.18334116e-02f, -1.63672835e-01f, -3.00478995e-01f, -3.83453250e-01f, 2.31232032e-01f,
  -5.41818261e-01f, 4.71811593e-01f, 4.49482761e-02f, 5.03193855e-01f, -8.53878260e-01f, 5.84609853e-03f, -1.57333061e-01f, 3.10128212e-01f, 2.77104855e-01f, -5.65450728e-01f,
  -9.21571076e-01f, -1.53166890e-01f, -1.96078867e-01f, -2.64585167e-01f, -2.91509151e-01f, -4.15792823e-01f, -5.45427203e-02f, -3.30137730e-01f, 3.35432887e-01f, 1.01325616e-01f,
  1.49376780e-01f, 2.84653842e-01f, 1.64824530e-01f, 9.83835980e-02f, 1.93935186e-01f, -4.07399386e-01f, -6.87890947e-02f, -4.36151862e-01f, -3.64351749e-01f, 3.79314452e-01f,
  -2.48038948e-01f, -9.92726907e-02f, 1.47904024e-01f, -8.13789293e-02f, 2.67003596e-01f, 5.95045269e-01f, -9.60034966e-01f, -3.97940159e-01f, 1.01768985e-01f, 2.35905051e-01f,
  -7.52190828e-01f, 4.89694774e-01f, -2.16896787e-01f, -1.35405630e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.19634710e-01f, 1.32233679e-01f, 1.28650299e-05f, 2.28359923e-01f, 1.64858416e-01f, 1.04880691e-01f, -7.58654624e-03f, -9.66250822e-02f, 9.09031332e-02f, 5.47898933e-03f,
  -9.41219088e-03f, 1.30012934e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    