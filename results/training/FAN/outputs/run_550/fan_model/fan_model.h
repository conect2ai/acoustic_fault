/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.61515468e-01f, -7.61497095e-02f, 5.49488254e-02f, 2.70300750e-02f, 1.01189494e-01f, 4.58202772e-02f, -4.45226319e-02f, 1.55089661e-01f, 1.86269924e-01f, 1.55006647e-01f,
  4.50275578e-02f, 1.50381833e-01f, -7.81446323e-02f, -1.34520397e-01f, -5.01264557e-02f, -2.31356308e-01f, -1.05761597e-02f, 1.00384749e-01f, -1.06899016e-01f, 1.78122036e-02f,
  -6.87900409e-02f, -1.28369421e-01f, -2.12471515e-01f, -1.38158321e-01f, 6.66741580e-02f, 3.09179239e-02f, -9.43353623e-02f, -1.06059782e-01f, 2.32606125e-03f, 2.99145691e-02f,
  4.62424522e-03f, 3.05912375e-01f, 6.93088919e-02f, 4.78678085e-02f, 2.40591634e-02f, 6.87840059e-02f, 2.49025226e-02f, -7.40399361e-02f, -1.37407798e-03f, 5.51298745e-02f,
  -1.06860593e-01f, -1.13522811e-02f, 6.73183799e-02f, -7.92766884e-02f, 1.17965482e-01f, 3.12081687e-02f, -7.06511959e-02f, -4.25682180e-02f, -4.90608218e-04f, -8.43279250e-03f,
  -8.75928774e-02f, -8.28955695e-03f, 4.58776578e-02f, -9.99669358e-02f, -3.69958878e-02f, 6.73256740e-02f, 2.82201320e-02f, -6.70717703e-03f, 7.63970762e-02f, 1.19487435e-01f,
  2.38460358e-02f, 1.98552758e-02f, 8.83390382e-02f, 8.07442702e-03f, 8.20912421e-03f, -2.93828337e-03f, -2.80036107e-02f, -2.69235875e-02f, -3.18766665e-03f, -2.48660576e-02f,
  -1.62112303e-02f, 1.22369163e-01f, 2.06860304e-02f, -1.93968713e-02f, -6.84346035e-02f, -1.37257809e-02f, -7.93719199e-03f, 1.47961676e-02f, -6.10550679e-02f, -7.06685614e-03f,
  3.58463041e-02f, -1.33526335e-02f, 9.20800790e-02f, 3.71361384e-03f, 9.73509923e-02f, -4.94836345e-02f, 5.19151539e-02f, 8.17096382e-02f, -1.85739733e-02f, -8.82892460e-02f,
  1.70686752e-01f, 2.77685255e-01f, 1.09758396e-02f, 1.38035730e-01f, 4.38566180e-03f, 6.19882680e-02f, -8.76194164e-02f, 8.53389204e-02f, 5.70345521e-02f, -1.47357741e-02f,
  4.08545062e-02f, 9.41034406e-02f, -1.23934483e-03f, 4.37747389e-02f, -8.70801732e-02f, 7.25797787e-02f, -1.82169601e-02f, 1.15847751e-03f, 7.00875819e-02f, -6.65327813e-03f,
  2.38554124e-02f, 1.17950505e-02f, -1.94052719e-02f, 2.52692066e-02f, -2.11239047e-02f, 7.15460181e-02f, -2.79504601e-02f, -2.30375472e-02f, -3.55965383e-02f, 2.28583924e-02f,
  1.23958644e-02f, 1.09458752e-01f, -1.65750861e-01f, 5.48134511e-03f, -1.80075429e-02f, 1.09779395e-01f, 1.92039743e-01f, 7.37222135e-02f, 1.66065767e-01f, 1.64095804e-01f,
  7.34483302e-02f, 9.27279121e-04f, 2.26583868e-01f, 1.49241894e-01f, -2.22458914e-02f, 1.90590918e-01f, -1.19796824e-02f, 1.11918062e-01f, 1.70965232e-02f, 1.30111173e-01f,
  4.03406434e-02f, 1.40116692e-01f, -8.36677104e-02f, 1.25156343e-02f, 2.88170762e-02f, -5.99174760e-02f, -1.28309652e-01f, 1.15676103e-02f, -1.50208622e-01f, 5.05625606e-02f,
  -5.90552166e-02f, 7.56782759e-03f, 2.31836997e-02f, 6.19702600e-03f, -5.91771305e-02f, -7.18463883e-02f, -1.26981676e-01f, -4.53953259e-02f, -4.37364168e-02f, 6.78290203e-02f,
  -3.53305861e-02f, -2.41966657e-02f, 8.73288438e-02f, 9.37577896e-03f, -3.45763080e-02f, 1.33541906e-02f, -8.49099383e-02f, -7.12107196e-02f, 4.12088111e-02f, 7.83070475e-02f,
  -1.68140233e-02f, -5.13796285e-02f, 2.66569294e-02f, 2.17578802e-02f, -1.76103003e-02f, -2.49239597e-02f, 2.83204149e-02f, -4.36361507e-02f, -2.17410885e-02f, -3.18197906e-02f,
  8.45856145e-02f, -2.27054767e-02f, 8.19576532e-02f, -1.24977343e-02f, 6.12780266e-03f, -1.05116561e-01f, -2.81054992e-02f, -1.11655600e-01f, 2.19130665e-02f, 1.33735659e-02f,
  -1.98706947e-02f, -4.63056192e-02f, 6.09533563e-02f, -3.54614966e-02f, 1.48225818e-02f, -7.25096539e-02f, -3.85930389e-03f, 9.43841878e-03f, 5.27679063e-02f, -1.51072472e-01f,
  1.31158130e-02f, 4.36175354e-02f, 7.79518634e-02f, -3.81358080e-02f, 6.49127811e-02f, 8.61546397e-03f, 2.50420123e-02f, 7.10593387e-02f, -1.10193491e-02f, -3.50846909e-02f,
  1.79460555e-01f, 2.48633638e-01f, -2.68477704e-02f, 3.87856625e-02f, -1.72730684e-02f, 4.40938845e-02f, 3.28693609e-03f, 4.48760279e-02f, 1.06841676e-01f, -2.95107681e-02f,
  -3.04183513e-02f, -2.96922009e-02f, -1.33962100e-02f, -3.88275221e-04f, -1.22562088e-01f, -1.55033143e-02f, 6.90922439e-02f, -3.13657033e-03f, 1.77752599e-02f, -1.06208615e-01f,
  -1.36561634e-03f, 8.02886114e-02f, -4.61025685e-02f, 2.18524504e-02f, -1.47030819e-02f, -6.16825148e-02f, -2.23999619e-02f, -5.28929709e-03f, 2.62644105e-02f, -7.44387927e-03f,
  1.90736741e-01f, -6.23585656e-02f, 2.12013766e-01f, 1.49694383e-01f, 2.50800133e-01f, 2.54545361e-01f, 1.85057983e-01f, 1.44628972e-01f, 1.23610057e-01f, -2.02097386e-01f,
  -4.41318564e-02f, 1.07278667e-01f, -2.27576792e-01f, -6.35998100e-02f, 2.82717198e-01f, -9.68070999e-02f, 7.85319582e-02f, 1.22751640e-02f, 6.45216554e-02f, 1.24588802e-01f,
  3.93789671e-02f, 1.23713678e-02f, 5.54561578e-02f, -3.93802710e-02f, 8.71223956e-02f, 3.25917937e-02f, -7.71410316e-02f, 1.31238699e-01f, -1.92644857e-02f, 1.32078350e-01f,
  1.10818110e-01f, -5.42426258e-02f, 1.34530440e-02f, -3.97614427e-02f, -1.94636136e-02f, -3.91941257e-02f, 3.47620733e-02f, 1.29668438e-03f, 9.84919909e-03f, 7.34747946e-02f,
  -1.07652932e-01f, -2.03765905e-03f, -1.02666821e-02f, 2.49174088e-02f, 3.08247302e-02f, 4.03939411e-02f, 4.61270548e-02f, -1.88022777e-02f, -4.87839542e-02f, -5.77827394e-02f,
  4.16498184e-02f, -5.16763963e-02f, -6.68241549e-03f, -6.16014637e-02f, -1.23060429e-02f, 1.51288733e-02f, -8.72975662e-02f, 1.65110119e-02f, 9.14924219e-02f, 6.96918070e-02f,
  5.64363301e-02f, -2.32224278e-02f, -2.02113818e-02f, -2.20339373e-02f, -2.24637784e-04f, -2.56731994e-02f, -1.03593446e-01f, -3.80413793e-02f, 1.75722931e-02f, 1.26065947e-02f,
  -2.81170420e-02f, 4.16604131e-02f, -6.38781562e-02f, 2.62284447e-02f, -4.48148921e-02f, -2.37329844e-02f, 4.31189202e-02f, -2.45055091e-02f, 4.49206308e-02f, -4.85346615e-02f,
  -3.39671597e-02f, 1.32963015e-02f, -7.51482621e-02f, -3.80174629e-02f, 9.15485248e-02f, 8.61332379e-03f, -1.90982129e-02f, -1.81084871e-02f, -3.10746767e-02f, -7.71435630e-03f,
  3.66780311e-02f, 1.59248799e-01f, -5.72471581e-02f, -5.84460050e-02f, -7.88867101e-02f, 3.09758186e-02f, 2.75349664e-03f, 1.07556805e-01f, 2.40231436e-02f, 3.05768251e-02f,
  5.20723918e-03f, -6.67132437e-02f, 1.18040098e-02f, 7.03766420e-02f, 7.04215318e-02f, -3.31125669e-02f, -4.12737913e-02f, -5.47419563e-02f, 7.16348812e-02f, 3.15031633e-02f,
  1.32037140e-02f, -7.97917694e-02f, -5.09558106e-03f, 2.55823769e-02f, -1.98888406e-02f, 7.32044689e-03f, 4.71303277e-02f, -4.72268239e-02f, 4.40275073e-02f, 1.41938301e-02f,
  5.58983311e-02f, -2.71649003e-01f, -2.53918737e-01f, -5.28607927e-02f, 3.82165909e-02f, 1.40959457e-01f, 2.38344997e-01f, -1.47758976e-01f, -2.44472444e-01f, 9.51911137e-02f,
  2.36039355e-01f, -1.78656578e-01f, -4.12430800e-02f, 2.33442724e-01f, -3.32249254e-02f, -3.57093439e-02f, 1.07765056e-01f, 4.96231019e-02f, -2.44179085e-01f, 3.43052894e-02f,
  -1.86810464e-01f, 1.83284312e-01f, -1.96215734e-02f, 6.18521031e-03f, 3.87244821e-02f, -4.90192175e-02f, 1.89212635e-01f, -1.29625872e-02f, 2.03237534e-01f, 4.08675484e-02f,
  1.04863614e-01f, -1.35359153e-01f, -2.77872812e-02f, 4.95178998e-02f, -6.43599555e-02f, 2.76009142e-02f, 8.81259218e-02f, 6.46827817e-02f, -1.86312627e-02f, 1.79389827e-02f,
  7.92238209e-03f, 2.93176454e-02f, 2.66734455e-02f, -7.23964674e-03f, 1.45691885e-02f, -3.03440820e-02f, -1.19018089e-02f, -1.45141566e-02f, -5.84590621e-02f, -3.42128053e-02f,
  -1.97615959e-02f, -5.97466677e-02f, -4.30627028e-03f, 2.07905695e-02f, -5.08444160e-02f, -6.72248006e-02f, 1.61232613e-03f, 4.47637215e-02f, -1.46830003e-04f, -3.87230776e-02f,
  4.56811721e-03f, 2.56168786e-02f, 5.12113199e-02f, 3.99422646e-02f, -1.46637848e-02f, -2.46248394e-02f, 3.40422690e-02f, 1.95427295e-02f, 1.57848429e-02f, 7.39101029e-04f,
  1.85296256e-02f, 4.84950133e-02f, -4.38345522e-02f, 1.73350945e-02f, 1.61389373e-02f, 5.08402511e-02f, 6.34600222e-02f, -6.48060953e-03f, -9.42694116e-03f, -5.95237799e-02f,
  5.13005592e-02f, 3.48524861e-02f, -9.48842019e-02f, 3.71686071e-02f, 4.19678800e-02f, 1.85681190e-02f, 3.75554077e-02f, -3.92426178e-02f, 5.78148931e-04f, -5.33724353e-02f,
  -4.16476279e-02f, -1.42113149e-01f, -9.17671770e-02f, -1.59315411e-02f, -3.13441493e-02f, 3.98820825e-02f, -3.14492686e-03f, -7.48211518e-02f, -1.18942916e-01f, 2.98228092e-03f,
  6.97346330e-02f, 9.03043374e-02f, 1.61241088e-02f, 2.85477713e-02f, -1.18926296e-03f, -5.02999388e-02f, 6.17655367e-02f, -1.33273436e-03f, 3.48063037e-02f, 2.24434473e-02f,
  2.62114480e-02f, 7.46395513e-02f, 4.57745381e-02f, 9.75541696e-02f, 2.30303444e-02f, 9.30497199e-02f, -5.65294586e-02f, -3.42816561e-02f, 3.75444330e-02f, -6.62502348e-02f,
  -3.66137862e-01f, 2.47335240e-01f, 3.98679078e-02f, -1.03263952e-01f, -1.12459168e-01f, -3.62657756e-02f, -1.39186710e-01f, 1.01254597e-01f, 1.80021942e-01f, 1.94590867e-01f,
  4.32298593e-02f, -1.31232202e-01f, 1.98010504e-02f, -1.96298049e-03f, -1.53343171e-01f, 1.98361054e-01f, 4.90561351e-02f, -5.46118617e-02f, 1.14087127e-01f, -1.04189947e-01f,
  -4.16044183e-02f, -4.60668467e-02f, -1.34112582e-01f, 1.16637602e-01f, -4.09653746e-02f, -1.98868960e-02f, -3.27735022e-02f, 3.34433839e-02f, -1.73204482e-01f, 2.04412118e-02f,
  1.04732141e-02f, 6.44270033e-02f, 8.91328324e-04f, 2.05755327e-02f, -6.27531633e-02f, -1.11371413e-01f, 3.22771780e-02f, -9.77389398e-04f, -8.89146477e-02f, 7.74545670e-02f,
  -1.19604999e-02f, -8.07827041e-02f, 3.29420157e-02f, -2.05260292e-02f, -1.01444520e-01f, -2.75905849e-03f, 2.76917703e-02f, -5.23277409e-02f, -9.39880311e-03f, -2.84631029e-02f,
  -1.18853161e-02f, -7.00399326e-03f, 6.65768795e-03f, 7.95425773e-02f, -4.68600867e-03f, 5.78904971e-02f, -6.43682554e-02f, -1.07601926e-01f, 7.48374462e-02f, -5.36119528e-02f,
  4.27399809e-03f, 9.97318551e-02f, -1.87773909e-02f, -1.56000415e-02f, -3.62132862e-02f, 1.26961142e-01f, 6.85364380e-02f, -3.88089940e-02f, -3.92576046e-02f, -2.80267168e-02f,
  -2.90133767e-02f, 3.46049592e-02f, 1.01794630e-01f, 3.18602361e-02f, -1.71910636e-02f, 2.00723857e-02f, 2.23025363e-02f, -1.47713926e-02f, -5.30094132e-02f, 3.64500582e-02f,
  1.45797640e-01f, 1.15771941e-03f, -1.02110744e-01f, 2.50930302e-02f, 1.05264723e-01f, -3.05734165e-02f, 1.12279772e-03f, 6.27926961e-02f, 2.08895057e-02f, -3.08286468e-03f,
  -4.20295401e-03f, 9.10382047e-02f, 4.86741289e-02f, -1.09307915e-02f, 7.56348595e-02f, 3.02355159e-02f, 5.84348477e-03f, -7.19083399e-02f, -3.26503254e-02f, 7.11664790e-03f,
  -1.81047842e-02f, -2.40317695e-02f, 1.25265688e-01f, 2.77882461e-02f, -7.16933189e-03f, 6.10406585e-02f, -3.55506912e-02f, 5.18028513e-02f, 6.51505440e-02f, -2.13639718e-02f,
  -3.48076434e-03f, -5.98504134e-02f, 4.00669165e-02f, 5.23562171e-02f, 5.88191859e-03f, -4.77419309e-02f, 1.07469466e-02f, -4.33867909e-02f, -2.35714465e-02f, 2.11422332e-02f,
  2.51403391e-01f, -2.55855739e-01f, -1.07471839e-01f, 1.86186537e-01f, 2.25027904e-01f, 1.08764069e-02f, 6.79762214e-02f, 3.51922326e-02f, 1.17539845e-01f, -1.92666963e-01f,
  1.20256886e-01f, -1.98083535e-01f, -5.75706325e-02f, -8.10045563e-03f, 2.62360275e-01f, -2.30976880e-01f, 1.27797574e-01f, -3.68214063e-02f, -9.42011364e-03f, 6.96928650e-02f,
  1.33198097e-01f, 6.14638627e-02f, -5.86274546e-03f, 2.81521287e-02f, 6.53630495e-02f, -5.06402403e-02f, 1.60189033e-01f, -9.16549340e-02f, -8.04698560e-03f, -1.62065402e-02f,
  -3.90950441e-02f, 4.90578040e-02f, 1.16648553e-02f, -1.27099723e-01f, 4.94407527e-02f, -8.62603821e-03f, -8.56630579e-02f, -1.85079016e-02f, 4.39737141e-02f, -2.61962693e-02f,
  3.88419442e-02f, 4.81324345e-02f, -1.62894689e-02f, -3.33342850e-02f, 1.02592908e-01f, 5.76919839e-02f, 5.98429479e-02f, -4.97397259e-02f, -9.67467353e-02f, -9.82090309e-02f,
  -1.02020223e-02f, -5.29887453e-02f, 6.66429624e-02f, -1.26123518e-01f, -2.28943899e-02f, -1.50563465e-02f, -8.39269757e-02f, -1.18427463e-01f, -2.63862889e-02f, -1.66922121e-03f,
  5.63330799e-02f, -3.89871709e-02f, -2.65135262e-02f, -3.21295261e-02f, -4.95411875e-03f, -2.19357060e-03f, 7.39430785e-02f, -4.25074324e-02f, 4.53004874e-02f, -9.36429296e-03f,
  1.18691139e-02f, 6.12764955e-02f, 1.47989867e-02f, -2.38914192e-02f, 1.68840494e-02f, 1.73957273e-02f, 5.04238941e-02f, -1.86463185e-02f, -1.34388532e-03f, 3.19620259e-02f,
  2.73371320e-02f, 8.62366334e-03f, -8.38751066e-03f, 2.63429731e-02f, -4.84904125e-02f, 1.19033270e-02f, 6.04942963e-02f, -7.45804235e-02f, 4.19612676e-02f, 1.15626846e-02f,
  4.51461673e-02f, -9.60164145e-02f, -7.14192316e-02f, -3.76688652e-02f, -1.59617905e-02f, 4.43490893e-02f, -2.77863424e-02f, 2.81291711e-03f, -6.27002344e-02f, 7.94210732e-02f,
  2.84327902e-02f, -4.10183221e-02f, -2.93355137e-02f, 7.81897157e-02f, -6.77901581e-02f, -2.20628269e-02f, -3.03967688e-02f, 8.59906599e-02f, 5.21506891e-02f, 9.20098498e-02f,
  -1.05887419e-02f, -1.45052560e-02f, -4.66128588e-02f, 7.72118643e-02f, 6.50300682e-02f, -4.40254733e-02f, 4.76675220e-02f, 5.00845760e-02f, -3.29935364e-02f, 5.67589104e-02f,
  3.52992833e-01f, -1.59157872e-01f, -1.54862866e-01f, -1.23161331e-01f, 2.28978097e-01f, -2.74022341e-01f, -5.55996150e-02f, -5.78761809e-02f, 5.02921082e-02f, -7.71505609e-02f,
  1.08370245e-01f, -8.50134641e-02f, 1.20496444e-01f, -2.43027061e-01f, 5.83324097e-02f, -6.58627525e-02f, -1.73467174e-01f, -1.07441753e-01f, 7.59053081e-02f, 8.09932575e-02f,
  -4.32050191e-02f, -6.68809637e-02f, -1.86339989e-01f, -1.37150502e-02f, 1.20563153e-02f, 5.33235893e-02f, 1.14133172e-01f, 1.28986865e-01f, -5.41760400e-02f, -5.09676263e-02f,
  1.18438952e-01f, 3.00094709e-02f, -1.31110698e-01f, -9.70432907e-02f, 7.38781914e-02f, -3.55744101e-02f, 2.76743155e-02f, -2.33295690e-02f, 2.32184101e-02f, -7.09816217e-02f,
  -1.51901403e-02f, 4.03489918e-02f, -8.37005824e-02f, -1.34180002e-02f, 2.54547559e-02f, -8.02523047e-02f, -7.46826455e-02f, -9.87693667e-02f, -2.77236830e-02f, -6.63241819e-02f,
  -9.85352322e-02f, -5.06827235e-02f, -7.23213926e-02f, -2.15894096e-02f, -4.15233225e-02f, -5.76784424e-02f, -2.94507556e-02f, 1.62887555e-02f, -4.79919054e-02f, -8.36229920e-02f,
  -2.54826751e-02f, 7.62561560e-02f, -2.80939415e-02f, -3.26054282e-02f, -4.13448397e-05f, 1.15291188e-02f, -3.25263068e-02f, -8.33162293e-03f, 4.71154749e-02f, 5.85207567e-02f,
  -6.34862762e-03f, 5.75674623e-02f, -1.49678672e-02f, 4.00877036e-02f, 2.11192202e-02f, 3.42987641e-03f, -1.13079017e-02f, -4.66651795e-03f, 6.64453954e-02f, 1.71064232e-02f,
  1.48651060e-02f, 5.85086793e-02f, 2.77448837e-02f, 2.33025048e-02f, -3.41259572e-03f, 3.07948627e-02f, -6.45043030e-02f, -3.03500239e-02f, 1.31663552e-03f, 3.67589034e-02f,
  6.86454400e-02f, 1.96528748e-01f, 4.96224687e-02f, -5.16389171e-03f, -8.53478536e-02f, -6.05000630e-02f, -2.12115236e-02f, -4.03413288e-02f, -9.66736674e-03f, 7.45580196e-02f,
  2.61377227e-02f, -1.38288606e-02f, 8.74467939e-02f, 1.65888306e-03f, 3.12856399e-03f, 5.00854217e-02f, 8.46615285e-02f, 4.26259935e-02f, 3.61649506e-02f, 7.40060285e-02f,
  1.34140868e-02f, 4.41023409e-02f, 6.48170933e-02f, 2.29793191e-02f, 3.92135344e-02f, 7.34989420e-02f, 5.02571650e-02f, -2.47231731e-03f, 4.54770289e-02f, -4.41520438e-02f,
  -9.14664939e-03f, 1.22613266e-01f, 3.15475091e-02f, -1.27707586e-01f, 1.87014267e-01f, -1.60082206e-01f, -1.36772588e-01f, 3.36264074e-01f, -1.44238710e-01f, -9.45460126e-02f,
  -1.10851757e-01f, -3.64945441e-01f, -1.21154152e-01f, -2.63362736e-01f, -3.32857430e-01f, -1.94508702e-01f, -2.53206372e-01f, -2.76470333e-01f, 5.74811921e-02f, -4.97450028e-03f,
  -1.32464655e-02f, 5.53794019e-02f, 1.43460974e-01f, 3.00384730e-01f, 1.47478268e-01f, 3.06750268e-01f, 1.59853593e-01f, 2.05942854e-01f, 1.22403592e-01f, -8.17510858e-02f,
  -1.37216583e-01f, -1.47460951e-02f, -1.19558377e-02f, 5.59718534e-02f, 8.78475327e-03f, -1.85070988e-02f, -4.55287769e-02f, -6.96673617e-02f, -3.01875938e-02f, 3.60640734e-02f,
  -7.63755366e-02f, -1.09646353e-03f, 6.45666495e-02f, 8.59168544e-02f, -2.00888719e-02f, 3.42964903e-02f, 1.81719959e-02f, 5.59872808e-03f, 4.75732982e-02f, -2.80958433e-02f,
  -2.57717837e-02f, -2.73840874e-02f, -9.93110016e-02f, -6.91806376e-02f, -6.28501475e-02f, -1.48929376e-02f, 1.12763904e-02f, -4.60569002e-02f, -2.31706407e-02f, 2.06396282e-02f,
  4.04422432e-02f, 4.23365645e-03f, -1.40833587e-03f, -4.49131653e-02f, -3.39665846e-03f, -1.11555494e-02f, -1.12637356e-01f, -2.11568028e-02f, 4.50383872e-02f, -9.63580702e-03f,
  -2.85567921e-02f, -3.79452511e-04f, -2.21704282e-02f, -2.50770375e-02f, -3.24545451e-03f, 9.39934999e-02f, -2.56157015e-04f, 6.87446296e-02f, 5.73428813e-03f, 3.70106176e-02f,
  -1.60352513e-02f, -7.38594085e-02f, 5.74630164e-02f, 3.75838857e-03f, -7.24519789e-02f, -5.17323427e-03f, 5.44818901e-02f, 2.06183437e-02f, 4.38023917e-02f, -1.63396299e-02f,
  -5.54623231e-02f, 7.09567815e-02f, 1.00197280e-02f, 3.49984542e-02f, -2.44360734e-02f, 4.75194454e-02f, -5.04158698e-02f, 3.41267474e-02f, -6.36166669e-06f, 7.94381462e-03f,
  1.67848710e-02f, -2.39957850e-02f, 1.03950091e-02f, -2.41117366e-02f, -2.60902140e-02f, -1.95448305e-02f, -1.47786006e-01f, -6.30958751e-03f, 9.79183707e-03f, 5.97352125e-02f,
  3.09920684e-02f, 2.54482925e-02f, 6.22882461e-03f, 1.20224692e-01f, 1.91222280e-02f, -4.12077866e-02f, -1.23422770e-02f, 3.67321074e-02f, 3.72619331e-02f, -1.24756686e-01f,
  -3.56824726e-01f, 1.85993433e-01f, 1.06601588e-01f, -6.45879135e-02f, -8.84575620e-02f, -1.42199770e-01f, -1.08334251e-01f, 1.03654534e-01f, -6.64805472e-02f, 1.85766399e-01f,
  -5.23427576e-02f, 9.73442942e-03f, 5.34509420e-02f, -1.26745030e-01f, -3.36003453e-01f, -1.16388023e-01f, -9.22982618e-02f, -7.53364712e-02f, -1.32347152e-01f, 7.77850002e-02f,
  -8.02499428e-02f, -2.03475207e-01f, -1.03883997e-01f, 3.25315110e-02f, 5.30753322e-02f, 7.75443390e-02f, 1.30346581e-01f, 7.05170333e-02f, 1.03556201e-01f, -2.68134009e-02f,
  -1.30082682e-01f, 3.82240675e-02f, 1.11769482e-01f, 1.98048390e-02f, 3.51788551e-02f, -4.12647240e-03f, 6.62967041e-02f, -6.27177283e-02f, -1.01945557e-01f, 3.87477428e-02f,
  3.78693044e-02f, -7.05072284e-02f, -7.80192018e-02f, -9.92507115e-03f, 5.57639450e-03f, -1.89394187e-02f, 9.22047999e-03f, 2.67946646e-02f, 5.53657003e-02f, -7.23590255e-02f,
  1.65811833e-02f, 4.76372316e-02f, -6.24300502e-02f, -8.05985183e-03f, -3.99876945e-02f, -1.47821931e-02f, -2.08617486e-02f, 9.34002250e-02f, 3.42767872e-02f, -3.53016667e-02f,
  2.67425254e-02f, 3.58860753e-02f, -3.03807650e-02f, 2.17824448e-02f, 1.36996647e-02f, 4.48355563e-02f, -5.39631285e-02f, 2.73288954e-02f, -2.38923188e-02f, 1.10748904e-02f,
  2.34776512e-02f, -1.54627068e-02f, -1.18790036e-02f, 5.73845766e-02f, -5.53289950e-02f, -1.23069128e-02f, 2.70643067e-02f, 8.80890002e-04f, 5.07970564e-02f, 1.94231663e-02f,
  -1.59514677e-02f, -7.35543817e-02f, 7.35702440e-02f, 5.31501975e-03f, -8.66552368e-02f, -2.79545188e-02f, -1.08966650e-02f, 2.97165159e-02f, 4.58256342e-02f, 1.66334305e-02f,
  1.33745611e-01f, 2.14697301e-01f, 2.50036158e-02f, -1.00702457e-01f, 1.01493355e-02f, -6.19358309e-02f, 7.78080337e-03f, 7.15330318e-02f, 8.15117508e-02f, 2.71623880e-02f,
  -2.40103062e-02f, -4.17639455e-03f, 7.74765164e-02f, 2.21865578e-03f, -4.95505519e-02f, 1.23003293e-02f, 3.69402133e-02f, 2.13375073e-02f, 2.89994497e-02f, -8.39208998e-03f,
  6.90753907e-02f, -3.37658152e-02f, -2.49259528e-02f, -2.30069682e-02f, -5.54724270e-03f, -2.59630033e-03f, 8.01331922e-02f, -6.18062951e-02f, 4.77997586e-03f, 6.63279444e-02f,
  -2.05806166e-01f, 5.22125401e-02f, 1.94661185e-01f, 4.44274694e-02f, -2.77755968e-02f, -1.85251310e-02f, -8.03178623e-02f, -3.61019410e-02f, -1.70245379e-01f, -8.21981393e-03f,
  2.59246095e-03f, 9.92542803e-02f, -4.40147445e-02f, -7.35156164e-02f, 1.16010480e-01f, -7.32726902e-02f, -6.42332202e-03f, -9.56774950e-02f, -1.34012848e-01f, 3.39408331e-02f,
  -1.18990783e-02f, -1.03177480e-01f, 1.93850011e-01f, 8.72018114e-02f, 8.25996771e-02f, 1.64959595e-01f, 1.29561216e-01f, 1.04500778e-01f, 2.39400670e-01f, 5.98298386e-02f,
  -5.88975474e-02f, -7.60515556e-02f, 3.21730264e-02f, 2.07712445e-02f, 9.13532171e-03f, 5.14027327e-02f, 1.09916672e-01f, 1.22556845e-02f, 5.22393212e-02f, -1.12606566e-02f,
  -3.90887037e-02f, 5.13110347e-02f, -1.20089673e-01f, -1.16844671e-02f, -8.57860744e-02f, 5.71992546e-02f, -2.63317265e-02f, 1.36425365e-02f, -5.52681368e-03f, -3.15014347e-02f,
  -2.05577090e-02f, 7.94031397e-02f, -3.58938985e-02f, 8.14174395e-03f, 4.38795723e-02f, 2.02874262e-02f, -2.52618901e-02f, -4.68121655e-02f, 2.14249473e-02f, -2.36847065e-02f,
  -5.28906658e-02f, 3.04260198e-02f, -3.55014428e-02f, 2.15041488e-02f, 2.61270925e-02f, 3.48868854e-02f, 3.40407975e-02f, -2.32035518e-02f, -4.95748362e-03f, 1.72143523e-02f,
  5.86269237e-02f, 5.96557334e-02f, -2.62712147e-02f, 2.88743153e-02f, -2.80886106e-02f, -8.20666701e-02f, 3.39057259e-02f, 2.08270624e-02f, -1.71268880e-02f, 5.42633496e-02f,
  1.51154976e-02f, 8.18680152e-02f, 2.69951066e-03f, 4.90632206e-02f, 5.88333011e-02f, 6.20622039e-02f, -1.43348717e-03f, 4.44169305e-02f, -4.50508930e-02f, 2.33613960e-02f,
  2.92285811e-04f, 7.16392370e-03f, -4.18844074e-02f, 4.52699587e-02f, 2.98794266e-02f, -9.46477205e-02f, -8.41365978e-02f, 5.42096607e-03f, 8.01834986e-02f, -9.01819468e-02f,
  5.74613437e-02f, -2.04803031e-02f, 9.26448032e-02f, -2.39967462e-03f, 2.44656354e-02f, -2.46008839e-02f, 3.79220992e-02f, 4.20703255e-02f, -3.50171514e-03f, 1.01649210e-01f,
  1.86202433e-02f, -3.94745590e-03f, 2.77503207e-03f, -3.21897343e-02f, -3.71180922e-02f, -1.12281535e-02f, -2.11472921e-02f, 4.44925502e-02f, 1.09384190e-02f, 3.26127931e-02f,
  -1.56314731e-01f, 2.16371119e-01f, 1.85820580e-01f, -1.32468551e-01f, -2.64375627e-01f, 2.07679942e-01f, 2.91199118e-01f, -1.49752378e-01f, -1.12666257e-01f, 4.20619510e-02f,
  -9.60094631e-02f, 2.79919177e-01f, 1.97407126e-01f, 4.51338245e-03f, 1.46627119e-02f, 1.89411089e-01f, -1.71356611e-02f, 7.08768219e-02f, -3.19597609e-02f, 4.29547764e-02f,
  -6.85403794e-02f, -2.08775192e-01f, 6.13395348e-02f, -8.52994770e-02f, 7.83189088e-02f, -6.60359263e-02f, -1.93129912e-01f, 2.54856739e-02f, -1.29200161e-01f, 4.66095209e-02f,
  1.00683779e-01f, -1.29567459e-02f, 7.26046041e-02f, 5.50940260e-02f, -3.12707797e-02f, -3.58275212e-02f, 6.26642779e-02f, 9.28974971e-02f, 1.55297108e-03f, -4.03186232e-02f,
  9.88493562e-02f, -4.37355451e-02f, -8.35336819e-02f, 1.92191973e-02f, 1.14638591e-02f, 1.06819894e-03f, -9.35353898e-03f, 1.37895923e-02f, 1.59768704e-02f, 4.78636362e-02f,
  3.90776694e-02f, 4.67804149e-02f, -9.87149123e-03f, 1.02145923e-03f, -3.74789163e-02f, -1.15905013e-02f, -6.41398132e-03f, 1.31847665e-01f, 3.80243845e-02f, 1.74252875e-02f,
  4.02272046e-02f, 5.27901091e-02f, 1.74297933e-02f, -5.52356355e-02f, 5.94270863e-02f, -7.46279955e-02f, -4.02263962e-02f, -5.69480136e-02f, 3.24160047e-02f, 2.80726533e-02f,
  -1.00387387e-01f, 5.17557329e-03f, -4.59511355e-02f, -8.16727579e-02f, 2.13640667e-02f, 3.38918157e-02f, -9.65138339e-03f, -2.31513493e-02f, -1.05195038e-01f, -2.04622280e-03f,
  -4.85377125e-02f, -1.11719714e-02f, 6.08510412e-02f, -6.87266886e-02f, 7.84099028e-02f, -6.58261478e-02f, -7.31096491e-02f, 3.49040739e-02f, -7.60746829e-04f, 1.26343733e-02f,
  5.04641458e-02f, -4.02994081e-02f, -2.75111403e-02f, -1.46244830e-02f, 4.94665131e-02f, 2.27423348e-02f, 5.45830652e-02f, -4.14978042e-02f, -1.61474179e-02f, 3.49679776e-02f,
  -4.15630601e-02f, -6.18062541e-02f, 1.86347347e-02f, -7.56905600e-02f, -6.63748160e-02f, 2.32579913e-02f, 9.02828351e-02f, -2.48327591e-02f, 2.03995407e-02f, 1.64820645e-02f,
  -4.18728702e-02f, 6.09751092e-03f, -5.05941436e-02f, -1.26890177e-02f, -9.46115404e-02f, 4.14119400e-02f, -3.89433838e-02f, -6.30152747e-02f, -2.34359000e-02f, 3.92371304e-02f,
  1.72175154e-01f, -8.38700607e-02f, 1.37851238e-01f, 5.85168786e-02f, 1.82015896e-01f, 4.23810445e-02f, 1.10578358e-01f, 1.12164527e-01f, 2.28671864e-01f, -2.18474194e-01f,
  -4.75786394e-03f, -1.85202081e-02f, 8.58355463e-02f, -2.12683901e-01f, 6.14421368e-02f, 8.11857656e-02f, -2.18624800e-01f, -1.34117439e-01f, 1.22986458e-01f, -1.49148285e-01f,
  9.78693068e-02f, -1.99929148e-01f, 3.05117038e-03f, -1.80088907e-01f, -1.65850505e-01f, -1.95821282e-02f, -2.90843725e-01f, 7.95510188e-02f, -2.37453163e-01f, 6.03147782e-02f,
  -4.88000643e-03f, 9.50631946e-02f, -9.45414454e-02f, -9.83615965e-03f, -1.43370554e-01f, 8.58680308e-02f, 3.47129554e-02f, 5.35015948e-02f, 3.14926468e-02f, 8.65178704e-02f,
  2.73855645e-02f, 2.66178697e-03f, -3.94565947e-02f, 8.27796236e-02f, 1.59452751e-01f, 2.53189113e-02f, 4.29224689e-03f, -3.37905064e-02f, 2.74295565e-02f, 9.48242769e-02f,
  1.12263642e-01f, 2.23442707e-02f, 1.78024676e-02f, -1.06474116e-01f, 7.28616351e-03f, 6.38417453e-02f, -4.57006041e-03f, 8.20580684e-03f, -6.49284273e-02f, 2.96358280e-02f,
  -2.23533157e-02f, 8.61235261e-02f, -9.98937804e-03f, -7.11382180e-02f, -1.90522540e-02f, -4.30038236e-02f, 5.04673645e-02f, 5.67813683e-03f, 5.21381721e-02f, -1.01645105e-01f,
  -8.99593607e-02f, 2.16537458e-03f, 6.76090866e-02f, -3.80305946e-02f, 4.16567810e-02f, -5.47168404e-02f, -1.27117513e-02f, -5.48765808e-02f, 1.75552927e-02f, -1.01663610e-02f,
  2.93712951e-02f, 1.99411083e-02f, -5.06997816e-02f, -2.12377738e-02f, 2.82426588e-02f, 3.57635468e-02f, 3.70579697e-02f, -4.11197692e-02f, -5.70451934e-03f, -7.61446878e-02f,
  -1.22866064e-01f, -1.75623730e-01f, -1.17776163e-01f, -4.47376966e-02f, -9.96283665e-02f, -3.30867618e-02f, 5.73301874e-02f, -1.18884891e-02f, -1.07588731e-02f, -2.76186839e-02f,
  -7.62341693e-02f, -5.92957884e-02f, -5.99794202e-02f, -4.90039028e-03f, 2.97762714e-02f, -6.45368099e-02f, 4.73817438e-02f, 5.79323107e-03f, -1.42271951e-01f, -2.61496548e-02f,
  -1.07492395e-01f, -1.04805753e-02f, -3.66697535e-02f, -1.02413125e-01f, -1.65945385e-02f, -1.10008299e-01f, 2.69992780e-02f, -4.38381955e-02f, -4.06859033e-02f, -3.54781486e-02f,
  -2.34758303e-01f, 8.09984952e-02f, 2.02342886e-02f, -1.78502172e-01f, 4.73990813e-02f, -6.65974319e-02f, -1.10835105e-01f, 5.93225136e-02f, 1.18864410e-01f, 7.50525519e-02f,
  -1.46407664e-01f, -1.35842040e-01f, 6.07651360e-02f, -2.89381683e-01f, -2.28662416e-01f, 4.51905616e-02f, -1.80570975e-01f, -1.07192449e-01f, 1.22594394e-01f, -1.07897349e-01f,
  -1.53984979e-01f, -1.52790830e-01f, -1.46416843e-01f, 1.05586194e-01f, -1.44657001e-01f, 4.42421734e-02f, -1.10539995e-01f, 9.44883376e-02f, -2.53711402e-01f, -1.38545126e-01f,
  -2.85359025e-02f, 1.47524681e-02f, 3.36197130e-02f, 8.18005577e-02f, 2.32177845e-04f, -1.44673288e-02f, -8.84283707e-02f, -9.75335762e-02f, 7.45715424e-02f, 1.72196571e-02f,
  9.04536992e-03f, -3.41722742e-02f, -1.62083805e-02f, -8.17897613e-04f, 7.80402636e-03f, -1.48589853e-02f, 5.78806810e-02f, -4.01058123e-02f, -3.34369764e-02f, -9.71916616e-02f,
  2.67376546e-02f, 1.83721948e-02f, -8.81132483e-02f, 1.63251311e-02f, -3.52256559e-02f, -2.50320341e-02f, -3.45693133e-03f, 7.02787098e-03f, 2.33461964e-03f, -2.61677299e-02f,
  -1.59162432e-02f, 9.90744606e-02f, -4.12810519e-02f, 7.11606145e-02f, 1.95601583e-02f, -9.65345651e-03f, -2.64353566e-02f, 4.93019521e-02f, 5.35482727e-02f, -8.68529268e-03f,
  3.33123244e-02f, -1.55933164e-02f, 2.59318743e-02f, -8.42020065e-02f, -1.54365357e-02f, 8.05552118e-03f, -2.59545492e-03f, 5.78272641e-02f, 3.38059813e-02f, -5.64060733e-03f,
  8.38582497e-03f, 1.79271419e-02f, -5.23031615e-02f, 6.37961105e-02f, 5.15907370e-02f, 4.40905578e-02f, -1.02931987e-02f, -3.31287198e-02f, -2.00001299e-02f, -3.73750404e-02f,
  -3.43123935e-02f, -4.04514670e-02f, 4.41885106e-02f, 3.68211884e-03f, -5.09288162e-03f, -6.85835555e-02f, 2.04157438e-02f, 5.66326268e-02f, -4.70791683e-02f, -3.03137805e-02f,
  -4.54066955e-02f, 7.73563534e-02f, -5.61589794e-03f, -1.60296652e-02f, 4.27684449e-02f, -5.08196726e-02f, -4.75832298e-02f, 1.93930082e-02f, -4.03756276e-02f, -4.46309000e-02f,
  -4.99984138e-02f, 4.01345417e-02f, -3.85520607e-02f, 1.87945440e-02f, -3.36001301e-03f, -3.10856756e-02f, -2.61538643e-02f, 6.68605044e-02f, 1.74568705e-02f, 6.05519675e-02f,
  8.61143917e-02f, -1.59038156e-01f, -1.10393211e-01f, -2.08260953e-01f, 1.15733773e-01f, 2.71215793e-02f, 3.78112458e-02f, -3.99374962e-02f, -1.84708402e-01f, 4.85435724e-02f,
  1.49418309e-01f, -5.20678982e-02f, -2.67654192e-02f, 6.16206564e-02f, -1.08749926e-01f, -2.29174733e-01f, 7.54607618e-02f, 9.19595510e-02f, -7.45699555e-02f, -1.43931076e-01f,
  -3.59700695e-02f, 3.32151093e-02f, -4.17306758e-02f, -5.73130064e-02f, 1.05606273e-01f, -2.46684328e-02f, 4.42271344e-02f, -9.04420465e-02f, 1.16108686e-01f, 9.06970799e-02f,
  1.19785992e-02f, -7.05000237e-02f, 1.00856796e-01f, 3.77064534e-02f, -3.81664187e-02f, 2.71980073e-02f, 6.84722066e-02f, 3.83608490e-02f, -3.51318195e-02f, -2.84858383e-02f,
  -9.46220569e-03f, -5.14943860e-02f, -6.77531064e-02f, 5.95798492e-02f, -4.02596919e-03f, -2.87524089e-02f, -2.24189404e-02f, 3.55388187e-02f, 3.55838500e-02f, 5.61008521e-04f,
  1.18098445e-02f, 5.72216101e-02f, 2.27103308e-02f, 4.45507132e-02f, 4.92272563e-02f, -1.05326632e-02f, 1.05782803e-02f, 1.12987779e-01f, 4.23891805e-02f, 1.19717028e-02f,
  -1.90806724e-02f, 6.85988143e-02f, -9.30819362e-02f, 5.06446231e-03f, -3.80867571e-02f, 7.32948333e-02f, 6.25600200e-03f, -1.74414571e-02f, 3.26079540e-02f, 5.76861612e-02f,
  -2.03475244e-02f, 3.89234349e-02f, -6.58722222e-03f, -1.47945024e-02f, 3.76925133e-02f, -4.22484279e-02f, 3.28241661e-02f, 8.05688929e-03f, 1.15307178e-02f, 2.96562444e-02f,
  8.87206756e-03f, 3.00034992e-02f, 2.62516923e-02f, 1.17280576e-02f, 5.28343767e-02f, 3.99814397e-02f, -3.33172977e-02f, 2.27999650e-02f, 2.82802135e-02f, 1.72682069e-02f,
  -1.04097612e-01f, -2.74840623e-01f, 3.94984633e-02f, 5.53259701e-02f, -1.14860460e-01f, 5.77284321e-02f, -6.56691715e-02f, -1.78407494e-03f, -9.90992859e-02f, 4.68670242e-02f,
  8.65029730e-03f, 1.66084170e-02f, 2.68378314e-02f, -1.48912231e-02f, -4.65041101e-02f, 4.69316021e-02f, -7.55427917e-03f, -2.20647454e-03f, -6.40677661e-02f, 4.83995713e-02f,
  1.32163092e-01f, -2.96402555e-02f, -4.70382310e-02f, 2.73415726e-02f, 5.07148169e-02f, 3.35468873e-02f, -9.63307247e-02f, 3.26602459e-02f, -2.15311497e-02f, -6.64399713e-02f,
  -2.08668560e-01f, -9.80462879e-02f, 4.87956144e-02f, -1.39605835e-01f, -1.88544959e-01f, 2.31565088e-02f, 5.92352673e-02f, -1.70975104e-01f, 4.01068367e-02f, 1.46231860e-01f,
  -1.19883709e-01f, 6.21685088e-02f, 5.51681072e-02f, -7.45671913e-02f, -2.80056119e-01f, 1.67640775e-01f, -1.12511955e-01f, 1.19308695e-01f, -9.35387611e-02f, -1.95848316e-01f,
  -1.66005284e-01f, -1.30444214e-01f, -1.47133276e-01f, -2.05450699e-01f, -1.27339497e-01f, -1.31315636e-02f, -1.53235272e-01f, -5.10572717e-02f, -6.95653493e-04f, -6.38677403e-02f,
  -1.41434386e-01f, -1.44445956e-01f, -8.97402968e-03f, -9.20118019e-03f, -2.44058166e-02f, 2.19487268e-02f, 7.96396807e-02f, 1.26476154e-01f, 4.82636876e-02f, 5.28850593e-02f,
  9.98615026e-02f, -3.67648937e-02f, 2.23531760e-02f, 6.57731816e-02f, -9.29391291e-03f, 4.63216938e-02f, -7.58668361e-03f, -3.08786277e-02f, -7.50802383e-02f, -1.75815430e-02f,
  5.92109859e-02f, 7.45662209e-03f, 1.41193923e-02f, 9.74930637e-03f, -5.69915250e-02f, -1.48689691e-02f, 1.00330804e-02f, -2.20391974e-02f, 7.88509939e-03f, -1.24775924e-01f,
  -2.18823683e-02f, -6.16248995e-02f, 6.72987476e-03f, -7.51054585e-02f, -1.96386147e-02f, -3.13607901e-02f, -2.45696194e-02f, 1.75206997e-02f, -2.61592935e-03f, -4.60564047e-02f,
  -9.56581980e-02f, -1.09404447e-02f, 2.08867174e-02f, 6.79672956e-02f, 8.74562364e-04f, -5.85252009e-02f, 7.87314549e-02f, 5.37532680e-02f, 4.78636175e-02f, 1.89636145e-02f,
  4.77981493e-02f, -4.20479253e-02f, -3.35585661e-02f, -1.66869757e-03f, -6.04341552e-02f, 6.50791451e-03f, -6.73018571e-04f, 1.23950420e-02f, -2.04136074e-02f, -8.93284678e-02f,
  -4.92143072e-02f, -2.89492965e-01f, -8.47746879e-02f, -6.09858483e-02f, -5.53634204e-02f, -5.27477115e-02f, 1.66522097e-02f, -9.33709182e-03f, 2.68876106e-02f, -4.45444845e-02f,
  -4.36359979e-02f, 6.74481615e-02f, -2.62111500e-02f, 4.05892171e-02f, 9.63216498e-02f, -8.55587274e-02f, 1.93012822e-02f, 1.93042832e-03f, -5.49947210e-02f, -8.87294337e-02f,
  -8.01655799e-02f, -1.34170102e-02f, 2.57262252e-02f, -5.64104617e-02f, 2.43043061e-02f, 2.19407957e-02f, -1.14476785e-01f, -6.06760308e-02f, -2.30996218e-02f, 6.24532439e-02f,
  3.80177021e-01f, -1.49443284e-01f, -2.63779843e-03f, 1.03766963e-01f, 2.32502535e-01f, 8.74972194e-02f, 1.22921197e-02f, 1.00664809e-01f, 1.67691126e-01f, -1.74525708e-01f,
  -5.30677885e-02f, -8.62879455e-02f, -1.00430265e-01f, -2.96023581e-02f, 1.34738013e-01f, -2.10985407e-01f, 2.16362551e-02f, -5.02980724e-02f, -2.45508365e-02f, 1.23855397e-01f,
  1.29843369e-01f, 1.17156908e-01f, -1.65106803e-01f, 6.91675767e-02f, 5.45941107e-02f, -3.32563967e-02f, -1.06404878e-01f, -1.33641392e-01f, -1.04700280e-02f, -3.21492888e-02f,
  -4.96749207e-02f, 5.70849776e-02f, -2.58963443e-02f, -1.18524069e-02f, 6.17513023e-02f, -2.62733903e-02f, -6.56766146e-02f, 5.66285430e-03f, -4.50372733e-02f, 1.00978212e-02f,
  -4.50100042e-02f, -3.89104662e-03f, -4.68845591e-02f, 1.59627211e-03f, 3.40940733e-03f, -2.55278628e-02f, 9.95126786e-04f, -1.36563778e-02f, 2.83077881e-02f, 2.70220102e-03f,
  8.16288684e-03f, 1.70754604e-02f, 6.62517622e-02f, 3.06611173e-02f, 3.28276679e-02f, -1.66169275e-02f, -4.21118774e-02f, -6.17787167e-02f, -2.61747185e-02f, 8.45258981e-02f,
  -1.69778173e-03f, -7.80755654e-02f, -2.18394529e-02f, 1.52872992e-03f, 8.96828920e-02f, -7.35684531e-03f, -7.13769812e-04f, -1.62512250e-02f, 4.26998967e-03f, -7.77680334e-03f,
  9.58075933e-03f, 5.62070161e-02f, 2.87617911e-02f, 3.82493995e-02f, 1.73563324e-02f, 7.32025951e-02f, -5.14542200e-02f, -2.64347587e-02f, -3.78988422e-02f, 3.81695814e-02f,
  -7.59375915e-02f, 7.80768543e-02f, 1.13452587e-03f, -2.85872836e-02f, -4.16084155e-02f, 4.93445061e-03f, 2.28233449e-02f, 4.41880636e-02f, 2.12857686e-02f, 6.08495902e-03f,
  2.94175465e-02f, 2.18908768e-02f, -9.61712897e-02f, -1.52562819e-02f, -7.39647970e-02f, 5.29035665e-02f, 2.21118182e-02f, 9.68906358e-02f, -4.36213380e-03f, 1.25600010e-01f,
  9.97637748e-04f, 2.52775522e-03f, 8.00650343e-02f, -5.00823222e-02f, -1.35127932e-01f, 6.20735884e-02f, -6.91219838e-03f, -2.74164975e-02f, -8.44351724e-02f, -9.36209187e-02f,
  -3.51427421e-02f, 8.62819627e-02f, 1.03469370e-02f, 9.12752524e-02f, -1.22462520e-02f, -9.11753159e-03f, 3.38835455e-02f, -3.67688574e-02f, -9.24841966e-03f, -4.60544750e-02f,
  3.52408960e-02f, 1.38320789e-01f, 8.05215836e-02f, 1.53269798e-01f, -2.93089718e-01f, -4.39488422e-03f, 4.41315491e-03f, -7.90043920e-02f, -3.31172422e-02f, -3.24633606e-02f,
  -1.07010290e-01f, 6.15074523e-02f, -4.12983485e-02f, 2.95570511e-02f, 1.78484470e-01f, 1.64230034e-01f, 1.88542262e-01f, 9.74279493e-02f, -2.87540015e-02f, 3.93880866e-02f,
  4.68046665e-02f, 4.36739139e-02f, 2.17288718e-01f, -5.11952117e-02f, -1.04419194e-01f, -3.30089219e-02f, 1.35723427e-01f, -2.46916618e-02f, 1.75554499e-01f, 2.78427135e-02f,
  -6.46603778e-02f, -1.49935365e-01f, -3.01988684e-02f, 3.10346670e-02f, -1.88630689e-02f, -7.45991021e-02f, 8.19968358e-02f, 1.07580498e-01f, -1.40033171e-01f, -5.02246246e-03f,
  -1.71599966e-02f, -1.93719584e-02f, -7.69221829e-03f, 2.53679883e-02f, -1.10661708e-01f, -1.86459571e-02f, -8.53143185e-02f, -1.25374660e-01f, -2.38227118e-02f, 1.33376420e-02f,
  -5.93561232e-02f, -7.02156499e-02f, -1.37484800e-02f, 6.42527416e-02f, -2.13603247e-02f, -5.08707501e-02f, 8.35136399e-02f, 5.38593866e-02f, 3.52438726e-02f, -4.58255745e-02f,
  -2.09059138e-02f, 5.29954135e-02f, -5.03959954e-02f, -2.30886266e-02f, -8.69932994e-02f, 2.88004782e-02f, 7.45311379e-02f, -1.27807364e-01f, 3.40321288e-02f, -5.57953902e-02f,
  -8.22728872e-02f, 2.68004332e-02f, -1.62412710e-02f, 3.44901793e-02f, -1.17505724e-02f, -3.79761793e-02f, 8.02156776e-02f, -9.89107490e-02f, 1.68276448e-02f, -2.64382437e-02f,
  -7.53865228e-04f, 4.03720811e-02f, 2.72562206e-02f, 2.73582619e-02f, -9.02767405e-02f, 4.44239713e-02f, -5.26280068e-02f, -2.75268350e-02f, -2.07689758e-02f, -2.93160602e-02f,
  2.37629451e-02f, 1.72977090e-01f, -5.89374304e-02f, -7.06209317e-02f, 5.35976291e-02f, 2.50728820e-02f, -6.01783469e-02f, -2.61474540e-03f, 1.17697202e-01f, 1.55738853e-02f,
  2.05210447e-02f, 9.33991969e-02f, 3.18722874e-02f, -6.48124143e-02f, 4.40245308e-02f, -3.38874087e-02f, -3.75832594e-03f, 1.02250930e-03f, 2.92410739e-02f, -3.73652503e-02f,
  1.68118789e-03f, -1.81331858e-02f, 3.57673429e-02f, 1.57006867e-02f, -6.97680702e-03f, 2.11998187e-02f, -3.55502740e-02f, -7.06437160e-04f, 1.11233480e-01f, 1.05597191e-02f,
  -1.81740358e-01f, 3.47576320e-01f, -6.46783412e-02f, 1.99722663e-01f, -1.04272194e-01f, 5.38567230e-02f, -4.76085469e-02f, 1.91069812e-01f, 1.94559425e-01f, 3.19194764e-01f,
  1.69873416e-01f, -1.49581404e-02f, -4.71335948e-02f, 3.41595262e-01f, -2.19233319e-01f, -7.59462863e-02f, 1.57130644e-01f, 9.26519558e-02f, 1.66612957e-02f, 2.33757466e-01f,
  4.35823621e-03f, 2.12192312e-01f, -7.42386431e-02f, 4.65782732e-02f, 1.34190783e-01f, 9.66733471e-02f, -2.27569300e-03f, -1.16597479e-02f, 1.23132080e-01f, -1.69033974e-01f,
  5.25374487e-02f, -8.22669361e-03f, 2.60194931e-02f, -4.79574203e-02f, 1.73613336e-02f, -3.61601450e-02f, 6.98425323e-02f, -1.88359216e-01f, -5.55854104e-02f, -5.31021208e-02f,
  -7.51308277e-02f, -3.76779139e-02f, 2.38880068e-02f, -1.15389032e-02f, 5.55680953e-02f, 4.01803926e-02f, 1.57277212e-02f, -2.07883436e-02f, 8.98526758e-02f, 3.98197733e-02f,
  1.91796310e-02f, -4.98586288e-03f, 2.98921894e-02f, 2.97877826e-02f, -3.70131666e-03f, -6.39890134e-02f, -2.39498969e-02f, -1.81538686e-02f, 1.19997384e-02f, 8.39739963e-02f,
  4.74007707e-03f, -2.02833656e-02f, -3.92066352e-02f, -4.94464561e-02f, 2.87032928e-02f, -1.77374799e-02f, 6.14671037e-02f, -9.42510646e-03f, -2.38402281e-02f, -2.51280442e-02f,
  2.14238670e-02f, -2.06484133e-03f, 3.60682569e-02f, 2.50586830e-02f, 9.44960639e-02f, 5.84081300e-02f, -6.25877902e-02f, -6.92572678e-03f, -9.73259285e-03f, 1.70497838e-02f,
  3.74217778e-02f, -2.16501802e-02f, 6.02873340e-02f, -5.94435669e-02f, 6.58423603e-02f, 1.00661232e-03f, 8.33018199e-02f, -2.59205848e-02f, -4.18112613e-03f, -5.24507873e-02f,
  1.50834918e-01f, 1.60218433e-01f, 2.42537428e-02f, -3.68552916e-02f, -8.15822035e-02f, -2.16669142e-02f, -5.84066734e-02f, 8.87941197e-02f, -4.25175726e-02f, 4.57574762e-02f,
  -3.95544618e-02f, -2.83169211e-03f, -5.32970428e-02f, 7.98395835e-03f, -1.09543800e-02f, -2.20558345e-02f, 6.21961523e-03f, -7.72669613e-02f, -5.45507409e-02f, 9.70358849e-02f,
  6.27064183e-02f, 2.56512780e-03f, 3.46210562e-02f, 3.08868401e-02f, 1.65536460e-02f, -2.07283571e-02f, 6.99952170e-02f, -9.34120454e-03f, -7.47309672e-03f, 2.50169411e-02f,
  1.95868477e-01f, -1.62037998e-01f, 2.05046162e-01f, 2.04668686e-01f, -5.59734479e-02f, -2.32846290e-01f, 1.73227534e-01f, 8.05651955e-03f, 3.12296838e-01f, -9.87041295e-02f,
  -1.04735069e-01f, 1.61563054e-01f, 7.16581121e-02f, -2.36788709e-02f, 7.79547021e-02f, 3.04817948e-02f, -1.23933151e-01f, 4.61658910e-02f, 1.47589212e-02f, -1.03657179e-01f,
  -7.86700547e-02f, -2.88865477e-01f, 1.50002921e-02f, -2.94000328e-01f, -4.77218442e-02f, 1.95358563e-02f, -6.58377260e-02f, -4.73611951e-02f, -2.53138512e-01f, -8.42274129e-02f,
  4.77397852e-02f, 1.29415467e-01f, 6.29407167e-02f, 1.37536883e-01f, -3.56097110e-02f, -9.27852616e-02f, -2.43231766e-02f, 2.71783471e-02f, 3.57939489e-02f, 7.30361696e-03f,
  6.43878803e-02f, 2.47777551e-02f, -6.40228903e-03f, 1.67060411e-03f, 3.76068726e-02f, 1.53102083e-02f, 5.54120168e-02f, -1.82627086e-02f, 5.77751994e-02f, -7.19996095e-02f,
  7.26057068e-02f, 2.66229175e-02f, -2.27375645e-02f, 3.80268618e-02f, 7.94313625e-02f, 5.26183881e-02f, 6.37041628e-02f, -3.18251923e-02f, 2.12222454e-03f, 4.21964750e-02f,
  -1.12940066e-01f, -2.11337470e-02f, 5.11666797e-02f, -5.57020642e-02f, -1.33729689e-02f, -4.56574373e-02f, -2.24657450e-02f, 3.89923737e-03f, 7.64374956e-02f, -5.52912727e-02f,
  4.36661616e-02f, 3.07670590e-02f, 4.11888547e-02f, -6.64745225e-03f, -3.15811709e-02f, 4.95347418e-02f, 2.33439561e-02f, -4.11762707e-02f, 3.51329781e-02f, -4.49052937e-02f,
  2.27925871e-02f, 4.20918129e-02f, -1.94657482e-02f, 8.54378119e-02f, 3.76606011e-03f, 3.78292054e-02f, 4.75719059e-03f, 4.69370894e-02f, 5.74649386e-02f, -6.03190884e-02f,
  -1.50557265e-01f, -2.26325661e-01f, 2.18109321e-02f, 1.69780552e-02f, 6.99644759e-02f, -3.04551031e-02f, -3.44840065e-02f, -3.81476176e-03f, 1.74251981e-02f, -3.43988352e-02f,
  1.06417574e-02f, -7.71710696e-03f, -1.35030271e-02f, -2.30947137e-02f, 1.32817181e-03f, -5.40610477e-02f, -5.97808287e-02f, 2.35352423e-02f, 5.93917556e-02f, -3.08738910e-02f,
  -3.08448542e-02f, 2.28549708e-02f, -1.66884325e-02f, -7.50257745e-02f, -6.13081753e-02f, -4.68651131e-02f, -3.30160074e-02f, 6.39006048e-02f, -7.10700527e-02f, -1.25415176e-01f,
  -3.48561555e-01f, 1.33644104e-01f, -2.25492287e-02f, -2.09979013e-01f, 1.77426711e-01f, -2.07182869e-01f, -2.75855064e-02f, 1.55406334e-02f, -1.77024335e-01f, 5.06675802e-02f,
  -1.05418675e-01f, -1.26286447e-01f, -2.63002403e-02f, -2.66506433e-01f, -2.94632256e-01f, -2.39241779e-01f, -2.63740987e-01f, -2.16937333e-01f, -1.06172264e-01f, -1.05663113e-01f,
  -1.39431074e-01f, -6.64966106e-02f, -5.08099161e-02f, 1.91322818e-01f, 6.55120462e-02f, 1.62032068e-01f, 6.23854399e-02f, 1.92418948e-01f, -1.12084873e-01f, -4.43941578e-02f,
  5.65971881e-02f, 2.14832406e-02f, -1.81065071e-02f, 2.78962310e-03f, -9.52711850e-02f, 2.96692848e-02f, -5.79490140e-02f, 5.73136061e-02f, 6.16009496e-02f, -3.90696153e-02f,
  -8.09715465e-02f, -3.02771013e-02f, -1.28056020e-01f, 6.59202365e-03f, 4.33813632e-02f, -6.25640005e-02f, 9.99381579e-03f, 1.59178786e-02f, 1.14617711e-02f, -4.44151601e-03f,
  3.56252603e-02f, -9.79985222e-02f, -2.14349870e-02f, -8.20693001e-02f, -4.80960272e-02f, -8.98314193e-02f, 1.17899450e-02f, 1.34519851e-02f, 2.39846506e-03f, -3.24749798e-02f,
  -5.64851575e-02f, -9.40155238e-02f, 3.25004384e-03f, 3.28765600e-03f, 5.94136678e-03f, -3.53303328e-02f, -1.06684277e-02f, 1.92468129e-02f, -1.04718953e-02f, 7.15689175e-03f,
  -1.02695078e-01f, 2.77599245e-02f, 4.47610319e-02f, 3.04310210e-02f, -6.17742985e-02f, -1.27306441e-02f, -7.29833124e-03f, -8.59905127e-03f, -3.91296223e-02f, 4.45173234e-02f,
  -5.01206592e-02f, -2.12529954e-02f, -4.14380208e-02f, 8.72851238e-02f, -3.01120561e-02f, 5.18764136e-03f, -6.79363087e-02f, -3.61613221e-02f, -1.42335414e-03f, 3.89598981e-02f,
  -6.56077191e-02f, -1.27086803e-01f, 1.14505328e-02f, 4.74879369e-02f, 6.46738783e-02f, 3.16934176e-02f, -8.43520686e-02f, -6.97786286e-02f, -1.57697946e-02f, -6.08615484e-03f,
  5.74222915e-02f, -3.41011584e-02f, 2.27589551e-02f, -6.31095618e-02f, 7.76232108e-02f, 8.23969860e-03f, -5.49395801e-03f, 7.11498484e-02f, -5.27366586e-02f, -1.05160870e-01f,
  9.21760965e-03f, 1.50155183e-02f, 3.13282758e-02f, 2.63868216e-02f, 2.10950561e-02f, 3.78992036e-03f, 1.56658061e-03f, 6.58264458e-02f, -4.91215140e-02f, -3.50380869e-04f,
  -2.52765536e-01f, -6.39297515e-02f, -2.77466118e-01f, -2.00433388e-01f, -1.01612210e-01f, -1.45613447e-01f, -1.81641772e-01f, -7.91500211e-02f, -2.79487699e-01f, 2.50090688e-01f,
  1.57328680e-01f, -1.01990521e-01f, 1.61999330e-01f, 3.98075162e-03f, -1.77847698e-01f, 5.61747290e-02f, 1.17688114e-02f, 1.66909862e-02f, -4.47987579e-02f, -2.88263764e-02f,
  -4.52597551e-02f, 1.13255069e-01f, -9.19624493e-02f, 2.00092509e-01f, -6.62903190e-02f, -9.99876335e-02f, 1.77722022e-01f, -9.48720053e-02f, 7.19591975e-02f, -8.55338275e-02f,
  3.36659141e-02f, 3.85640934e-02f, -2.14430131e-02f, -8.15098509e-02f, 1.51133966e-02f, -6.29631132e-02f, -4.55304747e-03f, -5.28440103e-02f, -7.48387799e-02f, -6.09669872e-02f,
  1.07274823e-01f, 6.09272458e-02f, -7.39853457e-03f, -3.49793322e-02f, -5.35378531e-02f, -3.97412330e-02f, 4.31966828e-03f, -5.30028343e-02f, -1.12984821e-01f, -7.48648345e-02f,
  -1.07844599e-01f, -1.04111925e-01f, -4.56376709e-02f, -6.16632663e-02f, -1.01846084e-01f, -1.02479309e-01f, -1.42546196e-03f, -4.04996751e-03f, -3.30883972e-02f, -2.26285588e-02f,
  -8.22899491e-02f, -3.92970741e-02f, 8.91123936e-02f, -4.16335389e-02f, 1.11269867e-02f, 5.55739775e-02f, -2.67734174e-02f, 6.91366717e-02f, 3.12929414e-02f, -1.31248077e-02f,
  1.03061181e-02f, -1.11116795e-02f, -9.33604464e-02f, -6.38554543e-02f, 7.90664703e-02f, -3.88868377e-02f, 1.00228079e-02f, 3.35023329e-02f, -1.46059403e-02f, 6.16908558e-02f,
  6.86001331e-02f, 1.46366153e-02f, 3.32530662e-02f, -2.12160274e-02f, -9.23978612e-02f, -3.66810448e-02f, -7.21679702e-02f, -6.63152710e-02f, -4.05433355e-03f, -4.22241278e-02f,
  3.60743031e-02f, -6.10368885e-02f, -5.11711836e-02f, -3.34669016e-02f, 4.06251848e-02f, 1.13383628e-01f, -8.15187991e-02f, 8.77271071e-02f, -4.51933816e-02f, -1.10800145e-02f,
  -1.67292394e-02f, 1.44256270e-02f, 2.85338685e-02f, -5.13655506e-02f, -8.45167190e-02f, 6.83033317e-02f, -5.03763556e-02f, 4.81852777e-02f, 1.35332975e-03f, 4.92627081e-03f,
  -2.48948764e-02f, 5.63192107e-02f, 4.65053990e-02f, 7.41732195e-02f, 7.50228912e-02f, 2.54105814e-02f, 1.35895303e-02f, -9.07194316e-02f, 3.57231833e-02f, -5.92892617e-03f,
  1.90576054e-02f, 8.50968510e-02f, -2.41295192e-02f, -1.52190238e-01f, 1.82489514e-01f, -1.55042047e-02f, -2.20479235e-01f, 1.78030670e-01f, 2.41993457e-01f, -1.84071079e-01f,
  -1.14232175e-01f, -4.44441028e-02f, -1.04074597e-01f, -1.39290303e-01f, -1.78544432e-01f, -3.41562033e-02f, -1.35228336e-01f, -9.49320495e-02f, 1.22380257e-01f, -3.61586474e-02f,
  5.78327291e-02f, -3.38935256e-02f, -2.89298564e-01f, 1.91443309e-01f, 8.27772543e-03f, -2.26147883e-02f, -8.75481665e-02f, 6.10127077e-02f, -1.35686472e-01f, -3.50854918e-02f,
  -6.79835752e-02f, 1.43988535e-01f, -1.03438506e-02f, 2.31272690e-02f, 1.66888442e-02f, -2.08939556e-02f, -5.64930551e-02f, -5.03826141e-02f, -1.27871819e-02f, 3.61835100e-02f,
  -5.50420992e-02f, 6.09374233e-02f, 2.03631409e-02f, 8.09528977e-02f, -4.61820187e-03f, -5.79111883e-03f, -5.96507713e-02f, -9.15214568e-02f, 4.57469653e-03f, 3.47031206e-02f,
  -6.30687401e-02f, -4.21904810e-02f, -4.47295569e-02f, -5.63781336e-02f, 4.66561317e-03f, -4.02619056e-02f, -4.91580777e-02f, -2.74940506e-02f, -9.96503979e-03f, -1.34348152e-02f,
  3.40612163e-03f, 1.12437427e-01f, 3.01115401e-02f, 5.06280586e-02f, 1.87506359e-02f, 2.81816199e-02f, -3.33618894e-02f, -2.09157076e-02f, 3.55031565e-02f, -8.51296932e-02f,
  -5.59905916e-03f, -3.42806764e-02f, 3.05061731e-02f, -1.12225814e-02f, -5.08199260e-02f, -9.82496608e-03f, -2.50043292e-02f, -2.52308659e-02f, -4.09057550e-02f, -1.39047727e-01f,
  -5.92332147e-02f, -5.97108528e-03f, 2.31245179e-02f, -6.74110577e-02f, 3.29257138e-02f, -5.42005338e-02f, 1.14849821e-01f, -5.80034740e-02f, 3.28624062e-02f, -5.62878996e-02f,
  4.34195530e-03f, 7.79663846e-02f, 6.87860027e-02f, -5.80905564e-02f, -8.72322246e-02f, 1.58236444e-01f, -5.47682829e-02f, -4.36734641e-03f, 8.32125619e-02f, 4.12694588e-02f,
  6.94544613e-02f, -2.68259756e-02f, -3.41048576e-02f, 6.94026705e-03f, -6.53350204e-02f, 6.90792054e-02f, 1.96669227e-03f, -2.45950632e-02f, -6.81604743e-02f, 5.22890091e-02f,
  5.31062018e-03f, 3.27639468e-02f, 4.66398448e-02f, 8.21863636e-02f, 7.47455135e-02f, -6.33744970e-02f, 2.89412532e-02f, -2.06603352e-02f, 4.58246507e-02f, -8.42612796e-03f,
  -3.70648921e-01f, 2.67478734e-01f, 9.95193794e-02f, -2.62509495e-01f, -6.15005242e-03f, -6.53130934e-02f, -2.24490479e-01f, 6.04546070e-02f, -1.17032394e-01f, 1.99616179e-01f,
  -5.15287109e-02f, -6.53249919e-02f, 9.96537954e-02f, -5.64545952e-02f, -3.34308505e-01f, -6.83696195e-02f, -1.05188258e-01f, -1.48762211e-01f, -2.69120038e-02f, 2.29775738e-02f,
  -7.95232058e-02f, -1.03041828e-01f, 3.80298868e-02f, 1.07077427e-01f, 7.63566270e-02f, -7.81491771e-03f, -6.62962422e-02f, 6.86109737e-02f, 1.06539384e-01f, -5.21038249e-02f,
  -2.82796044e-02f, -1.12712443e-01f, 7.01327175e-02f, -1.59115270e-02f, -3.68692428e-02f, 6.62099011e-03f, -6.90945005e-03f, -4.56608646e-03f, -6.40289038e-02f, 2.96919625e-02f,
  -5.65236509e-02f, 4.30177338e-02f, -4.06283103e-02f, -1.81978978e-02f, 5.96193336e-02f, 2.96824444e-02f, 1.76581852e-02f, -9.59622022e-03f, 5.18209748e-02f, 9.74560827e-02f,
  5.04533686e-02f, 4.74266112e-02f, 6.00756928e-02f, 6.64869836e-03f, 1.76617783e-02f, 4.64589708e-02f, 6.38095960e-02f, 1.90050378e-02f, -3.04339342e-02f, -5.32886721e-02f,
  3.73202562e-02f, 1.06349196e-02f, -3.18796709e-02f, -7.81138148e-03f, -9.06766802e-02f, 3.95391323e-02f, 6.55205399e-02f, 1.99220069e-02f, 5.39311534e-03f, 2.36907378e-02f,
  -4.31474149e-02f, 4.84448252e-03f, 1.84541512e-02f, 1.11759983e-01f, 1.36501128e-02f, -2.29258705e-02f, -1.64865814e-02f, -3.42240073e-02f, 1.45916035e-02f, -5.42487539e-02f,
  3.34521732e-03f, 1.47093190e-02f, -7.53522813e-02f, -1.85974538e-02f, -4.09916509e-03f, 2.23088935e-02f, 1.24660850e-01f, 6.04680404e-02f, -5.96220978e-03f, -7.89278895e-02f,
  -1.31261557e-01f, -1.33284065e-03f, -2.60219350e-02f, -1.64092034e-02f, -1.06914679e-03f, 1.43492902e-02f, -2.38955040e-02f, 2.36155726e-02f, -5.01140095e-02f, -1.41380616e-02f,
  9.32641625e-02f, 1.53643871e-03f, 9.77170840e-03f, -1.21170310e-02f, 1.87865216e-02f, -9.48979706e-03f, 3.08314990e-02f, 4.14480381e-02f, -7.82552212e-02f, 2.22890284e-02f,
  -5.81846759e-02f, 1.76342875e-02f, -2.17184760e-02f, -1.36698270e-03f, -1.38525125e-02f, -6.77869171e-02f, -3.54062431e-02f, 5.78284226e-02f, 3.73717397e-02f, 4.01897319e-02f,
  -3.09986204e-01f, -1.30797029e-01f, 3.51954624e-02f, -9.96969938e-02f, -1.04262969e-02f, 1.13788866e-01f, 1.47301793e-01f, -2.70443588e-01f, -8.35859254e-02f, 4.44854572e-02f,
  -5.33297239e-03f, -8.27771053e-03f, 2.29713619e-01f, 2.77648517e-03f, 1.19273655e-01f, 1.64897919e-01f, 6.99364468e-02f, -2.42275074e-02f, 5.52504845e-02f, -1.81201726e-01f,
  2.60274811e-03f, 2.03867145e-02f, 1.06671989e-01f, -1.15287520e-01f, -1.36282429e-01f, -1.22299053e-01f, 3.47178173e-03f, 6.26083463e-02f, -1.47864610e-01f, 5.43330498e-02f,
  -1.38780311e-01f, -2.53607363e-01f, 6.21139258e-02f, -8.54910687e-02f, -3.53116728e-02f, 1.07735991e-02f, -1.54324640e-02f, 4.04164381e-02f, 9.92401615e-02f, 3.84034142e-02f,
  5.02435155e-02f, -1.52171794e-02f, -2.35045068e-02f, 7.68985003e-02f, -1.15270801e-02f, -1.14651836e-01f, -2.89175678e-02f, -2.73615122e-02f, -9.39195044e-03f, -1.73171412e-03f,
  3.07000522e-02f, -4.98673040e-03f, 2.55075116e-02f, -4.66628671e-02f, 9.43846330e-02f, -4.24729250e-02f, 2.56790128e-03f, -4.38522967e-03f, -1.19442977e-01f, -8.80111232e-02f,
  -1.82897877e-02f, 5.22327349e-02f, 2.36109439e-02f, 3.34543139e-02f, -4.63690609e-03f, -2.57589929e-02f, 4.86383550e-02f, 5.68256304e-02f, 1.17021259e-02f, -4.01986018e-02f,
  -8.74315128e-02f, -7.89234415e-03f, -6.02803901e-02f, -9.41022579e-03f, -6.29120171e-02f, -6.70070946e-02f, 6.15494289e-02f, 2.82903649e-02f, -7.84608722e-02f, -2.44837236e-02f,
  -3.78503986e-02f, 2.62946356e-02f, 1.73466224e-02f, 6.47090329e-03f, 5.16536906e-02f, -9.15641314e-04f, -1.92891490e-02f, 2.82411487e-03f, 5.59181459e-02f, -5.12521826e-02f,
  -6.89497159e-04f, -2.58171380e-01f, 5.18733449e-03f, -9.45614767e-04f, 4.02034111e-02f, -5.43291904e-02f, 6.55395612e-02f, -2.49605570e-02f, -2.46440042e-02f, 1.66771538e-03f,
  -4.59756516e-02f, -1.42078632e-02f, -5.56188188e-02f, 5.17133921e-02f, 4.46158741e-03f, -7.39675743e-05f, 1.63131412e-02f, 5.83956689e-02f, 2.43277904e-02f, -9.76599529e-02f,
  -3.76681909e-02f, 1.71551737e-03f, 1.10263251e-01f, -6.37212396e-03f, 2.18028016e-02f, 2.47422252e-02f, -7.91577250e-02f, -6.56342283e-02f, 8.60995352e-02f, 2.89012641e-02f,
  -3.37457806e-01f, 2.52506845e-02f, 3.13209370e-02f, -1.40629470e-01f, 1.88589171e-01f, 2.50933111e-01f, 1.91013217e-01f, 9.03455019e-02f, 6.32769987e-02f, 2.45985538e-02f,
  -1.85365770e-02f, -8.54134932e-02f, -2.73028831e-03f, 1.48279428e-01f, 1.03711575e-01f, 2.06146836e-01f, 1.60104796e-01f, 1.30367115e-01f, 6.25221655e-02f, 1.74904664e-04f,
  -1.14757948e-01f, 5.72978333e-02f, 3.26786265e-02f, 7.72100314e-02f, -7.80364275e-02f, -4.69841249e-02f, -1.54649496e-01f, 1.19694639e-02f, 1.23459436e-01f, 6.20370023e-02f,
  -1.69184506e-02f, -2.90735751e-01f, -4.09009717e-02f, 7.12685212e-02f, -1.08363464e-01f, -1.28814727e-02f, 1.49551798e-02f, 2.51197852e-02f, -5.87494411e-02f, 7.77791813e-03f,
  -7.61375576e-03f, 3.87253352e-02f, 2.17758468e-03f, 4.04067226e-02f, 8.67879689e-02f, 2.79213600e-02f, 2.47732233e-02f, 7.13808313e-02f, -1.67302880e-02f, 2.40460578e-02f,
  -6.61297515e-02f, -2.08775941e-02f, -9.57679749e-02f, 3.71371098e-02f, 8.79846048e-03f, -3.36453356e-02f, 2.07591839e-02f, 1.21760508e-02f, -1.90355536e-02f, -5.21302670e-02f,
  1.79624651e-02f, 2.50962824e-02f, -2.41817310e-02f, -3.38611193e-02f, -2.78569795e-02f, -1.13059372e-01f, 3.08498461e-03f, 4.50479425e-02f, 2.48625595e-02f, 5.08201048e-02f,
  7.68143162e-02f, 6.43827543e-02f, -5.13914935e-02f, 4.49377969e-02f, -4.92649339e-02f, -4.95235547e-02f, -6.53917193e-02f, 1.06521398e-02f, -5.02583850e-03f, 5.19660767e-04f,
  -2.50296127e-02f, 5.58740646e-02f, -7.90273920e-02f, -4.62913513e-02f, 7.87822902e-02f, 5.36852777e-02f, 1.55133912e-02f, 1.15673561e-02f, 1.64287873e-02f, -2.02193465e-02f,
  -5.03440388e-02f, -6.05519041e-02f, -1.15938783e-02f, 3.73564251e-02f, 3.73890214e-02f, 2.13333368e-02f, 8.13597888e-02f, -2.33637895e-02f, 1.07768908e-01f, 5.76393530e-02f,
  -1.64533705e-02f, -2.40607355e-02f, -8.82315356e-03f, 2.75961421e-02f, 4.04952355e-02f, 1.86457504e-02f, 3.49226687e-03f, -1.04578519e-02f, 3.56406458e-02f, 6.11180142e-02f,
  -8.93603452e-03f, 2.54550446e-02f, 1.24235079e-02f, -8.72411802e-02f, -1.05411224e-02f, -1.34129515e-02f, -9.20365155e-02f, 8.08850825e-02f, -6.56004325e-02f, 8.43852311e-02f,
  -1.07397400e-01f, 2.77290076e-01f, -1.92355871e-01f, -4.42000516e-02f, 1.03627890e-01f, -9.32318531e-03f, 6.20858790e-03f, 3.91867720e-02f, 2.40817927e-02f, 2.51876354e-01f,
  5.00024557e-02f, -4.49173301e-02f, 1.87030360e-01f, 1.19281679e-01f, -2.43360057e-01f, -6.78937808e-02f, 5.02371453e-02f, -8.25352892e-02f, 4.40848246e-02f, 1.80864334e-01f,
  -1.44237489e-01f, 2.22574458e-01f, -6.02121875e-02f, 8.04307088e-02f, 1.05660204e-02f, -8.03424269e-02f, 9.31932703e-02f, -1.02380350e-01f, 4.87433486e-02f, -3.72305587e-02f,
  8.94429013e-02f, 1.35403618e-01f, 6.75538853e-02f, 3.55502330e-02f, 6.11010566e-02f, 6.38296828e-02f, -1.63723603e-02f, -6.16442822e-02f, -1.06545679e-01f, -4.69801482e-03f,
  -2.38568801e-02f, -3.37089342e-03f, -1.13482766e-01f, -1.43178860e-02f, 1.08722270e-01f, 9.13984794e-03f, 1.78804621e-02f, -2.85428502e-02f, 7.75040709e-04f, -6.92205057e-02f,
  4.89039160e-02f, 2.31652358e-03f, 3.46604735e-02f, -2.02530064e-02f, -2.15674639e-02f, 4.95814420e-02f, -6.49487153e-02f, -9.15678665e-02f, 1.80062130e-02f, -4.13868716e-03f,
  -4.04651873e-02f, 5.27375452e-02f, 3.21979634e-02f, 4.50091846e-02f, 3.45365480e-02f, -4.25017253e-02f, 8.73178989e-02f, 2.85059642e-02f, -3.31543833e-02f, 4.73724529e-02f,
  -2.58155745e-02f, 2.05599330e-02f, 1.04977225e-03f, -1.32860439e-02f, -8.58933199e-03f, -2.06861682e-02f, -1.49659794e-02f, 2.30379701e-02f, 3.83531563e-02f, -5.03610224e-02f,
  2.04219762e-02f, 3.94131206e-02f, -3.45958434e-02f, -5.79385236e-02f, 4.45577949e-02f, 8.68441351e-03f, 8.24502949e-03f, -5.93519844e-02f, 5.05357124e-02f, -2.21029576e-02f,
  2.93284953e-01f, 1.70127288e-01f, 1.52987823e-01f, 6.20513931e-02f, -4.63259348e-04f, -2.80060600e-02f, 1.08418260e-02f, -5.44863753e-03f, 1.04600891e-01f, 4.10072431e-02f,
  7.98502639e-02f, 6.33161291e-02f, 2.76892092e-02f, -6.17651343e-02f, 4.45437580e-02f, 3.48427221e-02f, 6.33257926e-02f, 7.34608844e-02f, 1.62929952e-01f, 1.14367031e-01f,
  2.03078948e-02f, 4.50364426e-02f, -7.89882317e-02f, -5.05806804e-02f, -9.24186632e-02f, 3.23613696e-02f, -8.35219584e-03f, -2.66056526e-02f, -4.07830477e-02f, 3.04337256e-02f,
  1.77415580e-01f, -4.37170178e-01f, -8.83644670e-02f, -3.73350233e-01f, 1.03450775e-01f, 2.92996392e-02f, 4.19320017e-02f, -1.54628173e-01f, -1.32436022e-01f, -1.09729685e-01f,
  -7.69058838e-02f, 1.24677703e-01f, 2.21680310e-02f, -3.35419387e-01f, 2.87804633e-01f, -1.31261468e-01f, -2.76001513e-01f, -6.42573982e-02f, 4.27255668e-02f, -1.65969878e-01f,
  -3.05289887e-02f, -2.47322142e-01f, -1.27855912e-01f, -9.27183330e-02f, -2.29404923e-02f, -3.84665839e-02f, -2.54148617e-02f, 1.44178018e-01f, -1.41444862e-01f, 1.65111735e-01f,
  7.27990046e-02f, -1.18498720e-01f, -7.73293748e-02f, 1.02379777e-01f, 2.95735255e-04f, 4.57681529e-02f, 5.61361164e-02f, 9.47734714e-02f, 6.56530038e-02f, 4.45396453e-02f,
  2.31335051e-02f, 4.78356890e-02f, -2.16968637e-03f, 1.81387346e-02f, -2.93419254e-03f, 2.21301578e-02f, 4.30595502e-02f, -6.13343902e-02f, -6.01913221e-02f, 3.45297381e-02f,
  -2.97340043e-02f, -5.04404679e-02f, -5.88349961e-02f, 5.51831760e-02f, -4.78848210e-03f, 4.09173267e-03f, -8.48974939e-03f, 5.96166141e-02f, 3.93977091e-02f, -5.95772685e-03f,
  1.42773464e-01f, 2.30993517e-02f, -2.90354416e-02f, 4.86377627e-02f, -3.55417021e-02f, -2.47668102e-02f, -8.15861672e-03f, 2.57618558e-02f, -1.27108088e-02f, -1.15969311e-02f,
  -3.91836651e-02f, -2.57975888e-02f, -2.08153818e-02f, -2.86937393e-02f, -9.06506330e-02f, -3.11723147e-02f, 4.65357862e-02f, -1.87154878e-02f, -2.55024433e-02f, 1.69333965e-02f,
  5.62960282e-02f, -1.06443530e-02f, -6.70366036e-03f, 1.99604537e-02f, -1.78520251e-02f, 6.93159029e-02f, -3.38306725e-02f, -1.30503001e-02f, 1.09653147e-02f, 4.43468094e-02f,
  -7.98185393e-02f, -2.07367823e-01f, 4.33369651e-02f, 9.15160216e-03f, -6.22795615e-03f, -3.50263119e-02f, -5.64963967e-02f, 5.82464784e-02f, 9.81073547e-03f, -8.70143156e-03f,
  2.33056042e-02f, -1.77709311e-02f, -2.79225153e-03f, -7.92065449e-03f, 2.20735166e-02f, -2.26468686e-03f, -5.75703904e-02f, 5.49735427e-02f, -6.26662094e-03f, 3.33961449e-03f,
  6.02017203e-03f, 2.81594992e-02f, 1.19044304e-01f, -7.94109032e-02f, -1.31337624e-02f, 9.50125828e-02f, 2.84956973e-02f, 2.78133098e-02f, 4.78349924e-02f, -1.81437898e-02f,
  -2.69325912e-01f, 1.81659311e-01f, -1.69568602e-02f, -1.86926603e-01f, -5.56247346e-02f, -2.14609459e-01f, -1.52338549e-01f, -1.50560560e-02f, -1.95029348e-01f, 1.07770629e-01f,
  -1.40124392e-02f, 6.53348267e-02f, 9.02687386e-02f, -8.67571160e-02f, -2.76145130e-01f, -6.51608109e-02f, -2.79044688e-01f, -5.11871502e-02f, -8.58879909e-02f, 2.03845296e-02f,
  -9.99529958e-02f, -2.53860820e-02f, 2.49220035e-03f, 6.67554960e-02f, 1.78422816e-02f, 1.38792679e-01f, 1.86980084e-01f, 8.35454985e-02f, -5.50851822e-02f, 5.65591939e-02f,
  -4.53247577e-02f, 5.23228049e-02f, 9.24566239e-02f, 4.45678458e-02f, -2.07480751e-02f, 2.04695296e-02f, 1.90679152e-02f, 3.75624225e-02f, 1.50866015e-02f, 2.23405436e-02f,
  3.27299833e-02f, -3.76724824e-02f, -9.40898359e-02f, 3.06626074e-02f, -4.25393544e-02f, -1.44513985e-02f, -3.32448371e-02f, -1.58178322e-02f, -3.27665359e-02f, 2.32061520e-02f,
  -9.86040607e-02f, -1.25280712e-02f, -8.22763294e-02f, -7.72329122e-02f, 2.35145446e-02f, -6.43604100e-02f, 1.11194449e-02f, 7.82282650e-03f, -5.65694124e-02f, -2.25935895e-02f,
  6.35794252e-02f, 7.91246071e-03f, 9.52024534e-02f, 1.55496951e-02f, -4.29716483e-02f, 5.07607795e-02f, -4.87108491e-02f, 2.82642320e-02f, -3.45497057e-02f, -4.02336903e-02f,
  -2.67559756e-02f, -1.54920965e-02f, -6.27927929e-02f, -1.31832324e-02f, -3.91372256e-02f, -3.88775058e-02f, -6.45164726e-03f, 1.20161725e-02f, -6.98353127e-02f, -6.93034828e-02f,
  -1.66368037e-02f, -1.42961787e-02f, 2.32027541e-03f, 1.01435870e-01f, -7.44493604e-02f, 4.42415886e-02f, 2.70617846e-02f, -5.12345694e-02f, -3.54814529e-02f, -8.07294250e-03f,
  -1.60619002e-02f, 4.57286797e-02f, 1.80729870e-02f, -6.39861152e-02f, -3.22893634e-02f, 1.43368868e-02f, -3.76965962e-02f, -1.41163431e-02f, 2.35220566e-02f, -4.59207147e-02f,
  3.61030512e-02f, 1.48014408e-02f, 7.16371238e-02f, 1.35427406e-02f, 5.18762805e-02f, 5.07823154e-02f, 2.84293666e-02f, -6.55422062e-02f, 2.83584390e-02f, 1.24369441e-02f,
  5.73654473e-02f, -7.02879876e-02f, 1.63134299e-02f, 6.72086254e-02f, -7.62396976e-02f, 8.29190463e-02f, 1.31828357e-02f, -2.69816574e-02f, 9.21828449e-02f, 4.12254147e-02f,
  3.81552540e-02f, -2.04156563e-02f, -7.02616051e-02f, -7.22434595e-02f, 3.81615236e-02f, 1.11110091e-01f, 1.82046499e-02f, 2.40702912e-01f, 3.58749437e-03f, -1.84789542e-02f,
  -3.03201806e-02f, -1.19807571e-01f, -2.01630145e-01f, 1.51651710e-01f, -5.74298352e-02f, -2.39421070e-01f, 1.75468415e-01f, -3.09208017e-02f, -1.21560507e-01f, 8.04975927e-02f,
  -2.52334625e-02f, 9.01449174e-02f, -4.46507186e-02f, 1.92822427e-01f, 8.34186673e-02f, -1.20739356e-01f, -4.91279289e-02f, -6.78611994e-02f, 1.07977293e-01f, -4.77620065e-02f,
  7.81895295e-02f, -5.66592030e-02f, 7.72749782e-02f, 6.18741941e-03f, -4.79284637e-02f, 6.68211058e-02f, -4.07690704e-02f, -4.04128022e-02f, -4.86822091e-02f, 3.91153432e-02f,
  -5.91991805e-02f, 1.58566125e-02f, -3.52075286e-02f, 9.52623785e-03f, 1.66916605e-02f, -2.55613141e-02f, -5.40072545e-02f, -9.91414115e-02f, -3.48198153e-02f, -4.30639535e-02f,
  2.13493556e-02f, -4.71113138e-02f, 7.21977949e-02f, 2.95153800e-02f, -8.45460817e-02f, 8.64097569e-03f, -1.73739698e-02f, 3.31217572e-02f, -3.20239328e-02f, -6.49126843e-02f,
  2.61986498e-02f, -8.47032145e-02f, 4.03982662e-02f, 8.38340819e-02f, 1.07380953e-02f, -1.45327821e-02f, -3.92234605e-03f, 6.11201003e-02f, 6.35359064e-02f, -2.62080170e-02f,
  9.01912674e-02f, -5.35604693e-02f, 7.25602135e-02f, 6.96219280e-02f, 7.69720227e-02f, 2.88915448e-02f, -7.06593543e-02f, -1.33104641e-02f, 8.76949131e-02f, 4.31855842e-02f,
  -4.16633077e-02f, 2.82855425e-02f, -6.46487996e-02f, -3.56289521e-02f, 9.37662274e-02f, -2.07592025e-02f, -3.19620669e-02f, -3.70663442e-02f, 6.45215064e-02f, -6.02077181e-03f,
  -3.97702418e-02f, -1.27746791e-01f, -2.45878920e-02f, 5.05977869e-02f, 2.30208244e-02f, 1.37480795e-02f, 2.03554537e-02f, 4.39519696e-02f, -3.40768918e-02f, 6.00486808e-03f,
  1.25810772e-01f, 1.31671345e-02f, -1.97323393e-02f, 5.09074889e-02f, -2.58928724e-02f, 6.81317225e-02f, -3.13999131e-02f, 2.51875557e-02f, 4.14908640e-02f, -3.63071673e-02f,
  -1.01435468e-01f, -3.28869149e-02f, 5.96057624e-02f, 2.03681365e-02f, 6.63415343e-02f, -3.76225598e-02f, 5.07685281e-02f, -7.58562014e-02f, -1.55004216e-02f, 1.61860920e-02f,
  -2.77766854e-01f, 5.34631545e-03f, -1.62044931e-02f, 4.57724370e-02f, 3.21758509e-01f, 5.33224866e-02f, -2.52571478e-02f, 2.03569576e-01f, 1.21925943e-01f, 2.85703931e-02f,
  1.08910315e-01f, -1.55777305e-01f, -2.22704541e-02f, 1.66614098e-03f, -2.62430638e-01f, -2.30453983e-01f, -3.61611694e-02f, 5.14657889e-03f, -4.81924713e-02f, 9.51423123e-02f,
  -4.73806933e-02f, 4.73616533e-02f, -1.94155246e-01f, 1.01362310e-01f, 2.55581625e-02f, 7.54030123e-02f, 7.96438977e-02f, -2.19931938e-02f, 6.24584891e-02f, 3.68381356e-04f,
  -1.27351671e-01f, 4.30359729e-02f, -1.04959019e-01f, -8.53264257e-02f, 1.87788047e-02f, 2.39184778e-02f, -6.68097287e-02f, -8.39484558e-02f, -8.47928412e-03f, -2.38570832e-02f,
  -1.97725203e-02f, -2.68024802e-02f, 1.10045142e-01f, 8.64362568e-02f, 4.69480604e-02f, -1.77320782e-02f, 8.98408704e-03f, 4.76992689e-02f, 2.52500139e-02f, -1.11813463e-01f,
  -1.43302148e-02f, -3.46807353e-02f, 5.71345203e-02f, -3.27247567e-02f, -4.32763342e-03f, 3.49859931e-02f, 3.27378474e-02f, -7.30227903e-02f, -1.31307193e-03f, 5.43597853e-03f,
  -5.03400760e-03f, -1.07178017e-01f, 6.46740794e-02f, -6.86171353e-02f, 2.50259954e-02f, 5.72143942e-02f, -2.43942812e-02f, -2.51578167e-02f, -5.81538081e-02f, 2.62539811e-03f,
  -2.03957930e-02f, -4.18981835e-02f, 8.80337805e-02f, -1.14178307e-01f, -6.75836131e-02f, -4.25188132e-02f, -9.29105505e-02f, -6.24266360e-03f, 3.31923254e-02f, -1.31294876e-01f,
  3.35052125e-02f, 8.83085132e-02f, -4.95398743e-03f, 7.83010945e-02f, -3.85770611e-02f, 7.92463273e-02f, 1.10055000e-01f, 9.37014073e-02f, 3.90215358e-03f, -5.70208244e-02f,
  1.02431230e-01f, 1.59480065e-01f, 6.84525669e-02f, 8.54830369e-02f, 1.25246337e-02f, -6.70628324e-02f, 4.00751596e-03f, 8.21598396e-02f, -5.27799241e-02f, 3.78328189e-02f,
  -6.12133741e-03f, 4.22426946e-02f, -5.66076394e-03f, -3.67056206e-02f, -6.00013509e-03f, 5.69917001e-02f, -9.43977907e-02f, -5.56791872e-02f, 7.48583227e-02f, -7.00630322e-02f,
  4.21791747e-02f, 5.40104173e-02f, -4.93493266e-02f, 7.13446662e-02f, 7.83148631e-02f, 1.82227138e-02f, -1.60754956e-02f, -4.05190140e-02f, -1.11851515e-02f, -1.67372860e-02f,
  1.32993385e-01f, -1.17792897e-01f, 1.43148080e-01f, -9.61017907e-02f, -5.13791703e-02f, -1.93465948e-01f, -1.78774402e-01f, -1.87545434e-01f, -3.49864125e-01f, -2.85240114e-01f,
  -1.26600146e-01f, -5.90281654e-03f, 6.40093535e-03f, -1.91335812e-01f, 2.08204985e-01f, -7.15089440e-02f, -1.28301829e-01f, -8.70095491e-02f, -5.96060529e-02f, -2.77202632e-02f,
  8.29483122e-02f, -1.46939948e-01f, 1.83110356e-01f, -3.15689258e-02f, 2.79854005e-03f, 8.88346229e-03f, 1.32158831e-01f, 1.15559004e-01f, 7.51778716e-03f, -7.66418055e-02f,
  8.95407870e-02f, 1.32538125e-01f, 6.73083067e-02f, 5.24445288e-02f, 9.82523616e-03f, 1.22901537e-01f, 1.24349535e-01f, 9.32169259e-02f, 9.38453376e-02f, 7.82985333e-03f,
  4.85357568e-02f, 9.74534303e-02f, -1.83867365e-02f, -8.61834958e-02f, -1.36403844e-01f, -5.08773662e-02f, 2.29822621e-02f, -7.99595937e-02f, 2.60058213e-02f, 8.68433043e-02f,
  2.51717698e-02f, 4.95415330e-02f, -1.06249951e-01f, 2.73198839e-02f, 2.15218645e-02f, -1.18759625e-01f, -1.84672028e-02f, -2.24984046e-02f, -3.54389362e-02f, -3.02595925e-02f,
  3.96110336e-05f, 6.03640750e-02f, -1.68526340e-02f, -7.49428049e-02f, -3.11079845e-02f, -1.57720204e-02f, -1.82144828e-02f, 3.09234913e-02f, 3.47224548e-02f, -5.78636006e-02f,
  -8.79582986e-02f, -2.85372436e-02f, 1.13009494e-02f, -4.11408283e-02f, -6.75439695e-03f, -1.32276759e-01f, -2.05845125e-02f, -5.12013920e-02f, -8.73133540e-02f, -8.63469467e-02f,
  6.38793269e-03f, 7.09963497e-04f, -7.13540707e-04f, 9.40871984e-03f, 3.92815704e-03f, 2.04731710e-02f, 1.24549177e-02f, -4.23154943e-02f, 3.77690904e-02f, 5.84286526e-02f,
  -4.65063751e-02f, 4.44135368e-02f, -1.61601193e-02f, 1.41272424e-02f, 4.18811012e-03f, 5.16047403e-02f, -3.39126661e-02f, -5.28790168e-02f, -1.10398615e-02f, 6.62926584e-02f,
  -4.36101891e-02f, -1.01157883e-03f, 8.09293315e-02f, 8.60470254e-03f, 1.80987921e-02f, -3.29817869e-02f, 7.01992810e-02f, 1.39090689e-02f, -5.63418306e-03f, -5.07472195e-02f,
  6.45775674e-03f, -5.75832371e-03f, 9.08228755e-02f, -3.32289748e-02f, 5.23082819e-03f, -8.16573873e-02f, -7.17755184e-02f, 6.51340745e-03f, -3.58391111e-03f, 2.20269803e-02f,
  4.04356331e-01f, -2.22936556e-01f, -2.68989652e-01f, 8.95650685e-02f, 2.45326787e-01f, 1.38945982e-01f, 9.26186666e-02f, 4.45351526e-02f, 2.38873437e-01f, -7.92347640e-02f,
  -5.53205013e-02f, -9.30313021e-02f, -2.06274256e-01f, -5.96943833e-02f, 1.22195132e-01f, -1.24660999e-01f, 1.05155595e-01f, 3.98983955e-02f, 5.02403043e-02f, 4.27011102e-02f,
  6.89170435e-02f, 9.02170911e-02f, -2.23890260e-01f, -3.66246440e-02f, 6.87521696e-03f, -1.83424186e-02f, -3.92825156e-02f, -7.83286765e-02f, -1.24937803e-01f, -4.88273017e-02f,
  -3.96134444e-02f, -7.24453572e-03f, 5.18629402e-02f, -5.66929579e-02f, 4.37822659e-04f, -1.32881003e-02f, 1.43664591e-02f, -5.16940169e-02f, 8.20830017e-02f, 2.18022112e-02f,
  -6.88029751e-02f, 5.39949455e-04f, -7.49948202e-03f, -2.76628900e-02f, 9.29832384e-02f, 3.08959577e-02f, -4.94010001e-02f, 5.26537299e-02f, 1.19050480e-02f, 3.18163075e-02f,
  -7.58976415e-02f, -6.67433366e-02f, 1.79124121e-02f, -9.97185931e-02f, 5.89824934e-03f, 5.06696589e-02f, 4.93581966e-02f, -3.82914237e-04f, 2.45873705e-02f, -2.05413010e-02f,
  7.02188862e-03f, 8.85242876e-03f, -2.43791081e-02f, -7.29614645e-02f, 2.68167108e-02f, 1.05784032e-02f, 3.97888664e-03f, -2.66967975e-02f, -2.24267393e-02f, -5.78565076e-02f,
  1.09844757e-02f, 2.43778713e-02f, -6.27331808e-02f, 6.43685460e-02f, 7.40233809e-02f, -7.36470707e-03f, -6.73137233e-02f, 2.67992797e-03f, 1.83619037e-02f, 1.17231603e-03f,
  -1.59291923e-02f, 3.18465345e-02f, -1.01694338e-01f, -6.55073822e-02f, 8.65607616e-03f, -4.40551639e-02f, 5.01686335e-03f, -6.39406741e-02f, -5.90584502e-02f, -1.86972283e-02f,
  -3.89540638e-03f, 3.10053322e-02f, -6.31926581e-02f, 5.31978207e-03f, -4.74335477e-02f, -3.14909630e-02f, -8.13766271e-02f, 6.40402213e-02f, 1.77525375e-02f, 3.82634550e-02f,
  5.67848049e-02f, -3.25460499e-03f, 7.99934044e-02f, -5.92103340e-02f, -2.64466107e-02f, 3.05535831e-02f, -1.64665394e-02f, 3.47347483e-02f, 7.73261115e-02f, -6.32094443e-02f,
  4.93631214e-02f, 3.35519724e-02f, -3.18365060e-02f, 1.93436425e-02f, 4.20888662e-02f, -4.48054858e-02f, 7.07016587e-02f, -4.83883210e-02f, 1.66288558e-02f, -2.39846837e-02f,
  -1.62291065e-01f, 1.54107869e-01f, 2.84555197e-01f, -8.91311616e-02f, -1.23290397e-01f, -2.81140149e-01f, -1.53279409e-01f, 3.64249237e-02f, 1.04962900e-01f, -4.65904139e-02f,
  -2.17406545e-02f, 9.56208557e-02f, 1.19678833e-01f, -1.66849103e-02f, -9.71596837e-02f, 5.39561585e-02f, -8.72461572e-02f, -7.90257752e-03f, 1.12594344e-01f, -2.44453028e-02f,
  -3.11577935e-02f, -2.17081264e-01f, 3.94294895e-02f, 2.38081850e-02f, -8.44613612e-02f, 7.07040280e-02f, -2.14051772e-02f, 5.28404340e-02f, -1.48984894e-01f, -1.09793089e-01f,
  3.35357897e-02f, 3.85616161e-02f, 6.45859390e-02f, 1.26115475e-02f, -9.11735445e-02f, -7.23865349e-03f, -5.20447865e-02f, -2.85827667e-02f, -4.92610224e-03f, -5.06075099e-02f,
  -5.64202783e-04f, 3.41479145e-02f, -8.88634101e-02f, 3.33191603e-02f, -8.02445877e-03f, 5.54575361e-02f, -4.05150317e-02f, -4.61680861e-03f, 9.34639424e-02f, 4.68262434e-02f,
  1.09328680e-01f, 1.65548120e-02f, -2.11867914e-02f, 6.84445128e-02f, -4.86651659e-02f, 9.66615975e-03f, 1.58152878e-02f, 5.75968325e-02f, 1.15577597e-02f, 5.47135994e-02f,
  -8.71511251e-02f, -3.54038402e-02f, 2.56200638e-02f, 3.42481285e-02f, -1.39651238e-03f, 4.88087535e-03f, 3.18149244e-03f, -6.02772236e-02f, 2.51892824e-02f, -4.70495857e-02f,
  2.50600204e-02f, 4.69206087e-02f, -8.36639777e-02f, 6.50202483e-02f, -4.36082706e-02f, 9.48333740e-02f, 1.38794689e-03f, 5.15537262e-02f, -4.43125740e-02f, 6.49779886e-02f,
  -7.80815538e-03f, 4.66505550e-02f, 5.49835041e-02f, -2.92867012e-02f, 9.21943858e-02f, 6.78671375e-02f, 6.04636148e-02f, -6.86959410e-03f, 3.01651955e-02f, 2.34425608e-02f,
  -1.21195287e-01f, -1.41289458e-01f, 4.89569381e-02f, 2.84398608e-02f, -1.70182325e-02f, -1.15917392e-01f, 1.01885267e-01f, 5.81079759e-02f, -1.20820306e-01f, 4.60192859e-02f,
  -4.87262681e-02f, 2.47971490e-02f, -7.04743266e-02f, 8.17853212e-02f, 1.39923599e-02f, -1.46703632e-03f, -1.43702999e-01f, -4.45167460e-02f, -9.51106399e-02f, -2.31472254e-02f,
  -3.18984129e-02f, -3.34640443e-02f, 7.46704340e-02f, -6.96390197e-02f, -2.29112227e-02f, 3.07825897e-02f, -4.38176244e-02f, 1.02386445e-01f, -8.52758214e-02f, -7.44950399e-02f,
  1.60777166e-01f, -3.54860574e-02f, 3.57519507e-01f, 1.34229839e-01f, -1.55155389e-02f, 1.49367799e-04f, 4.32304069e-02f, 1.36012748e-01f, 1.24382362e-01f, -2.51898885e-01f,
  -8.81278664e-02f, -3.82730290e-02f, 1.14798032e-01f, -2.42484659e-01f, 2.50949621e-01f, 2.30616421e-01f, 2.55239126e-03f, -8.75978619e-02f, 1.64381653e-01f, 8.74434114e-02f,
  1.57320604e-01f, -2.00911075e-01f, 1.37515172e-01f, -1.45430127e-02f, -1.29935339e-01f, -2.87552364e-02f, -1.29710972e-01f, 5.54908887e-02f, -2.06641555e-01f, -5.33456355e-02f,
  -7.79030025e-02f, 7.60101229e-02f, 1.13242812e-01f, -1.16977599e-02f, -1.50251025e-02f, -4.95663360e-02f, -1.00910932e-01f, -4.90423627e-02f, -2.75360513e-02f, 2.33703163e-02f,
  -4.99805156e-03f, -6.51569217e-02f, -4.75444458e-02f, 6.68914872e-04f, 2.70057041e-02f, 7.86614884e-03f, 5.73426560e-02f, -3.43451351e-02f, 3.57873105e-02f, -3.94108593e-02f,
  4.63825241e-02f, -5.63383736e-02f, 3.32535654e-02f, -4.14933711e-02f, 8.16675499e-02f, -4.49990295e-02f, 6.06984049e-02f, -7.98617117e-03f, 1.98011510e-02f, -2.24178638e-02f,
  -4.01939005e-02f, -8.51254910e-03f, -2.72076763e-02f, 1.05038788e-02f, -3.06460615e-02f, -3.04303505e-02f, -7.84567669e-02f, -6.37094975e-02f, 7.88779557e-03f, -8.00442882e-03f,
  2.51096059e-02f, 1.39047820e-02f, -9.25160050e-02f, -1.85655337e-02f, -2.68257735e-03f, 2.30863728e-02f, 4.73795161e-02f, -1.88792814e-02f, -1.39096240e-02f, -5.66074671e-03f,
  -3.27950381e-02f, 5.92218712e-03f, -8.12213272e-02f, -6.19267784e-02f, -7.40745589e-02f, 4.72900420e-02f, -1.36559218e-01f, 2.25730110e-02f, -2.85297185e-02f, 2.25505996e-02f,
  5.68498597e-02f, 3.50617170e-02f, -1.29097002e-02f, -3.50859091e-02f, 5.03705256e-02f, -2.74356492e-02f, -1.25623625e-02f, 1.32474713e-02f, 5.78147173e-03f, 8.49134773e-02f,
  -9.65988711e-02f, -8.87659658e-03f, -3.24517526e-02f, -8.28135684e-02f, 5.62209673e-02f, 2.12298594e-02f, 4.94298935e-02f, -3.17798704e-02f, 3.85014154e-02f, 2.14916393e-02f,
  3.46332625e-03f, -3.47467442e-03f, 6.39221668e-02f, 1.09946728e-02f, -1.15415499e-01f, -7.75413495e-03f, -2.54660491e-02f, -3.61779053e-03f, 3.76882521e-03f, 2.43448745e-02f,
  -1.65990353e-01f, 2.10216790e-01f, -1.04091778e-01f, -1.78447589e-01f, -8.65617841e-02f, 7.63438866e-02f, -1.90391898e-01f, 1.55993655e-01f, -1.13232858e-01f, 1.41485050e-01f,
  -7.88504723e-03f, -1.77156672e-01f, 1.55830190e-01f, 1.00764735e-02f, 1.58334553e-01f, 3.32311504e-02f, 1.08369827e-01f, -4.04702546e-03f, 5.32430876e-03f, 1.32542565e-01f,
  8.41650292e-02f, -1.46970563e-02f, 1.03179902e-01f, 9.43456218e-02f, -4.25674282e-02f, -1.37471840e-01f, 8.24750438e-02f, -5.71646634e-03f, 7.82051906e-02f, -1.02961175e-01f,
  1.17754892e-01f, -9.97226909e-02f, -9.92443636e-02f, 1.08760364e-01f, 8.06292966e-02f, -5.05741278e-04f, -4.42408491e-03f, -8.51758718e-02f, -1.12487584e-01f, 1.79845467e-02f,
  4.50407118e-02f, 6.29527196e-02f, -6.06024265e-02f, -3.02695110e-02f, 4.37066890e-02f, -2.58987304e-02f, 8.67036432e-02f, 1.01480581e-01f, -2.98666451e-02f, -4.52181734e-02f,
  8.41497723e-03f, 7.51385838e-02f, 6.50993809e-02f, -2.79652197e-02f, 5.25549520e-03f, -6.93108216e-02f, -8.00758600e-02f, -6.14173003e-02f, -2.95300013e-03f, -2.20552590e-02f,
  -8.02477151e-02f, 1.07618067e-02f, 3.51577848e-02f, -1.20514100e-02f, 7.11980388e-02f, -6.18202500e-02f, 4.13094983e-02f, -3.11998110e-02f, 3.97747122e-02f, 3.71562243e-02f,
  -2.14752890e-02f, -2.45252587e-02f, 2.09772382e-02f, 5.01798317e-02f, -3.01928148e-02f, -3.29951756e-02f, -4.44927216e-02f, -6.23006048e-03f, -5.63232647e-03f, 3.98137681e-02f,
  -9.11056995e-03f, 1.16310976e-02f, -3.93490158e-02f, -4.47736084e-02f, -2.78806151e-03f, 4.33792779e-03f, 8.46015513e-02f, 2.54374798e-02f, -4.68438640e-02f, 2.16582287e-02f,
  2.17080876e-01f, 1.62465394e-01f, -4.02143896e-02f, -1.97737720e-02f, 5.24632931e-02f, 1.38966348e-02f, 5.61881112e-03f, 1.71065368e-02f, 1.38309658e-01f, 1.48423249e-02f,
  1.03689194e-01f, -4.76717688e-02f, 3.53133045e-02f, -6.11107983e-02f, -1.25185885e-02f, 9.81975198e-02f, -4.88476492e-02f, 9.97073650e-02f, 1.15765203e-02f, 1.31344154e-01f,
  1.03247322e-01f, -8.53368416e-02f, -4.63551916e-02f, 1.45043922e-03f, -2.25121025e-02f, 5.20147569e-02f, -1.73783936e-02f, -6.29099458e-02f, 7.85015598e-02f, 7.98597261e-02f,
  -6.75004199e-02f, -3.57451178e-02f, 2.20004305e-01f, -1.85285583e-01f, -7.86915943e-02f, -2.37759933e-01f, -1.93169490e-01f, -1.65143609e-01f, -2.89063990e-01f, -9.93179679e-02f,
  -1.11301318e-01f, 1.03455922e-02f, 1.23491451e-01f, -1.89572871e-01f, 5.54495528e-02f, -8.52436423e-02f, -2.28904963e-01f, -6.50260597e-02f, -1.13070004e-01f, 1.04049459e-01f,
  -3.52284536e-02f, -3.52352299e-02f, 1.93039611e-01f, 4.86119650e-02f, -6.81181103e-02f, 1.43172964e-01f, 2.26037651e-01f, 5.08824959e-02f, 1.13496341e-01f, -1.18049040e-01f,
  -1.74637362e-01f, -1.20635122e-01f, 7.05681567e-04f, 1.93705130e-02f, 9.36279744e-02f, -2.48394944e-02f, 1.05784565e-01f, 1.05901733e-02f, -3.64511088e-02f, -1.02817306e-04f,
  5.09983301e-02f, 6.05156906e-02f, -3.51742990e-02f, -7.16185570e-02f, 9.48140770e-03f, -8.90962966e-03f, 3.09950020e-02f, -9.45996270e-02f, -3.61321755e-02f, -9.64841526e-03f,
  1.96152311e-02f, -8.78874809e-02f, 1.29937399e-02f, 3.06666214e-02f, 1.87919848e-02f, -7.50105903e-02f, 1.15241797e-03f, 6.43004552e-02f, -1.19707696e-01f, -4.68932278e-02f,
  1.46836583e-02f, -6.43710047e-02f, 4.25181538e-02f, -5.46360239e-02f, 9.93725806e-02f, -4.56091315e-02f, 4.22939807e-02f, 3.06189470e-02f, 2.55957562e-02f, 5.48474826e-02f,
  9.69332922e-03f, -2.71860715e-02f, -5.12262695e-02f, 8.04263353e-03f, -1.80162732e-02f, -7.97516927e-02f, 5.16631417e-02f, -4.35213335e-02f, -4.41111140e-02f, 4.28810250e-03f,
  -4.49840724e-02f, -2.85164770e-02f, 1.18722143e-02f, -7.15321861e-03f, -7.62389228e-02f, 7.79093876e-02f, -7.53233908e-03f, -4.28038053e-02f, -2.08036173e-02f, 7.81502798e-02f,
  4.25656475e-02f, 1.34452030e-01f, -3.07608284e-02f, -7.10973293e-02f, 6.80178329e-02f, 3.95492092e-02f, -7.67017677e-02f, 1.17093874e-02f, 7.36629590e-02f, -2.73303315e-02f,
  7.50048533e-02f, 5.12136519e-03f, -3.32159773e-02f, 6.68166801e-02f, -2.12555006e-02f, -1.14379926e-02f, 3.42878662e-02f, 3.09998449e-03f, 1.55826081e-02f, 6.33617714e-02f,
  6.77257180e-02f, 6.21042885e-02f, -4.58110049e-02f, -2.05379035e-02f, 1.70019269e-02f, 3.64084318e-02f, 1.45516768e-02f, 1.53402612e-02f, 2.53165290e-02f, -1.88430343e-02f,
  -1.60705432e-01f, -7.95324370e-02f, -1.39548630e-01f, -6.79487064e-02f, -2.85453290e-01f, 2.46034246e-02f, 1.30528480e-01f, -1.37207121e-01f, -2.01679066e-01f, 1.75886527e-01f,
  5.82884960e-02f, 2.19977926e-02f, 2.43216336e-01f, -8.04878101e-02f, 1.47527382e-01f, 1.16108827e-01f, 7.48242158e-03f, -3.98210734e-02f, -1.88243032e-01f, -4.62419465e-02f,
  -4.78312047e-03f, 8.87942538e-02f, 7.33770207e-02f, -1.20593719e-01f, -1.20081037e-01f, -1.76268354e-01f, 1.24500468e-01f, -1.62681773e-01f, -1.43687651e-02f, -4.38785106e-02f,
  3.45061012e-02f, -9.72039476e-02f, -9.19173658e-02f, -5.10443151e-02f, -2.76727546e-02f, -9.95783694e-03f, 1.07555725e-01f, 6.63876534e-02f, -4.92513068e-02f, 4.09250408e-02f,
  1.04534104e-01f, 1.92879755e-02f, -5.45532294e-02f, -3.65594216e-02f, -1.02154985e-01f, -7.56438002e-02f, -2.29686778e-02f, -4.77059297e-02f, -7.62114748e-02f, 1.62723660e-02f,
  -3.64726260e-02f, -1.47747591e-01f, -2.68319491e-02f, 1.27487749e-01f, -1.74882412e-02f, -8.81099179e-02f, 7.48367608e-02f, 6.89575747e-02f, -9.09527764e-03f, -4.66961041e-02f,
  -4.03888449e-02f, 6.58988894e-04f, -2.94184946e-02f, -1.35026556e-02f, -2.99090557e-02f, 4.24029343e-02f, -6.23155162e-02f, 3.24184410e-02f, -1.01173088e-01f, -3.46882753e-02f,
  2.86442302e-02f, -3.24809477e-02f, 4.48858365e-02f, -5.07931635e-02f, 4.04084623e-02f, 1.12641111e-01f, 8.64322335e-02f, 2.70407759e-02f, -1.38310129e-02f, 4.30526212e-03f,
  -5.67581318e-02f, -2.20942833e-02f, -1.12158908e-02f, 2.41557285e-02f, -9.82113648e-03f, -5.15558459e-02f, -2.37590224e-02f, -5.64882997e-03f, -6.14679344e-02f, 6.24915585e-03f,
  1.52993724e-02f, 1.00193471e-01f, 2.60977466e-02f, 7.68377781e-02f, -1.50917005e-02f, 5.74826300e-02f, -8.64689872e-02f, 1.85096432e-02f, -5.32210153e-03f, 3.71754542e-02f,
  -2.11763848e-03f, 6.84342384e-02f, 7.16983899e-02f, 2.84087937e-02f, 1.97780579e-02f, -2.11142655e-03f, 4.43510823e-02f, -5.00769466e-02f, -9.20914672e-03f, -5.02190590e-02f,
  7.80665353e-02f, 7.21680373e-02f, 1.17369648e-02f, 1.18623469e-02f, 1.44936573e-02f, 1.08827412e-01f, -3.43258344e-02f, 2.37965696e-02f, 4.09403704e-02f, 2.25324347e-03f,
  -1.92531228e-01f, 1.24876559e-01f, 2.26950362e-01f, 1.23947047e-01f, -2.01401204e-01f, -2.78185084e-02f, 8.28509182e-02f, -4.04362120e-02f, 7.31368810e-02f, -4.29396927e-02f,
  -1.45505592e-02f, 1.75542254e-02f, 1.19176336e-01f, 1.04480237e-01f, 2.68266201e-01f, 2.78940141e-01f, 1.64650500e-01f, 2.12352350e-03f, -1.11052850e-02f, 5.34176379e-02f,
  8.02371055e-02f, -9.58623663e-02f, 1.80516034e-01f, -1.20161057e-01f, -1.43938437e-01f, -1.38446510e-01f, -1.18043751e-01f, -8.54133293e-02f, -3.10440622e-02f, 1.14055455e-03f,
  -1.14713147e-01f, -7.21059442e-02f, 4.51464541e-02f, -2.48483047e-02f, -5.81217408e-02f, -2.86567528e-02f, -1.49207423e-02f, -2.48190165e-02f, -6.72511682e-02f, -2.40575764e-02f,
  -5.66822551e-02f, -7.61847273e-02f, 6.37451187e-02f, 2.01512501e-02f, -9.97009426e-02f, 2.55619138e-02f, 3.10827810e-02f, -4.39698808e-02f, 3.50969397e-02f, 1.20577877e-02f,
  1.10756435e-01f, 1.11387543e-01f, 5.63139394e-02f, 4.22638543e-02f, 8.26887488e-02f, -4.28783521e-02f, 9.26586688e-02f, 4.12345901e-02f, -9.86419991e-03f, 8.38216953e-03f,
  -4.81083132e-02f, -1.08705705e-03f, 1.27370553e-02f, -7.60893757e-03f, 5.49865104e-02f, -2.19184831e-02f, 2.66654510e-02f, -8.94177333e-02f, -1.78172234e-02f, -1.81950200e-02f,
  -4.97021712e-02f, 3.32258865e-02f, 3.11156944e-03f, 4.39928286e-02f, 2.31244024e-02f, -7.65774995e-02f, -5.91487512e-02f, -7.75595615e-03f, 1.21819384e-01f, -5.54215871e-02f,
  4.54364205e-03f, 6.76927119e-02f, 4.57448177e-02f, -6.40983582e-02f, -2.45100111e-02f, 8.55931193e-02f, 1.04135737e-01f, 1.67224370e-02f, 2.42927950e-02f, -1.89439226e-02f,
  -1.07173607e-01f, 1.23286672e-01f, 1.53704798e-02f, -2.58910693e-02f, -8.76067653e-02f, 1.08342454e-01f, -2.51665395e-02f, 1.99350379e-02f, 7.31458655e-03f, 3.37138809e-02f,
  -6.32206770e-03f, -8.99762809e-02f, -3.31401713e-02f, 4.25773226e-02f, -4.31651399e-02f, 1.09174535e-01f, 2.74478141e-02f, -2.13100435e-03f, -3.00174225e-02f, -4.28341478e-02f,
  -8.66933167e-02f, -1.19678490e-01f, -1.92535296e-02f, -6.85957149e-02f, -6.81478232e-02f, -2.48574652e-02f, -4.46165018e-02f, -2.06888895e-02f, 6.60922052e-03f, -2.43262053e-02f,
  1.49884433e-01f, 1.51893437e-01f, -1.33394986e-01f, -2.17740268e-01f, -2.92839333e-02f, 1.01699717e-01f, -7.71121383e-02f, -4.99583632e-02f, 1.61640458e-02f, 2.63460912e-02f,
  -1.65343493e-01f, 3.88385244e-02f, -4.11654748e-02f, -1.81348875e-01f, -1.98973671e-01f, -7.99580887e-02f, -1.50380984e-01f, -3.83123383e-02f, 6.75848350e-02f, 6.77269921e-02f,
  -1.17839803e-03f, -1.93237931e-01f, -8.54521394e-02f, 8.31030682e-02f, -2.16316874e-03f, 4.99992371e-02f, -1.40040264e-01f, -2.05116719e-02f, -1.27226666e-01f, -1.13452323e-01f,
  1.13546513e-01f, -6.21546507e-02f, -2.88369320e-02f, 8.91261250e-02f, 8.71553570e-02f, 7.35459626e-02f, 6.96186349e-02f, -5.47024757e-02f, -6.10847771e-02f, 1.58457756e-02f,
  9.18477327e-02f, 8.69685709e-02f, 3.01729003e-03f, -2.82616331e-03f, 5.68598099e-02f, -3.35169621e-02f, 1.82998925e-02f, -6.15843944e-02f, 5.34591191e-02f, -7.24575371e-02f,
  -5.43352477e-02f, -8.20136890e-02f, -3.00457161e-02f, -6.28574751e-03f, -9.16895643e-02f, -1.08926162e-01f, -3.25079598e-02f, 2.33550891e-02f, 5.54856360e-02f, -2.88755749e-03f,
  -7.50748739e-02f, 6.03201874e-02f, -2.53011845e-02f, 4.37922962e-03f, 2.74453983e-02f, -8.91737714e-02f, 1.19323693e-02f, -8.20553303e-02f, 2.00575609e-02f, 3.30930389e-03f,
  1.89144723e-02f, -3.02824210e-02f, -9.22610145e-03f, 9.57642943e-02f, -7.87278637e-02f, -2.56151054e-02f, 3.13824937e-02f, 3.41232419e-02f, 1.17522255e-02f, -5.71378246e-02f,
  -4.98658232e-02f, -4.16139141e-02f, -3.90124731e-02f, 2.31101941e-02f, -2.60086600e-02f, -4.87824529e-03f, -3.46546527e-03f, -8.49828962e-03f, 2.39860918e-03f, -2.66841259e-02f,
  2.42581129e-01f, 1.39314041e-01f, -5.14935255e-02f, -3.50586399e-02f, -5.57713537e-03f, -4.61304113e-02f, -1.38383154e-02f, 8.39262009e-02f, -6.00023419e-02f, 8.45828280e-03f,
  -5.95827494e-03f, -9.83134657e-02f, 9.84087810e-02f, 5.59947938e-02f, -2.85765026e-02f, 5.09092060e-04f, -3.85673679e-02f, 7.61819035e-02f, -7.75871202e-02f, 2.47854758e-02f,
  -4.98233875e-03f, 9.19638202e-02f, -2.88766474e-02f, 2.06797924e-02f, 1.28960246e-02f, 1.64473001e-02f, 9.71077681e-02f, -1.17552852e-04f, -3.97174992e-03f, -5.35689332e-02f,
  -1.62572324e-01f, -1.53922781e-01f, -1.95037231e-01f, -1.48273021e-01f, -5.29067740e-02f, 1.15688860e-01f, 7.98720419e-02f, -1.63129255e-01f, -1.31339371e-01f, 1.16287939e-01f,
  1.10547833e-01f, -5.79322428e-02f, 1.85355201e-01f, -3.56596969e-02f, 9.36668739e-02f, 9.36855748e-02f, -1.29957303e-01f, -5.25680594e-02f, -5.67157455e-02f, -1.57220885e-01f,
  -1.52655512e-01f, -1.20985061e-02f, -8.75161812e-02f, -1.89509034e-01f, -2.57305540e-02f, -7.50199929e-02f, 8.49035978e-02f, -5.47764227e-02f, -1.55868351e-01f, -2.76409159e-03f,
  -3.35715227e-02f, 1.89176714e-03f, -3.02804336e-02f, 1.86898895e-02f, -6.06113262e-02f, 1.01162970e-01f, 4.76438478e-02f, 6.37624562e-02f, -4.17899154e-02f, 6.19378239e-02f,
  4.17404510e-02f, -1.20264012e-02f, -5.58639280e-02f, -1.22764213e-02f, -1.20534450e-01f, -1.14011213e-01f, -2.92981118e-02f, -3.43155302e-02f, -9.33877937e-03f, 2.52346206e-03f,
  2.83014905e-02f, 3.25705186e-02f, -3.69403325e-02f, -9.67887137e-03f, -4.12625521e-02f, -1.65105760e-02f, 1.08965144e-01f, -2.44865306e-02f, 1.36350477e-02f, -4.07714359e-02f,
  -3.23679559e-02f, -2.51159016e-02f, 2.14508735e-02f, 3.14595364e-02f, 5.26033691e-04f, 3.68317068e-02f, 1.66418906e-02f, 1.69496126e-02f, -2.19503902e-02f, 1.21637955e-02f,
  -4.39574430e-03f, -1.89463180e-02f, 3.00112348e-02f, 6.07055612e-02f, 1.17025501e-03f, 6.04628511e-02f, -1.59387738e-02f, -1.65394954e-02f, -7.60076120e-02f, -1.05446614e-02f,
  -1.35473516e-02f, 5.68283796e-02f, 2.72512902e-04f, 3.06035019e-02f, 3.19184624e-02f, -3.37377042e-02f, -8.73592645e-02f, -3.74177471e-02f, 3.96358296e-02f, 6.45653158e-02f,
  -4.23196629e-02f, -2.01807152e-02f, -1.17136436e-02f, -8.65110010e-02f, 9.24795121e-02f, -3.55885774e-02f, 4.02315520e-03f, -5.15084900e-02f, -4.23599128e-03f, -6.77746981e-02f,
  -7.81161934e-02f, -3.68700102e-02f, 4.86809434e-03f, -1.32706044e-02f, -2.54923403e-02f, 2.65282746e-02f, 5.98544143e-02f, 9.04319715e-03f, -5.38152158e-02f, -1.22888945e-01f,
  5.47630154e-02f, -5.21050207e-03f, 4.19480093e-02f, 2.20464934e-02f, 5.48221767e-02f, -1.01737780e-02f, -5.84387556e-02f, -2.41304506e-02f, 1.27061605e-02f, 8.78682453e-03f,
  9.36724097e-02f, -2.45206535e-01f, 1.21258266e-01f, -9.20554027e-02f, 3.09322506e-01f, 2.57125527e-01f, 1.59191284e-02f, -2.55575385e-02f, -1.19517170e-01f, -1.91182598e-01f,
  -8.01887587e-02f, 1.06371619e-01f, -4.11725491e-02f, -1.54511899e-01f, -6.82662427e-02f, -1.46689966e-01f, -1.56209722e-01f, -6.95700645e-02f, 7.83541203e-02f, 3.45711373e-02f,
  4.95197400e-02f, 7.11243693e-03f, -3.28729674e-02f, -2.57036854e-02f, 1.16809398e-01f, -3.55145894e-02f, -1.52224571e-01f, 4.92986739e-02f, 8.67087319e-02f, 1.36470586e-01f,
  -3.05331182e-02f, -8.60342085e-02f, 6.39860481e-02f, -6.78355573e-03f, 2.08683088e-02f, -6.60907626e-02f, -1.66688859e-02f, -5.59799187e-03f, 6.21353230e-03f, -7.59023335e-03f,
  3.09087191e-04f, 7.66214803e-02f, 5.22557199e-02f, 2.24970318e-02f, 6.65050298e-02f, 1.93668809e-02f, 1.89158887e-01f, 8.67234394e-02f, 7.57003948e-02f, 1.15264460e-01f,
  3.89866978e-02f, 8.59085545e-02f, -2.20702160e-02f, -5.41469343e-02f, 2.33976133e-02f, -2.68227905e-02f, 1.01671843e-02f, 8.90825223e-03f, -3.24304774e-02f, -2.19578631e-02f,
  -6.46482483e-02f, 1.57267563e-02f, 6.32655174e-02f, 1.30196754e-02f, 2.63882987e-02f, -4.89987433e-02f, -1.71548650e-02f, 7.13013411e-02f, 5.33908345e-02f, -4.44066934e-02f,
  5.49231376e-03f, -3.39283724e-04f, 6.77396953e-02f, 9.29309800e-02f, -6.94282800e-02f, 1.42937908e-02f, 4.85004410e-02f, 1.40101165e-01f, -8.86289179e-02f, 4.48329747e-02f,
  9.32004489e-03f, 1.04256738e-02f, -5.23448065e-02f, 4.83484864e-02f, -9.31808352e-02f, -9.41018108e-03f, 4.38358448e-02f, 1.53153334e-02f, -6.61221743e-02f, 4.76451665e-02f,
  -2.25377634e-01f, -2.40234822e-01f, -4.23014089e-02f, -2.56363042e-02f, -1.63150262e-02f, 1.19870631e-02f, 5.45238182e-02f, 4.87934239e-02f, -6.78144619e-02f, 2.23728176e-02f,
  2.41405685e-02f, -2.51237787e-02f, 9.38487239e-03f, -2.22671274e-02f, -1.46554679e-01f, 4.78832349e-02f, 2.77040694e-02f, -3.29847969e-02f, 1.26317823e-02f, -2.53027920e-02f,
  -5.30642793e-02f, -2.53672190e-02f, 1.68505479e-02f, 1.02242967e-02f, -4.55705114e-02f, -3.36456113e-02f, -5.52496698e-04f, -1.14609990e-02f, 1.06842056e-01f, -5.11596277e-02f,
  -2.01754719e-01f, 1.54144958e-01f, 4.79458012e-02f, 3.98253351e-02f, -1.66619539e-01f, -2.17617035e-01f, -1.48779869e-01f, 6.88643157e-02f, -1.01460665e-02f, 1.99691713e-01f,
  -8.90670270e-02f, 1.81094274e-01f, -4.01040800e-02f, 9.32521839e-03f, -2.16877386e-01f, -3.33890393e-02f, 4.74118209e-03f, 4.15203720e-02f, 3.47062461e-02f, 7.75784701e-02f,
  -4.25772443e-02f, -4.11505327e-02f, -1.05675861e-01f, 1.20398581e-01f, -5.88798337e-03f, 1.78933471e-01f, 7.56186843e-02f, 1.98736112e-03f, 3.72648574e-02f, -8.79724473e-02f,
  -1.06543250e-01f, 3.74221615e-02f, 2.63500102e-02f, -1.68835949e-02f, 2.83874050e-02f, 8.75201449e-02f, 1.80461840e-03f, -1.42429266e-02f, -6.44541234e-02f, 6.23014942e-03f,
  4.49168123e-02f, -1.02465786e-02f, 6.55264258e-02f, -5.28884456e-02f, 3.80421653e-02f, 6.88996166e-02f, -4.30897400e-02f, 2.02195663e-02f, 4.22055162e-02f, -2.95814257e-02f,
  2.38030218e-03f, 5.64003289e-02f, 7.26212114e-02f, 3.48038375e-02f, 2.66160537e-02f, -2.58581135e-02f, 3.98552194e-02f, 4.37106937e-02f, 6.41149282e-02f, 5.89014478e-02f,
  2.45813484e-04f, -2.91325264e-02f, -4.55438271e-02f, 1.95930637e-02f, -9.31601003e-02f, 6.91253319e-03f, 1.47771714e-02f, -1.48682459e-03f, 2.88811382e-02f, -1.14388578e-03f,
  -1.27166901e-02f, 4.74910811e-02f, -3.12621007e-03f, -3.70586589e-02f, 1.39411120e-03f, 3.61773036e-02f, -5.15220948e-02f, 3.17870267e-02f, -1.93212330e-02f, -4.28980216e-02f,
  -6.38856227e-03f, 1.98493041e-02f, 1.56012289e-02f, 4.40532230e-02f, -6.79560378e-02f, -6.75948039e-02f, 4.55292612e-02f, -2.69435998e-03f, 4.55202535e-02f, 8.47136788e-03f,
  1.30583107e-01f, 3.26077640e-01f, -6.54068962e-03f, -3.40986326e-02f, 6.36062250e-02f, -9.68551685e-05f, -3.07480376e-02f, 6.40432686e-02f, 3.05971317e-02f, 2.98556909e-02f,
  1.84896439e-02f, 1.03141451e-02f, -2.30847206e-02f, -1.73335318e-02f, -4.58629914e-02f, -3.08557544e-02f, 3.68848890e-02f, 9.85234529e-02f, 2.20526047e-02f, 5.79320267e-02f,
  3.72340679e-02f, -3.04768216e-02f, 4.27860320e-02f, -6.14069998e-02f, 2.72625759e-02f, -9.73174162e-03f, 2.92277150e-02f, -3.38649331e-03f, -1.31342597e-02f, 2.05225423e-02f,
  -8.76829997e-02f, -1.61559626e-01f, -1.33688569e-01f, -1.28220484e-01f, -1.85514167e-01f, 6.98688254e-02f, 8.41095969e-02f, 3.29018310e-02f, 5.10561205e-02f, 1.61937848e-01f,
  1.63189322e-01f, -6.16344176e-02f, 3.34348619e-01f, 1.01121575e-01f, 1.16626106e-01f, 2.15902567e-01f, -1.48888469e-01f, -1.21530965e-02f, 1.52581464e-02f, -2.97670458e-02f,
  -3.10569890e-02f, 9.04330760e-02f, 5.26885083e-03f, -4.09425907e-02f, -2.93505676e-02f, -1.47419080e-01f, 1.11096546e-01f, 9.06700492e-02f, -2.92754602e-02f, 1.06843822e-01f,
  3.49126686e-03f, 5.96937016e-02f, 2.72570178e-02f, -7.44265243e-02f, -6.05713502e-02f, -5.18466830e-02f, -5.62235527e-02f, -1.67350750e-02f, -5.46813533e-02f, 6.04875349e-02f,
  1.39298048e-02f, 5.94182238e-02f, -7.34149888e-02f, 3.62434890e-03f, -1.06697425e-01f, -3.48813310e-02f, 1.52553068e-02f, 4.06886041e-02f, -2.55454760e-02f, -1.64703708e-02f,
  7.60773420e-02f, 3.58271562e-02f, -1.10532723e-01f, -6.36682510e-02f, -2.27583274e-02f, -5.66978976e-02f, -1.96151193e-02f, 6.26744051e-03f, 1.96893532e-02f, -2.92572621e-02f,
  1.03086717e-01f, 1.18291862e-02f, -6.76922202e-02f, 2.59786900e-02f, 2.14607874e-03f, -4.13904712e-02f, 5.34768887e-02f, -4.05134037e-02f, -3.73484790e-02f, 4.06170526e-04f,
  -5.02653280e-03f, -4.45635766e-02f, 5.37468009e-02f, 1.57116316e-02f, 3.57895382e-02f, 3.37859197e-03f, 5.81538007e-02f, 1.87818050e-01f, 4.25894978e-03f, 6.77057654e-02f,
  4.74489219e-02f, -5.46529815e-02f, 9.66404937e-03f, 1.05441593e-01f, -1.25784362e-02f, 1.78367253e-02f, 1.65927410e-02f, 5.62978089e-02f, -9.29512605e-02f, -2.46417848e-03f,
  2.15890743e-02f, 1.71842277e-01f, -2.60154367e-03f, 8.76584426e-02f, -7.02256411e-02f, -9.64701176e-02f, -4.22256179e-02f, 5.54469973e-02f, 7.00927973e-02f, 8.42012838e-02f,
  -6.75300434e-02f, -9.20761898e-02f, -3.67569700e-02f, -1.41743794e-02f, 1.50862923e-02f, 5.63796423e-02f, 3.13585252e-02f, 3.95688185e-05f, 3.20265293e-02f, 1.35549381e-01f,
  5.87332398e-02f, 3.67975384e-02f, -1.05015037e-03f, -1.27239272e-01f, 2.74084900e-02f, -5.87559119e-02f, -4.73593995e-02f, -2.51561366e-02f, 6.81989416e-02f, -9.55534652e-02f,
  -3.63376498e-01f, 7.81588852e-02f, 4.02321890e-02f, -2.09731653e-01f, -2.79054809e-02f, 1.74241364e-01f, 9.25123021e-02f, -4.15534787e-02f, -4.01979350e-02f, -4.92266193e-03f,
  -5.21647893e-02f, -1.33840129e-01f, 2.00357080e-01f, -1.75435953e-02f, 1.52782664e-01f, 1.82250753e-01f, -1.83769464e-02f, -4.50247005e-02f, 7.66409487e-02f, -1.35650590e-01f,
  3.62419039e-02f, -1.36649862e-01f, 8.86811838e-02f, 7.18497625e-03f, -1.59277692e-01f, -1.47681549e-01f, -1.65471762e-01f, 7.14422613e-02f, -7.40510672e-02f, -2.07647663e-02f,
  -3.12890708e-02f, -1.18478753e-01f, -2.99358964e-02f, 2.37518102e-02f, 2.44878884e-02f, -1.49128400e-02f, 8.32020398e-03f, 2.58716065e-02f, 4.71640825e-02f, -3.63072492e-02f,
  -3.66880149e-02f, -8.07850063e-02f, -9.09782872e-02f, 6.57306686e-02f, 6.60632476e-02f, 1.07519899e-03f, -2.83635221e-02f, -2.62671523e-02f, -3.96502092e-02f, 1.09414682e-02f,
  1.00690000e-01f, 5.53522520e-02f, 2.42113248e-02f, 3.33876871e-02f, -6.15318120e-02f, -1.01909833e-02f, 7.53257126e-02f, 3.31004038e-02f, -1.04420327e-01f, -7.89274871e-02f,
  7.54849017e-02f, -1.89474840e-02f, 9.32830013e-03f, -1.84208956e-02f, -4.76131439e-02f, 2.57988926e-03f, 5.11478260e-02f, 3.78375165e-02f, -4.17554658e-03f, -6.35548979e-02f,
  3.38129792e-03f, -1.00525767e-01f, -5.25401272e-02f, -1.37110939e-02f, -4.71306778e-02f, -3.74896526e-02f, -2.07659155e-02f, -5.19308820e-02f, -8.45984891e-02f, -9.13209915e-02f,
  -1.91263184e-02f, -7.51669239e-03f, 5.38390577e-02f, 3.04331072e-02f, -8.66876077e-03f, 4.85472642e-02f, 5.21012321e-02f, -5.72166108e-02f, 9.84602235e-03f, 9.53618030e-04f,
  -7.76663423e-02f, -1.04450069e-01f, -9.70810652e-03f, -4.89333719e-02f, 4.14676666e-02f, 6.40141144e-02f, 4.86323014e-02f, 3.42513211e-02f, -4.84019704e-02f, -2.79742014e-03f,
  -5.36852665e-02f, 8.31337050e-02f, 3.08373217e-02f, 5.33407275e-03f, -2.57427935e-02f, -6.05827719e-02f, -5.87979630e-02f, -7.57577717e-02f, -1.11663096e-01f, 2.50552185e-02f,
  -6.30419701e-02f, -4.87209298e-02f, 3.44333686e-02f, -9.31852981e-02f, -5.16846254e-02f, -9.36546400e-02f, -6.23337626e-02f, 3.55746038e-02f, -5.29724285e-02f, 3.92510965e-02f,
  -2.78532386e-01f, 1.57270893e-01f, -1.03179850e-01f, 3.18968818e-02f, 5.16795740e-02f, 1.42656431e-01f, -1.73288733e-02f, 1.16843805e-01f, -1.28067061e-01f, 1.45898193e-01f,
  7.69551471e-02f, -9.54508111e-02f, -1.48821190e-01f, 2.47062534e-01f, -5.88558950e-02f, -1.44609287e-01f, 2.94702470e-01f, 4.40848060e-02f, -5.87461106e-02f, 7.98239484e-02f,
  3.35853398e-02f, 2.22444221e-01f, -1.58908777e-02f, 2.34260336e-01f, -4.77369018e-02f, 9.17124934e-03f, 2.33393818e-01f, -1.16403095e-01f, 2.25710779e-01f, 1.18576642e-02f,
  3.99748459e-02f, -3.76740843e-02f, -1.07863069e-01f, -8.04631114e-02f, 6.08442575e-02f, 5.02727814e-02f, 5.43189421e-02f, -1.19905591e-01f, -4.04551178e-02f, -3.79186030e-03f,
  -1.94506627e-02f, -8.39749277e-02f, -1.94035321e-02f, -1.07406296e-01f, 2.31817514e-02f, -4.38673189e-03f, -4.86588478e-02f, -6.75073490e-02f, -3.69748957e-02f, -6.76652417e-02f,
  -1.03694923e-01f, 1.27630094e-02f, 7.82913566e-02f, 5.45036346e-02f, -3.28832678e-02f, 6.31358176e-02f, 5.93342297e-02f, -6.42472208e-02f, 9.24899057e-02f, 1.23510607e-01f,
  -2.65180636e-02f, 3.50326076e-02f, -6.13351613e-02f, -3.02621163e-03f, -6.57186732e-02f, -2.50465591e-02f, 6.86113955e-03f, 3.22592929e-02f, -5.37345037e-02f, -2.29854742e-03f,
  2.17787549e-02f, -2.85898857e-02f, -1.29749412e-02f, 4.99238223e-02f, 5.91607802e-02f, 3.46601829e-02f, 3.86315063e-02f, 4.24684733e-02f, -4.97395173e-03f, 2.07000598e-02f,
  -2.03144997e-02f, 8.74799564e-02f, -8.20939243e-03f, -2.03358624e-02f, 5.40938303e-02f, -1.15042683e-02f, 9.19988751e-02f, -8.13217834e-03f, 3.07125170e-02f, 3.04467436e-02f,
  1.82386234e-01f, 2.26977944e-01f, 2.02003960e-02f, -7.38340020e-02f, -2.76039764e-02f, -2.95693036e-02f, -8.21658000e-02f, 3.84076908e-02f, 6.77296072e-02f, 4.81483825e-02f,
  2.82268059e-02f, -7.10415561e-03f, 1.56980827e-02f, 6.66909963e-02f, 4.14500609e-02f, 3.18509415e-02f, 7.14437142e-02f, -1.14956638e-02f, 1.47696331e-01f, 7.08507048e-03f,
  8.29406008e-02f, -1.44473128e-02f, 4.01374092e-03f, 5.89517457e-03f, 1.16678417e-01f, -4.49777901e-04f, 5.68639599e-02f, 4.55303229e-02f, 8.40521138e-03f, -7.40108266e-02f,
  3.69979888e-01f, 1.99917015e-02f, 1.07544616e-01f, 1.14439420e-01f, -2.49870300e-01f, -2.44775519e-01f, -1.75392330e-01f, -6.28774911e-02f, -5.33098802e-02f, -7.54002109e-02f,
  -6.94347993e-02f, 1.43306047e-01f, 4.08635437e-02f, 3.46232019e-02f, 1.59151748e-01f, 2.03009844e-01f, -8.94259010e-03f, 7.28263636e-04f, -8.32534432e-02f, 5.60931042e-02f,
  8.33488703e-02f, -3.08358446e-02f, 2.18161806e-01f, -1.00610569e-01f, 7.54277185e-02f, 5.86185455e-02f, 1.52878568e-01f, -4.62439694e-02f, -8.75047371e-02f, -1.72014907e-02f,
  4.90515158e-02f, 5.09347133e-02f, -2.31644306e-02f, 9.24402196e-03f, -7.46024325e-02f, 2.80500506e-03f, -2.89378017e-02f, 4.36619017e-03f, -6.79324716e-02f, 4.12976854e-02f,
  -3.95154115e-03f, 2.61101406e-03f, -1.35740608e-01f, 1.26240980e-02f, 5.16356863e-02f, 1.08628506e-02f, 5.22514991e-02f, -4.66284081e-02f, -4.93133403e-02f, 7.95165971e-02f,
  5.18400297e-02f, 8.50903764e-02f, 4.30536680e-02f, -7.47593716e-02f, 2.15972066e-02f, -5.23062646e-02f, 8.20548013e-02f, -9.21829697e-03f, -4.90828902e-02f, -1.08184047e-01f,
  3.92638054e-03f, -7.93187227e-03f, 1.34533914e-02f, 1.52542451e-02f, -3.95358503e-02f, 3.29865376e-03f, 3.64887342e-02f, -1.61166601e-02f, -2.16987040e-02f, 7.45910555e-02f,
  -1.14954244e-02f, 9.35992412e-03f, 5.21795079e-02f, 2.23390404e-02f, 1.96628589e-02f, 6.97791204e-02f, 1.68733578e-02f, -1.55587243e-02f, 1.39979804e-02f, -4.06817952e-03f,
  -4.64282408e-02f, 6.87022731e-02f, -2.90258992e-02f, -2.69649439e-02f, -2.41604280e-02f, 4.20881659e-02f, 1.42796070e-03f, 9.94797871e-02f, -2.57367678e-02f, -1.92549173e-02f,
  -1.52808443e-01f, -8.24400708e-02f, 1.74732059e-02f, -9.55898315e-03f, -3.38640176e-02f, 7.65121030e-03f, 2.12062169e-02f, -5.99036254e-02f, -6.54269457e-02f, -7.37621933e-02f,
  -7.61049092e-02f, -8.00885782e-02f, 2.92249639e-02f, 4.10443991e-02f, -1.55035118e-02f, -3.39331967e-03f, -4.44177724e-02f, -5.99407107e-02f, 1.07765300e-02f, -3.06253545e-02f,
  3.89612094e-02f, -1.26223534e-03f, 3.04105505e-02f, -8.65985453e-02f, -8.94196332e-02f, -1.22888908e-02f, -2.39893049e-02f, -1.61643885e-02f, 4.17431444e-02f, 1.71927474e-02f,
  -1.74660966e-01f, 6.18192889e-02f, 1.75498337e-01f, -8.87833983e-02f, -1.36356071e-01f, -2.85130858e-01f, -1.59725174e-02f, -1.60942748e-01f, 2.87601389e-02f, 9.76660997e-02f,
  1.37471125e-01f, -2.75072306e-02f, 1.31357670e-01f, 9.52997953e-02f, -1.71281964e-01f, 2.00472549e-01f, -1.44186802e-03f, 8.26074332e-02f, 5.81067130e-02f, -9.98124480e-02f,
  -5.02867065e-02f, -4.59368788e-02f, 5.42876497e-02f, -3.71531174e-02f, -1.21172607e-01f, -7.77192339e-02f, 1.11233667e-01f, 1.01758175e-01f, -5.79757765e-02f, -7.59100318e-02f,
  -9.97809395e-02f, 6.51033316e-03f, -1.83982551e-02f, -1.48141023e-03f, -3.91844474e-02f, -2.43413281e-02f, -6.90351501e-02f, -5.85684972e-03f, -1.17976386e-02f, -7.26015195e-02f,
  -6.71777353e-02f, 8.92151147e-03f, -5.60153611e-02f, 4.92864065e-02f, -1.26766134e-02f, -1.43500688e-02f, 4.74927537e-02f, 5.03024235e-02f, 8.28291625e-02f, 2.86674760e-02f,
  -1.18368035e-02f, -6.25568852e-02f, 1.73592858e-03f, 2.72321030e-02f, 6.75915852e-02f, 5.44762202e-02f, 3.31302583e-02f, -6.59452379e-02f, -1.11840241e-01f, -6.10795170e-02f,
  3.93134318e-02f, 1.11099973e-01f, 4.88121845e-02f, 1.48631101e-02f, -8.53609573e-03f, -2.85382699e-02f, -3.40221040e-02f, 5.05463593e-02f, 1.51522115e-01f, 5.35853729e-02f,
  -9.40735266e-02f, 5.64174615e-02f, -5.29749654e-02f, 4.35758531e-02f, 6.78493036e-03f, 9.09741595e-02f, -3.55027467e-02f, -7.51382932e-02f, -1.59862246e-02f, 5.50098077e-04f,
  6.69564679e-02f, -6.00594245e-02f, 5.66036797e-05f, 8.88436884e-02f, -6.13873117e-02f, 5.16336262e-02f, 8.18844419e-03f, -6.86666509e-03f, 6.98081255e-02f, -3.63728106e-02f,
  -2.02234700e-01f, -2.49580685e-02f, -3.65179926e-02f, -1.67088546e-02f, -4.84658070e-02f, 6.46627247e-02f, 3.96710448e-02f, 4.98173349e-02f, -7.37049133e-02f, 2.13962160e-02f,
  -6.37045875e-02f, -3.24804001e-02f, -1.13108888e-01f, 4.14800495e-02f, -3.95801254e-02f, 2.64706705e-02f, -1.72958279e-03f, -6.63553178e-02f, -4.27581742e-02f, -4.91216406e-03f,
  4.84560393e-02f, -1.69012882e-02f, 5.61409257e-02f, -4.09130082e-02f, -9.54600703e-03f, 1.35994228e-02f, -7.18015954e-02f, 7.79907256e-02f, -1.35018183e-02f, -6.72396570e-02f,
  -4.26625878e-01f, 8.89784023e-02f, -8.50825608e-02f, -3.45753551e-01f, 1.30949929e-01f, 2.64312059e-01f, 6.51348010e-02f, -2.36909781e-02f, -2.28375614e-01f, 1.74502879e-01f,
  2.93310359e-02f, -1.65844366e-01f, 1.32848620e-01f, -1.40522301e-01f, -2.08410904e-01f, -9.31039359e-03f, -1.25349358e-01f, -5.86432628e-02f, -1.07680045e-01f, -6.84341788e-02f,
  -3.48754637e-02f, 1.14497580e-01f, -1.15375016e-02f, 2.59263903e-01f, -1.08410165e-01f, 4.69944365e-02f, 7.29758069e-02f, 1.45990536e-01f, 5.19135557e-02f, 8.38059634e-02f,
  3.24796736e-02f, -3.08995564e-02f, 1.24649908e-02f, 3.90196824e-03f, 4.15548719e-02f, 3.44404913e-02f, -2.65321992e-02f, 4.46814187e-02f, 2.20935475e-02f, 3.28967255e-03f,
  -4.42381501e-02f, -1.20632388e-02f, -3.51690613e-02f, -4.96175252e-02f, -2.62566954e-02f, -1.25532188e-02f, -7.65673071e-02f, -1.62710156e-02f, 3.55480574e-02f, -1.05080260e-02f,
  -6.28928021e-02f, -6.17406443e-02f, 3.88589948e-02f, 5.95618859e-02f, 4.28979136e-02f, 3.19999084e-02f, 4.17676521e-03f, -9.32666659e-03f, 4.28700494e-03f, -5.50083369e-02f,
  -3.44953462e-02f, 3.37467492e-02f, -3.19301616e-03f, -5.38066216e-03f, -7.28602707e-03f, 1.86064038e-02f, 2.88882852e-02f, -2.06302181e-02f, 2.77688038e-02f, -2.41166018e-02f,
  -6.18119463e-02f, 1.50684267e-02f, -7.06093162e-02f, -5.08990549e-02f, 2.55010724e-02f, -6.94598630e-02f, 3.06472760e-02f, -3.75950374e-02f, -5.50598241e-02f, -3.82657833e-02f,
  1.80808902e-02f, -7.32376426e-02f, -6.78662490e-03f, -7.04593062e-02f, 6.98206872e-02f, -4.90989015e-02f, -2.61641890e-02f, -1.61675848e-02f, -3.16932797e-02f, 2.10388023e-02f,
  1.51673909e-02f, 2.18347404e-02f, 2.26107687e-02f, -3.50200906e-02f, 3.04412581e-02f, -1.04964850e-02f, -5.14006801e-02f, 3.63287237e-03f, 4.33670059e-02f, -3.58447693e-02f,
  1.20212892e-02f, 4.53965180e-03f, 2.42518615e-02f, 1.71010084e-02f, 4.54046624e-03f, 5.19563770e-03f, 8.38460866e-03f, -1.10049769e-02f, -1.12501383e-02f, 8.74075666e-03f,
  -6.22217283e-02f, 2.75323875e-02f, -2.67785043e-02f, -1.10330023e-02f, -2.33349781e-02f, 1.18967984e-02f, -8.12583342e-02f, -2.98520405e-04f, 2.02699061e-02f, -3.01897898e-02f,
  3.48012447e-02f, 5.00899367e-03f, 2.13260740e-01f, 2.56272167e-01f, -2.08654985e-01f, -2.24045753e-01f, 2.95332987e-02f, -1.72962975e-02f, 5.09284437e-03f, 6.97785467e-02f,
  -4.46904264e-02f, 2.14749426e-01f, -1.53783083e-01f, 1.28830999e-01f, 7.76772213e-04f, -8.50794688e-02f, 2.20662311e-01f, 9.92059633e-02f, 1.74581502e-02f, 8.92598629e-02f,
  -2.18699332e-02f, -6.75368011e-02f, 1.22522727e-01f, -1.78346738e-01f, -4.83954884e-03f, 2.56902818e-02f, 5.71549386e-02f, 9.68875922e-03f, 9.88334268e-02f, 1.92193817e-02f,
  -1.20809078e-02f, 4.00712655e-04f, 1.27992677e-02f, 6.63202479e-02f, -2.96407547e-02f, -2.70675104e-02f, 3.64237539e-02f, 3.85530330e-02f, 1.69036034e-02f, 4.78376262e-02f,
  -6.89787865e-02f, -7.15765879e-02f, -2.73221824e-02f, 5.22661731e-02f, -2.04807017e-02f, 7.02801161e-03f, -3.28599699e-02f, -1.76987052e-02f, -3.74839045e-02f, 6.15410041e-03f,
  3.07157114e-02f, 4.07730341e-02f, 5.02066538e-02f, 3.26517299e-02f, -5.10145277e-02f, -4.87109944e-02f, 3.04911453e-02f, -2.91038640e-02f, -1.04028229e-02f, -1.95162147e-02f,
  -8.89074802e-02f, 4.04792093e-02f, 3.53161357e-02f, 3.12527455e-02f, 7.82381222e-02f, -4.12835628e-02f, 2.76596714e-02f, 6.87351748e-02f, 1.50255887e-02f, -2.07760595e-02f,
  -2.40553822e-02f, -2.29318477e-02f, -6.78256303e-02f, 1.38243875e-02f, 3.75832394e-02f, -1.79940704e-02f, 6.40150681e-02f, 6.19731005e-03f, 1.70403663e-02f, -5.13636097e-02f,
  6.27743602e-02f, -5.53816967e-02f, 2.09859814e-02f, -4.02834192e-02f, -6.06337190e-02f, 3.92638613e-03f, -1.20658474e-03f, 2.33825557e-02f, 4.16360497e-02f, -5.25436886e-02f,
  -1.17671847e-01f, 2.00056867e-03f, 5.23351738e-03f, -7.69564584e-02f, -2.55296542e-03f, -6.70761392e-02f, -1.35850823e-02f, -4.28854302e-02f, -1.61199924e-02f, -3.09604760e-02f,
  3.29737328e-02f, 4.74521220e-02f, -2.17600130e-02f, -1.81038994e-02f, 2.73130834e-02f, -8.99162218e-02f, -4.27214289e-03f, 3.06150354e-02f, 9.27482247e-02f, 2.75021903e-02f,
  5.84834628e-03f, 1.56094925e-02f, -3.69959772e-02f, -2.64538992e-02f, 5.66911139e-02f, 3.71754430e-02f, -6.36308789e-02f, 2.86422987e-02f, -7.19402060e-02f, 3.23339589e-02f,
  -1.42766863e-01f, 3.94808911e-02f, 9.85101312e-02f, 3.02684028e-02f, 8.11772943e-02f, 3.67939994e-02f, 3.29492167e-02f, 2.03660220e-01f, -8.20012018e-02f, -1.48328274e-01f,
  1.18281342e-01f, -1.33916125e-01f, -2.57480191e-03f, 2.53182054e-01f, 3.19832176e-01f, -7.01692104e-02f, 3.03517058e-02f, -9.96447131e-02f, -1.57933235e-02f, 7.99963549e-02f,
  1.01211779e-01f, 2.42845699e-01f, 2.31553108e-01f, 9.83136445e-02f, 7.37809297e-03f, -4.55464907e-02f, -4.96339090e-02f, -5.95674478e-02f, 9.24862996e-02f, 3.60344164e-02f,
  4.31266464e-02f, 4.23822142e-02f, 7.20287561e-02f, 9.77014308e-04f, 3.47990692e-02f, -3.83831710e-02f, 2.05030385e-02f, 2.87256986e-02f, 2.09197700e-02f, -9.80817154e-03f,
  -1.32669404e-01f, 8.26167837e-02f, 8.03288892e-02f, -9.63233877e-03f, -7.69299716e-02f, -2.88986322e-02f, 6.89477921e-02f, 5.15274964e-02f, 8.88649002e-02f, 4.95445207e-02f,
  1.04959473e-01f, 3.59410532e-02f, -2.30544973e-02f, -4.31319997e-02f, -9.88344699e-02f, 1.68006886e-02f, -2.74613220e-03f, -3.06066970e-04f, -3.89429927e-02f, -1.68622695e-02f,
  -6.47400841e-02f, -4.50656563e-02f, 4.43309173e-02f, 4.80593406e-02f, 4.63546254e-02f, 4.22233120e-02f, -1.01256985e-02f, 3.11387423e-02f, -2.57283337e-02f, 2.32507940e-02f,
  -3.79717746e-03f, 3.27478796e-02f, 8.25404450e-02f, 3.29724588e-02f, -1.61129460e-02f, -4.43718350e-03f, -1.85457002e-02f, 1.05448114e-02f, -7.42843449e-02f, -3.60911200e-03f,
  3.91580239e-02f, -5.75411879e-02f, -2.27558520e-02f, -6.52880147e-02f, 1.30623365e-02f, 2.91136652e-03f, 7.51234079e-03f, 1.26255313e-02f, 1.10157216e-02f, -1.77373942e-02f,
  -2.34197993e-02f, -1.44223878e-02f, 6.95745274e-02f, -1.68591384e-02f, -6.67001829e-02f, -2.70856507e-02f, -3.29970643e-02f, 1.11018866e-02f, -4.69449274e-02f, 5.96585535e-02f,
  2.78614089e-02f, -5.68061136e-02f, -1.43557951e-01f, 6.86658360e-03f, 6.07829355e-02f, 2.26037931e-02f, -8.20136517e-02f, -1.04875110e-01f, -7.36531690e-02f, -2.52264012e-02f,
  -7.97763020e-02f, -9.22780186e-02f, -3.21944989e-02f, 1.65274329e-02f, -8.97779241e-02f, -7.64186531e-02f, -2.35901517e-03f, -4.97159287e-02f, 6.25227531e-03f, 1.11674098e-03f,
  -9.44409966e-02f, 2.65067875e-01f, -1.71530396e-01f, 4.57164682e-02f, 2.37354599e-02f, 2.98235297e-01f, 1.70314610e-01f, -1.28359850e-02f, -1.15938932e-01f, 2.12828904e-01f,
  2.24475320e-02f, -5.41248247e-02f, 8.28437787e-03f, 2.57254392e-01f, 7.16197584e-03f, 1.12110391e-01f, 2.07022086e-01f, 1.49676129e-01f, -8.95956457e-02f, 1.01827845e-01f,
  -1.71214063e-02f, 2.37828955e-01f, 1.47602065e-02f, 1.13393195e-01f, -4.39226590e-02f, -1.98157623e-01f, -5.15351295e-02f, -1.36304840e-01f, 6.77885935e-02f, 3.66881415e-02f,
  -3.36165391e-02f, 9.26257484e-03f, -9.02046859e-02f, 4.82013375e-02f, 5.47804981e-02f, 6.03369474e-02f, -5.50788008e-02f, -6.62627518e-02f, -4.75148596e-02f, -4.37305029e-03f,
  -2.63570156e-02f, -2.96010394e-02f, -7.56440964e-03f, -2.57267579e-02f, -2.28676461e-02f, -7.75580183e-02f, 9.19241749e-04f, -3.22618596e-02f, -4.29578573e-02f, 3.54705006e-02f,
  5.54130925e-03f, -3.72830853e-02f, -6.25420958e-02f, 6.04655854e-02f, -4.93554026e-02f, 7.78799355e-02f, 7.77323171e-02f, 1.43803870e-02f, 6.01871945e-02f, 1.71406083e-02f,
  5.93782924e-02f, 7.96944872e-02f, 1.95268299e-02f, -1.00962613e-02f, 1.18705560e-03f, -5.97605892e-02f, 2.95797992e-03f, 1.58934090e-02f, -6.58201277e-02f, 1.22785605e-02f,
  -9.86595452e-03f, -6.45867959e-02f, 3.74917947e-02f, 5.83309010e-02f, -6.23378018e-03f, 1.40512269e-02f, -7.18383417e-02f, 1.09994747e-02f, -6.60649464e-02f, 7.69769168e-03f,
  -6.41705617e-02f, 3.60678509e-02f, -8.49714279e-02f, -1.64868142e-02f, -4.13752301e-03f, -5.75574972e-02f, 1.80866499e-03f, 2.91167516e-02f, -7.51798078e-02f, 7.93989841e-03f,
  1.27066359e-01f, 1.88435405e-01f, -1.17436992e-02f, 3.88823971e-02f, -5.78238107e-02f, -1.24849174e-02f, 5.77671826e-02f, 1.08137533e-01f, 3.26634794e-02f, 3.56856845e-02f,
  2.64688823e-02f, 5.20993620e-02f, 2.60215960e-02f, 7.32002826e-03f, 2.18190867e-02f, 1.55019052e-02f, 6.36599511e-02f, 3.97978052e-02f, 7.17261434e-02f, 2.70437524e-02f,
  2.38667745e-02f, 3.72095010e-03f, 2.14818474e-02f, -5.01230247e-02f, -3.98789234e-02f, -3.73203233e-02f, 3.63704301e-02f, -4.53050658e-02f, -7.81327486e-02f, 1.79633610e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.06659062e-01f, 1.92534953e-01f, 1.48270220e-01f, 6.96803331e-02f, -3.33356485e-02f, 2.05673240e-02f, -1.96735319e-02f, 4.27992791e-02f, -1.84490487e-01f, 5.55770881e-02f,
  -6.51690066e-02f, 1.53934345e-01f, 3.37253138e-02f, -2.71137267e-01f, -3.08159202e-01f, -2.56753564e-01f, -1.33937299e-01f, 7.85826519e-02f, -6.81944052e-03f, 1.42213166e-01f,
  7.10757971e-02f, -2.45951518e-01f, 4.25495803e-02f, -1.42395139e-01f, 8.28438029e-02f, 2.21138358e-01f, -7.17656175e-03f, 1.05895787e-01f, 1.37321472e-01f, -1.99123204e-01f,
  4.62763291e-03f, 3.27815418e-03f, 1.36904493e-01f, 5.39707206e-03f, 7.92215616e-02f, -9.65794362e-03f, -3.27922627e-02f, -1.05545551e-01f, -6.61278740e-02f, -1.89246498e-02f,
  -3.11359409e-02f, 1.35487374e-02f, -9.35178772e-02f, -5.21220230e-02f, 1.19257439e-02f, -1.78581774e-02f, 5.21469004e-02f, 6.87951688e-03f, 2.36165430e-02f, 6.45794123e-02f,
  2.82468982e-02f, 6.03266284e-02f, -2.25801449e-02f, -5.93385845e-02f, 1.34521797e-01f, 5.00648981e-03f, 4.60843071e-02f, 1.47624761e-01f, 2.86425203e-02f, -2.24904679e-02f,
  3.58829461e-02f, 6.95552230e-02f, -6.52911549e-04f, -1.06296152e-01f, -4.90726866e-02f, -3.12888883e-02f, 1.54144103e-02f, 6.09474853e-02f, -2.22918508e-03f, 1.01449830e-03f,
  7.91302323e-02f, 5.38956001e-02f, -1.32407233e-01f, 3.30853872e-02f, 9.59071741e-02f, 6.15158863e-02f, 2.49847174e-02f, 7.58499131e-02f, 4.38514166e-02f, 7.36056492e-02f,
  3.05950977e-02f, -4.48940396e-02f, -3.13715264e-02f, 4.56021586e-03f, -1.32093474e-01f, 9.50953886e-02f, 7.89246112e-02f, 3.98059450e-02f, -1.53580988e-02f, -8.36246461e-03f,
  -7.33828619e-02f, 7.70265833e-02f, -1.25266910e-01f, -9.33940709e-02f, -9.74563286e-02f, 1.90107543e-02f, -2.16860101e-02f, -1.07206866e-01f, 5.72682992e-02f, -6.49150386e-02f,
  4.52783331e-02f, -4.86626178e-02f, -3.98833305e-02f, 2.87788012e-03f, -1.41887575e-01f, 2.88921185e-02f, -9.83500257e-02f, -2.42678151e-02f, -1.25995755e-01f, 4.72710058e-02f,
  1.27360985e-01f, 1.58059910e-01f, -1.84095949e-01f, -7.95313865e-02f, 3.02296877e-02f, 1.45964194e-02f, 1.16037745e-02f, 5.93015291e-02f, 9.86200199e-02f, -2.34160889e-02f,
  1.52599737e-01f, -8.61076489e-02f, -2.79835045e-01f, -1.52917176e-01f, -1.13687806e-01f, -1.50867939e-01f, 2.03289930e-02f, -1.69638619e-01f, 1.83777750e-01f, 5.96564151e-02f,
  -1.69060886e-01f, 1.28869101e-01f, 2.43984293e-02f, -1.66563287e-01f, 1.88758582e-01f, 2.26080701e-01f, -1.05730444e-02f, 6.94489852e-02f, 2.99878214e-02f, 5.46103455e-02f,
  -9.59443599e-02f, -4.81425710e-02f, -1.40472129e-01f, -1.29661575e-01f, -1.85149878e-01f, -8.89834091e-02f, -9.53652114e-02f, -1.30393356e-01f, -2.06834838e-01f, 3.79847921e-02f,
  -1.23097301e-01f, 8.48183855e-02f, -1.38136372e-01f, 6.23212345e-02f, -7.72720352e-02f, -5.15721962e-02f, -9.17146541e-03f, -4.31402437e-02f, -1.05291732e-01f, 7.14872703e-02f,
  1.17163718e-01f, 2.78047007e-02f, 3.70447040e-02f, -4.96510603e-03f, 3.90803404e-02f, -1.10094696e-01f, -2.92562898e-02f, -3.02934293e-02f, -8.32393616e-02f, -6.97659254e-02f,
  1.88172814e-02f, 4.69626226e-02f, -2.12473273e-02f, 5.82197011e-02f, -1.15790568e-01f, 4.90929186e-02f, -1.61198173e-02f, -9.71574977e-04f, 7.23547116e-02f, 4.35718037e-02f,
  -6.20898344e-02f, 4.14738283e-02f, 1.03102013e-01f, -1.92338414e-02f, -1.01771124e-01f, -7.46129593e-03f, -7.21291527e-02f, -9.83341504e-03f, -2.55307741e-02f, 3.95642482e-02f,
  2.46780235e-02f, -8.09452981e-02f, -7.76194828e-03f, 7.74267614e-02f, 7.42127327e-03f, 9.62911174e-02f, -5.20289429e-02f, 6.85085729e-02f, 4.96050715e-02f, 2.07987502e-02f,
  -2.91224066e-02f, 8.89211707e-03f, -9.27551743e-03f, -9.80068892e-02f, -9.50214490e-02f, 2.30930019e-02f, -3.93499881e-02f, -6.51310310e-02f, -3.39199789e-02f, 2.42078379e-02f,
  6.55483976e-02f, 1.03186660e-01f, -3.76322195e-02f, -3.01885363e-02f, -5.54076536e-03f, 5.55402450e-02f, 6.01792857e-02f, -2.33801231e-02f, -1.61926020e-02f, 1.37682319e-01f,
  -6.08838014e-02f, 4.35079373e-02f, 1.23462990e-01f, 7.59933218e-02f, 6.17106445e-02f, -1.20107174e-01f, 6.57893345e-02f, 3.19604715e-03f, 3.76016535e-02f, -6.76909834e-03f,
  -7.23169520e-02f, 8.50807801e-02f, 8.74083936e-02f, -3.80076729e-02f, -6.78555220e-02f, -1.96929835e-02f, 6.12083748e-02f, -7.97620043e-02f, 8.27520248e-03f, 3.84552553e-02f,
  -5.02192914e-01f, 1.87861919e-01f, 9.98590216e-02f, 3.52692343e-02f, -1.95387870e-01f, 2.82823652e-01f, 3.61761987e-01f, -5.38972430e-02f, 2.33025625e-01f, 1.38496980e-01f,
  1.01450138e-01f, 8.44827145e-02f, 1.69521153e-01f, 1.22473650e-01f, -8.56870636e-02f, 8.55709687e-02f, 1.21789552e-01f, 1.54490128e-01f, 1.79368183e-01f, -1.41084880e-01f,
  -1.58455551e-01f, -1.18233953e-02f, -8.30829889e-02f, -5.66245355e-02f, -2.80329380e-02f, -1.28147349e-01f, -1.04815969e-02f, 7.26565570e-02f, 2.85697379e-03f, 1.53881580e-01f,
  -6.56791702e-02f, 5.41625917e-02f, -7.35989725e-03f, 9.98407751e-02f, -3.71169038e-02f, 4.07080762e-02f, -1.10003361e-02f, 4.87922542e-02f, 3.58980745e-02f, -5.97045943e-02f,
  3.45379300e-02f, 5.13942093e-02f, 1.38795465e-01f, 3.79809402e-02f, -5.66645712e-02f, -4.67358343e-02f, 7.34738484e-02f, -6.80340305e-02f, 4.21290472e-02f, -7.81683922e-02f,
  -2.26487052e-02f, -4.26862240e-02f, -3.66892107e-02f, -1.45227620e-02f, -3.90300248e-03f, 9.99512076e-02f, 4.43209708e-02f, -1.22827783e-01f, 2.99448986e-02f, -6.95606973e-03f,
  -7.58966729e-02f, 5.11327162e-02f, -3.42871919e-02f, -7.64449313e-02f, 8.92931670e-02f, -4.33714390e-02f, -3.04507790e-03f, -5.73838055e-02f, 6.46608397e-02f, -4.13599275e-02f,
  -2.10552476e-02f, 3.09200566e-02f, -5.26444288e-03f, -1.61563437e-02f, 6.24233000e-02f, -6.94116279e-02f, -8.12743083e-02f, -6.71425685e-02f, -9.36014857e-03f, 4.46707904e-02f,
  6.13518730e-02f, 8.11614916e-02f, 7.79213905e-02f, -5.06868362e-02f, 9.97718610e-03f, 1.44125288e-02f, 6.52948469e-02f, -4.44197170e-02f, 9.11824182e-02f, -5.55275343e-02f,
  1.22416981e-01f, 4.13324311e-02f, 1.12170748e-01f, -2.68231463e-02f, 4.52290885e-02f, -1.13363691e-01f, -6.74626902e-02f, -1.25366732e-01f, 1.75952930e-02f, -2.73662023e-02f,
  3.39030195e-03f, -1.02062803e-02f, -6.24565333e-02f, -1.45475110e-02f, -5.56846149e-02f, 1.79416075e-01f, 9.68428105e-02f, -1.78891723e-03f, -9.10381228e-02f, -1.16152994e-01f,
  -9.72445905e-02f, 4.53659482e-02f, -3.90258394e-02f, 7.00551420e-02f, -5.88432774e-02f, -3.35038677e-02f, -9.21362042e-02f, 1.51563771e-02f, 3.91537976e-03f, 3.73185389e-02f,
  2.74240412e-02f, 1.77982792e-01f, 1.70652330e-01f, 4.69477028e-02f, -2.23681882e-01f, 2.65989482e-01f, -6.11473508e-02f, 6.51062950e-02f, 1.66202590e-01f, 1.77724004e-01f,
  -2.41349459e-01f, 1.62444621e-01f, -5.85920513e-02f, -2.32274551e-02f, 5.21630496e-02f, 2.14797363e-01f, -8.78447816e-02f, -3.64028476e-02f, -2.68328702e-03f, -7.35500976e-02f,
  -7.99795613e-03f, -2.23680407e-01f, -6.53790981e-02f, -9.09438282e-02f, -2.22100273e-01f, -8.21345672e-02f, -3.56766731e-01f, -1.09607458e-01f, -1.21358484e-01f, -1.57115847e-01f,
  -8.81673098e-02f, 7.73316540e-04f, -2.06141144e-01f, -6.14235690e-03f, -1.37774259e-01f, -1.59973428e-01f, 6.19547293e-02f, -4.40324619e-02f, 2.77305092e-03f, 1.36335462e-01f,
  -4.84182723e-02f, 2.76614092e-02f, -4.07529958e-02f, 2.04284023e-02f, 3.15012112e-02f, 3.77371311e-02f, -1.50042828e-02f, -8.60917270e-02f, -5.28594330e-02f, -1.04488686e-01f,
  -1.17677338e-01f, 5.18832207e-02f, -5.18793873e-02f, 5.43240048e-02f, -1.37463519e-02f, -1.27782851e-01f, 1.49693593e-01f, -1.40088946e-01f, 1.66345816e-02f, -7.22641423e-02f,
  5.25461044e-03f, 8.19218829e-02f, 3.49833854e-02f, 4.94445302e-02f, 1.58780236e-02f, -9.88394693e-02f, -1.03751458e-02f, -4.61083949e-02f, 5.47174700e-02f, 6.48016930e-02f,
  9.26801786e-02f, 4.19942923e-02f, 1.08271748e-01f, -5.02471291e-02f, 5.21078072e-02f, -6.46952242e-02f, 1.22662224e-02f, 1.29991636e-01f, 1.64684560e-02f, -1.10782415e-01f,
  7.31682628e-02f, -8.95723142e-03f, -1.18875079e-01f, 6.40997589e-02f, -9.62343812e-02f, -3.11301928e-02f, -1.12660162e-01f, 1.00841373e-02f, -5.04231863e-02f, -9.65352729e-02f,
  -7.84576535e-02f, 7.15096965e-02f, -1.76733267e-02f, 6.16186671e-02f, -8.39478821e-02f, -4.97495979e-02f, 5.88843338e-02f, -8.80247280e-02f, -3.42050232e-02f, 4.40763729e-03f,
  5.67047223e-02f, -5.01715466e-02f, -4.93072271e-02f, 1.00758448e-02f, 1.41338423e-01f, 4.47585545e-02f, -1.13352172e-01f, -1.35541698e-02f, -1.85797568e-02f, -1.14778988e-01f,
  -6.80979341e-02f, 8.92167315e-02f, -1.61405280e-02f, 3.05629671e-02f, 1.27994344e-02f, 4.31346102e-03f, 5.57665937e-02f, 2.93232910e-02f, -1.60954058e-01f, -4.28462923e-02f,
  -6.74784258e-02f, -6.07326031e-02f, 1.98417097e-01f, 3.41099620e-01f, 1.42808467e-01f, -2.82276034e-01f, -1.99321404e-01f, 1.91964000e-01f, 1.65841162e-01f, -2.29549199e-01f,
  -9.20458511e-02f, -1.35703787e-01f, -1.81072816e-01f, 9.22333449e-02f, 2.44809508e-01f, 5.08733559e-03f, 1.44902766e-01f, 2.25619897e-02f, 1.89604461e-01f, 1.24672920e-01f,
  2.13546962e-01f, 1.81723922e-01f, 2.88356423e-01f, 2.31083378e-01f, 3.27501893e-02f, 2.32650325e-01f, 1.44885436e-01f, 1.32976264e-01f, 1.98475301e-01f, -3.51454429e-02f,
  -8.08355585e-03f, 1.00395791e-01f, 6.51181191e-02f, -2.19605919e-02f, 7.79737905e-02f, -1.10828586e-01f, -4.77006100e-02f, -1.01362197e-02f, 2.85661547e-03f, -7.49273300e-02f,
  -6.92418218e-02f, -4.42878455e-02f, -1.43952342e-02f, -4.30854708e-02f, -2.58552339e-02f, 1.84305832e-02f, 1.12403510e-02f, -4.40685041e-02f, 1.00940131e-02f, -7.81743228e-03f,
  7.19696581e-02f, 4.66283411e-02f, 1.20738996e-02f, 5.12657017e-02f, 3.44173461e-02f, -5.75151853e-03f, -4.13397588e-02f, 5.33286296e-02f, 6.50038943e-02f, 9.78620630e-03f,
  2.53491756e-02f, 2.76896581e-02f, -1.33377522e-01f, 7.57846236e-02f, -2.04465594e-02f, 1.19129322e-01f, 5.67601547e-02f, -8.26565176e-02f, -2.36508865e-02f, 7.21995905e-02f,
  1.08026862e-01f, -1.06735080e-02f, 4.01756689e-02f, 2.23967042e-02f, -4.09252793e-02f, -2.80000679e-02f, 8.07264894e-02f, 3.08223069e-03f, -2.97588389e-02f, 7.94212893e-02f,
  -5.38557395e-02f, 7.30245421e-03f, -1.17887352e-02f, -2.39993539e-02f, -1.42949205e-02f, -1.04867229e-02f, 7.58868642e-03f, -7.62385353e-02f, -1.39981778e-02f, 1.14188462e-01f,
  -6.26726821e-02f, 6.47651181e-02f, 4.48665433e-02f, -1.08171567e-01f, 5.35155237e-02f, -5.01607582e-02f, 3.56817357e-02f, -9.69356522e-02f, 5.71599826e-02f, 9.51330513e-02f,
  -3.34763713e-02f, 1.25439409e-02f, -1.24211378e-01f, 6.41699322e-03f, -6.14317730e-02f, 1.26367763e-01f, -1.15136541e-02f, -2.99385581e-02f, 3.79889905e-02f, 3.30933444e-02f,
  1.82923322e-04f, -3.67687717e-02f, 3.93553749e-02f, 1.45805493e-01f, -5.17800637e-02f, -1.94856245e-02f, -2.72791218e-02f, 6.45620469e-03f, 2.63040811e-02f, 6.31846786e-02f,
  -3.51266205e-01f, -1.96435899e-02f, 3.39765519e-01f, -3.29855114e-01f, 4.49494943e-02f, 3.33880842e-01f, -1.48845948e-02f, 2.74872500e-02f, -1.49443492e-01f, -1.92040965e-01f,
  -1.13950416e-01f, -6.12818170e-04f, 2.13811174e-01f, -1.27853408e-01f, 3.47975463e-01f, 8.78920257e-02f, -7.77452365e-02f, -5.82342371e-02f, -1.24986293e-02f, -1.30035922e-01f,
  -3.73592153e-02f, -1.47545829e-01f, 2.11023822e-01f, -2.36460064e-02f, 4.53022793e-02f, -9.74280015e-02f, -1.58824995e-01f, 1.80064633e-01f, -1.21820673e-01f, 7.58487359e-02f,
  -3.26544791e-02f, -2.43091956e-01f, -2.16553900e-02f, -4.61065657e-02f, 8.69411081e-02f, 7.31987879e-02f, -9.02862474e-02f, -3.30751250e-03f, -9.61560607e-02f, 2.53632548e-03f,
  -1.13989912e-01f, 5.63247129e-02f, -6.72769621e-02f, 6.21680319e-02f, -1.09005339e-01f, 1.56008918e-03f, 8.92575979e-02f, 1.61177553e-02f, -5.12684404e-04f, 1.64878815e-01f,
  8.72460678e-02f, -5.05431890e-02f, 2.00389419e-02f, -1.14751803e-02f, 6.10561147e-02f, 4.02750075e-03f, 6.57224208e-02f, 8.61422494e-02f, 8.63225386e-02f, 4.18886244e-02f,
  6.78441077e-02f, 7.80537874e-02f, 4.93480675e-02f, -8.29754546e-02f, -2.47989781e-02f, -8.63711759e-02f, -1.12092085e-02f, -5.59936389e-02f, -3.04222982e-02f, -3.95791531e-02f,
  -2.04303395e-02f, -4.31698859e-02f, -1.07759118e-01f, -4.11593020e-02f, 2.88251173e-02f, -1.41539067e-01f, -1.75876040e-02f, -4.61937971e-02f, 8.00072104e-02f, 5.19943275e-02f,
  3.03639751e-02f, 1.02381170e-01f, 2.85585001e-02f, -2.38433201e-02f, 5.04119284e-02f, -2.68177055e-02f, -9.09678917e-03f, 6.64011240e-02f, -4.71601970e-02f, 8.58373418e-02f,
  -8.84193853e-02f, -1.75032794e-01f, -1.07079111e-01f, -9.07369182e-02f, -5.27113602e-02f, -6.10565096e-02f, -8.22255611e-02f, -2.36027595e-02f, -6.75200522e-02f, -1.28163606e-01f,
  -7.39311278e-02f, 1.01895649e-02f, -5.92979267e-02f, -1.25834942e-02f, 7.13151470e-02f, -6.27101064e-02f, -1.24480166e-01f, -9.68230143e-02f, -5.48828878e-02f, -4.13816779e-05f,
  2.77825613e-02f, -8.32341835e-02f, 5.72005622e-02f, -1.99426860e-02f, -6.71385974e-02f, -4.64259945e-02f, -7.89388344e-02f, -7.74009600e-02f, 6.40366450e-02f, 6.01342469e-02f,
  2.81193912e-01f, -2.35208079e-01f, 1.01368122e-01f, 7.11050555e-02f, 9.89465490e-02f, 5.48005030e-02f, 2.01293632e-01f, -1.88048974e-01f, 2.01374814e-01f, -2.59402663e-01f,
  -1.44830421e-01f, 1.18400238e-01f, 1.82589650e-01f, -2.56679028e-01f, 2.20624268e-01f, 1.49135605e-01f, -2.23211404e-02f, 1.33130886e-02f, -1.67332906e-02f, -5.41721620e-02f,
  -2.08485872e-03f, -1.40572399e-01f, -2.09272113e-02f, -3.49477321e-01f, -1.68871239e-01f, -2.30974168e-01f, -1.25536099e-01f, 5.63511103e-02f, -2.66116947e-01f, -3.04070953e-03f,
  4.37099040e-02f, -1.22972764e-01f, 2.58255694e-02f, -5.68836508e-03f, -1.26324790e-02f, 4.12145890e-02f, 5.04007638e-02f, 8.77743065e-02f, 3.44301667e-03f, 3.73568833e-02f,
  3.71005833e-02f, 3.05457367e-03f, -5.25792614e-02f, 9.98922288e-02f, -5.39960526e-02f, -5.35164438e-02f, -7.78278857e-02f, -8.30216035e-02f, -3.81828770e-02f, 1.02137886e-01f,
  1.89111698e-02f, -3.12690176e-02f, 3.29613946e-02f, -1.41454414e-01f, 3.40010114e-02f, 2.73240451e-02f, -6.08583307e-03f, -4.05325741e-02f, 4.66454923e-02f, 5.98035706e-03f,
  -3.27683636e-03f, 2.74216570e-02f, 3.43166925e-02f, -2.54840162e-02f, -4.60671540e-03f, 5.59120253e-02f, 2.11348198e-02f, 8.98521245e-02f, -9.49252173e-02f, -2.12118849e-02f,
  3.75268119e-03f, -3.91832041e-03f, -6.11507753e-03f, 7.10176528e-02f, 3.29733118e-02f, -7.12768286e-02f, -5.31033576e-02f, 1.96821522e-03f, -4.45175916e-02f, 9.23679620e-02f,
  8.67986381e-02f, -3.72030213e-02f, -1.65768079e-02f, -8.97036027e-03f, 4.86891419e-02f, 9.86226927e-03f, -3.05941366e-02f, 2.43422948e-02f, 7.79780447e-02f, 5.79600185e-02f,
  -9.08974092e-03f, -1.69695079e-01f, -8.68396163e-02f, -7.20882788e-02f, 5.29890060e-02f, -1.47760853e-01f, -4.66136262e-03f, -5.43504506e-02f, -2.60342676e-02f, 4.99819480e-02f,
  -5.27376682e-02f, 5.16122542e-02f, -1.85208954e-02f, 4.13645506e-02f, 1.05605824e-02f, -6.07625581e-02f, 5.78219146e-02f, -2.27644611e-02f, 2.45889276e-02f, -8.77055973e-02f,
  -1.58214848e-02f, -1.67792216e-02f, 6.93056267e-03f, -8.62390473e-02f, -1.41745389e-01f, -2.25666491e-03f, -2.98602805e-02f, -6.28672093e-02f, 6.65495768e-02f, 3.17727029e-02f,
  1.33841485e-01f, 2.30379879e-01f, 2.58923382e-01f, 2.20985532e-01f, -2.85537124e-01f, 1.27568364e-01f, 5.59821427e-02f, -4.57384847e-02f, 2.83368409e-01f, 1.84314698e-01f,
  -2.43961439e-01f, 3.04628372e-01f, -1.66616887e-01f, 1.36235401e-01f, -1.93431854e-01f, -2.05745641e-02f, 7.26124272e-02f, 2.60572970e-01f, 7.21980305e-03f, 7.16560408e-02f,
  -1.17465615e-01f, -2.04436347e-01f, -1.76256597e-01f, -2.52827287e-01f, 1.38016805e-01f, 1.62942782e-01f, -3.80373985e-01f, -1.33895621e-01f, 1.32823616e-01f, -5.31998910e-02f,
  2.61903256e-02f, 4.32627648e-02f, -8.88163224e-03f, 9.95035693e-02f, -4.06019241e-02f, 4.56444211e-02f, 1.09576518e-02f, -9.17021632e-02f, -3.37651446e-02f, 7.31085911e-02f,
  1.31553292e-01f, 1.57472957e-02f, 1.16037419e-02f, 4.01587086e-03f, -1.08640045e-02f, 5.17695025e-02f, -5.07318638e-02f, 8.62834677e-02f, 1.26844093e-01f, 7.18585923e-02f,
  1.03574105e-01f, 3.37830149e-02f, 1.20041268e-02f, 6.19433932e-02f, -3.98542993e-02f, -6.78170752e-03f, 9.31442380e-02f, -6.64353445e-02f, 8.22751597e-02f, 4.78786193e-02f,
  -1.12679742e-01f, -8.93933550e-02f, 1.35193914e-02f, -2.28966847e-02f, -1.35548422e-02f, -6.38761818e-02f, 2.66745631e-02f, -1.14158526e-01f, 7.56526068e-02f, -3.49164158e-02f,
  3.16722095e-02f, 1.43558690e-02f, -1.18159935e-01f, 6.85864314e-02f, -4.07756530e-02f, 6.80691749e-02f, -8.71051177e-02f, 1.20344171e-02f, 7.20899925e-02f, -9.07179564e-02f,
  -1.02161765e-01f, 6.34748116e-03f, -2.42199339e-02f, -1.09715499e-02f, 2.35322379e-02f, 2.54841074e-02f, 3.87675911e-02f, 9.42597315e-02f, -1.13836505e-01f, -6.23742267e-02f,
  3.59938107e-02f, -8.90730843e-02f, -2.21299529e-02f, 2.17718333e-02f, -2.81296764e-02f, 2.91000102e-02f, -6.58008605e-02f, 1.13039970e-01f, 1.40776187e-02f, -7.98891205e-03f,
  -4.77623455e-02f, 3.54667637e-03f, 2.91988626e-02f, -9.78950560e-02f, 6.11657910e-02f, -8.79287869e-02f, 8.31497833e-02f, 2.02003755e-02f, -9.04136673e-02f, -1.84265978e-03f,
  -7.55374786e-03f, -1.04976082e-02f, 4.00104113e-02f, -5.24719022e-02f, 4.47359830e-02f, -2.37514097e-02f, 1.39325466e-02f, 3.58629227e-02f, -4.84199971e-02f, -1.75837707e-02f,
  -5.17182425e-02f, -1.18504286e-01f, 6.99248537e-02f, 2.83947140e-01f, -1.34281650e-01f, -3.28373104e-01f, -2.51455665e-01f, 4.29221168e-02f, -1.61470830e-01f, -2.24039093e-01f,
  -8.86509493e-02f, 1.65509179e-01f, -1.26422778e-01f, 1.89130366e-01f, 1.25296354e-01f, -1.66185677e-01f, 1.03047691e-01f, 6.75566122e-02f, 6.50881082e-02f, 5.52223884e-02f,
  1.39917597e-01f, 1.33700699e-01f, 2.51240224e-01f, 2.53492236e-01f, 5.20249568e-02f, 2.58117080e-01f, 2.28305727e-01f, 8.09906572e-02f, 3.49915713e-01f, 1.47092581e-01f,
  -5.53805567e-02f, -4.67790850e-02f, -6.67128265e-02f, 1.22844214e-02f, -7.06578940e-02f, -5.62108159e-02f, -8.77379999e-02f, 1.22810632e-01f, 4.45810258e-02f, 7.81280175e-02f,
  2.09575836e-02f, 8.99201706e-02f, 1.32922217e-01f, 8.99766013e-02f, 1.01158423e-02f, 7.34420940e-02f, 2.52857413e-02f, -7.79188052e-03f, -2.23524161e-02f, -2.50099394e-02f,
  7.33533967e-03f, -9.99161303e-02f, 1.69608537e-02f, 4.18606140e-02f, 2.50783414e-02f, 2.26194784e-02f, 1.33447135e-02f, 8.79486576e-02f, 1.28180217e-02f, -1.51632056e-02f,
  -6.07901849e-02f, 2.64247246e-02f, 6.99913949e-02f, 5.46466224e-02f, 5.35707064e-02f, -7.46816257e-03f, -1.05915420e-01f, 3.43031138e-02f, 1.10244066e-01f, -1.20857872e-01f,
  4.71387878e-02f, 8.55004117e-02f, -3.93849425e-02f, -8.98680463e-02f, -5.02118049e-03f, -3.30729485e-02f, -2.43846476e-02f, 5.65337203e-02f, 9.06962976e-02f, 3.47951055e-02f,
  -6.07930198e-02f, 6.15251735e-02f, -3.77380066e-02f, -6.64870068e-02f, 7.98195042e-03f, 2.31964439e-02f, 2.72380356e-02f, -7.41892606e-02f, 8.01972598e-02f, 2.84945630e-02f,
  -1.24144897e-01f, 1.38584495e-01f, 2.25007087e-02f, 2.95658633e-02f, -2.12955140e-02f, 7.42632337e-03f, 2.96242014e-02f, 3.88867259e-02f, -1.23321498e-02f, -6.25116006e-02f,
  -2.10603513e-02f, 5.76945208e-02f, -5.06286658e-02f, 2.16698386e-02f, 3.76742296e-02f, -4.22128700e-02f, 4.09946479e-02f, 1.08780220e-01f, 7.97823444e-02f, 1.02283336e-01f,
  2.59117149e-02f, -6.55965284e-02f, 6.22152798e-02f, -1.01594231e-03f, 6.76166788e-02f, -6.74084648e-02f, -1.44888097e-02f, -9.46034119e-02f, 1.89138670e-02f, -1.09464824e-02f,
  3.20272386e-01f, 3.53540212e-01f, 2.48318940e-01f, 3.00661415e-01f, -3.12756337e-02f, -2.83718348e-01f, -7.19974414e-02f, 1.89669430e-02f, 2.14173391e-01f, -1.57971069e-01f,
  -8.73999894e-02f, 2.55347311e-01f, -1.75191253e-01f, 2.56891906e-01f, -1.29898489e-01f, -1.26469791e-01f, 2.57517010e-01f, 9.86049771e-02f, 1.07006796e-01f, 1.01553962e-01f,
  2.28468627e-01f, -9.20519382e-02f, 3.48582231e-02f, -1.45942494e-01f, 8.68020207e-02f, 8.27944055e-02f, -4.25697826e-02f, -1.29021198e-01f, -4.92246784e-02f, -1.49369678e-02f,
  -3.80070843e-02f, 6.16397187e-02f, 7.68155307e-02f, 5.08808941e-02f, 6.69004023e-02f, 2.12236028e-02f, -6.90293033e-03f, -1.25848368e-01f, -1.04112830e-02f, -3.46174873e-02f,
  3.81351868e-03f, -6.58800080e-02f, 9.74327233e-03f, -7.32447878e-02f, -4.02551703e-03f, -5.60742989e-02f, 1.10542938e-01f, 1.08165435e-01f, 1.81011539e-02f, 9.55894589e-02f,
  1.17154993e-01f, 1.06937230e-01f, -4.11675014e-02f, 1.25045357e-02f, 1.87002927e-01f, 4.32779901e-02f, 5.34331910e-02f, 6.27983809e-02f, -2.95554325e-02f, 1.83148697e-01f,
  9.00287996e-04f, -4.14477773e-02f, 4.17978643e-03f, -4.97318730e-02f, 1.49490060e-02f, 7.80649111e-02f, -7.92417303e-03f, 3.10491063e-02f, 1.10004641e-01f, -8.68376568e-02f,
  -7.42151663e-02f, 5.07596284e-02f, 2.79405359e-02f, -8.08657184e-02f, 9.85962898e-02f, 1.12549827e-01f, -5.25938673e-03f, -2.31445655e-01f, -3.06791114e-03f, 4.98855449e-02f,
  4.13002893e-02f, -1.76433120e-02f, -6.14892356e-02f, -8.25845897e-02f, -9.08800438e-02f, -4.76188660e-02f, -4.51017506e-02f, -5.90201654e-02f, 7.60217197e-03f, -1.21518979e-02f,
  -1.17506657e-03f, 2.26410538e-01f, 9.48753878e-02f, -9.20590460e-02f, 5.45548871e-02f, -8.64389688e-02f, -2.00742413e-03f, -1.86402686e-02f, 9.61283669e-02f, 2.88201123e-02f,
  -2.95129288e-02f, 5.14170341e-02f, 5.70519976e-02f, -1.37743615e-02f, 9.77621600e-03f, -8.72927776e-04f, -7.23790899e-02f, 1.16325065e-01f, 2.07441598e-02f, -1.80820432e-02f,
  -8.52082483e-03f, -1.36315376e-01f, 6.10549599e-02f, 6.02425337e-02f, 8.07921216e-02f, -2.66537108e-02f, -2.18440704e-02f, 2.89611928e-02f, -5.21373115e-02f, 1.99904330e-02f,
  5.31065837e-02f, -1.20118596e-01f, -6.68452159e-02f, 9.43218470e-02f, -5.45767210e-02f, -2.14953229e-01f, -3.16033602e-01f, -5.34223281e-02f, -1.90665856e-01f, -1.75688684e-01f,
  -2.75270902e-02f, 1.17271081e-01f, 5.63083068e-02f, 2.20831275e-01f, 2.95688897e-01f, 1.04480516e-02f, 5.74908555e-02f, -3.29360142e-02f, 1.49649903e-01f, 6.57594278e-02f,
  1.44247293e-01f, 1.81943372e-01f, 3.27853203e-01f, 1.72930971e-01f, 1.47467688e-01f, 9.70181227e-02f, 2.05605477e-01f, 1.31481916e-01f, 9.18979123e-02f, 9.32351965e-03f,
  -2.80562397e-02f, 1.38620868e-01f, 1.19266950e-03f, -4.89157364e-02f, 4.31889780e-02f, -3.75834033e-02f, -3.28934491e-02f, 1.04549617e-01f, -5.48514165e-03f, -3.46993282e-02f,
  -4.28755656e-02f, -2.48671491e-02f, -5.19913957e-02f, 7.25454688e-02f, -5.22720665e-02f, -5.80674112e-02f, -2.28262972e-02f, 3.10451351e-02f, -2.45102588e-02f, -4.52606240e-03f,
  -1.18391715e-01f, -6.31250367e-02f, 2.69996915e-02f, -1.51682822e-02f, 1.55135617e-02f, -4.90482710e-02f, 1.43342419e-02f, 5.18389009e-02f, -6.22576149e-03f, 9.27706901e-03f,
  8.07184502e-02f, -1.40498895e-02f, -4.20311280e-02f, -1.04378937e-02f, 3.38098779e-03f, -1.46735599e-02f, -3.12800333e-02f, 6.26994297e-02f, 5.09407744e-02f, 5.71654178e-02f,
  -2.89236084e-02f, -2.27481928e-02f, -3.77658159e-02f, -9.77807939e-02f, 3.48886885e-02f, -6.31594956e-02f, 1.71715789e-03f, 8.45446065e-02f, -6.56555519e-02f, 5.33483457e-03f,
  7.14314282e-02f, -8.49407464e-02f, -4.98699630e-03f, 6.70510009e-02f, -1.18468888e-01f, 1.99100599e-02f, 1.52207449e-01f, -2.90744435e-02f, 5.06542586e-02f, -7.00142235e-03f,
  8.68824050e-02f, 1.66974574e-01f, -4.63260785e-02f, -9.80967656e-02f, 7.19826669e-02f, -1.01679392e-01f, 9.90605801e-02f, 4.21146164e-03f, 9.42764133e-02f, 1.17151497e-03f,
  1.36020863e-02f, 4.78586555e-02f, 5.51287755e-02f, -6.66117296e-02f, 1.03167057e-01f, 7.34086111e-02f, 8.74070823e-02f, 4.99582402e-02f, 1.98491421e-02f, 2.76436079e-02f,
  8.99888054e-02f, 1.14087155e-02f, 2.31365897e-02f, -1.28050923e-01f, 2.35662386e-02f, 2.94363033e-02f, -9.62984934e-03f, 4.70875180e-04f, 1.90962176e-03f, 5.43676727e-02f,
  -1.76292643e-01f, -1.32600039e-01f, -1.93336830e-02f, -1.87288135e-01f, 1.57033771e-01f, -1.63200617e-01f, -1.80996582e-01f, -1.76701814e-01f, -7.31590018e-02f, -2.57771194e-01f,
  -3.17411572e-02f, -4.50028367e-02f, 1.68510303e-01f, -2.46100500e-01f, 2.25726321e-01f, 1.52691394e-01f, -2.20923513e-01f, -1.98210031e-01f, -1.16781734e-01f, -2.15484560e-01f,
  -6.11347817e-02f, -1.92914501e-01f, -5.05669378e-02f, -9.53754857e-02f, -2.25561678e-01f, -1.08214982e-01f, 2.25405563e-02f, 8.94159898e-02f, -1.64756581e-01f, 1.38898134e-01f,
  -1.95991680e-01f, -3.90715376e-02f, -4.02559573e-03f, 4.20395136e-02f, 1.06196222e-03f, -1.84327383e-02f, 6.72543496e-02f, 1.35154158e-01f, -1.11032158e-01f, -5.70038818e-02f,
  7.58874938e-02f, -9.64938023e-04f, -9.01928172e-02f, 3.23876217e-02f, -8.35243389e-02f, 7.19341636e-02f, -1.20368332e-01f, -4.11580913e-02f, 4.84606251e-02f, 4.69619669e-02f,
  -2.01033633e-02f, 1.11160718e-01f, 3.38852853e-02f, -7.01160654e-02f, 5.71074449e-02f, -4.09212150e-02f, 7.28257522e-02f, 1.20641999e-01f, 6.73529431e-02f, -1.27451167e-01f,
  7.81383365e-02f, -4.57571894e-02f, -1.68372430e-02f, -9.19916481e-03f, 2.08085068e-02f, -1.64178126e-02f, -1.05465405e-01f, -4.03305963e-02f, -5.01628593e-02f, -3.93989235e-02f,
  -4.59811762e-02f, 9.14883912e-02f, -5.58930971e-02f, -8.99333432e-02f, -8.20553601e-02f, 3.16461623e-02f, -1.11297732e-02f, -4.45593186e-02f, -8.70158225e-02f, -3.58850062e-02f,
  -9.57609639e-02f, -1.61271974e-01f, 7.21955076e-02f, 1.51636815e-02f, 5.87270260e-02f, 8.89249370e-02f, -7.40166530e-02f, 5.77960387e-02f, -5.19507490e-02f, 2.50370968e-02f,
  -3.02866578e-01f, -1.53673589e-01f, -5.81025817e-02f, -4.52485941e-02f, -6.28081635e-02f, 9.64090601e-02f, 3.45800142e-03f, -1.24141559e-01f, -4.78399955e-02f, 4.71253507e-02f,
  -1.43664896e-01f, 1.13753155e-02f, -1.66150257e-01f, -5.84203638e-02f, 2.75840610e-02f, -8.40013847e-02f, -2.44032219e-02f, 5.07407300e-02f, -1.14901960e-02f, 2.23885197e-02f,
  -3.61388698e-02f, -4.31536436e-02f, -2.95812208e-02f, 8.69025104e-03f, 4.57989573e-02f, 3.22556831e-02f, 7.39099160e-02f, 6.52389508e-03f, 3.89961191e-02f, 1.10116377e-01f,
  -1.91730201e-01f, 1.77923203e-01f, -1.85304955e-01f, -1.17720112e-01f, -8.30614008e-03f, -2.79634893e-01f, -3.18655640e-01f, 6.58208430e-02f, 4.94697355e-02f, -3.07758376e-02f,
  -1.40732557e-01f, -7.09223282e-03f, 1.20543987e-01f, -1.62646830e-01f, 7.25657400e-03f, 1.07760206e-01f, -2.70725936e-01f, -1.77906469e-01f, 1.37615427e-01f, -6.40412867e-02f,
  6.21628240e-02f, -9.11872685e-02f, -6.64218441e-02f, 7.65173435e-02f, -5.05843535e-02f, 4.87033743e-03f, -2.73593273e-02f, 9.40415356e-03f, -1.50855497e-01f, 9.83303264e-02f,
  -3.34327161e-01f, -1.64796397e-01f, -2.00929239e-01f, -5.42210676e-02f, -1.63164794e-01f, -6.01855330e-02f, -1.38548717e-01f, 1.82480067e-02f, -3.78450602e-02f, -3.22943404e-02f,
  2.08229180e-02f, 1.18943959e-01f, 2.51512453e-02f, 1.45725429e-01f, -1.51149649e-02f, -8.12777318e-03f, -4.83148210e-02f, -9.26092640e-02f, -3.91461179e-02f, 9.68559384e-02f,
  6.73432723e-02f, 2.48478968e-02f, -5.97150996e-02f, -2.31659878e-02f, 2.09295135e-02f, -5.02864793e-02f, -8.81685987e-02f, -1.48279555e-02f, -4.51240875e-02f, -2.13049762e-02f,
  9.16186273e-02f, -4.40326110e-02f, 2.76081469e-02f, -9.85123217e-02f, 8.44496340e-02f, 2.13052947e-02f, -2.35459562e-02f, 3.87568511e-02f, 7.46649364e-03f, 9.05316882e-03f,
  1.96692012e-02f, -6.70692697e-02f, -1.67165976e-02f, -4.27112989e-02f, 3.66557352e-02f, 4.10624668e-02f, -4.84777763e-02f, -4.05445024e-02f, 1.04326732e-01f, -5.95620647e-02f,
  -2.12767366e-02f, 8.23657122e-03f, 1.29314493e-02f, -2.15443112e-02f, 2.51773167e-02f, 8.17794800e-02f, -2.72754580e-02f, -9.46397614e-03f, -1.20257260e-03f, -1.87586318e-03f,
  -3.25617552e-01f, -3.01457316e-01f, -1.02782682e-01f, -1.23812281e-01f, 9.41196084e-02f, -5.50245084e-02f, -1.66439489e-02f, -4.77115139e-02f, -7.14645907e-02f, -1.35801220e-02f,
  -3.25751528e-02f, -7.51374438e-02f, -3.57136428e-02f, -8.02853424e-03f, 4.43583727e-02f, -9.13711563e-02f, -2.12805346e-02f, -9.87236798e-02f, -1.09915793e-01f, 2.50589438e-02f,
  -6.26142174e-02f, -2.66049225e-02f, -1.83567666e-02f, 4.26793434e-02f, -1.19006895e-02f, -1.74034853e-02f, -4.88697318e-03f, -3.38091403e-02f, -7.58038312e-02f, 4.55038883e-02f,
  -9.45998952e-02f, 1.87131107e-01f, 1.37178898e-01f, -8.13007727e-02f, 4.41645011e-02f, -1.87989011e-01f, -1.70738026e-01f, -7.91230872e-02f, -7.39724748e-03f, 9.51977968e-02f,
  -8.79028887e-02f, 2.73838699e-01f, 1.12952076e-01f, -8.59600678e-02f, -1.86268687e-01f, -1.10525809e-01f, -2.62931824e-01f, -9.81766731e-02f, 4.93728146e-02f, -8.80285501e-02f,
  -1.07845336e-01f, -3.09690118e-01f, -1.07246704e-01f, 3.98859717e-02f, -2.68753488e-02f, 2.10830732e-03f, -1.45017236e-01f, 1.40459344e-01f, -2.66368371e-02f, 7.95843378e-02f,
  -1.30696893e-01f, 1.16071150e-01f, 6.78249775e-03f, -1.63818325e-03f, -2.03196406e-01f, -1.19800925e-01f, -1.75280962e-02f, 7.16271773e-02f, -3.96139659e-02f, 1.01857923e-01f,
  -6.37130216e-02f, -7.92846754e-02f, 8.70096162e-02f, 2.87065804e-02f, 1.89405419e-02f, 1.35243058e-01f, 6.76616281e-02f, 3.72578725e-02f, 9.97995026e-03f, 1.09072268e-01f,
  1.33056909e-01f, 5.97452112e-02f, -1.21128246e-01f, 5.14923707e-02f, 5.97571693e-02f, 3.78540196e-02f, 1.44259515e-03f, -1.20310914e-02f, 8.08415562e-02f, 3.16758379e-02f,
  -1.64574847e-01f, -8.64793360e-02f, 8.81476887e-03f, -2.03089882e-02f, 1.00863036e-02f, 1.85590964e-02f, 1.01661183e-01f, -7.41349757e-02f, 1.37386639e-02f, 2.77580339e-02f,
  -1.12757310e-01f, 1.78796593e-02f, -3.11468393e-02f, -6.08018190e-02f, -9.18187425e-02f, 8.76814201e-02f, 3.37829092e-03f, 1.63305365e-02f, -7.74880871e-02f, 1.23878447e-02f,
  -9.47819576e-02f, -3.13057378e-02f, -1.15280159e-01f, -4.51444574e-02f, -5.30446246e-02f, 1.77298789e-03f, 9.33127925e-02f, 9.03845672e-03f, -1.97191373e-03f, -3.62894908e-02f,
  -3.42855781e-01f, -3.15919310e-01f, -4.57975566e-02f, 9.99288186e-02f, 8.69651884e-03f, 3.10080573e-02f, -2.07124129e-02f, 6.70360923e-02f, -5.69174029e-02f, 3.10909804e-02f,
  -5.32416292e-02f, -1.01434037e-01f, -7.36768078e-03f, -4.84910933e-03f, -1.49876386e-01f, -1.75435513e-01f, -1.06330045e-01f, 2.09659617e-02f, 4.65030130e-03f, 1.12619065e-02f,
  -5.70022203e-02f, -7.75662139e-02f, 7.14853853e-02f, 1.44845489e-02f, -4.19610366e-02f, -7.68918321e-02f, -2.60888729e-02f, 6.05345853e-02f, 2.43883636e-02f, -5.64630553e-02f,
  -2.54186183e-01f, 1.23510286e-01f, 3.26797813e-01f, 2.56532803e-02f, -1.31736532e-01f, 2.62144595e-01f, 3.71217519e-01f, -1.26781851e-01f, 4.78297994e-02f, 1.37257248e-01f,
  -7.44858012e-02f, 1.25110745e-01f, 1.56972468e-01f, -3.41162309e-02f, 2.58553892e-01f, 8.39473233e-02f, 2.54874136e-02f, 6.13779537e-02f, -8.30671415e-02f, -9.31755900e-02f,
  -5.69944503e-03f, -1.21372947e-02f, -3.40173431e-02f, -1.45021483e-01f, -9.40687284e-02f, -4.89632115e-02f, 3.06231845e-02f, 1.40028328e-01f, 6.07729703e-02f, 1.45648643e-02f,
  -9.05010030e-02f, -7.44545609e-02f, -2.15308264e-01f, 1.00299269e-01f, -9.81032327e-02f, 4.94866306e-03f, -2.80934256e-02f, 9.98289511e-02f, -2.49573700e-02f, 1.22323744e-01f,
  -1.14696054e-03f, -4.71797138e-02f, -4.58535850e-02f, -3.22496891e-02f, 8.63412209e-03f, -9.80960280e-02f, -7.39980265e-02f, -3.64174694e-02f, 2.33724676e-02f, -3.86062600e-02f,
  -3.57623994e-02f, 2.14081760e-02f, -1.63891725e-02f, 4.28592749e-02f, -1.00594923e-01f, -7.74073005e-02f, 9.49698314e-02f, 9.74003971e-02f, -4.90196981e-03f, 2.23236978e-02f,
  -3.79212126e-02f, 4.21568565e-03f, -2.28264891e-02f, 1.48919243e-02f, 5.17318137e-02f, -8.86174217e-02f, -1.70665551e-02f, 1.24826394e-02f, -1.89338550e-02f, -3.91598865e-02f,
  -4.86516021e-02f, -3.26119885e-02f, -4.15939577e-02f, -3.32622193e-02f, 1.58124622e-02f, 3.98156531e-02f, 1.56023344e-02f, -8.39558244e-02f, 4.19023670e-02f, -1.33661665e-02f,
  -3.41830440e-02f, -5.22861183e-02f, 1.09320681e-03f, -4.73475968e-03f, -5.29315919e-02f, 4.83377874e-02f, -2.39845030e-02f, -8.30535740e-02f, -6.50644377e-02f, 1.04910627e-01f,
  9.75183249e-02f, 1.97228029e-01f, -1.11209095e-01f, 9.21993982e-04f, 5.82041182e-02f, -3.19487900e-02f, 3.95063162e-02f, -8.47271532e-02f, 9.35922787e-02f, 8.47854465e-02f,
  -1.45805217e-02f, -5.17823473e-02f, 5.35752019e-03f, -6.72761053e-02f, -1.67644806e-02f, -3.41438390e-02f, -3.42753194e-02f, 1.07547939e-01f, 3.18144895e-02f, -4.68419343e-02f,
  -5.16065955e-02f, -3.20915096e-02f, 3.84192169e-02f, -9.50241089e-02f, 5.14737368e-02f, 7.62480199e-02f, -7.70581067e-02f, -1.71971004e-02f, 1.20304506e-02f, -3.53273787e-02f,
  2.59760886e-01f, 1.57990202e-01f, 1.58208832e-01f, 2.80777723e-01f, 2.43320968e-02f, 1.09028704e-02f, -3.92409321e-03f, 1.35438770e-01f, 1.73406288e-01f, -1.37589476e-03f,
  -9.70311835e-02f, 1.00246809e-01f, -1.15917906e-01f, -1.64962187e-03f, -2.73505807e-01f, -1.14397191e-01f, -9.46805775e-02f, -4.28785309e-02f, 1.44534959e-02f, 1.36781977e-02f,
  -4.09410782e-02f, -1.38886675e-01f, -2.19328534e-02f, 3.40323113e-02f, 2.08419144e-01f, 2.09606752e-01f, -1.81296930e-01f, -1.48088902e-01f, 1.56622648e-01f, -5.38407229e-02f,
  -5.93521399e-04f, 6.20629415e-02f, 5.03174700e-02f, -5.48066199e-03f, 3.98275116e-03f, -1.24248356e-01f, -1.10338265e-02f, -5.34497155e-03f, -2.65219770e-02f, 8.74756724e-02f,
  2.39081942e-02f, 1.11432970e-02f, 1.03649616e-01f, 5.45607358e-02f, -1.59401260e-02f, 6.04798682e-02f, 1.45509228e-01f, 1.59483358e-01f, 3.41814570e-02f, 9.83766094e-03f,
  1.67193133e-02f, 4.90962230e-02f, 4.46430920e-03f, 2.11971607e-02f, -8.65795910e-02f, -6.97003379e-02f, 1.11360140e-02f, -6.18487671e-02f, 8.17046613e-02f, 2.30820552e-02f,
  1.66704670e-01f, -6.18498363e-02f, -1.33536209e-03f, 1.00939803e-01f, -3.16593945e-02f, -3.08389645e-02f, -6.87378049e-02f, -5.32840602e-02f, 5.27008139e-02f, -7.07614645e-02f,
  -1.20506443e-01f, 6.50778711e-02f, 7.33201951e-02f, 5.27876392e-02f, 4.65548001e-02f, 4.17566150e-02f, -4.15824465e-02f, 6.11978956e-02f, 1.04220621e-01f, -2.91767996e-04f,
  -4.79445942e-02f, -1.01347335e-01f, 9.25247557e-03f, 5.81520610e-02f, -5.14664985e-02f, -5.44923879e-02f, -3.51706296e-02f, 8.68033543e-02f, -1.98835954e-02f, -1.41016766e-01f,
  -2.35710785e-01f, -2.71908879e-01f, -4.11962764e-03f, 6.24305122e-02f, -4.75173518e-02f, -3.78530733e-02f, -8.33101943e-02f, 7.20854625e-02f, -1.19416438e-01f, 1.14188381e-01f,
  -2.55983677e-02f, 1.18926801e-02f, 1.76427029e-02f, 4.44532605e-03f, 3.58638279e-02f, -1.17701709e-01f, -4.53984253e-02f, 3.26816440e-02f, -1.06820419e-01f, -2.13823710e-02f,
  1.51455343e-01f, -1.09351709e-01f, 2.56041787e-03f, -8.50421265e-02f, 2.27149315e-02f, 7.18954625e-03f, -8.98392722e-02f, 7.44057298e-02f, 2.59364415e-02f, -6.58696070e-02f,
  1.94977388e-01f, -6.24128059e-03f, -3.44176859e-01f, -7.72293732e-02f, -1.94868192e-01f, -2.12558985e-01f, -2.15447053e-01f, 1.30398804e-03f, 1.78061306e-01f, 1.05331764e-01f,
  -8.34220275e-02f, 1.34521127e-01f, 3.81369978e-01f, -1.56318337e-01f, 4.66546565e-02f, 1.41835824e-01f, -1.26540914e-01f, 4.44077440e-02f, 5.74903004e-02f, 3.70582268e-02f,
  -8.53225589e-03f, 5.79421744e-02f, -9.88513306e-02f, -1.94454137e-02f, -2.35850796e-01f, -1.86012790e-01f, 2.30382755e-02f, -2.37589493e-01f, -2.38034859e-01f, -1.02809161e-01f,
  -1.89956576e-01f, -3.55404653e-02f, -1.22902706e-01f, -7.10389465e-02f, -6.83641359e-02f, -2.88668815e-02f, -2.06566513e-01f, -1.53629363e-01f, 5.13214094e-04f, -6.43431991e-02f,
  1.92629229e-02f, 7.56019726e-02f, -3.48844044e-02f, 1.37054265e-01f, 1.60572119e-02f, -9.62761343e-02f, -7.01902583e-02f, -1.25815675e-01f, 5.93368523e-02f, 2.94905459e-03f,
  -1.48800820e-01f, -1.59907922e-01f, -1.55478850e-01f, -1.59032568e-02f, -1.27011403e-01f, -1.11381859e-01f, 2.29311325e-02f, 1.52599411e-02f, -1.72845319e-01f, -6.92898557e-02f,
  8.64373893e-02f, -1.77203119e-02f, -4.39377166e-02f, 9.00020227e-02f, -5.64586557e-02f, -1.32924125e-01f, 9.19526890e-02f, -3.48573737e-02f, -4.29738797e-02f, -5.99329844e-02f,
  -1.35892695e-02f, 1.94547419e-02f, -5.82106598e-02f, 1.85178779e-02f, -1.32485237e-02f, 1.35096768e-02f, 1.22707382e-01f, -5.29748686e-02f, -1.28055019e-02f, -3.46742794e-02f,
  6.38108552e-02f, -6.98404983e-02f, -6.52312338e-02f, -7.24688098e-02f, 5.90525158e-02f, 3.32905091e-02f, 7.32549056e-02f, -3.63251269e-02f, 5.38587272e-02f, -2.58863717e-02f,
  -6.32339194e-02f, -1.49761308e-02f, 3.21161114e-02f, -9.87657160e-02f, 2.76253372e-02f, -6.24379590e-02f, 6.91936389e-02f, 5.67995152e-03f, -1.56936273e-01f, 4.23639491e-02f,
  5.53804114e-02f, -5.75576462e-02f, -4.08137031e-02f, 1.16233453e-02f, 9.32854426e-04f, 4.66835685e-02f, 9.16682780e-02f, 1.69621095e-01f, -8.15344080e-02f, 3.59024331e-02f,
  5.60411848e-02f, 1.30870908e-01f, 7.55203739e-02f, -5.15413657e-02f, 2.67487913e-02f, 2.97694225e-02f, -4.49915708e-04f, -6.03648424e-02f, -4.34796792e-03f, 6.97295219e-02f,
  2.84128010e-01f, 1.39812469e-01f, 1.21733427e-01f, 1.66241407e-01f, -6.90903068e-02f, 2.07052398e-02f, -2.64566336e-02f, -1.60714447e-01f, -2.71660611e-02f, 6.04988188e-02f,
  -1.68053553e-01f, 2.24610284e-01f, -9.77527574e-02f, 6.59729987e-02f, -2.47832119e-01f, -2.05175862e-01f, 9.06080604e-02f, 2.66799126e-02f, -1.43318698e-01f, -7.28841731e-03f,
  -1.06830209e-01f, -1.66334987e-01f, -5.58133274e-02f, -2.89523210e-02f, 1.70878276e-01f, 9.43478644e-02f, -1.82692990e-01f, -7.68093616e-02f, 1.74100175e-01f, -1.64570451e-01f,
  -3.39174233e-02f, -3.83327599e-03f, 2.25399490e-02f, 4.77858335e-02f, 5.04249707e-02f, 5.47392666e-02f, 9.09149498e-02f, -3.19116786e-02f, 4.75497171e-02f, -5.61883394e-03f,
  1.08095728e-01f, 4.01902013e-02f, 3.02707087e-02f, -6.72494546e-02f, 1.22347705e-01f, 8.88647065e-02f, -1.84505973e-02f, 1.32564247e-01f, -2.45328993e-02f, -2.92882472e-02f,
  8.63849074e-02f, 6.60039112e-02f, 1.59067616e-01f, 6.06573038e-02f, 4.55860607e-02f, 3.63146290e-02f, 8.20664316e-02f, 2.47413088e-02f, -4.85416614e-02f, -6.35451972e-02f,
  -1.31194515e-03f, -5.97425997e-02f, -3.14117037e-02f, 6.27214834e-02f, -8.14141780e-02f, 3.52196060e-02f, 2.60252785e-02f, -4.16713320e-02f, -3.53000909e-02f, 4.08289172e-02f,
  -4.95258421e-02f, 3.13485377e-02f, -1.65567230e-02f, 9.07631963e-02f, 9.53230169e-03f, 5.03968820e-02f, -1.83401827e-03f, -3.10018752e-02f, 7.91604817e-02f, 3.91111374e-02f,
  -1.99965406e-02f, 1.14501817e-02f, -4.45916504e-02f, 6.54830486e-02f, -9.12748370e-03f, 1.14530614e-02f, -3.71888317e-02f, 7.40077719e-02f, 3.66655886e-02f, 5.72331585e-02f,
  -1.78895853e-02f, -8.73292983e-02f, 3.78698185e-02f, 1.10212620e-02f, -7.69751333e-03f, 1.89104974e-02f, -1.38890827e-02f, -3.50874253e-02f, 2.15396266e-02f, -2.43799649e-02f,
  8.25171620e-02f, 1.03046954e-01f, 2.27245092e-02f, 4.31156419e-02f, -4.30765823e-02f, -6.57162517e-02f, 1.01988174e-01f, -3.94523377e-03f, -2.48358026e-02f, -2.58406880e-03f,
  1.02887787e-01f, 3.50124948e-02f, 6.86716139e-02f, 1.03272088e-01f, 6.55615628e-02f, -2.42805593e-02f, 5.52519672e-02f, -3.65409441e-03f, -4.14327793e-02f, 7.89789408e-02f,
  1.94755197e-01f, -2.57611305e-01f, -2.49834374e-01f, -9.83850583e-02f, 1.44731835e-01f, 7.37339407e-02f, -1.91988364e-01f, 1.35368139e-01f, -1.93084180e-01f, 1.03468597e-01f,
  1.11546576e-01f, -1.29982442e-01f, -2.81195551e-01f, -1.22387573e-01f, -7.64847770e-02f, -2.30856508e-01f, 9.94826555e-02f, 3.75769846e-02f, -1.13058850e-01f, 6.47758506e-03f,
  5.47852218e-02f, 4.74124104e-02f, -1.75539121e-01f, 2.68285573e-01f, 2.07479224e-01f, 1.59041479e-01f, 2.84038752e-01f, 4.85068597e-02f, 1.61698416e-01f, 1.30291894e-01f,
  -3.03401286e-03f, -2.87754163e-02f, -1.33027330e-01f, -6.07803173e-04f, 7.73436204e-02f, 1.51011139e-01f, 6.78728521e-02f, -1.30908757e-01f, -8.59892890e-02f, -9.28418934e-02f,
  9.46650356e-02f, -2.23002117e-02f, -3.22484821e-02f, 5.22643104e-02f, 7.77018964e-02f, 1.33899255e-02f, -1.21033631e-01f, -5.49793765e-02f, -7.01018125e-02f, -1.75711274e-01f,
  -6.36155978e-02f, 2.00499576e-02f, 1.18764184e-01f, 4.62623639e-03f, -2.29583178e-02f, 1.54078687e-02f, 9.95779335e-02f, -1.37885315e-02f, 1.47031695e-01f, 2.14117374e-02f,
  2.10956857e-02f, 1.58952013e-01f, -7.27414638e-02f, -1.96010247e-01f, -8.32424313e-03f, -6.99054301e-02f, -9.82707459e-03f, -7.82796592e-02f, 6.11647672e-04f, -2.87160557e-02f,
  -2.52139438e-02f, 2.38637403e-02f, -1.58525053e-02f, 3.49899232e-02f, 7.14976415e-02f, 1.23786256e-02f, 6.59931749e-02f, -3.55682522e-02f, -5.13734519e-02f, -9.73641053e-02f,
  -5.81002906e-02f, 1.11041777e-01f, -2.56780144e-02f, 3.94538091e-03f, 4.10847887e-02f, 3.16005163e-02f, -6.60087820e-03f, 1.59075148e-02f, 4.47823294e-03f, -2.90225563e-03f,
  1.27203718e-01f, 2.01110095e-02f, -9.60935131e-02f, -8.74087438e-02f, 2.08640136e-02f, 7.86619633e-02f, 4.14849259e-02f, -6.36275113e-02f, 1.98324770e-02f, 3.74409966e-02f,
  1.26255706e-01f, 8.35669935e-02f, 7.54657388e-02f, 5.91337569e-02f, 8.02007243e-02f, -4.03074324e-02f, 5.45552336e-02f, -1.18561415e-02f, 1.85641497e-01f, -1.04370425e-02f,
  1.45507440e-01f, 4.25416045e-03f, 4.73588780e-02f, -5.85651249e-02f, -1.17445998e-02f, 9.14637893e-02f, 1.11281842e-01f, 7.47638103e-03f, -1.01758530e-02f, -7.13864155e-03f,
  -4.50322270e-01f, 5.59713580e-02f, 2.64205575e-01f, -1.47859454e-02f, 1.53658375e-01f, 3.94153595e-01f, 2.06804544e-01f, 2.80788124e-01f, 3.42760198e-02f, 7.59743229e-02f,
  9.83552560e-02f, -2.23523259e-01f, 1.07759640e-01f, -3.22643705e-02f, 1.97343454e-01f, 9.20606256e-02f, 1.69996947e-01f, -4.04231586e-02f, -1.13727421e-01f, -8.94766524e-02f,
  -3.79906334e-02f, -6.32607788e-02f, 4.03017737e-02f, -8.73775408e-02f, 3.59728597e-02f, -1.37522340e-01f, -1.53567776e-01f, -1.47114754e-01f, -2.72053052e-02f, -7.67208403e-04f,
  2.30631195e-02f, -1.17211118e-01f, -1.44413216e-02f, 3.92218716e-02f, 4.63528074e-02f, 4.31119949e-02f, -1.09438129e-01f, -8.26214924e-02f, -8.67545083e-02f, 8.16471800e-02f,
  -8.21880102e-02f, 6.50680512e-02f, 3.92328948e-02f, -9.02211145e-02f, 3.93244848e-02f, 1.03269018e-01f, 6.51161224e-02f, 1.16620563e-01f, 1.45626040e-02f, 2.71525141e-02f,
  1.06029384e-01f, 1.38230428e-01f, 6.18390292e-02f, -7.82388374e-02f, 4.45751511e-02f, 7.82983750e-03f, 3.56256478e-02f, -1.48568600e-02f, 4.08932567e-02f, 7.61634186e-02f,
  -4.45066094e-02f, -9.37882215e-02f, 9.44567695e-02f, 8.77519101e-02f, -5.24403602e-02f, -4.19689517e-04f, -1.31406151e-02f, -1.89864868e-03f, -7.72288144e-02f, -9.56661925e-02f,
  -5.70529215e-02f, 1.68693322e-03f, -4.50019576e-02f, 4.96438565e-03f, -4.44312356e-02f, 3.66187133e-02f, -3.47202420e-02f, 5.67599535e-02f, 7.33511820e-02f, -2.79248655e-02f,
  1.55956922e-02f, -1.01815618e-03f, 5.32475337e-02f, 5.68607301e-02f, -2.07985416e-02f, 3.52634676e-03f, -1.04034692e-01f, 1.47231996e-01f, 6.56162500e-02f, -2.95914095e-02f,
  -9.01925638e-02f, -1.39113560e-01f, -9.17629600e-02f, -6.50917590e-02f, -7.48202950e-02f, 6.97039962e-02f, -7.03338310e-02f, 7.67502934e-02f, -6.90951422e-02f, 6.22832961e-02f,
  8.35637003e-02f, -8.51863995e-02f, -6.61312491e-02f, -4.78834063e-02f, -3.05008385e-02f, 1.96110711e-01f, -1.14557512e-01f, 1.80004928e-02f, -4.59183194e-02f, 5.67568392e-02f,
  1.70644242e-02f, -1.11771874e-01f, 2.38360707e-02f, -1.06523708e-01f, -4.80536558e-02f, 1.63345542e-02f, -1.05861180e-01f, -2.06021704e-02f, 2.96699908e-02f, -8.09540898e-02f,
  2.13313818e-01f, 5.05532734e-02f, -6.23121597e-02f, -8.77607167e-02f, -2.54690289e-01f, -3.03552002e-02f, -1.75443336e-01f, -4.65715155e-02f, 2.02608749e-01f, 7.91858695e-03f,
  -1.11729264e-01f, 1.81286633e-01f, 6.38365448e-02f, -1.15211271e-01f, 2.29052037e-01f, 1.05833694e-01f, -7.24620521e-02f, -8.71279761e-02f, -1.21938586e-02f, -4.34122235e-02f,
  3.17187719e-02f, -5.30919060e-02f, -2.30413750e-01f, -7.35841400e-04f, -2.58480102e-01f, -9.66003686e-02f, -1.20180398e-01f, -2.37624839e-01f, -1.89061016e-01f, -1.01889372e-01f,
  -6.62992075e-02f, 1.45054758e-01f, -1.50585733e-02f, 9.35077444e-02f, 7.65051320e-02f, -8.06759074e-02f, 1.39241358e-02f, 1.18294992e-02f, 1.29866693e-02f, 3.86887556e-03f,
  7.83026889e-02f, 5.97400451e-03f, 5.79017401e-02f, -3.69798243e-02f, -1.26791606e-02f, 1.09181106e-01f, 5.92585057e-02f, -7.15455338e-02f, -3.11887786e-02f, -2.10475978e-02f,
  -1.49306327e-01f, -1.16034318e-02f, -5.42432331e-02f, 2.57773511e-02f, 6.59011602e-02f, 1.07311331e-01f, -4.57570069e-02f, -4.89632152e-02f, -6.13901317e-02f, 4.73594815e-02f,
  3.82653996e-02f, 5.28765991e-02f, 2.97204573e-02f, -9.69205610e-03f, -3.91637012e-02f, -4.13197316e-02f, -7.31463730e-02f, 8.45263600e-02f, 1.24058791e-01f, -4.54864977e-03f,
  -4.62533720e-02f, 5.95348999e-02f, 3.48012298e-02f, -9.82561260e-02f, -4.23899256e-02f, -3.17239799e-02f, 4.48456444e-02f, -3.12523521e-03f, 1.82492770e-02f, -4.69790213e-02f,
  4.31648009e-02f, 8.25478062e-02f, -4.85224985e-02f, -3.65998186e-02f, -3.43401767e-02f, 3.36861648e-02f, -8.90508443e-02f, -3.96236638e-03f, -3.30965631e-02f, -3.65801528e-02f,
  1.06813997e-01f, 7.80115500e-02f, -3.42019461e-02f, 5.66033125e-02f, -1.91259105e-03f, 1.12797663e-01f, 7.31342519e-03f, -2.42152344e-03f, 1.26911521e-01f, 4.09647003e-02f,
  3.21036577e-02f, 6.41624928e-02f, -5.90341650e-02f, -6.01383969e-02f, 4.36056666e-02f, 1.21428862e-01f, 9.98503342e-02f, -6.99600652e-02f, 4.29806439e-03f, -1.19788632e-01f,
  -1.36497736e-01f, 1.33068159e-01f, 7.25072473e-02f, 2.42381934e-02f, -3.55076371e-03f, -8.19461141e-03f, 4.81675901e-02f, 4.08861339e-02f, 2.37454157e-02f, 1.02531135e-01f,
  -2.05449775e-01f, -5.01860976e-02f, -3.11521620e-01f, -6.97060972e-02f, 5.68822287e-02f, -4.90675330e-01f, -5.24411052e-02f, -7.40524009e-02f, 1.57677770e-01f, 2.37749517e-01f,
  2.22962871e-01f, 6.43654019e-02f, 1.26947954e-01f, -8.39525014e-02f, -3.54520857e-01f, -3.65931243e-02f, -3.39937747e-01f, -1.51533857e-01f, 6.12415746e-02f, -1.35095403e-01f,
  -1.25263423e-01f, 1.20451607e-01f, -1.21142171e-01f, 1.83053672e-01f, -7.31556714e-02f, 4.42947559e-02f, -8.46135058e-03f, 2.07006007e-01f, -2.05392167e-01f, -1.78836193e-02f,
  5.77809624e-02f, 2.43023977e-01f, 7.47600421e-02f, -4.62807417e-02f, -2.36844778e-01f, -6.23391103e-03f, -9.92831662e-02f, 8.58200863e-02f, 5.65054186e-04f, 1.07824076e-02f,
  -2.32558474e-02f, -3.69177982e-02f, -3.97685692e-02f, 1.17096081e-01f, 1.12551853e-01f, 2.53257286e-02f, -3.05207558e-02f, -1.69075787e-01f, 6.24058731e-02f, -1.07470877e-01f,
  3.72712240e-02f, -1.08905084e-01f, -8.54042172e-02f, -5.04519828e-02f, -1.23316973e-01f, 3.62468511e-02f, -1.30237684e-01f, -1.91297326e-02f, -7.89392889e-02f, -6.78594112e-02f,
  -2.22926605e-02f, 2.24874937e-03f, 6.65971786e-02f, 1.70341711e-02f, 2.40832120e-02f, -1.79111790e-02f, 5.33269681e-02f, 9.19761509e-02f, -2.30621174e-03f, -2.16588154e-02f,
  -4.91258837e-02f, 2.83682588e-02f, 7.13154525e-02f, -1.36385113e-01f, -7.96379969e-02f, -6.41823262e-02f, -5.97265065e-02f, 8.25536326e-02f, -7.17239752e-02f, -4.81387042e-02f,
  1.63970694e-01f, -2.26156488e-02f, 7.71020800e-02f, -6.44686224e-04f, -3.75085138e-02f, -3.01323999e-02f, 3.22629623e-02f, -9.84218046e-02f, -8.73291194e-02f, -4.09539342e-02f,
  -5.93262687e-02f, -1.05605394e-01f, 8.80698785e-02f, 1.05014123e-01f, 7.33912289e-02f, -2.01301761e-02f, -1.07757516e-01f, -9.99073908e-02f, 2.65502576e-02f, -9.08705369e-02f,
  -7.57148191e-02f, 8.38906690e-02f, -1.34356111e-01f, 2.73969360e-02f, -5.11425314e-03f, -6.32763207e-02f, 9.99645237e-03f, -9.33800917e-03f, -1.50444293e-02f, -8.12537894e-02f,
  6.68066666e-02f, 6.75911233e-02f, -9.20875091e-03f, -3.59591320e-02f, -6.65815324e-02f, 5.50631844e-02f, -3.08135394e-02f, 5.53555749e-02f, 4.73241741e-03f, 4.73913886e-02f,
  -3.32022637e-01f, 1.92831419e-02f, -2.02637196e-01f, 4.43050191e-02f, 3.94133255e-02f, 1.49611518e-01f, 1.97071582e-03f, -1.85716599e-02f, -2.00688988e-01f, 1.43966049e-01f,
  2.53906399e-01f, -2.07785264e-01f, -8.66445750e-02f, 2.72552639e-01f, -1.33077186e-02f, 2.02288702e-01f, 2.83824205e-01f, 1.35660514e-01f, 3.83865945e-02f, -1.33906648e-01f,
  -8.24023560e-02f, 3.53115112e-01f, 1.04946844e-01f, 6.21731095e-02f, 7.93496296e-02f, -2.28546083e-01f, 4.24599200e-02f, -1.49348259e-01f, 2.06723750e-01f, 3.08131315e-02f,
  1.69703647e-01f, -1.80330396e-01f, -1.86902415e-02f, -1.24904007e-01f, -1.07722193e-01f, -5.63601144e-02f, -1.42682225e-01f, 3.65904793e-02f, -7.40020499e-02f, 7.76390806e-02f,
  -1.71167910e-01f, -8.99215788e-03f, 4.18322794e-02f, -6.56769574e-02f, 2.87474822e-02f, -7.14948121e-03f, -2.41533015e-02f, 1.85360108e-03f, -5.87224215e-03f, 2.54066791e-02f,
  9.67354421e-03f, 4.06385437e-02f, -1.56593192e-02f, 9.80450492e-03f, -6.98863491e-02f, -8.01566318e-02f, -2.15235576e-02f, -9.79816467e-02f, 3.10971891e-03f, -1.09874859e-01f,
  6.90141832e-03f, -4.98061180e-02f, 5.75384833e-02f, 8.44413880e-03f, 1.10834211e-01f, 1.09936498e-01f, -2.50139907e-02f, 9.15896371e-02f, -9.41762775e-02f, 5.20465225e-02f,
  5.05270958e-02f, -2.00418849e-03f, -1.10610805e-01f, 2.99094841e-02f, 4.00372557e-02f, 3.99975777e-02f, 3.92879918e-02f, -3.40765938e-02f, 3.89293022e-02f, -4.69636201e-04f,
  -1.34765543e-02f, -5.75720631e-02f, 1.49093354e-02f, 9.79726762e-02f, -3.86224650e-02f, -5.48684187e-02f, 2.65048500e-02f, -2.11153533e-02f, -1.31873386e-02f, -4.67389561e-02f,
  4.73770918e-03f, -2.57976651e-01f, -7.11400211e-02f, 4.54295017e-02f, 5.64366244e-02f, 1.05315104e-01f, -3.27878781e-02f, -3.48767415e-02f, -8.89879391e-02f, 3.72633549e-05f,
  -9.94254500e-02f, -1.06541708e-01f, 1.43384803e-02f, -5.99856414e-02f, -5.74135408e-02f, 6.37965128e-02f, -3.65521386e-02f, -3.39779332e-02f, 3.45644802e-02f, -9.47666392e-02f,
  -3.08399368e-02f, -3.76355159e-03f, -5.58958314e-02f, 3.74366194e-02f, 1.04982264e-01f, 4.52902764e-02f, -2.07252726e-02f, -6.36297315e-02f, 6.42009825e-02f, 4.15353477e-02f,
  2.44245693e-01f, -1.76905766e-02f, -2.34396875e-01f, 6.29731640e-02f, 3.73510607e-02f, 1.43834263e-01f, -2.21479699e-01f, 2.94672027e-02f, -2.96260893e-01f, -8.63786880e-03f,
  3.14937197e-02f, -6.52429536e-02f, -2.88231671e-01f, 3.64365727e-01f, 3.70758951e-01f, -2.22133860e-01f, 2.49209851e-01f, 1.28393158e-01f, -1.17759772e-01f, 3.40335481e-02f,
  -3.41907516e-02f, 4.20170933e-01f, -3.53544205e-02f, 3.21130812e-01f, 1.28063709e-01f, 7.68088624e-02f, 1.40418187e-01f, -7.35346600e-02f, 2.81443775e-01f, 2.31402889e-01f,
  1.16070718e-01f, -5.76655194e-02f, 2.98812650e-02f, 7.24517554e-02f, -3.74096334e-02f, -7.48854429e-02f, -3.80687648e-03f, 1.09874979e-01f, -1.39453961e-02f, -4.84330989e-02f,
  1.16168689e-02f, 1.19604461e-01f, 5.96781895e-02f, -2.12406795e-02f, 1.21151671e-01f, -5.60895074e-03f, -8.04275051e-02f, -1.60077855e-01f, 2.47019436e-03f, 4.70740460e-02f,
  -1.22355454e-01f, 3.47541086e-02f, -9.82096344e-02f, -1.49350995e-02f, -6.60758987e-02f, -1.65323855e-03f, 1.76327992e-02f, -9.27788913e-02f, -6.47238940e-02f, 1.09660350e-01f,
  1.81806851e-02f, 1.76914334e-02f, 1.28964409e-02f, 1.65072326e-02f, -1.82062034e-02f, -2.11404357e-02f, 8.65106732e-02f, 1.59677342e-02f, -1.09672239e-02f, -3.24440040e-02f,
  1.68677364e-02f, 6.67633414e-02f, -3.54452357e-02f, -7.52554163e-02f, -3.72158969e-03f, 3.92522998e-02f, -8.79959017e-02f, -5.08820377e-02f, -1.44585386e-01f, 5.29053947e-03f,
  -2.35041045e-02f, -1.99959707e-02f, -4.20021033e-03f, 4.73605543e-02f, 8.31594840e-02f, -2.97960080e-02f, 1.92069844e-03f, -9.88835096e-02f, -1.28696173e-01f, 3.12075168e-02f,
  -9.40365251e-03f, -1.96727621e-03f, -4.96064201e-02f, 5.97764440e-02f, -5.52533045e-02f, 4.44447547e-02f, 9.89255495e-03f, 1.98560134e-02f, 2.52457466e-02f, -1.49844494e-02f,
  -3.31850760e-02f, -7.23463967e-02f, -2.64616148e-03f, 1.50601054e-02f, 1.02339782e-01f, -1.02748938e-01f, -1.54631399e-02f, -5.24329543e-02f, -3.25152427e-02f, 7.95533881e-02f,
  -4.75479886e-02f, -3.85878198e-02f, 2.83974037e-02f, 1.17023066e-02f, -3.84545065e-02f, -6.81538805e-02f, -2.65695378e-02f, 7.29571376e-03f, 1.04011968e-01f, -8.71322900e-02f,
  -1.44280106e-01f, 3.98126155e-01f, 2.87580192e-01f, -1.43398151e-01f, 6.32890016e-02f, -5.96301220e-02f, -1.17270164e-01f, 7.00821653e-02f, -3.29727381e-02f, 4.74515185e-02f,
  -1.61251202e-01f, 1.90105379e-01f, -6.31659245e-03f, 4.85243201e-02f, -2.76779741e-01f, -2.09250540e-01f, -2.68395066e-01f, -1.09458782e-01f, -2.51356885e-02f, -9.01962370e-02f,
  -6.39808998e-02f, -2.28004083e-01f, -1.27043709e-01f, 1.02148078e-01f, 5.91811202e-02f, 6.94515333e-02f, -2.21436054e-01f, 7.57359341e-02f, 7.78118446e-02f, 5.39724901e-02f,
  -4.21937779e-02f, -2.18336117e-02f, -6.26158789e-02f, -2.52966173e-02f, -4.83275056e-02f, 7.64424801e-02f, -6.76152632e-02f, -1.37431361e-02f, -6.47270605e-02f, 9.58872959e-02f,
  8.21373686e-02f, 4.55869846e-02f, -1.93807147e-02f, -5.93746640e-02f, 6.65610582e-02f, -5.93383703e-03f, 3.33462395e-02f, 2.53645740e-02f, 1.26624018e-01f, -1.05523206e-02f,
  8.63067433e-03f, 1.04407512e-01f, 5.47375716e-02f, -1.08696051e-01f, -3.23630273e-02f, 1.23984434e-01f, -1.82636417e-02f, -6.74932599e-02f, 1.50106037e-02f, 7.97495767e-02f,
  1.51267946e-01f, -1.34088755e-01f, -5.40823899e-02f, 8.98019820e-02f, -9.00463574e-03f, 4.41074893e-02f, -5.01487255e-02f, -1.03741273e-01f, -2.39511449e-02f, -4.51682694e-02f,
  4.07428620e-03f, -1.11815855e-02f, 3.14320847e-02f, -7.49073401e-02f, 1.26527371e-02f, -2.47339588e-02f, 3.24746892e-02f, 2.41416134e-02f, -3.29113118e-02f, -1.59817077e-02f,
  -5.16124628e-02f, -3.49122025e-02f, 8.56294557e-02f, -7.86011741e-02f, 1.02572329e-01f, 7.44884973e-03f, -9.26259235e-02f, 9.29849297e-02f, -9.30333659e-02f, -1.71573177e-01f,
  -1.57087579e-01f, -1.38695940e-01f, -9.79257748e-02f, 2.67979745e-02f, -3.64433625e-03f, -5.94738685e-02f, -8.93535390e-02f, -5.58734126e-03f, -9.87593383e-02f, 1.06519070e-02f,
  9.35116783e-02f, -2.02738717e-02f, -6.57734349e-02f, -5.07574193e-02f, -4.89931405e-02f, 2.63111684e-02f, -3.97128500e-02f, 1.58939399e-02f, -7.59827197e-02f, 3.32552977e-02f,
  -7.06216320e-02f, -9.60570201e-02f, 6.47213161e-02f, -6.10216632e-02f, -6.05017915e-02f, -3.29585816e-03f, -7.20144659e-02f, 7.31318910e-03f, -2.17016023e-02f, -2.57699564e-02f,
  -1.35241911e-01f, 9.95169654e-02f, 5.89610217e-03f, -1.92147434e-01f, 2.13054180e-01f, -3.09073865e-01f, -6.32733628e-02f, 2.29778349e-01f, 1.43335238e-01f, 1.10836299e-02f,
  3.30596305e-02f, -3.49099142e-03f, 2.50244588e-01f, -7.06349313e-02f, -1.73669025e-01f, -8.48966539e-02f, -2.73307651e-01f, -1.63614839e-01f, 8.45512077e-02f, -1.19686611e-01f,
  -2.34528612e-02f, 4.37063873e-02f, 4.18461785e-02f, 2.86788791e-01f, -3.14247720e-02f, 6.33807480e-02f, -2.26023227e-01f, 2.89789766e-01f, -9.82205570e-02f, 4.30091433e-02f,
  -2.29703691e-02f, 6.30639791e-02f, -4.26661596e-02f, -3.78907435e-02f, -1.47061363e-01f, -1.20186433e-02f, -1.26987666e-01f, 4.47075516e-02f, 5.86315664e-03f, 8.72716010e-02f,
  2.81898119e-02f, -9.07765888e-03f, -3.93419415e-02f, 4.47244048e-02f, 1.33078277e-01f, 1.67476833e-02f, 2.85967644e-02f, -1.08004503e-01f, 1.07180521e-01f, -8.24039523e-03f,
  4.14673984e-02f, -8.72008055e-02f, -5.88223115e-02f, 1.96139812e-02f, -2.36152485e-02f, -3.20457406e-02f, -4.05177027e-02f, -1.11319527e-01f, -3.70791815e-02f, -2.47892328e-02f,
  5.47284773e-03f, -8.82179141e-02f, -5.15455157e-02f, 1.24573454e-01f, 5.00056148e-02f, 1.08059831e-01f, -6.55528754e-02f, -7.43223205e-02f, 2.78681889e-02f, 5.15034162e-02f,
  -5.81716113e-02f, -2.02974100e-02f, 5.25499992e-02f, -7.63479024e-02f, -2.08108034e-02f, 4.46278304e-02f, -4.28542271e-02f, -3.68178375e-02f, 2.47623753e-02f, -1.91647112e-02f,
  1.04832985e-01f, -9.77536142e-02f, 7.19825700e-02f, -2.59253643e-02f, 9.49717760e-02f, 1.09206804e-03f, -3.45179699e-02f, 3.99319753e-02f, 3.14347930e-02f, 3.18725929e-02f,
  -1.94724634e-01f, 9.33509134e-03f, 1.59219448e-02f, 8.98203701e-02f, -7.75848627e-02f, -8.09653103e-02f, 2.13798508e-02f, 1.00021185e-02f, 5.15929461e-02f, 4.79072034e-02f,
  1.66270474e-03f, -6.21192679e-02f, -1.12886034e-01f, 1.44234523e-02f, -5.50560914e-02f, 2.53350828e-02f, -2.57657468e-03f, -2.52499282e-02f, -1.69075727e-01f, -5.91006801e-02f,
  3.92162129e-02f, 3.99267897e-02f, -3.28632700e-03f, 3.03587820e-02f, -1.07337229e-01f, -9.96271595e-02f, -5.19682653e-03f, -2.90521719e-02f, -1.41891157e-02f, -2.84397812e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.20934913e-01f, 2.17188209e-01f, 2.13536307e-01f, 2.13428587e-01f, 4.38748486e-02f, 1.40204420e-02f, 2.36813545e-01f, 1.88680276e-01f, -9.92354471e-03f, 1.72683686e-01f,
  2.03180820e-01f, 2.14333072e-01f, 8.51026326e-02f, 1.34212136e-01f, 2.37859979e-01f, 4.77414355e-02f, 1.03379525e-01f, 1.66931048e-01f, 1.27612472e-01f, 1.46515608e-01f,
  4.09198143e-02f, 5.71586471e-03f, 2.12832630e-01f, 1.58949807e-01f, 1.31128326e-01f, 1.71286285e-01f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  7.30221719e-02f, -9.26058814e-02f, -7.62660652e-02f, 4.45184708e-02f, -3.92258503e-02f, -1.20053729e-02f, -6.40889555e-02f, -1.12484537e-01f, 6.62526712e-02f, -4.99087479e-03f,
  -5.31788915e-02f, -8.42163898e-03f, 4.16648090e-02f, 1.97514631e-02f, 1.15802251e-01f, -4.79025915e-02f, 1.02475747e-01f, -8.67821649e-02f, 1.96138099e-02f, 1.68007575e-02f,
  7.52814533e-03f, -2.29541548e-02f, 3.75876040e-03f, 5.51059023e-02f, -7.08005279e-02f, 1.25148604e-02f, 2.34992690e-02f, 6.71395427e-03f, -4.56098355e-02f, -1.16386339e-01f,
  -3.00096124e-02f, -3.71500105e-02f, -2.01455634e-02f, -7.86896199e-02f, 4.90680449e-02f, -2.67199259e-02f, -7.51231611e-02f, -7.05996901e-02f, 3.06499787e-02f, 6.06684946e-03f,
  5.16772494e-02f, 3.33697498e-02f, 3.85770015e-02f, 1.71235446e-02f, 2.69681923e-02f, -3.38126086e-02f, 1.94820557e-02f, 9.02358219e-02f, 7.42278472e-02f, 7.14845285e-02f,
  -9.32373032e-02f, 4.22225893e-02f, 2.57013063e-03f, 3.85588184e-02f, 1.66261852e-01f, -5.21998629e-02f, 1.80602506e-01f, 6.48498610e-02f, -2.34887805e-02f, -1.72788441e-01f,
  -1.64817423e-01f, 4.92572337e-02f, 2.32141837e-02f, -1.30975127e-01f, 8.73823091e-02f, -1.15629494e-01f, 6.37653023e-02f, 4.21921946e-02f, -1.94600485e-02f, 9.23877656e-02f,
  -1.42918110e-01f, -6.01282418e-02f, -1.33964404e-01f, -1.62034377e-01f, 1.13253847e-01f, 5.92666529e-02f, 3.32449824e-02f, 9.95391309e-02f, -1.66044682e-01f, 2.82065943e-02f,
  -5.97125366e-02f, -1.30151346e-01f, 1.64885297e-01f, -1.13885917e-01f, -1.56622753e-02f, 4.85622417e-03f, -1.56333551e-01f, 1.38074428e-01f, -3.13514061e-02f, -3.47669721e-02f,
  8.65517929e-02f, -5.52113727e-02f, -1.12888262e-01f, 1.94149762e-02f, 9.89002362e-02f, -1.10457623e-02f, -4.91071232e-02f, -1.29990041e-01f, -8.05227458e-02f, -9.12607014e-02f,
  7.23558962e-02f, 5.18541448e-02f, -1.03622854e-01f, 9.91964787e-02f, 1.28242880e-01f, -8.25400651e-02f, -2.86742859e-02f, -1.83986612e-02f, 1.95631415e-01f, -5.41708022e-02f,
  -1.34279653e-01f, -9.74615067e-02f, -1.37189746e-01f, -4.77665551e-02f, -1.51840627e-01f, -1.07712060e-01f, 1.31804034e-01f, -8.51650238e-02f, 1.45482225e-02f, 8.16805810e-02f,
  1.13937827e-02f, 1.39953628e-01f, -2.89288815e-02f, -2.07360238e-01f, 1.89898536e-02f, -9.46656521e-03f, -1.99807242e-01f, -9.46162939e-02f, -2.28736503e-03f, 3.57359350e-02f,
  7.13684037e-02f, -7.06698699e-03f, -1.11060336e-01f, 4.25537815e-03f, 6.79343343e-02f, 5.15253097e-02f, 1.54154822e-02f, 4.21033576e-02f, -2.81683877e-02f, 1.12066297e-02f,
  2.03997925e-01f, -7.24133849e-02f, 7.56286830e-02f, -1.96390860e-02f, 6.34725380e-04f, -6.43200874e-02f, -5.00496477e-02f, 1.18918940e-02f, -1.09146141e-01f, 1.99273508e-02f,
  -4.38957699e-02f, -6.66003078e-02f, -8.16616341e-02f, 5.49107343e-02f, -9.64723006e-02f, 2.09419355e-02f, -3.88666764e-02f, 1.30770763e-03f, 5.88876866e-02f, -6.41809925e-02f,
  -4.24496531e-02f, 4.01891358e-02f, -2.71615330e-02f, 1.04200885e-01f, -1.09128930e-01f, -1.30259395e-02f, 8.24542493e-02f, -8.54307190e-02f, -1.46096364e-01f, 3.98810096e-02f,
  -1.38212256e-02f, -9.03254971e-02f, 4.67914306e-02f, 1.27698228e-01f, 2.36383639e-02f, -5.13848402e-02f, 7.06085339e-02f, 1.33154675e-01f, 1.04367889e-01f, -1.80650160e-01f,
  -6.66599870e-02f, -4.17827033e-02f, 6.67747436e-03f, 2.21834686e-02f, 1.31386323e-02f, -9.19474289e-02f, -1.74973220e-01f, -9.65287834e-02f, 1.06128186e-01f, 1.60899132e-01f,
  4.96837273e-02f, 4.72137854e-02f, -6.88434988e-02f, 2.34935686e-01f, -1.09576389e-01f, 4.39118668e-02f, -3.57341431e-02f, 1.94932044e-01f, 5.26803844e-02f, -1.45776019e-01f,
  -1.83051929e-01f, -6.18325621e-02f, 1.70143604e-01f, 9.52264890e-02f, -1.87810466e-01f, 3.32103600e-03f, -2.14478280e-02f, -2.51537468e-02f, -1.34731382e-01f, 1.33743063e-02f,
  -6.10066652e-02f, 1.29075184e-01f, 1.35347277e-01f, -1.80784449e-01f, -8.39908123e-02f, -4.19624560e-02f, 1.13733664e-01f, -1.62559256e-01f, 8.40629637e-02f, 9.69279334e-02f,
  -4.02644984e-02f, -1.09969325e-01f, 1.46319449e-01f, -4.50933799e-02f, 1.00895979e-01f, 1.24818794e-01f, 7.94359203e-03f, 1.52740002e-01f, -8.73798206e-02f, -1.15897596e-01f,
  6.05771784e-03f, -9.30906087e-02f, 5.92861362e-02f, -1.17700035e-02f, 5.46130501e-02f, 1.41753495e-01f, 8.79557207e-02f, 1.63921356e-01f, -8.09476525e-02f, -2.96698846e-02f,
  -4.41283397e-02f, 9.82179586e-03f, -7.98365772e-02f, -8.48461688e-02f, 1.05630964e-01f, 5.08073578e-03f, -1.25187397e-01f, 8.74652788e-02f, -2.45227307e-01f, 1.75601523e-02f,
  -2.34495290e-02f, -4.75214720e-02f, -4.24740510e-03f, -1.00309059e-01f, 5.81729822e-02f, -7.92441703e-03f, 1.46500960e-01f, -1.27270073e-01f, 9.98822302e-02f, -1.04218304e-01f,
  -2.89472961e-03f, -4.51392606e-02f, 1.04735782e-02f, -1.29196206e-02f, -1.18901908e-01f, 3.34949493e-02f, -1.38588175e-01f, 4.21951758e-03f, 1.31488398e-01f, 3.85077037e-02f,
  1.65714532e-01f, 9.67347622e-03f, 8.90323296e-02f, 1.39244407e-01f, -6.83217309e-03f, 4.27562669e-02f, -6.96006864e-02f, 5.35709932e-02f, 6.57356903e-02f, 8.34435690e-03f,
  1.29097104e-01f, 8.15269649e-02f, 1.87177300e-01f, -2.88553108e-02f, -2.36405898e-03f, -7.51030520e-02f, 1.03692584e-01f, -2.20130440e-02f, -4.22896408e-02f, -4.30004448e-02f,
  2.25368366e-02f, 2.40681730e-02f, -5.73914545e-03f, -7.96959624e-02f, -3.98443192e-02f, -5.38122170e-02f, -1.49417659e-02f, -9.59232226e-02f, 5.55395186e-02f, 1.04891062e-01f,
  3.95215489e-02f, 1.02223106e-01f, 3.87512967e-02f, 3.51954773e-02f, -5.73289059e-02f, -2.37376094e-02f, 6.51616231e-02f, 1.43530607e-01f, -1.26068145e-01f, 1.82822749e-01f,
  1.15903132e-01f, -2.27239564e-01f, 1.36062056e-02f, -2.75479699e-03f, -9.02015865e-02f, -4.53580879e-02f, -1.41565455e-02f, -4.78528515e-02f, -9.61722061e-03f, 5.94794266e-02f,
  1.38281345e-01f, -5.29218651e-02f, 4.30371463e-02f, 5.25931492e-02f, -1.40673652e-01f, 1.44731617e-02f, -1.80171859e-02f, -3.80754173e-02f, -1.27123028e-01f, -7.73506798e-03f,
  -5.32696769e-02f, 2.12383494e-02f, -1.69705406e-01f, 2.28612408e-01f, -1.15862764e-01f, 1.47797272e-01f, -4.76193689e-02f, 5.70059381e-02f, 1.74527064e-01f, -1.29278094e-01f,
  -8.30685869e-02f, -1.62311435e-01f, -3.39695401e-02f, 1.02941329e-02f, -1.41427472e-01f, 1.07869387e-01f, 2.66178343e-02f, 7.54276663e-02f, -8.61858428e-02f, -4.86231707e-02f,
  -1.42536104e-01f, 6.77920133e-02f, -1.25018433e-01f, -1.44795686e-01f, -2.90616769e-02f, 6.49419501e-02f, -5.32297194e-02f, -3.35845537e-02f, 8.95313397e-02f, -8.13218653e-02f,
  -1.59575433e-01f, 4.38651666e-02f, -5.11022396e-02f, -4.11934182e-02f, 1.87752858e-01f, 1.43527910e-01f, -6.42431676e-02f, 1.51188448e-02f, -1.89778745e-01f, -7.43041560e-02f,
  -1.80985570e-01f, -4.52963598e-02f, -2.50859698e-03f, 6.25724867e-02f, -8.75843614e-02f, 1.74626470e-01f, 1.53742179e-01f, -7.25519955e-02f, -1.56812623e-01f, -9.61639956e-02f,
  -1.25535384e-01f, 1.58233009e-02f, -3.68386880e-02f, -1.75959766e-01f, 1.12011433e-01f, -1.05679847e-01f, -3.41621079e-02f, -5.81660159e-02f, -2.12364513e-02f, 7.79934302e-02f,
  -5.40795475e-02f, -8.23251307e-02f, -5.28790094e-02f, -9.57104203e-04f, -6.46715015e-02f, 2.21316610e-02f, -5.04614040e-02f, -6.97365403e-02f, 3.85202281e-02f, 2.08118092e-02f,
  1.04847670e-01f, -3.83199267e-02f, 1.64042860e-02f, -3.07564829e-02f, -7.34738484e-02f, 3.01029924e-02f, -6.68103769e-02f, 1.67792831e-02f, 2.22044643e-02f, 1.30836456e-03f,
  -1.83949210e-02f, -8.15024786e-03f, 8.83939415e-02f, 4.90782857e-02f, 1.17715346e-02f, 9.15222317e-02f, 5.80262393e-02f, -2.95065008e-02f, 7.83531815e-02f, -1.85865127e-02f,
  -2.62981579e-02f, -8.20244178e-02f, -5.29375933e-02f, -4.90298457e-02f, 8.88396427e-02f, -3.17069190e-03f, 1.81063414e-02f, 6.44514635e-02f, -9.05492753e-02f, 6.72290847e-02f,
  -4.46169637e-02f, 1.41974360e-01f, 2.98258867e-02f, -1.23774810e-02f, -7.56285638e-02f, -1.24323919e-01f, -1.26596475e-02f, -1.03206202e-01f, 2.35229552e-01f, -1.22367270e-01f,
  1.69657692e-02f, 1.39499635e-01f, -2.48054668e-01f, -1.06535822e-01f, -7.55682439e-02f, -2.61095669e-02f, -7.37218410e-02f, -1.69437081e-01f, 6.24073520e-02f, -1.46397278e-02f,
  6.19779378e-02f, 2.39885300e-02f, 5.61557375e-02f, -1.78334396e-02f, -1.80342659e-01f, 1.15733661e-01f, -1.43699013e-02f, -1.28947064e-01f, 4.25552130e-02f, 1.19680636e-01f,
  8.40144157e-02f, 6.64033443e-02f, -2.75401343e-02f, 7.27849752e-02f, 9.09457877e-02f, 2.69613937e-02f, 7.44901747e-02f, -1.83798164e-01f, -2.31369913e-01f, -4.04941179e-02f,
  -8.83491114e-02f, 1.17028274e-01f, -1.48056164e-01f, 3.74027230e-02f, 1.48250788e-01f, -6.84792995e-02f, -5.50585426e-02f, 8.57808217e-02f, -2.37783846e-02f, 5.47185652e-02f,
  -1.89096332e-01f, -3.82895209e-02f, 4.47002612e-02f, -1.21650230e-02f, -2.17538327e-02f, 9.80103463e-02f, -1.28039290e-04f, 8.78927261e-02f, 1.44870296e-01f, -1.06620237e-01f,
  -8.44885260e-02f, -1.32652864e-01f, 1.26647696e-01f, -1.49614424e-01f, 3.00913975e-02f, -2.45905221e-01f, -5.29214367e-03f, 4.53918874e-02f, -4.04132297e-03f, -7.65529647e-02f,
  1.69543430e-01f, -1.52173162e-01f, 3.74719165e-02f, -2.72115134e-02f, 4.49354388e-02f, -5.25983833e-02f, -1.79683231e-02f, 8.49471688e-02f, 8.29274058e-02f, -7.79570686e-03f,
  -1.61185771e-01f, 1.25429584e-02f, 1.05816156e-01f, -7.08695650e-02f, 1.41103938e-01f, 2.29942203e-02f, 7.97377676e-02f, -2.15938259e-02f, -4.25851941e-02f, 1.94609594e-02f,
  -8.34875628e-02f, 3.88773084e-02f, -6.31086379e-02f, 1.70798004e-02f, -5.97328600e-03f, -7.77976122e-03f, 3.93305048e-02f, 7.99705759e-02f, 6.58130050e-02f, 1.29128486e-01f,
  -1.15207275e-02f, 1.66802946e-02f, 1.17348231e-01f, -3.32267396e-02f, -5.24740294e-02f, 5.85925877e-02f, -1.07078906e-02f, 1.16605973e-02f, 9.24048275e-02f, -1.31127298e-01f,
  -8.48945901e-02f, -3.99279445e-02f, 1.62700936e-01f, 1.11509506e-02f, -6.31759241e-02f, -8.09151903e-02f, 1.35086831e-02f, -8.10849667e-02f, -6.89844252e-04f, 8.21966585e-03f,
  -6.11906201e-02f, 1.78801585e-02f, -7.27696018e-03f, 6.78874776e-02f, -7.45424330e-02f, 2.01204009e-02f, -3.54129933e-02f, -2.60373168e-02f, 1.57952040e-01f, -9.07749310e-02f,
  7.05872402e-02f, -2.78640203e-02f, -6.34509772e-02f, 1.90490648e-01f, 7.96432048e-03f, 1.82952628e-01f, 1.30648026e-02f, -1.09203726e-01f, 1.77945703e-01f, 3.42697315e-02f,
  2.53340334e-01f, 3.68223339e-02f, 4.35403176e-02f, -8.95163119e-02f, -1.32959068e-01f, -1.53547451e-02f, 1.51862085e-01f, -1.99976653e-01f, 1.75905138e-01f, -6.41987175e-02f,
  1.64805934e-01f, -3.34075764e-02f, -1.76611580e-02f, 2.16217879e-02f, 2.01554671e-02f, -4.01701890e-02f, -2.15532795e-01f, -1.61197051e-01f, 3.04081161e-02f, -7.70011842e-02f,
  -1.24462703e-02f, 5.31142689e-02f, 8.80386308e-02f, -4.54142019e-02f, 1.81563437e-01f, -8.78360718e-02f, -4.59046960e-02f, 3.84105891e-02f, -1.54456915e-02f, -2.92171799e-02f,
  -1.46199271e-01f, 6.99077472e-02f, -7.58258626e-02f, -1.01785315e-02f, 8.38279799e-02f, -1.32438511e-01f, -1.94238603e-01f, 6.63777953e-03f, 3.61295007e-02f, -1.93550333e-01f,
  -9.24724936e-02f, 8.88299122e-02f, 4.49531823e-02f, 8.04462750e-03f, 1.80936515e-01f, 1.68715045e-02f, -1.58002436e-01f, -3.86510529e-02f, 6.78549707e-02f, -1.80964202e-01f,
  9.70518962e-03f, 3.01659051e-02f, 9.61137712e-02f, 1.09891899e-01f, -4.58769873e-02f, -8.99035856e-02f, 2.19787601e-02f, 4.99917120e-02f, -1.37263402e-01f, 2.39552900e-01f,
  3.89824919e-02f, -2.08763424e-02f, 1.60578802e-01f, -1.31252170e-01f, 5.69694191e-02f, -1.21034250e-01f, -5.99678233e-02f, 1.13564059e-01f, 1.37984544e-01f, -5.12724370e-02f,
  -4.47951220e-02f, -3.21264379e-02f, -5.18498234e-02f, -2.78886668e-02f, -1.11571755e-02f, -1.46236435e-01f, -7.91821331e-02f, 7.44156167e-02f, -4.74679098e-02f, -2.38583260e-03f,
  -1.65239982e-02f, -7.12938309e-02f, -1.07917711e-02f, 4.63557951e-02f, -7.16933459e-02f, -1.07732050e-01f, 4.79325578e-02f, -6.69218674e-02f, 1.45544130e-02f, -7.69132795e-03f,
  -9.89305787e-03f, 1.74793527e-02f, 5.48838042e-02f, -7.04830810e-02f, -1.20095480e-02f, 3.68970335e-02f, -2.97894832e-02f, -7.87695125e-02f, -1.51081324e-01f, -5.75790480e-02f,
  9.19992998e-02f, -5.36111221e-02f, -7.18920082e-02f, 3.89647223e-02f, 2.04505604e-02f, -1.35419354e-01f, -8.12278464e-02f, -3.50524411e-02f, -6.42364025e-02f, -1.25768289e-01f,
  -3.27778533e-02f, -5.97228594e-02f, 5.92592591e-03f, -4.43822257e-02f, -2.02449206e-02f, -5.83016351e-02f, -4.09341827e-02f, -1.48742735e-01f, -8.02644491e-02f, -1.08921632e-01f,
  7.15959892e-02f, 2.01164987e-02f, -1.09708153e-01f, 7.83245340e-02f, -1.11875482e-01f, -7.12235868e-02f, 1.25413224e-01f, -2.57895067e-02f, 1.65808350e-01f, -1.10329710e-01f,
  -4.33640294e-02f, -2.05630749e-01f, 1.28261268e-01f, -7.42633119e-02f, 3.48351151e-02f, -9.24733207e-02f, 4.47332375e-02f, -4.33704220e-02f, -5.90636134e-02f, 1.62972644e-01f,
  1.14796177e-01f, -9.76288691e-02f, 7.36708641e-02f, 9.96203274e-02f, -1.58923998e-01f, -1.03751689e-01f, -1.81779027e-01f, 8.94915089e-02f, -6.95054457e-02f, 7.66649991e-02f,
  -1.27670527e-01f, 6.36882409e-02f, -3.04891095e-02f, 9.99902040e-02f, 1.65224940e-01f, -4.34166715e-02f, -6.40744865e-02f, -2.19875425e-01f, 6.53316900e-02f, -2.27865167e-02f,
  -1.23768009e-01f, -5.41830286e-02f, -1.11255221e-01f, -7.27040842e-02f, -6.98111504e-02f, -8.06794539e-02f, 2.27486536e-01f, -3.94559726e-02f, -5.09542525e-02f, 4.82986569e-02f,
  8.44686627e-02f, -5.37221767e-02f, -3.61293666e-02f, 5.27659282e-02f, -9.42032486e-02f, 1.34914070e-02f, 1.79690644e-01f, -6.16196543e-02f, 2.49112584e-02f, -7.70034119e-02f,
  1.92308500e-01f, 1.94324404e-01f, 1.45484582e-01f, 4.12215218e-02f, 1.00748576e-01f, -1.34969885e-02f, -2.53641576e-01f, 1.27450421e-01f, 6.10795207e-02f, -2.64692605e-02f,
  1.00274101e-01f, 7.35360524e-03f, 8.53298530e-02f, -1.76487193e-01f, 6.75658435e-02f, 4.64117490e-02f, 2.44106911e-02f, 3.30593474e-02f, -6.30744621e-02f, 4.52405810e-02f,
  6.30625850e-03f, 3.19805853e-02f, 1.34664223e-01f, -5.97991683e-02f, -5.10024428e-02f, 3.83867472e-02f, 1.43946171e-01f, -2.32013427e-02f, 5.72408037e-03f, -9.60945562e-02f,
  8.05293918e-02f, 5.98034337e-02f, 1.13533944e-01f, -6.21825159e-02f, 1.17760926e-01f, 1.15837539e-02f, -7.13378862e-02f, 1.55466363e-01f, -7.68879279e-02f, 8.22361652e-03f,
  7.64349103e-02f, 6.72281813e-03f, -9.04959440e-02f, 1.43353855e-02f, 1.27684474e-01f, 1.14562795e-01f, 2.33505610e-02f, 1.95594560e-02f, -1.55269027e-01f, -5.23044122e-03f,
  4.56006490e-02f, -1.85324382e-02f, 2.69932430e-02f, -1.10580392e-01f, 6.97676931e-03f, 1.80565137e-02f, 8.33954513e-02f, -2.78662853e-02f, 4.21047537e-03f, 1.29763916e-01f,
  3.26918513e-02f, 8.07135254e-02f, -7.85049126e-02f, 4.01323512e-02f, 5.85339172e-03f, 2.75980085e-02f, -2.35117842e-02f, 3.29606012e-02f, -1.23730473e-01f, -2.34399773e-02f,
  7.10635707e-02f, -6.94660321e-02f, -1.28565170e-02f, 2.99561936e-02f, -9.51872580e-03f, -1.04854129e-01f, -1.71246126e-01f, -1.29087821e-01f, -1.40564218e-01f, 1.10149182e-01f,
  1.43411784e-02f, 7.45290378e-03f, 2.44519096e-02f, 1.20584287e-01f, 4.37181406e-02f, -6.10392876e-02f, 7.17637017e-02f, 7.87320137e-02f, -1.60379291e-01f, 6.58736899e-02f,
  2.23075356e-02f, -8.98035988e-03f, -5.79256602e-02f, 1.62978675e-02f, -6.68950155e-02f, -1.51273340e-03f, -7.30132684e-02f, -8.48060399e-02f, -1.75238162e-01f, 1.63987465e-03f,
  6.14960156e-02f, -3.15985270e-02f, 4.17652093e-02f, 8.45950991e-02f, -1.43775642e-01f, 5.25943004e-02f, -4.53378372e-02f, 1.06365733e-01f, 1.06286548e-01f, -9.43417698e-02f,
  -1.38965920e-01f, 2.15834975e-02f, 9.15457681e-02f, -3.02762184e-02f, 1.39366940e-01f, 5.00072353e-02f, -2.23826505e-02f, -7.41322264e-02f, -1.36830777e-01f, 9.78586748e-02f,
  -1.06111087e-01f, 1.56862572e-01f, 3.90498526e-03f, 1.85104281e-01f, -1.97735146e-01f, 1.58521757e-02f, 1.70706943e-01f, 2.32059956e-01f, -1.31918311e-01f, 8.86202157e-02f,
  1.32148881e-02f, -9.58184600e-02f, 9.72990245e-02f, -3.58476974e-02f, 3.63219231e-02f, 1.64237637e-02f, 3.95107009e-02f, 7.83604160e-02f, -7.79668614e-02f, 1.99508131e-01f,
  1.26767889e-01f, -1.57597750e-01f, -4.39726450e-02f, -1.45825908e-01f, -1.69461444e-01f, -1.65668994e-01f, 4.47319932e-02f, -5.82359955e-02f, -3.94585952e-02f, 3.32103595e-02f,
  -2.55464222e-02f, 5.84523268e-02f, -1.00776553e-02f, -1.72615342e-03f, 1.30311072e-01f, 1.50541849e-02f, -4.48252894e-02f, 7.64597729e-02f, 5.98229617e-02f, 8.01070929e-02f,
  -2.17348747e-02f, -6.66012466e-02f, 1.17848679e-01f, -4.78599854e-02f, 2.35049054e-02f, 5.71679845e-02f, 4.08210196e-02f, 7.55382925e-02f, -6.23249821e-03f, 5.77905476e-02f,
  2.57222131e-02f, -8.93447641e-03f, 7.77210966e-02f, 1.57878455e-02f, -6.80320337e-02f, -1.42536968e-01f, -8.31963718e-02f, 6.00038916e-02f, -6.52724281e-02f, 7.63877928e-02f,
  6.61483966e-03f, 9.02659670e-02f, -6.55501410e-02f, 1.21249156e-02f, -4.32251990e-02f, -2.02379515e-03f, -5.20361960e-02f, 2.26238910e-02f, 8.21981132e-02f, -3.78786437e-02f,
  -2.83079664e-03f, -1.04171550e-02f, -9.73127112e-02f, 1.08008243e-01f, 1.13462590e-01f, 6.67298734e-02f, -2.51368172e-02f, 4.28971276e-02f, 5.91797344e-02f, 9.52441841e-02f,
  3.33813168e-02f, 7.19441939e-03f, 1.01866588e-01f, 6.21637655e-03f, -1.99294239e-01f, -1.51639268e-01f, -1.29698470e-01f, 1.14254966e-01f, 1.67564116e-02f, -1.05394823e-02f,
  -7.19456971e-02f, -1.04393139e-01f, 2.56923418e-02f, 9.71877277e-02f, -6.03730716e-02f, 6.57341182e-02f, -2.17456177e-01f, -9.51064602e-02f, -4.46613692e-02f, -1.74554154e-01f,
  2.89764293e-02f, 7.02275336e-02f, 4.89202403e-02f, 1.55268386e-01f, -2.40314901e-01f, -1.19377993e-01f, -9.05404836e-02f, -5.46685942e-02f, 1.59103975e-01f, -4.18335460e-02f,
  3.65616865e-02f, -4.53003757e-02f, -1.02387927e-01f, 1.00742444e-01f, -4.16311622e-02f, 1.19639244e-02f, 9.56944004e-02f, 1.49876415e-03f, -1.41299188e-01f, 9.27119330e-02f,
  7.39747733e-02f, -6.66608214e-02f, 3.28972451e-02f, 1.25826132e-02f, -1.14999987e-01f, -6.78374171e-02f, 5.03491424e-02f, 5.40542118e-02f, -1.80449232e-01f, 1.13393001e-01f,
  9.81191993e-02f, 1.23557793e-02f, 4.99075046e-03f, 1.87720060e-01f, 1.45664066e-01f, 6.23199251e-03f, -2.14522049e-01f, -1.05652377e-01f, 1.80514287e-02f, 5.42681254e-02f,
  3.82732414e-02f, -5.55213802e-02f, 1.53499693e-01f, -5.10798804e-02f, 1.96407571e-01f, -6.36408105e-02f, -1.19490676e-01f, 1.35678947e-01f, 1.14627756e-01f, -9.43579245e-03f,
  -6.26871064e-02f, 3.69113497e-02f, -2.01268956e-01f, 1.94831062e-02f, -3.43486965e-02f, -2.17452813e-02f, -3.72939296e-02f, 9.39511433e-02f, -1.81000493e-02f, 7.55468803e-03f,
  8.65895450e-02f, 5.36658578e-02f, 5.61026745e-02f, 6.29292205e-02f, -3.29476781e-02f, -7.09004849e-02f, 4.60988134e-02f, 6.90609813e-02f, -4.65935022e-02f, 1.24696411e-01f,
  -4.25707288e-02f, -9.33975726e-02f, 1.19565343e-02f, 1.48776054e-01f, 9.02524665e-02f, -5.15759587e-02f, -2.25376468e-02f, 2.19803657e-02f, -9.37391371e-02f, 6.08906373e-02f,
  -6.24413900e-02f, 2.78772879e-02f, -5.15294299e-02f, -7.75610283e-02f, 4.16295901e-02f, 1.11654580e-01f, 5.75623624e-02f, 8.46530721e-02f, -5.49591184e-02f, 3.92149277e-02f,
  -6.62059933e-02f, 6.84748515e-02f, -5.34922853e-02f, -3.08411587e-02f, -2.07900926e-02f, -9.29831192e-02f, 8.44386965e-02f, 2.50690021e-02f, 4.83129546e-02f, 6.76221475e-02f,
  9.32753738e-03f, 1.88195761e-02f, -1.68798026e-02f, -8.50956962e-02f, -2.91808117e-02f, -4.86785546e-02f, -1.38305783e-01f, -2.21396573e-02f, -1.00598536e-01f, 8.99475440e-02f,
  2.43070051e-02f, -6.65830150e-02f, 6.56848848e-02f, 5.30225933e-02f, 1.70766890e-01f, 7.73241818e-02f, 9.56888571e-02f, 1.84736121e-02f, -1.67098474e-02f, 7.51924068e-02f,
  -7.29024261e-02f, -4.78266738e-03f, -1.69287056e-01f, 5.44016398e-02f, 1.86693408e-02f, -5.28619215e-02f, 9.92076471e-02f, 7.41232187e-02f, 1.15945570e-01f, -9.35807750e-02f,
  -1.35456756e-01f, 1.72836140e-01f, 7.70425573e-02f, -1.13922484e-01f, -1.57011941e-01f, 1.68555796e-01f, -1.42289773e-01f, 1.94294438e-01f, 1.84427992e-01f, 5.35508059e-02f,
  5.95467426e-02f, -2.33359411e-02f, 4.63398993e-02f, -2.18100026e-02f, 7.14739263e-02f, -7.43393041e-03f, -1.69226415e-02f, 8.98370519e-02f, 1.42070189e-01f, -6.45851418e-02f,
  9.64008346e-02f, 1.33926257e-01f, 1.14110531e-02f, 7.45926946e-02f, 1.91198941e-02f, -9.43218321e-02f, -3.34309712e-02f, 9.26179513e-02f, 2.96440385e-02f, -8.30766261e-02f,
  3.84798907e-02f, 2.05832794e-01f, -9.12299205e-04f, -1.30049795e-01f, -1.09087573e-02f, 1.76087022e-02f, 9.33662578e-02f, 2.00048342e-01f, 4.81876135e-02f, 1.76302716e-01f,
  1.13806419e-01f, -1.16849892e-01f, -7.72989243e-02f, -2.54932418e-02f, -8.63662213e-02f, 5.84969409e-02f, 5.03791906e-02f, 4.89113182e-02f, -1.09417416e-01f, -1.40168846e-01f,
  5.40757217e-02f, 4.57992442e-02f, -9.84011665e-02f, 7.07145333e-02f, -1.37261087e-02f, 4.67975959e-02f, -5.04292920e-03f, -2.03440879e-02f, -4.17577662e-02f, -1.40142050e-02f,
  -7.35410228e-02f, -1.05327573e-02f, -4.93685119e-02f, -1.62102915e-02f, -2.79047564e-02f, -5.66858500e-02f, -1.24689333e-01f, -4.01555002e-02f, -1.27271309e-01f, 1.77515913e-02f,
  2.89167482e-02f, -1.00774832e-01f, -2.84622107e-02f, -5.91466054e-02f, -6.14991188e-02f, -1.29424157e-02f, -1.26785144e-01f, -1.23204574e-01f, -7.24576116e-02f, -9.03648734e-02f,
  -1.00467257e-01f, -7.15998337e-02f, -1.64905861e-01f, -5.37094101e-02f, 3.44715826e-02f, -8.92049372e-02f, -2.63297688e-02f, -4.59339703e-03f, -1.19544283e-01f, 2.31882762e-02f,
  7.63607444e-03f, -9.48753804e-02f, -1.72620956e-02f, 5.16025573e-02f, 3.01686558e-03f, -2.53717434e-02f, -2.87127774e-02f, 3.65153067e-02f, -1.28685804e-02f, -7.42265731e-02f,
  -5.08340597e-02f, -5.02962545e-02f, 2.64340192e-02f, -1.88649967e-01f, 2.40914505e-02f, -1.57648697e-01f, -1.10951759e-01f, 1.50665581e-01f, -6.75718784e-02f, -1.06982596e-01f,
  2.60172188e-02f, 1.30994335e-01f, -8.47653598e-02f, 2.83247083e-02f, 4.61859768e-03f, 3.83717678e-02f, -9.34010819e-02f, 8.43731910e-02f, -1.69946313e-01f, -2.68646865e-03f,
  4.49713133e-02f, 4.98935534e-03f, 3.12195644e-02f, 2.29849249e-01f, 4.08092141e-02f, 2.46597733e-02f, 4.14777584e-02f, 1.26665890e-01f, 1.08004518e-01f, -1.13145910e-01f,
  4.58485410e-02f, 1.29055204e-02f, 1.25176892e-01f, -3.31354663e-02f, -2.55765498e-01f, 3.85048762e-02f, -4.93208170e-02f, 1.16848834e-01f, -1.68209877e-02f, 1.10207543e-01f,
  -1.43537410e-02f, -8.82975757e-02f, 3.26527841e-02f, -1.26275554e-01f, 1.26650587e-01f, 2.57720426e-02f, 1.33365378e-01f, -2.56757475e-02f, -1.09481532e-02f, 1.63325980e-01f,
  1.29882559e-01f, -1.29985482e-01f, 9.48860869e-02f, -6.49736300e-02f, -1.54689983e-01f, 1.88619792e-02f, 2.21887492e-02f, 6.81412891e-02f, 1.11153498e-02f, -9.47129130e-02f,
  -8.46201777e-02f, -1.20869661e-02f, -7.20090270e-02f, -1.88780457e-01f, -3.74235655e-03f, 1.66410413e-02f, 1.72302708e-01f, 7.23123103e-02f, -2.95451824e-02f, -1.24299034e-01f,
  9.90798250e-02f, -1.76602498e-01f, -1.07854858e-01f, 5.03777303e-02f, 2.82603335e-02f, 1.14042968e-01f, 1.43287182e-01f, -5.61171211e-02f, -3.15984860e-02f, -2.89650057e-02f,
  8.04487616e-02f, -3.84687968e-02f, -5.38245365e-02f, -7.80110732e-02f, -3.74835022e-02f, 2.87729483e-02f, -2.25309934e-02f, -1.54112307e-02f, 2.01970655e-02f, 4.22148667e-02f,
  2.07150560e-02f, 2.51874477e-02f, -9.73338261e-02f, 9.44594666e-02f, -5.11285923e-02f, 3.07854582e-02f, -6.86532538e-03f, -2.35877842e-01f, -2.00389661e-02f, 7.54787624e-02f,
  9.34032630e-03f, -9.94554237e-02f, -4.07059602e-02f, -8.07278976e-02f, 3.76150757e-02f, -9.49659720e-02f, -2.38176763e-01f, 7.13109598e-02f, 3.52808833e-02f, -2.18132678e-02f,
  -3.87653895e-02f, 6.54350370e-02f, 2.10524052e-02f, -1.97008923e-02f, 3.88716049e-02f, 6.18258342e-02f, 5.87380156e-02f, -2.10753530e-02f, 3.81515995e-02f, -8.63711443e-03f,
  -1.66568086e-02f, -2.32717302e-02f, -3.57378200e-02f, 8.45835824e-03f, -1.43545941e-01f, -1.12196229e-01f, -7.32410476e-02f, 1.58539966e-01f, -6.72493502e-02f, -1.14976220e-01f,
  -1.36683270e-01f, -9.23832282e-02f, -8.02835152e-02f, -4.56173643e-02f, 2.20446676e-01f, -1.46295115e-01f, 8.64825919e-02f, 8.73466805e-02f, -1.69862196e-01f, -1.23037137e-01f,
  6.20093979e-02f, -1.71774682e-02f, -1.84292242e-01f, -8.18151608e-02f, 7.33445361e-02f, -1.16877057e-01f, 7.97365829e-02f, 1.18060492e-01f, 2.90295780e-02f, -1.79395918e-02f,
  -4.43621315e-02f, 9.45222229e-02f, -1.99513331e-01f, -3.92814986e-02f, 1.10878840e-01f, -5.20090982e-02f, 4.40958254e-02f, -3.16471606e-02f, -1.08866617e-01f, 3.89022194e-02f,
  -1.34577602e-01f, 7.18534440e-02f, -6.41830191e-02f, -1.17804214e-01f, -1.52549043e-01f, 8.80401582e-03f, -3.46796364e-02f, 1.94588050e-01f, -8.48974437e-02f, -1.61521912e-01f,
  1.25119984e-01f, -2.50800308e-02f, -1.25024408e-01f, 1.83072165e-01f, 4.50460762e-02f, -5.23965049e-04f, 6.03859536e-02f, 3.85220945e-02f, -1.37734622e-01f, 4.06455658e-02f,
  8.04695114e-02f, -4.77606244e-02f, -6.37839809e-02f, -3.90806571e-02f, 8.91377330e-02f, -1.25431225e-01f, -4.82660644e-02f, -3.70058566e-02f, 1.42094687e-01f, -2.59994179e-01f,
  2.17414558e-01f, -1.54538319e-01f, 1.52494043e-01f, 7.71287829e-02f, -3.94729078e-02f, 4.30380963e-02f, -2.41287351e-02f, -1.94210455e-01f, 3.94967869e-02f, -3.25495601e-02f,
  9.19666961e-02f, 1.23630539e-01f, -7.03220144e-02f, -1.18498467e-01f, 1.80291846e-01f, 9.38173980e-02f, -2.07660034e-01f, -1.23537883e-01f, -1.02811605e-01f, 2.44758837e-02f,
  6.38874993e-02f, 9.36483964e-03f, 6.19677128e-03f, -3.91385034e-02f, -5.01226960e-03f, 7.72778392e-02f, 8.09422787e-03f, -3.63102816e-02f, 1.29767032e-02f, 5.00359721e-02f,
  -1.02496548e-02f, -4.74084122e-03f, 4.22882065e-02f, -1.30150176e-03f, -8.47003162e-02f, -1.31491140e-01f, -9.28837508e-02f, 1.85850877e-02f, 3.05527132e-02f, -3.22228223e-02f,
  6.75272495e-02f, -1.33643493e-01f, 6.75699860e-02f, -5.54948412e-02f, -1.29707888e-01f, 9.01751667e-02f, -2.22894717e-02f, 4.10498306e-03f, -3.96735035e-02f, 6.05489314e-02f,
  -7.08153285e-03f, -6.89819604e-02f, 1.30444253e-02f, 1.25781730e-01f, 1.00037456e-03f, 3.30023058e-02f, 1.69231463e-02f, 1.31986719e-02f, 1.38345491e-02f, -1.05009347e-01f,
  5.59218600e-02f, 1.37781035e-02f, -9.04245600e-02f, -1.58724524e-02f, -2.87485635e-03f, -1.01148253e-02f, 7.72452308e-03f, -1.53597314e-02f, 1.15080699e-01f, 7.73324445e-03f,
  -1.50757268e-01f, -4.04873490e-02f, -1.69135213e-01f, 8.45058039e-02f, -1.39352575e-01f, 5.19609563e-02f, -5.25139906e-02f, 1.01859324e-01f, 9.47442874e-02f, 1.50162965e-01f,
  1.39428347e-01f, 7.31188059e-02f, -1.27168410e-02f, 2.06437349e-01f, -6.65587857e-02f, -1.23143904e-02f, -1.52864560e-01f, 6.81620687e-02f, 1.16747528e-01f, -8.03009272e-02f,
  -2.04292592e-02f, 1.28856122e-01f, 4.79417993e-03f, -9.75179821e-02f, -1.23631328e-01f, 1.07867144e-01f, 1.73736870e-01f, -8.04123953e-02f, -1.41591340e-01f, 2.26732180e-01f,
  -1.64835870e-01f, 1.56499222e-01f, 6.08272925e-02f, -9.13712308e-02f, 1.28800228e-01f, -5.19345924e-02f, -3.58190835e-02f, -1.62844621e-02f, -4.64123003e-02f, 1.84917375e-01f,
  1.57982334e-01f, -8.58733505e-02f, 1.57501688e-03f, -1.27972856e-01f, 6.69597387e-02f, -3.44959833e-03f, -6.88353255e-02f, 1.43409902e-02f, -4.19654883e-02f, -1.82318136e-01f,
  -2.58965278e-03f, -3.01846676e-02f, -1.42715918e-02f, -8.65899697e-02f, -2.03059539e-02f, 5.77268787e-02f, -2.75156517e-02f, 9.36391726e-02f, 2.69343052e-02f, 2.69400701e-03f,
  4.13072370e-02f, 8.26811045e-02f, 1.76268667e-01f, 2.26916373e-01f, 8.79044458e-02f, -1.08619845e-02f, 8.62331241e-02f, -5.37482537e-02f, -1.78646892e-01f, -5.27630188e-02f,
  -1.74580589e-02f, 9.08936560e-02f, -1.53576553e-01f, -1.15968339e-01f, 6.11015819e-02f, 1.08104616e-01f, -4.93692495e-02f, -1.01752765e-02f, -4.22719195e-02f, -8.61032456e-02f,
  -6.23625070e-02f, -2.19182745e-02f, -1.30233496e-01f, -1.13066724e-02f, 1.15684355e-02f, -4.94353063e-02f, 4.82908376e-02f, -7.70218968e-02f, 2.82054916e-02f, 6.86299801e-02f,
  -1.53347626e-01f, -8.01068917e-02f, 2.43049264e-02f, -1.20961174e-01f, 1.00084417e-01f, 4.10322547e-02f, -4.86170501e-03f, -4.65774275e-02f, 9.82299298e-02f, -7.08255842e-02f,
  1.25666494e-02f, 7.23555014e-02f, -1.45622760e-01f, -8.06120969e-03f, 7.56047592e-02f, -2.56866030e-02f, -1.40285224e-01f, -6.75158650e-02f, 7.68831931e-04f, -6.36443645e-02f,
  1.08886622e-02f, 1.00235979e-03f, -8.15814435e-02f, -9.33479443e-02f, -5.51523305e-02f, -5.61757833e-02f, -2.00550053e-02f, -4.12733406e-02f, 6.64244778e-03f, -1.80867165e-02f,
  -3.02678868e-02f, 1.34829329e-02f, -1.04335412e-01f, 4.35338579e-02f, -7.30825067e-02f, 1.07125631e-02f, -2.44762450e-02f, -3.30361761e-02f, 1.98755339e-01f, -1.42047137e-01f,
  4.12943438e-02f, 5.67849316e-02f, -8.96182358e-02f, -5.52216731e-02f, -1.07736818e-01f, -1.18538621e-03f, -1.69342663e-02f, 1.01443067e-01f, -1.30609021e-01f, -3.74234002e-03f,
  -1.12957545e-01f, 3.24626677e-02f, -3.47889215e-02f, 8.07587057e-02f, 2.15904325e-01f, -1.24475911e-01f, -1.52283579e-01f, 5.23768403e-02f, -1.01432651e-01f, -1.41201437e-01f,
  1.85486283e-02f, 1.47993416e-01f, 1.95387468e-01f, -1.75740808e-01f, 3.65438312e-02f, -4.27382216e-02f, -1.56069519e-02f, -1.37657002e-01f, -1.04577243e-01f, -7.49511123e-02f,
  -1.18767368e-02f, 9.56993103e-02f, 1.78446677e-02f, 1.80814609e-01f, 1.16784953e-01f, -5.87904826e-02f, -3.65068614e-02f, -2.34431878e-01f, 9.45175290e-02f, 7.38379657e-02f,
  1.08188346e-01f, 1.56558305e-01f, -9.89288557e-03f, 1.12260193e-01f, 4.58879583e-02f, -9.35416371e-02f, 7.41604120e-02f, 1.85408592e-01f, -1.75131932e-01f, 1.98539589e-02f,
  2.15751991e-01f, 5.60679324e-02f, 4.85216416e-02f, -1.64809465e-01f, -1.12954214e-01f, 7.67211989e-02f, -2.84738751e-04f, 3.00996155e-02f, 1.30738676e-01f, -1.54994130e-01f,
  5.39211966e-02f, -6.14946708e-02f, 1.67453274e-01f, -8.88851285e-02f, 2.44457144e-02f, 2.67748851e-02f, -3.72927561e-02f, 4.80536260e-02f, -4.07865271e-02f, 4.42868322e-02f,
  5.35552539e-02f, -1.05473757e-01f, -2.19283089e-01f, -6.55233935e-02f, -5.17666526e-02f, -1.11660101e-02f, -9.99588054e-03f, -9.21611302e-03f, -5.15321828e-02f, -1.38445012e-02f,
  -7.05678985e-02f, -2.98356470e-02f, 9.04284604e-03f, 6.74174204e-02f, 1.17485449e-01f, -4.54694219e-02f, -7.57452473e-02f, -3.48616168e-02f, 1.58680677e-02f, -9.36946422e-02f,
  3.52686346e-02f, 6.62007779e-02f, -5.89626208e-02f, -2.33145524e-02f, 3.29215918e-03f, -3.90836671e-02f, -1.11173056e-01f, -3.23679385e-04f, -4.11042161e-02f, 4.60118912e-02f,
  5.58506660e-02f, -1.16955273e-01f, 9.27691609e-02f, 4.13878188e-02f, 3.23703289e-02f, -5.49088232e-02f, -4.02922183e-02f, -4.79595177e-02f, 3.39599252e-02f, -4.03507054e-02f,
  8.65781028e-03f, -6.77304789e-02f, -5.96887171e-02f, 3.29397433e-02f, -2.49558538e-02f, 6.95855692e-02f, 7.24259242e-02f, 3.62236053e-02f, 4.94473502e-02f, -1.24162692e-03f,
  -9.74376276e-02f, -7.58458748e-02f, 9.83905233e-03f, -4.89152223e-02f, -4.58684675e-02f, -1.29978061e-01f, 2.20097937e-02f, -1.96216062e-01f, 1.16732359e-01f, 1.17694549e-01f,
  -6.16655797e-02f, 5.71327657e-02f, 1.17690288e-01f, 1.96604412e-02f, -1.37314752e-01f, -5.02176024e-02f, -1.30749881e-01f, 4.54089344e-02f, 2.55812835e-02f, 2.66160648e-02f,
  -6.28981888e-02f, -1.55443847e-01f, 1.37841418e-01f, -1.05504967e-01f, 3.50042619e-02f, 2.25865647e-01f, 8.83662850e-02f, 1.11028410e-01f, 1.11554854e-01f, 1.28903553e-01f,
  1.82393700e-01f, -1.14835016e-01f, 1.08913019e-01f, 4.86868918e-02f, 1.83179587e-01f, -1.34613469e-01f, -8.70973840e-02f, -1.27460942e-01f, -1.25165939e-01f, 1.77747130e-01f,
  -3.04646790e-02f, 3.79284695e-02f, 3.15485112e-02f, -1.57451019e-01f, 5.74419610e-02f, -1.11501843e-01f, -3.97108644e-02f, 9.66893062e-02f, -2.18583569e-02f, 1.39532685e-01f,
  -1.04697242e-01f, 4.24186550e-02f, 1.81377396e-01f, -1.55279756e-01f, 1.35848016e-01f, 6.06038906e-02f, 2.83302795e-02f, 1.46435676e-02f, 3.29695642e-02f, -1.77352712e-01f,
  -1.85009390e-01f, -3.50435488e-02f, -1.93599775e-01f, -8.30287784e-02f, -2.17594698e-01f, -1.83370933e-01f, -8.41234326e-02f, 4.20445995e-03f, 3.52292857e-03f, 1.01263307e-01f,
  -2.64176056e-02f, -9.65910126e-03f, -8.22779611e-02f, -3.90041694e-02f, 3.81262116e-02f, 8.15860704e-02f, -9.26315635e-02f, 2.25968659e-01f, 2.27918372e-01f, 1.62870716e-02f,
  -1.98718775e-02f, 6.76700994e-02f, 6.76577389e-02f, 4.19323929e-02f, 7.54843205e-02f, -7.98112452e-02f, -9.85661615e-03f, 7.12913414e-03f, -5.35129011e-02f, -4.28279350e-03f,
  7.01638833e-02f, -8.95754769e-02f, -9.18218717e-02f, 6.82660099e-03f, -2.70485412e-03f, -7.24688638e-03f, -2.15238016e-02f, -1.24926209e-01f, 2.43969937e-03f, -7.02755898e-03f,
  -4.92924899e-02f, -2.73514595e-02f, -1.11878170e-02f, 1.14243433e-01f, 8.37683678e-02f, -4.23877053e-02f, 4.85601984e-02f, -3.27701196e-02f, 4.41525020e-02f, -1.60886417e-03f,
  -1.46825733e-02f, -4.87139188e-02f, 3.17298211e-02f, -7.73756877e-02f, -7.36433417e-02f, 6.01371601e-02f, 5.24906404e-02f, -2.45594215e-02f, -8.64893571e-02f, 1.59077980e-02f,
  -5.66595700e-03f, 3.79334576e-02f, -1.22394981e-02f, 6.53629601e-02f, -1.10982090e-01f, -4.78210375e-02f, -3.78908925e-02f, 3.87025042e-03f, -2.99073700e-02f, -3.90883312e-02f,
  8.64310861e-02f, 7.98057616e-02f, -8.56138766e-02f, 7.20756799e-02f, -1.75670739e-02f, 8.03836584e-02f, 2.35439800e-02f, -2.14089409e-01f, 8.42047706e-02f, -1.04477391e-01f,
  -6.24189936e-02f, -7.62035623e-02f, -7.25079551e-02f, 4.28028479e-02f, -4.68079485e-02f, -9.64226723e-02f, -1.04827341e-02f, -9.08960402e-02f, 2.46220198e-03f, 3.78456712e-02f,
  1.23671405e-01f, 1.45523965e-01f, -1.53022796e-01f, -3.04364953e-02f, -7.24012684e-03f, -1.78180769e-01f, -6.93850815e-02f, -8.75960812e-02f, -5.12255654e-02f, -1.11715272e-01f,
  -1.41727298e-01f, 1.09127320e-01f, -1.68563589e-01f, -1.19571038e-01f, 1.76768139e-01f, -1.01389199e-01f, 6.16276376e-02f, -1.36666313e-01f, -1.83873639e-01f, -1.24246487e-02f,
  -7.23285526e-02f, -8.08063745e-02f, -1.51335642e-01f, -2.13490520e-03f, -5.17418347e-02f, -1.01497993e-01f, -8.64046142e-02f, -7.02801198e-02f, 1.55959070e-01f, -5.58569208e-02f,
  -2.12053195e-01f, 1.41865820e-01f, -4.51479256e-02f, 7.67777860e-02f, -2.32240036e-02f, -7.63101205e-02f, -3.74229476e-02f, 1.36074737e-01f, -7.15848655e-02f, -7.76503012e-02f,
  -8.92863958e-04f, 2.04464510e-01f, -6.15911419e-03f, 1.14775099e-01f, -1.61276236e-01f, -1.68850824e-01f, -2.06016108e-01f, -4.09840383e-02f, -2.76071317e-02f, 1.59485906e-01f,
  -2.47134343e-02f, 1.67290851e-01f, 2.37169582e-02f, 4.16480154e-02f, -9.57604945e-02f, -1.72954723e-01f, -1.26655912e-02f, 2.59897504e-02f, -6.47809654e-02f, -9.17629339e-03f,
  -1.34665534e-01f, 4.68602292e-02f, -1.13244848e-02f, -1.70369484e-02f, -1.10915294e-02f, 6.17181063e-02f, -2.19422728e-02f, -4.70979474e-02f, -3.85879762e-02f, 1.11634806e-01f,
  3.53987142e-02f, -9.84960888e-03f, -1.32732779e-01f, 6.93414509e-02f, -5.06086387e-02f, 3.47728021e-02f, -1.62840616e-02f, 6.26325756e-02f, -3.06204781e-02f, -4.61781174e-02f,
  6.69622645e-02f, 3.48382704e-02f, -5.84744439e-02f, -4.84816357e-02f, -2.02733893e-02f, 6.44518733e-02f, -4.45652045e-02f, 7.60112107e-02f, 1.21195177e-02f, -7.36869723e-02f,
  -1.54213968e-03f, 1.20980248e-01f, -8.25736765e-03f, 4.01098728e-02f, 5.74566014e-02f, 1.86776742e-02f, -7.39796609e-02f, -6.79322425e-03f, 4.28980030e-02f, 5.11917025e-02f,
  9.87774357e-02f, 1.81140512e-01f, 1.08291700e-01f, -8.53104591e-02f, -7.16706812e-02f, -3.13714743e-02f, -9.84364301e-02f, -6.50890172e-03f, -2.75731869e-02f, 5.32685295e-02f,
  -3.58369537e-02f, -1.21130824e-01f, 6.77060559e-02f, -1.08803377e-01f, 7.27241114e-02f, 1.71658576e-01f, -1.34295985e-01f, -1.93879649e-01f, -2.55809892e-02f, 2.60113627e-02f,
  3.67581635e-03f, -3.81551459e-02f, -1.56702861e-01f, -2.17228904e-02f, -3.87308333e-04f, 2.71057189e-02f, -6.28637895e-02f, -3.84669006e-02f, 1.05002441e-01f, -1.82821706e-01f,
  1.05001584e-01f, 1.79015189e-01f, 6.59054443e-02f, 7.51978830e-02f, 1.10715359e-01f, 2.64093161e-01f, 2.28151847e-02f, -1.96203534e-02f, -4.91088144e-02f, -2.33311597e-02f,
  1.04060590e-01f, -4.53194007e-02f, -9.02223811e-02f, -6.16897307e-02f, -1.95910364e-01f, 1.20981455e-01f, -7.66858757e-02f, 1.51200548e-01f, -5.98227531e-02f, -9.07255486e-02f,
  6.58571199e-02f, -1.74296610e-02f, 9.61169824e-02f, 1.20297804e-01f, 1.57656804e-01f, 1.37418106e-01f, -2.22187117e-01f, -6.31370991e-02f, 1.24697208e-01f, -1.46812513e-01f,
  5.72408251e-02f, 1.57798469e-01f, -7.54059404e-02f, 6.29175901e-02f, 1.03839487e-01f, -1.90468710e-02f, 4.05443124e-02f, 2.44154241e-02f, -1.78188339e-01f, -8.94279033e-02f,
  1.17476366e-01f, -8.41917545e-02f, 6.61142468e-02f, 1.90209761e-01f, 1.95376754e-01f, 1.70728378e-02f, 5.78179434e-02f, -1.12240046e-01f, 5.59371971e-02f, -1.58822164e-01f,
  5.61420433e-03f, 7.70683959e-02f, 1.41732516e-02f, 2.50303447e-01f, 2.43428588e-01f, 2.26015344e-01f, 5.79338856e-02f, 8.93136933e-02f, 3.82497087e-02f, -8.28801990e-02f,
  -1.01173110e-01f, -4.18894216e-02f, -8.57091844e-02f, 6.23337366e-02f, 1.33569622e-02f, -3.53115276e-02f, 1.03199162e-01f, 3.93625125e-02f, -7.34419599e-02f, 1.12302579e-01f,
  1.22188896e-01f, 3.25178280e-02f, -4.74065766e-02f, 7.84200281e-02f, -3.03765433e-03f, -3.46715823e-02f, 4.32457328e-02f, 1.78478099e-02f, 7.32760690e-03f, -6.44206554e-02f,
  7.07457587e-02f, -1.14058428e-01f, -2.52470095e-02f, 3.36431935e-02f, 3.09222308e-03f, 5.76436222e-02f, -4.20338511e-02f, 6.59005865e-02f, -9.30608809e-02f, 1.11676544e-01f,
  -5.50181381e-02f, 1.43366922e-02f, -8.09815899e-02f, 8.77283514e-03f, -1.30530223e-01f, 9.32559147e-02f, 6.08701035e-02f, -2.65095811e-02f, 3.13650398e-03f, -7.89008960e-02f,
  3.53529789e-02f, -4.56046835e-02f, -6.91200495e-02f, 8.92270431e-02f, -1.04399845e-01f, 1.26900852e-01f, -5.08942418e-02f, 7.42389038e-02f, -3.52194463e-03f, -1.74441397e-01f,
  7.51754716e-02f, -1.02111258e-01f, 7.40518421e-02f, 9.07294080e-02f, -1.41959667e-01f, -1.35958731e-01f, -2.50506371e-01f, 1.18159512e-02f, 1.12121634e-01f, 1.99411377e-01f,
  1.00286976e-01f, -7.96576496e-03f, -5.72415814e-02f, 1.60396725e-01f, -7.72859305e-02f, 1.23710953e-01f, 9.42121893e-02f, 2.14067832e-01f, -1.16477981e-01f, -9.84644592e-02f,
  -1.90556288e-01f, -1.19143777e-01f, 6.82910830e-02f, 1.34128883e-01f, 5.12883551e-02f, -1.09074682e-01f, -1.33902013e-01f, -1.13083214e-01f, -1.12719811e-01f, 3.22999954e-02f,
  -1.63237765e-01f, -4.44473065e-02f, -1.86904911e-02f, -6.10545874e-02f, 3.85780744e-02f, 8.55974257e-02f, 1.47184944e-02f, -1.09030895e-01f, 5.97158372e-02f, -3.40170115e-02f,
  6.29783645e-02f, -6.09625429e-02f, 1.48162574e-01f, -7.92023726e-03f, 6.92275688e-02f, -1.40040983e-02f, 7.02042133e-02f, 1.90831795e-01f, -2.33084504e-02f, 5.38066328e-02f,
  2.63876058e-02f, -7.86549598e-02f, 1.79271385e-01f, -5.42883910e-02f, -1.46332547e-01f, -2.43138820e-02f, 5.81837557e-02f, 1.64210081e-01f, -1.52943224e-01f, 9.94758122e-03f,
  -5.83900958e-02f, -7.52344355e-02f, -1.23543501e-01f, -4.34001423e-02f, 1.42872766e-01f, 4.04697284e-02f, 5.56255206e-02f, 1.46906376e-01f, -2.25143149e-01f, -5.83092868e-02f,
  -4.86528315e-02f, 9.14269015e-02f, -8.56726542e-02f, -7.26620331e-02f, -3.85242961e-02f, -5.12858704e-02f, 7.95452222e-02f, 6.83534592e-02f, -1.41021878e-01f, 2.61995662e-02f,
  -1.02903672e-01f, 9.14244950e-02f, -4.42722961e-02f, -9.08753127e-02f, 5.57220355e-02f, 5.31357788e-02f, 5.39167300e-02f, 9.53694433e-02f, -7.11419731e-02f, 1.89981740e-02f,
  -1.21007152e-01f, -6.66216714e-03f, -2.43033543e-02f, -1.60241678e-01f, 4.97521125e-02f, -1.99213251e-02f, -4.80395034e-02f, -1.36942580e-01f, 3.34354267e-02f, -1.78910233e-02f,
  3.06402445e-02f, 2.66790669e-02f, -1.35319486e-01f, -7.08017051e-02f, 5.82978018e-02f, 1.80485956e-02f, -1.50008515e-01f, -4.14269604e-02f, -8.90457779e-02f, -7.55672306e-02f,
  -4.49154014e-03f, 1.12434037e-01f, -4.22373451e-02f, 9.03156325e-02f, -1.48694497e-02f, 6.39475808e-02f, 2.97546498e-02f, 2.02831198e-02f, 1.05918907e-01f, 1.13627203e-01f,
  -6.32006824e-02f, -1.13583744e-01f, -4.32223417e-02f, 7.33886808e-02f, -3.90941948e-02f, 4.96094376e-02f, -1.65396273e-01f, -1.14054590e-01f, 1.86521724e-01f, -2.68348046e-02f,
  1.94908939e-02f, 5.58305308e-02f, 1.71046406e-02f, 1.61301717e-01f, -1.59911945e-01f, -1.58880889e-01f, -1.31125018e-01f, -6.13715686e-02f, 8.29454213e-02f, -1.78587735e-01f,
  -5.42362817e-02f, -9.55423936e-02f, -1.17639773e-01f, 4.39743400e-02f, 9.95698348e-02f, 3.58698219e-02f, -1.57768890e-01f, 2.72507593e-02f, 6.03637565e-03f, -2.83439755e-01f,
  1.36441335e-01f, 5.18088117e-02f, 1.94237486e-01f, -6.93305535e-03f, 1.16526859e-03f, -1.26970530e-01f, 4.51284423e-02f, -3.75120156e-02f, -8.27606991e-02f, -1.57806426e-01f,
  -2.76193172e-02f, -5.32368161e-02f, 4.39917929e-02f, 1.62882820e-01f, 2.94785164e-02f, -5.92555292e-02f, 9.26474705e-02f, -1.69732079e-01f, 9.24909562e-02f, 2.31186643e-01f,
  -1.24787306e-02f, 5.33320149e-03f, -3.38194855e-02f, 1.47192348e-02f, -9.03554261e-02f, -5.67584112e-02f, -6.70160428e-02f, 3.93727273e-02f, -1.73620090e-01f, 9.68930200e-02f,
  2.02913046e-01f, -5.71204722e-02f, -7.22626224e-02f, -2.48069316e-02f, 1.47050507e-02f, -1.57121137e-01f, -1.14968032e-01f, -8.21330324e-02f, 7.63924196e-02f, 1.38092786e-01f,
  1.27052441e-01f, 1.40984029e-01f, 1.71274081e-01f, -8.85382295e-02f, 2.48513788e-01f, -1.48166984e-01f, -3.04903612e-02f, -3.83986533e-02f, 2.34997775e-02f, 2.27812946e-01f,
  -3.13205793e-02f, -7.61122704e-02f, -1.41381517e-01f, 9.88689810e-02f, -5.55946752e-02f, -9.79630724e-02f, -1.64004907e-01f, 3.11421719e-03f, 1.61959585e-02f, -3.67142037e-02f,
  -1.00212894e-01f, -1.06881715e-01f, 4.93021235e-02f, -3.71505804e-02f, -7.39959404e-02f, 4.15939242e-02f, 7.58666769e-02f, 7.73565238e-03f, 3.61897834e-02f, -1.79755196e-01f,
  3.54674198e-02f, 3.73221412e-02f, 1.93959624e-02f, 5.65339476e-02f, -1.68921053e-01f, -3.80562954e-02f, -5.87047562e-02f, 8.46542716e-02f, -1.26268581e-01f, -6.04807511e-02f,
  1.35374546e-01f, -1.26086742e-01f, 5.17228767e-02f, 9.18020681e-03f, -2.02505980e-02f, -1.20616563e-01f, 9.57870260e-02f, 1.12711042e-02f, 3.03500202e-02f, 1.13314399e-02f,
  -1.63446352e-01f, -3.20497975e-02f, 7.43958205e-02f, -4.41446640e-02f, -6.62522241e-02f, 3.87547798e-02f, -1.32092342e-01f, 4.13815351e-03f, 4.39666286e-02f, 2.13830359e-02f,
  -8.94346461e-02f, 5.89302368e-02f, 5.20151407e-02f, 9.55379382e-02f, -1.14615075e-01f, -1.43602192e-01f, 7.87135214e-02f, 1.45492293e-02f, 9.48161632e-02f, 1.34484798e-01f,
  6.45618513e-02f, 2.29529571e-02f, -5.93243055e-02f, -4.39299159e-02f, -1.24016345e-01f, 1.04666978e-01f, 1.27882194e-02f, -2.09554378e-02f, -8.76562446e-02f, 1.25835881e-01f,
  -3.41736861e-02f, 4.35986556e-02f, 1.33937404e-01f, 2.07446590e-01f, -1.94124669e-01f, -8.51569250e-02f, -7.57942349e-02f, -1.00646831e-01f, 1.13988370e-01f, 3.70491184e-02f,
  1.32045954e-01f, -1.84028417e-01f, -1.70679599e-01f, -4.03342471e-02f, 7.32045323e-02f, -8.95046070e-02f, -4.04382078e-03f, -7.99132735e-02f, 9.08771828e-02f, -1.66963920e-01f,
  -2.31931537e-01f, -9.05171111e-02f, -1.35655599e-02f, -1.83071624e-02f, 3.54719423e-02f, -1.07585467e-01f, -1.30391791e-01f, -2.94613861e-03f, -5.04944799e-03f, -5.64332567e-02f,
  1.08018778e-02f, 6.96313381e-02f, -2.70728543e-02f, 9.29630920e-02f, 9.38827768e-02f, 9.35559347e-02f, -1.30614400e-01f, -9.47675388e-03f, 2.00678512e-01f, -9.08038858e-03f,
  2.80695073e-02f, -7.34619051e-02f, 8.86656519e-04f, 1.40730381e-01f, -2.14665592e-01f, -2.68476810e-02f, -1.34807423e-01f, -2.21957609e-01f, -1.38206378e-01f, -2.65744478e-01f,
  6.55113235e-02f, 5.16492389e-02f, 5.95668852e-02f, 1.35492429e-01f, -1.19604714e-01f, -3.68033648e-02f, 3.25355269e-02f, 1.24731883e-01f, -2.21234243e-02f, -6.57280236e-02f,
  -1.19525872e-01f, -6.75145909e-02f, 1.74268231e-01f, -1.64286550e-02f, -2.75429781e-03f, -2.65700389e-02f, 7.43024200e-02f, 1.65973585e-02f, 1.37115242e-02f, -1.98750086e-02f,
  8.67176205e-02f, -9.14266780e-02f, 6.63945973e-02f, 5.57114668e-02f, 5.20961657e-02f, 3.09963170e-02f, 1.16743423e-01f, -5.59138730e-02f, 1.31184146e-01f, 6.13294244e-02f,
  -4.35718969e-02f, 4.83401380e-02f, -6.28326461e-02f, 6.90617785e-02f, 3.97220589e-02f, 1.41828032e-02f, -3.22187915e-02f, 4.78137620e-02f, 2.05255132e-02f, 3.55952829e-02f,
  -5.63201215e-03f, 3.91713940e-02f, -2.29354128e-02f, -1.85338408e-02f, -1.62480790e-02f, 6.06126487e-02f, 2.25116070e-02f, 2.80187232e-03f, 3.97065915e-02f, -3.65811661e-02f,
  -5.49370497e-02f, 8.05506632e-02f, 2.79808119e-02f, 4.29503899e-03f, 7.82054439e-02f, 1.08483262e-01f, -9.37714800e-02f, 1.34494295e-02f, 1.05147632e-02f, 5.12648001e-02f,
  -2.54394989e-02f, -6.44487962e-02f, -1.19781770e-01f, 1.06693976e-01f, -4.86325510e-02f, 1.16275765e-01f, 2.09540185e-02f, -1.16137289e-01f, 1.63946047e-01f, 1.82742476e-01f,
  -6.84854835e-02f, -1.02257967e-01f, -1.59987375e-01f, 9.06250812e-03f, 1.39729485e-01f, -1.04130745e-01f, 9.53285024e-02f, -1.08487993e-01f, 1.68328464e-01f, 1.90999079e-02f,
  2.97679007e-02f, 1.89799160e-01f, -1.88652471e-01f, -2.55351812e-02f, -3.06717074e-03f, -1.77652389e-01f, -1.74317900e-02f, -1.71294764e-01f, -1.14316553e-01f, 2.27619827e-01f,
  -5.62029816e-02f, -2.27177236e-02f, -1.48557588e-01f, 6.91178767e-03f, 2.68955350e-01f, -1.27070531e-01f, 8.34729001e-02f, -1.01041481e-01f, -3.38132121e-02f, -5.89618534e-02f,
  -2.04782799e-01f, 1.64313808e-01f, 4.88031693e-02f, 5.13119400e-02f, -8.66253972e-02f, -3.87898088e-02f, -1.54748470e-01f, -1.11962423e-01f, 5.91942854e-02f, -7.09675252e-02f,
  -7.71052763e-02f, -8.41837451e-02f, -1.06699549e-01f, 9.70480684e-03f, 4.67461422e-02f, 1.93345070e-01f, -9.31200944e-03f, 5.59093542e-02f, -1.46410957e-01f, -7.92979449e-02f,
  1.75182492e-01f, 1.72667131e-02f, -1.83328092e-01f, 3.03355251e-02f, -1.68923378e-01f, -1.80752892e-02f, -8.30841437e-02f, -1.05799586e-01f, 2.52645668e-02f, -7.16797858e-02f,
  9.65615958e-02f, 6.18243366e-02f, 1.61331877e-01f, -9.76692811e-02f, 4.84430119e-02f, -1.20342389e-01f, -1.95641473e-01f, -3.39886621e-02f, -1.59879625e-01f, 7.08125904e-02f,
  -9.52600092e-02f, 3.46533433e-02f, -4.07076776e-02f, 4.39464785e-02f, -1.45182479e-02f, 1.42667498e-02f, -3.71238850e-02f, -1.95266940e-02f, -5.18739270e-03f, 5.54806478e-02f,
  1.33976617e-04f, 1.11889578e-01f, -7.89416060e-02f, 1.12491734e-01f, 1.60313889e-01f, -3.45931277e-02f, -2.89215930e-02f, -1.46407172e-01f, -1.96829415e-03f, 6.07090220e-02f,
  5.91431372e-02f, -5.33586629e-02f, -7.76576102e-02f, -5.24579696e-02f, 3.63933630e-02f, -1.30366972e-02f, -8.73369798e-02f, 8.85162577e-02f, 8.04756507e-02f, 5.02731949e-02f,
  -7.21852705e-02f, 1.24677502e-01f, -9.65946987e-02f, -4.19463404e-02f, 1.24761891e-02f, 1.69298336e-01f, 2.38072071e-02f, 6.25128821e-02f, 6.10843152e-02f, -5.56098707e-02f,
  2.88936738e-02f, 7.52545893e-04f, -6.14669994e-02f, 8.04376900e-02f, 4.39131185e-02f, -5.00069037e-02f, -1.04603603e-01f, -2.96300985e-02f, -4.88092452e-02f, 5.62715046e-02f,
  -1.99792255e-02f, -8.29233974e-02f, -8.55329335e-02f, -2.00854033e-01f, 1.76566496e-01f, -5.79502508e-02f, -9.64632630e-02f, -5.63526452e-02f, -1.85364351e-01f, -1.84702389e-02f,
  4.46309969e-02f, 1.13247320e-01f, -6.89102709e-02f, 6.43915683e-02f, 1.02339968e-01f, 1.77758500e-01f, -1.42194286e-01f, -1.37026355e-01f, -3.48523632e-02f, 2.47278698e-02f,
  1.85467511e-01f, 1.05426073e-01f, -8.29865038e-02f, 1.45563319e-01f, 2.12857738e-01f, 1.35564819e-01f, -6.97374567e-02f, 1.52097344e-01f, 1.17506467e-01f, 4.47648652e-02f,
  -6.12702854e-02f, 1.02406427e-01f, -1.40461907e-01f, 7.33728334e-02f, -2.35343039e-01f, -3.53472680e-02f, 8.86095762e-02f, 3.69344577e-02f, -1.51836611e-02f, -7.43253306e-02f,
  1.50253043e-01f, 2.01000005e-01f, 1.96809997e-03f, 5.11562042e-02f, 6.23446144e-02f, -5.55029779e-04f, -1.55042171e-01f, 1.02857396e-01f, 1.60671070e-01f, -5.13958633e-02f,
  -5.20482361e-02f, -1.33918405e-01f, 2.55208630e-02f, -2.13257018e-02f, 3.41240801e-02f, -1.50589272e-01f, -1.67067394e-01f, 1.35128796e-01f, 8.04768279e-02f, 3.13273594e-02f,
  -1.01859070e-01f, -1.58900544e-01f, 1.19442260e-02f, 2.11586013e-01f, 3.26404497e-02f, 2.98180848e-01f, 5.81875108e-02f, 5.06054573e-02f, -1.49533063e-01f, -4.64707762e-02f,
  3.09443902e-02f, -8.17000642e-02f, -1.31261125e-01f, 2.00228706e-01f, 1.34996578e-01f, -6.00417405e-02f, 1.79078355e-01f, 7.31245801e-03f, -3.84170040e-02f, -6.83352053e-02f,
  6.70333684e-04f, -2.88503151e-02f, -4.99360375e-02f, 6.07478768e-02f, -3.46032940e-02f, -2.65090354e-02f, 1.11751571e-01f, -6.04649372e-02f, -8.03781971e-02f, -5.72982468e-02f,
  -2.95098741e-02f, 4.32259105e-02f, 7.06546828e-02f, 4.66019958e-02f, 7.88458213e-02f, 3.31637561e-02f, 6.87354431e-02f, 6.34241775e-02f, 9.66612697e-02f, 9.03513189e-03f,
  2.29418352e-02f, -6.29576296e-02f, -3.45659293e-02f, -4.82013263e-02f, 5.13643399e-02f, 4.24037986e-02f, 9.16427970e-02f, -6.94686398e-02f, -6.55644760e-02f, -5.95164634e-02f,
  -6.93927035e-02f, -8.31817277e-03f, 4.49431352e-02f, -5.62967546e-02f, -5.32558933e-02f, 3.70446071e-02f, -5.54208718e-02f, -1.01825837e-02f, 4.82179448e-02f, 5.14257476e-02f,
  4.59953323e-02f, 1.79404877e-02f, 7.70338625e-02f, 2.39330772e-02f, -1.35966567e-02f, 1.40247822e-01f, 1.14074953e-01f, 6.80959895e-02f, -8.37897137e-03f, -3.84650193e-02f,
  1.26978785e-01f, 3.75519916e-02f, 9.39054415e-02f, -6.83879480e-02f, 4.22832519e-02f, -2.04526439e-01f, -1.67663187e-01f, -8.99998620e-02f, 7.68026859e-02f, 1.44939110e-01f,
  1.02406181e-02f, -1.33137936e-02f, -2.19599996e-02f, -9.44208354e-02f, 9.91737470e-03f, 1.08600482e-01f, 1.24821663e-01f, -8.38252977e-02f, -1.37496918e-01f, -1.24091074e-01f,
  -8.39214697e-02f, -6.68944195e-02f, 2.68761739e-02f, 2.33084127e-01f, -2.29005422e-02f, 3.99620831e-02f, -2.48211343e-02f, 1.68037061e-02f, -1.04539752e-01f, -1.43971205e-01f,
  -6.07836694e-02f, -1.55532837e-01f, -1.26080483e-01f, 4.93800901e-02f, -6.29940704e-02f, 1.44496396e-01f, 1.18192844e-01f, -4.27258126e-02f, 6.94423318e-02f, 4.71004806e-02f,
  -8.73580948e-02f, 7.58173391e-02f, 6.63389564e-02f, -5.36742061e-03f, -2.43809987e-02f, -4.68456410e-02f, 7.19975233e-02f, 9.89269838e-03f, 1.99406996e-01f, 9.85285714e-02f,
  -1.78911597e-01f, 1.32161183e-02f, 1.23448975e-01f, -2.15683170e-02f, -5.71724251e-02f, 1.63079426e-01f, 7.53558651e-02f, 2.30252892e-02f, 2.60643847e-02f, -1.48527861e-01f,
  -2.92681661e-02f, 4.58295271e-02f, 3.50543036e-04f, 2.29965579e-02f, 1.22156747e-01f, -1.62997052e-01f, -8.24160650e-02f, 5.85658401e-02f, -4.71119620e-02f, 1.42064869e-01f,
  -9.10317376e-02f, -8.17871764e-02f, 1.67546004e-01f, 1.57244116e-01f, -7.93927163e-02f, -1.14112161e-01f, -2.15669535e-03f, 8.79168436e-02f, -1.22242935e-01f, 3.60390469e-02f,
  -2.36423444e-02f, 4.87668626e-02f, 1.37584165e-01f, 4.10363339e-02f, 1.12963110e-01f, 2.03817803e-02f, -4.16757613e-02f, 5.94038889e-02f, -3.13545717e-03f, 3.09521351e-02f,
  -2.17728666e-04f, 4.72222678e-02f, 2.03880109e-02f, -2.03419048e-02f, -7.82636479e-02f, -5.50797544e-02f, -9.67792049e-02f, 7.22129792e-02f, -2.93349829e-02f, 5.52692637e-03f,
  -7.15765208e-02f, -5.74380346e-02f, 5.05677387e-02f, -7.05146790e-02f, 7.46992007e-02f, 3.51698999e-03f, 4.91957814e-02f, -3.31440791e-02f, -3.62616703e-02f, -3.30907889e-02f,
  -3.27537507e-02f, 6.29021004e-02f, -9.64158252e-02f, -3.06475721e-03f, 5.95289953e-02f, -4.35455814e-02f, 7.16719329e-02f, 4.45948690e-02f, 5.59630208e-02f, 1.40436608e-02f,
  6.88335970e-02f, 4.11680378e-02f, -6.81812351e-04f, -2.75072921e-02f, -3.86780053e-02f, -3.30447778e-02f, -1.47247035e-02f, 7.09673762e-02f, -5.80844022e-02f, 5.62195666e-02f,
  -2.34666213e-01f, 1.03485160e-01f, -1.01208590e-01f, -2.52195839e-02f, -9.22525674e-02f, -9.36559737e-02f, -8.73622820e-02f, 1.14202552e-01f, 2.45427042e-01f, 5.05920090e-02f,
  -1.01409994e-01f, 3.14025171e-02f, 8.75343829e-02f, -1.37283728e-01f, -1.19692013e-01f, 1.74033478e-01f, 2.95065381e-02f, -2.36457929e-01f, -2.32827687e-03f, -1.06697939e-02f,
  2.59397123e-02f, 6.92833140e-02f, -1.11471154e-01f, 1.59841239e-01f, -1.02282241e-02f, -1.13116048e-01f, -7.53828138e-02f, 1.08592436e-01f, -6.12822268e-03f, 1.62607759e-01f,
  1.76021203e-01f, -9.48321447e-02f, -1.42742053e-01f, -1.36005342e-01f, -4.79946472e-02f, 8.40105489e-02f, 2.22541280e-02f, 7.63701871e-02f, 7.57523719e-03f, -5.67198321e-02f,
  -1.98366866e-02f, -1.53519198e-01f, 3.08378451e-02f, 3.81141193e-02f, -6.27920628e-02f, -4.71471921e-02f, -1.42171666e-01f, -1.21158391e-01f, -3.87244523e-02f, 1.01035193e-01f,
  9.41727962e-03f, 7.77498484e-02f, 2.20234506e-02f, 9.49327797e-02f, 6.29794225e-02f, 1.37007147e-01f, -1.55084848e-01f, -1.65138151e-02f, -1.42590091e-01f, 1.26058966e-01f,
  1.89305112e-01f, 1.69363469e-01f, 5.18958010e-02f, -1.71243381e-02f, -3.63139622e-02f, -5.49733825e-02f, -2.09990263e-01f, -2.53552664e-02f, 1.31603435e-01f, 1.41549572e-01f,
  -1.40783891e-01f, -1.39588714e-01f, 1.20410971e-01f, 1.74671173e-01f, 1.65848240e-01f, 3.23314173e-03f, 2.39540637e-02f, -6.76961616e-02f, -3.28216329e-02f, -8.47730562e-02f,
  6.75577819e-02f, -1.06201001e-01f, 8.33720267e-02f, -7.11458921e-02f, -1.16267979e-01f, -4.67293486e-02f, 1.47031527e-02f, -5.74713387e-02f, -5.70427440e-02f, 8.69038925e-02f,
  -7.49365473e-03f, 2.92789489e-02f, -7.10440725e-02f, 6.51290342e-02f, -3.15864757e-02f, -9.92784742e-03f, 7.15155504e-04f, 4.83078100e-02f, 5.73126487e-02f, 5.98534150e-03f,
  3.56792659e-02f, 5.03242910e-02f, -6.28570169e-02f, 8.04874599e-02f, 4.68368316e-03f, 4.83240001e-02f, 8.14572945e-02f, 2.69721244e-02f, -8.31277370e-02f, -2.06890032e-02f,
  -7.94494897e-02f, 1.28063157e-01f, -2.00811308e-02f, -5.18473834e-02f, -7.97550082e-02f, -3.86552848e-02f, 1.30563695e-02f, -2.29520388e-02f, 1.04620203e-03f, 8.77167135e-02f,
  6.74599484e-02f, 2.04647947e-02f, -3.97256017e-02f, -1.06130905e-01f, -1.65553242e-02f, 1.41897216e-01f, -9.11960676e-02f, 1.43387839e-01f, -2.24245995e-01f, -1.50812015e-01f,
  5.44105768e-02f, 9.71825942e-02f, -1.36138514e-01f, -9.86978114e-02f, 9.65051353e-02f, -7.82158598e-02f, 1.79021388e-01f, -1.51031584e-01f, -9.16916411e-03f, -4.52257413e-03f,
  5.09726405e-02f, 4.44229841e-02f, -1.11919798e-01f, 2.36439034e-01f, -1.91712707e-01f, -1.27776280e-01f, 2.74881013e-02f, -1.22206561e-01f, -1.99899487e-02f, -7.17830136e-02f,
  -2.57243931e-01f, 9.49064568e-02f, -1.66061759e-01f, -9.07519609e-02f, -6.92765638e-02f, 4.31705900e-02f, 4.95183356e-02f, 4.14496586e-02f, 1.88121140e-01f, -2.24715263e-01f,
  -8.18845779e-02f, -7.36123845e-02f, 1.29175901e-01f, -3.22963484e-02f, -1.96429804e-01f, -1.04374677e-01f, -7.17481524e-02f, -5.44964969e-02f, -5.80012985e-02f, -2.57578250e-02f,
  1.10972553e-01f, -3.87128927e-02f, -1.98422387e-01f, 1.59411475e-01f, -7.61675015e-02f, -1.17200218e-01f, -1.08601721e-02f, 9.54224616e-02f, -1.23702988e-01f, 1.71460763e-01f,
  1.62750050e-01f, -3.69765572e-02f, 7.63986558e-02f, 1.09708160e-01f, 2.61962533e-01f, 2.38696069e-01f, 7.95712844e-02f, 7.49011040e-02f, -7.27989376e-02f, -4.50122431e-02f,
  -1.16487565e-02f, 1.56419218e-01f, 1.64040506e-01f, 4.44506332e-02f, 2.18112879e-02f, -1.00930423e-01f, 7.66966566e-02f, -2.02785566e-01f, -1.05298154e-01f, 2.90207639e-02f,
  -1.41872004e-01f, -1.91176813e-02f, 1.35294661e-01f, 1.04256950e-01f, 1.35885403e-01f, 7.25857392e-02f, 6.23855321e-03f, -3.73350903e-02f, 1.56393975e-01f, 6.59578666e-02f,
  -8.08658544e-03f, 5.45557924e-02f, -3.95173617e-02f, 3.70962434e-02f, -7.47621730e-02f, 3.24069485e-02f, 8.09080377e-02f, 1.27395585e-01f, 5.18715568e-02f, 7.47879520e-02f,
  -2.31831029e-04f, 3.62937860e-02f, 7.52237719e-03f, 3.45981568e-02f, -1.54617196e-03f, 7.08236992e-02f, 3.71887498e-02f, -1.07257087e-02f, -6.85004815e-02f, -8.73607397e-02f,
  7.44922832e-02f, 7.49405995e-02f, 6.01442046e-02f, 4.96737398e-02f, -4.09139134e-02f, 1.91483740e-02f, 7.26325139e-02f, 1.50296390e-01f, 8.79931673e-02f, -3.70910689e-02f,
  7.80841112e-02f, 7.77913779e-02f, 6.91164732e-02f, -6.63360059e-02f, 7.39462599e-02f, 7.07850382e-02f, 7.41152391e-02f, 5.19925617e-02f, 2.17013136e-02f, 9.89767350e-03f,
  8.88536647e-02f, 8.44407603e-02f, 2.31653135e-02f, 1.13117158e-01f, -5.55783585e-02f, 5.57916053e-02f, 2.03886434e-01f, -1.98615476e-01f, 1.26469925e-01f, 8.53198692e-02f,
  9.42801312e-02f, 9.78916585e-02f, 1.08383998e-01f, -1.01406895e-01f, -4.89166901e-02f, -1.00393042e-01f, 1.74423262e-01f, -1.12852879e-01f, 1.98047519e-01f, -1.09574564e-01f,
  5.97047321e-02f, -6.62224889e-02f, -6.58481941e-02f, -1.22860827e-01f, 6.93190396e-02f, -8.21119770e-02f, -1.33710861e-01f, -1.00851372e-01f, 1.27768397e-01f, 5.16041508e-03f,
  3.08981445e-02f, 7.08482368e-03f, 1.12285368e-01f, 1.58691451e-01f, 7.46893510e-02f, 3.31234038e-02f, -1.22038335e-01f, -1.16462909e-01f, 1.33373991e-01f, -7.78747275e-02f,
  -1.56243056e-01f, 5.14758378e-02f, -1.97759625e-02f, 1.50747830e-02f, 3.68876122e-02f, -4.25227731e-02f, -1.39531672e-01f, -7.91177899e-02f, 1.21681862e-01f, -4.34437618e-02f,
  -9.59278569e-02f, 3.99530213e-03f, 4.15322371e-02f, -1.07215255e-01f, 2.20235661e-01f, -1.44329831e-01f, -1.25702560e-01f, -1.62638098e-01f, -1.20140882e-02f, -6.65745838e-03f,
  9.23909023e-02f, 6.59876922e-03f, 7.93826282e-02f, 1.43601567e-01f, -4.58915997e-03f, 1.39571456e-02f, -1.08289152e-01f, 1.01291128e-01f, 4.51057311e-03f, 1.26901641e-01f,
  -3.36882379e-03f, 9.99290049e-02f, 1.02664553e-01f, -1.33987606e-01f, -1.13051087e-01f, 4.18234840e-02f, 1.76043005e-03f, 1.39003396e-01f, 1.11441851e-01f, 1.86586276e-01f,
  -6.73991889e-02f, -4.66222968e-03f, 7.23031089e-02f, 1.17778391e-01f, -5.23137003e-02f, -3.70831564e-02f, 4.13779914e-02f, 2.09851991e-02f, 7.38502219e-02f, 1.22417495e-01f,
  5.43633588e-02f, 9.11287218e-02f, 9.74069089e-02f, 6.08003922e-02f, 9.20852348e-02f, 3.47622633e-02f, 3.51962149e-02f, 9.39526856e-02f, -1.80960540e-02f, 5.19767143e-02f,
  3.08300164e-02f, 5.04711568e-02f, 4.33394723e-02f, -2.30291300e-02f, 7.30193555e-02f, 5.82055673e-02f, 1.88341111e-01f, -8.16697106e-02f, 9.08872187e-02f, -1.47665071e-03f,
  5.08036725e-02f, -1.20104738e-02f, 1.06171556e-01f, 4.49887477e-02f, 4.93342578e-02f, 1.80320982e-02f, -1.14899324e-02f, -5.79945222e-02f, 1.02149785e-01f, -2.03413013e-02f,
  1.12981908e-02f, 1.13886558e-01f, -1.55768951e-03f, 1.17815323e-02f, 1.93804428e-01f, 1.19983159e-01f, 1.01662152e-01f, -1.14272848e-01f, 3.58679295e-02f, 1.21947154e-01f,
  1.60698891e-01f, 8.58818740e-02f, -1.99163258e-02f, 3.95846143e-02f, -1.51223615e-01f, 1.02980107e-01f, -6.43529743e-02f, -1.27856554e-02f, 1.09111965e-01f, 3.10602295e-03f,
  -5.17693348e-04f, -8.13776031e-02f, 9.50898454e-02f, 2.02066481e-01f, -7.45964944e-02f, 4.70564067e-02f, 3.05364151e-02f, -1.22277245e-01f, -1.06406868e-01f, -7.49959350e-02f,
  7.85982162e-02f, 1.83331426e-02f, 1.05016530e-01f, 1.10047415e-01f, 3.39936675e-03f, 1.04355328e-01f, -6.74607381e-02f, -1.51666049e-02f, -1.94066223e-02f, -3.95482518e-02f,
  1.77018374e-01f, -9.23128352e-02f, 9.99498460e-03f, 1.18974879e-01f, 3.89766730e-02f, -3.06560993e-02f, 9.50483140e-03f, -1.48028150e-01f, -7.51499133e-03f, 5.67509495e-02f,
  -1.33035406e-01f, 1.14524655e-01f, 1.61121115e-02f, -3.14755365e-02f, 1.04559578e-01f, 7.76934847e-02f, -2.10542053e-01f, -1.28533067e-02f, 1.53501526e-01f, -6.16518408e-02f,
  6.54641986e-02f, -8.27291980e-02f, 5.56648374e-02f, -1.00108251e-01f, 9.90732983e-02f, 1.18862398e-01f, -1.44419950e-02f, 1.29951537e-01f, 5.41277528e-02f, 9.73633081e-02f,
  -1.79702371e-01f, 6.07021432e-03f, 1.25133656e-02f, -5.12962565e-02f, -4.96927276e-02f, -1.03600062e-01f, -2.91385166e-02f, 1.06054813e-01f, -1.22924589e-01f, -1.65418983e-02f,
  6.61817715e-02f, -6.14357255e-02f, -1.06767826e-01f, 9.16334093e-02f, -2.25648545e-02f, -1.36632904e-01f, 9.07253399e-02f, 1.06087595e-01f, 3.25783342e-02f, -3.45050395e-02f,
  -4.67500649e-02f, 5.27644111e-03f, -1.25345290e-01f, -6.67599142e-02f, -5.38941696e-02f, -1.43819908e-02f, -6.90817609e-02f, -6.88909814e-02f, 2.42341645e-02f, 9.13799927e-02f,
  -1.87725320e-01f, -2.50912886e-02f, -5.31253628e-02f, -2.71540545e-02f, -5.96173760e-03f, -8.10650829e-03f, -8.02295748e-03f, -1.90431297e-01f, -1.18981935e-02f, -1.09490693e-01f,
  2.59278044e-02f, -8.06242973e-02f, 1.17745083e-02f, -2.45632753e-02f, -1.30442709e-01f, -1.21913984e-01f, -7.12643564e-02f, -7.79070780e-02f, 3.59041691e-02f, 4.36027981e-02f,
  -2.99374089e-02f, 3.41974907e-02f, -1.39775854e-02f, -5.33433817e-02f, 6.63928539e-02f, -1.01493314e-01f, -8.19234829e-03f, 5.11336548e-04f, 8.17682222e-02f, 7.89230540e-02f,
  -3.63273709e-03f, 4.55143638e-02f, -8.24192017e-02f, 3.80142890e-02f, -3.26190107e-02f, -1.35296425e-02f, -2.57786140e-02f, 6.20831177e-03f, -8.22232589e-02f, -3.93456966e-02f,
  4.56854850e-02f, -1.03405111e-01f, 9.86426324e-02f, 8.48483369e-02f, 1.40053913e-01f, 8.68796408e-02f, 7.92064529e-04f, 4.21377085e-03f, 7.12014064e-02f, -2.09154725e-01f,
  -2.04888567e-01f, -1.71324238e-01f, 2.98977289e-02f, -9.79202520e-03f, -1.57476682e-02f, -3.88268717e-02f, 8.63296092e-02f, -1.11614652e-01f, -2.78647766e-02f, 1.24822579e-01f,
  -4.19685319e-02f, -7.34651238e-02f, 4.40333076e-02f, 2.39165034e-02f, 1.53751522e-01f, -1.93634599e-01f, -1.77068673e-02f, -2.54531167e-02f, 1.37091145e-01f, -1.49855241e-01f,
  -4.18180451e-02f, -3.77347507e-02f, -1.68135986e-01f, 7.35188648e-02f, -1.65626928e-02f, 3.16919982e-02f, -5.96131161e-02f, -6.54275864e-02f, 1.74264666e-02f, -1.47295401e-01f,
  1.35194585e-01f, 1.62809849e-01f, -1.20495334e-01f, 2.14422539e-01f, -3.71988863e-02f, 5.42308688e-02f, 1.19453542e-01f, 5.36269993e-02f, 2.00545955e-02f, 1.52332619e-01f,
  -4.25031334e-02f, -1.02465779e-01f, 2.56230943e-02f, -6.45193532e-02f, -1.70806386e-02f, -2.24958181e-01f, -1.51821062e-01f, -1.74471602e-01f, 1.27269834e-01f, -9.63526890e-02f,
  1.55450061e-01f, 7.73151889e-02f, 1.61798894e-02f, 4.07223701e-02f, -5.73609164e-03f, 5.41796274e-02f, 6.37022629e-02f, -1.17115237e-01f, 1.35345548e-01f, -4.98093925e-02f,
  -5.02335653e-02f, 1.71061307e-01f, 7.72382617e-02f, 1.79013878e-01f, -3.10925255e-03f, 8.42111409e-02f, -1.98307484e-02f, 2.43960433e-02f, 3.78075391e-02f, 5.27524687e-02f,
  -4.80200946e-02f, -6.95586056e-02f, -8.30792710e-02f, -1.59392087e-03f, 9.29837988e-04f, 6.93281973e-03f, 8.29038098e-02f, 6.12286888e-02f, 1.02974698e-01f, 8.79915655e-02f,
  -3.31591815e-02f, -1.79474428e-01f, -7.37842452e-03f, 2.80978810e-02f, 7.80168399e-02f, -2.69396044e-02f, -1.08650103e-01f, -6.64925799e-02f, -9.29992497e-02f, 5.90713415e-03f,
  -1.28477137e-03f, 2.45182291e-02f, 6.55959100e-02f, -8.74868929e-02f, -1.97095238e-02f, 1.01017896e-02f, 8.89635459e-02f, -1.15390852e-01f, 6.22690767e-02f, -5.08803502e-02f,
  4.11182642e-02f, 1.11532994e-01f, -5.09297624e-02f, -1.23490900e-01f, -2.15999745e-02f, 4.94202338e-02f, -7.73208216e-02f, 6.57015964e-02f, -1.05177075e-01f, -2.44533941e-02f,
  8.86859223e-02f, 1.01541147e-01f, -4.11879271e-03f, 9.54602845e-03f, 1.53753394e-02f, 4.46307287e-02f, 1.45704742e-03f, -5.50216772e-02f, -5.82863539e-02f, -1.88533023e-01f,
  1.70735568e-01f, 9.33071375e-02f, 1.00174155e-02f, -8.77266303e-02f, 7.83052593e-02f, 1.18888691e-02f, -5.84230945e-02f, -1.75722614e-01f, 1.11235436e-02f, 6.82831779e-02f,
  1.81287574e-03f, 4.70629632e-02f, -1.20896913e-01f, -1.13443106e-01f, 4.16994654e-02f, -3.73722613e-02f, 1.39061749e-01f, 1.08023033e-01f, -1.25630721e-02f, 3.56943347e-02f,
  -3.63573320e-02f, -8.49486813e-02f, 7.62423351e-02f, -1.11715853e-01f, 8.89194012e-02f, 1.27131328e-01f, 6.32919669e-02f, -1.29672855e-01f, -2.05947515e-02f, 1.08500436e-01f,
  -8.38721842e-02f, -9.99672487e-02f, -1.13074541e-01f, -4.28339243e-02f, -1.50089011e-01f, -1.20268159e-01f, 1.41866403e-02f, 8.16744007e-03f, 2.49735694e-02f, -8.36944580e-02f,
  -4.60465439e-02f, 8.06532204e-02f, -5.85955344e-02f, 1.57687664e-01f, 7.16242492e-02f, -1.39672672e-02f, 5.46703152e-02f, -1.55205071e-01f, 4.91258986e-02f, -8.10044110e-02f,
  -2.18862426e-02f, -1.09040260e-01f, 6.18508551e-03f, -1.98379248e-01f, -5.44769429e-02f, -1.42226368e-02f, -5.59577346e-02f, -1.30701005e-01f, -2.11434156e-01f, -7.64428452e-02f,
  -4.90641072e-02f, 7.74852857e-02f, -8.68210122e-02f, 2.04894260e-01f, -4.63933758e-02f, 9.45940912e-02f, -2.43630316e-02f, 4.46301652e-03f, -1.73808903e-01f, 2.43675426e-01f,
  1.60187736e-01f, -6.41218722e-02f, 7.69853815e-02f, 1.10258438e-01f, -4.20662984e-02f, 1.01256147e-02f, 8.36457014e-02f, 1.22884698e-02f, 3.18886079e-02f, -4.69545238e-02f,
  1.20618545e-01f, 1.35460079e-01f, 1.08786799e-01f, -2.92556826e-02f, -4.86442782e-02f, 6.39083935e-03f, 6.16911426e-02f, -9.01535526e-02f, -1.39239617e-02f, 2.60205325e-02f,
  3.08271945e-02f, 2.55387798e-02f, -1.50255496e-02f, 1.29532248e-01f, -5.90669177e-03f, 5.07808626e-02f, -3.19693834e-02f, 3.30619514e-02f, -2.98108086e-02f, 2.62204800e-02f,
  1.16637863e-01f, 8.70715678e-02f, -8.08269456e-02f, 2.42178813e-02f, 8.89562741e-02f, -4.22678702e-02f, -1.90747734e-02f, -6.69407621e-02f, -9.07593220e-02f, 1.10969439e-01f,
  -4.17027362e-02f, 1.03347294e-01f, -1.06507363e-02f, -1.81988887e-02f, -4.35354933e-02f, -4.63888869e-02f, -4.82339077e-02f, -2.03174651e-02f, 9.52127501e-02f, 3.70051377e-02f,
  -3.55051905e-02f, 9.56099704e-02f, 1.81584470e-02f, 8.73023868e-02f, 7.25858733e-02f, 3.32126394e-02f, -1.31043971e-01f, 1.32799178e-01f, -2.08951205e-01f, -8.56725946e-02f,
  6.72180802e-02f, -5.22457175e-02f, -9.11300480e-02f, -1.56584978e-01f, 6.65567964e-02f, 1.18016094e-01f, 2.09602967e-01f, 1.24382392e-01f, -6.48322478e-02f, 1.06864296e-01f,
  6.68202490e-02f, 8.83837789e-02f, -1.21078789e-01f, 7.74734318e-02f, -5.64219095e-02f, -2.47753397e-01f, 2.14942060e-02f, -9.28444117e-02f, 1.01010673e-01f, -1.68389399e-02f,
  -1.67704135e-01f, 1.38856560e-01f, -2.16016732e-02f, -2.26944517e-02f, -1.74145192e-01f, 6.73582107e-02f, 1.62654109e-02f, 1.75857440e-01f, 1.01387940e-01f, -1.30360365e-01f,
  -1.39519826e-01f, -1.41839549e-01f, 1.32519931e-01f, 1.29665926e-01f, -1.08920857e-01f, 6.43548295e-02f, -1.27786458e-01f, -1.49507359e-01f, 2.67573968e-02f, -1.60280019e-01f,
  1.47981986e-01f, -2.35935654e-02f, -1.75915241e-01f, 2.27027349e-02f, -3.56742963e-02f, -8.54125023e-02f, -3.36957201e-02f, -5.08376211e-02f, -3.24293040e-02f, -1.03894891e-02f,
  4.94261831e-02f, 1.39219642e-01f, 1.98545530e-01f, 1.33841395e-01f, -1.24244414e-01f, 1.16762249e-02f, -1.27588376e-01f, -3.97993848e-02f, -1.47096673e-02f, -7.02836365e-02f,
  3.26480009e-02f, -2.83493809e-02f, -5.99276796e-02f, 2.26447452e-02f, -1.20172143e-01f, 1.40398800e-01f, 1.32792532e-01f, -1.27675742e-01f, -1.12940714e-01f, -1.62531167e-01f,
  3.68807130e-02f, 2.65698936e-02f, 5.56832626e-02f, 7.21113905e-02f, 6.63295016e-02f, 8.30705836e-02f, -1.96626540e-02f, -6.31656274e-02f, 8.79317597e-02f, 3.65655273e-02f,
  1.83984246e-02f, 4.03409339e-02f, 6.46890253e-02f, -8.00846666e-02f, -5.75713962e-02f, 2.54881065e-02f, -6.92106858e-02f, 7.26885498e-02f, -8.60453993e-02f, 4.34877798e-02f,
  -1.07416756e-01f, -4.91236746e-02f, 4.18336652e-02f, -1.06474310e-02f, 9.20736231e-03f, 8.14652890e-02f, 8.00614282e-02f, 2.15847814e-03f, -1.02158822e-01f, 2.88985595e-02f,
  -8.27156082e-02f, 4.23918143e-02f, -2.16914229e-02f, 1.98787805e-02f, -4.38036919e-02f, -3.94445993e-02f, -4.44335630e-03f, -8.60286579e-02f, 8.90918598e-02f, 6.65415674e-02f,
  8.76420587e-02f, 4.69077341e-02f, 6.18181890e-03f, -1.04488067e-01f, -2.03678813e-02f, 5.11644185e-02f, -4.68886737e-03f, -5.74201569e-02f, 1.14151388e-01f, -5.44643998e-02f,
  -8.22499841e-02f, -3.78305763e-02f, -3.72491740e-02f, 1.02313131e-01f, -3.39616574e-02f, -2.97842044e-02f, -1.79671288e-01f, 4.37189341e-02f, 7.04966709e-02f, 2.25114003e-01f,
  2.26366043e-01f, 1.05709769e-01f, 1.93779767e-02f, -8.37193057e-02f, -1.74110848e-02f, 3.44823562e-02f, -2.55498756e-02f, -3.93183716e-02f, 2.36542430e-02f, -8.17468613e-02f,
  3.75909917e-02f, 1.49276145e-02f, -3.35674100e-02f, 1.53384972e-02f, 1.31946713e-01f, 6.95618242e-02f, -1.06424615e-01f, -2.42323950e-01f, 1.57326847e-01f, -1.17392419e-03f,
  1.16593681e-01f, -5.95559739e-02f, 1.51606783e-01f, 1.65587410e-01f, 6.47089854e-02f, -5.04296925e-03f, 2.14024112e-02f, 9.62879285e-02f, 1.31004974e-01f, 5.48684075e-02f,
  -8.66243243e-02f, 1.73174962e-01f, -8.23581517e-02f, -2.91955285e-02f, 8.79501831e-03f, 3.16682756e-02f, -1.40685275e-01f, -2.57172100e-02f, -3.35556492e-02f, 7.71638826e-02f,
  3.77371069e-03f, 3.95367965e-02f, -1.13768488e-01f, -1.70722798e-01f, 1.38237447e-01f, 9.78037566e-02f, -1.67651609e-01f, -8.17270651e-02f, -4.49207239e-02f, -1.09564021e-01f,
  1.77297741e-02f, -5.19358590e-02f, 3.16372104e-02f, 1.60881504e-01f, 4.28625941e-02f, 5.51343150e-02f, -1.81587674e-02f, 7.87290335e-02f, -1.59136891e-01f, -6.01132819e-03f,
  9.10981745e-02f, -1.48367405e-01f, 7.89366663e-03f, -1.64912626e-01f, 8.23244974e-02f, 1.03946052e-01f, -9.79690030e-02f, -1.51417941e-01f, 6.19231537e-02f, 2.25086100e-02f,
  -1.62216634e-01f, -7.47148991e-02f, 6.24062233e-02f, -1.17648058e-01f, 2.88969725e-02f, 1.70258917e-02f, -9.18471813e-03f, 5.81500717e-02f, -1.24818766e-02f, 8.17739964e-02f,
  -5.24590202e-02f, 9.47798416e-02f, 6.42775595e-02f, -3.90743874e-02f, -9.10381600e-02f, 3.01360488e-02f, -8.86861328e-03f, -1.41608398e-02f, -7.18657449e-02f, 6.68688044e-02f,
  5.06598689e-02f, 2.77021062e-02f, -6.40224665e-02f, -1.02779999e-01f, 5.55614047e-02f, 4.91076894e-02f, -4.37858924e-02f, -2.39920951e-02f, -9.25528482e-02f, 1.01317391e-02f,
  7.51340166e-02f, 2.23819930e-02f, -8.66245702e-02f, 6.81243166e-02f, -1.87787358e-02f, 7.45161176e-02f, -6.55975044e-02f, -9.73088145e-02f, -1.00024775e-01f, 4.37967479e-02f,
  -6.97678626e-02f, 2.71020830e-02f, 3.87459211e-02f, 4.67224419e-03f, 5.40338494e-02f, 5.95789589e-02f, -7.01562613e-02f, -1.18959928e-02f, -1.26558691e-01f, -9.38926339e-02f,
  1.55105770e-01f, -7.98604339e-02f, -1.78262249e-01f, 1.31727234e-01f, 1.31429881e-01f, -8.38585943e-02f, -9.15090218e-02f, -2.02065051e-01f, 2.40729586e-03f, 1.70820802e-01f,
  2.35314518e-01f, 1.53286248e-01f, 2.93235434e-03f, 6.61503449e-02f, 1.32401913e-01f, 1.28213331e-01f, -1.14957802e-02f, 6.86071143e-02f, -9.47373211e-02f, 2.61793360e-02f,
  1.39259160e-01f, -1.31315455e-01f, -2.43584942e-02f, 2.21467331e-01f, 7.07307383e-02f, 1.26570612e-01f, -2.38249004e-01f, 1.15556106e-01f, 8.83040857e-03f, 1.55237809e-01f,
  -7.88920373e-02f, 1.54773623e-01f, -1.56199321e-01f, 4.29511778e-02f, -1.24589533e-01f, -3.53815220e-02f, 9.78488848e-02f, 7.89053366e-02f, 7.20074847e-02f, -1.20990373e-01f,
  1.26910964e-02f, 1.44568518e-01f, 1.85021933e-03f, -5.77629209e-02f, 5.81469946e-02f, 2.65016239e-02f, 4.83486708e-03f, -7.75843635e-02f, 1.02412358e-01f, 4.60520387e-02f,
  3.63974422e-02f, 7.22086243e-03f, -2.88511217e-02f, -7.52667040e-02f, -4.92033400e-02f, 3.06066982e-02f, -7.76337460e-02f, 1.91355556e-01f, -5.91459163e-02f, 1.10812970e-01f,
  2.03004628e-01f, -6.08615018e-02f, 1.78980045e-02f, -1.01937847e-02f, -8.86611044e-02f, -2.25856509e-02f, 5.36660813e-02f, 3.93253304e-02f, -1.99137449e-01f, 1.37416527e-01f,
  -6.73007071e-02f, -8.23969841e-02f, -5.11302054e-02f, -2.17012241e-01f, 8.21674764e-02f, 6.60069883e-02f, 1.60860628e-01f, -8.36395621e-02f, -8.21191352e-03f, -9.61229354e-02f,
  -1.89706422e-02f, -4.90383543e-02f, -3.03458143e-02f, -1.18936509e-01f, 1.57528799e-02f, -5.93229793e-02f, -4.76401253e-03f, -3.47707234e-02f, -4.41397121e-03f, -5.28952852e-02f,
  -1.60095636e-02f, -6.06321022e-02f, -1.45310834e-01f, -8.07742868e-03f, -2.02119332e-02f, 1.91748124e-02f, 5.84557019e-02f, -5.66239767e-02f, 1.62928924e-02f, -7.36378739e-03f,
  3.98695702e-03f, 9.73196980e-03f, 6.51917756e-02f, 1.69592127e-02f, -1.96901597e-02f, -1.43861726e-01f, -7.04789162e-02f, -7.33917877e-02f, 8.75496119e-03f, -1.00071318e-01f,
  -7.28965998e-02f, -1.01120919e-02f, 7.17370864e-03f, -9.47130844e-02f, 5.09997159e-02f, -1.01721033e-01f, -9.92842019e-02f, -3.98076233e-03f, 6.24919310e-03f, -1.03017054e-01f,
  -5.92209809e-02f, 4.68701907e-02f, -1.14672400e-01f, 1.43337231e-02f, 3.13582756e-02f, 3.48315723e-02f, 5.79697499e-03f, -5.64376116e-02f, -6.35236651e-02f, 8.48747194e-02f,
  -1.88672519e-03f, 1.42387062e-01f, 1.22841828e-01f, -7.11684972e-02f, 1.90542504e-01f, -1.91265587e-02f, 8.32290913e-04f, -1.29852980e-01f, -5.79452841e-03f, 2.00174618e-04f,
  -1.46511391e-01f, -4.21372578e-02f, 1.09355740e-01f, -1.70045659e-01f, 1.01157241e-01f, 1.17014118e-01f, 1.30146384e-01f, -6.48355559e-02f, -1.41617119e-01f, -2.96459161e-03f,
  -9.19038206e-02f, -1.17868870e-01f, -1.13134883e-01f, -7.90958777e-02f, -3.27712111e-02f, -1.23265110e-01f, -1.79444924e-02f, 2.47036498e-02f, -6.69323578e-02f, -1.25795856e-01f,
  1.00874007e-01f, -1.56305000e-01f, -9.91394594e-02f, -2.94384118e-02f, -1.07691482e-01f, -2.78136488e-02f, -7.41056912e-03f, -1.28139928e-01f, -1.03868917e-01f, 6.57036006e-02f,
  -6.27002791e-02f, 8.65802169e-03f, -1.69359580e-01f, 1.89958811e-02f, 1.21685885e-01f, -4.53700759e-02f, -2.05642298e-01f, 8.80466551e-02f, 1.00366682e-01f, 2.62658708e-02f,
  -2.29812823e-02f, -1.26007169e-01f, -1.06899805e-01f, -3.97764668e-02f, 8.38632584e-02f, -1.57980666e-01f, -1.03739955e-01f, -6.36661872e-02f, 1.60205647e-01f, 5.83583973e-02f,
  -2.50455439e-02f, -1.78622589e-01f, -6.76222071e-02f, -6.12099618e-02f, -1.14495710e-01f, 1.44061610e-01f, -6.23129457e-02f, 1.15042649e-01f, 7.07808435e-02f, -7.04383254e-02f,
  -3.69773023e-02f, -1.74167249e-02f, 7.21799061e-02f, 1.81166440e-01f, -7.80651066e-03f, 1.75825898e-02f, 2.33214404e-02f, 7.16950968e-02f, 5.96593246e-02f, 7.50622749e-02f,
  -2.07732003e-02f, 5.87486327e-02f, 4.12924625e-02f, -8.19880664e-02f, -4.70937742e-03f, -9.14352015e-02f, 8.18961635e-02f, -7.46809691e-02f, 2.76723597e-02f, 7.56900758e-02f,
  1.06472760e-01f, 6.42863438e-02f, -8.70126188e-02f, -5.53540215e-02f, -3.30920145e-02f, -5.62883057e-02f, 9.00596976e-02f, 3.62185426e-02f, 1.58526637e-02f, 6.89739222e-03f,
  3.30072530e-02f, -8.23895782e-02f, -3.42622101e-02f, -5.66895753e-02f, -7.64500797e-02f, -1.23909459e-01f, 9.10648629e-02f, 2.49552783e-02f, -3.26490551e-02f, -1.19248666e-01f,
  -9.42046382e-03f, 8.81042890e-03f, 5.69894724e-02f, -2.56346297e-02f, -6.54665753e-02f, -4.47788052e-02f, 6.28450066e-02f, -1.62507668e-01f, 1.57250687e-01f, 1.47272088e-03f,
  -1.75978784e-02f, -6.53576851e-02f, 3.03577688e-02f, 4.56680683e-03f, -8.62999633e-02f, -1.24532290e-01f, 7.04761520e-02f, 7.07233027e-02f, -8.23543966e-02f, 3.01819779e-02f,
  1.61486298e-01f, -1.64071888e-01f, 2.46362522e-01f, 2.10930452e-01f, 1.13046519e-01f, 1.23066688e-02f, 8.69146436e-02f, -1.15117066e-01f, -1.02896355e-01f, -5.34022897e-02f,
  -7.95634650e-03f, -9.69409421e-02f, 5.79286702e-02f, -3.22117694e-02f, -2.14528009e-01f, -1.12292081e-01f, -6.66335821e-02f, 1.02355808e-01f, -3.88961211e-02f, -1.35940099e-02f,
  1.13157712e-01f, -1.00217849e-01f, -3.58087309e-02f, 1.91424266e-01f, 2.00488605e-02f, 1.08171757e-02f, -3.71959656e-02f, 1.87664479e-01f, 1.40928105e-01f, -1.40122309e-01f,
  1.48473503e-02f, 3.50760594e-02f, 2.00346917e-01f, 7.22006261e-02f, -1.06646620e-01f, -4.63872850e-02f, -3.65957022e-02f, 1.72398165e-02f, -5.36118299e-02f, 5.98679222e-02f,
  4.66283855e-05f, 1.22067422e-01f, -1.32817179e-01f, -2.95035336e-02f, 2.25270856e-02f, -6.42730892e-02f, 6.17531165e-02f, -2.82653216e-02f, 5.84925413e-02f, 2.42009889e-02f,
  -1.48798794e-01f, -1.25977740e-01f, 1.21377982e-01f, 9.88291129e-02f, 7.55728260e-02f, -2.60100543e-01f, 2.31605843e-01f, -1.36163488e-01f, 1.51847243e-01f, 1.58088386e-01f,
  -1.39642730e-01f, 2.07089353e-02f, -4.01179232e-02f, -1.98779434e-01f, -1.55514991e-02f, -6.80988804e-02f, 1.31391898e-01f, -1.12336345e-01f, -5.66304587e-02f, -1.10326633e-01f,
  -1.75518263e-02f, 1.49992444e-02f, -1.71069384e-01f, 5.47018135e-03f, -9.35471132e-02f, 1.18190549e-01f, -8.41089189e-02f, -1.79446954e-02f, -2.54498683e-02f, -2.93082669e-02f,
  9.52288061e-02f, 7.64990598e-02f, 9.87128317e-02f, 1.18888922e-01f, -5.25349900e-02f, -3.43754590e-02f, 6.06436320e-02f, 5.49287535e-02f, 8.85294527e-02f, -9.51828659e-02f,
  1.69247296e-02f, 1.27329037e-01f, -3.13101634e-02f, 7.05602616e-02f, -2.78035533e-02f, 8.61557759e-03f, -4.41005938e-02f, 4.75062653e-02f, -7.04513937e-02f, -3.31284143e-02f,
  1.39512897e-01f, 1.26314074e-01f, 9.59321931e-02f, 2.07357872e-02f, -1.50638912e-02f, -7.40069300e-02f, -2.06137896e-02f, 5.57764955e-02f, -3.11920475e-02f, 3.34273800e-02f,
  -2.57687308e-02f, 9.21832025e-02f, 1.58635061e-03f, -3.81777808e-02f, -6.00905530e-02f, 1.03309192e-01f, -1.03065344e-02f, 7.91678056e-02f, 1.75594371e-02f, 1.09474875e-01f,
  -5.28046973e-02f, -5.13203517e-02f, 1.13276821e-02f, 1.54165611e-01f, 1.54788801e-02f, -1.18199009e-02f, -4.35299650e-02f, 6.53704209e-03f, -1.63751259e-01f, 1.85608000e-01f,
  -1.00994170e-01f, -9.67577547e-02f, 1.70392767e-02f, -1.13854565e-01f, -1.03742212e-01f, 1.67281196e-01f, 1.25770479e-01f, 1.72437221e-01f, -1.80095818e-03f, 2.85289157e-02f,
  -1.06134750e-02f, -1.04017921e-01f, -8.38563740e-02f, 2.31213868e-01f, 1.28384173e-01f, -5.32962382e-02f, 7.56444642e-03f, 9.68737304e-02f, -1.27006080e-02f, 4.48232405e-02f,
  -1.91658393e-01f, -5.77512570e-02f, -8.94459896e-03f, 1.48412911e-02f, -1.01172045e-01f, -1.68829262e-02f, -4.73690592e-02f, 7.70212859e-02f, 1.38087571e-01f, -1.71253145e-01f,
  -2.07320824e-01f, -1.23203635e-01f, 9.22010913e-02f, -1.18276589e-02f, 3.63698341e-02f, -1.03216348e-02f, -1.32012501e-01f, -2.99203973e-02f, 1.00031402e-02f, -1.59892559e-01f,
  -3.57781351e-03f, 1.36634737e-01f, -9.66002420e-03f, -9.28656161e-02f, 4.51463312e-02f, -1.24164581e-01f, -6.57044575e-02f, 1.49563262e-02f, 1.36167184e-01f, 1.47138834e-01f,
  2.29272153e-02f, 1.70236275e-01f, 4.30272631e-02f, 1.69877708e-01f, -1.83723181e-01f, 3.73077393e-02f, -1.05491936e-01f, 1.16509803e-01f, 1.82446495e-01f, 4.35974225e-02f,
  -5.52316681e-02f, 1.22870296e-01f, 7.44522661e-02f, 8.66694823e-02f, -1.78258702e-01f, 4.46226373e-02f, 1.07832193e-01f, 9.98301208e-02f, -9.20529366e-02f, -8.98921862e-02f,
  1.39669046e-01f, 3.38093936e-02f, -1.38021633e-02f, -7.13896751e-02f, 6.44534305e-02f, -1.02951884e-01f, 9.24811587e-02f, 1.67937819e-02f, 1.13555612e-02f, -7.02874064e-02f,
  -8.11515078e-02f, -4.75081801e-02f, 4.73091155e-02f, 2.21325569e-02f, 1.37358736e-02f, -5.77788949e-02f, 1.42166197e-01f, -1.10330038e-01f, 1.11538231e-01f, 9.56221521e-02f,
  -4.59501371e-02f, -5.32094464e-02f, -3.19892401e-03f, 5.13610356e-02f, 6.00580052e-02f, 1.36923611e-01f, 4.65173135e-03f, -2.25128662e-02f, 1.35856271e-01f, -1.63939819e-02f,
  2.43541859e-02f, 1.32318446e-03f, 5.59237003e-02f, 5.60954027e-03f, 2.96673831e-02f, 1.03094894e-02f, 1.16629802e-01f, -1.44698828e-01f, 3.21873315e-02f, -3.91574688e-02f,
  9.90734785e-04f, -3.90566476e-02f, 2.64963415e-02f, 1.43166520e-02f, 6.62554875e-02f, 1.18370794e-01f, -3.38484794e-02f, 2.28434186e-02f, 1.19696453e-01f, -9.48369503e-02f,
  1.03912026e-01f, 3.25064436e-02f, -6.01334013e-02f, 1.17454231e-01f, -6.95656911e-02f, 6.98397830e-02f, 1.22933291e-01f, -7.90220872e-02f, 1.08257703e-01f, -4.82235849e-02f,
  -3.20157595e-03f, -8.95724222e-02f, -1.59973189e-01f, -2.90694050e-02f, -8.72782171e-02f, -5.06218337e-03f, 3.24869379e-02f, -8.55527520e-02f, 1.43778324e-01f, -1.34670958e-01f,
  1.85124695e-01f, 4.57608066e-02f, -1.57219749e-02f, 1.52472062e-02f, 7.16402084e-02f, -3.42401080e-02f, -1.84930563e-01f, -9.86906793e-03f, 8.60594362e-02f, 6.30718768e-02f,
  -1.06469996e-01f, 1.26527116e-01f, 1.61921084e-02f, -2.10682034e-01f, 2.40825355e-01f, -1.01176247e-01f, -2.31953021e-02f, -1.88565254e-02f, -8.01693425e-02f, 6.38862234e-03f,
  -5.59431724e-02f, 1.96858764e-01f, -2.05139890e-02f, 5.03313728e-02f, 2.80518699e-02f, -1.16821699e-01f, -1.98124796e-01f, 1.29927844e-01f, -1.29578382e-01f, -6.10129870e-02f,
  2.31012031e-02f, 5.54996617e-02f, -3.33515853e-02f, 2.60624010e-02f, 2.22032350e-02f, -8.05173814e-02f, -1.44942924e-01f, -6.04714779e-03f, -6.74978346e-02f, -1.45592615e-01f,
  5.03866188e-02f, 1.07015774e-01f, -1.96321920e-01f, 9.06630531e-02f, -2.52942950e-01f, -2.42137238e-01f, -2.36071035e-01f, -1.49628013e-01f, -1.96065426e-01f, 1.93805113e-01f,
  -1.49237648e-01f, 2.22150624e-01f, 1.13378420e-01f, -9.38564166e-02f, 1.79413538e-02f, -1.40654951e-01f, 2.06800643e-02f, 1.01529725e-01f, -2.96315625e-02f, -3.60743143e-02f,
  -1.20118437e-02f, -4.95021977e-02f, 2.54605301e-02f, 2.05582250e-02f, -9.16500241e-02f, -2.54264735e-02f, -9.86256003e-02f, -2.27546636e-02f, 7.74648488e-02f, 2.99086771e-03f,
  2.69432440e-02f, 9.55724493e-02f, 1.31844744e-01f, 4.21408011e-04f, 7.78088942e-02f, -3.73853706e-02f, -1.07609937e-02f, -1.22340381e-01f, 1.78812183e-02f, -8.62034503e-03f,
  -2.68408265e-02f, -1.58689450e-02f, 4.90546487e-02f, -1.21795811e-01f, 4.15532663e-02f, -9.60250273e-02f, -5.50486706e-02f, 6.52504712e-02f, 6.78451583e-02f, -3.33382897e-02f,
  6.36763498e-02f, 4.12921719e-02f, -6.60955682e-02f, 5.57013694e-03f, 5.26028743e-04f, 1.48734570e-01f, -2.23511867e-02f, -5.19773401e-02f, 5.98912761e-02f, 3.96131203e-02f,
  -4.64056134e-02f, 2.92724222e-02f, 7.21452944e-03f, -3.78768966e-02f, -8.57215896e-02f, 2.57779434e-02f, -1.08077429e-01f, -5.52964630e-03f, -8.07589591e-02f, 3.95937413e-02f,
  5.44969961e-02f, -6.58820421e-02f, -1.81682989e-01f, -1.83637500e-01f, 1.12938739e-01f, -1.61201153e-02f, -1.48208737e-01f, -9.88315716e-02f, -2.00244620e-01f, 6.98249508e-03f,
  -3.53243575e-02f, 4.82151322e-02f, -1.18187601e-02f, 8.62556919e-02f, 8.31303820e-02f, 1.52774870e-01f, -1.39753118e-01f, -5.75507171e-02f, -5.31818829e-02f, 1.64110109e-01f,
  1.02109402e-01f, 1.37244284e-01f, -1.24573551e-01f, 1.16169669e-01f, 1.90789327e-01f, -1.29248761e-02f, -1.34310126e-01f, 1.49366111e-01f, 2.55118255e-02f, -7.48533309e-02f,
  -8.23415592e-02f, 1.11640893e-01f, -9.64309275e-02f, 1.00122489e-01f, -1.63607463e-01f, -1.83556333e-01f, -5.63708544e-02f, 8.39042738e-02f, -2.00710297e-02f, 1.47380829e-02f,
  1.29387394e-01f, 3.98802049e-02f, -4.25731093e-02f, 1.50985410e-02f, 1.12911984e-02f, -1.60276189e-01f, 3.16134058e-02f, 1.24622725e-01f, 8.95024538e-02f, 1.16886206e-01f,
  -1.26887888e-01f, -1.70071304e-01f, 4.82685044e-02f, -6.04316629e-02f, 1.10744618e-01f, -3.75267118e-02f, -6.08718954e-02f, 1.23197280e-01f, -3.42636667e-02f, 1.33965891e-02f,
  -1.15162119e-01f, -1.61292344e-01f, -6.89695850e-02f, 1.93734691e-01f, 1.45260289e-01f, 2.43723273e-01f, 9.27132741e-03f, 4.69986498e-02f, -1.08677208e-01f, 2.54247393e-02f,
  -1.20704122e-01f, 5.64025789e-02f, -7.22304061e-02f, 1.32639363e-01f, 4.24246723e-03f, -7.34305233e-02f, 7.96625838e-02f, -5.85478172e-02f, 1.90575514e-02f, 5.30811064e-02f,
  1.17512703e-01f, -7.16284662e-02f, 6.21891059e-02f, 4.48732190e-02f, -2.77002249e-02f, -2.96760481e-02f, 8.47260281e-02f, -9.23921689e-02f, -4.61261608e-02f, 6.73932508e-02f,
  4.07270156e-02f, -1.54432831e-02f, 2.85639130e-02f, 1.01180002e-01f, -5.01747755e-03f, 1.47057488e-03f, -6.76775128e-02f, 4.65954542e-02f, 2.88347676e-02f, 6.16300032e-02f,
  7.39135444e-02f, -4.73710224e-02f, 3.52291763e-02f, 3.94452922e-02f, 2.92545613e-02f, 1.03833258e-01f, 4.98929843e-02f, 8.00464973e-02f, 4.52347696e-02f, 1.75803050e-01f,
  4.60961973e-03f, 8.06737244e-02f, -2.12210463e-03f, -8.57174620e-02f, 3.08514275e-02f, 5.17809130e-02f, -1.36798665e-01f, -4.95228916e-02f, -2.65330225e-02f, -2.84333248e-02f,
  -1.13641601e-02f, 6.32273033e-02f, -1.03427574e-01f, 4.76105474e-02f, -1.53912306e-02f, 1.18959315e-01f, -6.00957423e-02f, -1.93130374e-02f, -3.90934460e-02f, 1.18099160e-01f,
  -7.74207711e-02f, -3.11369020e-02f, 7.08463341e-02f, -8.93852040e-02f, -1.10204436e-01f, -5.38390204e-02f, -6.72160685e-02f, 1.78920463e-01f, 2.02920139e-01f, 1.39853776e-01f,
  -1.34374082e-01f, -1.32350817e-01f, 2.37903744e-02f, 8.82648751e-02f, -2.52298415e-02f, 1.74481034e-01f, 1.66692466e-01f, -1.89048856e-01f, -1.51436374e-01f, 3.55535783e-02f,
  -1.27512425e-01f, 2.92649418e-02f, 3.73258516e-02f, -6.96357060e-03f, 1.43362105e-01f, -8.86393636e-02f, 4.87807319e-02f, 4.18134741e-02f, -1.55855790e-02f, 4.90387715e-02f,
  -6.37740642e-02f, -1.38670757e-01f, -2.17746496e-01f, 1.11838184e-01f, 1.31424978e-01f, 1.83150753e-01f, -8.73300154e-03f, 5.83625492e-03f, -7.58724809e-02f, -1.16082363e-01f,
  1.40250295e-01f, -4.50766087e-02f, -1.13624461e-01f, 1.63833126e-01f, 2.11539008e-02f, -1.33701995e-01f, 6.00319952e-02f, 2.04211883e-02f, 1.56308003e-02f, 1.33917674e-01f,
  1.34825990e-01f, -1.84960645e-02f, -2.06220220e-03f, -2.41465438e-02f, -6.21167533e-02f, 4.94571635e-03f, -2.24030223e-02f, 9.64580849e-02f, 1.44864067e-01f, -1.34356357e-02f,
  1.23992838e-01f, -1.03923425e-01f, -1.93989158e-01f, -8.17732587e-02f, 8.52413625e-02f, -7.56633207e-02f, -3.84291075e-02f, 7.87860677e-02f, 9.26944539e-02f, -3.31373550e-02f,
  -4.57406044e-02f, -1.55162185e-01f, 2.02648342e-02f, 8.68418440e-02f, 6.62179515e-02f, -2.04313099e-01f, -1.00101590e-01f, -8.32555741e-02f, 6.37095645e-02f, 4.20856699e-02f,
  -5.88809885e-02f, 1.15956150e-01f, 7.90150836e-02f, 1.20007053e-01f, -2.57631894e-02f, 1.27012417e-01f, 8.99529234e-02f, 6.69452362e-04f, 2.35183183e-02f, 2.45463829e-02f,
  -6.92691356e-02f, -2.30229758e-02f, 6.26756996e-02f, -6.18713871e-02f, -4.53844154e-03f, 3.06175407e-02f, -2.64742002e-02f, -1.87812035e-03f, 2.47397888e-02f, -3.05174049e-02f,
  -9.00458023e-02f, -9.72139463e-02f, -1.21103659e-01f, 1.59944311e-01f, -4.80834953e-02f, -8.62123370e-02f, -4.95652482e-02f, 8.94042552e-02f, -5.89447804e-02f, -1.42717548e-02f,
  -1.37355144e-03f, 2.35844366e-02f, -2.50299703e-02f, -4.25292295e-04f, -7.20716417e-02f, 2.40015592e-02f, -7.31428340e-02f, 8.76152143e-02f, -8.02656263e-02f, 8.67293403e-03f,
  -9.80827287e-02f, -9.11273584e-02f, -3.21704596e-02f, 9.78917405e-02f, -9.80314519e-03f, -2.20544711e-02f, -2.14378890e-02f, -2.00628296e-01f, 1.30053908e-01f, 4.95047979e-02f,
  9.73475203e-02f, 6.52795732e-02f, -1.41155288e-01f, -2.14291155e-01f, -1.68172285e-01f, -5.63384667e-02f, 4.19875793e-02f, 2.52405733e-01f, -8.16849805e-03f, -1.02677181e-01f,
  5.04531041e-02f, 1.00016057e-01f, -3.21378410e-02f, -2.99209915e-02f, 6.04779124e-02f, -8.80599543e-02f, -1.34274289e-01f, -1.17785949e-02f, -7.26685226e-02f, -2.89835501e-02f,
  1.67140037e-01f, 1.54991746e-01f, 5.75294718e-02f, -2.75813248e-02f, -3.28482576e-02f, 3.44213098e-02f, -7.20119998e-02f, -1.04450159e-01f, -9.34144258e-02f, -3.32137309e-02f,
  -7.94751421e-02f, 1.04591608e-01f, -1.51944635e-02f, 1.42215088e-01f, 8.71922895e-02f, -1.00050867e-01f, 6.18068650e-02f, 3.42969857e-02f, -8.92921314e-02f, 1.97024032e-01f,
  3.18054408e-02f, -4.46528643e-02f, 4.06895354e-02f, -6.76308498e-02f, 9.48183890e-03f, -5.00017703e-02f, 1.76733091e-01f, 1.16378389e-01f, -1.25405118e-01f, -6.89305067e-02f,
  2.12072581e-01f, -1.04151003e-01f, -4.09475379e-02f, 1.37115791e-01f, -3.02169360e-02f, -9.21528488e-02f, -1.17238909e-01f, -2.35277221e-01f, 3.82036231e-02f, 1.65342346e-01f,
  1.44396548e-03f, 6.35642484e-02f, 1.98405430e-01f, -1.08475238e-01f, -4.06479053e-02f, -6.96506798e-02f, -1.29250005e-01f, 5.24557494e-02f, -7.43491277e-02f, -8.26496482e-02f,
  1.44625664e-01f, 1.88696027e-01f, -3.84078994e-02f, -6.76456541e-02f, -1.90161057e-02f, 3.60472426e-02f, -1.36978261e-03f, 1.19467238e-02f, -1.86832882e-02f, 9.68336165e-02f,
  4.03526910e-02f, -4.81414944e-02f, 3.33226100e-02f, -9.71224457e-02f, -1.15777954e-01f, -3.31733972e-02f, -7.22541288e-02f, 1.32314907e-02f, -6.08775802e-02f, 1.19261123e-01f,
  -5.25549725e-02f, 2.06619091e-02f, 1.23380553e-02f, 8.69890675e-02f, 8.79012141e-03f, -3.88269573e-02f, 5.97798117e-02f, -6.09761812e-02f, -6.21767528e-02f, -7.99218565e-03f,
  -8.02677721e-02f, -1.94372814e-02f, -6.08037934e-02f, -7.31243640e-02f, -1.37444865e-02f, -4.22351062e-02f, 1.01849511e-01f, -3.34919058e-02f, -9.97257456e-02f, -4.37233858e-02f,
  -7.32474774e-02f, 5.63374609e-02f, -7.63437599e-02f, -5.93457278e-03f, 1.65689792e-02f, 7.37108588e-02f, -2.78418530e-02f, -4.70684096e-02f, 2.66707800e-02f, 5.58841377e-02f,
  -1.85172763e-02f, 1.42173067e-01f, 1.75372865e-02f, -8.06321111e-03f, 1.72421969e-02f, -1.10161364e-01f, -2.19894238e-02f, 1.34235650e-01f, -1.79443806e-01f, 6.98420703e-02f,
  -3.32210287e-02f, -4.23755199e-02f, -1.84452817e-01f, -7.88895190e-02f, 1.28669754e-01f, 5.88231646e-02f, 2.03304499e-01f, -5.94243929e-02f, -1.45407692e-01f, -7.20253438e-02f,
  -1.26243711e-01f, 1.59352779e-01f, -6.36249334e-02f, 9.84469056e-02f, -1.64734185e-01f, -1.65037200e-01f, -1.17812052e-01f, -1.61017388e-01f, 4.41381410e-02f, 4.84659523e-02f,
  -1.75813898e-01f, 8.20657762e-04f, -9.72891152e-02f, 1.16476491e-02f, -7.85259753e-02f, 6.35268018e-02f, 2.48050913e-02f, 1.94433238e-02f, 2.34410986e-01f, 3.68129904e-03f,
  7.85731822e-02f, 1.10350452e-01f, 1.24059699e-01f, -1.08691387e-01f, 6.68365806e-02f, -1.43124804e-01f, 3.35287042e-02f, 4.70568463e-02f, 1.70068145e-01f, -5.05352207e-02f,
  -1.91853810e-02f, 2.91764978e-02f, -7.56214038e-02f, -2.89798509e-02f, -2.56658569e-02f, 3.70285548e-02f, -1.94659993e-01f, 2.81250644e-02f, 1.33464336e-01f, 1.81132317e-01f,
  1.74452439e-01f, 2.12941095e-01f, 5.20398580e-02f, 3.31602991e-03f, 2.03952074e-01f, 1.02259338e-01f, 1.47840559e-01f, 3.50849144e-03f, 3.46697643e-02f, -6.83223233e-02f,
  2.08339334e-01f, -2.16574192e-01f, 1.26233965e-01f, -9.11361501e-02f, -2.20970169e-01f, 3.16434130e-02f, 1.34929299e-01f, -1.61240727e-01f, -1.47644043e-01f, -1.86519008e-02f,
  -5.75080141e-02f, -1.41158938e-01f, -9.11128987e-03f, 6.90458864e-02f, -7.62996227e-02f, -5.84342666e-02f, 1.17303342e-01f, 5.53724840e-02f, -4.80589382e-02f, 5.01473509e-02f,
  -2.19237823e-02f, 2.76403613e-02f, 1.29605249e-01f, -6.86658174e-02f, -6.78141341e-02f, 2.70203911e-02f, -9.51074660e-02f, -5.30394167e-02f, -5.79004325e-02f, -5.68815172e-02f,
  6.23866804e-02f, -9.67558101e-02f, -8.70651230e-02f, -2.07909513e-02f, 4.04510014e-02f, 2.06637383e-02f, -1.03342459e-01f, 1.15375658e-02f, -2.56185047e-02f, 6.13771826e-02f,
  -4.58608903e-02f, 7.64794201e-02f, 3.65740955e-02f, 3.91514152e-02f, 7.14346915e-02f, 2.54943259e-02f, 7.76073709e-02f, 1.74688622e-02f, -9.35145319e-02f, -1.68176796e-02f,
  3.60954739e-02f, -1.81796439e-02f, 1.15227448e-02f, 3.35206203e-02f, -1.33119535e-03f, 4.84043136e-02f, -1.90167334e-02f, 2.06289310e-02f, -3.42008173e-02f, -6.54835328e-02f,
  6.02885298e-02f, -1.07180402e-02f, -1.29718363e-01f, -2.07946803e-02f, 2.39793099e-02f, -1.14983201e-01f, 4.00173590e-02f, 8.04786384e-02f, -8.43629241e-02f, 4.32274118e-02f,
  3.90082598e-02f, 9.42561626e-02f, -1.17819697e-01f, -3.77419218e-02f, -8.69510025e-02f, -1.19592018e-01f, 1.20949656e-01f, 3.02782040e-02f, -4.25775647e-02f, -1.69510752e-01f,
  3.87489460e-02f, -8.27110931e-02f, 2.84886491e-02f, 2.88175136e-01f, 3.66571583e-02f, 1.53053433e-01f, -1.22233868e-01f, -1.82159305e-01f, 8.00271630e-02f, -2.43325964e-01f,
  1.63609356e-01f, 4.63019945e-02f, 1.70786589e-01f, 5.95742054e-02f, -2.21044987e-01f, 1.13671742e-01f, -1.32832974e-01f, 1.78883493e-01f, 1.47392489e-02f, 1.41752869e-01f,
  -5.79758920e-02f, -6.71303272e-03f, 4.68658544e-02f, -1.21295623e-01f, 8.98651928e-02f, 1.02944568e-01f, -1.26410639e-02f, 3.99383605e-02f, 5.50010465e-02f, 1.54603317e-01f,
  3.80396210e-02f, 1.06143784e-02f, -4.80614603e-03f, -1.26577854e-01f, 2.24779531e-01f, -8.79339650e-02f, -2.70898528e-02f, -9.57046263e-03f, -1.37045786e-01f, -1.66215286e-01f,
  -2.34707549e-01f, 9.96611714e-02f, 7.93847814e-02f, 7.33511895e-02f, 9.06497911e-02f, 5.00067100e-02f, 4.09854501e-02f, 1.32481635e-01f, -1.58298045e-01f, 8.31143260e-02f,
  -3.15180570e-02f, 6.67108670e-02f, 6.66574459e-04f, 1.60598457e-02f, 4.33015451e-02f, 2.26510927e-01f, 7.29071051e-02f, -1.19952150e-01f, 1.22968227e-01f, 6.81983531e-02f,
  3.64991874e-02f, -5.01440577e-02f, 5.51555529e-02f, -2.71100532e-02f, -9.63714793e-02f, -7.91391879e-02f, 1.46475092e-01f, 5.30789047e-02f, 2.81033595e-03f, -1.37212779e-02f,
  -1.42992577e-02f, 6.60493299e-02f, -5.06722927e-02f, -7.29829744e-02f, -3.31467763e-02f, -3.78326289e-02f, -8.55330378e-02f, -2.50072535e-02f, -2.11083572e-02f, 1.33935586e-02f,
  1.74280964e-02f, 3.32627632e-02f, 6.13945983e-02f, -3.21832485e-02f, -4.71104383e-02f, 8.40547681e-03f, 8.41659307e-03f, -7.33124465e-02f, 1.00494530e-02f, 4.35174815e-02f,
  1.53993130e-01f, 2.46740077e-02f, 8.36513564e-03f, -3.08177085e-03f, -9.30988118e-02f, 3.38262580e-02f, -5.40793166e-02f, 6.56257942e-02f, 7.87662268e-02f, 6.35558665e-02f,
  -3.14835869e-02f, -8.78566429e-02f, -5.16683087e-02f, 1.19863704e-01f, -4.98926938e-02f, 9.03345495e-02f, -8.65279511e-02f, 7.85889104e-02f, 3.76160517e-02f, -7.72940516e-02f,
  5.31258956e-02f, 4.32422422e-02f, -9.25136879e-02f, 1.67464167e-01f, -3.24704386e-02f, -1.72488138e-01f, 1.69708461e-01f, -4.72649410e-02f, -5.09636700e-02f, -1.16385706e-01f,
  4.96883169e-02f, -3.75696048e-02f, 1.42950833e-01f, -1.64093181e-01f, 2.74087247e-02f, -1.32486019e-02f, 7.14485496e-02f, 4.70968597e-02f, -1.45759732e-01f, 1.36029974e-01f,
  2.11062748e-02f, -2.38042131e-01f, -1.61620840e-01f, -1.55185774e-01f, -7.32060447e-02f, -7.49284774e-02f, -1.48429573e-01f, 7.11767524e-02f, -7.62423575e-02f, 8.29752013e-02f,
  -9.68096107e-02f, 1.14233375e-01f, 1.53075263e-01f, 1.00463413e-01f, 1.13470726e-01f, -1.87558398e-01f, 3.37921567e-02f, -1.62600979e-01f, -5.95002584e-02f, -1.06271215e-01f,
  -1.55885160e-01f, 1.45106360e-01f, -2.53175292e-02f, -1.25092745e-01f, -9.18789729e-02f, -1.61536530e-01f, 2.24810854e-01f, -1.44415190e-02f, -2.23152921e-01f, 1.44549489e-01f,
  -4.06361446e-02f, -1.21648386e-01f, -3.97809371e-02f, -5.59327044e-02f, 1.42186452e-02f, -4.28722091e-02f, 1.09747939e-01f, 6.11325167e-02f, 1.35287708e-02f, 1.09478749e-01f,
  1.12092935e-01f, 8.82681087e-02f, 3.05094267e-03f, 6.34654388e-02f, -2.82810964e-02f, 4.27418314e-02f, -6.76506683e-02f, 1.57131135e-01f, -1.77164942e-01f, 1.00379080e-01f,
  -8.95390958e-02f, -1.65298894e-01f, -3.16125266e-02f, -2.71624885e-02f, -1.09042086e-01f, 1.16172723e-01f, -3.08205932e-02f, 4.31152657e-02f, 3.50533910e-02f, 5.09463511e-02f,
  1.68605428e-02f, -2.34073233e-02f, 1.15809262e-01f, -4.02746201e-02f, -7.21828118e-02f, -8.53761286e-03f, 3.25265573e-03f, -7.54828826e-02f, -2.02229191e-02f, 2.76085045e-02f,
  -3.99252698e-02f, -1.90715194e-02f, -6.17325306e-02f, 1.27819911e-01f, -1.77601203e-02f, 3.44848000e-02f, 4.47171042e-03f, -1.08107544e-01f, -4.53414256e-03f, 6.97805658e-02f,
  6.15913533e-02f, -5.89814968e-02f, 8.21360126e-02f, -1.71010867e-02f, 5.01523282e-05f, -6.20698817e-02f, -8.75577796e-03f, 3.31147248e-03f, 9.81665179e-02f, 3.92763466e-02f,
  -8.35207850e-02f, -5.76729998e-02f, -6.82512345e-03f, -1.34561270e-01f, -6.24031536e-02f, 9.67755169e-03f, -2.50934437e-02f, -9.17344987e-02f, 8.01188424e-02f, -3.36811431e-02f,
  -5.69790602e-02f, 5.17084263e-03f, -1.12061955e-01f, -9.35799908e-03f, 1.20902233e-01f, -9.54250172e-02f, -4.80340533e-02f, -1.13001287e-01f, 7.07742479e-03f, 2.18833894e-01f,
  -1.78708732e-01f, -7.97636155e-03f, -9.50659439e-02f, -1.05021715e-01f, -2.76138104e-04f, -9.31019410e-02f, 5.38611338e-02f, 1.39843807e-01f, 1.40313655e-01f, -8.25073645e-02f,
  -1.67705715e-01f, -1.41056348e-02f, -4.13436368e-02f, -2.50698924e-02f, 1.02135383e-01f, 8.04083422e-02f, 1.29701659e-01f, -1.52783409e-01f, -3.76744382e-02f, -2.09750549e-04f,
  -5.98781183e-02f, 1.46596044e-01f, -1.98278576e-01f, -1.06572762e-01f, -1.55143877e-02f, 4.62659374e-02f, 4.92273830e-02f, -1.25851352e-02f, 6.39595464e-02f, 1.31415367e-01f,
  -3.42756673e-03f, -3.59859616e-02f, -1.22141182e-01f, 2.93169189e-02f, 1.88850164e-01f, 2.41866410e-02f, 6.54060543e-02f, 5.74952178e-02f, -1.86240241e-01f, -1.12138432e-03f,
  1.34731039e-01f, -1.18220523e-01f, -1.95747867e-01f, 1.46102309e-01f, 1.39112584e-02f, -4.93441187e-02f, -1.41676471e-01f, 1.70061171e-01f, -1.40558347e-01f, 4.54199640e-03f,
  9.74680856e-02f, -4.86692749e-02f, -2.24154308e-01f, -2.42644623e-02f, -4.64337692e-02f, -6.40031248e-02f, -1.58409715e-01f, 1.32278398e-01f, 2.22177938e-01f, 1.09513760e-01f,
  -1.51562737e-02f, -1.11136995e-01f, -9.01499093e-02f, 3.89736779e-02f, -1.67562112e-01f, 3.27816978e-02f, -5.89736998e-02f, 1.32600516e-01f, 1.72740072e-01f, -9.18034688e-02f,
  -6.19402453e-02f, -1.04784191e-01f, -2.19030920e-02f, 1.30029798e-01f, 1.12389484e-02f, -1.82323143e-01f, 1.81978330e-01f, 2.32315417e-02f, 2.57307105e-02f, -3.99008766e-02f,
  -2.28257943e-02f, 3.39220203e-02f, 1.03717640e-01f, -9.82497260e-02f, 4.19465303e-02f, -8.74096826e-02f, -9.70539916e-03f, -4.72256877e-02f, 4.30358807e-03f, 2.71170512e-02f,
  -8.74665678e-02f, -7.90932029e-02f, 8.35183188e-02f, 1.06935101e-02f, 6.04342483e-02f, -5.64961769e-02f, -1.76371466e-02f, 4.45173085e-02f, 9.96361449e-02f, -2.88546178e-03f,
  -5.38706109e-02f, -9.19877738e-02f, -9.23840776e-02f, -1.10912710e-01f, 4.45003361e-02f, -5.25323749e-02f, -9.19956565e-02f, -6.76165596e-02f, -3.96568850e-02f, 1.99831240e-02f,
  7.98496604e-03f, -1.12941876e-01f, -4.08818126e-02f, -8.63406749e-04f, -2.11120639e-02f, -3.25906486e-03f, -8.44151189e-04f, -9.27723423e-02f, -2.52159853e-02f, 5.15995249e-02f,
  -1.26572043e-01f, -9.22639817e-02f, -1.68594923e-02f, -3.03469058e-02f, 4.31849509e-02f, 2.26360150e-02f, -6.70996308e-02f, 1.86624542e-01f, 6.27777800e-02f, 1.47634745e-01f,
  -3.38261165e-02f, 1.34607144e-02f, 1.63892522e-01f, 2.66603023e-01f, -7.02737868e-02f, -6.18884824e-02f, -1.95675343e-01f, -6.35754839e-02f, 1.88556001e-01f, -9.17340219e-02f,
  -1.81880721e-04f, -7.39207864e-02f, 1.82813421e-01f, -3.75264138e-02f, -3.64730693e-03f, 3.65902819e-02f, -6.20410331e-02f, 1.08555267e-02f, -4.33244780e-02f, -2.32275695e-01f,
  -9.00662914e-02f, -1.74010471e-01f, 1.03747323e-01f, 4.34692390e-02f, 2.45133508e-02f, -1.04421645e-01f, -4.34078127e-02f, 9.52670351e-02f, 1.82319924e-01f, -1.92244947e-02f,
  8.11329782e-02f, -2.78038508e-03f, 8.91377330e-02f, -3.18411030e-02f, -3.51365865e-03f, 5.40215755e-03f, 5.51298074e-02f, -4.95980904e-02f, -4.83521894e-02f, 1.06886737e-01f,
  -1.14468105e-01f, -7.47601688e-02f, 8.52298588e-02f, -7.29457885e-02f, -4.43793498e-02f, -4.70163636e-02f, -6.33322075e-02f, -1.09810598e-01f, 1.17359795e-02f, 1.52150840e-01f,
  -9.20982361e-02f, -1.52953401e-01f, -2.27259155e-02f, -1.14680827e-01f, 1.65119067e-01f, -1.95918232e-01f, -1.20760471e-01f, 1.08669810e-02f, 7.84400478e-02f, 5.29684164e-02f,
  8.33889842e-02f, -1.05153218e-01f, 1.11615602e-02f, -1.22688465e-01f, 1.62901103e-01f, -8.07722211e-02f, 3.65694240e-02f, 7.56176636e-02f, 6.90829102e-03f, 8.61563087e-02f,
  -1.74625739e-02f, -1.39228940e-01f, -2.21457914e-01f, 1.26438171e-01f, -2.83300355e-02f, 7.49749970e-03f, -8.76104683e-02f, -5.37443943e-02f, -1.54489158e-02f, 4.14674357e-02f,
  2.35684719e-02f, -1.10992126e-03f, 4.87836450e-02f, 6.74647987e-02f, 8.23577940e-02f, 1.16393261e-01f, -2.90724002e-02f, 7.04944208e-02f, 1.30286336e-01f, 1.10960945e-01f,
  -9.21642184e-02f, -2.24068779e-02f, -8.22877213e-02f, 3.75966318e-02f, -5.78563176e-02f, -8.19988623e-02f, -8.61550588e-03f, 1.41550926e-02f, -3.33612561e-02f, -8.80133063e-02f,
  -7.89469406e-02f, -2.82384991e-03f, -7.46480227e-02f, 3.18286829e-02f, 7.62370974e-02f, -1.06156534e-02f, -6.21178672e-02f, -8.68831128e-02f, 1.03222892e-01f, 1.36096075e-01f,
  7.95713887e-02f, 9.09926891e-02f, -2.86434242e-03f, -7.86465332e-02f, 1.10374270e-02f, -8.57946128e-02f, -6.45196885e-02f, 6.27478138e-02f, 4.44854721e-02f, -5.40365232e-03f,
  2.64432989e-02f, 7.05388710e-02f, -3.53969485e-02f, 5.25098369e-02f, -5.56603214e-03f, 1.68674067e-02f, 3.10147670e-03f, -3.13992016e-02f, 9.95566845e-02f, -8.28027725e-02f,
  -2.01621633e-02f, 2.06444770e-01f, -1.55655131e-01f, 1.40330389e-01f, 1.95374736e-03f, 7.18786148e-03f, 1.31336629e-01f, 4.99171056e-02f, 1.45331487e-01f, 1.19541809e-01f,
  3.32962116e-03f, -1.02928832e-01f, -1.35858029e-01f, 1.91766977e-01f, 1.67957193e-03f, 4.49774079e-02f, -1.65296476e-02f, -8.76747295e-02f, 7.94295669e-02f, -2.03786194e-01f,
  -1.39642894e-01f, 1.57865614e-01f, 1.81189254e-02f, -1.36547163e-01f, -1.41366154e-01f, 1.11709572e-01f, -5.03302142e-02f, -1.05861546e-02f, -3.59234884e-02f, -1.94863513e-01f,
  1.27744183e-01f, 1.93654280e-02f, -1.40623093e-01f, 7.17154294e-02f, 3.76481540e-03f, 1.61568925e-01f, 9.53841209e-03f, -1.20432295e-01f, -1.14620075e-01f, -1.25896975e-01f,
  1.00142106e-01f, 1.04497612e-01f, 2.93390304e-02f, 9.61668715e-02f, -2.02677131e-01f, -1.23138979e-01f, 1.55683786e-01f, 3.54569894e-03f, 5.83583042e-02f, -3.23910788e-02f,
  -1.87548906e-01f, -5.77807799e-02f, 1.38484880e-01f, -4.26518731e-02f, -1.40092567e-01f, -7.43868724e-02f, -1.13024302e-01f, 7.17277378e-02f, -5.49169071e-02f, 6.29131198e-02f,
  6.57331049e-02f, 1.17946360e-02f, 9.02518630e-02f, 1.15296401e-01f, -4.46419157e-02f, -1.95286870e-01f, -4.30929810e-02f, 1.44922405e-01f, -1.54904500e-01f, -1.38015643e-01f,
  1.28462106e-01f, 8.53957143e-03f, 3.52718271e-02f, -1.22800665e-02f, -1.42036811e-01f, -1.12023324e-01f, 5.68744447e-03f, -3.63723971e-02f, -5.72303645e-02f, -1.34061694e-01f,
  -1.31769627e-01f, 4.77532968e-02f, -6.49999455e-02f, -3.70705165e-02f, 6.86524138e-02f, 6.38497174e-02f, 8.20299983e-03f, -1.24345295e-01f, -7.25882426e-02f, -2.95267384e-02f,
  8.37423503e-02f, -4.20074463e-02f, -4.48544472e-02f, -1.13561630e-01f, -8.24007466e-02f, -8.85560215e-02f, -2.69648191e-02f, -9.37511176e-02f, 6.78778291e-02f, -1.23171229e-02f,
  -1.46516021e-02f, -8.16316530e-02f, 6.15678988e-02f, -1.27013132e-01f, 7.03042075e-02f, -1.36465235e-02f, 2.11281758e-02f, 1.27947390e-01f, -4.75326106e-02f, -9.00796950e-02f,
  -1.26136139e-01f, -1.57518815e-02f, 5.79890609e-02f, -3.54638137e-02f, -3.87474112e-02f, -4.18912433e-02f, -9.81763601e-02f, 1.09356334e-02f, 4.68404731e-03f, -1.73801929e-01f,
  -5.00255860e-02f, -2.75562480e-02f, 1.64472722e-02f, -1.33757964e-01f, -1.53040692e-01f, -4.74507324e-02f, 9.38263685e-02f, 9.28351209e-02f, 1.12512983e-01f, 2.41548438e-02f,
  -5.11950697e-04f, -1.27098858e-01f, -1.85910136e-01f, -2.37517193e-01f, 1.07072681e-01f, -7.82632641e-03f, 1.40020952e-01f, 6.18645251e-02f, 7.38380104e-02f, -1.50730059e-01f,
  -1.69779405e-01f, 2.41489843e-01f, 7.23114386e-02f, 1.25039965e-01f, -6.65988103e-02f, -1.19642548e-01f, 2.34114518e-03f, 1.57036175e-05f, -1.27519712e-01f, 5.60879223e-02f,
  -3.82156074e-02f, -3.99146229e-02f, 7.70968348e-02f, -4.45572697e-02f, 1.59935877e-01f, 1.14146873e-01f, -2.07117032e-02f, -2.16408223e-01f, -1.04453728e-01f, -1.15733325e-01f,
  -5.51569499e-02f, -1.78658724e-01f, 8.45988542e-02f, 1.04581036e-01f, -3.05511523e-02f, -9.30356160e-02f, -1.28089085e-01f, -3.84564213e-02f, -1.97681788e-06f, 8.66846815e-02f,
  -1.31491661e-01f, -1.75576273e-03f, -1.29731551e-01f, -1.76437050e-01f, -5.56459352e-02f, 1.36395335e-01f, -5.71084917e-02f, -3.65456045e-02f, 5.37763201e-02f, -1.73990443e-01f,
  1.20958380e-01f, -5.28139398e-02f, 2.98952311e-02f, 7.08916336e-02f, 4.26723203e-03f, 1.96181405e-02f, 7.60556608e-02f, 8.73037875e-02f, -1.72821462e-01f, 5.01516089e-02f,
  1.37655869e-01f, 4.79120798e-02f, -5.41049317e-02f, -1.08382620e-01f, 1.90287065e-02f, 3.17027748e-01f, 8.57308432e-02f, -1.00138120e-01f, -5.31178527e-02f, 1.43984303e-01f,
  -1.01822801e-01f, 7.66469166e-03f, -4.52950746e-02f, 5.18584996e-03f, 8.12263563e-02f, 1.04438335e-01f, 4.31288332e-02f, 1.03860512e-01f, 4.95630726e-02f, -7.17281969e-03f,
  6.63271621e-02f, 1.16491035e-01f, -1.82213041e-03f, -3.96604016e-02f, -3.43801081e-02f, 8.31436366e-02f, -9.50137451e-02f, -4.81394231e-02f, 8.07483215e-03f, -7.67393634e-02f,
  -2.16657072e-02f, 1.57605833e-03f, 1.60563756e-02f, -6.19138964e-03f, -8.19422752e-02f, 2.17962489e-02f, -1.69635527e-02f, -6.00613188e-04f, -6.46993369e-02f, -2.41975915e-02f,
  6.85671791e-02f, -4.20046085e-03f, -6.21146113e-02f, 3.27755697e-03f, 4.03873622e-02f, 7.27575347e-02f, 3.64255346e-02f, 7.72591738e-04f, 1.25171356e-02f, 6.81126192e-02f,
  6.18845187e-02f, 2.08129231e-02f, -3.93938497e-02f, -1.13731818e-02f, -3.50631177e-02f, -4.62981574e-02f, 5.66830896e-02f, -7.61378780e-02f, -7.70346522e-02f, -4.17981297e-02f,
  5.71802743e-02f, 1.88553836e-02f, -7.45640248e-02f, -9.15067643e-02f, -1.19604982e-01f, 8.28870982e-02f, -1.49300858e-01f, 4.15957011e-02f, 1.97132245e-01f, 1.38773903e-01f,
  -6.80118874e-02f, 2.72826618e-03f, 2.65825354e-02f, 1.22101925e-01f, -3.59701440e-02f, 1.20875284e-01f, -1.52225271e-01f, -5.25263809e-02f, 2.56434996e-02f, -2.30728816e-02f,
  8.32971483e-02f, 1.40527427e-01f, 1.57170191e-01f, 1.71576753e-01f, -1.91708934e-02f, -1.30336940e-01f, -1.44748855e-02f, -1.02692461e-02f, 1.24817133e-01f, -1.41466007e-01f,
  2.28114687e-02f, 7.62764737e-02f, -1.01803780e-01f, 1.96070060e-01f, 3.94528173e-02f, 5.44400439e-02f, 2.16607675e-02f, -1.61533594e-01f, -5.05999587e-02f, 1.30252048e-01f,
  -7.23547935e-02f, 2.50676256e-02f, 1.42452210e-01f, -4.40929160e-02f, 1.54076349e-02f, -6.09842613e-02f, 1.10571161e-01f, 7.51138106e-03f, 1.01259258e-02f, 3.54023799e-02f,
  -1.18332013e-01f, -7.00752586e-02f, 5.69793470e-02f, 2.70687249e-02f, 2.87841409e-02f, 1.64379738e-02f, -3.54368575e-02f, -8.06210637e-02f, -5.13921082e-02f, 1.62893102e-01f,
  -6.82078227e-02f, 6.77098930e-02f, -2.30508111e-02f, -2.42112093e-02f, 1.28679037e-01f, 9.18005109e-02f, -3.17381769e-02f, 6.97954372e-02f, 2.68372875e-02f, 8.14089738e-03f,
  -1.66761205e-01f, -1.38993546e-01f, 1.31797448e-01f, 1.19881429e-01f, -1.19725622e-01f, -5.49915172e-02f, 1.20024756e-01f, 1.35494813e-01f, 1.93890631e-02f, -5.62971830e-02f,
  8.01813379e-02f, 4.54371870e-02f, 3.52408923e-02f, 8.68604332e-02f, 1.15367539e-01f, 3.20858732e-02f, 7.91277178e-03f, 8.19998235e-02f, 2.03619823e-02f, 6.24323748e-02f,
  -3.13635543e-02f, 2.24626493e-02f, -1.17074037e-02f, 1.17407084e-01f, -1.06301732e-01f, 1.57697815e-02f, 7.80004263e-02f, -8.18288401e-02f, -9.60888043e-02f, -4.72256169e-02f,
  -6.31707907e-02f, -3.01179592e-03f, -8.32065493e-02f, 3.18868198e-02f, 1.12234741e-01f, -3.05948257e-02f, 7.20025832e-03f, 3.57940979e-02f, 9.57723632e-02f, 6.01105951e-02f,
  -8.16756263e-02f, 5.83943427e-02f, 3.73600796e-02f, -1.56693142e-02f, 4.15227264e-02f, 1.11385368e-01f, 6.28219638e-03f, 8.47383365e-02f, 6.41314760e-02f, 2.58576055e-03f,
  -2.25462373e-02f, -9.54544246e-02f, 1.55885527e-02f, -7.75609761e-02f, 2.32333504e-02f, -1.75917184e-03f, -1.05923321e-02f, -3.01346518e-02f, 4.06964682e-02f, 7.18830749e-02f,
  1.07789196e-01f, -2.84233224e-02f, -2.33972147e-01f, 1.29609615e-01f, -1.73172072e-01f, -1.12393618e-01f, 3.04145142e-02f, 1.66298822e-01f, -1.31846862e-02f, 2.25195754e-02f,
  1.66383654e-01f, 1.61440060e-01f, -8.53551030e-02f, 5.11962697e-02f, -8.12917873e-02f, 6.01691864e-02f, 1.30455929e-03f, 8.64315182e-02f, 7.79127404e-02f, -5.00583611e-02f,
  1.24200732e-01f, 1.30557418e-01f, -1.17764480e-01f, -1.17388517e-01f, -1.05536112e-03f, -9.70495939e-02f, 1.24248929e-01f, -1.12872377e-01f, 1.18779376e-01f, -1.70002449e-02f,
  -9.39913914e-02f, 1.07992493e-01f, 7.61075020e-02f, -9.21615493e-03f, 5.99598847e-02f, -1.39638081e-01f, 2.78936140e-02f, 1.82960987e-01f, -1.93125829e-02f, -9.26790088e-02f,
  1.66399568e-01f, -1.06969178e-01f, 7.40015507e-02f, -7.15963691e-02f, 6.82516694e-02f, -4.78542224e-02f, 1.27164483e-01f, 1.97321251e-02f, -8.62672329e-02f, 2.64367387e-02f,
  -7.13037923e-02f, -1.71620902e-02f, 9.29137021e-02f, 4.52572964e-02f, 1.28860469e-03f, 2.34381519e-02f, -1.26940370e-01f, 1.05346799e-01f, -1.43503696e-01f, 1.11450113e-01f,
  -1.33905029e-02f, -4.23078388e-02f, 1.45963103e-01f, 1.15843900e-01f, 1.18099660e-01f, -2.84196921e-02f, 7.71928206e-02f, -8.56899321e-02f, -4.35227193e-02f, -1.21398522e-02f,
  1.45858243e-01f, 4.19103056e-02f, -2.19457656e-01f, -1.17446773e-01f, 1.84300438e-01f, 1.35326877e-01f, 1.88528020e-02f, -6.01395145e-02f, 1.29960254e-01f, 3.15819457e-02f,
  7.95457140e-02f, 7.64904320e-02f, 1.37275800e-01f, 7.25079030e-02f, 5.38125355e-03f, 3.79689001e-02f, 8.79026726e-02f, -8.83598104e-02f, 8.81842673e-02f, 3.73892523e-02f,
  2.24428363e-02f, 5.60532659e-02f, -3.21682133e-02f, 1.03676394e-01f, 4.38357741e-02f, 7.67881200e-02f, 4.33959179e-02f, 8.96123722e-02f, 1.28702438e-02f, 2.32820604e-02f,
  2.30896473e-02f, 2.89726220e-02f, 9.16394740e-02f, 1.08596660e-01f, 7.68456534e-02f, 6.18764162e-02f, -3.43527608e-02f, -6.77837357e-02f, 2.81617176e-02f, 2.54042167e-02f,
  -4.27284278e-02f, -1.37521073e-01f, 5.66220693e-02f, 1.87067706e-02f, -4.37234808e-03f, 1.00725673e-01f, 8.91777575e-02f, 5.34301773e-02f, 3.33099253e-03f, 4.54857610e-02f,
  1.10601038e-01f, -6.40015826e-02f, -1.34330466e-02f, 1.39124515e-02f, -2.25332119e-02f, 1.22665808e-01f, -1.03126401e-02f, 2.48315670e-02f, 1.11436456e-01f, 1.79536626e-01f,
  -4.38232757e-02f, 7.24620745e-03f, 1.23964913e-01f, 1.82486046e-02f, -3.10934652e-02f, -1.34340793e-01f, -1.09287418e-01f, 9.15690139e-02f, 7.15052709e-02f, -8.64665732e-02f,
  -1.17756203e-01f, -1.71984240e-01f, 1.06939159e-01f, 8.13897103e-02f, 6.22074530e-02f, 3.16685508e-03f, -7.24616274e-02f, -7.66793489e-02f, 1.05368374e-02f, -1.24090917e-01f,
  2.86112446e-03f, 4.72318828e-02f, 1.28594115e-01f, 5.79344295e-02f, -1.45886987e-01f, 9.50457379e-02f, 3.42916511e-02f, -6.19570985e-02f, 1.14346430e-01f, -1.49362579e-01f,
  1.40616581e-01f, 1.96712404e-01f, -2.13598963e-02f, 2.43182722e-02f, -3.32410261e-02f, 5.67812547e-02f, 4.62082447e-03f, -1.29657332e-02f, -1.20595641e-01f, 1.53209537e-01f,
  -2.10841950e-02f, -8.74935687e-02f, -1.00749582e-01f, -1.63637727e-01f, 4.95265760e-02f, -2.12158799e-01f, 1.62401602e-01f, 1.45454854e-01f, -6.48480877e-02f, 7.39010191e-03f,
  4.31588013e-03f, 3.80524956e-02f, 1.06705271e-01f, 1.76467061e-01f, 9.34641957e-02f, 1.74271385e-03f, -1.66963756e-01f, -9.65650454e-02f, -3.07190698e-02f, -1.05309807e-01f,
  1.63981486e-02f, -9.38598961e-02f, 1.73719674e-01f, -1.17541775e-01f, -6.50774222e-03f, -9.54807624e-02f, 9.38232914e-02f, 1.81936532e-01f, 7.33512938e-02f, -1.66264787e-01f,
  -4.40111272e-02f, 8.35044384e-02f, -1.24419428e-01f, -3.64237316e-02f, -1.10984698e-01f, 9.13112015e-02f, 6.38492331e-02f, 8.21158662e-02f, 5.79624549e-02f, 9.90034044e-02f,
  -5.55851869e-02f, 3.49288359e-02f, 1.34482728e-02f, 6.33868724e-02f, 1.07978292e-01f, -8.08108076e-02f, 2.89597325e-02f, -5.83535060e-02f, -2.49935538e-02f, 1.31808311e-01f,
  5.18667102e-02f, -5.52849993e-02f, -6.95804283e-02f, 8.02898332e-02f, 4.64733653e-02f, -5.18874414e-02f, -1.94830466e-02f, -1.13121040e-01f, -5.53164668e-02f, -5.17195761e-02f,
  -7.72470534e-02f, 3.02078594e-02f, 5.29059805e-02f, -4.72432934e-02f, -1.03278026e-01f, 2.34823879e-02f, -1.09180892e-02f, 5.58638014e-02f, -2.49796566e-02f, -7.93706700e-02f,
  2.51386017e-02f, -2.11297013e-02f, 4.22053784e-03f, 6.70160055e-02f, -1.42111350e-02f, 9.80502460e-03f, 4.59216610e-02f, -1.25833213e-01f, -6.04284666e-02f, -7.02666566e-02f,
  -5.54415993e-02f, -2.29549240e-02f, 2.38198470e-02f, -1.12392809e-02f, -4.11223248e-02f, -1.44600645e-01f, 5.70803769e-02f, -8.55478924e-03f, 7.65541270e-02f, 3.20945606e-02f,
  -7.17462376e-02f, -6.47372603e-02f, 1.31224930e-01f, 1.32269293e-01f, 1.54149055e-01f, 1.11429095e-02f, -5.74279465e-02f, -1.41132670e-02f, 5.24852723e-02f, -4.85001467e-02f,
  -2.15232167e-02f, 9.82687995e-02f, -2.02692766e-02f, -2.75651962e-01f, 5.24554849e-02f, 4.80946712e-02f, -7.89747909e-02f, 1.78472802e-01f, 1.38066843e-01f, 1.44274488e-01f,
  1.96010202e-01f, -4.71882075e-02f, -1.47154881e-03f, -6.06065691e-02f, 1.56939387e-01f, 3.69328484e-02f, -2.33959332e-01f, -6.10774495e-02f, 2.52102353e-02f, 2.71855056e-01f,
  1.55405313e-01f, 1.47835135e-01f, 5.38892597e-02f, -6.28184378e-02f, 1.10618956e-01f, -2.44202055e-02f, 1.41602159e-01f, 1.94212332e-01f, 1.77714676e-01f, 1.05544016e-01f,
  -3.63641120e-02f, 8.78766365e-03f, 2.29706898e-01f, -1.31011397e-01f, 8.53937268e-02f, 1.19759016e-01f, 5.54022752e-02f, -4.74819802e-02f, 6.33119866e-02f, -4.85584252e-02f,
  -3.65847386e-02f, 1.16308562e-01f, -1.44152164e-01f, -1.39184892e-01f, -5.00635691e-02f, -1.59033597e-01f, 2.24078014e-01f, 1.07930899e-01f, -3.69341858e-02f, -4.52966020e-02f,
  9.32926536e-02f, -4.97724563e-02f, -1.67577833e-01f, -8.03874284e-02f, 1.10900693e-01f, 1.61258861e-01f, -3.32643054e-02f, -1.21309213e-01f, 1.09581538e-01f, 2.19675917e-02f,
  -4.53321636e-02f, 3.85175133e-03f, 4.69124690e-03f, -6.59958348e-02f, -9.56503004e-02f, -6.74251765e-02f, -8.34077597e-02f, -6.62143752e-02f, -4.62229624e-02f, -4.34100218e-02f,
  -8.48169848e-02f, -2.70998534e-02f, -3.91827524e-02f, 6.42522499e-02f, -1.65912464e-01f, -1.04211241e-01f, 9.86301247e-03f, -5.40040657e-02f, -4.16540017e-04f, 1.23175390e-01f,
  -2.94740777e-02f, -1.77892283e-01f, 5.81926852e-02f, 7.63112353e-03f, -7.49562308e-02f, 3.64006720e-02f, -1.63640697e-02f, -5.73933385e-02f, 4.93702777e-02f, -4.16226387e-02f,
  -2.36506127e-02f, -9.90416855e-02f, 1.14401402e-02f, 6.71115369e-02f, -5.20602195e-03f, 7.54397537e-04f, 1.10744312e-01f, -1.77288074e-02f, 5.92787191e-02f, -3.55870053e-02f,
  -8.57915431e-02f, 7.69378990e-02f, 7.67532885e-02f, -2.11837087e-02f, 4.21031080e-02f, 5.81335872e-02f, 6.41997904e-02f, 3.68390977e-02f, -3.04566231e-02f, 8.42698663e-02f,
  -6.51492551e-02f, -1.95424631e-03f, -1.20971039e-01f, -1.07485540e-02f, 9.53322202e-02f, 9.56333056e-02f, 1.28969982e-01f, -2.72907820e-02f, 1.08149670e-01f, 3.25211026e-02f,
  -3.51433530e-02f, -1.01960726e-01f, 5.84787456e-03f, -4.16257307e-02f, -8.24240893e-02f, -7.99886212e-02f, -3.81194167e-02f, -1.49834692e-01f, 2.56325472e-02f, -4.81592081e-02f,
  4.04064208e-02f, -1.67039633e-01f, -1.21435337e-01f, 1.45827085e-01f, 9.13290158e-02f, -1.33913793e-02f, -1.35099277e-01f, 3.95255089e-02f, 2.19885647e-01f, 7.30860010e-02f,
  -1.37265429e-01f, 8.64125267e-02f, 5.01549542e-02f, -1.35928288e-01f, 1.65912122e-01f, -1.13572121e-01f, -1.99140385e-01f, -1.21981176e-02f, -7.98823461e-02f, 6.68520480e-02f,
  -1.64224744e-01f, -1.03672324e-02f, 8.32439065e-02f, -1.24183059e-01f, 4.60885875e-02f, 8.52032229e-02f, -9.94580910e-02f, 6.40792921e-02f, -1.71664327e-01f, -8.34607035e-02f,
  7.57316053e-02f, -1.48002937e-01f, -3.10047809e-02f, 1.36387020e-01f, -8.53737146e-02f, 9.00402665e-02f, 1.74881313e-02f, -4.59087305e-02f, 2.75288569e-03f, -1.57614276e-01f,
  -1.11757115e-01f, -4.83506881e-02f, -8.39660466e-02f, -8.30244049e-02f, -6.04943037e-02f, -9.81522053e-02f, -9.02202800e-02f, -4.54500392e-02f, 9.80848260e-03f, 2.05909088e-02f,
  4.80616279e-02f, 9.47033893e-03f, 1.72835886e-01f, -1.01203158e-01f, -8.24645087e-02f, 8.22427198e-02f, 7.65838251e-02f, 5.38324788e-02f, -1.09303318e-01f, 5.82241714e-02f,
  1.94574848e-01f, -3.28103974e-02f, -1.02234505e-01f, 4.82355803e-02f, 8.98069814e-02f, -1.21766344e-01f, 1.15751224e-02f, -6.64582103e-02f, 2.99744327e-02f, -7.16320574e-02f,
  -1.33473903e-01f, 2.30005570e-02f, -6.86775818e-02f, -3.10745835e-02f, -2.85651907e-02f, -1.46898497e-02f, 3.53000499e-02f, 1.73857082e-02f, 3.84587608e-02f, 7.29815736e-02f,
  3.35888378e-02f, -2.46530529e-02f, 3.54297273e-02f, 1.13949709e-01f, -2.53168289e-02f, 5.29812067e-04f, -1.63378764e-03f, 5.52050620e-02f, -1.00301087e-01f, 7.55403563e-02f,
  -7.68670067e-02f, -2.85358680e-03f, -3.49185728e-02f, 1.93664823e-02f, -7.57043213e-02f, -1.52212419e-02f, -7.77892862e-03f, 9.47816446e-02f, 8.57900903e-02f, -2.30759345e-02f,
  -1.44055393e-02f, 5.22824638e-02f, -4.15875241e-02f, 6.73889145e-02f, -2.26403456e-02f, 6.41201064e-02f, -2.26233136e-02f, -1.94871500e-02f, 8.28183964e-02f, 9.42829344e-03f,
  -1.02180190e-01f, 7.36767277e-02f, 4.90496010e-02f, 9.30366367e-02f, 2.58746464e-02f, -1.56423509e-01f, 1.19479351e-01f, 4.00712006e-02f, -3.13118771e-02f, -1.91649124e-01f,
  -4.20175754e-02f, -1.26652479e-01f, 1.14734881e-01f, -1.21963665e-01f, -9.05578956e-02f, -1.85150012e-01f, 1.51936516e-01f, 4.48362194e-02f, -1.47066079e-02f, 1.23646550e-01f,
  -1.36657044e-01f, -2.27786079e-01f, -2.64727902e-02f, -2.23137408e-01f, -3.37452032e-02f, -8.04677904e-02f, -7.98283219e-02f, 4.54627648e-02f, -8.47337097e-02f, 6.89340085e-02f,
  -7.30927363e-02f, -5.31250536e-02f, 2.04914346e-01f, -4.96594869e-02f, 1.27299875e-01f, -6.13067187e-02f, -1.35901943e-01f, 3.48098986e-02f, 4.81952913e-02f, -3.57759595e-02f,
  -7.99404532e-02f, -1.55672595e-01f, -1.65456221e-01f, -1.15390327e-02f, -1.49977133e-01f, -1.23635093e-02f, 5.12743071e-02f, -1.24576740e-01f, -2.21116275e-01f, 3.68015133e-02f,
  6.11737482e-02f, 2.28341371e-02f, -8.32544938e-02f, 1.25306249e-01f, -1.25981029e-02f, 1.05110697e-01f, 1.02467000e-01f, -1.48189319e-02f, 6.56638071e-02f, -7.10684806e-03f,
  1.07988276e-01f, 1.54005364e-01f, 2.44696945e-04f, -1.10828087e-01f, -7.51037821e-02f, -2.05979228e-01f, -1.92912593e-02f, -1.74186975e-02f, 1.51692525e-01f, -3.47319804e-02f,
  1.04557589e-01f, 2.74629761e-02f, 3.21178846e-02f, -1.98085919e-01f, -9.52802077e-02f, 1.50861338e-01f, -1.78031728e-01f, -1.18037619e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  -4.46541272e-02f, -1.75847008e-03f, 9.45310891e-02f, 5.56252450e-02f, 1.49778560e-01f, 1.77642301e-01f, 6.07648641e-02f, 2.56434739e-01f, 1.14409380e-01f, 1.37544245e-01f,
  1.25590697e-01f, -1.97711382e-02f, 2.45172352e-01f, 1.24037877e-01f, 9.82387140e-02f, 1.51501149e-01f, 1.12744264e-01f, 2.37541035e-01f, -2.88679730e-02f, 8.93962756e-02f,
  -5.47342375e-02f, 9.19858664e-02f, 1.68476924e-01f, 1.67225063e-01f, 7.90315568e-02f, 2.23354608e-01f, 1.89099744e-01f, 8.20283964e-02f, 1.81026906e-01f, 9.29756016e-02f,
  4.72644307e-02f, 9.95698050e-02f, 1.64768800e-01f, 1.28978983e-01f, 2.88167992e-03f, -5.98162971e-02f, -6.17539696e-02f, 5.88446669e-02f, 6.96732029e-02f, 1.16393469e-01f,
  6.86548650e-02f, 1.41687602e-01f, 1.64812580e-02f, -5.17562851e-02f, 1.79879531e-01f, 1.63097844e-01f, 6.46613762e-02f, 7.45354965e-02f, 4.49206531e-02f, 1.54705778e-01f,
  7.99820293e-03f, 2.13233963e-01f, 1.47066265e-01f, 1.00811817e-01f, -1.90747887e-01f, 3.40166055e-02f, -2.39871904e-01f, -2.53820956e-01f, -1.76535860e-01f, 1.53797567e-01f,
  2.68675406e-02f, 3.58421594e-01f, -5.61153479e-02f, 2.10907191e-01f, -1.13231502e-01f, 1.05372190e-01f, 5.79715590e-04f, 5.51161133e-02f, 2.21408695e-01f, 3.42926346e-02f,
  -1.31522238e-01f, -1.61840200e-01f, 8.19321573e-02f, 2.16667652e-01f, -2.89493408e-02f, 1.87422156e-01f, 1.52406424e-01f, -3.23920965e-01f, -9.83770862e-02f, 4.08494053e-03f,
  5.13631217e-02f, -9.77895036e-02f, 7.51929283e-02f, -8.16361755e-02f, -4.20525074e-02f, 2.62338877e-01f, -1.56706929e-01f, -8.89775828e-02f, 2.09351778e-01f, 2.17442378e-01f,
  1.19629176e-02f, -1.98169068e-01f, 1.69515967e-01f, -9.10363942e-02f, -2.50780080e-02f, 1.03373043e-01f, -1.42456844e-01f, -4.24664728e-02f, 1.18682332e-01f, -3.77342664e-02f,
  -4.06174697e-02f, 2.46512383e-01f, 1.33024156e-01f, 8.22606906e-02f, 1.64710730e-01f, 2.49293581e-01f, -2.03455180e-01f, 4.26394232e-02f, -8.51296261e-02f, 3.80315959e-01f,
  -2.58848846e-01f, 2.34754547e-01f, -1.01251692e-01f, -1.80668190e-01f, -1.27521411e-01f, -1.86806172e-02f, 1.32162139e-01f, 1.85799226e-01f, -3.06841023e-02f, 2.01459095e-01f,
  4.13891656e-04f, 2.50468314e-01f, 1.16013795e-01f, -4.00870591e-01f, -5.55444919e-02f, 1.89559236e-02f, 6.19377829e-02f, -1.84091389e-01f, 1.27107039e-01f, 5.42035289e-02f,
  1.67961329e-01f, 1.33712649e-01f, -2.35420447e-02f, -5.27799241e-02f, 1.04490653e-01f, 4.69885021e-02f, 6.03128485e-02f, 1.40265509e-01f, -5.53466603e-02f, 5.85868247e-02f,
  -2.87023503e-02f, 4.12452407e-02f, 8.40855166e-02f, 4.50328551e-02f, 7.88438618e-02f, -2.95475833e-02f, 1.25572309e-01f, 2.14095131e-01f, 1.42317399e-01f, 1.22644447e-01f,
  9.00747404e-02f, -5.21629602e-02f, 3.11619956e-02f, 8.48201886e-02f, 8.29354003e-02f, 9.81739461e-02f, 1.26499757e-01f, 1.28475428e-01f, 1.86708748e-01f, 1.73411984e-02f,
  -1.01940539e-02f, 1.34069577e-01f, 4.74224277e-02f, 1.08798675e-01f, 3.95842195e-02f, 5.00271805e-02f, -1.16303349e-02f, 7.66111240e-02f, 1.60939172e-02f, -6.89594597e-02f,
  7.71811083e-02f, 7.43865371e-02f, 2.62349118e-02f, 1.75501496e-01f, 5.01286052e-02f, 1.45883247e-01f, -2.44320892e-02f, -8.28936417e-03f, 6.98395222e-02f, -2.38608569e-02f,
  -1.52231008e-01f, 3.02636951e-01f, 8.54551122e-02f, -2.26778463e-01f, 1.30074501e-01f, -1.75188944e-01f, 3.77162546e-02f, -8.17380175e-02f, 1.47376478e-01f, 2.35531077e-01f,
  1.41188115e-01f, -1.31141052e-01f, 9.35423896e-02f, -1.09416611e-01f, 1.32047608e-01f, 8.91134068e-02f, -1.39012948e-01f, 4.11497243e-02f, -4.00078297e-02f, -2.90001571e-01f,
  -2.42928937e-01f, -1.38503253e-01f, 1.97711475e-02f, 1.29188085e-02f, -1.33990154e-01f, 1.76780954e-01f, -5.06437644e-02f, 1.52367339e-01f, -9.85077471e-02f, 1.81283966e-01f,
  -3.22451964e-02f, 3.57603058e-02f, 6.48455918e-02f, -1.54466361e-01f, 2.88029909e-02f, -1.73253283e-01f, 1.07985839e-01f, -1.71540394e-01f, -1.75017461e-01f, 2.57050335e-01f,
  -1.27951324e-01f, -1.11414514e-01f, 1.47947362e-02f, -1.79677308e-01f, 2.05844849e-01f, -3.24142985e-02f, -9.98973027e-02f, 2.11244613e-01f, 2.32892886e-01f, -9.01468620e-02f,
  1.46428764e-01f, -1.55485705e-01f, -3.20023187e-02f, -8.84278417e-02f, 1.86103791e-01f, 1.87571779e-01f, 1.15840666e-01f, 9.20038670e-02f, 2.17620820e-01f, 1.47116452e-01f,
  1.88417673e-01f, 5.97938858e-02f, -1.42847866e-01f, 1.90765157e-01f, 1.28175020e-02f, 9.60418433e-02f, -1.89552352e-01f, 9.30299088e-02f, -6.16004132e-02f, 7.24026039e-02f,
  -3.85544449e-02f, -2.24372819e-01f, 2.88157221e-02f, 3.78565669e-01f, 1.92682952e-01f, 1.57268178e-02f, -8.96999985e-03f, 1.41371638e-02f, 1.99244648e-01f, 9.97361094e-02f,
  2.67457720e-02f, 1.04616754e-01f, 7.29590282e-02f, 7.67439902e-02f, 1.38931587e-01f, 7.58117661e-02f, -1.67158581e-02f, -1.77931730e-02f, 1.13724336e-01f, -1.47357490e-02f,
  9.86867025e-03f, 1.36851355e-01f, -8.24421868e-02f, 1.13911279e-01f, 5.84007539e-02f, 1.41208500e-01f, 9.69520956e-02f, 4.70183268e-02f, 1.65028334e-01f, -4.86499369e-02f,
  4.73741293e-02f, 2.55652089e-02f, 2.08426844e-02f, 1.40298918e-01f, 1.69021022e-02f, 1.15498722e-01f, 1.18181005e-01f, 4.73518409e-02f, 1.11207746e-01f, -4.65218473e-04f,
  -6.12260811e-02f, 4.05651592e-02f, -1.31832268e-02f, 4.56517525e-02f, -2.91315056e-02f, 1.11744097e-02f, -2.47431044e-02f, -5.35575524e-02f, -6.77498579e-02f, -7.99390599e-02f,
  5.70824258e-02f, 1.23175897e-01f, 9.66413617e-02f, 2.25633401e-02f, -2.32868008e-02f, 1.81646515e-02f, 1.11270584e-01f, 1.47820711e-01f, -6.12467192e-02f, 2.24360734e-01f,
  -2.93985456e-01f, 3.38341761e-03f, -1.94486097e-01f, -2.53337979e-01f, -3.23560871e-02f, 2.05669016e-01f, 2.69017965e-01f, 2.46452183e-01f, 1.16163507e-01f, -1.74883474e-02f,
  -1.08590558e-01f, 1.08544175e-02f, 3.37452488e-03f, 2.30695680e-01f, 1.65125266e-01f, 8.41647908e-02f, -1.67139649e-01f, -2.14095801e-01f, -5.42170517e-02f, 1.13175012e-01f,
  -1.60739809e-01f, -1.85764343e-01f, -3.31234634e-02f, -1.71203107e-01f, 6.96157292e-02f, -5.70463389e-02f, -1.45321786e-01f, 4.08511832e-02f, -1.12239011e-01f, 2.41058171e-01f,
  2.35690594e-01f, -1.56151038e-02f, 5.99874109e-02f, -1.99179962e-01f, 1.91504478e-01f, -4.52210158e-02f, -3.01833630e-01f, -5.33715263e-02f, 1.29614249e-01f, -1.80798158e-01f,
  3.17070894e-02f, -9.05229598e-02f, 1.56912073e-01f, -3.62321325e-02f, -2.54938066e-01f, 1.65909797e-01f, -5.46717271e-03f, 1.89920124e-02f, 2.04951778e-01f, -6.27975166e-02f,
  -8.08136631e-03f, 1.73097059e-01f, 3.63172054e-01f, 1.38877869e-01f, -4.33048047e-02f, 2.04363242e-01f, 3.23173642e-01f, 3.75454724e-01f, 2.13636667e-01f, -7.94375762e-02f,
  -6.43808320e-02f, 1.58298880e-01f, 2.30563670e-01f, 1.37886330e-01f, -3.38903046e-03f, 1.53686926e-01f, -1.07205875e-01f, -1.02963619e-01f, 1.09209038e-01f, -3.14374298e-01f,
  -2.66831070e-01f, 9.54785049e-02f, 1.36894479e-01f, 3.09660938e-03f, 2.72053659e-01f, 8.92420411e-02f, -5.72950765e-02f, 8.53635222e-02f, 1.20772596e-03f, 1.22601561e-01f,
  -9.31274667e-02f, 1.58123791e-01f, 8.42199102e-02f, 5.51153310e-02f, 5.94610050e-02f, 9.93349925e-02f, -8.73396397e-02f, 7.21239746e-02f, -6.04310147e-02f, 8.31228122e-02f,
  1.99677035e-01f, -4.00775939e-01f, 3.89833166e-03f, 2.71282762e-01f, 7.69153312e-02f, -8.54902044e-02f, 1.11504428e-01f, -3.09170298e-02f, 4.00062054e-02f, -4.73536588e-02f,
  -4.13651645e-01f, 2.15715155e-01f, -1.47671932e-02f, -1.80824533e-01f, 1.75742712e-02f, 1.84959278e-01f, -3.03097423e-02f, 8.64493549e-02f, 1.26978531e-01f, 1.30145207e-01f,
  2.47199684e-01f, 2.05172747e-01f, 5.28076589e-02f, -2.06980258e-02f, 9.57590863e-02f, -7.26844296e-02f, 7.03697428e-02f, 5.85797913e-02f, -1.99163333e-01f, -5.25712892e-02f,
  -7.10506588e-02f, 1.25613570e-01f, 2.92493682e-02f, -1.29565313e-01f, -1.55757546e-01f, -1.05490431e-01f, -2.50881370e-02f, -1.26347542e-01f, -5.11102937e-02f, -1.88587591e-01f,
  -1.48119945e-02f, 3.89563769e-01f, -1.65114611e-01f, -3.11334133e-01f, -3.51869054e-02f, -5.13921231e-02f, 9.20470580e-02f, -1.90928340e-01f, 3.05371806e-02f, 1.61131006e-03f,
  -4.17952240e-02f, 9.18682963e-02f, -2.44037941e-01f, 2.75356710e-01f, -1.92858011e-01f, 1.60838693e-01f, -1.21471338e-01f, -2.02925801e-01f, 1.17887296e-01f, -3.45002830e-01f,
  2.89756954e-02f, 3.21179479e-01f, 6.87605664e-02f, -3.29405069e-01f, -4.04936701e-01f, 3.81453037e-01f, -6.85722306e-02f, 8.53793398e-02f, 1.12199381e-01f, -1.57819074e-02f,
  2.87798882e-01f, 1.90362528e-01f, -1.95647135e-01f, 1.42567948e-01f, 2.43609130e-01f, -5.48871681e-02f, -5.15368432e-02f, 2.23876297e-01f, -9.90406945e-02f, -1.85378179e-01f,
  4.58594143e-01f, 8.42697695e-02f, -3.21952879e-01f, 7.99204316e-03f, -2.22737387e-01f, -2.70813853e-01f, 7.45807365e-02f, 2.05297425e-01f, -1.04302272e-01f, -7.38478303e-02f,
  -1.08273476e-01f, 7.40506649e-02f, 3.25298220e-01f, -1.72305569e-01f, 2.09108487e-01f, 2.77525298e-02f, 2.99778223e-01f, 3.69622529e-01f, 1.92611068e-01f, 2.47785717e-01f,
  2.46533845e-02f, -1.89053252e-01f, 3.27897519e-01f, -2.58834977e-02f, 2.00177819e-01f, -1.58247918e-01f, 1.62267894e-01f, 2.36347556e-01f, -2.04969138e-01f, 3.05910017e-02f,
  -8.95365030e-02f, 8.99993349e-03f, 1.22831784e-01f, 1.60755649e-01f, 7.67624825e-02f, 2.18553469e-02f, 5.51118366e-02f, -8.07867870e-02f, 1.55787408e-01f, 1.40101105e-01f,
  -2.33986210e-02f, 4.72857393e-02f, 2.17214087e-03f, 6.94854334e-02f, 1.36788245e-02f, 1.08322218e-01f, 2.54038274e-01f, 1.28939837e-01f, 3.03836614e-02f, 8.82464126e-02f,
  4.24645282e-02f, -2.63230801e-02f, 1.47282973e-01f, 5.22198416e-02f, -1.33951828e-02f, 1.49217591e-01f, 2.08119124e-01f, 5.61210848e-02f, 2.52438515e-01f, -4.63464223e-02f,
  1.22922249e-01f, 1.12236649e-01f, 9.63378698e-02f, 5.96704371e-02f, 2.62528099e-02f, 1.26128405e-01f, 1.29644737e-01f, 2.16921359e-01f, 7.82342181e-02f, 9.51491073e-02f,
  8.67948532e-02f, 8.06111321e-02f, 9.51054096e-02f, 8.97734091e-02f, 1.34247571e-01f, 3.14294100e-02f, 4.69889715e-02f, 1.12496115e-01f, 1.96276270e-02f, 4.45184018e-03f,
  1.23561911e-01f, 4.11678590e-02f, 2.22950682e-01f, -9.29440930e-02f, -2.67285645e-01f, 4.26725633e-02f, 1.90561682e-01f, -7.88197517e-02f, 2.10553601e-01f, 1.31420135e-01f,
  2.31044784e-01f, -6.53837994e-02f, 1.42420888e-01f, -6.98111504e-02f, 1.50209427e-01f, 6.12563454e-02f, 2.19067171e-01f, -1.87130086e-02f, 1.07159719e-01f, -2.71615177e-01f,
  -3.02654564e-01f, -7.96923041e-03f, 2.61716753e-01f, 3.41437161e-02f, 7.97150731e-02f, 1.33583590e-01f, 1.46751795e-02f, 1.03393659e-01f, -2.28802919e-01f, 2.43071243e-01f,
  8.86463746e-02f, 9.34467167e-02f, 7.73165897e-02f, 6.77735731e-02f, 7.61830881e-02f, -7.55013674e-02f, -1.38972383e-02f, -1.40681729e-01f, 5.69279492e-02f, -1.49867386e-01f,
  -2.03349367e-01f, -4.54687923e-02f, -1.32298367e-02f, 2.91295111e-01f, -2.09073931e-01f, -1.27728850e-01f, 2.80473121e-02f, -1.33952066e-01f, -7.05444440e-02f, -3.73274013e-02f,
  2.34961450e-01f, -2.60919690e-01f, 1.19762555e-01f, -8.43905285e-02f, 1.00452967e-01f, -1.96423605e-02f, -1.63111761e-01f, -6.08235374e-02f, -1.92041527e-02f, 1.83733046e-01f,
  5.31772338e-02f, -1.83798209e-01f, 5.67400418e-02f, -1.75560892e-01f, -3.42445374e-02f, 3.46815795e-01f, 8.66675451e-02f, 3.08859557e-01f, -1.54746518e-01f, 1.21056400e-01f,
  -2.00805679e-01f, 7.42136091e-02f, 2.50181705e-01f, 7.36781433e-02f, -5.27659096e-02f, 2.17199624e-01f, 1.48972690e-01f, 1.08760357e-01f, 2.79924899e-01f, 2.60369450e-01f,
  -1.91826269e-03f, 1.16167702e-01f, 1.16687588e-01f, 8.01149979e-02f, 9.95104238e-02f, -8.80849734e-02f, 2.26451173e-01f, 1.91098452e-02f, 1.11110277e-01f, 7.35315606e-02f,
  1.21589392e-01f, -3.31774838e-02f, 1.57098919e-01f, -4.84600943e-03f, 2.72886120e-02f, -1.43958926e-01f, 1.39913633e-01f, 1.79199621e-01f, -6.76436350e-02f, 3.84268314e-02f,
  -6.16267025e-02f, 1.91027805e-01f, -9.79866982e-02f, 1.43452659e-01f, -5.74285053e-02f, 1.29382178e-01f, 1.99654028e-01f, -4.84082736e-02f, 5.89322373e-02f, -3.51720053e-04f,
  -8.02567601e-02f, -7.27529526e-02f, 8.78880322e-02f, -9.92836524e-03f, 6.29220754e-02f, -1.14479894e-02f, 7.90830553e-02f, 8.87822434e-02f, 1.91661552e-01f, 1.65729895e-01f,
  4.99342903e-02f, 1.50887117e-01f, 4.23951186e-02f, 1.11461274e-01f, 1.91349402e-01f, 7.53576607e-02f, 9.52308998e-02f, -7.14978129e-02f, 1.72836855e-01f, 7.30608180e-02f,
  -1.15785580e-02f, 5.24320155e-02f, 2.50817448e-01f, 2.30760723e-01f, -3.23366314e-01f, 9.87062231e-02f, 7.76079893e-02f, -6.62703365e-02f, 3.45873117e-01f, -9.74341184e-02f,
  -3.06933165e-01f, -1.11937553e-01f, 1.99508369e-01f, 9.33126807e-02f, -1.79112270e-01f, -2.54804671e-01f, 2.72656173e-01f, -3.32153141e-01f, -8.61612409e-02f, 1.42449483e-01f,
  7.20214918e-02f, -1.72098830e-01f, 4.03862387e-01f, -6.88579828e-02f, 2.06181710e-03f, 1.47999614e-01f, -5.10107726e-02f, -1.88156635e-01f, -1.12522185e-01f, 1.28070354e-01f,
  8.37509111e-02f, -2.59922832e-01f, 2.01606527e-01f, 6.40072003e-02f, 3.97292227e-01f, -8.44784379e-02f, -3.28111112e-01f, -2.99211681e-01f, 1.15255110e-01f, -6.67461678e-02f,
  -2.08087087e-01f, 1.12596914e-01f, -2.09876329e-01f, -1.03703715e-01f, 3.65611538e-02f, -2.54561812e-01f, -1.14102997e-01f, -1.72649715e-02f, 3.48481275e-02f, -1.77856043e-01f,
  2.53054380e-01f, -7.50983655e-02f, -9.19863507e-02f, -9.87119675e-02f, 8.55646357e-02f, 1.51518747e-01f, 1.41199380e-01f, 1.90268770e-01f, -3.05873305e-02f, 1.12676665e-01f,
  -2.94459552e-01f, 1.20933466e-01f, -2.08229437e-01f, -3.84437703e-02f, 2.00804815e-01f, 3.81865166e-02f, -1.29072264e-01f, 5.04472330e-02f, -1.71167463e-01f, -1.98686928e-01f,
  -1.84136465e-01f, 2.22660363e-01f, 2.26157323e-01f, 1.83966324e-01f, 1.44533850e-02f, -1.20081589e-01f, 1.27818167e-01f, 4.08282995e-01f, -2.22679204e-03f, 1.58007115e-01f,
  5.36059588e-03f, 1.10324755e-01f, 3.55550349e-02f, 1.54806763e-01f, 1.00621209e-01f, 1.58866361e-01f, 1.38659507e-01f, -3.08420956e-02f, 1.32676452e-01f, -1.95923243e-02f,
  5.25532737e-02f, 1.09173529e-01f, -5.29983118e-02f, 1.49336517e-01f, -5.63150980e-02f, -1.26451582e-01f, 1.27809212e-01f, 1.34305477e-01f, 2.02315804e-02f, 1.38630554e-01f,
  6.58242926e-02f, 1.52053721e-02f, 5.01327105e-02f, -3.20264846e-02f, -8.18615556e-02f, 2.08181545e-01f, 7.69608617e-02f, 2.98403054e-02f, 7.51268417e-02f, 7.72000551e-02f,
  2.21449621e-02f, -9.38027445e-03f, 5.53151593e-02f, 1.73597597e-02f, -3.12518142e-02f, 1.47738412e-01f, 8.53575021e-02f, -9.27395597e-02f, -9.76047516e-02f, 1.02274254e-01f,
  5.89799099e-02f, 3.29519659e-02f, -1.50397057e-02f, 5.07065803e-02f, 8.78037289e-02f, 1.45049840e-01f, -3.27292792e-02f, -5.22615723e-02f, -3.37281413e-02f, -1.91806018e-01f,
  -1.60023674e-01f, -2.11912289e-01f, -9.37483981e-02f, 1.04834981e-01f, -1.64825201e-01f, -1.86831176e-01f, -5.04874252e-02f, 1.69031233e-01f, 1.73178807e-01f, 2.78158858e-02f,
  -8.81930664e-02f, -5.74767776e-03f, -6.21822067e-02f, 1.81868434e-01f, -2.60428160e-01f, 2.17016220e-01f, -5.95190786e-02f, 7.03138262e-02f, 7.98145756e-02f, 8.15187246e-02f,
  -1.20869346e-01f, 1.67665809e-01f, 9.59630460e-02f, -1.16305538e-01f, -1.49894893e-01f, -1.46561846e-01f, 4.43080142e-02f, -1.25115931e-01f, -2.29427114e-01f, 2.08000898e-01f,
  -3.54622573e-01f, 1.87398046e-01f, 1.33126244e-01f, 1.55607432e-01f, 2.25064710e-01f, 1.51712820e-01f, 2.82605231e-01f, -6.82823211e-02f, 6.62692189e-02f, -1.74582183e-01f,
  1.03143349e-01f, 1.00049160e-01f, 1.32969424e-01f, -1.07461594e-01f, 2.05524698e-01f, 2.82577753e-01f, 1.40845394e-02f, 1.87018171e-01f, 3.93314250e-02f, -1.13750041e-01f,
  5.73234558e-02f, 2.94259768e-02f, 6.40401766e-02f, 1.37108117e-01f, 1.74958721e-01f, 2.06827566e-01f, 1.81411877e-02f, 2.56042331e-02f, 2.66592532e-01f, 5.53216934e-02f,
  2.18156606e-01f, 1.46499649e-01f, 2.24110007e-01f, 2.74085402e-01f, 1.21481977e-01f, -1.50514918e-03f, 1.17979698e-01f, -1.46069881e-02f, -8.38520005e-02f, 2.21363410e-01f,
  9.13579911e-02f, -1.33456839e-02f, 1.55445516e-01f, -1.12948701e-01f, 1.74153611e-01f, 8.17321166e-02f, 1.92037329e-01f, 8.64403769e-02f, 2.22621769e-01f, 5.95379956e-02f,
  1.38905957e-01f, 3.24866734e-02f, 1.39212340e-01f, 1.67762693e-02f, 3.20138223e-02f, -6.18539692e-04f, -7.49583356e-03f, 7.47935846e-02f, 4.90146615e-02f, 1.40436381e-01f,
  2.35020444e-02f, 8.88192579e-02f, 1.07942246e-01f, 2.19370529e-01f, -3.16714756e-02f, 1.62696302e-01f, 5.11672348e-02f, 1.41809389e-01f, 1.70050412e-01f, 2.18665421e-01f,
  7.11260810e-02f, 1.97975606e-01f, 2.33673513e-01f, 1.48985863e-01f, 1.10550173e-01f, 1.33769482e-01f, 1.11471482e-01f, 1.40897840e-01f, 5.47380261e-02f, 1.66747183e-01f,
  9.25254524e-02f, -3.23927179e-02f, 6.23982511e-02f, 3.22028548e-02f, 5.11604995e-02f, 4.11298536e-02f, 1.35745481e-01f, 9.79447439e-02f, 9.01846141e-02f, 7.61095583e-02f,
  6.03622608e-02f, 1.32732987e-01f, 1.78737313e-01f, 2.91208853e-03f, 1.17191710e-01f, -2.19690669e-02f, 1.41618118e-01f, 2.67075300e-01f, -8.49364623e-02f, 1.40567452e-01f,
  8.33221599e-02f, -2.53041208e-01f, 2.18004122e-01f, 1.33237064e-01f, 1.30512297e-01f, 1.68403715e-01f, 2.12243453e-01f, -1.57832816e-01f, -1.72835350e-01f, -8.01010579e-02f,
  5.28108627e-02f, -1.87943131e-01f, 2.00703204e-01f, 3.98010612e-02f, 8.61108452e-02f, -2.75424957e-01f, -2.37107873e-02f, -1.05306163e-01f, 8.86061192e-02f, 1.22121103e-01f,
  -2.27937162e-01f, -9.61901098e-02f, 1.08444788e-01f, 2.99342610e-02f, -8.14833790e-02f, 2.32908398e-01f, 1.35133997e-01f, -2.97676865e-03f, 3.04276139e-01f, -1.83565214e-01f,
  2.88861971e-02f, 2.76963532e-01f, 1.86876357e-01f, -1.29464582e-01f, -5.07832654e-02f, 6.65210411e-02f, -1.89731181e-01f, -5.74050993e-02f, 8.30035433e-02f, -2.24721789e-01f,
  -2.02152029e-01f, 3.05659086e-01f, -3.87302414e-02f, -3.17057431e-01f, -5.30316941e-02f, 6.80801347e-02f, 8.41900427e-03f, 7.82271028e-02f, 2.37451926e-01f, 9.25592799e-03f,
  -2.38911346e-01f, 7.04408139e-02f, 3.12929422e-01f, 3.17233279e-02f, 8.72351378e-02f, 8.57961625e-02f, 2.48168260e-01f, 2.17380211e-01f, 1.58824831e-01f, -1.24559663e-01f,
  -3.06261361e-01f, -2.23558620e-01f, -8.01527724e-02f, 4.04234454e-02f, -1.09170534e-01f, 1.97626457e-01f, 3.18356365e-01f, 7.39536423e-04f, 1.47051818e-03f, -2.16106385e-01f,
  -2.55131088e-02f, 4.31395680e-01f, 4.89317402e-02f, -1.52604252e-01f, -2.70005129e-02f, 2.15812586e-02f, 3.08007430e-02f, 1.01286821e-01f, -3.19618247e-02f, 1.07331842e-01f,
  9.25548226e-02f, 6.09933492e-03f, 4.87564728e-02f, 1.22776322e-01f, 8.38282257e-02f, 1.17392205e-01f, 5.75764477e-02f, 9.24134478e-02f, 3.15986834e-02f, 2.60288059e-03f,
  -7.89942518e-02f, 1.15054436e-01f, 1.38805598e-01f, 6.36495948e-02f, -5.48038222e-02f, -3.91768627e-02f, 4.79543284e-02f, 3.97304483e-02f, -5.34493923e-02f, 1.73269391e-01f,
  -6.20645992e-02f, -9.43998399e-04f, 1.40771583e-01f, 5.50967939e-02f, 9.92644392e-03f, 1.78543478e-02f, 1.16053529e-01f, 1.43174082e-01f, 2.33596563e-02f, 1.25044927e-01f,
  -3.58280577e-02f, 2.29398329e-02f, 2.65844427e-02f, 3.44527476e-02f, -6.71922714e-02f, 9.02848095e-02f, 5.01301736e-02f, -2.58751623e-02f, 9.80471447e-02f, 5.06332405e-02f,
  7.43247643e-02f, -3.51996981e-02f, -4.66287322e-02f, 1.45039961e-01f, 8.99818842e-04f, -1.58571869e-01f, 8.98123160e-02f, -3.02153915e-01f, -2.29317203e-01f, 2.86021441e-01f,
  -3.35752249e-01f, -2.61977553e-01f, -4.35112836e-03f, 2.58498490e-01f, 4.65571135e-02f, 8.42746645e-02f, 1.89003814e-02f, 2.99996007e-02f, -1.40499726e-01f, 3.55392009e-01f,
  -1.84665397e-01f, 1.87705476e-02f, 2.36775562e-01f, 1.34969816e-01f, -6.24465980e-02f, -4.89938585e-03f, -7.70757794e-02f, 1.15412727e-01f, 1.00622671e-02f, -7.19731906e-03f,
  1.77298144e-01f, -4.17502910e-01f, 4.46673036e-02f, -1.24512747e-01f, 7.92996958e-02f, -1.56954989e-01f, -2.57315814e-01f, 1.44909352e-01f, -1.09981924e-01f, -3.33510637e-02f,
  -1.48130581e-01f, -7.79868811e-02f, 1.05624452e-01f, 1.58444438e-02f, -1.45123348e-01f, -2.49126941e-01f, 2.68608540e-01f, -1.25940442e-01f, 1.08419880e-01f, -7.43393078e-02f,
  4.86996733e-02f, 3.34336936e-01f, 1.65633969e-02f, 2.95499772e-01f, -1.28153369e-01f, 1.24358810e-01f, 1.54070228e-01f, 8.15363228e-02f, 2.90060759e-01f, 2.76110142e-01f,
  1.89224228e-01f, -7.22033232e-02f, -1.08417332e-01f, 3.87763679e-01f, 2.29784906e-01f, 3.73982489e-01f, -3.61607000e-02f, -6.09654970e-02f, 1.64095566e-01f, 1.22745566e-01f,
  8.88605118e-02f, 2.96574354e-01f, 2.64275849e-01f, 2.05715790e-01f, -2.32992247e-01f, -7.04488158e-02f, 6.94292784e-02f, 4.18062896e-01f, 1.59637615e-01f, -8.48544762e-02f,
  1.72642365e-01f, 2.76371717e-01f, 1.50214836e-01f, -5.22551872e-02f, 8.03621784e-02f, 2.20421515e-02f, 9.45613384e-02f, 5.00124209e-02f, 9.50194076e-02f, -1.81473717e-02f,
  -1.46880401e-02f, 5.12606688e-02f, 9.99913290e-02f, 1.38116345e-01f, 1.40883913e-02f, 1.24682672e-01f, 1.83169201e-01f, 9.30586606e-02f, 1.36254402e-02f, 2.46659145e-01f,
  1.31611079e-01f, -1.33452445e-01f, -2.72506457e-02f, 1.09783001e-01f, -6.22393116e-02f, 2.34314874e-01f, 6.83468506e-02f, 7.77114416e-03f, 1.34657010e-01f, -1.31528258e-01f,
  7.68160149e-02f, 2.39358917e-02f, 1.95157286e-02f, 2.01629635e-04f, -1.13906730e-02f, 9.91578959e-03f, 1.68554008e-01f, 6.92441389e-02f, 4.02976908e-02f, -1.95653383e-02f,
  2.49289144e-02f, 2.06709802e-01f, 1.97904631e-01f, 1.89282224e-01f, 7.99425095e-02f, 1.81923553e-01f, 5.78151867e-02f, -2.84373597e-03f, 1.02070913e-01f, 2.39293333e-02f,
  8.94669667e-02f, 7.09700584e-02f, 6.27818033e-02f, 1.71928048e-01f, 8.10536817e-02f, 1.22803815e-01f, 8.03670511e-02f, -4.23967913e-02f, 1.55179188e-01f, 1.39455944e-01f,
  8.31230506e-02f, -7.89302513e-02f, -9.08353254e-02f, -8.23558345e-02f, -1.41809270e-01f, 9.39759687e-02f, 2.63688825e-02f, -5.24495505e-02f, 1.84759349e-01f, -6.81032762e-02f,
  2.11826131e-01f, -1.38978094e-01f, -5.97202703e-02f, 1.03278786e-01f, 1.70098856e-01f, -9.93343592e-02f, -1.53019980e-01f, 1.22761324e-01f, 8.78584608e-02f, -4.79591563e-02f,
  -4.83186729e-02f, 1.71910733e-01f, 2.17331022e-01f, -2.75081992e-01f, 3.33711684e-01f, -1.75453454e-01f, -1.17843576e-01f, -2.13875305e-02f, -1.72483802e-01f, -8.79254043e-02f,
  -2.07325190e-01f, 1.96400225e-01f, 4.49740700e-02f, 3.51602137e-02f, -7.78345764e-02f, -3.84080559e-02f, -1.54927701e-01f, 9.75743085e-02f, -2.74620563e-01f, -2.57657349e-01f,
  6.96952939e-02f, -1.29966632e-01f, -5.13245575e-02f, 1.89065799e-01f, -3.91933769e-02f, 1.59079179e-01f, 1.02017164e-01f, 9.89378840e-02f, -6.02171198e-02f, -1.93724021e-01f,
  6.42974768e-03f, 8.47207308e-02f, -5.54985926e-02f, -2.41577290e-02f, -1.92571223e-01f, -6.92554638e-02f, 8.54465552e-03f, -4.63357158e-02f, -4.74258400e-02f, 4.13101241e-02f,
  4.21461388e-02f, 4.22214381e-02f, 1.90733880e-01f, -1.78758390e-02f, 5.00746854e-02f, 3.28176022e-01f, 9.28572044e-02f, 1.52069315e-01f, 3.85980904e-02f, 1.29775286e-01f,
  -7.35694468e-02f, 1.63855236e-02f, 2.16721639e-01f, 5.96098639e-02f, 1.17965005e-01f, 1.61290199e-01f, 6.99164346e-02f, 9.69657153e-02f, 7.09720775e-02f, -1.66566819e-02f,
  1.75028946e-02f, 7.41260797e-02f, 8.40764865e-02f, 2.92790011e-02f, 1.19875260e-01f, 1.82408601e-01f, -9.28296987e-03f, 5.17289788e-02f, 6.79552257e-02f, 1.01482503e-01f,
  -3.12421471e-02f, 1.74788371e-01f, 3.35739329e-02f, 1.75711975e-01f, 3.75322625e-03f, 1.30390748e-01f, 1.03301138e-01f, 2.03825489e-01f, 2.05707755e-02f, 4.28062081e-02f,
  5.23105413e-02f, 1.03301235e-01f, 1.31228060e-01f, 5.50902523e-02f, 2.43323632e-02f, 3.36817913e-02f, 1.42473176e-01f, 6.48709610e-02f, 1.41318515e-01f, -2.77015511e-02f,
  1.14745289e-01f, 1.34065509e-01f, 1.62719592e-01f, -7.84010366e-02f, 1.73133031e-01f, -2.60150246e-03f, 1.90173715e-01f, -4.29715849e-02f, 4.73111421e-02f, 6.25576079e-02f,
  1.10111795e-01f, 1.90014154e-01f, -1.00011215e-01f, -1.49934888e-02f, -4.07970220e-01f, 1.99014321e-01f, -1.69105187e-01f, 4.29125428e-02f, 2.03407496e-01f, 2.28044331e-01f,
  6.46192953e-02f, 1.65244162e-01f, 2.63752565e-02f, 2.54440159e-01f, -2.48051673e-01f, 1.60664730e-02f, -7.21746981e-02f, 1.06174134e-01f, 5.04550636e-02f, 5.83049934e-03f,
  2.63384525e-02f, -1.24790750e-01f, 2.16742396e-01f, 1.34131685e-01f, -1.77862182e-01f, -6.17266335e-02f, -1.10132582e-01f, 1.20379396e-01f, 1.48097724e-01f, -1.55417114e-01f,
  5.68479951e-03f, 1.99585378e-01f, 8.90241191e-03f, 1.17678188e-01f, 1.55427650e-01f, 1.80205181e-01f, 1.40491903e-01f, -1.43692017e-01f, 6.97335079e-02f, 3.24747622e-01f,
  -1.88243449e-01f, -3.25794928e-02f, 3.00712973e-01f, -2.33124807e-01f, -1.02879308e-01f, 1.10288225e-01f, -1.02490641e-01f, -6.81569874e-02f, -9.28335637e-03f, -7.88127780e-02f,
  -1.62576780e-01f, -4.14274819e-02f, 2.95464873e-01f, 1.00611128e-01f, 1.41049810e-02f, 2.72327155e-01f, 1.51270196e-01f, 1.80760339e-01f, 5.90027086e-02f, 2.98265070e-01f,
  2.30129555e-01f, 3.17075878e-01f, 9.48580205e-02f, 1.49286300e-01f, 1.89513177e-01f, 1.38997346e-01f, 1.57050446e-01f, -1.91074796e-02f, 6.37203977e-02f, 1.53213963e-01f,
  1.23222917e-01f, 6.37857020e-02f, 1.74936011e-01f, -2.74084806e-01f, -2.77851671e-01f, -5.75783625e-02f, 1.36914074e-01f, 2.29838560e-03f, 1.38923272e-01f, -1.63794141e-02f,
  2.13193670e-02f, 1.11277334e-01f, 1.57362908e-01f, 1.85747189e-03f, 4.90274653e-02f, -7.65776783e-02f, 7.85471722e-02f, -7.18662981e-04f, 9.77037698e-02f, -4.94234860e-02f,
  1.66814372e-01f, -1.18650980e-02f, 1.06760440e-02f, -2.39382591e-02f, 1.37717173e-01f, 1.20144635e-01f, 1.30417943e-01f, 3.46434638e-02f, 1.11863930e-02f, 1.67067736e-01f,
  1.14021294e-01f, -1.30468616e-02f, 1.37688830e-01f, 6.35039881e-02f, 1.16350308e-01f, 7.39890635e-02f, 1.41935095e-01f, 1.53083280e-01f, 2.71195918e-02f, 2.95571070e-02f,
  1.51890382e-01f, 6.00783713e-02f, 7.54082799e-02f, -7.04353824e-02f, -1.70119535e-02f, 7.45023638e-02f, 2.26043910e-02f, 2.07737703e-02f, 8.50270167e-02f, 9.12512988e-02f,
  6.30994290e-02f, 1.26494721e-01f, 8.36728588e-02f, 1.39688909e-01f, 1.77309155e-01f, -3.17285135e-02f, 5.01548611e-02f, 2.45298781e-02f, 1.04027979e-01f, 1.96480855e-01f,
  6.77721426e-02f, 8.46977085e-02f, -5.06189419e-03f, -8.35351646e-02f, 3.16421203e-02f, 7.92304985e-04f, -9.95594636e-02f, 1.21953957e-01f, 2.24809442e-02f, -7.90280625e-02f,
  -2.29465384e-02f, -1.31410345e-01f, 1.05009032e-02f, 6.90976158e-02f, 7.02333674e-02f, 9.25323367e-02f, 1.97956219e-01f, 1.06637962e-01f, -1.69119596e-01f, -8.98844600e-02f,
  -6.43449798e-02f, -5.64397126e-02f, -5.80642037e-02f, -1.94290578e-01f, 8.80329683e-02f, -2.44233251e-01f, -8.94168764e-02f, 1.28474668e-01f, 1.39137506e-01f, -1.72764361e-01f,
  8.72223750e-02f, -1.11028895e-01f, 8.06191638e-02f, -1.14946313e-01f, -8.53573754e-02f, 1.40093584e-02f, 9.09609273e-02f, -4.72626686e-02f, -2.93992683e-02f, -1.34021446e-01f,
  6.34616166e-02f, -4.46810871e-02f, -2.15079591e-01f, 2.20017880e-01f, -6.59796596e-02f, -1.95467360e-02f, -1.16279595e-01f, 1.52241260e-01f, -1.25779524e-01f, 1.12509102e-01f,
  2.01750666e-01f, 9.97940972e-02f, 1.04947872e-01f, 1.52460724e-01f, 1.42802715e-01f, -2.64089346e-01f, 1.12725347e-01f, 1.40573427e-01f, 1.43891171e-01f, 2.55537629e-01f,
  -1.25128984e-01f, -1.64142922e-01f, -1.82795689e-01f, -2.13612109e-01f, 1.40721612e-02f, 1.88231796e-01f, 5.17488718e-02f, 2.82928377e-01f, 2.03291699e-01f, -8.88607372e-03f,
  -3.76511924e-02f, -7.83261731e-02f, -2.79177632e-02f, -4.21032198e-02f, -1.36615932e-01f, -1.57882780e-01f, -6.48049563e-02f, 7.66499564e-02f, 6.79083914e-02f, 3.45821381e-02f,
  4.01155837e-02f, -8.27995781e-03f, 1.62136018e-01f, 1.34722725e-01f, 1.85554683e-01f, 1.15362331e-01f, 4.59004864e-02f, 3.88454199e-02f, 8.36464390e-02f, 6.54545799e-03f,
  9.51262638e-02f, 9.95296463e-02f, -4.86363620e-02f, 2.04224717e-02f, 8.37369710e-02f, 7.06751496e-02f, -1.07781198e-02f, 1.10981762e-01f, -6.62878738e-04f, -9.12729576e-02f,
  -1.72404051e-02f, 1.45081952e-01f, 1.71749234e-01f, 1.77842408e-01f, 1.00808024e-01f, 1.09191984e-02f, -8.60781148e-02f, 1.58387601e-01f, 1.16011940e-01f, 1.90815270e-01f,
  6.49615228e-02f, 1.42374724e-01f, 6.41985610e-02f, 7.88255185e-02f, 9.76255387e-02f, 2.32424140e-02f, -5.22595793e-02f, 1.42098814e-01f, 7.21198991e-02f, -5.63726388e-02f,
  1.64157495e-01f, 1.74884424e-01f, 4.78719026e-02f, 2.08521172e-01f, -4.66966163e-03f, 9.38283727e-02f, 1.68076009e-01f, -3.14587861e-01f, 1.89124644e-01f, -2.48762462e-02f,
  -2.07579389e-01f, 2.43985504e-01f, -3.34465146e-01f, -2.47103065e-01f, -5.21800257e-02f, 1.09545089e-01f, -7.15302676e-03f, 3.22912276e-01f, 1.32814065e-01f, 1.77086413e-01f,
  -8.95134360e-02f, 2.42113292e-01f, -1.65850639e-01f, -2.23918594e-02f, 4.47737798e-02f, 7.68722668e-02f, 4.95209396e-02f, -7.21713454e-02f, -7.26233721e-02f, 1.21124960e-01f,
  2.62383074e-01f, 2.65230179e-01f, -9.01255533e-02f, -5.10994717e-02f, -1.79178417e-02f, -1.69298518e-02f, -1.16060548e-01f, -1.23686559e-01f, -2.67121971e-01f, 1.40897036e-01f,
  1.38004422e-01f, 5.58359474e-02f, -7.25221708e-02f, 1.47529710e-02f, 2.58403480e-01f, -7.17669204e-02f, -3.63335945e-02f, 2.72581410e-02f, -4.01776619e-02f, 3.21335979e-02f,
  1.72240481e-01f, -1.62198797e-01f, -1.69959292e-01f, 2.04727650e-01f, 1.64465815e-01f, -1.09793097e-01f, 1.31168485e-01f, 1.48799732e-01f, -4.07929309e-02f, -9.93890241e-02f,
  3.31916720e-01f, 2.54135042e-01f, 7.56093562e-02f, 3.37813497e-01f, -3.47607881e-02f, 2.07505107e-01f, -2.01553345e-01f, -8.71406049e-02f, -2.99987439e-02f, -1.72419380e-02f,
  1.08942620e-01f, 2.50718147e-01f, 2.48135433e-01f, 9.35510024e-02f, 2.87163518e-02f, -4.48422618e-02f, -3.69371742e-01f, 2.99434423e-01f, 1.99568421e-02f, 8.95335451e-02f,
  1.16857156e-01f, -7.89774209e-02f, 2.05827773e-01f, 1.09084338e-01f, 7.14398827e-03f, -7.32266232e-02f, 4.77565872e-03f, 6.07714020e-02f, 1.69105902e-02f, 3.92235778e-02f,
  1.46117836e-01f, 1.36702899e-02f, -7.62900570e-03f, 2.75304038e-02f, 7.70193636e-02f, 9.15445536e-02f, -1.53204963e-01f, 9.06346589e-02f, -8.31259564e-02f, 1.65334255e-01f,
  -2.74696741e-02f, 3.16013657e-02f, 8.61861855e-02f, -2.53810436e-02f, 2.15639219e-01f, 8.15022662e-02f, 6.55407272e-03f, -3.58742476e-02f, -6.29328713e-02f, 3.39455344e-02f,
  1.31055294e-02f, 1.19308442e-01f, 6.54940531e-02f, 7.64626712e-02f, -6.27860725e-02f, 1.22932233e-01f, -1.62896737e-02f, 1.12964585e-01f, 1.22711301e-01f, -1.08478375e-01f,
  9.19790938e-02f, -1.32770818e-02f, -1.11512863e-03f, 3.03218253e-02f, 5.13694286e-02f, -1.18330505e-03f, -1.32931843e-02f, -4.20624875e-02f, 8.47159419e-03f, 2.54742447e-02f,
  1.06659248e-01f, 1.36115208e-01f, 4.97863442e-02f, 2.59901062e-02f, -1.08326003e-01f, 1.22401595e-01f, 1.13209456e-01f, 3.36301386e-01f, -1.22632034e-01f, -8.78374577e-02f,
  1.23194560e-01f, -9.98226628e-02f, 6.82396814e-02f, -1.08456865e-01f, 1.28781889e-03f, -1.94539398e-01f, -1.62329674e-01f, -2.17557028e-01f, -2.58859485e-01f, -2.54313499e-01f,
  1.78983167e-01f, 2.90342361e-01f, 1.91763192e-01f, -1.11612551e-01f, -2.94294596e-01f, -2.08434865e-01f, 4.63578403e-02f, -1.60532475e-01f, -2.39298686e-01f, 5.13853952e-02f,
  3.13566737e-02f, -2.28198737e-01f, -1.62157834e-01f, 1.89081565e-01f, 4.88606952e-02f, -7.09775016e-02f, 1.33877367e-01f, -1.71193063e-01f, 4.73815463e-02f, 1.67351067e-01f,
  9.28445831e-02f, -9.43937451e-02f, 1.77697241e-01f, -1.66874081e-01f, -3.23827296e-01f, -2.68030792e-01f, 5.19189872e-02f, 1.58421054e-01f, -2.13810831e-01f, 2.46622860e-01f,
  1.93215489e-01f, -2.07320884e-01f, -1.89745933e-01f, 9.63972658e-02f, 1.94104359e-01f, 2.07508415e-01f, -1.17220372e-01f, 6.69709370e-02f, 4.84340899e-02f, -1.35905212e-02f,
  4.00447965e-01f, -1.15894474e-01f, -9.93301421e-02f, 9.10505746e-03f, 4.46542263e-01f, 3.05407763e-01f, 3.15381616e-01f, -6.37835786e-02f, 5.81705049e-02f, -2.46305764e-01f,
  -2.45144218e-03f, 3.88159268e-02f, 1.90644622e-01f, -4.66575883e-02f, 8.86456966e-02f, -8.94078240e-02f, 2.55348146e-01f, -1.41241729e-01f, 8.70119706e-02f, 4.73915875e-01f,
  -2.28239924e-01f, 1.33991554e-01f, 4.51717675e-02f, 1.04095921e-01f, 2.42248690e-03f, 1.19751515e-02f, 6.85743615e-02f, 1.44094437e-01f, 1.30183667e-01f, 1.69109255e-01f,
  2.06056178e-01f, 1.25914231e-01f, 5.57862110e-02f, 1.16320200e-01f, -1.19415345e-02f, 9.41339657e-02f, 1.34173557e-01f, 1.18276477e-02f, 5.59226237e-02f, -5.20881899e-02f,
  6.94674179e-02f, 4.23838906e-02f, 2.08347850e-02f, -2.61210855e-02f, 1.20714553e-01f, 3.78950350e-02f, 6.80019259e-02f, 1.03120983e-01f, 3.44118960e-02f, 2.01674193e-01f,
  1.60659969e-01f, -1.65132899e-02f, -1.04433954e-01f, 1.85166523e-01f, 7.45691061e-02f, 1.53065426e-02f, -2.33028535e-04f, 1.85729995e-01f, -1.37744118e-02f, 3.78782973e-02f,
  1.81016073e-01f, 1.64411739e-01f, 8.30891132e-02f, 1.68822799e-02f, 1.00216359e-01f, 8.83068815e-02f, -9.10531171e-03f, 1.20553084e-01f, -4.66208011e-02f, 1.41837656e-01f,
  9.52380896e-02f, 6.75715134e-02f, 6.73600063e-02f, -9.69153121e-02f, 2.34104812e-01f, -1.84827164e-01f, -4.07106578e-02f, 1.39553010e-01f, -1.03299141e-01f, -7.21230209e-02f,
  -1.99503794e-01f, -7.51461908e-02f, -5.70699573e-02f, 3.27673167e-01f, 1.54022321e-01f, 1.38253868e-01f, -1.41688719e-01f, 2.41579220e-01f, -2.13492915e-01f, 1.95800625e-02f,
  -8.41006935e-02f, 2.19735563e-01f, -9.95247364e-02f, -3.30380313e-02f, 4.31279801e-02f, -1.47563919e-01f, 2.00691685e-01f, 1.98511496e-01f, -6.43028319e-02f, 6.89767823e-02f,
  -6.46461621e-02f, -1.48372993e-01f, -1.75569028e-01f, 2.37525981e-02f, -1.67280585e-01f, 5.03756814e-02f, 4.62210812e-02f, -1.84796788e-02f, -1.11977704e-01f, 2.13763356e-01f,
  1.43818662e-01f, 4.33012098e-02f, 2.73852497e-01f, -7.82831907e-02f, -7.36182034e-02f, 7.64796957e-02f, 2.94516325e-01f, -1.42297536e-01f, -3.58688645e-02f, 8.91948044e-02f,
  7.97902886e-03f, -1.90523773e-01f, -1.00085817e-01f, 1.03284577e-02f, -1.23705663e-01f, 2.19645396e-01f, 3.12647074e-01f, 1.69811383e-01f, -9.29609463e-02f, 2.74900526e-01f,
  2.74132520e-01f, -6.46789670e-02f, -1.73717737e-01f, -1.09039500e-01f, 1.62784904e-01f, 3.28900427e-01f, 2.32432306e-01f, 1.73237622e-01f, 3.99932265e-01f, -2.06813574e-01f,
  2.88608313e-01f, -1.75671667e-01f, -2.12414384e-01f, 1.75900221e-01f, 1.18019864e-01f, 1.89974710e-01f, 3.14395800e-02f, -7.51114711e-02f, 7.34619498e-02f, 1.59878805e-01f,
  1.15575396e-01f, 5.82710430e-02f, -8.47412944e-02f, 1.70375332e-01f, 4.32138108e-02f, -2.70477850e-02f, 8.89461413e-02f, -2.07886994e-02f, 8.44424684e-03f, 3.92574742e-02f,
  1.24447808e-01f, 6.48418665e-02f, 3.48175690e-02f, 3.51134054e-02f, 5.03221080e-02f, 6.75793812e-02f, 8.20305273e-02f, 9.08421427e-02f, 1.22016907e-01f, 9.36224312e-02f,
  -5.07891178e-03f, 1.13103777e-01f, 5.89212067e-02f, 5.52472845e-02f, 8.78953561e-02f, 4.87948805e-02f, 4.36703786e-02f, -3.56242917e-02f, 1.11559629e-01f, 1.72472537e-01f,
  1.58629000e-01f, 7.99547508e-02f, 1.23937733e-01f, 1.21421926e-01f, 3.35116535e-02f, 1.35712713e-01f, 8.25130194e-02f, 2.13247567e-01f, 1.92414299e-01f, 1.25426069e-01f,
  4.18068022e-02f, -1.98334120e-02f, 1.04229264e-01f, 5.90812340e-02f, 8.64785463e-02f, 2.87883673e-02f, 1.15428187e-01f, 8.37206282e-03f, 1.09265886e-01f, 1.00011654e-01f,
  4.59813885e-02f, 1.75744906e-01f, 5.92859238e-02f, 2.74620391e-02f, -2.44981810e-01f, 1.31051332e-01f, 3.41290608e-02f, 2.46188968e-01f, 1.63518697e-01f, 7.85151049e-02f,
  -7.47466609e-02f, -1.15169540e-01f, 3.46087158e-01f, 1.39085531e-01f, -2.18218237e-01f, 1.00379236e-01f, 1.19716577e-01f, -1.27499700e-01f, 3.67710516e-02f, 3.21554005e-01f,
  -1.14229001e-01f, -1.45145729e-01f, 1.95824638e-01f, -1.50110483e-01f, -1.13595106e-01f, -3.48834217e-01f, -1.24184024e-02f, 1.76277757e-02f, 7.48808160e-02f, -1.17252566e-01f,
  5.18294387e-02f, 5.13597317e-02f, -4.32807610e-06f, 1.99114919e-01f, 3.34568530e-01f, -2.09156170e-01f, 4.81969193e-02f, -2.09198371e-01f, -3.86309773e-02f, 9.78652015e-02f,
  -2.04840735e-01f, -3.21743898e-02f, 2.15068161e-01f, -1.66351348e-01f, -1.84161261e-01f, -2.51883209e-01f, 1.07986704e-01f, 1.55530069e-02f, -2.77632713e-01f, 8.29448476e-02f,
  -8.18708166e-02f, -2.25116551e-01f, 1.39797345e-01f, 1.67506978e-01f, 9.17589515e-02f, 2.05304712e-01f, 1.74542069e-01f, -7.28293955e-02f, 1.84955135e-01f, 1.79892763e-01f,
  2.79838089e-02f, 3.75325501e-01f, -2.43158136e-02f, 4.37486582e-02f, 2.13513881e-01f, 2.54988462e-01f, 3.16045131e-03f, 1.26364067e-01f, 2.86493987e-01f, -1.03130266e-02f,
  -7.61503652e-02f, -1.98371578e-02f, 2.45470881e-01f, 2.77002901e-01f, -2.22086877e-01f, -1.49320841e-01f, 2.64600009e-01f, 3.05141330e-01f, 2.21644923e-01f, 1.53618112e-01f,
  4.19198126e-02f, 1.34899721e-01f, 3.26692313e-02f, -2.31793702e-01f, 6.95490465e-02f, -1.55810148e-01f, -8.94040242e-02f, 4.51047346e-02f, -8.11349675e-02f, -7.05017596e-02f,
  1.37812957e-01f, 1.83277309e-01f, 1.05261855e-01f, -2.80131221e-01f, 1.66210815e-01f, 1.71260908e-01f, -6.78045154e-02f, -6.10486418e-02f, 1.09243251e-01f, 4.74009849e-02f,
  -2.10689068e-01f, 1.02299318e-01f, 1.86908871e-01f, -1.75458699e-01f, 2.49518543e-01f, -7.99131617e-02f, 5.13504585e-03f, 1.30173966e-01f, 4.26469624e-01f, -2.24038988e-01f,
  1.56049743e-01f, -7.20900223e-02f, 2.60689016e-02f, 2.95742989e-01f, 2.41925810e-02f, 1.51564926e-01f, -6.89150346e-03f, 1.05770551e-01f, -1.64904013e-01f, -9.58040133e-02f,
  4.68895659e-02f, 1.89018101e-01f, 3.98695506e-02f, 3.63155663e-01f, 1.21440291e-01f, -1.85189933e-01f, 2.51750976e-01f, 9.30949301e-02f, 4.01271999e-01f, -3.09321806e-02f,
  -5.24154067e-01f, 2.87530363e-01f, 1.71538368e-01f, -4.04570580e-01f, 3.94270509e-01f, 3.32847908e-02f, 7.13003147e-03f, -4.49207067e-01f, -1.65781185e-01f, -2.17639938e-01f,
  3.74756694e-01f, -8.61895829e-02f, 3.03144217e-01f, 3.22334543e-02f, 3.12456727e-01f, -2.38038152e-01f, -4.56047237e-01f, 5.15495300e-01f, 9.86527000e-03f, -3.40123028e-01f,
  -1.93239942e-01f, -1.91173315e-01f, -2.96282247e-02f, -3.02170843e-01f, -6.80297911e-01f, 2.94119239e-01f, -2.61247009e-01f, 1.38468757e-01f, -2.41478562e-01f, 5.57554401e-02f,
  3.45680952e-01f, 1.08952269e-01f, 1.91024363e-01f, -6.39832854e-01f, -3.11277717e-01f, -4.27317023e-01f, -1.42568991e-01f, -4.14462537e-01f, -1.06737919e-01f, 5.42648554e-01f,
  -4.92647290e-01f, -5.04069805e-01f, -1.61121443e-01f, -5.75498402e-01f, 4.32984143e-01f, 8.77409875e-02f, -3.69159937e-01f, 2.38910466e-01f, 1.56226888e-01f, -4.23586965e-01f,
  1.91666514e-01f, -9.98049453e-02f, -3.30236703e-01f, -4.43269089e-02f, 2.92241007e-01f, 3.55245918e-02f, 3.65155309e-01f, 1.55724868e-01f, 2.07112700e-01f, 2.33399227e-01f,
  -1.83259934e-01f, 5.27188033e-02f, -4.12341595e-01f, 1.45874932e-01f, -1.89786673e-01f, 6.21967733e-01f, -3.11205834e-01f, 3.49883467e-01f, 1.19897634e-01f, 6.31362647e-02f,
  -5.83802797e-02f, -1.66055456e-01f, 9.63833630e-02f, 9.29928049e-02f, 1.36304662e-01f, 7.57578164e-02f, -1.40924767e-01f, 1.88889261e-03f, 5.86518049e-02f, -3.00414991e-02f,
  7.08531663e-02f, 1.68599471e-01f, -1.25778630e-01f, 2.41370380e-01f, 1.47767663e-01f, 6.73692152e-02f, 1.30256146e-01f, 3.98463272e-02f, -1.28632143e-01f, 1.31764069e-01f,
  -5.55210598e-02f, -4.29824255e-02f, 1.75835252e-01f, -2.43963093e-01f, 6.60868585e-02f, 1.82832122e-01f, 2.62509994e-02f, -2.90392818e-05f, 6.56305104e-02f, -9.14580449e-02f,
  -1.45768434e-01f, 1.00283623e-01f, -8.72842893e-02f, 1.41433254e-01f, 1.33664966e-01f, -1.21971466e-01f, -2.16564640e-01f, 1.40717179e-01f, -5.94637655e-02f, 7.76122734e-02f,
  1.57639727e-01f, 7.42017617e-03f, -5.13180792e-02f, 1.09941132e-01f, 6.50220811e-02f, 1.08358130e-01f, 5.71797676e-02f, 2.23989323e-01f, -1.79965451e-01f, 6.77509084e-02f,
  -1.52180165e-01f, -9.38600600e-02f, 3.98675576e-02f, 1.39373824e-01f, 3.95386256e-02f, 1.19495548e-01f, -2.04351351e-01f, 2.46702991e-02f, 1.85700297e-01f, -2.29390785e-01f,
  7.77698681e-02f, -2.15758067e-02f, -2.05060452e-01f, -1.89588442e-01f, -1.32142529e-01f, -1.08017772e-01f, -3.04758996e-01f, 2.69667178e-01f, -2.63765752e-01f, -1.81497470e-01f,
  2.10581005e-01f, -2.58696321e-02f, 6.37013614e-02f, 2.50615850e-02f, 3.41465622e-01f, -6.82615191e-02f, -2.28622437e-01f, 2.17979699e-01f, -8.61539841e-02f, -4.15934343e-03f,
  -8.59727412e-02f, 1.47580475e-01f, 1.85090095e-01f, -2.91247368e-01f, 1.14700742e-01f, 1.21074088e-01f, -2.11291820e-01f, -2.97349811e-01f, -3.88554074e-02f, 2.08780169e-02f,
  -2.15799138e-01f, 1.49150014e-01f, -1.56404033e-01f, 1.01326980e-01f, -1.28027231e-01f, 1.12446710e-01f, -4.82194982e-02f, -1.90238833e-01f, 8.42015967e-02f, 1.51917264e-01f,
  -7.48249590e-02f, -1.24423139e-01f, 2.45377988e-01f, -1.12243041e-01f, -1.87277719e-01f, -4.37020473e-02f, 1.81498211e-02f, 7.02474862e-02f, 1.34533450e-01f, 1.40356988e-01f,
  7.23139346e-02f, 2.01022495e-02f, -5.15948892e-01f, -2.41155595e-01f, -1.03901051e-01f, 4.34301376e-01f, -2.57913798e-01f, 1.40684634e-01f, 9.04068798e-02f, 6.55001542e-03f,
  2.41721854e-01f, 5.22200406e-01f, -4.24168967e-02f, 4.60108548e-01f, 1.89793631e-01f, 1.75847426e-01f, 5.62364012e-02f, 2.04645753e-01f, 1.23138100e-01f, 3.27393323e-01f,
  3.69092792e-01f, 1.81748837e-01f, 3.77391100e-01f, 5.03134616e-02f, 2.67720342e-01f, 8.44225138e-02f, -1.19112462e-01f, 5.75800948e-02f, 4.55570184e-02f, 1.32609472e-01f,
  1.28876552e-01f, -7.74837658e-02f, 1.17709391e-01f, 3.98866720e-02f, -2.36253347e-02f, -1.48094798e-04f, 2.28107255e-02f, 2.31026504e-02f, 1.26690596e-01f, 7.37711117e-02f,
  1.19608650e-02f, -3.22513729e-02f, 2.47416478e-02f, 2.07280681e-01f, 8.75641927e-02f, 1.34979486e-01f, 8.40643123e-02f, 1.65460870e-01f, 5.71017303e-02f, 5.57024740e-02f,
  -3.83477844e-02f, 1.68169793e-02f, -5.19649871e-02f, 1.11791447e-01f, 6.19748272e-02f, 1.11598216e-01f, 5.08499146e-02f, 1.01853691e-01f, 1.10556051e-01f, 8.49638432e-02f,
  7.38267452e-02f, 7.69254491e-02f, 1.05758542e-02f, 9.17484239e-02f, 1.29700765e-01f, 5.75509407e-02f, 2.08778799e-01f, 1.44541845e-01f, 8.19903240e-02f, -1.23386178e-02f,
  7.89150894e-02f, 1.21327817e-01f, 3.53352204e-02f, 4.52687629e-02f, 4.40050662e-02f, 6.67242780e-02f, -4.95889783e-02f, 2.01359436e-01f, -1.27917096e-01f, -1.59409314e-01f,
  1.41163161e-02f, 2.40985721e-01f, -3.30916435e-01f, -2.59239018e-01f, -5.90266399e-02f, 3.98124866e-02f, 2.96032012e-01f, -3.89351957e-02f, -1.40739858e-01f, 7.12925196e-02f,
  1.50651693e-01f, 1.66802362e-01f, -2.84906894e-01f, 2.48127073e-01f, -2.36525714e-01f, -2.75681973e-01f, -9.60551649e-02f, -2.79736847e-01f, 1.60853773e-01f, -1.16943419e-01f,
  -2.61196613e-01f, 2.75508523e-01f, -2.73056895e-01f, -2.02943802e-01f, -2.33746797e-01f, 2.24266544e-01f, 2.72252530e-01f, 1.71232633e-02f, 1.75962165e-01f, -1.36283919e-01f,
  -2.57044006e-02f, 1.34819448e-01f, 1.35076880e-01f, 1.13841109e-02f, 1.27708703e-01f, -2.49691140e-02f, -5.52541688e-02f, -1.15986280e-02f, 1.55573636e-01f, -1.69515178e-01f,
  3.25359823e-03f, -4.87941802e-02f, -1.92273393e-01f, 1.52964205e-01f, -2.20949918e-01f, 2.44467221e-02f, -8.11642483e-02f, 2.52840668e-01f, 5.63745983e-02f, 2.79314816e-01f,
  1.99960604e-01f, 8.87001976e-02f, 3.30551893e-01f, 4.53653373e-02f, 2.28751034e-01f, 4.97825369e-02f, 1.82347875e-02f, 1.30874798e-01f, 6.40386194e-02f, -1.00349091e-01f,
  3.39625061e-01f, -2.54435629e-01f, 3.18184286e-01f, 1.06150240e-01f, -1.46714464e-01f, -1.13640481e-03f, 2.10761875e-01f, -1.46627411e-01f, -2.66319782e-01f, -1.16341911e-01f,
  -2.84018576e-01f, -4.56981082e-03f, 1.69279084e-01f, -1.30033605e-02f, 7.17651471e-03f, -2.76518539e-02f, 1.86160415e-01f, 2.14772269e-01f, 3.45765874e-02f, 5.58709763e-02f,
  5.52205518e-02f, 1.38989007e-02f, 8.49626735e-02f, 1.12509660e-01f, 1.93618074e-01f, 9.20522064e-02f, 4.21368293e-02f, 1.05704710e-01f, 1.09545007e-01f, -5.73379584e-02f,
  1.57059357e-01f, 4.02484387e-02f, -2.22831778e-02f, 3.45565863e-02f, 1.08996078e-01f, -2.53574904e-02f, 1.15697002e-02f, 2.20457360e-01f, 9.11314785e-03f, 1.22515760e-01f,
  5.19016869e-02f, 5.95138185e-02f, -9.32742208e-02f, 2.12634072e-01f, 4.26959470e-02f, 1.05293624e-01f, 9.55704972e-02f, 4.19409834e-02f, -4.07077707e-02f, 1.41584352e-01f,
  -2.68694852e-03f, 8.53203759e-02f, 1.44921988e-01f, 1.13407314e-01f, 3.84421200e-02f, 2.63604019e-02f, -3.98766249e-02f, -3.68701555e-02f, 2.25391582e-01f, 1.94283843e-01f,
  1.96723044e-01f, 6.29650429e-02f, -7.24039273e-03f, 2.10579634e-01f, 3.02898377e-01f, -8.33761171e-02f, 1.27067015e-01f, 4.24892269e-02f, -1.01525396e-01f, -9.15221050e-02f,
  -2.45703548e-01f, 1.26588985e-01f, -1.08205885e-01f, 1.44144729e-01f, -2.20819131e-01f, -1.69871971e-01f, -7.03566372e-02f, -6.03730530e-02f, -4.00533862e-02f, 1.40324712e-01f,
  2.51903176e-01f, -1.89812839e-01f, -2.67607093e-01f, 1.67343363e-01f, -1.24990411e-01f, 9.04320565e-04f, -1.52606413e-01f, 1.45890946e-02f, 3.20960283e-01f, -2.47329250e-01f,
  1.40026761e-02f, 2.66124904e-02f, 1.45168990e-01f, -1.93052322e-01f, 4.26361263e-02f, -1.64102212e-01f, -2.82096982e-01f, 2.15097889e-01f, 4.53745499e-02f, 2.51023024e-01f,
  2.77552870e-03f, 2.86465675e-01f, -3.16378335e-03f, -3.30262154e-01f, 2.23845959e-01f, 1.33519217e-01f, -1.22423299e-01f, 3.00815791e-01f, -1.24590240e-01f, -2.04033270e-01f,
  -1.22389972e-01f, 6.42666593e-02f, -2.34839857e-01f, 3.31632972e-01f, 1.20871805e-01f, 1.87294990e-01f, 2.51737177e-01f, 1.28210708e-01f, -2.79976070e-01f, -2.24582940e-01f,
  1.51390452e-02f, 3.15640032e-01f, -1.27234057e-01f, 2.89942861e-01f, 2.65725683e-02f, -3.53051782e-01f, -1.54900700e-01f, -1.36979461e-01f, 2.52697915e-01f, -1.23128016e-02f,
  2.59060711e-01f, 2.53810018e-01f, 1.75682336e-01f, -2.56568519e-03f, 1.20295264e-01f, -1.74596354e-01f, 4.97129187e-02f, -4.48864046e-03f, -9.64825749e-02f, -2.26001069e-01f,
  -9.35860053e-02f, 8.48488361e-02f, 7.39527270e-02f, 1.49867922e-01f, 1.77828968e-01f, 1.67462423e-01f, 4.64642158e-04f, 2.02187985e-01f, 2.09230840e-01f, 1.80361524e-01f,
  2.10487485e-01f, 6.20538294e-02f, 1.15771525e-01f, 2.13722587e-01f, 3.63982245e-02f, 2.45931447e-01f, 8.16259682e-02f, -1.57986492e-01f, 4.37333174e-02f, 1.81377724e-01f,
  5.37571236e-02f, 1.25420138e-01f, 1.23731777e-01f, -6.91454262e-02f, -2.21311357e-02f, 3.79754193e-02f, 1.31239807e-02f, 2.82320082e-01f, 1.44565344e-01f, -2.69874968e-02f,
  -1.72362432e-01f, 1.71822116e-01f, -1.68484566e-03f, 4.79054600e-02f, 1.99403331e-01f, 2.19598264e-01f, 1.15819149e-01f, -6.60276506e-03f, 1.77517887e-02f, 1.61089465e-01f,
  3.33181508e-02f, 2.44511843e-01f, 7.84398541e-02f, -6.37338534e-02f, 1.86880641e-02f, 6.65820464e-02f, -1.77731086e-02f, 2.96474785e-01f, 1.73973665e-01f, 1.07321493e-01f,
  1.90484989e-02f, -2.14784592e-01f, -9.68941078e-02f, -1.33935690e-01f, 2.65484691e-01f, -6.30725026e-02f, -1.14759728e-01f, -2.63919652e-01f, -2.81638086e-01f, -2.16852024e-01f,
  -3.79336327e-02f, 2.09708840e-01f, -1.91099346e-01f, -5.74280247e-02f, 1.77801415e-01f, 3.62860486e-02f, -2.28682220e-01f, 1.76918924e-01f, -1.64894581e-01f, -2.50908345e-01f,
  -5.91099635e-02f, 2.56699711e-01f, -2.18913108e-01f, 1.80748869e-02f, 2.42096752e-01f, 3.70096326e-01f, -4.51136120e-02f, 2.12391376e-01f, -1.39361814e-01f, 1.16430512e-02f,
  -1.99013114e-01f, 7.31777539e-03f, -1.90078378e-01f, -1.49967417e-01f, -1.30237117e-01f, 2.28340015e-01f, 5.45812361e-02f, 3.36564332e-01f, 1.16499767e-01f, -9.43830758e-02f,
  3.92527580e-01f, -7.98719376e-03f, -1.53593704e-01f, 3.10705036e-01f, 2.61599302e-01f, 1.38184726e-01f, -1.13421477e-01f, 6.31230846e-02f, 1.51775241e-01f, -2.57894993e-01f,
  2.00446010e-01f, 1.61300525e-01f, -7.24464729e-02f, 1.64007500e-01f, 2.90224731e-01f, 1.91432592e-02f, -9.03275609e-02f, 3.26633900e-01f, 1.91534609e-01f, -1.41667023e-01f,
  5.21422438e-02f, -3.70926231e-01f, 2.98914492e-01f, 4.20024872e-01f, 1.54882535e-01f, 7.08605424e-02f, 3.02841365e-01f, -2.10196093e-01f, 1.51089594e-01f, -1.40503734e-01f,
  2.30318546e-01f, 2.63276726e-01f, 4.15997207e-02f, -1.17807627e-01f, 4.34231818e-01f, 3.09049189e-01f, -5.56516685e-02f, -1.86609313e-01f, -1.28339017e-02f, 8.10880139e-02f,
  6.96919709e-02f, 7.45164305e-02f, 1.21204734e-01f, 5.38983159e-02f, 6.29946962e-02f, 8.25180709e-02f, 5.08763045e-02f, 2.25857235e-02f, 5.04447743e-02f, -3.35596092e-02f,
  -5.97035065e-02f, 3.18216756e-02f, 1.62653141e-02f, -2.87050549e-02f, 1.17336825e-01f, 1.61043540e-01f, -4.27170880e-02f, -1.34958401e-01f, 1.93124339e-02f, 1.37391537e-01f,
  -5.61277494e-02f, 1.40864477e-01f, -7.89391901e-03f, -2.25806236e-02f, 2.13008836e-01f, -6.64160028e-02f, 1.74791381e-01f, -5.68901449e-02f, 8.50132853e-02f, 9.51357745e-03f,
  2.80950591e-02f, 1.45110175e-01f, 7.16097327e-03f, 9.60030630e-02f, 1.40574157e-01f, 2.90176310e-02f, -2.86215567e-03f, 2.18821898e-01f, 1.42649889e-01f, 1.93486944e-01f,
  -1.58628747e-02f, 1.02586232e-01f, 9.67199057e-02f, 5.49085205e-04f, 6.70184046e-02f, -5.96210845e-02f, 5.89170009e-02f, 1.10019647e-01f, 3.89178470e-02f, 2.06380144e-01f,
  1.44523337e-01f, -5.13543747e-03f, -1.02374099e-01f, -4.65317927e-02f, 1.36834145e-01f, 7.61906132e-02f, 2.47048914e-01f, -1.24420069e-01f, -2.94881642e-01f, -1.17373213e-01f,
  -1.68974847e-02f, 2.79210024e-02f, 7.17276260e-02f, -2.45761782e-01f, 2.42770910e-01f, -2.46168718e-01f, 7.61547312e-02f, -1.15578718e-01f, 1.58806983e-02f, 1.30290762e-01f,
  3.18443298e-01f, -5.76773472e-02f, -1.90232843e-01f, 9.36185271e-02f, 1.59443840e-01f, 2.08041333e-02f, 7.55775347e-02f, 1.58125132e-01f, 2.16761038e-01f, -2.13611498e-01f,
  2.23473221e-01f, -1.10871151e-01f, 3.85234728e-02f, 5.86849749e-02f, -3.54555435e-02f, -2.45017722e-01f, -2.24813387e-01f, 2.58013725e-01f, -5.31077087e-02f, 2.00502813e-01f,
  -1.42133161e-01f, -4.94339392e-02f, -1.13159247e-01f, -3.10808010e-02f, -1.28448322e-01f, -2.12208033e-01f, 8.98854285e-02f, -3.36910099e-01f, 9.39867347e-02f, 1.84820257e-02f,
  1.40975147e-01f, 1.33846357e-01f, -6.03511781e-02f, 3.37249301e-02f, 6.69149086e-02f, -1.75634772e-02f, 2.78119985e-02f, -3.67392302e-02f, -1.62782222e-01f, 8.74618515e-02f,
  -7.70340860e-02f, 8.61037523e-02f, 2.44926825e-01f, 1.95448831e-01f, -1.84197515e-01f, 1.48848355e-01f, -9.40353330e-03f, -7.57140247e-03f, 7.84281343e-02f, 1.60096765e-01f,
  2.33681813e-01f, 2.59911597e-01f, 1.54285446e-01f, 5.16207628e-02f, 1.19068928e-01f, 3.45983922e-01f, 5.98836392e-02f, 5.79548106e-02f, 1.62716553e-01f, -2.76112184e-02f,
  1.50979236e-01f, 7.08765835e-02f, 1.00960746e-01f, -8.33906829e-02f, -2.34929454e-02f, 1.08570494e-01f, 4.74389195e-02f, 2.26171255e-01f, -1.01027258e-01f, 1.27638921e-01f,
  2.45575532e-01f, 2.13594884e-01f, 1.85219824e-01f, 1.54863462e-01f, 1.82041954e-02f, -1.20407186e-01f, 2.21385151e-01f, 2.18650177e-02f, 2.81480756e-02f, 1.29943579e-01f,
  7.99808502e-02f, 3.69831622e-02f, 1.58130929e-01f, 4.07445896e-03f, 7.41549907e-03f, 9.61514935e-02f, 1.87960610e-01f, 6.95386380e-02f, -6.49940744e-02f, 8.75683650e-02f,
  2.75627553e-01f, 1.26152888e-01f, 2.70752728e-01f, -6.95241615e-02f, 5.63154221e-02f, 9.88040045e-02f, 2.32430950e-01f, 1.46587923e-01f, 7.75550902e-02f, 1.19348794e-01f,
  1.76651366e-02f, 1.00961722e-01f, 1.95985004e-01f, 3.71555332e-03f, 1.91056013e-01f, -4.02811170e-02f, -8.30816198e-03f, 2.29263812e-01f, -1.62954077e-01f, -7.10694715e-02f,
  3.21068525e-01f, -2.00715467e-01f, 1.86057597e-01f, 2.27860630e-01f, 2.87490249e-01f, 1.46350861e-01f, 1.31948084e-01f, -2.99639583e-01f, -4.41537440e-01f, -1.91373155e-02f,
  3.00409645e-01f, -1.76194176e-01f, 1.03727207e-01f, -7.55039454e-02f, -1.20224012e-02f, -3.55455518e-01f, 2.40632176e-01f, 4.08192605e-01f, 2.12801382e-01f, 5.24242260e-02f,
  -2.06267536e-01f, -9.94784944e-03f, 1.92542732e-01f, 2.65144646e-01f, 9.52877402e-02f, 1.68477803e-01f, 2.32726723e-01f, -2.26293821e-02f, 2.24633723e-01f, -2.14665025e-01f,
  -4.10738915e-01f, 1.42128229e-01f, 2.01630041e-01f, 2.38611102e-02f, -4.10460681e-01f, 2.03207821e-01f, 2.02097278e-02f, 4.01724800e-02f, 1.52154535e-01f, -3.40020061e-02f,
  -2.41634369e-01f, 2.66657233e-01f, -3.01907599e-01f, -1.85143769e-01f, 1.91088617e-01f, -2.30138063e-01f, -1.01129957e-01f, -6.54764622e-02f, 3.52721900e-01f, 9.20384526e-02f,
  -2.60333955e-01f, -1.42967820e-01f, 2.01825642e-05f, -3.02580178e-01f, -1.59558758e-01f, -2.15255722e-01f, 1.32522151e-01f, -1.79321602e-01f, -2.29778606e-02f, 5.86272702e-02f,
  2.41770558e-02f, 8.35468620e-02f, -3.09501946e-01f, 6.63553253e-02f, 3.52906473e-02f, 1.02931425e-01f, 4.62072343e-01f, -2.89163888e-01f, 1.15271043e-02f, 2.18553305e-01f,
  1.94275409e-01f, 4.32251215e-01f, 1.38994381e-01f, 1.84702456e-01f, -3.37752025e-03f, 1.27707034e-01f, 2.19496727e-01f, 1.54322190e-02f, 8.59810933e-02f, 2.27014925e-02f,
  1.44525290e-01f, 8.53311121e-02f, 1.18853124e-02f, 1.16405502e-01f, -2.65450459e-02f, -6.06808178e-02f, 1.08159922e-01f, 9.54606012e-02f, 1.37996171e-02f, -1.84888802e-02f,
  1.08547799e-01f, -6.66969083e-03f, -3.67743894e-02f, 1.70744896e-01f, 5.56808859e-02f, 3.37948166e-02f, 6.65711239e-02f, 3.10522523e-02f, 1.11543559e-01f, -6.06277660e-02f,
  3.09934514e-03f, 1.39558032e-01f, 1.57925189e-02f, 8.12098607e-02f, 8.96059945e-02f, -9.86241363e-03f, 1.36143014e-01f, 1.10896051e-01f, 4.28599752e-02f, 6.14268780e-02f,
  1.54171154e-01f, 5.76230139e-02f, 6.82714581e-02f, 4.06016000e-02f, -6.15247488e-02f, 5.91170602e-02f, 2.50818171e-02f, 1.63875092e-02f, 5.46773747e-02f, 1.30336329e-01f,
  -1.67260319e-02f, 4.95107472e-02f, 8.40247199e-02f, 1.38720676e-01f, 3.45948078e-02f, -1.77977875e-01f, -1.89452156e-01f, 1.86490446e-01f, 9.22033787e-02f, -1.08782724e-01f,
  2.15336934e-01f, -1.29174426e-01f, 1.89307585e-01f, -3.42141930e-03f, 1.55635267e-01f, -4.89833318e-02f, 5.77607825e-02f, -2.23800670e-02f, 6.86292872e-02f, -7.88272023e-02f,
  1.20680839e-01f, -5.17549887e-02f, -6.15899786e-02f, -9.90495458e-02f, 5.18976487e-02f, -3.22825164e-02f, -1.02481894e-01f, 3.33375931e-02f, -7.79177668e-03f, 6.33100048e-02f,
  -2.11412549e-01f, -1.67617202e-02f, 3.31358463e-02f, 1.18860096e-01f, -3.05658262e-02f, 1.04731724e-01f, -4.83622402e-02f, 2.79807877e-02f, 5.36194630e-02f, 4.65293452e-02f,
  1.38793945e-01f, -1.03009373e-01f, 4.99686450e-02f, -1.77130282e-01f, -8.33715796e-02f, 6.91199377e-02f, -1.31433398e-01f, -4.45971228e-02f, -4.47887965e-02f, 4.71452624e-03f,
  1.62729546e-01f, 3.11756302e-02f, 6.42917231e-02f, -1.06357699e-02f, 3.39083642e-01f, -9.20362845e-02f, 1.41192958e-01f, -1.68706954e-01f, -8.89016017e-02f, -6.62603006e-02f,
  3.53445679e-01f, 2.99316645e-01f, 2.51171645e-02f, -1.46058053e-01f, 2.18996525e-01f, -1.68851390e-02f, 2.41983354e-01f, 9.29193422e-02f, -4.31600437e-02f, 1.20318588e-02f,
  -6.78118616e-02f, 1.48870677e-01f, -2.37387761e-01f, -3.14827934e-02f, 1.55304462e-01f, 2.20407248e-01f, -1.01204738e-01f, -1.69230819e-01f, 2.83173710e-01f, 3.11327934e-01f,
  9.70496163e-02f, 1.22621700e-01f, -5.29617332e-02f, 1.81616440e-01f, 1.31524131e-01f, 1.25628963e-01f, -1.38454454e-03f, 1.07814848e-01f, 4.17826697e-02f, 2.41149813e-01f,
  -4.13520783e-02f, 1.14369631e-01f, 7.84240067e-02f, 3.71254124e-02f, 7.52066970e-02f, 7.40755498e-02f, 2.03757063e-01f, 1.15234859e-01f, 3.17923427e-02f, 1.11332089e-01f,
  -3.01271453e-02f, 1.19994201e-01f, 3.41237374e-02f, 1.26586840e-01f, 6.79490641e-02f, 1.07661828e-01f, 1.63535967e-01f, 4.14696969e-02f, 7.34345615e-02f, 8.96071419e-02f,
  5.60145266e-02f, 7.83024356e-03f, 9.58460942e-02f, 2.50767600e-02f, 8.73309225e-02f, 1.58306271e-01f, 6.86937347e-02f, 1.68088675e-01f, 4.33096513e-02f, 4.55871597e-02f,
  1.10516706e-02f, 7.09555969e-02f, 1.33109003e-01f, -2.78388280e-02f, 1.03721566e-01f, 9.75886285e-02f, 1.95529878e-01f, 1.77048281e-01f, 1.65849745e-01f, -2.51456089e-02f,
  7.29640573e-02f, 3.67109687e-03f, 1.84177041e-01f, 8.66276398e-02f, -2.46575162e-01f, -1.11442067e-01f, -5.07147051e-02f, -2.75191851e-02f, -2.49078244e-01f, -6.12808987e-02f,
  9.82678756e-02f, 2.95698315e-01f, 1.19552091e-01f, 2.27369830e-01f, 7.26398602e-02f, 1.93002582e-01f, 1.86654061e-01f, 2.21488491e-01f, -8.73339027e-02f, -2.34264016e-01f,
  -1.59424067e-01f, -4.98906188e-02f, 3.40009719e-01f, -4.30323072e-02f, 2.02178985e-01f, 2.24649847e-01f, -7.67351091e-02f, -9.41040292e-02f, -1.48323968e-01f, 3.02840889e-01f,
  3.29682320e-01f, 7.06536472e-02f, 4.51417491e-02f, 1.35900155e-01f, -2.77111024e-01f, 2.53878593e-01f, -2.72547901e-02f, 8.60677510e-02f, 2.08412588e-01f, -1.00803040e-02f,
  -1.15387984e-01f, 1.59525082e-01f, -4.40627038e-02f, 2.86230326e-01f, 9.61124524e-02f, -2.24875703e-01f, -8.29865877e-03f, -1.78663895e-01f, -1.09878384e-01f, 9.51685458e-02f,
  1.69897646e-01f, -1.15865357e-01f, -3.59676890e-02f, -1.63681179e-01f, 3.04168254e-01f, -2.68284917e-01f, -1.15497619e-01f, 5.47812879e-02f, -2.68537581e-01f, 2.44320974e-01f,
  -4.34220731e-02f, 8.96292403e-02f, -1.25777245e-01f, 3.64731182e-03f, -8.73420164e-02f, 1.63229212e-01f, 2.74184775e-02f, 2.64404327e-01f, 5.55655360e-02f, 7.69442469e-02f,
  -3.59730780e-01f, 1.97951794e-01f, 1.16367005e-01f, 8.38563666e-02f, -1.08670697e-01f, -1.67451035e-02f, -5.08040236e-03f, -8.27421248e-02f, 2.91115493e-01f, 5.34432605e-02f,
  7.11193681e-02f, 1.33437976e-01f, 6.09282628e-02f, 7.09397271e-02f, 2.79960502e-02f, -3.18149733e-03f, 2.34737974e-02f, 1.25234544e-01f, -2.37914198e-03f, 1.50045633e-01f,
  -8.00103992e-02f, -2.43102405e-02f, 3.13942172e-02f, 5.18441461e-02f, 1.53451234e-01f, 7.46529475e-02f, 1.05305575e-01f, -3.78762856e-02f, 1.15463942e-01f, 1.12975620e-01f,
  8.28725472e-02f, 3.04786712e-02f, -1.97813641e-02f, -1.55880405e-02f, 1.37153655e-01f, 4.58292849e-02f, 3.45893838e-02f, 1.16976090e-01f, 4.89502475e-02f, 7.77178183e-02f,
  1.90933526e-01f, 7.57400990e-02f, 2.32414529e-02f, -2.57933401e-02f, -4.79131304e-02f, 2.22739458e-01f, 9.32192802e-02f, 7.35995686e-03f, -5.53067252e-02f, 9.71019492e-02f,
  -5.68934567e-02f, -4.36783172e-02f, -4.67830412e-02f, 4.02130410e-02f, 5.31272814e-02f, 1.12260319e-01f, 2.70912666e-02f, 1.01594187e-01f, 1.24319211e-01f, 1.33798257e-01f,
  1.38691157e-01f, -1.74571157e-01f, -2.74738401e-01f, 1.11999840e-01f, 2.88415313e-01f, -2.70401359e-01f, 9.27030016e-03f, -2.25701854e-01f, -1.43946841e-01f, -9.85534266e-02f,
  8.26034397e-02f, 5.61641306e-02f, -3.68240029e-02f, -9.53206494e-02f, 1.48145095e-01f, -4.13576737e-02f, 6.76890761e-02f, -6.21194392e-02f, -2.27519318e-01f, -4.43130881e-02f,
  2.91639604e-02f, -1.19613826e-01f, -1.24132738e-01f, 2.06082333e-02f, 1.47180945e-01f, 9.22941193e-02f, -1.59814194e-01f, 2.60466605e-01f, -4.60101888e-02f, 1.71905041e-01f,
  -5.51683456e-02f, -2.95044412e-03f, 1.91942155e-02f, 6.27336651e-02f, -2.12960765e-01f, -2.70687610e-01f, -8.73541739e-03f, -5.46259061e-02f, -4.66563106e-02f, -2.32063293e-01f,
  -2.01324211e-03f, 2.13051274e-01f, -2.73614615e-01f, -1.78036928e-01f, 2.77470760e-02f, -1.50633812e-01f, 7.62012675e-02f, 3.97963449e-02f, 8.14854447e-03f, 5.57419211e-02f,
  1.40526742e-01f, -7.62237534e-02f, 1.17469266e-01f, -9.33287144e-02f, 2.23488174e-03f, -2.92733125e-02f, -7.84720236e-04f, 1.73786432e-01f, 5.04738875e-02f, 4.74606976e-02f,
  4.29308414e-02f, -1.58799410e-01f, 2.75021838e-03f, 6.24034852e-02f, -4.54651192e-02f, 1.78364858e-01f, -4.88348752e-02f, 8.87642726e-02f, -3.25439483e-01f, 1.95260629e-01f,
  1.20189972e-01f, 1.71093509e-01f, -7.48833641e-02f, -1.59483194e-01f, 2.70154238e-01f, 2.75799125e-01f, 1.82349369e-01f, -4.29872125e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  6.93077734e-03f, 1.45590812e-01f, 9.19486657e-02f, 1.30935445e-01f, 5.89194447e-02f, 1.42085794e-02f, 6.34771809e-02f, 9.88870710e-02f, 5.02047837e-02f, 5.66839054e-03f,
  -3.83328530e-03f, 4.11288068e-02f, 5.26893102e-02f, 1.18349917e-01f, 5.12730591e-02f, 5.97322918e-02f, 7.25618303e-02f, 5.54808490e-02f, 1.25530958e-01f, 1.50252596e-01f,
  1.19440898e-01f, 1.26900718e-01f, 1.40369430e-01f, 7.43504167e-02f, 1.53319359e-01f, -1.52714150e-02f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  3.23726349e-02f, 3.07240465e-04f, -3.32729379e-03f, -6.07355088e-02f, -1.91321582e-01f, -1.23576246e-01f, -4.40934673e-03f, 4.95548323e-02f, 1.54044539e-01f, 5.19825965e-02f,
  1.16960034e-02f, -5.24826609e-02f, -2.43335664e-01f, -1.26758605e-01f, 2.66424902e-02f, -1.44282997e-01f, -2.33049303e-01f, 8.42248648e-03f, 9.04870182e-02f, -8.79791901e-02f,
  -8.32120180e-02f, -6.45793229e-02f, 9.22621489e-02f, -8.63574743e-02f, 1.31453469e-01f, 1.10786393e-01f, 1.48115233e-01f, 1.05465010e-01f, -7.57716000e-02f, -1.86917767e-01f,
  -2.56273188e-02f, 5.51588163e-02f, -1.26732543e-01f, 6.45003170e-02f, 8.31598267e-02f, 7.62872323e-02f, -1.89940240e-02f, -5.97383678e-02f, 1.12668745e-01f, 2.91221011e-02f,
  -1.68590724e-01f, -7.49470294e-02f, -1.50347501e-01f, 7.83186480e-02f, 8.84723142e-02f, 1.11227512e-01f, 2.76043676e-02f, 1.20271735e-01f, -5.89754619e-02f, 8.17286149e-02f,
  8.20828527e-02f, 9.90467146e-02f, 1.35097876e-01f, -2.07448781e-01f, 2.07643360e-01f, -1.90306395e-01f, -1.14519671e-01f, 2.49328688e-01f, 1.19410545e-01f, -9.60339233e-02f,
  3.78836334e-01f, 2.76930690e-01f, -2.52540886e-01f, 1.75108001e-01f, 2.46037737e-01f, -2.17853524e-02f, -8.06943029e-02f, 1.83895811e-01f, 1.57993630e-01f, 3.65539879e-01f,
  -3.25371623e-01f, 3.26329201e-01f, 1.18473850e-01f, -2.45309070e-01f, -1.15498707e-01f, -1.92742124e-01f, 8.12773034e-02f, 9.38372388e-02f, 2.80794472e-01f, -2.23728999e-01f,
  -1.77262858e-01f, 3.28701027e-02f, -1.94845676e-01f, -1.29459858e-01f, 5.58224991e-02f, -9.59740952e-02f, 3.19231302e-01f, 1.48294225e-01f, 1.57279745e-01f, 7.43633648e-03f,
  2.24471927e-01f, -1.45497859e-01f, -2.09264532e-01f, -1.55266806e-01f, -2.26905018e-01f, -5.62716536e-02f, -1.45989090e-01f, -1.95416614e-01f, 1.12405621e-01f, 1.77754372e-01f,
  -1.98076442e-02f, -2.50710070e-01f, 1.08613767e-01f, -2.35096827e-01f, -2.16254920e-01f, -3.40779960e-01f, -3.46755296e-01f, -5.07514179e-01f, 1.97012156e-01f, -2.54565507e-01f,
  2.99056590e-01f, -8.77005309e-02f, -4.11526978e-01f, 9.78612229e-02f, 1.94335639e-01f, -1.72882542e-01f, 1.19730152e-01f, -3.86227518e-01f, -2.65891440e-02f, 2.79588729e-01f,
  -1.76113710e-01f, 1.57340288e-01f, 2.41615355e-01f, -3.48748833e-01f, -4.10616875e-01f, -3.51596773e-02f, -2.00499877e-01f, -1.65942218e-02f, 3.64388116e-02f, -1.27802208e-01f,
  1.46541625e-01f, -8.52901042e-02f, 1.44625172e-01f, -5.39640971e-02f, 1.69889167e-01f, -5.28929122e-02f, -2.66485009e-02f, 6.74987659e-02f, -5.38807884e-02f, -1.51958495e-01f,
  5.68972640e-02f, 1.01397835e-01f, 1.15081973e-01f, -1.44658580e-01f, 6.72478899e-02f, -2.24721357e-02f, 4.60227281e-02f, 4.57961150e-02f, 1.57058299e-01f, -1.06338263e-01f,
  -7.43360296e-02f, 1.86149463e-01f, 2.48401016e-02f, 1.54199824e-01f, -5.83101436e-02f, 8.75189379e-02f, -6.30709380e-02f, 1.18824027e-01f, -6.67862669e-02f, 7.75018781e-02f,
  1.45055249e-01f, 1.22221880e-01f, 3.24980728e-02f, -4.76420522e-02f, -6.94467276e-02f, -6.91544861e-02f, 1.56061858e-01f, 1.28876895e-01f, 1.43216759e-01f, 1.17689297e-01f,
  6.00570440e-02f, -5.03378548e-02f, -1.61428213e-01f, -8.31399336e-02f, 7.11754784e-02f, -2.18954936e-01f, 7.55155459e-02f, -7.73553997e-02f, 3.22451368e-02f, 1.25330910e-01f,
  -2.89157629e-01f, -7.22988322e-02f, 2.11557552e-01f, 2.45409653e-01f, -1.35246545e-01f, 2.29367465e-01f, 1.46581814e-01f, -2.36776680e-01f, -1.63179129e-01f, 3.05754006e-01f,
  -4.59973626e-02f, 2.44590566e-01f, 2.57511944e-01f, 1.15588114e-01f, 1.12393953e-01f, -6.73677325e-02f, 2.25035086e-01f, -2.82042511e-02f, 9.54760686e-02f, -1.08232416e-01f,
  4.62678298e-02f, -1.67509332e-01f, -2.08873674e-01f, 1.78911448e-01f, -1.38601318e-01f, 1.51127070e-01f, -2.00082630e-01f, -2.56653219e-01f, -1.38582543e-01f, -1.90624490e-01f,
  3.10679018e-01f, 3.02193128e-03f, -2.83376664e-01f, 2.22477958e-01f, -2.19039068e-01f, 1.20760880e-01f, 2.35145614e-01f, -1.53595254e-01f, -4.50004684e-03f, -3.03340942e-01f,
  -5.39587922e-02f, 9.08557326e-02f, -1.59741491e-01f, -8.30878019e-02f, -7.84877539e-02f, -2.68254697e-01f, -4.80025448e-02f, 2.96528280e-01f, 2.77409732e-01f, 2.38995135e-01f,
  6.21424429e-03f, -1.30592827e-02f, -2.21466541e-01f, 1.98502213e-01f, -1.20659813e-01f, 6.08187057e-02f, -2.87856936e-01f, 9.73492712e-02f, -2.56970942e-01f, 1.95378244e-01f,
  -3.16554546e-01f, -3.95232923e-02f, -1.73770547e-01f, 1.94348931e-01f, -9.92689654e-02f, -3.48534882e-01f, -8.35248470e-01f, 3.60875636e-01f, -1.70655638e-01f, 1.77705094e-01f,
  1.37726232e-01f, 1.98594123e-01f, 1.29419029e-01f, 1.16523206e-02f, -2.79192477e-01f, -2.21526679e-02f, 1.43827587e-01f, 4.77571674e-02f, -6.72829151e-02f, 4.62621152e-02f,
  -2.66967490e-02f, 3.61678414e-02f, -8.61795843e-02f, 4.94210236e-02f, -1.83527300e-03f, -1.46685243e-01f, 7.67891249e-03f, -6.95572272e-02f, -7.95697197e-02f, -7.60830194e-03f,
  4.63021584e-02f, -7.46968538e-02f, 2.33636070e-02f, -8.64437968e-02f, -7.80266300e-02f, 1.08366363e-01f, 5.94116561e-02f, -4.22182865e-02f, -1.09038897e-01f, -1.10572249e-01f,
  -6.69715255e-02f, 1.07841775e-01f, 2.43247822e-02f, 8.06143954e-02f, 1.15979776e-01f, -8.69328231e-02f, -9.90192667e-02f, -1.92665264e-01f, -1.09885983e-01f, 7.87496269e-02f,
  5.96017390e-02f, -3.71105410e-02f, 3.06652114e-03f, 6.44916296e-02f, -6.25380874e-02f, -2.28888597e-02f, -1.02406755e-01f, 4.81312871e-02f, -7.85724968e-02f, -6.75375462e-02f,
  1.32552072e-01f, -1.42990410e-01f, -1.46677151e-01f, 6.34688064e-02f, 1.12378955e-01f, 7.03729093e-02f, -1.66572660e-01f, 4.83377418e-03f, -8.46991017e-02f, 2.01930761e-01f,
  2.05606326e-01f, 6.09636009e-02f, 2.48825237e-01f, -1.98227346e-01f, -4.41607796e-02f, -1.41814828e-01f, -8.99072438e-02f, 2.23345324e-01f, -1.90513611e-01f, -2.20572665e-01f,
  -1.75466374e-01f, 1.07998960e-01f, 1.46988645e-01f, -1.49542138e-01f, -1.06626175e-01f, -1.42592475e-01f, -8.14877450e-04f, -3.45240310e-02f, 1.79863930e-01f, -2.01729611e-01f,
  1.51280984e-01f, -2.44241226e-02f, 3.28466506e-03f, 2.52972841e-01f, 7.92474858e-03f, -8.02058801e-02f, -2.59431154e-01f, 3.36919338e-01f, 1.45501137e-01f, 1.74586177e-01f,
  -2.41547674e-01f, 1.40834987e-01f, -1.45128936e-01f, 1.85422882e-01f, -4.03956696e-02f, 6.03080355e-03f, -2.54682004e-01f, 1.44285381e-01f, 2.06415430e-01f, -1.68994084e-01f,
  -1.54636681e-01f, 1.00321285e-01f, -1.76072672e-01f, -1.70509487e-01f, -2.14900151e-02f, -2.26544991e-01f, 2.47119531e-01f, 1.07895210e-01f, -5.15444815e-01f, 1.79807931e-01f,
  -2.25592386e-02f, -3.01405370e-01f, 1.71015874e-01f, -4.66510534e-01f, -2.38272294e-01f, 1.34002835e-01f, -1.88041463e-01f, 1.11385033e-01f, -3.01358759e-01f, 2.39322130e-02f,
  -2.79677510e-01f, 1.74837142e-01f, -3.07459950e-01f, -2.63138175e-01f, 2.15695262e-01f, -4.23928708e-01f, -1.84545910e-03f, -2.67630965e-01f, -3.32208760e-02f, -9.80073884e-02f,
  1.99892357e-01f, 1.71401709e-01f, -3.06652546e-01f, 2.21183285e-01f, -2.23417103e-01f, 9.26811695e-02f, -1.58236936e-01f, 4.60038781e-02f, 6.53809905e-02f, -7.96473622e-02f,
  7.42705688e-02f, 1.27802819e-01f, 5.53444736e-02f, 1.98964421e-02f, -1.29867107e-01f, -1.68732498e-02f, 6.69853315e-02f, -1.84747636e-01f, -1.72867775e-01f, -1.51948944e-01f,
  6.99723959e-02f, 5.93042038e-02f, 2.74173468e-02f, -8.75047892e-02f, -1.30440459e-01f, -2.30343435e-02f, -1.08148210e-01f, -1.04575090e-01f, -4.32431251e-02f, -1.75873086e-01f,
  -5.09054819e-03f, -1.35731593e-01f, 1.43108228e-02f, -5.13560176e-02f, 3.46200913e-02f, -1.56656906e-01f, 4.89438958e-02f, -1.74528822e-01f, -6.84687272e-02f, 5.49281202e-03f,
  -2.91178729e-02f, 6.73376620e-02f, -1.21063523e-01f, -1.96294799e-01f, 3.57280709e-02f, -4.59605455e-02f, 7.04884753e-02f, -8.12905747e-03f, 1.28166065e-01f, -2.09469467e-01f,
  -1.74879521e-01f, 6.07526004e-02f, 1.20879009e-01f, 1.23903491e-01f, -9.21711847e-02f, -9.08827176e-04f, -1.69614211e-01f, -2.18338534e-01f, -1.21422648e-01f, -8.69307443e-02f,
  -1.72326013e-01f, -3.44122022e-01f, -1.68722689e-01f, 1.47833064e-01f, 2.88833857e-01f, -1.18973635e-01f, 2.09549457e-01f, -5.76365180e-02f, 1.77891999e-01f, -5.48679233e-02f,
  -1.33001041e-02f, -1.02115899e-01f, 3.55322093e-01f, 3.18227289e-03f, -2.67161697e-01f, 6.23395033e-02f, -2.90222079e-01f, 2.52047569e-01f, -1.43576518e-01f, 1.53243661e-01f,
  6.69252723e-02f, 6.62531033e-02f, 2.55098015e-01f, -2.94810474e-01f, 2.71277666e-01f, -2.21369386e-01f, -1.06469207e-01f, -3.03958505e-01f, 2.38468021e-01f, -1.91385016e-01f,
  1.65841252e-01f, -3.56605738e-01f, -4.94702570e-02f, -2.13703319e-01f, 1.85855646e-02f, -1.01895638e-01f, -2.98834831e-01f, -4.89352718e-02f, 2.57977545e-01f, 2.06385195e-01f,
  -5.92249818e-03f, 1.70579385e-02f, -3.24345708e-01f, -1.45320385e-03f, -5.28402291e-02f, 1.03537351e-01f, -2.13503674e-01f, -2.48051256e-01f, -1.21144518e-01f, -1.01992175e-01f,
  1.29618317e-01f, 1.62842765e-01f, -6.01702780e-02f, -3.24230045e-01f, 2.63679355e-01f, 1.28454432e-01f, -4.15321365e-02f, -2.53734946e-01f, 1.05445728e-01f, -4.04539052e-03f,
  7.29687214e-02f, 2.37686977e-01f, -9.04274344e-01f, 1.11647949e-01f, -4.17532355e-01f, -2.03709781e-01f, -3.03642720e-01f, 1.66068390e-01f, 4.62179780e-02f, -1.37257144e-01f,
  8.51764381e-02f, -1.66640833e-01f, 1.08492024e-01f, 2.50067506e-02f, 6.88763261e-02f, -9.41336006e-02f, 1.45458244e-03f, 1.18805431e-01f, 1.02090046e-01f, 1.99443772e-01f,
  -1.25428677e-01f, 1.96471259e-01f, -3.43279205e-02f, 1.10549293e-01f, 3.67278494e-02f, 1.55923575e-01f, -8.62085968e-02f, -8.70678276e-02f, 8.75948071e-02f, 1.45241991e-01f,
  9.35392082e-03f, -4.36523836e-03f, -3.05840150e-02f, 2.29350924e-02f, 6.76389262e-02f, 1.70978025e-01f, 2.04690367e-01f, -2.07647219e-01f, -1.58709660e-01f, 1.71670318e-01f,
  -3.66613269e-02f, 4.86963168e-02f, 9.14536268e-02f, -1.53001934e-01f, -3.21623422e-02f, -8.00476819e-02f, -1.10649012e-01f, 6.16702326e-02f, 9.10191517e-03f, 6.78637475e-02f,
  1.93057463e-01f, 1.43958256e-01f, 1.65718377e-01f, -1.87468268e-02f, -1.87797472e-01f, 7.20957145e-02f, -1.23682857e-01f, 1.92047596e-01f, -4.76206243e-02f, -2.74131354e-02f,
  -9.60749239e-02f, -1.44029096e-01f, -2.50485875e-02f, -2.63703346e-01f, 1.67330980e-01f, -2.18594596e-01f, -2.57038832e-01f, -2.13269800e-01f, -8.86815116e-02f, 1.24683313e-01f,
  1.71884298e-01f, 1.94033757e-01f, -2.88183778e-03f, -2.35766470e-01f, 1.06889248e-01f, -6.01183921e-02f, 2.63253469e-02f, -2.42596239e-01f, 1.90501571e-01f, -4.73455898e-02f,
  -2.89183021e-01f, -2.91121989e-01f, -3.43077302e-01f, 1.54160023e-01f, 1.86294064e-01f, 1.23490393e-01f, -2.72025883e-01f, -2.23056357e-02f, 6.51629874e-03f, -1.82579741e-01f,
  -1.44197017e-01f, 2.36878261e-01f, -2.16060743e-01f, 3.16183239e-01f, -2.13799998e-02f, 3.35877463e-02f, -2.41516903e-02f, -2.03309759e-01f, 6.28063157e-02f, -9.93898362e-02f,
  2.47002169e-01f, 2.13835493e-01f, -4.20721099e-02f, -1.58764705e-01f, -1.74403280e-01f, -1.66933835e-01f, -1.82507321e-01f, -1.62401259e-01f, 2.01010555e-01f, 9.21911597e-02f,
  2.53783345e-01f, 2.55161196e-01f, -1.10678568e-01f, -3.69922161e-01f, 8.96549448e-02f, 6.33919165e-02f, 6.89165741e-02f, -4.04353350e-01f, 1.58358216e-01f, 2.56537288e-01f,
  1.24548964e-01f, -1.53745813e-02f, -1.07235089e-01f, -1.64193630e-01f, 1.58211559e-01f, -3.39548260e-01f, 2.40624517e-01f, -8.51253569e-02f, 7.29498863e-02f, -1.29538685e-01f,
  -4.00880992e-01f, -1.84321165e-01f, -1.71922117e-01f, -3.31766248e-01f, 1.45221606e-01f, 4.01789397e-02f, -3.40157926e-01f, 2.05015287e-01f, 2.04808250e-01f, 6.05814233e-02f,
  1.49515420e-01f, 1.39280215e-01f, 7.53204301e-02f, 7.83904865e-02f, 1.24611266e-01f, -3.72221507e-02f, -1.28245562e-01f, -1.56943738e-01f, 8.93104449e-02f, -2.30928119e-02f,
  -3.06562427e-02f, 5.89697994e-02f, 1.05262659e-01f, 2.71699633e-02f, 1.31732985e-01f, 2.02266723e-01f, -2.30749864e-02f, 1.08291239e-01f, 7.83110261e-02f, 1.32612035e-01f,
  -6.29382506e-02f, 2.18017343e-02f, 1.38963342e-01f, 4.35770638e-02f, 7.95404091e-02f, -1.06992781e-01f, -3.28217670e-02f, -9.40057859e-02f, 3.47862169e-02f, 6.72506839e-02f,
  -9.18471664e-02f, -7.80657455e-02f, -1.31358087e-01f, -1.11552663e-02f, 1.20112553e-01f, 2.49707187e-03f, 3.80994752e-02f, 1.86006755e-01f, -1.34178504e-01f, -4.02359143e-02f,
  5.63304238e-02f, -1.45767825e-02f, 1.40072569e-01f, 1.41512081e-01f, -5.76393493e-02f, 1.91530883e-01f, 2.25910805e-02f, -1.90913901e-01f, 9.90886390e-02f, 1.07160792e-01f,
  -2.42838468e-02f, 2.30353177e-01f, 4.16453965e-02f, -1.79430712e-02f, 7.92806000e-02f, -7.70433918e-02f, -2.14162856e-01f, -3.62479351e-02f, 1.03208348e-01f, -7.20546916e-02f,
  -4.69151028e-02f, -3.42189521e-01f, -2.41785049e-01f, 2.44425297e-01f, -3.00111890e-01f, 1.05865687e-01f, 1.79419726e-01f, 2.58015782e-01f, 1.17125049e-01f, 2.99005508e-01f,
  3.18538845e-01f, -1.98281616e-01f, 1.66517094e-01f, 2.72974193e-01f, 2.58747965e-01f, -5.57621643e-02f, 5.80804758e-02f, -2.24633858e-01f, -2.19143182e-01f, 2.13723063e-01f,
  -1.84826538e-01f, -3.36766653e-02f, -1.54334232e-01f, -2.03405067e-01f, 1.50965691e-01f, 6.54569268e-02f, -1.62553787e-01f, 4.32447717e-02f, 9.78263915e-02f, 1.87348828e-01f,
  -2.28539824e-01f, -5.04011661e-02f, -6.47841096e-02f, -1.16549388e-01f, -1.93243086e-01f, -1.52504474e-01f, 1.44530218e-02f, 2.81665355e-01f, 5.11336774e-02f, -2.67173976e-01f,
  3.12249083e-02f, 1.91520989e-01f, 2.39352301e-01f, -9.13216397e-02f, 1.29849762e-01f, -2.67767966e-01f, -3.67494732e-01f, 1.01931512e-01f, -1.64661720e-01f, 4.01870050e-02f,
  1.34221926e-01f, 1.50675252e-01f, 1.71378091e-01f, 1.41303569e-01f, 1.27044618e-01f, 1.12059578e-01f, 1.10836901e-01f, 1.19118661e-01f, -5.58804750e-01f, -1.18869625e-01f,
  2.40355089e-01f, 1.61864385e-01f, -1.55626014e-01f, -7.82700330e-02f, -4.05840635e-01f, -2.53804415e-01f, -3.03018004e-01f, -2.23767087e-01f, 6.33733794e-02f, -1.17523316e-02f,
  4.84912731e-02f, 3.41070704e-02f, 4.76242043e-02f, 5.27383275e-02f, 2.90766824e-03f, 2.56851073e-02f, 8.57139528e-02f, -1.17699683e-01f, 4.28083539e-02f, 2.69200020e-02f,
  -7.53764585e-02f, 5.55743873e-02f, 1.78731419e-03f, -1.79009102e-02f, 6.45389035e-02f, 9.41473171e-02f, 1.18812867e-01f, -1.18069373e-01f, -1.70172695e-02f, 5.13657592e-02f,
  7.44317025e-02f, 3.40108089e-02f, -5.08090369e-02f, -5.24483733e-02f, -1.54105246e-01f, 3.50954309e-02f, -9.07327756e-02f, 5.61305545e-02f, -4.89168093e-02f, 1.81874782e-01f,
  1.65549457e-01f, -1.48829743e-01f, -5.03474846e-02f, 3.03468816e-02f, -1.00464553e-01f, -7.63588697e-02f, 1.26086742e-01f, 1.22832125e-02f, -7.68444687e-02f, 1.16782382e-01f,
  1.42558873e-01f, 1.43288031e-01f, -2.18397025e-02f, 1.40059724e-01f, 1.03372201e-01f, -1.25551879e-01f, -2.10612819e-01f, -1.24436170e-02f, -2.01933414e-01f, 1.44331396e-01f,
  1.05496131e-01f, 1.36230797e-01f, -2.34963223e-01f, 2.16451347e-01f, 2.71820337e-01f, 7.95244649e-02f, 1.67728573e-01f, -3.73599045e-02f, -9.38113481e-02f, -3.08798373e-01f,
  -2.04804495e-01f, -6.52254298e-02f, -9.73278359e-02f, 2.26492718e-01f, -3.48949015e-01f, -2.24722937e-01f, -2.59048283e-01f, 2.19246596e-01f, 1.44172043e-01f, -3.12314749e-01f,
  -3.91241424e-02f, 1.82414398e-01f, 3.56305912e-02f, -6.54605404e-02f, 1.09758317e-01f, -2.12542072e-01f, 1.72715157e-01f, 2.12382168e-01f, 6.52847812e-04f, -1.64619476e-01f,
  8.61327201e-02f, -1.85149074e-01f, 1.90616235e-01f, 2.87826240e-01f, -1.17925219e-01f, -3.37303728e-01f, -2.04634860e-01f, -4.06459942e-02f, -1.31079063e-01f, 1.85433358e-01f,
  -2.53676862e-01f, 2.47983754e-01f, 8.19721166e-03f, 2.70409018e-01f, -1.84082657e-01f, -1.47976473e-01f, 9.59612802e-02f, -1.43978938e-01f, -5.22168614e-02f, 1.43689960e-01f,
  -1.32445410e-01f, 5.49812615e-02f, -8.53258967e-02f, -2.98762023e-01f, 1.16549440e-01f, 4.16050643e-01f, -3.29089135e-01f, 5.11729270e-02f, -2.05312997e-01f, 1.13939844e-01f,
  -1.71266526e-01f, 1.39753744e-01f, -1.69518277e-01f, -1.33156285e-01f, -1.59901857e-01f, 1.85308143e-01f, 3.55014026e-01f, -3.75900120e-01f, 2.66808178e-02f, -3.39695215e-01f,
  -4.72347409e-01f, 1.87551707e-01f, -1.88621834e-01f, 9.59545299e-02f, -1.48202047e-01f, 1.11451680e-02f, 5.15864789e-02f, 2.91569717e-02f, -9.36886668e-02f, 6.01957105e-02f,
  4.70828563e-02f, 4.50845286e-02f, -1.24115519e-01f, -6.02105483e-02f, -1.24995589e-01f, 7.87135810e-02f, 8.38491544e-02f, -1.04861885e-01f, -2.16737539e-02f, -5.94629161e-02f,
  -4.47556674e-02f, -2.72971410e-02f, 9.13026109e-02f, -1.07385509e-01f, -1.11530729e-01f, -3.90939042e-02f, -2.71704351e-03f, 2.39720158e-02f, -2.22403873e-02f, -7.53224790e-02f,
  1.06374167e-01f, 1.44556537e-01f, -8.26577656e-03f, -5.30007705e-02f, 8.80870968e-02f, -1.19177900e-01f, -8.80289674e-02f, -1.04047872e-01f, 6.26868680e-02f, -1.42507683e-02f,
  -1.27621636e-01f, -7.27536529e-02f, -4.68347035e-02f, 5.18230982e-02f, 5.55327609e-02f, 1.84134697e-03f, 4.14493792e-02f, 3.04714087e-02f, -6.94337487e-03f, -6.86436817e-02f,
  -2.24159565e-02f, -9.82194990e-02f, 7.29411393e-02f, 7.37272650e-02f, -3.17931771e-02f, -9.95883346e-02f, 9.86803100e-02f, -1.22111715e-01f, -1.10260800e-01f, -1.51374355e-01f,
  -8.12708586e-02f, -8.92093480e-02f, 1.72721162e-01f, 1.95671767e-01f, 1.38517037e-01f, 8.08077902e-02f, 8.92120898e-02f, 6.39645532e-02f, 1.20375954e-01f, 1.92302708e-02f,
  -1.23478904e-01f, -5.37973158e-02f, 7.40074217e-02f, -1.75568938e-01f, 1.39320165e-01f, -5.08046858e-02f, 2.45915323e-01f, 5.48403673e-02f, -2.38742515e-01f, 1.07246339e-01f,
  1.99718460e-01f, -1.10745408e-01f, -1.98129892e-01f, -1.45343706e-01f, -1.95789039e-01f, 3.13804708e-02f, 2.29421228e-01f, -1.48601964e-01f, -7.45160156e-04f, 6.12192042e-02f,
  -8.82942602e-03f, -6.56100512e-02f, 1.61385894e-01f, -1.57195538e-01f, -8.27252939e-02f, 2.09375575e-01f, 1.47307619e-01f, -9.89952460e-02f, -5.51267043e-02f, 2.53906101e-01f,
  1.33312911e-01f, 1.76156908e-01f, 1.26340389e-01f, 1.67329431e-01f, -2.07552195e-01f, -1.27390385e-01f, -1.09907389e-01f, 5.51407374e-02f, -3.58488709e-01f, -3.59037161e-01f,
  -1.15387186e-01f, 5.24244368e-01f, -8.45320225e-02f, -4.06218737e-01f, 1.97760299e-01f, -2.27278233e-01f, -1.34135395e-01f, -3.04654300e-01f, 1.59480855e-01f, -2.20936492e-01f,
  -2.09831610e-01f, -4.86780480e-02f, 1.68927655e-01f, 2.16503203e-01f, -6.13058865e-01f, 1.14587151e-01f, 2.74715215e-01f, -9.15769562e-02f, 1.17957331e-01f, -4.98265401e-02f,
  -1.38424963e-01f, -2.59364128e-01f, -1.48622021e-01f, -3.53780121e-01f, -1.76849857e-01f, 9.18351579e-03f, -8.91871005e-02f, 6.40562689e-03f, 2.28624837e-03f, -8.74237251e-03f,
  -6.89974725e-02f, -6.26961067e-02f, 9.83161926e-02f, -9.96852294e-04f, 3.12934518e-02f, 1.61817431e-01f, 6.88710660e-02f, -4.58550900e-02f, 1.20569997e-01f, 1.25063946e-02f,
  1.69034377e-02f, 5.42681739e-02f, -1.96382523e-01f, 8.21775645e-02f, -2.33526304e-01f, 1.18264101e-01f, -1.23760805e-01f, -9.61910039e-02f, -1.86980307e-01f, 1.15134619e-01f,
  6.01996295e-02f, 1.52180819e-02f, 3.59732355e-03f, -7.13344142e-02f, -4.25380282e-02f, 6.85516149e-02f, -4.38602977e-02f, -7.84799010e-02f, -7.02310875e-02f, -2.18938649e-01f,
  -9.40050855e-02f, 1.72477122e-02f, -2.83174627e-02f, 1.70598496e-02f, 1.36816883e-02f, -9.67619717e-02f, 1.32660612e-01f, -5.84946126e-02f, -5.88768460e-02f, 1.11831568e-01f,
  7.69749954e-02f, 6.53563887e-02f, 4.09244467e-03f, 8.27999413e-02f, 7.29974732e-03f, -1.68133274e-01f, -1.08432777e-01f, -2.41111591e-01f, -2.01726988e-01f, 2.02559263e-01f,
  1.74894854e-01f, -2.44952664e-01f, -2.07640246e-01f, 1.09639019e-01f, -9.73325074e-02f, 1.16338916e-01f, -7.77382553e-02f, 1.51293129e-01f, -1.44104198e-01f, 5.02687588e-04f,
  -1.08622357e-01f, -9.68968347e-02f, 3.56053654e-03f, -1.35876313e-01f, -2.23548070e-01f, -1.72816321e-01f, -1.16295114e-01f, -1.46254405e-01f, 1.69177175e-01f, -1.02532888e-02f,
  -1.27643347e-01f, 2.01383859e-01f, -1.42933905e-01f, -1.31592631e-01f, 2.76295811e-01f, -1.66038275e-02f, 2.25611106e-01f, 1.51070029e-01f, -1.94676310e-01f, -2.26247296e-01f,
  -1.33371353e-01f, 3.95490490e-02f, -5.94612658e-02f, 2.09066570e-01f, 1.83957219e-01f, 4.49779518e-02f, 5.40528931e-02f, 9.34461653e-02f, -1.97290093e-01f, -1.89821348e-01f,
  -3.47627103e-02f, -7.62327993e-03f, 7.54564023e-03f, 1.53027251e-01f, -1.93836242e-01f, 1.70154661e-01f, -1.80899277e-01f, 1.50618836e-01f, 2.86453515e-01f, 1.17525868e-01f,
  -2.71957576e-01f, -3.29678953e-01f, 2.70620346e-01f, 1.88457295e-01f, 1.64450586e-01f, -3.21943045e-01f, 1.42513096e-01f, 1.64550513e-01f, -2.77017921e-01f, 2.93349236e-01f,
  -2.32367098e-01f, 1.74022898e-01f, -5.01508355e-01f, -2.61978149e-01f, -4.30160128e-02f, 3.82504566e-03f, -2.97918528e-01f, -2.52006114e-01f, -1.31639257e-01f, 1.91743508e-01f,
  -2.37953275e-01f, -1.36852890e-01f, 7.87369441e-03f, -1.80372477e-01f, 7.67479464e-02f, -5.10143787e-02f, 5.24462154e-03f, 7.34943077e-02f, 6.19616434e-02f, -9.61762369e-02f,
  -1.35956824e-01f, -1.61417499e-01f, -3.30481268e-02f, 1.28293946e-01f, -2.03442480e-02f, -1.67592600e-01f, 1.51160181e-01f, 1.55533895e-01f, 1.00251182e-03f, 9.98638943e-02f,
  2.71927752e-02f, -3.88535373e-02f, 6.85206847e-04f, -7.06546009e-02f, 8.20349306e-02f, 2.81851850e-02f, -2.76713707e-02f, 1.72494218e-01f, -1.06800996e-01f, -1.30658090e-01f,
  -1.18100017e-01f, 1.24260690e-02f, 7.65680745e-02f, -4.39683460e-02f, -2.68966984e-02f, 5.36636375e-02f, -3.40119675e-02f, -5.12780957e-02f, 5.58336675e-02f, -5.77940643e-02f,
  -4.26941551e-02f, -9.20159221e-02f, -7.58036599e-02f, -1.49347171e-01f, 9.07862261e-02f, -1.12227865e-01f, 8.83299857e-02f, 3.39295231e-02f, 9.70483348e-02f, -2.56178919e-02f,
  1.09222434e-01f, -5.16501777e-02f, 1.30121946e-01f, 1.69134885e-01f, 1.57797843e-01f, 1.90385252e-01f, 1.42214030e-01f, -2.54160494e-01f, -1.75896630e-01f, 5.96732944e-02f,
  1.14267860e-02f, 1.90507397e-01f, -1.69602722e-01f, 3.17870051e-01f, 1.70879841e-01f, -1.60399884e-01f, -1.21382020e-01f, 3.96279013e-03f, -2.80929416e-01f, 2.41111994e-01f,
  2.25973800e-01f, -5.42091504e-02f, 1.93484664e-01f, 3.24712127e-01f, 2.24514440e-01f, 1.94974765e-01f, 1.43151239e-01f, 1.13145337e-01f, 4.75670956e-02f, -6.39899597e-02f,
  -1.65607512e-01f, 1.87177286e-01f, -2.12681815e-01f, 2.15134516e-01f, -1.68186381e-01f, 1.83174193e-01f, 1.35657236e-01f, -2.71779448e-01f, 2.63519347e-01f, -5.59787527e-02f,
  2.08224460e-01f, 1.47813529e-01f, -1.06234349e-01f, 2.06966758e-01f, -1.48326218e-01f, 1.48108840e-01f, 3.39113802e-01f, 6.17748313e-03f, -2.59401262e-01f, -2.91140556e-01f,
  -4.08177264e-02f, -1.46261409e-01f, -6.79222941e-02f, 1.79604560e-01f, -3.00676346e-01f, 1.80154681e-01f, -4.10409495e-02f, 2.85110712e-01f, 1.19313300e-01f, -2.68298656e-01f,
  1.15724327e-02f, -1.16422094e-01f, -3.56449246e-01f, -1.97440624e-01f, -2.57042319e-01f, -1.26456842e-01f, 1.42186116e-02f, -3.19981575e-01f, 1.37836143e-01f, -3.57599854e-02f,
  1.32070795e-01f, -4.20184404e-01f, 2.39495710e-01f, -2.00266331e-01f, 1.37203306e-01f, -3.23922664e-01f, -2.98734903e-01f, 8.82883146e-02f, -2.05739099e-03f, 1.42893255e-01f,
  1.06837833e-02f, -8.24748874e-02f, 1.44812778e-01f, 1.29621970e-02f, -7.88141266e-02f, -9.16745290e-02f, 6.64747730e-02f, -3.00839730e-02f, 1.08449258e-01f, -5.60296721e-05f,
  8.36029053e-02f, 1.52424440e-01f, -7.21225748e-03f, 1.99246202e-02f, -7.49897882e-02f, 1.78921483e-02f, -9.93367732e-02f, 6.80836961e-02f, -1.46655366e-01f, 1.30902171e-01f,
  1.23867542e-01f, 1.94590520e-02f, 9.10999328e-02f, -1.16862692e-01f, -1.45790339e-01f, -1.41783297e-01f, 6.08257838e-02f, 6.11676537e-02f, -1.22489899e-01f, -8.69135633e-02f,
  2.64926534e-02f, -3.02357245e-02f, 9.59847346e-02f, 1.15835562e-01f, -1.48517294e-02f, 1.36841238e-01f, 3.00666764e-02f, -1.15716800e-01f, -1.99319139e-01f, -6.00880384e-02f,
  -6.74693659e-02f, 4.78749648e-02f, 9.30272564e-02f, 3.44254039e-02f, 1.06483474e-01f, 8.70526657e-02f, 1.47321180e-01f, 2.91233719e-03f, 4.39067297e-02f, 7.60067180e-02f,
  -7.35388398e-02f, -1.74681261e-01f, -1.51535496e-01f, 2.07031772e-01f, 1.10536166e-01f, 1.57869622e-01f, -9.55986381e-02f, -1.59555241e-01f, -1.81952313e-01f, -1.08862102e-01f,
  -1.12385981e-01f, -2.65090436e-01f, -7.53091052e-02f, -1.77675352e-01f, 2.79080063e-01f, -2.23235264e-01f, 1.65229082e-01f, -2.20887765e-01f, -2.73403972e-01f, -4.31259051e-02f,
  4.57956009e-02f, 2.58980542e-01f, -2.43993357e-01f, -2.66654164e-01f, -2.42075339e-01f, 4.94319759e-02f, 4.63448316e-02f, 5.78509942e-02f, 2.79660791e-01f, -1.96410894e-01f,
  2.48427272e-01f, -2.74827108e-02f, -2.03323990e-01f, 3.37763786e-01f, -1.67696536e-01f, 3.33965451e-01f, -3.23240124e-02f, 2.63638198e-01f, -1.82180941e-01f, -9.05389637e-02f,
  1.30257100e-01f, -2.26440191e-01f, 2.82313615e-01f, -1.20826244e-01f, 1.14694782e-01f, -1.56915918e-01f, 2.10075587e-01f, 2.00179622e-01f, -5.34637123e-02f, 2.13095620e-01f,
  1.17873527e-01f, -3.11781913e-01f, 4.63399813e-02f, -2.43692517e-01f, -1.70743465e-01f, -2.13082030e-01f, 1.81930795e-01f, -4.97116536e-01f, -1.92840263e-01f, 2.52952844e-01f,
  -1.46793216e-01f, 2.10845649e-01f, 1.42437205e-01f, 1.32989973e-01f, -3.30070823e-01f, -3.27968836e-01f, -2.36452535e-01f, -6.06878772e-02f, -8.76175940e-01f, -2.93525338e-01f,
  -2.31567770e-01f, 1.35815829e-01f, -8.53306577e-02f, 9.72186923e-02f, 3.63355964e-01f, -3.48190553e-02f, 1.72673792e-01f, -4.45049442e-02f, -1.19023338e-01f, 5.85722029e-02f,
  5.32616898e-02f, -1.92128196e-01f, -8.03591087e-02f, 4.56169546e-02f, -6.79588353e-04f, 1.51233962e-02f, 6.94290772e-02f, -9.10621583e-02f, -9.09016877e-02f, -1.31459624e-01f,
  -3.67897041e-02f, -9.83300582e-02f, 6.54203072e-02f, 2.16369759e-02f, 3.00303623e-02f, -2.11784482e-01f, -3.91512103e-02f, 5.18244915e-02f, 1.20094836e-01f, 6.33976609e-02f,
  4.54355329e-02f, 5.93616702e-02f, -1.58497572e-01f, 3.21464613e-02f, -1.78109378e-01f, 7.17714280e-02f, 7.17787584e-03f, 5.21157123e-02f, -5.43613397e-02f, 7.77358785e-02f,
  -1.82752356e-01f, -5.19013554e-02f, -1.45678455e-02f, 2.65047923e-02f, 2.17777924e-04f, -3.17051373e-02f, 4.14920636e-02f, -7.02897012e-02f, -6.01243321e-03f, -3.94633822e-02f,
  -1.78831205e-01f, -6.47727847e-02f, -1.19389575e-02f, -1.67510197e-01f, -1.02042630e-01f, 1.17444947e-01f, -1.54661492e-01f, -1.43570989e-01f, 1.11060239e-01f, 5.37253777e-03f,
  1.58553660e-01f, 1.61599115e-01f, -7.66000301e-02f, 1.69042036e-01f, 3.34955007e-02f, 6.11120984e-02f, -1.81563720e-01f, 6.62431791e-02f, -5.08135855e-02f, -1.90436896e-02f,
  1.50130719e-01f, -4.27515022e-02f, -2.14445814e-01f, 2.06558838e-01f, -3.19497496e-01f, 1.58949211e-01f, -1.64689288e-01f, 1.99280232e-02f, 5.45158684e-02f, 1.37949884e-01f,
  -1.83201656e-01f, 4.19380404e-02f, 1.68463752e-01f, -9.99713689e-02f, -1.14608910e-02f, -1.24040104e-01f, 1.43361971e-01f, 2.24261776e-01f, 7.60077313e-02f, 3.04047823e-01f,
  -1.02837406e-01f, -1.74896717e-01f, 1.67113468e-02f, 1.97798297e-01f, 1.79224491e-01f, 1.63602754e-01f, -9.40621868e-02f, -2.39059404e-01f, 1.43979400e-01f, 2.02848464e-01f,
  2.93420970e-01f, -9.21677873e-02f, 1.93947956e-01f, -4.90776747e-02f, 1.58923417e-01f, 1.62456200e-01f, -2.55914301e-01f, -1.81537271e-01f, -1.10399306e-01f, -2.32669756e-01f,
  2.02657402e-01f, 1.43525496e-01f, 2.40969703e-01f, -2.02683136e-01f, -1.00930117e-01f, -2.77702749e-01f, 7.74436863e-03f, 3.33969705e-02f, 2.12552443e-01f, -1.46725193e-01f,
  1.33008018e-01f, 8.17364976e-02f, -1.70522053e-02f, -2.42359579e-01f, -2.33888537e-01f, 1.05192520e-01f, 2.97321472e-02f, 4.12901908e-01f, -2.34779611e-01f, 5.55116124e-02f,
  -5.87951958e-01f, -1.23718277e-01f, -1.87581122e-01f, -4.49110493e-02f, 1.95320293e-01f, 8.96611661e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.45373154e-02f, 5.96416928e-02f, 3.33869494e-02f, 7.62006566e-02f, -1.68899540e-02f, 7.25744367e-02f, 1.65935652e-03f, 7.22621381e-02f, -7.22322389e-02f, 6.55100346e-02f,
  -1.35313384e-02f, 4.19816263e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    