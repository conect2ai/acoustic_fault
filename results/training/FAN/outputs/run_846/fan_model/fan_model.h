/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.64237404e-01f, 1.38132751e-01f, -1.93000302e-01f, -1.64278999e-01f, 3.83453481e-02f, 2.28853785e-02f, -7.69291967e-02f, -1.77077889e-01f, -3.93432938e-02f, 1.33841738e-01f,
  2.41505399e-01f, 2.10055739e-01f, 2.62020677e-01f, 1.24671161e-01f, -1.02229208e-01f, -4.67547635e-03f, -5.65234870e-02f, -2.54833549e-01f, -1.02159604e-01f, 3.09528541e-02f,
  1.76875174e-01f, -5.26038967e-02f, -3.13174337e-01f, -1.15032971e-01f, 9.19472948e-02f, 6.28496855e-02f, 7.63758272e-02f, 2.21518204e-02f, 1.38450250e-01f, 1.26479194e-01f,
  2.21646085e-01f, -1.12081774e-01f, 1.50746303e-02f, 1.25955880e-01f, 7.57258832e-02f, -1.17066368e-01f, 1.28011927e-02f, -1.11915162e-02f, 5.83485188e-03f, -1.62619818e-02f,
  3.44259962e-02f, 3.56117897e-02f, -1.27666324e-01f, 3.17762233e-02f, -4.52886187e-02f, 1.87820904e-02f, -4.95633185e-02f, -1.12555705e-01f, 8.78846552e-03f, 2.42757704e-02f,
  9.57398415e-02f, 5.20613790e-02f, -8.76007304e-02f, 5.11711538e-02f, -8.11016038e-02f, 4.89120521e-02f, -3.95529494e-02f, -3.80765237e-02f, -3.78818251e-02f, 1.12134345e-01f,
  -5.30998316e-03f, 2.78401896e-02f, -2.64778659e-02f, 1.02428030e-02f, -3.72557826e-02f, 2.80282311e-02f, -1.70709155e-02f, 1.55211268e-02f, 1.29462229e-02f, -8.88410658e-02f,
  6.76911771e-02f, 1.47129521e-02f, 7.23560201e-03f, -4.09456668e-03f, 8.29564333e-02f, -5.23205213e-02f, -1.25502929e-01f, 6.10078424e-02f, -4.04264703e-02f, -5.09941019e-02f,
  1.06998831e-02f, -4.79552224e-02f, 3.76778878e-02f, -2.31940188e-02f, 5.35231866e-02f, -4.52329032e-02f, 2.09759884e-02f, 1.95283890e-02f, 8.02679956e-02f, -3.98026109e-02f,
  1.06862694e-01f, -2.94205062e-02f, 7.65305534e-02f, -3.93743664e-02f, -6.26563281e-02f, 4.33372632e-02f, 4.88200365e-03f, -2.50797551e-02f, 3.61183174e-02f, 6.02748478e-03f,
  -2.53249127e-02f, -6.32951185e-02f, 1.10659942e-01f, -1.65960118e-02f, -7.85985589e-03f, -4.52536531e-02f, 1.01547383e-01f, -3.00050676e-02f, 4.16829027e-02f, 4.02177870e-02f,
  4.02347073e-02f, -8.63584876e-02f, -5.08965328e-02f, 7.30463676e-03f, 6.37639016e-02f, -5.16344607e-03f, 4.10808399e-02f, -1.32111153e-02f, -7.19514638e-02f, -1.39346123e-02f,
  -1.29612923e-01f, 1.87951662e-02f, 1.46386445e-01f, -1.75984323e-01f, 1.33068949e-01f, 3.08853686e-01f, 5.06445289e-01f, 1.45658134e-02f, -1.40920535e-01f, 8.62476304e-02f,
  -2.47256570e-02f, -2.59886920e-01f, -2.11189672e-01f, -9.56418961e-02f, 3.68626676e-02f, 1.31322682e-01f, 1.75704390e-01f, -5.34418449e-02f, 6.57944009e-02f, 9.07490551e-02f,
  3.05079855e-02f, -4.87247482e-02f, -1.23116143e-01f, -1.58633664e-01f, -7.26291463e-02f, -5.52328676e-02f, 4.22443710e-02f, 3.00974753e-02f, -1.70533676e-02f, 1.07564195e-03f,
  1.02344416e-01f, 8.48716795e-02f, -4.91340719e-02f, -7.06834495e-02f, 7.11145699e-02f, -1.34592606e-02f, 5.74943125e-02f, 5.60227036e-02f, -8.19563493e-02f, -7.51235783e-02f,
  4.75053722e-03f, -5.93507327e-02f, 6.28583059e-02f, -3.05247493e-02f, 1.27134860e-01f, 2.21089404e-02f, -6.53375685e-02f, -6.58347905e-02f, -1.14466017e-02f, -3.89581732e-02f,
  -1.77864600e-02f, 1.97721254e-02f, 1.02809675e-01f, 3.98959294e-02f, -3.20220031e-02f, -7.11001735e-03f, 9.40045416e-02f, -4.32257652e-02f, -6.51374757e-02f, -1.56001687e-01f,
  -5.73868677e-02f, 2.83023585e-02f, 1.02352530e-01f, -3.94034944e-03f, 5.91109283e-02f, -3.96165214e-02f, -1.26051409e-02f, 1.87820029e-02f, 3.17715704e-02f, -1.84572954e-02f,
  -3.91719341e-02f, -1.46851456e-02f, 5.25036966e-03f, -4.76502590e-02f, -3.66889359e-03f, -5.52617805e-03f, 1.12124562e-01f, -1.27765788e-02f, -8.05743337e-02f, 3.94455045e-02f,
  -7.95863196e-02f, 3.65963914e-02f, 1.91589426e-02f, 5.82769997e-02f, -2.12577470e-02f, -5.34103960e-02f, -3.02992072e-02f, 2.82714032e-02f, -8.90821069e-02f, -1.37659535e-02f,
  -7.72913843e-02f, 5.46779484e-02f, -9.40649398e-03f, 2.54803970e-02f, 8.57412815e-03f, -1.07152268e-01f, -2.73551559e-03f, -2.03146692e-02f, 4.14323807e-02f, 5.95341902e-03f,
  7.18259066e-02f, 6.15323037e-02f, 1.15313148e-02f, -4.81816009e-02f, 3.59222777e-02f, -4.06609513e-02f, -1.50686894e-02f, 7.97077939e-02f, -1.45351486e-02f, 1.29183736e-02f,
  -8.35206509e-02f, 6.72764108e-02f, 2.55207755e-02f, 9.08726268e-03f, -8.56239572e-02f, 6.46465570e-02f, 9.42284390e-02f, 7.25112185e-02f, 6.89500794e-02f, -5.97922914e-02f,
  3.74740601e-01f, 5.63732013e-02f, 1.71541050e-01f, 4.37857769e-02f, -2.22983047e-01f, -1.26207814e-01f, 4.87853028e-02f, -1.43611589e-02f, -4.70475703e-02f, 5.20178676e-02f,
  -1.19473107e-01f, -2.67216861e-02f, 1.74687266e-01f, 3.45861390e-02f, 2.54288226e-01f, 1.40299663e-01f, 1.98400185e-01f, 2.68188715e-01f, 1.62403777e-01f, -9.52740312e-02f,
  -1.75625548e-01f, 8.85642171e-02f, 2.57753700e-01f, 1.26165122e-01f, -5.44283427e-02f, 1.16891395e-02f, -6.46078773e-03f, -5.70519753e-02f, -2.28957132e-01f, -1.99196830e-01f,
  6.21699207e-02f, -5.39657325e-02f, 3.94327305e-02f, 5.99166639e-02f, -1.07106201e-01f, 1.55334324e-02f, -2.51771342e-02f, 8.52374956e-02f, 1.31651042e-02f, 1.69118315e-01f,
  -2.41703410e-02f, 2.91167758e-03f, -7.14936778e-02f, -8.04268047e-02f, -4.76376619e-04f, 7.33057708e-02f, 4.67428342e-02f, 6.34533390e-02f, 1.34311229e-01f, 2.80854721e-02f,
  -9.68506262e-02f, -9.42792967e-02f, 6.60063997e-02f, -9.90782958e-03f, 5.29750884e-02f, -1.02764577e-01f, -5.63483723e-02f, -1.18708514e-01f, -4.09677345e-03f, 8.83370116e-02f,
  4.23181430e-02f, 2.73727644e-02f, -4.15833630e-02f, 2.73842528e-03f, 2.90281866e-02f, -1.78189389e-02f, -8.29434395e-02f, 3.64555568e-02f, 1.26854498e-02f, 2.45710332e-02f,
  3.35387476e-02f, -1.71504281e-02f, 4.76147644e-02f, 1.07625127e-01f, -2.03165114e-02f, -3.75922173e-02f, -8.97931531e-02f, 1.03005795e-02f, 3.33497263e-02f, -3.59027050e-02f,
  2.49036774e-02f, -6.76893890e-02f, -8.06565117e-03f, -3.50345038e-02f, -2.74378546e-02f, -4.13441919e-02f, -4.02469821e-02f, 1.32298851e-02f, 1.11463018e-01f, 1.98728759e-02f,
  2.54198551e-01f, -6.73760548e-02f, 3.11554987e-02f, 9.77082402e-02f, -6.21220358e-02f, -9.13383346e-03f, -1.05596362e-02f, -1.97220454e-03f, -1.45887947e-02f, 7.30252184e-04f,
  2.12701522e-02f, 6.67961836e-02f, 2.62661688e-02f, -1.40541885e-02f, -5.86020434e-03f, 1.16529740e-01f, 4.10460643e-02f, 2.67431419e-02f, -8.87052417e-02f, -6.10131621e-02f,
  1.65479824e-01f, 7.59921297e-02f, 1.05947360e-01f, 2.78473981e-02f, -4.95487712e-02f, 9.10222381e-02f, 2.84055993e-02f, -2.61534601e-02f, 7.31140897e-02f, 3.00313801e-01f,
  5.27313501e-02f, -1.12449609e-01f, 5.13384072e-03f, 9.40172523e-02f, -2.04551712e-01f, -1.69903055e-01f, -2.40652710e-01f, -1.87586337e-01f, -1.43258646e-01f, 4.49499907e-03f,
  -3.81300822e-02f, 1.13191329e-01f, 4.90609147e-02f, 1.37425363e-01f, 1.19427480e-01f, 1.44691214e-01f, 2.70905167e-01f, 2.82019347e-01f, 4.27616574e-02f, 4.58598956e-02f,
  -3.64766046e-02f, 1.52947277e-01f, 2.03158066e-01f, -1.36035476e-02f, 4.01672535e-02f, 1.65960360e-02f, -1.57233067e-02f, 8.43164772e-02f, -6.90277740e-02f, 2.95702696e-01f,
  1.69466972e-01f, -8.66285563e-02f, 9.99923050e-02f, 3.46501842e-02f, -3.57369408e-02f, -4.84526195e-02f, -1.91376302e-02f, 1.35763101e-02f, -2.77893376e-02f, -2.08120630e-03f,
  1.06162407e-01f, 9.87402201e-02f, 8.16318113e-03f, 8.85556489e-02f, 9.45863500e-02f, 2.22344510e-02f, -6.72059134e-02f, 3.91457006e-02f, 6.21475652e-02f, -1.78899899e-01f,
  -2.76547056e-02f, 9.06532630e-03f, -2.17025280e-02f, -3.43629130e-04f, -6.62874132e-02f, 7.36530647e-02f, -9.37430561e-03f, -3.81039418e-02f, -5.72199561e-02f, 6.04356192e-02f,
  -1.74110141e-02f, -1.09890504e-02f, -3.87748592e-02f, -2.78959032e-02f, -1.65652037e-02f, -4.42049243e-02f, 5.47006391e-02f, 9.70532279e-03f, 7.99727961e-02f, -4.09465889e-03f,
  -8.21086317e-02f, -2.52418201e-02f, 2.02785552e-04f, 8.37712665e-04f, 6.82680830e-02f, -1.58152189e-02f, 1.45242745e-02f, 6.02256581e-02f, 6.00617044e-02f, 3.22607718e-02f,
  6.98858351e-02f, 2.35544592e-02f, -9.04635936e-02f, 8.15473646e-02f, -4.55136178e-03f, -4.26425785e-03f, 4.17403802e-02f, -1.98753215e-02f, -7.93965459e-02f, 4.89767864e-02f,
  -1.67820558e-01f, 1.64636120e-01f, 6.05266690e-02f, 1.09315701e-02f, 5.02631031e-02f, -5.31562492e-02f, 1.90351419e-02f, 5.62931634e-02f, 5.73388264e-02f, -1.14324444e-03f,
  -3.48743647e-02f, -9.72606055e-03f, 6.87049888e-03f, 6.88674524e-02f, -1.15883341e-02f, 4.03707139e-02f, -3.05536427e-02f, 3.79023552e-02f, -1.84838921e-02f, -1.21080913e-01f,
  -8.41986462e-02f, 2.99282316e-02f, -5.12778992e-03f, -8.15795213e-02f, -6.48060394e-03f, 2.04812698e-02f, -1.86153837e-02f, -7.65222907e-02f, 2.17453577e-02f, -2.25069255e-01f,
  4.31650668e-01f, -1.10405102e-01f, -3.93558666e-02f, 2.19340965e-01f, -2.47362643e-01f, -2.98605144e-01f, -6.18619323e-01f, 4.63352054e-02f, 1.73865408e-01f, -1.96958974e-01f,
  -8.84692147e-02f, 1.46618977e-01f, 1.43900007e-01f, 8.04949626e-02f, 6.26052767e-02f, -2.13128805e-01f, -1.43473029e-01f, 5.92720881e-02f, 1.49547487e-01f, -4.20999974e-02f,
  -6.28004037e-03f, -4.49914336e-02f, 1.94141418e-01f, 6.60878941e-02f, -5.50782355e-03f, 1.05129614e-01f, -1.59948051e-01f, 4.89979088e-02f, -9.63469297e-02f, 2.66623609e-02f,
  -7.11152107e-02f, 1.22090600e-01f, -4.33494747e-02f, 1.06365092e-01f, -1.05899476e-01f, 1.84258679e-03f, 1.81519166e-02f, 3.60823013e-02f, 2.18846207e-03f, 4.54981066e-02f,
  -1.34902084e-02f, -5.20243235e-02f, 6.70145126e-03f, -1.95554290e-02f, -3.05434894e-02f, 3.80152240e-02f, 1.92486718e-01f, 1.19073138e-01f, 3.65337208e-02f, -3.89993973e-02f,
  -9.95081514e-02f, -8.55552405e-03f, -2.68333945e-02f, -8.49503204e-02f, 8.27988684e-02f, -3.96942794e-02f, 8.15213695e-02f, 6.94150180e-02f, 8.94217417e-02f, 1.13770068e-01f,
  -5.32470942e-02f, 3.61449569e-02f, -6.93592429e-02f, -3.66166160e-02f, 1.93761867e-02f, -5.21970354e-03f, -1.20914131e-02f, -5.95756397e-02f, -4.51303422e-02f, 4.92031202e-02f,
  -1.44463428e-03f, 8.24289694e-02f, 3.87254730e-02f, -5.18461615e-02f, 2.33760923e-02f, -2.19867495e-03f, -4.79818620e-02f, -1.76196173e-02f, 4.88078371e-02f, 6.17613643e-03f,
  8.72443989e-03f, -2.60632727e-02f, 2.37718578e-02f, 1.33391600e-02f, 5.46599291e-02f, 7.41562173e-02f, 5.08906171e-02f, 2.30837129e-02f, 4.74600755e-02f, -6.86298162e-02f,
  8.90413206e-03f, 1.94941778e-02f, 1.64866801e-02f, 4.09153150e-03f, 2.06016805e-02f, 2.37169769e-02f, -3.77895832e-02f, 1.49891563e-02f, 6.49958150e-03f, -2.71251462e-02f,
  -2.28367671e-02f, 2.24897917e-02f, -1.88476592e-02f, 7.20498804e-03f, -1.71050560e-02f, -8.66753012e-02f, -1.90363862e-02f, -8.76793489e-02f, 3.31012122e-02f, 4.69674356e-02f,
  1.76948973e-03f, -3.24996822e-02f, -1.64821409e-02f, -9.05007273e-02f, -1.34777026e-02f, 2.13834234e-02f, -4.93328795e-02f, 3.22813466e-02f, -3.57808731e-02f, -1.86729193e-01f,
  9.60204825e-02f, -2.21295863e-01f, -5.29599376e-02f, 1.70196742e-01f, 1.03695011e-02f, -1.88020766e-01f, -4.56388205e-01f, -7.32068270e-02f, 9.66785103e-02f, -1.94744229e-01f,
  -4.49739546e-02f, -3.56793106e-02f, -1.34987365e-02f, -5.51455878e-02f, -5.05281873e-02f, -2.35425472e-01f, 7.33697042e-02f, 1.77060366e-01f, 2.94736936e-04f, -8.42481181e-02f,
  -1.09231390e-01f, 8.89923722e-02f, -1.18315290e-03f, -3.65151502e-02f, 8.49159509e-02f, 8.94027576e-02f, 1.14028856e-01f, 1.56676188e-01f, 2.79232231e-03f, 3.09988528e-01f,
  6.06670193e-02f, -1.02664428e-02f, 6.51158169e-02f, -4.72155288e-02f, 6.96928725e-02f, 6.39402419e-02f, -7.79158473e-02f, 1.24788202e-01f, 3.14530060e-02f, -2.92029008e-02f,
  5.99067332e-03f, -2.93504670e-02f, 1.00630879e-01f, 4.15539034e-02f, -3.57776992e-02f, -3.45410989e-03f, -4.63969223e-02f, 1.51305199e-02f, -1.37942173e-02f, -1.44006938e-01f,
  -2.86141820e-02f, -1.00704767e-01f, 1.49680376e-02f, 1.96802076e-02f, -9.11307111e-02f, 2.70018801e-02f, -3.75657752e-02f, 9.72749386e-03f, 4.29786071e-02f, 1.45730555e-01f,
  7.80959949e-02f, 2.35475739e-03f, 9.14079919e-02f, -9.92720854e-03f, -2.86736451e-02f, 2.88599283e-02f, 6.39883801e-02f, 4.49653305e-02f, 3.32719199e-02f, -4.86953482e-02f,
  7.25268945e-02f, -7.04002380e-02f, 2.81360857e-02f, 1.38539001e-01f, -3.94038372e-02f, 1.28554301e-02f, 4.58997972e-02f, -5.36449514e-02f, -8.81911516e-02f, 2.12653819e-02f,
  1.80272907e-02f, 6.87428657e-03f, -4.15838137e-02f, -7.97123276e-03f, -7.65511813e-03f, 4.79790494e-02f, -6.29888698e-02f, -6.94362074e-02f, 2.60423422e-02f, -3.97015475e-02f,
  4.22933921e-02f, -3.26164700e-02f, -6.42729783e-03f, -6.41289651e-02f, 1.96434706e-02f, -2.68122628e-02f, -9.25075845e-04f, -1.83145907e-02f, 2.24736258e-02f, -8.00129920e-02f,
  -1.27079695e-01f, 3.22665609e-02f, 1.49652343e-02f, -4.62314747e-02f, 3.61292018e-03f, -8.52774978e-02f, -5.06794713e-02f, 1.78838912e-02f, -7.05962032e-02f, 4.34552319e-02f,
  -4.79856320e-02f, -1.22128211e-01f, -1.05182037e-01f, -1.11893184e-01f, 1.92670319e-02f, -4.62083369e-02f, -7.68860802e-02f, -4.85682413e-02f, -7.90669769e-02f, -2.07122102e-01f,
  2.87343532e-01f, -2.16378868e-01f, -2.20044270e-01f, -4.04287204e-02f, -3.16744186e-02f, -4.32447717e-03f, 9.29647833e-02f, 3.04900855e-02f, 1.64945808e-03f, -4.74876985e-02f,
  -8.26897621e-02f, -4.13061790e-02f, 1.04290098e-02f, -1.75943002e-02f, 6.02607690e-02f, 2.92754602e-02f, 2.04047170e-02f, 1.82083168e-03f, 1.63490608e-01f, 1.05406858e-01f,
  2.31199227e-02f, -1.60518717e-02f, 3.89477442e-04f, -5.28066866e-02f, -1.20489955e-01f, 1.51925415e-01f, -4.16650204e-03f, -1.69976667e-01f, -2.11279225e-02f, -2.16019481e-01f,
  -2.75629032e-02f, -2.77685046e-01f, 7.39684999e-02f, 4.18690853e-02f, -7.43428990e-02f, 9.23442692e-02f, 1.30416639e-02f, -1.96741112e-02f, 4.49269302e-02f, 3.18512097e-02f,
  -7.89535716e-02f, -1.54057331e-02f, 2.75665484e-02f, -4.05644476e-02f, 2.09831893e-02f, -9.19470191e-02f, -2.67911963e-02f, -1.17424861e-01f, -7.49493465e-02f, -4.12343889e-02f,
  -9.89760458e-02f, -1.14167713e-01f, -1.12119049e-01f, -1.41599372e-01f, -1.07566277e-02f, -7.88315386e-02f, -1.59355793e-02f, -1.52460650e-01f, -2.44545043e-02f, -3.19865122e-02f,
  9.32009816e-02f, -1.03695937e-01f, -4.61348100e-03f, 2.97190566e-02f, 6.92373365e-02f, 1.26704946e-02f, -1.91443320e-02f, -2.17867224e-03f, -1.59739349e-02f, 4.22153771e-02f,
  -6.29813969e-02f, 1.57922767e-02f, -3.37546729e-02f, -1.00784106e-02f, -4.72029950e-03f, -3.56033407e-02f, -1.11555951e-02f, -3.91716883e-02f, -1.89614408e-02f, 1.27614923e-02f,
  1.97431743e-02f, -6.51713312e-02f, -3.81165594e-02f, 1.15119331e-02f, -1.04883432e-01f, -2.84849126e-02f, 7.22406209e-02f, 2.13820953e-02f, -1.46428663e-02f, -1.37425717e-02f,
  3.10707062e-01f, -1.65169969e-01f, 1.54748425e-01f, 1.13967940e-01f, 4.30214144e-02f, -4.94370013e-02f, -1.50994677e-03f, -5.74229145e-03f, -8.58131871e-02f, -3.59998271e-03f,
  -4.67758439e-02f, 9.89423096e-02f, -1.52292047e-02f, -3.52157801e-02f, 1.60054073e-01f, 4.45504002e-02f, -3.09910392e-03f, 7.66448155e-02f, -4.22473215e-02f, 2.11223890e-03f,
  5.73200397e-02f, 1.67488039e-01f, 2.27439955e-01f, 1.19744249e-01f, 1.62230343e-01f, 2.74937600e-01f, 1.62513554e-01f, 2.32733145e-01f, 2.05154613e-01f, 4.32070971e-01f,
  -2.68064111e-01f, -2.84959786e-02f, -3.47616404e-01f, -3.32750052e-01f, -3.16334188e-01f, -1.52827442e-01f, -1.00038446e-01f, -5.18343002e-02f, 5.72266616e-02f, -1.24632027e-02f,
  -1.67576503e-02f, 1.00266874e-01f, -3.47309717e-04f, 1.50151290e-02f, -4.51501720e-02f, -5.28921373e-02f, -1.39329270e-01f, -1.58107042e-01f, -2.88739502e-01f, -2.31254980e-01f,
  -9.20999702e-03f, -1.98869988e-01f, -1.31382987e-01f, -2.36931909e-02f, -2.87993792e-02f, -8.11044350e-02f, -9.51657165e-03f, -1.10158987e-01f, 1.22692041e-01f, -2.08430782e-01f,
  -1.60948440e-01f, -2.18808025e-01f, -3.59339304e-02f, 8.17889497e-02f, -5.33751100e-02f, 4.98933196e-02f, 3.36029455e-02f, 1.15273900e-01f, 4.81450371e-02f, -6.11534715e-02f,
  -5.89061354e-04f, 4.84808125e-02f, -2.03671176e-02f, -1.83567256e-02f, -6.01649284e-02f, -7.03048334e-02f, 8.33788980e-03f, 6.98909350e-03f, -2.03371234e-02f, -4.83516939e-02f,
  -1.88475717e-02f, -2.09401939e-02f, -1.11338794e-01f, 4.50638793e-02f, -2.83670872e-02f, -3.64840440e-02f, 6.43878356e-02f, -8.41057375e-02f, -2.51661427e-02f, 8.65428299e-02f,
  -2.98068542e-02f, -2.74042971e-02f, 3.64357084e-02f, -2.46720705e-02f, 3.81715484e-02f, 7.54806101e-02f, -2.90123671e-02f, 6.07289039e-02f, -3.53106447e-02f, 6.96035400e-02f,
  -2.36954708e-02f, 4.73967026e-04f, 7.91505352e-03f, -5.90856597e-02f, -1.11580342e-02f, -4.11476642e-02f, 7.32298791e-02f, 3.30840517e-03f, 3.46792452e-02f, 6.84515536e-02f,
  -4.46492657e-02f, 2.49594375e-02f, -6.70513362e-02f, 6.06864393e-02f, -5.48134297e-02f, -3.06516699e-02f, -4.85520884e-02f, -7.88581092e-03f, -5.81662580e-02f, 5.07189659e-03f,
  2.96702739e-02f, 1.13187842e-01f, 4.38140593e-02f, -6.57544844e-03f, -3.41631658e-02f, 1.03695199e-01f, 4.15665992e-02f, 4.08426672e-02f, 2.62723789e-02f, -8.58185068e-02f,
  3.61446701e-02f, -5.60170449e-02f, -2.79069915e-02f, 2.80675688e-03f, -4.73589972e-02f, -7.55868852e-02f, 9.75311548e-02f, 8.45261477e-03f, 8.20763633e-02f, 5.99345658e-03f,
  2.62093302e-02f, 8.36536114e-04f, 1.45728169e-02f, 9.49077532e-02f, 1.38069112e-02f, -2.59854253e-02f, 2.55770702e-02f, 7.74665736e-03f, 2.12459881e-02f, 1.01680338e-01f,
  -5.74346125e-01f, 4.71993119e-01f, 7.10975677e-02f, -1.66520894e-01f, 1.20141603e-01f, -3.97874340e-02f, 2.26463556e-01f, 5.94582818e-02f, -1.32478714e-01f, 1.53605655e-01f,
  -1.24096358e-02f, -1.45396590e-01f, -1.72302172e-01f, -1.94331795e-01f, -8.81386548e-02f, 3.29199284e-01f, 2.16531992e-01f, -8.52780268e-02f, -3.86497319e-01f, -1.67375401e-01f,
  1.06780171e-01f, 6.08121380e-02f, -1.81232795e-01f, -1.24444358e-01f, 2.14710802e-01f, -1.72020607e-02f, 1.54280305e-01f, 6.96124882e-02f, 6.10614158e-02f, 5.18834889e-01f,
  -7.40083754e-02f, 1.42042469e-02f, -1.69313341e-01f, -6.99872375e-02f, -3.98968533e-02f, -9.00703818e-02f, -1.46621848e-02f, -2.62132287e-02f, 4.41732109e-02f, 2.44724341e-02f,
  2.66040340e-02f, 5.70975477e-03f, -4.82883886e-04f, 4.81642783e-02f, -8.78869649e-03f, -3.50322165e-02f, 5.81545383e-02f, -5.01369871e-02f, -1.30652994e-01f, 8.00575465e-02f,
  1.95408240e-01f, 6.18909821e-02f, -7.12664798e-04f, 3.84163065e-03f, -7.93988779e-02f, -5.50614111e-02f, -9.80862789e-03f, -1.04628094e-01f, -9.06278044e-02f, 8.01681578e-02f,
  3.81511040e-02f, 6.84242975e-03f, -6.70966581e-02f, 5.21135293e-02f, 1.93876475e-02f, -4.63171452e-02f, 5.46763390e-02f, -2.90314928e-02f, -1.95117090e-02f, 8.36875215e-02f,
  -4.01430242e-02f, 2.57332483e-03f, 3.10277455e-02f, -1.34394607e-02f, -5.48465177e-03f, 5.30396141e-02f, -6.61430284e-02f, 2.34986991e-02f, -1.29879732e-02f, 3.30916755e-02f,
  -3.57206166e-02f, -4.94324304e-02f, 6.90737739e-02f, -3.87574434e-02f, 9.00495276e-02f, -3.83027531e-02f, 7.38937333e-02f, -1.23647880e-02f, 4.73867953e-02f, 2.47045439e-02f,
  -5.56225404e-02f, -9.58734900e-02f, 8.63727555e-02f, 3.45310234e-02f, -1.06867710e-02f, 1.16163222e-02f, -3.56865600e-02f, -4.63918857e-02f, -2.25798208e-02f, -2.69561671e-02f,
  -9.87988189e-02f, -2.59396620e-02f, 3.22191231e-03f, 2.22147219e-02f, -1.71198715e-02f, -3.66436690e-02f, 6.26035631e-02f, -1.04118166e-02f, -2.72636171e-02f, -5.88342287e-02f,
  -9.46210138e-03f, -2.96207555e-02f, -8.01459849e-02f, -3.47721241e-02f, 3.46171074e-02f, -7.98105970e-02f, 3.84015217e-02f, -5.28362617e-02f, -1.23730481e-01f, 1.44273654e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.53100118e-01f, 1.41916081e-01f, 1.68895230e-01f, 2.39435676e-02f, -4.23321873e-02f, 8.42995644e-02f, 1.06055468e-01f, -7.57314684e-03f, 8.02478846e-03f, 3.17481235e-02f,
  3.45424153e-02f, -5.87751381e-02f, 9.66381282e-02f, -2.18207315e-02f, 1.30174249e-01f, -1.12445932e-03f, 3.90199535e-02f, 9.54472497e-02f, 6.53733090e-02f, 9.09765586e-02f,
  -9.97604355e-02f, -1.13931149e-02f, -3.67139429e-02f, 8.71979594e-02f, -7.57869557e-02f, 3.97737212e-02f, 5.50175235e-02f, 5.44300377e-02f, 1.57557300e-03f, -5.90114295e-03f,
  -4.00851294e-02f, 1.69773161e-01f, -1.19845256e-01f, -7.24708363e-02f, 9.03270170e-02f, 4.76434305e-02f, 1.09977268e-01f, 1.83365457e-02f, 3.25200967e-02f, -3.43897715e-02f,
  2.51471642e-02f, -7.41357803e-02f, 1.08814426e-03f, 7.81529695e-02f, -2.22230032e-02f, -4.22126949e-02f, 7.92627633e-02f, 7.87938982e-02f, 1.38485283e-02f, 1.00528754e-01f,
  3.06402557e-02f, 9.07051712e-02f, 4.60950807e-02f, 1.17495216e-01f, 1.02469884e-01f, 2.26070136e-02f, 2.73081250e-02f, -1.91707201e-02f, -3.65892947e-02f, 6.29838631e-02f,
  4.69145477e-02f, 5.07953390e-02f, 6.64516166e-02f, -2.00844649e-02f, -4.32656854e-02f, -7.09843859e-02f, -1.40629141e-02f, 3.60051915e-02f, -7.84504116e-02f, -4.56788354e-02f,
  7.56662712e-02f, -6.90036193e-02f, 4.84834351e-02f, 2.25643944e-02f, -1.40121300e-02f, -4.26799767e-02f, 8.34247619e-02f, 5.86626828e-02f, -6.71045631e-02f, -4.45618629e-02f,
  8.04029405e-02f, -4.35839333e-02f, -6.62842393e-02f, 4.31718491e-02f, 1.49042509e-03f, -3.83822098e-02f, -4.51112650e-02f, 4.61581647e-02f, 3.84335183e-02f, -3.52301798e-03f,
  -1.02025464e-01f, 2.59300298e-03f, -1.25359595e-01f, -4.31978004e-03f, -6.56837821e-02f, 1.06699707e-03f, -8.04711413e-03f, 5.14104180e-02f, 2.19154265e-02f, 2.23114137e-02f,
  7.17600808e-02f, 6.73031583e-02f, 8.99919029e-03f, 5.17570674e-02f, 3.50797512e-02f, -2.09897608e-02f, 1.04855942e-02f, -9.50965732e-02f, 2.99022067e-02f, -8.70162398e-02f,
  -3.48281935e-02f, -1.87867917e-02f, 2.82035526e-02f, 3.45946699e-02f, -4.15447019e-02f, -7.24137528e-03f, -3.36661525e-02f, 5.53135052e-02f, -4.57444526e-02f, -3.62010598e-02f,
  -2.41754636e-01f, -2.36062356e-03f, -9.81004909e-03f, 2.35833526e-01f, 1.78492457e-01f, 1.28844738e-01f, 2.12240070e-01f, 2.13161305e-01f, 1.35430619e-01f, 1.81624696e-01f,
  -3.66440862e-02f, 1.37515828e-01f, 1.49157882e-01f, 1.29754722e-01f, 1.57367021e-01f, 1.92203835e-01f, 1.55870527e-01f, 9.52825174e-02f, 7.09515959e-02f, 1.32742643e-01f,
  1.48822322e-01f, -7.29773641e-02f, -1.20766118e-01f, -8.29531532e-03f, 1.29257888e-01f, 1.18889876e-01f, -6.25725975e-03f, -6.51457757e-02f, -1.71751976e-02f, 9.46072415e-02f,
  -4.36044708e-02f, -1.87162861e-01f, 3.13129053e-02f, -7.54468441e-02f, -2.81603690e-02f, -1.28113791e-01f, 1.25546986e-03f, -1.39900610e-01f, -9.88777447e-03f, -3.15628350e-02f,
  1.62551999e-02f, -1.06275663e-01f, 7.12482631e-02f, 1.10496236e-02f, -1.16815522e-01f, -1.07433707e-01f, -3.24762048e-04f, 4.14413363e-02f, 1.11606315e-01f, -4.73058857e-02f,
  1.96967963e-02f, 1.27490573e-02f, 1.50155555e-02f, -3.39053757e-02f, -1.50236429e-03f, 2.78361756e-02f, -7.68299624e-02f, -2.95980964e-02f, 5.98039031e-02f, 7.73897171e-02f,
  4.23154533e-02f, 5.33620007e-02f, 3.63309421e-02f, 9.40235239e-03f, -7.13768415e-03f, 4.94166352e-02f, 3.02612539e-02f, 3.28440517e-02f, 1.66828632e-02f, -6.12173742e-03f,
  5.32409884e-02f, 6.42505428e-03f, 1.16165623e-01f, 1.33570489e-02f, -9.36290994e-03f, 1.78650096e-02f, 7.86782652e-02f, -4.27602530e-02f, -1.00753628e-01f, -8.58488008e-02f,
  1.95279941e-02f, -3.41390632e-02f, -1.04462644e-02f, -2.47959830e-02f, 7.08954409e-02f, 7.12482333e-02f, -6.46046037e-03f, -7.25439936e-02f, 5.07607944e-02f, -8.44068825e-02f,
  -4.35516052e-02f, -7.12932423e-02f, 1.38278037e-01f, -5.76605201e-02f, 5.03671132e-02f, -9.51348692e-02f, 7.92483091e-02f, 1.12553732e-02f, -1.07008025e-01f, -2.96123140e-02f,
  -4.02610004e-02f, -3.78045291e-02f, -2.68275272e-02f, -6.87600523e-02f, -4.32753339e-02f, -1.32419718e-02f, 7.25115389e-02f, 5.08644246e-02f, 5.90029471e-02f, -3.67117934e-02f,
  6.41707703e-02f, 8.66121501e-02f, -6.72750473e-02f, 1.20527387e-01f, 8.91392492e-03f, 4.60783131e-02f, -4.49191332e-02f, -2.89659444e-02f, -3.09303738e-02f, 1.26668602e-01f,
  8.60126242e-02f, 2.13200405e-01f, -7.40011111e-02f, 1.35936633e-01f, 1.94038987e-01f, 2.78489608e-02f, -3.92467380e-02f, 8.12894141e-04f, 7.29071572e-02f, 5.58541082e-02f,
  2.20117718e-01f, 9.51416716e-02f, -8.22543576e-02f, -1.75792277e-02f, -1.10902183e-01f, -5.76569326e-02f, 5.29479347e-02f, -1.66551083e-01f, -2.95922220e-01f, -1.20438814e-01f,
  -2.72115394e-02f, -6.33137580e-03f, -7.13324640e-03f, -3.25124338e-02f, 1.76921934e-01f, -8.40532556e-02f, -3.43677364e-02f, 8.44222009e-02f, 6.55278787e-02f, 2.02498093e-01f,
  1.67262778e-01f, 2.74041146e-01f, -2.04121470e-01f, 5.26367091e-02f, 9.24889967e-02f, -4.97742742e-02f, 5.83813675e-02f, 2.34575123e-02f, -2.43422925e-03f, 6.66598156e-02f,
  1.30679337e-02f, 1.21936999e-01f, 1.87755395e-02f, -1.13746128e-03f, 1.99782923e-02f, 7.57591352e-02f, 4.01626937e-02f, -1.67265698e-01f, -3.69784422e-02f, -1.98060479e-02f,
  1.74839243e-01f, 1.51091740e-01f, 9.75052416e-02f, -6.74839020e-02f, -1.08553506e-01f, -3.46298097e-03f, -9.66423154e-02f, -6.78348243e-02f, -1.79329053e-01f, -7.94869512e-02f,
  1.22037651e-02f, 2.14275140e-02f, 6.39251024e-02f, 2.41683070e-02f, 9.19101983e-02f, -6.27181435e-04f, 5.14568724e-02f, 6.73532262e-02f, -1.10332400e-01f, 1.02851123e-01f,
  -6.89294860e-02f, 1.25523331e-02f, -4.87598628e-02f, -5.03278933e-02f, 1.85757689e-02f, -2.11040266e-02f, 7.39419386e-02f, -1.76883601e-02f, 2.19316389e-02f, 4.33009379e-02f,
  -5.59268445e-02f, -3.09105869e-02f, 4.33961395e-03f, 8.25828165e-02f, -5.21694273e-02f, 5.87516241e-02f, -6.28697500e-02f, -5.56125753e-02f, -2.62464359e-02f, 5.52199110e-02f,
  -8.25948790e-02f, -1.08038805e-01f, 3.26073654e-02f, 4.75707874e-02f, -6.09936798e-03f, -4.08187285e-02f, 3.84107828e-02f, 2.37230863e-02f, 1.61555141e-01f, 1.12094143e-02f,
  2.43761949e-02f, -4.30299751e-02f, -2.05796473e-02f, -7.06982762e-02f, -8.48225728e-02f, -5.55551052e-02f, 1.27718911e-01f, -6.60472959e-02f, -1.69397235e-01f, 2.63101794e-02f,
  -2.72203721e-02f, -1.18263923e-01f, -4.99966145e-02f, -6.95261434e-02f, -3.35277542e-02f, -1.10871360e-01f, -1.37965545e-01f, -4.02180515e-02f, -2.06897929e-01f, -1.33989409e-01f,
  6.00829199e-02f, -2.38217428e-01f, -7.00571388e-02f, 1.48493409e-01f, 7.39092231e-02f, 2.29833722e-02f, -4.86777313e-02f, 1.53914317e-01f, 2.01875761e-01f, 1.78674199e-02f,
  5.15542142e-02f, 1.36837423e-01f, 1.40859127e-01f, 1.14048226e-02f, 5.21909408e-02f, -6.12576902e-02f, 9.08810422e-02f, 1.46689668e-01f, 1.04170159e-01f, 4.18331288e-02f,
  5.05497716e-02f, 3.32027790e-03f, -2.79897321e-02f, 1.17715053e-01f, 5.70523404e-02f, 7.63328820e-02f, 5.01979291e-02f, -2.68382803e-02f, -1.34891216e-02f, -8.88867676e-02f,
  -6.96940497e-02f, -1.02838583e-01f, 1.29059732e-01f, -1.30510274e-02f, -1.75994024e-01f, -7.20113143e-02f, 2.96632722e-02f, -1.40911147e-01f, -4.98056598e-02f, -2.49120891e-02f,
  8.53415206e-02f, -9.68575303e-04f, 9.77413729e-03f, -8.44248459e-02f, -6.48442283e-02f, 4.28903252e-02f, -1.43898591e-01f, -9.05319490e-03f, 6.84271604e-02f, -3.54300179e-02f,
  -3.43584195e-02f, -1.37748525e-01f, 3.36419493e-02f, 9.73023549e-02f, 1.87001992e-02f, 1.38294756e-01f, -5.30088954e-02f, -1.36591867e-01f, -3.29662710e-02f, -7.54131228e-02f,
  2.50043767e-03f, 4.96770516e-02f, 2.00928524e-02f, -1.61638856e-02f, 6.20791204e-02f, 2.27023163e-04f, -2.03988254e-02f, -5.59332259e-02f, 1.02714382e-01f, -4.97414023e-02f,
  -2.14347560e-02f, 8.48353654e-02f, -3.92504558e-02f, 1.61435138e-02f, 8.57674107e-02f, -2.02927589e-02f, -2.57127825e-02f, 4.01803665e-03f, 3.35230939e-02f, 8.60283244e-03f,
  -6.73612729e-02f, -3.46620642e-02f, -9.59789306e-02f, 3.64412591e-02f, 5.93505567e-03f, 3.60555016e-02f, 9.38787311e-02f, 2.58412235e-03f, -8.42348710e-02f, -3.43349017e-03f,
  5.78027871e-03f, 7.42183700e-02f, 9.07480493e-02f, -3.12872380e-02f, 1.06515354e-02f, 3.15143093e-02f, 4.20704596e-02f, 1.40760699e-02f, -1.31986633e-01f, -2.54208054e-02f,
  -1.01436555e-01f, -4.43560556e-02f, 1.33550726e-02f, 1.87647659e-02f, 4.40977924e-02f, -2.60133436e-03f, -7.39443973e-02f, -7.92442169e-03f, 4.19487357e-02f, -1.24460883e-01f,
  -2.04748120e-02f, 9.89601668e-03f, 2.22847927e-02f, 9.27303880e-02f, -5.51456250e-02f, 1.51216045e-01f, 9.18170214e-02f, 7.16515332e-02f, 5.19368239e-03f, 9.79674514e-03f,
  1.69902414e-01f, 4.45037931e-02f, -1.16123281e-01f, -1.63662713e-02f, -1.67727433e-02f, -9.24107060e-02f, -1.21816080e-02f, -3.74159217e-02f, 1.26215488e-01f, 6.97430968e-02f,
  7.06508458e-02f, 2.17509672e-01f, 1.52467772e-01f, 2.60323565e-02f, -3.06402650e-02f, -5.76755106e-02f, 4.49248329e-02f, 3.89662720e-02f, 3.63663994e-02f, 6.81697577e-02f,
  1.03891544e-01f, 5.50616086e-02f, 6.17566518e-02f, -8.07493702e-02f, -5.61780594e-02f, 1.21627830e-01f, -2.56073792e-02f, 4.59159128e-02f, -3.60210836e-02f, -1.60238873e-02f,
  6.53868541e-02f, -1.01969251e-02f, 6.14898885e-03f, 1.53964430e-01f, 2.76209600e-02f, 2.92813685e-02f, 2.96222772e-02f, 4.64415923e-02f, 8.61375779e-02f, -3.35182674e-04f,
  -1.55693584e-03f, 1.14886984e-01f, -1.77144893e-02f, 2.66986769e-02f, 1.28837293e-02f, 1.08320288e-01f, -2.78812740e-02f, 1.62790604e-02f, -3.33314128e-02f, 4.35346551e-02f,
  2.24241931e-02f, 8.22679549e-02f, 5.07816374e-02f, -3.17519158e-02f, 2.72995140e-02f, 1.33206844e-01f, 3.32192294e-02f, 3.81892584e-02f, -1.03847384e-02f, 9.54228919e-04f,
  7.12252706e-02f, -4.07714024e-03f, 1.15200222e-01f, 9.39316601e-02f, 5.21543473e-02f, -6.57632798e-02f, 4.20755632e-02f, -3.28065418e-02f, 7.04030618e-02f, 1.99789293e-02f,
  -2.14619171e-02f, 8.62769112e-02f, 4.59989049e-02f, -1.09566785e-02f, -5.74391009e-03f, 6.07583374e-02f, -2.24707443e-02f, 6.59883022e-02f, -6.87363297e-02f, 9.61126313e-02f,
  -5.67073980e-03f, 6.49456754e-02f, -1.68211889e-02f, -9.13273077e-03f, 5.93554862e-02f, 4.77095656e-02f, 9.10376459e-02f, 1.49740234e-01f, 3.85678783e-02f, -8.36080592e-03f,
  -4.88254689e-02f, -2.76967045e-02f, 3.87701429e-02f, 7.28997067e-02f, 7.27843354e-03f, -6.22094870e-02f, 6.11712635e-02f, 7.38656521e-03f, -5.26203215e-02f, -2.78430991e-02f,
  8.21746290e-02f, -9.63546783e-02f, -6.49966151e-02f, -7.24059939e-02f, 5.74200489e-02f, 3.51058021e-02f, 6.23492151e-02f, 9.13576335e-02f, 3.92527282e-02f, 7.12280646e-02f,
  -2.83381641e-02f, 1.10319383e-01f, 2.19657235e-02f, -1.05157398e-01f, 8.23035836e-02f, 3.14939581e-02f, 6.10947907e-02f, -1.49965370e-02f, -2.35848897e-03f, 1.69884805e-02f,
  8.34300816e-02f, -3.47407572e-02f, 2.15937775e-02f, -6.62668899e-04f, -3.29754204e-02f, 6.39281869e-02f, 8.08608979e-02f, 5.92906214e-02f, -4.02142853e-02f, -5.48662432e-02f,
  -4.10988629e-02f, 1.16260257e-02f, -1.20525341e-03f, -1.69604849e-02f, -1.06731489e-01f, 1.42365014e-02f, -8.50420892e-02f, -5.60230128e-02f, -8.31151083e-02f, -1.09602258e-01f,
  3.42252688e-03f, -7.38606378e-02f, 4.78101671e-02f, 3.69582623e-02f, 6.68021291e-02f, -6.54860726e-03f, 3.88119631e-02f, 6.44522905e-02f, 4.57716174e-02f, -2.07139738e-02f,
  -4.29113992e-02f, -1.68011580e-02f, -1.31379023e-01f, 5.51586933e-02f, 4.11955342e-02f, -2.53174156e-02f, 2.04217993e-02f, 6.33269325e-02f, 2.71727163e-02f, -2.25907695e-02f,
  7.09950253e-02f, -4.41906936e-02f, 5.88228228e-03f, -2.72676516e-02f, 5.42729199e-02f, -6.11550249e-02f, -9.29417461e-03f, 4.15853560e-02f, -5.46491928e-02f, -1.73371714e-02f,
  9.31842700e-02f, 8.60664323e-02f, 4.20288965e-02f, 5.97533472e-02f, 4.16238755e-02f, -1.05730258e-02f, -1.82665065e-02f, -7.94384256e-02f, -7.94236735e-02f, 1.12296687e-02f,
  -1.70300733e-02f, 6.06428199e-02f, -5.25075942e-02f, -5.46422265e-02f, -5.15143201e-02f, -8.43480751e-02f, 7.65602887e-02f, 1.88617539e-02f, 1.22722157e-03f, -5.52562289e-02f,
  2.24206578e-02f, -5.63447885e-02f, 5.24742119e-02f, 2.53629256e-02f, 6.21223915e-03f, 5.26184449e-03f, -2.39436869e-02f, -7.26274103e-02f, -6.84152320e-02f, -5.08365110e-02f,
  -3.14819664e-02f, -5.23174293e-02f, -2.29802057e-02f, 4.91425917e-02f, 7.68732280e-02f, -1.82337547e-03f, 2.36929525e-02f, 1.67321134e-02f, -2.40083020e-02f, -1.65815428e-02f,
  2.03294363e-02f, -3.50463241e-02f, 8.49652477e-03f, -6.16514497e-02f, -2.40154080e-02f, -5.10871746e-02f, -1.36749493e-02f, 1.79806408e-02f, 4.43073176e-03f, -3.53208296e-02f,
  6.97269216e-02f, -3.47008184e-02f, -8.61355849e-03f, -6.27503544e-02f, 4.24098782e-02f, 8.51666480e-02f, 7.55682513e-02f, 2.72251945e-02f, 6.52637258e-02f, -6.31420836e-02f,
  -6.27636239e-02f, -5.02392203e-02f, -4.07530414e-03f, -6.38722554e-02f, -9.94002223e-02f, -1.13369927e-01f, -3.13972011e-02f, 5.31965196e-02f, -6.52762577e-02f, -2.70316899e-02f,
  -2.00839907e-01f, -3.30075830e-01f, -2.25070938e-01f, -3.59492749e-02f, -1.47385746e-02f, 1.09998383e-01f, -1.12001128e-01f, 1.69423193e-01f, 1.40644744e-01f, -1.85998261e-01f,
  -1.08144879e-01f, 4.07938026e-02f, -5.19695915e-02f, -5.82091995e-02f, -3.28474492e-02f, -2.75478959e-01f, -1.68021202e-01f, -4.26105782e-02f, 7.90253803e-02f, 2.37007365e-01f,
  1.60284583e-02f, -7.25641102e-02f, -8.25631917e-02f, 1.01713955e-01f, -1.12502217e-01f, -1.07424505e-01f, -2.13803858e-01f, -1.75381571e-01f, -1.00075789e-01f, -3.07007104e-01f,
  -2.72877067e-01f, 3.79909109e-03f, 2.03699060e-02f, -4.01759185e-02f, -1.61313578e-01f, 6.75537884e-02f, -3.06417923e-02f, -8.86025950e-02f, -2.29370669e-02f, -6.12360835e-02f,
  -3.22650447e-02f, 1.14583068e-01f, 9.30497944e-02f, 1.69008679e-04f, 7.53053576e-02f, 4.21257392e-02f, 3.06088687e-03f, -1.29350260e-01f, -9.15325731e-02f, 2.38617156e-02f,
  2.88916961e-03f, -4.15294021e-02f, 3.47075202e-02f, -3.98474485e-02f, -6.18320368e-02f, 2.75480207e-02f, -1.91072561e-02f, 6.12083189e-02f, -1.02901131e-01f, -2.53477782e-01f,
  -3.81076448e-02f, -4.79946360e-02f, 4.07133624e-02f, -5.68860918e-02f, 6.22546263e-02f, -4.65835333e-02f, -4.89647724e-02f, -1.45955468e-02f, 7.93247744e-02f, -9.73699465e-02f,
  -1.40363593e-02f, -7.50215948e-02f, 4.77294289e-02f, 5.84316850e-02f, -1.03602104e-01f, -6.61697462e-02f, 5.39295003e-02f, -1.96357761e-02f, -8.32540821e-03f, -3.27394679e-02f,
  -2.79978067e-02f, 6.31618500e-03f, -2.50683930e-02f, 3.69778275e-02f, -5.94427474e-02f, -3.65397781e-02f, 9.80533753e-03f, 8.34597871e-02f, 2.06708480e-02f, 9.58926827e-02f,
  -8.54710042e-02f, 3.35473605e-02f, -9.77225751e-02f, 1.97033305e-02f, 1.06072836e-02f, -2.78358459e-02f, -5.17723011e-03f, -3.43101192e-03f, 7.04427063e-02f, 3.91532779e-02f,
  1.29538074e-01f, -3.88415381e-02f, -5.49837500e-02f, 9.56766382e-02f, 5.50945215e-02f, 5.08040637e-02f, -6.49573058e-02f, 6.39174879e-03f, 1.70265511e-02f, 7.01050237e-02f,
  -7.99766332e-02f, -5.53687923e-02f, 1.96365267e-02f, -3.98813747e-02f, 4.19015102e-02f, -3.59057039e-02f, -3.09717618e-02f, -1.70675352e-01f, -6.29600585e-02f, -2.47275978e-01f,
  -1.39451072e-01f, -5.09047322e-03f, 1.39093995e-01f, -6.29825890e-02f, 7.37120435e-02f, 1.16407380e-01f, 1.80306863e-02f, -5.29027320e-02f, -1.00863084e-01f, -6.62854910e-02f,
  -8.55866596e-02f, -8.66955593e-02f, 1.09559214e-02f, 3.40159908e-02f, 4.26722467e-02f, 1.04181558e-01f, 8.21767189e-03f, -3.16336155e-02f, 9.52518359e-02f, 3.35358679e-02f,
  3.72291394e-02f, -8.76525789e-02f, -1.30444571e-01f, -1.10345453e-01f, -9.38415676e-02f, -5.83628267e-02f, 1.23825390e-02f, -9.55116376e-03f, -8.34518969e-02f, -4.61426340e-02f,
  -7.04542780e-03f, 1.28970016e-02f, 8.96525458e-02f, -5.45861833e-02f, -1.03580672e-02f, -2.46034581e-02f, 5.81083894e-02f, -4.87024635e-02f, -1.10075697e-02f, -6.29152283e-02f,
  -3.81412655e-02f, -3.85582671e-02f, -1.03968807e-01f, -5.53311221e-03f, -1.30897224e-01f, -9.22083408e-02f, -1.56240975e-02f, -2.24494189e-02f, -2.69153304e-02f, -7.93691427e-02f,
  -1.40755177e-02f, -3.92394103e-02f, -3.13080885e-02f, 5.33154272e-02f, -5.89941815e-02f, -8.93470421e-02f, 1.36605361e-02f, 2.83410344e-02f, 4.99403775e-02f, 1.34243825e-02f,
  1.71288997e-02f, -9.34910309e-03f, 1.86851956e-02f, -9.68227163e-03f, -3.50939110e-02f, 5.83314151e-03f, -6.17471486e-02f, -4.74070795e-02f, -3.40583287e-02f, 1.68728102e-02f,
  6.27474263e-02f, 4.50271443e-02f, -6.32046163e-02f, -1.13052353e-02f, -4.62824777e-02f, 4.23377939e-02f, -3.59560102e-02f, 1.46584054e-02f, 5.65246083e-02f, -8.29371437e-02f,
  2.07324587e-02f, -2.16999445e-02f, -1.10996746e-01f, 3.29324193e-02f, -1.68957841e-02f, 6.23290464e-02f, 3.88055369e-02f, -5.39849363e-02f, 3.58823277e-02f, 9.84593481e-03f,
  -2.96001062e-02f, 7.00602755e-02f, -6.86939433e-02f, 5.79753630e-02f, 2.68384665e-02f, -4.39658351e-02f, -3.79285552e-02f, -7.13008866e-02f, 7.22846463e-02f, 4.36114613e-03f,
  -1.08121596e-02f, -4.75443155e-02f, -5.46680158e-03f, 3.74851115e-02f, -2.17241347e-02f, -8.27054083e-02f, -6.90804198e-02f, -2.33393069e-03f, -2.75236666e-02f, 4.00789231e-02f,
  -3.89733277e-02f, -7.45127723e-02f, -1.24864794e-01f, -1.86325349e-02f, 2.76883580e-02f, -5.68106361e-02f, 7.04589784e-02f, 3.48498449e-02f, -3.55491973e-02f, -1.08069636e-01f,
  2.00136825e-01f, 2.33325645e-01f, -7.74660558e-02f, 1.42007172e-01f, -9.19870213e-02f, -8.03761780e-02f, -3.82630639e-02f, -1.30878210e-01f, -4.44799438e-02f, 8.58340561e-02f,
  -5.93083911e-03f, 1.79480519e-02f, 9.66245383e-02f, -4.67715273e-03f, 1.80870797e-02f, 1.32496864e-01f, 1.65273845e-01f, 1.76645234e-01f, 3.12377512e-02f, 8.79879221e-02f,
  1.87721342e-01f, 3.68132293e-02f, 2.51159873e-02f, -3.77159156e-02f, 1.37760758e-01f, 3.31665315e-02f, 2.09167134e-03f, 1.24045247e-02f, 1.25640750e-01f, 3.93554747e-01f,
  1.08130455e-01f, 3.79336774e-02f, -1.06438667e-01f, 8.74542966e-02f, -1.09649293e-01f, 5.41653410e-02f, 8.44448805e-03f, -1.34417589e-03f, -4.78135794e-02f, -5.94459623e-02f,
  1.29275918e-02f, -9.20747966e-03f, 6.48584738e-02f, -5.57133779e-02f, -4.14441749e-02f, -3.96905951e-02f, -5.36138602e-02f, 1.04239747e-01f, -5.83823510e-02f, 1.07137419e-01f,
  9.37141944e-03f, 9.89293456e-02f, -5.42962588e-02f, -1.86143696e-01f, -3.07567157e-02f, -1.29350368e-02f, -8.01520189e-04f, 2.20967270e-03f, -7.94033930e-02f, 7.03008845e-02f,
  -4.30608504e-02f, 2.73925401e-02f, -5.75168245e-02f, 4.94965538e-02f, 6.86354376e-03f, 1.36825470e-02f, 5.54060424e-03f, -9.91483312e-03f, -3.86930332e-02f, 6.52059317e-02f,
  -8.72211233e-02f, -3.95897515e-02f, -1.77343898e-02f, -4.00637761e-02f, -4.44541611e-02f, 9.99720953e-03f, -5.73261688e-03f, -7.13496748e-03f, -6.98067434e-03f, -9.58291441e-02f,
  -6.70937635e-03f, -8.43889788e-02f, -2.89582908e-02f, 4.69104946e-02f, 6.89650998e-02f, 2.72314921e-02f, 6.59569725e-02f, -2.50368323e-02f, -5.18567711e-02f, 4.82318513e-02f,
  -1.63968861e-01f, -1.69233143e-01f, 1.25081688e-01f, 8.98042247e-02f, 2.51748096e-02f, 8.13242272e-02f, 2.44689807e-02f, -3.68979909e-02f, 6.26656180e-03f, -4.45825197e-02f,
  -1.35596888e-02f, -1.38193986e-03f, 6.37693182e-02f, 2.32380945e-02f, -3.77204716e-02f, -6.09235764e-02f, -4.36263392e-03f, 7.53808618e-02f, 8.80231895e-03f, 1.06036447e-01f,
  1.95479430e-02f, -1.23212807e-01f, -6.46917224e-02f, -3.49364802e-02f, -3.70192975e-02f, -8.11390802e-02f, -3.08404919e-02f, -2.88616959e-02f, -1.24925695e-01f, -5.45318238e-02f,
  -2.81194627e-01f, -4.31140177e-02f, 9.07641742e-03f, 1.03289470e-01f, 2.17938706e-01f, 1.91935807e-01f, 2.06857696e-01f, 1.46875918e-01f, 1.09063543e-01f, -2.03447863e-02f,
  1.34239206e-02f, -1.03528418e-01f, 4.00436606e-04f, -5.41876145e-02f, 4.12502103e-02f, 1.62381768e-01f, 4.48503047e-02f, 2.57964116e-02f, -2.81771850e-02f, -3.20924856e-02f,
  -1.08481608e-02f, -9.78911854e-03f, -5.91240376e-02f, 8.78798589e-02f, 7.05260634e-02f, 1.18537666e-02f, -5.87841235e-02f, -5.19799031e-02f, 2.73215771e-02f, 1.17567971e-01f,
  -6.49244115e-02f, -2.74183508e-02f, 4.04471122e-02f, 1.01414090e-02f, -1.44870216e-02f, -8.15462917e-02f, -8.12783986e-02f, -1.07371993e-01f, -9.13048685e-02f, 7.07403570e-02f,
  -9.84468758e-02f, 5.62916435e-02f, -1.01322038e-02f, -5.67203294e-03f, 3.68522778e-02f, -5.19172251e-02f, 3.26111466e-02f, -8.85119960e-02f, 7.59784058e-02f, 1.20874252e-02f,
  1.75253656e-02f, 1.14764079e-01f, 1.75459459e-02f, 5.35020865e-02f, 1.32781882e-02f, -2.42069364e-02f, 2.49330718e-02f, -2.03601029e-02f, -9.36684012e-02f, -1.07960373e-01f,
  -8.58850628e-02f, -9.48070511e-02f, -7.83825517e-02f, -5.70192300e-02f, -7.86669999e-02f, 7.06147477e-02f, 1.10118305e-02f, 1.26492670e-02f, 1.36920176e-02f, -6.58487976e-02f,
  -8.69856030e-02f, -3.70113999e-02f, -2.33356673e-02f, 4.29672226e-02f, -5.15695103e-02f, 6.36483058e-02f, 3.76334451e-02f, -6.41764775e-02f, 3.08641624e-02f, 4.50250842e-02f,
  5.89435874e-03f, 4.47349186e-04f, 8.27713981e-02f, -5.09816445e-02f, -9.17679816e-03f, 1.23753212e-02f, 1.12534739e-01f, -2.70767454e-02f, 6.72903135e-02f, -8.33517537e-02f,
  -8.98163170e-02f, 2.33724248e-02f, 4.07184027e-02f, -7.42124021e-02f, -4.25725654e-02f, -1.61263570e-02f, -8.00604522e-02f, -3.33341844e-02f, 4.71823104e-02f, 7.04636499e-02f,
  -9.05236825e-02f, -1.40751168e-01f, -1.31356735e-02f, 2.34986562e-02f, -9.07246675e-03f, -3.79401073e-02f, -1.10332437e-01f, 2.22613383e-02f, -1.66035201e-02f, 5.36707230e-02f,
  6.25972673e-02f, 1.34795710e-01f, 2.06851307e-02f, 4.88118604e-02f, -7.58757675e-03f, 2.06077173e-02f, 3.44972759e-02f, 9.19721723e-02f, 8.64601880e-02f, 1.53361792e-02f,
  -1.13672111e-02f, -2.51672752e-02f, 7.80613199e-02f, 1.75586939e-02f, 1.17361397e-01f, 4.40130569e-02f, -7.75138242e-03f, 4.74120788e-02f, 4.49603749e-03f, -5.33711910e-02f,
  3.46228443e-02f, -6.32703826e-02f, -3.31445620e-03f, 3.20610963e-02f, 7.01203719e-02f, -3.82216200e-02f, 1.38368329e-03f, -3.53076272e-02f, -4.42393385e-02f, 7.42251575e-02f,
  -1.43381795e-02f, 6.74061775e-02f, -9.56302062e-02f, 4.16094400e-02f, -8.27594176e-02f, -1.70624405e-02f, 7.13484213e-02f, 2.34355628e-02f, -8.12595412e-02f, 2.63233148e-02f,
  -9.89357755e-02f, 5.79457395e-02f, -3.17925103e-02f, 6.65291548e-02f, 3.11113149e-02f, 5.03387675e-02f, -9.43049639e-02f, -4.05003466e-02f, -4.30414453e-02f, -5.30979224e-02f,
  7.47510791e-02f, 2.39540227e-02f, -5.91450110e-02f, -6.60369918e-02f, 4.07253802e-02f, -1.23472251e-02f, 1.93333235e-02f, -8.54980852e-03f, 3.24004441e-02f, -5.04403710e-02f,
  3.22604226e-03f, -5.85393682e-02f, 1.56476013e-02f, 1.22358734e-02f, 3.46461944e-02f, -4.61738035e-02f, -3.50789316e-02f, 9.36095603e-03f, 9.53835621e-02f, -4.76508364e-02f,
  -3.19275819e-02f, -3.04435752e-02f, -2.53539812e-02f, -1.52096394e-02f, 2.63032969e-02f, 3.36227491e-02f, -5.60067594e-03f, -6.75242115e-03f, 4.86686192e-02f, -5.92631064e-02f,
  2.97605302e-02f, -1.79411937e-03f, 3.43707651e-02f, 1.93080101e-02f, 7.13617578e-02f, 7.00099953e-03f, -4.61572632e-02f, 1.93118602e-02f, 6.80275857e-02f, -5.13217784e-02f,
  -1.11947237e-02f, -3.37364487e-02f, -3.50860991e-02f, 3.64343673e-02f, 3.31326053e-02f, 5.41908704e-02f, 4.89232875e-02f, -6.47549033e-02f, 3.62655260e-02f, 2.21946929e-02f,
  -1.29086778e-01f, 2.68773977e-02f, -3.38361375e-02f, -5.90539649e-02f, 5.03593422e-02f, 5.12331836e-02f, -5.49622178e-02f, 3.07157598e-02f, -3.96508016e-02f, 4.04045731e-02f,
  -3.64492834e-02f, 4.61251810e-02f, -8.02513808e-02f, -3.46176489e-03f, -5.15826494e-02f, -6.47293180e-02f, 8.26876704e-03f, -2.39613489e-03f, -7.44603872e-02f, -1.41620440e-02f,
  -5.64940237e-02f, 1.78399291e-02f, 1.40885646e-02f, 5.05883545e-02f, -1.44778406e-02f, -6.82317019e-02f, 3.82207036e-02f, -7.78827593e-02f, 5.48917875e-02f, -6.73427731e-02f,
  -6.95972368e-02f, -9.76888537e-02f, -1.54115736e-01f, 2.28688754e-02f, 7.39885122e-02f, -4.65762764e-02f, 5.88039868e-02f, -1.37640405e-02f, 1.62038922e-01f, 2.52653528e-02f,
  -3.33921500e-02f, 8.22140574e-02f, 9.72219482e-02f, 8.26102421e-02f, 7.49114156e-02f, 1.44912954e-02f, 1.36300772e-01f, 4.62572575e-02f, 2.23366972e-02f, 1.02659382e-01f,
  6.80175722e-02f, 7.05997571e-02f, -3.10990419e-02f, 2.79013980e-02f, 1.50099234e-03f, 2.48324330e-04f, -1.52038131e-02f, -4.06239927e-02f, -2.51132576e-03f, 7.07722977e-02f,
  -5.83061427e-02f, -9.64271873e-02f, 1.40783386e-02f, 1.09512232e-01f, -4.21414785e-02f, 9.44720879e-02f, 3.21182087e-02f, -1.77669153e-02f, -3.12444251e-02f, -3.28519419e-02f,
  1.45626720e-02f, 4.95068058e-02f, 1.16992295e-01f, 5.28320335e-02f, -6.59252331e-02f, 6.86654672e-02f, -2.21535005e-02f, 3.29294465e-02f, -5.82875311e-02f, 7.95581490e-02f,
  9.44284126e-02f, -8.12626034e-02f, -1.53287509e-02f, -9.06665847e-02f, 3.27076251e-03f, -1.00626461e-02f, -5.14590293e-02f, 6.69553801e-02f, -9.74579230e-02f, -6.12611591e-04f,
  9.21517462e-02f, -4.51167114e-02f, -3.47012654e-02f, 2.36214679e-02f, 4.90406230e-02f, -3.06946002e-02f, 9.32483599e-02f, 1.28897622e-01f, -7.06165005e-03f, 3.05324942e-02f,
  4.90810983e-02f, -5.28268665e-02f, -1.87958796e-02f, 4.14003916e-02f, 6.72350973e-02f, -9.18351710e-02f, 1.94237530e-02f, 6.83568567e-02f, -6.95693865e-02f, -4.44862992e-03f,
  3.31823081e-02f, -2.14904621e-02f, -6.31770566e-02f, 1.50773898e-01f, 3.56402472e-02f, 5.86200040e-04f, -1.82392839e-02f, 5.98134920e-02f, 4.06085886e-02f, -3.63395251e-02f,
  2.20881589e-02f, -1.24842376e-01f, 7.69255981e-02f, 3.27936150e-02f, 3.01826857e-02f, -6.61509633e-02f, 7.62051493e-02f, -8.22377428e-02f, -8.72233361e-02f, 1.02012448e-01f,
  -9.13539454e-02f, 1.95978582e-03f, -2.82849073e-02f, -4.66930792e-02f, -2.32438254e-03f, 4.10383427e-06f, 7.02867657e-02f, 8.34691077e-02f, -7.38700703e-02f, -8.05976707e-03f,
  -6.64128140e-02f, -1.74549893e-02f, -1.12892024e-01f, -8.80065411e-02f, -6.12490661e-02f, -9.17247608e-02f, -1.33872062e-01f, 1.70390941e-02f, -1.05471179e-01f, -1.19051330e-01f,
  3.98367226e-01f, -7.15303496e-02f, -4.01609182e-01f, 1.15952380e-01f, -1.17838383e-01f, 3.33088264e-02f, -8.89748707e-02f, -2.95468280e-03f, 1.60493597e-01f, -1.18375178e-02f,
  2.08689962e-02f, 1.57081798e-01f, 1.88849047e-01f, 4.06831466e-02f, 1.18537070e-02f, -1.41066134e-01f, -1.99683473e-01f, -1.01253182e-01f, 1.16118684e-01f, -5.15857488e-02f,
  1.89685058e-02f, -2.28083730e-02f, 1.37958676e-01f, 8.73334482e-02f, -1.66606084e-01f, -1.00387022e-01f, -2.71083444e-01f, -1.54531047e-01f, -6.11692443e-02f, -1.18625894e-01f,
  -1.09806076e-01f, -4.03043926e-02f, -4.59295772e-02f, 1.45942390e-01f, 2.53308052e-03f, -6.60684854e-02f, 3.64534892e-02f, -1.28237039e-01f, 6.74692988e-02f, -1.84910782e-02f,
  -2.01364458e-02f, -1.21313576e-02f, 9.38659236e-02f, -4.45140153e-02f, -3.08211576e-02f, -6.56003058e-02f, 4.02845033e-02f, -1.46010322e-02f, -9.84957367e-02f, -1.02127530e-01f,
  4.12701815e-02f, 4.95560579e-02f, -1.02369888e-02f, 7.66172707e-02f, 7.84151629e-02f, 1.21847671e-02f, -1.01081379e-01f, 3.91797237e-02f, 5.07078618e-02f, 1.99661814e-02f,
  7.43456632e-02f, -6.58390746e-02f, 1.17744962e-02f, 7.81671926e-02f, -2.20753886e-02f, -3.39126848e-02f, 5.64474501e-02f, -4.54042759e-03f, -3.16936374e-02f, -2.85354666e-02f,
  2.94355880e-02f, -8.30672830e-02f, -2.80299131e-02f, -5.39636426e-02f, -7.47983530e-02f, 4.15475443e-02f, 1.40538225e-02f, -2.01605726e-02f, 1.45527935e-02f, 6.22871891e-02f,
  3.53024341e-02f, -4.00343444e-03f, -2.03943271e-02f, -1.70644540e-02f, -2.12365203e-02f, -2.93474700e-02f, 2.57640202e-02f, -2.84780096e-02f, 4.22729962e-02f, -3.51248607e-02f,
  8.59934986e-02f, 7.57000297e-02f, 3.59204225e-02f, 9.72899199e-02f, -6.68192804e-02f, -7.02433139e-02f, -9.50756483e-03f, -5.50749265e-02f, 3.18582430e-02f, 8.18586200e-02f,
  2.82897651e-02f, 5.25000840e-02f, -6.25175387e-02f, 6.71710400e-03f, 3.05351173e-03f, -1.30960178e-02f, 2.34170612e-02f, 9.80815291e-02f, -7.23127127e-02f, -5.82092777e-02f,
  3.79611924e-02f, 1.01301275e-01f, 1.89874485e-01f, 7.02516437e-02f, -2.85633020e-02f, 7.77756423e-02f, -1.76147185e-02f, -6.94915727e-02f, -1.19894175e-02f, 8.29015821e-02f,
  3.07660192e-01f, 1.11843064e-01f, 1.32430764e-02f, 1.12995073e-01f, 4.55058366e-02f, -1.42863542e-01f, -2.10604265e-01f, -2.06344351e-01f, 1.91131122e-02f, 3.41229583e-03f,
  -1.61805339e-02f, 8.77693594e-02f, 2.80231200e-02f, -1.51659220e-01f, -1.36547446e-01f, -4.03411873e-02f, -1.05661310e-01f, -1.54605687e-01f, -1.32955581e-01f, -9.46626440e-02f,
  -5.45974113e-02f, 6.47887960e-03f, 8.44475403e-02f, 2.35018618e-02f, 3.13735418e-02f, -1.66693162e-02f, 7.50512443e-03f, 9.90905389e-02f, -6.01529628e-02f, 2.20946014e-01f,
  1.45597756e-01f, 1.30750285e-02f, -1.18794799e-01f, -3.28796767e-02f, 1.09792583e-01f, -4.58897278e-02f, -1.79436300e-02f, 3.28101106e-02f, -1.03895538e-01f, 4.72513698e-02f,
  1.33654281e-01f, 5.85891455e-02f, 7.66139477e-03f, -5.51627949e-02f, -2.26715058e-02f, -7.36950561e-02f, -2.93208472e-02f, -3.41311991e-02f, -1.33302808e-01f, 2.69641522e-02f,
  2.49751359e-02f, 6.51897043e-02f, 4.21157815e-02f, -1.70445681e-01f, -6.32057935e-02f, -8.62859488e-02f, 2.56375540e-02f, 2.23170463e-02f, -1.17488697e-01f, 2.71950252e-02f,
  -8.12018067e-02f, 1.62195917e-02f, -4.33864295e-02f, 4.25632820e-02f, -5.73020689e-02f, -5.21198846e-02f, -9.83742997e-02f, -3.37627046e-02f, -7.73937851e-02f, -7.41827711e-02f,
  5.04091904e-02f, -8.38583857e-02f, 5.62803335e-02f, -8.26547146e-02f, -2.84449924e-02f, -7.66832847e-03f, -3.67926583e-02f, -4.41543199e-02f, -6.18368536e-02f, 4.56780829e-02f,
  -4.88869287e-03f, 7.93664455e-02f, 2.40748026e-03f, -7.83856362e-02f, -7.66427219e-02f, -8.95292759e-02f, 2.20773276e-02f, -1.61915440e-02f, -1.34607539e-01f, 2.29618717e-02f,
  1.55257229e-02f, -2.47094274e-01f, -5.24333157e-02f, -1.81560796e-02f, 6.73530400e-02f, -2.00390397e-03f, 8.88834968e-02f, -7.78696761e-02f, 1.90639645e-02f, 6.91305846e-02f,
  3.48392427e-02f, 4.81553748e-02f, -2.74498481e-02f, -1.73304193e-02f, 3.99893224e-02f, -1.31780338e-02f, -5.35877831e-02f, 5.76216690e-02f, -7.96235949e-02f, -2.10174397e-02f,
  -1.81068201e-02f, -1.40671255e-02f, -5.48859760e-02f, -2.23125275e-02f, 4.54487577e-02f, -1.40898868e-01f, -9.36283097e-02f, -3.27146836e-02f, -8.29454213e-02f, -6.37327507e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -2.97785122e-02f, 1.02088470e-02f, 3.04385215e-01f, 1.58276245e-01f, 5.98119609e-02f, -6.01218976e-02f, 2.44893909e-01f, -4.06078016e-03f, 8.98049325e-02f, 1.55502960e-01f,
  2.28866152e-02f, 2.50882115e-02f, 1.40509501e-01f, 6.54981956e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.85298190e-01f, 1.02456093e-01f, -1.25937641e-01f, -1.99143905e-02f, 1.98741987e-01f, -1.55070439e-01f, 2.07971022e-01f, 8.03431943e-02f, 1.14055417e-01f, 7.65037909e-02f,
  -3.32362294e-01f, -9.20908824e-02f, 3.07750218e-02f, 4.83529776e-01f, 2.00773835e-01f, -1.70937225e-01f, 1.41024306e-01f, -2.87171662e-01f, -2.47977767e-02f, 1.14565231e-01f,
  -1.72593236e-01f, 1.64034620e-01f, 2.38287747e-01f, -7.39917383e-02f, 2.18827546e-01f, -5.83280064e-02f, -9.40795019e-02f, -2.46252596e-01f, 3.69363092e-02f, 7.79874623e-02f,
  -1.33918598e-01f, 7.05004334e-02f, 4.06758457e-01f, 1.81502581e-01f, -1.97611049e-01f, -1.27485797e-01f, 1.16999529e-01f, -2.11279407e-01f, 1.82182506e-01f, 1.25212088e-01f,
  8.20140094e-02f, 2.61578560e-01f, -5.67420900e-01f, -3.00386637e-01f, 1.07108159e-02f, 4.34352666e-01f, 1.17147177e-01f, 7.93066546e-02f, 5.10468483e-01f, -2.13210359e-01f,
  -8.15551579e-02f, 1.39362931e-01f, -2.28582509e-02f, 6.01300783e-02f, 1.72816902e-01f, 4.01714481e-02f, -1.40921438e-05f, -2.66200453e-01f, -2.86510475e-02f, -3.21013965e-02f,
  -1.97801605e-01f, 2.16216803e-01f, 3.15304607e-01f, 1.38134867e-01f, 1.26645923e-01f, 2.39947848e-02f, 9.55072269e-02f, 1.44568428e-01f, -2.47626036e-01f, 1.42968148e-01f,
  -1.48634359e-01f, -1.26605198e-01f, -3.20415348e-01f, -6.09238982e-01f, 1.58419218e-02f, 3.53168577e-01f, 1.62652537e-01f, 1.71779841e-01f, 1.55140772e-01f, 2.83175379e-01f,
  -3.04624170e-01f, -4.47286844e-01f, 1.21445239e-01f, 7.14352503e-02f, -3.54071498e-01f, 1.45783633e-01f, -1.47719249e-01f, 9.83862206e-02f, 4.33253050e-02f, 1.45061657e-01f,
  2.24464238e-02f, -1.75160632e-01f, -1.21525757e-01f, 3.00827567e-02f, 1.12318210e-01f, -2.74925798e-01f, 1.05921566e-01f, 1.64781824e-01f, -1.33947209e-01f, 3.31571884e-02f,
  -5.73727302e-02f, 6.57442585e-02f, 4.99036396e-03f, -2.10462660e-01f, -9.84082296e-02f, -2.43009105e-01f, -8.29607546e-02f, -1.35556888e-02f, -1.58480540e-01f, 1.86802968e-01f,
  -9.83665138e-02f, 1.99877501e-01f, 4.95959282e-01f, -3.40597957e-01f, 2.20819727e-01f, -2.07059607e-01f, -2.15736985e-01f, -1.56569541e-01f, -2.14236394e-01f, -1.79601610e-01f,
  1.24977991e-01f, -8.68105814e-02f, -3.31219107e-01f, -1.02109626e-01f, -5.82443667e-04f, 1.08029386e-02f, 1.86368853e-01f, -3.23470473e-01f, -3.56253050e-02f, 1.93454430e-01f,
  -3.98296453e-02f, 3.17915268e-02f, 1.22577220e-01f, 1.28630519e-01f, -6.66057914e-02f, 4.62426655e-02f, -1.35305107e-01f, 4.69954200e-02f, -8.44680145e-02f, 2.22159192e-01f,
  -2.21235380e-01f, -2.32934892e-01f, -3.00189406e-01f, 3.15616131e-01f, 1.70020342e-01f, -2.17023529e-02f, 1.22035472e-02f, 2.13517219e-01f, -1.28984585e-01f, 2.11680368e-01f,
  -1.72170121e-02f, -5.57797737e-02f, 8.00679848e-02f, 6.41912296e-02f, -3.22406799e-01f, 2.35872227e-03f, 8.55736956e-02f, 4.87395860e-02f, 2.06400201e-01f, -9.16535556e-02f,
  -2.47214790e-02f, 3.11023258e-02f, -2.22816542e-01f, -2.06101891e-02f, 2.24062204e-01f, 1.44303039e-01f, -7.07566738e-02f, -5.28044701e-02f, 1.23397797e-01f, 3.28813612e-01f,
  -1.61519215e-01f, -5.22233658e-02f, -2.31903493e-01f, -2.23510653e-01f, -1.28638655e-01f, 9.92796943e-02f, 1.15910739e-01f, 1.66754335e-01f, -2.20732614e-01f, -3.32594886e-02f,
  6.81301877e-02f, -4.48175594e-02f, -7.81924203e-02f, 1.34766072e-01f, 1.13035440e-01f, 2.05896571e-01f, -2.09221095e-01f, 1.61884785e-01f, 1.33627191e-01f, -8.96928236e-02f,
  -1.73799941e-04f, -1.03466563e-01f, -8.55212510e-02f, -2.28838503e-01f, -2.51029670e-01f, -1.50556654e-01f, 1.42913342e-01f, -8.93979594e-02f, -2.26989895e-01f, -1.60354208e-02f,
  -2.67079502e-01f, 1.52982110e-02f, 3.46660912e-01f, -2.17631698e-01f, -1.03889801e-01f, -3.87497306e-01f, -3.27420644e-02f, -2.38057762e-01f, -3.22354525e-01f, 2.68318743e-01f,
  -7.66434222e-02f, 1.70538008e-01f, -2.21414510e-02f, 4.22935709e-02f, -1.70921996e-01f, 6.95740758e-03f, 9.38328952e-02f, 1.79122657e-01f, -2.44993269e-01f, 3.09352279e-01f,
  1.22145981e-01f, -1.59802623e-02f, -2.16051564e-01f, -2.08315164e-01f, 4.01320052e-04f, 6.77939504e-02f, -7.97913522e-02f, 7.95454532e-03f, -3.21528353e-02f, -3.06350235e-02f,
  -7.87494183e-02f, -1.65960491e-01f, 3.57032001e-01f, 2.57618517e-01f, -2.70761270e-02f, -1.91828087e-01f, -3.14248383e-01f, -2.11206093e-01f, -4.50374894e-02f, -1.28517404e-01f,
  2.54348963e-01f, 4.06118512e-01f, 6.56691045e-02f, -1.84057310e-01f, 3.50915462e-01f, -1.96865857e-01f, 2.04750776e-01f, 1.25942871e-01f, -1.47235855e-01f, -1.14377223e-01f,
  9.21770334e-02f, 6.89400285e-02f, -7.41166547e-02f, -1.22899480e-01f, -7.64126852e-02f, 1.70543537e-01f, 2.44397134e-01f, -3.73197943e-01f, 1.02763586e-01f, 6.56410307e-02f,
  -2.26206973e-01f, 1.65652677e-01f, -1.58279181e-01f, -2.66878307e-01f, -5.75695276e-01f, -6.47022903e-01f, 2.02813536e-01f, 1.11719400e-01f, 2.22324014e-01f, 1.58998579e-01f,
  3.83830033e-02f, 1.17572747e-01f, -3.47573847e-01f, -2.11551726e-01f, 1.31993309e-01f, 2.13790819e-01f, 2.95381807e-02f, -6.97693750e-02f, -2.59548854e-02f, 1.62418202e-01f,
  1.31456435e-01f, -7.06507042e-02f, 1.88508090e-02f, 2.81494498e-01f, 1.31893530e-01f, 9.34057757e-02f, 2.24782765e-01f, 2.02924851e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.93031207e-01f, -8.52981582e-03f, 1.73632234e-01f, -5.07209897e-02f, -4.88452762e-02f, 2.91833252e-01f, 1.28486037e-01f, 4.08004411e-03f, -4.95568424e-01f, 1.13617748e-01f,
  -2.89898831e-02f, -9.45229158e-02f, -4.93390812e-03f, 2.14105457e-01f, 1.20975025e-01f, -1.86280977e-05f, -2.19815612e-01f, -2.53044009e-01f, -2.95617074e-01f, 2.72927821e-01f,
  -1.13333121e-03f, 3.06552291e-01f, -9.55340415e-02f, -1.36442527e-01f, 3.83611500e-01f, 9.16774794e-02f, 1.28887832e-01f, 2.06586510e-01f, 1.48689141e-04f, 2.02512532e-01f,
  2.01053813e-01f, -1.40009969e-01f, 1.02600344e-01f, 2.11059809e-01f, 1.45566449e-01f, -3.66078168e-02f, 3.59721273e-01f, 3.89110371e-02f, 2.02744693e-01f, 1.24239765e-01f,
  2.31371820e-01f, 8.39368775e-02f, -3.74513417e-01f, -1.67713910e-01f, 1.77482903e-01f, 2.64196903e-01f, 2.60102719e-01f, -1.98469803e-01f, -1.52388727e-02f, 1.32055640e-01f,
  -1.75671000e-02f, 1.66154336e-02f, 3.59569490e-01f, -1.12749375e-01f, 7.63958395e-02f, -2.76118144e-02f, 6.61571845e-02f, 2.71804468e-03f, 3.43103647e-01f, 4.27030362e-02f,
  -9.70482454e-03f, 1.63496003e-01f, 1.17058024e-01f, 2.94266194e-01f, 8.78687650e-02f, 3.17289650e-01f, 1.30707160e-01f, 5.18830419e-01f, 9.78334025e-02f, 4.02310908e-01f,
  -2.32803613e-01f, -5.87380156e-02f, -1.35801181e-01f, -9.93176401e-02f, 1.17834464e-01f, 3.07165295e-01f, -2.44511962e-01f, -3.14955443e-01f, -2.30437279e-01f, 5.51909685e-01f,
  7.28802308e-02f, -1.99690118e-01f, -2.68952191e-01f, 3.50250572e-01f, -2.72563726e-01f, 4.55384910e-01f, 8.12543780e-02f, -1.14506952e-01f, 2.73666531e-01f, -6.37721196e-02f,
  6.73642196e-03f, 1.78486139e-01f, -4.08015177e-02f, 1.71151489e-01f, 2.43295148e-01f, -2.06962809e-01f, 1.21761918e-01f, -1.34289563e-01f, 1.99616268e-01f, 4.16092947e-02f,
  -5.83591871e-02f, -7.40390643e-02f, 8.93309265e-02f, -9.00034234e-02f, -3.95666920e-02f, -2.13169932e-01f, 7.17091048e-03f, -8.49761516e-02f, -1.57691166e-01f, 1.54475495e-01f,
  -1.01693586e-01f, 6.42811880e-02f, -2.26704944e-02f, -2.43190695e-02f, 5.34158573e-02f, 3.65779884e-02f, 5.13386838e-02f, -1.63386315e-01f, -1.61621511e-01f, 1.49318516e-01f,
  8.24571587e-04f, -1.20820403e-01f, 6.63063377e-02f, -1.52515188e-01f, -2.69582774e-02f, 1.71643153e-01f, 4.40679900e-02f, -3.83897386e-02f, -1.12293825e-01f, 1.59182087e-01f,
  1.18165888e-01f, -3.74568589e-02f, -1.79844543e-01f, -1.53473839e-01f, 1.40286959e-03f, -9.25999954e-02f, -1.17039368e-01f, -3.74887660e-02f, -1.15805387e-01f, 1.43561363e-01f,
  -2.74363551e-02f, -2.90191919e-02f, -1.65097684e-01f, 8.33851844e-02f, 1.52137935e-01f, -1.47769146e-03f, -6.37439638e-03f, 2.23975573e-02f, -1.48312047e-01f, 6.99805394e-02f,
  1.45182714e-01f, -5.73225282e-02f, 4.54184748e-02f, -1.53982311e-01f, 7.35413656e-02f, 1.03347423e-02f, -3.10176499e-02f, 7.13136047e-02f, 7.47169480e-02f, -1.80051059e-01f,
  1.72921687e-01f, 2.39490181e-01f, 9.93798450e-02f, 1.28866211e-01f, 8.20013285e-02f, 1.31701663e-01f, -7.88964108e-02f, 6.86541051e-02f, -2.02965885e-01f, -2.42888182e-01f,
  7.93837458e-02f, -3.50953974e-02f, 3.47536296e-01f, 8.06853473e-02f, 2.48930231e-01f, -2.98027098e-01f, -3.44956249e-01f, 1.72550946e-01f, -5.92257529e-02f, 4.01685238e-01f,
  3.88531804e-01f, -1.94673449e-01f, 2.04615481e-02f, 3.09293787e-03f, -1.35849819e-01f, -1.68599218e-01f, 3.82108390e-01f, 3.90502810e-02f, -1.18605256e-01f, 2.46742636e-01f,
  1.20163158e-01f, 3.23553354e-01f, -6.61727116e-02f, 1.32271461e-02f, -4.01632525e-02f, -9.11654606e-02f, -3.89726274e-02f, -1.07074484e-01f, -1.47732407e-01f, -1.37551472e-01f,
  -8.85805115e-02f, 1.06019206e-01f, 5.84120303e-02f, 3.07629537e-02f, -1.25951037e-01f, -1.86627790e-01f, -2.55105626e-02f, 1.44450888e-01f, 1.90016720e-02f, 1.63163412e-02f,
  -1.56649008e-01f, -1.10625312e-01f, 6.49576858e-02f, -1.49940878e-01f, -1.62919331e-03f, 7.71323405e-03f, -1.12976870e-02f, -1.44530892e-01f, -7.82188177e-02f, 1.09057248e-01f,
  -3.53082754e-02f, -6.29513785e-02f, -7.39636421e-02f, 1.45136163e-01f, -8.62740353e-02f, -3.52909304e-02f, 3.76858264e-01f, 3.97264272e-01f, 3.53862077e-01f, 3.89520943e-01f,
  -1.68581024e-01f, -6.58244491e-02f, 4.57225502e-01f, -4.01114225e-01f, 7.82445371e-02f, 3.53224695e-01f, -1.21395431e-01f, -8.07224661e-02f, -7.48955235e-02f, 3.24982047e-01f,
  -1.33384928e-01f, -6.63712323e-02f, 1.23679593e-01f, 7.00417906e-02f, -7.30915591e-02f, -1.26430228e-01f, 1.16656117e-01f, -1.21859863e-01f, -1.12366363e-01f, -2.20693575e-04f,
  -6.34153932e-02f, 9.43641141e-02f, 1.48051865e-02f, -1.53085053e-01f, 4.84360680e-02f, 1.87959090e-01f, -1.59051731e-01f, -4.31092875e-03f, 7.24307075e-02f, 7.64958262e-02f,
  -1.44656420e-01f, -4.24958244e-02f, -4.83814441e-03f, -1.01496279e-01f, 5.12784757e-02f, -1.18783519e-01f, 9.68793929e-02f, 1.27980307e-01f, -7.64927194e-02f, -4.21911478e-02f,
  -1.77104294e-01f, -4.09759209e-02f, 6.45675883e-02f, -1.84719518e-01f, 1.54132783e-01f, 1.20830812e-01f, 1.35692418e-01f, 2.27019489e-02f, 2.09728271e-01f, -8.22497234e-02f,
  -2.95558088e-02f, -5.41578010e-02f, 1.81235313e-01f, 1.23776652e-01f, -2.38599889e-02f, 1.64454982e-01f, 1.45537153e-01f, 2.23201290e-02f, -2.26083964e-01f, 1.14490323e-01f,
  8.75643864e-02f, -8.95470753e-02f, -7.59486780e-02f, -8.18093792e-02f, 5.77100590e-02f, 4.99799065e-02f, -4.43849750e-02f, 1.65070102e-01f, 1.06001168e-01f, -1.14080600e-01f,
  -7.61055052e-02f, -2.16790527e-01f, -4.41424288e-02f, -1.54741108e-01f, -6.82597095e-03f, 9.50192884e-02f, 6.81285784e-02f, 5.93556017e-02f, 1.51242360e-01f, -6.56391233e-02f,
  1.59984343e-02f, -1.77265093e-01f, 1.34261791e-03f, -4.46913578e-02f, -1.52054667e-01f, 1.85616855e-02f, -9.62053686e-02f, -6.27166480e-02f, -1.34403080e-01f, 7.50607997e-02f,
  -6.02431595e-02f, -4.56082337e-02f, -1.16712511e-01f, -1.94549263e-01f, -1.02766544e-01f, -6.61855862e-02f, 1.59483507e-01f, 2.27523781e-02f, -3.51439081e-02f, 1.42497227e-01f,
  -2.88490266e-01f, -2.74510026e-01f, -1.88823983e-01f, 2.89520055e-01f, 5.00495248e-02f, -5.86692393e-02f, 2.73128986e-01f, -1.47310272e-01f, -1.31799579e-01f, -1.20822690e-01f,
  -6.94299266e-02f, -1.73922747e-01f, -9.63339359e-02f, 6.45423681e-02f, 3.84534240e-01f, -1.91268206e-01f, -7.63479099e-02f, -1.05786778e-01f, -6.26052096e-02f, 1.14246815e-01f,
  1.10865936e-01f, 1.96065351e-01f, 3.74258943e-02f, 6.98714033e-02f, -6.21716641e-02f, -6.19569942e-02f, 2.02718198e-01f, 2.72996128e-01f, -2.17079557e-02f, 7.22204968e-02f,
  -2.07538351e-01f, 4.39809673e-02f, -8.31695199e-02f, -3.16801161e-01f, 4.63270731e-02f, 2.09847271e-01f, -2.13237435e-01f, -7.07320198e-02f, 2.23358676e-01f, -2.66045868e-01f,
  2.43807316e-01f, 1.78939044e-01f, 9.09913108e-02f, 2.08013564e-01f, 1.45322561e-01f, 5.09639457e-02f, 6.01881504e-01f, -1.39028803e-01f, 1.09912939e-02f, 1.99484214e-01f,
  1.09228194e-01f, -3.48093510e-02f, 3.33982021e-01f, -9.04162228e-02f, -2.23774210e-01f, 2.40385458e-01f, 6.77944794e-02f, 3.51713598e-01f, 2.29343057e-01f, 3.38639587e-01f,
  -1.17882416e-01f, 4.58621085e-02f, 3.83378088e-01f, 3.87098491e-01f, 2.05823421e-01f, -3.17615509e-01f, -3.50299627e-01f, -3.53906482e-01f, -3.60533506e-01f, -3.52946781e-02f,
  -1.11068502e-01f, 1.68805420e-01f, 8.13679248e-02f, 1.86667025e-01f, 1.30476773e-01f, -1.10305674e-01f, -1.13491572e-01f, 4.90904190e-02f, 1.46223590e-01f, 2.67514884e-01f,
  -1.50901219e-02f, 1.83692500e-01f, -5.61164245e-02f, -1.76432699e-01f, -2.64379591e-01f, -1.73511580e-02f, 3.15594465e-01f, 2.21436083e-01f, -2.07952470e-01f, -3.45382988e-02f,
  1.80663154e-01f, 1.85457110e-01f, 3.55257988e-02f, -1.02338731e-01f, -1.61701605e-01f, 2.48753786e-01f, -2.68650770e-01f, -3.48731846e-01f, 6.33775117e-03f, 2.64854401e-01f,
  1.03499629e-01f, -2.58352910e-03f, 1.68107554e-01f, -1.43212274e-01f, -9.20599885e-03f, 8.22637230e-02f, 3.13856632e-01f, 3.65051180e-02f, 1.16353460e-01f, -1.20857477e-01f,
  4.77211893e-01f, -6.86654970e-02f, -1.91646427e-01f, -1.31583363e-01f, -2.17083562e-02f, 9.67167094e-02f, 3.01266074e-01f, 1.25828937e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.54266298e-01f, 2.19397202e-01f, 3.73284787e-01f, -4.29244936e-02f, -1.64126083e-01f, 4.25316304e-01f, -2.87390202e-02f, 2.23339304e-01f, -2.08471087e-03f, 2.13895082e-01f,
  -9.35820788e-02f, 2.47609660e-01f, 2.50107467e-01f, 3.97051096e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -4.84050177e-02f, -9.09739137e-02f, -2.54996300e-01f, 9.47508812e-02f, -4.34557535e-02f, 1.54119387e-01f, 4.54469249e-02f, -1.24026008e-01f, -3.02380562e-01f, -2.35286176e-01f,
  -2.75206089e-01f, -2.47212276e-01f, 4.40667942e-02f, 3.41002524e-01f, 2.23198831e-01f, 2.28978142e-01f, 1.18798941e-01f, -3.73135954e-01f, -2.11009860e-01f, -1.20775819e-01f,
  1.43454745e-01f, -5.06991595e-02f, 6.19620495e-02f, -2.47383744e-01f, -1.47437854e-02f, -3.91326584e-02f, 1.43230855e-01f, 1.38844505e-01f, 8.76396745e-02f, -3.88282388e-02f,
  4.08321619e-01f, 6.43824413e-02f, 8.82868543e-02f, 2.06526414e-01f, -3.01800966e-01f, -3.17583442e-01f, -2.11725399e-01f, -6.41430840e-02f, -1.09795809e-01f, 8.18624571e-02f,
  -3.79723430e-01f, 4.42057364e-02f, 1.92655638e-01f, -5.32901406e-01f, -4.45763357e-02f, 4.64273244e-02f, -2.78128311e-02f, 1.52955219e-01f, 2.37707779e-01f, -3.71457547e-01f,
  4.20329198e-02f, 2.65113920e-01f, -7.43926386e-04f, 1.24982119e-01f, 1.13380499e-01f, 2.12016717e-01f, 1.14272639e-01f, -4.11301404e-01f, 2.00901683e-02f, 5.10123037e-02f,
  -1.86826587e-01f, -1.25866920e-01f, 2.75801808e-01f, -1.63273096e-01f, -6.09960705e-02f, -1.06653050e-01f, -2.41158962e-01f, -1.76666662e-01f, 2.08982229e-01f, -5.82733341e-02f,
  -1.41731173e-01f, -1.32227153e-01f, 8.61849710e-02f, -1.48918599e-01f, 2.42209770e-02f, 3.13794792e-01f, 2.88066059e-01f, 2.83616722e-01f, 1.82285517e-01f, 4.76137996e-01f,
  -2.54730701e-01f, 4.53874171e-01f, 2.69291610e-01f, -1.67615622e-01f, 8.82781148e-02f, 1.91528186e-01f, -1.53490648e-01f, 1.47434875e-01f, -1.19773678e-01f, -2.00757489e-01f,
  4.26544920e-02f, 1.24514543e-01f, 3.49307954e-01f, 3.32646132e-01f, -2.30345994e-01f, 3.69130403e-01f, 1.21009402e-01f, 1.84047028e-01f, 1.60781920e-01f, -9.64934826e-02f,
  -3.66343558e-02f, 3.01875751e-02f, -2.12411493e-01f, -1.24312259e-01f, -2.35299066e-01f, -3.80112492e-02f, -3.66123229e-01f, 2.60646436e-02f, -1.57634929e-01f, -1.29620656e-01f,
  -2.31867135e-01f, 3.74846995e-01f, -1.56043693e-01f, 1.47739694e-01f, 9.87353474e-02f, 1.29847124e-01f, -3.71994749e-02f, -4.31124642e-02f, -9.84053537e-02f, 2.76427984e-01f,
  1.67511061e-01f, 1.69991180e-01f, -1.71436906e-01f, 7.18933344e-02f, -2.09552869e-01f, -3.52049202e-01f, 1.56837076e-01f, -2.42023036e-01f, 9.58420858e-02f, 1.94065019e-01f,
  2.56425828e-01f, -4.96972539e-02f, 1.39501423e-01f, -1.00953810e-01f, -1.75583914e-01f, 1.96533829e-01f, 2.92205036e-01f, -1.96637750e-01f, -2.72924513e-01f, 1.24248654e-01f,
  -4.65685666e-01f, -1.31198183e-01f, -4.80393112e-01f, 1.12056762e-01f, -1.06009163e-01f, 3.86148244e-01f, -1.88542008e-01f, 5.08389324e-02f, -8.99126055e-04f, -1.13779176e-02f,
  4.58280183e-02f, 4.24786508e-01f, -5.78811504e-02f, 6.69383928e-02f, -1.43252954e-01f, -5.12342416e-02f, 6.46508038e-02f, -2.43123442e-01f, -1.95276216e-01f, -9.68527198e-02f,
  1.00179732e-01f, -6.09508157e-02f, -5.12012430e-02f, -2.55161792e-01f, 2.34966278e-02f, 1.31610374e-03f, -2.27325782e-01f, -5.74208908e-02f, -2.13885769e-01f, -1.81873083e-01f,
  -6.93402946e-01f, 4.73639697e-01f, 1.02488816e-01f, -4.80830334e-02f, -3.60131897e-02f, 4.38343138e-01f, -5.83923310e-02f, 5.94988585e-01f, 3.79600795e-03f, -2.76801139e-01f,
  2.36255631e-01f, 3.45945582e-02f, -4.13124897e-02f, 1.60807341e-01f, 1.72578722e-01f, 2.33031064e-01f, 1.11555070e-01f, -9.12458301e-02f, 9.09441859e-02f, -3.05166841e-02f,
  3.85632776e-02f, -2.99418718e-01f, -4.98118401e-02f, -2.46068642e-01f, -9.05785188e-02f, 2.96644837e-01f, 1.93729520e-01f, 1.22638486e-01f, 1.83667466e-01f, 6.70946762e-02f,
  3.03674012e-01f, -1.58103809e-01f, -4.59992617e-01f, 2.10030302e-01f, -3.39546353e-01f, -3.12797993e-01f, -3.09006244e-01f, 9.53590423e-02f, 1.10373698e-01f, 1.42411023e-01f,
  -6.91434592e-02f, 6.07793033e-03f, -2.09757298e-01f, 3.24380537e-03f, -1.48566067e-01f, 4.86280695e-02f, 1.44489482e-01f, 8.10893103e-02f, 1.96990892e-01f, -3.76066589e-03f,
  5.54071404e-02f, -3.04684434e-02f, 1.56319544e-01f, -7.12611452e-02f, 3.77569079e-01f, 3.04223537e-01f, 1.66331962e-01f, 8.34070444e-02f, 1.83987066e-01f, -1.45337015e-01f,
  -1.19937606e-01f, 1.94104284e-01f, -1.54298082e-01f, -2.64978141e-01f, -5.85281670e-01f, 3.62419724e-01f, -1.07254222e-01f, 1.03998750e-01f, -1.89336732e-01f, 1.13993853e-01f,
  -2.59798437e-01f, 4.40601885e-01f, -1.90526515e-01f, -8.11325088e-02f, 1.79770842e-01f, 1.68981180e-01f, 4.44096513e-02f, 1.32174427e-02f, -7.73949698e-02f, 1.93123117e-01f,
  2.30773076e-01f, 1.33325875e-01f, -2.56963521e-01f, -3.01158838e-02f, 9.54680368e-02f, -2.88176686e-01f, 1.35612130e-01f, -4.76226658e-02f, 5.09541072e-02f, -2.13697314e-01f,
  -1.18650272e-01f, -1.39934629e-01f, 1.18494861e-01f, -1.45407334e-01f, -5.48182279e-02f, 1.17964018e-02f, -1.99173003e-01f, 2.38088697e-01f, -4.10803378e-01f, -9.45408791e-02f,
  -2.15590045e-01f, 1.22492351e-01f, 4.11631074e-03f, 4.03241456e-01f, 1.06063157e-01f, 1.59188464e-01f, -2.01024190e-01f, -3.79519686e-02f, 3.82764712e-02f, 4.88439023e-01f,
  9.94770601e-02f, 6.16671816e-02f, 2.37929299e-01f, 8.63297004e-03f, -3.93540375e-02f, -4.34610769e-02f, -1.92815065e-02f, -1.22876018e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.61046982e-01f, 1.40486300e-01f, 8.44252412e-04f, 1.15990914e-01f, 2.13358626e-01f, 1.34382457e-01f, 6.47361204e-02f, 3.66134286e-01f, 2.19171166e-01f, 4.18000251e-01f,
  6.42743587e-01f, -1.32407537e-02f, 3.78451422e-02f, -2.42256954e-01f, -1.13173664e-01f, -7.28497431e-02f, -2.39982843e-01f, 1.28337026e-01f, 3.67544651e-01f, 4.68755215e-01f,
  -1.25772133e-01f, -1.13094293e-01f, -6.87359050e-02f, 4.34703827e-01f, 1.03681885e-01f, -3.53156984e-01f, -1.83807895e-01f, -1.85289666e-01f, 2.29283378e-01f, 3.36454570e-01f,
  -2.22390339e-01f, 1.66269302e-01f, 1.53542653e-01f, 2.88096458e-01f, 2.26915896e-01f, 1.69981509e-01f, 1.36606589e-01f, 2.71341875e-02f, -1.30461380e-02f, 5.72574288e-02f,
  2.46355429e-01f, 2.60083899e-02f, 8.67588744e-02f, -8.16862378e-03f, 1.10427909e-01f, 1.42717332e-01f, 7.54990652e-02f, 4.34513986e-02f, 1.43048406e-01f, -1.94774464e-01f,
  -9.46718529e-02f, 2.10004989e-02f, 4.53292951e-02f, 2.02748366e-02f, -1.66208670e-01f, -6.30157515e-02f, 9.62995589e-02f, 1.49244860e-01f, -9.11472291e-02f, -1.68677539e-01f,
  -1.52091578e-01f, 9.22862068e-02f, 2.22163141e-01f, 1.09241838e-02f, -1.38673797e-01f, -4.32257354e-02f, 8.22778940e-02f, 3.22476625e-02f, 2.00829789e-01f, 2.30591223e-01f,
  7.85518289e-02f, 2.14089707e-01f, 3.34249407e-01f, 2.81015009e-01f, 1.48233131e-01f, 2.86036730e-01f, 3.02636772e-01f, 2.10221097e-01f, -1.11810379e-01f, -1.44643754e-01f,
  -1.42938599e-01f, 1.22565292e-01f, 3.17065150e-01f, 1.99590698e-01f, 1.04084045e-01f, 6.97783306e-02f, 7.53177404e-02f, 1.48447258e-02f, -1.09982453e-01f, 3.84898782e-02f,
  -1.01573154e-01f, -2.81809092e-01f, 1.56340063e-01f, 2.89390951e-01f, -3.50958973e-01f, 3.50546449e-01f, -6.12253137e-02f, 1.47782221e-01f, -5.52682281e-02f, -8.59665424e-02f,
  1.10166915e-01f, -6.13368722e-03f, 6.64790943e-02f, 1.94611058e-01f, 1.45277634e-01f, -3.96518856e-02f, 7.85580184e-03f, -2.11125806e-01f, 5.51713742e-02f, -8.93504766e-04f,
  -2.31569842e-01f, -1.80210814e-01f, -1.21640518e-01f, 1.90153822e-01f, 1.05525322e-01f, 1.88415706e-01f, -1.79954484e-01f, 6.15739599e-02f, 1.22006007e-01f, 9.46618915e-02f,
  1.09437421e-01f, 2.33237781e-02f, -1.88410785e-02f, -1.42391145e-01f, -4.97277007e-02f, -7.28639355e-03f, -9.93996039e-02f, -6.22073971e-02f, -2.06833780e-01f, -1.26547813e-01f,
  -1.45001605e-01f, -1.39783889e-01f, 2.05102578e-01f, -1.75054118e-01f, 1.78406283e-01f, -8.72005895e-02f, 1.92466840e-01f, 5.65240607e-02f, 3.07139717e-02f, 1.04256667e-01f,
  9.40268934e-02f, 3.45527828e-02f, -2.11108699e-01f, -1.86203450e-01f, -2.98607290e-01f, 2.13651638e-02f, 3.03173542e-01f, 7.57647902e-02f, -3.57956700e-02f, 1.16834000e-01f,
  1.27704427e-01f, -1.01585150e-01f, 1.00185297e-01f, -1.65182292e-01f, -1.12917826e-01f, -1.43733457e-01f, 2.53933668e-01f, 3.18816781e-01f, -1.13298312e-01f, 3.06750476e-01f,
  1.67629525e-01f, -1.66088849e-01f, -5.79165518e-02f, 3.88214767e-01f, 1.48489878e-01f, 7.78740272e-02f, 3.94368172e-01f, 1.73496321e-01f, 1.73742533e-01f, 4.65925217e-01f,
  4.53723520e-01f, -8.45938087e-01f, 9.62898433e-02f, 6.03269860e-02f, 4.47159231e-01f, 5.23880348e-02f, 2.85080314e-01f, -5.50734401e-01f, -5.60651310e-02f, 3.48863810e-01f,
  -1.60966948e-01f, -2.00050950e-01f, -2.54493892e-01f, -6.81408942e-02f, 1.04042307e-01f, -2.75039792e-01f, -3.46864350e-02f, 1.05155215e-01f, 3.26437294e-01f, 2.94668078e-01f,
  5.69634318e-01f, 4.67055798e-01f, 3.01876187e-01f, -1.90775946e-01f, 1.01697966e-01f, -1.83471024e-01f, 3.23441550e-02f, 1.05675906e-01f, 4.76581529e-02f, 2.18491912e-01f,
  2.00937584e-01f, -2.32889846e-01f, -2.44230069e-02f, 6.70326054e-02f, -1.09058738e-01f, 1.01465881e-01f, -3.97859365e-02f, 5.74004762e-02f, 1.07128441e-01f, 2.94104129e-01f,
  -5.05539104e-02f, -6.60762414e-02f, 4.09848720e-01f, 3.38504054e-02f, -1.63382128e-01f, 2.06690118e-01f, 8.46463740e-02f, 1.19868495e-01f, -4.23019640e-02f, -1.84754387e-01f,
  -1.14024170e-01f, 1.75730959e-01f, 1.85891613e-01f, 2.27156445e-01f, -1.78107321e-01f, -2.16894731e-01f, -2.30177447e-01f, 7.00154454e-02f, 5.45408949e-02f, 1.15155719e-01f,
  -9.18475166e-02f, -1.38229787e-01f, -5.75873768e-03f, -9.46313664e-02f, -1.10403724e-01f, 3.27357739e-01f, 1.35699317e-01f, 1.26192749e-01f, -4.14408445e-02f, -1.46222934e-01f,
  -1.14322789e-01f, 2.34234303e-01f, 7.90793523e-02f, 6.39787316e-02f, 1.02759846e-01f, -8.32056627e-02f, -1.04534924e-01f, 1.55792207e-01f, -1.08745620e-01f, 1.37214854e-01f,
  -1.67810824e-02f, -4.78332080e-02f, 1.76290318e-01f, 2.22035632e-01f, 8.66013914e-02f, 1.95284888e-01f, -1.42868180e-02f, 1.09170690e-01f, -1.79501817e-01f, -3.58136803e-01f,
  -1.33192567e-02f, 7.57211894e-02f, 3.95593755e-02f, 2.70701885e-01f, -2.02987045e-01f, 2.29069337e-01f, -1.11528434e-01f, 5.84187686e-01f, 6.93653598e-02f, 1.94628730e-01f,
  -1.46225408e-01f, 6.95097297e-02f, -4.50079650e-01f, 5.15805662e-01f, 5.25898516e-01f, -1.94228500e-01f, 6.69412494e-01f, -1.08831547e-01f, 1.85005590e-01f, 1.51357308e-01f,
  -1.26103610e-02f, -1.86060056e-01f, 1.25827864e-01f, -1.01465322e-02f, -4.78645833e-03f, 3.67234677e-01f, -1.71169430e-01f, 2.94699222e-01f, 2.89057463e-01f, 8.38348344e-02f,
  6.16364956e-01f, 5.13572395e-01f, 1.64303362e-01f, 3.30506742e-01f, 1.37267262e-01f, 2.96526074e-01f, 2.69562304e-01f, 1.22833904e-02f, -1.07944794e-01f, 5.66547990e-01f,
  2.62911439e-01f, 2.50485003e-01f, 2.13000581e-01f, -6.18685246e-01f, -2.65258193e-01f, -2.01480597e-01f, -2.39225551e-01f, -3.60366452e-04f, 6.62035525e-01f, -1.12343254e-02f,
  -9.14609656e-02f, 1.34193525e-02f, 1.21474296e-01f, 7.55328119e-01f, 5.64032309e-02f, -7.73519278e-02f, -4.37104292e-02f, -1.93746105e-01f, -8.87434632e-02f, -2.06905171e-01f,
  2.54764110e-01f, 8.54296014e-02f, 3.61420244e-01f, -4.18891907e-01f, -1.69568956e-01f, 1.13157049e-01f, -3.15801054e-02f, 2.32521147e-01f, -4.80186045e-02f, -2.60128438e-01f,
  -9.29494053e-02f, 1.90167446e-02f, -2.09563419e-01f, -2.07264088e-02f, -4.90433984e-02f, 2.25009602e-02f, 1.29360542e-01f, 1.42020479e-01f, 3.26195866e-01f, 7.65134301e-03f,
  2.29802847e-01f, 1.64284900e-01f, -4.80844192e-02f, 2.98613548e-01f, -3.20462510e-02f, -1.71366632e-01f, -1.10312328e-01f, -4.30103280e-02f, 1.65217698e-01f, 7.71315470e-02f,
  9.57956538e-02f, 1.71908200e-01f, 1.55657455e-01f, -1.74209848e-01f, 3.02088242e-02f, -2.94546366e-01f, -3.66774201e-02f, 1.72170401e-01f, -9.34845507e-02f, 1.80157170e-01f,
  -5.55960201e-02f, -5.60601093e-02f, 1.54498190e-01f, -3.42674524e-01f, 1.04507677e-01f, -1.15557060e-01f, -5.61313331e-02f, 9.56076011e-03f, 3.24743450e-01f, 8.66087899e-02f,
  -1.97590664e-02f, 3.86585474e-01f, -6.48988830e-03f, 2.46230066e-02f, -1.64381728e-01f, 3.28646123e-01f, -1.04317060e-02f, 5.38678057e-02f, 1.56238481e-01f, -9.42403823e-02f,
  1.76792130e-01f, -2.68697292e-02f, 1.24437816e-01f, 9.86658037e-02f, 9.27547067e-02f, -2.42477544e-02f, 2.57679641e-01f, 3.97339612e-01f, 2.15157807e-01f, 2.24299252e-01f,
  4.39075410e-01f, 2.47512773e-01f, 1.96940273e-01f, 1.95040986e-01f, -1.30971387e-01f, -3.67507994e-01f, -5.93991816e-01f, -5.72104394e-01f, -4.18798774e-01f, -3.18824291e-01f,
  3.20854276e-01f, 1.05421744e-01f, -3.14286292e-01f, 5.21151006e-01f, -5.78881383e-01f, -2.37616990e-02f, -1.38553768e-01f, 6.00648940e-01f, -1.50247052e-01f, 5.97001836e-02f,
  -9.72604677e-02f, 4.35688123e-02f, -9.61812213e-02f, 5.47826430e-03f, -2.86665726e-02f, 1.42849376e-02f, 3.60478103e-01f, 1.76649049e-01f, 3.29088122e-01f, 1.20308623e-01f,
  3.77567589e-01f, 2.26578668e-01f, 4.03853774e-01f, 1.90985724e-01f, -1.99450925e-01f, -5.26145875e-01f, -6.99543417e-01f, -3.15942079e-01f, -1.73705801e-01f, 1.87641203e-01f,
  2.75604457e-01f, 5.77963769e-01f, 2.28118435e-01f, 6.45253956e-02f, 9.28918719e-02f, -3.36161107e-01f, 5.59087276e-01f, -1.62625968e-01f, 1.17269225e-01f, 2.39541400e-02f,
  1.51246667e-01f, 7.34538585e-02f, -1.34704486e-01f, 1.25837088e-01f, -1.37284800e-01f, 6.62090480e-02f, 5.35087168e-01f, -1.96888626e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  3.34121943e-01f, -3.18350755e-02f, 3.82389911e-02f, 1.84441954e-01f, -3.91950123e-02f, 2.71215498e-01f, 6.09635003e-02f, 6.56095380e-03f, 2.77995676e-01f, 3.46564740e-01f,
  2.21499458e-01f, 1.96358547e-01f, 3.10509354e-01f, 2.69493401e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  3.45280692e-02f, -2.33592302e-01f, -5.63275099e-01f, -4.26968008e-01f, -2.14082286e-01f, -1.20011769e-01f, -3.15903462e-02f, -4.33342844e-01f, -1.25025898e-01f, -1.98021770e-01f,
  -2.68017232e-01f, -1.27549507e-02f, 1.33340225e-01f, -2.91307747e-01f, -2.58925110e-01f, -7.66165107e-02f, -2.37010494e-01f, -1.01315416e-01f, 2.85553068e-01f, -4.69612256e-02f,
  5.19801557e-01f, 8.14720392e-02f, 6.08057678e-01f, 3.67735118e-01f, -5.87636940e-02f, 1.54123932e-01f, 2.97705054e-01f, -3.44960243e-01f, 4.53435890e-02f, 7.40374997e-02f,
  -5.79703748e-01f, -1.26472935e-01f, 1.69426158e-01f, -4.05261256e-02f, -2.39208639e-01f, 1.00529194e-01f, 2.50396669e-01f, 4.70723301e-01f, 9.64931548e-02f, 2.49241546e-01f,
  -3.48350927e-02f, -3.19086343e-01f, -8.66660550e-02f, 3.35891843e-01f, -3.97006124e-01f, -1.35608852e-01f, 3.79988998e-01f, -2.25118205e-01f, 2.56223023e-01f, -1.29281860e-02f,
  5.92946000e-02f, -2.52077520e-01f, 3.63392323e-01f, -4.29589972e-02f, 1.19060248e-01f, -7.31418371e-01f, 2.94978976e-01f, 2.88361579e-01f, 1.08176875e+00f, 1.16899833e-01f,
  -6.66360334e-02f, -1.25977218e-01f, -3.56162995e-01f, -4.19493914e-01f, -3.11820656e-01f, 2.43425071e-01f, 1.69392124e-01f, 3.67803514e-01f, 4.20599401e-01f, -1.30133629e-01f,
  1.82983369e-01f, 4.56550926e-01f, 6.96778536e-01f, -5.28886318e-01f, -5.18569589e-01f, -2.72689581e-01f, -1.72120824e-01f, 4.83324558e-01f, -6.11188829e-01f, 5.34812696e-02f,
  -3.39185864e-01f, 5.88447712e-02f, 5.86129367e-01f, 1.04943901e-01f, 3.68625700e-01f, 2.00118929e-01f, 2.22944751e-01f, -8.58039632e-02f, -3.87045473e-01f, -8.52497220e-02f,
  -8.85947868e-02f, 2.76945561e-01f, -4.18423772e-01f, -3.59710336e-01f, 4.01291460e-01f, -3.92141402e-01f, -2.30120718e-01f, 4.20159847e-02f, 3.32580298e-01f, -3.17750610e-02f,
  4.82338108e-02f, 6.43327385e-02f, -5.30335419e-02f, 3.44215661e-01f, 9.10297409e-02f, 3.88795137e-01f, 5.08671641e-01f, 3.92250642e-02f, -9.53686163e-02f, -5.89778721e-01f,
  -5.24170935e-01f, -1.55573949e-01f, -3.38051528e-01f, -4.99580234e-01f, -1.86157197e-01f, 2.69111246e-01f, -3.05542648e-01f, 4.50891592e-02f, -1.42499194e-01f, 8.25874925e-01f,
  9.80241075e-02f, -2.02173397e-01f, -9.52251405e-02f, -5.30366540e-01f, -2.25574866e-01f, -1.23785079e-01f, -2.95891523e-01f, 5.27534723e-01f, 1.87090769e-01f, 4.47060391e-02f,
  3.19405854e-01f, -3.00547302e-01f, -3.10446210e-02f, -3.61611098e-01f, -1.35617582e-02f, -5.42174816e-01f, 1.38165742e-01f, 1.96998566e-01f, 2.38148764e-01f, 2.56714493e-01f,
  -1.96600020e-01f, -5.95888793e-01f, 1.05488434e-01f, -1.21976528e-02f, -3.38940293e-01f, -3.06199104e-01f, 3.28143477e-01f, -9.83895361e-02f, -1.25810295e-01f, -1.67912886e-01f,
  5.81430867e-02f, 9.56741333e-01f, -2.82357007e-01f, 4.81613837e-02f, -3.40945452e-01f, -2.98064709e-01f, -4.76826251e-01f, 2.03002363e-01f, 1.75318375e-01f, -5.92785776e-01f,
  3.85222137e-01f, 1.36131316e-01f, 6.61545038e-01f, -1.02964461e-01f, 3.87518018e-01f, 2.35536397e-01f, 1.95319891e-01f, 3.92173678e-01f, 7.79449642e-02f, -1.38171345e-01f,
  -4.41269249e-01f, 2.39922300e-01f, -4.66614157e-01f, -1.28980204e-01f, -1.66635588e-01f, -3.64739329e-01f, -5.70805557e-02f, -4.79748517e-01f, -8.83307979e-02f, 3.32875222e-01f,
  3.09363633e-01f, -1.24721730e-03f, -3.22588235e-01f, 1.16287209e-02f, 3.47696662e-01f, -1.63539767e-01f, -1.36059582e-01f, 8.28651011e-01f, 6.87307864e-02f, 3.01667899e-01f,
  -4.14856613e-01f, -3.61312807e-01f, -5.99660397e-01f, 1.96198747e-01f, 6.44354820e-02f, 4.13560197e-02f, -6.59007430e-01f, 5.31598747e-01f, -6.21351786e-02f, 3.14877510e-01f,
  -6.64543569e-01f, -1.14141963e-01f, 5.41579612e-02f, -2.97438622e-01f, 2.57855922e-01f, -5.73493075e-03f, -2.30927065e-01f, 2.06570700e-01f, 5.34858882e-01f, 2.61081994e-01f,
  3.61329854e-01f, 4.17821109e-02f, -6.52878210e-02f, 1.70572788e-01f, 6.44069351e-03f, -6.78883731e-01f, -2.19558179e-02f, 2.42026858e-02f, -1.61268502e-01f, -9.14905742e-02f,
  1.51909903e-01f, 1.02190077e-01f, 8.00882697e-01f, -4.24700081e-01f, -3.90549265e-02f, -1.86134502e-01f, -3.93828571e-01f, -3.62910956e-01f, -4.03611869e-01f, 5.98874837e-02f,
  1.93957195e-01f, -7.78315142e-02f, -4.45632577e-01f, -1.79141879e-01f, 5.65438509e-01f, 5.44400930e-01f, 4.49893981e-01f, 3.35798234e-01f, 3.65622610e-01f, -1.65244728e-01f,
  2.38731116e-01f, 3.56408596e-01f, 2.42558986e-01f, -3.22942734e-02f, -5.09181470e-02f, 3.22138034e-02f, 2.52007768e-02f, -2.93494940e-01f, 1.18736096e-01f, -9.52809826e-02f,
  5.25812745e-01f, -4.29883003e-01f, 5.28551042e-01f, 2.05159515e-01f, -2.10474655e-01f, 5.68781555e-01f, -6.29172996e-02f, -4.41968948e-01f, 3.97106335e-02f, 1.99272018e-02f,
  7.26239681e-02f, -2.54111081e-01f, 1.38768191e-02f, -4.42085624e-01f, 1.24765687e-01f, 1.16457388e-01f, -4.14058298e-01f, -1.15496516e-02f, 2.09645554e-01f, 5.31253517e-01f,
  6.76571429e-01f, 5.35771728e-01f, 4.65359911e-02f, 1.79227218e-02f, -5.44269800e-01f, -8.34956020e-03f, -5.19103408e-02f, -1.97557494e-01f, 1.23482808e-01f, -4.50092703e-01f,
  2.84658343e-01f, 2.83304811e-01f, 2.83717960e-01f, 6.33063555e-01f, -1.07623070e-01f, -3.55733544e-01f, -3.63451481e-01f, 5.72526574e-01f, -1.45166561e-01f, -1.94417998e-01f,
  3.28641087e-02f, 6.86312541e-02f, -3.90158519e-02f, -3.44977081e-01f, 3.97693403e-02f, -1.66705996e-01f, -1.28305748e-01f, -3.68534386e-01f, 4.70244080e-01f, -2.52173990e-01f,
  3.98039818e-02f, 6.29236400e-01f, -2.68244863e-01f, 1.14540458e-01f, -7.23957062e-01f, 5.07811904e-01f, 3.63969237e-01f, -2.53850847e-01f, 7.65491463e-03f, 1.61825910e-01f,
  5.38455434e-02f, 2.51607180e-01f, 1.02625810e-01f, -5.70174158e-02f, -3.60119969e-01f, -8.59426081e-01f, 4.87377010e-02f, 4.72980469e-01f, 6.30484700e-01f, -2.93352485e-01f,
  -5.45029044e-02f, 1.68957531e-01f, -2.96901405e-01f, 2.17132866e-01f, 2.98788637e-01f, 4.73854303e-01f, 2.85340428e-01f, 3.33278447e-01f, -2.72677541e-02f, 6.29838824e-01f,
  2.49678805e-01f, -5.75642943e-01f, -2.57497150e-02f, -4.35161561e-01f, -4.00320917e-01f, -3.09610248e-01f, 3.37798715e-01f, -6.43412590e-01f, -6.89047754e-01f, 1.48657531e-01f,
  -5.06341398e-01f, -1.43155918e-01f, -1.40372366e-01f, -2.24899612e-02f, -1.04552910e-01f, -1.73526198e-01f, -3.33648801e-01f, 7.25557446e-01f, -3.43026854e-02f, -1.57168761e-01f,
  -1.78316146e-01f, 6.26049340e-01f, 3.44839871e-01f, 2.07484215e-01f, -6.23020716e-02f, 2.06043273e-01f, -8.09358209e-02f, 1.60022721e-01f, -4.54729855e-01f, -1.67129546e-01f,
  -2.04322189e-02f, -2.30140332e-02f, -3.14690709e-01f, 1.27955880e-02f, 2.91911274e-01f, 4.79635030e-01f, 5.28849363e-01f, 3.93243492e-01f, 4.56081063e-01f, 5.46756685e-01f,
  -5.50667882e-01f, 1.69709288e-02f, -2.70541489e-01f, 1.08139291e-01f, -1.15152925e-01f, -1.41071334e-01f, 3.34707916e-01f, -1.03267275e-01f, -4.27298546e-01f, -3.08867041e-02f,
  -8.76733288e-02f, 1.54374272e-01f, 8.40799034e-01f, 5.77129424e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.55925149e-01f, -3.35167721e-02f, 8.73593390e-02f, 1.32097036e-01f, -7.50118587e-03f, 2.04468042e-01f, -2.07384899e-01f, -1.07506618e-01f, -1.75576568e-01f, -2.77836740e-01f,
  -2.55711330e-03f, 2.14576587e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    