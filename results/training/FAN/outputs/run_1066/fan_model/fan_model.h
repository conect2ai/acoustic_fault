/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.46333218e-01f, -1.59564801e-02f, -6.13337398e-01f, -1.82619095e-01f, 1.57550201e-02f, -9.89715233e-02f, -1.24747120e-01f, 5.89348702e-03f, -3.23680304e-02f, -8.01467001e-02f,
  1.18091837e-01f, 3.04633766e-01f, 2.41462559e-01f, 2.09342539e-01f, 1.24680251e-02f, -3.88985639e-03f, -1.21283852e-01f, -2.84511745e-01f, -1.28194496e-01f, -9.73924249e-03f,
  2.19518796e-01f, -3.19814915e-03f, -2.03466147e-01f, -6.01316057e-02f, 7.03393891e-02f, 3.05512160e-01f, -6.36356026e-02f, 3.25823501e-02f, 1.59531370e-01f, 9.17922705e-02f,
  -2.89696515e-01f, -2.58202970e-01f, 8.15252960e-02f, 2.00110257e-01f, -4.57363529e-03f, 6.27086908e-02f, -2.05392260e-02f, 3.96921299e-02f, 8.58133212e-02f, 3.18630077e-02f,
  -3.34897265e-02f, -6.64605126e-02f, 5.59296161e-02f, 6.89776465e-02f, -6.70438856e-02f, -8.49249586e-02f, 5.71729355e-02f, -7.02417716e-02f, 6.49640486e-02f, 8.57442245e-02f,
  2.63638824e-01f, -1.27051845e-01f, -1.27648309e-01f, 1.08833455e-01f, -5.49931489e-02f, 8.55423585e-02f, -2.97772669e-04f, -5.09584732e-02f, 5.06760878e-03f, 7.86104575e-02f,
  1.22548811e-01f, -1.62598670e-01f, -1.08534165e-01f, -1.41185231e-03f, 6.78709075e-02f, 7.39598600e-03f, -1.49073871e-02f, 5.28388210e-02f, -2.35806610e-02f, -6.95478395e-02f,
  -2.63881478e-02f, -1.10661462e-02f, -1.51543468e-02f, 1.52001167e-02f, 1.22439653e-01f, -6.41672909e-02f, -4.20894176e-02f, 2.73828823e-02f, 3.07450071e-02f, 1.61861640e-03f,
  -7.55121326e-03f, -8.64369124e-02f, 1.80247352e-02f, 1.40495943e-02f, -7.30191357e-03f, -5.10184914e-02f, -4.48830090e-02f, 5.64841554e-02f, -2.04914482e-03f, -4.56802510e-02f,
  2.26876006e-01f, 3.62797678e-02f, 5.65910935e-02f, -9.21326969e-03f, 3.65643129e-02f, 8.21078420e-02f, 4.31728400e-02f, 2.67739929e-02f, 1.09488390e-01f, 4.10175286e-02f,
  -4.76460031e-04f, -1.14429919e-02f, -4.89368290e-02f, 6.02805838e-02f, -4.85853963e-02f, 8.74834657e-02f, 8.91524926e-02f, 2.99267080e-02f, -3.21874693e-02f, -3.76970582e-02f,
  1.16412237e-01f, -3.24956514e-02f, -1.89303681e-01f, 3.39021869e-02f, 1.29307192e-02f, 6.39710873e-02f, -1.29537694e-02f, 5.62448166e-02f, -7.17264414e-02f, 4.12014574e-02f,
  4.41609561e-01f, -5.04644036e-01f, 1.73022196e-01f, 2.75409907e-01f, -1.80337988e-02f, -2.90253013e-01f, -5.17358541e-01f, -1.56444043e-01f, 1.08791165e-01f, -6.29037097e-02f,
  3.15898247e-02f, 3.40344280e-01f, 2.84865677e-01f, 2.17506915e-01f, 5.72119653e-03f, -2.50301331e-01f, -2.17566758e-01f, 2.34353796e-01f, 4.44319218e-01f, 1.80398911e-01f,
  4.26859036e-02f, 5.26828691e-02f, 8.70171636e-02f, 4.01437543e-02f, 1.41633702e-02f, 2.79984325e-01f, -1.14825800e-01f, 6.58792853e-02f, -1.23671435e-01f, 1.89269871e-01f,
  3.86524171e-01f, 1.47661775e-01f, 1.93428248e-01f, 3.42895016e-02f, -8.66607111e-03f, 9.82576013e-02f, 9.29646716e-02f, 1.44762442e-01f, 6.70754258e-03f, 3.79409976e-02f,
  9.41276699e-02f, 7.14130402e-02f, 1.61345348e-01f, 8.39575231e-02f, -1.56975146e-02f, 7.80436993e-02f, 1.35161608e-01f, 1.25986367e-01f, 7.84942433e-02f, 1.44066093e-02f,
  4.56458330e-03f, 2.69870497e-02f, 1.28514886e-01f, 2.52914131e-02f, 4.23605517e-02f, 2.63859600e-01f, -4.98342887e-02f, 1.84140444e-01f, 1.99169144e-01f, 2.69619338e-02f,
  -9.87771526e-02f, -9.66120735e-02f, -3.88441533e-02f, -5.15860654e-02f, -6.65755793e-02f, -1.23936735e-01f, -1.11427903e-02f, -1.34721845e-01f, -1.22882975e-02f, -1.21433027e-01f,
  -5.81024215e-03f, -3.91224492e-03f, -1.65379215e-02f, -2.00801622e-02f, 4.97232340e-02f, -1.25575047e-02f, 6.73273057e-02f, -3.50867175e-02f, -5.01490459e-02f, 8.49523954e-03f,
  1.51370503e-02f, 5.81765920e-02f, 2.02925969e-02f, -3.76393029e-04f, -3.56438458e-02f, -3.93060148e-02f, 5.38113564e-02f, -3.36312875e-02f, -9.22697932e-02f, -1.03480592e-01f,
  7.37939999e-02f, -7.23788841e-03f, 1.54941186e-01f, 1.95945099e-01f, 1.01715066e-01f, 9.88928229e-02f, 6.60918280e-02f, 7.33053759e-02f, 1.12786651e-01f, 5.14776297e-02f,
  1.05389141e-01f, 1.47396043e-01f, 7.18900636e-02f, 1.48884773e-01f, 1.79065794e-01f, 9.87103134e-02f, -4.28210385e-02f, 1.97240636e-01f, 6.47988543e-02f, 5.35468496e-02f,
  -7.22775832e-02f, 2.99934912e-02f, -8.29983409e-03f, 1.65635645e-02f, 1.05669558e-01f, 1.81896418e-01f, 5.34843393e-02f, 3.38626318e-02f, 8.92780721e-02f, -1.94049269e-01f,
  -1.30609423e-01f, 6.92444071e-02f, 5.18015325e-02f, -1.98494241e-01f, -1.21128246e-01f, -1.62652478e-01f, -4.79926057e-02f, -5.51129915e-02f, -4.46237549e-02f, -1.85063228e-01f,
  -1.55146718e-01f, -2.02595010e-01f, -1.62672669e-01f, -7.63604343e-02f, -1.53412700e-01f, -2.03250855e-01f, -1.32877231e-01f, -1.56233624e-01f, -2.51398504e-01f, -2.51318455e-01f,
  -2.85915375e-01f, -2.15179637e-01f, -3.00880581e-01f, -1.05992995e-01f, -2.46523753e-01f, -2.15320125e-01f, -1.29854888e-01f, -4.82367650e-02f, -1.47154108e-01f, -7.08832666e-02f,
  -4.22306359e-01f, -3.86282951e-02f, 3.77798118e-02f, 3.67918261e-03f, -3.52208018e-02f, -9.36084148e-03f, 4.97821579e-03f, 5.16488291e-02f, 3.98567729e-02f, -1.67216450e-01f,
  -1.37261152e-01f, -6.80994168e-02f, -9.11339372e-02f, -2.03213349e-01f, -1.23743005e-01f, -8.69789347e-02f, -4.98390719e-02f, -1.02864943e-01f, -3.07055432e-02f, -4.59374599e-02f,
  -2.09897041e-01f, -1.70562238e-01f, 3.52340527e-02f, 6.41602874e-02f, -9.56147015e-02f, 3.14052477e-02f, -5.97340195e-03f, 2.88989209e-02f, 8.39476436e-02f, -1.49511099e-01f,
  -1.67176962e-01f, -3.35431583e-02f, 2.86738761e-02f, -1.48924634e-01f, -9.31540430e-02f, -1.05211310e-01f, -6.25128001e-02f, -9.58122090e-02f, -5.17202765e-02f, -1.44013077e-01f,
  -1.72822624e-01f, -8.90696943e-02f, -1.12011701e-01f, -1.80602103e-01f, -1.88963160e-01f, -3.78980339e-02f, -7.05799758e-02f, -2.18807366e-02f, -6.07962273e-02f, 1.19952271e-02f,
  -1.16543323e-01f, -8.56987312e-02f, -6.89892173e-02f, -6.50334433e-02f, -1.85826808e-01f, -1.50609881e-01f, -6.80090338e-02f, -6.65533990e-02f, -5.46558537e-02f, -1.69815421e-01f,
  3.97522599e-02f, 1.22976765e-01f, -3.90259847e-02f, 8.99495035e-02f, 1.05317615e-01f, 7.31594115e-02f, 5.84108345e-02f, 2.26798013e-01f, 1.70777440e-02f, -8.68177339e-02f,
  -9.29132011e-03f, -1.64373025e-01f, 2.17574798e-02f, -2.13818438e-02f, -1.44258961e-01f, -1.35275856e-01f, -7.07065836e-02f, -1.92172790e-03f, 5.28873429e-02f, -7.18393326e-02f,
  1.80794597e-02f, 1.28976285e-01f, 4.45989780e-02f, 1.48991227e-01f, -5.63069507e-02f, 1.18552595e-01f, 1.49000496e-01f, 6.87564388e-02f, 2.03737989e-01f, -6.55537238e-03f,
  -1.91624656e-01f, 3.04613322e-01f, -3.65473658e-01f, -1.10189170e-01f, -2.40423024e-01f, -2.34281346e-01f, 2.04421505e-01f, 6.43181652e-02f, -5.69331050e-02f, 1.90287232e-01f,
  -1.16067223e-01f, -1.07876234e-01f, 1.61934420e-02f, 5.29460721e-02f, 2.45838836e-01f, 2.93179691e-01f, 2.28629395e-01f, 9.39093903e-02f, 4.60387319e-02f, 1.92616642e-01f,
  3.02169412e-01f, 2.44960845e-01f, 1.84779033e-01f, 2.20379114e-01f, 7.71444887e-02f, -2.25788243e-02f, 1.78098790e-02f, -2.96769701e-02f, 1.54333368e-01f, 3.90126586e-01f,
  1.17622599e-01f, -6.13278262e-02f, 9.17920098e-02f, 1.50731161e-01f, 3.78770418e-02f, 1.60580844e-01f, 1.30123213e-01f, 1.01056010e-01f, 4.91570421e-02f, 2.00552613e-01f,
  6.62218546e-03f, 2.83256080e-02f, 1.28694162e-01f, 1.64844751e-01f, 1.63208991e-02f, 8.88862014e-02f, 1.18574657e-01f, 3.59977074e-02f, 6.00310378e-02f, 1.05356462e-01f,
  2.82561690e-01f, 7.69199207e-02f, -2.21629851e-02f, 4.24219109e-02f, 2.00511850e-02f, -4.39611115e-02f, 8.94717202e-02f, 9.66137946e-02f, 1.12726344e-02f, 2.18736500e-01f,
  5.75933605e-02f, -9.36784223e-02f, -9.43371803e-02f, -5.79383671e-02f, 3.98949571e-02f, -7.75337666e-02f, -3.27711622e-03f, -1.04450900e-02f, 3.78069580e-02f, -3.55926380e-02f,
  -3.52626815e-02f, -5.68686761e-02f, -3.24978977e-02f, 9.61246248e-03f, 6.47394881e-02f, -1.19503904e-02f, -2.48265490e-02f, 1.18569247e-01f, 5.87834232e-02f, -3.76415588e-02f,
  5.13061993e-02f, -1.08577415e-01f, -1.58596206e-02f, -5.15976772e-02f, -2.30809562e-02f, 3.10788173e-02f, -2.40736622e-02f, 6.50178418e-02f, -2.75893994e-02f, 8.80055279e-02f,
  1.16119027e-01f, -2.08989844e-01f, 2.21237630e-01f, 2.21028626e-01f, 6.31354898e-02f, 1.16262652e-01f, 5.21161780e-02f, 1.14506252e-01f, 4.21602465e-02f, 1.21884190e-01f,
  2.51305960e-02f, 1.07205287e-01f, 3.14125679e-02f, 1.80537999e-01f, 3.12308688e-02f, 4.86102402e-02f, 1.86188668e-01f, 1.07938290e-01f, 7.01244473e-02f, 1.00572094e-01f,
  1.99857473e-01f, 2.72300005e-01f, 1.75634101e-01f, 8.29160959e-02f, 1.30701497e-01f, 1.07099451e-01f, 2.11631373e-01f, 1.56111196e-01f, 1.44230932e-01f, 3.41759652e-01f,
  2.73999065e-01f, -6.90692216e-02f, 4.98643577e-01f, 6.91081583e-02f, 2.35553920e-01f, 1.56861976e-01f, -1.11158445e-01f, -2.89851129e-01f, -1.28243744e-01f, 4.56575267e-02f,
  -5.55291818e-03f, -1.45000629e-02f, 1.47094354e-01f, -3.87835093e-02f, -4.50186618e-02f, 2.86628772e-02f, 3.17845672e-01f, 3.96135181e-01f, 1.06275417e-01f, -8.84033740e-02f,
  -9.01846811e-02f, 4.03429493e-02f, 7.61081576e-02f, -4.71296012e-02f, 7.53913894e-02f, 1.88651755e-01f, 1.75019994e-01f, 3.02546620e-01f, 1.14852823e-01f, 1.47477239e-01f,
  4.34667110e-01f, -1.26220621e-02f, 4.42806035e-02f, 1.89843792e-02f, 5.77214845e-02f, -7.49328062e-02f, -7.13616014e-02f, -8.28524455e-02f, 1.95849091e-02f, -3.39746587e-02f,
  -3.84389013e-02f, 1.91180948e-02f, 7.93455392e-02f, 2.84604467e-02f, 5.36542274e-02f, -1.66613143e-02f, 3.18159647e-02f, 8.00643116e-02f, 6.58520237e-02f, 3.85747738e-02f,
  -8.16346630e-02f, 1.63435683e-01f, 1.97904706e-01f, -1.09077059e-01f, -1.37697458e-01f, 8.67034867e-02f, -5.99955730e-02f, -5.48768155e-02f, -2.72384118e-02f, -9.36623365e-02f,
  -3.57908607e-02f, 1.21527426e-01f, 1.97672956e-02f, -5.05916066e-02f, -4.46768738e-02f, -6.83042929e-02f, 3.56514864e-02f, 4.28228341e-02f, -2.04652287e-02f, -9.93490815e-02f,
  -4.27717753e-02f, -1.79436002e-02f, 5.10168448e-02f, -1.14070028e-01f, 8.30161385e-03f, 9.04932246e-02f, -5.12843989e-02f, -5.32689057e-02f, 3.90801579e-02f, 5.09733446e-02f,
  -2.08643600e-02f, 2.34144162e-02f, 1.36344153e-02f, -8.19173008e-02f, -3.78825590e-02f, 1.62206665e-02f, -6.65994436e-02f, -6.33542091e-02f, -9.99565050e-03f, 3.22647803e-02f,
  1.17014632e-01f, -4.94649448e-02f, 1.17802462e-02f, -1.89779013e-01f, 8.58814195e-02f, -4.75477893e-03f, 4.41229530e-02f, 5.96038299e-03f, 1.64095350e-02f, -1.92550141e-02f,
  -1.07386284e-01f, -6.97853491e-02f, 4.51512896e-02f, 5.32487184e-02f, -4.60593589e-03f, -4.27214801e-02f, -6.88888505e-02f, 1.17026508e-01f, -4.96312194e-02f, -2.34400369e-02f,
  3.55350636e-02f, 3.69644612e-02f, 1.55993864e-01f, 1.21226653e-01f, -2.34748088e-02f, 1.37888953e-01f, 1.47359997e-01f, 9.40670818e-03f, 1.19780213e-01f, -3.06267254e-02f,
  2.27361843e-01f, 2.96705246e-01f, 2.25965068e-01f, -3.54650676e-01f, -2.38294065e-01f, 6.71215504e-02f, 2.75131851e-01f, 1.45494878e-01f, -3.70403677e-01f, 4.62847836e-02f,
  -4.66017239e-02f, -2.48447701e-01f, -2.52592295e-01f, -1.46673784e-01f, 2.03841314e-01f, 9.83075127e-02f, -3.67422439e-02f, 8.58487636e-02f, -6.34853244e-02f, -6.89396784e-02f,
  -2.49911651e-01f, -2.52612203e-01f, -1.33029252e-01f, -3.12461760e-02f, -1.39092967e-01f, -2.17516005e-01f, -5.04200459e-02f, 2.33477559e-02f, -1.06567740e-02f, 1.68992055e-03f,
  3.11107159e-01f, 2.21125007e-01f, -2.05837131e-01f, -1.93081394e-01f, -1.13889545e-01f, 1.20044197e-03f, -9.04933363e-02f, -7.86611661e-02f, -1.00072600e-01f, -5.16516203e-03f,
  -1.59845322e-01f, -5.31922691e-02f, -7.30881989e-02f, -9.80112925e-02f, -4.85340133e-02f, -2.59322114e-02f, -1.17303647e-01f, 1.77903753e-02f, -1.01522081e-01f, 2.87802983e-02f,
  -2.33580112e-01f, -1.65831849e-01f, 7.17040747e-02f, 1.64425652e-02f, -6.05605682e-03f, -8.31616446e-02f, -2.26424560e-02f, -3.33749652e-02f, 1.33978516e-01f, 8.56428966e-02f,
  -8.67353752e-02f, 5.55622801e-02f, 8.25196132e-02f, 6.91097304e-02f, 4.97130342e-02f, 7.40834773e-02f, -1.06447032e-02f, -2.59502437e-02f, 2.45812107e-02f, 9.97280255e-02f,
  6.17144965e-02f, 8.39514285e-02f, 8.96077380e-02f, 6.77986071e-02f, 6.51793331e-02f, 1.13224290e-01f, 5.14925197e-02f, 3.48324552e-02f, 1.80103797e-02f, 7.85171315e-02f,
  8.77595395e-02f, 7.35408068e-02f, 5.04667088e-02f, 3.83706912e-02f, 2.88971290e-02f, 1.57207578e-01f, 1.62344381e-01f, 4.47491482e-02f, 1.17657736e-01f, 1.03680149e-01f,
  -2.31501564e-01f, -1.46353826e-01f, -8.20399299e-02f, -9.05646682e-02f, -1.77531809e-01f, -1.45631447e-01f, -1.08041003e-01f, -1.43119514e-01f, -1.13026924e-01f, 1.91823710e-02f,
  1.49733271e-03f, -1.48471585e-03f, -1.36293828e-01f, -3.22122276e-02f, -1.17289722e-01f, -1.16001539e-01f, -1.27619654e-01f, -1.36366144e-01f, -9.35923755e-02f, -7.52580538e-02f,
  -2.20881790e-01f, -1.28580540e-01f, -1.39282674e-01f, -1.82936892e-01f, -1.02952190e-01f, -1.54877931e-01f, -1.93897877e-02f, -3.59564088e-02f, 2.57064272e-02f, -4.25481945e-02f,
  2.30067730e-01f, 2.44611084e-01f, 1.15773439e-01f, 1.11711703e-01f, 7.42043331e-02f, 8.07291176e-03f, 1.26981393e-01f, -5.44895930e-03f, -5.38405031e-02f, 9.06502157e-02f,
  -2.80694980e-02f, -3.90927613e-01f, -3.08754086e-01f, -1.95640802e-01f, -1.73704237e-01f, 5.94213977e-03f, 6.55492470e-02f, -1.04488313e-01f, -2.70576864e-01f, -1.17350720e-01f,
  -1.15578137e-01f, 2.69455403e-01f, 2.13829175e-01f, -4.72135618e-02f, 1.36788175e-01f, -3.71021330e-02f, 2.60414630e-01f, 2.04509035e-01f, 2.13786140e-02f, 1.83614939e-01f,
  -1.07177570e-01f, 1.02944493e-01f, -1.91148460e-01f, -7.99587294e-02f, 4.96217236e-02f, -8.67442712e-02f, 3.42924185e-02f, 2.29546465e-02f, -5.23730740e-02f, 2.59453766e-02f,
  6.33702576e-02f, -1.26985848e-01f, -9.89097208e-02f, 4.89860177e-02f, -1.58217258e-03f, -4.66105342e-02f, 2.84958705e-02f, -7.85132423e-02f, 1.01256669e-02f, -6.31864145e-02f,
  -7.27448687e-02f, 5.48350625e-02f, 1.22049920e-01f, -1.74941379e-03f, -7.70739242e-02f, -2.86173131e-02f, 7.73054585e-02f, -3.31361257e-02f, 4.20022793e-02f, 2.40133658e-01f,
  1.29736245e-01f, 6.27084970e-02f, -2.85917874e-02f, 8.15669224e-02f, 8.63479674e-02f, 1.62352938e-02f, 7.86142051e-03f, 7.93478545e-03f, 6.72464818e-03f, 3.67781296e-02f,
  -4.86960541e-03f, 2.66844314e-02f, 3.98339890e-02f, 8.95214230e-02f, -6.32361742e-03f, 1.32456347e-01f, 9.25816447e-02f, -4.87154610e-02f, 3.43250707e-02f, 1.33221354e-02f,
  -2.08127908e-02f, 6.34717802e-03f, 1.30867120e-02f, -1.15892552e-02f, -3.28863412e-02f, -2.32855659e-02f, -1.83105748e-02f, -4.42861728e-02f, 2.50062197e-02f, 7.72711039e-02f,
  -6.35797307e-02f, 1.62510443e-02f, -5.82628660e-02f, -1.62093908e-01f, -1.40798255e-03f, -1.08851016e-01f, -3.35226357e-02f, -3.76408696e-02f, -8.28633904e-02f, -4.69074100e-02f,
  -6.08306006e-02f, 4.52068774e-03f, -4.60289977e-02f, -7.07243457e-02f, 3.92527543e-02f, -1.03817731e-02f, 3.52965631e-02f, 3.84800769e-02f, -1.30362377e-01f, 1.33063295e-03f,
  2.39567421e-02f, 5.08538857e-02f, -5.54707758e-02f, -5.55158667e-02f, 5.78548796e-02f, -1.68765485e-02f, 2.83180047e-02f, 8.97279382e-03f, 5.68003394e-02f, 1.49039894e-01f,
  -2.82860041e-01f, -2.41454709e-02f, -1.92610510e-02f, 1.16989845e-02f, 1.95009068e-01f, 3.31267267e-01f, 4.04713094e-01f, 1.19261250e-01f, -5.17436974e-02f, 9.01837721e-02f,
  -1.12287857e-01f, -1.98728412e-01f, -2.54768938e-01f, -1.22469842e-01f, -9.17405635e-02f, 3.24263692e-01f, 1.66336462e-01f, -1.21382684e-01f, -4.61634025e-02f, 7.94715136e-02f,
  1.64908692e-01f, -1.53914511e-01f, -3.95646423e-01f, -2.34106407e-01f, 1.15662210e-01f, -1.28603920e-01f, -6.91760853e-02f, -1.01435184e-01f, 1.19986385e-02f, 7.43420422e-02f,
  -3.67826931e-02f, -2.15054646e-01f, -6.29780069e-02f, -1.62846476e-01f, -1.49567232e-01f, -1.54435590e-01f, -1.00044750e-01f, -2.02976033e-01f, -1.17231064e-01f, -1.40894920e-01f,
  -1.41515940e-01f, -1.79402992e-01f, 8.72305688e-03f, -3.52254771e-02f, -1.59883201e-01f, -4.43551317e-02f, -9.99237522e-02f, -1.43976152e-01f, -8.50914270e-02f, -3.65871415e-02f,
  1.31929955e-02f, -7.17652738e-02f, -3.79807837e-02f, -1.20507196e-01f, -1.89290538e-01f, -1.78841069e-01f, -1.13758639e-01f, -8.59952122e-02f, -2.32223600e-01f, -6.90684244e-02f,
  5.18480428e-02f, 1.65801942e-02f, -3.36753540e-02f, 8.30815136e-02f, 3.08348071e-02f, 4.85538021e-02f, 6.80227652e-02f, 1.30866677e-01f, -2.04888135e-02f, 5.76806851e-02f,
  9.23995301e-02f, -1.95754413e-03f, 3.39875966e-02f, 7.40828440e-02f, 9.57016647e-02f, -3.08958460e-02f, 5.41454442e-02f, 3.83015871e-02f, 4.53173369e-02f, 1.32793441e-01f,
  1.08855754e-01f, 5.94171546e-02f, -6.92412117e-03f, 7.93047771e-02f, 1.19852237e-02f, -8.64826841e-04f, 9.96998791e-03f, -1.28124151e-02f, 4.14834172e-02f, 9.07077268e-02f,
  -9.85003561e-02f, -2.58227617e-01f, 3.48834358e-02f, -1.17733300e-01f, 2.29461701e-03f, -9.26785320e-02f, -9.58769768e-02f, -4.81439866e-02f, -8.32601115e-02f, 2.70392764e-02f,
  -3.42830308e-02f, -6.32090345e-02f, -8.31434950e-02f, -9.74729732e-02f, 8.15074220e-02f, -1.01206563e-02f, 5.53220324e-02f, -6.24528006e-02f, -7.89889097e-02f, -9.96248126e-02f,
  -4.41907421e-02f, 2.42835865e-03f, 1.10113755e-01f, -5.12499809e-02f, 8.52349121e-03f, -6.54442310e-02f, 2.33602971e-02f, -4.43736501e-02f, 3.86662502e-03f, 1.46369100e-01f,
  -3.76390755e-01f, -4.87880170e-01f, -1.94456026e-01f, -2.19479173e-01f, -4.68830159e-03f, 3.53565067e-02f, -1.52775705e-01f, -2.25243643e-01f, -2.79411841e-02f, 2.92682778e-02f,
  1.98811561e-01f, 2.44393751e-01f, 2.75073171e-01f, 2.34798595e-01f, -4.17452455e-02f, -1.55879363e-01f, -1.37309372e-01f, 1.15988545e-01f, 9.38739181e-02f, 1.49450332e-01f,
  1.26614362e-01f, -1.48696050e-01f, -1.63899526e-01f, -8.04069117e-02f, -1.24160042e-02f, 2.99370974e-01f, -1.43994048e-01f, -6.08982295e-02f, 1.48858801e-01f, 1.14695258e-01f,
  6.36370778e-02f, -4.19292152e-01f, 7.31055811e-02f, 1.68616086e-01f, -9.30925310e-02f, -1.28632173e-01f, -4.33918349e-02f, -1.93320826e-01f, -1.13245040e-01f, -7.99266472e-02f,
  -7.70223653e-03f, -4.96543832e-02f, -4.28907201e-03f, -5.90339079e-02f, 2.07476858e-02f, -6.09518141e-02f, -1.66590899e-01f, -2.02525169e-01f, -7.40212053e-02f, -3.27622555e-02f,
  3.91232148e-02f, -4.76082563e-02f, -5.57069108e-02f, -9.58679169e-02f, -1.62276477e-01f, 5.04537523e-02f, -8.10050070e-02f, -8.11166689e-02f, -1.20275117e-01f, -1.43995255e-01f,
  1.16260964e-02f, 4.22777049e-03f, 4.40430604e-02f, -5.67196272e-02f, 5.27520031e-02f, -3.12136542e-02f, 1.23180911e-01f, 7.08595812e-02f, 1.61729362e-02f, -1.25981445e-04f,
  6.14529401e-02f, 9.54172388e-02f, 5.02083786e-02f, -7.69780111e-03f, 1.49552301e-01f, -1.84224807e-02f, 1.17686681e-01f, 4.82180938e-02f, 5.44164814e-02f, -5.07342145e-02f,
  1.38702244e-01f, 4.55938987e-02f, 5.71581647e-02f, 8.32112134e-02f, 5.75272180e-02f, 7.24385381e-02f, 9.97916684e-02f, 8.64823610e-02f, 5.99431396e-02f, 2.62201373e-02f,
  5.07260934e-02f, 1.41940564e-01f, -1.25374170e-02f, -4.65228036e-02f, -8.65728501e-03f, -9.18289870e-02f, 2.61284504e-02f, -4.53378148e-02f, -3.73445377e-02f, 1.86224896e-02f,
  5.95932119e-02f, -8.36369172e-02f, -5.25453016e-02f, -7.76403248e-02f, -2.89761443e-02f, 1.83846317e-02f, -1.05984896e-01f, 5.25506362e-02f, 1.23661533e-02f, -1.20682992e-01f,
  -1.29757628e-01f, 6.96802139e-02f, 3.56161818e-02f, -2.37721875e-02f, -5.67735471e-02f, 1.57993004e-01f, 4.67842408e-02f, 6.83590397e-02f, 1.54411972e-01f, -1.18078440e-01f,
  1.49075478e-01f, 6.35685205e-01f, -2.35293984e-01f, -1.01044305e-01f, 1.44221878e-03f, 2.90917605e-01f, 4.45935100e-01f, 2.80475050e-01f, -6.48745522e-02f, 1.98748872e-01f,
  -8.27370733e-02f, -3.82667869e-01f, -3.51123661e-01f, -2.92595804e-01f, 8.09956416e-02f, 2.50406593e-01f, 9.08393860e-02f, -2.56162763e-01f, -1.79265365e-01f, 9.03419629e-02f,
  5.17482795e-02f, 3.67350504e-02f, 2.04105601e-02f, -2.18712483e-02f, 5.31585515e-02f, 2.75632273e-02f, 7.79495984e-02f, 1.48831457e-01f, 2.14430973e-01f, 1.71956077e-01f,
  -1.74305320e-01f, 3.97252142e-02f, -1.69370919e-01f, -9.30673480e-02f, -1.48676574e-01f, -9.59162787e-03f, 6.22752719e-02f, -8.85377303e-02f, -4.69056480e-02f, 4.47907187e-02f,
  -7.43614063e-02f, -5.50037809e-02f, -7.79480562e-02f, -9.43749025e-02f, -1.69402678e-02f, 8.02049600e-03f, 4.98381555e-02f, -8.63822326e-02f, -9.74181667e-02f, -8.42097774e-02f,
  -1.88275054e-02f, 7.31151700e-02f, 7.81335086e-02f, 1.30125239e-01f, -5.22581711e-02f, -1.16700098e-01f, 7.70691037e-02f, 1.39379635e-01f, 9.54055041e-02f, 3.19884121e-01f,
  1.14755511e-01f, 9.82632767e-03f, 5.29673360e-02f, 8.08921233e-02f, 5.08344993e-02f, -2.90876701e-02f, -4.70920233e-03f, 2.61639673e-02f, 7.69035611e-03f, 6.64915219e-02f,
  -4.91677150e-02f, -4.74334843e-02f, -3.58542539e-02f, -8.38582292e-02f, -6.81214705e-02f, -5.99873252e-02f, 4.00713235e-02f, -1.59263387e-02f, -1.89919863e-02f, 5.44098392e-03f,
  -1.17643103e-01f, 3.05363466e-03f, -5.04019409e-02f, 2.54716799e-02f, -1.18639385e-02f, -5.71851991e-02f, -2.01313049e-02f, -4.89968993e-02f, 2.48995759e-02f, 7.00383708e-02f,
  -1.02224976e-01f, -1.82731867e-01f, 2.71772854e-02f, 1.12948706e-02f, 4.13192958e-02f, -7.72010488e-03f, 4.64558452e-02f, -3.50321531e-02f, 5.74463222e-04f, -3.27911340e-02f,
  -1.50546376e-02f, 4.89895493e-02f, 7.51191601e-02f, 6.93995804e-02f, 1.62424762e-02f, 7.80275315e-02f, 8.18168893e-02f, -5.91192096e-02f, -3.52297314e-02f, -2.73301196e-03f,
  8.73755962e-02f, 1.32451385e-01f, -3.00874151e-02f, 1.54112607e-01f, 2.69716606e-02f, -5.86757250e-02f, 2.84838062e-02f, 1.36665655e-02f, 3.30824330e-02f, 3.02108914e-01f,
  -5.27240038e-01f, 1.28598914e-01f, 2.19954282e-01f, -8.54934566e-03f, 2.27684215e-01f, 1.14882082e-01f, 2.47766078e-01f, -1.41319498e-01f, -1.37349650e-01f, 1.06653906e-01f,
  -1.69063836e-01f, -3.57585579e-01f, -1.49060279e-01f, -1.08083613e-01f, -1.42783061e-01f, 3.44045550e-01f, 3.52969944e-01f, 1.55079197e-02f, -3.05947244e-01f, -2.52382576e-01f,
  9.49359685e-03f, -1.07644260e-01f, -2.95131952e-01f, -1.86951548e-01f, 7.59338066e-02f, -9.07554328e-02f, 1.96609095e-01f, 1.11109398e-01f, 1.02345563e-01f, 3.32942396e-01f,
  -1.98830113e-01f, -2.05120906e-01f, -1.61132753e-01f, -2.02094659e-01f, -1.48810223e-01f, -1.75146654e-01f, -1.06499314e-01f, -5.32278605e-02f, -1.42774075e-01f, -6.38498440e-02f,
  -1.13584720e-01f, -1.22321390e-01f, -7.44696707e-03f, 7.28712277e-03f, -1.15088448e-01f, -5.37878536e-02f, -1.46482110e-01f, -7.53012374e-02f, -6.14624135e-02f, -1.18879862e-01f,
  8.31524655e-02f, -1.38403010e-02f, -9.96155217e-02f, -3.58397700e-03f, -1.09886959e-01f, -7.37094432e-02f, -8.83249789e-02f, -8.01103115e-02f, -1.33623719e-01f, -1.52758986e-01f,
  -4.42615189e-02f, 1.01247676e-01f, 1.56390145e-02f, 7.89727718e-02f, 1.01392157e-01f, 1.14236735e-01f, 4.55390923e-02f, 7.22421929e-02f, 3.32843363e-02f, 2.46018153e-02f,
  1.20224683e-02f, 7.77967498e-02f, 5.75774498e-02f, 2.55875550e-02f, 3.92251611e-02f, 1.39338285e-01f, 1.04071870e-01f, 9.30814594e-02f, 4.97723594e-02f, 8.65430310e-02f,
  7.69435838e-02f, 2.15284582e-02f, 1.03114195e-01f, 7.24200811e-03f, 1.10834256e-01f, 7.29001909e-02f, 9.12510082e-02f, -1.87455071e-03f, 4.85326089e-02f, 1.59431741e-01f,
  -3.86645585e-01f, -1.62402242e-01f, -4.14626412e-02f, -1.55899987e-01f, -2.95713022e-02f, -1.37069374e-01f, -1.17196456e-01f, -1.38961166e-01f, -6.17781933e-03f, -1.29809782e-01f,
  -1.71045914e-01f, -1.90869018e-01f, -1.13620423e-01f, -1.08395949e-01f, -1.59174547e-01f, -3.85029987e-02f, -9.41675752e-02f, 2.50667445e-02f, -7.67188817e-02f, -4.81588319e-02f,
  -9.10626445e-03f, -7.27109089e-02f, -1.96301430e-01f, -9.96791944e-02f, -8.21190625e-02f, -1.52798340e-01f, -9.28321928e-02f, -1.31104484e-01f, -1.32726669e-01f, -1.44870609e-01f,
  -1.27173364e-01f, 1.87935039e-01f, -3.14698257e-02f, 7.33963922e-02f, 1.68846652e-01f, 2.69279659e-01f, 3.78117740e-01f, 1.35842606e-01f, 8.48010704e-02f, 9.67725292e-02f,
  2.71320017e-03f, -1.05164237e-01f, 1.06525421e-01f, -1.12625666e-01f, 1.51595026e-01f, 2.70795643e-01f, 1.99158043e-01f, -2.64999960e-02f, -3.20642680e-01f, -3.58762890e-01f,
  -1.00088373e-01f, -1.60612687e-01f, -1.97671786e-01f, -2.10150287e-01f, -1.46432415e-01f, 3.59619893e-02f, 6.65350407e-02f, -1.45061925e-01f, -2.33515333e-02f, -2.80992299e-01f,
  -1.76889822e-01f, -1.73974186e-01f, 5.47818914e-02f, -9.96512473e-02f, -9.55804214e-02f, -3.77472304e-02f, -3.30627821e-02f, -2.19171077e-01f, -7.78426379e-02f, -5.29561080e-02f,
  -5.16307913e-02f, -1.50909051e-01f, -1.01128750e-01f, -1.05700679e-01f, -1.01151794e-01f, -8.27847496e-02f, -2.81871203e-02f, -1.72003090e-01f, -1.86814014e-02f, -1.53232262e-01f,
  2.39447933e-02f, -4.04394604e-02f, 3.89542431e-02f, 1.09261945e-02f, 3.98224331e-02f, -6.31946698e-02f, -1.76391341e-02f, -1.30639508e-01f, -6.89912736e-02f, 4.89312690e-03f,
  -2.33701356e-02f, 3.10342908e-02f, -5.92143387e-02f, 4.75077070e-02f, 4.54719327e-02f, 4.50999886e-02f, 6.67101741e-02f, 1.59776155e-02f, 3.32894847e-02f, -7.06278440e-03f,
  7.45805129e-02f, 4.16933857e-02f, -2.95976512e-02f, 7.15656281e-02f, 8.83274376e-02f, 3.06280218e-02f, 5.55268265e-02f, 2.92659719e-02f, 1.92150753e-02f, 6.69945106e-02f,
  1.90985221e-02f, 7.16316476e-02f, 1.00219538e-02f, 4.12526168e-02f, 3.52087920e-03f, 7.68739134e-02f, 6.62195832e-02f, 4.78203269e-03f, 7.96852484e-02f, 7.18083084e-02f,
  2.02435181e-01f, 2.01435149e-01f, 7.97042716e-03f, 2.17257552e-02f, 1.89769659e-02f, -1.56922154e-02f, -2.18259599e-02f, -4.30672355e-02f, -1.46755297e-02f, -2.47885026e-02f,
  2.82160118e-02f, 1.70443356e-02f, 7.43061304e-02f, -5.21710105e-02f, -7.23554343e-02f, 7.18671456e-02f, 5.53423837e-02f, -7.29687279e-03f, -3.71341519e-02f, -5.99308610e-02f,
  8.95757694e-03f, 7.38423765e-02f, 2.08423331e-01f, 9.44836885e-02f, 6.08207956e-02f, 8.84233117e-02f, 8.31291452e-02f, 3.02651152e-02f, 1.53361648e-01f, 3.13233554e-01f,
  3.49611610e-01f, 1.61343172e-01f, 4.85689253e-01f, -1.36876091e-01f, -2.42478848e-01f, -5.99876642e-02f, 1.41316310e-01f, -6.44521788e-02f, -2.19097242e-01f, -9.27233547e-02f,
  -2.41074800e-01f, -3.08280110e-01f, -2.10964322e-01f, -2.37790897e-01f, -1.08285613e-01f, -9.66171827e-03f, -1.00609995e-02f, 9.85759776e-03f, 5.36583588e-02f, -2.24323511e-01f,
  -2.64818609e-01f, -2.42829204e-01f, -2.07046360e-01f, -1.67388752e-01f, 5.10899490e-03f, -2.12440953e-01f, -4.09464799e-02f, -1.87747534e-02f, -1.33644929e-02f, 1.00940064e-01f,
  2.96849817e-01f, 1.31459266e-01f, -2.51195222e-01f, -3.35456491e-01f, -1.30458161e-01f, 4.28858865e-03f, -4.16000411e-02f, -4.63570468e-03f, -1.20043956e-01f, 1.80069357e-02f,
  -1.25899523e-01f, -1.42784685e-01f, -7.85741508e-02f, -5.33574857e-02f, -6.02597594e-02f, -2.35094521e-02f, -2.13397011e-01f, 7.66279921e-03f, -4.01860140e-02f, -7.45775029e-02f,
  -2.49552935e-01f, -1.22321993e-01f, 1.00220628e-01f, -1.12134963e-01f, -8.27511325e-02f, -2.15269819e-01f, 5.57525419e-02f, 2.72848755e-02f, 3.72211710e-02f, 5.23838308e-03f,
  -9.48557332e-02f, 1.64900348e-01f, 6.14610240e-02f, 1.93604037e-01f, 1.91936418e-02f, 1.01968236e-01f, 4.28009741e-02f, 6.32661805e-02f, 5.76011203e-02f, 2.37563252e-01f,
  4.48030978e-02f, 8.74852613e-02f, 9.17195231e-02f, 1.05071500e-01f, 1.56179043e-02f, 1.83540955e-01f, 1.29462704e-01f, 6.24581873e-02f, 5.09759560e-02f, 1.45787477e-01f,
  1.70469075e-01f, 1.26834288e-01f, 1.44584835e-01f, 1.00673176e-01f, 1.10813148e-01f, 1.29610896e-01f, 8.08256865e-02f, 1.10351644e-01f, 1.90420210e-01f, 6.13417290e-02f,
  -1.38664261e-01f, -3.97595078e-01f, -3.98511300e-03f, -3.49797793e-02f, -6.88333809e-02f, -2.08467230e-01f, -1.88446239e-01f, -7.98611119e-02f, -6.12379648e-02f, -2.30669416e-03f,
  -1.04503296e-01f, -8.92681256e-02f, -1.77022949e-01f, -1.85923085e-01f, -1.31410971e-01f, -9.46216881e-02f, -2.18476951e-01f, -1.17118947e-01f, -9.90179926e-02f, -1.69944555e-01f,
  -1.70424566e-01f, -8.67164209e-02f, -4.58568484e-02f, -1.41467139e-01f, -6.92996159e-02f, -2.32166499e-01f, -6.49751499e-02f, 3.93810049e-02f, -6.58641234e-02f, -1.02792300e-01f,
  7.39691496e-01f, -4.75744665e-01f, 5.31210341e-02f, 1.46830782e-01f, -2.89205164e-01f, -1.82343200e-01f, -1.87085465e-01f, 4.66280207e-02f, 2.98351407e-01f, -1.73327811e-02f,
  -2.44988218e-01f, 1.07821926e-01f, 1.87460497e-01f, 1.46090969e-01f, 3.01766187e-01f, -6.23499714e-02f, -2.88413744e-02f, 3.82316411e-01f, 4.04438227e-01f, 1.33053124e-01f,
  -1.19203046e-01f, 9.78625640e-02f, 3.46306056e-01f, 2.16076374e-01f, -1.15576208e-01f, 1.98375195e-01f, -6.14208262e-03f, -1.81160793e-01f, -7.76154697e-02f, -1.03014009e-02f,
  1.23822890e-01f, -2.49568503e-02f, 3.01463276e-01f, 9.21272412e-02f, 8.58689100e-02f, 3.44286591e-01f, 1.90841526e-01f, 2.00905576e-01f, 1.04789019e-01f, 1.38100296e-01f,
  7.05134720e-02f, 1.76897064e-01f, 7.88491070e-02f, 7.96011463e-02f, 4.81654927e-02f, 1.67562976e-01f, 9.36299115e-02f, 2.84861028e-01f, 2.20746562e-01f, -2.74838731e-02f,
  -1.22676224e-01f, -8.98367092e-02f, 4.10032645e-02f, 7.33992234e-02f, 1.49636164e-01f, 2.37542287e-01f, 3.55540588e-02f, 2.09199071e-01f, 2.18255416e-01f, 3.12600404e-01f,
  8.69782567e-02f, -1.03475273e-01f, -1.18472531e-01f, -1.43913358e-01f, -1.11971475e-01f, -1.37346879e-01f, -8.92029852e-02f, -1.61107004e-01f, -1.09384216e-01f, -1.51108980e-01f,
  -7.47364014e-02f, -6.80198669e-02f, -1.41405374e-01f, -4.83222380e-02f, -6.23682775e-02f, -1.22204490e-01f, -1.24019787e-01f, -9.98849571e-02f, -1.67777672e-01f, -8.64183307e-02f,
  -3.67847495e-02f, -1.51509404e-01f, -1.36264995e-01f, -1.30096212e-01f, -1.32421434e-01f, -5.45925498e-02f, -6.69087544e-02f, -9.14652497e-02f, -9.75646358e-03f, -1.07584827e-01f,
  1.97590247e-01f, -3.23202759e-02f, 2.38359228e-01f, 2.39184350e-01f, 5.74733280e-02f, 1.35681525e-01f, 1.16146252e-01f, 9.14321244e-02f, 9.79831740e-02f, 1.45839334e-01f,
  9.53265056e-02f, 1.65826485e-01f, 1.27417311e-01f, 5.07310331e-02f, 1.76060870e-01f, 1.01896703e-01f, 6.90321922e-02f, 1.44478843e-01f, 9.67971683e-02f, 2.50547361e-02f,
  9.51739475e-02f, 1.22140720e-01f, 2.47344464e-01f, 1.25916526e-01f, 1.09124340e-01f, 3.73398304e-01f, 2.05911264e-01f, 2.17859313e-01f, 2.71819592e-01f, 3.36745858e-01f,
  -7.07875609e-01f, -2.59777419e-02f, 3.96580845e-01f, -1.75389320e-01f, 3.85485351e-01f, 4.43737060e-01f, 4.82446700e-01f, 9.91252586e-02f, -1.44834027e-01f, 8.43104944e-02f,
  1.69647798e-01f, -1.65473521e-01f, -2.19278097e-01f, -1.26418024e-01f, -5.33579439e-02f, 2.22694665e-01f, 2.08895445e-01f, -1.25081927e-01f, 5.41228689e-02f, 1.35101750e-01f,
  -2.50158962e-02f, -3.43308717e-01f, -4.56335992e-01f, -2.77098924e-01f, -3.47784050e-02f, 4.27474640e-02f, 9.04815085e-03f, 8.44308063e-02f, 2.37522200e-01f, -9.65549946e-02f,
  1.12765282e-01f, 1.09481439e-02f, 5.87748326e-02f, -1.42812788e-01f, 5.28660938e-02f, -1.22663349e-01f, 4.63550501e-02f, -1.07469894e-01f, 1.58126894e-02f, -1.67662017e-02f,
  -8.37572813e-02f, -8.05383474e-02f, -3.45187820e-02f, -1.22285290e-02f, 7.89616443e-03f, 2.75034104e-02f, -1.32181197e-01f, -1.84620351e-01f, -3.44533995e-02f, 5.92224486e-02f,
  6.78393021e-02f, 1.12060860e-01f, 1.44770637e-01f, 4.62850332e-02f, 4.44820197e-03f, -1.15047894e-01f, 1.41478088e-02f, -4.85175811e-02f, -9.76766180e-03f, -2.50670373e-01f,
  -1.06256464e-02f, 9.36432555e-02f, 1.07905008e-01f, -6.80317059e-02f, 4.87796813e-02f, -7.16910660e-02f, 6.14590989e-03f, -3.84500629e-04f, 4.37611062e-03f, -7.35295936e-02f,
  4.23956662e-03f, 4.31804806e-02f, 6.14431798e-02f, 8.75530392e-02f, 1.21263126e-02f, 2.49368884e-02f, 1.16622243e-02f, 9.07470565e-03f, 5.07895425e-02f, -4.92960438e-02f,
  -4.56685498e-02f, 3.17311920e-02f, -2.05712244e-02f, -4.48429845e-02f, 4.28314358e-02f, 5.22588603e-02f, -9.89303961e-02f, 7.79353902e-02f, -3.26547399e-02f, -9.50636491e-02f,
  -1.28273576e-01f, 9.05311853e-02f, -9.92763042e-02f, -9.24212709e-02f, 7.54868090e-02f, -1.26258442e-02f, 9.92324725e-02f, 2.45955959e-02f, 3.75158526e-02f, -3.73775773e-02f,
  1.17447078e-01f, -3.65320146e-02f, -1.78525411e-02f, -7.76483631e-03f, 3.45974863e-02f, -4.94898632e-02f, 1.73994713e-02f, -1.90132093e-02f, -4.17474993e-02f, -5.62820397e-02f,
  -1.24760009e-01f, 6.56371713e-02f, 7.87079856e-02f, -2.77131889e-02f, -5.46951443e-02f, 7.16219023e-02f, 7.45926499e-02f, 3.05512436e-02f, 1.53548285e-01f, -1.49892420e-01f,
  7.00174630e-01f, -3.47109497e-01f, -2.78239042e-01f, 4.43282843e-01f, -8.11141357e-03f, -1.46900833e-01f, -3.97435218e-01f, 6.28327131e-02f, 3.57405335e-01f, 1.63533166e-02f,
  -3.37942913e-02f, 2.18698010e-01f, 8.79505947e-02f, -1.18820526e-01f, -7.68524334e-02f, -3.42101365e-01f, -3.62922311e-01f, -3.62191387e-02f, 1.41124561e-01f, 1.06401660e-01f,
  -5.22475988e-02f, 8.59860629e-02f, 1.88319772e-01f, 1.47434622e-01f, 7.36673251e-02f, 1.10060841e-01f, -7.90310353e-02f, 9.99645982e-03f, -1.88909024e-01f, -1.45116299e-01f,
  -1.18336491e-01f, 7.25957975e-02f, -1.41860871e-02f, 1.31396502e-01f, -8.89132842e-02f, 8.76119584e-02f, 8.47101491e-03f, 6.91506118e-02f, 3.03978212e-02f, -3.63748334e-02f,
  -2.89336108e-02f, 7.61263743e-02f, -1.75425299e-02f, -1.24031484e-01f, 4.99547459e-02f, -1.65054724e-02f, -4.91856150e-02f, -3.69979814e-02f, 6.56718342e-03f, -1.29416272e-01f,
  -1.51704535e-01f, -1.03628254e-02f, -7.25060552e-02f, -6.86563551e-02f, -1.35033906e-01f, -4.57639135e-02f, -6.95264563e-02f, -3.19053829e-02f, 3.89508717e-02f, 8.58253911e-02f,
  1.70855857e-02f, -1.32634202e-02f, 1.60070080e-02f, -8.62908736e-02f, 3.59501541e-02f, -2.08587050e-02f, -8.14530253e-03f, -3.12953666e-02f, 7.12841656e-03f, 5.48382849e-02f,
  2.56151594e-02f, 1.29228458e-02f, -1.98926404e-02f, 3.35346372e-03f, -4.35717143e-02f, -6.54115826e-02f, -6.37710914e-02f, -8.92234445e-02f, -4.72448133e-02f, -3.01004741e-02f,
  -6.10725544e-02f, 3.81349362e-02f, 1.15357665e-02f, -3.94465327e-02f, -9.90346819e-02f, -6.64791316e-02f, -7.89430644e-03f, -9.39207734e-04f, -5.20246886e-02f, -3.58480662e-02f,
  2.75074601e-01f, -5.91044687e-02f, -1.70710892e-03f, -8.54296796e-03f, 3.56736071e-02f, 5.44238882e-03f, -1.65352118e-04f, -1.35537749e-02f, -3.28278877e-02f, 2.93739233e-02f,
  -2.37936489e-02f, -4.07344252e-02f, -1.80093478e-02f, -7.30598941e-02f, 9.78633985e-02f, 5.62638268e-02f, -2.28300244e-02f, -3.84118184e-02f, -8.07029381e-02f, 8.82083401e-02f,
  -1.15438208e-01f, 8.79165456e-02f, 6.76690713e-02f, 3.65857556e-02f, 8.45416635e-02f, 1.11898169e-01f, -4.16536964e-02f, 2.30792221e-02f, -6.40062839e-02f, 1.13405541e-01f,
  -4.89650577e-01f, -2.26867899e-01f, 4.72600684e-02f, 1.18784204e-01f, 5.23468375e-01f, 5.05772352e-01f, 4.15859103e-01f, 1.15570962e-01f, -1.10090980e-02f, -1.14337578e-01f,
  1.75155774e-02f, -7.65618086e-02f, -1.75301820e-01f, -1.03782713e-01f, -1.79292917e-01f, 1.02998242e-01f, 4.34412546e-02f, -1.93559423e-01f, 2.94185597e-02f, 1.58505350e-01f,
  1.51558667e-01f, -9.85904187e-02f, -3.46362829e-01f, -8.88990611e-02f, -4.13508825e-02f, -3.45843434e-02f, -1.17189437e-01f, 3.75731364e-02f, 2.79538408e-02f, -3.34625661e-01f,
  -2.29004368e-01f, 4.63327533e-03f, 1.04320340e-01f, -2.17496008e-02f, -1.84059108e-03f, -5.56086302e-02f, -5.14159398e-03f, -5.81104644e-02f, -4.61711511e-02f, -1.39052970e-02f,
  -1.29785081e-02f, -7.50621408e-03f, 2.92303227e-02f, 2.66592633e-02f, 1.82224847e-02f, -4.49704146e-03f, -4.28504236e-02f, -1.39333919e-01f, -3.52215022e-02f, 4.15883064e-02f,
  6.96870834e-02f, 1.04524955e-01f, 4.44776341e-02f, 1.50359079e-01f, 1.31601319e-01f, 3.30493599e-02f, 3.40025015e-02f, 4.01663817e-02f, -6.19964413e-02f, -1.93387002e-01f,
  2.07503233e-02f, -6.49431050e-02f, -1.82815399e-02f, 1.79192889e-02f, -7.01320767e-02f, -3.64822559e-02f, -8.47109966e-03f, 1.52367027e-02f, -3.77500914e-02f, 1.95884649e-02f,
  4.30252329e-02f, 7.28675071e-03f, -2.18872190e-03f, -1.18125957e-02f, 2.28444301e-03f, -3.13466508e-03f, -3.51540861e-04f, -7.16110840e-02f, -7.26085063e-03f, -3.08852233e-02f,
  1.64859686e-02f, -1.29188849e-02f, -7.51826018e-02f, -6.27866909e-02f, 3.44870910e-02f, -1.47086298e-02f, 2.07749940e-02f, -6.21126480e-02f, 8.97689350e-03f, 8.08950886e-02f,
  -6.53698817e-02f, 1.15293555e-01f, -9.63220596e-02f, -1.04472237e-02f, 1.72826219e-02f, -5.82847297e-02f, -2.78898031e-02f, 9.50440671e-03f, 5.59899732e-02f, 1.06753847e-02f,
  9.15604308e-02f, -8.13036785e-03f, -6.42208681e-02f, 2.02777935e-03f, 7.05401376e-02f, 6.94923773e-02f, -9.73892733e-02f, 2.06376612e-02f, -3.65158124e-03f, 8.14446807e-02f,
  4.33747564e-03f, 8.87663215e-02f, -6.03379831e-02f, 2.42071580e-02f, 6.81034997e-02f, -6.86169043e-02f, 7.82201886e-02f, 1.30310416e-01f, -4.45845388e-02f, -1.35961905e-01f,
  -2.12923765e-01f, 2.13870034e-01f, -2.77888298e-01f, -3.16291079e-02f, 1.14319347e-01f, 2.31508482e-02f, -3.80662037e-03f, 5.23779169e-02f, 5.63372709e-02f, 8.74679983e-02f,
  3.92568856e-01f, 2.61106700e-01f, 2.14884445e-01f, 8.59959945e-02f, 4.68877517e-02f, -5.58456667e-02f, -2.89663881e-01f, -3.27150673e-01f, -2.17902899e-01f, -8.43680650e-02f,
  6.86543509e-02f, -4.34320755e-02f, -1.74710974e-01f, -1.24559321e-01f, 1.50904004e-02f, 1.71878278e-01f, 3.73114981e-02f, 7.46632591e-02f, 5.24415225e-02f, -2.08080634e-01f,
  1.82415485e-01f, 2.47263815e-02f, 6.60987347e-02f, 7.61928111e-02f, 9.53425691e-02f, 6.49481118e-02f, 6.82782531e-02f, 4.42291424e-02f, 9.68564674e-02f, 8.44263937e-03f,
  4.09451406e-03f, 5.05199060e-02f, -1.09921237e-02f, -3.90301906e-02f, 9.60832089e-02f, -6.14409940e-03f, -7.83942565e-02f, -1.14588469e-01f, 3.26685347e-02f, 2.04169168e-03f,
  2.80026300e-03f, -5.32329679e-02f, 2.28916258e-02f, 1.45186201e-01f, -1.43042754e-03f, 1.57915300e-03f, 1.59877390e-01f, 9.83075052e-03f, 1.06934294e-01f, -2.34911852e-02f,
  1.44326881e-01f, 3.72272097e-02f, -1.14088535e-01f, -2.67728660e-02f, -4.66507040e-02f, 1.23568019e-02f, -6.52561486e-02f, 4.23257649e-02f, -5.72779328e-02f, 1.96861438e-02f,
  -4.19198796e-02f, 2.90083308e-02f, -9.89090726e-02f, 9.13665667e-02f, 6.83407485e-02f, -7.62518421e-02f, -1.96684077e-02f, 2.07523834e-02f, 1.32408321e-01f, -4.19798493e-02f,
  -4.01581600e-02f, -2.82173436e-02f, -2.74138954e-02f, -9.58300903e-02f, -3.76519188e-02f, -5.06408811e-02f, 5.17459325e-02f, 2.36026421e-02f, 7.86426142e-02f, 5.30023016e-02f,
  3.77293617e-01f, 1.00384519e-01f, 6.71314225e-02f, 1.87678903e-04f, 4.26271819e-02f, 9.85377580e-02f, 7.99407065e-02f, 3.72877121e-02f, 7.07861260e-02f, 7.99037740e-02f,
  1.31866217e-01f, 1.90155674e-02f, 9.38792452e-02f, 7.56730810e-02f, -2.01722863e-03f, 1.04820043e-01f, 1.30458266e-01f, -9.31612402e-02f, 7.21575618e-02f, 1.28527373e-01f,
  9.74103436e-02f, 1.32189333e-01f, 1.19911581e-01f, 1.82376862e-01f, 1.89864695e-01f, 9.36407819e-02f, 1.55889615e-01f, 1.88941896e-01f, 9.29958746e-02f, 3.09831589e-01f,
  3.90204519e-01f, 1.04554079e-01f, -7.01387376e-02f, -4.67748903e-02f, -1.71540126e-01f, -6.77836835e-02f, -1.36652752e-03f, -1.20444193e-01f, -2.11374938e-01f, -4.06686552e-02f,
  2.78299242e-01f, 2.55066484e-01f, 9.71943140e-02f, 1.66367620e-01f, 1.65932745e-01f, -2.54047722e-01f, -2.56181836e-01f, -2.25532576e-02f, 2.48142123e-01f, 1.51852623e-01f,
  9.35112461e-02f, -6.38710856e-02f, 2.39480083e-04f, 2.19523925e-02f, -1.79125935e-01f, -6.78620264e-02f, -3.89974713e-01f, -3.00057754e-02f, 4.81070913e-02f, -9.99486819e-02f,
  3.50844413e-01f, 2.04484388e-01f, -5.68396710e-02f, 6.50336221e-02f, -1.28468825e-03f, 1.16465189e-01f, 1.15750059e-01f, 7.55190998e-02f, -2.29070894e-02f, -2.95260567e-02f,
  8.03938583e-02f, 1.01384141e-01f, 1.58988088e-01f, 4.05909382e-02f, -4.66408245e-02f, 2.65062824e-02f, -1.50942057e-01f, -5.52177615e-02f, -6.58094212e-02f, 6.15296364e-02f,
  1.71974674e-02f, 5.22079393e-02f, 5.92587516e-02f, -6.76246136e-02f, 2.32845768e-02f, 2.39707790e-02f, -3.89297493e-02f, 7.53064826e-02f, -1.52268251e-02f, -9.03420523e-02f,
  1.20984368e-01f, -4.07294028e-05f, -7.50577971e-02f, -1.23569220e-01f, -1.46489531e-01f, -4.96099479e-02f, -4.54862090e-03f, -5.55415526e-02f, -3.74771319e-02f, -1.03755698e-01f,
  -6.76831976e-02f, -2.00630184e-02f, -4.77196835e-02f, 1.86055712e-02f, 3.72327603e-02f, -6.44009262e-02f, -6.37744293e-02f, -8.07862654e-02f, 1.90281998e-02f, -8.39990526e-02f,
  -3.22004110e-02f, -8.24916512e-02f, -6.52940124e-02f, 6.08497905e-03f, 2.30972283e-02f, -1.80468131e-02f, -1.36652328e-02f, -1.74096003e-02f, -5.31811006e-02f, -9.41730663e-03f,
  -1.64301664e-01f, 1.01969820e-02f, 7.71304518e-02f, 5.93535006e-02f, -1.92128904e-02f, -8.41912702e-02f, -4.17555273e-02f, -4.79446724e-02f, 1.00444488e-01f, 6.02820776e-02f,
  4.62780893e-02f, 7.91957229e-02f, 9.03328434e-02f, 1.19667882e-02f, 3.83822918e-02f, 8.76301993e-03f, -8.56055617e-02f, 7.98123702e-02f, -5.29316701e-02f, -4.33036163e-02f,
  -8.56500864e-02f, -1.70290262e-01f, 4.59477715e-02f, -1.36466011e-01f, -1.13099903e-01f, 4.63669598e-02f, 2.51080692e-02f, -1.45493984e-01f, -1.61707383e-02f, -2.00188681e-01f,
  -7.52029717e-02f, -1.97052822e-01f, 7.54438341e-02f, 3.37476015e-01f, 1.40345320e-01f, -2.84674853e-01f, -4.57334369e-01f, -1.72773778e-01f, 1.84772119e-01f, 3.81367393e-02f,
  -1.43934965e-01f, -4.18581702e-02f, 1.17318192e-03f, -9.29211155e-02f, -1.92722902e-01f, -7.35012665e-02f, 2.32590050e-01f, 7.66099766e-02f, -1.98704943e-01f, -1.14163913e-01f,
  6.43636659e-02f, 2.20999762e-01f, 2.10578162e-02f, 7.30220750e-02f, 3.84606481e-01f, 5.44232950e-02f, 1.12129129e-01f, 1.02332495e-01f, -6.38539195e-02f, 2.85391152e-01f,
  -1.79068238e-01f, 1.35020524e-01f, -3.51454727e-02f, 3.96217927e-02f, 6.23872764e-02f, 1.63671635e-02f, -4.48776205e-04f, 1.36727482e-01f, 2.24100463e-02f, 1.22255012e-01f,
  1.45323291e-01f, 6.43248633e-02f, 8.17771256e-02f, 1.34284794e-01f, 4.27962206e-02f, 7.83188418e-02f, 1.57977417e-01f, 9.05890986e-02f, 3.20110545e-02f, -2.02154852e-02f,
  1.11806966e-01f, 7.33785257e-02f, 7.16857463e-02f, 2.81939991e-02f, 1.21098250e-01f, 5.47420718e-02f, 7.70593658e-02f, 1.63623601e-01f, -9.61630046e-02f, 1.52648658e-01f,
  6.05015196e-02f, -8.91548693e-02f, -3.29751000e-02f, -9.77371857e-02f, -1.14380017e-01f, -2.52604485e-02f, -1.13888301e-01f, -9.71537530e-02f, -3.37483510e-02f, -1.40215689e-03f,
  -1.30956843e-01f, -2.17477158e-01f, -4.42355275e-02f, -1.09402977e-01f, -5.14847636e-02f, -4.39199805e-02f, -1.13597468e-01f, -1.15873523e-01f, -6.04650192e-02f, -1.17277160e-01f,
  -1.31038800e-01f, -9.29715037e-02f, -5.14964536e-02f, -8.58737379e-02f, -1.38529003e-01f, -3.14651504e-02f, -4.39185910e-02f, -8.96036476e-02f, -1.27010634e-02f, -9.26164389e-02f,
  -4.46242839e-03f, -2.59719133e-01f, -4.85325046e-02f, 1.13830410e-01f, 1.27333328e-01f, 1.35119826e-01f, 2.06180234e-02f, 2.58399323e-02f, 8.91862884e-02f, -8.42093080e-02f,
  8.49617086e-03f, -3.39483395e-02f, 7.78619424e-02f, 7.35452324e-02f, -1.76522303e-02f, -3.12559232e-02f, 8.37241113e-02f, 3.33718253e-06f, 5.25611416e-02f, 1.28947347e-01f,
  4.87128757e-02f, -1.07602626e-01f, -2.03068808e-01f, -9.39974412e-02f, 9.05155689e-02f, -1.73928440e-01f, -1.40166640e-01f, -8.14448223e-02f, -1.43506050e-01f, -1.56909645e-01f,
  2.19052762e-01f, 3.44296768e-02f, 2.41054103e-01f, 1.37363076e-01f, -8.03895295e-02f, 5.15877679e-02f, 5.61431199e-02f, 1.15671242e-03f, 4.32555154e-02f, 4.39969897e-02f,
  4.82275262e-02f, 5.64250648e-02f, 1.86530699e-03f, -4.87612747e-02f, -7.33957961e-02f, -1.23059601e-01f, -1.83952019e-01f, -5.35266735e-02f, 6.96532205e-02f, 1.36129754e-02f,
  -9.54878032e-02f, 9.90565270e-02f, 8.10919255e-02f, -3.52302603e-02f, -2.67535478e-01f, -1.72668457e-01f, -7.60632828e-02f, -1.78749353e-01f, -1.86287329e-01f, -3.98236841e-01f,
  -6.79149330e-02f, -1.82690710e-01f, -4.48701680e-02f, -1.93294853e-01f, -1.27290264e-01f, -5.88844866e-02f, -1.01995520e-01f, -1.66752666e-01f, -8.55458677e-02f, -1.08645067e-01f,
  -9.59327891e-02f, -1.80064335e-01f, -2.07037121e-01f, -6.75475374e-02f, -1.44789955e-02f, -7.56628811e-02f, -1.21763624e-01f, 4.09188382e-02f, -3.46431285e-02f, -4.44330238e-02f,
  -1.78399801e-01f, -1.60758227e-01f, 2.43002847e-02f, -9.10482034e-02f, -1.76685005e-01f, -1.38845826e-02f, -1.71187282e-01f, -1.10499844e-01f, -1.25604093e-01f, -7.87271857e-02f,
  2.66508572e-03f, 1.46290496e-01f, 1.62718430e-01f, 1.93485186e-01f, 1.59262523e-01f, 1.26737908e-01f, 7.66669810e-02f, 9.50380489e-02f, 1.15421832e-01f, 1.39475822e-01f,
  9.57845524e-02f, 1.95805252e-01f, 1.63536251e-01f, 9.30381417e-02f, 1.66259762e-02f, 6.29626885e-02f, 6.70571104e-02f, 9.03489664e-02f, 7.96378255e-02f, 7.17077106e-02f,
  8.50735307e-02f, 1.65098682e-01f, 8.28154385e-02f, 2.98125129e-02f, 1.25068352e-01f, 7.20805079e-02f, 1.67184085e-01f, 2.36264974e-01f, 1.11325152e-01f, 1.89974234e-01f,
  2.02574492e-01f, -1.21097609e-01f, -3.72634083e-02f, -3.64694633e-02f, -1.39049560e-01f, -1.03507191e-01f, -1.63458660e-01f, -9.51447785e-02f, -1.39471233e-01f, -6.09262995e-02f,
  -9.85958651e-02f, -3.39261368e-02f, -1.13124721e-01f, -1.04658768e-01f, 8.11098330e-03f, -1.09896496e-01f, 2.30449848e-02f, 4.03855182e-02f, -5.47293313e-02f, -1.51860220e-02f,
  -2.22265664e-02f, -1.57573931e-02f, 1.22817867e-01f, -4.59387060e-03f, 1.96256372e-03f, 2.06424613e-02f, 2.72524252e-04f, -7.76560828e-02f, 6.95688576e-02f, 1.41593963e-01f,
  -2.71001160e-01f, -1.78256005e-01f, 3.31167847e-01f, -2.84451041e-02f, -1.07730487e-02f, 7.62049481e-02f, -1.34791166e-01f, -5.62493876e-02f, -5.07483371e-02f, -1.72754928e-01f,
  -2.94988394e-01f, -1.27628371e-01f, 1.69320226e-01f, 1.52790487e-01f, 3.12735885e-01f, 2.08948970e-01f, 4.58108455e-01f, 4.92961645e-01f, 4.62364912e-01f, 1.55562133e-01f,
  8.81498680e-03f, 4.51204628e-02f, 2.65637208e-02f, 1.19597629e-01f, 4.97237034e-02f, 1.70685008e-01f, 9.17032287e-02f, -7.74341123e-03f, 9.09928679e-02f, 1.63724810e-01f,
  9.24558267e-02f, -1.72462910e-01f, 2.28112772e-01f, 4.79100570e-02f, 6.96141794e-02f, 1.34431645e-01f, 2.27347035e-02f, 1.27034694e-01f, -3.65042761e-02f, 8.90129879e-02f,
  -1.90929212e-02f, 7.27451295e-02f, 8.13146010e-02f, 9.06295478e-02f, 9.55568552e-02f, 8.03154036e-02f, 8.87304395e-02f, 9.96138304e-02f, 8.11444670e-02f, 6.06626309e-02f,
  -9.01687816e-02f, 7.57540256e-05f, 9.74915177e-02f, 3.81976962e-02f, 6.12146370e-02f, 2.14679629e-01f, 3.29501815e-02f, 1.21749438e-01f, 1.62062451e-01f, 1.89338927e-03f,
  8.25229660e-02f, 5.73087670e-02f, -1.27534270e-01f, -3.83376330e-02f, -9.09247994e-02f, 1.36187728e-02f, -2.55050622e-02f, 3.55406338e-03f, 7.13376328e-02f, -1.54505009e-02f,
  1.51176751e-02f, -1.86562743e-02f, 4.58861068e-02f, -3.11198644e-02f, 6.28343523e-02f, 2.62707304e-02f, 1.05045270e-02f, -4.74812761e-02f, 2.02045543e-03f, 5.72148524e-02f,
  -1.42868031e-02f, -2.30104662e-02f, -3.80516313e-02f, -9.39611867e-02f, -5.07251360e-02f, 1.68051682e-02f, 2.38751583e-02f, -9.26330239e-02f, -2.09393948e-02f, 2.73183156e-02f,
  -1.45508379e-01f, 1.65174097e-01f, 4.34504263e-02f, 6.29027933e-02f, 4.59714085e-02f, 3.36343683e-02f, 2.45791953e-02f, 7.44965971e-02f, 3.14021036e-02f, -4.83173244e-02f,
  -4.07619551e-02f, 7.61574283e-02f, 4.03589346e-02f, 6.90947026e-02f, 1.01655059e-01f, 3.41920257e-02f, 6.96004322e-03f, -6.27799407e-02f, 1.12920992e-01f, -5.27168810e-02f,
  -3.78437415e-02f, -1.21455519e-02f, 6.00999743e-02f, 6.85456023e-02f, 8.32921341e-02f, 2.50622910e-02f, 1.09597072e-01f, 6.01843446e-02f, 4.29975018e-02f, 1.22256121e-02f,
  -1.15947776e-01f, -4.95932996e-02f, -1.69989079e-01f, -1.22021109e-01f, -9.33792815e-02f, -1.00581020e-01f, -2.33159214e-01f, -4.21418846e-02f, -1.08696185e-01f, -1.16672762e-01f,
  1.59262910e-01f, 3.46244961e-01f, 1.08727060e-01f, 1.07299149e-01f, -7.17647970e-02f, -3.27514648e-01f, -3.03896278e-01f, -2.74967670e-01f, -7.64622316e-02f, -6.48782477e-02f,
  3.72501789e-03f, -6.97549358e-02f, -9.67234224e-02f, -1.85519457e-01f, -2.04333305e-01f, -7.37604350e-02f, -2.79322624e-01f, -1.91033617e-01f, -5.57586998e-02f, -3.03872049e-01f,
  -2.39002407e-01f, -8.58360231e-02f, 3.53220813e-02f, 2.00059544e-02f, -3.52271050e-02f, 5.09680621e-03f, -7.02205151e-02f, -7.98661783e-02f, -3.36262584e-02f, -7.05215633e-02f,
  4.89796512e-02f, 1.14213154e-02f, -1.31730214e-01f, -7.68923312e-02f, -1.60402283e-01f, -6.96937516e-02f, 1.27544515e-02f, -7.67681375e-02f, -4.83156703e-02f, -3.05855423e-02f,
  6.59124833e-03f, -3.68923321e-02f, -1.50001988e-01f, -6.49703369e-02f, -3.63186449e-02f, -9.94669050e-02f, -3.24030034e-02f, -1.76986367e-01f, -8.66251215e-02f, -2.81932473e-01f,
  -4.30814549e-02f, -1.75491795e-02f, 6.59202226e-03f, 9.74344909e-02f, -2.22901478e-02f, 9.89634320e-02f, -6.78984597e-02f, 8.29598606e-02f, -3.07682145e-04f, 7.26785362e-02f,
  7.92660862e-02f, -2.23461054e-02f, 2.78857425e-02f, -1.60782933e-01f, 2.13629752e-02f, -1.32322498e-02f, -2.64232289e-02f, -8.30860883e-02f, 3.53316851e-02f, 1.76432282e-02f,
  6.18745126e-02f, 6.60337284e-02f, 5.26853465e-02f, 2.30963100e-02f, 6.95190653e-02f, -3.53882015e-02f, -1.75163671e-02f, 1.72603548e-01f, 1.03460424e-01f, 8.52530375e-02f,
  1.76267669e-01f, 1.59312248e-01f, -1.44729689e-01f, -2.78561637e-02f, -1.16307214e-01f, -6.36172518e-02f, 1.37436977e-02f, -1.10379823e-01f, 7.10317418e-02f, -1.05094515e-01f,
  2.22141389e-02f, -5.23137040e-02f, -4.13229577e-02f, 1.48859899e-03f, -5.51624363e-03f, -3.13038975e-02f, -2.56953351e-02f, -5.41142672e-02f, -3.57342437e-02f, -1.35312220e-02f,
  -5.94157167e-02f, -9.87947881e-02f, -7.48010539e-03f, -1.33035183e-01f, -3.45986374e-02f, -1.67236030e-02f, -1.93496317e-01f, -7.89244100e-02f, -8.86214674e-02f, -2.26468638e-01f,
  -9.29428078e-03f, -1.49287373e-01f, 1.25548139e-01f, -1.36057451e-01f, 1.99477583e-01f, 2.77392894e-01f, 1.93435833e-01f, 2.97290069e-04f, 1.89215001e-02f, -2.22211797e-02f,
  -4.03694548e-02f, -2.17283592e-02f, -1.70842946e-01f, -1.45047069e-01f, -2.21741661e-01f, -4.15234901e-02f, -1.03937194e-01f, -7.02504739e-02f, -9.31726955e-03f, 7.17421994e-02f,
  4.78197299e-02f, -1.12675168e-01f, -1.07635260e-01f, -1.10131465e-01f, 9.36530828e-02f, 3.93017009e-02f, -4.77545261e-02f, 7.74780139e-02f, 1.23759188e-01f, -7.03897774e-02f,
  7.31445178e-02f, 2.70269508e-03f, 1.93571836e-01f, -4.31905985e-02f, 1.36140764e-01f, 1.66697547e-01f, 1.41704962e-01f, 9.87326875e-02f, 1.36522114e-01f, 1.44459054e-01f,
  6.44944459e-02f, -2.04198901e-02f, 1.48790650e-05f, 8.06975067e-02f, 1.04652889e-01f, 1.28786609e-01f, -7.44893542e-03f, -4.88543622e-02f, 6.71744049e-02f, 5.34167700e-02f,
  -3.57888900e-02f, 1.71290949e-01f, 5.68234250e-02f, 1.77361779e-02f, -1.65864434e-02f, 4.08682749e-02f, 8.29693899e-02f, 1.76016092e-01f, 1.50763214e-01f, 7.98169076e-02f,
  -6.48755804e-02f, 1.52474241e-02f, 3.66738439e-02f, -1.23632863e-01f, -1.03672296e-01f, -3.48463506e-02f, -1.29675522e-01f, -9.25734490e-02f, 2.72045322e-02f, 2.40267143e-02f,
  -7.89477825e-02f, -7.90003687e-02f, -1.18683577e-01f, -2.43885759e-02f, -1.13649808e-01f, 6.28281198e-03f, -7.52148330e-02f, -9.75404531e-02f, -1.08182788e-01f, -4.04875400e-03f,
  4.24247628e-05f, -3.28016020e-02f, -4.44209352e-02f, -1.16863161e-01f, -1.51274335e-02f, -5.00526130e-02f, 1.69513766e-02f, -7.15704709e-02f, -9.69297811e-02f, 4.78383861e-02f,
  -3.40687446e-02f, 2.16198534e-01f, 2.16971152e-02f, -9.32205841e-03f, 1.15303792e-01f, 1.07820779e-01f, 6.06509112e-02f, 9.49350819e-02f, 7.68400356e-02f, 7.79594108e-02f,
  9.93991643e-02f, -9.25550163e-02f, -5.38680516e-03f, 1.88775092e-01f, 1.25408977e-01f, 8.58646035e-02f, -7.13468641e-02f, 6.32407665e-02f, 4.09984216e-02f, 1.19148389e-01f,
  3.29122320e-02f, 1.34149805e-01f, 5.83056249e-02f, 1.37260064e-01f, 1.05348147e-01f, 1.43788680e-01f, 1.17025651e-01f, 1.67646527e-01f, 1.88034564e-01f, 8.76806751e-02f,
  4.18552279e-01f, 7.00336993e-02f, 2.34043300e-01f, 1.75784498e-01f, 2.25971192e-01f, 3.77975255e-01f, 4.45970565e-01f, 2.58279890e-01f, 6.50665313e-02f, 2.23732784e-01f,
  1.68867335e-01f, -1.25377119e-01f, -1.37998000e-01f, 1.93233509e-02f, 2.60638539e-02f, 2.77301967e-01f, 2.17293516e-01f, 1.65032089e-01f, 6.77832216e-02f, 1.55210227e-01f,
  3.43801640e-02f, -2.89074201e-02f, -1.28536094e-02f, -8.91774073e-02f, -7.14210495e-02f, -7.63669536e-02f, 1.04240134e-01f, -1.17108338e-02f, -5.78158014e-02f, -1.67386178e-02f,
  -9.08909142e-02f, 2.14339837e-01f, 9.63893160e-03f, -2.43989807e-02f, 6.52883872e-02f, 4.58408613e-03f, -3.18779796e-03f, 5.23816384e-02f, 3.06803291e-03f, -8.24789982e-04f,
  9.27472189e-02f, 8.52533355e-02f, 9.20097455e-02f, -1.79053153e-04f, 6.34063631e-02f, -2.95442138e-02f, 5.04210666e-02f, 1.84506569e-02f, -8.29296187e-03f, 1.03913166e-01f,
  4.86789271e-02f, 6.17512241e-02f, 8.08911175e-02f, 2.83928365e-02f, 1.87105499e-02f, -9.37032327e-02f, 4.41409368e-03f, -1.28755216e-02f, 5.77932689e-03f, 3.48790251e-02f,
  -2.83721816e-02f, -7.69435614e-02f, 3.65030356e-02f, -7.66981542e-02f, 9.25376564e-02f, -8.40947963e-03f, -1.17032798e-02f, -3.66799310e-02f, -4.41407785e-02f, -1.57471895e-01f,
  8.84920284e-02f, 8.35342705e-02f, 6.16096184e-02f, 3.19217518e-02f, 2.87883673e-02f, 4.75814492e-02f, 1.71734113e-02f, 3.35022737e-03f, -1.24545842e-01f, 5.63592799e-02f,
  -4.67883013e-02f, 7.13237450e-02f, 3.95553792e-03f, -1.30214375e-02f, 8.55129063e-02f, -1.54313855e-02f, -6.57352433e-02f, 3.93585749e-02f, -1.04799412e-01f, -1.16321230e-02f,
  -3.12447101e-01f, 9.32046473e-02f, 2.07818449e-02f, -7.28097782e-02f, 1.72903705e-02f, -7.48215169e-02f, -7.87847489e-02f, -3.43853906e-02f, -4.38747108e-02f, -8.95040780e-02f,
  8.84643346e-02f, -3.26871430e-03f, -5.04877493e-02f, -7.18126670e-02f, -3.79425436e-02f, -6.86788261e-02f, 2.53978204e-02f, 5.06668910e-02f, 2.08668839e-02f, -1.13570899e-01f,
  1.44543245e-01f, 2.00529378e-02f, -7.52344131e-02f, -7.49844015e-02f, -9.00944695e-02f, -7.44085014e-02f, -2.20201001e-01f, -1.08805381e-01f, -6.99719787e-02f, -5.98497204e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.04492772e+00f, -6.84573174e-01f, -1.01514637e+00f, 3.13094884e-01f, 9.62510780e-02f, 1.99149385e-01f, 2.71466643e-01f, 3.29410523e-01f, 3.12288374e-01f, -1.83200866e-01f,
  -1.15658984e-01f, 1.19871646e-01f, -1.49029732e-01f, -1.61029115e-01f, 7.08996654e-02f, -3.74831498e-01f, -5.09047568e-01f, -2.02575922e-01f, 5.58017135e-01f, 6.36019289e-01f,
  3.22243929e-01f, 4.08520937e-01f, 4.08050090e-01f, 1.67946234e-01f, -2.27754161e-01f, 5.46635464e-02f, -6.05437934e-01f, -4.25591409e-01f, -3.69901538e-01f, -7.74946749e-01f,
  -2.99461693e-01f, -6.08190954e-01f, 8.36509615e-02f, -1.15982167e-01f, -1.77817121e-01f, 5.73629774e-02f, 7.24742860e-02f, -8.52428302e-02f, 5.74003011e-02f, -6.32098615e-02f,
  -1.80856541e-01f, -8.15250799e-02f, -6.00033589e-02f, 2.02056393e-02f, 1.96798787e-01f, -9.04238038e-03f, -8.17502588e-02f, -1.31340951e-01f, -8.96673128e-02f, -2.15475813e-01f,
  -2.56541401e-01f, -2.11330265e-01f, -3.20244990e-02f, -1.38535678e-01f, -1.24797195e-01f, -7.82789141e-02f, -1.20666347e-01f, -6.57239631e-02f, -4.32974324e-02f, -7.27417469e-02f,
  7.35148191e-02f, -6.48508295e-02f, -3.48852873e-02f, -4.03782837e-02f, 1.73484147e-01f, -2.41273735e-02f, 3.11478302e-02f, -3.70886102e-02f, 2.35289633e-02f, 7.75768748e-03f,
  6.14048541e-02f, -1.39885724e-01f, -4.11001071e-02f, -1.09330773e-01f, -6.37943223e-02f, -9.36354920e-02f, 2.20902488e-02f, -9.80153158e-02f, -1.37183130e-01f, 1.47685051e-01f,
  -9.81267355e-03f, -5.24580777e-02f, -1.16497248e-01f, -6.02710098e-02f, -1.08338952e-01f, -1.49556801e-01f, -1.21906266e-01f, 4.48315963e-02f, 5.77757247e-02f, 4.91399541e-02f,
  7.55813599e-01f, -3.14895034e-01f, -3.72572406e-03f, -1.58909470e-01f, -2.14128584e-01f, -9.31860581e-02f, -2.04848707e-01f, -5.70009314e-02f, -5.16090617e-02f, 2.80182138e-02f,
  -7.43997619e-02f, -1.45104183e-02f, -1.20800994e-01f, 4.45043854e-02f, 2.81909585e-01f, 5.16767614e-02f, -2.44937185e-02f, -4.44101952e-02f, -3.23172212e-02f, 4.08244766e-02f,
  3.18135247e-02f, 2.60478109e-01f, 5.11357009e-01f, 6.46391585e-02f, 4.20881920e-02f, 3.18648577e-01f, 1.26224592e-01f, 6.76835179e-02f, 1.72329664e-01f, 5.37137210e-01f,
  -1.58702552e+00f, -3.29343230e-01f, 7.13061392e-01f, -1.23750556e+00f, -1.48180395e-01f, 3.50998610e-01f, 8.05142373e-02f, -1.99114934e-01f, -5.69442391e-01f, -3.19748878e-01f,
  1.92731529e-01f, 2.00718254e-01f, 2.12867334e-01f, 4.41516370e-01f, 2.65901566e-01f, -2.54891098e-01f, -2.69664764e-01f, 4.78893220e-01f, 9.68392849e-01f, 4.76264089e-01f,
  -8.96290466e-02f, -3.44683260e-01f, -1.65332884e-01f, 4.90898546e-03f, -6.25455856e-01f, -5.76319098e-02f, -2.09748730e-01f, -4.43608850e-01f, 1.51278168e-01f, -8.43004107e-01f,
  5.23011327e-01f, -4.80885625e-01f, 2.52660245e-01f, 1.08883902e-01f, -3.16959769e-02f, -5.69662265e-02f, -5.85893318e-02f, -3.47192138e-01f, -1.60304174e-01f, -1.99843481e-01f,
  -2.61220664e-01f, 1.61609784e-01f, -1.80580944e-01f, 1.25159606e-01f, -3.01483035e-01f, 7.33340811e-03f, -2.63609346e-02f, 7.02571943e-02f, -6.69002831e-02f, 1.63181946e-01f,
  3.50244492e-02f, -1.21397793e-01f, 1.61720604e-01f, 3.44682246e-01f, 2.15084404e-01f, 3.30649167e-01f, 3.36422920e-01f, 1.09058097e-01f, 2.72931606e-01f, -4.12771285e-01f,
  -1.89247951e-01f, -2.74480972e-02f, 4.49633971e-02f, -1.07433018e-03f, -2.26341039e-02f, -6.74880520e-02f, 8.37164652e-03f, 9.93926376e-02f, 3.04111410e-02f, 6.63798824e-02f,
  6.79483786e-02f, -8.76931474e-02f, 1.18989326e-01f, -2.33046174e-01f, -1.69023290e-01f, -2.03356743e-01f, -4.11805250e-02f, -1.41662419e-01f, -9.93755534e-02f, -3.31703722e-01f,
  -3.41087505e-02f, -9.62324217e-02f, -2.84763783e-01f, 1.75446898e-01f, -7.29017425e-04f, 1.98074449e-02f, -1.70000285e-01f, 3.42114568e-01f, -1.27994478e-01f, -1.52931765e-01f,
  -1.01254538e-01f, 3.90563667e-01f, -3.74431938e-01f, -1.70684204e-01f, -3.74749631e-01f, -4.74100485e-02f, -2.65084416e-01f, 3.27437222e-02f, -1.32620618e-01f, 2.32635587e-02f,
  2.02015594e-01f, 6.17552623e-02f, -1.61226541e-01f, 1.64669394e-01f, 3.04908734e-02f, -7.70072713e-02f, -2.25011826e-01f, -5.31785339e-02f, -2.45322213e-02f, -5.50685786e-02f,
  -1.19073711e-01f, -1.32885024e-01f, -8.92270356e-02f, 4.91662845e-02f, -4.62364517e-02f, 9.96385068e-02f, 3.24508160e-01f, 9.82607156e-02f, 1.51913568e-01f, -4.57476676e-01f,
  -1.06250286e+00f, 9.54999775e-02f, -1.25141895e+00f, 1.58713177e-01f, 6.12947226e-01f, -1.80355936e-01f, -6.87796295e-01f, -3.65903944e-01f, 4.69115317e-01f, 1.46944776e-01f,
  5.87221920e-01f, 7.01740921e-01f, -7.98675567e-02f, -2.31059685e-01f, -1.12191975e+00f, -4.39762115e-01f, -5.25440812e-01f, -1.07878101e+00f, -8.21208894e-01f, 2.10576639e-01f,
  9.54720974e-01f, 2.78393757e-02f, -6.84773624e-01f, -1.35423362e-01f, 9.24499512e-01f, 2.96432525e-01f, -5.19567989e-02f, -5.26328720e-02f, -8.54277611e-02f, 7.48993307e-02f,
  -3.92728806e-01f, -6.26500368e-01f, 5.41601665e-02f, 8.58958587e-02f, 1.92663506e-01f, -1.06640518e-01f, -1.01986021e-01f, -2.05830142e-01f, 1.22855073e-02f, -5.06034270e-02f,
  2.32762873e-01f, 1.11857839e-01f, 2.98119992e-01f, 1.01070844e-01f, -2.61508077e-02f, -2.49327809e-01f, -3.67605478e-01f, -6.83453441e-01f, -6.72394931e-01f, -3.80399317e-01f,
  6.40628219e-01f, 8.19094479e-02f, -9.92485523e-01f, -4.99819487e-01f, -4.34057713e-01f, -2.14566588e-01f, -3.57493162e-01f, -1.30351335e-01f, -8.75617445e-01f, -4.51630592e-01f,
  -9.41440761e-02f, -1.97104260e-01f, 8.59753415e-02f, -5.41318813e-03f, 2.09594250e-01f, 2.75153100e-01f, 6.49737492e-02f, 5.49092777e-02f, 1.22055106e-01f, 2.12995317e-02f,
  -1.31781712e-01f, 7.43508637e-02f, -6.23065121e-02f, -1.64809808e-01f, -1.91124558e-01f, -4.17034095e-03f, -8.03125501e-02f, -1.77473530e-01f, -2.16156557e-01f, 1.46644041e-01f,
  -7.73012489e-02f, 4.73462194e-02f, 2.67039001e-01f, -1.11114986e-01f, -4.05186936e-02f, -3.97788793e-01f, 1.08062379e-01f, 2.40378112e-01f, -1.05370693e-01f, -1.86480451e-02f,
  3.77793103e-01f, -2.27307938e-02f, -1.42008319e-01f, 2.86620632e-02f, -1.73804313e-02f, 3.05558532e-01f, -6.83185011e-02f, 2.87907925e-02f, 8.37865174e-02f, -1.56881705e-01f,
  -2.42527649e-01f, -1.34582147e-01f, 2.70691961e-01f, 1.71362415e-01f, -7.22943619e-02f, -7.87933096e-02f, 1.24769881e-01f, -2.23330297e-02f, -1.62497029e-01f, 4.43453699e-01f,
  1.05346944e-02f, -2.14298919e-01f, -4.75214183e-01f, -5.88753164e-01f, 1.62866935e-01f, -4.72353309e-01f, -4.23094243e-01f, -1.54867873e-01f, -8.06020856e-01f, -4.74109530e-01f,
  1.05316603e+00f, 2.89383262e-01f, 3.63044441e-01f, 5.54796159e-01f, 5.73789954e-01f, -2.69571871e-01f, -8.56933892e-01f, -6.78950071e-01f, 6.61751628e-02f, -2.82393754e-01f,
  2.56262034e-01f, 2.99812347e-01f, 3.47402722e-01f, -2.95956999e-01f, -7.58075356e-01f, -8.71866107e-01f, -5.04294574e-01f, -4.22929227e-01f, -7.02231109e-01f, -5.70795298e-01f,
  -2.41378263e-01f, 1.58943743e-01f, 4.98533063e-02f, -3.03901643e-01f, 4.70515996e-01f, 2.81511266e-02f, 3.61023754e-01f, 4.14486557e-01f, -1.15476504e-01f, 2.33676836e-01f,
  4.08332527e-01f, 6.23827934e-01f, -4.08590436e-01f, 2.69623920e-02f, 3.13527703e-01f, -1.67801425e-01f, -1.95675030e-01f, 8.75939727e-02f, -6.30333612e-04f, -1.01345755e-01f,
  4.54617083e-01f, 2.29002200e-02f, 2.93409467e-01f, 6.51485287e-03f, 1.38314543e-02f, -1.39100671e-01f, -3.02790347e-02f, -3.13300908e-01f, -7.75646642e-02f, -1.01216093e-01f,
  1.65607650e-02f, 3.06320637e-01f, 5.41910827e-01f, -1.65077418e-01f, 3.74496132e-02f, 1.50234699e-01f, 1.02965772e-01f, 1.30639046e-01f, 1.16847627e-01f, 5.32005392e-02f,
  -2.50351727e-01f, -6.01843856e-02f, -8.46000537e-02f, 3.22973169e-02f, -1.83282256e-01f, 1.76870450e-01f, 1.48031011e-01f, 2.39515975e-02f, -5.63354716e-02f, 1.32214144e-01f,
  3.21982317e-02f, 1.10028729e-01f, 9.73999873e-02f, 1.60436362e-01f, 1.00480475e-01f, 2.85847753e-01f, 1.07381806e-01f, -1.23072065e-01f, 1.06787108e-01f, 4.36550193e-02f,
  5.69943450e-02f, 5.17656244e-02f, 2.37639427e-01f, -1.55189097e-01f, 1.68886818e-02f, 9.51366052e-02f, 1.46789979e-02f, 4.29608859e-02f, 7.90089369e-02f, 1.73590794e-01f,
  1.37620047e-01f, -2.29872018e-01f, 7.89920315e-02f, -3.43482584e-01f, -3.99706475e-02f, 4.34688516e-02f, 1.39790177e-01f, -6.08652458e-02f, 2.91519105e-01f, -1.23527870e-01f,
  -3.26623693e-02f, -1.52443070e-02f, 2.91445762e-01f, -2.13527322e-01f, -1.90671444e-01f, 8.49684700e-02f, -3.87852862e-02f, -1.96960047e-02f, -2.33393371e-01f, 3.86061817e-02f,
  -2.04320416e-01f, -4.80962217e-01f, -2.43217781e-01f, -3.03063184e-01f, 2.38547269e-02f, 1.29451752e-02f, -5.09165637e-02f, -1.91904321e-01f, -2.43986219e-01f, -7.30165243e-01f,
  -8.94434512e-01f, -6.26686275e-01f, 2.76995838e-01f, -1.15884459e+00f, -5.00419915e-01f, 1.41955152e-01f, -6.93475306e-01f, -3.71055394e-01f, -3.35042775e-01f, -6.10885143e-01f,
  5.36140464e-02f, 7.41065592e-02f, -1.17680812e-02f, 1.22245066e-01f, 3.57895017e-01f, -5.55628479e-01f, -2.16536403e-01f, 3.64365727e-01f, 3.95258009e-01f, -3.21159244e-01f,
  -6.25321984e-01f, -9.07703876e-01f, -2.09686697e-01f, -1.44305110e-01f, -1.09073329e+00f, -3.67756993e-01f, -3.49127382e-01f, -4.94680762e-01f, 1.54117569e-01f, -9.83252108e-01f,
  -7.67964900e-01f, -2.00896412e-02f, 3.36731553e-01f, 1.19136684e-01f, -3.54675561e-01f, 7.60089383e-02f, -2.01758429e-01f, -1.75000411e-02f, 2.81006038e-01f, -1.01763392e-02f,
  -2.83548441e-02f, 3.61957461e-01f, 5.28133176e-02f, 9.76633132e-02f, -2.10872546e-01f, 3.27874608e-02f, 2.40197964e-02f, 2.14584172e-01f, 1.40471160e-01f, 8.16541687e-02f,
  -1.00331582e-01f, 8.53674859e-02f, 2.11850747e-01f, 2.41941035e-01f, 8.81437883e-02f, 3.85125697e-01f, -4.15700600e-02f, 1.16735950e-01f, 6.51885986e-01f, -1.07191420e+00f,
  -1.02265991e-01f, -9.40363202e-03f, -5.75898439e-02f, 1.19717922e-02f, -7.55409300e-02f, 1.30019486e-01f, -3.42991529e-03f, -9.59097221e-02f, 9.84929204e-02f, -3.44489694e-01f,
  6.22292459e-02f, 9.71178934e-02f, -2.68520284e-02f, -2.14134082e-01f, 4.50257659e-02f, 2.58953068e-02f, 1.18997283e-01f, -4.82262932e-02f, 5.72082996e-02f, 3.64238992e-02f,
  2.86358967e-03f, 3.37996297e-02f, 5.12743033e-02f, -4.21794467e-02f, 2.32089385e-01f, 2.79830750e-02f, 9.48288664e-03f, 6.66362569e-02f, -2.04167068e-01f, 6.44942150e-02f,
  -6.71728611e-01f, 1.03013289e+00f, -5.46627462e-01f, 1.31879285e-01f, -1.11971177e-01f, 1.34843633e-01f, -1.46335945e-01f, 7.96297491e-02f, -9.45170298e-02f, -2.56242484e-01f,
  1.34332940e-01f, -2.65886158e-01f, -5.36288209e-02f, -4.08100374e-02f, -1.04211397e-01f, 6.26602918e-02f, -1.49649113e-01f, -2.51694143e-01f, 2.80327201e-01f, -1.29568279e-01f,
  -6.22398295e-02f, -8.87720212e-02f, -4.29109842e-01f, -2.94269890e-01f, -2.68295050e-01f, 3.43096927e-02f, -4.83559340e-01f, -3.56765389e-01f, 2.20770776e-01f, -1.32331359e+00f,
  -2.10447073e-01f, -7.97783613e-01f, 3.35156739e-01f, 4.68449980e-01f, 6.71868563e-01f, 4.23101693e-01f, 1.97021380e-01f, 2.74924010e-01f, 2.59264678e-01f, 1.33498311e-01f,
  -3.24678093e-01f, 4.02358212e-02f, 3.16865258e-02f, -2.13875659e-02f, 6.35604635e-02f, 3.31366509e-01f, 5.05070090e-01f, 3.36702615e-01f, 3.33437532e-01f, 1.20315768e-01f,
  4.64475639e-02f, -4.70443629e-03f, -1.76785409e-01f, 6.00852892e-02f, -6.97027380e-03f, 2.53959775e-01f, 9.39142108e-02f, -8.46782047e-03f, -7.18603730e-02f, 1.95400387e-01f,
  -1.95434496e-01f, -3.43097925e-01f, 1.87439397e-01f, -1.84180930e-01f, -2.07387537e-01f, -2.24731088e-01f, 4.00104485e-02f, -2.86555529e-01f, -2.15147197e-01f, -3.10116690e-02f,
  -1.56782568e-01f, -2.10508063e-01f, 7.01311305e-02f, -1.25219315e-01f, -2.35671159e-02f, -2.15310171e-01f, -6.63694069e-02f, -2.72983685e-02f, 1.24445438e-01f, -5.16455509e-02f,
  3.34282368e-02f, 3.74664590e-02f, 2.46401548e-01f, 2.04720020e-01f, 1.62174299e-01f, 1.42157584e-01f, -1.64311379e-01f, 3.53774317e-02f, -1.87871698e-02f, -7.46465698e-02f,
  1.68493539e-01f, 8.22023228e-02f, 9.84544083e-02f, 8.26425701e-02f, 9.63038579e-03f, 1.23748846e-01f, 2.45138943e-01f, 4.99475859e-02f, 1.24812573e-01f, 5.65016232e-02f,
  2.74004098e-02f, 2.97113210e-01f, 4.28606123e-02f, 4.56362544e-03f, 8.55959877e-02f, 1.54911876e-01f, 6.07113875e-02f, -1.19697899e-01f, 1.81717485e-01f, 3.64106558e-02f,
  9.66844559e-02f, 1.38115212e-01f, -1.76984280e-01f, -1.88410487e-02f, -7.64252394e-02f, 2.07365066e-01f, 4.49124500e-02f, -9.17888731e-02f, -9.13102925e-02f, 3.55577841e-02f,
  -1.93691880e-01f, 5.27631998e-01f, 3.44845116e-01f, -3.70090716e-02f, -1.05129302e-01f, -1.44130260e-01f, 7.92215168e-02f, -1.54180780e-01f, -1.68588310e-01f, -7.54445493e-02f,
  -1.98989689e-01f, -1.90114498e-01f, -1.08128883e-01f, -1.12699665e-01f, -2.41500773e-02f, -2.06868220e-02f, -2.26183638e-01f, 9.68730971e-02f, 7.82497376e-02f, -9.78609920e-02f,
  -1.36168689e-01f, 2.16183186e-01f, 2.35123098e-01f, 2.06419036e-01f, 7.76408538e-02f, 1.74698308e-01f, -8.31009522e-02f, -3.21924202e-02f, 1.35254145e-01f, -2.17039809e-02f,
  1.36702669e+00f, 5.01367748e-01f, 2.18748987e-01f, 3.62864375e-01f, 2.56148428e-01f, -6.96471557e-02f, -1.33465961e-01f, -1.71667948e-01f, 5.06566316e-02f, 3.36815447e-01f,
  5.05517781e-01f, 5.08750319e-01f, 3.97360355e-01f, 1.39312372e-01f, -3.11157126e-02f, -2.71767795e-01f, -2.82850832e-01f, -2.66358573e-02f, 7.40085542e-02f, 1.19726665e-01f,
  1.79407552e-01f, 1.34532526e-01f, 1.01978883e-01f, 6.55417889e-02f, 2.10612103e-01f, 1.45089850e-01f, 1.89680327e-02f, 7.30834231e-02f, 2.07892731e-01f, 2.62847334e-01f,
  6.05110228e-01f, 2.76019394e-01f, -1.62938699e-01f, 9.36982185e-02f, 3.94068621e-02f, -1.06319532e-01f, -8.53557885e-02f, -2.32372522e-01f, 2.85032298e-02f, -1.95964321e-01f,
  -1.03458483e-02f, 1.62390530e-01f, -1.06476117e-02f, -3.94123718e-02f, -8.03492740e-02f, -1.91842660e-01f, -1.05197780e-01f, -1.39050677e-01f, -1.56989712e-02f, 2.57797912e-02f,
  2.74371300e-02f, 1.52176261e-01f, 4.63479804e-03f, -1.37423962e-01f, 6.36021467e-03f, 1.42871320e-01f, 1.22129358e-01f, 9.10905227e-02f, -4.53385115e-02f, 6.18858784e-02f,
  4.90153730e-01f, 2.30518565e-01f, 3.33909810e-01f, 1.53258830e-01f, 1.56825289e-01f, 5.76169454e-02f, -9.64368060e-02f, -1.21739963e-02f, 3.47096622e-02f, 5.97137436e-02f,
  1.14927683e-02f, 6.36257231e-02f, -5.54693416e-02f, -8.44164640e-02f, 1.73119113e-01f, 1.81839406e-01f, -1.57451630e-01f, -7.08299549e-03f, 4.74780332e-03f, -1.16782360e-01f,
  1.43905327e-01f, -9.10339952e-02f, -1.19980343e-03f, -6.99184164e-02f, -9.89812911e-02f, 1.20783202e-01f, 2.63825320e-02f, 1.39607221e-01f, 5.94003722e-02f, 3.50672305e-02f,
  -8.15982461e-01f, 1.23922108e-02f, 1.01028733e-01f, -1.43299714e-01f, 5.19488491e-02f, -7.11917952e-02f, 2.13712275e-01f, -7.52689829e-03f, -9.41747874e-02f, -2.20623702e-01f,
  -1.19783446e-01f, 7.71756843e-02f, -2.26355419e-02f, -1.67610541e-01f, -2.93549091e-01f, -1.13871135e-01f, 5.24605699e-02f, 2.96108406e-02f, -4.50009592e-02f, -3.43243144e-02f,
  -1.72241047e-01f, -1.50306195e-01f, -1.76534444e-01f, -1.69769660e-01f, -1.53169960e-01f, 9.47715156e-03f, -1.08778037e-01f, -1.25451908e-01f, -1.49528220e-01f, -2.17921421e-01f,
  6.24274790e-01f, -5.62995136e-01f, 1.24157794e-01f, -3.03698462e-02f, -5.25036573e-01f, -7.47000873e-01f, -8.05128038e-01f, -4.22070622e-01f, -1.96670696e-01f, -1.21772073e-01f,
  -4.32466686e-01f, 9.68092382e-02f, 4.29106027e-01f, -6.11151895e-03f, -2.01009855e-01f, 1.25562539e-02f, 1.09400012e-01f, 2.22639218e-01f, -7.78569952e-02f, -7.62440979e-01f,
  -5.30502141e-01f, -8.11996385e-02f, -1.34034883e-02f, -1.75415233e-01f, -1.07734881e-01f, 8.71657804e-02f, 1.48989186e-01f, -2.63209075e-01f, -5.96138060e-01f, -9.29516740e-03f,
  3.12750518e-01f, -3.69465113e-01f, -3.22441608e-02f, -1.12981685e-01f, -1.49332881e-02f, 3.60377133e-02f, 4.12484556e-02f, 3.60959321e-02f, 4.06679921e-02f, 1.38958320e-02f,
  -1.23460531e-01f, -1.91481501e-01f, -4.04518321e-02f, -6.62564412e-02f, -2.86868997e-02f, -7.44759887e-02f, -1.00975864e-01f, -1.90103024e-01f, -6.62205666e-02f, -6.23059608e-02f,
  -3.00942838e-01f, -3.09064448e-01f, 1.00331545e-01f, -3.62789482e-02f, -8.94832984e-02f, 8.29558447e-02f, -1.05088368e-01f, -1.02072060e-01f, -1.41788840e-01f, 1.36440799e-01f,
  -2.03537986e-01f, 1.90676272e-01f, -9.08489972e-02f, -5.73193654e-02f, -1.11034058e-01f, 7.73082450e-02f, 6.58595860e-02f, -7.80669749e-02f, -9.33413580e-02f, -8.96645114e-02f,
  -1.76773041e-01f, -1.16925076e-01f, -1.34902939e-01f, -1.08663432e-01f, -1.81692522e-02f, -9.92952660e-02f, -1.54404119e-01f, -2.61648387e-01f, -2.28516400e-01f, -1.68727010e-01f,
  -2.19972745e-01f, -1.44799590e-01f, 3.11171394e-02f, -1.60382673e-01f, -2.52314746e-01f, -1.68730974e-01f, -1.26602232e-01f, -2.74584025e-01f, -2.22593565e-02f, -1.58597171e-01f,
  3.61532182e-01f, -2.84120917e-01f, 3.52585524e-01f, 9.12673995e-02f, -2.11541187e-02f, -7.46973082e-02f, 3.81692611e-02f, -1.85829803e-01f, 9.09068510e-02f, -6.13871627e-02f,
  -2.93244332e-01f, 8.03431496e-02f, 5.79918697e-02f, -2.59140674e-02f, -4.47888598e-02f, -1.41504660e-01f, -1.52036339e-01f, 3.83707061e-02f, -1.09097525e-01f, -1.03756428e-01f,
  -2.43266057e-02f, 6.81188554e-02f, 3.63480389e-01f, 2.88414150e-01f, 2.01824419e-02f, 3.72349769e-01f, 3.76425356e-01f, 1.34866178e-01f, 1.96826115e-01f, 4.02788013e-01f,
  1.08992326e+00f, 7.62809396e-01f, 3.49735051e-01f, 1.80045769e-01f, -5.61858378e-02f, 3.25699091e-01f, 7.57570744e-01f, 5.36750793e-01f, 1.25259040e-02f, 3.31733823e-01f,
  2.06710711e-01f, -1.03437319e-01f, 2.42817421e-02f, -1.72355890e-01f, 1.91904396e-01f, -1.67233020e-01f, -3.30385476e-01f, -2.13192254e-02f, 1.04651168e-01f, 1.89060196e-02f,
  -1.79173157e-01f, 1.51524559e-01f, 4.67440307e-01f, 3.19030858e-03f, -2.40105674e-01f, -3.05752188e-01f, 2.30993167e-03f, -3.54979634e-02f, -6.75875023e-02f, -4.52807277e-01f,
  -3.34364414e-01f, 4.61171269e-01f, -3.90269488e-01f, -2.53944010e-01f, -7.47300386e-02f, 7.73015767e-02f, -5.39364181e-02f, 1.24606073e-01f, 1.11201204e-01f, -1.90496534e-01f,
  -1.88161954e-01f, 3.93544994e-02f, 1.87078163e-01f, 1.44164085e-01f, -1.86786661e-03f, 8.91162306e-02f, 4.27088775e-02f, 1.06818423e-01f, 7.17967451e-02f, 4.43853028e-02f,
  -1.64833367e-01f, -4.21830267e-02f, 6.25935942e-02f, -8.65085721e-02f, 4.92941290e-02f, -7.32027218e-02f, 1.17507972e-01f, -1.83639359e-02f, 2.13843305e-02f, -1.96165987e-03f,
  -1.49779350e-01f, -6.11005444e-03f, -7.16500124e-03f, -5.22353388e-02f, 2.11040840e-01f, -3.17768566e-02f, -1.41014650e-01f, -1.49391159e-01f, 9.42436978e-02f, 2.02997953e-01f,
  -9.89478379e-02f, 2.59780884e-02f, 1.63215637e-01f, 8.18688571e-02f, -2.37234682e-01f, -4.60189506e-02f, 2.87347427e-03f, 1.18290797e-01f, 7.69264717e-03f, 1.14823908e-01f,
  1.73545912e-01f, 9.96512845e-02f, 1.53033793e-01f, 2.56112278e-01f, 1.00489907e-01f, -3.65857184e-02f, -6.46434426e-02f, 1.34230539e-01f, 1.46246403e-01f, 6.17292635e-02f,
  -2.45243296e-01f, 1.39777854e-01f, -2.92914510e-01f, -2.14891389e-01f, 2.10170988e-02f, 1.41146854e-01f, -1.18324988e-01f, -9.52864364e-02f, -1.22911334e-01f, -1.30552426e-01f,
  -3.10607422e-02f, -1.15283482e-01f, 2.08374277e-01f, 1.14515208e-01f, -1.93512421e-02f, -1.88263327e-01f, -7.83608109e-02f, 4.65488285e-02f, -6.18810914e-02f, -1.98237136e-01f,
  -1.09603226e-01f, -7.34614730e-02f, 1.08472317e-01f, -3.80645543e-02f, -1.90062314e-01f, -3.41297120e-01f, -9.97412056e-02f, -7.01111648e-03f, 8.40696618e-02f, 3.54448199e-01f,
  -1.03443086e+00f, 7.23204672e-01f, -5.65509349e-02f, -4.33761388e-01f, -3.84431660e-01f, -3.58143806e-01f, 1.08291700e-01f, 5.45852706e-02f, 1.76983789e-01f, 5.69323778e-01f,
  2.85206586e-01f, -4.70374674e-01f, -1.42562270e-01f, -3.40286255e-01f, -5.97121298e-01f, 8.92958418e-02f, -3.28576982e-01f, -1.15160251e+00f, -1.24871123e+00f, -7.70312786e-01f,
  -5.06566882e-01f, -8.30975235e-01f, -1.13869798e+00f, -6.25698805e-01f, 2.66523808e-01f, -3.40812325e-01f, 1.48772091e-01f, -5.36474645e-01f, -3.51805985e-01f, -3.58147956e-02f,
  2.65377462e-01f, -2.27010101e-01f, -1.31199047e-01f, -1.79768473e-01f, 1.13089681e-01f, 1.96256135e-02f, -2.97467280e-02f, 1.18424378e-01f, 1.71389338e-02f, 1.96458027e-01f,
  -8.97321925e-02f, 2.14675702e-02f, -3.72595936e-02f, 3.31456251e-02f, -1.41102940e-01f, -1.27376944e-01f, 8.40426907e-02f, -1.02830090e-01f, -4.24742475e-02f, 3.67503226e-01f,
  9.49432328e-02f, -2.02082217e-01f, -1.54717444e-02f, 2.84765244e-01f, 6.76565850e-03f, -3.63794476e-01f, 2.96009868e-01f, 1.15098082e-01f, 6.27136678e-02f, 3.42491478e-01f,
  1.72994241e-01f, 2.38396183e-01f, 1.54716466e-02f, -2.42747385e-02f, 8.86970535e-02f, 4.08279710e-03f, 4.65003029e-02f, 1.23211466e-01f, -6.88336417e-02f, -7.77255837e-03f,
  2.21457034e-01f, 1.04713693e-01f, 9.33628122e-04f, -5.79964407e-02f, -1.69521552e-02f, -7.64316842e-02f, -1.18571423e-01f, 1.26588494e-01f, -1.73740871e-02f, -8.59797522e-02f,
  -3.33539769e-02f, 5.60473315e-02f, -1.25926230e-02f, 5.18425889e-02f, -1.02299377e-02f, 1.07987225e-01f, 1.47038242e-02f, -1.37467444e-01f, -9.63418558e-02f, -8.01102594e-02f,
  3.49964261e-01f, -5.71478665e-01f, 9.51769054e-02f, -2.46945880e-02f, -4.63775061e-02f, 6.33893088e-02f, 9.43721458e-02f, 2.89745945e-02f, -5.54095246e-02f, -1.35642793e-02f,
  -3.89810055e-02f, -3.01145650e-02f, 1.41065970e-01f, 1.35310695e-01f, -6.71080947e-02f, 1.22016540e-03f, 1.11038275e-01f, 7.29077831e-02f, -5.18232733e-02f, 2.98385978e-01f,
  2.65168190e-01f, 4.54313457e-02f, -5.52612394e-02f, 2.46659294e-01f, 8.70562270e-02f, -3.12721133e-01f, 1.08973876e-01f, 7.04842433e-02f, -6.68406561e-02f, 3.89534235e-01f,
  8.89689147e-01f, -3.67868841e-01f, -1.36695468e+00f, -3.89593095e-01f, -9.11317348e-01f, -4.27384853e-01f, -2.26308435e-01f, 2.26971447e-01f, -9.56253856e-02f, -6.23874426e-01f,
  2.15994697e-02f, 6.20664299e-01f, -1.23095334e-01f, 6.47913590e-02f, 4.61266041e-01f, -8.03903461e-01f, -9.30759072e-01f, -3.93793821e-01f, 3.81322682e-01f, 4.00608927e-01f,
  8.90276134e-02f, -1.12534001e-01f, 1.00333862e-01f, -1.57159775e-01f, -6.22294962e-01f, -3.21414351e-01f, -1.01054919e+00f, -5.12076497e-01f, -4.23987865e-01f, -9.43576217e-01f,
  -5.14567494e-01f, -2.56632328e-01f, 1.55367851e-01f, 2.51569808e-01f, -2.70314336e-01f, 7.75514916e-02f, 8.22113380e-02f, -3.06242615e-01f, 5.81450351e-02f, -4.15188372e-02f,
  -9.00659040e-02f, 1.92525685e-01f, 1.61937937e-01f, 1.20986141e-01f, -2.26238053e-02f, 1.86351523e-01f, -2.16991499e-01f, -1.45558655e-01f, -1.25332832e-01f, -6.34914711e-02f,
  -5.55605628e-03f, -1.94384813e-01f, -2.12558135e-01f, -9.84939784e-02f, -3.36768315e-03f, 3.76084372e-02f, -2.40381658e-01f, -4.69677113e-02f, -9.48775634e-02f, -3.68360311e-01f,
  -1.70058563e-01f, -5.44642173e-02f, 3.27096283e-02f, -8.67132992e-02f, 9.96818617e-02f, 9.36754455e-04f, 1.17637753e-01f, 2.24382225e-02f, 1.22123761e-02f, -5.72543070e-02f,
  -2.66118092e-03f, -1.76642358e-01f, 6.93302006e-02f, -7.32500628e-02f, -1.18050061e-01f, -1.64473671e-02f, 4.19165865e-02f, -6.54996186e-02f, -1.57135695e-01f, 4.19983976e-02f,
  1.21193297e-01f, 6.82997778e-02f, 4.82989401e-02f, 1.19398363e-01f, -6.95521086e-02f, -5.83838001e-02f, 1.63023546e-02f, 2.06864342e-01f, 1.61866337e-01f, 5.39831631e-02f,
  4.80084479e-01f, -3.57044674e-03f, -1.31105483e-01f, 4.13002312e-01f, -1.69660091e-01f, -1.47159204e-01f, -1.86445907e-01f, -6.49501383e-02f, 4.30222973e-02f, 1.82201356e-01f,
  6.48894310e-02f, 1.27109230e-01f, -1.69056818e-01f, -1.15438282e-01f, -8.99894815e-03f, -6.58235773e-02f, 6.89212093e-03f, 2.01016869e-02f, 9.76641774e-02f, -1.34628236e-01f,
  -7.53788650e-02f, 1.38723508e-01f, 5.45570850e-01f, 8.77567679e-02f, 1.89985424e-01f, 2.89708406e-01f, -1.45448044e-01f, 3.34321335e-02f, 2.59799033e-01f, 5.81411719e-02f,
  -2.71218419e-01f, 4.81769413e-01f, -1.63600162e-01f, 2.93121666e-01f, 2.70703197e-01f, 3.83445144e-01f, 3.91658694e-01f, 3.59455258e-01f, 3.11882675e-01f, 2.86044925e-01f,
  3.79309654e-01f, 4.45154071e-01f, 2.99562246e-01f, 2.41026357e-01f, 2.63924241e-01f, 3.44285280e-01f, 1.84274882e-01f, -2.04028204e-01f, -2.09112391e-01f, 1.17662817e-01f,
  3.27487230e-01f, 1.65187687e-01f, -1.83118820e-01f, 8.14358369e-02f, 5.04048727e-02f, 1.63148746e-01f, 2.18251497e-01f, 2.90850401e-01f, 2.06514567e-01f, 1.17909819e-01f,
  -1.53113101e-02f, 1.63042173e-02f, -8.40075873e-03f, -1.00072876e-01f, -3.86773534e-02f, -1.86905354e-01f, -1.80132911e-01f, -1.95859596e-01f, -2.11403802e-01f, -9.32218060e-02f,
  -9.27023143e-02f, -1.45133898e-01f, -7.06002582e-03f, -5.10708950e-02f, -1.45880446e-01f, -1.67389110e-01f, -3.20147462e-02f, 1.05141930e-01f, 4.96749505e-02f, 2.63637267e-02f,
  6.37205169e-02f, -4.38416637e-02f, -4.28480320e-02f, 2.96849888e-02f, 5.58867492e-02f, -1.42390449e-02f, -8.13025758e-02f, -5.02313897e-02f, -2.92061437e-02f, -1.96572363e-01f,
  -1.80984974e-01f, -1.16841784e-02f, 7.57081062e-02f, -9.20538604e-02f, -1.39325932e-01f, -2.66082466e-01f, -9.58059579e-02f, 1.00103028e-01f, 1.21971622e-01f, -1.13996513e-01f,
  1.08835753e-02f, -2.49898853e-03f, -8.79609957e-02f, -4.14688364e-02f, -2.09515095e-02f, -3.32549997e-02f, -1.29178718e-01f, -2.19530780e-02f, -1.18861146e-01f, -5.49246706e-02f,
  -6.45372272e-02f, -4.59874384e-02f, -1.46713123e-01f, -2.67334823e-02f, -4.55380753e-02f, -1.36207029e-01f, -1.47310987e-01f, 9.95056937e-04f, -8.63780677e-02f, 1.03345318e-02f,
  5.17725229e-01f, 2.04270244e-01f, -7.97844771e-03f, 9.62612852e-02f, -6.03832565e-02f, -1.48298547e-01f, 1.49854809e-01f, -2.25438923e-02f, -1.81318948e-03f, -5.57161830e-02f,
  -9.30964723e-02f, -2.10922554e-01f, 7.99890310e-02f, -8.98349285e-02f, -1.74118221e-01f, -1.05986178e-01f, 8.32723826e-02f, 1.50811076e-01f, 1.69913307e-01f, -5.12813218e-02f,
  -6.51449040e-02f, -1.09822243e-01f, -1.07261129e-02f, -4.21902724e-02f, 5.69375902e-02f, -8.98746625e-02f, -1.38824418e-01f, -1.51160955e-01f, -9.22965109e-02f, -1.68378726e-01f,
  -6.31562322e-02f, -2.72812575e-01f, 4.63090479e-01f, 1.59757718e-01f, -5.06102555e-02f, 1.56505287e-01f, -3.48782577e-02f, 1.05824985e-01f, 4.03934836e-01f, 2.49945030e-01f,
  -1.62328146e-02f, 2.94696331e-01f, 2.21334472e-01f, 1.88935176e-01f, 1.10215470e-01f, 1.64493904e-01f, 2.81169921e-01f, 3.12601417e-01f, 4.53529477e-01f, 2.25711569e-01f,
  1.18751384e-01f, -5.71439862e-02f, 3.31761055e-02f, 2.31453866e-01f, 2.52228320e-01f, 4.19559151e-01f, 2.27720007e-01f, -4.18620445e-02f, -1.56529937e-02f, 3.63312542e-01f,
  1.42574027e-01f, -3.66367549e-01f, 3.95053506e-01f, -1.77192241e-01f, -2.48038471e-01f, 9.68850628e-02f, 2.24965185e-01f, 9.93168950e-02f, -7.49654695e-02f, 9.01902616e-02f,
  -1.09678999e-01f, -1.14764929e-01f, -1.63614869e-01f, -7.69811571e-02f, -6.49905950e-02f, -4.33078296e-02f, -1.15610287e-01f, 4.52669002e-02f, -1.02147944e-01f, -4.00106385e-02f,
  -1.10925823e-01f, -1.59261636e-02f, 1.03484437e-01f, 3.90662104e-02f, -2.49391928e-01f, -7.38956034e-02f, -1.08220220e-01f, -2.69230977e-02f, -4.95784841e-02f, 1.16242945e-01f,
  2.11297974e-01f, 2.77593508e-02f, -1.51645631e-01f, 1.51997298e-01f, 6.82638958e-03f, 1.12209588e-01f, 1.64690033e-01f, -1.12038799e-01f, -3.48583758e-02f, -9.81795564e-02f,
  1.50849208e-01f, 7.46593997e-02f, 2.12049007e-01f, -8.55324231e-03f, 1.49384096e-01f, 1.47370417e-02f, 3.53812650e-02f, -6.13646135e-02f, -2.13457987e-01f, -1.91676617e-01f,
  -2.89431870e-01f, 6.51086718e-02f, 9.37790647e-02f, 3.53943706e-02f, -6.61787484e-03f, 7.50563443e-02f, 1.01205647e-01f, -5.36014745e-03f, 2.89187115e-02f, -6.59359396e-02f,
  8.42341334e-02f, -3.50124329e-01f, 8.32819939e-02f, -1.47767708e-01f, -2.19271317e-01f, -1.79804534e-01f, -1.24207757e-01f, -7.56112710e-02f, -1.86548397e-01f, 8.76568705e-02f,
  -1.74265891e-01f, 2.97935288e-02f, -2.08193481e-01f, -8.14172924e-02f, 2.33827785e-01f, 6.23436607e-02f, -3.06245714e-01f, 6.12487458e-03f, -8.43906403e-02f, -7.88221806e-02f,
  4.32513235e-03f, 1.92703053e-01f, 3.68692189e-01f, 2.04856977e-01f, 4.09525000e-02f, 2.58338511e-01f, 1.29284963e-01f, 1.07463881e-01f, 1.87100768e-02f, 2.93650568e-01f,
  1.18621945e+00f, -5.85206270e-01f, -3.66314739e-01f, 1.66947842e-01f, 7.53125967e-03f, 1.14117853e-01f, -1.89296752e-02f, 9.58420709e-02f, 1.36266351e-01f, 3.91659029e-02f,
  8.85107219e-02f, 2.19137743e-01f, 1.60620615e-01f, 4.72134724e-02f, 6.11998364e-02f, -3.16729903e-01f, -3.95584643e-01f, -3.46026942e-02f, 2.92419404e-01f, 6.08207472e-02f,
  -1.42197117e-01f, -6.85373321e-02f, 1.37175977e-01f, -1.43719181e-01f, -3.47575754e-01f, -4.16262671e-02f, -3.34404379e-01f, -3.28601509e-01f, -3.75648677e-01f, -6.78449869e-01f,
  -4.00408417e-01f, 1.11086525e-01f, 8.43435004e-02f, 1.04701646e-01f, 9.18755829e-02f, 3.30198705e-02f, 1.46262199e-01f, -4.90681864e-02f, 1.53074756e-01f, -6.28397763e-02f,
  -1.32650554e-01f, 1.44792506e-02f, 4.80192602e-02f, -7.91880041e-02f, -6.66607767e-02f, 7.42474850e-03f, 1.45930856e-01f, -8.66763443e-02f, 1.04435235e-02f, -5.84043674e-02f,
  -4.78483103e-02f, -2.53430400e-02f, -3.96086350e-02f, 2.32685819e-01f, 3.09672475e-01f, 1.47480100e-01f, 1.05245091e-01f, 3.92877273e-02f, 1.47652745e-01f, 1.37766898e-01f,
  2.09698528e-01f, 6.99679926e-02f, 8.32274333e-02f, 1.15862623e-01f, 2.22435191e-01f, 1.02891982e-01f, -9.19283554e-02f, 4.80813421e-02f, 1.66123182e-01f, 1.66312575e-01f,
  -9.15089026e-02f, 7.59837031e-02f, 9.51561332e-02f, 8.33394751e-02f, 9.87991970e-03f, -1.64913028e-01f, -2.50666142e-01f, -2.20936053e-02f, -1.00188535e-02f, -6.53597787e-02f,
  2.24683225e-01f, -1.43771455e-01f, -2.04375565e-01f, -1.83221683e-01f, -1.32806942e-01f, 1.63313262e-02f, -8.58434737e-02f, -2.21327078e-02f, -3.11284475e-02f, -1.96717799e-01f,
  -5.18742204e-01f, 2.63446242e-01f, 1.08402334e-01f, -1.05658323e-01f, 1.27138803e-02f, -5.06044514e-02f, 1.01584615e-02f, -2.30553344e-01f, -2.34667346e-01f, -1.28431827e-01f,
  1.12018436e-02f, -4.44884151e-02f, -1.26166552e-01f, 6.35068119e-02f, 5.07800467e-02f, 1.31196469e-01f, 1.48664325e-01f, 8.68987478e-03f, -1.20186731e-01f, -1.52456343e-01f,
  -1.04711115e-01f, 1.83039069e-01f, 2.80961871e-01f, 1.80471048e-01f, 1.91487402e-01f, 1.36698663e-01f, 7.17977285e-02f, 1.19584128e-01f, 1.22288562e-01f, 1.68867886e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  9.09291267e-01f, 1.27820635e+00f, 7.82176793e-01f, 5.43727994e-01f, 9.27991927e-01f, 7.82209635e-01f, 4.26250219e-01f, 9.11903381e-01f, 7.63905644e-01f, 9.91533399e-01f,
  -2.12281402e-02f, 4.10548896e-01f, 4.34292853e-01f, 7.66549170e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -2.31574878e-01f, 7.95240924e-02f, -6.11220896e-02f, -1.65920198e-01f, -4.78234112e-01f, -1.03898063e-01f, -3.87516111e-01f, -1.01786301e-01f, -1.14395404e-02f, -1.03997476e-01f,
  -6.38976574e-01f, -3.89994472e-01f, -2.71901548e-01f, 7.69017935e-02f, 7.96673521e-02f, -2.61684328e-01f, -1.69360131e-01f, 2.83510666e-02f, 7.02322349e-02f, 2.70670447e-02f,
  -5.14312349e-02f, -1.51998540e-02f, -1.77005813e-01f, -7.39437789e-02f, -1.34257466e-01f, 2.33297274e-01f, 3.19433749e-01f, -8.98765773e-03f, -8.14603791e-02f, 1.42435640e-01f,
  -1.64507508e-01f, -6.03852570e-02f, -9.88436863e-02f, 4.26355079e-02f, -1.26369074e-01f, -2.95379251e-01f, -3.29163253e-01f, 9.63436589e-02f, 1.14196818e-02f, -2.06858873e-01f,
  1.87966108e-01f, 5.21956861e-01f, 6.61459938e-02f, 2.42311016e-01f, -7.01405481e-02f, 8.42216704e-03f, 1.00135066e-01f, -3.59512299e-01f, 3.83816883e-02f, -3.45389470e-02f,
  5.41851699e-01f, 2.34970629e-01f, 3.19197983e-01f, -6.82487488e-01f, 7.82099292e-02f, -9.05366361e-01f, -7.46536255e-01f, -1.09780395e+00f, -6.55250311e-01f, -4.84475404e-01f,
  6.14752471e-01f, -8.40786934e-01f, -2.93692142e-01f, 6.85255826e-01f, -1.64971650e-01f, -4.66325954e-02f, -2.16569036e-01f, 1.36548474e-01f, 2.19677001e-01f, -5.87309450e-02f,
  3.76476459e-02f, -6.75656125e-02f, -1.90192506e-01f, 3.59195992e-02f, -2.50235230e-01f, 1.81675330e-01f, 1.60782740e-01f, -1.51421145e-01f, -5.66500425e-02f, -1.50084943e-01f,
  7.89410397e-02f, 1.41595438e-01f, -2.49150246e-01f, 1.58266518e-02f, -5.40060587e-02f, 2.11222202e-01f, -7.60138705e-02f, 1.16781279e-01f, -3.24663907e-01f, 1.54826239e-01f,
  4.61031228e-01f, -2.85336655e-02f, -2.37228662e-01f, 3.04083657e-02f, -5.87553382e-02f, -3.16394299e-01f, -4.45928186e-01f, 4.30049807e-01f, -4.01376337e-01f, -3.01401287e-01f,
  2.81247407e-01f, -7.00629223e-03f, 4.73791331e-01f, -2.95574795e-02f, 3.30072373e-01f, -3.01403970e-01f, 2.36770734e-01f, 3.11593682e-01f, -1.35739669e-01f, 1.21621206e-01f,
  -2.83815600e-02f, 1.52645990e-01f, -9.98418033e-02f, -7.71942548e-03f, 1.75460815e-01f, -2.60022312e-01f, -1.97465253e+00f, -2.63956785e-01f, 6.35748148e-01f, 1.34746492e-01f,
  4.66647834e-01f, 2.90247593e-02f, 7.38154501e-02f, -1.18492508e+00f, 9.19306219e-01f, -3.21184359e-02f, -4.87964749e-02f, 4.59344506e-01f, 1.50030583e-01f, -1.00434422e-01f,
  3.14182550e-01f, -4.51552086e-02f, 6.36021346e-02f, 2.56260574e-01f, 1.20318852e-01f, -8.01993087e-02f, 1.20397851e-01f, -1.41204536e-01f, 3.95610958e-01f, -6.28750697e-02f,
  1.06663533e-01f, 7.54774138e-02f, 7.49112293e-02f, 2.12830707e-01f, 1.83688581e-01f, -1.65280625e-01f, 1.05582714e-01f, 1.65783510e-01f, 1.65276542e-01f, 1.99007168e-01f,
  3.34450692e-01f, 2.05314592e-01f, 3.34336936e-01f, 2.43390873e-02f, 4.57921177e-01f, -7.00824335e-02f, -3.52804869e-01f, 2.90798008e-01f, -1.79314315e-01f, -1.67040884e-01f,
  -2.86820501e-01f, 6.56217709e-02f, -4.59343493e-01f, -3.91005501e-02f, -3.99081916e-01f, -3.20371777e-01f, 4.69824940e-01f, -8.11415493e-01f, -1.32331446e-01f, -3.94534320e-01f,
  -6.86860383e-01f, -1.62738442e-01f, 3.48398417e-01f, 1.67917460e-02f, 4.07883734e-01f, 2.27121621e-01f, -2.51481265e-01f, -3.34017664e-01f, -4.87804204e-01f, 3.24046075e-01f,
  -5.44893026e-01f, -4.88672480e-02f, 1.18088937e+00f, 2.37662241e-01f, -5.15691876e-01f, 1.23677015e-01f, -3.93648833e-01f, -1.16946232e+00f, -1.25234997e+00f, -8.58922601e-01f,
  6.28443882e-02f, 2.77680874e-01f, -4.29386795e-02f, -7.24861503e-01f, -3.85968350e-02f, -7.46376440e-03f, -3.31389159e-01f, 1.84731260e-02f, -2.61438370e-01f, 1.18659042e-01f,
  6.24558851e-02f, 1.56776249e-01f, -7.20371902e-02f, -2.00842232e-01f, 6.34757653e-02f, -3.28412682e-01f, -8.51040304e-01f, 3.04152071e-01f, -6.06930315e-01f, 1.82349294e-01f,
  1.00135468e-02f, -1.11020198e-02f, -1.98482543e-01f, 1.48370609e-01f, -2.02369452e-01f, -2.36856937e-01f, 8.19792271e-01f, 2.28928879e-01f, -2.87255675e-01f, 1.73575208e-01f,
  -1.38090044e-01f, -3.89604509e-01f, -3.32975030e-01f, -4.34702151e-02f, 2.09685713e-01f, -2.22518057e-01f, 3.81053202e-02f, 7.12858915e-01f, 4.30684865e-01f, -2.99099147e-01f,
  -1.23608455e-01f, 1.04928827e+00f, -9.52284038e-01f, 8.82279992e-01f, 1.74016356e-01f, -1.13550425e-01f, -4.86446083e-01f, -2.83194363e-01f, -3.83666018e-03f, 3.44333006e-04f,
  3.01864862e-01f, -3.05132627e-01f, -1.27463818e+00f, 9.18133020e-01f, -4.96139489e-02f, -1.70294261e+00f, 7.33164310e-01f, -4.44457904e-02f, -1.40912354e+00f, -1.29241931e+00f,
  -2.20819071e-01f, 3.53037000e-01f, -5.91470122e-01f, -6.86167955e-01f, -4.91053499e-02f, -5.24442136e-01f, 7.64939263e-02f, -2.28621945e-01f, -1.68426648e-01f, -4.75739121e-01f,
  1.57539234e-01f, -6.16990663e-02f, -1.04922473e-01f, -1.03163064e-01f, -2.70567536e-01f, -3.83693755e-01f, 3.33861401e-03f, 2.02618301e-01f, 3.64220813e-02f, -1.18786357e-01f,
  4.60385442e-01f, -1.71197969e-02f, 9.71373394e-02f, 8.44657980e-03f, -1.39794677e-01f, 2.43661582e-01f, -9.58848745e-02f, -1.50589570e-01f, -1.54022083e-01f, 7.02264905e-02f,
  1.87557582e-02f, 8.00102204e-02f, -7.49528632e-02f, -2.04056241e-02f, -1.36996135e-01f, -4.56235886e-01f, -4.52665314e-02f, -3.16956431e-01f, -1.17808774e-01f, 1.11817475e-02f,
  -1.32350206e-01f, -1.00085936e-01f, -1.07646197e-01f, -4.28694822e-02f, -2.70419121e-01f, -5.00045158e-02f, 3.16811651e-01f, -1.00817690e-02f, 3.63146335e-01f, -3.50836635e-01f,
  3.17611426e-01f, -1.06135346e-02f, -1.29742444e-01f, 3.27123344e-01f, 1.44780695e-01f, -7.85708427e-02f, -1.40431356e+00f, -7.20833480e-01f, 3.42484325e-01f, 5.02911448e-01f,
  -8.02924260e-02f, -4.64386046e-02f, -3.35004210e-01f, 5.85779436e-02f, -1.04977392e-01f, 7.15496242e-01f, -6.70337796e-01f, 5.31948879e-02f, 2.81154454e-01f, -3.75696808e-01f,
  1.64395913e-01f, 1.79583058e-01f, 3.50210853e-02f, -2.39031669e-02f, -4.80632707e-02f, -4.90688160e-02f, 1.52953118e-01f, 1.33112907e-01f, 1.78179905e-01f, 1.35760948e-01f,
  1.40508935e-01f, 4.37808968e-02f, 1.05731033e-01f, 3.96412283e-01f, -8.37770402e-02f, 4.66767848e-02f, -6.80760220e-02f, 2.26789881e-02f, 1.09418489e-01f, 5.45981377e-02f,
  1.12036251e-01f, -4.86693718e-02f, 2.49973223e-01f, 1.33856133e-01f, 1.12966076e-01f, 2.63689905e-01f, -6.06301486e-01f, 3.51655126e-01f, 2.31676027e-01f, -5.79033852e-01f,
  -5.85293397e-02f, 2.67256349e-01f, 4.05796692e-02f, -3.00005674e-01f, 3.40674996e-01f, -1.94887832e-01f, 5.10664463e-01f, -2.93182999e-01f, 3.04769486e-01f, -7.44165123e-01f,
  4.33894604e-01f, -4.40901875e-01f, 4.34127271e-01f, -5.85411251e-01f, -8.56519863e-02f, 2.86985129e-01f, -5.91188729e-01f, 3.18146288e-01f, -2.13804871e-01f, -1.35702807e-02f,
  7.97442317e-01f, -1.93897283e+00f, 1.77354470e-01f, -6.69310629e-01f, -9.16472316e-01f, -8.27977359e-01f, -5.75151324e-01f, -2.95246560e-02f, 2.71675557e-01f, 3.40482235e-01f,
  4.12625104e-01f, 1.24974903e-02f, 2.54087925e-01f, 3.10886465e-02f, -3.03648580e-02f, 1.57115474e-01f, -4.44455475e-01f, 5.26170768e-02f, 2.01386675e-01f, -3.10776830e-01f,
  1.70366749e-01f, 1.06191196e-01f, -8.93221051e-02f, 2.36930266e-01f, 3.97097468e-01f, -5.16856730e-01f, -3.69958505e-02f, -1.11034531e-02f, -6.52664721e-01f, 1.93878725e-01f,
  -4.68987882e-01f, -4.49898750e-01f, 2.83973515e-01f, -2.33534783e-01f, 4.25865501e-02f, 1.60242200e-01f, -2.51404971e-01f, -2.56147474e-01f, 3.11186701e-01f, -3.34883243e-01f,
  3.25542390e-01f, -1.37837335e-01f, 3.51765335e-01f, 4.79123116e-01f, 4.80356306e-01f, 4.77698714e-01f, -2.52675802e-01f, -8.68454754e-01f, 2.52163231e-01f, 1.89042583e-01f,
  -7.90465951e-01f, 8.76614451e-01f, 4.41201955e-01f, -1.09294593e+00f, -1.02788433e-01f, -1.04827070e+00f, -4.53490883e-01f, 4.56460238e-01f, 3.33400160e-01f, -1.92855731e-01f,
  1.47677526e-01f, -4.74394083e-01f, -4.66642946e-01f, 4.92738634e-01f, -8.71960938e-01f, -1.17772889e+00f, -1.47584879e+00f, 4.63714391e-01f, -1.07188356e+00f, -6.78007960e-01f,
  3.25626701e-01f, 3.78002346e-01f, 1.61994755e-01f, -7.72933841e-01f, -5.44846714e-01f, 1.78546086e-01f, -1.68305598e-02f, -3.99158448e-01f, -1.54452294e-01f, 2.31425446e-02f,
  -2.23802418e-01f, -2.11566180e-01f, 3.05931240e-01f, 4.20505218e-02f, 1.21997297e-01f, -3.08170944e-01f, 1.66901484e-01f, -2.77273118e-01f, -7.13019311e-01f, 2.03888252e-01f,
  1.25815421e-01f, -2.40281314e-01f, 1.19795129e-01f, -3.15887332e-01f, -1.28567204e-01f, 1.02384165e-01f, -1.06211133e-01f, -4.52959910e-02f, -2.94346988e-01f, 1.22882977e-01f,
  -2.20209658e-01f, -3.20448607e-01f, -8.86202753e-02f, 4.69860077e-01f, -5.58030605e-01f, 1.35355204e-01f, 1.95946485e-01f, -1.66468933e-01f, -3.24202567e-01f, -7.00738339e-04f,
  2.70806938e-01f, 1.28067032e-01f, 2.18085185e-01f, 5.05822860e-02f, 6.42807066e-01f, -4.66007531e-01f, -2.82445788e-01f, 3.40911508e-01f, -2.93163836e-01f, 5.52436888e-01f,
  -3.33843231e-01f, -5.34789741e-01f, 2.82206178e-01f, -1.06960103e-01f, 4.14828956e-02f, -1.32735908e-01f, -1.95074052e-01f, 2.86641449e-01f, -6.31724596e-01f, -1.35507882e-01f,
  1.08762157e+00f, -5.08116126e-01f, -7.47143209e-01f, 4.29109275e-01f, -3.58446002e-01f, -2.19248876e-01f, -6.55433714e-01f, -6.82066202e-01f, -9.15900111e-01f, 3.28744680e-01f,
  -1.10050105e-02f, -9.40311730e-01f, 1.31217241e-01f, 2.34577551e-01f, -8.71317238e-02f, 1.94029748e-01f, -5.01026213e-02f, 1.66744009e-01f, 3.80282812e-02f, -8.78866166e-02f,
  3.28639507e-01f, 2.29405407e-02f, 1.10600911e-01f, 1.51964769e-01f, 1.45644322e-03f, -3.47237028e-02f, -1.08120903e-01f, 2.42913589e-01f, -1.12407230e-01f, 2.07416058e-01f,
  1.83387756e-01f, 8.61008540e-02f, 1.51696935e-01f, -2.71245360e-01f, -2.58457124e-01f, -8.00058544e-02f, -1.72219090e-02f, -4.60273087e-01f, 1.81045309e-01f, 4.60690200e-01f,
  6.77443892e-02f, 5.53576052e-01f, -4.38994505e-02f, 5.03055036e-01f, 3.41576397e-01f, 5.79159409e-02f, 4.19107974e-01f, 3.63587469e-01f, 3.21749181e-01f, 4.51497316e-01f,
  3.70889038e-01f, 7.63669074e-01f, 1.31228622e-02f, 7.84241140e-01f, -1.13896556e-01f, -6.66050017e-01f, -9.57656056e-02f, 1.78677797e-01f, 5.99406540e-01f, -4.98744905e-01f,
  3.48471165e-01f, 2.40052313e-01f, 1.03515851e+00f, 5.65410079e-03f, -9.69587982e-01f, -8.72391284e-01f, -6.44569457e-01f, 4.36364621e-01f, -7.60797143e-01f, 4.66658175e-01f,
  -3.99681553e-03f, -1.18987167e+00f, -5.91488719e-01f, -8.45616162e-01f, 1.66970104e-01f, -3.30330223e-01f, 4.37638611e-01f, -1.02084897e-01f, 1.16146117e-01f, -1.19083546e-01f,
  -3.62223148e-01f, 1.07800886e-01f, 2.62276560e-01f, 3.05816889e-01f, 2.17731252e-01f, 3.15084249e-01f, 1.16588555e-01f, -2.74258971e-01f, 1.24979325e-01f, 8.63003358e-02f,
  5.14211170e-02f, -1.20790442e-02f, 3.03036034e-01f, 1.95014149e-01f, 4.35033031e-02f, -1.56405613e-01f, -2.02026606e-01f, -2.85230041e-01f, 2.38894343e-01f, 1.78737491e-01f,
  3.72941792e-01f, 1.66639224e-01f, 5.88969588e-01f, -2.75071561e-01f, -1.87766347e-02f, 3.60574499e-02f, -4.16599214e-01f, 1.25653103e-01f, -3.50634009e-02f, 5.74404418e-01f,
  -5.81848741e-01f, 2.97608882e-01f, -5.84990799e-01f, -4.57516432e-01f, -2.66519874e-01f, -6.10180125e-02f, 3.01377568e-02f, -6.78200364e-01f, -3.03177655e-01f, 3.24559510e-01f,
  1.87019378e-01f, -1.92512542e-01f, -3.90667945e-01f, 4.57574219e-01f, 1.41757533e-01f, -2.59947836e-01f, -1.00188887e+00f, -1.16760230e+00f, 8.74542654e-01f, 8.54370654e-01f,
  -1.16259515e+00f, -8.49550739e-02f, 4.95862961e-01f, 1.18360989e-01f, -1.26614058e+00f, -6.74231112e-01f, -3.53959113e-01f, 1.99730381e-01f, -2.60951728e-01f, -7.65993476e-01f,
  1.26599208e-01f, 1.48869157e-01f, 1.19161038e-02f, 1.28201902e-01f, 3.54468703e-01f, 1.07919276e-01f, 3.01080048e-01f, 2.47353632e-02f, -4.55607861e-01f, 7.83393085e-02f,
  2.06785187e-01f, -6.43762499e-02f, 9.39703286e-02f, 2.74432421e-01f, -7.14973779e-03f, 1.24640077e-01f, 3.15342188e-01f, -6.45782113e-01f, 2.63261586e-01f, -2.72666454e-01f,
  -2.46308237e-01f, 5.26074991e-02f, 2.13808253e-01f, 2.93540001e-01f, -5.75224578e-01f, 3.27891648e-01f, -6.98893815e-02f, 1.43367007e-01f, 3.26957464e-01f, 5.86986721e-01f,
  1.16399257e-02f, -3.33426714e-01f, 3.64662141e-01f, 5.84795952e-01f, -5.10818139e-02f, -2.17111990e-01f, 4.94067311e-01f, 5.01199722e-01f, 5.52876629e-02f, 6.59438133e-01f,
  -5.02770424e-01f, -3.47867072e-01f, 4.36027676e-01f, -6.12135641e-02f, -3.47962707e-01f, 5.55658698e-01f, 1.10948518e-01f, 2.80900180e-01f, -9.76924896e-02f, -3.07933331e-01f,
  6.68835547e-03f, 1.15449715e+00f, -3.31452787e-01f, -4.62167144e-01f, -1.31071055e+00f, -5.85747480e-01f, -5.62233090e-01f, 2.41129801e-01f, -7.57364810e-01f, 1.61600128e-01f,
  -2.26994395e-01f, -5.73861957e-01f, 3.90066266e-01f, -1.28236294e+00f, -2.50240088e-01f, 1.48359388e-01f, 2.55061418e-01f, 1.10960677e-01f, 2.00515792e-01f, 3.78821529e-02f,
  -3.02869588e-01f, 4.13465872e-02f, -3.86254936e-01f, -2.93556392e-01f, 1.05587162e-01f, 4.16493237e-01f, -5.31150885e-02f, -4.76464592e-02f, 4.11190182e-01f, -1.00347973e-01f,
  5.63163102e-01f, 4.70714480e-01f, 5.48630133e-02f, 1.38589293e-01f, 2.18150288e-01f, 3.06767225e-02f, -1.61873121e-02f, 2.18559116e-01f, -7.97959089e-01f, -6.51090384e-01f,
  -3.66296619e-01f, -3.45093310e-01f, -3.84852558e-01f, -4.29692231e-02f, 2.96961606e-01f, 3.35329086e-01f, -4.06244367e-01f, -1.87906444e-01f, 3.61467361e-01f, 1.51976660e-01f,
  2.64006525e-01f, 3.82494330e-01f, -3.00656766e-01f, 1.06524539e+00f, -3.48963618e-01f, 7.02244639e-01f, 3.11414413e-02f, 4.51260298e-01f, -1.58353984e-01f, -2.48698935e-01f,
  -4.92021292e-01f, -3.12402174e-02f, 2.80442297e-01f, -1.68736860e-01f, -5.16381919e-01f, 7.08637908e-02f, -1.41677296e+00f, 6.37261093e-01f, 2.87917703e-02f, -2.90816218e-01f,
  7.71619007e-02f, -8.57587159e-01f, 1.07745004e+00f, -2.12082550e-01f, -8.40311766e-01f, 2.87013948e-01f, -1.10678661e+00f, -3.88541877e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.76226035e-01f, -5.80368400e-01f, 6.82977557e-01f, -2.40460053e-01f, -1.30443156e-01f, -2.97737238e-03f, 6.45506024e-01f, 4.95475903e-02f, -8.08791444e-02f, 2.89741784e-01f,
  -2.65016437e-01f, 2.39631254e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    