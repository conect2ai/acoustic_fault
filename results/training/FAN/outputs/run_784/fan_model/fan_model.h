/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.62417328e-01f, 3.84880841e-01f, 3.16730052e-01f, -2.30604067e-01f, 5.21469004e-02f, 1.86478823e-01f, 5.70988774e-01f, 8.46773461e-02f, -1.70069456e-01f, 1.66596919e-01f,
  -1.66223288e-01f, -4.75424767e-01f, -3.67480576e-01f, -2.45174825e-01f, -4.33441587e-02f, 4.70035791e-01f, 3.76254648e-01f, -1.23771824e-01f, -8.58574212e-02f, 7.76918307e-02f,
  4.52032834e-02f, 8.21794420e-02f, -2.92701274e-01f, -1.50084980e-02f, 9.70620438e-02f, -1.88810602e-01f, 9.76176932e-02f, -5.41669130e-02f, -2.03663446e-02f, 2.87692904e-01f,
  -6.05232567e-02f, 9.40472707e-02f, -5.10691591e-02f, -1.26872867e-01f, -8.79942477e-02f, -1.89730674e-02f, 1.53606003e-02f, -1.98363159e-02f, -9.89266261e-02f, 6.26090318e-02f,
  -1.03896320e-01f, -4.78822738e-02f, -3.69768701e-02f, 2.37427857e-02f, 4.25384939e-02f, 9.00048064e-04f, -4.43406664e-02f, 1.00132292e-02f, 3.81730758e-02f, 2.43855100e-02f,
  -1.97744314e-02f, -2.00190339e-02f, 9.83075798e-02f, 1.03092201e-01f, 4.21259832e-03f, -9.11277011e-02f, -1.78796221e-02f, -1.24174193e-01f, -1.28772929e-01f, 3.22793308e-03f,
  2.05619987e-02f, -2.76600532e-02f, -1.48552535e-02f, 4.23508361e-02f, -6.18274398e-02f, 2.06103995e-02f, 8.30047727e-02f, -6.78229704e-03f, 6.56355685e-03f, 1.53455101e-02f,
  2.93987561e-02f, -7.33504910e-03f, 2.67062448e-02f, 2.29180772e-02f, -2.97556613e-02f, 3.62594947e-02f, 6.03762195e-02f, -1.36392964e-02f, -7.71244392e-02f, 1.49096912e-02f,
  -4.71870080e-02f, 1.70257781e-02f, 2.36750022e-02f, 7.18678162e-03f, 3.83840054e-02f, -1.04590990e-02f, -3.80177051e-02f, -4.81285527e-02f, -6.22889921e-02f, -2.06504390e-02f,
  -1.01914100e-01f, -9.93327275e-02f, 3.17820944e-02f, -2.66662915e-03f, 7.40318745e-02f, -4.34537306e-02f, -3.06411944e-02f, -2.00502761e-02f, -1.05824610e-02f, 2.45247688e-02f,
  4.60665813e-03f, -3.61256190e-02f, 3.98355164e-02f, 2.22409051e-02f, 1.85913835e-02f, 7.86001701e-03f, -6.67418772e-03f, -6.18656874e-02f, -4.56602275e-02f, -3.94020192e-02f,
  -3.04842531e-03f, 5.34756184e-02f, -1.84866302e-02f, -4.77926806e-02f, -1.25851119e-02f, 2.74677221e-02f, 1.19979545e-01f, 4.24624719e-02f, 1.18657108e-03f, 2.12643668e-01f,
  -1.68439716e-01f, -3.97365838e-01f, 3.77861798e-01f, -1.43837288e-01f, -5.03287613e-02f, -4.66777720e-02f, -2.06635281e-01f, -1.74444988e-01f, -9.00620893e-02f, -1.48079649e-01f,
  -8.40647221e-02f, 2.57005453e-01f, 1.45535886e-01f, 2.29051396e-01f, 5.11779785e-02f, -5.86626232e-02f, 1.65053293e-01f, 3.35869998e-01f, 3.25392485e-01f, 9.45737511e-02f,
  -9.88411233e-02f, -8.43894109e-02f, -3.26252282e-02f, -1.09476313e-01f, -1.20912664e-01f, 2.47754037e-01f, -7.46787116e-02f, 2.94081327e-02f, -5.73084317e-02f, -6.89992085e-02f,
  2.49839678e-01f, -1.81952149e-01f, 2.48157978e-01f, 4.69405986e-02f, 4.37985212e-02f, 1.03938527e-01f, 9.74296685e-03f, 7.18758702e-02f, 6.80913031e-02f, 6.69827387e-02f,
  1.04873449e-01f, 1.25352833e-02f, -3.77874635e-02f, 4.64153774e-02f, -7.50845857e-03f, -3.82215492e-02f, -4.80543487e-02f, 7.13430196e-02f, 1.87817857e-01f, 3.46017405e-02f,
  -6.08762875e-02f, -1.78005509e-02f, -3.73295066e-03f, -5.47578894e-02f, 3.60977761e-02f, 1.58688411e-01f, 1.11618191e-02f, -4.20926809e-02f, 4.65684338e-03f, -1.72041371e-01f,
  -1.06988791e-02f, 1.78616084e-02f, 7.40816891e-02f, -7.66658336e-02f, -3.16268913e-02f, 5.90779297e-02f, 3.07026431e-02f, -4.39109653e-02f, -9.05695483e-02f, -4.06390950e-02f,
  6.21715654e-03f, -4.75133844e-02f, 6.56402186e-02f, -1.19376024e-02f, 2.34908797e-02f, 1.49257053e-02f, 5.00999875e-02f, 1.31037170e-02f, -2.13494830e-04f, -3.67648862e-02f,
  -3.08788121e-02f, 9.96526331e-02f, 3.13717946e-02f, -1.89615954e-02f, 1.97562482e-02f, 7.95912817e-02f, -1.28205251e-02f, -4.31667157e-02f, 2.39860658e-02f, -5.33156618e-02f,
  -2.13794038e-02f, 1.51071325e-01f, 3.11181415e-02f, -5.79452142e-03f, 9.50134397e-02f, 1.07586225e-02f, 1.56747364e-02f, -1.64450184e-02f, 4.29953858e-02f, 2.99568754e-02f,
  5.00682816e-02f, 3.81383263e-02f, 5.14854910e-03f, 1.52224619e-02f, -1.14610484e-02f, 1.92721561e-02f, -2.25026999e-02f, 1.25627264e-01f, 6.98003322e-02f, -1.85297243e-02f,
  2.94622630e-02f, 7.47704953e-02f, 1.44669145e-01f, 1.27820209e-01f, 7.49410316e-02f, 1.35974273e-01f, 1.33823650e-02f, 1.13124922e-01f, 1.77390218e-01f, -1.11757115e-01f,
  2.30828464e-01f, 2.59858161e-01f, -2.19824538e-02f, 2.65694886e-01f, -1.15225084e-01f, -2.90992349e-01f, -2.52041399e-01f, -7.22912550e-02f, 8.06545094e-02f, 1.80138588e-01f,
  -7.07036490e-03f, 2.59118062e-02f, 9.01833773e-02f, -4.56502661e-02f, -6.91974163e-02f, 9.32322219e-02f, 7.76717067e-02f, -5.81277609e-02f, -3.36089849e-01f, -2.56029248e-01f,
  -7.11492747e-02f, 6.49509281e-02f, 8.44489038e-02f, 3.35098095e-02f, 1.77791506e-01f, -7.49396905e-02f, 2.58516282e-01f, 1.31567359e-01f, -1.54473847e-02f, 3.59081864e-01f,
  2.56019592e-01f, 1.39418885e-01f, -1.20327525e-01f, -1.48058916e-02f, 2.13436335e-02f, 7.56602660e-02f, -1.21227307e-02f, 1.51188925e-01f, -1.22617548e-02f, 1.22995205e-01f,
  5.28170541e-02f, 9.60298907e-03f, 5.37793152e-03f, 6.01470917e-02f, 8.94614831e-02f, -4.33689021e-02f, 1.14993237e-01f, 5.84242381e-02f, 1.06104083e-01f, 1.19259343e-01f,
  6.60261419e-03f, -4.26212363e-02f, 1.07064173e-02f, -7.50815496e-02f, 5.35250595e-03f, -1.30101472e-01f, -6.80652782e-02f, -9.63356420e-02f, -4.53784168e-02f, 3.23425502e-01f,
  -6.98939189e-02f, 4.86575365e-02f, -6.84049129e-02f, 2.64316779e-02f, -5.17477281e-02f, 9.67336539e-03f, 7.24494681e-02f, 1.85099430e-02f, -5.56492209e-02f, 4.64890711e-02f,
  -7.47495219e-02f, 4.41245027e-02f, -1.44713325e-02f, 4.36805971e-02f, 4.75068316e-02f, -3.58140748e-03f, -4.24884595e-02f, -1.54116098e-03f, -6.65490702e-03f, 3.82737182e-02f,
  -3.49975540e-03f, -2.11619921e-02f, 5.58418892e-02f, -2.02572215e-02f, -6.85373545e-02f, -2.66033038e-02f, -5.83731905e-02f, -4.65095565e-02f, 6.42469898e-02f, 2.01705452e-02f,
  1.26625687e-01f, -3.08557600e-01f, 2.57387072e-01f, -4.21704389e-02f, 4.98446673e-02f, 1.34552680e-02f, 8.21998790e-02f, -7.77811110e-02f, 7.07288552e-03f, 1.12951931e-03f,
  -9.20921341e-02f, -4.59205918e-02f, 1.19179733e-01f, 7.76834029e-04f, -3.82676162e-02f, -5.49139194e-02f, 1.48486458e-02f, -7.67390728e-02f, -7.61112869e-02f, 2.30464078e-02f,
  2.55178590e-03f, -4.44722250e-02f, -7.55767804e-03f, 2.84024496e-02f, 4.27345671e-02f, -1.25053078e-01f, 5.15622310e-02f, -3.14031616e-02f, -2.01601535e-01f, 2.00435311e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.08656776e-01f, -4.14003432e-01f, -4.13758397e-01f, -2.45812207e-01f, -4.64186333e-02f, -1.67058464e-02f, -1.28479198e-01f, 1.14801697e-01f, 4.61550429e-02f, -2.59031504e-01f,
  -5.63339330e-02f, -2.21224874e-02f, -1.43629968e-01f, 5.48689477e-02f, 8.07156637e-02f, -1.47827521e-01f, -1.71417356e-01f, -2.54563615e-02f, 2.04767972e-01f, 1.89661160e-01f,
  6.43293038e-02f, -1.71290144e-01f, -2.61165723e-02f, 1.07434519e-01f, -1.80987537e-01f, -2.60325111e-02f, -2.86735058e-01f, -7.54553676e-02f, -1.99099649e-02f, -3.95051777e-01f,
  -2.39678323e-01f, 5.48232906e-03f, 2.24723533e-01f, 8.62481911e-03f, -1.20566286e-01f, 2.74024680e-02f, -1.17673690e-03f, -7.51134427e-03f, -1.68882143e-02f, -5.66226877e-02f,
  -7.62381330e-02f, 2.54447311e-02f, -8.86666309e-03f, -1.07994480e-02f, -1.06821498e-02f, -1.79717373e-02f, -5.56054153e-02f, -4.46924083e-02f, 8.05227384e-02f, -2.83232494e-03f,
  -9.27463844e-02f, -9.15000737e-02f, -8.05995464e-02f, -2.94482056e-02f, 1.48425475e-01f, -1.20704241e-01f, -2.80173328e-02f, 1.10161118e-02f, 2.83739027e-02f, -1.49913043e-01f,
  -1.66015960e-02f, -1.40645923e-02f, 3.29631269e-02f, -2.59984620e-02f, 3.16885882e-03f, -5.15919831e-03f, -1.91105213e-02f, 5.68489470e-02f, 3.79624963e-02f, -1.30124846e-02f,
  -1.31636381e-03f, -1.18630351e-02f, -1.90938152e-02f, -1.26675248e-01f, 6.57778755e-02f, -1.44657254e-01f, 2.99632717e-02f, -8.33820403e-02f, 2.97713596e-02f, 2.25723684e-02f,
  3.28132026e-02f, 3.60520184e-02f, -7.62243792e-02f, 4.26209047e-02f, -9.41922516e-02f, 2.89365463e-03f, -3.98861095e-02f, 1.22727588e-01f, 2.72984523e-02f, 6.28500730e-02f,
  -1.62913144e-01f, 1.27426222e-01f, -6.05611019e-02f, -2.10905517e-03f, -9.10559967e-02f, -3.74042019e-02f, -8.39628726e-02f, 7.00274333e-02f, 4.95172255e-02f, -2.76807100e-02f,
  2.82685664e-02f, -6.79304376e-02f, -8.38858187e-02f, 6.73938170e-02f, 4.25736569e-02f, 3.78313139e-02f, 5.19211055e-04f, -9.01982784e-02f, 6.74525052e-02f, -5.98636940e-02f,
  -1.20434068e-01f, -1.38055578e-01f, -1.55779585e-01f, -6.86768368e-02f, -9.92100909e-02f, -1.01876989e-01f, -1.21590383e-01f, -1.22909054e-01f, -4.81787771e-02f, -2.76306510e-01f,
  -2.95135617e-01f, -1.22666791e-01f, 1.94414735e-01f, -2.05464989e-01f, -1.57517791e-01f, -3.65016535e-02f, 1.71369538e-02f, 2.30872445e-02f, -1.47529393e-01f, -7.32291909e-03f,
  3.97935472e-02f, 8.97020325e-02f, 9.24600102e-03f, 7.27336630e-02f, 5.59021719e-02f, 1.44295335e-01f, 1.16057880e-01f, 6.40049204e-02f, 2.17065588e-01f, -8.02333280e-02f,
  4.24208455e-02f, -2.82963570e-02f, 1.04165580e-02f, -1.29797041e-01f, -8.83926153e-02f, 4.65701148e-02f, -4.64838929e-04f, -8.17674994e-02f, -6.62526935e-02f, -5.20158596e-02f,
  3.68310273e-01f, -3.34566325e-01f, 3.35519724e-02f, -7.32657909e-02f, -5.51178642e-02f, 3.17491367e-02f, 7.47481501e-03f, -3.51919942e-02f, -7.70960823e-02f, 4.19921055e-02f,
  -3.00143920e-02f, -1.05026975e-01f, -1.81515496e-02f, -6.68300316e-02f, -2.45647803e-02f, 5.00739040e-03f, -6.29876927e-02f, -5.34265861e-02f, 2.61589829e-02f, -8.79424997e-03f,
  -1.86467886e-01f, -6.40026107e-02f, 5.81394248e-02f, -5.16152475e-03f, -1.46351427e-01f, -1.15047567e-01f, -9.56131145e-02f, -9.43743065e-02f, -3.40129435e-02f, 5.67623191e-02f,
  -6.34733215e-02f, 1.63729750e-02f, 4.32299748e-02f, -7.96866044e-02f, 6.05269708e-02f, 4.52031270e-02f, 1.05588883e-01f, 4.39823084e-02f, 4.43303166e-03f, 1.51196256e-01f,
  -3.94270383e-02f, -4.35232073e-02f, 2.66196709e-02f, 5.36939949e-02f, -1.05071757e-02f, -3.43641229e-02f, 3.11644878e-02f, -2.30093524e-02f, 7.39995064e-03f, -1.31582648e-01f,
  -2.62490800e-03f, 2.61782063e-03f, 4.07910720e-03f, 6.01637289e-02f, -4.61441688e-02f, -2.80203559e-02f, -7.36761540e-02f, -1.41642332e-01f, -1.12076020e-02f, 6.23669587e-02f,
  4.00398254e-01f, -2.23196760e-01f, 1.55635878e-01f, -5.46224713e-02f, -6.20610937e-02f, -9.58310887e-02f, -8.25872924e-03f, 3.98192443e-02f, 9.07202438e-02f, 1.03257606e-02f,
  -1.30797774e-01f, 1.28000481e-02f, -1.20730316e-02f, 1.25173025e-03f, 5.87896295e-02f, 3.32261026e-02f, -7.35043883e-02f, 1.28855184e-01f, -4.84995637e-03f, -5.48179634e-02f,
  -6.25761226e-02f, 1.77769363e-01f, 3.05992007e-01f, 2.62741476e-01f, -5.01456968e-02f, 1.42540589e-01f, 2.82075822e-01f, 1.59026176e-01f, 1.49420232e-01f, 3.47356498e-01f,
  2.32492134e-01f, -3.53954196e-01f, 2.58578777e-01f, -2.36177370e-01f, -4.20005411e-01f, -3.82812262e-01f, -3.83779407e-01f, -1.26001313e-01f, -7.44166598e-02f, -2.51806408e-01f,
  -3.31616104e-01f, -1.33852959e-01f, 8.45360681e-02f, 1.37392014e-01f, 2.51033604e-01f, 4.53366823e-02f, 1.58009306e-01f, 5.84060490e-01f, 4.14334238e-01f, 7.96211362e-02f,
  -1.99014783e-01f, 1.55950740e-01f, 4.67406809e-01f, 2.13244364e-01f, -9.56327319e-02f, -2.79256441e-02f, 7.33393282e-02f, -1.03646107e-01f, -2.60437615e-02f, 1.71974048e-01f,
  -1.66943699e-01f, -1.21171787e-01f, 4.08398509e-02f, -5.43766357e-02f, -1.38016567e-01f, 5.03269881e-02f, -6.93012848e-02f, 5.54582328e-02f, -3.06041390e-02f, 5.34133315e-02f,
  -1.47280738e-01f, -3.90425846e-02f, -8.27100649e-02f, -1.01949181e-02f, -3.99370976e-02f, -2.67785359e-02f, 1.86329573e-01f, 3.14214826e-01f, 9.06993076e-02f, -3.74629758e-02f,
  -2.49814957e-01f, -1.73157305e-01f, -4.50600199e-02f, -1.07684415e-02f, 6.68993741e-02f, 7.35221729e-02f, -1.09357312e-02f, 7.15805665e-02f, 1.01474868e-02f, 3.93117182e-02f,
  8.17617867e-03f, -1.04626771e-02f, -2.92939562e-02f, 3.27219404e-02f, -3.51858214e-02f, -1.80549137e-02f, 3.78546044e-02f, -8.93677101e-02f, 1.09526785e-02f, -8.76067299e-03f,
  4.76347357e-02f, 2.18514875e-02f, 3.08756121e-02f, 4.17530946e-02f, -5.32481857e-02f, 4.37509827e-02f, -2.06218269e-02f, 1.93979647e-02f, -9.65272635e-03f, 4.44635302e-02f,
  2.27731653e-03f, -8.64109490e-04f, -3.28417756e-02f, 9.06800702e-02f, 3.51742283e-02f, -2.86835730e-02f, 1.91006977e-02f, -8.30386132e-02f, -5.65058663e-02f, -1.00651151e-02f,
  -2.32232317e-01f, 6.87277466e-02f, -3.98174813e-03f, 1.47024930e-01f, -5.46731576e-02f, 4.18394282e-02f, -9.07904133e-02f, -2.12679915e-02f, -2.49439590e-02f, -2.43948661e-02f,
  -8.69958103e-02f, 9.23771784e-02f, -3.09700556e-02f, 8.48677233e-02f, -5.31393364e-02f, -7.16381967e-02f, -1.30961761e-01f, -5.29498197e-02f, -4.80251908e-02f, -5.85793629e-02f,
  2.12787148e-02f, -8.79101977e-02f, -1.11342706e-01f, -1.34353712e-01f, -1.14572912e-01f, -1.26355425e-01f, -1.13671117e-01f, -1.28230929e-01f, -6.10442013e-02f, -1.88284308e-01f,
  6.83289230e-01f, -5.59040308e-01f, -7.51694888e-02f, 3.18294615e-01f, 2.28867799e-01f, 2.10639372e-01f, 7.04236841e-03f, 1.68656439e-01f, 2.31722742e-01f, 7.81855080e-03f,
  -2.90383473e-02f, 1.67728916e-01f, 8.12385827e-02f, 2.61204746e-02f, 1.12054206e-01f, -4.03844453e-02f, 6.51346818e-02f, 3.83139737e-02f, 1.71237946e-01f, 9.63593721e-02f,
  4.69357632e-02f, -1.55517966e-01f, 1.73987541e-02f, -1.06066823e-01f, -7.77253285e-02f, 1.29303811e-02f, -2.19270885e-01f, -2.57423997e-01f, -1.33376777e-01f, -1.89833656e-01f,
  -2.27206156e-01f, -3.16151381e-01f, 1.97543263e-01f, -6.81607006e-03f, -1.50214106e-01f, -3.84056941e-02f, 1.16285319e-02f, -1.18927568e-01f, -2.27187742e-02f, -9.24511999e-02f,
  -9.52418074e-02f, -1.49172798e-01f, 2.32348852e-02f, -8.70527104e-02f, -3.43564600e-02f, 5.66826086e-04f, -8.77589062e-02f, -1.16011776e-01f, 6.48524286e-03f, -1.55659139e-01f,
  -1.63506508e-01f, -1.38193890e-01f, 3.10531911e-03f, -1.21723125e-02f, -2.07084026e-02f, 1.15009308e-01f, -2.61781663e-01f, -4.01331931e-02f, 8.61333981e-02f, -2.20407452e-02f,
  1.70702673e-03f, 3.84615958e-02f, 1.14413481e-02f, 6.12197025e-03f, 7.22406134e-02f, 1.17888980e-01f, 2.91871578e-02f, -2.06846111e-02f, 4.72733080e-02f, -4.08332376e-03f,
  8.42761621e-03f, 4.42247838e-02f, -1.47856092e-02f, 1.12445958e-01f, -4.53768373e-02f, 9.40940250e-03f, 3.07147168e-02f, -1.02196418e-01f, -6.40051439e-02f, 1.31930038e-01f,
  7.96534941e-02f, -6.31866558e-03f, -9.07768384e-02f, -8.01286176e-02f, -6.17873706e-02f, -5.80104254e-02f, 2.06596442e-02f, -1.79754943e-02f, -4.79974672e-02f, 5.75787872e-02f,
  3.15280855e-02f, 1.87186018e-01f, 2.54736990e-01f, -7.17624724e-02f, 4.06154767e-02f, -9.26792920e-02f, 2.26255562e-02f, -8.00377950e-02f, -1.59086451e-01f, 3.63997626e-03f,
  -9.84450579e-02f, -5.18227369e-02f, -8.75145271e-02f, -4.93376330e-02f, 8.87896121e-02f, 3.85466702e-02f, -3.27301882e-02f, 8.41561332e-02f, -1.05876319e-01f, -1.72564149e-01f,
  -1.00965925e-01f, 2.17040733e-01f, 3.11281085e-01f, 2.17521444e-01f, 1.02670699e-01f, 3.33620489e-01f, 2.06241617e-03f, 5.23707457e-02f, 1.99419916e-01f, 3.47553194e-01f,
  -7.52927840e-01f, 9.37112495e-02f, -3.34148586e-01f, 1.95049465e-01f, 3.39400917e-01f, 2.83346809e-02f, -1.62167445e-01f, -1.66797727e-01f, 6.33567050e-02f, 6.21070489e-02f,
  1.20126493e-01f, 2.24072576e-01f, 1.99262291e-01f, -6.92164451e-02f, -2.64189243e-01f, 4.57344167e-02f, 3.19075376e-01f, -1.78910613e-01f, -4.24516410e-01f, -1.65946111e-01f,
  2.39308819e-01f, 6.98556378e-02f, -3.60097647e-01f, -6.44904897e-02f, 3.76705676e-01f, 8.80673081e-02f, 1.28603116e-01f, 1.88286170e-01f, -2.27684565e-02f, 3.33423942e-01f,
  -1.22136399e-01f, -2.27237374e-01f, -8.97583589e-02f, 1.28915280e-01f, 5.14116623e-02f, -1.34331286e-01f, -1.39952540e-01f, 8.93256720e-03f, -3.49361673e-02f, -6.78219274e-02f,
  1.74437508e-01f, -8.31101015e-02f, 1.59928635e-01f, 3.19244787e-02f, -1.07716218e-01f, -1.58031687e-01f, -7.91673809e-02f, -1.93108380e-01f, -9.45342183e-02f, -1.56466737e-01f,
  3.14271420e-01f, 6.41176105e-02f, -1.23943985e-01f, -1.13948941e-01f, -1.02347657e-01f, -6.15761019e-02f, -1.36869460e-01f, -1.80443436e-01f, -3.90468538e-01f, -2.32947081e-01f,
  -2.76262481e-02f, 8.16506445e-02f, 5.62841184e-02f, -2.50297952e-02f, -1.92855820e-02f, -7.59684760e-03f, 6.80180714e-02f, 3.27867419e-02f, -1.04711372e-02f, 4.09252793e-02f,
  -2.49128938e-02f, 1.55664431e-02f, -7.20754415e-02f, -1.13035347e-02f, 3.77289467e-02f, 7.11946422e-03f, 3.56812892e-03f, -6.10926859e-02f, -2.08972711e-02f, -3.39617133e-02f,
  -1.22520225e-02f, -6.23625405e-02f, 1.99769507e-03f, 2.87309848e-02f, -1.12386541e-02f, -3.21773589e-02f, 1.66929569e-02f, -3.74308601e-02f, 2.49200556e-02f, -2.89603285e-02f,
  -8.74363165e-03f, -1.40020445e-01f, 9.22493711e-02f, -5.01977727e-02f, 3.99531387e-02f, -4.58590575e-02f, 8.47239420e-02f, -4.68206815e-02f, 1.25557542e-01f, -1.02116466e-01f,
  -1.01669654e-01f, -4.18968201e-02f, 5.30223884e-02f, -5.62614612e-02f, -6.61111325e-02f, -5.77337816e-02f, 6.08123727e-02f, 9.38539803e-02f, -8.31080005e-02f, 2.92599499e-02f,
  -3.42312735e-03f, -1.06275745e-01f, -1.48546234e-01f, -8.42821822e-02f, 7.89618865e-02f, -5.97657077e-02f, -1.72259241e-01f, -1.13024570e-01f, -2.81730622e-01f, -3.20190310e-01f,
  -9.12746906e-01f, -6.90132529e-02f, 3.87840420e-01f, -5.27712584e-01f, -4.08119857e-02f, 3.86333428e-02f, -8.49116966e-02f, -2.50959128e-01f, -2.57806182e-01f, 2.91276500e-02f,
  1.94221690e-01f, 9.85626504e-03f, 1.74999274e-02f, -2.16866639e-02f, -2.70295709e-01f, -7.54780769e-02f, -1.94363892e-01f, -1.90501854e-01f, -1.84163749e-01f, -2.19341263e-01f,
  -1.92245945e-01f, -2.36260921e-01f, -3.35590661e-01f, -2.09120587e-01f, -4.09490727e-02f, 1.21029995e-01f, 1.94475144e-01f, -7.31255412e-02f, 2.17157707e-01f, 4.44452800e-02f,
  3.62900138e-01f, -1.08192317e-01f, 5.09455241e-02f, -4.78112623e-02f, 2.32186869e-01f, -1.07431011e-02f, 3.73714231e-02f, 3.52923125e-02f, 9.92651582e-02f, -2.91361585e-02f,
  -3.57844979e-02f, -6.93554953e-02f, -3.92277762e-02f, -4.46680896e-02f, -6.36959970e-02f, -1.36828437e-01f, -9.41683352e-02f, -3.66216376e-02f, -4.00130972e-02f, 1.18235946e-01f,
  4.50121798e-02f, -1.58701658e-01f, -1.43365949e-01f, -1.04848649e-02f, 1.93829425e-02f, 3.58626433e-02f, 2.40985695e-02f, 4.13248874e-02f, 3.75214368e-02f, -7.13927671e-02f,
  -5.91634633e-03f, 3.86909880e-02f, 2.84912325e-02f, -8.80730376e-02f, -5.10992967e-02f, 1.08547948e-01f, -4.04784689e-03f, -4.92457226e-02f, -4.93118092e-02f, -5.88087402e-02f,
  2.92179361e-02f, 8.62162560e-02f, 4.05520536e-02f, 1.36755826e-02f, 3.28076668e-02f, -4.89308462e-02f, -3.90001498e-02f, -6.19717352e-02f, -1.70511324e-02f, -6.06207084e-03f,
  2.29448676e-02f, 5.58756478e-03f, 3.19699906e-02f, -1.64129324e-02f, 2.53845695e-02f, -4.26252969e-02f, 2.71849539e-02f, 6.12896346e-02f, 4.33289958e-03f, -1.66809151e-03f,
  -2.02136248e-01f, 2.11239755e-01f, -9.37501565e-02f, -1.45508319e-01f, -7.07785636e-02f, 4.33936603e-02f, 6.13864325e-02f, 7.09465668e-02f, 8.72521568e-03f, -5.03847860e-02f,
  4.87226844e-02f, -9.54997689e-02f, -2.01793313e-02f, 7.25466199e-03f, -1.03064604e-01f, -5.26570193e-02f, -1.31236836e-01f, -1.87389761e-01f, -1.27252266e-01f, 1.04695687e-03f,
  -1.40376419e-01f, -2.63940841e-01f, -3.87756467e-01f, -8.42362270e-02f, -3.38715054e-02f, -1.83061540e-01f, 2.69518215e-02f, 3.31175923e-02f, -1.25917464e-01f, -1.88725188e-01f,
  2.27844775e-01f, 6.77935705e-02f, 2.19356287e-02f, 3.98299620e-02f, -1.55115589e-01f, 3.70870046e-02f, -1.04298778e-02f, 1.09321147e-01f, 1.42414823e-01f, 1.89407393e-01f,
  7.71793425e-02f, 6.72563314e-02f, 1.80882022e-01f, 2.00030699e-01f, 2.45717272e-01f, 1.24542847e-01f, 3.56369419e-03f, 1.26664817e-01f, 6.72645941e-02f, 8.57639015e-02f,
  4.90534985e-05f, 2.50960365e-02f, 4.11757501e-03f, -1.88079830e-02f, 1.18825100e-01f, 3.66151854e-02f, -9.22513828e-02f, -7.79061839e-02f, 9.05090012e-03f, 7.03158826e-02f,
  -4.66211997e-02f, 1.08655505e-01f, 6.86689764e-02f, 7.41330087e-02f, -8.79456252e-02f, -3.70039456e-02f, 4.09143278e-03f, -5.86917102e-02f, -1.85558479e-02f, 9.94189754e-02f,
  -5.49517423e-02f, -3.09068654e-02f, 4.27992549e-03f, 3.19813378e-02f, -3.34056616e-02f, 6.09788932e-02f, -5.47287287e-03f, 1.36769459e-01f, 1.70481384e-01f, 9.73029584e-02f,
  -6.26602247e-02f, -2.80254427e-02f, -8.17076489e-02f, 9.90143940e-02f, 1.65699005e-01f, -6.28518388e-02f, 7.18340799e-02f, 9.60472226e-02f, 1.39008194e-01f, 1.28183886e-01f,
  -2.22636927e-02f, 2.98317354e-02f, -5.41548915e-02f, 8.02900791e-02f, 1.64732267e-03f, 7.73574486e-02f, -2.10855678e-02f, -2.28881221e-02f, 2.88935527e-02f, -5.88660389e-02f,
  4.08089273e-02f, 5.67896888e-02f, -1.09327137e-02f, 8.80078133e-03f, 2.88994540e-03f, -5.82936220e-02f, 2.39572139e-03f, -4.01655100e-02f, -4.85022040e-03f, -5.36067449e-02f,
  4.78351600e-02f, -1.19203073e-03f, -8.33542794e-02f, 1.94409932e-03f, 7.52992113e-04f, 6.30980805e-02f, -4.34232838e-02f, 4.32641543e-02f, -7.70399719e-02f, -5.94797209e-02f,
  2.33883187e-02f, -7.06363693e-02f, 8.42255279e-02f, 8.11923444e-02f, -1.04491673e-01f, -6.25082180e-02f, -8.55916068e-02f, -8.07510465e-02f, -1.34498402e-01f, 6.91174483e-03f,
  -1.97925083e-02f, -3.90347908e-03f, 3.95807736e-02f, -7.48574063e-02f, -7.29579628e-02f, -7.52041116e-02f, -4.08391990e-02f, 5.56664094e-02f, 6.98097870e-02f, -6.50061518e-02f,
  -6.12851419e-02f, -1.14164334e-02f, -4.62266840e-02f, -5.39001450e-03f, 5.69681302e-02f, -2.65104342e-02f, -2.28249412e-02f, -1.33755896e-02f, -1.00844793e-01f, -3.07334065e-02f,
  3.57154548e-01f, -2.05148503e-01f, -7.10425735e-01f, 3.44942212e-02f, -3.41267973e-01f, -3.53070527e-01f, -3.14624637e-01f, 3.21947807e-03f, 2.44763017e-01f, -1.41733259e-01f,
  -5.62558286e-02f, 3.05716712e-02f, -1.08851902e-01f, -9.33771804e-02f, -1.35571033e-01f, -3.87124181e-01f, -3.39414179e-01f, -4.01384741e-01f, -2.52532989e-01f, -2.99972165e-02f,
  -8.92676860e-02f, -1.33588195e-01f, -5.94287142e-02f, -6.08736984e-02f, -8.00202265e-02f, -1.36048198e-01f, -2.21286237e-01f, -1.32477582e-01f, -3.30325693e-01f, -3.85009557e-01f,
  -3.89113188e-01f, -4.58655022e-02f, -4.00067866e-02f, 1.74699590e-01f, -6.33898228e-02f, 7.34129995e-02f, -5.43056950e-02f, 2.51997747e-02f, 6.41682819e-02f, -7.64751621e-03f,
  -9.37418044e-02f, -2.73671094e-02f, -1.37565518e-02f, -1.32855326e-01f, 4.57552895e-02f, -5.51272184e-02f, -7.04325438e-02f, -3.76902297e-02f, -3.10389083e-02f, -1.08455718e-01f,
  -2.25463212e-02f, -2.27011412e-01f, -1.27017289e-01f, 6.51916191e-02f, -4.33226638e-02f, -4.19952571e-02f, -5.67349158e-02f, -5.86275160e-02f, -1.50685862e-01f, 8.85895416e-02f,
  -1.60734840e-02f, -9.12532434e-02f, -7.72912577e-02f, 7.25759491e-02f, 9.67516284e-03f, 4.81027104e-02f, -7.16303766e-04f, -1.40058156e-02f, 3.43509577e-03f, 2.10142788e-02f,
  5.79698943e-02f, -5.87287769e-02f, 3.84104438e-02f, 3.18391360e-02f, -5.27348444e-02f, -9.95889585e-03f, 1.43477079e-02f, 4.75922599e-03f, -4.02351320e-02f, -9.87041648e-03f,
  -2.44731992e-03f, -8.20257291e-02f, -1.53323468e-02f, 1.08130940e-03f, -3.09001543e-02f, -1.02076761e-01f, 1.07572526e-02f, -1.68159381e-02f, 8.83281901e-02f, 2.88375821e-02f,
  4.45553750e-01f, -1.95471704e-01f, 2.28960393e-03f, 1.52845070e-01f, -9.63781998e-02f, -3.41074839e-02f, 9.23155341e-03f, 5.52151538e-02f, 2.91279126e-02f, -4.14025374e-02f,
  2.64869910e-02f, 1.35144040e-01f, -4.14707176e-02f, 1.66241638e-02f, -6.05360717e-02f, 6.89397231e-02f, 5.53011410e-02f, -6.55136853e-02f, -1.93503238e-02f, 1.09464601e-01f,
  9.97554958e-02f, 1.42691387e-02f, 1.24908857e-01f, 8.62349477e-03f, 2.50284560e-02f, 9.98420455e-03f, -6.61384463e-02f, 1.59942985e-01f, -6.54903725e-02f, 1.83867857e-01f,
  6.69100732e-02f, -2.81797945e-01f, 1.88589972e-02f, 1.07060216e-01f, -7.13467272e-03f, -2.13595003e-01f, -4.49771255e-01f, -2.83437878e-01f, 3.52685302e-02f, -1.05747163e-01f,
  9.35310870e-03f, 1.84273705e-01f, -2.03184113e-02f, -2.65199840e-02f, -1.21146850e-01f, -1.08316451e-01f, -1.22806892e-01f, 1.05266944e-02f, -4.05921377e-02f, -1.20781794e-01f,
  5.00315800e-02f, -6.99192509e-02f, -5.16281649e-02f, 6.40287530e-03f, 2.42004618e-01f, 2.26307631e-01f, 1.19568422e-01f, 1.29870176e-01f, 1.35477200e-01f, 2.97283024e-01f,
  1.37762681e-01f, -6.56817779e-02f, -1.72726400e-02f, 4.33913805e-02f, 6.15406223e-02f, -3.34397256e-02f, -1.80797111e-02f, 6.25163093e-02f, 3.13738659e-02f, -1.46287298e-02f,
  1.43888876e-01f, 8.39786008e-02f, 3.45532573e-03f, 7.13756308e-02f, 1.41617209e-02f, 6.41037673e-02f, -2.74025686e-02f, -3.62408496e-02f, -1.01074815e-01f, -1.89427156e-02f,
  -1.70760024e-02f, 7.94155449e-02f, -1.06441183e-02f, -1.52883619e-01f, -1.74316056e-02f, 1.28600448e-01f, -1.97224226e-02f, 5.91432340e-02f, 3.21476697e-03f, 5.68299741e-02f,
  4.67622504e-02f, 5.70268333e-02f, 3.18989828e-02f, -6.15013950e-03f, -3.42544876e-02f, 5.04474305e-02f, 2.73396373e-02f, 1.09608844e-02f, -7.47937411e-02f, -2.23416183e-02f,
  -1.26316790e-02f, 1.66449733e-02f, -6.83096936e-03f, -3.85129824e-02f, 5.00491727e-03f, 5.88277876e-02f, -5.63425943e-02f, -7.01016095e-03f, -3.58864143e-02f, 5.51308319e-02f,
  -9.49185528e-03f, 3.16123874e-03f, 1.34134234e-03f, 7.27786571e-02f, 1.72621161e-02f, 9.75575820e-02f, -2.67947633e-02f, 4.37952317e-02f, -7.99454227e-02f, 3.90553065e-02f,
  -8.72905701e-02f, -9.01775882e-02f, 6.26866743e-02f, 2.55492087e-02f, 1.31375398e-02f, 9.58264470e-02f, -1.24062467e-02f, 3.63707244e-02f, 7.03275725e-02f, 3.41221946e-03f,
  -6.10076403e-03f, -2.01984774e-03f, -8.54843855e-02f, 2.12470032e-02f, -5.68724833e-02f, 5.28002493e-02f, -9.65679884e-02f, 8.77746567e-02f, -4.95734066e-02f, 5.09166718e-02f,
  -4.84148078e-02f, -1.77260563e-01f, -1.44114301e-01f, -7.67481327e-02f, -3.73042040e-02f, 1.21436855e-02f, -1.61622271e-01f, -3.36700864e-02f, -1.44091040e-01f, -2.92507797e-01f,
  -5.66996157e-01f, -6.17477763e-03f, -8.17510784e-02f, -3.36263478e-01f, -5.89264557e-02f, -2.74051656e-03f, 3.57756577e-02f, -5.20124622e-02f, -1.27175912e-01f, -1.30994976e-01f,
  -3.36174741e-02f, -2.03753505e-02f, -7.20344037e-02f, -4.74658944e-02f, -3.57597061e-02f, -8.19827244e-02f, -2.13055938e-01f, -3.75096619e-01f, -2.55641729e-01f, -2.08793394e-02f,
  -6.36085644e-02f, -3.00869673e-01f, -3.63982499e-01f, -1.75614655e-01f, 1.14966799e-02f, -5.51198497e-02f, -6.29297271e-02f, -2.01362252e-01f, -5.75871766e-02f, -1.35106817e-01f,
  1.67987868e-01f, -1.75489098e-01f, 5.51224835e-02f, -8.34470168e-02f, -5.33651821e-02f, -7.79062286e-02f, -1.12825669e-02f, -1.16384178e-01f, -9.07475352e-02f, -8.11309181e-03f,
  2.24231021e-03f, 6.36813119e-02f, -1.45307571e-01f, 6.50722608e-02f, -2.60561444e-02f, 4.69024442e-02f, -2.40600090e-02f, -7.26508945e-02f, -7.12384051e-03f, 8.74905288e-02f,
  1.68175951e-01f, -2.60747341e-03f, 6.30000681e-02f, 6.76691905e-02f, 1.34315729e-01f, -1.55294985e-02f, 1.21785522e-01f, 1.48865119e-01f, 8.44550133e-02f, 7.30818510e-02f,
  2.12916713e-02f, 1.25081897e-01f, 6.51933253e-02f, 2.02566180e-02f, 4.16136160e-02f, 1.16742332e-03f, -1.27625130e-02f, 5.02866134e-03f, 2.92099826e-02f, 3.42438892e-02f,
  -4.54293424e-03f, 9.40570757e-02f, -6.61155507e-02f, -2.87071969e-02f, -1.21137062e-02f, 6.14145352e-03f, -5.59319146e-02f, 7.63803720e-02f, 1.90298725e-02f, -7.31280148e-02f,
  -8.51687565e-02f, 2.03822460e-02f, -1.30300358e-01f, 9.44093764e-02f, 2.76250839e-02f, 1.05141348e-03f, -4.23465855e-02f, 1.96089633e-02f, -3.33242607e-03f, -7.46282712e-02f,
  1.87965691e-01f, -1.61325887e-01f, 6.14249781e-02f, 3.51939872e-02f, -8.00946280e-02f, -8.58370960e-03f, 1.05315004e-04f, -4.77047116e-02f, -1.24740340e-01f, 6.44244067e-03f,
  5.63985966e-02f, 2.70151310e-02f, 4.04858403e-02f, 5.36439754e-02f, -1.09812044e-01f, -1.87121276e-02f, -2.32538655e-02f, 1.68384146e-02f, 3.99959721e-02f, 1.08611368e-01f,
  1.12984665e-01f, 4.70635518e-02f, 3.11757941e-02f, 5.85906655e-02f, 1.57083765e-01f, -1.09973013e-01f, 1.52969420e-01f, 1.04066059e-01f, -2.87089832e-02f, 6.20910451e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  1.48199543e-01f, 2.10630313e-01f, 1.67765811e-01f, 4.25515532e-01f, 1.03787631e-01f, 6.09252214e-01f, -1.96986962e-02f, 2.71826088e-01f, 2.60767668e-01f, 3.08580071e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  5.34970239e-02f, 2.49290720e-01f, 5.55678010e-01f, -2.31861308e-01f, 2.27906734e-01f, 5.99863194e-02f, -2.75811970e-01f, 6.05470777e-01f, -3.65940593e-02f, 1.91789359e-01f,
  -5.15833274e-02f, -5.46877123e-02f, -3.11581016e-01f, -1.04771212e-01f, -2.18976855e-01f, -2.77310163e-01f, 1.91796459e-02f, -2.40722358e-01f, -3.12825650e-01f, 1.34398162e-01f,
  -1.15685463e-01f, 3.55118811e-01f, -2.30735183e-01f, -2.75851578e-01f, -4.15209029e-03f, -3.62809122e-01f, 4.72340673e-01f, -1.54520243e-01f, 1.03798412e-01f, -9.41395015e-02f,
  5.07631481e-01f, -2.14359298e-01f, 3.52096021e-01f, 3.58768135e-01f, 2.58937508e-01f, 6.13512516e-01f, -6.13754451e-01f, -3.12023520e-01f, 1.64619550e-01f, -3.85076106e-01f,
  -4.12990928e-01f, -1.11705825e-01f, 4.51610863e-01f, 3.32728587e-02f, -1.28076330e-01f, 2.36288026e-01f, -1.09514497e-01f, -1.52901113e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.23670049e-01f, 4.95649993e-01f, -3.03251445e-01f, 5.87383211e-01f, 1.31442294e-01f, -9.02909860e-02f, -1.36949286e-01f, 2.15768799e-01f, 2.28787959e-01f, 4.15857732e-01f,
  1.51681185e-01f, -1.73064470e-01f, -2.89945692e-01f, -3.31513762e-01f, 2.72085696e-01f, 4.61600162e-02f, -1.30127236e-01f, 5.12500517e-02f, -1.01810388e-01f, 1.04916066e-01f,
  8.08248594e-02f, 9.03638974e-02f, -2.40631789e-01f, -1.39287069e-01f, -5.83980866e-02f, 1.28277410e-02f, -6.79513440e-02f, -1.36625886e-01f, -2.26853013e-01f, -1.22190431e-01f,
  1.86564654e-01f, 7.33216554e-02f, 8.23700786e-01f, 1.03754416e-01f, 2.96402752e-01f, -6.40908241e-01f, -6.25116408e-01f, 1.04052258e+00f, -3.03745359e-01f, 2.76094407e-01f,
  -3.58017206e-01f, -9.97336861e-03f, 7.49210194e-02f, 4.16172326e-01f, -4.39480208e-02f, 1.00301385e+00f, 3.26055139e-01f, 5.68612278e-01f, -5.77226162e-01f, 2.23030493e-01f,
  -3.24935764e-02f, -1.26546457e-01f, 4.61328208e-01f, -7.19188988e-01f, 5.64385474e-01f, -1.52750239e-01f, -3.13422263e-01f, 1.32886136e+00f, 3.58448386e-01f, -4.31100667e-01f,
  2.71604627e-01f, 1.08318043e+00f, -6.90822080e-02f, 3.14373821e-01f, 2.16479108e-01f, -4.66701463e-02f, 2.01541279e-02f, 1.48005471e-01f, 5.41353047e-01f, -6.49116516e-01f,
  5.27689636e-01f, 1.74339592e-01f, 1.36238623e+00f, -5.01333594e-01f, -6.23389006e-01f, 7.15010107e-01f, 2.41749305e-02f, -3.73357423e-02f, 3.95254493e-02f, 5.16709268e-01f,
  -2.84653574e-01f, 1.91238672e-01f, 2.46773809e-01f, 1.20885454e-01f, 1.13885634e-01f, -1.08733945e-01f, 1.59368470e-01f, -1.74584135e-01f, 5.60683385e-03f, -9.72020440e-03f,
  1.14061105e+00f, 1.48787975e-01f, -5.24081178e-02f, -3.01069736e-01f, 1.65681586e-01f, -4.20757756e-02f, -1.12038516e-01f, -1.68355356e-03f, -1.84936345e-01f, -1.03499487e-01f,
  -1.37085393e-01f, 2.49209985e-01f, -8.04197043e-02f, -2.31742069e-01f, -6.94174692e-02f, 1.02688856e-01f, 7.92861953e-02f, -1.41737908e-02f, -7.64776468e-02f, -4.83164191e-02f,
  -1.41523987e-01f, 2.66696870e-01f, 4.09032017e-01f, -1.49067249e-02f, 9.75893959e-02f, 7.34715998e-01f, -6.99842751e-01f, -5.59015036e-01f, 5.38438261e-01f, -3.84901375e-01f,
  -3.45462948e-01f, 5.99340014e-02f, -2.15869874e-01f, 5.02521873e-01f, -4.17300388e-02f, 2.04809055e-01f, -6.55933693e-02f, 6.14991486e-01f, 6.29642844e-01f, 8.82896874e-03f,
  5.61980426e-01f, 1.23403203e+00f, 1.80228353e-01f, -2.71974534e-01f, -3.09979051e-01f, 6.57436788e-01f, -3.89129132e-01f, 2.17647627e-01f, 5.66595078e-01f, 1.02786291e+00f,
  -4.26747620e-01f, -5.00875294e-01f, -2.11962834e-01f, 5.74482977e-01f, 3.39589305e-02f, 1.82378978e-01f, 9.99732763e-02f, -9.93300259e-01f, 4.42482233e-01f, -1.83018744e-01f,
  4.88829970e-01f, -2.28000298e-01f, -1.13150246e-01f, -1.31651253e-01f, 5.96460462e-01f, 1.02328610e+00f, -4.82923836e-01f, 2.45381936e-01f, 7.52627254e-01f, 3.12414169e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  2.73615658e-01f, -1.67840198e-01f, 4.24432874e-01f, 4.71119702e-01f, 3.69973540e-01f, -1.11667201e-01f, -1.27642140e-01f, 2.29191452e-01f, 2.70925194e-01f, 1.00159191e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -1.02329755e+00f, -7.97787666e-01f, -5.09941280e-01f, -2.46648967e-01f, 7.74874315e-02f, 1.15199193e-01f, 5.00783585e-02f, -2.26642296e-01f, -7.31162652e-02f, 5.38001597e-01f,
  2.82371700e-01f, 1.14994816e-01f, -1.03807405e-01f, 3.65910262e-01f, -1.15320408e+00f, 4.44640756e-01f, 9.81261358e-02f, -4.04774994e-01f, 1.51113272e-01f, 3.51338506e-01f,
  -5.12040615e-01f, -7.19801664e-01f, -5.19992173e-01f, 2.19923064e-01f, -2.44914472e-01f, 1.42064404e+00f, -2.56228656e-01f, -2.18527630e-01f, -4.56600673e-02f, -5.88016272e-01f,
  -9.46508348e-01f, 1.73886195e-01f, -1.04876505e-02f, 2.12496027e-01f, 1.39047414e-01f, 3.31519663e-01f, -5.59335411e-01f, -8.07853699e-01f, -3.91995788e-01f, 3.43055911e-02f,
  -6.51617110e-01f, -3.80168498e-01f, 1.06475067e+00f, 1.34174496e-01f, 1.43127307e-01f, -3.74349952e-01f, -2.63248533e-01f, 6.72348499e-01f, -4.99605983e-01f, -4.78823751e-01f,
  -8.70014906e-01f, -5.18179119e-01f, -2.85691381e-01f, 4.80718948e-02f, -6.55565485e-02f, -2.23022118e-01f, -5.84204316e-01f, -2.15989962e-01f, 5.38420320e-01f, 1.09888367e-01f,
  1.46567658e-01f, 9.92171526e-01f, 4.68385458e-01f, 8.83079618e-02f, -7.18821704e-01f, 2.32831970e-01f, -4.16802138e-01f, -5.74982464e-01f, -3.53101552e-01f, -1.10833846e-01f,
  -1.17375851e-01f, -6.60223961e-02f, 8.76643956e-01f, -4.78049517e-01f, -3.59994650e-01f, -3.54307353e-01f, 1.11548774e-01f, -8.02868526e-05f, 4.67253439e-02f, 7.46686816e-01f,
  2.96889275e-01f, -2.34105334e-01f, 1.61819115e-01f, 4.06466126e-01f, -1.06283331e+00f, 5.88646948e-01f, -3.58071595e-01f, 7.20933005e-02f, 1.11350822e+00f, 4.02443945e-01f,
  -8.02307367e-01f, -2.15079352e-01f, -2.49945506e-01f, 1.22124493e-01f, -6.37434304e-01f, -3.84889245e-01f, 6.98413134e-01f, 5.35575747e-01f, 1.10484898e+00f, -8.10338438e-01f,
  7.46088982e-01f, -6.38375401e-01f, 2.83100456e-01f, 3.18975523e-02f, 3.19244713e-01f, -7.51639247e-01f, 8.92299891e-01f, -4.39726710e-01f, -2.14938328e-01f, -3.22732687e-01f,
  -6.31950915e-01f, -7.64336348e-01f, 1.22632079e-01f, 9.30847973e-02f, -1.16400683e+00f, -4.71444458e-01f, 9.24471319e-01f, 5.16660333e-01f, 9.53581408e-02f, 1.80665597e-01f,
  -4.84366834e-01f, 6.06069863e-01f, -2.71607012e-01f, 8.96119475e-01f, -1.59746706e-01f, -2.57487327e-01f, 5.05578578e-01f, -2.29933709e-01f, -2.71987259e-01f, -2.94816434e-01f,
  3.41820449e-01f, 9.25867856e-01f, -5.67363799e-01f, 1.44858107e-01f, 7.83494532e-01f, -1.29596628e-02f, -9.76618350e-01f, 6.34187162e-01f, -3.85619938e-01f, -3.12997550e-01f,
  1.07479706e-01f, -1.92096010e-01f, 6.14252090e-01f, -5.18132567e-01f, 2.97064602e-01f, -1.91832960e-01f, 6.97235346e-01f, -1.15622178e-01f, 9.67597246e-01f, 7.27773756e-02f,
  -4.00040857e-02f, -1.61541641e-01f, 5.81328094e-01f, -6.60644233e-01f, -8.01872075e-01f, 4.63911533e-01f, -4.07825373e-02f, -7.40835071e-01f, -2.08522066e-01f, 1.08439255e+00f,
  -6.90354466e-01f, -7.32538939e-01f, 4.07432541e-02f, 5.00591934e-01f, -2.20786840e-01f, -7.23324537e-01f, -1.28968775e-01f, 1.89450577e-01f, 3.11075240e-01f, -5.45958221e-01f,
  3.46284270e-01f, -1.67967215e-01f, -1.75906301e-01f, -2.12146819e-01f, 9.93095040e-01f, -1.10566430e-01f, 1.19000983e+00f, 1.43147516e+00f, 1.94895327e-01f, -1.00913763e-01f,
  -9.48115289e-02f, 1.21681571e+00f, -8.92756656e-02f, 1.45982906e-01f, 1.54357865e-01f, -3.67285103e-01f, -4.91785288e-01f, -2.15408430e-01f, 1.59442261e-01f, 5.11886120e-01f,
  5.54890454e-01f, -7.32094407e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -4.27288234e-01f, -2.53359973e-01f, 1.20849423e-01f, -4.22859937e-01f, -3.55200231e-01f, 1.01438574e-01f, 7.72307336e-01f, 2.70257127e-02f, 8.13889727e-02f, 1.45452231e-01f,
  -3.79469544e-01f, 8.62630367e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    