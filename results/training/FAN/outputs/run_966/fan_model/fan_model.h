/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.27165157e-01f, 4.65892851e-01f, 4.15110767e-01f, -2.48552144e-01f, 2.07830369e-01f, 9.82315913e-02f, 2.30283797e-01f, 2.84952559e-02f, -1.13655485e-01f, 1.33134499e-01f,
  2.35695645e-01f, -1.96692795e-01f, -2.84842521e-01f, -1.61328092e-01f, -9.54848230e-02f, 1.34951428e-01f, 5.24169877e-02f, -3.22947025e-01f, -2.06744239e-01f, 4.03673984e-02f,
  6.14973716e-03f, -9.63258818e-02f, -2.28755116e-01f, -1.02590933e-01f, 1.17483437e-01f, -6.63644969e-02f, 1.57501921e-01f, 9.67036188e-02f, 2.74116158e-01f, 1.79394051e-01f,
  2.29550615e-01f, 2.76753694e-01f, -5.77339008e-02f, -2.06307732e-02f, 1.53613031e-01f, -6.91398978e-02f, -7.58898854e-02f, -4.23738547e-03f, 7.80560300e-02f, 4.73791212e-02f,
  1.96551844e-01f, 2.23096982e-02f, -3.94085012e-02f, 5.64751774e-02f, 1.39742702e-01f, 2.59806253e-02f, -5.53239286e-02f, -2.78513506e-02f, 5.40896058e-02f, 1.94887027e-01f,
  1.54804677e-01f, 2.94709861e-01f, 2.30176300e-01f, 7.02334493e-02f, 1.64551258e-01f, 5.67312129e-02f, 3.17411661e-01f, 1.66198313e-01f, 1.44988626e-01f, 9.23889428e-02f,
  2.28645764e-02f, 3.23276259e-02f, -2.04779059e-02f, 9.45762992e-02f, 1.11556239e-02f, -7.06849098e-02f, -1.74928848e-02f, 2.80062226e-03f, -6.87083751e-02f, -8.92440230e-02f,
  6.26102183e-03f, -1.80127174e-02f, 2.00507920e-02f, 2.68191230e-02f, -1.31841794e-01f, 8.85848328e-02f, -2.86532361e-02f, 1.60803385e-02f, -7.81175941e-02f, -8.30770656e-02f,
  -7.68908933e-02f, -6.42060908e-03f, -1.09823294e-01f, -1.09295398e-01f, -2.04306953e-02f, 6.57251943e-03f, 1.57736347e-03f, -6.72107413e-02f, -1.76296383e-02f, -2.68479418e-02f,
  -1.67469531e-01f, -5.66255525e-02f, -4.77114990e-02f, -2.89267115e-02f, -1.76068377e-02f, -1.14444882e-01f, -5.38148694e-02f, 4.60779108e-02f, 6.01397119e-02f, 4.05857638e-02f,
  3.18019502e-02f, -2.07785815e-02f, 5.17725274e-02f, -2.48719342e-02f, 1.45377871e-02f, 6.16893210e-02f, -3.37731130e-02f, 2.81695556e-02f, 3.87750678e-02f, 6.85509518e-02f,
  -1.18515482e-02f, 1.26222363e-02f, -1.60317138e-01f, -5.27609652e-03f, 6.27357960e-02f, -1.22485593e-01f, 2.14935392e-02f, -6.92857010e-03f, -1.06648043e-01f, -2.19760146e-02f,
  2.15762749e-01f, -1.61073864e-01f, -1.80722862e-01f, 1.19007297e-01f, -1.75110605e-02f, 1.66692674e-01f, 3.56890500e-01f, 1.73057109e-01f, 1.43919230e-01f, 4.40433472e-02f,
  -4.53914970e-01f, -3.32173169e-01f, -3.41524184e-01f, -1.16719298e-01f, 1.27158105e-01f, 2.54826456e-01f, 2.98105329e-01f, 1.99692130e-01f, 1.41548112e-01f, 3.06347907e-01f,
  5.33764847e-02f, 1.27319470e-01f, 5.71055301e-02f, 1.60417318e-01f, -7.79357627e-02f, -1.13025077e-01f, -2.28875637e-01f, -1.10767879e-01f, -9.90541354e-02f, -1.15387417e-01f,
  -1.39999194e-02f, -8.47707838e-02f, 3.57568450e-02f, -1.00361869e-01f, -2.72552133e-01f, 3.20443064e-02f, -3.38113979e-02f, -9.54564214e-02f, 1.97495129e-02f, 9.58644897e-02f,
  -1.14485800e-01f, 5.83922938e-02f, 6.47906633e-03f, -1.26414672e-02f, 1.11015573e-01f, -3.81785852e-04f, 9.72446948e-02f, 3.31742503e-02f, 5.39694587e-03f, 6.05830289e-02f,
  -1.50023242e-02f, 2.39404617e-04f, 8.80602561e-03f, -3.06589734e-02f, 1.02665029e-01f, -1.04343079e-01f, -3.41400206e-02f, 3.40393446e-02f, -8.91769677e-02f, 2.72302851e-02f,
  1.35120422e-01f, -6.56214207e-02f, -5.37735224e-02f, -4.54420317e-03f, -5.00937318e-03f, -9.08622593e-02f, -2.52143480e-02f, -2.72342656e-02f, 4.18800674e-02f, 7.81172700e-03f,
  -2.38504745e-02f, -8.93255472e-02f, 2.32772017e-03f, 1.07974382e-02f, 6.00028364e-03f, 6.75041089e-03f, -7.02929869e-02f, 3.05159297e-02f, 6.90109506e-02f, -4.19260263e-02f,
  4.81404364e-03f, -8.60544220e-02f, 1.06021091e-02f, -5.98903224e-02f, -4.55533527e-02f, -1.43429032e-02f, 3.57030630e-02f, -4.64313664e-02f, -3.67145538e-02f, 2.40559969e-02f,
  -1.47195533e-01f, -2.67218381e-01f, -8.59872438e-03f, 1.23673454e-01f, -3.09152696e-02f, -4.44891453e-02f, -1.82579100e-01f, 8.90413392e-03f, -2.16200054e-01f, -1.24002965e-02f,
  1.95349217e-03f, 4.82471958e-02f, -9.66692492e-02f, 9.29117948e-03f, -1.92622263e-02f, 9.40910168e-03f, 1.19459696e-01f, -1.75731212e-01f, -2.55835039e-04f, -1.10729989e-02f,
  1.00953817e-01f, 6.58135265e-02f, 4.72401828e-02f, -1.79457273e-02f, -2.44110785e-02f, -6.27079606e-03f, -1.07067199e-02f, 1.13773961e-02f, 1.47388959e-02f, 1.97698921e-01f,
  -6.43706083e-01f, 1.28673375e-01f, 5.80024064e-01f, -4.48267795e-02f, 3.46080244e-01f, 4.24893200e-01f, 4.76081222e-01f, -1.45025859e-02f, -6.26500472e-02f, 2.63618410e-01f,
  4.73978296e-02f, -2.36998528e-01f, -1.03235707e-01f, -9.40932333e-02f, -1.67834058e-01f, 3.64197195e-01f, 4.51129317e-01f, 4.16446142e-02f, -1.99460313e-01f, -3.72849971e-01f,
  -1.51396796e-01f, -1.48919269e-01f, -2.41929352e-01f, -2.10659936e-01f, -1.42650492e-02f, 9.72717628e-02f, 3.71860236e-01f, 2.76742596e-02f, 2.37632170e-02f, 9.23773050e-02f,
  1.25408038e-01f, -1.29181996e-01f, 2.51654238e-02f, -7.58291036e-02f, -3.90973613e-02f, -1.09770976e-01f, 8.86705145e-02f, -4.26354259e-02f, -1.17957126e-02f, 2.45190579e-02f,
  2.88758520e-02f, -8.14564712e-03f, -4.74011851e-03f, 4.32904670e-03f, 7.31654512e-03f, -1.07369320e-02f, -1.35867104e-01f, -8.14987645e-02f, 1.13949003e-02f, -1.05119310e-01f,
  -2.03010589e-02f, -3.29575576e-02f, 1.50490835e-01f, 6.00954294e-02f, -4.60915640e-02f, 1.92129146e-02f, -2.20520496e-02f, -1.25840262e-01f, -1.43385548e-02f, -8.61347318e-02f,
  -3.47741358e-02f, -3.28689106e-02f, -1.78172514e-02f, -6.16844147e-02f, -5.19063286e-02f, 5.73137701e-02f, 2.26874091e-03f, 7.62590095e-02f, -1.21070474e-01f, 1.11744022e-02f,
  1.01830009e-02f, 4.17438969e-02f, -6.50193617e-02f, 7.42241591e-02f, -7.46353343e-02f, 4.45515737e-02f, -4.27818764e-03f, -9.28765237e-02f, -1.75050404e-02f, -5.34931533e-02f,
  -1.19563818e-01f, -2.27808338e-02f, 2.24642009e-02f, -4.20120768e-02f, -4.97440696e-02f, -3.13838199e-02f, -7.20322654e-02f, -3.93868200e-02f, -4.07543778e-03f, 1.36745907e-02f,
  1.67150363e-01f, 1.75825879e-01f, 4.75799991e-03f, -5.99443577e-02f, 1.02219537e-01f, -4.60636765e-02f, 2.75523551e-02f, 1.23902010e-02f, 6.65228516e-02f, -3.16766836e-02f,
  -2.10788958e-02f, 1.66089088e-02f, 1.18363507e-01f, -1.29581876e-02f, 1.77629422e-02f, -7.94708822e-03f, 6.21605553e-02f, 7.60286227e-02f, 3.94675285e-02f, -2.52170060e-02f,
  -2.77188071e-03f, 1.59255832e-01f, 2.10872993e-01f, 1.62548482e-01f, -1.53251654e-02f, 7.77681172e-02f, 1.28659278e-01f, 1.58459365e-01f, 1.81436732e-01f, 2.83395559e-01f,
  4.46949840e-01f, 4.31634486e-01f, 7.76186734e-02f, 7.69684613e-02f, 2.95971692e-01f, 1.18057787e-01f, 3.31156671e-01f, 1.42553240e-01f, 2.21809465e-02f, 2.55580485e-01f,
  -6.58049658e-02f, -4.22233373e-01f, -4.07875657e-01f, -2.19874606e-01f, -2.36600474e-01f, 5.80493025e-02f, -3.46921533e-02f, -3.18152755e-01f, -2.33557329e-01f, 4.72009666e-02f,
  4.01469804e-02f, 1.84392884e-01f, 1.56926364e-01f, -1.10232331e-01f, 7.43380263e-02f, -2.43334636e-01f, 1.19093202e-01f, 6.51391447e-02f, -9.68331546e-02f, 3.44731286e-02f,
  -3.18774760e-01f, 1.77889660e-01f, -2.58978307e-01f, -8.76823962e-02f, 2.11927723e-02f, 2.56943349e-02f, 2.76650377e-02f, 4.05895151e-02f, 3.35423416e-03f, 5.62264435e-02f,
  -1.47221815e-02f, 6.70778528e-02f, 5.49037829e-02f, 2.52341796e-02f, 5.03802374e-02f, -1.03362836e-01f, -9.03772339e-02f, -5.56691140e-02f, -1.64961994e-01f, -2.06568390e-02f,
  -2.43842825e-02f, 1.00042909e-01f, -1.35312295e-02f, -1.18630275e-01f, -1.13605857e-01f, -1.87450036e-01f, 4.40878496e-02f, -8.59959275e-02f, -1.22021787e-01f, 9.49276760e-02f,
  -7.06293713e-03f, 2.50105381e-01f, 8.13065916e-02f, 3.10500301e-02f, -3.80622596e-02f, 1.02346748e-01f, 3.36931050e-02f, 2.47844700e-02f, 3.30417827e-02f, 9.34168398e-02f,
  1.85437296e-02f, -4.07910757e-02f, 9.18423831e-02f, 5.44167310e-02f, -4.83732820e-02f, 4.45884280e-02f, 1.05935551e-01f, 8.61223713e-02f, -8.71424004e-02f, 3.28895152e-02f,
  -7.96111003e-02f, 1.87556054e-02f, 4.23665605e-02f, 5.67086302e-02f, -3.03368010e-02f, 6.55936897e-02f, 4.57818806e-03f, 4.95047728e-03f, 7.21976236e-02f, 1.66433677e-01f,
  8.55010226e-02f, -2.17183411e-01f, -6.00471310e-02f, -3.28648798e-02f, 5.12618236e-02f, 3.96427512e-02f, -3.47131751e-02f, -3.58787812e-02f, -5.12409722e-03f, -6.84724823e-02f,
  -8.63077193e-02f, 2.97830557e-03f, 6.48263395e-02f, -2.30911020e-02f, -5.08701727e-02f, -7.50823244e-02f, 2.18379591e-02f, -1.36643842e-01f, 7.24756904e-03f, 1.02052093e-01f,
  2.14279257e-02f, 3.89605644e-03f, -1.19667314e-01f, -3.68006602e-02f, -6.65197447e-02f, -3.66878882e-02f, -7.23807067e-02f, -6.08973205e-02f, -1.22851118e-01f, 1.69434950e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.65961790e+00f, -2.48393655e-01f, 2.15308174e-01f, -1.96297479e+00f, -8.95982325e-01f, -8.63918960e-02f, -3.71559650e-01f, -1.61449656e-01f, -3.25097889e-01f, -3.03876549e-01f,
  2.87370145e-01f, 3.96134220e-02f, 8.89802445e-03f, 6.54891320e-03f, -1.22143634e-01f, -7.34762326e-02f, -6.80425167e-01f, -4.39594030e-01f, -2.28845373e-01f, -3.72127384e-01f,
  -5.48552752e-01f, -1.05283237e+00f, -9.77885246e-01f, -2.38949656e-01f, -2.73004651e-01f, -1.78481668e-01f, -1.49578422e-01f, -7.03566909e-01f, 1.22292511e-01f, -7.22751915e-01f,
  6.76492333e-01f, -3.04764777e-01f, 1.87860250e-01f, -1.57426242e-02f, 1.81772053e-01f, 1.34973392e-01f, -2.14720331e-02f, 1.30628413e-02f, -3.27911787e-02f, -1.92560479e-01f,
  -5.07515490e-01f, 1.17101885e-01f, -2.45246291e-01f, 2.24873677e-01f, -2.49104410e-01f, -9.08518210e-02f, -9.56794322e-02f, -1.87221467e-01f, -6.66170800e-03f, 3.81261349e-01f,
  -5.38712181e-02f, -4.13595498e-01f, 6.55526966e-02f, 3.60888958e-01f, 4.22000110e-01f, -1.99980542e-01f, 4.15819168e-01f, 7.99170136e-02f, 4.21915233e-01f, 1.21453546e-01f,
  3.07366569e-02f, 2.60108322e-01f, 2.44802147e-01f, -1.33371903e-02f, 9.54695940e-02f, 1.04910806e-02f, -6.25222400e-02f, -2.10968345e-01f, 3.43254283e-02f, -4.49615605e-02f,
  2.27665994e-02f, 4.52304371e-02f, 4.82261889e-02f, -3.52194577e-01f, -2.94076595e-02f, -1.69327125e-01f, -4.47325371e-02f, 2.00390983e-02f, 1.05837464e-01f, -3.60269576e-01f,
  -9.06672850e-02f, 1.77007407e-01f, -7.35273361e-02f, 2.30000138e-01f, 9.19350088e-02f, -1.26492381e-01f, 1.26457512e-01f, 1.78858221e-01f, -1.52357906e-01f, -6.06940687e-02f,
  -1.43606186e-01f, 2.42440507e-01f, 8.29979256e-02f, -1.32393479e-01f, 7.51808938e-03f, 1.13258079e-01f, -7.64254108e-02f, 2.50315577e-01f, -2.31499821e-02f, -1.91378981e-01f,
  -9.29871872e-02f, -1.41425148e-01f, 2.18778715e-01f, 4.21660021e-02f, 1.60123389e-02f, 2.57243961e-02f, -2.20012635e-01f, -4.15176541e-01f, 3.40194292e-02f, 2.38123044e-01f,
  5.07867932e-02f, -3.90848160e-01f, -5.16967118e-01f, 2.46830191e-03f, 1.90406770e-01f, -2.08163410e-02f, 4.29599166e-01f, 1.75347865e-01f, 2.04996899e-01f, -7.42545053e-02f,
  1.06867063e+00f, 8.33198309e-01f, 4.24559712e-01f, 5.55037677e-01f, 3.28440219e-01f, 2.58797258e-01f, 3.73143584e-01f, 7.40795285e-02f, 2.40350123e-02f, 3.11743438e-01f,
  2.04805940e-01f, -1.60534435e-03f, 9.53433216e-02f, -6.20215423e-02f, 1.25056237e-01f, 2.33520358e-03f, 6.74762577e-02f, 1.30623236e-01f, -1.33874089e-01f, 1.28009081e-01f,
  6.22782484e-02f, 2.20872425e-02f, -1.30010420e-04f, 8.94213170e-02f, 2.81787127e-01f, 1.47734404e-01f, 1.33768156e-01f, 2.68816054e-01f, 2.20992282e-01f, 5.01094162e-01f,
  4.60634589e-01f, 7.34345496e-01f, -3.97016317e-01f, -2.14155763e-01f, -7.26932101e-03f, -2.64191777e-01f, -1.45289987e-01f, -2.61127293e-01f, 2.81180516e-02f, -1.32320011e-02f,
  -7.48141408e-02f, -3.50172147e-02f, 2.25213692e-01f, -1.43823534e-01f, -1.15402453e-01f, -1.02357820e-01f, -5.30605838e-02f, 1.14980750e-01f, 8.15620832e-03f, -1.15972832e-01f,
  8.66916254e-02f, 1.34573683e-01f, -1.32755697e-01f, -6.78401589e-02f, 1.99580073e-01f, -9.05292407e-02f, 1.32726923e-01f, 1.95669562e-01f, -1.37574077e-01f, 1.88816965e-01f,
  6.61228448e-02f, 2.16535091e-01f, 3.04067999e-01f, -8.31102207e-03f, 1.68688968e-01f, 1.37191460e-01f, -1.60406735e-02f, -2.63251215e-02f, 2.63639957e-01f, 5.74115515e-02f,
  -7.07110912e-02f, 2.11955644e-02f, 4.16719727e-02f, -7.09828064e-02f, 6.61634468e-03f, -3.73357683e-02f, 3.97783816e-02f, -4.20542657e-02f, 1.56260319e-02f, -1.55596137e-01f,
  1.27209872e-01f, -1.57913432e-01f, -9.29936096e-02f, 3.47302966e-02f, -1.17194153e-01f, 2.20292926e-01f, 5.42396717e-02f, -9.44892690e-02f, -1.54875398e-01f, -5.98958647e-03f,
  -1.02895021e+00f, 1.68581590e-01f, 1.49933502e-01f, 5.19472174e-03f, 1.63920105e-01f, 2.86731776e-02f, 4.13630217e-01f, -8.14640447e-02f, -2.52614412e-02f, -6.76160827e-02f,
  -2.74435710e-02f, 3.90966050e-02f, 2.30908245e-01f, 3.21501028e-03f, -2.28541166e-01f, -3.12363356e-01f, -1.92737475e-01f, -9.35067714e-04f, -1.73896313e-01f, -1.23441108e-01f,
  -6.50606006e-02f, -3.61405700e-01f, -3.40058923e-01f, -2.66205281e-01f, -9.97609869e-02f, -2.94945002e-01f, -2.57791400e-01f, -3.23924065e-01f, -4.02456582e-01f, -3.63112986e-01f,
  1.42607653e+00f, -1.19491172e+00f, 1.21907628e+00f, 1.10741727e-01f, -1.79091096e-01f, 6.69153854e-02f, -5.67762256e-01f, -2.30029181e-01f, 4.43557166e-02f, -2.24881783e-01f,
  -7.54514277e-01f, -3.96008134e-01f, -9.22074094e-02f, -5.44783063e-02f, 2.44387016e-01f, -7.76429698e-02f, 3.43699485e-01f, 8.01013887e-01f, 9.99646902e-01f, 1.23023905e-01f,
  -4.03843105e-01f, 2.27239281e-01f, 5.03720820e-01f, 2.21945420e-01f, -2.25115716e-01f, 1.83284372e-01f, 1.27336159e-01f, -2.57959306e-01f, -4.04774725e-01f, -2.32869729e-01f,
  7.14717954e-02f, -3.67175668e-01f, 5.37397861e-01f, -1.68950990e-01f, -4.53004166e-02f, 6.02921620e-02f, -1.90539695e-02f, 1.69115961e-02f, -2.10142627e-01f, 6.02125973e-02f,
  -2.20495492e-01f, -1.96482658e-01f, -9.41619426e-02f, -9.43020135e-02f, 2.69156359e-02f, 3.27952914e-02f, 5.87176383e-02f, 2.35938430e-01f, 1.04753755e-01f, -1.17966972e-01f,
  -4.68966514e-01f, -1.43795073e-01f, 1.38344273e-01f, 1.21632829e-01f, -1.90150756e-02f, 2.52840549e-01f, -1.70045197e-01f, -4.57067154e-02f, 1.57876730e-01f, 8.86622146e-02f,
  1.45216763e-03f, 8.50059465e-02f, -1.94163062e-02f, 1.15469113e-01f, 9.24440622e-02f, 4.10245135e-02f, 2.16045424e-01f, 4.59450893e-02f, 7.64454305e-02f, -3.29424478e-02f,
  2.96592731e-02f, 6.11633919e-02f, 3.46563943e-02f, 1.29227683e-01f, -9.99105573e-02f, -4.23826724e-02f, 5.78909367e-02f, -1.31676719e-01f, 8.17968696e-03f, -7.63657391e-02f,
  -2.67817080e-03f, 6.33499995e-02f, 2.98281424e-02f, -8.18166509e-02f, -2.36407831e-01f, 1.24749154e-01f, 7.64021501e-02f, -1.24139979e-01f, -8.97625610e-02f, -1.72703385e-01f,
  -2.46476918e-01f, 2.41183475e-01f, 1.67767793e-01f, -4.32651937e-02f, 5.08324876e-02f, -1.35842860e-01f, -2.67739110e-02f, 1.96785834e-02f, -1.85133532e-01f, 1.03811128e-02f,
  -7.39146769e-02f, 3.41171362e-02f, -8.55703726e-02f, -4.00956534e-02f, 1.22390883e-02f, -5.06173307e-03f, -2.88993001e-01f, -4.84056622e-02f, -6.45383596e-02f, -2.21488401e-01f,
  -2.34020844e-01f, 3.12013086e-02f, 2.44458899e-01f, 1.13874368e-01f, -1.17477335e-01f, 2.97002882e-01f, 8.46477970e-03f, -2.06491146e-02f, 2.54379869e-01f, 8.87754634e-02f,
  -1.44095826e+00f, 8.72921497e-02f, 1.01810560e-01f, -4.10732180e-01f, 1.32063210e+00f, 3.20471138e-01f, -3.18571508e-01f, -6.52963161e-01f, -4.26052868e-01f, -3.78133416e-01f,
  7.78981268e-01f, 1.56577140e-01f, -2.83943921e-01f, -2.84926116e-01f, -6.75028443e-01f, -6.41653359e-01f, 8.91950577e-02f, -2.20104247e-01f, -4.41037826e-02f, 4.81555015e-01f,
  4.02962893e-01f, 6.81757182e-02f, -2.17191815e-01f, -9.05968919e-02f, 5.17824385e-03f, -1.04948856e-01f, 2.66503990e-01f, 2.14892000e-01f, 1.08973883e-01f, -5.37890196e-01f,
  -3.30333740e-01f, -2.75623441e-01f, 1.81635648e-01f, 1.15626514e-01f, 7.63354421e-01f, -4.65182692e-01f, -3.50907117e-01f, -1.82030961e-01f, 1.15616925e-01f, 5.29993474e-02f,
  5.27241945e-01f, 4.31383997e-02f, 5.83092749e-01f, -4.47394587e-02f, -4.45709191e-02f, -4.69036430e-01f, -1.66709274e-02f, -4.95635420e-01f, -7.29131937e-01f, -1.82627782e-01f,
  5.21934152e-01f, 7.86522508e-01f, 3.13271344e-01f, 1.16261236e-01f, -6.20288491e-01f, 2.22225010e-01f, 2.39933997e-01f, -4.37625349e-01f, -2.63526946e-01f, -9.12991703e-01f,
  1.17743760e-01f, 1.38103172e-01f, 1.12722889e-02f, -8.45923871e-02f, -8.96657929e-02f, 1.01193525e-01f, 1.38462842e-01f, 1.29438326e-01f, 1.62910447e-01f, -1.61758065e-01f,
  1.58935189e-01f, 1.57066807e-01f, 8.69855657e-02f, 3.66448350e-02f, -2.91179144e-03f, -1.15402482e-01f, 3.05282809e-02f, -1.78647727e-01f, 4.78863679e-02f, -1.07669882e-01f,
  1.44729227e-01f, 7.41826594e-02f, -3.76123823e-02f, -1.32610388e-02f, -1.44529240e-02f, 4.62843403e-02f, -1.03239924e-01f, -6.82691336e-02f, -1.11521363e-01f, -1.32913679e-01f,
  -7.14321673e-01f, 8.45007837e-01f, -7.99178421e-01f, 6.20965399e-02f, -2.56249815e-01f, 1.65814087e-01f, 1.75353616e-01f, 4.11074162e-02f, 2.00622201e-01f, -2.86928982e-01f,
  -1.24348402e-01f, -5.30507937e-02f, -2.45577484e-01f, 6.63533881e-02f, 3.54318283e-02f, -2.11116761e-01f, -1.68252304e-01f, -1.41308680e-01f, -6.32420108e-02f, 1.55957982e-01f,
  -2.51765341e-01f, -2.60623544e-01f, -6.89686000e-01f, -8.08569729e-01f, -1.34629300e-02f, -2.72466362e-01f, -4.90719914e-01f, -5.24943233e-01f, -6.05809033e-01f, -1.18875349e+00f,
  1.80880153e+00f, -5.43219388e-01f, -2.24996066e+00f, -1.20207652e-01f, -1.26316476e+00f, -9.19316173e-01f, -6.69818282e-01f, 3.27699184e-01f, 4.60969001e-01f, -3.54904473e-01f,
  5.81853129e-02f, 6.10460341e-01f, -1.15386441e-01f, 3.32368851e-01f, 5.74073493e-01f, -9.54453826e-01f, -1.17954469e+00f, -7.59731114e-01f, -6.28775358e-02f, 4.33490992e-01f,
  4.11934972e-01f, 1.69798449e-01f, 1.73390850e-01f, 5.13454378e-02f, -5.35421431e-01f, -1.70756668e-01f, -1.30992603e+00f, -6.55253589e-01f, -5.58042169e-01f, -1.08548474e+00f,
  -1.50223160e+00f, -6.00658119e-01f, -4.59746346e-02f, 4.30299401e-01f, -4.72759128e-01f, 8.91153440e-02f, -3.25354338e-02f, -2.99949259e-01f, 9.48845446e-02f, -1.90353394e-01f,
  -2.82854527e-01f, 9.94938836e-02f, 2.12022394e-01f, -2.76343852e-01f, -1.86200842e-01f, -1.43712714e-01f, -1.69520169e-01f, -3.55362296e-01f, -2.60956675e-01f, -1.31369919e-01f,
  8.47350955e-02f, -3.06680292e-01f, -4.98195529e-01f, -1.92165419e-01f, -6.43712655e-02f, -3.25470865e-01f, -7.99274564e-01f, -3.62003326e-01f, -5.12853086e-01f, -2.20094264e-01f,
  -3.17578763e-02f, -1.11176081e-01f, -8.45807940e-02f, 2.13447273e-01f, 4.02204305e-01f, 3.04573439e-02f, -2.07655299e-02f, 7.26126879e-02f, -1.40373865e-02f, -1.32559827e-02f,
  -9.47584286e-02f, -1.29748330e-01f, -1.21476902e-02f, 7.06499070e-02f, -1.89613581e-01f, 6.16806708e-02f, 7.56540373e-02f, 1.85357649e-02f, -2.28870120e-02f, 5.31908758e-02f,
  -1.13125741e-01f, -2.34148711e-01f, -8.10057819e-02f, 8.42735991e-02f, -1.04958117e-01f, -1.35932922e-01f, 2.74155810e-02f, 1.97507083e-01f, 2.56672055e-01f, -1.86208542e-02f,
  8.32453191e-01f, -1.54796571e-01f, 2.48672724e-01f, 3.33407283e-01f, -2.64945656e-01f, 2.09564972e-03f, -1.61310002e-01f, 1.85726419e-01f, 5.67585304e-02f, 8.70768800e-02f,
  -4.59238216e-02f, 1.83922917e-01f, -2.39012778e-01f, -1.40023902e-01f, 2.32299156e-02f, -5.03549352e-02f, 2.43871093e-01f, -6.69351295e-02f, 1.43963799e-01f, 3.03853899e-02f,
  1.82318628e-01f, 1.84510455e-01f, 6.16327465e-01f, 3.29233170e-01f, 2.96581686e-01f, 3.49099994e-01f, -3.31065238e-01f, -3.46092135e-01f, 2.63003320e-01f, 6.10229254e-01f,
  -4.31571275e-01f, 1.74925193e-01f, -3.95717382e-01f, 1.69838965e-01f, 8.44888911e-02f, -7.12200642e-01f, -5.55415452e-01f, -6.32604122e-01f, -4.43251103e-01f, 1.96851164e-01f,
  9.52760354e-02f, 3.70361149e-01f, 1.07537284e-02f, 1.18087292e-01f, -3.88849616e-01f, -1.22516051e-01f, -2.29492515e-01f, -3.26928914e-01f, -2.60593474e-01f, 2.38396317e-01f,
  6.12338901e-01f, 7.06304133e-01f, 1.73708543e-01f, -2.24117532e-01f, 5.11085808e-01f, 3.20267618e-01f, -2.49885637e-02f, 1.76700577e-01f, 4.51080278e-02f, 7.14241147e-01f,
  8.51685643e-01f, -2.50383139e-01f, 2.85394769e-02f, 1.67510435e-02f, 3.16934049e-01f, 4.68740333e-03f, 1.45571440e-01f, 7.20075518e-02f, -4.30354960e-02f, -7.87628666e-02f,
  8.40104818e-02f, 7.65719861e-02f, -1.49975687e-01f, 1.96160898e-01f, 1.99503988e-01f, 1.41513288e-01f, -1.66185796e-01f, -1.30140677e-01f, -2.72632450e-01f, 1.36427760e-01f,
  1.93158597e-01f, 2.51360033e-02f, -4.50657487e-01f, -3.61131340e-01f, -4.94576335e-01f, -2.06533968e-01f, -8.46867859e-02f, -8.87850374e-02f, -5.26843071e-01f, 3.07020903e-01f,
  9.84682292e-02f, -9.67261642e-02f, 9.70825702e-02f, 1.55055121e-01f, 1.01514459e-01f, -1.07109047e-01f, 3.59477699e-02f, 7.38481581e-02f, -1.51731923e-01f, -3.28809433e-02f,
  -6.94695115e-02f, 3.73731144e-02f, -8.66006594e-03f, -5.69058284e-02f, 4.66402434e-02f, 8.29027966e-02f, -3.12188249e-02f, 1.12990784e-02f, -7.08618462e-02f, -5.11769764e-02f,
  3.87385907e-03f, -1.69747978e-01f, 1.22987404e-01f, 1.29151955e-01f, 3.74953896e-02f, -7.43658617e-02f, 5.43838590e-02f, -1.32390866e-02f, -8.95111784e-02f, -6.77788705e-02f,
  4.16770786e-01f, -7.48808563e-01f, 5.15988052e-01f, -9.03448239e-02f, 4.71591055e-02f, -1.04876556e-01f, 1.33771092e-01f, 1.18506193e-01f, -2.67485920e-02f, -4.23138216e-02f,
  -1.30943641e-01f, -1.58002824e-01f, 1.35682048e-02f, 4.01152029e-05f, 7.79979751e-02f, -2.85201408e-02f, 1.06960759e-01f, 8.37208182e-02f, -1.56938836e-01f, 2.57386006e-02f,
  -1.44188881e-01f, -1.32416755e-01f, -1.62540041e-02f, -1.85185224e-02f, -2.93130428e-02f, -1.32494926e-01f, 2.91708678e-01f, 2.41106078e-01f, -1.85406074e-01f, 4.33139145e-01f,
  7.98350692e-01f, 3.44925314e-01f, 9.23509225e-02f, 9.80004668e-01f, -5.03201723e-01f, -1.16926479e+00f, -1.35445404e+00f, -3.49803001e-01f, 7.10688949e-01f, 3.40988278e-01f,
  -5.65207720e-01f, -2.52316386e-01f, 3.00816834e-01f, -3.34507763e-01f, -7.13557005e-01f, -3.18613760e-02f, 4.17678058e-01f, -9.94029194e-02f, -9.93134439e-01f, -1.15867460e+00f,
  -4.32101250e-01f, 2.09528103e-01f, 3.54628742e-01f, -1.41297683e-01f, 4.75621194e-01f, 7.16642812e-02f, 6.71497822e-01f, 3.90720785e-01f, -1.90046296e-01f, 9.96084690e-01f,
  -6.40818551e-02f, 3.72364879e-01f, -6.42052889e-01f, 2.08644122e-02f, 5.81891462e-03f, -7.81300012e-03f, -3.17258418e-01f, 3.57636511e-01f, -4.85603139e-02f, 2.86025167e-01f,
  -3.63363400e-02f, 7.91575015e-02f, -1.95057780e-01f, -2.46990725e-01f, -1.54994458e-01f, -3.18649322e-01f, 1.82271257e-01f, 7.50910938e-02f, 1.54497012e-01f, -8.63221288e-02f,
  -3.50829124e-01f, -3.09138983e-01f, -9.64235216e-02f, -2.43598774e-01f, -1.70694038e-01f, -7.20994174e-02f, -2.71267235e-01f, -2.86475956e-01f, -3.11148018e-01f, 6.96028709e-01f,
  1.04413144e-02f, 3.19108628e-02f, -9.86550748e-02f, 1.38447508e-01f, -6.49652407e-02f, -2.11097933e-02f, 2.24847496e-01f, -6.40770495e-02f, -4.46327291e-02f, -3.67299579e-02f,
  6.60952926e-02f, -2.77059264e-02f, 1.29325897e-01f, 1.76281333e-02f, 1.16871923e-01f, 1.08782277e-01f, -1.19388886e-01f, 3.16083580e-02f, 7.09474534e-02f, 9.71099064e-02f,
  -1.29760250e-01f, -6.02560565e-02f, -1.83173288e-02f, -1.26417100e-01f, -6.75724223e-02f, 2.83658858e-02f, 3.32911201e-02f, -8.45567286e-02f, 1.36348307e-01f, 2.71363445e-02f,
  9.84697714e-02f, -6.46312952e-01f, 3.59387308e-01f, -1.49981156e-01f, 2.59538949e-01f, 7.92966336e-02f, 1.47991568e-01f, 3.12181134e-02f, 2.49021709e-01f, -4.24223617e-02f,
  -2.80330777e-01f, -6.54935241e-02f, 3.14417750e-01f, -1.57664828e-02f, -3.51155281e-01f, -1.71195716e-02f, -1.03211656e-01f, -2.55206347e-01f, -1.14495270e-01f, 1.78277016e-01f,
  1.51049063e-01f, -1.86025545e-01f, -1.96631461e-01f, -2.84623533e-01f, 1.82402730e-01f, -5.61001837e-01f, -1.74253151e-01f, -1.25208095e-01f, -5.13192475e-01f, 2.80151010e-01f,
  -1.41376472e+00f, 7.06684828e-01f, -4.65698689e-01f, -3.57207388e-01f, 1.67989895e-01f, 1.65059671e-01f, 7.28352845e-01f, 2.59849168e-02f, -6.78159446e-02f, 3.71400803e-01f,
  -8.73372331e-02f, -4.49263781e-01f, -1.11745849e-01f, 4.67987694e-02f, 1.44764706e-02f, 7.90599346e-01f, 7.90441811e-01f, -4.01115745e-01f, -7.82577991e-01f, -2.05026045e-01f,
  5.39296627e-01f, -7.08597898e-02f, -7.25620091e-01f, -3.53999525e-01f, 8.98639038e-02f, -2.53353994e-02f, 1.12247273e-01f, -2.37905949e-01f, 2.41359338e-01f, 5.89251041e-01f,
  -3.03092390e-01f, -6.00200355e-01f, 1.21917769e-01f, -1.09858498e-01f, -1.94828942e-01f, -2.71182712e-02f, -1.43094435e-01f, -3.07086408e-01f, -1.54063597e-01f, -5.55211212e-03f,
  -2.63025343e-01f, -7.52469003e-02f, -3.48448396e-01f, 1.12984125e-02f, -2.14283586e-01f, -8.02470669e-02f, -1.32757634e-01f, -2.92858720e-01f, -2.34777033e-01f, -1.35937184e-01f,
  3.91378045e-01f, -3.30233783e-01f, -4.99537140e-01f, 2.19084606e-01f, -1.11312196e-01f, -3.12107354e-01f, -2.23407000e-01f, -4.33077991e-01f, -3.12736809e-01f, -1.73883159e-02f,
  6.54869452e-02f, -2.06028186e-02f, 5.69272377e-02f, 6.94077760e-02f, 1.30422756e-01f, 5.29658161e-02f, 3.55549902e-02f, 5.42712174e-02f, 3.57883610e-02f, 1.07311783e-02f,
  -6.85579181e-02f, 1.08417906e-01f, -6.94075003e-02f, -4.98928018e-02f, -7.87051022e-02f, -9.60408524e-02f, 1.10740408e-01f, -2.00000685e-02f, -1.54072866e-02f, -2.18643937e-02f,
  -1.19501956e-01f, 9.67993587e-02f, 1.15205785e-02f, -2.42529884e-02f, 9.75950956e-02f, -1.19688995e-01f, 5.35347546e-03f, -1.53820559e-01f, -5.32129556e-02f, -1.52162916e-03f,
  3.21255744e-01f, 7.38381520e-02f, 5.30306734e-02f, -5.58463149e-02f, 2.43785325e-02f, -4.16634418e-02f, -4.17866893e-02f, 1.25531301e-01f, -8.90277047e-03f, -1.51241850e-02f,
  -1.03621006e-01f, -2.40857944e-01f, 2.14175992e-02f, 2.84275208e-02f, -6.72168359e-02f, -8.40254053e-02f, 2.69245654e-01f, 7.51847923e-02f, 1.83899328e-01f, 4.38793842e-03f,
  2.39869446e-01f, 2.65593261e-01f, 1.57681897e-01f, 2.80847490e-01f, 1.42553195e-01f, 6.26010001e-02f, 5.73708937e-02f, 1.55487955e-01f, 1.35741696e-01f, 9.11657810e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.12646043e+00f, 1.02187359e+00f, 1.64087939e+00f, 1.66636419e+00f, 5.19794464e-01f, 1.29893768e+00f, 1.13783944e+00f, 1.65706551e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -3.74647945e-01f, 2.97341198e-01f, -1.22075176e+00f, 1.16453752e-01f, -4.31754619e-01f, 1.07111014e-01f, -4.96527493e-01f, -5.26345372e-01f, 2.48559609e-01f, -1.04205477e+00f,
  -1.57176876e+00f, 3.88160646e-01f, 6.39845967e-01f, -3.46992731e-01f, -1.56354702e+00f, -1.60361874e+00f, -3.49025309e-01f, 3.17287087e-01f, 3.44717652e-02f, 1.19649759e-02f,
  -6.16050363e-01f, -1.63073882e-01f, -3.60176504e-01f, -1.38868165e+00f, -2.16240704e-01f, 5.51847100e-01f, 7.13496566e-01f, -2.01634216e+00f, 9.29669797e-01f, -1.25592887e+00f,
  -1.59869504e+00f, -1.88398552e+00f, 2.41132211e-02f, 3.61625373e-01f, 2.13144049e-01f, -1.93131924e-01f, -6.23595655e-01f, -5.54052651e-01f, -4.37420666e-01f, -1.23924470e+00f,
  -3.92548144e-01f, -1.38410115e+00f, 6.99806809e-01f, 1.17268193e+00f, -1.21748567e+00f, -1.23615158e+00f, 4.71621454e-01f, -1.17737401e+00f, -4.53031033e-01f, -1.68516681e-01f,
  7.06028759e-01f, -1.19616240e-01f, 3.94653559e-01f, -2.10384950e-02f, 4.62175965e-01f, 2.19030455e-01f, 6.87193215e-01f, -9.46405888e-01f, -1.15187883e+00f, 6.15514576e-01f,
  -5.75072885e-01f, -2.22897863e+00f, -1.64479876e+00f, 1.07055891e+00f, -9.23810378e-02f, -8.40358138e-01f, 7.07403183e-01f, -3.50534767e-01f, 4.64474171e-01f, 5.24547603e-03f,
  -1.30121499e-01f, 3.08016449e-01f, 6.92387938e-01f, -4.63923246e-01f, -1.90497470e+00f, 1.23289287e-01f, -5.28636336e-01f, -4.37361091e-01f, 1.23225594e+00f, -9.49701130e-01f,
  -9.19027068e-03f, 2.88323790e-01f, 4.34847891e-01f, 3.73238325e-01f, -1.07893097e+00f, 6.83197856e-01f, -2.00371072e-01f, 1.39270127e+00f, -7.23816454e-01f, -2.06616431e-01f,
  -8.81873727e-01f, -1.35227275e+00f, 6.35619164e-01f, 4.30628240e-01f, 5.50907440e-02f, 6.70908570e-01f, 4.76060480e-01f, 3.42045277e-02f, -4.79598403e-01f, 5.86084306e-01f,
  3.07921588e-01f, 5.92288911e-01f, -7.79869497e-01f, 9.70387459e-01f, -9.91657615e-01f, 1.24081738e-01f, 7.11332336e-02f, -1.67197621e+00f, -1.55429053e+00f, 2.96129495e-01f,
  1.14696920e+00f, -1.97120094e+00f, 1.68824792e-01f, -3.36850107e-01f, -2.08022445e-01f, -2.50680208e-01f, -1.61877692e-01f, -4.04814035e-02f, 2.42650315e-01f, -6.67300522e-01f,
  -1.64760089e+00f, 1.65874183e-01f, -1.59923494e+00f, 3.32693249e-01f, -1.25860453e+00f, -5.26636779e-01f, -2.06097096e-01f, 1.66261315e+00f, 4.46125150e-01f, -6.20621502e-01f,
  -5.30919731e-01f, 2.02026680e-01f, 1.20841049e-01f, 4.45542783e-01f, 4.82709110e-01f, 7.53294468e-01f, -9.74616528e-01f, -7.25601912e-01f, 1.54839587e+00f, -5.37934184e-01f,
  -6.23005569e-01f, -6.81908369e-01f, -2.06294823e+00f, 3.73191208e-01f, 1.60687545e-03f, -3.68521482e-01f, 1.02360155e-02f, 1.84184741e-02f, -1.15297250e-01f, -6.62288964e-01f,
  -4.01945859e-01f, -3.88498962e-01f, -1.77586699e+00f, -1.95660248e-01f, -1.52932119e+00f, 7.83272088e-01f, -6.15937829e-01f, 1.36068869e+00f, 7.22730875e-01f, -7.81364441e-01f,
  2.41791695e-01f, 1.77950412e-01f, -2.45243073e-01f, -4.76698995e-01f, -6.80102557e-02f, -5.52456677e-01f, 5.46641886e-01f, -2.82127827e-01f, 5.56130528e-01f, -1.11297143e+00f,
  -7.08782911e-01f, -1.42350328e+00f, -5.07401466e-01f, 9.40301776e-01f, -1.83890986e+00f, 6.12575293e-01f, -1.09402800e+00f, 4.42685843e-01f, 6.13301277e-01f, -8.03673446e-01f,
  1.09147584e+00f, 1.35818675e-01f, 7.20354378e-01f, 1.20034325e+00f, -8.79876435e-01f, 5.51777124e-01f, -7.26773202e-01f, 8.93193305e-01f, -1.18864548e+00f, -2.35816979e+00f,
  -1.86056361e-01f, -9.02665377e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  6.58326223e-02f, 7.62820840e-01f, 1.23466499e-01f, -1.28690112e+00f, 3.64629567e-01f, 3.61978173e-01f, -2.66107947e-01f, 2.74058580e-01f, -2.98370898e-01f, -8.75013709e-01f,
  -1.27250504e+00f, 3.63595694e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    