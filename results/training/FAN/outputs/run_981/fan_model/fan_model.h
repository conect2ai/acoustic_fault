/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.00413835e+00f, -2.91293353e-01f, 5.95816374e-01f, 1.38507023e-01f, -5.24230480e-01f, -1.66748255e-01f, -2.79929757e-01f, 3.87322865e-02f, 1.50203660e-01f, -9.26549882e-02f,
  -1.74850494e-01f, -8.55920166e-02f, 1.51359648e-01f, -9.57172737e-02f, 1.59962073e-01f, -1.09204255e-01f, 5.54056577e-02f, 2.99543649e-01f, 2.41477251e-01f, -4.12771255e-01f,
  -4.08105880e-01f, 5.12833185e-02f, 2.85265148e-01f, 1.68639243e-01f, -2.11209357e-01f, -2.28833243e-01f, 1.09104685e-01f, -4.54718918e-02f, -2.80669510e-01f, -8.77182873e-04f,
  1.45337582e-01f, 1.76848277e-01f, -3.05610131e-02f, -1.57952875e-01f, -9.61451083e-02f, -1.20969769e-02f, -6.31097779e-02f, 6.58190995e-02f, -9.23479944e-02f, 1.73896290e-02f,
  -1.12062335e-01f, -6.46584900e-03f, 2.86893696e-02f, -5.80759160e-02f, 3.76168601e-02f, -3.66333202e-02f, 7.21616372e-02f, 1.65283099e-01f, 1.44643128e-01f, -1.17239691e-01f,
  -2.60370612e-01f, -7.05094486e-02f, 1.26444787e-01f, -2.01840550e-02f, 1.69106469e-01f, 4.03628387e-02f, -6.65475577e-02f, 1.08105978e-02f, 1.14689268e-01f, -7.05125704e-02f,
  -1.15270950e-01f, -2.16966844e-03f, -6.17744289e-02f, -1.73454974e-02f, -2.19528936e-02f, -2.98816804e-02f, 2.36786064e-02f, -3.10976077e-02f, -5.54016838e-03f, -6.20917492e-02f,
  8.05245042e-02f, 4.43292054e-04f, 1.88076161e-02f, 6.00479823e-03f, -4.69909497e-02f, 2.93388143e-02f, 9.40077100e-03f, -4.61612977e-02f, 1.69851575e-02f, 1.77821238e-02f,
  1.69275403e-02f, -1.31017966e-02f, 7.63633172e-04f, 5.00864536e-03f, -9.18187294e-03f, 1.28019974e-01f, 8.42331722e-03f, -4.60856892e-02f, 1.02873170e-03f, -4.56866063e-02f,
  5.97065547e-03f, 9.31712389e-02f, -1.47175472e-02f, 2.45429724e-02f, -1.01764454e-02f, 1.50561891e-02f, -3.17662321e-02f, 3.80527275e-03f, 2.66852491e-02f, 5.05329557e-02f,
  -3.33213694e-02f, 3.60607579e-02f, 5.28874062e-02f, 4.24978463e-03f, -8.13003629e-02f, -2.65856665e-02f, -8.76038671e-02f, -2.94664949e-02f, -6.17636479e-02f, -1.24084335e-02f,
  8.84671044e-03f, -1.68200936e-02f, -8.24157968e-02f, 9.03835893e-03f, -1.23502113e-01f, -3.10966801e-02f, -1.38689831e-01f, -1.49612442e-01f, 1.51119428e-03f, -2.17922732e-01f,
  1.60094246e-01f, -3.58425856e-01f, 1.67230722e-02f, -3.60276885e-02f, 3.52008939e-01f, 4.22360241e-01f, 2.98383862e-01f, 1.41373158e-01f, 1.49286225e-01f, 5.81913814e-02f,
  1.04367644e-01f, 9.19911414e-02f, -1.02085650e-01f, -1.07062459e-01f, -1.96740329e-01f, -4.72925492e-02f, -1.05079181e-01f, -3.21528792e-01f, 9.24427882e-02f, 1.85986996e-01f,
  -1.06943427e-02f, -6.74383193e-02f, -3.11356246e-01f, -2.86421448e-01f, -1.83416933e-01f, 1.40705347e-01f, -1.67270571e-01f, 6.01931661e-03f, -8.23325589e-02f, -6.08707786e-01f,
  -6.04388043e-02f, -1.14511885e-01f, -1.55422464e-02f, -8.06419626e-02f, -8.59090984e-02f, -1.13114461e-01f, 1.14313385e-03f, -1.33528411e-01f, -3.50969695e-02f, -9.33584571e-02f,
  -1.29499510e-01f, -5.32030277e-02f, -1.28813908e-01f, -2.38716844e-02f, -5.40122762e-02f, -8.69733375e-03f, -2.01608583e-01f, -2.71179318e-01f, -1.55292228e-01f, -1.47022173e-01f,
  -2.04437375e-01f, -1.59879476e-01f, -9.39773917e-02f, -1.40977427e-01f, -1.61597326e-01f, -3.68413515e-02f, -2.07596093e-01f, -2.06560060e-01f, -1.13516398e-01f, -1.67405173e-01f,
  -8.12826753e-02f, 1.22228805e-02f, 4.25528958e-02f, 6.80292072e-03f, 6.13499880e-02f, -2.04625586e-03f, 1.95343122e-02f, 4.99730855e-02f, 3.27596301e-03f, -5.46102412e-03f,
  -8.65852460e-03f, 6.34872466e-02f, 1.95967369e-02f, 9.06594470e-02f, 6.07824000e-03f, -3.27356383e-02f, 1.17163889e-01f, -3.14076878e-02f, 2.04237964e-04f, 8.96691680e-02f,
  5.04257530e-02f, 4.34714369e-02f, 5.21859201e-03f, 1.73954479e-02f, -2.33553164e-03f, -2.00978406e-02f, 5.42427525e-02f, -1.16167814e-02f, 1.68476701e-02f, 4.72204536e-02f,
  1.17462099e-01f, -2.99006924e-02f, 7.60805234e-02f, 4.57939655e-02f, 6.98008314e-02f, 2.55746339e-02f, 1.37920296e-02f, 2.50847638e-02f, 9.36122760e-02f, 6.41040429e-02f,
  -5.53780235e-03f, -1.00487219e-02f, -4.12975140e-02f, -3.89834866e-02f, 1.14627354e-01f, 3.24073732e-02f, 6.72676042e-02f, 1.11507982e-01f, 7.76347518e-02f, 5.25633805e-02f,
  1.83425434e-02f, 1.71155766e-01f, 1.61334783e-01f, 1.14352114e-01f, 1.30614951e-01f, 2.08980858e-01f, 1.45306259e-01f, 1.36810496e-01f, 1.68391854e-01f, 1.90268248e-01f,
  -1.39856175e-01f, -4.74576652e-01f, 4.02637571e-01f, 8.15957934e-02f, 4.11497429e-02f, -1.77610949e-01f, -5.48748434e-01f, -2.51798421e-01f, 2.51700342e-01f, -5.94098009e-02f,
  -3.04471076e-01f, -2.12175921e-02f, -3.74845415e-02f, -4.86703105e-02f, -1.49990126e-01f, -1.41037017e-01f, 2.56894976e-01f, 3.37875009e-01f, 1.75105542e-01f, -8.14845040e-02f,
  -6.32975101e-02f, 1.22472517e-01f, 1.84906572e-01f, 1.68099608e-02f, 2.03256249e-01f, 1.99676216e-01f, 4.13544141e-02f, 6.18166588e-02f, -1.16377421e-01f, 7.10928917e-01f,
  2.16934159e-02f, -1.61953196e-01f, 4.32482734e-02f, -1.30485334e-02f, 6.06968962e-02f, 3.66273932e-02f, -2.72697452e-02f, 1.19231507e-01f, -6.78756684e-02f, 9.78934616e-02f,
  5.84614947e-02f, 3.67022566e-02f, 7.20766187e-02f, 5.97213060e-02f, 5.40955365e-02f, 1.39713148e-02f, 4.28705104e-03f, 1.59438960e-02f, 4.05443460e-02f, -1.40792117e-01f,
  -4.58386838e-02f, -2.80045737e-02f, 6.24479773e-03f, -1.06394850e-01f, -1.68577299e-01f, 1.14890777e-01f, -6.90257251e-02f, 1.06793955e-01f, -2.15424672e-02f, 1.05569169e-01f,
  4.15972546e-02f, 2.65967436e-02f, 2.32251957e-02f, 9.92273912e-03f, -6.90838322e-02f, 6.36511073e-02f, 2.04828028e-02f, -8.64519924e-03f, 1.97448749e-02f, 1.92250255e-02f,
  -4.11868133e-02f, 1.35789420e-02f, -1.75874233e-02f, -3.90670747e-02f, 4.80698794e-02f, 2.34164968e-02f, 3.97248939e-03f, 6.33788928e-02f, -3.11156996e-02f, 6.87771887e-02f,
  -4.61031049e-02f, -6.81947544e-03f, -2.98010651e-02f, 4.39706072e-02f, -6.32607117e-02f, 1.61461253e-02f, 2.57164519e-02f, -8.11093599e-02f, 6.88746106e-03f, -2.28521973e-02f,
  -1.04562186e-01f, -3.91469859e-02f, 1.39829382e-01f, 1.71802193e-02f, 1.15569392e-02f, -1.78190377e-02f, 3.67164016e-02f, -6.46864297e-03f, -1.88663732e-02f, 9.48524475e-03f,
  -1.09422065e-01f, -4.63157706e-02f, -4.85496083e-03f, 3.75664681e-02f, 3.80145572e-02f, 2.60509998e-02f, -5.33914715e-02f, 3.98844369e-02f, 5.38769141e-02f, 5.74448071e-02f,
  -5.79140745e-02f, 4.14958596e-02f, -1.10577152e-03f, 1.83374304e-02f, -1.01013556e-02f, 6.65026456e-02f, 3.56320702e-02f, 7.02433242e-03f, -6.82972372e-02f, -1.64935187e-01f,
  -1.26965821e-01f, -1.20810747e-01f, -6.31569773e-02f, -6.20677881e-02f, -1.92394465e-01f, 1.67439014e-01f, 1.90052819e-02f, 1.58849850e-01f, 4.40131649e-02f, -1.52697265e-01f,
  -1.49313241e-01f, -6.86307177e-02f, 6.04564417e-03f, 2.15184182e-01f, 2.81485796e-01f, -8.20992440e-02f, -2.48411059e-01f, 1.12950392e-01f, 4.62721527e-01f, 2.85723567e-01f,
  -1.61864199e-02f, -1.30766720e-01f, -3.82087217e-03f, 1.38451725e-01f, -2.07719237e-01f, 1.45703048e-01f, -1.62650183e-01f, -1.93968251e-01f, -4.58452404e-02f, -4.74461555e-01f,
  -1.43250063e-01f, -2.12450311e-01f, 5.03907427e-02f, -5.94155453e-02f, -1.11719690e-01f, 6.70084953e-02f, 4.36404196e-04f, -5.34324385e-02f, -6.54056370e-02f, -9.53108165e-03f,
  -1.68691456e-01f, -4.18364890e-02f, -1.25717849e-01f, 4.52043861e-02f, -5.32542355e-02f, 6.28923252e-02f, -6.41814023e-02f, 1.78119261e-02f, 7.26844892e-02f, 2.21448876e-02f,
  -4.20020781e-02f, -1.93492219e-01f, -2.10967258e-01f, 9.02554113e-03f, 1.39905348e-01f, -1.07132025e-01f, -3.83022316e-02f, 1.14502937e-01f, 8.62099826e-02f, 6.70995489e-02f,
  5.27044572e-02f, 4.83307093e-02f, -2.60577127e-02f, 7.52547011e-03f, -4.41845916e-02f, 6.33524917e-03f, -2.25040298e-02f, -3.12479790e-02f, -5.51142283e-02f, 3.74044068e-02f,
  4.85916398e-02f, 3.95517573e-02f, 2.79574543e-02f, 7.09954184e-03f, 8.68723448e-03f, -2.99453400e-02f, -1.40382154e-02f, 5.45307137e-02f, -7.72469193e-02f, -1.32373208e-02f,
  2.55763121e-02f, -3.72128114e-02f, -5.11732846e-02f, 1.21415835e-02f, 3.30867805e-02f, 5.40378690e-02f, -5.49952388e-02f, 9.58726108e-02f, 4.11419906e-02f, -7.33902827e-02f,
  1.39107490e-02f, -1.70245357e-02f, -8.77265036e-02f, 5.65067120e-02f, -1.10037839e-02f, -1.89697444e-02f, -8.41640010e-02f, -2.52584368e-02f, -8.49088803e-02f, -4.63945046e-03f,
  3.82457227e-02f, 2.02830099e-02f, -2.23609190e-02f, 3.94161120e-02f, 1.08782826e-02f, -3.99623066e-02f, 2.40201596e-02f, 3.47102270e-03f, 3.94825041e-02f, -5.29712401e-02f,
  -1.64934453e-02f, 1.65350482e-01f, 1.01495661e-01f, 3.72303985e-02f, -2.50837225e-02f, 5.24441861e-02f, -6.61623082e-04f, 9.75684896e-02f, 9.01400372e-02f, 1.97331727e-01f,
  -3.81360769e-01f, 1.49533585e-01f, -3.26799661e-01f, 7.54195526e-02f, 7.31111169e-02f, -5.27484082e-02f, -1.70683905e-01f, 8.18302110e-02f, 1.14756651e-01f, -2.12061822e-01f,
  8.43009949e-02f, 5.05066887e-02f, -4.76329140e-02f, -4.63098846e-02f, 6.53821155e-02f, -3.97325277e-01f, -1.91741168e-01f, -1.95556685e-01f, 3.77138369e-02f, 7.16639310e-02f,
  5.40788695e-02f, 8.85686874e-02f, 9.96244475e-02f, 1.47688150e-01f, -1.27449870e-01f, -1.73293084e-01f, -1.70533881e-01f, 2.97507569e-02f, -2.39823833e-02f, -3.38445067e-01f,
  -4.87449974e-01f, 2.06418224e-02f, -1.09995663e-01f, 1.91269815e-02f, -6.39707893e-02f, -4.29191403e-02f, -1.21128149e-01f, -7.76462704e-02f, -1.00884475e-02f, -5.30948527e-02f,
  1.53622162e-02f, 2.09102817e-02f, -2.22776104e-02f, 8.92953761e-03f, 5.11362357e-03f, -2.93077528e-02f, -2.61920113e-02f, -5.29995635e-02f, 2.09509321e-02f, -9.80987772e-02f,
  1.63610689e-02f, 4.34328988e-02f, 3.80305760e-02f, 1.02252495e-02f, 1.11973271e-01f, 7.28048980e-02f, 4.95148525e-02f, 9.62033793e-02f, 1.30287752e-01f, -1.66911080e-01f,
  -3.21673118e-02f, 3.18521298e-02f, -1.38593437e-02f, -5.41021349e-03f, -1.32888213e-01f, -9.03037712e-02f, -4.86172363e-02f, -1.35022411e-02f, -2.48432625e-02f, -7.56818801e-03f,
  -1.97311062e-02f, -3.48578840e-02f, -4.16338369e-02f, -7.52582625e-02f, -2.48561036e-02f, -1.74043588e-02f, 7.13238120e-03f, -4.91962880e-02f, -5.21450154e-02f, -2.46762508e-03f,
  3.71592958e-03f, -1.61752570e-02f, 3.51698557e-03f, -8.40097852e-03f, 3.07947751e-02f, -1.01361193e-01f, 5.58413565e-03f, 1.90733653e-02f, -8.04129690e-02f, 3.41958925e-02f,
  -1.41712338e-01f, 6.49884492e-02f, -2.14064345e-01f, 7.98785780e-03f, -1.03259526e-01f, 4.93523777e-02f, -5.14266491e-02f, -5.41828126e-02f, -1.31112048e-02f, -1.09814696e-01f,
  4.40098420e-02f, -1.23729967e-01f, -1.01009600e-01f, -3.54624614e-02f, -4.77990769e-02f, -2.22924817e-02f, -1.88444015e-02f, -5.35037555e-02f, 4.57275547e-02f, 4.74910066e-02f,
  -1.60660017e-02f, -1.81114525e-02f, -1.22477226e-01f, -1.08570471e-01f, -4.65746634e-02f, -1.06147557e-01f, -1.52072176e-01f, -1.43463254e-01f, -2.53795702e-02f, -2.79577494e-01f,
  -1.08254147e+00f, -1.65081665e-01f, 4.80652183e-01f, -4.38750178e-01f, 2.30230168e-01f, 2.13295341e-01f, -6.92979097e-02f, -8.61089826e-02f, -1.31679609e-01f, -1.19387358e-01f,
  1.36356950e-01f, -1.77792478e-02f, 9.11758170e-02f, 8.73232037e-02f, 1.52679498e-03f, -1.78191178e-02f, -1.00071868e-03f, -1.88378443e-03f, 2.90601820e-01f, 9.74277779e-02f,
  7.43310526e-03f, -3.86742681e-01f, -2.79061824e-01f, -1.12876538e-02f, -1.83485731e-01f, 6.03682809e-02f, 2.67477147e-02f, -2.17356712e-01f, 1.70140505e-01f, -2.85362124e-01f,
  9.45303366e-02f, -6.69835955e-02f, 2.25781441e-01f, 2.55925674e-02f, 1.11211121e-01f, -4.65049744e-02f, 4.77800593e-02f, -4.55797948e-02f, 8.37482437e-02f, -1.63418427e-02f,
  1.88677907e-02f, 1.92719065e-02f, -6.40280321e-02f, 2.66030915e-02f, -9.31780887e-05f, 2.73727495e-02f, -2.30328776e-02f, -5.22640720e-02f, 4.78564985e-02f, 1.28885284e-01f,
  1.14550374e-01f, -1.34734362e-02f, 1.91594269e-02f, 1.80846110e-01f, 1.92304373e-01f, 1.13764487e-01f, 5.48512079e-02f, 7.17156380e-02f, 7.30914026e-02f, -2.47809961e-01f,
  -3.11226957e-02f, -7.02294856e-02f, -4.23969105e-02f, -4.76828255e-02f, -1.23520494e-02f, -3.16855498e-02f, 1.89185739e-02f, -2.60411296e-02f, -1.20556820e-02f, -4.80130985e-02f,
  9.00513900e-04f, 7.31430575e-02f, 5.73773030e-03f, -4.16292101e-02f, 3.55109274e-02f, -7.18714297e-02f, -6.34653354e-03f, 3.45892645e-03f, 7.94750601e-02f, -2.65064631e-02f,
  -2.77359132e-03f, -1.04255751e-02f, -5.21352421e-03f, -1.80467777e-02f, 1.42395832e-02f, 1.58513412e-02f, 7.37327104e-03f, -2.82101482e-02f, -7.92626143e-02f, -1.68359578e-02f,
  -1.37813464e-01f, 3.11759561e-01f, -1.25912368e-01f, 6.30876645e-02f, -3.78395687e-03f, 4.82745431e-02f, 2.05659680e-02f, 5.01811132e-02f, 4.26223017e-02f, -1.64585225e-02f,
  8.88029411e-02f, 1.86674893e-02f, 8.03522952e-03f, 9.22704116e-03f, 5.72317131e-02f, 9.56206992e-02f, -2.14031730e-02f, 1.42719988e-02f, 2.91968510e-02f, -4.40315530e-02f,
  6.65638447e-02f, -1.13242436e-02f, -8.94874707e-02f, 1.94702018e-02f, -1.64902061e-02f, -2.66245995e-02f, 8.49683061e-02f, 1.51615227e-02f, 7.29940012e-02f, -1.69434547e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.56765115e-01f, -4.53153253e-02f, 4.75714475e-01f, 7.21253902e-02f, 1.83660492e-01f, -3.33224893e-01f, -7.70641148e-01f, 2.29161754e-01f, 2.56626338e-01f, -1.82635419e-03f,
  1.39277175e-01f, 2.91364640e-01f, 2.98879355e-01f, 1.37451798e-01f, -6.47292912e-01f, -6.72070682e-01f, -6.32112384e-01f, -6.47448719e-01f, -3.26933324e-01f, -2.40470141e-01f,
  -3.64082158e-01f, -4.04016376e-01f, -3.00575495e-01f, -1.08723082e-01f, 1.86967030e-01f, 1.49120554e-01f, 1.75487190e-01f, 5.01099378e-02f, -3.39428872e-01f, -2.91577309e-01f,
  2.12997675e-01f, 9.96489599e-02f, -1.42154559e-01f, -2.28883356e-01f, 7.72981122e-02f, -1.02716938e-01f, -1.45317510e-01f, -2.25467086e-02f, 7.14760199e-02f, -1.96577925e-02f,
  7.71433413e-02f, -5.96288126e-03f, -4.12573386e-03f, 1.80297326e-02f, 6.05058251e-03f, -8.55857953e-02f, 8.85501355e-02f, -1.32602617e-01f, 8.36446211e-02f, 2.87147760e-01f,
  7.64067471e-02f, -2.45091781e-01f, 2.00867485e-02f, 1.43594921e-01f, -2.03203280e-02f, -1.47226527e-01f, 2.22977564e-01f, 1.21566191e-01f, 4.66195755e-02f, 2.05199420e-01f,
  -3.74320708e-02f, 1.16917327e-01f, 4.48933654e-02f, 8.24720878e-03f, -7.54126385e-02f, 2.29172446e-02f, -4.99240607e-02f, -5.53125441e-02f, -1.32067770e-01f, 3.12644169e-02f,
  4.43819771e-03f, 9.64546483e-03f, 8.15338194e-02f, -1.52458120e-02f, 4.40139808e-02f, 1.13345236e-02f, -1.04601018e-01f, 9.21525732e-02f, 5.56638427e-02f, -2.61536650e-02f,
  -1.16910739e-02f, -6.20876346e-03f, -6.11138791e-02f, 4.76804264e-02f, -7.36424252e-02f, 7.43943155e-02f, 2.62795743e-02f, -7.79975504e-02f, 2.80051120e-03f, -8.60119686e-02f,
  1.89776048e-01f, -3.75294328e-01f, -5.33232726e-02f, 3.83858681e-02f, -1.45237017e-02f, 2.31505409e-01f, 2.93546349e-01f, -8.74015242e-02f, 5.24616614e-02f, -1.81240067e-02f,
  -6.12366050e-02f, 7.45993573e-03f, -1.05965638e-03f, 2.72304914e-03f, -1.03144117e-01f, 7.22317323e-02f, -1.59135208e-01f, -6.31502420e-02f, -4.04043049e-02f, 1.91569433e-01f,
  1.91479083e-02f, -9.71692726e-02f, -1.32026047e-01f, 2.61021089e-02f, 1.79152772e-01f, -2.84626007e-01f, 2.25332990e-01f, 1.83052421e-01f, -1.83832839e-01f, -5.34962583e-03f,
  6.86385691e-01f, 1.06380977e-01f, 9.32357490e-01f, 6.93016171e-01f, 4.76663053e-01f, 7.09046602e-01f, 9.49990213e-01f, 3.97242576e-01f, 1.37075618e-01f, 2.01200619e-01f,
  -1.75505392e-02f, -2.45990798e-01f, -3.06921780e-01f, -2.74140477e-01f, 1.30425647e-01f, 3.72625470e-01f, 3.06965977e-01f, 1.03149667e-01f, 1.48106411e-01f, 6.65834248e-02f,
  -1.09195724e-01f, 3.86526994e-02f, -2.56495010e-02f, -3.26317325e-02f, 1.74399763e-01f, -8.36159587e-02f, 1.89166605e-01f, -1.76694337e-02f, -2.66178399e-01f, 1.39653925e-02f,
  8.27330444e-03f, 2.93908954e-01f, -2.61509772e-02f, -3.40736151e-01f, -5.44815883e-02f, -2.29692250e-01f, -1.08351223e-01f, -1.42442167e-01f, -2.94897199e-01f, -1.01347670e-01f,
  -5.84537983e-02f, -8.08815956e-02f, 6.64318055e-02f, 9.85548925e-03f, 6.27694130e-02f, -2.15561092e-02f, -5.66090196e-02f, 8.76769274e-02f, 9.48618352e-02f, 6.24766536e-02f,
  -5.59424013e-02f, 1.07345171e-01f, 1.86009288e-01f, 8.91656727e-02f, 2.20352903e-01f, -2.48400383e-02f, 1.05308212e-01f, 6.22982997e-03f, 2.00824901e-01f, 1.23016477e-01f,
  1.12162776e-01f, 2.36885529e-02f, 1.82644263e-01f, -1.60073978e-03f, 3.68358493e-02f, -7.62680173e-02f, 5.41433170e-02f, 4.01129089e-02f, 1.01012088e-01f, -5.65615036e-02f,
  -4.43084165e-02f, 7.46077895e-02f, -1.89194717e-02f, 9.97666195e-02f, -1.06411293e-01f, 1.77691072e-01f, 9.43755358e-02f, 4.51127440e-03f, -2.42512468e-02f, 2.03063246e-02f,
  5.24354074e-03f, -2.98785362e-02f, -4.22388092e-02f, 6.82726502e-02f, -1.30746827e-01f, 9.80168432e-02f, 3.87635827e-03f, -8.62514302e-02f, -4.76956833e-03f, -5.66027649e-02f,
  -3.67313802e-01f, 1.81844324e-01f, 3.62944640e-02f, 2.66664475e-02f, 7.23355412e-02f, -2.04514340e-01f, 1.01116158e-01f, 1.27522908e-02f, -1.88483089e-01f, -3.80927697e-02f,
  -3.79242399e-03f, -2.92382706e-02f, -1.45170307e-02f, -2.54076384e-02f, 1.62743144e-02f, -7.50352368e-02f, 1.25361979e-02f, 8.04344937e-02f, -2.26239804e-02f, -1.16865791e-01f,
  -6.62399903e-02f, 2.96685528e-02f, 2.27300916e-02f, 4.43389043e-02f, -1.38263941e-01f, -2.22193241e-01f, -1.86916009e-01f, -5.32331131e-02f, -1.91444494e-02f, -1.64615795e-01f,
  6.79339051e-01f, -8.63001466e-01f, -3.55867118e-01f, -1.81530908e-01f, -3.15294027e-01f, -7.33781382e-02f, -5.08258998e-01f, 2.75528058e-02f, 1.80985462e-02f, -4.68365580e-01f,
  6.83325678e-02f, 6.39531255e-01f, 4.02459741e-01f, 4.19594705e-01f, 3.82706970e-01f, -6.06579423e-01f, -6.18401289e-01f, 4.14842784e-01f, 8.13516915e-01f, 3.20486218e-01f,
  -4.57072891e-02f, -1.22940868e-01f, 2.03394756e-01f, 3.04976255e-01f, -4.41929638e-01f, 2.63370305e-01f, -3.24524462e-01f, -1.33421347e-01f, -9.45015550e-02f, -8.70818615e-01f,
  -2.57190932e-02f, -2.18229905e-01f, 2.60806382e-01f, 1.32887155e-01f, -9.39617604e-02f, -9.90454573e-03f, 4.92802635e-03f, -5.35326228e-02f, -1.93003621e-02f, -4.87979576e-02f,
  -6.27498282e-03f, 8.67212191e-03f, 7.66818374e-02f, 2.87058409e-02f, -8.26008841e-02f, -6.56200126e-02f, 5.80266938e-02f, 5.53572029e-02f, -5.02356701e-02f, -1.22924842e-01f,
  -1.13116920e-01f, -1.75029680e-01f, -6.57298192e-02f, 1.78293318e-01f, 2.44799122e-01f, 2.00101167e-01f, -3.72184161e-03f, 1.06743341e-02f, 1.58648282e-01f, -1.67397603e-01f,
  4.49829623e-02f, 1.16492156e-03f, 9.39950645e-02f, 2.27317587e-02f, 8.33543167e-02f, 1.29359234e-02f, -2.10311431e-02f, -3.29894759e-02f, 1.51881412e-01f, 1.74354538e-02f,
  -9.94038954e-02f, -1.60572713e-03f, 1.60903931e-02f, -8.63347203e-02f, 4.72115539e-03f, -4.08258475e-02f, -8.52136239e-02f, -4.47679637e-03f, 3.91401984e-02f, -8.08140077e-03f,
  9.86240432e-02f, 1.33342128e-02f, -1.06801819e-02f, 2.06350684e-02f, -1.23924941e-01f, 3.95548493e-02f, 3.96247096e-02f, 7.66082555e-02f, -3.01745180e-02f, -1.40673578e-01f,
  6.94797635e-02f, 3.42325926e-01f, -5.38089052e-02f, 1.15753368e-01f, -1.31960258e-01f, -7.43218809e-02f, 1.60872098e-02f, -7.81200128e-03f, -6.66399300e-02f, -1.84855778e-02f,
  3.72096524e-02f, 1.17336430e-01f, -1.23615086e-01f, -1.38116889e-02f, 1.41069591e-01f, 7.13121891e-02f, -2.59247813e-02f, 3.26195173e-02f, -2.27496177e-02f, -1.43287927e-01f,
  -1.52741656e-01f, -2.09646132e-02f, 1.58141166e-01f, 1.67128928e-02f, 4.07929420e-02f, 1.73422948e-01f, 7.99491815e-03f, 3.43016610e-02f, 6.83971867e-02f, -1.98013619e-01f,
  -8.74069571e-01f, -3.39129008e-02f, -4.53599721e-01f, -5.68592213e-02f, 5.05477905e-01f, 1.48247108e-01f, -1.11649267e-01f, 8.57804492e-02f, 1.63836479e-01f, -2.62674868e-01f,
  8.50200374e-03f, 3.88738334e-01f, 1.24733754e-01f, 5.43862522e-01f, 1.86243765e-02f, 1.88087560e-02f, 4.56277132e-01f, -1.08950563e-01f, 8.93240720e-02f, 1.53087452e-01f,
  5.77294528e-01f, -2.66007751e-01f, -6.90244734e-01f, -1.07778229e-01f, 1.12654688e-02f, 8.04185197e-02f, -2.42626294e-01f, -2.51983523e-01f, -2.73160666e-01f, -4.51935865e-02f,
  -2.93350488e-01f, -3.09939742e-01f, 2.19108403e-01f, -1.87236872e-02f, -2.58230940e-02f, -9.28196833e-02f, -9.10925567e-02f, 1.17507391e-02f, -1.45368367e-01f, -5.40728122e-02f,
  -1.46867380e-01f, -4.57653068e-02f, 1.14209265e-01f, 5.82898147e-02f, -5.59617206e-02f, -7.51938820e-02f, 1.13123104e-01f, -1.26728147e-01f, 1.33592347e-02f, -2.89831549e-01f,
  3.63473475e-01f, -4.72034216e-02f, -4.76994306e-01f, 1.98470116e-01f, 2.50882685e-01f, 1.16249382e-01f, -2.63505764e-02f, 1.01590678e-01f, 1.02476276e-01f, -2.12632865e-01f,
  9.21918154e-02f, -8.51778239e-02f, 5.83978370e-02f, -8.58849753e-03f, -3.35194990e-02f, 3.28613780e-02f, 6.38503283e-02f, 5.55556007e-02f, -2.14455426e-02f, -1.44911885e-01f,
  1.40969932e-01f, -1.75950766e-01f, 1.54866368e-01f, -9.04578567e-02f, -2.20428705e-02f, 1.47011979e-05f, 9.67576206e-02f, -8.78191888e-02f, 3.41945402e-02f, -7.77773410e-02f,
  4.11080904e-02f, -7.04636574e-02f, -1.06389113e-01f, 1.39042109e-01f, 3.05272248e-02f, 4.85456362e-02f, 9.05046761e-02f, 1.59127071e-01f, -4.41116728e-02f, -4.90764268e-02f,
  -2.69657940e-01f, 5.39585888e-01f, -1.79423645e-01f, 1.69692308e-01f, -1.11005954e-01f, -3.21004614e-02f, 2.68431008e-02f, -1.75170917e-02f, -6.99201152e-02f, -3.55192013e-02f,
  3.20773758e-02f, -4.77220118e-02f, -1.68504655e-01f, 6.79659694e-02f, 3.63308787e-02f, -2.59216800e-02f, -4.51148599e-02f, 1.64180417e-02f, -5.38473483e-03f, -8.08046460e-02f,
  -5.92278391e-02f, -1.68161452e-01f, -5.08444190e-01f, -1.00987710e-01f, -1.74869552e-01f, 9.46127996e-02f, -2.87301183e-01f, -3.01086694e-01f, -3.44389468e-01f, -7.51908183e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  2.02861577e-01f, 7.23969162e-01f, 4.52711046e-01f, 5.85174680e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -3.29765588e-01f, 1.98295996e-01f, -6.16662726e-02f, 1.53914556e-01f, 2.60777533e-01f, -4.25435742e-03f, 2.06994861e-01f, 7.76831955e-02f, -5.92825711e-01f, 2.46212199e-01f,
  2.96191245e-01f, 1.56325355e-01f, -3.91411126e-01f, 3.74781758e-01f, 4.16318238e-01f, -2.19778329e-01f, 4.18870658e-01f, 1.14711180e-01f, -2.26377934e-01f, -1.34007275e-01f,
  3.90792400e-01f, 2.82985717e-01f, 3.18656772e-01f, -4.88058984e-01f, 6.86895251e-01f, -3.58734459e-01f, 2.44597152e-01f, -3.63650799e-01f, 1.24897964e-01f, -2.42542140e-02f,
  -4.39885437e-01f, 3.89346331e-01f, -7.98927173e-02f, -6.19781137e-01f, -1.67391211e-01f, 2.24633992e-01f, 1.13659340e-03f, -5.30084312e-01f, -2.47422710e-01f, 3.69585194e-02f,
  7.38458872e-01f, 2.63671845e-01f, -1.96524873e-01f, -5.33881545e-01f, -3.06184441e-01f, 8.39808434e-02f, -3.45153540e-01f, -2.01319102e-02f, 2.84250528e-01f, -2.50929266e-01f,
  2.33599037e-01f, 2.44476661e-01f, 5.57342544e-02f, 3.84166300e-01f, 3.42236876e-01f, 5.35536349e-01f, 1.04099594e-01f, 7.14537621e-01f, -2.97049507e-02f, -2.22572893e-01f,
  -3.19595993e-01f, 2.43090123e-01f, 3.70763212e-01f, -5.50784826e-01f, -9.38955322e-02f, -3.57177764e-01f, 4.60492343e-01f, 6.33193374e-01f, -7.44176656e-02f, 6.17442019e-02f,
  3.16190481e-01f, 3.20687741e-01f, 8.31089258e-01f, 4.53277558e-01f, -4.29750323e-01f, 6.37181699e-01f, 2.23397478e-01f, -1.45732611e-02f, 1.19645424e-01f, -4.68084633e-01f,
  1.91070482e-01f, -1.11920729e-01f, -3.28596711e-01f, 1.09953649e-01f, -1.58153400e-01f, 3.22450608e-01f, -3.57684016e-01f, 4.37096246e-02f, 2.89617479e-01f, 3.60405385e-01f,
  -3.21502872e-02f, 1.41994908e-01f, 2.96012998e-01f, -3.03114861e-01f, 3.05540472e-01f, -1.02234641e-02f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -3.21736783e-01f, 8.37511122e-01f, 4.44971651e-01f, 5.08410752e-01f, 4.69648987e-01f, -1.04272544e+00f, -7.68220842e-01f, 1.23760450e+00f, -1.40559113e+00f, 6.56747997e-01f,
  5.66481829e-01f, 1.40970014e-02f, 1.38405704e+00f, -1.02174304e-01f, 1.98620856e-01f, 1.26870561e+00f, 1.35737288e+00f, 5.58706880e-01f, 8.27874064e-01f, 4.18863803e-01f,
  5.16413450e-01f, 1.08725739e+00f, -6.17592394e-01f, 7.78206050e-01f, -4.45873886e-01f, 2.15066493e-01f, -7.49970376e-01f, -8.22414637e-01f, 4.39071596e-01f, 2.28418544e-01f,
  4.93731260e-01f, -6.74580693e-01f, -7.64956092e-03f, 2.95378715e-01f, 7.19506025e-01f, 2.43484691e-01f, 3.97830635e-01f, 1.22443640e+00f, 1.39503264e+00f, 2.10492954e-01f,
  2.97265679e-01f, -1.16174495e+00f, 4.79932308e-01f, -8.41096997e-01f, 1.98723674e-01f, 1.04986453e+00f, 6.72514260e-01f, 3.14038694e-01f, -2.58768201e-01f, 1.23181351e-01f,
  1.65596604e-01f, -9.16219279e-02f, -4.80681121e-01f, 6.49323285e-01f, 1.01414919e-02f, -2.41413224e-03f, 4.97700125e-01f, 7.69444704e-01f, -2.22268149e-01f, 6.51423872e-01f,
  -5.42786345e-02f, 2.61387765e-01f, 1.60365987e+00f, 5.05660892e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  5.48361957e-01f, 3.74605030e-01f, 8.55396390e-01f, -1.36090592e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  2.02764310e-02f, 5.00402808e-01f, -7.97105968e-01f, 5.22109509e-01f, 6.48889363e-01f, -1.30906343e+00f, -1.60846468e-02f, -1.44893146e+00f, 3.23346585e-01f, 2.91751176e-01f,
  2.16185927e-01f, -5.16427875e-01f, 1.22645453e-01f, -5.52833736e-01f, -6.35195732e-01f, 1.07041395e+00f, -1.28998291e+00f, -4.28810120e-01f, -8.57134640e-01f, -8.07771385e-01f,
  1.75449029e-01f, -2.70902544e-01f, 1.55225769e-01f, -9.46550250e-01f, -3.92841429e-01f, 5.64078614e-02f, 7.04327822e-02f, 1.82855707e-02f, -3.88580680e-01f, -2.50798035e-02f,
  2.82423615e-01f, 6.60475314e-01f, 1.40007645e-01f, -5.54622412e-01f, 2.69286364e-01f, 3.81526440e-01f, -1.48992658e-01f, 5.69165051e-01f, 9.58551526e-01f, 1.37308609e+00f,
  -1.21808922e+00f, 1.03736885e-01f, 9.78207350e-01f, 1.39424551e+00f, -6.21772528e-01f, -1.08606350e+00f, 4.60468158e-02f, 7.97940433e-01f, 3.26729357e-01f, 7.25170553e-01f,
  7.66273856e-01f, 2.91776538e-01f, 2.54894137e-01f, 7.07137883e-01f, 7.45261135e-03f, 1.96119368e-01f, -1.20880032e+00f, -3.23095262e-01f, -9.92006600e-01f, -8.43967274e-02f,
  8.04990172e-01f, -1.40022159e+00f, -1.62564170e+00f, -6.17905378e-01f, -1.11022496e+00f, 1.40952393e-01f, -1.27527928e+00f, -4.43720609e-01f, 1.41098693e-01f, -2.30043337e-01f,
  -1.24125612e+00f, 8.23732197e-01f, 8.00560176e-01f, -1.09480011e+00f, 8.20546627e-01f, 1.13841724e+00f, 1.82435185e-01f, -1.82629734e-01f, 2.89243966e-01f, -5.25669873e-01f,
  5.37731409e-01f, 8.42445493e-01f, 6.71938837e-01f, -1.99911430e-01f, 9.40465510e-01f, 4.70487267e-01f, 7.08200991e-01f, -7.54537955e-02f, -6.56751543e-02f, 1.60103500e+00f,
  -4.20478731e-01f, -3.64724934e-01f, 3.22077014e-02f, 6.47317946e-01f, -3.82076055e-01f, -6.86862528e-01f, 1.19883108e+00f, 5.15739977e-01f, -9.60162461e-01f, 1.12768030e+00f,
  2.51453131e-01f, -2.11458474e-01f, 2.30360001e-01f, 7.91914105e-01f, 1.28495240e+00f, 1.07318830e+00f, 1.44643140e+00f, -1.05411482e+00f, -4.45525914e-01f, -9.79416311e-01f,
  3.17747980e-01f, -1.02965391e+00f, -1.22025497e-01f, -3.27097476e-01f, 4.96506631e-01f, -7.07961559e-01f, -6.70355260e-01f, -1.16315007e+00f, 4.85929489e-01f, 3.80683281e-02f,
  6.69413805e-01f, -3.71892929e-01f, -8.73780489e-01f, -6.36604309e-01f, 6.31064177e-02f, -7.56619036e-01f, 3.21337789e-01f, 2.52045959e-01f, 9.50932920e-01f, 3.53612840e-01f,
  8.74733999e-02f, -1.26755691e+00f, -1.12511802e+00f, 7.11841702e-01f, 9.87661064e-01f, -6.78134084e-01f, 1.25238264e+00f, -1.08012542e-01f, 6.97003901e-01f, -4.28852439e-01f,
  -2.23459387e+00f, 7.25052774e-01f, -1.14313215e-02f, 3.96507718e-02f, 5.48964500e-01f, -2.11329722e+00f, 9.36779380e-01f, 1.00484133e+00f, 8.53271961e-01f, 1.04779422e+00f,
  -1.76022446e+00f, 4.72476274e-01f, 8.09403062e-01f, -1.42742217e+00f, -1.60618830e+00f, -7.41367340e-01f, -1.02596784e+00f, 3.49092007e-01f, 9.04611796e-02f, -6.71417654e-01f,
  4.16981846e-01f, -8.23010623e-01f, -7.11483210e-02f, 1.13748515e+00f, -1.50942075e+00f, -2.58984476e-01f, -7.68303096e-01f, -1.06089032e+00f, -1.38294101e+00f, 4.86298017e-02f,
  1.04651761e+00f, 9.00599658e-01f, 6.02315255e-02f, 4.71090347e-01f, -2.20146799e+00f, 4.95399684e-01f, -1.63584316e+00f, 3.41566384e-01f, 5.19757330e-01f, 2.36028787e-02f,
  3.05037200e-01f, -1.04091609e+00f, 9.16155875e-01f, 3.38530213e-01f, -1.00918055e+00f, 1.20179319e+00f, -1.53872037e+00f, -1.20773260e-02f, -1.07748032e+00f, 2.79642224e-01f,
  3.97219002e-01f, -1.24916959e+00f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.60024005e-01f, -8.71538758e-01f, -1.14274956e-01f, -1.10741004e-01f, -2.15403914e-01f, 1.32050723e-01f, 5.62449992e-01f, -5.33751585e-02f, -1.30773589e-01f, 3.51481825e-01f,
  -9.69112478e-03f, -1.27798855e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    