/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.56967902e-01f, 4.24794853e-02f, 2.80414641e-01f, 2.54765898e-01f, -1.38133392e-01f, 1.83258265e-01f, 2.83035696e-01f, -1.02619037e-01f, 7.72230625e-02f, -1.46870106e-01f,
  -1.17666915e-01f, 1.35617986e-01f, -1.37277991e-01f, 1.51019081e-01f, 1.02740727e-01f, 5.88334613e-02f, 1.90364495e-01f, 9.45362821e-02f, -1.70292910e-02f, 5.07829562e-02f,
  -1.16799930e-02f, -1.35693744e-01f, 1.19700179e-01f, -2.24835336e-01f, 9.97512341e-02f, -5.47683388e-02f, -1.21095434e-01f, -1.23236822e-02f, -4.00010077e-03f, -2.26237681e-02f,
  5.05732745e-02f, -9.61673036e-02f, -2.11578924e-02f, 5.77251725e-02f, 5.04426323e-02f, 1.54961590e-02f, 4.05071639e-02f, -5.14612207e-03f, 2.30404194e-02f, -1.46551309e-02f,
  -1.31138153e-02f, 1.20140137e-02f, -8.13995581e-03f, -7.43770003e-02f, 2.35486217e-02f, -1.00688105e-02f, 6.12905882e-02f, 2.21869210e-03f, 2.38901414e-02f, 7.06210434e-02f,
  1.41956499e-02f, 6.92190155e-02f, 9.88498479e-02f, 3.57034355e-02f, -3.00631355e-02f, 4.19399701e-03f, 6.27441257e-02f, 5.69727160e-02f, -2.15993933e-02f, 1.02485828e-02f,
  -4.00385913e-03f, 1.53885130e-02f, 9.66595765e-03f, 1.15804113e-02f, 4.28104773e-02f, -3.03514656e-02f, 2.41476409e-02f, -8.78222845e-03f, 1.43221440e-02f, -3.77944373e-02f,
  4.15669754e-02f, -2.19947230e-02f, -3.88722606e-02f, 3.11869439e-02f, 7.97960348e-03f, 4.75678854e-02f, 3.21738459e-02f, 2.88104196e-03f, 4.16808948e-02f, 5.63173145e-02f,
  -1.91571712e-02f, 6.61803484e-02f, -1.13321366e-02f, -3.32877114e-02f, 3.67087573e-02f, -3.19753662e-02f, -2.10552402e-02f, 2.95030116e-03f, -6.17829757e-03f, 4.70112450e-02f,
  5.54729477e-02f, -6.70480281e-02f, 3.89107838e-02f, -3.73266488e-02f, -5.76939769e-02f, -5.21830879e-02f, 3.18967104e-02f, -3.98147516e-02f, 2.70640347e-02f, 3.66321839e-02f,
  -2.44279206e-02f, 1.18752839e-02f, 1.65878143e-02f, 5.17274439e-02f, 3.71258445e-02f, -4.72532660e-02f, -3.47536132e-02f, 1.89595632e-02f, 2.11247709e-03f, -7.79211298e-02f,
  -1.74315572e-02f, -2.29029134e-02f, -1.59478858e-02f, -2.97846161e-02f, -3.90722863e-02f, -1.85205955e-02f, 4.80612814e-02f, -1.88770406e-02f, -5.51430024e-02f, 1.58466976e-02f,
  2.91229576e-01f, -1.46646604e-01f, -2.32857510e-01f, 5.61841652e-02f, 7.26800933e-02f, -5.02900481e-02f, -7.03785270e-02f, -4.35530022e-03f, -1.79868013e-01f, -6.27343580e-02f,
  5.00814728e-02f, 5.10338321e-02f, -1.51545480e-01f, -5.37105165e-02f, 3.17875333e-02f, -2.51651496e-01f, 1.58060025e-02f, 1.00166164e-01f, -1.23430625e-01f, 1.14172697e-01f,
  -4.06644493e-02f, 1.14896201e-01f, -1.39183596e-01f, -6.58891723e-02f, 1.26408994e-01f, 2.58354712e-02f, 1.79460853e-01f, -5.08437753e-02f, 1.71453953e-01f, 2.37261429e-02f,
  5.30693261e-03f, 4.19437662e-02f, 1.55540113e-03f, -8.31983015e-02f, 1.25886455e-01f, -9.45000444e-03f, 2.66103018e-02f, -8.77833739e-02f, 1.43948430e-03f, -3.19930986e-02f,
  -3.72607894e-02f, 7.44913295e-02f, 4.12616469e-02f, -1.47377923e-01f, 1.92639958e-02f, 7.01618055e-03f, -2.87753064e-02f, 4.35631946e-02f, -2.26945262e-02f, -5.38988300e-02f,
  5.08960150e-02f, 5.29527292e-02f, 6.62902230e-03f, -2.46226322e-02f, -4.32973765e-02f, -8.61389749e-03f, -2.28493586e-02f, -1.44685153e-02f, 3.91014330e-02f, -2.05457713e-02f,
  -5.17238155e-02f, -8.00776834e-05f, -4.93641458e-02f, 5.11370087e-03f, 1.46868103e-03f, 5.74871823e-02f, 1.20821325e-02f, 4.37170640e-03f, -1.94786098e-02f, 2.24846993e-02f,
  1.21467013e-03f, 8.96993726e-02f, -1.25857014e-02f, -3.96584393e-03f, -3.73958697e-04f, 3.14243436e-02f, 1.89126597e-03f, 4.93520685e-02f, -7.65777938e-03f, 2.51268037e-02f,
  -8.04105550e-02f, 6.50573149e-02f, 2.53913403e-02f, 6.60441117e-03f, -1.91894006e-02f, 2.58458201e-02f, 3.03217098e-02f, -3.19274841e-03f, -9.15148929e-02f, 6.06344938e-02f,
  1.71247825e-01f, 1.02154791e-01f, 2.57464796e-02f, 1.22315452e-01f, -5.14561795e-02f, 3.39248814e-02f, -9.37914997e-02f, 2.81628259e-02f, -7.42718428e-02f, -4.19259630e-03f,
  9.29469988e-03f, 2.65313275e-02f, 1.99381374e-02f, 5.90933077e-02f, -4.07585725e-02f, -3.97059247e-02f, 2.84330491e-02f, -1.65021215e-02f, 3.88383642e-02f, 9.13128927e-02f,
  4.29388210e-02f, 1.15581760e-02f, 1.10073192e-02f, 6.58207620e-03f, -1.35226185e-02f, 1.10940151e-02f, 1.08137317e-01f, -2.66842507e-02f, 3.41348462e-02f, 2.30493937e-02f,
  -8.17675069e-02f, 1.35145426e-01f, 1.27335414e-01f, -1.29362568e-01f, 1.59686446e-01f, 6.20345175e-02f, -6.82504699e-02f, 1.22942673e-02f, 2.41331592e-01f, -2.44060844e-01f,
  -2.73604095e-02f, -2.62110890e-03f, -4.38726135e-02f, -2.35504238e-03f, -1.85918182e-01f, 1.18376933e-01f, -1.24314502e-01f, -2.29026359e-02f, 2.65497386e-01f, -1.44936353e-01f,
  7.10328594e-02f, -1.42517060e-01f, 4.41012671e-03f, -3.10662575e-03f, -9.83541235e-02f, 4.92936224e-02f, -3.22669536e-01f, 1.47839352e-01f, -1.37604758e-01f, 5.61544560e-02f,
  1.62333678e-02f, 1.67533495e-02f, -2.83902138e-03f, 1.02112472e-01f, -2.20636539e-02f, 1.47792082e-02f, -5.91338612e-03f, 1.55188823e-02f, 7.60566443e-02f, 5.70284389e-02f,
  2.55644741e-03f, -5.38334064e-02f, 3.90558317e-02f, 5.82547151e-02f, 9.75601673e-02f, 3.28271724e-02f, 2.56298445e-02f, -1.75860319e-02f, 2.86757853e-02f, 3.58308963e-02f,
  9.16458517e-02f, 5.59301302e-02f, -3.75472903e-02f, -1.06763197e-02f, -1.33038824e-02f, 8.65396410e-02f, -1.95086207e-02f, -5.99256996e-03f, 2.57357745e-03f, 7.83351064e-02f,
  3.11411563e-02f, 1.01639770e-01f, -3.68049331e-02f, 1.50647582e-02f, -5.69070466e-02f, 5.13361301e-03f, -2.64672227e-02f, 4.56191460e-03f, -4.61225733e-02f, -7.90620595e-02f,
  -7.85720572e-02f, 3.33200023e-02f, 6.67530373e-02f, 7.71371648e-02f, -3.53376754e-02f, -6.25981614e-02f, 1.13001298e-02f, 8.86126980e-03f, -2.05367301e-02f, -8.08986574e-02f,
  -5.66990522e-04f, 1.86657645e-02f, 3.30425575e-02f, -3.66231017e-02f, 4.39250423e-03f, 4.14918996e-02f, 1.11277215e-02f, 1.55066531e-02f, -4.57694121e-02f, 2.54076766e-03f,
  -1.20645963e-01f, -9.92106050e-02f, 2.24342141e-02f, 4.52817045e-02f, -7.11176768e-02f, -7.01646134e-02f, -7.29691423e-03f, 2.79062483e-02f, -6.46135807e-02f, -8.95184949e-02f,
  -5.09954318e-02f, -7.24567175e-02f, -2.69286670e-02f, 5.28705344e-02f, -2.22537015e-02f, -2.20784210e-02f, -4.52621914e-02f, 4.74967621e-02f, -1.09137028e-01f, -1.94671527e-02f,
  -9.56598893e-02f, 1.54028647e-03f, 2.96323951e-02f, -1.21258616e-01f, -6.04329556e-02f, -3.97456884e-02f, -2.07044408e-02f, 8.75616074e-02f, 2.28942968e-02f, -2.43164860e-02f,
  -1.83569446e-01f, 2.20683113e-01f, 2.19349638e-01f, 1.40338857e-02f, -5.62879033e-02f, -3.34506750e-01f, -1.82670444e-01f, 1.84125096e-01f, -1.15887776e-01f, 1.01527177e-01f,
  -6.98380098e-02f, 2.99816914e-02f, 5.88190332e-02f, -1.02765389e-01f, -3.92553717e-01f, -6.35194033e-02f, -1.07976139e-01f, -1.44030184e-01f, -1.27337426e-02f, 2.01441776e-02f,
  -1.53143713e-02f, -1.99582949e-01f, 1.57227993e-01f, 1.25273079e-01f, 1.02473088e-01f, 1.60485893e-01f, 3.97755839e-02f, 1.35096014e-01f, 1.03406213e-01f, -6.78335354e-02f,
  -7.68435821e-02f, -3.37708779e-02f, 1.50906652e-01f, 3.82399303e-03f, -1.04969526e-02f, 3.39910761e-02f, -3.56676243e-02f, -1.96518414e-02f, 6.00856775e-03f, -1.56710409e-02f,
  -3.69981788e-02f, -3.27718146e-02f, -4.42554094e-02f, 4.80875559e-02f, -5.67175895e-02f, 7.52056986e-02f, 2.13865209e-02f, 6.45176470e-02f, 2.75258627e-02f, -1.92387216e-02f,
  2.93014199e-02f, 4.70356271e-02f, -2.90749911e-02f, -9.92167648e-03f, 1.99611578e-02f, -2.11164057e-02f, -6.42678663e-02f, 1.58552416e-02f, -1.01225693e-02f, -7.01148435e-02f,
  -5.14634475e-02f, 4.13878374e-02f, 6.43192381e-02f, 4.25873585e-02f, -2.60056034e-02f, 7.43504837e-02f, -2.67540850e-02f, -2.29570344e-02f, 6.37829537e-03f, -1.84110564e-03f,
  -5.82492277e-02f, 2.68103387e-02f, -5.25919609e-02f, 4.51837946e-03f, 3.52072017e-03f, 2.15531942e-02f, 4.02865373e-03f, 1.72856869e-03f, 6.36912603e-03f, 6.95918947e-02f,
  -9.36109386e-03f, -8.08102340e-02f, 7.01465607e-02f, -1.40400678e-02f, -3.93216461e-02f, -2.20509246e-03f, 5.10557257e-02f, 1.16134070e-01f, 1.93703808e-02f, -1.69813763e-02f,
  -1.49424642e-01f, 7.30776936e-02f, 3.63228694e-02f, 2.23878715e-02f, 2.57120244e-02f, -1.12965098e-02f, -7.83119276e-02f, 2.54665106e-03f, -2.22065747e-02f, 3.34170312e-02f,
  6.09884337e-05f, 2.76804087e-03f, -1.50140692e-02f, -1.29670044e-02f, -1.24085717e-01f, -1.66200157e-02f, -6.29587471e-02f, -6.18983768e-02f, -3.77428681e-02f, 3.67723964e-02f,
  -6.99037919e-03f, -6.89846054e-02f, -5.55547625e-02f, -1.16495686e-02f, -8.74218866e-02f, -1.02475151e-01f, 3.42316516e-02f, 9.42054577e-03f, -2.18152609e-02f, -1.01105694e-03f,
  1.41718909e-01f, 1.63703755e-01f, -1.01042293e-01f, 1.26260877e-01f, -1.86945409e-01f, -1.47875637e-01f, -9.14484169e-03f, 4.01852280e-02f, 9.28001553e-02f, 7.58900791e-02f,
  6.43207356e-02f, 1.61008704e-02f, -1.29504753e-02f, 2.10277259e-01f, 6.29164353e-02f, 1.55412212e-01f, 1.85913801e-01f, 1.32810539e-02f, 5.84393479e-02f, 5.16695939e-02f,
  7.98061565e-02f, 9.41632167e-02f, -4.27664258e-02f, 6.57468364e-02f, -8.14055577e-02f, 1.66056547e-02f, 5.72856329e-02f, -5.26492670e-02f, 1.38760451e-02f, -9.49447826e-02f,
  2.37825662e-02f, 1.32164389e-01f, -1.74926557e-02f, -7.27540106e-02f, -4.08731177e-02f, -3.14306915e-02f, -4.78832349e-02f, -2.67036166e-02f, 2.39272049e-05f, -5.17593324e-03f,
  2.94889230e-02f, -1.55252218e-02f, 4.60002245e-03f, 1.40024638e-02f, -8.22269768e-02f, -1.74937639e-02f, -9.07324180e-02f, -1.58655085e-02f, -1.86090043e-03f, -3.63369100e-02f,
  -7.28899688e-02f, -7.97790103e-03f, 1.03951059e-02f, -1.43555300e-02f, -6.04933202e-02f, -4.72444743e-02f, -7.35258386e-02f, -7.87082464e-02f, 6.28839480e-03f, 6.36470737e-03f,
  -6.67765439e-02f, 2.29927134e-02f, -3.33207995e-02f, 8.32644524e-04f, 3.78110856e-02f, -2.96078976e-02f, -8.26616120e-03f, 2.98307203e-02f, 4.52804379e-03f, -2.16140300e-02f,
  8.82260427e-02f, -1.35375233e-02f, 4.63390723e-02f, -3.04308627e-02f, 2.13869978e-02f, -1.91411041e-02f, 5.95262181e-03f, -7.23979576e-03f, -3.42814587e-02f, 1.07396757e-02f,
  3.53670344e-02f, -2.97693517e-02f, 3.29842344e-02f, -6.26407117e-02f, 1.60367973e-02f, -6.07312471e-03f, 4.57731672e-02f, -5.77725209e-02f, -3.13931331e-02f, -2.93975919e-02f,
  1.91817865e-01f, 2.79402971e-01f, -1.82540473e-02f, 1.34898722e-02f, 6.60426468e-02f, -2.76658107e-02f, 2.80028954e-02f, 1.22736010e-03f, 8.64553824e-02f, 2.85379849e-02f,
  -5.81385009e-02f, -4.86842841e-02f, 3.69131309e-03f, 8.13637674e-03f, 8.24583620e-02f, -4.20936346e-02f, 1.28207598e-02f, 3.88008319e-02f, -1.73647869e-02f, -4.25756630e-03f,
  1.27005614e-02f, 1.90219451e-02f, -5.06892279e-02f, 2.84382030e-02f, 1.28915766e-02f, 2.76141670e-02f, -3.18205580e-02f, -4.40602377e-03f, -3.06230169e-02f, -2.59982366e-02f,
  3.22974503e-01f, -1.06193364e-01f, 6.29959330e-02f, -1.18435532e-01f, -2.54002120e-02f, -2.09946156e-01f, -9.06915069e-02f, -5.31336479e-02f, 9.96578336e-02f, 4.16300893e-02f,
  -9.07866284e-02f, 1.40492961e-01f, 1.23006683e-02f, -2.40368322e-01f, -1.78293496e-01f, -1.23675928e-01f, -2.49829106e-02f, -2.33477689e-02f, -3.45724039e-02f, -5.35851344e-03f,
  2.12471336e-02f, -1.79949552e-01f, -1.87697768e-01f, -1.63505211e-01f, -8.36277157e-02f, 4.07846272e-02f, 1.88612007e-02f, 2.49777902e-02f, -1.69807196e-01f, -3.14472765e-02f,
  -3.40123251e-02f, 1.31472543e-01f, 6.01261482e-02f, 5.71760796e-02f, -1.96259432e-02f, 1.10602267e-01f, -2.00319570e-03f, -1.47757204e-02f, -6.90150820e-03f, -2.21060477e-02f,
  6.09009638e-02f, 3.06596905e-02f, 3.60430069e-02f, 1.18929064e-02f, 4.50376794e-02f, 4.97819968e-02f, -1.06753379e-01f, -4.16722754e-03f, -6.75439686e-02f, -4.76154648e-02f,
  -5.98881096e-02f, -4.89050746e-02f, -6.50318787e-02f, -6.27856404e-02f, -1.93966720e-02f, -4.94267941e-02f, -1.42325545e-02f, -2.35828906e-02f, -2.10270416e-02f, -3.23907919e-02f,
  8.19824040e-02f, -1.06306439e-02f, 1.82049684e-02f, -3.09579372e-02f, 2.53378954e-02f, -5.67842908e-02f, -4.90486808e-02f, 3.07622291e-02f, -4.19410085e-03f, 1.91205814e-02f,
  -2.93110311e-02f, -9.45538655e-03f, 4.11613882e-02f, 1.11179845e-03f, 8.99777841e-03f, 1.21130124e-02f, 5.72586479e-03f, 1.51561555e-02f, 4.83685285e-02f, -5.85193411e-02f,
  -2.14822982e-02f, -8.05220753e-03f, -1.29418615e-02f, 5.82286790e-02f, -1.52451545e-02f, -2.53992807e-02f, -4.22007740e-02f, -1.15420036e-02f, -4.14207280e-02f, -2.36617494e-02f,
  1.30627662e-01f, 1.89281195e-01f, -1.99161433e-02f, -1.68796070e-02f, -3.28556523e-02f, 3.67963538e-02f, 7.89000317e-02f, 1.68864839e-02f, 1.84934307e-02f, 1.17552644e-02f,
  3.56634296e-02f, -3.72633641e-03f, 1.26951579e-02f, -2.92596844e-04f, -4.27956209e-02f, -6.01722747e-02f, 9.51321274e-02f, 3.04837879e-02f, 5.41850105e-02f, -5.15315458e-02f,
  5.46144843e-02f, -5.11771161e-03f, 3.81068029e-02f, 4.09814939e-02f, 2.45881360e-02f, 3.19671407e-02f, 9.29442421e-02f, 9.24672261e-02f, -5.55412583e-02f, -1.58962309e-02f,
  1.12395853e-01f, 7.29072839e-02f, 1.39796380e-02f, 9.36193392e-02f, -1.08158976e-01f, 7.92424157e-02f, 4.37368006e-02f, 3.43217924e-02f, -8.27280283e-02f, 6.04019836e-02f,
  3.17430235e-02f, 3.44345197e-02f, 5.69552518e-02f, 8.27909559e-02f, 2.40375493e-02f, -4.47598062e-02f, 1.61581725e-01f, 1.01356216e-01f, -7.33989924e-02f, 1.12992544e-02f,
  2.30542738e-02f, 5.12385443e-02f, -1.41564058e-02f, -6.95878863e-02f, 1.82990283e-02f, 4.22450341e-02f, 4.49520443e-03f, -1.53384749e-02f, 6.37895316e-02f, -6.66031614e-02f,
  -9.22813267e-02f, -9.71099958e-02f, -3.20996381e-02f, 1.83500387e-02f, 1.92533918e-02f, 7.94308335e-02f, 6.44281358e-02f, 1.04702159e-03f, -3.71536091e-02f, 3.35064828e-02f,
  -2.14475356e-02f, -2.52167378e-02f, 3.91822159e-02f, -1.81687530e-02f, -1.55357020e-02f, 2.41731163e-02f, -8.75954889e-03f, -3.28796953e-02f, -6.97425613e-03f, 3.32270041e-02f,
  3.21911871e-02f, 3.14830779e-03f, 3.87970768e-02f, -3.83500271e-02f, -1.33384597e-02f, -2.58686058e-02f, 2.29131635e-02f, -1.87993515e-02f, 3.20607573e-02f, -5.62184840e-04f,
  5.25636524e-02f, 1.39426636e-02f, 2.93979049e-02f, 2.61225011e-02f, 3.31472494e-02f, -8.50391686e-02f, 1.65269952e-02f, -1.83313359e-02f, -2.85304263e-02f, 4.80847955e-02f,
  -2.99006365e-02f, 5.07465787e-02f, 2.63642352e-02f, 8.48148540e-02f, 4.70122434e-02f, -6.38287365e-02f, 5.49059473e-02f, 4.68266197e-02f, 2.18488649e-02f, 9.16678924e-04f,
  5.32394089e-02f, 1.44133605e-02f, -2.34981813e-02f, 4.45254296e-02f, -5.15228063e-02f, 4.25276160e-02f, -1.99606395e-04f, -6.67327316e-04f, -4.00285684e-02f, 4.28114906e-02f,
  1.21680982e-01f, 1.28728613e-01f, -6.33402392e-02f, 5.16247656e-03f, 9.72689781e-03f, -5.07170483e-02f, -5.10744471e-03f, 1.19983461e-02f, -2.27543563e-02f, -3.91268805e-02f,
  4.54543978e-02f, 2.33370308e-02f, 1.97044741e-02f, 6.77429046e-03f, 3.16841193e-02f, 3.67479399e-02f, -5.63273905e-03f, 1.51863433e-02f, 6.59375265e-02f, 5.64550906e-02f,
  8.40319991e-02f, -2.04109829e-02f, 2.69812234e-02f, -4.33438271e-02f, 8.11878033e-03f, 8.41223523e-02f, 5.36375903e-02f, 3.58663909e-02f, 6.17858432e-02f, -3.32930982e-02f,
  -2.32322328e-02f, 2.95544952e-01f, 2.09279343e-01f, 1.74672142e-01f, -1.00218870e-01f, -2.61165313e-02f, -1.86841507e-02f, 1.04866803e-01f, 2.61432648e-01f, 1.94704831e-02f,
  -1.42196044e-01f, 6.18645623e-02f, 1.72767732e-02f, 4.48752977e-02f, -8.82394239e-02f, 1.87735222e-02f, -1.25452830e-02f, 1.13904104e-02f, 4.30405848e-02f, 5.16285896e-02f,
  4.71818559e-02f, -8.15762132e-02f, -2.44293064e-02f, -3.82293910e-02f, 4.33098823e-02f, 1.43542916e-01f, -1.81781694e-01f, -1.22857024e-03f, -8.49140584e-02f, -1.16656579e-01f,
  4.74751815e-02f, 1.39944047e-01f, 4.20864858e-02f, 5.65030053e-02f, 4.07598279e-02f, -9.17865410e-02f, -6.01752428e-03f, -8.77891947e-03f, 2.80795451e-02f, 7.02913180e-02f,
  -8.13952088e-02f, -3.31045538e-02f, 7.20133632e-02f, -2.88364515e-02f, 6.68331459e-02f, 7.27982670e-02f, -9.34811030e-03f, -3.37120555e-02f, 1.75200701e-02f, -2.08747741e-02f,
  7.57720843e-02f, -4.44038659e-02f, 3.99611555e-02f, -3.56506817e-02f, 5.33459410e-02f, 7.12622926e-02f, -1.36862264e-03f, -6.18665805e-03f, 3.38368826e-02f, 1.14475219e-02f,
  -5.00350185e-02f, 2.23668870e-02f, -3.09980698e-02f, 2.13419888e-02f, 2.71872384e-03f, -1.94430817e-02f, 1.01883169e-02f, -6.66846856e-02f, -2.17234064e-02f, -3.25242691e-02f,
  5.83580323e-02f, 4.01962660e-02f, -1.20192335e-03f, 2.28481032e-02f, -4.77441885e-02f, -5.59767447e-02f, -6.17570803e-02f, -2.67641768e-02f, 1.05098104e-02f, -9.37771332e-03f,
  -5.66150062e-02f, 3.03165503e-02f, -1.38734942e-02f, -2.83152498e-02f, -3.25177535e-02f, 1.57196671e-02f, -4.69077304e-02f, 2.49149445e-02f, -5.08354791e-02f, -3.15029994e-02f,
  -9.47017819e-02f, -2.34491210e-02f, -3.84339551e-03f, 2.35344265e-02f, -2.23748088e-02f, -2.31375396e-02f, 4.73603699e-03f, 1.94552969e-02f, -3.22100446e-02f, -9.48316825e-04f,
  -2.90138014e-02f, 3.98616716e-02f, -1.23502389e-02f, -1.36001436e-02f, -4.13194820e-02f, -4.00257744e-02f, 5.45450626e-03f, 4.34411913e-02f, -2.29137335e-02f, -3.70491371e-02f,
  -5.86604401e-02f, -1.68495178e-02f, -3.03409956e-02f, 1.30596431e-02f, -7.35215694e-02f, -7.66309947e-02f, -5.59125841e-02f, 4.26035970e-02f, -9.90158021e-02f, -2.10787896e-02f,
  1.85310081e-01f, 1.99709199e-02f, 1.52318448e-01f, 1.47899687e-01f, -6.87034652e-02f, -1.83136538e-01f, 7.82489032e-02f, -3.07358690e-02f, 3.11185420e-01f, -1.66044891e-01f,
  -1.84354395e-01f, 2.30297133e-01f, 8.40448141e-02f, -1.84545472e-01f, 5.30783460e-02f, 1.12414546e-01f, -1.73793599e-01f, -6.67983592e-02f, 1.64295807e-01f, 7.11809145e-03f,
  6.50829598e-02f, -1.33772179e-01f, 9.34969541e-03f, -1.42618403e-01f, -9.07357112e-02f, 5.22064827e-02f, -1.96147636e-01f, 3.88552807e-02f, -2.54703760e-01f, -8.78105129e-05f,
  -5.47496192e-02f, 1.03169240e-01f, 2.58574970e-02f, 1.08451970e-01f, -5.17606251e-02f, -7.52633885e-02f, -5.30359661e-03f, 3.49710174e-02f, 4.25519869e-02f, -9.84492246e-03f,
  2.47235559e-02f, 2.36865785e-02f, -5.02807312e-02f, 3.04507855e-02f, 5.34616597e-02f, 4.14941125e-02f, -7.38578523e-03f, 3.28515433e-02f, 7.02742338e-02f, -2.75810789e-02f,
  7.92899132e-02f, -4.14131321e-02f, 2.12826999e-04f, -8.67420156e-03f, 5.62110096e-02f, -4.13047038e-02f, 1.53116172e-03f, -5.97336562e-04f, -2.65097758e-03f, 3.82217579e-02f,
  -3.83622013e-02f, -2.69729104e-02f, 1.63716655e-02f, -4.71068323e-02f, 3.28199612e-03f, -2.94814911e-02f, 1.20499134e-02f, -3.67373377e-02f, 6.49305731e-02f, -2.99713444e-02f,
  -2.58353213e-03f, -2.60825083e-02f, -5.82128502e-02f, -2.79180910e-02f, -1.74817462e-02f, 1.96584109e-02f, -5.53837046e-02f, -3.40020400e-03f, 6.34592352e-03f, -1.82643011e-02f,
  9.12374351e-03f, 3.31394076e-02f, 2.59768646e-02f, -1.50377750e-02f, 1.33393696e-02f, 1.78623423e-02f, -6.75808042e-02f, 2.93738320e-02f, 4.47860025e-02f, 1.87692104e-03f,
  -8.28669369e-02f, -1.07907075e-02f, 4.36489321e-02f, -1.16681363e-02f, -7.88384024e-03f, -5.11961877e-02f, -3.90002988e-02f, -2.08640881e-02f, -3.28074675e-03f, -6.84388098e-04f,
  -1.18830509e-01f, 3.45465206e-02f, 1.87947750e-02f, -4.13679555e-02f, 1.60952546e-02f, -4.59237210e-02f, -3.47627290e-02f, -6.04905821e-02f, -7.25172237e-02f, -1.24561191e-02f,
  -8.81223008e-02f, -2.64098844e-03f, 5.37721589e-02f, 8.84803385e-03f, -2.82488838e-02f, -3.45207006e-02f, -2.37516104e-03f, 7.06963148e-03f, -1.29523093e-03f, -4.83712964e-02f,
  -4.90272380e-02f, 2.36698970e-01f, 1.51124462e-01f, 1.66181967e-01f, -1.19834900e-01f, 1.51148051e-01f, 2.11691737e-01f, -3.69925499e-02f, -1.84849110e-02f, 2.01687559e-01f,
  1.11785578e-02f, 7.62680098e-02f, 3.12335361e-02f, 3.03214997e-01f, 1.60570163e-02f, 1.65205970e-01f, 2.24660680e-01f, 8.52310061e-02f, -6.36273101e-02f, 6.67839497e-02f,
  -1.01998122e-02f, 1.53859466e-01f, 2.42381934e-02f, -6.13660142e-02f, 1.02598049e-01f, -1.15264677e-01f, -1.12024143e-01f, -9.92333069e-02f, 1.17378458e-01f, 5.31375408e-02f,
  1.15734726e-01f, 1.35636888e-03f, 1.35114854e-02f, 5.93116954e-02f, 7.62416935e-03f, -5.63719496e-02f, 5.88481128e-02f, 3.44239175e-02f, -5.11355847e-02f, 1.51104284e-02f,
  5.00444025e-02f, -3.65395620e-02f, 6.74184859e-02f, 2.06741765e-02f, 2.08310457e-03f, -6.13075607e-02f, 3.85967568e-02f, 1.36808390e-02f, -1.21649336e-02f, 1.27188098e-02f,
  3.25459614e-02f, 4.86795753e-02f, -2.45857425e-02f, 7.19508296e-03f, -3.08145043e-02f, 1.62138566e-02f, 1.58748031e-02f, 4.09710919e-03f, -3.11195981e-02f, -3.08417790e-02f,
  3.20871621e-02f, 3.31255570e-02f, -2.80073355e-03f, 5.67720607e-02f, 2.98347231e-02f, -3.76378708e-02f, 1.48037719e-02f, -6.31059408e-02f, -2.98578348e-02f, 4.37078774e-02f,
  -6.56714588e-02f, 3.12068593e-02f, -2.62000933e-02f, 2.84781381e-02f, 1.75329088e-03f, 3.04357074e-02f, -5.12491427e-02f, 2.32145656e-02f, -4.46925573e-02f, -6.73926249e-02f,
  -9.31402016e-03f, -1.52574480e-02f, 1.51418441e-03f, -1.07563445e-02f, -2.07178742e-02f, -1.64090432e-02f, 3.88014130e-02f, 3.78551781e-02f, -1.47861522e-03f, -4.28459123e-02f,
  -1.02384519e-02f, 1.34052992e-01f, 4.87417885e-04f, -1.63479592e-03f, 3.35196331e-02f, 4.20991033e-02f, 7.79875647e-03f, 6.46667788e-03f, -2.63816193e-02f, -4.90768775e-02f,
  -1.30706308e-02f, 1.75987259e-02f, -7.34864771e-02f, 5.65019660e-02f, -5.16450256e-02f, 5.26868850e-02f, -2.25287070e-03f, 3.96915153e-03f, 5.70336580e-02f, -6.55229837e-02f,
  -7.11512193e-02f, -7.12487102e-02f, 5.95591264e-04f, -4.58388356e-03f, 3.08130179e-02f, -1.31143490e-03f, -4.75195646e-02f, 1.05917156e-02f, -5.97013868e-02f, 2.10534595e-02f,
  -5.04512899e-02f, 1.60559177e-01f, 2.47029513e-01f, -1.01025417e-01f, 1.04856849e-01f, 7.25499913e-03f, -2.45624796e-01f, 1.10812895e-01f, -2.05198169e-01f, -1.58226937e-01f,
  -2.41881371e-01f, 9.42806229e-02f, -2.56144911e-01f, -1.77222863e-01f, -7.61429518e-02f, -1.71453208e-01f, -7.88270980e-02f, -9.75076184e-02f, 8.57728347e-02f, -1.05592879e-02f,
  2.98585650e-02f, -6.91168234e-02f, 3.56194302e-02f, 2.00684682e-01f, -9.28167850e-02f, 1.38149798e-01f, -1.98705569e-02f, 1.58417355e-02f, 1.11755811e-01f, 4.96247262e-02f,
  -4.92122397e-02f, -3.77440415e-02f, 4.15541418e-02f, 7.72386193e-02f, -4.39080130e-03f, 1.69095062e-02f, -1.14092231e-02f, 1.93372797e-02f, -4.70872745e-02f, 1.06246118e-02f,
  -4.28890251e-02f, 6.46574050e-02f, -3.45871411e-02f, 3.71471532e-02f, -5.96849294e-03f, 6.78390563e-02f, -3.99471894e-02f, 1.69378854e-02f, -3.91154625e-02f, -9.64399520e-03f,
  -8.07887465e-02f, 1.35366311e-02f, -1.45302145e-02f, 4.46625985e-02f, -1.14852656e-02f, -6.59698807e-03f, 3.76379266e-02f, 4.73140702e-02f, 2.21584197e-02f, -3.49280424e-02f,
  4.82189357e-02f, -2.82997061e-02f, -6.30846769e-02f, 1.37269674e-02f, 8.50051194e-02f, 1.41557408e-02f, -3.13507505e-02f, 2.30544526e-02f, 8.15806165e-03f, -3.75525989e-02f,
  7.03528131e-05f, 4.34220247e-02f, -2.12888066e-02f, -4.25797105e-02f, -1.12913428e-02f, 1.13582509e-02f, 8.73060375e-02f, 5.45812063e-02f, -6.58062696e-02f, 1.40550938e-02f,
  -4.65629585e-02f, -6.72643185e-02f, -6.70817718e-02f, -1.13801938e-02f, -6.94025084e-02f, -1.17589366e-02f, -4.75683138e-02f, 2.03060620e-02f, -4.00419161e-02f, 5.72952665e-02f,
  -7.84404017e-03f, 7.10568652e-02f, -5.03564253e-02f, 3.11801713e-02f, 8.68682340e-02f, -1.85448229e-02f, -3.91392447e-02f, 4.81679291e-02f, -9.13629076e-04f, -2.57508829e-02f,
  9.19931475e-03f, -9.70773865e-03f, 3.29438895e-02f, -6.57855719e-03f, 4.64612655e-02f, -4.53446582e-02f, -5.95857808e-03f, 9.77244135e-03f, 5.83193265e-02f, 2.75683831e-02f,
  3.20260301e-02f, -5.20945638e-02f, -5.30892834e-02f, 4.65525277e-02f, 5.32992594e-02f, 3.11236717e-02f, 2.05750875e-02f, 2.17248760e-02f, 2.33598147e-02f, 3.68858166e-02f,
  -2.45637804e-01f, 1.39682263e-01f, 2.78961360e-02f, 9.83091518e-02f, 1.07607611e-01f, 1.70174703e-01f, 2.48343319e-01f, 1.86290547e-01f, 2.35583216e-01f, 1.20161772e-01f,
  5.19420989e-02f, 5.04185483e-02f, 2.74057277e-02f, 1.17606679e-02f, -3.74474749e-02f, 4.84118462e-02f, 1.77816615e-01f, 1.11401714e-01f, 7.83689991e-02f, 3.37916277e-02f,
  -4.54375036e-02f, 7.52045438e-02f, -1.33574843e-01f, 8.90160277e-02f, 1.41902501e-02f, -5.20319585e-03f, -7.43710669e-03f, -6.88584000e-02f, -3.50369401e-02f, 9.01160762e-03f,
  -6.40042052e-02f, 1.19614704e-02f, -5.55798337e-02f, -5.82105778e-02f, 3.47808078e-02f, 2.00530305e-03f, -3.89248729e-02f, -9.04785842e-02f, 3.16924527e-02f, 4.70655318e-03f,
  -6.18791534e-03f, 1.69293322e-02f, 9.02377889e-02f, -1.82245653e-02f, -2.02950630e-02f, -6.47625178e-02f, -4.03257124e-02f, -1.33292219e-02f, 1.03587015e-02f, -9.97353718e-02f,
  -1.40909990e-02f, 2.51361672e-02f, -2.64888704e-02f, 4.95453291e-02f, 1.24035776e-03f, -2.12980229e-02f, -3.83150503e-02f, -3.28731015e-02f, 7.71446293e-03f, 2.65281694e-03f,
  4.07442898e-02f, -1.87045857e-02f, 5.32692634e-02f, -5.26288431e-03f, -3.17669613e-03f, 1.45171126e-02f, 3.58590460e-03f, 3.78221571e-02f, -3.56795639e-02f, -3.97048146e-02f,
  1.13921538e-02f, 2.83881221e-02f, -2.56431904e-02f, -3.01164873e-02f, 8.02382361e-03f, -5.29322140e-02f, -7.54907653e-02f, -4.72147856e-03f, 4.69865352e-02f, -3.88153307e-02f,
  2.80080102e-02f, 5.24344807e-03f, 3.29176970e-02f, -5.93942851e-02f, -1.49678579e-02f, -1.88076068e-02f, 5.08895852e-02f, 5.06528246e-04f, 3.29176635e-02f, -8.72843899e-03f,
  2.08860159e-01f, 3.12452167e-01f, 7.65159726e-02f, 7.86583722e-02f, -2.12059729e-02f, -5.56509010e-03f, 2.02089846e-02f, 4.03716527e-02f, 6.56187683e-02f, 3.34673114e-02f,
  -8.88508279e-03f, 9.09925438e-03f, -4.56015766e-02f, -1.55562544e-02f, 4.42304052e-02f, 9.39766318e-02f, -8.37312359e-03f, 5.89207038e-02f, 5.58094010e-02f, 1.69257987e-02f,
  -1.46456799e-02f, -3.37338410e-02f, -5.63059039e-02f, 7.15342388e-02f, -9.83012095e-03f, 2.62199645e-03f, 4.40492593e-02f, -4.06883880e-02f, -3.32559049e-02f, 7.03433976e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.39076781e-01f, 1.79850847e-01f, 1.01650737e-01f, -1.09474801e-01f, -2.58512050e-01f, 9.70746577e-03f, 4.07494465e-03f, -1.25242159e-01f, 4.62630950e-02f, 2.21817628e-01f,
  1.75154150e-01f, -1.43560190e-02f, 2.37586662e-01f, 2.70952463e-01f, -2.84135282e-01f, 2.23100036e-01f, -1.57864857e-02f, 9.66996998e-02f, -9.09469556e-03f, -4.26899754e-02f,
  -1.04896747e-01f, 3.78424190e-02f, 9.47459042e-02f, 1.39623657e-02f, -6.55345321e-02f, -1.00777678e-01f, 9.12709236e-02f, -7.49428868e-02f, 7.46122301e-02f, -5.27501777e-02f,
  -9.17612389e-02f, -1.65407509e-01f, -3.39471735e-02f, -1.17833599e-01f, -7.90999681e-02f, -8.22355077e-02f, -7.03601092e-02f, 6.04878506e-03f, 4.53291982e-02f, -4.48866375e-02f,
  -3.07271089e-02f, 2.27024257e-02f, -4.09127995e-02f, -5.06806225e-02f, -8.13875720e-02f, 5.13065904e-02f, 4.07796577e-02f, 9.74127464e-03f, 4.54008020e-02f, -6.31045774e-02f,
  -7.64858350e-03f, 9.93920676e-03f, 3.94241177e-02f, 1.15774103e-01f, 6.53594062e-02f, -4.28092852e-02f, 8.17443803e-02f, -7.14789480e-02f, -3.22338417e-02f, -3.28593031e-02f,
  -5.63102625e-02f, -8.09333287e-03f, 9.05022994e-02f, -8.84995013e-02f, 3.28743756e-02f, -1.99585408e-02f, 3.52166072e-02f, 5.66022620e-02f, -3.53516303e-02f, -2.57433634e-02f,
  4.90640290e-04f, 1.88284162e-02f, -9.63875800e-02f, 1.78738069e-02f, -6.10323213e-02f, -5.55740707e-02f, -2.19675153e-02f, -6.50275359e-03f, 5.72809614e-02f, 2.94049866e-02f,
  8.60583931e-02f, -7.53089264e-02f, 5.87781109e-02f, -3.33476029e-02f, -4.08703871e-02f, 1.15611563e-02f, -6.00930266e-02f, 1.67911611e-02f, -2.13300101e-02f, 6.97109429e-03f,
  -1.49497241e-01f, -1.96879849e-01f, 2.46007014e-02f, -1.83289312e-02f, -3.32263634e-02f, -3.58073451e-02f, 4.66197692e-02f, -2.12661792e-02f, -2.52242964e-02f, -1.31185308e-01f,
  -9.63374898e-02f, -5.18693142e-02f, -3.17510366e-02f, -4.46809009e-02f, -5.12355976e-02f, -1.49205225e-02f, -1.01688514e-02f, -8.02272372e-03f, -9.53622833e-02f, -3.99779864e-02f,
  -8.03709403e-03f, -6.34305552e-02f, -2.57808454e-02f, 5.50756045e-03f, -4.31063734e-02f, 8.10384303e-02f, -2.37441678e-02f, 6.20768145e-02f, 5.18365251e-03f, 5.87047376e-02f,
  9.16777700e-02f, -2.71872848e-01f, 4.96244989e-02f, 1.24897137e-01f, 2.02832669e-01f, 9.70162973e-02f, 1.60836041e-01f, -3.33853550e-02f, -1.35913402e-01f, -8.82105678e-02f,
  7.52883255e-02f, -4.51088101e-02f, -4.87883948e-02f, 4.74688783e-02f, 1.28771156e-01f, -1.28379181e-01f, -2.32194010e-02f, 8.46586153e-02f, -2.79317442e-02f, -6.43790811e-02f,
  2.51817070e-02f, -2.97825113e-02f, 5.74568100e-03f, 3.40223201e-02f, 1.10739946e-01f, -9.20378342e-02f, 1.30105228e-03f, -2.30548903e-02f, 1.05660006e-01f, 3.76285352e-02f,
  4.72791903e-02f, -6.37587681e-02f, -9.87477824e-02f, -2.66344417e-02f, -3.39521677e-03f, 5.65014444e-02f, -4.12910767e-02f, 1.36327848e-01f, -3.81733663e-02f, -8.93387496e-02f,
  1.07982839e-02f, 5.07211164e-02f, 9.66230116e-04f, -4.72064167e-02f, -5.69354817e-02f, 8.17791224e-02f, 6.80882335e-02f, 4.82863076e-02f, -9.60761216e-03f, 6.27226830e-02f,
  2.86228377e-02f, -1.51459258e-02f, 5.01758866e-02f, 5.15633496e-03f, 6.90373406e-02f, -5.36791012e-02f, 4.10194285e-02f, 7.97989070e-02f, -3.05742435e-02f, 7.27346838e-02f,
  -8.19826201e-02f, -3.99569534e-02f, -1.14181424e-02f, 7.74399203e-04f, 1.77250486e-02f, -6.20829349e-04f, 5.73437512e-02f, -9.45578981e-03f, -1.79404579e-02f, 5.36670759e-02f,
  -3.33241820e-02f, 5.99010512e-02f, 2.13536602e-02f, -8.99561495e-03f, -4.32390836e-04f, -4.86785322e-02f, 6.46295175e-02f, 2.10623797e-02f, -7.49463588e-02f, 5.77335944e-03f,
  -5.55745438e-02f, -5.26519604e-02f, -8.35535116e-03f, -4.58701104e-02f, 1.67849604e-02f, -3.20130512e-02f, -1.01359691e-02f, -9.10086706e-02f, -7.74423257e-02f, 3.31851542e-02f,
  -5.66200688e-02f, -1.01413913e-01f, -6.89415857e-02f, 3.71323191e-02f, 1.33873662e-02f, 3.25031318e-02f, 7.10823908e-02f, -1.37461051e-02f, -6.49577752e-02f, 1.65519305e-02f,
  -2.94928346e-02f, 9.37085226e-03f, 8.80448055e-03f, 1.22654671e-02f, -4.60701510e-02f, 9.07072797e-03f, -6.68290257e-02f, -1.00582279e-03f, -1.79732982e-02f, -8.28280523e-02f,
  4.15278831e-03f, -1.65050812e-02f, 1.57184247e-02f, -3.96868074e-03f, 1.37381470e-02f, 2.94709578e-02f, -5.72411306e-02f, -1.97669286e-02f, 3.82906385e-02f, -7.69061297e-02f,
  -2.33102947e-01f, -1.42311901e-01f, 2.87894011e-01f, -1.89282253e-01f, 7.80624673e-02f, 2.35561952e-01f, 4.69585024e-02f, 6.08603954e-02f, -2.33309418e-01f, -1.21625789e-01f,
  -8.66834298e-02f, -8.20601285e-02f, 1.11024000e-01f, 2.98508499e-02f, 2.27273449e-01f, 7.68649951e-02f, -1.00692920e-01f, -4.33005691e-02f, -1.90748833e-02f, -1.00377128e-01f,
  3.85879762e-02f, -1.42320678e-01f, 1.19436815e-01f, 3.62887532e-02f, -4.86194044e-02f, -1.27553329e-01f, -1.52598545e-02f, 1.03989653e-01f, 2.01192182e-02f, 1.26362175e-01f,
  1.18623758e-02f, -5.20727895e-02f, -1.25732794e-02f, 5.28498404e-02f, 4.32881191e-02f, -3.68355541e-03f, 9.14947987e-02f, 7.09582120e-02f, 7.17555285e-02f, 3.33391577e-02f,
  -3.66323180e-02f, 4.21951413e-02f, -9.82682183e-02f, -2.22585853e-02f, 4.16175015e-02f, -1.78493764e-02f, 6.34502107e-03f, 4.99331914e-02f, 7.05861971e-02f, 5.22963591e-02f,
  1.20256938e-01f, 4.94666323e-02f, -1.30347023e-02f, -5.37808985e-02f, 6.27146661e-02f, 5.03633320e-02f, 2.19321027e-02f, 2.45639402e-02f, -8.03367496e-02f, -4.09070738e-02f,
  3.04840617e-02f, 6.72000721e-02f, 9.86980051e-02f, 6.96182773e-02f, 4.91317883e-02f, -3.40253636e-02f, 1.28114142e-03f, -4.90698814e-02f, 4.88791503e-02f, 2.83677746e-02f,
  1.90455411e-02f, -7.43971765e-02f, 2.72896886e-02f, 4.31170166e-02f, -4.83211391e-02f, -5.25008738e-02f, 4.20097634e-02f, -2.78470088e-02f, -4.05940935e-02f, 7.01220781e-02f,
  -4.08172570e-02f, -6.97775185e-02f, -5.32236462e-03f, 3.11134271e-02f, 8.78602117e-02f, 6.28083646e-02f, 2.12188531e-02f, -4.19466868e-02f, -5.13996696e-03f, -3.06740515e-02f,
  -4.48179767e-02f, -9.29751173e-02f, 5.38223190e-03f, 1.12767369e-02f, 3.29439864e-02f, -3.82125825e-02f, -3.06543726e-02f, -5.09498604e-02f, 3.86074632e-02f, -2.82175522e-02f,
  3.55194099e-02f, 1.40573429e-02f, 3.67331319e-02f, 1.47082785e-03f, 8.84665921e-02f, 1.28934514e-02f, -3.12110242e-02f, 5.23216873e-02f, -1.88701022e-02f, 2.70530283e-02f,
  5.56754060e-02f, 3.03936601e-02f, -4.91472371e-02f, -1.86815771e-04f, 1.39948083e-02f, 4.62886281e-02f, -3.98819149e-02f, -1.88137610e-02f, 1.03380181e-01f, -1.17580071e-02f,
  -2.59898975e-02f, 1.83047652e-02f, 7.47176632e-02f, 2.20954642e-02f, -8.23757648e-02f, 1.99925661e-01f, 1.60762563e-01f, 3.86293568e-02f, -2.92194891e-03f, 1.16477586e-01f,
  -3.92056182e-02f, 4.81680855e-02f, 5.07230759e-02f, -1.22575304e-02f, -1.66897345e-02f, 4.82501052e-02f, 1.14348382e-01f, 1.75330356e-01f, -1.01375543e-02f, 1.12430360e-02f,
  -5.91148473e-02f, 4.84081954e-02f, -6.71215281e-02f, -1.23193953e-02f, -6.26266450e-02f, -7.95134157e-02f, -4.62988019e-02f, -6.09000027e-02f, -1.51055316e-02f, 4.36597504e-02f,
  -7.32512325e-02f, 4.05730233e-02f, -7.47203976e-02f, -5.50095178e-02f, 8.53986479e-03f, -3.55775543e-02f, -5.58440909e-02f, 8.34756047e-02f, -6.13133647e-02f, -2.00568661e-02f,
  -6.94459453e-02f, -4.67856899e-02f, 1.92636661e-02f, 4.56500612e-02f, -6.29893243e-02f, -2.54914891e-02f, -6.59687072e-02f, 5.65661676e-02f, -7.57144764e-02f, -5.69476299e-02f,
  4.17656861e-02f, -1.31130517e-02f, 4.62081172e-02f, 1.06695361e-01f, -6.18229583e-02f, 4.75781709e-02f, -3.45818922e-02f, 6.10791557e-02f, -7.20144883e-02f, -2.65517458e-02f,
  -6.58632070e-02f, -5.27909840e-04f, -5.77826090e-02f, -7.74917975e-02f, 7.98796490e-02f, 7.52930576e-03f, -6.60239607e-02f, 8.07908401e-02f, 5.15770130e-02f, 4.91163023e-02f,
  -7.28367120e-02f, -3.52651952e-03f, 3.37531394e-03f, -8.17544535e-02f, 1.01603739e-01f, 1.07400101e-02f, 8.20245147e-02f, 7.82761872e-02f, -2.98138112e-02f, 6.41037198e-03f,
  2.55647730e-02f, -7.05645978e-02f, 1.41108409e-02f, -2.82855649e-02f, 8.95963162e-02f, -7.93149322e-02f, -9.06841010e-02f, -9.94657651e-02f, -6.66664764e-02f, -7.16829374e-02f,
  7.21283955e-03f, 1.20718352e-01f, -8.27992931e-02f, 7.97621813e-03f, 4.70725112e-02f, -7.83570632e-02f, 5.73234670e-02f, -2.97535565e-02f, 1.67826395e-02f, 2.72491463e-02f,
  1.06582694e-01f, 5.76021001e-02f, 5.42711802e-02f, -9.27829649e-03f, -5.55897169e-02f, -1.76362358e-02f, 8.11712146e-02f, 3.74684259e-02f, 6.30448014e-02f, 6.70233369e-02f,
  -6.08990975e-02f, -5.80582432e-02f, 4.73276107e-03f, -4.03593518e-02f, 8.66809264e-02f, -5.64328469e-02f, -1.80407893e-02f, -2.19066367e-02f, 4.65110317e-02f, 3.39017957e-02f,
  2.19775409e-01f, -2.00526327e-01f, 1.03441380e-01f, 3.05624157e-01f, 5.67158349e-02f, -1.22624435e-01f, 1.01473287e-01f, 4.07922491e-02f, 2.39076316e-01f, -2.12834254e-01f,
  -6.41791755e-03f, 3.83437052e-02f, -6.35355860e-02f, 2.01166868e-02f, 1.54494241e-01f, -7.88658783e-02f, 2.71076802e-02f, 1.00080492e-02f, 1.38264582e-01f, 1.22153580e-01f,
  1.73339859e-01f, 7.58842602e-02f, 5.13936467e-02f, -3.52755971e-02f, -9.27233398e-02f, -4.27032448e-02f, 6.54124608e-03f, -1.19775310e-01f, -1.28765270e-01f, -5.79723194e-02f,
  -1.04512414e-02f, 6.66366443e-02f, 5.57514876e-02f, -3.74279618e-02f, 1.47929825e-02f, -1.15025260e-01f, -5.98811880e-02f, -6.85506016e-02f, 3.74801792e-02f, -4.88631651e-02f,
  1.79718640e-02f, -3.79440859e-02f, 5.71093075e-02f, -1.73959602e-02f, 2.37004813e-02f, -1.71399713e-02f, 1.97494552e-02f, -4.51906957e-02f, -1.14095956e-02f, 6.06077202e-02f,
  1.67134032e-02f, 2.22046468e-02f, 2.63082776e-02f, -8.72974768e-02f, 5.60852252e-02f, 6.51518628e-02f, -5.61751984e-02f, -6.20450601e-02f, -6.04941398e-02f, 5.30756675e-02f,
  -1.79590490e-02f, 2.25984380e-02f, -1.05811387e-01f, -4.20980714e-02f, 3.11624762e-02f, -3.06037571e-02f, 1.69036188e-03f, -2.02043001e-02f, -2.67875474e-03f, 7.50889853e-02f,
  -4.31700721e-02f, 3.43339099e-03f, 8.81879851e-02f, 1.39397942e-03f, -2.32160203e-02f, 3.79141979e-02f, -2.49447972e-02f, 3.90305370e-03f, 7.91245177e-02f, 5.83247356e-02f,
  -1.07888561e-02f, -2.86723822e-02f, -6.88904375e-02f, -5.58943786e-02f, 3.03865839e-02f, -6.83549345e-02f, -1.73229370e-02f, -7.36272112e-02f, 2.15830989e-02f, -4.47144508e-02f,
  1.60413831e-02f, -4.59104031e-02f, 3.67969535e-02f, 1.20613826e-02f, -7.67646059e-02f, -7.84870088e-02f, -1.56673826e-02f, -8.22860561e-03f, -2.90757250e-02f, 1.88622754e-02f,
  3.07607539e-02f, -6.13624938e-02f, -7.61644915e-02f, 3.03128716e-02f, 2.72324774e-02f, 5.34900799e-02f, 1.86114025e-03f, 7.06876442e-02f, -5.80712073e-02f, -6.08092174e-02f,
  4.02002595e-02f, -2.70377025e-02f, 6.60110265e-02f, 3.38912420e-02f, 5.64785264e-02f, -4.39544879e-02f, 6.17079157e-03f, 5.78211397e-02f, -8.41416419e-02f, 2.08094232e-02f,
  7.38946944e-02f, -3.20979744e-01f, 1.56064808e-01f, -4.81385142e-02f, -7.43888393e-02f, -1.15873121e-01f, 1.81341887e-01f, -3.88469398e-01f, -1.69542655e-01f, -3.14709902e-01f,
  -1.01130165e-01f, 1.85251072e-01f, 2.39180863e-01f, -2.71696597e-01f, 4.96489882e-01f, 7.74362758e-02f, -2.86704212e-01f, -2.24777218e-03f, 1.94106232e-02f, -1.67038336e-01f,
  1.85808986e-02f, -2.14062080e-01f, 3.42064574e-02f, -3.33955050e-01f, -1.67838603e-01f, -1.32579327e-01f, 1.22400999e-01f, 9.14291888e-02f, -2.19835892e-01f, 1.68033376e-01f,
  -1.10529691e-01f, -2.30600253e-01f, -3.59600261e-02f, -5.14186360e-02f, -2.96202172e-02f, -1.02031296e-02f, 7.91129842e-02f, 1.73467755e-01f, 1.79847386e-02f, 2.46937852e-02f,
  7.64195397e-02f, -5.38152410e-03f, -1.48207203e-01f, 1.17478915e-01f, -7.96674192e-02f, -1.03874445e-01f, -2.56133848e-03f, -7.05307052e-02f, -2.84818877e-02f, -4.06128122e-03f,
  -1.02386978e-02f, -8.55325311e-02f, 5.22090308e-03f, 7.13155344e-02f, 8.41106754e-03f, -7.65194818e-02f, 3.46326493e-02f, 1.04805484e-01f, -6.85021132e-02f, -3.87857743e-02f,
  2.45563667e-02f, -2.16077827e-02f, 8.21100548e-03f, 3.20921540e-02f, -3.44724916e-02f, -4.68889019e-04f, 1.05410097e-02f, 4.55733538e-02f, 6.42104866e-03f, -3.96919064e-02f,
  1.73581466e-02f, 4.48126271e-02f, -3.72743830e-02f, 7.80659076e-03f, -1.16782906e-02f, 1.00068245e-02f, 5.14265299e-02f, 2.26669293e-02f, -2.30745580e-02f, 1.20415743e-02f,
  5.44705428e-02f, 1.04493564e-02f, 1.28942623e-03f, 1.51835475e-02f, -8.91110674e-03f, 4.12574075e-02f, -4.58246879e-02f, 2.00291220e-02f, 4.37787063e-02f, 8.40980336e-02f,
  -1.59241855e-01f, -1.81293234e-01f, -7.18959868e-02f, 1.76392607e-02f, -4.50826958e-02f, -7.87664652e-02f, -7.16037229e-02f, -1.14291213e-01f, 1.53491944e-02f, -4.76509444e-02f,
  -5.53570651e-02f, 6.85365638e-03f, -8.77317414e-02f, 2.74102967e-02f, -1.43461525e-02f, -3.07663530e-02f, 4.20413688e-02f, 2.50122119e-02f, 9.07317083e-03f, -7.56390318e-02f,
  -1.91585980e-02f, 5.68266101e-02f, 4.02220860e-02f, -4.00319621e-02f, -2.50313859e-02f, 7.05596209e-02f, -1.30876191e-02f, 8.67334977e-02f, -2.14022659e-02f, -1.37596056e-02f,
  1.81255549e-01f, -3.07271451e-01f, 1.56261958e-02f, 1.16869003e-01f, 1.00807890e-01f, 1.35315746e-01f, 2.15687558e-01f, -6.44851774e-02f, -1.26070395e-01f, -1.80009454e-01f,
  1.20891199e-01f, -7.63121769e-02f, -1.28220972e-02f, 3.96191590e-02f, 2.48050123e-01f, -3.17484103e-02f, 7.73457661e-02f, 3.77955250e-02f, -2.46280618e-02f, 2.40160599e-02f,
  1.45423457e-01f, 1.16201984e-02f, 2.32053585e-02f, -1.06816076e-01f, 3.74622941e-02f, -7.94501081e-02f, 1.16130582e-03f, 2.79390551e-02f, -2.73390412e-02f, 5.54895103e-02f,
  4.39233445e-02f, -2.25532316e-02f, 1.12359487e-02f, 1.85596524e-03f, -1.14913797e-02f, 1.92776918e-02f, 9.60784405e-02f, 8.63862559e-02f, 8.64131972e-02f, -7.82065764e-02f,
  -2.24200301e-02f, -4.19116691e-02f, 3.53200994e-02f, -9.01021808e-03f, 1.16194412e-02f, -3.52866836e-02f, -5.16628437e-02f, -3.54478434e-02f, 4.63210940e-02f, -9.13593639e-03f,
  1.20252883e-02f, -3.40153836e-02f, -1.26808975e-02f, -1.31783232e-01f, -8.86987671e-02f, 3.97170782e-02f, -4.14564312e-02f, -2.69796010e-02f, 4.28067595e-02f, -4.86493148e-02f,
  -5.81640080e-02f, -7.06347525e-02f, -4.45113666e-02f, -4.52479012e-02f, 9.85433254e-03f, 1.29380636e-02f, -4.15264480e-02f, 3.61891948e-02f, -1.25719653e-02f, -5.00712357e-02f,
  1.59804132e-02f, 1.44006982e-02f, 2.25357432e-02f, -1.38154039e-02f, -3.98802496e-02f, -4.63738525e-03f, 4.95052822e-02f, 3.44610848e-02f, 2.21154522e-02f, 1.02578597e-02f,
  2.05920381e-03f, -2.69273091e-02f, 2.19164486e-03f, -5.36381453e-02f, -8.93315747e-02f, 2.88316258e-03f, -6.85071275e-02f, -1.20736687e-02f, 1.93283856e-02f, 2.19870321e-02f,
  -4.88824435e-02f, -2.04292029e-01f, -2.60147620e-02f, 2.34326739e-02f, 3.43267829e-03f, 2.09698807e-02f, -4.62819673e-02f, -7.45277852e-02f, -3.56902718e-03f, -4.24359553e-02f,
  -7.93993175e-02f, 2.77879485e-03f, -3.52124753e-03f, 9.61816288e-04f, -1.02800671e-02f, 9.41318646e-03f, -4.63965386e-02f, 2.32605301e-02f, -2.27845879e-03f, 4.17468734e-02f,
  -2.73032300e-02f, -9.18850601e-02f, -2.37400122e-02f, 8.25907663e-03f, -2.59871036e-02f, -3.63756865e-02f, -8.58344510e-02f, -2.56534480e-02f, -7.49735045e-04f, -8.31811205e-02f,
  -2.00562268e-01f, -9.47797969e-02f, -1.47104144e-01f, -8.46123546e-02f, 5.58628067e-02f, 1.55415356e-01f, 1.43169733e-02f, -3.42581086e-02f, -8.09707195e-02f, 7.94827789e-02f,
  1.53291240e-01f, -1.16891101e-01f, -8.01815689e-02f, 7.63375163e-02f, -6.64320290e-02f, -6.03694357e-02f, 5.29333241e-02f, 1.21444717e-01f, 1.25031248e-02f, -1.18125789e-02f,
  -4.03078683e-02f, 2.08561346e-01f, 4.18270826e-02f, 1.21517643e-01f, 7.93218017e-02f, 1.57242492e-02f, 1.48273453e-01f, -6.45724162e-02f, 2.05811277e-01f, 1.63183391e-01f,
  -8.11398402e-02f, -9.66048688e-02f, -3.14703248e-02f, -6.30280599e-02f, -7.89767951e-02f, -3.34074870e-02f, 9.15476680e-03f, -1.20397722e-02f, -1.95388608e-02f, 4.19065505e-02f,
  -1.06576890e-01f, 5.57902120e-02f, 8.04188997e-02f, 7.13375211e-02f, 5.43439426e-02f, -4.37569767e-02f, 4.95601110e-02f, -2.71885959e-03f, -7.26916119e-02f, -8.77312273e-02f,
  -1.91106591e-02f, 1.29645085e-02f, 7.83176348e-02f, -2.20185071e-02f, -6.23292513e-02f, -3.48402001e-02f, -3.24168727e-02f, 1.22701181e-02f, -1.97031209e-03f, 5.15261069e-02f,
  -3.76396477e-02f, -6.49435148e-02f, -9.34239849e-03f, -4.50889505e-02f, 2.56284140e-02f, 1.92061141e-02f, 4.57595475e-02f, 5.45688644e-02f, -8.67774189e-02f, 4.08846289e-02f,
  -4.82373610e-02f, -5.60097173e-02f, -5.01694530e-02f, 5.82184419e-02f, 6.76740706e-02f, 4.95020635e-02f, -7.10435435e-02f, 7.55739063e-02f, 4.06480543e-02f, -7.10844025e-02f,
  -3.13841179e-02f, 4.55112085e-02f, 6.41507143e-03f, 5.35497777e-02f, -3.94637436e-02f, -4.58596200e-02f, 5.30358553e-02f, -4.60517826e-03f, -4.34697308e-02f, -1.02639496e-02f,
  5.84875718e-02f, -1.15809865e-01f, -2.81205233e-02f, 2.81369034e-02f, -8.33549276e-02f, -7.04096258e-02f, 5.26157729e-02f, 3.25069651e-02f, -7.51541704e-02f, -4.41492461e-02f,
  1.67496838e-02f, 8.76059383e-02f, 5.11441231e-02f, -4.33719866e-02f, 7.72255957e-02f, 5.89979663e-02f, -4.72428929e-03f, 4.15573418e-02f, 2.80939247e-02f, -2.44182255e-02f,
  4.24922444e-02f, -7.65495189e-03f, 3.92200798e-02f, 3.62524576e-02f, 8.55578035e-02f, -3.36813591e-02f, -2.65784264e-02f, -1.21105919e-02f, 7.83844292e-02f, 1.90734472e-02f,
  1.19601889e-02f, 1.61014736e-01f, 2.16634244e-01f, -3.45980003e-02f, -1.00209109e-01f, -3.28256898e-02f, -3.93428020e-02f, -2.79071019e-03f, -7.13416422e-03f, 1.05917215e-01f,
  -1.26954973e-01f, 3.13064307e-01f, 6.55888841e-02f, 4.87124808e-02f, -1.18064284e-01f, -1.74035877e-01f, -1.62141472e-01f, 5.02196215e-02f, -8.76261219e-02f, -1.19788582e-02f,
  -1.60695508e-01f, -2.69901812e-01f, -4.09087129e-02f, -1.21298440e-01f, 7.85008296e-02f, 1.19208716e-01f, -2.21355781e-01f, 4.65423651e-02f, -3.16406749e-02f, 3.80462245e-03f,
  -1.00471109e-01f, 8.70991051e-02f, 5.47235347e-02f, 2.54981946e-02f, -7.73379803e-02f, -3.92732620e-02f, -5.33995545e-03f, 3.62777449e-02f, -3.23850252e-02f, 5.69453649e-02f,
  9.98283252e-02f, 2.83307508e-02f, -2.62236744e-02f, 8.62855930e-03f, 7.86556154e-02f, 1.04810812e-01f, -4.24675867e-02f, -1.78836696e-02f, 1.01528227e-01f, 1.07361257e-01f,
  7.50908405e-02f, 4.36229669e-02f, -1.43222902e-02f, 1.06589064e-01f, -6.52014166e-02f, -7.08754733e-02f, 1.61006767e-02f, 1.26135419e-03f, 1.03244483e-01f, -6.15211343e-03f,
  5.06442860e-02f, -7.96816945e-02f, -7.71976961e-03f, 2.44321097e-02f, 8.49039182e-02f, -1.76948458e-02f, 4.29561324e-02f, -1.25291422e-02f, -7.75898769e-02f, -5.05362935e-02f,
  -2.24270014e-04f, -5.05968928e-03f, 3.33584822e-03f, -1.76837686e-02f, 5.66286407e-03f, 8.48161522e-03f, -5.83453744e-04f, 9.65682194e-02f, -5.46586774e-02f, 2.98081860e-02f,
  2.61913966e-02f, 3.38476598e-02f, 1.12248659e-01f, -2.79719848e-02f, 5.05367890e-02f, -2.83065289e-02f, -7.80850975e-03f, 1.74116623e-02f, -8.10725987e-03f, -9.18011516e-02f,
  -2.94191372e-02f, -1.63251325e-01f, 2.31410842e-02f, -5.09214401e-03f, -4.34825942e-03f, -6.61330000e-02f, 6.79726014e-03f, -4.17141430e-02f, -2.51885429e-02f, -2.94875931e-02f,
  -6.95136860e-02f, 1.53403240e-03f, 3.10536996e-02f, 6.32907152e-02f, 1.66331511e-02f, -9.07817557e-02f, -9.15037841e-02f, -3.45927924e-02f, -1.21278884e-02f, 3.79401296e-02f,
  7.50267133e-02f, -4.61792275e-02f, -4.75456798e-03f, -7.80148059e-02f, -1.62512511e-02f, -8.12683851e-02f, 1.51227787e-02f, 5.08259125e-02f, -4.84609567e-02f, 6.39297962e-02f,
  1.02866478e-01f, 7.12040961e-02f, -1.08764887e-01f, 6.04406595e-02f, 1.13753602e-01f, -1.03805019e-02f, -2.70679891e-02f, 1.65384803e-02f, 1.77949876e-01f, -4.15851139e-02f,
  -1.50988642e-02f, -8.22958276e-02f, 2.84166113e-02f, 1.63929712e-03f, 6.44574165e-02f, -1.11705707e-02f, -6.21321760e-02f, -2.09805164e-02f, 8.20246264e-02f, 5.27515970e-02f,
  -3.52587588e-02f, 2.41433047e-02f, -8.13673586e-02f, -2.70304619e-03f, -1.34722993e-01f, -1.03020497e-01f, -1.14551499e-01f, -5.57690859e-02f, -2.46418249e-02f, 6.35750517e-02f,
  -8.97360891e-02f, 1.06975496e-01f, 2.42677499e-02f, -4.42014486e-02f, 6.30019903e-02f, -7.29184225e-02f, -1.72340833e-02f, 2.00910345e-02f, -2.69765127e-02f, -3.10735106e-02f,
  -3.54537629e-02f, 1.88594516e-02f, -3.02725611e-03f, 2.21195649e-02f, 2.15079840e-02f, -7.31996298e-02f, -2.04165019e-02f, -8.91404524e-02f, 6.04426675e-02f, -1.48904894e-03f,
  -3.95713933e-02f, -9.55573916e-02f, 5.91194779e-02f, -8.82362202e-02f, 3.30839753e-02f, -4.94850986e-02f, -1.06298430e-02f, -2.43918300e-02f, 1.38637302e-02f, 1.00936316e-01f,
  1.22792926e-03f, 1.00296345e-02f, -1.21276462e-02f, -3.55938822e-02f, 9.41246375e-02f, 8.75381660e-03f, -1.35098665e-03f, -3.04115377e-02f, 1.52734127e-02f, 4.25271504e-02f,
  -5.23572974e-03f, 2.34693307e-02f, 4.29628463e-03f, -6.74212277e-02f, -7.41469339e-02f, -6.18564524e-02f, -8.52217749e-02f, 5.76794706e-03f, 3.42725292e-02f, 7.37973303e-02f,
  5.78676239e-02f, 6.54456615e-02f, -5.09625785e-02f, -1.21040652e-02f, 4.39429702e-03f, 3.78449000e-02f, 5.21671027e-02f, -8.30047205e-02f, 5.31681627e-03f, 7.79855177e-02f,
  2.43759733e-02f, 2.84191184e-02f, 1.56718143e-03f, 8.08838457e-02f, -6.52951375e-02f, -7.32052699e-02f, 4.12111171e-02f, 1.49759359e-03f, 2.12537888e-02f, 4.76169474e-02f,
  -4.14291434e-02f, -8.44769999e-02f, 3.34417671e-02f, 7.87533522e-02f, -1.64354462e-02f, 3.91709581e-02f, -1.01266682e-01f, -5.56458049e-02f, 3.20900865e-02f, 5.52065596e-02f,
  7.06145093e-02f, 4.43513952e-02f, 7.05346419e-03f, -5.44666573e-02f, -9.37159434e-02f, 1.76047664e-02f, 7.96035025e-03f, -6.43718392e-02f, -1.05026819e-01f, -4.53578122e-02f,
  1.49694592e-01f, -1.76983207e-01f, 1.62801847e-01f, 2.99942970e-01f, 2.31219098e-01f, 9.59195197e-02f, 2.13853285e-01f, 2.16473341e-01f, 4.17329431e-01f, -1.96244225e-01f,
  -3.48978899e-02f, -9.38387066e-02f, -1.01563990e-01f, 4.68241312e-02f, -1.87083222e-02f, -8.74343142e-02f, 1.05576195e-01f, -5.64422570e-02f, 1.09827772e-01f, 7.58506265e-03f,
  1.49728060e-01f, -1.23283863e-01f, -6.21261559e-02f, -2.06445947e-01f, 1.12983227e-01f, -5.21354415e-02f, -2.05170259e-01f, -1.06905282e-01f, -1.74809784e-01f, -9.36603695e-02f,
  -4.26879600e-02f, 1.39662176e-01f, -6.82300031e-02f, -2.45504472e-02f, -4.03047241e-02f, 5.07889129e-02f, -1.06127735e-03f, -1.46790082e-02f, 4.01578210e-02f, 9.91095603e-02f,
  -7.01659918e-02f, 5.72423302e-02f, -3.83774005e-02f, -3.02122068e-02f, 1.60917714e-02f, 4.20903899e-02f, 6.21961728e-02f, 9.11393240e-02f, 4.36849473e-03f, 7.25502074e-02f,
  -3.41967009e-02f, -2.00130567e-02f, 2.72973552e-02f, 1.88658740e-02f, 2.16393135e-02f, -2.02457476e-02f, -2.70738564e-02f, -1.04054637e-01f, -2.02073785e-03f, 2.16227844e-02f,
  3.05953249e-02f, -6.05455115e-02f, 4.45594117e-02f, 3.75760458e-02f, 2.50071362e-02f, 4.01226133e-02f, -3.14412341e-02f, -6.28447086e-02f, 1.30907679e-02f, 2.03572884e-02f,
  -1.38728172e-02f, 4.45990562e-02f, 4.74644899e-02f, -4.54722671e-03f, 5.58347739e-02f, 1.16200767e-01f, 4.78508025e-02f, 7.46532381e-02f, 3.90985906e-02f, 8.66738930e-02f,
  5.80677651e-02f, -3.64364460e-02f, -1.21853910e-02f, 1.03273652e-01f, 4.61094966e-03f, -1.21467169e-02f, 4.77453656e-02f, 1.62564423e-02f, 7.33740926e-02f, -1.45993689e-02f,
  -1.02636799e-01f, -1.73283443e-01f, -1.04327291e-01f, 1.66343804e-02f, -2.32036375e-02f, -8.38562027e-02f, -3.40489633e-02f, -3.35642248e-02f, -3.40073369e-02f, -4.96790744e-03f,
  9.52520594e-03f, 9.35236439e-02f, -7.67624229e-02f, -3.81155941e-03f, -7.91407228e-02f, 3.04679107e-02f, 2.67496984e-02f, -5.90905957e-02f, -7.87040219e-02f, -1.19148925e-01f,
  -2.01688372e-02f, 2.63692085e-02f, 1.73351336e-02f, -4.60554659e-02f, -4.31714877e-02f, -3.65328602e-02f, 3.12340651e-02f, -4.02681902e-02f, -5.90985268e-02f, -1.23472279e-02f,
  1.13760792e-01f, 1.78063110e-01f, 1.42447710e-01f, -3.32890376e-02f, -1.00668162e-01f, 9.38698575e-02f, -4.12693322e-02f, 1.75524149e-02f, 1.65991709e-02f, 1.26442939e-01f,
  -6.73416490e-03f, 1.70599937e-01f, -7.20023271e-03f, 1.52771145e-01f, -4.69480865e-02f, -5.61923310e-02f, 9.77294967e-02f, 8.37779194e-02f, 2.80856322e-02f, 3.80062312e-02f,
  4.12332639e-02f, -1.07122295e-01f, 3.40415277e-02f, -1.14198156e-01f, 3.92442085e-02f, -1.55046051e-02f, -1.68723509e-01f, -8.97659585e-02f, 8.93316939e-02f, 4.15652283e-02f,
  1.50581554e-01f, 1.35548953e-02f, 5.24386950e-03f, 1.07187465e-01f, 9.60917398e-02f, -3.46557610e-02f, 1.37293544e-02f, -5.08025177e-02f, -3.61008346e-02f, 7.80950533e-03f,
  -5.67801148e-02f, 5.81971556e-02f, 3.57136992e-03f, -9.51788276e-02f, -2.83533335e-02f, -2.68503446e-02f, 7.38173425e-02f, -3.45169683e-04f, -2.66393721e-02f, 1.48348520e-02f,
  8.14963281e-02f, 8.78770873e-02f, -7.26413727e-02f, 7.26722647e-03f, 1.88541505e-02f, 4.54014391e-02f, 5.02913594e-02f, -4.72693145e-02f, -2.27153841e-02f, 5.59811890e-02f,
  8.92688613e-03f, -7.52332807e-02f, -5.19833453e-02f, 5.40937446e-02f, -5.19573465e-02f, -6.60497621e-02f, -8.81790463e-03f, -1.25543149e-02f, -6.52034394e-03f, 8.51302892e-02f,
  -5.95066845e-02f, 4.33080904e-02f, -2.80236956e-02f, -3.67648043e-02f, -9.32261348e-02f, 8.25700685e-02f, -6.71383366e-02f, -6.44375086e-02f, 8.59859884e-02f, 2.88571306e-02f,
  2.72387192e-02f, 5.64634986e-02f, -6.64287573e-03f, 5.04671372e-02f, -1.60001609e-02f, -9.15951058e-02f, 7.63267726e-02f, -9.06702410e-03f, 1.40991481e-02f, -1.92608871e-02f,
  2.90446170e-02f, -1.50545269e-01f, 7.28243589e-02f, 2.24636234e-02f, 1.00463815e-01f, 1.94270089e-02f, -5.94337620e-02f, 1.02153597e-02f, 4.18270975e-02f, -7.13541657e-02f,
  3.31512354e-02f, -5.39673045e-02f, 1.61220809e-03f, 1.56902596e-02f, -9.65978801e-02f, 3.96696813e-02f, 2.51780301e-02f, 1.77543592e-02f, -9.91600286e-03f, 5.59845269e-02f,
  3.21903341e-02f, -1.31069366e-02f, -7.07644001e-02f, -8.60248953e-02f, 2.49497709e-03f, 2.47781985e-02f, -8.91030114e-03f, -9.09046307e-02f, 7.02063963e-02f, -9.31449980e-02f,
  1.23296507e-01f, -1.64230078e-01f, 4.42884713e-02f, 4.11513969e-02f, 4.89751399e-02f, -2.29754113e-02f, -7.03801140e-02f, 3.56327519e-02f, 1.27115160e-01f, -1.96689516e-01f,
  -7.64074326e-02f, 7.26664811e-02f, 8.79621366e-05f, 2.02515405e-02f, 2.08379522e-01f, 3.08583677e-02f, 5.45440847e-03f, 2.52980217e-02f, 8.15854147e-02f, -5.49955443e-02f,
  -7.15948083e-03f, -8.43078047e-02f, -3.73443700e-02f, -1.55304357e-01f, -4.38117944e-02f, -1.17405325e-01f, -4.47333492e-02f, -6.25922158e-02f, -5.29800691e-02f, -6.86690211e-02f,
  7.98329711e-02f, -2.69252770e-02f, 8.93984288e-02f, 6.08964115e-02f, -2.79070958e-02f, 2.02443469e-02f, 5.34316860e-02f, 5.81211038e-02f, 8.91077965e-02f, 4.47559878e-02f,
  4.21709102e-03f, 1.96233913e-02f, 7.66563267e-02f, -5.66422567e-02f, -1.44756734e-02f, 5.55264577e-02f, -4.99465279e-02f, 9.84467566e-03f, 3.68899927e-02f, -7.65954480e-02f,
  -2.90031042e-02f, 2.95963809e-02f, 2.31932523e-03f, -3.29910740e-02f, 5.22359759e-02f, -9.91486572e-03f, -5.14632724e-02f, 6.52793497e-02f, -1.60680506e-02f, 5.33448122e-02f,
  2.98539046e-02f, 4.17496897e-02f, 4.10918631e-02f, 4.58058976e-02f, -5.95634095e-02f, 5.43726701e-03f, 5.99859804e-02f, 4.99788672e-03f, -1.54942712e-02f, 7.02509210e-02f,
  -8.54616091e-02f, 8.46813321e-02f, 3.48622873e-02f, -4.81714755e-02f, 4.89341207e-02f, -1.58517547e-02f, -1.14337709e-02f, -3.19960713e-02f, -3.25519592e-02f, -7.44287372e-02f,
  -2.15769447e-02f, -4.26781178e-02f, -4.22586873e-02f, -2.34292578e-02f, 4.47313264e-02f, -6.68979809e-02f, 2.50864564e-03f, 5.20593710e-02f, 3.13620120e-02f, -9.84140933e-02f,
  -9.47689265e-02f, 1.48013961e-02f, -2.97851842e-02f, -1.09491544e-03f, -3.18533815e-02f, -9.40085948e-02f, 4.30478528e-02f, 8.12260136e-02f, -4.06160951e-02f, 4.03033271e-02f,
  -8.50025713e-02f, -3.00997309e-02f, 7.68900290e-02f, -3.34067456e-03f, -7.02286512e-02f, -5.52152246e-02f, 4.01285626e-02f, 5.73428050e-02f, 5.97083829e-02f, 1.82474423e-02f,
  2.16498189e-02f, -6.28799200e-02f, -3.26690525e-02f, -2.78728269e-02f, -5.70803955e-02f, 4.74373531e-03f, -5.71828261e-02f, -5.75861856e-02f, 7.23749548e-02f, -4.07808051e-02f,
  2.07793508e-02f, -3.96333411e-02f, -2.01491326e-01f, -2.00112790e-01f, 1.18889622e-02f, -3.29080701e-01f, -2.96915650e-01f, -1.23945639e-01f, 5.87582737e-02f, 5.43839252e-03f,
  -6.25986978e-02f, 4.09397706e-02f, 8.79278407e-02f, -2.25971520e-01f, -2.99274057e-01f, -7.50770746e-03f, -3.05922568e-01f, -1.85629413e-01f, -6.75965920e-02f, -1.09347068e-01f,
  -1.43785045e-01f, -7.62667730e-02f, -7.56369084e-02f, 7.92213455e-02f, -4.26889248e-02f, -5.79945445e-02f, 4.52354476e-02f, 9.10769701e-02f, -5.14288507e-02f, -5.22546656e-02f,
  -5.45777194e-02f, 5.18446974e-02f, -6.31549358e-02f, 5.31748757e-02f, -2.07073241e-02f, -4.96574752e-02f, 2.98355445e-02f, 1.35350060e-02f, -7.53392093e-03f, -1.04177538e-02f,
  -3.44995707e-02f, 6.30389825e-02f, 6.75197691e-02f, 1.07025281e-01f, 2.31841356e-02f, -7.55429417e-02f, -6.08838275e-02f, 5.47284782e-02f, 3.02943736e-02f, -3.05744745e-02f,
  -2.50185281e-02f, -4.85171936e-03f, 3.57216895e-02f, -1.26118176e-02f, -6.42626779e-03f, -4.62211929e-02f, -3.06721181e-02f, 4.21569720e-02f, -7.48922825e-02f, -3.45814601e-02f,
  8.24324936e-02f, 8.40012208e-02f, 2.81184949e-02f, 2.27107853e-02f, 4.67346609e-03f, -1.28573459e-02f, -6.68201689e-03f, -2.13208813e-02f, 4.92061712e-02f, -3.24330735e-03f,
  3.39382850e-02f, -2.34210975e-02f, 8.57917219e-02f, -8.70431308e-03f, 2.53311731e-02f, -2.08549928e-02f, 7.75445923e-02f, 1.99535470e-02f, -4.81834896e-02f, -1.71083789e-02f,
  2.79871710e-02f, 3.17739844e-02f, 3.32849734e-02f, 1.18713807e-02f, -6.64298311e-02f, -4.72283177e-02f, 1.89716294e-02f, 1.38490181e-03f, 2.69986410e-03f, -6.73809350e-02f,
  -5.92433140e-02f, -1.02978244e-01f, 2.99970284e-02f, 4.62661721e-02f, 5.04471944e-04f, 1.06063429e-02f, 3.31378877e-02f, -1.02208547e-01f, -6.31280057e-03f, -1.31701017e-02f,
  -6.16723811e-03f, 1.71191711e-03f, 7.27056563e-02f, -6.69440180e-02f, 5.94558008e-02f, -5.56100905e-02f, 9.91878733e-02f, 3.03753442e-03f, -1.42170116e-02f, -5.66831715e-02f,
  1.83362933e-03f, 1.08136320e-02f, 1.40293017e-02f, 1.32154375e-02f, 7.74933919e-02f, 5.80011643e-02f, -6.20064326e-02f, 3.47677842e-02f, -4.74210717e-02f, -1.03841228e-02f,
  3.96297351e-02f, 7.87198767e-02f, 2.39940174e-02f, -6.61933273e-02f, 2.92407051e-02f, -6.68771043e-02f, -1.59775957e-01f, 2.10042093e-02f, 2.66791433e-02f, 4.05658111e-02f,
  3.94183248e-02f, -7.20938072e-02f, -1.26623899e-01f, 9.88076348e-03f, -4.18793634e-02f, -1.03276975e-01f, -1.97574701e-02f, -1.94877405e-02f, -5.47595061e-02f, 6.69153705e-02f,
  -8.72512162e-03f, 8.21881648e-03f, 3.06254309e-02f, 1.06690608e-01f, 2.86561735e-02f, -2.32592076e-02f, 5.14252074e-02f, -3.97208147e-02f, 1.28568746e-02f, 8.27277005e-02f,
  -7.26460153e-03f, 7.37175196e-02f, 1.10070318e-01f, 6.72111958e-02f, -2.42528431e-02f, -3.24783213e-02f, 1.62275936e-02f, 4.41811979e-02f, 6.00513108e-02f, 5.67593612e-02f,
  1.64195225e-02f, -5.91880195e-02f, -4.72315177e-02f, -7.22172111e-02f, 4.24602069e-02f, -1.25588262e-02f, 2.95912139e-02f, 1.99920535e-02f, 1.15216142e-02f, 7.66630471e-02f,
  3.98291275e-02f, -6.79354742e-02f, 6.73631653e-02f, 9.04465392e-02f, -7.41865765e-03f, -4.48299944e-02f, -7.58740529e-02f, -3.79525200e-02f, -2.70156935e-03f, 3.47376242e-02f,
  -9.43891406e-02f, -5.80529720e-02f, -4.45664972e-02f, 7.88230151e-02f, -6.90250918e-02f, 4.37898450e-02f, 2.61753369e-02f, 6.73330054e-02f, 2.97944266e-02f, 1.83913559e-02f,
  8.47952347e-03f, -5.09232581e-02f, -6.73275068e-02f, -1.84476785e-02f, -4.89409007e-02f, 6.74992949e-02f, -5.80625720e-02f, -6.05955496e-02f, -8.01853463e-02f, -6.97500035e-02f,
  -2.29269359e-02f, -5.08616865e-02f, -4.87496816e-02f, 7.70874843e-02f, -4.65338714e-02f, 4.90462072e-02f, 1.02768689e-02f, 9.18589234e-02f, -2.13104784e-02f, -7.14904740e-02f,
  -2.97315512e-02f, -8.81650951e-03f, -5.01725264e-02f, 8.00640061e-02f, 9.70693231e-02f, 9.74036288e-03f, 8.41408446e-02f, -2.84490529e-02f, 1.39544606e-02f, 3.16261426e-02f,
  -4.24981378e-02f, -8.19548070e-02f, 3.16474959e-02f, 9.35709551e-02f, -6.07769303e-02f, -3.01171616e-02f, 5.00079878e-02f, 3.85998376e-02f, -1.26288859e-02f, 3.53941582e-02f,
  -3.05591617e-02f, -9.57118794e-02f, -8.21067616e-02f, 5.92552163e-02f, -1.00723077e-02f, 1.08798044e-02f, -9.57871005e-02f, 1.01226922e-02f, -6.98126927e-02f, -5.62247895e-02f,
  -6.29899874e-02f, 2.03926846e-01f, -1.76282600e-01f, -5.54019064e-02f, 1.33312782e-02f, -2.01774612e-01f, -1.66569069e-01f, 9.67560858e-02f, 1.37379691e-01f, 1.05976254e-01f,
  5.55063337e-02f, -5.22353575e-02f, 2.04033375e-01f, -1.26049459e-01f, -3.37433338e-01f, 5.19871935e-02f, -2.69226044e-01f, -7.30464682e-02f, 4.21131179e-02f, -1.52979836e-01f,
  -1.12426668e-01f, -1.43142594e-02f, -2.10587487e-01f, 1.08320676e-01f, -5.46439216e-02f, 3.28835994e-02f, -1.19993510e-02f, 9.25852805e-02f, -1.31661475e-01f, 4.05507050e-02f,
  6.64481223e-02f, 1.69375554e-01f, 3.64163667e-02f, 9.43992659e-02f, -1.35549784e-01f, -9.70757380e-02f, -6.10846654e-02f, 8.94379020e-02f, -4.27390598e-02f, 5.49501888e-02f,
  -8.11881348e-02f, 7.82831237e-02f, 3.95536311e-02f, 5.95274605e-02f, 2.60980949e-02f, 4.98192199e-03f, -4.35855910e-02f, -9.89909098e-02f, -5.29733375e-02f, 4.79893684e-02f,
  1.68883223e-02f, -3.43809947e-02f, -1.07672043e-01f, -5.04656248e-02f, -1.19262040e-01f, 1.94364693e-02f, -5.45685440e-02f, -3.06672268e-02f, -5.78245111e-02f, -1.02099910e-01f,
  -5.08286618e-02f, -1.21228456e-01f, -4.37563993e-02f, 5.10992110e-02f, 7.80079588e-02f, 1.70978997e-02f, 3.48812863e-02f, -3.45202237e-02f, -3.51691358e-02f, 2.71227546e-02f,
  -3.36115956e-02f, 1.63226202e-02f, -2.56326478e-02f, -1.44741148e-01f, -9.29215103e-02f, 2.56979149e-02f, -6.28100261e-02f, 6.03640750e-02f, -7.33267665e-02f, -1.11916602e-01f,
  4.93755899e-02f, -5.13637997e-02f, 1.72160361e-02f, -5.95261082e-02f, 2.43912288e-03f, 6.34983927e-02f, 1.06566891e-01f, -4.48816791e-02f, 1.93627421e-02f, 1.40139111e-03f,
  -9.05492753e-02f, -3.92521638e-03f, 9.76259485e-02f, 5.37567548e-02f, 4.10669856e-02f, 1.87418442e-02f, -3.47275054e-03f, -6.78645000e-02f, -6.90008700e-02f, -3.70634459e-02f,
  -6.34174943e-02f, -5.50506562e-02f, -1.47355735e-01f, -2.13359315e-02f, -2.00164802e-02f, 2.13574767e-02f, -7.80352950e-02f, -4.08808514e-02f, -8.92393440e-02f, -4.32530046e-02f,
  3.63738984e-02f, 2.44618449e-02f, -5.73639758e-03f, -7.28244334e-02f, -5.34531884e-02f, 1.87819246e-02f, 1.37089100e-03f, 5.91372438e-02f, -4.63307612e-02f, -1.11875031e-02f,
  -2.89137006e-01f, 2.15862080e-01f, -1.49964228e-01f, -4.19767313e-02f, -1.19795665e-01f, -5.90132512e-02f, 2.36482099e-02f, -8.26498643e-02f, -6.51561916e-02f, 1.97615311e-01f,
  6.77320361e-02f, 3.66480462e-02f, 6.74752444e-02f, 5.99056780e-02f, -1.58444896e-01f, 1.01948515e-01f, 5.06315567e-02f, 1.24862995e-02f, -8.06134939e-02f, -7.45154619e-02f,
  -4.77002375e-02f, 1.05251484e-01f, -4.02671359e-02f, 2.55684722e-02f, 1.99897885e-02f, 3.92373353e-02f, -4.47574556e-02f, -2.82034911e-02f, -1.48045113e-02f, -1.11892089e-01f,
  -5.13855927e-02f, -1.34797350e-01f, -3.86652909e-02f, -8.18359852e-03f, -1.52347435e-03f, 4.81397621e-02f, -7.83220306e-02f, -3.28934006e-02f, -2.40846090e-02f, -6.44410253e-02f,
  -3.58814746e-02f, -8.70208591e-02f, -4.98022437e-02f, 4.69692536e-02f, -8.59806240e-02f, 1.06371539e-02f, -4.40722071e-02f, -1.56465662e-03f, 6.55943155e-02f, -1.84236187e-02f,
  4.65563163e-02f, 5.72140561e-04f, 2.45996062e-02f, -1.27769411e-02f, -3.45988646e-02f, 4.14522924e-02f, -5.78205772e-02f, -2.53020078e-02f, -1.03698142e-01f, -6.29639626e-02f,
  2.41092704e-02f, 4.06013848e-03f, 2.02906947e-03f, -7.01395199e-02f, 3.20087820e-02f, 8.11512098e-02f, -4.09370521e-03f, -6.53125420e-02f, -4.46696877e-02f, -4.99321297e-02f,
  2.66502053e-02f, 4.11488451e-02f, 2.06692461e-02f, -8.26478526e-02f, 2.27992237e-02f, 2.91623697e-02f, -5.46719832e-03f, -4.45139632e-02f, 5.63544631e-02f, -2.96454784e-02f,
  -5.46240211e-02f, 3.56267695e-03f, 1.45005053e-02f, 6.31614178e-02f, 2.49887835e-02f, 1.71887297e-02f, -2.46331058e-02f, 7.79719092e-04f, -5.41657135e-02f, 4.59696837e-02f,
  1.05308834e-02f, -1.71478137e-01f, 1.45477233e-02f, -3.16923745e-02f, -7.70167485e-02f, -1.12679362e-01f, -2.01428626e-02f, -8.45163390e-02f, 4.10132762e-03f, -3.00886836e-02f,
  3.37566100e-02f, -1.47757139e-02f, 1.82978343e-02f, 4.84197587e-02f, -2.60601062e-02f, 2.95639411e-02f, 8.98233131e-02f, 5.93472123e-02f, 3.03199189e-03f, -7.12714046e-02f,
  -2.22078543e-02f, -6.33285865e-02f, 5.51762395e-02f, 1.37679065e-02f, 3.80796418e-02f, -2.72361524e-02f, -2.29873825e-02f, -8.78936052e-02f, -6.05990551e-02f, 3.03489226e-03f,
  2.26772666e-01f, -5.79959191e-02f, -1.09354012e-01f, -3.24656628e-02f, 3.53031531e-02f, 6.25013337e-02f, -8.79776012e-03f, 2.47534532e-02f, -1.31597534e-01f, -8.75003561e-02f,
  1.25911459e-01f, 3.15867364e-02f, 5.18916771e-02f, -4.39312719e-02f, 8.69194344e-02f, 2.16649398e-02f, -2.42504105e-02f, 5.76007664e-02f, -2.43813898e-02f, -3.96156684e-02f,
  -5.44603094e-02f, 2.20875093e-03f, -1.26196668e-02f, -7.33364224e-02f, 6.69798553e-02f, -9.34940800e-02f, 1.01933502e-01f, 1.15738854e-01f, -1.23175271e-02f, -1.24981813e-03f,
  -2.14773063e-02f, 1.04688443e-01f, 4.68046218e-02f, 3.88524644e-02f, -1.30508689e-03f, 5.20271773e-04f, 2.24984288e-02f, -5.07401004e-02f, -7.94746280e-02f, -4.80681770e-02f,
  -7.30828494e-02f, 8.95051286e-03f, -9.51196402e-02f, 7.69397318e-02f, -6.13824129e-02f, -3.15220319e-02f, -4.14229631e-02f, -1.20512405e-02f, -6.09942600e-02f, -4.69057113e-02f,
  4.24688980e-02f, -6.53296262e-02f, -3.85642424e-02f, -1.55942086e-02f, -3.21565419e-02f, 5.18587083e-02f, -8.49844515e-02f, 1.94007959e-02f, 3.96736227e-02f, -2.07131710e-02f,
  -2.15441529e-02f, 6.40000775e-02f, -3.92194092e-02f, 9.77431051e-03f, 7.18787909e-02f, -9.12639499e-02f, 5.79763297e-03f, -1.07120149e-01f, 5.22604845e-02f, 9.00755543e-03f,
  -5.20016029e-02f, -2.41861586e-02f, -6.27882481e-02f, 2.16074195e-03f, 2.95778224e-03f, 7.83992857e-02f, 5.08284792e-02f, -4.99238186e-02f, -1.14145547e-01f, -2.87558474e-02f,
  4.82287398e-03f, 7.88895879e-03f, 1.89331535e-03f, -3.79384682e-02f, -9.76002738e-02f, 4.69221510e-02f, 3.23764980e-02f, 2.13822555e-02f, 2.83178519e-02f, -3.77662405e-02f,
  5.59450686e-02f, 8.49668831e-02f, -1.26508288e-02f, -5.84542044e-02f, -2.92018596e-02f, -7.25784972e-02f, -3.22260670e-02f, 8.48039091e-02f, -2.26890831e-03f, -5.14486767e-02f,
  -2.38856231e-03f, -3.43512259e-02f, 5.07364795e-02f, -1.04220593e-02f, -2.84158476e-02f, 4.28448170e-02f, 4.45463099e-02f, -7.13418126e-02f, -1.76749695e-02f, -2.26736516e-02f,
  -5.94570562e-02f, -2.71822065e-02f, 6.77905530e-02f, 2.91803349e-02f, -6.82771578e-02f, 2.14428362e-02f, -7.19456673e-02f, -5.40446341e-02f, -2.36461721e-02f, -9.88401845e-02f,
  -6.39824616e-03f, 9.22852233e-02f, 3.92447487e-02f, 1.32111311e-01f, -8.79007205e-03f, -1.63392171e-01f, -2.68934970e-03f, 7.02111572e-02f, -6.60344958e-02f, 1.22910365e-01f,
  1.39393762e-01f, -3.44172940e-02f, -2.10972670e-02f, -8.15477967e-02f, -1.52243152e-01f, -1.20473774e-02f, -6.82631359e-02f, -1.22858204e-01f, -7.53276572e-02f, 1.37764126e-01f,
  4.98277768e-02f, 1.49239786e-02f, 8.65282640e-02f, 1.73649028e-01f, 3.32400911e-02f, 1.41454950e-01f, 1.72335669e-01f, 2.50471756e-02f, 3.44872288e-03f, -7.47995302e-02f,
  2.80891638e-02f, -7.19299121e-03f, -5.32308221e-02f, -5.20512238e-02f, -1.27262389e-02f, 2.41451617e-02f, 1.29990056e-02f, 4.84457193e-03f, -9.44143347e-03f, -4.94603813e-02f,
  -2.47947574e-02f, -8.08286369e-02f, -6.40102327e-02f, 4.34751473e-02f, -4.67275549e-03f, 3.89562063e-02f, -7.50368088e-02f, -5.85674532e-02f, -5.04586846e-03f, -1.44785959e-02f,
  3.19764912e-02f, -5.17309532e-02f, -5.47357881e-03f, -3.62284482e-02f, 2.59008142e-03f, 7.28681162e-02f, -6.14509247e-02f, 3.65829282e-02f, 3.84678319e-02f, -7.72630051e-02f,
  2.00857911e-02f, 5.25494888e-02f, 3.39389071e-02f, 3.71858925e-02f, -2.02534758e-02f, -6.95898086e-02f, 1.83690637e-02f, -2.57112067e-02f, -4.71215025e-02f, 1.07304573e-01f,
  -1.55817333e-03f, 7.54853785e-02f, -5.93239889e-02f, 3.24186124e-02f, 6.91795647e-02f, 2.83628125e-02f, -6.61519244e-02f, 2.05443799e-02f, 2.84570847e-02f, -2.00232468e-03f,
  -3.37402634e-02f, 3.12279481e-02f, 3.70873101e-02f, -2.01963894e-02f, -4.13123481e-02f, 4.10118774e-02f, 1.31549211e-02f, -3.44259776e-02f, 7.76346177e-02f, 3.25107761e-02f,
  2.76060775e-04f, 2.08674833e-01f, -4.47696401e-03f, 1.35234315e-02f, 8.01352933e-02f, 3.17149120e-03f, 4.62352298e-02f, -8.77411440e-02f, 4.77148071e-02f, -9.62643605e-03f,
  -3.30492780e-02f, 5.12226000e-02f, 3.68338376e-02f, -1.07808309e-02f, -3.89632098e-02f, 2.87931394e-02f, 7.37428963e-02f, 7.54568577e-02f, 7.58785084e-02f, 1.75418016e-02f,
  1.25058845e-01f, 1.35263931e-02f, 7.01742887e-04f, -3.82862240e-02f, 6.14801189e-03f, 1.16303870e-02f, 3.97815444e-02f, 3.20996232e-02f, -2.70328280e-02f, 5.16163334e-02f,
  1.67273939e-01f, -3.14585656e-01f, 1.76840052e-02f, 1.50199845e-01f, 1.95974335e-01f, 1.40549958e-01f, 1.53254092e-01f, 1.20894425e-02f, 1.08479269e-01f, -1.30821630e-01f,
  -1.35386243e-01f, -2.27189958e-02f, -2.60035425e-01f, 2.78304089e-02f, 1.99119776e-01f, -4.53669801e-02f, 7.09900931e-02f, 2.82885935e-02f, 6.53278306e-02f, -3.28137949e-02f,
  1.43323198e-01f, 7.09417611e-02f, 4.30303775e-02f, -9.60699245e-02f, -1.45756379e-02f, 4.17294987e-02f, -4.53032814e-02f, -2.35178676e-02f, -2.74600312e-02f, -2.25536432e-02f,
  1.13145702e-01f, -2.25939360e-02f, -1.17031736e-02f, 5.39464541e-02f, -9.77268517e-02f, -4.31912094e-02f, 7.94847533e-02f, 1.30778059e-01f, 4.81481571e-03f, 3.62850539e-02f,
  -3.60462605e-03f, -5.26337698e-02f, -1.82186067e-02f, 2.24643424e-02f, 6.23692805e-03f, 7.34704966e-03f, -3.18861939e-02f, 4.39841785e-02f, -7.41777755e-03f, -9.02297050e-02f,
  -9.10597108e-03f, -6.86787292e-02f, 3.36369947e-02f, 2.66582780e-02f, -5.02767749e-02f, 8.43952820e-02f, 6.12378605e-02f, -7.27586374e-02f, -7.15754107e-02f, -2.45374888e-02f,
  -4.32498404e-04f, 7.09552541e-02f, 6.03484884e-02f, 2.50002779e-02f, 6.92938343e-02f, -4.14422639e-02f, -1.84981655e-02f, 2.16921791e-02f, 2.34149881e-02f, -4.14787680e-02f,
  1.55296996e-02f, 3.19045000e-02f, -2.73945164e-02f, 9.24038235e-03f, 5.77612817e-02f, -2.41325572e-02f, 7.23291039e-02f, -9.20163319e-02f, 8.28898475e-02f, -6.67864829e-02f,
  5.60508762e-03f, -5.45851849e-02f, 4.37888019e-02f, 1.27478996e-02f, -5.10715842e-02f, 8.78320038e-02f, -3.56026203e-03f, 1.02411471e-02f, -2.47925129e-02f, -5.71406856e-02f,
  -2.28411154e-04f, -1.57837808e-01f, 2.66390555e-02f, -6.12251200e-02f, -3.84021108e-03f, -2.71062497e-02f, 7.53051341e-02f, 8.79975930e-02f, -6.80403784e-02f, -5.32450061e-03f,
  3.67771310e-04f, -9.60475579e-03f, 3.53289098e-02f, 7.60725066e-02f, -5.75352982e-02f, -7.11898729e-02f, 5.53600490e-02f, -3.91755067e-03f, -3.24515030e-02f, 3.16073969e-02f,
  1.49307819e-02f, 6.49589449e-02f, -5.13991788e-02f, -4.57305685e-02f, 1.83162317e-02f, -6.78948388e-02f, 7.52195134e-04f, -6.68900833e-02f, 5.45900129e-02f, 7.16425776e-02f,
  1.79843143e-01f, -1.19581722e-01f, 7.74997175e-02f, 3.17781329e-01f, 1.09638222e-01f, -2.08830476e-01f, -1.16082758e-01f, 1.15074456e-01f, 5.88696823e-02f, -1.36693478e-01f,
  -5.78021556e-02f, 1.23626024e-01f, -1.71498597e-01f, 1.28599867e-01f, 1.24299318e-01f, -2.12610245e-01f, 7.25839362e-02f, 7.63693526e-02f, -5.44645935e-02f, 5.48462905e-02f,
  2.20617458e-01f, 6.88105673e-02f, 1.06654897e-01f, 1.73014507e-01f, 1.39974654e-01f, 6.86315373e-02f, 1.90747499e-01f, -6.96195513e-02f, 1.56848162e-01f, 1.16573915e-01f,
  -5.37251793e-02f, -4.15627509e-02f, 3.76667865e-02f, -9.47905891e-03f, -6.06374107e-02f, 4.88987081e-02f, -3.84213515e-02f, 5.99970594e-02f, 1.15829580e-01f, -4.50806133e-03f,
  -5.64004807e-03f, -1.02285501e-02f, 1.18265398e-01f, 7.33415186e-02f, -1.73540208e-02f, 6.50154203e-02f, 3.46165746e-02f, -4.79260869e-02f, 7.07868338e-02f, -8.60280357e-03f,
  -1.73781905e-02f, -1.06839864e-02f, -3.68567444e-02f, 4.25879657e-02f, 7.25085810e-02f, 3.17024067e-02f, 4.66554761e-02f, -7.80743361e-02f, -2.14175973e-02f, -5.86705357e-02f,
  -6.56162128e-02f, 2.11030543e-02f, -1.85773578e-02f, 3.82514708e-02f, 1.52407931e-02f, -6.37057424e-02f, -6.02017231e-02f, -8.09540749e-02f, -1.53291067e-02f, -6.56234622e-02f,
  4.34197895e-02f, -4.41891178e-02f, 4.35629971e-02f, -1.58705711e-02f, 4.32680435e-02f, -5.65342046e-02f, -2.82358248e-02f, -5.20121790e-02f, 4.29001600e-02f, 9.70496088e-02f,
  -8.67446046e-03f, -6.72777817e-02f, 2.14467496e-02f, 2.33940892e-02f, 6.22459166e-02f, -4.65239696e-02f, -1.86842326e-02f, 5.29590473e-02f, -4.35786471e-02f, 7.32601881e-02f,
  -2.68455856e-02f, -7.19679147e-02f, -6.35690391e-02f, 7.21773580e-02f, -7.35627264e-02f, 3.71989831e-02f, 1.57729927e-02f, -1.78874619e-02f, -8.52565244e-02f, -6.20789304e-02f,
  -5.74639738e-02f, 9.81149077e-02f, -3.57908718e-02f, -4.45953608e-02f, 5.79521656e-02f, -6.51533157e-02f, -1.82674099e-02f, 3.88570689e-02f, 5.59540838e-03f, 2.54618861e-02f,
  -4.19429317e-02f, -3.48155424e-02f, -3.87859754e-02f, 6.83816895e-02f, 7.08525479e-02f, -6.52511567e-02f, -2.53677592e-02f, 2.54492890e-02f, -1.06253354e-02f, 1.78423151e-02f,
  -2.80551404e-01f, 1.20054215e-01f, -2.31318399e-02f, -2.44419485e-01f, 5.68754226e-02f, -2.92847715e-02f, -1.23951308e-01f, -7.05937520e-02f, -1.30762666e-01f, -1.01128906e-01f,
  -1.07270040e-01f, -1.20966285e-02f, 1.75074816e-01f, -1.79883480e-01f, 1.75326675e-01f, 1.69713721e-01f, -1.71426892e-01f, -4.31413315e-02f, -2.07161531e-02f, -1.26058415e-01f,
  -3.28120217e-03f, -6.08501062e-02f, 1.22180946e-01f, 4.61378954e-02f, -1.56816095e-01f, -7.02534690e-02f, -1.18384808e-01f, 1.31354138e-01f, -1.87539712e-01f, 5.68114482e-02f,
  -8.96107033e-02f, -2.52332181e-01f, -1.34616747e-01f, -1.00051090e-02f, -8.61961395e-02f, -9.48454067e-02f, 2.06656232e-02f, 9.35870558e-02f, 3.20108272e-02f, -9.03821364e-02f,
  3.12821493e-02f, 1.14406394e-02f, -4.48364913e-02f, -4.78846282e-02f, -4.75286394e-02f, -5.73779345e-02f, 4.01448645e-02f, -5.13707893e-03f, -4.43909578e-02f, -5.50123106e-04f,
  1.41855562e-02f, 5.37022017e-02f, -8.13808143e-02f, -7.04453588e-02f, 5.91458892e-03f, -4.33997288e-02f, -5.29775806e-02f, -2.70891488e-02f, -1.60361808e-02f, -8.68093073e-02f,
  9.05751958e-02f, -5.80272339e-02f, -3.00774463e-02f, -1.53730009e-02f, 8.58497322e-02f, -2.78698397e-04f, -3.35345827e-02f, 5.09529468e-03f, 7.53040761e-02f, -2.27621291e-03f,
  -8.37446898e-02f, -4.08839732e-02f, -1.89013861e-03f, -8.26872066e-02f, -3.14130299e-02f, -2.31412216e-03f, -7.59452581e-02f, 3.61984968e-02f, 4.71244715e-02f, 9.14647132e-02f,
  4.19981256e-02f, -2.35556662e-02f, -3.37878093e-02f, 4.58615907e-02f, -4.61737290e-02f, 4.89763618e-02f, -2.48377733e-02f, -5.37867993e-02f, -6.86135069e-02f, -2.72580758e-02f,
  -1.18077807e-01f, -1.96091995e-01f, -6.35126159e-02f, -4.90398630e-02f, 1.05359964e-03f, 3.00725922e-02f, -7.82433376e-02f, -1.85715836e-02f, -1.05340429e-01f, 3.77075039e-02f,
  -5.17687872e-02f, -3.43614891e-02f, -1.01267081e-02f, -1.32231908e-02f, 7.78323710e-02f, 4.94018644e-02f, 2.78968066e-02f, -1.56291854e-02f, -1.13502860e-01f, 1.17398966e-02f,
  -2.59648287e-03f, -4.54216748e-02f, 3.67414542e-02f, -2.41153948e-02f, -3.35657038e-02f, -6.51265234e-02f, -3.82729843e-02f, -1.27361733e-02f, -1.66152641e-02f, 5.94434105e-02f,
  1.98850036e-03f, -1.00157827e-01f, -6.01130445e-03f, 2.09698886e-01f, -1.17661752e-01f, -2.79705524e-01f, -2.69826174e-01f, 3.55620012e-02f, 4.67686765e-02f, -2.19497949e-01f,
  -9.46101025e-02f, 8.38818923e-02f, -2.07430482e-01f, 1.65235952e-01f, 2.55859405e-01f, -1.04261823e-01f, 7.98472241e-02f, -3.82648259e-02f, 1.36466369e-01f, 4.53873277e-02f,
  2.36865312e-01f, 6.80599734e-02f, 2.49217272e-01f, 1.95413083e-02f, 9.97202992e-02f, 2.28905082e-01f, 1.92430779e-01f, -1.07147349e-02f, 1.97469607e-01f, 7.50812069e-02f,
  4.03012615e-03f, 3.92009653e-02f, 4.91680540e-02f, -6.88152313e-02f, -2.61711888e-02f, -7.52388537e-02f, 1.54118687e-02f, 8.72484893e-02f, 7.74809942e-02f, 1.05768619e-02f,
  -8.27737376e-02f, 1.04619011e-01f, 2.97765434e-02f, -6.63481727e-02f, 3.57772261e-02f, 7.64850602e-02f, 5.18559031e-02f, 7.68414652e-03f, -7.86392856e-03f, -8.22784901e-02f,
  -8.24495032e-02f, -7.32094375e-03f, -6.27570599e-02f, 3.37000005e-02f, 1.56619735e-02f, 8.21710005e-03f, 5.68174049e-02f, 3.94875258e-02f, -7.34705627e-02f, 9.65205580e-02f,
  -1.53272226e-02f, -1.60738472e-02f, 1.60358008e-02f, -1.52735999e-02f, 6.54561073e-02f, -5.00316620e-02f, 5.70028983e-02f, 2.83876043e-02f, -3.25500183e-02f, -6.24743402e-02f,
  2.61548068e-02f, 3.05660777e-02f, 6.18882701e-02f, -2.22363006e-02f, 3.45377214e-02f, -4.36746292e-02f, -1.77244525e-02f, -6.51561283e-03f, -2.73504425e-02f, -3.44795808e-02f,
  4.99310680e-02f, 6.58274591e-02f, 6.61676526e-02f, -5.80021879e-03f, 4.92009632e-02f, 2.31717434e-02f, -2.96929739e-02f, -1.83983017e-02f, 3.53071615e-02f, -8.22726171e-03f,
  -8.00603554e-02f, 2.15158947e-02f, -6.30547404e-02f, 5.72485998e-02f, -3.58595662e-02f, 6.22417603e-04f, -4.71151620e-02f, -1.28530283e-02f, 1.40089830e-02f, -9.28013679e-03f,
  -3.13460156e-02f, 4.36096340e-02f, 1.21478075e-02f, 9.41830277e-02f, 3.34140621e-02f, -3.16600949e-02f, 3.17712873e-02f, 8.02541673e-02f, 2.42638197e-02f, 7.90542588e-02f,
  5.90050146e-02f, -9.92234275e-02f, 8.66493359e-02f, -4.60772477e-02f, 3.73311304e-02f, -8.01301897e-02f, -6.71813823e-03f, 1.40331034e-02f, -2.20631771e-02f, 6.25007972e-02f,
  -1.80430517e-01f, 1.56771749e-01f, 1.38183832e-01f, -1.22997321e-01f, -2.09992900e-02f, 1.75915100e-02f, -8.14403519e-02f, 1.08765259e-01f, 1.32533759e-01f, 1.34239271e-01f,
  1.09955017e-02f, 1.31721944e-01f, 9.94730815e-02f, -9.56302285e-02f, -1.74038008e-01f, -1.19598530e-01f, -1.57735437e-01f, -1.22993723e-01f, 3.95250805e-02f, -1.34075791e-01f,
  -1.40778139e-01f, -7.11409003e-02f, -2.16799229e-01f, 5.74805513e-02f, -1.10458441e-01f, -9.91453137e-03f, -9.20351744e-02f, 1.23777390e-01f, 5.19505963e-02f, 7.69023895e-02f,
  -1.35944173e-01f, -2.27030348e-02f, -6.52773306e-02f, -1.99975190e-03f, 4.76782881e-02f, 1.61426384e-02f, -6.52282313e-02f, -7.70848915e-02f, 3.11773364e-02f, -3.96010876e-02f,
  -1.66051127e-02f, -5.91439232e-02f, 2.82021351e-02f, -1.65229943e-02f, 3.47329155e-02f, 5.84767275e-02f, -2.89327689e-02f, -5.02797170e-03f, 4.07158025e-02f, 5.42182699e-02f,
  4.57749516e-03f, 8.99787620e-02f, -4.28391844e-02f, 2.56155077e-02f, -7.18861893e-02f, -3.82487178e-02f, -4.58922461e-02f, -1.02492914e-01f, -4.20159884e-02f, 2.76611187e-02f,
  -6.68467432e-02f, 3.22803929e-02f, 5.37279882e-02f, 4.09297645e-02f, -3.88052277e-02f, -1.48037774e-03f, 7.19497874e-02f, -4.98289391e-02f, 6.61315247e-02f, 3.34238000e-02f,
  -1.31409708e-02f, 4.06983830e-02f, 7.88897797e-02f, 4.41685058e-02f, -8.10271800e-02f, 5.53675257e-02f, -5.66633930e-03f, 3.21319550e-02f, 2.92354599e-02f, 6.12462498e-02f,
  -2.67530642e-02f, -2.21932046e-02f, -5.12884930e-02f, -4.48346362e-02f, 1.12036854e-01f, 7.95000978e-03f, 1.01467641e-02f, 5.02202613e-03f, -7.53265619e-02f, -3.02519370e-03f,
  3.59555590e-03f, 1.07985482e-01f, 8.47137347e-03f, -4.47607972e-02f, -4.29441594e-02f, -4.64139469e-02f, -3.97789218e-02f, -8.69113728e-02f, -4.37583178e-02f, 7.79953301e-02f,
  1.68118738e-02f, 7.36418739e-02f, -5.91092221e-02f, 2.44723018e-02f, 2.94607636e-02f, -7.50596076e-02f, -3.51673476e-02f, 5.29224984e-02f, 4.62380843e-03f, -1.66278183e-02f,
  1.75338108e-02f, 2.01294906e-02f, 3.38173960e-03f, 2.08945349e-02f, -6.39387071e-02f, -1.81169752e-02f, 2.98455786e-02f, -9.30397864e-03f, -1.75721496e-02f, 3.80775356e-03f,
  -1.01108059e-01f, 1.86501145e-01f, -2.89415456e-02f, -1.01431236e-01f, -2.56137371e-01f, 1.22195534e-01f, 2.83063769e-01f, -4.32373881e-02f, -8.43562111e-02f, 2.69423366e-01f,
  -7.46760471e-03f, -1.60692528e-01f, 1.98982134e-01f, 1.30701721e-01f, 5.11908792e-02f, 3.67157668e-01f, 1.55889541e-01f, 2.16186285e-01f, 3.38264578e-03f, -6.57561794e-02f,
  -6.26039058e-02f, -1.20699033e-02f, 8.73896256e-02f, -3.98428030e-02f, -1.57111615e-01f, -1.57415807e-01f, -1.39442489e-01f, -1.23842724e-01f, -1.61874089e-02f, -1.03679806e-01f,
  1.30936965e-01f, 1.68401022e-02f, -2.96890400e-02f, 7.98123255e-02f, 8.66745319e-03f, 3.06570195e-02f, -2.82091238e-02f, 2.23224163e-02f, -1.23578995e-01f, -2.28647273e-02f,
  -3.18792537e-02f, -7.53883738e-03f, -2.47873943e-02f, 2.18929369e-02f, -5.07602766e-02f, 1.42598003e-02f, -7.75342882e-02f, 1.86985548e-04f, -3.58557515e-02f, -3.59272175e-02f,
  -2.95792855e-02f, -1.90570578e-02f, -4.07332927e-03f, 3.58027853e-02f, -9.77534503e-02f, 6.02112822e-02f, -6.89814519e-03f, -9.03851241e-02f, 1.03938417e-03f, 3.67081501e-02f,
  -2.44588088e-02f, 5.51816970e-02f, 5.07829105e-03f, -3.86808626e-02f, 3.97286229e-02f, -3.94673869e-02f, -3.37373950e-02f, -7.40501136e-02f, -1.66834239e-03f, 3.11854426e-02f,
  -7.47661665e-03f, -6.32372200e-02f, 2.67391559e-02f, 9.17078778e-02f, 9.05169845e-02f, 1.32539659e-03f, 5.50290234e-02f, -5.07744178e-02f, -7.02581853e-02f, -4.81285304e-02f,
  -2.31616274e-02f, -9.88383871e-03f, 1.95692182e-02f, 2.95061469e-02f, 3.63527723e-02f, -1.30391615e-02f, 2.99376007e-02f, 7.04899505e-02f, 9.70286131e-02f, -9.86888539e-03f,
  1.67478472e-02f, 1.19370162e-01f, 1.38285030e-02f, 7.35411867e-02f, 5.80222495e-02f, 6.12316169e-02f, 4.84842546e-02f, 5.89142041e-03f, -3.02771144e-02f, 1.40511105e-02f,
  -7.39402846e-02f, 1.02976812e-02f, -6.98090121e-02f, 4.14053574e-02f, -6.06222600e-02f, -3.11128050e-02f, -1.61152221e-02f, -8.68100971e-02f, 5.41752689e-02f, -6.08374625e-02f,
  5.15731089e-02f, -5.20908311e-02f, 7.15632178e-03f, -6.10899786e-03f, -2.69825105e-02f, -2.65412871e-02f, 9.53390321e-04f, 5.43182306e-02f, -6.12412617e-02f, 1.04776602e-02f,
  8.57355446e-03f, 1.27627254e-01f, -2.51866207e-02f, -1.07686475e-01f, -7.20019713e-02f, -1.40218705e-01f, -2.38184184e-02f, -8.25073496e-02f, -8.83745216e-03f, 2.22712353e-01f,
  1.43545330e-01f, 8.20489228e-03f, 4.64995950e-03f, -7.22139105e-02f, -3.32584023e-01f, -1.24599896e-01f, -1.46061093e-01f, 1.00989947e-02f, -1.00885943e-01f, -5.51026054e-02f,
  -1.77406013e-01f, 6.45447671e-02f, -3.48765589e-02f, -5.84282819e-03f, 7.40540847e-02f, 1.50389227e-04f, 8.73761475e-02f, 4.88069141e-03f, -2.11783927e-02f, -4.09534909e-02f,
  -4.45585931e-03f, -1.82030268e-03f, 6.24232814e-02f, -6.70079365e-02f, -7.61885419e-02f, -3.75262983e-02f, 8.85117501e-02f, 5.92518710e-02f, 5.70002235e-02f, -1.00209536e-02f,
  3.77599709e-02f, -4.71349210e-02f, 3.49196456e-02f, -9.45746154e-02f, 8.10130313e-02f, -3.72691751e-02f, 3.95268947e-02f, -5.04129305e-02f, 1.04898801e-02f, 4.88871746e-02f,
  -1.38004795e-02f, 9.34147686e-02f, 3.37039120e-02f, 5.69644310e-02f, -4.07703146e-02f, 2.18033381e-02f, -1.18862195e-02f, 6.34895712e-02f, 7.22201094e-02f, -6.22467883e-02f,
  -4.48737480e-02f, 2.82865092e-02f, -4.44675609e-02f, -3.97420228e-02f, 5.49319498e-02f, 1.12434877e-02f, -3.30022089e-02f, 9.44300368e-02f, -4.06787209e-02f, 5.85713983e-02f,
  -1.05951063e-01f, 4.41804864e-02f, 1.00086741e-01f, -6.73155859e-03f, 4.51262370e-02f, 5.43774329e-02f, -2.75486764e-02f, -6.79919310e-03f, -2.04924233e-02f, 4.22037672e-03f,
  2.95682978e-02f, -2.02815514e-02f, -1.06385006e-02f, 7.52439126e-02f, 7.89575104e-04f, 1.83989480e-02f, -4.59806388e-03f, 1.47686154e-02f, 4.48974259e-02f, 3.66554968e-02f,
  -5.99391088e-02f, -9.07086302e-03f, -5.96884638e-02f, 1.16071485e-01f, -6.04136102e-02f, 3.21517065e-02f, -2.04331093e-02f, 2.56635062e-02f, -1.17111824e-01f, -1.75460856e-02f,
  -4.79469188e-02f, -2.26892345e-02f, -7.79688656e-02f, 4.67452258e-02f, -5.89038106e-03f, -9.84703600e-02f, -3.70381102e-02f, 4.51629944e-02f, 6.56130239e-02f, 1.40827205e-02f,
  1.01472028e-02f, 4.39959345e-03f, -7.60547351e-03f, -1.15355542e-04f, -6.53241575e-02f, 6.06706440e-02f, -5.27333170e-02f, 4.64220829e-02f, 8.44812170e-02f, -4.68761995e-02f,
  6.28685653e-02f, -1.58537254e-01f, -4.19081226e-02f, 4.99171838e-02f, 7.53119364e-02f, 7.03630894e-02f, -5.23748770e-02f, 4.90828007e-02f, 1.01241313e-01f, -9.53319222e-02f,
  -7.36275539e-02f, 2.55871261e-03f, -6.17962182e-02f, 6.08453266e-02f, -7.55917132e-02f, 5.34258736e-03f, -9.79557261e-02f, -8.00892189e-02f, -5.42128272e-02f, -1.47247305e-02f,
  6.85015023e-02f, 7.91184232e-02f, 4.40044468e-03f, -1.20966144e-01f, 3.42071503e-02f, -1.10419743e-01f, -1.23422548e-01f, -1.11775920e-01f, -1.13767907e-01f, -1.24759428e-01f,
  9.13343355e-02f, 3.91847629e-04f, -7.79012442e-02f, 2.29908172e-02f, -3.23747918e-02f, -7.01887533e-02f, -7.81308115e-02f, -2.77354592e-03f, 9.91459638e-02f, -1.62513815e-02f,
  4.73643951e-02f, 4.24152352e-02f, -6.43852502e-02f, 9.52095166e-02f, 7.82688856e-02f, 3.92732285e-02f, 8.77324119e-02f, -3.92512083e-02f, -1.12575352e-01f, 3.41964141e-02f,
  2.52233818e-02f, 3.30798998e-02f, -5.13639078e-02f, 2.28062412e-03f, -6.19753450e-03f, -8.83705989e-02f, -1.10019691e-01f, -2.09276397e-02f, -6.38793930e-02f, -5.59278242e-02f,
  -5.65534793e-02f, -9.89309102e-02f, -5.00222482e-02f, 8.73354003e-02f, -2.99406350e-02f, 4.67594936e-02f, -1.00686541e-02f, -4.93724234e-02f, 8.53577927e-02f, -7.77162611e-02f,
  8.25290680e-02f, 9.18756723e-02f, -5.19332141e-02f, -2.81548332e-02f, -4.65935804e-02f, -3.72653529e-02f, 2.00925115e-02f, -9.59579945e-02f, 1.63913111e-03f, 1.16858948e-02f,
  -6.41722679e-02f, -2.40440127e-02f, 5.38785709e-03f, -1.44523606e-02f, 2.27050502e-02f, 5.61928824e-02f, -2.27843802e-02f, 8.19614679e-02f, 2.53617391e-02f, 3.53482403e-02f,
  -5.76150371e-04f, 1.30259311e-02f, -6.66522682e-02f, 1.37849769e-04f, 1.40073793e-02f, 4.99464907e-02f, -5.79356998e-02f, -4.26924452e-02f, -3.47638428e-02f, 9.39109847e-02f,
  -7.64237642e-02f, 6.78655179e-03f, -1.05161086e-01f, 5.82663752e-02f, -8.45781863e-02f, 9.70406178e-03f, -2.49157827e-02f, -6.46217167e-02f, -1.16615057e-01f, 5.35348654e-02f,
  7.48114362e-02f, -9.06664133e-02f, -4.77304235e-02f, 6.26664236e-02f, -2.09336495e-03f, 5.01580276e-02f, -2.81136855e-02f, 5.33834323e-02f, -3.13118473e-02f, 3.62490187e-03f,
  -1.39573425e-01f, 1.01000272e-01f, 8.43580347e-03f, -1.16498657e-01f, -8.88468027e-02f, 1.68594141e-02f, -1.19784750e-01f, 4.53187618e-03f, -8.42371807e-02f, 5.34049422e-02f,
  -8.64985306e-03f, -1.59566477e-02f, 4.92561273e-02f, -1.15950868e-01f, 4.21959870e-02f, 2.39337772e-01f, -7.01032905e-03f, -1.96025912e-02f, 1.34163305e-01f, -9.45248604e-02f,
  3.45055349e-02f, -4.01937068e-02f, 8.85983631e-02f, 2.17947946e-03f, -1.93599567e-01f, -9.40144584e-02f, -4.89139557e-02f, -1.66888423e-02f, -1.46345437e-01f, 2.99669127e-03f,
  1.41668901e-01f, -1.13129087e-01f, -7.60764927e-02f, -1.95605867e-02f, -1.12024201e-02f, -1.18188694e-01f, 1.65991038e-02f, -7.79754147e-02f, -1.17859216e-02f, 6.57493770e-02f,
  1.47354826e-02f, 9.17924494e-02f, -2.49954243e-03f, -1.92472991e-02f, -2.38692816e-02f, -9.73098129e-02f, 1.18327951e-02f, 5.04754856e-02f, -4.60787006e-02f, -1.87124982e-02f,
  -1.17498897e-02f, -6.83274958e-03f, -5.99547406e-04f, -3.97375189e-02f, -7.22680390e-02f, -4.01156098e-02f, 3.96148600e-02f, 8.25991854e-02f, -4.71383985e-03f, -3.75861302e-02f,
  -5.59297316e-02f, -4.31946255e-02f, -3.36543322e-02f, 6.81155026e-02f, 6.19925596e-02f, 4.17664312e-02f, 5.42469211e-02f, -4.16537039e-02f, -4.10748906e-02f, 1.74175370e-02f,
  5.10830134e-02f, -9.20414031e-02f, -3.86926308e-02f, -2.14364659e-02f, 2.87988130e-02f, -3.34992744e-02f, -9.30312425e-02f, -5.06506898e-02f, -3.06739789e-02f, -4.64012325e-02f,
  -5.17163277e-02f, -9.86676067e-02f, 4.00612429e-02f, 5.87909333e-02f, 4.45580147e-02f, -2.11381391e-02f, -7.74984956e-02f, 5.97568043e-02f, 1.27779186e-01f, -2.14684196e-02f,
  1.46453202e-01f, -1.02762366e-02f, -2.27976292e-02f, 7.86361024e-02f, -5.09321876e-02f, -4.38523991e-03f, 9.64725614e-02f, -1.16944678e-01f, 1.01231141e-02f, -1.57242976e-02f,
  4.93921665e-03f, 3.09717972e-02f, 5.64894453e-02f, 3.75780952e-03f, -5.24704494e-02f, -5.10553038e-03f, -4.48381118e-02f, 4.05997075e-02f, 4.35469598e-02f, -1.24790445e-02f,
  4.90346774e-02f, 1.46478461e-02f, -5.95802106e-02f, 7.93727040e-02f, -7.31789544e-02f, -7.35147893e-02f, 5.44198975e-02f, -3.75933871e-02f, -1.60555560e-02f, 1.22261122e-02f,
  1.86679810e-01f, 2.13807270e-01f, 3.07994694e-01f, 1.47514209e-01f, -1.13549478e-01f, -1.21469878e-01f, -6.07382730e-02f, -9.33626741e-02f, 1.84919289e-03f, 8.63866732e-02f,
  -1.23520471e-01f, 3.56421322e-01f, -1.74475089e-01f, 1.38913125e-01f, -1.17429547e-01f, -2.19515160e-01f, -3.79977748e-02f, 1.18771799e-01f, 4.56410162e-02f, 1.06331229e-01f,
  -2.99460422e-02f, -1.05137698e-01f, 1.11703582e-01f, -6.28072545e-02f, 8.36427435e-02f, 2.15520427e-01f, 2.53517553e-03f, -8.98414403e-02f, 1.79057494e-01f, -6.54767454e-02f,
  -1.68561414e-02f, -5.60352020e-02f, 1.41157150e-01f, 6.06036969e-02f, -4.44919046e-04f, 7.63532892e-02f, 6.32866621e-02f, 4.26237173e-02f, -7.30723515e-02f, -7.67553151e-02f,
  5.76499328e-02f, 4.86571761e-03f, 3.31443585e-02f, 2.61515519e-03f, -3.16309705e-02f, 5.19021749e-02f, -5.58097195e-03f, 1.93236396e-02f, 1.90096572e-02f, 1.81806441e-02f,
  1.68146603e-02f, 7.50911683e-02f, 1.07015230e-01f, 2.25744117e-02f, -4.86956760e-02f, 2.81576961e-02f, -2.20339019e-02f, 5.65307327e-02f, -8.07515904e-03f, -1.97019372e-02f,
  -1.23445883e-01f, -1.48123940e-02f, -1.10942302e-02f, 2.80194208e-02f, -4.87694480e-02f, 9.96466726e-02f, -3.37373912e-02f, -6.05198368e-02f, 1.54582588e-02f, -7.63222352e-02f,
  5.83112761e-02f, 4.45071002e-03f, -7.64348805e-02f, 6.35896996e-02f, -1.29562225e-02f, 6.21597357e-02f, 1.32314088e-02f, 9.25398525e-03f, -1.18837981e-02f, 1.10042477e-02f,
  1.44962417e-02f, 2.36781202e-02f, -5.13030849e-02f, -2.36989241e-02f, -2.16223896e-02f, 2.01651119e-02f, -9.80202015e-03f, 1.03699669e-01f, 5.96320583e-03f, 3.72104309e-02f,
  -2.70984452e-02f, -8.92027542e-02f, -6.63438719e-03f, -1.40579119e-02f, -9.87950806e-03f, -2.10168436e-02f, 2.70110667e-02f, 3.00333761e-02f, -7.32283369e-02f, -1.63459275e-02f,
  1.09762384e-03f, 1.77327562e-02f, 3.98216844e-02f, -4.83594835e-02f, -8.19364712e-02f, -3.10787708e-02f, -4.51860167e-02f, 1.84687804e-02f, 1.47223631e-02f, 3.39225382e-02f,
  4.28078882e-02f, -1.63865779e-02f, 4.97218557e-02f, 6.34708926e-02f, 7.40438849e-02f, 2.45215110e-02f, 2.15554163e-02f, 8.75723511e-02f, 1.04313910e-01f, 4.81014922e-02f,
  4.10228670e-02f, -2.66317546e-01f, -1.48015395e-01f, 1.00938044e-01f, 1.62880719e-01f, -2.48804013e-03f, 2.41662133e-02f, 1.09253369e-01f, 6.40431121e-02f, -9.36754495e-02f,
  -1.14763938e-01f, -2.21392691e-01f, -2.01746613e-01f, -6.32036552e-02f, -1.19217172e-01f, -3.16748053e-01f, 3.72572656e-04f, -1.46850795e-01f, -4.05013710e-02f, -7.92856738e-02f,
  8.17122534e-02f, 6.81227222e-02f, -9.46719721e-02f, 6.36888370e-02f, 1.18619636e-01f, 1.50095999e-01f, 1.29501998e-01f, -2.57475767e-02f, 2.63800174e-02f, -5.02899289e-02f,
  8.49625245e-02f, -4.75357659e-02f, -2.87807025e-02f, 6.28191754e-02f, 1.15059637e-01f, 1.12593226e-01f, -1.16062397e-02f, -7.90000632e-02f, 1.50213381e-02f, -4.64810170e-02f,
  -1.00699365e-02f, 3.92070636e-02f, -1.20855402e-03f, 3.19670662e-02f, 1.64064333e-01f, 2.38007363e-02f, -8.66365507e-02f, 3.55417356e-02f, -2.70548053e-02f, -1.14336491e-01f,
  -1.15787415e-02f, -9.14644916e-03f, 2.88713537e-02f, 3.64110470e-02f, -7.24087805e-02f, 6.80034012e-02f, 2.93323351e-03f, -5.38527071e-02f, 5.18320426e-02f, -1.05251022e-01f,
  1.33571737e-02f, 1.41455354e-02f, 2.93197259e-02f, 1.21231759e-02f, -4.14032117e-02f, 1.03238359e-01f, 2.55844928e-03f, -3.38067226e-02f, -1.04492186e-02f, 1.22768898e-02f,
  7.57306144e-02f, -2.51606088e-02f, 4.58086543e-02f, 2.19872501e-02f, 1.97872855e-02f, -1.90698691e-02f, -3.72593515e-02f, -1.73873901e-02f, -1.45346485e-02f, -1.93496160e-02f,
  -1.88268088e-02f, 4.24940772e-02f, -2.49518305e-02f, 3.74404825e-02f, -2.14123819e-02f, 4.77376319e-02f, -6.95364624e-02f, -4.76644821e-02f, 5.68007566e-02f, -2.12110449e-02f,
  3.52187604e-02f, -1.41169876e-01f, -5.76263629e-02f, -1.66280121e-02f, 1.50688579e-02f, -2.08347701e-02f, -8.33755732e-02f, -8.55613276e-02f, -2.62848986e-03f, 8.20985250e-03f,
  5.67151569e-02f, 4.23241174e-03f, 1.01962581e-01f, 7.45192543e-02f, -3.75601426e-02f, -7.29180686e-03f, -5.35695441e-02f, -3.06090433e-02f, 1.27035424e-01f, -3.53930108e-02f,
  7.05415457e-02f, 6.89283758e-02f, 6.45431876e-02f, 4.70977910e-02f, 3.62851508e-02f, 3.12381964e-02f, -3.12301461e-02f, 1.52578279e-02f, -6.48340508e-02f, -3.94626036e-02f,
  2.55111545e-01f, 9.01005417e-02f, -1.91558346e-01f, 4.51696441e-02f, 2.96226554e-02f, 4.88032699e-02f, -2.79659871e-02f, 9.99048278e-02f, -7.53963068e-02f, 4.01962213e-02f,
  -2.96127535e-02f, 2.86994260e-02f, -1.35658205e-01f, 1.38431981e-01f, 2.67782778e-01f, 7.59535506e-02f, 2.27665305e-01f, 3.95938270e-02f, -9.76380706e-03f, 1.27303168e-01f,
  1.92199796e-02f, 2.08277002e-01f, 3.21613834e-03f, 1.05679259e-01f, 1.46373898e-01f, 1.82261392e-02f, 1.07243389e-01f, -1.56990558e-01f, 2.27262881e-02f, 1.89697027e-01f,
  3.63868997e-02f, 1.83397159e-02f, -6.60139322e-02f, 9.04678367e-03f, -5.92465624e-02f, 5.78925610e-02f, -1.27723902e-01f, -4.67873439e-02f, -1.87434852e-02f, 6.45634755e-02f,
  -3.22009511e-02f, 1.77606959e-02f, 5.46429120e-02f, -7.04616606e-02f, -5.20132817e-02f, 1.40175978e-02f, 7.36802816e-02f, -3.72508280e-02f, 3.17062065e-02f, 6.74729869e-02f,
  -1.42369587e-02f, 3.77880260e-02f, -4.73975651e-02f, 1.03477156e-02f, -1.24329077e-02f, 5.48297949e-02f, -5.46637662e-02f, -3.79975922e-02f, 8.50358158e-02f, 3.66400816e-02f,
  1.68381743e-02f, 8.17244947e-02f, -3.77319157e-02f, -2.60694195e-02f, 2.28360277e-02f, -1.07784264e-01f, -3.43262032e-02f, -7.59482831e-02f, -1.57154407e-02f, 2.28263047e-02f,
  -1.69738885e-02f, -5.23021072e-02f, 5.69663458e-02f, -2.44089961e-02f, 4.75347191e-02f, 5.68078272e-02f, 2.83756312e-02f, 3.42356563e-02f, -3.19956653e-02f, -2.65375860e-02f,
  1.42059224e-02f, 1.36883054e-02f, -1.72857177e-02f, -2.90862359e-02f, -3.91590297e-02f, 2.87890844e-02f, 1.21200578e-02f, -3.25434096e-02f, -1.37483971e-02f, -8.28960761e-02f,
  9.63193178e-03f, 1.58249855e-01f, -3.78835909e-02f, 1.25019886e-02f, -3.93024273e-02f, 6.92890957e-02f, 3.87161151e-02f, 4.93706297e-03f, 9.14594904e-02f, 2.80773193e-02f,
  -3.24392840e-02f, -7.57122040e-02f, 8.88674557e-02f, -2.43455097e-02f, -3.88313010e-02f, 1.17853865e-01f, -2.10524146e-02f, -2.04361845e-02f, -3.77082676e-02f, -6.90719159e-03f,
  -5.91839524e-03f, -9.20225866e-03f, 4.56747636e-02f, -1.22936885e-03f, -3.42910811e-02f, 3.21820229e-02f, 5.03832139e-02f, -4.91967462e-02f, 3.23176309e-02f, -1.27760870e-02f,
  1.78164631e-01f, 2.11511049e-02f, -1.61564305e-01f, -2.72354484e-02f, -2.33221412e-01f, -1.48267969e-01f, -1.53505489e-01f, 5.83109446e-02f, 2.14941427e-02f, 1.14768092e-02f,
  -1.05089568e-01f, 1.20642252e-01f, 1.33021206e-01f, -1.45835742e-01f, 7.13892430e-02f, 1.37405574e-01f, 2.05194987e-02f, -5.43233044e-02f, 5.82836904e-02f, -5.38417101e-02f,
  1.03319753e-02f, 4.29387437e-03f, -1.00669853e-01f, -1.33072466e-01f, -1.92509845e-01f, -1.26571536e-01f, -3.82918194e-02f, -1.55646428e-02f, -4.77440357e-02f, -5.03786467e-02f,
  -6.11841306e-02f, 5.68293482e-02f, -3.15426216e-02f, -3.19217369e-02f, 3.27017456e-02f, -6.36988729e-02f, 2.51154136e-02f, 5.91031015e-02f, -6.03703782e-02f, 1.01184376e-01f,
  -3.41135487e-02f, 5.69235384e-02f, 7.10503161e-02f, 4.14590836e-02f, -5.34289740e-02f, -3.93125787e-02f, -4.64743599e-02f, 4.10245880e-02f, -2.12597772e-02f, 6.78420365e-02f,
  4.40559350e-03f, 5.60359769e-02f, 1.06126210e-02f, 3.43096107e-02f, -7.46010989e-02f, -7.07775503e-02f, 5.36006503e-02f, -2.12077200e-02f, 1.99741852e-02f, 2.88405139e-02f,
  9.97977108e-02f, -1.43686933e-02f, 3.13396901e-02f, -3.49530727e-02f, 7.91774988e-02f, -1.67332951e-03f, -5.74030094e-02f, -2.36533626e-04f, -4.83077802e-02f, 8.94383900e-03f,
  -3.28814350e-02f, -3.55920754e-02f, -7.07312375e-02f, 3.15794237e-02f, 3.81602757e-02f, 5.05835935e-02f, -1.85125880e-02f, -8.34137052e-02f, -3.03508155e-02f, 7.40210665e-03f,
  1.36973811e-02f, 7.12817162e-02f, -3.74679193e-02f, 3.32929716e-02f, -1.55443382e-02f, 8.86021182e-03f, -6.97199032e-02f, -5.22227660e-02f, -5.75125869e-03f, -3.36722098e-02f,
  6.19999580e-02f, 1.21620588e-01f, -5.90501055e-02f, 2.25684699e-02f, -5.28553426e-02f, 7.17806071e-02f, -2.56102458e-02f, -3.16319522e-03f, 9.17454213e-02f, -3.42098959e-02f,
  -7.35723600e-03f, -6.92308620e-02f, 4.21231091e-02f, 6.08133562e-02f, -2.60871965e-02f, -4.02175635e-02f, 1.87271051e-02f, 7.43319690e-02f, 4.09288704e-02f, -3.36637497e-02f,
  -7.19391182e-02f, 1.18777893e-01f, 1.10292599e-01f, 2.57562064e-02f, -4.50299904e-02f, 4.19313908e-02f, 9.36363172e-03f, -5.38564660e-02f, 1.31586045e-02f, 6.67208049e-04f,
  -2.70941388e-02f, -2.36004621e-01f, -5.94726577e-02f, 9.36940312e-02f, 9.55856219e-02f, -1.65276770e-02f, -6.37195930e-02f, -1.19068705e-01f, -1.47437617e-01f, -2.20576987e-01f,
  -3.60506587e-02f, 8.37497637e-02f, -9.81210247e-02f, 1.39626972e-02f, 2.30437383e-01f, -9.12835598e-02f, 1.95497908e-02f, -2.58972403e-02f, 7.84234405e-02f, -5.76433986e-02f,
  -6.54324563e-03f, 1.08262107e-01f, 1.06363162e-01f, 8.23388621e-02f, -4.11898382e-02f, 5.57938777e-02f, 3.40976715e-02f, 1.05601914e-01f, 1.33238137e-01f, 1.02770440e-01f,
  -4.55244891e-02f, -6.34123385e-02f, -9.58141312e-02f, -3.07263061e-02f, -1.07569695e-01f, -3.35810566e-03f, 5.96001260e-02f, -1.26139848e-02f, 8.44548866e-02f, 1.38188619e-02f,
  1.98960695e-02f, 1.11704748e-02f, -2.06573773e-02f, 1.02096321e-02f, 2.40306538e-02f, -1.65804401e-02f, 4.84717451e-02f, 8.34315363e-03f, -1.10497815e-03f, 1.88536160e-02f,
  -2.33756490e-02f, 2.29133908e-02f, 5.77805713e-02f, -6.67399764e-02f, 7.08280355e-02f, 3.01307235e-02f, 6.89107180e-02f, 3.86249870e-02f, -4.25498113e-02f, 8.86330288e-03f,
  2.53744442e-02f, 3.37272435e-02f, -7.40308687e-02f, -5.01196682e-02f, -1.96545664e-02f, -4.70304638e-02f, 5.78883924e-02f, -2.13063061e-02f, 6.14418387e-02f, -4.20561545e-02f,
  -3.20870019e-02f, -7.06026107e-02f, -4.57079224e-02f, -5.27660102e-02f, -2.03287620e-02f, -3.16367559e-02f, -2.83689890e-02f, -3.17528807e-02f, 2.01974288e-02f, -1.86366364e-02f,
  2.14024447e-02f, 2.46171728e-02f, -9.02014300e-02f, -1.26089314e-02f, -4.08926532e-02f, 3.58054601e-02f, -5.16332462e-02f, -8.99259895e-02f, -1.62552837e-02f, -6.63005263e-02f,
  -1.88553333e-01f, -1.40118927e-01f, 2.71030702e-02f, -9.34945345e-02f, -6.08218089e-02f, 4.97268848e-02f, 8.15176219e-02f, 4.60072123e-02f, 7.40614859e-03f, -6.38022050e-02f,
  -6.38774037e-02f, 9.08378419e-03f, -5.91956042e-02f, -6.43286109e-02f, -5.25098182e-02f, -4.49540727e-02f, -8.31126645e-02f, 1.49081340e-02f, 7.74188375e-04f, 2.36068070e-02f,
  -5.49546517e-02f, -9.99632478e-02f, -5.73366210e-02f, -5.71992435e-02f, -2.79915985e-02f, -4.08016294e-02f, -2.35844851e-02f, 1.18154464e-02f, 2.48833224e-02f, -8.53302181e-02f,
  -2.07725465e-01f, -5.23769343e-03f, 1.80098146e-01f, -6.07410632e-02f, -6.29031658e-02f, 2.97713608e-01f, 2.19568804e-01f, -3.55316140e-02f, 1.32764492e-03f, -1.33022577e-01f,
  -1.39086530e-01f, -2.61122603e-02f, 1.87386617e-01f, -4.17149402e-02f, 2.68775135e-01f, 2.21634984e-01f, 1.11683927e-01f, 2.46578915e-04f, -2.50361860e-02f, -5.41054010e-02f,
  -8.56111422e-02f, -1.90895364e-01f, 7.51415715e-02f, -1.88952714e-01f, -1.79797515e-01f, -1.24363087e-01f, -2.02293873e-01f, 5.40834367e-02f, -1.31118894e-01f, 8.58305916e-02f,
  -1.03392914e-01f, -4.94183563e-02f, -2.47031543e-02f, 1.07866377e-01f, -2.59302221e-02f, 1.91807859e-02f, 8.83327797e-02f, 3.36333625e-02f, 7.22682290e-03f, 7.51151815e-02f,
  -3.66553739e-02f, -3.62705439e-02f, -2.44966876e-02f, -2.78279260e-02f, -6.24097213e-02f, -6.21287823e-02f, -8.90288502e-02f, 6.19221255e-02f, -2.51581278e-02f, 4.71999422e-02f,
  4.02491027e-03f, -7.04359356e-03f, 4.15211078e-03f, 1.25320433e-02f, -6.03017025e-03f, -1.98653154e-02f, 6.06634654e-02f, 4.44216914e-02f, 1.02309600e-01f, -7.85102844e-02f,
  3.91967334e-02f, 5.21512479e-02f, -2.55997647e-02f, -3.67016532e-02f, -7.51537755e-02f, -2.64805555e-02f, 8.16647056e-03f, 2.06637233e-02f, -6.16345778e-02f, 1.91243477e-02f,
  -5.20390682e-02f, 2.08406355e-02f, 4.84935753e-02f, -4.26744819e-02f, -6.51293844e-02f, -3.60326245e-02f, 2.03604568e-02f, 4.22704704e-02f, -6.65867748e-03f, -5.66932894e-02f,
  1.35975564e-02f, 1.29764676e-01f, -1.79492624e-03f, -3.66883092e-02f, 3.46661918e-02f, 7.06057101e-02f, 2.02115271e-02f, 2.73956805e-02f, -1.00597842e-02f, 1.23115525e-01f,
  1.16720255e-02f, 4.55863327e-02f, 4.72288132e-02f, 3.85196880e-03f, 4.56582196e-02f, -6.36330694e-02f, 1.07455283e-01f, 2.23179329e-02f, 8.73437971e-02f, 6.03718609e-02f,
  -8.47277790e-02f, -6.05633631e-02f, 1.65509284e-02f, -5.50964959e-02f, 1.61498357e-02f, -2.84143239e-02f, -1.27829555e-02f, 3.19097005e-02f, -5.42993248e-02f, 5.74913546e-02f,
  4.74541225e-02f, -6.03949418e-03f, 5.00635467e-02f, -6.86359257e-02f, -3.39231789e-02f, 3.28502133e-02f, -8.92408341e-02f, 3.73781733e-02f, -4.95327562e-02f, 3.32501568e-02f,
  1.34679183e-01f, -6.86613424e-03f, -9.59017053e-02f, 8.27600341e-03f, -1.90420169e-02f, 1.08931344e-02f, -6.34251982e-02f, 2.59433556e-02f, 2.45101169e-01f, -4.53531481e-02f,
  -1.42652735e-01f, 2.18520641e-01f, -5.92748411e-02f, -5.28376140e-02f, 1.56127259e-01f, 1.31266281e-01f, -6.29368722e-02f, -8.47990438e-03f, 3.98780704e-02f, -6.78015053e-02f,
  -1.52453789e-02f, -4.36799712e-02f, -5.71771637e-02f, -1.60689726e-01f, -1.22027628e-01f, -6.10986017e-02f, -1.41673192e-01f, -1.79640397e-01f, -1.59057632e-01f, 1.65174119e-02f,
  -9.21142623e-02f, -3.67278308e-02f, -8.75591338e-02f, -5.79370148e-02f, -1.08810037e-01f, -3.20284671e-05f, -5.62952422e-02f, -5.53532764e-02f, 5.10995947e-02f, -8.58103763e-03f,
  1.01270989e-01f, -3.57827246e-02f, -7.45753245e-03f, -2.52563972e-02f, -3.43813226e-02f, -4.61658053e-02f, 2.46113841e-03f, -1.35146722e-01f, 4.42278348e-02f, -8.89532939e-02f,
  -5.28090037e-02f, 7.79157877e-03f, -9.54611525e-02f, -1.72855332e-02f, -1.84217934e-02f, 8.52650180e-02f, 9.38069224e-02f, 4.63548638e-02f, -3.06754857e-02f, 9.04738232e-02f,
  -9.54358280e-02f, 5.42614795e-02f, 3.50567177e-02f, -6.37252852e-02f, -9.63371899e-03f, 2.01136768e-02f, 2.96052732e-02f, -6.75036907e-02f, 4.87080775e-04f, -1.92530043e-02f,
  -2.89537348e-02f, 4.08001505e-02f, 6.76266700e-02f, -3.53404582e-02f, -4.43471856e-02f, 7.06610605e-02f, -1.89172644e-02f, -3.19230817e-02f, 8.63568205e-03f, -7.84473345e-02f,
  -6.65833578e-02f, -1.30673321e-02f, 5.18852798e-03f, -1.03556693e-01f, -4.74236719e-02f, 3.87238413e-02f, -1.53134170e-03f, 6.23532757e-02f, -1.07855745e-01f, -7.57328048e-02f,
  1.38430476e-01f, 2.24387810e-01f, -2.28242725e-02f, -5.07381745e-02f, 5.71115911e-02f, 9.18425545e-02f, 5.93489781e-03f, 6.39801100e-02f, 6.89191893e-02f, -2.02697515e-02f,
  -4.58483631e-03f, 6.15104549e-02f, 1.70599227e-03f, -7.46790320e-02f, 7.62849301e-02f, 1.03030510e-01f, 2.71874350e-02f, -1.91499610e-02f, 2.63729058e-02f, -6.05955534e-02f,
  -1.36337489e-01f, -5.15024215e-02f, 5.30391224e-02f, 8.33836496e-02f, -6.63142726e-02f, 6.40548649e-04f, 7.17688277e-02f, -3.72436121e-02f, 7.89257362e-02f, 4.81906869e-02f,
  2.15164557e-01f, -5.96012361e-02f, -2.02673465e-01f, -2.02101469e-03f, 6.73417374e-02f, 1.14522010e-01f, -6.48956299e-02f, 5.58805987e-02f, -4.20185626e-02f, 1.11540724e-02f,
  1.87733900e-02f, 1.04852073e-01f, -1.53831393e-01f, 1.05308071e-01f, -8.77338275e-03f, -5.85905612e-02f, 3.22522968e-02f, 6.10146783e-02f, -4.12218785e-03f, 5.18621355e-02f,
  -6.18423596e-02f, 7.47234002e-02f, -7.57153332e-02f, 5.20704873e-02f, 1.51894808e-01f, -4.61564548e-02f, -4.44729887e-02f, -1.05509892e-01f, 3.84420790e-02f, -1.33989872e-02f,
  4.74186353e-02f, 6.84160441e-02f, -4.92336974e-02f, -3.53470221e-02f, 2.53545400e-02f, 4.01281379e-02f, -2.86405254e-02f, -6.43959939e-02f, 5.10241464e-02f, -3.26823145e-02f,
  -2.30139140e-02f, 1.77745577e-02f, -3.94418091e-02f, 8.14972669e-02f, 3.04470508e-04f, 2.17564665e-02f, -4.85841930e-02f, -3.29234861e-02f, -3.54495496e-02f, -9.91609879e-03f,
  1.95955206e-02f, -7.55815208e-02f, 5.34357578e-02f, -9.32079032e-02f, 3.09191905e-02f, 6.50470257e-02f, 3.22656818e-02f, -1.00980056e-02f, -9.51625220e-03f, 2.67451797e-02f,
  1.30913824e-01f, -1.08310692e-02f, -2.32329071e-02f, 2.42451038e-02f, -6.29903972e-02f, 9.51697305e-03f, 8.32775608e-03f, 1.67939980e-02f, -1.75846945e-02f, 4.52316180e-02f,
  -7.23860040e-02f, 4.37167287e-02f, -3.76368575e-02f, 7.62335062e-02f, -5.08157210e-03f, -7.45216310e-02f, -5.60628250e-02f, 3.75637300e-02f, -2.10719798e-02f, -5.91571182e-02f,
  -4.39210534e-02f, -3.34555120e-03f, 5.04049025e-02f, 8.90314486e-03f, 2.61483807e-02f, -5.57929911e-02f, 1.27967717e-02f, 6.52517304e-02f, -1.57887805e-02f, 7.84553066e-02f,
  3.65661569e-02f, 8.97426903e-02f, -2.08052937e-02f, 1.75948115e-03f, -3.58036831e-02f, 1.12506703e-01f, -2.68122330e-02f, 7.65669271e-02f, 4.14124839e-02f, 4.09867242e-02f,
  -5.12223504e-02f, -5.55444621e-02f, 1.84709895e-02f, 2.87680179e-02f, -8.90089273e-02f, -3.87650840e-02f, -5.33996746e-02f, 6.31621480e-03f, 6.87916055e-02f, 1.20747313e-02f,
  1.30745936e-02f, -5.70093431e-02f, -7.00325742e-02f, -1.47503316e-02f, -4.12772559e-02f, 5.57332523e-02f, 2.18358431e-02f, 6.41652942e-02f, -6.41439185e-02f, -5.38362488e-02f,
  -2.17626616e-02f, 6.50735423e-02f, -1.97424561e-01f, 2.48465296e-02f, 8.15029293e-02f, 2.55024463e-01f, 5.36813140e-02f, 1.46819070e-01f, 8.30533952e-02f, 1.49536297e-01f,
  3.55179496e-02f, 1.05232969e-01f, 1.01389224e-02f, 3.13810498e-01f, 2.08910301e-01f, -2.25229766e-02f, 2.82762408e-01f, 1.62287533e-01f, 1.47464452e-02f, 6.32287115e-02f,
  6.30353987e-02f, 3.38693857e-01f, -6.58347923e-03f, 7.87554979e-02f, 1.30439103e-01f, -1.38058141e-01f, -7.64255524e-02f, -1.89353064e-01f, 4.89641204e-02f, 1.51039794e-01f,
  2.40224637e-02f, -2.94024721e-02f, -1.03013203e-01f, 4.59082332e-03f, -5.13448566e-02f, -4.54513021e-02f, 1.66508034e-02f, 3.37417088e-02f, -6.87548742e-02f, 1.74954883e-03f,
  -5.12658581e-02f, 2.73274146e-02f, -1.69177614e-02f, 3.02645713e-02f, 6.56486228e-02f, 7.23665161e-03f, -6.72295168e-02f, -6.94778562e-02f, -9.14966613e-02f, -3.73828784e-02f,
  -1.12310216e-01f, 7.74328923e-03f, -9.62222815e-02f, 5.08003831e-02f, 6.18971959e-02f, -5.92663884e-02f, 1.44936191e-02f, -1.18377233e-04f, 2.87064686e-02f, 7.15197623e-02f,
  8.86140838e-02f, -5.81876226e-02f, 1.01901315e-01f, -2.31739860e-02f, 6.43805191e-02f, 3.16484272e-02f, -1.26886982e-02f, 1.24484608e-02f, -1.51646053e-02f, 1.92674678e-02f,
  -4.50834492e-03f, -1.17038628e-02f, 1.26968808e-02f, -1.04696713e-02f, 5.67688532e-02f, 7.27590546e-02f, -8.18184838e-02f, 2.38854773e-02f, 7.68457027e-03f, 1.21860662e-02f,
  -7.28096440e-03f, -9.78910644e-03f, 4.25206833e-02f, -8.94672144e-03f, 7.36571476e-02f, -2.65194345e-02f, -2.98848394e-02f, -2.90590990e-02f, -1.32673150e-02f, 2.44539138e-02f,
  1.32364303e-01f, 1.47672400e-01f, 4.34315093e-02f, 9.48979054e-03f, 1.25773146e-03f, 2.34503243e-02f, -1.50470100e-02f, 4.95842658e-03f, -5.34459651e-02f, 8.43769461e-02f,
  -2.89418343e-02f, -4.20386717e-02f, 1.07465699e-01f, -9.03045833e-02f, -1.60949994e-02f, 3.72320674e-02f, -6.19416730e-03f, 5.38744368e-02f, 1.15131892e-01f, 5.50738461e-02f,
  -1.81503110e-02f, -5.40112071e-02f, 2.30380092e-02f, -7.84137547e-02f, 5.19511104e-03f, -8.67937952e-02f, 7.51334876e-02f, 1.81408913e-03f, 4.48601432e-02f, -6.14209212e-02f,
  1.61308676e-01f, 2.21538246e-01f, 3.35940748e-01f, 3.56602281e-01f, -1.02930330e-01f, -2.81085163e-01f, -7.60944411e-02f, -1.81651637e-02f, 1.68456301e-01f, 5.58536127e-02f,
  -2.09120512e-01f, 3.56970102e-01f, -1.09790333e-01f, 1.79518342e-01f, -1.54590756e-01f, -1.05743162e-01f, 1.16012424e-01f, -3.12157930e-03f, 5.25642112e-02f, 1.89220920e-01f,
  3.38265598e-02f, -7.82406703e-02f, 8.32008794e-02f, -9.18618739e-02f, 5.98446354e-02f, 2.33327195e-01f, -1.16488591e-01f, -1.51102528e-01f, 3.68289798e-02f, -1.05055459e-01f,
  -1.67442597e-02f, 1.48676291e-01f, -2.11772695e-02f, 7.13016745e-03f, 1.92171466e-02f, -4.04065102e-03f, 3.79850641e-02f, -1.65663183e-01f, -4.21970151e-02f, 6.01558052e-02f,
  1.14803530e-01f, -7.69713661e-03f, -7.37895351e-03f, -5.56240557e-03f, -3.42171453e-02f, -3.06010209e-02f, 1.28571987e-01f, 8.05625692e-02f, 4.36175391e-02f, 5.58380373e-02f,
  1.59009963e-01f, -9.77254193e-03f, 1.04572974e-01f, 1.74769107e-02f, 9.10956636e-02f, 4.04742509e-02f, 6.55439198e-02f, 1.07897201e-03f, 9.07265693e-02f, 1.10195085e-01f,
  5.17207980e-02f, -6.57213703e-02f, -2.38966700e-02f, -4.39532995e-02f, 1.72309566e-03f, -2.08868627e-02f, 2.38909125e-02f, -2.93876720e-03f, 5.48663437e-02f, -8.32145214e-02f,
  -2.84379255e-02f, 2.15316080e-02f, -1.93375889e-02f, -3.98549661e-02f, 1.44525878e-02f, 4.03163880e-02f, -3.37500013e-02f, 1.49130141e-02f, -6.48516091e-03f, -1.63250417e-03f,
  -4.30258922e-02f, -6.51340932e-02f, 2.35762075e-02f, 1.67243090e-02f, -1.03362568e-01f, -1.70810819e-02f, 3.76548916e-02f, -2.90348493e-02f, 2.11237371e-02f, -7.29927570e-02f,
  6.95945546e-02f, 1.47461444e-01f, 6.13847785e-02f, -3.14984918e-02f, -2.27980549e-03f, -5.49966730e-02f, 5.91702722e-02f, 7.63824806e-02f, 8.67863595e-02f, -8.60482454e-02f,
  -1.23691559e-02f, -5.89343160e-02f, -1.95852201e-02f, -7.84073845e-02f, 2.48283613e-02f, 5.73349036e-02f, 4.86249849e-02f, 5.76999113e-02f, 7.67582580e-02f, 4.32615727e-02f,
  3.95166278e-02f, 1.42680909e-02f, -5.50941564e-02f, 3.48841958e-02f, -2.48407219e-02f, 7.88276792e-02f, 3.73587124e-02f, 3.81952375e-02f, 2.57147569e-02f, 1.73421707e-02f,
  1.74299762e-01f, 7.51524568e-02f, -2.23745722e-02f, 1.55537561e-01f, -1.21795096e-01f, -1.53456882e-01f, -1.31073520e-01f, 1.22661583e-01f, -1.28742456e-01f, -1.38875142e-01f,
  4.75664921e-02f, -9.50684324e-02f, 6.81955442e-02f, 1.43569514e-01f, 7.74454772e-02f, -8.33631377e-04f, -3.02397124e-02f, -9.65957865e-02f, 8.58359970e-03f, 2.06579238e-01f,
  2.33476207e-01f, 2.26657048e-01f, 2.28264853e-01f, 1.03873104e-01f, 8.17536041e-02f, 1.74314976e-01f, 2.48182386e-01f, 7.75222406e-02f, 7.98131749e-02f, -7.92143419e-02f,
  -5.30295521e-02f, 1.56522483e-01f, -2.63716988e-02f, 3.25606652e-02f, -1.37528004e-02f, -7.71858618e-02f, 2.65919678e-02f, 2.01505162e-02f, -3.71084623e-02f, 3.47363316e-02f,
  -2.64320150e-02f, 1.18105393e-02f, -8.27875733e-02f, 2.00935621e-02f, -1.14039592e-02f, 3.90787981e-02f, -7.07295351e-03f, 1.23990308e-02f, -6.37839039e-05f, 3.02924700e-02f,
  6.72696233e-02f, -8.92193541e-02f, 3.03745922e-02f, -5.53584732e-02f, -3.08693349e-02f, -6.68079108e-02f, -7.65481964e-02f, 1.31367054e-02f, 2.48150956e-02f, -5.54291941e-02f,
  1.31891921e-01f, -1.71205215e-02f, 6.77283807e-03f, -3.14265899e-02f, -1.64870527e-02f, 6.13821596e-02f, 7.13846460e-02f, 3.35131027e-02f, 2.57040542e-02f, 7.97762163e-03f,
  -7.39101768e-02f, 1.02719888e-01f, 1.96310673e-02f, 2.57152580e-02f, -4.49397899e-02f, -1.19216040e-01f, 5.56473620e-03f, 4.57497016e-02f, 6.54599071e-02f, 6.03378639e-02f,
  -4.04655673e-02f, 6.51112273e-02f, 2.32383329e-02f, 5.49156815e-02f, -6.10590652e-02f, 3.55995186e-02f, 1.01580620e-01f, 5.58140017e-02f, 1.94708575e-02f, 6.06429875e-02f,
  3.16915438e-02f, 1.80417553e-01f, 4.38640788e-02f, -7.48176798e-02f, -3.60759608e-02f, -3.95808034e-02f, 3.44062746e-02f, 4.33742069e-02f, 1.33861631e-01f, 1.43633876e-02f,
  -4.98262346e-02f, -4.15799953e-02f, -2.38273684e-02f, 4.85419519e-02f, 1.06127020e-02f, 8.60573631e-03f, 1.08063370e-01f, 3.96589041e-02f, -4.02377062e-02f, 6.99493214e-02f,
  -2.47650333e-02f, 4.37648892e-02f, -4.19024751e-02f, -6.27192855e-02f, -2.02351268e-02f, -3.76835018e-02f, -9.62268934e-02f, -1.73824131e-02f, 9.00109485e-02f, -4.75097075e-02f,
  -1.05184667e-01f, 6.84958622e-02f, -3.10004521e-02f, -2.37309948e-01f, -1.74287334e-01f, -4.86098304e-02f, -1.44305006e-01f, -1.30723566e-01f, -4.60606366e-02f, -8.81247669e-02f,
  -1.69839635e-01f, 3.92361581e-02f, 1.38094738e-01f, -4.86813672e-02f, 9.12901163e-02f, 1.77202240e-01f, -1.19685814e-01f, -1.12745427e-01f, 8.72928947e-02f, -2.12268442e-01f,
  -4.90693450e-02f, -7.74081796e-02f, 7.67739415e-02f, 2.71941777e-02f, -1.84967011e-01f, -3.79113145e-02f, -5.58076501e-02f, -7.61762932e-02f, -1.01285055e-01f, -7.86431879e-02f,
  -4.40124534e-02f, -1.53101668e-01f, -7.11219162e-02f, -1.12543911e-01f, -1.13536857e-01f, -5.63047044e-02f, -1.09880656e-01f, 5.02833724e-03f, 1.81483608e-02f, -8.70282575e-02f,
  -7.07213208e-02f, 3.57296020e-02f, 2.70040683e-03f, 6.17563985e-02f, -7.17030689e-02f, -6.63228109e-02f, 7.24190846e-02f, -5.46315387e-02f, 2.26700641e-02f, 7.87548022e-04f,
  1.11702299e-02f, 5.26504442e-02f, 1.81268789e-02f, 2.47025397e-02f, 4.44319658e-02f, -5.49238622e-02f, 7.79189244e-02f, -5.22070006e-03f, -1.91037674e-02f, -6.09392263e-02f,
  -5.89203052e-02f, -3.50996628e-02f, -5.26275970e-02f, 4.32141963e-03f, 1.76820327e-02f, -9.33740512e-02f, 1.55172981e-02f, 2.88135186e-02f, 4.59392294e-02f, 9.16542187e-02f,
  -5.14568873e-02f, -5.87829351e-02f, 5.25738951e-03f, 3.72108035e-02f, 3.63352522e-02f, -2.02966984e-02f, 5.77343665e-02f, -2.93213967e-03f, 2.93034362e-03f, -2.62712166e-02f,
  -6.11175895e-02f, 4.75363247e-03f, -8.56511947e-03f, 3.17199081e-02f, 3.83049529e-03f, 7.36768693e-02f, 3.50036398e-02f, 7.56479353e-02f, -5.74468039e-02f, 2.67869346e-02f,
  -9.14294273e-02f, -2.03184262e-01f, 5.01748584e-02f, -7.27434158e-02f, 7.00121894e-02f, 2.76329312e-02f, -2.55543385e-02f, -9.64054093e-03f, -1.02057807e-01f, -1.27022877e-01f,
  4.40852344e-03f, 2.56708860e-02f, -4.48267236e-02f, -2.87041068e-03f, 9.28043500e-02f, 6.61106780e-02f, -2.12058965e-02f, -9.66867432e-02f, -7.06122592e-02f, -2.05108225e-02f,
  4.86979112e-02f, -7.00220689e-02f, 7.35157430e-02f, -2.71813944e-03f, -2.68012136e-02f, -3.89361382e-02f, -9.13771018e-02f, 1.04482420e-01f, 1.42289879e-04f, 5.42716756e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.06051147e-01f, 1.59089074e-01f, 7.55296648e-02f, 1.58835109e-02f, 1.89117417e-01f, 1.89139485e-01f, 1.76187560e-01f, 1.28440320e-01f, 1.79834634e-01f, 1.54949307e-01f,
  2.40296558e-01f, 1.91262588e-01f, 1.01946801e-01f, 5.57348132e-02f, 5.76788671e-02f, 7.52227083e-02f, 3.22893150e-02f, 3.03132460e-04f, 7.42936581e-02f, 1.20929927e-01f,
  2.40870759e-01f, 1.64348051e-01f, 1.61164314e-01f, 1.27285808e-01f, 1.67613670e-01f, 2.01310426e-01f, 1.24734178e-01f, 9.43236277e-02f, 8.79872516e-02f, 1.44189179e-01f,
  1.80907547e-01f, 1.41953900e-01f, 3.11124902e-02f, 2.21754551e-01f, 1.82162359e-01f, 6.85780570e-02f, 2.36458600e-01f, 3.01662475e-01f, 1.22548200e-01f, 1.06951408e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -7.10084336e-03f, 8.01514685e-02f, -2.07039006e-02f, -2.12969333e-01f, 1.07240789e-01f, -3.25623564e-02f, -3.45322974e-02f, -9.45454985e-02f, -3.57719488e-03f, -1.47513403e-02f,
  3.89716122e-04f, 4.73209796e-03f, -6.31318102e-03f, 3.82008821e-01f, -6.59909621e-02f, -6.47136196e-02f, 6.93899989e-02f, 6.30390346e-02f, 2.88119931e-02f, 1.29674906e-02f,
  -8.06751400e-02f, -1.52858794e-01f, 1.70468569e-01f, -9.71476287e-02f, -3.04390728e-01f, 7.25386217e-02f, -1.92236647e-01f, -1.43455565e-01f, 1.20521732e-01f, -4.15169671e-02f,
  -2.14783810e-02f, 6.56687561e-03f, -8.54579136e-02f, 1.08238436e-01f, -5.92709472e-03f, -1.17822941e-02f, 1.31603479e-01f, 8.25253651e-02f, 1.24385469e-01f, -3.61922383e-02f,
  -1.26047000e-01f, -1.14116840e-01f, 2.16049496e-02f, 1.77481964e-01f, 2.09431276e-01f, -1.29302993e-01f, 2.44469002e-01f, -1.37875080e-01f, -2.35191599e-01f, -4.60928753e-02f,
  7.21216053e-02f, 3.55273224e-02f, 8.43621790e-03f, 2.58733898e-01f, 1.14186503e-01f, 4.48671654e-02f, -4.88422997e-02f, -1.88732237e-01f, -1.25270095e-02f, 1.30897835e-01f,
  9.73268226e-02f, 3.24319326e-03f, 3.68380882e-02f, -2.26796702e-01f, -8.28763843e-02f, -1.65123090e-01f, 4.82311584e-02f, 2.43018661e-03f, -3.61694396e-02f, -8.38693008e-02f,
  -2.85382941e-02f, -1.43554538e-01f, 2.61318963e-02f, -3.96494493e-02f, -1.69840604e-02f, -2.47647464e-01f, 4.80274186e-02f, -1.13333404e-01f, 2.41124734e-01f, -2.03807041e-01f,
  1.80655241e-01f, 3.85280177e-02f, 5.17260730e-02f, 1.85662568e-01f, 1.13496572e-01f, 1.97674826e-01f, -1.17563821e-01f, 1.44513652e-01f, -2.34728437e-02f, -2.00452983e-01f,
  -7.30195343e-02f, 3.69803868e-02f, -1.47790074e-01f, -2.01806769e-01f, -2.39301935e-01f, -7.00397119e-02f, 4.84366193e-02f, -8.57170597e-02f, 7.86071569e-02f, -2.79710032e-02f,
  9.16826203e-02f, 9.26086083e-02f, 3.70522812e-02f, 9.40153748e-02f, 1.23440683e-01f, -8.57117400e-02f, -1.83507144e-01f, -8.39391053e-02f, -1.63731545e-01f, 3.64436721e-03f,
  -2.05322038e-02f, 1.47091627e-01f, 1.53840512e-01f, 3.85305695e-02f, -1.08860470e-01f, 9.71447378e-02f, -3.60185653e-02f, -1.83860868e-01f, 7.03246742e-02f, 1.75048605e-01f,
  -2.13787302e-01f, 5.31672426e-02f, 1.44415691e-01f, -2.12114826e-02f, 1.75540894e-01f, 5.85763380e-02f, -9.95020270e-02f, 1.69250876e-01f, -1.25211664e-02f, 2.25176271e-02f,
  2.19982024e-02f, 7.59466514e-02f, 1.32500753e-01f, 1.88529715e-01f, 5.76346666e-02f, 2.17529107e-02f, -9.73419175e-02f, -5.06482609e-02f, 8.62930939e-02f, 2.61062402e-02f,
  -1.29037946e-01f, 1.75483614e-01f, 3.77721190e-02f, -1.39457226e-01f, 1.49970889e-01f, 3.27076256e-01f, 1.76889598e-01f, 5.43546006e-02f, 1.88896954e-01f, -1.24572553e-01f,
  -1.43615529e-01f, 2.08631277e-01f, -3.24860215e-01f, -1.01473689e-01f, -1.86272442e-01f, 6.42635077e-02f, 3.98864038e-02f, 3.02295983e-02f, -9.69575122e-02f, -1.21427134e-01f,
  -1.43240511e-01f, 7.44544640e-02f, 1.99255183e-01f, 5.31897657e-02f, 4.88554724e-02f, -2.27957256e-02f, 9.50178970e-03f, 2.90527418e-02f, -1.33687615e-01f, 1.52799904e-01f,
  1.75697476e-01f, -9.71724745e-03f, 7.09327310e-02f, -1.93442509e-01f, 3.13612893e-02f, 8.47552121e-02f, -1.26603246e-01f, -4.72229393e-03f, 9.91759822e-02f, -5.60914874e-02f,
  -1.59926843e-02f, 1.00269578e-01f, 1.64736003e-01f, 9.46799815e-02f, -1.39473274e-01f, -1.52477041e-01f, 6.94219396e-02f, 1.29206449e-01f, 6.34517968e-02f, 2.17717439e-01f,
  1.24484360e-01f, -1.62699491e-01f, 7.04473481e-02f, -2.50657964e-02f, -1.64077014e-01f, 9.93077382e-02f, 2.28104815e-02f, -2.80208443e-03f, 1.13203213e-01f, -3.04204561e-02f,
  1.94127321e-01f, 1.34502143e-01f, 1.21883638e-01f, 8.20217282e-02f, 6.78424025e-03f, -1.73513591e-01f, 1.72248855e-01f, 9.39745381e-02f, 2.96063900e-01f, -1.95024446e-01f,
  -2.81226598e-02f, 2.27146164e-01f, -3.70165594e-02f, 3.90169094e-03f, -4.00567465e-02f, 1.89979255e-01f, 7.78942462e-03f, -1.98294148e-01f, -5.13626598e-02f, 4.89448905e-02f,
  1.98634900e-02f, -3.22286367e-01f, -1.80037767e-01f, 6.67087138e-02f, -1.50447190e-01f, 6.92832842e-02f, 4.93365042e-02f, -9.76192281e-02f, -6.03664108e-02f, -1.60159439e-01f,
  6.17895983e-02f, 1.49993808e-03f, 1.03231110e-01f, 3.65238860e-02f, 4.12514433e-02f, -1.26375318e-01f, -1.22984506e-01f, 1.59732357e-01f, 1.31898439e-02f, 7.62498155e-02f,
  1.46578535e-01f, -1.30235583e-01f, -3.96318771e-02f, 9.77018923e-02f, -1.92054242e-01f, -1.78827122e-01f, 7.82576948e-02f, -7.63208047e-02f, -8.76652226e-02f, 8.55529010e-02f,
  1.28145933e-01f, -2.80537996e-02f, 2.20737830e-01f, 2.31136871e-03f, 2.44329944e-01f, -5.98900206e-02f, -7.03185350e-02f, 2.26998165e-01f, -8.14419836e-02f, -4.06419933e-02f,
  -8.79851803e-02f, 1.49518684e-01f, -1.20860405e-01f, -7.04359859e-02f, -7.98410326e-02f, -6.36938289e-02f, -1.68808371e-01f, 6.49977699e-02f, 2.45847493e-01f, -1.26737028e-01f,
  -8.07181448e-02f, 1.88490123e-01f, 1.32817343e-01f, 2.44044393e-01f, -4.14365195e-02f, 6.58266768e-02f, 3.17934871e-01f, -2.90091103e-03f, -1.75197273e-01f, -7.04325922e-03f,
  1.35139123e-01f, -8.11326578e-02f, -1.02991074e-01f, 3.84875350e-02f, 2.04093516e-01f, 9.72580910e-03f, 5.44666313e-02f, -1.81527004e-01f, 2.72046067e-02f, -1.00923106e-01f,
  2.47881562e-01f, 4.26236540e-02f, 3.37496065e-02f, -4.33873013e-02f, -8.60885680e-02f, -2.85855811e-02f, -6.60618320e-02f, 4.00258601e-02f, 1.50047421e-01f, -5.65515272e-02f,
  -1.10776946e-02f, -1.52130947e-01f, 1.26334354e-01f, -1.69636279e-01f, -5.64903915e-02f, 5.94863109e-02f, 1.93892773e-02f, -5.43311723e-02f, 2.40995124e-01f, -1.12416893e-01f,
  -6.84062093e-02f, 4.74006571e-02f, -8.34033713e-02f, -4.94287722e-02f, -4.47562290e-03f, -1.60211131e-01f, -1.46675631e-01f, 2.18319505e-01f, 4.37892526e-02f, -6.56940714e-02f,
  -4.86752763e-02f, -9.36128013e-03f, 2.29002815e-02f, -2.79771890e-02f, -8.75086784e-02f, 5.46465665e-02f, -6.04482479e-02f, 7.60960653e-02f, -1.13401555e-01f, -1.18422583e-01f,
  -2.17603128e-02f, 8.55800435e-02f, -3.20719443e-02f, 1.78795204e-01f, -3.47219139e-01f, -7.12162331e-02f, 1.44104421e-01f, -5.13149984e-02f, 1.86695367e-01f, 2.90875044e-02f,
  -2.59668440e-01f, 1.16148621e-01f, -9.53857973e-03f, 8.69201198e-02f, 2.10323129e-02f, 3.76641192e-02f, -1.00521766e-01f, 7.83321038e-02f, 1.47892848e-01f, -1.27086133e-01f,
  1.11921147e-01f, 6.82712421e-02f, -1.43626586e-01f, 2.08068676e-02f, 1.30041257e-01f, 6.01322465e-02f, -4.99452949e-02f, -1.25161543e-01f, -7.40182623e-02f, -1.24545649e-01f,
  1.26195639e-01f, 6.62259534e-02f, 1.34467185e-01f, -8.16502944e-02f, 6.82964027e-02f, -2.17140123e-01f, 3.09140906e-02f, 4.06982750e-02f, -2.87377965e-02f, 1.02358818e-01f,
  -4.40353900e-02f, -8.72961059e-02f, 1.76796213e-01f, 1.20104127e-01f, -2.77397670e-02f, -9.35958400e-02f, -9.69011113e-02f, -1.00782223e-01f, -1.49026200e-01f, 1.15403328e-02f,
  1.17409386e-01f, 2.06076473e-01f, 6.59302101e-02f, -1.67740509e-01f, 2.43017115e-02f, 1.13235652e-01f, 1.23565450e-01f, 1.51170224e-01f, 6.99555948e-02f, 1.30548507e-01f,
  5.34090735e-02f, 1.94798931e-01f, -1.10211760e-01f, -8.05062354e-02f, 1.57132044e-01f, -8.20915028e-02f, -9.03662518e-02f, -1.07587382e-01f, -4.73655090e-02f, -2.59566903e-01f,
  -8.89099855e-03f, 1.42686158e-01f, 1.30678872e-02f, -2.07521528e-01f, 8.34654365e-03f, -1.69630215e-01f, -1.44285664e-01f, 4.91196103e-02f, -1.63331255e-02f, 8.33171010e-02f,
  1.01595763e-02f, 9.50488821e-02f, -1.00275852e-01f, 1.19758055e-01f, 8.07274804e-02f, -4.38257679e-02f, -1.46377549e-01f, 4.80766296e-02f, -7.40121603e-02f, -1.32319659e-01f,
  -2.83300821e-02f, 1.16373122e-01f, -9.33912098e-02f, 1.57861054e-01f, -1.15174480e-01f, -1.42850280e-02f, -5.69758452e-02f, 4.41036420e-03f, -1.68797091e-01f, 3.84398811e-02f,
  -1.94477201e-01f, -2.41608135e-02f, 1.70600399e-01f, -3.86070833e-02f, -3.96519005e-02f, 1.68221295e-01f, -2.06282243e-01f, 9.47182924e-02f, -9.87976566e-02f, 7.24807009e-02f,
  2.93585304e-02f, 1.66005388e-01f, 1.29084349e-01f, 3.80373634e-02f, -2.34376285e-02f, -2.80925453e-01f, -1.83608681e-01f, 8.69563445e-02f, 4.72397506e-02f, 1.25995710e-01f,
  3.71829532e-02f, 8.01380798e-02f, 3.70455310e-02f, 2.51676366e-02f, 2.14210767e-02f, -7.59301633e-02f, 2.36116424e-02f, 7.65192285e-02f, 2.02488974e-01f, 8.06708038e-02f,
  1.07381465e-02f, -1.72128305e-02f, 6.62706420e-02f, 1.03472233e-01f, -2.21204445e-01f, 1.96058378e-01f, -1.13996193e-01f, 1.79142393e-02f, 2.30616882e-01f, -1.99559659e-01f,
  2.13270679e-01f, -4.14543860e-02f, -2.46802375e-01f, 1.20700151e-01f, 1.42950803e-01f, -1.02382690e-01f, 9.82271284e-02f, 2.63595402e-01f, 9.01911706e-02f, 1.60444193e-02f,
  -4.17442359e-02f, 2.31294474e-03f, 7.40872398e-02f, -6.66759908e-02f, 1.41308993e-01f, -1.01976387e-01f, -1.60078943e-01f, -1.88249722e-01f, -1.74735725e-01f, 6.21228479e-03f,
  -1.86860830e-01f, 3.25066335e-02f, -7.48645440e-02f, 2.67607234e-02f, 5.49688041e-02f, 5.05487854e-03f, -1.63616315e-01f, 7.01706391e-03f, -6.85751215e-02f, 4.35328558e-02f,
  1.18292682e-01f, -9.06157121e-02f, -1.01544835e-01f, 1.15388446e-03f, 8.15735981e-02f, 2.05756634e-01f, 1.22545272e-01f, -5.84176145e-02f, -1.58977240e-01f, -8.82864818e-02f,
  -1.30893558e-01f, 1.32432088e-01f, -7.64423013e-02f, 9.64593440e-02f, -1.25780925e-01f, 7.35918246e-03f, -3.78392711e-02f, 2.79757921e-02f, 4.04048003e-02f, 7.20878914e-02f,
  1.69628367e-01f, 1.18618377e-01f, 4.53397743e-02f, -1.64660513e-02f, 3.46632712e-02f, -3.56554776e-01f, 2.36433074e-01f, 2.24489689e-01f, 2.10054845e-01f, -5.13665471e-03f,
  -2.01323163e-02f, 3.00141573e-01f, 2.15822607e-01f, 7.89759457e-02f, -4.01231870e-02f, 1.56609565e-01f, 1.44810379e-01f, -1.27101600e-01f, 9.96156931e-02f, 1.79494694e-02f,
  -5.50329797e-02f, -2.69048125e-01f, -2.17718244e-01f, -1.83895275e-01f, 3.16237733e-02f, 2.07592212e-02f, 1.37934357e-01f, 3.15808989e-02f, 3.49179544e-02f, -1.05530761e-01f,
  9.80209187e-02f, 1.43861637e-01f, 1.01172656e-01f, -8.06678012e-02f, 1.52622256e-02f, -2.22848698e-01f, -7.00082034e-02f, 1.08943671e-01f, -4.10618074e-02f, 1.06881730e-01f,
  1.52897432e-01f, 3.84334587e-02f, -1.08930916e-01f, 1.66197389e-01f, -6.98761735e-03f, -1.41839743e-01f, -4.92150113e-02f, 1.17891729e-01f, -8.11818466e-02f, 3.17796990e-02f,
  6.82919174e-02f, 3.05562047e-04f, 1.77388825e-02f, 1.49367213e-01f, 8.48762095e-02f, 2.11843729e-01f, 4.00580876e-02f, -1.49261244e-02f, -6.72774240e-02f, -3.83949988e-02f,
  2.18948331e-02f, 4.29321043e-02f, 1.14901513e-01f, 1.73822436e-02f, -6.18571378e-02f, -1.12454705e-01f, -1.70448214e-01f, 7.49722943e-02f, 5.18390387e-02f, -1.10171624e-01f,
  -3.47280949e-02f, -1.61115751e-01f, 4.70159799e-02f, -1.41573520e-02f, -6.84130490e-02f, 1.08075909e-01f, 6.69171438e-02f, 7.61517510e-02f, -1.87993303e-01f, 7.82440752e-02f,
  5.71147911e-02f, -1.15103438e-01f, -1.42366618e-01f, -9.80024785e-02f, 1.68145642e-01f, -1.07073888e-01f, -4.84423786e-02f, 4.87445109e-02f, -2.21973211e-01f, 1.19745016e-01f,
  6.97091669e-02f, -4.86857332e-02f, 1.32609814e-01f, -1.57539248e-01f, 1.21118650e-02f, -1.39501125e-01f, 7.45404586e-02f, -8.60247836e-02f, -9.53342095e-02f, 1.31754130e-01f,
  3.12887058e-02f, -4.23634797e-02f, -5.62975742e-02f, -1.06106982e-01f, 1.61902040e-01f, -1.37682790e-02f, 1.66477188e-01f, 1.14602283e-01f, -1.65039226e-01f, 1.07154928e-01f,
  1.52267233e-01f, 4.96442318e-02f, 4.66436073e-02f, 5.51467761e-02f, 1.56773832e-02f, 1.14204220e-01f, -5.33354655e-03f, -1.48246959e-02f, -1.34499878e-01f, -8.10547359e-03f,
  -1.47267938e-01f, -9.28987041e-02f, 2.55020466e-02f, -4.58752997e-02f, 3.04134898e-02f, -8.96880403e-03f, -1.51319914e-02f, -1.63067821e-02f, -1.25432879e-01f, -1.21362559e-01f,
  -3.88583206e-02f, -1.15357921e-01f, 7.38030449e-02f, 1.16017357e-01f, 1.00496866e-01f, 1.61280140e-01f, -2.73126997e-02f, 1.30289927e-01f, -4.68793027e-02f, -3.68657708e-02f,
  1.62424624e-01f, -3.57840098e-02f, 1.67623416e-01f, -1.79351091e-01f, 3.66907716e-02f, 1.15951575e-01f, -8.81625265e-02f, -8.68307948e-02f, -1.86233856e-02f, 2.75276482e-01f,
  -3.74600329e-02f, -1.60719424e-01f, 1.62358090e-01f, -7.08207488e-02f, -1.75842106e-01f, -7.03947693e-02f, 1.07582234e-01f, 1.47752851e-01f, 9.02210549e-02f, 7.96463862e-02f,
  -4.66803126e-02f, 2.15086788e-02f, -7.57620111e-02f, -1.87808126e-02f, -5.02522923e-02f, 9.11528990e-02f, -3.83871607e-02f, 9.33770835e-02f, 6.71046525e-02f, -6.71276450e-02f,
  -3.87008823e-02f, 3.21515128e-02f, 9.26580131e-02f, -1.97102755e-01f, -8.70912820e-02f, -7.91749135e-02f, -3.00485659e-02f, -5.06826974e-02f, -6.22310825e-02f, 2.55461503e-02f,
  -1.50976583e-01f, 5.05816657e-03f, -1.29417896e-01f, 1.65120184e-01f, 9.86967608e-02f, -1.35144517e-01f, 7.10543804e-03f, 1.01826660e-01f, -1.39813140e-01f, 1.65175926e-02f,
  -9.14191245e-04f, -1.76525619e-02f, 1.15693301e-01f, 4.59319428e-02f, -7.44182244e-02f, 1.59967214e-01f, 1.72414593e-02f, 1.09263971e-01f, 1.60514582e-02f, 1.53419703e-01f,
  -8.06450248e-02f, -1.73431039e-01f, 5.84595315e-02f, 3.59128900e-02f, -1.44956522e-02f, -2.12915674e-01f, 1.91888794e-01f, -9.67485383e-02f, -1.91504091e-01f, 1.66051313e-01f,
  -3.65461782e-02f, -1.09833814e-01f, 5.87212555e-02f, -1.99434698e-01f, 1.32596552e-01f, 8.13748538e-02f, -1.58073664e-01f, 9.26600397e-02f, 6.32989826e-03f, -7.20512718e-02f,
  5.90452403e-02f, -2.43184734e-02f, 3.80206555e-02f, 1.88756119e-02f, -6.32167757e-02f, 1.02389216e-01f, 8.82774219e-02f, 2.00688038e-02f, -2.84618195e-02f, 5.12253419e-02f,
  8.56145471e-02f, -1.09719606e-02f, -1.64639354e-01f, -1.34649843e-01f, 1.34651661e-01f, -4.32995893e-02f, -1.89339548e-01f, 1.35934576e-01f, 4.56898659e-02f, -8.94746408e-02f,
  5.80617115e-02f, -8.33228603e-02f, -7.37241581e-02f, 2.42702160e-02f, 2.73197182e-02f, -6.89447746e-02f, 2.57758778e-02f, -1.03706859e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.11442581e-01f, 4.01343824e-03f, 7.83790797e-02f, 2.29008853e-01f, -4.15557437e-02f, 6.31879270e-02f, 9.76288766e-02f, 7.10479468e-02f, -3.32985036e-02f, 1.33619875e-01f,
  1.83570594e-01f, 1.71831250e-01f, 4.43115048e-02f, -7.09833726e-02f, 1.39646679e-01f, 4.39778455e-02f, -6.07780851e-02f, -8.51594433e-02f, -3.72883976e-02f, -6.62947819e-02f,
  -4.50314730e-02f, 1.75071545e-02f, -1.28096193e-02f, 1.25944793e-01f, 8.97230208e-02f, -8.79888982e-02f, 1.47916064e-01f, 1.44125400e-02f, -1.46931499e-01f, 1.22001551e-01f,
  -1.79594364e-02f, -7.45960250e-02f, 1.35234922e-01f, -9.06393528e-02f, 1.89853549e-01f, 9.13330987e-02f, 5.23641631e-02f, -1.83449522e-01f, -8.37650374e-02f, -1.71245098e-01f,
  -3.60750519e-02f, -1.13803305e-01f, -1.08498588e-01f, -7.81644955e-02f, -1.53448388e-01f, 5.83541803e-02f, -8.70550796e-03f, -6.30024523e-02f, 1.81592062e-01f, 5.90607785e-02f,
  1.29016861e-01f, 9.00103301e-02f, 1.14573382e-01f, 6.21145666e-02f, 2.50445399e-03f, -1.35056078e-01f, 3.25227678e-02f, 1.40896678e-01f, -6.20721057e-02f, -1.00331649e-01f,
  -1.73152402e-01f, -4.94005866e-02f, 8.51575881e-02f, 1.78660125e-01f, 1.93390712e-01f, -9.13345218e-02f, 1.06829427e-01f, 1.21678844e-01f, 5.19708917e-03f, 2.63935588e-02f,
  -6.53184876e-02f, 4.21482995e-02f, 1.13391533e-01f, 1.89603761e-01f, 6.88000098e-02f, -2.21843664e-02f, 4.06362191e-02f, -2.56653756e-01f, 2.63378590e-01f, 1.74017295e-01f,
  -1.21018663e-01f, -1.14582308e-01f, -5.64581379e-02f, 4.96664122e-02f, 5.80055118e-02f, 4.94921431e-02f, 2.34308079e-01f, -6.89749024e-04f, 1.49420276e-01f, -4.22261050e-03f,
  9.63813663e-02f, -1.36999235e-01f, 1.75162759e-02f, 7.97204375e-02f, -1.32919624e-01f, 7.71197975e-02f, 2.35983387e-01f, 1.50493115e-01f, 5.36372811e-02f, 1.26770973e-01f,
  6.54627290e-03f, -5.28084561e-02f, 1.89191215e-02f, 1.44539654e-01f, 2.43990961e-02f, 7.65349790e-02f, 6.17836192e-02f, -2.99618691e-02f, 8.22172463e-02f, 2.83424854e-01f,
  -3.13377902e-02f, 2.34651975e-02f, -1.02156393e-01f, -4.20884490e-02f, -2.60858461e-02f, 1.47931084e-01f, 5.35168089e-02f, -2.80908365e-02f, -1.02958381e-01f, 7.76548609e-02f,
  5.52014001e-02f, 9.34945717e-02f, 7.75660425e-02f, -8.30244049e-02f, -7.72261024e-02f, 1.67907640e-01f, 1.39001563e-01f, 7.05473050e-02f, 3.04566592e-01f, 3.78768556e-02f,
  2.40042359e-02f, 1.73614800e-01f, -4.06834036e-02f, 9.74789783e-02f, 1.81435004e-01f, 1.28117204e-01f, 1.75426915e-01f, 2.25643769e-01f, 9.17018205e-02f, 3.55372429e-01f,
  -1.35625213e-01f, 2.82248527e-01f, -2.61941135e-01f, 3.12070727e-01f, 7.75855556e-02f, -2.07818955e-01f, 1.76724121e-01f, -1.53127357e-01f, -2.88069874e-01f, -9.22631994e-02f,
  2.99156755e-01f, -1.34169772e-01f, -6.35742992e-02f, -5.43348566e-02f, 1.86789632e-01f, -1.12188019e-01f, 1.15581580e-01f, -8.33517313e-02f, -3.17642950e-02f, 7.15905949e-02f,
  -1.61050886e-01f, -9.82237458e-02f, -1.33415759e-01f, 5.89115359e-02f, 5.01568168e-02f, -9.17883366e-02f, 1.75963432e-01f, -1.96943983e-01f, -2.23038569e-02f, -1.29459158e-01f,
  1.41150102e-01f, -1.06833376e-01f, 3.04979563e-01f, 5.89351431e-02f, 3.14950645e-01f, -1.11458547e-01f, -7.43213762e-03f, -2.91191116e-02f, -1.03486262e-01f, 1.13380358e-01f,
  1.61324203e-01f, 6.64424896e-02f, 5.18350042e-02f, -6.19262829e-02f, 6.87569976e-02f, -3.05592138e-02f, -1.92599222e-01f, 1.43905524e-02f, 1.45569611e-02f, 1.90363869e-01f,
  3.87955308e-01f, 5.38967475e-02f, 1.07353866e-01f, 6.42855000e-03f, 8.22370574e-02f, -5.21732382e-02f, 1.61552325e-01f, -7.53533691e-02f, 1.30700752e-01f, 1.56540483e-01f,
  -5.96964955e-02f, -2.72147171e-02f, 4.12297854e-03f, 1.56219915e-01f, -8.41286778e-02f, -3.25121395e-02f, 1.36287376e-01f, 4.68490869e-02f, -5.62933926e-03f, -2.51322128e-02f,
  -2.05953941e-02f, 6.07651584e-02f, 1.16516471e-01f, -5.94552681e-02f, -4.29060943e-02f, -1.35018229e-01f, 9.18786004e-02f, -8.11778307e-02f, 5.75537607e-02f, -1.11684926e-01f,
  -1.24494970e-01f, 1.04665652e-01f, 8.32529832e-03f, 3.66406590e-02f, 1.19571283e-01f, -7.86544383e-02f, -5.12434654e-02f, -1.75494119e-03f, 7.68054053e-02f, 1.78734139e-01f,
  6.94750473e-02f, 2.21773192e-01f, 1.22208580e-01f, 2.35862229e-02f, -3.83809246e-02f, -1.31118566e-01f, 1.05129369e-01f, 6.37592301e-02f, -8.38108882e-02f, 1.84626337e-02f,
  5.40767573e-02f, 2.08787605e-01f, -4.41971347e-02f, 1.42796189e-01f, 6.98652817e-03f, -1.59013718e-02f, 4.91620600e-02f, 1.39243985e-02f, -1.13929041e-01f, -1.09313704e-01f,
  1.60343368e-02f, -6.66945660e-03f, -9.35699716e-02f, 8.74247849e-02f, -1.41558975e-01f, 1.19074747e-01f, 1.95011660e-01f, -2.17181109e-02f, -7.69527927e-02f, 8.22428986e-02f,
  -1.29696429e-01f, -1.85561012e-02f, 1.76268190e-01f, 7.73153454e-02f, 1.02183841e-01f, 6.32700995e-02f, 4.27300110e-02f, 1.97211742e-01f, 2.13052243e-01f, 2.97613628e-02f,
  -6.15413189e-02f, 1.92535460e-01f, 1.56914756e-01f, -1.93921421e-02f, 7.14307129e-02f, -1.05160065e-02f, -2.70812120e-02f, 1.20250024e-01f, 7.38099888e-02f, -9.85407680e-02f,
  1.69115826e-01f, 6.35318458e-02f, 4.26331349e-02f, 1.16456278e-01f, -5.02480865e-02f, 1.98514074e-01f, -1.00291669e-01f, -6.95233792e-02f, 8.28739032e-02f, -1.74923874e-02f,
  2.85684154e-03f, 5.31794690e-02f, 1.41381755e-01f, -1.41612545e-01f, 9.90126133e-02f, -7.22620264e-02f, -1.35291426e-03f, -9.58765373e-02f, -8.70604068e-03f, -8.50813165e-02f,
  -1.05909230e-02f, 1.47639617e-01f, 2.67479159e-02f, 4.94852625e-02f, 1.71888888e-01f, -1.11119717e-01f, 1.27779037e-01f, 1.64802149e-01f, 6.36723638e-02f, -1.42800629e-01f,
  4.42417786e-02f, 1.07888974e-01f, 1.07474633e-01f, -4.46562702e-03f, -7.13890642e-02f, -1.64281160e-01f, -5.87340444e-02f, 2.61118323e-01f, 2.05550551e-01f, 1.20237939e-01f,
  1.00975983e-01f, -4.65653576e-02f, 1.38975084e-01f, -5.91452122e-02f, 4.99368347e-02f, 8.47531706e-02f, -3.73055488e-02f, 9.01930034e-02f, -2.23468635e-02f, 3.91597487e-03f,
  -4.50573899e-02f, 9.16468054e-02f, 1.66397363e-01f, -1.25166312e-01f, 1.23713270e-01f, -1.10733695e-01f, 1.53407156e-01f, 5.24425060e-02f, -1.30876929e-01f, 6.36192337e-02f,
  2.13658303e-01f, -6.56817704e-02f, 5.18684536e-02f, -5.13729416e-02f, -5.85756712e-02f, 3.57212275e-02f, -1.20993137e-01f, -8.09122771e-02f, 1.35606691e-01f, -1.06270514e-01f,
  6.85748383e-02f, -1.62658647e-01f, 6.02827705e-02f, 9.72830951e-02f, 2.03078091e-01f, 1.27762020e-01f, -2.62941625e-02f, 6.05586618e-02f, -2.62531471e-02f, 1.06931597e-01f,
  4.40332777e-04f, -1.24955982e-01f, 3.23635191e-02f, -1.19224470e-02f, 9.22473054e-03f, 4.70687337e-02f, -1.98370479e-02f, 4.44281809e-02f, 4.90756445e-02f, -7.32902512e-02f,
  9.67024863e-02f, 1.09937087e-01f, 1.14289723e-01f, 7.25081638e-02f, -3.48627195e-02f, 1.84862599e-01f, -1.08445935e-01f, 1.58208594e-01f, 2.09408358e-01f, -5.39435446e-02f,
  4.91850227e-02f, 1.18931174e-01f, -4.78328206e-02f, -2.51327101e-02f, 6.70205578e-02f, 1.30114585e-01f, -4.21552956e-02f, 9.01665539e-02f, 9.94819924e-02f, -8.36642161e-02f,
  1.85885967e-03f, 1.26071915e-01f, 1.10237479e-01f, 7.20034093e-02f, 1.04131266e-01f, 2.15673640e-01f, 1.48917571e-01f, -8.60537738e-02f, 8.60017762e-02f, 5.12025170e-02f,
  -1.61283329e-01f, -5.60291670e-02f, -8.92755613e-02f, -8.60897005e-02f, -4.08791900e-02f, -3.41358148e-02f, 1.48349002e-01f, -1.92180663e-01f, -6.65284470e-02f, -2.55555310e-03f,
  2.29616717e-01f, 8.59160256e-03f, 7.62710422e-02f, 3.15033883e-01f, 1.22285165e-01f, -4.78049032e-02f, -1.98202413e-02f, -6.94833696e-02f, 1.06794655e-01f, 8.23792070e-02f,
  1.74171031e-01f, -6.61193281e-02f, -8.90121236e-02f, -3.76409777e-02f, -1.43969148e-01f, 6.79319398e-03f, -7.08807781e-02f, 7.34914020e-02f, 1.27216786e-01f, 1.21229619e-01f,
  1.07050896e-01f, -2.53880396e-02f, -1.20714277e-01f, -5.83289713e-02f, -7.47011043e-03f, 4.53504026e-02f, 1.58735365e-01f, 6.82772771e-02f, -1.20453514e-01f, 5.34631722e-02f,
  6.67884350e-02f, 1.59930348e-01f, -9.09806564e-02f, 5.96496370e-03f, -1.16342204e-02f, -1.21149585e-01f, 7.98110366e-02f, 1.40010655e-01f, -4.87204231e-02f, 2.27107555e-01f,
  9.90445986e-02f, 1.61742344e-01f, 7.82237425e-02f, 1.84548303e-01f, -3.20983976e-02f, 1.61561266e-01f, 1.65711641e-01f, 8.68847445e-02f, -4.94209938e-02f, 7.66521618e-02f,
  3.18175644e-01f, -5.38622681e-03f, 2.27548890e-02f, -2.45926887e-01f, 7.42844073e-03f, -5.72771356e-02f, -4.98482846e-02f, 7.55818514e-03f, 1.67942733e-01f, 1.68852404e-01f,
  -3.03301215e-01f, -3.58367004e-02f, 2.37018778e-03f, 1.05995014e-01f, 1.03095248e-01f, -6.62531182e-02f, 2.20965222e-01f, 3.74871582e-01f, 1.47871435e-01f, -6.08057305e-02f,
  -1.07199043e-01f, 5.63112982e-02f, 2.74031639e-01f, -2.02246383e-02f, 8.52376819e-02f, -1.76038802e-01f, -1.40342340e-01f, 6.65943399e-02f, -1.06535770e-01f, 5.72057255e-02f,
  -6.82308972e-02f, 9.32201371e-02f, 7.48939067e-02f, 7.26574659e-02f, -5.14330640e-02f, -5.53119145e-02f, 2.49463711e-02f, -3.71614061e-02f, -3.36083621e-02f, -1.34349376e-01f,
  -8.27984810e-02f, -2.04091519e-02f, 1.66245475e-02f, 9.78245027e-03f, 6.47543147e-02f, 2.29019195e-01f, 5.76014183e-02f, 3.82736176e-02f, 6.37143329e-02f, -7.00535905e-03f,
  1.17149346e-01f, -1.37015507e-01f, 2.51974523e-01f, -4.97184023e-02f, 1.19559221e-01f, -4.51813377e-02f, 2.82614768e-01f, 1.73278093e-01f, 9.35746133e-02f, -4.08503488e-02f,
  8.13041702e-02f, 3.04503918e-01f, 2.59079576e-01f, 8.20002928e-02f, 4.04533923e-01f, 1.00123763e-01f, 2.11064205e-01f, -1.02452196e-01f, -3.50862406e-02f, -1.64027855e-01f,
  5.65426759e-02f, 1.30289555e-01f, 4.66411933e-02f, 2.51334570e-02f, 2.03933716e-01f, -2.17483807e-02f, -2.35737756e-01f, 1.45783499e-01f, 1.48924991e-01f, 4.70665656e-03f,
  -1.07643902e-01f, 2.76457723e-02f, 1.00212611e-01f, 8.11944380e-02f, 2.47737661e-01f, 1.05142966e-01f, 4.41789851e-02f, 1.71667546e-01f, -8.89529474e-03f, -2.01696008e-01f,
  3.19092870e-02f, -1.02999628e-01f, -4.30073552e-02f, -9.17022154e-02f, -2.00791195e-01f, 6.57134503e-02f, 1.01104721e-01f, 1.42620169e-02f, -3.65875885e-02f, 1.11106515e-01f,
  8.07212070e-02f, 4.77073307e-04f, 4.28537540e-02f, -8.19651261e-02f, 2.30062589e-01f, -1.79530919e-01f, 1.90067321e-01f, 2.40524579e-02f, 1.08589239e-01f, 2.17359006e-01f,
  1.82252765e-01f, 3.93202454e-02f, 1.36539370e-01f, 2.21553475e-01f, -9.24492851e-02f, -1.01026565e-01f, -4.62089553e-02f, -1.22950161e-02f, -8.89371857e-02f, 1.06110491e-01f,
  1.04398057e-01f, 6.54467046e-02f, 2.87589394e-02f, 4.81844619e-02f, -7.63042569e-02f, 4.34008166e-02f, -1.01705119e-02f, -6.79526255e-02f, 6.40775487e-02f, 1.01605736e-01f,
  3.73310558e-02f, 2.56102383e-02f, -2.23062709e-02f, -1.07831424e-02f, 3.16364989e-02f, -2.13943180e-02f, 1.06271707e-01f, 1.00201048e-01f, -1.05829589e-01f, 3.23376991e-02f,
  -1.27744943e-01f, 2.51464881e-02f, 3.05924695e-02f, 8.17540511e-02f, 2.96645798e-02f, -4.64675166e-02f, -8.12750310e-02f, -6.96378248e-03f, -7.22776055e-02f, 8.91908258e-02f,
  2.18675360e-01f, 9.01005790e-02f, 1.31133780e-01f, -1.61544401e-02f, 2.81921029e-02f, 1.77026284e-03f, -1.33356765e-01f, -1.02613412e-01f, 4.70908023e-02f, -1.31463306e-02f,
  -1.54525731e-02f, -1.91515796e-02f, 4.67306264e-02f, 1.01617388e-02f, 3.22534926e-02f, -1.59905508e-01f, -2.71005370e-02f, -6.19742386e-02f, 7.10484236e-02f, 9.71830357e-03f,
  6.16603717e-03f, -7.38220140e-02f, 4.96912599e-02f, 4.91313972e-02f, 3.21370587e-02f, 8.52933824e-02f, 2.76947841e-02f, 1.34283071e-02f, 8.23912248e-02f, -1.14379190e-01f,
  -3.24517339e-02f, 9.03484784e-03f, 2.99159996e-02f, -5.41110300e-02f, 3.71152256e-03f, -9.22127441e-02f, -5.97028472e-02f, -5.92353893e-03f, 1.37515813e-01f, 7.08631650e-02f,
  -8.86110868e-03f, 7.00270850e-03f, 5.64119630e-02f, -2.32613496e-02f, 8.88632517e-03f, 6.99191540e-02f, 8.21838677e-02f, -3.86268785e-03f, 1.09567925e-01f, 5.19909747e-02f,
  2.69846842e-02f, -6.48958003e-03f, -1.00508593e-01f, 5.97159890e-03f, 1.94593379e-03f, -1.09374084e-01f, 1.00805864e-01f, 3.44806835e-02f, -8.07821155e-02f, -1.19720221e-01f,
  -9.72262174e-02f, 6.61698878e-02f, 1.19639345e-01f, -3.59715126e-03f, 2.01992057e-02f, 9.08162817e-02f, 1.25240326e-01f, 9.69686359e-02f, 9.21257436e-02f, 1.16386404e-02f,
  1.81460776e-03f, 1.19797707e-01f, -7.95868337e-02f, 6.74278066e-02f, -1.21621415e-01f, 1.08969398e-01f, 4.92477529e-02f, 8.23352933e-02f, 5.66086592e-03f, -1.30495861e-01f,
  8.46703816e-03f, 9.97070074e-02f, -9.76091251e-02f, -4.04355265e-02f, 8.43508542e-02f, 1.23659790e-01f, 1.02328308e-01f, -3.41254547e-02f, 1.52720913e-01f, 1.36429891e-01f,
  7.51807243e-02f, 5.60186236e-05f, -1.92946829e-02f, 4.24042977e-02f, 1.05397098e-01f, 1.00127771e-01f, 1.71771720e-02f, 3.97867300e-02f, -5.95594831e-02f, -9.56269912e-03f,
  1.84840769e-01f, 2.20837131e-01f, -8.62838700e-04f, 2.84299906e-02f, 4.24782224e-02f, -1.88740134e-01f, -5.49682751e-02f, 1.50711954e-01f, -2.20516875e-01f, -3.13960731e-01f,
  3.10233682e-01f, -3.72307487e-02f, -2.20177136e-02f, -2.18708798e-01f, -2.76004226e-04f, 1.75560847e-01f, -2.15230182e-01f, 1.51633350e-02f, -7.17971027e-02f, -8.33567753e-02f,
  -9.44532976e-02f, -4.47024591e-03f, -6.04456104e-02f, 3.45212936e-01f, 3.49183418e-02f, -3.17212082e-02f, -1.17748834e-01f, 1.79243833e-01f, 3.55428364e-03f, 1.32203922e-02f,
  6.59129322e-02f, 2.29594931e-01f, -6.36801273e-02f, 2.22573187e-02f, -9.24746394e-02f, 1.10479891e-01f, 1.19123631e-03f, -1.19576687e-02f, 3.71485241e-02f, 1.50805667e-01f,
  2.11885944e-01f, 8.67279712e-03f, 1.09695286e-01f, 4.31710156e-04f, 1.24860406e-01f, 6.13829829e-02f, 7.28462413e-02f, -1.63330466e-01f, 3.66945177e-01f, 2.74848342e-01f,
  -9.61147845e-02f, 3.61552760e-02f, 2.52179533e-01f, 1.43496722e-01f, 3.60189080e-01f, -6.67877272e-02f, 2.11710244e-01f, 1.88650787e-01f, 4.99114245e-02f, -2.92907488e-02f,
  -1.03247978e-01f, -1.09986134e-01f, -3.25248539e-02f, -1.24043263e-02f, 4.86292876e-02f, 2.83099301e-02f, -1.04722872e-01f, -1.14088982e-01f, -7.72099346e-02f, -4.69058566e-02f,
  6.61373809e-02f, 6.60119904e-03f, 4.19349372e-02f, -4.69184071e-02f, 1.32144302e-01f, 8.98944214e-02f, -3.94689813e-02f, -8.58071297e-02f, 1.77381560e-02f, 1.16401918e-01f,
  -7.61481076e-02f, -1.18870132e-01f, -1.15257129e-02f, -1.23626277e-01f, -5.56205958e-02f, -2.22526025e-02f, 6.43803105e-02f, -1.31777879e-02f, -6.95900843e-02f, 3.52139398e-02f,
  -1.64951757e-02f, -1.70988515e-02f, -8.21463764e-03f, 3.15870084e-02f, -3.69546264e-02f, -5.57489097e-02f, -4.49579582e-02f, -8.13922007e-03f, -9.51362923e-02f, -7.75853246e-02f,
  2.87358575e-02f, 4.61491942e-02f, 4.98773865e-02f, -1.23639174e-01f, -5.93689047e-02f, -1.49525786e-02f, -7.09613934e-02f, -1.18197642e-01f, 5.93568236e-02f, 8.84978995e-02f,
  1.13653697e-01f, -2.71746540e-03f, 1.00666925e-01f, -9.24941450e-02f, 1.13716431e-01f, -1.25785828e-01f, -5.33402190e-02f, 5.61546236e-02f, 1.19752191e-01f, -2.05798075e-03f,
  6.87094703e-02f, -5.54678813e-02f, 2.47849241e-01f, 1.57711357e-01f, 1.74898177e-01f, -8.21159557e-02f, 2.01873183e-01f, 7.20668444e-03f, 1.02638423e-01f, -6.93535060e-03f,
  -4.01327573e-02f, 1.07115813e-01f, 4.36252244e-02f, 9.63951498e-02f, 2.43781075e-01f, -5.45545518e-02f, -2.04459637e-01f, -2.26709604e-01f, 2.39676535e-01f, -2.35932603e-01f,
  6.19526356e-02f, 6.19983710e-02f, -2.72372335e-01f, 2.81107813e-01f, -5.49947917e-02f, 1.41610831e-01f, 1.23589747e-01f, 1.78582519e-01f, -4.47455049e-02f, 1.73073858e-01f,
  -1.77143104e-02f, -2.29460761e-01f, 4.32912931e-02f, 9.60822329e-02f, -4.18113619e-02f, 4.51245606e-02f, 1.13462143e-01f, 2.53325284e-01f, 1.34697594e-02f, -1.55351922e-01f,
  7.67546967e-02f, -6.29975125e-02f, -3.19332182e-02f, -7.52699748e-02f, -8.84446278e-02f, 1.83140323e-01f, 2.07543924e-01f, -4.29745354e-02f, 2.82051831e-01f, -1.23040818e-01f,
  2.31019706e-01f, 1.07327275e-01f, -3.80315743e-02f, -7.90558904e-02f, 2.68466890e-01f, 1.70697048e-01f, 9.01421979e-02f, 2.50237361e-02f, 1.39670059e-01f, 1.14333984e-02f,
  5.95617369e-02f, 8.13233182e-02f, 3.61175954e-01f, 2.42037877e-01f, 4.74488037e-03f, 4.38573062e-02f, -7.97478631e-02f, 1.34618655e-01f, -7.65149444e-02f, -2.46239137e-02f,
  6.03264831e-02f, 8.11364949e-02f, 2.48996876e-02f, -7.50403628e-02f, -9.79153961e-02f, -1.19047463e-01f, -4.26728576e-02f, 6.61097420e-03f, 7.73339644e-02f, -1.18776828e-01f,
  7.04539120e-02f, -5.00414260e-02f, 7.42361173e-02f, -9.81421322e-02f, 9.71578583e-02f, 3.37568335e-02f, 2.52622757e-02f, -5.52705163e-03f, 3.69736552e-03f, -1.35821611e-01f,
  -5.69251105e-02f, -3.56238186e-02f, -8.67274776e-02f, -1.08570419e-01f, -1.21304698e-01f, 1.65000781e-01f, -9.53277275e-02f, -8.47372189e-02f, -9.00711343e-02f, 1.26934901e-01f,
  -6.60593882e-02f, 6.63069338e-02f, -6.67887777e-02f, 9.80060548e-02f, -1.08078733e-01f, -3.19370851e-02f, 1.23608388e-01f, -7.64486194e-02f, 2.50743739e-02f, 4.26832698e-02f,
  3.94597389e-02f, 9.64292139e-02f, -9.22427177e-02f, -4.17411420e-03f, -6.33331761e-02f, -4.19406593e-02f, -4.21064794e-02f, 1.80748366e-02f, 6.58068582e-02f, 1.20472550e-01f,
  7.61833638e-02f, 1.46866783e-01f, 1.03070639e-01f, -1.78180728e-02f, -7.28313774e-02f, -2.58754976e-02f, -6.03363551e-02f, -1.07058465e-01f, -9.23226774e-02f, 1.33046597e-01f,
  -3.39285769e-02f, -8.54109451e-02f, 1.66403577e-02f, -9.00464803e-02f, -7.85920545e-02f, -6.02713563e-02f, 6.42329641e-03f, 1.28320456e-01f, 4.89572585e-02f, 3.57008656e-03f,
  -6.73176646e-02f, 5.97011745e-02f, -1.72877461e-01f, -2.08603218e-01f, 9.09855217e-02f, -7.18455538e-02f, -7.35585690e-02f, -1.45999510e-02f, -9.04360563e-02f, -7.18935803e-02f,
  -7.73862824e-02f, -1.26590967e-01f, -1.04425378e-01f, -3.03227338e-03f, 2.40816355e-01f, -4.60774004e-02f, -5.71136437e-02f, -1.02826126e-01f, -6.80239648e-02f, 4.45954613e-02f,
  -1.56960711e-01f, 1.24610700e-01f, 9.43183377e-02f, 1.02075391e-01f, -2.78777275e-02f, 5.04604317e-02f, 4.14716080e-02f, 1.05162881e-01f, -5.39154820e-02f, 2.46478990e-01f,
  2.18106627e-01f, 8.29895362e-02f, -4.33241129e-02f, 5.80731593e-03f, 2.59760842e-02f, 2.14667559e-01f, 8.46123789e-03f, -5.11336047e-03f, 1.85240149e-01f, 1.09779924e-01f,
  1.33049905e-01f, 1.82213858e-01f, -4.79910225e-02f, -3.55794057e-02f, 1.15858376e-01f, 1.38749152e-01f, -8.13966210e-04f, -9.31779295e-02f, 5.75488061e-02f, 8.81963875e-03f,
  -6.66254535e-02f, -1.26050562e-01f, 9.63629186e-02f, 3.35690640e-02f, -2.64099557e-02f, 6.37496188e-02f, -2.16598120e-02f, 1.71983242e-02f, 9.43648815e-02f, -3.82843129e-02f,
  -4.37013851e-03f, -5.95991835e-02f, -2.92767603e-02f, -4.06020358e-02f, 7.53296986e-02f, -6.53674528e-02f, 1.19264126e-01f, -1.18967339e-01f, 1.77522957e-01f, 7.60284998e-03f,
  -8.20680186e-02f, 4.77432162e-02f, -5.71757481e-02f, -3.69045250e-02f, -7.15882098e-03f, -1.01357371e-01f, -1.05783269e-02f, 5.79275526e-02f, 8.93353596e-02f, 1.08381845e-01f,
  1.32492378e-01f, 4.50429320e-02f, 1.04220681e-01f, -2.28128079e-02f, 6.02587461e-02f, 9.81513336e-02f, 1.49550308e-02f, 2.71436404e-02f, 3.84627804e-02f, 1.10248320e-01f,
  1.20784178e-01f, -1.17658034e-01f, 1.21930182e-01f, -1.10727079e-01f, -9.35472846e-02f, -5.31011075e-03f, 1.55450664e-02f, 1.19745828e-01f, 1.14344053e-01f, 4.41352986e-02f,
  -2.02174298e-02f, -6.63301572e-02f, -7.29893297e-02f, 8.31170231e-02f, 7.52344653e-02f, -3.52233760e-02f, -1.64996274e-02f, 6.20948225e-02f, 1.57458726e-02f, -2.34467518e-02f,
  9.32337865e-02f, 1.93532500e-02f, -1.13939969e-02f, -4.56310436e-02f, -9.50250104e-02f, -8.64340737e-02f, -3.32525074e-02f, -7.61952028e-02f, 1.30367324e-01f, 8.37374106e-03f,
  2.00435147e-01f, 1.24932796e-01f, 1.91537857e-01f, 1.53813273e-01f, 7.61031881e-02f, 2.08854690e-01f, 6.36933669e-02f, 3.12434603e-02f, -4.11609598e-02f, 1.76741302e-01f,
  -2.20931128e-01f, 8.71011913e-02f, -6.40529096e-02f, 7.93544278e-02f, -1.02604041e-02f, 8.87140408e-02f, 1.12654552e-01f, -1.73869729e-02f, -2.78162748e-01f, 1.43191069e-01f,
  -2.75336336e-02f, 2.37634420e-01f, 2.45771527e-01f, -4.06155102e-02f, -1.47751287e-01f, 9.77326930e-02f, 3.17094848e-03f, -1.85799852e-01f, -8.92401114e-03f, 1.27147183e-01f,
  4.63789217e-02f, -1.24601863e-01f, -1.03500292e-01f, 8.20263103e-02f, -3.16707157e-02f, 6.82753548e-02f, -8.96240994e-02f, 9.66875032e-02f, 5.38009927e-02f, -6.94045424e-02f,
  2.02385321e-01f, -1.64608890e-03f, -1.45045295e-01f, -9.31907520e-02f, -1.81839705e-01f, 1.55270770e-01f, 1.52945012e-01f, 9.07105207e-02f, -3.22671942e-02f, -3.41970427e-03f,
  7.01640248e-02f, -4.79591675e-02f, -7.65539035e-02f, 3.39500420e-02f, -1.86263040e-01f, 2.76408214e-02f, 4.90133315e-02f, 9.93145704e-02f, -3.92563380e-02f, 1.10958248e-01f,
  2.78235339e-02f, -5.26218452e-02f, 2.33646080e-01f, 1.39379263e-01f, 1.42697886e-01f, 2.13637531e-01f, 1.20482750e-01f, 6.02095090e-02f, 1.10247478e-01f, 1.53076202e-01f,
  2.25620478e-01f, 1.09098412e-01f, 1.17482342e-01f, 6.33038878e-02f, 1.34386495e-01f, -2.54431635e-01f, -3.44966315e-02f, -3.23319823e-01f, -7.05809221e-02f, -1.54920891e-01f,
  1.69456199e-01f, -9.52475667e-02f, -1.77208379e-01f, 2.07128257e-01f, -2.94712216e-01f, 1.64726004e-01f, 2.28189677e-01f, 2.08377317e-02f, 2.06002221e-01f, 1.18498005e-01f,
  -1.87226936e-01f, 2.46242151e-01f, 4.97807600e-02f, 7.82751665e-02f, 2.86174081e-02f, 7.89689869e-02f, -1.41412750e-01f, 1.22739531e-01f, -4.74280789e-02f, -1.24888249e-01f,
  -1.04242072e-01f, -9.70774442e-02f, 1.67102218e-01f, 8.50805864e-02f, -2.99221948e-02f, 7.52623305e-02f, -1.45416722e-01f, 1.26308113e-01f, -2.49474168e-01f, 3.16395075e-03f,
  3.69993716e-01f, 3.76061611e-02f, 4.18529101e-02f, 1.38240665e-01f, -1.11227214e-01f, -5.69598787e-02f, 6.79299980e-02f, -3.08196689e-03f, -1.56397194e-01f, 2.77366787e-01f,
  -1.07733205e-01f, -3.49346474e-02f, 8.47068727e-02f, -2.28370637e-01f, 6.55349270e-02f, -3.78924236e-02f, 2.94059813e-01f, -8.70117769e-02f, 9.27468389e-02f, 1.75828576e-01f,
  5.13146631e-02f, 1.12490050e-01f, 9.53741595e-02f, 3.87793668e-02f, 1.74595490e-01f, 1.23359814e-01f, 2.22486705e-01f, 7.21007735e-02f, 1.23921826e-01f, -2.20262438e-01f,
  1.29567042e-01f, 2.03419566e-01f, -1.70888230e-01f, 7.99593031e-02f, 8.57817233e-02f, 1.51041791e-01f, -6.48394451e-02f, 1.86280578e-01f, 1.82252869e-01f, 7.35353529e-02f,
  1.64968178e-01f, -1.01906747e-01f, 2.54003316e-01f, 7.80850574e-02f, -1.18706077e-01f, -1.27743125e-01f, -1.21979713e-01f, 5.92989214e-02f, 1.62610605e-01f, -1.16064273e-01f,
  -2.61673518e-02f, 1.91181198e-01f, -2.82494118e-03f, -1.15882993e-01f, -4.58080880e-02f, -3.11264638e-02f, -5.34515679e-02f, -6.34647384e-02f, -3.58781666e-02f, -7.24372221e-03f,
  -1.64513901e-01f, 1.87649623e-01f, -7.35484511e-02f, 4.20171618e-02f, 1.60820752e-01f, -4.22576889e-02f, -9.59090963e-02f, 2.21174583e-01f, -1.38500780e-02f, 1.65592823e-02f,
  -3.04531772e-02f, 6.23538606e-02f, 5.06171137e-02f, 2.67768085e-01f, -2.94775274e-02f, 2.91350093e-02f, 2.08251681e-02f, 2.13076193e-02f, -1.08771794e-01f, 1.42781779e-01f,
  2.92092711e-02f, 9.51190591e-02f, -2.48448830e-02f, 6.10222705e-02f, 1.20313816e-01f, -1.03506707e-01f, -7.26296613e-03f, 1.47364661e-01f, -2.56779492e-02f, 2.91022044e-02f,
  -3.62207331e-02f, -5.25248386e-02f, -6.73804134e-02f, 1.83228970e-01f, -3.72475013e-02f, -2.73592565e-02f, 1.42329156e-01f, -1.13277882e-01f, -5.27077056e-02f, -1.97081473e-02f,
  -1.64295547e-02f, -7.44130313e-02f, 5.28762601e-02f, -8.22312851e-03f, -7.83806592e-02f, 2.24632602e-02f, 1.31484233e-02f, -2.86442433e-02f, 2.20785420e-02f, -4.66463231e-02f,
  8.50433204e-03f, 1.72589291e-02f, -6.20376132e-02f, 5.41929603e-02f, -1.85393877e-02f, 9.52102467e-02f, 1.41204685e-01f, 3.61105651e-02f, -6.35716766e-02f, -1.37513340e-01f,
  -1.52881414e-01f, 3.52943763e-02f, 6.12677634e-02f, 4.47277762e-02f, 2.63104409e-01f, 5.84541820e-03f, 3.42133284e-01f, -1.65709928e-01f, -2.48437952e-02f, -2.50751413e-02f,
  2.30233911e-02f, -1.01091154e-01f, -6.25320226e-02f, 1.27077401e-01f, 1.07384354e-01f, 1.36723844e-02f, 1.77196994e-01f, -5.67127354e-02f, 1.41376376e-01f, 7.03177601e-02f,
  1.96663454e-01f, -6.15872145e-02f, 1.00204326e-01f, 1.20542198e-01f, 8.49779323e-02f, 1.10338047e-01f, 2.02185690e-01f, 7.70732462e-02f, 1.99308559e-01f, -7.12275133e-02f,
  1.91317961e-01f, 5.58725521e-02f, -3.82074155e-02f, -3.05936225e-02f, 1.92311645e-01f, 3.22018974e-02f, -2.47503519e-02f, 2.47459173e-01f, -2.72696763e-01f, -3.08973402e-01f,
  -9.25729796e-03f, 1.11997187e-01f, 2.43313033e-02f, -3.03709120e-01f, -1.09967209e-01f, -8.20011124e-02f, -9.62771252e-02f, -9.39026996e-02f, -2.03740329e-01f, 1.94294244e-01f,
  8.72858018e-02f, 9.10904482e-02f, 3.84386554e-02f, 4.85481948e-01f, 7.46964440e-02f, 1.88858092e-01f, -5.31068556e-02f, -3.51012610e-02f, -1.20296910e-01f, -7.39496648e-02f,
  1.39617354e-01f, 1.96139738e-01f, -2.88962796e-02f, -1.18936665e-01f, -4.05860692e-03f, 1.64565355e-01f, -1.24594510e-01f, 1.67143121e-01f, 8.52784887e-02f, 1.41687632e-01f,
  1.85553562e-02f, -5.70532009e-02f, 1.28715590e-01f, 7.70597532e-02f, 1.03638299e-01f, 1.00015052e-01f, -1.18482783e-01f, 1.36780843e-01f, 2.46339981e-02f, 1.60153463e-01f,
  1.01131216e-01f, 9.55787674e-02f, 1.70757934e-01f, 9.48951021e-02f, 8.23834240e-02f, -4.82555702e-02f, 9.22126696e-03f, 8.89892206e-02f, 1.32693768e-01f, 7.76709542e-02f,
  -2.97226347e-02f, -1.96810067e-02f, 8.85220841e-02f, -1.48652449e-01f, 3.33392583e-02f, -7.21594915e-02f, 3.35072540e-02f, 2.54280139e-02f, 5.96155599e-02f, -4.36459817e-02f,
  -1.52667761e-01f, -6.56334534e-02f, -7.19822124e-02f, 7.70545825e-02f, -6.52458668e-02f, -7.83132669e-03f, -1.48574203e-01f, -8.58224109e-02f, -7.12490231e-02f, -1.46570355e-01f,
  -6.89233560e-03f, -1.37411013e-01f, 8.18226263e-02f, 8.18409547e-02f, 3.80613171e-02f, 3.34506631e-02f, -3.67898941e-02f, 1.08715437e-01f, 1.02141328e-01f, -3.11466996e-02f,
  -5.64614031e-03f, 3.52333207e-03f, 2.94155497e-02f, -1.56271644e-02f, -6.05195649e-02f, -4.97531220e-02f, -7.55549967e-02f, 3.10261864e-02f, -5.59330322e-02f, -4.54121269e-02f,
  -1.13323189e-01f, -1.29715711e-01f, -1.18071670e-02f, 1.28862873e-01f, 4.54318561e-02f, 1.38070375e-01f, 5.84787726e-02f, -1.20916419e-01f, -6.30385801e-02f, -1.85927525e-02f,
  -7.76678920e-02f, -3.90039594e-03f, -1.35261109e-02f, 1.30557254e-01f, 5.09410203e-02f, 7.20569566e-02f, 7.20353574e-02f, -6.96467049e-03f, 8.77770334e-02f, 1.24656215e-01f,
  1.26845673e-01f, 1.60499111e-01f, -1.28359705e-01f, -2.84607895e-02f, 2.61868685e-02f, -2.66629662e-02f, 1.03429027e-01f, 1.59180880e-01f, 5.67314290e-02f, -3.51553336e-02f,
  -3.16341929e-02f, 2.81996001e-02f, 1.40217662e-01f, -1.77735109e-02f, -1.86609372e-01f, -6.72776997e-02f, -5.99564202e-02f, -5.91755845e-02f, -1.47944972e-01f, 1.50524884e-01f,
  4.00888436e-02f, 4.19766493e-02f, -4.19477262e-02f, -7.75746256e-02f, 1.87398531e-02f, -3.38392928e-02f, -7.38279894e-02f, -5.38120903e-02f, 1.13870345e-01f, -1.24296479e-01f,
  -5.07478304e-02f, 5.59477061e-02f, -9.51632112e-02f, -7.99010396e-02f, 8.04808214e-02f, 6.10332638e-02f, 3.56251821e-02f, 1.94832217e-02f, -1.32477134e-02f, 7.38632977e-02f,
  -2.97885258e-02f, 1.09585673e-01f, 1.48492813e-01f, -6.06216229e-02f, -6.68337569e-02f, -1.40949324e-01f, 1.07451461e-01f, 1.45414621e-01f, -5.19296490e-02f, -2.96206530e-02f,
  -7.39729265e-03f, 1.20648026e-01f, 8.01983923e-02f, -7.64354244e-02f, -1.02292262e-01f, 3.65870595e-02f, 3.48419994e-02f, 6.80893511e-02f, 7.54217654e-02f, -1.15079343e-01f,
  -6.09821156e-02f, -9.98330340e-02f, -8.41342881e-02f, 5.88840246e-03f, 5.21966703e-02f, -4.28508669e-02f, 1.90110564e-01f, 1.35615133e-02f, -3.04978769e-02f, 2.43241135e-02f,
  -1.00143859e-02f, 6.83915913e-02f, 2.29692291e-02f, 1.44944221e-01f, -9.57128033e-02f, -1.47738308e-02f, 1.60299331e-01f, 1.07266411e-01f, -3.24532054e-02f, 1.79741219e-01f,
  -7.63894916e-02f, -2.44099751e-01f, 7.24091306e-02f, -1.55488789e-01f, -6.55683801e-02f, -2.28920132e-01f, -2.28411347e-01f, -6.63036183e-02f, -1.11586571e-01f, -9.82419029e-02f,
  -3.20928916e-02f, 1.93580747e-01f, -1.20170370e-01f, -1.09750517e-02f, 3.82028632e-02f, 3.63503359e-02f, 1.62937179e-01f, 1.82858735e-01f, 2.57512759e-02f, -5.39030097e-02f,
  1.92667112e-01f, 7.74057731e-02f, 1.46850750e-01f, 9.49923173e-02f, -4.59275246e-02f, -2.84710042e-02f, -1.44664139e-01f, 8.82352814e-02f, -1.10211022e-01f, 3.46069001e-02f,
  -1.09318338e-01f, -1.28418177e-01f, -1.64331704e-01f, 2.47330517e-02f, -4.36151810e-02f, 9.12931189e-02f, 1.10293388e-01f, -1.70673206e-01f, -6.49416372e-02f, 1.66270316e-01f,
  2.58966148e-01f, -4.38284874e-02f, 8.97971615e-02f, -3.59465443e-02f, -3.73521373e-02f, 2.36813694e-01f, 1.62367538e-01f, -1.72016904e-01f, 9.68796462e-02f, -1.64622083e-01f,
  7.37767667e-02f, 2.20582813e-01f, 1.93191051e-01f, 7.47989723e-03f, 2.03301728e-01f, 1.28877595e-01f, 1.15260594e-01f, 3.74131501e-02f, 1.92594185e-01f, 8.86673778e-02f,
  -8.97117555e-02f, 1.30872205e-01f, 2.96413869e-01f, -1.25071779e-01f, 2.10911967e-02f, -9.19040367e-02f, 5.29905222e-02f, -1.18292488e-01f, -4.50927205e-02f, 1.43060775e-03f,
  1.58411264e-01f, 1.61082059e-01f, -2.17552975e-01f, 3.08449734e-02f, 1.48536235e-01f, 1.36983141e-01f, -3.18450257e-02f, -4.33211140e-02f, 1.44174740e-01f, -9.68995839e-02f,
  6.99133202e-02f, 1.08021677e-01f, -8.98092911e-02f, -1.44020319e-02f, 2.79354006e-01f, 1.53421968e-01f, -2.06001080e-03f, -1.44362003e-01f, -2.65150946e-02f, -1.31343961e-01f,
  1.07818976e-01f, -1.15065269e-01f, -1.19460024e-01f, 1.29062966e-01f, 4.37809564e-02f, -1.37158811e-01f, -1.19571820e-01f, -1.36778623e-01f, 1.78641617e-01f, -2.30512805e-02f,
  1.50413051e-01f, 4.74069417e-02f, 1.12152308e-01f, 1.99548900e-02f, -9.01704654e-02f, 1.07478991e-01f, -1.43939316e-01f, 5.89595623e-02f, -7.48504028e-02f, 4.14087437e-02f,
  1.24350667e-01f, 3.99418585e-02f, -1.52294308e-01f, 7.32752308e-02f, 1.13640256e-01f, 7.23160952e-02f, -1.24550965e-02f, -1.47269722e-02f, 1.16880879e-01f, 8.80230069e-02f,
  1.53952584e-01f, 1.40468359e-01f, 9.68687236e-02f, 3.39977406e-02f, 2.19031647e-01f, -1.04313977e-01f, -7.06105977e-02f, 7.23985508e-02f, -1.00454956e-01f, -4.80493158e-02f,
  1.40677884e-01f, 1.37483552e-01f, -7.34000728e-02f, -8.96721780e-02f, 5.02176732e-02f, -1.25017866e-01f, 8.93315747e-02f, 2.03012630e-01f, -4.41583619e-02f, 2.11136974e-02f,
  -6.25767037e-02f, 1.04106583e-01f, 7.88056701e-02f, -1.36066481e-01f, -1.73368566e-02f, 3.38789150e-02f, -1.36968926e-01f, 1.44722000e-01f, -3.29571962e-02f, -1.38692096e-01f,
  -9.57697183e-02f, 1.81668296e-01f, 1.29514739e-01f, -7.23747313e-02f, 4.24598828e-02f, 4.27388586e-02f, 9.82378647e-02f, -1.53165625e-03f, 4.61832806e-03f, -3.73286679e-02f,
  1.49918884e-01f, 3.99135873e-02f, 8.38591624e-03f, -7.74049237e-02f, -3.63369212e-02f, -9.03393179e-02f, -1.33778065e-01f, 1.57017931e-01f, 3.33404094e-02f, 1.39826357e-01f,
  -5.81809767e-02f, -5.57113625e-02f, 9.20702294e-02f, -3.17674130e-02f, 1.30034447e-01f, 5.13621457e-02f, 1.59918651e-01f, -5.42980731e-02f, 9.82983187e-02f, 1.39762416e-01f,
  6.95438087e-02f, 1.76595405e-01f, 1.06069386e-01f, 4.91710678e-02f, 2.93800980e-03f, 5.03752381e-02f, 9.11068842e-02f, 7.23095611e-02f, 2.01664031e-01f, 1.62381172e-01f,
  2.35357910e-01f, -1.67288229e-01f, 2.34592140e-01f, -1.84648901e-01f, -1.20256938e-01f, 6.48177713e-02f, -1.71382040e-01f, 9.14678648e-02f, 3.20435315e-01f, 8.80416390e-03f,
  -2.79639401e-02f, -4.38596644e-02f, -1.00062102e-01f, 4.76388633e-02f, -1.56079428e-02f, 1.33119568e-01f, 1.38499707e-01f, 1.45871922e-01f, -1.89569946e-02f, -1.74756542e-01f,
  1.13628712e-02f, 1.50399536e-01f, 2.94821948e-01f, -1.12903034e-02f, 1.53800070e-01f, -1.06687574e-02f, -1.10890619e-01f, 3.02367788e-02f, -4.36805710e-02f, -7.09542856e-02f,
  2.55767070e-02f, 1.82208255e-01f, 1.88717723e-01f, 8.47130865e-02f, 2.10450917e-01f, -1.36449113e-01f, -4.00253630e-04f, -2.25167036e-01f, 2.24201065e-02f, 9.95580107e-02f,
  -6.51434660e-02f, 1.61453918e-01f, 3.75308581e-02f, 7.18762726e-02f, 2.61834525e-02f, 2.09969699e-01f, 2.90342927e-01f, 4.23149914e-02f, -1.20982662e-01f, 6.14818484e-02f,
  1.80068426e-02f, 1.25886783e-01f, -4.46899161e-02f, 2.51141489e-01f, 1.14645630e-01f, -2.07734555e-02f, 2.68599719e-01f, 1.36706471e-01f, 1.81113288e-01f, 1.07681878e-01f,
  2.05019310e-01f, 2.99026340e-01f, 1.19770013e-01f, 3.53290468e-01f, -6.73164427e-02f, -1.05300300e-01f, 3.13315183e-01f, 2.12472260e-01f, -3.14165443e-01f, 4.73681316e-02f,
  -9.46229175e-02f, 2.56185353e-01f, 2.58120477e-01f, -2.34996691e-01f, -4.89021167e-02f, -1.30570874e-01f, -1.37926683e-01f, 4.65483144e-02f, 2.43626977e-03f, -1.64730310e-01f,
  3.07665855e-01f, 2.38812380e-02f, 2.54645377e-01f, -1.17311135e-01f, 6.01667762e-02f, 1.71723694e-01f, 5.10671914e-01f, 4.15673442e-02f, 1.85395822e-01f, 9.96350050e-02f,
  1.05212390e-01f, 1.95849925e-01f, -4.51151580e-02f, 3.88101302e-02f, -1.59205705e-01f, 2.97399402e-01f, 1.66134551e-01f, -7.37614632e-02f, -4.13918160e-02f, -1.05956525e-01f,
  -1.69787124e-01f, -7.82870874e-03f, 2.47512057e-01f, 4.71990779e-02f, -1.09828152e-02f, 2.03608423e-01f, -1.62706509e-01f, -8.07160288e-02f, 5.86131103e-02f, -2.07644403e-02f,
  1.34940222e-01f, -6.47656918e-02f, -7.22350702e-02f, 1.16138153e-01f, -3.73605117e-02f, -2.84975190e-02f, -3.91176715e-02f, 3.98595855e-02f, 5.36195748e-03f, -7.20103532e-02f,
  3.00213844e-02f, 9.58184004e-02f, -7.01190829e-02f, 1.40472099e-01f, 8.00854787e-02f, -2.17678603e-02f, -6.94429949e-02f, -1.03538811e-01f, 3.32082547e-02f, 1.09148808e-02f,
  4.15872261e-02f, 5.85842654e-02f, 2.02272087e-01f, 4.11259755e-02f, 7.46842250e-02f, -8.64975080e-02f, 2.87910700e-02f, 1.00389190e-01f, -1.25016868e-01f, 4.74837534e-02f,
  3.70797776e-02f, -7.91062564e-02f, -5.21191508e-02f, 3.77858095e-02f, -3.44983973e-02f, -1.11581706e-01f, 3.32864597e-02f, 9.78358462e-02f, 1.08119912e-01f, -1.45724108e-02f,
  1.35759634e-04f, -7.54786506e-02f, 1.68504752e-03f, 1.63816243e-01f, 2.13773381e-02f, 1.22438081e-01f, 5.68611771e-02f, 7.80317262e-02f, 7.96934590e-02f, -5.38943373e-02f,
  1.00845441e-01f, 9.23742801e-02f, -7.97782391e-02f, -6.32643998e-02f, 3.10932081e-02f, -3.85552272e-02f, 5.63833974e-02f, -9.77360085e-02f, -5.60064204e-02f, -6.21729009e-02f,
  2.03040630e-01f, 7.59229809e-02f, -3.98726910e-02f, -1.03835456e-01f, 1.33548194e-04f, 1.67485356e-01f, 1.38724685e-01f, 1.50426686e-01f, 1.95448384e-01f, 8.45808461e-02f,
  1.29445419e-01f, 6.93556964e-02f, 8.36880803e-02f, 2.87905276e-01f, 2.21280769e-01f, 4.18662913e-02f, 2.28209674e-01f, 1.54994726e-01f, 1.02460988e-01f, 7.80839249e-02f,
  1.95328191e-01f, 2.14261919e-01f, -2.36291468e-01f, -1.38910189e-01f, 9.91006847e-04f, -5.43256253e-02f, -1.80940837e-01f, -1.70992643e-01f, -1.65454060e-01f, 3.47244553e-02f,
  -4.41635512e-02f, -1.49484565e-02f, 8.38279575e-02f, 1.65128931e-01f, 2.16832280e-01f, 8.94523934e-02f, 9.30222869e-02f, 1.25367008e-02f, -1.34849370e-01f, -2.23537534e-01f,
  3.23409624e-02f, 1.24854200e-01f, -1.72055349e-01f, -3.70014533e-02f, 1.43125981e-01f, -8.82301629e-02f, -7.92492256e-02f, -9.07295272e-02f, 1.46114171e-01f, 1.17443681e-01f,
  1.45717263e-01f, 5.48060145e-03f, 1.33731648e-01f, 8.01640227e-02f, -2.07322147e-02f, 2.24592444e-02f, -1.99917957e-01f, 1.49247259e-01f, 8.60903859e-02f, 1.33746326e-01f,
  1.23150080e-01f, 1.60799190e-01f, -2.22106442e-01f, 1.62842900e-01f, -4.41624746e-02f, -7.84992501e-02f, -1.36994556e-01f, 1.26661677e-02f, -9.41322297e-02f, -4.21770662e-02f,
  -2.80882251e-02f, -2.35007748e-01f, 4.46681604e-02f, 1.29509568e-02f, 1.52127193e-02f, 1.56777561e-01f, 8.61745179e-02f, 1.77267671e-01f, 1.29703194e-01f, 2.51390666e-01f,
  1.50262147e-01f, -3.87169309e-02f, 1.93907857e-01f, 1.82951629e-01f, 8.85195658e-02f, 2.17356920e-01f, -3.06018908e-03f, 9.55536216e-02f, -4.91678044e-02f, 1.65157527e-01f,
  1.63994908e-01f, 1.24513052e-01f, 1.44713238e-01f, 2.24345028e-01f, 6.77934587e-02f, -6.70197532e-02f, 4.76926118e-02f, 9.51063558e-02f, 3.35478447e-02f, -4.16670330e-02f,
  1.03167370e-01f, 8.28235745e-02f, 1.02814183e-01f, -7.54029080e-02f, -9.74231586e-02f, -9.43943858e-02f, -6.86551407e-02f, -1.04158418e-02f, 5.95260225e-02f, 7.07019027e-03f,
  8.57817084e-02f, -8.45202059e-02f, -1.95462760e-02f, -1.69520646e-01f, -1.41290069e-01f, -1.15356877e-01f, 9.92856920e-02f, 1.63400337e-01f, 2.35832483e-01f, -1.89012706e-01f,
  2.28197262e-01f, 6.07024282e-02f, -1.32461876e-01f, -8.42197910e-02f, -4.58317772e-02f, 7.59134442e-02f, 1.83823392e-01f, 1.50662839e-01f, 1.19670592e-01f, 1.31178603e-01f,
  6.14555553e-02f, 4.10259888e-02f, 1.85000882e-01f, 7.78511390e-02f, -1.19249843e-01f, 2.02417970e-01f, 7.45247304e-02f, -1.67971581e-01f, 5.68278916e-02f, -4.41408642e-02f,
  3.96688804e-02f, 1.00298986e-01f, -6.84618354e-02f, -1.30344719e-01f, -8.57779682e-02f, 7.92436674e-02f, 9.10614952e-02f, -8.21341723e-02f, 1.67664345e-02f, -1.20981205e-02f,
  -7.68148378e-02f, -5.24192378e-02f, 5.84296323e-02f, -8.10856745e-03f, -5.98185658e-02f, 1.55944964e-02f, 6.31866828e-02f, -1.31560162e-01f, 4.02482376e-02f, 1.14483729e-01f,
  -5.17439842e-02f, 1.79347824e-02f, -4.34188880e-02f, 7.02500418e-02f, -2.41434108e-02f, -8.61634091e-02f, 8.58600065e-02f, 4.19665081e-03f, -5.39046861e-02f, -7.08655491e-02f,
  1.32744480e-02f, 9.77331996e-02f, -9.75469649e-02f, 1.10370904e-01f, 7.34817758e-02f, 1.00868955e-01f, 1.39908284e-01f, 1.39553398e-02f, 1.05123438e-01f, 7.86641389e-02f,
  4.95518558e-03f, 1.02548487e-02f, -8.93327072e-02f, -7.58064315e-02f, -5.43315820e-02f, -3.55847701e-02f, 1.50231376e-01f, -1.09733544e-01f, 1.08890014e-03f, -8.94695893e-03f,
  1.10700406e-01f, -9.65209752e-02f, 1.23284400e-01f, 1.00747377e-01f, -1.21243805e-01f, -5.69180883e-02f, 6.80379048e-02f, 3.40909436e-02f, 8.06035101e-02f, -4.84090224e-02f,
  1.25549823e-01f, 1.46022573e-01f, 1.91524103e-01f, 3.28348763e-02f, 1.03254192e-01f, 1.42423317e-01f, 2.04034477e-01f, -6.07084809e-03f, 1.59309544e-02f, 5.70764393e-02f,
  3.15058860e-03f, -5.70927486e-02f, 4.06584255e-02f, 2.42941692e-01f, -1.75695211e-01f, -7.07544759e-02f, -3.25416289e-02f, -1.15522007e-02f, 1.71329286e-02f, 4.82775867e-02f,
  -9.14369300e-02f, -2.65263230e-01f, -1.78107128e-01f, -1.83172718e-01f, -3.40890400e-02f, -1.76213473e-01f, 4.85905856e-02f, -2.10439190e-02f, 1.95096746e-01f, 5.46297505e-02f,
  -2.02894839e-03f, 3.65894198e-01f, 1.81705743e-01f, 1.40221134e-01f, -3.40750813e-02f, -8.52624401e-02f, -9.80365127e-02f, -2.63962522e-02f, -3.37610804e-02f, -4.19402495e-02f,
  6.66220337e-02f, 7.34507516e-02f, -7.30823576e-02f, -3.08804424e-03f, -1.14804907e-02f, 1.65522158e-01f, 1.06435746e-01f, 1.90936238e-01f, 9.37798843e-02f, -9.57784653e-02f,
  1.03327475e-01f, 2.13818792e-02f, 8.21282864e-02f, 3.04515008e-02f, -3.63534465e-02f, 1.34965047e-01f, -1.18610859e-01f, 7.84273967e-02f, 1.78135008e-01f, 1.05430797e-01f,
  3.71877067e-02f, -8.70222226e-02f, -6.75018877e-02f, -1.50455892e-01f, -1.50376484e-01f, 1.38145119e-01f, -1.48905412e-04f, 7.72756636e-02f, 7.15301707e-02f, 5.58589846e-02f,
  8.04308802e-02f, 1.80846125e-01f, -3.24126668e-02f, 7.61321709e-02f, -2.81617194e-02f, -1.48802493e-02f, 1.36650845e-01f, -1.44299209e-01f, -1.28862530e-03f, -1.10242069e-01f,
  1.19487695e-01f, -1.31311774e-01f, 6.92945868e-02f, 2.97311507e-02f, -4.30587716e-02f, 1.53047964e-01f, 1.66360542e-01f, 1.43057615e-01f, 3.33335176e-02f, 8.89398009e-02f,
  8.26294720e-02f, -1.50607988e-01f, 6.21182844e-03f, 1.55522749e-01f, 1.11038767e-01f, -1.02864094e-02f, -1.27247974e-01f, -1.20857581e-01f, 7.17333257e-02f, -5.28362300e-03f,
  -1.59140136e-02f, 4.23224829e-02f, 7.81516880e-02f, -9.70871970e-02f, -1.13691777e-01f, 5.15271276e-02f, -7.50401840e-02f, -8.41342881e-02f, -1.11876363e-02f, -6.97224960e-02f,
  1.00445651e-01f, 4.49534543e-02f, 1.67677224e-01f, 1.60677046e-01f, -8.64533707e-03f, -5.55340275e-02f, -6.27993932e-03f, 1.44564301e-01f, -7.70856515e-02f, -1.28388181e-01f,
  5.70071898e-02f, -3.29344235e-02f, -1.11697532e-01f, 7.60073364e-02f, 1.48915812e-01f, -1.07295081e-01f, 9.58020389e-02f, -5.76021038e-02f, 1.98859852e-02f, 1.66909397e-01f,
  -2.64363494e-02f, 1.15705058e-01f, -1.77543797e-02f, 3.99145596e-02f, -2.86355354e-02f, -9.86886621e-02f, 9.75274742e-02f, -9.56104547e-02f, 9.23761576e-02f, 1.57682195e-01f,
  -9.89980549e-02f, 4.16236930e-03f, 1.84207141e-01f, 5.89195266e-02f, -9.14617777e-02f, 1.24069676e-01f, 4.96100076e-02f, 5.45967929e-02f, 5.80551215e-02f, 9.41720605e-02f,
  -1.01818904e-01f, 3.23988385e-02f, 2.65713893e-02f, -1.27250358e-01f, -1.09891877e-01f, -5.74639402e-02f, 2.39530914e-02f, 1.14006817e-01f, -2.27351133e-02f, 2.08566114e-02f,
  -5.31409048e-02f, -1.10493064e-01f, 1.98763639e-01f, -6.36337623e-02f, -8.52668807e-02f, -3.93767655e-02f, 3.02984435e-02f, 7.00232163e-02f, 3.86422686e-02f, -9.21743214e-02f,
  5.43555878e-02f, 7.98362941e-02f, -7.02211931e-02f, 6.45260587e-02f, 2.85976585e-02f, -2.62523163e-02f, 7.93735981e-02f, 2.86886040e-02f, -6.19225204e-02f, 8.34320672e-03f,
  -3.91028225e-02f, 9.86423790e-02f, 2.44170114e-01f, -1.17541522e-01f, -2.99244486e-02f, 9.22289863e-02f, -5.44666909e-02f, 7.00853989e-02f, 9.29648206e-02f, 4.20348048e-02f,
  8.94294754e-02f, 1.27160534e-01f, 1.35132357e-01f, -2.71155294e-02f, 1.23376757e-01f, 5.66841550e-02f, 1.42353317e-02f, -3.06671318e-02f, 8.55095312e-02f, 1.39902800e-01f,
  -3.29380743e-02f, 7.15952739e-02f, 9.01174471e-02f, 6.69298470e-02f, 1.29501879e-01f, 1.10461272e-01f, -2.99616754e-01f, -1.15708284e-01f, 4.42752279e-02f, -1.41058452e-02f,
  9.87123251e-02f, -6.67940006e-02f, -1.98200375e-01f, -1.29784141e-02f, -1.24482244e-01f, -2.02575505e-01f, 3.58352661e-02f, -8.74241143e-02f, 6.78032190e-02f, -2.90787779e-02f,
  4.43056375e-02f, -8.10018778e-02f, 3.23256962e-02f, -1.09241858e-01f, 2.20183358e-02f, 1.36566371e-01f, 6.51559420e-03f, 2.72209384e-02f, -1.20170049e-01f, -1.25304893e-01f,
  -1.06401026e-01f, 1.90967783e-01f, -6.29831553e-02f, 2.96226740e-01f, -3.75424437e-02f, 3.14594507e-02f, 3.08884140e-02f, -1.32033870e-01f, -9.19394717e-02f, 6.65253177e-02f,
  5.92954122e-02f, 2.29000613e-01f, -9.57211629e-02f, 1.19284824e-01f, 7.99190439e-03f, 3.53972949e-02f, -1.95591021e-02f, -1.01996265e-01f, 1.43757507e-01f, 8.96875411e-02f,
  3.48815024e-02f, 5.89534789e-02f, 7.10301250e-02f, -4.08668257e-02f, 2.16365587e-02f, 4.12645042e-02f, 1.22868359e-01f, 1.64727375e-01f, 1.43851934e-03f, 2.45383263e-01f,
  1.89453706e-01f, -6.21838123e-02f, 1.08179301e-01f, 2.34501466e-01f, 5.09303957e-02f, 1.70400858e-01f, 2.05733553e-01f, -4.82265539e-02f, 2.20041186e-01f, -1.00004740e-01f,
  7.62675330e-02f, 8.04633927e-03f, 1.18632235e-01f, 3.48778558e-03f, 6.26390055e-02f, 3.03975552e-01f, 1.10264540e-01f, 1.32613912e-01f, 7.99513087e-02f, 1.00003362e-01f,
  -2.03792322e-02f, 5.99006154e-02f, -3.74481715e-02f, -1.17214747e-01f, -1.41460001e-01f, -5.95891960e-02f, 1.29362836e-01f, -2.26261113e-02f, -1.64198592e-01f, -1.85234159e-01f,
  1.73828021e-01f, 5.67156374e-02f, 4.32291217e-02f, 5.14335297e-02f, 2.00482812e-02f, 1.06379464e-01f, 5.06789237e-02f, 7.60318264e-02f, -2.40100548e-02f, -1.69236306e-02f,
  -5.10358810e-02f, 1.02792062e-01f, 1.45532250e-01f, 3.70762572e-02f, 7.40241334e-02f, 4.47848551e-02f, 6.72447160e-02f, -5.70500977e-02f, 1.20675243e-01f, 1.00145778e-02f,
  8.27513337e-02f, -1.58590209e-02f, 1.29384428e-01f, 1.59955487e-01f, -1.56911775e-01f, -8.06901045e-03f, 8.53947103e-02f, 5.63591532e-02f, -4.82945070e-02f, 3.61930370e-01f,
  1.25554547e-01f, -8.23163316e-02f, 2.78872512e-02f, -4.28830087e-02f, 1.23530701e-02f, -7.50834942e-02f, -1.02918530e-02f, 1.35562560e-02f, -6.07619993e-02f, 2.69350316e-03f,
  1.36448726e-01f, 1.60987392e-01f, -3.54201719e-02f, 1.29408315e-01f, -3.83551414e-05f, -1.53639928e-01f, 1.30120754e-01f, 1.04190178e-01f, -4.35128137e-02f, -5.20111956e-02f,
  -8.93881842e-02f, 1.20090857e-01f, -6.83154389e-02f, 9.70987156e-02f, -9.55354944e-02f, -1.10018536e-01f, 1.28431052e-01f, -1.12831660e-01f, 1.13133313e-02f, 4.91966456e-02f,
  -5.14522903e-02f, -1.02804862e-01f, 6.71777502e-02f, 9.62566212e-03f, 7.62110874e-02f, 7.26217553e-02f, -2.81844661e-02f, 1.27062991e-01f, -5.27059473e-02f, 2.96156965e-02f,
  -4.53645363e-03f, 1.11957408e-01f, -1.58858486e-02f, 1.21238856e-02f, 7.68145323e-02f, 1.10703669e-02f, 2.77779512e-02f, 4.69258763e-02f, -5.78244701e-02f, 1.13049373e-01f,
  1.73332002e-02f, -2.47438741e-03f, -3.39715444e-02f, 5.01729874e-03f, -8.67608562e-02f, -7.97934011e-02f, -8.04207698e-02f, 2.56071202e-02f, -7.71204308e-02f, -4.81802970e-02f,
  -6.03113649e-03f, 7.05475882e-02f, 4.54051606e-03f, -4.22158167e-02f, -7.73962811e-02f, 1.94415040e-02f, 2.08577774e-02f, 2.34607860e-01f, 9.04414281e-02f, 1.24923393e-01f,
  2.55292892e-01f, 1.61761314e-01f, 2.22942725e-01f, 2.63403893e-01f, 8.95021707e-02f, 1.04997560e-01f, 2.39735335e-01f, 1.45237952e-01f, -5.01853585e-01f, -9.54518095e-02f,
  2.55542636e-01f, 4.76450890e-01f, -1.91946149e-01f, 2.77094364e-01f, -2.40493223e-01f, 1.19180821e-01f, 1.84713811e-01f, -1.66035086e-01f, 2.04319715e-01f, -1.66904867e-01f,
  1.38976917e-01f, -4.18294705e-02f, -8.55813473e-02f, -8.92002732e-02f, -1.17230080e-01f, -9.96692255e-02f, -2.28999794e-01f, 4.94684875e-02f, 2.16565967e-01f, 1.03239007e-01f,
  -1.69157162e-01f, 5.01860604e-02f, -4.86179329e-02f, 3.34916532e-01f, 1.24795876e-01f, 4.13075686e-01f, 2.09613502e-01f, -1.29021853e-01f, -4.94983373e-03f, -1.37899444e-01f,
  3.48771084e-03f, 2.89412171e-01f, 1.83839612e-02f, 4.16204423e-01f, -2.04730511e-01f, 3.96062940e-01f, 1.16489992e-01f, 3.68271284e-02f, 2.04180285e-01f, 1.42406076e-01f,
  -1.83413282e-01f, -5.77234849e-02f, -4.76695262e-02f, -1.90892503e-01f, -6.55897632e-02f, 1.35796964e-01f, -2.30364472e-01f, 3.08798015e-01f, -1.18387192e-01f, 8.40482563e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.53122842e-01f, 3.63967456e-02f, 1.53890103e-01f, 7.07611535e-03f, 3.02205812e-02f, 8.79966915e-02f, 1.45140573e-01f, 7.58362785e-02f, 2.22011819e-01f, 7.68974647e-02f,
  -7.36014172e-02f, 1.53719440e-01f, 3.52131426e-02f, 1.00195251e-01f, 7.62886778e-02f, 1.26983568e-01f, 3.36853340e-02f, 2.95112371e-01f, 1.92375794e-01f, 1.51769012e-01f,
  -5.25309704e-03f, 5.78576177e-02f, -3.57063487e-02f, -3.34954746e-02f, 2.10919872e-01f, 2.09092185e-01f, 2.34715194e-01f, 2.00947672e-01f, 1.53190106e-01f, 1.29017174e-01f,
  2.50979096e-01f, 1.11781051e-02f, 7.87286088e-02f, 1.40616134e-01f, 1.07057244e-01f, 1.25526801e-01f, 1.30664542e-01f, 1.43590020e-02f, -3.57753374e-02f, 2.93353915e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -3.17463040e-01f, 1.66610956e-01f, -2.22020045e-01f, -3.70164402e-02f, 1.52296484e-01f, 1.54554039e-01f, 9.07657817e-02f, -2.58177787e-01f, 8.25995356e-02f, -2.43212637e-02f,
  -2.58317497e-02f, -5.84190749e-02f, -3.36910218e-01f, 1.85761780e-01f, -4.42486703e-01f, 2.03926727e-01f, -2.73247771e-02f, 2.65724063e-01f, 1.03183344e-01f, -4.20028865e-01f,
  3.00717860e-01f, 3.18292558e-01f, -2.47595608e-01f, -3.42286885e-01f, 1.88076243e-01f, -1.91291526e-01f, -1.31245255e-01f, 1.23631172e-01f, 1.84661448e-01f, -2.29038838e-02f,
  -9.61425751e-02f, -1.64491553e-02f, -3.69812220e-01f, -1.82690486e-01f, -3.21706049e-02f, -4.26847078e-02f, -1.18211053e-01f, 3.73931110e-01f, 7.50580523e-03f, 2.68851072e-01f,
  -1.20696172e-01f, 3.81647736e-01f, 6.45302534e-01f, 2.50710219e-01f, -2.22885221e-01f, -1.07076623e-01f, -6.90184534e-02f, -1.45578176e-01f, -1.13958843e-01f, 4.34224576e-01f,
  -2.11115435e-01f, -2.85224646e-01f, -5.71262181e-01f, 3.73183303e-02f, 3.23447168e-01f, -3.25639307e-01f, 6.84335828e-02f, 9.35684666e-02f, -5.47492094e-02f, -8.13686773e-02f,
  -8.53592008e-02f, -2.76644379e-01f, 9.03044790e-02f, -3.43033046e-01f, 3.67279828e-01f, 3.93576503e-01f, 2.87458822e-02f, -6.45569265e-02f, -4.09067869e-02f, -6.40318394e-02f,
  2.25811273e-01f, -9.73480344e-02f, 1.55880764e-01f, -1.23692527e-02f, -1.34535670e-01f, 1.12296835e-01f, 2.65452534e-01f, 6.61468282e-02f, 3.28233987e-01f, 9.04426575e-02f,
  -3.12565237e-01f, 2.71476805e-01f, 1.49295732e-01f, -5.49773753e-01f, -3.66306812e-01f, 7.22428933e-02f, -1.22757271e-01f, -3.74358147e-02f, -2.18382269e-01f, -2.59490132e-01f,
  -1.28314167e-01f, -1.15310706e-01f, -1.89710781e-01f, -1.08331501e-01f, -1.98577911e-01f, 4.71396372e-02f, 1.14481382e-01f, 1.01784520e-01f, 3.56456675e-02f, 6.67209983e-01f,
  3.20381448e-02f, 3.63533884e-01f, 5.50112650e-02f, -8.16112459e-02f, -2.34676879e-02f, 1.01501048e-01f, 2.80824631e-01f, -2.46323436e-01f, 6.39179423e-02f, 3.13606739e-01f,
  -3.08658667e-02f, -2.48066355e-02f, 5.46871424e-01f, 7.52680078e-02f, 1.80468053e-01f, -4.04576957e-01f, -4.67718750e-01f, 3.02851975e-01f, -3.88397928e-03f, -3.04728210e-01f,
  2.44285807e-01f, -2.18053356e-01f, -1.07168011e-01f, 7.98767582e-02f, -7.92202726e-03f, -1.00808084e-01f, -2.81861648e-02f, -5.17371356e-01f, -4.24635381e-01f, -2.61763036e-01f,
  1.24138415e-01f, 8.16514529e-03f, -2.06199035e-01f, 8.91622454e-02f, 1.75680354e-01f, 1.15160093e-01f, -5.17082453e-01f, 6.05830997e-02f, -9.03300568e-02f, -9.71582457e-02f,
  3.98838282e-01f, -1.17534541e-01f, -1.07841246e-01f, -2.14676425e-01f, -3.15823078e-01f, 1.85843229e-01f, -2.38598913e-01f, -7.74604306e-02f, -4.71593499e-01f, 5.07469811e-02f,
  -8.55305418e-02f, 2.01691106e-01f, -2.15212718e-01f, -3.29302438e-02f, 3.98625731e-01f, -1.87993214e-01f, -9.17799696e-02f, -8.62246379e-02f, 1.97753012e-01f, -5.32664359e-02f,
  2.87535489e-01f, 3.56400646e-02f, -9.25182402e-02f, 9.78914090e-03f, -8.32780078e-03f, 4.85279292e-01f, -1.03237510e-01f, -5.94416261e-02f, 4.67851870e-02f, -2.64549166e-01f,
  -2.41640240e-01f, -1.54568583e-01f, 3.82657945e-01f, 3.17384183e-01f, -1.35222180e-02f, -5.22927232e-02f, 2.11073667e-01f, -1.37035968e-02f, -2.84746978e-02f, 2.14527231e-02f,
  -7.38843605e-02f, -9.11241770e-02f, -5.24797104e-02f, 7.89474323e-02f, -2.57368870e-02f, 1.85153216e-01f, 8.91706720e-03f, -2.95792613e-02f, -4.58337478e-02f, -3.09722900e-01f,
  -4.11165208e-02f, -3.16717476e-01f, 5.73064499e-02f, 1.34359851e-01f, -2.61439420e-02f, 2.87524294e-02f, 4.70719375e-02f, -1.49241790e-01f, 4.70470972e-02f, 1.01466784e-02f,
  -1.77952439e-01f, -8.71255100e-02f, 3.96892875e-02f, 3.64625566e-02f, -3.61044675e-01f, 1.49393706e-02f, -1.00031547e-01f, 2.05622181e-01f, -1.14418671e-01f, -2.16007650e-01f,
  3.53676975e-02f, -2.11397797e-01f, 4.31543887e-01f, -6.89625069e-02f, 1.39013067e-01f, -8.03612918e-02f, -2.59389907e-01f, 1.99265242e-01f, -4.08520609e-01f, 2.09498495e-01f,
  -2.49921367e-01f, -1.14525072e-02f, -2.31838197e-01f, -2.03283101e-01f, -4.09067512e-01f, -7.90086575e-03f, -6.89815730e-02f, -2.11627886e-01f, 6.72905073e-02f, -4.65544641e-01f,
  -7.22293481e-02f, 2.93878496e-01f, -6.28494769e-02f, 1.33854479e-01f, -1.60489053e-01f, -7.02157095e-02f, -5.88413477e-02f, -4.19863403e-01f, -2.55985856e-02f, 1.92198008e-01f,
  -8.02333355e-02f, -2.90938348e-01f, -4.02540416e-02f, -2.33090475e-01f, 2.45931149e-01f, 1.50152951e-01f, 2.44468585e-01f, -2.71935105e-01f, 4.12934236e-02f, -1.83925703e-01f,
  -7.46748596e-03f, -1.93560645e-01f, 3.95013243e-01f, 5.15119806e-02f, 1.99728385e-01f, 9.04694617e-01f, -2.18314216e-01f, 7.70357773e-02f, 1.53838506e-03f, -1.57544073e-02f,
  -1.21477775e-01f, -1.60379425e-01f, 2.24702150e-01f, 8.48091319e-02f, -7.32725412e-02f, 1.93117186e-01f, 1.08784456e-02f, 1.76091060e-01f, -3.53723079e-01f, 4.46181111e-02f,
  -4.85936582e-01f, 4.22787815e-01f, -3.08145106e-01f, -4.51759785e-01f, 9.46033821e-02f, 3.36277425e-01f, 3.39897990e-01f, -6.87370135e-04f, -5.47662191e-02f, 1.79133117e-01f,
  4.11591262e-01f, 4.59265321e-01f, 1.37106419e-01f, -2.70595290e-02f, 2.22901881e-01f, 3.08682024e-03f, 3.00426990e-01f, -1.76121712e-01f, 2.17409298e-01f, 1.40677718e-02f,
  1.20462388e-01f, -2.75566459e-01f, -6.60797283e-02f, -2.76688576e-01f, -1.10790551e-01f, -1.59039199e-02f, 1.40379921e-01f, -1.21284515e-01f, 2.63061941e-01f, 5.91505587e-01f,
  -3.61778475e-02f, -2.08195195e-01f, 1.65409356e-01f, -1.02680519e-01f, -9.20008272e-02f, -6.15422167e-02f, -1.33650333e-01f, 1.36747867e-01f, 9.22221467e-02f, -1.29013032e-01f,
  3.85102630e-01f, -8.53743628e-02f, 9.44844633e-02f, 7.12517425e-02f, 2.65351497e-02f, -9.54679623e-02f, 1.49177089e-01f, -2.82748610e-01f, 1.29816800e-01f, 5.34314550e-02f,
  1.56236395e-01f, -9.98557508e-02f, 1.02081500e-01f, -1.09158725e-01f, 2.02487275e-01f, 2.81440150e-02f, 4.77076545e-02f, 3.72895449e-01f, -1.92897812e-01f, 1.41250283e-01f,
  1.30256917e-02f, 3.24604521e-03f, -3.47477943e-01f, 4.89497125e-01f, 4.28503126e-01f, 4.02065426e-01f, 1.14779979e-01f, -1.25604540e-01f, 1.85024843e-01f, 3.04884668e-02f,
  4.42205340e-01f, 2.61628866e-01f, -2.32631147e-01f, -3.34595740e-01f, 5.90990111e-03f, -1.79543570e-02f, -4.16949451e-01f, -1.83613867e-01f, 3.85794602e-02f, 3.10549885e-01f,
  -2.37485364e-01f, 2.38773942e-01f, 4.02505755e-01f, 1.53345466e-01f, 8.63026604e-02f, 1.19974256e-01f, -7.78464004e-02f, 1.33322388e-01f, -1.17520794e-01f, -1.67981580e-01f,
  1.28824003e-02f, 7.14404508e-02f, 2.12040812e-01f, 2.27180928e-01f, -6.34810105e-02f, -6.67650253e-02f, -1.55338019e-01f, -5.59682250e-02f, -2.57918328e-01f, 2.75519073e-01f,
  1.56427130e-01f, 3.85747552e-01f, -2.02787310e-01f, 8.84658620e-02f, -4.67702486e-02f, 2.24945799e-01f, 2.30467841e-02f, -3.33388656e-01f, 3.91479492e-01f, -2.38397066e-02f,
  -1.28718182e-01f, 3.62017363e-01f, -5.70511296e-02f, -3.99006844e-01f, 1.18638761e-02f, 4.32227738e-02f, -1.85604870e-01f, 1.33938015e-01f, -2.57909074e-02f, 4.16171625e-02f,
  1.29227489e-01f, -7.88882826e-05f, 9.73578766e-02f, -8.81749913e-02f, -8.31845850e-02f, 6.63371533e-02f, 1.81501403e-01f, -2.72335589e-01f, 3.68305713e-01f, 1.65893827e-02f,
  3.08861762e-01f, 2.99704187e-02f, 2.18545906e-02f, 1.89014137e-01f, -2.27212775e-02f, 3.38382721e-01f, -2.67362356e-01f, 3.24269056e-01f, 1.01404432e-02f, -1.60021856e-01f,
  -2.81309396e-01f, -7.83621967e-02f, -7.19714463e-02f, 2.28172943e-01f, 8.56385306e-02f, 3.19978803e-01f, -1.74634382e-01f, 2.09291160e-01f, -1.41913265e-01f, -2.86729783e-01f,
  -8.14737529e-02f, -6.63759783e-02f, -8.36974159e-02f, -4.75429185e-02f, 1.49943575e-01f, -1.41808808e-01f, -2.73053885e-01f, -3.41306448e-01f, 3.29856426e-02f, -1.60289198e-01f,
  -1.64125785e-01f, -1.14982173e-01f, 1.82968423e-01f, 3.92296046e-01f, 2.81001404e-02f, 4.26394135e-01f, 9.01615143e-01f, -1.31552070e-01f, 2.08412409e-01f, 2.13948935e-01f,
  -2.88780127e-02f, -1.84042856e-01f, -1.55543536e-01f, -1.37834683e-01f, -2.35547170e-01f, 9.21607763e-02f, -1.34117186e-01f, -1.85722858e-01f, -1.91021875e-01f, -4.52602580e-02f,
  -5.77944256e-02f, 5.01366565e-03f, -5.11307940e-02f, -3.57935965e-01f, -2.92915672e-01f, -1.32949993e-01f, -1.40118331e-01f, -2.77615227e-02f, -9.77749154e-02f, -1.13725111e-01f,
  -1.56544466e-02f, 1.91100165e-01f, 3.78463380e-02f, -1.59669518e-01f, 3.40343378e-02f, -2.14473799e-01f, 5.97117878e-02f, 2.78475642e-01f, 2.98958812e-02f, 1.45173609e-01f,
  4.25792903e-01f, -2.35718653e-01f, -5.07322550e-02f, 1.28626391e-01f, -3.07060093e-01f, 2.64839232e-01f, 1.02324583e-01f, 2.15159953e-01f, 1.40957087e-01f, -5.16957156e-02f,
  -2.93152660e-01f, -1.01255090e-03f, 4.77890633e-02f, 4.77022141e-01f, 5.83507381e-02f, -2.72847354e-01f, 1.20956495e-01f, 2.77585357e-01f, 6.90179542e-02f, -2.53702164e-01f,
  -2.30614290e-01f, -6.05459139e-02f, 1.07307255e-01f, 3.94381315e-01f, 1.81826562e-01f, 2.47244183e-02f, -2.12979004e-01f, -2.48228475e-01f, 6.97534159e-02f, 2.04947397e-01f,
  3.66819813e-03f, 5.47925755e-02f, -2.89648861e-01f, -1.80829450e-01f, 1.81015149e-01f, 3.36885959e-01f, 1.08501375e-01f, 1.03280507e-02f, 1.71419144e-01f, 8.55513215e-02f,
  -1.11432239e-01f, 3.53737473e-01f, -2.26229541e-02f, -2.12633878e-01f, -1.10225186e-01f, -1.18250616e-01f, -2.93399617e-02f, -1.89521581e-01f, -2.90035069e-01f, -4.09148913e-03f,
  1.55428723e-01f, 6.43387586e-02f, -6.70241117e-02f, 4.56964932e-02f, 2.34270737e-01f, -1.85423687e-01f, 2.62287050e-01f, 3.42360795e-01f, 4.10254896e-01f, 3.17095935e-01f,
  -3.74232858e-01f, -2.05329046e-01f, 8.25159401e-02f, -1.24566704e-01f, -1.00876585e-01f, 1.38242558e-01f, -1.35503247e-01f, 5.69639355e-02f, 7.57232070e-01f, -1.39000326e-01f,
  3.61074686e-01f, -2.61247600e-03f, 1.41913248e-02f, -5.47338091e-03f, -1.29152492e-01f, -1.74296796e-02f, -3.28090191e-02f, 1.91978931e-01f, 5.23146801e-02f, 1.24971814e-01f,
  -1.13169052e-01f, -4.84201908e-02f, -1.20839953e-01f, -3.95184234e-02f, -3.55486035e-01f, -1.70335144e-01f, 1.77234873e-01f, -2.14202121e-01f, 4.32221815e-02f, -5.22880405e-02f,
  -2.56562233e-01f, -1.27315983e-01f, 1.77241966e-01f, -1.03837758e-01f, -2.11099058e-01f, 1.89775169e-01f, -3.70527625e-01f, 3.94175053e-01f, -3.15454192e-02f, -2.13201329e-01f,
  2.10992619e-02f, 1.31959811e-01f, 1.07937694e-01f, 2.01670364e-01f, 3.10873892e-02f, -1.38507426e-01f, 1.27491847e-01f, -2.01456219e-01f, 2.46192925e-02f, -8.31996929e-03f,
  9.72436816e-02f, 5.06096482e-02f, -7.75913969e-02f, -2.53958583e-01f, 2.66146399e-02f, 5.09980991e-02f, 3.20810527e-02f, 8.42053536e-03f, -3.06498349e-01f, -3.25694889e-01f,
  -1.75746083e-01f, -4.65841770e-01f, 7.15037361e-02f, -3.03957462e-01f, 3.97336334e-01f, 3.85406137e-01f, -4.29372549e-01f, -1.49370238e-01f, 2.25501359e-01f, -1.62427932e-01f,
  1.15163803e-01f, -6.61141500e-02f, -2.15697020e-01f, -7.38468319e-02f, 7.49950185e-02f, -1.03421651e-01f, 3.62798631e-01f, 5.61104834e-01f, 1.58228144e-01f, -5.06409146e-02f,
  -9.89336222e-02f, 9.60007682e-02f, 1.95269976e-02f, -2.69663990e-01f, -1.12258634e-02f, -1.40688404e-01f, 7.11875260e-02f, -2.72941589e-01f, 4.60643500e-01f, -5.10080159e-02f,
  -6.48220554e-02f, 4.90141213e-01f, -4.23029214e-02f, -4.27151918e-02f, 4.51278798e-02f, 1.16475038e-01f, -2.50893980e-01f, 1.39850602e-01f, 1.35009721e-01f, -2.25463212e-02f,
  -1.27291873e-01f, -1.95023000e-01f, -1.23199821e-01f, 2.38959000e-01f, -4.03574333e-02f, 6.49018809e-02f, -2.44089216e-01f, -1.90544218e-01f, -1.59920484e-01f, -4.40631121e-01f,
  3.02127779e-01f, -1.92430660e-01f, 1.37859568e-01f, 2.61449575e-01f, 3.01691685e-02f, 1.37613297e-01f, 1.44572720e-01f, 3.02867800e-01f, 1.92835510e-01f, 1.84909552e-01f,
  2.33566195e-01f, 6.63131708e-03f, 2.88950652e-01f, -4.36097413e-01f, 3.49212289e-01f, -1.75655186e-01f, -3.10126454e-01f, 3.04853708e-01f, 2.09220737e-01f, 1.27501532e-01f,
  -4.31244433e-01f, -2.40670219e-01f, -1.60292268e-01f, 8.14961269e-02f, 4.17804979e-02f, -2.57664144e-01f, 3.43970239e-01f, 1.09650171e-03f, -1.83356494e-01f, -1.44487530e-01f,
  -6.41137213e-02f, -4.06112820e-01f, -2.74977058e-01f, -1.34287968e-01f, -9.44422334e-02f, -3.05371106e-01f, -1.47301927e-01f, -3.25221002e-01f, -5.71599342e-02f, -1.44679874e-01f,
  -1.20534800e-01f, 4.63791788e-01f, -4.23987210e-02f, 6.50808066e-02f, -1.87139750e-01f, 1.80016428e-01f, -3.52352895e-02f, 1.55146271e-01f, 1.06241003e-01f, -2.02471450e-01f,
  2.36117929e-01f, -3.73336375e-01f, -7.13678896e-02f, -8.57014284e-02f, 3.40451747e-01f, 8.70381966e-02f, -2.03522574e-02f, 1.68394953e-01f, -2.10676670e-01f, -1.02144904e-01f,
  1.45769864e-01f, -8.45358074e-02f, -1.07694604e-01f, 4.93060261e-01f, 2.27752924e-01f, 2.27001868e-02f, -1.97967533e-02f, 2.17007659e-02f, -1.23620652e-01f, 1.94131330e-01f,
  -2.40981132e-01f, -2.25482159e-03f, -4.70866598e-02f, 8.61625895e-02f, 1.30633146e-01f, -2.78548487e-02f, -5.17231077e-02f, -2.19906345e-02f, 2.26495825e-02f, -2.84993917e-01f,
  3.41120452e-01f, 7.96192437e-02f, -5.49609840e-01f, 2.02988666e-02f, 1.89323008e-01f, -1.98061273e-01f, 1.91555724e-01f, -1.92816064e-01f, 6.63862377e-02f, 2.03811124e-01f,
  -5.49049415e-02f, 1.73292398e-01f, 1.46290839e-01f, 1.54139563e-01f, 6.51478469e-02f, -2.50287980e-01f, 4.41698998e-01f, -2.94484869e-02f, -5.24662761e-03f, -3.40474039e-01f,
  -1.25286961e-02f, 1.97665498e-01f, -3.20138894e-02f, -1.82558984e-01f, 7.78278708e-02f, 1.19892851e-01f, -3.24456871e-01f, 2.15135261e-01f, -2.18908280e-01f, -3.49875033e-01f,
  -4.02782019e-03f, -7.43059665e-02f, -1.89111501e-01f, 1.51604593e-01f, -2.94895649e-01f, -1.20708004e-01f, 2.80705988e-01f, 5.63259572e-02f, -3.86751443e-01f, 1.62486687e-01f,
  9.74832550e-02f, -2.88324237e-01f, -6.12666868e-02f, 2.62348235e-01f, -2.33519331e-01f, 2.79863387e-01f, 6.20847531e-02f, 5.61741710e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.02478832e-01f, 1.37233630e-01f, -1.22984879e-01f, 5.85562885e-02f, 7.65555799e-02f, 9.68621969e-02f, -3.42282839e-02f, -1.64038651e-02f, -1.52502388e-01f, -2.67390832e-02f,
  1.84929281e-01f, -7.99925998e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    