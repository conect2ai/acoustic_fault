/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.03317702e+00f, 2.03149796e-01f, 4.47757058e-02f, -5.30218817e-02f, 1.33407936e-01f, -1.07916258e-01f, -1.27929702e-01f, -3.58913355e-02f, -1.75298266e-02f, 1.00868702e-01f,
  -5.33576235e-02f, -6.38288707e-02f, 3.45913284e-02f, 4.24099863e-02f, -2.70512789e-01f, 1.22211978e-01f, 1.89330548e-01f, -2.07294986e-01f, -3.06443185e-01f, 2.12513711e-02f,
  2.06234470e-01f, -1.98910292e-02f, -2.47713804e-01f, -5.52114435e-02f, 3.84286970e-01f, -4.60021608e-02f, 1.07715297e-02f, 2.96746958e-02f, 1.18641123e-01f, 6.88505709e-01f,
  2.05519438e-01f, -3.33976634e-02f, -2.52441652e-02f, -2.83669960e-02f, 5.62730059e-02f, 1.65293757e-02f, -5.88140525e-02f, 2.10035518e-02f, -2.40059337e-03f, 1.06289081e-01f,
  8.30707476e-02f, 3.33720706e-02f, -1.04278184e-01f, 3.04771606e-02f, -1.53630169e-03f, 3.42627689e-02f, -5.75675368e-02f, -5.15266396e-02f, -3.19619477e-02f, 8.99827480e-02f,
  1.22220516e-01f, 7.05259219e-02f, -2.26993058e-02f, -6.64198026e-02f, -2.06728891e-01f, -8.58387873e-02f, 3.22382972e-02f, 4.85237613e-02f, -1.38829753e-01f, 9.73298028e-02f,
  2.78225709e-02f, -3.06482483e-02f, -1.60234757e-02f, 2.72400454e-02f, -1.62482131e-02f, -1.99379362e-02f, 4.13878150e-02f, -4.49892953e-02f, -3.86108682e-02f, -6.17503412e-02f,
  8.17771330e-02f, 2.12852415e-02f, 3.40733752e-02f, -1.23264745e-01f, 3.13087963e-02f, -2.21971162e-02f, -1.46410381e-03f, -1.37827347e-03f, 3.53457243e-03f, 6.90757111e-02f,
  -4.81544919e-02f, 1.64883733e-02f, -1.03904130e-02f, 1.97693631e-02f, 8.38469714e-02f, -9.56264921e-05f, 1.87420286e-02f, -3.25711863e-03f, -7.01095769e-03f, 7.35143200e-02f,
  2.92242151e-02f, -2.40786970e-01f, 6.82840422e-02f, -1.36969294e-02f, -8.28326866e-02f, -9.64560546e-03f, 3.51554602e-02f, 4.37879451e-02f, 9.60590765e-02f, 2.81184297e-02f,
  -2.74265856e-02f, -5.56609780e-02f, 3.18730623e-02f, 4.09306102e-02f, -5.33441417e-02f, 1.73971206e-02f, -3.36744562e-02f, -1.77623238e-02f, 3.84053215e-02f, 1.36006564e-01f,
  6.74626529e-02f, -4.13793847e-02f, -1.10428236e-01f, 5.51693141e-02f, -1.39917703e-02f, -1.14816763e-01f, 5.21073304e-02f, 3.32231782e-02f, -1.60227269e-01f, -2.75100768e-02f,
  5.54469451e-02f, -4.12044197e-01f, -4.14565615e-02f, -1.79161225e-02f, 1.63705990e-01f, -1.41764536e-01f, -6.50025606e-01f, -7.68719837e-02f, 5.89125082e-02f, -3.52742881e-01f,
  2.10716456e-01f, 6.34588718e-01f, 3.21638972e-01f, 2.19006822e-01f, -2.10721850e-01f, -7.08546817e-01f, -7.13650346e-01f, -1.54752046e-01f, 8.96440446e-02f, 7.20311105e-02f,
  7.20891505e-02f, -1.40186146e-01f, -1.32909939e-01f, -9.93220657e-02f, -1.02032907e-02f, 2.60958374e-01f, -1.31067693e-01f, 1.23631939e-01f, -9.14604496e-03f, -1.33682668e-01f,
  1.64387330e-01f, -7.73384944e-02f, 9.60635096e-02f, -1.83032360e-02f, 1.52311042e-01f, -1.59366503e-02f, 4.62994445e-03f, -1.20968616e-04f, 1.51364906e-02f, -5.38415238e-02f,
  1.88773945e-01f, 7.86704421e-02f, 3.55634168e-02f, 7.59074986e-02f, -9.65954363e-02f, -4.14694659e-02f, -1.30968779e-01f, -8.08555707e-02f, -6.53231665e-02f, 3.59595716e-02f,
  1.00741580e-01f, 8.92549157e-02f, -4.05593804e-04f, -1.05395898e-01f, -3.31617855e-02f, 4.84144650e-02f, -1.13222478e-02f, 7.25805610e-02f, 6.11808449e-02f, -1.13943286e-01f,
  -3.51767503e-02f, 1.97447417e-03f, 4.21384498e-02f, 3.36964875e-02f, 2.79779732e-02f, 1.09452412e-01f, -3.14969905e-02f, 8.17140006e-03f, -5.45248203e-02f, -4.00747638e-03f,
  5.21565564e-02f, 2.57612485e-02f, 1.98294558e-02f, -4.70904931e-02f, -3.22723463e-02f, 5.14679886e-02f, -3.13928723e-03f, -8.50111917e-02f, 2.69882567e-02f, -5.46142980e-02f,
  -2.47249217e-03f, 9.37423185e-02f, -4.80810031e-02f, 5.38312346e-02f, -4.51633222e-02f, 2.13983022e-02f, 5.98188825e-02f, 1.06375143e-01f, 1.30318940e-01f, 4.29436415e-02f,
  8.10719207e-02f, 9.61279199e-02f, -3.58606242e-02f, -2.45052949e-02f, -4.60399650e-02f, -7.53064901e-02f, -6.08453993e-03f, -7.65743181e-02f, 9.29309800e-02f, -3.38710286e-02f,
  8.49538576e-03f, -3.05310171e-02f, -4.73022349e-02f, -2.77482662e-02f, -1.37528121e-01f, 2.57318653e-03f, -1.13094777e-01f, 3.08410786e-02f, -1.18763775e-01f, -6.19237050e-02f,
  -1.56871617e-01f, -2.30282918e-01f, 7.11484859e-03f, -4.45664227e-02f, -2.89181154e-03f, 5.43490127e-02f, -5.61390929e-02f, -7.90983886e-02f, -7.46753812e-02f, -3.49692553e-01f,
  -1.01839781e+00f, 5.78986704e-01f, -1.15970643e-02f, -4.66148742e-02f, 9.57529619e-02f, -1.29485652e-01f, 2.90574674e-02f, 4.20902446e-02f, -1.33185685e-01f, 3.49977352e-02f,
  2.11651891e-01f, -1.16247930e-01f, 1.95910826e-01f, 3.14377472e-02f, -6.56252354e-03f, 2.04168856e-01f, 4.33521509e-01f, -2.04659373e-01f, -4.82744724e-01f, -5.09661436e-01f,
  -5.59611358e-02f, -7.74348602e-02f, -2.72900999e-01f, -1.14702396e-02f, -2.50965338e-02f, -1.13320179e-01f, 3.42523724e-01f, 1.01025850e-01f, 1.80334777e-01f, 1.74204320e-01f,
  -3.62570077e-01f, -1.69834107e-01f, -1.87079180e-02f, 1.54861137e-02f, 2.89573912e-02f, -2.37473354e-01f, -1.36471435e-01f, -9.67973769e-02f, -1.73146930e-02f, -5.92380092e-02f,
  5.44351526e-02f, -4.93968911e-02f, 2.90062670e-02f, -7.24145770e-02f, -8.41621161e-02f, -1.42013744e-01f, -5.00075407e-02f, -8.89592394e-02f, 9.04621929e-02f, -1.35259300e-01f,
  2.06921265e-01f, -7.70301893e-02f, 5.30509762e-02f, 6.55988902e-02f, -3.93583849e-02f, 1.48881778e-01f, 4.06470001e-02f, -4.60665561e-02f, 3.09677236e-02f, -1.71810761e-01f,
  2.44482723e-03f, -2.38279514e-02f, 4.63388562e-02f, -1.83386039e-02f, 8.18174630e-02f, 6.33475780e-02f, 2.50936989e-02f, -1.16397440e-02f, 2.36577727e-02f, -4.02980596e-02f,
  1.02982081e-01f, 1.15785301e-02f, 1.57468766e-02f, -1.98858865e-02f, 5.39686121e-02f, 7.53465667e-02f, 2.88625285e-02f, 1.80881843e-02f, 5.86235262e-02f, 1.17942616e-01f,
  8.10439140e-02f, 2.99047772e-02f, 1.30943492e-01f, 8.46943185e-02f, 6.95107207e-02f, 4.16833572e-02f, 1.26935011e-02f, -2.86744423e-02f, 5.73895164e-02f, 6.56307712e-02f,
  -3.01489029e-02f, 2.07583264e-01f, -2.06624940e-01f, -1.15532696e-01f, -9.56547558e-02f, 7.33510107e-02f, 4.14756611e-02f, -7.69042149e-02f, 5.04455864e-02f, -5.81725128e-02f,
  1.03743663e-02f, -1.59312949e-01f, 5.66229820e-02f, -6.47035688e-02f, -1.17649101e-01f, -6.61166459e-02f, -1.59402564e-02f, -3.52882892e-02f, -1.51538346e-02f, 2.25501135e-02f,
  8.65177736e-02f, -9.44379196e-02f, -2.75988728e-01f, -1.16108373e-01f, -1.46821477e-02f, -2.15031371e-01f, -1.19671509e-01f, -2.02158958e-01f, -5.12654260e-02f, -2.69396007e-01f,
  -2.19625279e-01f, 1.65366620e-01f, 8.14773679e-01f, 1.25061810e-01f, -3.35614458e-02f, -1.52696043e-01f, -7.20084980e-02f, -2.34391659e-01f, -2.20661268e-01f, 9.77720544e-02f,
  -7.83422962e-03f, -1.61896095e-01f, 1.93858907e-01f, -6.04292341e-02f, -8.23116526e-02f, 9.03390050e-02f, 3.41451317e-01f, 4.00978923e-01f, -2.12620899e-01f, -4.97586727e-01f,
  -2.61871547e-01f, 6.76292703e-02f, 8.59269500e-02f, -8.73613805e-02f, 1.06875852e-01f, -6.12736568e-02f, 3.61613065e-01f, 1.59984753e-01f, -3.77436914e-02f, 4.63321120e-01f,
  4.39130664e-01f, 2.54467040e-01f, -1.21344753e-01f, -1.14381321e-01f, 6.91268295e-02f, -6.66078702e-02f, -6.25824258e-02f, 8.58207569e-02f, -3.19558978e-02f, 1.88436836e-03f,
  4.79906984e-02f, -2.59003714e-02f, 7.58077204e-03f, -1.85945984e-02f, 1.97179448e-02f, -3.11078373e-02f, 3.51479352e-02f, 7.35686272e-02f, 4.81231585e-02f, 1.06627103e-02f,
  3.36805009e-03f, 7.68164173e-02f, 1.50253862e-01f, -6.89696567e-03f, -8.57443362e-02f, 1.11159654e-02f, -8.01221561e-03f, -1.99099537e-02f, -5.86063713e-02f, -2.70411801e-02f,
  -8.90020728e-02f, 6.35526255e-02f, -5.29823080e-02f, -2.00695097e-02f, -6.47854879e-02f, 5.68084791e-02f, 5.22439927e-02f, 1.94681287e-02f, -9.00784731e-02f, 8.08586180e-02f,
  -2.75047477e-02f, -2.32480429e-02f, 7.10214823e-02f, 2.73862816e-02f, 1.32536972e-02f, 7.37382621e-02f, 1.14481188e-02f, 8.02437682e-03f, -9.86424834e-03f, -4.57993932e-02f,
  -1.14824869e-01f, -3.27056572e-02f, 6.13318682e-02f, 3.14203352e-02f, -6.58970848e-02f, 4.53657806e-02f, 6.93556212e-04f, -1.91162005e-02f, -1.79815013e-02f, 6.09671697e-03f,
  -2.20682815e-01f, -1.06499426e-01f, 6.68727979e-02f, -2.59039570e-02f, 9.28781331e-02f, -8.37443862e-03f, 1.12862289e-01f, -5.75129315e-02f, 3.26359607e-02f, -4.44383249e-02f,
  -3.63640077e-02f, -1.16381962e-02f, 1.16735585e-01f, 4.19041589e-02f, -8.35346431e-02f, -1.29167065e-01f, -1.15664797e-02f, 7.82213137e-02f, -1.02617070e-01f, 4.07299958e-03f,
  -1.37238428e-02f, -1.32743090e-01f, -1.96508557e-01f, -5.11630811e-02f, -6.51748851e-02f, -7.22128004e-02f, 8.48086327e-02f, -2.88148634e-02f, -8.41867328e-02f, -1.53292358e-01f,
  -6.07988536e-01f, -2.76505560e-01f, 1.05716191e-01f, -3.70756626e-01f, -8.13790113e-02f, 1.53288469e-01f, -1.76153600e-01f, 2.09073089e-02f, -1.50602564e-01f, -3.32430422e-01f,
  -8.65282416e-02f, 2.84700483e-01f, 2.24818677e-01f, 4.80657578e-01f, 3.25366974e-01f, -7.51812905e-02f, -9.93115678e-02f, 3.38109076e-01f, 5.01313210e-01f, 1.64923236e-01f,
  -2.15896424e-02f, -3.58230978e-01f, -2.33018994e-01f, 1.23490533e-02f, -3.74768913e-01f, 3.09366763e-01f, -3.17980498e-01f, -2.61928737e-01f, 3.48118320e-02f, -1.49995863e-01f,
  3.33184097e-03f, -2.04000115e-01f, 2.77938336e-01f, 3.76926325e-02f, -6.42928183e-02f, 2.94221155e-02f, -3.06992698e-03f, -1.35442451e-01f, 3.76405008e-02f, -4.83429842e-02f,
  1.88005418e-02f, -4.78360988e-02f, 3.67087647e-02f, 2.82097999e-02f, -3.32843624e-02f, 9.57510099e-02f, -1.85087975e-02f, 9.19386223e-02f, 1.46338806e-01f, -3.05119641e-02f,
  1.97529122e-02f, -1.45784855e-01f, -3.10044140e-02f, 1.25216246e-01f, 1.60570994e-01f, 1.67338416e-01f, 7.78196007e-02f, 5.40633127e-02f, 1.87080011e-01f, -1.59607634e-01f,
  -6.05605431e-02f, -3.26632112e-02f, 4.16249298e-02f, -9.56833661e-02f, 2.10385919e-02f, -9.03231325e-04f, 1.47236921e-02f, -3.82473953e-02f, 4.12101112e-02f, -1.11021511e-01f,
  8.34869817e-02f, 1.53835886e-03f, 6.75862953e-02f, -4.05946560e-02f, 2.99121663e-02f, -7.84733891e-02f, 3.93791869e-02f, -5.07275090e-02f, 9.89392325e-02f, -1.06522506e-02f,
  9.12280604e-02f, 4.06788066e-02f, -6.63794354e-02f, 7.96603635e-02f, 8.65638722e-03f, 1.01546496e-02f, 1.43164592e-02f, 1.89216789e-02f, -8.04883018e-02f, -6.58372343e-02f,
  -3.45354006e-02f, 2.71131426e-01f, -1.16897963e-01f, 9.37727615e-02f, -7.63852224e-02f, 6.55269297e-03f, 1.78602822e-02f, 5.57274185e-02f, -3.03523168e-02f, 3.44225839e-02f,
  9.95283723e-02f, 8.62854496e-02f, -5.12466244e-02f, 7.37842992e-02f, 1.20867878e-01f, 2.60517932e-02f, -4.37375009e-02f, 2.70539410e-02f, 7.39034489e-02f, -5.54841943e-02f,
  -7.92004615e-02f, 1.29407656e-03f, 6.76102564e-02f, 9.22329277e-02f, -5.31644095e-03f, 3.82268392e-02f, -1.32772597e-02f, 7.27035180e-02f, 2.05139741e-01f, -2.44162858e-01f,
  3.30336004e-01f, -3.84669125e-01f, -5.71335018e-01f, 3.84784430e-01f, -1.66646466e-02f, -2.15634048e-01f, -5.03343463e-01f, -7.83378854e-02f, 1.37963891e-01f, -1.36828929e-01f,
  -1.22802280e-01f, 2.47409716e-01f, 3.18538919e-02f, 5.79779595e-02f, -1.53104544e-01f, -3.29124033e-01f, -2.66177416e-01f, -7.63645768e-03f, 8.00079107e-02f, 5.76682836e-02f,
  4.02588658e-02f, 2.13393003e-01f, 3.52569491e-01f, -7.11501539e-02f, 1.78521544e-01f, 5.83130658e-01f, 9.38110426e-02f, 1.69927701e-01f, -1.04604527e-01f, 3.30844015e-01f,
  -6.31111562e-02f, -2.06277847e-01f, 2.22018603e-02f, 1.41246825e-01f, -3.76453660e-02f, -2.59115156e-02f, -6.24540821e-02f, 4.78141606e-02f, 6.50012493e-02f, -8.16382021e-02f,
  4.34812978e-02f, 4.46427194e-03f, 3.62714790e-02f, 6.12689219e-02f, 2.64267363e-02f, 1.29323816e-02f, -3.55520914e-03f, -1.10727251e-01f, -9.09501985e-02f, -6.45709261e-02f,
  -1.47098601e-01f, -6.59566298e-02f, -2.64808685e-01f, -1.87914357e-01f, -2.88424045e-01f, -4.76415269e-02f, -1.41149372e-01f, -1.94559153e-02f, -1.82104886e-01f, 2.10380316e-01f,
  5.55835031e-02f, -4.03443985e-02f, 3.80410850e-02f, -1.49546927e-02f, 7.51236007e-02f, 1.09796906e-02f, 3.23660597e-02f, 3.96803468e-02f, -3.44722085e-02f, 4.90248129e-02f,
  -3.62972431e-02f, 5.02322018e-02f, 2.08177473e-02f, 1.26961526e-02f, 9.88848060e-02f, -2.79589146e-02f, -2.68549789e-02f, 7.56666586e-02f, -6.47561997e-03f, 1.41958660e-02f,
  -5.58144506e-03f, 2.81894654e-02f, 6.21354915e-02f, 4.89312075e-02f, -2.63818372e-02f, -2.51390394e-02f, 4.43333946e-03f, 3.49092185e-02f, 5.74328192e-02f, 3.83758987e-03f,
  2.49763042e-01f, -2.39282265e-01f, 1.65447578e-01f, -9.13427919e-02f, -1.37856649e-03f, 1.39056891e-02f, 4.70687896e-02f, -4.98369001e-02f, -1.12006543e-02f, -1.58943757e-02f,
  -1.07881315e-01f, 9.63220224e-02f, -1.15491830e-01f, 1.62107050e-02f, 1.78712398e-01f, -5.60330003e-02f, 7.85569474e-02f, 6.16935231e-02f, -1.25261815e-02f, -5.13526518e-03f,
  -1.32631045e-02f, -7.10413093e-03f, 1.70411527e-01f, -5.26938252e-02f, 9.05589387e-02f, 5.13918251e-02f, 6.38786331e-02f, 1.37402445e-01f, -2.56270133e-02f, 2.01755598e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.39358151e-01f, 2.50731558e-01f, -1.16869819e+00f, 2.78035313e-01f, -9.02217448e-01f, -5.55372059e-01f, -3.59264076e-01f, 4.51469213e-01f, 5.64310014e-01f, 4.99308556e-02f,
  1.46173403e-01f, 5.30345440e-01f, 9.50754225e-01f, -6.23296201e-02f, -3.42139900e-01f, -3.37175846e-01f, -6.62621498e-01f, -7.88736284e-01f, -9.90767717e-01f, -1.07608545e+00f,
  -9.87270176e-01f, -6.49552524e-01f, -4.82756823e-01f, -2.78330803e-01f, 2.02478126e-01f, 2.13764086e-01f, 3.16993594e-01f, -3.62356663e-01f, -4.43155885e-01f, -5.00684917e-01f,
  -1.79035455e-01f, -2.17247501e-01f, -1.30846590e-01f, -1.88995674e-01f, -2.41659153e-02f, 2.26387799e-01f, 5.37689135e-04f, 1.62518620e-01f, 3.43564361e-01f, 2.74057984e-01f,
  -8.44467878e-02f, -1.90754905e-01f, 1.47950351e-01f, 1.07899425e-03f, 3.35597526e-03f, -9.09606218e-02f, 1.61225982e-02f, -3.47864836e-01f, 9.02111642e-03f, 9.40201655e-02f,
  -1.92914292e-01f, -6.01809084e-01f, -7.25351870e-02f, 1.83400989e-01f, -1.18708014e-01f, -3.04987431e-01f, 1.62101045e-01f, -2.23319214e-02f, -7.57076964e-02f, 4.56511647e-01f,
  -1.82708442e-01f, 3.68910909e-01f, -5.65139242e-02f, -9.76347625e-02f, 7.90587664e-02f, 1.64948270e-01f, -8.12146906e-03f, -5.62498681e-02f, 9.99438390e-02f, 9.82397348e-02f,
  9.68724117e-02f, 1.87583566e-01f, 4.46995571e-02f, 2.40117639e-01f, -4.28767353e-02f, -2.70030349e-02f, -5.13440333e-02f, 7.94952586e-02f, -3.62564214e-02f, -4.18145917e-02f,
  -1.24246337e-01f, -1.34671271e-01f, -4.30914462e-02f, 2.65444815e-02f, -4.12767589e-01f, 2.45135054e-02f, 6.70183748e-02f, 2.73622703e-02f, 4.05299105e-02f, -1.45010412e-01f,
  9.93631959e-01f, -4.75004375e-01f, 4.80088800e-01f, -3.09710354e-02f, -3.00419182e-02f, 7.97604620e-02f, 3.14368248e-01f, -6.08862489e-02f, 1.75487906e-01f, 1.95898227e-02f,
  -2.62645751e-01f, 1.49224967e-01f, 1.71679065e-01f, 3.63410115e-02f, 3.39740291e-02f, -1.73870191e-01f, -1.54847149e-02f, -1.75716564e-01f, -1.70122921e-01f, -1.22111522e-01f,
  -2.66719013e-02f, -2.88779810e-02f, 1.79404587e-01f, 3.29779297e-01f, 1.68204289e-02f, -1.15500756e-01f, 2.35697195e-01f, 1.35839120e-01f, -1.27179911e-02f, 6.52625799e-01f,
  -1.88431501e+00f, -4.45811033e-01f, -5.82088888e-01f, -5.22440016e-01f, 1.05654073e+00f, 4.51887786e-01f, -2.63973027e-01f, -2.11265534e-01f, -1.41043156e-01f, -2.72447288e-01f,
  4.54329640e-01f, 4.77843583e-01f, -4.59186226e-01f, 1.14691034e-02f, -5.44822633e-01f, -2.03453407e-01f, 7.22974911e-02f, -4.79989976e-01f, -2.17633210e-02f, 3.72022092e-01f,
  8.50555420e-01f, 8.45757220e-03f, -4.07780349e-01f, -1.90870002e-01f, -2.14105234e-01f, -4.27969731e-02f, -2.26218924e-01f, -5.32056354e-02f, 2.84546800e-02f, -4.14460450e-01f,
  -7.28267372e-01f, -6.69562876e-01f, 4.00189102e-01f, 3.69301677e-01f, 3.87531519e-01f, -4.63100612e-01f, -2.15854421e-01f, -8.23756084e-02f, 5.42894378e-03f, -2.88280994e-01f,
  4.63563837e-02f, 1.54657781e-01f, 3.78894717e-01f, 2.99747497e-01f, 2.33738363e-01f, -3.34807217e-01f, 7.54787996e-02f, -4.23047930e-01f, -5.97628832e-01f, -3.44384193e-01f,
  8.55281949e-01f, 4.06462073e-01f, -6.45728886e-01f, 3.26125950e-01f, 2.32399657e-01f, 3.02700132e-01f, 7.01381192e-02f, -2.53309816e-01f, -7.06887424e-01f, -9.79164004e-01f,
  1.88877836e-01f, 1.50934070e-01f, 1.28601700e-01f, -1.93934068e-01f, -9.02702212e-02f, 1.25894234e-01f, 3.20579507e-03f, 2.00697839e-01f, 2.69098394e-02f, -1.44084156e-01f,
  1.83582395e-01f, 7.81045929e-02f, -9.76720303e-02f, -7.38976523e-02f, -5.32931760e-02f, 2.34337747e-01f, -1.60631955e-01f, 6.13063425e-02f, -1.87575981e-01f, -6.60637766e-02f,
  7.10945949e-02f, -1.08398996e-01f, 6.91981837e-02f, -1.35385334e-01f, 2.11113274e-01f, -3.11333299e-01f, -7.22589493e-02f, 9.66217071e-02f, -8.83015692e-02f, -2.33730808e-01f,
  -4.42716300e-01f, 8.30991447e-01f, -6.47238553e-01f, 1.08308516e-01f, -1.79537445e-01f, 2.70601839e-01f, 6.53829798e-02f, 1.10943124e-01f, -2.84615397e-01f, -1.38696328e-01f,
  -8.18855762e-02f, -1.73627660e-01f, -1.89162359e-01f, 3.46177556e-02f, -1.98365688e-01f, -1.31152838e-01f, 1.12029448e-01f, -2.12232947e-01f, -3.46957445e-02f, 1.63834035e-01f,
  3.37296426e-02f, -4.52824056e-01f, -9.79735792e-01f, -5.51279187e-01f, -6.14155717e-02f, -5.32536209e-01f, -8.01176786e-01f, -4.18965071e-01f, -1.18186247e+00f, -1.58528173e+00f,
  -1.00375986e+00f, 1.34402558e-01f, 5.76954961e-01f, -7.07936347e-01f, 7.91763842e-01f, 9.66556072e-01f, 1.50136065e+00f, 1.88320115e-01f, -5.23800492e-01f, 8.19182396e-02f,
  -9.24955681e-03f, -4.81121659e-01f, -4.43928331e-01f, -3.77958536e-01f, -5.52052446e-02f, 6.39413953e-01f, 2.38841087e-01f, -7.96855316e-02f, 2.86314070e-01f, 3.50004643e-01f,
  -1.28039166e-01f, -3.04884106e-01f, -5.64804375e-01f, -3.87735605e-01f, -9.11688507e-02f, -8.28388240e-03f, -3.85964736e-02f, -1.07691363e-01f, 8.40357766e-02f, -2.99697489e-01f,
  3.08928400e-01f, -3.06241244e-01f, -5.23788892e-02f, -3.72487217e-01f, -7.75548890e-02f, -3.85744661e-01f, 3.66247334e-02f, -1.56581655e-01f, -6.59435093e-02f, -3.39344218e-02f,
  -2.49850765e-01f, -1.73906714e-01f, 5.05296364e-02f, 2.63722204e-02f, 9.71689001e-02f, 2.56437436e-02f, -2.51470983e-01f, -2.87739426e-01f, -4.02286679e-01f, -1.37482688e-01f,
  -1.31136194e-01f, 1.46928281e-01f, 2.59227604e-01f, 1.47759184e-01f, -1.47332311e-01f, -1.86076388e-01f, -8.23654234e-02f, -2.42360130e-01f, -1.49176180e-01f, -3.16693783e-01f,
  5.86539730e-02f, 1.13439254e-01f, 1.03535697e-01f, 1.01323888e-01f, -6.37778938e-02f, 5.66185080e-02f, 7.50118047e-02f, 1.81160092e-01f, 4.08290662e-02f, 1.00147426e-01f,
  1.34087667e-01f, 1.21450111e-01f, 5.55261038e-02f, 5.59840538e-02f, -3.02210469e-02f, -1.02930795e-02f, 5.99825531e-02f, -7.76449069e-02f, 2.51778997e-02f, -1.57214880e-01f,
  -2.30431184e-02f, -1.43852951e-02f, -9.38865766e-02f, -1.24288723e-02f, 9.26051736e-02f, -1.34701028e-01f, -5.97945563e-02f, -1.72589775e-02f, -8.20016414e-02f, -1.16861098e-01f,
  -8.68903324e-02f, 1.00956894e-01f, 1.16928509e-02f, -2.49917936e-02f, 1.81474075e-01f, -1.24649033e-01f, 1.22066140e-01f, -7.27049336e-02f, 4.77918908e-02f, 8.29350501e-02f,
  6.54379353e-02f, 8.43827054e-02f, 1.66011006e-01f, 9.52488780e-02f, 2.68699110e-01f, 1.21314861e-01f, -1.24182887e-01f, 1.46275684e-01f, -2.45047852e-01f, -1.09483182e-01f,
  -7.29471594e-02f, 6.43309429e-02f, 2.75290459e-01f, 1.25047624e-01f, -8.29625800e-02f, 2.65085727e-01f, 3.91139656e-01f, 1.39840737e-01f, 3.01190525e-01f, 3.03802967e-01f,
  9.54900146e-01f, 5.79652607e-01f, -1.83535501e-01f, 7.65919447e-01f, 3.76355648e-01f, 9.99136344e-02f, -1.56426467e-02f, -2.16264352e-02f, 2.64552981e-01f, 4.63641733e-01f,
  4.01708782e-01f, 6.31085455e-01f, 3.16582352e-01f, 1.97355479e-01f, -3.84712107e-02f, 1.54172584e-01f, 1.83634311e-01f, 4.00168728e-03f, -1.74868390e-01f, 3.06287557e-01f,
  5.85341215e-01f, 7.02630281e-02f, -1.32729053e-01f, 4.12364304e-02f, 4.11659539e-01f, 3.42638433e-01f, -1.49235696e-01f, 1.33043066e-01f, 2.01546252e-01f, 9.32349145e-01f,
  3.57105613e-01f, 1.75814807e-01f, -2.35006120e-02f, 1.19218335e-01f, -5.80263287e-02f, -1.36558548e-01f, -6.63336143e-02f, -3.30047727e-01f, -2.62085110e-01f, -6.45947680e-02f,
  -3.02944332e-02f, 2.14254409e-02f, 2.45427825e-02f, -7.20013529e-02f, -1.83068395e-01f, -2.03726307e-01f, -2.10558504e-01f, -2.21563242e-02f, 1.25187524e-02f, 1.10792801e-01f,
  3.05958569e-01f, 7.12592825e-02f, -2.34316096e-01f, -2.83439666e-01f, 2.24903086e-03f, -2.16835309e-02f, -3.23218971e-01f, 8.27109814e-03f, -2.65212834e-01f, 1.84615359e-01f,
  3.58031392e-01f, 9.03688967e-02f, 9.30309966e-02f, 1.70123622e-01f, 9.94510129e-02f, -4.95877117e-02f, 1.59887880e-01f, 9.19591710e-02f, 1.23898990e-01f, -1.37942925e-01f,
  -1.30810484e-01f, 5.17373011e-02f, -1.47561461e-01f, 1.05207980e-01f, 7.07455501e-02f, -4.51802800e-04f, 9.27982405e-02f, -1.61810331e-02f, -1.72842164e-02f, -1.18045397e-01f,
  6.65870756e-02f, -6.03140856e-04f, -1.26864612e-01f, -1.29701510e-01f, -1.53091148e-01f, -6.01850413e-02f, -4.76560369e-02f, -1.12868376e-01f, -9.05740336e-02f, -5.36345318e-02f,
  -4.72935289e-01f, -2.11016148e-01f, 5.51948309e-01f, 6.43754080e-02f, 9.75241512e-02f, -1.21681415e-01f, 4.04640913e-01f, -3.44918594e-02f, 1.25236623e-02f, 9.31265876e-02f,
  -6.35358021e-02f, -5.63779548e-02f, 9.60715394e-03f, -1.34927720e-01f, -2.60404080e-01f, -1.75415516e-01f, 1.93721578e-02f, 1.58926412e-01f, 9.77771729e-02f, 5.08310366e-03f,
  -8.79144371e-02f, -8.72838050e-02f, -2.31097788e-01f, -5.84015958e-02f, 1.44967049e-01f, -4.49186452e-02f, -3.85873258e-01f, -2.61771858e-01f, -3.14065546e-01f, -2.47385725e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.15518475e+00f, 9.06864345e-01f, 1.64015722e+00f, 6.22826397e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  5.27489901e-01f, -1.12195432e+00f, -1.54027581e-01f, -1.97604918e+00f, -9.33635049e-03f, -2.97273576e-01f, -3.64986986e-01f, -5.27939908e-02f, -1.24355006e+00f, -9.13917065e-01f,
  1.20776415e+00f, -2.28837550e-01f, 1.06181279e-01f, 6.00085735e-01f, -1.41920900e+00f, -1.17951643e+00f, -2.16695404e+00f, -1.83866277e-01f, -1.59541637e-01f, -4.40840930e-01f,
  9.11633223e-02f, 5.59827745e-01f, -2.34727454e+00f, 1.00373101e+00f, -1.21815491e+00f, -6.02719963e-01f, 1.62619531e+00f, 7.87978053e-01f, 4.38767791e-01f, -1.58083022e+00f,
  -6.97387278e-01f, 5.25232017e-01f, 1.18570733e+00f, 8.22949708e-01f, 3.92165929e-01f, 6.89257801e-01f, 9.19865549e-01f, 8.27654600e-01f, -8.51360500e-01f, 9.18561637e-01f,
  7.94555366e-01f, 1.23127055e+00f, 1.64119864e+00f, 8.67633402e-01f, -1.72739577e+00f, 7.71269262e-01f, -1.43738413e+00f, -1.40629506e+00f, -5.19781351e-01f, 6.75417662e-01f,
  -2.44387373e-01f, 4.85114045e-02f, -1.53657913e-01f, -2.41166615e+00f, 1.40009296e+00f, -9.82510075e-02f, 1.38941288e+00f, -1.18278396e+00f, 7.90658593e-01f, -8.55187654e-01f,
  -2.54358232e-01f, 5.07277906e-01f, 5.52034378e-01f, -1.97701287e+00f, -1.19987035e+00f, -4.42258745e-01f, 1.34282500e-01f, 1.60302055e+00f, 2.30726153e-01f, 4.06760961e-01f,
  1.39697170e+00f, 1.63679793e-01f, 1.03875649e+00f, 6.00304484e-01f, -9.44055378e-01f, -1.42315161e+00f, 6.90924823e-01f, 9.93949547e-02f, -1.44502842e+00f, -1.05853239e-02f,
  7.33335435e-01f, 1.03792727e+00f, 6.19687498e-01f, -4.61302042e-01f, 6.34600163e-01f, -4.81131703e-01f, -1.00960636e+00f, -1.06010032e+00f, -2.36605555e-01f, -1.60323954e+00f,
  -1.80109918e+00f, 7.63546824e-01f, 6.41373515e-01f, -8.60259116e-01f, -5.40730417e-01f, -6.52030408e-02f, 1.74632227e+00f, 4.88255650e-01f, 9.98296797e-01f, -6.15044832e-01f,
  -2.74739444e-01f, 1.18449426e+00f, 3.30359131e-01f, -1.47407544e+00f, -9.76047575e-01f, 1.28120351e+00f, -1.36284578e+00f, 1.07927501e+00f, -1.26658857e+00f, -1.86948669e+00f,
  -2.20760918e+00f, 1.19009890e-01f, -7.52184689e-01f, -9.53956246e-01f, -1.55319178e+00f, 3.78360897e-01f, -3.20203543e-01f, 2.58717269e-01f, 1.63882697e+00f, -4.62986017e-03f,
  3.84829529e-02f, -4.11065698e-01f, 8.35000455e-01f, -6.76165283e-01f, -2.00455475e+00f, 5.00432611e-01f, 2.19783992e-01f, 3.06391627e-01f, 4.36376482e-01f, -6.41461968e-01f,
  -1.13590014e+00f, 2.01064453e-01f, 6.01498485e-01f, 1.11993957e+00f, -7.41819143e-01f, -6.49474740e-01f, -9.33466971e-01f, -1.04443562e+00f, -3.61672550e-01f, 4.57269192e-01f,
  -1.70934951e+00f, -5.19816875e-01f, 1.08753872e+00f, -5.50090790e-01f, -9.86359566e-02f, -9.64737311e-02f, 9.65029955e-01f, 9.82005522e-02f, -1.07008435e-01f, -6.79257154e-01f,
  2.32274127e+00f, 1.81920481e+00f, 2.61675954e-01f, 8.94641280e-01f, -1.27030087e+00f, 1.82368827e+00f, -5.75656176e-01f, 4.52344060e-01f, -1.01864481e+00f, 7.42083415e-02f,
  -6.90110326e-02f, -1.33659422e-01f, 3.82730901e-01f, 8.35709751e-01f, -6.38238728e-01f, 4.32672888e-01f, 1.82644796e+00f, 7.07004189e-01f, -4.57133442e-01f, 9.35951173e-01f,
  9.91851032e-01f, 1.37755454e-01f, 3.04997951e-01f, -1.28062391e+00f, 7.14538217e-01f, -1.25553524e+00f, -6.62206262e-02f, 4.65508066e-02f, 6.66329324e-01f, 4.62826431e-01f,
  -8.88162911e-01f, -1.46934927e+00f, -1.96737170e+00f, -5.86101353e-01f, 9.08979475e-01f, 1.14845800e+00f, -8.02858412e-01f, -1.72963560e+00f, -1.22786975e+00f, -1.64486602e-01f,
  5.18460453e-01f, -1.22558892e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  3.21340740e-01f, 3.42898190e-01f, 9.77536917e-01f, -3.69226277e-01f, -2.47073397e-01f, -1.31986544e-01f, 3.48046333e-01f, -3.64881694e-01f, -1.32054597e-01f, -2.41547197e-01f,
  -5.61351597e-01f, 2.19029803e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    