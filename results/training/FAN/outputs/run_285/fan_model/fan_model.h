/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.30193248e-01f, -4.01456654e-02f, 2.51492471e-01f, 7.36524463e-02f, -5.17308079e-02f, -3.14314030e-02f, 2.78687865e-01f, -9.53727067e-02f, 2.37110317e-01f, -1.27472961e-02f,
  -2.72477180e-01f, 7.90364444e-02f, 8.08295757e-02f, -1.84635743e-01f, -1.57342315e-01f, 5.29581048e-02f, -1.46768525e-01f, -1.33125158e-02f, 1.00054674e-01f, -9.46322009e-02f,
  7.03006461e-02f, -2.63621241e-01f, -2.35329978e-02f, -2.33163625e-01f, -5.37832789e-02f, 3.81707251e-02f, -2.15721935e-01f, 6.14122562e-02f, -2.55022734e-01f, -6.48564398e-02f,
  -6.66883066e-02f, -4.13477235e-02f, 5.24092168e-02f, 9.24218595e-02f, -7.09615871e-02f, -3.19550149e-02f, 1.04335621e-01f, -2.40246914e-02f, 3.82015444e-02f, 9.26651433e-03f,
  6.36315048e-02f, 1.69638521e-03f, 2.17138859e-03f, 1.71108153e-02f, 2.95886677e-03f, 2.39270832e-02f, 3.93402167e-02f, 3.44216190e-02f, 5.56433126e-02f, 3.97220738e-02f,
  5.50588593e-02f, -1.23876873e-02f, 2.65804809e-02f, 4.83593484e-03f, -1.99427158e-02f, -6.60552469e-04f, -5.79801481e-03f, 4.46267128e-02f, 2.70905029e-02f, 3.81480134e-03f,
  2.52703428e-02f, 6.46016002e-02f, -5.24308346e-02f, -3.13246576e-03f, -4.75052334e-02f, -4.26514670e-02f, -1.10695523e-03f, -7.48245418e-02f, 5.84897362e-02f, 7.57573592e-03f,
  -7.60278329e-02f, 6.94867224e-03f, 5.35115711e-02f, 3.05469837e-02f, -2.11119018e-02f, 3.32832374e-02f, -1.49094844e-02f, -7.89023116e-02f, 3.36831696e-02f, -5.75170293e-02f,
  8.79425928e-02f, -3.86586934e-02f, -9.74010155e-02f, 3.15579437e-02f, -4.20021974e-02f, -1.35171143e-02f, 5.82831970e-04f, 4.66245897e-02f, 5.98529875e-02f, 3.68683180e-03f,
  -2.09211558e-01f, -1.01624981e-01f, 1.34764621e-02f, -5.64407511e-03f, -3.98629047e-02f, -4.44474146e-02f, 4.80951294e-02f, -5.32349832e-02f, -8.61686990e-02f, -5.64403795e-02f,
  1.14727439e-02f, -1.03976233e-02f, -5.58555909e-02f, 3.93020734e-02f, 2.98462529e-02f, -5.43092825e-02f, 3.75806838e-02f, -1.50920982e-02f, -3.22293565e-02f, -1.61398631e-02f,
  -3.67025658e-02f, -4.58812490e-02f, -1.14616286e-03f, -7.20603466e-02f, -3.71438041e-02f, -3.26887332e-02f, 2.01101322e-02f, 2.44843531e-02f, -4.26763706e-02f, 6.17511496e-02f,
  -2.99214572e-01f, 3.39160860e-01f, -1.17633371e-02f, 3.57149661e-01f, -3.08822542e-01f, -2.20524460e-01f, -4.43007536e-02f, -3.07182241e-02f, -2.23979577e-01f, 1.53353140e-01f,
  -7.14117810e-02f, 1.08461499e-01f, 5.90080954e-02f, 1.77605107e-01f, -1.47650987e-01f, 1.34342268e-01f, -4.81260084e-02f, 6.47481903e-02f, 3.20436209e-02f, 6.75853565e-02f,
  7.52288774e-02f, 2.51631439e-02f, 1.54203385e-01f, -3.72185335e-02f, -1.10286865e-02f, 4.32279259e-02f, 3.06666475e-02f, 3.45442593e-02f, 4.34060171e-02f, -9.01558176e-02f,
  -1.16262183e-01f, 2.73799710e-02f, 1.14599345e-02f, 3.99102606e-02f, -7.36968406e-03f, -3.34485318e-03f, 5.21588549e-02f, -2.50494517e-02f, 3.19912657e-02f, 5.01681753e-02f,
  6.66897884e-03f, -2.27397494e-02f, -2.61168294e-02f, -7.97492638e-03f, -4.29572426e-02f, 6.44013733e-02f, 1.67357326e-02f, -3.66045684e-02f, 5.65732755e-02f, 2.50177067e-02f,
  3.62692252e-02f, 2.25286689e-02f, -2.16171220e-02f, 2.76331268e-02f, -4.67377855e-03f, 9.53307375e-02f, 2.75894124e-02f, 8.31648533e-04f, -2.81117801e-02f, -5.57555556e-02f,
  -9.15462710e-03f, 7.96370134e-02f, -6.26030425e-03f, 4.05297913e-02f, -1.17910430e-02f, -4.34033647e-02f, 1.17911017e-02f, -5.95585583e-03f, 1.64538510e-02f, 1.52153252e-02f,
  -3.55138034e-02f, 2.05082912e-02f, -5.91197573e-02f, 1.05382013e-03f, 4.15363126e-02f, -4.66632806e-02f, -8.56141746e-03f, 1.95469521e-02f, -7.98007380e-03f, -3.60059552e-02f,
  -1.81275085e-02f, 3.70251713e-03f, -2.49474831e-02f, -1.54898604e-02f, 5.76677732e-03f, 4.50631268e-02f, 4.59576398e-03f, 9.36481077e-03f, 2.39000171e-02f, -1.31817795e-02f,
  8.02660435e-02f, 6.45596087e-02f, 4.34091799e-02f, -9.79229808e-03f, 4.14818525e-02f, -1.47104738e-02f, 4.09723818e-02f, -6.67080656e-02f, 3.21215503e-02f, -1.83259454e-02f,
  -8.45041499e-03f, 1.90405026e-02f, -8.04409850e-03f, 1.54521521e-02f, 4.64635566e-02f, -3.04354150e-02f, 8.58774260e-02f, 4.29002866e-02f, 4.62598773e-03f, 1.22690387e-02f,
  1.51001774e-02f, -4.88241501e-02f, 3.97909321e-02f, -6.80505484e-02f, 3.90334334e-03f, -5.82872331e-02f, -8.28278530e-03f, -4.62564491e-02f, -3.87344174e-02f, 2.54243631e-02f,
  -2.58384526e-01f, -1.07562833e-01f, -1.38496771e-01f, -1.17719389e-01f, -1.49883345e-01f, 1.61649715e-02f, 6.44811764e-02f, -1.62323400e-01f, -1.42588079e-01f, 1.51833415e-01f,
  4.44889590e-02f, -1.37061611e-01f, 1.68814704e-01f, 5.20742498e-02f, 1.22635201e-01f, 2.61975884e-01f, 9.36001241e-02f, 5.88578498e-03f, -7.75591135e-02f, -1.77092969e-01f,
  -3.62142622e-02f, 2.77991779e-03f, 1.09924132e-03f, -1.00857496e-01f, -9.17536169e-02f, -1.97847530e-01f, -6.00749552e-02f, -1.13054812e-01f, 3.17744724e-02f, 1.43309338e-02f,
  -1.30390480e-01f, -9.19462591e-02f, -1.50966048e-01f, -2.80931517e-02f, 3.83113585e-02f, -5.26854135e-02f, 2.15615910e-02f, -2.49109871e-04f, 4.10413602e-03f, 1.78439133e-02f,
  1.05617773e-02f, -4.84830141e-03f, 5.03901392e-02f, -1.94254108e-02f, -8.45998749e-02f, -1.04472898e-01f, -1.00281136e-02f, 1.72646102e-02f, -1.16901055e-01f, 2.11145766e-02f,
  -1.59787051e-02f, 8.90276805e-02f, -1.52825760e-02f, 4.44767810e-02f, -6.25401586e-02f, -2.45902520e-02f, 8.07600841e-02f, 3.08217723e-02f, -6.25498407e-03f, -6.79198876e-02f,
  1.12950869e-01f, -6.72948360e-02f, -7.89953470e-02f, -7.08728731e-02f, -1.69192106e-02f, -2.07325574e-02f, -2.07723584e-02f, -8.24145973e-03f, -6.69593215e-02f, -2.74790172e-02f,
  -2.19131596e-02f, -5.03813885e-02f, 3.63505036e-02f, 2.63942033e-03f, 6.75048530e-02f, -2.34254543e-02f, 3.26274112e-02f, 4.65233140e-02f, 4.92170118e-02f, -4.42709625e-02f,
  -1.58765018e-02f, -7.21753091e-02f, 1.10640451e-02f, 3.73318009e-02f, -7.36295208e-02f, 3.08467261e-02f, -1.35871265e-02f, 2.27128547e-02f, -1.46413203e-02f, -1.17892046e-02f,
  -1.86866850e-01f, -2.45228827e-01f, -1.97553597e-02f, -3.24650370e-02f, -8.30408409e-02f, 4.15941365e-02f, 1.20434249e-02f, 1.05197644e-02f, -4.90507036e-02f, 4.88894247e-02f,
  -5.02777472e-02f, -3.80072556e-02f, 2.67049093e-02f, 7.46852681e-02f, 7.57790506e-02f, 7.52911419e-02f, 5.05656609e-03f, -8.92712269e-03f, -1.95810068e-02f, -2.34375261e-02f,
  -3.40961777e-02f, -4.35408554e-04f, -2.77551655e-02f, -1.39853265e-02f, 5.75353615e-02f, 5.04488721e-02f, -1.11426152e-01f, -1.79677233e-02f, 5.59237264e-02f, 5.46381697e-02f,
  -4.57629383e-01f, 2.40862221e-01f, -4.51320270e-03f, 2.94214878e-02f, 2.63466574e-02f, -1.63854107e-01f, -6.77211285e-02f, 1.36478320e-01f, 8.29074904e-02f, 2.66434979e-02f,
  -2.93341149e-02f, -2.21418701e-02f, 1.64048113e-02f, 3.06536201e-02f, -1.42913209e-02f, 2.43404880e-01f, 1.61414277e-02f, -7.71248192e-02f, -4.56529111e-02f, -5.26868924e-02f,
  -8.24079663e-03f, 7.52618397e-03f, -1.07930273e-01f, 1.41290188e-01f, -1.76801980e-01f, -1.83946386e-01f, 1.01281464e-01f, -2.13440899e-02f, -9.89575908e-02f, 1.45624176e-01f,
  -4.53765839e-02f, -1.21837109e-02f, -5.26779816e-02f, 2.83285999e-03f, -1.40441656e-01f, -1.08203210e-01f, 2.74367421e-03f, 3.79105378e-03f, -7.93906450e-02f, -8.90972242e-02f,
  -2.27321312e-02f, -1.42559651e-02f, -5.20689748e-02f, 5.24500236e-02f, 2.00200789e-02f, -5.21573611e-02f, -2.93366034e-02f, 4.66656126e-02f, -2.69274469e-02f, -8.27575475e-02f,
  -4.03169133e-02f, -9.27663222e-02f, -1.63812730e-02f, -4.50843200e-02f, -1.44843140e-03f, -1.01873137e-01f, -6.93568066e-02f, -2.28255875e-02f, 4.18606885e-02f, 3.02982591e-02f,
  -2.68873479e-02f, -7.07750544e-02f, 1.26360049e-02f, -6.20873757e-02f, 3.56959514e-02f, 3.31855416e-02f, 2.91274562e-02f, -9.14648622e-02f, 1.36466287e-02f, -4.72121984e-02f,
  -1.21399723e-01f, 4.52208593e-02f, -8.46972410e-03f, 1.28005557e-02f, 2.35346314e-02f, -5.23833977e-03f, 7.21407086e-02f, -1.30692184e-01f, -3.94815169e-02f, -7.78370129e-04f,
  4.13580872e-02f, -1.76276434e-02f, -4.99093160e-02f, 3.18155140e-02f, -7.60811474e-03f, -1.09610729e-01f, 3.62790860e-02f, 5.07614994e-03f, -1.41019337e-02f, 1.39383972e-02f,
  -5.96348662e-03f, 1.65094540e-01f, -4.82660420e-02f, -8.49290043e-02f, 4.02510464e-02f, 1.83612928e-02f, 2.82984804e-02f, 3.28063630e-02f, 2.34164018e-02f, 2.20575482e-02f,
  -5.79475723e-02f, -5.57436869e-02f, 4.46976572e-02f, -2.52285711e-02f, 1.36045367e-02f, 1.74791319e-03f, -2.82929167e-02f, -2.24543530e-02f, 2.20422987e-02f, -8.89099017e-03f,
  -4.02524648e-03f, 2.35280674e-02f, -7.74708316e-02f, 1.62081849e-02f, -1.87992398e-02f, 4.37689126e-02f, 3.82647179e-02f, -5.40497303e-02f, 1.44815957e-02f, 1.61474440e-02f,
  -1.73447356e-02f, 3.09552252e-01f, -4.03413139e-02f, 1.65500969e-01f, 8.92996714e-02f, 1.19803816e-01f, 1.02840498e-01f, 1.99713841e-01f, 2.43895993e-01f, 1.86994806e-01f,
  4.84100282e-02f, 1.77369401e-01f, 1.83604255e-01f, 9.76312235e-02f, 1.20487742e-01f, 2.00223103e-01f, -5.73407523e-02f, -5.95601881e-03f, 5.71317337e-02f, 4.20820042e-02f,
  -3.43877673e-02f, 2.89424993e-02f, 2.90203486e-02f, 3.69528197e-02f, 3.00677624e-02f, 2.02436149e-02f, -1.27670497e-01f, -6.16324544e-02f, -2.58965231e-03f, -8.01612362e-02f,
  -6.94980100e-02f, 4.21768390e-02f, -4.39806432e-02f, -2.36085914e-02f, -7.30222673e-04f, -7.24074990e-02f, -8.88233483e-02f, -9.79751274e-02f, 8.84323791e-02f, 1.04978895e-02f,
  -1.51776746e-02f, 2.51979847e-02f, -1.41421556e-02f, -6.45163879e-02f, 5.68778180e-02f, -1.36176609e-02f, -3.65377292e-02f, -3.27012851e-03f, 4.11450043e-02f, 7.61304274e-02f,
  4.21804152e-02f, -1.63202416e-02f, -2.43253261e-02f, -3.18414718e-02f, 2.75535363e-04f, 2.98451018e-02f, 4.15465422e-02f, 1.41408965e-02f, 4.43802960e-02f, 6.17921073e-03f,
  -4.52584252e-02f, -5.42415248e-04f, -2.14726720e-02f, -2.51920763e-02f, 1.58516821e-02f, -6.72890022e-02f, 2.88351774e-02f, -1.35933682e-02f, -5.59160672e-02f, 9.44759883e-03f,
  2.30753087e-02f, 8.95198341e-03f, -3.31326798e-02f, 6.03493378e-02f, -4.61144000e-02f, -5.38938977e-02f, 7.57899368e-04f, -8.69962294e-03f, -3.79487127e-02f, 4.58285436e-02f,
  3.12833786e-02f, 3.71739231e-02f, 1.73927960e-03f, 4.80237696e-03f, -1.61791146e-02f, 3.47558744e-02f, -2.97796205e-02f, 2.60384753e-02f, -2.25660857e-02f, 1.85620412e-03f,
  1.00668415e-01f, -7.30832992e-03f, 2.81271227e-02f, 7.05333706e-03f, -1.42555637e-02f, 6.19186573e-02f, 1.06390584e-02f, 2.51188651e-02f, -2.85651465e-03f, -4.41267788e-02f,
  -4.14317772e-02f, -2.16609612e-02f, -6.68987036e-02f, -2.89662834e-02f, -5.19974791e-02f, 3.39008905e-02f, 5.19175897e-04f, -3.69848423e-02f, -8.76579285e-02f, 5.47751645e-03f,
  -1.51982186e-02f, 5.30857332e-02f, -2.17412077e-02f, 8.99731647e-03f, 2.41416506e-02f, -1.12176225e-01f, -3.19696334e-03f, 3.06237885e-03f, 1.80808995e-02f, 1.74071230e-02f,
  4.71484572e-01f, 3.68782640e-01f, 3.01884972e-02f, 3.54633808e-01f, -5.24149388e-02f, 8.09290707e-02f, 5.65426201e-02f, 8.68803188e-02f, 5.86664900e-02f, 2.78464705e-01f,
  3.78538147e-02f, 1.52514368e-01f, 1.80015769e-02f, 2.00697199e-01f, -1.03071138e-01f, 1.10856183e-01f, 2.32901305e-01f, 1.38130650e-01f, 4.35429305e-04f, 1.08470991e-01f,
  -3.08294371e-02f, 1.42787501e-01f, -1.25701889e-01f, 1.60734716e-03f, -6.59717321e-02f, 3.00246617e-03f, 1.46461334e-02f, -7.35908374e-02f, 3.48689184e-02f, 3.96188460e-02f,
  -1.15163222e-01f, 7.63552412e-02f, 1.85280498e-02f, 4.83863838e-02f, 4.38161418e-02f, 2.76238099e-02f, -3.91872376e-02f, -3.43297794e-02f, -3.14334482e-02f, -3.10442280e-02f,
  1.47118717e-02f, -3.13456804e-02f, 4.86861132e-02f, 9.75076342e-04f, 3.62870260e-03f, -6.78367093e-02f, -3.21330614e-02f, 1.24101331e-02f, -2.47811116e-02f, -4.57330868e-02f,
  -2.14477871e-02f, 2.20764312e-03f, 6.92249974e-03f, 3.40147465e-02f, -4.46200408e-02f, -9.89724416e-03f, -2.19153333e-03f, -6.88868994e-03f, -1.69472955e-02f, 4.73779552e-02f,
  6.68163132e-03f, -5.22499019e-03f, -5.27771078e-02f, -2.83310935e-02f, 2.36055329e-02f, 8.67399853e-03f, 1.48255005e-02f, 1.06208557e-02f, 1.35352118e-02f, -4.31919508e-02f,
  3.67087908e-02f, -2.23694071e-02f, 1.29817948e-02f, 3.39404903e-02f, 6.49558082e-02f, 2.47211531e-02f, 4.67987657e-02f, 5.97694190e-03f, 5.76499142e-02f, -3.75203118e-02f,
  -4.55663763e-02f, 3.23108248e-02f, 2.34045405e-02f, -6.92832172e-02f, -4.74513844e-02f, 1.97390895e-02f, 7.59316087e-02f, 9.33978066e-04f, -3.87872495e-02f, -3.28240059e-02f,
  4.48085032e-02f, 1.19658835e-01f, -4.26620692e-02f, -5.80141954e-02f, 1.88927185e-02f, -1.49481883e-03f, -1.84129030e-02f, 3.36500518e-02f, -3.66564915e-02f, 8.63521267e-03f,
  3.94331105e-02f, 2.49013137e-02f, 2.72014346e-02f, 2.02187011e-03f, -1.91043019e-02f, 2.31140405e-02f, 2.26846375e-02f, 3.85751724e-02f, 5.59305064e-02f, 6.08312665e-03f,
  -4.48064730e-02f, -2.44559273e-02f, -7.28248507e-02f, 1.08810123e-02f, -3.86122689e-02f, -6.58588624e-03f, 1.82110984e-02f, 4.30883616e-02f, -4.01458293e-02f, -9.40037239e-03f,
  3.87728781e-01f, 1.89323977e-01f, 1.82290539e-01f, 3.40549111e-01f, -1.08336195e-01f, 3.07022110e-02f, 2.79275179e-02f, 4.80463468e-02f, 1.62545994e-01f, -9.35509149e-03f,
  -1.25113964e-01f, 1.18774958e-01f, -9.97450054e-02f, 5.72701432e-02f, -7.50793144e-02f, -8.29429477e-02f, 1.09492809e-01f, 9.99804735e-02f, 1.62328072e-02f, 1.94372255e-02f,
  9.74797383e-02f, -6.55734465e-02f, -4.89630885e-02f, -3.80592495e-02f, 8.59146938e-02f, 1.36662379e-01f, -1.02200232e-01f, -1.54768690e-01f, 1.43383920e-01f, -2.99639404e-02f,
  -2.74559017e-02f, 1.32099763e-01f, 4.17189151e-02f, -6.52134372e-03f, 1.32713262e-02f, 5.64562203e-03f, -8.40462092e-03f, -4.68926206e-02f, 7.25343376e-02f, 1.50873503e-02f,
  3.02439295e-02f, -3.62644494e-02f, 3.19005139e-02f, 6.22313619e-02f, 4.73587215e-02f, 1.60718020e-02f, -1.75023377e-02f, 9.50317383e-02f, 7.88010831e-04f, 7.76758343e-02f,
  1.06878288e-01f, 5.58994412e-02f, 7.00169802e-02f, -1.72019619e-02f, -2.83520930e-02f, -3.17754038e-02f, -1.69517025e-02f, 1.28878169e-02f, 7.83570483e-02f, 2.87505575e-02f,
  3.02698612e-02f, -8.40850547e-02f, -1.39701450e-02f, -3.01977079e-02f, 2.76617147e-02f, -1.28995301e-02f, -6.18730066e-03f, -6.53446317e-02f, -1.42497141e-02f, -3.55966203e-02f,
  -4.36350107e-02f, 2.62860395e-02f, 2.99954005e-02f, 3.90733033e-02f, 6.13508150e-02f, 8.89086127e-02f, -3.56552266e-02f, 6.08060360e-02f, 5.40206172e-02f, 2.69979145e-02f,
  3.10963765e-02f, -6.53408095e-02f, -4.31527458e-02f, 1.32438336e-02f, 9.88110993e-03f, -5.15658818e-02f, -1.40443852e-03f, 8.39588568e-02f, -6.66359663e-02f, 9.01018735e-03f,
  -4.89115417e-02f, 1.80718988e-01f, -1.43521735e-02f, -3.74792926e-02f, -5.50258607e-02f, 1.18407970e-02f, 3.56982313e-02f, 1.30363004e-02f, -1.36362286e-02f, 1.95504986e-02f,
  -3.25113051e-02f, 1.93773229e-02f, -1.51826693e-02f, -4.14788797e-02f, 5.05856723e-02f, 2.04881392e-02f, 2.98904814e-02f, -5.62793529e-03f, 8.82418826e-04f, 2.91007403e-02f,
  1.31082721e-02f, 1.72042158e-02f, -2.53628697e-02f, 9.02669271e-04f, 1.44621134e-02f, 6.15388528e-02f, 6.36084080e-02f, 5.26588000e-02f, -9.79173370e-03f, 3.36074978e-02f,
  2.92708457e-01f, -1.20917529e-01f, -1.70117617e-01f, 7.10057840e-02f, 9.19791162e-02f, -1.25127718e-01f, -2.11298913e-01f, 1.16012350e-01f, -3.29787545e-02f, 9.42772161e-03f,
  3.73329222e-02f, -9.70052034e-02f, -1.85566768e-01f, -6.46631792e-03f, -1.02205709e-01f, -2.50983626e-01f, 8.09742883e-02f, -3.10604498e-02f, -6.47018179e-02f, 4.81286198e-02f,
  6.42787740e-02f, 1.10851549e-01f, -1.23880446e-01f, 1.18702456e-01f, 8.38129297e-02f, 3.92203815e-02f, 1.37184173e-01f, -1.54146224e-01f, 1.36903122e-01f, -1.58327026e-03f,
  -1.18749157e-01f, -9.61045399e-02f, 2.01233737e-02f, -2.86995135e-02f, -4.01688255e-02f, 2.01078989e-02f, 8.40733759e-03f, -6.75080111e-03f, 2.94474594e-04f, 3.73848118e-02f,
  1.21136792e-02f, -6.26660883e-03f, 6.08635657e-02f, 9.70500335e-03f, 5.43154441e-02f, -6.47304021e-03f, -2.14938167e-02f, -1.20259179e-02f, -1.13507053e-02f, -6.26786947e-02f,
  -7.36777410e-02f, -3.44609320e-02f, 4.55412408e-03f, 1.85903795e-02f, -8.41092411e-03f, 2.55165417e-02f, -1.49784973e-04f, -7.77477995e-02f, 6.71856152e-03f, -3.73135731e-02f,
  5.26028164e-02f, 3.06065045e-02f, 1.26265138e-02f, 6.26464561e-02f, -4.94420752e-02f, 6.69184849e-02f, 1.42528247e-02f, 1.11834668e-02f, 5.79151092e-03f, 1.11731524e-02f,
  -2.75326669e-02f, 3.37510221e-02f, -1.87234452e-03f, 6.29178435e-03f, 3.73527519e-02f, 2.62790117e-02f, 2.93621868e-02f, -4.11113687e-02f, -2.91704480e-02f, 5.78216761e-02f,
  4.90072928e-02f, -1.16175022e-02f, -7.39115700e-02f, 4.64442782e-02f, 2.62295660e-02f, -4.32747267e-02f, 4.27130274e-02f, -9.65755375e-04f, 5.40451817e-02f, 4.73268097e-03f,
  -2.16328613e-02f, 3.37803625e-02f, -3.21146697e-02f, 5.40552586e-02f, -2.14111451e-02f, 4.27213721e-02f, 7.92081561e-03f, 4.25051106e-03f, -1.44241760e-02f, -6.75621554e-02f,
  6.69796616e-02f, -3.81302508e-03f, -1.72999059e-03f, 1.61546655e-02f, 2.55407710e-02f, -5.59296235e-02f, 3.57118994e-02f, 1.84849985e-02f, 5.09072058e-02f, 2.50018877e-03f,
  7.55565614e-02f, 5.16074523e-02f, 1.10934544e-02f, 4.38457318e-02f, 3.93447690e-02f, -7.37581030e-02f, 5.97429425e-02f, -5.71668036e-02f, 1.98817644e-02f, -1.14367576e-02f,
  1.22699641e-01f, -6.81414381e-02f, 1.67968590e-02f, -9.20321271e-02f, -9.91925318e-03f, 1.76266000e-01f, 1.86356395e-01f, -3.94213665e-03f, 4.35803384e-02f, -8.54875594e-02f,
  -3.11928242e-02f, -1.61851719e-02f, 6.22235090e-02f, 1.71241388e-02f, 2.92739183e-01f, 1.18986309e-01f, 5.48082478e-02f, 8.30761269e-02f, 3.41028199e-02f, -2.18076166e-02f,
  4.06977013e-02f, -5.22020347e-02f, -2.70841960e-02f, -1.58714235e-01f, -1.49962887e-01f, -1.30326971e-01f, -1.29683996e-02f, -1.22079797e-01f, -1.64379150e-01f, 2.83040293e-02f,
  9.09622684e-02f, 1.16667273e-02f, -2.78971214e-02f, -2.11456679e-02f, -2.15456914e-03f, 5.49030639e-02f, 2.63797678e-02f, 3.40319276e-02f, -2.25191675e-02f, -6.24041073e-03f,
  4.15970385e-02f, -1.45017793e-02f, -4.81196158e-02f, 5.67923188e-02f, 5.41975386e-02f, -5.68511561e-02f, -2.00607302e-03f, -6.69808388e-02f, -7.20154960e-03f, -7.84362704e-02f,
  -4.70691659e-02f, -7.10761128e-03f, -6.11516573e-02f, 1.24974726e-02f, -4.85448204e-02f, -1.13014029e-02f, 6.18938282e-02f, -2.50755511e-02f, -4.44365144e-02f, 4.35751490e-02f,
  8.28758106e-02f, 5.39487116e-02f, 2.94985306e-02f, -9.41554317e-04f, -5.24429120e-02f, -9.18547250e-03f, 8.00705329e-03f, 1.64783616e-02f, -7.84137323e-02f, 2.79529253e-03f,
  -4.48970497e-02f, -5.17911240e-02f, -2.00037882e-02f, -6.85342848e-02f, 9.56655368e-02f, 2.12222580e-02f, 4.50089425e-02f, 2.22763512e-02f, -3.43790255e-03f, 6.89499453e-02f,
  7.05307052e-02f, -3.55466194e-02f, -2.65078098e-02f, 1.85036696e-02f, 4.74708788e-02f, 9.22084227e-03f, -1.37684792e-02f, -1.57606304e-02f, -1.23241972e-02f, 3.98100615e-02f,
  6.51600063e-02f, 5.06531596e-02f, -7.13529345e-03f, 2.98556872e-02f, -2.42217146e-02f, 7.41580129e-03f, -1.33040324e-02f, 1.03998072e-02f, 8.39409009e-02f, -2.52904892e-02f,
  -1.87985487e-02f, -5.82065247e-02f, 9.39595848e-02f, -6.13911077e-02f, 3.22583131e-02f, -3.74642015e-03f, -3.93458316e-03f, -2.93432944e-03f, -1.08392946e-02f, 2.21252032e-02f,
  1.50184464e-02f, 5.01954071e-02f, -1.69772916e-02f, -3.58096659e-02f, 1.55965416e-02f, 4.26382124e-02f, 1.84832942e-02f, -4.65392880e-02f, 5.58296181e-02f, -1.49760619e-02f,
  -3.76084059e-01f, 1.36635348e-01f, 6.89096004e-02f, -8.59569237e-02f, -2.28526220e-02f, -9.32061672e-02f, 1.91393849e-02f, -2.99031306e-02f, 6.99867122e-03f, 6.99853376e-02f,
  -2.42938232e-02f, -5.68137392e-02f, 4.22593951e-02f, -9.84189063e-02f, -3.29312891e-01f, 2.94195451e-02f, -4.44406085e-02f, 3.63047794e-03f, -1.10502141e-02f, -3.41925547e-02f,
  -6.29608035e-02f, -1.87158376e-01f, -3.31004336e-03f, -5.16824871e-02f, 8.09162855e-02f, 1.35120630e-01f, -2.72545200e-02f, 1.36226090e-02f, -7.54074976e-02f, -9.24280584e-02f,
  -2.16113217e-02f, 3.21776681e-02f, 7.92656839e-03f, 4.49211225e-02f, 6.84798062e-02f, 5.08733988e-02f, 4.91009913e-02f, -3.29589248e-02f, 2.13863403e-02f, 4.81192656e-02f,
  2.73337550e-02f, -4.08585817e-02f, -8.47403612e-03f, -4.72904406e-02f, 2.04990227e-02f, -5.06465062e-02f, -4.52007167e-02f, -2.61902786e-03f, -5.12236310e-03f, 3.49440128e-02f,
  4.30686511e-02f, 5.57648987e-02f, 4.69614267e-02f, 2.31978409e-02f, 1.82210375e-02f, -4.16633673e-02f, 8.49140435e-02f, 1.03548635e-02f, -3.60509567e-02f, -2.73328014e-02f,
  5.32575697e-02f, 4.39155102e-02f, 4.92888279e-02f, -6.05724461e-04f, -4.33641672e-02f, -5.72720356e-03f, -3.96518447e-02f, 5.34219071e-02f, -8.75738636e-03f, -5.31122759e-02f,
  3.03691030e-02f, 7.42703583e-03f, -1.90281160e-02f, 6.22515567e-02f, -2.85543269e-04f, 2.98485179e-02f, 7.67709734e-03f, 1.78988725e-02f, 8.56825635e-02f, 2.13512275e-02f,
  1.63176488e-02f, -1.04731657e-02f, 3.03860754e-02f, 3.15223485e-02f, -3.83271612e-02f, 1.79767311e-02f, 7.68441474e-03f, -1.70118492e-02f, 3.49274301e-03f, 4.75603808e-03f,
  8.11953768e-02f, 9.88072250e-03f, -4.26277556e-02f, 5.06268756e-04f, 1.08127072e-02f, 3.75619121e-02f, -1.19374596e-01f, 2.55844817e-02f, 8.98698159e-03f, -3.58504839e-02f,
  8.40441287e-02f, 6.84421137e-02f, 5.87132350e-02f, -9.64426063e-03f, -5.28678037e-02f, 1.89131405e-02f, 3.37596387e-02f, 2.23443806e-02f, -3.46088707e-02f, 1.01138391e-02f,
  7.41794631e-02f, 1.99688077e-02f, -2.85853352e-02f, 1.20440573e-02f, 3.74673121e-02f, 5.92647903e-02f, -4.82839458e-02f, 3.17785181e-02f, 7.21323043e-02f, 1.27285104e-02f,
  -1.33780509e-01f, -6.15088865e-02f, 8.64399690e-03f, -2.50379294e-01f, 3.42414714e-02f, -1.04789473e-01f, -1.46686554e-01f, -3.71572673e-02f, -6.44612238e-02f, 6.60824478e-02f,
  -1.03060827e-01f, 1.43840343e-01f, -2.97708884e-02f, -1.80080131e-01f, -3.47338498e-01f, -1.15783758e-01f, -2.70644963e-01f, -4.69983853e-02f, -1.63841605e-01f, -7.20753968e-02f,
  -1.70427904e-01f, -2.07507700e-01f, -2.30284795e-01f, -2.07269145e-03f, -4.11894433e-02f, 4.73129712e-02f, -1.41363144e-01f, -3.08963377e-02f, 7.07663819e-02f, 2.49316748e-02f,
  -7.24154189e-02f, 3.33180912e-02f, 2.08233282e-01f, 5.14307581e-02f, -6.47123829e-02f, 9.69268903e-02f, 7.39117563e-02f, -2.23530699e-02f, -8.83366540e-03f, -4.81559783e-02f,
  7.64111951e-02f, 7.38536045e-02f, -1.49451410e-02f, 1.81869939e-02f, 8.00859705e-02f, -2.36916840e-02f, -2.52763485e-03f, 4.33892012e-02f, 9.06199068e-02f, 1.49797136e-02f,
  -5.58999926e-02f, -1.75208468e-02f, -1.36187086e-02f, 4.48979996e-02f, -6.89110160e-02f, 2.89962888e-02f, -2.75674835e-02f, -3.58649306e-02f, 4.54435572e-02f, 1.42693594e-02f,
  6.23661019e-02f, -4.99209687e-02f, -3.12104076e-02f, -4.80291508e-02f, -6.00113682e-02f, -1.82407182e-02f, 2.22515166e-02f, -4.79906015e-02f, -5.96559346e-02f, 2.85856277e-02f,
  -3.41314077e-02f, -4.63456754e-03f, -3.68034653e-02f, -5.99001674e-03f, 6.60266355e-02f, 7.27740973e-02f, -9.69589408e-03f, -7.98374880e-03f, 7.65605085e-03f, -3.64094414e-02f,
  -3.56600843e-02f, -3.45159159e-03f, 3.15086276e-04f, -1.26370713e-02f, 3.30846943e-02f, -2.02904437e-02f, -1.51426522e-02f, 7.84695074e-02f, 5.93607919e-03f, -1.15816042e-01f,
  -1.09217837e-01f, -7.77871683e-02f, -8.50851834e-02f, 2.36187465e-02f, 1.68372113e-02f, -3.30906287e-02f, -1.04815856e-01f, 2.68286318e-02f, -7.89183006e-02f, -3.28018703e-02f,
  -1.82333924e-02f, -2.29773689e-02f, -1.91081241e-02f, 9.69852228e-03f, -4.94274348e-02f, -5.03407381e-02f, -5.50483167e-02f, -5.76217135e-04f, -3.80990580e-02f, -4.48029488e-03f,
  3.08600697e-03f, -6.93528280e-02f, -7.14832023e-02f, -2.70073414e-02f, 3.09897158e-02f, -1.85880978e-02f, -5.95526723e-03f, 5.21524772e-02f, 6.20665886e-02f, 5.90523332e-02f,
  2.44123667e-01f, 2.84622699e-01f, -2.41697840e-02f, 2.81045437e-01f, 5.73053099e-02f, 1.78868353e-01f, 1.69217482e-01f, 4.81517054e-02f, -5.27738072e-02f, 1.00639053e-01f,
  2.10319102e-01f, -7.63843730e-02f, 7.02496246e-02f, 2.25692227e-01f, -9.54922736e-02f, 2.12560166e-02f, 1.69897735e-01f, 1.07225902e-01f, -1.13611646e-01f, 7.98211694e-02f,
  -3.19068581e-02f, 2.10019052e-01f, 8.12767893e-02f, 7.38216490e-02f, 1.02729566e-01f, -2.05692481e-02f, 2.68812967e-03f, 4.17948142e-02f, 1.14755511e-01f, 5.90301468e-04f,
  6.13281466e-02f, -3.75635065e-02f, -1.50475372e-03f, -4.48867530e-02f, 2.19474863e-02f, 1.71463042e-02f, 5.80189303e-02f, -3.89678893e-03f, -4.82403822e-02f, 4.30912226e-02f,
  3.30197513e-02f, -1.06129898e-02f, -3.25827710e-02f, -8.86500161e-03f, 9.47109237e-03f, -1.50895845e-02f, 2.12207604e-02f, -2.41697412e-02f, -9.30353720e-03f, -1.01841815e-01f,
  -6.44524619e-02f, -1.09538101e-02f, 3.01399417e-02f, 1.36575941e-02f, -3.28086801e-02f, 5.71860671e-02f, 3.04715820e-02f, -2.42916495e-02f, 2.40288991e-02f, -1.56802684e-02f,
  6.76615462e-02f, 1.26301795e-02f, 5.77037297e-02f, 4.40172702e-02f, -2.31870506e-02f, -5.35071734e-03f, 6.95346901e-03f, 3.81290130e-02f, -6.81977794e-02f, 3.84798832e-02f,
  -2.72089965e-04f, -7.98247196e-03f, -2.29858626e-02f, -4.41259965e-02f, 9.36736073e-03f, 1.51031902e-02f, 2.65504364e-02f, -7.09024724e-03f, 1.33895762e-02f, -2.84349564e-02f,
  -1.20295794e-03f, -1.27274599e-02f, 7.04449937e-02f, 5.32527380e-02f, 2.32279468e-02f, -1.32643688e-03f, -4.63018231e-02f, 1.53304292e-02f, -5.84740937e-02f, -5.44893593e-02f,
  1.51046336e-01f, 5.67694455e-02f, -1.78950820e-02f, 1.20370183e-03f, -4.62797880e-02f, -6.49012020e-03f, 3.97658162e-02f, 5.25517836e-02f, -3.82753797e-02f, 7.20902695e-04f,
  -4.29643914e-02f, 4.37057465e-02f, -2.51389164e-02f, 2.64893770e-02f, 1.16794193e-02f, 2.03035679e-02f, -2.63040420e-02f, 1.61118712e-02f, -5.99711947e-03f, -1.05161527e-02f,
  2.75778864e-02f, 2.16033813e-02f, -1.92605797e-02f, 7.11216405e-03f, 6.78289011e-02f, 1.39567079e-02f, -5.27579412e-02f, -7.59992003e-02f, 1.42055666e-02f, 1.57648455e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.04342632e-01f, 8.97844359e-02f, -8.69204402e-02f, -4.30923142e-02f, 1.95251592e-02f, -2.55381428e-02f, -1.17973099e-02f, 2.28810478e-02f, -4.04844694e-02f, 2.16461092e-01f,
  -1.87631045e-02f, 2.32229177e-02f, 8.05114862e-03f, -2.52156705e-02f, -1.44530326e-01f, -1.29281446e-01f, 3.06703597e-02f, -1.01029195e-01f, 1.57046947e-03f, 9.26080048e-02f,
  2.15779059e-02f, -6.51597902e-02f, -9.85443294e-02f, 3.74647938e-02f, 7.51229748e-02f, 7.77088255e-02f, 1.43636212e-01f, -1.96189433e-02f, 8.10330883e-02f, -9.35011059e-02f,
  -1.22937068e-01f, 3.47752720e-02f, 2.84193121e-02f, -5.21837138e-02f, 1.31762847e-01f, 8.33036155e-02f, 1.26808072e-02f, -7.98901841e-02f, -5.74233681e-02f, 3.72173116e-02f,
  6.07055277e-02f, -5.58852702e-02f, -1.14272900e-01f, 5.25721982e-02f, 7.34524503e-02f, -6.80903252e-03f, -1.49098970e-02f, 1.90268867e-02f, 2.95391269e-02f, -9.61474106e-02f,
  -1.42536741e-02f, 4.34774794e-02f, -1.13395294e-02f, -7.50446692e-02f, 2.04514135e-02f, 5.39262407e-02f, -5.73982410e-02f, 7.10302368e-02f, -5.27468100e-02f, -3.94123122e-02f,
  5.39399907e-02f, 5.26311509e-02f, -5.09208962e-02f, -2.37821625e-03f, 1.98505856e-02f, -6.68023676e-02f, 3.45752239e-02f, -1.87135190e-02f, 1.79421175e-02f, 8.60939473e-02f,
  -6.20335117e-02f, -6.05722666e-02f, -9.24287587e-02f, -4.21106331e-02f, 4.65165600e-02f, -1.10248446e-01f, 1.62539314e-02f, 2.35977452e-02f, -3.78804840e-02f, -5.31258173e-02f,
  -6.75008120e-03f, -5.61461672e-02f, 6.39614835e-02f, 7.60153830e-02f, -8.96278247e-02f, -1.84409749e-02f, -5.12738042e-02f, 2.50830259e-02f, 3.71952839e-02f, 5.36573902e-02f,
  3.17821540e-02f, 7.32049942e-02f, -1.83942150e-02f, -3.26148868e-02f, 1.36649897e-02f, 8.36174563e-02f, -2.00058091e-02f, -7.29201511e-02f, 4.63356413e-02f, -6.78521171e-02f,
  5.25410613e-03f, -6.71778154e-03f, 8.95026475e-02f, 4.80434038e-02f, -7.15931579e-02f, -1.86285209e-02f, -1.50801595e-02f, -3.78926098e-02f, 1.88513957e-02f, 4.07299064e-02f,
  4.98307869e-02f, 4.79032919e-02f, -2.31503919e-02f, 8.67110789e-02f, -4.34387363e-02f, -3.62992845e-02f, 6.17697388e-02f, 1.90527067e-02f, -5.14364205e-02f, -6.23537265e-02f,
  4.79591861e-02f, 6.16970584e-02f, -1.34013176e-01f, -4.91729043e-02f, 2.38254406e-02f, -2.35303208e-01f, -1.16120897e-01f, -1.33321807e-02f, 1.81971937e-01f, 1.06200717e-01f,
  -1.32377580e-01f, 2.58586824e-01f, -7.52700269e-02f, -4.47836220e-02f, -2.31870204e-01f, -1.36709094e-01f, -2.61456728e-01f, 1.57203712e-02f, -5.30929603e-02f, -2.98815481e-02f,
  -1.78612292e-01f, -3.40831466e-02f, -2.07693577e-01f, -4.33353968e-02f, -7.44154155e-02f, 6.80754930e-02f, -3.16596180e-02f, -3.95655148e-02f, -8.29401240e-02f, -5.44915833e-02f,
  -1.58117320e-02f, 2.91169379e-02f, -4.66726162e-02f, -5.78806289e-02f, -7.82378763e-03f, -9.71274301e-02f, -2.52823681e-02f, 1.94335803e-02f, 3.05818692e-02f, -1.08522698e-02f,
  6.01337515e-02f, -3.63879427e-02f, 6.60260469e-02f, -3.92843112e-02f, -1.72498897e-02f, 7.87615776e-03f, -3.76060419e-02f, -7.27782249e-02f, -6.62192106e-02f, -6.69166371e-02f,
  -3.61998640e-02f, -9.73578915e-03f, -4.63580564e-02f, 5.80561580e-03f, -8.44758451e-02f, 6.06612721e-03f, -8.39687232e-03f, 1.59782078e-02f, 3.20260301e-02f, -2.44084410e-02f,
  4.35279943e-02f, -5.37687875e-02f, -5.30864038e-02f, 2.28352044e-02f, -2.16828417e-02f, 3.06133926e-02f, -1.44651942e-02f, 7.36987069e-02f, -4.22367826e-02f, -5.01064695e-02f,
  1.46508904e-03f, 2.42760368e-02f, 1.06555730e-01f, -7.88689032e-02f, -6.00047037e-02f, 7.98032135e-02f, -4.76844609e-02f, 5.31804748e-02f, -2.74971500e-02f, 2.04821583e-02f,
  4.64311615e-02f, -3.62020428e-03f, 3.54007585e-03f, 1.71706863e-02f, -9.13075730e-02f, 7.69702671e-03f, 1.26581751e-02f, -3.57741024e-03f, -6.06551692e-02f, 1.81914847e-02f,
  -1.49512589e-01f, -7.93115571e-02f, -9.14065391e-02f, -4.57041338e-02f, -4.35951687e-02f, 1.61464363e-02f, 1.43935019e-02f, -5.99549711e-02f, -9.42190215e-02f, -7.78493099e-03f,
  -4.15370390e-02f, -1.11125838e-02f, -2.31166109e-02f, 1.75834689e-02f, -1.11897858e-02f, 1.82103198e-02f, 2.20430642e-02f, 3.30881588e-03f, -2.32059937e-02f, 2.97012590e-02f,
  1.98118519e-02f, 8.35981816e-02f, 5.55900298e-02f, 7.69725163e-03f, 5.65102696e-03f, -3.63923684e-02f, 6.75249845e-02f, -4.92644347e-02f, -1.22671768e-01f, 3.21111642e-02f,
  -4.81536649e-02f, -2.49336958e-01f, -2.24686310e-01f, 5.87365068e-02f, 1.55506924e-01f, 6.26059026e-02f, 1.71225965e-02f, -7.00947568e-02f, -1.64884984e-01f, 2.54181679e-02f,
  1.30443200e-01f, -7.73286214e-04f, -4.56854962e-02f, -1.11225799e-01f, 3.38979363e-02f, -9.16120633e-02f, -4.54648137e-02f, 1.13065466e-02f, -1.09059431e-01f, 5.26364334e-02f,
  -9.50879790e-03f, -2.97260303e-02f, 3.27527942e-03f, -5.02271391e-03f, -8.91322456e-03f, 5.65982237e-02f, 1.76002204e-01f, 1.26922697e-01f, 1.26265571e-01f, 3.89178400e-03f,
  -6.14745542e-02f, -6.33954778e-02f, -2.38528457e-02f, -3.49898934e-02f, 3.18387188e-02f, -7.14791790e-02f, 2.81819776e-02f, 4.95370030e-02f, 8.06364492e-02f, -2.63644569e-02f,
  1.69157702e-02f, -1.14037417e-01f, -2.54064091e-02f, -4.51851338e-02f, -9.94654000e-02f, -2.05384921e-02f, -1.43090449e-02f, -2.71553062e-02f, -1.24119736e-01f, 1.19905430e-03f,
  -4.70731668e-02f, 1.21614449e-02f, -2.14163028e-02f, -1.15571752e-01f, -5.61940856e-02f, 2.06776783e-02f, 4.70627323e-02f, 1.04497358e-01f, 2.00700518e-02f, 1.29687518e-01f,
  -2.89025567e-02f, 6.77696541e-02f, 3.24849933e-02f, -3.06796078e-02f, 5.99094443e-02f, -3.78968008e-02f, -2.33201440e-02f, 1.70645621e-02f, -1.64452437e-02f, -9.63971391e-02f,
  -7.29120672e-02f, 5.82632003e-03f, -1.22398520e-02f, 1.11000419e-01f, -1.82274133e-02f, -5.36488891e-02f, 6.60858303e-02f, -6.67929873e-02f, 2.24654097e-02f, -3.10433339e-02f,
  2.86916047e-02f, -5.65400608e-02f, -4.65307720e-02f, -5.95438667e-02f, -8.42670798e-02f, 2.63217781e-02f, 6.47843480e-02f, -4.40892018e-02f, -8.25436413e-02f, 5.21242395e-02f,
  7.78838173e-02f, 6.92151636e-02f, -1.17615855e-03f, -4.65032049e-02f, -6.89395098e-03f, 3.22655775e-02f, -1.41497878e-02f, -3.72626586e-03f, -7.30796671e-03f, -1.17606139e-02f,
  -1.55782849e-02f, 6.49060681e-02f, -6.63150921e-02f, -7.85382167e-02f, -4.42645699e-03f, -6.57221396e-03f, 7.08723580e-03f, 1.41130149e-01f, -1.11927040e-01f, 8.98494646e-02f,
  1.09073833e-01f, 2.82985494e-02f, 2.04829536e-02f, -5.03630526e-02f, 4.98415418e-02f, 4.68613720e-03f, -3.82861644e-02f, 4.20749448e-02f, -4.06821407e-02f, -1.52055146e-02f,
  2.19313279e-01f, 6.48895428e-02f, -1.59883514e-01f, -1.11489519e-01f, 7.06168935e-02f, 1.72415767e-02f, 4.17382009e-02f, -1.04306206e-01f, -5.00823967e-02f, 2.69320812e-02f,
  5.53779602e-02f, -4.06804159e-02f, 3.35320868e-02f, 6.01991601e-02f, -6.41359994e-03f, 9.81805399e-02f, 1.08357668e-01f, 1.37497440e-01f, -1.37147769e-01f, 3.00555695e-02f,
  -7.44926333e-02f, 9.45279151e-02f, -4.18386087e-02f, 3.85415703e-02f, -5.07899560e-03f, -6.64588809e-02f, -3.38488445e-02f, -1.42224640e-01f, -1.18227318e-01f, 3.71755250e-02f,
  1.33515790e-01f, 1.46407774e-03f, -2.56338069e-04f, -5.16742691e-02f, -1.94016304e-02f, -6.88781440e-02f, -9.47349966e-02f, 5.82769886e-02f, -7.50002190e-02f, 5.07640876e-02f,
  3.88179757e-02f, -1.06787682e-01f, 5.65028563e-02f, 7.84361064e-02f, -5.80354221e-02f, 7.20177172e-03f, -1.01110116e-01f, 5.97052723e-02f, -1.38517311e-02f, -3.50231454e-02f,
  3.73489819e-02f, -7.69216716e-02f, 2.07630564e-02f, 4.49305400e-02f, 5.59969097e-02f, -1.67638324e-02f, -7.36895725e-02f, 2.74469927e-02f, -6.12420589e-02f, 4.28890884e-02f,
  6.88392147e-02f, -3.36315781e-02f, -3.57850529e-02f, -3.83557305e-02f, -3.81518416e-02f, -3.61133739e-02f, -4.61282246e-02f, 2.13842113e-02f, 1.72689222e-02f, -2.15919707e-02f,
  -3.89714129e-02f, 4.18706648e-02f, -4.53093983e-02f, -2.64615417e-02f, 7.79849524e-03f, 1.02440201e-01f, -2.36610193e-02f, -4.01693657e-02f, -7.75064677e-02f, -6.78923205e-02f,
  4.57184203e-02f, -6.87603354e-02f, -8.80271718e-02f, 3.48292850e-02f, 5.67202233e-02f, 3.15311737e-02f, 9.18484107e-03f, -3.11581567e-02f, -3.19294743e-02f, -2.55337022e-02f,
  -1.23011814e-02f, 1.15703167e-02f, -5.71584478e-02f, 8.45143870e-02f, 7.99228847e-02f, -4.14139926e-02f, 2.31795162e-02f, -5.38509823e-02f, 1.81634426e-02f, -2.54156198e-02f,
  3.84301208e-02f, -1.63454041e-02f, 1.12727024e-01f, 4.54007909e-02f, -6.99168369e-02f, 1.10355234e-02f, 5.05913571e-02f, -4.38888185e-02f, -2.45558862e-02f, 8.17745402e-02f,
  7.77724013e-02f, -7.01705441e-02f, 4.41995226e-02f, 2.47776322e-02f, 4.55454960e-02f, 6.42772987e-02f, -9.46379453e-02f, 1.37074841e-02f, -9.67931673e-02f, -4.99467663e-02f,
  -5.68240359e-02f, -2.07990468e-01f, 2.06451103e-01f, 1.01874094e-03f, 4.81783077e-02f, 3.77887972e-02f, 1.27803102e-01f, -1.78346917e-01f, -1.67350665e-01f, -1.59776226e-01f,
  -6.03711456e-02f, 3.53631116e-02f, 1.98355347e-01f, -3.65988053e-02f, 2.80647069e-01f, 1.33497298e-01f, -1.41540710e-02f, -1.75748430e-02f, 4.60748002e-03f, -6.50229454e-02f,
  -1.03051431e-01f, -1.17900118e-01f, 1.67110618e-02f, -9.53880548e-02f, 6.55956287e-03f, -2.09151153e-02f, 4.73975390e-02f, 1.02162004e-01f, -6.35070503e-02f, 9.74122509e-02f,
  3.32241617e-02f, -4.21858206e-02f, -3.45202833e-02f, 2.64106486e-02f, 1.64155010e-02f, -6.25786558e-02f, 2.06081066e-02f, 1.39876500e-01f, 1.46100782e-02f, 1.00523178e-02f,
  1.00688934e-02f, 5.64958602e-02f, 1.44078732e-02f, 3.05544178e-04f, -7.38951564e-02f, -3.58732417e-02f, -1.55864842e-02f, -3.92891802e-02f, 3.75627577e-02f, -1.04030473e-02f,
  2.55277287e-02f, 6.18347898e-03f, 1.95629913e-02f, 5.25707863e-02f, 4.51078974e-02f, -5.79339266e-02f, -9.46158450e-03f, 4.73534055e-02f, 1.31923174e-02f, 2.30547246e-02f,
  -7.51676187e-02f, -1.75195597e-02f, -6.38254778e-03f, 2.99976114e-02f, -2.32987050e-02f, -1.63974222e-02f, -6.50397539e-02f, 5.30613959e-03f, 6.08561039e-02f, -3.55914421e-02f,
  -5.35053201e-02f, 3.82767431e-02f, 7.42458319e-03f, 3.78048047e-02f, 1.00352578e-02f, -5.23424745e-02f, 4.13592644e-02f, -2.48047244e-02f, -3.61276455e-02f, 1.34649463e-02f,
  -3.55739780e-02f, 2.45859940e-03f, 2.56541502e-02f, 6.08297475e-02f, -1.39197083e-02f, 3.06334291e-02f, 2.71794596e-03f, -6.52487390e-03f, 4.98973988e-02f, 3.59278508e-02f,
  -1.43710628e-01f, -1.16941199e-01f, -4.46011871e-02f, -1.14983648e-01f, 2.88598742e-02f, 2.78157834e-02f, 9.60757490e-03f, -3.73575538e-02f, -9.35064554e-02f, -1.25460392e-02f,
  -5.64044379e-02f, 9.02293995e-02f, -1.57743879e-03f, 4.57110964e-02f, -2.06068344e-02f, -2.01457106e-02f, -8.18099920e-03f, -7.94855654e-02f, -4.87695262e-02f, -1.00474574e-01f,
  1.87758356e-02f, 1.11713121e-03f, 3.74315865e-02f, -3.36447209e-02f, -6.31165653e-02f, -1.74289886e-02f, 5.23963682e-02f, 2.05540787e-02f, -3.93835567e-02f, -4.08451147e-02f,
  7.34145045e-02f, -1.04190290e-01f, -5.10795191e-02f, 6.77389130e-02f, 4.67672162e-02f, -1.76208422e-01f, -1.34353593e-01f, -2.72300020e-02f, -1.16561458e-01f, -1.03783548e-01f,
  3.91351283e-02f, 6.89611509e-02f, 6.10010186e-03f, 9.38830227e-02f, 1.73105150e-01f, 6.29093349e-02f, 2.05521490e-02f, 7.60119259e-02f, 1.68473274e-03f, 6.75476044e-02f,
  2.11425975e-01f, 1.57280073e-01f, 2.53519475e-01f, 1.55705139e-01f, 1.29204780e-01f, 1.81672230e-01f, 2.28223637e-01f, 1.24420166e-01f, 1.60328880e-01f, 1.34812877e-01f,
  -5.92189608e-03f, -1.02301147e-02f, 8.07152763e-02f, -4.87017765e-04f, 1.91288684e-02f, 3.08741182e-02f, 4.42458689e-02f, 8.51244107e-02f, 6.59984574e-02f, -4.31824801e-03f,
  6.35422021e-02f, 7.48438537e-02f, -4.78506647e-02f, 8.19030851e-02f, -1.08232507e-02f, 4.02366705e-02f, 2.47918777e-02f, 4.40212935e-02f, 2.00482551e-02f, 1.05913155e-01f,
  3.56712565e-02f, 7.44929817e-03f, -6.91433921e-02f, -1.22005315e-02f, -1.02999331e-02f, -6.73800856e-02f, 3.06391995e-02f, 5.39286714e-03f, 1.01952814e-02f, -7.43864104e-02f,
  -1.67032648e-02f, 1.58004705e-02f, -3.23935486e-02f, -3.74906845e-02f, -8.51458963e-03f, -7.07032382e-02f, 5.41867316e-02f, 3.62994857e-02f, 6.27410365e-03f, 9.20196548e-02f,
  5.58772981e-02f, 3.07343919e-02f, 3.36022414e-02f, 4.16358151e-02f, -1.99728012e-02f, -2.25896365e-03f, 2.83771697e-02f, 6.67939186e-02f, 5.76547198e-02f, 1.86673012e-02f,
  5.92601895e-02f, 2.79429164e-02f, -9.62915830e-03f, -6.40825778e-02f, -2.18904554e-03f, -1.23930881e-02f, -6.34982623e-03f, 1.75882597e-02f, 6.48450032e-02f, 5.63331507e-02f,
  4.84727323e-03f, 1.20702796e-01f, -4.08008173e-02f, 6.59363018e-03f, -2.23069768e-02f, -1.01658162e-02f, -3.67207304e-02f, -4.97619994e-02f, 3.08057107e-03f, 1.52370548e-02f,
  -3.39595079e-02f, -4.37587267e-03f, 2.24108733e-02f, 1.74401980e-03f, 9.62189585e-02f, 8.87268968e-03f, -4.02878411e-02f, -2.35854480e-02f, 5.37658781e-02f, 3.59480381e-02f,
  -6.63363934e-02f, -1.75560471e-02f, 8.17774832e-02f, -5.62595278e-02f, -5.42347133e-02f, 9.48977470e-03f, 3.35615054e-02f, 7.08116814e-02f, 2.93970425e-02f, 8.42906386e-02f,
  6.20392896e-02f, 6.51289597e-02f, 2.31959205e-02f, 3.30673195e-02f, -5.61801679e-02f, -3.81232500e-02f, -3.68327871e-02f, 2.43024956e-02f, -4.75456119e-02f, -7.52329603e-02f,
  3.75926904e-02f, -3.84320691e-02f, -6.09512776e-02f, 4.87306528e-02f, -3.63190547e-02f, 1.99275203e-02f, -4.32472639e-02f, -2.20301207e-02f, 5.06952666e-02f, 8.18563178e-02f,
  -9.35608614e-03f, 5.08492179e-02f, -5.62507473e-03f, 7.76413381e-02f, 5.31237870e-02f, 1.55770078e-01f, 5.27774952e-02f, 6.65969029e-02f, 8.39023292e-02f, 4.68997248e-02f,
  -1.01907335e-01f, -2.60037631e-02f, 3.17270383e-02f, -6.62516132e-02f, -4.89384122e-02f, 5.50230183e-02f, 6.08897209e-02f, 1.95475891e-02f, -3.83774983e-03f, -4.67437580e-02f,
  -1.11117132e-01f, 4.15482596e-02f, 3.24780196e-02f, -4.89157438e-02f, -7.48287290e-02f, 2.84242891e-02f, -3.02819721e-02f, -2.56943833e-02f, -6.61193579e-02f, -6.75101504e-02f,
  -5.32628112e-02f, -3.20834555e-02f, -1.78504512e-02f, 1.17400937e-01f, 5.55872135e-02f, 5.78163974e-02f, -5.81656173e-02f, -3.34034637e-02f, -9.62481946e-02f, -2.83395988e-03f,
  -1.04770660e-01f, 1.86480545e-02f, 3.72298025e-02f, -1.30504966e-02f, -2.47490872e-02f, 5.21031916e-02f, 2.87481621e-02f, 5.52147394e-03f, 6.14970997e-02f, 2.54939981e-02f,
  -5.67126088e-02f, 5.70700765e-02f, -3.95324603e-02f, -8.15590993e-02f, 2.40127016e-02f, -2.38515623e-02f, -6.90330341e-02f, 2.93311067e-02f, 8.37764591e-02f, -2.13949904e-02f,
  7.35357255e-02f, -9.28307399e-02f, 3.98310386e-02f, -2.39638519e-02f, -6.05784506e-02f, 7.96163306e-02f, -4.06228453e-02f, 2.32597142e-02f, 5.89716248e-02f, -2.46092975e-02f,
  -1.53193353e-02f, -9.23189707e-03f, -9.52961855e-03f, 2.19193995e-02f, 3.77189890e-02f, -3.18302289e-02f, 2.35284138e-02f, -6.57826941e-03f, 5.67181110e-02f, 3.34994160e-02f,
  4.46397848e-02f, -8.98957811e-03f, 7.17664231e-03f, 4.05254513e-02f, -3.11771370e-02f, 1.67538617e-02f, 2.44464055e-02f, -4.42796871e-02f, 6.27410710e-02f, 8.28427821e-02f,
  -1.03888633e-02f, -4.01814282e-02f, -2.32997779e-02f, -4.25770245e-02f, 3.77580747e-02f, 7.74663836e-02f, -8.39806944e-02f, 4.74133864e-02f, -5.43422960e-02f, 1.30050238e-02f,
  -1.53683633e-01f, -1.74348563e-01f, -4.06054854e-01f, -9.68743712e-02f, -2.59411663e-01f, -2.51117766e-01f, -2.56058842e-01f, -9.21515524e-02f, -5.46894632e-02f, 2.26460546e-01f,
  -3.99563797e-02f, 3.23315375e-02f, 1.24971792e-01f, -2.77295671e-02f, -1.91404652e-02f, 2.15543374e-01f, -7.00813383e-02f, 6.87837824e-02f, 5.15897349e-02f, -1.92879006e-01f,
  4.08071913e-02f, -6.53621927e-02f, -8.49740654e-02f, -8.71112272e-02f, -1.52059928e-01f, -4.38291207e-02f, 1.09347530e-01f, -1.38538346e-01f, -7.82154575e-02f, -9.14549008e-02f,
  -1.25312641e-01f, -1.65588614e-02f, 1.51083330e-02f, -3.37984823e-02f, -3.63213159e-02f, 3.13789509e-02f, -1.11872211e-01f, 1.70994066e-02f, -2.20018458e-02f, 1.26388678e-02f,
  -6.62387209e-03f, -5.03894947e-02f, 1.10848248e-03f, 4.07217890e-02f, -2.31090672e-02f, -7.52676055e-02f, -2.00985577e-02f, -7.90401455e-03f, -5.98002784e-02f, -3.65895772e-04f,
  -2.00095270e-02f, -1.99716650e-02f, -4.27738056e-02f, 4.31712382e-02f, -8.10322631e-03f, -4.15578149e-02f, -8.05982947e-03f, -4.85227443e-04f, -6.56502694e-02f, -3.79969068e-02f,
  -9.16369706e-02f, 2.48417389e-02f, -2.83197667e-02f, 2.37421300e-02f, 1.79048739e-02f, -6.65027276e-02f, -1.27488505e-02f, 2.74838004e-02f, 1.48874382e-02f, -2.65149847e-02f,
  1.60482079e-02f, -4.99268062e-02f, 7.61935487e-03f, 1.33375023e-02f, -6.01930718e-04f, -6.02740124e-02f, -5.39956335e-03f, -5.12364320e-02f, -7.96314180e-02f, 1.48600433e-02f,
  5.55710383e-02f, -3.90403830e-02f, 4.45944117e-03f, -1.36384424e-02f, 1.96862034e-03f, 1.03280604e-01f, -4.21806821e-04f, 1.76470242e-02f, -3.28449160e-02f, -4.07528989e-02f,
  -1.38471276e-01f, -1.77305028e-01f, -2.11938098e-03f, -2.45960914e-02f, 7.89324567e-02f, -3.92595343e-02f, -7.06625450e-03f, -4.30800114e-03f, -6.75950050e-02f, -9.42718834e-02f,
  -2.37112921e-02f, 5.92484176e-02f, -6.72891811e-02f, 1.39442692e-02f, -4.16328385e-02f, 2.62226956e-03f, 6.84019830e-03f, -4.08178242e-03f, -4.27656062e-02f, -1.70617905e-02f,
  -7.61273317e-03f, 2.26778518e-02f, 7.91251436e-02f, 1.23607680e-01f, 2.41229171e-03f, 1.45070720e-02f, -4.45019417e-02f, 9.64875594e-02f, -5.81703745e-02f, -4.01404202e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  9.72337499e-02f, 1.26366943e-01f, -3.97706702e-02f, -1.54360868e-02f, 1.75395869e-02f, 3.66236418e-02f, -1.01796985e-02f, -1.40303954e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  9.38870385e-02f, -2.20943838e-01f, -1.79537177e-01f, 1.56730846e-01f, 1.51502520e-01f, 3.06650959e-02f, 7.83084631e-02f, 9.04077142e-02f, 1.57707725e-02f, 5.58286756e-02f,
  4.07662429e-02f, -2.58950949e-01f, -1.99642241e-01f, 1.46598846e-01f, 1.02950297e-01f, 9.86366272e-02f, -2.55016327e-01f, -6.51751384e-02f, 6.33558929e-02f, -6.85235411e-02f,
  1.10948272e-01f, 1.26288161e-01f, 3.31927799e-02f, 6.92599639e-02f, 1.62217975e-01f, -7.63249351e-03f, 8.76574740e-02f, -1.87069416e-01f, 1.01809569e-01f, 2.71120369e-01f,
  -2.85589229e-02f, 1.28786325e-01f, 1.74353138e-01f, -1.31371602e-01f, -7.74896517e-02f, 1.24936653e-02f, 2.35633194e-01f, 5.13471477e-02f, -1.45768270e-01f, -1.46537140e-01f,
  -5.05906828e-02f, 9.95674133e-02f, -6.61983788e-02f, 5.65422028e-02f, 1.54414013e-01f, 4.64091778e-01f, 1.92566171e-01f, 3.46936911e-01f, 4.20909561e-02f, -2.34211814e-02f,
  -1.13765463e-01f, -3.38997036e-01f, -1.74520567e-01f, 1.97237849e-01f, -1.47156315e-02f, -6.92528188e-02f, -1.11755721e-01f, 5.37121668e-04f, -2.66736776e-01f, -2.52002865e-01f,
  -2.47803889e-02f, 7.45432125e-03f, 8.04333091e-02f, 2.88735628e-01f, -1.36380330e-01f, -2.47550055e-01f, 6.96685573e-04f, 9.10280719e-02f, -1.73034836e-02f, -2.17723772e-01f,
  -3.50525677e-02f, -1.52569562e-01f, 1.59110025e-01f, 1.61469117e-01f, -1.58330873e-01f, -2.88244430e-02f, -3.01881015e-01f, 9.40707400e-02f, 7.84597769e-02f, 9.79675651e-02f,
  -1.22282460e-01f, -2.23667752e-02f, -1.50538623e-01f, 1.02395251e-01f, -1.10363856e-01f, -7.09538534e-02f, -1.94591761e-01f, 4.20657843e-02f, -9.70226601e-02f, -2.24619135e-01f,
  1.17621318e-01f, 6.55234233e-02f, 1.11911319e-01f, 3.23369414e-01f, 9.49982926e-02f, 8.53503570e-02f, -3.78584228e-02f, 6.20957203e-02f, -1.65707365e-01f, -1.62408307e-01f,
  -1.10989526e-01f, -2.59722531e-01f, -2.94430047e-01f, -2.38316447e-01f, 8.45220760e-02f, -1.21790171e-01f, -2.39816725e-01f, -2.86388975e-02f, -2.52705365e-01f, 1.05553269e-01f,
  -1.59262300e-01f, 2.25721538e-01f, -1.67220801e-01f, -1.14014663e-01f, 1.00490361e-01f, 1.50481537e-01f, -2.17900172e-01f, 1.29398778e-01f, 4.38624710e-01f, -2.02514827e-01f,
  1.84180483e-01f, 2.62568444e-01f, 1.14350446e-01f, -9.04889777e-02f, -1.33044705e-01f, -3.26724499e-02f, 4.53267805e-02f, 5.80440685e-02f, -5.30296154e-02f, 2.05648109e-01f,
  1.57369778e-01f, 5.80086075e-02f, -1.96366116e-01f, -3.05574480e-02f, 1.83966488e-01f, -1.28216848e-01f, 1.35090938e-02f, 2.07798749e-01f, 2.08517555e-02f, -3.19376618e-01f,
  1.62893265e-01f, -2.59026438e-01f, 2.96888977e-01f, -5.00185452e-02f, 1.23761661e-01f, -1.78107351e-01f, -1.74057096e-01f, -2.94089526e-01f, 3.03798974e-01f, -1.46526456e-01f,
  -1.72465727e-01f, -1.57975197e-01f, -2.79895127e-01f, -1.76459312e-01f, -8.98235291e-02f, -2.86184568e-02f, 1.29790917e-01f, 8.35968703e-02f, -1.99456513e-01f, 3.27424072e-02f,
  -3.74456108e-01f, -2.77455628e-01f, 1.22287184e-01f, 3.37663032e-02f, -1.73388764e-01f, -1.30376890e-01f, -4.99923974e-02f, -1.39588699e-01f, 5.34520485e-02f, -3.34006637e-01f,
  -1.50650069e-01f, -1.85317174e-01f, -2.68869668e-01f, -5.19588590e-02f, -2.67633736e-01f, -3.46223824e-02f, 5.99827804e-02f, 2.76325941e-01f, 1.31447032e-01f, 3.81637841e-01f,
  -9.19657201e-02f, -2.35141993e-01f, -2.80023903e-01f, 1.02497503e-01f, -1.46257877e-03f, -1.22676842e-01f, 4.99584600e-02f, 1.74563169e-01f, -2.56381482e-01f, 3.60094458e-01f,
  1.28245428e-01f, -2.72372991e-01f, 1.43931553e-01f, -1.22483224e-01f, -3.30753699e-02f, 2.06746235e-01f, 2.04747632e-01f, -8.84744227e-02f, 1.47221193e-01f, 2.03768820e-01f,
  1.88726008e-01f, 9.35873836e-02f, -4.97844815e-02f, -1.20599300e-01f, -2.11457804e-01f, 2.02847570e-01f, -4.62415814e-02f, 2.34807923e-01f, 1.77738667e-01f, 7.42577855e-03f,
  -1.26650214e-01f, -1.07615314e-01f, 1.37451559e-01f, 7.36944824e-02f, 4.74861003e-02f, 1.86372355e-01f, -1.39407292e-01f, -2.76723187e-02f, -8.01349506e-02f, 1.13460936e-01f,
  1.16728144e-02f, 2.08747581e-01f, 1.51232839e-01f, 2.93858886e-01f, 1.42883271e-01f, -2.62146026e-01f, 2.07913946e-02f, -1.31922513e-01f, 1.52568534e-01f, -9.36955512e-02f,
  -1.23301335e-01f, 2.04466194e-01f, 4.65788282e-02f, 7.18176067e-02f, -8.46489966e-02f, -3.36015940e-01f, 5.21644168e-02f, 3.71759961e-04f, -1.12497598e-01f, 2.47779280e-01f,
  2.14251935e-01f, -3.16651240e-02f, 8.15749168e-03f, -1.11757234e-01f, 1.88566223e-01f, 4.69168387e-02f, -1.31844535e-01f, 7.12960213e-02f, 1.57680176e-02f, 4.36685979e-02f,
  -1.34999827e-01f, 1.99762017e-01f, 4.36221063e-02f, -1.95236076e-02f, -1.06275961e-01f, 2.96199411e-01f, 4.68725339e-02f, -2.27175634e-02f, 1.80670112e-01f, 1.83484957e-01f,
  -7.50640705e-02f, 8.95683467e-02f, -1.28760800e-01f, 1.19924709e-01f, 2.31905337e-02f, 5.99148162e-02f, 1.30358905e-01f, 2.84066617e-01f, 3.78555171e-02f, -1.22367844e-01f,
  -1.03347026e-01f, -2.65736699e-01f, -2.25799248e-01f, -1.86145809e-02f, -8.41694102e-02f, 4.02113572e-02f, 2.77323695e-03f, -5.24497032e-02f, -9.22811851e-02f, -3.32594290e-02f,
  1.93202585e-01f, -1.87424868e-01f, 2.58396089e-01f, 3.39888744e-02f, 1.65324837e-01f, 1.47854924e-01f, -7.82352611e-02f, -2.63049781e-01f, -1.48362532e-01f, 3.80087309e-02f,
  1.01555131e-01f, -6.89450055e-02f, -2.40838766e-01f, 1.35686889e-01f, 2.57214576e-01f, -2.90415347e-01f, 3.11143342e-02f, -2.52073497e-01f, 1.84412733e-01f, -8.08026046e-02f,
  -2.05361277e-01f, -2.57740498e-01f, 3.83616537e-01f, -7.01256245e-02f, 6.88839629e-02f, -2.10967973e-01f, -1.02562889e-01f, 1.55219272e-01f, 7.95728639e-02f, -1.43657088e-01f,
  -6.47413209e-02f, 3.71089950e-02f, 1.58537582e-01f, -2.89498031e-01f, 2.25081518e-01f, -4.82018804e-03f, 2.22112194e-01f, 6.80287033e-02f, 3.52641828e-02f, -6.57745600e-02f,
  5.90822659e-02f, 1.59119815e-02f, 1.11884512e-01f, -3.37354504e-02f, -1.74376041e-01f, 2.06809774e-01f, 8.90217274e-02f, -2.09525496e-01f, -4.62704077e-02f, -2.17828691e-01f,
  1.27398759e-01f, 2.29421273e-01f, 2.08863225e-02f, -3.00830930e-01f, 2.60362476e-01f, -1.73227876e-01f, -2.86322862e-01f, -3.24105799e-01f, -1.78188398e-01f, 1.28915861e-01f,
  1.07670926e-01f, -5.29068187e-02f, 1.95956752e-01f, -2.92091459e-01f, -1.47424325e-01f, -1.44223258e-01f, 7.48207793e-02f, -1.25495285e-01f, 3.63042593e-01f, 3.11841127e-02f,
  6.94865137e-02f, -2.33057842e-01f, 2.38573313e-01f, 3.26645821e-01f, 2.17756614e-01f, 7.82304257e-02f, 1.34030163e-01f, -2.00344902e-02f, 1.10909157e-01f, -1.24109089e-01f,
  3.19247432e-02f, -1.57725796e-01f, -7.76412264e-02f, 2.31474657e-02f, 5.26593346e-03f, -1.68975711e-01f, 8.82688686e-02f, -3.81587036e-02f, -3.66287023e-01f, -5.76109827e-01f,
  -3.90861034e-01f, -4.39984761e-02f, 5.09070884e-03f, 6.89948723e-03f, 3.30901831e-01f, -3.81246984e-01f, -7.95150623e-02f, 1.97092623e-01f, 2.09237397e-01f, -1.87782332e-01f,
  2.20789284e-01f, -3.40811303e-03f, -1.35380760e-01f, -1.16792256e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.63614029e-01f, 2.32120454e-01f, -6.36080801e-02f, 2.58609019e-02f, 1.14348508e-01f, -6.87607657e-03f, 2.78383732e-01f, 1.65259108e-01f, 8.59946012e-02f, 2.37621576e-01f,
  9.58790481e-02f, -1.91235855e-01f, -6.04922213e-02f, 1.23127222e-01f, 1.62739724e-01f, 9.11213085e-02f, -6.54873028e-02f, -4.22725856e-01f, -2.46001035e-01f, -2.13980958e-01f,
  8.75390507e-03f, 2.28087261e-01f, 4.43534367e-02f, -2.59337336e-01f, 1.53831905e-03f, 2.15936765e-01f, -5.66228351e-04f, -7.81134441e-02f, -1.38600305e-01f, 1.73314855e-01f,
  -9.72897932e-02f, 1.95521772e-01f, 8.23366046e-02f, -1.44069389e-01f, 1.33523881e-01f, -1.33576959e-01f, -1.04365364e-01f, -8.72381926e-02f, 1.09331086e-01f, 1.31138256e-02f,
  -2.39219740e-02f, -1.60656273e-01f, -8.68498459e-02f, -3.10868155e-02f, -3.50242220e-02f, -1.73550341e-02f, -2.39381101e-03f, 7.89291114e-02f, -7.11947680e-02f, 2.76394486e-02f,
  5.25026908e-03f, 6.15151413e-02f, 1.76598467e-02f, 6.85944706e-02f, -2.09956262e-02f, -1.16484329e-01f, -1.57402769e-01f, -9.20832753e-02f, -1.43824652e-01f, -8.70253965e-02f,
  -5.17645739e-02f, 9.99479592e-02f, 1.02438346e-01f, 5.07869087e-02f, -1.65439859e-01f, 9.47234258e-02f, -6.50717830e-03f, 2.12062240e-01f, -5.03936270e-03f, -9.54005569e-02f,
  1.84534773e-01f, -1.01607889e-01f, -1.23137243e-01f, -1.19619884e-01f, -7.62026943e-03f, 9.76049900e-02f, -2.20327511e-01f, -1.67216305e-02f, 1.10973231e-01f, -7.21302554e-02f,
  1.26792669e-01f, -1.04241952e-01f, 7.84791112e-02f, 2.03467891e-01f, 6.45818040e-02f, 5.65448776e-02f, -4.64942679e-02f, 1.76998213e-01f, -1.46985263e-01f, -6.67731985e-02f,
  -1.46972388e-01f, -1.61189083e-02f, -1.89411670e-01f, 1.88476190e-01f, 1.48393009e-02f, -1.29148111e-01f, -7.58128166e-02f, 1.51172951e-01f, 2.48775691e-01f, -4.73005585e-02f,
  -8.05499032e-02f, 4.33151051e-02f, 2.08649889e-01f, 2.28531081e-02f, -5.55625148e-02f, 6.61355406e-02f, 2.27280959e-01f, 1.39975753e-02f, -4.96576019e-02f, -1.79005131e-01f,
  -7.02415481e-02f, -1.12107366e-01f, 1.94822103e-01f, 2.69899964e-01f, 1.41691059e-01f, -8.17688704e-02f, 2.86329776e-01f, -2.47170851e-01f, -1.59775436e-01f, 1.65380195e-01f,
  4.09536511e-02f, 6.01814836e-02f, -1.45358384e-01f, 1.85099706e-01f, -4.79350723e-02f, -8.92372206e-02f, -9.19182673e-02f, 9.99691486e-02f, 1.22744650e-01f, 3.14336330e-01f,
  5.58963344e-02f, 9.46802199e-02f, 2.15443550e-03f, 1.33590296e-01f, 1.85583428e-01f, 1.84161700e-02f, 2.45429501e-01f, -9.28813685e-03f, -1.35134356e-02f, 2.32693776e-01f,
  -4.26001996e-01f, -6.39994163e-03f, 1.56389192e-01f, -1.23266518e-01f, -2.93001890e-01f, -3.16832632e-01f, -2.77178466e-01f, 1.39797002e-01f, -1.68180257e-01f, 1.37047738e-01f,
  -2.28435490e-02f, 1.02892131e-01f, 2.17410639e-01f, 4.23134379e-02f, 5.23961335e-02f, -1.14950322e-01f, -7.90624619e-02f, 2.00090855e-01f, -5.54195642e-02f, -2.79758275e-02f,
  1.77143320e-01f, 2.84899414e-01f, 2.51872867e-01f, -2.43104864e-02f, 2.74736404e-01f, 3.66628349e-01f, -1.54870391e-01f, 9.11669657e-02f, 3.15694213e-02f, 8.21580142e-02f,
  -1.00240558e-01f, 4.54729676e-01f, 1.93144128e-01f, -1.56765029e-01f, -3.61554652e-01f, -6.08982295e-02f, -6.20938838e-02f, -2.24886537e-02f, 1.49637625e-01f, 1.83327883e-01f,
  -3.57141525e-01f, 3.53049666e-01f, 1.40440568e-01f, -2.08376735e-01f, 9.00066867e-02f, 1.35387108e-01f, 1.05745547e-01f, -1.00483142e-01f, -5.25415055e-02f, -1.63502380e-01f,
  -6.52885437e-03f, -1.93201199e-01f, 1.27778396e-01f, 3.61307301e-02f, -1.10141784e-01f, -1.12914383e-01f, 1.69511408e-01f, -1.78977773e-01f, 1.63760483e-01f, -1.47333881e-02f,
  -5.30263856e-02f, 1.17340341e-01f, -7.79724047e-02f, -1.42423242e-01f, -4.94502932e-02f, -7.28840232e-02f, -5.03643509e-03f, 6.05934300e-03f, -1.15380278e-02f, -7.52141103e-02f,
  -6.55943379e-02f, 7.05997720e-02f, -6.93555027e-02f, 1.50611386e-01f, 1.66145951e-01f, 9.62498114e-02f, -1.91836372e-01f, 1.78985208e-01f, -1.01903975e-01f, 3.96364406e-02f,
  1.03524953e-01f, -1.67208463e-01f, -3.96483298e-03f, 1.67468339e-01f, 1.32910281e-01f, -1.88326374e-01f, -1.53663114e-01f, -1.67481244e-01f, -4.55782115e-02f, -1.87212527e-01f,
  -1.57648250e-01f, 7.62585700e-02f, -1.07434861e-01f, 5.00405654e-02f, 3.06275189e-02f, 9.25077125e-02f, -4.86235321e-02f, -9.39484611e-02f, -1.30286003e-02f, -9.40640271e-02f,
  1.57550767e-01f, -6.83252583e-04f, -9.65920389e-02f, -1.71816349e-01f, -1.53362811e-01f, -1.00390695e-01f, -1.24010947e-02f, -7.68175051e-02f, -1.03657588e-01f, -7.30865356e-03f,
  1.67344913e-01f, 1.00160107e-01f, 4.13541828e-04f, -7.56126344e-02f, -1.62717611e-01f, 2.04163730e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.36798874e-01f, -3.23016532e-02f, 1.77484557e-01f, 2.42659852e-01f, 8.62929672e-02f, 2.49141708e-01f, 1.83104187e-01f, -3.40904444e-02f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  5.32832071e-02f, 2.37162318e-02f, 1.57845184e-01f, -8.72465745e-02f, -1.22949377e-01f, -7.26595223e-02f, 1.66818440e-01f, 8.24042037e-02f, -8.19168389e-02f, 9.75936279e-02f,
  2.56087612e-02f, -2.33661652e-01f, -9.65932012e-02f, -1.30708098e-01f, -1.99404389e-01f, 4.51691486e-02f, 9.37168375e-02f, -4.62247789e-01f, -2.36541014e-02f, -5.16480133e-02f,
  -7.34130591e-02f, -2.16188937e-01f, 1.86809763e-01f, 5.33949733e-01f, 2.04170391e-01f, -1.72042012e-01f, -2.30103299e-01f, 2.60785241e-02f, -1.37709126e-01f, 3.08595151e-01f,
  1.85875267e-01f, -4.06753570e-02f, -5.84065393e-02f, -6.67181090e-02f, -4.58488502e-02f, -8.79863203e-02f, 1.17899753e-01f, -1.69187710e-01f, 1.47903115e-01f, 1.85322791e-01f,
  -2.45956406e-02f, 1.48836449e-01f, -1.36817023e-01f, -1.97254434e-01f, 5.52920215e-02f, 4.45702858e-02f, 1.36975467e-01f, -1.49546042e-01f, 2.19758391e-01f, 1.25721425e-01f,
  1.27707765e-01f, 1.80800095e-01f, 1.72948703e-01f, 1.94378123e-01f, 2.44505584e-01f, 2.01848984e-01f, 2.21610889e-01f, 4.19253744e-02f, -6.65683597e-02f, -2.08689645e-01f,
  6.95234388e-02f, -5.44050522e-02f, 1.51665166e-01f, -1.50154710e-01f, -3.27360220e-02f, -9.20873657e-02f, -3.57818007e-02f, -2.26428330e-01f, 2.55208369e-02f, -2.72875354e-02f,
  6.84989034e-04f, 1.28040671e-01f, 1.25033334e-01f, -1.62737623e-01f, -1.55579597e-01f, 2.21837193e-01f, -2.52091914e-01f, -2.13638648e-01f, -1.80744603e-01f, -9.25111622e-02f,
  2.58781135e-01f, 2.28483319e-01f, -1.02752782e-01f, -2.18388781e-01f, 1.39036044e-01f, 1.79753363e-01f, 2.19758540e-01f, 1.92187458e-01f, -2.85167605e-01f, -1.44179881e-01f,
  1.23265621e-04f, 2.58546472e-01f, -5.74613065e-02f, -8.89029950e-02f, 4.49664338e-04f, 2.26854868e-02f, -1.70963064e-01f, -4.92806695e-02f, 7.09971937e-04f, -4.10564207e-02f,
  -1.63562968e-01f, 3.79857942e-02f, -1.23914123e-01f, -8.05885494e-02f, 1.72465608e-01f, 1.67649109e-02f, -5.54588996e-02f, -9.64429304e-02f, 2.14189216e-01f, -1.45367789e-03f,
  1.74576584e-02f, 1.47041082e-01f, -3.92538220e-01f, 6.23498671e-02f, 6.21698238e-02f, -1.83591514e-03f, 1.78580776e-01f, -3.56694520e-01f, -1.95035949e-01f, -2.43766710e-01f,
  1.28301740e-01f, -5.50320335e-02f, -1.19442634e-01f, -1.51230395e-02f, -7.98625052e-02f, 2.55914718e-01f, -8.22706968e-02f, 1.62965313e-01f, -6.48782179e-02f, 3.37326489e-02f,
  1.42220948e-02f, 1.75355136e-01f, -2.55095717e-02f, -2.13211209e-01f, 1.09080829e-01f, 1.71150416e-01f, 1.09191626e-01f, -1.48774758e-01f, 1.01202935e-01f, -2.44978681e-01f,
  -1.20322242e-01f, 2.31331155e-01f, -3.05964965e-02f, 1.25194758e-01f, -4.25404966e-01f, 1.97241604e-02f, 1.07289776e-01f, -2.63632722e-02f, 1.26462594e-01f, -3.36203933e-01f,
  -1.87831521e-01f, -1.84048995e-01f, 1.69498697e-02f, -1.28873870e-01f, 1.22520268e-01f, -4.52886745e-02f, -1.16318904e-01f, 2.98071563e-01f, 1.12995394e-01f, -1.22508600e-01f,
  -6.55105198e-03f, 8.52286518e-02f, -1.03324272e-01f, 1.81663670e-02f, 1.06447265e-01f, 6.95598498e-02f, 1.31674901e-01f, 9.21981351e-04f, -2.02352274e-02f, -7.08054304e-02f,
  -2.42173765e-02f, 1.82241589e-01f, -5.31047657e-02f, -4.12706017e-01f, -6.83282390e-02f, 1.16621710e-01f, -1.15169264e-01f, 4.80677158e-01f, -3.71460840e-02f, -1.28488289e-03f,
  2.15424418e-01f, 2.48982534e-01f, 1.38107434e-01f, -1.17400862e-01f, -3.24888170e-01f, 6.56361803e-02f, -1.90970749e-02f, 2.78818190e-01f, 4.32420783e-02f, 8.74115229e-02f,
  4.21312861e-02f, 5.04024886e-02f, -1.31837428e-01f, 7.64186978e-02f, 2.33633257e-02f, 3.41138308e-04f, -1.19333662e-01f, -2.13547513e-01f, -2.20174789e-01f, -2.56473094e-01f,
  -1.77333102e-01f, -1.71863455e-02f, -2.21729666e-01f, -4.92172986e-02f, 2.02662006e-01f, 6.23893924e-02f, 3.01198006e-01f, 1.74623668e-01f, 9.80369672e-02f, 8.20642933e-02f,
  7.34983012e-02f, -2.05094904e-01f, -1.17232511e-02f, 3.92375588e-01f, 3.27518612e-01f, 2.30500311e-01f, 2.08839655e-01f, -1.55423000e-01f, -3.34926173e-02f, 6.60916045e-02f,
  3.68690252e-01f, -2.68714875e-01f, -7.85080567e-02f, 2.53317505e-02f, -1.74438283e-01f, -1.03273317e-02f, 1.01232886e-01f, -1.82506904e-01f, -1.78112641e-01f, -2.82678846e-02f,
  -1.75590754e-01f, -2.41348609e-01f, -2.21833855e-01f, -2.01922610e-01f, 5.74159622e-02f, -2.23889202e-01f, 1.40518323e-01f, 1.76003486e-01f, -5.04604951e-02f, 2.34808490e-01f,
  1.95064649e-01f, -3.90408814e-01f, -1.12844914e-01f, 1.21621542e-01f, -8.30073059e-02f, -1.72879115e-01f, 1.11410268e-01f, 3.31389874e-01f, 1.76696286e-01f, 1.84349064e-02f,
  -1.42504245e-01f, -1.26193777e-01f, 1.32459253e-01f, 3.70515399e-02f, 2.53814757e-01f, -1.42852470e-01f, -2.18122393e-01f, -3.23512927e-02f, 1.04948990e-01f, 1.68701544e-01f,
  -1.84856266e-01f, -1.32934988e-01f, -2.21604750e-01f, -2.21758053e-01f, -1.01976365e-01f, -5.48234172e-02f, -2.38060758e-01f, -3.24819922e-01f, 2.26277694e-01f, 5.68709634e-02f,
  2.19024140e-02f, 2.73876905e-01f, 3.34876090e-01f, -2.13761672e-01f, 6.47093430e-02f, 3.24712023e-02f, -9.99131650e-02f, 2.02964976e-01f, 2.50728726e-01f, 3.01483423e-01f,
  2.87167430e-02f, 1.33907050e-01f, 1.24565065e-01f, -4.89550196e-02f, 2.86857605e-01f, -1.44560769e-01f, -1.36276945e-01f, 8.27346817e-02f, 8.16482678e-02f, -2.40478516e-02f,
  1.99188054e-01f, -6.30441085e-02f, -3.23294587e-02f, -1.56992331e-01f, -1.47104099e-01f, 5.15334494e-02f, 1.55261144e-01f, 2.27413908e-01f, -5.03911860e-02f, -1.43767789e-01f,
  1.51499942e-01f, 1.54210120e-01f, 2.68830895e-01f, -2.76860178e-01f, 1.43669233e-01f, 3.35937768e-01f, 2.35182330e-01f, 9.78674442e-02f, -1.82164416e-01f, -3.31157520e-02f,
  -3.01594645e-01f, -4.84948248e-01f, 7.68657997e-02f, 1.86020751e-02f, -6.19307272e-02f, 9.11327079e-02f, -3.67284641e-02f, -4.82928216e-01f, -1.71918105e-02f, 9.72498655e-02f,
  4.95858453e-02f, -5.29621057e-02f, -3.27974036e-02f, -5.57866022e-02f, 2.87647508e-02f, -1.82334065e-01f, 2.26430912e-02f, -1.32533191e-02f, -3.07263690e-03f, -1.65300980e-01f,
  9.97519046e-02f, -2.11774871e-01f, 9.97551829e-02f, -1.04717843e-01f, 3.28334600e-01f, 2.15780079e-01f, -1.00271441e-01f, 1.04854114e-01f, -9.64720994e-02f, -1.12984385e-02f,
  -4.19975780e-02f, 2.30166405e-01f, -4.97901998e-02f, 1.42866418e-01f, -2.44031977e-02f, 1.31733613e-02f, -1.14523046e-01f, -2.25038409e-01f, 2.89782703e-01f, -9.36903134e-02f,
  1.38467669e-01f, 5.20488769e-02f, 1.11950479e-01f, -1.89370811e-01f, 4.02014256e-02f, -1.69395670e-01f, 6.61979988e-02f, 1.16819605e-01f, 3.60448882e-02f, 1.80528134e-01f,
  1.60503224e-01f, -2.03155085e-01f, 5.19964052e-03f, 1.57037720e-01f, -1.21354826e-01f, 7.92297572e-02f, -9.85750929e-02f, -2.45424971e-01f, -3.90189499e-01f, 3.43148500e-01f,
  3.31913196e-02f, 1.80716515e-01f, 4.90216725e-03f, -7.13571087e-02f, -3.88551027e-01f, -6.45142019e-01f, -3.73535454e-01f, 2.52141394e-02f, 6.19561635e-02f, 1.92249745e-01f,
  -1.94635168e-01f, -4.34378833e-02f, 1.00715376e-01f, -1.48744211e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -2.63066106e-02f, -1.27296776e-01f, 2.25486249e-01f, 1.59410536e-01f, 1.36976272e-01f, 1.64137110e-01f, 1.99029639e-01f, -6.07006252e-02f, 3.87355126e-02f, 4.13319133e-02f,
  1.17850505e-01f, 1.30178079e-01f, -5.25603481e-02f, -3.02154034e-01f, 1.50247186e-01f, -4.22342569e-02f, -1.82545573e-01f, 1.68778732e-01f, 3.93690094e-02f, -3.10530216e-01f,
  7.71597847e-02f, 1.36992052e-01f, 1.60779893e-01f, 1.92400247e-01f, -9.35190767e-02f, -1.69979781e-02f, 1.90081179e-01f, -4.00526710e-02f, 2.73477018e-01f, 3.94283503e-01f,
  -1.39813647e-01f, 1.28967389e-01f, 2.99922466e-01f, -1.70874484e-02f, 1.04538873e-01f, -2.02636212e-01f, 3.03730458e-01f, 2.47800663e-01f, 4.09699231e-01f, 3.94306570e-01f,
  -1.13290930e-02f, 2.97691643e-01f, -1.20634055e-02f, 1.28579050e-01f, -3.38932812e-01f, -3.27697694e-01f, -1.61752358e-01f, -4.33795065e-01f, 5.53700328e-01f, -1.53151721e-01f,
  -2.40256041e-01f, -1.45065457e-01f, 3.21457297e-01f, 3.12159210e-01f, 5.67506492e-01f, 1.86483160e-01f, -1.32209528e-02f, -1.24432325e-01f, -1.09873883e-01f, 3.41092855e-01f,
  -3.64218950e-02f, 1.87974796e-01f, -2.00703457e-01f, -9.23771411e-02f, -1.76911261e-02f, -5.25288843e-02f, 1.08406954e-01f, 8.83324966e-02f, 1.09106846e-01f, 1.85173035e-01f,
  1.09758735e-01f, 2.61040665e-02f, 1.79654866e-01f, 1.59994334e-01f, 1.80566028e-01f, 2.20578879e-01f, -9.71398726e-02f, -6.83416650e-02f, -1.34406373e-01f, 7.19003975e-02f,
  -2.43570711e-02f, 7.21580461e-02f, 8.81021097e-02f, -5.26317162e-03f, -5.73395938e-02f, -1.22346863e-01f, -3.88033725e-02f, -1.23793386e-01f, 3.96991074e-02f, 6.59112586e-03f,
  5.86588122e-02f, 1.14199117e-01f, 8.56610388e-02f, 8.28806162e-02f, -1.33490026e-01f, -2.04688255e-02f, 3.46342385e-01f, 1.58350781e-01f, 1.73513144e-02f, 1.33148849e-01f,
  7.99154639e-02f, 7.02350438e-02f, 3.61448109e-01f, 8.57173651e-02f, -1.07346639e-01f, 1.35628164e-01f, -1.27885286e-02f, -1.36953518e-02f, -2.84271967e-02f, -2.48835146e-01f,
  -2.13324964e-01f, 1.82392150e-01f, -3.15121740e-01f, -8.36778339e-03f, -1.38040587e-01f, -4.34296936e-01f, 3.06796223e-01f, 1.32724002e-01f, 3.73834133e-01f, 4.51986969e-01f,
  -4.30905297e-02f, -3.89826186e-02f, 1.47519201e-01f, -2.27119312e-01f, 4.40647811e-01f, 4.60450083e-01f, -1.22207344e-01f, -1.56669214e-01f, 1.87321473e-02f, 2.73867160e-01f,
  1.43079804e-02f, 3.48020345e-01f, -1.21692428e-03f, -1.65335104e-01f, 2.26916410e-02f, 3.09511691e-01f, 1.89571187e-01f, 1.57096069e-02f, 2.68510729e-01f, 1.57823458e-01f,
  9.87827480e-02f, 3.41403395e-01f, -1.34594023e-01f, 3.42912674e-02f, -1.41457900e-01f, -3.39283556e-01f, -4.40706424e-02f, -1.43291475e-02f, -6.86085299e-02f, -3.41574788e-01f,
  -1.92465901e-01f, -1.29548050e-02f, 1.46428972e-01f, 8.26754048e-02f, -2.44177710e-02f, -2.89293416e-02f, 1.81799725e-01f, 2.72690833e-01f, 1.44439384e-01f, 2.24580299e-02f,
  2.14924380e-01f, 1.18711546e-01f, 2.20288381e-01f, 2.36433148e-01f, 2.17033029e-01f, -1.02080874e-01f, 3.49818841e-02f, 4.49916013e-02f, 1.64509133e-01f, 2.31469169e-01f,
  2.18053848e-01f, -1.36169810e-02f, -1.35205373e-01f, 2.91669250e-01f, -2.05549434e-01f, 1.93985745e-01f, 1.80485800e-01f, -5.84192872e-01f, 1.48656279e-01f, 4.01930846e-02f,
  -2.95134485e-01f, -3.61536801e-01f, -2.40779504e-01f, 2.28277028e-01f, 4.00763124e-01f, 1.20713018e-01f, -2.36064777e-01f, -4.69747093e-03f, 1.25675678e-01f, 1.54927075e-01f,
  1.66994676e-01f, -1.33073807e-01f, 1.38890907e-01f, -3.65986452e-02f, -8.49990696e-02f, -9.69523285e-03f, -1.64589867e-01f, -3.19691710e-02f, -4.71692719e-02f, 1.13377407e-01f,
  7.80362487e-02f, 5.42610139e-02f, -1.15878932e-01f, -1.76735535e-01f, 1.99560300e-01f, -6.42374903e-03f, 9.13338438e-02f, 3.01790815e-02f, 1.97151020e-01f, 6.71349615e-02f,
  1.45380571e-01f, 1.08491048e-01f, -1.07445613e-01f, -1.47154853e-01f, -7.39623851e-04f, 1.02139421e-01f, 1.68124557e-01f, -1.12643912e-01f, -7.49422088e-02f, 1.18786097e-01f,
  1.21918425e-01f, -6.80387467e-02f, -1.25929072e-01f, 1.53730065e-01f, 9.42653194e-02f, 1.23484731e-01f, 1.52701244e-01f, 1.77275445e-02f, 2.93050855e-01f, -8.32362100e-02f,
  -6.38578683e-02f, 2.54903406e-01f, 1.16632327e-01f, 1.95445344e-01f, 1.16266496e-01f, -3.97014804e-03f, -5.87072363e-03f, 1.11969113e-01f, -1.15553856e-01f, -1.78132445e-01f,
  4.66333777e-01f, -2.84971446e-01f, 1.73523307e-01f, 2.29509056e-01f, -1.31384835e-01f, -1.35630459e-01f, -9.63196903e-02f, 1.77631021e-01f, 3.28540236e-01f, -7.67320842e-02f,
  -1.08367227e-01f, 2.24709138e-01f, -2.05446795e-01f, -2.57883251e-01f, 1.55645639e-01f, 8.42754841e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  1.99655637e-01f, 1.41662747e-01f, 1.23283073e-01f, 7.83166066e-02f, 1.63879082e-01f, 2.47002453e-01f, 1.10565215e-01f, 3.20313245e-01f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  1.15107216e-01f, -1.02400236e-01f, 1.25006244e-01f, 1.04432747e-01f, -2.83371359e-01f, -5.52078756e-03f, -2.04704553e-01f, 5.36319762e-02f, 7.47386217e-02f, -2.76292294e-01f,
  -4.53144610e-02f, 1.40105590e-01f, -6.41996339e-02f, -3.10512275e-01f, -9.23900381e-02f, 1.51652262e-01f, 1.29167184e-01f, 1.71014797e-02f, -1.72315136e-01f, 2.70925630e-02f,
  -2.53110286e-02f, -2.69979149e-01f, 9.86961741e-03f, -1.95620537e-01f, 1.59844130e-01f, -9.14042145e-02f, 1.75493836e-01f, 1.76486149e-01f, 9.84467641e-02f, 8.52965191e-02f,
  -1.69531614e-01f, -2.67719299e-01f, 8.04774165e-02f, -4.03345115e-02f, -1.26779720e-01f, 6.35122135e-02f, -5.07343449e-02f, 1.46940321e-01f, -2.32724860e-01f, -1.85361773e-01f,
  -1.14637557e-02f, 1.57529503e-01f, -1.95986137e-01f, 9.07021482e-03f, 3.73766422e-02f, -3.41933936e-01f, 3.47724587e-01f, -1.33629993e-01f, -1.61896616e-01f, 5.07506192e-01f,
  4.67651524e-03f, -2.16733918e-01f, -1.82775810e-01f, -2.58581907e-01f, 6.85584098e-02f, 9.40993875e-02f, 2.76185930e-01f, 2.57292539e-01f, 1.47891209e-01f, 3.08374316e-01f,
  -1.86540261e-01f, -2.43068308e-01f, -1.68168351e-01f, -1.67219266e-01f, -7.37858415e-02f, -1.35080153e-02f, 1.02534875e-01f, -2.57421821e-01f, -3.03133518e-01f, -1.25969693e-01f,
  -2.63233364e-01f, 2.16629475e-01f, -5.20220697e-02f, -1.15429992e-02f, -4.30922247e-02f, -2.03384217e-02f, 4.42978352e-01f, -9.82483774e-02f, 1.44407034e-01f, -1.85138822e-01f,
  -2.21397996e-01f, -6.30188212e-02f, 6.01619110e-02f, 2.42138311e-01f, -3.31394151e-02f, -5.47317207e-01f, -1.38105944e-01f, -3.96661043e-01f, 9.40508321e-02f, 1.74655259e-01f,
  1.17597006e-01f, 3.22691411e-01f, -2.38423031e-02f, 1.46468580e-02f, -1.81864291e-01f, -1.89755172e-01f, -9.16609615e-02f, -1.86704114e-01f, -1.89870805e-01f, 1.37948409e-01f,
  1.17701720e-02f, 1.80618376e-01f, -1.05413690e-01f, 1.07492827e-01f, 1.72582939e-02f, -9.77143124e-02f, -1.45508096e-01f, 1.63602144e-01f, 5.02503455e-01f, -1.45551652e-01f,
  -2.79269516e-01f, 1.34486765e-01f, 1.98050380e-01f, -4.55455005e-01f, -8.73899907e-02f, 2.80533195e-01f, -9.00719538e-02f, -1.81291044e-01f, -3.00571546e-02f, -3.90437007e-01f,
  -2.19946712e-01f, -3.23633164e-01f, -5.79390079e-02f, -6.16144203e-02f, 3.48637670e-01f, 4.10815418e-01f, 3.64320055e-02f, 5.16734868e-02f, 3.13659251e-01f, 1.09677412e-01f,
  -3.14671956e-02f, 1.27355428e-02f, -1.34763969e-02f, -1.05191402e-01f, 2.04496104e-02f, -1.12051889e-01f, -1.67834327e-01f, -8.12913477e-03f, 2.29340255e-01f, -6.40544072e-02f,
  -2.87210345e-01f, -2.22792089e-01f, -2.24626571e-01f, 2.60995477e-01f, -8.69763736e-03f, -2.09504906e-02f, -2.02555776e-01f, -3.67813068e-03f, -2.54892051e-01f, 1.09679520e-01f,
  1.21021479e-01f, 3.11791450e-01f, 2.23698363e-01f, -2.17253983e-01f, 5.89918625e-03f, 1.19919807e-01f, 5.40344380e-02f, -3.60252038e-02f, -8.24187994e-02f, -2.59206593e-01f,
  -2.55548477e-01f, 4.72034588e-02f, 1.66599080e-02f, 1.95450827e-01f, 1.57675534e-01f, -1.49398804e-01f, 2.49658316e-01f, 1.52628705e-01f, 2.45022878e-01f, -2.27469847e-01f,
  -1.09840415e-01f, -2.63190418e-01f, 1.73040912e-01f, 1.07994705e-01f, -1.67043716e-01f, 2.66234158e-03f, 1.15121566e-01f, -2.37194031e-01f, 3.29986334e-01f, 3.43468904e-01f,
  1.93942010e-01f, -2.88576391e-02f, 2.67389268e-01f, -1.83012873e-01f, 4.44172248e-02f, -2.61914492e-01f, -2.29395200e-02f, 1.22311383e-01f, 1.17966093e-01f, 1.36835814e-01f,
  8.87427405e-02f, -1.67200044e-01f, -1.09202623e-01f, -5.06993160e-02f, -2.17324466e-01f, -2.34740213e-01f, -2.00010762e-01f, 5.07484712e-02f, 1.28763035e-01f, 5.76828718e-02f,
  1.93361163e-01f, -8.71969834e-02f, 3.58291306e-02f, -5.78948064e-03f, 2.07673863e-01f, 4.54296777e-03f, -2.41746977e-01f, -9.54294503e-02f, 3.11195496e-02f, -4.25258338e-01f,
  -2.14227047e-02f, 4.08321023e-01f, 3.34286183e-01f, -2.70214796e-01f, 1.81408748e-01f, -2.99377263e-01f, -1.49150595e-01f, -3.57375622e-01f, -4.77687232e-02f, 3.93608958e-02f,
  2.05960736e-01f, 2.87175626e-01f, -1.18546084e-01f, 1.40814096e-01f, -5.75358495e-02f, 9.86486971e-02f, 3.03467102e-02f, 4.04859111e-02f, 7.92623684e-02f, -1.53358266e-01f,
  -4.35123414e-01f, 2.07359746e-01f, -2.24921733e-01f, 2.49320939e-01f, -2.27291614e-01f, 9.40203890e-02f, 4.99227494e-01f, -1.64121035e-02f, -3.96455526e-02f, -2.94189882e-02f,
  -1.55239804e-02f, -3.43687415e-01f, 7.24707246e-02f, 2.25498259e-01f, 5.63372187e-02f, -3.20076868e-02f, -1.54946417e-01f, -1.85358092e-01f, -2.75334954e-01f, 6.23653159e-02f,
  -8.34376067e-02f, -3.62095356e-01f, 7.90105164e-02f, 2.67842025e-01f, -9.10729021e-02f, 2.40209654e-01f, -2.14461073e-01f, -1.49815828e-01f, -1.44962464e-02f, -1.83208898e-01f,
  -2.78646559e-01f, -2.01696709e-01f, -1.02874286e-01f, -2.78360210e-02f, 2.12991342e-01f, -2.71612078e-01f, -1.70877445e-02f, -1.63475901e-01f, 1.26663163e-01f, -1.56677678e-01f,
  -2.54495025e-01f, 2.10408866e-01f, 1.57406792e-01f, -3.63367617e-01f, 3.49187315e-01f, 2.95144916e-01f, 2.69045025e-01f, -1.89875573e-01f, 1.42473027e-01f, -4.66224372e-01f,
  -3.02932803e-02f, -4.34270024e-01f, 6.78960755e-02f, 6.79362416e-02f, -1.28690690e-01f, 3.37641299e-01f, 7.38116866e-03f, 8.23892467e-03f, 9.31490213e-02f, -3.36611792e-02f,
  -1.18326843e-01f, -7.47496188e-02f, 6.36898950e-02f, -1.45941064e-01f, 1.48307115e-01f, 8.65126550e-02f, -4.18100469e-02f, -1.49913564e-01f, 5.28371446e-02f, -6.97103590e-02f,
  -1.10247105e-01f, 4.52654064e-02f, 3.29867541e-03f, -9.09353867e-02f, 3.38170268e-02f, -4.05031182e-02f, 1.36581153e-01f, 2.78039753e-01f, 5.75855635e-02f, 2.84419835e-01f,
  1.78280786e-01f, 5.94732054e-02f, -2.31978148e-01f, -4.89511311e-01f, -1.69618174e-01f, -3.35823894e-01f, 2.17883103e-03f, 7.72329094e-03f, 9.86167509e-03f, 2.63359547e-01f,
  1.90270782e-01f, 1.08439192e-01f, 5.87440915e-02f, 3.50628160e-02f, 2.04383224e-01f, 2.25084051e-01f, -2.11712439e-03f, -3.01873267e-01f, 5.82308657e-02f, 1.98217466e-01f,
  2.79840261e-01f, 2.37452030e-01f, -3.92633706e-01f, -8.73273015e-02f, 1.13785058e-01f, -1.51605010e-01f, 9.73353237e-02f, 3.20182472e-01f, -3.05250108e-01f, -3.20815474e-01f,
  -3.38261962e-01f, 2.09280476e-01f, -6.67589232e-02f, 5.42109728e-01f, 5.69458604e-02f, 3.19968790e-01f, -5.42479865e-02f, -2.21967325e-02f, -1.15832970e-01f, -2.87106752e-01f,
  8.20562840e-02f, 2.39642430e-02f, -3.20675038e-02f, -3.69982012e-02f, 3.05983704e-02f, 1.03116997e-01f, -3.24922353e-02f, 4.11632843e-02f, -3.26727509e-01f, 8.17867592e-02f,
  5.55057265e-02f, 7.66656771e-02f, 1.12014033e-01f, 1.71952620e-01f, 1.06617920e-01f, -1.37701362e-01f, -2.39014089e-01f, 2.25556329e-01f, 2.62894720e-01f, -3.49875838e-01f,
  -1.41893223e-01f, 1.90380678e-01f, 8.92504528e-02f, 1.85073778e-01f, -3.59751806e-02f, 3.09475005e-01f, -3.04679513e-01f, -3.85976613e-01f, -4.96358946e-02f, -9.64561030e-02f,
  3.01143289e-01f, 3.28321487e-01f, -1.30543202e-01f, 2.64336139e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  5.36371358e-02f, 2.28702545e-01f, 2.09808037e-01f, -2.33265571e-02f, 7.23572001e-02f, 2.25757748e-01f, 2.85132945e-01f, 1.03461780e-01f, 4.15677935e-01f, 1.87210500e-01f,
  2.40690291e-01f, -1.12068810e-01f, 2.54518896e-01f, 1.84234113e-01f, 3.14309061e-01f, -3.81486505e-01f, -2.97472894e-01f, 2.79366583e-01f, 1.96052462e-01f, -2.07135528e-01f,
  7.70646036e-02f, -4.11101550e-01f, 8.27964172e-02f, -3.81652713e-01f, 3.28554511e-01f, 6.23285592e-01f, -6.71510324e-02f, 6.05533719e-01f, -2.41772488e-01f, -2.17086166e-01f,
  4.86103185e-02f, -2.98740100e-02f, 1.83799744e-01f, 3.15098703e-01f, 2.08813220e-01f, 2.64360011e-02f, 4.45846051e-01f, 3.57143991e-02f, -1.00591015e-02f, -7.70545751e-02f,
  -7.26832971e-02f, 8.46309513e-02f, -1.03864066e-01f, 3.67804438e-01f, -1.22426771e-01f, -1.54491723e-01f, 2.08014864e-02f, -1.01337239e-01f, -1.00121357e-01f, 1.90676808e-01f,
  -6.71027973e-02f, -4.40449178e-01f, -4.10098523e-01f, 3.57638568e-01f, -3.17337722e-01f, 4.77225006e-01f, -3.56975012e-02f, 1.60156906e-01f, 2.68202245e-01f, -2.17604384e-01f,
  1.75487548e-02f, 2.68208802e-01f, 3.77700254e-02f, 3.63112926e-01f, -1.73974723e-01f, 8.85790139e-02f, -1.00566246e-01f, 4.60046940e-02f, 1.07472405e-01f, 4.37684879e-02f,
  2.48304471e-01f, 2.87019581e-01f, 1.30865008e-01f, 3.50201756e-01f, 6.42155483e-02f, -2.14836329e-01f, 3.75385582e-01f, 2.60301650e-01f, 6.20273948e-02f, -1.86893567e-01f,
  -4.04783413e-02f, -4.54073064e-02f, -1.14040494e-01f, 1.98934555e-01f, 1.74092382e-01f, -1.80395111e-01f, -4.47390713e-02f, -4.16501760e-01f, -2.39709988e-01f, 4.03652966e-01f,
  -9.77539495e-02f, -1.77861881e-02f, 1.93699002e-01f, 4.82466519e-01f, 1.28415212e-01f, 4.23284441e-01f, -1.68225318e-01f, -3.12695839e-02f, 2.93724816e-02f, 6.24820814e-02f,
  1.02236703e-01f, 1.08848557e-01f, 2.39350975e-01f, 3.10726315e-01f, 2.39571139e-01f, 9.61253196e-02f, 3.47018056e-02f, -1.89811606e-02f, 4.17643376e-02f, 2.12166071e-01f,
  -9.81216654e-02f, -3.29216421e-01f, -2.45401308e-01f, -3.25841695e-01f, 5.47503121e-02f, 1.82443216e-01f, 8.82821232e-02f, 1.52624339e-01f, 1.26704305e-01f, -3.68887872e-01f,
  -8.59060362e-02f, 2.40090743e-01f, -1.37463257e-01f, -3.26064788e-02f, 1.53255016e-01f, 1.94633111e-01f, 1.75196230e-02f, 2.07646310e-01f, -2.71726698e-02f, 3.13016325e-01f,
  1.05465509e-01f, 2.02636160e-02f, -3.23507428e-01f, 3.70222121e-01f, 7.26430342e-02f, 4.29863065e-01f, -1.04703553e-01f, -2.25704700e-01f, 3.06255192e-01f, 2.02187464e-01f,
  1.30571306e-01f, -1.81386769e-01f, -3.13386887e-01f, 3.68467480e-01f, 2.10606545e-01f, 2.84814835e-02f, -3.10649365e-01f, -1.28716081e-01f, -2.42903978e-01f, -2.15781614e-01f,
  -3.65628116e-02f, -1.40596241e-01f, 3.61063540e-01f, -2.65768737e-01f, 8.07321165e-03f, 6.44401371e-01f, 5.27208567e-01f, 1.50394753e-01f, -6.77419454e-02f, -3.89167130e-01f,
  1.62560374e-01f, 2.30208993e-01f, 2.23995432e-01f, 2.74049997e-01f, -5.72331399e-02f, -7.84462169e-02f, -2.99855828e-01f, 1.72505245e-01f, -1.81322724e-01f, 2.70040452e-01f,
  -1.31103188e-01f, 8.13708603e-02f, 1.82250530e-01f, -2.32157871e-01f, -6.69622002e-03f, -9.06407684e-02f, 2.31569529e-01f, -1.16410516e-01f, -2.25042179e-01f, -1.22279525e-01f,
  -9.38404053e-02f, 8.72221664e-02f, -2.83243358e-01f, -3.02686393e-02f, -2.52621740e-01f, 3.16622019e-01f, 1.53379038e-01f, -2.08203062e-01f, 3.01439434e-01f, 5.19083619e-01f,
  -2.00379461e-01f, 2.67817348e-01f, 2.91349560e-01f, 3.37012112e-01f, -3.79350372e-02f, 7.75600150e-02f, 9.34476405e-02f, 2.82097518e-01f, 1.57674626e-01f, -2.27570161e-01f,
  1.57447815e-01f, 1.49713770e-01f, 4.18685466e-01f, 6.09781221e-03f, -2.26859570e-01f, 7.51466304e-02f, -1.28514796e-01f, 1.89208761e-01f, 1.40863389e-01f, 3.93224806e-02f,
  -1.70055613e-01f, -2.32174799e-01f, -1.80133820e-01f, 4.21657562e-01f, -1.36512876e-01f, 4.25897568e-01f, -1.27403587e-01f, -3.31120282e-01f, 2.38633782e-01f, -2.57146984e-01f,
  1.56361595e-01f, 7.92671666e-02f, 1.89070880e-01f, 2.62375891e-01f, -3.65789570e-02f, 6.81043863e-02f, 6.80617690e-02f, 9.86726210e-02f, 7.80597031e-02f, -1.38766572e-01f,
  -3.29492688e-02f, -9.52086784e-03f, -1.56208128e-01f, -9.85356867e-02f, 8.13590959e-02f, 9.37685892e-02f, 2.27761045e-01f, 9.28108767e-02f, 1.92056209e-01f, -1.64298788e-01f,
  2.68781129e-02f, 1.11688539e-01f, 1.41586568e-02f, -1.58266425e-01f, 1.30979255e-01f, -2.35504016e-01f, -1.63486287e-01f, -1.26825571e-01f, 1.68465927e-01f, 3.33471149e-01f,
  5.74979447e-02f, 1.31232604e-01f, -1.70943126e-01f, 4.70554978e-02f, 3.20879668e-02f, -1.19283549e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  8.99326429e-02f, 2.60501504e-01f, 2.11423673e-02f, 2.12995589e-01f, 1.20010011e-01f, 3.12919728e-02f, 4.18118507e-01f, -1.20300174e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  2.86373496e-01f, -5.53193033e-01f, 1.11555576e-01f, -2.12417752e-01f, 2.92548180e-01f, 2.67645925e-01f, 2.21717119e-01f, 1.71282724e-01f, 3.85226995e-01f, 3.79105568e-01f,
  5.13104618e-01f, -1.77566648e-01f, -1.66942552e-01f, -4.82334852e-01f, -3.36399943e-01f, 5.39716482e-01f, 5.64792603e-02f, -2.50648856e-02f, 2.66390562e-01f, 5.02586186e-01f,
  -3.53014529e-01f, 2.70131648e-01f, 3.40980768e-01f, 1.25373915e-01f, -6.06988430e-01f, 5.01653552e-01f, 4.06633224e-03f, 2.91235149e-01f, -1.21052705e-01f, 1.55249491e-01f,
  3.09762001e-01f, -1.67840928e-01f, 7.94571266e-02f, 1.23229884e-01f, 1.44065648e-01f, -5.15291750e-01f, 1.88802198e-01f, -7.89061114e-02f, -3.85716259e-01f, -1.19064011e-01f,
  -5.27313411e-01f, 9.14869606e-02f, -5.58431864e-01f, 2.42704958e-01f, -3.18581790e-01f, 5.04695594e-01f, -5.89871168e-01f, -5.35439193e-01f, 2.79979616e-01f, -2.00431183e-01f,
  -2.58817852e-01f, -5.17370462e-01f, 1.06526762e-01f, -2.57583082e-01f, -1.18816115e-01f, -4.41166520e-01f, -5.37311891e-03f, 6.24579132e-01f, -3.99374038e-01f, -3.25947374e-01f,
  -5.23753226e-01f, 4.81658056e-02f, 3.02984446e-01f, -7.31260404e-02f, 9.35077295e-02f, -4.08473283e-01f, -1.55216068e-01f, -3.48202109e-01f, 9.98743176e-02f, 1.00529566e-01f,
  3.35673131e-02f, -5.84232509e-01f, -3.34317476e-01f, 2.10454669e-02f, -1.02626942e-01f, -4.88246709e-01f, 5.09513309e-03f, -4.86975955e-03f, 2.25641772e-01f, -3.85108769e-01f,
  9.19251367e-02f, -5.67485876e-02f, -2.71600455e-01f, -3.74005586e-01f, -3.19189638e-01f, 1.46508276e-01f, 1.82211116e-01f, -1.70555171e-02f, 8.65117133e-01f, -9.72772092e-02f,
  -4.01531070e-01f, 1.00141410e-02f, -6.07944503e-02f, -5.77494502e-01f, -2.20868990e-01f, 2.00075805e-01f, -9.28837247e-03f, -2.13428721e-01f, -7.57178590e-02f, 2.70033604e-04f,
  1.17469830e-02f, -8.83916486e-03f, -6.57533228e-01f, -1.28004635e-02f, -1.64016068e-01f, -4.57879342e-02f, -1.31785110e-01f, -5.50047040e-01f, 3.88219863e-01f, -6.41483605e-01f,
  3.39386702e-01f, -1.52244881e-01f, -5.46362437e-02f, 3.69107276e-01f, 1.49270773e-01f, 2.87931591e-01f, 7.73252845e-01f, -1.36847481e-01f, -3.92334312e-01f, 3.05952311e-01f,
  -4.34643239e-01f, -5.15337408e-01f, 2.85000533e-01f, 1.32137746e-01f, 5.15544474e-01f, 2.85142660e-01f, -1.88185066e-01f, -8.38351399e-02f, 1.91612110e-01f, -9.17376252e-04f,
  1.99971810e-01f, -2.07255989e-01f, -9.40353870e-02f, 3.47057432e-02f, 3.45235765e-02f, 2.08758246e-02f, 7.65797853e-01f, 4.34022993e-02f, 2.42122829e-01f, 2.87089080e-01f,
  -1.23544894e-01f, -6.79780841e-01f, 1.26131877e-01f, 5.12565494e-01f, -2.96109140e-01f, 2.95409411e-01f, 6.75842404e-01f, 3.60334933e-01f, -1.47120636e-02f, -1.62444308e-01f,
  -4.27135795e-01f, 4.87636119e-01f, 1.69359460e-01f, -1.29300997e-01f, 5.02002001e-01f, 3.61691684e-01f, -2.13731945e-01f, 2.99778819e-01f, -3.21231663e-01f, 1.05511583e-01f,
  -1.42590702e-01f, 5.76750696e-01f, 4.67584431e-01f, 6.40145421e-01f, 1.46852747e-01f, -1.85663074e-01f, 1.24793626e-01f, -5.85450865e-02f, -3.08402896e-01f, -2.70614386e-01f,
  -2.63896346e-01f, 1.55340061e-01f, -3.97048742e-02f, 1.45263106e-01f, -9.09351930e-02f, 3.93443465e-01f, -2.05602795e-01f, -4.62892115e-01f, -4.55503672e-01f, 5.33149421e-01f,
  -2.72211164e-01f, -2.50488907e-01f, 4.25665557e-01f, 4.10420358e-01f, -2.77988404e-01f, 4.60906148e-01f, 5.02016954e-03f, 4.96753864e-03f, -3.16829890e-01f, 5.70957184e-01f,
  3.79381031e-02f, -1.70194849e-01f, 9.25744921e-02f, -1.96012422e-01f, 8.31170306e-02f, 5.91720879e-01f, 1.38609603e-01f, -2.06019923e-01f, -7.74093717e-02f, 4.90884095e-01f,
  -5.54463327e-01f, -1.81576148e-01f, -1.36331633e-01f, 2.95147449e-01f, 4.36374806e-02f, 4.04687196e-01f, 4.65335697e-01f, -6.42503381e-01f, -2.71903485e-01f, -3.59802365e-01f,
  -5.34185290e-01f, 2.21505426e-02f, 1.79822087e-01f, 3.05740744e-01f, 4.75897998e-01f, -5.03500819e-01f, 2.05536440e-01f, 2.06729084e-01f, 1.17033727e-01f, -2.30070561e-01f,
  1.01217337e-01f, 8.29445571e-02f, -4.91220415e-01f, 3.85273963e-01f, 1.61445469e-01f, -5.32929003e-01f, 8.72491449e-02f, -3.76230806e-01f, -4.41674665e-02f, -3.26374352e-01f,
  -6.19358003e-01f, -3.32838774e-01f, -1.35895893e-01f, 1.04169369e-01f, -3.25011075e-01f, -4.78828520e-01f, -4.18155342e-01f, 2.61788517e-02f, -2.37083733e-01f, -1.12633966e-01f,
  -2.03755111e-01f, 2.79777110e-01f, 8.03216174e-02f, 1.75186589e-01f, 6.18117213e-01f, 5.33773601e-01f, -3.75551701e-01f, 1.48499548e-01f, -2.22429007e-01f, -1.07141607e-01f,
  5.51819861e-01f, 2.72232324e-01f, -6.35153949e-01f, 1.39193535e-01f, 1.65674403e-01f, 1.06834568e-01f, 2.20682956e-02f, 3.24500710e-01f, -5.21963596e-01f, 4.31809247e-01f,
  -1.07934907e-01f, 1.39986977e-01f, 1.34687200e-01f, -2.15131506e-01f, -2.64101714e-01f, 9.37317982e-02f, -3.71973068e-01f, 2.16384932e-01f, -9.79525968e-02f, -3.62766206e-01f,
  -5.94865084e-01f, -4.22481567e-01f, 3.84058774e-01f, -6.18805401e-02f, -6.23942614e-01f, -3.39930624e-01f, -5.57804644e-01f, 1.48646668e-01f, 3.04041237e-01f, 2.55273968e-01f,
  -4.61521000e-01f, -2.12316075e-03f, -4.42557633e-01f, -2.47806340e-01f, 4.46517676e-01f, -2.16274500e-01f, 6.99133575e-01f, -7.84223229e-02f, 1.39793232e-01f, 4.35153842e-01f,
  -2.66320080e-01f, 4.56390560e-01f, -5.07333934e-01f, 1.35302052e-01f, 4.40804660e-01f, 1.83097363e-01f, -1.79440938e-02f, -1.61648691e-01f, 3.54101837e-01f, 2.33498868e-02f,
  -2.58770347e-01f, 2.58024544e-01f, 2.62388110e-01f, -1.65372983e-01f, -2.06705093e-01f, 1.44971132e-01f, -6.28265589e-02f, 9.03267562e-02f, -4.28113997e-01f, -5.55529706e-02f,
  2.51328081e-01f, -4.41531658e-01f, 5.11142194e-01f, -4.98028845e-01f, 4.10747051e-01f, 4.53560978e-01f, -3.69563967e-01f, -2.30246991e-01f, -3.33456695e-01f, 1.12409517e-01f,
  -2.99994826e-01f, 1.25127539e-01f, -3.16319801e-02f, 2.22351700e-01f, 1.93128347e-01f, -3.31821591e-01f, 2.02458769e-01f, -2.52187818e-01f, 6.24407828e-01f, -2.60825127e-01f,
  2.64608324e-01f, 3.87699068e-01f, 1.20417073e-01f, 3.39903414e-01f, 2.49175876e-01f, 3.54905277e-01f, 5.04428744e-02f, 5.35558999e-01f, 3.69472295e-01f, -5.23809314e-01f,
  3.91399443e-01f, 2.01069266e-01f, -3.95336092e-01f, -2.28954196e-01f, 4.31886286e-01f, -4.62312967e-01f, 1.27194569e-01f, 4.94868867e-02f, 5.62930942e-01f, -3.61770898e-01f,
  -3.58770013e-01f, 2.97430437e-02f, -3.30173522e-01f, 4.66947019e-01f, -7.54895434e-02f, -4.96765792e-01f, 1.09955862e-01f, 3.71943891e-01f, 3.23686600e-01f, 3.54253113e-01f,
  5.17017663e-01f, -7.59123042e-02f, 3.67985815e-01f, -2.47617990e-01f, 4.30683345e-01f, 3.14943463e-01f, 4.36231077e-01f, 4.60711271e-01f, 2.51934767e-01f, 7.82561302e-02f,
  3.56354356e-01f, 1.70864671e-01f, 1.34170771e-01f, -1.86573893e-01f, -3.73620316e-02f, 4.17116433e-01f, -3.23316216e-01f, 5.32359933e-04f, -3.40984404e-01f, -3.74449998e-01f,
  6.31063938e-01f, 3.37817132e-01f, -1.04980715e-01f, -1.01821885e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -8.81507024e-02f, 1.59222588e-01f, -1.86478436e-01f, -1.59298733e-01f, 2.66265366e-02f, 1.25797108e-01f, 1.09170549e-01f, 1.45610213e-01f, 2.08561510e-01f, 2.31722724e-02f,
  -1.64171830e-01f, -6.05551861e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    