/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.14175984e-01f, -1.13492928e-01f, 8.11149701e-02f, -5.04244976e-02f, 3.07684429e-02f, -7.18161389e-02f, -2.72262871e-01f, -2.63659079e-02f, 1.32269025e-01f, 2.58457549e-02f,
  2.64840692e-01f, 3.01372081e-01f, 3.24305177e-01f, 2.61538863e-01f, 1.00393042e-01f, -2.52145141e-01f, -1.81964934e-01f, -1.15466909e-02f, 2.08126590e-01f, 7.53677115e-02f,
  -5.89165278e-03f, -8.81932750e-02f, 9.35544819e-02f, 1.02032628e-02f, -1.60310775e-01f, 1.02820266e-02f, -1.08873531e-01f, -8.42505246e-02f, -1.21742338e-01f, -2.59573519e-01f,
  1.61625192e-01f, 1.77569643e-01f, 2.50398248e-01f, 2.36770406e-01f, 2.29905322e-01f, 1.23173863e-01f, 1.42518654e-01f, 2.19929770e-01f, 1.36843070e-01f, 1.55214667e-01f,
  2.19854087e-01f, 1.82974815e-01f, 1.47755563e-01f, 6.67224005e-02f, 2.09475964e-01f, 1.30053282e-01f, 1.23964816e-01f, 7.54786059e-02f, 1.61523476e-01f, 9.26646739e-02f,
  7.74291456e-02f, 8.19246694e-02f, 1.18814006e-01f, 1.13750510e-01f, 9.93428603e-02f, 1.04652748e-01f, -9.79882572e-03f, -2.50061229e-02f, 6.90913051e-02f, -1.80083349e-01f,
  -8.18406045e-03f, -9.67107341e-03f, -7.55082965e-02f, -1.03946276e-01f, -1.74545884e-01f, -5.93388081e-02f, -6.71974868e-02f, -9.08205286e-02f, -8.87355879e-02f, -9.00576189e-02f,
  -3.62666287e-02f, -6.97633773e-02f, -1.29352093e-01f, -1.08476020e-01f, -1.43090218e-01f, -3.62139940e-02f, -1.17061123e-01f, -1.70890734e-01f, -9.96288136e-02f, -1.34014919e-01f,
  -1.17883533e-01f, -5.71589498e-03f, -7.71546811e-02f, -8.64240900e-02f, -5.06953001e-02f, -3.47686037e-02f, -9.85838547e-02f, -1.82474051e-02f, 4.51234467e-02f, 3.01230364e-02f,
  2.05682293e-01f, 2.45973065e-01f, 9.91563872e-02f, 1.30275756e-01f, 1.62349641e-01f, 1.28961518e-01f, 1.86050326e-01f, 8.35227743e-02f, 2.21623570e-01f, 8.65446627e-02f,
  1.58209726e-01f, 1.05491668e-01f, 1.15145236e-01f, 1.10548757e-01f, 1.57086208e-01f, 1.09787516e-01f, 5.89474365e-02f, 1.56387642e-01f, 1.16371281e-01f, 6.38163760e-02f,
  1.23522937e-01f, 5.06471917e-02f, 1.56951204e-01f, 1.02533273e-01f, 8.61370489e-02f, 2.43235379e-01f, 1.24378376e-01f, 6.34927601e-02f, 1.39025077e-01f, -1.52585819e-01f,
  -7.97654614e-02f, -2.06796512e-01f, -3.24271351e-01f, 1.80673867e-01f, 3.25704604e-01f, 3.01673770e-01f, 4.14637417e-01f, 3.18759382e-01f, 1.80005565e-01f, -1.05163358e-01f,
  -2.47265458e-01f, -2.22679362e-01f, -3.33924502e-01f, -1.92083955e-01f, -6.81324974e-02f, -2.09630318e-02f, -1.39311656e-01f, -1.60884678e-01f, 7.20863342e-02f, 1.80536315e-01f,
  2.88967699e-01f, 1.48896173e-01f, -3.80837754e-03f, 4.62295786e-02f, 5.69488704e-02f, -1.21823743e-01f, -7.54585862e-02f, -4.36414964e-02f, -1.81610435e-01f, -2.37022489e-01f,
  -4.97654676e-01f, 1.88816190e-02f, -4.25195880e-02f, -8.58358294e-02f, -1.82323143e-01f, -4.12107632e-02f, -4.27288152e-02f, -3.27944532e-02f, 1.56610534e-02f, 2.20270511e-02f,
  -5.78185655e-02f, -1.37863439e-02f, -8.93487781e-02f, -6.84593990e-02f, 8.57077613e-02f, -5.21503836e-02f, 2.15808712e-02f, -1.16011113e-01f, -1.68056041e-01f, -7.21789673e-02f,
  -1.35387629e-01f, -5.09287529e-02f, -1.25353113e-01f, -3.00376415e-02f, 3.23094949e-02f, -9.85984802e-02f, -6.35848567e-02f, -1.01686949e-02f, -6.58456683e-02f, -7.25676715e-02f,
  4.11417782e-02f, -6.03008009e-02f, 1.41057909e-01f, 1.09327808e-01f, 8.44312385e-02f, -1.15784798e-02f, 5.06481454e-02f, 9.42767635e-02f, 9.46783349e-02f, 1.22375652e-01f,
  2.55864635e-02f, -4.69369395e-03f, 2.71767415e-02f, 6.03092574e-02f, -6.40970021e-02f, -5.57050051e-04f, 2.36556847e-02f, 1.69571545e-02f, -7.88185149e-02f, 2.39246190e-02f,
  -4.63997945e-02f, 2.95144189e-02f, -1.91003084e-02f, 4.30334872e-03f, -5.14820358e-03f, -7.08961952e-03f, 8.10346603e-02f, 9.05773938e-02f, 9.99369472e-02f, 1.14655212e-01f,
  -6.31005391e-02f, -1.49343282e-01f, -1.44006044e-01f, -1.30461697e-02f, -3.80637404e-03f, -5.43502234e-02f, -6.22976571e-02f, -6.83524385e-02f, -2.94631831e-02f, -6.77860901e-02f,
  1.27430726e-02f, 2.95722554e-03f, -5.74293472e-02f, -9.70494654e-03f, 3.04639824e-02f, 4.13514264e-02f, -3.83488387e-02f, -1.03445329e-01f, -5.06732576e-02f, 8.58696643e-03f,
  2.52768733e-02f, -2.22652443e-02f, -5.01403473e-02f, -7.05851838e-02f, 6.11530691e-02f, -7.63221905e-02f, -7.20983818e-02f, 2.97020879e-02f, 3.28964321e-03f, 1.03729948e-01f,
  -1.89699113e-01f, 1.08948268e-01f, -2.18757540e-01f, 5.01390174e-02f, 2.63704769e-02f, -1.80953860e-01f, -1.41061544e-01f, 1.52640021e-03f, 1.96103722e-01f, 5.04550003e-02f,
  3.03630590e-01f, 1.65203035e-01f, 1.69635743e-01f, 1.14758769e-02f, -1.51625022e-01f, -3.34816217e-01f, -2.74011880e-01f, -3.03211242e-01f, -2.11594939e-01f, 4.16516932e-03f,
  2.21925095e-01f, 1.86664000e-01f, -2.25724485e-02f, 1.57684267e-01f, 3.40845436e-01f, 9.72411782e-02f, 2.27988549e-02f, 8.32097232e-02f, 7.24409372e-02f, 8.16968158e-02f,
  2.58449852e-01f, -3.12318802e-02f, 1.29831001e-01f, 1.32825673e-01f, 1.88123763e-01f, 1.38390794e-01f, 9.24792513e-02f, 1.30397856e-01f, 6.15749992e-02f, 5.61121665e-02f,
  6.20093495e-02f, 1.54055938e-01f, 1.10194255e-02f, 1.78452507e-01f, 9.29477364e-02f, 1.33165896e-01f, 1.05437100e-01f, 7.60646444e-03f, 4.29534800e-02f, 1.57420352e-01f,
  2.49201044e-01f, 4.08818759e-02f, -3.35367806e-02f, 1.33372471e-01f, 7.65559301e-02f, 8.18263441e-02f, 9.66829807e-02f, 9.93223041e-02f, 4.56961617e-02f, 2.24401399e-01f,
  -1.55835271e-01f, -2.01804012e-01f, -9.37116817e-02f, -1.29802883e-01f, -4.45541926e-02f, -6.71095997e-02f, -8.43395963e-02f, -1.11096844e-01f, -1.09097779e-01f, -9.34725553e-02f,
  -1.28161296e-01f, -1.26333609e-01f, -1.42284796e-01f, -2.07662627e-01f, -8.19859281e-02f, -1.50167271e-01f, -1.51362121e-01f, -7.00511783e-02f, -1.81883335e-01f, -1.60074323e-01f,
  -6.81074783e-02f, -1.96697991e-02f, 1.19672471e-03f, 1.08213862e-02f, -7.98180625e-02f, -2.04022110e-01f, -1.37024522e-01f, -8.35446119e-02f, -1.21495448e-01f, -9.75147933e-02f,
  5.23934782e-01f, 1.08625805e-02f, 1.53531790e-01f, 6.17182292e-02f, 4.41624410e-02f, 1.17159024e-01f, 1.80227056e-01f, 1.18485890e-01f, 1.17020227e-01f, 2.29999393e-01f,
  7.03156218e-02f, 9.90077779e-02f, 1.23856112e-01f, 1.23293646e-01f, 9.82036963e-02f, 8.34124312e-02f, 1.22219808e-01f, 1.41041547e-01f, 1.57238156e-01f, 2.26629242e-01f,
  1.46811962e-01f, 1.16305491e-02f, 7.20819831e-02f, 7.90266320e-02f, 1.35945737e-01f, -1.88311599e-02f, 1.77038997e-01f, 1.43580794e-01f, -8.96530896e-02f, 2.30571449e-01f,
  4.02129501e-01f, 2.88527012e-01f, -2.80580550e-01f, 8.56630430e-02f, -1.36972353e-01f, -2.15696886e-01f, -6.62062690e-02f, 1.36698782e-01f, -3.84877883e-02f, -8.73725638e-02f,
  9.08364654e-02f, -1.01820953e-01f, -2.97111720e-01f, -1.97243348e-01f, -2.05595363e-02f, -5.41107841e-02f, -3.26100111e-01f, -3.18643302e-01f, -1.67997584e-01f, -8.94784629e-02f,
  -2.71768689e-01f, -9.46223214e-02f, 5.74653745e-02f, -1.24091879e-01f, -1.79931328e-01f, -3.87277007e-01f, -2.15461701e-01f, -9.37341005e-02f, -1.11743353e-01f, -3.89114469e-01f,
  -1.79730803e-01f, 3.59709144e-01f, -2.20748350e-01f, -7.85840023e-03f, -1.82791520e-02f, 7.63136148e-02f, 3.18250991e-02f, -6.47181422e-02f, 5.58402650e-02f, -7.09653199e-02f,
  -1.17794022e-01f, -8.27255007e-03f, -1.55196398e-01f, -1.06949888e-01f, 3.46346088e-02f, 3.08398716e-03f, 2.11263951e-02f, -3.73807512e-02f, -2.45876219e-02f, 7.33175278e-02f,
  -5.00775427e-02f, -1.03242680e-01f, -4.28872667e-02f, -5.85980713e-03f, 8.53343084e-02f, -2.09485516e-01f, 1.35004222e-02f, 5.29053845e-02f, 4.05911217e-03f, -6.13012873e-02f,
  -8.96765515e-02f, 4.19837609e-02f, 6.64328784e-02f, 7.30649158e-02f, 6.09151684e-02f, 1.08225480e-01f, 5.12219518e-02f, 1.08349994e-02f, 5.86087517e-02f, 1.36979967e-01f,
  7.39948004e-02f, 4.54059988e-02f, 2.24226881e-02f, 6.39732406e-02f, 1.29904947e-03f, 4.26417142e-02f, 9.62764472e-02f, 4.67681922e-02f, 5.51839545e-02f, 1.11267999e-01f,
  1.14551075e-02f, 1.28965199e-01f, 6.63069040e-02f, -8.82058442e-02f, 5.97112626e-02f, 4.02515903e-02f, -5.59240626e-03f, 9.66784656e-02f, 1.55096203e-01f, 7.02654049e-02f,
  -1.34506330e-01f, -7.10026026e-02f, -9.01142322e-03f, -4.32677474e-03f, -1.11383662e-01f, 1.73152760e-02f, -1.48525923e-01f, 4.53199353e-03f, -2.27931645e-02f, -7.18248934e-02f,
  4.82313149e-02f, -5.02228513e-02f, -6.52080253e-02f, -9.27403197e-02f, -1.67890936e-01f, -2.01347843e-02f, -3.04311588e-02f, -1.64534897e-01f, -4.54112813e-02f, 8.06264207e-02f,
  -2.12403033e-02f, -8.86706337e-02f, -7.41118342e-02f, -1.75652906e-01f, 1.47099578e-04f, -2.29032174e-01f, -2.17910603e-01f, -1.91851720e-01f, -2.21605673e-01f, -1.24794938e-01f,
  1.95177481e-01f, 3.44643831e-01f, 9.17123631e-02f, -5.02607636e-02f, 1.07563689e-01f, 3.95560861e-01f, 5.26155472e-01f, 3.02585930e-01f, -1.46950744e-02f, 1.05933428e-01f,
  7.90289268e-02f, -9.20879468e-02f, 1.41042307e-01f, 9.23719332e-02f, 3.42082202e-01f, 2.77104408e-01f, 2.37121403e-01f, 1.81218684e-01f, -2.25164052e-02f, -6.50215521e-02f,
  1.90183129e-02f, -1.73994601e-01f, -1.87843040e-01f, 2.83099990e-02f, -2.28445217e-01f, -1.20165072e-01f, -3.10737193e-02f, -1.95606798e-01f, 4.18578722e-02f, -2.21454993e-01f,
  -1.32244617e-01f, 1.59166396e-01f, 2.21571788e-01f, 1.03368219e-02f, 1.51767684e-02f, 9.89210978e-02f, 1.70403779e-01f, -4.72215638e-02f, 1.02847092e-01f, 8.70587006e-02f,
  -9.46774632e-02f, 1.31836906e-02f, 6.84471354e-02f, -6.41516075e-02f, 6.67840764e-02f, 5.05668223e-02f, 1.00751380e-02f, 5.37371673e-02f, 6.57230243e-02f, -6.92004571e-03f,
  6.89577237e-02f, -2.12594327e-02f, 8.12450796e-02f, 1.53112650e-01f, 1.60022765e-01f, 1.40135273e-01f, 1.65244997e-01f, -1.28388470e-02f, 1.23216555e-01f, -1.18581429e-02f,
  -1.33082075e-02f, -7.79165179e-02f, -1.51885256e-01f, -1.30345851e-01f, -8.19624886e-02f, -4.59583290e-02f, -9.15052742e-02f, -6.62333518e-02f, -5.36740050e-02f, -1.09647818e-01f,
  -5.02849407e-02f, 2.39197966e-02f, -1.37767363e-02f, -2.02817470e-02f, -1.50524423e-01f, -2.76773293e-02f, -3.27903219e-02f, -7.49057084e-02f, -7.04854801e-02f, -2.13663224e-02f,
  -4.39144857e-02f, -6.78871199e-02f, -2.10539311e-01f, -6.37857318e-02f, -9.09434408e-02f, -3.93161364e-02f, -2.12352738e-01f, -1.23060912e-01f, -1.93889245e-01f, -1.26227155e-01f,
  5.35796210e-02f, 3.71804267e-01f, 1.03375837e-01f, 8.63357410e-02f, 1.96075882e-03f, -4.36381027e-02f, 8.07580426e-02f, 5.23297936e-02f, 1.05101667e-01f, 2.06943735e-01f,
  -1.89452302e-02f, 6.11474551e-02f, 6.73815906e-02f, 7.53789645e-05f, 8.00373182e-02f, 6.54197708e-02f, -4.70831292e-03f, 1.22305758e-01f, 9.39067975e-02f, -7.58135468e-02f,
  3.24118398e-02f, 1.80091053e-01f, 2.79719055e-01f, 3.56949717e-01f, 4.70193885e-02f, 1.99326098e-01f, 1.47748336e-01f, 8.89649242e-02f, 2.92909205e-01f, 2.91912764e-01f,
  -4.57372129e-01f, 2.13040352e-01f, 4.25840497e-01f, 3.75447609e-02f, 3.27152073e-01f, 3.38768601e-01f, 2.93502390e-01f, -1.53938994e-01f, -7.86073282e-02f, 1.33816168e-01f,
  1.52418166e-01f, -1.47489309e-01f, -2.70293411e-02f, -1.41810358e-01f, -6.49096444e-02f, 3.00807714e-01f, 2.15065509e-01f, 8.35395306e-02f, -5.32363318e-02f, -3.28145064e-02f,
  5.10128625e-02f, -9.06799659e-02f, -1.28788829e-01f, -1.24540113e-01f, -1.88351364e-03f, -3.81588489e-02f, 2.00912759e-01f, 4.54672016e-02f, 1.80408478e-01f, 1.88052237e-01f,
  3.33458722e-01f, -1.25825241e-01f, -5.04346304e-02f, -1.53089598e-01f, 4.87278998e-02f, -2.04463050e-01f, 2.30551139e-02f, -6.10924512e-02f, -4.96794619e-02f, 5.87096848e-02f,
  6.66459352e-02f, -1.02286205e-01f, -6.88235983e-02f, 1.76055338e-02f, -6.28881752e-02f, -1.32168815e-01f, -9.45640653e-02f, -1.52895108e-01f, -9.03365202e-03f, -2.40295921e-02f,
  5.50778769e-03f, 1.51180878e-01f, 6.46895245e-02f, 2.66576633e-02f, -1.64468408e-01f, -9.29682329e-02f, 2.82774819e-03f, -4.34766859e-02f, 1.01179769e-02f, -1.40367478e-01f,
  -3.75195742e-02f, 1.38611540e-01f, 6.86717629e-02f, -5.74498065e-02f, -3.46998833e-02f, 7.55512044e-02f, 5.32460399e-02f, 1.27782270e-01f, -3.36588025e-02f, 6.88112825e-02f,
  8.81480461e-04f, 6.85524568e-02f, 1.21160988e-02f, 5.41377813e-02f, 8.32665265e-02f, 1.73635498e-01f, 7.75763094e-02f, 8.79872516e-02f, 4.32146415e-02f, 7.79996580e-03f,
  -1.96914189e-03f, 4.05717408e-03f, 8.34431127e-02f, -1.01601509e-02f, 1.09957248e-01f, 1.95054580e-02f, 9.67546478e-02f, -1.97728705e-02f, 7.01633096e-02f, 9.21008289e-02f,
  -2.03746498e-01f, 4.23090085e-02f, -3.78587656e-02f, -1.13207251e-01f, 7.41839558e-02f, -7.52472952e-02f, -5.41314902e-03f, 9.20181628e-03f, -3.70224416e-02f, -5.88483289e-02f,
  -8.33219662e-02f, -1.07608758e-01f, 6.50108904e-02f, -5.78984134e-02f, 3.99606749e-02f, -8.66953582e-02f, -1.10868447e-01f, 1.37786064e-02f, -6.26720935e-02f, 7.83254057e-02f,
  -4.75928374e-03f, 5.87896332e-02f, -7.93727785e-02f, 2.11351942e-02f, 1.08564226e-02f, 2.10498143e-02f, 1.06312126e-01f, -1.41126830e-02f, 1.45504195e-02f, -4.85034436e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.37364191e-01f, -8.94435942e-02f, -6.30032569e-02f, 3.75643283e-01f, -1.11322496e-02f, -1.33461684e-01f, -4.05681461e-01f, -3.00843809e-02f, 2.27569416e-01f, 2.06776544e-01f,
  2.24219874e-01f, 3.67074281e-01f, 2.74920732e-01f, 2.17204288e-01f, 1.51698157e-01f, -1.40933553e-02f, 1.86666191e-01f, 7.60292560e-02f, 7.75762349e-02f, -3.38508375e-02f,
  8.77115317e-03f, -2.39732359e-02f, 1.09621763e-01f, 1.57350883e-01f, 9.82622355e-02f, 1.37968436e-01f, 2.64518373e-02f, -2.24540770e-01f, -1.14274867e-01f, 8.11424851e-03f,
  -9.28941369e-02f, -3.55711998e-03f, 3.42296451e-01f, 3.03340256e-01f, 2.40062118e-01f, 1.30770773e-01f, 1.47418797e-01f, -1.09227619e-03f, 8.17977116e-02f, 1.16642276e-02f,
  1.01826247e-02f, -2.09895615e-02f, 7.56926462e-02f, 9.91206616e-03f, -1.14849500e-01f, -2.81988755e-02f, 2.45400295e-01f, 3.70533839e-02f, 3.71296480e-02f, 1.01857975e-01f,
  2.38629609e-01f, -4.47434187e-03f, -9.89331082e-02f, 3.38673592e-03f, 1.97304502e-01f, 1.13950312e-01f, 4.83435914e-02f, 1.43934041e-01f, 3.87804508e-02f, 1.07277803e-01f,
  2.09763899e-01f, 1.80723101e-01f, 8.79711062e-02f, 3.25877182e-02f, 3.16273645e-02f, -7.64181092e-03f, -2.48618543e-01f, -9.62469876e-02f, -4.83996235e-02f, -7.16759339e-02f,
  -1.26136318e-01f, -2.79171299e-02f, -4.16051447e-02f, -1.76686853e-01f, 3.95650417e-02f, -6.39401227e-02f, -2.56029278e-01f, -1.71483972e-03f, -6.72119707e-02f, -7.80671313e-02f,
  -4.79801856e-02f, -1.86682984e-01f, -1.02639772e-01f, -1.52353406e-01f, -1.13060161e-01f, 5.60160242e-02f, -6.98167086e-02f, -3.43564823e-02f, -1.20688103e-01f, -1.44289777e-01f,
  -6.50064647e-02f, 1.02088884e-01f, 1.79961920e-01f, 6.51353672e-02f, 6.46393597e-02f, -3.25546153e-02f, 1.28285825e-01f, -1.28625080e-01f, -1.87803641e-01f, -1.23594671e-01f,
  3.58632952e-02f, 5.77061176e-02f, -3.26126814e-02f, 6.40860945e-02f, -1.26113370e-01f, 3.24322283e-02f, 2.46724948e-01f, 2.08266392e-01f, 1.17557786e-01f, 8.46107602e-02f,
  1.56041831e-01f, -5.05459309e-02f, -9.93016139e-02f, 3.94313000e-02f, -2.39997581e-02f, 1.29502848e-01f, -7.55386055e-02f, -1.05000652e-01f, -1.52288243e-01f, -1.08643271e-01f,
  3.52309734e-01f, 8.67774725e-01f, 6.61161169e-02f, 7.79378973e-03f, 9.07659009e-02f, 3.74049932e-01f, 7.84897983e-01f, 3.21874022e-01f, -1.54338136e-01f, 3.93582702e-01f,
  3.24409544e-01f, -2.28445888e-01f, -1.94510832e-01f, -1.86719954e-01f, 1.90324783e-01f, 5.01890838e-01f, 1.48160040e-01f, -9.63658616e-02f, -5.01534045e-01f, -6.37006462e-02f,
  1.82754070e-01f, 2.93394357e-01f, 3.83213721e-02f, -7.12492615e-02f, 2.10746214e-01f, -3.52533281e-01f, 1.22686632e-01f, 3.26687634e-01f, 5.46875894e-01f, 5.34726977e-01f,
  1.18551835e-01f, 3.62462044e-01f, -4.96567935e-01f, -6.18260764e-02f, 1.54936463e-02f, -8.11736956e-02f, -1.88420132e-01f, -1.50442347e-01f, -2.21772045e-02f, 9.89473090e-02f,
  1.51979402e-01f, 1.37196004e-01f, 2.21992761e-01f, -2.93972064e-02f, 2.09834054e-02f, -1.24206528e-01f, -4.31048311e-02f, -4.95951250e-02f, -1.27923369e-01f, -9.87138674e-02f,
  2.08752885e-01f, 2.29928255e-01f, -3.52368951e-02f, -3.92062515e-01f, -2.83333480e-01f, -4.13243085e-01f, 2.93722283e-02f, -1.76816225e-01f, -1.77800506e-01f, -1.15793191e-01f,
  -2.60524273e-01f, 5.39951175e-02f, 1.39746871e-02f, -2.65671194e-01f, -1.11656345e-01f, -1.57063290e-01f, 3.78451403e-03f, 5.31744659e-02f, -1.85816437e-02f, -5.37069663e-02f,
  -1.94707543e-01f, -2.48090595e-01f, -2.36451969e-01f, -1.71242595e-01f, -2.94235468e-01f, 9.08386260e-02f, 9.33188107e-03f, -1.25175519e-02f, -2.29876012e-01f, -2.54621506e-02f,
  -1.10166371e-01f, 2.82673258e-03f, -1.40780017e-01f, -1.23626463e-01f, -1.63187031e-02f, -2.61289239e-01f, -2.57549256e-01f, -1.50595576e-01f, -1.82959527e-01f, 1.43331349e-01f,
  -1.30983442e-01f, -2.02291206e-01f, -2.45600730e-01f, 4.50338684e-02f, 3.21597189e-01f, 1.43155232e-01f, 1.65222988e-01f, 5.68709485e-02f, 3.40089142e-01f, 2.83550862e-02f,
  3.18133831e-01f, 3.79966684e-02f, 3.06584269e-01f, -1.03714429e-02f, -3.05096835e-01f, -1.77630156e-01f, 2.07403019e-01f, 5.29958420e-02f, 2.15155184e-02f, -1.22998223e-01f,
  3.41354311e-02f, -2.60532796e-01f, -4.93579566e-01f, -5.30076325e-01f, -3.55589360e-01f, -4.75033015e-01f, -1.84175909e-01f, -2.57822692e-01f, -1.32785335e-01f, -3.97232294e-01f,
  -5.06061435e-01f, -4.89394516e-02f, -8.04634213e-01f, -6.15329385e-01f, -9.75659192e-01f, -8.52373660e-01f, -4.83061403e-01f, -2.03070983e-01f, -4.70660269e-01f, -5.50082147e-01f,
  5.01629822e-02f, 7.08014488e-01f, 4.68300849e-01f, 4.49317992e-01f, 4.85017300e-01f, -6.72214746e-01f, -1.03066516e+00f, -3.76664311e-01f, 2.27989212e-01f, 4.27299878e-03f,
  -1.44648924e-01f, -1.46162689e-01f, -2.15927120e-02f, -7.28883892e-02f, -1.15704045e-01f, 3.03411961e-01f, -4.49281961e-01f, -4.25760031e-01f, -3.40369344e-01f, -5.10145068e-01f,
  5.83884478e-01f, -3.03053707e-01f, -1.55192940e-02f, -1.25143453e-01f, -1.59185454e-01f, -2.19206791e-02f, -6.65090606e-02f, -1.62584588e-01f, -1.01873629e-01f, -2.78595924e-01f,
  -2.13686824e-01f, -1.04506038e-01f, 3.23043168e-02f, 7.29630813e-02f, -5.54477833e-02f, -7.25035295e-02f, -3.52129430e-01f, -1.78941637e-02f, -8.24871957e-02f, -4.47589196e-02f,
  -8.06332752e-02f, -3.92939776e-01f, 1.31286398e-01f, -8.82001668e-02f, -1.08970227e-02f, -1.28805310e-01f, 4.04165983e-02f, -1.35953069e-01f, -6.69157356e-02f, -1.07186586e-02f,
  -3.74281337e-03f, 7.93879330e-02f, -5.62694371e-02f, 6.51795268e-02f, 1.07093573e-01f, 1.02025680e-01f, 1.74716376e-02f, 7.90244564e-02f, 5.00875413e-02f, 1.75047413e-01f,
  -2.37830430e-02f, -1.01564266e-01f, 1.56659707e-01f, 5.25447018e-02f, 4.49444763e-02f, -2.06388846e-01f, -1.30635455e-01f, 2.00066447e-01f, -3.96309868e-02f, -8.55769515e-02f,
  5.86220669e-03f, -1.31661266e-01f, -9.67831388e-02f, 2.07188651e-01f, -3.54271710e-01f, -5.85101284e-02f, -1.90258309e-01f, 1.91042989e-01f, 6.83497041e-02f, -4.16949302e-01f,
  9.59986150e-01f, -4.00511235e-01f, 2.63586134e-01f, 1.44466251e-01f, -1.32363707e-01f, -5.21445908e-02f, -1.74043812e-02f, -2.69239619e-02f, -1.89917032e-02f, -3.07040662e-03f,
  -1.60505578e-01f, 9.51851308e-02f, 7.67648220e-02f, -1.22921906e-01f, -4.77929674e-02f, 7.46278837e-02f, -1.61459282e-01f, 1.75212756e-01f, 1.13562420e-02f, -2.01727688e-01f,
  -2.10446581e-01f, -2.12708395e-02f, 4.67452556e-01f, 3.69623899e-01f, 7.39045516e-02f, 1.33573189e-01f, 3.90280902e-01f, 2.86672086e-01f, 2.88701415e-01f, 3.52046311e-01f,
  1.07696772e+00f, 3.92681926e-01f, 2.30202705e-01f, 3.48277003e-01f, -3.08088064e-01f, -6.33147895e-01f, -5.73754489e-01f, 1.31446362e-01f, 2.64506727e-01f, 3.40424120e-01f,
  -1.62323669e-01f, -4.22927260e-01f, -2.85170637e-02f, -5.84564567e-01f, -5.28533638e-01f, -1.05500378e-01f, 8.28015730e-02f, -2.43755892e-01f, -6.59403741e-01f, -8.10755968e-01f,
  -5.91140270e-01f, 1.22099288e-01f, 4.64405149e-01f, 9.74922404e-02f, 3.92731339e-01f, -9.43204239e-02f, 5.88965714e-01f, 4.69406903e-01f, 6.21847063e-03f, 2.81352669e-01f,
  4.82157916e-02f, 9.84747767e-01f, -4.88198966e-01f, -2.30536833e-02f, 7.34621584e-02f, -4.30704206e-02f, -2.48444185e-01f, 3.99073184e-01f, -1.30411670e-01f, 8.09307918e-02f,
  -2.14124098e-01f, -1.28762901e-01f, -2.32446659e-02f, -1.75171793e-01f, 1.11216463e-01f, -2.63248473e-01f, 3.00586164e-01f, 7.29379579e-02f, 1.25835285e-01f, 1.25106886e-01f,
  -5.93212962e-01f, -2.55305748e-02f, 1.66746736e-01f, -1.28293142e-01f, 9.18689277e-03f, -2.86086828e-01f, 1.54761478e-01f, 3.97242494e-02f, 1.84441060e-01f, 4.98599023e-01f,
  -1.05262827e-02f, -7.13526160e-02f, -1.51255401e-02f, 1.79618776e-01f, -6.00585863e-02f, 7.99805671e-03f, 6.48494959e-02f, -7.34151378e-02f, -5.37208766e-02f, -2.06458066e-02f,
  4.88268137e-02f, 1.41005531e-01f, 1.04831696e-01f, 1.24195136e-01f, 7.09531014e-04f, 3.97781916e-02f, -2.15283602e-01f, 7.50769451e-02f, 5.19562289e-02f, 8.39513019e-02f,
  -3.12564075e-01f, -4.47408222e-02f, 1.49993107e-01f, 4.57871296e-02f, -1.62499949e-01f, 6.17330312e-04f, -1.26993552e-01f, -4.11202312e-02f, 9.85388234e-02f, 1.54858708e-01f,
  -9.50457007e-02f, -3.86885613e-01f, -1.42222404e-01f, -1.84191391e-01f, 1.05884083e-01f, 6.51839674e-02f, -5.19369505e-02f, 7.62847736e-02f, 9.97663289e-02f, -8.18015561e-02f,
  -2.30357364e-01f, 5.69200106e-02f, 2.37529829e-01f, -2.26636484e-01f, -2.71441847e-01f, 9.04831514e-02f, -1.04116581e-01f, -2.00446352e-01f, -2.72585154e-01f, 5.51541895e-02f,
  7.26997554e-02f, -2.31325656e-01f, -3.81730020e-01f, -1.92552015e-01f, -7.22211152e-02f, -3.56978059e-01f, -2.58310348e-01f, -1.68483421e-01f, -2.52289832e-01f, 1.32902339e-01f,
  6.49888694e-01f, 1.66778192e-01f, 2.28190303e-01f, 2.93541729e-01f, 4.49897230e-01f, 7.27232873e-01f, 7.10208595e-01f, 3.49843919e-01f, 1.35687172e-01f, 2.47759566e-01f,
  2.46385798e-01f, -1.09417692e-01f, 1.59873188e-01f, -1.14123277e-01f, 2.95605157e-02f, 1.02088995e-01f, -2.80135814e-02f, -8.84519517e-02f, 1.13632299e-01f, 1.45404115e-01f,
  5.93399666e-02f, 2.98653066e-01f, 2.05702558e-02f, -3.66611034e-02f, -1.28976017e-01f, -1.14719644e-01f, 2.77779938e-04f, 7.70504475e-02f, -5.47724450e-03f, -5.71703315e-01f,
  -4.11097407e-01f, 1.09590806e-01f, -2.17015743e-01f, -2.67811716e-01f, -1.47528991e-01f, -1.96334437e-01f, -1.49855232e-02f, -2.26966485e-01f, -7.61245117e-02f, -1.39717937e-01f,
  -8.70320722e-02f, -1.28268212e-01f, -3.36791873e-02f, 2.96788901e-04f, 1.65366046e-02f, 6.11932650e-02f, -8.04293230e-02f, -1.64810568e-01f, -2.26539597e-01f, -2.34695867e-01f,
  -2.44993567e-01f, -9.33327004e-02f, 1.37813520e-02f, 9.15401354e-02f, -2.19529495e-03f, -1.79601565e-01f, 6.25682026e-02f, -3.65370438e-02f, -8.67863074e-02f, -2.12229595e-01f,
  -2.86740512e-01f, -2.68599182e-01f, -9.45131034e-02f, -8.04041177e-02f, 1.03982531e-01f, 9.15961266e-02f, -1.03593454e-01f, 9.13404450e-02f, 7.11151138e-02f, 4.28115427e-02f,
  -1.64208829e-01f, -1.04937151e-01f, -6.77466467e-02f, 6.31927773e-02f, -8.74255896e-02f, -7.20248595e-02f, 8.24157149e-02f, 1.09323869e-02f, 1.27825633e-01f, 1.16989933e-01f,
  2.50227619e-02f, -1.81802467e-01f, -6.60336986e-02f, -1.33711010e-01f, -2.04376340e-01f, -2.39757121e-01f, -1.31849095e-01f, 1.53151201e-02f, -9.85852033e-02f, -3.66319232e-02f,
  -2.12518945e-01f, 3.57138753e-01f, -9.18061808e-02f, -4.36635822e-01f, -9.77159068e-02f, -1.80263445e-01f, -4.68237279e-03f, -2.33029723e-01f, -4.43766974e-02f, 6.16262294e-02f,
  1.86397806e-01f, -1.37424201e-01f, 1.56571418e-01f, 9.08281058e-02f, 1.10024534e-01f, 1.05899081e-01f, -1.07889034e-01f, -2.36617941e-02f, -1.35507733e-01f, -1.02471568e-01f,
  -8.45504105e-02f, -3.78642371e-03f, 4.95292805e-02f, 1.61440626e-01f, -2.32340395e-02f, 7.23027214e-02f, 6.28480837e-02f, 9.06652957e-02f, 2.12302759e-01f, 2.95635760e-01f,
  1.04105920e-01f, -9.38603878e-01f, 5.51695645e-01f, -1.23453543e-01f, -2.78409302e-01f, -2.25540578e-01f, -9.86055136e-01f, -4.44539875e-01f, 2.31735911e-02f, -7.18093336e-01f,
  -1.98784202e-01f, 8.39761853e-01f, 9.34191406e-01f, 5.74144304e-01f, 3.15407336e-01f, -9.06383157e-01f, -4.38199699e-01f, 6.31153464e-01f, 4.13396388e-01f, -7.67533898e-01f,
  -8.86913180e-01f, -3.43816698e-01f, 1.78380609e-01f, 2.20553782e-02f, -6.24777615e-01f, 2.66049355e-01f, 1.55648023e-01f, -1.04211673e-01f, -2.19056681e-01f, -2.54794449e-01f,
  -3.36666182e-02f, -9.32117552e-02f, 4.79408920e-01f, 2.65278339e-01f, -5.73129253e-03f, 1.59464762e-01f, -2.25402135e-02f, 1.47876784e-01f, -4.04044762e-02f, -2.30826950e-03f,
  1.80944100e-01f, -1.71047196e-01f, 2.62135446e-01f, -1.36888817e-01f, -1.94790542e-01f, -2.10689493e-02f, -7.69565105e-02f, 4.64531034e-02f, 1.45865664e-01f, -3.33602935e-01f,
  -5.67854702e-01f, -2.12493524e-01f, 3.57932270e-01f, 2.47545596e-02f, 2.05372438e-01f, 2.00653210e-01f, -1.10248670e-01f, 3.50855030e-02f, 4.40323800e-01f, -3.00682455e-01f,
  -2.19464347e-01f, 2.74943113e-01f, 1.20053105e-02f, -6.06905073e-02f, -5.97104579e-02f, 6.09555840e-02f, 1.37992173e-01f, -9.59753394e-02f, 6.15206175e-02f, -6.09580986e-02f,
  5.72567768e-02f, -1.30105361e-01f, 9.14724916e-02f, -8.57998654e-02f, 1.10844031e-01f, -4.93034013e-02f, -3.92160080e-02f, -1.17154624e-02f, 5.49122952e-02f, -6.70109093e-02f,
  -1.73452906e-02f, 1.00576356e-02f, 5.43128066e-02f, -4.47223373e-02f, 3.80384400e-02f, 1.13742225e-01f, 1.28759995e-01f, 4.97165620e-02f, -9.51819718e-02f, -1.18800826e-01f,
  2.76544392e-01f, 5.29783309e-01f, -1.30376771e-01f, 5.36013804e-02f, -1.71743169e-01f, -3.82986665e-02f, -7.85356089e-02f, 7.08837062e-02f, 1.92448050e-01f, -6.94807321e-02f,
  4.18896377e-02f, -1.61069974e-01f, 3.17815654e-02f, -4.09675725e-02f, -2.17018291e-01f, -2.67754737e-02f, -4.21840847e-01f, 1.10558532e-02f, 7.64761865e-02f, -1.69643089e-01f,
  -2.59490371e-01f, -2.24767089e-01f, 1.41844666e-02f, 6.29846379e-02f, -1.60653174e-01f, 3.02548110e-01f, -1.69406105e-02f, -2.32953995e-01f, 2.38226742e-01f, -7.58318365e-01f,
  -1.10066605e+00f, -5.92623115e-01f, -6.12947583e-01f, 1.79138601e-01f, 1.71537712e-01f, -3.96545142e-01f, -6.00781262e-01f, -3.71977657e-01f, -3.81488465e-02f, -5.15832245e-01f,
  -3.69845927e-01f, 2.08925307e-01f, 1.85510945e-02f, 1.21702082e-01f, -2.05192998e-01f, -2.86594301e-01f, 3.35071325e-01f, 2.81139761e-01f, 1.62945852e-01f, 1.95207760e-01f,
  5.30276418e-01f, 4.52816695e-01f, 1.57030776e-01f, 3.49884033e-01f, 4.26225305e-01f, 4.88150239e-01f, 1.95722908e-01f, 2.67169863e-01f, 1.43839732e-01f, 4.74422812e-01f,
  -8.68658960e-01f, -5.00757515e-01f, 1.83939055e-01f, 3.97350192e-01f, -4.28589806e-02f, -2.57584065e-01f, -2.62581736e-01f, -5.81765920e-02f, -1.88547224e-01f, -1.99523464e-01f,
  6.88120276e-02f, -1.69752002e-01f, 1.07975073e-01f, 1.62108794e-01f, -1.55727714e-02f, -1.51937664e-01f, 1.71064451e-01f, -1.03783369e-01f, -1.80203930e-01f, -2.97666371e-01f,
  5.66925883e-01f, 9.86621678e-02f, -5.76808453e-01f, -9.93482396e-02f, -8.52563903e-02f, 3.94753665e-01f, -3.20243984e-01f, -5.43821491e-02f, -4.31004077e-01f, -4.65585470e-01f,
  -2.04475179e-01f, 9.72033851e-03f, 2.17263252e-02f, -9.89777967e-02f, 7.99482092e-02f, 2.39634626e-02f, 1.25749961e-01f, 7.18490630e-02f, -9.83857810e-02f, -5.15443385e-02f,
  -9.18548927e-02f, -1.27134845e-01f, 1.47027314e-01f, -2.35793427e-01f, 1.05100185e-01f, -4.22480404e-02f, 2.57209856e-02f, 4.79663424e-02f, 7.01999217e-02f, -1.72684833e-01f,
  -2.16565400e-01f, 3.78195010e-03f, 1.80492803e-01f, 2.47393951e-01f, -9.32833478e-02f, 1.07119814e-01f, 1.52156144e-01f, 5.25580347e-02f, -6.67490512e-02f, -1.40858591e-01f,
  2.27996528e-01f, 3.33416432e-01f, -5.61091423e-01f, 5.97627312e-02f, -1.20835826e-01f, -9.89491120e-03f, 5.86938076e-02f, -6.65667132e-02f, 1.42721146e-01f, -2.50001818e-01f,
  -1.49970397e-01f, -3.62286359e-01f, -6.70292452e-02f, 2.11117491e-01f, -6.27874807e-02f, -7.64118731e-02f, 3.92567664e-02f, -1.36611154e-02f, -1.00575253e-01f, -9.12860502e-03f,
  9.93599966e-02f, -4.02576387e-01f, -6.90286577e-01f, -3.97917330e-01f, -8.17638934e-02f, -2.15960905e-01f, -2.21153304e-01f, -2.54682809e-01f, -5.76490104e-01f, -7.28205025e-01f,
  8.13233912e-01f, 4.06624109e-01f, -1.11999905e+00f, 3.68534416e-01f, -3.12142670e-01f, -3.23116302e-01f, 1.12432428e-01f, 3.85214567e-01f, 1.98051050e-01f, 8.24653059e-02f,
  1.06853619e-01f, 2.54325390e-01f, 1.13265350e-01f, 2.36065127e-02f, 2.22185388e-01f, -2.18255833e-01f, -4.42526430e-01f, -4.38387483e-01f, -9.81788263e-02f, 1.44155875e-01f,
  4.23234195e-01f, 4.17057306e-01f, 3.92850876e-01f, 6.81969672e-02f, -7.56777599e-02f, -8.37779865e-02f, -3.64269972e-01f, -1.11785404e-01f, -2.57611334e-01f, -5.28867543e-01f,
  -7.41656363e-01f, -3.28574687e-01f, 9.42111835e-02f, 2.35260993e-01f, -3.20178531e-02f, 1.20516635e-01f, 1.02743939e-01f, 3.03663965e-02f, 1.53430834e-01f, 1.30554304e-01f,
  -5.95082752e-02f, -3.54494341e-02f, -2.07690392e-02f, 4.89993393e-02f, 4.66255248e-02f, -5.13299517e-02f, -2.31506694e-02f, 8.40625539e-02f, -6.04356937e-02f, -2.11456984e-01f,
  -7.25077763e-02f, -1.54014066e-01f, -2.08636492e-01f, -2.92185917e-02f, -1.69330537e-01f, -2.24922597e-01f, -1.04788430e-01f, -1.40423894e-01f, -1.58914179e-01f, 1.81585521e-01f,
  -1.13509139e-02f, 1.37309283e-01f, -7.87415579e-02f, -4.47794162e-02f, 1.79382667e-01f, -7.38334563e-03f, 2.06883419e-02f, 5.58641218e-02f, 4.92673554e-02f, 1.06096148e-01f,
  3.04790270e-02f, -1.62246868e-01f, -2.36372203e-02f, 9.43643451e-02f, -7.35761523e-02f, -7.29466155e-02f, -8.73541310e-02f, 1.21766970e-01f, -7.59441257e-02f, 4.22087917e-03f,
  4.40764939e-03f, -2.38523595e-02f, 4.06740233e-02f, -2.19417103e-02f, -6.47104979e-02f, -1.00766420e-01f, -4.90420274e-02f, 1.42576741e-02f, 5.82924820e-02f, 1.00149907e-01f,
  5.24986506e-01f, -3.52282971e-01f, -1.27264615e-02f, -5.82809225e-02f, -2.67571539e-01f, -4.77909148e-02f, -2.62658834e-01f, -3.93514037e-02f, -2.88809072e-02f, -4.81155552e-02f,
  -1.65190682e-01f, 2.68888716e-02f, 1.97038352e-02f, 1.80970170e-02f, 1.43810675e-01f, -6.02861680e-02f, 1.20228082e-01f, -3.06504462e-02f, 7.99559057e-02f, -1.96481664e-02f,
  1.68238118e-01f, 1.50914848e-01f, 1.68227986e-01f, 1.06656522e-01f, 6.04645908e-02f, 9.68437716e-02f, 2.25280579e-02f, 1.18923210e-01f, -1.99557580e-02f, 5.16928971e-01f,
  -2.14849785e-01f, -4.77212042e-01f, 1.76957503e-01f, 5.44829130e-01f, 7.20274270e-01f, 6.80468023e-01f, 6.20727301e-01f, 4.35294509e-01f, 4.64332223e-01f, 2.67721593e-01f,
  -3.15354839e-02f, 1.96677908e-01f, 1.19362481e-01f, 5.00838310e-02f, 1.08176604e-01f, 4.91164744e-01f, 6.63885534e-01f, 2.32050136e-01f, 1.62402987e-01f, 3.25488746e-01f,
  2.70942271e-01f, 9.13966298e-02f, -2.70824581e-01f, 3.26300040e-02f, 1.00776955e-01f, 3.08377057e-01f, 9.79718566e-02f, 1.10822015e-01f, 7.86060765e-02f, 6.18358813e-02f,
  -5.70338845e-01f, -3.45907748e-01f, 8.27293396e-02f, -1.61675110e-01f, -2.15052351e-01f, -4.02600676e-01f, 1.83618348e-02f, -1.74666479e-01f, -1.95673376e-01f, 4.68078963e-02f,
  -3.12496442e-02f, -1.96965188e-01f, -2.34374069e-02f, -8.92884582e-02f, -9.07421038e-02f, -1.23019487e-01f, -1.70031369e-01f, 1.55255005e-01f, 1.03162423e-01f, -3.12751159e-02f,
  -4.46407087e-02f, 2.98605502e-01f, 2.61112183e-01f, 2.09655657e-01f, -5.81298061e-02f, 1.40540123e-01f, -2.39479855e-01f, -1.22153364e-01f, 6.79298863e-02f, 2.48714238e-02f,
  3.77785325e-01f, 1.70588344e-01f, 6.36912063e-02f, 1.34554833e-01f, 9.66090709e-03f, 1.51239917e-01f, 1.96500093e-01f, 2.14669585e-01f, 1.59451917e-01f, 1.03000268e-01f,
  9.47137997e-02f, 2.11774096e-01f, 1.58741951e-01f, 1.06091902e-01f, 3.76726757e-03f, 2.63314396e-02f, -2.40712147e-02f, -1.30288135e-02f, -3.26543115e-02f, 5.80585599e-02f,
  -4.45654280e-02f, 1.12503275e-01f, -1.78406328e-01f, -6.28882572e-02f, 1.30818501e-01f, 1.18697777e-01f, 5.56774810e-02f, -6.93395883e-02f, -3.83273475e-02f, 6.48605153e-02f,
  1.77489907e-01f, 2.66308963e-01f, 7.08821714e-02f, 1.25360787e-01f, -1.09412588e-01f, -2.04479858e-01f, -2.79892869e-02f, -1.43367469e-01f, -1.41110376e-01f, -7.24762529e-02f,
  -1.90011173e-01f, -2.16419563e-01f, -1.10582463e-01f, -9.52510834e-02f, -7.60309072e-03f, 3.72767225e-02f, -1.76335528e-01f, 2.22216681e-01f, 1.46479771e-01f, -2.70203967e-02f,
  -1.30268335e-01f, 2.80665249e-01f, 4.24778908e-01f, 1.16087802e-01f, 1.17067397e-01f, 3.03531885e-01f, -9.68851075e-02f, -5.63310608e-02f, 1.01785645e-01f, 1.51052130e-02f,
  -2.47118369e-01f, -7.96251655e-01f, 7.66076326e-01f, -3.89678359e-01f, 6.71230778e-02f, 2.35903710e-01f, 4.90232222e-02f, -1.43227816e-01f, -2.77986884e-01f, -1.38661474e-01f,
  -6.25996232e-01f, -5.27167559e-01f, -3.88144433e-01f, -2.92646557e-01f, -2.21772596e-01f, 1.30515665e-01f, 3.04338694e-01f, 6.19949281e-01f, 7.95777678e-01f, 4.23779994e-01f,
  -6.63293004e-02f, 1.71537116e-01f, 1.81122348e-01f, 6.31643683e-02f, -2.64606416e-01f, 6.24497645e-02f, 7.52957761e-02f, -1.76693603e-01f, -2.00209871e-01f, -2.59187788e-01f,
  5.74136615e-01f, -6.11005843e-01f, 2.42881551e-01f, -3.87579829e-01f, -9.40816030e-02f, -5.51646091e-02f, 9.72531661e-02f, -1.13626150e-02f, -1.34945447e-02f, 1.22089550e-01f,
  -2.46853650e-01f, -8.31190497e-02f, -1.39985085e-01f, -6.87063264e-04f, 2.40879059e-01f, 2.14808553e-01f, -9.56661180e-02f, -2.33221382e-01f, -1.64102674e-01f, -1.44009516e-01f,
  -2.26180583e-01f, -1.98441178e-01f, 4.73021381e-02f, -1.96400583e-01f, -3.66999626e-01f, 1.22274086e-02f, -1.42772198e-01f, -2.75634259e-01f, 6.88629039e-03f, -8.22394788e-02f,
  1.77672938e-01f, -3.13917473e-02f, -2.15318650e-01f, -6.93839937e-02f, -8.34105685e-02f, 1.51367318e-02f, -2.58149710e-02f, -1.43297330e-01f, -8.59991759e-02f, 6.97876420e-03f,
  -1.81216039e-02f, -1.23929262e-01f, -7.30088949e-02f, 8.64302143e-02f, 3.46048153e-03f, -1.75635725e-01f, -2.50957869e-02f, -5.50023615e-02f, -5.20114750e-02f, -1.04209982e-01f,
  -2.22867340e-01f, -1.42164603e-01f, 4.10884134e-02f, 4.65541631e-02f, -1.50462031e-01f, -1.37854666e-01f, -1.10154882e-01f, -8.04695338e-02f, 8.90312716e-02f, -6.14452809e-02f,
  1.30448967e-01f, -1.18448168e-01f, 1.53213620e-01f, -2.09259495e-01f, -1.63054932e-02f, -2.31703117e-01f, -1.72492296e-01f, -2.60481313e-02f, -1.23041533e-01f, 1.02003358e-01f,
  -2.10391089e-01f, 5.88251948e-02f, 3.84512134e-02f, -2.58794483e-02f, 3.87852609e-01f, 1.68109506e-01f, -2.34567404e-01f, 1.02565512e-02f, -1.42870426e-01f, -3.98025103e-02f,
  -4.45835032e-02f, 1.88392013e-01f, 2.77400911e-01f, 1.30301416e-01f, -4.04186137e-02f, 2.82271653e-01f, 4.44514960e-01f, 2.97371209e-01f, 2.55986601e-01f, 4.16081458e-01f,
  1.42442429e+00f, -9.45821345e-01f, -9.21361923e-01f, 7.35879838e-01f, 5.57895064e-01f, -1.25339761e-01f, -8.43804061e-01f, -2.60312527e-01f, 7.00503588e-01f, -2.30567098e-01f,
  -3.27802688e-01f, 1.70330629e-01f, -2.84454852e-01f, -4.09155637e-01f, -8.88231814e-01f, -1.04606974e+00f, -5.85081518e-01f, -3.06803584e-01f, 5.33369966e-02f, 2.53576130e-01f,
  2.56999433e-01f, 3.85385305e-01f, 1.29875794e-01f, -1.25385508e-01f, 2.30307534e-01f, 2.87390709e-01f, -5.04120529e-01f, -6.43487945e-02f, -4.29726511e-01f, -1.31169066e-03f,
  -7.58858621e-02f, -4.12839770e-01f, 3.11700813e-02f, 1.23732455e-01f, 3.31753418e-02f, 2.89283749e-02f, -3.84780206e-02f, 1.54376831e-02f, -8.69247317e-03f, -7.50275850e-02f,
  2.14808613e-01f, -1.27637237e-02f, 5.20554222e-02f, -1.33884564e-01f, -1.09884769e-01f, 5.22616543e-02f, -2.58999616e-01f, -3.57128143e-01f, -2.58670270e-01f, -3.57766002e-01f,
  -3.62770259e-02f, 1.02829754e-01f, -2.51333147e-01f, -4.20645654e-01f, -3.87395561e-01f, 1.43671721e-01f, -2.82316208e-01f, -2.27076471e-01f, -4.48502094e-01f, 4.35804650e-02f,
  -5.86036667e-02f, 5.53019606e-02f, 6.35721534e-02f, 4.26110141e-02f, 1.36299714e-01f, 1.03202321e-01f, -7.06509948e-02f, -1.02078162e-01f, 1.20907053e-02f, -9.86330491e-03f,
  -1.76153511e-01f, -7.11039081e-02f, 6.67797700e-02f, -1.16862647e-01f, 1.23027926e-02f, -2.85416618e-02f, 1.01282790e-01f, -3.26696813e-01f, -6.03158101e-02f, 5.12452051e-02f,
  6.98552430e-02f, 8.79901052e-02f, 1.94678500e-01f, -1.27316728e-01f, -1.39977545e-01f, -2.86673337e-01f, 7.39573836e-02f, -1.01020396e-01f, 3.92159633e-02f, 1.31814972e-01f,
  4.78038520e-01f, -3.96742493e-01f, 2.77179807e-01f, -2.30420142e-01f, 6.71948791e-02f, 7.21512288e-02f, 1.54594630e-01f, -3.57333533e-02f, 1.57113075e-01f, 1.55610055e-01f,
  -2.03006953e-01f, 3.01663931e-02f, -7.16761351e-02f, 1.80942994e-02f, 1.15433931e-01f, 4.47497778e-02f, -4.91406582e-02f, 8.26805085e-02f, -1.34030357e-01f, 3.20535988e-01f,
  -4.92743477e-02f, 1.62733436e-01f, 3.74317318e-01f, 2.19530817e-02f, 1.95266962e-01f, 3.83309543e-01f, -4.01515700e-02f, 1.20141543e-01f, -9.45955142e-03f, 2.13986799e-01f,
  -1.27011824e+00f, -4.45348591e-01f, -2.70742446e-01f, -7.85918593e-01f, -2.25579560e-01f, 2.24052235e-01f, 4.98790555e-02f, 9.93882939e-02f, -4.66630831e-02f, -1.17270328e-01f,
  -4.28525284e-02f, -4.34442222e-01f, -4.98753130e-01f, -3.07339221e-01f, -2.52028555e-01f, 2.38437131e-02f, -6.31666929e-02f, -4.75951195e-01f, -3.36778313e-01f, 8.62747431e-03f,
  -1.61492795e-01f, -5.89016259e-01f, -4.83763039e-01f, -3.27764541e-01f, -2.62559682e-01f, -3.95449102e-01f, -1.69215426e-01f, -4.54292655e-01f, -4.74043489e-02f, -5.20229697e-01f,
  -1.34410828e-01f, -1.96881145e-01f, 3.39116514e-01f, -3.71201605e-01f, 1.50929093e-01f, 9.72039357e-04f, 6.89591765e-02f, 4.27604616e-02f, -2.76256129e-02f, 2.20863000e-02f,
  -2.21314594e-01f, 2.70718277e-01f, -2.35633686e-01f, -2.63775229e-01f, -1.14950597e-01f, 1.20652458e-02f, -1.09168075e-01f, -2.55259812e-01f, -1.87859073e-01f, 2.99485445e-01f,
  -1.60825431e-01f, -5.99672675e-01f, -6.09674931e-01f, 2.63918012e-01f, 3.01561058e-01f, -2.80107051e-01f, -4.20201682e-02f, -1.60840638e-02f, -1.89383969e-01f, -5.58009088e-01f,
  1.94120884e-01f, 2.33446926e-01f, 7.05021471e-02f, 5.57337189e-03f, -7.45693296e-02f, 5.51354885e-03f, -1.25943631e-01f, -7.57493898e-02f, 6.77972212e-02f, -1.50851563e-01f,
  7.06430003e-02f, 2.07395151e-01f, 1.50915012e-02f, 2.41691135e-02f, 1.25110438e-02f, -8.06660801e-02f, -1.34905586e-02f, 9.99558717e-02f, -8.35821182e-02f, -1.24864904e-02f,
  -1.77284881e-01f, -2.51517087e-01f, -2.64260083e-01f, -8.75755697e-02f, 4.49353233e-02f, 3.55313974e-03f, 4.29605506e-02f, -1.18078470e-01f, -7.40861595e-02f, 1.10632427e-01f,
  -2.87680447e-01f, 2.82288909e-01f, -2.31343731e-01f, -3.43923926e-01f, -7.19371065e-02f, 1.54904351e-01f, -1.50205165e-01f, 1.36319742e-01f, -2.00964473e-02f, -8.71672928e-02f,
  -8.29700287e-03f, -4.73566614e-02f, -2.90365089e-02f, 7.37654343e-02f, 1.17479227e-02f, 6.87236711e-02f, -1.98179786e-03f, -2.93402523e-01f, -6.09814227e-02f, 2.49528070e-03f,
  -2.00597137e-01f, -6.45215213e-01f, -7.68965781e-01f, -3.51670742e-01f, -4.62944843e-02f, -5.91756701e-01f, -4.45102692e-01f, -3.03806126e-01f, -3.73947173e-01f, -5.76285720e-01f,
  -6.48363471e-01f, 5.63972354e-01f, -7.02648237e-02f, -2.33210176e-01f, 8.94703925e-01f, 2.05611557e-01f, -2.08722189e-01f, -6.28447235e-01f, -1.27772078e-01f, 1.87729403e-01f,
  9.27999198e-01f, 4.60849524e-01f, -1.77399069e-01f, -2.50218332e-01f, -7.28533804e-01f, -3.54468733e-01f, -3.57260346e-01f, -8.84157896e-01f, -6.60494149e-01f, 1.09895833e-01f,
  4.27665085e-01f, -4.66047321e-03f, -3.67799908e-01f, -4.46709633e-01f, 2.14180931e-01f, 1.97407827e-01f, 1.08843610e-01f, 2.89946735e-01f, 2.52110511e-01f, 1.85293220e-02f,
  1.36578754e-02f, -1.80697158e-01f, -8.82615745e-02f, 1.39401838e-01f, 5.89211881e-01f, -5.17392874e-01f, -2.97415823e-01f, -1.83486611e-01f, 8.84202030e-03f, -2.01837987e-01f,
  5.17257273e-01f, 8.49032998e-02f, 2.81966358e-01f, -1.83342054e-01f, -1.88587025e-01f, -3.85912180e-01f, -3.34540784e-01f, -6.64478183e-01f, -6.38920665e-01f, -4.58760094e-03f,
  6.64713264e-01f, 7.87203312e-01f, 1.17726736e-02f, -2.46061832e-01f, -5.56501687e-01f, -7.57342502e-02f, -1.25892863e-01f, -3.44946355e-01f, -6.56061292e-01f, -4.80846286e-01f,
  -5.68007864e-02f, 7.12034926e-02f, 5.71993478e-02f, -1.12926558e-01f, -1.17637381e-01f, 1.76671252e-01f, 9.81267318e-02f, 2.66801789e-02f, 1.19262166e-01f, 3.21567897e-03f,
  1.16774872e-01f, 7.44870007e-02f, -1.06483012e-01f, -1.86571199e-02f, 8.51693191e-03f, 3.52322273e-02f, 7.25510046e-02f, -1.46306425e-01f, 1.45814434e-01f, -9.09455940e-02f,
  -1.22438617e-01f, -2.32418533e-02f, 2.08526552e-01f, -3.10154676e-01f, -2.99200974e-02f, -8.88288021e-02f, -1.63601577e-01f, -3.66851911e-02f, -1.73190296e-01f, -2.23052148e-02f,
  -1.32450804e-01f, 2.27915540e-01f, -1.16644457e-01f, -2.60383993e-01f, 6.95572942e-02f, 9.60874856e-02f, 8.91571119e-02f, 6.55571595e-02f, 1.22930400e-01f, -2.92296171e-01f,
  -9.32236388e-02f, -9.70404148e-02f, 1.05198815e-01f, 9.31830984e-03f, -6.09714091e-02f, -8.14624354e-02f, 8.89306441e-02f, -2.44265776e-02f, -1.19994342e-01f, 1.65755674e-01f,
  -5.32952845e-02f, -2.55367965e-01f, -3.58896732e-01f, -3.95404220e-01f, -1.22616351e-01f, -1.63262367e-01f, -3.72216702e-01f, -2.79193074e-01f, -4.68593955e-01f, -6.83430612e-01f,
  4.80162837e-02f, -1.74745172e-02f, 7.50025809e-01f, 4.16955382e-01f, -4.18011487e-01f, -6.00491405e-01f, -7.88483381e-01f, -2.77197182e-01f, 8.40314254e-02f, 1.45453334e-01f,
  -3.95031810e-01f, 9.16401520e-02f, 2.85709471e-01f, 1.30699098e-01f, 1.24020845e-01f, 1.98670059e-01f, 6.93458796e-01f, 5.67089319e-01f, 7.84765184e-02f, -3.47856343e-01f,
  -2.05548599e-01f, -9.00997221e-02f, 6.22918978e-02f, 1.41053811e-01f, 3.55137289e-01f, 7.52567127e-03f, 1.44138366e-01f, 9.23849419e-02f, 3.09701767e-02f, 9.65567529e-01f,
  2.33604059e-01f, -6.30174726e-02f, -1.71328023e-01f, -1.50198460e-01f, 1.01038352e-01f, 1.64114982e-01f, -1.66739300e-01f, 1.70604661e-01f, 5.47699407e-02f, 5.14655560e-02f,
  -1.60469443e-01f, 1.53672501e-01f, -7.53753725e-03f, 1.26487523e-01f, -2.65179574e-01f, -2.78811276e-01f, 8.66899267e-02f, 1.73344135e-01f, 2.49724939e-01f, 2.07704157e-02f,
  -1.21705122e-01f, -3.80788147e-01f, -3.14170331e-01f, -4.17879522e-01f, 8.28849524e-02f, 8.52966234e-02f, -3.76844138e-01f, -7.31641352e-02f, -4.12622392e-01f, 1.02459237e-01f,
  -1.21738583e-01f, -2.34393686e-01f, -1.42980993e-01f, 1.69249982e-01f, -6.06919751e-02f, 2.49287710e-02f, 1.20328784e-01f, -1.06733590e-02f, 7.50654489e-02f, 3.07642613e-02f,
  6.97039664e-02f, -1.80750534e-01f, 1.33096501e-01f, -6.81662336e-02f, -1.49519205e-01f, -4.09512483e-02f, -2.81296559e-02f, -8.95396024e-02f, -5.69163971e-02f, 1.16117395e-01f,
  2.88306605e-02f, 1.66733190e-01f, 2.16879677e-02f, 1.27634272e-01f, -7.03734532e-02f, 7.90497959e-02f, -1.99196950e-01f, -1.27394989e-01f, -1.90839604e-01f, -2.64229715e-01f,
  -3.74591589e-01f, -2.91267663e-01f, 6.52804971e-02f, 1.01041295e-01f, -1.13634311e-01f, -1.29416129e-02f, 1.25761271e-01f, -1.11975990e-01f, 2.72680894e-02f, -3.81618133e-03f,
  -2.66980082e-01f, 1.71555191e-01f, 6.35460392e-02f, -2.41476316e-02f, -1.08066484e-01f, -1.31791249e-01f, -2.54911870e-01f, -1.10104360e-01f, -2.29887247e-01f, 9.20520723e-02f,
  5.57667576e-02f, -5.14954090e-01f, -5.30964136e-01f, -1.64543405e-01f, -3.80590320e-01f, -5.72512269e-01f, -5.06850600e-01f, -3.79472315e-01f, -7.18428493e-01f, -6.51466250e-01f,
  -1.04780100e-01f, -6.14472926e-01f, -2.22271338e-01f, -9.68591511e-01f, -3.72430891e-01f, 3.59082699e-01f, 9.16836187e-02f, 1.24125518e-01f, -2.10350692e-01f, -5.81411481e-01f,
  -4.08121556e-01f, -2.76781917e-01f, -3.44951451e-01f, 1.36075601e-01f, 5.60929418e-01f, -1.88007057e-01f, -1.09210029e-01f, 5.10378897e-01f, 8.47496212e-01f, 5.15796721e-01f,
  7.89568201e-02f, -9.56250057e-02f, 2.20382139e-01f, 4.34758738e-02f, -9.68008399e-01f, -4.02581692e-01f, -6.88354731e-01f, -3.29350173e-01f, 1.46345273e-01f, -8.66908610e-01f,
  -5.94608963e-01f, -5.28236665e-02f, 1.41549453e-01f, -6.09510988e-02f, -2.07306832e-01f, 1.84021130e-01f, -1.11009285e-01f, -1.35935292e-01f, 8.49476457e-02f, -1.89370975e-01f,
  -4.52724874e-01f, 1.53122947e-01f, -1.32682189e-01f, -1.28635958e-01f, -2.63316959e-01f, 5.84023334e-02f, 8.14375803e-02f, 2.19392046e-01f, 1.97347656e-01f, 3.29298265e-02f,
  -1.04615726e-01f, 7.54092336e-02f, 1.45493848e-02f, 2.76349634e-01f, 1.52798161e-01f, 2.66012430e-01f, -5.64405508e-02f, 1.71569332e-01f, 4.39507246e-01f, -4.77266043e-01f,
  -7.45433345e-02f, -8.22024420e-02f, 1.54105887e-01f, 1.43939614e-01f, 1.39693290e-01f, 4.24742103e-02f, -1.53396174e-01f, -4.78564203e-02f, 1.63319468e-01f, 2.98638921e-02f,
  3.82271074e-02f, 2.32793733e-01f, 1.53089315e-01f, -9.13880616e-02f, -1.48518085e-01f, -6.81969896e-02f, 1.55923709e-01f, -1.17794432e-01f, -1.19942300e-01f, 1.21347405e-01f,
  -1.93677098e-03f, 5.76939993e-02f, -1.21226087e-01f, 1.05777346e-01f, 1.37512952e-01f, -3.18681262e-02f, -1.14498049e-01f, 5.40812574e-02f, -2.70405766e-02f, 3.72218564e-02f,
  -8.88850451e-01f, 6.77469194e-01f, -5.18204391e-01f, -1.63089186e-02f, -2.36762434e-01f, -9.13842469e-02f, -2.70800024e-01f, -5.80873154e-03f, -2.68175870e-01f, -2.72252653e-02f,
  7.18716010e-02f, -2.01818366e-02f, -1.97886378e-01f, 4.32543494e-02f, 1.24844134e-01f, -2.74059195e-02f, 1.72661781e-01f, -9.70957503e-02f, 9.38482061e-02f, 4.46195342e-02f,
  1.88864842e-01f, 2.45070934e-01f, 2.41240654e-02f, 2.24999394e-02f, -3.81037174e-03f, 1.67856112e-01f, 5.24699092e-02f, 2.25905135e-01f, 6.30189538e-01f, -2.74480164e-01f,
  1.16733992e+00f, 2.63120115e-01f, 5.88094056e-01f, 1.25683248e-01f, -5.23112789e-02f, 1.72439357e-03f, -4.67493720e-02f, -8.69107991e-02f, -2.22482145e-01f, 1.06110089e-01f,
  1.52539641e-01f, -1.20342150e-01f, 1.72339100e-02f, 3.94825675e-02f, 7.94131160e-02f, -9.96190310e-02f, -2.37622157e-01f, 2.64095306e-01f, 3.73165995e-01f, 1.87928334e-01f,
  -1.29287794e-01f, 1.65059894e-01f, 3.26796085e-01f, 2.90509816e-02f, -1.75891563e-01f, -3.30207407e-01f, 3.60855460e-02f, 1.17833354e-01f, -9.33828428e-02f, -2.08840594e-01f,
  3.87737185e-01f, 5.75971961e-01f, -1.26706719e-01f, -1.34303287e-01f, 2.11622506e-01f, 9.58721153e-04f, 9.34263319e-02f, 8.80238339e-02f, -1.67826608e-01f, -2.95251966e-01f,
  -4.10080934e-03f, 7.95558281e-03f, 8.19543153e-02f, 7.69577250e-02f, 5.77433817e-02f, -1.08961780e-02f, 1.22018486e-01f, -1.54298423e-02f, -4.75943312e-02f, 1.29947513e-01f,
  -1.07158862e-01f, 1.70013398e-01f, 1.88407034e-01f, -2.10511778e-02f, 1.44349575e-01f, 1.64540822e-03f, 1.17041200e-01f, -2.34477464e-02f, 3.34999822e-02f, 5.15933260e-02f,
  5.80717623e-02f, 4.27744240e-02f, 1.79339156e-01f, 1.30194843e-01f, 9.35737938e-02f, 1.33878691e-02f, -1.38678923e-02f, -1.37142003e-01f, 1.19503573e-01f, 2.33050957e-01f,
  -1.42007619e-01f, 7.77728409e-02f, 1.43471628e-01f, 8.66091251e-02f, 1.39208883e-01f, 1.81763098e-01f, 3.64862531e-02f, -1.57865986e-01f, 1.83419913e-01f, -1.33594707e-01f,
  9.94827375e-02f, -8.40612724e-02f, 2.65975535e-01f, 1.04863048e-01f, -1.82207718e-01f, 1.32804289e-01f, 7.56500512e-02f, 1.61714870e-02f, 1.57204106e-01f, -5.03678173e-02f,
  -5.35828590e-01f, 4.45551604e-01f, -7.72209764e-02f, -8.82467031e-02f, 5.50813340e-02f, 1.51788294e-01f, -3.56091163e-03f, -2.04783604e-01f, -3.13910276e-01f, -2.51325667e-01f,
  -1.43892303e-01f, 1.45267457e-01f, 1.13440253e-01f, 1.32948041e-01f, 3.28062475e-02f, -4.73524369e-02f, 1.44343019e-01f, -1.86707061e-02f, -2.38771904e-02f, 7.00070523e-03f,
  -1.70715138e-01f, -2.34747049e-03f, -6.30171224e-02f, -6.84336275e-02f, -1.46336555e-02f, -7.36338645e-02f, -1.30710050e-01f, -3.76685821e-02f, -8.71298462e-02f, -1.79660931e-01f,
  1.67720079e-01f, 2.23161146e-01f, -6.85450062e-02f, 2.25743577e-01f, -6.80663824e-01f, -7.07785964e-01f, -3.43529321e-02f, -2.01180335e-02f, 2.02273279e-01f, 4.40287560e-01f,
  -3.10454756e-01f, -6.22071624e-01f, 4.44548316e-02f, -1.09457411e-01f, 1.03338724e-02f, 7.65547454e-01f, 5.24134815e-01f, -2.05799770e-02f, -7.71068096e-01f, -9.04349625e-01f,
  -2.23862797e-01f, -1.22021269e-02f, -4.18626107e-02f, -1.94593921e-01f, 1.47450343e-01f, -2.11058736e-01f, 3.03337157e-01f, -8.42920318e-02f, -2.30462536e-01f, 3.93048197e-01f,
  1.44197926e-01f, -3.29920202e-01f, -2.05747575e-01f, -1.69324368e-01f, -5.43624461e-02f, -1.27166659e-02f, -1.07076310e-01f, -7.77820274e-02f, -6.30281270e-02f, 6.07869551e-02f,
  -2.04106227e-01f, -1.69594169e-01f, -2.92400390e-01f, -1.91038668e-01f, -2.83941478e-01f, -2.81319618e-01f, 1.24471471e-01f, -9.53396410e-03f, 8.73783603e-02f, 1.44163407e-02f,
  -2.05415756e-01f, -5.11906803e-01f, -2.47353435e-01f, -1.19420305e-01f, -1.36798143e-01f, -2.44645476e-01f, -2.18989506e-01f, -4.46297079e-01f, -4.03454036e-01f, 4.82613504e-01f,
  7.09853619e-02f, 1.20290533e-01f, 1.04752652e-01f, 2.10172355e-01f, 2.37423450e-01f, -1.50341159e-02f, 1.57841220e-01f, -3.90841514e-02f, -6.69015497e-02f, 1.70225725e-01f,
  -1.53218687e-01f, 1.14351906e-01f, -3.18698697e-02f, 1.10076264e-01f, 6.31548911e-02f, 5.68503924e-02f, 5.32374345e-02f, 1.05496839e-01f, -9.80730355e-02f, 1.38479456e-01f,
  -8.36254656e-02f, -3.80077548e-02f, -5.63012250e-02f, 1.51854873e-01f, 4.54692692e-02f, 6.20072111e-02f, 4.03518826e-02f, -1.35368891e-02f, -4.06363569e-02f, -2.26553250e-02f,
  4.43239152e-01f, -1.95510089e-01f, 4.63042051e-01f, 6.69727772e-02f, 6.66846856e-02f, -1.56476334e-01f, 2.05809131e-01f, -1.03982598e-01f, -5.06083295e-02f, -1.07892565e-01f,
  -2.27440298e-01f, -1.95411012e-01f, 4.14627530e-02f, 8.39608461e-02f, -2.62319237e-01f, -1.59251034e-01f, 3.07206303e-01f, -1.00641936e-01f, -1.28148973e-01f, 1.73453763e-01f,
  5.17056763e-01f, 1.04195043e-01f, 3.99234205e-01f, 2.80811816e-01f, -3.51015106e-02f, -8.28010589e-03f, 2.62263000e-01f, 5.80833517e-02f, -1.09289527e-01f, 8.09896529e-01f,
  -1.32295024e+00f, 1.52270779e-01f, 1.12893626e-01f, -7.64316440e-01f, 2.38709617e-04f, 3.03189635e-01f, 1.13265812e-01f, -1.74674064e-01f, -1.92195296e-01f, 1.07166201e-01f,
  4.15500253e-01f, 4.21323143e-02f, -2.40955934e-01f, -2.85954773e-01f, -5.95574141e-01f, -2.69355714e-01f, -5.34300506e-01f, -7.11197555e-01f, -5.79168975e-01f, -1.82195544e-01f,
  -3.75034779e-01f, -7.75933444e-01f, -7.30193496e-01f, -4.79576796e-01f, 1.20847873e-01f, -1.23819143e-01f, -9.42433551e-02f, -2.72259414e-01f, 1.26005605e-01f, -1.93915486e-01f,
  5.77721000e-01f, 2.46649772e-01f, -4.39131968e-02f, -3.42088640e-01f, -1.31674930e-01f, 4.46124300e-02f, 5.10906763e-02f, -5.98499775e-02f, 8.87574032e-02f, 7.26114959e-02f,
  6.74693584e-02f, 1.41757712e-01f, 1.29848728e-02f, 2.70127684e-01f, -1.16494834e-01f, 5.34712486e-02f, -6.11343682e-02f, -1.13597080e-01f, -1.03854062e-02f, 5.24871230e-01f,
  1.96927279e-01f, 6.71463227e-03f, 1.83681652e-01f, 8.75849277e-02f, 1.93462923e-01f, -6.19202293e-02f, 3.32006574e-01f, 3.29268426e-01f, -3.14931460e-02f, -1.34809718e-01f,
  -1.98594816e-02f, 1.53796688e-01f, 1.65323511e-01f, 2.12800398e-01f, -2.90573966e-02f, 1.60194665e-01f, -1.11139208e-01f, -1.33239776e-02f, -9.59110409e-02f, -2.34882254e-02f,
  8.38738978e-02f, 1.57999784e-01f, -1.74152330e-02f, -2.09876850e-01f, -1.18036412e-01f, -1.39150441e-01f, -4.13458161e-02f, -1.16926640e-01f, -2.04487704e-02f, -4.14325809e-03f,
  1.45332487e-02f, 1.02651507e-01f, -1.74695589e-02f, -8.53420943e-02f, 2.20557332e-01f, -9.45858378e-03f, 2.72396594e-01f, 3.21340442e-01f, 1.61162898e-01f, 7.04393014e-02f,
  -8.31132308e-02f, -2.43231907e-01f, 3.18455286e-02f, -3.50325853e-02f, 6.93386933e-03f, 3.53444107e-02f, 6.71026334e-02f, -1.00085765e-01f, 5.04600108e-02f, 6.83062226e-02f,
  2.82606304e-01f, 3.65463272e-02f, 4.29010391e-02f, 2.09191784e-01f, -4.75240275e-02f, 7.67533258e-02f, -7.40116984e-02f, -1.57483131e-01f, 1.41491339e-01f, 3.97882640e-01f,
  6.29831851e-02f, -3.11489642e-01f, -2.48393416e-01f, -4.39508520e-02f, 1.56457454e-01f, -2.04092413e-01f, 2.09682152e-01f, 2.14909658e-01f, -1.25664532e-01f, -3.37473392e-01f,
  9.01911974e-01f, -4.58523005e-01f, -8.77426326e-01f, -5.79328127e-02f, -6.33530617e-02f, -4.05431688e-01f, -6.96375310e-01f, -1.18276961e-01f, 1.70491517e-01f, -1.62893444e-01f,
  3.68200898e-01f, 7.94642925e-01f, 2.75501966e-01f, 3.03569376e-01f, 2.13191986e-01f, -4.59884495e-01f, -5.48084259e-01f, 3.08946241e-02f, 4.13389325e-01f, 5.15625060e-01f,
  3.27302337e-01f, 1.43292934e-01f, 4.85218614e-01f, 1.26113147e-01f, -1.97509632e-01f, 1.52347803e-01f, -4.78480726e-01f, -1.86671093e-01f, -1.22069493e-01f, -4.72973049e-01f,
  6.34199381e-02f, -2.07654256e-02f, 1.26058102e-01f, 4.80780602e-01f, -4.27708775e-02f, -1.93009809e-01f, -1.81528747e-01f, -1.72879845e-01f, 2.31143404e-02f, -2.71012306e-01f,
  -1.50505781e-01f, 1.73851196e-02f, -3.28188054e-02f, -5.65717891e-02f, -1.28348634e-01f, -5.31553887e-02f, -2.25791067e-01f, -2.42012188e-01f, -1.45430148e-01f, -1.09878272e-01f,
  4.67966944e-02f, 5.78524135e-02f, -3.15984100e-01f, -2.58360922e-01f, -2.40111694e-01f, 2.70431280e-01f, -2.95653641e-01f, -1.51889607e-01f, -6.22485206e-02f, -3.53677869e-01f,
  2.17404023e-01f, -1.95582017e-01f, 1.29887275e-02f, 4.60690819e-02f, 1.00798979e-01f, -1.51410848e-01f, -1.27371132e-01f, 1.11267060e-01f, 1.35322124e-01f, -1.45306125e-01f,
  -7.18841478e-02f, 8.89720619e-02f, 7.04561993e-02f, -1.65460482e-02f, -2.81373523e-02f, 1.25741549e-02f, -1.18139021e-01f, -3.92037518e-02f, 2.56603569e-01f, 1.53047279e-01f,
  2.11044908e-01f, -9.53498390e-03f, 1.80201121e-02f, 7.95918331e-02f, -1.12699745e-02f, 8.16302970e-02f, 1.10956758e-01f, 4.27587144e-02f, 1.45204350e-01f, -8.76807645e-02f,
  -2.77250577e-02f, 3.60440135e-01f, 6.76567033e-02f, 2.94931103e-02f, -5.58268204e-02f, -2.92819012e-02f, 2.59656012e-02f, 2.39204675e-01f, -4.57872972e-02f, -8.47268105e-02f,
  2.62715276e-02f, 1.28653243e-01f, -2.25358069e-01f, -2.00503051e-01f, 2.17433255e-02f, 5.98749630e-02f, 1.37420580e-01f, 1.71738580e-01f, 6.40000030e-02f, -1.35028541e-01f,
  -1.05255045e-01f, -2.02988330e-02f, 1.75005376e-01f, -3.15693580e-03f, 7.78880715e-02f, 2.28563428e-01f, -2.76443243e-01f, -9.63709950e-02f, 9.17191356e-02f, -2.12717265e-01f,
  6.50421023e-01f, 3.52729887e-01f, 7.26853237e-02f, 4.43814754e-01f, -4.91034128e-02f, -1.36236951e-01f, -7.86179826e-02f, -1.25001088e-01f, 8.60639885e-02f, 2.23904565e-01f,
  1.02047451e-01f, 3.27202380e-01f, 1.94756061e-01f, 2.39955276e-01f, 1.19726315e-01f, 2.07683593e-01f, 1.27976611e-01f, 1.94306165e-01f, 7.15163201e-02f, 3.50953817e-01f,
  4.32193518e-01f, 2.52459049e-01f, 2.10998610e-01f, 7.67429844e-02f, 3.66215348e-01f, 1.80538297e-01f, 1.22289166e-01f, 2.27292851e-01f, 3.07700962e-01f, 5.14302552e-01f,
  5.31660914e-01f, 1.72666103e-01f, -1.11783601e-01f, -2.96406802e-02f, -1.00688748e-01f, -8.15347582e-02f, -4.51967791e-02f, -1.11087434e-01f, -1.36193171e-01f, -7.58007318e-02f,
  -1.11993052e-01f, 1.48395151e-02f, -6.17306493e-02f, -2.23321817e-03f, -5.87004498e-02f, 2.40965467e-02f, -1.65285878e-02f, 8.39155074e-03f, -1.12263702e-01f, 1.28590256e-01f,
  2.32455492e-01f, -9.70915612e-03f, -6.17391951e-02f, -1.93905115e-01f, 1.41782716e-01f, 4.28108387e-02f, -2.15263513e-04f, 7.90662169e-02f, -8.48698318e-02f, 1.67630166e-01f,
  1.68846443e-01f, 1.22729085e-01f, 3.26101393e-01f, 1.91426829e-01f, 2.74012506e-01f, 4.34915274e-02f, 1.25532806e-01f, 1.03584923e-01f, -8.91078264e-03f, 1.26002878e-01f,
  -1.26247332e-02f, 1.07518554e-01f, -1.54910967e-01f, 1.65845752e-01f, 1.11846142e-01f, 1.46379247e-01f, 1.63394898e-01f, 9.28380191e-02f, -4.59257439e-02f, -1.47033334e-01f,
  1.35481834e-01f, -6.27671704e-02f, -9.98016149e-02f, 1.39544404e-03f, -1.54049218e-01f, 1.60104427e-02f, 1.71496168e-01f, 1.67016238e-01f, 2.40012139e-01f, 2.22662855e-02f,
  -6.08587801e-01f, -4.91413534e-01f, 2.62484819e-01f, 8.55063275e-03f, -6.14989735e-03f, -7.90595710e-02f, 4.58713993e-02f, -1.55430898e-01f, -4.40221317e-02f, -4.80179973e-02f,
  -1.24455027e-01f, -3.67010422e-02f, -2.20502794e-01f, -2.02747971e-01f, -1.55312508e-01f, -9.75962505e-02f, 8.47020652e-03f, -6.98227435e-02f, -1.52795106e-01f, -5.70069216e-02f,
  -1.33730695e-01f, -3.50708216e-01f, -2.67241359e-01f, -2.19503924e-01f, -2.48204041e-02f, -3.46824266e-02f, -2.06420928e-01f, -5.40004633e-02f, -2.92164445e-01f, -2.18056500e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  2.38368928e-01f, 7.89193213e-01f, 3.37942243e-01f, 9.80020702e-01f, 7.82133579e-01f, 3.87618363e-01f, 8.06120038e-01f, 5.73522091e-01f, 5.84518671e-01f, 1.18902349e+00f,
  1.24075985e+00f, 3.86825472e-01f, 6.62003160e-01f, 8.96661222e-01f, 6.75641119e-01f, 7.55793631e-01f, 9.22226131e-01f, 8.28733623e-01f, 5.06027281e-01f, 3.82224470e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -2.33082399e-01f, -4.26766217e-01f, -2.14146420e-01f, -2.41640046e-01f, -1.97555989e-01f, -5.42083919e-01f, 2.13392731e-02f, 4.44380939e-01f, 1.19754426e-01f, -8.13814402e-02f,
  -9.22290683e-02f, -2.89861947e-01f, 2.68950015e-01f, -1.14864695e+00f, 2.39667892e-01f, -6.06916130e-01f, -1.73444524e-01f, -1.88275442e-01f, 4.94401842e-01f, 4.15133648e-02f,
  -1.46701670e+00f, -1.02072227e+00f, 4.66725379e-01f, 2.10942119e-01f, -3.11074015e-02f, -1.10744512e+00f, 4.22011137e-01f, -2.48738870e-01f, -1.46081018e+00f, 8.74214023e-02f,
  6.82139635e-01f, -2.51165777e-01f, -3.35301787e-01f, 8.05644915e-02f, 1.27871111e-01f, 4.36666794e-02f, -9.07573029e-02f, -2.36261487e-01f, 3.46833676e-01f, -1.05907567e-01f,
  -2.49260932e-01f, 9.81390849e-02f, 3.18934202e-01f, -4.24064875e-01f, 2.20273748e-01f, -3.02860200e-01f, 3.26702118e-01f, -1.39856935e+00f, 4.85585779e-01f, 1.33647823e+00f,
  -1.30353189e+00f, 1.88582540e-01f, -1.38778418e-01f, -5.47183394e-01f, 3.61751378e-01f, -7.65173078e-01f, -1.10043788e+00f, -4.06594574e-02f, 5.09926081e-01f, 1.57007337e-01f,
  -5.51386952e-01f, -6.48684382e-01f, 8.68067682e-01f, 3.18929285e-01f, 1.48838401e-01f, -1.46898165e-01f, 1.19996697e-01f, 1.00317053e-01f, -1.36788622e-01f, 5.46602830e-02f,
  1.86360389e-01f, -1.50329888e-01f, -1.55762389e-01f, -2.82552838e-01f, -4.72635508e-01f, -2.21007004e-01f, 2.01004073e-01f, -6.96089983e-01f, -8.14507127e-01f, -2.25066960e-01f,
  -5.86167395e-01f, 1.09062707e+00f, 8.56557071e-01f, -8.01254690e-01f, -7.32967973e-01f, 9.62990001e-02f, -4.57887620e-01f, -1.89797595e-01f, -4.94363219e-01f, 6.51453555e-01f,
  5.05227506e-01f, 5.30914009e-01f, -2.92770743e-01f, -7.80932009e-01f, 2.94687718e-01f, -7.27952003e-01f, -4.53489274e-01f, 4.19130892e-01f, -2.47680545e-02f, 2.55687684e-01f,
  1.11224823e-01f, 2.05036476e-01f, 3.60370912e-02f, 2.03179061e-01f, 1.39538810e-01f, 3.07849824e-01f, 5.81106901e-01f, 3.43512297e-01f, -8.70259523e-01f, 2.65872568e-01f,
  -5.16951382e-01f, -1.05077112e+00f, -2.43153021e-01f, -6.41769946e-01f, -3.44920188e-01f, -9.79241312e-01f, -2.32193977e-01f, -1.73868090e-02f, -2.22914052e+00f, 8.24274421e-01f,
  5.43469846e-01f, -4.43528891e-01f, 8.75061631e-01f, -7.66173363e-01f, -1.46656260e-01f, 5.15484393e-01f, -1.89595476e-01f, -6.25677824e-01f, -2.05186546e-01f, 1.54713122e-02f,
  -1.70945510e-01f, -1.49700806e-01f, -3.33184339e-02f, 2.08242834e-01f, 1.20240353e-01f, -2.06998333e-01f, 2.23991647e-01f, 6.72926009e-02f, -4.02810216e-01f, -2.09276050e-01f,
  1.35914162e-01f, -1.04789883e-01f, -2.01457754e-01f, 1.18034577e+00f, -2.64376372e-01f, 5.12605965e-01f, -2.07333028e-01f, -6.36110127e-01f, 1.57604471e-01f, -1.03958631e+00f,
  -1.91347927e-01f, 2.00246409e-01f, 2.47619063e-01f, 3.47761065e-02f, -1.34175134e+00f, -1.34513184e-01f, 2.49609590e-01f, 4.96596009e-01f, -6.78814411e-01f, -1.17117453e+00f,
  3.24401677e-01f, 1.75782949e-01f, -1.02502741e-01f, 3.53293121e-02f, 2.28397667e-01f, -9.90781263e-02f, -1.99067131e-01f, 2.64122903e-01f, 2.12625548e-01f, 3.74449462e-01f,
  1.02352604e-01f, -3.97202343e-01f, 1.73067600e-01f, -1.09588243e-01f, 1.00088259e-02f, 2.39631519e-01f, 3.57402176e-01f, -1.44444358e+00f, -1.03015834e-02f, 1.16860878e+00f,
  -2.36097708e-01f, -2.41973981e-01f, 5.15546501e-01f, -1.78308174e-01f, -3.82890403e-01f, -1.02640295e+00f, -4.46687222e-01f, -7.95866907e-01f, 1.10217714e+00f, -3.45418304e-01f,
  2.45584637e-01f, -5.80634475e-02f, -2.22324625e-01f, -4.69406182e-03f, 4.77631800e-02f, 2.49052987e-01f, 2.84778178e-01f, 8.31121057e-02f, -1.91071287e-01f, -3.93330872e-01f,
  -3.94456863e-01f, 3.23982954e-01f, -3.71220589e-01f, -2.88407236e-01f, 8.31955969e-02f, 4.38167393e-01f, -5.13958395e-01f, 8.46655965e-01f, -7.56451309e-01f, -6.37440562e-01f,
  -2.22824007e-01f, 1.08350068e-02f, -9.19532120e-01f, -3.18526477e-01f, -7.78460383e-01f, -6.42782748e-01f, -1.65112805e+00f, 9.66226637e-01f, -6.45242095e-01f, 2.23169297e-01f,
  3.54459941e-01f, -1.28212392e+00f, -6.69536293e-01f, 4.28706646e-01f, -3.50656718e-01f, -1.57392293e-01f, 8.91458883e-04f, -3.49723905e-01f, 1.95493549e-01f, 2.65212264e-02f,
  -7.09209368e-02f, 1.29324123e-01f, -1.53268412e-01f, -1.25509724e-01f, 4.91435230e-01f, 1.41288750e-02f, 3.91759239e-02f, -9.49095488e-02f, -3.14275771e-01f, -8.53609025e-01f,
  -2.29500130e-01f, -6.61991000e-01f, 7.66302109e-01f, -3.18468243e-01f, 4.48569864e-01f, -6.10478878e-01f, -9.26839411e-01f, 8.56976360e-02f, 6.53275967e-01f, 1.94968626e-01f,
  -5.97894311e-01f, -1.06946981e+00f, 1.88626409e-01f, -5.73398530e-01f, -1.33938432e+00f, -7.39679784e-02f, 1.42967105e-01f, 6.77631646e-02f, -9.30327326e-02f, -7.44508877e-02f,
  5.57344891e-02f, 1.20430864e-01f, -2.59895176e-01f, 6.84733868e-01f, -2.83988863e-01f, -4.96084899e-01f, 2.92937964e-01f, 2.06098229e-01f, -3.49354237e-01f, -4.50428396e-01f,
  -8.07890832e-01f, -8.00892293e-01f, 3.54707360e-01f, -4.26830560e-01f, -4.40986812e-01f, -6.14478886e-01f, 4.42325383e-01f, 1.11204088e+00f, 1.13265252e+00f, -6.62501633e-01f,
  -3.62954170e-01f, -2.55073488e-01f, -6.61109108e-03f, -5.51993437e-02f, 1.52375489e-01f, -8.96571994e-01f, -1.02100539e+00f, -6.06044948e-01f, 2.21779034e-01f, -3.31191987e-01f,
  -4.25467566e-02f, -1.17867827e-01f, -8.19745958e-01f, -1.78796545e-01f, 4.11485359e-02f, -7.93469489e-01f, 6.04226589e-01f, -9.81087983e-02f, -5.24895847e-01f, 3.84756982e-01f,
  1.04887784e-01f, 2.08908692e-02f, -8.60122263e-01f, -5.73463999e-02f, -9.03911531e-01f, -7.83464134e-01f, 4.05305296e-01f, -1.06309199e+00f, -5.50219119e-01f, -2.80778352e-02f,
  1.02541161e+00f, -7.23231912e-01f, 9.71308768e-01f, 3.04048155e-02f, -1.23408043e+00f, -5.93850343e-03f, -5.33172905e-01f, -8.54409486e-02f, 5.01878738e-01f, 5.42697906e-01f,
  2.28080034e-01f, 3.15913856e-02f, -1.05786219e-01f, 1.41519636e-01f, 5.55009581e-02f, 3.20621759e-01f, 2.49166280e-01f, -4.77309078e-01f, 4.97566789e-01f, -5.85161448e-01f,
  1.82575539e-01f, 6.15719616e-01f, -5.22450268e-01f, -2.63642639e-01f, 9.80894446e-01f, -1.10077417e+00f, 2.37550903e-02f, -4.54916731e-02f, -5.23206115e-01f, -4.21890646e-01f,
  -4.84084278e-01f, 7.87957430e-01f, -1.07800281e+00f, -6.57133400e-01f, -6.62275434e-01f, -3.58049303e-01f, -8.88034046e-01f, -5.20314515e-01f, 7.01143801e-01f, 3.30418587e-01f,
  -5.04011810e-01f, 1.21718332e-01f, -2.28012819e-02f, 3.40792537e-01f, -1.62998063e-03f, 3.31554204e-01f, 1.02659039e-01f, -4.70149480e-02f, 1.61916241e-01f, 2.43726015e-01f,
  -1.00604817e-01f, 3.18964422e-01f, 4.60241437e-01f, 3.85993361e-01f, -5.67432463e-01f, 8.19179714e-01f, -3.65235329e-01f, 7.33988881e-01f, 6.32058620e-01f, -1.03770860e-01f,
  -1.16092646e+00f, -3.52703840e-01f, -4.19759303e-01f, -9.40376878e-01f, -8.82391036e-01f, -4.33271259e-01f, 6.25780463e-01f, -8.31423283e-01f, 6.72486722e-02f, 8.77645373e-01f,
  -7.26906538e-01f, 1.45756394e-01f, -8.27312469e-01f, -3.45192343e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -8.39528069e-02f, -9.07190964e-02f, 6.83915019e-02f, 3.03456970e-02f, -1.43589169e-01f, -5.76687455e-02f, -2.09524989e-01f, -5.41145727e-02f, -1.06713288e-02f, 1.28262639e-01f,
  1.19891524e-01f, 1.20693602e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    