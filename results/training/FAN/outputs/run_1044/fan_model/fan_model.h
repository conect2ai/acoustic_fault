/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.26622903e-01f, -2.69055188e-01f, -2.23894492e-01f, -3.01808808e-02f, 8.93947668e-03f, -1.85411245e-01f, -4.02075619e-01f, -1.08923845e-01f, 1.26665384e-01f, -1.81621805e-01f,
  1.88840210e-01f, 3.99978071e-01f, 1.83852792e-01f, 1.72031581e-01f, -7.03418702e-02f, -2.21441835e-01f, -1.42821550e-01f, -8.36753324e-02f, -7.69179389e-02f, 9.95572358e-02f,
  6.89385980e-02f, -4.71628457e-02f, 3.11676809e-03f, -1.74639970e-02f, 1.68297403e-02f, 1.35615572e-01f, -5.61782271e-02f, 1.56643521e-02f, 1.93362515e-02f, -8.87116864e-02f,
  -1.04924031e-02f, -1.96013629e-01f, 3.39201875e-02f, 9.40531194e-02f, -4.46153171e-02f, -9.03477147e-02f, -1.44259498e-01f, -1.70230508e-01f, -6.79273978e-02f, -5.26254252e-02f,
  7.00647980e-02f, 1.32803190e-02f, -1.12302840e-01f, -2.64389552e-02f, -1.55293718e-01f, -9.94037762e-02f, -4.81413789e-02f, -8.67046416e-02f, -1.43826276e-01f, -3.54395136e-02f,
  7.42026716e-02f, -1.98147278e-02f, -5.26032373e-02f, -3.66250090e-02f, -1.31728426e-01f, 1.01139277e-01f, -4.83146459e-02f, -3.28420140e-02f, 8.86633396e-02f, -4.19206694e-02f,
  7.04528615e-02f, 1.84418872e-01f, 1.88604165e-02f, 3.71583970e-03f, -5.41035272e-03f, 4.00570594e-02f, -3.55562493e-02f, -3.39642093e-02f, -1.11647556e-02f, -1.61591500e-01f,
  3.92088704e-02f, 6.88442588e-03f, -4.85406853e-02f, -9.78848413e-02f, 9.15731415e-02f, -3.91850434e-02f, -2.18143389e-02f, 4.66401912e-02f, 6.96562754e-04f, 1.27263013e-02f,
  -1.05510578e-01f, -1.49400029e-02f, -8.40010121e-03f, -3.91060524e-02f, -1.18935276e-02f, -1.01934848e-02f, -3.21341269e-02f, -5.38316481e-02f, 4.45209146e-02f, -3.54299136e-02f,
  5.32766897e-03f, 6.23015501e-02f, -1.07075483e-01f, -9.55905691e-02f, -1.29966829e-02f, -4.64712009e-02f, -4.64045294e-02f, -8.47112387e-02f, 6.38713455e-03f, -5.83961308e-02f,
  1.20633347e-02f, -1.06998354e-01f, -6.80604652e-02f, -1.13752084e-02f, -3.05839125e-02f, -3.56237516e-02f, 5.65033145e-02f, -6.59091249e-02f, 5.39841466e-02f, -1.61830224e-02f,
  -5.84696271e-02f, -4.51143719e-02f, -1.32438028e-02f, 3.70415971e-02f, 2.64957435e-02f, -4.14144285e-02f, 3.49742621e-02f, -8.70202929e-02f, 3.27911191e-02f, -2.42258772e-01f,
  -1.26830012e-01f, 2.82896869e-02f, -1.86283082e-01f, 2.86417931e-01f, -8.22590441e-02f, -1.72617123e-01f, -1.83386460e-01f, 2.28341054e-02f, 1.51142895e-01f, 1.57652915e-01f,
  2.26698034e-02f, 1.36191174e-01f, 2.25376219e-01f, -8.39499682e-02f, -1.00311048e-01f, -5.35142981e-02f, 7.44402558e-02f, -8.09651464e-02f, -3.85506481e-01f, -3.34569156e-01f,
  -9.52329487e-02f, 1.18117653e-01f, 7.06249923e-02f, -5.83187379e-02f, 1.82106882e-01f, 1.48448318e-01f, 2.50629216e-01f, 1.47625953e-01f, 1.69778522e-02f, 3.20968062e-01f,
  2.67683063e-02f, -1.68190598e-01f, 5.80647681e-03f, 2.30272627e-03f, 1.45021930e-01f, 3.38819474e-02f, 3.52684110e-02f, 1.91309258e-01f, 3.70597802e-02f, 1.35757133e-01f,
  5.07755615e-02f, -8.71309265e-03f, 2.58677229e-02f, 8.89540911e-02f, 7.26728737e-02f, 2.04518475e-02f, 4.74491902e-02f, -6.64578378e-02f, -3.90594862e-02f, -2.62047518e-02f,
  -1.06025618e-02f, -2.63742208e-02f, -1.24144413e-01f, -1.11909278e-01f, -6.45682141e-02f, 4.33823280e-03f, -2.66775098e-02f, -8.64880979e-02f, -1.41675249e-01f, 2.26058811e-01f,
  3.79006639e-02f, 3.66350301e-02f, 2.14014295e-02f, 6.96937367e-02f, 4.48626354e-02f, 6.12057373e-02f, 2.74080574e-03f, 2.14172825e-02f, -1.09593337e-02f, 7.64538124e-02f,
  1.19306304e-01f, -1.65690780e-02f, 1.72641966e-02f, 6.33722469e-02f, 7.33832717e-02f, 7.20211416e-02f, -1.95095614e-02f, 8.73301029e-02f, 9.88011286e-02f, 1.04663879e-01f,
  5.72616011e-02f, -1.20122358e-02f, 1.94297601e-02f, 4.40303534e-02f, -5.81766367e-02f, -2.15968001e-03f, 5.69421239e-02f, -6.52549639e-02f, 7.16506392e-02f, 2.33906470e-02f,
  2.97960162e-01f, -1.11540202e-02f, 1.44626498e-01f, 7.92901311e-03f, 5.68437204e-02f, 4.20346893e-02f, 1.25030831e-01f, -3.60707305e-02f, 1.24158319e-02f, 5.08552939e-02f,
  -6.72014877e-02f, 2.84758070e-03f, 2.98124496e-02f, -5.42276092e-02f, 2.34178361e-02f, 4.38965037e-02f, 4.92031723e-02f, -3.87061648e-02f, -3.99130173e-02f, 9.10744220e-02f,
  1.03211544e-01f, -4.68426980e-02f, 2.63167955e-02f, 7.19597414e-02f, 9.45329815e-02f, -6.15397841e-02f, 8.33534077e-02f, 3.26514244e-02f, -7.90390074e-02f, 1.94828808e-01f,
  4.01553273e-01f, -3.14352632e-01f, -3.04072887e-01f, 1.23433501e-01f, 3.07672676e-02f, 6.42531142e-02f, -2.19481945e-01f, 1.63254172e-01f, 1.82703391e-01f, -4.41436023e-02f,
  -9.78813469e-02f, 2.30609626e-01f, 1.74474288e-02f, 7.48122707e-02f, 1.73779465e-02f, -1.80592626e-01f, -2.28543073e-01f, 7.97628313e-02f, 3.16521704e-01f, 1.40937224e-01f,
  9.28357095e-02f, 1.08697854e-01f, 1.45201579e-01f, 1.63696811e-01f, 3.22741666e-03f, 2.22656056e-01f, -1.59057558e-01f, -1.33587420e-01f, -8.15444365e-02f, -3.59343082e-01f,
  -3.35754454e-01f, -2.84179181e-01f, 1.67055413e-01f, 1.99448690e-02f, -7.08565190e-02f, 4.79206853e-02f, 4.33187699e-03f, 7.11662397e-02f, 4.36708406e-02f, 5.14825014e-03f,
  -3.57954614e-02f, 8.69200677e-02f, -2.69025024e-02f, -2.15571430e-02f, -1.52144311e-02f, 2.16958150e-02f, -3.83863859e-02f, -9.13909357e-03f, 1.89027991e-02f, -1.00899197e-01f,
  -5.46431132e-02f, -1.42674476e-01f, -2.07061559e-01f, -9.31271762e-02f, -8.22979063e-02f, 9.06497464e-02f, -1.75816730e-01f, -1.39134616e-01f, -9.06813666e-02f, -1.52689844e-01f,
  9.56239104e-02f, -6.98834211e-02f, -7.70890042e-02f, -6.37524575e-02f, 7.50061423e-02f, -1.34202332e-04f, 6.49981899e-03f, -7.96673528e-04f, -4.85726297e-02f, -8.71441420e-03f,
  2.91202385e-02f, -5.61730899e-02f, -4.28548735e-03f, -2.84209475e-02f, 9.79422964e-03f, -6.57392219e-02f, -4.52245818e-03f, 2.91933157e-02f, -5.73958233e-02f, 7.33122081e-02f,
  -2.85609160e-02f, -2.96609718e-02f, 1.33727184e-02f, 5.03390506e-02f, 2.42800498e-03f, 3.15781571e-02f, 1.52897201e-02f, 5.58387563e-02f, 6.42243475e-02f, 9.43089724e-02f,
  1.45613834e-01f, -1.40048608e-01f, 4.48445752e-02f, -7.59963468e-02f, -6.58911280e-03f, 1.86460596e-02f, -7.80712366e-02f, -5.25774248e-03f, -1.61334909e-02f, 2.85308771e-02f,
  7.58770853e-02f, 3.06667220e-02f, 1.41018620e-02f, -9.53360051e-02f, 1.22681618e-01f, -4.00596745e-02f, -6.68403134e-02f, 4.52147759e-02f, -1.13449944e-02f, -2.20981315e-02f,
  3.03122867e-02f, 1.66965842e-01f, 1.87635303e-01f, -4.97754738e-02f, -4.56631742e-02f, 7.74871930e-02f, 7.12172985e-02f, 3.87138948e-02f, 5.03007844e-02f, 2.03285381e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.33133662e-02f, -4.78248261e-02f, -1.11071989e-01f, 2.50569373e-01f, 1.16397282e-02f, -7.02058971e-02f, -9.63301957e-02f, -1.08223200e-01f, -1.01382250e-03f, 1.68097578e-02f,
  1.28794268e-01f, 2.52751946e-01f, 1.10054679e-01f, 9.19232070e-02f, 3.91542912e-02f, 1.18139669e-01f, 2.52356231e-01f, 1.93013772e-01f, 5.87845333e-02f, 1.53925791e-01f,
  2.81165868e-01f, 6.57871889e-04f, -1.17372394e-01f, -1.03052128e-02f, 1.61357567e-01f, 1.28715247e-01f, -4.36440259e-02f, -7.79579580e-02f, 5.17616868e-02f, 4.21006083e-01f,
  1.68309093e-01f, 1.36350170e-02f, 7.14930743e-02f, 1.83538452e-01f, -7.59096742e-02f, -1.24582581e-01f, -7.22593218e-02f, -8.47076699e-02f, -3.10981795e-02f, -7.21663907e-02f,
  6.77660853e-02f, -3.24432664e-02f, 1.21952072e-01f, -3.02459896e-02f, -1.54648229e-01f, -1.97862461e-02f, -2.22986042e-02f, 2.67968811e-02f, -9.49801207e-02f, -1.46472886e-01f,
  2.15942621e-01f, 5.76758198e-02f, -1.76114753e-01f, -6.61815107e-02f, -6.78501725e-02f, 1.37345627e-01f, -9.04333964e-02f, -1.19496149e-03f, -2.22798422e-01f, -6.16313964e-02f,
  -9.85384174e-03f, -1.17742665e-01f, 3.50648537e-02f, 5.10973334e-02f, 2.21613079e-01f, 2.20564842e-01f, 1.34011924e-01f, 7.94663578e-02f, 3.10212653e-02f, -5.63042015e-02f,
  1.54998794e-01f, 2.93328464e-02f, -1.18434392e-01f, -1.36955619e-01f, 2.10800227e-02f, -6.49835318e-02f, -3.83142643e-02f, -4.83369529e-02f, -1.57560855e-01f, -8.44834149e-02f,
  -9.87698697e-03f, 7.10224882e-02f, -5.07067554e-02f, 1.51674762e-01f, -1.95341166e-02f, 7.29310662e-02f, -6.52885735e-02f, -1.13345191e-01f, -5.51206991e-03f, -1.37571782e-01f,
  -1.59869492e-01f, 1.91128859e-03f, 1.22094005e-01f, 2.42003314e-02f, -1.45225063e-01f, 4.79244888e-02f, -2.92033013e-02f, -7.45784268e-02f, -1.76501274e-02f, -9.68870074e-02f,
  -2.32083499e-02f, -5.51759489e-02f, -1.89113542e-02f, 4.10666168e-02f, 5.56846634e-02f, -2.61344407e-02f, 2.14039460e-02f, 1.54984608e-01f, 1.30552836e-02f, -2.41716206e-01f,
  3.74349914e-02f, -5.06029055e-02f, 2.53556985e-02f, -1.00252524e-01f, -1.06353626e-01f, 1.31728172e-01f, -1.54123262e-01f, -1.43233612e-01f, -1.97065428e-01f, -1.98483735e-01f,
  2.87757158e-01f, 7.67878443e-02f, 9.89823714e-02f, 4.34523374e-02f, 1.95668116e-01f, 3.05731833e-01f, 1.33352295e-01f, -5.01026288e-02f, -9.82030109e-03f, 4.62232204e-03f,
  -4.20915820e-02f, -2.05628082e-01f, -9.16080326e-02f, -9.52645615e-02f, -9.48822275e-02f, -6.07376024e-02f, -1.02697752e-01f, -2.54836142e-01f, -5.18241450e-02f, 6.65184483e-02f,
  -1.55356139e-01f, -1.36079788e-01f, -7.87134841e-02f, -1.16511889e-01f, -2.38910615e-02f, -4.27130945e-02f, 5.12422062e-02f, 2.22159535e-01f, 1.92664862e-01f, -9.44674537e-02f,
  -3.30955461e-02f, 2.69477099e-01f, 1.48216942e-02f, 5.03750257e-02f, 1.07649148e-01f, 4.54914197e-02f, -2.52696946e-02f, 9.41448957e-02f, 1.28888804e-02f, 1.35172391e-02f,
  2.73586158e-02f, -7.90416524e-02f, 3.82666998e-02f, 1.12926438e-02f, 3.24542075e-02f, 6.16297908e-02f, 6.89475890e-03f, -1.20748244e-02f, -3.17983073e-03f, 4.24823277e-02f,
  8.94518849e-03f, 1.60896689e-01f, 3.05154145e-01f, 1.01869702e-01f, 7.04129785e-02f, 1.94204330e-01f, 1.23833336e-01f, 1.46351203e-01f, 1.47062704e-01f, 9.65988412e-02f,
  -9.85171199e-02f, -1.12908058e-01f, 5.58018759e-02f, -4.21751216e-02f, -1.40026927e-01f, 8.22794661e-02f, 3.71529199e-02f, 3.63173746e-02f, -1.39232859e-01f, -7.96912387e-02f,
  -4.36147302e-02f, -1.40961051e-01f, -8.87445733e-02f, -2.22348068e-02f, -4.75009307e-02f, 5.93430735e-02f, 1.17295586e-01f, 1.38139511e-02f, -6.04995787e-02f, -4.48276103e-02f,
  -1.71804689e-02f, 6.67714179e-02f, 1.70293897e-02f, -5.58554716e-02f, 1.44694773e-02f, -7.57434964e-02f, 3.20187327e-03f, -6.36282712e-02f, -1.02393739e-02f, 4.40802872e-02f,
  6.41584247e-02f, 1.12420768e-01f, -1.95329294e-01f, -1.31666198e-01f, 1.44457430e-01f, 5.96278235e-02f, -4.04884629e-02f, 1.18650729e-02f, 1.46821707e-01f, 7.82395771e-04f,
  2.07958981e-01f, 7.20594265e-03f, 2.78009679e-02f, -5.67829758e-02f, -9.58458707e-02f, 1.07059248e-01f, 4.16383073e-02f, -5.73012866e-02f, 5.73115200e-02f, 1.15856193e-01f,
  5.11980355e-02f, 1.85556546e-01f, 2.45488659e-01f, 8.72979462e-02f, 1.50633380e-01f, 1.44841984e-01f, 1.61322430e-01f, 4.87685949e-02f, 1.71302751e-01f, 5.00705242e-02f,
  6.83645189e-01f, -1.93095312e-01f, -2.40474761e-01f, 6.38681501e-02f, -1.19060293e-01f, -1.60491511e-01f, -1.57590002e-01f, -1.29642319e-02f, 1.40581101e-01f, -2.13683024e-02f,
  2.36187026e-01f, 3.06598812e-01f, 2.27133587e-01f, 1.20121792e-01f, 1.05470866e-01f, -1.57056674e-01f, -2.80877739e-01f, -1.29942715e-01f, -1.64497904e-02f, 2.71132588e-02f,
  -3.73454653e-02f, -1.95956200e-01f, -9.30871293e-02f, 2.77615376e-02f, -1.16416588e-01f, 2.31392369e-01f, -3.33818011e-02f, -1.17363535e-01f, -1.04145750e-01f, -1.13955058e-01f,
  -5.06154299e-01f, 9.54706371e-02f, 1.96666330e-01f, 1.22617818e-01f, 2.05412079e-02f, 1.21561214e-01f, 9.78839770e-02f, -1.17949717e-01f, -3.84797645e-03f, -1.04181014e-01f,
  -2.45502573e-02f, -8.39304700e-02f, -5.63408583e-02f, 2.70600915e-02f, -1.57651544e-01f, -1.04629677e-02f, 7.46756941e-02f, 1.05242021e-02f, -7.46264756e-02f, -3.90962027e-02f,
  -1.85870416e-02f, 1.60206167e-03f, -5.27031114e-03f, 1.22602277e-01f, 3.31247263e-02f, 5.75059690e-02f, 9.31954607e-02f, 1.05088517e-01f, 1.83194280e-01f, 9.15592313e-02f,
  -7.38684461e-02f, 9.61316451e-02f, 1.39234185e-01f, 1.70738742e-01f, 5.33035584e-02f, 1.06183514e-02f, -5.89480735e-02f, -3.78829986e-02f, -1.42537029e-02f, 5.34948185e-02f,
  -5.28049022e-02f, 5.57995075e-03f, -3.45478230e-03f, 2.72529200e-02f, -2.75521167e-02f, 1.64866634e-02f, -5.26819117e-02f, -1.72020383e-02f, -7.58177936e-02f, 3.43223363e-02f,
  -7.47525017e-04f, -1.66260153e-02f, -1.19680800e-02f, -1.48095906e-01f, -1.44350424e-01f, 2.23916005e-02f, -6.90306909e-03f, 4.14396524e-02f, 4.68011834e-02f, -7.29798079e-02f,
  -2.07538873e-01f, 2.93337017e-01f, -1.14495738e-03f, 8.16692635e-02f, -9.56349969e-02f, -1.46521524e-01f, 8.02105218e-02f, -9.91497636e-02f, -1.36711970e-01f, -1.34850144e-01f,
  -1.29021376e-01f, -1.24233082e-01f, -1.79871708e-01f, -7.15288147e-03f, -2.09445823e-02f, -5.50263673e-02f, 1.65095910e-01f, -3.36757526e-02f, -1.65323347e-01f, -2.16808841e-01f,
  -6.50442615e-02f, 1.56473637e-01f, 2.06886411e-01f, 1.85419381e-01f, 1.00600749e-01f, 1.81724757e-01f, -1.22032359e-01f, -1.59194022e-02f, 1.25736460e-01f, 1.48512587e-01f,
  -1.49824649e-01f, -3.90061855e-01f, -1.88135237e-01f, -2.83919901e-01f, -2.84909427e-01f, -9.74766761e-02f, -2.35380620e-01f, 1.02852836e-01f, 3.17470096e-02f, -3.85853469e-01f,
  -1.02671683e-01f, 1.85807824e-01f, -7.22411051e-02f, 6.28871843e-02f, 4.66769300e-02f, -3.84649038e-01f, -2.74783224e-01f, 4.99910899e-02f, 3.69306326e-01f, 1.16559260e-01f,
  -5.03967740e-02f, 2.46328730e-02f, 1.45875558e-01f, 1.21020250e-01f, -2.30277181e-01f, -7.37791061e-02f, -1.44393325e-01f, -2.25731120e-01f, -2.00953379e-01f, -5.45455337e-01f,
  -2.04789773e-01f, 3.18340696e-02f, 7.95607269e-02f, 6.31849393e-02f, 1.53701361e-02f, -4.92260605e-02f, -3.02034840e-02f, 3.26800607e-02f, 1.10169239e-01f, 2.28317510e-02f,
  -1.79888994e-01f, 4.35745418e-02f, 3.68556231e-02f, 1.35410309e-01f, -4.92180884e-02f, 1.52194917e-01f, 3.96351330e-02f, 5.26003465e-02f, -1.40898868e-01f, -1.77529410e-01f,
  -1.79182619e-01f, -6.84775319e-03f, -1.00137509e-01f, -8.34472775e-02f, 1.00536598e-03f, 7.43153170e-02f, -6.57484382e-02f, -8.72017965e-02f, -2.43236274e-02f, -3.76910597e-01f,
  -5.80065474e-02f, 3.88339460e-02f, -4.46368717e-02f, -8.21259469e-02f, -1.67641218e-03f, -5.95336966e-02f, -1.10918447e-01f, -4.73427847e-02f, 4.39882502e-02f, -8.85913074e-02f,
  5.91943376e-02f, -7.24716708e-02f, 7.14782700e-02f, -4.54143807e-02f, -2.64886227e-02f, -1.25762567e-01f, -5.92009798e-02f, -4.31072749e-02f, 6.57145157e-02f, -2.55005043e-02f,
  1.84731446e-02f, -6.00779476e-03f, -4.10052165e-02f, 8.84981602e-02f, -1.04893714e-01f, -5.02184557e-04f, 1.65816210e-02f, -7.69249499e-02f, -1.15889600e-02f, -1.50607293e-02f,
  -4.59594615e-02f, 3.04263920e-01f, -2.01829121e-01f, 6.74139857e-02f, 3.86739820e-02f, 1.00529604e-02f, -1.42611668e-01f, 5.79150058e-02f, 4.81050387e-02f, -9.27797779e-02f,
  9.95384976e-02f, -2.54055336e-02f, -1.09265871e-01f, 1.05472602e-01f, -2.26221960e-02f, -6.02009445e-02f, -9.14242119e-02f, -1.28249759e-02f, -9.66172963e-02f, -1.12251244e-01f,
  -7.56197646e-02f, -1.12257175e-01f, -1.53857037e-01f, -1.27371430e-01f, -1.32282332e-01f, -1.37922429e-02f, -1.34977460e-01f, -1.76265821e-01f, 5.51457107e-02f, -2.01554596e-01f,
  3.76612663e-01f, 2.44967610e-01f, -6.09763972e-02f, 1.72144607e-01f, 1.02769751e-02f, -2.43126735e-01f, -1.44684479e-01f, -1.47680551e-01f, -1.17041141e-01f, -1.04388092e-02f,
  -2.52617560e-02f, 5.94242923e-02f, 1.32150561e-01f, 1.16955124e-01f, 3.70901898e-02f, 1.06278352e-01f, 2.49024794e-01f, 2.26764187e-01f, 1.55375883e-01f, -3.03911101e-02f,
  2.73137182e-01f, 1.39978319e-01f, 1.46036908e-01f, 1.25425488e-01f, 2.19461605e-01f, -4.80879657e-02f, -8.48599151e-02f, 2.53036693e-02f, 1.10131592e-01f, 4.83241022e-01f,
  -1.34925008e-01f, 1.07988343e-01f, -1.69736385e-01f, 2.03982845e-01f, 3.73126604e-02f, -9.28299222e-03f, -3.11493669e-02f, -3.78709957e-02f, 1.54769486e-02f, -1.08724773e-01f,
  4.95945998e-02f, 7.28731160e-04f, 1.11921243e-01f, 3.72442268e-02f, -4.29338701e-02f, -4.10650894e-02f, -1.72152277e-02f, 1.18857197e-01f, 1.41138270e-01f, -2.90390030e-02f,
  1.15858570e-01f, 4.94442098e-02f, -4.64644395e-02f, -8.51901472e-02f, -3.13807093e-02f, -1.76607575e-02f, -9.62432623e-02f, 6.52817190e-02f, -8.57053101e-02f, 5.97209223e-02f,
  -8.43601972e-02f, 1.10144675e-01f, -7.31619000e-02f, 1.96246710e-02f, 2.51220688e-02f, -1.19122192e-01f, -7.36175524e-03f, 3.78482067e-03f, 1.64619833e-01f, 8.43872949e-02f,
  -1.38597950e-01f, -6.37463257e-02f, -3.19789685e-02f, -2.05192193e-02f, 1.57763269e-02f, 7.01404586e-02f, 8.69423971e-02f, 1.24025168e-02f, -1.18914664e-01f, 1.06341001e-02f,
  1.36500180e-01f, -2.29102727e-02f, 3.85418683e-02f, 8.04372970e-03f, 3.42370756e-02f, -4.26235907e-02f, -3.55606899e-02f, -5.99341020e-02f, 2.26300042e-02f, 1.13861777e-01f,
  -5.29217899e-01f, -2.37242088e-01f, 8.90534073e-02f, 3.19328725e-01f, 1.73319429e-01f, 1.05933785e-01f, 5.64214028e-02f, 8.03795904e-02f, 9.78948623e-02f, -8.20438713e-02f,
  5.55155687e-02f, 5.87132536e-02f, 4.18886123e-03f, -1.40040383e-01f, -8.51676613e-02f, -1.54753000e-01f, 8.25992450e-02f, 1.26321405e-01f, 1.00023104e-02f, -9.33175087e-02f,
  3.79952975e-02f, -1.98840886e-01f, -2.93000489e-01f, -1.27553657e-01f, 1.77065586e-03f, -1.74004048e-01f, -1.99911594e-01f, -2.21597240e-03f, -1.26550764e-01f, -1.74125567e-01f,
  -4.47983086e-01f, -3.29990648e-02f, 2.78612167e-01f, -1.47792175e-01f, -2.61676520e-01f, -3.26646596e-01f, -2.89627612e-01f, -1.46862224e-01f, -2.92072259e-02f, 6.20767102e-03f,
  5.67516014e-02f, 1.15070619e-01f, 1.60281971e-01f, 2.01529965e-01f, 1.98115557e-01f, 7.65671134e-02f, 1.26095459e-01f, 1.10469848e-01f, 1.29605636e-01f, -5.41998670e-02f,
  1.20197602e-01f, 1.36147484e-01f, 8.69876891e-02f, -9.80990231e-02f, -2.27861136e-01f, 2.35966463e-02f, 1.76025316e-01f, 5.29101305e-02f, -1.10307559e-01f, 1.25079647e-01f,
  1.32354602e-01f, -3.75958830e-01f, -3.89896259e-02f, -2.14014515e-01f, -1.32257551e-01f, -2.49071553e-01f, -3.14728647e-01f, -3.24784547e-01f, -2.09390849e-01f, 6.21126965e-02f,
  -1.24937572e-01f, -8.86415392e-02f, -1.48653314e-01f, -4.76037301e-02f, -2.97582261e-02f, -1.72531843e-01f, -1.64505318e-01f, -9.65294465e-02f, -1.13938987e-01f, -6.19797222e-02f,
  7.87625611e-02f, 5.75795658e-02f, -1.51388034e-01f, -5.44130392e-02f, -1.00729674e-01f, -2.23648567e-02f, 8.70246142e-02f, -4.95234579e-02f, -3.53291221e-02f, 4.84151356e-02f,
  4.05839048e-02f, 2.65521891e-02f, -1.15154229e-01f, 3.60868052e-02f, 1.14634901e-01f, -8.51016045e-02f, -7.27847144e-02f, 1.14633046e-01f, 1.48678958e-01f, 4.48263809e-02f,
  -1.17473297e-01f, -3.59723009e-02f, 7.19208941e-02f, 4.53188410e-03f, -9.92873162e-02f, -1.31139129e-01f, -6.41473904e-02f, 8.27811509e-02f, -1.61774278e-01f, 2.07311418e-02f,
  3.52079421e-02f, 1.18644826e-01f, 2.67374199e-02f, -9.13270712e-02f, -3.21040978e-03f, 3.04203350e-02f, -4.96667549e-02f, 2.78151631e-02f, 9.25774779e-03f, -1.73943296e-01f,
  1.60926089e-01f, 4.64450917e-04f, 9.50208157e-02f, -2.57490762e-02f, -5.04489057e-02f, -1.59746721e-01f, -7.79060721e-02f, -1.39827862e-01f, 2.90898122e-02f, -8.46914127e-02f,
  -2.56880075e-02f, 2.30527706e-02f, -5.87946661e-02f, 4.54818867e-02f, -2.73643509e-02f, 2.80895662e-02f, 4.06622700e-03f, -1.43808350e-01f, 2.79405620e-02f, -1.49483055e-01f,
  1.03738263e-01f, 2.36114040e-02f, 1.88042998e-01f, 1.96350545e-01f, 8.75087902e-02f, 2.16182834e-03f, 1.85978964e-01f, 1.29907697e-01f, 8.80150199e-02f, 9.08039436e-02f,
  -3.65343206e-02f, -1.17277808e-01f, 8.18005651e-02f, -3.74237448e-01f, -2.34779105e-01f, -1.90334413e-02f, 1.28471717e-01f, -1.76300153e-01f, -2.55956441e-01f, -5.48644476e-02f,
  -3.28123420e-02f, 1.90568358e-01f, 1.99411705e-01f, 1.98176011e-01f, 1.58717811e-01f, -5.73704466e-02f, -2.24013105e-01f, 1.78676650e-01f, 2.67772555e-01f, 4.70662266e-02f,
  -1.51052311e-01f, -2.23712742e-01f, -1.22271098e-01f, -8.18930641e-02f, -1.58271819e-01f, 6.63358346e-02f, -1.97281763e-01f, -1.76154077e-01f, -3.38043049e-02f, -2.94726789e-01f,
  4.89869654e-01f, -1.64953232e-01f, 5.93263432e-02f, -7.10851774e-02f, -5.93652129e-02f, 4.55717631e-02f, 7.14037344e-02f, -3.94832995e-03f, -1.29435837e-01f, -1.48972690e-01f,
  -4.68591787e-02f, -7.43905082e-02f, -6.50307387e-02f, -2.09859181e-02f, 1.05025200e-02f, -4.21070270e-02f, -1.34746224e-01f, -1.78024933e-01f, -8.48622993e-02f, 3.33255678e-02f,
  -1.00211568e-01f, -4.99759465e-02f, 3.91494036e-02f, -7.61702470e-03f, -1.08021729e-01f, 2.36522947e-02f, -1.36533156e-01f, -1.84298411e-01f, -7.48591796e-02f, 1.69868451e-02f,
  1.67690992e-01f, -7.41041219e-03f, 1.49466470e-02f, -9.33972076e-02f, -4.29153023e-03f, 4.63345014e-02f, 3.49957272e-02f, 4.95382510e-02f, 3.43765132e-02f, -1.24799972e-02f,
  -1.51697928e-02f, -5.88060962e-03f, -8.99980366e-02f, -1.30163237e-01f, -1.60029344e-02f, -1.78862691e-01f, -7.57006556e-02f, -1.14878863e-01f, -1.22857049e-01f, -5.63794114e-02f,
  -5.02266288e-02f, -8.52851793e-02f, -1.14628412e-01f, -2.28357390e-02f, -2.38735944e-01f, -6.62776604e-02f, -6.64415732e-02f, -1.26468927e-01f, -9.69391130e-03f, -7.84364119e-02f,
  9.99918655e-02f, -1.22615263e-01f, 2.10679248e-01f, -2.62793638e-02f, 5.04376441e-02f, 1.94694884e-02f, 1.53322428e-01f, -8.41717720e-02f, 5.30372784e-02f, 5.25163077e-02f,
  8.38269740e-02f, 1.38336897e-01f, 3.28737944e-02f, 1.58882216e-02f, -2.77447067e-02f, -7.56105036e-02f, 3.86302881e-02f, 7.52822235e-02f, -7.74092153e-02f, -1.01191618e-01f,
  -1.55731633e-01f, -1.01492042e-02f, 1.26634598e-01f, 1.51457995e-01f, 1.70184076e-01f, 3.08283031e-01f, 2.32651234e-01f, 2.75314543e-02f, 1.37309387e-01f, 1.73968539e-01f,
  -2.91290909e-01f, -1.02496684e-01f, 9.70445946e-02f, 4.69323605e-01f, 4.22680825e-01f, 3.51050496e-01f, 2.74061054e-01f, 2.45308101e-01f, 1.88651994e-01f, 1.67948410e-01f,
  7.63846561e-02f, 2.12239265e-01f, 1.68967023e-01f, 2.38823175e-01f, 2.29721308e-01f, 1.89109415e-01f, 2.49033526e-01f, 1.47053376e-01f, 4.88017425e-02f, 1.60325497e-01f,
  2.21876696e-01f, -1.82976555e-02f, -1.08636215e-01f, -1.47609832e-02f, 7.94471279e-02f, 2.03592688e-01f, 1.19677879e-01f, 1.55039117e-01f, 9.55348909e-02f, 1.14171930e-01f,
  3.42654362e-02f, -3.62016819e-02f, 4.42150235e-02f, -9.00257528e-02f, -9.55030173e-02f, -2.64259875e-01f, -8.46958756e-02f, -9.32315663e-02f, -8.69722478e-03f, -1.04103483e-01f,
  6.19708374e-03f, -7.13364929e-02f, 1.06114736e-02f, -1.38707250e-01f, -1.24499388e-01f, -1.86660856e-01f, -4.42670025e-02f, 2.11602505e-02f, 7.29175210e-02f, 1.32821512e-03f,
  -4.27224748e-02f, -1.49526551e-01f, 4.61296849e-02f, 1.09862434e-02f, 1.28250942e-01f, 7.57477358e-02f, -7.20936507e-02f, 1.42942346e-03f, -7.61426017e-02f, -1.58740431e-01f,
  1.13696881e-01f, -5.37142344e-02f, -5.35479141e-03f, -1.09400246e-02f, -7.48466328e-02f, -1.65840834e-01f, 5.97056001e-02f, -9.89833102e-03f, -6.87065395e-03f, -2.27269426e-01f,
  9.54944417e-02f, 9.57412720e-02f, 6.83271661e-02f, -3.80215198e-02f, -6.85973987e-02f, -7.24149123e-02f, -1.59715012e-01f, -1.95284728e-02f, -1.83163211e-01f, -6.26278743e-02f,
  -6.64055273e-02f, 2.10644267e-02f, -3.29031050e-02f, 3.21850032e-02f, 2.45562736e-02f, 7.30838701e-02f, -9.62169915e-02f, -3.82305458e-02f, -6.03592675e-03f, -1.12187766e-01f,
  1.48262918e-01f, 1.24398544e-01f, 1.71955265e-02f, 1.77639827e-01f, -5.97709045e-03f, -1.08935431e-01f, 1.42676964e-01f, 5.68798929e-03f, 2.30654962e-02f, 8.37948024e-02f,
  -1.41233042e-01f, -5.74927777e-02f, -9.23477635e-02f, -1.24106258e-01f, 3.56183993e-03f, -9.46312547e-02f, -6.68323040e-02f, 8.04098099e-02f, 2.16982532e-02f, -1.03356992e-03f,
  1.19537646e-02f, 3.36355194e-02f, 5.10610342e-02f, 3.58492434e-02f, 9.29346457e-02f, 1.37111023e-02f, -2.19697244e-02f, -1.10801451e-01f, -4.38584685e-02f, -4.62110229e-02f,
  3.88715565e-01f, 4.42095965e-01f, -8.72552991e-02f, 1.03975885e-01f, 1.20418213e-01f, 2.22292095e-01f, 5.86849391e-01f, 2.34466195e-01f, -1.18417010e-01f, 1.33862093e-01f,
  -1.05355188e-01f, -4.28221077e-01f, -3.05559278e-01f, -2.66328812e-01f, -6.73550218e-02f, 3.30444068e-01f, 2.16278717e-01f, -1.41845465e-01f, -2.36717120e-01f, -5.82417101e-02f,
  -1.01577327e-01f, 1.82493582e-01f, 1.24400325e-01f, -5.55380201e-03f, 1.73724741e-01f, -2.91180193e-01f, 1.34689122e-01f, 1.30653813e-01f, -1.04243152e-01f, -1.81105360e-01f,
  -4.32925820e-01f, 2.12309241e-01f, -1.56256765e-01f, -9.88747776e-02f, -1.94392711e-01f, -4.16921787e-02f, 7.10529415e-03f, 2.33224519e-02f, -2.19671100e-01f, -7.15228990e-02f,
  -1.80146828e-01f, -4.47257571e-02f, -1.26712933e-01f, -9.52026173e-02f, 5.41850142e-02f, -1.26267642e-01f, 1.07559279e-01f, 4.98198457e-02f, -1.82631865e-01f, -2.04939142e-01f,
  -1.88699514e-01f, -1.24324478e-01f, 8.57267529e-02f, -3.74425668e-03f, -1.55738264e-01f, -2.21551776e-01f, -1.20308874e-02f, -7.48123974e-02f, -2.83706844e-01f, 5.32907769e-02f,
  -1.00280829e-01f, -6.81560710e-02f, 9.18199401e-03f, 6.15028143e-02f, 8.57108161e-02f, -2.89453752e-02f, -7.95282125e-02f, 7.65885264e-02f, 1.15589583e-02f, 1.20865768e-02f,
  -4.15264070e-02f, -8.22803937e-03f, -1.02585837e-01f, 9.49622914e-02f, -5.68958707e-02f, -2.69941259e-02f, -8.19458663e-02f, 1.67527705e-01f, 1.39192492e-02f, 5.13703525e-02f,
  -4.75235172e-02f, -8.92487727e-03f, -4.56338786e-02f, -1.80819899e-01f, -4.14525270e-02f, -2.36532353e-02f, -1.31724671e-01f, -4.56902608e-02f, 1.33576393e-02f, 6.38459018e-03f,
  -2.85255283e-01f, -1.53656170e-01f, -1.16899408e-01f, 4.86896373e-03f, 7.80848861e-02f, -3.11329905e-02f, -3.60897779e-02f, -6.31124005e-02f, 9.57135782e-02f, 2.34029628e-02f,
  -8.61009490e-03f, -2.78258920e-02f, -1.32935103e-02f, 1.02494799e-01f, 1.73679609e-02f, 3.67462747e-02f, 1.51315108e-01f, 9.85656865e-04f, -6.56551495e-02f, 7.98325986e-02f,
  8.13567489e-02f, 2.32480004e-01f, 8.88655558e-02f, 7.25633204e-02f, -4.71161604e-02f, -8.42317939e-02f, 1.87841862e-01f, 1.95669755e-02f, 2.00875364e-02f, 3.17323744e-01f,
  -4.21747088e-01f, 1.81319848e-01f, 7.64078349e-02f, -1.71892457e-02f, 3.16368043e-01f, 1.94373548e-01f, 5.29036373e-02f, -1.30277514e-01f, -4.87919562e-02f, 9.14441496e-02f,
  1.66714162e-01f, 8.61547515e-02f, 1.36993498e-01f, -1.26741128e-02f, -2.27696255e-01f, 2.29644462e-01f, 2.02277392e-01f, -1.97722837e-01f, -1.64736867e-01f, -1.04110055e-01f,
  2.34664381e-01f, -9.59054828e-02f, -2.68228024e-01f, -9.87268165e-02f, 2.36894146e-01f, -2.59615295e-02f, 2.39332132e-02f, 6.49654567e-02f, 1.23038307e-01f, 2.47089475e-01f,
  1.63810894e-01f, -1.74788371e-01f, 1.09258547e-01f, 7.86124822e-03f, -8.38692021e-03f, -2.38073528e-01f, -1.58745840e-01f, 2.20784508e-02f, -2.42675841e-03f, -1.68715268e-02f,
  1.15051448e-01f, -3.42049822e-02f, 1.26378104e-01f, -1.01372689e-01f, -1.26976997e-01f, -1.40093729e-01f, -2.82273710e-01f, -3.08286965e-01f, -3.15944582e-01f, -2.90161937e-01f,
  1.56465188e-01f, 6.92312047e-02f, -6.68408945e-02f, -1.32327244e-01f, 1.58505403e-02f, -1.76239774e-01f, -8.63072127e-02f, -1.72405273e-01f, -2.12055549e-01f, -2.54596978e-01f,
  -5.03033586e-03f, 2.01417296e-03f, 6.84804171e-02f, 7.34167732e-03f, -3.50071229e-02f, 1.48066327e-01f, 7.28154629e-02f, 1.69689715e-01f, 9.64515060e-02f, -6.38459157e-03f,
  1.69725937e-03f, -5.67983948e-02f, -6.77458802e-03f, 4.58829738e-02f, 6.63358048e-02f, 6.73968270e-02f, 1.05794050e-01f, -9.06950757e-02f, 1.63346436e-02f, -1.08099163e-01f,
  4.65392740e-03f, 3.61183807e-02f, 8.86721313e-02f, -5.22195473e-02f, 3.28575373e-02f, 4.12711948e-02f, 6.90681785e-02f, -2.14347634e-02f, 6.89463988e-02f, 1.04347467e-01f,
  -8.85387138e-02f, 1.01232089e-01f, 4.10375483e-02f, -6.27369760e-03f, 1.17538154e-01f, -6.61603734e-02f, -2.09494103e-02f, 1.47921458e-01f, 1.23845059e-02f, -2.00265527e-01f,
  -1.36185978e-02f, -4.74545397e-02f, 1.80537984e-01f, 5.32459952e-02f, -7.11017475e-02f, 3.36794779e-02f, -3.22007500e-02f, 5.15192263e-02f, -1.25778943e-01f, -1.58921733e-01f,
  -5.77875227e-02f, -1.57101139e-01f, -1.14710562e-01f, -2.28130147e-02f, 3.62653919e-02f, -1.89805314e-01f, -5.89150973e-02f, -8.08012262e-02f, -7.44596720e-02f, -1.36642054e-01f,
  -3.64028186e-01f, -1.32755503e-01f, -1.32509053e-01f, 2.62630507e-02f, 8.42330977e-02f, 8.00826922e-02f, -2.00962067e-01f, -1.11946501e-01f, 1.14538006e-01f, -1.73779592e-01f,
  8.16650339e-04f, -4.31043133e-02f, -7.37886205e-02f, -1.43100396e-01f, -5.29146433e-01f, -3.78461361e-01f, -2.17366233e-01f, -3.35440755e-01f, -2.70229489e-01f, 2.03126699e-01f,
  7.18264207e-02f, -1.59596458e-01f, -1.47887021e-01f, 5.44926012e-03f, 1.86468422e-01f, 3.19548696e-02f, -8.00724030e-02f, -1.46865979e-01f, -4.88916747e-02f, -9.66619998e-02f,
  -1.56443998e-01f, 2.03543399e-02f, 1.73776835e-01f, 2.02132203e-02f, 1.58425763e-01f, -2.79134847e-02f, 7.28669092e-02f, -9.08317119e-02f, 1.25203580e-01f, 1.08696213e-02f,
  5.17261541e-03f, 1.01459101e-01f, 1.33485377e-01f, 9.21817124e-02f, 2.51074638e-02f, -1.33234337e-01f, -8.69520605e-02f, -7.59486631e-02f, -4.34604362e-02f, 6.16309680e-02f,
  5.81176095e-02f, -1.13025844e-01f, -1.92931250e-01f, -2.67122220e-02f, -7.04858825e-02f, -1.14483066e-01f, 1.50208429e-01f, 1.60294041e-01f, -1.78542435e-02f, -1.85921550e-01f,
  3.05996742e-02f, 7.95619935e-03f, 1.49981141e-01f, -6.85356110e-02f, -1.22390829e-01f, -1.71418046e-03f, 8.38677734e-02f, -1.25460654e-01f, 1.15592154e-02f, -8.07546303e-02f,
  -1.01181194e-02f, -1.83082707e-02f, -3.99971679e-02f, 4.63284366e-02f, -7.14673623e-02f, 8.37819353e-02f, -3.71671729e-02f, -3.69567983e-02f, -4.42874171e-02f, -1.07740752e-01f,
  -2.67305430e-02f, 9.63629633e-02f, -3.36984098e-02f, -5.43341897e-02f, -6.15231358e-02f, -1.66867673e-01f, 2.80064382e-02f, -8.18611011e-02f, -1.30116597e-01f, 3.36246416e-02f,
  -2.23699510e-01f, -3.30477178e-01f, -2.51097977e-02f, 1.02908783e-01f, 4.78854328e-02f, 9.35226381e-02f, 1.22759059e-01f, -9.06382967e-03f, -2.91075371e-02f, 5.95183950e-03f,
  -2.04856656e-02f, -8.39904919e-02f, 2.51565389e-02f, 8.94920826e-02f, 4.76555601e-02f, -1.46410353e-02f, -1.47798777e-01f, -1.11243889e-01f, 1.18020676e-01f, 1.71031415e-01f,
  -1.89905521e-02f, -1.70967236e-01f, -3.31616372e-01f, -1.73748687e-01f, 6.12057373e-03f, -2.49517471e-01f, -1.12710461e-01f, 4.82045673e-02f, -2.11273029e-01f, -4.55383241e-01f,
  3.47402990e-01f, 9.49827731e-02f, -3.69376361e-01f, 1.17045507e-01f, -3.35149854e-01f, -2.69215882e-01f, -1.09660521e-01f, 5.04805595e-02f, 2.09376186e-01f, -1.09506190e-01f,
  -1.34486556e-01f, 1.51112363e-01f, 9.74250957e-02f, -6.50062189e-02f, 1.52315900e-01f, -1.89596534e-01f, -2.63644516e-01f, -6.71972409e-02f, -9.48276818e-02f, -2.23032117e-01f,
  -6.81226403e-02f, -7.76182711e-02f, 1.70174800e-02f, -4.53844108e-03f, -2.27232486e-01f, -7.51056001e-02f, -2.22107545e-01f, -1.17086455e-01f, -2.93353885e-01f, -3.56680065e-01f,
  -8.47580954e-02f, -2.53066659e-01f, -4.46413346e-02f, -3.97698358e-02f, -1.06298938e-01f, 3.02795079e-02f, -9.77756083e-02f, -4.28398810e-02f, -1.91274937e-02f, 2.51770429e-02f,
  -1.08090555e-02f, -2.63488479e-02f, -1.89952746e-01f, -9.55300108e-02f, -1.74268112e-01f, -1.25858918e-01f, -1.08229890e-02f, -6.47509238e-03f, -9.92891118e-02f, -1.58888400e-01f,
  -4.37165834e-02f, -1.16807275e-01f, -7.61660840e-03f, 2.46581063e-02f, -1.38973787e-01f, -1.45070210e-01f, -1.23890087e-01f, -1.33226350e-01f, -6.17784411e-02f, -5.32892533e-02f,
  -8.45883600e-03f, 5.78791648e-03f, -1.44219264e-01f, 2.04702956e-03f, 2.86916979e-02f, -4.02367953e-03f, -4.26782630e-02f, -1.45070655e-02f, 3.16773616e-02f, 3.28478403e-03f,
  -1.84935518e-02f, -2.53495239e-02f, -2.49379762e-02f, 2.12689280e-03f, -1.07455976e-01f, -9.66014937e-02f, 2.72149965e-03f, 1.21018238e-01f, -5.68493381e-02f, -9.22343954e-02f,
  1.79096833e-02f, -1.39174955e-02f, 2.86171269e-02f, 5.80050722e-02f, -5.43118417e-02f, -1.10585123e-01f, 2.22150572e-02f, -8.13035369e-02f, 3.56215872e-02f, -9.17608961e-02f,
  3.90024364e-01f, -1.73750773e-01f, 1.61641970e-01f, 1.11559473e-01f, -6.51972890e-02f, -3.31767239e-02f, 9.80687365e-02f, 7.92924613e-02f, -1.61043089e-02f, 9.34693068e-02f,
  -7.82685950e-02f, 9.42273661e-02f, -9.60551128e-02f, -6.19086660e-02f, -3.33151072e-02f, 7.72459432e-03f, 2.65246127e-02f, 1.97458882e-02f, -1.08673230e-01f, -7.25045474e-03f,
  3.90573069e-02f, 1.54682562e-01f, 2.04016045e-01f, 1.63269162e-01f, -2.16377638e-02f, 1.18109487e-01f, 6.90227151e-02f, 5.56392483e-02f, 7.57762343e-02f, 3.13013792e-01f,
  -5.67040443e-01f, 2.99691379e-01f, 1.11383513e-01f, -4.81024273e-02f, 1.61815867e-01f, 1.92453608e-01f, 3.51873219e-01f, -9.60405245e-02f, -2.12886527e-01f, 1.69197530e-01f,
  3.44344109e-01f, -5.47084399e-02f, -9.44433967e-04f, 1.37271145e-02f, -7.75744393e-02f, 1.73933625e-01f, 2.14782625e-01f, -1.27215147e-01f, -3.39717448e-01f, -1.53821051e-01f,
  -1.59717556e-02f, -2.62918532e-01f, -4.14528877e-01f, -1.64203078e-01f, 8.91352892e-02f, -1.15446508e-01f, 3.95085812e-02f, -8.33171755e-02f, 1.02579415e-01f, 3.24486792e-01f,
  -1.59890112e-02f, -2.86620632e-02f, 6.91903522e-03f, -9.37458053e-02f, 9.08492804e-02f, -1.26648694e-01f, -1.10061295e-01f, -4.14873585e-02f, 2.36029569e-02f, 4.50129770e-02f,
  -4.17736694e-02f, 3.95157970e-02f, 1.72156081e-01f, 8.96077529e-02f, -1.36590138e-01f, -9.65139791e-02f, -2.04226762e-01f, -1.58577889e-01f, -3.72233987e-02f, -1.80224448e-01f,
  6.42673150e-02f, -4.41603139e-02f, 9.89464298e-03f, 2.37880666e-02f, 5.36835231e-02f, -7.03164563e-02f, -1.06946126e-01f, -1.19029328e-01f, -1.19724281e-01f, -2.14011461e-01f,
  -2.04967633e-02f, -4.73668724e-02f, 1.43206930e-02f, -1.49624392e-01f, -6.67866543e-02f, 6.90076593e-03f, -3.95240169e-03f, 6.27397597e-02f, -7.90100358e-03f, -1.02203302e-01f,
  1.67775527e-01f, -4.85071465e-02f, 1.30296824e-02f, 4.74646725e-02f, -1.12978131e-01f, -4.64379191e-02f, -2.88600009e-02f, -8.23205188e-02f, -1.60425603e-01f, -1.04218110e-01f,
  7.83018246e-02f, 5.04451692e-02f, 9.89047438e-02f, -6.32187054e-02f, 1.34782270e-01f, -2.63394918e-02f, -1.16986617e-01f, -2.78291386e-03f, 1.55017395e-02f, 4.03137952e-02f,
  -1.97311133e-01f, 4.85643782e-02f, -9.95117128e-02f, -1.09244570e-01f, 6.39090613e-02f, 1.37628429e-02f, 9.81962830e-02f, 1.47106620e-02f, 1.10397518e-01f, -6.82784338e-03f,
  6.81857914e-02f, 7.04947487e-02f, 5.25484234e-02f, -5.09927347e-02f, -9.71314982e-02f, -7.81955197e-02f, -1.08589001e-01f, -2.45032441e-02f, -9.07633901e-02f, -1.10210747e-01f,
  -8.69096369e-02f, -1.75187752e-01f, -1.19794048e-01f, 1.84927154e-02f, -1.70532107e-01f, -1.97034553e-01f, -1.47455379e-01f, -1.60653874e-01f, -6.13619797e-02f, -1.22892529e-01f,
  6.13267660e-01f, 1.26788527e-01f, 4.93232399e-01f, 2.11689606e-01f, 2.74764091e-01f, 3.20073754e-01f, 3.40970755e-01f, 2.17318937e-01f, 8.70547220e-02f, 1.53505877e-01f,
  5.98675720e-02f, -9.50054824e-02f, -6.63845167e-02f, -1.03398792e-01f, -5.56787774e-02f, 1.19103655e-01f, -3.38071794e-03f, 4.30684015e-02f, 5.26061356e-02f, 1.20083272e-01f,
  -5.51433004e-02f, 5.58694191e-02f, 4.11742665e-02f, 1.01975061e-01f, 1.70626829e-03f, 4.05897871e-02f, 1.12721898e-01f, 1.07512437e-01f, -9.59824547e-02f, -3.66196372e-02f,
  -1.98580071e-01f, 1.85877427e-01f, 1.09517232e-01f, -1.35568976e-01f, 1.04155026e-01f, -2.15379521e-02f, -9.16555617e-03f, -7.35189691e-02f, -1.52082875e-01f, -7.86363333e-02f,
  -5.09474538e-02f, -1.16937958e-01f, -3.37051339e-02f, 9.24364179e-02f, 6.80082887e-02f, 6.19140230e-02f, -5.17526530e-02f, 3.52934934e-02f, -1.15976529e-02f, -8.77015665e-02f,
  -6.04842268e-02f, -5.75842187e-02f, 1.73007697e-01f, 7.43398350e-03f, 1.42870303e-02f, 1.21204723e-02f, 7.58999288e-02f, 9.64196324e-02f, 1.12747550e-01f, 6.73006624e-02f,
  -8.97311885e-03f, 2.49233589e-01f, 1.02411278e-01f, 2.54466925e-02f, 6.92498405e-03f, 1.12321392e-01f, -3.08542456e-02f, -4.46144603e-02f, 1.66635707e-01f, 3.35660949e-02f,
  -2.85148155e-02f, 4.07229401e-02f, -9.74333961e-04f, 2.53008050e-03f, 3.64300013e-02f, -3.59028243e-02f, -2.98785530e-02f, -1.29991099e-01f, -3.82039845e-02f, -1.02822646e-01f,
  -1.16018273e-01f, 8.68217275e-02f, 7.09722470e-03f, -1.13631196e-01f, -6.61248192e-02f, 6.93451166e-02f, -2.31400579e-02f, -1.20957129e-01f, -1.69422645e-02f, -1.26094550e-01f,
  -3.48282874e-01f, -9.58472043e-02f, -1.35256931e-01f, -2.07507968e-01f, -2.37480607e-02f, -5.78438491e-03f, -1.67321227e-02f, 9.00776032e-03f, -1.37886778e-01f, -1.37006491e-01f,
  -6.55922219e-02f, -9.54727978e-02f, -7.80974105e-02f, 4.58443314e-02f, -1.08495571e-01f, -8.54000729e-03f, -7.19432458e-02f, -7.19196275e-02f, -2.89560463e-02f, -8.87694657e-02f,
  -1.38239130e-01f, -6.07703850e-02f, 1.05372638e-01f, 1.00378029e-01f, -3.94215472e-02f, 1.47520062e-02f, 3.94299179e-02f, -3.38687038e-04f, 1.13814957e-01f, 7.08464682e-02f,
  2.55621463e-01f, 2.50382334e-01f, 6.96445704e-02f, 8.83356407e-02f, 6.81159422e-02f, -1.04103655e-01f, -1.97665870e-01f, -1.22425497e-01f, 1.27658248e-01f, 1.56349033e-01f,
  5.52025773e-02f, 2.19254047e-02f, 1.37982108e-02f, -7.97678716e-03f, -2.12296933e-01f, -4.07610275e-02f, 6.22490235e-02f, 7.19523206e-02f, -1.36960536e-01f, -1.54721439e-01f,
  1.17717050e-01f, 2.08286121e-01f, 3.62983458e-02f, -2.11372167e-01f, 1.49219364e-01f, 1.43057173e-02f, 6.24149553e-02f, 2.40248650e-01f, 5.95629178e-02f, 2.31971517e-01f,
  8.57545584e-02f, 1.16427600e-01f, -4.24013913e-01f, 1.25381529e-01f, 6.72456324e-02f, 1.79348532e-02f, 1.01076543e-01f, 1.42884925e-01f, 3.59950028e-02f, 1.11289680e-01f,
  1.73516914e-01f, 1.56406790e-01f, 1.10604078e-01f, -9.60224122e-02f, 1.03861362e-01f, -1.18529834e-01f, -1.36513099e-01f, -4.82269078e-02f, -1.54378384e-01f, -8.63907337e-02f,
  1.22844681e-01f, 3.19126070e-01f, -1.91359408e-02f, -2.44187534e-01f, -1.79657295e-01f, -1.04955517e-01f, -7.33093917e-02f, -6.81126267e-02f, -1.45264342e-01f, 4.73101661e-02f,
  -4.56514284e-02f, -1.49354665e-02f, -2.85978280e-02f, -7.35817626e-02f, 3.42156254e-02f, -4.76610661e-02f, 3.71754281e-02f, 1.18686482e-02f, -1.48842126e-01f, -7.56141916e-02f,
  -1.12183681e-02f, -3.36956531e-02f, -1.32203922e-01f, -1.50529772e-01f, -5.09249568e-02f, 6.80497885e-02f, -1.36785477e-01f, -1.55666441e-01f, -5.85437343e-02f, 1.17171228e-01f,
  1.24355191e-02f, -3.87906246e-02f, 2.01878063e-02f, -1.45811871e-01f, -4.55378518e-02f, -9.84738842e-02f, -1.34122580e-01f, -2.25262009e-02f, -7.86703303e-02f, 1.04981564e-01f,
  -9.85856354e-02f, -2.15967938e-01f, -1.20198362e-01f, -5.23042530e-02f, 4.85248677e-02f, -8.99760798e-02f, -1.08980916e-01f, -1.23301342e-01f, 4.53871302e-02f, -3.44906636e-02f,
  4.23905253e-02f, -1.11803189e-01f, 7.05400556e-02f, -2.40800045e-02f, -1.32102937e-01f, -6.98269084e-02f, -1.78108424e-01f, -2.00370237e-01f, -1.38634562e-01f, -1.14615150e-01f,
  -4.68637273e-02f, -2.31058195e-01f, -2.98486888e-01f, -1.23543501e-01f, -8.98262337e-02f, -1.63390279e-01f, -6.93544671e-02f, -3.55905131e-03f, -1.56522974e-01f, -2.75210917e-01f,
  -7.51816869e-01f, 3.47385108e-02f, -8.34340155e-02f, -2.07973793e-01f, 1.78697303e-01f, 2.58711785e-01f, 3.60659659e-01f, 4.00733538e-02f, -1.49251550e-01f, 6.63998276e-02f,
  1.37262493e-01f, -9.16021541e-02f, -2.76093781e-02f, 9.07561108e-02f, 2.58186311e-02f, 3.63284200e-01f, 2.94497848e-01f, -7.18206093e-02f, -9.58924964e-02f, 2.59393845e-02f,
  2.02391237e-01f, -2.41419151e-01f, -4.17379886e-01f, -1.43241763e-01f, 5.55684138e-03f, -9.84533690e-03f, -4.41913791e-02f, -4.66676541e-02f, 1.71095446e-01f, 2.75174141e-01f,
  -7.20596984e-02f, -4.04661208e-01f, 5.09208664e-02f, 4.24764073e-03f, -5.94626367e-02f, -1.45438895e-01f, -9.13404524e-02f, -1.19779378e-01f, -4.90122698e-02f, -9.66033861e-02f,
  -4.01543975e-02f, -3.16188969e-02f, 3.86436358e-02f, -3.77738476e-03f, -1.45766944e-01f, -2.86403187e-02f, -2.26657130e-02f, -2.07597300e-01f, -1.07859246e-01f, 1.43961743e-01f,
  3.75317723e-01f, 4.78858911e-02f, -1.00604594e-01f, 9.86428261e-02f, 4.97996584e-02f, -1.10440783e-01f, -7.55210668e-02f, -1.89146437e-02f, -7.29202479e-02f, -2.01351985e-01f,
  8.73623881e-03f, 1.49351405e-02f, 1.18086338e-02f, -4.20450866e-02f, -2.21989397e-02f, 1.77747309e-02f, 3.91002595e-02f, 9.49904919e-02f, 7.15317130e-02f, -1.09709263e-01f,
  -4.64430312e-03f, 5.94392186e-03f, 4.30856980e-02f, -2.97959838e-02f, 1.62599787e-01f, -1.30975563e-02f, 1.43877760e-01f, -4.95302044e-02f, -3.69439125e-02f, 3.16056050e-02f,
  -7.34040514e-02f, 1.42500950e-02f, -1.54717192e-01f, -4.05090228e-02f, 5.27234077e-02f, 5.20161502e-02f, -7.32414424e-02f, -5.43952435e-02f, -1.21611886e-01f, -7.15096444e-02f,
  -1.16671503e-01f, -2.07295176e-02f, -1.03520729e-01f, -2.30073053e-02f, -8.34018737e-02f, -1.34890541e-01f, -3.81401158e-03f, 4.93473783e-02f, -5.88473789e-02f, -1.46723352e-02f,
  -8.62879083e-02f, -1.93070978e-01f, -1.24308899e-01f, 3.98340821e-02f, 3.69793624e-02f, 1.30058289e-01f, 8.47811922e-02f, 3.03751566e-02f, 1.84556708e-01f, 5.34513406e-02f,
  9.97846797e-02f, 6.63381740e-02f, -1.95332393e-01f, -9.95950624e-02f, -3.26793082e-02f, -1.80927858e-01f, -1.52498886e-01f, -1.81996599e-02f, -2.44921707e-02f, -1.40487298e-01f,
  -8.24599788e-02f, -3.23755950e-01f, 3.08074832e-01f, 1.61060378e-01f, -1.25599876e-01f, -4.29949999e-01f, -5.86670339e-01f, -3.56472820e-01f, -1.53555302e-02f, -2.70017147e-01f,
  -2.99435645e-01f, -2.53160391e-02f, 2.77636647e-02f, -6.71072677e-02f, -1.38317809e-01f, -1.78517967e-01f, 1.34964600e-01f, 3.37061465e-01f, 1.21651173e-01f, -1.52923912e-01f,
  5.93619887e-03f, 1.32484347e-01f, 1.95938975e-01f, 2.08449662e-02f, 1.39329419e-01f, -2.10489109e-02f, 1.80355310e-01f, 2.38005474e-01f, 8.32658261e-02f, 2.95607686e-01f,
  2.32116818e-01f, 1.36123598e-02f, -1.03332009e-02f, -2.59743202e-02f, 3.85469384e-02f, 5.69540188e-02f, -2.96799913e-02f, 1.61671564e-01f, -6.55937344e-02f, 1.05640203e-01f,
  -3.95631790e-02f, -1.88137606e-01f, -1.15826219e-01f, -3.01454086e-02f, -6.50217757e-02f, -1.64725289e-01f, 1.55447006e-01f, 1.32677361e-01f, 9.09252688e-02f, 1.03589945e-01f,
  -2.14055449e-01f, 7.84041360e-02f, -8.33410397e-02f, -4.23387215e-02f, 5.85417636e-02f, 1.23420306e-01f, -1.74039185e-01f, -7.26975733e-03f, -1.13816507e-01f, -1.47138804e-01f,
  5.84443994e-02f, 2.91311219e-02f, 7.09019378e-02f, -5.09414189e-02f, -7.02233687e-02f, 8.64591151e-02f, 1.69699043e-01f, -8.64619166e-02f, -7.35266134e-02f, 1.58180557e-02f,
  -5.49946576e-02f, 1.62763536e-01f, -5.75050861e-02f, 1.19789571e-01f, 5.48802018e-02f, 6.76887035e-02f, 1.50440645e-03f, 8.14503878e-02f, 1.81089759e-01f, 1.63153338e-03f,
  -3.12096309e-02f, -2.20222268e-02f, 3.69920395e-02f, -3.45705897e-02f, 3.25715914e-02f, 2.16134787e-01f, -2.90116165e-02f, -1.19439051e-01f, 3.96113098e-02f, 4.23003584e-02f,
  -3.16444248e-01f, 7.42656440e-02f, -1.10090606e-01f, 4.24729995e-02f, 3.36435763e-03f, -1.32422959e-02f, -1.28344493e-02f, 1.06607564e-01f, 1.04866751e-01f, -5.43379337e-02f,
  -1.91978350e-01f, -4.29751799e-02f, -2.55233701e-02f, -5.16054407e-02f, -1.86161101e-01f, -1.26454711e-01f, -4.08922359e-02f, -1.97307959e-01f, -1.13665059e-01f, -1.70164943e-01f,
  -2.16753677e-01f, -3.24294508e-01f, -4.06354219e-01f, -2.50716954e-01f, -6.47546351e-02f, -2.43666112e-01f, -2.67556697e-01f, -2.18056187e-01f, -2.73832262e-01f, -3.97246540e-01f,
  9.70226750e-02f, -2.29416430e-01f, -3.45410585e-01f, -2.00027034e-01f, -3.82875025e-01f, -2.91947991e-01f, -2.87082851e-01f, -2.27370650e-01f, -2.74809927e-01f, -4.58999634e-01f,
  -2.07342699e-01f, 1.99872822e-01f, 2.37983182e-01f, 1.18999481e-01f, 2.99758673e-01f, -2.48079583e-01f, -2.92922169e-01f, -6.68239817e-02f, 2.79851496e-01f, -5.05032167e-02f,
  -1.00285009e-01f, 8.70973319e-02f, 1.83873489e-01f, 9.95684266e-02f, -1.37633085e-01f, 6.98462203e-02f, -3.03906232e-01f, -7.22828656e-02f, 5.77016138e-02f, -3.27970386e-01f,
  -1.44892544e-01f, -2.05940232e-01f, -1.12399690e-01f, 4.14783582e-02f, -5.70066348e-02f, -2.27246918e-02f, 5.11307195e-02f, 2.78819762e-02f, -2.89350189e-03f, -1.60579085e-01f,
  -7.56481513e-02f, -2.09313389e-02f, 7.01176375e-02f, -4.43582647e-02f, -7.45831281e-02f, 6.87939627e-03f, -8.21980760e-02f, 5.43993758e-03f, 1.46398367e-02f, 6.58719540e-02f,
  7.05291005e-03f, -4.42533940e-03f, 1.61021709e-01f, 5.33243977e-02f, -3.03310268e-02f, 4.38686498e-02f, 8.80943239e-03f, -4.71541658e-02f, -2.65924609e-03f, -8.91645849e-02f,
  -1.63702160e-01f, 6.00064620e-02f, 1.89598441e-01f, 1.89067125e-01f, 7.17233792e-02f, 8.80446732e-02f, 5.86547554e-02f, 1.73640624e-02f, -1.28421886e-03f, 1.05039500e-01f,
  -4.69964705e-02f, -9.97871682e-02f, -2.13095676e-02f, -1.09192375e-02f, -1.57592651e-02f, -2.79258806e-02f, 3.85269783e-02f, 1.66546911e-01f, 9.59408469e-03f, 4.54452559e-02f,
  1.06854634e-02f, 3.02753653e-02f, -6.56714067e-02f, 1.71452984e-02f, -8.66720639e-03f, 5.18293828e-02f, -9.61491540e-02f, 7.30096847e-02f, -7.49832094e-02f, -4.87738177e-02f,
  1.52081415e-01f, -5.95758520e-02f, -1.32172853e-01f, 7.16581047e-02f, -3.28048654e-02f, -5.55162318e-02f, 1.69686712e-02f, 9.63058099e-02f, 6.12692982e-02f, -1.52663477e-02f,
  3.32194269e-02f, 7.73516148e-02f, -8.51240605e-02f, 2.50046887e-02f, -5.58068119e-02f, 4.08777371e-02f, -4.36049141e-02f, 9.24689546e-02f, 9.08296332e-02f, -4.07888405e-02f,
  3.37290950e-02f, 1.80239752e-01f, 1.28345475e-01f, 6.41746912e-03f, 3.23937051e-02f, 6.78147450e-02f, 1.75974891e-01f, 1.03789940e-01f, 1.98993802e-01f, 3.99841890e-02f,
  -2.28042245e-01f, 3.15886550e-02f, 4.28552836e-01f, -2.13597283e-01f, -1.94356874e-01f, 9.78458449e-02f, 4.15128678e-01f, 7.66165555e-02f, -3.14421922e-01f, -4.76148687e-02f,
  -2.39337981e-02f, -7.50391334e-02f, -1.06476657e-01f, -6.08142577e-02f, 7.24132806e-02f, 2.87831634e-01f, 4.06523868e-02f, 2.93475091e-01f, 2.01963738e-01f, 1.58071727e-01f,
  -1.50518753e-02f, 7.08200261e-02f, 7.26828724e-02f, -3.36937904e-02f, 1.04495235e-01f, 1.00608850e-02f, 2.60909684e-02f, 3.28042470e-02f, -1.08629882e-01f, 1.84700102e-01f,
  6.02166235e-01f, -1.97360039e-01f, -9.11255255e-02f, -3.98024350e-01f, -3.44723389e-02f, -9.43030715e-02f, 1.05605692e-01f, 3.66424844e-02f, -1.57214150e-01f, 7.24102706e-02f,
  -1.16396725e-01f, -7.72454515e-02f, 5.36347590e-02f, 5.74447438e-02f, 8.20977762e-02f, 3.09660397e-02f, -3.81411538e-02f, 5.74655756e-02f, -1.17019445e-01f, -5.44858016e-02f,
  -2.30524857e-02f, -6.60254434e-02f, 6.87435865e-02f, 3.94652747e-02f, 2.46566609e-02f, -1.52649164e-01f, 5.86443022e-02f, -1.73491612e-01f, -6.14062510e-02f, 1.11373499e-01f,
  -8.04605186e-02f, 5.70338443e-02f, -5.35704754e-03f, 6.76933005e-02f, 1.10791162e-01f, -1.34903258e-02f, 1.85673863e-01f, 1.35570258e-01f, 1.96171165e-01f, 1.06853560e-01f,
  8.27834234e-02f, 9.29324776e-02f, 2.09000945e-01f, 8.08907226e-02f, -4.11880203e-02f, 1.45288082e-02f, 8.06025118e-02f, 6.62464276e-02f, -1.04077488e-01f, -6.10840283e-02f,
  6.66030869e-02f, 3.83277312e-02f, -9.79532227e-02f, 1.79264411e-01f, -8.00562873e-02f, -4.48771566e-02f, 1.80009082e-02f, -4.65161167e-02f, -2.84058768e-02f, -1.70681611e-01f,
  2.71412730e-01f, -4.21444803e-01f, 1.88897565e-01f, -9.94303748e-02f, -9.07482654e-02f, -2.78963268e-01f, 9.97719020e-02f, -1.69625089e-01f, -6.89915046e-02f, 6.84259683e-02f,
  -7.30050653e-02f, -1.23919673e-01f, 1.11369200e-01f, 1.70322523e-01f, 1.48873240e-01f, -7.87295494e-03f, -2.69224048e-01f, 1.08168470e-02f, -5.18769324e-02f, 9.91055891e-02f,
  4.63763578e-03f, -3.71827595e-02f, 1.64275914e-01f, 1.24587238e-01f, -9.08868108e-03f, 6.99713826e-02f, 2.77650267e-01f, 4.38385084e-02f, -3.95117514e-03f, 1.28144071e-01f,
  -1.55238569e-01f, 3.04052792e-02f, 4.17451799e-01f, 9.74364113e-03f, -2.04903737e-01f, -4.19567823e-01f, -4.93923277e-01f, -4.34951305e-01f, -1.40208706e-01f, -9.30050835e-02f,
  -2.06282154e-01f, 3.59863676e-02f, 2.40277573e-02f, 1.12002753e-01f, -1.62638739e-01f, -1.48345195e-02f, 2.80409515e-01f, 3.25318038e-01f, 4.78456430e-02f, -2.28743449e-01f,
  -4.66567874e-02f, 1.71886638e-01f, 1.39197558e-01f, -3.69745716e-02f, 1.55262917e-01f, 2.07095984e-02f, 2.30541334e-01f, 5.11421598e-02f, 4.26688902e-02f, 5.76604664e-01f,
  3.87578875e-01f, -1.59631342e-01f, 6.06628060e-02f, -2.86443951e-03f, 5.94166219e-02f, 4.90120575e-02f, 3.04718353e-02f, 2.80827910e-01f, 3.45299649e-03f, -5.54476269e-02f,
  1.43359289e-01f, -2.05097552e-02f, -1.44991940e-02f, 6.89103007e-02f, -1.16674416e-01f, -1.04590088e-01f, 7.29909688e-02f, 3.13447565e-02f, 9.93631557e-02f, -6.80990564e-03f,
  6.50614826e-03f, -1.35500699e-01f, -8.87246653e-02f, -2.57330686e-01f, -1.00703031e-01f, 6.26667216e-02f, -2.05864057e-01f, -5.22683561e-03f, -8.12356248e-02f, 3.73369120e-02f,
  -1.91724584e-01f, -1.23001203e-01f, -9.43952240e-03f, -1.36886254e-01f, -1.04844280e-01f, -1.73343360e-01f, -1.28104135e-01f, -3.92665081e-02f, -1.01922877e-01f, -9.28481370e-02f,
  -1.26242816e-01f, -6.35064393e-02f, -6.16634451e-02f, 2.61479914e-02f, 1.98190007e-02f, 9.92020220e-02f, -1.05633236e-01f, -3.94314118e-02f, -1.12037122e-01f, 3.15804407e-02f,
  -1.78445429e-02f, -9.72765088e-02f, 7.24327266e-02f, 5.89239271e-03f, -8.20075870e-02f, -5.76908365e-02f, -1.22388825e-01f, -5.18467762e-02f, 2.13665725e-03f, 2.51755547e-02f,
  -1.98676959e-01f, -1.02050684e-01f, 5.69751970e-02f, 1.99778259e-01f, 4.03978936e-02f, 1.13530792e-01f, 1.65193826e-02f, 3.53475399e-02f, 1.08877286e-01f, 1.36778355e-02f,
  -7.11537823e-02f, 9.94536877e-02f, 9.49830487e-02f, 1.07676059e-01f, 1.91691853e-02f, 7.23497570e-02f, -1.52885213e-01f, 5.84388971e-02f, 3.25412070e-03f, 4.40938734e-02f,
  7.04306737e-02f, -2.19852105e-01f, -3.08120459e-01f, -1.63237691e-01f, -1.08248048e-01f, -1.73310898e-02f, -5.98200224e-02f, 2.72118039e-02f, -1.07919395e-01f, -2.79033810e-01f,
  1.51311487e-01f, -8.49704370e-02f, -3.40388387e-01f, 1.66646972e-01f, 4.51852083e-02f, -1.01938143e-01f, -2.70929128e-01f, -1.38116866e-01f, 1.67184740e-01f, -1.39896944e-01f,
  -6.64291754e-02f, 1.91079035e-01f, 1.93683475e-01f, -1.29885137e-01f, -3.58171314e-01f, -3.78805131e-01f, -3.15295041e-01f, -2.63956726e-01f, -5.94251864e-02f, -2.02777162e-01f,
  1.87741697e-01f, 2.51813680e-01f, 1.80546075e-01f, 2.65643559e-03f, 9.99839157e-02f, 1.00411214e-01f, 4.14451100e-02f, 5.05398214e-02f, 3.66008133e-02f, 4.51338440e-02f,
  6.20078407e-02f, -3.63320857e-01f, -3.05284597e-02f, 3.54557373e-02f, -1.07656792e-02f, 8.07139277e-02f, -5.33764735e-02f, -1.50480598e-01f, -4.43184227e-02f, -1.21039398e-01f,
  -3.05443350e-02f, -3.65805998e-02f, -1.87567957e-02f, 1.59884423e-01f, 4.97458763e-02f, -5.40744476e-02f, -9.22537744e-02f, -1.87279999e-01f, -2.50292689e-01f, -1.48570389e-01f,
  1.22810572e-01f, -7.14893034e-03f, -2.83326477e-01f, -2.56456733e-01f, -3.37166756e-01f, 7.44812191e-03f, -1.19298756e-01f, -2.80901551e-01f, -1.80858359e-01f, 2.96959504e-02f,
  -3.23324129e-02f, -1.36067063e-01f, -1.58291496e-02f, 2.49730609e-02f, 4.25186083e-02f, 4.79674637e-02f, 4.48350385e-02f, 6.35776296e-02f, 8.45401920e-03f, 4.89425696e-02f,
  -9.82724056e-02f, -5.88741116e-02f, 1.44053018e-02f, -1.27203241e-01f, 6.23855181e-02f, 8.32215250e-02f, 3.30978222e-02f, -8.74448195e-02f, -6.52603135e-02f, -1.15753049e-02f,
  5.48976399e-02f, 3.53396088e-02f, 8.85073170e-02f, 1.33538604e-01f, -2.20359698e-01f, -9.98871773e-02f, -6.19445415e-03f, -1.76267967e-01f, 5.72512224e-02f, 5.21567911e-02f,
  3.55622470e-01f, -2.11681306e-01f, -4.32982221e-02f, -1.26097307e-01f, 4.38346267e-02f, -5.41214459e-03f, 5.85469902e-02f, -9.90870595e-02f, 1.25139818e-01f, 6.19163327e-02f,
  -9.02437046e-02f, -8.78942385e-03f, 1.46918431e-01f, 1.58329397e-01f, 1.90787427e-02f, -1.86171792e-02f, 6.74038334e-03f, -5.66083333e-03f, -5.99760748e-02f, 1.10278241e-02f,
  8.64204392e-02f, -5.48815392e-02f, -3.09721734e-02f, -4.15487662e-02f, -8.57198909e-02f, -2.34720632e-02f, 9.10458937e-02f, 7.92589858e-02f, -1.25096187e-01f, 1.23256661e-01f,
  6.84950829e-01f, -4.00867224e-01f, 1.55066758e-01f, 3.45871717e-01f, 9.97897089e-02f, 7.62310773e-02f, -1.09459534e-01f, 6.97955163e-03f, 1.40148282e-01f, -8.13874602e-02f,
  6.67965859e-02f, 1.84399515e-01f, 2.23905236e-01f, 1.77322596e-01f, 3.35637107e-02f, -4.71723713e-02f, -6.41812906e-02f, 2.54485816e-01f, 2.81765997e-01f, 6.95174411e-02f,
  -1.01078779e-01f, -1.58406451e-01f, 4.19183485e-02f, -6.02587983e-02f, -2.66786963e-01f, 1.90485105e-01f, 8.89897645e-02f, 3.09074447e-02f, -6.01947121e-02f, -9.61337984e-02f,
  -2.91203763e-02f, 8.99977144e-03f, 1.15034796e-01f, 9.33151133e-03f, -4.92236950e-02f, 8.09202641e-02f, 4.36995476e-02f, -6.62224367e-02f, -6.89760894e-02f, -7.26003498e-02f,
  1.04046213e-02f, -1.43248364e-01f, 1.90755632e-02f, -1.41725749e-01f, -2.22095653e-01f, -2.08422113e-02f, -2.06154287e-01f, -5.00753857e-02f, -6.56922236e-02f, -3.28252204e-02f,
  -1.14130609e-01f, 6.84410781e-02f, 6.14782013e-02f, -2.11121459e-02f, 1.10257464e-02f, 2.31191397e-01f, 1.66415866e-03f, 1.62885021e-02f, 1.27985720e-02f, -1.23019993e-01f,
  1.21101499e-01f, -1.51781082e-01f, 1.48992275e-03f, 1.54278148e-02f, 3.49681377e-02f, 1.21628538e-01f, 5.01847230e-02f, -2.35687289e-02f, 8.94771218e-02f, -8.78050923e-02f,
  -1.79691184e-02f, 1.10946737e-01f, 1.17317690e-02f, 9.66636240e-02f, -3.50496769e-02f, -3.81717645e-02f, 9.25023705e-02f, -2.37155631e-02f, 6.96500167e-02f, -2.83267908e-02f,
  -2.71910802e-02f, 8.70998725e-02f, -5.32983057e-03f, -8.00950676e-02f, 5.64728007e-02f, -8.90238583e-02f, 1.39350919e-02f, -4.20158133e-02f, -1.43109426e-01f, -3.08451708e-02f,
  3.93702760e-02f, 3.44428182e-01f, 1.50962085e-01f, 1.91087089e-02f, 5.24186678e-02f, 1.11092709e-03f, 2.19263211e-01f, -5.61706536e-02f, 6.91657607e-03f, 1.71242282e-02f,
  -4.11533862e-02f, 8.57873634e-02f, 2.75721736e-02f, -2.06786856e-01f, 3.50505225e-02f, 1.26747414e-01f, -8.38340893e-02f, 5.28781563e-02f, 3.96952704e-02f, -1.92248061e-01f,
  -1.79037318e-01f, 8.15429166e-02f, 2.60320902e-01f, 1.86272785e-01f, 6.92926869e-02f, 2.92593390e-01f, 1.91622097e-02f, -6.70279711e-02f, 1.98480234e-01f, 6.73346519e-02f,
  -3.72301221e-01f, -1.69366345e-01f, -1.19898446e-01f, -4.44172174e-01f, -8.21885541e-02f, 1.06447838e-01f, 1.53198659e-01f, -2.16115490e-02f, -1.58882454e-01f, -5.51397540e-02f,
  1.12047918e-01f, 6.96914122e-02f, -1.16503267e-02f, 9.34958458e-02f, 1.51022658e-01f, -1.10394940e-01f, -1.73061654e-01f, -1.22113012e-01f, 1.99741587e-01f, 3.51497650e-01f,
  1.44666240e-01f, -1.12846777e-01f, -4.56430689e-02f, 4.06608954e-02f, -3.00631225e-01f, -1.74190644e-02f, -1.42639130e-01f, -2.58060157e-01f, -1.72348414e-02f, -2.81794429e-01f,
  -1.04354732e-01f, 5.13930693e-02f, 1.24997050e-01f, 3.36420722e-02f, 1.29601778e-02f, 1.80281885e-02f, 1.01012036e-01f, -2.08101615e-01f, 5.61212283e-03f, 1.30381705e-02f,
  -4.59536677e-03f, 1.03382625e-01f, -2.12285832e-01f, 8.85340348e-02f, -7.65691325e-02f, 2.00096473e-01f, -6.97369277e-02f, -2.29914729e-02f, -4.50570732e-02f, 8.99915770e-02f,
  -1.19170383e-01f, -3.76458019e-02f, -3.51377428e-02f, 1.79862287e-02f, 5.59465475e-02f, -1.50761560e-01f, 5.37000410e-02f, 1.79965973e-01f, 1.64787933e-01f, -1.30172968e-01f,
  6.63394034e-02f, 2.15535313e-02f, 1.49160713e-01f, -1.11833196e-02f, 3.73673625e-02f, 1.11740474e-02f, -9.94178355e-02f, 6.18135706e-02f, 5.75910062e-02f, -1.42800003e-01f,
  -3.02100107e-02f, 1.04615651e-01f, 8.36843178e-02f, -8.73436853e-02f, 5.17650694e-02f, -8.72403011e-02f, -4.10576165e-02f, -6.82006255e-02f, -9.21671987e-02f, 4.70806882e-02f,
  1.97438970e-02f, -6.39630482e-02f, 3.91959399e-03f, 8.56597275e-02f, 7.12992325e-02f, -1.41401952e-02f, 1.25410231e-02f, 1.00283071e-01f, -1.74643267e-02f, 1.72404610e-02f,
  -2.40924746e-01f, 1.29853547e-01f, -2.48337418e-01f, 1.12951897e-01f, 5.43618351e-02f, 1.55435549e-02f, -1.55924037e-01f, 1.66078433e-02f, -1.14217788e-01f, 4.81362417e-02f,
  1.58093095e-01f, -7.17187598e-02f, -1.67892814e-01f, 8.72034952e-02f, 6.16486110e-02f, 1.33731052e-01f, 1.56434570e-02f, 5.54968324e-03f, 6.64259568e-02f, -3.35123539e-02f,
  2.99534369e-02f, 3.20617706e-02f, -1.50243968e-01f, 2.43891664e-02f, -9.27445590e-02f, -6.99712336e-02f, -9.91996303e-02f, -1.00061573e-01f, -7.23383063e-03f, -1.97806388e-01f,
  -1.96997106e-01f, -5.86607575e-01f, 4.55984026e-01f, -7.50758350e-02f, 4.83765393e-01f, 3.91745597e-01f, 2.83400565e-01f, 3.14169899e-02f, -8.37333500e-02f, -9.32600200e-02f,
  -3.44638467e-01f, -4.23589975e-01f, -3.57886702e-01f, -1.66709155e-01f, -1.93933770e-01f, 2.56155171e-02f, 2.00506091e-01f, 1.95545614e-01f, 4.49038625e-01f, 2.70043135e-01f,
  -5.60997911e-02f, -7.77481273e-02f, -2.42133215e-01f, -4.15750444e-02f, -1.73949555e-01f, 3.40280607e-02f, -1.52227983e-01f, -1.24946937e-01f, -5.52309211e-04f, -1.81121632e-01f,
  1.14567019e-01f, -2.13653758e-01f, 9.74525884e-02f, -3.87763903e-02f, -5.38939610e-02f, -1.71253443e-01f, 3.71945836e-02f, -7.69160613e-02f, -9.67690945e-02f, 8.95884037e-02f,
  -5.59461452e-02f, -6.90439669e-03f, 1.78127717e-02f, -1.40543520e-01f, 5.89026250e-02f, -2.55810991e-02f, -1.04699939e-01f, -1.68969765e-01f, -1.80864558e-01f, -2.42226310e-02f,
  -2.27421209e-01f, 1.35468826e-01f, 8.13179016e-02f, -5.76983169e-02f, -9.13823023e-02f, 1.22192964e-01f, -1.07190534e-01f, -5.57579026e-02f, 7.92163517e-03f, 7.41535448e-04f,
  2.90292371e-02f, -2.44579613e-02f, -1.16724290e-01f, 7.95241669e-02f, -6.67437585e-03f, -1.61856215e-03f, 1.65851638e-02f, -2.31968146e-02f, 1.70307998e-02f, 1.85077321e-02f,
  -7.07388893e-02f, -4.07969533e-03f, -6.94828853e-02f, -7.81646520e-02f, -1.16784880e-02f, -5.98880015e-02f, 2.99401935e-02f, -9.16548744e-02f, -1.97298196e-03f, -3.33128721e-02f,
  -1.05273470e-01f, -1.29229929e-02f, -5.02710082e-02f, 1.39589598e-02f, -3.61351320e-03f, 8.60635377e-03f, 6.36755005e-02f, -7.97771066e-02f, -9.01926681e-03f, -1.96615718e-02f,
  -1.21328667e-01f, -1.43708482e-01f, 7.00906441e-02f, -7.57842287e-02f, 6.34367019e-02f, -8.30753446e-02f, -2.18867958e-01f, -3.55299860e-02f, 1.29050948e-02f, 1.02586403e-01f,
  -7.89296404e-02f, 1.46299228e-02f, -3.21322344e-02f, -1.52582258e-01f, 1.41729727e-01f, 1.11412942e-01f, -1.76657334e-01f, -1.45344278e-02f, -4.89437059e-02f, -2.89674243e-03f,
  -3.72324996e-02f, 1.24184981e-01f, 2.46397257e-01f, 8.12610015e-02f, 1.04240738e-01f, 2.48957410e-01f, 9.92527381e-02f, 1.31493166e-01f, 1.97687641e-01f, 2.28918895e-01f,
  -2.48160928e-01f, -9.20531452e-02f, -2.76581168e-01f, 7.91090801e-02f, -1.09342802e-02f, -1.20582603e-01f, -2.03691706e-01f, 1.19221278e-01f, 2.28150934e-01f, -2.39767760e-01f,
  -1.69114128e-01f, -1.30482659e-01f, -8.87682289e-02f, -2.40219772e-01f, -4.31989104e-01f, -2.71524638e-01f, -2.08615854e-01f, -3.41996074e-01f, -2.96844453e-01f, 2.42787250e-03f,
  -9.59626585e-02f, -1.22452259e-01f, -2.03628063e-01f, 3.33004311e-04f, 2.15259969e-01f, 4.15070727e-03f, -2.79767346e-02f, -1.09461891e-02f, 5.17880097e-02f, -1.74526945e-01f,
  -2.58730233e-01f, 1.01021700e-01f, 2.46039126e-02f, -1.66973814e-01f, -1.15335956e-01f, 1.00069746e-01f, -7.41327927e-02f, -1.78741410e-01f, -7.46630132e-02f, -8.54264349e-02f,
  3.71548869e-02f, 1.18613601e-01f, -9.47565492e-03f, -3.73313166e-02f, -1.53321058e-01f, -7.36471191e-02f, -6.84228390e-02f, -1.34159103e-01f, -9.20248181e-02f, 1.19172715e-01f,
  1.90053787e-02f, -9.65220556e-02f, -9.13738310e-02f, 1.87156618e-01f, 1.67131975e-01f, 5.30213602e-02f, 1.94950998e-01f, 2.84973353e-01f, 5.30293472e-02f, -1.21320682e-02f,
  -9.65187419e-03f, -9.17656794e-02f, -2.03078035e-02f, 7.66391009e-02f, -5.51460870e-02f, 8.12306553e-02f, 1.24182459e-02f, -1.73989654e-01f, 1.74010135e-02f, -2.99740471e-02f,
  5.21430150e-02f, 2.59563681e-02f, -9.07088593e-02f, -4.15788181e-02f, 9.71476641e-03f, 1.19491722e-02f, -1.21230349e-01f, -1.43822670e-01f, 3.80327776e-02f, -1.64024159e-02f,
  -3.17157246e-02f, 7.12243393e-02f, -1.80062074e-02f, -5.29336296e-02f, -3.00580710e-02f, -1.93455622e-01f, 1.15833646e-02f, 9.30337422e-03f, -4.49467599e-02f, -1.12052470e-01f,
  -3.60788628e-02f, -1.63294569e-01f, -1.55019730e-01f, 5.71474098e-02f, 7.67083615e-02f, -2.45186849e-03f, 6.90431669e-02f, -8.65021572e-02f, -2.38541067e-02f, 8.69670976e-03f,
  -1.08852033e-02f, 5.82907833e-02f, 1.19540868e-02f, 1.02249570e-01f, -8.61894339e-03f, 6.96572885e-02f, 6.40731677e-02f, -1.58371925e-01f, -8.52123275e-02f, 2.41713330e-01f,
  2.22788136e-02f, -1.33206621e-01f, -1.92743182e-01f, -1.59525629e-02f, 3.65178809e-02f, -1.57599851e-01f, -4.01363010e-04f, 8.29757378e-02f, -7.73277953e-02f, -1.35925695e-01f,
  3.73436958e-01f, 1.79593101e-01f, -2.41327092e-01f, 3.56638640e-01f, 1.54660627e-01f, -1.18741520e-01f, -5.48615903e-02f, -9.33355838e-02f, 1.50329471e-01f, 1.34404749e-01f,
  1.45353094e-01f, -1.04871057e-01f, -1.09305754e-01f, -1.91306591e-01f, -4.65851307e-01f, -1.72936976e-01f, -1.12801202e-01f, -3.65649462e-01f, -5.84964037e-01f, -2.76748210e-01f,
  -1.68275028e-01f, 1.13642868e-02f, -6.43761680e-02f, -2.43513465e-01f, 3.19328040e-01f, 7.87294134e-02f, 2.19819680e-01f, 2.19743088e-01f, -7.79112941e-03f, 3.23050857e-01f,
  7.87506849e-02f, 2.28637561e-01f, -2.14880750e-01f, -3.90682891e-02f, 1.97047293e-02f, 4.12998945e-02f, -1.02999948e-01f, -2.74145999e-03f, 2.00421363e-02f, -5.56428693e-02f,
  5.29541522e-02f, -1.12563752e-01f, -3.28886583e-02f, 8.10392760e-03f, -5.00218607e-02f, -3.80573794e-02f, 4.75977212e-02f, -1.31072357e-01f, -2.06694186e-01f, -6.49645403e-02f,
  4.53797169e-02f, 2.09540538e-02f, -3.58785912e-02f, -3.05929761e-02f, -1.57008901e-01f, -4.90125678e-02f, 2.50519402e-02f, -9.27553326e-02f, -1.02211833e-01f, 3.43384683e-01f,
  1.14334924e-02f, 5.41047864e-02f, 2.74696480e-02f, 7.50421137e-02f, 2.33839713e-02f, 7.33066276e-02f, -6.43643364e-02f, 7.62637705e-02f, -5.11821769e-02f, 7.38146678e-02f,
  -4.16131951e-02f, 4.14788984e-02f, 4.50097062e-02f, 2.07611583e-02f, 2.12551374e-02f, 1.50923459e-02f, 4.36747782e-02f, -1.37481038e-02f, -1.62762567e-01f, -4.27790591e-03f,
  -8.47251862e-02f, -6.88466355e-02f, 2.88158786e-02f, -4.27782126e-02f, 6.67021647e-02f, -4.29658927e-02f, 2.61379480e-02f, -5.35885729e-02f, -4.76732589e-02f, 5.72791509e-03f,
  5.37451841e-02f, -2.79453039e-01f, 2.43561864e-01f, -1.52835295e-01f, -6.22131862e-02f, -5.12871295e-02f, 1.73035935e-01f, 8.66868254e-03f, 1.41963493e-02f, 3.55823487e-02f,
  -7.86093995e-02f, 6.28202558e-02f, 5.21356128e-02f, -1.46251336e-01f, -2.81044897e-02f, 1.55087365e-02f, -1.35022765e-02f, -5.43299168e-02f, -1.26190186e-01f, 6.75230697e-02f,
  -1.26161249e-02f, 5.96990734e-02f, 2.75578555e-02f, 1.99265592e-02f, 6.52224198e-02f, 2.24333648e-02f, 5.01969680e-02f, -1.21814743e-01f, -2.27169812e-01f, 1.56016171e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  9.32949036e-02f, -1.41759831e-02f, 1.93600118e-01f, 1.73953682e-01f, 1.99809715e-01f, 2.10870698e-01f, 1.54554054e-01f, 4.61550169e-02f, 4.65002030e-01f, 6.26382381e-02f,
  -1.60216577e-02f, 1.20044403e-01f, -6.68065110e-03f, 1.36552542e-01f, 2.00335339e-01f, -1.11857317e-01f, 1.99716210e-01f, 1.24250546e-01f, -1.32839940e-03f, 2.52180934e-01f,
  2.45445192e-01f, 4.14092429e-02f, -6.00362308e-02f, 2.57212520e-01f, -7.94590935e-02f, 1.61917672e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -8.27125646e-03f, -4.26028930e-02f, -1.35807380e-01f, -6.12602085e-02f, 2.87920167e-03f, -5.93131721e-01f, 1.09241694e-01f, 8.37073177e-02f, 8.93217549e-02f, -1.09748743e-01f,
  2.12073371e-01f, -3.62753682e-02f, 2.86641061e-01f, -1.58160925e-01f, -1.72093779e-01f, 1.46617278e-01f, -1.39834046e-01f, 4.34444211e-02f, 2.70491749e-01f, 1.93137825e-01f,
  -1.20867714e-01f, 2.81786531e-01f, 9.39791575e-02f, -1.43917516e-01f, 1.09699100e-01f, -6.59027100e-02f, -1.59375101e-01f, 5.60996979e-02f, 1.36468992e-01f, 2.51475036e-01f,
  -3.21921445e-02f, -2.06610218e-01f, -1.97527669e-02f, -2.12423708e-02f, -7.12745450e-03f, 2.44368181e-01f, -3.70455608e-02f, -1.88951328e-01f, 1.62795603e-01f, 2.09731996e-01f,
  5.36741391e-02f, -8.31075013e-02f, 6.38500378e-02f, 3.87481786e-02f, 1.07761204e-01f, -6.71913400e-02f, -2.11222861e-02f, 2.71265805e-01f, 1.30236775e-01f, -1.39322668e-01f,
  2.53627986e-01f, -2.16323465e-01f, -2.82755774e-02f, 2.92157650e-01f, -1.10837765e-01f, -1.57717802e-02f, -3.85229439e-02f, -6.68602511e-02f, -3.54068689e-02f, -8.68576616e-02f,
  1.09794229e-01f, -1.23216532e-01f, 5.91740869e-02f, 1.70009565e-02f, -2.45600834e-01f, 1.11109495e-01f, 6.26331270e-02f, -2.36946702e-01f, -9.30098444e-02f, -2.12366670e-01f,
  3.67737152e-02f, -1.55148387e-01f, 9.45269018e-02f, -2.22868115e-01f, -2.48286612e-02f, -2.73382843e-01f, -1.38683364e-01f, -2.22274303e-01f, 2.77764142e-01f, -2.82162547e-01f,
  -1.29278274e-02f, -1.16581373e-01f, 1.91682857e-02f, 9.15913135e-02f, 2.14947686e-01f, -4.93796408e-01f, 8.62115771e-02f, 3.13057117e-02f, 4.44992408e-02f, -1.35186061e-01f,
  -1.98732048e-01f, -3.32280338e-01f, -2.00335905e-01f, -2.87602283e-02f, 1.09307751e-01f, 3.29379082e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  4.26704884e-02f, -1.02707148e-01f, -8.47724825e-02f, 2.06890985e-01f, -3.38139415e-01f, 4.94290888e-02f, 1.86119974e-01f, 1.27878428e-01f, -3.43256183e-02f, 1.64258957e-01f,
  -1.22634865e-01f, 6.32970110e-02f, 1.12537324e-01f, 7.87520707e-02f, -5.50484478e-01f, 9.40726027e-02f, 2.12417573e-01f, -4.82254997e-02f, 1.54047251e-01f, 1.68189719e-01f,
  6.53183041e-03f, 2.66727924e-01f, 9.83208567e-02f, -6.63745701e-02f, -3.31764102e-01f, 2.98779719e-02f, 2.43949201e-02f, 3.10274735e-02f, 3.70047867e-01f, -1.27001435e-01f,
  2.57489651e-01f, 3.00498962e-01f, 2.40542635e-01f, 2.33910114e-01f, 3.75553071e-02f, 8.37707743e-02f, -1.15838885e-01f, -5.39554656e-01f, 1.85991913e-01f, -1.04778357e-01f,
  1.13974087e-01f, -5.18111438e-02f, 4.16446894e-01f, 2.03555256e-01f, 2.23862063e-02f, 2.22131878e-01f, 6.71993718e-02f, 2.08031714e-01f, -4.46911193e-02f, -7.39886463e-02f,
  2.83021718e-01f, 2.72712767e-01f, -1.53679609e-01f, 1.70567691e-01f, 1.18043266e-01f, 1.70251936e-01f, 2.26464555e-01f, 8.07485282e-02f, -2.87015021e-01f, 5.26594557e-02f,
  2.15727985e-01f, 1.97440088e-01f, -1.14803135e-01f, -1.87166616e-01f, 1.69557691e-01f, -7.96573535e-02f, 1.63235143e-01f, -4.30156849e-02f, 2.55982149e-02f, -8.44649822e-02f,
  -9.32668522e-02f, 1.99281693e-01f, 2.53548920e-01f, 3.49709302e-01f, -1.18860781e-01f, -6.46476522e-02f, -1.60240099e-01f, -1.96369484e-01f, -6.65087283e-01f, -1.37951523e-01f,
  1.25465348e-01f, 1.24792129e-01f, 5.72484769e-02f, 1.86886191e-01f, -2.08488122e-01f, 2.03238010e-01f, 1.62831590e-01f, 2.44496703e-01f, -5.21396816e-01f, 6.58152252e-02f,
  1.18931442e-01f, 9.59026515e-02f, 8.14944878e-02f, -4.00900375e-03f, 2.89420128e-01f, -3.41516584e-02f, -1.06901415e-01f, 4.93368395e-02f, -1.03147157e-01f, -2.17558648e-02f,
  2.05720127e-01f, 7.19090700e-01f, -2.06160136e-02f, 8.34937096e-02f, -2.99145468e-02f, 2.86032688e-02f, -7.76197910e-02f, -7.41954818e-02f, 9.34836268e-02f, 7.28120878e-02f,
  -6.22178316e-02f, -1.93814766e-02f, 2.03939334e-01f, 1.24369271e-01f, -3.27934623e-01f, 1.18447930e-01f, -6.56778514e-02f, 5.61407395e-02f, -9.49288383e-02f, 1.73641279e-01f,
  1.38184041e-01f, -9.24162567e-02f, 3.83846790e-01f, -1.64161101e-02f, -2.66034715e-02f, -5.29459536e-01f, 4.87399735e-02f, 3.29728544e-01f, 1.89328700e-01f, 5.44186905e-02f,
  1.42231062e-01f, -3.88002284e-02f, -3.03479820e-01f, 5.40251195e-01f, 9.26733688e-02f, 1.55347988e-01f, -1.69095084e-01f, 3.61817688e-01f, -2.09195718e-01f, 7.21878856e-02f,
  -2.05596328e-01f, -2.63274223e-01f, 1.36732280e-01f, 2.01193929e-01f, 3.22867393e-01f, -3.79300416e-02f, 1.90659374e-01f, 8.65369663e-02f, -3.71711284e-01f, 9.92984921e-02f,
  2.72033453e-01f, -2.45133340e-02f, 1.67933837e-01f, 2.21896693e-02f, -9.85507816e-02f, -2.68912073e-02f, 3.88184249e-01f, 7.51735926e-01f, 2.69277155e-01f, -5.51047921e-01f,
  5.26437908e-02f, 4.49853577e-02f, -9.61079169e-03f, 8.67526084e-02f, -5.68543524e-02f, 5.81368566e-01f, -7.30821416e-02f, -1.38090387e-01f, 1.66357458e-01f, 1.17234416e-01f,
  -6.85320199e-02f, -6.72047958e-02f, 3.16832244e-01f, 2.63176840e-02f, -1.17107749e-01f, 1.10332668e-02f, -1.06011838e-01f, 1.24738537e-01f, -2.64447391e-01f, -2.72606373e-01f,
  -7.85372569e-04f, 2.81692762e-02f, -2.20083386e-01f, 3.20666224e-01f, 3.10244143e-01f, -2.18153626e-01f, 2.32537046e-01f, 1.45539820e-01f, 7.23194284e-03f, -1.99410111e-01f,
  1.35659883e-02f, -2.91467041e-01f, 9.24118329e-03f, 6.07256126e-03f, -4.07461226e-02f, -1.29376709e-01f, -3.32653731e-01f, -2.74118990e-01f, -1.65396452e-01f, 1.41418487e-01f,
  -4.17874724e-01f, 2.93309003e-01f, -5.16494691e-01f, -1.73026681e-01f, 9.09428596e-02f, -3.15184593e-01f, -1.68270156e-01f, 6.51961518e-03f, 2.72037685e-01f, -1.13148972e-01f,
  3.39060187e-01f, 2.89773084e-02f, -1.80125564e-01f, 1.23925947e-01f, 2.84252256e-01f, 1.69383839e-03f, -1.30287513e-01f, -5.10485396e-02f, 1.82696469e-02f, -1.77854091e-01f,
  3.95513266e-01f, -3.18863727e-02f, 3.22832316e-01f, -1.46280766e-01f, 3.79252106e-01f, 4.00935560e-01f, 5.38420737e-01f, -2.13227630e-01f, 5.67346141e-02f, -5.20756304e-01f,
  2.31831595e-01f, -1.03309296e-01f, -1.90699920e-02f, 1.11130998e-01f, 1.57397002e-01f, 4.57162768e-01f, -1.16841666e-01f, -7.63727725e-02f, 5.38012981e-01f, 4.77704704e-02f,
  3.00616566e-02f, -3.16120647e-02f, 1.41912431e-01f, 1.07032560e-01f, 2.35597387e-01f, -4.16325144e-02f, 2.56639987e-01f, -4.59555686e-02f, 1.30769804e-01f, 1.53914347e-01f,
  3.84094454e-02f, -1.23176686e-01f, -1.91945001e-01f, 2.71357208e-01f, -1.27069533e-01f, 2.01117713e-02f, 1.02762192e-01f, 1.79773733e-01f, -1.36178687e-01f, -4.93096784e-02f,
  -2.44213834e-01f, 1.00178286e-01f, 8.48489255e-02f, -8.65413100e-02f, 1.56161860e-01f, 9.52331945e-02f, 1.42547190e-01f, -2.12809727e-01f, -1.83737263e-01f, 2.18789384e-01f,
  1.68872252e-02f, 5.26794232e-02f, 4.85408260e-03f, -9.37314630e-02f, 4.99087930e-01f, 2.37986725e-02f, -3.00356776e-01f, 5.11284232e-01f, -2.10966185e-01f, 2.13508174e-01f,
  8.79804045e-02f, -4.36975390e-01f, -4.76133116e-02f, 2.94729501e-01f, 9.90332291e-02f, 1.71965107e-01f, -6.08906709e-02f, -4.33972001e-01f, 4.63767760e-02f, 1.60807788e-01f,
  1.46652281e-01f, -1.50419369e-01f, 3.25109474e-02f, -7.06369996e-01f, -4.28243242e-02f, -1.86896592e-01f, -3.80482197e-01f, -1.31500671e-02f, 1.33908436e-01f, 3.13959688e-01f,
  2.86002338e-01f, -2.08988395e-02f, 1.47164181e-01f, 2.35049516e-01f, 4.65668961e-02f, -5.74603416e-02f, 2.54328489e-01f, -5.93968742e-02f, 7.34618902e-02f, 3.85910779e-01f,
  -1.28152505e-01f, 1.76204126e-02f, 4.80765879e-01f, 3.17665905e-01f, 1.92597941e-01f, -2.35862270e-01f, -8.17343965e-02f, 3.78073514e-01f, -8.61081854e-02f, -3.31628211e-02f,
  1.28271431e-01f, 1.72904450e-02f, 1.31546274e-01f, -2.30607480e-01f, 1.25453368e-01f, 9.17418480e-01f, -3.17711122e-02f, 1.80941224e-02f, 2.57515043e-01f, 8.14817194e-03f,
  -5.53450957e-02f, -1.62883565e-01f, 5.13694175e-02f, 6.70301393e-02f, -2.89706457e-02f, 1.05286509e-01f, 1.20838257e-02f, 3.29646200e-01f, -9.78789181e-02f, 1.56495333e-01f,
  -2.32126247e-02f, -1.94864422e-01f, -3.34797502e-01f, 2.34424755e-01f, 2.52994090e-01f, -2.06219658e-01f, 2.75619686e-01f, 9.90841091e-02f, -1.06662422e-01f, 2.33605653e-01f,
  9.52120200e-02f, -2.87335604e-01f, 1.63106158e-01f, 3.26797098e-01f, 7.91206807e-02f, 4.03806679e-02f, -1.17012940e-01f, 5.42997181e-01f, 2.26388723e-01f, 1.22698113e-01f,
  3.19473803e-01f, 2.00008452e-01f, -9.10793394e-02f, 1.32437721e-01f, 2.29529545e-01f, 5.67320324e-02f, -2.17964530e-01f, -1.05909862e-01f, 2.40754522e-02f, 3.02428037e-01f,
  -3.25493336e-01f, 1.00504830e-01f, -2.20665723e-01f, -1.77376345e-01f, -1.63755164e-01f, 8.27533081e-02f, -1.24627583e-01f, -2.03574821e-01f, 2.21385330e-01f, 2.75657445e-01f,
  7.56310821e-02f, -1.93690643e-01f, 1.49162263e-02f, -3.75866026e-01f, 3.03831846e-01f, -7.80220106e-02f, -1.83609333e-02f, 1.27313333e-02f, 5.40223658e-01f, -5.80302142e-02f,
  2.40711093e-01f, -8.82952362e-02f, 1.83015779e-01f, 7.53879547e-02f, 5.53100705e-02f, 3.11114728e-01f, -2.23280951e-01f, 2.62914505e-02f, 4.16335613e-01f, 4.21248555e-01f,
  2.96864182e-01f, 4.70846415e-01f, 3.05149943e-01f, -1.91124961e-01f, 1.58000454e-01f, 4.65629846e-01f, -1.16942078e-01f, 4.57342761e-03f, -1.93549156e-01f, -1.62685364e-01f,
  3.57127637e-01f, -2.38713980e-01f, -2.32689723e-01f, -2.06686795e-01f, 2.83684582e-01f, 3.44995588e-01f, 8.28517750e-02f, 3.95593457e-02f, 1.31596774e-01f, 7.81483352e-01f,
  -1.23972809e-02f, 1.30169928e-01f, -3.40372361e-02f, -1.40928641e-01f, -2.47177780e-02f, 3.35668892e-01f, -1.22801226e-03f, -1.81273166e-02f, -4.79398787e-01f, 4.63949665e-02f,
  -6.59781814e-01f, 3.77003938e-01f, 3.41511160e-01f, -2.27395594e-01f, 1.94914207e-01f, -2.60132879e-01f, 1.32397134e-02f, -6.47280887e-02f, 4.11102712e-01f, -1.35664865e-01f,
  -2.52628773e-01f, 2.48506412e-01f, 2.38170326e-01f, -1.75421700e-01f, 2.30309904e-01f, -5.26438467e-02f, 3.27227801e-01f, -9.04131157e-04f, 1.63287312e-01f, 1.06475174e-01f,
  2.94923056e-02f, -1.87504068e-01f, -3.19625437e-01f, 5.98680191e-02f, -9.41985324e-02f, 2.36015394e-01f, -3.52976501e-01f, -2.49698758e-01f, -3.73646170e-02f, -3.77597630e-01f,
  2.19725762e-02f, -7.57059976e-02f, 4.76475328e-01f, 5.54400422e-02f, -2.86595166e-01f, -4.58349377e-01f, 2.03670725e-01f, -1.53740123e-01f, 2.68684238e-01f, -5.34736454e-01f,
  2.41691023e-01f, -5.09237289e-01f, 2.69125581e-01f, 1.22848473e-01f, -7.15550780e-01f, 1.72975525e-01f, -3.95539552e-01f, 5.48691511e-01f, -9.86706093e-02f, 8.64472389e-02f,
  2.47693270e-01f, 2.73994088e-01f, 2.32589126e-01f, 2.37878412e-01f, 3.30257565e-01f, -4.85732481e-02f, 2.35444114e-01f, 4.46155444e-02f, -9.90057215e-02f, -4.15256098e-02f,
  3.00736189e-01f, 3.94411564e-01f, 1.62686333e-01f, -3.40699613e-01f, -2.11314291e-01f, -3.03852521e-02f, -4.94871326e-02f, 1.67537943e-01f, -1.55635685e-01f, -2.44285271e-01f,
  1.06366232e-01f, -3.85492682e-01f, 3.18660349e-01f, 8.23414400e-02f, 2.10457653e-01f, 5.49416721e-01f, 9.21696983e-03f, -2.63746113e-01f, -5.47663122e-02f, -2.81385213e-01f,
  -3.09781544e-02f, -4.73252609e-02f, 3.13653052e-01f, 1.35545045e-01f, 5.04278183e-01f, 3.04963917e-01f, 2.53741682e-01f, 3.16587090e-01f, 8.92109498e-02f, -3.43709886e-01f,
  2.05883771e-01f, 1.77904382e-01f, 2.46952638e-01f, 1.60372809e-01f, 7.06370696e-02f, -9.56443511e-03f, -2.54374802e-01f, -2.14632496e-01f, -5.12781180e-02f, 2.36914903e-01f,
  -2.71496028e-01f, -1.78724021e-01f, 3.03452224e-01f, -3.40287209e-01f, 3.35299253e-01f, -1.35892001e-03f, 2.83957750e-01f, 3.43973726e-01f, 2.80598432e-01f, 2.18986884e-01f,
  -1.36707231e-01f, -6.25891387e-02f, 1.44366482e-02f, 9.69756246e-02f, 6.08968250e-02f, 3.23490292e-01f, 2.56483197e-01f, -3.29181910e-01f, -1.31962493e-01f, 3.02055240e-01f,
  -1.27082676e-01f, -1.93132281e-01f, -8.17382187e-02f, 1.80662259e-01f, -1.18928716e-01f, 1.89384580e-01f, 2.77737468e-01f, -2.90300012e-01f, 3.91874135e-01f, 3.03082243e-02f,
  -2.61675268e-01f, 9.67037603e-02f, -2.38263458e-01f, 7.72509426e-02f, -5.30860312e-02f, -3.83645892e-02f, 2.90663660e-01f, 2.91710049e-01f, 3.59804392e-01f, 3.11256856e-01f,
  2.94429325e-02f, -3.17576877e-03f, 1.59418836e-01f, 5.03205657e-01f, -1.83275357e-01f, -3.26997638e-01f, -4.74540032e-02f, 4.07964200e-01f, 2.31869906e-01f, -3.63013387e-01f,
  -8.21974874e-02f, -3.46897662e-01f, 1.13355391e-01f, 2.39493717e-02f, -2.62236178e-01f, -3.82273465e-01f, 1.79556742e-01f, -4.59665686e-01f, -2.78598011e-01f, -8.89123678e-02f,
  4.10657227e-01f, -7.21186101e-02f, 1.41883880e-01f, -6.46657944e-01f, 5.18347323e-02f, -1.59375127e-02f, 3.16925794e-01f, -4.37659621e-01f, 1.95780490e-02f, -2.46414058e-02f,
  1.87003896e-01f, -3.20674386e-03f, 1.92685768e-01f, -3.20719302e-01f, -4.29138482e-01f, -3.75490367e-01f, -2.70635188e-01f, 4.17644829e-01f, 2.28262514e-01f, 3.91184166e-02f,
  -2.22864360e-01f, -2.01610848e-01f, -2.75924236e-01f, -1.54343590e-01f, 1.16062045e-01f, 1.18074290e-01f, -4.27106142e-01f, -1.84030741e-01f, 2.12412789e-01f, -3.22558492e-01f,
  -3.21628489e-02f, 2.52936304e-01f, 3.35893929e-01f, -3.90563220e-01f, -4.69815552e-01f, -1.79778665e-01f, 1.96398437e-01f, 2.21051484e-01f, 6.11596555e-03f, -6.25226438e-01f,
  3.41370106e-02f, -5.88780701e-01f, -5.72582036e-02f, 1.74966723e-01f, -5.46395421e-01f, 1.28712103e-01f, -2.63810396e-01f, -5.56846075e-02f, -1.67221159e-01f, 4.14882839e-01f,
  3.43219548e-01f, 3.80560428e-01f, 2.29130566e-01f, -1.50104687e-02f, 1.26721144e-01f, -4.31912858e-03f, 2.02198640e-01f, -2.78062344e-01f, 7.01945135e-03f, -2.98305098e-02f,
  1.73929632e-01f, -2.60715764e-02f, 3.45995843e-01f, 2.46575683e-01f, -3.43459882e-02f, 1.96219422e-02f, -3.63833070e-01f, 3.71188633e-02f, 1.03823371e-01f, 1.48419151e-02f,
  -1.17251731e-01f, 1.00187138e-01f, 1.17098488e-01f, 2.61607051e-01f, 4.94728416e-01f, 2.23218665e-01f, -9.26435739e-02f, 6.71333075e-02f, -1.60161182e-01f, 3.00329477e-01f,
  -1.70930907e-01f, -2.73912139e-02f, -1.19026020e-01f, 1.12878822e-01f, -1.27077699e-01f, 3.15803587e-01f, -3.41293693e-01f, -4.00563963e-02f, -1.66663751e-01f, 5.89621328e-02f,
  6.50434569e-02f, 3.81374151e-01f, -3.73789966e-01f, 2.96358287e-01f, -2.54699290e-01f, -2.60296673e-01f, -5.03418684e-01f, 1.70128599e-01f, 1.76481813e-01f, 6.07972145e-02f,
  1.83094755e-01f, -2.42637083e-01f, -8.68588760e-02f, 2.08201453e-01f, -3.22024748e-02f, 3.33322078e-01f, -2.17895642e-01f, -1.31513819e-01f, -3.23156710e-03f, 1.74710318e-01f,
  4.67054844e-01f, 8.69245976e-02f, 2.81915516e-01f, -4.73721772e-01f, 1.29355311e-01f, 3.03897168e-02f, 3.77785802e-01f, -2.92710830e-02f, 2.92984754e-01f, -3.00711125e-01f,
  1.54713064e-01f, -8.39005113e-02f, 1.19062392e-02f, -1.44133344e-01f, 2.08539754e-01f, 2.34474033e-01f, -2.85865366e-01f, 1.15895651e-01f, -2.14932054e-01f, 2.17073128e-01f,
  6.51331618e-02f, -2.63148956e-02f, 5.87592572e-02f, -3.32892269e-01f, 2.69810647e-01f, 2.46771201e-02f, 3.59902322e-01f, -1.07517578e-01f, -8.75446126e-02f, 3.86537999e-01f,
  3.01960886e-01f, -1.14745677e-01f, -2.91407377e-01f, -1.96559608e-01f, 2.15010140e-02f, 3.68934512e-01f, 1.70109332e-01f, 1.51142329e-01f, -4.54536900e-02f, -1.15409801e-02f,
  -1.87041461e-01f, 2.21045110e-02f, 2.66352177e-01f, -6.89011887e-02f, 2.60917962e-01f, 1.91543266e-01f, -1.71410978e-01f, -1.80347517e-01f, 4.01380323e-02f, 3.36485207e-01f,
  -2.05100641e-01f, 7.95876011e-02f, -1.13440035e-02f, -7.68136838e-03f, 3.90369564e-01f, 1.30114891e-02f, -1.09635308e-01f, 4.47074205e-01f, -3.01000178e-01f, 2.09233761e-01f,
  1.45225963e-02f, -4.10834938e-01f, -1.78146154e-01f, 2.40435168e-01f, 3.63507271e-01f, 3.44641879e-02f, -6.69509694e-02f, -4.30311650e-01f, -3.60014364e-02f, 3.19950014e-01f,
  5.61743557e-01f, 1.76348791e-01f, 1.92917868e-01f, 3.23991179e-02f, -5.50381057e-02f, 6.70225844e-02f, -1.46013265e-02f, 2.55728573e-01f, -2.71891784e-02f, 4.23031867e-01f,
  1.20059242e-02f, -2.52677739e-01f, -2.53027409e-01f, 1.15846999e-01f, -1.01295792e-01f, 1.44752249e-01f, -1.02918975e-01f, -2.29902223e-01f, 9.49746221e-02f, -7.02240244e-02f,
  3.56788486e-01f, 3.74764919e-01f, 1.08125053e-01f, 1.37806609e-01f, 2.57729501e-01f, -1.32503361e-01f, 1.90257747e-02f, -1.29748553e-01f, 1.35293886e-01f, -1.16123088e-01f,
  1.09909095e-01f, 2.38367885e-01f, 3.44844699e-01f, -9.10838619e-02f, 2.86203682e-01f, -2.22027481e-01f, -2.00746462e-01f, 2.05118984e-01f, -2.54990846e-01f, -5.64721189e-02f,
  -2.11774454e-01f, 1.14490896e-01f, -1.82624489e-01f, 2.41609588e-01f, 5.14676511e-01f, 4.01873976e-01f, 2.04360247e-01f, 4.47254442e-02f, 2.70508468e-01f, -1.17176482e-02f,
  3.71681631e-01f, -1.04969457e-01f, 3.26479748e-02f, 6.75347727e-03f, -1.94876269e-01f, -1.87134668e-01f, 1.03387251e-01f, -3.47226381e-01f, -6.51032478e-03f, -1.00040413e-01f,
  2.67686963e-01f, 6.61342084e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.61443019e-01f, 3.23863685e-01f, 1.33534186e-02f, -1.17730804e-01f, 1.43325463e-01f, 2.32701942e-01f, 8.30746070e-02f, 3.57259721e-01f, 1.39473215e-01f, 1.20461516e-01f,
  3.42924795e-05f, 6.61832467e-02f, 3.38795781e-01f, 2.37044767e-01f, 6.01660162e-02f, 1.99443147e-01f, 3.37413996e-01f, 2.24581271e-01f, 3.51553917e-01f, -7.74398400e-03f,
  2.68192738e-01f, 2.20600739e-01f, 1.48600072e-01f, -4.63098362e-02f, 2.17323422e-01f, 3.23353320e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.56085283e-01f, 1.10516986e-02f, -1.97129205e-01f, 3.94178420e-01f, 1.50093049e-01f, 1.02235213e-01f, 5.63575402e-02f, 1.17724940e-01f, 1.85015619e-01f, -4.47552055e-02f,
  4.75072563e-02f, 2.86420435e-01f, -9.82380062e-02f, -1.45456314e-01f, 7.93383121e-02f, 2.29232162e-01f, 6.73927441e-02f, 1.10688373e-01f, -1.61438480e-01f, -2.03122020e-01f,
  -2.32378654e-02f, -7.18187392e-02f, -1.27899915e-03f, -1.01696849e-02f, -1.45343482e-01f, 2.70727456e-01f, 9.28565562e-02f, 1.74922273e-01f, -1.23857893e-01f, -3.28144780e-03f,
  -1.24198459e-01f, -1.42740548e-01f, -2.89550424e-01f, -2.05771133e-01f, 1.46444410e-01f, 1.32253066e-01f, -1.65445045e-01f, -5.62176630e-02f, -1.24914259e-01f, 2.32669134e-02f,
  -4.95830588e-02f, -1.80709898e-01f, 1.73099339e-01f, -3.70733440e-01f, -6.83921808e-03f, 1.07411079e-01f, 8.88924673e-02f, 1.08040482e-01f, 9.01377499e-02f, -2.22787216e-01f,
  3.08802992e-01f, -1.61200926e-01f, -1.97390944e-01f, 2.41613761e-01f, -5.70687316e-02f, 1.28672468e-02f, 1.62146002e-01f, -1.39145330e-01f, -1.28183484e-01f, -2.36044914e-01f,
  2.69789100e-01f, -1.12927221e-01f, 2.48059854e-02f, -1.62185356e-02f, 1.95187479e-01f, 2.59276301e-01f, 1.50065452e-01f, -1.83742359e-01f, -2.79383212e-01f, -7.55423978e-02f,
  -1.45876989e-01f, -2.68033862e-01f, 1.56039134e-01f, 3.88211533e-02f, -2.87510157e-02f, 4.95284647e-02f, 2.28423044e-01f, -6.45149872e-02f, 1.57283142e-01f, -2.06121907e-01f,
  1.82763606e-01f, 4.15999861e-03f, 1.73883319e-01f, -3.00122201e-02f, 2.67635703e-01f, -1.80983633e-01f, -1.48668185e-01f, 7.46931434e-02f, 1.93087503e-01f, -8.66246670e-02f,
  -7.91090950e-02f, 2.37248600e-01f, -1.08313926e-01f, 4.06087041e-02f, -1.42127886e-01f, -5.60263395e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.59575367e-01f, 2.83620775e-01f, 3.84522468e-01f, -1.91827342e-01f, -5.22756815e-01f, 1.45391136e-01f, -5.75350761e-01f, 4.64973785e-02f, -4.47340071e-01f, -1.39598310e-01f,
  5.29977143e-01f, 1.75886453e-04f, -5.18746935e-02f, 1.63078144e-01f, -2.09234748e-02f, 1.66419595e-01f, 2.85739779e-01f, 4.98832688e-02f, -1.94490284e-01f, -3.16780865e-01f,
  5.27867317e-01f, -3.07726674e-02f, 1.92047711e-02f, 5.18565238e-01f, 2.64060944e-01f, 1.82626784e-01f, 1.76607937e-01f, -2.94007897e-01f, -1.01240218e-01f, -8.94668177e-02f,
  1.24084413e-01f, 2.36475423e-01f, 2.75372237e-01f, 3.75008844e-02f, 3.36350083e-01f, -9.39399283e-03f, 1.87867776e-01f, 2.53511015e-02f, -1.14067823e-01f, 7.47904554e-02f,
  -9.92641300e-02f, -1.81959078e-01f, -2.09701389e-01f, -2.11190119e-01f, -1.45509839e-01f, 8.19409341e-02f, -1.29888684e-01f, 8.21733326e-02f, -1.44255126e-03f, 3.83363701e-02f,
  1.66057944e-01f, 1.22646347e-01f, -1.05883125e-02f, 3.32592785e-01f, 5.41035235e-02f, 3.19905840e-02f, 8.07943344e-02f, -1.80199161e-01f, 1.59140199e-01f, -2.15513408e-01f,
  3.05482566e-01f, -1.89608619e-01f, 9.41177160e-02f, 3.27880144e-01f, -2.92939134e-02f, 1.58199579e-01f, -2.05069318e-01f, 1.14767671e-01f, 1.83529034e-01f, -6.62696004e-01f,
  -4.10180017e-02f, 3.86573762e-01f, 7.97452554e-02f, -2.96918273e-01f, 2.25861475e-01f, 1.62115663e-01f, 1.01857875e-02f, 2.46168211e-01f, 3.49365771e-01f, 3.29455674e-01f,
  6.46488443e-02f, 4.99443226e-02f, 1.60654321e-01f, -2.48564798e-02f, -2.97705352e-01f, -2.79209390e-02f, 1.73003793e-01f, 4.80314255e-01f, -5.11372507e-01f, -8.22690055e-02f,
  3.98244828e-01f, 2.69749284e-01f, -3.64133269e-01f, 1.73905671e-01f, 1.86907917e-01f, -4.24477905e-01f, 1.49263248e-01f, -2.07642913e-02f, 8.93855840e-02f, 4.96048272e-01f,
  2.56453186e-01f, 3.07475567e-01f, -3.26936275e-01f, 2.75413785e-02f, -2.73254663e-01f, -1.06133297e-01f, 7.19894320e-02f, -1.51708454e-01f, -2.28765070e-01f, 1.68698505e-01f,
  3.74924690e-02f, 1.74213260e-01f, 4.47130688e-02f, -1.77107394e-01f, 8.87699500e-02f, -1.44054785e-01f, 2.41472736e-01f, -1.71566904e-01f, -2.53347903e-01f, 2.48030081e-01f,
  3.89515847e-01f, 1.95829928e-01f, 2.50926733e-01f, -3.37624460e-01f, 1.98101059e-01f, 2.50452161e-01f, -2.70403624e-01f, 1.43072248e-01f, 2.45125219e-01f, 2.43822470e-01f,
  1.48423314e-01f, -4.02993619e-01f, -2.44409621e-01f, -2.80856341e-01f, 1.85462624e-01f, -1.04536109e-01f, 3.72628719e-01f, 7.58510381e-02f, 3.69499415e-01f, 1.10873505e-01f,
  5.02346037e-03f, 1.57700315e-01f, -2.60120720e-01f, -3.90584283e-02f, 1.33991629e-01f, 3.58028203e-01f, 1.18212163e-01f, 1.95845768e-01f, -2.27671966e-01f, 1.13273501e-01f,
  6.32270724e-02f, 7.30105117e-02f, -2.79295534e-01f, -2.02648595e-01f, -9.96531732e-03f, 2.09422722e-01f, 6.88968524e-02f, -1.91770479e-01f, 3.70621055e-01f, 1.02005072e-01f,
  8.76796395e-02f, 4.59442198e-01f, -5.03322072e-02f, -6.95254207e-01f, 1.32205442e-01f, -1.77306592e-01f, 2.54369467e-01f, -7.45899752e-02f, 1.83397576e-01f, 1.44075722e-01f,
  -2.46451478e-02f, 1.31077528e-01f, 3.30602750e-02f, -1.49231866e-01f, 2.99411435e-02f, -3.57418209e-01f, 1.71588641e-02f, 2.47828752e-01f, 3.43233466e-01f, 2.63266444e-01f,
  -3.61901700e-01f, 1.44618303e-01f, 5.71602173e-02f, -2.87670314e-01f, -4.81662154e-02f, -9.76599231e-02f, 7.25223571e-02f, -6.25551566e-02f, 4.79325019e-02f, 1.32500634e-01f,
  1.26429930e-01f, 3.82480115e-01f, 2.75824070e-01f, -2.12226555e-01f, -1.20683290e-01f, 7.04615235e-01f, 7.22104132e-01f, 8.40470493e-02f, 1.56829268e-01f, -3.36336344e-02f,
  -9.83918756e-02f, 6.80363327e-02f, -1.84135646e-01f, -2.25985751e-01f, 2.06353843e-01f, 2.02175640e-02f, -1.39092375e-02f, 3.01353395e-01f, 8.46098512e-02f, -7.45686144e-02f,
  2.65303224e-01f, 1.32846072e-01f, 2.01929448e-04f, 1.34624526e-01f, -3.47980782e-02f, -5.09817064e-01f, 2.67848343e-01f, 1.43454850e-01f, 1.11830920e-01f, -1.47524074e-01f,
  2.91530430e-01f, 5.62418960e-02f, -1.85163945e-01f, 4.62401956e-02f, 3.18713993e-01f, 3.44285131e-01f, 1.52363092e-01f, -3.47423822e-01f, 3.09145749e-01f, -5.40431589e-02f,
  1.74085110e-01f, -1.94743872e-01f, 2.70072818e-01f, -1.08760893e-01f, 4.84374851e-01f, -2.57274985e-01f, 6.25635087e-01f, 2.01938182e-01f, -2.67710388e-01f, -2.08883017e-01f,
  -9.11903828e-02f, -1.59419388e-01f, 3.90986085e-01f, 5.56417763e-01f, -9.11786184e-02f, -2.12182269e-01f, 2.65054107e-01f, 1.73594628e-03f, -2.26800039e-01f, -2.39545211e-01f,
  -2.42980331e-01f, 1.72422364e-01f, 3.47135186e-01f, -4.12797987e-01f, 2.54965991e-01f, 4.91498232e-01f, 7.03782216e-02f, -4.63957824e-02f, 1.59595594e-01f, 3.36739689e-01f,
  2.12598279e-01f, 2.03392267e-01f, -1.03123769e-01f, 8.40220153e-02f, -5.91853745e-02f, -2.91389912e-01f, -2.03987136e-01f, -4.28415984e-01f, 1.68424666e-01f, 3.13886672e-01f,
  -9.07353386e-02f, 3.18711907e-01f, -3.04362684e-01f, -2.01818794e-01f, 1.89419482e-02f, 1.12944581e-01f, 9.25867725e-03f, 3.39623630e-01f, -2.26411577e-02f, -2.62771430e-03f,
  3.76424730e-01f, -4.00092788e-02f, -8.92792791e-02f, 1.18699834e-01f, 3.40621412e-01f, -2.61863559e-01f, 4.42009382e-02f, 3.16268176e-01f, 8.27520043e-02f, -1.58658892e-01f,
  -7.93289542e-02f, 1.06386825e-01f, 6.06380999e-01f, 2.30234154e-02f, -1.55144840e-01f, -1.65909007e-01f, -1.68872792e-02f, -9.43205655e-02f, -2.02102140e-01f, -4.46305335e-01f,
  -4.18817513e-02f, -1.52065426e-01f, 7.34079536e-03f, 3.86290669e-01f, -1.88808784e-01f, -4.15743232e-01f, 3.11086178e-01f, 8.32506493e-02f, -5.53599775e-01f, -4.01692912e-02f,
  7.59529695e-02f, -4.27644491e-01f, 8.88957381e-02f, -1.37415275e-01f, 5.49851768e-02f, 2.65533547e-03f, 3.59319657e-01f, -1.27140479e-02f, 1.23798214e-01f, 2.87195981e-01f,
  1.82384282e-01f, 8.66532996e-02f, 1.99106336e-01f, -4.43359107e-01f, 2.40158156e-01f, -1.66518852e-01f, 2.77758211e-01f, -2.37727702e-01f, 1.45813063e-01f, 1.59210414e-01f,
  1.92708746e-02f, -3.09172809e-01f, 2.23911792e-01f, 2.78457105e-01f, -1.22081801e-01f, -2.59664416e-01f, -2.60151684e-01f, -2.05068197e-02f, 3.52469653e-01f, 4.81939107e-01f,
  -5.67270696e-01f, 1.50283277e-01f, 2.94652581e-01f, -2.28657395e-01f, -3.30542505e-01f, -1.76288500e-01f, -2.06027001e-01f, -5.90671562e-02f, 3.45578581e-01f, -2.30704769e-01f,
  2.11443439e-01f, 3.02163094e-01f, 3.67263705e-02f, 3.48741084e-01f, -2.45986179e-01f, -7.71729201e-02f, 1.09753653e-01f, -1.37190074e-01f, 8.76766741e-02f, 2.20882520e-02f,
  3.48534107e-01f, -6.98843822e-02f, 2.37953484e-01f, 2.99017187e-02f, 7.05701262e-02f, -1.35555491e-01f, 1.69708431e-01f, -5.92850208e-01f, 1.15400560e-01f, 2.92807907e-01f,
  5.58219701e-02f, 1.43662721e-01f, -2.52685517e-01f, -2.63884544e-01f, 1.47913232e-01f, -2.52207071e-01f, 2.09011678e-02f, 1.82574764e-01f, -1.99388683e-01f, 5.04360437e-01f,
  -1.72459081e-01f, 4.08451349e-01f, 1.31742805e-01f, -3.61735933e-02f, 6.19801916e-02f, 2.88535237e-01f, 5.12292266e-01f, -2.48679563e-01f, 8.17236006e-02f, -4.65973437e-01f,
  1.14352845e-01f, -1.03433654e-01f, 2.29126379e-01f, -1.26256421e-01f, -4.09074455e-01f, 5.61349327e-03f, -3.59095812e-01f, 3.29528823e-02f, -6.59717619e-02f, -3.14669311e-01f,
  2.40725040e-01f, 2.10471258e-01f, 1.14046127e-01f, -1.27620757e-01f, -1.15283906e-01f, 8.49271715e-02f, 2.60167003e-01f, -2.83640325e-01f, 9.58175212e-02f, -3.23901251e-02f,
  -1.57967851e-01f, -2.36684918e-01f, 8.66924897e-02f, -3.70425284e-02f, 2.43846819e-01f, 6.84944838e-02f, -1.19556323e-01f, 3.51964355e-01f, 2.63012737e-01f, -2.84153253e-01f,
  -1.79850563e-01f, -4.39149022e-01f, -2.64317691e-01f, 1.63339674e-01f, -2.58681506e-01f, 4.51959074e-02f, -2.65914232e-01f, 4.42366570e-01f, -5.45900404e-01f, 2.38881350e-01f,
  -8.08780715e-02f, 2.99555689e-01f, 8.97168219e-02f, 1.99303567e-01f, 3.00380766e-01f, -2.74004936e-01f, -5.51709056e-01f, 3.57552111e-01f, 2.57250786e-01f, 1.13054641e-01f,
  -3.45885418e-02f, -7.29374215e-02f, 3.97338182e-01f, -2.25219920e-01f, 3.11540049e-02f, 3.59077677e-02f, 1.15991771e-01f, -7.98973441e-02f, 3.81294191e-01f, 1.37446195e-01f,
  4.73632693e-01f, 3.84049445e-01f, 4.37277891e-02f, 9.04607773e-02f, 1.66730508e-02f, 1.30545780e-01f, -1.65805891e-01f, -2.40976319e-01f, -3.31814378e-01f, -2.46942610e-01f,
  -1.86263859e-01f, 2.69553810e-01f, -5.45888901e-01f, 3.18333626e-01f, -2.38781780e-01f, -2.01611459e-01f, -1.69921368e-01f, 2.24865079e-01f, 2.67913997e-01f, 4.55844074e-01f,
  4.64935929e-01f, -1.16944527e-02f, 4.40804303e-01f, 2.39282131e-01f, 2.50692964e-02f, -1.67917497e-02f, 2.95283824e-01f, -4.29369420e-01f, 3.33549082e-01f, 8.19447413e-02f,
  4.23075080e-01f, 1.28305554e-01f, 1.66239709e-01f, 4.54544455e-01f, -2.69106030e-02f, 2.11022615e-01f, -2.11936906e-01f, 2.70013422e-01f, -4.45276916e-01f, -3.74766700e-02f,
  2.86522321e-02f, -3.00521344e-01f, -2.66352683e-01f, 3.15134674e-01f, 2.85502166e-01f, 1.33747727e-01f, 8.89653638e-02f, -7.32689053e-02f, 1.18879750e-01f, -2.24286944e-01f,
  2.27273375e-01f, -6.71298727e-02f, -3.59934688e-01f, -1.35168552e-01f, 5.10710299e-01f, 1.13472521e-01f, 9.38181207e-02f, -5.53977787e-01f, -1.31923063e-02f, 3.58647443e-02f,
  -4.54393923e-01f, 3.29912543e-01f, 3.37942183e-01f, -2.45824493e-02f, 2.21151605e-01f, 5.63414097e-01f, 5.26499093e-01f, 1.05246238e-01f, 6.37670904e-02f, 1.02514900e-01f,
  -6.54830113e-02f, -5.26664674e-01f, 9.39939842e-02f, -6.31744385e-01f, 2.50062972e-01f, 1.25440165e-01f, 4.40922342e-02f, 7.70965442e-02f, -4.86859113e-01f, -4.89168614e-02f,
  8.17711204e-02f, -2.68759523e-02f, 2.58317571e-02f, 1.64390370e-01f, 2.66359020e-02f, -6.55747056e-02f, 9.16507170e-02f, 4.11519744e-02f, -1.41961709e-01f, 1.57582134e-01f,
  1.51359841e-01f, -6.24398328e-02f, 1.34659693e-01f, 3.43171746e-01f, 7.91438818e-02f, -2.37757303e-02f, -1.93042561e-01f, 7.07479358e-01f, 4.65466082e-01f, -2.26932079e-01f,
  2.22765375e-02f, 2.81734794e-01f, -1.24075331e-01f, -6.03116810e-01f, 3.06507021e-01f, -4.20170695e-01f, 1.41241364e-02f, 3.27885866e-01f, 1.02263980e-01f, 3.29337239e-01f,
  -3.48562330e-01f, -1.44258384e-02f, 1.36741057e-01f, -2.63712406e-02f, -3.06302891e-03f, -3.17665994e-01f, -3.90362531e-01f, -1.88226461e-01f, -6.30994067e-02f, -3.13882887e-01f,
  1.28847674e-01f, 8.74234810e-02f, 5.13567254e-02f, 3.51803929e-01f, -5.33301197e-03f, 1.29227638e-01f, 1.92252472e-01f, 1.88855618e-01f, 7.79907554e-02f, 7.63843119e-01f,
  6.29869759e-01f, -2.07938403e-01f, 1.31190404e-01f, 1.52163878e-01f, -8.07404295e-02f, 1.33679911e-01f, -1.67266965e-01f, -3.98862243e-01f, -6.74638450e-02f, 2.33165070e-01f,
  1.79824337e-01f, 1.48678198e-01f, -1.55178487e-01f, -1.75532207e-01f, 3.25721651e-01f, 1.97772458e-01f, -1.69005424e-01f, -2.51465350e-01f, -1.90821812e-01f, -5.35308838e-01f,
  2.80713379e-01f, 1.55863479e-01f, 7.43510425e-02f, -3.61422412e-02f, 1.56084239e-01f, 2.11665452e-01f, -1.31904021e-01f, 1.15571119e-01f, 9.82886329e-02f, 2.89901823e-01f,
  2.93886811e-01f, -3.12058628e-01f, -3.96547079e-01f, 4.55359697e-01f, -1.10747635e-01f, 1.19680025e-01f, -2.48953998e-01f, 1.32785007e-01f, -2.03507021e-01f, -2.54254341e-02f,
  -4.37583655e-01f, 2.79597223e-01f, -5.68540804e-02f, 1.27644027e-02f, 1.96309015e-01f, -8.28391537e-02f, 5.16240716e-01f, -1.26071692e-01f, 8.59190002e-02f, -1.45803899e-01f,
  -8.69151577e-02f, 1.07155778e-01f, 2.42929846e-01f, 3.11534375e-01f, 9.00683999e-02f, -5.19713759e-01f, 1.22673787e-01f, 4.17043939e-02f, -2.28474662e-01f, 4.30546463e-01f,
  6.12779297e-02f, 4.57941175e-01f, 3.77261378e-02f, -4.37513620e-01f, -5.90905905e-01f, -2.32822582e-01f, -1.00873441e-01f, 1.57053962e-01f, 2.74875075e-01f, -1.83217674e-01f,
  1.44849777e-01f, 1.19922705e-01f, -1.67844042e-01f, 1.06333114e-01f, 5.76157123e-02f, -3.04049641e-01f, 9.88964457e-03f, 2.86381751e-01f, -2.82593101e-01f, 5.56257963e-02f,
  -1.19945724e-02f, 3.81241590e-01f, 3.53300869e-01f, 4.45859730e-01f, -1.16449773e-01f, 1.14181712e-01f, 2.75497437e-01f, 5.18616959e-02f, 1.65952407e-02f, -1.38251223e-02f,
  2.40447968e-01f, -2.40505472e-01f, 3.31178337e-01f, 2.98156857e-01f, 2.65256941e-01f, 2.83640444e-01f, -1.02218360e-01f, -6.13738634e-02f, 2.27293521e-02f, 1.15162864e-01f,
  4.10581939e-02f, -6.50552571e-01f, 8.09458047e-02f, -1.01796106e-01f, -1.39567822e-01f, 4.53245312e-01f, -1.48363854e-03f, -5.39494157e-02f, -5.38786590e-01f, -1.15899444e-01f,
  -1.99919924e-01f, 1.90010563e-01f, 6.27053529e-02f, 3.05513144e-01f, 1.19686633e-01f, 9.22996849e-02f, 4.53051895e-01f, 9.35683250e-02f, 3.29700917e-01f, -3.18311676e-02f,
  3.88538986e-01f, 5.98680750e-02f, 2.79475395e-02f, -1.64754003e-01f, -2.57486515e-02f, 1.46720454e-01f, 6.41140267e-02f, -2.79375702e-01f, -2.88152248e-02f, -2.12782905e-01f,
  -3.72229397e-01f, -1.56974107e-01f, -9.28148851e-02f, 1.29811287e-01f, -1.44982725e-01f, 2.23322392e-01f, -1.69197604e-01f, 3.06805760e-01f, -4.30620909e-01f, 1.22623093e-01f,
  -9.49099883e-02f, -2.83175521e-03f, 1.46448746e-01f, 7.22697303e-02f, -5.58144093e-01f, 4.34311390e-01f, 4.41980004e-01f, 3.51743668e-01f, -5.93423322e-02f, -3.12681109e-01f,
  3.40328932e-01f, -1.42669812e-01f, 3.13058406e-01f, -4.35181290e-01f, 1.60903737e-01f, 6.77389652e-02f, -5.15419766e-02f, 1.11131882e-03f, -4.31364894e-01f, 3.88411194e-01f,
  2.50408292e-01f, -7.04090819e-02f, -7.36037195e-02f, 1.60062432e-01f, 7.42303627e-03f, 1.28896400e-01f, -3.54769588e-01f, 2.18131885e-01f, -2.95519680e-01f, -1.19460486e-01f,
  4.40807313e-01f, 3.19605805e-02f, -5.06321453e-02f, 2.16290593e-01f, 1.86168581e-01f, 6.48270398e-02f, -2.05186978e-01f, 4.03479813e-03f, -1.03277992e-02f, -2.59931535e-01f,
  -1.70753539e-01f, 3.53655107e-02f, 1.72842652e-01f, -1.03418969e-01f, -2.38844603e-02f, 4.77158636e-01f, 6.26948401e-02f, -3.13946567e-02f, 2.78193988e-02f, 1.69428661e-01f,
  3.91328102e-03f, -1.46459147e-01f, -3.90903391e-02f, -5.81705011e-02f, -2.28463579e-02f, 6.46763220e-02f, 1.25843912e-01f, -2.66924739e-01f, -1.61949486e-01f, -3.30878526e-01f,
  -3.41939963e-02f, 2.53723592e-01f, 5.54807950e-03f, -3.83309694e-03f, -1.38468161e-01f, -1.40940055e-01f, -1.52304396e-02f, 2.98596859e-01f, -5.98402560e-01f, 9.11891088e-02f,
  3.39386225e-01f, -1.31449029e-01f, 1.18928500e-01f, -1.95644513e-01f, 3.64331715e-02f, -1.78711310e-01f, 3.11149627e-01f, -1.39717832e-01f, -8.00356343e-02f, -5.95857948e-02f,
  2.15865709e-02f, 3.53830010e-01f, 6.77675232e-02f, -7.01233894e-02f, -1.09797217e-01f, 2.54935026e-01f, -1.69635385e-01f, 3.81931990e-01f, 3.28892544e-02f, 1.18039958e-01f,
  -3.98555666e-01f, -7.28951469e-02f, -2.26722553e-01f, 3.83450270e-01f, -1.06063016e-01f, 4.23473060e-01f, -2.64052510e-01f, 4.34964634e-02f, 1.91712394e-01f, -1.08680628e-01f,
  -3.04405391e-01f, 2.75147915e-01f, 3.69691968e-01f, -4.78678681e-02f, 2.78097272e-01f, 3.34209859e-01f, 4.04694319e-01f, -1.04715951e-01f, 2.67760038e-01f, -4.47351933e-02f,
  2.11438417e-01f, 3.38179502e-03f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  2.07101882e-01f, 2.16148898e-01f, 1.95235655e-01f, -8.22475255e-02f, 3.00450802e-01f, 1.95858195e-01f, 1.15410648e-01f, 2.60234535e-01f, 3.61538194e-02f, -1.02062047e-01f,
  3.51250798e-01f, 2.04581276e-01f, 3.86573046e-01f, 2.44469598e-01f, 3.42434347e-01f, 7.94416666e-02f, 3.66237879e-01f, 7.00997859e-02f, 3.35652202e-01f, 2.89761543e-01f,
  1.80998102e-01f, 3.62225443e-01f, 2.47394353e-01f, -2.00316265e-01f, -1.21277897e-02f, 1.43817857e-01f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -2.74242703e-02f, 2.30662301e-02f, -1.02470793e-01f, 1.03933156e-01f, 1.63841397e-01f, -2.73344994e-01f, 2.46251792e-01f, -1.82005074e-02f, -2.56239325e-01f, 2.83410877e-01f,
  -1.97934523e-01f, 3.40227187e-02f, 1.30147278e-01f, 5.44194989e-02f, 2.18007341e-01f, 7.64961764e-02f, -9.56524462e-02f, -1.21224403e-01f, 1.59142703e-01f, -2.11398564e-02f,
  1.49397030e-01f, 9.41109881e-02f, -1.19571529e-01f, -3.47955339e-02f, 1.00141801e-01f, 3.75099741e-02f, 5.64286634e-02f, -1.04900151e-02f, -1.19689099e-01f, -7.98700005e-02f,
  9.65983495e-02f, -2.10664958e-01f, -3.42350192e-02f, 6.23192592e-03f, -8.30359831e-02f, -5.41687617e-03f, 1.49914697e-01f, -1.14338696e-01f, -5.75726777e-02f, 7.02172294e-02f,
  -1.38524339e-01f, 3.37691531e-02f, 1.32130265e-01f, -6.10673130e-02f, -2.06327751e-01f, -4.96709459e-02f, -1.30631089e-01f, -1.24651268e-01f, -1.14355221e-01f, 1.70336589e-01f,
  2.66215473e-01f, 1.43171102e-01f, 2.20027298e-01f, -2.30981395e-01f, -2.17539862e-01f, -2.65707195e-01f, -3.87958810e-02f, -1.00848682e-01f, 2.24770069e-01f, 1.73370183e-01f,
  4.89465930e-02f, -7.42123276e-02f, -1.23863019e-01f, -5.51526248e-02f, -2.39160568e-01f, -2.31328294e-01f, -1.54289350e-01f, 1.00143112e-01f, -1.54590374e-02f, -9.08677727e-02f,
  7.06498697e-02f, -1.44209087e-01f, 1.86892495e-01f, 2.30458185e-01f, 8.72684717e-02f, 7.02281110e-03f, 8.59493539e-02f, -5.09502813e-02f, 9.39932466e-02f, 1.00186706e-01f,
  -1.51426028e-02f, 2.40641579e-01f, -2.06854925e-01f, -2.12538719e-01f, 1.16187278e-02f, -7.85504356e-02f, 3.35129201e-02f, -3.52779478e-01f, 1.23452127e-01f, -8.49732384e-02f,
  1.73558846e-01f, -8.55689347e-02f, -1.85741216e-01f, -2.47777421e-02f, -1.17264509e-01f, -1.07179128e-01f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  1.05007268e-01f, 1.12779081e-01f, 3.92347127e-01f, 3.27232659e-01f, -6.16399288e-01f, 9.55687165e-02f, -8.39046910e-02f, -5.96972443e-02f, 2.29575917e-01f, -1.14920437e-01f,
  2.95960546e-01f, -3.27578862e-03f, -1.28180921e-01f, -2.59161592e-01f, -1.22664660e-01f, -1.31647006e-01f, -1.71762869e-01f, -1.03117183e-01f, 3.10359329e-01f, 2.76050538e-01f,
  -1.82471331e-02f, 2.23800570e-01f, -2.52712339e-01f, -2.95269161e-01f, 2.63330370e-01f, 2.06314832e-01f, 2.97953859e-02f, -1.01742506e-01f, 2.83194669e-02f, -1.78356811e-01f,
  -2.58577257e-01f, 1.30351856e-01f, 2.34091982e-01f, 1.19017646e-01f, 3.93416584e-02f, 3.65621075e-02f, 4.06189896e-02f, 4.33224618e-01f, 4.63099748e-01f, 1.42436966e-01f,
  -6.99795559e-02f, 7.82161877e-02f, 2.27186643e-02f, -6.41578883e-02f, -2.76281033e-02f, 2.33684555e-01f, -5.77562451e-01f, -4.17516977e-01f, 2.89375722e-01f, -1.54105231e-01f,
  -4.55286428e-02f, 1.36387078e-02f, -1.78328201e-01f, 2.27086514e-01f, -2.93476760e-01f, -2.26028234e-01f, -2.93643832e-01f, 3.25157702e-01f, 6.46772385e-02f, -2.05586091e-01f,
  9.97871459e-02f, 8.88772234e-02f, 8.27148929e-02f, -1.71324536e-01f, 4.17531206e-04f, 4.22379255e-01f, 2.96122003e-02f, -3.67313445e-01f, 1.38641700e-01f, -1.71547204e-01f,
  2.47041449e-01f, 1.78289115e-02f, -2.25797355e-01f, 2.17641238e-02f, 1.98713198e-01f, 2.92708892e-02f, -1.80617161e-02f, 2.12386742e-01f, 1.86219260e-01f, 5.63439205e-02f,
  4.92091961e-02f, 1.30471617e-01f, -2.16078132e-01f, -1.82704940e-01f, 1.83819786e-01f, 1.67430833e-01f, 8.28231685e-03f, -3.98404300e-01f, -2.38999292e-01f, 2.95951754e-01f,
  2.64365703e-01f, -7.73334727e-02f, 8.84871483e-02f, -8.35029110e-02f, -4.29229066e-02f, 3.56958389e-01f, -2.65798956e-01f, -3.64707023e-01f, -1.70596838e-02f, 4.04131077e-02f,
  -3.81852984e-01f, -2.47990027e-01f, -2.63461292e-01f, 1.15493864e-01f, 3.15141708e-01f, -1.45174101e-01f, 7.33983889e-02f, 1.72641158e-01f, 1.03570960e-01f, -1.95298910e-01f,
  -5.63333742e-02f, 6.25952184e-02f, 7.09781274e-02f, -3.04077528e-02f, 1.77342236e-01f, 3.86686593e-01f, 1.58240750e-01f, -9.37504768e-02f, -4.62329909e-02f, -3.05887491e-01f,
  9.54330489e-02f, -1.07762218e-01f, 3.35136414e-01f, -2.12389845e-02f, 4.56904858e-01f, 2.46936321e-01f, 1.06272377e-01f, 3.66865098e-01f, -4.85246807e-01f, -7.79026449e-01f,
  -3.01606864e-01f, 3.13547179e-02f, -6.53677583e-02f, 6.01835698e-02f, -6.07021265e-02f, 9.87717062e-02f, 2.02873260e-01f, -1.74221620e-02f, -9.72590297e-02f, -7.13580009e-03f,
  2.23635852e-01f, -3.89393538e-01f, 2.42196545e-01f, 3.62715632e-01f, -1.90348983e-01f, 3.25184882e-01f, 2.46038899e-01f, 1.38015896e-01f, -9.98268351e-02f, 7.07768500e-02f,
  -9.82665196e-02f, -3.58010978e-02f, 2.37780660e-01f, -4.39583808e-02f, 1.25226483e-01f, 1.45472676e-01f, 1.30403772e-01f, 4.40544218e-01f, 3.26935530e-01f, -7.23581910e-02f,
  7.89239556e-02f, -1.84210718e-01f, -1.82377666e-01f, 1.45083666e-02f, 1.97221190e-01f, -1.96533278e-01f, 9.73766446e-02f, 1.12884104e-01f, -9.81612056e-02f, -3.66478637e-02f,
  3.48221838e-01f, 1.61047891e-01f, -4.21508342e-01f, 1.10399574e-01f, -3.29612553e-01f, -2.70440072e-01f, -1.01031683e-01f, 2.28363305e-01f, 3.78211611e-03f, 2.45194957e-01f,
  -1.12148687e-01f, -3.35252881e-01f, -2.22503409e-01f, -9.48209390e-02f, -3.38827103e-01f, -2.63059974e-01f, 2.92268634e-01f, 1.08126327e-02f, 3.81659925e-01f, -1.44945383e-01f,
  -4.22703065e-02f, 1.20284751e-01f, 1.66462585e-01f, 1.71168298e-01f, -9.97498482e-02f, -1.20594323e-01f, -7.31768981e-02f, -4.69090641e-01f, -2.45666623e-01f, 1.08322829e-01f,
  -7.47201815e-02f, -2.04786751e-02f, 2.23547928e-02f, 1.20350368e-01f, -1.67863861e-01f, 1.27590165e-01f, 8.30617622e-02f, -4.76650633e-02f, 3.09008539e-01f, -1.05562590e-01f,
  -6.30408451e-02f, 1.38847172e-01f, 4.54463452e-01f, -4.01439577e-01f, 1.97185446e-02f, -4.12998587e-01f, -2.51578659e-01f, -3.15109700e-01f, 1.66979507e-01f, 3.86254221e-01f,
  3.72702241e-01f, -4.84646112e-01f, 3.43471438e-01f, 3.49084258e-01f, 3.20249721e-02f, 1.16156526e-01f, 2.55676478e-01f, 2.76075542e-01f, 1.49516627e-01f, -3.13569382e-02f,
  -2.07177371e-01f, 3.13794076e-01f, -1.86626032e-01f, -7.52336681e-02f, -4.96438369e-02f, 1.34862587e-01f, 3.65743726e-01f, 3.56514975e-02f, 2.57331878e-01f, 8.51465836e-02f,
  6.79949299e-02f, -1.22700639e-01f, 9.82931405e-02f, -1.46173015e-01f, 1.96812004e-01f, 2.55798906e-01f, 4.44860071e-01f, 3.51708859e-01f, 3.49385977e-01f, -1.77143943e-02f,
  -1.07062779e-01f, 3.10956627e-01f, -2.01803699e-01f, -3.22629847e-02f, 1.44551590e-01f, 1.70831338e-01f, -5.37939370e-02f, 5.89722730e-02f, 2.31143042e-01f, 2.22243339e-01f,
  -2.17430726e-01f, 1.66384757e-01f, -4.25517291e-01f, 2.43978240e-02f, 4.50996719e-02f, 1.95381287e-02f, -3.60992402e-02f, -4.95205671e-02f, 3.97180617e-01f, 1.52394567e-02f,
  3.24588835e-01f, 4.15604204e-01f, 1.28284991e-01f, -7.96760470e-02f, 3.65983769e-02f, 1.55886576e-01f, 1.02403231e-01f, -2.42968589e-01f, 1.94693998e-01f, 3.89806479e-01f,
  1.81055561e-01f, -1.93957120e-01f, -3.00142348e-01f, 7.33361989e-02f, 2.58992136e-01f, -1.56550840e-01f, 2.47361749e-01f, 2.02551052e-01f, 9.82999802e-03f, 2.66364545e-01f,
  -1.21478997e-01f, 4.70402092e-02f, 3.43846083e-02f, 1.41489699e-01f, 4.18763727e-01f, 1.90337196e-01f, 3.65556568e-01f, 2.58055300e-01f, 6.27707168e-02f, -3.52712899e-01f,
  -1.41772032e-01f, -3.07728261e-01f, -1.40947595e-01f, -1.83630474e-02f, -4.81806882e-02f, -4.97220248e-01f, -4.79558915e-01f, 2.74074286e-01f, 1.84078012e-02f, 1.48109034e-01f,
  -2.43839636e-01f, 4.25455511e-01f, -1.67245567e-01f, 7.53469244e-02f, -3.54024977e-03f, -2.73069561e-01f, 1.34627998e-01f, -1.19665615e-01f, -4.04172063e-01f, 1.09049324e-02f,
  3.04295629e-01f, 8.81492123e-02f, 2.46016666e-01f, 2.20648274e-01f, -1.12841174e-01f, 3.90994251e-01f, 6.54668808e-02f, 4.12351727e-01f, -4.44408566e-01f, 1.52582601e-01f,
  9.62866023e-02f, -1.38008790e-02f, 5.55773824e-02f, -1.83490515e-01f, 1.06060669e-01f, -1.51840582e-01f, -1.89221017e-02f, 1.74368545e-01f, 5.35170674e-01f, 1.94678977e-01f,
  3.59504372e-01f, 2.74851382e-01f, 4.41549085e-02f, -2.78026313e-01f, 2.66816765e-01f, 4.89708304e-01f, 1.64076835e-01f, 3.43720853e-01f, 2.56055117e-01f, 2.66170297e-02f,
  2.97321200e-01f, 2.11275861e-01f, 3.86478275e-01f, 4.35182720e-01f, 3.19793612e-01f, 8.69010985e-02f, 3.38439703e-01f, -4.70990427e-02f, -2.24196147e-02f, 1.93480268e-01f,
  -2.91565150e-01f, 2.94673085e-01f, -2.70559698e-01f, 7.78839961e-02f, 2.13453084e-01f, 5.83983399e-02f, 4.51757312e-01f, 3.14071327e-01f, -6.00394197e-02f, 1.26618758e-01f,
  8.94046500e-02f, 1.16122119e-01f, 3.17644358e-01f, 4.25981909e-01f, 3.68116945e-01f, 2.64271080e-01f, 2.23180026e-01f, 2.44337171e-01f, -1.26393557e-01f, 2.28850901e-01f,
  -7.64553994e-02f, 8.91381130e-02f, -1.34674072e-01f, 8.98563862e-02f, 2.63219714e-01f, 2.45423242e-01f, 1.41585097e-01f, -1.22421540e-01f, -1.38742579e-02f, 2.13914543e-01f,
  -9.96515155e-02f, -5.49397757e-03f, 4.03115034e-01f, 1.06672972e-01f, 1.97160959e-01f, 1.53163388e-01f, 2.97812551e-01f, 4.72736180e-01f, 1.83145791e-01f, 2.89972186e-01f,
  4.29655105e-01f, 2.34991074e-01f, 4.28819507e-02f, -3.72320856e-03f, -3.11843455e-01f, 2.76193649e-01f, 3.69686246e-01f, 6.86541855e-01f, 2.36922637e-01f, 5.02070412e-02f,
  4.95002046e-02f, 4.08110283e-02f, -2.88915515e-01f, 3.27278048e-01f, -1.30447298e-01f, -2.58937359e-01f, -5.50677776e-01f, -6.51058316e-01f, -2.84985721e-01f, 2.60503352e-01f,
  -4.62724835e-01f, -1.32062748e-01f, 2.27441005e-02f, -1.10684127e-01f, -2.19673887e-02f, -1.47948623e-01f, -3.63112725e-02f, 1.12562753e-01f, 1.47808999e-01f, -3.38060290e-01f,
  2.26949379e-02f, -2.39251673e-01f, -5.89264296e-02f, 1.47127241e-01f, 1.41638935e-01f, 2.13927552e-01f, 3.66975367e-01f, -3.16969723e-01f, 4.09829095e-02f, -1.26065359e-01f,
  -1.18566319e-01f, -1.28618315e-01f, 2.31562972e-01f, 2.77900249e-01f, 2.02793241e-01f, -5.85791059e-02f, 3.54506373e-01f, 2.20898151e-01f, -5.10831848e-02f, -1.99815989e-01f,
  3.88524204e-01f, 4.64750409e-01f, -4.37545270e-01f, -8.07470754e-02f, 3.03741153e-02f, -3.01904321e-01f, 4.49688077e-01f, 1.85417846e-01f, 9.49588418e-02f, -1.03993535e-01f,
  1.93918914e-01f, -1.76918224e-01f, 1.44716233e-01f, 1.42820805e-01f, -9.68530327e-02f, 9.72165987e-02f, 1.60273820e-01f, 4.21141833e-02f, -2.19640821e-01f, 3.12533230e-01f,
  2.68650740e-01f, 7.30625629e-01f, 3.67100239e-01f, -1.96832106e-01f, 1.35032073e-01f, 1.99589849e-01f, -3.41440380e-01f, 5.00066727e-02f, -1.33820087e-01f, -1.16120055e-01f,
  1.52426988e-01f, -2.99126655e-01f, -6.11974061e-01f, 7.75868446e-02f, 4.21951599e-02f, -1.73650190e-01f, 3.68157238e-01f, -1.27996087e-01f, 4.69331741e-01f, 2.01057747e-01f,
  2.78615206e-01f, -5.97306564e-02f, -1.87643215e-01f, 1.82384863e-01f, -1.22911008e-02f, -2.33431414e-01f, 9.57861990e-02f, 3.02109897e-01f, -3.59859675e-01f, -5.86928464e-02f,
  5.84165379e-02f, -2.36855775e-01f, 1.60329342e-01f, 3.24016362e-01f, -1.61448151e-01f, -3.50609571e-01f, 1.97963700e-01f, 5.27490258e-01f, -1.67215034e-01f, -3.07312489e-01f,
  -1.34524837e-01f, -2.08078861e-01f, 1.88381448e-02f, 3.45829651e-02f, 2.08897918e-01f, 3.28765064e-01f, -6.50369883e-01f, -1.18453912e-02f, 5.94400577e-02f, -2.31700614e-01f,
  4.54418182e-01f, 1.09371617e-01f, 3.07414144e-01f, 1.85039014e-01f, -1.65064633e-01f, -9.14735496e-02f, -2.31448606e-01f, -1.47486135e-01f, -2.41097361e-01f, -5.41922599e-02f,
  2.75702655e-01f, 5.22439420e-01f, -2.54054457e-01f, -1.16013093e-02f, -3.00972581e-01f, 2.57727146e-01f, 3.45396549e-02f, -8.15437362e-02f, 7.33976811e-02f, -2.08770528e-01f,
  2.58648217e-01f, 6.64157420e-02f, -6.03047013e-01f, 1.25295907e-01f, 1.80887148e-01f, 4.68905538e-01f, 8.86042863e-02f, 1.96741283e-01f, 1.77085936e-01f, -2.01505125e-01f,
  4.73948389e-01f, 1.30618840e-01f, 2.24617973e-01f, -1.31319314e-02f, -6.96327165e-02f, -4.83720332e-01f, -2.16813758e-02f, -1.07834540e-01f, 8.70522857e-02f, -4.18612450e-01f,
  -1.63136497e-01f, -4.56883699e-01f, -1.69362098e-01f, 1.48314878e-01f, 2.78923869e-01f, 2.14687526e-01f, 2.29725659e-01f, -3.54513347e-01f, -1.20314859e-01f, 1.50330901e-01f,
  2.49212131e-01f, 3.19022387e-01f, 2.06991300e-01f, -3.84582520e-01f, -3.05387467e-01f, 1.61119491e-01f, 1.67279959e-01f, 2.34213695e-01f, -2.83667833e-01f, 3.12550664e-01f,
  -9.60234776e-02f, -2.64349133e-01f, -1.39359728e-01f, 1.57452449e-01f, 3.29749137e-01f, -1.14573888e-01f, 3.75412516e-02f, -1.10785522e-01f, 1.08885877e-01f, 1.06540397e-01f,
  1.45623460e-01f, 1.72452673e-01f, -1.34482637e-01f, -2.08260700e-01f, -2.15238377e-01f, 1.04982756e-01f, 7.22299591e-02f, -1.54734492e-01f, 1.99350432e-01f, 2.32890904e-01f,
  8.80471095e-02f, -3.25323015e-01f, -1.24224454e-01f, 2.34664425e-01f, 1.31920055e-01f, -2.22743545e-02f, 1.48242518e-01f, 1.28221124e-01f, 1.82994500e-01f, 3.49992454e-01f,
  2.23955348e-01f, -2.18540460e-01f, 1.89522520e-01f, -3.08413859e-02f, 3.00035894e-01f, 1.65636137e-01f, -1.32031903e-01f, 2.98611999e-01f, -3.89273286e-01f, -1.45553902e-03f,
  2.01375917e-01f, -1.74593940e-01f, 5.18523715e-02f, 2.29409844e-01f, -1.21806100e-01f, 2.31062427e-01f, -5.07335179e-02f, -3.02748922e-02f, -9.89178196e-03f, 4.05897409e-01f,
  -8.95795673e-02f, 7.63369426e-02f, 5.78907393e-02f, 2.24471152e-01f, -2.92273294e-02f, 2.50232905e-01f, -4.07774448e-01f, 5.42342961e-01f, -9.03340504e-02f, 2.09802285e-01f,
  -4.48295295e-01f, -3.75730038e-01f, -5.43369241e-02f, 3.58944416e-01f, -1.22715667e-01f, -8.83031115e-02f, -2.52532214e-01f, 2.18691453e-01f, -2.84666508e-01f, 3.09394926e-01f,
  -3.09059113e-01f, -2.19806999e-01f, 4.64990944e-01f, -2.40918502e-01f, 1.42284155e-01f, 1.55076668e-01f, -1.82492454e-02f, -1.46780998e-01f, 2.37655088e-01f, 2.54641294e-01f,
  2.27966383e-01f, 1.10572398e-01f, 1.12987548e-01f, -2.08635613e-01f, 3.29008728e-01f, 2.48566687e-01f, -2.53862411e-01f, 2.67217606e-01f, -6.68383762e-02f, 1.28729314e-01f,
  2.59799540e-01f, 2.03987151e-01f, 5.44503808e-01f, 5.85284770e-01f, 1.82931051e-01f, -2.90151417e-01f, 1.08804882e-01f, 4.56567794e-01f, 2.92363882e-01f, 1.08665936e-01f,
  3.78922261e-02f, -1.18926533e-01f, 9.67788622e-02f, 1.13366723e-01f, -2.43832201e-01f, 2.88314670e-01f, -2.00881124e-01f, -6.77522197e-02f, 2.57646233e-01f, 3.65668446e-01f,
  -5.50995506e-02f, -3.95515151e-02f, -2.57152319e-01f, -2.15904832e-01f, 2.14410678e-01f, 3.14931571e-01f, 3.14294398e-02f, 6.10539690e-02f, 1.95114285e-01f, -2.72550751e-02f,
  8.59155953e-02f, -3.69928777e-01f, -4.01872471e-02f, -1.84861124e-01f, 1.32140117e-02f, 2.56532133e-01f, 2.71349192e-01f, -2.19392985e-01f, -5.56253940e-02f, 2.62590677e-01f,
  -4.74009842e-01f, 1.24684028e-01f, 2.43090257e-01f, -1.91995725e-01f, 3.70260864e-01f, 4.13307071e-01f, -2.16005500e-02f, 4.81370717e-01f, 1.49924755e-01f, 4.18717682e-01f,
  4.79848117e-01f, 3.11972827e-01f, 2.77488261e-01f, -3.39873619e-02f, 8.58639181e-03f, -1.54166669e-01f, 2.70574808e-01f, 8.65136608e-02f, 2.07898304e-01f, -4.55736555e-02f,
  7.67379487e-03f, -1.82795495e-01f, 9.12522003e-02f, -1.03315577e-01f, 2.41626009e-01f, -5.15705012e-02f, 4.52846140e-01f, 3.36332768e-01f, 4.10183132e-01f, -2.32434914e-01f,
  -2.70952493e-01f, 3.71771097e-01f, -6.16306588e-02f, 7.58355781e-02f, -2.35422701e-01f, -2.22516805e-02f, 1.12666972e-01f, 5.08143544e-01f, 1.59666449e-01f, 3.41507852e-01f,
  -2.16515630e-01f, 1.56749129e-01f, 3.93674910e-01f, 1.39374003e-01f, 3.16034138e-01f, 1.88555464e-01f, -2.23732322e-01f, 3.05116653e-01f, 1.91903725e-01f, -2.34328598e-01f,
  1.97899163e-01f, 3.51900101e-01f, -1.49281576e-01f, -5.06017268e-01f, 1.68717682e-01f, 8.30831099e-03f, 8.25246572e-02f, 1.10347964e-01f, 3.06848437e-01f, 5.89215457e-01f,
  4.67376441e-01f, -4.40390892e-02f, -2.57571161e-01f, -8.67424533e-02f, -9.22459364e-02f, 1.62085861e-01f, -2.17137814e-01f, -1.77475810e-01f, 1.54078171e-01f, -5.96059002e-02f,
  1.97285771e-01f, 3.14432792e-02f, 1.42663389e-01f, -1.52126625e-01f, 2.96845108e-01f, -2.84626365e-01f, 4.97853428e-01f, 3.62801373e-01f, 4.96108353e-01f, -1.99266076e-01f,
  3.95129956e-02f, -4.43852037e-01f, -5.77798970e-02f, 5.36905751e-02f, 8.28719065e-02f, 4.55694869e-02f, 5.07731259e-01f, -3.61102074e-01f, 4.84712809e-01f, 2.20539883e-01f,
  8.60690549e-02f, -2.04958215e-01f, -1.27202690e-01f, 3.39195400e-01f, -1.87259883e-01f, 1.04241259e-01f, 2.34516174e-01f, 1.54851722e-02f, 3.36498708e-01f, 2.34027669e-01f,
  8.03902522e-02f, 8.86612982e-02f, -2.08800644e-01f, -2.33492360e-01f, -1.86631292e-01f, -1.68275312e-01f, -2.45090038e-01f, 9.44064371e-03f, 4.42891791e-02f, 4.90560830e-01f,
  -2.54279941e-01f, 8.55157301e-02f, -2.61083245e-01f, -2.37609699e-01f, -1.72457322e-01f, 2.29933158e-01f, 4.26701337e-01f, 5.15200980e-02f, 3.13347846e-01f, -8.67657363e-02f,
  -2.13968128e-01f, 3.22777152e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  1.86608329e-01f, 2.76252478e-01f, 4.10265811e-02f, 1.09372986e-02f, -6.21922016e-02f, 5.25312759e-02f, 5.99453114e-02f, 1.60011277e-01f, 3.15321356e-01f, 5.94864003e-02f,
  4.84270185e-01f, 2.76169598e-01f, 8.95807445e-02f, 4.43638004e-02f, -4.66307215e-02f, -3.42315324e-02f, -1.01824649e-01f, 7.91884959e-03f, 4.11363095e-02f, -8.25447403e-03f,
  2.08491743e-01f, 3.28194380e-01f, 5.45324311e-02f, 5.95466059e-04f, 4.38731313e-01f, 3.14106256e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  7.31709227e-03f, -2.06017285e-03f, -3.42009664e-01f, 2.15328902e-01f, -2.39411831e-01f, -5.52408174e-02f, -2.96213478e-01f, 1.02704234e-01f, 1.75818235e-01f, -1.34014666e-01f,
  -3.44519526e-01f, 2.87490308e-01f, 3.77998315e-02f, -2.85310626e-01f, -3.59840989e-01f, -1.88960239e-01f, -4.73930001e-01f, -6.01442575e-01f, 2.10556671e-01f, -1.03188507e-01f,
  -3.30921113e-01f, 3.46139282e-01f, 8.94786324e-03f, -2.32669979e-01f, -3.40009570e-01f, -8.49152729e-02f, -6.68276027e-02f, 2.01936096e-01f, 2.08393767e-01f, 1.97735623e-01f,
  -1.85377598e-01f, -2.37425253e-01f, -6.36130124e-02f, -2.60467708e-01f, -9.55840722e-02f, -1.18578717e-01f, -1.17646746e-01f, 4.66340810e-01f, 2.91947156e-01f, -4.23901141e-01f,
  -2.30117291e-01f, 2.51170456e-01f, 3.32711905e-01f, 1.62653551e-01f, -1.87783986e-01f, -2.26958334e-01f, -4.45840687e-01f, -5.17587483e-01f, -6.37922361e-02f, -2.97115713e-01f,
  2.95594726e-02f, 4.10125911e-01f, 2.41206154e-01f, -1.37775302e-01f, 3.69621366e-01f, -1.66422099e-01f, -3.71363372e-01f, 1.41140938e-01f, 4.03663255e-02f, -8.24598148e-02f,
  -6.78121969e-02f, -1.00397244e-01f, -8.54779333e-02f, 2.84525603e-01f, -3.47337462e-02f, -6.10370934e-03f, -5.87260313e-02f, -3.34419996e-01f, 2.48269737e-01f, -1.50573313e-01f,
  -3.86180341e-01f, -5.05371951e-02f, 6.70968890e-02f, -5.00115864e-02f, 7.49745071e-02f, 3.35287541e-01f, 2.60874450e-01f, -1.40601546e-01f, -2.01514706e-01f, -4.41413701e-01f,
  6.03227206e-02f, -3.55030000e-01f, -6.79736584e-02f, 2.16560498e-01f, -1.51092097e-01f, 4.35223043e-01f, -5.13766229e-01f, 3.02322626e-01f, 7.35137314e-02f, -6.45829320e-01f,
  -4.64877665e-01f, 2.66353637e-01f, 2.28858292e-02f, -5.17397344e-01f, 2.29298800e-01f, 1.21486410e-02f, -2.64472425e-01f, -1.22227706e-01f, -8.20274428e-02f, -1.18259802e-01f,
  3.85232210e-01f, 2.37673372e-01f, -3.84273559e-01f, -3.53092849e-01f, -2.70018786e-01f, -4.19895202e-01f, -2.75138706e-01f, -1.86460227e-01f, -5.26258707e-01f, 1.19854555e-01f,
  2.57471949e-01f, -9.94312316e-02f, -6.55274093e-01f, 2.43540341e-03f, 1.78814679e-01f, -2.54661858e-01f, 3.84148419e-01f, 1.92253977e-01f, 1.00502566e-01f, -7.82222822e-02f,
  2.01219082e-01f, -3.46319437e-01f, -3.15710694e-01f, 2.16430694e-01f, 2.17188850e-01f, -1.40947983e-01f, -3.92836750e-01f, -3.72237623e-01f, 1.90566272e-01f, 8.49088430e-02f,
  2.52935499e-01f, -1.41260415e-01f, 1.75088167e-01f, -1.85378245e-03f, -3.31334889e-01f, -2.38696009e-01f, 3.39728475e-01f, -3.16990949e-02f, 2.76845638e-02f, -1.45480156e-01f,
  1.51531488e-01f, 6.61620200e-02f, 1.42731369e-01f, 2.95325089e-02f, -9.10076797e-02f, 1.52695393e-02f, 1.94521993e-01f, -8.10785592e-01f, -3.39728087e-01f, -1.79715976e-01f,
  -3.80899280e-01f, -4.19881821e-01f, 2.17340253e-02f, 2.61233836e-01f, -3.88143837e-01f, 8.72178748e-02f, 2.32642114e-01f, 2.31527567e-01f, 1.43591210e-01f, -3.61492872e-01f,
  1.00020789e-01f, 1.45368814e-01f, -2.77507585e-02f, -1.15019776e-01f, 3.66854519e-01f, -3.47989589e-01f, 3.20007533e-01f, 3.22265446e-01f, -4.84947041e-02f, -4.15925682e-02f,
  -4.47659791e-01f, 1.77404210e-01f, -6.85985833e-02f, -3.58824253e-01f, -9.49741155e-02f, -4.12978828e-02f, 2.19905019e-01f, -1.63937539e-01f, -9.40341577e-02f, -2.89875388e-01f,
  -4.49322522e-01f, -5.46285510e-01f, 1.87055498e-01f, 8.95127505e-02f, -4.50493425e-01f, -1.39874890e-01f, -2.31768534e-01f, 3.22538793e-01f, -5.76895662e-02f, 3.05230349e-01f,
  3.09288740e-01f, 1.78567678e-01f, 2.19513059e-01f, -2.05739692e-01f, -1.58993304e-01f, 1.92536652e-01f, 3.74982148e-01f, -8.95050913e-02f, -2.94804931e-01f, -4.39895876e-02f,
  2.58363634e-01f, 3.75045277e-02f, 1.21397540e-01f, -3.01699728e-01f, 6.63111061e-02f, -7.70572573e-02f, 4.35894616e-02f, -3.48527491e-01f, 1.86331809e-01f, 8.58326927e-02f,
  -6.00801051e-01f, 7.81192258e-02f, -4.77850616e-01f, -2.88537025e-01f, -2.03037277e-01f, 3.69605929e-01f, 9.68804508e-02f, 3.89213761e-04f, 8.13805610e-02f, -6.24853037e-02f,
  -4.62793171e-01f, -4.16471452e-01f, 6.85217232e-02f, 1.38439178e-01f, -4.02411781e-02f, -1.49728626e-01f, -1.25183821e-01f, 2.75720716e-01f, -3.97977740e-01f, 2.21012563e-01f,
  -2.30628535e-01f, 1.47426948e-01f, -3.91881257e-01f, -1.93791702e-01f, 3.56348723e-01f, -2.19466791e-01f, -3.69498581e-01f, 1.43898293e-01f, 2.03452468e-01f, -1.32681757e-01f,
  -9.96844261e-04f, 9.40201208e-02f, 1.69980481e-01f, -1.76750302e-01f, 1.85910150e-01f, -3.40919763e-01f, -3.74373436e-01f, -5.63414872e-01f, 1.72702312e-01f, 2.42404908e-01f,
  1.72632724e-01f, -2.47370079e-01f, -1.96113393e-01f, 4.97509688e-02f, -4.38907534e-01f, -8.53945464e-02f, 1.47960052e-01f, -4.98876199e-02f, 8.98328200e-02f, 3.01955670e-01f,
  -2.55257607e-01f, 2.63579965e-01f, 5.75395711e-02f, 3.45667481e-01f, -4.09171656e-02f, -3.57720286e-01f, -6.03907555e-02f, -2.87757039e-01f, -3.19474280e-01f, -3.19902182e-01f,
  -2.47131243e-01f, 5.38648844e-01f, -1.50536343e-01f, -2.76746064e-01f, 1.26273841e-01f, -2.38076463e-01f, 1.40153453e-01f, 1.29349992e-01f, 1.98242858e-01f, 3.96131456e-01f,
  -1.94376752e-01f, 1.55195817e-01f, -2.65938967e-01f, -9.43691358e-02f, -4.02714670e-01f, -5.33251941e-01f, -2.79136121e-01f, 2.18998805e-01f, 3.97543699e-01f, 3.44128817e-01f,
  -6.00842126e-02f, 2.32215568e-01f, 1.28955960e-01f, 2.90339351e-01f, 1.61416113e-01f, -1.95358604e-01f, -2.79916734e-01f, 4.79921140e-02f, 1.07265443e-01f, -7.44756013e-02f,
  1.18055977e-01f, 2.16181770e-01f, 2.03560680e-01f, -3.99690926e-01f, 1.88725099e-01f, -1.12418178e-02f, -2.40799233e-01f, 2.57286638e-01f, 4.00680564e-02f, -7.20817089e-01f,
  -2.68962473e-01f, -2.05318436e-01f, -6.62301481e-03f, -4.45154637e-01f, 2.52202898e-01f, -7.04791188e-01f, 1.71962574e-01f, -7.36501664e-02f, 2.32589781e-01f, -5.06289124e-01f,
  -5.88963889e-02f, -2.15991914e-01f, -7.23361224e-02f, -2.97137350e-01f, -7.74649233e-02f, -4.30733114e-01f, -3.65866385e-02f, -5.32804430e-01f, -3.83757874e-02f, 3.14651608e-01f,
  3.49599831e-02f, 1.52785972e-01f, 1.14499450e-01f, -2.58868605e-01f, 5.97200207e-02f, 4.09857094e-01f, -2.81773597e-01f, -2.69273460e-01f, -4.60287988e-01f, 3.31312507e-01f,
  -2.65054196e-01f, -2.91298963e-02f, 3.03051740e-01f, 2.50404596e-01f, 2.81179309e-01f, -2.92407274e-01f, -1.05919413e-01f, -6.20633721e-01f, -4.09690648e-01f, -5.92162371e-01f,
  5.43953590e-02f, 2.25508928e-01f, -2.18877047e-01f, 2.21147075e-01f, 1.05119444e-01f, 2.17991456e-01f, -2.54711926e-01f, -5.49932182e-01f, 6.88747019e-02f, -5.61156690e-01f,
  4.58846278e-02f, -6.27012670e-01f, -4.79908854e-01f, -2.13090986e-01f, -4.92039412e-01f, 2.79071033e-01f, -1.49276063e-01f, -6.85521141e-02f, 2.46391147e-01f, 2.69085079e-01f,
  -1.81734383e-01f, -6.22243345e-01f, 1.82904765e-01f, -3.48541111e-01f, -3.55353802e-01f, 3.60038668e-01f, -5.09969406e-02f, 2.41165370e-01f, 8.61040428e-02f, -2.77124137e-01f,
  -3.14392418e-01f, -3.54169905e-01f, -1.56544566e-01f, -2.01187745e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.45819390e-01f, 2.10904703e-02f, 1.81476519e-01f, 7.14750066e-02f, -6.95268810e-02f, 5.67441620e-02f, 2.00881269e-02f, -1.30428687e-01f, -1.58950225e-01f, 7.94178620e-02f,
  -1.72705397e-01f, -1.04512818e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    