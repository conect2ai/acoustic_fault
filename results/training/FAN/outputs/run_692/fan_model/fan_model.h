/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.49256268e-01f, 2.83942938e-01f, -5.80668896e-02f, -7.17014670e-02f, -5.10144280e-03f, 1.92312121e-01f, 3.88565063e-01f, 8.82142261e-02f, -1.62879124e-01f, 3.94519232e-02f,
  2.03015227e-02f, -2.99103428e-02f, -1.24483239e-02f, -1.15405485e-01f, -2.56683794e-03f, 1.65500462e-01f, 1.44617399e-03f, -9.21784490e-02f, -1.20876834e-01f, -2.09111929e-01f,
  -4.79283966e-02f, -1.15816988e-01f, -1.95448369e-01f, -9.60986763e-02f, -1.34998485e-01f, 4.35421523e-03f, -3.39995772e-02f, -4.57907543e-02f, -3.61721106e-02f, -1.72954068e-01f,
  -1.63356036e-01f, -3.01875696e-02f, -1.12616658e-01f, -2.25778848e-01f, -6.40269220e-02f, -2.08922878e-01f, -3.89336012e-02f, -2.14676529e-01f, -2.91701127e-02f, -1.23459309e-01f,
  -1.49331778e-01f, -1.94281235e-01f, -5.11591248e-02f, -8.26597139e-02f, -7.18250349e-02f, -8.18609372e-02f, -1.34693205e-01f, -9.67023298e-02f, -1.43189237e-01f, -1.81181759e-01f,
  -1.30552217e-01f, -7.44657218e-02f, -7.06805065e-02f, -2.98343133e-02f, -4.05696081e-03f, -1.00441292e-01f, 3.00001283e-03f, -6.60198629e-02f, -1.07736960e-01f, -1.86411828e-01f,
  -2.35162694e-02f, 1.38641885e-02f, 1.16873160e-01f, 9.99696255e-02f, 1.25687972e-01f, 1.25138760e-01f, 1.44786850e-01f, 1.47603825e-01f, 2.39862651e-02f, 1.09881759e-01f,
  7.77051598e-02f, 1.30983084e-01f, 1.25134498e-01f, 1.13246791e-01f, 7.81792775e-02f, -2.96921167e-03f, 6.33894652e-02f, 1.29014611e-01f, 1.40511245e-01f, 3.46809141e-02f,
  1.64770514e-01f, 9.08368379e-02f, 2.74207667e-02f, 1.17051102e-01f, 7.63062760e-02f, 4.71884757e-02f, 1.03947870e-01f, 5.40440194e-02f, 4.92798313e-02f, 8.36250335e-02f,
  -6.05083890e-02f, -4.27864864e-02f, -1.28594130e-01f, -6.27815202e-02f, -1.80627704e-02f, -9.91962776e-02f, -3.70336100e-02f, -6.20323941e-02f, -4.23201695e-02f, 8.62009916e-03f,
  -1.56090315e-02f, -6.52157664e-02f, -6.76112100e-02f, -1.45701751e-01f, -5.64941727e-02f, -1.31298611e-02f, -4.12691273e-02f, -2.70890612e-02f, -1.43188283e-01f, -2.71249712e-02f,
  -8.34566504e-02f, 7.68664153e-03f, -5.87907247e-02f, 7.81287551e-02f, -7.66181424e-02f, -6.90787565e-03f, 4.98626381e-02f, -5.25229611e-02f, 3.63851972e-02f, 1.09759763e-01f,
  5.23463070e-01f, -1.46318689e-01f, 8.46235752e-02f, 1.64535925e-01f, 2.98419632e-02f, 1.84964970e-01f, 1.78343453e-03f, 1.28571451e-01f, 1.32098764e-01f, -7.33678341e-02f,
  2.23415866e-02f, 6.54753447e-02f, 3.87718976e-02f, -1.75626148e-02f, 1.74469844e-01f, -1.41570717e-01f, -1.29878849e-01f, 1.51871860e-01f, 1.38998970e-01f, 1.28712893e-01f,
  -1.60137445e-01f, 1.14004478e-01f, 2.47926190e-01f, 1.27571672e-01f, -4.37798984e-02f, 4.22775000e-02f, -1.28291860e-01f, -6.08208589e-02f, -1.53201863e-01f, -2.74939477e-01f,
  -2.53079124e-02f, 1.67497799e-01f, 9.26914141e-02f, 3.33377011e-02f, -5.29023893e-02f, 9.90442708e-02f, 9.15218443e-02f, 1.05598487e-01f, 1.78174935e-02f, 6.58352599e-02f,
  3.77434641e-02f, -2.49953046e-02f, 1.16999701e-01f, -3.83788720e-02f, 1.18129730e-01f, 6.15048371e-02f, 3.67531441e-02f, 1.53471321e-01f, 1.57611042e-01f, 2.86738621e-03f,
  -1.47563100e-01f, 9.14177150e-02f, 1.59613535e-01f, 4.09142189e-02f, 3.80518623e-02f, 1.09678581e-01f, 7.40854144e-02f, 1.11537792e-01f, 3.80603001e-02f, 8.35015848e-02f,
  -4.53522988e-03f, 4.23509665e-02f, 1.23998597e-02f, -6.55235432e-04f, 2.82309093e-02f, -3.82941812e-02f, -8.53651837e-02f, -5.99388517e-02f, 7.50545785e-02f, -5.28920405e-02f,
  4.02764417e-02f, -3.12180873e-02f, -6.11800067e-02f, -2.64997259e-02f, -1.54230390e-02f, -1.51391830e-02f, -1.79268625e-02f, -6.55379966e-02f, -2.13232096e-02f, -1.57041028e-02f,
  3.30084749e-02f, -3.47664841e-02f, -4.19811159e-02f, -8.29392597e-02f, -4.04322296e-02f, 4.51113097e-02f, 7.38773048e-02f, 2.72490401e-02f, -5.27679101e-02f, 5.99963591e-02f,
  3.61661948e-02f, 3.92116494e-02f, 2.18383018e-02f, 2.51636691e-02f, 3.18216234e-02f, 5.39184250e-02f, 9.88817513e-02f, -2.46232171e-02f, 4.26851921e-02f, 7.77608231e-02f,
  2.74302065e-02f, 1.66540742e-01f, -1.86647885e-02f, 5.73413558e-02f, 4.27985266e-02f, 9.43410397e-02f, -2.97135450e-02f, 4.09945250e-02f, -5.56025952e-02f, 1.09662451e-01f,
  -1.92467012e-02f, 1.75697714e-01f, 1.81807399e-01f, 9.14910585e-02f, -2.06500851e-03f, 8.31331387e-02f, -3.71521935e-02f, 1.07705124e-01f, 6.79218024e-02f, 8.29258859e-02f,
  -9.39586908e-02f, -3.59383933e-02f, -6.51882142e-02f, 1.54947210e-03f, -1.13122411e-01f, -3.42886835e-01f, -2.21451893e-01f, -2.20347106e-01f, -1.16543733e-02f, 1.35277975e-02f,
  -1.60236910e-01f, 6.54199794e-02f, 2.43634637e-02f, -6.79184273e-02f, -1.20990470e-01f, 3.09518576e-02f, 1.81487232e-01f, 1.49648599e-02f, -2.02699415e-02f, -4.87472378e-02f,
  -1.40535394e-02f, 5.15404083e-02f, 6.67772144e-02f, 1.16584316e-01f, 2.98255235e-01f, 1.62404150e-01f, 3.29926834e-02f, 2.89247781e-02f, 5.01236282e-02f, 4.80307758e-01f,
  9.14981887e-02f, 1.37882335e-02f, -1.02936193e-01f, -5.10936417e-02f, -1.56878334e-04f, 4.86655869e-02f, -1.56392436e-02f, 1.71462111e-02f, -9.01051611e-02f, -1.30883269e-02f,
  4.17649522e-02f, -4.50571179e-02f, 1.23638995e-02f, 6.80420846e-02f, 6.29437566e-02f, 5.44682853e-02f, -7.36835226e-02f, 5.29459352e-03f, -1.01155214e-01f, -3.35768610e-02f,
  7.80792013e-02f, 2.82617472e-03f, -9.34344009e-02f, -8.80461857e-02f, -1.30341232e-01f, -6.41990602e-02f, -5.40071214e-03f, 6.67410791e-02f, -4.56330292e-02f, 2.30740756e-01f,
  -4.32734378e-02f, 3.76771912e-02f, -3.22698466e-02f, 8.15628320e-02f, -6.12331554e-03f, 3.17336842e-02f, -1.62515454e-02f, 8.56102444e-04f, 7.25697279e-02f, 4.75827716e-02f,
  -5.17091230e-02f, -1.45166740e-03f, 3.43428515e-02f, -1.92914456e-02f, -2.16945447e-02f, 9.56478938e-02f, 1.26751652e-02f, -1.16443615e-02f, 2.33550705e-02f, 3.70708406e-02f,
  -3.57085913e-02f, 9.60933194e-02f, 3.45797129e-02f, 1.52333230e-01f, 2.33418345e-02f, -4.77984846e-02f, 9.42145661e-02f, -2.70626359e-02f, -3.58875953e-02f, 3.10910097e-03f,
  -8.43040124e-02f, -3.02816153e-01f, 8.03916156e-02f, 8.20451453e-02f, -1.77058543e-03f, -9.69422832e-02f, -1.90864783e-02f, 2.56059971e-02f, -1.14288637e-02f, -3.61636840e-02f,
  -7.61408582e-02f, -8.66438970e-02f, -3.67803909e-02f, -2.78754607e-02f, -1.09098315e-01f, -4.56655100e-02f, -3.93111371e-02f, 1.70643106e-02f, 1.57036334e-02f, -8.86288472e-03f,
  -1.50616407e-01f, -1.02124445e-01f, -1.52114287e-01f, 2.87698279e-03f, -1.35256881e-02f, -1.76917508e-01f, 1.75374914e-02f, -6.18754514e-02f, -1.83989257e-01f, 1.66490320e-02f,
  3.92761528e-01f, 1.50497586e-01f, 1.17365252e-02f, 1.91863671e-01f, 6.85579777e-02f, 1.64388567e-01f, 2.77325630e-01f, 4.60329503e-02f, 9.35557187e-02f, 1.34743392e-01f,
  -1.96873490e-02f, -1.18114553e-01f, -1.63050160e-01f, -1.57799944e-01f, -1.59998760e-01f, 1.06681138e-01f, 1.08885534e-01f, 1.34767219e-03f, -1.19306467e-01f, 2.16732677e-02f,
  -7.41567612e-02f, 2.62969900e-02f, -8.29927530e-03f, -6.73669055e-02f, 5.84735274e-02f, -1.02090389e-01f, -4.49735783e-02f, 1.07840784e-01f, -2.43368614e-02f, -3.44571774e-03f,
  1.15663610e-01f, 2.64388844e-02f, -1.80611715e-01f, -2.02669188e-01f, -8.00017416e-02f, -1.24049909e-01f, 5.98255843e-02f, -1.77491397e-01f, -7.86828473e-02f, -4.99532558e-02f,
  1.58694126e-02f, -5.63767254e-02f, -2.43035089e-02f, -1.56928346e-01f, -5.34613021e-02f, 5.00290655e-02f, -1.41575664e-01f, -1.67173773e-01f, -1.40768602e-01f, -3.82690728e-02f,
  -1.81669205e-01f, -4.81472202e-02f, 5.48086017e-02f, -1.78470761e-01f, -1.14398003e-01f, -5.52639291e-02f, -4.41700891e-02f, -1.89742386e-01f, -5.10422550e-02f, 9.28967446e-03f,
  -3.98221016e-02f, 3.39161903e-02f, -3.80246788e-02f, 1.38524935e-01f, -5.09422086e-03f, -1.55071067e-02f, 2.15754658e-02f, 4.74917851e-02f, -3.74739640e-03f, 3.49830911e-02f,
  -7.33286608e-03f, 7.32900724e-02f, -3.78344059e-02f, 8.82083401e-02f, 1.78005192e-02f, 5.06819934e-02f, 6.29997402e-02f, -3.21142599e-02f, 6.99885115e-02f, -3.50696556e-02f,
  2.51035932e-02f, 1.54418983e-02f, 5.29782586e-02f, -4.99802195e-02f, 8.77685696e-02f, 2.82414164e-02f, 1.10879309e-01f, -2.64852401e-02f, 8.82597864e-02f, 8.43111128e-02f,
  4.94624861e-02f, -2.27259502e-01f, 7.71890059e-02f, -2.66293231e-02f, -8.41732621e-02f, -7.64238182e-03f, 3.80344391e-02f, -6.02722950e-02f, -7.37554505e-02f, 2.48834528e-02f,
  -3.11169699e-02f, -2.72458177e-02f, -2.43122373e-02f, -2.16456428e-02f, 3.28149423e-02f, -3.12422160e-02f, -6.63871458e-03f, -5.65365590e-02f, -1.02346018e-01f, -2.85962392e-02f,
  -5.13289236e-02f, 6.34859875e-02f, 1.08283125e-01f, 2.04852112e-02f, 2.76683085e-02f, -1.86773315e-02f, -3.88454623e-03f, 1.66151654e-02f, 3.16676795e-02f, 1.50690302e-01f,
  5.78743160e-01f, -1.20571524e-01f, 4.40464526e-01f, 1.14878498e-01f, -1.99756771e-01f, -1.43073738e-01f, -1.15281992e-01f, -1.34041216e-02f, 4.45000129e-03f, -8.63566846e-02f,
  -1.56917974e-01f, -1.87045529e-01f, 3.09484731e-02f, -1.42308578e-01f, 3.43090296e-02f, -1.02357101e-02f, 8.94096121e-02f, 2.91107386e-01f, 1.61813349e-01f, -7.79159814e-02f,
  -2.12627307e-01f, 4.82669137e-02f, 9.98462066e-02f, 6.48143291e-02f, -1.64646238e-01f, -1.35014072e-01f, 6.22247830e-02f, -1.33643094e-02f, -2.02472702e-01f, -9.45421401e-03f,
  1.78338692e-01f, 1.79229096e-01f, -3.66558023e-02f, -7.87685141e-02f, 4.18315642e-02f, 1.51255161e-01f, -9.85510554e-03f, 7.49286264e-02f, -4.31733914e-02f, 1.03944585e-01f,
  -2.86391247e-02f, 4.84827310e-02f, 8.01093318e-03f, 1.60820708e-02f, 5.96789457e-02f, 5.58718257e-02f, 1.51533922e-02f, 2.01752007e-01f, 2.57089585e-02f, 2.88313464e-03f,
  -1.87075511e-01f, -7.25364266e-03f, 3.15803178e-02f, 1.01886347e-01f, 1.08563408e-01f, 7.57469609e-02f, 7.21412227e-02f, 1.42152309e-01f, 1.67137846e-01f, 3.26413363e-02f,
  -8.38677660e-02f, 3.07108392e-03f, -9.02729668e-03f, -5.18157780e-02f, -2.03066462e-04f, -2.16633994e-02f, -2.38713026e-02f, -1.15711458e-01f, -1.71249267e-02f, -4.56373580e-02f,
  -4.92024720e-02f, 3.70649099e-02f, 3.87897380e-02f, -5.49077913e-02f, -2.21731327e-02f, -4.18971553e-02f, -1.76057126e-02f, -1.05150968e-01f, 3.75919268e-02f, -6.03433363e-02f,
  4.22191918e-02f, 1.61112528e-02f, -6.07719459e-02f, 4.55526821e-02f, -8.12106282e-02f, 7.05830529e-02f, -2.74539404e-02f, -4.29112092e-02f, -1.66753121e-02f, -1.23939710e-04f,
  2.22518910e-02f, 6.82383180e-02f, 2.76392382e-02f, 6.84543028e-02f, 1.38210075e-03f, 1.98836811e-02f, 4.64218408e-02f, 5.61441435e-03f, 4.77640815e-02f, 7.56462291e-02f,
  -2.63894983e-02f, 8.22300240e-02f, 1.32646142e-02f, 9.75318719e-03f, 3.54088098e-02f, 2.62029748e-02f, -6.01993129e-02f, 3.86071280e-02f, 3.94831263e-02f, -5.49759157e-02f,
  -2.65531968e-02f, -2.32213568e-02f, 1.36130497e-01f, -2.05862541e-02f, -5.64996898e-02f, 6.51147068e-02f, 1.08170673e-01f, 1.84414834e-02f, 7.19617605e-02f, 6.62458763e-02f,
  -1.29129082e-01f, 9.14427266e-02f, 2.25240648e-01f, -6.78536445e-02f, -6.97284762e-04f, 2.63572522e-02f, 2.44963497e-01f, -5.75889088e-02f, -7.87201449e-02f, 2.91651059e-02f,
  -1.17284209e-01f, -3.17471832e-01f, -2.21347034e-01f, -1.90083161e-01f, -7.09842192e-03f, 6.20134100e-02f, 1.29963189e-01f, 6.22065105e-02f, -1.89047486e-01f, -1.82186827e-01f,
  -1.18015908e-01f, -5.47537468e-02f, -8.55158567e-02f, -2.69357916e-02f, 1.20406628e-01f, -8.03114772e-02f, 1.14440680e-01f, 1.49551332e-01f, 6.43924484e-03f, 7.55589455e-02f,
  2.79497020e-02f, 1.02329850e-01f, -9.25015435e-02f, -1.04833536e-01f, 1.05874659e-02f, -1.10505976e-01f, 3.12882364e-02f, 6.83393925e-02f, -2.04468495e-03f, 7.57866800e-02f,
  3.56272124e-02f, 4.36999723e-02f, -6.65732175e-02f, -4.86047193e-02f, 1.03258975e-01f, -5.04650511e-02f, -9.61961411e-03f, -3.59861813e-02f, -4.68804315e-02f, -2.86615063e-02f,
  -3.73295471e-02f, 2.10927557e-02f, 1.25680268e-01f, 1.07083373e-01f, 2.41101463e-03f, -1.97649486e-02f, 1.60781071e-01f, -2.98055373e-02f, 2.60140877e-02f, 1.75587222e-01f,
  -5.29026389e-02f, -3.53318453e-02f, 3.07203233e-02f, 5.84183000e-02f, 5.82244955e-02f, -6.76414445e-02f, 7.46743158e-02f, 4.28398475e-02f, -8.97585675e-02f, 8.08838010e-02f,
  -6.49726167e-02f, -4.33089770e-02f, 5.25058582e-02f, -3.80428298e-03f, -1.62888393e-02f, -1.02890478e-02f, 1.54782468e-02f, 2.79644947e-03f, -2.93602329e-02f, 4.98343930e-02f,
  -7.54546970e-02f, -4.34306189e-02f, -7.45306164e-02f, 1.36906039e-02f, 9.76439565e-03f, 5.97403906e-02f, 3.13063003e-02f, -2.95202788e-02f, -3.65107507e-02f, -4.62610312e-02f,
  -9.91359577e-02f, -1.04781300e-01f, 9.18825809e-03f, -2.14151628e-02f, -3.53170969e-02f, 4.20754105e-02f, -2.76262909e-02f, -1.24786347e-02f, -3.88496481e-02f, -1.75691154e-02f,
  -6.11039693e-04f, -3.29025416e-03f, -2.89088413e-02f, -9.68833081e-03f, -7.27839693e-02f, 1.53890802e-02f, -1.56883895e-02f, 2.92772036e-02f, 4.88990359e-02f, 7.16856420e-02f,
  2.51744241e-02f, 4.28055180e-03f, -7.73838013e-02f, -4.15076204e-02f, -1.00551853e-02f, -1.48544768e-02f, 3.59016545e-02f, 9.06660855e-02f, 3.16116773e-02f, 7.94796348e-02f,
  -8.92407522e-02f, 2.43690848e-01f, 1.05298035e-01f, -1.08980060e-01f, 4.80647311e-02f, 1.45817950e-01f, 2.94127584e-01f, 1.31833762e-01f, -1.11207627e-01f, 8.37918818e-02f,
  -2.05456503e-02f, -1.64355919e-01f, -1.63982734e-01f, -1.65136028e-02f, 1.11411832e-01f, 2.02681914e-01f, 1.26481652e-01f, 5.73570058e-02f, -1.04233138e-02f, 5.14621623e-02f,
  8.73199105e-02f, 3.73821221e-02f, -5.54546304e-02f, 4.77085263e-02f, 9.08074677e-02f, -2.07433283e-01f, 8.99298564e-02f, 1.02146633e-01f, 1.87631935e-01f, 1.34770930e-01f,
  -1.63869649e-01f, 2.51843631e-01f, -1.08975526e-02f, -7.18491077e-02f, 1.41835898e-01f, 7.67832845e-02f, 2.39986572e-02f, 4.86548916e-02f, 3.74041609e-02f, 9.20091048e-02f,
  1.34661451e-01f, 5.37244454e-02f, 5.07112183e-02f, 1.47464005e-02f, 1.94175374e-02f, 8.29858854e-02f, 7.01375306e-02f, 7.77884573e-02f, 8.32719952e-02f, 1.90376908e-01f,
  8.80064741e-02f, 8.81554037e-02f, 8.15213099e-02f, 1.33607432e-01f, 1.32440910e-01f, -7.67421443e-03f, 9.90301967e-02f, 1.23299532e-01f, 1.57205146e-02f, 4.87532560e-03f,
  -8.34376514e-02f, -1.60359845e-01f, -5.09082898e-02f, -1.59236621e-02f, -5.20745069e-02f, -8.01504999e-02f, -1.04552336e-01f, 1.20270960e-02f, -5.86792491e-02f, -1.31483048e-01f,
  -1.37816459e-01f, -1.56296249e-02f, -6.19623736e-02f, -2.02500504e-02f, -1.18866041e-01f, 8.74412339e-03f, -3.82064171e-02f, -7.53406212e-02f, -9.43985656e-02f, -1.21178580e-02f,
  -7.70130530e-02f, -8.41337293e-02f, -1.04181036e-01f, -3.30338429e-04f, -5.84117882e-02f, -9.39771309e-02f, -1.23026185e-01f, -1.14898659e-01f, -1.53140560e-01f, -1.64190009e-02f,
  -1.81471527e-01f, 4.55586538e-02f, -6.24456964e-02f, 1.45203680e-01f, 2.09795963e-02f, 5.69578446e-02f, 9.79099423e-02f, 3.52962501e-02f, 5.05275019e-02f, 7.43465573e-02f,
  1.16999917e-01f, 7.03192577e-02f, 1.25220176e-02f, 1.57173619e-01f, 1.08311556e-01f, 6.04429282e-02f, 8.03592429e-02f, 1.17031313e-01f, 1.50295096e-02f, 1.85636897e-02f,
  7.19743744e-02f, 2.90286075e-02f, -5.63212149e-02f, -4.20515910e-02f, -2.76955757e-02f, -1.56797782e-01f, -6.74815699e-02f, -1.14986584e-01f, -9.58694071e-02f, -6.03109263e-02f,
  7.65885636e-02f, -2.32289419e-01f, -1.06255732e-01f, 1.11977540e-01f, -2.85747787e-03f, -2.36746356e-01f, -4.48984653e-01f, -1.76542759e-01f, 4.41429615e-02f, -1.41854277e-02f,
  -1.59725491e-02f, 1.70425668e-01f, 2.38164067e-02f, 5.09787276e-02f, -2.77707517e-01f, -3.46537769e-01f, -2.79456466e-01f, -9.86379310e-02f, -1.51885003e-01f, -1.45970643e-01f,
  4.03944589e-02f, -2.75064935e-03f, 5.49772792e-02f, 6.11499995e-02f, 1.16463095e-01f, 1.29870132e-01f, 1.07412055e-01f, 2.76782829e-03f, -1.48440108e-01f, 3.89880352e-02f,
  -2.95579340e-02f, 5.17567359e-02f, -6.80563971e-02f, 3.01911291e-02f, 3.16726863e-02f, 1.23012187e-02f, -2.29796059e-02f, 3.10417637e-02f, 5.63083552e-02f, 6.13920875e-02f,
  1.04550399e-01f, 8.35665017e-02f, 8.15660357e-02f, 2.18558079e-03f, -1.01705091e-02f, 1.90546662e-02f, 4.63907383e-02f, -9.87512805e-03f, 5.73416688e-02f, 2.60532573e-02f,
  8.16072747e-02f, -1.02505814e-02f, -4.82790060e-02f, -2.27930266e-02f, 4.71643312e-03f, 5.86948730e-02f, -3.69727938e-03f, 3.76355909e-02f, 3.20195244e-03f, 2.41516065e-02f,
  -2.70736273e-02f, -4.72516939e-02f, 2.02297065e-02f, 4.96502630e-02f, 1.30893756e-02f, -2.29355153e-02f, 3.48678902e-02f, -2.68818755e-02f, 4.52641509e-02f, -2.70028543e-02f,
  -2.58246483e-03f, -4.01622131e-02f, -4.04931679e-02f, -3.05634346e-02f, -6.94792941e-02f, -1.79113983e-03f, -5.12751639e-02f, -5.82472458e-02f, 1.86665468e-02f, 4.32593329e-03f,
  6.16906285e-02f, -1.17493735e-03f, 5.43230288e-02f, -2.29267199e-02f, -2.61951815e-02f, 7.37948297e-03f, 2.94928104e-02f, 8.27667862e-03f, 3.13974539e-04f, -1.45298271e-02f,
  1.74258813e-01f, -1.10885814e-01f, 4.80853692e-02f, 4.80087735e-02f, -1.15118166e-02f, 9.13624763e-02f, -1.93134584e-02f, 5.48580177e-02f, 7.82810673e-02f, 1.41564105e-02f,
  -1.24116717e-02f, 1.40583776e-02f, -3.38208899e-02f, 7.96432719e-02f, 3.55970524e-02f, 2.00641062e-02f, 4.78754938e-02f, 1.21849980e-02f, -7.66088292e-02f, 9.74735022e-02f,
  -3.04882266e-02f, -1.25702128e-01f, -5.66430278e-02f, -9.87783521e-02f, 4.55984361e-02f, -3.33038233e-02f, -7.13234842e-02f, 7.84798712e-02f, -1.61574438e-01f, -3.64241078e-02f,
  1.86355427e-01f, 1.37179330e-01f, 2.65759498e-01f, 3.69493246e-01f, 3.99035275e-01f, 2.48015061e-01f, 4.20604795e-02f, 1.55896887e-01f, 1.34882197e-01f, 9.81296450e-02f,
  -9.68464091e-03f, 2.10462958e-01f, 2.35327095e-01f, 2.12526068e-01f, 7.15378448e-02f, 1.75958693e-01f, 2.61783689e-01f, 3.18311244e-01f, 2.51133442e-01f, 2.03108832e-01f,
  3.02079946e-01f, 2.93676168e-01f, 2.39808246e-01f, 1.72444731e-01f, 1.78396776e-01f, 2.94133991e-01f, 1.76827103e-01f, 1.68140888e-01f, 2.49868944e-01f, 3.08741271e-01f,
  4.26668227e-02f, 1.12749688e-01f, 1.42831773e-01f, 1.65512830e-01f, 1.50669396e-01f, 2.35793330e-02f, 1.57837514e-02f, 1.33802876e-01f, 2.95066852e-02f, 9.61119831e-02f,
  1.23768173e-01f, 1.73393145e-01f, 7.92403817e-02f, 6.41399026e-02f, 1.97317228e-01f, 1.33808076e-01f, 6.36246428e-02f, 2.35801175e-01f, 4.64891717e-02f, 9.78102162e-02f,
  1.20054960e-01f, 1.07527882e-01f, 1.53122708e-01f, 5.53023964e-02f, 3.30819339e-02f, 1.18320554e-01f, 4.55697402e-02f, 1.60000116e-01f, 1.29807636e-01f, -6.91093178e-03f,
  -1.12023644e-01f, -6.43360168e-02f, 9.69127417e-02f, -1.97740048e-02f, 5.20807179e-03f, -1.73747372e-02f, 5.42445183e-02f, 6.66362792e-03f, 2.62021665e-02f, 2.37541217e-02f,
  -2.80805137e-02f, -1.14281736e-02f, -4.80773486e-02f, -8.16864986e-03f, 3.15501317e-02f, 1.28076375e-01f, -9.30026919e-03f, -3.00130825e-02f, -1.18286073e-01f, -3.24681774e-02f,
  -5.69313541e-02f, -3.56656648e-02f, 2.57060900e-02f, -9.29904636e-03f, 9.49362591e-02f, 5.20228408e-02f, -9.38247237e-03f, -7.15479553e-02f, 7.19586760e-02f, 1.70757454e-02f,
  -2.76218038e-02f, 8.16924050e-02f, 7.38542676e-02f, 1.01178572e-01f, 1.08911626e-01f, 5.04763275e-02f, -5.23760263e-03f, 1.74917188e-02f, 5.35760261e-02f, 1.55661955e-01f,
  5.67057692e-02f, 6.22456335e-02f, 9.48705599e-02f, 5.78676313e-02f, 1.37715742e-01f, 9.44880694e-02f, 7.20811784e-02f, 1.95813745e-01f, 1.14120267e-01f, 2.56348941e-02f,
  8.60023201e-02f, 6.03857003e-02f, -1.12659512e-02f, -5.68521582e-02f, 7.20304921e-02f, 1.98086053e-02f, 6.58713728e-02f, 4.95841093e-02f, 4.74205315e-02f, -4.08238731e-02f,
  -1.87044412e-01f, -1.15202516e-02f, -1.83541611e-01f, -3.45508724e-01f, -1.42570183e-01f, 1.13329263e-02f, 1.03840001e-01f, 7.38489032e-02f, -1.65308177e-01f, 1.82457659e-02f,
  1.29886894e-02f, -9.46437940e-02f, -5.17470054e-02f, -2.02403963e-02f, 5.09030074e-02f, 1.61815155e-02f, 2.54351031e-02f, -3.51126306e-02f, -8.16465020e-02f, -1.27019897e-01f,
  -7.85833523e-02f, -1.44805625e-01f, -3.34517797e-03f, -3.36098410e-02f, -9.73863602e-02f, -9.14726257e-02f, -1.47332186e-02f, -1.08292520e-01f, 1.40539795e-01f, -1.68665007e-01f,
  -1.00413337e-01f, -7.98907410e-03f, 1.54224917e-01f, -1.27041433e-02f, 6.23008795e-02f, 1.40943574e-02f, -2.53307894e-02f, 1.70820922e-01f, 5.98151935e-03f, 5.05149104e-02f,
  -1.13268394e-03f, 1.11623202e-03f, 1.01086246e-02f, -6.59504756e-02f, -3.29311937e-02f, 1.13033531e-02f, -3.55025083e-02f, 3.71711403e-02f, 2.46058535e-02f, 1.26408413e-01f,
  -8.73396397e-02f, -3.68974470e-02f, 8.40311274e-02f, 1.13152906e-01f, 2.06154566e-02f, -1.84044652e-02f, 1.32054687e-01f, 1.50111154e-01f, 2.00293548e-02f, -1.38750961e-02f,
  7.52135590e-02f, 2.12641824e-02f, 4.16753581e-03f, -2.09641848e-02f, 3.19308834e-03f, 7.86491409e-02f, 4.27526981e-02f, -4.20692451e-02f, -4.07950516e-04f, 8.52122381e-02f,
  2.19655260e-02f, -2.01390288e-03f, -3.81005220e-02f, 4.12540138e-02f, -6.30390793e-02f, -1.64163839e-02f, 7.94290192e-03f, 6.21009618e-03f, 4.95385677e-02f, -9.68739856e-04f,
  -4.11944687e-02f, -3.62193473e-02f, -3.90882269e-02f, 8.00783411e-02f, 1.99566074e-02f, -3.82980630e-02f, -3.20981480e-02f, -4.20367122e-02f, 7.68759195e-03f, -3.40280458e-02f,
  2.80103330e-02f, 2.90172100e-01f, 9.54224914e-02f, 6.32708669e-02f, 7.58673027e-02f, 1.37631148e-01f, 1.19863048e-01f, 1.15589082e-01f, 8.50479826e-02f, 3.60488817e-02f,
  9.90767777e-03f, 2.89924238e-02f, 8.68770480e-02f, 1.49792537e-01f, 7.34751970e-02f, 1.69946495e-02f, 9.85563174e-02f, 3.57647659e-03f, 3.75055037e-02f, 8.68249908e-02f,
  1.03763647e-01f, 1.14437461e-01f, 1.84152335e-01f, 1.93497181e-01f, 1.01630181e-01f, 1.31315231e-01f, 2.66643703e-01f, 1.22536041e-01f, 9.32946429e-02f, 2.26629153e-01f,
  3.62929963e-02f, 1.44490629e-01f, -2.57792119e-02f, 1.71926826e-01f, -1.67841874e-02f, -4.88711223e-02f, 1.15170991e-02f, -1.15650594e-01f, 1.30939662e-01f, 1.04445241e-01f,
  -1.39593244e-01f, -1.38678148e-01f, -1.57309741e-01f, -1.73051223e-01f, -1.79684848e-01f, 2.23259404e-01f, 2.59855568e-01f, 5.78110144e-02f, -2.52080411e-01f, -1.20645814e-01f,
  9.46807191e-02f, 1.01384699e-01f, 5.80055602e-02f, -9.57638845e-02f, 1.53216049e-01f, 2.46728268e-02f, 1.04979590e-01f, 3.26580331e-02f, -5.11379689e-02f, 3.11989367e-01f,
  -8.34520161e-02f, 8.29621404e-02f, -5.62816784e-02f, 1.06791325e-01f, 1.53354183e-02f, 6.37118444e-02f, -5.66815492e-03f, 9.76069793e-02f, 8.36701915e-02f, 3.88893038e-02f,
  1.32971453e-02f, 7.75700361e-02f, -5.21511538e-03f, -2.22789701e-02f, 7.01055676e-02f, -5.20042516e-02f, 3.24419290e-02f, 1.05212376e-01f, 5.63414656e-02f, -7.60929435e-02f,
  7.79121667e-02f, 9.71899256e-02f, 5.80819137e-02f, -5.80888242e-02f, -3.42847705e-02f, -4.66200635e-02f, -3.83862816e-02f, -3.91672663e-02f, -5.05276285e-02f, 1.71708062e-01f,
  1.15878470e-01f, -1.12421758e-01f, -8.38308111e-02f, -7.26799518e-02f, -5.25250360e-02f, 2.00078264e-02f, 3.71326804e-02f, -3.01298476e-03f, 1.11177200e-02f, -2.32225992e-02f,
  -1.47994736e-03f, -7.82057941e-02f, -4.21067886e-02f, -1.15531683e-02f, 1.74527115e-03f, -1.09417783e-02f, 3.74917407e-04f, 6.61179051e-03f, -3.97851095e-02f, 2.75344849e-02f,
  -4.65984829e-02f, -5.42628206e-02f, 4.13672589e-02f, -1.04464896e-01f, 1.56556461e-02f, -5.85604906e-02f, -7.40665719e-02f, -1.07787654e-01f, 5.26767969e-03f, 2.43229419e-02f,
  -2.81989039e-03f, -1.22292913e-01f, 1.18960209e-01f, 7.71404207e-02f, 1.09515004e-01f, 5.61351217e-02f, 1.14214391e-01f, 8.49475637e-02f, 1.23686388e-01f, 1.49005903e-02f,
  -1.05569446e-02f, 2.28296295e-02f, -1.69673294e-03f, -5.65215126e-02f, 1.84343196e-02f, 2.45445613e-02f, 1.93290617e-02f, 3.49604748e-02f, -1.34060401e-02f, 6.97039589e-02f,
  1.00429714e-01f, -3.47692296e-02f, -2.41068173e-02f, -5.78797609e-02f, -4.59247045e-02f, -7.11974576e-02f, -9.33614448e-02f, 4.35980111e-02f, -1.90319687e-01f, 5.44358604e-02f,
  5.00684619e-01f, 2.36117303e-01f, 1.46290541e-01f, 3.76953222e-02f, -2.23042190e-01f, -5.59764318e-02f, -3.43045257e-02f, 4.63329591e-02f, -1.65380239e-02f, -5.89226224e-02f,
  2.10435130e-02f, -3.60348895e-02f, -5.14541660e-03f, -8.53621885e-02f, 6.88824505e-02f, -1.12944141e-01f, -1.01477943e-01f, 4.75814976e-02f, -6.63267374e-02f, -1.79320365e-01f,
  -2.03130528e-01f, -1.18509233e-01f, 1.39298633e-01f, 4.45158258e-02f, -1.05155498e-01f, -2.18230665e-01f, -1.24926746e-01f, -1.31886944e-01f, -1.18529320e-01f, -1.00705437e-01f,
  -8.62233061e-03f, 2.52792746e-01f, -1.23902224e-01f, -5.10424050e-03f, 5.88753028e-03f, 1.18642151e-01f, 1.26927840e-02f, -1.77522898e-02f, 3.50124687e-02f, 7.18029914e-04f,
  4.85770404e-02f, 2.80842353e-02f, 5.92349991e-02f, -2.46886332e-02f, -2.19655354e-02f, -9.43596102e-03f, 6.19415119e-02f, 5.90089001e-02f, 7.63428286e-02f, 5.11707887e-02f,
  -1.55637721e-02f, 4.75758724e-02f, 1.40884072e-01f, -7.71771222e-02f, 5.70932068e-02f, -2.83958483e-02f, -3.22739370e-02f, 9.03895721e-02f, 2.17288863e-02f, -3.58979567e-03f,
  5.57920672e-02f, -7.93640986e-02f, -6.87169731e-02f, -4.27940562e-02f, -6.61706254e-02f, -6.99681714e-02f, -1.19852986e-04f, -1.40536383e-01f, -6.17158674e-02f, -9.21932161e-02f,
  -1.03513859e-01f, -2.03603581e-02f, -1.13829173e-01f, -1.80606861e-02f, -1.29130960e-01f, 2.54014935e-02f, -1.26068611e-02f, -7.53591955e-02f, -7.04520345e-02f, 4.74352650e-02f,
  -6.17386401e-02f, -5.56334667e-02f, -5.83173409e-02f, -1.06358148e-01f, -6.55889278e-03f, -1.84157398e-02f, -9.97321680e-02f, -8.19363296e-02f, -5.32215163e-02f, -7.48012448e-03f,
  -1.55342996e-01f, 7.96197653e-02f, 3.50211770e-03f, 7.61513561e-02f, -2.08591837e-02f, -4.31372970e-02f, -5.19732535e-02f, 4.46818545e-02f, -1.15535380e-02f, 4.28829379e-02f,
  -1.71570722e-02f, 3.35691236e-02f, 2.09103618e-02f, -8.19745436e-02f, -1.44102335e-01f, -1.49995758e-04f, -8.12413096e-02f, -6.48306981e-02f, 2.31668148e-02f, 8.35762545e-03f,
  -6.59662113e-02f, -8.65897909e-02f, -5.49086444e-02f, -7.54541997e-03f, -6.20783940e-02f, -5.47390990e-02f, -2.45219525e-02f, -4.23847213e-02f, 5.12186112e-03f, -1.19791910e-01f,
  4.75319505e-01f, -4.46507007e-01f, 5.74097596e-02f, -5.13937026e-02f, -1.89724609e-01f, -4.06426378e-02f, -2.17248350e-01f, 1.49831586e-02f, 1.38786972e-01f, -2.20483169e-01f,
  -2.28218168e-01f, -4.56922352e-02f, -3.55008654e-02f, -4.00357582e-02f, 1.61864132e-01f, -1.84052423e-01f, -1.33119121e-01f, 2.46815503e-01f, 3.83972675e-01f, 1.59907028e-01f,
  -5.20241819e-02f, 5.55923441e-03f, 2.92019337e-01f, 2.04074010e-01f, -1.96261793e-01f, 1.72597468e-02f, -1.45079747e-01f, -1.16778068e-01f, -1.61719784e-01f, -1.65764168e-01f,
  2.28441949e-03f, 5.37015721e-02f, 5.16984016e-02f, -8.84103477e-02f, -1.44716380e-02f, -1.60779466e-03f, 5.52875362e-02f, -2.11497545e-02f, -3.28363292e-03f, 2.20932066e-02f,
  -6.45457283e-02f, 4.62261662e-02f, -5.69785945e-02f, 2.50723176e-02f, 5.21642603e-02f, 7.30503947e-02f, 9.05360561e-03f, 2.16935910e-02f, -2.89056264e-02f, -2.39572115e-02f,
  -1.25230223e-01f, -7.94279575e-02f, -5.31604588e-02f, -3.74181159e-02f, 7.04413978e-03f, 6.89115524e-02f, 4.27600509e-03f, 8.55087265e-02f, -3.44456144e-04f, -8.40232074e-02f,
  4.05389667e-02f, -3.97237279e-02f, 7.87470192e-02f, -6.39108121e-02f, -2.78301630e-02f, -5.90059943e-02f, 1.83782373e-02f, -7.70239979e-02f, 1.87525142e-03f, 5.18551134e-02f,
  2.68961657e-02f, -6.63186014e-02f, -6.34718984e-02f, 1.56382360e-02f, -6.96325377e-02f, 7.00777536e-03f, -1.28520345e-02f, -3.44985537e-02f, -1.70493517e-02f, 4.57289591e-02f,
  -1.44018214e-02f, 1.92744713e-02f, -2.04932038e-02f, 6.13733716e-02f, -3.04436218e-02f, -3.27391773e-02f, 7.88404793e-03f, -2.46629007e-02f, 4.92534004e-02f, -4.63737249e-02f,
  -6.41510338e-02f, 2.39369143e-02f, -1.89616927e-03f, 6.71311691e-02f, 4.24642824e-02f, -1.20548587e-02f, -3.54244076e-02f, -2.11885329e-02f, -4.60525416e-02f, 6.17312221e-03f,
  5.15940674e-02f, 1.04914814e-01f, -3.23044956e-02f, 1.24133676e-02f, 1.01750299e-01f, 1.00171529e-02f, -9.33858827e-02f, -5.05924709e-02f, -1.72042958e-02f, -7.64255673e-02f,
  3.67018231e-03f, -3.03714201e-02f, 1.01616435e-01f, -9.40152630e-02f, 3.13135609e-02f, 1.49233297e-01f, -6.00492768e-02f, 8.61058831e-02f, 1.28070384e-01f, -1.38873875e-01f,
  -3.99498403e-01f, -4.08139646e-01f, -1.58100411e-01f, -1.39369130e-01f, -5.47162257e-02f, 1.02719277e-01f, 6.77259034e-03f, 4.56071123e-02f, -2.59200912e-02f, -1.92552999e-01f,
  -1.77329242e-01f, -9.22949761e-02f, 9.32716485e-03f, -5.28958775e-02f, 1.04749970e-01f, -1.13996916e-01f, -1.58082753e-01f, 8.08236971e-02f, 1.92204684e-01f, 1.47035956e-01f,
  -7.81981498e-02f, -1.49465084e-01f, -1.84921309e-01f, -7.22554922e-02f, -2.95490801e-01f, 5.67327160e-03f, -2.86533564e-01f, -1.92449450e-01f, -1.79456741e-01f, -4.55509871e-01f,
  -1.30975321e-01f, -3.88200253e-01f, 9.67573002e-02f, -1.74656674e-01f, -1.89218178e-01f, -1.38236225e-01f, -4.96009365e-02f, -2.28397697e-01f, -1.51156679e-01f, -8.99624303e-02f,
  -1.73101023e-01f, -1.97742000e-01f, -1.58820063e-01f, -9.84193683e-02f, -1.51157632e-01f, -6.95737451e-02f, -2.01298386e-01f, -1.51374131e-01f, 1.53951431e-02f, -1.84898496e-01f,
  -1.55402839e-01f, -1.04111083e-01f, -6.86414763e-02f, -5.70214167e-03f, -6.89313486e-02f, -2.51218788e-02f, -1.88126460e-01f, -1.70055449e-01f, -1.13263570e-01f, -1.69868857e-01f,
  1.33666620e-01f, 2.10060887e-02f, 1.08108558e-01f, 7.52688572e-02f, 6.74328506e-02f, 6.94783926e-02f, 8.41130987e-02f, 1.26538217e-01f, 1.15406692e-01f, 7.25584850e-02f,
  1.11563906e-01f, 1.37115240e-01f, 6.36830851e-02f, 5.20145297e-02f, 1.53301105e-01f, 3.30155753e-02f, 9.90485922e-02f, 1.34133086e-01f, 1.55333668e-01f, 1.31798670e-01f,
  1.33303359e-01f, 1.02886453e-01f, 7.45776668e-02f, 8.09184462e-02f, 3.79393324e-02f, 1.66649625e-01f, 1.16545312e-01f, 3.70596685e-02f, 4.48169336e-02f, 3.29046063e-02f,
  1.18332021e-01f, 6.73876107e-02f, -9.55949575e-02f, -3.98459546e-02f, -5.72743006e-02f, -6.25212267e-02f, -7.03935772e-02f, -8.79955515e-02f, -1.03439786e-01f, -8.93354490e-02f,
  -5.50811924e-02f, -1.36016011e-01f, -1.42595157e-01f, -7.19975084e-02f, -8.79569072e-03f, 4.35515633e-03f, -6.51583970e-02f, -7.39193638e-04f, -7.17687681e-02f, -3.72411609e-02f,
  -9.34602097e-02f, 9.66601744e-02f, 8.20623115e-02f, -4.45460454e-02f, -6.03110418e-02f, 2.79082414e-02f, 5.24420030e-02f, 8.96951482e-02f, 2.28590723e-02f, 1.95303354e-02f,
  -4.23552394e-01f, 2.59548128e-01f, 1.65612698e-01f, -9.60990861e-02f, 1.57656640e-01f, 2.03226909e-01f, 2.37036601e-01f, -1.03010193e-01f, -3.54199931e-02f, -1.66245960e-02f,
  9.27469656e-02f, 6.97796345e-02f, 1.21220522e-01f, 1.01422958e-01f, 1.19980745e-01f, 1.72064081e-01f, 2.05068365e-01f, -2.74820323e-03f, 2.16377918e-02f, 1.69242490e-02f,
  -3.67660224e-02f, -9.66581553e-02f, -5.70838824e-02f, 2.09844150e-02f, 5.03089093e-02f, 9.37718898e-03f, 5.88529976e-03f, 8.92209485e-02f, 1.40603021e-01f, 2.61887342e-01f,
  1.13610223e-01f, 4.75580655e-02f, 5.21706678e-02f, 6.93298429e-02f, 9.82421190e-02f, 2.42535397e-02f, 1.22097388e-01f, 7.89725333e-02f, 8.24327487e-03f, 1.16620690e-01f,
  1.01799853e-01f, 4.81548905e-02f, 1.68091938e-01f, 7.82744363e-02f, 5.13066053e-02f, 3.30890529e-02f, -5.93053130e-03f, 1.38452470e-01f, 4.12944192e-03f, 1.33927688e-01f,
  1.99899837e-01f, 1.96233928e-01f, 1.29563361e-01f, 1.52970523e-01f, 1.10868484e-01f, 3.32836658e-02f, 1.65139392e-01f, 1.74879432e-01f, 3.08451504e-02f, -6.73793852e-02f,
  -7.89481029e-02f, -3.81175093e-02f, -8.17931369e-02f, -1.96011424e-01f, -1.18108623e-01f, -1.08484045e-01f, 1.61448363e-02f, -5.91323338e-02f, -4.31960598e-02f, -1.04453512e-01f,
  -3.59277762e-02f, -9.58389118e-02f, -1.26004562e-01f, -7.65875503e-02f, -4.00174409e-02f, -3.35805155e-02f, -9.62108597e-02f, -1.02872849e-01f, -6.94854334e-02f, -7.43003413e-02f,
  -8.08829740e-02f, -6.31033704e-02f, -2.59521045e-02f, -2.25770604e-02f, -9.25108939e-02f, -1.01832174e-01f, -2.05146953e-01f, -1.18477285e-01f, -5.83009869e-02f, -6.55730069e-02f,
  -3.60178351e-02f, 2.62859583e-01f, 6.57409430e-02f, 1.36807576e-01f, 1.47971466e-01f, 1.18884340e-01f, 1.19213335e-01f, 1.45859793e-01f, 1.77707419e-01f, 4.80897464e-02f,
  1.20427340e-01f, 1.17614157e-01f, 1.49636477e-01f, 1.66133180e-01f, 5.70951626e-02f, 8.60334784e-02f, 1.57488242e-01f, 8.33201483e-02f, 1.54979318e-01f, 1.31352723e-01f,
  1.70137271e-01f, -1.15126409e-02f, -3.80360596e-02f, 8.17188844e-02f, 1.26265660e-01f, -1.41463391e-02f, 9.28156227e-02f, 6.42199516e-02f, 8.60517472e-03f, -7.21632093e-02f,
  2.56116867e-01f, 1.81291044e-01f, 5.12617677e-02f, 5.92716262e-02f, 7.74453208e-02f, 2.85055079e-02f, 2.65630931e-01f, -1.11019157e-01f, -6.94912747e-02f, 1.69471562e-01f,
  -6.17331304e-02f, -2.28630424e-01f, -1.26757070e-01f, -2.18342349e-01f, -1.04277171e-01f, 1.57776356e-01f, 1.99505985e-01f, 1.82099473e-02f, -1.48356482e-01f, -1.63332373e-01f,
  4.53240201e-02f, 1.25947684e-01f, -1.84067488e-02f, -5.87831140e-02f, 3.91041525e-02f, -8.06911364e-02f, 1.33648634e-01f, 1.57851756e-01f, -9.68538038e-03f, 1.65161073e-01f,
  1.41383797e-01f, 2.91837696e-02f, -1.73861682e-01f, -1.62326708e-01f, -2.32187156e-02f, -9.65162292e-02f, -3.69615816e-02f, 2.83718482e-02f, -1.83169350e-01f, -1.04283720e-01f,
  -4.88776676e-02f, -1.39756938e-02f, -1.14738621e-01f, 3.50514352e-02f, -7.91164190e-02f, -7.91010410e-02f, -1.91290490e-02f, -8.58843625e-02f, -1.36129290e-01f, -2.06687637e-02f,
  -1.13063514e-01f, -1.93436258e-02f, 6.38282001e-02f, -1.46075085e-01f, -8.01613256e-02f, -1.04995020e-01f, -1.05521448e-01f, -4.77316454e-02f, -1.28149122e-01f, 1.02121189e-01f,
  -1.04796968e-01f, 6.73205256e-02f, 1.02382280e-01f, 1.00462578e-01f, 5.25343344e-02f, 2.54213903e-02f, 4.78381217e-02f, 9.71411318e-02f, 7.34418482e-02f, 1.70251559e-02f,
  -3.92795429e-02f, 1.16776768e-02f, 1.92483403e-02f, 3.49015817e-02f, -6.25383332e-02f, 3.76780219e-02f, -1.77592728e-02f, -3.99243832e-02f, -2.09304150e-02f, 6.43874556e-02f,
  6.34620860e-02f, 7.46068135e-02f, -1.08352827e-03f, 5.23223504e-02f, -5.44226281e-02f, -3.50219634e-04f, -2.81276666e-02f, -2.60357447e-02f, 2.00054012e-02f, 5.30551113e-02f,
  -5.22009376e-03f, -2.90621579e-01f, 2.09199134e-02f, 7.09574148e-02f, -5.97911775e-02f, -8.86463001e-02f, 1.28931515e-02f, 9.70459916e-03f, -5.26859798e-02f, -1.09825455e-01f,
  -2.91569196e-02f, -3.75159085e-02f, -5.98693788e-02f, 2.59851459e-02f, 3.39191481e-02f, -3.10379919e-02f, 9.77563784e-02f, -2.89745275e-02f, -9.16224495e-02f, -2.14164536e-02f,
  2.51091085e-03f, 5.73498979e-02f, 2.24823356e-02f, 7.78459907e-02f, -6.89669922e-02f, 3.65145206e-02f, -4.10246775e-02f, 4.58118506e-02f, 5.81759810e-02f, 9.21811163e-02f,
  -4.53380525e-01f, -9.09739435e-02f, -2.72066057e-01f, -1.63847566e-01f, -9.67873707e-02f, 9.11068842e-02f, -8.73186588e-02f, -1.26786148e-02f, 9.13736448e-02f, 6.50569126e-02f,
  -1.77154616e-02f, 1.23232014e-01f, 1.36154249e-01f, 3.51929404e-02f, 3.62430923e-02f, -6.83498532e-02f, -1.27088442e-01f, -1.51523843e-01f, 1.13382615e-01f, 1.78580016e-01f,
  7.50503093e-02f, -6.10232055e-02f, -7.14568645e-02f, -1.53541900e-02f, -1.09827938e-02f, 5.39666526e-02f, -3.08710709e-02f, -1.73092112e-01f, 6.39469922e-02f, -8.10019821e-02f,
  -1.82647660e-01f, -1.52283683e-01f, 1.34675547e-01f, 8.60549137e-02f, -1.21406086e-01f, -8.31283629e-02f, -4.14403751e-02f, -5.15246689e-02f, -3.05490717e-02f, 2.07017809e-02f,
  -5.63851446e-02f, -3.29223834e-02f, -7.63211772e-03f, -6.43515065e-02f, -6.42139912e-02f, 5.10719530e-02f, -6.61211312e-02f, -4.69621159e-02f, -1.00989051e-01f, 5.96481794e-03f,
  7.79268742e-02f, -6.06402345e-02f, -1.88296407e-01f, -6.15477711e-02f, -5.04513495e-02f, -2.85548475e-02f, -9.43619162e-02f, -9.46885049e-02f, -2.97767390e-02f, -1.14588127e-01f,
  1.38327315e-01f, -5.91744408e-02f, -1.42961787e-02f, 1.59550589e-02f, 1.26266452e-02f, 4.21516821e-02f, -1.10436156e-02f, -1.16963144e-02f, 5.70955314e-02f, -2.08805613e-02f,
  4.90852408e-02f, 5.19236131e-03f, 6.69983029e-02f, 2.31953096e-02f, 4.18899022e-02f, -6.07518889e-02f, 3.16544548e-02f, 4.57975594e-03f, 3.02551072e-02f, 1.07400315e-02f,
  -2.48538367e-02f, -1.59519110e-02f, -9.62925404e-02f, 1.40898414e-02f, -1.35670183e-02f, 6.43069893e-02f, 5.05778342e-02f, 2.25165533e-03f, 1.00513928e-01f, 2.47127209e-02f,
  3.28100473e-02f, -6.22275621e-02f, 4.73853759e-03f, 2.35462543e-02f, -4.22518849e-02f, 2.71405131e-02f, 5.31413406e-02f, 7.71032125e-02f, -2.79606748e-02f, -2.14061886e-02f,
  -6.89081177e-02f, -8.29322636e-03f, -8.15114230e-02f, -7.45781586e-02f, -2.42502205e-02f, 1.78518426e-02f, -3.99021357e-02f, -1.75073289e-03f, 6.99185133e-02f, -1.77709647e-02f,
  -6.23375997e-02f, -5.05155101e-02f, 6.17885031e-03f, 8.06252882e-02f, -1.10714799e-02f, 5.10291616e-03f, -7.72073865e-02f, 5.28296307e-02f, 1.92245319e-02f, 5.87874725e-02f,
  -1.20703466e-01f, 1.77233189e-01f, 1.31488129e-01f, -3.26694965e-01f, -6.59825131e-02f, 2.32386321e-01f, 3.37535053e-01f, 1.86651647e-01f, -1.01085246e-01f, 8.52926373e-02f,
  -1.14182189e-01f, -2.49209732e-01f, -2.28739262e-01f, -5.43465763e-02f, 1.03822857e-01f, 1.12011597e-01f, -6.90525696e-02f, -1.76663697e-01f, -5.86959347e-02f, 1.38187408e-01f,
  -7.60454312e-02f, 1.72072947e-02f, -2.58067437e-02f, -3.20945145e-03f, -3.48044303e-03f, -2.66654283e-01f, 8.52225944e-02f, -3.54713239e-02f, 1.11206964e-01f, -2.62192599e-02f,
  3.70940613e-03f, 2.22599044e-01f, -1.15030058e-01f, -3.89537774e-02f, -9.84342918e-02f, -4.47852574e-02f, -1.94621421e-02f, -9.57821384e-02f, -9.11531001e-02f, 4.19829488e-02f,
  -9.01948810e-02f, -3.39101702e-02f, -2.79333722e-02f, 1.58581045e-02f, 6.11281535e-03f, 1.19456381e-01f, -1.36977562e-03f, 5.23940101e-02f, 2.60010827e-02f, 8.65274668e-02f,
  -1.17544949e-01f, 3.76023389e-02f, 1.19208522e-01f, 8.10201392e-02f, 1.16323188e-01f, -8.14354196e-02f, 2.79523395e-02f, 2.16554236e-02f, 1.65556058e-01f, 5.05306050e-02f,
  -1.43468780e-02f, -3.34351882e-02f, 5.18344194e-02f, 5.03300019e-02f, 1.14222653e-02f, -9.01161134e-02f, 4.80454694e-03f, -1.49285588e-02f, 5.62013313e-03f, 2.78771389e-02f,
  3.50096030e-03f, 5.63592613e-02f, 7.75832171e-03f, 3.71320397e-02f, -1.09220937e-01f, 5.12623675e-02f, -4.16171886e-02f, 2.43818462e-02f, 2.08384339e-02f, 7.59297088e-02f,
  7.52383610e-04f, 4.61233407e-02f, -4.57984284e-02f, -2.10240651e-02f, 1.96603616e-03f, -4.24260646e-02f, -3.11310925e-02f, -2.42326949e-02f, -3.11070457e-02f, 2.22743601e-02f,
  -1.70880929e-01f, 3.02586928e-02f, -6.12569451e-02f, 6.10811263e-03f, 2.18791980e-02f, 4.36223671e-02f, -4.58477102e-02f, 9.40874685e-03f, 2.78020483e-02f, -2.80817021e-02f,
  7.19724596e-02f, -1.90756135e-02f, 2.18851753e-02f, 9.62923244e-02f, 1.66575462e-02f, 1.41983572e-02f, -4.35203612e-02f, -8.95775408e-02f, -3.00130378e-02f, 1.14929816e-02f,
  -3.20129395e-02f, 2.32300218e-02f, -2.02384993e-01f, -2.87281591e-02f, 4.88271117e-02f, -1.16824850e-01f, -5.93471117e-02f, -3.93654307e-04f, -2.41073333e-02f, -7.82600492e-02f,
  1.73713148e-01f, 1.44487545e-02f, 7.01935403e-03f, 7.50874951e-02f, -7.90159404e-02f, -1.40529171e-01f, -2.53021628e-01f, -1.12030044e-01f, 8.83762538e-02f, 9.46130529e-02f,
  9.33169201e-03f, 1.97156549e-01f, 1.24603279e-01f, 1.02854736e-01f, -2.18135118e-02f, -1.13482006e-01f, -2.97876839e-02f, -5.51850498e-02f, 4.57232669e-02f, -4.50978093e-02f,
  2.95826644e-02f, 1.54286966e-01f, 8.23669732e-02f, 8.23639054e-03f, 2.75855780e-01f, 2.81374276e-01f, 1.32905990e-01f, 1.09481968e-01f, 1.52281702e-01f, 3.72943282e-01f,
  2.91924119e-01f, -7.02717975e-02f, 4.41438854e-02f, 7.05285221e-02f, 5.36983237e-02f, 8.42420012e-02f, 1.63942367e-01f, 1.15509912e-01f, 8.96987841e-02f, 1.20149896e-01f,
  7.71631598e-02f, 9.58583802e-02f, 4.16502394e-02f, 7.90699720e-02f, 5.46255484e-02f, 5.51376841e-04f, -5.12931403e-03f, 3.82485799e-02f, 3.20662782e-02f, -1.10273215e-03f,
  7.55150244e-02f, 5.25027253e-02f, -3.34394723e-02f, -1.56126320e-02f, 1.62197500e-02f, -2.69902740e-02f, 8.43638256e-02f, 1.20184325e-01f, 9.57978144e-03f, 2.46902004e-01f,
  -4.97760363e-02f, -6.02825880e-02f, -1.77080464e-02f, 1.85507815e-02f, 4.02439348e-02f, -4.09024060e-02f, 2.51217484e-02f, 7.90614635e-03f, -2.93473229e-02f, 8.33715945e-02f,
  -6.17517196e-02f, -6.93968982e-02f, -2.06597149e-02f, -5.07567963e-03f, -8.93086009e-03f, -4.66347672e-02f, -2.41581984e-02f, -1.13893300e-02f, -2.06097104e-02f, 2.43916642e-02f,
  3.58953178e-02f, -6.93231728e-03f, -2.95776743e-02f, 4.61273529e-02f, 2.76670065e-02f, -2.32394673e-02f, 3.36332843e-02f, 1.19847124e-02f, 3.56372073e-02f, -2.35606451e-02f,
  1.26578927e-01f, -2.55841047e-01f, 1.52573705e-01f, 1.17775567e-01f, 2.28876993e-02f, 8.25593844e-02f, -4.94405720e-03f, 7.80260414e-02f, 3.62065583e-02f, 1.44813225e-01f,
  1.11118190e-01f, 7.21112937e-02f, 1.51146442e-01f, 3.93807590e-02f, 7.26816729e-02f, 5.79638481e-02f, 7.50522763e-02f, 1.08722165e-01f, 2.83168573e-02f, 1.41642049e-01f,
  6.67648241e-02f, 1.45767570e-01f, 2.05210611e-01f, 1.31957993e-01f, 1.32751018e-01f, 5.47824912e-02f, 1.85128585e-01f, 2.10013002e-01f, 1.47161111e-01f, 3.03578794e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.89734417e-01f, -9.42539051e-02f, -2.85982341e-01f, -2.41607904e-01f, -2.67456830e-01f, -4.41789813e-02f, -6.50682896e-02f, 9.77897197e-02f, 4.64898311e-02f, -9.81330872e-02f,
  1.48709983e-01f, 4.36946899e-01f, 2.48927236e-01f, 3.03421229e-01f, 4.52306330e-01f, -3.07370842e-01f, -3.06688756e-01f, -1.27831651e-02f, 3.78867209e-01f, 8.62703323e-02f,
  1.15314499e-02f, -2.08465904e-01f, 3.53126004e-02f, 5.71887614e-03f, -4.82769340e-01f, -2.24853791e-02f, -4.82542843e-01f, -2.24490672e-01f, 2.19107186e-03f, -4.68948096e-01f,
  -8.69716182e-02f, -1.04726829e-01f, 1.14091836e-01f, 1.98064446e-01f, 1.37213385e-02f, 1.02075472e-01f, 5.23696244e-02f, -9.03410465e-02f, 2.13043064e-01f, -8.14682171e-02f,
  -1.82110351e-02f, 1.67198494e-01f, 7.25450739e-02f, -1.21404594e-02f, -1.41336501e-01f, -1.19498193e-01f, -1.48486555e-01f, -4.85383235e-02f, 1.18954629e-02f, -1.56405225e-01f,
  -9.34257582e-02f, 3.19974171e-03f, -1.26033276e-01f, -1.81232721e-01f, -1.51673794e-01f, -3.67614850e-02f, -2.78753281e-01f, -1.63745776e-01f, 5.31372167e-02f, -4.88390118e-01f,
  -2.68976875e-02f, -1.50431558e-01f, -4.13991092e-03f, -4.32947353e-02f, 4.03721742e-02f, 3.12835425e-02f, 2.69265678e-02f, 8.48219395e-02f, 6.22851141e-02f, -1.73225015e-01f,
  7.61368424e-02f, 2.23567449e-02f, 6.31259978e-02f, -7.21031288e-03f, -3.52055579e-02f, -4.53531817e-02f, -5.41625805e-02f, -3.52651440e-02f, 1.70322787e-02f, 7.81674385e-02f,
  8.14752281e-02f, 7.94012472e-02f, -6.77846298e-02f, 3.80242616e-02f, 4.91663292e-02f, -6.00934252e-02f, -4.56019826e-02f, 1.31396994e-01f, 7.95326158e-02f, 7.84105584e-02f,
  2.49975711e-01f, 1.56219885e-01f, -3.03938463e-02f, 7.10476935e-02f, 6.50237640e-03f, 3.60310599e-02f, -3.05298753e-02f, 8.16441849e-02f, 1.39599651e-01f, 4.60507832e-02f,
  8.01426843e-02f, 5.10895997e-02f, -1.22613180e-02f, -1.61179334e-01f, 4.89499478e-04f, 6.48123994e-02f, 1.00217059e-01f, 1.10156715e-01f, 9.05870274e-02f, -2.12029889e-01f,
  -6.62173778e-02f, 9.39751938e-02f, 1.86889246e-01f, 8.60495865e-02f, -5.63598610e-02f, 1.89077988e-01f, -8.89553204e-02f, -1.31313354e-01f, 2.51488507e-01f, -4.86946814e-02f,
  6.76550746e-01f, 3.24319512e-01f, -4.97334599e-02f, 5.64663373e-02f, -1.76694706e-01f, -2.06070423e-01f, -2.21208856e-01f, -2.05173157e-03f, -5.69352247e-02f, 8.19543600e-02f,
  1.94872484e-01f, 1.76516086e-01f, 1.79113522e-01f, 3.23774256e-02f, 8.01303834e-02f, -1.48748755e-01f, -1.49016067e-01f, -6.83176666e-02f, 3.05537358e-02f, 1.04995193e-02f,
  1.20107140e-02f, -1.55180126e-01f, -4.30629365e-02f, -8.85069296e-02f, 3.49019803e-02f, 2.01491397e-02f, -1.89806744e-01f, -1.30003512e-01f, -2.13644832e-01f, -1.34297639e-01f,
  9.08313617e-02f, 2.57604927e-01f, 1.51147246e-01f, 1.71200275e-01f, 1.67046756e-01f, 1.05189219e-01f, 1.40103564e-01f, 1.22998513e-01f, -1.82110202e-02f, -1.01991761e-02f,
  -6.16133306e-03f, 9.25570801e-02f, -6.18084893e-02f, -8.64153653e-02f, -1.34330705e-01f, -2.90781632e-02f, -1.73012577e-02f, 2.66394136e-03f, -7.54038393e-02f, 2.12163990e-03f,
  4.36282195e-02f, -1.09776527e-01f, -5.70936967e-03f, 1.68241430e-02f, -5.99171175e-03f, 8.37322697e-02f, 1.09411720e-02f, 1.60025246e-02f, 2.74612922e-02f, -5.83701245e-02f,
  -1.63990155e-01f, 7.97743350e-02f, 1.04796953e-01f, 2.46670954e-02f, -8.60546604e-02f, -2.06421651e-02f, -8.75617489e-02f, -6.42511770e-02f, 4.04238738e-02f, -1.11322902e-01f,
  -2.76711434e-02f, -4.96288389e-02f, -8.14440250e-02f, 2.51792744e-02f, 9.52646658e-02f, 1.00188695e-01f, -4.97720726e-02f, 1.14567727e-02f, -6.11421242e-02f, -3.45068276e-02f,
  5.76368161e-02f, -1.15252145e-01f, 6.31323829e-02f, -1.13711968e-01f, -4.79371473e-02f, -2.05977969e-02f, -7.54817873e-02f, -6.76435307e-02f, -4.56186831e-02f, -1.14212938e-01f,
  2.25694910e-01f, 1.19965374e-01f, 1.49941340e-01f, 1.27957627e-01f, -8.73840507e-03f, 3.29958238e-02f, 1.59090653e-01f, 1.66521128e-02f, 3.87323834e-02f, -1.13074712e-01f,
  2.14647409e-02f, 6.37183115e-02f, 6.45698383e-02f, -5.33222035e-02f, -1.00161210e-02f, -5.04228985e-04f, 1.71228617e-01f, 1.40375912e-01f, 2.79739499e-02f, -4.80826832e-02f,
  1.04288593e-01f, -6.43723086e-02f, -3.68264094e-02f, 8.39614309e-03f, -8.90185907e-02f, 1.06416985e-01f, 5.98727576e-02f, 6.28130436e-02f, 8.61128345e-02f, 3.11182979e-02f,
  6.08681023e-01f, -4.46052581e-01f, -3.28957558e-01f, 3.47269960e-02f, 3.23669314e-02f, 1.48834854e-01f, 2.66667344e-02f, 8.25567767e-02f, 1.88938096e-01f, 5.39308786e-02f,
  8.27245489e-02f, 1.02054015e-01f, -7.19689131e-02f, -1.09123521e-01f, -2.30753962e-02f, -2.26578340e-01f, -2.70325035e-01f, -8.70886818e-03f, 2.56822586e-01f, 1.14379346e-01f,
  -3.06723826e-02f, 2.49892380e-02f, 9.08720046e-02f, 8.26309333e-05f, -2.49684334e-01f, -4.58616251e-03f, -1.73790872e-01f, -2.19989866e-01f, -1.41439140e-01f, -4.80150640e-01f,
  -4.44367766e-01f, 8.13870057e-02f, 1.54594138e-01f, 3.29853073e-02f, -6.01010248e-02f, 9.91223380e-02f, 5.35661392e-02f, -3.79854664e-02f, -2.46958900e-03f, 2.41570733e-02f,
  -1.65772103e-02f, 6.15037307e-02f, 5.82430921e-02f, -5.13791740e-02f, 2.03647260e-02f, 1.42948106e-01f, 4.14342023e-02f, 6.06672280e-02f, 2.15227716e-03f, -7.41443634e-02f,
  -5.74846007e-02f, 8.71306434e-02f, 2.18350384e-02f, 1.30092934e-01f, 2.04233050e-01f, 9.96882394e-02f, 3.71872708e-02f, -1.16460947e-02f, 6.70247898e-02f, 7.84746483e-02f,
  9.91350692e-03f, -6.55843168e-02f, 4.29907851e-02f, 2.10999221e-01f, 1.83023408e-01f, 9.39037651e-02f, -1.11055344e-01f, 9.51385647e-02f, 2.20005229e-01f, 1.36773646e-01f,
  -9.92797837e-02f, 4.72938567e-02f, 1.06141567e-01f, 6.74401373e-02f, -1.43135637e-01f, -2.41252240e-02f, -4.14953046e-02f, 1.60358916e-03f, 6.39760867e-02f, 4.50186133e-02f,
  2.21004412e-02f, -1.04489490e-01f, -6.53338060e-02f, -5.36711365e-02f, -1.71277270e-01f, -5.45564219e-02f, -6.40594661e-02f, 4.78503993e-03f, 6.35726238e-03f, -5.27530499e-02f,
  -2.05150992e-01f, 8.39905962e-02f, -1.01875283e-01f, -1.36288077e-01f, 8.32569879e-03f, -7.17754811e-02f, -5.82902022e-02f, -6.83581457e-02f, -1.53266519e-01f, -1.00954920e-01f,
  -8.01421609e-03f, -5.06588630e-02f, -2.70306859e-02f, 7.58916512e-02f, 1.32393181e-01f, 4.05158661e-03f, 5.59746176e-02f, 5.36739603e-02f, -3.52941304e-02f, -1.77559510e-01f,
  -1.40733108e-01f, 2.92594004e-02f, 1.12717591e-01f, 1.59557641e-01f, 1.62691221e-01f, 1.46333829e-01f, 1.22768153e-02f, 4.84378301e-02f, 2.18360946e-02f, 2.26738185e-01f,
  -3.45495135e-01f, 1.29510745e-01f, 1.53263032e-01f, -9.43968371e-02f, 1.31877005e-01f, -2.40873858e-01f, -3.81222278e-01f, -2.52827436e-01f, -1.59238465e-02f, -2.68097557e-02f,
  1.70646459e-01f, 2.35057667e-01f, 2.06664622e-01f, -5.65425195e-02f, -3.47197235e-01f, -2.90125966e-01f, -1.66383564e-01f, -3.84138644e-01f, -2.93260336e-01f, -3.21488410e-01f,
  -6.20847717e-02f, -6.93384260e-02f, -2.86358982e-01f, -2.00979680e-01f, 2.86186457e-01f, 2.36837655e-01f, 2.21556991e-01f, 1.26446009e-01f, 5.49494512e-02f, 1.64215058e-01f,
  2.48994946e-01f, -3.21876071e-02f, 3.02732885e-02f, -1.21496178e-01f, 2.37835392e-01f, -1.44851105e-02f, -1.34024546e-01f, -1.05818570e-01f, -6.24804460e-02f, -7.86741525e-02f,
  -2.11254954e-02f, -1.37234539e-01f, -7.63093084e-02f, 6.10569306e-02f, -2.65518516e-01f, -3.04920137e-01f, -1.62390873e-01f, -1.91184938e-01f, -1.05032079e-01f, -7.33136758e-02f,
  3.43998522e-02f, -9.38521922e-02f, 3.63842398e-02f, 1.38452888e-01f, -8.37282017e-02f, 2.01039016e-02f, 2.34050795e-01f, 6.17593303e-02f, 6.97425008e-02f, 1.20254815e-01f,
  9.24587809e-03f, -1.22720916e-02f, -9.73393470e-02f, 2.21440122e-02f, -9.12803877e-03f, 8.46396685e-02f, -1.41777340e-02f, -9.84909162e-02f, 5.65192336e-03f, 6.80043176e-02f,
  6.16531298e-02f, 1.11802819e-03f, -5.53253479e-02f, -4.43071267e-03f, -4.86485437e-02f, -4.51211855e-02f, -1.33478492e-01f, -3.18950266e-02f, -7.84889683e-02f, 1.91279221e-02f,
  -8.69073942e-02f, -3.17365415e-02f, 9.32059214e-02f, -5.52443080e-02f, -2.41305139e-02f, -1.78637132e-01f, -3.73704918e-02f, 3.56033519e-02f, 1.64747257e-02f, -6.71848804e-02f,
  2.09972560e-01f, -2.21609715e-02f, -6.16585463e-02f, -1.94899872e-01f, -1.41703278e-01f, 1.60505474e-01f, 2.93296389e-02f, -2.38493979e-01f, -4.27049063e-02f, -1.50752798e-01f,
  -1.60896152e-01f, -1.02910489e-01f, 1.11916013e-01f, 5.33456504e-02f, -1.61607146e-01f, -3.23723182e-02f, -2.12006480e-01f, 2.49662753e-02f, -1.62164971e-01f, -1.76008061e-01f,
  -1.06134690e-01f, -2.16208234e-01f, -5.15729375e-02f, 1.47911459e-01f, -5.52178323e-02f, -1.36492420e-02f, 1.54684067e-01f, 2.25359708e-01f, -1.40392214e-01f, 9.57715437e-02f,
  2.36396149e-01f, -2.51724929e-01f, -5.81745386e-01f, -9.99913663e-02f, -2.78930902e-01f, -2.93247640e-01f, -1.46217301e-01f, 1.35051133e-02f, -1.61880516e-02f, -2.73491949e-01f,
  -1.04133628e-01f, 1.71876535e-01f, -1.00981936e-01f, -3.56825329e-02f, -6.47293478e-02f, -3.90097827e-01f, -3.23574305e-01f, -1.27837539e-01f, 1.46164551e-01f, 6.23103008e-02f,
  -9.04597566e-02f, -6.72861561e-02f, -6.69548213e-02f, -1.23329051e-01f, -1.59311071e-01f, -5.39799966e-02f, -2.95322835e-01f, -1.30968779e-01f, -1.78995609e-01f, -4.55634505e-01f,
  -1.36881977e-01f, -2.63629973e-01f, 8.57356787e-02f, -4.22023199e-02f, -8.15028474e-02f, 1.35016972e-02f, -4.46396060e-02f, 4.22407873e-02f, 4.02104333e-02f, -7.13957697e-02f,
  -8.05406123e-02f, 1.90058555e-02f, 1.27910629e-01f, 8.56073946e-02f, 1.65479649e-02f, -1.95300598e-02f, 2.76110414e-02f, -4.36803326e-02f, -1.15700744e-01f, -1.80283263e-01f,
  -1.23994857e-01f, -1.68831259e-01f, 7.66412616e-02f, 1.62480753e-02f, 1.53989415e-03f, -9.15276818e-03f, 6.68769144e-03f, -3.02752443e-02f, -7.51356187e-04f, 9.07566175e-02f,
  -1.39279157e-01f, -2.27956660e-02f, 4.51733880e-02f, 8.34839344e-02f, 1.38759822e-01f, 1.00903183e-01f, 2.92584021e-02f, 6.78970069e-02f, 5.68742566e-02f, 9.88401622e-02f,
  -4.48304750e-02f, -4.55567986e-02f, -3.93384136e-02f, -6.54737428e-02f, -8.28277916e-02f, 7.89068341e-02f, -1.91238560e-02f, -3.60930264e-02f, 8.15323612e-04f, 1.37709752e-01f,
  1.29158661e-01f, 7.72057772e-02f, 1.21916933e-02f, 9.84673575e-02f, -1.47903576e-01f, -3.59033495e-02f, -1.13462158e-01f, -3.03265173e-02f, 9.64975059e-02f, -3.69746378e-03f,
  4.59981859e-01f, -3.92119974e-01f, 2.15468206e-03f, 8.85351747e-02f, 1.97467878e-02f, -8.18628743e-02f, -8.16293210e-02f, -4.82293926e-02f, -1.10079996e-01f, -1.10202841e-01f,
  -6.94986284e-02f, 3.34376954e-02f, -5.92348948e-02f, 1.07833156e-02f, 1.89980164e-01f, -1.80114992e-02f, 1.26188308e-01f, 1.08556934e-01f, 5.44555448e-02f, -3.38847302e-02f,
  -1.19848303e-01f, 1.61178991e-01f, 2.62317240e-01f, 1.85765013e-01f, 8.08705986e-02f, 1.92595184e-01f, 9.90873128e-02f, 9.53618363e-02f, 3.13022137e-02f, 1.73745066e-01f,
  2.21517593e-01f, -3.89044940e-01f, 3.10691625e-01f, 2.31455028e-01f, 5.53120673e-02f, -6.48546740e-02f, -5.04741147e-02f, 5.96552677e-02f, 1.96974769e-01f, 3.40155214e-02f,
  -5.25935367e-02f, 6.61820620e-02f, 2.71735370e-01f, 1.52413443e-01f, 2.76323020e-01f, 2.72478461e-01f, 3.19773793e-01f, 5.04913151e-01f, 2.50044435e-01f, 2.36402422e-01f,
  5.29958913e-03f, 1.00409523e-01f, 2.42144585e-01f, 1.93204179e-01f, 1.92657292e-01f, 2.65577525e-01f, 1.96598351e-01f, 1.07630156e-02f, 1.28887072e-01f, 3.00399512e-01f,
  -1.63681418e-01f, -2.19913796e-01f, 2.43091375e-01f, 1.31476885e-02f, -1.30129023e-03f, -1.01445571e-01f, -4.27073799e-02f, -6.33828044e-02f, -1.14852406e-01f, -1.10360920e-01f,
  -4.35361825e-02f, -1.51644036e-01f, -9.00312960e-02f, 1.73512716e-02f, -7.44960979e-02f, -8.69493112e-02f, 2.66891643e-02f, 1.05375722e-01f, 6.85078278e-02f, 1.60377810e-03f,
  5.78966551e-02f, -1.39347166e-01f, -1.65572539e-02f, -6.59816945e-03f, -8.66436306e-03f, 1.16201974e-01f, -2.73065865e-02f, 6.02450855e-02f, 6.97374195e-02f, -5.30503371e-07f,
  1.61682978e-01f, 5.50822243e-02f, 1.59398064e-01f, 1.23518787e-01f, 1.54110998e-01f, -3.54139321e-02f, 1.13002330e-01f, 1.83235016e-02f, 7.21421763e-02f, 3.30175739e-03f,
  1.27202928e-01f, 8.92094150e-02f, 5.45084290e-02f, 1.74546897e-01f, 5.48232496e-02f, -1.77164469e-02f, -9.69102420e-03f, -3.64318714e-02f, 5.83549589e-02f, 1.00583211e-02f,
  7.33087882e-02f, 8.37265793e-03f, 3.67030837e-02f, -2.69521661e-02f, -3.20937485e-02f, 1.45287648e-01f, 8.73026252e-02f, -1.49350669e-02f, -8.06370899e-02f, 7.53953606e-02f,
  -5.01974821e-01f, -3.94719206e-02f, 1.54437944e-01f, -5.35458475e-02f, -5.81379235e-02f, -4.58592176e-03f, -6.74026832e-02f, -1.61488265e-01f, -1.99621558e-01f, -1.80016100e-01f,
  -2.05228165e-01f, -6.10450134e-02f, -5.94156794e-02f, 6.40799105e-02f, -3.24917398e-02f, -1.60448134e-01f, -4.38646041e-02f, -8.23321715e-02f, -2.99250837e-02f, -1.77721560e-01f,
  5.23647703e-02f, -1.81875050e-01f, -1.82728589e-01f, -8.48275423e-02f, -8.02853703e-02f, -4.47711200e-02f, -1.66161172e-02f, 2.58526653e-02f, 1.83881563e-03f, -1.21797346e-01f,
  4.05704647e-01f, 4.42358017e-01f, 2.51826406e-01f, 9.27583799e-02f, -3.53659280e-02f, 2.25232974e-01f, 3.07850391e-01f, 2.41463706e-01f, -1.83477074e-01f, -2.32418310e-02f,
  -5.31905983e-03f, -2.52271116e-01f, -1.05016477e-01f, 3.44409831e-02f, 1.55479252e-01f, 1.91250071e-01f, 1.31084725e-01f, 1.43016487e-01f, 8.05242211e-02f, 8.03103000e-02f,
  -7.11535364e-02f, 6.77775368e-02f, 1.03917845e-01f, 1.15856849e-01f, 1.00148939e-01f, -1.26012877e-01f, 1.67890906e-01f, 2.28117108e-01f, 1.52572840e-01f, 1.05799198e-01f,
  1.39272049e-01f, 3.77622485e-01f, -2.48347878e-01f, -1.07737981e-01f, -2.09710579e-02f, -1.73367187e-02f, 5.04309386e-02f, -8.04485753e-02f, -3.24241333e-02f, -1.03635475e-01f,
  -5.58021627e-02f, 1.42169684e-01f, 1.09500259e-01f, 1.86978981e-01f, 1.51924357e-01f, 8.39788467e-02f, 2.67872155e-01f, 1.89763382e-01f, 2.45349661e-01f, 8.82147476e-02f,
  -7.30508864e-02f, 6.13319129e-02f, 1.01999708e-01f, 7.55630508e-02f, 1.51500687e-01f, -4.81833220e-02f, 5.12137637e-02f, 1.28847882e-01f, 1.02201335e-01f, 8.02073032e-02f,
  9.46181081e-03f, 4.68059257e-02f, -2.81198043e-02f, 4.92210016e-02f, 3.50945070e-02f, 1.71041004e-02f, -1.31397352e-01f, 9.04289931e-02f, 1.15993537e-01f, 1.46435767e-01f,
  -3.91131341e-02f, 1.22255243e-01f, -7.56087378e-02f, 1.14387032e-02f, -1.53697282e-01f, 2.07775347e-02f, 4.83854413e-02f, -5.98233752e-03f, 1.02360010e-01f, 1.75152579e-03f,
  -7.78457336e-03f, 1.05411477e-01f, 7.79513717e-02f, 8.44491720e-02f, -3.28400172e-02f, -4.46169339e-02f, -1.28207207e-02f, -4.14423198e-02f, -9.99631546e-03f, -9.45156217e-02f,
  -2.74722993e-01f, 2.23217696e-01f, -2.17089832e-01f, 3.59316580e-02f, 1.09173417e-01f, 2.72666719e-02f, -4.15655188e-02f, 1.18707540e-02f, -7.86592364e-02f, -1.16862901e-01f,
  1.63106583e-02f, -5.38851274e-03f, 1.79216951e-01f, 2.45870780e-02f, -7.38997608e-02f, -1.44429371e-01f, -1.13334104e-01f, -2.39455048e-02f, -9.38387662e-02f, -5.42579331e-02f,
  -4.07330692e-02f, -1.95220515e-01f, -2.53252625e-01f, -1.29407272e-01f, -2.06878707e-01f, -3.69660825e-01f, -2.28948280e-01f, -1.30779788e-01f, -1.76609874e-01f, -1.73463106e-01f,
  4.00938690e-01f, -5.92730284e-01f, 2.83039868e-01f, 2.06260562e-01f, 3.12125027e-01f, 2.32616559e-01f, 2.27380499e-01f, 1.53139949e-01f, 1.57652557e-01f, -4.35307622e-02f,
  -2.03310892e-01f, -2.58410186e-01f, -2.75653541e-01f, -2.06848249e-01f, -8.44145641e-02f, 9.75017622e-02f, 6.86696470e-02f, 1.44534871e-01f, 3.18647385e-01f, 2.10799903e-01f,
  -2.54335646e-02f, -4.05570166e-03f, 1.10880278e-01f, 1.17286384e-01f, -1.62068665e-01f, -5.30449860e-02f, -3.45618650e-02f, -1.19661719e-01f, -9.95402262e-02f, -9.52882320e-02f,
  -3.40537578e-01f, -2.06451461e-01f, 1.66779220e-01f, -1.54199153e-01f, -1.87865451e-01f, 2.59136152e-03f, 6.85335174e-02f, -4.74184044e-02f, 3.39021869e-02f, 8.05225447e-02f,
  -9.15523097e-02f, 1.33303797e-03f, -1.48926198e-01f, -1.44655839e-01f, -2.18906421e-02f, 2.72977408e-02f, -7.12545516e-05f, -1.20349742e-01f, -1.50021240e-01f, -1.37609899e-01f,
  -2.71583796e-01f, -2.45017791e-03f, 5.21971472e-02f, -1.62814725e-02f, -6.53878450e-02f, -1.40232337e-03f, -3.64868864e-02f, -1.12360872e-01f, -6.46275058e-02f, 4.72675376e-02f,
  1.43397853e-01f, -3.50825936e-02f, -1.73572451e-01f, -9.57968459e-02f, 8.87882523e-03f, 4.38860767e-02f, 3.67909782e-02f, 5.67964949e-02f, -2.98730340e-02f, 2.81611551e-02f,
  -8.16213526e-03f, -1.29198842e-02f, -4.69767787e-02f, -5.18582948e-02f, -1.42482266e-01f, -1.64797589e-01f, 3.01633291e-02f, -7.32016265e-02f, -1.24833822e-01f, -1.11033402e-01f,
  -4.61390764e-02f, 7.28000626e-02f, 1.27417212e-02f, -9.66407061e-02f, -7.44595826e-02f, -8.42326432e-02f, -5.83417006e-02f, -8.44099075e-02f, 1.71367303e-02f, 5.29270135e-02f,
  -4.84420747e-01f, -4.31758016e-02f, 1.36425346e-01f, -9.71737802e-02f, 1.12610767e-02f, -1.31625354e-01f, -8.99246931e-02f, 2.42827851e-02f, 2.62403004e-02f, -1.85804125e-02f,
  -3.12913619e-02f, 1.17433500e-02f, -1.46335602e-01f, -3.65069918e-02f, 1.29188851e-01f, 1.54939666e-01f, -7.09219202e-02f, 3.28509435e-02f, 3.27448696e-02f, -9.98441055e-02f,
  -4.97601852e-02f, 1.88284054e-01f, 1.66192085e-01f, 1.06587261e-01f, 1.03294328e-01f, 2.61303246e-01f, 1.00256808e-01f, 8.10747966e-02f, 1.97945789e-01f, 2.19446599e-01f,
  2.77363062e-01f, -1.66828595e-02f, 3.23937565e-01f, 4.58704591e-01f, 4.83910412e-01f, 4.05002862e-01f, 3.45200777e-01f, 3.23611677e-01f, 1.83625445e-01f, 1.81410253e-01f,
  2.97156721e-02f, 3.95485722e-02f, 2.76336800e-02f, -3.22393840e-03f, 7.80657679e-02f, 2.85467282e-02f, 8.93759802e-02f, -7.48784542e-02f, 1.57429948e-01f, 8.33370090e-02f,
  4.61929440e-02f, 3.91044989e-02f, -2.51638517e-03f, -6.16969652e-02f, 6.71597645e-02f, 2.46793441e-02f, 1.02084413e-01f, 9.78717804e-02f, -5.11053614e-02f, -1.96051285e-01f,
  -2.08472475e-01f, 1.10644676e-01f, -5.93336560e-02f, -7.29919970e-02f, -1.24885708e-01f, -9.27224159e-02f, -4.91246991e-02f, -1.57583341e-01f, -1.04421325e-01f, 1.58017259e-02f,
  -1.31985977e-01f, -1.29560098e-01f, 2.22402979e-02f, -9.53930542e-02f, -2.37276405e-02f, 1.16745150e-03f, -1.95399120e-01f, -3.59758846e-02f, -3.49394791e-02f, -5.10265417e-02f,
  -5.06980233e-02f, 5.98791614e-02f, 3.68983299e-02f, 8.68903920e-02f, -5.40079921e-02f, -6.90350235e-02f, -7.19007552e-02f, -1.17271304e-01f, 5.79639450e-02f, -2.29179394e-02f,
  2.96095848e-01f, 5.39924167e-02f, 5.07256724e-02f, 3.08121573e-02f, 1.73985604e-02f, 1.15076415e-01f, 1.48286968e-01f, 3.33013684e-02f, 1.45742267e-01f, -5.92615716e-02f,
  -2.99352426e-02f, 6.98029026e-02f, 1.39859855e-01f, -1.51905825e-03f, 1.94406416e-02f, 1.11316964e-01f, 7.47457594e-02f, -6.51229769e-02f, -1.44728841e-02f, 5.99608123e-02f,
  -2.53542699e-02f, -2.30129119e-02f, -2.90512219e-02f, -1.35371774e-01f, 4.47217561e-03f, 6.69789761e-02f, -3.67249958e-02f, -4.40532193e-02f, -1.67250670e-02f, -1.74527839e-02f,
  1.77482203e-01f, 2.14952961e-01f, -6.40149787e-02f, -1.12646118e-01f, -8.37115645e-02f, -9.94431302e-02f, 7.61123002e-02f, -5.52624688e-02f, -8.43755230e-02f, 4.12943438e-02f,
  5.19607067e-02f, -5.97332530e-02f, -3.68558802e-02f, -2.24616136e-02f, 1.12629503e-01f, 5.01524508e-02f, -1.38164356e-01f, 8.99861082e-02f, -3.18736173e-02f, 3.02297883e-02f,
  1.86188950e-03f, 2.10008577e-01f, 1.92214787e-01f, 1.57051131e-01f, 3.45671885e-02f, 6.61917105e-02f, 3.18747163e-02f, 2.26532221e-02f, 1.15735047e-01f, 5.53812496e-02f,
  -5.05167305e-01f, -5.95922284e-02f, 8.81219730e-02f, -2.20477477e-01f, 9.83148664e-02f, 2.79967308e-01f, 1.23136275e-01f, 2.00454116e-01f, 5.05658872e-02f, -1.01807654e-01f,
  2.65258309e-02f, -1.59320179e-02f, -1.04296528e-01f, -9.28974338e-03f, -5.76494411e-02f, -1.84734493e-01f, -3.02888066e-01f, -8.14583376e-02f, 1.54334038e-01f, 2.04096794e-01f,
  2.86527313e-02f, -1.68977201e-01f, -1.85605988e-01f, -9.55049768e-02f, -4.01853770e-01f, -1.86107874e-01f, -2.81092405e-01f, -3.00913125e-01f, -1.98169529e-01f, -5.65827131e-01f,
  -1.92550600e-01f, -3.18748839e-02f, 3.40179116e-01f, -2.82964796e-01f, 2.34813485e-02f, 1.31674066e-01f, 1.48931205e-01f, -4.89319190e-02f, 1.04179293e-01f, 1.04270456e-02f,
  -1.15330286e-01f, 7.02295974e-02f, -1.06964611e-01f, 1.11056641e-01f, 5.11574447e-02f, 7.09080324e-02f, 1.60863642e-02f, 8.69906694e-02f, -4.60605808e-02f, 1.74954429e-01f,
  -1.16320349e-01f, -2.23103896e-01f, -8.87685046e-02f, 1.60893559e-01f, 1.84358224e-01f, -5.83464615e-02f, 5.90455569e-02f, -2.98743378e-02f, 5.05425893e-02f, -3.87179881e-01f,
  5.26065603e-02f, 1.19990103e-01f, 1.00775249e-01f, 3.88106965e-02f, -5.81801981e-02f, -4.92695607e-02f, -8.52446854e-02f, -1.58685625e-01f, 7.26899505e-02f, -6.62171990e-02f,
  7.18030110e-02f, 4.87917401e-02f, -9.80180800e-02f, -8.60453323e-02f, -1.55585378e-01f, -1.21222317e-01f, -9.45083052e-02f, -1.33508012e-01f, -2.32055157e-01f, -7.55044743e-02f,
  -7.13555813e-02f, -1.94047943e-01f, -8.99694040e-02f, -2.93451548e-02f, 4.79623042e-02f, -1.80579662e-01f, 7.83141851e-02f, 9.18495730e-02f, -9.66589805e-03f, 5.08012995e-02f,
  -1.66458726e-01f, 2.75527358e-01f, -2.81189799e-01f, 3.14290053e-03f, -7.28304312e-02f, -2.16419194e-02f, -1.79414660e-01f, 7.15364590e-02f, -5.96010722e-02f, -2.73011029e-02f,
  1.81202158e-01f, -1.61589324e-01f, -1.30077049e-01f, -2.35457215e-02f, 6.89349994e-02f, -1.18727915e-01f, -1.89829424e-01f, -2.37317428e-01f, 2.97633894e-02f, -5.43511100e-02f,
  -1.75577775e-01f, -2.19363302e-01f, -3.01704884e-01f, -2.26325303e-01f, -1.05893575e-01f, -2.21921012e-01f, -2.21208006e-01f, -1.25884250e-01f, -6.40223250e-02f, -4.44828421e-01f,
  1.47186458e-01f, -4.62760270e-01f, 2.70304140e-02f, -1.33856609e-01f, -3.00685138e-01f, -2.91068226e-01f, -4.64889646e-01f, -1.65460065e-01f, -2.74084993e-02f, -5.71222842e-01f,
  -2.36796752e-01f, 2.30006039e-01f, 1.52688324e-01f, 1.59646198e-01f, 2.33286455e-01f, -4.67122644e-01f, -2.38511711e-01f, 3.69792819e-01f, 6.03681624e-01f, 8.01043510e-02f,
  -1.20634325e-01f, -3.26902862e-03f, 4.24670458e-01f, 1.91457540e-01f, -3.28569353e-01f, 3.44040915e-02f, -1.99560896e-01f, -1.40832394e-01f, -1.55351132e-01f, -4.48885560e-01f,
  -2.69436836e-01f, -1.15748540e-01f, -4.98131327e-02f, 3.12286895e-02f, -6.46559075e-02f, 5.27189262e-02f, -1.07467189e-01f, -3.78556475e-02f, 1.18649434e-02f, -1.49660751e-01f,
  -6.92969263e-02f, 9.09147114e-02f, 1.64110273e-01f, 1.43070787e-01f, -4.54362519e-02f, 2.99851969e-02f, 5.39757460e-02f, 1.29943803e-01f, 6.17682002e-02f, -1.13909125e-01f,
  -1.51848152e-01f, -6.27833530e-02f, 7.17570856e-02f, 2.57686526e-02f, 1.40470406e-02f, 1.88223213e-01f, -7.12860301e-02f, 1.94420051e-02f, 7.35842586e-02f, -3.80220711e-01f,
  -5.38038351e-02f, -2.94746142e-02f, -7.03682303e-02f, 2.73460690e-02f, -6.12491705e-02f, -2.49189697e-02f, 1.08992808e-01f, -3.11257374e-02f, 9.35845599e-02f, 2.42754295e-02f,
  3.16538736e-02f, -1.01782061e-01f, 1.02984592e-01f, -1.73317447e-01f, 5.80874495e-02f, 9.13573653e-02f, 1.69280339e-02f, -7.84318000e-02f, -4.37221639e-02f, 3.05589698e-02f,
  3.44755985e-02f, -4.77521941e-02f, 1.15403123e-02f, 6.10435680e-02f, 3.84803489e-02f, 9.04688910e-02f, 2.78535578e-02f, 8.66635144e-02f, -2.71151289e-02f, -3.65842357e-02f,
  3.81707363e-02f, 2.04704985e-01f, -3.62765968e-01f, 1.70003533e-01f, -1.33279666e-01f, 1.58000514e-02f, -1.27164023e-02f, -1.70859303e-02f, 7.30068311e-02f, -7.49957561e-02f,
  3.24908756e-02f, -1.38000259e-02f, 8.95386469e-03f, -3.92770022e-02f, -7.28806704e-02f, -1.74607839e-02f, -4.06595096e-02f, 4.75591682e-02f, 3.69321741e-02f, -1.38673410e-01f,
  3.03602181e-02f, -2.21150485e-03f, -3.14440355e-02f, -4.13027368e-02f, -9.49881375e-02f, 9.98289511e-02f, -1.48790956e-01f, -1.93103403e-01f, 6.98303208e-02f, -3.95859212e-01f,
  -9.09359217e-01f, -4.41526234e-01f, 3.33027512e-01f, 1.81607809e-02f, 2.86546201e-01f, 2.37207040e-01f, 5.77702792e-03f, -2.36617550e-02f, -3.46182510e-02f, -1.08294465e-01f,
  -2.61245310e-01f, -1.81608334e-01f, -2.25791916e-01f, -1.60168841e-01f, -1.85721561e-01f, -1.72846857e-02f, 8.82083252e-02f, 1.15078390e-01f, 2.44721957e-02f, 7.44282305e-02f,
  4.77363244e-02f, -2.89908908e-02f, -2.17817694e-01f, 4.20764880e-03f, -6.78710341e-02f, -2.85768881e-02f, -4.04996462e-02f, 1.29727930e-01f, 1.12874834e-04f, 9.50453058e-02f,
  5.39665759e-01f, -4.89318743e-02f, -1.12545099e-02f, -6.98863789e-02f, 2.52231937e-02f, -1.91675529e-01f, -4.42577712e-02f, 5.63294441e-02f, 5.34572639e-02f, 1.81349471e-01f,
  1.28659368e-01f, -8.72769207e-02f, 6.87170848e-02f, -5.47583327e-02f, 1.78684920e-01f, 2.59040762e-02f, 5.66805601e-02f, 5.98268472e-02f, 1.77943021e-01f, 8.50015134e-02f,
  2.76117772e-02f, 2.22151987e-02f, 2.20030725e-01f, 1.46106690e-01f, -7.96664208e-02f, 2.54727434e-02f, 7.13418201e-02f, 1.68672891e-03f, 1.04478814e-01f, -6.21432662e-02f,
  8.03752914e-02f, -8.71221647e-02f, 3.42719704e-02f, 5.67196533e-02f, -1.69677198e-01f, 4.58820686e-02f, 2.65052747e-02f, 7.21130073e-02f, -2.36255117e-02f, -9.72541943e-02f,
  1.35925159e-01f, 1.59594893e-01f, 8.97486508e-02f, 4.93843406e-02f, 1.89748406e-02f, 1.32072985e-01f, 3.89625914e-02f, -1.60455815e-02f, -4.02069055e-02f, 4.12436984e-02f,
  3.97591516e-02f, 1.46203876e-01f, -2.27116346e-02f, 6.78416416e-02f, 3.84773053e-02f, 3.28406170e-02f, 1.14709318e-01f, 2.60428376e-02f, 8.45376588e-03f, 6.59296894e-03f,
  3.59726042e-01f, -5.29275239e-02f, 2.68893898e-03f, -8.09291601e-02f, 6.81414129e-03f, -1.71798602e-01f, -1.20638661e-01f, -1.64374672e-02f, 1.35055572e-01f, 2.12749198e-01f,
  1.14873782e-01f, -3.64920241e-03f, 5.70602864e-02f, 4.22854349e-02f, 8.87903497e-02f, 1.04350500e-01f, -1.33504272e-01f, 5.68782464e-02f, 1.09837443e-01f, 7.61504844e-02f,
  1.05369620e-01f, 1.37651682e-01f, 3.96879092e-02f, 1.39236838e-01f, -5.12655545e-03f, -3.33089428e-03f, 7.83227906e-02f, 5.12816980e-02f, 1.87528040e-02f, -3.94599847e-02f,
  -3.52984309e-01f, -3.66892308e-01f, -5.24349026e-02f, -5.92922978e-02f, 5.06880842e-02f, -8.19872990e-02f, -4.17530358e-01f, -1.99882817e-02f, 1.57083616e-01f, -2.67041713e-01f,
  -1.01211190e-01f, 5.21779396e-02f, -6.93818629e-02f, -9.38543230e-02f, -3.81821662e-01f, -4.27307606e-01f, -2.45221421e-01f, -1.00982949e-01f, 2.68351063e-02f, 1.86357439e-01f,
  5.40224202e-02f, 7.17196614e-02f, 1.20420456e-01f, 8.34861621e-02f, 5.32992966e-02f, 4.64284886e-03f, 5.46411090e-02f, -1.18165545e-01f, -1.80607572e-01f, -2.99035549e-01f,
  -5.27873039e-01f, -1.38183072e-01f, 2.70756930e-01f, 5.72917052e-02f, 7.21149370e-02f, -6.52694982e-03f, 5.35403155e-02f, 7.04462528e-02f, -3.50044705e-02f, -1.08213715e-01f,
  9.03872401e-03f, 1.28113449e-01f, 1.40425032e-02f, 6.99460134e-03f, 7.39420578e-02f, -5.49109243e-02f, 6.23749681e-02f, 3.35992798e-02f, -5.01253977e-02f, -7.50901923e-02f,
  -1.68084949e-01f, -2.39210546e-01f, -2.48044938e-01f, -4.22488973e-02f, -7.59094357e-02f, 8.42635408e-02f, 6.72266036e-02f, -2.20027640e-02f, -7.28148147e-02f, -2.26924017e-01f,
  -9.74620134e-02f, 9.83039141e-02f, 7.38130212e-02f, 6.90043494e-02f, -6.82527795e-02f, 6.09309189e-02f, 3.64283994e-02f, 1.78301483e-02f, 1.44701421e-01f, -6.43705875e-02f,
  1.09773390e-02f, -4.09967490e-02f, -2.89659086e-03f, -1.57693967e-01f, -1.55641288e-02f, -7.34427348e-02f, -1.18265130e-01f, -8.73532519e-02f, -2.73205414e-02f, 4.68521453e-02f,
  2.65949243e-03f, -7.59429671e-03f, 7.13913888e-02f, -1.64127033e-02f, -9.07393023e-02f, -4.47195321e-02f, -6.16944879e-02f, 5.81200980e-02f, -9.89573169e-03f, -1.95976980e-02f,
  -3.75045873e-02f, 2.59394288e-01f, -7.97163546e-02f, -1.89628992e-02f, -2.17762172e-01f, 2.79808436e-02f, -6.18387349e-02f, -7.21388124e-03f, 5.59853949e-02f, 5.89210242e-02f,
  2.04487238e-02f, -7.71900341e-02f, 8.62540677e-02f, 1.61710709e-01f, 6.19668253e-02f, -5.39140543e-03f, -1.79251030e-01f, -7.35600293e-02f, -2.06061825e-02f, 1.40399233e-01f,
  -3.33885103e-02f, -2.92355061e-01f, -3.41831774e-01f, -2.82378316e-01f, -5.64963035e-02f, 6.36040792e-03f, -1.11254072e-02f, -1.14493050e-01f, -1.22715391e-01f, -3.75267923e-01f,
  4.87509035e-02f, 3.05947810e-01f, -2.74595588e-01f, 1.85547814e-01f, 3.10561627e-01f, 2.53183842e-01f, 4.35857654e-01f, 3.66735667e-01f, 1.55618012e-01f, 2.44359300e-01f,
  2.85162747e-01f, 3.13050926e-01f, 2.85246521e-01f, 2.44484499e-01f, 2.66865700e-01f, 2.95541376e-01f, 2.51747519e-01f, -3.30037139e-02f, -8.15523639e-02f, 1.48908019e-01f,
  3.23792160e-01f, 1.67256117e-01f, -5.63576147e-02f, 3.80514264e-02f, 1.35471681e-02f, 4.19949889e-02f, 1.91595599e-01f, 2.20326796e-01f, 1.74733847e-01f, 9.02301595e-02f,
  -3.15221548e-01f, -1.28942370e-01f, 3.96325439e-02f, 1.60873719e-02f, -7.87500590e-02f, -9.77434739e-02f, -1.60592839e-01f, -1.39539421e-01f, -3.42540368e-02f, -1.40929669e-02f,
  -7.96504766e-02f, -1.88419119e-01f, -9.36489478e-02f, -2.14875266e-02f, -6.81491941e-02f, -1.37256846e-01f, -2.87929848e-02f, 6.65005371e-02f, 1.66416727e-02f, 1.44630449e-03f,
  1.75025809e-04f, -9.52765569e-02f, 7.18137994e-02f, 9.79457721e-02f, 8.30436274e-02f, 1.51161952e-02f, 3.86312716e-02f, -3.19097266e-02f, -2.92166676e-02f, 5.07979058e-02f,
  8.26888308e-02f, -1.50648113e-02f, -1.35962591e-01f, 2.68692933e-02f, 3.84713374e-02f, -4.08707932e-02f, -2.07098797e-02f, -1.54539645e-02f, 9.05026346e-02f, -7.36485273e-02f,
  8.94756541e-02f, -4.69917022e-02f, -1.07814327e-01f, -1.86660532e-02f, -9.89702567e-02f, -1.42768800e-01f, -1.63795408e-02f, -1.73404053e-01f, -1.90903753e-01f, -1.46797612e-01f,
  -1.80596888e-01f, -2.57333014e-02f, -2.19751433e-01f, -1.40224129e-01f, 6.47881767e-03f, -1.19839080e-01f, -1.23899477e-02f, -8.76603127e-02f, -6.45970330e-02f, 8.62995461e-02f,
  5.33635877e-02f, -1.50467530e-01f, -9.26598534e-02f, 9.89339799e-02f, -1.10181779e-01f, -4.80086692e-02f, -1.21125005e-01f, -1.76368624e-01f, 3.10354643e-02f, -1.30491778e-01f,
  -5.64608648e-02f, -1.75962076e-01f, -1.72353219e-02f, -4.86353040e-03f, -6.77951127e-02f, -1.76874891e-01f, -6.39001280e-02f, 1.07414834e-02f, -4.39921906e-03f, -6.30684048e-02f,
  6.13115095e-02f, 6.40691742e-02f, 2.28758920e-02f, 2.47885771e-02f, 4.71476242e-02f, 2.34102644e-03f, -9.82451439e-02f, -6.88799024e-02f, 2.52393237e-03f, 6.95017204e-02f,
  2.63559788e-01f, 5.75710647e-02f, 1.37904465e-01f, 9.44327489e-02f, -1.26261130e-01f, -1.25648245e-01f, -8.32710266e-02f, 7.22993836e-02f, 1.13171987e-01f, -2.56596059e-02f,
  -1.40358314e-01f, 6.13666065e-02f, 9.40910950e-02f, 1.87726751e-01f, 2.67192632e-01f, 1.52034745e-01f, 3.02047402e-01f, 2.16573551e-01f, 1.48545146e-01f, 1.03751935e-01f,
  8.02667663e-02f, -5.60180731e-02f, 6.29127398e-02f, 1.26840532e-01f, 1.39995068e-01f, 9.51856747e-02f, -3.26840058e-02f, -1.27659068e-01f, -7.62553811e-02f, 4.51430202e-01f,
  -8.81637931e-02f, -1.21557258e-01f, 1.23322140e-02f, -1.37371629e-01f, -2.55752057e-02f, 8.18005279e-02f, 3.36489715e-02f, -4.06138832e-03f, 3.19788642e-02f, -4.00537066e-02f,
  -1.27019539e-01f, -1.30284175e-01f, 8.42725486e-02f, -4.43083569e-02f, -4.23637405e-02f, -1.00473933e-01f, 1.04524698e-02f, 5.65197840e-02f, 1.18591249e-01f, 9.95642245e-02f,
  3.63151319e-02f, -1.88920006e-01f, -1.76963657e-01f, -1.44768029e-01f, 3.31203900e-02f, 4.04823236e-02f, -1.45232782e-01f, -3.42570096e-02f, -8.64342153e-02f, 2.42645182e-02f,
  4.30851504e-02f, -1.64283991e-01f, -3.17063294e-02f, 1.58371747e-01f, 1.27687126e-01f, 1.13353521e-01f, 1.61158577e-01f, 2.80149430e-02f, 1.15665182e-01f, 6.48034588e-02f,
  5.67735434e-02f, 5.15403114e-02f, -1.63116325e-02f, 3.79195139e-02f, -3.83086922e-03f, 3.17324325e-02f, 6.58116937e-02f, -1.33659557e-01f, -7.18268305e-02f, -1.14867844e-01f,
  -6.76173046e-02f, 8.05194080e-02f, 1.81830730e-02f, 2.16178983e-01f, 4.20924351e-02f, -4.90450067e-03f, 5.59498668e-02f, -3.96274701e-02f, -7.66313449e-03f, -1.23609982e-01f,
  -4.02404159e-01f, -4.37021136e-01f, 1.87574700e-01f, 1.82773117e-02f, -1.19609468e-01f, -1.20620981e-01f, -6.29783571e-02f, -4.24108356e-02f, -1.94138929e-03f, 9.73710883e-03f,
  -2.35996380e-01f, 4.82866764e-02f, -1.69761792e-01f, -6.82529360e-02f, -1.60966273e-02f, -7.19622523e-02f, 5.54649532e-02f, 1.35520592e-01f, -2.47640405e-02f, 2.13610511e-02f,
  6.05085865e-02f, -1.12374268e-01f, -2.15248302e-01f, 1.32601121e-02f, -1.12824060e-01f, -1.58378720e-01f, -2.01963365e-01f, -8.07534754e-02f, -2.47925475e-01f, -1.51894063e-01f,
  -3.60386640e-01f, 9.56400707e-02f, -5.37597835e-01f, 8.03423971e-02f, 2.59704262e-01f, 2.48837650e-01f, 4.37440693e-01f, 1.69955101e-02f, -6.39322326e-02f, 8.81275907e-02f,
  -1.51461631e-01f, -1.96813524e-01f, -9.84629542e-02f, -4.65334915e-02f, 3.67787816e-02f, 2.84976035e-01f, 4.08939064e-01f, -1.95173711e-01f, -2.82280624e-01f, 7.48611763e-02f,
  2.76315749e-01f, -7.17774918e-03f, -4.38336194e-01f, -6.13261499e-02f, 5.68649210e-02f, 7.11237788e-02f, -1.45807251e-01f, -1.01687610e-01f, 1.22282691e-01f, 2.25573093e-01f,
  -4.60018843e-01f, -5.02326608e-01f, 6.55741394e-02f, -9.55233052e-02f, -1.05677515e-01f, -5.99974729e-02f, 2.92465556e-02f, -2.55773157e-01f, -7.27398917e-02f, -2.10587922e-02f,
  -1.43466694e-02f, -1.69651479e-01f, 1.40055314e-01f, 2.82090530e-02f, 6.06762096e-02f, 1.42969014e-02f, -1.21427372e-01f, -2.59947777e-01f, -2.95318305e-01f, -2.68758953e-01f,
  3.30835760e-01f, -2.12590337e-01f, -4.63515162e-01f, -6.62584603e-02f, -9.49708372e-02f, -2.05959722e-01f, -4.08763111e-01f, -3.07707071e-01f, -4.03383553e-01f, -1.40462920e-01f,
  -9.46797337e-03f, -1.22539997e-01f, -1.13621550e-02f, 1.57084055e-02f, 4.22717966e-02f, -2.91259363e-02f, 2.71957535e-02f, 8.53433162e-02f, 3.45448405e-02f, -2.17454806e-02f,
  -1.15214065e-01f, -1.91881806e-02f, -1.39283925e-01f, -6.67307060e-03f, 7.20791146e-02f, -9.71342847e-02f, 6.81346804e-02f, 3.34259085e-02f, -1.00218333e-01f, 9.18903351e-02f,
  -1.51309706e-02f, -2.82455310e-02f, -9.64724720e-02f, 7.74051845e-02f, 6.73755035e-02f, -6.12642989e-02f, -1.09388782e-02f, 3.99486814e-03f, 8.94551910e-03f, -9.21948478e-02f,
  1.32307306e-01f, -1.17894020e-02f, -4.67043631e-02f, 6.54696673e-02f, 2.90295538e-02f, -8.03851187e-02f, -5.27405776e-02f, 1.84706897e-02f, 1.04348343e-02f, -5.13180047e-02f,
  -3.87910455e-02f, 2.02544741e-02f, 9.47922990e-02f, 6.94491342e-02f, 4.14664187e-02f, 5.37972562e-02f, 3.89294893e-01f, 1.14742868e-01f, 1.19193651e-01f, -6.13821223e-02f,
  2.45592013e-01f, 1.57422319e-01f, 8.82367603e-03f, 8.00907612e-02f, 5.13217896e-02f, 4.64718752e-02f, -1.11115180e-01f, -1.85098909e-02f, -7.95662552e-02f, 2.94697374e-01f,
  -8.25581491e-01f, -3.82070124e-01f, 5.30841667e-03f, -2.80454993e-01f, 6.59001097e-02f, 1.34380728e-01f, 1.28276870e-01f, -1.42598292e-02f, -9.30936560e-02f, -8.55272710e-02f,
  2.46196780e-02f, 2.49083966e-01f, 2.46721104e-01f, 2.21745014e-01f, 1.82118118e-01f, 2.32880250e-01f, 2.55405575e-01f, 3.02078575e-01f, 1.51646510e-01f, 4.78729643e-02f,
  1.15525231e-01f, -2.36923113e-01f, -1.83534011e-01f, -2.45701708e-02f, -1.29649594e-01f, 1.76586032e-01f, 1.73822790e-03f, -1.63191244e-01f, -7.67693855e-03f, -1.41907662e-01f,
  4.64035451e-01f, -4.36580539e-01f, 6.88759834e-02f, -1.59775153e-01f, -8.01730901e-02f, -2.06145763e-01f, -1.32547207e-02f, -1.92361400e-01f, -1.23645037e-01f, -6.29530624e-02f,
  -2.73528136e-02f, -3.73243690e-02f, 5.02998307e-02f, -1.14865981e-01f, -1.38773948e-01f, -9.43533257e-02f, -1.10381521e-01f, -1.59491412e-02f, 3.99900600e-02f, 6.51743710e-02f,
  9.26282331e-02f, -1.48219332e-01f, 1.01491742e-01f, 1.77306071e-01f, 4.87852655e-02f, 5.37307151e-02f, -8.68378878e-02f, -1.20514758e-01f, 8.88723806e-02f, -1.89299002e-01f,
  4.98959646e-02f, 1.33670479e-01f, -4.02530245e-02f, 9.78242382e-02f, 1.02579501e-03f, 5.38819237e-03f, 9.28767249e-02f, 2.89253127e-02f, 1.10331573e-01f, -4.47542034e-02f,
  -3.71969156e-02f, 7.56818280e-02f, 1.38315991e-01f, -2.69050281e-02f, -5.87192848e-02f, -7.52789229e-02f, -7.40785501e-04f, 1.45903798e-02f, 2.12168097e-02f, -5.39634861e-02f,
  2.49028020e-02f, -2.51948722e-02f, -7.54209086e-02f, 1.16684206e-03f, -4.56205867e-02f, -6.83148131e-02f, -8.70434847e-03f, 4.54344191e-02f, -7.84996450e-02f, -6.94136545e-02f,
  2.51993120e-01f, 2.86221474e-01f, 1.29116654e-01f, 5.02884053e-02f, -1.72585383e-01f, -1.71446040e-01f, 1.06553607e-01f, -1.09446421e-01f, -9.23077241e-02f, 1.58827856e-01f,
  4.23461534e-02f, -3.87006178e-02f, 5.58993174e-03f, -2.25576125e-02f, 2.90840585e-03f, -2.79200030e-03f, -8.41205567e-02f, 9.90050286e-02f, 1.20388426e-01f, 4.43962635e-03f,
  -5.44354804e-02f, 3.61015685e-02f, 1.31989092e-01f, 1.51849955e-01f, 8.51849839e-02f, 1.53534651e-01f, 2.25382537e-01f, 8.45166296e-02f, 1.68901935e-01f, 5.73408566e-02f,
  -5.64057902e-02f, 3.00029904e-01f, -1.10498518e-01f, 2.75593996e-01f, -1.50455059e-02f, -1.83341146e-01f, 1.26321865e-02f, 1.33094162e-01f, 1.91159487e-01f, 2.89337158e-01f,
  2.78927445e-01f, -1.09659232e-01f, -4.42665368e-02f, -2.53320694e-01f, -2.90682763e-01f, -1.42107442e-01f, -9.82359275e-02f, -3.73911768e-01f, -6.35757267e-01f, -1.57229125e-01f,
  -2.02746913e-01f, -1.58502251e-01f, -2.65416086e-01f, -2.70283252e-01f, 3.04087326e-02f, -3.62822354e-01f, -1.53111234e-01f, -2.16900766e-01f, -3.71257991e-01f, -2.57873207e-01f,
  -9.43331495e-02f, 8.29962790e-02f, -3.14053409e-02f, -3.58496867e-02f, -2.75690481e-03f, -4.68098819e-02f, -2.47370955e-02f, 3.21666710e-02f, 1.30498126e-01f, 7.12398440e-02f,
  -5.06218150e-02f, 1.74428031e-01f, -1.01322100e-01f, -4.35518287e-02f, -3.65043543e-02f, 4.73241210e-02f, 1.31682262e-01f, 3.48288454e-02f, 8.28648219e-04f, 1.98334903e-02f,
  1.76458567e-01f, -3.68141234e-02f, -4.61246297e-02f, 5.54361306e-02f, -1.62556931e-01f, -2.22328901e-01f, -3.02276778e-04f, -5.61010502e-02f, -3.06145519e-01f, 9.13292989e-02f,
  -1.60702541e-01f, -5.84529638e-02f, -1.96817815e-02f, 9.53139886e-02f, 6.38170987e-02f, 1.09760605e-01f, 1.20318895e-02f, 4.31781374e-02f, -5.62025681e-02f, 4.59284075e-02f,
  1.38513103e-01f, 5.91116846e-02f, 7.58982971e-02f, 3.16789486e-02f, 2.74740346e-02f, 3.53122838e-02f, -1.72162056e-02f, 1.00785661e-02f, 8.21403116e-02f, 6.40127584e-02f,
  1.42168431e-02f, -5.73094971e-02f, 6.48993105e-02f, -4.28174101e-02f, 8.40649754e-02f, -3.86517495e-02f, 4.09106612e-02f, 6.36409596e-02f, -4.73715961e-02f, 5.98918237e-02f,
  2.53900558e-01f, -1.18690841e-01f, 8.45472291e-02f, 7.34103546e-02f, 1.00156233e-01f, 2.03038707e-01f, 1.66004777e-01f, 1.52557150e-01f, 1.15330465e-01f, 1.51079938e-01f,
  5.94565421e-02f, 5.82300406e-03f, 1.67803355e-02f, 1.34190977e-01f, -8.24765209e-03f, 2.19822209e-02f, 2.17361823e-01f, 7.35829696e-02f, 1.78531173e-03f, 2.29385659e-01f,
  2.71831930e-01f, 1.14895344e-01f, -4.49172705e-02f, 2.90835276e-02f, -8.15517157e-02f, -2.22256392e-01f, -4.84601371e-02f, -1.25682671e-02f, -1.98598787e-01f, 7.34744444e-02f,
  -5.73764622e-01f, -2.27433890e-01f, -4.45210040e-01f, -5.96115828e-01f, -3.01907599e-01f, 1.54147729e-01f, 1.82776049e-01f, 2.94348635e-02f, -1.67849541e-01f, -3.31328243e-01f,
  -3.48356515e-02f, -1.80677071e-01f, -3.73579413e-01f, -7.06813112e-02f, 2.58254677e-01f, -2.89516654e-02f, -2.75230438e-01f, -2.16341957e-01f, 6.71436042e-02f, 2.24373698e-01f,
  -1.88543424e-02f, -2.68928051e-01f, -1.24710694e-01f, -8.06246251e-02f, -2.28340730e-01f, -2.52173394e-01f, -3.08259279e-01f, -2.22416684e-01f, 1.92675442e-01f, -2.85994142e-01f,
  -3.74986380e-01f, -1.37567788e-01f, 5.58405146e-02f, 4.10730578e-02f, -1.97046503e-01f, 3.68260336e-03f, -4.70632222e-03f, -2.33585954e-01f, -3.26758474e-02f, -8.76900181e-02f,
  -1.00544982e-01f, 7.47148767e-02f, -2.12840751e-01f, -4.77366038e-02f, -2.38278538e-01f, 9.55862254e-02f, -1.36004508e-01f, -9.61482003e-02f, -3.30116935e-02f, 1.99344441e-01f,
  1.18066303e-01f, -7.09142163e-02f, -3.54095153e-03f, 1.73292533e-01f, 1.05102859e-01f, 2.92215012e-02f, 1.90798312e-01f, 2.35616937e-01f, 2.01286465e-01f, -8.93449187e-02f,
  1.20126396e-01f, -1.01012163e-01f, -4.21213955e-02f, -1.59259383e-02f, 9.87453684e-02f, -9.45526455e-03f, -8.24724808e-02f, 1.09377302e-01f, 1.07580654e-01f, -7.71384537e-02f,
  4.71302494e-02f, 4.54019904e-02f, 5.59042208e-03f, -1.50199696e-01f, 1.51165612e-02f, -1.50793213e-02f, 6.35721385e-02f, -5.48583455e-03f, 6.86567873e-02f, -5.20823337e-02f,
  -1.17008546e-02f, -3.71988863e-02f, -4.19735126e-02f, 5.20486720e-02f, 1.20104067e-01f, -5.09437360e-02f, -1.21451346e-02f, 7.94388726e-02f, -1.38533577e-01f, 1.38804540e-01f,
  -5.02340913e-01f, 3.74991834e-01f, -1.63786814e-01f, -2.82410271e-02f, -1.05421782e-01f, -6.69047683e-02f, -2.04567447e-01f, -5.82461879e-02f, -1.25502646e-01f, 2.41245367e-02f,
  1.55933619e-01f, -7.28843957e-02f, -1.68166965e-01f, -2.75926366e-02f, 1.84253156e-02f, 4.04584855e-02f, 6.74295574e-02f, -8.28786194e-02f, 1.57743752e-01f, 4.45787944e-02f,
  1.65967494e-01f, 1.30521879e-01f, -3.41749266e-02f, -5.12528494e-02f, 5.22553995e-02f, -6.42727241e-02f, 1.90429483e-02f, 1.19769275e-01f, 1.78380325e-01f, -7.41804987e-02f,
  6.90967381e-01f, 4.73693050e-02f, -6.84401333e-01f, 2.82426685e-01f, -4.58976567e-01f, -4.49835718e-01f, -3.56531441e-01f, 2.77485877e-01f, 3.85264933e-01f, -1.96459144e-01f,
  -2.47286335e-01f, -2.07779072e-02f, 3.97368185e-02f, -1.08290389e-01f, -2.09063992e-01f, -2.96449482e-01f, -2.46530190e-01f, -3.66165400e-01f, -4.48510259e-01f, -2.98074961e-01f,
  -1.32172778e-01f, 1.33958578e-01f, 6.25528768e-02f, 5.86192217e-03f, 9.82925743e-02f, 1.85796674e-02f, -3.26743647e-02f, -1.03807360e-01f, -2.34130517e-01f, -1.83155417e-01f,
  -5.85171223e-01f, -7.33245686e-02f, -1.53645784e-01f, 1.18431985e-01f, -3.73973399e-02f, 2.89683398e-02f, -8.59358609e-02f, 1.03760511e-01f, 6.59462437e-02f, -2.58605536e-02f,
  -3.26996706e-02f, -1.15220301e-01f, -8.78484249e-02f, -2.47322023e-01f, -1.17319167e-01f, -8.63538533e-02f, 3.80726494e-02f, -9.53075066e-02f, 3.71700376e-02f, -1.04570568e-01f,
  -1.70241460e-01f, -3.49041790e-01f, -2.09225655e-01f, 8.22747592e-03f, -4.22143154e-02f, -2.11457103e-01f, -6.50251508e-02f, -8.30720589e-02f, 3.92646380e-02f, 2.50124246e-01f,
  7.48646557e-02f, 1.08350612e-01f, 1.67246927e-02f, 5.18493727e-02f, 1.09498672e-01f, 6.37601390e-02f, -2.57359818e-02f, 4.67677563e-02f, -7.53852203e-02f, 1.37753682e-02f,
  1.40242344e-02f, -4.74441685e-02f, 3.63236852e-02f, 6.21924223e-03f, 4.84245345e-02f, -5.20506315e-02f, 1.02372235e-02f, -1.70913804e-02f, -5.19001223e-02f, 6.69745356e-02f,
  -6.80913702e-02f, -9.96955335e-02f, 2.01939158e-02f, 7.03711510e-02f, -1.69545561e-02f, -2.47601885e-02f, 5.96075766e-02f, -1.76235866e-02f, 3.89256701e-02f, -3.83583605e-02f,
  3.81948918e-01f, -1.91232890e-01f, 1.97337896e-01f, 6.86970204e-02f, -7.75098205e-02f, -8.85371566e-02f, 6.99624270e-02f, -6.98538646e-02f, -1.08067691e-01f, -1.25363648e-01f,
  -2.27413684e-01f, 3.13269608e-02f, -1.06308796e-01f, -1.11752734e-01f, -2.29166836e-01f, -1.42662844e-03f, -1.07542805e-01f, -1.83393165e-01f, 1.64099112e-02f, 5.41369878e-02f,
  1.70912802e-01f, 1.02682382e-01f, 6.87499493e-02f, 1.17648266e-01f, 1.82758868e-01f, -1.33402292e-02f, -8.49099606e-02f, 1.51472269e-02f, -3.20915431e-02f, 3.17133665e-01f,
  7.34847844e-01f, 4.53340411e-01f, -3.69228512e-01f, 2.33867481e-01f, 1.03109311e-02f, 5.96871637e-02f, 3.70677173e-01f, 3.54936153e-01f, 1.90870121e-01f, 2.78106660e-01f,
  3.19653451e-01f, 8.14931840e-02f, 2.70817745e-02f, -4.45420668e-02f, 6.23989813e-02f, -8.81177112e-02f, -1.26206189e-01f, -3.08640867e-01f, -2.09736243e-01f, 4.12417091e-02f,
  1.15691656e-02f, 2.58774102e-01f, 2.48468637e-01f, 6.91243410e-02f, -1.70845583e-01f, -1.58199221e-01f, 7.87587557e-03f, -5.07713296e-02f, -3.50655429e-02f, -4.87854391e-01f,
  -4.51385438e-01f, 5.86055405e-02f, -6.36135563e-02f, 2.65534203e-02f, 3.51870768e-02f, 1.48796231e-01f, 8.53957757e-02f, 1.38029084e-02f, 1.13362454e-01f, -4.96801585e-02f,
  -1.57457173e-01f, -3.03762089e-02f, -1.52553748e-02f, -8.12897906e-02f, 5.94168641e-02f, -9.29236859e-02f, 5.37185967e-02f, -9.48189013e-03f, -2.08974890e-02f, -7.17631951e-02f,
  3.68196256e-02f, -7.90277869e-02f, 4.95036393e-02f, 5.77626862e-02f, -5.45104034e-02f, -2.13635270e-03f, -6.96772784e-02f, -1.74654394e-01f, -3.83022316e-02f, 1.00010112e-01f,
  -8.72786902e-03f, 4.90392968e-02f, -4.88228276e-02f, -2.10667931e-04f, 1.24049537e-01f, -2.33159699e-02f, -2.12805420e-02f, -2.42741872e-02f, 7.19135553e-02f, 7.19355866e-02f,
  1.10226810e-01f, -8.07778686e-02f, 1.82234757e-02f, 1.26912400e-01f, -9.11611393e-02f, -4.19144258e-02f, -7.45061636e-02f, 9.71379224e-03f, -2.39131600e-02f, 9.68285054e-02f,
  2.84497403e-02f, 6.82083890e-02f, 1.63002815e-02f, -6.06174730e-02f, 5.10045560e-03f, -1.07212238e-01f, -1.00834072e-01f, 3.93867642e-02f, 3.91705930e-02f, 6.55835867e-02f,
  2.42682889e-01f, 3.25383507e-02f, -1.23035043e-01f, -6.15514256e-02f, -1.87571168e-01f, -7.55539462e-02f, -3.25530954e-02f, -9.63647440e-02f, -1.26825590e-02f, -1.03622511e-01f,
  -3.30601670e-02f, 1.15629109e-02f, -1.69229740e-03f, 6.25218600e-02f, -4.18145768e-02f, -3.43236402e-02f, 1.98070422e-01f, 8.56590346e-02f, -7.17869475e-02f, -1.29303301e-03f,
  5.72525002e-02f, 1.35471106e-01f, 1.00609124e-01f, 1.05592869e-01f, -7.08736330e-02f, -3.26392464e-02f, 6.84055313e-02f, -5.05344868e-02f, -1.05038453e-02f, 3.78562331e-01f,
  3.74381632e-01f, -3.15684736e-01f, -1.28575653e-01f, 1.00668751e-01f, 1.31240159e-01f, 1.28574163e-01f, 2.20198244e-01f, 9.35048759e-02f, 1.39182806e-01f, -2.23430190e-02f,
  -2.50045985e-01f, -2.55810350e-01f, -9.69853625e-02f, -1.49049252e-01f, -1.03236742e-01f, 1.72531549e-02f, 1.33749634e-01f, -5.22636401e-04f, 1.26320168e-01f, 1.48838326e-01f,
  1.20528843e-02f, 1.32989869e-01f, 1.71077326e-02f, -6.52394593e-02f, -3.75590771e-02f, 2.43927073e-02f, -8.06780457e-02f, -6.71641678e-02f, -3.12445521e-01f, -2.59989560e-01f,
  2.59318948e-01f, -3.15420896e-01f, -2.24431511e-02f, -2.02539071e-01f, -1.59618452e-01f, -3.83600630e-02f, -1.87972095e-02f, -1.43634096e-01f, -1.69575028e-02f, 1.06979296e-01f,
  -1.68239281e-01f, -1.76237926e-01f, -8.39731023e-02f, -9.29944441e-02f, 9.01729241e-03f, -1.21120475e-02f, -1.44794673e-01f, -1.99505258e-02f, -1.66858450e-01f, -1.26865089e-01f,
  -1.67785838e-01f, -4.89253327e-02f, 6.85009584e-02f, -1.35864997e-02f, -1.93665490e-01f, -5.60605638e-02f, -2.99805775e-02f, -1.48221806e-01f, -2.59287637e-02f, 4.10636552e-02f,
  1.18821003e-01f, 6.01846725e-02f, -1.52129576e-01f, -4.61538993e-02f, 5.69990799e-02f, 7.67932758e-02f, 1.38190359e-01f, 2.56909002e-02f, 1.07965441e-02f, 3.17273363e-02f,
  8.57746974e-02f, 6.69335155e-03f, -2.92856572e-03f, 4.70079854e-02f, -1.61121413e-01f, -1.50247151e-02f, -4.82535325e-02f, -3.28794718e-02f, -1.24660127e-01f, -1.03212893e-01f,
  -1.42768383e-01f, -5.58612347e-02f, -3.26112881e-02f, -7.40783066e-02f, -2.12687165e-01f, -7.07109496e-02f, -1.40992682e-02f, -9.85655114e-02f, -7.88069591e-02f, -7.59971365e-02f,
  3.11874777e-01f, -1.48760363e-01f, 2.30397165e-01f, -8.07359815e-02f, 2.18493049e-03f, -1.16440423e-01f, -9.76608694e-02f, -5.77479415e-02f, -6.06531538e-02f, 1.06179886e-01f,
  -6.63673654e-02f, -6.22922108e-02f, 7.71988556e-02f, 1.02822341e-01f, 2.16768250e-01f, -1.34306150e-02f, -5.66594601e-02f, 3.76948975e-02f, -8.75591263e-02f, 6.13778876e-03f,
  5.91261610e-02f, 5.75816184e-02f, 2.05965415e-01f, 1.53218105e-01f, 5.42296693e-02f, 2.29182616e-01f, 1.87122285e-01f, 1.67244803e-02f, 2.03381345e-01f, 3.85560304e-01f,
  5.57818234e-01f, -1.83948472e-01f, 1.10197172e-01f, 1.00604542e-01f, -1.70965061e-01f, -1.25255138e-01f, -3.13514739e-01f, -1.21300137e-02f, -3.91596630e-02f, 3.64849530e-02f,
  4.52892296e-02f, 1.81257978e-01f, 1.55922130e-01f, 2.35075116e-01f, 1.42520174e-01f, 2.00060289e-03f, -3.66199799e-02f, 2.15562388e-01f, 1.09904826e-01f, -4.55438569e-02f,
  -1.38231575e-01f, -4.69609909e-02f, 3.27922516e-02f, 9.74091887e-02f, -1.63947821e-01f, 5.53925224e-02f, -1.33635402e-01f, -2.36531571e-01f, -1.84975341e-01f, -1.19588427e-01f,
  1.05450623e-01f, 1.02910846e-01f, 2.33258978e-01f, 1.46724895e-01f, -6.57764673e-02f, 9.68672186e-02f, 1.80890396e-01f, -2.79713739e-02f, -1.21530965e-01f, -3.82663384e-02f,
  9.65005253e-03f, -5.10181226e-02f, -6.26368821e-02f, -1.63582355e-01f, -1.66712284e-01f, -7.34566078e-02f, -1.46474913e-02f, 5.26124388e-02f, -4.14300263e-02f, -7.80232251e-02f,
  -6.55103624e-02f, -3.74948494e-02f, 1.77933760e-02f, -6.05365774e-03f, 1.46459177e-01f, 9.22338665e-02f, 9.62956846e-02f, -1.46149062e-02f, 1.02392562e-01f, 7.10600168e-02f,
  -5.42001128e-02f, 7.76285455e-02f, 1.31176114e-01f, 1.26219699e-02f, 1.95592567e-02f, -5.86049594e-02f, 3.98776494e-02f, -3.28623839e-02f, -1.95827670e-02f, -6.69774339e-02f,
  -6.90652281e-02f, 1.02372080e-01f, 1.15926847e-01f, 4.79862131e-02f, 8.51822495e-02f, 4.65792604e-02f, 1.92962401e-02f, 6.17164075e-02f, -8.00908264e-03f, -3.76593992e-02f,
  9.99303088e-02f, -2.73109097e-02f, -1.20872378e-01f, -3.78506221e-02f, -3.78277414e-02f, 3.35583813e-03f, -7.33544379e-02f, -7.44479746e-02f, 4.86794999e-03f, -1.42008275e-01f,
  -1.57629132e-01f, 4.48008418e-01f, 2.63074785e-01f, 1.44502968e-01f, -5.33719957e-02f, -4.71105091e-02f, 2.53458172e-01f, 1.67368483e-02f, -1.66463897e-01f, 8.32599550e-02f,
  2.18567662e-02f, 7.15902001e-02f, 6.64487705e-02f, -1.67144723e-02f, -5.82398660e-02f, -6.45408733e-03f, -5.74023090e-02f, -3.27268615e-02f, -8.16808641e-02f, -4.08727676e-03f,
  -1.29405454e-01f, -1.08608477e-01f, 1.32557705e-01f, 1.45186946e-01f, 1.41850770e-01f, 1.02880567e-01f, 7.95385987e-02f, -6.32781610e-02f, -3.30001712e-02f, 1.82355922e-02f,
  3.22397768e-01f, -3.24056476e-01f, -7.24841833e-01f, 2.41884470e-01f, 1.99102327e-01f, -1.30805060e-01f, -5.15818179e-01f, -2.64577359e-01f, 2.68832356e-01f, 2.28209980e-02f,
  2.25646600e-01f, 4.85907942e-01f, 4.45306953e-03f, 3.31387594e-02f, -2.78966188e-01f, -3.71447325e-01f, -2.98385441e-01f, -2.55415291e-01f, 1.15306936e-02f, 3.09599578e-01f,
  4.03933078e-01f, 3.01006049e-01f, 3.26773703e-01f, 1.00121200e-01f, 2.19935834e-01f, 1.14685766e-01f, -2.25793585e-01f, 8.44744071e-02f, 1.13207296e-01f, -5.07634245e-02f,
  5.30176796e-02f, -3.97318527e-02f, -7.65935555e-02f, 3.24652940e-01f, 5.56056984e-02f, -1.51518404e-01f, -1.31069154e-01f, -1.82156935e-01f, 6.69011027e-02f, -9.33659524e-02f,
  1.91756010e-01f, 1.17629305e-01f, 2.31875688e-01f, 1.00854933e-01f, 2.01524049e-01f, -6.82423413e-02f, -1.62991822e-01f, -2.91394681e-01f, -3.75065714e-01f, -3.76579426e-02f,
  9.16004255e-02f, 1.44839928e-01f, -1.82867661e-01f, -3.60121280e-01f, -3.69178534e-01f, -1.18095532e-01f, -1.61658406e-01f, -6.35126531e-02f, -4.24545705e-01f, -2.41160840e-01f,
  7.34258220e-02f, -4.85364906e-02f, 8.77962355e-03f, -6.73887730e-02f, 9.01711732e-02f, -1.22248121e-02f, -2.67242156e-02f, 5.75446114e-02f, 2.01567963e-01f, -7.94121921e-02f,
  -4.71881926e-02f, 6.64089471e-02f, 3.20480578e-02f, -5.94111830e-02f, 6.58338219e-02f, -2.47198511e-02f, -4.52947430e-03f, -1.50058880e-01f, 5.08874319e-02f, -7.04062954e-02f,
  1.11929789e-01f, -7.68754557e-02f, 7.53033161e-02f, 4.39694747e-02f, -4.03229892e-02f, -1.42674625e-01f, -1.63914822e-02f, 7.99708590e-02f, -1.44441519e-02f, 3.75495329e-02f,
  5.92619702e-02f, -1.87477380e-01f, 3.83347869e-02f, -2.20072456e-02f, 2.23781168e-02f, 1.12497481e-02f, -1.13815963e-02f, 3.98174375e-02f, 1.48194935e-02f, -6.87809214e-02f,
  4.05655429e-02f, -4.86773439e-02f, 2.55946256e-02f, 3.59950773e-02f, 7.95047432e-02f, 9.27517861e-02f, -1.51750362e-02f, 8.33654702e-02f, 3.94428819e-02f, 1.23458028e-01f,
  -1.44769594e-01f, 5.23817763e-02f, 2.04450246e-02f, -3.20240796e-01f, 4.99096699e-02f, 7.26663768e-02f, -1.17813163e-01f, -1.79834574e-01f, -3.87053221e-01f, -5.09412348e-01f,
  -3.98165196e-01f, -1.95204422e-01f, -3.78384352e-01f, -1.14305273e-01f, -4.10477407e-02f, -1.03184372e-01f, -1.59762695e-01f, 3.28130275e-02f, -1.09081753e-02f, -1.23396248e-01f,
  -1.02166086e-02f, 2.00141817e-02f, -1.63241118e-01f, -2.26323545e-01f, -3.17237437e-01f, -3.50963265e-01f, -4.08433259e-01f, -5.12415946e-01f, -3.17948431e-01f, 2.91968826e-02f,
  -7.63269663e-02f, -2.59043813e-01f, -2.39508256e-01f, -1.54600561e-01f, 7.22186044e-02f, -8.25070031e-03f, -1.82228312e-01f, -1.95291936e-01f, -1.52110040e-01f, -1.94474593e-01f,
  -1.31842211e-01f, 1.47783548e-01f, -2.60986648e-02f, 6.61750976e-03f, 1.89545341e-02f, -4.42025289e-02f, -7.75348321e-02f, -2.60975156e-02f, 8.42251554e-02f, 1.65357351e-01f,
  3.49760614e-02f, 8.91211778e-02f, 6.53963089e-02f, 9.03929248e-02f, 7.99521208e-02f, 2.30668709e-02f, 6.34934604e-02f, 2.20792647e-02f, 2.95312162e-02f, 1.91160157e-01f,
  1.22902378e-01f, 5.57220653e-02f, 9.53762382e-02f, 2.55164027e-01f, 1.44248188e-01f, 9.47704017e-02f, 1.15248889e-01f, 1.81316644e-01f, 6.26338199e-02f, 2.64223963e-01f,
  2.07129680e-02f, 1.65393546e-01f, 5.79921640e-02f, 2.85041090e-02f, 9.79485512e-02f, 2.22814567e-02f, 6.51748553e-02f, 1.22427888e-01f, -7.91225731e-02f, -6.82577565e-02f,
  7.21999183e-02f, -2.58821175e-02f, -8.20428580e-02f, -6.52608350e-02f, -5.78490570e-02f, -9.84806046e-02f, -4.76015396e-02f, -8.69465694e-02f, 2.64620315e-02f, -2.22477876e-02f,
  -1.71128530e-02f, 8.24978426e-02f, -1.31818846e-01f, 8.74594674e-02f, -9.56931785e-02f, -5.93123287e-02f, -6.85329363e-02f, -5.05064838e-02f, -1.11625679e-01f, 3.31608057e-02f,
  5.94798289e-02f, -2.86842555e-01f, -1.48108467e-01f, 4.33003493e-02f, -7.39450157e-02f, -2.45818845e-03f, 3.78754623e-02f, -8.94668996e-02f, 5.03760502e-02f, 1.09057352e-01f,
  9.59569663e-02f, -5.76646021e-03f, -1.85762644e-02f, 1.53623551e-01f, 7.91583508e-02f, -6.84308782e-02f, -1.20281547e-01f, 3.03173568e-02f, -4.12497632e-02f, 6.04441687e-02f,
  -3.88314314e-02f, -1.87534709e-02f, -3.55293602e-02f, 2.90706754e-02f, 5.56075834e-02f, -2.06836417e-01f, 3.05983704e-02f, 1.16172828e-01f, -7.62176439e-02f, 8.68225619e-02f,
  -2.89127409e-01f, 3.93682927e-01f, 3.60296845e-01f, -9.23092365e-02f, 3.58717561e-01f, -9.31123178e-03f, 2.39954377e-03f, -2.35669225e-01f, -3.61831263e-02f, 3.75301331e-01f,
  3.96991163e-01f, -1.00634024e-02f, 8.58376622e-02f, -3.15575255e-03f, -2.61904478e-01f, 8.95436183e-02f, 1.05948597e-01f, -2.68797725e-01f, -4.92781699e-01f, -3.46914232e-01f,
  -8.33422840e-02f, -2.28513569e-01f, -3.52486998e-01f, -3.14372301e-01f, 1.49204701e-01f, -4.25260626e-02f, 1.76628083e-01f, 4.17329334e-02f, 7.93289840e-02f, 2.86209434e-01f,
  7.04574287e-02f, 2.05068141e-01f, -9.91923809e-02f, 4.85566035e-02f, 2.35727265e-01f, -1.20363943e-01f, -1.72862224e-02f, 1.21256679e-01f, 1.87700279e-02f, 2.05289498e-02f,
  2.13941082e-01f, 1.02585673e-01f, 1.57630816e-01f, -4.40809876e-02f, -6.99581578e-02f, -2.54320443e-01f, -4.92299534e-02f, -2.35766977e-01f, -2.48937875e-01f, -1.80953413e-01f,
  7.90747404e-02f, 1.84487313e-01f, -2.17548814e-02f, -6.90085739e-02f, -5.46835363e-02f, -9.21420902e-02f, -1.89958572e-01f, -2.71223575e-01f, -2.26723820e-01f, -3.56895417e-01f,
  -1.68430631e-03f, 3.18880454e-02f, 6.00237884e-02f, 3.56744304e-02f, -3.20286006e-02f, 1.56557769e-01f, 1.91750079e-01f, 1.47457317e-01f, 9.60015599e-03f, -8.11894983e-02f,
  4.94968481e-02f, 5.30556738e-02f, 4.81790490e-02f, 3.91868986e-02f, -5.99461496e-02f, 5.23100533e-02f, -1.61175039e-02f, -9.82776359e-02f, 1.91797726e-02f, 5.08863479e-02f,
  -6.31551966e-02f, 5.47498241e-02f, 5.12284450e-02f, -9.13347825e-02f, 9.49212238e-02f, 6.64655194e-02f, 4.78706695e-02f, -3.17878053e-02f, -7.13661453e-03f, 4.88737635e-02f,
  -2.84143656e-01f, 9.24446881e-02f, -4.35287086e-03f, -9.18011367e-02f, 8.23798701e-02f, 1.97909903e-02f, 1.48494795e-01f, 1.15702106e-02f, 1.23573191e-01f, -1.93159580e-01f,
  -9.02977288e-02f, 5.83721586e-02f, 1.50039941e-01f, -8.41865465e-02f, -1.90896451e-01f, -2.46755639e-03f, 8.21716711e-02f, -2.61230450e-02f, -1.01473816e-01f, -1.11680649e-01f,
  -9.52126831e-02f, -3.46298367e-01f, -2.75412768e-01f, -1.17752820e-01f, -1.35413960e-01f, -1.71938539e-01f, -2.43112743e-01f, -2.85946101e-01f, -2.32886493e-01f, -5.27968287e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.33456284e-01f, 1.33885201e-02f, 2.87371665e-01f, 2.67477125e-01f, 2.14882940e-01f, 5.27906120e-01f, 3.85746628e-01f, 2.07978785e-01f, 1.41109034e-01f, 2.43856549e-01f,
  3.27902436e-01f, 2.61797249e-01f, 3.44200164e-01f, 1.41947240e-01f, 1.57645255e-01f, 5.29103279e-01f, 5.40536821e-01f, 3.58949304e-01f, 1.52852252e-01f, 3.28067750e-01f,
  3.78505200e-01f, 5.44574440e-01f, 1.90961346e-01f, 3.67945910e-01f, 1.28693745e-01f, 2.39539057e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -7.70214829e-04f, -2.06419542e-01f, -3.13211083e-02f, -6.57280535e-02f, -1.88944653e-01f, -1.37566984e-01f, -7.38767236e-02f, -1.34932458e-01f, 3.60208899e-02f, -2.04424232e-01f,
  -3.83907855e-02f, -1.42191932e-01f, -2.23909542e-02f, -1.73572395e-02f, -1.34688556e-01f, 5.17223123e-03f, -2.48512551e-01f, -1.75089523e-01f, -3.33456546e-02f, 2.33225673e-01f,
  1.07698373e-01f, -1.76562607e-01f, 1.67733476e-01f, -5.73247522e-02f, 1.36140451e-01f, 2.04366475e-01f, -1.18411750e-01f, 3.39425243e-02f, -1.01849183e-01f, -1.19238868e-01f,
  3.84105071e-02f, -5.70197776e-03f, 1.11609131e-01f, 1.13807999e-01f, 1.04188487e-01f, 1.14625946e-01f, 8.59787762e-02f, -1.30424738e-01f, -5.71722127e-02f, -7.29309618e-02f,
  -9.46698487e-02f, -3.58044356e-02f, -1.19285591e-01f, -5.26656881e-02f, 7.45801926e-02f, 3.94020975e-02f, 1.24639282e-02f, 1.15602925e-01f, -2.09396273e-01f, -9.14795995e-02f,
  -5.31504489e-02f, 5.14546968e-02f, -4.61281687e-02f, 6.17545024e-02f, 2.61081934e-01f, -5.29788015e-03f, 5.98609671e-02f, -4.22562420e-01f, -2.83784736e-02f, 1.19400144e-01f,
  -1.21510647e-01f, -4.07798558e-01f, -9.41939354e-02f, 1.59264013e-01f, 4.94420789e-02f, -1.28216758e-01f, -2.80086957e-02f, 1.50615856e-01f, -1.58159584e-01f, -1.58278400e-03f,
  -1.38068780e-01f, -2.41365787e-02f, -5.64684719e-02f, -1.60937145e-01f, -3.04313283e-02f, -8.00466686e-02f, -1.45951390e-01f, 1.03405334e-01f, 7.52894953e-02f, -6.76644072e-02f,
  -7.00956583e-02f, -1.18548609e-01f, 3.39015312e-02f, 1.68169945e-01f, -7.39495158e-02f, -1.98001545e-02f, -8.98409542e-03f, -7.66421407e-02f, -2.13734314e-01f, -9.14367847e-03f,
  6.18977621e-02f, -2.21315563e-01f, -9.27829072e-02f, -1.46810144e-01f, 1.56677905e-02f, -1.74093112e-01f, 7.98330829e-03f, 1.78028777e-01f, -1.34758815e-01f, 8.00561458e-02f,
  -1.93067670e-01f, 1.10747032e-01f, 2.79348493e-01f, 1.20312452e-01f, 7.63566867e-02f, 5.81067987e-02f, -1.03576556e-02f, -7.25938752e-02f, -1.02967970e-01f, -8.70479345e-02f,
  2.74820272e-02f, -4.28227969e-02f, -5.53932749e-02f, 9.50564444e-02f, -1.70637399e-01f, 6.48742635e-03f, -3.22358608e-02f, 2.17480943e-01f, 2.19284058e-01f, -1.25829622e-01f,
  5.05504943e-02f, -2.76091754e-01f, -3.65193060e-04f, -6.92401975e-02f, 1.23133399e-01f, 3.74375194e-01f, 3.28074992e-01f, -9.44844633e-03f, -1.15310885e-02f, -1.43401861e-01f,
  -1.13710677e-02f, 4.48135436e-02f, -8.70092213e-03f, 7.01926351e-02f, -1.36991695e-01f, 1.46164671e-01f, -1.11850742e-02f, -1.15638629e-01f, -3.62134203e-02f, 9.54812318e-02f,
  -8.32130909e-02f, -8.83802306e-03f, 1.27861127e-02f, -2.76694689e-02f, 7.87589550e-02f, 1.44579202e-01f, 1.16862215e-01f, 4.49552853e-03f, 1.13533311e-01f, -8.65815580e-02f,
  9.93042365e-02f, 3.08476359e-01f, 7.90113509e-02f, 2.28714600e-01f, -7.97987357e-02f, -1.28097758e-02f, -8.27766731e-02f, 1.54781165e-02f, 5.15070595e-02f, 7.59347677e-02f,
  1.38408497e-01f, 2.07928754e-02f, 1.09419599e-01f, -2.79036984e-02f, 2.75715053e-01f, 4.56294715e-02f, 1.72732085e-01f, -1.39153060e-02f, 1.49215162e-01f, -2.78378159e-01f,
  -2.41696164e-02f, 4.29497175e-02f, 1.37370706e-01f, 1.93302199e-01f, 8.07274133e-02f, 2.28601620e-01f, 1.47141516e-01f, 9.44536626e-02f, 2.08933540e-02f, 1.75029352e-01f,
  1.77518162e-03f, 6.00184835e-02f, -3.44863124e-02f, -2.65501559e-01f, 2.77680278e-01f, -1.85233504e-01f, -1.08856469e-01f, -1.84431877e-02f, 3.76198664e-02f, -2.88412213e-01f,
  -2.57807989e-02f, 6.45589782e-03f, -2.16580685e-02f, -1.85999110e-01f, -1.61151886e-02f, -3.43234576e-02f, -1.04103036e-01f, -2.10419856e-02f, -1.95016056e-01f, -6.09130273e-03f,
  4.67655659e-02f, -8.13759267e-02f, -1.59660354e-01f, 1.47785544e-01f, 1.79135293e-01f, -1.29718944e-01f, 4.55156416e-02f, 7.04103187e-02f, -2.10866164e-02f, -7.00420663e-02f,
  -6.80298060e-02f, 1.45943500e-02f, -1.01252049e-01f, 8.62953812e-02f, 2.68975813e-02f, 9.80212092e-02f, 1.57693356e-01f, 2.63444066e-01f, -1.52539471e-02f, 1.14334889e-01f,
  -1.20927110e-01f, 8.94183144e-02f, 4.11784127e-02f, -5.33566661e-02f, -1.26026556e-01f, -5.20723872e-02f, 1.71577945e-01f, -1.96236521e-01f, 2.59218693e-01f, 4.02382389e-02f,
  -2.51602530e-01f, 8.06880072e-02f, -1.18120268e-01f, 1.02852359e-01f, -3.08999509e-01f, -4.05000225e-02f, 2.58224398e-01f, -1.63243875e-01f, 3.86464000e-02f, 1.62141025e-02f,
  -2.74166912e-01f, 9.15468335e-02f, 5.83708920e-02f, 5.33262789e-02f, 4.75407615e-02f, 7.40502477e-02f, -1.78244740e-01f, -1.41493872e-01f, 3.35237645e-02f, -1.04691617e-01f,
  -9.53287035e-02f, -1.68405354e-01f, 4.48911488e-02f, -1.64077848e-01f, -1.27357274e-01f, 3.10204148e-01f, -8.36237594e-02f, 1.25329420e-01f, -3.86966914e-02f, -3.98054048e-02f,
  1.76640917e-02f, -6.63708448e-02f, 8.65810588e-02f, -1.57323226e-01f, -3.92404497e-02f, -2.62820870e-02f, 3.68508324e-02f, -1.97475120e-01f, 1.48163009e-02f, -8.07299465e-02f,
  1.26505062e-01f, -6.67025074e-02f, -1.08888276e-01f, -5.74670322e-02f, -1.37916744e-01f, -2.36742310e-02f, -8.82456005e-02f, 1.67550042e-01f, -5.21683432e-02f, -1.45777419e-01f,
  -1.85454637e-01f, -1.51732080e-02f, 1.68602839e-01f, -1.37112096e-01f, 1.18886776e-01f, 1.23639621e-01f, -1.92892686e-01f, -2.79073268e-01f, 1.64978523e-02f, -1.10714277e-02f,
  8.28269199e-02f, 8.00365582e-02f, -2.85166539e-02f, 7.84689561e-02f, -2.94877112e-01f, -4.98138517e-02f, 1.90575738e-02f, 2.59999841e-01f, 1.23944074e-01f, -6.16219677e-02f,
  -1.34981081e-01f, -1.54294878e-01f, -9.20298621e-02f, 1.59547865e-01f, -5.00798643e-01f, -1.34025291e-01f, 8.63902550e-03f, 2.71460507e-02f, 3.99026871e-02f, 2.87788004e-01f,
  5.10602631e-02f, 2.65070230e-01f, -5.69969416e-02f, 1.03997864e-01f, -6.31953822e-03f, -7.08333254e-02f, -1.31698176e-01f, 1.59347504e-01f, 8.89093801e-02f, 1.10094398e-01f,
  2.69540888e-03f, -1.60924979e-02f, -5.25286347e-02f, -2.99548432e-02f, -1.92476571e-01f, 2.35540457e-02f, -1.81307659e-01f, -9.00655612e-02f, -6.56496733e-02f, 3.83796096e-02f,
  -5.93544692e-02f, 1.06336385e-01f, -1.62688464e-01f, -1.38135673e-03f, -4.83224019e-02f, -1.44522730e-02f, -2.04304401e-02f, 6.13902090e-03f, -1.26962215e-01f, 1.12948261e-01f,
  3.51508078e-03f, -3.86246026e-01f, -4.44932934e-03f, -2.02587292e-01f, -2.54829191e-02f, -7.09707141e-02f, -8.17479864e-02f, 4.68190014e-03f, 6.95332289e-02f, -9.52034295e-02f,
  -9.74018201e-02f, -1.74963608e-01f, 1.06531493e-01f, 8.76033679e-02f, -1.65294230e-01f, 1.41325042e-01f, -8.84620324e-02f, -1.73177585e-01f, 2.94421762e-01f, -1.24102660e-01f,
  1.60593003e-01f, 1.06210537e-01f, 1.81927830e-01f, -1.56721368e-01f, -2.43378580e-01f, 1.07980236e-01f, 1.10206798e-01f, 2.30235174e-01f, -1.80914491e-01f, -1.06623530e-01f,
  -1.92036536e-02f, 1.59288138e-01f, -9.50845480e-02f, 1.98292121e-01f, 1.66893139e-01f, 4.54057641e-02f, 1.27085373e-01f, -1.19306266e-01f, 2.47271322e-02f, -1.20432787e-01f,
  -9.88064632e-02f, 4.86524291e-02f, 2.45546207e-01f, -5.40279178e-03f, -5.02971634e-02f, 4.47332626e-03f, 5.13978899e-02f, -4.25601378e-02f, 1.15756188e-02f, 5.34405708e-02f,
  1.34721741e-01f, -1.52302921e-01f, 1.69996396e-01f, -1.16662029e-02f, -3.94008569e-02f, 4.35434729e-02f, -6.26997789e-03f, -1.34058446e-01f, 5.04695103e-02f, -1.02800898e-01f,
  3.58238164e-03f, 4.07645330e-02f, -5.79810105e-02f, -1.48236468e-01f, 2.27578674e-02f, -1.18180968e-01f, -1.96257662e-02f, -1.81152392e-02f, -5.59958965e-02f, -1.12542599e-01f,
  6.95346519e-02f, -6.53287023e-02f, 2.79503673e-01f, -1.28906313e-02f, -1.97736606e-01f, 1.58582151e-01f, 6.76256567e-02f, -4.79287654e-02f, 1.08629636e-01f, 7.95741286e-03f,
  1.13382295e-01f, 5.00998534e-02f, -1.71418533e-01f, -8.86647925e-02f, 8.71582031e-02f, 7.39211440e-02f, 2.23663431e-02f, 1.74905721e-03f, -9.00428146e-02f, 3.30303520e-01f,
  -1.49457514e-01f, 1.48961961e-01f, 2.93791890e-02f, 4.09649238e-02f, 2.16965213e-01f, 3.17791291e-02f, -1.56852067e-01f, -1.59429893e-01f, 4.67442684e-02f, 6.36389628e-02f,
  -5.09976223e-02f, -5.40008694e-02f, -2.08280221e-01f, 3.64479981e-02f, -1.15904704e-01f, 2.83827513e-01f, 1.33685812e-01f, 1.60937831e-02f, 1.19846530e-01f, -3.02107371e-02f,
  -5.33751994e-02f, -1.07288040e-01f, -3.92296053e-02f, -1.45454314e-02f, 5.30927777e-02f, -8.48824717e-03f, -1.02536857e-01f, -1.36160374e-01f, -1.11541323e-01f, 9.40072536e-02f,
  -2.88993698e-02f, -1.07854642e-01f, 2.84298062e-02f, -1.78278834e-01f, 4.23819348e-02f, -8.31285417e-02f, -8.43065679e-02f, 5.02504930e-02f, 2.10953698e-01f, -1.35366559e-01f,
  6.53950945e-02f, -1.82879239e-01f, -9.43009332e-02f, 8.66814889e-03f, -1.17160171e-01f, -1.58305198e-01f, -8.25504120e-03f, -1.79816350e-01f, 9.91426855e-02f, 6.61836192e-02f,
  1.34606406e-01f, 1.87581906e-03f, -1.48768172e-01f, 1.85855031e-01f, 5.98094650e-02f, 2.09475309e-02f, 3.08888167e-01f, -4.35715206e-02f, 5.53480024e-03f, -1.44801602e-01f,
  -2.54774503e-02f, 6.60485625e-02f, 7.00006559e-02f, 3.69013399e-02f, 2.35508550e-02f, 8.16224366e-02f, 2.19492987e-01f, -1.99819013e-01f, -7.20437325e-04f, 3.60420570e-02f,
  -4.00905982e-02f, -1.44979870e-02f, 1.33933231e-01f, -1.14204809e-01f, 3.70942146e-01f, -1.14393145e-01f, -6.18627593e-02f, -2.00620294e-01f, 9.63387191e-02f, -4.18336578e-02f,
  2.98153819e-03f, -1.04587980e-01f, 3.33925597e-02f, 1.92124769e-01f, 2.80283280e-02f, 7.32075945e-02f, 8.88755023e-02f, -5.33138122e-03f, 6.82637170e-02f, 4.95334901e-02f,
  1.10452680e-03f, 1.05907053e-01f, -2.04493850e-02f, 7.16395825e-02f, 1.18247338e-01f, 9.46973339e-02f, -1.12513579e-01f, -6.58495352e-02f, -1.58785269e-01f, -1.85885206e-02f,
  1.46584928e-01f, -4.75012138e-02f, 2.45904103e-02f, 1.51702538e-01f, 1.25288665e-01f, 6.22958466e-02f, -1.22109681e-01f, 8.27681720e-02f, 2.99520075e-01f, 7.12010190e-02f,
  1.26608517e-02f, 6.85656443e-02f, 2.12772633e-03f, 2.68477630e-02f, -5.45913465e-02f, -1.09744698e-01f, 8.05533156e-02f, -1.88367143e-01f, -2.13166922e-01f, -5.76773733e-02f,
  -1.00589536e-01f, 2.09345147e-01f, 9.45064574e-02f, 4.83501218e-02f, 2.57360581e-02f, 3.29476446e-02f, -4.10687067e-02f, -4.21453454e-03f, -9.68314558e-02f, -5.18058725e-02f,
  1.90523788e-01f, -3.62555981e-02f, 5.88078797e-02f, -8.55993107e-02f, 5.27665913e-02f, -3.05652350e-01f, -1.54859498e-01f, 1.08095095e-01f, -1.84539244e-01f, 3.78449798e-01f,
  2.01080963e-01f, -5.12970015e-02f, -8.93850848e-02f, 4.66783345e-01f, -1.03088468e-02f, -1.74094096e-01f, 4.75119464e-02f, -1.60467997e-02f, 1.14073772e-02f, 1.31258994e-01f,
  -1.70853302e-01f, 1.16979800e-01f, 4.67322245e-02f, 1.11697398e-01f, -1.20414734e-01f, -6.53088465e-02f, 3.07304673e-02f, -1.33554209e-02f, -2.58042831e-02f, -1.68595865e-01f,
  1.75379477e-02f, -3.00471075e-02f, -6.14077784e-02f, -4.98760715e-02f, 1.02614589e-01f, 4.63098809e-02f, 1.27762869e-01f, -2.86297593e-02f, 9.83885750e-02f, 4.67560440e-02f,
  -3.08293309e-02f, 5.88008761e-02f, -8.32147747e-02f, 1.12726077e-01f, -5.64051382e-02f, 7.15663955e-02f, 1.09919190e-01f, 2.67243087e-01f, -1.45611260e-03f, 1.62669253e-02f,
  4.61670011e-02f, -9.58544537e-02f, 1.74951255e-02f, 4.74303737e-02f, -2.37894226e-02f, 2.20268890e-01f, 1.64287522e-01f, -3.53790075e-01f, 1.20595276e-01f, 6.00871779e-02f,
  -9.06853825e-02f, 1.98514596e-01f, -8.16070884e-02f, -1.68539643e-01f, 2.12168321e-01f, 1.82503015e-01f, -2.06127197e-01f, -1.82995334e-01f, 1.07047014e-01f, -1.49908304e-01f,
  1.13599181e-01f, -1.86425880e-01f, -9.42137912e-02f, -7.51807764e-02f, 2.88583618e-02f, 1.86265498e-01f, 2.30266109e-01f, 9.90832821e-02f, 6.03453629e-02f, -2.68105537e-01f,
  1.48282424e-01f, -1.47537753e-01f, 3.78451161e-02f, -6.51916265e-02f, -3.31680924e-02f, -2.36242171e-02f, 2.75038723e-02f, -2.99067236e-02f, -1.09643474e-01f, -4.08415906e-02f,
  2.19062850e-01f, 3.58390361e-02f, 8.37198570e-02f, 8.54582340e-02f, 1.33878132e-02f, -3.03122811e-02f, -5.88705242e-02f, -7.46193007e-02f, 9.22942460e-02f, -6.47779554e-02f,
  -1.13075343e-03f, -4.85186838e-02f, 1.35617226e-01f, 2.44930953e-01f, 4.68384102e-02f, -1.69315245e-02f, 5.87876067e-02f, -7.45092519e-04f, 1.28089607e-01f, -1.52541120e-02f,
  2.14073248e-02f, 2.47746147e-02f, -5.71086183e-02f, -7.36431405e-02f, -1.65589303e-02f, 7.02035725e-02f, 3.73300053e-02f, -1.38282567e-01f, 1.37823284e-01f, 1.85403496e-01f,
  -7.53655061e-02f, -1.45527318e-01f, 7.41474107e-02f, -3.64427939e-02f, -3.51705328e-02f, 4.15246449e-02f, 7.40320757e-02f, 6.01900145e-02f, -5.71245700e-03f, 2.01445714e-01f,
  -5.39102107e-02f, -3.58079448e-02f, 2.53757611e-02f, -3.84099513e-01f, 1.12969086e-01f, -2.45569739e-02f, -1.55901201e-02f, 1.46908671e-01f, 4.18176539e-02f, 1.21409826e-01f,
  4.99726646e-02f, -2.56970048e-01f, -2.91174073e-02f, -2.82197017e-02f, -5.30531928e-02f, 1.15460001e-01f, 1.49925619e-01f, -7.85589516e-02f, -3.64217162e-02f, 3.67153399e-02f,
  -4.18333225e-02f, -1.62386261e-02f, 1.34118706e-01f, 1.41621023e-01f, 1.66140664e-02f, 4.15810309e-02f, -1.06116705e-01f, -3.10906526e-02f, 3.68786380e-02f, 3.75310355e-03f,
  1.63440093e-01f, 9.10781920e-02f, 1.69565141e-01f, -8.70584399e-02f, 1.59799773e-02f, 1.11318529e-01f, -2.06549168e-01f, -4.03124206e-02f, 1.56804770e-01f, 4.87292968e-02f,
  1.51017234e-01f, -3.57370041e-02f, -5.04120961e-02f, 1.70013189e-01f, -7.06279576e-02f, 8.41406826e-03f, -8.54880549e-03f, -8.38055536e-02f, -2.94617843e-02f, -2.41380930e-02f,
  7.49503225e-02f, -1.81498423e-01f, -3.47482830e-01f, -1.20888561e-01f, 7.90923759e-02f, 7.10670650e-02f, 1.18687833e-02f, 1.50022790e-01f, 1.66280400e-02f, 9.89249814e-03f,
  -1.14230722e-01f, -4.29806076e-02f, 9.70690250e-02f, -3.13049592e-02f, 2.39813015e-01f, -3.27307964e-03f, 2.00620331e-02f, 1.32798314e-01f, -1.27638400e-01f, 1.40214560e-03f,
  -2.51492590e-01f, 2.64706668e-02f, -2.56442204e-02f, -2.69675434e-01f, -1.50580287e-01f, 6.36452390e-03f, 6.99773133e-02f, 2.71152519e-02f, 1.33197000e-02f, 7.12601701e-03f,
  6.83060959e-02f, -6.40630648e-02f, 3.01111825e-02f, -1.04124367e-01f, -9.23799127e-02f, -4.77836058e-02f, -6.54117577e-03f, 5.25817461e-02f, -5.63725606e-02f, -4.32091728e-02f,
  -8.53140056e-02f, 5.06713651e-02f, -1.44787272e-02f, -5.19838706e-02f, -1.53408065e-01f, -1.48491606e-01f, -6.70730025e-02f, -4.88582253e-02f, 1.19613044e-01f, -1.94277078e-01f,
  -1.34842232e-01f, -8.15544277e-02f, -2.13511139e-02f, 6.21926896e-02f, 8.54258463e-02f, -3.46692353e-02f, -1.98021042e-03f, -1.71415284e-01f, 1.35139436e-01f, -1.20283477e-01f,
  -4.19674329e-02f, 1.44952796e-02f, -3.65879573e-02f, 2.89793070e-02f, 1.65264234e-01f, -1.78686336e-01f, 8.72438401e-02f, -8.01661685e-02f, 1.21763065e-01f, 6.51278272e-02f,
  6.61284626e-02f, -1.14747539e-01f, 9.32189375e-02f, -1.40563801e-01f, 1.35305867e-01f, 2.16233477e-01f, 5.22257797e-02f, -1.21816359e-02f, 1.11333355e-01f, 1.83908612e-01f,
  -2.89927602e-01f, -2.13620171e-01f, 6.19042888e-02f, 5.99943548e-02f, 1.34257227e-01f, 2.96143740e-02f, 7.97642618e-02f, -2.49163151e-01f, -1.09103799e-01f, 1.90960407e-01f,
  1.99928194e-01f, -1.17051169e-01f, -1.39236018e-01f, -4.16816026e-02f, 1.57658637e-01f, 5.68224974e-02f, 2.75695585e-02f, 6.54179230e-02f, -1.15664843e-02f, -4.67796018e-03f,
  6.62583113e-02f, 7.47327954e-02f, 1.68671571e-02f, 8.82833526e-02f, -7.44327381e-02f, 2.31358875e-02f, -6.93412796e-02f, 8.75866562e-02f, 7.09121525e-02f, -2.64223607e-04f,
  -4.84636985e-03f, 1.19889572e-01f, -5.08555174e-02f, 6.78912327e-02f, -1.11713357e-01f, -4.09959741e-02f, 1.03776276e-01f, 9.11580678e-03f, -1.47625118e-01f, -4.57384065e-02f,
  -1.18658908e-01f, 1.65107474e-01f, 1.56938471e-02f, 5.52929416e-02f, 5.01767173e-03f, 1.46906450e-01f, 1.21842027e-01f, -4.70377915e-02f, 2.63960417e-02f, -9.58048403e-02f,
  -2.17077434e-01f, 2.19593681e-02f, 4.52105366e-02f, 5.62247373e-02f, -2.97111392e-01f, 1.22014605e-01f, -3.34076658e-02f, 7.91107789e-02f, 5.39860167e-02f, -2.81730797e-02f,
  -1.80541813e-01f, 8.70858282e-02f, 1.81843806e-02f, 1.47231057e-01f, -9.27790478e-02f, 9.51842591e-02f, -5.02877869e-02f, 6.06969371e-02f, 1.25745401e-01f, -3.27988155e-02f,
  7.63629451e-02f, -7.29008242e-02f, -1.45344129e-02f, -4.54459079e-02f, -1.03615433e-01f, 3.71798098e-01f, -7.22807692e-03f, -1.00512631e-01f, 3.13255787e-02f, -1.77195687e-02f,
  7.84876645e-02f, -1.19419985e-01f, -2.34407764e-02f, 2.76157856e-02f, 9.57137048e-02f, 6.12266734e-02f, 1.38225436e-01f, -1.05281226e-01f, -7.52139837e-02f, 2.19310492e-01f,
  -7.59671554e-02f, 1.31959110e-01f, -1.80911675e-01f, -1.01496033e-01f, -1.46720722e-01f, 8.35842937e-02f, -3.63243814e-03f, -1.98350087e-01f, 1.68296352e-01f, -1.69691205e-01f,
  5.68987131e-02f, 1.98761910e-01f, -1.19565375e-01f, -7.56329596e-02f, 1.38025135e-01f, -3.92928757e-02f, 8.23118165e-02f, -1.63761526e-01f, 6.00454919e-02f, 7.58459643e-02f,
  4.33567092e-02f, -1.07975140e-01f, 1.58110067e-01f, -1.67169064e-01f, -9.21746045e-02f, 3.73208076e-02f, 1.55542195e-02f, 1.01753205e-01f, -1.57042205e-01f, -1.23283997e-01f,
  1.06748253e-01f, -1.19713552e-01f, 1.47240937e-01f, 2.49534979e-01f, -1.46388665e-01f, -5.41063771e-03f, 1.65946603e-01f, 2.59281788e-02f, -2.45344698e-01f, 1.66270752e-02f,
  -9.03090984e-02f, 2.06174314e-01f, 2.02422887e-01f, 2.24208653e-01f, 3.22405249e-01f, -1.94082126e-01f, -1.98753610e-01f, 1.96886417e-02f, -3.29033774e-03f, 6.41435608e-02f,
  1.07210511e-02f, 1.10604614e-02f, -4.16944660e-02f, 1.75247726e-03f, -4.05738764e-02f, 4.79495823e-02f, -6.08511753e-02f, 1.29528880e-01f, -6.17846400e-02f, -1.52366936e-01f,
  -3.11408658e-02f, 3.92509401e-02f, -2.70778947e-02f, 7.26338252e-02f, -3.98051850e-02f, 4.00869399e-02f, 1.75987110e-01f, -1.19843960e-01f, 8.95812809e-02f, 8.62381384e-02f,
  -1.13269560e-01f, 5.67041188e-02f, -9.79449879e-03f, -1.18743099e-01f, 8.64763632e-02f, 1.61901757e-01f, -7.57731050e-02f, 1.11457139e-01f, -2.38971282e-02f, 1.23907559e-01f,
  6.35036752e-02f, -3.33560944e-01f, -2.71844696e-02f, -9.80219245e-02f, 5.64880781e-02f, -9.11384374e-02f, 1.28246024e-01f, 3.58107523e-03f, -2.39964992e-01f, -4.14182432e-03f,
  -1.70491606e-01f, 1.84157744e-01f, -1.20709777e-01f, 1.20534496e-02f, 8.44989046e-02f, -1.92521527e-01f, -1.90713674e-01f, -3.66853885e-02f, -2.45692059e-01f, -6.53319135e-02f,
  -9.51645151e-03f, -9.15308222e-02f, 1.01924323e-01f, 1.62022650e-01f, -5.29831499e-02f, 2.35306844e-01f, -2.15271879e-02f, -4.59889974e-03f, 2.97807492e-02f, -1.34697929e-01f,
  -9.16047469e-02f, -1.03046015e-01f, 4.60222550e-02f, 3.67947638e-01f, -4.88139391e-02f, -1.27811432e-01f, -5.14589399e-02f, 1.44883797e-01f, -3.50461379e-02f, -7.39014447e-02f,
  -2.76267640e-02f, -1.75859064e-01f, 4.74231951e-02f, -3.75374742e-02f, 1.99834220e-02f, -1.47904396e-01f, -7.29591027e-02f, -2.10396727e-04f, -1.77607492e-01f, 5.50243556e-02f,
  3.07011977e-02f, 4.22158651e-02f, -5.16250990e-02f, -3.61666940e-02f, -6.01749122e-03f, -4.06154133e-02f, 1.78719223e-01f, -1.59934253e-01f, -1.76441342e-01f, -1.79091915e-01f,
  -2.27049440e-02f, 1.06441230e-01f, -8.09603333e-02f, 1.09592199e-01f, 2.25652885e-02f, -1.95545718e-01f, 8.65704417e-02f, 6.24415763e-02f, -3.71877030e-02f, -6.83873370e-02f,
  -1.41801417e-01f, 9.75984260e-02f, 1.27319217e-01f, -1.04710072e-01f, -3.33281420e-02f, -8.61547068e-02f, -3.40107493e-02f, -9.59725976e-02f, -3.21759671e-01f, 1.10598437e-01f,
  2.90171444e-01f, -1.67165741e-01f, -2.24468306e-01f, 1.62056640e-01f, -1.76195785e-01f, 1.45429596e-01f, -9.67733860e-02f, 1.42850935e-01f, 2.08333179e-01f, 3.09896655e-02f,
  -2.98322201e-01f, -7.08466098e-02f, 3.16545740e-02f, 1.31077006e-01f, -3.69841345e-02f, 1.64430916e-01f, -1.81977421e-01f, 4.13950905e-02f, -1.85435355e-01f, 7.59237334e-02f,
  -1.09384827e-01f, -9.38953832e-03f, 1.68159574e-01f, 6.68362007e-02f, -1.11512601e-01f, 1.85308084e-02f, 2.18202192e-02f, -1.86961964e-02f, -1.19218282e-01f, -1.07051387e-01f,
  -8.10223818e-02f, -8.40782896e-02f, 1.06041476e-01f, 6.11824356e-02f, 5.98444678e-02f, 4.99208197e-02f, -8.42564479e-02f, -9.57093835e-02f, -1.05598308e-01f, 1.93130463e-01f,
  -8.00806358e-02f, 4.19171900e-02f, 9.66058820e-02f, 1.64965149e-02f, 2.65696496e-01f, -6.62424490e-02f, -8.68490562e-02f, -4.82873134e-02f, 1.34039402e-01f, -1.07146285e-01f,
  -1.63498759e-01f, -5.51836789e-02f, -1.06592268e-01f, -6.51671886e-02f, -1.02978341e-01f, 2.51277208e-01f, -2.55125374e-01f, 1.20554402e-01f, -2.11876959e-01f, 1.87960848e-01f,
  -1.28945708e-01f, 1.14525758e-01f, 5.86298406e-02f, -2.38429278e-01f, -1.19808376e-01f, -1.30558416e-01f, 1.39009282e-01f, 1.24290384e-01f, 5.39774857e-02f, -4.96291593e-02f,
  1.17061637e-01f, -2.54660398e-01f, -5.08955047e-02f, -6.06825342e-03f, -3.06976318e-01f, 1.21212222e-01f, -1.71747476e-01f, -9.44694504e-02f, 1.15509950e-01f, 1.37674138e-01f,
  4.52455357e-02f, 1.89550087e-01f, 4.43283729e-02f, -9.97118372e-03f, -1.35388272e-02f, 1.78363621e-02f, 4.79112305e-02f, -1.41566068e-01f, -6.24662644e-05f, -6.66854903e-02f,
  1.32228076e-01f, -6.44344464e-02f, -7.31406063e-02f, -6.40409142e-02f, 3.65509130e-02f, -2.37180740e-02f, -5.51402988e-03f, -1.73921511e-02f, 7.20743136e-03f, -1.60604659e-02f,
  -8.03081784e-03f, 5.53863831e-02f, -1.41427428e-01f, 1.81367576e-01f, 1.12225451e-01f, 3.59389693e-01f, 6.57828450e-02f, -7.05598518e-02f, 4.70197201e-02f, 1.01950467e-01f,
  -4.71687689e-02f, 2.38172129e-01f, 2.38017142e-01f, -1.54199451e-02f, -1.38446927e-01f, 3.54737453e-02f, 2.68512350e-02f, -1.99090153e-01f, 1.15204558e-01f, -1.98832676e-01f,
  -3.72021109e-01f, -1.00211464e-01f, -5.99452257e-02f, 1.50190368e-01f, -1.53673947e-01f, -1.88819901e-03f, 8.76493528e-02f, -8.34972784e-02f, -2.08288625e-01f, -1.08992055e-01f,
  -8.00945889e-03f, 1.39549538e-01f, 1.63135365e-01f, 3.10393889e-02f, 4.30801958e-02f, -3.57941121e-01f, -1.23717345e-01f, 8.57149586e-02f, -3.02738845e-01f, 1.35370702e-01f,
  -1.75188661e-01f, -9.60131511e-02f, -1.48740560e-01f, 9.12874714e-02f, 1.63633619e-02f, 2.59141356e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.27555981e-01f, 1.37891591e-01f, 1.85154051e-01f, 1.80531159e-01f, 1.42419025e-01f, 7.84223750e-02f, 2.37531155e-01f, -2.19875034e-02f, 1.71857178e-01f, 1.54818133e-01f,
  9.45894271e-02f, 5.34072816e-02f, 1.45725653e-01f, -2.09714975e-02f, 1.40594661e-01f, 3.24425668e-01f, 2.24254191e-01f, 2.40463480e-01f, 1.45753995e-01f, -1.60469282e-02f,
  -1.30483180e-01f, 8.31169337e-02f, -5.79941124e-02f, -1.33745536e-01f, -3.81439365e-02f, -7.14311525e-02f, 2.25613505e-01f, 4.40731272e-03f, 8.18711892e-02f, 4.76179756e-02f,
  1.02739118e-01f, -3.63436222e-01f, -2.91605771e-01f, 1.39720529e-01f, 6.94191903e-02f, 6.54928535e-02f, -1.52618483e-01f, 1.14352323e-01f, -3.36348176e-01f, 2.42801793e-02f,
  -4.12063241e-01f, 5.86224794e-01f, -8.62970389e-03f, -1.13504864e-02f, -1.02720093e-02f, -2.13195384e-01f, -2.04587609e-01f, -1.22355469e-01f, -1.37772532e-02f, 2.29639485e-01f,
  1.37217045e-01f, -3.01360905e-01f, -9.31513757e-02f, -2.94030964e-01f, 3.52404326e-01f, 3.10679018e-01f, -4.02343899e-01f, 3.84389013e-02f, -4.85051215e-01f, -1.58695430e-02f,
  -8.72399891e-04f, 2.63936102e-01f, 9.28407013e-02f, 4.24789041e-01f, 2.48238966e-01f, 2.97637701e-01f, -3.00010797e-02f, 1.73231527e-01f, 6.35818243e-02f, 2.02351823e-01f,
  1.26237139e-01f, 9.35263783e-02f, 4.05107625e-03f, -3.49309333e-02f, 1.44837955e-02f, 7.91917443e-02f, 2.79288471e-01f, 9.00003091e-02f, 8.10868591e-02f, 8.35095868e-02f,
  1.89051196e-01f, 2.37830147e-01f, 8.08355212e-02f, -2.90539801e-01f, -8.86251703e-02f, 4.19169277e-01f, -2.22388897e-02f, -1.09563328e-01f, -2.65679330e-01f, -6.39763251e-02f,
  2.78930336e-01f, 2.62486666e-01f, -2.43483916e-01f, 1.81546614e-01f, -5.26770726e-02f, 3.07040393e-01f, -1.49998382e-01f, -7.43295699e-02f, 1.04543626e-01f, -1.00516468e-01f,
  -4.11389977e-01f, 8.92121866e-02f, -1.05140015e-01f, 2.69500405e-01f, -2.18583539e-01f, 1.02702394e-01f, 1.07075788e-01f, 4.85470176e-01f, -7.07958883e-04f, -8.85948818e-03f,
  -1.59545973e-01f, -1.14408873e-01f, 3.23387831e-01f, -1.48623645e-01f, 2.44385555e-01f, 1.23855725e-01f, 5.15088558e-01f, 2.51829445e-01f, -6.32127523e-02f, 1.11204371e-01f,
  -6.56675100e-02f, 5.02922058e-01f, -2.13556826e-01f, 1.02754891e-01f, 3.20286125e-01f, 8.61224055e-01f, -2.13079467e-01f, -1.36233568e-01f, 1.20564140e-01f, 6.84026331e-02f,
  2.01015174e-01f, -3.60684656e-02f, 1.53086334e-01f, 1.79211676e-01f, 1.24364778e-01f, 2.01465100e-01f, 1.16951533e-01f, 1.28087267e-01f, 2.61064172e-01f, 2.22178683e-01f,
  2.82604873e-01f, 1.80000409e-01f, 1.68843508e-01f, 2.26556748e-01f, 8.04469883e-02f, 1.15318142e-01f, 1.98278800e-01f, 1.08443499e-01f, 2.96345919e-01f, -1.56247810e-01f,
  1.84161231e-01f, 2.20665514e-01f, 2.46159479e-01f, 6.77619874e-02f, -3.70602240e-03f, 3.11214656e-01f, -3.50627191e-02f, 1.60792172e-02f, 1.31241888e-01f, 3.20037067e-01f,
  -2.70525049e-02f, -1.59522206e-01f, 8.77369344e-02f, -2.05235600e-01f, 8.38775709e-02f, -2.68010944e-01f, 2.94566661e-01f, -9.65548381e-02f, 2.92684406e-01f, -3.67931187e-01f,
  6.10828139e-02f, 2.56236464e-01f, 2.93339580e-01f, 3.69125098e-01f, 1.22263409e-01f, -1.13044634e-01f, 6.11023009e-01f, 9.71705914e-02f, -2.12116111e-02f, -3.32584769e-01f,
  5.71988970e-02f, -2.26635203e-01f, 1.07560143e-01f, -3.13180804e-01f, -1.72587100e-03f, -1.77262232e-01f, 8.52343291e-02f, 2.20737293e-01f, 1.56919047e-01f, -3.30494434e-01f,
  -2.89263070e-01f, -1.74879178e-01f, 1.85531661e-01f, 1.64032698e-01f, 4.84708436e-02f, 1.51122198e-01f, 1.52995616e-01f, 1.60632223e-01f, 3.43094431e-02f, 1.63953096e-01f,
  1.67807311e-01f, -1.61462580e-03f, 1.78034499e-01f, 1.34340361e-01f, 1.37631059e-01f, 1.28735945e-01f, -4.41434942e-02f, 6.30538017e-02f, -9.06232446e-02f, -9.68335271e-02f,
  2.37051547e-02f, -1.64019257e-01f, 8.88222083e-02f, 1.79345720e-03f, -1.19312614e-01f, -1.96931630e-01f, -3.02404791e-01f, 8.18789750e-02f, 7.53570721e-02f, -1.51445374e-01f,
  6.25379011e-02f, 6.71920106e-02f, 1.48484394e-01f, 1.98304132e-02f, -1.54880226e-01f, -4.79831807e-02f, -1.04067490e-01f, 3.09485216e-02f, 4.10014279e-02f, -8.38722289e-02f,
  4.45528507e-01f, 1.52062073e-01f, 1.48919135e-01f, 2.14167193e-01f, 1.12771481e-01f, 2.78656036e-01f, -1.46707192e-01f, -2.12396514e-02f, -1.42727882e-01f, 3.66284430e-01f,
  -4.79297414e-02f, -6.10703826e-02f, 2.31870219e-01f, 2.66582221e-01f, 1.35270193e-01f, -9.29393470e-02f, -2.89463639e-01f, 4.54818338e-01f, 4.84890461e-01f, 5.02031207e-01f,
  2.67867565e-01f, -8.62318724e-02f, 2.35996563e-02f, 5.78328073e-01f, 8.66521299e-02f, 6.98858127e-02f, 1.10510305e-01f, 6.87770247e-02f, 1.25447899e-01f, -4.76329066e-02f,
  2.25682944e-01f, 3.14030737e-01f, 1.78030685e-01f, 1.69451222e-01f, -5.14145009e-02f, 3.90714929e-02f, 3.51934321e-02f, 2.02839166e-01f, 2.12851897e-01f, -3.36587206e-02f,
  1.08859852e-01f, 1.81321695e-01f, 3.26358795e-01f, 3.44722360e-01f, 2.06719548e-01f, -8.57882351e-02f, 2.14798912e-01f, 1.14359193e-01f, 7.13738948e-02f, 2.94384807e-01f,
  7.64002725e-02f, -1.93661273e-01f, 1.77887022e-01f, 7.36694559e-02f, -9.56740901e-02f, -4.82899621e-02f, 2.78142542e-02f, 4.20013487e-01f, 1.06553644e-01f, -4.88428622e-02f,
  -8.55674744e-02f, 2.89462600e-02f, -2.75869876e-01f, 2.65249491e-01f, 3.57352465e-01f, -1.27871007e-01f, 3.61915678e-02f, 2.12258734e-02f, 2.43900105e-01f, 3.81028533e-01f,
  1.83315426e-01f, 2.17648014e-01f, -1.29267111e-01f, -7.73375407e-02f, 6.06881380e-01f, -5.27167581e-02f, -1.87415779e-01f, -2.36722037e-01f, 3.46688271e-01f, -3.20156008e-01f,
  3.16830397e-01f, -3.94248307e-01f, -1.06578819e-01f, -3.28701049e-01f, -1.93524271e-01f, 2.91278064e-01f, 1.06003053e-01f, -2.09589869e-01f, 7.03718215e-02f, -2.87361473e-01f,
  1.53635249e-01f, 1.75812170e-01f, 8.63054395e-02f, 2.13791355e-01f, 3.27976882e-01f, 2.04556614e-01f, 2.37327456e-01f, 1.76248908e-01f, -4.82317843e-02f, 6.07001632e-02f,
  9.80439559e-02f, 3.37661833e-01f, 3.23569447e-01f, 1.90187782e-01f, 5.01081496e-02f, -1.43177470e-03f, -5.58141712e-03f, 9.35755745e-02f, 2.77972877e-01f, -1.41494185e-01f,
  2.78728995e-02f, 2.02286214e-01f, 9.96869579e-02f, 1.33726195e-01f, 1.02107851e-02f, 4.85846885e-02f, 9.14477855e-02f, 1.47954151e-01f, -2.61415035e-01f, 1.41240224e-01f,
  4.76435013e-02f, 1.05370030e-01f, -2.66489744e-01f, -2.90876120e-01f, 8.20104554e-02f, -1.97353154e-01f, 3.03575426e-01f, 1.15337603e-01f, -2.51482844e-01f, 2.21090734e-01f,
  -3.13775092e-01f, 1.75031230e-01f, 3.44112106e-02f, -1.91989034e-01f, 9.57263932e-02f, -1.83081225e-01f, -1.25678942e-01f, -1.06719173e-01f, -4.14727002e-01f, -1.85903534e-01f,
  1.61819172e-03f, 2.39817411e-01f, 2.43215039e-02f, -3.21657211e-01f, -6.73750997e-01f, 2.26426214e-01f, -9.33963209e-02f, 4.41445798e-01f, 4.50953841e-01f, -1.51649788e-01f,
  5.08658886e-02f, 2.85877019e-01f, 7.72056133e-02f, 2.08622053e-01f, 1.92808598e-01f, 2.98162162e-01f, 2.06026703e-01f, 6.19044676e-02f, 1.65640265e-01f, 1.77053928e-01f,
  9.30293277e-02f, 3.37678850e-01f, 1.16871379e-01f, -9.98005178e-03f, 2.64742136e-01f, 4.37473021e-02f, 2.13251904e-01f, 1.38623327e-01f, 1.10427607e-02f, 1.16663396e-01f,
  2.47463062e-01f, 1.77747726e-01f, 2.14497164e-01f, -1.23141713e-01f, 2.41759494e-01f, -5.07477596e-02f, 2.03612074e-02f, 2.61969775e-01f, -1.43152937e-01f, -2.56734669e-01f,
  1.27380908e-01f, 6.46250024e-02f, -6.76846951e-02f, -5.58335334e-02f, 7.73729384e-02f, 2.08922207e-01f, 1.04061864e-01f, -2.43751973e-01f, -3.96871604e-02f, -3.75906052e-03f,
  -3.07710320e-01f, 1.63731128e-01f, 5.84690571e-01f, 3.25273313e-02f, 2.70670742e-01f, -3.70396644e-01f, 2.27685675e-01f, 4.35822070e-01f, 1.14465110e-01f, 2.26926073e-01f,
  -1.11277640e-01f, -2.29544818e-01f, 3.71543616e-01f, -3.36334974e-01f, -5.30881397e-02f, -2.67659954e-04f, 2.21418701e-02f, -4.20447178e-02f, -1.52907863e-01f, 3.71933728e-02f,
  1.54141739e-01f, 3.66760820e-01f, 2.79848397e-01f, 2.51393497e-01f, 6.73436299e-02f, 1.51039615e-01f, -5.71860783e-02f, -6.23912036e-01f, 1.48856282e-01f, 1.65439099e-01f,
  3.08229953e-01f, 2.84947455e-01f, 9.92705226e-02f, 1.20946085e-02f, 1.25336185e-01f, 5.91673777e-02f, 1.61602452e-01f, 1.09731831e-01f, 1.18541278e-01f, 7.97515288e-02f,
  2.08221704e-01f, 1.56151548e-01f, -1.45781441e-02f, 3.03695232e-01f, 3.01045507e-01f, 2.07720205e-01f, 1.92039475e-01f, -1.92237273e-01f, -1.10754170e-01f, -8.60097483e-02f,
  -2.16165975e-01f, -2.05607310e-01f, -4.30210263e-01f, -3.62678766e-01f, 2.30580106e-01f, -7.16682225e-02f, 1.23863425e-02f, -2.22719721e-02f, -1.76132783e-01f, -1.59316018e-01f,
  -4.35535125e-02f, 1.66380614e-01f, -1.51530430e-01f, 9.76046249e-02f, -6.74006879e-01f, 1.43903807e-01f, 3.02862495e-01f, -1.08549416e-01f, 4.98045199e-02f, 6.03160262e-01f,
  1.95754707e-01f, 1.64447784e-01f, -3.20443243e-01f, -1.90388814e-01f, 9.99382511e-02f, 8.28919932e-02f, -5.02159335e-02f, -2.18168750e-01f, 2.09292933e-01f, -7.20482245e-02f,
  -1.19898796e-01f, 7.73394927e-02f, 2.86668956e-01f, 3.71614099e-01f, -1.15094051e-01f, 2.43360937e-01f, 1.91053804e-02f, 1.28769562e-01f, -8.05495679e-02f, 6.75469398e-01f,
  2.64960319e-01f, -3.02926227e-02f, 1.90540589e-02f, 7.33508216e-03f, 2.04047799e-01f, -9.94066615e-03f, 7.50445649e-02f, 1.00312181e-01f, -1.12859331e-01f, 1.95886016e-01f,
  -1.24220558e-01f, -3.88059691e-02f, 7.86655322e-02f, -6.48496673e-02f, -7.98767433e-02f, -6.53899228e-03f, 4.58830409e-02f, -1.41756954e-02f, 5.99609315e-03f, 2.06746876e-01f,
  5.49377874e-02f, 1.86980814e-01f, 2.93896478e-02f, -1.27482623e-01f, 1.45416781e-01f, 1.34217426e-01f, 3.35298866e-01f, 3.58314157e-01f, -2.02059716e-01f, 1.19288050e-01f,
  -3.08324248e-01f, 2.44682077e-02f, 1.94369286e-01f, -2.08563447e-01f, -2.45684907e-02f, 1.29732713e-01f, 8.69302303e-02f, -2.91047633e-01f, 1.72866926e-01f, -1.37694597e-01f,
  -2.10783705e-01f, -9.40268263e-02f, 3.63868997e-02f, -4.11833704e-01f, -1.88124448e-01f, 2.07172468e-01f, 4.52151239e-01f, -1.23616800e-01f, 3.19243640e-01f, -3.43338579e-01f,
  -1.23255663e-01f, 3.69963422e-02f, -1.93940073e-01f, 3.89250875e-01f, 1.62662491e-01f, 2.65388072e-01f, 2.90212154e-01f, -2.92931888e-02f, -2.11891577e-01f, -1.58681616e-01f,
  3.47458810e-01f, -1.15880579e-01f, 6.31476566e-02f, -1.35017186e-01f, -4.56749916e-01f, 2.06095189e-01f, 1.03262670e-01f, 9.10604820e-02f, 1.38064131e-01f, 2.06831887e-01f,
  5.92019409e-02f, 4.78802204e-01f, 1.53352305e-01f, 1.66424394e-01f, 6.84376657e-02f, 6.52260780e-02f, 1.63095206e-01f, 2.55334169e-01f, 1.57320991e-01f, 2.40258530e-01f,
  -3.28009799e-02f, 1.25883579e-01f, 3.52586925e-01f, 5.85453808e-02f, 1.88411981e-01f, 2.05903068e-01f, -2.62831092e-01f, 6.43501803e-02f, -1.72880143e-01f, 1.18452258e-01f,
  -6.99120015e-03f, 2.78734535e-01f, -3.04150805e-02f, 5.58522195e-02f, -1.24326192e-01f, 1.73008248e-01f, -8.43052864e-02f, -4.13806945e-01f, -1.25484794e-01f, 1.70945570e-01f,
  4.16433141e-02f, -8.81123915e-03f, -1.82512533e-02f, -3.67256880e-01f, -2.29330450e-01f, -1.63084473e-02f, -4.38896120e-01f, 4.47904497e-01f, -3.32789719e-01f, 8.96567404e-02f,
  3.10751200e-01f, -3.97815645e-01f, -2.14365318e-01f, 1.56651944e-01f, 1.58104286e-01f, 2.02785254e-01f, 1.34956375e-01f, 1.69418067e-01f, 1.01510555e-01f, 3.04253310e-01f,
  4.89371985e-01f, 1.39610991e-01f, 1.82095096e-01f, -2.75811851e-01f, -3.40302885e-01f, -3.08793962e-01f, -1.68481007e-01f, -1.96462244e-01f, -2.30399147e-02f, 6.73611701e-01f,
  9.29546952e-02f, 1.44412294e-01f, -5.12508377e-02f, 1.55243352e-01f, 1.11468993e-01f, 1.31042019e-01f, 4.81804125e-02f, 5.51753938e-02f, 2.47661937e-02f, 7.44355982e-03f,
  9.29484740e-02f, 1.87434927e-01f, 2.02673957e-01f, -1.53748751e-01f, 3.64038646e-02f, -2.14095339e-02f, 4.96392101e-02f, 2.08129540e-01f, 8.80852193e-02f, 2.98617221e-02f,
  6.87235668e-02f, 2.09098965e-01f, 1.64074570e-01f, 1.91665679e-01f, 2.88292170e-01f, 2.18984634e-01f, 2.56421398e-02f, 1.06854131e-02f, -2.08160147e-01f, 2.39536747e-01f,
  2.18896732e-01f, -1.32428020e-01f, -1.93147808e-01f, -4.79532294e-02f, 2.11104646e-01f, -3.95941854e-01f, 2.83227116e-01f, 1.10573314e-01f, -4.32392657e-01f, -1.30354300e-01f,
  -1.51321828e-01f, 8.49344358e-02f, -2.61321813e-01f, 4.94659394e-02f, 4.71742183e-01f, 2.49810871e-02f, -8.68951976e-02f, -3.41539443e-01f, -2.15149626e-01f, 8.00354183e-02f,
  -2.26349831e-01f, 8.72973800e-02f, 3.28861147e-01f, -6.11168966e-02f, -2.81276286e-01f, 2.31179357e-01f, -2.43102029e-01f, -6.10155538e-02f, 2.57113744e-02f, -1.12576112e-01f,
  -3.65750611e-01f, 3.67265731e-01f, -8.18135291e-02f, 4.99985307e-01f, 1.79060444e-01f, 1.86904803e-01f, 1.70100778e-01f, 1.27886191e-01f, 1.34701625e-01f, -1.79562613e-01f,
  1.12286650e-01f, 8.18590447e-03f, 1.90852776e-01f, 2.45464176e-01f, 1.76686510e-01f, -2.59308163e-02f, 3.40572745e-01f, 1.85738966e-01f, 4.08363268e-02f, 7.93545321e-02f,
  -6.57546939e-03f, 1.17300585e-01f, 2.93394685e-01f, 1.24010429e-01f, -4.47606072e-02f, -3.96432608e-01f, -5.36474735e-02f, -2.64965057e-01f, -1.84396561e-02f, 1.51199818e-01f,
  1.21456139e-01f, -3.47396941e-03f, 7.11382255e-02f, -4.29077670e-02f, 1.62994474e-01f, -1.49433479e-01f, -1.69652775e-01f, -1.51862595e-02f, -4.21593785e-02f, -6.98048845e-02f,
  2.49141231e-01f, -3.66316766e-01f, -1.18484415e-01f, -1.33541822e-01f, 1.49019271e-01f, 8.11297446e-02f, 1.86652750e-01f, -2.98658997e-01f, 3.41425151e-01f, -2.76184976e-01f,
  1.36253685e-01f, 3.15346956e-01f, -3.64196658e-01f, -3.99739258e-02f, 3.07881296e-01f, 2.21002564e-01f, -2.24397123e-01f, -9.13804919e-02f, -3.81072611e-01f, 3.90959889e-01f,
  1.56119019e-02f, 3.62276673e-01f, 3.64665061e-01f, -8.19717422e-02f, -2.03801975e-01f, 5.57975590e-01f, 2.59247750e-01f, 3.34791809e-01f, 2.24491894e-01f, -4.11101840e-02f,
  9.06325281e-02f, 1.85981259e-01f, 1.23605393e-02f, 2.69558281e-01f, 3.64433043e-02f, -6.27852306e-02f, 1.09793581e-01f, -8.45381767e-02f, 1.43363565e-01f, 6.96842447e-02f,
  1.43430918e-01f, -5.59350923e-02f, 5.21503389e-02f, 1.16884850e-01f, 3.80653501e-01f, 1.94725633e-01f, 1.70819610e-01f, -1.63839191e-01f, -1.18056618e-01f, 2.50402212e-01f,
  1.56496793e-01f, -1.56514540e-01f, 8.54503065e-02f, -2.46183071e-02f, 3.88223901e-02f, 2.09757462e-02f, -4.50315885e-02f, 3.60245079e-01f, -1.58942953e-01f, -6.42670840e-02f,
  -1.62720188e-01f, 2.82677203e-01f, 1.56695634e-01f, -8.03069323e-02f, -3.94976586e-01f, 1.72881961e-01f, -4.16265458e-01f, -1.51980609e-01f, -7.98341911e-03f, 4.21323180e-02f,
  1.55478287e-02f, 2.85633028e-01f, -4.18163687e-02f, 3.20210248e-01f, 1.81632310e-01f, -4.18494880e-01f, -3.84439617e-01f, 1.99994460e-01f, -1.30971046e-02f, -4.61402237e-02f,
  8.55644494e-02f, 3.97257507e-01f, 7.72772580e-02f, -1.74915999e-01f, -2.55402893e-01f, -4.47398722e-02f, -1.92793936e-01f, 2.15491176e-01f, -6.24545626e-02f, 5.35376489e-01f,
  -2.00255558e-01f, 2.70254105e-01f, 2.93524563e-01f, 1.02070875e-01f, 2.16941252e-01f, 7.28441328e-02f, 1.51116610e-01f, 2.30377093e-01f, 1.15958646e-01f, 1.54736295e-01f,
  1.21355683e-01f, 1.12834871e-01f, 3.12793076e-01f, 2.03756899e-01f, 3.27684700e-01f, 2.07864549e-02f, 1.10896885e-01f, 1.17972367e-01f, 3.31052005e-01f, 3.06737751e-01f,
  1.79456592e-01f, 1.83492377e-01f, 4.37994562e-02f, -6.55149445e-02f, 3.14454079e-01f, 1.86249763e-01f, 2.98950255e-01f, 6.71001226e-02f, -1.79871351e-01f, 1.85527667e-01f,
  2.96539783e-01f, 2.96643198e-01f, -2.18472734e-01f, -1.22884221e-01f, 7.89740905e-02f, -1.91668436e-01f, 3.76505762e-01f, -4.51017432e-02f, 1.87792346e-01f, 1.75952271e-01f,
  -4.17809337e-01f, -2.92761475e-01f, 1.53846845e-01f, 3.22335586e-03f, 1.63825586e-01f, -6.97683543e-02f, 2.52694413e-02f, 3.49248141e-01f, -5.02742194e-02f, -4.47521023e-02f,
  -6.15594804e-01f, 5.07739037e-02f, -2.42100701e-01f, 5.04665822e-02f, -2.08255872e-01f, 3.39500070e-01f, -1.40800670e-01f, 2.84970731e-01f, -1.62553325e-01f, 3.68992150e-01f,
  3.10549468e-01f, 3.88225287e-01f, -2.94731349e-01f, -1.78920314e-01f, 1.52048856e-01f, 4.74641509e-02f, 1.48007825e-01f, 6.80015311e-02f, 1.15696445e-01f, 8.64979476e-02f,
  1.59333989e-01f, 2.24510998e-01f, 4.26688641e-02f, 4.66658846e-02f, -1.60645340e-02f, -1.22395560e-01f, 1.34928003e-01f, -4.88360561e-02f, -7.18299896e-02f, 1.50266021e-01f,
  -8.97795428e-03f, 2.47444585e-01f, 2.16706038e-01f, 1.41716853e-01f, 1.77229613e-01f, 5.23412712e-02f, 6.39468729e-02f, 8.54821652e-02f, 3.18733864e-02f, 1.72514886e-01f,
  -1.00001462e-01f, -1.58984676e-01f, 2.25834742e-01f, 1.23732090e-01f, 2.13250890e-03f, 1.62198916e-01f, -1.48887038e-01f, -1.13703283e-02f, 9.10586342e-02f, -3.41215208e-02f,
  1.01453207e-01f, 1.73574284e-01f, -4.55791801e-01f, 8.33639354e-02f, 1.78428590e-01f, -7.84662887e-02f, 1.99453950e-01f, 2.85474095e-03f, 3.74992967e-01f, 2.41011903e-02f,
  -2.55827218e-01f, 3.78370553e-01f, 3.02385479e-01f, 5.15058450e-02f, 2.34128218e-02f, 1.05422124e-01f, -1.49747683e-02f, 2.84073740e-01f, 1.27583414e-01f, 6.10311806e-01f,
  3.91820878e-01f, -8.80921334e-02f, -3.82898211e-01f, 4.76690054e-01f, 1.31058946e-01f, 3.20448309e-01f, 7.49083906e-02f, -2.65608281e-01f, 1.41541749e-01f, -3.02751899e-01f,
  7.18923286e-02f, -8.71895030e-02f, 2.02294558e-01f, 3.49312648e-02f, 1.96349844e-01f, 6.87698722e-02f, 2.27380022e-01f, 2.05941215e-01f, 1.32982671e-01f, 2.68915892e-01f,
  2.19695792e-01f, 6.21095747e-02f, 1.20522067e-01f, 6.25009686e-02f, 6.21616514e-03f, 2.95510851e-02f, 2.14370608e-01f, 1.47659872e-02f, -4.34136353e-02f, 8.27771425e-02f,
  -1.80841103e-01f, -1.90575704e-01f, -2.32045665e-01f, -1.81503788e-01f, -9.04411301e-02f, 7.49557912e-02f, -1.36577962e-02f, -1.70453507e-02f, 1.65014029e-01f, -1.38063073e-01f,
  -1.52356982e-01f, -1.42205164e-01f, 7.70909339e-02f, 4.68329340e-02f, -2.42554307e-01f, 6.12307452e-02f, 2.60737062e-01f, -2.27335185e-01f, -1.34540871e-02f, -3.68870676e-01f,
  -3.51242691e-01f, 3.14242542e-01f, -1.92438200e-01f, 9.81440768e-02f, -2.15853557e-01f, 9.57387015e-02f, -4.21674073e-01f, 4.46288496e-01f, 2.46675000e-01f, 2.56783456e-01f,
  3.06773096e-01f, -4.60736230e-02f, -9.65814814e-02f, -1.16941199e-01f, 3.19863647e-01f, 1.93689078e-01f, 2.28209034e-01f, -1.27904760e-02f, -3.46749812e-01f, -4.65983063e-01f,
  -8.73249844e-02f, -3.29911381e-01f, 1.58738464e-01f, 5.43228805e-01f, 3.93877737e-02f, 2.05186024e-01f, 2.24804832e-03f, 5.35266008e-03f, -9.70578343e-02f, 1.91252790e-02f,
  7.76633201e-03f, 6.07870817e-02f, 9.17780325e-02f, 1.27767371e-02f, -1.84767600e-03f, 3.17381099e-02f, -4.56996076e-03f, 8.70982260e-02f, 8.99142846e-02f, 3.84391844e-02f,
  -4.97372262e-02f, -3.93648259e-03f, 4.54433337e-02f, 8.62312242e-02f, 9.79151055e-02f, -1.87307790e-01f, -2.28856415e-01f, -1.22452285e-02f, -1.43197188e-02f, 5.22152744e-02f,
  -6.07107580e-02f, -3.89457156e-04f, 1.72736272e-01f, -1.64865464e-01f, -2.23705381e-01f, 2.58957237e-01f, 9.23263207e-02f, -4.58048880e-02f, -1.94625348e-01f, 8.55001435e-02f,
  1.24895468e-01f, -2.75886565e-01f, 2.34421998e-01f, -5.23916744e-02f, 4.56081867e-01f, -1.88334882e-01f, -3.21643823e-03f, 3.74092340e-01f, 2.81004280e-01f, -1.16987437e-01f,
  -1.32928595e-01f, 4.42011327e-01f, 6.64215147e-01f, 2.41492182e-01f, 3.50716561e-01f, -3.99621695e-01f, -1.20877966e-01f, -6.56692162e-02f, 2.13159338e-01f, -1.17220342e-01f,
  5.53869963e-01f, -4.18857783e-02f, -1.53095335e-01f, -3.00248116e-01f, 1.00005850e-01f, 1.99745953e-01f, 1.64639682e-01f, -1.79260120e-01f, 1.56364053e-01f, 1.72723867e-02f,
  1.66859344e-01f, 1.91321880e-01f, 7.90133253e-02f, 2.48436555e-01f, -1.88888490e-01f, 1.49383500e-01f, -1.45549819e-01f, -9.47623625e-02f, 2.34593049e-01f, -7.24056875e-03f,
  1.20074399e-01f, -1.57334730e-02f, 1.06968105e-01f, 1.07548900e-01f, 1.37979224e-01f, 5.00595458e-02f, 2.07017854e-01f, 2.36027479e-01f, 1.81071654e-01f, -2.92430490e-01f,
  2.89067626e-01f, 2.14744270e-01f, -1.15204476e-01f, -1.77779883e-01f, -1.29351085e-02f, -2.11086705e-01f, -2.87500080e-02f, -2.98937093e-02f, 3.85898411e-01f, -2.42397234e-01f,
  -3.25966515e-02f, -1.61249638e-01f, 2.15250045e-01f, -1.92417860e-01f, -1.41274378e-01f, 9.06305760e-03f, 3.99377435e-01f, 4.44980804e-03f, 2.69274086e-01f, 1.30486742e-01f,
  3.15634608e-01f, 9.68500040e-03f, 1.85091361e-01f, -7.25875869e-02f, 1.89315319e-01f, -1.94871873e-01f, 6.94251433e-02f, -3.08713675e-01f, -1.52436405e-01f, 2.46733695e-01f,
  -1.04810335e-01f, -1.23773098e-01f, 1.70979932e-01f, 7.60436505e-02f, -4.72380966e-02f, 3.02495062e-01f, 3.51456583e-01f, 1.11903891e-01f, 9.71980318e-02f, -1.76282331e-01f,
  1.19216025e-01f, 4.76013198e-02f, 1.43304214e-01f, 1.76921099e-01f, 3.03721637e-01f, 2.09754184e-01f, 1.67781383e-01f, 1.07611068e-01f, 1.67565122e-02f, 2.70213991e-01f,
  -4.03630175e-02f, -1.99915752e-01f, 1.32925883e-01f, 1.16053455e-01f, 4.99657430e-02f, 1.84501708e-01f, 1.49073958e-01f, 1.37087077e-01f, 1.07084841e-01f, 2.15229854e-01f,
  -3.38975154e-02f, 3.35275054e-01f, -1.74795419e-01f, -1.91170260e-01f, -6.14506705e-03f, -2.28313208e-01f, 1.35681614e-01f, 1.72616363e-01f, -2.90531754e-01f, -2.07686663e-01f,
  8.57679471e-02f, -1.29822046e-01f, -2.17592031e-01f, -3.60361755e-01f, 1.86108604e-01f, 1.49723202e-01f, 1.43938124e-01f, 4.03303236e-01f, 2.41693437e-01f, -1.64017767e-01f,
  3.00098300e-01f, -1.74402222e-01f, -2.97495991e-01f, 8.41965899e-02f, 3.53683889e-01f, -1.67281851e-01f, 9.55939889e-02f, -2.04712763e-01f, -2.49549504e-02f, 3.12802613e-01f,
  -3.46096575e-01f, 2.73536127e-02f, -1.55720815e-01f, 2.48519912e-01f, -5.17170615e-02f, 8.83219540e-01f, 5.57635248e-01f, -2.19829613e-03f, 5.34526587e-01f, -1.93249539e-01f,
  -9.53434631e-02f, 2.23959565e-01f, -6.38341382e-02f, -2.44154438e-01f, 1.53349429e-01f, 1.96696237e-01f, 1.09035663e-01f, 2.95727760e-01f, 1.85873836e-01f, 8.41772258e-02f,
  7.11525455e-02f, 1.44088537e-01f, 2.23884806e-01f, 1.36159230e-02f, 1.34112537e-01f, 1.42734021e-01f, 3.96441780e-02f, 1.04367107e-01f, 3.12918454e-01f, 1.51922926e-01f,
  2.10363671e-01f, 5.07567227e-02f, -8.68014246e-02f, 3.16745877e-01f, 9.42152590e-02f, 2.17270628e-02f, -4.77739163e-02f, 7.96580222e-04f, 1.95890278e-01f, -1.93567649e-01f,
  -6.58226237e-02f, -2.16346592e-01f, 1.77087020e-02f, -1.35776162e-01f, 8.84733647e-02f, -4.33133431e-02f, -2.32528329e-01f, -1.62946269e-01f, -2.67890394e-02f, -1.49373606e-01f,
  1.64316893e-01f, 1.99115537e-02f, -5.56959659e-02f, 1.06684901e-01f, -1.47221237e-01f, 2.61636339e-02f, 5.10600097e-02f, 2.68867999e-01f, 2.51918882e-01f, -1.16470650e-01f,
  -2.33892892e-02f, 1.44874677e-01f, -5.25204316e-02f, 5.95027208e-02f, -4.22132015e-01f, 1.46547243e-01f, 6.85932338e-02f, 2.18849462e-02f, -2.60658532e-01f, 1.31129876e-01f,
  -2.13342056e-01f, 1.84921622e-01f, -2.46007591e-01f, 1.79616347e-01f, 4.90678996e-02f, 2.37633795e-01f, -2.86170423e-01f, 2.82875896e-01f, 1.90851510e-01f, 2.06947587e-02f,
  1.54247449e-03f, 3.94782387e-02f, -2.97753308e-02f, 1.37669563e-01f, -1.40744718e-02f, 8.41631070e-02f, 5.48642874e-02f, 1.44953325e-01f, 3.50367203e-02f, -1.15210511e-01f,
  1.60366625e-01f, 6.53364658e-02f, -4.64502238e-02f, 1.18563563e-01f, -7.79173002e-02f, 9.16406438e-02f, 1.46069117e-02f, 1.48369521e-01f, 6.24972396e-02f, -8.54976401e-02f,
  1.80171773e-01f, -3.95370647e-02f, 8.15581903e-02f, -4.74452674e-02f, -2.68250853e-01f, -1.63114309e-01f, 1.39760688e-01f, -1.84305802e-01f, 1.36312246e-01f, -1.25773773e-01f,
  1.23702861e-01f, 8.96348283e-02f, 8.19406286e-02f, -1.67638168e-01f, -9.20566693e-02f, 1.77606225e-01f, -1.32048026e-01f, 6.17833175e-02f, 4.74998266e-01f, -1.41687235e-02f,
  2.67256856e-01f, -3.92552763e-02f, 3.31155419e-01f, 1.00099169e-01f, -6.56831264e-02f, 6.06947392e-02f, -7.42907599e-02f, 3.39139521e-01f, 1.13462463e-01f, -8.57822895e-02f,
  1.38296023e-01f, 1.19687609e-01f, 9.31862667e-02f, 2.27812514e-01f, 2.23893486e-02f, 1.33060113e-01f, 4.15976226e-01f, 3.88091713e-01f, 2.32542455e-01f, 1.37271941e-01f,
  7.07723349e-02f, 3.04351151e-01f, 1.25374213e-01f, -3.96117955e-01f, 1.22343689e-01f, -1.08291497e-02f, -9.49146450e-02f, -3.50038670e-02f, 3.52099463e-02f, 5.12884334e-02f,
  5.28257117e-02f, 7.56462812e-02f, -4.71222065e-02f, -1.47474813e-03f, 6.32534027e-02f, 1.00029252e-01f, -8.00371543e-02f, 9.62209180e-02f, 1.34179801e-01f, 6.63914531e-02f,
  6.63981587e-02f, 6.48906678e-02f, 1.23181574e-01f, -2.01165095e-01f, 1.34237006e-01f, 9.51475427e-02f, -1.05580159e-01f, 2.49323159e-01f, -1.40516505e-01f, 6.73721954e-02f,
  1.17086895e-01f, 4.42422256e-02f, -1.31879136e-01f, -2.13930190e-01f, 1.17584348e-01f, 3.71706724e-01f, 8.00628290e-02f, -1.96695775e-02f, -2.59944707e-01f, 7.96145871e-02f,
  -2.64757693e-01f, -2.54313331e-02f, 3.12322527e-01f, 1.36002287e-01f, 2.08272815e-01f, -5.39539289e-03f, 7.58191198e-02f, 5.94764948e-01f, 1.88617513e-01f, -1.72588360e-02f,
  1.12847790e-01f, 2.03876719e-01f, 7.17665315e-01f, -1.66178137e-01f, 2.79391736e-01f, -1.80137217e-01f, 3.46838772e-01f, -4.90015805e-01f, 1.31045714e-01f, -9.56954509e-02f,
  1.32958353e-01f, -2.25371718e-02f, -1.38032377e-01f, -1.90084368e-01f, 2.60768145e-01f, 2.50292271e-01f, 5.33036403e-02f, -2.35392004e-01f, 6.83959350e-02f, 1.95561185e-01f,
  2.32764393e-01f, 4.25490066e-02f, 1.75124839e-01f, 3.45736086e-01f, 4.33802791e-02f, 3.86873722e-01f, 1.44113302e-02f, -3.11541520e-02f, -8.07444900e-02f, 1.28921568e-01f,
  1.83644921e-01f, 8.44265446e-02f, 1.24911211e-01f, 1.64110124e-01f, 2.44321600e-01f, 3.78198236e-01f, 1.61837235e-01f, -5.17807752e-02f, -1.05652869e-01f, 3.03895533e-01f,
  -3.01041752e-01f, 3.89599264e-01f, 3.50746773e-02f, -3.81504446e-02f, 3.95576619e-02f, 1.21994138e-01f, -1.91024631e-01f, 9.67244655e-02f, -8.63914564e-02f, 7.82733113e-02f,
  2.90601477e-02f, -6.42737898e-04f, -3.57183665e-02f, -1.54203931e-02f, -2.74679810e-01f, 1.46104231e-01f, 1.94598287e-01f, -2.10334925e-04f, -2.94080198e-01f, 2.18670428e-01f,
  3.04365814e-01f, 2.67794132e-01f, 5.89082614e-02f, -1.83881715e-01f, -3.32250357e-01f, -2.41147235e-01f, 4.07167077e-01f, 3.25543694e-02f, -6.26112521e-02f, -6.38478994e-02f,
  4.81759220e-01f, 1.40523940e-01f, 4.12185520e-01f, -1.62694380e-01f, -2.96641797e-01f, -3.53735894e-01f, -3.56965184e-01f, 2.24371716e-01f, 1.63381454e-02f, -1.23591319e-01f,
  -7.78800696e-02f, -1.05831459e-01f, -1.88016724e-02f, 3.79090384e-02f, 4.57544550e-02f, -5.04981168e-02f, 2.21366752e-02f, -1.41299844e-01f, -5.33918850e-02f, -3.96924205e-02f,
  -1.88870132e-01f, 5.33202700e-02f, -1.01652788e-02f, -4.92344387e-02f, 1.39420358e-02f, -6.49798363e-02f, 5.54828234e-02f, -3.95087898e-03f, 5.62297478e-02f, 2.00259566e-01f,
  2.02806424e-02f, -9.39295366e-02f, 1.45414891e-02f, -7.44519234e-02f, -5.79510443e-02f, 1.53279901e-01f, -4.03994024e-02f, -4.27482463e-03f, 2.55611897e-01f, 7.09992945e-02f,
  -4.68717255e-02f, -3.10539305e-02f, -9.04709846e-02f, 2.46947259e-01f, -5.60640842e-02f, -1.46745637e-01f, -2.18820840e-01f, -2.78803464e-02f, 1.15360327e-01f, 5.88603243e-02f,
  -7.17703551e-02f, 1.01601081e-02f, -1.29040249e-03f, 2.86542773e-01f, 2.47392401e-01f, -8.64668936e-02f, -2.63427973e-01f, -4.15469259e-01f, -2.49009490e-01f, 2.26105481e-01f,
  4.33046699e-01f, 2.40846440e-01f, 3.46250564e-01f, -3.76652062e-01f, -5.39375693e-02f, -5.04189074e-01f, -2.76426207e-02f, 1.09769255e-01f, -1.23318188e-01f, 2.92831004e-01f,
  -2.82019347e-01f, -1.79292858e-01f, 9.09565110e-03f, 2.94203550e-01f, 3.50159645e-01f, -7.10664392e-02f, 1.22130096e-01f, -4.72913060e-04f, 7.21701682e-02f, -3.81863751e-02f,
  1.69027776e-01f, 2.13420019e-01f, 1.53316567e-02f, 1.92677796e-01f, -1.68394357e-01f, -1.14701791e-02f, 1.43842369e-01f, 1.53873088e-02f, 1.55624345e-01f, -3.19874287e-02f,
  1.08586431e-01f, 1.24316283e-01f, 1.24066293e-01f, 2.18490884e-01f, 2.72878617e-01f, 1.09655038e-01f, 2.57764399e-01f, -2.60400862e-01f, 1.26144961e-01f, 3.41671169e-01f,
  3.19025546e-01f, 1.46788090e-01f, -1.77947834e-01f, -3.03634331e-02f, -1.74853802e-01f, -7.40143135e-02f, 3.01410168e-01f, 2.07078233e-01f, 7.57325813e-02f, -1.72724411e-01f,
  1.05473042e-01f, -3.20728689e-01f, 4.31943476e-01f, -3.74752991e-02f, 5.15605770e-02f, 1.02716209e-02f, 9.38876569e-02f, -3.30397069e-01f, 6.07844330e-02f, 1.89972699e-01f,
  3.81521940e-01f, 2.51703233e-01f, 1.45459101e-01f, -1.54299542e-01f, 7.35992268e-02f, -1.42577127e-01f, -2.56754637e-01f, -8.62462148e-02f, 6.80883378e-02f, -3.32590044e-01f,
  -1.18352495e-01f, -1.94099545e-01f, 5.40681668e-02f, 1.88512467e-02f, 1.26220018e-01f, 2.32161313e-01f, -1.00886270e-01f, -2.66599417e-01f, -2.22110301e-01f, -1.05235420e-01f,
  1.55543789e-01f, 1.87043384e-01f, 1.60708770e-01f, 2.62707323e-01f, 2.39489228e-02f, 1.71346720e-02f, 2.02564821e-01f, 5.14758714e-02f, 1.07399628e-01f, 2.94676363e-01f,
  1.07738838e-01f, 1.93987459e-01f, 2.03008845e-01f, 2.33043581e-01f, 3.18647712e-01f, 3.92949767e-02f, 2.86276340e-01f, 1.31078258e-01f, 9.32075456e-02f, 7.20645487e-03f,
  -2.14266464e-01f, -1.40607372e-01f, -1.89114735e-01f, -2.66735524e-01f, 9.81659889e-02f, 1.01292031e-02f, -4.92778830e-02f, -6.06307993e-03f, 1.65517494e-01f, -9.18917824e-03f,
  -2.23212793e-01f, -2.28244647e-01f, 1.06180526e-01f, 1.01313598e-01f, -1.31297335e-01f, 1.64690167e-01f, 2.93056548e-01f, -2.82111585e-01f, -2.63093144e-01f, -1.96132243e-01f,
  -1.49884447e-01f, 2.39160806e-01f, 5.69188595e-02f, 1.64390609e-01f, 1.11193405e-02f, 1.83155477e-01f, 1.86465964e-01f, 4.40802366e-01f, -1.71949178e-01f, 4.01534766e-01f,
  4.67391193e-01f, -6.29661232e-02f, -8.73655453e-02f, 5.76801658e-01f, 1.32332683e-01f, 1.90858632e-01f, 1.89324170e-01f, -1.26221269e-01f, -2.57025510e-01f, 1.41666412e-01f,
  -1.38228193e-01f, 1.79854572e-01f, 3.48949790e-01f, 5.37328780e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  3.66005957e-01f, 2.49121800e-01f, 4.16970819e-01f, 1.73296675e-01f, 1.63654238e-01f, 4.43033457e-01f, 2.04813898e-01f, 1.71941042e-01f, 2.49133244e-01f, 4.44499135e-01f,
  3.95740896e-01f, 1.43687844e-01f, 3.45209092e-01f, 2.80702531e-01f, 7.97488019e-02f, 1.79355934e-01f, -5.90830855e-02f, 8.96650627e-02f, 9.12749842e-02f, 1.78013518e-01f,
  -1.58650279e-01f, 4.60322462e-02f, 2.09937721e-01f, 5.68441264e-02f, 3.02598804e-01f, 3.56874883e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  2.24624217e-01f, -1.73997313e-01f, -1.18689820e-01f, -8.05351585e-02f, 9.25991312e-02f, -9.24012810e-02f, -2.87954748e-01f, -3.46304953e-01f, 4.38756607e-02f, 5.79139125e-03f,
  1.67085513e-01f, 4.26717252e-02f, -2.61542797e-01f, -3.68314721e-02f, -2.21123233e-01f, -2.06886515e-01f, -3.14817905e-01f, 5.65202124e-02f, -1.24015167e-01f, 2.03319088e-01f,
  2.30959848e-01f, -7.61784986e-02f, 3.18727463e-01f, 2.64070570e-01f, -2.03735366e-01f, -1.53370380e-01f, 4.17060733e-01f, -2.97519863e-02f, -2.87009567e-01f, 9.22619477e-02f,
  1.34021148e-01f, -3.42629164e-01f, -3.65407139e-01f, -1.05004281e-01f, -3.67992461e-01f, 1.64400950e-01f, -3.05555910e-01f, -1.44244894e-01f, -1.77025571e-01f, -6.31239265e-02f,
  -3.43037456e-01f, 1.12861216e-01f, -9.27278250e-02f, -1.76582813e-01f, -6.14176057e-02f, 9.81929600e-02f, -2.74936646e-01f, -6.58718348e-01f, -6.44818544e-02f, 1.57896861e-01f,
  -4.62949798e-02f, -3.93440932e-01f, -1.46533847e-01f, -1.16356283e-01f, 4.42659080e-01f, -3.19869667e-01f, -9.95542258e-02f, 3.72794196e-02f, 2.09778249e-01f, 2.00191304e-01f,
  -3.18127066e-01f, 3.35848033e-01f, -1.45986572e-01f, 9.91415530e-02f, 6.76508993e-02f, 2.53824238e-02f, -3.64992092e-03f, 2.00156659e-01f, -3.14951390e-01f, -5.26891509e-03f,
  -2.49963868e-02f, -7.43113980e-02f, 1.04340035e-02f, -2.81873178e-02f, -1.71727851e-01f, -2.02936620e-01f, 1.33229032e-01f, -1.69826776e-01f, 5.20872101e-02f, -3.06003660e-01f,
  -2.74073277e-02f, 1.31633282e-01f, -2.69075036e-01f, -5.36519885e-02f, 5.82692027e-01f, 1.66815579e-01f, 1.96497943e-02f, -3.22966367e-01f, 3.00031453e-01f, -2.34698012e-01f,
  3.46890092e-01f, 7.73372203e-02f, 4.70718592e-01f, 3.98428112e-01f, -5.27345300e-01f, 3.13415557e-01f, -1.82448983e-01f, 1.14587825e-02f, -2.29252651e-01f, 2.92242527e-01f,
  -3.01093847e-01f, 1.00921234e-02f, -4.89753753e-01f, 4.54750843e-04f, 1.23639211e-01f, 8.20134506e-02f, 1.89410791e-01f, -2.44922325e-01f, 3.56530160e-01f, 8.14911649e-02f,
  1.55937493e-01f, -4.62285280e-01f, -7.38616362e-02f, -2.55574584e-01f, -1.41480088e-01f, -6.55615926e-01f, 5.59697710e-02f, -4.81348395e-01f, 1.75208479e-01f, 3.20124269e-01f,
  -1.74293309e-01f, -3.32999110e-01f, 2.30058417e-01f, 3.01332712e-01f, -8.93967599e-02f, 8.58288407e-02f, 9.35211480e-02f, -6.51417732e-01f, -4.65697795e-01f, 2.08391652e-01f,
  7.70668089e-02f, 5.98073006e-02f, -3.37747872e-01f, 2.00810414e-02f, 4.88042794e-02f, 1.02485716e-02f, -1.76955223e-01f, 1.75870750e-02f, 1.35717466e-01f, -3.42932135e-01f,
  1.02312006e-01f, -1.47368103e-01f, -8.66661593e-02f, -1.27966672e-01f, -1.25252143e-01f, 2.90267915e-02f, 1.20419376e-01f, -6.77360967e-02f, -6.19554400e-01f, 6.20904453e-02f,
  -2.93447495e-01f, -1.28470033e-01f, -3.43913108e-01f, 1.09548070e-01f, -1.00884929e-01f, 2.93524146e-01f, -3.50928530e-02f, -3.61264765e-01f, 3.24485511e-01f, -1.92518115e-01f,
  1.93790630e-01f, -3.99152562e-02f, -1.95594877e-01f, -2.39417553e-01f, 1.94672883e-01f, 2.31258906e-02f, 1.63321290e-02f, 5.02314456e-02f, 3.72804523e-01f, -3.88731211e-02f,
  2.45865360e-01f, -3.07081163e-01f, 1.02572076e-01f, -4.58724312e-02f, -3.10675651e-01f, 2.36385211e-01f, -5.68064749e-01f, -2.80152828e-01f, -2.79087037e-01f, -4.92150098e-01f,
  -9.79977697e-02f, 3.70608985e-01f, 3.70035261e-01f, -4.89735574e-01f, -6.27200782e-01f, -1.17803939e-01f, -1.29409179e-01f, 3.60304207e-01f, 3.11284363e-01f, -1.21943820e-02f,
  -1.48234919e-01f, -1.08055770e-01f, 5.13395965e-01f, 1.16935827e-01f, 8.75041354e-03f, 2.95554399e-01f, 3.96477170e-02f, -7.75019154e-02f, 3.83563824e-02f, -1.52612731e-01f,
  -1.34914890e-01f, -1.90996483e-01f, 1.29703805e-01f, -7.90380407e-03f, -1.38142720e-01f, -1.54255833e-02f, -7.45138824e-02f, 3.34562152e-03f, -1.12266295e-01f, -1.59712419e-01f,
  -2.60121942e-01f, -7.36993505e-03f, 2.65965223e-01f, 3.16528350e-01f, -9.27483365e-02f, 5.53593412e-02f, -1.14917029e-02f, 2.14754239e-01f, 4.60264206e-01f, -7.28990376e-01f,
  -4.16897200e-02f, -9.39972028e-02f, -2.54979193e-01f, 1.39505059e-01f, 2.32325524e-01f, 4.79895510e-02f, 2.67861784e-01f, -1.72750384e-01f, -4.15677994e-01f, -2.59164631e-01f,
  -1.97073206e-01f, -9.72090721e-01f, -1.37042120e-01f, 1.60719126e-01f, -3.06479812e-01f, -1.95034340e-01f, -3.06789011e-01f, -2.58412305e-02f, -4.84947473e-01f, 3.02662909e-01f,
  -3.21743608e-01f, 2.24215118e-03f, -2.08434075e-01f, -9.41477269e-02f, -6.04082882e-01f, 4.18826789e-01f, 2.21537724e-01f, -3.29506397e-01f, 4.82900202e-01f, -9.54652131e-02f,
  3.11943442e-02f, -1.94788203e-01f, -3.89698744e-01f, -3.07387143e-01f, -9.54600349e-02f, 2.79071033e-01f, -3.23683769e-01f, -1.29331388e-02f, -5.03996052e-02f, -7.22358972e-02f,
  -9.40809026e-02f, -2.42391616e-01f, -1.77692682e-01f, 9.18179080e-02f, 1.92692697e-01f, -4.40947831e-01f, -7.77243674e-02f, 1.05454601e-01f, -2.71595329e-01f, 4.19735670e-01f,
  -1.23561569e-01f, 1.39056265e-01f, -2.32704833e-01f, 2.09239423e-01f, 1.99490055e-01f, -2.14474559e-01f, -3.40845883e-01f, -4.38762844e-01f, -4.66710150e-01f, 2.81687230e-01f,
  4.73363787e-01f, 2.61613995e-01f, -3.07364404e-01f, 3.73918086e-01f, -6.26365393e-02f, 1.75985768e-01f, 2.76361287e-01f, 2.83698887e-01f, -5.39759221e-03f, -2.86979675e-02f,
  4.27265972e-01f, -2.85453387e-02f, 4.96957958e-01f, 2.88193375e-01f, 4.49231863e-01f, -1.12770937e-01f, -3.14154685e-01f, 9.21763927e-02f, -3.61807644e-01f, 2.32954115e-01f,
  -6.32089078e-01f, 1.42884418e-01f, 1.65659308e-01f, 4.55908403e-02f, -2.30045289e-01f, 1.96682721e-01f, -5.60082316e-01f, 7.06274584e-02f, -2.01721434e-02f, 3.09775114e-01f,
  -3.56527179e-01f, 1.40586942e-01f, -2.88528204e-01f, 7.67403543e-02f, -6.36963993e-02f, -3.96015914e-03f, -3.71199429e-01f, 2.56292522e-01f, 6.89967722e-02f, 1.41440585e-01f,
  -2.68419981e-01f, -1.33725544e-02f, -3.26880999e-02f, -2.44503409e-01f, 3.38542998e-01f, 2.49864738e-02f, 3.35667878e-01f, -4.46226448e-03f, -2.76279986e-01f, 4.30386096e-01f,
  6.91564307e-02f, 1.23057038e-01f, 1.18512847e-01f, 2.47239903e-01f, 8.54512751e-02f, 1.62369385e-01f, 2.14612275e-01f, 3.75151262e-02f, -1.34894714e-01f, 2.73186658e-02f,
  -3.34453136e-01f, -2.99686819e-01f, -3.99352573e-02f, 2.27956221e-01f, 4.68811616e-02f, -1.69955850e-01f, -2.38227412e-01f, 3.20452958e-01f, -2.10071146e-01f, -8.42431411e-02f,
  -1.07954457e-01f, 2.06663996e-01f, 6.74182922e-02f, 4.03063476e-01f, -6.10457323e-02f, -1.64179385e-01f, -2.64826894e-01f, -2.44499296e-01f, -3.67722958e-01f, 5.54753887e-03f,
  -1.85076430e-01f, 2.23242611e-01f, -3.63883734e-01f, 1.28421724e-01f, 2.05897212e-01f, 2.44328663e-01f, -1.55781731e-01f, -5.31947434e-01f, -4.72336024e-01f, 1.82780936e-01f,
  -1.74144447e-01f, 4.23107594e-01f, 1.90638855e-01f, -5.65786004e-01f, -3.96014601e-01f, 8.95835310e-02f, 7.71896681e-03f, 3.38627756e-01f, 2.51477331e-01f, -3.38441789e-01f,
  -3.46412122e-01f, -2.95805782e-01f, -8.56961608e-02f, -1.72404706e-01f, 1.07790507e-01f, 7.11061200e-03f, 2.08793074e-01f, 6.93850815e-02f, 2.27752045e-01f, -3.08715671e-01f,
  -6.64403588e-02f, 2.04992160e-01f, -6.53466955e-02f, -1.45791262e-01f, 2.23251104e-01f, 2.51039028e-01f, -1.20402381e-01f, 2.19159499e-01f, -9.26734414e-03f, 1.67900726e-01f,
  -1.20148376e-01f, 2.52117123e-02f, 1.05278436e-02f, -1.62533119e-01f, -2.83070356e-01f, 3.16730797e-01f, 4.47233528e-01f, -3.30245763e-01f, -6.41047582e-02f, -2.69168913e-01f,
  -3.51536982e-02f, 1.40235335e-01f, 4.96291459e-01f, 7.70668760e-02f, 1.32893369e-01f, -4.06169742e-01f, 2.20479876e-01f, -3.94746184e-01f, 1.89356282e-01f, -4.88618195e-01f,
  4.92681712e-01f, 2.72495478e-01f, -2.95232773e-01f, 3.37795019e-01f, 3.39255631e-02f, 3.66915539e-02f, 2.62225956e-01f, 4.62747484e-01f, 1.30894512e-01f, -8.49106848e-01f,
  -1.53675195e-04f, 2.82805804e-02f, 3.04249704e-01f, -6.77346349e-01f, -1.55309821e-02f, -1.02370121e-01f, -2.91923404e-01f, -3.34783018e-01f, -5.24959445e-01f, -2.72027642e-01f,
  -4.31662500e-01f, -2.71544397e-01f, -2.41696134e-01f, 6.01856001e-02f, 3.02575439e-01f, -5.29632866e-01f, 1.61215857e-01f, -7.63755798e-01f, -2.73374692e-02f, -2.81115592e-01f,
  -1.36047363e-01f, -8.16267952e-02f, -1.17502950e-01f, 1.46361679e-01f, -2.29453236e-01f, 1.08115807e-01f, 1.54196486e-01f, -3.06319386e-01f, -3.10851216e-01f, -2.63241470e-01f,
  8.73343796e-02f, -2.43713126e-01f, 1.51855901e-01f, -3.29179466e-01f, -1.02004588e-01f, -1.76562928e-02f, 2.90455716e-03f, 2.18282089e-01f, 1.10449106e-01f, 1.09945603e-01f,
  1.10411949e-01f, 1.72419533e-01f, 1.95906267e-01f, -3.33729208e-01f, -1.54567808e-01f, -2.55142868e-01f, -2.37470269e-01f, -3.22376549e-01f, 1.95137337e-01f, -7.46865571e-02f,
  -6.62515461e-02f, -3.32052223e-02f, 2.44334862e-01f, 2.34780475e-01f, 3.79003920e-02f, -1.15755513e-01f, -2.21464053e-01f, 3.13538387e-02f, -2.10614935e-01f, -1.96895868e-01f,
  -2.48850673e-01f, -3.62356663e-01f, -3.95290852e-01f, -3.54936242e-01f, 2.40493596e-01f, 3.36431354e-01f, 6.55664876e-02f, -1.08365327e-01f, 2.26270646e-01f, -2.83850223e-01f,
  1.41536176e-01f, -1.44124493e-01f, -3.54068905e-01f, -4.52279076e-02f, 4.40370291e-01f, -3.52790356e-01f, -1.12949729e-01f, -2.16399774e-01f, 7.63986558e-02f, -2.03527108e-01f,
  -2.61129677e-01f, 1.54569134e-01f, 1.72234714e-01f, -4.19703797e-02f, -1.91038340e-01f, 1.01295017e-01f, -1.81624666e-01f, -4.43306789e-02f, 1.17077798e-01f, -3.25923078e-02f,
  -3.92655469e-03f, -1.52038440e-01f, -8.75221938e-02f, 3.58754047e-03f, -8.21504816e-02f, 5.99276461e-02f, 1.14054956e-01f, -2.86090195e-01f, -3.49102430e-02f, -2.82068074e-01f,
  -5.85111938e-02f, -1.14171179e-02f, -3.52901220e-01f, 2.49034479e-01f, -4.82696593e-01f, -2.18508378e-01f, 4.59802747e-02f, 4.66249615e-01f, -2.33633220e-01f, -2.80561090e-01f,
  1.23691134e-01f, 1.66145787e-01f, -6.25443384e-02f, -3.15779477e-01f, 2.96020806e-01f, -4.11526471e-01f, -1.87501252e-01f, 3.75358343e-01f, -1.44167960e-01f, -2.93594062e-01f,
  -3.83630276e-01f, -2.52079755e-01f, 3.96224976e-01f, -6.73643708e-01f, 2.95297831e-01f, -6.06147826e-01f, 3.23314555e-02f, -2.93271512e-01f, -7.25087225e-02f, -4.37031478e-01f,
  -2.99720056e-02f, -4.90635306e-01f, 4.89025652e-01f, 5.72138846e-01f, 1.94880947e-01f, -2.76164830e-01f, -1.88246667e-01f, -5.18141836e-02f, -2.62724966e-01f, 1.25239119e-01f,
  -1.95389360e-01f, -9.57676321e-02f, -1.78411171e-01f, -3.55695367e-01f, 3.30814213e-01f, 2.51617789e-01f, -7.34073669e-02f, 2.43094023e-02f, 1.68776646e-01f, 3.21590751e-01f,
  8.08668286e-02f, -1.62875857e-02f, -4.25895629e-03f, 2.05575619e-02f, 2.38698255e-02f, 2.34408639e-02f, -4.02298748e-01f, 1.76217668e-02f, 1.14074968e-01f, 1.03634847e-02f,
  2.22293258e-01f, 1.77499413e-01f, 3.56362194e-01f, -3.00079316e-01f, 1.85821980e-01f, -5.16364314e-02f, 2.56485045e-01f, -4.88699347e-01f, 1.37865022e-01f, 3.90692085e-01f,
  -5.00477552e-01f, 1.29530191e-01f, -2.47147799e-01f, 1.85961828e-01f, -4.94007409e-01f, -3.23710144e-01f, 4.55746055e-02f, -3.02942663e-01f, 1.72060594e-01f, -2.21488476e-01f,
  1.38760537e-01f, 1.58033460e-01f, 4.14218754e-01f, 3.88659775e-01f, 4.64810103e-01f, 2.95397520e-01f, -5.97314000e-01f, 1.36200517e-01f, -1.21950567e-01f, 5.40679172e-02f,
  -1.81138515e-01f, 3.99024248e-01f, -3.22890133e-01f, 1.32928059e-01f, 2.10605443e-01f, 5.73383048e-02f, 4.97364223e-01f, -4.69117731e-01f, -4.41096902e-01f, -6.46973014e-01f,
  -3.30969304e-01f, -4.62491006e-01f, -4.45748568e-01f, 5.16990721e-02f, -2.18086988e-01f, 6.93191960e-03f, 4.25043479e-02f, -1.19734809e-01f, -5.54398000e-01f, -1.12300195e-01f,
  1.02766104e-01f, -2.44441733e-01f, 1.78511202e-01f, -1.82557434e-01f, 1.99641109e-01f, -1.04546435e-02f, 1.43466771e-01f, 5.07728942e-02f, 1.11276060e-01f, 2.44287461e-01f,
  1.13189735e-01f, 5.96152693e-02f, -2.37112176e-02f, 9.30909887e-02f, 1.51588619e-01f, 1.13726847e-01f, 1.45876959e-01f, 2.03326657e-01f, 1.39918536e-01f, -2.68696789e-02f,
  3.40293407e-01f, -2.92942345e-01f, -2.74135441e-01f, 1.19427092e-01f, 1.43200099e-01f, 1.62024215e-01f, -5.25838062e-02f, -4.24037725e-01f, 1.62783399e-01f, 9.68129933e-02f,
  -3.15292776e-01f, -7.61928633e-02f, -3.92654091e-01f, -4.33194131e-01f, -2.07083225e-01f, 1.51337937e-01f, 2.81960666e-01f, -2.47753307e-01f, 4.33724225e-01f, -5.01999378e-01f,
  -2.83480734e-01f, -5.97478390e-01f, 3.42732817e-01f, -4.06930983e-01f, -2.83496290e-01f, 2.29500711e-01f, -6.15676522e-01f, -4.61779088e-02f, -3.00687760e-01f, -4.45969760e-01f,
  -2.99778491e-01f, -2.09253374e-02f, 1.78229406e-01f, -8.65199864e-02f, -3.57355297e-01f, 1.27639666e-01f, 5.24385333e-01f, 2.51256585e-01f, -8.73644948e-02f, -3.73249441e-01f,
  5.05177617e-01f, 4.90727127e-02f, -2.42119506e-01f, 5.03717847e-02f, 1.74335063e-01f, 1.41566889e-02f, -1.15722351e-01f, -7.95062780e-02f, -7.06216469e-02f, 3.01638156e-01f,
  1.24390326e-01f, -2.87282355e-02f, 5.85320666e-02f, 6.70416653e-02f, 2.75144935e-01f, 2.47872218e-01f, 1.28838718e-01f, -1.19642630e-01f, -6.09042235e-02f, 3.25061798e-01f,
  2.08475232e-01f, 2.33521596e-01f, 2.83425540e-01f, 4.09138680e-01f, -1.98500305e-01f, 2.39548862e-01f, 3.68780315e-01f, -2.12829113e-01f, -2.45091885e-01f, -1.34641394e-01f,
  -8.34890306e-02f, 1.04066338e-02f, -1.33909091e-01f, 1.29986122e-01f, -9.67431143e-02f, 3.14146996e-01f, 2.59498894e-01f, 5.94617128e-01f, 1.45172819e-01f, -2.31917918e-01f,
  -4.68694597e-01f, 2.81002939e-01f, -1.55340098e-02f, -5.51078320e-01f, 2.49154583e-01f, -2.44781598e-01f, -2.13391304e-01f, 1.93840653e-01f, -8.26077834e-02f, -5.50776839e-01f,
  2.47390196e-01f, -1.62220141e-03f, 4.06788290e-01f, 6.11334503e-01f, -1.16458856e-01f, 1.58501238e-01f, -6.43493533e-01f, -2.02304482e-01f, 8.62872973e-02f, 1.92785412e-01f,
  1.28598705e-01f, 1.29896224e-01f, -3.78047585e-01f, -5.07954121e-01f, -5.20727277e-01f, -1.76976815e-01f, 3.58864218e-01f, 5.34358397e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.02197745e-01f, -5.33235110e-02f, 2.89733033e-03f, 2.60861088e-02f, -3.91981676e-02f, -1.23943068e-01f, 2.13255227e-01f, 4.04694453e-02f, -5.59176765e-02f, 1.30485043e-01f,
  -9.58659593e-03f, 1.47845358e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    