/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.35460222e-02f, 1.12823531e-01f, 1.84683546e-01f, 4.12053503e-02f, -1.00036734e-03f, -1.06926844e-01f, -1.26144603e-01f, -6.37191981e-02f, -1.97739437e-01f, 8.34569614e-03f,
  -4.16039191e-02f, -6.24558292e-02f, -9.80864614e-02f, 2.38926592e-03f, 6.70938008e-03f, 4.84225191e-02f, 2.09074184e-01f, 1.76439211e-01f, -1.52389869e-01f, -2.20886335e-01f,
  -8.14581960e-02f, -5.66751920e-02f, 6.09312356e-02f, -3.61679634e-03f, -1.19151130e-01f, -4.82692234e-02f, 7.16148317e-02f, 2.03509163e-02f, 2.54551824e-02f, 3.13476712e-01f,
  -3.82524766e-02f, 5.94416708e-02f, -2.65194811e-02f, 2.21128333e-02f, 8.11644793e-02f, -3.77894356e-03f, -1.19344359e-02f, 8.87370557e-02f, 2.26185359e-02f, -1.00601334e-02f,
  8.58442262e-02f, 4.08942290e-02f, 3.87314297e-02f, 1.71217415e-02f, 7.31461681e-03f, -2.98375022e-02f, 7.18437657e-02f, 8.19067806e-02f, 7.08918720e-02f, 2.24651652e-03f,
  2.95853056e-02f, 1.50468677e-01f, 1.47087802e-03f, -1.50996130e-02f, 1.48023218e-02f, 6.44148365e-02f, -1.98102295e-02f, 4.97791320e-02f, -6.41382560e-02f, -8.84841830e-02f,
  3.64957452e-02f, -6.53794110e-02f, 3.26760449e-02f, -1.04762828e-02f, 6.20945648e-04f, 2.10067257e-02f, 3.11845206e-02f, -3.85693423e-02f, 7.01741874e-02f, -3.86286788e-02f,
  1.38405589e-02f, -6.23407476e-02f, 9.52560548e-03f, -4.07924093e-02f, -7.29918014e-03f, 1.56828240e-02f, -6.80945516e-02f, 1.22118797e-02f, 6.06677718e-02f, 1.20279863e-02f,
  -3.82886529e-02f, -4.74532554e-03f, 2.23559747e-03f, -4.35261577e-02f, 8.73840973e-02f, 5.95857017e-02f, -1.22883089e-03f, 3.51684093e-02f, -4.80005667e-02f, 5.03185540e-02f,
  -3.30451816e-01f, 9.09877121e-02f, -4.71017361e-02f, -3.30125727e-02f, 2.28254478e-02f, 4.42308933e-02f, 3.95584740e-02f, 3.15618142e-02f, 3.22107673e-02f, -9.09553543e-02f,
  -1.22876549e-02f, -3.43028419e-02f, -5.92860393e-03f, 2.57098414e-02f, -1.20416127e-01f, 2.07335479e-03f, 5.11376150e-02f, -1.25198871e-01f, 3.50809209e-02f, 5.59194274e-02f,
  2.64081638e-02f, -9.84091088e-02f, -2.34186783e-01f, -1.24522008e-01f, -1.24277189e-01f, -1.77549616e-01f, -1.88969582e-01f, -1.58873275e-01f, -2.34790474e-01f, -3.04920375e-01f,
  1.87526360e-01f, -6.35026991e-02f, 4.47682232e-01f, 1.46409934e-02f, 2.49698162e-01f, 1.78746834e-01f, 2.09575996e-01f, 1.77492738e-01f, -2.37091500e-02f, 7.62963071e-02f,
  -5.19114397e-02f, -1.81243837e-01f, -2.49114439e-01f, -1.91044509e-01f, 6.84134290e-03f, 4.96392846e-02f, 9.13407356e-02f, 1.63471699e-01f, 1.83289751e-01f, 8.60769451e-02f,
  -3.09013147e-02f, 1.73929438e-01f, 7.23833516e-02f, 7.72029310e-02f, -1.73728482e-03f, -1.28173709e-01f, 6.44394085e-02f, -2.36561298e-02f, -3.29994895e-02f, -2.11797152e-02f,
  -4.23189066e-02f, 2.36637712e-01f, 4.58599478e-02f, -3.59479780e-03f, -7.35828280e-02f, 4.94279026e-04f, -1.53211681e-02f, 4.67281714e-02f, 2.01103045e-03f, 3.63095067e-02f,
  5.50353006e-02f, 2.22205073e-02f, 3.81420180e-02f, -2.62957904e-02f, 4.24241908e-02f, 8.70120823e-02f, -2.76485812e-02f, 9.03468430e-02f, -2.06935201e-02f, 5.44520169e-02f,
  -1.03178084e-01f, 1.58749163e-01f, 1.21943407e-01f, 8.12243149e-02f, 3.22545879e-02f, 4.46231514e-02f, 8.95383582e-02f, -4.93431045e-03f, 1.33108407e-01f, -1.60958096e-02f,
  1.11727528e-02f, 7.69164972e-03f, -2.93071587e-02f, 1.91782750e-02f, -5.21279387e-02f, 3.36138392e-03f, 3.93302273e-03f, -3.58624086e-02f, 1.81854181e-02f, -4.17003185e-02f,
  -1.25552376e-03f, -7.75026111e-03f, -1.53774824e-02f, 1.02175720e-01f, -8.08334649e-02f, 3.12416125e-02f, -8.28338601e-03f, -4.94519696e-02f, -9.11543425e-03f, -5.22616096e-02f,
  -2.28310609e-03f, 3.70225720e-02f, -8.17121938e-03f, -2.41432767e-02f, 2.81458329e-02f, -1.93920713e-02f, -3.14129516e-03f, -1.51372943e-02f, -5.08069061e-03f, 2.47372352e-02f,
  -1.22536190e-01f, -7.09791407e-02f, -8.08849335e-02f, -5.21423146e-02f, 9.40653533e-02f, -6.45498708e-02f, -4.33481596e-02f, -7.97684398e-03f, -3.51137854e-02f, -6.25362620e-03f,
  4.46991175e-02f, -3.27859446e-02f, 1.78588349e-02f, 2.29448769e-02f, 4.10540961e-02f, 6.19152784e-02f, -9.65633392e-02f, 3.83482799e-02f, -3.43005657e-02f, -2.62109935e-02f,
  -9.37700178e-03f, -2.87886951e-02f, -4.31644954e-02f, 4.39725630e-02f, -3.71445902e-02f, -1.35945613e-02f, 6.36237487e-02f, 4.07925472e-02f, 1.57703646e-02f, -1.50614873e-01f,
  -3.71384025e-01f, 2.40729693e-02f, -1.28422290e-01f, -3.39675039e-01f, 6.55560568e-02f, 2.50434935e-01f, 9.88828465e-02f, 1.88857183e-01f, 6.84800446e-02f, -3.90554219e-02f,
  3.82407056e-03f, -5.48533313e-02f, -1.12294301e-01f, -1.96692292e-02f, -4.82752398e-02f, -9.04933959e-02f, -1.28810585e-01f, -1.58654362e-01f, -9.49399266e-03f, 1.41282544e-01f,
  -3.10079996e-02f, -1.67639583e-01f, -1.56520337e-01f, -1.07483054e-03f, -9.16366931e-03f, 4.53766771e-02f, -6.28733262e-02f, -4.90882210e-02f, 4.43587527e-02f, -1.03884198e-01f,
  -9.33695585e-02f, 6.58604130e-02f, 6.65790886e-02f, 1.03488732e-02f, 1.07006291e-02f, -2.64530238e-02f, -3.91946808e-02f, -7.84363002e-02f, 7.52094090e-02f, -6.61140634e-03f,
  -3.20620239e-02f, 5.22243697e-03f, -1.13352053e-01f, -2.49249525e-02f, -1.35536622e-02f, 1.86099131e-02f, 4.50579338e-02f, 3.10379416e-02f, 1.02420419e-03f, 2.46873740e-02f,
  7.36615504e-04f, 1.45701855e-01f, -7.03837276e-02f, 1.37310773e-01f, 8.53519514e-02f, -6.01988919e-02f, 4.13796213e-03f, 1.24124877e-01f, 3.45684923e-02f, 1.07369900e-01f,
  2.34638471e-02f, -7.30048940e-02f, 4.33298871e-02f, -2.92943348e-03f, 1.02784168e-02f, 5.64289317e-02f, -6.30766386e-03f, 2.73372550e-02f, 2.97019668e-02f, -3.05246841e-02f,
  2.64088456e-02f, -2.16334742e-02f, 4.03326657e-03f, -2.30642296e-02f, 1.20415678e-02f, -4.72064503e-03f, -3.22185047e-02f, -1.71849858e-02f, 3.73329930e-02f, -4.70701344e-02f,
  -2.40792781e-02f, 8.57533142e-03f, -2.61855647e-02f, 7.09462315e-02f, 4.41069007e-02f, -6.41562715e-02f, -4.81032059e-02f, 1.03512436e-01f, -5.63146621e-02f, 5.65797314e-02f,
  -1.76599354e-01f, 6.74914643e-02f, -1.52485475e-01f, 1.86924413e-02f, -4.54032384e-02f, 8.15264136e-02f, -1.82289705e-02f, 1.45885791e-03f, -1.41558364e-01f, -4.63401116e-02f,
  -1.86811760e-03f, -2.82474086e-02f, -6.81104884e-02f, 6.60682097e-02f, 3.51513065e-02f, 5.16530052e-02f, -8.65985826e-03f, -8.46791193e-02f, 7.28434697e-02f, 2.90962886e-02f,
  1.04845457e-01f, 2.41705570e-02f, -1.64233312e-01f, -1.10813878e-01f, 7.68924132e-02f, -1.26223117e-01f, -9.60982889e-02f, -6.78283423e-02f, -2.25530714e-02f, -1.83015257e-01f,
  4.36845869e-02f, 2.15868592e-01f, 9.43083595e-03f, -1.44072130e-01f, 2.63557956e-03f, -1.64173231e-01f, 3.02463740e-01f, 6.29740730e-02f, -1.44180268e-01f, 1.83797404e-01f,
  -8.57641920e-02f, -2.11220980e-01f, 7.84904808e-02f, -4.99551967e-02f, 1.44743189e-01f, 3.10693115e-01f, 1.75626069e-01f, 5.84341474e-02f, -1.67139605e-01f, -2.78053850e-01f,
  -1.53072566e-01f, 4.66810577e-02f, -7.27702379e-02f, -6.01887330e-02f, 5.98518103e-02f, -5.11193015e-02f, 1.79217398e-01f, 1.64218266e-02f, -7.57537559e-02f, 3.16095740e-01f,
  -1.07432874e-02f, 9.26955789e-03f, 1.16220266e-02f, -6.02252930e-02f, -3.42237912e-02f, 5.68552613e-02f, 1.28604658e-02f, -1.22423097e-03f, -1.01949880e-02f, 1.29082557e-02f,
  -6.40137792e-02f, -6.82390407e-02f, -5.03283069e-02f, -6.87888488e-02f, 4.43372037e-03f, 1.21227540e-02f, -3.86547088e-03f, 9.09800828e-02f, 9.65197757e-02f, -2.16265619e-02f,
  2.59424895e-02f, -9.80043486e-02f, 3.55542302e-02f, 1.04908263e-02f, 2.07489692e-02f, -1.65201008e-01f, 4.22837818e-03f, -4.11567725e-02f, 1.55379429e-01f, 1.08792722e-01f,
  4.19633556e-03f, 6.22271374e-03f, -1.93599623e-03f, 1.23295682e-02f, 2.68435832e-02f, 2.66623311e-02f, -1.90428202e-03f, 3.38840187e-02f, -3.43074873e-02f, 6.25462681e-02f,
  -3.28381569e-03f, 1.03669958e-02f, 1.90127417e-02f, 2.23108698e-02f, 7.45093042e-04f, -8.38307571e-03f, -8.97828862e-03f, 3.40363407e-03f, -4.60684933e-02f, 4.28141244e-02f,
  -1.09191146e-02f, -1.17421215e-02f, -3.71250249e-02f, 3.42989042e-02f, -9.03280743e-04f, -4.06226292e-02f, -6.32585958e-03f, -1.98637694e-02f, 3.08026616e-02f, -2.61462610e-02f,
  5.93313426e-02f, 4.47019786e-02f, 4.87454496e-02f, 5.86375259e-02f, -5.88539466e-02f, -1.11279152e-02f, -1.35833975e-02f, -1.24596413e-02f, -9.04022716e-03f, -3.52263264e-03f,
  -5.96094737e-03f, 7.05251917e-02f, 6.48754369e-03f, 1.81067623e-02f, 5.04769869e-02f, 2.77324370e-03f, -6.02339115e-03f, -2.35378742e-02f, -3.98967303e-02f, -1.70647204e-02f,
  4.32812162e-02f, 7.37563819e-02f, 5.84009141e-02f, 5.74551038e-02f, 7.01376125e-02f, 2.52824388e-02f, 5.72378114e-02f, 3.10404021e-02f, 1.51819915e-01f, 3.85481626e-01f,
  -6.49482906e-01f, 1.18648343e-01f, 2.57960558e-01f, -3.07616264e-01f, 3.00776184e-01f, 2.11987332e-01f, 3.81090850e-01f, 3.81489247e-02f, -1.28132895e-01f, 2.07440823e-01f,
  -1.78767163e-02f, -1.57065078e-04f, -7.11074993e-02f, -4.22074721e-04f, -2.76816823e-02f, 1.46315739e-01f, 1.10401452e-01f, -1.00738265e-01f, 7.02365041e-02f, -3.48125286e-02f,
  2.54753709e-01f, 8.96058325e-03f, -3.90383452e-01f, -1.30559549e-01f, -6.94995448e-02f, 1.18899323e-01f, 7.74478167e-02f, -1.50582850e-01f, -1.08581521e-01f, 1.46047652e-01f,
  -6.31856872e-03f, -1.72490284e-01f, 1.03252761e-01f, -7.22199753e-02f, -2.93220058e-02f, -5.23889512e-02f, 5.57907671e-03f, -2.41529308e-02f, 6.29707351e-02f, 5.82431024e-03f,
  3.60984504e-02f, 2.15536356e-02f, -3.95967960e-02f, 4.37784046e-02f, -4.24943417e-02f, -4.86343019e-02f, -2.72601889e-03f, -6.12361543e-02f, -3.27589102e-02f, -5.09034432e-02f,
  8.72343034e-02f, 2.08965782e-02f, -3.66437696e-02f, 1.04346827e-01f, -6.24110661e-02f, 8.21629241e-02f, -4.27145436e-02f, -1.50778204e-01f, -4.70388532e-02f, -2.58422289e-02f,
  2.32075360e-02f, -2.24434901e-02f, 3.76953855e-02f, -1.89442504e-02f, -5.05965611e-04f, -4.36469400e-03f, 1.29820984e-02f, 2.79051866e-02f, -4.56485637e-02f, -2.05136072e-02f,
  -1.72422230e-02f, 1.27912546e-02f, 1.40627641e-02f, -4.84667234e-02f, 1.13083338e-02f, 1.84100457e-02f, 2.91211959e-02f, -2.99551822e-02f, -3.29223536e-02f, -3.60276513e-02f,
  2.67705694e-02f, 7.74095859e-03f, 4.34207125e-03f, -1.81453582e-02f, 4.07113843e-02f, -4.66586053e-02f, 8.62324331e-03f, -5.68959750e-02f, 7.58827711e-03f, 2.88189054e-02f,
  1.97049826e-02f, 2.48220302e-02f, -4.38066870e-02f, 4.73992527e-02f, 1.27073366e-03f, 2.93416958e-02f, -9.70637705e-03f, -2.51654368e-02f, -1.69254728e-02f, 1.84732359e-02f,
  1.26250414e-02f, -4.55565788e-02f, 1.28816422e-02f, 6.54088240e-03f, 7.93092605e-03f, 4.85117882e-02f, -2.22023427e-02f, 5.18949367e-02f, 1.10319540e-01f, -1.19320368e-02f,
  -9.03437659e-03f, 4.54570912e-02f, 9.46803018e-02f, 3.36228088e-02f, 5.38489819e-02f, 1.38230938e-02f, 1.49755523e-01f, 1.85332850e-01f, 8.01077038e-02f, 1.33510903e-01f,
  6.24076843e-01f, 2.99376473e-02f, 4.54500355e-02f, 1.36461213e-01f, 1.59367546e-01f, -1.47153651e-02f, 1.88031510e-01f, -7.01105595e-02f, -3.07264980e-02f, 2.00027138e-01f,
  1.03216141e-01f, -4.56829276e-03f, -5.62276728e-02f, -1.08453661e-01f, -1.49710067e-02f, -6.92790886e-03f, 1.84790175e-02f, 3.47314738e-02f, 1.67324431e-02f, 7.89974779e-02f,
  8.18379521e-02f, 1.75783008e-01f, 7.72097334e-02f, -2.35176638e-01f, 8.92061368e-02f, -1.06334962e-01f, 2.13169947e-01f, 1.52070194e-01f, -5.76679818e-02f, 1.58963576e-01f,
  2.46707976e-01f, 1.29398018e-01f, -8.53668153e-02f, 6.36766627e-02f, 9.09203216e-02f, -9.72657055e-02f, -1.21061608e-01f, 2.87308283e-02f, -1.09111466e-01f, -5.24266660e-02f,
  6.25922829e-02f, -1.28894905e-02f, -5.62872998e-02f, -5.04074655e-02f, 4.41259332e-02f, -6.45940155e-02f, -3.75483162e-03f, -9.31945443e-03f, -2.50891391e-02f, 4.79615554e-02f,
  8.05400535e-02f, 7.00213090e-02f, -6.34339899e-02f, -1.09085329e-01f, -4.83088829e-02f, -3.91479209e-03f, -4.24399190e-02f, -1.01864830e-01f, -1.01378322e-01f, 2.31599715e-02f,
  1.60876252e-02f, -2.15398837e-02f, 6.00627549e-02f, -1.95222069e-02f, 5.92671195e-03f, 2.75873020e-02f, -1.40268384e-02f, 3.46801952e-02f, 2.67147981e-02f, 5.95411705e-03f,
  -1.91426033e-03f, 1.25237107e-02f, -3.38515863e-02f, -1.20810745e-02f, 2.40327921e-02f, 3.14608379e-03f, 5.65188611e-03f, 1.43946353e-02f, 2.95511149e-02f, -5.34079298e-02f,
  3.69382203e-02f, -3.27341706e-02f, 2.85669863e-02f, -1.76676717e-02f, -4.28459514e-03f, 3.70804826e-03f, 2.56093424e-02f, 7.89256883e-05f, -2.39241067e-02f, 2.60236394e-03f,
  -6.78130761e-02f, -8.95183533e-02f, 4.72511873e-02f, -8.99954587e-02f, 4.19012271e-02f, 1.53002990e-02f, 5.54693229e-02f, -2.78629512e-02f, -2.22305432e-02f, 2.48377696e-02f,
  -5.83330132e-02f, -2.75714844e-02f, 3.71670127e-02f, -1.10723944e-02f, 2.28171237e-02f, 4.73426990e-02f, 9.90254246e-03f, 2.95318607e-02f, -4.96801101e-02f, -6.30979538e-02f,
  1.30221061e-02f, -4.38116640e-02f, -5.31408079e-02f, -1.73234660e-02f, -2.53234198e-03f, 3.49006522e-03f, -9.58726630e-02f, -4.26644692e-03f, -9.53460559e-02f, -4.91847582e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.13381124e-01f, 2.66080320e-01f, 2.09711328e-01f, 6.57430813e-02f, 1.12252086e-01f, 1.91806585e-01f, 4.30986196e-01f, 1.55926898e-01f, -9.05700177e-02f, 6.21051155e-02f,
  2.22655475e-01f, -1.19291894e-01f, 3.34727056e-02f, -1.20029025e-01f, 2.18116850e-01f, 6.31046370e-02f, -2.08827510e-01f, -2.95725875e-02f, 7.33524039e-02f, 1.08053848e-01f,
  -1.90395281e-01f, -5.69040105e-02f, -2.17425381e-03f, -2.94642653e-02f, -9.39272121e-02f, -1.67562023e-01f, -5.48431091e-02f, 8.05675238e-02f, 6.19697012e-03f, -3.67251456e-01f,
  1.11772791e-01f, 2.47426465e-01f, -1.03948772e-01f, 1.16977273e-02f, 1.12709012e-02f, -8.41197744e-02f, 4.40856367e-02f, -9.32939351e-02f, -2.56502558e-03f, -1.72389357e-03f,
  1.71033069e-02f, -7.15713948e-02f, -4.16336209e-02f, 1.60308760e-02f, 3.15574147e-02f, 5.22150062e-02f, -1.62709951e-02f, 1.13074705e-01f, 1.75520051e-02f, 1.16999462e-01f,
  7.44972564e-03f, 1.01938009e-01f, 1.84898615e-01f, 6.38744906e-02f, 1.06080957e-01f, 2.74827573e-02f, 1.21838041e-01f, -3.15247593e-03f, 5.56781143e-02f, -2.09517449e-01f,
  -4.25405353e-02f, 2.44067307e-03f, -3.43562923e-02f, 2.61043645e-02f, -3.05924024e-02f, -8.75434279e-02f, 2.91501507e-02f, -4.41216640e-02f, -1.51319718e-02f, -6.75977841e-02f,
  3.86362486e-02f, -2.15798467e-02f, 4.53468673e-02f, -1.69461872e-02f, -2.45541171e-03f, 1.51604293e-02f, -1.24603976e-02f, 1.12490028e-01f, -9.53927636e-02f, -2.00714115e-02f,
  7.14782551e-02f, -3.65674011e-02f, 8.25517699e-02f, -2.35283133e-02f, -4.08759667e-03f, 3.04883569e-02f, -4.50214408e-02f, -1.88420396e-02f, -2.27328036e-02f, -2.09354088e-02f,
  -1.11882344e-01f, 1.96991622e-01f, -9.59195197e-02f, -4.42342237e-02f, 5.05316118e-03f, 2.42644195e-02f, -1.18125910e-02f, -1.69000831e-02f, 2.21838988e-02f, -1.30074453e-02f,
  8.88352692e-02f, -3.37929018e-02f, 1.06439129e-01f, 1.57355797e-02f, 1.37421275e-02f, -8.70759189e-02f, -3.77177224e-02f, -6.40086690e-03f, 5.77308387e-02f, -4.14205417e-02f,
  -3.68949883e-02f, -3.79610583e-02f, 4.70872298e-02f, -1.20313317e-02f, 1.22605506e-02f, -1.43800020e-01f, -7.06280321e-02f, 1.14609376e-02f, 7.40624890e-02f, -6.91666827e-02f,
  -3.01596075e-01f, -6.95060268e-02f, 1.08318642e-01f, 7.46659860e-02f, 2.76044589e-02f, -8.08476135e-02f, -1.35633960e-01f, 4.78757955e-02f, 1.28516495e-01f, -1.09828830e-01f,
  -2.66858220e-01f, -7.12950230e-02f, 7.64560029e-02f, 1.67543650e-01f, 1.18390821e-01f, 8.78126696e-02f, 2.51163781e-01f, 3.40725094e-01f, 2.47872531e-01f, -1.91595465e-01f,
  -2.09099930e-02f, 2.01430976e-01f, 1.23382457e-01f, 1.15529597e-01f, 3.89604867e-02f, -5.56326061e-02f, 1.24324955e-01f, -8.26994404e-02f, 2.51834728e-02f, 2.42675930e-01f,
  -2.24897906e-01f, -1.19255714e-01f, 1.63946718e-01f, -7.42890872e-03f, 7.96782151e-02f, -2.65535470e-02f, -5.44411726e-02f, 4.76080701e-02f, 4.96351831e-02f, -9.57647711e-03f,
  -2.36211848e-02f, -7.17105120e-02f, -4.36129533e-02f, 5.93361445e-02f, -3.67438272e-02f, -5.05611487e-02f, 1.09270237e-01f, 6.94598183e-02f, 9.30547044e-02f, -2.81736609e-02f,
  -8.74875784e-02f, -4.36589047e-02f, -2.44733952e-02f, 6.55612797e-02f, 2.77725253e-02f, 1.84779182e-01f, 5.85344471e-02f, -9.11574662e-02f, -8.57980922e-03f, -1.05538808e-01f,
  4.09870595e-03f, -2.92503536e-02f, 1.28293112e-02f, -4.01049154e-03f, 2.53784060e-02f, 9.84392688e-03f, 3.25047858e-02f, 8.02524853e-03f, 1.11606885e-02f, -2.61627026e-02f,
  6.50877133e-02f, -1.64028332e-02f, -4.76917289e-02f, -2.71056369e-02f, -1.67364068e-02f, 4.96025793e-02f, -1.31432125e-02f, 4.22686003e-02f, -1.50965096e-03f, 7.87139963e-03f,
  3.17868255e-02f, -2.10954677e-02f, 4.38113734e-02f, 2.92812344e-02f, 1.09651394e-03f, -6.19521039e-03f, -2.89370399e-02f, -1.00960303e-02f, -1.65837798e-02f, 9.66346543e-03f,
  3.15194242e-02f, 1.50140375e-01f, -1.83201745e-01f, 2.79840417e-02f, -5.28421700e-02f, 4.66136485e-02f, 9.55898780e-03f, -4.96139564e-02f, -3.99656668e-02f, -5.50971413e-03f,
  -2.94179376e-02f, 2.37433072e-02f, 5.09074852e-02f, 2.58167554e-02f, 2.08870936e-02f, 2.25964617e-02f, -5.03308438e-02f, 6.50059804e-02f, 4.78969552e-02f, -5.60740605e-02f,
  1.16034001e-02f, -5.75118922e-02f, -6.17018417e-02f, 3.43976617e-02f, -1.30801186e-01f, -1.03583187e-02f, -6.03948124e-02f, -8.26544017e-02f, -1.05281025e-02f, -1.50038719e-01f,
  4.77848738e-01f, -9.92934033e-02f, -3.66915166e-01f, 2.91389525e-01f, 4.75179888e-02f, 1.52526470e-02f, -4.62278305e-03f, 1.29544765e-01f, 1.72062680e-01f, -9.90292355e-02f,
  -1.00072868e-01f, -8.46231207e-02f, -1.37148038e-01f, -7.35170096e-02f, 2.95972992e-02f, -3.63298394e-02f, 6.10153982e-03f, 1.40876453e-02f, -7.43167773e-02f, 6.73874244e-02f,
  1.55078424e-02f, 3.64747457e-02f, 1.44094139e-01f, 1.77161805e-02f, -1.38535917e-01f, -1.43687144e-01f, -1.33629024e-01f, -1.07575841e-02f, -1.91374719e-01f, -1.85017154e-01f,
  -3.94765317e-01f, -7.25319386e-02f, 5.49357645e-02f, 4.02734727e-02f, -2.61426698e-02f, 6.04712777e-02f, 4.10169587e-02f, 2.78802514e-02f, 5.94125222e-03f, 2.65344903e-02f,
  -5.22843003e-02f, -1.69870388e-02f, 4.30638948e-03f, -7.96674043e-02f, -1.08143967e-02f, -3.17383162e-03f, -6.42786324e-02f, 2.29282361e-02f, 2.39475165e-03f, -9.76328626e-02f,
  -8.81673396e-02f, -6.35381117e-02f, -4.36585695e-02f, -9.69883874e-02f, -7.53249880e-03f, -9.70897079e-02f, -1.03169098e-01f, -1.37815148e-01f, -1.26144066e-01f, -7.40002319e-02f,
  -7.79680850e-04f, -5.98759763e-03f, 8.17520451e-03f, -1.85133759e-02f, 5.92379533e-02f, 3.38088498e-02f, -2.29366273e-02f, 5.75472834e-03f, 3.17514315e-02f, 8.68139206e-04f,
  -1.29141733e-01f, -7.33797299e-03f, -5.28109595e-02f, -3.87705937e-02f, -2.37811096e-02f, 6.60657650e-03f, -7.25875571e-02f, -2.35346686e-02f, -1.07654911e-02f, 2.02389974e-02f,
  7.05626188e-03f, -2.64872462e-02f, 4.77776909e-03f, -4.17472832e-02f, -3.68229346e-03f, -4.40662652e-02f, -3.78398113e-02f, -2.59512439e-02f, 5.42275049e-02f, 3.92738990e-02f,
  1.56505495e-01f, -1.16456551e-02f, 8.40941146e-02f, 1.39573654e-02f, 1.11972131e-02f, -8.29705445e-04f, 1.07305208e-02f, 1.24115741e-03f, 7.90560246e-02f, -9.44011658e-02f,
  -1.59244929e-02f, 1.30190169e-02f, -1.43552246e-02f, -6.98114932e-02f, 6.35767803e-02f, 8.78967866e-02f, 4.43663821e-02f, 2.17086691e-02f, 8.40797052e-02f, 3.42314020e-02f,
  1.34399319e-02f, 1.83273092e-01f, 1.61646500e-01f, 1.17798775e-01f, 1.06287420e-01f, 1.45241827e-01f, 6.64042234e-02f, 1.62352636e-01f, 1.12937257e-01f, 2.19195351e-01f,
  5.15449107e-01f, 5.10729700e-02f, -2.36620530e-01f, 3.41590010e-02f, -8.19936916e-02f, 4.98771714e-03f, -3.22009958e-02f, 6.57453313e-02f, 1.70592144e-02f, -1.35020074e-03f,
  1.52101189e-01f, 3.86407137e-01f, 3.17150146e-01f, 1.24086477e-01f, 3.08129698e-01f, -6.38533533e-02f, -2.13990137e-02f, 1.34606004e-01f, 2.02939417e-02f, 2.13190075e-02f,
  -9.24357623e-02f, -7.52857029e-02f, 4.22621779e-02f, 4.23771515e-02f, -2.89908260e-01f, 1.88082874e-01f, -8.04300979e-02f, -5.30827977e-02f, -1.22804984e-01f, -1.56922847e-01f,
  2.92390604e-02f, -1.93272941e-02f, 1.74928784e-01f, 1.33482084e-01f, -1.95212197e-02f, -3.45615260e-02f, -3.96246612e-02f, -1.72876436e-02f, -1.73934381e-02f, -3.10618803e-02f,
  8.44142362e-02f, 3.90507244e-02f, -1.89958811e-02f, -1.27580971e-01f, -2.97870860e-02f, -7.59487674e-02f, -1.76741883e-01f, 1.02127343e-01f, 1.46375559e-02f, -6.17438368e-02f,
  -1.32525131e-01f, -2.58387867e-02f, -6.33391365e-03f, -8.08293894e-02f, 3.52010131e-02f, 8.33731703e-03f, -3.23879384e-02f, -8.05981904e-02f, 1.49751902e-01f, 1.32659692e-02f,
  7.73446783e-02f, 1.70153193e-02f, 5.88279590e-02f, -1.22173643e-02f, 2.36599464e-02f, 2.06035357e-02f, -5.03158709e-03f, 6.44310340e-02f, -5.90371527e-02f, -2.35237516e-02f,
  8.76640081e-02f, -2.31821872e-02f, 1.94920283e-02f, 4.44454141e-02f, 5.80227794e-03f, -4.49549891e-02f, 1.16942981e-02f, -7.05160871e-02f, 3.92012335e-02f, -4.70584594e-02f,
  7.01942891e-02f, -2.22240835e-02f, -6.51288107e-02f, -8.75599459e-02f, -4.51771496e-03f, -4.55095433e-02f, 7.27104694e-02f, -1.37839504e-02f, 4.45393734e-02f, 2.30380930e-02f,
  8.66213366e-02f, 1.83141366e-01f, 4.62719947e-02f, 4.86556068e-02f, -4.14773077e-02f, -2.12728400e-02f, -1.65338360e-03f, 5.30997012e-03f, -7.95582905e-02f, 3.04483660e-02f,
  -4.93647344e-02f, 2.78451927e-02f, 2.00138744e-02f, 1.67801492e-02f, 9.53733474e-02f, 5.70678748e-02f, 8.48886967e-02f, 6.12875782e-02f, 9.69493762e-02f, -1.12432107e-01f,
  2.80745421e-02f, 7.13779032e-02f, 1.64723977e-01f, 1.69824764e-01f, 8.05597082e-02f, 2.22369969e-01f, 7.74583220e-02f, 3.34521644e-02f, 2.58896112e-01f, 1.61072448e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.01070281e-03f, 1.58858821e-01f, 2.02914312e-01f, 6.91530062e-03f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.68000013e-01f, 2.71024942e-01f, -2.58410215e-01f, -8.09165016e-02f, 6.07926734e-02f, 2.11122394e-01f, -2.01079309e-01f, -1.74512535e-01f, 1.75788045e-01f, -2.47783840e-01f,
  4.76967283e-02f, -1.54821843e-01f, 1.32933900e-01f, 1.19783744e-01f, 3.18378136e-02f, 7.57370815e-02f, -2.09899560e-01f, -1.37788564e-01f, 3.23092163e-01f, 9.55263004e-02f,
  2.52352599e-02f, 2.49704868e-01f, -2.90829778e-01f, 7.38144387e-03f, -4.12883818e-01f, 1.15536757e-01f, -1.77252948e-01f, 3.23359579e-01f, 4.12035525e-01f, -2.12975085e-01f,
  4.62879121e-01f, 3.82394284e-01f, 1.88059345e-01f, 4.30263281e-02f, 1.99067637e-01f, -2.44047448e-01f, 2.27821559e-01f, -2.55175769e-01f, 6.61505312e-02f, 2.72494078e-01f,
  1.73233643e-01f, -3.62520754e-01f, -1.02006328e+00f, 2.42837086e-01f, 3.02172780e-01f, -2.69853473e-01f, 2.48939648e-01f, 2.30214387e-01f, 6.39986172e-02f, 3.28138560e-01f,
  -5.92163503e-01f, -2.84818649e-01f, 2.67144162e-02f, 1.49107855e-02f, 2.13816449e-01f, -1.92025065e-01f, 2.82578230e-01f, -4.03446823e-01f, 1.32433400e-01f, -3.80072385e-01f,
  -3.07206124e-01f, 1.28687263e-01f, -3.48652303e-01f, 2.81235218e-01f, -1.23849208e-03f, -3.35870802e-01f, 6.82013258e-02f, -2.80768275e-02f, -5.45468509e-01f, 3.10233504e-01f,
  2.45680679e-02f, 4.93101150e-01f, -9.48959738e-02f, 4.25031483e-01f, 2.94940084e-01f, 2.71171361e-01f, 9.94046032e-02f, 2.15543613e-01f, 2.46067017e-01f, -2.77868450e-01f,
  -1.07001387e-01f, 9.01007652e-02f, -3.09896708e-01f, -3.38124901e-01f, 1.61351264e-01f, -3.75537246e-01f, 3.30820769e-01f, 2.38307506e-01f, -9.59328562e-02f, -1.35899216e-01f,
  -3.44237685e-01f, 4.01873589e-01f, 6.28541648e-01f, -3.82071771e-02f, -2.73831457e-01f, -2.86293268e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -2.12327372e-02f, 3.27475555e-02f, 3.54098558e-01f, 1.92696810e-01f, -9.60101411e-02f, 3.84547561e-01f, 3.03051472e-01f, 1.75746530e-01f, 1.19950715e-02f, -1.61632016e-01f,
  3.65140170e-01f, -2.74889231e-01f, -2.24641621e-01f, 4.56628442e-01f, -1.55449033e-01f, -1.16764158e-01f, 4.59715456e-01f, 4.91143018e-02f, -2.35597163e-01f, -2.71353453e-01f,
  -7.99513683e-02f, -1.93445623e-01f, -5.75331748e-01f, -2.41819888e-01f, 3.74778479e-01f, -4.18892086e-01f, -2.96453536e-01f, -4.31977183e-01f, 2.84394711e-01f, -2.33748883e-01f,
  2.82037139e-01f, 3.14165950e-01f, -1.08293496e-01f, -1.29628077e-01f, -2.01815534e-02f, 2.15676144e-01f, 9.72667038e-02f, 1.76999971e-01f, -1.11540228e-01f, 2.28289977e-01f,
  -1.46730006e-01f, 4.21540290e-02f, -3.16624641e-01f, -9.09758508e-02f, 4.48656082e-01f, -1.24038495e-01f, -2.24925756e-01f, 4.53731060e-01f, 2.98219502e-01f, 2.74462998e-01f,
  2.03279048e-01f, 3.13998103e-01f, -2.69493405e-02f, 8.73890705e-03f, 6.09787941e-01f, 9.67640057e-02f, -1.42702982e-01f, 4.48517548e-03f, -2.05781996e-01f, 3.48381209e-03f,
  -3.67068589e-01f, 4.51655716e-01f, -4.85524893e-01f, -2.49547869e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  1.18778504e-01f, 3.21563780e-01f, 5.70784546e-02f, 1.71445504e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -8.98015276e-02f, -2.99213622e-02f, 5.83229810e-02f, 1.22421607e-01f, 1.60984755e-01f, 3.21333438e-01f, -2.86006421e-01f, -2.47932076e-01f, -3.55644912e-01f, 3.93867701e-01f,
  2.82449037e-01f, -2.42106486e-02f, 1.69647440e-01f, -3.86657149e-01f, -2.83261061e-01f, 6.24405444e-01f, -3.25652331e-01f, -2.75705010e-02f, 3.64044085e-02f, -2.29990363e-01f,
  -8.57547075e-02f, -1.85144320e-01f, -2.00131223e-01f, 7.01565683e-01f, -4.26987149e-02f, -8.19179714e-01f, 6.35647357e-01f, 5.87050676e-01f, 1.85756087e-01f, -3.64295721e-01f,
  4.30374354e-01f, 1.43806145e-01f, -1.32008582e-01f, -1.62945464e-01f, -3.71969610e-01f, -1.68631554e-01f, 2.13043526e-01f, -5.79293013e-01f, -5.76017611e-02f, 7.34804571e-01f,
  -3.79864335e-01f, -6.50920331e-01f, 4.38724667e-01f, -3.55568647e-01f, -2.19076127e-01f, -2.35737085e-01f, -1.79913834e-01f, -5.48627138e-01f, -2.92241722e-01f, 1.19631596e-01f,
  2.05490172e-01f, 2.25625709e-01f, -3.15914631e-01f, 3.30401003e-01f, 8.61932114e-02f, -1.84124038e-01f, -9.60229039e-02f, -3.23945656e-02f, 2.12325364e-01f, -1.40088663e-01f,
  9.41684470e-02f, 4.28742826e-01f, 2.84268558e-01f, -5.91877364e-02f, -2.77641892e-01f, 2.13841379e-01f, -1.42736062e-01f, 1.06529281e-01f, 6.27785549e-02f, 1.17619000e-01f,
  2.65465707e-01f, -2.81910330e-01f, -8.01183105e-01f, 3.66884649e-01f, 2.12828159e-01f, -1.97169468e-01f, 1.26913071e-01f, 1.16557300e-01f, 9.04831737e-02f, 2.53724962e-01f,
  3.36205363e-02f, -1.50186755e-02f, 1.01988666e-01f, 2.31877416e-01f, 1.40683442e-01f, -4.45998870e-02f, 8.17651004e-02f, -1.35457635e-01f, 8.74706581e-02f, 3.17590714e-01f,
  -6.01563394e-01f, -1.17983706e-02f, 7.37161413e-02f, 6.15030289e-01f, -4.57163006e-02f, -8.28148127e-02f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  2.62590289e-01f, 6.89206347e-02f, 4.34512585e-01f, 3.69771540e-01f, 1.59743562e-01f, -5.01833186e-02f, -4.69453720e-04f, 1.68293744e-01f, 6.07672870e-01f, -5.34314811e-01f,
  -2.56021708e-01f, -1.92232892e-01f, -2.12735265e-01f, -1.61064863e-01f, 9.66340899e-02f, 2.38873690e-01f, 3.98347855e-01f, 3.59440923e-01f, 3.16231459e-01f, 3.50524396e-01f,
  4.21149909e-01f, -3.63025628e-03f, 1.63371395e-02f, -1.00516984e-02f, -8.56725216e-01f, -3.91497552e-01f, 1.33354917e-01f, -4.16536510e-01f, 6.26538217e-01f, -6.73537478e-02f,
  -2.20346391e-01f, 3.12415808e-01f, 4.37712222e-01f, 2.98693359e-01f, 9.96664092e-02f, 7.54007638e-01f, 3.92139375e-01f, 4.14272010e-01f, 3.55111182e-01f, -9.85544696e-02f,
  5.52248478e-01f, 3.81487221e-01f, -7.75259614e-01f, -9.90984142e-02f, -1.34494826e-01f, 6.60708666e-01f, 1.17695235e-01f, -1.04273774e-01f, 4.15489227e-01f, -8.51510391e-02f,
  2.79279977e-01f, -2.35003993e-01f, 2.12042749e-01f, 4.10431176e-01f, 1.81568667e-01f, -3.41586858e-01f, -3.95176709e-01f, 3.11705440e-01f, 2.99106687e-01f, -5.14997900e-01f,
  4.44325149e-01f, -1.69390693e-01f, -1.70342579e-01f, 1.68647438e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  4.50266838e-01f, 4.27544743e-01f, 2.70913780e-01f, 2.32510552e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  2.29990780e-01f, 4.35716748e-01f, 7.43282020e-01f, 4.01565313e-01f, 2.28424460e-01f, 3.36791366e-01f, -4.63348031e-01f, 3.15477490e-01f, 7.39681065e-01f, 3.01625878e-01f,
  -4.92675900e-01f, -7.15801120e-02f, 6.47996485e-01f, 2.11891562e-01f, -4.92451400e-01f, 2.70326305e-02f, 3.77780676e-01f, -1.70091629e-01f, -6.43672049e-02f, 2.30302766e-01f,
  3.62862885e-01f, 3.36225063e-01f, 3.09240550e-01f, 7.20383584e-01f, -4.93941069e-01f, -5.30924857e-01f, -4.11963105e-01f, -2.32274249e-01f, 3.85531813e-01f, -2.90680110e-01f,
  -5.36262035e-01f, -1.10513404e-01f, -2.06404760e-01f, -7.76313424e-01f, -3.29609782e-01f, 1.19093105e-01f, -5.23056351e-02f, -3.60196769e-01f, -4.79898810e-01f, 1.39660105e-01f,
  -2.88804829e-01f, 1.49469614e-01f, -2.80796528e-01f, 1.88812092e-01f, 2.18647737e-02f, -5.58094978e-01f, 3.16535830e-01f, -2.71443605e-01f, -2.19813079e-01f, 4.06416506e-01f,
  1.67201176e-01f, 5.86553290e-02f, -1.10851914e-01f, 3.41155797e-01f, 6.36480033e-01f, 3.70318115e-01f, -1.06250644e-01f, -1.11478783e-01f, 3.04452688e-01f, -1.43390670e-01f,
  5.63453995e-02f, 5.00325918e-01f, -5.99726021e-01f, 1.94986105e-01f, 2.08348468e-01f, 3.58212292e-01f, 3.81814122e-01f, -2.64360666e-01f, -2.03481223e-02f, -2.25809857e-01f,
  -5.39926231e-01f, 1.84811912e-02f, -1.20608136e-02f, -2.41130114e-01f, -4.50482331e-02f, 1.74470484e-01f, 1.01429641e-01f, -1.63857099e-02f, 6.69485688e-01f, -8.20284724e-01f,
  4.33411270e-01f, 1.03003196e-02f, -3.62185240e-01f, 1.22763962e-02f, 2.12829113e-01f, 2.06431933e-02f, 2.38695264e-01f, -4.29998755e-01f, -7.07502484e-01f, -8.70115533e-02f,
  -2.53415793e-01f, 1.81591623e-02f, 1.18651278e-02f, -3.44630688e-01f, 8.39270413e-01f, -3.35891932e-01f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  4.85843271e-02f, 6.35900646e-02f, -6.54538453e-01f, 2.51981527e-01f, 5.15429139e-01f, -1.11790672e-02f, 3.85693669e-01f, -2.67825246e-01f, -1.13801193e+00f, 1.80013731e-01f,
  -3.33337396e-01f, 6.17602527e-01f, 6.28203928e-01f, -3.19456011e-01f, 5.22901297e-01f, -3.35986912e-02f, -1.30009055e-01f, 2.03372508e-01f, 5.14821291e-01f, 3.28024089e-01f,
  1.25012577e-01f, 2.47978136e-01f, 4.47463125e-01f, 7.37942159e-01f, -2.52356172e-01f, 3.39697301e-01f, 3.01956862e-01f, -2.25406244e-01f, 3.90885100e-02f, 8.56202602e-01f,
  -4.92706388e-01f, 2.18544543e-01f, 4.05928046e-01f, -5.03311217e-01f, -4.02827740e-01f, 3.97231787e-01f, -8.49305186e-03f, 1.57840699e-01f, 6.26277089e-01f, -6.08794510e-01f,
  -4.69189227e-01f, 1.05466142e-01f, 5.42191684e-01f, 4.51505810e-01f, -3.72812033e-01f, 7.22289979e-01f, 1.38963848e-01f, 5.41412055e-01f, 4.36256379e-01f, 1.16260493e+00f,
  3.33087236e-01f, 2.61455700e-02f, 2.77887523e-01f, 2.65878141e-01f, 3.47884119e-01f, -7.35713124e-01f, 8.61485958e-01f, -1.77380145e-01f, -2.68476531e-02f, 5.14147103e-01f,
  2.65396416e-01f, 3.44369829e-01f, 2.04291105e-01f, -2.61443853e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  2.87305504e-01f, 1.65349737e-01f, 1.97939828e-01f, -8.67020190e-02f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -2.19255120e-01f, -1.84607759e-01f, -1.02471745e+00f, -4.56327289e-01f, -5.15039921e-01f, -1.99888259e-01f, -1.33642483e+00f, -4.63040560e-01f, 3.10858965e-01f, 3.32189113e-01f,
  2.19803244e-01f, -7.69987777e-02f, 7.68579304e-01f, -2.48151630e-01f, -1.21835597e-01f, -6.11715376e-01f, -1.30800337e-01f, -3.07341926e-02f, 7.67528787e-02f, -4.95121598e-01f,
  -6.67853951e-01f, -5.60241044e-01f, 7.98456907e-01f, -2.24840865e-01f, 1.00444221e+00f, -7.11158991e-01f, -3.01507884e-04f, 3.95437926e-01f, 8.64542246e-01f, -5.12062192e-01f,
  -9.72886324e-01f, 4.73286659e-02f, 1.48693895e+00f, -1.22157015e-01f, -4.23140347e-01f, -1.57384783e-01f, 1.95298404e-01f, 5.96907973e-01f, 1.46169379e-01f, -3.71305585e-01f,
  -2.86656678e-01f, 5.85667908e-01f, -7.95739353e-01f, 1.71905443e-01f, 1.99221224e-01f, -1.80760205e-01f, 3.81770611e-01f, 3.63549739e-01f, 2.21858114e-01f, 1.14019521e-01f,
  2.39103913e-01f, 4.47793633e-01f, 1.06512994e-01f, 5.07774428e-02f, -1.25056267e+00f, -4.24487650e-01f, 1.57745674e-01f, -5.56535661e-01f, -8.49518239e-01f, 7.07338333e-01f,
  6.41072774e-03f, -2.83743382e-01f, 9.28450346e-01f, -6.70292854e-01f, 9.64594781e-01f, 2.35123560e-01f, 3.12840313e-01f, -3.37289423e-01f, 1.25007614e-01f, -5.63544989e-01f,
  -1.10357738e+00f, -2.34584570e-01f, 7.99641728e-01f, -9.95701730e-01f, 4.40505326e-01f, -3.49621803e-01f, 4.31339025e-01f, -5.90183914e-01f, 5.73669374e-01f, 4.11575772e-02f,
  -5.80840051e-01f, 5.49859583e-01f, 5.16933501e-01f, 5.44036746e-01f, -4.82429653e-01f, 2.28923678e-01f, 5.74128749e-03f, -3.53684127e-01f, -5.09378016e-01f, -7.80845225e-01f,
  3.59861523e-01f, 4.47784632e-01f, 1.18514057e-02f, -2.74965405e-01f, -5.69992304e-01f, 9.84739184e-01f, -3.03079844e-01f, -6.12346292e-01f, 1.96612790e-01f, 9.30831768e-03f,
  3.51116866e-01f, 4.00695801e-01f, 1.03393221e+00f, 6.38242662e-01f, -4.21037883e-01f, 9.51855361e-01f, 1.56921923e-01f, 5.10629892e-01f, 3.82468164e-01f, 6.48690462e-01f,
  -1.54733345e-01f, -5.22096217e-01f, -6.69355989e-02f, -1.24141825e-02f, -4.76476461e-01f, -7.04977334e-01f, -6.51275158e-01f, -1.96406260e-01f, 3.90949905e-01f, -2.81525165e-01f,
  2.08751202e-01f, -3.26955229e-01f, -1.73361078e-01f, -7.24243164e-01f, -3.18991333e-01f, 6.58616841e-01f, 4.63019550e-01f, -5.84612668e-01f, -9.63514686e-01f, 3.64883840e-01f,
  -5.86000085e-01f, -1.52765304e-01f, -2.04668567e-02f, 2.17565969e-01f, -5.60922742e-01f, 9.39596593e-01f, -6.23034298e-01f, 1.05799615e+00f, -6.75225079e-01f, -7.59802818e-01f,
  -7.77021706e-01f, 6.45214677e-01f, -2.88174421e-01f, 9.23462808e-02f, 1.01162052e+00f, 6.80254102e-01f, 3.30352336e-01f, 7.07796693e-01f, 3.37663800e-01f, -6.03243530e-01f,
  6.21850252e-01f, 7.57369518e-01f, -7.32900739e-01f, 1.25636131e-01f, 2.32068643e-01f, 1.57150645e-02f, 6.66804373e-01f, -3.91245782e-01f, -1.13005407e-01f, 2.73233563e-01f,
  -7.32924283e-01f, 1.44134462e-01f, -6.02939725e-01f, -1.75993800e-01f, 4.54631269e-01f, 4.63352323e-01f, 6.89133942e-01f, -7.05085635e-01f, -4.56078127e-02f, 6.80675387e-01f,
  2.93396145e-01f, -2.92757750e-01f, -8.33169401e-01f, -1.02991639e-02f, 1.92561910e-01f, 8.66153538e-01f, -1.12161732e+00f, -4.44005370e-01f, 8.57192159e-01f, 9.79064047e-01f,
  5.87816477e-01f, 5.75779974e-01f, 2.55110115e-01f, 1.07193542e+00f, 3.02440524e-01f, -4.49833035e-01f, 5.27368486e-01f, 2.91445404e-02f, -2.67228514e-01f, -2.79884458e-01f,
  -4.89894807e-01f, -4.83707279e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.12627208e-01f, 2.88197905e-01f, -3.52836251e-01f, -7.18064904e-02f, -3.75229150e-01f, 3.92372906e-02f, -1.46107554e-01f, 1.05532862e-01f, 1.99856311e-01f, -2.88654149e-01f,
  -2.15923324e-01f, 4.99034554e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    