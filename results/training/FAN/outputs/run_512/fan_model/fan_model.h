/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.37434044e-01f, -2.14008734e-01f, -1.13374695e-01f, -2.15307817e-01f, 9.30832028e-02f, 1.85857162e-01f, 1.05841257e-01f, -2.21101999e-01f, -2.17912376e-01f, -8.04744586e-02f,
  3.73867117e-02f, -2.33785473e-02f, 2.18549613e-02f, 3.34065109e-02f, 6.66432157e-02f, 2.41208617e-02f, -9.93548185e-02f, 2.86834501e-02f, -3.58018577e-02f, -1.66532174e-01f,
  -1.30536765e-01f, 5.98082058e-02f, -8.58095959e-02f, 2.47101928e-03f, -4.83339056e-02f, -1.35841325e-01f, -6.15894906e-02f, 6.83415458e-02f, -9.49066319e-03f, 2.19515875e-01f,
  -5.24408370e-02f, -9.28277448e-02f, 2.97203381e-02f, -6.51483983e-02f, -6.06251396e-02f, -2.37593264e-03f, 6.77912384e-02f, 1.22798063e-01f, -1.68559738e-02f, -1.54630402e-02f,
  2.60540303e-02f, 1.85638219e-02f, 4.91496213e-02f, 7.55026639e-02f, -5.03611341e-02f, -2.86424514e-02f, 6.13167360e-02f, 4.89001274e-02f, -2.16293465e-02f, 8.10776725e-02f,
  1.83463003e-02f, 8.69231001e-02f, 9.53734946e-03f, 5.91476029e-03f, 8.96694697e-03f, 4.96496372e-02f, -1.33988596e-02f, 6.91806301e-02f, 5.06445020e-02f, 8.73103179e-03f,
  2.21251287e-02f, -2.33542565e-02f, -6.10460751e-02f, 7.74945132e-03f, -7.58983642e-02f, 2.06582062e-02f, 5.85859641e-02f, 3.09484024e-02f, 1.91371271e-03f, -1.06224455e-02f,
  -6.82018474e-02f, -3.91443539e-03f, -2.65234429e-02f, 3.74413421e-03f, 3.38533707e-02f, -5.44106364e-02f, -1.83908846e-02f, 6.55616587e-03f, -3.72710638e-02f, 2.01009959e-02f,
  -2.49411110e-02f, -5.96487038e-02f, -1.48478821e-02f, 3.18330759e-03f, 2.12689824e-02f, 2.53398865e-02f, 7.63872173e-03f, 9.60893929e-03f, 1.63963176e-02f, 4.08786200e-02f,
  -1.37909517e-01f, -3.31478059e-01f, -2.43751295e-02f, 9.04444382e-02f, 7.28155151e-02f, 4.89869714e-02f, -2.29421966e-02f, -1.42829660e-02f, 2.49286853e-02f, -5.88227287e-02f,
  -1.51822239e-03f, 2.46374663e-02f, -4.36409898e-02f, -3.62911704e-03f, 4.63077798e-02f, 2.84476578e-02f, -3.25596929e-02f, -6.29764348e-02f, 2.96988692e-02f, -2.27164552e-02f,
  -1.20862015e-02f, -5.42017408e-02f, 6.55766623e-03f, -3.75950187e-02f, 1.82630159e-02f, 3.56089883e-02f, -4.13389616e-02f, -1.25579983e-02f, 4.36434783e-02f, -2.09117681e-02f,
  8.51595625e-02f, 2.06137002e-01f, -1.57017931e-01f, 6.43658936e-02f, 1.23299651e-01f, -1.27710387e-01f, -1.10188961e-01f, 1.21254064e-01f, 2.72295065e-02f, 1.23431861e-01f,
  -8.44513252e-02f, 1.59266323e-01f, -1.33414924e-01f, 3.58905420e-02f, -3.79954338e-01f, -4.40710969e-02f, -9.48712677e-02f, 3.35272625e-02f, 1.01473384e-01f, 1.34367526e-01f,
  -1.53521383e-02f, -2.63911095e-02f, -1.04655772e-01f, 1.80794019e-02f, 1.00675263e-01f, 1.30859911e-01f, -7.56638944e-02f, -4.55160476e-02f, -1.38530489e-02f, 1.00447098e-03f,
  -2.26368438e-02f, 2.02600002e-01f, 3.97270806e-02f, 1.17649827e-02f, 1.68312469e-03f, -6.80943280e-02f, -7.81607926e-02f, -7.09507167e-02f, -1.00042060e-01f, -2.13513407e-03f,
  1.17026707e-02f, 6.95122033e-02f, 2.99227145e-03f, 7.10033774e-02f, 1.82155427e-02f, 5.12711704e-02f, 7.53679648e-02f, 2.87157614e-02f, 9.70878825e-02f, 3.73168401e-02f,
  1.43040698e-02f, 4.38827202e-02f, 3.73951234e-02f, 1.29217654e-02f, -5.39763160e-02f, 4.01626788e-02f, -7.57824406e-02f, -3.80648188e-02f, 3.71443853e-02f, 4.82849441e-02f,
  5.78162400e-03f, -1.86312869e-02f, -3.96323130e-02f, 1.00539595e-01f, 4.59056161e-03f, 2.42940504e-02f, 2.45859008e-02f, -3.77274863e-02f, -2.43966542e-02f, 7.72354379e-02f,
  6.62757549e-03f, 1.01610854e-01f, 3.63713242e-02f, 6.38468042e-02f, 1.58074144e-02f, 5.02098314e-02f, -5.35146520e-02f, 7.70735219e-02f, -2.16391757e-02f, 1.13206655e-02f,
  2.22094078e-02f, 2.26261709e-02f, 3.57386284e-02f, -1.33831557e-02f, 7.16623152e-04f, -5.51224425e-02f, 1.05448246e-01f, 4.40441407e-02f, -3.54295298e-02f, -6.27665892e-02f,
  1.29319236e-01f, -2.55138557e-02f, 8.15073252e-02f, 1.27575457e-01f, -1.59064420e-02f, 3.06482473e-03f, 2.01536436e-02f, 1.14487074e-01f, -7.94937648e-03f, 1.11972047e-02f,
  -7.38976225e-02f, 4.66598049e-02f, -7.87400547e-03f, 3.20854317e-03f, -3.51528674e-02f, -4.63329665e-02f, -1.01132482e-01f, -3.22674103e-02f, -3.07376459e-02f, 8.61857086e-02f,
  -3.63796279e-02f, -4.38412614e-02f, -1.09688677e-01f, 2.55736802e-02f, -7.35787228e-02f, -1.33722946e-02f, -7.29453517e-03f, 3.22366171e-02f, -2.68592965e-02f, -7.14793277e-04f,
  -2.95687199e-01f, 7.64418840e-02f, -4.61064018e-02f, -1.63016498e-01f, -2.17621431e-01f, -1.55143842e-01f, -2.85080820e-01f, 2.90356926e-03f, 4.31261770e-02f, 1.01455525e-02f,
  -3.25778825e-03f, 1.01287872e-01f, 8.50990415e-02f, -8.77691954e-02f, -1.94427237e-01f, 1.74597576e-01f, -1.28705487e-01f, 1.41665405e-02f, 5.90942204e-02f, -1.67659089e-01f,
  -1.12262107e-02f, -1.17648385e-01f, 2.24432647e-02f, -5.27013540e-02f, -1.03756398e-01f, 1.32030711e-01f, -3.60197462e-02f, -4.64275926e-02f, 4.99510057e-02f, -7.37739205e-02f,
  2.52994169e-02f, 1.15928479e-01f, 1.57602672e-02f, 1.25523861e-02f, -6.53022453e-02f, 1.69581324e-02f, -4.79735099e-02f, -3.30403517e-03f, -4.25152741e-02f, 2.42735464e-02f,
  -7.65907541e-02f, -1.29481638e-02f, -2.70184334e-02f, -7.23044761e-03f, 2.95803621e-02f, 3.98837365e-02f, -5.21823615e-02f, 3.95208821e-02f, -2.53950935e-02f, 6.25386760e-02f,
  -1.28115471e-02f, 3.88263129e-02f, 6.95136236e-03f, 5.70864789e-02f, 4.01711985e-02f, -8.11065082e-03f, 2.27244347e-02f, 1.41058099e-02f, -2.15602536e-02f, -2.33306829e-02f,
  -7.87905417e-03f, -2.86653973e-02f, -1.38944760e-03f, 9.51348543e-02f, -1.14084417e-02f, -3.25863138e-02f, 4.99318168e-02f, -2.04946529e-02f, 2.08720826e-02f, 4.99509610e-02f,
  1.17191635e-02f, 2.63359305e-03f, 1.13002975e-02f, -3.30540761e-02f, 3.40284407e-02f, -2.01972593e-02f, 3.82071882e-02f, 8.90923850e-03f, -4.79942970e-02f, 1.28969932e-02f,
  2.24768631e-02f, -6.00901283e-02f, 7.24597871e-02f, -2.17718538e-02f, 4.42054980e-02f, 2.16531288e-02f, 7.81208724e-02f, -1.30725023e-03f, -1.21927289e-02f, -5.33291027e-02f,
  -1.38645053e-01f, -1.24729618e-01f, 8.02068412e-03f, 8.66801850e-03f, 1.16804197e-01f, 4.60682847e-02f, -1.46780545e-02f, -2.57710740e-02f, -1.18121272e-02f, -4.73331250e-02f,
  -9.54677351e-03f, -5.88405579e-02f, -8.25330615e-02f, 6.29257783e-02f, 4.06208634e-02f, -3.97715531e-02f, -4.74340841e-02f, 3.83357378e-03f, -7.05814138e-02f, 4.39792238e-02f,
  -4.67459373e-02f, -1.90975133e-03f, 5.06336167e-02f, -8.85329694e-02f, -1.95376556e-02f, -8.63152817e-02f, 1.65780168e-02f, -2.70821247e-03f, 1.03958305e-02f, -2.25666352e-02f,
  1.91494018e-01f, -2.11064264e-01f, -1.78021312e-01f, 8.38351250e-02f, 1.14798091e-01f, 1.07572474e-01f, 2.01100826e-01f, 9.98162553e-02f, 4.69019003e-02f, -1.32230911e-02f,
  1.89217523e-01f, -9.43432450e-02f, -1.93667579e-02f, 2.65443921e-01f, 3.51803929e-01f, 6.81794286e-02f, 1.55098364e-01f, 1.17521718e-01f, -1.23724178e-03f, 8.96437466e-02f,
  8.65252092e-02f, 2.31894419e-01f, 8.30213949e-02f, -7.31636882e-02f, 2.44217217e-02f, -2.06241146e-01f, 7.60760829e-02f, -5.13440110e-02f, 1.34086283e-02f, 8.40024054e-02f,
  -7.40097696e-03f, -9.05359238e-02f, -4.65346985e-02f, -9.08870995e-02f, 1.96911283e-02f, -6.43269904e-03f, -6.23229630e-02f, 4.54529300e-02f, -8.28972366e-03f, 5.65030500e-02f,
  -8.33862871e-02f, -6.53800846e-04f, 2.09380332e-02f, -4.09146212e-02f, 4.76101134e-03f, 6.14902414e-02f, -2.11525075e-02f, -6.59709424e-02f, 7.89651945e-02f, 5.01037762e-02f,
  -2.38033719e-02f, -1.64366129e-03f, -1.56252850e-02f, -7.00336769e-02f, -2.12040879e-02f, 4.87945937e-02f, 5.39204851e-02f, 6.49814913e-03f, -4.44809236e-02f, 7.60541409e-02f,
  4.84881438e-02f, -5.43837920e-02f, 1.18284086e-02f, -2.59560738e-02f, 2.96862796e-02f, 3.25879008e-02f, 6.67923391e-02f, -4.01853509e-02f, 3.75945270e-02f, -5.03801368e-03f,
  6.50324076e-02f, 5.75731881e-02f, 1.67564750e-02f, 2.80715097e-02f, 5.79827316e-02f, 8.14668927e-03f, -4.71545802e-03f, 5.38896956e-03f, -2.88801007e-02f, -1.24186985e-02f,
  4.58245203e-02f, -3.53833809e-02f, -3.54903303e-02f, -4.72307466e-02f, 3.92260961e-02f, 6.98014395e-03f, 4.05121408e-02f, -8.98626808e-04f, -2.20393529e-03f, -1.97065827e-02f,
  7.08056465e-02f, -1.86697096e-02f, -1.24600949e-02f, 2.96236249e-03f, 2.37976620e-03f, -6.72945529e-02f, 4.46985401e-02f, -1.46054057e-02f, -3.68236490e-02f, 9.49876849e-03f,
  -4.39954549e-02f, 2.47583892e-02f, -6.88211694e-02f, 1.00297900e-02f, 4.28818464e-02f, -1.69676933e-02f, -1.64198317e-02f, 1.88050289e-02f, 3.77441011e-02f, -2.74551148e-03f,
  1.04593839e-02f, -1.52556701e-02f, -6.90242974e-03f, 1.60463955e-02f, 2.56665200e-02f, -7.63309933e-03f, -5.19838333e-02f, 1.63501240e-02f, 8.38292688e-02f, -4.73290980e-02f,
  -1.31479025e-01f, 1.52362347e-01f, 5.71052656e-02f, 1.89502031e-01f, -1.34689078e-01f, -2.14285851e-01f, -1.54065922e-01f, 5.62164709e-02f, -9.47661772e-02f, 8.81250575e-02f,
  2.18465533e-02f, 6.74107522e-02f, -1.55307865e-02f, 9.40352306e-02f, -1.44621417e-01f, -2.54876595e-02f, 4.32159752e-03f, 5.10252593e-03f, 3.36711183e-02f, 7.26205036e-02f,
  -4.54232618e-02f, 5.37117831e-02f, 1.99906185e-01f, 1.18557878e-01f, -2.57616043e-02f, 8.53491351e-02f, 2.12855622e-01f, 9.54970717e-03f, 1.85645521e-01f, -7.66094774e-02f,
  -1.12970196e-01f, -2.62515433e-03f, 3.69034372e-02f, 3.39415893e-02f, 1.82890669e-02f, 3.71380672e-02f, 1.17898658e-02f, -1.82254333e-02f, -3.59736793e-02f, 1.49179371e-02f,
  -3.19844671e-03f, 8.66681617e-03f, -1.27059342e-02f, -2.97465548e-02f, -5.69063462e-02f, 3.33552249e-02f, -2.98995599e-02f, -5.60712479e-02f, 4.44489531e-02f, 1.58607550e-02f,
  -8.02797824e-02f, 5.65724727e-03f, 7.72261713e-03f, 7.38052651e-02f, -7.98806734e-03f, 1.66569767e-03f, -3.08975931e-02f, 7.74405198e-04f, -4.48290892e-02f, 5.46883754e-02f,
  -2.12443955e-02f, -8.40854123e-02f, -3.47319357e-02f, 1.27664115e-02f, -2.48726383e-02f, -2.53770687e-03f, 3.33483741e-02f, -3.24270921e-03f, -2.28629750e-03f, 2.69530416e-02f,
  5.68358880e-03f, 6.44460320e-02f, -3.28457952e-02f, -7.95371905e-02f, -9.21375118e-03f, 1.08563695e-02f, -2.37924531e-02f, -1.35935945e-02f, 8.40495620e-03f, 3.76080759e-02f,
  -5.41752353e-02f, -2.32058372e-02f, 6.84744120e-02f, 2.71896422e-02f, 5.09465393e-03f, -2.19674781e-03f, 5.58503270e-02f, 3.72892395e-02f, -5.06616607e-02f, 8.26126244e-03f,
  9.13303569e-02f, 7.39181265e-02f, 5.25712110e-02f, -9.74003226e-02f, 2.03022584e-02f, 8.53777584e-03f, -7.80277187e-03f, 4.51462008e-02f, 3.36071029e-02f, -2.71751080e-02f,
  -2.68363822e-02f, -1.71006247e-02f, -3.18625830e-02f, -4.70616072e-02f, -1.45243444e-02f, -1.89828556e-02f, 1.50402710e-02f, 7.73681924e-02f, 3.33871081e-04f, 4.39006649e-02f,
  3.98407653e-02f, -7.71766007e-02f, -5.01146093e-02f, -5.94515465e-02f, 7.20216483e-02f, -5.78787699e-02f, -4.92258668e-02f, -3.39354388e-02f, 5.02784140e-02f, -1.83397233e-02f,
  1.70543879e-01f, 1.75517946e-02f, -1.41722485e-01f, 1.51734903e-01f, -2.94573773e-02f, -5.56781655e-03f, 2.48400327e-02f, 4.15987186e-02f, 2.34832894e-02f, -1.06245857e-02f,
  1.74865872e-01f, -5.62825762e-02f, -1.14416247e-02f, 1.81886211e-01f, -1.04997493e-01f, -3.66935357e-02f, 1.13016345e-01f, 1.29709572e-01f, -2.84697693e-02f, 1.08076734e-02f,
  4.89752144e-02f, 4.94542643e-02f, -3.03504169e-02f, 1.40849268e-02f, -8.62140395e-03f, 4.83084172e-02f, 1.06493041e-01f, -1.29376307e-01f, -1.73441991e-02f, -3.50999902e-03f,
  -5.84200621e-02f, 9.98660401e-02f, -3.44533648e-04f, -1.00866430e-01f, 8.78280103e-02f, 1.58590749e-02f, 3.31185423e-02f, -1.97364371e-02f, 4.68831621e-02f, 4.05256748e-02f,
  -1.12059250e-01f, 2.25427505e-02f, 1.20884937e-03f, -3.12708728e-02f, -3.80409807e-02f, -2.84343939e-02f, -6.96134716e-02f, 4.70829979e-02f, 8.22683144e-03f, -2.58626416e-02f,
  -5.09334654e-02f, -3.61003056e-02f, 1.50128119e-02f, 6.27388433e-02f, -9.09375306e-03f, 1.88442152e-02f, -1.11713372e-02f, -5.31460010e-02f, -1.69001780e-02f, 2.77845189e-02f,
  -6.45718649e-02f, 9.57083423e-03f, 7.78092891e-02f, -4.17411067e-02f, 4.35337657e-03f, 5.67845516e-02f, 3.93960774e-02f, -1.99611094e-02f, 2.07125908e-03f, 4.98692654e-02f,
  5.42224385e-02f, -1.27021065e-02f, -2.82231462e-03f, 7.39457905e-02f, 1.09533090e-02f, -9.42208897e-03f, 1.77451447e-02f, 3.85828875e-02f, -4.00365703e-02f, 5.90635696e-03f,
  9.10305139e-03f, -8.33765492e-02f, 2.43813824e-02f, 4.76144515e-02f, 6.82286322e-02f, 2.60807909e-02f, 2.25491598e-02f, 1.94032546e-02f, -6.73143007e-03f, -6.79714233e-02f,
  7.18770251e-02f, 1.11247435e-01f, -6.78057894e-02f, 4.08714935e-02f, 4.53963093e-02f, -9.10173059e-02f, -1.02666013e-01f, -6.67099729e-02f, 2.57137530e-02f, -7.91063979e-02f,
  5.02410382e-02f, 8.57492760e-02f, -7.07130060e-02f, 4.46849577e-02f, -4.80583422e-02f, 2.17235386e-02f, 3.34844291e-02f, -5.77271208e-02f, 4.75468114e-02f, -2.80973595e-03f,
  5.43340249e-03f, 1.25473710e-02f, 3.97406369e-02f, 1.33099183e-01f, -2.40583275e-03f, -3.69299985e-02f, -2.48974469e-02f, -7.76720867e-02f, 6.03599250e-02f, -2.22157296e-02f,
  3.61031055e-01f, -8.74671489e-02f, -8.13074708e-02f, 1.10007718e-01f, -1.80285983e-02f, -1.41825050e-01f, -9.66225341e-02f, -6.13016002e-02f, -1.51932299e-01f, -1.42332435e-01f,
  -4.08669971e-02f, 8.75644460e-02f, -8.40200856e-02f, 1.03364006e-01f, 2.07177131e-03f, -9.79162380e-03f, 7.15435371e-02f, 4.99271229e-02f, -1.09359594e-02f, 6.01262785e-02f,
  6.44416660e-02f, 5.69717027e-02f, 1.21734828e-01f, -7.51317963e-02f, 8.55661184e-02f, 6.41310215e-02f, 7.01211542e-02f, -9.67636630e-02f, -8.72224849e-03f, 1.41466095e-03f,
  1.67529240e-01f, 9.96542275e-02f, 4.87716310e-02f, 6.73456267e-02f, 1.06879715e-02f, 3.07947062e-02f, -2.38352399e-02f, 4.44355048e-02f, 1.11656683e-02f, -4.91029844e-02f,
  -1.51467873e-02f, 2.19106153e-02f, -1.30209420e-02f, -2.77500730e-02f, -6.14883658e-03f, -9.73943323e-02f, 8.16402212e-02f, -1.81147736e-02f, -9.56674367e-02f, 3.72080170e-02f,
  -2.63715126e-02f, -1.27464095e-02f, -6.90221041e-02f, 2.87107620e-02f, 2.69092619e-02f, 3.52788866e-02f, 4.87047434e-02f, 1.90485790e-02f, 2.98948027e-03f, -9.16481689e-02f,
  1.25527665e-01f, 4.88278903e-02f, 4.57140803e-02f, 5.07437531e-03f, -3.95158231e-02f, -1.70403149e-03f, 1.64425783e-02f, 2.85786893e-02f, -6.52601048e-02f, 4.42431383e-02f,
  -1.09519844e-03f, 6.62901020e-03f, 6.72786683e-02f, -5.72989322e-02f, 6.67824149e-02f, 3.95245403e-02f, 4.88874726e-02f, 6.29191026e-02f, -3.73487845e-02f, -4.13780175e-02f,
  -1.00236312e-02f, 2.82300077e-02f, 9.08611044e-02f, 5.54718636e-02f, -6.32394701e-02f, 7.53469467e-02f, 4.98151183e-02f, 7.38517717e-02f, 2.33830344e-02f, 5.93213271e-03f,
  5.57355322e-02f, 1.23860881e-01f, -2.48421915e-02f, -2.72755511e-02f, -3.28112952e-02f, -4.95935939e-02f, 1.19747914e-01f, -2.85465959e-02f, -1.38569966e-01f, 2.74574589e-02f,
  -2.90315822e-02f, 3.20836902e-02f, 2.61128638e-02f, -9.41099375e-02f, -1.40158281e-01f, 7.84539524e-03f, -3.45081352e-02f, -4.39328812e-02f, -4.84119281e-02f, -9.27604958e-02f,
  -4.35287096e-02f, -3.70467789e-02f, 4.34955247e-02f, 9.38941017e-02f, 6.44760057e-02f, -6.35100678e-02f, 6.13148995e-02f, -5.28841317e-02f, 7.47799221e-03f, -2.09840946e-02f,
  3.75387281e-01f, -1.22400172e-01f, -3.02721500e-01f, 7.34862387e-02f, 1.86111405e-01f, 5.10956682e-02f, -8.03762600e-02f, 2.01742589e-01f, 2.04566225e-01f, -4.21042964e-02f,
  -1.66725889e-02f, -2.21892506e-01f, -1.96800619e-01f, -4.23181728e-02f, -3.96679975e-02f, -9.11890715e-02f, 1.02394052e-01f, -4.20395322e-02f, -1.21713337e-02f, -4.48379740e-02f,
  1.23943433e-01f, 7.70684928e-02f, -1.55028984e-01f, 1.08961083e-01f, 3.14228162e-02f, -4.16074097e-02f, -1.07339233e-01f, -1.83758587e-01f, 4.29507643e-02f, -6.30326644e-02f,
  4.69388515e-02f, 5.75584844e-02f, 1.00567713e-02f, 1.30728865e-02f, 3.13192457e-02f, -4.01564650e-02f, -4.63592894e-02f, -1.34788156e-01f, -1.95695311e-02f, 2.90153027e-02f,
  2.25055870e-02f, -4.49071117e-02f, 3.57267559e-02f, -5.92450029e-04f, 5.84325232e-02f, -1.28253056e-02f, 4.48202379e-02f, 5.48074059e-02f, 2.21776720e-02f, -6.49440521e-03f,
  -6.73281625e-02f, -2.89944019e-02f, 3.55960242e-02f, -7.06523061e-02f, -1.63387787e-02f, -2.96260156e-02f, -4.53892797e-02f, -6.23972937e-02f, 2.31958423e-02f, 5.35526052e-02f,
  -4.78930101e-02f, 7.91086536e-03f, -1.67503469e-02f, 3.57724130e-02f, 3.25284898e-02f, 7.19598979e-02f, 7.25047104e-03f, 3.56419906e-02f, -1.48640061e-02f, 1.24065569e-02f,
  5.35987839e-02f, 1.21186022e-02f, -3.48635241e-02f, -9.02796350e-03f, -4.40272316e-02f, 8.59257281e-02f, -4.34718654e-02f, -4.12690230e-02f, -7.54582928e-03f, 3.87290157e-02f,
  -1.05843460e-02f, 2.02276986e-02f, -9.20785218e-02f, -3.95703726e-02f, -6.18622173e-03f, -1.32473512e-02f, -1.11225294e-02f, -6.88904151e-02f, 1.75597630e-02f, 6.40573632e-03f,
  -8.66468698e-02f, -1.30131394e-01f, 1.29769407e-02f, -1.44401211e-02f, -9.41018760e-02f, 2.21252218e-02f, 3.40493247e-02f, 7.05812797e-02f, -2.38509458e-02f, 2.79293340e-02f,
  -3.84927243e-02f, 5.98126426e-02f, -2.87245158e-02f, -6.39340058e-02f, -8.35361183e-02f, 1.78065225e-02f, -2.45870464e-02f, 2.93856859e-02f, -4.48531695e-02f, 1.66405104e-02f,
  2.36677527e-02f, 5.87187633e-02f, -8.53264891e-03f, 8.97217020e-02f, 7.98450634e-02f, -2.77443212e-02f, 1.77705269e-02f, -5.70281222e-02f, -9.16870460e-02f, -3.90502214e-02f,
  3.04463178e-01f, 1.31030023e-01f, 2.09980741e-01f, 1.12242848e-01f, 7.63400644e-02f, 8.14692378e-02f, 4.37657535e-02f, 1.66056193e-02f, 1.38715073e-01f, -1.99495584e-01f,
  -9.96828750e-02f, -5.21889608e-03f, -6.63959561e-03f, -2.11024910e-01f, 1.96053889e-02f, 8.17432553e-02f, -3.50313745e-02f, -9.26173851e-02f, 6.07935749e-02f, -4.19488102e-02f,
  4.37100753e-02f, -9.22331661e-02f, 2.12588385e-02f, -6.32946417e-02f, -4.88446243e-02f, 1.00281551e-01f, -9.04949307e-02f, 1.36613294e-01f, -1.77609727e-01f, -2.40665041e-02f,
  5.80902165e-03f, -1.51190870e-02f, -1.89785995e-02f, 2.55386606e-02f, 1.07646577e-01f, 7.90992305e-02f, -7.24777877e-02f, 8.82861018e-03f, 5.06414957e-02f, -4.34948914e-02f,
  4.22647186e-02f, -3.70089523e-02f, -5.46156839e-02f, 1.31165925e-02f, -1.28220832e-02f, 5.64434938e-02f, -4.84519452e-02f, -1.87545121e-02f, -4.82714437e-02f, 5.25925606e-02f,
  4.45243604e-02f, 2.62310766e-02f, -4.26690048e-03f, 1.19750276e-02f, 1.24059971e-02f, 9.93028507e-02f, -2.74800975e-02f, 1.97641272e-02f, 2.69654971e-02f, 2.13738792e-02f,
  1.97726022e-02f, 2.70572826e-02f, 4.56378646e-02f, -4.41664569e-02f, -4.53062728e-02f, -6.56951517e-02f, -2.81950068e-02f, -4.46726233e-02f, 8.69408026e-02f, -1.04127349e-02f,
  -2.37149280e-02f, -3.05211488e-02f, -2.13760529e-02f, 5.30733317e-02f, -5.58052063e-02f, -3.46798822e-02f, 3.78887132e-02f, -2.68520862e-02f, -5.53944185e-02f, -8.16140417e-03f,
  -8.19174126e-02f, -2.37050503e-02f, 4.87764589e-02f, -3.01633589e-02f, -1.14122014e-02f, -1.68710749e-03f, -1.58820283e-02f, 3.00850044e-03f, 4.36081961e-02f, -1.56086599e-02f,
  -4.06866111e-02f, 6.73955493e-03f, 2.02461537e-02f, -2.47943290e-02f, -4.64250110e-02f, -7.90474657e-03f, 7.24560469e-02f, 2.73811705e-02f, 6.12669177e-02f, 3.27145979e-02f,
  3.03692240e-02f, 6.22224212e-02f, -4.13953811e-02f, 2.10722163e-02f, 3.07117235e-02f, 1.66783556e-02f, -2.73298901e-02f, 2.72792205e-02f, 3.28668728e-02f, 9.57254097e-02f,
  3.83953052e-03f, -7.95568228e-02f, -1.56029891e-02f, -1.26657039e-02f, -1.78957302e-02f, -2.69983821e-02f, 5.04859537e-02f, 1.47083737e-02f, 3.99979809e-03f, -2.93444954e-02f,
  2.19574600e-01f, 1.60280883e-01f, 5.58697209e-02f, 2.42719814e-01f, -1.58681408e-01f, 5.44955209e-02f, 1.92229658e-01f, 9.47126523e-02f, 2.29801610e-01f, 1.33158386e-01f,
  5.34944162e-02f, -2.77368408e-02f, 1.84844568e-01f, 1.94294900e-01f, 1.26838535e-01f, 2.51284570e-01f, 2.92379737e-01f, 4.92046354e-03f, 1.19204685e-01f, 9.94854495e-02f,
  3.31910662e-02f, 9.23223123e-02f, 6.11380525e-02f, -8.99587572e-02f, 1.00131936e-01f, -9.01338160e-02f, -3.03131137e-02f, -1.00807808e-01f, 9.56818461e-03f, -1.09699413e-01f,
  -7.06685036e-02f, 2.76089702e-02f, -4.47066799e-02f, -1.02036238e-01f, -9.68056638e-03f, -6.71679825e-02f, -6.86767474e-02f, 2.21422762e-02f, -5.19086607e-02f, -3.54531570e-03f,
  -9.80381966e-02f, -5.31584285e-02f, -2.60561258e-02f, 2.91654188e-03f, 1.70237571e-02f, -1.92293487e-02f, 4.14513936e-03f, -2.40862239e-02f, -2.40477603e-02f, -2.90949270e-02f,
  2.47879643e-02f, -1.64810624e-02f, 4.54516336e-02f, 2.09723730e-02f, 1.26227206e-02f, 4.28627990e-02f, 4.02380042e-02f, -2.53133718e-02f, -2.75771394e-02f, 4.34775054e-02f,
  6.32927520e-03f, -1.98527775e-03f, 4.23684232e-02f, -1.99634656e-02f, 2.66556721e-02f, -6.19019791e-02f, 5.41955885e-03f, -7.78811872e-02f, 3.60390954e-02f, 3.39370556e-02f,
  -3.72204259e-02f, -1.57856643e-02f, 1.10240225e-02f, -2.51702871e-03f, -5.07002994e-02f, 2.41566002e-02f, -9.75855663e-02f, -3.26388068e-02f, 1.19629856e-02f, 2.03617546e-03f,
  -2.71577984e-02f, 2.38106307e-02f, -3.00947484e-02f, -2.22268738e-02f, -2.36360338e-02f, 1.35220299e-02f, 3.07194404e-02f, 1.33132990e-02f, 6.41897833e-03f, 3.48955803e-02f,
  1.19197518e-01f, 1.97936907e-01f, 7.42611140e-02f, 1.42468670e-02f, -5.19195646e-02f, -6.25216141e-02f, 5.55286780e-02f, 2.38853283e-02f, -3.37208547e-02f, -1.25599904e-02f,
  -5.16626686e-02f, 8.66460577e-02f, 3.29210912e-03f, -3.49647999e-02f, -7.76155619e-03f, 1.16055645e-01f, -4.20287587e-02f, -3.43516059e-02f, 1.43249994e-02f, 5.64720631e-02f,
  2.25342475e-02f, -4.15579490e-02f, -2.62138364e-03f, -5.15514798e-02f, -4.38838638e-02f, -4.88881432e-02f, -5.50511479e-03f, -2.80268621e-02f, 3.33491266e-02f, -2.30020601e-02f,
  1.99447602e-01f, -1.45510122e-01f, 2.56777983e-02f, -3.57955061e-02f, 3.15376669e-02f, -3.05151522e-01f, -2.22854301e-01f, -2.48713568e-02f, -2.30414718e-01f, -1.51183903e-01f,
  -3.85059342e-02f, -4.20061573e-02f, -6.91155642e-02f, 1.28380256e-02f, 1.59228574e-02f, -1.17681339e-01f, -1.22739725e-01f, -1.47624612e-01f, -5.35654090e-02f, 1.52083591e-01f,
  5.69361560e-02f, 8.49806443e-02f, 5.55753969e-02f, 6.55672550e-02f, -6.28358796e-02f, 4.73390780e-02f, 1.82272673e-01f, 4.59206775e-02f, 7.09302723e-02f, -1.03927642e-01f,
  8.88777226e-02f, 2.31420025e-02f, -6.06774762e-02f, -2.43094116e-02f, 6.24769330e-02f, -7.18076015e-03f, -3.03233479e-04f, -5.58517240e-02f, -5.15773930e-02f, -5.32370992e-02f,
  -1.28450915e-01f, -3.26894671e-02f, -8.78681839e-02f, -5.20589985e-02f, -1.09851189e-01f, 2.25573289e-03f, 3.46331745e-02f, 7.23524159e-03f, 8.14235881e-02f, -2.75296848e-02f,
  3.16837393e-02f, -7.55859911e-02f, -5.39573133e-02f, -6.58373684e-02f, -5.01849083e-03f, -6.33804277e-02f, 5.68872914e-02f, 1.74611360e-02f, 2.93587353e-02f, -4.81441505e-02f,
  1.81666377e-03f, -2.08179541e-02f, 6.01571575e-02f, 6.54345974e-02f, 3.75686213e-02f, 5.49990386e-02f, -2.60965563e-02f, 2.13769972e-02f, 1.32352218e-01f, -9.92384553e-03f,
  9.78004709e-02f, 1.76236161e-03f, 3.85187045e-02f, -4.91349259e-03f, 4.30821963e-02f, 2.69773770e-02f, 3.20299156e-02f, 2.15451494e-02f, 3.35360467e-02f, -1.99033483e-03f,
  6.34162277e-02f, -2.50178725e-02f, 1.51962908e-02f, -9.21936147e-03f, -5.90147227e-02f, -3.48949693e-02f, 1.02028595e-02f, -2.35806815e-02f, 5.57965506e-03f, -6.86532725e-03f,
  -7.39943562e-03f, 1.40079111e-01f, 5.86227402e-02f, -2.55711260e-03f, 4.78127114e-02f, 1.84465870e-02f, -4.53428254e-02f, -5.42308912e-02f, -5.87200187e-02f, 3.37935649e-02f,
  -1.89955682e-02f, 3.46106887e-02f, 3.70816626e-02f, -5.09649254e-02f, -2.69545577e-02f, -6.78498968e-02f, 5.92624843e-02f, -1.06296400e-02f, 3.28595825e-02f, 2.16173045e-02f,
  2.20004879e-02f, 9.39853713e-02f, 6.73489552e-03f, 1.17352247e-01f, -5.59066497e-02f, 4.42944542e-02f, -1.10806152e-02f, -1.26777003e-02f, -3.09318816e-03f, -1.86346821e-03f,
  -4.16215286e-02f, 2.28426322e-01f, 1.17890969e-01f, -7.55643249e-02f, -4.02187109e-02f, -3.65278453e-01f, -1.91166371e-01f, -2.70504504e-02f, 1.26564622e-01f, 1.01024173e-01f,
  -2.15293944e-01f, 2.37676978e-01f, 3.57299782e-02f, -1.46627948e-01f, -1.80800796e-01f, 8.04363117e-02f, -2.31816277e-01f, -8.92442614e-02f, 7.21284226e-02f, -7.51795340e-03f,
  -8.22208449e-02f, -2.45927498e-01f, -1.22539356e-01f, -7.43548013e-03f, 4.15053731e-03f, 7.26835355e-02f, -6.02021255e-02f, 6.19297698e-02f, -1.79751977e-01f, 1.51634309e-02f,
  -1.13753565e-01f, 1.48352176e-01f, 9.08636823e-02f, -5.49337752e-02f, -5.17202616e-02f, -7.08526298e-02f, -6.35522977e-02f, 3.55964713e-02f, -9.58546717e-03f, -4.76108529e-02f,
  -4.47134674e-02f, -6.85590282e-02f, 1.79611146e-02f, -1.34590408e-02f, 1.08297011e-02f, 5.51272333e-02f, 7.74520636e-02f, 3.65871862e-02f, 5.64234033e-02f, 6.07275628e-02f,
  4.60348241e-02f, -5.60378954e-02f, -2.20891498e-02f, 3.94412540e-02f, -5.87280542e-02f, -9.17627942e-03f, 1.36917187e-02f, 3.22876647e-02f, -2.92545976e-03f, 2.88590719e-03f,
  5.06114122e-03f, -2.30613519e-02f, -1.41997291e-02f, -1.05677489e-02f, -3.11626587e-02f, 2.15660147e-02f, -1.79197285e-02f, -3.17776911e-02f, 9.51765999e-02f, -4.56897132e-02f,
  -2.60178633e-02f, 7.34592676e-02f, 3.03118266e-02f, -3.40806916e-02f, -2.92027630e-02f, 2.18554717e-02f, -3.01218610e-02f, 1.07599674e-02f, -6.77750260e-03f, -6.15949072e-02f,
  8.73480216e-02f, -3.87774520e-02f, -2.29590908e-02f, -5.40684946e-02f, -8.28664973e-02f, 2.91783549e-02f, -7.83902407e-02f, 2.85568517e-02f, 3.41774374e-02f, -7.92979524e-02f,
  -3.11352429e-03f, -3.51880980e-03f, 5.86632341e-02f, 8.47606920e-03f, 5.39558679e-02f, -1.74440611e-02f, -2.30794344e-02f, -1.15964804e-02f, -1.14546288e-02f, 2.86697652e-02f,
  -4.48155925e-02f, -5.55518130e-03f, 8.47261772e-03f, -3.81557867e-02f, -7.90228248e-02f, -9.12052467e-02f, -2.03320570e-02f, 1.07218223e-02f, -6.72083199e-02f, -7.58433342e-02f,
  -2.07871590e-02f, 2.94118300e-02f, 1.30999042e-02f, -4.49964330e-02f, -3.82754430e-02f, -6.68759495e-02f, -4.03336063e-02f, -3.95587794e-02f, 1.22103840e-02f, -1.44042261e-02f,
  -5.83314896e-02f, 1.76040530e-01f, -6.98795617e-02f, -4.92362585e-03f, -4.33935188e-02f, 6.59043044e-02f, -4.60056625e-02f, 6.98850304e-02f, -1.58667669e-01f, 1.40814215e-01f,
  1.83233954e-02f, 3.69065925e-02f, 1.21125273e-01f, 4.77667898e-02f, 4.93521877e-02f, 5.22669218e-02f, 4.71143834e-02f, -1.30402297e-02f, -1.37823880e-01f, 2.63529960e-02f,
  -3.94432573e-03f, 3.70559506e-02f, 1.01637647e-01f, -3.61433998e-02f, -4.87526543e-02f, -4.89814579e-02f, 3.55523415e-02f, 5.72598428e-02f, 2.41113696e-02f, 7.73602305e-03f,
  1.90238327e-01f, 5.22375442e-02f, -3.33269499e-02f, 9.93117765e-02f, -9.51158756e-04f, 3.94246541e-02f, -1.30641749e-02f, -6.78952113e-02f, -5.94642609e-02f, -6.81471527e-02f,
  2.12859898e-03f, 4.06439304e-02f, -2.87401304e-02f, 2.88636889e-02f, 8.12612101e-02f, -8.52806792e-02f, -3.96136800e-03f, 4.92034592e-02f, -1.86884869e-02f, 9.99962166e-02f,
  4.32982296e-03f, 1.90028513e-03f, 5.95483705e-02f, 1.41014997e-02f, 6.68004528e-02f, -1.06891595e-01f, 2.31981389e-02f, 3.09631675e-02f, 4.75846417e-03f, 6.24284185e-02f,
  -5.98039962e-02f, -6.06023381e-03f, 5.61779644e-03f, 5.86591437e-02f, -3.88140045e-03f, -4.84927855e-02f, 7.34555498e-02f, 5.08727506e-02f, 5.04344404e-02f, 7.05188066e-02f,
  8.57140943e-02f, 2.07297411e-02f, -1.59830898e-02f, -7.16155842e-02f, -3.80504802e-02f, -5.79152741e-02f, -2.53235418e-02f, 3.45636136e-03f, 4.28389832e-02f, -2.63818912e-02f,
  -2.80879010e-02f, 1.48614505e-02f, 4.00744453e-02f, 7.06483275e-02f, 6.12116456e-02f, 1.07156299e-02f, 3.27165588e-03f, -2.14481503e-02f, -5.58347069e-02f, 1.10579999e-02f,
  2.92145699e-01f, 2.81213969e-01f, 7.76934298e-03f, -6.45581575e-04f, 3.09401695e-02f, 3.50057110e-02f, 3.49018574e-02f, 6.82637328e-03f, 1.83873735e-02f, -4.53980751e-02f,
  7.12514371e-02f, 2.35175174e-02f, -3.94512201e-03f, -7.15280650e-03f, -1.20002115e-02f, -5.23910113e-02f, 4.63205129e-02f, -9.66897584e-04f, 1.23782702e-01f, 1.93658043e-02f,
  7.96249881e-02f, 8.67353901e-02f, -6.00358332e-03f, 1.22318426e-02f, 4.55527343e-02f, 5.74317090e-02f, 6.39782324e-02f, -6.53090999e-02f, 3.40903969e-03f, 2.89890766e-02f,
  3.29785906e-02f, -2.16775462e-01f, 2.15104863e-01f, -1.11556016e-01f, 1.75875887e-01f, -1.32055089e-01f, 4.59120646e-02f, 3.48541141e-02f, -5.49211055e-02f, -2.65804648e-01f,
  -3.73211242e-02f, -7.96706975e-02f, 2.87682284e-02f, -1.70029789e-01f, 1.99423030e-01f, -7.09361956e-02f, 2.28372794e-02f, -1.02097869e-01f, 1.97004806e-02f, -9.71034169e-02f,
  6.83484897e-02f, -1.47809133e-01f, 2.12874725e-01f, -2.48717256e-02f, 1.12229988e-01f, 4.29260097e-02f, 1.73012409e-02f, 1.33238152e-01f, -9.83756930e-02f, 4.98171747e-02f,
  -1.47833943e-01f, -1.52948862e-02f, -5.04347831e-02f, -3.99662629e-02f, -1.39452359e-02f, 8.82909745e-02f, -6.61439151e-02f, 2.93804221e-02f, -1.00544868e-02f, 2.57233134e-03f,
  -4.09794692e-03f, 8.27817619e-02f, -4.41596508e-02f, 5.60107753e-02f, 1.03315217e-02f, 4.12187614e-02f, 4.25210558e-02f, -3.38795558e-02f, 2.64847353e-02f, 7.10172951e-02f,
  3.42054181e-02f, -2.58588623e-02f, -1.26673514e-02f, -2.65540332e-02f, 3.42104025e-02f, -6.46458790e-02f, -1.14663607e-02f, 2.93700453e-02f, -8.56165364e-02f, 1.78917460e-02f,
  4.08711024e-02f, 3.45575549e-02f, -3.89236137e-02f, 1.25021748e-02f, -5.54564595e-02f, 3.77865247e-02f, -8.34402516e-02f, -2.16818899e-02f, -4.04936261e-02f, -1.93039402e-02f,
  -2.07304750e-02f, -4.61400747e-02f, 6.52340287e-03f, 1.94647089e-02f, -3.99916358e-02f, -3.34266163e-02f, -7.04069883e-02f, -2.70267036e-02f, -4.32933774e-03f, 8.37501809e-02f,
  2.66895685e-02f, -6.78175390e-02f, 2.64993142e-02f, 1.37972711e-02f, 3.77591811e-02f, -4.90633829e-04f, -1.62012363e-03f, -1.07227853e-02f, -4.26178519e-03f, 1.15149073e-01f,
  -2.14820504e-01f, -2.19467893e-01f, 4.31391969e-03f, -1.39077708e-01f, -6.69062734e-02f, 1.52599225e-02f, -3.88446897e-02f, -7.14474125e-03f, -5.24790585e-02f, -4.71834838e-02f,
  -7.13172257e-02f, -9.93807167e-02f, 1.20898169e-02f, -5.04086949e-02f, -3.04137059e-02f, -7.60749402e-03f, -9.93851796e-02f, -5.66053465e-02f, -3.42908986e-02f, 1.28777139e-02f,
  2.92392876e-02f, 3.25470865e-02f, -2.53525339e-02f, -1.28014302e-02f, -6.41950518e-02f, 4.66373973e-02f, 3.88924144e-02f, -1.76241603e-02f, 1.06538221e-01f, -1.00565981e-02f,
  -2.51944780e-01f, 2.24545807e-01f, -2.58540630e-01f, 1.00050025e-01f, -3.36474963e-02f, 1.97498232e-01f, 1.46851158e-02f, -4.98256981e-02f, -1.43084124e-01f, 1.56651571e-01f,
  -1.04709297e-01f, 1.49604632e-02f, -2.47677621e-02f, 2.53847390e-01f, -1.91623449e-01f, -4.28606719e-02f, 1.08447172e-01f, 1.16382174e-01f, -8.97610281e-03f, 3.83974276e-02f,
  -1.13347299e-01f, 2.18565017e-01f, -1.56404868e-01f, 1.08135846e-02f, -5.11286929e-02f, -1.24893948e-01f, -6.03478998e-02f, -2.04527024e-02f, 6.84442967e-02f, 2.37338133e-02f,
  1.10010784e-02f, -8.42439458e-02f, -6.17156141e-02f, -4.51672971e-02f, -6.29323721e-02f, 4.85631227e-02f, 2.87152249e-02f, -4.24487144e-02f, -2.31260564e-02f, -1.99894980e-02f,
  -8.81025475e-03f, -7.05191270e-02f, -3.16091701e-02f, -2.45454814e-02f, -3.90041173e-02f, -7.76462853e-02f, 1.70575380e-02f, 4.65055294e-02f, 3.14246230e-02f, 3.20238546e-02f,
  -8.09274316e-02f, 4.26539443e-02f, -7.57979229e-02f, -6.71504959e-02f, -9.95279700e-02f, -1.24111036e-02f, 6.55282214e-02f, 1.32201621e-02f, 1.12825697e-02f, 1.94226168e-02f,
  -4.67397496e-02f, 3.53728305e-03f, 3.84179391e-02f, -2.12172996e-02f, 1.62439793e-02f, 1.23287523e-02f, -1.25889881e-02f, -2.26500928e-02f, -2.55745128e-02f, 2.60392241e-02f,
  -6.95988834e-02f, -3.59153450e-02f, 3.25133726e-02f, -1.79943200e-02f, 6.98625892e-02f, 4.02049348e-02f, 2.61037946e-02f, -1.12733021e-02f, -4.11936305e-02f, -1.30553301e-02f,
  1.57306921e-02f, 2.60962844e-02f, 5.19111007e-02f, 2.74029616e-02f, 5.57375513e-02f, -6.67965114e-02f, 2.54633580e-03f, -2.83633899e-02f, -2.03676452e-03f, -1.06224101e-02f,
  7.51232058e-02f, 1.43030837e-01f, -2.72731925e-03f, -1.79106593e-02f, -2.13648472e-02f, -1.24787055e-02f, -3.78899015e-02f, 1.00379400e-02f, -1.86007302e-02f, -4.04919237e-02f,
  -1.85762905e-02f, 3.74995396e-02f, 4.31694202e-02f, 1.62197668e-02f, 7.64433818e-04f, 1.14723407e-02f, -1.43689616e-02f, -8.87741987e-03f, -5.84579492e-03f, -2.60933638e-02f,
  9.68316942e-02f, -2.90381704e-02f, 2.88093928e-02f, -1.82719659e-02f, 9.23927948e-02f, 5.00761671e-04f, 5.19541800e-02f, -3.06080393e-02f, 3.40947174e-02f, -2.75946949e-02f,
  1.09204255e-01f, -3.47550780e-01f, 1.59151867e-01f, -1.48426950e-01f, 3.17380458e-01f, 8.55825692e-02f, 2.70495154e-02f, -1.76349934e-02f, -1.15228847e-01f, -2.29630604e-01f,
  -7.20344782e-02f, -1.19136900e-01f, -8.68640840e-02f, -2.96670943e-01f, 4.29517180e-02f, -1.40866473e-01f, -9.37124118e-02f, -1.00610368e-01f, -2.00869143e-03f, 2.30603553e-02f,
  -1.00821286e-01f, -6.65157214e-02f, -1.43666312e-01f, 7.14049414e-02f, -3.48463319e-02f, 1.03969254e-01f, -6.67238981e-02f, 1.43268093e-01f, -1.02092521e-02f, -4.45948541e-02f,
  6.91013113e-02f, -1.37593612e-01f, 3.63772153e-03f, -1.64259709e-02f, 5.47720045e-02f, 5.46291135e-02f, 7.78716896e-03f, 7.98678920e-02f, 5.94461821e-02f, 5.21390438e-02f,
  -6.95745647e-02f, -1.56699326e-02f, -4.73864228e-02f, 7.45076090e-02f, 3.56621817e-02f, 8.65852162e-02f, 2.34583374e-02f, 3.60712148e-02f, 1.03484159e-02f, 5.33365682e-02f,
  2.12226268e-02f, -3.61533649e-02f, 4.51280357e-05f, 2.87452084e-03f, 3.29353684e-03f, 1.62084196e-02f, 2.29275618e-02f, 2.27857381e-02f, -7.46371597e-02f, -6.12483732e-03f,
  3.83609571e-02f, -1.88379232e-02f, 6.15748279e-02f, 4.30256650e-02f, 6.87498078e-02f, 6.52977452e-02f, 5.53990267e-02f, -4.15001623e-02f, 3.66136618e-02f, 7.02002272e-03f,
  7.55089149e-02f, -5.30448593e-02f, -5.52122807e-03f, 1.69361364e-02f, -7.40654692e-02f, -2.13516541e-02f, 4.32577953e-02f, 1.97264608e-02f, -1.14714354e-01f, -7.73868486e-02f,
  3.27295717e-03f, -4.41386625e-02f, -5.35152555e-02f, 4.58187684e-02f, 2.06648149e-02f, 8.62424634e-03f, -4.10163067e-02f, -4.54283617e-02f, 2.76082847e-02f, -6.07970590e-03f,
  -7.46819898e-02f, -1.73624724e-01f, -1.28594905e-01f, 6.83630556e-02f, -1.05187781e-02f, -5.97934276e-02f, -2.63989624e-02f, -9.98364412e-04f, -6.20677732e-02f, -4.24882621e-02f,
  -1.54011429e-03f, 2.63158139e-02f, 3.09494380e-02f, -2.99549419e-02f, 5.06167533e-03f, -5.36760651e-02f, -5.03692254e-02f, -1.22189522e-01f, -9.64538008e-02f, 6.20320532e-03f,
  3.86611037e-02f, 6.26088381e-02f, -1.08310801e-03f, 8.56724684e-04f, -1.08286715e-03f, -2.62158327e-02f, 8.43938906e-03f, 1.17151394e-01f, 1.13902546e-01f, -5.75603731e-02f,
  2.86848217e-01f, 1.40015140e-01f, 1.52279466e-01f, 2.28406444e-01f, -8.35241079e-02f, 1.03255339e-01f, 1.08200431e-01f, 2.94203870e-02f, 2.70772010e-01f, -2.82582603e-02f,
  -1.66662291e-01f, 2.21045971e-01f, -6.40209392e-02f, 6.25801831e-03f, 9.01182294e-02f, -7.25619271e-02f, 1.14560544e-01f, 4.61275131e-02f, 1.90655757e-02f, 8.56517162e-03f,
  -4.55727652e-02f, -1.55364051e-01f, -1.16463318e-01f, -1.75679535e-01f, 6.42430186e-02f, 1.54376710e-02f, -2.38769770e-01f, -5.20066954e-02f, -8.78813937e-02f, -4.88180853e-02f,
  8.76643285e-02f, -2.98758950e-02f, 1.52286130e-03f, -2.89978292e-02f, -1.01013847e-01f, 2.09570099e-02f, -1.04096830e-02f, 1.84828117e-02f, -4.21665497e-02f, -8.93687550e-03f,
  5.17931171e-02f, 5.07667400e-02f, -1.00434646e-02f, 2.38092188e-02f, 8.52778703e-02f, 7.16746692e-03f, -2.99956203e-02f, -2.33970280e-03f, -2.19539627e-02f, -1.88538358e-02f,
  -1.55201228e-02f, 3.89772318e-02f, 8.45513213e-03f, 7.66638108e-03f, -5.19094393e-02f, 3.53595391e-02f, 2.64203381e-02f, -1.62365870e-03f, 2.02059541e-02f, 1.97607465e-02f,
  -4.87332232e-02f, 1.48256598e-02f, -4.80000302e-02f, -1.41850654e-02f, 1.09982565e-02f, -3.69049087e-02f, -7.21933395e-02f, -2.24612076e-02f, 2.64372751e-02f, -8.22567206e-04f,
  -3.25164548e-03f, -3.86855844e-03f, -5.12334891e-02f, 5.91115132e-02f, 7.98366964e-03f, 1.33396043e-02f, -3.29354964e-02f, 1.88575666e-02f, -2.22385209e-02f, -1.12145115e-03f,
  2.49310881e-02f, -1.29753714e-02f, -4.33066860e-02f, -4.22309563e-02f, 1.30742863e-02f, 1.90520383e-04f, 8.28917883e-03f, -1.82043090e-02f, 3.06453668e-02f, -3.29106152e-02f,
  -1.05439320e-01f, -2.44781058e-02f, -5.58841936e-02f, -1.00640655e-02f, 9.21586901e-02f, -2.40580738e-03f, 5.90248033e-02f, -4.58443388e-02f, 6.78282231e-02f, 3.64936665e-02f,
  -8.62150863e-02f, -1.73678715e-02f, 6.13009594e-02f, 5.40286163e-03f, 4.45348816e-03f, -1.12805553e-02f, -2.70225145e-02f, 1.16811534e-02f, -4.49063629e-02f, -5.43754436e-02f,
  -1.93180293e-02f, 2.79482882e-02f, 1.35061042e-02f, -6.72585815e-02f, -6.20992109e-03f, -8.75490606e-02f, 1.89310387e-02f, 3.82951647e-02f, -1.43393371e-02f, -1.63325574e-02f,
  -2.20086575e-01f, 1.14781201e-01f, -3.73605490e-02f, -1.12975918e-01f, 1.77905053e-01f, -1.06461607e-01f, -2.65461177e-01f, 8.71572495e-02f, 2.75036246e-02f, 3.29104774e-02f,
  1.30527262e-02f, 6.53047115e-02f, -1.34686008e-01f, 2.40660682e-02f, -3.25664192e-01f, -1.70094758e-01f, -2.44446680e-01f, -7.33410120e-02f, -3.59952673e-02f, -1.46430880e-01f,
  -1.33949474e-01f, -6.82729855e-02f, -2.46186197e-01f, 7.42091909e-02f, 1.71261039e-02f, -4.13723551e-02f, -8.93970206e-02f, -6.09119460e-02f, 2.16863807e-02f, 1.49115222e-02f,
  -2.48775687e-02f, 1.01991147e-01f, 8.40741917e-02f, 8.72926638e-02f, -1.56123757e-01f, -7.97839984e-02f, -6.64212480e-02f, -5.10895029e-02f, 7.55965244e-03f, -9.96280834e-02f,
  -2.32014526e-02f, -7.03873485e-02f, 7.88881779e-02f, -4.89300825e-02f, 1.08785197e-01f, 3.46827842e-02f, 7.11417422e-02f, -9.18782279e-02f, -6.94575207e-03f, 7.79319834e-03f,
  5.03176451e-02f, 3.96390036e-02f, 7.90516008e-03f, -8.02717544e-03f, 2.07711365e-02f, 1.10423684e-01f, 4.38296385e-02f, -2.64077168e-02f, 1.83631517e-02f, 4.95130196e-02f,
  -4.74170689e-03f, 6.18956611e-03f, 8.58406946e-02f, 3.15949433e-02f, -3.92705314e-02f, 2.12724246e-02f, -1.31865114e-03f, 4.59485874e-02f, 4.34171855e-02f, 4.51291353e-02f,
  -1.85518693e-02f, 8.41770992e-02f, -5.72991930e-03f, -4.10965793e-02f, -1.10289924e-01f, 2.92431284e-02f, -5.55373318e-02f, 3.00083775e-02f, 6.76485151e-02f, -5.48039451e-02f,
  -3.46630365e-02f, 5.75373881e-02f, -2.49121375e-02f, -2.59847920e-02f, 1.62864458e-02f, -7.00722188e-02f, 1.86133794e-02f, 4.55156304e-02f, -4.26918715e-02f, -8.31252858e-02f,
  -9.76664051e-02f, -1.06172144e-01f, -4.78234999e-02f, -1.71415452e-02f, -2.80718934e-02f, -2.28990074e-02f, -1.22940401e-02f, 6.87110946e-02f, -4.00463026e-03f, 1.35596283e-02f,
  5.61725646e-02f, 5.02332114e-02f, -5.80204129e-02f, -3.96195352e-02f, -4.86297384e-02f, 7.47331232e-02f, 2.61132699e-03f, -1.29480613e-02f, -7.75132747e-03f, 1.24081271e-02f,
  4.19039764e-02f, 1.19311465e-02f, 1.06500043e-02f, 5.78003116e-02f, 5.84575869e-02f, -8.00553430e-03f, 6.06906377e-02f, 4.31988016e-02f, -6.70636371e-02f, 3.47748809e-02f,
  -1.30678579e-01f, -9.60104465e-02f, 2.33206153e-01f, -5.63856773e-02f, 7.03552887e-02f, -1.36121213e-01f, -5.77954017e-02f, -8.48349407e-02f, -1.38670862e-01f, -1.26483604e-01f,
  -1.26079336e-01f, 1.29680917e-01f, -5.82792796e-02f, -3.17175508e-01f, -2.19511148e-02f, -1.89429447e-01f, -1.88838273e-01f, -2.00298801e-02f, 3.41528351e-03f, 7.86847025e-02f,
  4.57253978e-02f, -1.43361658e-01f, -1.23127420e-02f, 6.12534732e-02f, 2.83688381e-02f, 1.74623057e-01f, -7.53668509e-03f, 1.24590933e-01f, 1.00254931e-01f, 4.67319377e-02f,
  -6.87611476e-02f, -6.87129349e-02f, 5.33581376e-02f, -1.03744846e-02f, -4.27856250e-03f, 1.10629015e-03f, 5.41519970e-02f, 5.97994886e-02f, 5.15748970e-02f, 2.59393062e-02f,
  -5.63581511e-02f, -8.06004703e-02f, -1.40965655e-02f, -5.52647971e-02f, -9.86254588e-03f, -3.90181667e-03f, -2.93718167e-02f, 6.89452328e-03f, 5.89930592e-03f, -6.92409649e-02f,
  -5.09449430e-02f, 6.15368672e-02f, 2.60615014e-02f, -8.06011353e-03f, 1.79859903e-02f, 2.37927753e-02f, -1.23898974e-02f, 9.07152444e-02f, 1.99312046e-02f, -6.35202825e-02f,
  -1.32673293e-01f, 7.43973330e-02f, 5.01571894e-02f, -5.97662572e-03f, 9.10848826e-02f, 3.03560286e-04f, 4.76017036e-03f, 3.09765842e-02f, 5.32301888e-02f, -4.91616949e-02f,
  3.92377414e-02f, 1.50092542e-02f, -6.77588433e-02f, 1.71094462e-02f, -2.46597491e-02f, -1.11997351e-01f, 2.66069192e-02f, 1.92417745e-02f, 7.60063250e-03f, -1.37739340e-02f,
  -4.33516242e-02f, 5.01355715e-02f, 2.86486708e-02f, -2.13999636e-02f, -2.54066065e-02f, 4.21967208e-02f, -4.17445600e-02f, 1.70888137e-02f, 6.33411808e-03f, 6.87387437e-02f,
  -4.55925465e-02f, 3.55102904e-02f, 1.40149817e-02f, -7.26610096e-03f, 1.77317541e-02f, -7.77334347e-02f, -2.24016309e-02f, -2.16822121e-02f, -5.60746118e-02f, -2.63481047e-02f,
  4.30136919e-02f, 3.96886691e-02f, 8.88109431e-02f, -2.35748719e-02f, 9.58646927e-03f, -5.29367328e-02f, 3.65240984e-02f, 8.08026716e-02f, 6.72680810e-02f, 2.79681049e-02f,
  -1.22770304e-02f, -8.44251737e-02f, 6.53207004e-02f, -5.72118023e-03f, -3.35645527e-02f, 8.61793105e-03f, 2.84822993e-02f, -3.56242433e-03f, 4.01293859e-03f, -2.43871915e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.20866615e-01f, -1.75586268e-01f, 1.18729778e-01f, 2.66265213e-01f, 2.78462976e-01f, 1.01197653e-01f, 1.21875815e-01f, 8.85505527e-02f, 3.36705416e-01f, -8.29504952e-02f,
  1.97193995e-02f, -3.83457653e-02f, -9.28420126e-02f, -1.47191444e-02f, 7.53061995e-02f, -7.87194222e-02f, 8.27006474e-02f, 1.07709110e-01f, 1.43246084e-01f, 2.35548243e-02f,
  2.17198655e-01f, 1.11513764e-01f, -1.92748636e-01f, -1.24412932e-01f, 2.77878493e-02f, -1.96081609e-01f, -3.17611992e-01f, -9.03966725e-02f, -2.53144354e-01f, 4.54519205e-02f,
  1.02960542e-01f, 5.20347692e-02f, -7.04609156e-02f, -7.38901198e-02f, -1.64886098e-02f, -5.62466159e-02f, 1.27700667e-04f, -2.85351053e-02f, 1.28872931e-01f, -6.58239350e-02f,
  -6.74793050e-02f, -4.72412072e-02f, -8.50114319e-03f, 5.42908646e-02f, 1.20739825e-01f, -5.40560484e-02f, -1.58138685e-02f, 4.94316220e-02f, -6.91772550e-02f, 1.98062919e-02f,
  -7.21927136e-02f, -2.68190913e-03f, 2.42433809e-02f, -1.64884552e-01f, -3.97954248e-02f, -4.25779819e-02f, -1.04127459e-01f, -1.14686757e-01f, -5.71894050e-02f, 3.62616144e-02f,
  -4.89393696e-02f, 3.41758467e-02f, 9.06583574e-03f, 2.03035641e-02f, 1.67919360e-02f, 4.70586568e-02f, 6.65400997e-02f, -3.93525418e-03f, 3.73541787e-02f, -3.06222830e-02f,
  -5.72016202e-02f, 8.99474621e-02f, 5.67493737e-02f, -6.06119866e-03f, 1.41337976e-01f, 8.80022347e-02f, -7.30641708e-02f, -2.79614870e-02f, -1.52980688e-03f, 2.16494966e-02f,
  -1.05061335e-03f, 1.43073425e-02f, 3.09100952e-02f, 2.51174085e-02f, 5.32867722e-02f, 6.02559075e-02f, 2.04501227e-02f, 8.81674699e-03f, -2.91483123e-02f, 2.04385109e-02f,
  6.05115481e-02f, -3.93742770e-02f, 1.93083230e-02f, -3.38797905e-02f, -3.32149714e-02f, -2.97944550e-03f, 9.59477294e-03f, 4.02165726e-02f, -2.88949665e-02f, 1.15407951e-01f,
  -7.81958476e-02f, -3.06292493e-02f, 2.34128274e-02f, -5.46434037e-02f, 3.42063755e-02f, 2.14607716e-02f, -3.14246751e-02f, -9.73255113e-02f, -2.40870900e-02f, -1.04768813e-01f,
  -1.28670454e-01f, -7.40101859e-02f, 1.06638618e-01f, 4.66591213e-03f, -1.67811587e-02f, -1.21429870e-02f, 1.62618663e-02f, -9.38690156e-02f, 5.27070719e-04f, -6.43373206e-02f,
  -7.68610910e-02f, -1.09638028e-01f, -3.35937142e-01f, -5.99811040e-02f, 1.36008620e-01f, 1.38405591e-01f, -1.15894929e-01f, 5.95147274e-02f, -2.23153397e-01f, 2.46059299e-01f,
  1.23386264e-01f, -2.12315202e-01f, -2.45835647e-01f, 9.78961214e-02f, 3.87594551e-02f, -9.94794369e-02f, 1.50243372e-01f, 5.98736890e-02f, -1.07477471e-01f, 7.82276392e-02f,
  -1.27103999e-02f, 2.80864924e-01f, -1.15033656e-01f, 8.51850584e-02f, 4.42388142e-03f, -1.05857693e-01f, 1.63428977e-01f, -3.09904609e-02f, 1.74502686e-01f, -5.12521015e-03f,
  5.85492067e-02f, -4.08063792e-02f, 2.32546106e-02f, -6.23883381e-02f, -4.32082005e-02f, 1.16011478e-01f, 9.26610269e-03f, -7.64988661e-02f, 3.80602805e-03f, -1.13643669e-01f,
  -6.92262799e-02f, 2.17588022e-02f, -6.61076233e-02f, -1.07761562e-01f, -6.01374581e-02f, -3.49521600e-02f, -1.84074920e-02f, -2.03369651e-02f, -9.96778831e-02f, -7.49138147e-02f,
  -1.47705585e-01f, -3.52737755e-02f, 8.70930217e-03f, 3.71913351e-02f, -9.76017267e-02f, -5.39260544e-02f, -7.97882304e-02f, 1.70594063e-02f, -1.85380988e-02f, -6.56367019e-02f,
  -2.66115200e-02f, -7.16507027e-04f, -9.71397534e-02f, -6.28413036e-02f, -2.20419634e-02f, 1.60761699e-02f, 6.28243387e-02f, 4.18125615e-02f, -2.82725263e-02f, -5.79993017e-02f,
  -2.71174479e-02f, 3.55627090e-02f, 7.46391490e-02f, 3.56861874e-02f, -3.75241078e-02f, 2.40079947e-02f, -2.84208395e-02f, 4.60199378e-02f, -6.22024247e-03f, -2.10663234e-03f,
  2.19845101e-02f, -9.89349652e-03f, 7.00763240e-03f, 5.45849912e-02f, 1.06169835e-01f, -6.69831112e-02f, -2.13624556e-02f, -2.79749446e-02f, -4.30393353e-04f, -5.20798145e-03f,
  2.29314808e-02f, -6.42700270e-02f, -4.87525240e-02f, -4.66626361e-02f, -2.95984577e-02f, 1.35724276e-01f, 5.21658314e-03f, -1.27064645e-01f, -5.26226163e-02f, -8.08620825e-02f,
  1.17294975e-02f, 4.50408161e-02f, -2.84010754e-03f, -7.41880015e-02f, -9.28391442e-02f, -2.49216575e-02f, -2.06832048e-02f, 4.09981469e-03f, 7.22173527e-02f, 8.93179253e-02f,
  1.10176831e-01f, -6.19362630e-02f, 1.25347311e-02f, 1.75364583e-03f, 1.85365751e-02f, 2.95241624e-02f, 2.01402903e-02f, -8.23038742e-02f, 9.13697407e-02f, -1.02781929e-01f,
  5.27325645e-02f, -4.31257188e-02f, -1.64368838e-01f, -1.17447264e-01f, -1.55814011e-02f, 1.43775240e-01f, -3.02519556e-02f, -4.24120650e-02f, -2.33311653e-01f, 2.23728135e-01f,
  1.75057247e-01f, -1.50926188e-01f, 7.16136117e-03f, 1.65420160e-01f, -2.43157018e-02f, 2.74089146e-02f, 1.31477624e-01f, 1.11272246e-01f, -1.67105764e-01f, 1.20761931e-01f,
  -1.39808655e-01f, 2.49011651e-01f, -2.12211236e-01f, 1.57435060e-01f, 1.61252782e-01f, -5.73567525e-02f, 1.09524690e-01f, -1.45895779e-01f, 3.97191616e-03f, -4.79224604e-03f,
  1.10410966e-01f, -5.55819497e-02f, -8.24326500e-02f, -1.53031014e-02f, 1.75426323e-02f, 5.40639497e-02f, -1.13877421e-03f, -4.68369983e-02f, -8.00751597e-02f, -8.57309103e-02f,
  6.24137744e-02f, -4.17545028e-02f, 6.27819598e-02f, -3.46605703e-02f, 2.80123539e-02f, -1.20479852e-01f, -1.95692196e-01f, -6.72814697e-02f, -1.89725831e-01f, -2.64895167e-02f,
  -9.50881094e-02f, -1.72400773e-02f, 2.45577432e-02f, -5.82636893e-02f, -3.78736854e-02f, 2.17328109e-02f, -6.88902363e-02f, -1.22054638e-02f, 1.07451148e-01f, -6.11007735e-02f,
  9.88669395e-02f, -2.91021783e-02f, 4.74529713e-02f, -1.78496670e-02f, -1.29886121e-02f, 3.68378162e-02f, -2.54393350e-02f, 7.88234081e-03f, -1.19760506e-01f, 6.52856007e-02f,
  -2.66591050e-02f, -3.25842127e-02f, -4.50424030e-02f, 6.75337762e-02f, 2.03834996e-02f, 6.86394274e-02f, -2.73560658e-02f, 4.00663838e-02f, -8.26352686e-02f, -3.93659174e-02f,
  -2.70143915e-02f, -4.33510430e-02f, 5.89785632e-03f, 6.93529798e-03f, 7.66307861e-02f, -9.32813529e-03f, 8.66379812e-02f, -8.04947540e-02f, 1.07682357e-02f, -4.07968462e-02f,
  9.94675532e-02f, 7.27674887e-02f, 2.89422292e-02f, -9.21902955e-02f, 1.85290501e-02f, 5.98771088e-02f, 2.07081474e-02f, 9.32504088e-02f, -2.08209194e-02f, 8.04201886e-02f,
  1.10117234e-01f, -1.63649470e-01f, 1.13599680e-01f, -4.96452190e-02f, -6.85911328e-02f, 1.15025811e-01f, 1.18372120e-01f, -9.14378539e-02f, 4.76629212e-02f, -7.32286870e-02f,
  7.00984448e-02f, 3.08761559e-02f, -6.44731075e-02f, 2.98278984e-02f, -7.46191107e-03f, -2.62080412e-02f, -7.21597150e-02f, -8.03036094e-02f, 1.12680718e-01f, -1.02811502e-02f,
  -1.71888262e-01f, -1.16218723e-01f, -2.14193776e-01f, -6.23449236e-02f, -3.17795515e-01f, -1.64940402e-01f, 4.72490601e-02f, -2.59118408e-01f, 5.80541231e-02f, 2.95132786e-01f,
  7.42058530e-02f, -5.01645952e-02f, 1.67558402e-01f, -2.92133708e-02f, 5.50719313e-02f, 2.98024565e-01f, -6.35443851e-02f, 1.73347909e-02f, -2.00258285e-01f, -1.37201980e-01f,
  -2.32932158e-02f, -1.38143316e-01f, -1.40356617e-02f, -3.12243253e-01f, -2.77912915e-01f, -1.10503092e-01f, 1.46091551e-01f, -1.68753684e-01f, -1.12359226e-01f, -1.50277406e-01f,
  -3.23015660e-01f, -1.07597247e-01f, -8.83085057e-02f, 2.43559740e-02f, -8.24876353e-02f, -6.60065189e-02f, 1.90486461e-02f, -7.84666166e-02f, -2.97430120e-02f, -4.11114693e-02f,
  5.10890782e-02f, -8.24190900e-02f, 3.63872312e-02f, 3.07710283e-02f, -2.96423826e-02f, -6.98844120e-02f, -7.75308628e-03f, -2.69726347e-02f, 3.71370912e-02f, -2.36769989e-02f,
  -7.14785140e-03f, -4.02616449e-02f, -6.01474289e-03f, 4.23424207e-02f, -6.94727525e-02f, -2.26328019e-02f, 6.27429560e-02f, -9.70602315e-03f, -6.01832792e-02f, -1.09423026e-01f,
  1.32757649e-02f, 5.35715893e-02f, 4.98370044e-02f, -8.12344160e-03f, -2.84316894e-02f, -4.36323043e-03f, -2.85381880e-02f, 3.28544192e-02f, 1.02594737e-02f, 9.01342649e-03f,
  4.57154103e-02f, 1.36686526e-02f, -6.83648363e-02f, 9.52180102e-02f, -9.27980430e-03f, 9.70661566e-02f, 3.89542803e-02f, -5.64142279e-02f, -1.05735464e-02f, -8.41572285e-02f,
  -3.87354125e-03f, -1.57440212e-02f, -2.75627263e-02f, -1.85355486e-03f, -2.32204366e-02f, 2.23487578e-02f, -6.94315135e-02f, -2.16235109e-02f, 6.00160174e-02f, -6.96372986e-03f,
  -2.99987912e-01f, -2.13862091e-01f, 3.51134837e-02f, 6.55747280e-02f, 2.35141702e-02f, -4.08724621e-02f, -1.94020588e-02f, -8.68867151e-03f, -5.38574979e-02f, -2.37277686e-03f,
  -9.89830680e-03f, 3.60959098e-02f, -1.15257196e-01f, 2.12371089e-02f, 5.51647954e-02f, -1.26428837e-02f, 5.79055473e-02f, -9.54309851e-03f, -5.35376482e-02f, -1.38952538e-01f,
  3.37370187e-02f, 7.55298734e-02f, 9.49504897e-02f, 2.41331831e-02f, 9.37729236e-03f, 5.46949357e-02f, 3.13557312e-03f, 4.20931242e-02f, -1.12432934e-01f, -1.00105211e-01f,
  -1.18213199e-01f, 2.13417690e-02f, -1.03338249e-01f, -1.75678991e-02f, -2.95361015e-03f, -6.24022335e-02f, -1.21121950e-01f, 5.72242104e-02f, -2.31530927e-02f, 1.67099983e-01f,
  -8.30805674e-02f, -1.15361884e-01f, 2.56731529e-02f, -2.65494317e-01f, -3.70777935e-01f, -1.60785452e-01f, -2.11033329e-01f, -1.41497776e-01f, -9.23451260e-02f, 7.07554594e-02f,
  8.94448310e-02f, -1.47059858e-01f, -1.54317975e-01f, 6.42800406e-02f, 5.48035838e-02f, 2.28530213e-01f, 2.99525499e-01f, 2.23914027e-01f, 4.91677374e-02f, -3.63180786e-02f,
  -7.11390972e-02f, -1.34535981e-02f, 4.49563526e-02f, -1.05735682e-01f, 4.15919460e-02f, 1.07427806e-01f, 5.57313375e-02f, 4.07462828e-02f, -3.51047032e-02f, -1.61201861e-02f,
  1.02526180e-01f, 1.23418421e-02f, -5.04826419e-02f, -1.40946254e-01f, 1.05657302e-01f, -3.64955924e-02f, -6.48214668e-02f, -4.66753170e-02f, 9.74215716e-02f, 1.77903362e-02f,
  -6.16738223e-04f, 2.31524557e-02f, -2.12699343e-02f, -6.49423972e-02f, 4.11805287e-02f, -5.67475632e-02f, -3.40269841e-02f, 3.71469669e-02f, -1.60225166e-03f, 4.39991131e-02f,
  -4.55548279e-02f, -2.87772380e-02f, 1.49955479e-02f, -9.31712389e-02f, -1.91528406e-02f, 6.17428198e-02f, 2.26718169e-02f, 5.04917558e-03f, 7.87908211e-02f, -7.85522088e-02f,
  9.06717479e-02f, 2.72504501e-02f, -5.84526844e-02f, 8.57701153e-02f, 1.42384712e-02f, 3.36957425e-02f, 2.39997637e-02f, -1.11032873e-01f, -2.45347638e-02f, -3.83208394e-02f,
  -4.94639836e-02f, -4.34132926e-02f, 7.09162280e-02f, 8.89864042e-02f, -1.04010694e-01f, -3.24152671e-02f, -1.47784632e-02f, -1.25277825e-02f, 2.37333588e-02f, -1.34778759e-02f,
  -8.07190966e-03f, 7.32590333e-02f, 4.42698188e-02f, -1.60906054e-02f, 4.15694248e-03f, -1.25191500e-03f, -1.19127229e-01f, -3.74504291e-02f, -3.46863978e-02f, -4.71062735e-02f,
  1.14104830e-01f, 9.70546380e-02f, -5.31946160e-02f, -9.85410437e-03f, -4.73890081e-02f, -7.95375705e-02f, 6.07769899e-02f, -2.65142992e-02f, 2.39914339e-02f, -3.04431492e-03f,
  1.87692195e-01f, -6.63191602e-02f, 2.20988709e-02f, 4.16286662e-02f, 7.01443627e-02f, -2.78343856e-02f, 2.58837994e-02f, 6.88057989e-02f, 8.97800326e-02f, 2.95679066e-02f,
  -1.02026805e-01f, 2.14785919e-01f, -8.24752897e-02f, 1.05260864e-01f, 8.59046429e-02f, -1.25072077e-01f, -1.87574431e-01f, 9.24803913e-02f, -4.88957055e-02f, 1.28420778e-02f,
  1.13426931e-02f, -4.66591530e-02f, -5.50178885e-02f, -3.87702808e-02f, -1.40253440e-01f, -1.93359211e-01f, 1.75094515e-01f, -9.68013331e-02f, -8.34410116e-02f, 5.80461733e-02f,
  -5.97676300e-02f, 1.39987707e-01f, 4.92755398e-02f, 1.07749276e-01f, 1.15590163e-01f, 1.32991254e-01f, 3.57909918e-01f, -2.69741863e-02f, 1.47092044e-01f, -6.95951581e-02f,
  -9.97763574e-02f, -2.17789523e-02f, -4.38713953e-02f, -1.16369531e-01f, -1.81413570e-03f, -1.49786361e-02f, 4.31774464e-03f, 3.76558490e-02f, -4.12774682e-02f, 8.76774266e-02f,
  -1.17601976e-01f, 6.35129958e-02f, -4.84181456e-02f, 5.66535480e-02f, -1.69875305e-02f, -1.20807085e-02f, -7.28313401e-02f, 6.05356507e-03f, -1.17814548e-01f, 4.04281840e-02f,
  -4.22459841e-02f, 1.15631208e-01f, 1.43848322e-02f, -1.44658135e-02f, -4.86509353e-02f, -5.35057262e-02f, -3.13417576e-02f, -5.05919717e-02f, 3.87614258e-02f, 6.35311007e-02f,
  -4.94309291e-02f, 1.39556423e-01f, -5.21344952e-02f, -2.61282362e-02f, 8.44235271e-02f, -1.14533462e-01f, 6.99873865e-02f, 5.02250679e-02f, -7.36188423e-03f, -9.31635499e-02f,
  4.99376580e-02f, -3.69877666e-02f, -3.88256907e-02f, 5.43786809e-02f, -8.68494362e-02f, 1.17964685e-01f, 2.20442563e-02f, 3.33241671e-02f, -4.79916185e-02f, 5.71650490e-02f,
  -2.63491608e-02f, -2.95350254e-02f, 4.50906046e-02f, -6.95218844e-03f, -1.15598831e-02f, -2.80718748e-02f, 5.51910587e-02f, 3.34825590e-02f, -7.22954795e-02f, 4.39371839e-02f,
  7.93860853e-02f, 1.93615735e-01f, 6.45921305e-02f, -2.43298654e-02f, -9.83226150e-02f, -5.30391075e-02f, -2.18421947e-02f, -2.61739083e-02f, 1.06744103e-01f, 3.56701352e-02f,
  2.65226904e-02f, 5.26041575e-02f, 1.44624412e-01f, -6.97880089e-02f, 9.91914272e-02f, -2.71965768e-02f, 6.03378527e-02f, 7.00786188e-02f, 9.35511142e-02f, 2.05404870e-02f,
  3.41238752e-02f, 1.35854736e-01f, 4.80775833e-02f, -3.38619538e-02f, 1.46477828e-02f, 8.81292522e-02f, -1.83942541e-02f, -9.80238337e-03f, 1.00494899e-01f, -7.28553161e-02f,
  2.44814530e-01f, -1.34773552e-01f, 2.80339032e-01f, 6.99101165e-02f, 2.34907269e-01f, 2.36890569e-01f, 2.32988268e-01f, 1.66569754e-01f, 2.29594484e-01f, -2.40849897e-01f,
  -7.34981224e-02f, -1.92507818e-01f, 3.03886160e-02f, -3.90822925e-02f, 2.31570810e-01f, 4.81976829e-02f, 3.03048026e-02f, -9.52549800e-02f, 5.75255081e-02f, -6.53579533e-02f,
  9.90694296e-03f, -1.48853824e-01f, -1.09868675e-01f, -1.75421759e-01f, -4.10009101e-02f, -2.35772785e-02f, -1.93963051e-01f, 1.46759883e-01f, -1.64401725e-01f, 6.98557869e-02f,
  -8.69199261e-02f, 2.70565096e-02f, -4.28817570e-02f, -3.00743487e-02f, -4.63507064e-02f, -5.93941333e-03f, -2.95235887e-02f, -6.30265027e-02f, 1.63168937e-03f, -7.78840035e-02f,
  -8.76188427e-02f, 3.80319729e-02f, 6.50818180e-03f, -3.91091183e-02f, 4.36156876e-02f, -4.12225090e-02f, 9.43643227e-03f, 6.89627901e-02f, 8.58520046e-02f, -2.23334739e-03f,
  6.94091618e-03f, 4.16906811e-02f, 7.49831870e-02f, -1.26257628e-01f, 5.58645353e-02f, 1.89559422e-02f, -6.76176399e-02f, -1.18970163e-02f, -1.54062761e-02f, 3.00866198e-02f,
  -1.10591184e-02f, 1.40189648e-01f, -4.35885042e-02f, 6.00856496e-03f, -7.36818090e-02f, 4.72519025e-02f, -5.59284128e-02f, -1.11524686e-02f, 2.56227050e-02f, 7.47182965e-02f,
  -1.02344781e-01f, 1.67485755e-02f, 6.76702112e-02f, -5.96852675e-02f, -3.87219489e-02f, -5.55574223e-02f, 1.63282249e-02f, 6.77356217e-03f, 7.54480883e-02f, -2.79847868e-02f,
  -1.50352679e-02f, 2.61196829e-02f, 8.71613771e-02f, 1.29724508e-02f, 8.56167171e-03f, -7.45999254e-03f, -6.92558289e-02f, 8.75785500e-02f, 1.34859784e-02f, -4.03960645e-02f,
  -2.11494401e-01f, -2.13704258e-01f, -6.13972060e-02f, -1.49037108e-01f, -3.72566767e-02f, -1.32663231e-02f, 1.86031368e-02f, -3.78483231e-03f, 3.91023904e-02f, -2.69704647e-02f,
  -4.37697731e-02f, -2.88708899e-02f, -7.92572051e-02f, -1.55694559e-02f, -8.90271589e-02f, 3.77938594e-03f, -8.74538273e-02f, -3.30127887e-02f, -8.58303998e-03f, -7.44623244e-02f,
  1.00878244e-02f, -3.32703702e-02f, -4.12145741e-02f, -8.68560076e-02f, -8.40409622e-02f, -2.07024883e-03f, 5.52929342e-02f, 1.18924938e-02f, -6.69775307e-02f, 4.34755050e-02f,
  1.06421430e-02f, 1.30673945e-01f, 9.00999978e-02f, 3.84922810e-02f, -5.88153973e-02f, -8.45149532e-02f, -4.45551500e-02f, 2.86308099e-02f, -9.60438922e-02f, 3.52893248e-02f,
  -2.28628628e-02f, 1.42120928e-01f, 2.66015455e-02f, 1.44583182e-02f, -6.62142634e-02f, -1.88422397e-01f, -3.81093249e-02f, -7.12351352e-02f, -6.24311119e-02f, 1.98964640e-01f,
  -1.20598469e-02f, 8.51389468e-02f, -1.54464403e-02f, 8.12883005e-02f, 1.57475382e-01f, 1.64710492e-01f, 2.41896063e-01f, -1.66560039e-02f, 3.12030390e-02f, 1.64864808e-02f,
  -6.18329681e-02f, -7.65565559e-02f, 3.10084261e-02f, -8.95788372e-02f, 1.00395620e-01f, 1.09528393e-01f, 1.09459786e-02f, -9.94444564e-02f, -3.31125408e-02f, 2.11400390e-02f,
  -3.74368168e-02f, 3.36604193e-02f, -8.31394419e-02f, 4.69933152e-02f, 1.01590909e-01f, 5.83908819e-02f, 6.62240759e-02f, 1.63650718e-02f, 7.64295459e-02f, 4.02915739e-02f,
  7.36848712e-02f, -8.93245544e-03f, 2.93660676e-04f, 5.53820282e-02f, -1.00248251e-02f, 6.05866835e-02f, 1.38899401e-01f, 1.46283552e-01f, -3.57288606e-02f, 1.82575826e-02f,
  -1.11160286e-01f, 1.38578430e-01f, 4.37655672e-02f, -1.31259009e-01f, 1.09842181e-01f, -1.03117809e-01f, -6.05958179e-02f, -2.05964986e-02f, -8.57863650e-02f, 1.50274709e-01f,
  2.78627519e-02f, -8.95100459e-03f, -1.46798771e-02f, 1.10293694e-01f, 2.10703034e-02f, 8.52320120e-02f, -7.37468004e-02f, 8.04749876e-03f, 3.44232321e-02f, -5.56701161e-02f,
  -4.75554802e-02f, 6.13809144e-03f, 9.37090367e-02f, -7.73342773e-02f, -5.00891544e-02f, -1.80999711e-02f, -1.31644709e-02f, -1.87712982e-02f, -3.49014513e-02f, -4.11158092e-02f,
  1.13699198e-01f, 1.93517163e-01f, -7.65280426e-02f, 2.60429624e-02f, -3.53777967e-02f, 6.12027347e-02f, -6.37351647e-02f, -2.46738605e-02f, 3.59626785e-02f, 1.33696645e-01f,
  9.96179730e-02f, -4.23657000e-02f, -3.68580930e-02f, 7.47478008e-02f, 6.69881050e-03f, 8.12301263e-02f, 5.11077866e-02f, -2.23762989e-02f, 1.15157962e-01f, 4.25532460e-02f,
  1.55817285e-01f, 9.18542892e-02f, -9.55503155e-03f, -7.03336820e-02f, -6.96568042e-02f, 3.00285425e-02f, 5.00120558e-02f, 1.14406466e-01f, -1.66950151e-02f, 1.34925693e-02f,
  8.88240710e-02f, -2.61984646e-01f, -7.50404298e-02f, 1.23681866e-01f, 1.43868998e-01f, -4.54173386e-02f, 4.76223715e-02f, -1.33684471e-01f, -3.21455687e-01f, -1.69918403e-01f,
  3.08722258e-01f, 4.43197973e-02f, 4.47986647e-02f, 3.08383554e-02f, 3.14107686e-01f, 3.00275255e-02f, 9.82767120e-02f, 6.15871176e-02f, -1.93456095e-02f, 6.06745966e-02f,
  1.20252304e-01f, 1.28299460e-01f, 2.37355381e-01f, 1.38602734e-01f, 8.55520591e-02f, -3.91624495e-03f, 2.17893735e-01f, 1.05566919e-01f, 2.29897201e-01f, 2.10802361e-01f,
  -4.51384112e-02f, -4.47965711e-02f, -6.07125759e-02f, -9.54820812e-02f, 4.58775125e-02f, 5.72661087e-02f, 1.24463066e-03f, 1.21297259e-02f, -6.38258159e-02f, 2.52104979e-02f,
  -8.29425603e-02f, 9.34490189e-02f, 4.05949494e-03f, 6.31716028e-02f, -4.28574011e-02f, -7.32967630e-02f, -6.64167032e-02f, 7.16552138e-02f, -8.12957063e-02f, 5.52473217e-02f,
  5.22289313e-02f, -7.48976320e-03f, 1.54690128e-02f, 1.34256735e-01f, -2.64340155e-02f, 6.10797480e-02f, -6.54407730e-03f, 3.80323678e-02f, -4.20507602e-02f, -1.36131030e-02f,
  -7.64916986e-02f, -7.15859458e-02f, -1.68297235e-02f, 7.01189563e-02f, 6.53751520e-03f, 5.06612621e-02f, -6.44320101e-02f, 4.34118025e-02f, 4.43951925e-03f, 5.18260524e-02f,
  -6.40623155e-04f, 2.19982360e-02f, -4.70579639e-02f, -7.59201422e-02f, 6.65803030e-02f, -1.37964100e-01f, -1.83774494e-02f, 4.74744476e-02f, 8.98156688e-02f, -8.91756080e-03f,
  -6.04593381e-02f, 1.02561302e-01f, 8.02958533e-02f, -1.31483078e-01f, -6.62295148e-02f, 7.77478591e-02f, -4.53209504e-02f, -3.39566283e-02f, 7.77079165e-02f, -3.49172093e-02f,
  -4.42886092e-02f, -4.00970466e-02f, 1.07542165e-01f, -4.99802455e-02f, 6.26180246e-02f, 2.55560856e-02f, 1.59142222e-02f, -2.36039665e-02f, 1.29467890e-01f, 1.03018619e-03f,
  7.57452846e-02f, 3.07573695e-02f, -1.48888960e-01f, 2.22849920e-02f, -6.88105300e-02f, 1.02639459e-02f, 3.15248556e-02f, -1.02236345e-02f, 2.71860268e-02f, 6.23069070e-02f,
  9.09566209e-02f, -5.07080257e-02f, 2.53431685e-02f, 4.86013666e-02f, -1.80189416e-03f, -3.04166097e-02f, 2.37006433e-02f, -8.18758756e-02f, 4.22483422e-02f, -8.88111442e-03f,
  -6.44003630e-01f, 2.79500902e-01f, -9.24253091e-02f, -3.17356549e-02f, -1.32740602e-01f, 7.34933913e-02f, 1.60013095e-01f, -5.05161621e-02f, -1.39260635e-01f, 1.88706473e-01f,
  1.76506802e-01f, -3.38174313e-01f, 7.80087411e-02f, 2.63053149e-01f, -2.09937632e-01f, 2.99764752e-01f, 1.87863201e-01f, 5.97646534e-02f, 2.15701666e-02f, -5.59896864e-02f,
  8.95086117e-03f, 1.87645644e-01f, 1.73086017e-01f, 1.54286265e-01f, -7.24042431e-02f, -1.41266212e-01f, -4.85449359e-02f, -1.24511914e-02f, 9.91752967e-02f, -6.82967305e-02f,
  -2.26239800e-01f, -3.35282862e-01f, -1.59258977e-01f, -2.24976391e-01f, -8.18193406e-02f, -6.33693337e-02f, -3.48217264e-02f, -4.96906154e-02f, -3.20490859e-02f, -9.27998871e-02f,
  -7.15073273e-02f, 5.17243461e-04f, -6.50767982e-02f, 6.02959730e-02f, -7.95779824e-02f, -2.35820077e-02f, 6.25776127e-02f, 5.56810126e-02f, 1.18473675e-02f, -3.86999510e-02f,
  4.34784591e-02f, -5.41873053e-02f, 1.05861314e-02f, 2.02347469e-02f, 1.74960820e-03f, 3.87260914e-02f, 3.91271561e-02f, -2.49815825e-02f, -1.16483212e-01f, -1.44602591e-02f,
  1.37972832e-03f, 4.38009501e-02f, 1.32834380e-02f, 1.07018575e-02f, 2.93396134e-02f, 3.51510532e-02f, -1.88329704e-02f, -7.15055540e-02f, 1.02671541e-01f, 4.04033549e-02f,
  -6.44279048e-02f, -5.02722301e-02f, -8.78160596e-02f, 5.47530204e-02f, 5.42241111e-02f, 7.65723130e-03f, 2.20720861e-02f, -5.00679889e-04f, -9.81125887e-03f, -1.48661518e-02f,
  2.13198531e-02f, -4.45265882e-02f, 5.12474515e-02f, 2.83649452e-02f, -8.46916363e-02f, 2.45431438e-02f, -1.04499925e-02f, 1.96004286e-04f, 9.20753032e-02f, -2.63606347e-02f,
  -2.55598098e-01f, -3.26994717e-01f, 6.33757710e-02f, -6.49299398e-02f, -4.08869572e-02f, -1.38294948e-02f, -1.95044484e-02f, 8.81419983e-03f, -2.21830849e-02f, -8.03931952e-02f,
  -1.28148496e-01f, -1.74036752e-02f, -8.16121325e-02f, -3.27151082e-02f, 1.30024906e-02f, 1.26057506e-01f, 9.27843675e-02f, -8.85427520e-02f, 1.40493996e-02f, -3.10689565e-02f,
  2.31079888e-02f, -8.95365477e-02f, 8.01043659e-02f, 7.90758282e-02f, -1.20409485e-02f, 3.67833786e-02f, -1.44458666e-01f, -1.95045564e-02f, -7.70578310e-02f, 1.86670274e-02f,
  -3.62086087e-01f, 1.76756576e-01f, 1.46271616e-01f, -3.16123404e-02f, 2.75643133e-02f, 2.89708972e-01f, 2.33831063e-01f, 1.35242119e-01f, 1.96182787e-01f, 4.26476337e-02f,
  -1.26004979e-01f, 3.36014666e-02f, 1.63878873e-02f, -9.99479294e-02f, -1.39469206e-01f, 8.74302536e-02f, -5.90023547e-02f, 6.47293180e-02f, 4.26961370e-02f, 3.07022035e-02f,
  -4.21425290e-02f, -1.74106300e-01f, 5.90010285e-02f, 2.87853591e-02f, -3.12490594e-02f, 1.03116274e-01f, -2.14692131e-01f, 1.15490422e-01f, -1.67830825e-01f, 2.33551972e-02f,
  1.18776985e-01f, 3.89282741e-02f, -2.58888844e-02f, 8.88309255e-02f, 1.15839228e-01f, -6.45061070e-03f, 1.02109209e-01f, 6.55537024e-02f, 6.54154569e-02f, -1.46576427e-02f,
  -6.85021840e-03f, -5.26758796e-03f, -8.70144833e-03f, -4.76724431e-02f, 6.87368065e-02f, 6.74426928e-02f, 3.35601903e-02f, 1.25856446e-02f, 8.67700428e-02f, 6.59641027e-02f,
  -2.51339581e-02f, 2.01470200e-02f, 6.86207488e-02f, -4.55871178e-03f, 2.58768396e-03f, -2.97954269e-02f, 8.00438002e-02f, -8.30624327e-02f, -5.50533235e-02f, 8.25319737e-02f,
  -4.55442257e-02f, 1.15332521e-01f, 6.53188378e-02f, -9.68610402e-04f, -4.23675170e-03f, 1.60144866e-02f, 3.78404632e-02f, -3.50796133e-02f, 3.71133350e-02f, -1.01559617e-01f,
  -3.03493086e-02f, 4.90295738e-02f, 4.06544060e-02f, 1.85192283e-02f, 7.94149190e-02f, 1.85470097e-02f, 2.26031560e-02f, 9.83157679e-02f, 6.24225214e-02f, -6.06732406e-02f,
  4.88340631e-02f, -3.91478045e-03f, -9.61225033e-02f, 1.04428240e-04f, 6.96753263e-02f, 3.17972563e-02f, -2.03571152e-02f, -7.44261444e-02f, 3.60577670e-03f, -3.52710299e-02f,
  8.89168605e-02f, 2.64237434e-01f, 7.49999378e-03f, 2.70756185e-02f, 1.41879931e-01f, -8.56387690e-02f, 4.99963798e-02f, -6.95239529e-02f, 1.11913882e-01f, -3.61721553e-02f,
  5.36036827e-02f, 7.23839253e-02f, 2.59184688e-02f, -5.08243637e-03f, -1.13482006e-01f, 2.44193617e-02f, 1.20098896e-01f, -9.23797563e-02f, 1.29692042e-02f, -7.27911890e-02f,
  -1.57409072e-01f, 1.56167448e-01f, -9.74787027e-03f, 7.79276490e-02f, 2.04201080e-02f, 4.43880633e-02f, 4.56109643e-02f, -5.70047013e-02f, 6.94588944e-02f, 5.03496192e-02f,
  -1.14696138e-01f, 2.69494243e-02f, -2.17092797e-01f, -2.84169555e-01f, 1.11607298e-01f, 1.20920882e-01f, 4.14872579e-02f, 5.47632724e-02f, -1.82821959e-01f, 1.98711723e-01f,
  7.08879456e-02f, -1.59998477e-01f, -1.35895938e-01f, -5.45821115e-02f, -2.45275274e-01f, -2.04827949e-01f, -6.03746660e-02f, -5.27908560e-03f, -1.20535120e-01f, 6.68755174e-02f,
  5.55999903e-03f, -1.48670822e-02f, -1.80394024e-01f, 6.43349513e-02f, 2.29261275e-02f, 2.64745913e-02f, 2.12877557e-01f, 8.76450390e-02f, -3.45679410e-02f, -3.76161970e-02f,
  -1.72362127e-03f, -8.53067636e-02f, -7.86892250e-02f, 1.21997688e-02f, 1.21169731e-01f, 8.90727714e-03f, 1.18630715e-01f, -1.13425143e-01f, -9.12072584e-02f, -1.55414985e-02f,
  2.72385813e-02f, -2.10807025e-02f, -2.82448065e-02f, -7.25757629e-02f, 1.25098631e-01f, 3.11467685e-02f, -1.24601834e-02f, -8.58030990e-02f, 4.30814624e-02f, 2.48985160e-02f,
  -8.95280316e-02f, -6.42622933e-02f, 1.82367023e-02f, -1.63177222e-01f, -6.86028153e-02f, 2.18532961e-02f, -1.17674684e-02f, -1.98677145e-02f, -1.29622435e-02f, 1.64012983e-02f,
  -3.12151387e-02f, 2.06750464e-02f, 1.58534441e-02f, 1.94430482e-02f, -5.68056665e-02f, -6.25131354e-02f, -6.93212226e-02f, -9.52552818e-03f, 4.21591587e-02f, -9.09004062e-02f,
  9.97750927e-03f, 2.31570452e-02f, 9.18923765e-02f, 9.27442983e-02f, 3.33667360e-02f, -6.35395646e-02f, 4.47141454e-02f, -5.86420000e-02f, -9.26337391e-02f, 4.77230921e-03f,
  -4.85710353e-02f, -4.82479408e-02f, -1.03979141e-01f, -1.33327506e-02f, -3.26167196e-02f, 8.70488770e-03f, -5.40937483e-02f, -3.48878130e-02f, 5.17900754e-03f, 1.77243408e-02f,
  1.40528351e-01f, 1.02108419e-02f, -8.19975585e-02f, -3.83142903e-02f, 6.23584762e-02f, 1.40283862e-02f, 4.98378426e-02f, -5.98521940e-02f, -3.43724526e-02f, 1.31502703e-01f,
  5.53480163e-02f, 1.10595055e-01f, 8.51493850e-02f, 2.18747202e-02f, 4.77428772e-02f, 6.45063743e-02f, -6.21605441e-02f, 5.87366186e-02f, 4.37739156e-02f, -3.43379863e-02f,
  4.87722009e-02f, -8.15400039e-04f, -5.49455434e-02f, -4.76355627e-02f, -1.54144000e-02f, 1.15530550e-01f, 1.18665993e-01f, 5.18283546e-02f, 4.06534635e-02f, -4.60189246e-02f,
  1.64225608e-01f, -7.05362931e-02f, -3.03718209e-01f, -1.04276547e-02f, 1.73497573e-01f, 1.09528437e-01f, -8.50469992e-02f, 3.73943113e-02f, -2.03471601e-01f, 3.32171805e-02f,
  9.70783010e-02f, -1.29211918e-01f, -1.80983976e-01f, 2.86254063e-02f, 3.17650549e-02f, -2.37032667e-01f, 8.36941451e-02f, -3.23149934e-03f, -3.05825714e-02f, 1.36696398e-01f,
  -4.96231839e-02f, 3.11766624e-01f, -7.49682933e-02f, 1.51790142e-01f, 6.70244843e-02f, -5.65141253e-02f, 1.34324014e-01f, -1.88428944e-03f, 2.22333565e-01f, -8.56938772e-03f,
  3.06016188e-02f, -6.23412393e-02f, 4.05828729e-02f, -2.14938298e-02f, 8.51047039e-02f, 9.05990750e-02f, 7.83909038e-02f, -7.17544481e-02f, 4.10821696e-04f, -9.73305702e-02f,
  4.75924313e-02f, -5.68596087e-03f, 6.45764470e-02f, 1.29520325e-02f, 2.78635602e-02f, 1.14308566e-01f, 9.18437727e-03f, -6.36707619e-02f, -1.68406919e-01f, -4.36430909e-02f,
  -9.04361084e-02f, -9.23390687e-02f, -8.88876542e-02f, -1.16170244e-02f, -6.00892678e-02f, -8.39195773e-02f, 3.33435573e-02f, -2.85128374e-02f, -5.80989048e-02f, -6.73198234e-03f,
  1.79866143e-02f, 8.60862583e-02f, -2.51543242e-02f, 1.05713923e-02f, -6.08832426e-02f, 5.09089157e-02f, 3.03049050e-02f, -1.25849247e-01f, -3.59274261e-02f, 6.13445304e-02f,
  -9.11533460e-03f, 4.81297635e-02f, -6.67163283e-02f, -6.82874583e-03f, 1.07798375e-01f, -2.54956950e-02f, 9.32664052e-03f, 7.89359659e-02f, 2.27490254e-02f, -2.91820075e-02f,
  -9.29733589e-02f, 3.82674187e-02f, -2.56969351e-02f, -8.94014686e-02f, 1.92527324e-02f, -1.09773492e-02f, 1.72417015e-02f, 8.46598148e-02f, -1.36050195e-01f, 7.25257844e-02f,
  -2.52512917e-02f, 9.17618349e-02f, -5.17628752e-02f, -2.05272287e-02f, 1.56783883e-03f, 1.77386686e-01f, -8.00905153e-02f, 4.94999476e-02f, 4.36362587e-02f, 6.68364167e-02f,
  1.06108822e-01f, -1.85693000e-02f, 7.80881569e-03f, 3.77848968e-02f, -3.60850319e-02f, 9.49886888e-02f, -1.38175003e-02f, -4.95788045e-02f, -2.72770878e-02f, 4.79318574e-03f,
  1.42066728e-03f, 7.81660900e-02f, -1.29345402e-01f, 2.26386823e-02f, 7.35034943e-02f, -1.25295296e-02f, 5.11821620e-02f, -1.98919997e-02f, -2.29105353e-02f, 3.21900123e-03f,
  -2.36896068e-01f, -9.70094651e-02f, -1.69816315e-01f, -1.78388178e-01f, 2.42817134e-01f, 6.61385059e-02f, -1.72000200e-01f, 2.86712404e-02f, -7.13796541e-02f, 2.23612487e-02f,
  4.84006619e-03f, -7.32043236e-02f, -2.08386078e-01f, -1.11943781e-01f, -2.48345792e-01f, -1.55626878e-01f, -1.42796814e-01f, -1.42311156e-01f, -1.73324376e-01f, -3.29726264e-02f,
  -1.75034225e-01f, 8.60735625e-02f, -1.74123570e-01f, 1.94394082e-01f, 9.04934183e-02f, -4.92797084e-02f, 5.09481281e-02f, 1.31816953e-01f, 1.33807451e-01f, 5.92053719e-02f,
  1.97533295e-02f, -1.60887584e-01f, -3.18952426e-02f, 2.23401785e-02f, 1.21071311e-02f, 9.24286693e-02f, 5.34341373e-02f, 9.23233107e-02f, 2.29992997e-02f, 4.61050979e-04f,
  8.49559680e-02f, 1.41191564e-03f, 4.55532223e-02f, -4.62139845e-02f, 4.00029309e-02f, -6.72722012e-02f, 2.15077624e-02f, -3.28584947e-02f, -4.54295054e-02f, 3.85389826e-03f,
  -4.32742834e-02f, 5.58579043e-02f, 2.96356957e-02f, 2.98235286e-02f, -2.58172788e-02f, -5.49155250e-02f, -1.18758909e-01f, -1.02031432e-01f, -5.48225194e-02f, -7.21853152e-02f,
  7.48208985e-02f, -1.05233723e-02f, -3.71302404e-02f, -6.03206158e-02f, -3.77281904e-02f, 6.56529469e-03f, -1.47248618e-02f, -6.05349205e-02f, -5.72260609e-03f, -2.41165850e-02f,
  5.08672521e-02f, -2.40350515e-02f, -4.40900065e-02f, 1.03454083e-01f, -2.94052158e-02f, 5.71828485e-02f, 4.78083715e-02f, 8.01608316e-04f, -2.22690031e-02f, -2.30731852e-02f,
  9.72769633e-02f, -8.53093155e-03f, 1.61997695e-02f, -4.61736023e-02f, -9.99358296e-03f, 7.40995109e-02f, 1.82032846e-02f, 9.16036218e-02f, -1.82260778e-02f, 4.37639840e-02f,
  5.89141399e-02f, 8.28028470e-03f, 4.06300500e-02f, 2.92866081e-02f, -3.85042317e-02f, 9.65262204e-02f, 4.32861336e-02f, 7.49355033e-02f, 9.50446501e-02f, -7.02975467e-02f,
  4.73171324e-02f, -3.61312367e-02f, 7.08034039e-02f, 9.49581787e-02f, -3.17895710e-02f, 9.98108461e-02f, -5.05574904e-02f, 9.87685546e-02f, 6.69613853e-02f, 3.35128494e-02f,
  1.85531192e-02f, 1.02322318e-01f, 2.52079461e-02f, -3.17652859e-02f, 9.71545428e-02f, -2.01462593e-04f, -1.17960398e-03f, -1.46332771e-01f, 5.36696874e-02f, 3.67985331e-02f,
  2.31931970e-01f, -3.99794690e-02f, -3.86718661e-02f, 1.17073461e-01f, 7.17879087e-02f, -1.38831079e-01f, -1.17754139e-01f, 1.85013972e-02f, -9.71242711e-02f, -1.23927407e-01f,
  9.90631711e-03f, 4.99785580e-02f, -1.61382958e-01f, 6.62426949e-02f, 3.86206210e-02f, -2.97956169e-01f, 1.97021753e-01f, 9.46326554e-02f, -4.42803949e-02f, 1.43938243e-01f,
  3.00178826e-02f, 1.89220041e-01f, 1.97539717e-01f, 1.02171294e-01f, 1.99396133e-01f, 1.29317939e-01f, 1.33723587e-01f, 1.97288653e-04f, 2.30334044e-01f, 1.02056280e-01f,
  -3.76552902e-03f, 6.25654310e-02f, -2.69860886e-02f, 6.51616752e-02f, -7.71008208e-02f, 6.28101379e-02f, -3.87122110e-02f, -2.93538254e-02f, -4.82624359e-02f, -1.23697340e-01f,
  -6.27394170e-02f, 6.13525175e-02f, 6.79379180e-02f, -3.40833627e-02f, 6.76823780e-02f, -4.01365891e-04f, -5.34828268e-02f, -7.03509450e-02f, 4.26795371e-02f, -1.59193818e-02f,
  3.79979312e-02f, -5.77831604e-02f, 1.04647363e-02f, -8.50183517e-03f, -7.98218884e-03f, 7.92580247e-02f, -3.72980610e-02f, -6.60645450e-03f, 9.96435732e-02f, 3.58254649e-02f,
  4.57358807e-02f, 3.07258428e-03f, -2.91057937e-02f, 6.01547137e-02f, 1.44320689e-02f, -5.77225275e-02f, -8.55243206e-02f, -7.57808164e-02f, -6.71907738e-02f, -8.95708241e-03f,
  1.31550655e-02f, -4.10223491e-02f, 2.25995164e-02f, -6.69609085e-02f, -6.41044453e-02f, -4.01227316e-03f, -6.11363240e-02f, -1.19059216e-02f, -6.88867085e-03f, -1.28187593e-02f,
  -8.82852729e-03f, -4.50407416e-02f, -5.72053567e-02f, 9.05151591e-02f, 2.23787185e-02f, -6.24206886e-02f, -1.94368027e-02f, -7.18198940e-02f, 1.26997447e-02f, -3.13116214e-03f,
  -1.07593417e-01f, -4.83010449e-02f, -2.94215083e-02f, 1.74631216e-02f, -6.63836598e-02f, 3.16294394e-02f, -9.63408574e-02f, 7.71739185e-02f, 3.78502198e-02f, -1.13303714e-01f,
  9.39192716e-03f, 2.93106232e-02f, -6.63860291e-02f, 8.16858709e-02f, 9.28491727e-02f, -3.34123801e-03f, 5.09841554e-02f, 1.94673277e-02f, 1.17137842e-01f, 4.48650457e-02f,
  1.96236800e-02f, -1.47597641e-01f, 8.66739452e-02f, 1.23705426e-02f, 2.89393030e-02f, -6.73432127e-02f, 1.70094762e-02f, -6.09316789e-02f, -2.76199989e-02f, -5.16076721e-02f,
  2.52740353e-01f, 1.79473460e-01f, 2.05315083e-01f, 2.25646228e-01f, -7.63164535e-02f, -3.52307975e-01f, -1.19703270e-01f, 1.89920098e-01f, 8.84662494e-02f, -1.56042978e-01f,
  9.63266753e-03f, -4.03642282e-02f, 2.85763554e-02f, 4.46513668e-02f, 5.57482243e-02f, -8.04431811e-02f, 2.01658055e-01f, -5.47472350e-02f, -4.20694612e-02f, 1.76419869e-01f,
  2.24981904e-01f, 2.11121817e-03f, 1.26863956e-01f, 3.19833793e-02f, 1.30093321e-01f, 1.77753225e-01f, 2.37484068e-01f, 1.38097527e-02f, 6.78890720e-02f, -3.35642397e-02f,
  -9.37197581e-02f, 9.47970152e-02f, 6.04253151e-02f, -1.13548800e-01f, 4.19959202e-02f, -5.21752164e-02f, -2.51378454e-02f, -8.12268183e-02f, -6.54809996e-02f, -3.08161154e-02f,
  4.10816893e-02f, -4.57435101e-02f, 6.24169856e-02f, 8.91808793e-02f, -3.09581682e-02f, 1.05064102e-01f, 8.40223953e-02f, 3.72548401e-02f, 1.07352771e-02f, 9.73508582e-02f,
  6.40027449e-02f, -1.38122709e-02f, -4.28375117e-02f, -8.11543223e-03f, 1.10692665e-01f, -3.90274972e-02f, -2.17487011e-02f, -5.41326888e-02f, -4.74605151e-02f, -4.20727171e-02f,
  9.31843221e-02f, -1.39289126e-02f, -4.94167246e-02f, 2.71736886e-02f, -4.39530797e-02f, 7.63925165e-02f, -1.61896385e-02f, 1.96309499e-02f, 5.79682216e-02f, -3.28656919e-02f,
  -2.27777846e-02f, 1.04614228e-01f, 3.26744164e-03f, 9.36824922e-03f, 2.64114402e-02f, -7.32004344e-02f, -4.86393413e-03f, 8.14565085e-03f, 6.51078597e-02f, 8.54210171e-04f,
  1.92943085e-02f, 2.38375366e-02f, 1.91296823e-02f, 4.49932702e-02f, -5.88518456e-02f, -2.24749260e-02f, 7.92916045e-02f, -1.71819180e-02f, -1.09320153e-02f, -1.14717418e-02f,
  1.60223397e-03f, 6.99931905e-02f, -1.29922433e-03f, 1.96842290e-02f, 1.88944973e-02f, -1.25021748e-02f, -5.97541295e-02f, 4.23514619e-02f, 1.09858476e-01f, 4.22700979e-02f,
  1.46203605e-03f, -7.03868419e-02f, -2.62255408e-02f, 7.69275278e-02f, -2.31495388e-02f, -2.22682785e-02f, -1.68526056e-03f, 1.41927856e-03f, 1.20697878e-02f, 6.89484850e-02f,
  7.66404942e-02f, -1.07371278e-01f, -5.09691015e-02f, -1.95589829e-02f, 1.59305353e-02f, -8.34266692e-02f, -5.88967279e-03f, 3.35005745e-02f, 6.33319244e-02f, 1.03174694e-01f,
  2.59059221e-01f, 2.57742465e-01f, 2.50672758e-01f, 2.59977579e-01f, -2.97353771e-02f, -2.63407201e-01f, -1.36131436e-01f, -1.09413685e-02f, 6.02835678e-02f, -1.00286370e-02f,
  -1.01573385e-01f, 3.71176839e-01f, -2.39325494e-01f, 2.29720756e-01f, -1.36610597e-01f, -2.36861095e-01f, 1.40950963e-01f, 1.15919143e-01f, 3.38476300e-02f, 2.11844578e-01f,
  1.25011370e-01f, -9.22226235e-02f, 1.08301200e-01f, 4.37916219e-02f, 9.30068418e-02f, 1.36958048e-01f, -1.48330107e-01f, -1.36159122e-01f, 2.40174532e-01f, -8.01504478e-02f,
  -2.63351966e-02f, 4.84189428e-02f, 5.16891442e-02f, 5.99925593e-02f, -6.68215426e-03f, 6.73112795e-02f, 4.51538675e-02f, -1.38799608e-01f, 3.26627158e-02f, 6.68262914e-02f,
  6.87975362e-02f, 3.69756483e-02f, 4.19192165e-02f, -5.25360741e-02f, 4.09683511e-02f, 7.68746212e-02f, -1.05843702e-02f, 1.54271415e-02f, 1.18900076e-01f, 1.03696525e-01f,
  4.97176163e-02f, 1.30380094e-01f, 1.55876786e-01f, 4.28947620e-02f, 1.04947895e-01f, 2.06975844e-02f, -1.30777666e-02f, 7.05866218e-02f, 1.34057486e-02f, 1.29029483e-01f,
  -1.06874898e-01f, -2.36259419e-02f, -3.74310426e-02f, 6.39898479e-02f, 5.51382266e-02f, 4.71495651e-02f, -1.35400740e-03f, 1.27122030e-02f, 7.70135671e-02f, -3.51390243e-02f,
  1.10169221e-02f, 8.80872458e-03f, -8.69032890e-02f, -2.00333968e-02f, 6.54648170e-02f, 3.76395322e-02f, -8.46068375e-03f, -4.20033783e-02f, -2.43095085e-02f, 2.62244605e-02f,
  -3.00825797e-02f, -8.40288326e-02f, 4.73309029e-03f, -6.41883388e-02f, -4.95367609e-02f, 4.39403281e-02f, -3.21742543e-03f, 1.15157880e-01f, 1.89634543e-02f, -1.57260671e-02f,
  -1.75622687e-01f, -2.68762894e-02f, -4.91514988e-03f, -2.32605319e-02f, 3.57498750e-02f, 9.63502526e-02f, 7.85715953e-02f, 7.31388927e-02f, -9.91418865e-03f, 2.45878585e-02f,
  1.20996498e-01f, -4.89340164e-02f, -5.14075570e-02f, -2.32026596e-02f, -3.16819176e-03f, 1.09973803e-01f, 3.41301085e-03f, 3.51485200e-02f, 3.76771539e-02f, -2.55963299e-02f,
  1.92235392e-02f, -6.20348321e-04f, 5.38350083e-03f, 1.32985264e-01f, 3.08237784e-02f, 3.69530506e-02f, 5.99651132e-03f, 5.21269590e-02f, -5.10280430e-02f, -2.18852442e-02f,
  -2.75330037e-01f, 1.45672664e-01f, 5.89884408e-02f, 5.46997078e-02f, 2.84690946e-01f, 3.88513833e-01f, 1.58124790e-01f, 2.15450451e-01f, 3.51866245e-01f, -8.16821754e-02f,
  -6.23041615e-02f, -1.22519180e-01f, -2.23760605e-01f, 5.68313850e-03f, -1.74766947e-02f, -1.86621025e-02f, 1.86573550e-01f, 3.13966572e-02f, 7.52215609e-02f, -9.43266898e-02f,
  1.72550753e-02f, -1.50689455e-02f, -2.95144677e-01f, -1.61081534e-02f, -1.15968473e-02f, -4.96461168e-02f, -2.06519321e-01f, -1.60717338e-01f, -2.02754974e-01f, -4.24767919e-02f,
  -4.38330211e-02f, -1.46219786e-02f, -1.18148997e-01f, -7.93906152e-02f, 2.27152426e-02f, 3.69774774e-02f, -1.08686410e-01f, -6.75890893e-02f, -7.67039508e-02f, 1.12651614e-02f,
  -2.26316098e-02f, -5.94355837e-02f, 8.70933160e-02f, -1.28372638e-02f, 7.03614280e-02f, 3.11855804e-02f, -7.80033991e-02f, 1.12359107e-01f, -9.04105604e-02f, -6.97281659e-02f,
  -2.55525727e-02f, 1.63215827e-02f, 5.38007766e-02f, 1.49751842e-01f, 4.75842096e-02f, 1.00383600e-02f, 1.10293098e-01f, -2.69927438e-02f, -4.51750569e-02f, -1.04031535e-02f,
  -2.02097390e-02f, 6.34431019e-02f, -8.50217938e-02f, 1.96687207e-02f, -3.89186256e-02f, -2.85902042e-02f, -1.71366632e-02f, 5.09555079e-02f, 3.05244550e-02f, -3.39059010e-02f,
  2.69566569e-02f, -3.19511481e-02f, 2.58344002e-02f, -3.38434763e-02f, 4.02814373e-02f, -3.61290872e-02f, 3.29431370e-02f, 9.30865034e-02f, 7.35298768e-02f, -3.48699503e-02f,
  9.02650654e-02f, -1.55852214e-02f, -1.43335313e-02f, 8.55141133e-02f, 9.88262706e-03f, -6.67741969e-02f, -4.32394706e-02f, -2.07144506e-02f, 4.69957627e-02f, 5.38695343e-02f,
  2.26214737e-01f, 3.05520177e-01f, -9.52485204e-02f, 1.45384623e-02f, 1.26940710e-02f, -2.74509075e-03f, -2.98081692e-02f, 4.91177440e-02f, 1.33072451e-01f, 6.72711208e-02f,
  1.09782994e-01f, -5.39374538e-03f, 6.86373487e-02f, -1.33479610e-01f, -8.07608142e-02f, 2.30022222e-02f, 5.15259709e-03f, 8.38045180e-02f, 1.29368782e-01f, -6.44903332e-02f,
  -5.23559228e-02f, 5.66536449e-02f, 3.29981074e-02f, 1.13119952e-01f, 1.18981764e-01f, 7.01021776e-03f, 3.05191297e-02f, 4.08615656e-02f, 2.13668961e-02f, 5.44125578e-06f,
  3.50674652e-02f, -2.75642842e-01f, -6.98296949e-02f, 1.74987689e-01f, 1.13971315e-01f, -1.06690332e-01f, -2.40246221e-01f, 1.65383548e-01f, -2.33697742e-02f, -1.15335546e-01f,
  5.53043298e-02f, -2.29762435e-01f, -2.09015563e-01f, 7.94189796e-02f, 1.90362811e-01f, -1.27068102e-01f, 1.61873311e-01f, 5.63720427e-02f, -6.70260563e-02f, 2.30848361e-02f,
  1.24078237e-01f, 1.99995577e-01f, -1.78168342e-02f, 2.34130412e-01f, 3.86685207e-02f, 1.83842346e-01f, 2.29862362e-01f, -1.36658445e-01f, 2.08040059e-01f, 1.87951922e-01f,
  -1.71660725e-02f, -9.05288383e-02f, 6.37445748e-02f, -7.57830441e-02f, -2.97426078e-02f, -7.17953518e-02f, -5.71510494e-02f, -2.37426404e-02f, -1.59370713e-02f, 1.40469931e-02f,
  -1.92515794e-02f, 3.10309585e-02f, 2.64613070e-02f, 5.49762361e-02f, 1.86248664e-02f, 9.06051099e-02f, 1.18628265e-02f, 2.06365250e-02f, 7.85573851e-03f, -1.44766390e-01f,
  -8.03756043e-02f, 3.26272212e-02f, 5.67814745e-02f, -2.90637352e-02f, 7.57468194e-02f, -6.64069504e-02f, -1.17316842e-03f, -2.87114317e-03f, -6.70942804e-03f, -1.82154439e-02f,
  6.83320537e-02f, -4.17110026e-02f, 7.82968029e-02f, 5.70782945e-02f, -3.14144008e-02f, -5.53976111e-02f, -2.06294321e-02f, 8.48274752e-02f, 1.12276621e-01f, -7.47465342e-02f,
  -4.86079976e-02f, 2.55543888e-02f, 1.09333724e-01f, -8.62508565e-02f, -6.17731921e-02f, -5.87401316e-02f, 8.43802318e-02f, 5.56284338e-02f, -1.50656980e-02f, 7.05728456e-02f,
  -1.58576500e-02f, -2.79275589e-02f, 5.52526824e-02f, 7.45903030e-02f, 2.38095652e-02f, -8.23177993e-02f, 4.75252717e-04f, -9.33995545e-02f, -3.34203541e-02f, -8.07046741e-02f,
  6.13663755e-02f, -1.06595650e-01f, -3.49813551e-02f, 4.81204465e-02f, -3.09374202e-02f, -6.54699802e-02f, -6.77520633e-02f, 1.34075172e-02f, -7.75163770e-02f, 6.70406036e-03f,
  8.75719413e-02f, -6.40426353e-02f, 3.65198888e-02f, 5.17058000e-02f, 1.34093106e-01f, -1.69652980e-02f, -4.83180359e-02f, 6.35640100e-02f, 1.41769201e-01f, 2.92582363e-02f,
  -5.26076704e-02f, -9.61557403e-02f, 1.15098223e-01f, -1.04577828e-03f, 1.64504386e-02f, 4.11956199e-02f, 4.69969027e-02f, 6.16604425e-02f, 2.49473955e-02f, 3.37384753e-02f,
  -9.74811390e-02f, -4.83342301e-04f, -1.51123255e-01f, -4.11513932e-02f, -1.54658452e-01f, 1.55312896e-01f, 2.37133186e-02f, -2.10996475e-02f, -1.22342467e-01f, 2.59916186e-01f,
  1.13330163e-01f, -1.71328619e-01f, 1.84249863e-01f, 7.76401833e-02f, -1.60505399e-01f, 1.55975655e-01f, 7.97452629e-02f, 2.31916625e-02f, -8.90835002e-02f, 6.44441992e-02f,
  2.68807970e-02f, 2.15384990e-01f, -1.51189923e-01f, 7.82283172e-02f, 4.10361923e-02f, 1.03706084e-01f, 1.53694838e-01f, -2.86661815e-02f, -2.41038436e-03f, -6.07104339e-02f,
  -1.56907141e-02f, 5.82273677e-02f, 1.82167813e-02f, -7.99104273e-02f, 2.07195595e-01f, 1.73626304e-01f, -3.69511582e-02f, 5.42145185e-02f, -4.73882817e-02f, 2.14398168e-02f,
  -7.41812885e-02f, -1.37713715e-01f, 3.69712636e-02f, -5.39860502e-02f, -9.68717486e-02f, -1.25339508e-01f, -7.95846456e-04f, -1.06202275e-01f, -2.32360903e-02f, -1.08612187e-01f,
  -1.59933567e-01f, -1.13846250e-02f, 4.45195287e-02f, 2.29466595e-02f, -1.67093620e-01f, -9.45004299e-02f, -7.60572031e-02f, -1.00702502e-01f, -4.60825302e-02f, -1.09121919e-01f,
  8.83471817e-02f, -8.67324974e-03f, 1.25013530e-01f, -1.57477856e-02f, -7.43625686e-02f, 3.79275866e-02f, -3.26558948e-02f, 8.64546224e-02f, -6.84845895e-02f, 6.75781220e-02f,
  3.50259580e-02f, -1.15900636e-01f, 3.58860381e-02f, -3.00947074e-02f, 1.60347894e-02f, -9.06262770e-02f, 3.63274454e-03f, 2.04817206e-02f, 6.38739998e-03f, 2.59921420e-02f,
  4.90835086e-02f, -2.64333040e-02f, 8.94314274e-02f, 8.74530002e-02f, -1.11696139e-01f, -8.27257801e-03f, -1.22128287e-02f, -2.19630823e-02f, 6.82925731e-02f, -1.15482502e-01f,
  1.52329654e-01f, 1.61757559e-01f, 2.79988833e-02f, -4.90678772e-02f, -6.62269667e-02f, 1.38983265e-01f, 1.04700394e-01f, -6.50816560e-02f, 8.02759677e-02f, -1.11756884e-02f,
  8.36625695e-03f, -1.24510489e-01f, 7.66415223e-02f, 1.96413882e-02f, -7.79003650e-02f, 2.24561840e-02f, -1.75617356e-02f, 2.01672055e-02f, -2.23188736e-02f, -1.45835774e-02f,
  6.85551856e-03f, -4.72852215e-02f, -4.38877493e-02f, 3.13347019e-02f, 1.44493937e-01f, 4.68022190e-02f, 9.14085656e-02f, 3.75945447e-03f, 2.60417070e-02f, -9.36845597e-03f,
  -3.92412543e-01f, 6.62210658e-02f, -1.12032056e-01f, -1.13104567e-01f, 1.69810399e-01f, -2.96089172e-01f, -1.05403118e-01f, 1.62768349e-01f, -1.40982926e-01f, 1.11211911e-01f,
  4.93558273e-02f, -1.70392096e-01f, 1.38244763e-01f, -3.28491569e-01f, -4.09809351e-01f, -1.13357075e-01f, -3.03329885e-01f, -1.83928892e-01f, -1.28664911e-01f, 7.89454207e-02f,
  -5.13151065e-02f, -9.30020660e-02f, -1.36813030e-01f, 1.52082920e-01f, 1.32193282e-01f, 9.47653651e-02f, 2.55482227e-01f, 1.97316080e-01f, -7.37934466e-03f, -1.00558445e-01f,
  -5.34720123e-02f, 1.24648504e-01f, -7.64122680e-02f, 2.48179529e-02f, 2.31494009e-02f, -1.35481283e-02f, -8.39381665e-03f, -7.03581795e-02f, 8.96747857e-02f, -1.28217071e-01f,
  5.55657558e-02f, -4.83618956e-03f, -3.94668318e-02f, 8.26762468e-02f, 1.34624708e-02f, -2.87635364e-02f, -4.38489318e-02f, 4.33691544e-03f, -3.44227962e-02f, -1.72521859e-01f,
  -9.76722986e-02f, -1.09226421e-01f, 6.26945943e-02f, -8.50671604e-02f, 3.29722161e-03f, 1.31022399e-02f, 5.53640444e-03f, 2.41967663e-02f, -7.34631112e-03f, -6.54053167e-02f,
  9.85173658e-02f, 9.82907191e-02f, -4.21358086e-02f, -1.06296271e-01f, 2.94026230e-02f, 8.62884149e-02f, -2.47619748e-02f, -3.82301025e-02f, 4.22819108e-02f, -1.61045995e-02f,
  -5.81424125e-02f, -5.74348234e-02f, -3.40708084e-02f, 3.01844031e-02f, -1.83511488e-02f, -8.41065720e-02f, 6.52307570e-02f, 4.04169858e-02f, -6.60236478e-02f, -6.42481074e-02f,
  6.20262809e-02f, -8.39919492e-04f, -9.28926095e-02f, 1.46376574e-02f, -6.57187253e-02f, 8.10478181e-02f, 1.93082336e-02f, -5.54576255e-02f, 5.35145728e-03f, 9.88997705e-03f,
  -2.78423782e-02f, 2.38725558e-01f, -4.93566394e-02f, -5.42824529e-02f, 3.45961936e-02f, -4.40777615e-02f, -3.50439292e-03f, -2.84337020e-03f, 1.03651034e-02f, 6.24307953e-02f,
  1.02347277e-01f, 3.79860066e-02f, 6.88985065e-02f, -8.99493992e-02f, -2.00893916e-02f, -6.45029247e-02f, 7.04226941e-02f, 1.09004445e-01f, -2.08370890e-02f, 1.18435258e-02f,
  1.97147295e-01f, -1.56213134e-03f, -8.08678344e-02f, 5.70487157e-02f, -2.10741255e-02f, 5.34231514e-02f, 3.69754992e-02f, -4.94338060e-03f, 3.22074592e-02f, 4.40618396e-02f,
  1.38034359e-01f, -1.88988209e-01f, -2.50162512e-01f, -2.79302616e-02f, -2.04887856e-02f, -3.05312514e-01f, -3.14624906e-01f, -1.78064823e-01f, 1.77430019e-01f, -1.75335929e-01f,
  -1.75650463e-01f, 8.58996511e-02f, 5.54599911e-02f, -2.06195995e-01f, 2.69856632e-01f, 1.97481245e-01f, -3.20363730e-01f, -1.73208013e-01f, 1.34829417e-01f, -2.68705547e-01f,
  -2.87234895e-02f, -1.56816140e-01f, -3.17547284e-02f, -1.83696717e-01f, -2.99429774e-01f, -1.75946191e-01f, 7.14869052e-02f, -1.65299922e-01f, -1.86842829e-01f, 1.59598887e-02f,
  1.11965783e-01f, 1.71268672e-01f, 5.10437973e-02f, 7.20499316e-03f, 3.72987576e-02f, -7.66035989e-02f, -1.10246949e-01f, 7.82586932e-02f, 1.28310069e-01f, -2.96701286e-02f,
  -1.45838046e-02f, -6.03687204e-02f, -1.49653452e-02f, 3.01677156e-02f, -7.67064095e-02f, -6.11625798e-02f, -3.90250385e-02f, 6.62633777e-02f, 2.39814874e-02f, -3.78769934e-02f,
  -4.21827622e-02f, 7.25434944e-02f, -1.02452181e-01f, -9.71639995e-03f, -9.22337249e-02f, 2.12443396e-02f, -1.58503987e-02f, -7.59971067e-02f, -9.42468420e-02f, 8.17191824e-02f,
  -6.56824782e-02f, -9.23078433e-02f, -7.69703090e-03f, 1.16024995e-02f, -1.14251748e-02f, 6.46655187e-02f, -2.87786592e-02f, 4.45797108e-02f, -1.36596322e-01f, -2.42048036e-02f,
  -5.50880097e-02f, -6.03281930e-02f, 3.60641293e-02f, -1.25176762e-03f, -1.06513575e-01f, 9.37461406e-02f, 2.42997538e-02f, -1.73201002e-02f, -4.29001376e-02f, 7.31185079e-02f,
  7.29330927e-02f, -8.23522359e-02f, -9.09240618e-02f, -1.07262701e-01f, -6.21830784e-02f, 5.92626184e-02f, -3.91850621e-02f, -1.07201755e-01f, 5.61383441e-02f, -6.28968030e-02f,
  1.10818148e-01f, -2.27465015e-03f, -2.42314413e-02f, 6.70276806e-02f, -2.38590986e-02f, 1.14977293e-01f, 3.93615179e-02f, -1.13431759e-01f, -5.14802821e-02f, -1.81117970e-02f,
  -2.01542843e-02f, 7.41768479e-02f, 3.41197066e-02f, -6.87968591e-03f, -2.84240711e-02f, -1.84075367e-02f, -2.53504161e-02f, -1.06504979e-02f, -1.46045275e-02f, 1.00422231e-02f,
  1.91544853e-02f, -1.12935007e-02f, -2.27875728e-02f, -5.37035055e-02f, -1.05965160e-01f, 6.52156910e-03f, 7.08791018e-02f, 1.40907113e-02f, -9.00437385e-02f, -1.85221210e-02f,
  -5.31234801e-01f, 4.97093052e-02f, -5.54187819e-02f, -2.98124880e-01f, -1.15437377e-02f, -3.69173825e-01f, -1.87162042e-01f, 1.55680075e-01f, 1.28007874e-01f, -9.25496593e-02f,
  -4.82414477e-03f, -1.23399846e-01f, 1.37832582e-01f, -8.25985000e-02f, -2.64484882e-01f, -3.95900533e-02f, -2.20752493e-01f, -1.16695784e-01f, 1.37890324e-01f, -1.02796800e-01f,
  -4.07566205e-02f, 8.91206637e-02f, -1.13732293e-01f, 2.14858621e-01f, -1.11003935e-01f, 3.39771062e-02f, -1.02674462e-01f, 1.76155388e-01f, -2.41319403e-01f, 2.84260847e-02f,
  -1.14085540e-01f, 1.70833264e-02f, -2.96302442e-03f, -4.63398062e-02f, -6.99588060e-02f, -2.09846999e-03f, -1.73888311e-01f, -4.95446511e-02f, -4.87021543e-02f, 6.51481524e-02f,
  1.01555360e-03f, 6.08649291e-02f, -1.31791890e-01f, 1.32297263e-01f, 9.39438194e-02f, 1.13080457e-01f, -4.78683710e-02f, -1.24478444e-01f, -4.95842211e-02f, -1.56403352e-02f,
  9.38488841e-02f, -1.18095078e-01f, -6.46700189e-02f, 2.57133730e-02f, 7.12423995e-02f, 5.80382310e-02f, -1.04832999e-01f, -3.59850302e-02f, -1.19700141e-01f, -9.68282446e-02f,
  -8.26759078e-03f, -8.63635167e-02f, 3.98023389e-02f, 1.70077115e-01f, -6.27934188e-02f, -2.57853623e-02f, -6.34031370e-02f, 4.66331393e-02f, -7.14037567e-02f, 4.23356220e-02f,
  -2.95255389e-02f, -7.04316497e-02f, 1.01836219e-01f, -4.62857336e-02f, -3.20625380e-02f, -3.74025069e-02f, -1.07762434e-01f, 9.20102075e-02f, -1.27288967e-01f, -8.68530106e-03f,
  3.89583483e-02f, 3.40351858e-03f, 1.96970254e-02f, -3.45497578e-02f, 5.43844774e-02f, -1.70170683e-02f, 4.41362672e-02f, -4.64318916e-02f, -2.47023650e-03f, -8.89451280e-02f,
  -2.58123547e-01f, 1.00863799e-02f, 6.79402947e-02f, 3.14143412e-02f, 9.97397001e-04f, -7.52794743e-02f, 4.93554249e-02f, -6.61035627e-02f, -6.18781000e-02f, -1.37277378e-03f,
  3.30544189e-02f, 5.07608801e-02f, -7.49674737e-02f, 4.92552407e-02f, 3.13060768e-02f, -6.37673363e-02f, 2.52595767e-02f, -3.46757248e-02f, -7.55997449e-02f, 3.64449956e-02f,
  -9.97316763e-02f, 6.15394302e-03f, 1.16527928e-02f, -9.83629655e-03f, -5.74295856e-02f, -2.48605181e-02f, -7.09887147e-02f, 2.30599195e-03f, -1.76878087e-02f, -7.97110274e-02f,
  3.83123040e-01f, 4.09294553e-02f, 2.10813746e-01f, 3.20286274e-01f, 8.89542326e-02f, -1.63710847e-01f, -6.81562796e-02f, 9.28885341e-02f, 2.43166938e-01f, -7.45333061e-02f,
  -1.64429620e-01f, 7.36571625e-02f, -2.53081650e-01f, -3.65358405e-02f, -3.16507041e-01f, -1.98308051e-01f, -1.23304605e-01f, -1.09535661e-02f, 8.25780211e-04f, 5.82840061e-03f,
  5.20355627e-02f, -1.35794416e-01f, -6.88776746e-02f, -1.52857289e-01f, 1.87848017e-01f, 2.34045595e-01f, -1.30211264e-01f, -9.55021456e-02f, 1.19116977e-01f, -1.65990576e-01f,
  2.57956143e-02f, 2.59599723e-02f, 6.34588823e-02f, -3.15632075e-02f, 8.50476772e-02f, 5.34638837e-02f, 2.10595550e-03f, -8.02875236e-02f, 5.68399671e-04f, -4.53303717e-02f,
  -1.18423533e-02f, -2.46747695e-02f, 5.20912521e-02f, -5.64170033e-02f, 1.53141782e-01f, 9.00453608e-03f, 1.58760011e-01f, 2.23010197e-01f, 6.63342699e-02f, 1.16318770e-01f,
  1.42114878e-01f, 7.88216665e-02f, -3.78688313e-02f, 9.61063132e-02f, 3.17676328e-02f, -1.78009886e-02f, 8.11062157e-02f, -3.06723658e-02f, 8.02885443e-02f, 1.81811471e-02f,
  6.50169626e-02f, -9.88056287e-02f, -1.25843555e-01f, -1.02708796e-02f, -1.09963976e-01f, 6.02076054e-02f, -1.15629725e-01f, -1.09521486e-01f, -7.76665136e-02f, -5.09349369e-02f,
  -3.72640453e-02f, -6.32882118e-02f, 9.64463223e-03f, 9.77234617e-02f, 7.20081106e-02f, 5.36175631e-02f, 1.69141088e-02f, 3.24793626e-03f, 1.93199277e-01f, 6.98309094e-02f,
  -1.12308271e-01f, -6.91677108e-02f, -3.72921824e-02f, 4.78329062e-02f, -7.71177709e-02f, 5.81701025e-02f, 4.75204103e-02f, 3.17437872e-02f, 7.83210397e-02f, -1.09110408e-01f,
  -4.80131470e-02f, -8.56895447e-02f, 4.94202785e-02f, -4.33348864e-02f, -1.26868710e-01f, 3.07746213e-02f, -1.20407566e-01f, 7.12804124e-02f, -1.42918639e-02f, -1.20612048e-01f,
  1.12096392e-01f, -8.16667732e-03f, -9.85800922e-02f, 3.05068027e-02f, -5.30049428e-02f, -6.09678142e-02f, -3.71648334e-02f, 2.51915772e-02f, -6.17169589e-02f, 1.88055001e-02f,
  1.36048526e-01f, 8.22360590e-02f, 3.74259055e-02f, 3.50916125e-02f, 1.22927293e-01f, 4.82124873e-02f, -9.29637905e-03f, 9.29122120e-02f, -4.60992977e-02f, -6.14344105e-02f,
  -6.68049991e-01f, 4.01870042e-01f, 2.38865942e-01f, -1.37369066e-01f, 1.08512111e-01f, 3.40251297e-01f, -8.48538578e-02f, 1.05872951e-01f, -4.85023186e-02f, -8.01773369e-02f,
  -8.22772682e-02f, -1.61186308e-01f, -3.74715663e-02f, 1.66050345e-02f, 3.26854922e-02f, 4.82312404e-02f, 9.16550159e-02f, -3.87845710e-02f, 9.15391967e-02f, -4.16090712e-03f,
  1.03764180e-02f, -5.47857881e-02f, 3.30562666e-02f, 6.44323379e-02f, 6.22428134e-02f, -2.15904266e-02f, -2.16645017e-01f, 7.04968050e-02f, -1.96916591e-02f, 5.57120144e-02f,
  1.85032177e-03f, -8.77121761e-02f, -1.77590605e-02f, 2.18058168e-03f, -5.11778109e-02f, -1.14900097e-01f, -9.59325302e-03f, -5.32468110e-02f, -1.37462080e-01f, 7.30800182e-02f,
  -2.43156254e-02f, 1.49801910e-01f, -6.96172193e-02f, -6.88797235e-02f, 1.07045658e-01f, 4.68653850e-02f, 8.05911236e-03f, 2.74638347e-02f, 7.18361586e-02f, 1.11394180e-02f,
  2.03028485e-01f, 1.46955460e-01f, -6.44743070e-02f, -2.23505888e-02f, 3.23080011e-02f, 2.10090354e-02f, 7.74457678e-02f, -1.99649781e-02f, 1.49552107e-01f, 9.15823784e-03f,
  -5.50834909e-02f, 1.98004637e-02f, -1.33001789e-01f, -7.21645504e-02f, -4.25594337e-02f, 3.15159485e-02f, -1.10449761e-01f, -1.12608105e-01f, -7.78306369e-03f, -2.33800653e-02f,
  -1.02811664e-01f, -2.65741367e-02f, 1.23960160e-01f, 1.95002630e-02f, -1.14885472e-01f, 6.22331491e-03f, -1.07868783e-01f, 6.80994242e-02f, 5.09055369e-02f, 2.27139834e-02f,
  -1.09907351e-01f, -2.89822519e-02f, -2.79116929e-02f, 5.95416613e-02f, 1.07939038e-02f, 2.89226826e-02f, 2.08594464e-02f, 9.09109861e-02f, 2.01361459e-02f, -1.23233318e-01f,
  2.44189039e-01f, 5.32067521e-03f, -5.80870397e-02f, 6.17172271e-02f, 2.54371539e-02f, 3.84347253e-02f, -4.30800579e-02f, 4.39732298e-02f, -6.13013422e-03f, 6.66124746e-02f,
  -1.08876005e-01f, -3.10564507e-02f, 4.28556837e-02f, -9.66902170e-03f, -6.56282380e-02f, 4.92864549e-02f, -1.46941423e-01f, 6.57552108e-02f, -1.65374558e-02f, -1.52526274e-02f,
  3.72804739e-02f, -6.80823717e-03f, -9.33859497e-02f, 2.51180269e-02f, -5.97328320e-02f, -1.33538127e-01f, -9.98174176e-02f, 4.16253358e-02f, -1.14538670e-02f, -3.54745016e-02f,
  -1.26303807e-01f, -1.64163232e-01f, -7.86826313e-02f, -2.04681367e-01f, 3.56922485e-02f, -1.73568368e-01f, -2.13138968e-01f, -5.87070137e-02f, -1.45307273e-01f, -8.21611732e-02f,
  -1.82144329e-01f, 1.40385762e-01f, 1.80086359e-01f, -2.42780998e-01f, 2.04120025e-01f, 2.48618931e-01f, -1.40305609e-01f, -9.31412876e-02f, -1.07876547e-01f, -1.57936737e-02f,
  3.99766639e-02f, -1.23552643e-01f, 1.61654521e-02f, -2.06837207e-01f, -4.80901524e-02f, -3.85200009e-02f, -6.22983873e-02f, -7.29458481e-02f, -1.93347663e-01f, 5.76079153e-02f,
  -1.29128352e-01f, -2.75884300e-01f, -1.53754890e-01f, -2.19241474e-02f, -1.47264097e-02f, 7.34474659e-02f, -3.83677892e-02f, 2.81670727e-02f, -5.47075383e-02f, 1.77489538e-02f,
  2.84767840e-02f, 8.83009881e-02f, -1.24239594e-01f, 1.57744989e-01f, 9.58145130e-03f, -5.82838245e-02f, 6.33436814e-02f, -2.67433655e-02f, -6.57243431e-02f, 1.22456484e-01f,
  -3.40609066e-02f, -6.04121014e-02f, -9.78653356e-02f, -9.12998691e-02f, 1.30334934e-02f, -1.32012084e-01f, 3.86864766e-02f, 7.47622401e-02f, 2.08311118e-02f, -7.89279118e-02f,
  -4.65325229e-02f, 1.15579218e-01f, -6.20971061e-02f, -1.08579062e-01f, -4.89252545e-02f, 3.37382518e-02f, -3.11905388e-02f, 4.95041683e-02f, -3.01074143e-02f, -5.74969798e-02f,
  -1.12833194e-01f, 8.83084312e-02f, -1.02910973e-01f, 2.08785478e-03f, -2.50189696e-02f, 4.77465317e-02f, -3.75013216e-03f, -5.63390031e-02f, 5.56381699e-03f, -6.86110929e-02f,
  -1.06992476e-01f, -4.95607853e-02f, 8.43451396e-02f, 8.15730169e-02f, 1.55137051e-02f, 3.84149477e-02f, -3.21035497e-02f, 6.53995201e-02f, -2.46857554e-02f, -1.30879581e-02f,
  -1.55871645e-01f, -1.88595384e-01f, -1.29738212e-01f, -1.77759349e-01f, -6.78057522e-02f, -1.71032734e-02f, 5.73479896e-03f, 4.08734530e-02f, -1.15162492e-01f, 2.68844049e-02f,
  -9.69791133e-03f, -2.46875864e-02f, -8.34311694e-02f, -4.23996262e-02f, -2.36726422e-02f, -9.18793008e-02f, -1.40373245e-01f, 4.96867225e-02f, -3.87571119e-02f, -5.39479405e-02f,
  -1.27941126e-03f, -2.54042298e-02f, 1.32764235e-01f, 8.16722214e-02f, 9.32533294e-02f, -1.31217986e-01f, 8.80441442e-02f, -1.48274442e-02f, 9.96840522e-02f, 7.39081576e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.80830583e-01f, 1.62757799e-01f, 1.76582374e-02f, 2.06839684e-02f, 1.44199014e-01f, 1.57117307e-01f, 2.57296473e-01f, 1.18275084e-01f, 2.15132654e-01f, 7.56903812e-02f,
  3.02587241e-01f, 2.20615938e-01f, 1.45433411e-01f, 1.47930190e-01f, 2.03657746e-01f, 1.66681379e-01f, 1.12355791e-01f, 2.10254878e-01f, 1.71090942e-02f, 2.11228043e-01f,
  5.11806794e-02f, 8.30126554e-02f, 1.90761000e-01f, 1.52907908e-01f, 2.59773582e-01f, 1.59239560e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  5.94040975e-02f, 1.93300426e-01f, 9.08274651e-02f, 8.51896839e-05f, -1.16293207e-01f, -5.77724241e-02f, 1.78576291e-01f, -4.39974554e-02f, 3.85841308e-03f, -1.94467887e-01f,
  -1.20129310e-01f, 1.41291812e-01f, 1.56520202e-03f, -3.70928645e-02f, 5.04381955e-03f, 2.54505277e-02f, -1.49786472e-01f, 1.88438803e-01f, -1.87794968e-01f, -8.92456174e-02f,
  7.58435577e-02f, -1.60196081e-01f, -6.61338791e-02f, 5.89570105e-02f, 1.44159704e-01f, 8.57164040e-02f, 2.80512094e-01f, 7.34443963e-02f, 3.76088321e-02f, 3.50571275e-02f,
  -9.65196565e-02f, 5.53513393e-02f, 3.67328860e-02f, 1.34410905e-02f, -2.56516524e-02f, 2.43242204e-01f, 1.07729651e-01f, 7.05561265e-02f, 1.06728159e-01f, 1.48025557e-01f,
  3.94526906e-02f, -2.88859755e-01f, -6.09379932e-02f, 1.13236234e-01f, 7.26005882e-02f, 1.43916368e-01f, -5.91627397e-02f, -3.35091501e-01f, -5.39487749e-02f, 8.89209732e-02f,
  1.93044037e-01f, 8.97174329e-02f, 2.10267290e-01f, 2.48196885e-01f, 2.44037777e-01f, 8.88870955e-02f, 8.70619416e-02f, -1.49939761e-01f, 3.72859947e-02f, -1.64449453e-01f,
  -2.89176047e-01f, 2.91205466e-01f, -6.23006299e-02f, -3.36528033e-01f, 4.30541746e-02f, 7.23377466e-02f, 1.25636950e-01f, 9.28371251e-02f, 2.27767661e-01f, 7.25728571e-02f,
  5.59280142e-02f, 1.23226373e-02f, -4.00471427e-02f, 5.37359603e-02f, -2.12037787e-02f, 7.18788654e-02f, 3.34378146e-02f, -6.74705654e-02f, -3.15185152e-02f, 1.06194362e-01f,
  -6.98142499e-02f, -1.25382558e-01f, 4.18638848e-02f, -7.25189969e-02f, 3.72929387e-02f, 1.19333759e-01f, -2.24072725e-01f, 1.07119687e-01f, -8.39868113e-02f, -3.13575298e-01f,
  -1.86261505e-01f, -1.43378004e-01f, -5.80139086e-02f, -2.05718830e-01f, 2.05240145e-01f, 2.10454509e-01f, -2.04042614e-01f, 2.51739562e-01f, -2.18913749e-01f, 9.54106152e-02f,
  2.20016673e-01f, -7.88612440e-02f, -8.42802003e-02f, 1.79901458e-02f, 1.03723884e-01f, -1.18040711e-01f, -7.88831711e-02f, 1.51621830e-02f, -1.90769941e-01f, 1.40609860e-01f,
  -1.00797229e-01f, 1.32105514e-01f, 2.13368714e-01f, 2.02364445e-01f, -6.43968508e-02f, 8.60967934e-02f, -1.35705695e-01f, -2.56819595e-02f, 1.02410838e-01f, 3.15718018e-02f,
  -2.00319886e-01f, 8.85835588e-02f, -9.59021300e-02f, -1.82913467e-01f, 3.67010795e-02f, -7.11325929e-02f, 3.29054564e-01f, -1.74734399e-01f, 5.92661239e-02f, -2.74762541e-01f,
  -1.42340645e-01f, 7.20335171e-02f, 9.46501270e-02f, -1.64957747e-01f, -1.18613489e-01f, -6.97154999e-02f, -1.36819124e-01f, 1.05375268e-01f, -7.58091658e-02f, -2.68197715e-01f,
  -3.34324911e-02f, 3.76252122e-02f, -6.80882391e-03f, -1.28482893e-01f, -2.17821868e-03f, -1.36082396e-01f, 1.17238536e-02f, 8.56758431e-02f, 2.64402218e-02f, 1.51586533e-01f,
  -1.22407228e-01f, 8.47617015e-02f, 8.81511644e-02f, 1.00124836e-01f, -8.51714313e-02f, -7.96816126e-02f, -1.01490363e-01f, -5.33415526e-02f, 1.18163958e-01f, -1.49409741e-01f,
  -8.71557713e-05f, 8.51925313e-02f, -1.90216094e-01f, -4.31925878e-02f, 3.02382708e-02f, -2.00122185e-02f, -6.09550290e-02f, -5.90556115e-02f, -3.71684842e-02f, 1.95044085e-01f,
  -1.13992110e-01f, -3.26305553e-02f, -1.31422415e-01f, 6.07286394e-02f, -1.29564628e-01f, 2.48779982e-01f, 1.41072855e-03f, -1.48818895e-01f, -1.10884957e-01f, 6.12502843e-02f,
  9.73481759e-02f, 8.32460672e-02f, 6.28505722e-02f, -1.63297951e-01f, 7.47605786e-02f, 4.51878123e-02f, -5.11275306e-02f, 9.68556628e-02f, 2.28782803e-01f, -7.81916603e-02f,
  6.83890469e-03f, 1.16640888e-01f, -2.75392234e-02f, -1.20559454e-01f, 7.27815703e-02f, 9.59151760e-02f, 2.78105363e-02f, -3.38368826e-02f, -9.67754051e-03f, 9.46364179e-02f,
  5.85094020e-02f, -1.64856073e-02f, -6.20929105e-03f, 1.14617590e-02f, 1.07701711e-01f, 7.81312883e-02f, 1.42137408e-01f, -1.60971452e-02f, 1.61531940e-01f, 4.76997681e-02f,
  1.24815881e-01f, 2.80541450e-01f, -2.01603606e-01f, -2.62186695e-02f, 2.78884880e-02f, -1.99846596e-01f, -2.73961693e-01f, 1.09665114e-02f, -2.35936195e-01f, -2.00631693e-02f,
  -2.71661043e-01f, 1.35921657e-01f, -9.49933529e-02f, -8.69780499e-03f, 2.84844756e-01f, -3.81301977e-02f, 2.84154415e-01f, -9.44430903e-02f, -2.32985884e-01f, 2.81755596e-01f,
  5.60364872e-02f, 3.14121060e-02f, 2.72742771e-02f, -1.35554120e-01f, -1.60655886e-01f, -1.56188622e-01f, -1.94563158e-02f, -6.58087879e-02f, 2.11746648e-01f, 1.59504376e-02f,
  2.77122185e-02f, -1.33624837e-01f, -1.19089589e-01f, 5.14696799e-02f, 9.07882228e-02f, -2.39135370e-01f, -3.29491168e-01f, -3.02254111e-01f, -7.77836293e-02f, -1.91329196e-01f,
  -5.52525483e-02f, -1.46998823e-01f, -8.38425308e-02f, -2.48918280e-01f, 6.93967268e-02f, 1.23521104e-01f, -3.89463864e-02f, 1.93092655e-02f, -1.01830140e-01f, -1.32037833e-01f,
  -7.54365772e-02f, 1.65358678e-01f, -5.15741669e-02f, -9.53276753e-02f, -1.00994945e-01f, -1.17013395e-01f, -3.78072523e-02f, -1.20712847e-01f, 7.24499822e-02f, 1.00893334e-01f,
  6.71374649e-02f, 1.42330825e-01f, -9.46953148e-02f, 9.55915973e-02f, 5.79683036e-02f, -4.11055749e-03f, 2.31739059e-01f, -1.33612314e-02f, -1.31537557e-01f, -1.60695482e-02f,
  1.92358911e-01f, 1.24912933e-01f, 3.23308557e-01f, 3.23228016e-02f, -1.55486390e-01f, 1.24108024e-01f, 1.15359373e-01f, -2.26297662e-01f, -4.13454436e-02f, -6.58325031e-02f,
  9.51621532e-02f, 8.22447706e-03f, 2.63535231e-01f, -1.35331869e-01f, 3.23898531e-02f, 1.78880751e-01f, -7.85695389e-02f, -8.07290450e-02f, 1.76386863e-01f, 1.81751579e-01f,
  -5.16982116e-02f, -4.95061167e-02f, -2.87255123e-02f, -1.79838344e-01f, -1.32689178e-01f, 1.74144767e-02f, 8.27493705e-03f, 4.09337170e-02f, 2.15832055e-01f, 2.69177854e-01f,
  3.32135767e-01f, -8.13199654e-02f, 2.15754136e-01f, -1.54482741e-02f, 2.18177319e-01f, 1.69155404e-01f, 1.74627423e-01f, 2.79938817e-01f, -1.77983880e-01f, 4.05484922e-02f,
  -2.00303331e-01f, 9.20051038e-02f, 1.94728181e-01f, -4.30360362e-02f, -3.36556532e-03f, 6.43239617e-02f, 9.49472412e-02f, -4.35678586e-02f, 6.73816353e-02f, 9.61408317e-02f,
  4.45521735e-02f, 1.79899652e-02f, -1.14702068e-01f, 1.21749014e-01f, 1.24615198e-02f, 1.50444418e-01f, -1.23261459e-01f, -1.54326215e-01f, -3.03898342e-02f, -3.59988189e-03f,
  7.34566525e-02f, -9.61373150e-02f, -6.96926638e-02f, 1.33251607e-01f, -4.09371307e-04f, -6.98219612e-02f, -7.35676661e-02f, -1.01635410e-02f, -1.37109786e-01f, 1.71936765e-01f,
  1.28112048e-01f, 4.38421592e-02f, 2.60190994e-01f, -9.76460800e-02f, 2.59921610e-01f, -3.97997472e-04f, 2.69351471e-02f, 1.33353636e-01f, -2.52294331e-03f, -3.01486626e-03f,
  -1.12627007e-01f, -2.05318376e-01f, 1.45359367e-01f, 5.69150783e-02f, 1.56071901e-01f, -5.53859510e-02f, 1.34874031e-01f, -1.74523339e-01f, -1.37175724e-01f, -4.94300723e-02f,
  7.07371086e-02f, 1.00258537e-01f, 3.16211842e-02f, 1.64612159e-01f, 2.27198586e-01f, -7.46829761e-03f, 2.04939649e-01f, -3.99979576e-02f, 2.94080079e-01f, -2.91786164e-01f,
  1.69903517e-01f, -4.13901545e-02f, 7.53431916e-02f, -1.50915802e-01f, -1.43584788e-01f, 1.48564994e-01f, 7.14247599e-02f, -3.31263058e-02f, -1.82791293e-01f, -1.01522654e-01f,
  -2.09366120e-02f, -2.15455368e-02f, 2.38490626e-02f, -2.14499146e-01f, -1.51722610e-01f, 1.64021730e-01f, -3.14756408e-02f, 8.26422721e-02f, -1.59312576e-01f, -4.97786216e-02f,
  -4.27582264e-02f, -1.14252763e-02f, -2.37503007e-01f, -1.09583773e-01f, -4.91003245e-02f, -1.71262562e-01f, 1.71096727e-01f, 7.24277049e-02f, 1.35785609e-01f, -6.59897849e-02f,
  -2.31953278e-01f, 2.34957244e-02f, 2.71333843e-01f, -7.36513585e-02f, -1.10867962e-01f, 2.95506716e-01f, -3.29704344e-01f, 1.24437645e-01f, -2.11842418e-01f, -5.18158600e-02f,
  5.08187804e-04f, 1.87723581e-02f, 5.81186116e-02f, 3.59433256e-02f, 1.97970897e-01f, 1.88795775e-01f, -5.49383797e-02f, 2.05312252e-01f, -2.32471690e-01f, 3.09217982e-02f,
  9.96197835e-02f, 1.12026997e-01f, 4.41195592e-02f, 8.42693448e-02f, 1.35927558e-01f, -2.73332428e-02f, -3.61881256e-02f, 2.76333075e-02f, 3.31228599e-02f, 1.64741650e-01f,
  -2.04609692e-01f, 1.39521673e-01f, 6.51496276e-02f, -8.02810937e-02f, -1.34407461e-01f, -1.11548558e-01f, 8.20444599e-02f, -1.82181820e-01f, 1.18755594e-01f, 2.23797187e-01f,
  4.33843099e-02f, -1.31310523e-01f, 8.61594528e-02f, 2.56451853e-02f, 1.88245680e-02f, -1.20509990e-01f, -1.16229624e-01f, -5.82679585e-02f, 9.62322280e-02f, -2.91411038e-02f,
  -1.27109557e-01f, -6.92159981e-02f, -4.59307581e-02f, 1.39274985e-01f, -8.34851861e-02f, 1.20025858e-01f, 1.09993934e-03f, 1.77147686e-01f, 5.85019402e-02f, -7.48290122e-02f,
  1.76933199e-01f, -2.41274610e-01f, -3.92824262e-02f, -1.15110509e-01f, 3.83697629e-01f, -1.34059014e-02f, -1.48353428e-01f, 1.48423105e-01f, -1.12408936e-01f, -9.49021280e-02f,
  1.48931235e-01f, -1.68526024e-01f, 1.70928374e-01f, -1.52341112e-01f, 3.84036973e-02f, -1.03743814e-01f, 2.15590596e-01f, 2.48020422e-03f, 1.17355227e-01f, -2.76235938e-01f,
  7.21552670e-02f, -7.06630796e-02f, 8.72767493e-02f, 3.26604024e-02f, 1.73140280e-02f, -2.81588703e-01f, 2.31707357e-02f, 1.26751438e-01f, 2.22983718e-01f, 1.84451297e-01f,
  4.14653905e-02f, -1.20483682e-01f, -2.11695388e-01f, 1.07754059e-01f, 2.05211848e-01f, 8.36155489e-02f, 9.43751559e-02f, -1.06224716e-01f, -9.84868705e-02f, -2.69922689e-02f,
  2.20549032e-02f, -1.98596671e-01f, -6.61036596e-02f, 2.21209377e-02f, 6.53226897e-02f, -1.34505779e-01f, -3.39416526e-02f, 2.83829961e-02f, 6.99094683e-03f, -7.34764570e-03f,
  5.30119948e-02f, -1.10510938e-01f, -3.03329825e-02f, -2.00267762e-01f, -3.99198644e-02f, 3.75053808e-02f, -3.56547274e-02f, -2.36136056e-02f, 1.05160922e-01f, -2.12636948e-01f,
  -2.42059585e-02f, 6.94810152e-02f, 1.81188866e-01f, -8.92468542e-02f, -3.79244611e-02f, 1.48300007e-01f, 1.83080420e-01f, 4.61111218e-02f, -6.70654839e-03f, -2.29779139e-01f,
  5.66014973e-03f, -3.64426002e-02f, -1.52500212e-01f, 2.21990291e-02f, -1.87016919e-01f, 2.94043899e-01f, -1.66935533e-01f, -1.55572280e-01f, 4.05776687e-02f, -4.54818010e-02f,
  -1.87989026e-01f, 8.83544236e-02f, 2.34972298e-01f, -7.93205500e-02f, 5.08493371e-02f, 2.71560848e-01f, -1.85638040e-01f, 1.38584375e-01f, 2.41713896e-01f, 1.49586424e-01f,
  -6.27198815e-02f, 1.80465937e-01f, 2.17363834e-01f, 2.23027989e-01f, 2.21289873e-01f, 1.47507444e-01f, -4.04201681e-03f, -8.37509483e-02f, 7.01464117e-02f, 4.86478359e-02f,
  3.29633832e-01f, -2.06694171e-01f, 7.61455670e-02f, 4.19041626e-02f, 1.15062796e-01f, -6.24197721e-02f, 8.90707150e-02f, -6.40240461e-02f, 6.72059357e-02f, 4.60001007e-02f,
  5.48871830e-02f, 5.84816784e-02f, -1.25376135e-01f, 9.59144458e-02f, -1.11122623e-01f, -4.23639603e-02f, -3.65250334e-02f, 6.76091313e-02f, 1.57193770e-03f, -1.17616132e-01f,
  5.80408759e-02f, -1.34610504e-01f, 1.57546788e-01f, 1.41971791e-02f, -1.17961176e-01f, 2.02618122e-01f, -2.32547283e-01f, -1.33602738e-01f, -6.50397316e-02f, -2.61055641e-02f,
  -5.83736822e-02f, 5.91028146e-02f, -7.77913854e-02f, 7.75413681e-03f, 1.97369568e-02f, -1.44213215e-01f, -9.45030674e-02f, 1.76555395e-01f, 3.75524303e-03f, 3.13247629e-02f,
  -1.12459123e-01f, 8.44108537e-02f, -2.28326306e-01f, -8.33395571e-02f, -2.03604504e-01f, -4.50459123e-02f, 1.09638192e-01f, 7.56000057e-02f, -2.39646509e-01f, -1.50627732e-01f,
  -6.32355437e-02f, -9.65464264e-02f, 1.19053096e-01f, 2.42975071e-01f, -3.22629511e-03f, -4.05314639e-02f, 7.75636062e-02f, -1.74838841e-01f, 8.34508017e-02f, -2.21186072e-01f,
  -5.33169620e-02f, -2.61925384e-02f, 5.50457276e-02f, -1.15319947e-02f, -3.59495491e-01f, 1.00332715e-01f, -2.19553858e-01f, -1.66835576e-01f, 2.77939975e-01f, 1.83334649e-01f,
  8.34030733e-02f, 6.34647980e-02f, -1.52941942e-01f, 7.86088780e-02f, -5.03277369e-02f, 9.81278345e-03f, 8.33793804e-02f, 3.18187922e-02f, -2.21833531e-02f, -5.74479327e-02f,
  -9.61518958e-02f, 6.27625883e-02f, -2.58325841e-02f, -4.08488363e-02f, -1.27997398e-01f, -2.01752424e-01f, -5.91287613e-02f, 2.05194697e-01f, -1.33746877e-01f, -2.67147452e-01f,
  1.58736944e-01f, -9.79840308e-02f, 1.71673462e-01f, 5.38727418e-02f, 1.67322770e-01f, -3.10953427e-02f, 2.32853085e-01f, -2.12694779e-02f, 3.22346270e-01f, -2.78081596e-01f,
  5.43974107e-03f, -2.30232831e-02f, -1.04889326e-01f, 1.58066470e-02f, -3.10674071e-01f, 8.80250782e-02f, -8.85166228e-03f, -3.63229305e-01f, 1.65486559e-01f, 1.45218587e-02f,
  3.53712626e-02f, 2.32892603e-01f, -1.46501333e-01f, 1.34929776e-01f, 4.76026088e-02f, 2.18976624e-02f, -2.37743035e-01f, -2.49305610e-02f, -8.78788084e-02f, -9.01220515e-02f,
  -3.59564796e-02f, -2.80685604e-01f, 1.25808865e-01f, 2.19938755e-01f, 2.42258281e-01f, 8.34202468e-02f, -1.82620913e-01f, 1.94410935e-01f, -1.14417084e-01f, 1.87056720e-01f,
  -1.49243876e-01f, 2.07557857e-01f, -1.92873895e-01f, -1.33779526e-01f, 8.25041756e-02f, 1.01602934e-01f, 1.96809433e-02f, -3.32376778e-01f, -1.14390105e-01f, 6.17807545e-02f,
  -1.25499934e-01f, -9.21110213e-02f, 2.52017230e-02f, -1.79705322e-02f, -1.83674335e-01f, -2.03398645e-01f, -8.49152207e-02f, 4.77686077e-02f, -5.32377325e-02f, 1.06595613e-01f,
  1.14326999e-01f, -4.88199070e-02f, -7.10842460e-02f, -2.56641451e-02f, 1.07890248e-01f, -1.88057393e-01f, 1.36502728e-01f, -2.91230017e-03f, 2.04383969e-01f, -2.76497472e-03f,
  1.54039621e-01f, -2.71301180e-01f, -2.35979483e-02f, 1.29121048e-02f, -7.23739937e-02f, 1.29114464e-01f, -1.29794389e-01f, 7.90536106e-02f, -6.55421466e-02f, 4.55222651e-03f,
  6.80175647e-02f, 5.61965397e-03f, -1.02509297e-01f, 1.16616577e-01f, 1.28144294e-01f, -2.46948615e-01f, -1.91358715e-01f, 4.40219939e-02f, -9.47864577e-02f, 4.91548069e-02f,
  1.76087633e-01f, -1.05879463e-01f, -2.54859924e-01f, 1.11667886e-01f, 2.14505687e-01f, 1.37587383e-01f, 1.41960844e-01f, 1.40554592e-01f, 8.04550499e-02f, -9.24867243e-02f,
  8.36822018e-02f, -1.16508439e-01f, -7.22878277e-02f, 3.09974551e-02f, -1.57198668e-01f, -1.15988173e-01f, 5.19655831e-02f, -1.67682782e-01f, -1.77168623e-01f, 5.65881319e-02f,
  7.75880143e-02f, -1.83474794e-01f, -1.09972961e-01f, -2.46755593e-02f, 4.98209745e-02f, 8.93581137e-02f, -1.41156793e-01f, 1.76591519e-02f, -1.83256999e-01f, 1.32466468e-03f,
  1.03248149e-01f, -8.74714181e-02f, -2.23808095e-01f, -1.13612257e-01f, -1.30363539e-01f, 2.46030446e-02f, 8.10487568e-03f, -1.44213969e-02f, 1.22163504e-01f, -3.43990438e-02f,
  4.43531126e-02f, 7.83965662e-02f, 2.09506124e-01f, 1.76558241e-01f, 1.57113448e-01f, -2.03721747e-01f, -1.46156633e-02f, 1.77584618e-01f, -1.64727032e-01f, 1.45775244e-01f,
  -1.51850075e-01f, 2.31641665e-04f, -1.45289302e-01f, -1.69476390e-01f, 1.28500178e-01f, -7.77739063e-02f, -2.16131762e-01f, 2.32779756e-01f, 2.26967707e-01f, 9.36028585e-02f,
  1.46509185e-01f, 1.30969733e-01f, -1.59237504e-01f, 1.73084334e-01f, 9.52245519e-02f, 5.83985932e-02f, -1.72974199e-01f, 3.56111340e-02f, 1.83892921e-01f, 7.21633658e-02f,
  1.60403118e-01f, 6.57215789e-02f, -5.43017425e-02f, -4.31364998e-02f, 2.00309962e-01f, -2.63618939e-02f, 1.34438619e-01f, -1.93574801e-01f, -1.42748281e-01f, 8.81958529e-02f,
  -5.02169579e-02f, -2.30744392e-01f, -1.27732098e-01f, -1.14839576e-01f, 2.11518016e-02f, -8.50902125e-02f, -2.00259034e-02f, 1.51560232e-01f, 1.24814190e-01f, -7.95316398e-02f,
  1.52760729e-01f, -1.20644115e-01f, 1.50731549e-01f, -1.15044443e-02f, 6.23370409e-02f, 7.50529096e-02f, 5.74549139e-02f, 2.24716634e-01f, -1.45379245e-01f, -6.69476669e-03f,
  2.78679263e-02f, -7.60501763e-03f, 1.75727040e-01f, -4.25151810e-02f, 3.49787660e-02f, -7.56829744e-03f, -1.09340638e-01f, 1.39155984e-01f, 1.70896035e-02f, 3.85040455e-02f,
  -1.84050247e-01f, 1.31555587e-01f, 1.93396389e-01f, -7.18760565e-02f, 1.58704761e-02f, 7.29489625e-02f, 2.41886765e-01f, 1.83743805e-01f, 2.62482441e-03f, 2.25638196e-01f,
  1.31483108e-01f, -5.10337688e-02f, 3.81129384e-02f, -2.47404367e-01f, 9.29432437e-02f, 1.34198129e-01f, -6.62171245e-02f, 1.01206236e-01f, -2.02725232e-02f, -1.34243980e-01f,
  -1.31351084e-01f, 1.30326658e-01f, -3.25563215e-02f, 1.02724433e-01f, 1.47171468e-01f, 8.97634774e-02f, 1.97069466e-01f, -1.21688589e-01f, 1.76581025e-01f, -1.14959180e-01f,
  2.47133300e-01f, 1.39270537e-02f, -2.11305320e-02f, 1.95056990e-01f, -8.26162100e-02f, -1.97487563e-04f, 1.76339895e-01f, 1.34556115e-01f, -6.57063797e-02f, -1.44570246e-01f,
  -1.01108760e-01f, 2.86727976e-02f, 1.08572669e-01f, -2.04318047e-01f, 6.99918717e-02f, -1.60731435e-01f, 3.92446341e-03f, -4.21507955e-02f, -1.28842711e-01f, -6.75237626e-02f,
  2.71136835e-02f, -1.09450102e-01f, -9.41803455e-02f, 1.99918270e-01f, -1.96056500e-01f, -1.43999621e-01f, 1.45373255e-01f, -1.54370993e-01f, 1.65312365e-02f, -1.75034210e-01f,
  1.34478450e-01f, 1.22900829e-01f, 3.41864645e-01f, -3.26681808e-02f, 9.64868590e-02f, 2.10077256e-01f, -1.88171417e-01f, 7.67697766e-02f, -5.87230623e-02f, 5.63462302e-02f,
  1.76742822e-01f, 1.70110464e-01f, 4.78455191e-03f, -5.96312769e-02f, 1.72655880e-01f, 1.03883356e-01f, 3.05719357e-02f, -1.65269244e-02f, 1.26788497e-01f, 2.20257360e-02f,
  -1.21565953e-01f, -8.24058056e-03f, 1.28899887e-01f, -2.78976887e-01f, -3.41459252e-02f, 2.22118974e-01f, 2.99539417e-01f, 2.70834845e-02f, 8.81032199e-02f, -1.04051851e-01f,
  -6.44880384e-02f, 1.30583823e-01f, 3.11249971e-01f, -7.77084231e-02f, -4.23255563e-03f, -8.28267932e-02f, -1.80065513e-01f, 1.30978748e-01f, -2.21456096e-01f, -2.72705972e-01f,
  -1.61758631e-01f, -8.75598416e-02f, -2.35817842e-02f, 1.43781036e-01f, -9.29292440e-02f, 3.07585802e-02f, -1.52838910e-02f, -1.27221867e-01f, -2.60811616e-02f, 2.08429232e-01f,
  1.18431516e-01f, 8.38036612e-02f, 6.50062505e-03f, -2.61140224e-02f, 1.53507635e-01f, 8.05347264e-02f, -5.84760383e-02f, 2.81686452e-03f, 4.74007726e-02f, -1.76595934e-02f,
  -9.25328434e-02f, -1.15837818e-02f, 9.20544937e-02f, 2.26424951e-02f, -2.54878569e-02f, 2.00966597e-01f, -1.46552727e-01f, 6.48356900e-02f, 5.95357865e-02f, 2.44249478e-02f,
  5.34122437e-02f, 2.39561108e-04f, 1.68245599e-01f, -1.62773021e-02f, 1.20338961e-01f, 2.59622902e-01f, -1.09469548e-01f, 1.35508090e-01f, -2.66254432e-02f, -1.51715100e-01f,
  -2.89875209e-01f, -1.51180461e-01f, 5.60406744e-02f, 4.44245785e-02f, 1.85094863e-01f, 7.70650804e-02f, 2.16893733e-01f, -5.42482547e-02f, 1.64985680e-03f, -1.14480220e-01f,
  -3.17119323e-02f, -7.91930109e-02f, 1.70966610e-01f, 2.90300101e-01f, 2.25863531e-01f, -2.98044711e-01f, 9.67191234e-02f, -2.63082236e-01f, -2.44118065e-01f, -1.33123666e-01f,
  -1.32297233e-01f, -2.89588645e-02f, 1.27711236e-01f, -1.65023252e-01f, -3.11897928e-03f, 1.30434439e-01f, -3.62971611e-02f, -2.18313962e-01f, -5.97523488e-02f, 9.17300507e-02f,
  -4.06633392e-02f, -6.22108355e-02f, -3.56918722e-02f, -1.11010931e-01f, 4.39655297e-02f, -1.49944112e-01f, -2.18620524e-02f, 7.44389370e-02f, 2.48642843e-02f, 9.92069095e-02f,
  -6.14042729e-05f, -9.04534087e-02f, -1.83368623e-01f, -4.20166366e-02f, 3.04926962e-01f, -5.13513237e-02f, 7.86698908e-02f, 1.57060787e-01f, 1.60310015e-01f, 7.85796866e-02f,
  2.50466615e-01f, -5.61827980e-02f, 1.09753855e-01f, 2.41060145e-02f, -3.67573574e-02f, 7.65846297e-02f, -1.53273344e-01f, 1.24904215e-01f, 6.67925971e-03f, -6.01654686e-02f,
  1.99490070e-01f, -3.22350226e-02f, 1.37889862e-01f, 1.65725216e-01f, 3.31705213e-02f, -2.40077719e-01f, 9.83352885e-02f, 7.87849575e-02f, -2.06594899e-01f, 8.86626616e-02f,
  9.85220298e-02f, -8.92357826e-02f, -2.40380839e-01f, 9.91161242e-02f, 1.72581896e-01f, 1.65526524e-01f, 1.12349324e-01f, 1.96843788e-01f, 7.20068589e-02f, -4.07260172e-02f,
  2.71665275e-01f, 2.36566346e-02f, 2.12628707e-01f, 1.30630240e-01f, -6.90701753e-02f, 6.34359568e-02f, 2.24538352e-02f, -1.81090906e-01f, 1.49624854e-01f, 5.93941882e-02f,
  1.96987260e-02f, 6.42567575e-02f, 1.07449636e-01f, -1.01516254e-01f, 1.05451807e-01f, 1.96311418e-02f, -6.50203377e-02f, 1.71686828e-01f, -3.46295093e-03f, 4.33640890e-02f,
  -7.80844167e-02f, -4.25149761e-02f, -7.94749483e-02f, 1.14611305e-01f, 3.97875570e-02f, 1.11258619e-01f, -9.68210399e-02f, 2.15420760e-02f, 4.64688726e-02f, -2.07172334e-02f,
  -1.73696384e-01f, -1.24087624e-01f, -1.58984900e-01f, 1.40602604e-01f, 1.11882679e-01f, 1.71861976e-01f, -1.06903389e-01f, 3.85199971e-02f, 9.98093784e-02f, -2.45032296e-01f,
  2.50825197e-01f, -1.40513033e-01f, 2.22684622e-01f, 1.03921250e-01f, 6.84553534e-02f, 3.08962981e-03f, 1.60149530e-01f, -7.36059099e-02f, -6.92403540e-02f, -1.52394384e-01f,
  -5.22837415e-02f, -1.88691676e-01f, 1.20081142e-01f, -1.14405237e-01f, -7.83050582e-02f, -6.72922507e-02f, -1.63247064e-01f, -6.24343194e-02f, 4.71576527e-02f, -5.21744080e-02f,
  1.02778740e-01f, -6.10013343e-02f, 2.30774134e-01f, -7.31579289e-02f, 1.31716490e-01f, -1.74133062e-01f, -3.41370732e-01f, 1.17186740e-01f, -8.27255920e-02f, 2.40765840e-01f,
  -6.34814203e-02f, 1.17581151e-01f, -4.06882130e-02f, 8.84187371e-02f, -1.26817077e-01f, -8.44609514e-02f, 8.58562738e-02f, 7.26650581e-02f, -4.31871898e-02f, 1.26377434e-01f,
  4.87008169e-02f, 5.41791916e-02f, -5.93632571e-02f, -1.53567955e-01f, -7.11455941e-02f, 4.42790315e-02f, -1.19637489e-01f, -1.25287130e-01f, 8.43662322e-02f, -1.25737369e-01f,
  -1.54967263e-01f, 2.18123898e-01f, -1.31978050e-01f, -1.17312223e-01f, 2.14383945e-01f, 3.17955157e-03f, 1.22669309e-01f, -3.97031344e-02f, -1.36026256e-02f, -2.72713989e-01f,
  -2.54447132e-01f, 1.48530588e-01f, -2.62073874e-01f, 7.64635280e-02f, -1.59661129e-01f, 2.62634516e-01f, -4.31304164e-02f, -2.90386528e-01f, -5.45563400e-02f, 5.48278876e-02f,
  -1.81557223e-01f, 2.97373563e-01f, 1.29470125e-01f, 1.41189452e-02f, -2.45420989e-02f, 1.39068484e-01f, -2.99311489e-01f, 5.94117120e-03f, 2.34542906e-01f, 3.11002195e-01f,
  -1.91500112e-01f, 1.72607780e-01f, 1.89388901e-01f, 2.77662635e-01f, -3.02353185e-02f, -1.34709671e-01f, -2.68958181e-01f, -8.84926226e-03f, 1.87863514e-01f, 1.31705925e-01f,
  2.77704358e-01f, -6.45992085e-02f, 1.35464240e-02f, -1.88246280e-01f, -2.64310762e-02f, -5.88158853e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.89659923e-01f, 1.79609835e-01f, 8.33349302e-02f, -1.22509472e-01f, 2.52539098e-01f, 1.99284792e-01f, 3.16548258e-01f, 2.11765483e-01f, 5.31480648e-02f, 8.02237093e-02f,
  1.25264615e-01f, -3.14058810e-02f, 2.05021575e-01f, 1.21191591e-01f, 8.28553140e-02f, 1.22474737e-01f, 8.75891522e-02f, -7.69447908e-02f, -8.21893513e-02f, -4.34565730e-02f,
  2.10324913e-01f, 8.29919055e-02f, -9.67094973e-02f, 1.46116734e-01f, 8.97261947e-02f, -1.72285154e-01f, -1.36638850e-01f, -2.76884913e-01f, -2.18370296e-02f, 6.79559112e-02f,
  -1.36124238e-01f, 1.00213781e-01f, -2.70726532e-01f, 2.61773199e-01f, -5.53517602e-02f, -9.32877958e-02f, 1.91816553e-01f, 6.99780043e-03f, -4.44819927e-02f, 2.76923537e-01f,
  1.10084534e-01f, -5.34214266e-02f, 2.15721697e-01f, 2.30496630e-01f, -2.75006056e-01f, 1.42103449e-01f, 2.19765350e-01f, 1.70391634e-01f, 6.79617748e-03f, 1.86941728e-01f,
  4.61789556e-02f, 1.32380605e-01f, 1.11216515e-01f, 3.80192399e-02f, 2.02570796e-01f, 1.91377793e-02f, 1.61541730e-01f, 1.41923711e-01f, 2.55170077e-01f, -1.51725739e-01f,
  -5.82173914e-02f, 1.67711258e-01f, -7.71930302e-03f, -1.79334462e-01f, 2.11946830e-01f, 2.75844246e-01f, 2.71463096e-01f, 3.84533972e-01f, 2.85611659e-01f, 2.47550353e-01f,
  8.53446275e-02f, 3.24629307e-01f, 2.57035792e-01f, -2.29775961e-02f, -9.30806771e-02f, 4.01924461e-01f, 2.83946455e-01f, 5.46224266e-02f, 2.02353299e-01f, -2.70411558e-02f,
  7.77828917e-02f, 1.35891065e-01f, 3.01184773e-01f, -3.69348228e-01f, 1.46945238e-01f, -6.73036203e-02f, 1.80362314e-01f, -6.28383234e-02f, -6.79702535e-02f, -2.22378626e-01f,
  -2.10158706e-01f, 1.55105665e-01f, 1.65961072e-01f, -2.80615926e-01f, -1.21298052e-01f, 2.78131455e-01f, -3.51767659e-01f, 1.49885967e-01f, -3.23783726e-01f, -3.89036275e-02f,
  -2.00790852e-01f, -1.58557996e-01f, 2.86818929e-02f, 1.06810080e-02f, 2.17688307e-01f, 1.83318481e-01f, -2.24463806e-01f, 1.37154743e-01f, 1.28990158e-01f, 1.88991383e-01f,
  -1.22584105e-01f, 1.45303667e-01f, 2.99094647e-01f, 1.44678712e-01f, 1.84936702e-01f, -1.35297775e-01f, -1.09579504e-01f, 3.05064190e-02f, 2.04406641e-02f, 3.31593663e-01f,
  -2.60543317e-01f, 1.74094275e-01f, -2.51977265e-01f, 1.17716696e-02f, -4.05929796e-03f, -8.05003569e-02f, 2.86699384e-01f, 5.81870414e-02f, 3.39268208e-01f, 9.20524374e-02f,
  1.85240149e-01f, -7.77759850e-02f, 3.02131712e-01f, 1.66921169e-01f, 8.81723613e-02f, 2.60326862e-01f, 8.63412917e-02f, 7.55463019e-02f, 1.32409424e-01f, 9.74634439e-02f,
  7.59157687e-02f, 1.23247415e-01f, 2.64468223e-01f, 1.71343550e-01f, 2.64378022e-02f, 1.92332730e-01f, 2.12761268e-01f, 1.85360104e-01f, 2.00558126e-01f, 1.73832193e-01f,
  -1.82464957e-01f, -3.41221616e-02f, -1.15439281e-01f, -1.97491825e-01f, 1.49100676e-01f, 1.12097329e-02f, -2.72820383e-01f, 4.41482365e-02f, -4.31449851e-03f, 2.62029860e-02f,
  -4.29499336e-02f, 9.35846791e-02f, 2.52005160e-01f, -1.03446446e-01f, 2.16856763e-01f, 1.73188910e-01f, 1.04644075e-01f, 1.77718416e-01f, 4.10621762e-02f, -4.14126247e-01f,
  1.69711992e-01f, 1.36490956e-01f, 5.72255366e-02f, -5.22499681e-02f, -3.09013259e-02f, -2.81232651e-02f, 1.25108883e-01f, 3.09704125e-01f, 1.94771633e-01f, 2.45160818e-01f,
  1.19052514e-01f, -1.58037126e-01f, -1.65642038e-01f, 2.42277741e-01f, 1.83589216e-02f, 8.27200897e-03f, 3.89689744e-01f, -4.29038778e-02f, 3.15248758e-01f, 1.08767144e-01f,
  2.66585469e-01f, 1.64833944e-02f, 2.27981433e-01f, -1.49972856e-01f, 1.28046125e-01f, -1.72370642e-01f, 1.03864685e-01f, -4.12468240e-03f, 2.52213150e-01f, 6.37064874e-02f,
  1.17524765e-01f, 1.22611359e-01f, 1.49468049e-01f, -2.62982219e-01f, 2.11307898e-01f, 5.06950170e-02f, 1.70803368e-01f, 1.79750577e-01f, -8.42052922e-02f, -2.53337342e-02f,
  -6.07807264e-02f, 3.45959663e-02f, 3.36097360e-01f, 2.53245860e-01f, -3.22268128e-01f, 1.23984918e-01f, 6.34089559e-02f, -9.21931863e-02f, -1.48482919e-01f, -7.94962123e-02f,
  -1.46628380e-01f, 5.16827554e-02f, 2.08956391e-01f, -1.37158662e-01f, -1.40149817e-01f, 2.95514494e-01f, 2.90736668e-02f, 1.91329613e-01f, 2.89953440e-01f, 2.38361791e-01f,
  -7.44534209e-02f, 1.06196731e-01f, 6.04606159e-02f, 5.80582814e-03f, 1.07912190e-01f, 5.59245385e-02f, -2.61179507e-01f, 7.38534937e-03f, -3.94641608e-01f, -5.77506833e-02f,
  9.71396221e-04f, 6.70768470e-02f, -2.17022523e-01f, 1.63437411e-01f, 6.83886856e-02f, 2.15766560e-02f, 4.32205945e-01f, -2.16039181e-01f, -2.26544827e-01f, 4.35568020e-02f,
  2.22356290e-01f, -2.13457942e-01f, 7.17371106e-02f, 1.60955653e-01f, 7.06124902e-02f, -3.91627997e-02f, -1.89723015e-01f, 2.86882091e-02f, 1.14695966e-01f, 1.74508333e-01f,
  -1.94105878e-01f, -7.08939210e-02f, 1.87411383e-01f, 1.43556520e-01f, 1.72639117e-01f, 7.04916343e-02f, -1.11002199e-01f, 2.21869610e-02f, 3.06275971e-02f, 6.08259998e-02f,
  -1.05733253e-01f, -8.27316195e-02f, -1.88099131e-01f, -1.00707687e-01f, 1.72275245e-01f, -2.93167472e-01f, 5.95666505e-02f, -1.31072793e-02f, -2.40664274e-01f, 1.95997626e-01f,
  3.83119509e-02f, 2.51669109e-01f, -1.90063819e-01f, 5.98643050e-02f, 1.81204349e-01f, 2.52570629e-01f, 3.14564258e-01f, 2.19555035e-01f, 1.23431988e-01f, -1.07555225e-01f,
  -5.08763492e-02f, -6.81060627e-02f, -1.01093806e-01f, 3.61856461e-01f, -2.28715450e-01f, 3.03150564e-02f, 1.07652890e-02f, -9.14470702e-02f, 1.27678841e-01f, 2.07301855e-01f,
  -2.34451517e-01f, 2.43085995e-01f, 1.94518194e-01f, -3.37718844e-01f, -3.17517715e-03f, 8.82194489e-02f, 2.88634468e-02f, -8.48999321e-02f, 1.11451648e-01f, 3.38138372e-01f,
  2.41265893e-01f, -5.82703874e-02f, 5.07907867e-02f, 1.15094617e-01f, 1.52476072e-01f, -1.65542308e-03f, 8.33187476e-02f, 2.26610363e-01f, -8.02602321e-02f, -9.01073590e-02f,
  1.04290582e-01f, -1.41767800e-01f, -5.69625236e-02f, 6.38255626e-02f, 1.32961571e-01f, 4.09709588e-02f, -7.51201510e-02f, 2.13275909e-01f, 1.58262804e-01f, 2.59245872e-01f,
  1.15941688e-01f, 1.16713196e-02f, 1.25798523e-01f, -4.94224839e-02f, 2.60349214e-01f, 1.02781959e-01f, 3.16342860e-01f, -1.18962020e-01f, 1.46896392e-01f, 3.19420636e-01f,
  -2.76855290e-01f, 9.67431813e-02f, -2.34888852e-01f, -1.89360723e-01f, -3.63361388e-01f, 1.42000616e-02f, -3.48061949e-01f, 6.85232058e-02f, -1.94860175e-01f, -8.80804434e-02f,
  5.44016473e-02f, -1.34700030e-01f, 3.41390371e-01f, -9.21168029e-02f, 1.23282939e-01f, -7.33020455e-02f, -1.33356169e-01f, 2.66692817e-01f, -6.78289682e-02f, -7.15609044e-02f,
  -1.53916553e-01f, 2.35642061e-01f, -9.41708386e-02f, -2.30244666e-01f, 2.82394644e-02f, -1.34388834e-01f, 2.41687953e-01f, 3.64420265e-02f, -8.29705745e-02f, -5.01221046e-02f,
  -4.60976250e-02f, -1.20392598e-01f, -7.74846002e-02f, -1.95619598e-01f, -2.56029695e-01f, -7.28770494e-02f, -2.20326722e-01f, 1.65436119e-02f, -8.83782469e-03f, 3.27005059e-01f,
  2.91751802e-01f, -3.42947632e-01f, 1.53682023e-01f, 4.36362118e-01f, 2.03732863e-01f, 5.49165383e-02f, 1.48573415e-02f, 4.14835699e-02f, 1.97535440e-01f, 2.43118498e-02f,
  3.09657883e-02f, 2.47595176e-01f, 2.66373098e-01f, 1.41168743e-01f, 1.51471719e-01f, -4.41031232e-02f, 2.22205147e-01f, 6.36170339e-03f, 1.15520276e-01f, 1.40638918e-01f,
  2.62592435e-01f, -1.14004888e-01f, 2.68226564e-01f, 3.09886664e-01f, -3.10921040e-03f, 2.79731721e-01f, -2.74392903e-01f, 9.98425782e-02f, -2.96615273e-01f, 3.34481820e-02f,
  -4.91158254e-02f, -1.14783101e-01f, -3.74180526e-01f, 1.70628905e-01f, 7.14357942e-02f, -2.14257419e-01f, 3.26775402e-01f, -1.13925755e-01f, 7.91340172e-02f, -2.53042936e-01f,
  2.70160109e-01f, 2.37402081e-01f, -1.51055962e-01f, 1.79369658e-01f, -1.24443777e-01f, -9.83260050e-02f, 1.15034245e-01f, 3.30131687e-02f, 5.70690930e-02f, -2.81599946e-02f,
  3.32142822e-02f, 1.63595736e-01f, 1.54207811e-01f, 5.15903421e-02f, 5.75930951e-03f, 1.60043776e-01f, 3.38397175e-02f, -1.37298793e-01f, -5.34695722e-02f, -1.71890497e-01f,
  1.13758594e-01f, -3.20490450e-02f, 1.87653452e-01f, 1.22266248e-01f, 1.84756562e-01f, -7.56280944e-02f, 2.43909955e-01f, 2.92392343e-01f, 1.35686100e-01f, 3.06880742e-01f,
  1.48381427e-01f, 2.61519104e-01f, 2.93445081e-01f, 2.65112996e-01f, 3.11965376e-01f, 1.79464996e-01f, 3.18142951e-01f, 2.20443174e-01f, 1.61107853e-01f, 1.87642694e-01f,
  1.50395066e-01f, 2.72711515e-01f, 1.32931247e-01f, -1.23262042e-04f, 3.78790289e-01f, 2.33540297e-01f, 7.98557103e-02f, 9.17815790e-02f, -1.76275522e-01f, -2.99527109e-01f,
  2.56032199e-01f, -1.63955033e-01f, -4.24672142e-02f, 1.48556605e-01f, 1.66250199e-01f, 1.87157124e-01f, 8.28019083e-02f, -4.91397902e-02f, -2.76203543e-01f, 7.89280906e-02f,
  1.16546050e-01f, 3.35757993e-02f, 8.32653698e-03f, 2.77554303e-01f, -1.45848304e-01f, -1.04195662e-01f, 3.08772564e-01f, 9.76377651e-02f, 7.11857155e-02f, 1.98810294e-01f,
  -1.07827768e-01f, 8.84581655e-02f, 2.52934128e-01f, 9.90351588e-02f, 2.85120517e-01f, 4.33154069e-02f, 1.09808788e-01f, 1.80150300e-01f, 1.48082465e-01f, 3.46874297e-02f,
  2.56740451e-01f, 1.64958209e-01f, 1.09965410e-02f, 1.24728218e-01f, 6.56430870e-02f, 9.92591754e-02f, -2.90589124e-01f, -3.43913846e-02f, -2.90647805e-01f, 3.23173287e-03f,
  5.21959625e-02f, 5.18513583e-02f, 1.21397786e-01f, -1.46275461e-02f, 1.40148737e-02f, -2.06549034e-01f, -6.48584142e-02f, 9.10523236e-02f, 1.56387761e-01f, -8.92168209e-02f,
  1.16366722e-01f, 1.74356595e-01f, -3.85446176e-02f, -2.20670313e-01f, -5.00713326e-02f, 9.25749987e-02f, 5.44120669e-02f, -1.10290321e-02f, 7.82505944e-02f, 1.73357710e-01f,
  -9.98447984e-02f, 5.74379042e-02f, 2.50334162e-02f, -4.96709906e-02f, 1.20580755e-01f, 1.08697452e-01f, 2.84507871e-01f, 2.78611749e-01f, 1.91394255e-01f, -2.53042907e-01f,
  1.24203367e-02f, 2.09564179e-01f, -1.44319847e-01f, -2.18110345e-02f, 1.45503640e-01f, 1.04307206e-02f, -1.21275522e-01f, 5.96486703e-02f, 3.43841058e-03f, -8.67267847e-02f,
  2.02224195e-01f, 1.13738492e-01f, 2.41020694e-02f, -2.22406462e-01f, -1.63533241e-01f, 1.61262468e-01f, 1.11521035e-01f, -5.45304604e-02f, 2.55957425e-01f, -4.91713732e-03f,
  -2.07053408e-01f, 3.50621305e-02f, 2.66843557e-01f, -1.83734242e-02f, 2.03033984e-01f, 1.97293818e-01f, 2.12326393e-01f, 3.04202642e-02f, 2.75176227e-01f, -5.82654588e-03f,
  -8.14099386e-02f, 2.04924438e-02f, -2.42972165e-01f, 8.60442370e-02f, -3.75943594e-02f, -1.90196320e-01f, 2.01075584e-01f, 3.12105063e-02f, 5.84243471e-03f, -5.16311033e-03f,
  2.57493585e-01f, -4.86945696e-02f, -8.92399698e-02f, 3.64635624e-02f, -6.18373370e-03f, 2.10969239e-01f, 1.34780616e-01f, -5.65308817e-02f, 9.85703841e-02f, 7.63701648e-02f,
  1.36985481e-01f, 1.91598430e-01f, 1.68438956e-01f, -2.03197509e-01f, 1.87299296e-01f, 1.65334538e-01f, 3.77402604e-02f, 2.78348416e-01f, -1.71042815e-01f, 2.68596262e-01f,
  -2.44107023e-02f, -1.77259833e-01f, -3.22606117e-02f, -2.27313519e-01f, -2.92209655e-01f, -2.40222048e-02f, 1.74522102e-01f, -4.99166586e-02f, 7.32594654e-02f, 1.24954470e-01f,
  -3.34211402e-02f, -2.94683784e-01f, 2.95005918e-01f, -5.82767650e-02f, -1.96167648e-01f, 1.85028598e-01f, 6.20500073e-02f, 1.07394150e-02f, 1.58534050e-01f, 7.76183829e-02f,
  -6.89298511e-02f, 1.19066527e-02f, -1.18361555e-01f, 4.31465924e-01f, 1.62836149e-01f, 1.48516491e-01f, 5.50676510e-02f, 3.53663159e-03f, -2.63574302e-01f, -1.01427086e-01f,
  -8.90540183e-02f, -1.50039002e-01f, -2.04337761e-01f, 3.51439491e-02f, 2.97406077e-01f, 4.84840982e-02f, 4.00118440e-01f, 1.14538245e-01f, 2.04156771e-01f, 2.13278811e-02f,
  2.43875816e-01f, 2.79449731e-01f, 2.35998631e-01f, 1.29802860e-02f, 2.62446642e-01f, 6.51261061e-02f, 1.75500393e-01f, 1.72688082e-01f, 1.30971923e-01f, -3.09700668e-02f,
  2.62114406e-01f, 2.17451826e-01f, 7.13091437e-03f, 1.23914987e-01f, 2.53249556e-01f, 1.87076017e-01f, 1.98767766e-01f, 1.47942007e-01f, 1.67266056e-01f, -4.23969068e-02f,
  2.16088474e-01f, 1.18167931e-02f, -2.00550586e-01f, -9.82746631e-02f, 7.74270520e-02f, -1.37397051e-01f, 3.06050032e-01f, 9.99437552e-03f, -2.15662271e-01f, 6.71067238e-02f,
  1.51421805e-03f, -4.94344719e-02f, -5.60176596e-02f, 4.50482778e-03f, 2.59255230e-01f, -2.41844639e-01f, 1.82758272e-01f, 1.96041927e-01f, 8.29985738e-03f, 1.52771160e-01f,
  3.66524868e-02f, -2.49609426e-01f, 3.18611354e-01f, 1.58357888e-01f, 2.49810562e-01f, -2.46332828e-02f, 1.14418030e-01f, -2.26508632e-01f, -6.36177436e-02f, 2.64695227e-01f,
  2.50618964e-01f, 2.43081987e-01f, 1.27376288e-01f, -2.29206458e-02f, 5.46110235e-03f, 9.92833897e-02f, 3.14805359e-02f, 1.70677438e-01f, 3.46432477e-01f, -7.27706924e-02f,
  1.22804351e-01f, 3.34927231e-01f, 3.12480312e-02f, 1.21590711e-01f, 1.42415687e-01f, 1.59354389e-01f, 2.25748911e-01f, 1.17061570e-01f, 2.45193288e-01f, 3.17229450e-01f,
  3.72515589e-01f, 4.90742959e-02f, 1.77902922e-01f, 2.05054224e-01f, 3.05851936e-01f, 3.54189903e-01f, 2.70847261e-01f, 2.22836673e-01f, 1.42409295e-01f, 7.61118978e-02f,
  2.96043813e-01f, 3.20200592e-01f, 1.79317400e-01f, -4.56899963e-02f, -6.18494861e-02f, -2.98682511e-01f, 8.00781623e-02f, -2.09335059e-01f, 6.70795888e-02f, 2.49007016e-01f,
  2.22384483e-01f, 1.70892835e-01f, 1.85500353e-03f, 1.34032890e-01f, -2.29228348e-01f, -7.38481879e-02f, 2.55953789e-01f, -2.16303289e-01f, 3.40785444e-01f, 1.14125751e-01f,
  -2.42601663e-01f, 2.03111902e-01f, 3.54491621e-01f, 6.01414070e-02f, -8.63608867e-02f, -3.90426330e-02f, 2.25089230e-02f, 1.64835826e-01f, 3.67011279e-01f, 1.81331187e-01f,
  3.07260126e-01f, -2.38011494e-01f, 1.09331034e-01f, 1.94617257e-01f, 1.53898224e-01f, 1.34616882e-01f, 1.91128805e-01f, 1.93215892e-01f, 4.80994172e-02f, -2.44228845e-03f,
  3.04882765e-01f, 3.08356453e-02f, -1.04931131e-01f, -3.19601707e-02f, -8.03591684e-02f, 2.70046562e-01f, -3.74290943e-02f, 2.90024951e-02f, -1.10611536e-01f, 1.96179792e-01f,
  1.06162988e-01f, 5.73857203e-02f, -7.09464177e-02f, 1.27713720e-03f, 1.95308179e-02f, 1.85037792e-01f, 6.35481179e-02f, -5.69261760e-02f, -4.04757150e-02f, -7.33975545e-02f,
  1.56595320e-01f, 2.64149547e-01f, -6.03279006e-03f, 1.59399807e-01f, 1.56637192e-01f, 8.01493227e-02f, -2.06731237e-03f, 8.05008039e-02f, -9.34315696e-02f, -8.59619752e-02f,
  1.74476922e-01f, 4.15863506e-02f, 2.43351787e-01f, 1.10488065e-01f, -3.11849974e-02f, -2.10522860e-01f, -5.50678782e-02f, 2.22471938e-01f, -1.51421279e-01f, 1.36679247e-01f,
  -3.83994691e-02f, 8.73673521e-03f, 4.62852530e-02f, 2.68096151e-03f, -1.57995403e-01f, 2.29938999e-01f, -7.65713602e-02f, 1.74787566e-01f, 9.97766405e-02f, -3.67750466e-01f,
  2.12882131e-01f, 2.25185841e-01f, -1.12913318e-01f, 1.50295645e-01f, 3.50438803e-01f, -1.45932376e-01f, -2.25546986e-01f, 1.43045768e-01f, 3.02411288e-01f, 1.49857849e-01f,
  2.06109434e-01f, 2.70224750e-01f, 7.63009787e-02f, -2.25560293e-01f, 3.66325796e-01f, -1.13951531e-03f, 1.41987368e-01f, -5.00129089e-02f, -1.36280447e-01f, -1.11410700e-01f,
  -1.66882470e-01f, -2.69466192e-01f, 5.25812469e-02f, -3.36444490e-02f, -4.36640680e-02f, -1.43240452e-01f, 2.97537446e-01f, 2.08840314e-02f, 1.10793680e-01f, 2.19072625e-01f,
  1.12248689e-01f, 1.98997214e-01f, 2.62040824e-01f, -3.01020831e-01f, 2.52628833e-01f, 1.17776655e-01f, 1.75713718e-01f, 2.65377939e-01f, 1.51804104e-01f, 5.61471805e-02f,
  1.21207386e-01f, 2.23073572e-01f, -4.39677387e-03f, 6.93141073e-02f, -6.33227453e-02f, -6.19674288e-02f, -1.73560664e-01f, 1.86971426e-01f, 1.93026572e-01f, -1.84694141e-01f,
  -3.00486773e-01f, 2.01403201e-01f, 1.97594211e-01f, -4.08044130e-01f, 1.80699602e-01f, -1.93509370e-01f, 1.45401061e-01f, 1.49185434e-01f, 3.14289719e-01f, 7.83654749e-02f,
  2.86940150e-02f, 1.39466226e-01f, -1.59411088e-01f, 1.25579819e-01f, 1.05056360e-01f, 1.71979845e-01f, 9.66895558e-03f, -1.26551032e-01f, 3.17889452e-02f, -1.44595444e-01f,
  -1.01081938e-01f, -2.27316152e-02f, 7.57369846e-02f, 2.22550109e-01f, 1.66361153e-01f, 4.38966975e-02f, 3.83742064e-01f, -1.73812702e-01f, 1.90036640e-01f, -1.61395609e-01f,
  -4.30324022e-03f, 4.03798580e-01f, 3.19099963e-01f, 2.42064565e-01f, -1.17001414e-01f, 2.40652710e-01f, 1.58880189e-01f, 2.22763598e-01f, 5.26803210e-02f, 2.73284495e-01f,
  8.49051923e-02f, 1.90832466e-01f, 1.10352598e-01f, -2.14487314e-03f, 2.36683533e-01f, 1.99381575e-01f, 2.17570081e-01f, 3.08570862e-01f, 9.07890946e-02f, 6.98706582e-02f,
  1.88460872e-01f, 1.10714115e-01f, 1.07447490e-01f, 3.45975161e-01f, 2.46023834e-01f, -7.91416094e-02f, -2.44647622e-01f, -1.41620055e-01f, 3.67813632e-02f, -1.95751205e-01f,
  -3.17320079e-02f, 1.62955850e-01f, 1.57041013e-01f, 3.36503386e-01f, 2.06794053e-01f, -1.17283724e-01f, -8.55209082e-02f, -7.44678974e-02f, 3.17581624e-01f, -3.56316477e-01f,
  1.06996298e-01f, 1.64170459e-01f, -1.17039241e-01f, -9.91298875e-05f, 1.49217919e-01f, -2.51435161e-01f, -1.30786255e-01f, 2.51139700e-01f, -8.94847661e-02f, -2.44473163e-02f,
  3.09168786e-01f, -1.10896230e-01f, -5.08880205e-02f, 4.80634347e-02f, 6.84790909e-02f, -1.57193854e-01f, -1.54498577e-01f, -1.10550895e-01f, 1.93754863e-02f, 2.60812759e-01f,
  8.46831053e-02f, 8.38704631e-02f, 1.63838655e-01f, 5.69004565e-03f, -2.24180743e-01f, 3.63656402e-01f, 1.60684213e-01f, 2.28872180e-01f, -1.68060049e-01f, 2.90848881e-01f,
  9.17010158e-02f, -3.40351723e-02f, 8.56153145e-02f, 1.81429759e-01f, 3.06755751e-01f, 1.32597849e-01f, 1.12643145e-01f, 3.13884586e-01f, 5.94844446e-02f, 2.16421559e-01f,
  1.02008455e-01f, 4.24536616e-02f, 1.01913549e-01f, 2.82847136e-01f, 1.78728729e-01f, 2.32863933e-01f, 5.48263229e-02f, -8.50476474e-02f, 7.22437873e-02f, 9.71591379e-03f,
  5.65680414e-02f, 2.72493809e-01f, -2.81801403e-01f, 2.14716241e-01f, -7.62985796e-02f, -1.44198686e-01f, -2.40441456e-01f, -3.71880978e-02f, -1.06699495e-02f, -1.83747664e-01f,
  2.12888598e-01f, 5.11442423e-02f, -2.11558595e-01f, 2.76932359e-01f, -4.41800393e-02f, -2.19353542e-01f, 2.34030321e-01f, 1.11468375e-01f, -7.35976398e-02f, -5.23427501e-02f,
  5.40415458e-02f, -8.68760794e-03f, 1.32181913e-01f, -3.65516148e-03f, 3.70483212e-02f, 1.82659119e-01f, -1.85431838e-01f, 3.10004652e-01f, 1.66469455e-01f, 1.63826108e-01f,
  -2.40312710e-01f, 5.59068546e-02f, -8.68840516e-02f, -6.66707903e-02f, 6.73847646e-02f, 1.09800376e-01f, -3.43729973e-01f, 2.49655083e-01f, 3.62135172e-01f, -5.18057309e-02f,
  4.59168524e-01f, 3.15681621e-02f, 4.50492501e-01f, 1.72375500e-01f, 2.68510729e-01f, 1.08862400e-01f, 9.81596764e-03f, -9.84632522e-02f, 2.70482302e-01f, -1.14992307e-03f,
  2.03851089e-01f, 1.03695355e-02f, -4.54309843e-02f, 1.36856316e-02f, 6.21773042e-02f, -1.11019850e-01f, 1.45271784e-02f, 1.75465047e-01f, -1.61303654e-02f, 6.38738871e-02f,
  1.77013427e-01f, 1.00220397e-01f, -2.99934540e-02f, 1.97683409e-01f, 4.77661267e-02f, -1.13728881e-01f, 2.39607379e-01f, -8.48988965e-02f, 2.67797470e-01f, -1.55660465e-01f,
  1.65603459e-01f, -3.04282933e-01f, -1.21468179e-01f, 1.37432173e-01f, -4.06280935e-01f, 1.72904670e-01f, -3.20345104e-01f, 3.43433380e-01f, 5.45669831e-02f, -1.20380513e-01f,
  -2.46755704e-02f, -1.40325055e-01f, 3.05132614e-03f, 3.65358233e-01f, 1.14212349e-01f, 1.35455236e-01f, 1.52590215e-01f, 1.67961001e-01f, -3.09624076e-01f, 8.31062794e-02f,
  3.19259495e-01f, 1.17324449e-01f, -1.89519376e-01f, 1.21900380e-01f, 3.13895106e-01f, 1.82155818e-01f, 1.35757759e-01f, -2.06670836e-01f, -1.08338155e-01f, 1.78010926e-01f,
  2.24005833e-01f, 2.12609559e-01f, -3.51699628e-02f, -1.33493230e-01f, -2.27960303e-01f, 7.32361227e-02f, -4.66850922e-02f, -2.32386544e-01f, 1.76254228e-01f, 2.51788437e-01f,
  1.80711821e-01f, 2.28142381e-01f, 1.96333587e-01f, 1.47974700e-01f, 2.02030271e-01f, 1.55446688e-02f, 3.02890718e-01f, 2.40923956e-01f, 1.40980527e-01f, 3.84037703e-01f,
  1.02129243e-01f, 1.81481823e-01f, 3.77511501e-01f, 7.25173205e-02f, 2.71014392e-01f, 2.68032372e-01f, 3.12316507e-01f, -1.47099823e-01f, 2.68814433e-02f, -2.68598497e-01f,
  -7.36610740e-02f, -1.77609637e-01f, -1.33090422e-01f, 7.46242562e-03f, 1.96305409e-01f, 3.19914609e-01f, 2.62205839e-01f, 1.04809022e-02f, -1.03098281e-01f, 3.20226401e-02f,
  2.64306605e-01f, -9.84958410e-02f, 3.86018567e-02f, 3.42507690e-01f, -1.65518895e-01f, 7.83172995e-02f, 2.98649698e-01f, -1.52705073e-01f, 2.10647136e-02f, -1.32030547e-01f,
  6.49800450e-02f, 4.81660776e-02f, 2.58473098e-01f, 1.31458208e-01f, 7.93530941e-02f, -1.14263453e-01f, 2.11123958e-01f, 6.73757717e-02f, 2.00482026e-01f, -4.87658978e-02f,
  2.58665830e-01f, 1.18849806e-01f, 2.65854746e-01f, 2.12953821e-01f, 2.19800323e-02f, 2.38463581e-02f, -1.62605643e-01f, -1.16207734e-01f, -2.21932054e-01f, 2.98119962e-01f,
  2.26988554e-01f, -1.74972042e-01f, 2.28610471e-01f, 1.82421342e-01f, 3.21260780e-01f, 7.91162774e-02f, 3.03890258e-01f, 1.69100791e-01f, 2.37233952e-01f, 1.67682737e-01f,
  1.55148700e-01f, 1.74898550e-01f, 3.04066122e-01f, -4.18189280e-02f, 1.98384747e-01f, 5.89453951e-02f, 2.72756040e-01f, 2.60292202e-01f, 2.47285843e-01f, -5.96072944e-03f,
  -2.74848915e-03f, 5.31383045e-02f, 4.49696593e-02f, -6.52153045e-02f, 9.54830945e-02f, -1.53582111e-01f, 3.48776355e-02f, -1.04986534e-01f, 1.46379501e-01f, -2.99251080e-02f,
  -1.84374005e-01f, 3.53440829e-02f, -2.84690380e-01f, 1.58849135e-01f, -8.04245323e-02f, 7.03385398e-02f, 2.83423126e-01f, -1.77962139e-01f, 2.00671405e-01f, 5.23490869e-02f,
  4.51684594e-02f, 1.18808553e-01f, 2.64474273e-01f, -2.66666591e-01f, 1.54774487e-01f, -4.06363942e-02f, 2.04708874e-02f, 5.28464280e-02f, 1.90201849e-01f, 4.38865758e-02f,
  2.20457211e-01f, 3.58763218e-01f, 2.88773268e-01f, 1.75299793e-01f, 5.69630228e-02f, -2.43187338e-01f, -9.79124978e-02f, 2.47438133e-01f, -3.06308530e-02f, 8.72606784e-02f,
  1.27942100e-01f, -1.55040622e-01f, 7.01306537e-02f, -5.94174629e-03f, 2.14450508e-01f, -1.04750663e-01f, -1.72074847e-02f, 8.85069892e-02f, 2.20584586e-01f, 1.58401415e-01f,
  1.00956112e-01f, 2.13976309e-01f, 3.00376713e-01f, 2.73752779e-01f, 1.45131037e-01f, 3.27821597e-02f, 7.84765556e-02f, 3.43863785e-01f, 1.70693234e-01f, 2.12376818e-01f,
  6.13775365e-02f, -1.75220929e-02f, 2.81391181e-02f, 1.90108597e-01f, 1.26916870e-01f, -3.67280394e-01f, 2.29998991e-01f, -1.84036829e-02f, -9.78804566e-03f, 1.43531010e-01f,
  8.93193260e-02f, -1.31311104e-01f, -6.42622635e-02f, -9.34348442e-03f, 2.30259821e-01f, -2.00975612e-01f, -4.75596599e-02f, 2.30672717e-01f, -2.32462212e-01f, 4.55400907e-02f,
  -1.20795175e-01f, 9.88064334e-02f, -1.16474982e-02f, 1.39620095e-01f, 5.71784861e-02f, 7.56421462e-02f, 1.50029600e-01f, 1.99820265e-01f, 1.34972498e-01f, 7.95420110e-02f,
  -1.47135183e-01f, 2.44890749e-01f, -4.06281948e-02f, -8.28275904e-02f, 2.79103428e-01f, 2.03929007e-01f, 4.56323996e-02f, 6.64455444e-02f, 1.23846509e-01f, 2.30167851e-01f,
  2.05782995e-01f, 3.00406456e-01f, -9.13864002e-02f, 1.83700219e-01f, 1.61684975e-01f, -2.14352086e-01f, -9.10864100e-02f, 3.32289994e-01f, -4.95954119e-02f, 1.79539546e-02f,
  -2.19499152e-02f, 2.25921184e-01f, 3.60871404e-02f, 9.29023325e-02f, -1.59694016e-01f, 5.14189713e-02f, -3.38768959e-02f, 1.48820370e-01f, -2.11122204e-02f, -7.36244172e-02f,
  -1.37989596e-01f, 1.25858769e-01f, 1.57620221e-01f, -9.36575513e-03f, -6.97420016e-02f, 1.03916973e-01f, 6.16484173e-02f, 1.59717739e-01f, 1.47414282e-01f, -3.13677043e-01f,
  8.90843421e-02f, -1.76978126e-01f, 1.05602883e-01f, 1.74371190e-02f, 2.71546930e-01f, 1.44955650e-01f, 1.55577734e-01f, 1.70121863e-01f, 3.08685750e-01f, 1.30627230e-01f,
  -6.30290136e-02f, 2.56651968e-01f, -9.02058650e-03f, -1.11394249e-01f, -4.05241176e-02f, -1.48048438e-02f, -2.53143489e-01f, -1.18401863e-01f, 5.16285710e-02f, -8.19851756e-02f,
  1.53433815e-01f, -2.52070308e-01f, 1.30647495e-01f, 2.06613392e-01f, 1.41603783e-01f, 1.92627087e-01f, 1.04263179e-01f, -1.91939726e-01f, -1.81727245e-01f, -9.09140259e-02f,
  1.35216728e-01f, 5.15895803e-03f, 5.04297614e-02f, 2.82766581e-01f, 9.01913196e-02f, 1.42904118e-01f, -1.28386365e-02f, 1.32237762e-01f, 2.21561506e-01f, 7.11898431e-02f,
  1.31874159e-02f, 2.06531007e-02f, -1.10362424e-02f, -2.56418645e-01f, 1.25996530e-01f, -2.93126199e-02f, 1.19344041e-01f, -4.69984114e-02f, -1.62416103e-03f, 1.99111462e-01f,
  2.44382232e-01f, 9.93565321e-02f, 1.24041460e-01f, 1.42830566e-01f, 9.13266316e-02f, -9.10756364e-02f, 1.06324196e-01f, 3.42876874e-02f, 9.34134424e-02f, 1.62120014e-01f,
  1.69762790e-01f, 2.66656369e-01f, 1.16630182e-01f, -2.47588187e-01f, 1.31275088e-01f, 1.56201303e-01f, -2.52490014e-01f, 1.78838268e-01f, 1.27040699e-01f, 2.41655901e-01f,
  1.00122467e-01f, 1.07584342e-01f, 9.60736908e-03f, -2.05548108e-01f, 2.69348800e-01f, -1.84764892e-01f, -2.32607424e-01f, -1.31950267e-02f, -1.87399268e-01f, 4.04732168e-01f,
  9.11234617e-02f, 8.86349455e-02f, 1.40544370e-01f, -2.29503497e-01f, -1.68081790e-01f, 2.93131262e-01f, 8.14718902e-02f, -1.54826581e-01f, 1.29896268e-01f, 6.18489906e-02f,
  -4.50552702e-01f, -4.20979321e-01f, 7.29256421e-02f, -1.49072751e-01f, -1.82382002e-01f, -1.87917948e-01f, 4.38963175e-02f, 1.04082108e-01f, 4.18059438e-01f, -4.57486734e-02f,
  -1.50838792e-01f, -1.04572214e-01f, -2.80383408e-01f, 2.15796590e-01f, -1.00216933e-01f, 3.45749408e-01f, -7.72162080e-02f, 3.25583220e-02f, 2.79597223e-01f, 4.91329916e-02f,
  1.37362108e-01f, 2.62441248e-01f, 2.58860618e-01f, 7.79845491e-02f, 1.36112079e-01f, 2.87907600e-01f, 2.50734270e-01f, 8.41107368e-02f, 2.63611376e-01f, 2.44857505e-01f,
  1.13783382e-01f, 1.40952706e-01f, 2.40841091e-01f, 2.33877957e-01f, -2.99917869e-02f, -5.89216165e-02f, 6.71958625e-02f, 3.89351137e-02f, 1.41594991e-01f, 1.76931083e-01f,
  -3.05189639e-01f, 1.21960394e-01f, -2.04466224e-01f, -3.14079791e-01f, -3.04846704e-01f, -1.19140185e-01f, -1.25662863e-01f, -2.93448061e-01f, 2.36422896e-01f, 5.00449948e-02f,
  -4.36712876e-02f, 2.16216162e-01f, 5.27895913e-02f, -7.07693920e-02f, 2.60012776e-01f, 1.83407500e-01f, -2.09806815e-01f, 1.48570081e-02f, -3.30746695e-02f, 4.28904779e-02f,
  1.96458042e-01f, 6.79798722e-02f, 3.72078866e-02f, -2.82533914e-02f, -1.49092942e-01f, 4.22462583e-01f, 3.11342329e-01f, 2.33161137e-01f, -4.51412797e-03f, 2.64212787e-02f,
  -1.31014988e-01f, -1.49360567e-01f, 5.19351102e-02f, 2.27994025e-01f, -2.77923822e-01f, 2.76000470e-01f, 1.69257849e-01f, -3.00249636e-01f, 2.41605341e-01f, 2.18552262e-01f,
  2.89638102e-01f, -2.45547108e-02f, 2.31666923e-01f, 2.13164687e-01f, 8.87397230e-02f, 1.14756182e-01f, 3.87506694e-01f, 2.28014901e-01f, -4.76062074e-02f, 1.78502902e-01f,
  2.67424434e-01f, 1.73337340e-01f, 2.05698475e-01f, 5.52764833e-02f, 1.16052561e-01f, 9.43166092e-02f, 1.35135829e-01f, 1.87346369e-01f, 3.32023770e-01f, -2.44793613e-02f,
  1.45046279e-01f, 2.63332218e-01f, 1.42546341e-01f, 4.23634239e-02f, -3.38580646e-02f, 2.11426355e-02f, 2.22427454e-02f, -3.02735478e-01f, -1.20179303e-01f, -9.52178761e-02f,
  -4.21834253e-02f, -2.70073622e-01f, -1.56540334e-01f, 9.31690708e-02f, -1.95957258e-01f, 3.30676109e-01f, -8.49801078e-02f, -2.91380584e-01f, 8.23769644e-02f, -2.67615169e-01f,
  -1.46280825e-01f, 2.98858017e-01f, 2.90052861e-01f, -1.05785364e-02f, -2.78723329e-01f, -1.44792972e-02f, -2.73239929e-02f, 4.60327938e-02f, 1.87308326e-01f, 5.07475138e-01f,
  1.63891733e-01f, -1.12164570e-02f, 2.41114616e-01f, 1.53867647e-01f, 8.62587169e-02f, -2.21125543e-01f, -3.13372076e-01f, 2.00871751e-01f, 6.16410673e-02f, 2.17659622e-01f,
  -1.33594409e-01f, 1.80253163e-01f, 1.56196296e-01f, -3.94492000e-01f, 5.71488976e-01f, 1.81612581e-01f, -2.55224258e-01f, -2.41126735e-02f, -2.69126929e-02f, 4.71772105e-02f,
  -1.24978930e-01f, 1.32363707e-01f, 6.44401535e-02f, 1.40355706e-01f, 2.48059720e-01f, 1.56381950e-01f, 1.09999739e-02f, 8.96380469e-02f, 2.03345530e-02f, 1.81773230e-01f,
  1.79956809e-01f, 1.46565378e-01f, 1.61196291e-01f, 7.54033923e-02f, 7.00292215e-02f, 1.25283301e-01f, -3.98155928e-01f, -1.89357147e-01f, 1.93421468e-01f, 8.02901909e-02f,
  1.22485586e-01f, 2.66338229e-01f, -2.74913102e-01f, 8.11339319e-02f, -1.18900895e-01f, 1.56549960e-01f, -1.63068026e-01f, 2.21439600e-02f, 3.97197813e-01f, -3.03550333e-01f,
  -7.28391251e-03f, 5.69701679e-02f, -3.37857783e-01f, 1.96586043e-01f, 2.67013852e-02f, 1.12254821e-01f, -1.62155524e-01f, 1.37269437e-01f, 7.57914335e-02f, 2.57339805e-01f,
  1.69922058e-02f, -3.87776718e-02f, 3.99396807e-01f, -2.64320523e-01f, -8.33689943e-02f, -8.71628076e-02f, 2.27706879e-02f, 7.52780512e-02f, 2.03688934e-01f, 1.66031703e-01f,
  1.68038592e-01f, -4.53710228e-01f, 1.62230596e-01f, -3.89549732e-02f, 9.16863158e-02f, 4.69308980e-02f, -1.31313458e-01f, -4.77987202e-03f, -3.43484163e-01f, 3.74129951e-01f,
  1.40633866e-01f, -1.23232916e-01f, -2.44267862e-02f, 1.96910053e-02f, 2.18157366e-01f, 1.83173522e-01f, 1.26636147e-01f, 2.57277519e-01f, 2.04394788e-01f, 1.36980876e-01f,
  2.47868299e-01f, -1.78581968e-01f, 1.53649986e-01f, 1.32118925e-01f, 1.84797049e-01f, 1.94793150e-01f, 9.17880982e-02f, -6.74697086e-02f, 1.91111371e-01f, 1.04101218e-01f,
  2.56220818e-01f, 3.26550841e-01f, -3.00606102e-01f, 1.65176392e-01f, -1.18659303e-01f, 5.79594746e-02f, -1.12652984e-02f, 5.89859672e-02f, -1.85171098e-01f, -1.38537169e-01f,
  1.64581746e-01f, -2.71881819e-01f, -6.24579489e-02f, -9.60336924e-02f, 6.68548942e-02f, 4.84817289e-02f, 3.12773287e-01f, 9.49333310e-02f, -1.64204210e-01f, -1.91412136e-01f,
  -1.12394914e-01f, 9.12049264e-02f, 3.36608216e-02f, -1.13516524e-01f, 6.99860752e-02f, -7.10164458e-02f, -1.33786812e-01f, 8.55660141e-02f, 5.90318404e-02f, 3.83621790e-02f,
  -4.43408452e-02f, 6.01542108e-02f, -3.09815221e-02f, -9.07670259e-02f, 2.72324294e-01f, -3.25954407e-02f, -1.25000089e-01f, -1.06773295e-01f, -1.32210568e-01f, 3.07341158e-01f,
  2.25863338e-01f, 2.62901664e-01f, 2.72634160e-03f, 3.15066069e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.03078157e-01f, 1.43130139e-01f, 1.97196975e-01f, 2.24800631e-02f, 9.18227807e-02f, 5.94970137e-02f, 2.06579059e-01f, 3.11386764e-01f, -1.68676376e-02f, 1.75501823e-01f,
  1.11543842e-01f, 1.08160168e-01f, 5.53619042e-02f, 6.77303970e-02f, 1.11314811e-01f, 1.61360815e-01f, -2.08258871e-02f, 1.62668571e-01f, 2.28657737e-01f, 3.64157818e-02f,
  4.00859118e-02f, 1.51433215e-01f, 3.67660783e-02f, 1.81435943e-01f, 1.93364576e-01f, 1.24962121e-01f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -6.85978606e-02f, 7.60896355e-02f, 9.86703783e-02f, -4.14482728e-02f, -1.29088163e-01f, -7.73896277e-02f, 1.95066631e-02f, 9.44336206e-02f, -1.13540441e-01f, -1.24273479e-01f,
  -1.19616259e-02f, -3.69428843e-02f, 1.25612468e-01f, -6.88399300e-02f, -1.07767545e-01f, 1.94457099e-02f, 2.67334860e-02f, 7.60873184e-02f, -6.55607786e-03f, -2.05428928e-01f,
  -1.05751203e-02f, 1.63008556e-01f, 3.06669436e-02f, 6.29402101e-02f, -1.30045936e-01f, -7.50604048e-02f, 3.53892259e-02f, -2.83854199e-03f, 2.02809647e-01f, 1.56773761e-01f,
  2.21253559e-01f, 1.26003996e-01f, -1.06231764e-01f, -2.90723564e-03f, -5.84312491e-02f, 1.30279765e-01f, -2.90982854e-02f, 1.50823638e-01f, -1.19819582e-01f, 2.99257133e-02f,
  -2.52290769e-03f, 2.85186153e-02f, -1.54741496e-01f, 7.59495720e-02f, 3.91940214e-02f, 1.29691780e-01f, 1.51930332e-01f, 8.24546069e-02f, -1.42388582e-01f, -1.68980435e-01f,
  -8.70807376e-03f, 2.60727346e-01f, -8.63881260e-02f, -1.28413647e-01f, 9.95016471e-02f, -1.56433001e-01f, 6.81641400e-02f, -1.36160642e-01f, 6.94946013e-03f, -2.44744457e-02f,
  -3.08113303e-02f, 1.70496449e-01f, 2.01410726e-02f, 6.34828284e-02f, 6.55980557e-02f, 7.36953393e-02f, 5.85569255e-02f, 1.66538320e-02f, -1.00581320e-02f, -6.53377455e-03f,
  -1.73518628e-01f, 4.86765914e-02f, -2.29403414e-02f, 7.40210935e-02f, -6.60196915e-02f, 1.04962261e-02f, 5.21966852e-02f, 3.99642661e-02f, 1.03567034e-01f, -7.27598816e-02f,
  1.15655335e-02f, -3.32798846e-02f, -2.81394571e-02f, -5.93756288e-02f, 1.24485314e-01f, -1.19859815e-01f, -2.69512720e-02f, -5.60416207e-02f, -1.78082578e-03f, 1.45933554e-01f,
  6.45963550e-02f, 1.30933449e-01f, -2.57280678e-01f, 1.25232726e-01f, 1.04736172e-01f, 4.21455316e-02f, 9.60045904e-02f, -4.13680412e-02f, -2.32253164e-01f, -1.07155945e-02f,
  -1.68250889e-01f, 1.87377390e-02f, 1.14669144e-01f, 1.01863153e-01f, 3.67662124e-02f, 2.87058614e-02f, 1.16475321e-01f, -1.61678210e-01f, -1.58872321e-01f, -4.34471257e-02f,
  -3.18723768e-02f, 1.78018659e-01f, 6.04413152e-02f, -7.40134791e-02f, -5.32138012e-02f, -1.86720207e-01f, -1.03705838e-01f, 5.64139225e-02f, 1.30737990e-01f, -9.47894976e-02f,
  -5.59066162e-02f, 2.37511247e-01f, 2.01756001e-01f, -1.67825624e-01f, 3.86466682e-02f, 5.30799888e-02f, 3.37672606e-02f, -1.57215998e-01f, 1.68600362e-02f, 2.19324771e-02f,
  2.02270579e-02f, 1.10561483e-01f, -6.74028099e-02f, 1.47444485e-02f, 6.34740293e-02f, -4.43368927e-02f, 5.15381284e-02f, -1.29424352e-02f, -4.57658544e-02f, -6.62388429e-02f,
  5.13456911e-02f, -7.37371668e-02f, 1.37445582e-02f, -2.44257711e-02f, 1.03421338e-01f, -9.79365781e-02f, -1.24061264e-01f, -8.14636946e-02f, 1.22035913e-01f, -3.81988147e-03f,
  -8.54209587e-02f, -3.84442620e-02f, -2.45045517e-02f, 1.71114057e-01f, 1.95209056e-01f, 1.86988771e-01f, -6.30043298e-02f, 1.14719808e-01f, -7.14842929e-03f, 9.05092508e-02f,
  5.26031852e-03f, 6.15203716e-02f, -1.58990294e-01f, 1.02007268e-02f, -1.42945260e-01f, 2.30542615e-01f, 1.48081928e-01f, 8.25934298e-03f, 1.00356616e-01f, 1.15719110e-01f,
  -1.53645739e-01f, -8.47657844e-02f, 2.66396571e-02f, -9.59253162e-02f, -1.50894940e-01f, -1.44184176e-02f, -3.60431895e-02f, -9.32645947e-02f, 1.29329845e-01f, 1.02138035e-01f,
  1.45587521e-02f, 1.50829792e-01f, 1.79448307e-01f, -2.21662939e-01f, 9.80516076e-02f, 2.55809780e-02f, -8.20446834e-02f, -1.53719231e-01f, 4.53898404e-03f, 4.10874076e-02f,
  -1.45568848e-01f, -1.45304352e-01f, 1.51530460e-01f, 6.44673184e-02f, -2.60390807e-03f, -5.26313297e-02f, -5.95755540e-02f, 3.82439941e-02f, -7.96852484e-02f, -3.48069705e-02f,
  -3.14316228e-02f, 1.46206513e-01f, 1.32553160e-01f, -8.69778842e-02f, 3.86442244e-02f, -5.70675433e-02f, -3.17159146e-02f, 1.49645701e-01f, -5.76173030e-02f, -4.39005196e-02f,
  1.23569988e-01f, -1.85830425e-02f, -1.66553050e-01f, 4.38556001e-02f, -8.16383287e-02f, 1.03874579e-01f, -9.24871787e-02f, -1.63802922e-01f, -1.08410120e-01f, -3.72443981e-02f,
  -8.46065804e-02f, 7.51735419e-02f, -8.65382850e-02f, -1.00607105e-01f, -1.97145268e-02f, 8.55206698e-03f, 1.49671853e-01f, -1.60745438e-02f, 1.00203313e-01f, -7.51970112e-02f,
  -8.65742490e-02f, -1.23313613e-01f, -2.02850327e-02f, -8.38290304e-02f, -2.02196706e-02f, 1.76673263e-01f, -1.59101292e-01f, 1.51616439e-01f, 1.81168869e-01f, -1.38593078e-01f,
  2.37995991e-03f, 2.44488604e-02f, -2.36093439e-02f, 3.06326132e-02f, 1.43014356e-01f, -1.13816537e-01f, -2.53133569e-03f, 3.35313156e-02f, 8.64663720e-02f, -1.05127700e-01f,
  6.23722211e-04f, -3.96090886e-03f, -1.57129988e-01f, -1.54399782e-01f, 1.80004582e-01f, 1.46478079e-02f, 1.43179465e-02f, -5.76837212e-02f, 5.87789081e-02f, -1.10513285e-01f,
  -4.70699891e-02f, 6.40680194e-02f, -4.52071093e-02f, 1.94136798e-01f, -3.69954966e-02f, -1.80954132e-02f, -1.12636879e-01f, 8.68273154e-02f, -1.65150106e-01f, 5.44069707e-02f,
  5.27110919e-02f, -5.24886064e-02f, 6.01839423e-02f, 1.14507690e-01f, 1.77735969e-01f, -1.11742534e-01f, -2.01953173e-01f, 1.15171932e-02f, -8.81854519e-02f, 6.23428449e-02f,
  1.60136566e-01f, -1.21122353e-01f, -3.62248681e-02f, -1.32443994e-01f, -1.30847216e-01f, 1.95883922e-02f, 2.11195834e-02f, -2.87654828e-02f, 2.09801018e-01f, -1.77955672e-01f,
  1.26494125e-01f, 7.00820982e-02f, -1.08870670e-01f, -1.02188885e-01f, 7.23738968e-02f, -1.22354381e-01f, -1.26214743e-01f, 2.43530124e-01f, 8.18133727e-02f, 1.50635064e-01f,
  1.05180643e-01f, -1.24310739e-01f, -6.09780513e-02f, -1.16896667e-01f, -3.44234444e-02f, 5.81779256e-02f, 8.27818513e-02f, 3.46952379e-02f, 6.27136976e-02f, 1.70224249e-01f,
  -1.37436092e-01f, -8.68365839e-02f, -8.40726569e-02f, -2.68739518e-02f, 1.94961324e-01f, 6.44154251e-02f, -1.12179063e-01f, -1.44961059e-01f, 6.13814406e-02f, 1.30356282e-01f,
  5.54867573e-02f, -3.14017162e-02f, 5.63806109e-03f, 1.21785752e-01f, 4.87036407e-02f, -1.24211282e-01f, -8.52165073e-02f, -4.24851477e-02f, -3.87438908e-02f, -1.65252954e-01f,
  -4.20727767e-02f, 4.30829264e-02f, 6.52693352e-03f, -1.59429148e-01f, -1.16267942e-01f, -1.51671708e-01f, 2.96884086e-02f, -4.93218340e-02f, -1.75481737e-01f, 2.73129568e-02f,
  1.35458678e-01f, -3.43902819e-02f, -1.58049017e-02f, 7.61513636e-02f, 2.26633679e-02f, 1.75050795e-01f, -4.47387248e-02f, 2.43676618e-01f, -2.33244404e-01f, -7.80544477e-03f,
  1.84185416e-01f, 1.95883811e-01f, 6.45762831e-02f, 2.68977997e-03f, 9.77862254e-02f, 2.14548692e-01f, -1.99424416e-01f, 8.29266980e-02f, 1.08219802e-01f, -2.02167928e-01f,
  4.40288372e-02f, 1.20919310e-01f, 1.70338094e-01f, -4.86633033e-02f, -6.82759732e-02f, -7.22331032e-02f, 7.13451877e-02f, 1.08599737e-01f, 4.04699892e-02f, -6.19989373e-02f,
  1.48931593e-01f, 6.58934265e-02f, -2.05298588e-01f, 3.26554738e-02f, 9.94618759e-02f, 4.99653444e-02f, -5.03262319e-02f, 9.58784148e-02f, 1.70926839e-01f, -5.14141135e-02f,
  8.55032504e-02f, 4.31485064e-02f, -1.25170633e-01f, 2.08361391e-02f, 5.25660962e-02f, 1.08257517e-01f, 1.03528202e-01f, 6.98799789e-02f, -1.16932251e-01f, 1.28191918e-01f,
  -3.41563337e-02f, 8.69083330e-02f, 3.27439718e-02f, 5.10327108e-02f, 5.50552097e-04f, 1.86740458e-02f, 9.18747634e-02f, -7.08500072e-02f, -1.45854905e-01f, 7.10929260e-02f,
  2.20392961e-02f, -4.25862186e-02f, 8.01505670e-02f, -1.79437101e-01f, 2.39912704e-01f, 6.70325607e-02f, 1.42089892e-02f, 2.71709524e-02f, -7.62270391e-02f, -5.02721556e-02f,
  -8.12032595e-02f, 1.03426397e-01f, 1.41535094e-02f, 6.96201101e-02f, -1.09416835e-01f, -1.49148762e-01f, -1.72588587e-01f, -1.06584094e-01f, -1.69703141e-01f, -2.61208415e-02f,
  -1.70817614e-01f, -6.68539405e-02f, -9.28399563e-02f, 1.48623422e-01f, 6.42473921e-02f, 3.91390845e-02f, -1.10825323e-01f, 9.13851708e-03f, 2.35490501e-02f, 2.94670444e-02f,
  1.53404577e-02f, -1.84618980e-02f, -6.48554638e-02f, -1.54202059e-01f, -1.09632589e-01f, -5.26733175e-02f, -1.00373447e-01f, 7.27152675e-02f, -7.57721364e-02f, 2.25837789e-02f,
  6.33604974e-02f, -1.43458620e-01f, -1.91190597e-02f, -1.07268497e-01f, 1.64728090e-01f, 2.18386099e-01f, -1.23488717e-01f, -8.23763758e-02f, -4.28174585e-02f, 4.41778079e-02f,
  -4.74409312e-02f, 2.03964651e-01f, 4.17070538e-02f, -8.36165920e-02f, -8.68948027e-02f, -1.26086652e-01f, -7.68194422e-02f, 1.44708082e-01f, 6.00452982e-02f, -9.64475200e-02f,
  1.10744312e-01f, 1.20593868e-01f, -3.25684883e-02f, -3.84255010e-03f, 7.99363181e-02f, -6.25637323e-02f, -1.25403136e-01f, 3.04077640e-02f, -2.36680850e-01f, -2.62677837e-02f,
  -9.14558023e-02f, 1.50364503e-01f, -1.40530810e-01f, -1.19906239e-01f, 9.97339860e-02f, -2.21692510e-02f, 2.73219310e-02f, 2.94359744e-01f, 1.68280587e-01f, 4.97895926e-02f,
  -1.34670250e-02f, 1.54016599e-01f, -2.61922061e-01f, 2.20084265e-01f, 1.18122749e-01f, 1.19273931e-01f, -8.75937641e-02f, -9.18579772e-02f, 1.21415861e-01f, -1.76152959e-01f,
  -1.11147091e-01f, -1.51705220e-01f, -1.45349294e-01f, 1.19538233e-01f, 1.30748451e-01f, -1.11253589e-01f, 1.34412766e-01f, -2.49448232e-02f, -1.53180897e-01f, 1.78674147e-01f,
  1.31826431e-01f, -1.35629624e-01f, 1.32505640e-01f, -3.14554609e-02f, -6.57306910e-02f, -1.16310097e-01f, 2.67938282e-02f, 4.96797496e-03f, -2.24359602e-01f, 1.01553820e-01f,
  -1.51896536e-01f, 5.43086156e-02f, -4.29382687e-03f, -4.00849283e-02f, -3.21812928e-02f, 2.19138693e-02f, -1.70379616e-02f, 8.50629956e-02f, -4.31230217e-02f, -7.52463564e-03f,
  7.56366411e-04f, 6.50655851e-02f, -9.73849595e-02f, 9.03936699e-02f, 9.55261961e-02f, -1.77247692e-02f, 6.79955399e-03f, -4.82633933e-02f, -4.99778017e-02f, -1.11529745e-01f,
  -4.36644144e-02f, 8.06718022e-02f, -1.43479377e-01f, -9.05087069e-02f, 4.29246388e-02f, 7.92126507e-02f, 2.23699748e-03f, -1.05589509e-01f, 1.56349108e-01f, 3.52622867e-02f,
  -8.08459669e-02f, -8.92129987e-02f, 1.90279961e-01f, -6.25875369e-02f, -4.11210442e-03f, 2.31665030e-01f, 8.42368826e-02f, 1.32507235e-01f, 6.21588007e-02f, 5.09308837e-02f,
  3.17870118e-02f, -1.43346086e-01f, -9.54410434e-02f, -1.04561985e-01f, -1.51757866e-01f, -1.22536458e-01f, -7.22567141e-02f, 1.53719366e-01f, 1.01962946e-01f, -8.71777609e-02f,
  9.70898196e-02f, 8.65404755e-02f, 9.31551754e-02f, -1.15930788e-01f, 1.34957597e-01f, -9.20445696e-02f, 8.00457522e-02f, 1.93521276e-01f, -6.86675087e-02f, -1.61845297e-01f,
  -2.68162414e-02f, -7.09209219e-02f, -5.94470873e-02f, -5.05247749e-02f, -1.87450740e-02f, -1.74793467e-01f, 4.24442701e-02f, 6.41730428e-02f, -4.73613665e-02f, -1.84648246e-01f,
  1.02874778e-01f, 6.18433952e-02f, -4.09243954e-03f, -3.05479709e-02f, 9.19801891e-02f, -7.30726272e-02f, -3.61258686e-02f, -1.04115345e-01f, -3.65519710e-02f, 1.33553907e-01f,
  -1.48719549e-01f, 6.37621656e-02f, 1.01704180e-01f, -6.84233382e-02f, -2.10400149e-02f, -2.36776724e-01f, -7.50510544e-02f, 3.84123437e-02f, 1.11829653e-01f, -6.42930716e-02f,
  -1.98488403e-02f, -1.82542354e-01f, -1.42279387e-01f, -1.04024947e-01f, 6.66480362e-02f, -2.57224560e-01f, 4.64710966e-02f, -1.33783549e-01f, 3.61643918e-02f, -4.57181185e-02f,
  1.38221517e-01f, -1.86211348e-01f, 2.02059403e-01f, -1.62643194e-01f, -8.39926489e-03f, -3.84157673e-02f, -9.66326147e-02f, 7.84503371e-02f, -6.76826835e-02f, 2.45552868e-01f,
  2.00112015e-01f, -1.12672728e-02f, -1.80411357e-02f, 3.10744215e-02f, 4.13360856e-02f, -6.01591589e-03f, -5.71062937e-02f, 1.36256590e-01f, -5.88711444e-03f, -2.71078218e-02f,
  -2.48201229e-02f, -6.84672520e-02f, 9.07471925e-02f, -1.59605086e-01f, -2.42290661e-01f, 6.89646974e-02f, 5.73415570e-02f, -1.15701154e-01f, -3.60420682e-02f, 1.93935543e-01f,
  -3.98824029e-02f, 2.91255955e-02f, 3.19782235e-02f, 5.17888647e-03f, 1.40305832e-01f, -4.71234834e-03f, 1.29609302e-01f, 5.34931608e-02f, -5.08453064e-02f, -6.92629814e-02f,
  -4.41104062e-02f, -6.34209737e-02f, -6.21002130e-02f, 1.72122717e-01f, 5.77635318e-02f, -1.15061328e-02f, 1.22809522e-01f, 6.96685612e-02f, 7.50813587e-03f, 8.51747841e-02f,
  -2.83325333e-02f, 7.18471333e-02f, -6.33183941e-02f, 6.17365651e-02f, 2.02899188e-01f, -1.15652777e-01f, 5.33418320e-02f, -8.05485547e-02f, -2.67679960e-01f, 9.11492705e-02f,
  -5.49194170e-04f, -1.97582040e-02f, 1.47055164e-01f, -2.00954359e-02f, -6.28715828e-02f, 1.00766070e-01f, 2.07389854e-02f, -2.19251737e-01f, -6.26116544e-02f, 8.51170626e-03f,
  2.35531062e-01f, -5.20625971e-02f, 1.03072733e-01f, -1.21530399e-01f, 1.13626279e-01f, -1.08947799e-01f, -2.96566859e-02f, 1.93373673e-02f, 1.18462108e-01f, -3.98139693e-02f,
  -5.13401404e-02f, -1.03712790e-01f, 9.06709433e-02f, 4.18274105e-02f, -8.81036147e-02f, -6.85441792e-02f, -3.96364965e-02f, 9.36906636e-02f, 2.42622092e-01f, 2.17601936e-03f,
  1.50075719e-01f, -1.16230145e-01f, -1.50743693e-01f, 1.91429555e-02f, -7.12207109e-02f, 1.10896900e-01f, 1.85152143e-01f, -2.13794038e-01f, -1.75939173e-01f, -3.42762619e-02f,
  -6.57861903e-02f, 1.18816987e-01f, 8.92738178e-02f, 2.61289179e-02f, -4.53740172e-02f, 1.24114405e-04f, -1.07667424e-01f, 6.50722235e-02f, 1.26373872e-01f, 1.18136704e-01f,
  -9.11599621e-02f, 1.33929357e-01f, 6.50904477e-02f, -1.18042856e-01f, 2.57131845e-01f, -8.04841369e-02f, 9.51249674e-02f, -2.64174461e-01f, 1.11855958e-02f, 1.52583569e-01f,
  -2.43272841e-01f, -1.13560170e-01f, 2.68104821e-01f, -1.12163119e-01f, -8.06901008e-02f, -1.41213283e-01f, -5.70872761e-02f, -1.68474182e-01f, -1.37218246e-02f, -1.67818204e-01f,
  -1.82667121e-01f, -1.08951338e-01f, -1.20197386e-01f, 1.73445269e-01f, -1.25384763e-01f, -8.55552703e-02f, 9.29343924e-02f, 1.94101945e-01f, -5.87295182e-02f, 1.42696965e-02f,
  1.42153108e-03f, 6.85411543e-02f, -9.06024128e-02f, -1.61244527e-01f, 7.94702768e-03f, -2.20285594e-01f, 1.00905731e-01f, 4.39540483e-02f, -9.71739814e-02f, 1.08657777e-01f,
  -5.35078980e-02f, 1.00804403e-01f, -3.10734920e-02f, -1.65834818e-02f, -8.42800885e-02f, -2.06129923e-02f, 1.44361079e-01f, 3.04195657e-02f, -4.74917851e-02f, -6.11147545e-02f,
  -8.72600265e-03f, 1.05902612e-01f, -8.27125646e-03f, 3.00323386e-02f, 1.33765176e-01f, -1.72403678e-01f, 3.46052647e-02f, -6.52165562e-02f, -1.45420089e-01f, -3.80791612e-02f,
  -1.21689782e-01f, -3.44503820e-02f, -2.51194574e-02f, 1.29131928e-01f, 9.58401486e-02f, -1.14615839e-02f, -7.05128089e-02f, 4.13752347e-02f, 3.48356320e-03f, -1.17080286e-01f,
  4.66454737e-02f, -2.65967026e-02f, 6.09423555e-02f, -1.72667414e-01f, 1.01368397e-01f, -8.88900757e-02f, 1.42097175e-01f, -1.60440966e-01f, 2.36284137e-02f, -1.22891173e-01f,
  9.88848507e-03f, 1.62926823e-01f, 5.22760265e-02f, -7.69471675e-02f, 1.11172862e-01f, -2.48324499e-01f, -1.76269487e-01f, -5.84021620e-02f, 8.43999237e-02f, 3.50900888e-02f,
  3.79915498e-02f, -4.44795340e-02f, -1.00611828e-01f, -2.51427628e-02f, -7.60864615e-02f, -2.03770176e-01f, 1.14776917e-01f, 2.14693993e-01f, 5.53311110e-02f, -1.98799923e-01f,
  7.23520759e-03f, 8.22698474e-02f, -3.28513235e-02f, 2.80777544e-01f, -4.31163609e-02f, -4.26937971e-04f, -2.25519642e-01f, 1.28804564e-01f, 3.68623957e-02f, -2.26933584e-02f,
  -1.89780369e-01f, -6.86783642e-02f, -1.04950652e-01f, -7.22359344e-02f, -1.16110044e-02f, 2.99897920e-02f, -6.31691143e-02f, 9.71104428e-02f, 4.70045768e-03f, -6.84415773e-02f,
  -1.25173867e-01f, 2.47182753e-02f, -1.14686847e-01f, -7.03407601e-02f, 8.50225464e-02f, -7.61108696e-02f, 4.42942232e-03f, -2.91926367e-03f, -1.85246840e-02f, 6.18285164e-02f,
  6.34591356e-02f, -1.99130937e-01f, -9.31056365e-02f, -2.70855930e-02f, 1.40095070e-01f, -2.95969099e-02f, 5.09605780e-02f, -1.32948622e-01f, 8.78717154e-02f, 2.07993433e-01f,
  5.77903688e-02f, -2.21795753e-01f, 9.72044915e-02f, 2.18003452e-01f, -1.07883647e-01f, 4.34218906e-02f, -2.20466912e-01f, -7.19543472e-02f, -1.11393698e-01f, 3.11170518e-01f,
  3.55158336e-02f, -9.71186087e-02f, 3.41196693e-02f, 3.02857403e-02f, -7.97268897e-02f, 2.15995628e-02f, 2.37775996e-01f, 6.42801388e-05f, 7.68075958e-02f, 1.86173841e-01f,
  3.24041136e-02f, -1.17401309e-01f, 3.00805774e-02f, 3.56859043e-02f, -7.37768188e-02f, 8.46669136e-04f, 2.52058029e-01f, -1.53904945e-01f, 9.17429775e-02f, -3.23873088e-02f,
  -1.67390630e-01f, -9.08259302e-02f, -5.06219715e-02f, 8.88257772e-02f, 2.60160938e-02f, -3.17770988e-02f, -8.12847167e-02f, 9.85784009e-02f, -1.02891391e-02f, -9.07153115e-02f,
  -2.55737118e-02f, 6.16598427e-02f, -7.78508410e-02f, 9.83985215e-02f, 2.50906944e-02f, -3.99481170e-02f, 1.60106614e-01f, 9.77994949e-02f, 6.30439073e-02f, 3.72487940e-02f,
  1.13984197e-01f, -2.70064641e-02f, 3.31119373e-02f, -1.04377642e-01f, 7.30066001e-02f, -1.91548228e-01f, -1.83931005e-03f, 1.02841608e-01f, -1.41055202e-02f, 3.12282611e-02f,
  -6.92132488e-02f, -1.45271420e-01f, 1.24765548e-03f, 8.52364376e-02f, -3.16425934e-02f, -2.25149561e-02f, 1.05124548e-01f, -1.24497369e-01f, 2.51743607e-02f, -1.66711241e-01f,
  -4.36907560e-02f, -3.64925452e-02f, 4.23560590e-02f, -7.51701295e-02f, 7.23468512e-02f, -1.27976060e-01f, 5.77345155e-02f, -3.78777422e-02f, 8.41712859e-03f, 1.77069873e-01f,
  8.24121851e-03f, -8.74294415e-02f, -4.18086275e-02f, 1.44913748e-01f, -9.84131917e-02f, -1.22126415e-01f, -1.48525136e-02f, 1.75974295e-01f, -1.85649004e-02f, 1.15997158e-01f,
  3.53170224e-02f, -1.89793870e-01f, 7.98660815e-02f, -8.01823065e-02f, -1.48528218e-01f, 1.56150937e-01f, 4.34641317e-02f, -3.00709140e-02f, 3.01163252e-02f, 1.27086416e-01f,
  4.67267334e-02f, -1.35023132e-01f, -1.02332562e-01f, -1.51841253e-01f, -4.71767597e-02f, -1.87352538e-01f, -4.91205156e-02f, -1.66538671e-01f, -1.04616657e-01f, -1.87021628e-01f,
  7.35724927e-04f, -4.49319631e-02f, 9.18304268e-03f, -9.51203480e-02f, 9.67491493e-02f, -1.80058375e-01f, -1.04406811e-02f, 2.52338797e-02f, 1.11230845e-02f, -2.26272214e-02f,
  -8.75531733e-02f, 1.41403049e-01f, -1.47878170e-01f, 1.15382940e-01f, -5.20548895e-02f, -3.62160243e-02f, -1.11877494e-01f, 1.33404881e-01f, -1.31223043e-02f, -1.56653181e-01f,
  8.17925707e-02f, 2.18837872e-01f, 1.08784109e-01f, -1.76273510e-02f, 1.14305370e-01f, 2.13119298e-01f, 2.43324190e-02f, 2.96663225e-01f, 1.43174574e-01f, 9.60686523e-03f,
  -9.55309197e-02f, 1.77040830e-01f, 1.09268606e-01f, 6.25296161e-02f, -9.15131643e-02f, -5.69828637e-02f, 3.01817842e-02f, 5.72818704e-02f, 4.69733812e-02f, -4.85066976e-03f,
  1.41075715e-01f, 1.66399181e-01f, -1.17730722e-01f, 2.39020642e-02f, 1.06314600e-01f, -1.20602958e-02f, -4.42557633e-02f, -7.76711330e-02f, -5.02295978e-02f, 4.11518961e-02f,
  -2.17555895e-01f, -1.66692566e-02f, 1.14505887e-01f, 3.47334482e-02f, -1.48229569e-01f, -3.55069339e-02f, 1.64672419e-01f, -2.49610543e-01f, 9.15745459e-03f, 8.66181552e-02f,
  8.83705467e-02f, 1.72985211e-01f, -3.94232292e-03f, 2.60600168e-02f, 1.19128868e-01f, -1.19501844e-01f, -1.73482075e-01f, 1.25417039e-01f, -6.24765418e-02f, -1.12484232e-01f,
  -2.82905623e-02f, 7.92769939e-02f, 1.91290230e-01f, -2.35042766e-01f, -1.21686511e-01f, 1.03395022e-01f, 6.50311857e-02f, -4.67280075e-02f, 2.08388731e-01f, -6.23069983e-03f,
  -2.27394141e-02f, -4.45121750e-02f, -1.37483805e-01f, -2.63326138e-01f, 1.64643466e-01f, 9.68287587e-02f, 7.88363069e-02f, -2.75097251e-01f, 2.16211259e-01f, -1.00381836e-01f,
  -2.46773418e-02f, -5.03905192e-02f, -1.15583301e-01f, -4.28194627e-02f, -1.10780515e-01f, 3.68966237e-02f, 1.04837187e-01f, 2.98014700e-01f, 2.43686318e-01f, -9.86412168e-03f,
  1.00487694e-02f, 1.53823316e-01f, -6.75413683e-02f, 1.72083136e-02f, 2.46636495e-01f, 1.28520116e-01f, 1.37224654e-02f, 9.40154493e-02f, -1.99815989e-01f, -7.35048652e-02f,
  -1.63118139e-01f, -1.26885828e-02f, 1.38239741e-01f, -1.63725436e-01f, -9.53274220e-02f, 6.76962659e-02f, 9.12275314e-02f, -3.39144655e-02f, -7.80140385e-02f, 8.20822045e-02f,
  -1.09061506e-02f, 9.01746377e-02f, -1.14365704e-01f, -7.93807730e-02f, -1.30444854e-01f, -7.36201182e-02f, 4.45923395e-02f, -7.20500797e-02f, -3.22249392e-03f, 4.09226902e-02f,
  6.25987351e-02f, 1.54356360e-02f, 6.17531165e-02f, -1.68036237e-01f, 1.40069082e-01f, -1.83795411e-02f, 5.69355674e-02f, 4.80253734e-02f, 4.96301847e-03f, 2.61960924e-02f,
  -1.59244210e-01f, 2.00854599e-01f, -3.95490266e-02f, 2.64889523e-02f, -1.27925873e-01f, 1.88278899e-01f, -2.58947939e-01f, 1.41678199e-01f, 1.10513354e-02f, 1.55675441e-01f,
  1.30763605e-01f, 3.27636153e-02f, -1.07602105e-01f, 7.82621577e-02f, -2.04943746e-01f, 1.61336213e-01f, 1.12071536e-01f, 3.02538718e-03f, -1.49484789e-02f, 9.33946148e-02f,
  1.69941962e-01f, 2.62391362e-02f, -5.81853054e-02f, -1.25403509e-01f, -7.79132918e-02f, -5.38650081e-02f, 9.13146064e-02f, -2.86671203e-02f, 7.94021338e-02f, -1.15943357e-01f,
  -1.53836176e-01f, 8.56594592e-02f, 3.92587967e-02f, -1.29070967e-01f, -4.69434112e-02f, 9.31718722e-02f, 1.14691272e-01f, 1.33838564e-01f, 1.16750650e-01f, 9.21377540e-03f,
  3.44824828e-02f, -1.50364898e-02f, 1.65582418e-01f, 3.82970124e-02f, -1.88889857e-02f, -6.51697192e-05f, 6.59205839e-02f, 1.64032709e-02f, 6.39854148e-02f, -2.18894575e-02f,
  -1.87061774e-03f, 1.11716781e-02f, -1.26591817e-01f, -1.29884019e-01f, 5.98201975e-02f, -8.88581201e-02f, -2.50619557e-02f, 1.58950035e-02f, -1.19514382e-02f, -7.24797100e-02f,
  -2.16105789e-01f, 2.07280934e-01f, 4.75439876e-02f, 2.24186275e-02f, -2.24739108e-02f, 1.63006619e-01f, 2.27433577e-01f, 5.53850271e-02f, 2.11417489e-02f, 2.02217340e-01f,
  -1.57465056e-01f, 4.58085686e-02f, 1.53289035e-01f, 8.07766840e-02f, 1.43202767e-01f, 2.12055206e-01f, 1.73159510e-01f, 1.48862794e-01f, 1.00881957e-01f, 2.52730608e-01f,
  1.07058734e-01f, -1.59630373e-01f, 1.52160181e-02f, -4.77653509e-03f, 4.39079218e-02f, -1.82531580e-01f, -1.70887724e-01f, -2.75114253e-02f, 1.62607744e-01f, 2.73178909e-02f,
  -1.97725184e-02f, 1.34670064e-01f, 1.74349144e-01f, 6.70464262e-02f, -2.71332674e-02f, -5.17144613e-02f, 9.68902558e-02f, 1.18561409e-01f, -4.03595902e-02f, 9.05214772e-02f,
  -6.32756352e-02f, 4.78433110e-02f, -1.97378635e-01f, -1.87445045e-01f, -4.23077755e-02f, -4.63670678e-03f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  7.95243084e-02f, 1.59673899e-01f, -1.08896486e-01f, 1.57060638e-01f, 1.82967484e-01f, -8.41129422e-02f, 8.85469690e-02f, 2.69522648e-02f, -6.63313642e-02f, 1.02158919e-01f,
  -1.20511867e-01f, 1.18925527e-01f, -2.26055402e-02f, -1.19373284e-01f, 1.12361625e-01f, -5.02738990e-02f, 9.74877328e-02f, -3.33302352e-03f, 1.56262398e-01f, 2.43672788e-01f,
  -2.17402969e-02f, -2.18872234e-01f, -8.23827237e-02f, 3.08686167e-01f, 2.52999753e-01f, 1.26798794e-01f, -1.06621437e-01f, 2.16066048e-01f, -4.13193643e-01f, -9.48862359e-03f,
  -1.36252423e-03f, 1.96989879e-01f, 3.95931035e-01f, 8.36844444e-02f, 1.57389671e-01f, 7.74201751e-02f, -1.41745076e-01f, 2.26991437e-02f, 2.11474359e-01f, -1.45364270e-01f,
  1.33702204e-01f, 3.81117970e-01f, 3.32819641e-01f, -3.36066753e-01f, -4.55852598e-03f, 4.29170989e-02f, 1.17561802e-01f, 1.00931741e-01f, 3.14068168e-01f, 2.32061043e-01f,
  3.15427482e-01f, 1.01230651e-01f, 6.30142018e-02f, 6.21435791e-02f, 1.27319440e-01f, 1.26687899e-01f, 7.96731710e-02f, 2.90030152e-01f, 9.23528224e-02f, 2.66818941e-01f,
  9.03871432e-02f, -2.53845185e-01f, 2.92082250e-01f, -1.11056203e-02f, 1.15332648e-01f, 4.87529859e-02f, -8.85919929e-02f, 9.16460808e-03f, 1.01653002e-01f, 1.68116286e-01f,
  1.93066776e-01f, -2.03317334e-03f, -4.35633101e-02f, 7.39764422e-02f, -2.96713281e-02f, 1.78182021e-01f, -1.16894588e-01f, 1.40672863e-01f, -2.81838160e-02f, 2.14510590e-01f,
  7.40760192e-02f, 2.57405583e-02f, 1.37188599e-01f, 1.05569214e-01f, 2.20026504e-02f, -1.68894678e-01f, 1.67778715e-01f, 4.85033542e-03f, 2.65720915e-02f, 7.32284561e-02f,
  2.76719034e-01f, -3.81121129e-01f, -2.94684052e-01f, 6.45619258e-02f, -3.98477077e-01f, -1.16134450e-01f, -6.68711364e-02f, 2.16200203e-01f, -1.00426972e-01f, -1.37532130e-01f,
  -3.99980284e-02f, -4.20367301e-01f, -1.19483635e-01f, 2.82173067e-01f, 1.16573140e-01f, -3.18950355e-01f, 1.61857918e-01f, -2.45425716e-01f, 4.80595566e-02f, 4.72922251e-02f,
  -3.64020735e-01f, -1.24661908e-01f, 2.32032061e-01f, 2.58980513e-01f, -6.55463338e-02f, -2.59189337e-01f, 2.45043635e-01f, 1.33471981e-01f, -1.69681296e-01f, 3.21684241e-01f,
  1.14473343e-01f, 2.06417277e-01f, 9.27372724e-02f, -7.96408579e-02f, 1.02291726e-01f, -1.90027669e-01f, -1.92241281e-01f, 2.85278317e-02f, -8.51856358e-03f, 1.18358791e-01f,
  2.03251153e-01f, 1.17707834e-01f, 2.27721371e-02f, -6.02863356e-02f, -3.65962014e-02f, 1.79213196e-01f, -1.28230572e-01f, 1.46955922e-01f, 1.92313582e-01f, 1.43384129e-01f,
  -1.06467843e-01f, 1.58218995e-01f, 2.53330231e-01f, 2.45076371e-03f, -1.46450149e-02f, -7.57058859e-02f, 9.11978781e-02f, 1.58665031e-01f, -3.91274273e-01f, 1.30424693e-01f,
  -1.29242584e-01f, 2.13385507e-01f, 6.03893809e-02f, 5.08845821e-02f, -2.08396748e-01f, -1.32737651e-01f, -1.74845740e-01f, 2.15515941e-01f, -7.77010173e-02f, 1.52003080e-01f,
  1.16871119e-01f, -1.99346825e-01f, -1.37373358e-02f, 4.37311418e-02f, -2.92457454e-03f, -1.69000417e-01f, -4.58048880e-02f, 1.83239073e-01f, -2.31921986e-01f, -2.23322079e-01f,
  5.14535904e-01f, 2.81794906e-01f, 5.78839295e-02f, 4.89110947e-02f, 1.37319550e-01f, -1.57398164e-01f, 1.63630452e-02f, 1.10296652e-01f, 2.06915259e-01f, 3.07639688e-01f,
  3.83154571e-01f, -3.89578305e-02f, -8.65247920e-02f, 1.06144421e-01f, -2.19200179e-01f, 2.12909818e-01f, 2.50657201e-01f, 4.28469121e-01f, -3.61851126e-01f, -1.91806555e-01f,
  3.58225048e-01f, 1.83275893e-01f, 2.29796767e-01f, 1.95146784e-01f, 1.03275388e-01f, 1.28710672e-01f, 1.43769562e-01f, 2.06259280e-01f, 2.05401499e-02f, 1.32389173e-01f,
  9.28437784e-02f, 1.53379753e-01f, -8.75759050e-02f, -6.68453276e-02f, -8.53008032e-03f, 2.47919381e-01f, 1.41759127e-01f, 1.24292120e-01f, 1.53034925e-01f, 9.10554528e-02f,
  1.36506289e-01f, 4.76856120e-02f, 2.63726681e-01f, -2.04745218e-01f, -3.39204147e-02f, 3.18811908e-02f, -2.68886872e-02f, 9.37856808e-02f, 2.91555345e-01f, -1.10785417e-01f,
  -2.69375414e-01f, -6.76636919e-02f, 1.20257272e-03f, -2.15405449e-01f, 1.69943094e-01f, 1.49304140e-02f, -7.31206611e-02f, 8.83144811e-02f, 1.77138880e-01f, -3.08659524e-01f,
  1.07747078e-01f, 2.14052022e-01f, 3.50087613e-01f, 2.07643226e-01f, -3.47463712e-02f, -1.99540079e-01f, 4.42239344e-02f, -1.57918498e-01f, -1.54431194e-01f, -1.24098118e-02f,
  1.94847658e-01f, -1.11737043e-01f, -1.54740319e-01f, 4.77446392e-02f, -1.88732833e-01f, 2.34059498e-01f, -1.28736153e-01f, 1.87828422e-01f, 2.61289805e-01f, 1.86766267e-01f,
  -9.58926529e-02f, 3.11297923e-01f, 7.67264441e-02f, 1.71305642e-01f, -3.81146669e-01f, 1.55705184e-01f, 1.72578216e-01f, 6.09591827e-02f, 5.09917997e-02f, 2.44789004e-01f,
  9.43657905e-02f, -1.52821578e-02f, 8.83471221e-02f, 1.52583094e-02f, -2.43823305e-02f, 5.68106212e-02f, -2.02890802e-02f, 5.86836264e-02f, 1.79159448e-01f, 8.22708532e-02f,
  1.14351563e-01f, -1.98421604e-03f, -4.78800535e-02f, 2.68251356e-02f, -4.38761301e-02f, 1.95430100e-01f, -1.00034691e-01f, -2.17269406e-01f, -1.70938492e-01f, 4.87161838e-02f,
  -2.07744278e-02f, 2.93425113e-01f, 3.89547914e-01f, 3.66122037e-01f, 9.00526792e-02f, 1.55564830e-01f, 2.30429128e-01f, 3.50783199e-01f, 1.34540200e-02f, 3.71468931e-01f,
  -1.48634478e-01f, 3.35364342e-01f, -7.68056959e-02f, 3.83615643e-01f, 2.45863020e-01f, 9.58789513e-02f, 1.61838219e-01f, -2.34959394e-01f, -6.23054057e-02f, -2.67878115e-01f,
  -2.28228923e-02f, 2.15329081e-01f, 2.18307406e-01f, -1.43779770e-01f, 2.57262111e-01f, 2.90804327e-01f, 1.62371978e-01f, -1.69827998e-01f, -3.57023180e-02f, -2.08083853e-01f,
  3.78157228e-01f, 1.10760354e-01f, 2.73089856e-01f, -2.65033003e-02f, 2.17166632e-01f, -4.07120168e-01f, -1.67230874e-01f, 2.99388647e-01f, -1.25128418e-01f, -1.79985791e-01f,
  -4.47238656e-03f, 1.18716620e-02f, -5.61547093e-02f, 2.95196950e-01f, 1.68039083e-01f, 1.11729711e-01f, 2.93352846e-02f, 7.99345151e-02f, 1.63286686e-01f, 1.63317144e-01f,
  1.09278776e-01f, 1.20021053e-01f, 6.66511580e-02f, 1.47619121e-05f, 1.27735227e-01f, 9.60794650e-03f, 1.38831392e-01f, 2.19201036e-02f, -1.27654776e-01f, 1.84474543e-01f,
  -3.30809981e-01f, -9.24924985e-02f, -9.03838947e-02f, 1.30728140e-01f, -3.15111786e-01f, -1.71878442e-01f, 1.00460961e-01f, -3.56394291e-01f, -7.23437592e-02f, 4.09640491e-01f,
  -2.77277678e-01f, -2.08494589e-01f, -6.17593378e-02f, 2.06640735e-01f, -2.15619206e-01f, -1.39170110e-01f, 2.85661310e-01f, -1.69336393e-01f, -1.87828407e-01f, 1.02591522e-01f,
  1.23010002e-01f, -1.74647383e-02f, -6.77897558e-02f, 1.14672936e-01f, -2.63132583e-02f, 1.20507451e-02f, -6.18065186e-02f, -2.34883025e-01f, 1.36891067e-01f, 2.16868788e-01f,
  -3.14957857e-01f, 3.82677436e-01f, 3.54289263e-01f, -1.74022704e-01f, -4.24848869e-02f, 1.96760461e-01f, -3.20506580e-02f, 1.72995493e-01f, -3.47080678e-02f, 4.60842699e-01f,
  -1.42317742e-01f, -1.68653741e-01f, -1.09462909e-01f, 2.91148156e-01f, -8.55756924e-03f, 4.57092142e-03f, 1.58740096e-02f, 2.26825118e-01f, 2.07288731e-02f, -6.37107641e-02f,
  2.21164450e-02f, -1.14371389e-01f, 6.80163316e-03f, -9.41870362e-02f, -7.19775409e-02f, 1.72736704e-01f, 7.94174820e-02f, -1.35648157e-02f, 1.07199416e-01f, -1.64150521e-01f,
  2.37340868e-01f, -1.10790379e-01f, -5.30838594e-02f, 1.25118196e-01f, 2.51491427e-01f, 3.56203131e-02f, -1.22874849e-01f, 1.47600383e-01f, -1.12596964e-02f, 1.55850142e-01f,
  3.86591166e-01f, 3.91739964e-01f, -1.57536760e-01f, 3.97166610e-02f, 3.25993672e-02f, 2.16680720e-01f, 2.65521437e-01f, 3.83793004e-02f, -3.85565042e-01f, 2.97098666e-01f,
  -3.59398931e-01f, 4.02735740e-01f, 3.16542953e-01f, 4.75996807e-02f, 2.86669016e-01f, 3.14660519e-01f, -1.52201444e-01f, -2.59845138e-01f, -1.73142143e-02f, -6.75199330e-02f,
  -1.19499691e-01f, 2.26031527e-01f, 2.59459257e-01f, -4.01892588e-02f, 6.15037940e-02f, 8.20963643e-03f, -4.09359515e-01f, 2.31300235e-01f, 3.88657689e-01f, -3.47745806e-01f,
  3.52831364e-01f, 2.06491694e-01f, -1.38549238e-01f, -2.52226591e-01f, 8.81329328e-02f, 1.60742626e-01f, -3.19116592e-01f, 8.97521079e-02f, 1.02215163e-01f, 2.31501997e-01f,
  1.86198935e-01f, 2.38033123e-02f, 4.07945039e-03f, 6.23903424e-02f, 7.25373626e-02f, 1.94621086e-01f, -4.78993505e-02f, 2.62284935e-01f, 5.31854816e-02f, 1.02805644e-01f,
  -1.39785364e-01f, 2.22490013e-01f, 1.35304943e-01f, 9.71297547e-02f, 1.23872615e-01f, 2.64925390e-01f, 1.74154297e-01f, 2.75928229e-01f, -1.02688603e-01f, -2.86705375e-01f,
  -9.47948545e-02f, -1.02780750e-02f, 1.12590510e-02f, 1.25498608e-01f, -1.13005169e-01f, -1.13256507e-01f, -7.87996203e-02f, 4.61423546e-01f, -9.51812342e-02f, -7.91354626e-02f,
  2.31999829e-02f, 1.53065756e-01f, 9.67484787e-02f, 1.20481156e-01f, -1.78114444e-01f, -2.17170045e-01f, 1.04865484e-01f, 3.92876416e-01f, -9.13625658e-02f, -3.23858976e-01f,
  3.66755337e-01f, -2.43550211e-01f, -4.17497665e-01f, 2.97022104e-01f, 1.22575209e-01f, -4.88156915e-01f, -1.76193211e-02f, 2.30162874e-01f, 1.80760220e-01f, -2.93017089e-01f,
  3.26037914e-01f, -2.06547931e-01f, -9.25597996e-02f, 4.50879455e-01f, -8.51268396e-02f, 2.63924211e-01f, 3.68023098e-01f, 8.22244063e-02f, -1.53917149e-01f, -1.20368786e-01f,
  1.34558961e-01f, -1.65077403e-01f, 1.34718329e-01f, 1.19016496e-02f, 2.12958425e-01f, -2.14273080e-01f, 5.25297560e-02f, 1.42044500e-01f, 7.53615284e-03f, 2.22083971e-01f,
  2.07160071e-01f, 9.56528634e-02f, 9.19960812e-02f, 1.68568328e-01f, 2.08596081e-01f, -7.63762817e-02f, 1.19541856e-02f, 1.44663468e-01f, -6.52499646e-02f, 2.05961168e-01f,
  1.22440614e-01f, -3.30433935e-01f, 2.48024702e-01f, 8.76622945e-02f, 1.96673825e-01f, -4.52399224e-01f, -9.65160877e-02f, -1.81676850e-01f, -4.16803032e-01f, -5.76072298e-02f,
  3.44234794e-01f, -3.36684406e-01f, -3.42489868e-01f, -2.91875094e-01f, 7.54732592e-03f, -4.59472477e-01f, 9.91225690e-02f, -1.78250626e-01f, 1.50927886e-01f, -3.24039072e-01f,
  1.58646122e-01f, 1.75839171e-01f, 5.84779494e-02f, 2.78410673e-01f, 9.35369655e-02f, 2.82258719e-01f, 2.24931642e-01f, 6.44344464e-02f, -2.45824784e-01f, 2.22186998e-01f,
  -1.13037132e-01f, 5.68348989e-02f, -2.61017144e-01f, 4.16013710e-02f, -3.70289795e-02f, 4.03048366e-01f, -1.85160235e-01f, -1.37793343e-03f, 1.13986194e-01f, 1.88793287e-01f,
  -3.47873598e-01f, 2.76979506e-01f, 1.82905957e-01f, 2.35146686e-01f, 1.47322893e-01f, 2.42091119e-01f, 1.54811397e-01f, 1.69923082e-02f, 3.37185450e-02f, -8.61323103e-02f,
  4.73897606e-02f, 3.92630845e-02f, 7.05568716e-02f, -6.74865693e-02f, -8.76235887e-02f, -5.34327589e-02f, -5.10729989e-03f, -1.56866554e-02f, 1.29175693e-01f, 5.18231839e-02f,
  1.06128767e-01f, 1.10925488e-01f, -1.30557105e-01f, 5.21544740e-02f, 2.29292382e-02f, 1.31289706e-01f, -4.45879668e-01f, -2.57759601e-01f, 2.20063403e-01f, -3.65734138e-02f,
  3.29713464e-01f, -1.54675618e-01f, 2.63956755e-01f, 5.44437915e-02f, -2.23468989e-02f, -3.87213022e-01f, 1.51638731e-01f, 1.90843910e-01f, 8.15607011e-02f, 2.00198069e-01f,
  3.19970727e-01f, 7.52675384e-02f, 1.08654171e-01f, 1.99315414e-01f, 1.76069319e-01f, -2.06346989e-01f, 1.35827750e-01f, -1.66817397e-01f, 1.73627079e-01f, 7.16739669e-02f,
  1.84612468e-01f, 3.92121315e-01f, 2.48882771e-01f, -1.16876297e-01f, 1.86581522e-01f, 3.60553533e-01f, 2.71855950e-01f, 3.11201453e-01f, 9.84140262e-02f, -2.48715937e-01f,
  2.91712850e-01f, 1.73098758e-01f, 1.60441801e-01f, -1.06142387e-01f, 1.32699460e-01f, -4.15000528e-01f, 8.27458780e-03f, -6.89551830e-02f, 4.12185341e-01f, -2.05398947e-01f,
  1.32203192e-01f, -1.70575250e-02f, -7.72388726e-02f, 3.21287572e-01f, 1.43401057e-01f, -4.31561843e-02f, 1.18135475e-01f, -7.66545907e-02f, 1.97627708e-01f, -4.10561003e-02f,
  2.31597964e-02f, 1.72303885e-01f, 1.41253665e-01f, -1.47072587e-03f, 2.02572390e-01f, 1.05566978e-02f, 2.58076757e-01f, -7.00284392e-02f, -1.03070222e-01f, 3.12339306e-01f,
  2.71269202e-01f, -8.26644003e-02f, -7.86878467e-02f, 4.60301526e-02f, 2.01313589e-02f, 2.38486342e-02f, 7.50257354e-03f, 1.24835439e-01f, -9.63307917e-02f, 3.82029921e-01f,
  -3.12180459e-01f, -4.33958322e-02f, -8.38902891e-02f, 9.30599943e-02f, -8.05273131e-02f, -2.15684325e-01f, -1.11144267e-01f, -1.97095513e-01f, 1.97601199e-01f, 3.69990826e-01f,
  2.97561854e-01f, 1.48477763e-01f, 1.73754636e-02f, -4.00897920e-01f, -1.10169016e-01f, 4.68562171e-02f, -1.31097600e-01f, 2.20729828e-01f, 2.21499547e-01f, -2.33165808e-02f,
  -3.15736085e-01f, -6.24261312e-02f, 2.75136847e-02f, 1.94853500e-01f, 5.70381097e-02f, 1.48791283e-01f, 2.93712735e-01f, 3.73899668e-01f, -9.72345546e-02f, 3.72057617e-01f,
  2.96647400e-01f, 6.08077087e-02f, -3.49775344e-01f, 6.05360977e-02f, 1.38064086e-01f, 9.20885429e-02f, -3.67002897e-02f, 1.15496121e-01f, -2.97046285e-02f, 4.48019393e-02f,
  5.75739071e-02f, -1.06866866e-01f, -9.34554264e-02f, -9.22979265e-02f, 3.69535387e-02f, 1.50484582e-02f, 2.02222168e-01f, -9.25937071e-02f, 2.81185787e-02f, 3.80190015e-02f,
  1.57044858e-01f, -8.68300498e-02f, -1.93240821e-01f, 2.64851481e-01f, 7.38666579e-02f, -1.15622446e-01f, 6.53196350e-02f, 3.11786860e-01f, 2.48176739e-01f, 1.28546476e-01f,
  2.74928242e-01f, 2.83539444e-01f, -1.54883116e-01f, -1.88186213e-01f, 3.85662556e-01f, 2.20946684e-01f, 3.13936561e-01f, 1.75461680e-01f, -1.55291796e-01f, 3.89555573e-01f,
  -1.14098914e-01f, 3.24752539e-01f, 3.00011933e-01f, 2.47201063e-02f, 1.60046160e-01f, 4.02317733e-01f, 6.06665090e-02f, -3.11639369e-01f, 1.74613446e-01f, -1.61688905e-02f,
  3.00084114e-01f, 1.65543661e-01f, 2.15456337e-01f, 7.64098689e-02f, 3.41293037e-01f, 2.98556119e-01f, -1.70419350e-01f, 3.28378007e-02f, 3.03977340e-01f, -1.26113668e-01f,
  3.01774591e-01f, 2.46741161e-01f, 7.91389495e-02f, -1.04708895e-01f, 2.63213813e-01f, 8.31116810e-02f, 4.98828590e-02f, 1.95725948e-01f, 2.92280495e-01f, 4.35949750e-02f,
  -3.92590947e-02f, -1.52370825e-01f, 2.12928966e-01f, 2.21979797e-01f, 1.07385486e-01f, 9.59052294e-02f, -2.83628833e-02f, 2.30901122e-01f, -8.67293477e-02f, 1.56413063e-01f,
  -1.27133697e-01f, 1.35721087e-01f, 2.26411238e-01f, 7.17872307e-02f, -1.23072818e-01f, 1.86231360e-01f, 9.59068537e-02f, 3.05408090e-01f, -6.22669496e-02f, -3.92112404e-01f,
  2.23943323e-01f, 5.57189016e-03f, 1.40217587e-01f, 5.21565489e-02f, 1.39606446e-01f, -1.50704429e-01f, -1.05100557e-01f, -6.86068311e-02f, 7.53875151e-02f, 8.44213292e-02f,
  2.09543467e-01f, 3.51309478e-01f, 1.61394060e-01f, -1.79627277e-02f, -2.50868476e-03f, -1.01515904e-01f, 1.20496474e-01f, 2.24030882e-01f, 1.34299304e-02f, 4.36278656e-02f,
  1.46923617e-01f, 4.73809727e-02f, -8.16790834e-02f, 2.30639860e-01f, -3.79946344e-02f, -3.00494790e-01f, 1.97231963e-01f, 4.87895995e-01f, 3.84621978e-01f, -2.56787948e-02f,
  1.24609388e-01f, -1.49046764e-01f, 2.15596892e-02f, 4.85645145e-01f, 8.07676837e-02f, 3.00416172e-01f, 3.36705148e-01f, -8.21349025e-02f, 6.63219988e-02f, 1.97505262e-02f,
  3.33905995e-01f, -9.18476656e-02f, 8.89824927e-02f, 1.79112568e-01f, 7.11535513e-02f, -1.56313077e-01f, 9.54565853e-02f, 1.17951035e-01f, 2.12213710e-01f, 1.91141460e-02f,
  1.62018031e-01f, -3.01575921e-02f, -5.41891828e-02f, 3.81170996e-02f, -7.32766315e-02f, 1.76348150e-01f, -1.74297050e-01f, -8.49036351e-02f, -4.25108559e-02f, 1.46209568e-01f,
  1.17405586e-01f, -2.58798867e-01f, 1.04524665e-01f, -1.65696815e-01f, 1.48490369e-01f, 8.63093697e-03f, 3.43450576e-01f, -2.92169720e-01f, 2.18927264e-01f, -3.05106677e-03f,
  -2.55611360e-01f, -5.06963551e-01f, -1.26355648e-01f, -7.81223699e-02f, 3.19850355e-01f, -1.58907384e-01f, -8.62080082e-02f, 5.88730089e-02f, 6.49429485e-02f, 7.42835104e-02f,
  2.88086653e-01f, -2.22382754e-01f, 4.01917994e-01f, 3.13983202e-01f, 2.25224748e-01f, 2.60323256e-01f, 4.28994298e-01f, -3.08986187e-01f, -2.26671264e-01f, 4.29940879e-01f,
  3.76532882e-01f, -9.16020200e-02f, 9.05915871e-02f, 3.66459906e-01f, -1.30203813e-01f, 4.10409540e-01f, -6.44334406e-02f, -1.50842909e-02f, 1.15876690e-01f, -3.32018994e-02f,
  -2.26134986e-01f, -9.39396545e-02f, 2.86609560e-01f, 9.70764756e-02f, -8.02775100e-02f, 1.91196978e-01f, -6.14970028e-02f, 7.79462680e-02f, 1.69848278e-01f, -1.25132501e-01f,
  5.09240329e-02f, 1.96083501e-01f, 1.55711651e-01f, -1.74408518e-02f, 7.14983940e-02f, 1.28241524e-01f, 2.28507251e-01f, -8.71229023e-02f, 3.09183374e-02f, 8.23097900e-02f,
  -1.48538992e-01f, 1.11604713e-01f, -1.40712112e-01f, 1.69219330e-01f, 1.19752385e-01f, -1.91541389e-01f, -3.83493572e-01f, 9.05989930e-02f, 3.20324123e-01f, 4.24111374e-02f,
  -5.85327707e-02f, -4.75861073e-01f, 1.06450528e-01f, -2.57746071e-01f, 4.99181040e-02f, -3.47439200e-01f, -5.87244406e-02f, -1.76557392e-01f, -9.29132178e-02f, -2.68246889e-01f,
  1.89583272e-01f, -1.04418121e-01f, 2.45115355e-01f, -5.49408123e-02f, -1.29353046e-01f, -3.08390439e-01f, 7.91410431e-02f, -2.05271244e-01f, -1.66645259e-01f, 4.63561326e-01f,
  2.75427520e-01f, 1.18229024e-01f, 2.56594896e-01f, 1.57369390e-01f, 5.06398752e-02f, 2.69470483e-01f, 1.89844117e-01f, 5.47909915e-01f, 3.53917897e-01f, -1.40027190e-02f,
  7.42412955e-02f, 1.07877694e-01f, -5.15720882e-02f, -3.22901845e-01f, -2.11092159e-01f, 2.35036295e-03f, 1.10095264e-02f, 2.24681035e-01f, 2.81083643e-01f, 1.81183115e-01f,
  2.69242406e-01f, 1.99538171e-01f, 5.43546863e-02f, -2.32950613e-01f, 1.23846523e-01f, 3.09044391e-01f, 1.23173766e-01f, 7.62376934e-02f, 2.30831914e-02f, 1.38155162e-01f,
  -1.09099291e-01f, -1.06428422e-01f, -6.27228096e-02f, 3.07324857e-01f, -1.83181241e-01f, 2.47878492e-01f, -8.01836029e-02f, 2.69481689e-01f, 1.05007790e-01f, -2.77815554e-02f,
  4.17234413e-02f, -2.48157099e-01f, 1.87923342e-01f, -2.33628109e-01f, 2.88891017e-01f, -5.86403906e-02f, 4.43297565e-01f, -4.08884026e-02f, 1.14929795e-01f, -4.57821190e-01f,
  2.08948687e-01f, 1.12166917e-02f, -1.42835170e-01f, 1.10559009e-01f, 1.55128222e-02f, 1.67848670e-03f, 1.89448237e-01f, 1.32986277e-01f, -3.28553701e-03f, 7.93457851e-02f,
  3.01594347e-01f, -1.52542770e-01f, -2.78529495e-01f, 7.56937116e-02f, 1.14432171e-01f, -8.16550758e-03f, 4.93768342e-02f, 1.67260006e-01f, 2.58693635e-01f, 1.73366383e-01f,
  1.45668462e-01f, -1.00856572e-02f, -4.50373180e-02f, -3.42813395e-02f, 1.77438632e-01f, 1.96183234e-01f, 3.76212597e-01f, -2.40578979e-01f, -1.49315417e-01f, -4.09994245e-01f,
  5.49180955e-02f, 2.76003718e-01f, -4.02216092e-02f, -7.16485456e-02f, -2.38773942e-01f, 3.51216570e-02f, 2.27727786e-01f, 2.86143184e-01f, 1.27105176e-01f, -7.57251158e-02f,
  1.18644141e-01f, 6.11303076e-02f, 9.46782902e-02f, -6.37993291e-02f, 8.51083398e-02f, 1.66027904e-01f, 5.54654412e-02f, -6.93572313e-02f, -1.18982084e-01f, -2.81078536e-02f,
  2.25501180e-01f, 5.71948029e-02f, -3.03934496e-02f, -3.48009765e-01f, 3.18879992e-01f, 1.77712917e-01f, 1.33216558e-02f, -9.41250920e-02f, -8.10557008e-02f, -1.79270625e-01f,
  -2.91219682e-01f, 1.84700578e-01f, 4.22098823e-02f, 3.89154889e-02f, -2.23852113e-01f, -1.09022744e-02f, -1.31895259e-01f, -2.65947372e-01f, -2.83068627e-01f, -1.02865085e-01f,
  -1.25798956e-02f, 8.21290724e-03f, 1.43345892e-01f, 2.66172171e-01f, 1.74164623e-01f, 1.65187418e-01f, 1.12123400e-01f, 2.06249043e-01f, 3.80626142e-01f, -2.25652203e-01f,
  -3.16165239e-01f, 5.88679492e-01f, 2.61316150e-01f, -2.15489104e-01f, -2.55246580e-01f, 2.39574894e-01f, 7.13886768e-02f, 5.37388325e-01f, -1.48145482e-01f, -3.04505438e-01f,
  1.40054271e-01f, 7.21031949e-02f, -1.65197968e-01f, 7.38429353e-02f, 4.34637874e-01f, 3.42575669e-01f, -2.68911570e-01f, 3.60157937e-01f, -4.93680798e-02f, -3.68144386e-03f,
  1.83959216e-01f, -3.73920947e-02f, 6.61974922e-02f, -8.40867124e-03f, 1.09345891e-01f, 2.39162415e-01f, -5.33339381e-02f, 3.40043032e-03f, 1.29192606e-01f, -5.73118888e-02f,
  -4.61339913e-02f, 2.21687347e-01f, -4.23710607e-02f, 2.74947733e-02f, -8.61934870e-02f, 1.89313322e-01f, 2.21348777e-01f, -3.90620202e-01f, -2.65158057e-01f, 4.06628884e-02f,
  1.85511366e-01f, 1.31976390e-02f, 1.42001957e-01f, -1.91449896e-01f, 9.18805078e-02f, -8.27300027e-02f, 5.49648255e-02f, -4.08020288e-01f, -1.32857338e-01f, -7.20941424e-02f,
  5.97963817e-02f, -2.22853556e-01f, -2.30563551e-01f, -1.34166449e-01f, 9.05782506e-02f, 2.88799033e-02f, 5.79407476e-02f, -1.38377860e-01f, 3.33527565e-01f, -2.18619592e-02f,
  -1.04262806e-01f, 4.57315654e-01f, 4.78556514e-01f, -6.15862198e-02f, 4.26505283e-02f, 2.61449754e-01f, 1.96505442e-01f, 1.26663391e-02f, 1.63615942e-01f, 3.29742104e-01f,
  1.99911576e-02f, 2.03723565e-01f, -7.77660906e-02f, -2.70900816e-01f, 1.88292280e-01f, -2.71784335e-01f, -2.55783916e-01f, -7.72251263e-02f, 1.27587272e-02f, 2.17901424e-01f,
  2.99829513e-01f, 3.25870067e-01f, -1.95396580e-02f, -1.09026179e-01f, -3.75752188e-02f, -1.57406434e-01f, -1.98554769e-01f, -9.96469632e-02f, 2.35547926e-02f, 2.04326630e-01f,
  1.19375609e-01f, 8.37873295e-02f, 5.06572761e-02f, 1.10248262e-02f, -1.15811594e-01f, -1.33847430e-01f, 6.83793873e-02f, -1.03308797e-01f, -4.87719011e-03f, 1.57840505e-01f,
  9.69953761e-02f, 3.79534923e-02f, -1.00269102e-01f, -6.84880540e-02f, 1.09060556e-01f, 3.06441337e-02f, 9.56457853e-02f, -1.13340132e-01f, -1.36459276e-01f, 1.73848599e-01f,
  1.07316673e-01f, -2.13391483e-01f, 8.20576772e-03f, 2.07648292e-01f, 3.42901409e-01f, -4.84870560e-02f, 3.56110185e-01f, 3.64773534e-02f, 2.08242372e-01f, 3.49163525e-02f,
  2.15583295e-01f, -6.95403740e-02f, 1.46561805e-02f, 6.55260533e-02f, 3.14479083e-01f, 1.81314886e-01f, 8.46282095e-02f, 2.46642336e-01f, 5.71920872e-02f, -2.66233653e-01f,
  8.95201787e-02f, 2.34062612e-01f, 4.53611523e-01f, 2.94049889e-01f, 1.93385407e-01f, -2.79184073e-01f, 8.99111629e-02f, 4.42721546e-02f, 1.11743070e-01f, 2.88568828e-02f,
  -6.96283579e-02f, 1.82347134e-01f, 3.39589529e-02f, -2.14893937e-01f, 5.84368825e-01f, -1.46782482e-02f, 1.73776925e-01f, 2.42532387e-01f, 1.70344859e-01f, -1.86232731e-01f,
  2.86313295e-02f, 2.32779682e-01f, 2.15910360e-01f, 1.45866185e-01f, 2.59088159e-01f, 1.78036317e-01f, 1.76131666e-01f, 4.93172109e-02f, -1.74132362e-02f, 5.46755493e-02f,
  9.35114846e-02f, 1.68393120e-01f, -1.02028415e-01f, 8.16200152e-02f, 1.63170725e-01f, -4.01631027e-01f, 2.87202090e-01f, -1.84411988e-01f, 5.82794547e-02f, -4.29306567e-01f,
  -1.69502944e-01f, 1.37833089e-01f, 5.74371032e-02f, 1.34890020e-01f, 3.15406740e-01f, -2.34387547e-01f, -2.49325648e-01f, -1.96191192e-01f, -1.60538688e-01f, -2.92676479e-01f,
  -1.06116243e-01f, -2.95045376e-01f, -3.12865049e-01f, 1.26440153e-01f, 1.18157506e-01f, 2.90530175e-01f, 2.13586763e-01f, -1.12209916e-01f, -1.23021603e-01f, 1.91501811e-01f,
  1.89207911e-01f, 1.42555088e-01f, -4.40418303e-01f, 1.63536727e-01f, -1.43004805e-01f, 2.89328434e-02f, -1.50181457e-01f, -4.03416216e-01f, 3.87501568e-02f, 2.54572064e-01f,
  1.81170374e-01f, 4.05436419e-02f, 1.22004613e-01f, 2.12712601e-01f, -1.80674419e-01f, -2.27919504e-01f, 4.27826524e-01f, 2.73342609e-01f, 2.07008775e-02f, -6.13459805e-03f,
  8.18913206e-02f, -1.24099277e-01f, 7.37680495e-02f, 1.89048290e-01f, 2.72978004e-02f, 1.36555165e-01f, 1.02524593e-01f, -1.73267663e-01f, 1.82947859e-01f, 2.09705621e-01f,
  -1.16499728e-02f, 1.62692130e-01f, 1.24784745e-01f, -1.35974020e-01f, -1.26411170e-01f, 2.63324142e-01f, 1.07655309e-01f, -1.83771878e-01f, -3.21798623e-01f, 4.35117215e-01f,
  -1.66147023e-01f, -7.35240281e-02f, 2.35543832e-01f, 2.23650530e-01f, 2.98029184e-01f, -4.15823728e-01f, 2.91952640e-01f, -1.95689291e-01f, -1.68917999e-01f, 8.99859797e-03f,
  -1.55085713e-01f, -9.51406211e-02f, 9.92076024e-02f, 2.99745679e-01f, 3.91698122e-01f, -1.96911588e-01f, 3.87200832e-01f, -1.82500452e-01f, -4.28156070e-02f, -2.70274073e-01f,
  1.03002369e-01f, 2.11741015e-01f, -1.49188891e-01f, -3.02014261e-01f, 9.30110142e-02f, 3.01119804e-01f, 1.90610349e-01f, -1.50224447e-01f, 6.03941828e-02f, 2.99465150e-01f,
  -2.23583281e-02f, 3.13905627e-01f, 1.25321403e-01f, -2.24391967e-01f, 3.72258504e-03f, 3.81279409e-01f, 9.25511345e-02f, 7.83393383e-02f, -7.27205276e-02f, 3.79043579e-01f,
  7.04828352e-02f, -3.02663147e-01f, 4.98482212e-02f, 2.74228275e-01f, 2.15937018e-01f, 4.38720919e-02f, 1.35269091e-01f, -1.70089751e-01f, 1.25574961e-01f, 2.10284293e-01f,
  6.35469481e-02f, 8.17554370e-02f, 2.14543715e-01f, 2.20104188e-01f, 9.50162560e-02f, 9.24090520e-02f, -7.55339935e-02f, 2.64207542e-01f, -7.94299506e-03f, 2.34596044e-01f,
  3.06057232e-03f, 2.16634899e-01f, 1.66548774e-01f, -1.29949346e-01f, -6.90845847e-02f, -2.92166084e-01f, 2.65572548e-01f, -2.44400844e-01f, -2.25831434e-01f, -2.22094029e-01f,
  9.20880288e-02f, -3.75224620e-01f, 1.49227306e-01f, -1.19517088e-01f, -3.41855526e-01f, -1.13902032e-01f, -5.51031604e-02f, 4.42016423e-02f, 1.78277493e-01f, -2.78174907e-01f,
  2.91075945e-01f, -3.42164189e-01f, -3.57569903e-01f, 2.11084083e-01f, 1.54136971e-01f, -2.50573099e-01f, -2.47676462e-01f, 2.65021622e-01f, 1.38836103e-02f, 3.37939620e-01f,
  -2.94019103e-01f, -3.14532727e-01f, 1.64907366e-01f, 3.29101801e-01f, -3.18118870e-01f, -1.32926479e-01f, 2.64477879e-01f, -1.60876974e-01f, -2.92631328e-01f, 2.40668163e-01f,
  2.67803311e-01f, -4.85030375e-02f, 5.37538566e-02f, -1.24220811e-02f, 5.08052520e-02f, 1.45041093e-01f, -2.62922365e-02f, 7.60118514e-02f, -5.23728542e-02f, 4.24076393e-02f,
  8.66144076e-02f, 2.15265125e-01f, 1.02504678e-01f, -4.12051193e-03f, 4.50941473e-02f, 6.62789419e-02f, 4.66498621e-02f, 1.28996775e-01f, 2.01342240e-01f, 1.41554903e-02f,
  1.45330623e-01f, -4.44190428e-02f, 2.40728781e-02f, 1.74378142e-01f, 2.37591326e-01f, -4.30194512e-02f, -1.41809089e-03f, -1.66051149e-01f, 2.10467681e-01f, 1.53792977e-01f,
  -1.89450920e-01f, -1.32145137e-01f, -4.11767632e-01f, 1.31301463e-01f, -2.14929283e-01f, -1.19716503e-01f, 2.09810928e-01f, 3.69402379e-01f, -2.93274343e-01f, -2.54279912e-01f,
  -1.45034581e-01f, -2.28945062e-01f, -2.48624280e-01f, -1.08569421e-01f, 2.50142273e-02f, -2.53560394e-01f, 1.51424676e-01f, 2.92402506e-01f, -8.88752043e-02f, 1.87495992e-01f,
  -9.36276093e-02f, 1.49809226e-01f, 4.25832197e-02f, 2.05548748e-01f, -6.81610182e-02f, 3.19359414e-02f, -2.40259687e-03f, 2.79533565e-02f, -2.47073665e-01f, 6.25609001e-03f,
  2.90172100e-01f, 2.51871318e-01f, 1.25303846e-02f, 1.66071862e-01f, -8.61188918e-02f, 5.83489090e-02f, -8.64960179e-02f, 4.95381713e-01f, 2.33765110e-01f, 3.11714023e-01f,
  -2.85821974e-01f, 2.80977428e-01f, 5.53091280e-02f, 2.10114829e-02f, 1.31650046e-01f, 9.75365117e-02f, -9.54860747e-02f, 4.91310656e-02f, 2.17311215e-02f, 2.20516697e-01f,
  9.50854644e-02f, 2.41865173e-01f, -9.58787948e-02f, 4.63282727e-02f, 1.36939764e-01f, 1.36185512e-01f, -4.03065570e-02f, 2.30054371e-02f, 7.97171891e-02f, 2.01897651e-01f,
  -4.45606522e-02f, 2.63104942e-02f, 4.57525164e-01f, 1.06465809e-01f, -5.99366613e-02f, 9.76530835e-03f, 4.83532622e-02f, -1.09256677e-01f, -9.67286080e-02f, 1.39856488e-01f,
  -1.56624801e-02f, -9.93423015e-02f, 2.14320481e-01f, -7.28504434e-02f, 4.71990891e-02f, -6.86607957e-02f, 1.27387822e-01f, 6.78170845e-02f, 1.67815790e-01f, 5.02954721e-02f,
  2.34879255e-01f, 1.46675408e-02f, 2.30984420e-01f, 3.54794651e-01f, -1.72940850e-01f, -1.05936691e-01f, 1.74729690e-01f, -7.51033202e-02f, 1.47240639e-01f, 1.02086482e-03f,
  -1.86039098e-02f, 6.51401132e-02f, 1.25113204e-01f, 3.96316648e-01f, -7.75451511e-02f, 1.27645329e-01f, 6.46698922e-02f, -1.05281617e-03f, -2.53893696e-02f, 3.23912911e-02f,
  -1.47844806e-01f, 3.13040733e-01f, 1.05149947e-01f, 1.39306605e-01f, -1.08272098e-01f, 3.29286695e-01f, 1.14114314e-01f, 2.07957074e-01f, 1.36775360e-01f, 3.37725818e-01f,
  5.08115105e-02f, -1.01080075e-01f, -8.84377770e-03f, -5.71860336e-02f, 1.20471351e-01f, 8.02992433e-02f, 1.40495777e-01f, 1.33206621e-02f, 1.62045777e-01f, -1.94305070e-02f,
  6.38233572e-02f, 2.05922395e-01f, 5.75923659e-02f, 1.74266294e-01f, -4.98522334e-02f, -2.36226972e-02f, 3.37150723e-01f, -7.29004294e-02f, -1.07223950e-01f, -1.78125367e-01f,
  -3.01148355e-01f, 4.22448128e-01f, 5.13873585e-02f, 2.12990746e-01f, 1.49530411e-01f, 3.65741074e-01f, 1.93676189e-01f, 3.68473381e-01f, -1.81620225e-01f, 7.86434412e-02f,
  -3.07533056e-01f, 1.45076901e-01f, -2.31227025e-01f, 2.85346746e-01f, 3.46005678e-01f, 2.24349052e-01f, 9.30355638e-02f, -1.61763430e-01f, 4.60249409e-02f, -3.21573138e-01f,
  -2.68709719e-01f, 2.92270422e-01f, 7.08047524e-02f, -8.26731026e-02f, -3.83996293e-02f, 1.99640486e-02f, 1.71467155e-01f, -4.08843517e-01f, 2.20769048e-02f, 2.54906826e-02f,
  4.25913244e-01f, 2.45970398e-01f, 2.54845798e-01f, 3.24865371e-01f, 2.01928928e-01f, -3.54283929e-01f, -1.77082997e-02f, 4.02534604e-01f, -1.03527740e-01f, -2.25876078e-01f,
  3.16182673e-01f, 2.63382554e-01f, 1.93440672e-02f, -1.09088548e-01f, 2.07962513e-01f, 2.58834660e-01f, 2.09242970e-01f, 1.78090170e-01f, 4.42997888e-02f, 1.62581652e-01f,
  1.80300787e-01f, -8.04633461e-03f, -9.48274136e-02f, 2.85975158e-01f, 8.19623917e-02f, 1.41865045e-01f, 6.46063313e-02f, 1.23238690e-01f, 1.95941478e-01f, -2.69049227e-01f,
  2.72098660e-01f, -2.36796543e-01f, 1.64886445e-01f, -3.56133044e-01f, -2.67588228e-01f, 2.18230456e-01f, 1.87983856e-01f, -4.90523987e-02f, 4.23000395e-01f, 1.39409766e-01f,
  -1.98755503e-01f, -1.68721050e-01f, -3.78992826e-01f, -4.88812514e-02f, -2.91691329e-02f, -1.84365079e-01f, -5.50557524e-02f, -4.70798202e-02f, -6.18839376e-02f, 4.86605883e-01f,
  -5.85730895e-02f, -3.35088968e-01f, -1.35823295e-01f, 2.67029405e-01f, -1.63033515e-01f, 3.26602519e-01f, -1.96730331e-01f, -7.51496628e-02f, 1.25692189e-01f, 2.19705209e-01f,
  3.28542218e-02f, -4.02922392e-01f, 1.26625404e-01f, 9.39187035e-02f, 3.90165113e-02f, 1.99875996e-01f, 1.49471521e-01f, 1.32226214e-01f, 1.53160334e-01f, -2.54644245e-01f,
  6.37110770e-02f, 2.68489003e-01f, 6.93411902e-02f, -1.52143463e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  2.00441070e-02f, -7.08805211e-03f, 2.40925550e-01f, 7.17853010e-02f, 1.79160208e-01f, 4.38184217e-02f, -3.84430103e-02f, 1.13888264e-01f, 2.03013010e-02f, 5.65786399e-02f,
  5.14914021e-02f, 1.31145120e-01f, 8.96864235e-02f, -1.03040105e-02f, 1.00533687e-01f, 3.28549906e-03f, -6.50270726e-04f, -2.40856074e-02f, -1.85566340e-02f, 1.76185351e-02f,
  -3.12542841e-02f, 2.27262080e-03f, 7.59658292e-02f, 1.77062377e-02f, 2.17936575e-01f, 1.12055041e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  2.58089434e-02f, -6.91395253e-02f, -2.14737520e-01f, -1.29909530e-01f, -1.84899896e-01f, 1.83748156e-01f, -7.51411617e-02f, 9.36995819e-02f, -1.27877086e-01f, 5.18571632e-03f,
  4.60775979e-02f, 1.65445097e-02f, -5.51861264e-02f, 1.03162959e-01f, 1.43805474e-01f, 5.16496226e-02f, 9.52715650e-02f, 8.95220935e-02f, -1.19489573e-01f, 3.14037830e-01f,
  1.49304613e-01f, 2.29662508e-01f, -4.19247374e-02f, 3.55669260e-02f, 8.13153684e-02f, 1.19453475e-01f, -2.00397849e-01f, -2.31514543e-01f, -2.15841293e-01f, -3.55497330e-01f,
  1.96237609e-01f, -3.67528409e-01f, 3.54424179e-01f, 1.02094218e-01f, -1.63901806e-01f, -3.17286700e-01f, 1.11988120e-01f, -1.73630305e-02f, -3.45988840e-01f, -2.50992358e-01f,
  -1.97222650e-01f, -1.62983492e-01f, 6.22162828e-03f, -2.36729354e-01f, 1.72144458e-01f, -2.66661286e-01f, 1.54403448e-01f, -3.87827426e-01f, 1.77642763e-01f, -3.98497283e-02f,
  -4.25813377e-01f, -2.32940525e-01f, -3.08248818e-01f, -2.30975449e-01f, 2.76868522e-01f, -1.39672399e-01f, -1.76549226e-01f, 2.90303558e-01f, -1.48535520e-01f, -2.07790434e-01f,
  2.54874468e-01f, -7.00510591e-02f, 2.91089058e-01f, 1.24014296e-01f, 1.12550035e-01f, -1.22805610e-01f, 1.46128774e-01f, 1.25242203e-01f, -1.23865925e-01f, 5.94809987e-02f,
  1.63880214e-01f, -1.23348050e-01f, 8.51392895e-02f, -1.78087622e-01f, -4.40252805e-03f, 1.31015524e-01f, -3.60342003e-02f, 1.58376455e-01f, 1.43138291e-02f, 1.98450208e-01f,
  -7.96326101e-02f, 6.84322566e-02f, 2.41704389e-01f, 2.54574299e-01f, 1.01418786e-01f, 3.66902858e-01f, -1.93162009e-01f, -1.38109818e-01f, 1.88687935e-01f, 7.06579685e-02f,
  3.13316375e-01f, 2.54571140e-01f, -1.46830350e-01f, -4.24133167e-02f, -1.94509104e-01f, -1.34781837e-01f, 1.78150594e-01f, -1.71065256e-01f, -5.08508692e-03f, -1.12163171e-01f,
  1.01234615e-02f, 2.15406328e-01f, -8.09334517e-02f, -1.83447003e-01f, -7.20167160e-02f, 8.11151415e-02f, 3.52788568e-01f, -2.36114681e-01f, 1.93550393e-01f, 9.07411575e-02f,
  -3.34741741e-01f, -4.29734997e-02f, -3.04554999e-02f, 1.78929076e-01f, 1.00001998e-01f, -2.89599180e-01f, -2.96180069e-01f, 2.14702502e-01f, -3.16558212e-01f, -3.21720004e-01f,
  -1.81648418e-01f, -7.60146156e-02f, -4.26616013e-01f, -5.90472594e-02f, -7.48594776e-02f, 8.00611544e-03f, 3.16738248e-01f, 2.05702856e-01f, 1.14648007e-01f, 8.04410949e-02f,
  1.55055717e-01f, 1.85805224e-02f, -4.67937142e-02f, 1.57747626e-01f, -9.57430527e-03f, 1.58376973e-02f, -2.21561790e-01f, 8.17962140e-02f, 3.98475043e-02f, -2.11928770e-01f,
  8.67101699e-02f, -3.70630808e-02f, -4.18197811e-02f, 1.05779819e-01f, 1.75371375e-02f, 1.04611702e-02f, 2.42778882e-02f, 3.80464122e-02f, -1.62663102e-01f, -3.23402993e-02f,
  -3.84602733e-02f, -1.08247228e-01f, 7.91256055e-02f, -1.89794749e-01f, 1.99491441e-01f, 1.59397915e-01f, -7.56033584e-02f, -8.75880867e-02f, -1.03168562e-01f, 1.02528639e-01f,
  1.91152453e-01f, -2.11090535e-01f, 2.04192638e-01f, 1.21173009e-01f, -2.12463230e-01f, 1.26527578e-01f, 1.30829975e-01f, -4.44819450e-01f, -1.77130252e-01f, -2.04398990e-01f,
  5.54052629e-02f, -1.36672840e-01f, -9.68247652e-02f, -1.00881644e-01f, -3.44976187e-01f, 2.68501937e-01f, -3.20505232e-01f, 1.38731375e-01f, 3.92806940e-02f, -1.35338921e-02f,
  3.01540762e-01f, 1.64552167e-01f, -2.78158426e-01f, 1.15232117e-01f, 1.96400627e-01f, -3.43611419e-01f, 2.13171646e-01f, -2.10523441e-01f, -4.50779080e-01f, 2.21328244e-01f,
  -3.45781557e-02f, -1.98098525e-01f, 7.30937943e-02f, -3.24363969e-02f, -1.49486035e-01f, -6.21363930e-02f, 3.63770500e-02f, -4.45984304e-02f, -1.40726134e-01f, -2.72116493e-02f,
  3.31247002e-02f, -6.46378547e-02f, -2.21811995e-01f, 6.36139065e-02f, -1.62790671e-01f, -1.54579282e-01f, -3.05971712e-01f, 1.82344317e-02f, -1.02353752e-01f, -1.37420207e-01f,
  -1.98404744e-01f, 5.51985651e-02f, 2.22041637e-01f, 1.92569688e-01f, -7.57001713e-02f, 2.52556086e-01f, 2.04818785e-01f, 1.15566052e-01f, -4.69750538e-02f, -2.31290609e-03f,
  1.08975314e-01f, 1.54936433e-01f, -3.59957129e-01f, -2.91771293e-01f, 2.12893169e-02f, -5.89633500e-03f, -8.52481499e-02f, 2.34156787e-01f, 2.47529238e-01f, -1.60656661e-01f,
  -1.31570380e-02f, -1.25021338e-01f, -1.18268982e-01f, 1.91047922e-01f, -3.84492993e-01f, -2.42810920e-01f, 2.01345205e-01f, -8.82130787e-02f, 6.51935115e-02f, -3.65154862e-01f,
  3.48417312e-02f, 9.10711884e-02f, -4.16926146e-01f, 2.58595765e-01f, -3.47081386e-02f, 3.70590128e-02f, 2.68043935e-01f, 2.16564685e-01f, -3.52478057e-01f, 7.00144693e-02f,
  -4.16708320e-01f, -3.05839360e-01f, -3.00613008e-02f, 1.11729190e-01f, -3.23333651e-01f, -3.86832029e-01f, 5.38810343e-02f, 1.37257785e-01f, 2.69937694e-01f, 5.28281629e-02f,
  1.50405392e-01f, 3.38533185e-02f, -1.04457185e-01f, -8.17253664e-02f, -4.52906638e-02f, -4.83012274e-02f, 5.95358573e-02f, 1.01910822e-01f, 1.13189712e-01f, 1.04852065e-01f,
  8.53794366e-02f, -1.95482880e-01f, -7.47637376e-02f, 2.05433927e-02f, 2.02503223e-02f, -8.93563703e-02f, -2.48176083e-01f, -9.19771492e-02f, -3.19456965e-01f, -2.40922913e-01f,
  -1.17040403e-01f, 2.40194827e-01f, -3.39612812e-02f, -2.47311309e-01f, 2.53915101e-01f, 1.51828110e-01f, 2.66699344e-01f, 9.28687528e-02f, 7.13741556e-02f, 2.49908954e-01f,
  -2.10188795e-02f, 2.09282249e-01f, -3.57333690e-01f, -3.69298905e-02f, -3.63178283e-01f, 9.97632071e-02f, -3.75883669e-01f, 8.62526149e-02f, -1.24303862e-01f, -2.00694114e-01f,
  -2.57898092e-01f, -5.04418612e-01f, 1.94612697e-01f, -1.36169568e-01f, -8.26327056e-02f, -1.99314132e-01f, -8.54917094e-02f, 1.74598530e-01f, 1.73946857e-01f, 3.02062541e-01f,
  1.93807036e-01f, 9.56717879e-02f, -2.53795058e-01f, 2.50926882e-01f, -8.11031088e-02f, 1.53267920e-01f, 6.05165120e-03f, 8.48084167e-02f, -2.01432541e-01f, 1.26537919e-01f,
  4.53866497e-02f, 1.16919719e-01f, 1.29986301e-01f, 1.75069630e-01f, -1.38063368e-03f, -1.26196578e-01f, 8.01740512e-02f, 1.99499175e-01f, -2.04285316e-04f, 6.05200268e-02f,
  1.12093978e-01f, -4.77064215e-02f, 3.46820578e-02f, -1.98596939e-01f, -5.93212843e-02f, -2.73629755e-01f, -3.48621793e-02f, 1.02727555e-01f, -7.51859620e-02f, -1.20342053e-01f,
  1.68279886e-01f, -4.29810323e-02f, -4.89730015e-02f, -2.12835714e-01f, -1.66909948e-01f, 2.43799642e-01f, -1.54686645e-01f, -8.19743723e-02f, -2.73628294e-01f, 4.77955900e-02f,
  3.35709214e-01f, 2.57936925e-01f, -3.85055572e-01f, -6.94462508e-02f, -3.90737206e-02f, -1.83371648e-01f, -2.35679954e-01f, -1.95840806e-01f, -3.98451649e-02f, 2.81844854e-01f,
  -6.33772537e-02f, 2.02273265e-01f, -1.47599146e-01f, 6.36168718e-02f, -2.20057026e-01f, 2.61274874e-01f, 3.92105132e-02f, -4.27649587e-01f, 1.67985275e-01f, -3.40518892e-01f,
  1.00326270e-01f, -4.15118366e-01f, -4.73621368e-01f, -1.23260170e-01f, -8.31940100e-02f, -3.06851327e-01f, -1.86942428e-01f, 1.80121601e-01f, -1.94461778e-01f, 2.03236669e-01f,
  1.54936939e-01f, 1.84856832e-03f, 8.55646208e-02f, 2.36668095e-01f, -1.33356690e-01f, 5.95300756e-02f, -6.96869642e-02f, -2.09865496e-01f, -1.23499893e-02f, -1.72030404e-01f,
  -1.92135144e-02f, -2.45279089e-01f, -2.60938048e-01f, 1.74441710e-01f, 1.05514079e-01f, 9.99234766e-02f, -7.70947263e-02f, -1.81392431e-01f, -1.49716020e-01f, -1.30334228e-01f,
  1.08258925e-01f, -2.12126933e-02f, 1.49801522e-01f, -1.40425295e-01f, -1.85930818e-01f, -1.66385368e-01f, 2.72612602e-01f, -1.39306605e-01f, -1.95961744e-01f, -2.48318955e-01f,
  2.54837602e-01f, 1.79355577e-01f, -3.63761894e-02f, 1.03666268e-01f, -2.91159421e-01f, 2.59860381e-02f, -8.48104283e-02f, -1.08400747e-01f, -1.06268860e-01f, -3.51952285e-01f,
  -2.40031064e-01f, 8.00382495e-02f, 5.46993539e-02f, 2.57639587e-01f, 1.39080450e-01f, -4.90845442e-02f, 1.45174591e-02f, 2.66096026e-01f, -2.15737402e-01f, 1.56829685e-01f,
  -3.29375982e-01f, 6.34187460e-02f, 8.59041214e-02f, -1.79953948e-01f, 6.45669997e-02f, -3.03856522e-01f, -2.34178677e-02f, -1.09907851e-01f, -3.56241763e-01f, -3.66224736e-01f,
  -1.18415467e-01f, -5.22404015e-01f, 3.63141090e-01f, 1.77320957e-01f, 2.67821476e-02f, -3.07742864e-01f, -1.97014093e-01f, 2.34939698e-02f, -2.75736693e-02f, -4.50434126e-02f,
  4.33738828e-02f, 8.48109424e-02f, -8.38551074e-02f, -1.06898069e-01f, 5.70255183e-02f, -1.17692314e-01f, -1.41274527e-01f, -6.08446859e-02f, 1.17446095e-01f, 1.25325276e-02f,
  -2.21384726e-02f, 6.02996238e-02f, -1.36104628e-01f, 1.37676582e-01f, 1.88723374e-02f, 1.13256283e-01f, -1.06010154e-01f, 2.70340979e-01f, -1.09705955e-01f, -2.26527005e-01f,
  1.96478933e-01f, 2.73713797e-01f, -1.40838936e-01f, 1.06629804e-02f, 2.13049531e-01f, -8.05964619e-02f, 1.94999948e-01f, -1.13190738e-02f, -5.08918911e-02f, -1.90684557e-01f,
  4.01543267e-03f, 9.83785540e-02f, 5.52396476e-02f, 1.04604572e-01f, -2.16526538e-01f, -8.81664976e-02f, -2.54537195e-01f, -2.02999115e-01f, 3.50233585e-01f, -1.37742445e-01f,
  -2.03804851e-01f, 2.73390502e-01f, -2.90161967e-01f, -2.83925086e-01f, 8.07990730e-02f, -2.34359145e-01f, -2.60568738e-01f, -2.76288182e-01f, -3.08736593e-01f, 4.20114174e-02f,
  3.34228456e-01f, -3.77893955e-01f, 2.96292156e-01f, 2.86653221e-01f, 3.70479189e-02f, -2.97300756e-01f, -1.23107806e-01f, 2.35294495e-02f, 1.86402649e-01f, 1.38032019e-01f,
  -2.31544092e-01f, -3.01212758e-01f, -9.95581970e-02f, -8.42057019e-02f, 6.87488317e-02f, 8.51784125e-02f, -1.19971354e-02f, -1.47407398e-01f, -1.27328157e-01f, -5.21384403e-02f,
  1.05775997e-01f, -1.47141963e-01f, 9.94490981e-02f, 6.35315329e-02f, 1.14720054e-01f, 5.73795848e-02f, -1.02935068e-01f, 4.06054445e-02f, -1.59935921e-01f, -1.90984413e-01f,
  -5.83134294e-02f, -2.38974616e-01f, 2.04228908e-01f, -2.31873438e-01f, 5.90653829e-02f, 3.67335767e-01f, 9.47297066e-02f, -6.01202585e-02f, -1.50324970e-01f, 1.89537629e-01f,
  4.07731570e-02f, 2.46564493e-01f, -1.24605494e-02f, -1.30335912e-01f, -3.16778928e-01f, -2.06886306e-01f, 2.19085813e-01f, 2.36659124e-01f, 8.88695791e-02f, 1.57603472e-01f,
  2.91585863e-01f, -4.83355336e-02f, 4.07044351e-01f, -2.42050916e-01f, 1.19475008e-03f, -2.36408025e-01f, -2.68711925e-01f, 3.09903264e-01f, -9.11627337e-02f, 9.20553133e-02f,
  -1.21517777e-01f, 8.32853243e-02f, 1.85849607e-01f, -1.54848814e-01f, -2.30144367e-01f, -4.65546280e-01f, -1.58461258e-01f, -3.16620260e-01f, 1.50263280e-01f, -3.78700435e-01f,
  -1.71664104e-01f, -3.06823671e-01f, -2.90514827e-01f, -1.03034265e-01f, 7.48900771e-02f, -5.42237097e-03f, 7.84534067e-02f, 4.08504903e-03f, -1.64273530e-01f, -1.37175754e-01f,
  7.17730075e-02f, -1.66779757e-01f, 2.13740021e-01f, 9.80341434e-02f, 1.43058255e-01f, -1.21898137e-01f, 5.38135543e-02f, -1.02743162e-02f, 1.62168637e-01f, 7.36450031e-02f,
  4.66798134e-02f, 6.88679963e-02f, -1.73678882e-02f, -9.81964022e-02f, 9.84708965e-02f, -2.13160552e-02f, -1.26557767e-01f, -1.59483552e-01f, 1.87400743e-01f, 1.35616243e-01f,
  8.55727047e-02f, -1.50131419e-01f, -1.14571057e-01f, 2.99526483e-01f, 2.67906904e-01f, -3.46290469e-01f, 3.16933215e-01f, 2.59366035e-01f, -1.64071649e-01f, 6.22130893e-02f,
  -1.54126212e-01f, 2.89819419e-01f, -1.70926258e-01f, -2.47172236e-01f, -2.17266470e-01f, 2.24880408e-03f, 1.00775763e-01f, -1.94325596e-01f, -2.55275398e-01f, -6.78611919e-02f,
  -4.74460460e-02f, -3.05712763e-02f, 1.99731857e-01f, 1.63552880e-01f, -4.83133852e-01f, -3.79103005e-01f, 1.21150889e-01f, -1.47232234e-01f, 1.70548618e-01f, 9.35974568e-02f,
  -3.73849273e-01f, 1.28288075e-01f, 1.81400776e-01f, 1.84168696e-01f, -2.15673055e-02f, 2.79219449e-01f, -8.85405317e-02f, -3.58551145e-01f, -3.73466313e-01f, 2.71471888e-01f,
  -1.58040270e-01f, -1.39840826e-01f, -1.56604230e-01f, -2.60574073e-01f, -1.88144837e-02f, -1.05551347e-01f, 9.70102102e-02f, -1.01354197e-01f, 1.73268821e-02f, -3.36495079e-02f,
  -1.96169302e-01f, -1.88604116e-01f, 3.82230937e-04f, -1.38919624e-02f, 2.28320733e-01f, 7.65472800e-02f, -8.79013836e-02f, -1.98096931e-01f, 1.10024117e-01f, -1.70443445e-01f,
  9.17969197e-02f, 1.40824854e-01f, -5.30611314e-02f, -1.32139027e-01f, 2.82351440e-03f, -7.72078261e-02f, -1.07266866e-01f, -2.90624052e-01f, -1.47724092e-01f, 1.81840375e-01f,
  2.36185938e-02f, 7.31769577e-02f, 2.86063761e-01f, 3.91797461e-02f, 1.08785495e-01f, -2.43140578e-01f, 1.58912137e-01f, 5.07612787e-02f, 1.79198340e-01f, 1.68594345e-01f,
  -3.06534111e-01f, 4.91816290e-02f, 1.53571814e-02f, -2.21325532e-01f, 2.55156487e-01f, -3.74351829e-01f, -9.57144722e-02f, 1.08240366e-01f, 1.28114745e-01f, 1.97406203e-01f,
  1.51914090e-01f, 1.85971871e-01f, -4.06032920e-01f, 5.74603975e-02f, 1.54723842e-02f, 2.52888189e-03f, -1.71569444e-03f, 3.09718996e-02f, -1.52516797e-01f, -1.96884349e-01f,
  -2.89087504e-01f, -6.84923083e-02f, -2.32749786e-02f, -1.70511767e-01f, -4.15762514e-02f, 1.10678069e-01f, 9.20667350e-02f, 1.04208492e-01f, -6.78191483e-02f, 1.58864796e-01f,
  9.42524001e-02f, -8.32078606e-02f, 4.40042242e-02f, 1.52931452e-01f, 1.34450272e-02f, 4.40410711e-02f, 9.00503397e-02f, -2.98120212e-02f, 2.03609895e-02f, -3.81623395e-02f,
  2.15799622e-02f, -3.51903513e-02f, 1.11657597e-01f, -7.60669038e-02f, -1.29087061e-01f, -3.27414632e-01f, -2.14799270e-01f, 1.48841128e-01f, 2.62757838e-01f, -1.75684333e-01f,
  -2.22534195e-01f, -1.77962899e-01f, 2.06943005e-01f, 2.38940179e-01f, -2.16141611e-01f, 2.30813235e-01f, -3.34561259e-01f, 1.65527835e-01f, 1.23897552e-01f, -1.52141109e-01f,
  9.85889435e-02f, 2.47263357e-01f, 1.42253458e-01f, -1.35966048e-01f, -3.88416578e-04f, 1.41371012e-01f, -3.51928920e-01f, 8.32989067e-02f, -6.72381148e-02f, -1.60699382e-01f,
  2.25746021e-01f, -1.56044081e-01f, 1.84743375e-01f, 1.58138782e-01f, -4.76820115e-03f, 2.90213004e-02f, -1.58441722e-01f, -2.94493496e-01f, 5.24685159e-03f, -2.47914389e-01f,
  7.08990246e-02f, -2.06986517e-01f, 3.17506880e-01f, -1.40533134e-01f, 1.94121003e-01f, 2.74213105e-01f, -1.97659001e-01f, -2.67214358e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -4.04522233e-02f, 2.49487348e-02f, 4.63609844e-02f, -4.22679149e-02f, 1.06797159e-01f, 1.71564389e-02f, -1.01305112e-01f, 8.36710259e-02f, 1.09309249e-01f, 9.33973119e-02f,
  4.45602015e-02f, -6.69507235e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    