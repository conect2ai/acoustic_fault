/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.85170388e-01f, 4.23330873e-01f, 1.19006482e-03f, 1.12053499e-01f, -2.50897020e-01f, -3.33989769e-01f, -2.48242930e-01f, -5.25001325e-02f, 1.52883872e-01f, 1.11759834e-01f,
  1.28638864e-01f, 4.61793244e-02f, 2.20346972e-02f, 2.39429250e-02f, -1.06995218e-02f, -1.94984991e-02f, 7.43750781e-02f, -3.82013656e-02f, -3.96622449e-01f, -3.53330851e-01f,
  -9.62867662e-02f, -7.95774683e-02f, 1.61716506e-01f, -9.19121876e-02f, 3.84965055e-02f, -2.22587943e-01f, 1.20779127e-01f, 1.80812061e-01f, 1.82990640e-01f, 2.71322310e-01f,
  1.31993592e-01f, 4.91906524e-01f, -1.30888447e-01f, 1.07587241e-01f, 3.08874771e-02f, 2.52288803e-02f, -1.16245644e-02f, 3.24498229e-02f, -2.09967289e-02f, 1.46271735e-02f,
  -4.33280412e-03f, 2.68356241e-02f, -1.33498488e-02f, 8.89037084e-03f, 1.33873746e-02f, -3.51461321e-02f, 3.44109423e-02f, 5.51469550e-02f, 5.75340576e-02f, 6.84513338e-03f,
  -8.38741362e-02f, 1.22370534e-01f, 8.00232664e-02f, 8.35272577e-03f, 7.43256137e-02f, -6.79608732e-02f, 1.11967228e-01f, 2.49045175e-02f, 9.77123529e-02f, 5.94386384e-02f,
  4.87605706e-02f, 1.52725391e-02f, 4.32372428e-02f, -2.76819849e-03f, -6.23323694e-02f, -9.91898254e-02f, 3.89306224e-03f, -3.83202359e-02f, -5.56672923e-02f, -8.08890909e-02f,
  1.99089758e-02f, -3.12990285e-02f, 3.89022492e-02f, 7.07999710e-03f, -2.12773066e-02f, 3.52326557e-02f, -1.32586295e-02f, -2.56014243e-02f, 5.70080690e-02f, 1.67057086e-02f,
  4.32715006e-02f, 9.98226106e-02f, 7.23396614e-02f, -2.90813595e-02f, 7.97827467e-02f, -3.85863483e-02f, 1.99207682e-02f, -5.27808256e-02f, -8.31827521e-02f, -3.58551787e-03f,
  -6.95600873e-03f, 1.84919655e-01f, -1.97238028e-02f, -1.95745341e-02f, -2.48126383e-03f, 6.03916496e-02f, 2.32140664e-02f, -6.67611137e-02f, -3.25752385e-02f, -2.39450634e-02f,
  6.92066774e-02f, -2.66602803e-02f, 2.41801925e-02f, 5.07959276e-02f, -7.43167028e-02f, -1.28083289e-01f, -4.42928635e-02f, -8.12957957e-02f, 4.64467891e-02f, 1.54634165e-02f,
  7.33537450e-02f, -1.01256594e-01f, -9.68440622e-02f, -5.87169379e-02f, -4.41513583e-03f, -6.73044100e-02f, -1.25220478e-01f, -1.15313694e-01f, -2.98994314e-02f, -1.77104115e-01f,
  2.30604839e-02f, -4.25197966e-02f, 3.72580379e-01f, -2.67228633e-01f, -8.40744227e-02f, 2.14264274e-01f, 4.09734219e-01f, 1.25165656e-01f, -1.85463816e-01f, -1.17569253e-01f,
  -1.85267851e-01f, -3.46998990e-01f, -2.22783908e-01f, -3.37707251e-03f, 4.67501551e-01f, 3.95241618e-01f, 6.12015069e-01f, 5.23146749e-01f, 3.36187959e-01f, 1.32763028e-01f,
  -1.62470803e-01f, -9.61430930e-03f, 1.75706267e-01f, 1.35063037e-01f, -2.77474821e-01f, -2.29634881e-01f, 3.88269387e-02f, 5.57563193e-02f, 6.95924461e-02f, 6.64095336e-04f,
  -4.20910046e-02f, 9.85578075e-02f, 8.85165948e-03f, -9.73109603e-02f, -7.02192336e-02f, 3.81870717e-02f, 6.16832338e-02f, 1.24426186e-03f, -9.98343229e-02f, -2.03208867e-02f,
  -3.71799320e-02f, -7.68249333e-02f, 7.96487555e-03f, -4.93684001e-02f, 8.99470598e-02f, 1.13047650e-02f, 1.18798070e-01f, 1.87286034e-01f, -4.67217490e-02f, 4.28809114e-02f,
  -1.30392596e-01f, 5.77282486e-03f, 1.31647810e-01f, 5.23194075e-02f, 1.16167307e-01f, 2.59634349e-02f, -2.08205618e-02f, 1.57133285e-02f, 7.56981894e-02f, -2.52725836e-02f,
  -6.05803691e-02f, 1.98119674e-02f, 1.32382102e-03f, -1.96326710e-03f, -3.07734106e-02f, -4.23687883e-02f, 2.92317923e-02f, 9.90611967e-03f, 8.27723220e-02f, -3.26545052e-02f,
  -1.81771982e-02f, -2.20323317e-02f, 3.01204827e-02f, 9.56457853e-02f, -8.33327174e-02f, 1.83606651e-02f, 5.96663244e-02f, -1.14863934e-02f, -1.60380658e-02f, -8.23492110e-02f,
  -5.17876372e-02f, 6.02704659e-02f, -5.59430011e-02f, 2.83472855e-02f, 9.16523784e-02f, 5.59244417e-02f, 2.79202349e-02f, -1.07079729e-01f, -9.67717469e-02f, -4.98698913e-02f,
  -3.33930314e-01f, 1.10435605e-01f, -1.20396674e-01f, 5.83225228e-02f, -4.53337207e-02f, -3.53699960e-02f, -1.30369306e-01f, -4.38259318e-02f, -1.11885116e-01f, -7.13658929e-02f,
  -5.65589592e-02f, 5.61086275e-02f, 3.48653048e-02f, 5.30054234e-02f, 6.34618849e-02f, -3.59741710e-02f, 4.07258943e-02f, -6.81112558e-02f, 4.29826751e-02f, -1.14498951e-01f,
  6.83384240e-02f, 5.76359108e-02f, -4.44507897e-02f, -4.02648710e-02f, -3.73001979e-03f, 5.72167151e-02f, -5.35975955e-02f, -8.88518021e-02f, 1.38615265e-01f, -1.18852198e-01f,
  6.57009125e-01f, -1.51172206e-01f, 2.18176290e-01f, -1.02699898e-01f, -5.90251237e-02f, 9.42744613e-02f, 9.16830599e-02f, -2.30886079e-02f, -1.47947788e-01f, 2.10200194e-02f,
  -1.60130560e-01f, -1.61363006e-01f, -2.21879795e-01f, -6.44226223e-02f, -2.82643512e-02f, 3.42952646e-02f, -1.59338579e-01f, 1.31700382e-01f, 2.44197920e-01f, 2.16018036e-01f,
  -1.00903168e-01f, -1.25373140e-01f, -1.11189373e-02f, -6.51252121e-02f, -1.30716845e-01f, 2.36261394e-02f, -1.74237520e-01f, -9.80642736e-02f, -2.78482330e-03f, -2.29598165e-01f,
  4.54895288e-01f, -1.48005448e-02f, 1.24709897e-01f, -1.15587527e-03f, 2.42891442e-02f, 9.33361575e-02f, 1.02782480e-01f, 6.27978146e-03f, -4.90777381e-02f, 2.76934989e-02f,
  -6.65006638e-02f, 6.51085451e-02f, 1.38350511e-02f, -9.55957621e-02f, 5.18665835e-02f, 4.06608954e-02f, -1.28729958e-02f, -5.39735518e-02f, 9.79930628e-03f, 4.62873001e-03f,
  -1.34964228e-01f, -4.89254110e-02f, -3.41530815e-02f, -8.18063854e-04f, -8.29753503e-02f, -7.80342519e-02f, -3.25092785e-02f, -2.41635591e-02f, -6.20107353e-02f, 3.11289895e-02f,
  1.97400317e-01f, 4.43300493e-02f, -4.25680354e-02f, 3.26107666e-02f, -7.77874561e-03f, -1.84378121e-02f, 2.08300129e-02f, 2.07487983e-03f, -7.62163103e-02f, -4.56244964e-03f,
  -3.66046466e-02f, 6.77901804e-02f, -1.02797039e-01f, -3.97376418e-02f, -1.33765176e-01f, -7.90429860e-02f, -8.42473879e-02f, -3.71128395e-02f, -8.76159966e-02f, 6.01324588e-02f,
  -2.12988891e-02f, -2.04541981e-02f, -2.80725658e-02f, -7.95201361e-02f, -1.22266389e-01f, -5.95852081e-03f, -5.63907772e-02f, -1.68830324e-02f, 4.35011759e-02f, 1.23386513e-02f,
  1.50757253e-01f, -1.01034738e-01f, 9.24664140e-02f, 1.27552196e-01f, 5.25400862e-02f, 5.39796567e-03f, 1.66262724e-02f, -2.15882175e-02f, 6.16095923e-02f, 2.90163159e-02f,
  6.67788163e-02f, 1.43741608e-01f, 3.69821228e-02f, 3.51284705e-02f, 1.42567933e-01f, -4.29065190e-02f, -5.84475733e-02f, 3.32056708e-03f, 2.62612794e-02f, 8.22201818e-02f,
  -3.14718634e-02f, 2.43096445e-02f, 1.04891755e-01f, 7.43925124e-02f, 2.87616719e-03f, 9.49266404e-02f, 2.50474531e-02f, 2.50836574e-02f, 6.48743808e-02f, 2.04661772e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.33163595e-01f, -1.79415166e-01f, 2.38756046e-01f, 7.45923638e-01f, 2.73195598e-02f, -2.81515628e-01f, -4.77399468e-01f, 1.19323190e-02f, 5.00976026e-01f, 1.30891040e-01f,
  4.54937071e-02f, 4.22931433e-01f, 4.32977676e-01f, 3.17101121e-01f, 8.81662965e-02f, 2.76856553e-02f, 4.44262028e-01f, 7.84963369e-01f, 3.72120827e-01f, 1.54025137e-01f,
  3.53880882e-01f, 5.54079175e-01f, 4.76528198e-01f, 2.76141196e-01f, 9.84109822e-04f, 4.13730115e-01f, 2.42278740e-01f, 2.69204322e-02f, 2.92587746e-03f, 5.74771583e-01f,
  -3.04190516e-01f, 1.01722805e-02f, 2.05109268e-01f, 8.90126005e-02f, -5.89510612e-02f, 6.21916652e-02f, -7.39568919e-02f, -5.66800237e-02f, -2.84753144e-02f, 3.11794635e-02f,
  -1.99831590e-01f, -5.83469011e-02f, -2.81580444e-02f, 1.60094704e-02f, -5.17530926e-03f, -3.85773554e-02f, 1.11276641e-01f, 6.71147183e-02f, -7.91519806e-02f, -2.69862711e-01f,
  4.11001109e-02f, -2.27188945e-01f, -3.37893873e-01f, -1.48839146e-01f, -1.20846756e-01f, 1.94132805e-01f, -2.30353504e-01f, -1.24796905e-01f, -9.50061083e-02f, 5.00183180e-02f,
  -9.94690135e-02f, -1.20202877e-01f, 1.91915836e-02f, 4.08213176e-02f, 3.56900066e-01f, 5.64357378e-02f, 1.76942632e-01f, 2.91962177e-02f, 1.85242355e-01f, 9.89839807e-03f,
  1.43810600e-01f, 1.07808463e-01f, -6.09510876e-02f, 1.74715817e-02f, 1.62890047e-01f, -1.23848148e-01f, -1.94380358e-01f, 2.31613014e-02f, -2.82031391e-02f, 7.66218407e-04f,
  -2.79132370e-03f, -1.23223029e-01f, 9.16027725e-02f, -1.32182106e-01f, 1.12363704e-01f, 1.98788956e-01f, 1.26956955e-01f, -1.84965171e-02f, 1.15311556e-01f, 1.56457961e-01f,
  -2.38446429e-01f, 2.45689571e-01f, 1.55338302e-01f, -1.30316198e-01f, -1.72214851e-01f, -4.12935428e-02f, 4.97871563e-02f, -1.22653227e-03f, -1.18283480e-01f, -2.55855685e-03f,
  -2.83226758e-01f, -1.87916070e-01f, 5.12501188e-02f, -4.24378216e-02f, 1.49953991e-01f, -8.41298997e-02f, -2.66310591e-02f, 1.08432516e-01f, -1.15045346e-01f, -4.38860416e-01f,
  2.03059590e-03f, -1.79701433e-01f, -3.49920779e-01f, -1.63175702e-01f, -1.24277815e-01f, 7.19046965e-02f, -2.97947586e-01f, -2.81794518e-01f, -2.12510169e-01f, -8.42579305e-02f,
  -4.27716434e-01f, 1.78505525e-01f, -1.70507297e-01f, 6.27562046e-01f, 5.45949280e-01f, 4.55895245e-01f, 4.86937314e-01f, 3.50157380e-01f, 2.25438476e-01f, 1.82760552e-01f,
  1.26617670e-01f, 3.15453112e-01f, 2.02882707e-01f, 3.44938159e-01f, 2.83597201e-01f, 3.98283988e-01f, 3.63207221e-01f, -4.28383164e-02f, 1.76291950e-02f, 1.27011165e-01f,
  2.17118740e-01f, -4.42616530e-02f, -4.14695293e-01f, -1.27505943e-01f, 3.75256278e-02f, 1.23916827e-01f, 1.02820314e-01f, 3.27619761e-02f, 1.32727817e-01f, 6.17608316e-02f,
  -4.46085900e-01f, -5.73859513e-02f, 1.05121650e-01f, -9.81269497e-03f, -1.79554477e-01f, -2.22729206e-01f, 1.15023553e-02f, -2.52793938e-01f, -4.38929647e-02f, -2.99156699e-02f,
  -4.28019986e-02f, -1.47980392e-01f, 1.37949169e-01f, -1.07861415e-01f, -1.02635533e-01f, -2.49166906e-01f, -1.63040906e-01f, -1.67834952e-01f, 9.54865739e-02f, -6.23920001e-02f,
  2.09604263e-01f, -1.44605398e-01f, -8.94487724e-02f, 9.97006670e-02f, 1.69087619e-01f, -3.43621895e-03f, -2.53886003e-02f, -2.59190630e-02f, -7.98160657e-02f, -5.74370548e-02f,
  1.17911220e-01f, 1.42294262e-02f, 9.19268504e-02f, -5.56561872e-02f, 7.96609372e-02f, -8.92943814e-02f, 2.96323970e-02f, 3.42195034e-02f, 5.08556738e-02f, -7.27868453e-02f,
  3.44276093e-02f, 1.31086782e-01f, 7.74639398e-02f, 2.51808707e-02f, -1.74192246e-02f, -1.05626792e-01f, 5.33841737e-02f, 9.11557749e-02f, -2.69343816e-02f, -9.52485502e-02f,
  6.81045279e-02f, -2.26935018e-02f, -5.69077134e-02f, 1.85818579e-02f, -4.26560314e-03f, 5.73032498e-02f, 1.31066158e-01f, 8.66781846e-02f, 1.11384362e-01f, 2.55611874e-02f,
  9.93164405e-02f, 3.28704983e-01f, 1.20203294e-01f, 2.21494175e-02f, -4.66901250e-02f, -1.18946299e-01f, 1.46828726e-01f, -1.42836928e-01f, -1.26584113e-01f, -1.45970106e-01f,
  -5.97779360e-03f, -1.08161278e-01f, -4.02314998e-02f, -1.00076273e-01f, -1.07870169e-01f, -2.23413572e-01f, 9.23974663e-02f, -5.19103603e-03f, 6.74242899e-02f, 1.52065642e-02f,
  4.20665089e-03f, -2.72869412e-02f, -1.82805970e-01f, 6.75377548e-02f, 3.30427699e-02f, 9.89299789e-02f, -7.98811913e-02f, -9.62974280e-02f, -1.82279944e-02f, -2.32799888e-01f,
  -1.34655714e+00f, 7.74201006e-02f, 2.63405651e-01f, -9.84953701e-01f, 2.19056830e-01f, 4.40761745e-01f, 4.01594222e-01f, 2.28631109e-01f, -1.21499136e-01f, -4.41870012e-04f,
  2.82193422e-01f, -3.39958131e-01f, -5.05264282e-01f, -5.59113510e-02f, -3.38716090e-01f, 1.93138961e-02f, -2.21252277e-01f, -6.51852369e-01f, -3.93220872e-01f, 3.45568478e-01f,
  2.40112841e-02f, -4.84353751e-01f, -6.67843342e-01f, -1.49382532e-01f, -3.47269952e-01f, -5.61530232e-01f, -7.22038373e-02f, -2.94651031e-01f, 2.80764669e-01f, -6.35656238e-01f,
  -2.20276862e-01f, 7.17781708e-02f, 2.66792655e-01f, -3.24769095e-02f, -1.10649802e-01f, -1.69931084e-01f, 5.19843921e-02f, -2.24403530e-01f, 1.12947792e-01f, 2.78525818e-02f,
  -1.72195688e-01f, 1.38069436e-01f, -1.36827022e-01f, 1.78416371e-02f, -2.23608658e-01f, 9.42571983e-02f, 6.90998808e-02f, -9.58802626e-02f, -1.62971169e-01f, 5.25149345e-01f,
  2.00869203e-01f, 1.65184274e-01f, -1.04943924e-01f, 4.45442826e-01f, 4.33641404e-01f, -1.36935279e-01f, 3.09457630e-01f, 1.34461224e-01f, 3.99908274e-01f, -5.72790384e-01f,
  -1.63283441e-02f, 5.38588539e-02f, 1.78391978e-01f, 3.23731154e-02f, -1.19828373e-01f, 1.93115681e-01f, -1.29627094e-01f, -4.13069278e-02f, 2.04372436e-01f, -2.57383615e-01f,
  2.11762533e-01f, 1.25846148e-01f, 1.02446589e-03f, -9.97661352e-02f, 3.47617380e-02f, -6.90924749e-02f, -1.26337931e-01f, -1.02182895e-01f, 2.87640747e-02f, -9.96143650e-03f,
  -1.87113993e-02f, 8.34932327e-02f, 1.99857354e-02f, -1.34683415e-01f, 2.32022434e-01f, -2.62498647e-01f, 2.53775180e-03f, 2.12183848e-01f, -7.78682604e-02f, 8.83343294e-02f,
  -8.66055369e-01f, 4.18782800e-01f, -7.44869530e-01f, -2.19603498e-02f, 3.28855217e-02f, 4.10994403e-02f, -3.01926881e-01f, 6.45842552e-02f, 7.67217204e-02f, -5.31116538e-02f,
  3.54084671e-01f, -2.31917843e-01f, -9.48511213e-02f, 2.16468081e-01f, -2.13611051e-02f, 9.70568731e-02f, -4.11559492e-02f, -2.73176521e-01f, 1.01703614e-01f, -8.20563547e-03f,
  -2.00653970e-02f, -1.37369901e-01f, -5.38484216e-01f, -1.13444351e-01f, -2.18758166e-01f, -2.95819908e-01f, -6.13447487e-01f, -1.74360439e-01f, -4.02939886e-01f, -1.06851888e+00f,
  7.58469224e-01f, 9.53787863e-01f, 5.41793942e-01f, -1.58672377e-01f, -2.24992260e-01f, -4.48760420e-01f, 2.03062519e-02f, -1.31104857e-01f, -2.73762375e-01f, 1.86949894e-01f,
  -2.62317974e-02f, -5.24244964e-01f, -2.09354773e-01f, -7.80194998e-02f, 1.46207631e-01f, 1.80463299e-01f, 1.53243765e-01f, 2.58394480e-01f, -3.64791900e-01f, -2.80174077e-01f,
  -1.73614591e-01f, 1.30956456e-01f, 2.04138651e-01f, 2.60053575e-02f, 5.15492335e-02f, -3.61562848e-01f, 1.08260050e-01f, 1.32119775e-01f, 2.11078033e-01f, 6.27678692e-01f,
  4.35981512e-01f, 6.55987382e-01f, -7.08809912e-01f, -1.38101593e-01f, 9.74170789e-02f, 1.64774284e-01f, -4.33679260e-02f, 1.00671113e-01f, -9.27158818e-02f, 1.75468326e-01f,
  1.25026956e-01f, 1.36314794e-01f, 9.48218927e-02f, -1.31402850e-01f, -4.15722840e-02f, -1.71417519e-01f, 1.60765067e-01f, 2.60516107e-01f, -2.12510735e-01f, 2.13565025e-02f,
  -8.37478414e-02f, 1.28676623e-01f, 1.91985704e-02f, -4.08696413e-01f, -1.40488178e-01f, -1.90828308e-01f, 1.02938907e-02f, -6.81934804e-02f, -1.40664309e-01f, 1.19964607e-01f,
  -2.13964775e-01f, 1.95718452e-01f, 7.86006749e-02f, 4.35164571e-02f, 7.11062178e-02f, -7.06359819e-02f, 7.69846560e-03f, -1.04644433e-01f, -2.13878572e-01f, 1.28519714e-01f,
  -1.78194597e-01f, -1.17899045e-01f, 7.60856969e-03f, -4.41354252e-02f, -1.50399998e-01f, 3.69826257e-02f, -5.48556149e-02f, 4.67322916e-02f, 4.38510552e-02f, 7.78276697e-02f,
  -9.67497230e-02f, 8.09331760e-02f, 3.83638702e-02f, -2.87761893e-02f, -1.41809642e-01f, 2.54327990e-02f, -1.69386432e-01f, -1.58738524e-01f, -7.15485588e-02f, 5.45056947e-02f,
  -4.35856164e-01f, -2.51909018e-01f, 1.19353890e-01f, 3.71329337e-01f, 2.25368708e-01f, 1.52827546e-01f, 1.87639982e-01f, 2.03074440e-01f, 8.42395946e-02f, 1.39275521e-01f,
  4.26258482e-02f, 1.70801520e-01f, 1.45150542e-01f, 2.04939917e-02f, -3.32765967e-01f, -1.09827906e-01f, 1.02476619e-01f, 1.92408301e-02f, -2.43967660e-02f, 1.74601898e-01f,
  -4.80130169e-04f, -3.22834224e-01f, -4.72945303e-01f, -1.67490646e-01f, -3.04871082e-01f, -5.29890954e-01f, -4.52041686e-01f, -1.01709239e-01f, -4.81615126e-01f, -4.32280719e-01f,
  -3.03403199e-01f, -1.27157941e-02f, -6.05428159e-01f, 8.09606135e-01f, 3.11838508e-01f, -3.39811713e-01f, -5.96630335e-01f, -4.20240313e-01f, 4.52446610e-01f, 8.80470425e-02f,
  -1.59088336e-03f, 1.59167185e-01f, 2.86444426e-01f, -2.13106930e-01f, -5.92768729e-01f, -2.17441916e-02f, 2.01913580e-01f, -3.18781137e-01f, -7.98832893e-01f, -5.04637599e-01f,
  3.82508636e-01f, 1.59621879e-01f, -4.45292890e-01f, -1.44821957e-01f, 6.34090722e-01f, 2.40489185e-01f, 1.55215606e-01f, 2.40540490e-01f, -1.84064165e-01f, 8.33855212e-01f,
  -1.36596039e-01f, -6.82553276e-02f, -2.34561995e-01f, 1.67188123e-01f, 1.09280556e-01f, -1.58782080e-01f, -2.32133359e-01f, 5.65728918e-02f, 5.01607805e-02f, -1.08787127e-01f,
  3.52495044e-01f, 8.35490376e-02f, 3.05306911e-01f, 1.16947569e-01f, 1.20164733e-02f, -2.22331937e-02f, -1.81788504e-01f, -3.87272000e-01f, -3.19677711e-01f, -3.25966209e-01f,
  4.42124307e-01f, 9.82354730e-02f, -3.33354533e-01f, -2.82715142e-01f, -3.24559599e-01f, -5.42338938e-02f, -2.04946607e-01f, 9.74670425e-02f, -5.93075514e-01f, -1.40203461e-01f,
  -4.48068529e-02f, -3.51165310e-02f, 5.14732786e-02f, -2.40472648e-02f, 3.06142773e-02f, 6.43366277e-02f, 2.04694942e-01f, -1.08259311e-02f, 9.83793661e-02f, -1.85683668e-01f,
  -2.23385375e-02f, -1.07566819e-01f, 6.01924546e-02f, -1.79067850e-01f, 1.55877545e-02f, 5.74887209e-02f, -7.93990679e-03f, -2.48046219e-01f, -9.70900338e-03f, -7.38839060e-02f,
  -2.42940057e-02f, 1.15313046e-01f, 1.03410020e-01f, -9.33631137e-03f, -4.98492382e-02f, -6.88157752e-02f, 1.04311749e-01f, -4.51557375e-02f, -8.98034777e-03f, -1.93932001e-02f,
  9.40442607e-02f, -2.87938297e-01f, 1.23943835e-01f, -4.81716543e-02f, -2.76868213e-02f, 6.18909206e-03f, 1.37056947e-01f, -1.00718634e-02f, 2.28278816e-01f, -8.48967060e-02f,
  -1.46094963e-01f, -1.07436307e-01f, 9.19846073e-02f, -6.83628470e-02f, -6.18072413e-02f, 1.05678193e-01f, 3.25757079e-02f, 1.95078433e-01f, -1.69091430e-02f, 2.83321217e-02f,
  -6.12685382e-02f, -1.49957195e-01f, -2.34370351e-01f, -1.60392448e-01f, 8.46462771e-02f, -1.18526816e-01f, -2.00157762e-01f, -2.53256053e-01f, -3.66066635e-01f, -4.68363732e-01f,
  1.09216785e+00f, -6.63194895e-01f, -9.12846744e-01f, -2.84531534e-01f, -5.67101061e-01f, -4.19258982e-01f, -6.80113792e-01f, 1.18573077e-01f, 1.56381726e-01f, -6.64887249e-01f,
  -2.90056229e-01f, 6.65475249e-01f, 3.35705012e-01f, 3.47475171e-01f, 6.59286320e-01f, -8.87574792e-01f, -7.22939610e-01f, 2.19772160e-01f, 6.25244141e-01f, 7.70034119e-02f,
  -3.55892666e-02f, 3.04069132e-01f, 7.49070704e-01f, 2.85213590e-01f, -7.69694328e-01f, 5.02802767e-02f, -8.29531789e-01f, -3.60200882e-01f, -5.09545684e-01f, -1.25935173e+00f,
  -8.76881659e-01f, -2.99916536e-01f, -1.67663619e-01f, 2.96476066e-01f, -1.09925814e-01f, 6.00670790e-03f, -2.64403746e-02f, -9.91970152e-02f, 1.19387932e-01f, -2.55223904e-02f,
  1.26426056e-01f, 1.36833802e-01f, 1.06634036e-01f, 5.69340065e-02f, 2.23429482e-02f, 6.13161363e-02f, -1.14015959e-01f, 7.32612759e-02f, 4.19217572e-02f, -2.66074568e-01f,
  -6.15623444e-02f, 3.86138782e-02f, -2.02659264e-01f, -1.06583104e-01f, -1.52860910e-01f, -1.53962625e-02f, -3.00749719e-01f, -1.01521648e-01f, -1.40011996e-01f, -4.86787856e-01f,
  -6.75029233e-02f, -6.23627985e-03f, -4.05084379e-02f, -3.69145125e-02f, 1.33970410e-01f, -1.12456530e-02f, -7.51662105e-02f, -5.61595522e-02f, 2.65756100e-02f, -1.72089878e-02f,
  -1.15597129e-01f, -1.44489989e-01f, 9.32389721e-02f, -2.02723861e-01f, -5.22253104e-02f, 7.97572080e-03f, -5.19857109e-02f, -2.81272531e-02f, 2.93433368e-02f, 9.32602808e-02f,
  1.17695980e-01f, 3.22463736e-02f, 1.34858310e-01f, 7.32058063e-02f, -1.27809480e-01f, -5.12738116e-02f, -2.61922423e-02f, -2.67222095e-02f, 4.98373546e-02f, -1.25880539e-02f,
  2.39921793e-01f, 2.18744040e-01f, -1.20012164e-01f, 1.05480850e-01f, 2.11224630e-02f, 1.13339335e-01f, -1.59336701e-01f, 8.42099115e-02f, 1.15694076e-01f, 5.90603240e-03f,
  9.93057266e-02f, 5.31184860e-02f, 6.58934936e-02f, -8.53857771e-02f, -5.04580103e-02f, 1.84062552e-02f, 8.86432528e-02f, 8.42149407e-02f, 7.10251182e-02f, -4.51544225e-02f,
  -8.82937293e-03f, 4.50283475e-02f, 1.98901638e-01f, -1.57415509e-01f, -7.56592155e-02f, 8.97267088e-02f, -1.23718850e-01f, -1.38455749e-01f, 9.16653126e-02f, -2.65245497e-01f,
  8.50121498e-01f, 4.16064680e-01f, -5.72256148e-01f, 3.79886061e-01f, 2.38609284e-01f, 1.94288918e-03f, 6.38351738e-01f, 4.06226814e-01f, 3.37160915e-01f, 4.66713876e-01f,
  9.22480822e-02f, -5.46129525e-01f, -2.91898131e-01f, -6.80373013e-01f, -3.58259201e-01f, 1.95478201e-01f, 1.10557936e-01f, -7.07008600e-01f, -6.83480084e-01f, -4.19067353e-01f,
  -2.24740908e-01f, 3.05086762e-01f, 2.25477114e-01f, -1.84362814e-01f, 1.11380287e-01f, -3.68494749e-01f, 2.22453982e-01f, 5.95453680e-02f, -4.77252334e-01f, -7.02196717e-01f,
  -7.30378926e-01f, 1.09235756e-02f, -2.15119392e-01f, 5.69074601e-02f, 7.56804720e-02f, 3.50312293e-02f, -8.06976557e-02f, 4.48183417e-02f, 2.22532481e-01f, 1.93841830e-01f,
  1.65859405e-02f, -1.08236700e-01f, -5.66733070e-02f, -1.64934814e-01f, 3.35438810e-02f, -7.40904137e-02f, 1.82004914e-01f, -4.83250059e-02f, -2.95349099e-02f, -1.42814159e-01f,
  -1.53259128e-01f, -5.92603087e-02f, -3.63921672e-02f, -4.66400273e-02f, -1.74568832e-01f, -1.58369973e-01f, -1.43247679e-01f, -3.86032671e-01f, -4.15829927e-01f, 7.61322230e-02f,
  -9.32996571e-02f, 9.14655160e-03f, 3.87768075e-02f, 5.89331873e-02f, 2.24616632e-01f, 9.82566103e-02f, -7.68038109e-02f, 1.94674045e-01f, -1.67106330e-01f, 1.99589074e-01f,
  3.74918915e-02f, 1.07542649e-02f, -9.66446623e-02f, 1.29278153e-01f, -2.86665484e-02f, -1.86971314e-02f, -1.61722917e-02f, 1.29489684e-02f, 6.57313466e-02f, 1.79130077e-01f,
  8.55867378e-03f, 9.12222825e-03f, 2.97175199e-02f, -1.27895787e-01f, -1.78376764e-01f, -7.82737434e-02f, -1.43376440e-01f, -1.50662050e-01f, 6.79121166e-02f, 1.23842970e-01f,
  2.34701887e-01f, -2.02393919e-01f, 2.03532092e-02f, -6.40508533e-02f, 7.83843175e-02f, 6.68093842e-03f, -3.03540118e-02f, -5.03267273e-02f, -7.83768389e-03f, -1.17161289e-01f,
  -1.29606232e-01f, -3.81964669e-02f, 1.11021295e-01f, 3.01329587e-02f, 4.67188917e-02f, 6.24293573e-02f, 2.92998254e-01f, -1.37091890e-01f, -7.33386129e-02f, 2.52848327e-01f,
  3.27168226e-01f, 2.08221257e-01f, 3.23958039e-01f, 9.22294334e-02f, 1.40656009e-01f, 1.29164204e-01f, -1.11024491e-02f, 3.03754173e-02f, -9.45367068e-02f, 5.62601864e-01f,
  -5.35264850e-01f, 2.74184644e-01f, -9.38062489e-01f, -5.42843044e-01f, -8.95235896e-01f, -8.49966586e-01f, -3.58025938e-01f, -1.38430625e-01f, -3.76116335e-01f, -1.80393592e-01f,
  1.15040340e-01f, 3.92589748e-01f, 6.53207600e-01f, 1.56680614e-01f, -1.38018988e-02f, -5.32772839e-01f, -1.19009244e+00f, -7.44472623e-01f, -5.44058919e-01f, -4.84972030e-01f,
  -3.40887904e-01f, -4.12416160e-01f, -3.99172753e-01f, -1.45297617e-01f, 2.88626134e-01f, 2.50504941e-01f, -1.75998271e-01f, -2.83657640e-01f, -2.25335404e-01f, -2.25015417e-01f,
  5.01140654e-01f, -1.73799306e-01f, -6.11949600e-02f, -2.70098656e-01f, -1.11848548e-01f, 4.59837653e-02f, -7.33803958e-02f, -3.15821334e-03f, -7.86268339e-02f, -7.71926120e-02f,
  -9.84217599e-02f, -1.27647057e-01f, -1.12511382e-01f, 3.48383524e-02f, -3.20277140e-02f, -2.70572752e-02f, 2.97317188e-03f, -9.34880003e-02f, -6.93198368e-02f, 5.36488853e-02f,
  1.49634900e-02f, -4.41015393e-01f, 3.79714444e-02f, 7.72653818e-02f, 8.07219967e-02f, -2.08223075e-01f, 1.78193420e-01f, -1.34045675e-01f, -9.71196741e-02f, 4.02197003e-01f,
  -1.04876198e-01f, 4.57709014e-01f, 8.60529467e-02f, 2.90221404e-02f, 7.76414275e-02f, 4.44549322e-03f, 1.39890626e-01f, 1.87797219e-01f, -8.14162493e-02f, 7.36528933e-02f,
  4.33767401e-02f, 7.73524344e-02f, 2.64523681e-02f, 4.26886007e-02f, -2.94251591e-02f, -2.84736872e-01f, -1.38501361e-01f, 1.34044796e-01f, -1.44263759e-01f, -6.37284890e-02f,
  -1.10360622e-01f, -1.24669254e-01f, 6.74961433e-02f, 1.16327189e-01f, -3.14233214e-01f, -1.53118700e-01f, -5.96988797e-02f, 1.22115645e-03f, 1.52554014e-03f, -2.11867824e-01f,
  9.51668084e-01f, -3.80116940e-01f, 3.98254842e-01f, 2.42366597e-01f, -8.62625465e-02f, -1.67246386e-02f, 1.07710965e-01f, -1.76667236e-02f, 1.22240663e-01f, -7.61075616e-02f,
  -1.99697405e-01f, 9.94458646e-02f, 1.07113771e-01f, 1.46241665e-01f, -1.09320305e-01f, -1.41081840e-01f, -3.58026139e-02f, 5.18578961e-02f, -9.77403596e-02f, 6.96474761e-02f,
  4.68660183e-02f, -6.16033524e-02f, 2.31095970e-01f, 2.51797974e-01f, 1.09801479e-01f, -3.66455205e-02f, 4.57981348e-01f, 1.68319166e-01f, 1.50136366e-01f, 4.75889325e-01f,
  8.14614892e-01f, -1.04115978e-01f, 3.93179744e-01f, 3.90863776e-01f, 8.53560567e-01f, 6.91554785e-01f, 9.49932516e-01f, 5.51634431e-01f, 1.24920107e-01f, 1.45898059e-01f,
  -3.10162514e-01f, -7.56419301e-01f, -4.78699267e-01f, -3.99335295e-01f, -1.64078891e-01f, 4.52986598e-01f, 3.71514708e-01f, 8.63614306e-02f, 1.39912188e-01f, 2.13229224e-01f,
  -1.84986591e-01f, 1.88489616e-01f, 4.50303890e-02f, 1.85456499e-02f, 2.85335351e-02f, -2.89350152e-01f, 2.11368129e-01f, 3.60103756e-01f, -5.21376841e-02f, -3.15657526e-01f,
  -2.28562325e-01f, 3.22599858e-01f, -1.67200163e-01f, -1.92787424e-01f, -6.27102181e-02f, -3.43281448e-01f, -6.24472499e-02f, -2.93217093e-01f, -1.84312686e-01f, -3.89692597e-02f,
  -8.83049592e-02f, -3.51581424e-02f, 1.26888268e-02f, -8.30992013e-02f, 2.28891358e-01f, -1.61908288e-02f, -1.01528786e-01f, -7.88049474e-02f, -1.48920596e-01f, -2.28713810e-01f,
  -3.53179276e-01f, 1.40911773e-01f, 2.23698825e-01f, 4.07937653e-02f, -1.07552633e-02f, -1.25714630e-01f, -5.81642496e-04f, -8.47586766e-02f, 1.89976748e-02f, -2.09430277e-01f,
  -4.84545119e-02f, 3.54660675e-03f, 6.76255450e-02f, 7.12441057e-02f, 1.60565227e-02f, 2.18282249e-02f, 4.36005974e-03f, -4.61337119e-02f, 3.54903527e-02f, 1.91669747e-01f,
  -9.36573595e-02f, 9.37166065e-02f, -1.36143826e-02f, -5.18526323e-02f, -1.73014298e-01f, 2.44700275e-02f, 1.36237228e-02f, -2.52225131e-01f, -3.72965150e-02f, 4.69861552e-02f,
  9.62357670e-02f, 8.86166096e-02f, -3.27939242e-02f, 4.42948714e-02f, 5.55803291e-02f, -9.76074394e-03f, -9.79639292e-02f, -1.13170773e-01f, -8.22932273e-03f, 2.57615838e-03f,
  -1.73496023e-01f, -1.08212708e-02f, -2.13405043e-01f, -2.34947633e-02f, 7.68224001e-02f, -1.00126944e-01f, -1.77427288e-02f, -1.46608025e-01f, 1.15734756e-01f, -5.25766350e-02f,
  -4.11976278e-02f, -1.24124296e-01f, -2.92492770e-02f, 9.39565599e-02f, 9.15780887e-02f, -2.93938797e-02f, -1.93589106e-01f, 8.88056457e-02f, -4.35255431e-02f, -4.24881428e-02f,
  -1.03000104e-01f, 7.43383765e-02f, 1.22803599e-01f, 4.95017618e-02f, -1.52202561e-01f, 6.01836247e-03f, -2.98936516e-02f, 8.54999572e-02f, 1.46753252e-01f, 9.15441737e-02f,
  9.14230764e-01f, -5.12889147e-01f, 3.32418978e-01f, 1.54542342e-01f, 1.49296045e-01f, 1.45827353e-01f, -8.51450637e-02f, -5.69637343e-02f, 1.34354383e-01f, -4.31551486e-02f,
  1.29541412e-01f, 3.65689576e-01f, 1.61315858e-01f, 7.76469409e-02f, 2.87797630e-01f, 1.68788865e-01f, 7.57738650e-02f, 2.75143415e-01f, 4.39781815e-01f, 1.52742609e-01f,
  -1.55283377e-01f, -2.82289356e-01f, -2.07496405e-01f, -6.64125234e-02f, -2.82636464e-01f, 7.14882761e-02f, -2.12093189e-01f, -2.05478728e-01f, -1.89391121e-01f, -1.80805370e-01f,
  3.13767225e-01f, 1.12832487e-01f, 1.83052570e-01f, -4.93791215e-02f, -2.69958917e-02f, -2.80546080e-02f, 1.00640349e-01f, -1.15143433e-01f, -1.26869470e-01f, -6.00183979e-02f,
  -1.99553967e-02f, -1.80041611e-01f, 3.73885855e-02f, -9.56970602e-02f, 2.22302368e-03f, -1.99489687e-02f, -1.00753792e-01f, 9.72125605e-02f, 6.66861162e-02f, -1.09314127e-02f,
  -2.32564867e-01f, 1.31496310e-01f, 1.93780854e-01f, 5.74238263e-02f, 1.76616356e-01f, 1.71834499e-01f, -1.28862128e-01f, -7.94536918e-02f, 1.18669443e-01f, -6.84091896e-02f,
  2.40977742e-02f, 7.81179930e-04f, 1.63637012e-01f, -7.80396014e-02f, 9.88295227e-02f, 1.59465909e-01f, 1.24603122e-01f, 1.05291091e-01f, 1.75984249e-01f, 3.74940746e-02f,
  1.29284352e-01f, 1.83898285e-01f, 1.14556827e-01f, -4.68826666e-02f, -8.41203481e-02f, -1.89250439e-01f, -9.64460447e-02f, -2.07014188e-01f, 1.93604946e-01f, -3.34364437e-02f,
  1.17964551e-01f, 3.85720283e-02f, -2.38905493e-02f, -2.50854623e-02f, -2.83019934e-02f, 8.43164474e-02f, -2.44204924e-02f, -9.67422202e-02f, -8.05950463e-02f, -1.96849883e-01f,
  -2.59607375e-01f, 3.36053163e-01f, 1.79160357e-01f, 4.38233390e-02f, 7.28457943e-02f, -1.24096699e-01f, 9.96402353e-02f, -1.61478609e-01f, -2.42608935e-01f, 5.67062609e-02f,
  5.86505942e-02f, -6.94656894e-02f, -1.87732149e-02f, -6.01365045e-02f, 1.21014208e-01f, 2.55520251e-02f, -1.15335464e-01f, 1.06652088e-01f, 4.20164950e-02f, -3.28225568e-02f,
  -1.41975418e-01f, 9.80631933e-02f, 3.89080822e-01f, 2.29957700e-01f, 2.62580723e-01f, 2.21403301e-01f, 3.46992277e-02f, -2.56425403e-02f, 8.25321525e-02f, 5.36400825e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  1.34543312e+00f, 3.69472690e-02f, 2.56376177e-01f, 1.06342602e+00f, 3.33808213e-01f, 8.26308846e-01f, 9.38618541e-01f, 9.80689704e-01f, 9.41423357e-01f, 2.30038479e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.57895982e-01f, -1.17754573e-02f, -5.76903820e-02f, -2.22083881e-01f, -1.28303304e-01f, 5.59697509e-01f, 6.94786608e-02f, -1.69792950e-01f, -3.25261205e-01f, -3.79382163e-01f,
  -2.20910951e-01f, 5.71196079e-01f, 4.29947637e-02f, -3.42071652e-02f, 1.71429113e-01f, -9.11215469e-02f, -7.09045902e-02f, 2.29228418e-02f, -1.42577961e-01f, -2.07344562e-01f,
  -2.02910267e-02f, 1.28186094e-02f, 9.21841711e-02f, 3.86672020e-01f, -9.36771929e-02f, -4.55101520e-01f, 3.11613590e-01f, 3.59476537e-01f, 2.20973805e-01f, -9.83123258e-02f,
  -3.07775736e-01f, -2.79056907e-01f, 5.30011579e-02f, 1.68991193e-01f, 4.63036709e-02f, -2.61873633e-01f, 1.81278393e-01f, 2.65093267e-01f, 4.07343246e-02f, -2.81715244e-01f,
  1.19588502e-01f, -1.03893414e-01f, -5.50444007e-01f, 1.23706974e-01f, 4.15011942e-01f, -3.56506437e-01f, 2.41711020e-01f, -4.42787223e-02f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.57165134e-01f, 3.67436767e-01f, 6.01035357e-01f, 1.23518087e-01f, 7.10691810e-01f, -2.76324898e-02f, 7.54388571e-01f, -5.28831184e-01f, 6.00668848e-01f, 1.02218676e+00f,
  -8.82060349e-01f, 7.82785058e-01f, -4.51606780e-01f, -1.26688942e-01f, 9.74942818e-02f, 2.54798919e-01f, 8.96863043e-01f, 3.74267958e-02f, 5.59859633e-01f, 8.71031404e-01f,
  2.65400440e-01f, -7.03962505e-01f, 6.37726843e-01f, -9.81092900e-02f, 1.28639773e-01f, 7.54201889e-01f, 1.42338514e+00f, -3.27436507e-01f, 9.96920645e-01f, 1.03421956e-01f,
  -2.94054747e-01f, -1.15487802e+00f, 3.87108773e-01f, 6.08703136e-01f, 3.33035141e-02f, -8.50305915e-01f, 6.84822083e-01f, 5.61762368e-03f, 6.20448887e-02f, 1.94254704e-02f,
  6.95547462e-01f, -2.20869109e-01f, -5.88446379e-01f, 1.37465835e+00f, 1.66560844e-01f, 2.78152347e-01f, 5.64985931e-01f, -1.26008570e-01f, -2.51278520e-01f, -6.01100400e-02f,
  -2.21000865e-01f, -9.30996537e-02f, 4.89946723e-01f, 3.80210906e-01f, 3.66315961e-01f, 3.80731404e-01f, -3.14540476e-01f, 7.88863122e-01f, 7.62355983e-01f, -6.59038126e-01f,
  2.10669935e-01f, -3.96359771e-01f, 9.25549626e-01f, -1.42600209e-01f, 1.78208604e-01f, 3.51185173e-01f, 3.93752754e-01f, -5.36498785e-01f, -8.28558326e-01f, 1.09635973e+00f,
  6.89109445e-01f, 1.63180783e-01f, -8.67146850e-01f, -5.22980273e-01f, -3.84862155e-01f, 9.16002452e-01f, 1.10595381e+00f, 7.18977630e-01f, 4.38046604e-01f, -7.88158849e-02f,
  -1.98150445e-02f, 5.19640625e-01f, 2.12270439e-01f, -1.09653485e+00f, -2.54417807e-01f, -7.62441903e-02f, -2.94827133e-01f, 1.98707685e-01f, 1.20148516e+00f, -1.03442915e-01f,
  3.34094375e-01f, -9.90430415e-01f, 8.69019985e-01f, 1.12046444e+00f, 1.02213860e+00f, -5.23562312e-01f, 5.43116070e-02f, -2.88839042e-01f, 3.50757122e-01f, 1.11529969e-01f,
  -1.39755189e+00f, -2.39610314e-01f, -5.24622686e-02f, -4.74388093e-01f, 6.01804972e-01f, -1.27175778e-01f, 1.12775314e+00f, 8.76363337e-01f, -1.21955968e-01f, 8.14385414e-01f,
  -3.84587288e-01f, -1.29358783e-01f, -2.49775052e-01f, -1.95442900e-01f, 4.46817636e-01f, 3.37212235e-01f, 6.61005616e-01f, 2.00922608e-01f, -9.31010619e-02f, -3.55724990e-01f,
  7.89676785e-01f, 5.52856088e-01f, -7.36957729e-01f, -2.46197984e-01f, 9.94890749e-01f, 1.45135419e-02f, 1.03078222e+00f, -7.17030108e-01f, 4.50278282e-01f, -1.46760136e-01f,
  2.63003349e-01f, 1.52870929e+00f, -2.29476139e-01f, -4.88909513e-01f, 2.58496795e-02f, 6.61620915e-01f, -4.58753407e-01f, 5.37725031e-01f, 7.33544767e-01f, 8.45762968e-01f,
  1.20368814e+00f, 1.10635221e-01f, 6.46194696e-01f, 2.41225436e-01f, -1.15843572e-01f, 1.81566983e-01f, -4.48537946e-01f, -7.80927956e-01f, 5.01383722e-01f, 3.26876998e-01f,
  2.53065675e-01f, 3.73244077e-01f, -3.27290240e-04f, -7.09605217e-01f, 8.42548132e-01f, -6.84816465e-02f, 2.92016059e-01f, -4.66210067e-01f, 3.40090781e-01f, 4.07381982e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  3.34702075e-01f, 7.76196539e-01f, -1.25050113e-01f, 1.18512034e-01f, -2.80969352e-01f, 4.74243015e-01f, 2.33900532e-01f, -1.16879359e-01f, 1.98473543e-01f, -1.12340063e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -1.59133971e-01f, -1.19542468e+00f, -3.87198150e-01f, 9.69602346e-01f, 3.84294599e-01f, -6.69066012e-01f, 8.82654861e-02f, -8.40315104e-01f, 5.89612067e-01f, -7.15872169e-01f,
  -4.54835236e-01f, -2.66920656e-01f, 5.28057992e-01f, 9.20530222e-03f, -2.94938087e-01f, 2.10879877e-01f, -2.64927298e-01f, 5.60178876e-01f, 3.32032055e-01f, -5.11528909e-01f,
  1.19179331e-01f, -2.73856938e-01f, 1.51734948e-01f, -1.34724319e+00f, 3.68208021e-01f, 2.27506027e-01f, 5.94656110e-01f, -1.02282727e+00f, 2.14766301e-02f, -1.21984398e+00f,
  2.02495053e-01f, 1.11847846e-02f, 6.76050127e-01f, 3.13354880e-01f, 4.78841692e-01f, 6.81341290e-01f, 7.88211405e-01f, 2.54230678e-01f, 8.97706330e-01f, 5.28646588e-01f,
  4.69821185e-01f, -9.26792145e-01f, -4.20456588e-01f, -1.21630096e+00f, -1.26205891e-01f, -3.62326026e-01f, -3.03434968e-01f, -3.99618536e-01f, -5.72763383e-01f, 7.38457203e-01f,
  3.85670424e-01f, -6.74636960e-01f, -7.60644674e-02f, -5.17610848e-01f, 4.12398189e-01f, -1.42226130e-01f, 3.60632986e-01f, -2.77541220e-01f, -1.33696806e+00f, 5.92445433e-01f,
  -6.15242124e-02f, 4.34134662e-01f, -1.42740226e+00f, -4.59340781e-01f, 5.90772450e-01f, 4.13477957e-01f, -1.11047721e+00f, -1.02949250e+00f, -7.46934563e-02f, 7.06197143e-01f,
  -7.48590052e-01f, 2.73072392e-01f, -5.32686472e-01f, -5.77621877e-01f, -5.49748003e-01f, 2.74164587e-01f, 3.88372809e-01f, 4.77424189e-02f, 2.04274207e-01f, 2.20115751e-01f,
  -6.22339062e-02f, -7.54783332e-01f, 6.14246488e-01f, 6.31141901e-01f, 7.94271529e-01f, 3.49202394e-01f, -6.06694937e-01f, 3.03692132e-01f, -2.73518324e-01f, -5.63772321e-01f,
  5.64346552e-01f, -1.05395123e-01f, -2.84536749e-01f, -1.32095113e-01f, 2.40158021e-01f, 7.42622986e-02f, -1.42408907e-01f, -1.40701637e-01f, 6.59585297e-01f, -4.29437190e-01f,
  -8.71087015e-01f, -3.44855666e-01f, 5.90702951e-01f, 4.17689025e-01f, -1.07131767e+00f, 4.08713996e-01f, -8.91129255e-01f, -1.62082767e+00f, -1.00356972e+00f, 3.82594019e-01f,
  -3.22728366e-01f, -7.49782026e-01f, -7.63266563e-01f, -7.21668482e-01f, -9.56612051e-01f, -4.35826778e-01f, 4.31353189e-02f, -5.01474917e-01f, -1.46684325e+00f, 2.06666872e-01f,
  -2.95992196e-01f, 4.73620892e-01f, -2.78661281e-01f, 2.80482233e-01f, -8.16010058e-01f, -5.86737156e-01f, 2.47563750e-01f, 2.04524457e-01f, -1.18832126e-01f, -2.44348437e-01f,
  -5.90619922e-01f, 1.67963421e+00f, -9.81339216e-01f, 1.17670238e+00f, -3.65512401e-01f, -1.32423604e+00f, 2.10904196e-01f, 2.64625072e-01f, -3.46847996e-02f, 3.33554119e-01f,
  -5.56454539e-01f, 2.54935712e-01f, -1.62989393e-01f, 5.01377404e-01f, 6.20089322e-02f, 9.35426176e-01f, -5.92872798e-01f, -7.23646939e-01f, 4.09940481e-01f, -4.50206161e-01f,
  -2.62258381e-01f, 7.99986064e-01f, -1.32482648e+00f, 4.18124422e-02f, -4.25865561e-01f, -9.86561477e-01f, 5.47159314e-01f, -1.16601431e+00f, 2.47328505e-01f, -6.53443158e-01f,
  3.27278346e-01f, 3.16741377e-01f, 1.50217209e-02f, 7.79616475e-01f, -4.85089272e-01f, -6.59450293e-01f, -1.04106927e+00f, -7.54659891e-01f, -9.66930483e-03f, -6.45152211e-01f,
  6.78789914e-01f, 5.54817855e-01f, 1.32258385e-01f, -1.47081709e+00f, -1.51359928e+00f, -1.32892597e+00f, 2.06693694e-01f, 2.47352287e-01f, 4.65507627e-01f, -5.91480076e-01f,
  -8.71621370e-01f, 5.29686451e-01f, 7.48610273e-02f, -5.98770618e-01f, -2.75183886e-01f, 1.27502754e-01f, -5.71503282e-01f, 1.27020419e-01f, -1.17699218e+00f, 8.20874035e-01f,
  5.34311056e-01f, -1.19564593e+00f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.66168541e-01f, -5.08580327e-01f, 1.27516761e-01f, -1.43139333e-01f, 2.35948905e-01f, 1.89409420e-01f, -5.31252213e-02f, -6.65000603e-02f, -3.72189939e-01f, 4.73120093e-01f,
  -8.01732764e-02f, 2.82132756e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    