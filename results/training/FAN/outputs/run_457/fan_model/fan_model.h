/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.38268182e-01f, -7.52554759e-02f, 8.82851612e-03f, 1.85892716e-01f, 7.04485318e-03f, 3.69308978e-01f, 3.92340869e-01f, -7.39415661e-02f, 1.39057040e-02f, 2.79656164e-02f,
  1.12984866e-01f, -8.12706873e-02f, 8.87691379e-02f, 2.28763148e-01f, 2.77986348e-01f, 1.33734018e-01f, 2.66225576e-01f, 1.54336721e-01f, -1.00476027e-01f, 7.39369988e-02f,
  6.45489246e-02f, 1.37486547e-01f, 1.28673509e-01f, -1.21116675e-01f, 1.60138249e-01f, -8.84877145e-02f, -2.43284702e-02f, -4.69053239e-02f, -1.83280092e-02f, -2.08135899e-02f,
  8.89023915e-02f, 8.12200923e-03f, -1.88726969e-02f, 7.89601803e-02f, 6.02575541e-02f, 4.70624790e-02f, 1.35351926e-01f, 4.62890938e-02f, -2.65553333e-02f, 9.57395229e-03f,
  -5.12506347e-03f, -1.42118083e-02f, -1.55999837e-02f, -4.48476970e-02f, 1.46357128e-02f, 3.48769464e-02f, -5.27414940e-02f, -1.32548576e-02f, 2.36852746e-03f, -4.81264368e-02f,
  5.71985207e-02f, 4.37039249e-02f, 8.16529319e-02f, 6.89580524e-03f, -1.71033032e-02f, 1.86767075e-02f, 1.56850033e-02f, 8.71264376e-03f, 6.41102204e-03f, -4.96458597e-02f,
  -1.43645965e-02f, 2.20958032e-02f, 2.21810360e-02f, -3.11300457e-02f, -2.78747696e-02f, -5.04695736e-02f, 5.84869012e-02f, -1.56537909e-02f, -1.07563594e-02f, 1.03508085e-01f,
  1.45959435e-02f, 4.58597718e-03f, 8.09543859e-03f, 6.90982565e-02f, 2.56247148e-02f, -5.87604605e-02f, -4.56522219e-03f, -4.78283316e-03f, 2.38175821e-02f, -1.42444915e-04f,
  -1.48410844e-02f, 8.08606297e-02f, -2.49499995e-02f, 7.82588497e-02f, 6.54609501e-02f, -7.18963426e-03f, 6.32207766e-02f, 1.94081739e-02f, -2.25807074e-02f, 6.82302117e-02f,
  2.39375066e-02f, -1.05255164e-01f, -5.21605723e-02f, -4.21035960e-02f, -5.86144393e-03f, -3.03912312e-02f, 4.67473008e-02f, -7.01549500e-02f, 7.26163909e-02f, 5.81543613e-03f,
  1.05333693e-01f, 6.79603443e-02f, 1.60846151e-02f, 3.66559974e-03f, -1.44769000e-02f, -4.53973748e-02f, 7.55681917e-02f, 3.37520055e-02f, 1.65852793e-02f, -5.22464514e-02f,
  -3.65542695e-02f, 6.28718967e-03f, -6.63478896e-02f, 5.11210002e-02f, -2.25602966e-02f, 2.14778334e-02f, -8.65442455e-02f, 1.86304247e-03f, 1.90045722e-02f, -3.63612436e-02f,
  2.89237708e-01f, -1.75061449e-01f, 1.20135238e-02f, 1.29648045e-01f, 1.19146019e-01f, -2.31628820e-01f, 1.24149304e-02f, -5.64606600e-02f, -1.77148774e-01f, -3.13561738e-01f,
  -2.98936777e-02f, -1.33990213e-01f, -8.69671348e-03f, -1.90048218e-01f, 1.41890094e-01f, -1.17614299e-01f, -1.15219504e-01f, -1.77141711e-01f, 3.05143595e-02f, 1.89370871e-01f,
  1.38136074e-01f, 3.75228487e-02f, 1.45159110e-01f, -1.67317446e-02f, 1.01406630e-02f, 1.16190808e-02f, -2.23230496e-02f, 5.57490066e-02f, -1.76401109e-01f, -1.06351838e-01f,
  1.42039746e-01f, 1.94769114e-01f, -5.53313531e-02f, -7.87454247e-02f, 6.22596852e-02f, 4.08804826e-02f, -5.84570169e-02f, -9.24406275e-02f, 2.99377870e-02f, -2.66985949e-02f,
  -9.03244168e-02f, -1.35652333e-01f, -4.98830620e-03f, -7.20897689e-02f, -6.42515570e-02f, -7.54457489e-02f, -3.56022082e-02f, -7.37797171e-02f, -1.76160596e-02f, 6.64738417e-02f,
  -1.94312446e-03f, -6.75014257e-02f, -4.54147533e-02f, -3.33773345e-02f, 4.50494103e-02f, 3.04519776e-02f, 6.62492439e-02f, -4.77708802e-02f, -4.34936248e-02f, 3.40357535e-02f,
  4.39608321e-02f, -4.91490064e-04f, 2.42517795e-02f, 9.03575122e-03f, 4.67322730e-02f, 1.31068781e-01f, -2.07578354e-02f, 7.30165914e-02f, -4.47808839e-02f, 1.86325051e-02f,
  1.08779911e-02f, 2.60063503e-02f, 3.38049643e-02f, -7.15548694e-02f, 4.78929002e-03f, 3.13313715e-02f, 4.97529423e-03f, 2.89384723e-02f, -4.24352996e-02f, 7.97526687e-02f,
  -4.09217775e-02f, 2.20373017e-03f, -6.13438385e-03f, 6.16702437e-03f, -5.41892350e-02f, -4.19061966e-02f, -2.85579953e-02f, 1.17177432e-02f, 2.64651068e-02f, 6.02003485e-02f,
  3.85390222e-02f, 4.28649597e-02f, -2.81081833e-02f, 1.76003971e-03f, -3.91705446e-02f, -9.14638638e-02f, -4.20062914e-02f, 5.14687551e-03f, -3.98558415e-02f, 4.38842364e-03f,
  2.29544919e-02f, 1.04124825e-02f, 3.48476432e-02f, -6.22752197e-02f, -6.13288023e-02f, 4.12554899e-03f, 2.32382007e-02f, -7.41116777e-02f, -9.29152872e-03f, 4.26388085e-02f,
  -4.04196698e-03f, 1.43531740e-01f, -3.12669016e-02f, 8.62824097e-02f, 9.00252983e-02f, -3.45637314e-02f, 2.01692972e-02f, -3.96794900e-02f, 8.25712755e-02f, -1.50037520e-02f,
  -3.14619660e-01f, 1.35794789e-01f, -3.31176221e-02f, -2.73754448e-01f, -1.04247622e-01f, 5.12629375e-02f, -1.53848818e-02f, -3.58853452e-02f, 3.79511304e-02f, 1.36684567e-01f,
  -8.70379061e-02f, -1.03719890e-01f, 8.63508359e-02f, -3.17797869e-01f, -4.04060632e-01f, -4.20643389e-02f, -2.23784655e-01f, 6.00309484e-03f, -4.17568609e-02f, 2.87154620e-03f,
  -1.02924295e-01f, -1.93196937e-01f, -2.23173589e-01f, -4.76540215e-02f, -6.12756722e-02f, 6.18853271e-02f, -8.34762380e-02f, 1.15635082e-01f, -1.28797114e-01f, -6.01864606e-02f,
  5.46236672e-02f, -1.29683863e-03f, -6.81470856e-02f, 1.53921787e-02f, -7.86333811e-03f, -5.78508014e-03f, -1.17851598e-02f, 4.15570661e-02f, 5.01144268e-02f, 1.03681892e-01f,
  5.32691330e-02f, -8.87009874e-02f, -6.70919046e-02f, 1.93818621e-02f, 3.79414633e-02f, -2.56840531e-02f, 2.72628460e-02f, -2.37035681e-03f, -2.17060260e-02f, -1.35807499e-01f,
  -2.97315046e-02f, 1.77794732e-02f, -4.65852246e-02f, 4.07328270e-02f, -2.35049352e-02f, 1.70751475e-02f, -3.58127942e-03f, 1.87770277e-03f, 1.10315355e-02f, -3.11357826e-02f,
  2.68467329e-02f, -3.67677547e-02f, -2.31018942e-02f, -3.46274627e-03f, -4.77705710e-02f, 2.36705542e-02f, -1.25142848e-02f, -5.78413010e-02f, -2.95875706e-02f, -1.54979422e-03f,
  4.24261615e-02f, -3.30008902e-02f, 1.93847902e-02f, 3.28375623e-02f, -3.69915143e-02f, -2.05879658e-02f, -2.35688258e-02f, 3.96568850e-02f, 8.39508791e-03f, -2.43951343e-02f,
  5.25322668e-02f, 8.72095022e-03f, -1.34827187e-02f, 7.71684851e-03f, 4.85181585e-02f, -1.73051674e-02f, 2.35685576e-02f, 2.61047892e-02f, 7.57196844e-02f, 1.99596062e-02f,
  1.19649582e-01f, -5.86360169e-04f, -2.53576860e-02f, 4.63809185e-02f, 6.18936308e-03f, 7.75835384e-03f, -3.82830016e-02f, -2.50778440e-02f, 8.07312950e-02f, -9.09708887e-02f,
  -1.23428823e-02f, 4.60319258e-02f, 6.58834204e-02f, 6.12333342e-02f, 1.05667338e-01f, 6.42399630e-03f, -4.97202910e-02f, 9.68957171e-02f, 7.83163402e-03f, -4.31375764e-02f,
  -2.72958856e-02f, 2.03843098e-02f, 1.21568255e-02f, -6.11220598e-02f, 4.21782136e-02f, -1.25447465e-02f, -2.35987194e-02f, 3.89845599e-03f, 1.72457676e-02f, 4.21774052e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.78086253e-02f, 2.97760606e-01f, -4.15217727e-02f, 3.46612215e-01f, -9.40084308e-02f, -1.41984925e-01f, -2.42941245e-01f, 1.98823094e-01f, -1.61720574e-01f, 2.11779103e-01f,
  8.05038139e-02f, 8.79115462e-02f, -1.64183527e-01f, 1.49527654e-01f, -5.13654314e-02f, -1.60040900e-01f, 1.27285033e-01f, 6.49241582e-02f, -6.29943386e-02f, 2.37271041e-01f,
  7.02923015e-02f, 1.40914917e-01f, 7.58119151e-02f, 1.09078705e-01f, 2.92953968e-01f, 1.19741641e-01f, 1.76544309e-01f, -1.40626095e-02f, 2.27452144e-01f, 6.76415712e-02f,
  -5.01396544e-02f, 2.05158308e-01f, 1.48234978e-01f, 1.72826219e-02f, 1.30670875e-01f, 6.58438727e-02f, 1.64109245e-01f, -1.73074186e-01f, -6.03327453e-02f, 1.18094087e-02f,
  -6.74729571e-02f, -3.46686505e-02f, 1.37197614e-01f, -6.25326037e-02f, -6.00126199e-02f, 4.32147682e-02f, -8.26118607e-03f, 1.14661474e-02f, 1.10013522e-01f, 4.60455716e-02f,
  1.44609347e-01f, 8.86828080e-02f, 8.14025104e-02f, 6.80011660e-02f, -1.18562803e-01f, 6.52122870e-02f, -3.72517705e-02f, 9.43153575e-02f, 1.69798523e-01f, 6.62364811e-03f,
  -6.51512221e-02f, -2.52861623e-02f, -5.76698035e-02f, 6.98003843e-02f, 1.22765869e-01f, 1.23825930e-02f, -6.61722720e-02f, -2.96837911e-02f, -1.17400415e-01f, 7.50155821e-02f,
  6.23381510e-02f, 8.31359178e-02f, -3.07139866e-02f, 8.46916884e-02f, 1.48474528e-02f, 3.03849354e-02f, -1.53468922e-01f, 3.32369581e-02f, -1.13598235e-01f, 1.09849773e-01f,
  4.75463904e-02f, -8.11513439e-02f, 1.68647636e-02f, -1.58387329e-03f, -7.55048022e-02f, 1.64737865e-01f, 6.42309859e-02f, 2.16637999e-02f, -2.90899747e-03f, 3.14105861e-02f,
  1.47450238e-01f, 4.00812805e-01f, -7.18751997e-02f, 1.44752767e-02f, 1.14405483e-01f, 5.09150960e-02f, 9.85572189e-02f, 1.65284309e-03f, -7.41574168e-02f, 1.06926776e-01f,
  1.50266066e-01f, -1.73633322e-02f, 7.70836174e-02f, -1.09486595e-01f, -1.93562537e-01f, 2.11377248e-01f, 9.27552395e-03f, -1.39059555e-02f, 1.34997517e-01f, 2.13234708e-01f,
  1.91332012e-01f, 1.21926181e-01f, -1.61532938e-01f, -9.81291756e-02f, 3.49956900e-02f, 9.01525691e-02f, 6.12266548e-02f, -1.89969931e-02f, -1.27105461e-02f, 6.00404572e-04f,
  -4.11702394e-01f, -5.41996323e-02f, 1.94979608e-01f, -4.38070446e-01f, 1.84338287e-01f, 1.10094510e-01f, 4.22243215e-02f, -1.87065482e-01f, -2.45845690e-01f, -3.02309185e-01f,
  -1.52242333e-01f, -5.65210264e-03f, 3.30003858e-01f, -2.04261675e-01f, 2.16290087e-01f, 2.87454873e-01f, -1.76599681e-01f, -1.42174006e-01f, 1.26871362e-01f, -1.11624181e-01f,
  -4.60591055e-02f, -1.48775309e-01f, 1.51637211e-01f, -9.44671184e-02f, -4.96810339e-02f, -2.40580216e-01f, -1.69471025e-01f, 2.49200448e-01f, -1.88144282e-01f, 1.01828486e-01f,
  2.99330875e-02f, -3.32643688e-01f, 1.24146091e-02f, 8.29398930e-02f, -3.99927460e-02f, -2.86837630e-02f, 2.30283253e-02f, 9.37289149e-02f, -1.60668744e-03f, 7.60929808e-02f,
  -4.62305248e-02f, 3.14914365e-03f, -1.16592303e-01f, 8.59562680e-02f, 1.80113781e-02f, -4.75726500e-02f, 2.19429098e-02f, 9.57166404e-02f, -4.46503945e-02f, 9.20250174e-03f,
  1.13622770e-01f, 1.65860746e-02f, -4.28409316e-02f, -5.89804165e-02f, 8.81986693e-03f, -1.23959385e-01f, 2.42795143e-02f, 1.38343900e-01f, -6.41561002e-02f, -6.15187883e-02f,
  6.39508292e-03f, 6.67647645e-02f, 2.35970058e-02f, 8.93994495e-02f, -1.13032609e-02f, -6.93721399e-02f, 1.21314544e-03f, 1.45799695e-02f, -1.94944944e-02f, -9.81106311e-02f,
  1.12758931e-02f, -7.02889264e-02f, 8.09191242e-02f, -7.30465678e-03f, -1.06315680e-01f, -4.77116629e-02f, 7.21053183e-02f, -9.51811373e-02f, -2.68557947e-02f, -4.86181341e-02f,
  -1.01705730e-01f, -9.54485834e-02f, -2.74399407e-02f, -2.75466014e-02f, 6.99429587e-02f, 3.15129496e-02f, -4.72067064e-03f, 8.83926675e-02f, -2.20054369e-02f, -3.87219293e-03f,
  -4.13189754e-02f, -2.89779007e-01f, -3.46142589e-03f, -5.79895973e-02f, 5.39747961e-02f, -8.29601958e-02f, 1.33978590e-01f, -4.97590043e-02f, -9.48184729e-02f, -3.17640108e-04f,
  -4.26522903e-02f, 7.10542372e-04f, -6.37176409e-02f, -2.93721501e-02f, 2.71025207e-02f, -2.55756918e-02f, 6.55434234e-03f, -4.84720431e-02f, -9.32473019e-02f, 6.63355738e-02f,
  3.83197181e-02f, -1.30490931e-02f, 8.63053724e-02f, -9.94907171e-02f, -1.01908721e-01f, -2.18948200e-02f, -4.55752574e-02f, -7.15089589e-02f, 9.38182920e-02f, -9.02789906e-02f,
  -2.17944428e-01f, -6.92218542e-02f, 1.69338852e-01f, -3.17250699e-01f, 3.16076800e-02f, 9.27120522e-02f, -3.27553377e-02f, 8.74350518e-02f, -2.45219693e-02f, -1.06863268e-01f,
  -7.92308524e-02f, -4.01899480e-04f, 2.55809903e-01f, -1.66558698e-01f, 3.03479880e-01f, 1.56894803e-01f, -1.95403576e-01f, -1.37999550e-01f, -5.37047200e-02f, -1.59722164e-01f,
  -5.64725511e-02f, -2.76616007e-01f, -1.09955389e-02f, -1.67826146e-01f, -1.68671608e-01f, -2.01729193e-01f, -1.10595807e-01f, 2.21367157e-03f, -1.97857827e-01f, -9.06526074e-02f,
  -2.42986917e-01f, -2.53880084e-01f, -5.89006916e-02f, 1.48358122e-01f, -1.05500184e-01f, -1.24548441e-02f, -1.60065219e-01f, 1.33145854e-01f, -8.01976845e-02f, 3.83339934e-02f,
  5.20246802e-03f, 7.69321993e-02f, -8.12959895e-02f, 6.51940033e-02f, -9.82556418e-02f, -1.60457864e-02f, -3.47560756e-02f, 5.89158328e-04f, 9.25681442e-02f, 1.62400026e-02f,
  2.82004084e-02f, 1.18487505e-02f, -3.95451486e-02f, -1.15133457e-01f, 1.19320871e-02f, 7.46100917e-02f, 4.73476062e-03f, 1.06986547e-02f, -8.17613229e-02f, -1.07461102e-01f,
  -7.30784098e-03f, -7.28366524e-02f, 1.00122608e-01f, -5.99327050e-02f, 6.70991316e-02f, -9.18541197e-03f, -2.92636286e-02f, 4.53176945e-02f, -7.57005215e-02f, 1.25296311e-02f,
  -2.88650990e-02f, -1.20620325e-01f, -3.43043990e-02f, -9.19845235e-03f, -3.64423584e-04f, 3.02873198e-02f, 4.79569361e-02f, 3.36813810e-03f, 9.01207328e-03f, 3.18962447e-02f,
  -1.77070368e-02f, 9.97781977e-02f, -7.25205094e-02f, -3.54411937e-02f, 3.08663659e-02f, 7.24767223e-02f, -2.61515267e-02f, -2.96512358e-02f, -6.03764690e-02f, 2.49574874e-02f,
  -2.57536471e-01f, -3.96805704e-01f, 3.57502028e-02f, -6.82262778e-02f, 8.27397034e-02f, 3.04457210e-02f, -5.70057631e-02f, 1.17880039e-01f, -1.17017115e-02f, -8.11872482e-02f,
  -1.52006606e-02f, -7.20538422e-02f, 1.37568023e-02f, -4.51836772e-02f, 8.96745399e-02f, -1.89199131e-02f, -1.29413441e-01f, -7.89037719e-02f, 2.22991109e-02f, 3.32290009e-02f,
  1.46213006e-02f, -4.82986085e-02f, 1.55064948e-02f, -4.93035764e-02f, 4.54129577e-02f, -1.05865851e-01f, -3.23973745e-02f, 5.62740043e-02f, -7.10768476e-02f, 3.88710573e-02f,
  2.25580543e-01f, 1.51788056e-01f, 1.89511329e-01f, 1.90701962e-01f, -7.43254498e-02f, -5.37959188e-02f, -6.93189278e-02f, -2.83847284e-02f, 2.30376780e-01f, -5.83380535e-02f,
  -2.35364288e-01f, 2.73782998e-01f, -8.16153586e-02f, 2.21740931e-01f, -1.98175699e-01f, -6.54833615e-02f, 3.54357623e-02f, 1.94876105e-01f, 4.65693586e-02f, -3.86599973e-02f,
  6.72826022e-02f, -2.29304045e-01f, -2.06091002e-01f, -1.77093536e-01f, 1.23095378e-01f, 5.81781231e-02f, -2.43070185e-01f, -1.37127846e-01f, -2.06765175e-01f, -3.09146289e-02f,
  5.05844653e-02f, -2.84930617e-02f, 5.13790219e-05f, -2.13175919e-03f, -8.32678825e-02f, -2.70907748e-02f, -4.61334037e-03f, -3.98812704e-02f, 1.24760726e-02f, -5.02265319e-02f,
  2.10737556e-01f, -6.57006353e-02f, -2.11216565e-02f, 5.81499236e-03f, -2.97422875e-02f, 6.79326952e-02f, 6.96516410e-02f, 1.62517920e-01f, 8.66364390e-02f, 3.72808601e-04f,
  1.89351842e-01f, 1.48660019e-01f, -9.64490846e-02f, -6.31703883e-02f, 1.68421883e-02f, 2.21273284e-02f, -3.31791267e-02f, -8.03061128e-02f, -5.53632528e-03f, 3.12445220e-02f,
  -1.36929881e-02f, 3.89315337e-02f, -8.13229457e-02f, -2.53263377e-02f, -2.03154031e-02f, 5.26856072e-02f, -6.84068426e-02f, -7.71824270e-02f, 4.63153832e-02f, -3.05572432e-02f,
  1.68923251e-02f, 3.53219658e-02f, 1.67612154e-02f, 7.81408697e-02f, 6.03903718e-02f, 8.02179042e-04f, -9.49784145e-02f, 4.70763557e-02f, 1.37774572e-01f, 3.96966226e-02f,
  2.49502659e-02f, -2.89056264e-02f, -7.20792264e-02f, 6.01991713e-02f, -1.29843159e-02f, -6.71002269e-02f, -1.15003099e-03f, 8.38941336e-02f, 5.64569309e-02f, -9.19849053e-02f,
  -7.75097981e-02f, 3.01720239e-02f, 4.46495455e-04f, -1.23243034e-02f, -1.58905145e-02f, -6.86591342e-02f, 3.98023501e-02f, 4.21163104e-02f, -7.08334818e-02f, -1.33730983e-03f,
  1.05565175e-01f, -3.08486242e-02f, -1.72513034e-02f, -7.35539431e-03f, -6.87512010e-02f, -7.76444301e-02f, 4.40415964e-02f, -7.25301960e-03f, -1.24810256e-01f, -4.66579087e-02f,
  8.75459164e-02f, -1.97008774e-02f, 2.43941844e-02f, 5.32011613e-02f, 5.22898845e-02f, -4.09259573e-02f, 7.32954741e-02f, -5.59915192e-02f, -4.85504884e-03f, -6.22637756e-02f,
  -4.26595718e-01f, -2.95752376e-01f, -5.67106009e-01f, 1.13989793e-01f, 6.48806542e-02f, 2.50346601e-01f, -1.63462579e-01f, -1.41392916e-03f, -1.97133601e-01f, 1.69298902e-01f,
  1.78234264e-01f, -1.15219042e-01f, -2.98843950e-01f, 2.67680645e-01f, -9.91251245e-02f, -1.34958789e-01f, 2.43056059e-01f, 2.25465730e-01f, -1.14104398e-01f, -6.05122857e-02f,
  -4.92534228e-02f, 3.79258901e-01f, -5.69213703e-02f, 2.55119890e-01f, -3.99988517e-02f, -4.66163196e-02f, 2.16531634e-01f, -1.76738977e-01f, 3.21588397e-01f, 2.04425842e-01f,
  5.77520765e-02f, -3.31690758e-01f, -7.19333813e-02f, 3.80471162e-02f, -4.95881913e-03f, 7.18375668e-02f, 1.06291339e-01f, -4.11813445e-02f, -3.21460180e-02f, -5.27404100e-02f,
  -4.38651070e-02f, -1.29419733e-02f, 6.26538098e-02f, 1.23715904e-02f, 1.51040843e-02f, -2.49471683e-02f, -1.00623265e-01f, 7.03035519e-02f, -4.15368713e-02f, -1.27000600e-01f,
  -1.16550870e-01f, 5.92794679e-02f, 1.20900303e-01f, -3.25230975e-03f, -5.84375747e-02f, 1.04285382e-01f, 6.95540160e-02f, 2.87735695e-03f, 4.68755402e-02f, 8.45992342e-02f,
  -6.73466995e-02f, 1.00097675e-02f, -5.73916063e-02f, 6.34210110e-02f, -9.41677094e-02f, -3.43712643e-02f, 3.91538814e-02f, 8.23498443e-02f, -2.88904458e-02f, -3.76950279e-02f,
  6.81283846e-02f, -5.24488464e-02f, 3.14757228e-02f, -3.30957980e-03f, 1.13931283e-01f, 3.64379887e-03f, 6.37459988e-03f, 1.43010439e-02f, 1.89710166e-02f, 3.74889150e-02f,
  1.09298959e-01f, -3.37383263e-02f, -2.79997457e-02f, 3.87896150e-02f, 5.95760234e-02f, -1.27732560e-01f, 3.48287188e-02f, -1.27365455e-01f, 4.63389745e-03f, 1.13735653e-01f,
  -2.11867198e-01f, -3.44083190e-01f, 7.66884759e-02f, 3.08304820e-02f, -1.09651042e-02f, 1.13986701e-01f, -2.74487194e-02f, 8.24336801e-03f, -4.73380014e-02f, -5.57836033e-02f,
  -6.37495071e-02f, 1.31929919e-01f, -6.66447654e-02f, -4.45383973e-02f, 8.95615593e-02f, 1.70280803e-02f, -3.80859408e-03f, -2.55520036e-03f, 8.41206759e-02f, -9.90273524e-03f,
  2.89857145e-02f, -1.47120535e-01f, 1.36255205e-01f, -2.56862142e-03f, 1.14020862e-01f, -5.78935556e-02f, 9.69023928e-02f, 2.20285710e-02f, 1.12555899e-01f, -2.95432173e-02f,
  -4.16924447e-01f, 2.44003937e-01f, -3.01143825e-01f, -1.88355222e-01f, 2.02655960e-02f, -4.35408145e-01f, -3.30709547e-01f, 8.75179991e-02f, 1.75221965e-01f, 1.37871757e-01f,
  2.25648601e-02f, 3.96050923e-02f, 2.08905533e-01f, -1.63117766e-01f, -4.21796143e-01f, 1.64526161e-02f, -2.94436663e-01f, -1.85609877e-01f, -9.78328288e-03f, -9.45618749e-02f,
  -5.60774654e-02f, 6.39320686e-02f, -2.80879915e-01f, 1.41615808e-01f, -3.75932157e-02f, 2.00872555e-01f, 1.34222195e-01f, 2.90545791e-01f, -9.97967422e-02f, 8.29268321e-02f,
  -2.41884604e-01f, 1.22873135e-01f, 4.27039452e-02f, -1.22733593e-01f, -1.15660250e-01f, -4.50867154e-02f, -4.30530794e-02f, 2.99897790e-02f, -1.51995430e-02f, -6.81259185e-02f,
  -3.29474583e-02f, -2.19020266e-02f, 3.00560594e-02f, 6.93158880e-02f, -1.50733804e-02f, -1.78367700e-02f, 4.42680009e-02f, -4.66438383e-02f, -2.61084503e-03f, -2.29059905e-02f,
  -1.70450043e-02f, -1.33929830e-02f, 2.48475540e-02f, -5.53159323e-03f, -1.60859190e-02f, 4.32948768e-02f, -1.82038859e-01f, 2.34550703e-02f, -6.32761195e-02f, -3.91603075e-02f,
  -5.54450043e-02f, -1.52081735e-02f, 2.09815148e-02f, 1.26004934e-01f, -4.63997043e-04f, 9.05616879e-02f, 9.91201960e-03f, 5.03201373e-02f, -1.30181601e-02f, 7.99383223e-02f,
  -3.91951762e-02f, 3.29600759e-02f, 7.97860697e-02f, 5.18668303e-03f, -2.48320904e-02f, 4.01623780e-03f, 6.47312403e-02f, -4.75617014e-02f, -7.76096657e-02f, -7.90281296e-02f,
  8.96915421e-02f, -4.08078916e-02f, 6.21940121e-02f, -3.93918641e-02f, -1.79495569e-02f, -6.33611605e-02f, 3.42845148e-03f, 7.71468133e-02f, -4.58925106e-02f, -1.03941569e-02f,
  -1.40218839e-01f, 9.89931524e-02f, 9.51230973e-02f, 2.76120044e-02f, 2.09391844e-02f, -2.84716301e-02f, -6.86174084e-04f, -1.52240628e-02f, -8.39517638e-02f, 6.11104891e-02f,
  7.39409775e-03f, -4.69555445e-02f, -6.58840388e-02f, -2.05311384e-02f, -1.69665068e-02f, 2.78096683e-02f, -2.48714089e-02f, 6.55290261e-02f, -9.58661512e-02f, 6.15708791e-02f,
  8.87979418e-02f, 5.48077608e-03f, 1.24679729e-02f, -1.72478259e-02f, 7.94077132e-05f, -9.34791863e-02f, -5.18544530e-03f, -9.20919422e-03f, 7.94033229e-04f, -9.91778001e-02f,
  -5.19866869e-02f, 3.18494514e-02f, -1.06665399e-02f, 6.20102584e-02f, 8.76404420e-02f, -2.02709846e-02f, -2.90119648e-01f, 2.07635671e-01f, -2.04529181e-01f, -7.07093328e-02f,
  1.37233481e-01f, -4.42726873e-02f, -1.34003669e-01f, 1.31414443e-01f, 3.07343513e-01f, -2.00859040e-01f, 1.94866598e-01f, 1.47971660e-01f, 6.89939782e-02f, 2.59825885e-01f,
  2.47262090e-01f, 2.99815208e-01f, 1.53787225e-01f, 1.85557127e-01f, 2.70076871e-01f, 2.26997003e-01f, 2.84549981e-01f, 1.25518930e-03f, 3.33105147e-01f, 1.01632290e-01f,
  -1.40278682e-01f, 8.51804838e-02f, -2.83565503e-02f, -4.06724624e-02f, 5.68880178e-02f, -1.02241039e-01f, -2.56031882e-02f, -4.94728126e-02f, 4.47767973e-03f, 1.00355312e-01f,
  2.23775972e-02f, -1.11590615e-02f, 1.29261464e-02f, -1.85895804e-02f, -4.37664054e-02f, -1.01319313e-01f, 4.95559685e-02f, -1.30663991e-01f, -3.13023711e-03f, 7.54316477e-03f,
  5.94078526e-02f, 2.06781458e-02f, 4.02380787e-02f, -6.40924945e-02f, -4.48041186e-02f, -2.14191563e-02f, 1.14522494e-01f, -4.45294455e-02f, 4.65420485e-02f, 6.53676689e-02f,
  8.15181732e-02f, -6.62146648e-03f, -7.56317228e-02f, -2.58211978e-02f, -1.46964053e-02f, -2.29627010e-03f, 7.55718648e-02f, -3.88925895e-02f, 8.89631920e-03f, -2.93666460e-02f,
  -5.60887307e-02f, -4.29369621e-02f, -1.52147189e-02f, -5.01556974e-03f, 2.00593267e-02f, -3.88583913e-02f, 7.32777116e-04f, 4.10318077e-02f, -8.38247165e-02f, 6.72383010e-02f,
  -1.47412598e-01f, 1.97203308e-02f, -5.24658896e-02f, -4.00702283e-02f, 8.91056880e-02f, -7.00734407e-02f, 2.33185515e-02f, 4.84226048e-02f, 7.71085992e-02f, -7.97079003e-04f,
  8.50495473e-02f, 2.88145483e-01f, 4.53320891e-02f, -6.24636114e-02f, -3.64556164e-02f, 8.43754038e-02f, -1.10400490e-01f, 1.24883004e-01f, 1.28448904e-01f, 7.05144331e-02f,
  7.59603083e-02f, 5.46316318e-02f, 2.27445904e-02f, -1.12868957e-01f, 4.66574542e-02f, 7.44268065e-03f, 4.32600677e-02f, 7.38009661e-02f, -1.54688652e-03f, 1.05002835e-01f,
  6.38359413e-02f, 5.98966563e-03f, 2.64855125e-03f, 2.68419087e-02f, -3.55905555e-02f, 1.87662139e-03f, 9.90542583e-03f, 6.92194253e-02f, 1.42746612e-01f, 3.60369533e-02f,
  2.03728393e-01f, 2.72268355e-01f, -2.29088366e-01f, 5.02369665e-02f, -4.56085384e-01f, 1.71512589e-01f, 1.06687576e-01f, -2.22240210e-01f, 1.02307267e-01f, 2.35654175e-01f,
  1.50592431e-01f, 1.97023824e-01f, 1.44390389e-01f, 3.20916325e-01f, -2.41097361e-01f, 1.25535354e-01f, 3.38857561e-01f, 1.89823449e-01f, -4.12383899e-02f, 1.53539270e-01f,
  -2.56778356e-02f, 3.19936723e-02f, 1.07845120e-01f, -7.38727525e-02f, 1.73330665e-01f, -2.01651510e-02f, -2.29724478e-02f, -1.46081701e-01f, 1.07340567e-01f, -7.67913386e-02f,
  4.37579565e-02f, 1.58390015e-01f, -5.94160259e-02f, 3.17115104e-03f, 4.76873247e-03f, 1.40512109e-01f, -6.18406944e-02f, -1.62217379e-01f, -8.99129137e-02f, 4.45176363e-02f,
  2.93558706e-02f, -8.11377093e-02f, -3.52058001e-03f, -2.01984659e-01f, 4.94523421e-02f, -7.73366094e-02f, -2.85028480e-03f, -1.01318210e-01f, 5.52712567e-02f, 3.14309187e-02f,
  8.45183581e-02f, 1.03196219e-01f, 6.58112466e-02f, 2.19068676e-02f, -1.93930343e-02f, 1.02188043e-01f, 8.39057192e-02f, -6.85162619e-02f, -6.23072498e-04f, 7.02087134e-02f,
  1.70176793e-02f, 2.76548415e-02f, 1.15333386e-01f, 9.20466781e-02f, -8.94326344e-02f, -1.64468568e-02f, 3.36428918e-02f, 5.29074334e-02f, -5.75625598e-02f, -7.25959092e-02f,
  7.43862763e-02f, -5.26416712e-02f, 3.61110121e-02f, -2.16004020e-03f, 1.08854443e-01f, 9.73983482e-02f, 1.40004968e-02f, -1.20471664e-01f, 5.06999791e-02f, -6.69339523e-02f,
  5.62055362e-03f, -3.93298306e-02f, 6.96317852e-02f, 8.66633877e-02f, 8.81192908e-02f, 1.34631591e-02f, 1.53410494e-01f, -1.12586897e-02f, -3.82617973e-02f, 5.59127107e-02f,
  -1.54494564e-03f, -7.80397803e-02f, 2.65535153e-02f, 2.77063232e-02f, 7.58198509e-03f, -3.52961123e-02f, 5.19801825e-02f, 4.03516702e-02f, 1.05312400e-01f, 1.97773823e-03f,
  -5.20868301e-02f, -4.51409519e-02f, 4.35839482e-02f, -5.80964573e-02f, -1.40625332e-02f, 7.60801136e-02f, 7.27555305e-02f, 6.46292344e-02f, -5.14853895e-02f, -3.97884753e-03f,
  -3.76203097e-02f, 2.94103976e-02f, 3.14499624e-02f, 4.85677458e-03f, 1.46311242e-02f, 1.75527483e-02f, -1.54062897e-01f, 6.01011813e-02f, 4.33652662e-02f, 9.67726931e-02f,
  2.00692758e-01f, 1.03883669e-01f, 1.69328839e-01f, 2.12011412e-01f, 9.94552076e-02f, -1.84858039e-01f, -1.65011346e-01f, 3.18688713e-02f, -1.19249046e-01f, 1.44328251e-01f,
  -2.63877958e-01f, 1.78159773e-01f, -3.45347852e-01f, -3.73215340e-02f, -4.26349908e-01f, -3.58400792e-01f, -1.16029426e-01f, -5.49639352e-02f, -2.39128962e-01f, 4.62525412e-02f,
  4.29990143e-02f, -9.40728858e-02f, -5.20769283e-02f, 1.26656339e-01f, 2.29095325e-01f, 2.96734810e-01f, 2.21544966e-01f, 4.24241535e-02f, 3.14624667e-01f, -4.43336628e-02f,
  -2.63480227e-02f, -6.89624250e-02f, 8.38808417e-02f, 6.99598119e-02f, -1.38763255e-02f, 1.23801999e-01f, 1.21214502e-01f, -1.28121078e-01f, -4.78414223e-02f, 3.29646505e-02f,
  4.20402437e-02f, 4.97249104e-02f, -4.46237996e-02f, -2.00335104e-02f, 9.84880626e-02f, 2.26679016e-02f, 1.24511547e-01f, 1.39143482e-01f, 9.82925519e-02f, -4.59600007e-03f,
  5.28283902e-02f, 8.56621638e-02f, 1.38575420e-01f, -4.22169492e-02f, -3.32549252e-02f, -7.13298991e-02f, 1.11458994e-01f, 1.05766870e-01f, 1.42593011e-01f, 2.22451370e-02f,
  -5.32735698e-02f, 7.21181855e-02f, 3.47981080e-02f, 3.64462249e-02f, 6.26132041e-02f, 3.86673249e-02f, -2.80043390e-02f, -4.12021913e-02f, 3.64119895e-02f, 4.28617261e-02f,
  3.68027613e-02f, 6.95699602e-02f, -1.29398191e-02f, 9.92228091e-02f, 8.50721821e-02f, -2.18026824e-02f, 5.88411093e-02f, -7.74545770e-04f, 1.14541072e-02f, -3.99427041e-02f,
  -9.37097147e-02f, -6.99447766e-02f, -5.66594675e-02f, -1.33658303e-02f, -9.09660757e-02f, -5.43102473e-02f, 5.09359427e-02f, 4.25182879e-02f, 3.88294086e-02f, 1.30559858e-02f,
  -6.24020845e-02f, -1.41952589e-01f, -6.43772483e-02f, -5.78950755e-02f, -1.77644473e-03f, -2.22300948e-03f, -5.31698391e-02f, 9.86771733e-02f, -8.22099596e-02f, -7.69417733e-02f,
  1.18150972e-01f, 8.85970145e-02f, 2.46909764e-02f, 4.92338017e-02f, -3.66337448e-02f, -1.36910662e-01f, -6.86999550e-03f, 3.51918936e-02f, 1.09274305e-01f, 7.49936909e-04f,
  8.52246396e-03f, -6.84972405e-02f, 8.87093842e-02f, 5.08022383e-02f, -2.47211568e-02f, 5.57305180e-02f, 1.62129407e-03f, 8.64651576e-02f, -1.12462323e-02f, -1.23731010e-02f,
  9.65114012e-02f, -7.48915821e-02f, 2.01051474e-01f, 2.78787434e-01f, 2.66095586e-02f, -1.59140304e-01f, -8.51026773e-02f, 3.17215443e-01f, 1.17108645e-02f, -2.73337603e-01f,
  -1.27325375e-02f, -3.25222313e-01f, -7.11763129e-02f, -3.49996723e-02f, 1.94629520e-01f, -2.10500509e-01f, 1.20293424e-01f, -1.54774904e-01f, 1.22434713e-01f, 1.36591688e-01f,
  2.77683258e-01f, 1.27590209e-01f, 3.02270889e-01f, 3.68657649e-01f, 1.45283684e-01f, 3.90341729e-01f, 3.85111094e-01f, 1.03397764e-01f, 1.10357516e-01f, 1.62762534e-02f,
  -2.01462787e-02f, -8.12550485e-02f, 2.16675512e-02f, -1.28012538e-01f, 1.06731758e-01f, -4.45536561e-02f, -1.04228742e-01f, -5.81582189e-02f, 6.44436181e-02f, -2.80045550e-02f,
  -1.22070774e-01f, 4.93275970e-02f, -2.84297019e-02f, -1.36080459e-01f, -5.20279184e-02f, 1.53248310e-01f, 9.59588289e-02f, 4.05545682e-02f, -2.77026352e-02f, 2.06658691e-02f,
  3.72827537e-02f, -1.17486037e-01f, 1.56772714e-02f, -5.87208979e-02f, 7.26869404e-02f, 1.32746471e-03f, -9.79122426e-03f, 3.02584581e-02f, -1.59712266e-02f, 1.51072547e-01f,
  8.45768116e-03f, -3.47881541e-02f, 5.68226390e-02f, 1.11329660e-01f, 5.44478707e-02f, -3.99248488e-02f, -1.08254571e-02f, -4.71627079e-02f, 3.54803773e-03f, 6.38636574e-02f,
  -5.22203930e-03f, -1.67756919e-02f, -2.13834108e-03f, 3.42711434e-02f, -4.32714708e-02f, -9.25480723e-02f, 1.59210283e-02f, -5.13402745e-02f, 1.01576746e-01f, -3.19862203e-03f,
  -2.52755079e-02f, -8.22775885e-02f, 1.02227271e-01f, -5.30084148e-02f, 7.80569948e-03f, -3.63517702e-02f, 4.03299276e-03f, -1.66380703e-02f, -1.80365890e-02f, 7.97177702e-02f,
  -6.90361559e-02f, 1.71222351e-02f, 1.40096517e-02f, -2.30901632e-02f, 4.39308807e-02f, -1.61716044e-02f, -1.46641493e-01f, -6.09928742e-03f, -5.43924980e-02f, -1.85352713e-02f,
  1.80225093e-02f, 4.58538644e-02f, -2.02005386e-01f, 3.13555077e-02f, 1.55245170e-01f, -3.72352563e-02f, -3.49106193e-02f, 8.26752558e-02f, 8.76898766e-02f, 6.14610203e-02f,
  4.83580716e-02f, -1.65721346e-02f, 1.37506962e-01f, -7.06697926e-02f, 1.00569949e-01f, -1.19583115e-01f, -5.67833297e-02f, -2.58977935e-02f, -1.93646401e-02f, 1.06900111e-02f,
  -2.84802735e-01f, 2.89832354e-01f, -2.34935880e-01f, -6.54256344e-02f, -3.03719193e-01f, 6.00800931e-01f, 3.63724977e-01f, 7.43009325e-04f, 7.20870048e-02f, 3.31325322e-01f,
  2.87679493e-01f, -7.78872520e-02f, 2.35931531e-01f, 2.71356881e-01f, 1.06340528e-01f, 4.91049796e-01f, 2.87916481e-01f, 2.76972592e-01f, -2.14161277e-02f, 1.21333227e-02f,
  -5.03015295e-02f, 2.47677326e-01f, 8.63728300e-02f, -1.48629457e-01f, 3.31875347e-02f, -2.30866373e-01f, -8.98161903e-02f, -6.09918907e-02f, -3.09162773e-02f, 3.35759819e-02f,
  6.17587678e-02f, -2.24010181e-03f, -2.29038566e-01f, -6.84018210e-02f, 1.85323022e-02f, -1.31335855e-01f, -7.80139118e-02f, -9.32136327e-02f, -1.47215769e-01f, 6.73845317e-03f,
  7.11524263e-02f, -2.24044938e-02f, 4.17376943e-02f, -4.37081009e-02f, -4.77250665e-02f, -7.27462173e-02f, 1.96018703e-02f, 8.88537674e-04f, -1.02682086e-02f, -6.82360530e-02f,
  8.08130726e-02f, 4.90826108e-02f, 8.05275291e-02f, 3.02636344e-02f, -8.66275281e-02f, -2.49363091e-02f, 1.35078713e-01f, 3.34578343e-02f, 6.88966811e-02f, 1.87121332e-02f,
  -1.32941324e-02f, 2.81023514e-02f, 4.69161682e-02f, -3.83348465e-02f, -4.00782935e-02f, -4.10825275e-02f, -4.53500748e-02f, -1.61228944e-02f, -3.92296277e-02f, 3.83598059e-02f,
  -1.32962381e-02f, -4.51339968e-02f, 6.11007996e-02f, 6.44812733e-02f, -1.85956210e-02f, 4.58803624e-02f, -9.26277265e-02f, -2.05593868e-04f, 6.05473779e-02f, 3.51281762e-02f,
  -2.28599161e-02f, 2.46639363e-02f, 9.06497706e-03f, -9.04879048e-02f, 8.50118976e-03f, -3.37800719e-02f, 4.20071110e-02f, 7.11873621e-02f, 5.56836277e-02f, -2.13083308e-02f,
  2.41484344e-01f, -4.21781391e-02f, 3.01365871e-02f, 5.83186597e-02f, -7.02006519e-02f, 7.06712296e-03f, -2.16333698e-02f, -1.05131175e-02f, 3.09028709e-03f, 2.28602942e-02f,
  5.33101335e-03f, 5.05323485e-02f, -6.76309271e-03f, -7.72457942e-02f, -6.29609376e-02f, 4.02270816e-02f, 7.62062669e-02f, 2.38671284e-02f, 5.12010269e-02f, 1.04475487e-02f,
  -4.85494323e-02f, 2.20560059e-02f, -5.63691519e-02f, 3.10314400e-03f, 1.04209529e-02f, 8.44395310e-02f, 4.09790389e-02f, -6.85692057e-02f, -7.38312677e-02f, 3.10692471e-02f,
  3.87763619e-01f, -1.14560015e-01f, 2.68160433e-01f, 2.75144845e-01f, 3.25957417e-01f, 3.00659001e-01f, 4.02955055e-01f, -8.44493974e-03f, 4.34242636e-01f, -2.18648076e-01f,
  -8.54262337e-02f, 8.13092738e-02f, -6.55847713e-02f, -3.46256755e-02f, 2.18392592e-02f, -8.83216634e-02f, 1.35929525e-01f, 6.03268780e-02f, 2.15666801e-01f, 1.05003521e-01f,
  1.66124940e-01f, -1.40242457e-01f, -9.01334584e-02f, -3.21738869e-01f, 1.48173675e-01f, 6.57980442e-02f, -2.56376684e-01f, 8.51316825e-02f, -1.76016867e-01f, 1.00665085e-01f,
  1.16839960e-01f, 6.31343126e-02f, -1.52961174e-02f, -7.92416930e-02f, 2.16308832e-02f, -4.52114008e-02f, -6.16802759e-02f, -1.07622497e-01f, 3.21807340e-02f, -3.09510753e-02f,
  -1.02983885e-01f, -6.53309971e-02f, -5.14569953e-02f, 3.25940475e-02f, 2.54710559e-02f, 7.88073242e-02f, 6.92861602e-02f, -2.06354931e-02f, -6.32543713e-02f, 1.11815399e-02f,
  -6.92812800e-02f, -8.81854817e-02f, 3.23442221e-02f, -1.21362917e-02f, -2.99665388e-02f, 5.48127778e-02f, -1.20944142e-01f, -2.86705438e-02f, 6.43749759e-02f, 2.74923779e-02f,
  -6.82505891e-02f, -4.90133464e-02f, 4.77378443e-02f, 5.77305630e-02f, 1.72600504e-02f, -1.62962396e-02f, 4.40251455e-02f, -4.62729000e-02f, -3.34868347e-03f, 2.46082265e-02f,
  6.27223551e-02f, 2.51391307e-02f, -6.39672354e-02f, 7.78689682e-02f, 3.27213369e-02f, -2.47866660e-02f, -4.92219925e-02f, -1.06944248e-01f, 4.03592475e-02f, 6.12090295e-03f,
  -5.61554125e-03f, -3.82630117e-02f, 2.16167513e-02f, 4.16584015e-02f, 3.65413800e-02f, -1.04086073e-02f, -5.79681471e-02f, -4.45356295e-02f, 1.88595953e-03f, -6.51607737e-02f,
  -1.01984777e-02f, -1.73724279e-01f, -5.84028102e-02f, -1.47233158e-01f, -1.02804430e-01f, 9.27789509e-03f, 8.19616765e-03f, 1.20756645e-02f, 7.91914936e-05f, -1.54314516e-02f,
  -8.06739479e-02f, 9.75108594e-02f, -1.98971201e-02f, 9.23652481e-03f, -1.02510393e-01f, 6.59510791e-02f, 2.42896890e-03f, -1.11450702e-01f, -5.89240976e-02f, -7.16151595e-02f,
  -4.87995446e-02f, -5.28641641e-02f, -2.28731260e-02f, -2.54813880e-02f, -4.96124551e-02f, -9.68570262e-02f, -1.30891055e-02f, 4.21256684e-02f, -4.79001515e-02f, -2.83414535e-02f,
  3.82347524e-01f, -2.71458179e-01f, -2.75825024e-01f, 8.94230306e-02f, 3.79877836e-01f, 1.53809071e-01f, -1.50155187e-01f, 1.69879273e-01f, 1.20373806e-02f, -1.69653863e-01f,
  1.72483459e-01f, -2.56511420e-01f, -3.06752324e-01f, 1.56457782e-01f, 9.91514027e-02f, -2.51969218e-01f, 1.39532983e-01f, 9.60986987e-02f, -6.24622330e-02f, -1.65041368e-02f,
  -7.63894320e-02f, 3.70838404e-01f, -2.63054222e-01f, 2.27208018e-01f, 1.76484749e-01f, -1.61403134e-01f, 5.34929708e-02f, -1.94885626e-01f, 2.08033808e-02f, 7.85235241e-02f,
  6.42432049e-02f, -8.58149230e-02f, -1.74896559e-03f, -2.56876890e-02f, -6.69250637e-02f, 5.61654381e-02f, -5.75976036e-02f, 9.43557639e-03f, -5.25475703e-02f, 7.83828273e-03f,
  -9.00110696e-03f, -6.45941794e-02f, 1.04962900e-01f, -5.06102592e-02f, 7.22266212e-02f, 1.20896392e-01f, -2.38669775e-02f, -6.20528907e-02f, -6.34202641e-03f, -1.48947820e-01f,
  -1.15101449e-01f, 7.50834122e-02f, 2.85331234e-02f, -7.82496706e-02f, -1.42893428e-02f, -3.34324129e-02f, -1.37494221e-01f, -6.77428693e-02f, 8.76420438e-02f, 8.44789855e-03f,
  -3.87471728e-03f, -5.27487844e-02f, 3.63970734e-03f, 3.37081999e-02f, -2.71810461e-02f, -1.47647550e-03f, 6.36554509e-02f, 3.10647092e-03f, -5.84138408e-02f, -5.96498922e-02f,
  -1.09746614e-02f, 4.39636707e-02f, -1.10230483e-02f, 2.33770870e-02f, -6.06152527e-02f, -1.06162755e-02f, -4.23618876e-05f, -8.38984251e-02f, -2.09566411e-02f, 5.63433543e-02f,
  -5.62230684e-02f, 1.32543212e-02f, -6.90756962e-02f, -3.92413288e-02f, 5.06384857e-02f, -1.40874777e-02f, 3.92508022e-02f, -5.87386787e-02f, -1.47133535e-02f, 6.52022148e-03f,
  -7.86313564e-02f, -2.18367532e-01f, -1.35110974e-01f, 1.12816133e-01f, -1.81673635e-02f, 7.97392428e-02f, 1.73428580e-02f, 1.10283226e-01f, -9.05135740e-03f, -5.85243013e-03f,
  1.21732438e-02f, 1.32746734e-02f, 2.39583123e-02f, 9.48491395e-02f, 7.02723712e-02f, -3.21844406e-02f, -4.89430092e-02f, -3.22212614e-02f, 4.48681833e-03f, 1.92384068e-02f,
  8.84795636e-02f, -5.28835431e-02f, -3.16087306e-02f, 1.67434037e-01f, 5.14738858e-02f, -7.78272003e-02f, -1.22848470e-02f, -8.82785320e-02f, -7.60827772e-03f, -3.83710377e-02f,
  -3.74348499e-02f, -1.33170590e-01f, -1.39395803e-01f, -9.67253149e-02f, -1.34259596e-01f, -5.17930031e-01f, -3.77455384e-01f, -1.31702617e-01f, 1.27397060e-01f, -9.26455408e-02f,
  -3.07103731e-02f, 1.03884444e-01f, 1.91990510e-01f, -2.12369487e-01f, 2.07388289e-02f, 1.13029756e-01f, -3.27860355e-01f, -2.10453674e-01f, 1.94332711e-02f, -3.04612666e-02f,
  -5.95968124e-03f, -1.39086545e-01f, -1.71678215e-02f, -5.71705885e-02f, -1.62781268e-01f, 1.00223228e-01f, 1.18912220e-01f, 1.03490204e-01f, -2.09288329e-01f, 3.58661488e-02f,
  -7.98659772e-02f, 1.18990786e-01f, -7.24934042e-02f, 1.23033170e-02f, -1.04836620e-01f, -6.58862069e-02f, -2.23982334e-01f, -3.40833887e-02f, 4.12848704e-02f, 1.33786529e-01f,
  -9.86164659e-02f, 2.09299922e-02f, 3.76127884e-02f, 5.20392805e-02f, -4.26160581e-02f, 3.96488681e-02f, 8.02957453e-03f, -1.32338732e-01f, 8.16051364e-02f, -3.91195007e-02f,
  5.12956381e-02f, -5.70383482e-02f, -4.94906977e-02f, 5.32587245e-02f, 3.40713449e-02f, 1.48378741e-02f, -8.91296268e-02f, -3.85671966e-02f, -2.93401419e-03f, 2.34213918e-02f,
  -6.02703393e-02f, 4.24882658e-02f, -3.94048542e-02f, -8.76957271e-03f, 2.31434386e-02f, -6.90669566e-02f, 4.68682274e-02f, -2.41493918e-02f, 9.72610191e-02f, -1.10859722e-01f,
  -1.71269774e-02f, 6.86150119e-02f, -3.44655216e-02f, -4.89906184e-02f, -1.62575897e-02f, -2.93965843e-02f, -7.93907270e-02f, 4.87204175e-03f, -4.52947952e-02f, -5.82876429e-02f,
  1.28939554e-01f, 2.66773580e-03f, -7.45313242e-02f, 9.80414823e-03f, -5.83170541e-02f, -1.19113348e-01f, 6.36469424e-02f, -5.12411706e-02f, 1.43885821e-01f, 3.31642516e-02f,
  -7.38467649e-02f, 2.86773089e-02f, -1.41487196e-02f, 1.04073875e-01f, -1.09413497e-01f, -1.31551579e-01f, -3.78298424e-02f, 6.24091327e-02f, 7.31587335e-02f, 4.25535366e-02f,
  -3.58722508e-02f, 2.16243807e-02f, -1.34523198e-01f, 1.32222027e-02f, -5.10089882e-02f, -1.15030147e-01f, 1.00552574e-01f, 3.82652432e-02f, -1.71040073e-02f, 2.48314403e-02f,
  3.34036388e-02f, -1.02910548e-01f, 1.69217676e-01f, 3.15044336e-02f, 8.88055004e-03f, 1.00865103e-02f, -1.02001637e-01f, -6.01196885e-02f, -3.26148495e-02f, 3.29099596e-02f,
  7.68353939e-02f, -4.48502988e-01f, 1.31395250e-03f, -7.41285384e-02f, 1.88728780e-01f, -1.32847764e-02f, -2.49751639e-02f, -2.82664061e-01f, -1.38284802e-01f, -2.93786317e-01f,
  3.40948743e-03f, 1.32659525e-01f, -9.29444656e-02f, -2.33624429e-01f, 5.55482924e-01f, 1.02213599e-01f, -6.29601926e-02f, 6.00894466e-02f, 5.25281690e-02f, -1.63450375e-01f,
  8.39377230e-04f, -1.83266729e-01f, 1.32628769e-01f, -1.55397967e-01f, 3.03293974e-03f, -7.32810982e-03f, 2.06489250e-01f, 2.19232023e-01f, -8.98482427e-02f, 2.94275761e-01f,
  -1.80777460e-01f, -1.60289094e-01f, -1.38462245e-01f, -4.45347540e-02f, -1.76210374e-01f, 5.80353215e-02f, 1.09696850e-01f, 1.53295696e-01f, -1.89039037e-02f, -6.29014596e-02f,
  3.04592066e-02f, 4.15268056e-02f, -9.24772695e-02f, 8.39215368e-02f, -1.56807974e-02f, -1.94339715e-02f, -3.64282797e-03f, -3.83078307e-02f, 4.07044739e-02f, 3.06546204e-02f,
  1.27611458e-01f, 4.48740572e-02f, -4.86708917e-02f, -4.18774737e-03f, 1.08661596e-02f, 8.87246877e-02f, 1.33958738e-02f, 1.19695827e-01f, 8.65412578e-02f, 3.03162932e-02f,
  1.13202989e-01f, 1.59871373e-02f, -6.16340861e-02f, -7.25024566e-02f, -8.96598473e-02f, -2.66348328e-02f, -1.89487170e-02f, 2.25146096e-02f, -8.18827376e-02f, -2.83274837e-02f,
  -9.69425812e-02f, -1.83782540e-02f, -5.97896390e-02f, -4.13219407e-02f, -1.19643351e-02f, -6.43006116e-02f, 4.24257526e-03f, 2.24781744e-02f, 1.10388845e-02f, -4.15411778e-03f,
  1.40153505e-02f, 4.89308592e-03f, 2.86318492e-02f, -7.60623207e-03f, 7.30372919e-03f, 4.14370075e-02f, -5.44362143e-02f, -2.95217778e-03f, 3.57666798e-02f, 5.47901317e-02f,
  -3.67495477e-01f, -4.84802127e-01f, -2.15113219e-02f, -1.08621716e-01f, -6.87091649e-02f, -4.46899571e-02f, -6.12387098e-02f, -4.92505692e-02f, -1.14721388e-01f, -4.00724337e-02f,
  3.67841721e-02f, -2.44103801e-02f, -3.82161140e-02f, 3.82704027e-02f, -3.76664512e-02f, -5.17890640e-02f, 5.01285046e-02f, -1.87991951e-02f, -6.22696988e-02f, -7.68954679e-02f,
  -4.60433401e-02f, 7.37297460e-02f, 5.63665703e-02f, 1.33747663e-02f, -1.64379720e-02f, 3.99294794e-02f, -2.85206120e-02f, -1.24811139e-02f, 7.77531564e-02f, 3.86680514e-02f,
  -7.63557076e-01f, 3.39443147e-01f, 1.03108652e-01f, 2.43157316e-02f, -1.82204649e-01f, 3.01125318e-01f, 3.67360115e-01f, -2.51769368e-02f, 1.89228311e-01f, 4.85038534e-02f,
  -4.68102582e-02f, -1.43219516e-01f, 4.78749648e-02f, 4.00071256e-02f, 7.79837929e-03f, 1.78706512e-01f, 2.20125198e-01f, 3.86936329e-02f, 2.40972131e-01f, -2.86550045e-01f,
  -5.13058789e-02f, -6.62468076e-02f, -1.06539568e-02f, -2.23756600e-02f, -1.97795793e-01f, -9.68811288e-02f, -2.01620191e-01f, 6.07644506e-02f, -1.39936998e-01f, 1.29951149e-01f,
  -2.15629369e-01f, -1.73526749e-01f, -2.23347664e-01f, -1.06705710e-01f, -9.37774032e-02f, -6.04487509e-02f, 6.46620020e-02f, 1.07450904e-02f, -5.65005206e-02f, -6.15289509e-02f,
  1.38709042e-02f, -3.80892232e-02f, 8.27179942e-03f, 4.48096097e-02f, 4.24897149e-02f, -9.51036811e-03f, -2.64328979e-02f, -9.59522575e-02f, -5.74910901e-02f, -2.17460897e-02f,
  -7.25550503e-02f, -1.71399936e-02f, -4.05662134e-02f, 1.15366764e-01f, 1.44937560e-02f, 7.15297908e-02f, 2.58929990e-02f, -1.12796668e-02f, -1.14838639e-02f, 1.01526249e-02f,
  -2.29855254e-03f, 3.15037146e-02f, -5.91824064e-04f, -5.13957068e-02f, 1.50084281e-02f, -2.26721056e-02f, -1.48151759e-02f, 4.40960415e-02f, 4.38205376e-02f, -9.07936394e-02f,
  -2.50862390e-02f, -2.66889241e-02f, -1.09495707e-01f, -2.26757359e-02f, -9.68972221e-03f, -1.08253524e-01f, -3.68994363e-02f, -4.12685238e-02f, 1.95516478e-02f, -7.36255571e-02f,
  7.89291933e-02f, -6.79605221e-03f, 5.98565023e-03f, -1.89303420e-02f, 2.17353664e-02f, -7.58065432e-02f, 1.73434112e-02f, -4.97090593e-02f, 9.67487879e-03f, 7.39297718e-02f,
  1.03666596e-01f, 1.17513523e-01f, 3.23459087e-03f, -4.85694222e-02f, -2.87240297e-02f, -1.27315655e-01f, 1.16161685e-02f, -4.36615236e-02f, 6.07069097e-02f, -3.96127766e-03f,
  -4.17696834e-02f, -1.04246810e-01f, -5.76362386e-02f, 5.51020764e-02f, 8.66473019e-02f, 4.51502427e-02f, 3.23296003e-02f, -2.60787401e-02f, -5.49459904e-02f, -8.32331106e-02f,
  -3.72420922e-02f, 1.03790410e-01f, 1.03125446e-01f, 6.31329939e-02f, 8.58703814e-03f, -1.28197655e-01f, -1.26139387e-01f, -2.45303530e-02f, 2.51387898e-02f, 4.95764539e-02f,
  3.10925454e-01f, 2.14537054e-01f, 1.55200437e-01f, 3.16936195e-01f, 7.80116394e-02f, 1.41622141e-01f, 6.17421418e-02f, 2.55811214e-01f, 5.05231202e-01f, 1.46748992e-02f,
  -1.64235279e-01f, 1.41607225e-01f, -2.78024822e-01f, 1.08474538e-01f, -2.42646206e-02f, -2.26530731e-02f, 1.91800445e-01f, 9.35859457e-02f, 8.31615627e-02f, 5.80289215e-02f,
  9.67911333e-02f, -5.34862578e-02f, -1.48351073e-01f, -2.25074977e-01f, -6.55173976e-03f, -5.80267012e-02f, -4.15394336e-01f, -1.86939806e-01f, 4.65710461e-03f, -1.04890831e-01f,
  -4.93497588e-02f, 2.39739083e-02f, 4.66572419e-02f, 2.87698545e-02f, -4.32514884e-02f, -3.08766011e-02f, 2.91887783e-02f, -5.53143471e-02f, -2.87432410e-02f, 3.72672603e-02f,
  -1.26988916e-02f, 7.37695843e-02f, 1.04180783e-01f, 3.63879763e-02f, 1.62693471e-01f, 1.08165964e-02f, -4.21364866e-02f, 6.89845085e-02f, -3.67810093e-02f, 4.78600860e-02f,
  3.67961191e-02f, 1.26191601e-01f, 7.37128332e-02f, 2.83933934e-02f, -7.66781345e-02f, 6.73153400e-02f, 3.69170271e-02f, -3.38186137e-02f, 7.04635456e-02f, 7.08526000e-04f,
  1.25392014e-02f, -2.16273800e-03f, -2.50185039e-02f, 1.68901216e-02f, 1.82617921e-02f, -6.78337291e-02f, -3.79499458e-02f, -6.32694587e-02f, 7.72448853e-02f, 6.82635903e-02f,
  -9.16470680e-03f, -4.56170150e-04f, 1.22887552e-01f, -2.34220996e-02f, -6.84321206e-03f, 5.11625186e-02f, 7.16317371e-02f, 1.18319914e-01f, 5.24290465e-02f, -5.79537451e-02f,
  -2.20632404e-02f, 3.88893820e-02f, -1.33231848e-01f, -1.56121477e-02f, 2.29410827e-02f, -5.20010851e-02f, 2.88262535e-02f, 1.18085302e-01f, -8.04720446e-02f, -3.09354626e-02f,
  -1.63396716e-01f, -8.96104798e-02f, -3.25547382e-02f, 2.69667059e-02f, 2.08229516e-02f, -8.46150368e-02f, -1.48398811e-02f, 8.71828943e-02f, -6.22944012e-02f, 4.96246181e-02f,
  5.40033206e-02f, 1.90363657e-02f, -6.07160889e-02f, -4.57558632e-02f, 2.43086517e-02f, -1.39354005e-01f, -1.26346014e-02f, 1.89794097e-02f, -1.57765709e-02f, -7.90643273e-04f,
  2.19301730e-02f, 2.73957681e-02f, 7.84111023e-03f, -1.67407710e-02f, 3.95983197e-02f, -1.11743025e-01f, 5.91380931e-02f, -1.99129768e-02f, -7.53979757e-02f, 4.19051088e-02f,
  4.38674361e-01f, -1.50850356e-01f, 1.82835963e-02f, 2.38946602e-01f, 1.73982754e-01f, 2.93109417e-02f, 2.60277819e-02f, 2.26433322e-01f, 3.17237914e-01f, -1.35258079e-01f,
  -1.88150600e-01f, -2.11700313e-02f, -3.18843216e-01f, -5.46655059e-02f, -1.41037414e-02f, -2.47144878e-01f, 4.81850617e-02f, 8.39407928e-03f, 5.82726747e-02f, -4.70924415e-02f,
  1.25833005e-01f, 4.43175919e-02f, 1.00420669e-01f, 2.35736948e-02f, 1.02096468e-01f, 1.82352319e-01f, -1.82970107e-01f, -1.37425601e-01f, 6.72593638e-02f, -4.00321707e-02f,
  -1.58300661e-02f, 4.84187193e-02f, 7.47442245e-02f, 7.48155173e-03f, -2.24375948e-02f, -6.08202070e-02f, -7.13938475e-02f, -7.33143836e-02f, 3.82458381e-02f, 7.06500188e-02f,
  -1.36222634e-02f, 1.08304881e-01f, 1.32406399e-01f, 6.28231093e-02f, 1.23571999e-01f, 2.29238495e-02f, 9.89564732e-02f, -2.89095137e-02f, 7.91597515e-02f, -4.27233391e-02f,
  -4.66441289e-02f, 1.61427390e-02f, 4.73233266e-03f, 3.07190325e-02f, -8.29073563e-02f, 5.12051918e-02f, 7.97755793e-02f, 5.40311597e-02f, -2.72489786e-02f, 8.29017013e-02f,
  -1.25769805e-02f, -1.86929889e-02f, -7.73238316e-02f, 4.88615781e-02f, 3.57698202e-02f, 8.39643031e-02f, 1.97204426e-02f, -7.29683191e-02f, -5.64950742e-02f, -4.84752394e-02f,
  -7.17107952e-03f, 1.65336467e-02f, -1.66089479e-02f, 2.97583677e-02f, 1.39222424e-02f, -1.08873947e-02f, -5.20927869e-02f, -3.94565724e-02f, -6.20887503e-02f, 1.02092430e-01f,
  5.31498045e-02f, -6.61724508e-02f, -6.77137226e-02f, 4.74676117e-02f, -6.21527694e-02f, -7.03876689e-02f, -7.49779865e-03f, -1.88769735e-02f, 3.91831249e-02f, -3.46256234e-02f,
  -3.07208925e-01f, -3.42057258e-01f, -5.68722673e-02f, 3.37460898e-02f, -7.87824988e-02f, -5.82833327e-02f, 5.61320633e-02f, -1.81407854e-02f, -1.82774533e-02f, 4.77970392e-02f,
  -5.03052957e-02f, 4.27172426e-03f, 4.12008986e-02f, 1.25516891e-01f, -9.48521718e-02f, 2.63031553e-02f, -3.04340627e-02f, -1.02839164e-01f, -2.33798567e-02f, 1.61754880e-02f,
  -8.34154934e-02f, 8.28510076e-02f, -3.36815715e-02f, 4.80678827e-02f, 9.34153199e-02f, 2.61432882e-02f, 3.82709987e-02f, 3.44015993e-02f, -3.99561599e-02f, -9.03681740e-02f,
  -6.94827855e-01f, 3.13278645e-01f, 1.26847727e-02f, -2.55176514e-01f, 1.12895947e-02f, 3.00547555e-02f, -6.80683851e-02f, 6.17540218e-02f, -1.97576985e-01f, 2.22204849e-01f,
  2.45480668e-02f, -1.44386366e-01f, 1.20491274e-01f, 1.74480793e-03f, -4.15575147e-01f, -3.56198959e-02f, -1.80158094e-01f, 1.09570526e-01f, -1.91670172e-02f, 5.11009432e-02f,
  -1.99133024e-01f, -1.29434645e-01f, -5.91528490e-02f, 2.01567084e-01f, 8.11346024e-02f, 4.20969948e-02f, -1.37099728e-01f, 8.52126330e-02f, 3.90884578e-02f, -1.72603935e-01f,
  -2.36310601e-01f, -5.28324880e-02f, 8.23005140e-02f, 3.78596932e-02f, -5.54911382e-02f, 4.47491705e-02f, -5.09539135e-02f, -1.73751125e-03f, -3.85756940e-02f, -3.70626673e-02f,
  -3.89505476e-02f, -1.98186375e-03f, -8.06178898e-02f, -1.08448200e-01f, 8.63531306e-02f, 1.48729488e-01f, 7.85025582e-02f, -4.12661694e-02f, 3.84473652e-02f, -5.39382873e-03f,
  1.16979375e-01f, -9.64384805e-03f, -1.45065235e-02f, -9.83819924e-03f, -7.91266933e-02f, 6.62146583e-02f, -8.26599356e-03f, 1.47584714e-02f, -1.77904628e-02f, -9.70837101e-02f,
  -1.59732427e-03f, -1.20718889e-02f, 1.04413196e-01f, -4.18438092e-02f, 6.22423179e-02f, -1.83845982e-02f, -1.40856940e-03f, 2.74394266e-02f, 3.21709849e-02f, 6.46270066e-02f,
  -1.51907340e-01f, 6.93125129e-02f, -4.35508378e-02f, -1.28278166e-01f, -2.61178613e-02f, -1.00406349e-01f, -1.56784859e-02f, 6.58587515e-02f, 4.33516223e-03f, -5.05832210e-02f,
  3.49684129e-03f, -3.27175297e-02f, 3.71536016e-02f, 8.75985101e-02f, -5.40559031e-02f, -4.47051134e-03f, -8.70168209e-02f, -4.97226380e-02f, 7.60196224e-02f, -1.26524404e-01f,
  -3.23200673e-01f, -2.41492689e-01f, -6.01629205e-02f, 2.46847142e-02f, -6.83883065e-03f, 4.34632003e-02f, -1.15793929e-01f, -5.63040860e-02f, -1.52292103e-02f, 1.08053945e-02f,
  8.81285593e-02f, 9.53215640e-03f, -1.08027726e-01f, -1.24987781e-01f, -9.80385244e-02f, -2.99731758e-03f, -7.33209625e-02f, -1.53035492e-01f, 3.56516335e-03f, -9.72038209e-02f,
  1.02871522e-01f, 5.53149655e-02f, -3.06927552e-03f, -3.32195833e-02f, -1.37891874e-01f, -4.63001207e-02f, -3.69959176e-02f, 5.27677760e-02f, -1.04319289e-01f, 1.15025394e-01f,
  2.34933928e-01f, -1.89585790e-01f, -7.76890591e-02f, -9.14795175e-02f, -9.30975825e-02f, -7.16201290e-02f, 1.52621269e-01f, -2.92614460e-01f, 1.98117509e-01f, -1.97068065e-01f,
  -1.80495918e-01f, 2.13009953e-01f, 2.47152716e-01f, -2.73409396e-01f, 5.21986306e-01f, 3.27816904e-01f, -3.83596346e-02f, 9.26822722e-02f, -9.91371423e-02f, -2.14581087e-01f,
  -2.61618532e-02f, -3.12188476e-01f, -1.92038402e-01f, -3.27196777e-01f, -2.23694056e-01f, -2.84309268e-01f, -1.42155215e-01f, -6.97282627e-02f, -2.60643274e-01f, 1.55283120e-02f,
  -4.68520224e-02f, 6.69752955e-02f, -1.15859807e-01f, 2.30598692e-02f, -3.68533917e-02f, 2.23733410e-02f, 1.72126107e-02f, 6.08845018e-02f, 4.39169109e-02f, 8.19756016e-02f,
  8.52264389e-02f, 6.84998482e-02f, -6.69420585e-02f, 1.08993682e-03f, -1.18529968e-01f, -1.27294689e-01f, 2.35112011e-02f, -2.32229922e-02f, -3.05543691e-02f, -8.15276280e-02f,
  -2.00994853e-02f, -3.85476202e-02f, -9.91888344e-03f, 5.41921258e-02f, 8.00228640e-02f, -4.88441288e-02f, 4.77072187e-02f, 1.50562823e-01f, -6.88280910e-02f, -1.26486979e-02f,
  -1.16874464e-01f, 4.28253151e-02f, 1.65147372e-02f, -1.89017534e-01f, 1.33372017e-03f, -5.53149693e-02f, -2.63923500e-02f, -4.57537547e-02f, 1.29051477e-01f, 8.68873764e-03f,
  -4.59178686e-02f, 5.29172271e-02f, -6.24826085e-03f, -1.31763984e-02f, -2.65751462e-02f, 1.27919232e-02f, 6.20275140e-02f, 8.96986201e-03f, 9.91660357e-03f, 4.90451120e-02f,
  -1.57699920e-02f, -2.99114883e-02f, 3.82347777e-02f, -2.98988093e-02f, -1.14270076e-02f, 1.14988387e-01f, -2.58896127e-02f, 5.25320601e-03f, 5.83876297e-02f, 1.46070747e-02f,
  -6.54253736e-03f, -3.16501223e-02f, -8.81869048e-02f, 7.72277042e-02f, 5.97006595e-03f, -3.41168568e-02f, 3.79449204e-02f, 2.54570190e-02f, 5.07230237e-02f, 1.22987218e-02f,
  -1.01054624e-01f, -1.56235248e-02f, -2.55765188e-02f, -1.03304878e-01f, 2.93548461e-02f, -5.17561175e-02f, -1.13763930e-02f, 7.51380473e-02f, -4.94981632e-02f, -1.30999675e-02f,
  7.73932738e-03f, -2.67742649e-02f, 8.95858482e-02f, -1.11262418e-01f, -1.21601328e-01f, 7.86406696e-02f, 1.15612455e-01f, 4.80106212e-02f, 7.46661946e-02f, 5.21300659e-02f,
  3.80995452e-01f, -2.91234076e-01f, -2.71647394e-01f, 1.01814000e-02f, 2.04608247e-01f, 8.15870147e-03f, -1.12648480e-01f, 7.11382702e-02f, -1.32119820e-01f, 1.68963913e-02f,
  7.58001506e-02f, 3.20836529e-03f, -2.75455952e-01f, 3.93455476e-01f, 2.80698568e-01f, -1.57138735e-01f, 3.34315300e-01f, 9.00708959e-02f, -1.94130704e-01f, 3.36873680e-01f,
  2.27425560e-01f, 3.24517965e-01f, -8.81841481e-02f, 6.28402978e-02f, 3.29176694e-01f, -1.61961347e-01f, 2.32582446e-02f, -2.46909320e-01f, 9.01677385e-02f, -2.32243421e-03f,
  9.15538371e-02f, 1.64374843e-01f, 6.98385164e-02f, -8.39875787e-02f, 6.62596598e-02f, 1.16192840e-01f, -7.43980557e-02f, -4.65977639e-02f, -3.00527308e-02f, -1.81900915e-02f,
  4.96358946e-02f, 7.80413821e-02f, 2.28466112e-02f, 4.37956974e-02f, 7.93487802e-02f, 3.86859290e-02f, 6.99822828e-02f, -4.15999349e-03f, -2.10919976e-01f, 3.49008590e-02f,
  -1.16567947e-01f, -3.25170681e-02f, -6.62546381e-02f, -9.60945785e-02f, -4.32387814e-02f, -3.04976609e-02f, -5.71778938e-02f, 3.76506912e-04f, -9.12731215e-02f, 1.95191056e-02f,
  5.83174713e-02f, 9.79559030e-03f, 2.80164671e-03f, -5.41843921e-02f, 8.11471641e-02f, 3.90715413e-02f, -3.12558077e-02f, 3.99084128e-02f, 2.42015086e-02f, 4.81453426e-02f,
  -7.39277378e-02f, -8.38159248e-02f, 8.84500053e-03f, -1.98424738e-02f, 1.15467824e-01f, 7.63397738e-02f, 8.04768503e-03f, 6.12606369e-02f, -8.25267136e-02f, -7.24950656e-02f,
  -3.19516696e-02f, 1.00523662e-02f, -3.72637510e-02f, -3.56770828e-02f, -5.55140199e-04f, 4.86386828e-02f, 6.43444285e-02f, 9.93567556e-02f, -1.23197071e-01f, -9.94972140e-02f,
  1.02769651e-01f, 1.90752372e-01f, -8.05338323e-02f, -2.09131707e-02f, 1.98711958e-02f, 1.53036937e-01f, -3.09240278e-02f, 7.21538812e-03f, -1.09342840e-02f, 5.01252636e-02f,
  1.12750866e-01f, -8.14698115e-02f, 7.30862562e-03f, -3.14222858e-03f, -7.24252537e-02f, -8.11908115e-03f, -5.46733215e-02f, -8.53264779e-02f, -4.08211388e-02f, 5.33135273e-02f,
  -5.63707761e-02f, 3.99425477e-02f, -1.23563278e-02f, 2.93655582e-02f, -1.02352407e-02f, -1.27828624e-02f, -3.38831507e-02f, -9.96755809e-02f, 8.14396665e-02f, -1.02216974e-01f,
  -3.28223884e-01f, -2.45378762e-01f, 1.10675871e-01f, -4.80460197e-01f, 1.49768487e-01f, 3.62271547e-01f, 7.73013383e-02f, 2.48785019e-02f, -2.31078014e-01f, 5.59761701e-03f,
  1.23900324e-01f, -1.18853256e-01f, 2.49682628e-02f, -3.54301304e-01f, -2.44824722e-01f, -3.05800319e-01f, -2.17896909e-01f, -1.01864539e-01f, -1.86874196e-01f, -5.87827861e-02f,
  -1.25852883e-01f, -2.27113739e-01f, -2.49764130e-01f, 1.60881966e-01f, 1.10408582e-01f, 1.25622839e-01f, 1.48664087e-01f, 3.06046844e-01f, 7.52838999e-02f, 8.55507553e-02f,
  -2.15122759e-01f, -1.52791828e-01f, -5.87801822e-02f, 1.10877037e-01f, 1.15602970e-01f, 1.58326566e-01f, 3.87094617e-02f, 3.32950540e-02f, -1.33007830e-02f, -4.00336236e-02f,
  6.76982924e-02f, 9.93376002e-02f, -6.20056093e-02f, -6.27177358e-02f, -5.39829321e-02f, -5.50832180e-03f, -3.46657597e-02f, 4.33074217e-03f, 3.19336057e-02f, 3.34877819e-02f,
  -1.68271378e-01f, 1.36644289e-01f, 5.35606034e-02f, 4.70642671e-02f, -3.14305499e-02f, 3.03553492e-02f, -9.66139063e-02f, 3.58844846e-02f, 4.70411032e-02f, -4.02709804e-02f,
  -3.90350670e-02f, 5.52324206e-02f, 9.13548544e-02f, 3.26650403e-02f, -3.92935537e-02f, 5.73722692e-03f, 2.32905317e-02f, -3.54298316e-02f, 8.28620195e-02f, 3.00001781e-02f,
  2.80748755e-02f, -4.47708666e-02f, -6.15996569e-02f, 5.40665984e-02f, 5.24791293e-02f, -4.09320369e-02f, 1.77584693e-03f, -3.51855010e-02f, 3.34175527e-02f, 3.09796464e-02f,
  -1.92923378e-03f, -3.77544388e-02f, -3.83949205e-02f, 5.03466763e-02f, 1.31801388e-03f, -1.73233054e-03f, -9.62857064e-03f, 1.46327764e-02f, 1.62054133e-02f, 6.31274208e-02f,
  1.26068443e-01f, 1.23828975e-02f, -1.93136893e-02f, -6.46845326e-02f, 1.36808985e-05f, -2.32992154e-02f, -1.39936686e-01f, -4.80472818e-02f, -1.95193756e-02f, -1.69089049e-01f,
  1.06331237e-01f, -1.80832278e-02f, 1.30309567e-01f, -6.71231523e-02f, -3.95887308e-02f, -1.65360719e-02f, 5.18068485e-02f, 5.95275834e-02f, -6.57542348e-02f, 1.96746755e-02f,
  2.57403087e-02f, -4.25930833e-03f, -8.10286496e-04f, 6.80831596e-02f, 6.30128458e-02f, 1.84152618e-01f, -3.51522975e-02f, -6.85295016e-02f, 7.78901353e-02f, 2.82485969e-02f,
  2.51848727e-01f, -1.31949447e-02f, -8.44360236e-03f, 2.85624981e-01f, -3.09429262e-02f, -2.37231389e-01f, -3.37497592e-01f, 2.76591718e-01f, -1.64142232e-02f, -5.59233800e-02f,
  4.76646647e-02f, 4.53284197e-02f, -1.80591166e-01f, 1.92050993e-01f, 2.60382652e-01f, -2.01138139e-01f, 3.16084892e-01f, 1.96152963e-02f, 7.12233707e-02f, 2.49233916e-01f,
  2.60912031e-01f, 1.47753060e-01f, 1.82631359e-01f, 1.14215285e-01f, 1.40101939e-01f, 1.71465248e-01f, 3.04205149e-01f, -8.86257291e-02f, 1.64787173e-01f, -3.48912627e-02f,
  1.53738474e-02f, 8.32174197e-02f, -3.91565040e-02f, 1.17771085e-02f, 6.95114136e-02f, -1.57685071e-01f, 5.91627369e-03f, 4.34068888e-02f, 6.72860891e-02f, -1.70334969e-02f,
  -1.05989520e-02f, 1.06755150e-02f, 5.67187071e-02f, 2.87216119e-02f, -5.94213866e-02f, 1.15994543e-01f, 3.36454734e-02f, 5.54603375e-02f, -7.16106445e-02f, -1.04702979e-01f,
  -1.07018312e-03f, -6.56180643e-03f, 3.44235264e-02f, 7.39002787e-03f, 7.43156895e-02f, 8.03009495e-02f, -7.36650079e-02f, 3.87040451e-02f, -1.09348949e-02f, -4.70945127e-02f,
  9.40828025e-02f, -1.26166180e-01f, -1.54029010e-02f, -4.37071286e-02f, -5.73512837e-02f, -1.13760158e-01f, -1.43933753e-02f, -2.97347493e-02f, -1.33243366e-03f, -1.11894310e-01f,
  3.61911729e-02f, 1.17319658e-01f, 1.60712693e-02f, -4.22155336e-02f, -1.77711295e-03f, -7.95359239e-02f, 1.75425317e-02f, 8.22672322e-02f, -6.29167398e-03f, -1.00148521e-01f,
  -3.90058919e-03f, -3.96591751e-03f, 4.93825674e-02f, 3.17325369e-02f, -4.21552099e-02f, 4.92399596e-02f, 9.27015990e-02f, 1.45283695e-02f, -5.87832741e-02f, 1.88024156e-02f,
  -1.27936685e-02f, -1.38645973e-02f, -6.57390654e-02f, -1.43572791e-02f, -1.05856985e-01f, -7.00052679e-02f, -3.49260569e-02f, 5.02526611e-02f, 8.10163934e-03f, -6.51044920e-02f,
  8.01638067e-02f, -3.48800458e-02f, 3.08376327e-02f, 1.77654084e-02f, -1.48720099e-02f, 5.06901890e-02f, 9.42066237e-02f, -3.71891931e-02f, 3.01988497e-02f, 4.40871753e-02f,
  2.03749463e-02f, -3.78052965e-02f, -5.32612950e-02f, -1.38520012e-02f, 3.32136899e-02f, 2.35152822e-02f, 4.66273166e-02f, -1.29789812e-02f, 7.35877752e-02f, 2.73234639e-02f,
  -2.27914885e-01f, -1.02209598e-01f, -2.58220792e-01f, -7.23868906e-02f, -2.50144958e-01f, -4.42040384e-01f, -1.70602694e-01f, -1.16902970e-01f, 2.23852411e-01f, 3.23727548e-01f,
  2.02132966e-02f, 1.70354068e-01f, 3.52003664e-01f, -1.93347838e-02f, -1.33644551e-01f, 2.34509766e-01f, -1.97745338e-01f, -4.19490077e-02f, 9.60976481e-02f, -1.85846105e-01f,
  -1.01700641e-01f, -1.63971379e-01f, -1.74904391e-01f, -1.29789099e-01f, -3.24623674e-01f, -1.92321595e-02f, -4.35065888e-02f, -1.31368533e-01f, -2.81238019e-01f, -1.82402626e-01f,
  -4.24702428e-02f, 1.63261279e-01f, -1.08445264e-01f, 7.61959888e-03f, -1.30046576e-01f, -1.33156329e-01f, -1.29967749e-01f, 5.34840859e-03f, -6.97200447e-02f, -4.41488437e-02f,
  9.93726999e-02f, 9.74319875e-03f, 5.46598341e-03f, 4.09980677e-02f, 1.51049877e-02f, 5.90239689e-02f, -3.40351020e-03f, -4.67270538e-02f, 2.68111117e-02f, 3.08293686e-03f,
  -1.22483619e-01f, -1.13116719e-01f, -3.93045060e-02f, 5.49779162e-02f, -9.44690704e-02f, -2.06351765e-02f, 2.61892211e-02f, 2.80140969e-03f, -6.53417856e-02f, -4.73834723e-02f,
  -2.53842920e-02f, -7.99544379e-02f, 3.28827463e-02f, 8.05166438e-02f, 3.13045867e-02f, -2.92252600e-02f, -3.65504296e-03f, 3.09864501e-03f, -7.61533007e-02f, -7.42016658e-02f,
  2.65044067e-02f, -8.74813348e-02f, 3.42557952e-02f, -8.25964808e-02f, -3.61013412e-02f, 1.08308092e-01f, 7.19311461e-02f, -5.67679107e-02f, -4.03346345e-02f, -4.87364549e-03f,
  -4.11693268e-02f, -1.24958187e-01f, 3.28109786e-02f, -2.82994173e-02f, 1.83496680e-02f, 1.06117010e-01f, -1.87233910e-02f, 8.16224292e-02f, -3.83784957e-02f, -9.90854353e-02f,
  -1.52119234e-01f, -3.26636247e-02f, 1.24587029e-01f, -6.06625937e-02f, 1.07335284e-01f, -4.52930443e-02f, 8.17321986e-03f, -1.68254897e-02f, -3.62265669e-02f, -8.57107192e-02f,
  -1.02571346e-01f, 9.34976190e-02f, -7.88636133e-02f, 4.92980890e-02f, 8.64371732e-02f, -5.46136647e-02f, 5.41350152e-03f, -2.12689303e-02f, -1.60102040e-01f, 1.01445604e-03f,
  -4.28070351e-02f, 3.74009088e-02f, 6.23911731e-02f, 8.14622268e-02f, -1.77925583e-02f, 2.76778024e-02f, -1.55074475e-02f, 1.50015606e-02f, 2.69949473e-02f, -2.63915043e-02f,
  1.66268855e-01f, 3.64511728e-01f, 1.96897238e-01f, 2.46413067e-01f, -1.08875729e-01f, -1.22247666e-01f, -4.23788428e-02f, -5.96144721e-02f, 1.37814432e-01f, 1.27952427e-01f,
  -1.54697657e-01f, 4.12258953e-01f, -1.65560395e-01f, -1.36174828e-01f, -1.71083882e-01f, -2.35614583e-01f, 5.12123518e-02f, 1.51821390e-01f, -2.49628313e-02f, 2.17985615e-01f,
  6.40682504e-02f, -2.47786552e-01f, -1.01587147e-01f, -1.76081955e-01f, 1.07256640e-02f, 2.07533926e-01f, 8.11375752e-02f, -5.73620424e-02f, 1.34581387e-01f, -5.03698923e-02f,
  -3.77750769e-02f, 5.72630502e-02f, -3.55989113e-02f, 5.64861968e-02f, 6.55475929e-02f, -6.99444767e-03f, 1.43136010e-01f, -3.30399834e-02f, -5.95457964e-02f, 2.50273924e-02f,
  4.54887077e-02f, -2.78183334e-02f, -7.36929402e-02f, -8.82652476e-02f, 5.85425459e-02f, 1.36154339e-01f, 1.48548529e-01f, 1.43787220e-01f, 1.54228536e-02f, -5.71617596e-02f,
  2.25213040e-02f, 7.59934038e-02f, 7.17393681e-02f, 1.83938473e-01f, 8.41566920e-02f, -5.18778004e-02f, 8.90813172e-02f, 1.07070684e-01f, 1.82026759e-01f, 5.70771992e-02f,
  -9.16934852e-03f, -1.46818161e-02f, -1.14859924e-01f, -1.67104632e-01f, -1.74816743e-01f, -1.21255349e-02f, 8.81045908e-02f, 3.32488380e-02f, 1.38845608e-01f, -3.04010231e-02f,
  6.67139590e-02f, -3.76074538e-02f, -6.87683150e-02f, -7.55180642e-02f, -5.19344248e-02f, -2.53473185e-02f, -1.24836741e-02f, -5.68464026e-02f, 1.45746216e-01f, 3.51561308e-02f,
  -1.38924539e-01f, 1.83974598e-02f, 1.57695618e-02f, -4.44703065e-02f, -1.67171225e-01f, -5.55307493e-02f, -1.61003381e-01f, -1.94161455e-03f, -9.74186882e-02f, 1.14980645e-01f,
  1.34224072e-01f, 2.44959012e-01f, 9.38251540e-02f, 3.68229710e-02f, 3.22565362e-02f, -1.31416665e-02f, 3.09859253e-02f, 2.21351217e-02f, 1.14594139e-01f, -7.29218349e-02f,
  7.59651065e-02f, 1.40631362e-03f, 1.18370235e-01f, -5.88081256e-02f, -1.11134447e-01f, 1.73632413e-01f, 5.61188757e-02f, -1.74027197e-02f, 6.21339167e-03f, -1.21971808e-01f,
  7.06402287e-02f, 1.98317971e-02f, 8.68875086e-02f, 1.07187564e-02f, 7.91867375e-02f, 1.57475710e-01f, -8.21332484e-02f, 7.79064521e-02f, 1.31125242e-01f, 9.69433188e-02f,
  -7.60197818e-01f, 3.69594336e-01f, -2.18140498e-01f, -1.08685587e-02f, 2.63916478e-02f, 1.65590689e-01f, 6.35088161e-02f, -1.84540253e-03f, -2.16685236e-01f, 7.84044191e-02f,
  1.16845101e-01f, -2.42821321e-01f, 9.87180602e-03f, 3.44091564e-01f, -2.22490728e-01f, 1.67958394e-01f, 1.05063960e-01f, -3.68653014e-02f, 9.28208791e-03f, -1.37186646e-01f,
  -6.65572584e-02f, 2.87812650e-01f, 1.07953019e-01f, 2.37385735e-01f, -3.09451576e-02f, -1.44503206e-01f, -1.63066745e-01f, -5.17144017e-02f, 2.08656862e-01f, 2.89019123e-02f,
  -2.23426491e-01f, -3.03709567e-01f, -2.50583500e-01f, -1.11638188e-01f, -1.55880362e-01f, -1.23389050e-01f, -9.80454236e-02f, -5.62797375e-02f, -4.75300588e-02f, 3.97835346e-03f,
  -6.25899509e-02f, -4.10545282e-02f, 1.02442704e-01f, 2.30123848e-02f, -1.31109580e-01f, 1.28010497e-03f, 1.29543170e-01f, 9.59109664e-02f, 7.91446865e-02f, 9.86935720e-02f,
  8.29403326e-02f, 3.24509740e-02f, -7.37324059e-02f, 7.47714788e-02f, 1.16803885e-01f, 1.91573408e-02f, -9.53741670e-02f, 8.38395115e-03f, 2.10187882e-02f, -4.33843676e-03f,
  -7.05934241e-02f, -7.03699067e-02f, -1.82307139e-02f, -2.93081757e-02f, 2.56133471e-02f, 9.09777805e-02f, 1.73390415e-02f, -3.80691960e-02f, -1.70600954e-02f, 3.71958911e-02f,
  2.42333189e-02f, -5.20889014e-02f, -2.98185330e-02f, 1.84377711e-02f, 1.69743914e-02f, -8.29577893e-02f, -1.03119612e-02f, -1.99807361e-02f, 1.07317567e-01f, 5.31541109e-02f,
  -7.91575387e-02f, -5.35994247e-02f, 7.87610263e-02f, 4.54373956e-02f, 1.73734762e-02f, -3.58714163e-02f, -5.77027090e-02f, 4.55575250e-02f, -5.84527887e-02f, 1.90986367e-03f,
  -4.44480926e-01f, -3.40664059e-01f, -8.77463818e-02f, -1.02934130e-01f, -1.03834584e-01f, -4.13436024e-03f, 7.94096664e-02f, -5.88592608e-03f, -1.11535110e-01f, -8.09798911e-02f,
  -9.88217816e-02f, -4.34564054e-02f, -4.68794405e-02f, 3.02701835e-02f, -7.04406053e-02f, 5.49704172e-02f, -6.50250837e-02f, -2.20833253e-02f, -3.27546783e-02f, 4.71367799e-02f,
  -4.00296152e-02f, -1.53045421e-02f, -6.91885948e-02f, 4.91028652e-02f, 8.19803998e-02f, -3.43347229e-02f, -3.68711539e-02f, 5.97531721e-02f, 2.54996307e-02f, 1.55176297e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.92064089e-01f, 2.52023727e-01f, 2.68632323e-01f, 1.84563145e-01f, 2.94226725e-02f, 2.81692952e-01f, 3.46660256e-01f, 3.62967849e-01f, 3.17866415e-01f, 3.99837285e-01f,
  3.60573322e-01f, 2.78602809e-01f, 1.65169254e-01f, 3.91059928e-02f, 2.50299007e-01f, 4.33965683e-01f, 3.12083989e-01f, 1.19268754e-02f, 3.70265305e-01f, 3.05790275e-01f,
  3.01682025e-01f, 4.75944996e-01f, 2.54313439e-01f, 1.46331713e-01f, 2.83855945e-01f, 2.39613935e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.09718233e-01f, -8.72212797e-02f, 2.76446879e-01f, 2.92235583e-01f, -1.59389719e-01f, -5.09642512e-02f, -1.07533902e-01f, -4.72759921e-03f, -9.71276462e-02f, 1.78598598e-01f,
  -9.18107554e-02f, -4.18793321e-01f, -2.34404758e-01f, 3.15564662e-01f, -7.57478401e-02f, -5.04840948e-02f, 3.42171311e-01f, 3.02564532e-01f, -4.09221202e-02f, -2.57269710e-01f,
  -2.08239451e-01f, 1.31926954e-01f, 2.03195199e-01f, 8.13355073e-02f, -9.28351283e-02f, 2.07674876e-02f, -1.06925145e-01f, -6.35075057e-03f, -5.20781428e-02f, -2.81417847e-01f,
  8.81297216e-02f, -2.80191121e-03f, 4.52333763e-02f, 1.71734780e-01f, 1.55740619e-01f, 1.88597158e-01f, 1.62221536e-01f, -2.27071196e-02f, -6.37842566e-02f, -1.99369445e-01f,
  9.76982117e-02f, 2.52712280e-01f, -3.06740046e-01f, -2.02979699e-01f, -2.61814356e-01f, 1.81894138e-01f, 1.50834516e-01f, -2.98333261e-02f, -2.53876466e-02f, 3.78425568e-01f,
  -2.42837891e-01f, 5.69453603e-03f, 2.15395421e-01f, 1.30048767e-02f, 2.38551959e-01f, 1.29957378e-01f, -2.11162776e-01f, 2.97068030e-01f, -2.99262434e-01f, -2.45332405e-01f,
  -7.09368959e-02f, 1.82259560e-01f, 2.22854063e-01f, -4.77028370e-01f, -8.02590400e-02f, 1.30082950e-01f, -1.99499071e-01f, -1.82977855e-01f, 2.26735264e-01f, 1.92859128e-01f,
  8.51133168e-02f, 2.52279997e-01f, 1.32142246e-01f, -1.94545224e-01f, -1.90201372e-01f, 3.29184830e-01f, 3.14970374e-01f, -3.35228860e-01f, -2.19199225e-01f, 9.94976014e-02f,
  -4.01338875e-01f, -1.58925220e-01f, -1.21259600e-01f, 2.26430476e-01f, 1.66128069e-01f, 8.26160833e-02f, -2.08385557e-01f, -2.70724267e-01f, -3.24907936e-02f, -7.19794119e-03f,
  2.44474113e-02f, 1.44068092e-01f, 1.25557482e-01f, 1.46136209e-01f, -3.16537917e-03f, -7.35345855e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.01043075e-01f, 1.43570870e-01f, -1.04420945e-01f, -4.76793081e-01f, -1.84295714e-01f, 1.70364723e-01f, 2.00700641e-01f, -7.53631592e-02f, -2.85988361e-01f, 2.99005538e-01f,
  3.36476356e-01f, 4.95362878e-01f, 1.35044813e-01f, 2.23780155e-01f, 3.73876512e-01f, -1.67251766e-01f, -5.74282825e-01f, -4.98560965e-02f, 9.57028940e-03f, 1.31816240e-02f,
  -3.22897732e-01f, -2.98294514e-01f, 7.93624669e-02f, -9.29150209e-02f, 4.12633985e-01f, -3.48748773e-01f, -1.61479846e-01f, 4.56149966e-01f, -1.49699315e-01f, 8.29192773e-02f,
  3.69246483e-01f, 6.76457025e-03f, 2.35287175e-01f, 4.39516604e-02f, 1.09915189e-01f, -5.05896807e-01f, -1.80871740e-01f, 4.96962041e-01f, 2.05309272e-01f, 3.09106886e-01f,
  2.81880442e-02f, 1.13602839e-01f, 3.18883359e-01f, 3.94527674e-01f, 1.02477029e-01f, 1.74064919e-01f, 2.66272187e-01f, 2.03126371e-01f, -8.66590887e-02f, -1.90436095e-01f,
  8.11520442e-02f, 7.46032149e-02f, -2.36755058e-01f, 7.19597116e-02f, -1.11989491e-02f, -9.76579338e-02f, 4.30586219e-01f, -4.11172748e-01f, -5.01420209e-03f, 4.56348628e-01f,
  -1.64635968e-03f, -8.97402614e-02f, 2.39138246e-01f, 5.02749920e-01f, 9.80822071e-02f, -3.83936018e-01f, 4.22443330e-01f, 4.37164754e-01f, -3.64549100e-01f, -4.16139305e-01f,
  2.88770229e-01f, -3.31180207e-02f, -8.64033923e-02f, -2.63223886e-01f, 6.66592037e-03f, -1.51974887e-01f, 2.08713874e-01f, 4.87029552e-01f, -1.48492888e-01f, -5.73793612e-02f,
  5.03453195e-01f, -2.81454980e-01f, 1.28054529e-01f, 1.28537506e-01f, -4.37764257e-01f, 1.87424049e-01f, -3.09302002e-01f, -3.88835311e-01f, 1.62204325e-01f, -1.45780534e-01f,
  1.72204614e-01f, -1.50419995e-01f, 1.26304090e-01f, -5.91028575e-03f, 1.60106774e-02f, 3.58130991e-01f, -7.84850866e-02f, -6.13980144e-02f, -5.44359908e-02f, -2.14347504e-02f,
  2.29159504e-01f, -2.34314024e-01f, 1.34681389e-01f, -3.72737288e-01f, -4.95232157e-02f, -1.88790306e-01f, 3.40381831e-01f, 6.71743751e-02f, 3.07478487e-01f, -1.67901739e-01f,
  3.15264106e-01f, 2.66970605e-01f, 8.11428204e-02f, -1.86205164e-01f, 3.28654885e-01f, 6.93627521e-02f, 1.66137189e-01f, -1.01432316e-01f, 4.97658411e-03f, 2.18613610e-01f,
  -2.23921299e-01f, -2.18152199e-02f, 2.20984682e-01f, 2.50549316e-01f, 3.82659197e-01f, -1.74181331e-02f, -1.20400777e-02f, 7.15148672e-02f, 1.22790568e-01f, 3.70470792e-01f,
  -7.71645159e-02f, -1.89237550e-01f, 8.11360553e-02f, 3.70818168e-01f, 1.27673134e-01f, -1.10773377e-01f, -1.15897551e-01f, 2.29871884e-01f, -1.96015969e-01f, 3.50308836e-01f,
  1.35473832e-01f, 2.25322708e-01f, 3.58170509e-01f, 2.84820437e-01f, 8.11426491e-02f, 9.00589600e-02f, -3.52086067e-01f, 3.57131213e-02f, -2.30419874e-01f, 2.23625109e-01f,
  3.00304025e-01f, 1.08661175e-01f, 4.55413386e-02f, 7.92696401e-02f, -8.94785151e-02f, 2.33375818e-01f, 1.95670813e-01f, 3.68530244e-01f, 4.92058009e-01f, -2.24497095e-01f,
  2.16461882e-01f, 5.33691905e-02f, 3.02654058e-01f, 2.12516680e-01f, -3.70785415e-01f, 3.04593265e-01f, 1.19313456e-01f, 1.16805084e-01f, 1.05575889e-01f, 1.65182725e-01f,
  3.72753203e-01f, -4.29609530e-02f, 7.24134073e-02f, 2.82043010e-01f, 2.43895441e-01f, -1.02145791e-01f, 4.32750463e-01f, 3.81025195e-01f, 3.52525376e-02f, -1.56568229e-01f,
  -3.05874497e-01f, 2.51241565e-01f, 4.23528165e-01f, 3.23336363e-01f, 3.48597258e-01f, 8.12788382e-02f, 1.43257827e-01f, 7.95717537e-02f, -5.05053326e-02f, -7.55188428e-03f,
  1.46796539e-01f, 1.94583461e-01f, -2.07242548e-01f, -4.08071280e-01f, -1.01425998e-01f, -6.89923465e-02f, -9.38778073e-02f, -2.97338575e-01f, 2.05477118e-01f, 3.05601686e-01f,
  2.11060852e-01f, -3.63591537e-02f, -1.54715981e-02f, 3.19773257e-01f, -2.14465000e-02f, 1.27605647e-01f, -1.39682787e-03f, 3.95117812e-02f, 7.83947036e-02f, -3.29472482e-01f,
  -2.95830905e-01f, 4.10694718e-01f, -1.76792264e-01f, 2.16502383e-01f, -2.56025434e-01f, -2.93331474e-01f, 2.90524811e-01f, 1.46233859e-02f, 3.35854471e-01f, -2.66125053e-01f,
  2.01458141e-01f, 4.68331814e-01f, 1.24556541e-01f, 2.95490891e-01f, 1.49374947e-01f, -6.90409914e-02f, -2.55459905e-01f, -1.57799289e-01f, 1.54497921e-01f, -2.81021148e-01f,
  3.35937053e-01f, -2.16681927e-01f, 1.01989239e-01f, 6.59625754e-02f, -2.58716404e-01f, 5.03357463e-02f, 3.03423703e-01f, 7.76983891e-03f, -3.64111550e-02f, 3.03949952e-01f,
  -4.09545191e-02f, 8.40862691e-02f, -3.33436728e-01f, 2.81577617e-01f, -3.19391757e-01f, 2.25677416e-01f, -2.22895909e-02f, -2.41215125e-01f, -2.72851855e-01f, -8.82485509e-02f,
  -7.36402571e-02f, -5.46691477e-01f, 3.64296228e-01f, -6.41847104e-02f, 2.51386911e-01f, -3.16432565e-01f, 3.43226999e-01f, 1.53508782e-01f, 2.17236921e-01f, -4.43167016e-02f,
  1.20198458e-01f, 2.31818601e-01f, -8.55815969e-03f, 3.76400679e-01f, 4.35593784e-01f, 2.14486737e-02f, -3.92363995e-01f, -1.26544997e-01f, -1.11044176e-01f, 3.83192487e-02f,
  -1.93304643e-01f, 1.46208182e-01f, 2.38871962e-01f, 1.87533602e-01f, -2.48854667e-01f, 3.93495038e-02f, 3.14048469e-01f, 4.75203514e-01f, 3.53117466e-01f, 1.41957507e-01f,
  4.06678133e-02f, 4.45364922e-01f, 8.45274515e-03f, 2.91685641e-01f, -9.17700529e-02f, 1.39439866e-01f, 2.35807255e-01f, 1.37358874e-01f, 6.74117822e-03f, 2.05572724e-01f,
  -1.63825184e-01f, -4.12150115e-01f, -2.08606511e-01f, 2.10838765e-01f, 2.94651836e-01f, 3.12602222e-01f, 3.17633092e-01f, -4.12711389e-02f, 3.08426052e-01f, 3.87663931e-01f,
  3.62426192e-01f, -2.95076743e-02f, 7.38051832e-02f, 1.05750285e-01f, -1.54408906e-02f, -1.75402686e-01f, 1.59704372e-01f, 3.54198575e-01f, 1.75472528e-01f, 2.83378541e-01f,
  -2.09867463e-01f, -1.55012950e-01f, 4.13644612e-01f, -8.22588876e-02f, 4.45047140e-01f, 3.33005816e-01f, 1.05538137e-01f, 3.10784727e-01f, -1.91439595e-02f, 4.23617274e-01f,
  2.25187957e-01f, 2.07248226e-01f, -2.20463172e-01f, -1.29982188e-01f, 4.19476599e-01f, -1.92077100e-01f, 1.22151323e-01f, 3.82471710e-01f, 1.70523167e-01f, -5.24435677e-02f,
  3.08177680e-01f, -2.44005844e-02f, 3.31728786e-01f, -1.76475689e-01f, 2.67340511e-01f, 5.11060715e-01f, -7.14003742e-02f, 4.19609547e-02f, 4.38431680e-01f, -1.37500748e-01f,
  4.51500028e-01f, -5.91182485e-02f, 4.68814708e-02f, 1.21063687e-01f, 6.02674671e-02f, 2.00562738e-02f, 3.14509153e-01f, 3.55680346e-01f, 2.30039522e-01f, -3.57863605e-01f,
  -2.29939386e-01f, 2.05584392e-01f, 3.03742945e-01f, 2.08433658e-01f, 1.99995618e-02f, -3.33198279e-01f, 2.18801662e-01f, -9.79986936e-02f, -1.56226188e-01f, -3.75680029e-01f,
  -1.94888547e-01f, 6.84682786e-01f, -3.74453425e-01f, -1.65487364e-01f, -3.68668109e-01f, 5.56715488e-01f, 6.68636739e-01f, 3.80168676e-01f, -2.18280479e-01f, 4.54910636e-01f,
  1.27876669e-01f, -1.56635702e-01f, -2.55712926e-01f, -7.67196953e-01f, 5.76036632e-01f, 4.49492365e-01f, 1.38808358e-02f, 9.40564275e-02f, -9.75415260e-02f, -2.43946388e-01f,
  2.67340064e-01f, 2.06623048e-01f, 4.07896519e-01f, -6.03590310e-02f, -2.82807406e-02f, 2.65496708e-02f, -7.50501826e-02f, 3.34305465e-02f, 3.17065835e-01f, -4.20026332e-01f,
  2.29631826e-01f, -3.94152373e-01f, -1.97301731e-01f, -2.20941395e-01f, 2.87266344e-01f, 1.32016376e-01f, 3.32067281e-01f, -9.38967690e-02f, 1.84570834e-01f, 2.32120484e-01f,
  1.02515608e-01f, -9.87866297e-02f, 4.50819880e-01f, 2.85286736e-02f, 1.50172502e-01f, -7.98304528e-02f, 1.90465182e-01f, 2.44840831e-01f, -2.40256980e-01f, -2.01643854e-02f,
  1.08087771e-01f, -3.16008657e-01f, 4.38055962e-01f, -4.66949105e-01f, -4.97493930e-02f, 1.91314980e-01f, 2.71155030e-01f, 9.02547985e-02f, 1.50500089e-01f, -1.99611858e-02f,
  2.96158820e-01f, -1.04046546e-01f, 9.06368196e-02f, -4.33868736e-01f, -9.58333090e-02f, 3.68068844e-01f, 2.99278378e-01f, 9.85811427e-02f, -2.40119919e-02f, 1.94342792e-01f,
  4.42691833e-01f, 4.33031112e-01f, -1.12357877e-01f, 4.47463572e-01f, 5.42047024e-01f, -6.72012269e-02f, 2.90863728e-03f, -2.22342834e-01f, 4.64734852e-01f, 4.34687883e-01f,
  5.25265187e-02f, -4.53579389e-02f, 1.80418447e-01f, 1.45612106e-01f, 3.31769913e-01f, -1.49840310e-01f, 3.42323214e-01f, -1.39437184e-01f, 1.21991239e-01f, 1.30071297e-01f,
  2.67598391e-01f, 3.49299908e-01f, -1.04238898e-01f, -3.96253407e-01f, 5.15823178e-02f, 4.83747929e-01f, 4.41483736e-01f, -1.24129482e-01f, -5.71345165e-02f, -3.86896878e-02f,
  2.62448788e-01f, -9.72403437e-02f, -3.21666896e-01f, 1.88298643e-01f, 1.94919348e-01f, 4.55733687e-01f, 2.03812763e-01f, 3.01048279e-01f, 4.51622814e-01f, 3.12212050e-01f,
  2.18088374e-01f, 9.10246521e-02f, -1.78656727e-01f, 6.13907695e-01f, 4.13430601e-01f, 3.15614678e-02f, 3.36426884e-01f, 2.56315112e-01f, -1.59679756e-01f, 2.73839146e-01f,
  -3.68581116e-01f, -2.96141624e-01f, -3.56739670e-01f, 9.36238393e-02f, -1.19430520e-01f, 1.56242594e-01f, 1.21569507e-01f, 7.94173032e-02f, -8.56992230e-02f, -1.15185037e-01f,
  2.85973493e-02f, 2.92863995e-01f, -3.48152250e-01f, 1.66402653e-01f, -7.07487687e-02f, -4.60108280e-01f, 1.07196428e-01f, -5.14163971e-01f, -4.11306798e-01f, 1.89934567e-01f,
  -3.73375058e-01f, 7.79893771e-02f, -2.41450459e-01f, -9.40551236e-02f, 3.62105787e-01f, -2.54547119e-01f, 2.02972755e-01f, -4.67004515e-02f, -3.74909759e-01f, 4.38466400e-01f,
  -3.92795652e-02f, 4.60485429e-01f, 3.32892835e-01f, 1.82599217e-01f, 1.18622743e-01f, -2.32734866e-02f, -2.27686495e-01f, -2.27273852e-02f, 3.50491375e-01f, -3.82323563e-03f,
  2.62039989e-01f, 3.40754241e-01f, -2.78057128e-01f, 1.20102428e-01f, 3.75331491e-01f, 4.14930284e-01f, 3.21688592e-01f, 2.88588963e-02f, 1.08540572e-01f, 2.83319363e-03f,
  -3.09971184e-01f, 1.85497925e-01f, -3.23229730e-01f, 1.51179641e-01f, 4.56174254e-01f, -2.66801834e-01f, -1.12409592e-02f, 2.03383327e-01f, -2.52481680e-02f, -1.07934691e-01f,
  3.77517700e-01f, 4.50269222e-01f, 4.52471226e-01f, -3.47847819e-01f, 2.86949188e-01f, 2.99380153e-01f, 3.60042721e-01f, -3.21951471e-02f, -5.05235493e-01f, 4.61662382e-01f,
  3.31713855e-01f, 1.10704623e-01f, 4.90123965e-02f, 1.13978341e-01f, 1.99132171e-02f, 1.66961327e-01f, 2.28443548e-01f, 1.42184630e-01f, 3.14993620e-01f, -7.98014458e-03f,
  1.51757449e-01f, -1.35023877e-01f, -3.52737546e-01f, -2.22121939e-01f, -3.33613098e-01f, 4.02489722e-01f, 1.26681134e-01f, 2.05616187e-03f, 4.62510198e-01f, -1.85629234e-01f,
  -3.31002399e-02f, 1.04711339e-01f, -1.17602106e-02f, 4.29691561e-02f, 3.92203420e-01f, 2.50771791e-01f, 2.38582883e-02f, 2.59652346e-01f, 2.62138546e-01f, 1.20546252e-01f,
  -1.41736865e-01f, 1.81180730e-01f, -1.88820302e-01f, 5.41386306e-01f, 4.39829111e-01f, -1.00462370e-01f, 1.15376543e-02f, 2.96896338e-01f, -1.40093684e-01f, 1.36510372e-01f,
  -3.78838956e-01f, -2.10198551e-01f, 1.67171836e-01f, -1.11663282e-01f, -3.46913576e-01f, 3.20380270e-01f, 4.31183487e-01f, 3.71568769e-01f, -1.87409565e-01f, -1.58346444e-01f,
  2.36976475e-01f, 4.25195843e-01f, -2.56139755e-01f, -1.15095071e-01f, -1.21199884e-01f, 4.99985129e-01f, 7.58026466e-02f, 4.17751849e-01f, -6.93526398e-03f, -9.73295979e-03f,
  4.41567183e-01f, 3.45697373e-01f, 3.59731734e-01f, -5.17436266e-01f, -5.86011522e-02f, 2.96674132e-01f, 2.90915996e-01f, 2.93610334e-01f, -2.00887218e-01f, -2.09638420e-02f,
  1.51362330e-01f, 2.48563737e-01f, 1.66854933e-01f, 3.39833677e-01f, 4.05867487e-01f, 5.40023923e-01f, 7.92847276e-02f, 3.19408625e-01f, 4.08955097e-01f, 1.43167600e-01f,
  2.53980756e-01f, 2.41350695e-01f, -3.00406754e-01f, 5.05589128e-01f, 2.88763613e-01f, 2.10196692e-02f, 4.82872650e-02f, -1.91400051e-02f, 2.63181120e-01f, -2.67788947e-01f,
  6.01685643e-01f, 2.03580946e-01f, 5.58953285e-01f, -8.25998113e-02f, -3.34813744e-01f, 3.88870001e-01f, 1.85660288e-01f, 3.43833655e-01f, 2.90279239e-01f, 9.20507386e-02f,
  -1.90782487e-01f, -1.96016058e-01f, 2.63936728e-01f, 5.66674136e-02f, -1.25366896e-01f, 3.24511491e-02f, 4.36169922e-01f, 3.25608134e-01f, -2.22898230e-01f, -3.49646598e-01f,
  6.23827940e-03f, 4.15427208e-01f, 4.15290475e-01f, -2.34964892e-01f, 3.29933256e-01f, -1.15346424e-01f, 2.74860878e-02f, 1.54026449e-01f, -1.26111373e-01f, -7.73244947e-02f,
  2.77530074e-01f, 2.24629462e-01f, 9.62370634e-02f, 4.39473033e-01f, -1.72568738e-01f, -4.56379056e-01f, 2.49607727e-01f, 1.94264233e-01f, 1.72490299e-01f, 3.66547674e-01f,
  2.17276886e-02f, 6.43978268e-02f, 2.44648293e-01f, 3.75689924e-01f, 5.28867394e-02f, -1.57058373e-01f, 2.59794742e-01f, -3.96141633e-02f, -2.44546399e-01f, 7.31077716e-02f,
  -2.52944287e-02f, 2.11459145e-01f, 5.71492076e-01f, 3.01559214e-02f, -1.09731883e-01f, -1.27701857e-03f, 2.84051776e-01f, 2.54173547e-01f, 8.63841772e-02f, 5.07937670e-01f,
  2.58641541e-01f, 7.88664296e-02f, 1.86752796e-01f, -2.14310661e-01f, 2.36622859e-02f, 2.98585117e-01f, -1.80500209e-01f, -5.07716119e-01f, 1.59400746e-01f, 1.94325373e-01f,
  2.63278961e-01f, 2.23398834e-01f, 3.14725965e-01f, 1.52840734e-01f, -1.31899789e-01f, 4.01744068e-01f, 2.99992800e-01f, -1.51627094e-01f, 1.85696796e-01f, 2.35330656e-01f,
  -1.33924395e-01f, -1.57471180e-01f, -1.87280342e-01f, 2.20115781e-01f, 1.84826329e-01f, 4.92616883e-03f, -1.56743035e-01f, -9.73567292e-02f, 2.55812556e-01f, 8.76982063e-02f,
  -1.80699618e-03f, 3.21610719e-01f, 6.19500503e-02f, 1.37198851e-01f, 1.67651221e-01f, 8.44603404e-02f, 2.45729554e-02f, -8.47523361e-02f, 1.21782184e-01f, 1.19323522e-01f,
  -4.47262824e-01f, -5.47382273e-02f, 4.15151507e-01f, -2.83643045e-02f, 2.90804058e-01f, 1.35028496e-01f, -5.43992501e-03f, 3.13240647e-01f, 7.06096515e-02f, 3.49321753e-01f,
  -1.05678905e-02f, 2.47498732e-02f, 4.29537982e-01f, -1.88725948e-01f, -1.22699179e-01f, 4.08899575e-01f, -2.79318869e-01f, 4.47038829e-01f, -7.10628331e-02f, -1.19705789e-01f,
  3.37103903e-01f, -1.40542835e-01f, 3.63024592e-01f, -2.52659351e-01f, -3.34464759e-02f, 5.35916686e-01f, -1.51916314e-02f, 2.59332269e-01f, 3.74752194e-01f, 1.58380896e-01f,
  3.05872023e-01f, 1.08452700e-01f, 4.98331711e-02f, -2.08213642e-01f, 3.44160348e-01f, 5.71317315e-01f, 4.33116674e-01f, -2.67918296e-02f, -3.36921126e-01f, -5.72866462e-02f,
  3.65377367e-01f, -2.64397860e-01f, -1.52654454e-01f, 2.55331993e-01f, 1.06177360e-01f, 1.69085398e-01f, 5.94979338e-02f, 8.90691066e-04f, 2.29524627e-01f, 1.11252069e-01f,
  -1.57839850e-01f, -1.32781595e-01f, 9.07439068e-02f, 2.56794453e-01f, 3.36142391e-01f, 3.09591979e-01f, 3.60753059e-01f, -1.61710292e-01f, 1.36305079e-01f, 1.99461542e-02f,
  3.16782504e-01f, 8.66460353e-02f, 4.33397681e-01f, 5.74970134e-02f, -1.05068170e-01f, -2.16674760e-01f, 2.21512422e-01f, -2.46023923e-01f, -1.36436716e-01f, 3.69398445e-01f,
  2.95356661e-01f, -1.34902418e-01f, 2.21250415e-01f, 4.27664042e-01f, 4.21676308e-01f, 1.58395037e-01f, 4.49429899e-01f, 1.97778925e-01f, 3.30982119e-01f, -4.40238751e-02f,
  -1.40810043e-01f, 1.80416793e-01f, 4.07755286e-01f, 2.29236722e-01f, -8.81544501e-03f, -8.18241015e-02f, 3.80245924e-01f, 5.90098351e-02f, 2.99407661e-01f, 8.15401599e-02f,
  1.94215298e-01f, 2.74009138e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  9.02884081e-02f, 1.18155524e-01f, 8.82848352e-02f, -6.65814653e-02f, 8.68090838e-02f, 2.86914289e-01f, -5.06323352e-02f, -6.37246645e-04f, 4.00193810e-01f, 8.31989199e-02f,
  3.23714048e-01f, 1.13086447e-01f, 2.34488118e-02f, -3.06423921e-02f, 4.32408631e-01f, -7.26778954e-02f, 6.69676512e-02f, 2.77659804e-01f, 1.68551728e-01f, 3.40924412e-01f,
  2.40215674e-01f, 3.89858156e-01f, 2.47838259e-01f, 5.81373088e-02f, 1.38535053e-01f, 2.18976960e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.20492838e-01f, -1.45607278e-01f, -2.59362347e-02f, -2.80607566e-02f, 2.99202025e-01f, 1.78916097e-01f, -3.98642197e-02f, 7.18292519e-02f, -2.64413446e-01f, 2.14957699e-01f,
  3.64620745e-01f, 1.66247323e-01f, -8.47390369e-02f, -9.42444578e-02f, 2.89986096e-02f, 6.85728621e-03f, -2.09846601e-01f, 4.47167037e-03f, 2.53759348e-03f, -6.26153052e-02f,
  -6.06409162e-02f, 3.42162043e-01f, 1.27083401e-03f, 6.80676848e-02f, 1.87657550e-01f, -2.13042602e-01f, 1.77421309e-02f, 8.97753388e-02f, -5.98292239e-02f, 6.98459372e-02f,
  -1.44319564e-01f, 2.69969646e-02f, -9.66098309e-02f, -6.44645989e-02f, -1.31991217e-02f, 1.94979534e-01f, -3.29316437e-01f, 1.32052869e-01f, -2.25137174e-01f, 1.22721486e-01f,
  1.20954856e-01f, 6.15862757e-02f, -1.63556281e-02f, 1.12202406e-01f, 2.20871940e-01f, 3.28841984e-01f, -2.31592387e-01f, 7.03566745e-02f, -2.33937539e-02f, -3.95030528e-02f,
  3.26294065e-01f, 1.89248174e-02f, 1.86403275e-01f, 1.09087773e-01f, -9.90002900e-02f, 5.78945354e-02f, -5.19162491e-02f, -1.03390642e-01f, 1.58110410e-01f, -3.16368610e-01f,
  -1.87659055e-01f, 2.06735209e-01f, -9.43805128e-02f, -1.37470663e-02f, 8.54004323e-02f, -1.97871387e-01f, 6.10246472e-02f, 1.73708946e-01f, 2.69459963e-01f, -3.25558901e-01f,
  2.61279285e-01f, -5.94968833e-02f, 3.41962516e-01f, -2.05320761e-01f, 1.80041790e-01f, -7.19946921e-02f, 8.67939070e-02f, 1.33261727e-02f, 3.15915942e-02f, -7.82501996e-02f,
  -2.33254597e-01f, 3.23748427e-05f, -1.12387560e-01f, 2.41672426e-01f, -1.10701369e-02f, 3.23276557e-02f, 5.49479909e-02f, -1.84393451e-01f, -1.23110101e-01f, 2.85752773e-01f,
  7.58014321e-02f, -6.91683665e-02f, -2.82322317e-01f, -5.07170558e-02f, -6.21969290e-02f, 3.03473920e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -8.64548758e-02f, 1.23491675e-01f, -3.77660766e-02f, -4.20853883e-01f, -4.08133566e-01f, 3.90298098e-01f, 7.49939531e-02f, 4.94849712e-01f, 1.04431294e-01f, 4.04311210e-01f,
  2.84607355e-02f, -1.00517459e-01f, 1.66429192e-01f, 2.25882888e-01f, -8.26407049e-04f, 4.21642691e-01f, 3.84632528e-01f, -7.10911214e-01f, 2.61785299e-01f, -1.65728778e-01f,
  4.59072702e-02f, 6.55373454e-01f, 5.12992637e-03f, 2.19293386e-01f, 1.36182010e-01f, -1.68508843e-01f, -1.31367296e-01f, 1.75995052e-01f, 2.79476672e-01f, 1.81761980e-01f,
  1.67929977e-01f, -4.54574861e-02f, 1.54225186e-01f, 1.65798753e-01f, 2.96787173e-01f, -4.10097748e-01f, -2.24382788e-01f, 5.20658612e-01f, 2.71121204e-01f, 4.55610067e-01f,
  -2.33454496e-01f, 2.18473282e-02f, 3.07049960e-01f, -2.12246522e-01f, -3.77813205e-02f, 1.31451547e-01f, 2.21674547e-01f, 3.83097440e-01f, 3.30714732e-01f, -1.45212561e-01f,
  -1.64569959e-01f, 1.70971770e-02f, 3.55872437e-02f, -1.94559827e-01f, 8.81860256e-02f, 4.67895381e-02f, 8.25239494e-02f, -1.45366848e-01f, 6.32066652e-02f, 5.53731978e-01f,
  4.31414276e-01f, -1.98227644e-01f, 2.86482215e-01f, -2.12141946e-01f, 9.07147974e-02f, 7.71969482e-02f, -7.90391713e-02f, 3.47311676e-01f, 4.00508463e-01f, -2.71654755e-01f,
  -7.23043442e-01f, -3.45857799e-01f, 2.22546354e-01f, -7.11567998e-02f, 7.91884586e-02f, 7.16165304e-02f, 2.90277421e-01f, 2.57518351e-01f, 4.99246329e-01f, 5.77343516e-02f,
  -7.57258534e-02f, -1.91319510e-01f, -3.01137149e-01f, -6.54100329e-02f, 5.04347861e-01f, -8.76224972e-03f, 1.65338919e-01f, 1.32641047e-01f, 3.46255302e-01f, 4.80037093e-01f,
  1.27918839e-01f, -1.51035562e-01f, 4.12034690e-02f, 2.66743958e-01f, 2.79523104e-01f, 1.87118039e-01f, -3.92736793e-02f, 8.41585919e-02f, 3.52275819e-01f, 2.30185743e-02f,
  4.62172240e-01f, 8.19413811e-02f, -3.69485080e-01f, -3.86735052e-01f, -3.87741178e-01f, -1.52899086e-01f, 2.39185840e-01f, 5.14945798e-02f, 1.81886420e-01f, 4.18502539e-01f,
  3.21727395e-01f, 1.72047988e-02f, -8.82535614e-03f, -5.34314096e-01f, -1.99197289e-02f, -3.27358812e-01f, 2.60508031e-01f, -1.85174450e-01f, 4.58235890e-01f, 3.69687527e-02f,
  3.55669677e-01f, 1.25020877e-01f, 3.44129920e-01f, 2.08575845e-01f, 1.26314238e-01f, -1.11152157e-01f, 3.26069534e-01f, -1.86874911e-01f, 3.27217579e-01f, -9.98555273e-02f,
  3.52368176e-01f, -3.34974408e-01f, -2.29168579e-01f, -1.23131782e-01f, 6.09985888e-02f, 2.83014476e-01f, -2.68235445e-01f, 3.87571156e-01f, 8.06737319e-02f, 2.71789640e-01f,
  -4.65179592e-01f, -5.26389658e-01f, 5.98155372e-02f, 1.08831219e-01f, 4.94876266e-01f, 1.03068817e+00f, 3.56290519e-01f, 4.71754968e-01f, 2.87282281e-02f, -5.64677000e-01f,
  1.06790379e-01f, 1.22215427e-01f, -3.11284095e-01f, 5.82997389e-02f, 2.51764178e-01f, 1.90919340e-01f, 5.99149195e-03f, -2.86965251e-01f, 2.26113155e-01f, 3.45907152e-01f,
  3.50111634e-01f, 2.24024475e-01f, 3.21567833e-01f, -1.90332502e-01f, -1.29044309e-01f, 4.36427385e-01f, -2.14998662e-01f, 2.66826209e-02f, 3.55032459e-02f, -1.36641532e-01f,
  1.19527832e-01f, -6.05362393e-02f, -1.43200800e-01f, 5.79486907e-01f, 3.33536267e-01f, 1.68152004e-01f, -1.50131173e-02f, -7.80173838e-01f, -1.09732278e-01f, -2.83248156e-01f,
  1.07639462e-01f, 3.02830506e-02f, 1.04943272e-02f, 1.77783534e-01f, 1.13799952e-01f, 1.58525348e-01f, 4.13595498e-01f, 1.72604263e-01f, 5.61112203e-02f, 1.28629848e-01f,
  4.89099324e-01f, -7.76111260e-02f, 3.82940024e-02f, 2.08484739e-01f, 5.33423433e-03f, -1.53071448e-01f, -4.45093393e-01f, 1.40292972e-01f, 2.55178839e-01f, -1.52958289e-01f,
  3.02545995e-01f, 5.48432589e-01f, -8.36972445e-02f, 5.66767193e-02f, 8.92095566e-02f, 3.58903348e-01f, -3.36309552e-01f, -5.67679070e-02f, 3.28498244e-01f, 2.66096890e-01f,
  2.67826676e-01f, 2.77965516e-01f, 1.00023858e-01f, -4.31402802e-01f, 9.50872377e-02f, -1.09738812e-01f, -2.08878636e-01f, 2.16780186e-01f, -1.39137104e-01f, 8.97518620e-02f,
  2.02361971e-01f, -8.09012130e-02f, 2.48020142e-01f, 2.73302108e-01f, 2.93393612e-01f, 2.49305293e-01f, 2.67330736e-01f, 9.26105231e-02f, -3.79108340e-02f, -3.54151204e-02f,
  -3.31400961e-01f, -2.81439066e-01f, 1.83580056e-01f, 1.28337458e-01f, -4.94545072e-01f, 7.96324462e-02f, 1.37464115e-02f, -5.70093870e-01f, 6.73134178e-02f, 2.81033486e-01f,
  1.97444469e-01f, 1.15339212e-01f, -1.16879847e-02f, 2.25876383e-02f, 4.96612012e-01f, -2.62579173e-01f, -1.83463693e-01f, -3.23057920e-01f, 1.87846065e-01f, 3.48419160e-01f,
  -1.11135408e-01f, 1.19782761e-01f, 2.37537131e-01f, 4.63631302e-02f, 3.96171987e-01f, 1.49972038e-02f, -2.32836291e-01f, -1.18258692e-01f, -1.91122919e-01f, 1.71602592e-01f,
  5.42313337e-01f, -4.57999974e-01f, 1.14281252e-02f, -1.25806212e-01f, -7.60870501e-02f, 9.05362964e-02f, 1.82205439e-01f, -3.18636820e-02f, -1.44290835e-01f, -3.95707563e-02f,
  2.28176311e-01f, -2.14900970e-01f, -5.90958409e-02f, 1.75816214e+00f, 1.96594015e-01f, 4.33424115e-01f, 1.48357585e-01f, -3.75521153e-01f, 3.04662824e-01f, -1.03409849e-02f,
  -7.48529658e-02f, 3.45354885e-01f, -1.26574457e-01f, 1.60971716e-01f, -1.50603518e-01f, 1.32256418e-01f, -5.84425107e-02f, 4.04946476e-01f, -9.84592214e-02f, 2.38669083e-01f,
  -1.43104315e-01f, -2.80701041e-01f, -1.62008822e-01f, 2.39265770e-01f, 2.23587602e-01f, 2.44323313e-01f, 4.88271952e-01f, -7.54107013e-02f, 1.57141566e-01f, 3.49473685e-01f,
  5.08967102e-01f, -9.69119519e-02f, -3.20371613e-02f, 5.33628106e-01f, -1.91184327e-01f, -1.30336046e-01f, -1.69713840e-01f, -2.03658000e-01f, -5.10534421e-02f, 2.34246165e-01f,
  2.09910199e-01f, 4.31783080e-01f, 1.91166580e-01f, -1.99077994e-01f, 6.29268736e-02f, 1.12346895e-01f, 1.14221163e-01f, 5.78598976e-01f, -7.80685544e-02f, 3.39827865e-01f,
  -3.07726674e-03f, 1.75599437e-02f, 5.51169030e-02f, -5.76406494e-02f, -3.08550298e-01f, 2.86353111e-01f, -2.08564743e-01f, 1.58905521e-01f, 1.56190302e-02f, 1.09852321e-01f,
  -1.90442622e-01f, -2.20581040e-01f, 4.70004320e-01f, 3.39726239e-01f, 2.53987372e-01f, 1.34478450e-01f, 1.33284092e-01f, -3.41228902e-01f, 2.18135417e-01f, -2.28876367e-01f,
  3.83392185e-01f, 4.58050370e-02f, 1.86266676e-01f, -9.98144448e-02f, 2.01856256e-01f, 1.18755631e-01f, 7.72754177e-02f, 1.31415129e-01f, 2.59337991e-01f, 2.71826386e-01f,
  4.06254798e-01f, -1.10717736e-01f, 1.16358764e-01f, 6.59925565e-02f, -2.67336100e-01f, 3.50311249e-01f, 5.45103922e-02f, -8.83258879e-02f, -1.49562970e-01f, -7.79942125e-02f,
  5.49181879e-01f, -1.52624361e-02f, -2.82883104e-02f, 1.40455961e-01f, 3.52791905e-01f, 6.63023353e-01f, -1.58766657e-01f, -2.16955826e-01f, 2.74579544e-02f, 7.41298974e-01f,
  8.34302604e-02f, -8.57673679e-03f, -1.25186406e-02f, -2.48471424e-01f, 4.20742810e-01f, 1.58553436e-01f, 4.13062572e-02f, 3.20238292e-01f, 2.08246931e-01f, -3.48944545e-01f,
  -7.98036680e-02f, 3.19281310e-01f, 2.59020597e-01f, 2.91679829e-01f, -1.41861081e-01f, -6.00509010e-02f, 1.05341740e-01f, -1.96332000e-02f, 5.01667619e-01f, 2.04015747e-01f,
  3.10646474e-01f, 3.15854289e-02f, -5.52753091e-01f, -1.56205460e-01f, 2.87280560e-01f, 1.01428978e-01f, 3.17889266e-02f, 3.38975996e-01f, 1.81116059e-01f, 1.60391569e-01f,
  1.64060414e-01f, 9.72090662e-01f, 8.34998265e-02f, 2.10815504e-01f, 1.22796699e-01f, 2.48426303e-01f, -2.36941259e-02f, -1.90688759e-01f, 1.92032978e-01f, 3.40083629e-01f,
  -1.03690393e-01f, 4.52789754e-01f, 2.35747710e-01f, -2.49244962e-02f, 1.68957949e-01f, -2.87171185e-01f, 2.42928863e-01f, 1.46608308e-01f, 1.68932483e-01f, 8.86355937e-02f,
  9.46458504e-02f, 1.54482901e-01f, 1.25900492e-01f, 4.48940784e-01f, 1.07514504e-02f, -2.57639557e-01f, 1.71572894e-01f, 3.21628094e-01f, -7.32989758e-02f, -4.04166698e-01f,
  2.17496499e-01f, 1.14012137e-01f, -2.08664387e-01f, -1.71412870e-01f, -3.92364025e-01f, -2.41048217e-01f, -1.00122884e-01f, -2.61593349e-02f, 2.13849902e-01f, 6.21588826e-01f,
  1.64209291e-01f, -1.47445828e-01f, 4.79419857e-01f, -9.17989761e-02f, 3.17870647e-01f, 2.49775767e-01f, 2.39131711e-02f, 1.42689839e-01f, 1.12590887e-01f, 1.35439590e-01f,
  2.02914640e-01f, 3.70333403e-01f, 4.52048600e-01f, -3.78376842e-01f, -4.20632213e-01f, -4.41991061e-01f, 1.76911160e-01f, 1.48618355e-01f, -2.76523173e-01f, 3.82537246e-01f,
  9.48390290e-02f, -5.03936470e-01f, 3.50020111e-01f, 3.63252722e-02f, 2.32200306e-02f, -3.90318111e-02f, -5.36031090e-02f, 7.48523325e-03f, 4.22767937e-01f, -1.15567490e-01f,
  1.96781367e-01f, -5.13496026e-02f, 2.72867024e-01f, 5.64004123e-01f, 3.32864076e-01f, 6.92255795e-02f, -2.76745707e-01f, 8.58673602e-02f, 1.93819150e-01f, 4.00171787e-01f,
  2.44904846e-01f, 7.10591152e-02f, 1.29632249e-01f, 4.73083526e-01f, 4.19539094e-01f, -4.02553201e-01f, -2.00788036e-01f, 2.04558782e-02f, 2.84458458e-01f, -2.11723536e-01f,
  3.35425586e-01f, 3.52420747e-01f, -3.64425987e-01f, -1.03083387e-01f, 3.72030824e-01f, -2.60276198e-01f, -2.64985442e-01f, 7.20642865e-01f, -2.25782141e-01f, 3.21014822e-01f,
  1.08042814e-01f, -2.05270816e-02f, 1.90266624e-01f, 3.88541877e-01f, 7.47313127e-02f, 3.03099573e-01f, 4.90106732e-01f, -2.47749150e-01f, -2.34463170e-01f, 1.15807857e-02f,
  6.33022636e-02f, 1.99522704e-01f, 3.22370619e-01f, 9.50500444e-02f, 2.56901652e-01f, 3.12366307e-01f, -3.56976181e-01f, -1.63387194e-01f, -1.36346787e-01f, 2.23278239e-01f,
  1.01359800e-01f, 1.28328791e-02f, -4.74773616e-01f, 2.94256419e-01f, 2.56159186e-01f, -4.24367011e-01f, 1.18143156e-01f, 2.23630339e-01f, 3.02328497e-01f, -1.55018017e-01f,
  6.52355924e-02f, -4.99961153e-02f, 4.22605306e-01f, 4.55319941e-01f, -3.11975747e-01f, -3.59091945e-02f, 3.35772842e-01f, -1.06024528e-02f, 2.76839525e-01f, -2.08574727e-01f,
  -2.64142483e-01f, 2.38145232e-01f, 1.99067920e-01f, 1.40231863e-01f, -2.25963175e-01f, -5.46852536e-02f, 1.48249967e-02f, -3.09606437e-02f, 3.91313076e-01f, 2.66814142e-01f,
  4.93543327e-01f, 3.96236688e-01f, -3.87020171e-01f, -1.86867222e-01f, 4.60681260e-01f, 2.05928236e-01f, 2.89395541e-01f, 5.72993457e-01f, -1.23820655e-01f, 1.43663019e-01f,
  -3.80898297e-01f, 4.41872478e-01f, -2.10999548e-01f, 1.39263362e-01f, -1.96411654e-01f, 3.89686406e-01f, 4.73008037e-01f, 4.12607908e-01f, 1.94941565e-01f, -2.78757393e-01f,
  1.48628965e-01f, 5.78333884e-02f, 2.73874968e-01f, 1.93240985e-01f, 1.81263238e-02f, 1.06767833e-01f, -6.60562068e-02f, 5.92176951e-02f, -4.17731702e-02f, -3.48097435e-03f,
  -1.07750386e-01f, -1.37889594e-01f, -1.54023200e-01f, -1.09935343e-01f, 9.95042473e-02f, 1.53803676e-01f, -5.75121269e-02f, -8.51894170e-02f, -1.78051338e-01f, 1.32364795e-01f,
  -5.49926162e-02f, -1.73222080e-01f, -3.10965031e-02f, -3.00218742e-02f, -6.77422509e-02f, -1.29115134e-01f, 1.56870745e-02f, 1.72301412e-01f, -5.56135066e-02f, 1.17527112e-01f,
  -7.08985627e-02f, -1.01162702e-01f, -1.79016739e-01f, 1.35774538e-01f, 5.03099039e-02f, 4.61137667e-02f, 1.23740800e-01f, -1.11894391e-01f, 7.62163550e-02f, 1.43454343e-01f,
  1.14151537e-02f, -1.74678206e-01f, -1.23782672e-01f, -1.92823276e-01f, 2.07223982e-01f, 2.17692837e-01f, -2.70344079e-01f, 5.05801439e-01f, 2.72142619e-01f, 1.73203051e-01f,
  -4.95880216e-01f, -2.36620739e-01f, -1.05789222e-01f, 3.95707833e-03f, 2.65215635e-01f, 1.37203324e+00f, 4.44309145e-01f, 5.50797105e-01f, -5.09526320e-02f, -4.55488741e-01f,
  2.65457213e-01f, 6.32255003e-02f, -4.17411506e-01f, 2.32783318e-01f, 1.25812914e-03f, 1.18907094e-01f, 3.36298086e-02f, -1.09322779e-01f, -4.32161801e-02f, 4.48597401e-01f,
  4.01990652e-01f, 2.40927771e-01f, 3.72021139e-01f, -1.28539816e-01f, 7.80424550e-02f, 3.96954268e-01f, 3.68343920e-01f, 1.54859573e-01f, -3.40966940e-01f, -3.48106176e-01f,
  1.37077749e-01f, -2.09996440e-02f, -2.48757944e-01f, -5.77018201e-01f, 3.15572470e-01f, 1.12721354e-01f, 4.65342343e-01f, 4.62352782e-01f, -3.51097435e-01f, 4.09824662e-02f,
  -3.50926109e-02f, -2.04658404e-01f, -1.09718122e-01f, 2.06377149e-01f, 6.58812225e-02f, 4.73773517e-02f, 3.00118268e-01f, 4.73166257e-01f, 3.04104596e-01f, -3.23912740e-01f,
  2.06623659e-01f, 5.62248528e-02f, -4.28244680e-01f, -5.86364008e-02f, -3.89537960e-01f, -3.20379406e-01f, -2.06703842e-01f, 7.55620822e-02f, 6.63455248e-01f, 4.17123467e-01f,
  1.52124569e-01f, -1.74873997e-03f, 2.32387573e-01f, -1.57748926e-02f, 5.40309131e-01f, 1.68221265e-01f, -1.01779647e-01f, 4.72736746e-01f, -4.22840714e-02f, 4.63468544e-02f,
  -1.86152272e-02f, 3.10369441e-03f, -1.62147835e-01f, 5.47775805e-01f, 2.60735363e-01f, 1.93605691e-01f, 1.71491489e-01f, -1.77989647e-01f, 3.73807102e-02f, 3.54649812e-01f,
  3.27830046e-01f, 4.49802011e-01f, -6.28753752e-02f, 1.52305260e-01f, -6.36013091e-01f, -2.68362790e-01f, -3.47568244e-01f, 2.20508818e-02f, 5.43294668e-01f, -2.30527118e-01f,
  3.88716012e-02f, -1.83172509e-01f, 1.35018393e-01f, -1.18458539e-01f, 4.10240382e-01f, 6.11622185e-02f, 3.98590505e-01f, 7.27997541e-01f, 2.48738110e-01f, 2.74042666e-01f,
  -4.10165936e-01f, 1.12525749e+00f, -2.02475041e-01f, 4.14369442e-02f, 1.90818310e-01f, 3.54716569e-01f, 3.32810491e-01f, 1.02166094e-01f, 1.23650543e-01f, 6.08851085e-04f,
  -4.31339443e-02f, -3.16630974e-02f, 1.02030247e-01f, 3.42638701e-01f, -7.80847594e-02f, -1.45926058e-01f, 1.49764806e-01f, 1.19147979e-01f, 1.19182453e-01f, -3.51609856e-01f,
  -2.77306318e-01f, 2.58179307e-02f, -5.74767515e-02f, -1.78757429e-01f, -8.56479257e-02f, 3.87442678e-01f, 2.31055439e-01f, -1.49868935e-01f, -2.45263606e-01f, 1.53677613e-01f,
  -6.71026902e-03f, 2.23343641e-01f, 5.36017954e-01f, 5.06410301e-01f, 4.11339432e-01f, 2.72715539e-01f, 4.18736398e-01f, -4.27312434e-01f, 1.94472000e-01f, -1.19497649e-01f,
  -2.58170009e-01f, 3.93949002e-01f, 6.00578710e-02f, 3.01193327e-01f, 3.72864276e-01f, -3.50725025e-01f, 3.55333447e-01f, 3.30845982e-01f, -2.86073595e-01f, -1.43492907e-01f,
  -1.79025069e-01f, 6.39716685e-02f, -4.04379487e-01f, -3.31497863e-02f, 8.77443422e-03f, 1.33780882e-01f, 1.15476921e-01f, 8.20290595e-02f, -5.53237535e-02f, 8.61470401e-03f,
  5.68582177e-01f, 3.03752303e-01f, -7.77869672e-02f, 3.05092543e-01f, 1.56629398e-01f, -3.67587507e-02f, 2.96765506e-01f, -2.71795560e-02f, 1.15566917e-01f, 6.50036335e-01f,
  -1.77528813e-01f, 6.59001805e-03f, 2.29522407e-01f, -2.40934148e-01f, -1.17563233e-01f, -9.57840160e-02f, 1.48466468e-01f, 2.67470390e-01f, -3.02325133e-02f, 4.35670577e-02f,
  6.96518719e-02f, 2.31586039e-01f, 7.49768689e-02f, 5.49970828e-02f, -5.13211429e-01f, -1.06482632e-01f, -6.33199960e-02f, 2.93474972e-01f, 5.97325921e-01f, -1.57440737e-01f,
  5.01327626e-02f, 1.87637776e-01f, 2.78491229e-01f, 2.03799978e-01f, 1.25901848e-01f, 4.18854624e-01f, -5.29554151e-02f, -4.04475987e-01f, 2.24296793e-01f, -8.38593692e-02f,
  -3.00284661e-02f, -1.54756248e-01f, 7.64531121e-02f, 5.09226739e-01f, -1.68261155e-01f, -2.08296582e-01f, 4.90670800e-01f, -2.05001876e-01f, 9.80402529e-02f, 4.55807865e-01f,
  8.29165131e-02f, 1.04214951e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  -5.51038459e-02f, 1.84160814e-01f, 1.53021077e-02f, 2.06146449e-01f, 1.48740590e-01f, 9.34442133e-02f, 5.56601211e-02f, 1.17290489e-01f, -8.43436942e-02f, 1.60748169e-01f,
  -9.91342813e-02f, -9.25107114e-03f, 1.39893606e-01f, 2.22376943e-01f, 1.33033544e-01f, 1.11926287e-01f, 2.46438473e-01f, 7.61624575e-02f, -1.74767092e-01f, 3.75227109e-02f,
  6.81906268e-02f, -5.63990138e-02f, -2.16449484e-01f, 8.25601593e-02f, -6.55166656e-02f, -4.21156399e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  7.81381130e-02f, -2.23988146e-01f, -1.49591118e-01f, 2.29264975e-01f, 1.19225055e-01f, 2.53676306e-02f, 8.89813229e-02f, -4.55185682e-01f, 1.17459722e-01f, -3.72903973e-01f,
  -5.39837301e-01f, -7.44941160e-02f, -3.92872185e-01f, -1.27279699e-01f, -3.83608580e-01f, 2.68168747e-01f, -1.86721936e-01f, 2.15545282e-01f, -6.12414300e-01f, 1.74549043e-01f,
  3.46710421e-02f, 1.82662606e-01f, 2.64289945e-01f, -1.38031602e-01f, 2.21832134e-02f, -4.52671617e-01f, -4.99117404e-01f, 2.28245810e-01f, 1.84514411e-02f, -6.60011888e-01f,
  3.40691417e-01f, 2.24828079e-01f, -2.57366359e-01f, -1.52032003e-01f, 2.25677058e-01f, -2.96626776e-01f, 1.19949371e-01f, 4.30673927e-01f, -2.26706415e-01f, -3.13034981e-01f,
  5.90097383e-02f, -5.53779483e-01f, 3.26717235e-02f, -1.23140020e-02f, 2.34883770e-01f, 3.33758116e-01f, 2.19517294e-02f, 2.46639073e-01f, 5.15080430e-02f, 3.12649071e-01f,
  -5.91911376e-01f, -1.66424230e-01f, 1.28864676e-01f, -3.65826711e-02f, 1.60712928e-01f, -5.05488217e-01f, -6.39548451e-02f, -8.80907550e-02f, -6.30305588e-01f, -1.68772519e-01f,
  -4.90284383e-01f, 3.13851908e-02f, -1.03706270e-01f, 3.46880257e-01f, 1.06682263e-01f, -9.02425721e-02f, -1.22400858e-01f, -1.13816641e-01f, 3.07869136e-01f, -3.96074355e-01f,
  1.57006457e-01f, -4.64726239e-02f, -4.55356091e-01f, -2.95559853e-01f, 3.91473293e-01f, -3.53194475e-01f, 9.03060958e-02f, 9.58786011e-02f, 8.91083181e-02f, -5.08025706e-01f,
  -3.03987339e-02f, -2.53668934e-01f, -1.11145042e-01f, -2.92202860e-01f, -6.03309311e-02f, -4.62089300e-01f, 2.78053910e-01f, -3.57368559e-01f, 6.95134103e-02f, 3.00861239e-01f,
  -2.81844825e-01f, -1.05885893e-01f, -1.22651839e+00f, 2.85723478e-01f, 2.32498005e-01f, -3.64081115e-01f, -1.25880361e-01f, 3.94137166e-02f, -2.82822922e-03f, 6.96461871e-02f,
  2.36473516e-01f, -7.10349828e-02f, 2.82991946e-01f, 8.61421973e-02f, -3.67612869e-01f, -1.23577565e-01f, -4.51086253e-01f, 1.05512902e-01f, -3.54210138e-01f, -2.31785610e-01f,
  -3.35722119e-01f, 1.61377862e-01f, 1.39120772e-01f, -4.79473025e-01f, 1.67954713e-01f, 2.92514302e-02f, -6.41041994e-01f, -4.33894396e-01f, 8.12533945e-02f, 3.40062529e-01f,
  -3.46825980e-02f, -4.54542369e-01f, -1.29549310e-01f, 2.52977610e-01f, 1.82232454e-01f, -3.40282023e-01f, 3.59996498e-01f, -3.58940028e-02f, 8.89124647e-02f, 1.59314439e-01f,
  -1.70227855e-01f, 5.08596972e-02f, 3.15784901e-01f, -4.10048604e-01f, 2.84006968e-02f, 1.94273457e-01f, 1.16307510e-03f, 1.03187710e-01f, 1.02599725e-01f, 3.11045259e-01f,
  -2.39799812e-01f, 3.53273191e-02f, -5.92214942e-01f, 6.05041459e-02f, 2.52054185e-01f, -2.29180843e-01f, -1.76828697e-01f, 3.35652053e-01f, -1.44329980e-01f, 5.48152300e-03f,
  3.10296565e-01f, -1.56559929e-01f, -5.99584449e-03f, -3.92211735e-01f, 2.51265377e-01f, -1.84329152e-01f, -3.84230763e-01f, -1.10941134e-01f, -8.63680765e-02f, 2.54559845e-01f,
  3.69385183e-02f, 2.20868245e-01f, 1.54514939e-01f, 2.06979021e-01f, 5.48019290e-01f, 1.71238407e-01f, -5.49688995e-01f, -4.24500912e-01f, 3.08033496e-01f, 3.55665386e-01f,
  -1.10607535e-01f, 1.30577385e-01f, -3.40324640e-01f, -2.30612412e-01f, 1.81423903e-01f, -1.03228748e-01f, -1.58579826e-01f, 6.32527247e-02f, -1.79670632e-01f, 2.11756214e-01f,
  1.75154075e-01f, 3.58682513e-01f, -5.43119311e-02f, 1.15377963e-01f, 1.13086499e-01f, -1.33514881e-01f, -3.02851617e-01f, -1.47552952e-01f, 2.25834012e-01f, -2.17282042e-01f,
  -6.43921614e-01f, -2.38931216e-02f, 8.13878775e-02f, 2.32084021e-01f, 2.05387771e-02f, -2.97177702e-01f, 4.61193919e-02f, 4.39643145e-01f, -4.28348541e-01f, -3.09304744e-01f,
  1.67681694e-01f, -3.29578012e-01f, 2.61233598e-01f, -3.56001407e-01f, -3.45164537e-02f, 4.95201983e-02f, 2.46124655e-01f, -6.88551605e-01f, -3.57635349e-01f, -1.62140206e-02f,
  2.42499277e-01f, -4.41111326e-01f, 1.80346727e-01f, 3.07544768e-01f, 2.59830803e-02f, -6.04241252e-01f, -9.62286890e-02f, 2.17806116e-01f, -1.02688536e-01f, -7.43797183e-01f,
  -1.37366310e-01f, 7.23099113e-02f, -4.36658293e-01f, -6.34735227e-01f, 8.59596953e-02f, -1.83807477e-01f, -2.98541468e-02f, 2.40301549e-01f, -2.75944442e-01f, -8.27072635e-02f,
  -4.36415970e-02f, 4.05613780e-02f, 3.42182457e-01f, 3.55997950e-01f, -3.83770317e-01f, -9.56318974e-02f, -3.25425684e-01f, 2.37025544e-01f, 1.54768303e-01f, 1.73453599e-01f,
  2.16111675e-01f, -2.92929351e-01f, 3.19173247e-01f, -2.12870076e-01f, -3.07654832e-02f, -5.04040062e-01f, -3.32784772e-01f, -1.88327312e-01f, -1.91723537e-02f, -3.52625370e-01f,
  -2.51178354e-01f, 2.61049300e-01f, 4.11960423e-01f, -6.69010431e-02f, -1.66343600e-02f, -5.30589938e-01f, -5.51013835e-02f, -1.38895705e-01f, 2.34936755e-02f, -2.08382517e-01f,
  9.85964686e-02f, -1.65212944e-01f, 1.82254732e-01f, 1.52393624e-01f, -1.72941059e-01f, -8.99331048e-02f, -5.48725836e-02f, 7.58141875e-02f, 2.02308074e-01f, -2.74837196e-01f,
  -4.19742167e-02f, -1.57152772e-01f, 2.27253497e-01f, 3.21065277e-01f, -3.27684768e-02f, -3.40662479e-01f, -4.42992508e-01f, -3.56243938e-01f, -5.88029981e-01f, 3.23913805e-02f,
  -1.33249000e-01f, 1.59973986e-02f, -4.73482221e-01f, 2.63877902e-02f, 7.45416880e-02f, 2.16385156e-01f, 2.18403973e-02f, 9.02656559e-03f, -5.41872531e-02f, -1.04240991e-01f,
  3.38531494e-01f, -4.17702161e-02f, -4.61609632e-01f, 8.35245028e-02f, -2.59395629e-01f, 8.44357535e-02f, 1.51674032e-01f, 3.11763495e-01f, -1.81935892e-01f, 3.73920679e-01f,
  -7.99030364e-02f, 4.25151795e-01f, -1.93973199e-01f, -3.46111178e-01f, 2.68012676e-02f, -1.25341937e-01f, 2.48186797e-01f, -1.10629603e-01f, 2.31158361e-01f, 2.92269383e-02f,
  2.11444318e-01f, -4.05580878e-01f, -5.70375808e-02f, -3.60580474e-01f, 3.58423740e-01f, -6.63444757e-01f, -5.01373351e-01f, 6.79371208e-02f, -6.67386770e-01f, -6.47002697e-01f,
  -5.84365167e-02f, -2.69647539e-02f, 1.40537769e-01f, 3.96138340e-01f, -1.82512999e-01f, -4.71916109e-01f, 1.52613312e-01f, 3.15411001e-01f, -5.36295474e-01f, -3.85833234e-01f,
  3.09437096e-01f, 1.69161543e-01f, -2.43577547e-02f, -2.76837409e-01f, -3.13765824e-01f, 1.77029312e-01f, -2.80237317e-01f, -4.67112243e-01f, 8.26149136e-02f, 1.21035397e-01f,
  -5.88066995e-01f, -1.81068122e-01f, -2.81090498e-01f, 3.66506875e-02f, -8.35696831e-02f, 1.33031070e-01f, 2.45636016e-01f, 1.69405669e-01f, -5.04695773e-01f, 8.34880695e-02f,
  -3.70281935e-01f, 6.65703565e-02f, 7.52391517e-02f, 6.61576465e-02f, 5.42386174e-02f, 1.75081491e-01f, -3.48190904e-01f, 3.58128875e-01f, -4.92348641e-01f, -8.45190957e-02f,
  -4.15363103e-01f, -3.69438589e-01f, 2.05902100e-01f, -4.18428838e-01f, -2.04942062e-01f, -3.58964860e-01f, 2.90048808e-01f, -7.83629995e-03f, -5.54809034e-01f, -1.65689096e-03f,
  -5.52490987e-02f, 2.22640380e-01f, -2.21695647e-01f, 2.10300758e-01f, -4.78736728e-01f, 3.27108294e-01f, -8.27309191e-02f, 1.11169063e-01f, 2.16747820e-01f, 3.43368277e-02f,
  -4.12992388e-03f, -1.34373158e-01f, -4.32111263e-01f, -1.31416664e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  4.80642468e-02f, 7.62954652e-02f, 1.69752955e-01f, -8.78542662e-03f, -6.68782592e-02f, 1.75355032e-01f, 7.85366818e-02f, -1.75854579e-01f, -7.88983256e-02f, -6.73887357e-02f,
  -3.39500755e-02f, -2.24795137e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    