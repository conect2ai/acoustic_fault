/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.53368202e-02f, -1.52785793e-01f, 1.95455953e-01f, 1.00284778e-01f, -1.56479955e-01f, 1.67793125e-01f, 1.76540926e-01f, -1.66480675e-01f, 1.40367240e-01f, -1.37076437e-01f,
  -1.18238917e-02f, -5.39554693e-02f, 2.12731566e-02f, -4.02642936e-02f, 5.56549542e-02f, 1.59219742e-01f, -1.85869075e-02f, -6.44951011e-04f, 4.20906991e-02f, -4.86796014e-02f,
  1.31202927e-02f, -1.74766600e-01f, 7.21247718e-02f, -2.09518805e-01f, 1.16763473e-03f, 5.83202317e-02f, -1.00563824e-01f, -3.62890474e-02f, 2.30600871e-02f, -6.83790818e-02f,
  -5.89663982e-02f, -1.15312666e-01f, -1.09040295e-03f, -3.61491516e-02f, -3.56257148e-02f, -2.30032541e-02f, 4.68067043e-02f, 2.04743639e-01f, 2.32967902e-02f, 9.03457925e-02f,
  1.26641601e-01f, 4.94403094e-02f, 3.71943116e-02f, 1.17241360e-01f, -8.01717117e-02f, 5.13328984e-02f, 6.60406649e-02f, 4.23700511e-02f, 1.64829865e-02f, 1.72253270e-02f,
  8.99157077e-02f, 6.27955049e-02f, 2.73350440e-02f, 4.47607376e-02f, 9.65168141e-03f, 3.96542326e-02f, 8.33138451e-02f, -1.26049770e-02f, -2.34233178e-02f, -1.33629721e-02f,
  -5.96946590e-02f, -6.71053082e-02f, 3.64622436e-02f, -3.91178876e-02f, 1.13179125e-02f, -3.38238999e-02f, 7.21850526e-03f, -1.45624364e-02f, -2.94737909e-02f, -4.04945686e-02f,
  -1.78034585e-02f, -7.04439133e-02f, -1.40785677e-02f, 3.30123194e-02f, 2.88670510e-02f, 8.34819302e-03f, 5.32526560e-02f, 3.04311346e-02f, 1.99346822e-02f, -2.82213744e-02f,
  -2.27876231e-02f, -2.69678589e-02f, -4.21287157e-02f, 6.45460114e-02f, -5.57047874e-02f, 4.86584008e-03f, 8.58241841e-02f, 7.75447041e-02f, 8.52283239e-02f, 1.20584434e-02f,
  -2.32838631e-01f, -1.66573435e-01f, -8.00252110e-02f, -9.64296535e-02f, 1.14694545e-02f, 6.21381626e-02f, 2.29717065e-02f, -8.71712749e-04f, 9.52087343e-03f, -3.76113616e-02f,
  2.90668774e-02f, -2.48635169e-02f, -1.38333784e-02f, -2.35738792e-02f, 2.26907991e-02f, 4.69124597e-03f, 2.45093629e-02f, 1.49797676e-02f, -1.18686676e-01f, -1.23880312e-01f,
  -5.06532416e-02f, 3.18453205e-03f, -1.65531747e-02f, -1.92994699e-02f, -5.31714968e-02f, -6.10639267e-02f, -6.49546040e-03f, -1.91477500e-02f, -3.15045901e-02f, 1.24946367e-02f,
  4.46868956e-01f, -2.79682279e-01f, -4.22405191e-02f, 4.88567278e-02f, 1.34750158e-01f, -1.70830131e-01f, 2.49015540e-02f, -2.19584964e-02f, -1.61484331e-02f, -1.86515734e-01f,
  -2.82808375e-02f, -1.89076215e-02f, -5.98708652e-02f, -6.41565844e-02f, 1.09845392e-01f, -1.69850007e-01f, 1.06647849e-01f, -1.69670451e-02f, -7.35987723e-02f, 2.09508315e-02f,
  4.51065116e-02f, -3.71340737e-02f, -4.31496613e-02f, -1.12002678e-01f, 1.75628308e-02f, 1.44277113e-02f, 6.74175322e-02f, -4.17423956e-02f, -4.10506204e-02f, -3.81824151e-02f,
  1.73592214e-02f, -1.35271410e-02f, 6.93975464e-02f, -4.39186990e-02f, -4.10031676e-02f, 3.33017297e-02f, 1.75056569e-02f, 2.16202866e-02f, -8.89473502e-03f, -4.44125161e-02f,
  -3.87771912e-02f, -2.80547179e-02f, -6.64109215e-02f, -3.21206376e-02f, -1.00979591e-02f, 2.74993014e-02f, -4.08831909e-02f, 9.47107077e-02f, -8.59829187e-02f, -8.25809911e-02f,
  3.83935533e-02f, -6.13711737e-02f, 1.94862336e-02f, -6.69970140e-02f, 4.84759733e-02f, -4.64871861e-02f, -2.10916046e-02f, -3.05079687e-02f, -1.35942567e-02f, 3.35404649e-02f,
  4.07518484e-02f, -1.81122180e-02f, -1.27598075e-02f, -2.82860883e-02f, 2.15233094e-03f, 1.69120822e-02f, 4.91970554e-02f, -5.26394807e-02f, 4.07070145e-02f, -3.93453334e-03f,
  1.97204854e-02f, -1.08882282e-02f, -3.96879166e-02f, 1.60783231e-02f, 3.38936970e-02f, -2.95638200e-02f, 6.85510114e-02f, -3.28187048e-02f, 3.63950133e-02f, -1.89193264e-02f,
  -4.98762876e-02f, 2.59710997e-02f, 2.58154497e-02f, 2.47675292e-02f, -4.53057773e-02f, 3.45682316e-02f, -4.28910702e-02f, -1.16308657e-02f, -2.95614414e-02f, 4.37353440e-02f,
  -1.13325074e-01f, -1.34024784e-01f, -2.65496783e-03f, 5.52404486e-03f, -4.10122350e-02f, 8.04012343e-02f, -4.29454632e-02f, 2.78036166e-02f, -6.37928024e-02f, -2.59102299e-03f,
  6.52612327e-03f, 3.43997329e-02f, -9.19159781e-03f, 8.26706812e-02f, 1.15390969e-02f, -8.27823430e-02f, -1.68503020e-02f, -3.46157029e-02f, 1.64184943e-02f, -5.83677553e-03f,
  -5.02108522e-02f, 1.41427852e-03f, 1.93961039e-02f, 6.32590009e-03f, 2.32738052e-02f, -5.11088930e-02f, 9.22812298e-02f, -6.73693046e-03f, 1.16210536e-03f, -1.30027682e-02f,
  -3.33075047e-01f, 1.76897049e-01f, -7.92616308e-02f, -1.28323972e-01f, -1.94242212e-03f, -2.80449450e-01f, -1.82175055e-01f, 9.69872773e-02f, -7.16740489e-02f, 1.18718944e-01f,
  -3.72834578e-02f, -5.49662113e-02f, 9.38203484e-02f, -1.25596747e-01f, -1.14033327e-01f, -5.07388115e-02f, -1.50192186e-01f, -6.54607117e-02f, 1.13187740e-02f, 2.15742961e-02f,
  8.45023841e-02f, 4.47928086e-02f, -1.59062725e-02f, 1.92261413e-01f, -5.05417585e-02f, 1.00133076e-01f, 1.31623089e-01f, 1.26444891e-01f, 1.01917924e-03f, -5.30114137e-02f,
  1.87990125e-02f, 4.36838567e-02f, 1.28821535e-02f, -2.55574621e-02f, -5.80502860e-02f, -3.72788124e-02f, -6.81797192e-02f, -6.39289469e-02f, -3.19402292e-02f, -4.93483730e-02f,
  -8.26343969e-02f, 8.49216804e-03f, -3.43101658e-02f, 4.75678779e-02f, -5.10761552e-02f, -8.00756440e-02f, 2.54341797e-03f, -8.38093609e-02f, 6.08555414e-02f, -8.93767104e-02f,
  1.13615906e-02f, -3.19721475e-02f, -7.56389946e-02f, 3.51304486e-02f, 6.91145882e-02f, -9.93619487e-02f, -2.78120153e-02f, -5.19134942e-03f, -5.47896735e-02f, -5.96277602e-03f,
  -7.21184388e-02f, -4.63995226e-02f, 8.52187444e-03f, -3.07579245e-02f, 5.79981990e-02f, -5.45827486e-03f, 1.93573553e-02f, 1.08789634e-02f, -2.52119564e-02f, 3.09246499e-02f,
  6.76643550e-02f, -4.82952259e-02f, 3.96810360e-02f, -3.90060805e-02f, 2.23124139e-02f, -4.31057364e-02f, 2.40748022e-02f, -4.11797985e-02f, -4.48922776e-02f, -6.13165647e-02f,
  -2.26051062e-02f, 2.51253936e-02f, 4.00972851e-02f, 7.79748484e-02f, -2.47677024e-02f, 1.72176100e-02f, 3.06194816e-02f, 4.39562276e-02f, -2.58509237e-02f, 4.33326839e-03f,
  1.16922036e-01f, 1.17699549e-01f, -2.78878249e-02f, 4.28851731e-02f, -3.89055386e-02f, -4.12965529e-02f, -8.97946674e-03f, 1.38898790e-02f, 1.04970336e-01f, -7.12471604e-02f,
  2.69626006e-02f, -1.12104066e-01f, 5.35414480e-02f, -1.50040593e-02f, -1.83481183e-02f, -1.96184702e-02f, -2.14518961e-02f, -4.21012938e-02f, -7.84670785e-02f, -3.56106274e-03f,
  -3.05562131e-02f, -6.88266829e-02f, 4.12123688e-02f, -2.82252934e-02f, -6.37228191e-02f, 4.86910567e-02f, -8.28144886e-03f, 1.28290299e-02f, 3.45913367e-03f, 2.89367884e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.87934357e-01f, 1.31338328e-01f, 1.87712282e-01f, -3.17114681e-01f, 2.76385725e-01f, 9.30352658e-02f, -4.37012315e-02f, 2.29814872e-01f, 1.06541112e-01f, -2.89260298e-01f,
  -1.25280857e-01f, -2.10585132e-01f, 3.35346386e-02f, 1.38929300e-02f, -1.21963084e-01f, 1.37824491e-01f, -1.10370241e-01f, -2.19654009e-01f, 1.34873196e-01f, -1.27030751e-02f,
  5.82771860e-02f, -2.08017975e-03f, 2.79955298e-01f, 2.20085546e-01f, 8.31792429e-02f, 2.76483595e-02f, -2.42901936e-01f, 1.24138243e-01f, -1.94482803e-01f, -1.71589982e-02f,
  5.73342927e-02f, 1.36881202e-01f, 6.70991018e-02f, 1.59085721e-01f, -5.49433939e-02f, -2.31603943e-02f, -8.60522240e-02f, 8.02250206e-02f, 1.26983011e-02f, 8.42414573e-02f,
  -1.24968924e-01f, 6.73701242e-02f, -1.30650222e-01f, 1.02177538e-01f, 1.39064893e-01f, 1.26483753e-01f, 1.84922412e-01f, 6.80233985e-02f, 9.37676653e-02f, 1.13196634e-01f,
  1.41440332e-01f, 1.74307674e-02f, -2.03771871e-02f, -1.17968023e-01f, 1.12748355e-01f, 4.71628010e-02f, -8.56563076e-02f, -1.03106901e-01f, 2.45343018e-02f, -1.64451413e-02f,
  1.05874255e-01f, -4.36515734e-02f, 9.63987410e-02f, -4.76887524e-02f, -1.27518043e-01f, -4.53599580e-02f, -1.20759513e-02f, -1.40593350e-01f, 4.12701070e-02f, -3.89412567e-02f,
  -9.82723162e-02f, 8.88126530e-03f, 1.27598673e-01f, 7.12311640e-02f, -8.25952068e-02f, -3.17062228e-03f, -1.57954730e-02f, -8.51627663e-02f, -4.52848338e-02f, -7.88486525e-02f,
  8.58055521e-03f, -1.13640586e-02f, 1.27803162e-02f, -8.96098837e-03f, 1.02520073e-02f, -1.42424051e-02f, 7.91263804e-02f, 2.12955941e-02f, 2.65887436e-02f, 1.69209354e-02f,
  -1.24700539e-01f, -1.18664123e-01f, 8.23702291e-02f, 1.84515593e-04f, -4.17174809e-02f, 2.80960407e-02f, 1.12425663e-01f, -8.70989710e-02f, -7.11582303e-02f, 1.16434200e-02f,
  2.25621015e-02f, -2.35954262e-02f, -6.08692728e-02f, -6.80030659e-02f, -2.33801454e-02f, -4.87947278e-02f, -1.05569199e-01f, -1.05489545e-01f, -6.94179311e-02f, -9.59158912e-02f,
  -1.81587301e-02f, -6.76671567e-04f, 1.45061705e-02f, 1.90510172e-02f, 1.67778712e-02f, -9.46853310e-02f, -1.14049486e-04f, 1.10221216e-02f, 7.05608428e-02f, -1.87445572e-03f,
  1.03677914e-04f, -1.51667982e-01f, -3.74582887e-01f, -3.56408209e-01f, 2.06500754e-01f, 2.28757650e-01f, -2.29483739e-01f, -5.10549322e-02f, -2.81993926e-01f, 2.26895899e-01f,
  9.51505974e-02f, -3.38884860e-01f, -2.35305876e-01f, -2.52448559e-01f, -4.31547850e-01f, -3.11295837e-01f, -4.14547510e-02f, -7.34768733e-02f, -1.08413845e-01f, 3.45640294e-02f,
  -1.49602160e-01f, 1.58962548e-01f, -3.38341385e-01f, 3.70527148e-01f, 1.67335257e-01f, -1.98162105e-02f, 2.25933313e-01f, 8.72045606e-02f, 2.31646568e-01f, 1.41715199e-01f,
  -2.80472878e-02f, -7.66405091e-02f, -6.50041401e-02f, -5.59971221e-02f, 3.69906649e-02f, 1.00499846e-01f, 9.48033258e-02f, -7.42007606e-03f, -6.89731985e-02f, -7.28042722e-02f,
  8.51135552e-02f, -5.52408472e-02f, -5.39195053e-02f, -8.03200004e-04f, 5.25286533e-02f, -5.32281697e-02f, -2.54914258e-02f, -9.66596454e-02f, -1.41887128e-01f, -1.40079278e-02f,
  -1.96595997e-01f, 4.18506861e-02f, 1.38422917e-03f, -3.20605226e-02f, -1.38905421e-01f, 2.95819622e-02f, -7.25212246e-02f, 6.28217356e-03f, 5.57089075e-02f, -1.36782220e-02f,
  1.17165901e-01f, 9.98308510e-02f, 5.01421578e-02f, -5.98274544e-02f, -9.07984748e-03f, -2.07737256e-02f, -9.16524231e-02f, -3.53702530e-02f, -9.78972614e-02f, -2.49298029e-02f,
  -1.07863955e-02f, -1.74249902e-01f, 2.64224689e-02f, 1.78513434e-02f, 3.61080207e-02f, -1.22610321e-02f, 6.22035339e-02f, 2.87892520e-02f, 1.72478217e-03f, -9.71806645e-02f,
  -7.45871738e-02f, -5.76665923e-02f, -6.13082759e-02f, 1.66287050e-02f, -6.82727769e-02f, -1.39086032e-02f, 1.00996271e-01f, -3.32983434e-02f, 4.92432481e-03f, 4.64308783e-02f,
  1.18074464e-02f, 9.68734324e-02f, -4.15349156e-02f, -9.25356597e-02f, 2.95589119e-03f, 6.87551498e-02f, -7.70350099e-02f, -4.13189344e-02f, -5.40973246e-02f, 3.04092094e-02f,
  4.15429026e-02f, -2.66376249e-02f, 2.08789632e-01f, -1.47682965e-01f, -2.82565728e-02f, 1.41665563e-01f, 2.92056166e-02f, 4.98505197e-02f, 5.77968284e-02f, -1.77266356e-02f,
  1.47117928e-01f, 7.61941224e-02f, 3.46222222e-02f, -6.04084432e-02f, 4.24845964e-02f, 9.20544714e-02f, 7.35390559e-02f, -2.92004570e-02f, 1.39428586e-01f, -4.35498096e-02f,
  -1.98222071e-01f, -3.31901371e-01f, 1.64078847e-01f, -2.62541026e-01f, -5.45598865e-02f, 5.52005470e-02f, 2.23812416e-01f, -4.11122739e-01f, -3.18936408e-01f, -2.69898772e-01f,
  -1.66673854e-01f, 4.60173711e-02f, 3.31567615e-01f, -2.13090971e-01f, 4.71216410e-01f, 1.88984945e-01f, -2.40700349e-01f, -1.87088717e-02f, 9.10828337e-02f, -2.21493468e-01f,
  -9.68226194e-02f, -2.20084697e-01f, 3.48118454e-01f, -3.10222745e-01f, -9.63169262e-02f, -1.57539099e-01f, -2.27396283e-03f, 2.37719789e-01f, -2.41197392e-01f, 1.68619365e-01f,
  -1.56535506e-01f, -1.96000740e-01f, -1.21569328e-01f, -9.50505808e-02f, -7.17195421e-02f, 4.91306186e-02f, 8.12017173e-02f, 3.09553355e-01f, 8.88369456e-02f, 5.31860488e-03f,
  8.14986005e-02f, -2.42235977e-02f, -8.63897651e-02f, 1.03940748e-01f, -1.49746910e-01f, -1.41564175e-01f, -2.19382327e-02f, -1.54608730e-02f, -9.70652550e-02f, 1.75615251e-01f,
  -1.69646349e-02f, -1.33287057e-01f, -4.87441644e-02f, -7.65690356e-02f, 9.00227278e-02f, -1.71941578e-01f, 7.14450330e-02f, 1.69694066e-01f, -9.58546549e-02f, -2.08421201e-02f,
  5.10387979e-02f, 1.41739026e-01f, -9.71608311e-02f, -2.15038657e-02f, -1.91126745e-02f, -5.34595810e-02f, -1.39545416e-02f, 1.83367599e-02f, 3.33641805e-02f, 1.68787017e-02f,
  3.07536293e-02f, -5.86063974e-02f, 1.67533513e-02f, -4.47097495e-02f, -2.61151530e-02f, -9.38832164e-02f, 8.89123753e-02f, -5.02595268e-02f, -5.61494427e-03f, -1.89346529e-03f,
  -6.12665862e-02f, -3.65700088e-02f, 3.57861482e-02f, -6.38458319e-03f, -5.84938265e-02f, -5.15782181e-03f, -3.03139375e-03f, -5.24762785e-03f, 2.69272830e-03f, 8.53504911e-02f,
  -2.12859318e-01f, -3.80226433e-01f, -1.74321830e-02f, -2.01111034e-01f, 9.79542136e-02f, -9.62622389e-02f, -2.92215869e-02f, -6.16360307e-02f, -1.09564416e-01f, -4.14809510e-02f,
  -1.20432951e-01f, 4.49170880e-02f, -5.56680933e-02f, -4.98388079e-04f, 2.03687716e-02f, -3.14324461e-02f, -5.44642657e-02f, -2.14683004e-02f, -6.02014139e-02f, -7.70030096e-02f,
  -3.98112871e-02f, -4.52775881e-02f, 1.26179814e-01f, 2.99302153e-02f, -6.92833140e-02f, 2.65430547e-02f, -9.87040848e-02f, -5.19478470e-02f, 7.01085925e-02f, -5.37703075e-02f,
  -3.22068155e-01f, -4.45119552e-02f, -3.21895540e-01f, -2.59092927e-01f, 1.18050374e-01f, -3.90097260e-01f, -1.60182446e-01f, -1.71700791e-01f, -5.60267940e-02f, 4.96520884e-02f,
  2.17026211e-02f, 1.26639977e-02f, 2.53962159e-01f, -2.05599591e-01f, -2.34110236e-01f, 2.37267330e-01f, -4.64758396e-01f, -2.75627017e-01f, 4.87886071e-02f, -1.83037803e-01f,
  -1.72328562e-01f, -9.20317397e-02f, -2.04779103e-01f, 4.21040989e-02f, -3.74993116e-01f, -1.07563160e-01f, 1.40663952e-01f, 2.41811469e-01f, -1.81464702e-01f, 9.96458158e-02f,
  -2.15815917e-01f, -1.70595199e-01f, -1.17292829e-01f, -6.57344535e-02f, -2.00735122e-01f, -7.12108016e-02f, -1.12503663e-01f, 1.05900198e-01f, 6.04142770e-02f, 4.45928201e-02f,
  4.40849848e-02f, 3.25576542e-03f, -8.82906541e-02f, 3.63840349e-02f, 1.35594020e-02f, 5.25738448e-02f, -5.31603023e-02f, -1.61773920e-01f, -1.03382654e-01f, -1.60508931e-01f,
  -9.27034095e-02f, -1.72597542e-02f, -1.21259868e-01f, -2.46921070e-02f, 7.30578275e-03f, -2.67482474e-02f, -2.20461097e-02f, 6.40481487e-02f, -2.14641377e-01f, -1.41350284e-01f,
  2.12581847e-02f, -2.11681817e-02f, -6.87829107e-02f, 6.25783503e-02f, -1.55813275e-02f, -7.58068189e-02f, -2.83155981e-02f, 1.02175914e-01f, 8.44861716e-02f, 9.29580554e-02f,
  -7.33623207e-02f, -5.96346334e-02f, -5.42557314e-02f, -2.03827880e-02f, 1.65305901e-02f, -1.77302286e-02f, -5.58244660e-02f, -6.96017593e-02f, -8.58649537e-02f, -8.59184936e-02f,
  -8.57937703e-05f, -1.95048172e-02f, 1.37207329e-01f, -3.05539370e-02f, -9.91683803e-04f, 1.36120580e-02f, -7.66545767e-03f, -2.56076660e-02f, 9.50490218e-03f, 5.61292879e-02f,
  -8.05423558e-02f, -1.65573090e-01f, 5.66000529e-02f, 4.49660756e-02f, 1.93431955e-02f, -1.11942567e-01f, 1.54352039e-02f, -5.46609312e-02f, 6.74038753e-02f, -2.54379287e-02f,
  -7.60573447e-02f, -3.78632136e-02f, -7.02778623e-02f, 6.52128160e-02f, 3.11541073e-02f, -1.14286505e-01f, 4.68259603e-02f, 2.60041673e-02f, -8.45307633e-02f, -5.82479648e-02f,
  5.49652651e-02f, 3.02100219e-02f, -7.34799495e-03f, -5.38874231e-02f, -3.97835113e-02f, -4.93104495e-02f, -1.75389904e-03f, 1.35820229e-02f, 2.58861622e-03f, -2.47952528e-03f,
  1.32687703e-01f, 2.27210805e-01f, -3.87329957e-03f, -1.02125444e-02f, -1.66976318e-01f, 7.93657526e-02f, 7.18631595e-02f, -5.56586720e-02f, 3.00704837e-02f, 2.03651145e-01f,
  -8.91519114e-02f, 3.21531415e-01f, -1.42228067e-01f, 1.29443511e-01f, -3.29788536e-01f, -6.72188550e-02f, 9.94223803e-02f, 1.64275423e-01f, -9.06951493e-04f, 1.19585343e-01f,
  -1.17093071e-01f, -1.36429846e-01f, -2.20793322e-01f, -4.95033450e-02f, 1.96580246e-01f, 1.37195989e-01f, -1.92766458e-01f, -1.00466147e-01f, 1.90180227e-01f, 2.83357557e-02f,
  5.30999042e-02f, 2.56276637e-01f, 8.79062340e-02f, 1.20759252e-02f, 6.38868213e-02f, 1.09493598e-01f, 1.35053173e-01f, 8.85502025e-02f, -1.34932980e-01f, 7.84006640e-02f,
  8.96440670e-02f, 4.99890782e-02f, 9.53710824e-02f, -8.74585733e-02f, -1.87480170e-02f, -1.34285446e-02f, 4.89040874e-02f, -4.45219129e-02f, 8.48001540e-02f, 1.32295648e-02f,
  -6.10293914e-03f, 8.33532065e-02f, -7.82482550e-02f, 1.05619125e-01f, -4.69773188e-02f, -1.90676060e-02f, -3.04491213e-03f, 8.34944919e-02f, 1.66153207e-01f, 2.25669239e-02f,
  4.88830134e-02f, 6.01286395e-03f, 2.53858566e-02f, 1.24763499e-03f, -7.33057335e-02f, -5.93946502e-02f, -1.45096574e-02f, -8.69813934e-02f, -8.45182836e-02f, 8.06254521e-02f,
  -7.61952177e-02f, 1.94202568e-02f, -6.82491511e-02f, -3.85982171e-02f, -1.40558500e-02f, 1.32284090e-01f, -8.82473588e-03f, 2.28396803e-02f, 4.33367416e-02f, -4.84109446e-02f,
  3.05705180e-04f, 4.29355800e-02f, -2.22269520e-02f, -2.85038762e-02f, -1.72169860e-02f, -5.28965443e-02f, 5.26651554e-02f, 2.32216809e-02f, 3.17702331e-02f, -2.58864835e-02f,
  5.10402657e-02f, 1.34069160e-01f, 1.13093071e-01f, -1.40597054e-03f, 3.89501229e-02f, 4.62931208e-02f, -7.53114223e-02f, 2.20070198e-01f, 4.86245984e-03f, -5.50103411e-02f,
  2.35248473e-04f, -1.89358275e-02f, 1.73026592e-01f, -8.55590254e-02f, 2.77366266e-02f, 1.01492882e-01f, 2.32771747e-02f, -4.69080955e-02f, -4.08664905e-02f, 7.34768342e-03f,
  -7.13556400e-03f, 8.09934214e-02f, 1.30450323e-01f, -1.25318438e-01f, -5.58442203e-03f, 7.52491355e-02f, 6.26055873e-04f, 4.53080535e-02f, 3.48595828e-02f, 4.76174206e-02f,
  -6.68999791e-01f, 3.27726156e-01f, -1.71627149e-01f, -2.24879101e-01f, -2.84117162e-01f, -1.37071535e-01f, -1.18242308e-01f, -1.91985145e-01f, -5.37943281e-02f, 2.76209146e-01f,
  1.29065946e-01f, -2.10473575e-02f, 2.09481850e-01f, 2.58227766e-01f, -3.35151702e-01f, 3.54984075e-01f, 3.95404473e-02f, -1.99489743e-02f, -4.15574647e-02f, -2.43798301e-01f,
  -1.63683116e-01f, 6.55894727e-02f, 1.98049366e-01f, 1.54959140e-02f, -1.32068425e-01f, -1.35977417e-01f, -7.00460514e-03f, -3.47095467e-02f, 6.44707605e-02f, -1.10308729e-01f,
  -4.38616276e-01f, -3.38967502e-01f, -1.28455967e-01f, -5.49576543e-02f, -1.50230661e-01f, -6.92251846e-02f, -3.50092159e-04f, -9.73630473e-02f, -1.22404806e-01f, -1.47151843e-01f,
  -7.62107745e-02f, -2.01291963e-02f, -7.04570413e-02f, -1.62918624e-02f, -8.33476484e-02f, -2.16661487e-02f, 5.75231463e-02f, 1.97460083e-03f, 9.52078998e-02f, 9.86674875e-02f,
  1.19565874e-01f, -3.37514356e-02f, 8.03870335e-02f, 1.30043000e-01f, 6.50310144e-02f, -4.63296287e-02f, -2.25851554e-02f, 2.30610352e-02f, -2.49370169e-02f, -7.08680674e-02f,
  3.16704288e-02f, 2.31851507e-02f, 3.62996422e-02f, -1.09379269e-01f, 3.48893590e-02f, 3.22400555e-02f, -6.24570772e-02f, -4.44214325e-03f, -6.65165251e-03f, 4.82387766e-02f,
  -5.38656488e-02f, -7.67045422e-03f, -1.30235553e-01f, 7.56574869e-02f, -1.20119182e-02f, -8.73008817e-02f, 5.39691895e-02f, -1.67205408e-02f, -4.56257015e-02f, -5.57020456e-02f,
  1.44615797e-02f, -9.76002738e-02f, 5.92030510e-02f, 7.07504079e-02f, -7.18210042e-02f, 4.98301759e-02f, -3.40976305e-02f, 9.26642939e-02f, 3.33523527e-02f, -1.03834912e-01f,
  -5.76996863e-01f, -4.97896940e-01f, -1.45387128e-02f, -5.89798428e-02f, 5.01430817e-02f, -6.94302619e-02f, -6.61873817e-02f, 1.91978691e-03f, -1.32619873e-01f, -1.26719669e-01f,
  -8.98451507e-02f, 2.89968997e-02f, -6.83103502e-02f, 1.00760721e-01f, 9.08526629e-02f, 4.84068170e-02f, -1.17383771e-01f, 2.49288157e-02f, -1.42817631e-01f, 5.23399152e-02f,
  -4.02619466e-02f, -6.57959208e-02f, 6.92157866e-03f, 7.94020146e-02f, 7.66818374e-02f, -5.58967851e-02f, -9.93664488e-02f, 6.89270720e-02f, -6.62735701e-02f, -1.62678584e-02f,
  -2.74996310e-01f, 2.85119116e-01f, -2.96761364e-01f, 2.07242519e-01f, -2.27434441e-01f, 1.38514310e-01f, 3.47312927e-01f, -3.97015456e-03f, 8.49730521e-02f, 4.99917746e-01f,
  3.24054211e-01f, -3.16051543e-02f, 1.99072197e-01f, 5.25320232e-01f, -1.30801752e-01f, 3.48091394e-01f, 4.32740003e-01f, 3.28458518e-01f, -1.20216176e-01f, 1.52188465e-01f,
  -5.66218272e-02f, 3.67714226e-01f, 1.26271725e-01f, -3.86564098e-02f, 5.65370657e-02f, -1.84477657e-01f, 1.03101566e-01f, -2.45994017e-01f, 2.62971878e-01f, 6.83654025e-02f,
  1.03710309e-01f, 5.93837388e-02f, -1.78692460e-01f, -1.14229344e-01f, -6.79010600e-02f, -5.69523424e-02f, -9.16647241e-02f, -1.05310507e-01f, -1.25396192e-01f, 6.70982227e-02f,
  -1.38498500e-01f, -7.71222785e-02f, -6.18471242e-02f, -5.99839054e-02f, -7.56158009e-02f, -9.00968462e-02f, -2.15298403e-02f, -2.42075883e-02f, -5.04615009e-02f, -1.34064496e-01f,
  4.59117442e-02f, -4.87837195e-02f, -3.89735657e-03f, 9.57722962e-02f, -1.29270092e-01f, 1.07154436e-01f, 2.72277053e-02f, -1.85256719e-03f, 3.86560732e-03f, 5.00900671e-03f,
  -2.54136603e-02f, -2.45170929e-02f, 4.84120473e-02f, -1.98413003e-02f, -9.17139128e-02f, -3.71595994e-02f, 9.47169289e-02f, 4.94526373e-03f, -8.69752094e-02f, 1.18700061e-02f,
  -3.07015656e-03f, -7.18889711e-03f, 7.10661486e-02f, -1.78497471e-02f, 3.82512994e-02f, 2.02284083e-02f, -1.06712908e-01f, -4.32234295e-02f, -1.04074832e-02f, 1.23924669e-02f,
  3.64897698e-02f, -2.58734054e-03f, 4.97535318e-02f, 6.82443976e-02f, -3.67616229e-02f, -8.88570845e-02f, 1.31004274e-01f, 2.30249912e-02f, 4.33128094e-03f, -6.28316626e-02f,
  1.29803956e-01f, 3.27033401e-01f, 1.11207217e-01f, -8.13147798e-03f, -1.94873381e-02f, -8.88086632e-02f, 2.28432063e-02f, 1.13582881e-02f, 1.38529226e-01f, -1.47766192e-02f,
  -8.48405957e-02f, 4.29492667e-02f, -1.69107374e-02f, -1.98180601e-02f, -3.73053327e-02f, 8.56434256e-02f, 1.60493106e-01f, -7.71089410e-03f, 3.85813713e-02f, -1.05121419e-01f,
  1.07983192e-02f, -9.40735545e-03f, -1.41646704e-02f, -5.68088852e-02f, 7.26825818e-02f, 8.36413819e-03f, -4.62032296e-02f, -1.74394056e-01f, -8.06349814e-02f, 9.32053477e-02f,
  7.26957247e-02f, -1.98546335e-01f, -2.51213461e-01f, -1.82015866e-01f, 1.78711815e-03f, -1.15906164e-01f, -1.75425470e-01f, -2.35803694e-01f, -6.67523816e-02f, -1.30213220e-02f,
  -9.46216136e-02f, 4.48294431e-02f, 7.49031231e-02f, -2.48422876e-01f, -6.70832917e-02f, -1.01289771e-01f, -1.27334356e-01f, 3.40426713e-02f, -7.16233104e-02f, -2.27397736e-02f,
  -5.95574733e-03f, -1.82925925e-01f, -1.10927597e-01f, -1.34558350e-01f, -2.41210207e-01f, 8.07739422e-02f, 2.02326581e-01f, -1.01525662e-03f, -2.57166419e-02f, -4.12493013e-02f,
  -2.79169232e-02f, -1.96282655e-01f, -1.23086393e-01f, -7.86607862e-02f, 5.07795848e-02f, 8.29775110e-02f, 3.39893736e-02f, 1.23449951e-01f, -9.75995511e-02f, -2.32388936e-02f,
  -4.16393764e-03f, 1.20802343e-01f, -1.35474771e-01f, 1.05988353e-01f, 1.22618034e-01f, -2.60641910e-02f, -3.80796641e-02f, 6.70729205e-02f, -1.74501136e-01f, -6.30524661e-03f,
  -3.68196741e-02f, 8.26218203e-02f, -4.24101092e-02f, 1.48144603e-01f, 5.56551255e-02f, -4.37598005e-02f, 5.13805076e-02f, 3.38254608e-02f, -9.17669237e-02f, 9.71332425e-04f,
  1.20741323e-01f, -2.57086172e-03f, -6.41820440e-03f, 3.31306197e-02f, -1.37935230e-03f, -1.10122049e-02f, -1.07528776e-01f, -6.50943369e-02f, 3.82029302e-02f, -6.40843511e-02f,
  -6.86358213e-02f, -1.72773767e-02f, -3.05251870e-02f, -1.31130129e-01f, 3.33905965e-02f, -1.03199273e-01f, 8.11223313e-02f, -2.72319019e-02f, 7.62961507e-02f, -4.60855216e-02f,
  -4.65876609e-02f, 7.91226048e-03f, 2.23297197e-02f, 1.99447609e-02f, -8.02755952e-02f, 6.65197223e-02f, -8.49319696e-02f, -1.10431634e-01f, 7.35963276e-03f, 8.66149813e-02f,
  -4.25655618e-02f, -3.54978107e-02f, -5.84047288e-02f, 3.27634416e-03f, -1.46169215e-02f, 5.73744774e-02f, -3.70746036e-03f, -3.64388376e-02f, -7.79259726e-02f, -1.86439395e-01f,
  9.61196050e-02f, 1.60906419e-01f, -3.50212604e-02f, 1.09837696e-01f, 2.67138984e-02f, -1.53327227e-01f, 1.07030593e-01f, 1.53410703e-01f, -4.29506712e-02f, 4.61504981e-02f,
  1.05501339e-01f, 5.78207038e-02f, 9.44100227e-03f, 4.71477695e-02f, 1.09545432e-01f, 6.91734627e-02f, -2.32600723e-03f, 4.00999263e-02f, 1.05751464e-02f, -6.19999075e-04f,
  -4.59109217e-01f, 4.41972874e-02f, -1.67042315e-01f, -4.36545372e-01f, 2.13203534e-01f, -1.93031937e-01f, -1.27187863e-01f, 1.74610049e-01f, -2.37676814e-01f, 2.85324305e-01f,
  1.78782612e-01f, -2.33403683e-01f, 1.50550380e-01f, -3.13273787e-01f, -4.42243695e-01f, -1.88132554e-01f, -2.70600170e-01f, -6.83228076e-02f, -8.82805660e-02f, 4.77598421e-02f,
  -1.76928148e-01f, 5.07805124e-03f, -2.06323102e-01f, 2.00320408e-01f, 4.95325066e-02f, 1.71752080e-01f, 2.55770683e-01f, 2.07453787e-01f, -1.75385140e-02f, -7.14545250e-02f,
  -3.00565995e-02f, 5.20207919e-02f, 8.03880766e-02f, -5.21476977e-02f, 9.45716649e-02f, 7.29334354e-02f, -1.26973344e-02f, -6.03358820e-03f, -7.34594911e-02f, 1.06276460e-02f,
  3.65640558e-02f, -7.44962394e-02f, -9.66463536e-02f, 1.57986060e-02f, -6.85158446e-02f, 9.01513100e-02f, -5.82388043e-02f, 1.23341745e-02f, -6.41274499e-04f, -1.21655867e-01f,
  -6.57134727e-02f, -5.73877394e-02f, -4.85388516e-03f, -5.93539253e-02f, 2.77130306e-02f, 3.80420573e-02f, -8.86050016e-02f, -3.53191681e-02f, 3.16655338e-02f, 1.99838132e-02f,
  3.65006067e-02f, 7.42974207e-02f, 1.79964639e-02f, 3.84536460e-02f, -5.08002676e-02f, 1.15480818e-01f, -3.14712860e-02f, 2.52975766e-02f, 4.87041213e-02f, 6.22785576e-02f,
  4.23683180e-03f, 2.92249266e-02f, -1.09272031e-02f, 1.19393282e-02f, -5.09318970e-02f, 7.34659750e-03f, -2.22593974e-02f, 1.06466733e-01f, -8.51824880e-02f, -9.99128353e-03f,
  1.17251784e-01f, -5.44455927e-03f, -3.68455146e-03f, 8.93473327e-02f, -3.48218679e-02f, 8.15504193e-02f, -6.01090677e-02f, -6.17954060e-02f, 9.30365473e-02f, 3.47482711e-02f,
  1.16323166e-01f, 2.77094156e-01f, 2.66189910e-02f, -3.16395499e-02f, 3.53063829e-02f, -2.45479476e-02f, -8.38933736e-02f, -4.88338899e-03f, -5.71693070e-02f, -1.86539665e-02f,
  1.03989653e-01f, 3.04118712e-02f, 1.10598639e-01f, -1.76736880e-02f, 4.11982611e-02f, 3.29064056e-02f, -2.59601772e-02f, -1.16177164e-01f, 4.34922491e-04f, 7.10605970e-03f,
  6.30163178e-02f, 1.09748375e-02f, -8.18792880e-02f, 9.86393727e-03f, 2.35823672e-02f, 2.96677109e-02f, 3.75457108e-02f, -5.59335649e-02f, -3.43987020e-03f, -1.17530236e-02f,
  5.74794829e-01f, -5.02742589e-01f, 3.32820833e-01f, 4.70291466e-01f, 3.49227130e-01f, 1.52973235e-01f, 1.74765661e-01f, 5.76721430e-02f, 1.92094222e-01f, -2.85022110e-01f,
  -6.66387007e-02f, -5.12721539e-02f, -2.64412224e-01f, 4.20531407e-02f, 2.33906254e-01f, -2.04893887e-01f, -1.85813922e-02f, 3.68037187e-02f, -4.12919186e-02f, 5.58509566e-02f,
  1.37921169e-01f, 4.25213203e-02f, 6.42839670e-02f, -1.16613142e-01f, 1.43394887e-01f, 8.50756764e-02f, -8.73381570e-02f, -6.82644919e-02f, 1.27649605e-01f, 3.84998396e-02f,
  -1.23184510e-01f, 6.86122030e-02f, 1.85865331e-02f, -8.05848166e-02f, -3.22816800e-03f, 4.71405014e-02f, 1.86647773e-02f, 5.77155175e-03f, 6.90953955e-02f, 1.54591622e-02f,
  -1.08039891e-02f, 3.66966985e-02f, 3.94219197e-02f, 4.74385731e-02f, 7.15547055e-02f, 1.25815436e-01f, 1.43476725e-01f, -2.89052576e-02f, 6.18488565e-02f, 8.21032450e-02f,
  8.00759643e-02f, -6.37160940e-03f, 2.02785227e-02f, -3.31693180e-02f, 1.09221777e-02f, 9.37782675e-02f, 1.63366441e-02f, 4.96330485e-03f, 8.82377935e-05f, 6.56062961e-02f,
  -8.03235099e-02f, -7.06950650e-02f, -1.93687063e-02f, 4.10341658e-02f, 1.85929295e-02f, 2.90325079e-02f, 4.23758142e-02f, 2.42330953e-02f, -4.12633158e-02f, 7.31448061e-04f,
  4.86786589e-02f, -5.22521511e-02f, 4.04058807e-02f, -5.11395149e-02f, -5.57252280e-02f, 9.33860987e-02f, -9.38654318e-03f, -2.40142420e-02f, -7.10992515e-02f, 1.02885373e-01f,
  1.77114476e-02f, 4.64573614e-02f, -7.98003972e-02f, 1.47219181e-01f, -3.19977626e-02f, -3.60672362e-02f, -4.37495150e-02f, 9.86294169e-03f, -8.20093229e-03f, -6.15956932e-02f,
  -4.85048413e-01f, -5.24369955e-01f, -9.18739066e-02f, -7.59597644e-02f, -1.32176355e-01f, -1.80483192e-01f, -5.76138087e-02f, -2.91749984e-02f, -7.22496733e-02f, -1.17207523e-02f,
  -1.39782906e-01f, 2.71141343e-02f, -8.00098404e-02f, 6.52744947e-03f, -8.45000967e-02f, -8.90027806e-02f, -4.83374447e-02f, -1.53685898e-01f, -6.53938800e-02f, -1.38100326e-01f,
  1.92260556e-02f, 5.35874069e-02f, 7.94572309e-02f, -2.72603743e-02f, -7.65423775e-02f, 5.03725559e-02f, -4.73451987e-02f, 2.01540757e-02f, -2.32638605e-03f, -3.91639136e-02f,
  1.81715190e-01f, 3.42414945e-01f, 2.36240596e-01f, 1.71163768e-01f, -4.92876954e-02f, -2.33275875e-01f, -1.48139685e-01f, -5.79566620e-02f, -7.88440481e-02f, 2.14028135e-01f,
  -3.06095898e-01f, 3.97171587e-01f, -1.89799979e-01f, -2.25824937e-01f, -4.79905456e-01f, -3.89071018e-01f, -1.65913627e-01f, 5.29072993e-02f, -8.99455696e-02f, 2.86374539e-01f,
  -1.36647731e-01f, -2.86788553e-01f, 7.47428462e-02f, -1.08627183e-02f, 2.93605179e-01f, 3.47306311e-01f, 4.34346832e-02f, 3.95015068e-02f, 3.18611622e-01f, -2.65090197e-01f,
  -1.37876526e-01f, -4.63518687e-02f, -3.27125425e-03f, 8.89814496e-02f, 2.19499059e-02f, 5.33822589e-02f, 8.93891752e-02f, -2.47632172e-02f, 3.86592597e-02f, 4.22213227e-02f,
  9.17263180e-02f, -6.05313703e-02f, 1.38048604e-02f, -9.35865343e-02f, 3.89291421e-02f, -1.68270362e-03f, 1.29720107e-01f, 8.84031504e-02f, -4.67167608e-03f, 4.99082841e-02f,
  1.56591192e-01f, 5.18201664e-02f, 2.41857618e-02f, -4.82739601e-03f, 8.59462656e-04f, -4.71093841e-02f, 6.32736981e-02f, 3.89910825e-02f, 3.04437056e-02f, 2.82174386e-02f,
  -2.76580546e-02f, 1.06090354e-02f, 4.70765494e-02f, -4.51291651e-02f, 3.69946845e-02f, -4.52707410e-02f, -1.31495237e-01f, -1.16340660e-01f, 9.58858803e-03f, 1.58829716e-04f,
  4.63494845e-02f, 5.62524833e-02f, -1.47993445e-01f, 7.87542984e-02f, 5.37305046e-03f, 7.48098791e-02f, 6.77484721e-02f, -7.74692148e-02f, -3.26434560e-02f, -3.11805569e-02f,
  -5.06515652e-02f, -5.70893139e-02f, 9.35069546e-02f, 8.44188556e-02f, -1.97435722e-01f, 7.76385190e-03f, 1.33577595e-02f, 9.78748053e-02f, 3.82469371e-02f, -6.75813258e-02f,
  -9.79037657e-02f, 9.12309159e-03f, 7.55067840e-02f, -7.61937127e-02f, -2.25598160e-02f, -4.62542288e-02f, 1.26022510e-02f, -3.14619988e-02f, 2.25297350e-04f, -4.63434979e-02f,
  8.28404129e-02f, 1.23397693e-01f, -7.93708116e-03f, 2.09789947e-02f, -7.12911189e-02f, 1.19531304e-02f, -9.25112050e-03f, 2.12559979e-02f, 7.65341446e-02f, 7.11702406e-02f,
  1.55526951e-01f, 4.66682725e-02f, -6.44031018e-02f, 8.27183574e-02f, -3.27112600e-02f, 9.19065550e-02f, 3.24379876e-02f, 1.47281379e-01f, -2.56719049e-02f, -2.88013997e-03f,
  9.97253358e-02f, -5.12121171e-02f, -2.92075425e-01f, -1.84076905e-01f, -4.22049910e-01f, -8.28704461e-02f, -7.22986236e-02f, -1.59556046e-01f, 1.26256749e-01f, 2.30261326e-01f,
  6.91234469e-02f, 8.80114958e-02f, 3.03758711e-01f, 9.08913556e-03f, 1.72092244e-01f, 2.20640197e-01f, 1.23392470e-01f, 1.19161882e-01f, -5.91574125e-02f, 4.86895144e-02f,
  -1.09760828e-01f, 2.67871609e-03f, 8.86092894e-03f, -2.05899954e-01f, -3.03353012e-01f, -2.82838613e-01f, 1.00770574e-02f, -2.34793693e-01f, -2.48974368e-01f, -1.33284852e-01f,
  -1.02204755e-01f, -1.23219952e-01f, -1.65813357e-01f, 2.81623378e-02f, -1.06972598e-01f, -2.30340119e-02f, -5.25700338e-02f, -7.25722313e-02f, -8.53969827e-02f, 6.05424633e-03f,
  8.37723762e-02f, -3.89766023e-02f, 9.24908817e-02f, 5.13612665e-02f, 3.24902460e-02f, -1.45703271e-01f, -1.77663080e-02f, -7.47541860e-02f, 6.02456182e-02f, -5.60108572e-02f,
  -9.28804353e-02f, -6.32072166e-02f, -6.73116148e-02f, -4.17549461e-02f, -6.03274815e-02f, -3.40997986e-02f, 2.07058843e-02f, -1.23041280e-01f, -4.84641641e-03f, -8.50769058e-02f,
  5.45964874e-02f, 4.16950369e-03f, -5.62383309e-02f, -4.52800132e-02f, 4.56603477e-03f, -1.12108715e-01f, 5.66961840e-02f, 8.53183940e-02f, 8.67840350e-02f, 1.24365017e-02f,
  -2.81241760e-02f, -1.28798215e-02f, 7.32062310e-02f, -3.54884975e-02f, 3.36416215e-02f, 6.46575391e-02f, 7.62400031e-02f, 2.03628056e-02f, -9.86994244e-03f, -1.55357802e-02f,
  6.37925789e-02f, 3.69182415e-02f, -1.63374431e-02f, -7.39270821e-02f, 2.22197864e-02f, -2.89410315e-02f, -6.21094890e-02f, 2.34264433e-02f, 5.13504222e-02f, -2.80954242e-02f,
  -1.15541436e-01f, -5.76602854e-02f, 7.62655437e-02f, -2.91023608e-02f, -7.18036518e-02f, -1.30043142e-02f, -1.52684292e-02f, -9.83080342e-02f, -1.35976002e-01f, -2.43418533e-02f,
  6.33196235e-02f, 4.05842774e-02f, -5.62343262e-02f, -2.85206970e-05f, 3.09249293e-02f, -1.19512323e-02f, 5.96501976e-02f, -5.32317301e-03f, 5.16802035e-02f, -2.45972183e-02f,
  5.81177548e-02f, 3.94405797e-03f, 8.82052705e-02f, -3.53308208e-02f, -3.50615047e-02f, -4.89513353e-02f, -1.80923920e-02f, -6.36371672e-02f, -1.37294084e-02f, -4.63656075e-02f,
  -4.31332856e-01f, 3.87452632e-01f, 5.45995414e-01f, 8.13601911e-02f, 4.97551151e-02f, 4.36899006e-01f, 3.98910373e-01f, 2.02762887e-01f, 3.05750638e-01f, -5.56127988e-02f,
  -3.38559180e-01f, 3.63612510e-02f, 8.41882229e-02f, -7.04512745e-02f, 1.51638195e-01f, 1.76321283e-01f, 1.94359794e-01f, 1.19159348e-01f, 2.14545339e-01f, -6.95178360e-02f,
  6.42791390e-02f, -2.10049376e-01f, 2.90269527e-04f, -1.21285468e-01f, -1.53798833e-01f, 2.89611090e-02f, -2.67737865e-01f, 7.01081529e-02f, -1.28629208e-01f, 1.93359286e-01f,
  -2.10142896e-01f, -1.95286367e-02f, -2.68503934e-01f, 5.90646686e-03f, -2.78043915e-02f, 5.52632473e-02f, 1.99771151e-02f, -3.92288901e-02f, 1.87255256e-02f, -6.16762489e-02f,
  -3.32934894e-02f, 5.07083908e-03f, -5.93938455e-02f, -8.09480771e-02f, 3.94970626e-02f, 5.23352399e-02f, -8.97115283e-03f, 2.62206420e-02f, -1.57633927e-02f, 7.99023360e-02f,
  4.61125895e-02f, -4.40343395e-02f, 2.45609265e-02f, 1.12822168e-02f, 8.21888596e-02f, 1.19566590e-01f, 1.03751741e-01f, 7.62577951e-02f, -1.46066910e-02f, 7.66488090e-02f,
  9.42073017e-02f, 1.49426386e-01f, -8.14450681e-02f, -4.04577069e-02f, 1.75933298e-02f, -8.62405002e-02f, -6.02288768e-02f, -7.29973242e-02f, 7.85165578e-02f, -9.48158056e-02f,
  -1.42327920e-01f, -1.00310348e-01f, -5.84776960e-02f, 4.16430794e-02f, -5.68754859e-02f, 1.20270560e-02f, -2.75046155e-02f, -3.80750187e-02f, 6.62968829e-02f, -2.12448463e-02f,
  1.37786549e-02f, -3.22843483e-03f, -6.59615993e-02f, 5.92117244e-03f, 7.85998031e-02f, -2.08334662e-02f, -1.27824396e-01f, 5.33103682e-02f, 2.18612012e-02f, -2.90817674e-02f,
  -2.66217720e-02f, 8.08078274e-02f, -9.08878669e-02f, -5.97392768e-02f, -5.60714342e-02f, -3.03085763e-02f, 1.87319983e-02f, -9.39485617e-03f, 1.57756045e-01f, -4.94106784e-02f,
  2.60854531e-02f, -3.25505957e-02f, 1.08702816e-02f, 1.84837077e-02f, 1.22594483e-01f, 6.86157495e-02f, -2.03426126e-02f, 5.62985241e-02f, -2.82555516e-03f, 7.88375065e-02f,
  -1.29098117e-01f, -8.90647396e-02f, -6.28556609e-02f, -6.64335862e-02f, -3.35833542e-02f, -3.72027792e-02f, -2.53121741e-02f, 1.92543585e-02f, -1.34099722e-02f, 8.08371007e-02f,
  8.84327665e-02f, 1.81901574e-01f, 5.34513630e-02f, 2.79223531e-01f, 1.38666183e-01f, 6.52429163e-02f, -1.22915149e-01f, 3.11419487e-01f, 1.48156881e-01f, -2.04018250e-01f,
  2.51113355e-01f, 3.86613747e-03f, -2.43642926e-01f, 4.71193045e-01f, 3.58836889e-01f, -1.16759405e-01f, 2.93986440e-01f, 1.36222646e-01f, 1.03623018e-01f, 2.55668372e-01f,
  2.74794012e-01f, 3.01834196e-01f, 2.05901861e-01f, 1.54983491e-01f, 1.81217771e-02f, 4.34743911e-02f, -4.29982096e-02f, -2.12092623e-01f, 2.09983736e-01f, -5.01635969e-02f,
  -8.08099508e-02f, 4.20221575e-02f, -9.31352600e-02f, -1.23644650e-01f, 9.14095938e-02f, -4.09624889e-04f, -1.84357554e-01f, -1.05652578e-01f, 2.90872660e-02f, 4.52913009e-02f,
  -8.58394206e-02f, 2.12506168e-02f, 1.37394473e-01f, -1.03024594e-01f, 6.15594313e-02f, 3.56284268e-02f, 4.35744002e-02f, -2.05357559e-02f, 5.09377643e-02f, 1.54025480e-01f,
  9.21149924e-02f, 2.56354902e-02f, 1.05777150e-03f, 2.66780555e-02f, 3.31262164e-02f, 9.15392190e-02f, -7.36069232e-02f, 2.44094711e-02f, 2.18941513e-02f, 1.05343029e-01f,
  -3.96881299e-03f, -1.48924321e-01f, -1.03316838e-02f, -6.57679141e-02f, 1.26951188e-01f, 1.44679546e-01f, 3.25319916e-02f, -6.07062653e-02f, 1.53878694e-02f, 1.06484629e-01f,
  2.41356473e-02f, 1.41163440e-02f, 6.71309233e-02f, 2.20709406e-02f, -4.13575815e-03f, 1.05720893e-01f, -3.66386734e-02f, 6.71202987e-02f, -5.72044291e-02f, 6.07874542e-02f,
  -9.64398980e-02f, 3.81722115e-02f, -2.46542748e-02f, -1.15447380e-01f, 2.08023135e-02f, -1.91441532e-02f, 7.07957661e-03f, -2.31119199e-03f, 1.80658866e-02f, -7.85183720e-03f,
  7.40792230e-02f, 1.40634090e-01f, 3.37122055e-03f, -1.17191829e-01f, 6.26467243e-02f, 1.62461743e-01f, -9.63093266e-02f, 7.33479634e-02f, -5.57962656e-02f, -1.93280950e-02f,
  2.60009225e-02f, -7.94186741e-02f, -1.32317347e-02f, 1.75507050e-02f, -7.26564508e-03f, 6.95851864e-03f, -4.29624580e-02f, -2.55789459e-02f, -3.11548840e-02f, 1.26023799e-01f,
  -1.20070940e-02f, 8.73702019e-02f, 4.30276804e-02f, 9.96479690e-02f, 2.39044130e-02f, -3.43655758e-02f, 4.93052304e-02f, -9.24434140e-02f, 3.71196754e-02f, 3.20472158e-02f,
  -7.84537569e-02f, -3.00666690e-01f, -3.33926201e-01f, -2.32464194e-01f, -7.05348104e-02f, -1.51475474e-01f, -8.77582058e-02f, -1.44543141e-01f, -2.53897667e-01f, 8.43768101e-03f,
  -1.72982946e-01f, -1.91659853e-01f, 8.71406198e-02f, -2.34836549e-01f, -8.43363404e-02f, 1.15659304e-01f, -2.06907034e-01f, -1.17736951e-01f, 4.84410860e-03f, -5.69783263e-02f,
  -1.76080689e-01f, -1.00827307e-01f, -1.38371199e-01f, -6.40432611e-02f, -1.00152150e-01f, -8.10189918e-02f, 2.86636680e-01f, -3.03685516e-02f, -4.90584858e-02f, -1.78472102e-01f,
  -8.57162252e-02f, 5.69387153e-03f, -3.69168445e-02f, -7.84805343e-02f, -4.79203314e-02f, 7.21071064e-02f, 1.43746987e-01f, -7.08278120e-02f, 2.65851105e-03f, -5.72301401e-03f,
  1.48008749e-01f, -1.50915096e-02f, -6.25191852e-02f, -3.82286794e-02f, -6.45102859e-02f, -1.39138117e-01f, -1.61497835e-02f, 5.52296173e-03f, 7.80309066e-02f, 3.74073833e-02f,
  -1.32314429e-01f, 8.87561440e-02f, 1.07492637e-02f, 1.50812969e-01f, -7.86922798e-02f, -8.60764682e-02f, 8.79351199e-02f, 1.55307427e-01f, 1.35057762e-01f, -6.73715919e-02f,
  5.09029180e-02f, 1.45271033e-01f, -1.17030405e-01f, -4.12939042e-02f, -9.12890658e-02f, 1.07043490e-01f, 1.25107050e-01f, -2.84686475e-03f, -5.92146851e-02f, -8.12646821e-02f,
  2.08859611e-02f, -7.17977108e-03f, 5.14588915e-02f, 3.12661752e-03f, 1.03006788e-01f, 1.40416816e-01f, -1.50973238e-02f, -9.31027755e-02f, -7.86726829e-03f, -5.02183894e-03f,
  7.67834261e-02f, -1.06811365e-02f, -8.17662627e-02f, 1.79506764e-01f, -6.42741174e-02f, -1.03934251e-01f, -5.02262935e-02f, 6.23706058e-02f, -2.83320397e-02f, 1.59895152e-01f,
  8.03532824e-02f, -5.35086840e-02f, -1.22848049e-01f, -4.20595855e-02f, 5.58415316e-02f, 6.68778084e-03f, -1.59930661e-02f, -1.24648318e-01f, -2.41921321e-02f, 9.74229127e-02f,
  2.33482253e-02f, 2.85124760e-02f, 5.43832481e-02f, -1.15977548e-01f, 5.12291417e-02f, -7.79093951e-02f, 1.20594956e-01f, -7.95539692e-02f, 4.72820923e-02f, 6.84115291e-03f,
  1.89716127e-02f, 1.06725179e-01f, 1.07950963e-01f, 1.89022422e-02f, 1.00702625e-02f, 1.45384207e-01f, 4.53362428e-02f, 7.28944838e-02f, 2.16093868e-01f, 7.41545781e-02f,
  3.21005546e-02f, -1.88011490e-02f, -1.28867850e-01f, 5.73446974e-02f, -2.05463931e-01f, 5.48365712e-03f, -2.15546060e-02f, -1.52620524e-01f, 3.57876420e-01f, -7.55985305e-02f,
  -2.17310578e-01f, 1.82371780e-01f, 2.14233592e-01f, -3.11579019e-01f, 4.09467369e-01f, 2.81149268e-01f, -5.88226803e-02f, -2.16211211e-02f, 8.56976807e-02f, -6.64239330e-03f,
  1.27075210e-01f, -2.09993362e-01f, -2.51086652e-01f, -3.74593318e-01f, -2.61627376e-01f, -2.42132157e-01f, -1.99674979e-01f, -1.25899851e-01f, -4.42000479e-01f, -5.66756465e-02f,
  1.72588006e-02f, 5.62472977e-02f, -7.08798238e-04f, 6.45042211e-02f, 5.37179783e-02f, -9.35975313e-02f, -1.05390195e-02f, -5.71990013e-02f, 1.03972204e-01f, 1.10237241e-01f,
  1.11942127e-01f, 2.82600969e-02f, -2.14278493e-02f, -1.02579415e-01f, -8.98410603e-02f, -2.50499472e-02f, -7.82775655e-02f, -2.40105391e-02f, -2.75407359e-02f, -1.26148015e-01f,
  4.06452864e-02f, -1.25102373e-02f, 1.21295424e-02f, -1.86775113e-03f, 3.40527929e-02f, 2.84513328e-02f, -2.65502036e-02f, 6.15510233e-02f, 2.11748970e-03f, 7.62371495e-02f,
  -4.77351174e-02f, 8.38638097e-02f, -9.22629051e-03f, -3.48437056e-02f, -4.97564673e-02f, -2.10438687e-02f, -5.62648624e-02f, -8.55957642e-02f, 6.75552115e-02f, -5.27167730e-02f,
  8.81968159e-03f, -2.94169448e-02f, -7.00466633e-02f, 6.83566332e-02f, 4.85706609e-03f, 4.47415709e-02f, 2.06679758e-03f, -8.45875591e-02f, 2.89441515e-02f, 3.23494971e-02f,
  -5.74684180e-02f, 1.01954766e-01f, -1.45928366e-02f, -4.65790220e-02f, -1.01545028e-01f, 3.51474471e-02f, 1.52474327e-03f, -8.73206556e-02f, 1.21936239e-01f, 1.71848774e-01f,
  8.40379149e-02f, 1.01672173e-01f, 8.29930082e-02f, -4.26372327e-03f, 4.88002449e-02f, -3.74354944e-02f, -1.39273412e-03f, 3.02632935e-02f, 1.62204519e-01f, 4.06543957e-03f,
  -7.45726600e-02f, 1.02169737e-01f, 1.83055550e-02f, -7.77468756e-02f, 3.21597569e-02f, -2.78129391e-02f, 9.87706855e-02f, 3.06955222e-02f, 7.72836283e-02f, -2.95508420e-04f,
  4.91213873e-02f, 1.27681687e-01f, 1.54045090e-01f, -2.98980009e-02f, -3.82322297e-02f, -2.58910824e-02f, 1.72270052e-02f, 4.31514867e-02f, -2.97552254e-02f, 6.01083972e-02f,
  1.50521882e-02f, -2.04657525e-01f, -1.40097082e-01f, 6.06099889e-02f, 6.36918768e-02f, -1.08810090e-01f, -3.34027797e-01f, 1.97250888e-01f, -2.03897119e-01f, -5.59786148e-02f,
  7.27192089e-02f, -9.92449224e-02f, -1.79508030e-01f, 5.50782308e-02f, 4.60534841e-02f, -2.84319997e-01f, 8.38243216e-02f, 4.77815606e-02f, -1.14980705e-01f, 1.95133343e-01f,
  1.96737006e-01f, 2.49760985e-01f, 1.80315509e-01f, 3.69047582e-01f, 7.33377039e-02f, 2.24358469e-01f, 3.38509381e-01f, 9.40145031e-02f, 4.06455249e-01f, 1.46687895e-01f,
  -5.57611138e-02f, 4.41854969e-02f, -1.20213144e-01f, -7.38140047e-02f, 1.42371744e-01f, -6.53483570e-02f, -2.62781586e-02f, 2.98861172e-02f, 6.91287443e-02f, -7.23888874e-02f,
  -1.10043250e-01f, 1.10095724e-01f, -5.31080887e-02f, 2.14729980e-02f, 8.65858942e-02f, 6.47014380e-02f, -7.22074732e-02f, -6.31453246e-02f, -1.40416741e-01f, 4.02699634e-02f,
  -9.55174956e-03f, -9.02979001e-02f, -1.03633568e-01f, 3.17687094e-02f, 8.46312046e-02f, 2.79751290e-02f, -1.47544325e-03f, 9.22074914e-02f, -3.52809280e-02f, 1.53089603e-02f,
  1.50785670e-01f, -1.56165957e-02f, 1.93243008e-02f, -9.11079198e-02f, -3.79321091e-02f, -6.22750297e-02f, -5.11377268e-02f, -2.46770624e-02f, 6.09944500e-02f, -2.30291858e-02f,
  7.14698508e-02f, 7.46827349e-02f, -3.22327428e-02f, 3.71900573e-02f, 1.07850246e-01f, -7.76904076e-02f, -1.74120720e-02f, -4.48493138e-02f, 4.16794904e-02f, 2.22932640e-02f,
  -7.20871165e-02f, 1.34317711e-01f, -4.93646450e-02f, 3.28564681e-02f, -7.44269714e-02f, 7.83467442e-02f, 8.84825960e-02f, 3.68669666e-02f, 3.48861292e-02f, -7.54676899e-03f,
  1.12340748e-01f, 1.13449872e-01f, 4.56226058e-02f, 3.58288810e-02f, -8.11829716e-02f, -5.39367571e-02f, -1.98468436e-02f, 9.52063203e-02f, 3.90446521e-02f, -3.76369171e-02f,
  1.63650095e-01f, 2.86401138e-02f, 7.57799344e-03f, 7.67401280e-03f, 5.40810376e-02f, 7.50291124e-02f, 5.73993139e-02f, 3.56815010e-02f, 1.31373048e-01f, 1.64149195e-01f,
  1.06677763e-01f, -8.05656761e-02f, -1.34310042e-02f, 1.39576169e-02f, 3.53864059e-02f, 2.13484224e-02f, 1.03769146e-01f, 1.01561271e-01f, 2.60218456e-02f, -7.32377097e-02f,
  4.91176583e-02f, 5.12201488e-02f, -2.96626747e-01f, -1.18132345e-01f, -2.12775260e-01f, -7.14793503e-02f, 5.88689325e-03f, -1.55077249e-01f, -7.55467266e-02f, 2.05879867e-01f,
  -1.29404813e-01f, 4.96873707e-02f, 2.33637497e-01f, 4.12384123e-02f, 4.90983687e-02f, 4.06623662e-01f, -1.87644064e-02f, 1.15938917e-01f, -1.73170179e-01f, 1.05995918e-02f,
  -1.49496913e-01f, 7.19638094e-02f, 1.08153529e-01f, -7.44266212e-02f, -8.09873641e-02f, -1.14430070e-01f, -1.45542592e-01f, -1.09699659e-01f, -1.48012966e-01f, -1.28800392e-01f,
  7.37256408e-02f, 1.26182541e-01f, 4.40232567e-02f, 1.62417088e-02f, 1.07716814e-01f, 7.00451210e-02f, -2.44027898e-02f, 8.04751515e-02f, -9.36828405e-02f, 5.34238629e-02f,
  7.49048889e-02f, 4.81860526e-02f, 9.02774110e-02f, -3.45794670e-02f, -2.70290021e-02f, -1.05790429e-01f, -1.28590107e-01f, -6.01996854e-02f, 8.28802399e-03f, 6.77069053e-02f,
  -1.02745265e-01f, 7.57604539e-02f, -1.50733352e-01f, 5.63525520e-02f, -5.41371591e-02f, -1.50223002e-01f, 8.44813436e-02f, 5.58096124e-03f, 1.03994377e-01f, -6.30753580e-03f,
  1.12565920e-01f, -3.20966206e-02f, 1.56188374e-02f, -5.07345311e-02f, -2.92839464e-02f, 5.26269451e-02f, -2.87870597e-02f, 1.22052012e-02f, -1.81531757e-01f, -5.74524701e-02f,
  -1.01257846e-01f, -5.40089197e-02f, 9.63810384e-02f, -9.22972634e-02f, 8.80523492e-03f, -2.33878326e-02f, 3.98371257e-02f, 5.51966466e-02f, -1.21264681e-01f, -1.24536932e-01f,
  4.40990850e-02f, 2.04578340e-02f, 7.15974495e-02f, 5.74205145e-02f, -1.56959724e-02f, -1.18225254e-01f, -8.83852243e-02f, -2.55725123e-02f, -3.95159423e-02f, 2.93646138e-02f,
  1.14352204e-01f, 1.67393625e-01f, 1.87840443e-02f, 6.60563931e-02f, 1.14246786e-01f, 3.25758755e-02f, 1.28280580e-01f, 6.76928610e-02f, 9.49717239e-02f, -9.39634163e-03f,
  4.52919081e-02f, 4.24766466e-02f, -1.09890074e-01f, -8.00112635e-02f, -9.53704491e-02f, -8.96948576e-03f, -7.76901841e-03f, -2.43026167e-02f, -2.66527478e-02f, -5.05294092e-02f,
  2.36177854e-02f, -1.33246952e-03f, 5.78721538e-02f, 7.61841685e-02f, -7.67436698e-02f, -4.48525771e-02f, -2.94003822e-02f, 5.65856211e-02f, 7.45098814e-02f, -8.74350518e-02f,
  2.55848020e-01f, -2.62824506e-01f, -3.76442254e-01f, -5.78979915e-03f, 1.76054686e-01f, 3.52161467e-01f, 1.51120126e-01f, -9.90615115e-02f, -2.66939133e-01f, -8.49517435e-03f,
  1.27622902e-01f, 8.90800208e-02f, -2.72864372e-01f, 3.63000900e-01f, 3.15572679e-01f, -1.30930603e-01f, 2.51488835e-01f, 1.12405695e-01f, -1.49537459e-01f, -2.05528840e-01f,
  -7.26872310e-02f, 3.73321891e-01f, 2.54439395e-02f, 1.30354613e-01f, 1.92888215e-01f, -1.36315823e-01f, 6.29914701e-02f, -3.37400772e-02f, 2.81660229e-01f, 2.45192751e-01f,
  1.54354975e-01f, -1.79950446e-01f, 3.70970964e-02f, 5.24197184e-02f, -8.61400589e-02f, -5.26675545e-02f, 1.23197913e-01f, 1.74712285e-01f, 5.53675480e-02f, -5.52935563e-02f,
  1.32945394e-02f, 8.12626183e-02f, 1.69038679e-02f, 6.13269508e-02f, 2.81666536e-02f, -3.46016437e-02f, -7.93082118e-02f, -2.77922470e-02f, -5.45581952e-02f, -7.36403167e-02f,
  -2.29632586e-01f, -4.90527041e-02f, -5.62950894e-02f, 4.43114303e-02f, 4.59127426e-02f, 1.28381075e-02f, -5.55826873e-02f, 4.95492341e-03f, -7.82375932e-02f, 8.27594623e-02f,
  2.55467054e-02f, 4.09782231e-02f, -2.11506318e-02f, 3.76073159e-02f, 5.43207452e-02f, -3.84841412e-02f, 5.37774675e-02f, 3.30230035e-02f, 1.51316365e-02f, -7.23994747e-02f,
  -4.56014574e-02f, -2.35531968e-03f, -2.02368237e-02f, 7.50110373e-02f, 6.14598133e-02f, -7.50047490e-02f, 2.60332171e-02f, 9.32633057e-02f, -5.22542633e-02f, -8.65893364e-02f,
  -3.92927881e-03f, -7.09488476e-03f, -7.20155239e-02f, -5.81015600e-03f, 5.78733310e-02f, 3.11714672e-02f, 1.73064210e-02f, -1.95164345e-02f, -2.15824768e-02f, -3.95590663e-02f,
  -5.76166138e-02f, -1.62471086e-01f, -5.08678406e-02f, 5.28451204e-02f, 8.76595790e-04f, -6.34497255e-02f, 1.00620352e-01f, 4.51383879e-03f, -5.72755076e-02f, 3.88835073e-02f,
  2.38459483e-02f, 3.33594009e-02f, 5.47143146e-02f, 1.70354750e-02f, 1.11830689e-01f, -3.21802194e-03f, -1.12570472e-01f, 6.47553578e-02f, -6.44268915e-02f, -7.63686970e-02f,
  5.06676082e-03f, -9.78352726e-02f, 5.58948815e-02f, -8.71831402e-02f, 6.83441609e-02f, -1.22199683e-02f, 2.75905710e-02f, -1.94079876e-02f, 1.88583471e-02f, -3.64556424e-02f,
  2.19562724e-01f, -7.43742734e-02f, -2.79476911e-01f, 4.21317630e-02f, 9.50650945e-02f, 1.30973250e-01f, 1.17601864e-01f, -6.05256967e-02f, -1.95990577e-01f, -4.82800268e-02f,
  1.03495650e-01f, -2.33414337e-01f, -6.87217861e-02f, 2.78249502e-01f, 3.16812396e-01f, -9.57257301e-02f, 3.21827024e-01f, 1.24608152e-01f, -8.62379745e-02f, 2.06297413e-01f,
  3.54890935e-02f, 3.71351421e-01f, 9.10914764e-02f, 1.91072568e-01f, 2.97206461e-01f, -2.98742037e-02f, 1.79495275e-01f, -1.14873998e-01f, 1.56847268e-01f, 3.23385112e-02f,
  1.60527691e-01f, 7.33234361e-02f, -3.46184261e-02f, -2.49312408e-02f, -2.07029451e-02f, 1.19889803e-01f, -4.69318032e-02f, 1.13379121e-01f, -4.62375954e-02f, -8.62795413e-02f,
  -3.30383144e-02f, 4.01114374e-02f, 2.55469084e-02f, 6.35383278e-02f, -9.08853952e-03f, 2.28539687e-02f, -6.17764629e-02f, -3.12187709e-02f, -5.33217080e-02f, 1.63043234e-02f,
  -1.43324388e-02f, 9.10084974e-03f, -1.37086660e-02f, 3.71939205e-02f, -1.65619478e-01f, -2.51201652e-02f, -1.83745567e-02f, -1.01597473e-01f, 1.78681165e-02f, -4.62025590e-02f,
  3.19601931e-02f, 9.53645110e-02f, -1.32001042e-02f, 1.09424502e-01f, -4.11023349e-02f, -5.59752807e-03f, 8.81444737e-02f, -8.96480680e-03f, -1.14480413e-01f, 1.49405682e-02f,
  4.93050963e-02f, 7.33426884e-02f, 4.10057083e-02f, 6.38996735e-02f, 5.65875284e-02f, 4.68171313e-02f, 3.00026350e-02f, -1.52468346e-02f, 2.58273128e-02f, -1.05141243e-02f,
  1.69152289e-03f, 9.91531555e-03f, -3.41488654e-03f, 2.87976041e-02f, 4.14539911e-02f, -1.47456095e-01f, -2.20893864e-02f, -7.89231881e-02f, -1.12275861e-01f, 2.71694940e-02f,
  4.74586077e-02f, 9.08519048e-03f, -9.54546481e-02f, 4.22854908e-02f, -4.05937508e-02f, 1.71761718e-02f, -6.58548623e-02f, 7.53330588e-02f, 6.98893964e-02f, -6.08158596e-02f,
  1.18085891e-01f, -3.39081511e-02f, 1.00738872e-02f, -2.16015093e-02f, -3.38701606e-02f, -9.71000493e-02f, -4.73809848e-03f, -1.09635316e-01f, -4.81262617e-03f, 5.44196293e-02f,
  3.33729498e-02f, -4.13651019e-02f, 3.82437184e-02f, -1.46235041e-02f, -4.64384146e-02f, -2.35524923e-02f, -4.57130559e-02f, -3.87146696e-02f, 8.62875581e-03f, -6.29075766e-02f,
  -8.42393860e-02f, 1.99419901e-01f, 3.02811325e-01f, 1.43234715e-01f, -1.13488561e-04f, -9.46786478e-02f, 1.26567528e-01f, 6.39060140e-02f, 4.12466049e-01f, 9.24176648e-02f,
  -5.62494211e-02f, 3.31403054e-02f, 6.32149354e-02f, 1.18296240e-02f, -1.99846074e-01f, 2.31163532e-01f, -2.21810997e-01f, 2.48929411e-02f, 2.01020911e-01f, -1.29789159e-01f,
  -1.05193727e-01f, -2.43099302e-01f, -1.49928138e-01f, -4.10465486e-02f, -7.38995448e-02f, 3.10861133e-02f, -3.41987401e-01f, 2.45578438e-01f, -1.40692025e-01f, 1.37196518e-02f,
  -1.49477154e-01f, 2.26068959e-01f, -8.99162963e-02f, 1.63610369e-01f, -2.18875222e-02f, -1.94627009e-02f, -6.62436411e-02f, 6.04039729e-02f, 1.28702685e-01f, 6.88066334e-02f,
  3.37199308e-02f, 2.76642106e-03f, 1.99448597e-02f, 3.39445435e-02f, 1.73776492e-01f, -1.43887959e-02f, -1.29961502e-02f, -1.44270718e-01f, 5.71785495e-03f, -8.40850472e-02f,
  -2.29093879e-02f, 4.84718159e-02f, -6.40629325e-03f, 5.31969480e-02f, -1.57576967e-02f, 8.34245384e-02f, 1.27509177e-01f, -6.32385984e-02f, 2.58082524e-02f, 1.49540335e-01f,
  -3.42155918e-02f, -3.35547179e-02f, -1.75638795e-02f, 1.54751884e-02f, 5.17337993e-02f, 4.58029509e-02f, 1.75692365e-02f, -1.40041515e-01f, 3.75647545e-02f, -8.02307501e-02f,
  4.28540744e-02f, 1.24505395e-02f, 1.73273996e-01f, 1.08718341e-02f, -1.43503435e-02f, -1.18094403e-02f, -1.27167199e-02f, 1.57793105e-01f, -5.31776287e-02f, -1.74666062e-01f,
  3.17523628e-02f, -3.91725376e-02f, -7.88071454e-02f, -1.05960436e-01f, 1.45771457e-02f, 1.32649079e-01f, -1.01768807e-01f, 9.20227468e-02f, -6.52086586e-02f, -2.05476746e-01f,
  -2.39657521e-01f, 1.02829210e-01f, -1.71397626e-02f, -3.97564247e-02f, -1.11498967e-01f, -1.88114330e-01f, 2.43028384e-02f, 3.20384162e-03f, -1.94798000e-02f, -8.58970161e-04f,
  -5.41422814e-02f, -2.54091769e-02f, -7.35817179e-02f, 4.15301882e-02f, -5.09725511e-02f, -1.73325211e-01f, -6.90927505e-02f, -5.22801541e-02f, -1.79576948e-01f, -8.45746771e-02f,
  -1.27689242e-01f, 2.75092740e-02f, -4.20220383e-02f, -1.00829504e-01f, -5.68196811e-02f, -8.90672803e-02f, -5.30548990e-02f, 2.78832894e-02f, -6.30948395e-02f, -5.64383008e-02f,
  -5.58382750e-01f, -1.95776030e-01f, 2.97223657e-01f, -1.84386879e-01f, -5.32153621e-02f, 4.54328209e-01f, 4.20184612e-01f, -2.58822292e-01f, -4.32417274e-01f, 9.14214402e-02f,
  2.49895349e-01f, 2.06426866e-02f, 2.69822836e-01f, 1.11080952e-01f, 3.16494018e-01f, 2.09043488e-01f, 8.97078291e-02f, 1.19201504e-01f, -1.84013143e-01f, -1.03480183e-01f,
  -5.56308627e-02f, 9.22517851e-02f, 2.90185899e-01f, -1.39463469e-01f, 4.73024286e-02f, -2.64820993e-01f, -8.94466136e-03f, 1.83369875e-01f, 8.29034895e-02f, 2.60294646e-01f,
  -1.56075582e-01f, -3.58980030e-01f, 2.38092542e-02f, 1.48571078e-02f, 8.65059197e-02f, 2.05657426e-02f, 2.04055402e-02f, 1.09438278e-01f, -1.19497906e-02f, 3.30944732e-02f,
  2.72376444e-02f, -7.95716494e-02f, -1.71803221e-01f, -1.69283934e-02f, -9.97892171e-02f, 1.25987334e-02f, 5.35715781e-02f, 1.65062808e-02f, 4.80815992e-02f, 8.57567564e-02f,
  1.67768002e-01f, 1.28379330e-01f, -1.94850750e-02f, -5.83007094e-03f, 8.93553644e-02f, 2.61871945e-02f, 6.19631745e-02f, 3.86339054e-02f, 5.85380644e-02f, -4.43163477e-02f,
  -1.15433149e-01f, -1.11450195e-01f, 7.32403994e-02f, -7.38445744e-02f, 5.19533502e-03f, 4.21496443e-02f, 1.38988076e-02f, 1.89682245e-02f, 7.88193545e-04f, 4.17726040e-02f,
  4.36143344e-03f, 1.43263675e-03f, -9.61179733e-02f, 3.55739854e-02f, -5.38572073e-02f, -4.33245860e-03f, 6.24861047e-02f, 1.19138360e-02f, -6.71578571e-02f, 7.83781782e-02f,
  -1.52775515e-02f, 6.12428971e-02f, 5.58436662e-03f, 1.89793911e-02f, 2.49063224e-02f, 1.30045176e-01f, -7.64622167e-02f, -6.98888972e-02f, 6.50730310e-03f, 1.73455074e-01f,
  -1.82810858e-01f, -2.68521607e-01f, 2.26353761e-03f, 6.08248860e-02f, -4.71287519e-02f, 4.84966524e-02f, -4.17383611e-02f, -8.38250890e-02f, -1.07488157e-02f, -4.73152027e-02f,
  5.16294083e-03f, -1.03338622e-01f, -4.66657057e-02f, -3.81956026e-02f, -3.22627686e-02f, -8.87462199e-02f, 5.68597876e-02f, -5.61953783e-02f, 7.33908191e-02f, -3.25425938e-02f,
  -1.50108170e-02f, -9.60758328e-03f, 3.65668237e-02f, -8.93691853e-02f, -4.08426113e-02f, 8.22971389e-02f, -1.27385497e-01f, 3.44011486e-02f, 2.29923204e-02f, 7.25911111e-02f,
  4.86373492e-02f, -2.77721673e-01f, -1.68810397e-01f, -4.36611138e-02f, -2.85445880e-02f, -2.94292927e-01f, -4.10266578e-01f, -9.57053825e-02f, 3.79502140e-02f, -1.12864017e-01f,
  -1.25910729e-01f, -9.61943641e-02f, -2.18957081e-01f, -1.86880603e-01f, 2.52379715e-01f, -4.50123064e-02f, -1.15181074e-01f, -7.21552595e-02f, -3.10744625e-02f, -1.01358280e-01f,
  1.50608465e-01f, -2.76954155e-02f, -1.51272928e-02f, 8.18109736e-02f, -1.82618305e-01f, 1.24322362e-01f, 2.11531997e-01f, -9.01034325e-02f, 2.02226982e-01f, 1.40541920e-03f,
  -1.52788028e-01f, -6.75750077e-02f, -9.90505815e-02f, 5.68186231e-02f, -2.91723292e-02f, 1.63592193e-02f, 2.51034610e-02f, -4.85418849e-02f, 3.79569046e-02f, -5.05062453e-02f,
  -8.39582756e-02f, 5.40489182e-02f, 8.56633782e-02f, 7.58009329e-02f, -5.74720390e-02f, 8.57974440e-02f, 6.62338035e-03f, 5.47577208e-03f, -1.52563322e-02f, 8.47669318e-03f,
  -1.60735965e-01f, 5.04363328e-02f, 6.03659451e-02f, 3.46274264e-02f, 4.52270964e-04f, -3.07755992e-02f, -1.05012804e-02f, -1.00579031e-01f, 4.99360226e-02f, 1.36295244e-01f,
  -4.14715782e-02f, 2.85209306e-02f, -1.55307263e-01f, -5.60115688e-02f, -3.91210951e-02f, -4.34724726e-02f, -1.17111159e-02f, -2.16873419e-02f, -9.72135887e-02f, -6.00179397e-02f,
  1.52267143e-02f, -7.09477514e-02f, 9.03947502e-02f, -4.16210294e-02f, -7.32014999e-02f, -9.97683406e-03f, 7.78728798e-02f, 3.67621817e-02f, -1.11449137e-02f, -2.46154014e-02f,
  3.31717692e-02f, -2.82862764e-02f, -1.07133007e-02f, 6.72629029e-02f, -1.74534768e-02f, -3.64139043e-02f, 4.75649387e-02f, 1.75997540e-02f, -6.89839199e-02f, -1.00986287e-01f,
  1.78578179e-02f, 1.49798319e-01f, 3.01233307e-02f, 3.44368108e-02f, 3.17019895e-02f, -1.50302619e-01f, -7.81763345e-02f, 3.58247496e-02f, 1.21577330e-01f, 4.26135063e-02f,
  3.63504654e-03f, 1.57040078e-02f, 1.05032779e-01f, 1.02624632e-01f, 3.30797322e-02f, -2.99256016e-02f, 7.60539845e-02f, 2.90663745e-02f, 4.40089516e-02f, 1.07117280e-01f,
  1.41113503e-02f, -7.53192455e-02f, 3.55199091e-02f, 3.01412772e-02f, 1.01077922e-01f, -6.34618057e-03f, -1.08624995e-02f, 5.84600344e-02f, 6.18576556e-02f, 4.05381806e-02f,
  -3.31736356e-01f, 3.99760962e-01f, 2.91491777e-01f, -7.89689422e-02f, -9.89476889e-02f, -5.90012185e-02f, -2.57012755e-01f, 6.92192242e-02f, -9.60261524e-02f, 2.07327932e-01f,
  -9.69932377e-02f, 2.68754333e-01f, 9.51539576e-02f, -2.50052996e-02f, -3.36982429e-01f, -2.00561479e-01f, -1.99097380e-01f, -3.69053930e-02f, -8.40434954e-02f, 5.24810702e-02f,
  -8.62909183e-02f, -2.53557146e-01f, -6.31880239e-02f, 2.12419719e-01f, -1.36505831e-02f, 7.47988597e-02f, -2.60354877e-01f, 5.82723692e-02f, -2.63088290e-02f, 2.44375747e-02f,
  -2.34924495e-01f, -1.01144716e-01f, 1.25793023e-02f, 7.30465129e-02f, -1.12168543e-01f, -4.55941819e-02f, -3.05333510e-02f, -3.32993232e-02f, -7.20735118e-02f, 2.25040112e-02f,
  6.15128763e-02f, 6.08894341e-02f, 8.27501863e-02f, -1.22580249e-02f, 3.67370732e-02f, 4.99446057e-02f, 1.51182301e-02f, 7.02651069e-02f, 9.18884352e-02f, 1.09618358e-01f,
  5.51086143e-02f, 3.85426544e-02f, -7.88653493e-02f, 3.10894139e-02f, -7.38690495e-02f, -1.72178987e-02f, 3.95767689e-02f, -8.02109390e-03f, 6.01599552e-02f, -9.50463116e-03f,
  -7.12023973e-02f, -1.69535011e-01f, -5.18825799e-02f, 7.39578456e-02f, -1.88260601e-04f, -6.45386130e-02f, 1.21700756e-01f, -1.61385909e-02f, -4.28950749e-02f, -4.86862846e-02f,
  -1.05308071e-01f, 9.28901695e-03f, -9.60716978e-02f, -8.48986581e-02f, 7.88600300e-04f, 2.65978612e-02f, -3.28767300e-02f, -2.79973913e-02f, 7.03139603e-02f, 5.96809275e-02f,
  -3.09732761e-02f, -2.82759294e-02f, 1.74747445e-02f, -1.38486505e-01f, -5.34705035e-02f, -3.29454476e-03f, 1.38113394e-01f, 2.97232997e-02f, -2.28541847e-02f, -3.47453617e-02f,
  -4.04219657e-01f, -1.94033667e-01f, -1.47023857e-01f, -6.09365143e-02f, 3.26582715e-02f, -1.13243079e-02f, -1.87371880e-01f, -1.44100599e-02f, -4.56795171e-02f, 5.00112493e-03f,
  3.39447446e-02f, -7.64575526e-02f, -4.11187522e-02f, -9.69715118e-02f, -7.31427148e-02f, -8.87215734e-02f, -1.05235726e-02f, -1.76473297e-02f, -1.51187390e-01f, -7.56115913e-02f,
  4.53519076e-02f, 1.10219955e-01f, -2.40183268e-02f, -1.55582443e-01f, -1.62991405e-01f, -4.94539142e-02f, 9.08571668e-03f, -2.50969827e-02f, -1.58546157e-02f, -4.62408550e-02f,
  3.02416948e-03f, 2.51362473e-01f, 1.40806148e-02f, 5.87070882e-02f, -2.00068846e-01f, -1.96761787e-01f, -9.09886435e-02f, -1.75919965e-01f, 1.50103848e-02f, 3.02966535e-01f,
  -1.51080221e-01f, 2.79520303e-01f, -1.18248016e-01f, -5.14926352e-02f, -5.28681219e-01f, -2.52910018e-01f, -1.93830699e-01f, 1.03502415e-01f, -1.54010877e-01f, -6.97730258e-02f,
  -1.27174526e-01f, -2.49674827e-01f, -2.00948447e-01f, -1.44460037e-01f, 7.52895623e-02f, 2.02807188e-01f, -5.39258309e-02f, -1.17170952e-01f, 5.25118858e-02f, -7.93099701e-02f,
  -7.98572004e-02f, -3.53138447e-02f, 1.42014161e-01f, 4.42289039e-02f, -2.12935526e-02f, 5.09762065e-03f, 1.03823110e-01f, 4.32382934e-02f, 1.74131710e-02f, 2.95082293e-03f,
  1.11631744e-01f, -1.15735166e-01f, -1.35322043e-03f, -5.56236990e-02f, 7.48924091e-02f, 1.42218813e-01f, 8.37992504e-03f, 5.99051155e-02f, 1.25361532e-01f, 8.17976817e-02f,
  8.06191042e-02f, 6.88228803e-03f, 1.39108524e-01f, 2.51110774e-02f, -8.55044276e-03f, 1.35409487e-02f, -1.64981894e-02f, -7.30934786e-03f, 1.40772630e-02f, -4.35433127e-02f,
  -1.28554618e-02f, 6.82860538e-02f, -8.55418816e-02f, 3.14514898e-02f, 3.87651734e-02f, 2.97290646e-02f, 3.78601812e-03f, 8.85499120e-02f, 1.27592683e-01f, -9.98404995e-02f,
  -4.07870561e-02f, -1.62331928e-02f, -2.19165478e-02f, 8.59409794e-02f, -1.79726183e-02f, 1.37493843e-02f, -2.97900885e-02f, 2.43068263e-02f, 2.05656271e-02f, 8.84831231e-03f,
  -4.20432687e-02f, -8.58953893e-02f, 2.14823596e-02f, -2.85230801e-02f, -8.93001556e-02f, -2.65162066e-02f, 9.69833415e-03f, 4.46882914e-05f, -3.11317630e-02f, -7.05254003e-02f,
  -1.24792278e-01f, -2.16896921e-01f, -1.46201756e-02f, 9.34390947e-02f, -6.95857406e-02f, 3.67612801e-02f, -6.77660927e-02f, 3.73010151e-02f, -3.45368162e-02f, -6.19373806e-02f,
  7.17938021e-02f, 1.03150986e-01f, -5.97837195e-02f, 1.23330638e-01f, -7.12272897e-02f, -5.83606474e-02f, -8.74106884e-02f, -3.98868956e-02f, -2.35366262e-02f, 4.11359258e-02f,
  9.24971998e-02f, 1.70280375e-02f, 4.57798913e-02f, 2.11268459e-02f, 3.41631770e-02f, 2.96595003e-02f, -6.67146035e-03f, 1.25602156e-01f, -4.60227544e-04f, -3.28928791e-02f,
  8.11496377e-02f, 1.31603464e-01f, 2.48399794e-01f, 3.88213754e-01f, -2.79737622e-01f, -4.80356634e-01f, -2.98353314e-01f, -7.90503621e-03f, -9.53160673e-02f, 5.18076792e-02f,
  -1.42119769e-02f, 2.70111620e-01f, -4.21521477e-02f, 7.02136084e-02f, -2.62516947e-03f, -1.62231460e-01f, 1.87894553e-01f, -1.15674272e-01f, 1.67828742e-02f, 1.29800245e-01f,
  1.42466173e-01f, 7.04454109e-02f, 3.11135322e-01f, 1.56394944e-01f, 7.55801201e-02f, 2.79157549e-01f, 3.62577885e-01f, 6.54921606e-02f, 2.51554877e-01f, 1.61406137e-02f,
  -1.33156866e-01f, 8.84895027e-02f, 9.62418690e-02f, -4.05722223e-02f, 6.94572404e-02f, -7.73034021e-02f, 7.24488795e-02f, -5.17166182e-02f, -7.16427118e-02f, -4.68770415e-02f,
  -4.39528048e-05f, -5.54989241e-02f, -8.94693285e-02f, -1.50135998e-03f, -9.62663442e-02f, 5.30860201e-02f, 7.89615735e-02f, 1.70969125e-02f, 1.20902702e-01f, 1.09846242e-01f,
  9.31737572e-02f, -8.58183503e-02f, 1.37186155e-01f, 2.77421754e-02f, 1.08507730e-01f, 9.03909430e-02f, -2.40451582e-02f, 9.48675722e-02f, 5.95443510e-02f, -2.08094977e-02f,
  5.55020571e-02f, -4.78167180e-03f, -2.30875015e-02f, -1.35457069e-02f, -3.09715271e-02f, -2.54934598e-02f, -4.89427475e-03f, 5.96485734e-02f, -3.67994905e-02f, -7.59213567e-02f,
  -8.43002945e-02f, 8.77863169e-02f, -7.27311596e-02f, 2.89947912e-02f, 6.64286837e-02f, -2.99225096e-02f, -4.83114757e-02f, -6.07616305e-02f, 7.71753266e-02f, 8.50501508e-02f,
  -3.82841155e-02f, 1.99253429e-02f, -6.12923875e-03f, -2.79900655e-02f, -7.21648037e-02f, -7.46330544e-02f, 4.08102833e-02f, -7.44847059e-02f, 2.35499069e-02f, 6.98615909e-02f,
  1.24402992e-01f, 2.92452276e-01f, -3.77979763e-02f, -1.07870959e-01f, -3.97523157e-02f, -2.32570227e-02f, -2.02395059e-02f, 1.14835292e-01f, 7.94593543e-02f, 2.18835976e-02f,
  1.01047151e-01f, -1.04148187e-01f, -4.24572863e-02f, -6.70437291e-02f, -3.43424678e-02f, 6.66917861e-02f, 2.48257145e-02f, 4.66965213e-02f, 1.91167593e-01f, 4.68820781e-02f,
  6.77142441e-02f, -1.74882337e-01f, 1.01882257e-01f, -1.55153675e-02f, 7.39384741e-02f, -8.44821483e-02f, -4.45808955e-02f, 1.30662741e-02f, 4.35882621e-02f, 1.00364856e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.07418001e-01f, 3.99334490e-01f, 3.28576088e-01f, 3.36190134e-01f, 1.42945603e-01f, 1.71025783e-01f, 4.20079857e-01f, 3.00966471e-01f, 2.16587335e-01f, 3.38072926e-01f,
  1.93281174e-01f, 9.71920937e-02f, 3.32566768e-01f, 4.07092333e-01f, 1.83087900e-01f, 1.88260376e-01f, 1.98294818e-01f, 3.04660976e-01f, 2.14558318e-01f, 3.03759277e-01f,
  3.69655669e-01f, 3.71903151e-01f, 2.56274581e-01f, 2.47865930e-01f, 3.50349396e-01f, 1.44353822e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  6.52665943e-02f, 2.04871371e-02f, 5.93248568e-02f, 2.72929724e-02f, 1.98124245e-01f, 1.02977790e-01f, 4.83087897e-02f, -2.08641559e-01f, 6.08211532e-02f, -1.88066900e-01f,
  2.97286687e-03f, -2.82876402e-01f, -4.44040269e-01f, 1.67643670e-02f, -2.59566039e-01f, 3.31925780e-01f, 1.58528790e-01f, 9.54297036e-02f, 2.34530628e-01f, 5.53918406e-02f,
  -2.92745858e-01f, 1.05126239e-01f, 1.10350542e-01f, 4.89655696e-02f, 2.48407826e-01f, 1.25288516e-02f, 3.75939570e-02f, 1.36534855e-01f, 7.37052709e-02f, 1.34760410e-01f,
  -9.76254418e-02f, 3.99856925e-01f, -3.64208501e-03f, 8.96291137e-02f, 7.62847885e-02f, 5.42123504e-02f, -6.88880831e-02f, -2.57644355e-01f, -3.80005151e-01f, 2.68347263e-01f,
  5.37793338e-02f, 2.94690449e-02f, -6.38297796e-02f, -3.31187584e-02f, 2.86067784e-01f, 2.89222270e-01f, -1.38152361e-01f, -9.27689597e-02f, -7.91438743e-02f, 2.69213527e-01f,
  -5.86833544e-02f, -1.31356195e-01f, 2.82202274e-01f, 2.64160000e-02f, 2.68526196e-01f, 3.16327997e-02f, 2.93878287e-01f, 1.67738467e-01f, -1.47050649e-01f, 1.55565202e-01f,
  1.40759200e-01f, -2.73254901e-01f, -1.18813865e-01f, -3.04902434e-01f, -5.28995059e-02f, -6.09292388e-02f, -1.01616569e-02f, -3.07021365e-02f, -1.76980183e-01f, 4.60111387e-02f,
  2.02761799e-01f, -4.34677526e-02f, -2.52474993e-01f, -4.60375808e-02f, 2.39234433e-01f, 2.81079113e-01f, 4.77574855e-01f, -1.94174811e-01f, 1.25222459e-01f, -2.07648262e-01f,
  8.79115015e-02f, -9.07261670e-02f, 1.65560424e-01f, 1.81007355e-01f, -1.41659424e-01f, -2.31937855e-01f, -1.73287898e-01f, 1.62541002e-01f, -1.65260613e-01f, 2.90202945e-02f,
  1.41937286e-01f, -1.22246377e-01f, -3.14398408e-01f, 1.43340752e-01f, 1.28921211e-01f, 1.52914003e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.80499154e-01f, 1.46072343e-01f, 2.80229330e-01f, 1.94800079e-01f, 4.58520710e-01f, -3.52993160e-01f, 2.76576638e-01f, 2.76340097e-01f, 3.66161793e-01f, -1.26781002e-01f,
  -1.40257508e-01f, -2.39561647e-01f, -1.86322629e-01f, 1.63459972e-01f, 2.07701728e-01f, 6.89799428e-01f, 3.74034971e-01f, -9.47079211e-02f, 1.93545088e-01f, 2.36408770e-01f,
  4.08600941e-02f, 2.32894614e-01f, 2.70125598e-01f, -1.68538928e-01f, 1.49066120e-01f, 3.15357745e-01f, 2.90198416e-01f, 2.87308693e-01f, 5.15719280e-02f, -1.58299848e-01f,
  1.07564844e-01f, 8.15119892e-02f, 3.06424558e-01f, 2.21235171e-01f, 6.57943636e-02f, -2.62008399e-01f, -3.15227598e-01f, 3.21639538e-01f, 3.11648726e-01f, 2.18207225e-01f,
  4.99305911e-02f, 3.09890062e-01f, 1.01588003e-01f, 3.25013250e-01f, -4.22454104e-02f, 8.08233693e-02f, 2.43926346e-01f, -1.43809080e-01f, 4.43153352e-01f, -5.37608504e-01f,
  1.07473224e-01f, -6.93521723e-02f, 5.93999103e-02f, -3.39290708e-01f, 1.73730329e-01f, -1.66344136e-01f, -1.68396577e-01f, -1.56459510e-01f, 2.83868641e-01f, 2.21091360e-01f,
  -1.89153209e-01f, 5.55705845e-01f, 5.29752553e-01f, 3.71422544e-02f, 4.66410458e-01f, 3.98017555e-01f, 5.57739198e-01f, 8.83436054e-02f, -4.50393379e-01f, -3.39170665e-01f,
  1.11416303e-01f, -1.11386150e-01f, 1.79876879e-01f, -8.89483169e-02f, 1.03409857e-01f, 1.40515849e-01f, 5.36184311e-01f, -1.73577756e-01f, -3.01576495e-01f, 1.18005415e-02f,
  -4.08754885e-01f, 9.75032151e-02f, 4.36687052e-01f, -8.02894961e-03f, 2.03108534e-01f, 9.44225863e-02f, -2.55773276e-01f, 2.56659597e-01f, 1.19490623e-01f, 1.66509688e-01f,
  3.29813696e-02f, 4.67268109e-01f, -1.54569730e-01f, -5.16956821e-02f, -2.10767746e-01f, -1.65641308e-01f, 1.30222052e-01f, 2.25390926e-01f, 2.97650080e-02f, -9.54230800e-02f,
  -7.20863491e-02f, 9.70690921e-02f, -2.68483460e-01f, 6.12404048e-02f, 2.79655963e-01f, 4.21808481e-01f, 1.03766859e-01f, 1.43353507e-01f, 1.23326920e-01f, 2.93759495e-01f,
  8.33610073e-02f, -3.03096473e-01f, 1.73380092e-01f, 2.03053549e-01f, -1.57912686e-01f, -2.19585150e-02f, 1.45624489e-01f, 3.03226203e-01f, 2.04835996e-01f, 2.21672356e-01f,
  -2.97742516e-01f, -3.39294314e-01f, 3.50991517e-01f, -4.00375068e-01f, 3.25604707e-01f, -6.18845411e-03f, 1.20021820e-01f, 3.15678000e-01f, 9.80482101e-02f, 6.31962195e-02f,
  -3.89742963e-02f, -1.48999721e-01f, 2.59608656e-01f, -3.69958550e-01f, -1.84048727e-01f, 2.90877512e-03f, 1.54329628e-01f, -1.57586589e-01f, -8.27632621e-02f, 7.79605955e-02f,
  1.50184199e-01f, 6.40881285e-02f, -9.90246013e-02f, 2.28839174e-01f, -7.70578161e-02f, 9.42650139e-02f, -6.68843761e-02f, 2.17466846e-01f, -2.08667256e-02f, -1.20861314e-01f,
  7.85037130e-02f, 5.48236743e-02f, 4.03702796e-01f, 3.67459267e-01f, -4.54911321e-01f, 4.00307626e-01f, 1.36161745e-01f, -2.82263100e-01f, -2.46796325e-01f, -2.46300504e-01f,
  2.02473789e-01f, 2.93257833e-01f, 2.58351058e-01f, -2.23055422e-01f, -2.94823825e-01f, -2.67402232e-01f, -9.30012316e-02f, 3.25628281e-01f, -1.07934467e-01f, -3.64075452e-01f,
  1.75991714e-01f, 3.13017607e-01f, 5.84320724e-01f, 8.09322745e-02f, -1.87953427e-01f, -3.19337517e-01f, 6.59424514e-02f, 2.21727163e-01f, 4.65590023e-02f, 4.12632734e-01f,
  2.93522060e-01f, -1.25111490e-01f, 5.85299768e-02f, 2.52042674e-02f, 3.90188456e-01f, 4.19786215e-01f, -2.67784536e-01f, 4.07990366e-01f, 9.15244818e-02f, 5.87324845e-04f,
  1.69409528e-01f, -6.44367114e-02f, 1.36060730e-01f, 2.55344762e-03f, 7.58207291e-02f, -1.85879737e-01f, -3.03293854e-01f, 4.06257451e-01f, 2.88798690e-01f, -2.78182458e-02f,
  5.37238605e-02f, 4.73797470e-01f, -8.55102539e-02f, 1.53334409e-01f, 3.49933952e-01f, -2.75513586e-02f, 4.71407771e-01f, -3.00304890e-01f, -3.89405675e-02f, 2.90050544e-02f,
  1.17753401e-01f, 2.82595605e-01f, 1.06874235e-01f, -2.38336902e-03f, 3.14180166e-01f, 2.44744867e-01f, -3.93871874e-01f, 2.37507567e-01f, 2.78031379e-01f, 5.80111742e-02f,
  7.34433532e-02f, 2.86442012e-01f, -1.56983197e-01f, 4.59844083e-01f, 1.23815231e-01f, 6.19691685e-02f, 1.78897783e-01f, 3.38012099e-01f, -2.97191262e-01f, -2.77981520e-01f,
  -4.30598766e-01f, -3.52765888e-01f, 7.75227770e-02f, -1.52869374e-01f, 2.44269982e-01f, 3.43175411e-01f, 4.70074892e-01f, 7.05677047e-02f, -1.74615964e-01f, -6.77369675e-03f,
  1.45303652e-01f, 2.07167640e-01f, 3.50315899e-01f, -2.89172471e-01f, 6.20748401e-02f, -9.69742611e-02f, -1.61935344e-01f, 2.34541312e-01f, 1.48642540e-01f, 2.12719038e-01f,
  8.28279555e-02f, 4.02663141e-01f, -2.60137200e-01f, 2.42537558e-01f, 3.52490336e-01f, 1.31051585e-01f, 1.65811121e-01f, 3.07577670e-01f, -4.18534130e-02f, 1.59614086e-01f,
  4.83655155e-01f, -9.70820561e-02f, 5.59424236e-02f, 7.81906024e-02f, 7.47587113e-03f, -2.80189037e-01f, -4.07025456e-01f, -2.75384396e-01f, 2.79616155e-02f, 1.35870963e-01f,
  2.18906283e-01f, 6.34271920e-01f, 2.68502831e-01f, -1.98316723e-01f, -2.15982690e-01f, 1.92791700e-01f, -1.30895197e-01f, 1.24547020e-01f, 1.84282631e-01f, -4.38102961e-01f,
  1.17735103e-01f, 2.90748566e-01f, 2.04564273e-01f, 1.21554449e-01f, 2.05410004e-01f, -3.20267349e-01f, -1.27612129e-02f, 3.42007667e-01f, -5.12667559e-02f, 2.32481197e-01f,
  -3.27796472e-04f, 1.01595335e-01f, -2.92902470e-01f, 5.12629509e-01f, 5.03697097e-01f, 1.26626164e-01f, 5.02114713e-01f, 4.20044482e-01f, 7.61939138e-02f, 5.89375377e-01f,
  1.29775167e-01f, 1.15364545e-03f, 4.51030850e-01f, 1.20036326e-01f, -8.88650119e-02f, -1.26829818e-01f, 1.57083720e-01f, -2.87824899e-01f, 9.84577462e-02f, -1.73540801e-01f,
  -2.01178819e-01f, 1.15562595e-01f, -5.24597093e-02f, -1.01888720e-02f, 1.82352722e-01f, 4.56118971e-01f, 1.43549874e-01f, 3.61572087e-01f, 1.73997700e-01f, -6.80154040e-02f,
  1.66058779e-01f, 1.89987510e-01f, 2.21856713e-01f, 2.47351810e-01f, 4.37259823e-01f, 1.83744788e-01f, 4.56803769e-01f, 1.54450163e-01f, 5.77950776e-01f, -1.63611412e-01f,
  -2.36275315e-01f, 2.83337474e-01f, -4.23283547e-01f, -1.88521951e-01f, 1.33966491e-01f, 4.45291936e-01f, -3.42993736e-01f, -5.03743947e-01f, 2.55170792e-01f, 2.11976767e-02f,
  -1.00646086e-01f, 2.75856197e-01f, 4.88404818e-02f, 1.28310040e-01f, 1.70688689e-01f, 1.62148714e-01f, 2.17965562e-02f, 2.80112803e-01f, -2.47567400e-01f, 2.84357786e-01f,
  -3.49909991e-01f, -1.48403928e-01f, 8.24055299e-02f, -2.94463057e-02f, 3.44088599e-02f, 2.06435725e-01f, 4.88021135e-01f, -2.78783828e-01f, -1.62851825e-01f, -2.56132632e-01f,
  5.85058570e-01f, 1.83093503e-01f, -1.37410745e-01f, -1.81466714e-01f, -1.20550729e-01f, 1.08801134e-01f, -2.26437643e-01f, 1.32736519e-01f, -2.04304025e-01f, -8.03991407e-02f,
  -2.26088554e-01f, -4.11450684e-01f, 2.60139406e-01f, 1.36293352e-01f, -1.23273507e-01f, -2.95608807e-02f, 2.79417992e-01f, 7.80318156e-02f, -2.14811012e-01f, 4.62876856e-01f,
  7.05444664e-02f, -2.84282625e-01f, -2.11951546e-02f, 1.56974211e-01f, 1.08602598e-01f, 3.60507667e-01f, 2.08383307e-01f, -5.18450797e-01f, 6.48107529e-02f, 7.86480233e-02f,
  -2.80781597e-01f, 3.66696537e-01f, -3.45171958e-01f, 2.06887573e-02f, -3.33306566e-02f, -5.63779891e-01f, 2.85775721e-01f, 2.36515686e-01f, 2.35143498e-01f, -1.68963835e-01f,
  1.21033266e-01f, -7.24904463e-02f, -4.05785233e-01f, 3.65638465e-01f, 3.56589794e-01f, -3.49804163e-01f, 5.40433109e-01f, -1.35583803e-01f, 4.12087083e-01f, 3.14633518e-01f,
  -5.77271461e-01f, 3.96107137e-02f, 2.10313827e-01f, -2.18453765e-01f, -1.60137713e-01f, 2.07864106e-01f, 4.15628195e-01f, 4.43005800e-01f, 1.51664600e-01f, -1.86860397e-01f,
  4.07821417e-01f, -1.89904600e-01f, -7.88688436e-02f, 1.29998714e-01f, -4.51906770e-01f, -4.95602161e-01f, 2.95149267e-01f, -3.34668636e-01f, -2.19430514e-02f, 1.85063720e-01f,
  -9.51717123e-02f, 5.10575593e-01f, 6.38621390e-01f, 1.30722120e-01f, 1.45894453e-01f, 4.33804482e-01f, 1.52745871e-02f, 2.40710348e-01f, 3.32467079e-01f, -6.14428408e-02f,
  3.24652225e-01f, 5.37081659e-02f, 2.42803305e-01f, -7.01205581e-02f, 1.87207162e-01f, 1.57447696e-01f, 1.25787348e-01f, 2.64308453e-01f, 1.08370006e-01f, 2.13206321e-01f,
  4.08113077e-02f, -3.72859329e-01f, -1.60635054e-01f, 2.21744582e-01f, -7.60648400e-02f, 4.53659803e-01f, -1.67852804e-01f, 3.13524544e-01f, 6.09063208e-02f, -2.11375952e-01f,
  2.09236562e-01f, 2.02707976e-01f, 4.48239923e-01f, -2.60942191e-01f, 5.20103127e-02f, -1.01305537e-01f, -3.39392185e-01f, 2.49249727e-01f, 3.80930394e-01f, -2.44932145e-01f,
  3.70703012e-01f, -1.30318642e-01f, -1.34377116e-02f, 1.43474326e-01f, -9.64699984e-02f, -4.71224710e-02f, 2.29656279e-01f, 2.87472248e-01f, 2.80489810e-02f, 2.77310938e-01f,
  1.02363326e-01f, 4.00663435e-01f, 2.56853849e-01f, -6.38442207e-03f, 3.81454647e-01f, -1.43291757e-01f, 1.38099894e-01f, -3.68043214e-01f, -3.00735921e-01f, -5.02998292e-01f,
  -2.36260056e-01f, -4.62459594e-01f, 3.24637145e-01f, -3.40366483e-01f, -3.86674821e-01f, 5.16205072e-01f, 2.32947785e-02f, 3.00260931e-01f, 3.95186692e-01f, 3.44848782e-01f,
  -4.40951496e-01f, 5.00563443e-01f, 2.66524166e-01f, -8.91031995e-02f, 7.19992742e-02f, 1.75422907e-01f, 2.85378665e-01f, -4.72196192e-01f, 1.71972901e-01f, -2.83262283e-01f,
  -2.58503407e-01f, 4.17997330e-01f, 2.82374144e-01f, 3.84638369e-01f, 2.94848770e-01f, 1.83833420e-01f, -5.46877623e-01f, 8.82946923e-02f, 3.27049047e-01f, 3.33181143e-01f,
  5.07625461e-01f, 1.77212253e-01f, 5.63878790e-02f, 2.42786497e-01f, 4.30667788e-01f, 4.57940660e-02f, 1.96312025e-01f, -2.39504814e-01f, -4.17857468e-01f, 2.09706128e-01f,
  4.11810249e-01f, 9.57303587e-03f, 2.08917066e-01f, 1.01435997e-01f, -1.66866586e-01f, 1.83022842e-01f, 5.90002649e-02f, 8.48155841e-02f, 2.42490873e-01f, 4.44820583e-01f,
  -5.59788831e-02f, 1.16539329e-01f, -9.20190215e-02f, -2.60670602e-01f, 3.69428471e-02f, 2.11683750e-01f, 2.06325486e-01f, 2.56810963e-01f, 4.26063180e-01f, -2.79252827e-01f,
  -4.25297499e-01f, -1.79813821e-02f, 2.92113930e-01f, 1.80105269e-01f, -2.84591287e-01f, 2.42772043e-01f, 2.98306823e-01f, 2.94783503e-01f, -1.70565560e-01f, 2.60017961e-01f,
  -1.37723252e-01f, 3.07030380e-01f, -2.36823440e-01f, -6.55811951e-02f, 8.50303769e-02f, 3.04529876e-01f, 1.19995244e-01f, 2.32189298e-01f, 3.91164809e-01f, 2.92815268e-01f,
  -2.03281060e-01f, 4.45780843e-01f, 3.76799613e-01f, -8.18710700e-02f, 1.47469901e-02f, 3.40988711e-02f, 4.29465562e-01f, 1.86950669e-01f, 1.34197295e-01f, 2.01887801e-01f,
  -1.85704306e-01f, -3.01245481e-01f, 1.00509532e-01f, -2.94288516e-01f, 4.96914864e-01f, 3.95427972e-01f, 1.59209803e-01f, 2.48747900e-01f, -4.44402406e-03f, 3.56620044e-01f,
  -3.03150833e-01f, 1.31002620e-01f, -3.40035200e-01f, 3.61043543e-01f, 5.50173879e-01f, -7.39962682e-02f, 2.44418487e-01f, 4.35287416e-01f, -1.68338075e-01f, 2.00119734e-01f,
  5.88394478e-02f, -2.48460010e-01f, 3.16154718e-01f, 1.68351993e-01f, 2.20900446e-01f, 2.05960810e-01f, 6.31568283e-02f, 6.98766783e-02f, 9.40081924e-02f, -3.19021866e-02f,
  1.54905068e-02f, -5.04174270e-02f, -9.68694538e-02f, 1.82098486e-02f, -3.93263042e-01f, -3.42020482e-01f, 1.95651576e-01f, 3.27169448e-01f, -2.61865091e-02f, -1.82174429e-01f,
  1.49959177e-01f, 6.25381544e-02f, -1.88858777e-01f, -9.41874832e-02f, 6.64538667e-02f, 4.03626889e-01f, 1.31469473e-01f, 4.58265781e-01f, 1.82263285e-01f, 2.27964252e-01f,
  3.95714045e-01f, 6.72030225e-02f, 3.29952151e-01f, 9.29211676e-02f, 3.09950531e-01f, -2.49814808e-01f, 4.59377527e-01f, -1.78417966e-01f, -3.28368545e-01f, 5.05863607e-01f,
  1.99924111e-01f, 3.26990575e-01f, 1.27355725e-01f, -3.81464809e-01f, 1.02894165e-01f, -1.33504614e-01f, -2.85583019e-01f, 4.04538512e-01f, -7.15862215e-02f, -1.89379185e-01f,
  -1.27557904e-01f, -4.02851999e-01f, 1.11577794e-01f, 3.69425297e-01f, 2.28802025e-01f, -7.97594562e-02f, -6.45595640e-02f, 1.71076447e-01f, -3.09612781e-01f, 1.57644778e-01f,
  6.85350969e-02f, -2.77508348e-01f, 2.77955949e-01f, 1.23867609e-01f, 4.98721540e-01f, 1.21168405e-01f, -4.46664780e-01f, 2.98090398e-01f, 3.16101573e-02f, -2.80892640e-01f,
  -1.05381474e-01f, 1.82230156e-02f, 2.97100782e-01f, 4.94786829e-01f, 3.17741334e-01f, -1.34487271e-01f, 6.45128340e-02f, -1.73947774e-02f, -2.09619567e-01f, 2.04701647e-02f,
  -2.16332018e-01f, 1.38055220e-01f, 3.28367978e-01f, -7.50339106e-02f, 2.25111693e-01f, 1.06740721e-01f, 2.42242530e-01f, 1.01300031e-01f, 4.53487217e-01f, 2.46976048e-01f,
  2.74760693e-01f, 1.57846510e-01f, 2.36887991e-01f, 3.81247133e-01f, -2.52840258e-02f, 1.82003289e-01f, 1.14980519e-01f, -2.20623076e-01f, 2.25826710e-01f, -9.71092358e-02f,
  1.89042568e-01f, 2.80163854e-01f, 3.98277432e-01f, 3.51036847e-01f, 1.91927832e-02f, 2.39145122e-02f, 1.49602905e-01f, -3.58398288e-01f, 1.98309943e-02f, -1.50454521e-01f,
  -4.93427068e-01f, 2.38639325e-01f, -1.52322799e-01f, -1.76708892e-01f, 4.68164161e-02f, 1.95782572e-01f, 2.71222025e-01f, 4.02185172e-02f, -1.74925491e-01f, 8.89852829e-03f,
  1.92838609e-02f, 1.10167079e-01f, -3.57200503e-01f, 3.48515093e-01f, 2.30257325e-02f, -3.90246898e-01f, 1.94801867e-01f, 1.21264093e-01f, 4.41054165e-01f, 2.44538069e-01f,
  -3.57887536e-01f, 1.88608095e-01f, 7.33401254e-02f, -1.16355792e-01f, -1.36312559e-01f, -8.08208287e-02f, 3.33255768e-01f, 2.52809197e-01f, 1.86208472e-01f, 2.22776189e-01f,
  -4.79411215e-01f, -1.25700548e-01f, 1.30159244e-01f, -1.01003289e-01f, -1.90109044e-01f, -8.48872364e-02f, 4.17761266e-01f, 5.32492578e-01f, 5.59553921e-01f, 1.07495360e-01f,
  -9.83623713e-02f, -9.07706097e-02f, 2.94286996e-01f, 1.38656467e-01f, 2.59079754e-01f, 1.97061136e-01f, -1.38087898e-01f, -1.56530678e-01f, -2.18977466e-01f, 3.84982944e-01f,
  1.44244894e-01f, -2.28975713e-02f, 3.35984856e-01f, 1.05566055e-01f, -2.41927475e-01f, 4.15358692e-01f, 4.72305745e-01f, 2.43714228e-01f, 3.13710541e-01f, 4.40863431e-01f,
  2.24982381e-01f, -1.46696374e-01f, -4.05423820e-01f, 9.56187323e-02f, -3.03619681e-03f, 2.83965379e-01f, 3.50859314e-01f, 5.98789342e-02f, -3.78977507e-02f, 3.08419764e-01f,
  2.89370149e-01f, 2.02569943e-02f, 1.42165676e-01f, -1.50691289e-02f, 5.01886904e-02f, 1.65451929e-01f, 2.56859422e-01f, 3.14224437e-02f, 3.04374635e-01f, 1.54966071e-01f,
  8.00335184e-02f, 6.10192381e-02f, 4.88085121e-01f, 1.48201793e-01f, -1.40523702e-01f, 3.46227914e-01f, 1.73208565e-01f, 7.88534954e-02f, 2.63394654e-01f, -2.25161552e-01f,
  -1.18213855e-02f, 1.72242314e-01f, 1.42711475e-01f, -2.77303964e-01f, -1.93300888e-01f, 2.22861618e-01f, -1.31095245e-01f, 3.72559041e-01f, 5.95238619e-02f, 3.76944631e-01f,
  -4.77825478e-02f, 6.73055723e-02f, -4.47982503e-03f, 2.93687344e-01f, 5.02074420e-01f, -7.92166367e-02f, 2.38997281e-01f, -4.93943766e-02f, -3.83459002e-01f, 4.50352356e-02f,
  4.01492238e-01f, 7.12541565e-02f, 1.49073854e-01f, -1.59994513e-01f, -1.59117937e-01f, -2.81857491e-01f, 1.21629313e-02f, -2.82782972e-01f, 2.78922528e-01f, 1.47075951e-01f,
  3.10050339e-01f, 2.18318760e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  3.66022557e-01f, 6.28604814e-02f, 1.94510654e-01f, 2.07325652e-01f, 9.41838771e-02f, 1.15822323e-01f, 1.34568557e-01f, 3.31385493e-01f, 3.29971433e-01f, 1.58633143e-01f,
  4.02493954e-01f, -1.43951476e-01f, 2.23175988e-01f, 4.17763561e-01f, -4.14717272e-02f, 2.41281301e-01f, 4.95721072e-01f, 1.24566704e-02f, 3.15790921e-01f, -1.00908265e-01f,
  2.66618520e-01f, 2.55004913e-01f, 1.45211622e-01f, 2.81764507e-01f, 4.42372084e-01f, 2.76831686e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  2.62599826e-01f, 4.60003056e-02f, 1.21523000e-01f, 1.92812771e-01f, -2.83248961e-01f, 7.53628463e-02f, 1.39257550e-01f, 1.25626013e-01f, 5.33164591e-02f, -2.15733320e-01f,
  -1.54684350e-01f, -1.70690551e-01f, -8.69605765e-02f, 2.52588630e-01f, 2.48217564e-02f, 1.51708737e-01f, 1.51923344e-01f, 1.97628766e-01f, -1.29823640e-01f, 2.71473676e-02f,
  -7.39470497e-02f, 1.31314725e-01f, 1.01353861e-01f, -1.56157464e-02f, 2.62420438e-02f, -2.25278273e-01f, -2.30723977e-01f, -6.96257204e-02f, -6.70937225e-02f, -1.68458056e-02f,
  -1.93990953e-02f, -1.44986778e-01f, -1.33366019e-01f, -1.43650264e-01f, -5.02692312e-02f, -8.99214894e-02f, -1.93041991e-02f, -2.38031879e-01f, -3.07133086e-02f, -4.27017398e-02f,
  -5.53849004e-02f, -3.97450365e-02f, 1.28750578e-01f, 1.99311182e-01f, -1.18266977e-01f, 3.00192237e-01f, 1.51307061e-01f, -9.04427320e-02f, -1.82560340e-01f, 2.99123049e-01f,
  -1.04978278e-01f, 1.03167735e-01f, -1.78636804e-01f, -2.25925237e-01f, -2.05803975e-01f, 2.97406048e-01f, -8.16313475e-02f, -1.24446668e-01f, -8.15446451e-02f, 5.11536077e-02f,
  1.12648606e-02f, 1.17393352e-01f, 8.08378160e-02f, -1.74324960e-01f, 1.38085067e-01f, -1.28622860e-01f, -7.11093843e-03f, -9.91534349e-03f, 2.30573729e-01f, 2.26148888e-01f,
  1.01430200e-01f, 1.85469285e-01f, -1.11996889e-01f, 1.30139574e-01f, 6.08901344e-02f, 1.03218649e-02f, -6.70067668e-02f, 1.23490959e-01f, 3.51309702e-02f, -3.30643207e-01f,
  -1.36531070e-01f, -2.74076462e-02f, 1.85131729e-01f, 5.17990179e-02f, 1.64456114e-01f, -2.36824509e-02f, -1.36187822e-01f, -2.90236413e-01f, -1.31223574e-01f, 2.76946992e-01f,
  3.00946534e-02f, 7.39932358e-02f, 2.09445089e-01f, 6.36095703e-02f, -5.03863469e-02f, -9.37159806e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.70602722e-02f, -1.51573241e-01f, -7.57736489e-02f, -2.86537021e-01f, 1.22338302e-01f, -7.92580023e-02f, -1.24628052e-01f, -2.43707597e-01f, -1.00214100e-02f, 2.49378175e-01f,
  -1.31604254e-01f, 1.74868077e-01f, 2.57561803e-01f, 2.51075961e-02f, -1.95758119e-02f, -1.80841550e-01f, -5.22124767e-01f, -1.27772883e-01f, 3.52351040e-01f, 1.63653493e-01f,
  3.51529896e-01f, 2.39433125e-01f, 1.90066785e-01f, -4.58877737e-04f, 1.46571040e-01f, 4.73211378e-01f, 5.07890992e-02f, 2.77226895e-01f, 8.26642513e-02f, 1.10086113e-01f,
  3.09470922e-01f, 2.51579940e-01f, 4.88864541e-01f, 2.78262883e-01f, 2.86554247e-01f, 1.17107250e-01f, 1.99869901e-01f, -8.27013925e-02f, 4.58493531e-01f, -1.60031930e-01f,
  5.54008603e-01f, -3.72629672e-01f, 4.11507547e-01f, 2.26505399e-01f, 7.30106011e-02f, 3.61331016e-01f, 1.53228134e-01f, 2.08751127e-01f, 6.34589434e-01f, 3.22364718e-01f,
  -2.01379642e-01f, -2.35486373e-01f, -3.46897990e-01f, -4.60020900e-02f, 5.41004896e-01f, 3.18706751e-01f, 4.06268001e-01f, -2.48348102e-01f, 1.11302257e-01f, -2.55772263e-01f,
  -8.55272040e-02f, 1.29910305e-01f, 2.80888993e-02f, -4.69532698e-01f, 3.89548212e-01f, -6.82181166e-03f, 1.06114894e-01f, 5.05804569e-02f, 1.56143323e-01f, -3.34879458e-02f,
  2.06635177e-01f, -3.36979851e-02f, 4.18060660e-01f, -3.57172966e-01f, 2.69801438e-01f, 5.04654586e-01f, -3.71019095e-01f, 5.50238371e-01f, 5.53575382e-02f, -5.05662300e-02f,
  2.36895382e-01f, -1.22512311e-01f, 2.13288024e-01f, 4.18435991e-01f, -2.47926578e-01f, -2.11229756e-01f, 3.21004480e-01f, 1.66076213e-01f, -2.19664909e-03f, -3.66067499e-01f,
  3.38385075e-01f, 2.02478036e-01f, 3.97738695e-01f, 5.47408700e-01f, 4.61283833e-01f, -2.78817475e-01f, 1.12600781e-01f, 1.57614559e-01f, 1.97502345e-01f, -3.70843977e-01f,
  -2.43936077e-01f, 3.47857922e-01f, -1.54476926e-01f, 4.78923559e-01f, -3.07768671e-04f, -7.89891630e-02f, 1.86793789e-01f, 3.74878079e-01f, 4.23606426e-01f, -5.20231836e-02f,
  -1.02234147e-01f, 2.06706375e-01f, 2.20688328e-01f, -1.29983112e-01f, 3.42144907e-01f, 4.36765030e-02f, 2.53895193e-01f, -2.55773246e-01f, 1.25976056e-01f, -5.34641519e-02f,
  -3.64006102e-01f, -2.76820689e-01f, 2.03730583e-01f, 1.18907742e-01f, 2.17669934e-01f, 2.42952049e-01f, 9.59448069e-02f, 3.03742468e-01f, 2.42965609e-01f, 3.41798425e-01f,
  1.92251042e-01f, 2.70335019e-01f, -4.48705077e-01f, 5.03929317e-01f, 1.53552711e-01f, 7.35311285e-02f, 3.02238345e-01f, 1.79945797e-01f, -2.39826396e-01f, 8.21727514e-02f,
  1.95126310e-01f, 4.17238712e-01f, -1.84250042e-01f, 2.10012764e-01f, 2.53581375e-01f, -2.84563363e-01f, -1.67524830e-01f, 2.15643466e-01f, -3.25975597e-01f, 2.97157645e-01f,
  2.94331014e-01f, 2.12642970e-03f, 5.23127496e-01f, 2.01590657e-01f, -3.01132023e-01f, 3.52435976e-01f, -3.37318331e-01f, 4.87597793e-01f, 2.45341063e-01f, 7.46644884e-02f,
  7.78575093e-02f, 1.12428255e-01f, 3.80523168e-02f, -2.82468468e-01f, 2.39973795e-02f, 9.93572399e-02f, -2.92896211e-01f, 2.55131334e-01f, 1.71511605e-01f, 1.50507793e-01f,
  -2.07460672e-01f, -1.44506991e-02f, 1.95834905e-01f, 3.87495548e-01f, -1.71854287e-01f, 5.63489974e-01f, 3.23165238e-01f, -3.08806691e-02f, -5.23926377e-01f, -1.28712475e-01f,
  2.51584034e-03f, -3.27095866e-01f, 4.90539163e-01f, 1.10110909e-01f, 4.22510475e-01f, -1.95571240e-02f, -4.98530120e-01f, 1.88303694e-01f, -2.17107520e-01f, 4.66083914e-01f,
  1.76824033e-01f, 1.56589709e-02f, -3.42144966e-01f, 1.36858046e-01f, 2.50495851e-01f, 3.29990417e-01f, 3.27782512e-01f, -3.40548098e-01f, 4.55850065e-01f, 1.80156589e-01f,
  -3.46122235e-01f, -2.12732106e-02f, 1.21127479e-01f, -2.17206791e-01f, -2.26968735e-01f, -3.61632913e-01f, 4.23103899e-01f, -6.72467351e-02f, 1.29446507e-01f, -9.31276977e-02f,
  4.27547723e-01f, 4.99488205e-01f, 8.45934227e-02f, 5.16430020e-01f, -3.67259204e-01f, 1.38427556e-01f, -3.64458203e-01f, -8.06615576e-02f, 9.81309339e-02f, 1.55961365e-01f,
  -9.80674569e-03f, -3.60112607e-01f, 1.25708073e-01f, 4.41392332e-01f, -3.20088208e-01f, -3.40920538e-01f, -1.90701112e-01f, -2.11322367e-01f, 3.72834086e-01f, 1.04421392e-01f,
  -1.76386222e-01f, -3.13191950e-01f, 2.68643826e-01f, 1.05496049e-01f, 3.38769972e-01f, 4.22412008e-01f, 2.26412803e-01f, 2.66165644e-01f, 1.23628020e-01f, -2.10862011e-01f,
  -1.84441566e-01f, 1.68743491e-01f, 4.19397175e-01f, -3.41542698e-02f, 1.44619480e-01f, 6.47860765e-02f, -4.03704448e-03f, 3.66295129e-01f, 2.44424358e-01f, 6.51965141e-01f,
  2.99001545e-01f, 6.14273213e-02f, 3.96189660e-01f, 2.51402203e-02f, 2.45650306e-01f, 1.37548577e-02f, 2.91577011e-01f, 9.74323601e-02f, 2.38111094e-01f, 4.34149325e-01f,
  2.19071403e-01f, -1.96788430e-01f, 5.16157806e-01f, -5.14998674e-01f, 2.02105373e-01f, 2.21459821e-01f, 1.22698069e-01f, -6.63688481e-02f, -4.09586072e-01f, -3.00269723e-02f,
  2.60874271e-01f, -1.42751798e-01f, 4.68138129e-01f, 3.15744668e-01f, 1.93618909e-02f, 1.96469411e-01f, -3.97987396e-01f, 3.02053511e-01f, 2.53453016e-01f, 2.70513564e-01f,
  4.86431926e-01f, -3.92865017e-02f, 1.66781917e-01f, 2.46263161e-01f, -7.57549191e-03f, -2.80872345e-01f, 1.57965928e-01f, -1.16057612e-01f, 3.29925388e-01f, 1.20554887e-01f,
  2.56032467e-01f, -2.78141320e-01f, 9.34390575e-02f, 4.56322342e-01f, -3.05991042e-02f, -7.97347054e-02f, 1.71508223e-01f, -1.26062445e-02f, -1.66316390e-01f, 2.18880877e-01f,
  2.88838327e-01f, 1.31764352e-01f, -1.83565721e-01f, -2.17912510e-01f, -5.40849745e-01f, -3.64480287e-01f, 3.10863733e-01f, 1.99855745e-01f, 3.72557849e-01f, 2.69279301e-01f,
  4.15035747e-02f, -2.26335619e-02f, -1.47953972e-01f, 6.14967085e-02f, 8.06679204e-02f, 1.47387505e-01f, -2.70959381e-02f, 3.58462512e-01f, -1.83671135e-02f, -1.19362958e-02f,
  2.05965936e-01f, -8.98726135e-02f, 2.87134759e-02f, -4.66792472e-02f, -2.87511826e-01f, 1.21820666e-01f, 2.24632770e-01f, 6.31599903e-01f, -3.53523701e-01f, 1.01518393e-01f,
  -2.92851239e-01f, 8.14593509e-02f, 2.21242100e-01f, -8.09082836e-02f, -1.92194358e-02f, 5.85139036e-01f, 1.67819068e-01f, -2.74374157e-01f, -1.33373931e-01f, 2.61130601e-01f,
  1.87971249e-01f, -3.98627311e-01f, 3.34677361e-02f, -2.11804301e-01f, -1.22612007e-01f, -3.39329958e-01f, -2.03737587e-01f, 1.86819315e-01f, -8.83375406e-02f, 1.92735255e-01f,
  2.04490378e-01f, 2.44500190e-01f, -9.78117660e-02f, 3.92620444e-01f, -1.47087425e-01f, 4.28371578e-01f, 1.20476417e-01f, -4.36991692e-01f, 4.98948604e-01f, -4.22492981e-01f,
  1.44964352e-01f, 3.52610558e-01f, 1.92989662e-01f, -1.76560372e-01f, 2.50945121e-01f, -5.09034656e-02f, 4.35907960e-01f, -1.28014773e-01f, 3.28328490e-01f, 4.83814567e-01f,
  2.42835909e-01f, 2.01452807e-01f, 8.83418098e-02f, 5.17222762e-01f, -1.68907523e-01f, 4.80493456e-01f, 4.98518527e-01f, 3.89078230e-01f, 1.51465133e-01f, 1.16589405e-01f,
  -3.13950330e-03f, -4.18444365e-01f, -1.39053583e-01f, 1.95519961e-02f, -3.83299887e-01f, -3.48877430e-01f, -3.95791918e-01f, -1.19002007e-01f, 3.67894918e-01f, -4.54147756e-01f,
  -1.30728126e-01f, -1.47501871e-01f, 3.73633541e-02f, 1.13793775e-01f, 1.63745254e-01f, 4.12745744e-01f, 1.40500041e-02f, 1.73612505e-01f, 2.63298780e-01f, 9.97798443e-02f,
  -1.84987411e-01f, 3.18574041e-01f, 2.16748387e-01f, 1.02682915e-02f, 4.66112494e-02f, -1.29908130e-01f, 2.39835098e-01f, 4.83962566e-01f, 3.62119526e-02f, 2.42800653e-01f,
  4.43648726e-01f, 1.07967062e-02f, 4.37884390e-01f, -1.01312578e-01f, 3.35917830e-01f, 2.14590179e-03f, 5.96358925e-02f, 2.44251400e-01f, 9.29070860e-02f, -4.12597731e-02f,
  2.64411986e-01f, 2.21233398e-01f, -4.84015420e-02f, 1.65876951e-02f, -1.02625052e-02f, 2.79362887e-01f, -3.63080829e-01f, 2.32518837e-01f, -2.16265887e-01f, 4.54332173e-01f,
  -5.23473769e-02f, -1.29933253e-01f, -5.68358839e-01f, -2.76601136e-01f, -2.82022543e-02f, 3.25634032e-01f, 1.72236830e-01f, 8.83807316e-02f, -7.48952990e-03f, 6.11160286e-02f,
  3.26402262e-02f, -9.34800059e-02f, -8.23729783e-02f, 4.12708610e-01f, -2.96613544e-01f, 3.82824153e-01f, 1.84283569e-01f, 9.40973908e-02f, 3.60884577e-01f, 1.17698029e-01f,
  3.10995758e-01f, -3.86822313e-01f, -7.65823871e-02f, 3.59492540e-01f, -6.29295707e-02f, 7.70132244e-02f, 3.56439203e-01f, -1.28602192e-01f, -7.30835199e-02f, 3.50341380e-01f,
  1.71481922e-01f, 1.91309825e-01f, -1.36732399e-01f, -3.15422863e-02f, 7.71787614e-02f, -4.23710614e-01f, 3.38452786e-01f, -2.72665292e-01f, 2.74976343e-01f, -1.51617840e-01f,
  3.76014262e-01f, -1.69783041e-01f, -1.93579584e-01f, -3.87040675e-01f, 3.53642702e-01f, 7.94351324e-02f, 1.91595167e-01f, -4.29900847e-02f, 1.90163642e-01f, 2.17524424e-01f,
  1.85426250e-01f, 3.01273227e-01f, -2.51533519e-02f, -3.64343196e-01f, -4.23924178e-02f, 1.56783193e-01f, 1.64183021e-01f, 3.92770857e-01f, 3.40862647e-02f, -2.60988548e-02f,
  -4.22280505e-02f, -1.33066714e-01f, 2.34510854e-01f, -2.19161034e-01f, 6.68678135e-02f, 4.26384896e-01f, 4.63072538e-01f, 2.74374366e-01f, 6.39216453e-02f, -3.08330953e-01f,
  2.11002365e-01f, -6.04174674e-01f, 4.10596132e-01f, -1.64357796e-02f, 1.28205381e-02f, -4.95496780e-01f, 4.33644690e-02f, 9.35845748e-02f, -3.10340643e-01f, -6.16534725e-02f,
  3.41788471e-01f, 1.96599007e-01f, -4.67113629e-02f, -2.15500534e-01f, -5.28212637e-02f, -2.37964258e-01f, -1.33177280e-01f, 5.96634783e-02f, -1.68243293e-02f, 3.83346349e-01f,
  -1.16948366e-01f, 1.68146312e-01f, 3.12129054e-02f, 2.92450815e-01f, 2.94285059e-01f, 2.79103935e-01f, 3.05621214e-02f, 2.05720067e-01f, -4.01526928e-01f, -3.09709370e-01f,
  -2.96143651e-01f, -1.60943076e-01f, 1.23221129e-01f, -1.75813720e-01f, 2.83106863e-01f, 7.91015700e-02f, 1.34364992e-01f, -7.06251850e-03f, -2.67194271e-01f, 3.54004413e-01f,
  1.35279745e-01f, 3.89118105e-01f, 1.02974653e-01f, 2.26937324e-01f, 3.08104992e-01f, 2.66766489e-01f, 2.31356412e-01f, 3.31235602e-02f, 4.08757240e-01f, 1.81266800e-01f,
  7.64096901e-02f, -3.05936098e-01f, 2.75446087e-01f, 3.49637151e-01f, -8.63310993e-02f, 1.23715073e-01f, 7.97575116e-02f, -1.25155568e-01f, -4.86805104e-03f, -5.18736124e-01f,
  -3.30227554e-01f, -4.67183948e-01f, 2.16150075e-01f, 4.67169017e-01f, 4.81571406e-02f, 5.99611938e-01f, 7.82300308e-02f, -4.06348705e-02f, 2.71891057e-01f, 6.81070805e-01f,
  3.40103239e-01f, 3.99909467e-01f, 1.60887659e-01f, -2.25851759e-02f, -1.26395309e-02f, 2.80487001e-01f, -2.45086402e-01f, -9.25126672e-02f, -1.63153127e-01f, 2.07821447e-02f,
  1.03071585e-01f, 1.77034974e-01f, 2.74926543e-01f, 3.48924905e-01f, -5.53225815e-01f, 4.09662962e-01f, -2.48215839e-01f, -2.14915842e-01f, 6.37228116e-02f, -1.82056591e-01f,
  -2.39838269e-02f, 1.82095170e-01f, -2.21193686e-01f, -2.97457159e-01f, -6.06678464e-02f, 3.18210900e-01f, 2.55267888e-01f, -2.63569444e-01f, -2.78401941e-01f, -4.50172387e-02f,
  1.38153704e-02f, -8.16941112e-02f, -2.53121164e-02f, 4.96942639e-01f, -2.13321179e-01f, 1.42874107e-01f, 4.68937643e-02f, 5.00734329e-01f, -7.73833916e-02f, -3.25249404e-01f,
  6.78933738e-03f, -1.94116592e-01f, 5.02956390e-01f, -3.68342280e-01f, 2.74398088e-01f, -2.28287606e-03f, 1.96373016e-01f, -6.17358238e-02f, 2.47603223e-01f, 1.50330842e-01f,
  -3.19923788e-01f, 8.01024586e-02f, -1.12835720e-01f, 1.32875955e-02f, 1.79403707e-01f, 3.15985143e-01f, 3.05384040e-01f, -2.50860155e-02f, 5.52620878e-03f, -4.25170124e-01f,
  2.50080734e-01f, 4.29351836e-01f, 1.66499004e-01f, -4.41354327e-02f, 5.12010038e-01f, -3.88624705e-02f, 1.85025975e-01f, -2.48273119e-01f, 4.40651327e-01f, 3.66747409e-01f,
  1.94266722e-01f, 5.70216924e-02f, 2.00422630e-02f, -3.75723928e-01f, -1.10449769e-01f, -7.21669495e-02f, -1.53324112e-01f, 1.26810089e-01f, -3.09419990e-01f, 2.00807452e-01f,
  -3.17786247e-01f, -1.65868625e-01f, 3.61997217e-01f, -4.46125627e-01f, -4.41761799e-02f, 3.50177437e-01f, 3.16442519e-01f, -1.34908527e-01f, 2.00211242e-01f, -2.60789424e-01f,
  3.29507977e-01f, -4.93550509e-01f, 4.11288828e-01f, -1.69710845e-01f, 1.75342470e-01f, -4.16312993e-01f, -3.49184535e-02f, 1.06324218e-01f, -3.27058762e-01f, -1.15330920e-01f,
  3.41948420e-01f, 4.79767114e-01f, 5.01660228e-01f, 5.27533233e-01f, 5.60944736e-01f, 2.45151147e-01f, -2.43192598e-01f, 3.66870701e-01f, 1.28557593e-01f, 1.22845419e-01f,
  1.38014965e-02f, 2.61713527e-02f, -2.64561534e-01f, 2.15255152e-02f, 2.69035131e-01f, -1.29268467e-01f, 3.34730476e-01f, -1.50957868e-01f, 2.96832651e-01f, -3.32023114e-01f,
  8.95091593e-02f, 4.01972502e-01f, 1.98723570e-01f, 4.76560712e-01f, 1.97925583e-01f, -2.89544016e-01f, 2.26203427e-01f, -1.57805517e-01f, -1.56951770e-01f, 3.11800629e-01f,
  -3.12867045e-01f, -5.42679615e-02f, 1.03849858e-01f, -8.53568465e-02f, -1.00872897e-01f, -1.24058485e-01f, 2.26516664e-01f, -4.35302764e-01f, 2.30703622e-01f, 1.63982362e-01f,
  -3.42349529e-01f, -8.10140669e-02f, 7.47484192e-02f, 3.68198395e-01f, -3.11240926e-03f, 2.33844742e-01f, 2.85114735e-01f, 6.44069910e-02f, -2.72860944e-01f, 5.10145009e-01f,
  -2.09119052e-01f, -4.10832688e-02f, 1.71991810e-01f, -3.73130292e-01f, 2.97982872e-01f, 2.91889012e-02f, 4.97464001e-01f, 2.70235837e-01f, 2.25750357e-01f, 2.37464294e-01f,
  -1.60821006e-01f, -3.39178778e-02f, -1.90661728e-01f, 3.26680660e-01f, 3.76192451e-01f, 2.22062871e-01f, 1.56626597e-01f, 3.08477521e-01f, 1.84299096e-01f, 3.49835992e-01f,
  -1.34086862e-01f, 8.13578218e-02f, 3.35407048e-01f, -4.44968045e-02f, -1.41291440e-01f, -1.14074878e-01f, 3.22770000e-01f, 2.98454821e-01f, 5.01995496e-02f, -8.52283761e-02f,
  4.43489581e-01f, -3.44212711e-01f, 7.03419596e-02f, -2.87590265e-01f, 3.73073846e-01f, 5.79417467e-01f, 2.64369816e-01f, 6.14684880e-01f, -3.64618629e-01f, 2.18480289e-01f,
  -3.10109913e-01f, 1.68004632e-01f, 3.45952630e-01f, 1.64595649e-01f, 4.57422078e-01f, 9.50173587e-02f, -1.11006737e-01f, 1.72703102e-01f, -3.15163523e-01f, 5.62796853e-02f,
  7.04303011e-02f, 1.15597799e-01f, -3.13533127e-01f, 1.54829361e-02f, 2.91599154e-01f, 3.00884128e-01f, -6.76271439e-01f, 4.22217846e-01f, -2.18646795e-01f, -9.46347862e-02f,
  3.01268727e-01f, -3.36620450e-01f, 4.18173969e-01f, 3.19951385e-01f, 2.03498334e-01f, -1.11775756e-01f, 7.95179382e-02f, 2.28125885e-01f, 3.21034700e-01f, 2.87479699e-01f,
  -1.92805082e-01f, 5.06747738e-02f, 3.88881974e-02f, 2.77529657e-01f, -1.96414158e-01f, 3.18525076e-01f, -7.94673264e-02f, 1.83145516e-02f, -1.19024105e-01f, 3.91805768e-01f,
  3.58688757e-02f, -2.17446715e-01f, 2.82776151e-02f, -4.94414896e-01f, 8.57558176e-02f, -3.60690057e-02f, 2.48081848e-01f, 2.79700756e-01f, 5.75258993e-02f, 1.50398880e-01f,
  3.54192019e-01f, 4.00081336e-01f, 7.23316800e-03f, -2.44263098e-01f, -1.18824363e-01f, 1.37870729e-01f, 2.80755103e-01f, -1.50233313e-01f, 5.11408091e-01f, -4.84296307e-02f,
  3.22714269e-01f, -2.84268230e-01f, 2.91365713e-01f, -2.87036300e-02f, -3.14925879e-01f, -2.28795812e-01f, 3.87254864e-01f, -2.77189445e-02f, 3.53255868e-01f, -2.02976465e-01f,
  4.13391650e-01f, 2.23528057e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  8.42220783e-02f, 4.03757900e-01f, 2.66742557e-01f, 1.43018603e-01f, 3.76175344e-01f, 1.26660228e-01f, 7.81571269e-02f, 2.10023522e-02f, 2.91614801e-01f, 2.44126201e-01f,
  1.97492927e-01f, 3.10451295e-02f, -1.34826183e-01f, 1.14893287e-01f, -8.19916353e-02f, 4.45305221e-02f, -1.10294804e-01f, 1.39746917e-02f, 8.97763595e-02f, 1.53333858e-01f,
  4.02374286e-03f, 4.32702512e-01f, -2.84691453e-02f, 2.50872463e-01f, 5.35319224e-02f, -3.02995089e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  1.19007930e-01f, -2.64070511e-01f, -1.70551568e-01f, 1.55423999e-01f, 2.88410217e-01f, -1.22777648e-01f, 5.78077920e-02f, 1.52933136e-01f, 1.97392896e-01f, 6.24309778e-02f,
  -5.01433238e-02f, 2.58983850e-01f, -1.30455986e-01f, 2.18763292e-01f, -4.19956475e-01f, -6.06424659e-02f, -2.16898695e-01f, -3.27072501e-01f, 2.87892789e-01f, 1.48616105e-01f,
  1.76811427e-01f, -2.05105796e-01f, 2.94066876e-01f, -3.62614572e-01f, -3.01312059e-01f, -6.17142469e-02f, -3.71455848e-01f, -6.64066017e-01f, 2.82548964e-01f, -4.80047584e-01f,
  -2.29203001e-01f, -1.25044271e-01f, 9.88985598e-02f, -2.24351212e-02f, -1.19727746e-01f, -2.07862005e-01f, 5.80436513e-02f, 1.55389205e-01f, 3.05538606e-02f, -8.22163075e-02f,
  2.21874088e-01f, 3.02255988e-01f, -2.04726234e-01f, -4.61084217e-01f, -4.84769940e-01f, 2.61009037e-01f, 2.59901844e-02f, 2.76905239e-01f, -3.26344073e-01f, -2.26662323e-01f,
  1.00554705e-01f, -2.09442407e-01f, 2.35083133e-01f, -4.88271058e-01f, -1.66910499e-01f, 2.13252470e-01f, -2.25985885e-01f, 1.12945013e-01f, -1.14176176e-01f, -2.54269123e-01f,
  -5.34839518e-02f, 2.46935278e-01f, -4.84546244e-01f, 3.43560576e-01f, -2.15943828e-02f, -6.63013803e-03f, -1.14137873e-01f, -3.36303532e-01f, -1.93166418e-03f, 4.10854399e-01f,
  -2.89223380e-02f, -2.40136087e-01f, 1.93376631e-01f, -2.62361020e-01f, -6.17024958e-01f, -1.11946188e-01f, 4.62833047e-01f, 2.97246993e-01f, 1.04486696e-01f, -3.32721502e-01f,
  -8.46457202e-03f, 1.50372297e-01f, 2.55416214e-01f, -5.23713529e-01f, -4.50858384e-01f, 8.68172571e-03f, -3.81409585e-01f, 3.48355509e-02f, -1.02607504e-01f, 1.73135504e-01f,
  -1.58941329e-01f, -4.13644344e-01f, -4.23139155e-01f, 3.15841436e-01f, -3.28788604e-03f, 1.85298756e-01f, 2.13625610e-01f, 5.42167947e-02f, 2.78937668e-02f, -1.70555562e-01f,
  -2.87181884e-01f, -1.43220454e-01f, -2.90763732e-02f, -5.31002283e-01f, -6.89227104e-01f, 2.01521009e-01f, 7.94149376e-03f, 2.61059314e-01f, -5.48423231e-01f, -5.12490213e-01f,
  -3.27164829e-01f, -4.75645177e-02f, 1.84264392e-01f, -3.63042712e-01f, -3.26993197e-01f, -1.13080144e-01f, -1.00173973e-01f, 3.15175384e-01f, 2.99886376e-01f, -4.55512971e-01f,
  2.08608583e-01f, -3.00992876e-01f, 3.01208407e-01f, -2.27187332e-02f, 2.01822072e-01f, -4.67780024e-01f, 3.41536850e-01f, 7.94902667e-02f, -4.15995829e-02f, 1.90557629e-01f,
  -5.33375293e-02f, 1.03948914e-01f, -3.72643888e-01f, -2.26524115e-01f, -3.42761964e-01f, 3.21157366e-01f, 8.10634568e-02f, 2.04594359e-01f, 3.17286611e-01f, 1.91676423e-01f,
  -3.91500473e-01f, -4.46913332e-01f, -7.93340355e-02f, -8.96725431e-02f, 2.05369458e-01f, -3.59812886e-01f, -3.78457963e-01f, -3.83299738e-01f, 2.17504323e-01f, 3.03984344e-01f,
  -7.10195228e-02f, -5.04195452e-01f, -3.72455269e-01f, -1.62193269e-01f, 1.29165560e-01f, 3.47992122e-01f, 6.32759258e-02f, -5.34427278e-02f, -2.38227352e-01f, 6.96271583e-02f,
  3.02742690e-01f, 2.41738766e-01f, 2.80498803e-01f, 1.22706391e-01f, -4.32701083e-03f, -8.16438533e-03f, 2.14999765e-01f, 1.39001906e-01f, 1.12578690e-01f, -3.56180578e-01f,
  2.71518707e-01f, 1.70028627e-01f, -5.32550514e-01f, -9.43586379e-02f, 1.98612094e-01f, 1.35538012e-01f, -4.75568712e-01f, -1.46564394e-01f, -2.71651149e-01f, 3.75922292e-01f,
  -8.66099820e-02f, -4.57474351e-01f, 2.84503959e-02f, 4.03565615e-01f, -4.54274982e-01f, -2.28191197e-01f, -3.46359193e-01f, 3.48843992e-01f, 9.75975618e-02f, -1.70195192e-01f,
  -4.42523450e-01f, -6.43431127e-01f, 8.99413824e-02f, 2.36859545e-01f, 1.66134402e-01f, 4.11636025e-01f, 9.11330525e-03f, -9.64398012e-02f, -4.94336963e-01f, 2.03683108e-01f,
  -5.88459894e-03f, -4.11460191e-01f, -9.93223563e-02f, -5.15359521e-01f, 4.50564414e-01f, -3.20082784e-01f, 3.20089400e-01f, -2.77179688e-01f, -3.34604353e-01f, 2.96794564e-01f,
  -1.68153316e-01f, -3.31249475e-01f, -3.20551544e-01f, -5.18599391e-01f, -3.03236961e-01f, 7.60924295e-02f, -3.53367656e-01f, -1.90973535e-01f, -6.44164979e-02f, 4.46370840e-01f,
  -3.62017989e-01f, 3.60175639e-01f, 1.60376757e-01f, -5.81973732e-01f, -1.79969415e-01f, 1.09707214e-01f, -1.19359173e-01f, -2.82730401e-01f, 1.25338838e-01f, 8.96347966e-03f,
  2.35682607e-01f, -3.83289784e-01f, -3.76261920e-01f, -4.01670843e-01f, -2.64604464e-02f, 1.87478632e-01f, 2.14623399e-02f, 1.35165513e-01f, 2.34702811e-01f, -3.31514180e-01f,
  5.44119347e-03f, 8.10691416e-02f, 2.20472381e-01f, 5.37879318e-02f, -4.24852282e-01f, -1.81896925e-01f, 1.72587276e-01f, 1.97239712e-01f, 2.33449027e-01f, 1.09280765e-01f,
  1.65690675e-01f, -3.01320463e-01f, 2.62903124e-01f, -3.19429517e-01f, 1.25508919e-01f, -8.91596265e-03f, 7.34999999e-02f, -2.20912576e-01f, -2.28100583e-01f, -2.00705692e-01f,
  -1.97035894e-01f, 2.14368939e-01f, 2.47783139e-01f, -4.82147336e-01f, -3.93046141e-01f, 1.59363717e-01f, -5.82989603e-02f, -2.50700712e-01f, 8.73975083e-03f, 1.76438764e-01f,
  -4.58059013e-01f, 2.88863808e-01f, -3.50440703e-02f, 2.92073071e-01f, 1.27062332e-02f, -1.33105889e-01f, 5.41256042e-03f, -4.11257714e-01f, -1.85426235e-01f, 2.97292590e-01f,
  -2.98860613e-02f, -4.62230057e-01f, -1.58381000e-01f, 1.28817827e-01f, -8.58569816e-02f, 2.19872579e-01f, 4.03517306e-01f, -1.03231937e-01f, 1.92988047e-03f, 5.94615899e-02f,
  -1.80424809e-01f, 1.61753953e-01f, 4.16979820e-01f, -7.28132948e-02f, -2.97117651e-01f, 3.26552689e-01f, 1.50214329e-01f, -4.21434790e-01f, -6.26845956e-02f, 3.67086455e-02f,
  -3.20901006e-01f, 8.12503844e-02f, 3.30048591e-01f, -2.32410058e-01f, -2.55215645e-01f, 3.37489128e-01f, 2.04501107e-01f, -1.72484010e-01f, -4.19470161e-01f, 2.05880195e-01f,
  -3.45782608e-01f, -4.43976939e-01f, 7.29006808e-03f, 3.99875134e-01f, -3.13331574e-01f, -4.68219101e-01f, -2.72306412e-01f, -1.83050424e-01f, -2.47643769e-01f, -1.74403518e-01f,
  -8.86485726e-02f, -1.12005517e-01f, -1.04400210e-01f, -2.47188255e-01f, -1.14698775e-01f, 3.20317596e-01f, 2.03821287e-01f, -2.47593641e-01f, -2.56641984e-01f, 2.11200729e-01f,
  -5.33415675e-01f, -2.13472337e-01f, 5.58908880e-01f, -3.32476199e-01f, -2.78015465e-01f, 1.11199081e-01f, 6.52392805e-02f, -3.01235527e-01f, -1.11537233e-01f, 2.03746378e-01f,
  2.83043087e-01f, 2.29283720e-01f, -2.80797649e-02f, 9.58430022e-02f, 1.53729007e-01f, 1.99286491e-01f, 1.93623170e-01f, 2.17110798e-01f, -2.79988572e-02f, -1.37164816e-01f,
  6.11050613e-02f, 3.08728486e-01f, -8.66373107e-02f, 2.07932189e-01f, 4.88889590e-02f, 1.38156572e-02f, 2.36592606e-01f, 3.96537364e-01f, -9.40632895e-02f, -4.84802961e-01f,
  2.90938705e-01f, 1.67686358e-01f, 3.24651629e-01f, 5.42325340e-02f, -9.03156549e-02f, -4.52308625e-01f, -2.79515117e-01f, 8.15904438e-02f, 2.69887626e-01f, -2.66636789e-01f,
  -3.51140916e-01f, 3.39968741e-01f, -2.54752368e-01f, -2.69757867e-01f, 2.72463620e-01f, -1.50825560e-01f, 3.11800808e-01f, -4.52049166e-01f, -2.90095180e-01f, 7.62704238e-02f,
  -3.72231096e-01f, 1.58934206e-01f, 1.59597382e-01f, -1.34883195e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.19733110e-01f, 1.43832788e-01f, -2.07217544e-01f, -2.73443684e-02f, 1.79311633e-01f, -4.09948491e-02f, 2.09937528e-01f, 5.88879138e-02f, 8.59248042e-02f, 9.77322087e-02f,
  -1.93878382e-01f, 1.84818521e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    