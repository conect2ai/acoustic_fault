/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.65295720e-01f, 2.39983704e-02f, 1.11033432e-01f, -3.61743830e-02f, -2.01375852e-03f, -2.31889024e-01f, -2.40613475e-01f, 1.65635303e-01f, -9.70638320e-02f, 2.20678933e-02f,
  -2.56895274e-01f, -5.21173924e-02f, -6.46698028e-02f, -2.32247829e-01f, -3.07183623e-01f, -1.30725771e-01f, -9.14490297e-02f, -1.33812398e-01f, 6.53304011e-02f, -6.55326201e-03f,
  3.03436220e-02f, -3.20685953e-02f, 1.52356729e-01f, 1.46854013e-01f, 6.46157935e-02f, 3.24830949e-01f, 1.54425442e-01f, 1.43009111e-01f, 7.01073185e-02f, -1.26932319e-02f,
  -7.63439760e-02f, -1.04812406e-01f, 7.62122571e-02f, 2.46947948e-02f, -1.23195667e-02f, 1.24224089e-02f, -1.03131970e-02f, 4.10368033e-02f, -2.31423695e-02f, 1.24573112e-01f,
  2.47535389e-02f, 1.08641768e-02f, 6.60088062e-02f, 1.16650881e-02f, 1.23776458e-02f, 1.17652863e-02f, 2.76449304e-02f, -5.13707884e-02f, 1.70317125e-02f, 1.18491966e-02f,
  -1.96260400e-03f, 2.93322634e-02f, -1.50670381e-02f, 1.09525539e-01f, 1.41255825e-03f, -4.04818542e-02f, 4.70854826e-02f, -1.25796162e-02f, -4.54734415e-02f, 4.18171473e-02f,
  1.71259101e-02f, 5.38026281e-02f, 7.65540823e-02f, 9.20690894e-02f, -1.23484340e-02f, -2.35265773e-02f, 5.58575466e-02f, -2.13664956e-02f, 6.42400309e-02f, -7.89096653e-02f,
  -1.35980649e-02f, 2.21276823e-02f, -3.57154608e-02f, -4.13606055e-02f, 7.94889554e-02f, 3.47488970e-02f, 8.17816630e-02f, 1.30701512e-02f, 7.06952205e-03f, 1.12591122e-04f,
  5.81523497e-03f, -4.54401001e-02f, 9.01170373e-02f, 5.20603992e-02f, 1.79955363e-02f, 8.47733095e-02f, -3.34482305e-02f, -2.24132929e-03f, 4.87395898e-02f, -9.27454908e-04f,
  -1.41446665e-01f, 9.89530310e-02f, 4.06604372e-02f, -9.38244462e-02f, -2.94455774e-02f, -7.69588947e-02f, 3.35294604e-02f, -5.91320321e-02f, 4.36235480e-02f, -2.14208085e-02f,
  3.15637439e-02f, 3.96963134e-02f, 8.93649980e-02f, 1.60733834e-02f, -3.34993340e-02f, 2.96235196e-02f, -4.88870665e-02f, -1.05589582e-02f, -2.17795651e-03f, -1.20368982e-02f,
  4.98038568e-02f, 2.94379517e-02f, 1.84865389e-02f, 7.62854815e-02f, 1.75065398e-02f, 4.64697694e-03f, -2.14908980e-02f, -1.97946932e-02f, 2.79837549e-02f, -1.06233032e-02f,
  -6.84564859e-02f, -2.72767603e-01f, 1.09970145e-01f, -1.33310065e-01f, 2.74682883e-02f, 1.30686343e-01f, 1.39925256e-01f, -1.17794849e-01f, -1.34621739e-01f, -5.10742282e-03f,
  4.86805029e-02f, -1.63287316e-02f, -5.33208027e-02f, 5.53417094e-02f, -1.42975440e-02f, -5.54879643e-02f, 2.12167874e-02f, 7.01317340e-02f, -1.21091671e-01f, -1.54982686e-01f,
  -5.94604500e-02f, -4.60818149e-02f, 6.43154532e-02f, -1.35818332e-01f, -4.05204967e-02f, -9.58911180e-02f, -3.01072039e-02f, 8.57665297e-03f, 6.85574636e-02f, 1.80671901e-01f,
  -1.28060028e-01f, -2.17109565e-02f, 2.53927968e-02f, -8.69123079e-03f, -1.03855036e-01f, -3.08538061e-02f, -4.81307879e-02f, 1.93600088e-01f, 5.50464056e-02f, 1.19609404e-02f,
  1.53255910e-02f, -1.94996707e-02f, 6.84802309e-02f, 1.80177502e-02f, -1.07236095e-02f, -4.81109731e-02f, 3.77726182e-02f, -3.09053753e-02f, 3.16306669e-03f, 9.35338438e-03f,
  -5.58308735e-02f, 1.29981451e-02f, -7.42456019e-02f, -5.18819876e-03f, 2.26912480e-02f, -2.18484327e-02f, 1.85501389e-02f, 1.01337470e-01f, 1.32531049e-02f, -1.98828578e-02f,
  5.77891730e-02f, 4.60480712e-02f, -3.50860022e-02f, -1.63504295e-02f, -4.18552496e-02f, -4.84563299e-02f, -8.97152629e-03f, 4.57448028e-02f, 4.34946939e-02f, -3.62170264e-02f,
  -1.05740435e-01f, -6.57081604e-02f, 3.44851650e-02f, 4.04971354e-02f, -5.04328869e-02f, 1.07563054e-02f, -5.00095412e-02f, 1.82307586e-02f, -8.08896683e-03f, -4.10958193e-02f,
  2.76618619e-02f, -4.40057963e-02f, -5.57223856e-02f, 4.14338037e-02f, -1.90284787e-04f, 6.09604865e-02f, -6.61850497e-02f, -5.23657389e-02f, 5.65319061e-02f, 6.95510656e-02f,
  -2.37234697e-01f, -2.99631774e-01f, -2.79323254e-02f, 3.15201608e-03f, -3.88161875e-02f, -3.55698494e-03f, 5.40832952e-02f, 1.56337004e-02f, -5.23916930e-02f, -4.82376032e-02f,
  5.31807728e-03f, -1.87659357e-02f, -8.52264538e-02f, -3.67172398e-02f, 9.72275913e-04f, -1.77427698e-02f, -4.00590710e-02f, 2.19354536e-02f, -6.22781850e-02f, -8.31856877e-02f,
  -5.81270717e-02f, -5.11242524e-02f, 2.39567626e-02f, -7.04282895e-02f, 4.30515744e-02f, 5.30863144e-02f, -7.13730976e-02f, 7.75232464e-02f, -2.57992353e-02f, 4.17110603e-03f,
  -1.90655991e-01f, 3.18781763e-01f, -1.16031289e-01f, 1.54520236e-02f, -1.54467613e-01f, -1.23564050e-01f, -2.77718753e-02f, 4.76847589e-02f, -1.20765306e-01f, 2.24114701e-01f,
  -5.48115931e-03f, 1.28146876e-02f, 4.34001945e-02f, 1.72806591e-01f, -2.51490831e-01f, 1.87538326e-01f, 8.79553035e-02f, 5.05297296e-02f, 5.84494174e-02f, 9.67468619e-02f,
  6.41042888e-02f, 1.11172430e-01f, 8.86079818e-02f, 9.52447578e-02f, -3.35887750e-03f, 3.42372134e-02f, 4.50631231e-02f, -1.24124818e-01f, 6.26585037e-02f, -4.69786637e-02f,
  2.61793640e-02f, 1.56747043e-01f, 6.54251948e-02f, -6.34831041e-02f, -6.15886189e-02f, -3.27485241e-02f, -1.95604786e-02f, -9.40496549e-02f, 4.25327511e-04f, -2.87542492e-02f,
  -2.92229615e-02f, -7.90698975e-02f, 2.84529496e-02f, -8.72969907e-03f, 1.91766117e-02f, 3.69958021e-02f, -6.26922920e-02f, 2.50913948e-02f, -7.44560808e-02f, -1.00909527e-02f,
  -4.50889161e-03f, 3.07958271e-06f, 3.26293632e-02f, -5.62416427e-02f, -4.16824743e-02f, -2.60038394e-02f, 2.65380051e-02f, 1.89136062e-02f, -1.00638147e-03f, 2.46987659e-02f,
  3.02701890e-02f, 5.80178015e-02f, -3.63887637e-03f, -4.41711470e-02f, -1.85498856e-02f, -4.47009057e-02f, -9.24455654e-03f, -2.23429184e-02f, -6.31909305e-03f, -4.06058459e-03f,
  -1.08683221e-01f, -3.04130409e-02f, 1.96751337e-02f, 1.87525246e-02f, 2.41401661e-02f, 4.03045453e-02f, -8.36120918e-02f, -4.53856364e-02f, -2.56474726e-02f, -5.55300787e-02f,
  9.69091663e-04f, 3.15799601e-02f, 4.72348258e-02f, -2.47995835e-02f, -7.74624199e-02f, -5.38297184e-02f, 4.85322401e-02f, -6.37070686e-02f, -6.03742488e-02f, -4.97127287e-02f,
  5.41207418e-02f, 1.91713482e-01f, 1.62946992e-02f, -3.76349799e-02f, -3.29438075e-02f, -7.86486175e-03f, -4.17258590e-02f, 6.97937831e-02f, 8.30436051e-02f, 3.09813228e-02f,
  1.22956559e-02f, -9.20864008e-03f, 5.05054779e-02f, -1.14435568e-01f, 1.89195923e-03f, 7.14219362e-02f, 5.03286384e-02f, 3.05253211e-02f, -7.19279349e-02f, 6.19702823e-02f,
  6.33583516e-02f, 6.90060779e-02f, -6.80257306e-02f, -4.75635976e-02f, 2.38558557e-02f, -1.10225558e-01f, -4.65942919e-02f, 2.30812114e-02f, 4.78282794e-02f, -5.10510281e-02f,
  -1.10017106e-01f, 1.17603466e-01f, 4.48194891e-02f, 1.83392949e-02f, 2.19898924e-01f, 1.00219980e-01f, -3.04811895e-02f, 1.27609164e-01f, 1.16842888e-01f, 7.10224062e-02f,
  -2.49340665e-02f, 2.44789151e-03f, -2.34716177e-01f, 8.10696483e-02f, -2.10259348e-01f, -2.47905850e-01f, 7.10798129e-02f, 7.64014721e-02f, -7.96405226e-02f, 8.69035646e-02f,
  -9.54747014e-03f, 2.61468776e-02f, -4.61703502e-02f, 7.82063976e-02f, -2.76173931e-02f, -2.92787026e-03f, -3.72319929e-02f, -1.27437428e-01f, 1.70061514e-01f, -8.63399531e-04f,
  9.05048922e-02f, -1.02936812e-01f, 5.84190525e-02f, -8.80422890e-02f, 4.23750505e-02f, -5.04295866e-04f, 1.09610356e-01f, -2.76168622e-02f, -5.66480346e-02f, 2.70121302e-02f,
  -2.07774956e-02f, -3.24164741e-02f, -4.37142849e-02f, -6.75395727e-02f, 5.98198846e-02f, 1.65155213e-02f, -5.27102649e-02f, 4.41860743e-02f, 6.39190152e-02f, 5.25678881e-02f,
  5.30663133e-02f, 3.25582661e-02f, 2.14698520e-02f, 1.16614565e-01f, -1.45410048e-02f, 9.01466832e-02f, 8.23733434e-02f, -3.47176045e-02f, 8.11443329e-02f, 6.22638427e-02f,
  4.22916226e-02f, -6.37454763e-02f, -4.33669351e-02f, 5.05246297e-02f, 3.52188461e-02f, 1.91133283e-02f, -1.27375184e-03f, 6.82882615e-04f, 1.17225870e-01f, 6.42845919e-03f,
  2.58854181e-02f, -1.23891896e-02f, -5.51312305e-02f, -5.07171899e-02f, -3.57562974e-02f, 4.68124263e-02f, -8.80031660e-02f, -7.84536675e-02f, 1.47861652e-02f, -3.59801091e-02f,
  -4.96413978e-03f, 5.17095113e-03f, -6.11846857e-02f, -4.77250740e-02f, 5.05569056e-02f, -1.32163793e-01f, -4.14812788e-02f, -1.65178422e-02f, -3.30700688e-02f, -4.63074744e-02f,
  3.75589095e-02f, 4.24618088e-02f, -6.72555238e-04f, 7.24483207e-02f, -3.57699730e-02f, 1.50175288e-03f, -7.95922428e-02f, -6.30167723e-02f, -2.31709145e-02f, -3.06384880e-02f,
  4.06426042e-02f, 5.71680963e-02f, -7.87359700e-02f, -2.43391888e-03f, 6.69431360e-03f, 2.96163782e-02f, -4.69610444e-04f, 4.31811921e-02f, 5.23921400e-02f, -7.56091299e-03f,
  7.12822229e-02f, -6.16429411e-02f, -4.30499204e-02f, 4.34043035e-02f, 7.37755671e-02f, -5.10184206e-02f, 1.20565563e-01f, -1.28085688e-02f, -9.88834724e-02f, 4.91949469e-02f,
  -3.62426400e-01f, -2.77014803e-02f, 1.29933089e-01f, -3.08111310e-02f, -9.52386558e-02f, -8.55250135e-02f, -3.32462452e-02f, -1.20594725e-01f, -1.95460990e-01f, 1.01930700e-01f,
  -6.75483001e-03f, 1.05166428e-01f, 1.27874002e-01f, -5.60476296e-02f, -8.70704055e-02f, 1.24297664e-01f, -1.89151675e-01f, 9.85177904e-02f, -6.65851459e-02f, -1.78036183e-01f,
  -4.04198542e-02f, -1.59937963e-01f, 9.45078731e-02f, -5.63596115e-02f, -1.68778479e-01f, -1.06003452e-02f, -1.03591129e-01f, 2.00722978e-01f, -1.03460141e-01f, 3.69632207e-02f,
  -1.97799895e-02f, 1.51600959e-02f, -1.95489526e-02f, 5.84758185e-02f, -3.53692807e-02f, 1.42915864e-02f, 3.48241366e-02f, 7.83977136e-02f, 1.48674529e-02f, 2.24461639e-03f,
  6.68633133e-02f, -5.22531606e-02f, -6.83311000e-02f, 4.24747868e-03f, -6.82446659e-02f, 2.23264098e-02f, -1.63467284e-02f, 2.75017619e-02f, 3.77058089e-02f, 3.80785204e-02f,
  -1.48140527e-02f, -3.23366784e-02f, 1.17278425e-02f, -2.29841042e-02f, -2.65055187e-02f, 1.11005660e-02f, 5.70944548e-02f, 8.81818533e-02f, -2.29382366e-02f, -1.24882862e-01f,
  -9.42702591e-03f, -9.84341800e-02f, 2.16991100e-02f, -9.18239355e-02f, -6.85011670e-02f, -5.45825735e-02f, -6.47471985e-03f, 1.08311800e-02f, -8.35067965e-03f, 7.82201625e-03f,
  -6.81370124e-02f, 2.42609568e-02f, -1.69434100e-02f, 3.02285049e-02f, -5.29390574e-02f, -7.48344138e-02f, 7.79116079e-02f, -3.83548327e-02f, -8.47671181e-02f, -2.42160987e-02f,
  3.27664725e-02f, -3.89545374e-02f, 2.91309925e-03f, 1.45632373e-02f, 1.99860241e-02f, -1.05718896e-02f, 7.77023239e-03f, -1.34058092e-02f, -2.11059432e-02f, -1.02025736e-03f,
  -2.55212992e-01f, -1.70071796e-01f, -1.05285943e-02f, -9.17124599e-02f, -8.79685953e-02f, 7.09746107e-02f, 3.80300693e-02f, 2.74232235e-02f, -6.60521388e-02f, -5.03820404e-02f,
  -6.35272861e-02f, 2.58510262e-02f, -8.30705836e-02f, 3.65184881e-02f, -4.41990281e-03f, -3.47104445e-02f, -2.19977666e-02f, -3.64682339e-02f, -2.26051714e-02f, -7.79258609e-02f,
  6.88612312e-02f, -5.72049106e-03f, 4.73873428e-04f, -2.52803285e-02f, 6.42201006e-02f, -8.08417872e-02f, -1.04459254e-02f, -3.81869562e-02f, 2.13864120e-03f, -6.76212876e-05f,
  -3.49705011e-01f, -2.04341397e-01f, -2.31329024e-01f, -1.93398938e-01f, 1.74520761e-02f, -3.84689309e-02f, -6.07077181e-02f, 1.69630833e-02f, -2.64291614e-01f, 1.37881860e-01f,
  2.09175542e-01f, -2.95950979e-01f, 1.99264258e-01f, -6.39324114e-02f, -2.17189398e-02f, 2.03899115e-01f, -1.71973839e-01f, -1.16969779e-01f, -1.84178795e-03f, -1.26079828e-01f,
  -4.39083911e-02f, 1.49892226e-01f, 2.92536262e-02f, 9.80487689e-02f, -1.08392604e-01f, -1.73983157e-01f, 2.01913744e-01f, 7.49890879e-02f, 1.64448307e-03f, 1.41841009e-01f,
  3.25901657e-02f, 3.65953706e-02f, 1.89838447e-02f, -4.73743752e-02f, 6.18491471e-02f, -4.11138460e-02f, 2.49727033e-02f, 5.95734604e-02f, -1.75948013e-02f, -1.58103108e-02f,
  4.31288173e-03f, -4.92722839e-02f, -3.19888517e-02f, 7.94946998e-02f, -4.58477028e-02f, -7.58792311e-02f, -1.46536576e-02f, -3.25240418e-02f, -3.99922989e-02f, 2.91242693e-02f,
  -7.32496232e-02f, 5.67312539e-02f, -5.28468639e-02f, -4.26401496e-02f, -4.72430000e-03f, -3.62761095e-02f, 1.79570797e-03f, 3.66850197e-02f, -3.50986570e-02f, -1.13337561e-01f,
  4.24942970e-02f, 1.96707826e-02f, -2.45674024e-03f, 5.04444875e-02f, -7.39598239e-04f, 4.32325043e-02f, 4.30567339e-02f, 5.83569966e-02f, -1.80701818e-02f, 4.52139741e-03f,
  -8.37817509e-03f, 7.52477115e-03f, 4.87319427e-03f, 2.38953419e-02f, -2.49771997e-02f, 4.59877495e-03f, -1.06355753e-02f, 7.99388513e-02f, -1.00239843e-01f, 8.79282132e-03f,
  1.75715741e-02f, -1.79013480e-02f, 8.61910060e-02f, 2.32690573e-02f, -1.47370743e-02f, 5.65855671e-03f, 2.20351461e-02f, 9.82757006e-03f, -4.52562310e-02f, 6.33271635e-02f,
  -5.44361360e-02f, -1.23075843e-02f, -4.01052572e-02f, -3.02462559e-02f, 5.66165559e-02f, 2.67543793e-02f, -2.67901216e-02f, -5.94237484e-02f, 2.29943246e-02f, 4.46945503e-02f,
  -1.56935137e-02f, 1.03633823e-02f, -2.91515365e-02f, -5.94325997e-02f, -5.43375872e-02f, 6.00678474e-02f, 3.80282551e-02f, -1.34530701e-02f, -3.77646312e-02f, 5.75998127e-02f,
  2.07682662e-02f, 2.31197737e-02f, -5.77825010e-02f, 4.68119383e-02f, -4.86430414e-02f, 5.69636561e-02f, -5.89662604e-02f, -1.38996109e-01f, 4.43547890e-02f, 1.83610190e-02f,
  2.75024176e-01f, -1.10747563e-02f, 3.23504269e-01f, 1.70160294e-01f, -2.13447407e-01f, -1.01462997e-01f, 8.06975290e-02f, 1.65869668e-02f, 2.87812233e-01f, -2.59583890e-02f,
  -1.77997112e-01f, 2.31648594e-01f, 1.91572174e-01f, -1.29513353e-01f, 2.12979823e-01f, 3.34138833e-02f, 2.85282936e-02f, 1.54449612e-01f, 2.58093369e-05f, 3.81371416e-02f,
  3.39951739e-02f, -3.17151666e-01f, 1.43037915e-01f, -2.97017336e-01f, -1.11905066e-02f, 1.12226270e-01f, -5.14830276e-02f, 1.09215435e-02f, -8.42891857e-02f, -5.15189804e-02f,
  -8.43974277e-02f, 7.73214549e-03f, 1.09276868e-01f, 1.12356670e-01f, 3.87544297e-02f, 3.52776013e-02f, 9.21358913e-02f, -5.18187601e-03f, -3.28397863e-02f, 5.05953729e-02f,
  7.11860806e-02f, 8.56949657e-04f, -2.93767583e-02f, -5.86860068e-02f, 3.46260406e-02f, 6.81958348e-02f, -4.06589024e-02f, 4.99287397e-02f, 4.49047871e-02f, 1.62775423e-02f,
  3.61215845e-02f, 4.16889153e-02f, 3.45268659e-02f, -3.74464281e-02f, 9.00043547e-02f, -6.18935609e-03f, 6.47532642e-02f, 7.48099620e-03f, 7.27328996e-04f, -1.82965565e-02f,
  4.93898690e-02f, 5.60674146e-02f, -3.73381898e-02f, 4.54936177e-02f, -5.17360792e-02f, -2.52563320e-02f, -1.97875630e-02f, 1.45485830e-02f, 3.47578749e-02f, -1.07965112e-01f,
  -1.85615979e-02f, 3.84236798e-02f, -2.86561716e-02f, 3.54573061e-03f, -4.78527211e-02f, 4.30184864e-02f, 5.15854508e-02f, -5.03431894e-02f, -2.03374512e-02f, -1.26835015e-02f,
  1.88516770e-02f, -6.28646910e-02f, -7.42451148e-03f, -6.72469512e-02f, -3.80649604e-02f, -6.08923612e-03f, 1.48935104e-03f, -5.45316376e-02f, 1.28426766e-02f, -8.46255794e-02f,
  1.32068191e-02f, 7.13247955e-02f, 4.07507867e-02f, -4.71885279e-02f, 5.95620535e-02f, -8.28803256e-02f, 2.90230699e-02f, 1.99325220e-03f, 5.24558686e-02f, -7.40074262e-04f,
  5.05857579e-02f, 1.87466741e-02f, -3.49445716e-02f, -1.62843373e-02f, -2.18500327e-02f, -7.78328702e-02f, 6.57906085e-02f, 4.77587134e-02f, -2.79918332e-02f, 2.79959049e-02f,
  -5.47122257e-03f, -1.01751283e-01f, 4.46007773e-02f, -7.33819604e-02f, -6.65125400e-02f, -1.60419736e-02f, -6.87749088e-02f, 6.77164644e-03f, -7.08480105e-02f, 8.19160789e-02f,
  2.56201684e-01f, -3.18924785e-01f, -2.27321208e-01f, -2.76438862e-01f, 2.22366109e-01f, -1.64428845e-01f, -2.01378942e-01f, 1.52853066e-02f, 1.61180943e-01f, 6.23625070e-02f,
  1.86320618e-01f, -2.68135928e-02f, 9.31503950e-04f, -1.69185773e-01f, 2.53716973e-03f, -8.91168416e-02f, -9.97708589e-02f, -1.92675088e-02f, -3.48106422e-03f, -4.36049737e-02f,
  6.10566093e-03f, 5.88797890e-02f, -2.60960430e-01f, -1.66435335e-02f, 6.82199141e-03f, -9.59017947e-02f, 7.79492483e-02f, 8.21669400e-02f, -6.28814325e-02f, 2.50958651e-02f,
  -1.04730219e-01f, 9.27286819e-02f, 3.09544783e-02f, 2.93583609e-02f, -5.62703386e-02f, 3.70858200e-02f, -6.03240244e-02f, 1.88674852e-02f, 4.70212242e-03f, 3.88874821e-02f,
  1.97643023e-02f, -1.42299896e-02f, -5.28162010e-02f, 1.98711213e-02f, -3.32100615e-02f, 6.99895471e-02f, 6.32873103e-02f, -1.92178376e-02f, -3.83526310e-02f, -1.06567569e-01f,
  -6.34996369e-02f, -1.01195022e-01f, -1.23658087e-02f, -6.13473952e-02f, 3.30613293e-02f, 7.58907348e-02f, -8.22306648e-02f, 2.63471603e-02f, -1.14740487e-02f, 1.07509144e-01f,
  3.34958173e-02f, -8.85180011e-03f, 6.32537901e-02f, 7.07583874e-02f, -1.20062893e-02f, 1.48269266e-03f, -1.42548578e-02f, 5.07781431e-02f, 1.12400539e-02f, 1.77759714e-02f,
  1.05862595e-01f, -4.41088015e-03f, 4.70643006e-02f, 6.31254574e-04f, -3.03663686e-02f, 1.35871079e-02f, -1.25641739e-02f, 2.64281090e-02f, -2.17974987e-02f, 2.91121262e-03f,
  -5.51837077e-03f, -5.63951470e-02f, 3.49653848e-02f, -5.78007698e-02f, 8.27082321e-02f, 1.07293399e-02f, 6.95660412e-02f, -3.39546390e-02f, -2.82615162e-02f, -5.87270930e-02f,
  -8.10589865e-02f, -1.77004799e-01f, -3.25060934e-02f, -2.63473615e-02f, 5.74319717e-03f, 8.17324221e-02f, -6.00996520e-03f, -1.12898229e-02f, -4.33094203e-02f, -7.14325681e-02f,
  3.66402641e-02f, -2.12349314e-02f, 3.31389569e-02f, -9.60524287e-03f, 4.80268374e-02f, 3.65124010e-02f, -3.61045897e-02f, 8.90719891e-03f, -1.34092756e-02f, 3.54032144e-02f,
  -3.85166928e-02f, 1.03202714e-02f, -6.57127006e-03f, -4.03492786e-02f, 6.98733144e-03f, -7.89621845e-04f, -7.59724621e-03f, -1.00082261e-02f, -5.68010733e-02f, -5.36978208e-02f,
  7.48159960e-02f, -9.38404053e-02f, -2.35126778e-01f, 6.40567765e-02f, 5.07815778e-02f, -6.54834285e-02f, -1.45124450e-01f, 4.53650504e-02f, -2.29981706e-01f, 1.22153111e-01f,
  1.14691854e-01f, -6.34156838e-02f, -9.65098888e-02f, -3.01071629e-02f, 3.97001058e-02f, -1.34373054e-01f, 5.46282269e-02f, 2.91214939e-02f, -1.74615651e-01f, 3.68750468e-02f,
  2.21163444e-02f, 1.86379686e-01f, -3.80093865e-02f, 1.11262441e-01f, 3.24975699e-03f, 7.99057856e-02f, 1.94339380e-01f, -2.18320601e-02f, 1.16771281e-01f, 9.81694385e-02f,
  3.79051939e-02f, 8.60367119e-02f, -5.87266944e-02f, -4.37204838e-02f, 5.55457659e-02f, 3.42076682e-02f, -3.95594798e-02f, -1.28564432e-01f, -4.66345958e-02f, -8.87243450e-02f,
  -2.25774311e-02f, 3.64921242e-02f, -1.78932492e-02f, -9.52679366e-02f, -2.88724601e-02f, -6.75387308e-02f, -7.83639699e-02f, 2.38743983e-02f, -4.67025451e-02f, -2.73934938e-02f,
  -2.74101663e-02f, -1.42920883e-02f, -1.14513403e-02f, 7.05648288e-02f, -2.24662535e-02f, -3.61426100e-02f, -3.40791717e-02f, 1.52558340e-02f, -1.05653750e-03f, -3.98432501e-02f,
  -1.34153254e-02f, 1.02520185e-02f, -2.56806277e-02f, 3.58208008e-02f, 1.72676742e-02f, 1.35491993e-02f, -3.29284631e-02f, 4.23268117e-02f, -6.45118160e-03f, 3.90476286e-02f,
  5.88697232e-02f, 3.53176915e-03f, 4.72131930e-02f, -7.97925610e-03f, 5.66184670e-02f, -4.16052602e-02f, 4.16174531e-02f, 7.13837594e-02f, -8.30209777e-02f, 7.18754008e-02f,
  5.90284634e-03f, -9.41996463e-03f, -1.48343397e-02f, 1.10628810e-02f, 3.05977892e-02f, -5.00094183e-02f, -5.65870292e-02f, -7.81966522e-02f, 3.16799735e-03f, 5.11123389e-02f,
  1.29816890e-01f, 1.87125370e-01f, -1.69362947e-02f, 6.26058653e-02f, 3.92717756e-02f, -2.13316199e-03f, -9.99783352e-02f, 4.34001200e-02f, -1.11625539e-02f, 1.29941031e-02f,
  3.08923959e-03f, -1.15088429e-02f, 1.61475949e-02f, 6.96676895e-02f, -2.46182233e-02f, 3.71224955e-02f, 1.26583083e-03f, 9.07595176e-03f, 5.14175557e-02f, 3.31613682e-02f,
  7.89286867e-02f, 3.81585620e-02f, -2.99301054e-02f, -9.19238292e-03f, 6.45161718e-02f, 3.50541584e-02f, 1.15927774e-02f, 3.29463631e-02f, -8.77397414e-03f, -2.53320653e-02f,
  -1.55521587e-01f, 2.25246713e-01f, 1.11822657e-01f, -1.56565886e-02f, -8.30837861e-02f, 8.25356692e-02f, -1.64894518e-02f, 1.01026120e-02f, 5.94389327e-02f, 8.14290494e-02f,
  -1.34885237e-01f, 1.54114172e-01f, -1.19581960e-01f, -3.61151993e-02f, -2.99350828e-01f, -7.07100108e-02f, -1.50917262e-01f, -5.56620620e-02f, 4.50813770e-03f, -8.07004869e-02f,
  -5.37882335e-02f, -2.11980894e-01f, -1.47398204e-01f, -1.13675363e-01f, -1.14594780e-01f, -1.57161076e-02f, -1.41539007e-01f, -5.20754606e-02f, -2.14825962e-02f, -5.94689958e-02f,
  3.53425778e-02f, 1.68139320e-02f, 2.81319115e-03f, -5.01061864e-02f, -4.73852921e-03f, -2.88641993e-02f, -6.72885105e-02f, -4.26522717e-02f, 4.03311662e-02f, 1.29206786e-02f,
  4.13116589e-02f, 1.33996375e-03f, 2.60372832e-02f, 6.83139730e-03f, 2.40012840e-03f, -3.13703120e-02f, 3.13073173e-02f, 3.58971171e-02f, 5.68283722e-03f, -8.47795326e-03f,
  -3.97911891e-02f, 1.52574051e-02f, 1.98067874e-02f, 5.40171983e-03f, -9.43825021e-02f, 2.97494512e-02f, -8.80426168e-03f, 1.30270177e-03f, 9.92474854e-02f, -2.13487968e-02f,
  -5.79500310e-02f, 7.84548596e-02f, -2.99956352e-02f, 2.57660192e-03f, -5.90817595e-04f, -7.53620490e-02f, 3.84633355e-02f, 2.94254511e-03f, 2.36539654e-02f, -5.60683943e-02f,
  4.85603660e-02f, -1.35551272e-02f, 1.19021991e-02f, 4.67569055e-03f, -2.19718628e-02f, 2.39413604e-02f, -2.26648320e-02f, 1.86869074e-02f, 5.31600267e-02f, -5.77929057e-02f,
  -2.40643173e-02f, 3.27859037e-02f, 2.60274261e-02f, 3.04720812e-02f, -3.01702395e-02f, 2.64657866e-02f, 3.44049148e-02f, -3.66769470e-02f, 3.44416196e-03f, -7.08712190e-02f,
  7.64938295e-02f, 1.50739938e-01f, 2.41006557e-02f, -8.80366541e-04f, -1.51121672e-02f, -1.98095851e-02f, -1.83735192e-02f, -3.31796259e-02f, -5.18867932e-02f, 1.67026073e-02f,
  3.93761694e-02f, -4.26829793e-02f, 4.15487625e-02f, 4.01290394e-02f, -1.62384678e-02f, -2.13666558e-02f, -1.60176903e-02f, -6.70035779e-02f, 5.15045337e-02f, 2.44780760e-02f,
  -5.81534766e-02f, -8.89663100e-02f, -2.28660647e-02f, -7.63380975e-02f, 6.80452883e-02f, -3.69373225e-02f, 8.28982666e-02f, 7.46704265e-02f, -3.19107585e-02f, 6.37846887e-02f,
  -3.66209507e-01f, 2.89647251e-01f, 5.56924343e-02f, 1.28298253e-01f, -2.12407708e-01f, -1.26608014e-01f, -1.30592763e-01f, 7.17218742e-02f, 7.37838075e-02f, 7.91261643e-02f,
  1.89310405e-02f, -3.39680701e-03f, -6.63758665e-02f, 2.07804173e-01f, -1.42521322e-01f, 1.01191200e-01f, -5.14891855e-02f, 7.45177194e-02f, 7.04150647e-02f, -3.32018398e-02f,
  4.49179159e-03f, -6.91974014e-02f, 4.32848558e-02f, 8.13125968e-02f, 9.42056403e-02f, -1.91896094e-03f, 6.02352656e-02f, 5.58714718e-02f, 6.42819777e-02f, 2.65645087e-02f,
  -6.55508637e-02f, 5.70532233e-02f, -2.45723221e-02f, 3.83748338e-02f, 5.84153272e-03f, -7.93664157e-02f, -3.41906734e-02f, 3.42883952e-02f, -4.36798781e-02f, -4.86212261e-02f,
  -4.74803969e-02f, 1.27084251e-03f, -6.13466799e-02f, -5.94341457e-02f, -8.35021362e-02f, 6.38810769e-02f, 2.11254247e-02f, 1.64651070e-02f, 7.85968378e-02f, -5.00552841e-02f,
  1.53191434e-03f, -1.42480098e-02f, 3.62596363e-02f, 8.83201137e-02f, 2.32651345e-02f, 5.69922626e-02f, -4.92878482e-02f, -7.58147091e-02f, 6.15542233e-02f, -1.08213341e-02f,
  -1.07300207e-01f, 2.88674645e-02f, -5.01275323e-02f, 1.10817952e-02f, 1.01216258e-02f, 6.70509413e-02f, -4.41517681e-02f, 2.76755691e-02f, -2.63037123e-02f, 2.02885717e-02f,
  6.85894350e-03f, 9.63163152e-02f, 4.99244174e-03f, 2.07390450e-02f, -5.08124828e-02f, 4.59521525e-02f, -2.02191118e-02f, 2.18139440e-02f, -1.34895863e-02f, -1.54505838e-02f,
  7.72188827e-02f, -5.19758426e-02f, -3.66338007e-02f, 6.18383894e-03f, 5.86460009e-02f, -6.53068861e-03f, 1.91858970e-02f, 8.96947831e-02f, 8.02943558e-02f, 3.55711132e-02f,
  6.64637052e-03f, 1.12740926e-01f, -3.09697017e-02f, -8.90733451e-02f, 4.25317883e-02f, 6.72809267e-03f, 2.32135002e-02f, 3.69448215e-02f, 1.03595950e-01f, 9.73355491e-04f,
  -3.87525558e-02f, 2.56429724e-02f, -3.89631744e-03f, 7.31554106e-02f, 1.78027973e-02f, 2.54060756e-02f, -3.93032841e-02f, 1.24615943e-02f, 1.27155473e-02f, -3.86285000e-02f,
  -6.88139582e-03f, -6.84526935e-02f, 2.01839488e-02f, 2.94213220e-02f, -4.37527448e-02f, 3.13817933e-02f, -6.02054112e-02f, -1.42207660e-03f, -5.86289391e-02f, 6.07486442e-02f,
  -1.94988623e-01f, -2.21558288e-01f, -1.63269993e-02f, -2.63344646e-01f, -1.84965748e-02f, -5.74087128e-02f, 9.73888263e-02f, -1.19551279e-01f, 1.84384384e-03f, -1.14660613e-01f,
  8.04478824e-02f, 5.64403236e-02f, 2.79633611e-01f, -2.50545114e-01f, 5.14872856e-02f, 2.44712546e-01f, -2.64043987e-01f, -4.26661223e-02f, 3.13615203e-02f, -1.12967707e-01f,
  -4.48999368e-02f, -1.28123909e-01f, 5.98619431e-02f, -4.23424095e-02f, -1.35935694e-01f, 5.12871239e-03f, 3.16912085e-02f, 1.06723852e-01f, -2.30261445e-01f, 4.47851606e-02f,
  2.51498315e-02f, -2.18950901e-02f, -4.97947335e-02f, -4.19050492e-02f, -8.03517178e-02f, 1.12740742e-02f, -1.61407376e-03f, 1.00362711e-01f, 8.64793807e-02f, 8.73412006e-03f,
  -1.51455235e-02f, -3.55222053e-03f, -9.37434807e-02f, 5.93299679e-02f, -7.64739141e-02f, -1.31344842e-02f, -7.17875585e-02f, -3.50306407e-02f, -5.66019269e-04f, -1.49594191e-02f,
  7.61670992e-02f, -5.50497361e-02f, -3.90648805e-02f, -6.06745407e-02f, -1.51595827e-02f, 3.30364369e-02f, -5.59586696e-02f, -6.98050559e-02f, -6.11360110e-02f, -9.58684087e-03f,
  -5.46814268e-03f, -1.33567676e-03f, 8.60218033e-02f, -2.53858119e-02f, 4.23447080e-02f, 5.91291972e-02f, -5.67144491e-02f, 1.07217818e-01f, 3.79438773e-02f, 4.54260074e-02f,
  1.10865952e-02f, -5.20699546e-02f, -3.94448750e-02f, -5.00481427e-02f, 4.26875278e-02f, -7.06867054e-02f, 8.29426646e-02f, -7.61290640e-02f, 9.65848751e-03f, -2.95545533e-02f,
  4.35028374e-02f, 4.81396951e-02f, -4.37738970e-02f, -1.68221258e-02f, 2.36687269e-02f, -4.80331108e-02f, -4.81179282e-02f, -1.38410153e-02f, -3.61273694e-03f, -6.84809536e-02f,
  -5.54869547e-02f, -4.13150266e-02f, 5.78201972e-02f, 4.37851548e-02f, 2.42011696e-02f, -1.00294508e-01f, 2.23296229e-03f, -4.40542549e-02f, -6.28365949e-02f, -3.57688330e-02f,
  -6.88744783e-02f, -1.42376218e-02f, -4.76805633e-03f, -3.42628248e-02f, 2.88775060e-02f, -2.75231879e-02f, 1.42844813e-02f, 7.60413567e-03f, -2.83976886e-02f, 2.22881846e-02f,
  -5.08300550e-02f, -2.83209570e-02f, 8.60718489e-02f, 6.23191036e-02f, -1.48193054e-02f, 5.97578548e-02f, -1.23438695e-02f, 9.26652625e-02f, 1.17585873e-02f, 5.18483296e-02f,
  2.59104595e-02f, -1.84874404e-02f, -5.30888699e-02f, 6.14284873e-02f, -1.92370191e-01f, -8.81446153e-02f, 1.02522522e-01f, -2.13253722e-01f, 3.80105735e-03f, 4.25519869e-02f,
  -4.27992530e-02f, 2.00677663e-01f, 1.51246786e-01f, -4.46577705e-02f, 3.05828303e-01f, 1.67368844e-01f, 9.14998204e-02f, 6.92432597e-02f, -1.31910210e-02f, -2.21357942e-02f,
  5.12351580e-02f, -6.51601776e-02f, 5.28513081e-02f, -2.02268198e-01f, -2.26989314e-01f, -1.77088067e-01f, 1.34943053e-01f, -4.56342101e-02f, -1.16449967e-01f, 9.11238566e-02f,
  -1.40613586e-01f, 3.81022394e-02f, -1.04234964e-01f, -1.06623210e-02f, -3.58327776e-02f, -3.26221362e-02f, -3.19435894e-02f, 6.43860921e-02f, -1.66468900e-02f, 3.47150750e-02f,
  5.83001301e-02f, 5.69253527e-02f, 4.08554450e-02f, -9.84682515e-03f, -4.88132499e-02f, -1.45776421e-02f, -3.39498147e-02f, -1.05713204e-01f, -6.25247508e-02f, 1.23381596e-02f,
  2.93928548e-04f, -6.30235940e-04f, -7.61392042e-02f, 2.33400911e-02f, -1.53054548e-02f, 1.69408936e-02f, 2.89710239e-02f, 2.80326288e-02f, 1.37562761e-02f, 3.51707153e-02f,
  -7.34774163e-03f, 5.57966232e-02f, 3.10426820e-02f, -7.52751231e-02f, -1.80138033e-02f, -5.90664968e-02f, 8.58649891e-03f, 9.30196885e-03f, 2.17546299e-02f, 2.10792981e-02f,
  2.50835693e-03f, 4.19963561e-02f, -3.17686237e-02f, -2.55618785e-02f, -1.49234915e-02f, -4.22574542e-02f, 3.07652112e-02f, 4.35698079e-03f, 1.73734687e-02f, -4.40823585e-02f,
  2.68435851e-02f, -2.00273469e-02f, 5.25773056e-02f, -1.31312162e-02f, -5.54803014e-02f, 5.01041003e-02f, -4.95173037e-03f, 3.91210690e-02f, -7.72795500e-03f, 9.27892327e-03f,
  9.05025676e-02f, 8.80750790e-02f, 2.27609277e-02f, -3.43314037e-02f, 5.77226654e-02f, -7.24524930e-02f, 2.57982742e-02f, -2.29596570e-02f, 2.13941094e-02f, 2.32187007e-02f,
  -4.26101051e-02f, -1.57310825e-03f, 4.78351079e-02f, -3.37324962e-02f, 3.07338145e-02f, -1.71198733e-02f, 9.32146460e-02f, 2.69414559e-02f, 8.07725862e-02f, 1.11327991e-02f,
  4.65442240e-02f, 2.58174096e-03f, 3.27370502e-02f, -5.52158169e-02f, -7.35568702e-02f, 8.87440294e-02f, -6.79121390e-02f, -6.18252577e-03f, 4.10937443e-02f, -1.73920840e-02f,
  -2.23485842e-01f, 1.73203513e-01f, -6.96560815e-02f, -4.62634265e-02f, -1.36262178e-01f, -1.17211126e-01f, 3.07342764e-02f, 2.81568859e-02f, 1.59688100e-01f, 1.47531882e-01f,
  -1.00342095e-01f, 1.32961096e-02f, 1.10344522e-01f, -1.74874216e-01f, -2.00631753e-01f, 2.19259709e-01f, 6.63339300e-03f, -4.07116897e-02f, 1.22874297e-01f, 2.83205491e-02f,
  -3.75337861e-02f, -1.08926103e-01f, -1.15355529e-01f, 2.78778654e-02f, -9.39143673e-02f, 8.64335001e-02f, -7.65064433e-02f, -6.63615006e-04f, -7.88625777e-02f, -3.99343297e-02f,
  8.67647957e-03f, 5.88377155e-02f, 4.83219065e-02f, 5.98807633e-02f, -7.19777718e-02f, -6.03933521e-02f, 1.52014801e-02f, -1.25654846e-01f, 2.20495928e-03f, -6.44836575e-02f,
  -5.37027568e-02f, -7.42421392e-03f, -2.88401693e-02f, 2.65676696e-02f, -1.34091210e-02f, 1.70999505e-02f, -4.22817841e-02f, -4.77193808e-03f, 3.06446590e-02f, -2.59808693e-02f,
  -4.59998585e-02f, -7.67327622e-02f, 3.41513976e-02f, -1.36215016e-02f, -2.27864198e-02f, -5.89644648e-02f, 3.92606622e-03f, 7.95300826e-02f, 4.69645038e-02f, -3.34939696e-02f,
  -7.48765934e-03f, 4.74275723e-02f, 5.66385500e-03f, -3.51402611e-02f, 3.47062573e-02f, -4.20817994e-02f, -4.16676253e-02f, -1.31999177e-03f, 7.92837366e-02f, -1.49762798e-02f,
  -8.00148174e-02f, -8.76877829e-02f, 6.20734096e-02f, -2.17694379e-02f, -5.80422394e-02f, -3.27335782e-02f, 6.60241523e-04f, -4.94463816e-02f, 1.92645136e-02f, 2.23134067e-02f,
  7.51326308e-02f, -5.70747815e-02f, 2.82251509e-03f, 1.30564384e-02f, 5.19950502e-03f, -1.33946929e-02f, 2.86891945e-02f, 5.74802095e-03f, -1.16289556e-02f, -4.50737625e-02f,
  -6.64164405e-03f, 8.67996290e-02f, 7.88289383e-02f, 4.18973751e-02f, 7.38760754e-02f, -5.85476384e-02f, 5.00574932e-02f, -4.60622348e-02f, 2.01557223e-02f, -9.55589712e-02f,
  -4.12157662e-02f, 3.94510664e-02f, -3.94631512e-02f, -9.49264020e-02f, -4.52242186e-03f, -2.45038345e-02f, 1.84393469e-02f, 4.17689197e-02f, -4.76950333e-02f, -6.65637553e-02f,
  -2.21304074e-02f, -3.88973713e-04f, 8.94795284e-02f, -1.12738227e-02f, -9.52269658e-02f, 1.43408636e-02f, 8.80863983e-03f, 3.16256098e-02f, -6.44993484e-02f, 3.19443494e-02f,
  -9.74966586e-03f, 2.17671275e-01f, -1.76914390e-02f, 6.71647862e-02f, -2.81332970e-01f, -2.73441046e-01f, -3.98062319e-02f, 6.43921867e-02f, -3.80912125e-02f, 3.65272641e-01f,
  7.68983886e-02f, 1.79360300e-01f, 8.01907107e-02f, 1.87721267e-01f, -3.62091273e-01f, -1.38467982e-01f, -7.11896643e-02f, 9.23269689e-02f, -1.37363344e-01f, 1.43152893e-01f,
  -4.50032316e-02f, 3.07746250e-02f, -1.38478026e-01f, 7.99994043e-04f, 1.09779269e-01f, 1.42014891e-01f, -8.05145875e-02f, -1.28804311e-01f, 1.03684500e-01f, -1.88469216e-01f,
  8.32271110e-03f, 3.88843194e-02f, -4.67378227e-03f, 7.82384500e-02f, 3.76742147e-02f, 2.38562226e-02f, -3.83501016e-02f, -1.14464171e-01f, -9.81491581e-02f, 8.26559439e-02f,
  8.69089812e-02f, 3.35747600e-02f, 7.36236647e-02f, -7.92587250e-02f, -5.86163439e-02f, -1.59850493e-02f, 4.41846773e-02f, -1.80246669e-03f, 4.34831083e-02f, -2.10204255e-02f,
  1.14983805e-02f, 6.91534281e-02f, -9.86750051e-03f, 2.54937056e-02f, -7.49382004e-02f, -1.04972534e-01f, 2.95901373e-02f, -6.56049550e-02f, 1.94653049e-02f, -3.91960964e-02f,
  -1.14072561e-02f, -3.13411690e-02f, 7.41769150e-02f, 6.05791882e-02f, 2.56654378e-02f, 4.97066230e-03f, 5.51215326e-03f, -2.09243707e-02f, -4.02729912e-03f, 1.16816452e-02f,
  3.29022706e-02f, 8.35206285e-02f, 7.29167312e-02f, -4.71084602e-02f, 4.94833142e-02f, 6.45846725e-02f, 3.40108201e-02f, 5.74260019e-02f, 8.69390145e-02f, 6.89825341e-02f,
  -1.06941992e-02f, -7.76292235e-02f, 8.68046433e-02f, -5.25177363e-03f, -6.84929267e-02f, -9.24153812e-03f, 7.86081478e-02f, 1.51136415e-02f, -3.93185690e-02f, -8.06699470e-02f,
  -1.50661394e-02f, 3.88671309e-02f, -1.48776574e-02f, -4.87625832e-03f, 3.80275212e-02f, -3.44249830e-02f, -1.12960273e-02f, 9.49019715e-02f, -2.09217109e-02f, -7.25813806e-02f,
  -2.58451663e-02f, -6.03612326e-03f, -4.94136661e-02f, -4.46874127e-02f, -8.11242312e-02f, -1.41473226e-02f, -3.59113067e-02f, -1.04192011e-02f, -3.87592912e-02f, 6.34204447e-02f,
  4.58782027e-03f, 2.11996883e-02f, 8.52794871e-02f, 3.53261456e-02f, -2.61385348e-02f, 9.72055942e-02f, -4.91477996e-02f, 1.63708702e-02f, -3.23914587e-02f, -2.88739074e-02f,
  1.51669711e-01f, -1.84362987e-04f, 1.25615627e-01f, -4.43385988e-02f, 1.63172990e-01f, 2.27479279e-01f, 1.67867839e-01f, 2.15986028e-01f, 2.56415427e-01f, -7.59428814e-02f,
  -5.79672754e-02f, -2.36481205e-01f, -1.30896524e-01f, -1.01910867e-02f, 1.03316784e-01f, 5.39382249e-02f, 1.32392824e-01f, 6.40897527e-02f, 1.27114832e-01f, 8.54079612e-03f,
  3.85286473e-02f, 4.07455675e-02f, -4.79739234e-02f, 5.55027165e-02f, -3.94433141e-02f, 3.65217775e-02f, -2.23121658e-01f, 7.65102953e-02f, -1.07598282e-01f, 1.17639109e-01f,
  1.47103250e-01f, -1.56263784e-02f, -4.31739241e-02f, -7.78046846e-02f, 3.94429266e-02f, 2.53429636e-02f, -1.03876352e-01f, -1.03394732e-01f, 2.73555107e-02f, -7.60188922e-02f,
  -1.27324685e-01f, -2.23593526e-02f, 4.14765216e-02f, -5.00681512e-02f, 9.46893357e-03f, -1.80829596e-02f, -1.60149876e-02f, -8.60152766e-03f, -1.20783281e-02f, -1.28288299e-03f,
  -5.87300658e-02f, 4.50445972e-02f, -2.62043276e-03f, -1.84692442e-02f, -8.23099613e-02f, 2.09559463e-02f, -2.91963015e-02f, 3.11633069e-02f, 5.19259907e-02f, 1.17344871e-01f,
  2.70409230e-02f, 1.02718018e-01f, 5.20974025e-02f, -3.64407487e-02f, -3.17268334e-02f, 1.21699469e-02f, -5.42412959e-02f, -4.19658720e-02f, 1.33971283e-02f, 6.95333956e-03f,
  -1.86669119e-02f, 4.02917787e-02f, 3.40430811e-02f, 5.33319302e-02f, -7.21603185e-02f, -2.57129427e-02f, -1.04435515e-02f, 1.90245584e-02f, 2.61598546e-02f, -6.03472756e-04f,
  -1.92331579e-02f, -3.89114991e-02f, -8.37923288e-02f, -7.46302158e-02f, 5.05435355e-02f, 5.72507940e-02f, -6.16881102e-02f, 3.44967954e-02f, -2.13711895e-02f, -6.80620689e-03f,
  -4.07085521e-03f, 4.16402258e-02f, -1.10930149e-02f, 4.01030574e-03f, -1.42264934e-02f, -5.35786077e-02f, 8.52374509e-02f, 6.64644912e-02f, 3.34673189e-02f, -5.04157059e-02f,
  2.90702470e-02f, 6.49541710e-03f, 2.12544389e-02f, 2.91198958e-02f, 1.30150351e-03f, 2.48291157e-02f, -5.63554019e-02f, 1.94325000e-02f, 6.44242540e-02f, 3.30663510e-02f,
  1.23115098e-02f, -1.16028242e-01f, -3.50587890e-02f, -7.27894017e-03f, 2.32352298e-02f, -6.21747933e-02f, 7.51111656e-03f, 1.12036489e-01f, -3.68154459e-02f, -3.18098664e-02f,
  -3.09559077e-01f, 1.02481134e-01f, 3.02497447e-02f, -1.66153580e-01f, 5.10382876e-02f, 4.28051233e-01f, 2.39875570e-01f, 2.39848476e-02f, 1.25724420e-01f, 1.97202846e-01f,
  5.91521226e-02f, -4.02461998e-02f, -1.01330392e-02f, 1.18937269e-01f, 1.93002164e-01f, 1.93631709e-01f, 1.45153612e-01f, 6.27178997e-02f, -1.28373727e-02f, -1.34366810e-01f,
  -7.26324767e-02f, 7.33303577e-02f, -6.47195205e-02f, -5.90123385e-02f, -8.58735889e-02f, -8.51529762e-02f, -2.11463943e-01f, -2.45751836e-03f, -3.65752131e-02f, 9.81417373e-02f,
  3.34305689e-03f, -7.45147765e-02f, -1.11430576e-02f, -2.05304995e-02f, 4.51504402e-02f, 2.63883136e-02f, -8.34161639e-02f, 1.12136170e-01f, -4.10309434e-02f, 6.94202334e-02f,
  9.05105937e-03f, 8.87808576e-02f, 5.65053010e-03f, 1.06551997e-01f, 9.43267718e-02f, 6.24665804e-02f, -4.07185331e-02f, 2.10055728e-02f, -5.64803146e-02f, -1.99240968e-02f,
  -3.50363106e-02f, 5.25423028e-02f, -4.78470847e-02f, 3.29793766e-02f, -7.84206539e-02f, 1.99791454e-02f, 4.25697751e-02f, -1.24312118e-02f, -2.57887244e-02f, 6.48035929e-02f,
  -3.32497396e-02f, -1.03372093e-02f, 5.81259467e-02f, 6.31072326e-03f, 6.73917830e-02f, -7.97928497e-02f, 3.32940533e-03f, -3.70206796e-02f, -3.63189541e-02f, 2.29147039e-02f,
  2.83852834e-02f, -3.33703645e-02f, -5.71716093e-02f, 8.11283365e-02f, -6.20857552e-02f, -1.82194784e-02f, 3.20626348e-02f, 9.19235963e-03f, -8.60549323e-03f, -6.58090338e-02f,
  1.36450380e-02f, -5.17858518e-03f, 1.23521937e-02f, -5.86040989e-02f, 7.49827400e-02f, -1.49415038e-03f, -4.50416841e-02f, -9.93633047e-02f, 3.35199609e-02f, -3.73948589e-02f,
  -6.71480447e-02f, -1.08521760e-01f, -2.26389449e-02f, 4.82687633e-03f, 2.95450874e-02f, 9.42304060e-02f, -6.66136341e-03f, -3.74968238e-02f, 9.45662633e-02f, 1.03981622e-01f,
  -7.15260133e-02f, -1.06533140e-01f, -1.56608522e-02f, 4.50836457e-02f, 4.81726676e-02f, -2.97629368e-02f, -1.02028407e-01f, -1.62886884e-02f, 1.49908690e-02f, -2.20656563e-02f,
  -7.24551305e-02f, -8.06410611e-02f, -1.36634074e-02f, -2.36528995e-03f, -2.65587121e-02f, -2.72263177e-02f, -5.00116050e-02f, -2.62206811e-02f, 1.79819185e-02f, 4.08263877e-02f,
  -4.34342027e-01f, 2.63833493e-01f, -2.95407865e-02f, -1.32725507e-01f, 6.24835417e-02f, 1.74725354e-01f, -1.37121826e-01f, 2.02333733e-01f, 1.50099872e-02f, 2.10211113e-01f,
  6.56454340e-02f, -9.33482945e-02f, -7.78330490e-04f, 1.91833898e-01f, -2.96411067e-01f, -1.75712164e-02f, 1.02876388e-01f, 7.40876198e-02f, -9.44974925e-03f, 1.93653516e-02f,
  -2.83881128e-02f, 3.42283621e-02f, -1.14969529e-01f, 1.43972680e-01f, 9.83483195e-02f, -4.52824123e-02f, -1.03619173e-01f, -2.56001204e-02f, 8.86114463e-02f, 1.00045986e-01f,
  -1.02931902e-01f, -3.35078873e-02f, -3.02333981e-02f, 3.90673205e-02f, -2.15634517e-02f, -4.40638550e-02f, -8.17209780e-02f, -8.49769339e-02f, -2.64238268e-02f, -2.96304822e-02f,
  -9.61348880e-03f, 1.25879617e-02f, 6.50734305e-02f, -1.33523718e-02f, 4.70846295e-02f, 4.83071730e-02f, 8.56793970e-02f, 6.43184409e-02f, 8.32510367e-02f, 3.58911902e-02f,
  1.42635599e-01f, 1.10000446e-02f, -1.19259330e-02f, -3.71750556e-02f, 1.80012127e-03f, 9.46165770e-02f, 1.50711066e-03f, -2.34848242e-02f, -3.29475254e-02f, 1.32919222e-01f,
  9.24682897e-03f, -4.91644628e-02f, 1.53446579e-02f, 4.05764207e-02f, -9.32953029e-04f, 2.67187646e-03f, 5.83107062e-02f, -6.17686249e-02f, -7.06607401e-02f, -2.50379313e-02f,
  3.47644091e-02f, -3.77028175e-02f, -1.44246910e-02f, -8.50083381e-02f, -1.50036309e-02f, 1.47274006e-02f, -7.34331310e-02f, 7.30072148e-03f, -2.36977339e-02f, -8.74276925e-03f,
  1.54100722e-02f, 9.00234934e-03f, 2.88939700e-02f, -9.58634838e-02f, 4.87432666e-02f, -2.86152158e-02f, 4.77375276e-02f, 9.29402374e-03f, 4.77209426e-02f, -1.03316046e-01f,
  2.56527737e-02f, -2.14396611e-01f, 1.83095671e-02f, -1.42357396e-02f, -5.77096501e-03f, 7.05353618e-02f, -4.47517037e-02f, 5.65335713e-02f, -4.30643447e-02f, -1.96374767e-02f,
  8.17008466e-02f, -2.74326410e-02f, -1.60420556e-02f, -4.55844356e-03f, -2.81131677e-02f, 1.36252968e-02f, -7.29618296e-02f, -2.48236605e-03f, -4.85920459e-02f, -4.62018093e-03f,
  -5.24953417e-02f, -3.22792083e-02f, 3.48135419e-02f, -5.59377857e-03f, -2.25276295e-02f, 5.91815822e-03f, -1.06864972e-02f, -1.92585029e-02f, 6.12765923e-03f, -5.89630045e-02f,
  -3.67582701e-02f, 2.14192256e-01f, 2.75998473e-01f, -1.85789838e-02f, -3.26220924e-03f, -2.47287109e-01f, -7.22366050e-02f, -1.94875821e-02f, 1.52743995e-01f, -5.79413809e-02f,
  -2.02757895e-01f, 2.52918392e-01f, 9.70943179e-03f, -1.57969549e-01f, -1.64144352e-01f, -1.13671765e-01f, -1.19121462e-01f, -3.95569541e-02f, 3.78671661e-02f, 5.96617721e-02f,
  2.43236870e-02f, -2.38629907e-01f, 1.86925437e-02f, -8.66443035e-04f, 9.26257968e-02f, 1.47870705e-01f, -1.20929800e-01f, 1.12567477e-01f, -1.33762121e-01f, -1.14400074e-01f,
  -4.82210927e-02f, 1.18011035e-01f, 5.86598590e-02f, 4.81951125e-02f, 3.29755843e-02f, -1.13047753e-02f, -6.86813667e-02f, 1.72643119e-03f, 2.83544362e-02f, 2.75423843e-02f,
  1.43169723e-02f, -5.92268363e-04f, 2.39268430e-02f, 9.28224716e-03f, 4.07501049e-02f, 3.66144367e-02f, 6.51984336e-03f, 3.84792127e-02f, 3.99613455e-02f, 3.21721174e-02f,
  7.92098418e-02f, 4.58263420e-02f, -1.21675199e-02f, -2.05835383e-02f, 5.09953983e-02f, 7.80235603e-03f, 4.47773226e-02f, -8.09276383e-03f, -3.37621905e-02f, 5.46060614e-02f,
  -5.02138510e-02f, 3.14960629e-02f, 1.79198347e-02f, 1.50990235e-02f, 7.77757494e-04f, 4.66712378e-03f, -8.31831619e-03f, -3.72562110e-02f, 4.35180031e-02f, -3.33401375e-02f,
  -6.58465549e-02f, -5.33129945e-02f, -1.93723291e-02f, 6.89771306e-03f, -2.76562944e-02f, 1.27157904e-02f, -1.54925501e-02f, 1.44696301e-02f, -9.71141213e-04f, 1.33035500e-02f,
  -2.14424320e-02f, 3.23744603e-02f, 8.38459134e-02f, -6.00314811e-02f, -3.94015461e-02f, 1.31689971e-02f, -3.19994278e-02f, -2.00939570e-02f, 7.71087175e-03f, 1.14095360e-02f,
  -3.18036526e-02f, 3.44220735e-02f, -2.13410296e-02f, -5.20409122e-02f, -2.99790893e-02f, -1.06384791e-02f, -3.51808704e-02f, 2.03967616e-02f, 4.84165139e-02f, -7.19078332e-02f,
  1.77160669e-02f, -3.03106122e-02f, 2.40559247e-03f, -2.66143214e-02f, -2.44582426e-02f, -2.63082907e-02f, 2.39861645e-02f, 1.75767113e-02f, -5.65089881e-02f, -3.99571918e-02f,
  2.21512392e-02f, 4.23605144e-02f, -4.45046797e-02f, -9.14436672e-03f, -1.86720025e-02f, -2.21906677e-02f, -4.75835539e-02f, 2.16018707e-02f, -8.59464332e-03f, 3.25640477e-02f,
  -8.67357701e-02f, -1.05653316e-01f, -1.35620788e-01f, -1.02203153e-01f, 8.95636305e-02f, 4.55326550e-02f, -7.55235925e-02f, 3.11766639e-02f, -2.60097504e-01f, 2.67862566e-02f,
  1.09763101e-01f, -1.19809724e-01f, 5.98580353e-02f, 9.66613814e-02f, -3.14766094e-02f, -1.46542359e-02f, 5.17396443e-02f, 8.90698805e-02f, -1.56219944e-01f, -3.71630536e-04f,
  -2.33739093e-02f, 1.32052854e-01f, 5.34423701e-02f, 1.67967975e-01f, 1.45898208e-01f, 6.25689551e-02f, 1.18843138e-01f, 8.00822228e-02f, 1.86231449e-01f, 1.34196460e-01f,
  9.26289801e-03f, -1.50008798e-01f, -4.41659540e-02f, 6.80017993e-02f, -5.01635112e-02f, 5.80002666e-02f, -1.74034443e-02f, -5.30171627e-03f, -3.45241465e-02f, -7.21775442e-02f,
  -1.09325862e-02f, 5.98260248e-03f, -7.43179442e-03f, 2.70781536e-02f, -7.85688534e-02f, 4.64699976e-02f, -9.44843069e-02f, 9.63338912e-02f, -9.85852908e-03f, -6.07966073e-03f,
  7.48126488e-03f, 2.29133815e-02f, 1.38291353e-02f, -2.20078863e-02f, -9.22181532e-02f, -4.29471955e-02f, -2.04697475e-02f, -4.49568080e-03f, 1.22939516e-02f, -9.07272249e-02f,
  1.44511685e-02f, 4.25448455e-02f, 9.01686847e-02f, 1.02689274e-01f, -4.45872657e-02f, 4.09379937e-02f, -4.71281866e-03f, 7.53934830e-02f, -4.73661944e-02f, -4.08400111e-02f,
  3.52953151e-02f, -2.94148773e-02f, 6.02754541e-02f, -2.94720139e-02f, -2.32518883e-03f, -1.96934827e-02f, 8.57454073e-03f, -3.13413255e-02f, -4.29313593e-02f, -3.05104405e-02f,
  4.62532453e-02f, 3.22170509e-03f, 3.96718532e-02f, 5.76709285e-02f, 6.05577696e-03f, -4.65617552e-02f, 2.69358847e-02f, -5.95392250e-02f, -1.54980160e-02f, 7.09047988e-02f,
  1.17768412e-02f, -5.00186644e-02f, 4.59365249e-02f, 1.35451544e-03f, -4.53701019e-02f, -2.76354514e-02f, -6.12169765e-02f, 1.40497703e-02f, -8.12068209e-03f, -5.39550744e-02f,
  -3.60714421e-02f, 6.73037767e-02f, 1.72728077e-02f, -5.57978079e-02f, 7.59713352e-02f, -9.72472206e-02f, 3.12058907e-02f, -6.15010671e-02f, 4.27331701e-02f, -2.67882682e-02f,
  -2.86549199e-02f, -1.00796163e-01f, -5.45945652e-02f, 2.01455001e-02f, 2.08539981e-02f, -5.40153356e-03f, -5.12293912e-02f, -2.60067955e-02f, 1.94822904e-02f, 4.35598344e-02f,
  -3.41067195e-01f, 2.26843029e-01f, 9.85439345e-02f, 1.30425975e-01f, 1.24508580e-02f, -1.41142443e-01f, -2.14935929e-01f, 2.60553360e-01f, 6.58643246e-02f, 5.59847802e-02f,
  3.88014205e-02f, -2.02432662e-01f, 8.59157145e-02f, 2.97314418e-03f, -1.19237326e-01f, -4.52802256e-02f, 2.94133630e-02f, -5.23156449e-02f, -4.51685017e-04f, 8.09458569e-02f,
  -7.40376487e-02f, 1.47678465e-01f, 1.94705417e-03f, 8.81390572e-02f, 3.91943567e-02f, 1.37043625e-01f, 1.58458278e-01f, 6.23797812e-02f, -1.46407289e-02f, -5.78232063e-03f,
  -9.93132964e-02f, 1.58159986e-01f, 2.80597098e-02f, 5.03927544e-02f, 2.86407117e-02f, -3.77790742e-02f, -1.05237864e-01f, -6.28441721e-02f, -7.42999315e-02f, 6.91112652e-02f,
  -9.43494514e-02f, -3.67656425e-02f, 2.58912016e-02f, -6.25365004e-02f, -3.24049592e-02f, 2.80986913e-02f, -3.84435756e-03f, -3.13584842e-02f, 3.06221917e-02f, -8.06848332e-02f,
  5.62909953e-02f, 2.24225335e-02f, -2.58304295e-03f, 2.05909479e-02f, 3.60607244e-02f, 4.31924732e-03f, -2.54329871e-02f, 3.39909717e-02f, -7.63835087e-02f, -5.17932288e-02f,
  -5.36592454e-02f, -1.41275629e-01f, -2.49768198e-02f, -6.02164492e-02f, -2.29334608e-02f, 2.91091297e-03f, -5.99764250e-02f, 1.20473271e-02f, -8.36713463e-02f, 3.42979841e-02f,
  -3.53862233e-02f, -1.83645803e-02f, 2.12998901e-04f, -4.08703052e-02f, 1.96249131e-02f, -7.79311312e-03f, -3.74426618e-02f, 1.79330558e-02f, -2.71064192e-02f, -1.66934896e-02f,
  5.40772192e-02f, -3.28233116e-03f, -3.18841673e-02f, 1.19087910e-02f, 1.18602579e-02f, 3.97486314e-02f, 9.29530617e-03f, 6.19018190e-02f, 2.98386402e-02f, -5.11347353e-02f,
  1.13171794e-01f, 2.01007292e-01f, 4.66912091e-02f, 9.19475313e-03f, 1.50266774e-02f, -4.42331322e-02f, 4.23728228e-02f, -4.09962377e-03f, 4.32760827e-02f, 6.81670904e-02f,
  5.21387272e-02f, -1.11530041e-02f, -3.88690196e-02f, -5.80695691e-03f, 1.36159472e-02f, 5.83772082e-03f, 3.00657917e-02f, -2.45732032e-02f, 6.13500997e-02f, 5.95641173e-02f,
  4.57770191e-02f, -5.02976030e-02f, -4.79682460e-02f, -7.76907653e-02f, -3.90389599e-02f, 1.47992987e-02f, -1.20170703e-02f, 6.82657957e-03f, -1.98297519e-02f, 2.46501025e-02f,
  6.98955283e-02f, -1.37096316e-01f, 8.53103921e-02f, 2.05733523e-01f, -5.26006445e-02f, -2.85669938e-02f, 3.07353828e-02f, 3.97045631e-03f, 3.40561792e-02f, -1.40440911e-01f,
  4.04789299e-02f, 2.10051700e-01f, -1.64295837e-01f, 1.14266962e-01f, 2.21601695e-01f, 8.40175301e-02f, 2.81533450e-01f, 5.26548102e-02f, -1.34582852e-03f, 1.11005325e-02f,
  8.23895186e-02f, 1.11290459e-02f, 2.25044966e-01f, -1.33410707e-01f, 2.77257785e-02f, -7.32330829e-02f, 2.13978216e-02f, -3.44599225e-02f, 6.86246082e-02f, 4.74981181e-02f,
  6.24464685e-03f, -8.89732465e-02f, 6.52408898e-02f, -4.20594178e-02f, 4.53036465e-02f, -6.09967448e-02f, 3.50983217e-02f, 1.38580836e-02f, -9.14153468e-04f, 3.09934169e-02f,
  1.04519287e-02f, -3.23656909e-02f, 2.80752173e-03f, -3.28123532e-02f, -5.71223460e-02f, -3.43569182e-02f, 4.78660986e-02f, 1.12286042e-02f, 1.72840226e-02f, 8.44041109e-02f,
  1.37836948e-01f, 9.34516713e-02f, 3.53022590e-02f, 3.79708111e-02f, -3.08651756e-03f, -6.29279688e-02f, 6.06697239e-02f, 8.57148394e-02f, 7.61183202e-02f, 5.02404906e-02f,
  1.07027546e-01f, -1.73944179e-02f, 5.45932688e-02f, -1.69473626e-02f, 6.73500970e-02f, -8.37765113e-02f, -1.51636414e-02f, -3.67897823e-02f, -1.26233697e-02f, 2.11077320e-04f,
  -1.19279521e-02f, 8.38568658e-02f, -1.31362274e-01f, 2.91064586e-02f, 1.98257416e-02f, -2.15661875e-03f, -7.23783392e-03f, -5.33423461e-02f, 2.55356617e-02f, 3.42808329e-02f,
  1.01937598e-03f, -1.84380673e-02f, -2.80624628e-02f, -2.10838695e-03f, -8.90198946e-02f, 6.94971681e-02f, 6.41053170e-03f, -3.53399329e-02f, 4.26641032e-02f, 2.89035197e-02f,
  -2.86267728e-01f, -3.06720268e-02f, 1.60163343e-02f, -8.03547725e-02f, -3.64954285e-02f, 4.67131101e-02f, 8.07280093e-02f, -7.13611096e-02f, -6.92376047e-02f, -3.58171612e-02f,
  -3.20859998e-02f, -4.10847105e-02f, -1.11354729e-02f, -5.16617894e-02f, 4.03348058e-02f, 1.85758807e-02f, 2.85357982e-02f, 1.46516412e-02f, 4.18372219e-03f, 7.43780360e-02f,
  3.78055498e-02f, -4.29147929e-02f, 3.93381640e-02f, 5.28439470e-02f, -3.38782668e-02f, 2.14269198e-02f, 5.16580082e-02f, -4.22706567e-02f, -1.23670353e-02f, -4.82198261e-02f,
  -3.28121752e-01f, 2.33458340e-01f, 1.31782621e-01f, -8.54837745e-02f, -1.69671953e-01f, 6.35639131e-02f, -9.72539857e-02f, -3.41615565e-02f, -1.08941570e-01f, 1.93110853e-01f,
  -1.03099585e-01f, 1.39504477e-01f, 1.63253143e-01f, -1.58464849e-01f, -2.85338789e-01f, 3.16078961e-02f, -1.45247802e-01f, -6.77543879e-02f, -2.81067099e-02f, 5.50074615e-02f,
  -2.38339547e-02f, -1.47626996e-01f, -5.77104948e-02f, 3.19309940e-04f, -1.34051722e-02f, 1.05882756e-01f, -7.38823488e-02f, 8.61353204e-02f, 6.48225918e-02f, -6.82055801e-02f,
  -8.85121003e-02f, -2.18699989e-03f, -4.53256778e-02f, 4.36257683e-02f, 3.56992567e-03f, -7.53347017e-03f, 5.53877093e-02f, -3.41817401e-02f, -6.49596676e-02f, 1.87671538e-02f,
  6.68085646e-03f, 1.04167843e-02f, -4.88406606e-02f, -4.98542376e-02f, -4.02134992e-02f, 2.03551706e-02f, -4.00308780e-02f, -1.15317535e-02f, 5.74345700e-02f, 1.69071201e-02f,
  2.10561268e-02f, 2.76207514e-02f, 1.95019413e-02f, 3.20414267e-02f, 2.37432532e-02f, 1.18087400e-02f, 4.61326540e-03f, 9.88610834e-02f, -6.69231405e-03f, 9.51925013e-03f,
  1.97638106e-02f, -5.08521963e-03f, 1.81611516e-02f, 2.44261362e-02f, -6.51365658e-03f, 2.78915800e-02f, -6.86025843e-02f, 4.76784036e-02f, -3.13442945e-02f, 5.06213084e-02f,
  -2.37248968e-02f, -4.13996400e-03f, -7.85563588e-02f, 9.53408983e-03f, -2.60219816e-02f, -7.79235065e-02f, 4.64003533e-03f, -3.17442678e-02f, 3.02213687e-03f, -2.38240324e-02f,
  -6.70562759e-02f, -9.70350504e-02f, -2.04730555e-02f, 5.47209848e-03f, -5.74613325e-02f, 3.50700691e-02f, -6.72961324e-02f, 6.75075874e-02f, -4.16458165e-03f, 7.88902193e-02f,
  4.38906476e-02f, 1.27060533e-01f, 5.91468550e-02f, 5.74286468e-02f, 4.79205176e-02f, 7.56940469e-02f, -3.47486138e-02f, 5.01100384e-02f, -1.07223969e-02f, 5.19612096e-02f,
  6.23840876e-02f, -2.49722004e-02f, 1.09214075e-01f, 1.62636433e-02f, 4.03713062e-02f, 7.88908526e-02f, 5.94720095e-02f, -5.03333248e-02f, -5.06883822e-02f, 7.18016475e-02f,
  3.50040682e-02f, -1.28065441e-02f, -9.83109232e-03f, -9.52042826e-03f, 1.28293550e-02f, -1.06745707e-02f, -8.51539057e-03f, -1.90928914e-02f, 6.64849207e-02f, -3.59251536e-02f,
  2.12363172e-02f, 1.75605029e-01f, 3.41365859e-02f, 2.77298510e-01f, -1.42812490e-01f, 7.97800124e-02f, 1.70044631e-01f, -1.26532122e-01f, -1.24440370e-02f, 6.47846982e-02f,
  1.16018623e-01f, 8.52727070e-02f, 5.96295856e-02f, 1.41197190e-01f, -4.49115178e-03f, 2.40152460e-02f, 2.19194517e-01f, 1.28714412e-01f, -1.56115621e-01f, 1.21100008e-01f,
  3.48848850e-02f, 1.28770903e-01f, 4.06006090e-02f, -4.80992831e-02f, 9.86961350e-02f, -1.34347798e-02f, 6.87422305e-02f, -7.22082555e-02f, 2.21557364e-01f, 7.71879451e-03f,
  -6.18956760e-02f, -1.05312169e-02f, -4.89608310e-02f, -6.33082539e-02f, -2.94408258e-02f, 7.14828968e-02f, 8.63805041e-02f, 4.48856764e-02f, 1.45692592e-02f, 3.54005173e-02f,
  5.29288650e-02f, -1.03613943e-01f, -7.34705152e-03f, -7.08204582e-02f, -2.99701989e-02f, -9.90124233e-03f, -4.94104549e-02f, 1.91867184e-02f, -8.65699574e-02f, -5.34778461e-03f,
  -8.51653442e-02f, -4.68019620e-02f, 5.92668205e-02f, 3.41862403e-02f, -1.41403247e-02f, 2.15091631e-02f, 8.04316103e-02f, 4.73439787e-03f, -5.73652498e-02f, 3.49565707e-02f,
  -4.30170931e-02f, -2.80441642e-02f, -2.84424145e-02f, -2.49884650e-02f, 6.21385723e-02f, -4.37835567e-02f, 6.13423027e-02f, -2.90789083e-02f, -1.01086199e-02f, -2.40504667e-02f,
  -8.73960031e-04f, -7.67864706e-03f, 4.17731702e-02f, -3.38091608e-03f, 2.11619795e-03f, 2.06279792e-02f, 6.72806352e-02f, 1.63116604e-02f, 3.83630954e-03f, -5.84136695e-02f,
  5.59515692e-02f, -3.48590054e-02f, -2.07544584e-02f, -1.42876515e-02f, 4.32355553e-02f, -4.99331802e-02f, -1.90309919e-02f, 5.11657521e-02f, -4.13282812e-02f, 2.03633681e-02f,
  1.53087482e-01f, 6.42701834e-02f, 2.88897753e-02f, -6.92922762e-03f, -1.43214278e-02f, 2.68371589e-02f, -3.09930164e-02f, 4.44577858e-02f, 2.60379631e-02f, -8.32665060e-03f,
  6.72131926e-02f, 3.73292565e-02f, -1.69473812e-02f, 1.25685921e-02f, 5.48537541e-03f, 3.06641050e-02f, 8.02448913e-02f, 6.25768751e-02f, 9.81884673e-02f, -4.55253981e-02f,
  6.29070923e-02f, 1.59823652e-02f, -1.07764952e-01f, -6.93911538e-02f, 9.36833620e-02f, 4.49640267e-02f, -8.70239958e-02f, -4.28859890e-02f, 4.44884673e-02f, -1.34919751e-02f,
  -2.32514426e-01f, -2.95381136e-02f, -6.71791062e-02f, 4.45178561e-02f, 2.18994036e-01f, 6.47270754e-02f, -1.71964720e-01f, 1.91436574e-01f, -8.07532370e-02f, -1.79867402e-01f,
  -3.43467183e-02f, -1.26339406e-01f, -1.96807563e-01f, 4.98613231e-02f, -1.00560538e-01f, -4.05939370e-02f, -4.68066260e-02f, -1.00656509e-01f, 1.25378713e-01f, 1.32432938e-01f,
  1.04010016e-01f, 2.27507085e-01f, -5.79141192e-02f, 2.67299354e-01f, 1.79951921e-01f, 2.71776821e-02f, 5.98829240e-03f, 5.23159988e-02f, 1.16177641e-01f, 3.60637344e-02f,
  2.90488768e-02f, -8.26491490e-02f, 4.24176008e-02f, -1.08684264e-01f, -7.81870559e-02f, -1.13340258e-03f, 2.02254113e-03f, 3.22759640e-03f, 5.45410253e-03f, -3.07552684e-02f,
  -6.51229471e-02f, 3.33155170e-02f, -1.53005160e-02f, 4.15928029e-02f, -7.40631074e-02f, -5.11815958e-02f, 5.23345321e-02f, 4.07671585e-04f, 1.46876825e-02f, 2.16037296e-02f,
  6.96604419e-03f, 7.83487502e-03f, -5.66736199e-02f, -8.24360177e-02f, -8.73330142e-03f, -6.07641675e-02f, -8.20483714e-02f, -6.75944090e-02f, 1.95152480e-02f, 3.94907929e-02f,
  -3.89666483e-02f, 5.60324378e-02f, -2.40069702e-02f, -1.42556047e-02f, 3.77544127e-02f, 5.10088690e-02f, -3.29487547e-02f, -4.37379675e-03f, -4.70189527e-02f, -2.55212169e-02f,
  7.11993221e-03f, 2.56624762e-02f, -1.82112157e-02f, 4.72315960e-02f, -2.50793174e-02f, -2.97330394e-02f, -2.12734845e-02f, -2.46033520e-02f, 4.43484411e-02f, -1.15316929e-02f,
  -1.45579372e-02f, -8.92425701e-03f, -2.95279231e-02f, 3.48404571e-02f, 1.68700644e-03f, 8.86056572e-03f, 1.02159996e-02f, 2.19368786e-02f, -8.31045210e-03f, -2.35137194e-02f,
  -4.55569848e-02f, -5.46941385e-02f, 5.89605272e-02f, -4.33332461e-04f, -2.66038552e-02f, 7.53568634e-02f, 1.98074672e-02f, 1.32296970e-02f, -1.31316110e-02f, 5.15744798e-02f,
  4.44423407e-02f, -5.49860150e-02f, -2.78605781e-02f, -2.80714445e-02f, 3.23636942e-02f, -1.75300855e-02f, 5.05982563e-02f, -2.01046672e-02f, 2.68156361e-03f, -1.62943285e-02f,
  1.18386326e-02f, -2.64026821e-02f, 6.21410981e-02f, 8.40928629e-02f, -2.80550355e-03f, 1.23547101e-02f, 1.44812176e-02f, -4.54791673e-02f, 3.02472170e-02f, -2.70821340e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.73688695e-01f, 1.42472476e-01f, -3.99076380e-02f, -1.16346456e-01f, 5.24309762e-02f, -2.04370111e-01f, -2.78718233e-01f, -7.28857070e-02f, 2.23235220e-01f, 1.36649385e-01f,
  9.02650505e-02f, 1.97776988e-01f, 5.19681536e-02f, -8.01859125e-02f, -2.59620190e-01f, 9.64233838e-03f, -2.24506110e-01f, -1.60306588e-01f, 4.67735380e-02f, -1.96119368e-01f,
  -1.71998993e-01f, -7.65855759e-02f, -1.00217357e-01f, 9.16440114e-02f, 9.01672337e-03f, -2.86650769e-02f, -1.56014577e-01f, 7.66989589e-02f, -1.31819382e-01f, 1.44739330e-01f,
  -6.17089160e-02f, 1.57663450e-01f, 6.92620426e-02f, 2.49621067e-02f, -5.78706618e-03f, 7.02078417e-02f, -4.09110216e-03f, 4.10973206e-02f, 3.44049446e-02f, 8.87585618e-03f,
  7.47480541e-02f, 9.84746665e-02f, -2.57373247e-02f, -9.20010451e-03f, 6.35090843e-02f, 9.04967263e-02f, -5.50211966e-03f, 1.37805119e-02f, 1.14811212e-01f, 7.20373392e-02f,
  4.44788765e-03f, 1.14782274e-01f, -8.41562822e-02f, -1.00498520e-01f, -1.94418915e-02f, 6.88416660e-02f, -9.18854550e-02f, -7.85714388e-02f, 2.24386230e-02f, 2.54876353e-02f,
  2.22769771e-02f, -1.25352694e-02f, 5.67687340e-02f, 7.60055333e-02f, 1.06625184e-02f, 4.32871096e-02f, -4.32726629e-02f, 6.98127225e-03f, 4.53438535e-02f, 1.92362387e-02f,
  -7.25597590e-02f, 4.69108708e-02f, 2.24833004e-02f, -5.06664328e-02f, 5.31809554e-02f, 3.49141918e-02f, -3.50246429e-02f, 4.77678552e-02f, -1.09325215e-01f, -3.77429500e-02f,
  -3.63913886e-02f, -2.65936775e-04f, 4.36202735e-02f, -6.87921867e-02f, -3.25806960e-02f, 2.20196247e-02f, -2.38602813e-02f, 8.50337073e-02f, -2.47950647e-02f, -9.40780938e-02f,
  -1.99154615e-01f, -1.31057292e-01f, 8.04114565e-02f, 1.80709690e-01f, 1.81301385e-02f, -2.14111153e-03f, -4.40639816e-02f, -8.34186748e-02f, 2.96112709e-03f, -5.48111275e-02f,
  -6.64032325e-02f, -4.86987419e-02f, -4.02544849e-02f, -2.46874448e-02f, 6.58048764e-02f, -7.50329345e-02f, -6.15279526e-02f, 3.31465304e-02f, 2.21552588e-02f, -4.37851442e-04f,
  2.81239897e-02f, 9.63501185e-02f, -6.35381341e-02f, -2.77964678e-02f, -3.24365050e-02f, 2.91985814e-02f, -2.42643449e-02f, 3.67618389e-02f, -8.07712302e-02f, -3.89901847e-02f,
  2.81767219e-01f, -1.06901955e-02f, 1.08181313e-01f, 5.91425002e-02f, 1.62908673e-01f, 7.10047334e-02f, 2.98967272e-01f, 7.10823461e-02f, 3.29398692e-01f, -1.27876282e-01f,
  -1.49666914e-03f, -1.76092744e-01f, -2.23766621e-02f, -4.26163971e-02f, 1.52411014e-01f, -3.21946926e-02f, 1.16234533e-01f, -4.39709723e-02f, 1.97771087e-01f, 2.37866044e-02f,
  2.04436138e-01f, 9.04386304e-03f, -7.27136247e-03f, -1.52451266e-02f, -5.66294454e-02f, 9.57912486e-03f, -2.23666996e-01f, 7.01418668e-02f, -2.72528976e-01f, -6.56139925e-02f,
  -2.53709797e-02f, 1.02854632e-01f, -2.77382061e-02f, 5.74945584e-02f, 5.70401661e-02f, -8.54407474e-02f, -8.42643827e-02f, -1.05417706e-01f, 1.82586089e-02f, 5.44791557e-02f,
  -2.16211025e-02f, 9.27174557e-03f, -1.23224342e-02f, -1.76764857e-02f, -5.18342704e-02f, 1.22790765e-02f, 5.28335012e-03f, 4.13386561e-02f, -1.62600018e-02f, 8.63041671e-04f,
  3.95940021e-02f, 3.47809084e-02f, 8.83869603e-02f, 4.82260622e-02f, 4.28466834e-02f, -3.55292745e-02f, -2.43144296e-02f, -9.51070711e-02f, -6.74977377e-02f, -9.01765302e-02f,
  -2.78564133e-02f, 2.26249360e-02f, -2.61713117e-02f, 3.01639121e-02f, 2.29124669e-02f, -2.60840058e-02f, -4.44830284e-02f, 4.28967960e-02f, 1.02923281e-01f, -8.68940800e-02f,
  5.65200113e-04f, -1.55053874e-02f, 2.43690349e-02f, 7.24498034e-02f, 1.85116325e-02f, 1.04696527e-02f, 1.21947937e-02f, 4.07637563e-03f, 2.36751698e-02f, -7.12290928e-02f,
  -9.68203507e-03f, 5.23454882e-03f, 6.17740825e-02f, 8.64798501e-02f, 1.36709372e-02f, 4.12293337e-03f, 2.07324866e-02f, 2.21488681e-02f, 6.79215640e-02f, -8.29391461e-03f,
  3.72643862e-03f, -8.03137273e-02f, 4.77863401e-02f, -6.54488057e-02f, 2.25360319e-02f, 4.77227420e-02f, 7.05333576e-02f, 3.18960249e-02f, 8.61859992e-02f, 8.39168727e-02f,
  -3.95221896e-02f, 2.41903905e-02f, -7.75816590e-02f, -4.45477068e-02f, -7.20317364e-02f, 1.30903006e-01f, -6.38096631e-02f, -3.58738215e-03f, -4.33697365e-02f, -1.22256353e-01f,
  4.12856452e-02f, 8.53585675e-02f, -1.92956291e-02f, 4.15945388e-02f, -3.87899391e-02f, -6.38760626e-02f, -1.12193367e-02f, -6.51391000e-02f, -4.40886803e-02f, 6.01681927e-03f,
  -2.39746198e-01f, 2.19122488e-02f, 1.87753946e-01f, -2.73630589e-01f, 9.36345831e-02f, 2.93548465e-01f, 9.41839218e-02f, -3.81697173e-04f, -2.38775730e-01f, -3.02383661e-01f,
  -1.41103148e-01f, -7.77647048e-02f, 8.22959840e-02f, -2.17036188e-01f, 2.07143411e-01f, 1.12977691e-01f, -1.11234277e-01f, -1.29747570e-01f, -5.22945710e-02f, -2.86620222e-02f,
  4.70111221e-02f, -1.69144973e-01f, 2.23286092e-01f, -7.17360824e-02f, -3.05322669e-02f, -2.40393490e-01f, -1.47821859e-01f, 2.59812567e-02f, -1.64701134e-01f, 1.82190370e-02f,
  9.35706943e-02f, 2.58381907e-02f, -3.16736624e-02f, 8.07065293e-02f, -3.79714407e-02f, 3.55936214e-02f, 7.69703612e-02f, 1.36689663e-01f, -4.80795279e-02f, -6.80882409e-02f,
  -6.34074435e-02f, 6.48458675e-02f, -9.64930803e-02f, -7.66336769e-02f, -6.74662413e-03f, -2.37667970e-02f, -8.48999061e-03f, 2.15145270e-03f, -1.31406076e-02f, 9.89080369e-02f,
  6.89663365e-02f, 3.66260149e-02f, -6.83538318e-02f, -1.86957177e-02f, 5.31184264e-02f, 2.30624597e-03f, -1.26738744e-02f, 1.31691864e-03f, 9.19037387e-02f, -6.00374192e-02f,
  3.14713409e-03f, 6.88013360e-02f, 1.34618673e-02f, -1.47222113e-02f, -8.40402097e-02f, -9.94931683e-02f, 3.89401652e-02f, 8.28666687e-02f, -1.00872561e-01f, 1.50858308e-03f,
  -4.61604621e-04f, -1.60512272e-02f, 1.08272262e-01f, -7.18443021e-02f, -9.54828709e-02f, -6.71601817e-02f, -4.80837040e-02f, 1.22440487e-01f, -1.60409864e-02f, 2.99750059e-03f,
  3.29489857e-02f, -6.83702230e-02f, 3.98334861e-02f, 2.50201579e-02f, 8.28793496e-02f, -2.01947894e-02f, 2.30780290e-03f, 9.99178290e-02f, -6.75545335e-02f, -7.14520807e-04f,
  1.04107939e-01f, -1.41104639e-01f, -2.97227129e-03f, 1.54103348e-02f, 1.41399801e-01f, 2.67149247e-02f, -3.01751383e-02f, -1.08184934e-01f, -3.19548398e-02f, -6.59914315e-02f,
  -1.10011995e-01f, 5.84930666e-02f, 1.69443898e-02f, -6.17971495e-02f, -4.63323891e-02f, -8.02409463e-03f, 1.34038310e-02f, 5.38049936e-02f, -2.07428355e-02f, -1.90276802e-02f,
  -7.84539506e-02f, -9.70618241e-03f, -1.20141536e-01f, -1.44382715e-01f, -9.45490226e-02f, -8.38740394e-02f, 1.09230243e-01f, -5.38163558e-02f, -3.15140784e-02f, -2.17204764e-02f,
  -2.84358889e-01f, 2.51710773e-01f, -2.97047436e-01f, 1.63632423e-01f, -2.01173395e-01f, 2.86306798e-01f, 3.69800478e-01f, -3.97881642e-02f, 1.64185047e-01f, 3.31544757e-01f,
  2.08178729e-01f, -1.22556135e-01f, 8.47460404e-02f, 3.76612455e-01f, -1.15749724e-01f, 2.36800104e-01f, 2.45593563e-01f, 1.79247305e-01f, -1.97671000e-02f, -2.01238226e-02f,
  -1.45942584e-01f, 2.93580055e-01f, 5.29598556e-02f, -3.74197401e-02f, -7.51906782e-02f, -2.27123946e-01f, 7.37359747e-02f, -1.83180168e-01f, -6.46203011e-03f, -5.15661500e-02f,
  1.53656611e-02f, -4.83574122e-02f, -1.12814665e-01f, 7.52583845e-04f, -6.88924640e-02f, -6.61601052e-02f, -2.69125652e-04f, -5.59620410e-02f, -9.55908820e-02f, 8.14800784e-02f,
  -6.63435906e-02f, -8.24495703e-02f, -2.33764872e-02f, -1.03013217e-02f, -5.37623279e-02f, -1.23680942e-01f, -4.19353694e-02f, -5.95646119e-03f, 2.29423214e-02f, -9.11050364e-02f,
  -4.76109721e-02f, -1.07315900e-02f, 7.56479846e-03f, 6.67105466e-02f, -5.19189239e-02f, -1.52586913e-02f, 5.38873821e-02f, -6.89286143e-02f, 2.23771818e-02f, 2.47278158e-02f,
  -3.95303406e-03f, -4.71376888e-02f, 5.68774194e-02f, 2.23687887e-02f, -8.29543471e-02f, -3.02723292e-02f, -2.84371059e-02f, 5.29589467e-02f, -4.31933552e-02f, 1.54814823e-02f,
  7.54544809e-02f, -4.04715538e-02f, 1.47876339e-02f, 6.75351545e-02f, 7.69135132e-02f, -2.22950839e-02f, -3.89815271e-02f, 1.03187058e-02f, -3.09849437e-02f, -5.39481677e-02f,
  2.53470652e-02f, -1.64524280e-02f, 2.97369305e-02f, 6.06855974e-02f, 6.78342243e-04f, 9.43687838e-03f, 8.51294026e-03f, 3.22621502e-02f, 3.46196629e-02f, -9.87384021e-02f,
  1.66057020e-01f, 3.38368677e-02f, 9.70254242e-02f, 7.51171038e-02f, 1.42067559e-02f, -3.94114628e-02f, 6.20805696e-02f, -1.08329214e-01f, 1.92823634e-02f, -7.49950856e-02f,
  -5.57220355e-02f, 4.81647886e-02f, 4.29887138e-02f, -1.15299784e-02f, -1.24857388e-02f, 1.06723942e-01f, 4.96492982e-02f, 2.91662533e-02f, 4.11731414e-02f, -1.68031175e-02f,
  -1.30382301e-02f, -2.65927613e-02f, 2.03270428e-02f, 4.24179074e-04f, 4.57549319e-02f, 7.53307119e-02f, 1.80989155e-03f, -5.59738800e-02f, -9.35382918e-02f, 1.21585401e-02f,
  -2.60737762e-02f, -9.45564210e-02f, -7.26587623e-02f, 1.87745988e-01f, -6.82454854e-02f, -1.36566311e-01f, -2.66082734e-01f, 1.45964369e-01f, -1.16753615e-01f, -8.86013955e-02f,
  -4.79219761e-03f, -1.83558270e-01f, -1.42848596e-01f, 2.50728548e-01f, 1.56938121e-01f, -1.05027355e-01f, 1.42735526e-01f, 3.12690474e-02f, 1.65610146e-02f, 1.14663914e-01f,
  1.78466842e-01f, 1.81195691e-01f, 1.34381130e-01f, 1.85867518e-01f, 4.19259332e-02f, 1.27948627e-01f, 2.74590492e-01f, -7.12983757e-02f, 2.96211571e-01f, 2.94538662e-02f,
  -1.12668067e-01f, 2.97254808e-02f, -6.23149425e-02f, 1.16837639e-02f, 3.53886969e-02f, -1.92198809e-02f, -9.60734636e-02f, 1.64672360e-02f, 1.12588994e-01f, -3.96746360e-02f,
  -7.88975209e-02f, -4.50230651e-02f, 2.27184556e-02f, -1.06965736e-01f, -3.80471162e-03f, 3.64421718e-02f, -5.93129173e-02f, -4.34642173e-02f, -2.46047601e-02f, -7.50655904e-02f,
  -1.61227599e-01f, 1.16454698e-02f, 3.76441181e-02f, -3.25947069e-02f, -8.34759623e-02f, 2.38593649e-02f, -6.64646104e-02f, -5.66998646e-02f, 3.27728614e-02f, 4.23780754e-02f,
  -2.21870914e-02f, 4.31993008e-02f, -3.30687910e-02f, 2.12169271e-02f, -8.86187702e-02f, 4.59353253e-02f, 3.74084935e-02f, 6.02719225e-02f, -2.57808529e-02f, -6.49018139e-02f,
  5.50746024e-02f, 2.66316254e-02f, -8.61210097e-03f, -3.73560074e-03f, -1.83116291e-02f, 2.71513760e-02f, -9.42840129e-02f, 2.15614717e-02f, -3.04466207e-02f, -2.77088471e-02f,
  -5.48624210e-02f, 6.82752579e-02f, -1.13329001e-01f, 6.89479932e-02f, 5.22343740e-02f, 2.69107223e-02f, 5.23166806e-02f, -2.87818145e-02f, -5.03224060e-02f, 6.97379708e-02f,
  4.95857187e-02f, 1.60150245e-01f, 1.00507848e-02f, 2.62276269e-02f, 8.31252337e-03f, -1.90087743e-02f, -6.54579327e-03f, 8.05373490e-02f, -1.91320702e-02f, 9.86798704e-02f,
  -2.55335830e-02f, 5.49660251e-02f, 9.54553857e-02f, -1.07718830e-03f, 1.13637902e-01f, 4.80888188e-02f, -1.58763882e-02f, -6.20655194e-02f, 2.49531236e-03f, 1.13555580e-01f,
  5.45661636e-02f, -3.15556079e-02f, 1.84934046e-02f, -1.26608104e-01f, 6.40886053e-02f, -5.20569459e-02f, 4.79698591e-02f, -1.11773379e-01f, 1.15142517e-01f, -4.01303433e-02f,
  2.58070767e-01f, 1.47018805e-01f, -3.45269024e-01f, -2.60561276e-02f, -2.80917227e-01f, 4.05241042e-01f, 2.11636037e-01f, -2.80511621e-02f, 8.41685906e-02f, 1.92088470e-01f,
  1.53551459e-01f, 7.17148632e-02f, 9.48667526e-02f, 2.41960362e-01f, -3.16660330e-02f, 2.51314670e-01f, 2.49969035e-01f, 2.29061723e-01f, -1.07097127e-01f, 1.19845279e-01f,
  -2.85097249e-02f, 2.75258839e-01f, -5.56721129e-02f, 4.04105820e-02f, 4.24615704e-02f, -2.36155868e-01f, -1.60379723e-01f, -1.89069122e-01f, -1.13668129e-01f, -5.08703217e-02f,
  -1.44872274e-02f, -5.20878285e-02f, 3.96322785e-03f, -5.57955988e-02f, 1.71914976e-02f, 1.55561109e-04f, -2.93588210e-02f, 3.42342928e-02f, -8.52553248e-02f, -2.93195006e-02f,
  3.67121175e-02f, 3.59806679e-02f, 4.62700911e-02f, -3.16567831e-02f, -1.79818124e-02f, -3.06514464e-02f, -9.67423245e-03f, -9.48637426e-02f, -3.18993516e-02f, -3.49847414e-02f,
  -1.35534823e-01f, -9.32027325e-02f, 1.14271194e-02f, 3.98848541e-02f, -7.91070014e-02f, 1.50768561e-02f, -4.67987955e-02f, -3.03118117e-02f, 1.34380236e-02f, -8.71644448e-03f,
  2.98391841e-02f, 4.21080217e-02f, 9.68774185e-02f, -4.77460958e-02f, 4.24785120e-03f, -4.38621305e-02f, 5.25933467e-02f, 4.74806987e-02f, -3.01909428e-02f, 9.18311626e-03f,
  -3.67129110e-02f, -6.98301494e-02f, 7.69691123e-03f, 3.11157890e-02f, -9.38721409e-04f, 1.60156339e-02f, 3.76306032e-03f, 2.15543695e-02f, -4.63581979e-02f, 3.62673067e-02f,
  6.13655476e-03f, 7.43894130e-02f, -6.58674836e-02f, -1.41419508e-02f, 3.29151493e-03f, -3.41689773e-02f, 5.26636057e-02f, -2.63778009e-02f, -6.97222131e-04f, -5.51790595e-02f,
  1.20059699e-01f, 8.50463659e-02f, -7.63576254e-02f, 1.52446646e-02f, -3.19813453e-02f, 6.48772642e-02f, 3.86065841e-02f, 5.66833355e-02f, -2.59739328e-02f, 5.67933433e-02f,
  1.29975621e-02f, -1.10341823e-02f, 4.43815030e-02f, -6.61670044e-02f, 5.65910377e-02f, 2.85434555e-02f, 5.88194132e-02f, -5.96496500e-02f, -3.13697681e-02f, -8.42914209e-02f,
  -4.71304953e-02f, 9.19460282e-02f, 3.21753100e-02f, -7.82865211e-02f, 6.10438846e-02f, 4.31753099e-02f, 3.95540372e-02f, -4.61658686e-02f, -1.45359104e-02f, 3.64126749e-02f,
  4.51575890e-02f, -1.55033365e-01f, -2.42789835e-01f, -2.71766126e-01f, -2.81253085e-03f, -2.98671156e-01f, -2.44339973e-01f, -1.57957509e-01f, 4.09852751e-02f, 3.04582100e-02f,
  -1.86892822e-01f, -1.56021446e-01f, 4.94985469e-02f, -4.23313141e-01f, -1.01575747e-01f, -4.60585915e-02f, -3.09249341e-01f, -2.28421256e-01f, 5.75147979e-02f, -2.82346457e-01f,
  4.70851101e-02f, -1.80927366e-01f, -3.04040998e-01f, 1.04573883e-01f, -2.05714941e-01f, 2.92986780e-02f, 3.70504349e-01f, -3.14518288e-02f, -1.26229912e-01f, 4.12395373e-02f,
  -9.80928354e-03f, -8.71321186e-02f, -1.71508342e-01f, 2.12543122e-02f, -1.59956831e-02f, 2.69371867e-02f, -2.45846994e-03f, -3.46989259e-02f, -6.94894120e-02f, -1.50858596e-01f,
  -1.04723312e-02f, 2.73310039e-02f, -1.22321606e-01f, 3.45443338e-02f, -4.79396991e-02f, -8.24818537e-02f, 3.41850296e-02f, 6.00049309e-02f, -3.38267982e-02f, -7.95899034e-02f,
  -1.76566198e-01f, 4.80243787e-02f, 3.06378007e-02f, 1.10002778e-01f, 9.90979560e-03f, 1.55840712e-02f, 3.05662826e-02f, -5.67430705e-02f, 6.70537818e-03f, 8.66370834e-03f,
  -3.61503251e-02f, 4.28847075e-02f, -6.05666377e-02f, 2.39602868e-02f, -6.56083152e-02f, -3.22691277e-02f, -4.14913818e-02f, -5.36862649e-02f, 6.45029992e-02f, -5.01713715e-03f,
  7.18941391e-02f, -2.83956935e-04f, -2.71264836e-03f, 2.81320792e-02f, 1.16384039e-02f, 7.30052367e-02f, 2.49363482e-02f, -6.46183044e-02f, 6.34818629e-04f, -8.12535882e-02f,
  6.69882298e-02f, -3.38736624e-02f, -4.95991297e-02f, 8.37242231e-02f, -1.15974963e-01f, -8.89772549e-02f, 3.09402589e-02f, -2.98187304e-02f, 1.71844736e-02f, 2.76010809e-03f,
  -5.49327303e-03f, 3.14232223e-02f, -4.31148708e-02f, -3.09131034e-02f, -3.08323447e-02f, 5.64869680e-02f, 2.50841640e-02f, -4.78300229e-02f, 7.01509044e-02f, -5.32394182e-03f,
  3.80752273e-02f, 5.38976602e-02f, 9.13664550e-02f, -2.23767459e-02f, 3.66507061e-02f, -3.72257642e-02f, -6.70713978e-03f, 4.44708839e-02f, 7.15248287e-02f, -4.45697233e-02f,
  1.48254499e-01f, 4.64161895e-02f, 2.07525361e-02f, -1.56854261e-02f, -5.38460016e-02f, 3.16262781e-03f, 2.03663460e-03f, -3.54246236e-02f, 1.70199890e-02f, -1.27577886e-03f,
  -2.43470035e-02f, 2.69455343e-01f, 6.70486093e-02f, 3.11453462e-01f, 1.29653007e-01f, 3.33632827e-01f, 4.64230441e-02f, 2.19953120e-01f, 3.73912245e-01f, 3.90288718e-02f,
  -2.02342700e-02f, 4.64313626e-02f, -1.30923212e-01f, 7.10973218e-02f, -1.00580342e-02f, 2.15191543e-01f, 2.47312561e-01f, 9.09813941e-02f, 1.90278322e-01f, 4.53037443e-03f,
  4.96752709e-02f, -4.26168693e-03f, -2.26522505e-01f, -1.96868226e-01f, -5.80193177e-02f, -1.11107983e-01f, -1.45874649e-01f, -8.26652795e-02f, -1.02296025e-01f, 8.21157992e-02f,
  3.30994986e-02f, 4.93607335e-02f, -1.38693228e-01f, -3.39549296e-02f, 2.07760762e-02f, -6.79656107e-04f, -3.21531296e-02f, 2.25411188e-02f, -5.92459664e-02f, 3.23441401e-02f,
  -2.96091870e-03f, 1.51752227e-03f, 9.08469968e-03f, 3.12067028e-02f, -3.83957885e-02f, -6.76641315e-02f, 4.43931334e-02f, 2.75188144e-02f, -5.36646061e-02f, 2.91318819e-02f,
  -1.86525583e-02f, 2.82342937e-02f, -4.07473296e-02f, -6.01308048e-03f, 4.56727389e-03f, 1.04000129e-01f, -1.30940182e-02f, -2.62887813e-02f, 8.86367559e-02f, 3.32987420e-02f,
  3.56799923e-02f, 6.61153793e-02f, -1.37738347e-01f, 1.12913651e-02f, -1.08857527e-01f, -5.26592322e-02f, 2.36995518e-02f, -1.29265422e-02f, 1.02956351e-02f, 4.49709892e-02f,
  6.10572062e-02f, 4.13637012e-02f, 6.97417855e-02f, 4.54418687e-03f, 1.05153568e-01f, -5.93509786e-02f, -3.54145654e-02f, 3.48746590e-02f, 5.53232543e-02f, -2.58928128e-02f,
  4.53811102e-02f, 6.25759512e-02f, -2.50873677e-02f, 2.40956936e-02f, -2.76378612e-03f, 3.39108706e-02f, 7.51336962e-02f, 1.49901388e-02f, -7.03399032e-02f, 1.02624416e-01f,
  8.24713260e-02f, 3.02153856e-01f, -1.71879288e-02f, -7.95671046e-02f, -5.59596494e-02f, -7.36300945e-02f, 5.59896454e-02f, 7.25339875e-02f, 2.58416757e-02f, 3.96705791e-02f,
  -4.51389812e-02f, -7.90031031e-02f, 6.77591339e-02f, -4.70115617e-03f, -6.35440648e-03f, -1.41700767e-02f, -1.71943998e-03f, 4.82859947e-02f, 7.93268457e-02f, 4.35433015e-02f,
  -6.54532537e-02f, -2.96952780e-02f, -1.26577675e-01f, -2.31654868e-02f, -3.47444303e-02f, -9.99576822e-02f, 6.29066080e-02f, -8.44807774e-02f, -1.58169325e-02f, 1.26348883e-01f,
  -6.21307075e-01f, 1.65736482e-01f, 3.05247337e-01f, -7.55050704e-02f, -1.64971471e-01f, 3.37031692e-01f, 4.19951200e-01f, -1.76616304e-03f, -7.08721578e-02f, 2.45280877e-01f,
  -3.98057587e-02f, -1.47722423e-01f, 1.70340896e-01f, 6.82076588e-02f, 1.08713612e-01f, 9.86674055e-02f, 3.09809465e-02f, 8.29156190e-02f, 2.08586343e-02f, -1.21003337e-01f,
  -1.59458537e-02f, 9.95562896e-02f, 6.88462853e-02f, -3.42822820e-02f, -1.19720310e-01f, -4.01731171e-02f, -7.68824592e-02f, 1.05104439e-01f, 9.14764218e-03f, -3.67859155e-02f,
  -3.55326712e-01f, -4.16009665e-01f, -2.41752431e-01f, -1.25051603e-01f, 9.40834545e-03f, 3.16900648e-02f, 1.21219575e-01f, -6.31209686e-02f, -1.57475650e-01f, -7.61746755e-03f,
  1.89709235e-02f, -4.86735106e-02f, -3.66923725e-03f, 1.07761761e-02f, -1.25192881e-01f, -1.64304357e-02f, 3.21650058e-02f, -4.33850056e-03f, 1.19290957e-02f, -3.69253680e-02f,
  2.70844884e-02f, -5.64463250e-02f, 4.90713641e-02f, 1.36572853e-01f, 7.84214288e-02f, -3.12678590e-02f, 7.27386400e-02f, -1.45967500e-02f, -3.77329923e-02f, -9.82165635e-02f,
  -3.57257016e-03f, 2.10286733e-02f, -1.08732834e-01f, -1.21503044e-02f, 3.97810526e-02f, 8.80222209e-03f, 2.49454714e-02f, -3.15020420e-02f, 3.25269774e-02f, 7.45662302e-02f,
  4.09591448e-04f, -5.53835891e-02f, -5.75883277e-02f, -7.81768747e-03f, 9.29007530e-02f, -2.41064988e-02f, -1.62447290e-03f, -3.93670015e-02f, 7.03191385e-02f, 5.37782535e-02f,
  -6.02621511e-02f, 5.04014380e-02f, 3.49675752e-02f, 2.55353320e-02f, 2.43456587e-02f, -3.48573215e-02f, -4.22882065e-02f, 1.22903124e-03f, -1.72473509e-02f, 2.34988816e-02f,
  -2.59443134e-01f, -2.68827468e-01f, -5.05731404e-02f, -9.82206389e-02f, -4.60239649e-02f, -7.84901679e-02f, -6.36010291e-03f, -3.03478446e-02f, -3.48080173e-02f, -6.06253520e-02f,
  -4.84279469e-02f, 3.37151550e-02f, 7.35926302e-03f, 7.88160041e-03f, 1.18751951e-01f, 4.31256555e-02f, 4.71433178e-02f, -2.28680260e-02f, -7.97827616e-02f, 1.91422347e-02f,
  -7.08930613e-03f, -4.79937391e-03f, 6.61790892e-02f, -2.79670227e-02f, -5.39103746e-02f, -1.12003961e-03f, -1.48597047e-01f, 1.16307743e-01f, -4.70156968e-02f, 8.83701518e-02f,
  -1.59219429e-01f, 8.36561620e-02f, -2.43390441e-01f, -2.97112823e-01f, 4.10904642e-04f, -3.33830059e-01f, -3.11236173e-01f, -7.98195153e-02f, 1.09651946e-01f, -1.02874056e-01f,
  -1.49459139e-01f, 2.16119420e-02f, 1.29488796e-01f, -1.81859195e-01f, 6.89396635e-02f, 9.23855305e-02f, -2.82783121e-01f, -1.19345479e-01f, -1.79623123e-02f, -1.57454997e-01f,
  -2.97682956e-02f, -1.53304219e-01f, -9.36753303e-02f, 1.32087143e-02f, -1.83217317e-01f, -1.13158680e-01f, -3.73306274e-02f, 7.94547983e-03f, -1.66725069e-01f, 1.44035118e-02f,
  -1.74002767e-01f, -3.20105478e-02f, -1.32615268e-01f, -7.73147866e-02f, -8.10453519e-02f, -3.07649262e-02f, -1.31923482e-01f, -4.45994176e-02f, -4.91843522e-02f, -1.38485804e-02f,
  -4.69836444e-02f, -4.47547399e-02f, -3.66774611e-02f, 5.76569811e-02f, 2.85684746e-02f, -1.02076650e-01f, 5.72271040e-03f, -1.53627992e-02f, -1.18716605e-01f, 6.17374294e-02f,
  -4.06530201e-02f, -4.89551127e-02f, -1.43701330e-01f, 4.70160693e-02f, 5.36195785e-02f, -1.82618257e-02f, -3.04895565e-02f, 5.30259646e-02f, -5.87825067e-02f, 3.35760787e-02f,
  9.21021588e-03f, 1.02143496e-01f, -9.38809514e-02f, 7.81692043e-02f, -3.85441668e-02f, 6.64897263e-02f, 4.74147946e-02f, 2.77669970e-02f, -1.17219955e-01f, -9.83744264e-02f,
  -2.96724867e-02f, -1.15720956e-02f, 3.63397710e-02f, -1.58028454e-01f, -1.03018329e-01f, 9.32120159e-03f, -6.26731962e-02f, -3.48215327e-02f, 2.16043536e-02f, 2.66866852e-02f,
  -6.22567348e-03f, -3.90932336e-02f, -1.78655535e-02f, -9.58860591e-02f, 3.13110230e-03f, 6.60421774e-02f, 5.41195907e-02f, -5.72988950e-03f, -1.75936278e-02f, 4.19987924e-02f,
  -2.80169010e-01f, -2.03481555e-01f, -5.68771325e-02f, -5.47603928e-02f, -1.06720798e-01f, -5.60770631e-02f, -4.07079160e-02f, 6.21322915e-02f, -7.03301653e-02f, 8.51365477e-02f,
  -1.78417861e-02f, -1.89810321e-02f, 4.21195291e-03f, 3.47351693e-02f, -2.91644614e-02f, 2.47460417e-02f, -5.25612533e-02f, -1.77061316e-02f, -8.20385888e-02f, -3.86108011e-02f,
  -1.80945788e-02f, 6.31731190e-03f, -1.80864483e-02f, -2.48339418e-02f, -2.38269493e-02f, -1.17437132e-01f, 1.10136718e-01f, -3.95364454e-03f, -5.54251194e-04f, 4.06467281e-02f,
  -7.75468647e-02f, -1.24548882e-01f, -3.81233580e-02f, 2.20447883e-01f, -1.02438487e-01f, -1.36155009e-01f, -2.25369200e-01f, 1.58685744e-01f, -1.48443967e-01f, -3.49700227e-02f,
  1.99661285e-01f, -3.23876590e-02f, -1.71957806e-01f, 2.69214720e-01f, 2.22720340e-01f, -2.02204343e-02f, 1.71985567e-01f, 4.09979344e-04f, 1.88618861e-02f, 1.96942791e-01f,
  1.50835410e-01f, 1.95242524e-01f, 1.72251865e-01f, 1.69454053e-01f, -5.88390045e-02f, 1.15902528e-01f, 1.57694906e-01f, -3.09488904e-02f, 2.93893665e-01f, -2.19014604e-02f,
  -1.26530118e-02f, 1.27215058e-01f, -4.74686138e-02f, -9.57683623e-02f, 7.16013536e-02f, 1.73193850e-02f, 3.74082699e-02f, 3.07185426e-02f, 3.67298387e-02f, 4.52957898e-02f,
  -1.10064015e-01f, 7.41952732e-02f, 3.72347515e-03f, 7.92439505e-02f, -5.64993210e-02f, 7.57082179e-02f, 3.34478952e-02f, -4.33382280e-02f, -3.40326875e-02f, -2.75728479e-02f,
  -1.31108969e-01f, -2.22730134e-02f, -6.14560843e-02f, 3.77649851e-02f, 4.85635698e-02f, 2.58239992e-02f, -5.45009188e-02f, -2.59481184e-03f, -4.05087806e-02f, 1.90780200e-02f,
  7.66044632e-02f, -7.94755518e-02f, -9.73942131e-02f, -2.22559012e-02f, 4.60036658e-02f, 1.09720668e-02f, -2.99519747e-02f, 2.54707243e-02f, 3.32836397e-02f, 7.11510256e-02f,
  2.82643400e-02f, 3.31635214e-02f, 3.19834799e-02f, -6.03677891e-02f, -2.05501206e-02f, -6.18017800e-02f, -4.10285546e-03f, -1.88546050e-02f, 6.59593493e-02f, -3.61009203e-02f,
  -3.17097716e-02f, -2.67158113e-02f, 7.43794367e-02f, -5.89993931e-02f, -1.39878849e-02f, 2.91251857e-02f, 7.39652589e-02f, -3.02565023e-02f, -2.38973834e-02f, -8.13038796e-02f,
  4.80627827e-02f, 7.28977770e-02f, 4.19916697e-02f, -1.02533124e-01f, -3.36748883e-02f, -2.17722785e-02f, 5.86371822e-03f, -3.14891376e-02f, 2.58680489e-02f, -1.11568905e-01f,
  6.15471676e-02f, -8.83848369e-02f, -1.98089494e-03f, 8.88286009e-02f, 3.89257036e-02f, -1.00177201e-02f, -2.19003055e-02f, 7.09437281e-02f, 1.04234986e-01f, 1.53837949e-01f,
  5.59778251e-02f, -9.73927453e-02f, 6.29123300e-02f, -1.36665981e-02f, 6.32672012e-02f, -8.78641084e-02f, 7.60883763e-02f, 3.63058373e-02f, 4.77623567e-02f, 8.98857266e-02f,
  -1.10767297e-01f, 1.69100855e-02f, -2.55980551e-01f, -2.31070638e-01f, 1.40226066e-01f, 5.26353531e-02f, 1.04802221e-01f, -2.48785038e-02f, -1.20595433e-01f, 2.79060811e-01f,
  1.38494046e-02f, -1.10435747e-01f, -2.65827887e-02f, -3.18001151e-01f, -2.99374789e-01f, -2.78153747e-01f, -1.20996401e-01f, -6.92463992e-03f, -1.05133630e-01f, 1.13590315e-01f,
  -1.76164925e-01f, -7.81103373e-02f, -2.47723505e-01f, 1.39983922e-01f, 1.29917279e-01f, 1.36058396e-02f, 2.22528681e-01f, 1.69058219e-01f, 2.50347238e-02f, -6.04117922e-02f,
  -1.17592089e-01f, -1.26141801e-01f, 2.91294772e-02f, -6.19416460e-02f, 4.31605205e-02f, 9.67706218e-02f, 1.37213871e-01f, -5.65326624e-02f, 3.22571397e-02f, 1.63642857e-02f,
  5.53664453e-02f, -1.76614244e-02f, -6.28247336e-02f, -4.38146479e-02f, 2.73562185e-02f, -3.24744061e-02f, -7.19376802e-02f, 4.83746827e-02f, -8.59103575e-02f, -9.21030417e-02f,
  -1.13858350e-01f, -5.63395582e-02f, 1.07408874e-01f, 2.34716125e-02f, -3.86501104e-02f, -3.49621475e-02f, -4.14607413e-02f, 1.80310272e-02f, -1.99189782e-02f, -1.57252513e-02f,
  3.75866815e-02f, 9.33335572e-02f, -1.48351640e-02f, -1.11941241e-01f, 3.80570465e-03f, -2.14867331e-02f, -2.16464512e-02f, -2.41339523e-02f, -2.79302485e-02f, 6.39557168e-02f,
  3.24311899e-03f, 9.46947187e-03f, -4.83930297e-02f, 1.25022739e-01f, 4.26484421e-02f, -4.99467924e-03f, 1.15344338e-02f, 1.56516265e-02f, -7.77550861e-02f, -6.14819936e-02f,
  7.15526417e-02f, 5.47287753e-03f, -1.55642945e-02f, 7.24687874e-02f, 2.14239527e-02f, -6.50127381e-02f, -1.62990345e-03f, -3.28336284e-02f, -6.25147205e-03f, -8.38014856e-03f,
  1.08400770e-01f, 1.91193447e-01f, 1.42033696e-02f, -6.91125123e-03f, 4.13012132e-02f, -5.33728488e-02f, -3.02874465e-02f, -7.46828467e-02f, -2.25016288e-02f, -1.06294835e-02f,
  3.59148048e-02f, 3.53991874e-02f, 1.08974107e-01f, -5.43609969e-02f, 3.64157706e-02f, 6.10001013e-02f, 9.21860151e-03f, 2.23524775e-02f, 3.91330607e-02f, 3.34526189e-02f,
  9.19818208e-02f, 5.18951342e-02f, -2.64277030e-02f, -8.54002219e-03f, -5.33136092e-02f, 9.91089195e-02f, 1.06431209e-01f, 7.79665783e-02f, -1.64178759e-03f, -1.60278298e-03f,
  3.98157805e-01f, -3.03279012e-01f, 9.10545364e-02f, 3.26796591e-01f, 1.88114330e-01f, 6.33312762e-02f, 4.76372056e-02f, 6.38384223e-02f, 1.92569479e-01f, -1.87554777e-01f,
  -9.72002093e-03f, -8.76851678e-02f, -3.34165961e-01f, -9.43399034e-03f, 3.33242826e-02f, -1.03878453e-01f, -6.83392510e-02f, 3.10021769e-02f, -1.27874585e-02f, 2.90760547e-02f,
  1.54156402e-01f, -1.00412741e-02f, -1.68063696e-02f, -7.01067373e-02f, 1.26541212e-01f, 5.46514504e-02f, -5.09711169e-02f, -2.05093831e-01f, 4.43997197e-02f, -1.06611364e-02f,
  -5.65592796e-02f, 6.46762624e-02f, -1.05145283e-01f, -4.79158610e-02f, 3.05397063e-02f, -4.61670803e-03f, -3.24968435e-02f, -9.69302505e-02f, 2.79033743e-02f, 2.66474374e-02f,
  -5.41529730e-02f, -5.74702099e-02f, 8.21206123e-02f, 7.56644756e-02f, -2.92192213e-02f, 6.90316558e-02f, 8.93535167e-02f, 3.11638173e-02f, -5.67423599e-03f, -5.66496439e-02f,
  1.30122900e-02f, -1.44875767e-02f, 5.68915904e-02f, -2.90142428e-02f, -1.13359522e-02f, 1.58971380e-02f, 3.68409120e-02f, -2.75363866e-02f, 8.24628863e-03f, 3.52838710e-02f,
  -1.50760151e-02f, -4.92076874e-02f, -3.20722535e-02f, 8.32218770e-03f, -3.42792906e-02f, 4.94329780e-02f, 2.81240735e-02f, 6.23974241e-02f, -1.05269700e-01f, 5.28228506e-02f,
  2.60032285e-02f, -2.78271306e-02f, 8.28649551e-02f, -3.94446366e-02f, 6.17691241e-02f, 3.76964696e-02f, -6.13787770e-02f, -3.18763056e-03f, -4.30268012e-02f, 1.60794482e-02f,
  8.07481706e-02f, 1.66585073e-02f, -1.52122611e-02f, 8.53589103e-02f, -3.11022568e-02f, -2.26396769e-02f, -6.03113547e-02f, -3.23327146e-02f, 2.08923277e-02f, -7.47322589e-02f,
  -4.60876018e-01f, -2.02107266e-01f, -3.43939848e-02f, -4.56362814e-02f, -8.05787444e-02f, -5.54404296e-02f, 4.23876047e-02f, 4.64230962e-02f, -1.78725079e-01f, 6.32392541e-02f,
  -4.73246276e-02f, 1.30045284e-02f, 5.12475111e-02f, 2.89580356e-02f, -5.58725744e-03f, 3.86327505e-02f, -2.95619760e-02f, -1.24745511e-01f, -4.90465686e-02f, 4.47006673e-02f,
  -4.15641442e-02f, 1.30689871e-02f, -7.11646527e-02f, -3.32034901e-02f, -4.03936999e-03f, 3.30775119e-02f, -5.10465121e-03f, -8.36967155e-02f, 7.03301094e-03f, -4.04892229e-02f,
  -1.51204214e-01f, -4.62968610e-02f, -1.12554662e-01f, -3.62598523e-02f, 1.49229333e-01f, 1.34876026e-02f, -4.33577858e-02f, 4.21088822e-02f, -2.24322230e-01f, 1.14588566e-01f,
  -1.97959933e-02f, -1.75814435e-01f, -4.97633964e-02f, -2.28902832e-01f, -1.72642857e-01f, -2.41651103e-01f, -3.00990995e-02f, -1.41802356e-01f, -1.46336615e-01f, 4.54160720e-02f,
  -2.94400030e-03f, 7.35418797e-02f, -1.24799293e-02f, 1.17981598e-01f, 1.90314278e-02f, 1.62510931e-01f, 2.98394948e-01f, 1.44507289e-01f, 1.15261041e-01f, -1.35226008e-02f,
  -5.44833951e-02f, -2.21845857e-03f, -4.00569476e-02f, -9.37048048e-02f, 3.36129330e-02f, 1.00517176e-01f, 3.65731195e-02f, -1.04577042e-01f, -8.33267719e-02f, -1.16598614e-01f,
  3.28922942e-02f, -1.07644475e-03f, -3.37793864e-02f, 3.51314954e-02f, 9.99598484e-03f, -1.15191698e-01f, -4.27021123e-02f, 2.83675976e-02f, -1.20954446e-01f, -9.68652070e-02f,
  -4.41899057e-03f, -3.69289182e-02f, 1.59303062e-02f, -5.31822257e-02f, 4.59450297e-03f, -1.33472411e-02f, 4.14869003e-02f, 7.10161915e-03f, 5.59181459e-02f, 2.05570599e-03f,
  3.76023538e-02f, 1.43048167e-01f, 1.65791884e-02f, -7.50590712e-02f, -4.93533164e-03f, -1.35767728e-03f, 9.87353735e-03f, 4.57216725e-02f, 2.13945340e-02f, 3.42533737e-02f,
  -1.74003690e-02f, -8.90507549e-02f, -4.43284772e-02f, 2.40836199e-03f, 3.35113294e-02f, -6.33714348e-02f, 5.35670333e-02f, 5.22717386e-02f, 6.77424446e-02f, -1.48606449e-02f,
  -2.40780432e-02f, 1.64484661e-02f, 3.71170156e-02f, -4.33830023e-02f, -2.15269756e-02f, 6.33203760e-02f, 8.18633810e-02f, 1.40509857e-02f, 3.44879064e-03f, 2.28010230e-02f,
  1.95865761e-02f, 1.38546884e-01f, 3.15603539e-02f, 1.65826664e-03f, 2.20717955e-02f, 5.74760996e-02f, 4.20792699e-02f, 3.81847620e-02f, 1.16795441e-02f, 3.88403274e-02f,
  1.12604283e-01f, 5.71332984e-02f, 8.77681524e-02f, -4.64491844e-02f, 2.11100001e-02f, 6.34485856e-02f, 5.97955473e-02f, 8.53483379e-02f, 1.30839989e-01f, 6.66385051e-03f,
  1.00641310e-01f, 2.05384218e-03f, 7.17785284e-02f, 6.11295402e-02f, 3.37021500e-02f, 9.14900228e-02f, 3.24966270e-03f, 6.58092424e-02f, 5.12794685e-03f, 1.03202332e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  7.50028864e-02f, 8.27456787e-02f, 1.59021795e-01f, 7.02902267e-04f, 6.97192326e-02f, 1.58918992e-01f, 1.23352706e-01f, 5.03805801e-02f, 1.16944201e-01f, 8.94152820e-02f,
  1.08215354e-01f, 3.30878012e-02f, 1.61630347e-01f, 3.87196839e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  6.34001344e-02f, -1.72258560e-02f, -5.78454807e-02f, 7.62358904e-02f, -9.45272520e-02f, -4.19628285e-02f, -7.68982247e-02f, -6.95369616e-02f, -4.28216644e-02f, -6.72135577e-02f,
  -6.31377324e-02f, 6.22724444e-02f, 4.92956955e-03f, -1.32517507e-02f, -1.37596652e-01f, 1.02670223e-01f, -1.96602911e-01f, -1.87871099e-01f, -9.26347971e-02f, 1.46533340e-01f,
  -2.39803687e-01f, -1.70455217e-01f, 1.33875147e-01f, 4.74401265e-02f, 3.24258842e-02f, 2.14495689e-01f, 9.58770216e-02f, 1.53428420e-01f, -1.04019947e-01f, 2.80226201e-01f,
  3.03039074e-01f, -1.54207408e-01f, -2.06900954e-01f, -1.74564585e-01f, 6.44357353e-02f, 2.28330657e-01f, 1.17399529e-01f, -1.20427661e-01f, -2.36911303e-03f, 1.07173890e-01f,
  1.15909362e-02f, 6.83435425e-02f, 2.08963782e-01f, -4.46693413e-03f, 2.34236661e-02f, 2.63432592e-01f, 7.23791271e-02f, 2.28652377e-02f, -1.44231856e-01f, 2.29998395e-01f,
  1.65562570e-01f, -1.47511452e-01f, 2.21903339e-01f, 8.40672925e-02f, 8.42368975e-02f, -2.09776565e-01f, -1.99449375e-01f, -9.00575668e-02f, 2.15104640e-01f, 7.88264424e-02f,
  1.65766388e-01f, -1.21071868e-01f, -1.56108975e-01f, -1.06387272e-01f, -6.13305047e-02f, -1.04619369e-01f, -8.83652046e-02f, 6.46501929e-02f, 1.23227143e-03f, 5.59532382e-02f,
  -7.56494924e-02f, 7.19746202e-02f, -7.09788129e-02f, -1.12531126e-01f, -2.58354526e-02f, 3.29463333e-02f, 7.50729218e-02f, -1.63821146e-01f, 1.36119490e-02f, 8.44817609e-02f,
  1.06463686e-01f, -1.31838009e-01f, 1.14870578e-01f, 5.42262802e-03f, 7.23359808e-02f, 1.39993444e-01f, -2.93611232e-02f, 9.30222794e-02f, -1.43993080e-01f, 4.33848053e-02f,
  2.30226949e-01f, -3.08725953e-01f, -1.46624194e-02f, 1.13022029e-01f, -9.02542323e-02f, -4.65794876e-02f, -1.01078399e-01f, -1.93995520e-01f, -6.29814938e-02f, -1.42083287e-01f,
  1.17046051e-01f, -4.68534715e-02f, -1.81444868e-01f, -3.23944002e-01f, 1.59098998e-01f, 1.27152696e-01f, 7.26999864e-02f, -1.14705205e-01f, 1.80117533e-01f, 4.75477949e-02f,
  1.53977603e-01f, -1.54318688e-02f, -7.11911544e-02f, 1.42917737e-01f, -3.53772193e-02f, 1.84299471e-03f, 2.14849085e-01f, -2.58449852e-01f, 1.08361803e-02f, -1.27965480e-01f,
  -1.53486669e-01f, -2.20272839e-01f, 1.73591703e-01f, -1.46490097e-01f, 2.18488891e-02f, -2.08780691e-01f, 1.32780746e-01f, -7.74700716e-02f, -1.74748421e-01f, -3.42590511e-02f,
  -4.49072085e-02f, 8.69774222e-02f, -1.00190401e-01f, -9.31642354e-02f, -1.41156074e-02f, 1.76306576e-01f, 1.28421545e-01f, 1.23552822e-01f, 3.40109840e-02f, 1.22061200e-01f,
  5.65257147e-02f, 6.93908110e-02f, -3.12235579e-02f, 7.73497820e-02f, 1.30174637e-01f, -4.47261892e-02f, 2.34648846e-02f, 1.18951201e-02f, 6.92322329e-02f, 8.56799819e-03f,
  -1.06995098e-01f, 6.58008158e-02f, 5.77314794e-02f, -2.21886352e-01f, -6.75712451e-02f, -6.20884262e-02f, 1.25094861e-01f, -1.16974272e-01f, -2.10070655e-01f, 1.89604342e-01f,
  4.67538042e-03f, -8.43795165e-02f, -1.05613187e-01f, -3.49044092e-02f, -2.23357335e-01f, -2.72624306e-02f, -1.50784090e-01f, 1.53586036e-02f, 1.02587730e-01f, -5.85420243e-02f,
  -7.91743621e-02f, -7.17014968e-02f, -5.96514046e-02f, -4.02912684e-02f, 3.83445174e-02f, -2.20272765e-01f, 1.74591124e-01f, -2.57545024e-01f, -1.07550323e-01f, 2.20780820e-01f,
  -2.07623228e-01f, 2.60328174e-01f, -1.30928308e-02f, 3.52107167e-01f, -2.02759132e-01f, 1.83082789e-01f, 2.09150389e-02f, -1.27029166e-01f, 4.17833962e-02f, -1.66116551e-01f,
  2.72058517e-01f, -1.63375571e-01f, -2.79901952e-01f, -3.99372019e-02f, -1.94938540e-01f, -1.09180674e-01f, -1.67991385e-01f, 1.10693707e-03f, 1.58953760e-03f, 3.25317755e-02f,
  1.05648115e-02f, 4.13847566e-02f, -9.11436751e-02f, 3.59656801e-03f, -5.74724153e-02f, -1.46935537e-01f, 2.02169027e-02f, -1.20083295e-01f, 5.61641492e-02f, -1.41914964e-01f,
  -1.29351988e-01f, -5.88895231e-02f, -1.87674478e-01f, -2.00414360e-01f, -1.11560032e-01f, 1.94852911e-02f, -4.77012917e-02f, -1.11597396e-01f, 3.63144875e-02f, -2.53084302e-01f,
  1.01628862e-01f, -2.50714988e-01f, 5.11629507e-02f, -3.01591158e-01f, 4.05174904e-02f, 3.36346716e-01f, -1.18919328e-01f, -2.22448930e-01f, -1.30613700e-01f, 3.77151892e-02f,
  -3.53228778e-01f, -1.01854444e-01f, 1.39354363e-01f, 8.65439698e-03f, -2.59204470e-02f, -2.45433569e-01f, 2.29889184e-01f, -7.07951337e-02f, 7.32594728e-02f, -2.30615154e-01f,
  1.57604799e-01f, 8.60220790e-02f, -1.84867054e-01f, 4.16443534e-02f, -1.44707516e-01f, -8.39516446e-02f, 2.10108116e-01f, -1.17084421e-02f, 1.07709073e-01f, -2.87921838e-02f,
  -2.53072172e-01f, -1.58150673e-01f, 1.39211521e-01f, 2.55940203e-02f, -7.91832134e-02f, 1.99878901e-01f, 3.95336635e-02f, -5.39919101e-02f, 1.51385199e-02f, 1.66944981e-01f,
  2.91586332e-02f, -1.17982395e-01f, -1.18616499e-01f, 1.16025336e-01f, -6.41367259e-03f, -5.69558367e-02f, 1.45599870e-02f, 1.96339071e-01f, -5.21539487e-02f, -9.30667296e-02f,
  -1.54748708e-01f, 6.36488125e-02f, 2.35824868e-01f, 5.80584966e-02f, -3.50516215e-02f, -9.13416892e-02f, 1.63450822e-01f, -2.40940005e-02f, -2.49374062e-01f, 4.87040207e-02f,
  -4.41071624e-03f, -1.77758634e-02f, 1.45766363e-01f, -2.55069941e-01f, 1.37910247e-01f, 3.00392136e-02f, -2.54803687e-01f, 8.36775601e-02f, -3.67048383e-02f, -2.24675640e-01f,
  -3.32312547e-02f, -3.51827927e-02f, 2.45298054e-02f, -1.48479477e-01f, -7.84103125e-02f, -2.09891260e-01f, 2.07195267e-01f, -3.26759741e-03f, 6.63369223e-02f, 9.79900211e-02f,
  1.13847263e-01f, -2.24326909e-01f, 2.26512477e-01f, -1.13362432e-01f, -1.47998393e-01f, 6.10963702e-02f, 6.45732954e-02f, 1.74701422e-01f, 9.06010866e-02f, -3.71523440e-01f,
  5.24122408e-03f, -1.99045524e-01f, -2.50246257e-01f, -1.81039944e-01f, 1.85933262e-01f, -2.15288639e-01f, -1.20279543e-01f, -2.14688420e-01f, 3.71247500e-01f, -1.39233440e-01f,
  -5.78546524e-02f, -1.90414116e-01f, -7.73450807e-02f, 5.43155968e-02f, -9.17286053e-02f, 2.92291999e-01f, 6.22920804e-02f, 1.17878556e-01f, -6.60188496e-02f, 2.09924709e-02f,
  -5.60366437e-02f, 1.07235104e-01f, 8.28870200e-03f, -8.31183568e-02f, 4.67680432e-02f, -7.91522413e-02f, -1.03441849e-01f, 1.92092806e-02f, 1.55342340e-01f, -4.70899493e-02f,
  -1.15617298e-01f, 1.49992453e-02f, 1.48507372e-01f, -1.24283299e-01f, 4.07654159e-02f, -6.82089105e-02f, 8.06577802e-02f, -3.56585998e-03f, 2.44414825e-02f, -4.39519063e-02f,
  7.17007220e-02f, -3.64679061e-02f, -1.98944896e-01f, -1.27665922e-01f, -2.74072856e-01f, 1.28417432e-01f, 5.25948964e-02f, 4.01227102e-02f, -9.18051228e-02f, -2.51033753e-01f,
  2.79327184e-01f, 2.26609543e-01f, 1.85471565e-01f, -9.82380435e-02f, 1.98795870e-01f, 2.45042235e-01f, 1.02298735e-02f, -1.21409439e-01f, 1.02879271e-01f, 6.63756207e-02f,
  -2.29184359e-01f, 1.13330141e-01f, 1.82337910e-01f, 1.96917266e-01f, 1.45261571e-01f, -4.52084057e-02f, -1.05189957e-01f, 1.60936162e-01f, 2.98997611e-01f, -2.04182237e-01f,
  1.96128502e-01f, -2.95761675e-01f, -6.62241355e-02f, -4.87541333e-02f, 1.87766746e-01f, 6.68191239e-02f, 9.80158895e-02f, -4.42223065e-02f, -5.62856607e-02f, 9.27140042e-02f,
  -1.48528637e-02f, -4.54993024e-02f, -7.24298432e-02f, 1.02356143e-01f, -1.21186897e-01f, 1.51615247e-01f, -1.05974898e-01f, -1.81953963e-02f, 1.59054518e-01f, 3.09348088e-02f,
  -2.35698074e-01f, -4.08021919e-02f, 1.49051219e-01f, 6.18512072e-02f, -1.51185632e-01f, -3.72412317e-02f, 4.91848774e-02f, -4.61455621e-02f, -8.00057948e-02f, 9.46235359e-02f,
  -2.48034537e-01f, 1.99833572e-01f, 1.83771290e-02f, 2.38615666e-02f, 1.82222679e-01f, -1.72369599e-01f, -1.17400624e-01f, -7.99706206e-02f, 1.01033583e-01f, 2.04001606e-01f,
  1.80849835e-01f, 9.89939943e-02f, 7.34835342e-02f, 1.12279706e-01f, 1.24794198e-02f, 2.08586693e-01f, -6.79090107e-03f, 5.64314164e-02f, -1.29277036e-01f, 2.79979616e-01f,
  -1.44194126e-01f, 1.53945163e-01f, -5.34486100e-02f, 1.43791109e-01f, -9.02142227e-02f, 7.19749406e-02f, 1.45477846e-01f, 1.98517829e-01f, -5.24290130e-02f, 1.37442663e-01f,
  -6.58836067e-02f, 1.73982993e-01f, 1.77401394e-01f, 9.89743471e-02f, 7.25392774e-02f, 9.50560495e-02f, -1.69256881e-01f, -1.02781370e-01f, -2.42584735e-01f, -8.84451345e-03f,
  -1.51331320e-01f, 9.42949727e-02f, 1.72715299e-02f, 7.26742223e-02f, 3.52684334e-02f, 2.58304011e-02f, -5.85721284e-02f, 4.12733890e-02f, 5.98382726e-02f, -9.86068249e-02f,
  -1.30378142e-01f, -2.53371466e-02f, 1.98243916e-01f, -2.84282230e-02f, 5.14423773e-02f, 7.58601399e-03f, 8.56688097e-02f, -1.68354083e-02f, -1.04341641e-01f, -1.91984117e-01f,
  -7.55718574e-02f, -1.25032812e-01f, 4.06282656e-02f, 1.18890055e-01f, -7.91423842e-02f, -2.21509725e-01f, 5.38857542e-02f, -4.64760289e-02f, -9.29242838e-03f, -4.70232293e-02f,
  1.98829681e-01f, 2.19545841e-01f, -2.23533913e-01f, -9.00113061e-02f, 1.41602301e-03f, -1.18798241e-01f, -1.12540931e-01f, 5.75124100e-03f, 3.09032295e-02f, -1.93878382e-01f,
  -1.80782765e-01f, 6.22494239e-03f, 6.16290495e-02f, -3.93683612e-02f, -3.50764990e-02f, -1.97278440e-01f, -5.02360053e-02f, 2.52161324e-01f, -1.52517527e-01f, -1.20808082e-02f,
  -1.94635034e-01f, -1.18196629e-01f, 1.64504677e-01f, -9.12546366e-02f, 2.31402680e-01f, 4.61040214e-02f, -8.51328671e-02f, -3.22054303e-03f, 1.10406727e-01f, 7.93572813e-02f,
  2.42093503e-01f, 2.15783015e-01f, 1.91998467e-01f, 1.31249040e-01f, -1.09454110e-01f, -9.27039385e-02f, -5.39389625e-02f, 7.80925378e-02f, 8.94296989e-02f, 5.89376129e-02f,
  8.43882337e-02f, 5.42772077e-02f, 6.85477182e-02f, -1.98171735e-02f, 4.88731936e-02f, -9.76183861e-02f, -1.19718872e-01f, 5.68660013e-02f, 1.41993091e-01f, -1.21376194e-01f,
  -5.97024746e-02f, 1.19700499e-01f, -1.79143418e-02f, -7.48706833e-02f, -4.63957805e-03f, -5.82373701e-02f, -1.14315316e-01f, 8.35359097e-02f, 1.34416252e-01f, 1.64543837e-01f,
  -1.44110575e-01f, 2.67636150e-01f, 1.30018041e-01f, -7.84074068e-02f, 3.69492592e-03f, -2.64063388e-01f, -7.60904467e-03f, 1.25693129e-02f, 1.93526298e-01f, -1.94919884e-01f,
  8.03022645e-03f, 5.67912050e-02f, 4.01413254e-02f, 2.06822902e-01f, 1.30053878e-01f, 2.44984757e-02f, 5.14569394e-02f, -1.25734344e-01f, -1.53664155e-02f, 9.90872383e-02f,
  -2.69895326e-02f, -5.01060449e-02f, 2.81582803e-01f, -1.74060673e-01f, 2.31954485e-01f, 1.11408554e-01f, -3.14205855e-01f, -3.06342300e-02f, -8.94797593e-02f, -1.43178716e-01f,
  2.07874671e-01f, 2.66113311e-01f, -2.71340489e-01f, -2.29948819e-01f, 5.82293794e-02f, -8.67667124e-02f, 1.39824346e-01f, -4.59185019e-02f, -8.67457464e-02f, -1.29622042e-01f,
  8.60811546e-02f, -2.78287306e-02f, 6.03451394e-03f, -1.79728940e-01f, 1.06214195e-01f, 3.75961550e-02f, -9.23255309e-02f, -1.28509104e-01f, 2.78001577e-02f, 1.18055917e-01f,
  -1.74937874e-01f, 1.27562299e-01f, -6.85166642e-02f, -6.99255690e-02f, -3.31241600e-02f, 6.36372939e-02f, -8.60402212e-02f, 1.15830891e-01f, 1.90858051e-01f, -7.02904537e-02f,
  3.09031866e-02f, 1.00404695e-01f, -4.53041866e-03f, 1.59192383e-01f, -2.22188175e-01f, 2.63779551e-01f, 7.18476325e-02f, 1.49119854e-01f, -4.87863608e-02f, 6.04237467e-02f,
  1.47421867e-01f, 2.34719276e-01f, 3.66155393e-02f, 2.94291496e-01f, 1.06795587e-01f, 4.17383797e-02f, -2.53636479e-01f, -1.44084483e-01f, -2.15438053e-01f, 2.71309186e-02f,
  3.88251692e-02f, 1.39824405e-01f, 2.75580436e-01f, 9.62121114e-02f, 6.45597291e-04f, -1.66091874e-01f, 2.38547385e-01f, -1.34443551e-01f, 1.68971509e-01f, 1.30015789e-02f,
  4.89364564e-02f, -1.77190617e-01f, 7.72036389e-02f, -1.48948058e-01f, 1.63270608e-01f, 2.37569079e-01f, 9.54800323e-02f, -9.79739204e-02f, -5.22832274e-02f, 2.80385278e-02f,
  1.52797103e-01f, 2.20333457e-01f, -1.28948092e-02f, -5.36741316e-02f, -1.02704786e-01f, -8.34110156e-02f, 1.03932329e-01f, -1.86522946e-01f, -3.26967333e-03f, 7.97300115e-02f,
  1.31935254e-01f, -8.55672583e-02f, 6.29866496e-02f, -5.47355637e-02f, -8.46896097e-02f, 1.05579093e-01f, -1.09805644e-01f, -3.99318486e-02f, -1.19449504e-01f, 8.52159113e-02f,
  4.78014052e-02f, -1.08457513e-01f, 8.27050805e-02f, -8.47751871e-02f, -1.37864709e-01f, -3.36745344e-02f, 6.15433753e-02f, 2.31994629e-01f, 1.66219603e-02f, 1.90029338e-01f,
  3.75138283e-01f, -1.75725400e-01f, 1.51959106e-01f, 1.08847925e-02f, -6.11235313e-02f, 1.72307000e-01f, -2.63323840e-02f, -1.60505161e-01f, -2.24364288e-02f, 1.96775481e-01f,
  -1.15294218e-01f, 2.21984282e-01f, 1.52989537e-01f, 6.03583865e-02f, -4.15009446e-04f, -9.16641057e-02f, -2.03207344e-01f, -3.80037352e-02f, -1.04028031e-01f, 5.04289381e-02f,
  1.79519057e-01f, -1.05537914e-01f, -4.99298200e-02f, 7.01543018e-02f, -1.07567549e-01f, 5.83510520e-03f, 3.62163000e-02f, -8.07247832e-02f, 1.33676618e-01f, 2.83795178e-01f,
  -1.60471737e-01f, 3.33325006e-02f, -9.62444469e-02f, -1.27835095e-01f, -6.42845258e-02f, 1.40815586e-01f, 3.77562121e-02f, 8.30094740e-02f, -5.87756047e-03f, -1.44643977e-01f,
  -1.57326341e-01f, -5.11127822e-02f, 3.00787967e-02f, -1.99418664e-02f, 6.23106100e-02f, 3.16782258e-02f, 1.33494213e-01f, -4.18663584e-02f, 1.36113465e-01f, 1.85223565e-01f,
  -1.49724796e-01f, 1.81270301e-01f, -1.58663884e-01f, -6.94511160e-02f, -1.25620633e-01f, -1.05718030e-02f, -1.57154560e-01f, 1.73509512e-02f, 1.53062701e-01f, 2.75622010e-01f,
  -1.67673886e-01f, 8.69938061e-02f, 2.12277383e-01f, -8.46007243e-02f, -8.90377089e-02f, -8.18833113e-02f, 3.02117076e-02f, 1.77244663e-01f, 1.15432583e-01f, 2.51312032e-02f,
  -3.05082083e-01f, -1.43015534e-01f, -1.08319663e-01f, 3.10053676e-01f, -2.05892827e-02f, -1.91212222e-01f, 8.70255828e-02f, -3.35770808e-02f, 8.67889449e-02f, 8.79616365e-02f,
  -4.51306105e-02f, 1.88976541e-01f, 7.32683465e-02f, 1.01501472e-01f, -3.13793235e-02f, -8.65646228e-02f, -1.69983760e-01f, -5.07981405e-02f, 1.90280959e-01f, -9.43751931e-02f,
  4.90688533e-02f, 1.87661096e-01f, -3.98044199e-01f, -2.98804734e-02f, 6.05921969e-02f, 1.15390934e-01f, -1.09643131e-01f, 8.79277512e-02f, -4.10006344e-02f, 4.85529453e-02f,
  4.63433862e-02f, 8.37359503e-02f, -8.58483538e-02f, -3.45197842e-02f, -5.49261719e-02f, -6.56838864e-02f, -1.56902775e-01f, -1.46804288e-01f, -5.72088510e-02f, 5.78739382e-02f,
  -6.23180158e-02f, 1.12684228e-01f, 1.07600681e-01f, -1.13945216e-01f, -3.33588123e-02f, 9.38240439e-02f, 4.19011861e-02f, -6.35300875e-02f, 2.04500630e-01f, 1.19291589e-01f,
  1.52042089e-02f, -3.12406924e-02f, 1.27060309e-01f, -1.30839854e-01f, -3.05547535e-01f, -9.76746082e-02f, 1.37030602e-01f, -3.15587014e-01f, -2.94904917e-01f, 1.30297616e-01f,
  -1.45080268e-01f, -5.86461090e-02f, 1.19392224e-01f, -1.91065267e-01f, -2.09064111e-01f, -1.43441767e-01f, -1.61809757e-01f, 9.30193141e-02f, 1.77521363e-01f, -1.94538310e-01f,
  4.06430773e-02f, 6.67731874e-05f, -3.24663855e-02f, 7.15931458e-03f, -1.24040768e-02f, -2.67238729e-02f, 1.49205878e-01f, -1.06768496e-01f, -2.07236707e-01f, 2.00762957e-01f,
  -1.81243882e-01f, -5.06730787e-02f, 3.68238203e-02f, 6.44212738e-02f, -6.64799437e-02f, 2.33941823e-01f, -2.48736009e-01f, -2.52660215e-01f, 5.70526086e-02f, 1.26088202e-01f,
  1.04559753e-02f, 8.47430006e-02f, -6.53163046e-02f, -1.51964471e-01f, -1.26006842e-01f, -1.80158578e-02f, 1.27902955e-01f, 1.32960647e-01f, -7.72797763e-02f, -2.16211993e-02f,
  9.08900574e-02f, -6.53942078e-02f, -1.64541341e-02f, -1.16353750e-01f, -7.73828998e-02f, -3.29052396e-02f, -4.46970686e-02f, 5.17466441e-02f, 3.90681997e-02f, -2.41161436e-01f,
  4.01578620e-02f, -4.16061915e-02f, -1.32307425e-01f, -1.21648498e-01f, 1.28547117e-01f, -1.19730979e-01f, -5.17589115e-02f, -6.92292750e-02f, 2.47461021e-01f, 1.95574954e-01f,
  -2.34382421e-01f, 2.70089388e-01f, 3.72607917e-01f, -6.75226897e-02f, -2.28589755e-02f, -1.93793952e-01f, -3.50338295e-02f, 1.91748202e-01f, 2.87215680e-01f, 9.53505039e-02f,
  9.96613991e-04f, -5.36805689e-02f, -1.66464537e-01f, 1.53695390e-01f, 7.35913813e-02f, 1.58771560e-01f, 8.57304558e-02f, 7.69240409e-02f, 1.58696011e-01f, 9.76868048e-02f,
  -8.68608654e-02f, 3.35696004e-02f, 9.46535245e-02f, -1.49062604e-01f, 3.67919832e-01f, 9.59084481e-02f, 1.58083159e-02f, -2.68946141e-01f, 3.51861268e-02f, -3.14077467e-01f,
  3.42407405e-01f, 2.78048545e-01f, 1.65348127e-02f, -2.16212451e-01f, -7.88200274e-02f, -1.20717056e-01f, -1.49117699e-02f, -5.92688136e-02f, -4.45131138e-02f, 1.01271093e-01f,
  -3.82755771e-02f, 1.09409742e-01f, -1.30592078e-01f, -9.77555290e-02f, -2.05955133e-01f, -1.46101743e-01f, -1.43870294e-01f, -1.88160536e-03f, -1.38338208e-02f, -1.65100947e-01f,
  1.20535247e-01f, 5.95884770e-02f, -8.70066658e-02f, -2.24131607e-02f, -2.10871354e-01f, 4.65218350e-02f, -7.86486119e-02f, -1.96268916e-01f, 4.05660495e-02f, -1.54210106e-01f,
  1.18087053e-01f, 1.68694034e-02f, -1.06059507e-01f, 1.55731946e-01f, 2.28435442e-01f, -7.20826238e-02f, 2.38278762e-01f, -4.28108841e-01f, -1.27596661e-01f, 2.96350896e-01f,
  -2.55690396e-01f, 1.04137331e-01f, -2.13237882e-01f, -4.90879342e-02f, -2.39891812e-01f, 2.56453872e-01f, -5.71952835e-02f, -2.58155502e-02f, 2.81350315e-01f, -2.43840724e-01f,
  3.71809065e-01f, -1.93351787e-02f, -1.40129879e-01f, -4.87341061e-02f, 2.66212463e-01f, 6.55729994e-02f, -2.47838140e-01f, -2.57674962e-01f, -1.35526985e-01f, 3.44242454e-01f,
  3.01229209e-01f, 4.33436707e-02f, 1.23075329e-01f, -4.91367914e-02f, -1.06940567e-02f, -1.61998853e-01f, 2.72749007e-01f, 2.62103975e-01f, -2.43112653e-01f, 1.72469825e-01f,
  -2.45586839e-02f, 1.43363066e-02f, 2.52141077e-02f, 1.19454876e-01f, 2.20423955e-02f, 1.42622694e-01f, 6.50545731e-02f, 1.87342931e-02f, -3.18500325e-02f, 5.69720268e-02f,
  5.95438248e-03f, -4.33593802e-02f, 7.00645475e-03f, -1.12758987e-02f, 2.74415500e-02f, 3.65218557e-02f, 1.04911119e-01f, -2.72463653e-02f, -4.10483172e-03f, -7.69990534e-02f,
  -1.54311582e-01f, 2.61000358e-02f, -1.47471666e-01f, -1.63402911e-02f, 5.32394424e-02f, 2.04321504e-01f, 5.95034212e-02f, -1.54130936e-01f, -5.19676767e-02f, 1.63634479e-01f,
  -3.78647968e-02f, 2.02964455e-01f, 1.65086284e-01f, 2.71217339e-02f, 1.88404589e-03f, -3.40773277e-02f, 1.74211279e-01f, 2.03773558e-01f, -7.65147060e-03f, -9.25460085e-03f,
  -9.02398378e-02f, -1.96074620e-01f, -6.11057319e-02f, 1.14777789e-01f, -1.09265178e-01f, 8.21749941e-02f, 8.52991492e-02f, -8.36671442e-02f, -7.57435784e-02f, 1.89211741e-01f,
  1.23778783e-01f, -1.14038154e-01f, 4.91294786e-02f, -2.77419835e-01f, 1.95565313e-01f, -2.60741621e-01f, 1.56125665e-01f, -8.29527676e-02f, -1.64796010e-01f, 2.42939055e-01f,
  2.44901478e-01f, 7.41536021e-02f, -2.27217991e-02f, -3.12013775e-02f, -1.42886853e-02f, 1.74647346e-01f, 1.98522732e-01f, 1.66599795e-01f, 5.67233637e-02f, -1.41144454e-01f,
  -1.46410346e-01f, 8.64655674e-02f, 8.09047297e-02f, 1.66876689e-02f, 1.51001781e-01f, 1.22826602e-02f, 1.30333290e-01f, -9.29108784e-02f, -6.48417845e-02f, 1.78855523e-01f,
  -2.59724315e-02f, 3.29218898e-03f, -3.27254206e-01f, 1.06581017e-01f, 1.16652146e-01f, -1.16196662e-01f, -1.44401506e-01f, 9.71663892e-02f, -1.60319991e-02f, 5.17351739e-02f,
  7.82484561e-02f, 4.01914306e-02f, 2.29238912e-01f, 5.52968420e-02f, 9.87872034e-02f, -2.11276487e-01f, -1.58578470e-01f, 3.73625942e-02f, -2.93034501e-02f, 3.28883715e-02f,
  -2.25429952e-01f, -1.85058534e-01f, -1.02452934e-01f, 1.73503935e-01f, -3.06604337e-02f, -1.45420060e-01f, 2.55196095e-01f, -7.84918964e-02f, 2.47117445e-01f, 2.78424490e-02f,
  -9.37589109e-02f, 1.54224858e-01f, 4.19281386e-02f, 3.74327210e-05f, 6.82482123e-02f, -2.96573251e-01f, -1.87725984e-02f, 5.99483736e-02f, 1.18654042e-01f, 1.16299368e-01f,
  -4.92950082e-02f, 5.26069012e-03f, 1.26990331e-02f, -1.72945231e-01f, 2.33331054e-01f, 2.50887126e-01f, -1.23870485e-01f, 1.55773744e-01f, -2.81871688e-02f, 3.36085297e-02f,
  -3.88059439e-03f, -5.29323369e-02f, -6.53628558e-02f, 3.98973189e-02f, 1.38920069e-01f, -1.37935309e-02f, 5.57909720e-02f, -7.75338858e-02f, 8.88408944e-02f, 6.87297294e-03f,
  -2.01067049e-02f, -1.18269131e-01f, 1.72656700e-01f, -9.72968787e-02f, 1.29648462e-01f, 1.45879433e-01f, 1.17721207e-01f, 2.88379658e-02f, 1.19745202e-01f, -7.24036768e-02f,
  -2.11249962e-02f, -1.41556347e-02f, 9.08129290e-02f, -1.95108905e-01f, -1.81137994e-01f, 1.82187569e-03f, -3.86284804e-03f, -2.34185338e-01f, -1.43571034e-01f, -9.95803177e-02f,
  2.48932570e-01f, 6.56454787e-02f, 1.09290421e-01f, -1.99940279e-01f, -3.15216780e-02f, 5.24752028e-02f, 1.62979532e-02f, -9.79221091e-02f, 1.12024054e-01f, -7.93515220e-02f,
  -1.53995931e-01f, -1.69241101e-01f, -2.32517377e-01f, -3.98663618e-02f, -1.84562415e-01f, -1.91876933e-01f, -6.62671104e-02f, -5.06830886e-02f, -7.57860690e-02f, 1.95409194e-01f,
  -2.03584507e-01f, -4.84883860e-02f, -1.19032174e-01f, 3.01752746e-01f, 2.78452486e-01f, 1.19909227e-01f, -3.36071312e-01f, 4.51488830e-02f, -6.59068823e-02f, 1.44864723e-01f,
  9.79701206e-02f, 1.47084072e-01f, 1.14999130e-01f, 1.72027722e-02f, 7.91715011e-02f, -2.03474969e-01f, -1.49245160e-02f, -1.64709732e-01f, 1.33198982e-05f, -3.33020128e-02f,
  1.36854693e-01f, 2.91088391e-02f, -5.09895198e-02f, -8.03797841e-02f, 4.82424945e-02f, 2.58433130e-02f, -6.51874915e-02f, -1.68316826e-01f, 9.78699774e-02f, 9.27754045e-02f,
  -2.37044282e-02f, -1.67176992e-01f, 5.64442873e-02f, 2.01132391e-02f, 1.02720425e-01f, -2.26559285e-02f, -1.81886256e-01f, -1.05519988e-01f, -6.63566962e-02f, -7.07566291e-02f,
  -1.21623585e-02f, 2.79207365e-03f, -2.49700502e-01f, 3.93053502e-01f, -3.39522138e-02f, -3.34682278e-02f, 2.05796719e-01f, -7.29186907e-02f, 1.46791255e-02f, 2.64493972e-01f,
  1.99533045e-01f, -2.02231798e-02f, 2.66987961e-02f, -1.73203051e-01f, -3.10457021e-01f, 1.39003739e-01f, -2.54913419e-01f, -1.85478374e-01f, -3.41510735e-02f, -9.50540155e-02f,
  9.82178971e-02f, -2.08711565e-01f, -3.01163010e-02f, 6.67546690e-02f, -1.15850143e-01f, -2.43456773e-02f, -1.94820553e-01f, 2.03438431e-01f, -5.30788302e-02f, 1.79045320e-01f,
  -1.80862382e-01f, 5.65096699e-02f, -1.63490489e-01f, -9.78711098e-02f, 2.04901159e-01f, -1.19303569e-01f, -6.95497990e-02f, -1.59225330e-01f, -7.59802386e-02f, -8.21002424e-02f,
  1.27611458e-02f, 9.61681753e-02f, 8.56307819e-02f, -5.48136421e-02f, -1.00539885e-01f, 1.50699168e-01f, -1.72376752e-01f, -7.02879652e-02f, -8.39918926e-02f, -1.43907428e-01f,
  1.11248724e-01f, 8.26847926e-03f, 1.07021421e-01f, -7.43398294e-02f, -8.36917162e-02f, 2.17386261e-02f, -1.60659999e-01f, -8.55150819e-02f, 2.66674273e-02f, -1.06484123e-01f,
  -1.13654621e-01f, 5.86606748e-03f, 2.06209436e-01f, -1.95848078e-01f, -2.06435136e-02f, 1.49216935e-01f, 2.57346720e-01f, -4.23219837e-02f, 1.58572003e-01f, 5.48558645e-02f,
  -1.71780154e-01f, -4.24028710e-02f, 1.55307814e-01f, 7.38588572e-02f, -2.48394266e-01f, -1.22558344e-02f, -1.68419585e-01f, 1.32982761e-01f, -1.15419216e-01f, -8.01498517e-02f,
  2.43343472e-01f, -1.55873835e-01f, 2.21866295e-01f, -1.77946642e-01f, -1.20854564e-01f, 1.45216156e-02f, -5.64991534e-02f, -3.39286774e-02f, 1.01908721e-01f, -5.76585568e-02f,
  7.24610463e-02f, -6.22511022e-02f, 1.98768675e-01f, -2.34648392e-01f, 2.58741826e-02f, 2.21300587e-01f, 3.90154719e-02f, -1.25770807e-01f, 7.20422715e-02f, 7.32718334e-02f,
  3.72670591e-02f, 1.49496431e-02f, 9.61366519e-02f, 1.82673484e-01f, -5.06856740e-02f, -7.94644207e-02f, 1.92495361e-02f, 1.20916687e-01f, 5.69179207e-02f, -2.48085577e-02f,
  1.20508604e-01f, -2.86542568e-02f, 1.98342074e-02f, 3.81183298e-03f, -1.53994888e-01f, 1.76486358e-01f, 3.76705602e-02f, 1.33159339e-01f, -1.67394020e-02f, -1.68027426e-03f,
  4.08891551e-02f, -6.92500696e-02f, -8.49404372e-03f, 9.13726613e-02f, -9.42912027e-02f, 2.50963241e-01f, 2.71837395e-02f, 1.26282498e-01f, 3.25274724e-03f, 2.67644376e-01f,
  -1.85359582e-01f, 2.16300264e-01f, -2.43472889e-01f, -1.57081801e-02f, 2.35644087e-01f, 3.23833883e-01f, -2.11482465e-01f, -2.92128813e-03f, 8.97754356e-02f, 1.13974653e-01f,
  -3.31323445e-02f, -8.89443085e-02f, 8.11686087e-03f, 1.58923775e-01f, -4.65179458e-02f, 1.86680257e-01f, 2.80373871e-01f, -4.58956882e-03f, -6.82365056e-03f, 8.10499862e-02f,
  2.48736605e-01f, -1.07111596e-01f, -6.93107843e-02f, -9.72474515e-02f, 2.63831764e-01f, -5.62883355e-03f, -5.69631942e-02f, -7.79884234e-02f, 1.12501472e-01f, -1.54011017e-02f,
  3.18273842e-01f, -1.38232619e-01f, 1.44990515e-02f, -5.68329208e-02f, -1.23261489e-01f, -3.05704325e-02f, -1.63339619e-02f, 6.12611063e-02f, -4.36649621e-02f, 2.00307354e-01f,
  -4.28208821e-02f, -7.50190485e-03f, -9.80991125e-03f, 3.12422179e-02f, -9.20529291e-02f, 1.25465438e-01f, 6.74543157e-02f, -1.46756440e-01f, -7.00727999e-02f, 2.06703208e-02f,
  -4.96168323e-02f, -1.32042751e-01f, 2.31546149e-01f, 2.69354135e-03f, 1.27909303e-01f, 2.45145578e-02f, -3.58477123e-02f, -4.29279022e-02f, -2.40447596e-02f, -1.76830918e-01f,
  7.64719546e-02f, -1.82008818e-01f, 5.86508773e-03f, -1.60953417e-01f, 3.15546244e-02f, -8.21134448e-02f, 1.38120502e-02f, -2.24989001e-02f, -2.50997841e-01f, -1.62698135e-01f,
  7.24804625e-02f, 8.33196267e-02f, 7.23464787e-02f, -3.33948880e-01f, 3.18864256e-01f, 1.33675173e-01f, -4.35236730e-02f, -1.13721631e-01f, -1.72314107e-01f, -5.11874780e-02f,
  7.20732734e-02f, -1.87353790e-01f, 1.25393961e-02f, -7.77194574e-02f, -8.70614350e-02f, 2.35478237e-01f, 2.02284873e-01f, 3.59097868e-02f, -8.88189115e-03f, 2.53096540e-02f,
  -1.33816674e-01f, 9.15644690e-02f, 2.00098008e-01f, 1.07180543e-01f, -8.04132968e-02f, -2.87813634e-01f, 1.39106929e-01f, -1.16365179e-01f, 2.33832687e-01f, 7.22003132e-02f,
  1.40516654e-01f, -5.39228208e-02f, 4.34192754e-02f, 5.81154451e-02f, 1.13639325e-01f, -8.59300569e-02f, 2.24172622e-01f, -4.99193184e-02f, 9.25316066e-02f, 4.10492606e-02f,
  1.12199262e-01f, -1.92763153e-02f, -2.23483503e-01f, 7.72894472e-02f, -1.26544341e-01f, -1.61011562e-01f, 1.79358110e-01f, -1.51230078e-02f, -1.04480110e-01f, 8.85703117e-02f,
  8.48173127e-02f, 4.59821522e-02f, 8.15805122e-02f, -7.72505477e-02f, 9.19708759e-02f, 1.68339625e-01f, -1.16647035e-01f, 3.24617088e-01f, 1.60294607e-01f, 2.62607962e-01f,
  -1.48887888e-01f, -2.87514776e-01f, 8.84070620e-02f, 2.66530842e-01f, 2.42293671e-01f, 2.22496778e-01f, 1.08196437e-01f, -4.22894545e-02f, -1.55946702e-01f, 3.65862511e-02f,
  -1.36691451e-01f, 2.36942559e-01f, -1.24446057e-01f, 7.94580951e-02f, 1.44473791e-01f, 2.31942117e-01f, 7.43269101e-02f, -2.32640818e-01f, 3.14952940e-01f, -1.19224317e-01f,
  2.14304343e-01f, 7.74381980e-02f, -6.83296844e-02f, -1.72096208e-01f, -1.88261583e-01f, 8.36974569e-03f, 3.13437968e-01f, 1.92380786e-01f, -9.75904986e-02f, -2.48909906e-01f,
  -1.90922931e-01f, -2.56650984e-01f, -1.32541791e-01f, -1.18387178e-01f, 1.04141995e-01f, -3.54174268e-03f, 1.03051923e-02f, 9.99771282e-02f, 6.50913566e-02f, -6.57590628e-02f,
  -6.97227428e-03f, 5.47911488e-02f, 1.31035019e-02f, -2.21748099e-01f, -4.99774069e-02f, 1.03160841e-02f, -6.82371482e-02f, -7.78401047e-02f, 1.07100777e-01f, -3.44152935e-02f,
  -8.33077058e-02f, -8.55421498e-02f, 6.66097999e-02f, 7.24771097e-02f, 8.31151009e-02f, 4.59499434e-02f, -2.33206376e-02f, -1.22410417e-01f, 6.01216592e-03f, -3.48372608e-02f,
  1.02489861e-02f, -1.47838980e-01f, -1.33279935e-01f, 3.88850987e-01f, 1.47331003e-02f, 1.08321555e-01f, -1.04892857e-01f, -3.46972384e-02f, -2.43333146e-01f, 3.33421469e-01f,
  -1.37190729e-01f, -4.23751492e-03f, -1.21082269e-01f, 1.68546271e-02f, -1.61744058e-01f, -1.58115089e-01f, -3.61674204e-02f, -2.17643321e-01f, 8.06730092e-02f, -1.98739529e-01f,
  1.12830989e-01f, -2.91115820e-01f, -5.38584962e-02f, -7.52556846e-02f, -3.31599154e-02f, 2.01126114e-01f, 1.24491386e-01f, 1.53574452e-01f, 1.36312604e-01f, 1.09387957e-01f,
  5.30801434e-03f, 1.10692978e-01f, 3.67416173e-01f, -1.89303458e-01f, 2.62667984e-01f, -1.84785917e-01f, -4.48693931e-02f, -1.29669502e-01f, -1.14324503e-02f, -7.34372288e-02f,
  -1.13663010e-01f, 1.24097049e-01f, 1.24501839e-01f, -1.73463047e-01f, -1.22848317e-01f, 1.25634730e-01f, 3.71273458e-02f, -1.41049489e-01f, -6.88636675e-02f, 1.47416994e-01f,
  -3.41549702e-02f, 2.14347336e-02f, -5.03810644e-02f, -9.54937413e-02f, 5.53337894e-02f, 1.23640269e-01f, 6.19900525e-02f, 5.77939786e-02f, 2.34482288e-01f, -1.60586596e-01f,
  -4.57225293e-02f, -1.93115219e-01f, -1.71735153e-01f, 1.69353798e-01f, -1.60678372e-01f, -6.71174377e-02f, 2.67658196e-02f, 1.17058977e-01f, -2.43500754e-01f, -6.47390634e-02f,
  -8.10157135e-02f, 3.60997394e-02f, 1.93943799e-01f, 1.89386830e-01f, 6.97719008e-02f, -1.72357727e-02f, -8.80237296e-02f, 2.83882052e-01f, -9.10924524e-02f, -9.93453711e-02f,
  3.77276503e-02f, 4.65710834e-02f, -1.12942599e-01f, 1.30281761e-01f, 1.33115247e-01f, -9.28329676e-02f, -1.83546066e-01f, 4.86068241e-02f, 2.42138430e-01f, 1.17662527e-01f,
  -4.99823578e-02f, 1.72275037e-01f, 5.63083328e-02f, 2.20579907e-01f, 1.87183604e-01f, -1.01085968e-01f, -5.16127758e-02f, -2.67009705e-01f, -3.00313294e-01f, -7.17738643e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.44191349e-01f, 1.10734403e-01f, 9.57984254e-02f, 1.83143169e-01f, 7.51399696e-02f, 1.55401409e-01f, 3.88769172e-02f, 8.08152854e-02f, 1.38425156e-01f, 4.25018594e-02f,
  2.08813161e-01f, 7.24300146e-02f, 3.14551711e-01f, 1.78728074e-01f, 2.82513201e-01f, 2.40578994e-01f, -7.76621252e-02f, 2.67527372e-01f, 1.04428530e-01f, 8.41829926e-02f,
  1.34329736e-01f, 2.60028720e-01f, 3.02011639e-01f, 2.10870773e-01f, 1.68610334e-01f, 6.78468049e-02f, -1.04314007e-01f, 2.13829011e-01f, 1.62935685e-02f, 6.66280016e-02f,
  2.31365636e-02f, 1.09847328e-02f, -2.92343736e-01f, 2.63514239e-02f, 1.24371707e-01f, 3.20462555e-01f, -2.92621434e-01f, 1.73016250e-01f, -6.05884343e-02f, 2.54298210e-01f,
  -1.72578394e-01f, 1.34380460e-01f, 1.46524534e-01f, 2.42975075e-02f, 1.38328806e-01f, 2.44628862e-01f, -3.63039039e-02f, 8.19516331e-02f, 3.09710443e-01f, -2.00298354e-02f,
  -4.57973219e-02f, -1.38121367e-01f, 1.06445067e-02f, 5.04165769e-01f, 4.23284501e-01f, 3.07526469e-01f, -8.96169171e-02f, 1.63282707e-01f, 2.49213070e-01f, -1.56206697e-01f,
  3.03815544e-01f, 8.04973394e-02f, -2.83484101e-01f, 3.24653760e-02f, 8.33691731e-02f, 2.38231778e-01f, 1.84506271e-02f, 1.94682330e-01f, 5.94031699e-02f, 5.72831929e-02f,
  1.93339854e-01f, -6.69565634e-04f, 2.07347795e-01f, 2.17676863e-01f, 2.26751626e-01f, 2.62730181e-01f, 1.58484086e-01f, 1.53140381e-01f, 2.50578940e-01f, 4.64953557e-02f,
  2.60842115e-01f, 1.89042091e-02f, 2.92847544e-01f, 1.84753940e-01f, 3.66909523e-03f, -1.42117634e-01f, 8.87885392e-02f, 3.31519730e-03f, 9.79226902e-02f, 2.45505199e-01f,
  3.46823372e-02f, -3.22427899e-02f, -2.42133170e-01f, 1.65928870e-01f, 1.87590152e-01f, -9.30612758e-02f, 3.65078628e-01f, -9.38842371e-02f, 1.51901767e-01f, 1.49522796e-01f,
  2.85405397e-01f, -7.85388872e-02f, 2.47148961e-01f, -5.70517220e-02f, -8.73029083e-02f, -1.14956066e-01f, -3.33462320e-02f, 1.63244039e-01f, -8.58082920e-02f, 2.23443255e-01f,
  -1.01557828e-01f, 1.43366724e-01f, -3.40861917e-01f, 1.87809542e-01f, 2.07045734e-01f, 2.66703725e-01f, 1.14556894e-01f, -4.83338028e-01f, 7.97180161e-02f, -3.05339098e-01f,
  2.43131846e-01f, -2.61888117e-01f, 2.80902907e-02f, 4.03020173e-01f, -3.26091889e-03f, 6.57881722e-02f, 2.40620092e-01f, 1.25511378e-01f, 2.94771325e-02f, 3.28017086e-01f,
  1.85170650e-01f, 2.01786131e-01f, 1.81092441e-01f, 9.01634321e-02f, 6.22488819e-02f, 2.33762354e-01f, -2.90148389e-02f, 5.24537154e-02f, 2.51080751e-01f, 1.71914488e-01f,
  -1.19769322e-02f, 2.81347394e-01f, 1.86699495e-01f, 1.12941109e-01f, 9.49513987e-02f, 1.55009061e-01f, 2.93549627e-01f, 1.91052645e-01f, 2.67634869e-01f, 1.58014208e-01f,
  -2.06158720e-02f, 6.83582351e-02f, 6.15924671e-02f, 1.96499035e-01f, -7.46108294e-02f, -4.61366326e-02f, 3.55059914e-02f, -1.36054337e-01f, 1.11000665e-01f, -1.52983025e-01f,
  3.81473958e-01f, -2.22709104e-01f, 1.35487869e-01f, -2.83932011e-03f, -1.02579547e-02f, -3.47844779e-01f, 2.87092924e-01f, -1.76290676e-01f, 2.54801482e-01f, -8.70099217e-02f,
  1.46112576e-01f, 2.24341810e-01f, -1.52051479e-01f, 1.47670105e-01f, -2.71092147e-01f, -1.24002313e-02f, -3.27250004e-01f, 2.58301347e-01f, 1.86512411e-01f, 2.23491088e-01f,
  1.23312272e-01f, -3.99993509e-01f, -4.33752090e-02f, -1.03194892e-01f, 8.86967480e-02f, 2.21669048e-01f, -6.45312946e-04f, 3.66825968e-01f, -4.19509746e-02f, 2.66032755e-01f,
  2.70964831e-01f, 2.33297218e-02f, -5.27027398e-02f, 1.56204298e-01f, 1.13273911e-01f, -1.36925057e-02f, 1.78184941e-01f, 4.35506701e-02f, 2.67319083e-01f, 1.75943002e-01f,
  2.08460808e-01f, 1.09389126e-01f, -1.00488914e-02f, 7.03088194e-02f, 1.31573126e-01f, 1.79453775e-01f, -4.36598882e-02f, 7.08167478e-02f, 2.48808507e-02f, -5.89009970e-02f,
  3.01324636e-01f, 3.05401590e-02f, 1.25219524e-01f, 1.57387465e-01f, 6.24879263e-02f, 8.35413188e-02f, 1.49019882e-02f, -4.09895629e-02f, -3.71987931e-02f, -2.40604386e-01f,
  -1.31493732e-01f, -2.03494467e-02f, -3.64269465e-01f, 4.37927455e-01f, 8.37090611e-02f, -2.01290369e-01f, -7.30246957e-03f, -1.62820041e-01f, 1.29877940e-01f, 1.12383544e-01f,
  1.34170800e-01f, -1.52843297e-01f, 3.08888167e-01f, 4.17464692e-03f, -3.60653788e-01f, 1.01158015e-01f, -2.82919079e-01f, -1.08174138e-01f, -3.70544903e-02f, -5.18898815e-02f,
  -1.70195736e-02f, -5.56783900e-02f, -1.17948800e-01f, 2.80606091e-01f, 7.19257146e-02f, -1.07897364e-01f, -1.74914405e-01f, -1.05864145e-01f, 1.43875703e-02f, 4.86095361e-02f,
  5.26321456e-02f, 1.46863028e-01f, -3.33990186e-01f, -3.07623625e-01f, 2.32989594e-01f, -2.13981718e-01f, 9.97852907e-02f, -1.71853930e-01f, -6.09951541e-02f, 2.98179448e-01f,
  1.09162495e-01f, 1.73964977e-01f, -3.48046795e-02f, 2.80867040e-01f, 1.28281221e-01f, 1.75014421e-01f, 4.08467203e-02f, 1.38736004e-02f, 6.68907212e-03f, 1.38450801e-01f,
  6.21187948e-02f, 2.71113694e-01f, 8.24650899e-02f, 2.67540067e-01f, 1.85970768e-01f, 7.88702890e-02f, -4.34632935e-02f, 1.19030312e-01f, 2.90709846e-02f, 1.73328176e-01f,
  2.18032777e-01f, 2.50829339e-01f, -3.05714067e-02f, -1.85296267e-01f, -8.40868130e-02f, -1.81071892e-01f, -1.06121652e-01f, 2.50193864e-01f, -1.97112113e-01f, 4.42028232e-02f,
  -3.22202086e-01f, 5.43576702e-02f, 2.49447487e-02f, -1.82135459e-02f, -2.39559755e-01f, -8.03101510e-02f, -1.16853744e-01f, -3.59285802e-01f, -3.71137649e-01f, 9.91655737e-02f,
  1.73092917e-01f, 3.42750072e-01f, 3.79001379e-01f, -2.08168775e-01f, -2.42791213e-02f, 2.89701879e-01f, -2.00028792e-01f, 2.53976762e-01f, 5.35919964e-02f, -3.21911186e-01f,
  3.12081128e-01f, -2.09493056e-01f, 2.56501958e-02f, -4.86701401e-03f, -4.31092158e-02f, -2.33040124e-01f, 3.26144397e-01f, 5.17002828e-02f, 2.10517421e-01f, 2.93059886e-01f,
  1.01886503e-01f, 3.19354516e-03f, 4.56539765e-02f, 6.64678067e-02f, 1.92705035e-01f, 9.49207321e-02f, 1.41810134e-01f, -5.04078949e-03f, 1.85069263e-01f, 2.11877704e-01f,
  -9.93056409e-03f, 2.05245718e-01f, 4.64520007e-02f, 7.49056935e-02f, 1.44093307e-02f, -7.66917169e-02f, 2.49210075e-02f, -7.02693015e-02f, 3.77369732e-01f, 2.15285793e-01f,
  1.30836472e-01f, 2.64469653e-01f, 1.69924498e-01f, 1.00379409e-02f, 6.83429092e-02f, -9.07319859e-02f, 2.87678894e-02f, -4.19734828e-02f, -2.22735599e-01f, 1.56087980e-01f,
  -2.35017408e-02f, 8.88288021e-02f, -1.13433167e-01f, -2.24374190e-01f, 7.13252351e-02f, -9.47782099e-02f, 1.92196116e-01f, 2.23148555e-01f, 6.91161826e-02f, -3.19272250e-01f,
  1.28825828e-01f, 9.40186456e-02f, -2.26664215e-01f, 1.28541172e-01f, -1.38634250e-01f, 1.29144028e-01f, 1.13653541e-01f, 4.93147559e-02f, -2.39044458e-01f, -1.20290846e-01f,
  1.18397184e-01f, 5.85207567e-02f, 2.88460910e-01f, -5.90046830e-02f, -1.26963541e-01f, 3.01134903e-02f, 8.42031911e-02f, -1.23500936e-02f, 3.29078078e-01f, 2.52721429e-01f,
  -2.84511358e-01f, -2.59507209e-01f, 8.57463554e-02f, -2.13443473e-01f, 1.22836635e-01f, 1.76295504e-01f, 2.22141985e-02f, 1.77523732e-01f, 5.19404821e-02f, 1.62661597e-01f,
  5.03962077e-02f, -1.38937935e-01f, -6.04121760e-02f, 1.73410967e-01f, 2.73424517e-02f, 2.46364623e-02f, -8.04561824e-02f, 8.56304914e-02f, 1.15983337e-01f, 1.44616202e-01f,
  -7.20362440e-02f, -1.61983043e-01f, 1.79073676e-01f, 1.02961436e-02f, 1.23548523e-01f, -4.77942862e-02f, -2.53049470e-02f, -6.11325400e-03f, 2.51943879e-02f, 1.35065004e-01f,
  8.13350379e-02f, 1.08029552e-01f, 2.53944695e-02f, 2.88059056e-01f, 4.75181431e-01f, -3.82350355e-01f, 3.01059216e-01f, -3.16923857e-02f, -4.41173390e-02f, 1.80184260e-01f,
  3.41787279e-01f, -4.15402539e-02f, 2.56003678e-01f, 1.05514437e-01f, -2.78546929e-01f, 1.15506679e-01f, 3.02584946e-01f, 3.64052579e-02f, 5.63763306e-02f, 2.44542986e-01f,
  -2.63504505e-01f, 8.82581621e-02f, -2.81111538e-01f, 1.75195634e-01f, 1.59424633e-01f, -1.70348525e-01f, 1.79063007e-01f, 2.65564859e-01f, -3.87819335e-02f, -2.49394607e-02f,
  2.48579830e-01f, -1.24415584e-01f, 2.46603042e-01f, 3.94100606e-01f, -9.54122320e-02f, 3.15257430e-01f, -2.34175533e-01f, -8.21409933e-03f, -3.71765867e-02f, -1.99847221e-01f,
  -1.51490331e-01f, 8.31881240e-02f, 6.10254407e-02f, 1.60606772e-01f, 1.42791584e-01f, 1.03640817e-01f, 8.73065069e-02f, 1.04045942e-01f, 6.28544064e-03f, -3.01985532e-01f,
  5.53158894e-02f, -6.60245027e-03f, -1.83152463e-02f, 1.71714351e-01f, 1.01089343e-01f, -1.32410049e-01f, 1.78628847e-01f, 1.58134624e-02f, -2.18449891e-01f, 1.13529593e-01f,
  1.74291402e-01f, -2.87014362e-03f, 6.75148293e-02f, 2.36892812e-02f, 1.50670335e-01f, -3.54623765e-01f, -1.75555468e-01f, 7.67875910e-02f, -4.41598743e-02f, 2.90936768e-01f,
  1.72354445e-01f, 1.04188576e-01f, -2.16668040e-01f, -8.38345066e-02f, 3.02644759e-01f, 4.83518928e-01f, -2.42714256e-01f, -2.43673906e-01f, -2.16496214e-01f, -1.39146239e-01f,
  -4.36287194e-01f, 2.70010475e-02f, -7.47903436e-02f, -3.71461101e-02f, 3.36799771e-01f, -2.23083287e-01f, 1.56963244e-01f, -1.65069163e-01f, 8.40827301e-02f, -4.70536314e-02f,
  2.26797566e-01f, -2.85444021e-01f, 2.93262631e-01f, -2.45492324e-01f, 7.36451373e-02f, -3.21214586e-01f, 1.66385118e-02f, 2.11666226e-01f, 1.77339092e-01f, -1.92520946e-01f,
  1.79577004e-02f, -3.99418874e-03f, 2.70879501e-03f, -3.12465038e-02f, 7.59701431e-02f, 1.82123795e-01f, -3.62201072e-02f, 4.00268346e-01f, 1.60469368e-01f, 1.52274147e-01f,
  3.60747799e-02f, 1.55689687e-01f, -5.87975234e-02f, 9.38229170e-03f, 1.40194729e-01f, 2.19798520e-01f, 1.62128210e-01f, 1.28634706e-01f, 6.65420443e-02f, -3.15965638e-02f,
  1.01564474e-01f, 2.98883677e-01f, 4.92742565e-03f, 2.41306782e-01f, 2.23563194e-01f, 1.32415472e-02f, 2.56994218e-01f, -2.28160337e-01f, -3.00268054e-01f, 7.29916319e-02f,
  -5.61380163e-02f, -1.37473121e-01f, 1.90416470e-01f, 1.19079925e-01f, -8.82788077e-02f, 1.70769930e-01f, -2.63941079e-01f, -3.70444870e-03f, 4.98586334e-03f, 2.37073600e-01f,
  -2.67232925e-01f, -6.49381950e-02f, -1.44966438e-01f, 8.56809020e-02f, -8.40871632e-02f, -2.07582131e-01f, 1.95018142e-01f, 6.18905798e-02f, 5.75883351e-02f, -2.19408467e-01f,
  8.56084228e-02f, -1.67671010e-01f, -2.02451289e-01f, 1.90500557e-01f, -3.69577892e-02f, 3.94533515e-01f, 2.41852254e-01f, 2.61192650e-01f, 1.41963378e-01f, 1.19612105e-01f,
  1.50019228e-01f, 1.93827320e-02f, 6.21288158e-02f, -6.07766397e-02f, -1.87231839e-01f, 6.98665679e-02f, 1.58504456e-01f, 1.81220844e-01f, 1.61929905e-01f, 2.16439947e-01f,
  1.12110965e-01f, -7.39647001e-02f, -4.86635379e-02f, 1.30291447e-01f, 1.91308126e-01f, 1.35777548e-01f, 1.65460348e-01f, 2.66360432e-01f, 1.53182922e-02f, 3.35587710e-01f,
  -1.37781680e-01f, -2.36645178e-03f, 1.78439930e-01f, 2.55333543e-01f, -5.51656410e-02f, 1.20275371e-01f, 2.24757463e-01f, 3.19215685e-01f, 9.43446979e-02f, 2.50561535e-01f,
  7.34871179e-02f, 1.80389941e-01f, -3.44913043e-02f, -1.25894174e-02f, 7.56677389e-02f, -1.12448484e-01f, -3.75093251e-01f, 2.52030015e-01f, -1.38377428e-01f, -3.31884176e-01f,
  1.81761667e-01f, -1.21264435e-01f, -2.61158526e-01f, -3.36253554e-01f, -2.40050554e-02f, 2.09267065e-03f, 8.41827914e-02f, -3.25595848e-02f, 1.49114385e-01f, 3.75252426e-01f,
  -1.69479564e-01f, -1.55278966e-01f, 1.59756154e-01f, 1.71192005e-01f, -1.73925772e-01f, -3.99358161e-02f, 1.91210344e-01f, 2.08213612e-01f, 2.56989628e-01f, -1.09894074e-01f,
  -2.45736554e-01f, 2.85212006e-02f, -2.28766650e-01f, 2.32113793e-01f, 1.36152253e-01f, -6.74824566e-02f, -2.34304264e-01f, -2.50269681e-01f, 1.64885312e-01f, -2.14647636e-01f,
  5.23387305e-02f, 1.09213993e-01f, 7.38341510e-02f, 7.97761232e-02f, 6.99866563e-02f, 2.14360639e-01f, -2.97718425e-03f, 1.13339335e-01f, 1.74561605e-01f, 1.29088819e-01f,
  2.37745166e-01f, -8.88628233e-03f, 4.52274382e-02f, -1.21180778e-02f, 1.82768822e-01f, 5.75168394e-02f, 3.52301598e-01f, 1.00350715e-01f, 1.99100837e-01f, 5.09948358e-02f,
  1.85606301e-01f, 4.31481712e-02f, -1.37025714e-01f, 1.12327203e-01f, 2.75634881e-02f, -1.06043197e-01f, 3.29887986e-01f, -3.57266277e-01f, 5.95376678e-02f, -2.48494651e-02f,
  1.45467088e-01f, -2.91072428e-01f, 3.47764492e-01f, 1.73050687e-01f, -3.78020436e-01f, -4.14535880e-01f, 1.26937047e-01f, 1.68896858e-02f, -3.04354668e-01f, -3.13490748e-01f,
  4.66826297e-02f, -1.14085808e-01f, -2.61035025e-01f, -2.93923467e-01f, 1.30308703e-01f, -3.88459772e-01f, 2.58438528e-01f, -3.68430674e-01f, -1.20376460e-01f, -2.84577906e-02f,
  1.29984558e-01f, 2.22316757e-01f, 1.69083118e-01f, -2.89559126e-01f, 1.71528399e-01f, 6.92517310e-02f, 2.84200132e-01f, -2.47181281e-01f, -1.45399878e-02f, 1.36352479e-01f,
  -6.05744608e-02f, 4.69125295e-03f, 4.65169132e-01f, 4.85481471e-02f, 1.57890424e-01f, 2.06460044e-01f, 1.50564507e-01f, 6.37356862e-02f, 1.64498761e-01f, -6.58080727e-02f,
  -6.09871522e-02f, 8.74070749e-02f, -2.14005206e-02f, 6.49574548e-02f, 2.15777159e-01f, 5.67259304e-02f, 1.41454041e-01f, 1.73624188e-01f, 5.88542596e-02f, 7.61960670e-02f,
  3.08212459e-01f, 1.24388248e-01f, -1.10692345e-01f, 2.26951414e-03f, 2.56238103e-01f, -5.99046871e-02f, -2.30823345e-02f, 1.42716765e-01f, 2.51888037e-01f, 3.06864440e-01f,
  -1.27513900e-01f, 2.42000632e-03f, 6.67112842e-02f, 1.54455587e-01f, -1.04550757e-01f, 3.66035625e-02f, 3.10821980e-01f, 6.13428354e-02f, 3.48858505e-01f, -6.89869225e-02f,
  -1.69657737e-01f, -3.56965035e-01f, -4.49406691e-02f, 3.90822887e-01f, -2.14059547e-01f, -4.12227005e-01f, -9.21942946e-03f, 1.88949615e-01f, 7.05396235e-02f, -1.12400772e-02f,
  -2.19270334e-01f, 1.12740651e-01f, -2.50756115e-01f, 5.60462661e-02f, 2.46360287e-01f, -1.06439240e-01f, -1.03650816e-01f, -1.99461281e-01f, 1.13431394e-01f, -1.54148564e-01f,
  2.34450698e-01f, -1.99938029e-01f, -2.83554345e-01f, 3.48335970e-03f, -5.82732372e-02f, 4.69594985e-01f, 2.26332724e-01f, 3.14438164e-01f, 6.06555678e-02f, -1.34617209e-01f,
  9.97655094e-02f, -2.15055168e-01f, -2.05175802e-01f, 1.25754684e-01f, 1.10918052e-01f, -1.74992248e-01f, -1.62035212e-01f, -1.18006095e-01f, -9.62042958e-02f, -9.44531336e-02f,
  2.73345828e-01f, 1.01444729e-01f, 1.86257705e-01f, 8.57344940e-02f, 6.71869330e-03f, -5.21951057e-02f, -1.53553456e-01f, 1.31936550e-01f, 3.69947553e-02f, -7.48612210e-02f,
  6.10216856e-02f, -1.44729599e-01f, 5.12755960e-02f, -2.90865541e-01f, -3.49374980e-01f, -3.54840867e-02f, 8.57046619e-02f, -4.35422331e-01f, 1.29661426e-01f, -3.26329827e-01f,
  -2.92022023e-02f, 1.82853907e-01f, -2.23736882e-01f, -2.92367544e-02f, 3.73021956e-03f, -4.36285660e-02f, -5.14646053e-01f, 3.02149475e-01f, -7.62460306e-02f, 1.22074664e-01f,
  2.62187988e-01f, -2.01294571e-01f, 1.61045894e-01f, -2.42688641e-01f, -4.08991456e-01f, -1.13526314e-01f, 1.83603470e-03f, -8.30148309e-02f, -9.72932652e-02f, 6.60696393e-03f,
  -1.07631478e-02f, 1.08246513e-01f, -3.30067202e-02f, 3.90946180e-01f, 1.70187756e-01f, 8.60898197e-03f, -1.10707819e-01f, -5.61458878e-02f, -6.83101937e-02f, 1.02224670e-01f,
  -1.21484727e-01f, -2.29373109e-02f, 2.21218035e-01f, 1.59452200e-01f, 2.04845548e-01f, 1.70369055e-02f, 9.53453630e-02f, -5.06609902e-02f, 1.24108940e-01f, 1.47449419e-01f,
  1.69385388e-01f, 3.24093513e-02f, -1.72551498e-02f, 1.12062998e-01f, 1.99787676e-01f, 2.00105563e-01f, 5.00183292e-02f, 8.14029276e-02f, 1.59548149e-01f, 1.85878277e-01f,
  1.79878280e-01f, 5.82361072e-02f, 1.89641222e-01f, 3.32194805e-01f, 2.75305733e-02f, 1.16639085e-01f, 1.91951856e-01f, -1.03486046e-01f, 1.79885313e-01f, -1.73574030e-01f,
  1.44417554e-01f, 6.08290359e-02f, -2.08456367e-01f, 3.38171065e-01f, -2.38547236e-01f, -1.88458622e-01f, 3.32967453e-02f, 1.15800180e-01f, -1.93213865e-01f, -3.07588726e-02f,
  1.89167678e-01f, 1.10665046e-01f, 8.63365754e-02f, 1.63352430e-01f, 2.63406634e-02f, 3.80256362e-02f, -2.81052683e-02f, -1.27207294e-01f, 1.37819186e-01f, -5.51956110e-02f,
  1.31131530e-01f, -3.20631444e-01f, 1.52343914e-01f, 1.47498429e-01f, 1.13775872e-01f, 1.49814829e-01f, -1.32316649e-01f, 6.33385256e-02f, -4.19738293e-01f, -6.63995296e-02f,
  2.30497420e-01f, -9.56422463e-02f, -7.51821250e-02f, -1.37775958e-01f, 2.74847239e-01f, -1.65716499e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  3.41550738e-01f, 2.08841100e-01f, 1.01160951e-01f, 6.90751150e-02f, 6.20017275e-02f, 1.78898960e-01f, 1.40059248e-01f, 1.47452965e-01f, 2.25782886e-01f, 1.54860228e-01f,
  1.66700587e-01f, 2.32915670e-01f, -3.23783867e-02f, 9.57719684e-02f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -2.21685637e-02f, 6.94050044e-02f, 1.01432130e-01f, -5.40637560e-02f, -4.86327447e-02f, -1.42911583e-01f, 1.53142810e-01f, 2.48316213e-01f, 7.36801624e-02f, 1.17634021e-01f,
  6.27523661e-02f, -4.74678632e-03f, 1.56809911e-02f, 9.00539979e-02f, -6.12099376e-03f, 1.54121786e-01f, -1.47971064e-01f, 5.39716519e-02f, 1.94095150e-01f, 1.52138799e-01f,
  1.97160825e-01f, -3.10441875e-03f, 8.60942677e-02f, -6.52584285e-02f, 5.74126393e-02f, 4.74756733e-02f, -8.11794922e-02f, -9.30963531e-02f, -1.11909176e-03f, -1.61968023e-01f,
  -2.77740657e-01f, 2.01663435e-01f, -2.55854994e-01f, 1.45241305e-01f, 1.50437728e-01f, 7.62198046e-02f, 2.14078510e-03f, -8.10750052e-02f, -8.07150528e-02f, -7.78900459e-02f,
  4.17837724e-02f, 7.43851885e-02f, 1.61134586e-01f, -1.00920334e-01f, -1.27975166e-01f, 1.22866802e-01f, -2.24441871e-01f, -1.75443522e-04f, 6.03297316e-02f, -5.18764108e-02f,
  3.61719280e-02f, 1.29466295e-01f, -2.17228625e-02f, -8.85785818e-02f, -2.69919306e-01f, 4.79568988e-02f, 1.84353322e-01f, -9.03683007e-02f, -3.60692702e-02f, 1.21267676e-01f,
  3.41412821e-03f, 1.34005919e-01f, -5.37448861e-02f, -1.24101572e-01f, 4.30529304e-02f, -6.21740296e-02f, -1.61997423e-01f, -5.00367284e-02f, 1.17239831e-02f, 1.77888833e-02f,
  4.59903106e-02f, -3.54123227e-02f, 3.34121473e-03f, -5.13574257e-02f, -2.54810639e-02f, -1.01810046e-01f, -8.91916975e-02f, 1.94265917e-01f, -2.38635708e-02f, 4.14803904e-03f,
  -5.34201972e-02f, 1.81210876e-01f, 7.55870938e-02f, -1.37966290e-01f, -1.53729692e-01f, -2.74400320e-02f, 7.45400712e-02f, -3.04864403e-02f, -6.08253665e-02f, 1.81778088e-01f,
  -1.56918228e-01f, 1.10262662e-01f, -1.89922258e-01f, -1.72664210e-01f, -2.03009307e-01f, 3.31596509e-02f, 3.54904272e-02f, 5.75027801e-02f, 3.78038138e-01f, -1.40552178e-01f,
  7.34679103e-02f, -1.61491409e-01f, 4.54232320e-02f, -7.78114647e-02f, 1.55669972e-01f, 1.25879034e-01f, -1.87057167e-01f, 2.45241731e-01f, 7.50380903e-02f, 1.88187584e-02f,
  -2.08063111e-01f, 3.67123127e-01f, 6.99194297e-02f, 3.01053450e-02f, 1.40673146e-01f, 3.19929942e-02f, -9.41527486e-02f, -5.40890470e-02f, -5.80411218e-02f, 4.71827872e-02f,
  5.66106513e-02f, 2.26075470e-01f, 1.33118043e-02f, -9.20846090e-02f, -1.68251902e-01f, 1.95384696e-01f, -1.37229189e-01f, 1.68017447e-02f, 9.23067033e-02f, -7.30524436e-02f,
  -3.94671373e-02f, -1.01207517e-01f, 8.02405924e-02f, 5.36869764e-02f, -4.34677713e-02f, 9.04456899e-02f, -8.70111063e-02f, -1.44169047e-01f, -6.42068014e-02f, 3.19729112e-02f,
  -2.53342073e-02f, 1.85263921e-02f, 2.44522821e-02f, 2.17257943e-02f, 3.61017138e-02f, -4.81304899e-02f, 1.46736845e-01f, -7.76171535e-02f, 2.15853080e-02f, -1.09314874e-01f,
  8.31289664e-02f, 5.54436557e-02f, 6.39754236e-02f, 6.93606287e-02f, -1.06083453e-01f, 5.87790608e-02f, -6.78683147e-02f, 1.06046394e-01f, -2.28721321e-01f, -2.58784354e-01f,
  -1.68089792e-01f, 1.95428386e-01f, 1.19103469e-01f, 1.19709916e-01f, 6.80076331e-02f, -6.10998347e-02f, 2.34832823e-01f, -3.22160482e-01f, 4.41182777e-02f, -1.56974405e-01f,
  3.23902108e-02f, 1.81428120e-01f, 1.37096420e-01f, 8.45795684e-03f, -1.73568636e-01f, 3.40124182e-02f, 2.06182953e-02f, -8.47614333e-02f, -2.86598414e-01f, 1.63758680e-01f,
  -8.97650421e-02f, 8.98605436e-02f, -1.18665531e-01f, 6.16954863e-02f, -4.69520353e-02f, 1.61752939e-01f, -6.70881569e-02f, 1.45359695e-01f, 1.02251418e-01f, 1.02810696e-01f,
  -1.53658047e-01f, 1.24438934e-01f, 1.91698238e-01f, 1.54029757e-01f, 2.24892601e-01f, -8.13811496e-02f, -1.80592332e-02f, -1.56341225e-01f, 2.33037457e-01f, 1.36387765e-01f,
  -9.43401009e-02f, -1.36305735e-01f, 1.54428989e-01f, 1.14213988e-01f, -5.80489561e-02f, -5.07282615e-02f, -1.34161651e-01f, -7.35223014e-03f, -1.31705135e-01f, 1.57507077e-01f,
  9.13986936e-02f, -6.99397326e-02f, -1.70955956e-01f, 3.07422634e-02f, 7.94534832e-02f, 1.36840539e-02f, 2.20713705e-01f, -1.26555100e-01f, -2.31020898e-01f, -1.70239553e-01f,
  2.37347633e-01f, -1.33547857e-02f, -2.08667934e-01f, 4.00614738e-02f, 6.02350496e-02f, 1.10605583e-02f, 1.47375241e-01f, 5.94869442e-02f, 2.74338007e-01f, 1.99582309e-01f,
  -2.07965001e-01f, 2.71833867e-01f, 1.45299971e-01f, 2.10973144e-01f, 1.48904637e-01f, 7.07960501e-02f, -1.50733916e-02f, 1.08424671e-01f, -2.94886142e-01f, -8.69406164e-02f,
  2.10618764e-01f, -7.86181446e-03f, 6.32185042e-02f, 2.96648312e-02f, -2.24831924e-02f, -1.78542748e-01f, -7.42177200e-03f, -5.78191616e-02f, 9.84970573e-03f, 6.44070879e-02f,
  -2.92635150e-02f, -8.47917497e-02f, 2.35092659e-02f, 1.37917340e-01f, 2.39489377e-02f, -6.95110336e-02f, -1.30161554e-01f, 3.29182521e-02f, 6.67907670e-02f, -1.41076714e-01f,
  -3.20871286e-02f, 7.98675716e-02f, -3.75269614e-02f, 7.37192705e-02f, 5.08102104e-02f, -1.02624319e-01f, -9.41557437e-02f, 4.07547541e-02f, -7.65131712e-02f, -8.12126603e-03f,
  8.52539539e-02f, -7.16858730e-03f, 2.18729556e-01f, -2.01768577e-02f, -9.97547712e-03f, -3.49673629e-02f, -1.19415931e-01f, 6.13225661e-02f, 2.16004893e-01f, -9.62258950e-02f,
  1.70637667e-01f, 2.53052324e-01f, -1.76595196e-01f, -2.28019848e-01f, -1.10537626e-01f, -9.38974693e-02f, -1.35281041e-01f, 8.77910107e-02f, 4.51715058e-03f, 1.15159102e-01f,
  1.35634005e-01f, -3.82888690e-02f, -9.81942564e-03f, 9.06631872e-02f, -3.57890800e-02f, -4.16796654e-01f, -1.06902294e-01f, -1.36710122e-01f, 1.33236170e-01f, 1.63060635e-01f,
  -2.29509279e-01f, 1.17632248e-01f, -4.30968292e-02f, 4.99570295e-02f, -2.52615213e-01f, -8.43520463e-02f, -1.21566616e-02f, 1.01456195e-02f, 2.35306054e-01f, 1.30380079e-01f,
  4.13114652e-02f, 6.59970939e-02f, 7.17775226e-02f, -1.66995272e-01f, -2.02034339e-01f, 9.96373370e-02f, -9.85372066e-02f, 1.73161313e-01f, -1.30668193e-01f, -8.47103000e-02f,
  3.64210755e-02f, -2.92518791e-02f, 1.30991220e-01f, -2.84191191e-01f, 1.61800340e-01f, -3.10618412e-02f, -1.12660930e-01f, 8.24957862e-02f, 6.34639561e-02f, 2.25004315e-01f,
  -1.97660297e-01f, -2.20047380e-03f, -7.26269633e-02f, 1.35157213e-01f, 1.20749034e-01f, 1.09007969e-01f, 1.08274274e-01f, 2.25735158e-01f, 1.02713883e-01f, -5.45060225e-02f,
  -1.96100488e-01f, 1.24945643e-03f, 7.05191344e-02f, -7.68276379e-02f, -1.02239914e-01f, 2.35559598e-01f, 2.57351212e-02f, 2.75734197e-02f, 1.05682366e-01f, 3.13130677e-01f,
  1.30255222e-01f, -6.01940900e-02f, -2.95702755e-01f, 2.59563923e-01f, -1.67433582e-02f, 3.04996152e-04f, -3.81112508e-02f, -1.68251842e-01f, 1.85226813e-01f, 8.75371471e-02f,
  2.21797049e-01f, 2.90094256e-01f, -9.71711352e-02f, -1.60373360e-01f, 1.55018896e-01f, 2.39965275e-01f, 5.87973138e-03f, 4.12785798e-01f, -1.69123530e-01f, -1.75143629e-01f,
  4.37184349e-02f, -4.27557155e-02f, -6.33480921e-02f, -1.17135197e-01f, 1.34050697e-01f, -2.17753928e-02f, 1.27031118e-01f, 2.50898246e-02f, -1.62820548e-01f, 5.95760271e-02f,
  1.06617376e-01f, -5.80456182e-02f, -2.23810952e-02f, 4.65285182e-02f, 9.76121947e-02f, -8.55714607e-04f, -5.53174615e-02f, 8.96213353e-02f, -1.75283700e-01f, -9.06314608e-03f,
  -9.29815397e-02f, -2.89514419e-02f, 5.02692237e-02f, 2.23110989e-02f, -2.10144430e-01f, 4.26738448e-02f, -1.86118245e-01f, -7.68126315e-03f, 1.55738723e-02f, 4.35808264e-02f,
  7.99117461e-02f, 7.18527511e-02f, 5.87172620e-02f, 1.07747048e-01f, -7.34305605e-02f, 4.07570973e-02f, -1.13035156e-03f, 8.02463517e-02f, 3.95967849e-02f, 1.77038342e-01f,
  -7.60814222e-03f, 1.12477869e-01f, -4.07093018e-02f, -1.53017715e-01f, 1.46433324e-01f, 1.14159003e-01f, 1.96637399e-03f, 1.11158997e-01f, 2.14202836e-01f, 1.22508369e-02f,
  -1.72587886e-01f, -1.83208138e-01f, 3.48055989e-01f, 6.19219169e-02f, 1.80940136e-01f, -1.38035029e-01f, -1.77456722e-01f, -1.26430392e-01f, 1.68823332e-01f, -7.00420588e-02f,
  1.14812411e-01f, 2.35032901e-01f, 8.95764157e-02f, 7.11403638e-02f, -7.44020417e-02f, 1.10838406e-01f, -6.51935115e-03f, 1.59383103e-01f, 7.45423585e-02f, 6.69543892e-02f,
  7.53102452e-02f, 2.30847374e-01f, 1.98171496e-01f, -2.02252209e-01f, 6.86193556e-02f, -1.79451972e-01f, -1.00604698e-01f, 1.08843677e-01f, -6.86912611e-02f, 1.12243481e-01f,
  -1.39084280e-01f, -5.54611757e-02f, -7.77172446e-02f, 6.97145462e-02f, -9.01249349e-02f, 2.20312774e-02f, 1.61997736e-01f, -1.56968728e-01f, 1.24962889e-01f, 1.51762262e-01f,
  -4.64619920e-02f, 1.43116573e-02f, -7.84662887e-02f, 9.02124792e-02f, -7.61463642e-02f, -1.22393735e-01f, -1.35535926e-01f, -1.05065361e-01f, 2.48755679e-01f, 3.49862326e-04f,
  -1.50209650e-01f, 6.88298047e-02f, -4.36812826e-02f, -2.79353678e-01f, 7.10183084e-02f, 1.03407770e-01f, 1.41883865e-01f, 6.67171329e-02f, -6.77979738e-02f, -1.41582966e-01f,
  1.77180320e-01f, -7.98543468e-02f, -2.66008765e-01f, -9.72469226e-02f, -1.10791892e-01f, 5.37453257e-02f, -1.67406887e-01f, -3.21311913e-02f, -2.59941369e-02f, -1.62195414e-01f,
  2.57962197e-01f, 1.38559818e-01f, -1.04664005e-01f, -3.50997224e-02f, 1.78358614e-01f, -2.72056371e-01f, 2.11796030e-01f, 1.34021953e-01f, -1.49320349e-01f, 4.35211957e-02f,
  8.80615879e-03f, 1.40111953e-01f, 9.03731491e-03f, 7.83614814e-02f, -1.44730315e-01f, -6.48638010e-02f, 1.44591063e-01f, -1.45001024e-01f, 1.87803745e-01f, -8.99646208e-02f,
  -1.00255953e-02f, -4.86384109e-02f, 3.74768600e-02f, 4.33927868e-03f, 5.15685715e-02f, 8.40985700e-02f, -4.70113717e-02f, -1.52475879e-01f, 2.09259503e-02f, 7.17187598e-02f,
  6.22027740e-02f, -5.87577820e-02f, -6.27911016e-02f, -1.10664694e-02f, 1.69306427e-01f, -4.75639962e-02f, -1.83912829e-01f, -1.21127874e-01f, -1.51641369e-01f, 1.47807941e-01f,
  1.58760205e-01f, 1.40480757e-01f, -1.63315665e-02f, -2.73860171e-02f, -1.36525497e-01f, -3.12700868e-02f, -5.62694706e-02f, -2.01469362e-01f, -6.05853498e-02f, 1.66347533e-01f,
  1.75674886e-01f, -1.67035386e-02f, 1.39972754e-02f, -1.81711406e-01f, -1.08919798e-04f, -1.45533770e-01f, 9.99609083e-02f, -1.47638515e-01f, 3.36573482e-01f, 9.65576395e-02f,
  -1.85847878e-01f, 3.25584084e-01f, -3.91641483e-02f, 2.76917845e-01f, -1.04804553e-01f, -1.45767191e-02f, -4.33147885e-02f, 6.55673593e-02f, -1.69926092e-01f, -1.37166709e-01f,
  2.86300071e-02f, -1.53099999e-01f, 1.59885064e-01f, -1.33543745e-01f, -1.31780580e-01f, -1.14997081e-01f, -1.13933673e-02f, -1.77787825e-01f, -1.90032601e-01f, 6.45473553e-03f,
  1.62443414e-01f, 5.29338606e-02f, -1.19811833e-01f, 3.49523649e-02f, 5.08918278e-02f, 7.13595748e-02f, -1.26785919e-01f, 2.71086041e-02f, -8.62292349e-02f, 1.86802760e-01f,
  4.39027622e-02f, 1.18931532e-01f, -8.94059986e-02f, 1.73799545e-02f, -7.93271437e-02f, 1.11852176e-01f, 1.72873437e-01f, 1.32524706e-02f, 1.00226581e-01f, 5.11230268e-02f,
  -1.20604739e-01f, 1.42053412e-02f, 2.14193687e-02f, 1.35383448e-02f, 1.21865779e-01f, 1.51323661e-01f, 2.60636479e-01f, 7.22960755e-02f, -4.10329588e-02f, 7.59110153e-02f,
  -8.52413550e-02f, -2.66679287e-01f, 2.01870456e-01f, 5.15792631e-02f, 2.17875749e-01f, 9.28976387e-02f, 2.26513833e-01f, 9.22418013e-03f, -2.56409366e-02f, -3.22325714e-02f,
  -2.22387180e-01f, -1.30506888e-01f, 8.61925036e-02f, -7.19335005e-02f, 3.27452384e-02f, 1.86803609e-01f, -1.31559879e-01f, -5.93474358e-02f, 1.13048285e-01f, -2.41423115e-01f,
  1.49358898e-01f, -1.32846728e-01f, 2.94065863e-01f, -2.15909511e-01f, 8.69034156e-02f, -1.06658577e-03f, -1.37976050e-01f, -1.16868973e-01f, -1.17162190e-01f, -3.72664407e-02f,
  2.63825897e-02f, -5.50735518e-02f, 4.26746905e-03f, 1.07538939e-01f, 1.62652314e-01f, 4.15152498e-02f, 2.32113644e-01f, -4.88955230e-02f, 9.39240456e-02f, 1.17064215e-01f,
  -1.53807551e-01f, 2.54186168e-02f, -1.44368112e-01f, -9.20900851e-02f, -2.48636696e-02f, -8.80423039e-02f, 8.89362693e-02f, -9.50922295e-02f, -1.29130939e-02f, -1.72443002e-01f,
  2.71607898e-02f, 1.58963934e-01f, -2.00746670e-01f, -2.76353415e-02f, 1.25514969e-01f, 7.34733650e-03f, 1.18838310e-01f, -1.00813448e-01f, -5.22923246e-02f, -5.87441400e-02f,
  -1.05726682e-01f, -9.19209421e-02f, 5.56791611e-02f, -2.68946569e-02f, 6.62000775e-02f, 1.31267890e-01f, -8.28830376e-02f, 6.91140220e-02f, -1.52341858e-01f, 1.98993832e-01f,
  -2.85091788e-01f, -1.71236143e-01f, -6.58519194e-02f, 5.15990071e-02f, -3.18134180e-03f, 5.53369746e-02f, -9.66898501e-02f, 7.25317448e-02f, -8.97984207e-02f, -2.74215877e-01f,
  -5.68086244e-02f, -9.70318764e-02f, 1.99915335e-01f, 2.71230847e-01f, -7.10065067e-02f, -8.82533416e-02f, -1.24998063e-01f, 2.31321916e-01f, -4.82717268e-02f, -1.47507638e-01f,
  -8.79275501e-02f, 7.80230910e-02f, 1.09297790e-01f, 1.92243069e-01f, -2.23674104e-01f, 2.47449987e-02f, -9.25185308e-02f, -9.25462916e-02f, -3.53423506e-02f, 1.43353075e-01f,
  -4.10730876e-02f, 6.63249940e-02f, 1.83643959e-02f, 7.73677975e-02f, -2.20278382e-01f, 2.50584930e-02f, -1.12462699e-01f, -1.84686139e-01f, 1.83854938e-01f, 4.44218665e-02f,
  -1.38861895e-01f, 1.68779166e-03f, -3.05760801e-02f, 1.36892483e-01f, 5.03576500e-03f, 1.97823748e-01f, -1.61355957e-02f, -2.77891736e-02f, 1.80705220e-01f, 1.78636640e-01f,
  -1.60357039e-02f, -4.51155119e-02f, -1.44230217e-01f, -6.81494921e-02f, -9.60525721e-02f, -2.71225870e-02f, 1.94721296e-02f, -7.87852854e-02f, -1.74705252e-01f, 2.42836893e-01f,
  1.78547099e-01f, -1.79653196e-03f, 5.14690652e-02f, 3.23299289e-01f, 1.33282751e-01f, -1.92035481e-01f, 3.67165953e-02f, 2.92374026e-02f, -1.66431591e-01f, -1.35913908e-01f,
  -8.23386535e-02f, -1.01644862e-02f, -2.19401091e-01f, -1.63136259e-01f, 7.33992755e-02f, 1.83329120e-01f, -1.38381561e-02f, -3.45094912e-02f, -1.13563232e-01f, 2.13464648e-01f,
  4.30004597e-02f, -4.39779125e-02f, -7.42132962e-02f, -2.82366008e-01f, -2.56612785e-02f, 2.88244598e-02f, 2.00514182e-01f, -2.24202890e-02f, 1.27571955e-01f, -1.35933899e-03f,
  2.71844510e-02f, -1.78821072e-01f, -2.08654329e-01f, 2.25424930e-01f, -7.56555125e-02f, -9.77182016e-02f, 4.39826176e-02f, 1.62943138e-03f, 1.15266386e-02f, 6.26221895e-02f,
  -1.01459334e-02f, 7.68606812e-02f, -5.09982510e-03f, -6.53816238e-02f, 7.84169417e-03f, -1.38684183e-01f, 8.33957940e-02f, 1.58204913e-01f, 9.00774747e-02f, -1.83402419e-01f,
  1.67063233e-02f, 7.96592683e-02f, 4.69645374e-02f, -7.34769031e-02f, -9.24266875e-02f, -5.81650920e-02f, 1.23132057e-01f, -1.49650816e-02f, -1.05138361e-01f, -1.26157207e-02f,
  5.99465333e-02f, 2.02905551e-01f, -9.83622670e-02f, -4.03499836e-03f, -1.31169796e-01f, 2.29344845e-01f, -2.98557669e-01f, -6.09130114e-02f, -7.97036514e-02f, 1.28573962e-02f,
  -1.48727939e-01f, 5.39519601e-02f, 3.65687907e-01f, 9.94396135e-02f, 1.65481735e-02f, -4.96083684e-02f, -1.77235544e-01f, -9.55164805e-02f, -6.45124614e-02f, 1.41148269e-01f,
  -2.62946934e-01f, 2.64474303e-01f, -2.32314467e-02f, -8.47683474e-02f, -1.08057864e-01f, 1.90657675e-01f, -1.49317430e-02f, 1.87205732e-01f, 7.65163079e-02f, -2.43577644e-01f,
  -5.48778400e-02f, 3.38319950e-02f, 9.32460800e-02f, 2.01680884e-01f, -1.28445894e-01f, 7.06099123e-02f, -1.02474838e-02f, 1.65258989e-01f, -1.85830042e-01f, -4.49966043e-02f,
  5.54297157e-02f, 5.67707121e-02f, 6.21754909e-03f, 1.92583781e-02f, 8.80308449e-02f, 9.19667408e-02f, 4.98600304e-02f, 8.61164331e-02f, 1.25492871e-01f, 1.50486320e-01f,
  1.51307836e-01f, 3.55734453e-02f, 1.80098426e-03f, 1.66939616e-01f, 1.11089297e-01f, 3.01730465e-02f, 1.12869004e-02f, 5.50056547e-02f, -1.90566421e-01f, -4.70135882e-02f,
  8.36224183e-02f, 6.22931980e-02f, 6.93221763e-02f, -6.69625700e-02f, -9.02649909e-02f, -4.73083705e-02f, 6.26491755e-02f, 1.79931559e-02f, 2.32747626e-02f, -1.93635225e-01f,
  1.84565365e-01f, -1.95782989e-01f, 5.14063351e-02f, 5.52547462e-02f, 1.29253957e-02f, -1.04712583e-01f, -2.52041698e-01f, 8.80531669e-02f, 1.87996954e-01f, 1.94649354e-01f,
  -2.13609636e-01f, 3.36090773e-01f, -4.13739197e-02f, 2.05385953e-01f, 1.07425779e-01f, -1.97815061e-01f, -1.63840622e-01f, -1.08313441e-01f, 1.20220326e-01f, -3.26459914e-01f,
  -3.45393270e-02f, -1.27135500e-01f, 4.94132517e-03f, -1.48794670e-02f, 6.60255998e-02f, -8.17826390e-02f, -4.11571488e-02f, -3.11390255e-02f, 9.77072418e-02f, -2.07604855e-01f,
  4.33764234e-03f, -6.44676983e-02f, 1.27208009e-01f, 7.82289356e-02f, -2.32817214e-02f, -1.37045324e-01f, -3.27935517e-02f, 2.69060396e-02f, 1.82876900e-01f, 7.28963464e-02f,
  1.72777295e-01f, -7.63289556e-02f, 1.43869996e-01f, 1.45530134e-01f, 1.00493371e-01f, 7.96924531e-02f, 7.01556206e-02f, -1.47449365e-02f, -4.73904051e-02f, -3.46705951e-02f,
  -8.18584189e-02f, 1.84673041e-01f, -1.09695159e-02f, -8.79177824e-02f, 5.12554832e-02f, -1.62273124e-01f, 1.35885313e-01f, 8.87916759e-02f, -3.39698717e-02f, 2.42814515e-02f,
  1.36174336e-01f, -1.10142380e-01f, -9.66411456e-02f, 5.82585968e-02f, 1.41379228e-02f, -6.74625905e-03f, -1.87920779e-01f, -8.08346793e-02f, -2.29650691e-01f, 9.08485278e-02f,
  6.30116761e-02f, 1.02419294e-01f, -5.03875129e-02f, -7.74249062e-02f, -1.59646140e-03f, -2.25224718e-01f, -1.20209686e-01f, -1.60056308e-01f, 1.62411481e-01f, 1.73325613e-01f,
  1.60673156e-01f, -1.51105404e-01f, -7.41358176e-02f, -2.06621662e-02f, 1.97729748e-02f, 1.82343706e-01f, -1.67556703e-01f, -1.95323229e-02f, 5.94470836e-02f, 1.86898902e-01f,
  -3.11587192e-02f, 1.39755577e-01f, -1.80384561e-01f, 1.43170461e-01f, 7.43373409e-02f, 2.28117749e-01f, 2.71967966e-02f, -8.74496102e-02f, 1.90374494e-01f, 3.19315121e-02f,
  -2.38271207e-02f, 7.09678978e-02f, -9.81565565e-02f, -1.96131282e-02f, -1.14151858e-01f, 2.85205618e-02f, -6.46134019e-02f, 1.06820919e-01f, 1.41312659e-01f, 1.07862301e-01f,
  4.89239506e-02f, -7.20401108e-03f, -5.88602461e-02f, -4.52013053e-02f, -3.85871418e-02f, 9.71521884e-02f, -1.30130872e-01f, -1.41303502e-02f, 9.39257294e-02f, 7.77663961e-02f,
  3.52636352e-03f, -7.95598403e-02f, 4.31726687e-02f, 2.15397216e-03f, 5.56510165e-02f, 5.03501557e-02f, 1.07981570e-01f, -1.13961816e-01f, 1.67484522e-01f, -1.72990873e-01f,
  6.72935555e-03f, 1.89317554e-01f, 1.70416847e-01f, -2.71100044e-01f, -1.46323547e-01f, 1.87632386e-02f, 2.02878073e-01f, -7.98004642e-02f, -1.42708734e-01f, 2.78975576e-01f,
  -5.86490817e-02f, 1.44849062e-01f, 1.39368121e-02f, -2.07195520e-01f, -7.02258572e-02f, -5.51105551e-02f, -9.24695134e-02f, -2.93971360e-01f, 6.12495951e-02f, -1.90179825e-01f,
  2.12292910e-01f, -7.77990511e-03f, 7.30240569e-02f, -2.68974781e-01f, -6.54218048e-02f, -6.91712275e-02f, 2.00811327e-01f, -5.58565520e-02f, 6.31868169e-02f, -1.20004818e-01f,
  3.01847775e-02f, 2.34370935e-03f, 1.66148432e-02f, -1.28706321e-01f, 8.93289074e-02f, -2.55844016e-02f, -1.30575877e-02f, -4.15322632e-02f, 9.48717371e-02f, 2.44724322e-02f,
  -2.15865746e-02f, 1.07576974e-01f, 7.57038370e-02f, 1.84169393e-02f, 8.75020847e-02f, -1.29480779e-01f, -4.66857702e-02f, 7.15613291e-02f, -1.34777464e-02f, 9.57490802e-02f,
  -4.65411842e-02f, 1.72452942e-01f, -1.43669741e-02f, 8.85088071e-02f, -7.82328099e-02f, -3.36313210e-02f, -7.59387836e-02f, -1.20214023e-01f, -8.99175182e-04f, 2.43155360e-01f,
  8.74345228e-02f, 1.53306974e-02f, 4.95633520e-02f, -3.51678357e-02f, -9.59806740e-02f, -1.50191635e-01f, 7.55991042e-02f, 1.54272011e-02f, 1.30324975e-01f, 9.16468631e-03f,
  7.96358883e-02f, -2.95046624e-02f, 6.89798295e-02f, 2.23867312e-01f, 1.25504538e-01f, 2.44203314e-01f, -9.87474807e-03f, -2.57892817e-01f, -6.08952902e-02f, 1.02387801e-01f,
  -1.11902647e-01f, -8.34464282e-02f, -1.48765817e-01f, -1.11564353e-01f, 1.02013737e-01f, 8.91272947e-02f, 2.38884743e-02f, -1.11259997e-01f, 1.59075156e-01f, -2.30058014e-01f,
  2.19263299e-03f, 3.80350761e-02f, -1.04762025e-01f, -2.54761335e-02f, -1.27901509e-01f, 2.13015139e-01f, -8.42185244e-02f, -1.05550997e-01f, 8.21819827e-02f, 9.91616696e-02f,
  4.14264426e-02f, -1.38491094e-01f, 1.19693600e-01f, -2.59013847e-02f, 6.22282038e-04f, 9.35727209e-02f, -8.99952184e-03f, -1.71767492e-02f, -1.73925925e-02f, 1.41541868e-01f,
  -1.64823890e-01f, 6.02665078e-03f, -3.36437672e-02f, 9.27413255e-02f, 1.03006370e-01f, 1.36897758e-01f, 1.16186582e-01f, -1.16283126e-01f, 1.83675215e-01f, 7.32777268e-02f,
  1.11345530e-01f, 3.95325571e-02f, -1.34521406e-02f, 2.09063053e-01f, -1.92589134e-01f, 1.18271656e-01f, -7.05522895e-02f, -9.28236097e-02f, -5.31725883e-02f, 2.20431030e-01f,
  -2.54541487e-01f, 9.87802520e-02f, 4.37894799e-02f, 2.18872368e-01f, -1.48189053e-01f, -3.76937515e-03f, 1.90409750e-01f, -9.44197699e-02f, 3.87158827e-03f, -2.92146914e-02f,
  -2.08886452e-02f, 3.87231559e-02f, 1.36404768e-01f, 4.89935316e-02f, 8.50557610e-02f, 2.31803641e-01f, 3.79264653e-02f, 2.54418820e-01f, 6.33963421e-02f, 1.07143767e-01f,
  1.14343531e-01f, -8.02371353e-02f, -2.03699678e-01f, 1.86442927e-01f, 8.07970539e-02f, -1.36297554e-01f, -1.33757312e-02f, 5.51620238e-02f, -2.25132238e-02f, -1.45604938e-01f,
  5.75217232e-02f, -5.27422875e-02f, -1.01393433e-02f, 1.35401279e-01f, -4.24531810e-02f, 1.32453859e-01f, -9.86041427e-02f, -6.11383729e-02f, 1.22828998e-01f, -5.56375273e-02f,
  -2.95468103e-02f, 3.43561685e-03f, 7.97666311e-02f, 3.38983838e-03f, 1.82502687e-01f, 1.90923996e-02f, -2.65050344e-02f, 2.69352905e-02f, 1.17903717e-01f, -1.85351502e-02f,
  -3.87191176e-02f, 9.57593918e-02f, 8.19771271e-03f, 3.58301252e-02f, 1.68877654e-02f, -8.01686198e-02f, -6.72281906e-02f, -8.61100778e-02f, -1.23665268e-02f, 9.24379751e-02f,
  8.15258026e-02f, -1.88236073e-01f, 2.19563127e-01f, 1.77851126e-01f, 2.32231960e-01f, -1.94675341e-01f, 4.62092869e-02f, 6.83320761e-02f, -4.68291827e-02f, 9.32887644e-02f,
  -2.12031767e-01f, 2.95351475e-01f, 7.66488388e-02f, -2.17308514e-02f, -1.65484883e-02f, -1.15521543e-01f, -1.68523118e-01f, -1.13151155e-01f, 1.00209387e-02f, -2.79625118e-01f,
  7.38505870e-02f, 2.55846143e-01f, 1.83956996e-01f, -1.05680242e-01f, -7.96264783e-02f, -2.00387388e-01f, 1.45551205e-01f, 3.13621871e-02f, -3.46373096e-02f, -1.92897663e-01f,
  1.18663281e-01f, -1.93134192e-02f, -2.09705621e-01f, -7.70027712e-02f, 1.84382379e-01f, -1.05733655e-01f, 5.99829666e-02f, -7.28538260e-02f, 4.50654961e-02f, -5.30647999e-03f,
  1.40432149e-01f, -4.28519845e-02f, -1.52364969e-01f, -1.27866521e-01f, -7.33170956e-02f, -5.43707497e-02f, -5.87444045e-02f, 1.23732954e-01f, -1.57653540e-02f, 1.58381723e-02f,
  6.84551671e-02f, 9.26692858e-02f, 7.11837560e-02f, 6.68714046e-02f, 5.30932993e-02f, -3.32918204e-02f, -1.81668606e-02f, 1.30971834e-01f, -5.18790931e-02f, -5.50021045e-02f,
  4.81531620e-02f, 7.97797665e-02f, -4.61888872e-03f, 4.46240753e-02f, -2.30751470e-01f, 1.75826520e-01f, 1.10560268e-01f, 1.36225998e-01f, -1.54465556e-01f, 2.44444117e-01f,
  1.23490907e-01f, 2.53021896e-01f, -9.64231640e-02f, -2.18246832e-01f, 8.68770778e-02f, -2.76970476e-01f, -1.59382209e-01f, -5.96191408e-03f, -1.39197692e-01f, 1.24638304e-01f,
  -1.34130241e-02f, 1.45697653e-01f, 1.82048708e-01f, 2.91729093e-01f, -2.76053473e-02f, 1.12143360e-01f, -8.82834569e-02f, -1.76591724e-02f, 1.06458604e-01f, 1.82188869e-01f,
  4.78948699e-03f, 2.01355100e-01f, 1.33547902e-01f, 4.01715487e-02f, -1.31675050e-01f, 5.13381772e-02f, 3.97149175e-02f, -5.78815341e-02f, -1.88008957e-02f, 1.35100082e-01f,
  -3.55680585e-02f, 5.10128774e-02f, -3.25737544e-03f, -5.83231486e-02f, -1.53874382e-01f, 8.05454105e-02f, -2.17286590e-02f, 4.07552272e-02f, -1.01823695e-01f, 2.25560702e-02f,
  1.08905211e-01f, -5.18166274e-02f, 1.24544185e-02f, -8.82204026e-02f, -1.50169153e-02f, -1.01741858e-01f, 9.28387567e-02f, -4.50231209e-02f, -4.03018110e-02f, 3.96376401e-02f,
  -3.34339254e-02f, -1.36393845e-01f, -1.26390234e-01f, -8.40467066e-02f, -1.09546773e-01f, -1.57238632e-01f, 6.89910650e-02f, 1.47310257e-01f, 1.76696926e-01f, -1.51949584e-01f,
  7.31901973e-02f, 6.54635802e-02f, 1.75992087e-01f, -7.58605972e-02f, -8.56064856e-02f, -1.77808255e-01f, 9.86122433e-03f, 2.60030106e-02f, -8.87999311e-03f, 1.99443161e-01f,
  1.83034703e-01f, 9.57764871e-03f, 9.58777294e-02f, 6.56445995e-02f, 1.39196843e-01f, -1.64418787e-01f, 1.15008667e-01f, -7.72256032e-03f, 1.14102282e-01f, 2.36980289e-01f,
  1.16842091e-01f, -1.20974600e-01f, -3.78236584e-02f, -1.05929665e-01f, 1.08363636e-01f, -8.53591189e-02f, -2.37461507e-01f, 1.40041336e-01f, 1.46837041e-01f, -2.02199921e-01f,
  -1.93870068e-01f, 1.22869480e-02f, 3.18152346e-02f, 4.52214591e-02f, 9.34688002e-02f, 1.98614046e-01f, -1.47741213e-02f, 2.56514341e-01f, -1.50903821e-01f, 8.14923197e-02f,
  -4.09932807e-02f, -1.21388920e-02f, 7.62419924e-02f, 1.32915899e-01f, 1.94902092e-01f, -8.19168519e-03f, 9.30161029e-02f, -6.86479807e-02f, -1.32226065e-01f, 7.92876855e-02f,
  -4.83389422e-02f, -1.32245302e-01f, 1.80355340e-01f, 1.98669150e-01f, 7.87457265e-03f, -1.11309096e-01f, -2.86770910e-02f, 1.08604217e-02f, 1.18617155e-01f, 3.40405433e-03f,
  -7.01910257e-02f, 3.02280840e-02f, 4.01203446e-02f, 6.72625080e-02f, -7.09218159e-02f, -2.32417416e-02f, 1.47712529e-01f, -1.24057094e-02f, -2.60861993e-01f, 2.49929458e-01f,
  6.28939271e-03f, 1.94199219e-01f, -1.77583858e-01f, 2.41801873e-01f, -2.95719057e-01f, 1.65868193e-01f, 5.50193265e-02f, -1.35771558e-01f, -1.63925201e-01f, -5.77393621e-02f,
  -3.62502597e-02f, -3.62669498e-01f, -2.02385694e-01f, -1.10977538e-01f, -6.76016361e-02f, -3.09235621e-02f, 1.30887985e-01f, -7.19141215e-02f, -1.40950724e-01f, -1.17067493e-01f,
  -1.41095608e-01f, -1.57865301e-01f, -9.33088735e-02f, 2.11358428e-01f, 1.17387451e-01f, 9.12643969e-02f, 4.19951454e-02f, 7.51305148e-02f, -1.24473404e-02f, -8.96044374e-02f,
  -8.55550021e-02f, 1.48116555e-02f, -3.28829736e-02f, -2.71502230e-02f, -1.01332515e-01f, 1.83485448e-01f, 1.32681616e-02f, -5.94287254e-02f, -7.23955333e-02f, 1.22891169e-03f,
  -7.33443424e-02f, 3.69212776e-02f, 2.33348012e-02f, -1.36264889e-02f, -4.99671362e-02f, -2.25116890e-02f, 3.70900445e-02f, 1.39366865e-01f, 1.21779018e-03f, -1.30465761e-01f,
  -2.41247565e-02f, -2.76180748e-02f, 4.83664870e-02f, -2.72596389e-01f, 5.75465076e-02f, -6.88186660e-02f, 2.07930490e-01f, -1.52293310e-01f, -1.17541306e-01f, -1.30758747e-01f,
  2.15808973e-01f, -1.20574161e-01f, -6.97878748e-02f, -1.70769945e-01f, -4.75091897e-02f, -2.60022208e-02f, -7.73312598e-02f, 8.41097832e-02f, 2.26624250e-01f, -1.05986230e-01f,
  2.59025633e-01f, -1.67450756e-01f, 1.12370297e-01f, 2.31796280e-02f, -6.99674105e-03f, -1.25253811e-01f, 2.37092793e-01f, 5.01682013e-02f, -3.39529552e-02f, 2.93585323e-02f,
  1.61073245e-02f, 8.63692388e-02f, 1.90207824e-01f, -1.31380960e-01f, -5.69840930e-02f, 1.99020609e-01f, 2.54559033e-02f, -2.29535401e-01f, 1.26468614e-01f, 5.09428680e-02f,
  -2.59963926e-02f, -3.92881334e-02f, 1.35162517e-01f, 5.68426773e-02f, 8.66725221e-02f, -1.61086380e-01f, -1.78400129e-01f, -1.48563879e-04f, -1.64171495e-02f, -8.27667043e-02f,
  -1.11323357e-01f, -1.72294397e-02f, -2.83724200e-02f, 2.20835228e-02f, -9.60511416e-02f, -2.86877807e-02f, 9.28468555e-02f, -1.90095037e-01f, -1.15751483e-01f, 9.45634618e-02f,
  -5.00144728e-04f, 1.20702304e-03f, -1.71918839e-01f, -9.40530598e-02f, 2.49025840e-02f, -2.73099658e-03f, 2.38234717e-02f, 9.80057754e-03f, -2.66840339e-01f, -7.31533244e-02f,
  -2.74326265e-01f, -2.08246365e-01f, -2.24113956e-01f, 1.35778114e-01f, 1.69244871e-01f, -8.10805187e-02f, 1.67793930e-01f, 1.55734479e-01f, 1.79758310e-01f, -1.38317436e-01f,
  3.19001079e-02f, 1.20031379e-01f, 2.57383645e-01f, 7.17008114e-02f, -9.86759663e-02f, 1.01944767e-01f, -5.22039421e-02f, 4.21439745e-02f, -3.86969447e-02f, 1.76685244e-01f,
  -6.58417270e-02f, -4.71387953e-02f, 1.78770214e-01f, 1.51026592e-01f, -2.01590285e-02f, -1.36927187e-01f, -8.64869507e-04f, -1.28656685e-01f, 3.98556143e-02f, 8.77775550e-02f,
  -8.61401856e-02f, -1.80395529e-01f, -1.48888305e-01f, 8.48078132e-02f, -1.21515736e-01f, -4.03071418e-02f, 7.90228769e-02f, -1.46515772e-01f, 1.12037919e-01f, 2.32490897e-02f,
  -6.14473000e-02f, -1.37249893e-02f, -4.31661606e-02f, 5.02860434e-02f, -8.41262937e-02f, 5.75268082e-02f, -1.36895075e-01f, -1.17647640e-01f, -5.34203500e-02f, -4.84064519e-02f,
  2.12978125e-02f, -3.26068811e-02f, -3.57789397e-02f, -4.60644141e-02f, -1.09442152e-01f, 6.09623753e-02f, -6.54612556e-02f, 2.76806448e-02f, 8.24146345e-02f, -9.02099535e-02f,
  8.34559798e-02f, 1.09647140e-01f, -6.45522820e-03f, -1.44324481e-01f, 1.57950576e-02f, 4.81837876e-02f, -7.27050975e-02f, -8.33751634e-02f, 1.05687387e-01f, -1.30678564e-01f,
  9.12637562e-02f, -1.08697511e-01f, 2.05249369e-01f, -1.22635871e-01f, -1.03501312e-01f, 2.63095498e-01f, 2.12794393e-01f, 1.38729393e-01f, 2.22442094e-02f, -3.37503627e-02f,
  -5.95922172e-02f, 1.70044556e-01f, -6.81585521e-02f, 5.26275195e-04f, -1.01323470e-01f, -2.67895371e-01f, 4.00244258e-03f, 1.54205024e-01f, -6.48883805e-02f, -2.24261403e-01f,
  9.43796113e-02f, -7.43494853e-02f, 1.38309568e-01f, 1.76327288e-01f, -1.97002273e-02f, -1.12452887e-01f, 9.71291885e-02f, 8.17112774e-02f, -1.79889694e-01f, -1.32132515e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.81786239e-01f, 3.24476026e-02f, 1.89634487e-01f, -1.81042477e-01f, 2.86743850e-01f, 1.78286657e-01f, 8.29189457e-03f, -1.79383129e-01f, 2.14253590e-01f, 3.76192749e-01f,
  3.61397594e-01f, 2.64620297e-02f, 3.06407034e-01f, 3.79291847e-02f, -2.00904980e-02f, 2.16841787e-01f, -1.65694896e-02f, 3.70147437e-01f, 2.44193286e-01f, 2.46307611e-01f,
  3.84491235e-01f, 2.19211891e-01f, -1.83331132e-01f, 1.93830952e-01f, -1.19199552e-01f, -9.83111858e-02f, 4.87835556e-01f, 1.62765071e-01f, 1.07700288e-01f, 3.28456372e-01f,
  3.89368445e-01f, -9.17885154e-02f, -4.19093907e-01f, 1.56113952e-01f, -3.88059705e-01f, 6.56327307e-02f, -2.41892993e-01f, -5.51224239e-02f, 4.16188128e-02f, 2.63838381e-01f,
  -3.41408223e-01f, 3.40837717e-01f, -8.42324495e-02f, -3.73781204e-01f, 1.35670111e-01f, 1.40649304e-01f, 3.59796166e-01f, 1.73957765e-01f, 2.70253029e-02f, 3.19296449e-01f,
  2.37440780e-01f, -2.14852065e-01f, -9.27178375e-03f, 1.80648953e-01f, -1.17824890e-01f, 2.05549389e-01f, 2.52755899e-02f, -1.69024572e-01f, 2.39800334e-01f, 1.86837718e-01f,
  3.85090262e-01f, -3.93246040e-02f, 1.76852897e-01f, 3.32228243e-01f, 6.02701232e-02f, 5.80781698e-02f, -1.90346077e-01f, -1.33869082e-01f, 6.39180541e-02f, 1.77312400e-02f,
  8.58905464e-02f, -6.28907084e-02f, 2.11507410e-01f, 1.46917641e-01f, 4.33979556e-02f, 1.29464209e-01f, 1.31856263e-01f, 5.67779355e-02f, 7.35573694e-02f, -1.22510893e-02f,
  1.60559222e-01f, 9.99776833e-03f, 1.62473962e-01f, -1.04675323e-01f, -1.21413559e-01f, 1.80638969e-01f, 2.28575394e-01f, 2.34156534e-01f, -6.07873648e-02f, -2.39371613e-01f,
  -3.84376943e-01f, 3.17370862e-01f, -2.13446602e-01f, -3.12174499e-01f, 2.66121570e-02f, 5.67382462e-02f, -3.24537307e-01f, -5.09950891e-03f, 1.00847811e-01f, -3.85380648e-02f,
  2.36926228e-01f, 3.33506554e-01f, -3.67940545e-01f, 6.76268712e-02f, -2.36804143e-01f, 3.03146273e-01f, -1.29198832e-02f, 3.24996084e-01f, -2.21420586e-01f, 9.42240357e-02f,
  -2.57961035e-01f, 1.51327595e-01f, 4.57286537e-01f, 2.42175117e-01f, 4.93371010e-01f, -2.21246958e-01f, -1.50870636e-01f, -7.89584941e-04f, -9.79757011e-02f, 9.92431939e-02f,
  -2.30076239e-01f, -2.30676666e-01f, 2.51594186e-01f, 2.47073948e-01f, -4.14538592e-01f, 6.27483875e-02f, 2.30241809e-02f, 1.64890215e-01f, 2.95503318e-01f, -7.59942606e-02f,
  2.78723240e-01f, 1.54455319e-01f, 3.40793788e-01f, 2.05754891e-01f, 1.19719811e-01f, 5.35285324e-02f, -7.92296976e-02f, 2.19667152e-01f, 1.43549353e-01f, -2.24991173e-01f,
  2.57996440e-01f, 1.98084712e-01f, 7.09061176e-02f, 2.61928290e-01f, 2.10542098e-01f, 3.87354225e-01f, 1.04698455e-02f, 3.18669491e-02f, -2.19135121e-01f, 1.66366905e-01f,
  -1.01511560e-01f, 2.45585293e-01f, 2.55883783e-01f, 1.18468098e-01f, 2.72081524e-01f, 2.32062876e-01f, 2.34541014e-01f, -4.30717990e-02f, 5.08104980e-01f, -9.15993080e-02f,
  -1.96201980e-01f, 5.73587976e-02f, 3.85131776e-01f, -4.00826752e-01f, 1.64819404e-01f, -2.10999414e-01f, 4.18030620e-01f, 6.81247264e-02f, 1.29248828e-01f, 6.97335973e-02f,
  -2.71312505e-01f, -1.76334992e-01f, 3.32287431e-01f, 8.08832645e-02f, 1.30867660e-01f, 3.64437073e-01f, 2.32132614e-01f, 3.87598962e-01f, 2.97882140e-01f, 1.20502822e-01f,
  -1.78923205e-01f, 3.43989432e-02f, 4.78955597e-01f, 1.45740062e-01f, -1.76309019e-01f, 5.00364900e-01f, 2.83254266e-01f, 5.74912094e-02f, 2.70572063e-02f, -2.25127846e-01f,
  -1.10581322e-02f, 1.52025729e-01f, -6.12378605e-02f, 2.00043038e-01f, -2.57377863e-01f, 1.23532094e-01f, 6.79903924e-02f, 4.75049987e-02f, 2.21501932e-01f, 2.42268201e-02f,
  2.51002014e-01f, -5.60058653e-02f, 2.04828829e-01f, 3.01875144e-01f, 2.19358146e-01f, -1.60645902e-01f, 3.12941857e-02f, 2.25230440e-01f, -1.14310542e-02f, -7.30061010e-02f,
  5.65486476e-02f, 2.23699704e-01f, 4.93528135e-02f, 1.82198241e-01f, 1.03637584e-01f, 1.62134975e-01f, -8.61347914e-02f, -4.70122248e-01f, -2.02273410e-02f, 2.36165524e-01f,
  1.69159785e-01f, 6.63899481e-02f, 3.40897925e-02f, -3.72037023e-01f, 9.52973664e-02f, -4.55460429e-01f, -4.59943831e-01f, -1.99303612e-01f, 2.42220387e-01f, 5.18269181e-01f,
  -6.21184051e-01f, 1.96283180e-02f, -7.23443851e-02f, 1.30340606e-01f, 2.79501885e-01f, 6.23860024e-02f, -1.78046301e-01f, 1.53832495e-01f, 1.77076057e-01f, -3.68940055e-01f,
  3.22531372e-01f, -3.39468688e-01f, 1.32747293e-01f, -6.64908737e-02f, 3.76803011e-01f, 1.32555589e-01f, 1.85461447e-01f, -1.72816798e-01f, -2.65904635e-01f, -2.92161882e-01f,
  9.18361619e-02f, 3.36670399e-01f, 2.44674817e-01f, 2.14907184e-01f, 4.66975980e-02f, 2.27798998e-01f, 2.48014227e-01f, 3.50785822e-01f, 3.40875126e-02f, 4.86873575e-02f,
  1.18900433e-01f, -4.97689508e-02f, 4.87689823e-02f, -9.36843008e-02f, 1.33579895e-01f, 2.14099690e-01f, 1.03626750e-01f, 3.21257822e-02f, 3.92214991e-02f, 1.86824828e-01f,
  4.70950678e-02f, -1.16340294e-01f, 3.13785195e-01f, 2.50463903e-01f, 2.66485572e-01f, -1.25776067e-01f, -1.02693163e-01f, 2.46076837e-01f, 4.72828597e-02f, 1.38665214e-01f,
  -5.63538074e-02f, -7.74647444e-02f, -3.74539942e-01f, 2.19276518e-01f, -2.32300252e-01f, -4.24536407e-01f, 2.90779740e-01f, 5.13190985e-01f, -2.25368977e-01f, -7.61960223e-02f,
  2.46590689e-01f, 1.95788462e-02f, 1.21505663e-01f, 2.96448827e-01f, -1.51096925e-01f, 1.43314600e-01f, -3.07716429e-01f, 5.37605397e-02f, -1.24249272e-01f, 3.47602516e-01f,
  -2.40710020e-01f, -2.76031047e-02f, 3.49339917e-02f, 2.81067431e-01f, 5.23195267e-01f, 3.62229884e-01f, 5.53229153e-01f, -2.38486230e-01f, -2.16728762e-01f, 6.19279034e-02f,
  1.13527119e-01f, 8.46018121e-02f, -1.01224363e-01f, -3.39279026e-01f, 4.82230395e-01f, 2.04050839e-01f, -4.13077831e-01f, -1.71739534e-01f, 1.63781330e-01f, 1.91010684e-01f,
  1.51863918e-01f, -5.96623756e-02f, 1.20515771e-01f, 2.05063194e-01f, -8.40343535e-02f, 8.08180347e-02f, 2.41429418e-01f, 1.70827031e-01f, 9.29414667e-03f, -3.37737538e-02f,
  -8.51526763e-03f, -2.41834577e-02f, 3.21553759e-02f, 1.36795551e-01f, -4.46540378e-02f, 1.98565021e-01f, 2.39078805e-01f, -3.41248512e-03f, 5.99817783e-02f, 2.00711370e-01f,
  2.40243629e-01f, 2.05616578e-01f, 5.63583262e-02f, 5.22745661e-02f, 2.33221024e-01f, 8.13389495e-02f, 3.00739378e-01f, -9.17687938e-02f, -3.08142632e-01f, 2.51253247e-01f,
  1.75912648e-01f, -7.93267861e-02f, 4.41322774e-02f, 3.40037286e-01f, 6.49738163e-02f, 9.85036641e-02f, -3.11426222e-01f, -1.96618989e-01f, 2.64225245e-01f, -3.73856574e-01f,
  2.97073811e-01f, -3.67727131e-01f, 2.36144006e-01f, 9.19070244e-02f, 2.09919110e-01f, 1.15575366e-01f, 3.08018893e-01f, 3.23427260e-01f, -2.80447397e-02f, 4.07645702e-02f,
  -2.42054626e-01f, 6.40693247e-01f, 5.50303221e-01f, 3.76158208e-01f, 4.79155511e-01f, 5.73233783e-01f, 1.58943728e-01f, 6.04733288e-01f, 1.46340802e-01f, 2.57005215e-01f,
  5.23956954e-01f, 6.42377362e-02f, -4.48704094e-01f, 4.43684310e-02f, 5.49778566e-02f, 1.00178361e-01f, 5.62690981e-02f, -1.15316845e-01f, 7.86690190e-02f, 4.90892865e-02f,
  -7.01154992e-02f, -1.30701110e-01f, -1.94570690e-01f, 1.38126090e-01f, -2.24711280e-02f, -1.21640209e-02f, 3.51247415e-02f, 1.80308267e-01f, 1.04030825e-01f, -4.61364910e-02f,
  2.08861887e-01f, 1.97716504e-01f, 2.60145031e-02f, 2.92718828e-01f, -1.86508447e-01f, 2.24045113e-01f, 3.85106541e-02f, 7.81981125e-02f, 1.07671350e-01f, 6.39982164e-01f,
  1.38427123e-01f, -9.93624423e-03f, -2.27923803e-02f, 8.42074901e-02f, 4.26821679e-01f, 2.87604600e-01f, -2.23757789e-01f, 4.16258335e-01f, 3.29561025e-01f, 4.10476327e-01f,
  -2.32222691e-01f, -3.80803198e-01f, 5.31563222e-01f, 1.73758104e-01f, 2.67987270e-02f, 2.84963936e-01f, -3.20768833e-01f, -5.19529104e-01f, -1.49046585e-01f, 2.00508893e-01f,
  1.26215383e-01f, 1.39227763e-01f, -3.67670208e-01f, 2.05595508e-01f, 4.01685953e-01f, 1.43170416e-01f, 3.09237361e-01f, -2.65015572e-01f, -4.60085534e-02f, 1.43855780e-01f,
  2.32211813e-01f, -4.07450795e-01f, 5.27083054e-02f, 7.05974773e-02f, -2.13312000e-01f, -1.73834935e-01f, -3.25884633e-02f, 2.19649032e-01f, -4.90964688e-02f, 1.56330392e-01f,
  8.65096152e-02f, 1.85259476e-01f, -4.76201475e-02f, 9.66615677e-02f, 1.11367106e-01f, 2.29530916e-01f, -2.14909121e-01f, 7.11990595e-02f, -8.44204128e-02f, 1.39750868e-01f,
  -1.05200253e-01f, 2.11556166e-01f, 6.57299906e-02f, 9.37722176e-02f, 1.58245265e-01f, 1.66837916e-01f, 1.22965977e-01f, 1.91401199e-01f, -8.81523266e-02f, 1.02039762e-01f,
  1.60574108e-01f, -4.57791574e-02f, 2.15306535e-01f, 4.87488449e-01f, -8.64371657e-02f, -1.09395601e-01f, 1.67693019e-01f, -2.04143196e-01f, 2.28474423e-01f, 4.16474909e-01f,
  -1.33212179e-01f, 2.41270840e-01f, 3.09411228e-01f, -4.43389686e-03f, 2.60897130e-01f, -1.20865501e-01f, 1.04846381e-01f, 2.89594322e-01f, 1.39321804e-01f, 3.24494272e-01f,
  -3.34322512e-01f, -4.43762839e-01f, -1.72146305e-01f, 4.91802245e-02f, -1.37456864e-01f, 6.12572096e-02f, -2.32949052e-02f, 2.66966403e-01f, 1.95761219e-01f, 2.68185467e-01f,
  9.81881022e-02f, -2.70494968e-01f, 1.88783243e-01f, 6.95450883e-03f, 1.52990714e-01f, -9.18791294e-02f, 1.77292377e-01f, 1.74670205e-01f, -3.36118668e-01f, 3.44822295e-02f,
  1.08506016e-01f, -2.01073468e-01f, 3.09471358e-02f, -1.05595647e-03f, -1.61197200e-01f, 3.89461756e-01f, -1.93961903e-01f, 1.72563016e-01f, 3.41901600e-01f, 1.49104550e-01f,
  7.12727904e-02f, 7.10887462e-02f, 6.99135810e-02f, 5.56320660e-02f, 1.68893605e-01f, -2.07245022e-01f, -1.24715291e-01f, 1.85736239e-01f, -1.35576576e-01f, -1.34072930e-01f,
  7.49019235e-02f, 3.06408316e-01f, 2.47415990e-01f, 6.98193163e-02f, 1.68489769e-01f, -4.00249287e-02f, 1.34236842e-01f, -2.67723382e-01f, -2.03480318e-01f, -1.41456783e-01f,
  2.72613078e-01f, -2.97258914e-01f, 3.98808867e-02f, -4.87022400e-02f, 4.16994780e-01f, -6.60363913e-01f, -2.78694063e-01f, -1.54707074e-01f, 1.90479323e-01f, 2.97039628e-01f,
  -4.87193227e-01f, 4.35140461e-01f, 1.02351822e-01f, 1.78009033e-01f, 3.65131289e-01f, -4.16120142e-01f, -1.52822360e-01f, -1.49580196e-01f, -1.53674319e-01f, -6.86178148e-01f,
  -7.61937499e-02f, -1.52596489e-01f, 1.72755167e-01f, 3.50618064e-01f, 3.64112407e-01f, -1.73397705e-01f, 4.13306653e-01f, -2.86923319e-01f, 9.27210897e-02f, -1.47920698e-01f,
  2.96599030e-01f, -9.99687538e-02f, 1.61169022e-01f, 3.78797501e-01f, 1.75495058e-01f, -2.07098767e-01f, 2.28863165e-01f, 6.45633368e-03f, 2.86849767e-01f, -8.48702118e-02f,
  2.42058769e-01f, 1.46583645e-02f, 1.43326357e-01f, 3.07432920e-01f, -2.40582731e-02f, 1.63086355e-01f, 1.78159952e-01f, -1.35520697e-01f, 1.51812583e-01f, 1.99478135e-01f,
  1.09401956e-01f, 1.74031362e-01f, 8.29350203e-02f, 1.20751485e-01f, 7.36450255e-02f, 1.36594906e-01f, -2.44155467e-01f, -8.14330876e-02f, 1.85587257e-01f, 1.34133752e-02f,
  2.56702214e-01f, 3.26536775e-01f, -1.42467409e-01f, -4.32008564e-01f, -2.16639385e-01f, -4.83015105e-02f, -3.44689459e-01f, 3.38731050e-01f, 3.83094102e-02f, 1.58597678e-02f,
  3.65635514e-01f, 3.03873330e-01f, 3.72297883e-01f, -2.52705574e-01f, -8.13040733e-02f, -1.00805148e-01f, 2.45458946e-01f, 3.67532402e-01f, -4.39955890e-02f, -2.60562688e-01f,
  -1.62229285e-01f, 1.87254071e-01f, -3.03892404e-01f, -2.83851922e-02f, -5.56489170e-01f, -3.57430428e-01f, 1.03928238e-01f, 4.01455402e-01f, 6.01519465e-01f, -6.23311512e-02f,
  1.23593278e-01f, 5.91849759e-02f, 3.23278993e-01f, -1.51526913e-01f, -1.82225958e-01f, 1.96957618e-01f, -1.56394929e-01f, 3.99280846e-01f, -2.48241380e-01f, -1.65948853e-01f,
  -1.37089595e-01f, 8.49229395e-02f, -1.13343045e-01f, -6.80243969e-02f, 2.38224745e-01f, 2.99440742e-01f, 1.76132783e-01f, -2.31930166e-02f, 2.51759440e-01f, 1.29259706e-01f,
  3.41755599e-01f, 1.73828632e-01f, 2.67790139e-01f, -6.73196688e-02f, 4.79922332e-02f, 2.52624035e-01f, 2.63552338e-01f, -3.09860371e-02f, -6.57249168e-02f, -1.44201010e-01f,
  1.69129029e-01f, -8.43167976e-02f, 1.84125289e-01f, 6.34746775e-02f, 1.89718738e-01f, -1.96216539e-01f, -1.53513536e-01f, 1.43285111e-01f, -2.83274502e-01f, 7.43733346e-02f,
  -6.74634352e-02f, 1.84725747e-01f, -5.28861359e-02f, -8.59825313e-03f, -2.45968565e-01f, -7.86016062e-02f, -1.72828481e-01f, 3.56486470e-01f, -4.95315820e-01f, -6.90799892e-01f,
  -3.68604541e-01f, 6.43617436e-02f, 2.74124026e-01f, 4.75763470e-01f, -3.81241590e-01f, 2.22966477e-01f, 2.08326261e-02f, -1.97588459e-01f, -3.69617105e-01f, 7.25957900e-02f,
  1.10954992e-01f, 1.38489828e-01f, 4.75057006e-01f, 2.58533329e-01f, 7.90413655e-03f, 1.82145551e-01f, -1.58243366e-02f, -5.32820404e-01f, -2.41043016e-01f, 4.69054192e-01f,
  -1.32757083e-01f, 2.66169816e-01f, -5.41687012e-02f, 2.92914003e-01f, 2.49753177e-01f, -2.47570723e-02f, 7.78436149e-03f, 1.26872152e-01f, -9.54967439e-02f, -1.84942424e-01f,
  2.20576912e-01f, 1.61909014e-01f, 2.34249741e-01f, 1.21105939e-01f, 1.50390506e-01f, 1.13483556e-01f, 1.30663946e-01f, 9.47086588e-02f, -2.08050668e-01f, -8.81592557e-02f,
  -5.13259396e-02f, 2.11301539e-02f, 2.94647485e-01f, 6.35179803e-02f, 3.16837043e-01f, 1.12243615e-01f, 9.60820690e-02f, 1.21507712e-01f, 1.23459667e-01f, -2.22457618e-01f,
  -4.79697645e-01f, 7.47406483e-02f, 3.96862216e-02f, -3.25684369e-01f, -3.38814557e-01f, 3.34395826e-01f, -1.76403314e-01f, -2.09166966e-02f, -8.19208473e-02f, 4.16152537e-01f,
  5.30022308e-02f, 2.40440294e-02f, -1.07953355e-01f, 4.10076499e-01f, -1.86887309e-01f, 2.56417245e-01f, 6.88885525e-02f, -2.45473757e-01f, 4.75119893e-03f, -7.25132823e-02f,
  -8.34958330e-02f, -1.59672692e-01f, 2.65509158e-01f, 1.45729125e-01f, 1.87466711e-01f, 2.95735985e-01f, 1.33434445e-01f, -3.34952682e-01f, -4.25598890e-01f, -9.87287238e-02f,
  5.60812950e-01f, -2.44229779e-01f, 8.00763220e-02f, -4.51170318e-02f, 1.36214331e-01f, 4.08305436e-01f, 3.59882057e-01f, -2.76547652e-02f, 1.97632775e-01f, 1.19643860e-01f,
  2.17588842e-01f, -3.46192360e-01f, 1.65578965e-02f, -2.63388194e-02f, -5.12731522e-02f, -7.03929141e-02f, 6.56612590e-02f, 9.84646901e-02f, 1.04563452e-01f, -4.07615192e-02f,
  2.54384607e-01f, 2.11584702e-01f, 1.35715991e-01f, 1.69601247e-01f, -2.04778850e-01f, 2.59667635e-01f, 1.49737094e-02f, 2.35822778e-02f, -3.87647122e-01f, -2.11897716e-02f,
  5.94072416e-03f, -4.44368199e-02f, -1.04822278e-01f, -6.20831884e-02f, -3.53909768e-02f, 2.04816982e-01f, 2.47227803e-01f, 2.91828036e-01f, -1.64280653e-01f, -4.08718079e-01f,
  8.97649229e-02f, -1.33183561e-02f, 1.64695159e-01f, -1.97152317e-01f, 2.47640371e-01f, 5.76869138e-02f, -1.12520784e-01f, 2.44538099e-01f, 3.79401296e-01f, 4.07941163e-01f,
  -1.65881962e-01f, -4.64945026e-02f, 1.01751447e-01f, 2.82908618e-01f, -3.96393627e-01f, 2.22222403e-01f, 7.01180398e-02f, -4.51089919e-01f, 2.23086149e-01f, 1.21505953e-01f,
  6.31060153e-02f, -2.23071530e-01f, 4.12301511e-01f, -2.69413203e-01f, -2.17180237e-01f, 2.79993474e-01f, -1.48807570e-01f, 1.50198996e-01f, 1.83012813e-01f, 5.54725707e-01f,
  -2.96306819e-01f, 1.65754601e-01f, 3.65418434e-01f, 9.59907919e-02f, 3.53587091e-01f, 2.97084581e-02f, 1.54102109e-02f, 1.21720918e-01f, 2.31586665e-01f, 2.04994559e-01f,
  3.42248268e-02f, 7.27574229e-02f, 1.65449485e-01f, -1.19096413e-01f, 3.53040189e-01f, 1.67141035e-01f, -1.15319468e-01f, 1.09653018e-01f, -1.45359829e-01f, 2.49930426e-01f,
  4.93610166e-02f, 1.68094803e-02f, -2.90764004e-01f, 7.27524757e-02f, -5.85741475e-02f, 1.04361087e-01f, 2.80469865e-01f, -8.86844546e-02f, 1.10395886e-01f, 2.55942047e-01f,
  1.82975769e-01f, 2.82090306e-01f, -7.49966055e-02f, -3.45127404e-01f, 1.36991605e-01f, 6.12639263e-02f, 1.59759730e-01f, -2.37405702e-01f, 4.44416225e-01f, 1.40892258e-02f,
  -1.06046617e-01f, 2.13299692e-01f, 2.09387720e-01f, 2.49763131e-01f, -2.41255254e-01f, -1.00514710e-01f, 3.24248523e-02f, -7.82155320e-02f, -2.91922659e-01f, -1.19704142e-01f,
  3.86188328e-02f, -2.36293837e-01f, 2.51094908e-01f, 7.43249282e-02f, -1.33716181e-01f, 6.68653622e-02f, 3.03799301e-01f, -1.23893224e-01f, -3.29086721e-01f, 4.37481999e-01f,
  6.78486228e-02f, 1.93224326e-01f, 1.31562114e-01f, 1.90322608e-01f, 3.91163416e-02f, 1.54112682e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.16053522e-01f, 4.73311469e-02f, 1.00068770e-01f, 2.82447726e-01f, 1.53357431e-01f, 1.49983704e-01f, 3.63590308e-02f, 9.51002389e-02f, 1.25658795e-01f, 2.57927209e-01f,
  7.90394321e-02f, 7.27566257e-02f, 2.46206552e-01f, 2.10868165e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  7.39120245e-02f, -1.97784975e-01f, -3.43775302e-02f, -8.30940809e-03f, -6.84345663e-02f, -5.78955933e-02f, -2.16969416e-01f, -1.20228790e-01f, 1.68709040e-01f, 1.27572060e-01f,
  -1.09940328e-01f, 4.42812257e-02f, -2.45813996e-01f, 2.58295704e-02f, 5.89758120e-02f, 3.64800729e-02f, 1.50976583e-01f, -1.30652219e-01f, -8.34162310e-02f, -1.13043681e-01f,
  3.35801803e-02f, 7.16005936e-02f, -1.41974300e-01f, 1.83136627e-01f, 6.82259649e-02f, 1.27346322e-01f, 3.91278774e-01f, -1.96294650e-01f, -2.37107679e-01f, -3.80373448e-01f,
  1.46887466e-01f, 2.13117022e-02f, -3.80090892e-01f, 2.06306249e-01f, 6.75980523e-02f, -3.36657256e-01f, -3.02470148e-01f, 2.29519174e-01f, -1.02570392e-01f, -2.85103559e-01f,
  2.06575379e-01f, -1.68374985e-01f, 2.12473214e-01f, 1.94450945e-01f, 3.61689031e-01f, 5.23047782e-02f, -3.67224365e-02f, -1.45230532e-01f, 2.11625949e-01f, -3.02106410e-01f,
  1.80545285e-01f, 2.23508999e-01f, 1.96646042e-02f, -3.27363372e-01f, 2.55293697e-01f, -3.72137368e-01f, 3.92735720e-01f, 1.11873373e-01f, -4.71410424e-01f, -3.81515980e-01f,
  -4.03858870e-01f, 2.62570590e-01f, -1.11290857e-01f, -1.38472527e-01f, 1.91228971e-01f, 1.35667711e-01f, 1.02512324e-02f, 3.72341648e-02f, -1.06989801e-01f, -1.84325635e-01f,
  1.95826739e-01f, 7.83123076e-02f, -2.35640362e-01f, -3.51363868e-01f, -6.33312911e-02f, -9.07360688e-02f, 1.71714932e-01f, -3.16324562e-01f, 5.34754843e-02f, -1.85728237e-01f,
  1.24175502e-02f, 1.73223823e-01f, -2.70015717e-01f, -7.32592717e-02f, 3.88289765e-02f, -8.60699341e-02f, 3.19929235e-02f, -2.56227758e-02f, 1.65599689e-01f, 1.82523817e-01f,
  -3.94916743e-01f, -7.09148273e-02f, 3.24013650e-01f, -2.80860752e-01f, -3.03761005e-01f, -1.56945169e-01f, 3.98618132e-01f, -2.03519519e-02f, 1.31990522e-01f, -1.84504032e-01f,
  -2.25673690e-01f, -5.42879403e-02f, 2.83355504e-01f, 1.04614556e-01f, 1.00124449e-01f, -1.46764889e-01f, 1.27399623e-01f, 1.47826254e-01f, -3.66811723e-01f, 2.97514915e-01f,
  3.01256090e-01f, 8.30209628e-02f, -2.32452124e-01f, -3.78153056e-01f, 1.47050932e-01f, 1.39259785e-01f, -2.40797885e-02f, 1.97917476e-01f, 1.25041679e-01f, -4.64601249e-01f,
  -1.80946186e-01f, 1.00244880e-01f, 2.90974796e-01f, -4.96485859e-01f, -2.30961323e-01f, 3.72849524e-01f, -3.20547521e-01f, 4.07911763e-02f, -8.82629422e-04f, 2.90175751e-02f,
  -3.36891226e-02f, 7.39295185e-02f, -1.48083881e-01f, -7.19987601e-02f, 9.34015140e-02f, -6.47398084e-02f, 9.64596681e-03f, -1.98833734e-01f, -1.21798858e-01f, 2.25035883e-02f,
  -1.94858789e-01f, -7.51829222e-02f, 1.49382159e-01f, 4.26167436e-02f, 8.90913382e-02f, -9.10680890e-02f, 2.17919320e-01f, 4.51927334e-02f, 1.58446684e-01f, 1.41940534e-01f,
  -1.95328966e-01f, 3.70861180e-02f, -7.81362951e-02f, -2.46927768e-01f, -3.20288420e-01f, -2.71599799e-01f, 3.03604782e-01f, -1.52697444e-01f, 3.95045638e-01f, -3.55679765e-02f,
  2.26786271e-01f, 3.01202774e-01f, 7.08113387e-02f, -8.77927989e-02f, 3.23763281e-01f, -2.32122391e-01f, 6.65688291e-02f, -2.99212754e-01f, 3.49932134e-01f, 2.57607490e-01f,
  -2.89280057e-01f, 1.39157221e-01f, -3.00238401e-01f, 2.25689441e-01f, 1.12913987e-02f, 1.47702470e-01f, -2.57156342e-01f, 3.37122053e-01f, 2.79405802e-01f, -3.49244505e-01f,
  1.72978848e-01f, 3.02912116e-01f, -4.43984538e-01f, -1.51147068e-01f, -2.74249375e-01f, -4.68479395e-01f, 1.40419915e-01f, -4.40524518e-01f, -5.04456103e-01f, -4.76802915e-01f,
  4.63703930e-01f, 1.89622998e-01f, -1.08542942e-01f, -3.07034165e-01f, 1.50764316e-01f, 2.79897898e-02f, -2.04057515e-01f, -2.64610648e-01f, 1.95651591e-01f, -3.44115734e-01f,
  -2.12202027e-01f, -1.02990314e-01f, 4.61720377e-02f, 2.13088412e-02f, -1.03503697e-01f, -7.47575015e-02f, 1.31654859e-01f, -2.34465718e-01f, -2.15311602e-01f, -2.25541115e-01f,
  -1.08391024e-01f, -4.23544012e-02f, -2.45606557e-01f, 1.59375593e-01f, 2.04556420e-01f, -2.34827712e-01f, -2.60764867e-01f, -2.26295367e-01f, 6.93684220e-02f, 3.25596660e-01f,
  1.09534182e-01f, -2.19869509e-01f, 3.33331734e-01f, 1.72269255e-01f, -1.48094043e-01f, -2.21089900e-01f, -1.20136254e-01f, 2.95883030e-01f, 1.40776932e-01f, -2.07103938e-01f,
  1.58795282e-01f, -2.88627476e-01f, 3.32795382e-01f, 2.84585714e-01f, 2.86983222e-01f, -2.66737223e-01f, 4.20969278e-01f, 1.16008306e-02f, -1.56174764e-01f, -1.34905502e-01f,
  2.21215740e-01f, 3.16148251e-01f, -5.48053205e-01f, -1.29557163e-01f, -5.07464707e-01f, -6.07449710e-01f, -3.72553706e-01f, 5.89268561e-03f, 2.48496592e-01f, 4.11550254e-01f,
  -1.91164277e-02f, 3.26631516e-01f, -4.76283021e-02f, 1.86959013e-01f, -5.04773781e-02f, -4.32650179e-01f, -7.28073344e-02f, 1.49444252e-01f, 4.96218465e-02f, 3.48126255e-02f,
  -4.66879010e-02f, -1.03435762e-01f, 1.86210312e-02f, 5.76065890e-02f, -2.56512612e-01f, 2.54142731e-01f, 6.62577376e-02f, 1.64501414e-01f, 2.39025667e-01f, -3.00979167e-02f,
  1.15911953e-01f, 1.72846586e-01f, 2.68609822e-01f, -1.25247538e-01f, 1.67034179e-01f, -1.79017693e-01f, -2.89602369e-01f, 1.43499359e-01f, -1.04474872e-01f, 2.12759420e-01f,
  1.23499393e-01f, 1.82755485e-01f, -2.57126570e-01f, -2.40150765e-02f, -2.83892810e-01f, 3.16274852e-01f, 2.35118121e-01f, 2.02056840e-01f, -3.97166580e-01f, -1.98626965e-01f,
  -7.17502609e-02f, 4.39463044e-03f, 3.03411812e-01f, 2.90111285e-02f, -2.27237530e-02f, 2.85396695e-01f, -1.51814163e-01f, -4.98246402e-02f, 8.77524763e-02f, -2.28839502e-01f,
  -1.49519205e-01f, -1.50724798e-01f, 1.51804805e-01f, -3.37048084e-01f, -3.44738841e-01f, -2.00388104e-01f, 2.54812926e-01f, -3.47693056e-01f, 6.95408732e-02f, -4.15536821e-01f,
  -2.49533966e-01f, 2.03143165e-01f, 3.86677444e-01f, 1.79773360e-01f, -3.47341001e-01f, 1.52562648e-01f, 6.10199384e-02f, -1.83916897e-01f, -4.33884710e-01f, -1.66066185e-01f,
  6.16123388e-03f, 1.85934067e-01f, 2.29896188e-01f, 5.03610969e-02f, 2.50591934e-01f, 7.61159584e-02f, 2.37288460e-01f, 1.93176195e-01f, 2.21074909e-01f, 2.53135383e-01f,
  -6.80164713e-03f, 1.72511384e-01f, -2.33956054e-01f, 1.75116658e-01f, -9.05736834e-02f, 2.04023674e-01f, -2.42034152e-01f, -6.41312078e-02f, 1.11557387e-01f, -1.84805468e-02f,
  7.90733248e-02f, 1.51275724e-01f, 5.65024726e-02f, -3.56323682e-02f, -2.31315732e-01f, -3.22628990e-02f, 3.31224799e-02f, -1.63232774e-01f, -3.10481369e-01f, 2.41316751e-01f,
  -3.37767869e-01f, -9.62385833e-02f, 4.24106210e-01f, -9.24115404e-02f, 5.45896776e-02f, 3.79503101e-01f, 1.48081154e-01f, 3.13781321e-01f, -2.01086596e-01f, 2.07229897e-01f,
  -2.76358843e-01f, -1.62989974e-01f, 2.73246646e-01f, 1.71017885e-01f, 3.12096328e-01f, 5.22245318e-02f, -1.20824099e-01f, -3.25936198e-01f, -3.14660728e-01f, -1.02607265e-01f,
  1.08503081e-01f, 3.24095160e-01f, 3.21257161e-03f, 1.37367353e-01f, 3.01497906e-01f, -1.60394266e-01f, -1.84595123e-01f, -4.51907754e-01f, -3.15564007e-01f, -3.45379710e-01f,
  3.93185973e-01f, -1.98655367e-01f, -4.87267494e-01f, -3.46826285e-01f, 6.55863136e-02f, -2.76447356e-01f, 1.12858944e-01f, -8.87169167e-02f, 1.77091226e-01f, -4.42739576e-02f,
  1.50268093e-01f, -2.70443261e-01f, 1.13693766e-01f, -2.17142552e-01f, -9.11177602e-03f, 1.88908260e-02f, -3.49602289e-02f, 2.47259945e-01f, -1.04788706e-01f, 1.31106809e-01f,
  6.64774328e-03f, 1.06126390e-01f, 1.22364499e-01f, 3.43408063e-02f, 6.03471175e-02f, -1.90929830e-01f, 6.44098744e-02f, -2.21859455e-01f, 6.68837950e-02f, -1.87225789e-01f,
  -1.84186593e-01f, 2.62043804e-01f, -1.71864942e-01f, 2.03904524e-01f, -3.51928711e-01f, 2.45097890e-01f, 7.46628419e-02f, -1.65746599e-01f, 1.16957679e-01f, 3.60301495e-01f,
  3.29320729e-01f, -1.03273347e-01f, -4.92654853e-02f, 2.33540922e-01f, -2.64516830e-01f, -6.15682602e-02f, -3.64993215e-01f, -2.84318745e-01f, 1.62667722e-01f, -1.93167448e-01f,
  2.59666532e-01f, 2.55819201e-01f, 1.88772008e-02f, -2.76794195e-01f, -6.48804903e-02f, -3.46645474e-01f, -2.32207775e-01f, 4.00303155e-01f, -5.77771783e-01f, 2.18390167e-01f,
  -2.53553152e-01f, -3.55902523e-01f, 2.41708487e-01f, -3.50545436e-01f, 2.28347555e-01f, -3.19640785e-01f, -2.53250897e-01f, -7.22584128e-02f, -2.71012485e-01f, 1.36133626e-01f,
  -2.15526387e-01f, 6.11562282e-02f, 5.33816665e-02f, 1.66986972e-01f, -2.60791242e-01f, 1.53815076e-01f, -1.95466712e-01f, 9.40255821e-02f, 8.74454007e-02f, -2.33594581e-01f,
  4.17769030e-02f, 2.63922721e-01f, -1.35003328e-01f, 1.23068474e-01f, 5.80007471e-02f, -2.22634509e-01f, -6.58120438e-02f, -2.16897115e-01f, -1.99091688e-01f, -6.42430484e-02f,
  7.21013322e-02f, 1.13699749e-01f, 1.99322373e-01f, 2.61132538e-01f, 2.96870500e-01f, 1.50032371e-01f, 2.95664668e-01f, 3.08556199e-01f, -3.94631237e-01f, 5.79228103e-02f,
  4.48219836e-01f, -6.65677413e-02f, -2.58660734e-01f, 2.81957656e-01f, -2.64116287e-01f, -2.57561952e-01f, -2.12048113e-01f, 2.09277481e-01f, -1.86507165e-01f, -3.36164325e-01f,
  2.81501353e-01f, -1.12362742e-01f, 1.80839598e-01f, -2.50950813e-01f, -2.52347648e-01f, 3.83757561e-01f, 3.13318938e-01f, 2.45558739e-01f, -3.82292181e-01f, -1.98382095e-01f,
  -2.41904467e-01f, -3.08057636e-01f, -1.11580551e-01f, 5.18116593e-01f, -4.61820066e-01f, -3.69517863e-01f, -9.00812894e-02f, 1.01513185e-01f, -2.34171852e-01f, 2.73325473e-01f,
  -3.21900576e-01f, -3.60503465e-01f, 1.23968475e-01f, -8.49067420e-02f, -1.54367536e-01f, -1.60804734e-01f, 1.43730164e-01f, -1.66096464e-02f, 5.51803969e-02f, -5.75536713e-02f,
  -1.21758424e-01f, 1.46029651e-01f, -2.19196275e-01f, 9.23568085e-02f, 3.39215100e-02f, 9.29579437e-02f, 7.53401816e-02f, 8.01314265e-02f, -1.20024085e-01f, 6.39386699e-02f,
  -2.48166904e-01f, -9.68640074e-02f, -1.11530922e-01f, -5.30554205e-02f, -5.63007258e-02f, -9.73661840e-02f, -3.59541997e-02f, -1.00456171e-01f, 3.40779364e-01f, -1.26796454e-01f,
  1.07839100e-01f, -5.20333881e-03f, -1.01212583e-01f, 1.36013821e-01f, -2.86884785e-01f, 3.04397587e-02f, -1.41764298e-01f, -1.19190030e-01f, -2.48036370e-01f, 1.34621784e-01f,
  -1.24826292e-02f, -2.78042406e-01f, 1.42220721e-01f, 8.81103426e-02f, -2.20187992e-01f, 4.56767641e-02f, -2.19740719e-01f, 2.39978328e-01f, -1.94982573e-01f, 1.21683858e-01f,
  3.13178837e-01f, 2.99937874e-01f, -5.07479131e-01f, 1.09502845e-01f, 3.02822739e-01f, -7.94795603e-02f, 2.04048589e-01f, -1.55392364e-01f, 1.30081866e-02f, 3.74553353e-01f,
  9.74857286e-02f, -1.24025519e-03f, -4.09215450e-01f, -4.31715608e-01f, 1.28041640e-01f, 2.66399801e-01f, 1.58736140e-01f, 1.72461480e-01f, -1.54082522e-01f, -1.52075440e-01f,
  -7.43434429e-02f, -1.01739261e-02f, -2.40788773e-01f, 1.03261307e-01f, 8.18585008e-02f, -2.65592903e-01f, 1.48583815e-01f, 6.86597079e-02f, -2.30452269e-02f, -1.73257306e-01f,
  -2.32979298e-01f, -1.88727990e-01f, 3.26495543e-02f, 2.50748277e-01f, 8.59141443e-03f, -2.01681256e-01f, 1.65562391e-01f, 3.28512602e-02f, 5.09362444e-02f, -2.46206000e-01f,
  1.04683504e-01f, -1.45620614e-01f, 2.14046985e-02f, 1.92955300e-01f, -2.22303838e-01f, -4.27414596e-01f, 1.64870664e-01f, -1.47507831e-01f, 2.86923528e-01f, -2.76296645e-01f,
  -1.70525368e-02f, -1.87466890e-02f, -3.37887555e-01f, 1.34961456e-01f, -2.58770436e-01f, -8.30125064e-02f, -2.84905851e-01f, -1.74497545e-01f, -2.98129003e-02f, -1.73760876e-01f,
  1.93549350e-01f, -8.99262205e-02f, -2.24401221e-01f, 1.83230534e-01f, -1.51278555e-01f, -1.62539974e-01f, 2.95202285e-01f, -3.20957512e-01f, 4.48108017e-01f, -2.66728520e-01f,
  -2.01529860e-01f, 2.92012304e-01f, -3.58087569e-01f, -2.97552288e-01f, -5.19595206e-01f, -4.71981883e-01f, -4.18178290e-01f, -2.80066729e-01f, -6.86194077e-02f, 2.98311621e-01f,
  -2.02953190e-01f, 1.63200691e-01f, 4.56158854e-02f, -6.41743168e-02f, 5.86624369e-02f, -4.91377525e-03f, 4.12425213e-02f, 1.24890283e-01f, 8.34165588e-02f, 2.04290450e-01f,
  5.02262861e-02f, 6.10115305e-02f, 1.19466424e-01f, -3.99183124e-01f, 8.19177330e-02f, -2.44750187e-01f, -2.10695356e-01f, 2.17585593e-01f, 2.83025891e-01f, 8.39264505e-03f,
  9.13552125e-04f, -2.23802239e-01f, 8.04177374e-02f, -1.78473413e-01f, -2.49704137e-01f, 6.98943064e-02f, 1.77254334e-01f, -3.52136493e-01f, 2.40574598e-01f, 2.58759081e-01f,
  -3.30304652e-01f, -3.87365520e-01f, -1.86435267e-01f, -1.62752997e-02f, -2.10786730e-01f, -1.64176762e-01f, -1.16166569e-01f, -1.68095693e-01f, -1.16190776e-01f, -2.95141727e-01f,
  -9.65843722e-02f, 1.13362417e-01f, -2.60660917e-01f, 2.48180702e-01f, -3.53683770e-01f, -1.19054027e-01f, 1.98482469e-01f, 2.21666142e-01f, 2.44928330e-01f, 2.57226706e-01f,
  -2.47080892e-01f, -1.26312464e-01f, -4.14754868e-01f, -2.05175411e-02f, -3.93707782e-01f, -1.67679548e-01f, -2.50469029e-01f, -1.17787495e-01f, 3.81544530e-01f, 2.58321792e-01f,
  9.81037468e-02f, 1.91404954e-01f, 2.53237486e-02f, 1.55342882e-02f, -2.44826257e-01f, 5.31108445e-03f, -1.05971042e-02f, -1.39449269e-01f, -4.17264737e-02f, -5.68195358e-02f,
  -5.29433452e-02f, -6.34017140e-02f, 1.25535086e-01f, 5.31596355e-02f, -1.79422036e-01f, -3.80422547e-02f, -1.63024992e-01f, 1.15186773e-01f, -7.55180791e-02f, 1.57201156e-01f,
  8.82463232e-02f, 1.49413764e-01f, 4.78512421e-03f, 3.54175568e-02f, -2.21981615e-01f, -1.34497449e-01f, -6.09749742e-02f, 1.81592464e-01f, 2.37607032e-01f, 1.74180150e-01f,
  2.86600083e-01f, 3.38013440e-01f, 3.80075991e-01f, 1.73498422e-01f, 2.07035720e-01f, -3.82733107e-01f, -1.81399047e-01f, 2.66594887e-01f, -2.89124310e-01f, 3.19860131e-01f,
  1.69490799e-01f, 3.23020518e-01f, -1.17767416e-01f, 2.16913328e-01f, -2.28317052e-01f, 2.40248829e-01f, 1.18890837e-01f, -3.19968402e-01f, 1.79933518e-01f, -1.69753835e-01f,
  1.52620226e-01f, -2.02337950e-01f, 7.21271336e-02f, -1.66759893e-01f, -6.51982352e-02f, 2.59111315e-01f, -2.45412529e-01f, 8.92698541e-02f, -1.04889311e-01f, -2.79537350e-01f,
  -1.37654990e-01f, -1.83770895e-01f, -3.62175852e-01f, 1.32395789e-01f, 1.77980408e-01f, 2.73813158e-02f, 4.23179865e-01f, 3.63137841e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.89584792e-02f, 1.18478961e-01f, -4.15828042e-02f, 5.89656346e-02f, -1.18376359e-01f, -6.70333654e-02f, 8.17188695e-02f, 1.11865737e-01f, -8.60431194e-02f, 7.70468488e-02f,
  -3.43676955e-02f, -9.10079256e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    