/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.52727360e-01f, -3.93448681e-01f, -2.11380705e-01f, 1.51728973e-01f, 7.19906241e-02f, 1.65641740e-01f, 1.94383085e-01f, -1.41362222e-02f, 4.88030165e-02f, 1.62470251e-01f,
  1.33205473e-01f, -7.60567700e-03f, -7.70247653e-02f, 3.03095520e-01f, 2.93050528e-01f, -3.84464189e-02f, 2.22997710e-01f, 5.73176928e-02f, -1.82033658e-01f, 4.31342609e-02f,
  4.30284301e-03f, 3.67681026e-01f, -2.13700663e-02f, -3.56563390e-03f, 7.63250291e-02f, -1.94569424e-01f, 2.33150169e-01f, -2.50754297e-01f, 1.44739434e-01f, 8.17681849e-03f,
  5.30844666e-02f, -5.70837036e-02f, -4.23524156e-02f, -1.40755177e-01f, -1.33391693e-01f, -5.27809747e-02f, -2.17361990e-02f, -6.10066280e-02f, -7.32564405e-02f, 1.89161841e-02f,
  -5.35724610e-02f, 6.14439435e-02f, -2.93328296e-02f, -5.24232090e-02f, 6.18153485e-03f, 6.32470027e-02f, 4.88405749e-02f, -9.93269682e-03f, 1.19754039e-01f, 2.92810351e-02f,
  3.05025112e-02f, -1.10271377e-02f, 9.00986791e-02f, 3.84327732e-02f, -2.02799328e-02f, 6.77107945e-02f, -2.77692191e-02f, -1.98238883e-02f, 8.64841640e-02f, 8.94834399e-02f,
  7.06602857e-02f, -2.87759434e-02f, -2.40371488e-02f, 4.59161252e-02f, -1.15659162e-01f, 4.32644859e-02f, 1.22552276e-01f, 9.11544785e-02f, -1.25743933e-02f, 8.17417800e-02f,
  5.10052405e-02f, -1.14758648e-01f, 1.40739962e-01f, 6.30056262e-02f, 2.58163344e-02f, 7.96518996e-02f, 2.94423886e-02f, -5.41610457e-02f, 1.21153230e-02f, -5.28999157e-02f,
  -5.47978766e-02f, 3.50278877e-02f, 2.76941992e-02f, 3.24114263e-02f, 5.40890906e-04f, 1.38776721e-02f, 3.34271863e-02f, -1.95348281e-02f, -3.66243087e-02f, -2.51658726e-02f,
  -2.20207460e-02f, -1.79159820e-01f, -6.60702139e-02f, -8.60177055e-02f, -1.35689855e-01f, -6.38546869e-02f, -3.13126948e-03f, -2.34528854e-02f, -8.35126042e-02f, -1.51973404e-02f,
  9.34918448e-02f, -2.86490824e-02f, 1.02838837e-02f, 1.23247914e-01f, -4.09003422e-02f, 7.68470094e-02f, -1.77273471e-02f, -2.49919575e-02f, 1.09387882e-01f, -6.42005503e-02f,
  5.53593151e-02f, 8.04693550e-02f, -1.48904382e-03f, 2.58347280e-02f, 6.78470079e-03f, 5.27285933e-02f, -3.88759933e-03f, 5.34513919e-03f, 2.08804794e-02f, 1.11278117e-01f,
  -5.74204385e-01f, 1.07723713e-01f, 9.43104096e-04f, -4.74603027e-02f, -8.00681636e-02f, -2.59642392e-01f, -2.12065414e-01f, 7.09852651e-02f, -1.29931390e-01f, 1.44278362e-01f,
  -1.23380356e-01f, -7.18866810e-02f, 1.04842141e-01f, 1.12841137e-01f, -1.65913254e-01f, 1.10369653e-01f, -1.27455562e-01f, -7.83476308e-02f, -4.50427569e-02f, -2.37132534e-01f,
  -1.34970456e-01f, 5.95945418e-02f, 9.66332182e-02f, 1.53482944e-01f, -9.53617021e-02f, -1.13272807e-02f, 2.04908341e-01f, 4.69452478e-02f, 9.02463123e-02f, 3.70396152e-02f,
  -2.16460124e-01f, -1.49451895e-02f, -1.25191025e-02f, 2.06868118e-03f, -1.15798727e-01f, -8.94927531e-02f, -1.21267095e-01f, -3.83827239e-02f, -8.11660737e-02f, 1.90416891e-02f,
  -8.47920924e-02f, 7.73384236e-03f, 2.00990159e-02f, 4.26755771e-02f, 2.90334355e-02f, 6.33615181e-02f, -1.80290546e-02f, -6.73811138e-02f, 4.57800180e-02f, 9.53826979e-02f,
  7.26341680e-02f, 7.44433403e-02f, 3.02610993e-02f, 9.87280533e-02f, 4.59929667e-02f, 6.93673640e-02f, 8.79501700e-02f, -4.72161174e-02f, -1.85274407e-02f, 7.24737644e-02f,
  2.93970499e-02f, 3.25977653e-02f, -2.30346676e-02f, 7.25176651e-03f, -5.11746220e-02f, 1.06218387e-03f, 4.42533046e-02f, 2.48052906e-02f, 4.41418439e-02f, -2.25079730e-02f,
  -5.84809948e-03f, -5.55545650e-02f, 6.47618994e-02f, 3.35965455e-02f, -6.43504877e-03f, 6.91035613e-02f, -9.22141597e-02f, -4.60517630e-02f, -6.45754114e-02f, -3.85892279e-02f,
  -1.13716964e-02f, -1.92534905e-02f, 8.65875836e-03f, 7.56879449e-02f, -4.17975895e-02f, 5.06477691e-02f, 7.90970698e-02f, -5.35636358e-02f, -7.96421468e-02f, -5.29220216e-02f,
  -1.62044913e-01f, -7.01861009e-02f, -1.21989232e-02f, -6.32073730e-02f, -5.09829186e-02f, -1.63718238e-02f, -1.15119573e-02f, -3.72481085e-02f, -9.11602303e-02f, 3.96170281e-02f,
  -7.65428543e-02f, 4.44654338e-02f, -1.17441174e-02f, -7.12962821e-02f, 1.92338843e-02f, 6.29915893e-02f, -7.18921423e-02f, -1.50498807e-01f, -1.45075228e-02f, -1.97873288e-03f,
  1.72219537e-02f, -3.35632153e-02f, 1.25008836e-01f, -6.78404421e-03f, -2.07945984e-02f, 3.94916534e-02f, -1.00988097e-01f, 7.76385069e-02f, 6.34480193e-02f, 6.26546144e-02f,
  -4.31704611e-01f, 2.70102233e-01f, 1.65239438e-01f, -9.78345498e-02f, -7.87062794e-02f, -1.43832430e-01f, 2.99291406e-02f, 3.44104283e-02f, -2.17877701e-01f, 1.89620167e-01f,
  1.49085686e-01f, -1.62455842e-01f, 1.31750926e-01f, 1.02910347e-01f, -5.03329575e-05f, 2.21136302e-01f, -5.94067909e-02f, -1.43154576e-01f, -1.10181712e-01f, 2.79848948e-02f,
  -4.50888416e-03f, 6.59583881e-02f, 2.80823916e-01f, 1.83472577e-02f, -7.89122377e-03f, 5.00032306e-03f, 2.15881437e-01f, 1.44041469e-02f, -8.62641633e-02f, -7.45784864e-02f,
  6.77164495e-02f, 2.84600747e-03f, 2.77285036e-02f, 4.06237915e-02f, 1.94216911e-02f, -4.29432094e-02f, -2.27714144e-03f, -5.79436012e-02f, -3.45353670e-02f, -5.60400859e-02f,
  -6.01444282e-02f, -2.49394868e-02f, -2.40938626e-02f, -3.98842581e-02f, -1.40556008e-01f, -7.00184926e-02f, -4.41781394e-02f, -8.70919728e-04f, -6.84900284e-02f, -5.22004329e-02f,
  5.09073352e-03f, 5.15015610e-03f, -1.07125744e-01f, -2.23544277e-02f, -7.89038911e-02f, -2.07752921e-02f, -1.92931760e-02f, -1.19895162e-02f, -4.62670773e-02f, -7.44819716e-02f,
  -6.37651682e-02f, -5.00237383e-02f, -4.04586755e-02f, 2.66003199e-02f, -7.24318530e-03f, 3.73641476e-02f, -8.28859955e-02f, 1.53034758e-02f, -2.89492756e-02f, -4.46600281e-02f,
  6.37101615e-03f, -9.57982466e-02f, -3.93112190e-02f, -6.51987940e-02f, -9.92961973e-02f, 5.52117601e-02f, 8.42931774e-03f, 8.87542218e-03f, -8.61974061e-02f, 4.53719199e-02f,
  -1.17262946e-02f, 4.25503440e-02f, 7.68319592e-02f, -2.04131957e-02f, 1.62516087e-02f, -5.14329970e-02f, -7.62657523e-02f, 1.52771855e-02f, 1.92273557e-01f, -6.97775111e-02f,
  1.07152555e-02f, 1.28409266e-01f, 4.71078269e-02f, 2.92956270e-03f, 1.12131508e-02f, -1.03598274e-02f, -2.93599647e-02f, -1.10504642e-01f, -6.81278333e-02f, 3.07468977e-02f,
  -1.07392281e-01f, -6.36644801e-03f, 3.52335423e-02f, -2.66023781e-02f, -1.89726911e-02f, 1.36060953e-01f, 4.83404696e-02f, 1.09349340e-02f, 2.61545368e-02f, -3.98216359e-02f,
  3.10834143e-02f, -6.74115866e-02f, -8.19765851e-02f, -8.63089859e-02f, -1.15144230e-01f, -9.71428398e-03f, -4.80039343e-02f, -3.61442082e-02f, 6.69297902e-03f, -3.45160626e-02f,
  -3.73666398e-02f, 2.77039200e-01f, -1.73186034e-01f, -4.47092950e-02f, 2.35502586e-01f, 8.64830986e-02f, -1.23588219e-01f, 2.18470901e-01f, 6.26198053e-02f, 3.07246864e-01f,
  3.06208711e-02f, 1.80155244e-02f, -3.38082351e-02f, 6.03137352e-02f, -1.46701718e-02f, -1.31106749e-01f, 7.28121772e-02f, -6.41809851e-02f, -3.60833816e-02f, 6.72084019e-02f,
  -1.42760528e-02f, 1.55147433e-01f, -2.17136323e-01f, 2.71935493e-01f, 3.01339291e-02f, -1.08662575e-01f, 2.50137895e-01f, -1.87693574e-02f, 5.35376258e-02f, 7.59027153e-02f,
  -1.18386678e-01f, -3.44941989e-02f, -5.92386201e-02f, -1.03463739e-01f, -1.83568913e-02f, -2.75017601e-02f, -9.50384364e-02f, -7.84039274e-02f, -1.34617209e-01f, 2.48792078e-02f,
  6.73607886e-02f, -4.62475121e-02f, -1.91629436e-02f, -4.38751057e-02f, 7.17733949e-02f, 2.08624583e-02f, -5.08141965e-02f, -3.80165987e-02f, 4.43883874e-02f, 2.62803435e-02f,
  7.37166591e-03f, 1.04588307e-02f, 3.05990074e-02f, 5.56578152e-02f, 8.81083533e-02f, 1.85706727e-02f, -3.20671611e-02f, 7.85122812e-02f, 1.01619817e-01f, 1.31725043e-01f,
  -6.27693208e-03f, 8.02046731e-02f, 1.84463151e-02f, -9.47729722e-02f, -3.86102013e-02f, -6.61540031e-02f, 5.01600616e-02f, 3.09321489e-02f, 4.44433428e-02f, 8.48421827e-02f,
  -4.17498499e-02f, -7.63526559e-03f, 2.83387247e-02f, 3.13999243e-02f, 1.42343178e-01f, 5.51547157e-03f, 9.13228933e-03f, 6.21701963e-02f, 3.44702825e-02f, -5.25585897e-02f,
  -4.81203236e-02f, -6.25603646e-03f, 2.21263077e-02f, 3.33702639e-02f, -1.45467922e-01f, 3.97220924e-02f, 9.49075297e-02f, -5.21959886e-02f, -1.33605123e-01f, 2.40580551e-02f,
  2.46211112e-01f, 2.02223271e-01f, -5.20374887e-02f, -6.57369196e-02f, -8.31016675e-02f, -9.82442754e-04f, -4.91964296e-02f, 1.38670643e-04f, 5.97391417e-03f, 6.91697001e-02f,
  1.24637246e-01f, -1.03797555e-01f, -7.68056931e-03f, -8.62895232e-03f, 2.89570261e-02f, 7.71628022e-02f, 3.75446752e-02f, 2.95868069e-02f, 1.45533562e-01f, 1.98373705e-01f,
  8.96658301e-02f, 3.54149267e-02f, 6.10366557e-03f, 3.17495540e-02f, 5.94821237e-02f, 8.96195844e-02f, 4.43599559e-02f, 5.50152548e-02f, 7.83394724e-02f, 7.01734424e-02f,
  2.78867275e-01f, -3.35739225e-01f, -1.04802132e-01f, 3.25412214e-01f, -4.92183156e-02f, -3.47624533e-02f, 2.77751267e-01f, -1.51313871e-01f, 3.21925610e-01f, -1.33593976e-02f,
  3.51151749e-02f, 1.61377460e-01f, -5.29490830e-03f, 6.13712333e-02f, 2.26591095e-01f, 1.62942454e-01f, 1.13188669e-01f, 1.52231902e-01f, 2.95538101e-02f, -1.01216972e-01f,
  8.81209299e-02f, -9.77636129e-03f, -1.32546946e-01f, -2.61512786e-01f, -5.42306416e-02f, -1.63490146e-01f, -9.15341005e-02f, -5.17626517e-02f, -1.51556879e-01f, 5.93235418e-02f,
  -9.57811251e-02f, -5.70608899e-02f, -2.48322301e-02f, -3.40568982e-02f, -6.24884814e-02f, -6.70227855e-02f, -3.12933624e-02f, 2.58017778e-02f, -1.12772025e-02f, 1.11074448e-01f,
  3.07557546e-02f, 3.93077210e-02f, 7.22871721e-03f, 6.10975400e-02f, 2.97464784e-02f, 6.83730170e-02f, -3.24032828e-03f, 3.05991452e-02f, -3.28286216e-02f, 4.96732481e-02f,
  1.02148451e-01f, 3.78946029e-02f, 3.19791101e-02f, 8.05879533e-02f, 6.55712634e-02f, 6.86447099e-02f, 4.06375863e-02f, 6.43645972e-02f, 4.59318459e-02f, 1.16817251e-01f,
  5.49105108e-02f, -4.33985181e-02f, -1.03563303e-02f, -5.12439534e-02f, -3.13709714e-02f, -3.16612013e-02f, 1.42784016e-02f, -1.46790873e-02f, 8.28061551e-02f, -2.67925914e-02f,
  -5.02046682e-02f, -1.60641242e-02f, -8.13507885e-02f, 5.49551770e-02f, 5.06446473e-02f, 3.07225399e-02f, -3.30946706e-02f, -3.64312530e-02f, 9.25593749e-02f, -1.26640191e-02f,
  6.32926375e-02f, -2.97154707e-04f, -7.57246278e-03f, 3.27704251e-02f, 1.96454953e-03f, 6.91722408e-02f, -7.61550814e-02f, -7.94562772e-02f, -1.21877432e-01f, -3.49564478e-02f,
  -1.36055872e-01f, -2.44209155e-01f, -1.91687010e-02f, -1.01226524e-01f, -8.66452754e-02f, -2.16805539e-03f, 4.22450947e-03f, -5.22411987e-02f, -8.57127607e-02f, 3.66970710e-02f,
  -4.32916246e-02f, -2.97575872e-02f, -9.18115824e-02f, 7.20084831e-02f, 4.62312400e-02f, -2.51816995e-02f, -2.89280489e-02f, 1.40891653e-02f, 7.73758069e-02f, -5.61262444e-02f,
  -5.17243594e-02f, 1.07255049e-01f, 6.22667782e-02f, 4.39821370e-03f, -4.76215445e-02f, 8.59384146e-03f, -8.68222043e-02f, 5.85674755e-02f, 7.90622756e-02f, 9.29763764e-02f,
  2.14392036e-01f, -5.19258790e-02f, -6.18851520e-02f, 1.42723962e-03f, -1.04300231e-01f, 2.26243079e-01f, 3.34689409e-01f, -1.25001132e-01f, 7.09144026e-02f, -4.02288511e-02f,
  2.83510275e-02f, -1.51915058e-01f, 1.89520136e-01f, 1.33380935e-01f, 1.99059501e-01f, 1.89386621e-01f, 2.06835330e-01f, 1.33908257e-01f, -5.99631220e-02f, 9.01132636e-03f,
  3.74450572e-02f, 8.65260884e-02f, 4.87880819e-02f, -1.47825420e-01f, 1.32708540e-02f, -2.52897620e-01f, -1.66500941e-01f, -1.03235975e-01f, -1.84743002e-01f, -7.19443858e-02f,
  6.48285523e-02f, -4.01384104e-03f, -1.78825147e-02f, 2.67230570e-02f, 4.24342938e-02f, -6.87522963e-02f, -1.88332926e-02f, -2.96170395e-02f, -3.08676511e-02f, 7.35945255e-02f,
  -7.38288322e-03f, -8.01792070e-02f, -5.57985008e-02f, -8.37116167e-02f, 1.63899938e-04f, -5.33748381e-02f, -1.37063973e-02f, 1.96229815e-02f, 1.24628050e-03f, 7.95366764e-02f,
  6.78339303e-02f, 9.81932785e-03f, 8.15615803e-02f, -5.36527447e-02f, -3.51477340e-02f, 1.52797857e-02f, 2.55527459e-02f, -3.68406586e-02f, 4.95468788e-02f, 1.24560939e-02f,
  -8.87864176e-03f, 1.07664712e-01f, 1.37178659e-01f, 4.31734025e-02f, 2.91897282e-02f, 1.36179021e-02f, 5.00095561e-02f, 8.77240747e-02f, -8.69367048e-02f, 4.75553758e-02f,
  -2.20127907e-02f, 1.16578983e-02f, 2.25266605e-03f, -3.70941274e-02f, 1.89948606e-03f, 8.83978903e-02f, 1.65937264e-02f, -6.10348247e-02f, 7.39836991e-02f, -4.06204686e-02f,
  -1.73908807e-02f, 1.36120254e-02f, 9.34284832e-03f, 2.16519255e-02f, 1.74659640e-01f, -1.19409235e-02f, -8.76229350e-03f, -7.33497292e-02f, -3.29553895e-02f, -1.54709602e-02f,
  -6.00681873e-03f, -8.89729261e-02f, -1.58768650e-02f, -1.27774864e-01f, -6.74799234e-02f, -8.28037784e-02f, -4.63947579e-02f, -7.19300658e-02f, -2.82068402e-02f, -1.91432331e-02f,
  -3.53778563e-02f, -5.34351170e-03f, -1.19632974e-01f, -9.01884341e-04f, -5.64916953e-02f, 7.17709661e-02f, -5.05237421e-03f, -8.44930857e-02f, -1.99752301e-02f, -4.56500612e-02f,
  -5.14841266e-02f, 3.14796828e-02f, 3.32981311e-02f, 5.28880507e-02f, -9.61101726e-02f, 2.19358684e-04f, -4.27047350e-02f, 1.07475771e-02f, -9.48655698e-03f, -5.59261441e-02f,
  -7.49186873e-02f, -4.46963936e-01f, -1.45499438e-01f, 1.03221893e-01f, 1.27361968e-01f, 7.86301941e-02f, -1.59472134e-02f, -1.00406937e-01f, 1.07346252e-01f, -1.28452986e-01f,
  -4.64084521e-02f, 4.02245112e-02f, -8.75749215e-02f, -3.88423689e-02f, 1.00106537e-01f, -5.22671230e-02f, -7.75805712e-02f, 4.72239451e-03f, -6.43948372e-03f, -2.68831998e-01f,
  -1.55196905e-01f, -1.28763884e-01f, -9.46314186e-02f, -7.16949552e-02f, -1.90685123e-01f, -6.51042312e-02f, 1.33769557e-01f, -1.99940875e-02f, 1.29711121e-01f, 1.03659190e-01f,
  -1.46620631e-01f, -1.63350537e-01f, -1.95223123e-01f, -1.04545578e-01f, -1.46728233e-01f, -5.98702021e-02f, -6.59677610e-02f, -9.67725590e-02f, 1.16174243e-01f, 1.21557757e-01f,
  9.75332037e-02f, 7.52641559e-02f, 6.66752681e-02f, 7.72810951e-02f, 1.03094831e-01f, 1.38910800e-01f, 1.08671479e-01f, 1.90534703e-02f, 7.84322768e-02f, -2.73390505e-02f,
  2.37086453e-02f, 1.44164255e-02f, 1.30732626e-01f, 1.48180366e-01f, 1.18547119e-01f, 7.66408220e-02f, -7.48596638e-02f, 5.99654578e-02f, 1.14655517e-01f, 9.81706306e-02f,
  -1.83278825e-02f, 3.09061408e-02f, -7.29003772e-02f, -5.43991402e-02f, 6.59147575e-02f, 8.48086998e-02f, 4.01234105e-02f, 2.56307293e-02f, 4.51057069e-02f, 3.01518720e-02f,
  1.22817449e-01f, -7.16897920e-02f, 4.60375100e-02f, 3.02329883e-02f, 3.40400003e-02f, -7.77643919e-02f, 7.16852322e-02f, -3.44727971e-02f, 3.55165277e-04f, -2.99598947e-02f,
  6.19529560e-02f, 5.05578844e-03f, 5.72868204e-03f, 3.03395391e-02f, -5.18522300e-02f, 8.16763565e-02f, -1.79192051e-02f, -2.37083193e-02f, 8.70377123e-02f, -1.40761277e-02f,
  -1.98654637e-01f, -1.85293987e-01f, -9.75017920e-02f, -1.19653203e-01f, -7.75399283e-02f, -1.47061288e-01f, -1.17339969e-01f, -9.38777626e-02f, 8.45378917e-03f, 3.02189775e-03f,
  -5.19982763e-02f, -3.48757654e-02f, 6.56348690e-02f, -2.88299415e-02f, 1.02079153e-01f, -7.87653401e-03f, 5.73968552e-02f, 6.31445199e-02f, 9.37928706e-02f, -3.11744101e-02f,
  1.06716789e-01f, 1.34173542e-01f, 1.48312062e-01f, 6.07736297e-02f, 3.38831060e-02f, 5.65892011e-02f, -3.14287506e-02f, 5.63278198e-02f, 9.66289416e-02f, 1.35133415e-01f,
  -2.31958538e-01f, 3.07206780e-01f, -3.98347825e-01f, -1.96748421e-01f, -2.01105028e-02f, 1.73120961e-01f, -3.88761945e-02f, 5.27208038e-02f, -6.20501377e-02f, 2.61900395e-01f,
  1.20631322e-01f, -1.05957411e-01f, -1.45070612e-01f, 2.75758564e-01f, -1.29820794e-01f, -4.67394367e-02f, 2.60583758e-01f, 1.71748504e-01f, -1.14923427e-02f, 1.35680541e-01f,
  -1.30648777e-01f, 2.20734939e-01f, -7.53525048e-02f, 1.45557106e-01f, 1.60468593e-02f, -3.47605906e-02f, -6.33023307e-02f, -1.96213841e-01f, 1.76764190e-01f, -6.06611110e-02f,
  9.09159482e-02f, -3.08580622e-02f, 6.59066737e-02f, 1.67038795e-02f, 3.85750309e-02f, 3.66133600e-02f, 8.08555633e-02f, -2.18900349e-02f, 8.07708874e-03f, -3.80841792e-02f,
  -7.17112571e-02f, -1.07041532e-02f, 1.82008778e-03f, 3.09763737e-02f, -6.42557815e-02f, -1.01062022e-02f, -8.85723084e-02f, 7.19529297e-03f, 5.79828918e-02f, -1.60170004e-01f,
  -1.58481762e-01f, -8.47819448e-02f, -8.08923468e-02f, -6.70982711e-03f, -8.05452168e-02f, -5.97838871e-02f, -4.22188826e-02f, -8.75038356e-02f, 3.84334363e-02f, 2.26640273e-02f,
  -1.24894962e-01f, -1.25854053e-02f, 2.93893963e-02f, 9.49485786e-03f, 3.52095813e-02f, -4.57091257e-02f, 3.31778601e-02f, 2.51991544e-02f, -8.37681070e-02f, -4.66296487e-02f,
  4.74881157e-02f, 5.34406938e-02f, 3.93895246e-02f, -4.87805046e-02f, 9.08291247e-03f, 7.43872765e-03f, -1.09714950e-02f, 6.18481338e-02f, -4.52747419e-02f, 5.40746339e-02f,
  -3.21188346e-02f, 1.32759418e-02f, 6.49787858e-02f, -2.91901026e-02f, 5.10080643e-02f, -8.87472555e-02f, 3.02813873e-02f, 6.97098598e-02f, 8.87076184e-02f, 5.05167916e-02f,
  2.33006001e-01f, 2.16550857e-01f, 6.35126308e-02f, 1.17829956e-01f, 1.08265243e-01f, 2.34170184e-02f, 9.35600698e-02f, 1.00615196e-01f, 8.32702070e-02f, 2.07934398e-02f,
  -3.49714532e-02f, 2.83507071e-02f, -6.59951717e-02f, 4.04779129e-02f, -1.56091887e-03f, -1.77031793e-02f, -4.57090437e-02f, 1.55141264e-01f, 3.50474901e-02f, 1.59099959e-02f,
  -2.36552134e-02f, -3.91052514e-02f, -3.42057645e-02f, 8.63162652e-02f, 6.78049549e-02f, -9.90653858e-02f, 9.90392193e-02f, -1.48069561e-01f, -1.19805798e-01f, 1.46601861e-02f,
  -5.23045719e-01f, -6.22318611e-02f, -1.00153491e-01f, -1.04333676e-01f, -2.00996399e-01f, -3.67719889e-01f, -2.13358507e-01f, -4.12114188e-02f, -1.73297822e-01f, 1.30603775e-01f,
  3.90965827e-02f, -1.20073743e-01f, 1.50085092e-01f, -1.17113166e-01f, -2.34809071e-01f, 1.85674429e-01f, -2.11790562e-01f, -7.35667124e-02f, -6.83191419e-02f, -6.58826679e-02f,
  -2.07400367e-01f, -1.14904307e-01f, 2.14465577e-02f, 1.68193150e-02f, -2.49007404e-01f, -6.22320399e-02f, 3.89781177e-01f, 9.63303540e-03f, 6.39164150e-02f, -9.75658670e-02f,
  -1.70430377e-01f, -1.79891754e-02f, 2.53657643e-02f, -9.86942500e-02f, 3.67494784e-02f, -3.00774034e-02f, 1.35794701e-02f, -5.94106279e-02f, 3.10808374e-03f, 2.31541991e-02f,
  -3.32409590e-02f, -5.83170056e-02f, -4.47338857e-02f, -2.80507058e-02f, -1.74723595e-01f, -4.30428423e-03f, -1.23237371e-01f, -1.64160226e-02f, 4.39326104e-04f, -2.25603282e-02f,
  -5.62947243e-02f, -4.15958129e-02f, 6.12250948e-03f, 9.71648246e-02f, -6.38502743e-03f, -5.49239255e-02f, -6.90322891e-02f, 1.04761543e-02f, 3.09143937e-03f, 2.79669464e-02f,
  4.55811098e-02f, 2.17224620e-02f, 1.71260871e-02f, -3.96070331e-02f, -7.77526125e-02f, 2.92988867e-02f, 3.44964080e-02f, -5.06929383e-02f, 2.05301936e-03f, 1.10168261e-02f,
  -2.65128519e-02f, 3.38093117e-02f, -1.59034561e-02f, -6.03664592e-02f, 1.93729661e-02f, 4.89365384e-02f, 3.43524874e-03f, 7.96287283e-02f, -1.38354540e-01f, 9.05659124e-02f,
  5.80830164e-02f, -1.01592839e-01f, 2.83583906e-02f, -1.26758628e-02f, -6.96102669e-03f, -3.67491730e-02f, 3.20285298e-02f, -1.46080030e-03f, 5.64680770e-02f, 8.49829987e-03f,
  5.15530221e-02f, 2.27437049e-01f, 1.99694000e-02f, -9.04981345e-02f, 4.16951142e-02f, -3.47900875e-02f, -6.93475753e-02f, -3.13976519e-02f, 4.28019688e-02f, 5.31702414e-02f,
  -5.77489771e-02f, 1.97057948e-02f, 8.28614552e-03f, 1.41483312e-02f, -3.07971588e-03f, 9.80817303e-02f, -1.03872372e-02f, 6.00019284e-02f, -2.49075238e-02f, 8.35525617e-02f,
  2.64263470e-02f, -7.26102144e-02f, 1.93907339e-02f, -3.11931502e-02f, 3.20839956e-02f, -1.37575407e-04f, 1.77511089e-02f, -9.00934264e-02f, 3.41897458e-02f, 4.20130976e-02f,
  1.23244002e-01f, 3.11714485e-02f, 2.47291967e-01f, 1.23294644e-01f, -1.46670982e-01f, -2.46598020e-01f, -2.28041038e-03f, -1.05272010e-01f, 1.16861604e-01f, -2.51612455e-01f,
  -8.68118107e-02f, 1.89244792e-01f, 4.58770841e-02f, -2.10805029e-01f, 4.35087383e-02f, 1.29185930e-01f, -2.31592461e-01f, -6.56883940e-02f, 1.88094258e-01f, -7.58481920e-02f,
  1.33737922e-01f, -3.10793400e-01f, 1.05762891e-01f, -2.83803850e-01f, -7.25820214e-02f, 1.99689642e-01f, -2.36586496e-01f, 1.36528254e-01f, -1.90050945e-01f, 3.34631465e-03f,
  -1.26362607e-01f, 1.00269847e-01f, 6.09573238e-02f, 2.97576692e-02f, -9.32115540e-02f, 1.41003346e-02f, 3.83129297e-03f, 9.73973125e-02f, 7.51165375e-02f, 1.73060875e-02f,
  -2.43773870e-02f, 2.54534110e-02f, -5.72937587e-03f, 3.61906476e-02f, 2.40913779e-02f, 1.23784319e-02f, 6.42840713e-02f, -9.71855130e-03f, -7.39426464e-02f, 6.76942021e-02f,
  8.19275230e-02f, 6.17633574e-02f, 4.45146486e-03f, -5.89207709e-02f, 5.50866351e-02f, -2.73858733e-03f, 8.56598541e-02f, 6.66863695e-02f, -3.62877734e-02f, -1.00188747e-01f,
  5.61536178e-02f, -8.70989859e-02f, -1.38386339e-01f, -2.58910917e-02f, 3.55868489e-02f, -2.69539226e-02f, -1.33624896e-01f, -6.74688071e-02f, 6.53034961e-03f, -1.26227632e-01f,
  -5.36458194e-02f, -4.00448442e-02f, -4.35377238e-03f, -1.01762898e-02f, -1.15492970e-01f, -8.53628293e-02f, -8.07695836e-02f, -1.18366918e-02f, -5.08097671e-02f, -6.42602518e-02f,
  9.89880878e-03f, 3.66778811e-03f, -6.74076229e-02f, -9.30663720e-02f, 3.23628485e-02f, 1.01027153e-01f, -2.94845607e-02f, 6.59734979e-02f, 3.17539610e-02f, -2.73485854e-03f,
  -3.44764113e-01f, -2.77622998e-01f, -3.28317657e-02f, 2.46435916e-03f, -4.36007343e-02f, 4.23267633e-02f, 9.18855704e-03f, -3.67607102e-02f, 2.91378070e-02f, -5.44043593e-02f,
  -5.22910953e-02f, -6.55465424e-02f, 3.63766216e-02f, -3.45591009e-02f, -4.08510156e-02f, -1.39761910e-01f, 1.96398534e-02f, -4.27001864e-02f, -1.41908526e-01f, -1.40398860e-01f,
  -1.05831139e-01f, -2.74212826e-02f, -1.71606261e-02f, -9.90220010e-02f, -4.04253379e-02f, -5.39907888e-02f, 2.10641157e-02f, 9.32065099e-02f, -8.62126946e-02f, -9.11806375e-02f,
  3.81999880e-01f, -1.10704258e-01f, 1.27566643e-02f, 7.82208145e-02f, 1.03638001e-01f, -9.77804810e-02f, 4.87840883e-02f, -1.41870052e-01f, -1.35613251e-02f, -2.19304845e-01f,
  -1.24320447e-01f, -2.37870384e-02f, -1.84632123e-01f, -1.92460224e-01f, 4.97311130e-02f, -3.09388638e-01f, 1.58073783e-01f, -2.64311377e-02f, -1.23180903e-01f, 1.83996320e-01f,
  4.42436934e-02f, 9.30020213e-02f, -9.35786590e-02f, -1.17773293e-02f, 1.41873777e-01f, 1.06154732e-01f, 1.96426824e-01f, 2.60261744e-02f, 1.42007113e-01f, 7.42802843e-02f,
  -2.23191269e-02f, -7.07193762e-02f, 4.25764099e-02f, 5.04838265e-02f, 1.48942336e-01f, 8.34229290e-02f, 7.96125606e-02f, 4.53244783e-02f, -6.54158816e-02f, -6.04710467e-02f,
  8.44108686e-03f, -5.26806787e-02f, -1.11398278e-02f, 2.92138336e-03f, 3.74731161e-02f, -1.56522058e-02f, -6.03357144e-02f, -9.99408290e-02f, -7.03629330e-02f, -5.60964160e-02f,
  -3.80102880e-02f, -9.68151018e-02f, 7.33569935e-02f, -1.96359549e-02f, 8.40468854e-02f, -2.77915262e-02f, 1.24655366e-01f, 7.46212825e-02f, 8.46712366e-02f, 5.99227101e-02f,
  -5.29778525e-02f, 1.80057615e-01f, 7.54901096e-02f, 4.45977487e-02f, 8.41033682e-02f, 3.95226181e-02f, 8.27151909e-02f, 4.64044139e-03f, 5.43436408e-02f, 1.12085290e-01f,
  7.13977814e-02f, 8.52779150e-02f, 3.85173671e-02f, 3.44619974e-02f, 7.05344081e-02f, -1.45976897e-02f, 1.10810837e-02f, 1.09809088e-02f, 8.06584656e-02f, -4.82883081e-02f,
  -3.26746441e-02f, 4.26387191e-02f, -9.92774218e-02f, 8.66724737e-03f, 2.93233562e-02f, 3.33764404e-02f, 1.50922537e-02f, -2.28167679e-02f, -1.85584873e-02f, 9.12611112e-02f,
  9.39661339e-02f, 2.45641887e-01f, 5.91976717e-02f, 9.23071336e-03f, 4.85920310e-02f, 2.11224309e-03f, -7.11314799e-03f, 4.93597873e-02f, 8.94319906e-04f, -9.23214033e-02f,
  5.23717143e-02f, 8.44873935e-02f, 5.69616742e-02f, 7.95979649e-02f, 2.83115562e-02f, 5.33155119e-03f, 3.60381901e-02f, 4.79397587e-02f, 1.20873600e-01f, 7.71240667e-02f,
  3.13368663e-02f, 4.33295742e-02f, 3.17850336e-02f, 6.93990886e-02f, 5.05664945e-02f, 7.48348087e-02f, 7.39165470e-02f, -2.18626205e-02f, 4.35483493e-02f, -5.80004975e-02f,
  3.12535107e-01f, -2.54231185e-01f, 1.69563666e-01f, 5.03118813e-01f, -8.07460025e-02f, -1.74899042e-01f, 1.75446849e-02f, -7.31771737e-02f, 1.62421420e-01f, -2.41403043e-01f,
  -1.35963365e-01f, 2.12463036e-01f, -1.88767567e-01f, 3.39103565e-02f, 3.22341472e-01f, -8.74197669e-03f, -4.00421694e-02f, 2.03092266e-02f, 1.15260676e-01f, -5.51605336e-02f,
  -1.38682589e-01f, -4.82604988e-02f, 2.67954217e-03f, 3.66382813e-03f, -2.16592737e-02f, 1.10542566e-01f, 4.39383090e-02f, 5.71519583e-02f, 8.41015279e-02f, 1.03507824e-01f,
  -1.28399655e-01f, 1.46597862e-01f, -3.40157598e-02f, -2.04033852e-02f, -4.59869299e-03f, -1.06598914e-01f, -1.69889927e-02f, -1.34883942e-02f, 6.45806491e-02f, 9.82856005e-02f,
  -6.98881969e-02f, -9.66991112e-02f, 3.36170048e-02f, 1.20516874e-01f, -3.64562906e-02f, 1.13926597e-01f, 2.23052539e-02f, -8.46093297e-02f, 4.64193970e-02f, 9.10495520e-02f,
  4.95419092e-02f, -6.68220222e-02f, 7.86951259e-02f, 5.20509593e-02f, 9.81486440e-02f, 5.60875125e-02f, 6.45078793e-02f, 2.38993932e-02f, 7.05000758e-02f, 1.85763940e-01f,
  -1.33756548e-01f, 4.50906530e-02f, 1.12007543e-01f, 6.78936094e-02f, 1.00218557e-01f, 3.44373919e-02f, 1.59095094e-01f, -6.13402855e-03f, 1.86537132e-01f, 2.96504553e-02f,
  -4.15552687e-03f, 7.53632411e-02f, -8.14995263e-03f, 9.92130265e-02f, 8.53942782e-02f, 3.32432613e-02f, 4.10995148e-02f, 8.20955038e-02f, 9.61553492e-03f, -1.63042489e-02f,
  -2.54962873e-02f, -6.48811311e-02f, -2.68800072e-02f, -8.19376186e-02f, -7.80046880e-02f, -4.29921737e-03f, -3.54336090e-02f, 4.21622880e-02f, -9.02302191e-02f, 5.70494644e-02f,
  -1.51937783e-01f, 1.12100706e-01f, -9.01405215e-02f, -4.48435955e-02f, 1.36276530e-02f, -7.48866200e-02f, 7.44284550e-03f, -8.33995715e-02f, 5.80525398e-02f, -2.96284761e-02f,
  -7.39626295e-04f, -2.85008010e-02f, 2.50233598e-02f, -3.28164622e-02f, 8.52272206e-04f, -1.22698611e-02f, -2.24780235e-02f, -7.03717843e-02f, 6.70287013e-02f, -4.21870127e-02f,
  -8.14253017e-02f, -5.52744269e-02f, 7.04675494e-03f, -4.89531085e-02f, -1.38375208e-01f, -5.27632702e-03f, 2.17319801e-02f, -2.17904337e-03f, 1.52145475e-01f, 6.14765026e-02f,
  1.36905894e-01f, 6.71537034e-03f, 2.24568129e-01f, 1.16745848e-02f, -5.03433272e-02f, 2.08350718e-01f, 2.55508065e-01f, -5.86948870e-03f, 2.07537547e-01f, -5.88139817e-02f,
  -8.11139122e-03f, -1.09239481e-01f, 1.25358269e-01f, -1.70402497e-01f, 7.65101090e-02f, 1.49724692e-01f, -6.96763173e-02f, -7.16740564e-02f, -1.65921807e-01f, -7.51197785e-02f,
  -1.21578991e-01f, -3.12542588e-01f, -1.03858121e-01f, -2.56902575e-01f, -1.41152799e-01f, -5.04234284e-02f, -9.90800485e-02f, -5.18563017e-02f, -9.88016203e-02f, -1.29456952e-01f,
  8.89657438e-02f, -2.65932027e-02f, 3.94153930e-02f, 5.18918820e-02f, 1.93431042e-02f, 9.54835734e-04f, 6.25375435e-02f, -4.99213226e-02f, 4.25787177e-03f, -3.71037014e-02f,
  5.71866259e-02f, -1.01630367e-01f, -1.31720245e-01f, -3.06738559e-02f, 1.06100269e-01f, 4.42676507e-02f, -7.15475306e-02f, 6.39644265e-02f, 3.85370553e-02f, -5.91286691e-03f,
  1.75334178e-02f, 9.05705523e-03f, 1.12583719e-01f, 4.36588563e-02f, -7.55795743e-03f, -5.88663155e-03f, -4.44667088e-03f, -3.78160961e-02f, -2.77259573e-02f, 5.78816235e-03f,
  -7.71855265e-02f, 1.31030962e-01f, 4.48898524e-02f, 3.94099541e-02f, -4.73804921e-02f, 4.42766659e-02f, 2.05275461e-01f, -4.43270579e-02f, 3.18734795e-02f, 1.17385678e-01f,
  6.74851164e-02f, 1.26797818e-02f, 5.28876968e-02f, 1.02768019e-01f, 8.34982470e-03f, 1.03833698e-01f, 9.76838619e-02f, -9.20570642e-02f, -1.59119051e-02f, 3.40580977e-02f,
  1.19699933e-01f, 9.25581008e-02f, 3.28189433e-02f, 3.15346606e-02f, 1.13576293e-01f, 7.82897100e-02f, 5.73676825e-02f, 9.13715810e-02f, -3.77998175e-03f, -1.44568205e-01f,
  1.34710774e-01f, -1.69036854e-02f, -6.20078966e-02f, -2.58601643e-02f, -6.42871037e-02f, -1.24511562e-01f, -1.09101191e-01f, -7.38208368e-02f, 5.01068942e-02f, -3.47515345e-02f,
  -4.78414930e-02f, 3.69889289e-02f, 1.49449781e-01f, 2.57361811e-02f, 7.51496106e-02f, 7.88122490e-02f, 1.02743737e-01f, -6.62785023e-02f, 2.99971681e-02f, -2.02792324e-03f,
  -5.86133189e-02f, 3.05777113e-03f, -6.23819903e-02f, -1.20309092e-01f, -9.89168361e-02f, 6.40376881e-02f, -5.65126091e-02f, -9.91806388e-02f, -1.58491116e-02f, -1.04094157e-02f,
  1.60984531e-01f, -2.70836409e-02f, -1.17268432e-02f, 1.90562651e-01f, -1.21089049e-01f, 8.87578279e-02f, 2.54423618e-01f, -1.12687998e-01f, -9.78155732e-02f, 5.21012843e-02f,
  5.30263931e-02f, 1.04750656e-01f, 6.93471497e-03f, 2.62802511e-01f, 3.13782245e-01f, 8.39489698e-02f, 3.25027645e-01f, 1.79840088e-01f, -1.37310818e-01f, 8.93852413e-02f,
  3.44973095e-02f, 1.88948825e-01f, 1.37547731e-01f, -2.06642956e-01f, 2.79306434e-02f, -2.60184258e-01f, 1.50182500e-01f, -2.29866922e-01f, 3.09555065e-02f, 8.86479393e-03f,
  4.10344452e-02f, 7.47282505e-02f, -4.60119061e-02f, -1.30923232e-02f, 4.97068912e-02f, -1.64806545e-02f, 4.45175134e-02f, 6.04101131e-03f, -9.71251801e-02f, -4.54097241e-02f,
  4.54986095e-02f, 2.58834641e-02f, 4.65461798e-03f, -1.26729369e-01f, -1.20596420e-02f, -7.81942606e-02f, -1.59648911e-03f, 3.51428590e-03f, -4.03371044e-02f, 9.27547589e-02f,
  -3.00682932e-02f, 3.70319784e-02f, 1.06893934e-01f, 1.05788052e-01f, 3.09537165e-02f, 4.75404933e-02f, 8.10709372e-02f, 5.06332628e-02f, 3.01372483e-02f, 5.33088259e-02f,
  1.63844302e-02f, 1.36204809e-01f, 1.16882369e-01f, -3.36011723e-02f, -2.23495215e-02f, 6.14638589e-02f, -5.96903730e-03f, 3.66555564e-02f, -1.03151195e-01f, 1.09024607e-01f,
  -1.34276329e-02f, 2.56802868e-02f, 3.55946086e-02f, -3.13624591e-02f, 7.31780156e-02f, 5.51100560e-02f, 1.33707941e-01f, 1.18987191e-04f, -4.37824465e-02f, 1.22011945e-04f,
  5.78235872e-02f, 4.64448482e-02f, -2.52035279e-02f, 1.31176738e-02f, 1.38909258e-02f, -5.43371961e-02f, 2.93936487e-02f, 1.93015803e-02f, -3.67021002e-02f, 1.08811045e-02f,
  6.92822635e-02f, 1.72377855e-01f, -4.60784771e-02f, -3.51890102e-02f, -4.33478020e-02f, -9.01599079e-02f, 3.83776687e-02f, 7.48350145e-03f, -1.05052002e-01f, -5.09636030e-02f,
  9.17249471e-02f, 1.78258438e-02f, -2.57965457e-02f, 2.00832845e-03f, 2.42666006e-02f, 7.91234598e-02f, 3.79304439e-02f, -2.53662802e-02f, 1.11405715e-01f, 5.24601005e-02f,
  6.32986352e-02f, 6.67644013e-03f, -1.80137251e-02f, -6.94462983e-03f, 4.51636277e-02f, 4.78409417e-02f, 1.47276167e-02f, -2.47458871e-02f, 1.49032483e-02f, -1.48791112e-02f,
  -1.22365326e-01f, 4.41683292e-01f, 4.08126146e-01f, 3.78378034e-02f, -1.42718583e-01f, 1.76809058e-01f, 1.88367337e-01f, 7.13820159e-02f, -1.73748769e-02f, 7.50718489e-02f,
  -1.27342895e-01f, 1.58265904e-01f, 1.35915413e-01f, -5.06234579e-02f, -1.53021291e-01f, 5.70005290e-02f, 6.17289580e-02f, 3.94575037e-02f, 6.91800863e-02f, 1.82368249e-01f,
  -7.13275969e-02f, -2.50450373e-01f, 2.23818019e-01f, -8.82785991e-02f, 6.89969659e-02f, 1.24250025e-01f, -2.07364112e-01f, 6.73737079e-02f, -5.99570479e-03f, -6.29953519e-02f,
  4.81022568e-03f, -9.07286629e-02f, 9.07361060e-02f, 8.86927533e-04f, 5.95089421e-02f, 1.75138097e-02f, -6.13015750e-03f, 6.33267453e-03f, -2.89594084e-02f, 4.89156581e-02f,
  2.05979999e-02f, -1.29413456e-01f, -8.02034810e-02f, -8.77300203e-02f, -3.73212770e-02f, -3.34242247e-02f, 3.50492746e-02f, 1.09077677e-01f, 2.85737701e-02f, 2.68767104e-02f,
  9.15732160e-02f, 3.82351130e-02f, -3.97623749e-03f, -3.25954407e-02f, 3.41824181e-02f, -8.03090539e-03f, 1.79156773e-02f, 7.24767372e-02f, 4.59382422e-02f, -9.76364873e-03f,
  -1.34491324e-01f, -5.33787832e-02f, 3.61560881e-02f, -1.03358012e-02f, 4.04536575e-02f, 6.24145847e-03f, -5.69584183e-02f, 4.92587164e-02f, 7.24322796e-02f, -1.98459104e-02f,
  3.91452387e-02f, 5.94538711e-02f, -1.07358456e-01f, -3.46777588e-02f, 2.34568436e-02f, -5.20965233e-02f, 1.94006991e-02f, 5.59653081e-02f, -1.55583164e-02f, 4.40163128e-02f,
  -5.33328056e-02f, -5.19994460e-02f, -1.86329905e-03f, -5.22381999e-02f, -1.84076782e-02f, -3.44009809e-02f, -5.30807674e-02f, 9.77991428e-03f, 8.27096577e-04f, -1.09001424e-03f,
  5.69030130e-03f, 1.09459102e-01f, 1.73367858e-02f, -5.41752875e-02f, 2.73259301e-02f, 5.01311012e-02f, -7.64395818e-02f, -7.49587789e-02f, 5.50766438e-02f, 1.14013307e-01f,
  -2.01517269e-02f, -7.89187998e-02f, -8.31249915e-03f, -1.88324898e-01f, -4.15198356e-02f, -3.98822017e-02f, 6.52604625e-02f, -4.76754084e-02f, 7.38978665e-03f, -7.78274890e-03f,
  2.90092919e-02f, -1.58679858e-02f, -1.31957065e-02f, -1.07039250e-02f, -4.91962954e-02f, -2.07448401e-03f, 1.01910820e-02f, 8.38331226e-03f, 2.85600368e-02f, -5.32718934e-02f,
  2.60379851e-01f, -5.61744086e-02f, 1.97194457e-01f, -1.40429541e-01f, 1.76608954e-02f, 1.94324121e-01f, -1.11921609e-03f, -1.37601852e-01f, 1.67821467e-01f, -3.08895528e-01f,
  -2.78039247e-01f, 2.35608622e-01f, -1.56952858e-01f, -1.68852881e-01f, 3.28399092e-01f, 2.41735801e-02f, -5.08681498e-02f, -3.75551805e-02f, 1.34220108e-01f, -9.80686769e-02f,
  2.52547897e-02f, -2.96304882e-01f, -1.28061071e-01f, -1.11148193e-01f, -1.68666586e-01f, -1.92103088e-02f, -2.76951641e-01f, -8.98266062e-02f, -1.42075881e-01f, 5.52232713e-02f,
  2.51656715e-02f, -5.69589585e-02f, -3.65488008e-02f, 9.41703748e-03f, -1.01290330e-01f, -1.20499156e-01f, 1.36096003e-02f, -5.81989661e-02f, 1.81150548e-02f, -9.07859020e-03f,
  -8.71437266e-02f, 2.43766494e-02f, 2.81549431e-03f, 3.18152574e-03f, -5.26523329e-02f, 4.38330323e-02f, -5.20095639e-02f, 6.80918060e-03f, 1.09788552e-02f, 8.11046064e-02f,
  5.28079197e-02f, 1.18587781e-02f, 1.06977537e-01f, 7.75722042e-03f, 7.37840831e-02f, 2.65323594e-02f, 1.00558043e-01f, 1.58106834e-02f, 2.28186473e-02f, 8.64004344e-02f,
  -4.87553142e-02f, 6.00443333e-02f, -2.24523973e-02f, -4.05490398e-02f, 8.21375400e-02f, -6.66186884e-02f, -2.11707689e-02f, -5.34129282e-03f, 1.10801920e-01f, -2.99173985e-02f,
  -2.10710876e-02f, -4.46087569e-02f, 7.08230678e-03f, -2.81678773e-02f, -7.35062361e-02f, 1.37983397e-01f, -5.61395707e-03f, -3.68298031e-02f, -4.28454168e-02f, -2.66154669e-02f,
  -7.92416930e-02f, 3.59138325e-02f, 1.03565060e-01f, -7.35491291e-02f, -5.70914298e-02f, 2.76821628e-02f, -9.74315554e-02f, -2.98571214e-02f, -4.55961823e-02f, -9.64827910e-02f,
  -4.49412642e-03f, -1.19594246e-01f, -3.58628556e-02f, -1.16719818e-02f, -3.19801830e-02f, -2.02258471e-02f, -1.55128725e-02f, -1.86058655e-02f, -3.79237607e-02f, 2.56174318e-02f,
  -1.10252798e-01f, -7.94185176e-02f, 2.21883575e-03f, 1.86746195e-02f, -9.02597457e-02f, 4.72780550e-03f, -6.40293956e-02f, -5.26074842e-02f, -1.01578489e-01f, -3.39721479e-02f,
  -1.30869731e-01f, 3.65313031e-02f, -1.81670468e-02f, 6.46906393e-03f, -1.26609191e-01f, -2.81746294e-02f, 1.29833817e-01f, 4.91069295e-02f, -8.70207921e-02f, -4.86179776e-02f,
  2.32523099e-01f, -2.47938141e-01f, 2.52291948e-01f, -2.01617137e-01f, -4.48642671e-02f, -2.28414565e-01f, -1.48416504e-01f, -7.63572156e-02f, -2.26416066e-02f, -3.29866171e-01f,
  -1.51776299e-01f, 2.91247666e-03f, 7.57526606e-02f, -3.18840176e-01f, -7.13834763e-02f, 6.54523149e-02f, -3.34059924e-01f, -1.30575478e-01f, 2.31925528e-02f, -1.96031973e-01f,
  1.96093544e-02f, -2.82595754e-01f, 3.02902572e-02f, -1.19157955e-01f, -4.06418256e-02f, 1.26845300e-01f, -4.28662822e-03f, 2.50792921e-01f, -1.84375182e-01f, 8.43823552e-02f,
  3.64332162e-02f, 4.39591147e-02f, 2.33098976e-02f, 1.21149734e-01f, -6.19507506e-02f, -3.11246160e-02f, -6.17861710e-02f, 1.05512224e-01f, 7.75654241e-02f, 9.35719237e-02f,
  6.01848625e-02f, 5.15018478e-02f, -2.76314504e-02f, -3.51880528e-02f, 2.80951988e-02f, 2.40021646e-02f, 8.57853219e-02f, -2.59098085e-03f, -1.22755056e-03f, 2.82005463e-02f,
  -4.59699100e-03f, 7.22201169e-02f, 4.06907313e-02f, 8.22296599e-04f, -3.26195098e-02f, 1.01817334e-02f, -9.82313156e-02f, 2.29242798e-02f, -4.45526355e-04f, -6.92107752e-02f,
  1.88099761e-02f, -1.97048299e-02f, 8.15278813e-02f, 1.27493143e-01f, -5.74640706e-02f, 8.71337354e-02f, 8.65766127e-03f, 2.89263278e-02f, 8.81328732e-02f, -1.48960482e-02f,
  7.17529748e-03f, 4.69934233e-02f, 4.97024395e-02f, -2.08085161e-02f, -8.33021179e-02f, 8.75099562e-03f, 1.06788762e-01f, 6.43401816e-02f, 1.07612219e-02f, 7.87071735e-02f,
  6.34932071e-02f, -2.16955021e-02f, 5.62398881e-02f, 6.94353357e-02f, 6.79439828e-02f, 1.73401050e-02f, -7.66946301e-02f, 2.82886252e-02f, -1.87892504e-02f, -2.95984205e-02f,
  -2.46556804e-01f, -2.84268528e-01f, -3.54071222e-02f, -2.85000764e-02f, -7.15785176e-02f, -4.63321768e-02f, -6.54234663e-02f, 1.48384571e-02f, 7.72718200e-03f, 5.88628203e-02f,
  -3.31802331e-02f, 9.87652130e-03f, -3.34645174e-02f, -1.19537115e-02f, 5.59985749e-02f, -7.82209635e-02f, 4.03541401e-02f, -3.41848731e-02f, -6.20914660e-02f, 4.18601707e-02f,
  -6.38866872e-02f, 1.35812266e-02f, 8.44852347e-03f, -8.05816278e-02f, -1.35510474e-01f, 3.26760300e-02f, -9.38213840e-02f, 1.69527549e-02f, 5.98655120e-02f, -6.97709620e-02f,
  9.83670056e-02f, -2.80777276e-01f, -9.99324024e-02f, -1.14184342e-01f, 1.96885034e-01f, -3.13371509e-01f, -3.12558293e-01f, 1.44910619e-01f, 1.86874494e-02f, -1.10818677e-01f,
  -1.04733501e-02f, -2.83602893e-01f, -1.25102341e-01f, -1.88508406e-01f, -2.26757914e-01f, -9.58510190e-02f, -3.07362676e-01f, -3.12956065e-01f, 9.37363133e-02f, -8.10141638e-02f,
  5.55153191e-02f, -6.68581277e-02f, 3.91113060e-03f, 1.20091915e-01f, 4.63014245e-02f, 2.14093074e-01f, 7.21566156e-02f, 1.05272532e-01f, 4.03283425e-02f, -1.92343316e-03f,
  -5.07023223e-02f, 9.72392932e-02f, 9.07547623e-02f, -2.59534549e-02f, -1.65492054e-02f, 9.80407074e-02f, 2.72069755e-03f, -1.68579612e-02f, 6.34300113e-02f, -6.22610450e-02f,
  -3.33215087e-03f, 8.50675777e-02f, -5.02842339e-03f, 2.30501909e-02f, -4.16240022e-02f, -1.07329460e-02f, 7.44335651e-02f, -4.13893946e-02f, 2.30381787e-02f, 5.54101681e-03f,
  -1.07749384e-02f, -1.09239645e-01f, -9.58277285e-02f, -4.76061329e-02f, 1.64895393e-02f, -1.57076884e-02f, -7.72714838e-02f, -3.21330093e-02f, -4.48013954e-02f, 2.51740757e-02f,
  1.47700772e-01f, -1.06765546e-01f, -1.15043253e-01f, -9.85181555e-02f, -3.85233313e-02f, 1.80823673e-02f, -1.95407525e-01f, -7.98329711e-02f, -2.14948431e-02f, -9.82270762e-02f,
  -4.58180206e-03f, -7.34178768e-03f, 1.87827542e-03f, -6.39685988e-02f, -8.97429213e-02f, -7.57394067e-04f, -1.97418734e-01f, -2.17606639e-03f, -3.58510576e-02f, 2.50344817e-02f,
  -1.28357373e-02f, 2.88228295e-03f, -4.81948443e-02f, 2.18396285e-03f, -1.32893741e-01f, 3.79019789e-02f, 8.79992619e-02f, 7.75377080e-02f, 1.02701567e-01f, -3.44435610e-02f,
  -2.40973324e-01f, -4.10711318e-02f, 2.07243413e-02f, 6.05549514e-02f, -1.08399289e-02f, 6.89916015e-02f, -5.56804948e-02f, 2.86339745e-02f, -1.88091565e-02f, 4.97487262e-02f,
  6.19201213e-02f, -7.69172766e-05f, -3.44766416e-02f, -4.61720973e-02f, -1.48415402e-01f, -3.20502557e-02f, 6.82988167e-02f, 4.08246405e-02f, -2.25860309e-02f, -3.24360877e-02f,
  1.20164985e-02f, -4.20459695e-02f, -5.43280430e-02f, 6.91929832e-02f, -3.66644450e-02f, 2.14456059e-02f, -6.41673952e-02f, 2.80138454e-03f, -8.22289586e-02f, -8.93463343e-02f,
  -3.34185600e-01f, 2.45789334e-01f, 4.67483029e-02f, 4.95024808e-02f, 6.77553490e-02f, -5.86484268e-04f, 1.32040083e-01f, 1.18413530e-01f, -5.99305779e-02f, -1.47388391e-02f,
  5.81005961e-02f, -7.09896237e-02f, -7.55505310e-03f, 1.19612634e-01f, -2.05126062e-01f, 1.69285424e-02f, -4.69371714e-02f, -4.33414392e-02f, -1.62344769e-01f, -1.34209335e-01f,
  -4.26938012e-02f, 4.40001339e-02f, 6.11598492e-02f, 2.11960107e-01f, 2.92108189e-02f, -1.01125970e-01f, -6.29893169e-02f, 1.54568225e-01f, 3.22070308e-02f, 1.24137960e-01f,
  -5.15946746e-02f, -1.21479698e-01f, -1.57630369e-01f, -1.49917647e-01f, -8.84270146e-02f, -1.74073890e-01f, -1.26034915e-01f, -4.24637012e-02f, -7.45611191e-02f, 3.98311531e-03f,
  7.89127592e-03f, -1.03774453e-02f, 5.05530415e-03f, -2.78800279e-02f, 4.37520817e-02f, 3.68934944e-02f, 1.86074246e-02f, -4.47572202e-05f, 5.37596531e-02f, 1.41264452e-02f,
  8.79997909e-02f, 4.16326337e-02f, 5.19635156e-03f, 2.93307025e-02f, -1.53736891e-02f, 4.37589809e-02f, -3.08039561e-02f, 4.60310020e-02f, 1.63860079e-02f, 3.22336853e-02f,
  1.17953671e-02f, -5.63004613e-02f, 4.76832837e-02f, -8.11491981e-02f, -4.64189015e-02f, 4.42803465e-02f, 9.05093402e-02f, -1.43828697e-03f, -8.52161199e-02f, -2.53584143e-02f,
  5.62727626e-04f, 3.90513497e-03f, 4.75702435e-03f, -5.76950237e-02f, -3.58302408e-04f, -9.40164030e-02f, 2.85014901e-02f, -4.86837216e-02f, -8.62442106e-02f, 1.34692108e-02f,
  -2.65878625e-02f, 4.91621830e-02f, 1.11227833e-01f, 1.40559465e-01f, 1.29684716e-01f, -1.22721971e-03f, 4.68093567e-02f, 1.04619905e-01f, -3.40228039e-03f, -8.10792372e-02f,
  -3.51866841e-01f, -2.69658923e-01f, -1.26882881e-01f, -7.99259022e-02f, -8.07748586e-02f, -1.49211928e-01f, -6.54546544e-02f, -6.87131509e-02f, -1.98270738e-01f, -6.21395074e-02f,
  -5.89444563e-02f, 6.13848642e-02f, 6.34238049e-02f, -1.31593838e-01f, 8.70441720e-02f, -6.79033110e-03f, -9.63514522e-02f, -9.28560048e-02f, -7.45723173e-02f, -2.92841848e-02f,
  4.90126163e-02f, 3.11399419e-02f, 6.53909519e-02f, 4.92807664e-02f, -1.44150993e-02f, -5.87794418e-03f, -2.61227172e-02f, 3.50341983e-02f, -2.48139910e-02f, 3.97249963e-03f,
  -3.43313217e-02f, -6.60444945e-02f, -7.17744455e-02f, 4.52302285e-02f, 7.27739409e-02f, -2.39635795e-01f, -9.33862925e-02f, -1.34425074e-01f, -2.01773360e-01f, 9.55946520e-02f,
  -3.20144147e-02f, 2.68010318e-01f, -6.88167587e-02f, 9.77917016e-02f, -1.68876261e-01f, -1.36556685e-01f, -1.85349703e-01f, -1.74401551e-01f, -6.14760891e-02f, -1.10562965e-01f,
  -1.83476806e-01f, 3.22224349e-02f, 1.21264427e-03f, 9.16091204e-02f, 1.51442856e-01f, 1.16533890e-01f, 3.84005368e-01f, 6.45316616e-02f, 2.05983907e-01f, 1.82845041e-01f,
  -5.64551279e-02f, 5.23588881e-02f, 1.08857602e-02f, -6.40125200e-02f, 2.27323696e-02f, 1.51488082e-02f, 1.41173729e-03f, 1.83029287e-02f, 4.98161018e-02f, -3.56666744e-02f,
  2.31071413e-02f, 3.72183719e-03f, 8.01417381e-02f, 1.67199094e-02f, -1.01870149e-01f, 1.37652993e-01f, 2.97819655e-02f, -4.41517644e-02f, -4.45049629e-02f, 1.61145795e-02f,
  -7.16334954e-02f, -1.71889830e-02f, 5.85620478e-02f, 1.39169469e-02f, 6.77443817e-02f, -1.65864322e-02f, -5.45875505e-02f, 3.69753391e-02f, -2.07799338e-02f, 4.28631492e-02f,
  -9.80739892e-02f, 1.94035787e-02f, 1.83534401e-03f, 2.91595943e-02f, 4.32970934e-02f, 1.41857809e-03f, -3.56949307e-02f, 8.72906074e-02f, 2.05142424e-01f, 2.87311468e-02f,
  3.07488386e-02f, -8.61541778e-02f, -3.44555117e-02f, -3.39088254e-02f, 1.11355528e-01f, 4.90891375e-02f, -4.99274395e-02f, 1.14001274e-01f, -6.88073561e-02f, -2.17925198e-02f,
  -5.13338484e-02f, -7.34272674e-02f, 6.27287524e-03f, -2.70823631e-02f, -1.96151346e-01f, 8.67482089e-03f, 3.89466174e-02f, -4.15462218e-02f, 8.03350508e-02f, 5.65188378e-03f,
  -6.78436384e-02f, 9.71373022e-02f, 6.91606328e-02f, 9.53651033e-03f, -1.22594880e-02f, 1.09089896e-01f, -5.33253327e-02f, -4.79944311e-02f, -6.28336221e-02f, 9.84046608e-02f,
  -2.78275982e-02f, -2.55365986e-02f, 5.14042638e-02f, 4.05054204e-02f, -5.16946204e-02f, -4.15849201e-02f, -3.85547318e-02f, 7.59929186e-03f, -2.61961762e-02f, -1.60227641e-02f,
  6.00090213e-02f, 1.16290003e-01f, 3.66714001e-02f, 8.03175643e-02f, -8.25515762e-02f, 1.03299454e-01f, 5.32568665e-03f, 4.03068736e-02f, 1.18944265e-01f, 8.71005058e-02f,
  3.36928785e-01f, -2.96413630e-01f, 1.60532251e-01f, 7.78967366e-02f, -3.17569673e-02f, 1.32275730e-01f, 1.10474154e-02f, -6.49652854e-02f, 2.82391697e-01f, -3.45732123e-01f,
  -2.73369372e-01f, 5.78680634e-02f, -1.58303902e-01f, -2.85715520e-01f, 3.67620140e-01f, 6.22864701e-02f, 9.55514237e-03f, 1.93702884e-03f, 1.30159348e-01f, -1.53033584e-01f,
  2.61819381e-02f, -3.18858296e-01f, -1.12577543e-01f, -1.71734303e-01f, -2.22525761e-01f, 4.96029072e-02f, -2.27310181e-01f, 1.72174405e-02f, -2.48690456e-01f, 3.70244123e-02f,
  -2.28425693e-02f, -6.10679872e-02f, -1.32687569e-01f, -7.57238343e-02f, 6.09173030e-02f, -3.70111428e-02f, 5.55118360e-02f, 7.67582655e-02f, 1.13820806e-01f, -1.15052432e-01f,
  -9.02259797e-02f, 2.88094813e-03f, -4.59664799e-02f, 8.65059253e-03f, 3.96272317e-02f, 6.78883940e-02f, -2.68910620e-02f, 3.98714840e-02f, -9.31160673e-02f, 2.57924246e-03f,
  1.83939580e-02f, -1.84845142e-02f, 1.28268257e-01f, 4.96004969e-02f, 2.03379169e-02f, -4.16721180e-02f, -1.53734665e-02f, 1.08162493e-01f, 2.13909261e-02f, 6.85548261e-02f,
  4.71337847e-02f, -1.83831472e-02f, -4.44284491e-02f, -5.46438918e-02f, -1.84372794e-02f, -7.69356936e-02f, 3.88693856e-03f, -1.24454675e-02f, 1.11938700e-01f, -1.77649781e-02f,
  2.20071003e-02f, -5.38247339e-02f, 4.15071361e-02f, -3.48853730e-02f, -4.33970019e-02f, -1.23781450e-02f, 3.74121256e-02f, 7.06692133e-03f, 4.64117341e-03f, 5.29671423e-02f,
  -7.62212947e-02f, -5.01444675e-02f, -1.32150706e-02f, -6.14616722e-02f, -3.11321486e-02f, 2.57222354e-02f, -1.18618034e-01f, -4.02566083e-02f, 3.75235006e-02f, -7.14252517e-02f,
  1.14591412e-01f, -8.83931527e-04f, -1.12900019e-01f, -7.72671327e-02f, 4.64564785e-02f, -4.74607386e-02f, 1.55557543e-01f, 3.08911968e-02f, 1.62946209e-01f, -3.67191359e-02f,
  -6.53154030e-02f, -8.07860419e-02f, -4.66890307e-03f, 1.28952295e-01f, -2.46390682e-02f, -8.82492885e-02f, -6.45503700e-02f, -7.09481072e-03f, 2.86771227e-02f, -6.86056241e-02f,
  -1.64363593e-01f, 7.77211506e-03f, -4.84459139e-02f, -3.26948315e-02f, -9.82920676e-02f, -3.07111237e-02f, 8.76193643e-02f, -3.94567810e-02f, 3.85484286e-02f, 4.29286249e-02f,
  1.49268389e-01f, 1.82953507e-01f, 2.59578615e-01f, 3.36428136e-01f, -9.65720192e-02f, -2.19152644e-01f, -2.22678870e-01f, 5.80469891e-02f, 7.90967941e-02f, -4.20475006e-02f,
  -2.18772501e-01f, 2.55712479e-01f, -4.12079841e-01f, 2.08551750e-01f, 1.26373708e-01f, -7.93366432e-02f, 2.41737008e-01f, 5.43414243e-02f, -2.52077058e-02f, 6.14176095e-02f,
  2.47708023e-01f, 7.37467362e-03f, 1.75658047e-01f, 5.01856022e-02f, 1.20475084e-01f, 1.96467668e-01f, 5.76487258e-02f, -7.26027936e-02f, 2.46713400e-01f, 9.17145684e-02f,
  -2.49756947e-02f, -1.58656910e-02f, 6.38533980e-02f, 3.68653908e-02f, -7.69320037e-03f, 2.21312139e-03f, 5.00309132e-02f, -4.11713775e-03f, -3.52684371e-02f, -7.04725310e-02f,
  -6.67338073e-03f, 4.15492207e-02f, -1.44297741e-02f, 4.65181768e-02f, -1.02024397e-03f, 4.78752218e-02f, 5.23103997e-02f, -1.23392604e-03f, 4.34817672e-02f, 2.63872072e-02f,
  1.90909263e-02f, -3.67045589e-02f, -5.19515052e-02f, 4.36500572e-02f, 9.49926004e-02f, 1.88277122e-02f, 1.21925540e-01f, 4.47736233e-02f, 6.07508309e-02f, 7.16645569e-02f,
  2.68438123e-02f, -8.80962089e-02f, -1.11116853e-03f, -3.44556682e-02f, -1.09516948e-01f, -6.11255728e-02f, -7.74632990e-02f, -7.96567798e-02f, -4.65583354e-02f, -4.50737886e-02f,
  -1.52896447e-02f, 9.90239903e-02f, -7.26400167e-02f, 4.42741811e-03f, -5.16600460e-02f, 4.54124399e-02f, 3.78662813e-03f, 1.05303824e-02f, 2.25789044e-02f, 4.64254525e-03f,
  -1.48882233e-02f, 1.56320557e-02f, -4.64104526e-02f, 3.13524455e-02f, -8.18514526e-02f, 4.64625508e-02f, 3.90367880e-02f, 1.25264838e-01f, -8.75463560e-02f, -4.59850505e-02f,
  -2.55209655e-02f, -1.47672314e-02f, -4.61839139e-02f, 6.79890043e-04f, -5.42847626e-03f, 6.36818781e-02f, 8.00249726e-03f, 1.60723850e-01f, 7.90786967e-02f, -3.11089065e-02f,
  9.61194113e-02f, 1.62479021e-02f, -6.53203875e-02f, 7.86525905e-02f, -2.17983443e-02f, -7.32991099e-02f, -1.02947634e-02f, 4.84959632e-02f, 4.30864245e-02f, 4.87512983e-02f,
  -5.38661629e-02f, -1.80062473e-01f, -6.90115839e-02f, -5.42068519e-02f, 1.06091067e-01f, -7.57026076e-02f, -7.66263902e-02f, 4.45961729e-02f, -6.25998899e-02f, -2.49921810e-02f,
  5.21441065e-02f, -2.53156096e-01f, 4.05469015e-02f, 8.47629607e-02f, -1.12268791e-01f, -2.33520463e-01f, 4.37405184e-02f, -1.23621881e-01f, 1.80936009e-02f, -2.39305437e-01f,
  8.56592208e-02f, -1.87407881e-01f, 1.74044341e-01f, -1.37864694e-01f, 1.55205086e-01f, 2.28064433e-01f, -7.29810596e-02f, -8.82550105e-02f, 1.45081207e-01f, -3.86651009e-02f,
  1.82680935e-02f, -3.87995578e-02f, 1.92547917e-01f, -2.12550983e-01f, -1.05076298e-01f, -3.03341486e-02f, -3.35302427e-02f, 3.09312511e-02f, -2.10935488e-01f, -1.20569319e-01f,
  -1.16958451e-02f, 1.61986381e-01f, 5.91617338e-02f, 6.99682534e-02f, 3.40198465e-02f, 4.13118489e-02f, 1.37910485e-01f, 1.33285969e-01f, 1.46674037e-01f, -1.14667408e-01f,
  -8.10438097e-02f, -2.10527908e-02f, -5.92564605e-02f, 5.12050577e-02f, -1.27915084e-01f, -2.53124647e-02f, -3.40156094e-03f, -1.37590384e-02f, -7.32244283e-04f, -8.23962837e-02f,
  -8.09325352e-02f, -8.62168074e-02f, -5.41047454e-02f, -1.15004279e-01f, -4.66977879e-02f, -1.01998374e-01f, -8.78665820e-02f, -1.04162186e-01f, -1.51393533e-01f, -9.92755219e-02f,
  -1.90253910e-02f, 3.68826091e-02f, 1.59757258e-03f, 9.07910094e-02f, 4.76491936e-02f, 3.47099975e-02f, -1.44764800e-02f, 2.16903389e-02f, -3.82585935e-02f, -3.21371220e-02f,
  2.51939520e-03f, -3.65037881e-02f, 1.22661181e-02f, -3.76010872e-02f, -3.23383249e-02f, -2.22218838e-02f, -7.67100453e-02f, -1.21926032e-01f, -3.56097776e-03f, 1.17512392e-02f,
  1.33632421e-01f, -4.76845577e-02f, -1.21064894e-02f, -6.00040518e-02f, 1.05794378e-01f, 8.41809530e-03f, -4.12172228e-02f, -1.40035544e-02f, 1.20239794e-01f, 4.16443162e-02f,
  -1.26246184e-01f, -1.12207852e-01f, 6.06104173e-02f, 2.13038232e-02f, 1.25935320e-02f, 2.23227404e-03f, 1.53112903e-01f, 1.89818032e-02f, 7.04319254e-02f, -1.14566239e-03f,
  -1.02764785e-01f, 3.05693727e-02f, -4.32887934e-02f, 3.63589148e-03f, -5.09100892e-02f, -8.52749050e-02f, 3.52258347e-02f, 1.00899339e-01f, -1.14593089e-01f, -1.54337496e-01f,
  -1.07457511e-01f, 9.76124406e-03f, -4.39349338e-02f, -3.47940587e-02f, -1.13777459e-01f, -5.67440279e-02f, -4.38009165e-02f, -4.28343490e-02f, -5.92101254e-02f, -3.82315628e-02f,
  -2.91010231e-01f, 1.65510640e-01f, -2.41651729e-01f, -3.36113393e-01f, 9.46283713e-02f, 1.81968454e-02f, -1.26861140e-01f, -4.98496275e-03f, -1.29646063e-01f, 1.62937954e-01f,
  1.34727791e-01f, -1.29681066e-01f, 2.64713019e-01f, -7.50865266e-02f, -1.97544962e-01f, 9.15793851e-02f, -1.95787460e-01f, -4.90227006e-02f, 9.08682682e-03f, -1.41408937e-02f,
  -2.16945380e-01f, 6.71089590e-02f, -9.91928205e-02f, 2.08392754e-01f, 3.05949487e-02f, -1.38908520e-01f, -6.08788393e-02f, 1.22948311e-01f, -1.54986486e-01f, 9.53509361e-02f,
  1.08229734e-01f, 3.55037302e-02f, -2.12413445e-03f, 1.26687691e-01f, -5.77395596e-02f, -7.17427656e-02f, -3.85571457e-02f, 1.83448978e-02f, 9.98557657e-02f, 3.66055639e-03f,
  9.65972915e-02f, 4.20135475e-04f, -1.88457873e-02f, -7.88505673e-02f, 1.02244355e-01f, 5.49151227e-02f, 2.32394272e-03f, -1.01852670e-01f, 9.62776691e-02f, -9.88996923e-02f,
  -1.01027563e-02f, 3.21838148e-02f, -2.28427574e-02f, 3.70258056e-02f, -4.12058048e-02f, 8.03348795e-03f, -2.18057707e-01f, -8.75297561e-02f, -4.54622209e-02f, -7.45350346e-02f,
  9.46088054e-04f, -2.82223914e-02f, 1.10225873e-02f, 2.24590581e-02f, -4.48394120e-02f, 4.85252915e-03f, 2.44236719e-02f, 7.80196711e-02f, -2.29167957e-02f, 3.53511944e-02f,
  -4.45640530e-04f, 1.00345127e-01f, 1.23263046e-01f, 1.32813221e-02f, -4.17865813e-02f, -1.69113204e-01f, 3.05868983e-02f, -1.17582873e-01f, 2.92715728e-02f, 2.50266660e-02f,
  1.06988162e-01f, 4.42543067e-02f, 1.13694564e-01f, 1.36732072e-01f, 1.26536146e-01f, 2.53395606e-02f, -1.05614863e-01f, -2.01350659e-01f, -1.68190338e-02f, -1.53846694e-02f,
  1.15769491e-01f, -7.70448521e-02f, 2.53879149e-02f, 6.72201887e-02f, -4.42428216e-02f, -3.28795016e-02f, -1.05044618e-01f, -1.57288425e-02f, 1.02444753e-01f, -4.66802791e-02f,
  6.64790571e-02f, 6.40153959e-02f, 6.24208301e-02f, -4.24500704e-02f, 1.35620698e-01f, 5.61106531e-03f, -5.11875860e-02f, 6.71671191e-03f, 5.72984852e-02f, -1.13876417e-01f,
  5.93358278e-03f, 4.94725108e-02f, 5.24766706e-02f, 1.11825345e-02f, 1.25342468e-02f, 3.91117409e-02f, -9.99935865e-02f, -4.37152572e-02f, 1.29009532e-02f, 2.29054037e-02f,
  -1.05404906e-01f, 2.19540507e-01f, 5.19506037e-02f, 1.12287246e-01f, -8.14918894e-03f, -1.82004020e-01f, -3.19288224e-01f, 1.28993571e-01f, -1.56753853e-01f, 3.60756256e-02f,
  4.12554927e-02f, 7.53222629e-02f, -1.09852709e-01f, 1.92107260e-01f, -9.57581624e-02f, -1.20996445e-01f, 1.34176284e-01f, 5.81632517e-02f, -3.75954024e-02f, 1.86882690e-01f,
  6.00816570e-02f, 9.52274352e-02f, 7.48940706e-02f, 1.68053970e-01f, 1.31559953e-01f, 1.41631603e-01f, 2.21365973e-01f, 1.47232348e-02f, 9.28251520e-02f, 4.46479917e-02f,
  -4.96756062e-02f, -1.90623123e-02f, 9.19134729e-03f, -2.78506875e-02f, 3.32029685e-02f, -1.75732728e-02f, 2.92020775e-02f, 6.13643974e-02f, -1.19130313e-01f, -5.95333911e-02f,
  6.55828863e-02f, 8.59516114e-03f, 1.52841836e-01f, -1.93280037e-02f, -5.19949361e-04f, -6.95160702e-02f, -3.20069306e-02f, -1.95923001e-02f, 3.00131962e-02f, 6.71353787e-02f,
  -1.18592558e-02f, 4.51462008e-02f, 9.19925570e-02f, 4.23525535e-02f, 1.75992176e-02f, 7.33156055e-02f, -1.45015121e-02f, -1.53949000e-02f, 9.52415541e-03f, 3.18330750e-02f,
  5.94969615e-02f, 4.12417017e-03f, -3.15113589e-02f, -5.98916970e-02f, -4.48860936e-02f, -3.06294654e-02f, 3.14676277e-02f, 3.54160531e-03f, -6.74245432e-02f, -2.69491635e-02f,
  -7.63945803e-02f, 8.33215117e-02f, -5.06804474e-02f, 7.06842728e-03f, 6.94968626e-02f, 7.70504959e-03f, 4.43895534e-02f, 3.36087681e-02f, -5.40468022e-02f, 1.09307077e-02f,
  2.45271046e-02f, 2.06613913e-02f, -1.80516720e-01f, 1.96262971e-02f, -5.97300231e-02f, -4.31942679e-02f, 1.20134220e-01f, -3.39434035e-02f, -1.52809508e-02f, 8.07470977e-02f,
  8.02495033e-02f, 1.53356880e-01f, -5.88295013e-02f, -5.30037191e-03f, 4.82489206e-02f, -1.57948509e-02f, 1.35745602e-02f, 1.49441645e-01f, -2.05100942e-02f, -5.24569601e-02f,
  1.48724720e-01f, -6.69645444e-02f, 1.76831838e-02f, -1.85457375e-02f, 8.72495398e-02f, 1.54707665e-02f, -1.51919015e-02f, -6.32651523e-02f, 1.42957801e-02f, 1.86287954e-01f,
  1.27221063e-01f, -3.62341739e-02f, 3.24870497e-02f, -2.45500803e-02f, 1.62944555e-01f, 6.56930059e-02f, 7.32864661e-04f, 2.81436145e-02f, 5.50707914e-02f, 4.88514341e-02f,
  -9.97560024e-02f, 4.00583565e-01f, -1.35043487e-01f, -1.14485905e-01f, -5.35821617e-02f, -1.46528613e-02f, -2.20675208e-02f, 5.22897877e-02f, 3.48275825e-02f, 2.26782769e-01f,
  -1.19223870e-01f, 1.48633614e-01f, -6.83492944e-02f, -2.87825987e-02f, -3.21441174e-01f, -2.37087771e-01f, -6.77219629e-02f, 1.14061378e-01f, -1.27198085e-01f, -1.05220415e-01f,
  -1.63430586e-01f, -2.14743540e-01f, -2.47402251e-01f, -2.89365333e-02f, -1.14347190e-01f, -3.96974683e-02f, 4.68527004e-02f, -7.31570125e-02f, 2.41533574e-02f, 7.28852674e-02f,
  -2.55556237e-02f, -1.37736231e-01f, -6.95076063e-02f, 1.39880758e-02f, -5.09630442e-02f, -6.07663952e-03f, 3.12342700e-02f, -6.22114427e-02f, -1.64130613e-01f, 1.99231934e-02f,
  5.84037043e-02f, -3.65415029e-02f, -3.11359372e-02f, -3.57912406e-02f, 1.06771827e-01f, 4.50371429e-02f, 8.39475077e-03f, 4.67261896e-02f, -4.90439236e-02f, 8.58109593e-02f,
  -7.98853561e-02f, -7.38905603e-03f, 5.29027618e-02f, -2.03368645e-02f, -4.17286791e-02f, 4.24008965e-02f, 3.70926247e-03f, 4.12464738e-02f, 4.96727461e-03f, 7.75995329e-02f,
  -2.43845228e-02f, 5.07952459e-02f, 5.87252229e-02f, 1.69544425e-02f, -8.88645798e-02f, 8.02078545e-02f, 6.30464926e-02f, 3.61410938e-02f, -4.14589373e-03f, 7.13942721e-02f,
  -2.44365148e-02f, 6.41830191e-02f, 8.89390591e-04f, 2.30274703e-02f, 1.29641011e-01f, 7.07151219e-02f, 4.42948416e-02f, 3.04230973e-02f, 1.92401335e-02f, -1.92125663e-02f,
  4.36828583e-02f, 3.00910287e-02f, 3.05847209e-02f, -3.20270881e-02f, 4.12464924e-02f, -4.31712903e-02f, 2.56130639e-02f, 7.00129792e-02f, -8.00285190e-02f, -5.22281006e-02f,
  -9.01234820e-02f, -6.86368570e-02f, -5.35836704e-02f, -1.16741816e-02f, 1.01418570e-02f, -2.70853247e-02f, -8.18840321e-03f, 1.48779457e-03f, -3.96693721e-02f, -1.29819214e-01f,
  8.55503976e-02f, -1.93574075e-02f, -8.56590793e-02f, -7.82247037e-02f, 5.44073246e-02f, 4.95404750e-02f, 1.34119559e-02f, -4.50273529e-02f, -7.99497291e-02f, 2.06143409e-01f,
  9.77044646e-03f, -6.06476627e-02f, -5.77557553e-03f, -6.50108755e-02f, -2.80526429e-02f, 4.54404205e-02f, 2.04015914e-02f, 7.51449466e-02f, -2.83125844e-02f, 8.25778395e-02f,
  -3.68391722e-01f, 2.78966159e-01f, -2.46687800e-01f, -1.80051461e-01f, 1.19652525e-01f, -6.62166029e-02f, -9.02014375e-02f, 1.33962199e-01f, 2.68446188e-02f, 1.84199646e-01f,
  3.24439466e-01f, -1.02687359e-01f, 3.81371796e-01f, 1.11905590e-01f, -1.72478318e-01f, 3.15288305e-01f, -5.36051430e-02f, 8.34213197e-03f, 2.49387287e-02f, 1.07204869e-01f,
  -4.28025797e-02f, 1.74628690e-01f, 5.32321148e-02f, 1.20689243e-01f, 3.69241685e-02f, -1.60491511e-01f, 1.04927517e-01f, -1.30395284e-02f, -7.86996037e-02f, -5.90262376e-02f,
  -1.21093787e-01f, 4.64260913e-02f, -1.35791063e-01f, -7.38794133e-02f, -1.09011509e-01f, -1.06272675e-01f, -1.40178248e-01f, -3.52889374e-02f, -2.24092100e-02f, 7.25980029e-02f,
  -2.60898285e-02f, 3.64854857e-02f, 2.27509700e-02f, 4.95593771e-02f, 1.38706239e-02f, -7.82333687e-02f, 8.90293270e-02f, -4.08849865e-02f, 1.43960148e-01f, -6.18596934e-02f,
  6.04909882e-02f, 9.38951410e-03f, 9.20697376e-02f, 1.08090930e-01f, 1.03319056e-01f, 7.52652949e-03f, -8.53736028e-02f, -9.84357372e-02f, -2.00683996e-03f, -5.26278429e-02f,
  1.26608592e-02f, -6.27212673e-02f, 9.67386812e-02f, 6.22202419e-02f, 9.44412500e-02f, 7.54224285e-02f, 8.57530087e-02f, 4.07005399e-02f, -7.89536983e-02f, 1.48374304e-01f,
  2.45687198e-02f, 4.20546904e-02f, 8.29692855e-02f, -2.07498167e-02f, -4.21398245e-02f, -6.19017594e-02f, -4.71577384e-02f, 1.76567081e-02f, -2.87379734e-02f, 3.91434325e-04f,
  5.35293259e-02f, -2.62752883e-02f, -1.94844056e-03f, -8.18946585e-03f, -6.88120257e-03f, 8.53597671e-02f, 1.09477781e-01f, 4.92664007e-03f, -1.95100382e-02f, 4.13325541e-02f,
  3.27460244e-02f, 1.38070896e-01f, 4.64906171e-03f, 1.74096804e-02f, -9.66060907e-02f, -3.78077067e-02f, -1.88033506e-01f, 4.49081361e-02f, 5.91849089e-02f, 1.08512193e-02f,
  4.98816185e-02f, 6.81235269e-02f, 5.37305698e-02f, 6.04876727e-02f, -3.29039507e-02f, 8.15729946e-02f, -3.94062996e-02f, 2.44073253e-02f, 5.67625202e-02f, -4.13302258e-02f,
  -1.80477351e-02f, 9.12226215e-02f, 2.83579770e-02f, 8.05381909e-02f, 1.20043680e-02f, 1.22803211e-01f, -5.77195473e-02f, -1.72651559e-02f, 1.74657330e-02f, 2.38869991e-02f,
  -2.91480541e-01f, 1.01068325e-01f, 4.73999158e-02f, -1.42650768e-01f, 5.72364107e-02f, 3.03367645e-01f, 2.84665436e-01f, -4.94455472e-02f, 3.31068188e-02f, 9.45772678e-02f,
  1.14585705e-01f, 1.49147406e-01f, 7.45299757e-02f, 2.30783418e-01f, -2.11078599e-02f, 3.59388739e-02f, 5.99555410e-02f, 1.34076312e-01f, -1.18154779e-01f, -1.21864669e-01f,
  -8.60723183e-02f, -5.41553907e-02f, 6.82887156e-03f, -1.53792828e-01f, 3.25282440e-02f, -2.06563011e-01f, -1.87362328e-01f, 5.59980646e-02f, 3.80361415e-02f, 1.58254400e-01f,
  -5.67057692e-02f, -1.82301536e-01f, -8.32593292e-02f, -9.20032784e-02f, -1.31003961e-01f, -8.99835527e-02f, -1.66963995e-01f, -6.23371154e-02f, -1.39901564e-01f, 3.20965610e-02f,
  -1.41101051e-02f, -8.44366178e-02f, 7.38700554e-02f, 8.58384818e-02f, 8.91027674e-02f, -4.00136486e-02f, 8.41251761e-02f, 7.04839975e-02f, -3.62727046e-02f, 9.08777118e-02f,
  7.58808032e-02f, 7.65298009e-02f, 8.85207802e-02f, 2.29276139e-02f, 4.39857915e-02f, 8.84376615e-02f, -6.02411851e-03f, 1.17035761e-01f, -4.47753072e-02f, -1.99376233e-02f,
  -3.10127009e-02f, -4.88459989e-02f, 2.54170299e-02f, -1.05078451e-01f, -1.63070299e-02f, -2.62862747e-03f, -5.04481196e-02f, 1.96885280e-02f, -4.78767827e-02f, -8.88369009e-02f,
  -1.12114288e-01f, -1.07701920e-01f, -5.77158704e-02f, -1.31825106e-02f, -2.75125308e-03f, -8.29729661e-02f, -7.92364776e-03f, -1.78567879e-02f, 6.77496865e-02f, -9.51320678e-02f,
  -6.14966191e-02f, 3.18066888e-02f, 6.05111942e-02f, -2.54465360e-02f, 6.50884956e-02f, 3.46628278e-02f, -4.69422638e-02f, 9.40999165e-02f, -3.74635234e-02f, -2.24479996e-02f,
  -1.84748352e-01f, -3.75617087e-01f, -7.30884373e-02f, -1.28388166e-01f, -9.77813378e-02f, -5.68615720e-02f, -1.25312641e-01f, -5.59784770e-02f, -1.51053920e-01f, -2.76714843e-02f,
  -1.23873688e-01f, -8.88131633e-02f, -5.77566661e-02f, 2.62823999e-02f, 8.66593570e-02f, 1.14864958e-02f, -4.30272799e-03f, -5.01579903e-02f, -5.80238476e-02f, -3.36237326e-02f,
  -1.01213261e-01f, -9.41187441e-02f, -4.87590022e-02f, -2.76324600e-02f, 4.21334384e-03f, 8.59558359e-02f, 5.39795384e-02f, 9.08878073e-02f, 3.61103974e-02f, 1.70610398e-02f,
  -2.39160165e-01f, -4.97932695e-02f, 2.48787865e-01f, -2.43648231e-01f, 9.19054896e-02f, 3.01224470e-01f, 1.17018349e-01f, 7.46317953e-02f, -1.93229064e-01f, -6.50821924e-02f,
  -2.04379529e-01f, -7.28860199e-02f, -9.29817259e-02f, -2.36408904e-01f, -6.30073296e-03f, -2.14260906e-01f, -7.18017519e-02f, -5.86586148e-02f, -5.34120165e-02f, -5.43458313e-02f,
  -3.97828110e-02f, -2.70825922e-01f, 9.76135880e-02f, -4.57426533e-02f, 5.90841807e-02f, 8.33640024e-02f, -6.53415918e-02f, 1.61423475e-01f, -2.37480924e-02f, 5.28636798e-02f,
  3.95517126e-02f, -1.69568449e-01f, 9.10622478e-02f, 4.53126766e-02f, 4.36800309e-02f, 3.04917302e-02f, 5.78616597e-02f, -3.53015843e-03f, -4.50443570e-03f, -2.52954476e-02f,
  -9.34213516e-04f, -4.81045656e-02f, -1.25777230e-01f, -1.27160236e-01f, 2.36308388e-02f, 4.06227522e-02f, 3.20659094e-02f, 1.24095529e-01f, 6.07145689e-02f, -5.77930734e-02f,
  -3.49522941e-02f, 3.11281178e-02f, 1.79864168e-02f, -8.47398266e-02f, 2.58627236e-02f, -8.97749439e-02f, -4.25035059e-02f, 3.65317799e-02f, 2.52817618e-03f, -9.88103375e-02f,
  -6.64843470e-02f, -1.31617129e-01f, -1.08910352e-01f, -2.57742405e-03f, -3.26112285e-02f, -8.09025485e-03f, -1.68893598e-02f, 9.59095731e-02f, 2.70314198e-02f, -1.62511375e-02f,
  1.35639012e-01f, 1.39632728e-02f, 2.56720800e-02f, -4.32495354e-03f, -7.65771046e-02f, -5.72862253e-02f, 2.98788752e-02f, -2.38097068e-02f, 6.28669560e-02f, 5.88340648e-02f,
  -4.44614850e-02f, -7.46102333e-02f, 2.90362667e-02f, 1.19095072e-01f, 3.01181413e-02f, -5.97690530e-02f, -1.11382693e-01f, 8.11267719e-02f, 2.41475552e-02f, 6.84042200e-02f,
  3.87736894e-02f, -1.33048177e-01f, 2.20143106e-02f, 3.60144377e-02f, -1.38052441e-02f, 3.04059424e-02f, -7.02970549e-02f, -4.14663851e-02f, 3.12627070e-02f, -4.21741977e-02f,
  -2.62868386e-02f, 2.69595371e-03f, 5.31066023e-02f, -1.24988325e-01f, 5.08280173e-02f, -5.83666340e-02f, -3.93217138e-04f, 6.64041890e-03f, 3.91980000e-02f, -6.48959074e-04f,
  2.39559133e-02f, -5.46186343e-02f, -1.70838740e-02f, -4.26572636e-02f, 2.80689560e-02f, -3.13545018e-02f, -5.77546237e-03f, 1.64070930e-02f, 4.99722688e-03f, -1.22657269e-02f,
  -2.77026862e-01f, 2.17500642e-01f, -1.20510913e-01f, -1.76538646e-01f, 8.60025734e-02f, 4.54104170e-02f, -1.21148147e-01f, 1.08584657e-01f, 2.02558830e-01f, -5.96827231e-02f,
  -8.16410705e-02f, -8.08991715e-02f, 1.13530211e-01f, -2.16410592e-01f, -2.03275174e-01f, 6.32464364e-02f, -1.69542819e-01f, -8.08272362e-02f, 1.19042449e-01f, -1.14192173e-01f,
  9.55490768e-02f, -7.58841485e-02f, -2.85622150e-01f, 1.86346546e-01f, -1.65578917e-01f, -2.46669911e-02f, -7.31729940e-02f, 1.34583846e-01f, -1.88083857e-01f, 4.07341532e-02f,
  2.54169758e-02f, 2.10081413e-02f, -1.21909976e-01f, 5.42561933e-02f, -6.81847408e-02f, -7.50289410e-02f, -5.77879325e-03f, -5.60598001e-02f, -5.37133850e-02f, -1.28023550e-02f,
  6.43322468e-02f, 6.01060130e-03f, -3.91947441e-02f, 2.54531261e-02f, 1.21591069e-01f, 4.32631820e-02f, 2.26207320e-02f, -7.75269866e-02f, -1.87565535e-02f, -1.55051081e-02f,
  -5.55975437e-02f, -2.81103142e-02f, 4.60633263e-02f, 4.29912917e-02f, 3.22203748e-02f, 6.90416023e-02f, -4.15046215e-02f, 3.24969599e-03f, -6.87096547e-03f, 2.62330263e-03f,
  -4.64316308e-02f, 1.65519014e-01f, -3.53326537e-02f, 3.58623713e-02f, -1.76026225e-02f, 7.22843334e-02f, 8.92817304e-02f, 3.15731158e-03f, 3.69162895e-02f, 4.71130833e-02f,
  -5.59836626e-03f, -8.51281285e-02f, 1.45868182e-01f, 5.92627712e-02f, -6.52062125e-04f, 1.36350757e-02f, -4.05684207e-03f, -2.19481532e-02f, 2.28622854e-02f, -1.38614833e-01f,
  7.58075044e-02f, 1.05397187e-01f, 2.77523566e-02f, 6.47635013e-02f, 7.47393295e-02f, 7.87858572e-03f, 1.32561415e-01f, -5.10421954e-02f, -4.59551923e-02f, -1.35063469e-01f,
  2.46566251e-01f, 2.31880695e-01f, 4.01950926e-02f, -6.72333091e-02f, 9.60518699e-03f, -8.89132991e-02f, -1.91280916e-02f, -9.08925980e-02f, 9.87545624e-02f, -4.49352302e-02f,
  7.69441947e-02f, 2.50546932e-02f, -4.40082699e-02f, 2.13544499e-02f, 3.15358229e-02f, 3.11873127e-02f, 5.43492846e-02f, 4.11129631e-02f, 3.38840708e-02f, 1.29136845e-01f,
  -4.32501994e-02f, -2.14537587e-02f, -6.59066737e-02f, -1.60760037e-03f, -1.02668062e-01f, -2.48983339e-03f, -3.07853986e-02f, -6.59869844e-03f, 4.51993681e-02f, 5.37274517e-02f,
  3.86808336e-01f, -2.44805247e-01f, 2.10994706e-01f, 1.06710494e-01f, -1.09005727e-01f, -2.90003773e-02f, 1.77595332e-01f, 4.49120961e-02f, 2.61489511e-01f, -2.25253887e-02f,
  2.30840780e-02f, 9.03808102e-02f, 1.01806164e-01f, 2.36276742e-02f, 1.96301416e-01f, 3.28909382e-02f, -1.18637867e-01f, -2.53831092e-02f, -4.70071360e-02f, 6.29794598e-02f,
  2.74871103e-02f, -1.94240019e-01f, 5.06980941e-02f, -2.52725631e-01f, -5.21463901e-02f, -3.02965231e-02f, -1.21485814e-01f, -8.81235749e-02f, -1.16000473e-01f, -8.06979313e-02f,
  7.74921179e-02f, 2.60499746e-01f, 1.26886249e-01f, 2.48838533e-02f, 9.78289321e-02f, 7.96135440e-02f, 1.13725312e-01f, -9.46034864e-02f, 6.01816289e-02f, 2.80447602e-02f,
  3.47676687e-02f, -1.17862294e-03f, -1.13553926e-01f, 2.08994057e-02f, -4.98919701e-03f, 2.64690593e-02f, -1.31853055e-02f, -7.04347622e-03f, -1.22815082e-02f, 4.42263670e-02f,
  4.74772006e-02f, -5.06801419e-02f, -3.51264998e-02f, -3.17640603e-02f, -1.89458225e-02f, -4.45190892e-02f, -6.72872737e-02f, 2.63494924e-02f, -5.69981374e-02f, 4.62558605e-02f,
  7.18670413e-02f, -5.95629923e-02f, -1.90371782e-01f, -6.87392280e-02f, 4.55680303e-03f, -3.97150889e-02f, -3.20942774e-02f, -1.06513642e-01f, 1.12090809e-02f, 3.36451791e-02f,
  1.01210792e-02f, -1.24600744e-02f, 6.84649646e-02f, 2.77998894e-02f, -5.11376932e-02f, 4.96098362e-02f, -1.33821338e-01f, 1.67445168e-02f, 5.43047115e-02f, 1.66705642e-02f,
  5.27143814e-02f, 1.60811498e-04f, 1.28558517e-01f, 2.69039311e-02f, -7.04573989e-02f, 2.98176743e-02f, -5.18725850e-02f, 3.30419168e-02f, 6.72085211e-02f, -8.88678059e-02f,
  6.70892745e-02f, 1.46939456e-01f, 2.64102463e-02f, -7.43724853e-02f, -4.30093743e-02f, -2.71136444e-02f, 1.23766763e-02f, -1.20284215e-01f, 3.78853977e-02f, 1.21516697e-01f,
  -1.51031455e-02f, -9.66320783e-02f, -7.71178454e-02f, -5.17832153e-02f, -5.86492606e-02f, -3.82164656e-03f, 2.87343916e-02f, -4.86616939e-02f, -1.17483800e-02f, -7.15125119e-03f,
  -4.75414321e-02f, -3.23831150e-03f, -8.57391506e-02f, -1.12025857e-01f, -7.25940391e-02f, -1.65929254e-02f, 3.58857550e-02f, -4.15878110e-02f, -5.58783077e-02f, -2.68523004e-02f,
  -2.51993537e-02f, 3.65636088e-02f, 1.66662455e-01f, -4.97062318e-02f, -5.04906654e-01f, -1.96042910e-01f, -3.06047555e-02f, -3.21549535e-01f, 2.45964434e-02f, 4.21472266e-02f,
  -2.60250717e-01f, 1.92121163e-01f, -1.05892783e-02f, -3.55079137e-02f, 1.75402183e-02f, 1.81175113e-01f, 1.00547440e-01f, 4.13987525e-02f, 8.71183351e-02f, -4.26627323e-02f,
  -1.05738260e-01f, -3.66957635e-01f, 3.71195152e-02f, -3.16026717e-01f, -3.41406882e-01f, -3.87338586e-02f, -1.52241632e-01f, -1.33837655e-01f, -1.26103759e-01f, -1.37782693e-01f,
  -4.06754613e-02f, 8.97233635e-02f, 8.45773965e-02f, 1.23873331e-01f, 4.08514822e-03f, 7.34698251e-02f, 1.15211725e-01f, -5.09191118e-02f, 1.01582021e-01f, 1.20152831e-02f,
  -2.95254756e-02f, -1.23799197e-01f, -9.06001553e-02f, -1.10082300e-02f, -8.27711001e-02f, 1.34580573e-02f, -4.03965712e-02f, 6.08419180e-02f, -9.24689602e-03f, -2.88366731e-02f,
  3.56729776e-02f, -7.76301026e-02f, 1.23727091e-01f, -3.60076241e-02f, -1.38334977e-02f, -7.46170953e-02f, 5.16225770e-02f, -6.01697229e-02f, -8.39766487e-02f, -2.78102122e-02f,
  -1.77030027e-01f, 1.43837750e-01f, 7.90676996e-02f, 9.27767530e-02f, 1.45244654e-02f, -1.46227982e-03f, 2.20702142e-01f, 1.13267645e-01f, 1.25953972e-01f, 1.67656895e-02f,
  -3.82995866e-02f, 7.04806745e-02f, -6.89462060e-03f, 5.80041017e-03f, 6.78719208e-02f, 1.07957482e-01f, 1.32994810e-02f, 2.72827763e-02f, 3.81445885e-02f, 1.46976402e-02f,
  3.68698454e-03f, -1.26911744e-01f, 6.03614300e-02f, -1.37695819e-02f, 1.57299377e-02f, -4.88959998e-02f, 1.54463779e-02f, 3.21038663e-02f, -1.29159745e-02f, -1.36043439e-02f,
  -3.50089632e-02f, 1.05336361e-01f, 2.74584219e-02f, -4.15274277e-02f, 1.01790696e-01f, 1.98632590e-02f, 1.31384075e-01f, -5.86705580e-02f, 6.49805143e-02f, -4.78545465e-02f,
  -4.25662138e-02f, -5.31965531e-02f, -1.22778393e-01f, -2.93521117e-02f, -7.84058422e-02f, -5.50781749e-02f, -3.06390226e-02f, 4.41492461e-02f, -9.44744274e-02f, -3.79775129e-02f,
  -8.41128826e-02f, -8.99951234e-02f, 1.83240939e-02f, -1.31999120e-01f, -4.41562273e-02f, -4.98302728e-02f, 6.86720535e-02f, -4.87145968e-02f, -3.70766185e-02f, 5.88805880e-04f,
  -4.69537735e-01f, 2.33374476e-01f, 2.19287112e-01f, -1.39985085e-01f, -2.03882843e-01f, -2.83204675e-01f, -2.44088918e-01f, 5.74207231e-02f, -1.11124873e-01f, 3.50817405e-02f,
  -9.15458202e-02f, -7.14474171e-02f, 6.05206937e-02f, -2.46078111e-02f, -1.93775564e-01f, 1.48273006e-01f, -2.01482370e-01f, -1.36707798e-01f, 1.69612293e-04f, -5.50985150e-02f,
  -1.40625924e-01f, -1.89689279e-01f, 1.49523094e-01f, 6.99417479e-03f, -1.80190086e-01f, 1.15908101e-01f, 1.33368865e-01f, 7.46536627e-03f, -2.31686179e-02f, -8.97378922e-02f,
  6.59042895e-02f, 8.40160400e-02f, 4.91145328e-02f, 3.31923999e-02f, 1.58827323e-02f, -8.30534846e-02f, -8.73374939e-03f, -2.56081913e-02f, 1.74237136e-02f, -4.61202748e-02f,
  -2.56925859e-02f, -2.79095620e-02f, -9.37835276e-02f, -3.79627571e-02f, -5.56550734e-02f, 7.23372027e-02f, 3.61407436e-02f, 3.47850285e-02f, 4.73099314e-02f, -3.34248208e-02f,
  2.77138781e-03f, 1.04070604e-02f, -5.53244725e-02f, 7.61993974e-03f, -4.60781381e-02f, -5.40105067e-03f, -4.63118143e-02f, 6.65669376e-03f, -5.85553981e-02f, -4.28151749e-02f,
  -3.88497114e-02f, -1.09233283e-01f, -1.14099398e-01f, 9.43433307e-03f, -1.72118545e-02f, 4.64255773e-02f, -5.70025742e-02f, 4.46419045e-02f, 6.50928468e-02f, 8.66334885e-03f,
  2.43337695e-02f, -7.16196075e-02f, 9.45795327e-03f, -4.31330055e-02f, -1.21646322e-01f, -6.92280103e-03f, -3.16299126e-02f, -1.43438885e-02f, -6.26690164e-02f, 4.22854275e-02f,
  -3.46918590e-03f, -2.68058181e-02f, 1.73983350e-02f, 4.64861840e-02f, 3.16666588e-02f, -1.90839898e-02f, -5.85951358e-02f, -1.09774871e-02f, 1.09042607e-01f, -1.34968758e-01f,
  3.85535732e-02f, 5.67341037e-02f, 4.22717445e-02f, -3.67520787e-02f, 4.76528220e-02f, -6.49359450e-02f, -1.26722297e-02f, -4.65817191e-02f, 1.14815608e-02f, -3.45494971e-02f,
  -2.45099533e-02f, 9.98033397e-03f, 1.94195157e-03f, -5.18429130e-02f, 3.83200608e-02f, -1.10614300e-03f, -1.89003926e-02f, -2.62635872e-02f, -2.84855030e-02f, 1.13500301e-02f,
  -3.51391174e-03f, -3.25934254e-02f, -2.28887387e-02f, -1.02951601e-01f, -1.06120139e-01f, -3.75606567e-02f, -3.02279647e-02f, 2.73717102e-02f, 5.64823970e-02f, 4.69601853e-03f,
  -3.25196087e-02f, 7.14509711e-02f, 1.26149952e-01f, 1.41052887e-01f, 1.91548124e-01f, -1.06665112e-01f, -1.20717242e-01f, 4.83969413e-02f, 1.57798398e-02f, -1.21275157e-01f,
  -1.42100438e-01f, 3.23344059e-02f, -6.85351416e-02f, 9.95181426e-02f, -2.30701044e-01f, -4.56969365e-02f, -1.11799024e-01f, -1.64498910e-01f, 1.42346993e-01f, 6.72082156e-02f,
  9.09418762e-02f, 5.24564534e-02f, 1.92684978e-02f, 2.05450892e-01f, 1.42795369e-01f, 1.58400163e-01f, -2.75501639e-01f, 5.14879599e-02f, 8.94998312e-02f, -3.09662540e-02f,
  3.24020721e-02f, 2.17921481e-01f, 8.13767314e-02f, -4.08703648e-02f, -4.68205363e-02f, -1.36361644e-02f, -8.44308585e-02f, -9.53264348e-03f, 2.53741853e-02f, 2.91270390e-02f,
  -5.24501055e-02f, 7.86549672e-02f, 1.49114296e-01f, 9.52336416e-02f, -4.36258353e-02f, 5.40159531e-02f, 1.73624963e-01f, -6.06860183e-02f, 1.58629939e-01f, 8.70660618e-02f,
  9.83023793e-02f, -6.36195065e-03f, -8.83083194e-02f, -9.67508834e-03f, 1.50809055e-02f, 1.40087366e-01f, 1.04486726e-01f, -7.22200423e-02f, -7.50672864e-03f, 8.03274959e-02f,
  -5.39967120e-02f, 4.72619310e-02f, 1.70356870e-01f, -1.06988614e-02f, 8.32338003e-04f, 6.79846853e-03f, 1.63471214e-02f, -1.32125644e-02f, -6.39429316e-02f, -5.32485135e-02f,
  -1.22948207e-01f, 5.20939566e-02f, 4.90836576e-02f, -1.62917003e-02f, 2.24784389e-02f, 4.97779027e-02f, -8.11346769e-02f, -2.07241327e-02f, -6.93907067e-02f, -1.15385227e-01f,
  6.42852485e-02f, -3.98223056e-03f, -9.40647125e-02f, 1.57531612e-02f, -7.47202858e-02f, 3.92326079e-02f, 1.59329444e-01f, 1.25378147e-01f, 2.64622811e-02f, -6.04388751e-02f,
  -2.50088960e-01f, -8.01664442e-02f, -9.99379321e-04f, 2.51640268e-02f, 3.44000082e-03f, -6.28074817e-03f, 1.74730178e-03f, 8.69276673e-02f, -8.48282501e-02f, -4.10155952e-02f,
  -4.51233424e-02f, -6.23162370e-03f, -3.71906459e-02f, -2.46099662e-02f, -1.28476709e-01f, -6.95708767e-03f, 1.12934848e-02f, -1.37444898e-01f, -8.32402706e-02f, 3.53540480e-02f,
  -1.88684203e-02f, 2.44122959e-04f, 8.12645853e-02f, 6.92072734e-02f, -8.99521075e-03f, 3.56087796e-02f, -9.58803892e-02f, -7.59823015e-03f, 1.44581599e-02f, 7.62283476e-03f,
  2.52387464e-01f, 3.44262332e-01f, 3.54416706e-02f, -7.27265850e-02f, -2.18869388e-01f, -4.43188041e-01f, -2.45473310e-01f, -1.30369797e-01f, -1.83255255e-01f, -2.27783732e-02f,
  -1.81476995e-01f, -1.99035630e-02f, 1.43480718e-01f, -1.31883338e-01f, -2.78355300e-01f, -8.23110417e-02f, -2.59546041e-01f, -1.85467005e-01f, 9.82346609e-02f, 6.04802072e-02f,
  2.75560096e-02f, -1.33316696e-01f, -1.18945606e-01f, 1.07726745e-01f, 7.13856816e-02f, 1.45602092e-01f, 7.09268004e-02f, 2.41450910e-02f, -7.75283054e-02f, -1.36251032e-01f,
  7.27161244e-02f, 5.80208860e-02f, 1.13321305e-03f, -9.41432826e-03f, 2.08624895e-03f, 2.16804538e-02f, 9.38830301e-02f, -9.24641415e-02f, -3.36916484e-02f, -1.08706564e-01f,
  1.14354240e-02f, 6.78505599e-02f, -3.46862935e-02f, 1.47792352e-02f, 1.30501226e-01f, 7.05619976e-02f, 7.60450438e-02f, -1.77049972e-02f, 1.07561864e-01f, 1.03506163e-01f,
  -4.20622964e-04f, 9.05171409e-02f, 5.79470359e-02f, 2.04428043e-02f, -3.57190631e-02f, 5.55684902e-02f, 2.43578795e-02f, -9.30141378e-03f, -3.18384520e-03f, 7.45054260e-02f,
  -8.66875798e-02f, 7.29858577e-02f, -2.44565750e-03f, 7.70997815e-03f, -2.78398413e-02f, 1.57482922e-01f, 8.64424706e-02f, -2.51625516e-02f, 5.50405271e-02f, 1.30272329e-01f,
  1.05215520e-01f, 4.75698821e-02f, 1.67679384e-01f, 4.14604368e-03f, 3.37602980e-02f, 1.38948187e-01f, 6.66319728e-02f, 4.01314609e-02f, -2.12100558e-02f, -2.63234582e-02f,
  3.60973664e-02f, 8.81516561e-02f, 9.73156001e-03f, 1.34213313e-01f, -1.55882994e-02f, -7.46092424e-02f, 1.13300569e-02f, -2.11449098e-02f, -3.81496549e-02f, -1.26219809e-01f,
  7.64873698e-02f, -8.14721510e-02f, -6.59828261e-02f, 7.51995668e-02f, 8.86129402e-03f, -9.47813466e-02f, -4.26244177e-02f, -1.24673679e-01f, -1.19185559e-01f, -1.04930349e-01f,
  2.68236436e-02f, -6.31623622e-03f, 6.29799142e-02f, 1.36785194e-01f, 1.48244450e-04f, 9.16590448e-03f, 1.24758683e-01f, -1.08756088e-01f, -7.34027475e-02f, 1.07175678e-01f,
  -3.07378527e-02f, 5.65687679e-02f, -5.81905767e-02f, -5.82743995e-02f, -2.62540188e-02f, 7.14843720e-02f, -1.05171092e-01f, 5.36802597e-02f, 9.57184136e-02f, 1.25685986e-02f,
  -3.01850796e-01f, 2.54499882e-01f, 1.43033653e-01f, -1.12113498e-01f, -2.69392550e-01f, -3.06879193e-01f, -8.93427506e-02f, -1.88941453e-02f, 1.69942230e-01f, 1.27425730e-01f,
  -1.35609686e-01f, 3.90590392e-02f, 1.33007452e-01f, -1.40966609e-01f, -4.99373168e-01f, 2.88391799e-01f, -1.52722910e-01f, 5.06609939e-02f, -3.76197994e-02f, -2.21394315e-01f,
  -1.03148080e-01f, -2.95999706e-01f, -1.12325579e-01f, -8.87856036e-02f, -1.30062476e-01f, 1.04380049e-01f, -2.01627016e-02f, -3.04731317e-02f, -1.53615758e-01f, -1.22188115e-02f,
  -3.11674038e-03f, 4.20790017e-02f, -4.67806049e-02f, -4.94933361e-03f, -9.25480574e-02f, -1.18887536e-01f, -7.65388533e-02f, -2.86392570e-02f, -4.47361507e-02f, 7.63434311e-03f,
  5.33610471e-02f, -9.73169804e-02f, -1.88146103e-02f, -4.21245955e-02f, -5.41812927e-02f, -1.20830294e-02f, -1.26943812e-02f, -4.81419964e-03f, 2.49052141e-02f, -1.81829352e-02f,
  1.14316167e-02f, 4.71928269e-02f, 7.08576962e-02f, 9.17887762e-02f, 1.88373197e-02f, 2.79049221e-02f, 2.08625682e-02f, -2.13724691e-02f, 1.14446983e-01f, -1.22891992e-01f,
  1.77652091e-02f, -2.16128421e-03f, -2.23312178e-03f, 5.60603663e-02f, -1.05146870e-01f, -5.00254370e-02f, 5.83703704e-02f, 3.38461101e-02f, 3.95309031e-02f, 8.24828516e-04f,
  -2.06731111e-02f, -5.70403121e-04f, -3.08729219e-03f, -6.53364062e-02f, -4.45171185e-02f, 1.24311009e-02f, -2.70197401e-03f, 1.32848909e-02f, -5.13346680e-02f, 9.55393258e-03f,
  4.61749248e-02f, -8.29638615e-02f, 4.10652682e-02f, 6.58191741e-02f, 3.11803054e-02f, 9.76010133e-03f, -3.79697494e-02f, -7.00362101e-02f, -6.28413111e-02f, -9.18037593e-02f,
  -8.50103945e-02f, -5.11219017e-02f, -1.78682781e-03f, -9.24613327e-02f, 6.63164705e-02f, -8.71330723e-02f, -3.05114407e-02f, -2.89015938e-02f, -7.90010300e-03f, -1.80660766e-02f,
  -8.15348849e-02f, 9.47596431e-02f, 1.36494478e-02f, -4.63195965e-02f, 5.92775010e-02f, 1.61373499e-03f, 2.59674713e-02f, 1.23953763e-02f, -7.84057155e-02f, -6.23587426e-03f,
  -1.08048143e-02f, 2.07071602e-02f, 1.05895683e-01f, -5.36715686e-02f, 4.11718749e-02f, 3.12389825e-02f, -8.26198384e-02f, -4.84545678e-02f, 6.55948371e-02f, 2.97211930e-02f,
  -3.84889990e-01f, 3.45601797e-01f, 1.70327220e-02f, -3.45533997e-01f, 4.36416827e-02f, -1.73342630e-01f, -1.64102241e-01f, 1.52493432e-01f, -1.48679212e-01f, 3.19125503e-01f,
  -2.43144229e-01f, 6.32331881e-04f, 1.85591411e-02f, -2.50095665e-01f, -4.37884182e-01f, -7.90461153e-02f, -3.19007933e-01f, -1.86393872e-01f, 6.43130345e-03f, -4.89552915e-02f,
  -1.46325633e-01f, -1.36169672e-01f, 4.56652269e-02f, 3.10913086e-01f, -2.23594625e-02f, 2.43265912e-01f, 1.27308577e-01f, 1.78008854e-01f, -1.86788887e-02f, 6.57221079e-02f,
  1.86953004e-02f, -7.19478400e-03f, 8.64166394e-02f, 2.85864826e-02f, -2.56692097e-02f, 2.97733881e-02f, -1.40373306e-02f, -2.79117804e-02f, -8.29928070e-02f, -1.64871775e-02f,
  -2.24979967e-02f, -7.74569660e-02f, -1.86247118e-02f, -4.00746055e-02f, -7.62610883e-02f, -5.83899301e-03f, -4.60979305e-02f, 1.32708540e-02f, -1.36851827e-02f, -4.83487137e-02f,
  -2.03402322e-02f, -5.12331910e-02f, -1.01674728e-01f, -2.53387671e-02f, -7.59560317e-02f, -2.27005733e-03f, -6.42081443e-03f, 6.75467923e-02f, 9.21730883e-03f, 4.82504489e-03f,
  1.29895785e-03f, -5.49066626e-02f, -1.87589023e-02f, 3.87474746e-02f, -2.78782770e-02f, 3.51521149e-02f, -4.83167209e-02f, 2.02505812e-02f, 7.86779448e-02f, -7.53270313e-02f,
  -5.17980419e-02f, -5.12582585e-02f, -3.54854614e-02f, -3.44669297e-02f, -2.73604523e-02f, 8.18067640e-02f, -9.08532238e-04f, 2.07917802e-02f, 5.52158849e-03f, 7.39347637e-02f,
  -5.90188429e-02f, -2.60144547e-02f, 4.88858409e-02f, 2.68267491e-03f, -2.56897453e-02f, -6.53891638e-02f, -7.17328340e-02f, 1.11676287e-02f, 1.06530808e-01f, -1.35148823e-01f,
  -3.40001844e-02f, 6.51182723e-04f, 6.72097802e-02f, 1.19831879e-02f, 5.04071731e-03f, 1.12669608e-02f, -3.63930240e-02f, 3.03390026e-02f, -4.45861444e-02f, 2.26725526e-02f,
  -1.75337866e-02f, -2.73972023e-02f, -9.12827719e-03f, -8.52786354e-04f, -6.99211806e-02f, 5.18315732e-02f, -4.76862453e-02f, -3.72047573e-02f, 3.12345941e-02f, -4.49805036e-02f,
  -6.54145330e-02f, -9.64062959e-02f, -3.99776660e-02f, 4.93669882e-02f, -4.94009107e-02f, -1.79575402e-02f, 5.82532585e-02f, 3.75515013e-03f, -6.98245130e-03f, -2.94151576e-03f,
  -2.27940813e-01f, -2.38092035e-01f, 2.14983225e-01f, 3.54353264e-02f, -4.92519327e-02f, -1.03402240e-02f, 4.24564481e-02f, -4.72383797e-02f, -1.37627095e-01f, -2.96882540e-01f,
  3.88739221e-02f, -8.04155786e-03f, 1.63743064e-01f, -2.22465709e-01f, 4.19989824e-01f, 1.80916324e-01f, -1.88628182e-01f, -1.06893770e-01f, 4.64589782e-02f, 2.14244449e-03f,
  -4.59155664e-02f, -1.90547168e-01f, 1.91442966e-01f, -1.60033271e-01f, -1.65559053e-01f, -6.92013353e-02f, 1.18519306e-01f, 9.33265164e-02f, -7.61159882e-02f, 2.24492699e-02f,
  -1.85911208e-02f, -1.45642415e-01f, -2.39330181e-03f, -4.12387550e-02f, -7.69252554e-02f, -5.69179393e-02f, 1.94429699e-02f, 3.99795212e-02f, 1.24809355e-01f, -1.25731365e-03f,
  -7.18675507e-03f, 7.07940990e-03f, -1.78220779e-01f, -3.60932238e-02f, -9.41030234e-02f, -2.35698335e-02f, 2.85804365e-02f, 6.57311976e-02f, -4.56989519e-02f, -2.94285384e-03f,
  2.53927391e-02f, -4.69255485e-02f, -5.51803922e-03f, -3.65705118e-02f, 1.67545322e-02f, 2.00921465e-02f, -5.37943169e-02f, -3.02951876e-03f, -3.28599662e-03f, -4.48229462e-02f,
  -9.42515135e-02f, -2.58012656e-02f, -4.53239307e-02f, 4.82852086e-02f, 1.61078740e-02f, 2.45637558e-02f, -2.20325403e-02f, 1.81056056e-02f, 4.53324504e-02f, 5.61488457e-02f,
  1.67800561e-01f, -3.76734277e-03f, -4.33582393e-03f, 1.27266422e-02f, 2.11530831e-03f, -1.00091502e-01f, 3.30900028e-02f, 1.07092336e-02f, -7.81567171e-02f, 6.66763633e-02f,
  7.24235401e-02f, -2.13967990e-02f, 4.69826907e-02f, -1.36257457e-02f, 5.19432202e-02f, 8.70169401e-02f, -1.27150491e-01f, 8.30039680e-02f, 4.01291735e-02f, 8.80463347e-02f,
  4.65769470e-02f, 6.94745705e-02f, 3.02400868e-02f, -6.63498715e-02f, 7.36981109e-02f, 3.21740657e-02f, -3.15976180e-02f, -9.48659256e-02f, 8.53611231e-02f, 2.21510865e-02f,
  -2.79294979e-02f, -1.24613363e-02f, 1.02858748e-02f, -1.23474404e-01f, 5.98288812e-02f, 3.12614404e-02f, 3.46936993e-02f, 5.25960140e-02f, 9.47719887e-02f, -2.48640403e-03f,
  3.89737524e-02f, 2.95714606e-02f, 2.17929315e-02f, -1.23881362e-01f, -3.58103141e-02f, 2.34455727e-02f, -1.53507153e-02f, -5.14622517e-02f, -6.08103769e-03f, -2.94955559e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.10262215e-01f, -6.15981743e-02f, -6.90557435e-02f, 2.25345045e-01f, 2.14764044e-01f, 1.43428922e-01f, 2.66916901e-01f, 1.53782949e-01f, 4.00521487e-01f, -4.35062721e-02f,
  2.83508468e-02f, -5.54411896e-02f, -4.92315963e-02f, 7.15057328e-02f, -7.18624592e-02f, -9.15582478e-02f, 2.59357750e-01f, 1.22648448e-01f, 1.48117289e-01f, 1.11282885e-01f,
  2.01987699e-01f, 9.51249748e-02f, -1.78583786e-01f, -1.12349473e-01f, 2.09232569e-01f, -1.17643379e-01f, -3.29942435e-01f, -1.61517084e-01f, -2.06169441e-01f, -9.14998651e-02f,
  4.41098996e-02f, 1.41696066e-01f, -1.53236766e-03f, -5.71452901e-02f, 1.39953285e-01f, 3.39716971e-02f, -1.12566419e-01f, -2.78663598e-02f, 2.07803939e-02f, 8.07715654e-02f,
  -3.16877500e-03f, -9.92635563e-02f, 9.62862894e-02f, -1.31053636e-02f, 1.59379840e-01f, -5.21425018e-03f, 1.84228960e-02f, -2.87128258e-02f, -1.07797086e-01f, 7.06292763e-02f,
  1.29700378e-01f, 6.10136464e-02f, 8.73576701e-02f, -5.89659587e-02f, 4.30209413e-02f, 1.65663660e-02f, 2.17453465e-02f, -1.27544567e-01f, -2.47654691e-02f, 3.19903865e-02f,
  -5.36925159e-02f, 1.03985295e-01f, 1.25301495e-01f, -2.52740420e-02f, 6.13466017e-02f, -1.24487411e-02f, 4.60895821e-02f, -2.15262175e-02f, -6.74356380e-03f, -6.59687677e-03f,
  -5.64531162e-02f, 2.04316173e-02f, 3.96836549e-04f, 1.58345513e-02f, 1.67839557e-01f, 3.33896317e-02f, -6.84989840e-02f, -1.47714838e-02f, 9.76459980e-02f, -1.29591208e-02f,
  -4.82243076e-02f, -2.16072612e-02f, -6.36380687e-02f, -7.58109167e-02f, -3.83676291e-02f, 3.33324522e-02f, 8.67479295e-02f, -2.81528346e-02f, -1.15061581e-01f, 8.34355503e-02f,
  -5.98460697e-02f, -8.78018141e-02f, -6.98254183e-02f, -6.42731339e-02f, -5.38060479e-02f, 8.50013867e-02f, 5.34913354e-02f, 1.27060264e-01f, -1.17187902e-01f, 6.69102073e-02f,
  6.05225414e-02f, 1.31175865e-03f, 6.92884400e-02f, -2.73669492e-02f, -1.64995655e-01f, 6.77816989e-03f, -6.11036196e-02f, -4.30496000e-02f, -8.84039626e-02f, -3.52024697e-02f,
  -5.17124729e-03f, 7.11601451e-02f, 3.53158861e-02f, 1.64206296e-01f, 9.74577814e-02f, -5.15593104e-02f, 2.90937815e-02f, -2.74685933e-03f, -7.24297436e-03f, -2.60971487e-02f,
  1.52168408e-01f, -2.97996640e-01f, 3.38782758e-01f, 6.43462017e-02f, 3.10794741e-01f, -3.01471297e-02f, 1.53320819e-01f, 8.01109988e-03f, 4.71106768e-02f, -4.68116432e-01f,
  -6.96733370e-02f, -2.25969613e-01f, 1.57104909e-01f, -2.04459295e-01f, 3.56064826e-01f, 1.35422096e-01f, -1.29802182e-01f, -1.94873169e-01f, 2.54006684e-01f, 1.95727408e-01f,
  8.07081088e-02f, -2.26627201e-01f, 3.46772850e-01f, -7.31649296e-03f, 1.31874457e-01f, -7.96501487e-02f, -9.71184969e-02f, 1.45753756e-01f, -3.57630670e-01f, -3.30979414e-02f,
  2.65762303e-02f, 5.75852878e-02f, 1.04442239e-01f, -5.03985845e-02f, 7.57665932e-02f, -9.06396955e-02f, -1.16247676e-01f, 5.31265251e-02f, 1.06664523e-01f, 9.97633394e-03f,
  -1.01582155e-01f, -7.08756968e-02f, -1.39532551e-01f, 6.82439730e-02f, 2.80165598e-02f, 3.20573747e-02f, 4.95360047e-02f, 9.56489891e-02f, 9.69325751e-03f, 1.00015402e-01f,
  1.82872459e-01f, -4.78384756e-02f, 1.07167698e-01f, -1.35351449e-01f, 8.68263021e-02f, -2.51147188e-02f, -3.54365930e-02f, -1.07735777e-02f, -5.56681957e-03f, -3.01200543e-02f,
  -9.99409035e-02f, -5.57993390e-02f, 7.50457421e-02f, 3.88247445e-02f, 5.89211844e-02f, -5.74598387e-02f, 1.97828934e-02f, -1.95841137e-02f, 1.77543476e-01f, -6.73266649e-02f,
  4.87235282e-03f, -3.55104059e-02f, 7.28894472e-02f, 1.42847337e-02f, -4.53708544e-02f, -1.09297829e-03f, 9.08645615e-02f, -2.01522908e-03f, 9.12366062e-02f, 9.60659906e-02f,
  -5.53588904e-02f, 9.76947043e-03f, 1.05290487e-01f, 1.73477847e-02f, -1.02913037e-01f, 6.79214448e-02f, -1.13940477e-01f, 3.16869915e-02f, 9.11064669e-02f, 2.18320694e-02f,
  -7.41341636e-02f, -3.01946253e-01f, 3.20602879e-02f, -1.00916132e-01f, 5.86769357e-03f, 1.21045141e-02f, 3.36769521e-02f, -1.20735519e-01f, -1.01613119e-01f, 1.23113722e-01f,
  -1.56910941e-01f, -2.80141030e-02f, -5.04024364e-02f, 9.44061652e-02f, -2.25781160e-03f, -5.35965944e-03f, -1.07266940e-01f, -1.16952918e-01f, 1.72916777e-03f, -1.72084391e-01f,
  -4.27479222e-02f, 1.44095451e-03f, -1.70146115e-02f, -3.33354622e-02f, -1.14894308e-01f, -1.07074730e-01f, 1.01119000e-02f, -5.18449172e-02f, 2.72157905e-03f, -4.53533307e-02f,
  2.56028324e-01f, 3.34015697e-01f, 1.99832976e-01f, 1.06411070e-01f, -1.16747782e-01f, -2.37268940e-01f, -2.81778455e-01f, 1.47030622e-01f, -1.35754243e-01f, -2.56414153e-02f,
  -7.80945942e-02f, -8.56029708e-03f, 1.10565620e-02f, 2.45854348e-01f, 1.35119874e-02f, 1.06992476e-01f, 6.66837618e-02f, -3.37810405e-02f, 1.58812534e-02f, 2.87021846e-01f,
  1.05391786e-01f, 3.01931612e-02f, 2.53620952e-01f, 1.96022183e-01f, 2.24260777e-01f, 2.18604684e-01f, 1.53551325e-01f, 7.51711577e-02f, 3.85987088e-02f, -9.57321897e-02f,
  -4.13797982e-02f, 1.00232095e-01f, 9.99625623e-02f, -4.12221253e-02f, 8.92633796e-02f, -5.93997538e-03f, -9.81277972e-03f, 2.17459425e-02f, -1.16939493e-01f, -4.78816032e-02f,
  4.70587313e-02f, -5.82111105e-02f, 8.52939039e-02f, -2.63566487e-02f, 2.59091333e-02f, -6.48643225e-02f, -2.37457585e-02f, -9.34695229e-02f, -4.44280803e-02f, 2.12965190e-01f,
  9.30142775e-02f, 5.26108369e-02f, 2.55374126e-02f, 2.39403527e-02f, -3.18673886e-02f, -5.49271982e-03f, -6.95395246e-02f, 9.35589075e-02f, 6.30157301e-03f, 5.13111837e-02f,
  1.65928543e-01f, -1.34004742e-01f, -1.41296508e-02f, -5.63277211e-03f, -6.40883297e-02f, -2.62072869e-02f, -1.25608221e-01f, -7.01482818e-02f, 1.60218906e-02f, -2.47393660e-02f,
  -1.12252615e-01f, 4.57831584e-02f, -9.14746225e-02f, -5.80449551e-02f, 5.60563244e-03f, -7.17521608e-02f, 7.67459045e-04f, 4.36663181e-02f, 6.53612316e-02f, 1.82043351e-02f,
  -1.72292188e-01f, -3.14397141e-02f, -1.34920239e-01f, -3.06067169e-02f, -8.57432187e-02f, -8.19661841e-02f, -8.34601447e-02f, 3.76499072e-02f, 1.27892001e-02f, 5.26250489e-02f,
  -1.69054407e-03f, 1.64298356e-01f, -5.19371964e-02f, -1.63455859e-01f, -8.18010326e-03f, 4.36231643e-02f, -1.36705199e-02f, 1.16622224e-01f, -2.68626194e-02f, 3.08790114e-02f,
  3.56712416e-02f, -7.79273137e-02f, -5.05938306e-02f, -1.26602035e-03f, -3.29329036e-02f, -3.72363143e-02f, -1.81091174e-01f, -2.18866616e-01f, -9.84910950e-02f, 1.59063503e-01f,
  1.81665644e-03f, -5.27051911e-02f, -1.41140912e-02f, -7.98663273e-02f, 4.53118384e-02f, -1.61798313e-01f, -8.04580655e-03f, 3.08336783e-02f, 1.23331361e-01f, 2.94372421e-02f,
  -1.92593690e-02f, 2.26622641e-01f, 2.68827409e-01f, 2.65193015e-01f, -1.84881166e-01f, -3.28140497e-01f, -2.07897067e-01f, 8.18341970e-02f, -5.49690053e-02f, -6.30401401e-03f,
  -1.69063106e-01f, 2.94257402e-01f, -2.62785286e-01f, -2.23433375e-02f, -1.72911942e-01f, -3.22734416e-01f, -8.04661401e-03f, -5.44488281e-02f, -2.74676401e-02f, 2.27255121e-01f,
  1.31810442e-01f, -1.94437951e-01f, 1.71781778e-01f, -4.41752635e-02f, 1.09267384e-01f, 2.89104402e-01f, 2.67278820e-01f, -3.14006694e-02f, 3.15325618e-01f, -5.13149723e-02f,
  -1.13927186e-01f, 4.47740033e-02f, 9.99235064e-02f, -7.03402609e-02f, 1.26578704e-01f, 7.11646257e-03f, 4.75685857e-02f, -7.65074193e-02f, -1.15400918e-01f, 2.69242618e-02f,
  8.00754577e-02f, -1.52104190e-02f, -2.48650758e-04f, -4.80129756e-02f, -1.17494306e-03f, 4.41634953e-02f, -6.85530622e-03f, 4.70293276e-02f, -1.03392312e-02f, 1.67781830e-01f,
  1.64782375e-01f, 1.07151248e-01f, 8.65300670e-02f, 8.19920599e-02f, 1.19023986e-01f, 2.88355276e-02f, 5.70893548e-02f, 1.88457444e-01f, 1.69817172e-02f, 9.51394737e-02f,
  8.65455866e-02f, -3.13402377e-02f, -1.49292395e-01f, -9.32241157e-02f, -8.18754807e-02f, -3.75943929e-02f, -5.17402515e-02f, -3.15862484e-02f, -2.17544790e-02f, -1.25094894e-02f,
  2.33641155e-02f, 8.29778425e-03f, -1.29297495e-01f, 6.98782429e-02f, 1.95213184e-02f, -1.13489389e-01f, 7.34778633e-03f, 4.78931181e-02f, 1.50931209e-01f, 5.37640303e-02f,
  -1.49081007e-01f, -1.34157389e-01f, 3.09904478e-02f, -2.06444878e-04f, -2.00735196e-01f, 4.04607952e-02f, -4.60744500e-02f, -5.93455471e-02f, -3.15611884e-02f, 5.57934716e-02f,
  5.19738607e-02f, 1.78556830e-01f, 1.56370103e-01f, -9.48278457e-02f, -4.07373831e-02f, 1.62497144e-02f, -1.04505830e-01f, 3.52616608e-02f, 3.25115137e-02f, -3.92685719e-02f,
  3.83160003e-02f, 5.07433414e-02f, -4.77915071e-02f, 9.59958602e-03f, -1.78242363e-02f, 1.09011225e-01f, -2.78613232e-02f, -3.24330069e-02f, 8.84563178e-02f, 1.26905903e-01f,
  4.33646254e-02f, -5.49050048e-02f, 2.54072738e-03f, -3.26617248e-02f, 2.40749307e-03f, 1.07682265e-01f, -4.90788370e-02f, 1.36848241e-01f, 8.21429342e-02f, 3.94920968e-02f,
  9.65105966e-02f, -3.89319807e-01f, -2.56713063e-01f, -1.58278033e-01f, -1.86665118e-01f, -2.74176031e-01f, -1.10866442e-01f, -3.33998144e-01f, -1.36191204e-01f, -1.21842287e-01f,
  -1.50924593e-01f, 1.15368694e-01f, 2.42123678e-01f, -3.51576835e-01f, 3.34046155e-01f, 2.90007740e-01f, -1.92456514e-01f, -3.09481993e-02f, 6.40970562e-03f, -1.02623917e-01f,
  -7.99152926e-02f, -1.28190979e-01f, -3.77821662e-02f, -2.37686038e-01f, -2.12528676e-01f, -1.62268087e-01f, 1.05570190e-01f, -7.15551302e-02f, -1.64832965e-01f, -1.46163389e-01f,
  -8.20755959e-02f, 1.33741219e-02f, -1.66133940e-02f, 4.30114977e-02f, -4.90009859e-02f, 2.51962505e-02f, 2.83584669e-02f, 8.86513367e-02f, 1.11620829e-01f, 2.74678227e-02f,
  5.02176955e-02f, 1.65439650e-01f, 4.56287265e-02f, 1.13240130e-01f, -1.28542274e-01f, -1.48503393e-01f, 7.24942833e-02f, -6.92603644e-03f, 7.48583535e-03f, -3.30144167e-02f,
  -3.90742831e-02f, -8.42400044e-02f, -8.20394456e-02f, 1.36527404e-01f, 5.60893305e-02f, -1.02044135e-01f, 4.30749916e-02f, 6.94169402e-02f, 9.98253822e-02f, 7.35168606e-02f,
  -6.27606362e-02f, 7.11767972e-02f, 6.68396875e-02f, -4.19757292e-02f, -8.27999320e-03f, -1.18925169e-01f, -1.09627627e-01f, -8.56636614e-02f, -2.40733102e-02f, -4.20211963e-02f,
  2.99697239e-02f, -1.14055797e-01f, -1.62654653e-01f, 9.06903704e-04f, -5.25133349e-02f, 5.01310304e-02f, -3.11586298e-02f, 2.08274461e-02f, -7.47414082e-02f, -6.74473569e-02f,
  2.43394449e-02f, -3.67329195e-02f, 3.49845365e-02f, -5.80558032e-02f, -1.72033727e-01f, 1.20989010e-01f, -5.90261593e-02f, 3.50392982e-02f, -1.02478288e-01f, 1.03374653e-01f,
  -5.57370149e-02f, 4.92870882e-02f, -9.66852829e-02f, 3.07542961e-02f, 1.41138548e-03f, -1.42612197e-02f, -5.24462238e-02f, -8.20320025e-02f, 4.57517989e-03f, 2.29739975e-02f,
  -6.16627112e-02f, 4.82313745e-02f, 5.99931255e-02f, -8.30632448e-02f, -8.66814479e-02f, -1.53127477e-01f, 9.92531776e-02f, 7.36566186e-02f, 6.55697333e-03f, -1.47221580e-01f,
  4.78833131e-02f, 8.38067383e-02f, 1.75827667e-01f, 1.04844943e-01f, 1.20723791e-01f, 1.46526992e-01f, 5.46789542e-03f, -3.64134461e-02f, 1.43773839e-01f, 3.35145891e-02f,
  1.65036708e-01f, -2.26117566e-01f, -4.57590282e-01f, -5.98435216e-02f, 1.53898492e-01f, 3.51466030e-01f, 2.26196513e-01f, -4.50635292e-02f, -2.91376323e-01f, 1.76937610e-01f,
  2.57304221e-01f, -9.60809216e-02f, -2.46014576e-02f, 4.28348005e-01f, 2.05470532e-01f, -7.14148302e-03f, 2.81350881e-01f, 1.65226489e-01f, -1.73902526e-01f, -1.06751531e-01f,
  5.93465716e-02f, 4.40066606e-01f, 8.40811874e-04f, 9.49642342e-03f, 2.19169766e-01f, -2.27727026e-01f, 1.61333665e-01f, -9.06777605e-02f, 2.40252048e-01f, 1.89999729e-01f,
  1.13798559e-01f, -3.36387120e-02f, -9.49310288e-02f, 1.36035178e-02f, -2.77185929e-03f, 7.35354498e-02f, 9.82495099e-02f, 6.56113699e-02f, 1.66668836e-02f, -6.90420158e-03f,
  3.37083451e-02f, 6.74621090e-02f, 1.67523436e-02f, 1.56005472e-03f, 6.44510090e-02f, -4.85110022e-02f, -2.22304296e-02f, -6.54276609e-02f, -7.78551102e-02f, 3.20773534e-02f,
  -8.06304440e-02f, -6.82350695e-02f, 9.33520310e-03f, -8.93997028e-02f, -5.72826639e-02f, -2.89525948e-02f, -3.46022029e-03f, -9.06428993e-02f, -3.84882726e-02f, -6.87639415e-02f,
  3.17278095e-02f, 9.12068710e-02f, 9.58438963e-02f, 6.46540448e-02f, -9.76951793e-03f, 3.68831214e-03f, 1.08554222e-01f, 7.70935370e-03f, -1.30460098e-01f, 2.82416586e-02f,
  -7.10837543e-02f, 4.36996259e-02f, 6.66498169e-02f, 7.31163919e-02f, 1.09239303e-01f, -3.93867344e-02f, 2.92775501e-02f, 6.17389604e-02f, -6.87505454e-02f, -4.40952517e-02f,
  5.35610281e-02f, 8.80662352e-03f, -4.79123853e-02f, 2.42184829e-02f, 4.09752429e-02f, -4.80101146e-02f, 1.39005527e-01f, 1.51813075e-01f, -6.55159056e-02f, 5.91525584e-02f,
  7.13940337e-03f, -1.95520699e-01f, -8.23611841e-02f, 6.20155707e-02f, -2.17522830e-02f, 4.77339737e-02f, 4.64224666e-02f, 4.50922828e-03f, 5.96613856e-03f, -4.82569821e-02f,
  9.80935618e-02f, -4.58337739e-02f, 3.42469700e-02f, -4.33715545e-02f, -6.55504167e-02f, -1.49142249e-02f, 3.06368005e-02f, -2.59140544e-02f, -3.26945372e-02f, 2.73926649e-02f,
  3.96244004e-02f, -4.41177515e-03f, -4.91919592e-02f, 3.40646952e-02f, 2.65360270e-02f, 8.57117772e-02f, 5.07594727e-04f, -6.58182278e-02f, -2.31471788e-02f, -1.45761184e-02f,
  -4.51120734e-01f, 3.88906658e-01f, -6.43161386e-02f, 2.37364128e-01f, -1.74269810e-01f, 2.54149586e-01f, 3.25389057e-01f, 1.85911745e-01f, 3.49810869e-01f, 1.97401568e-01f,
  -3.67801264e-02f, 3.69082056e-02f, 8.26865062e-02f, 2.12280959e-01f, -6.55430257e-02f, 1.72099829e-01f, 1.50296807e-01f, 2.03168705e-01f, 1.71963245e-01f, -6.07233606e-02f,
  -3.28421826e-03f, 7.72301480e-02f, -2.20330566e-01f, 3.21018323e-02f, -9.25130844e-02f, -5.15988991e-02f, -1.67977989e-01f, 6.82448270e-04f, -1.45395538e-02f, 1.17901474e-01f,
  -1.45563647e-01f, -9.93653610e-02f, -2.45165884e-01f, -9.47346538e-02f, -1.65660188e-01f, -8.81129056e-02f, -1.74093805e-02f, -4.16541733e-02f, -3.39265354e-02f, 5.80915548e-02f,
  -2.74445508e-02f, -1.08014673e-01f, 3.26388478e-02f, 1.95325874e-02f, 7.26270229e-02f, -3.70356962e-02f, -9.33272690e-02f, -2.08106153e-02f, -5.93504421e-02f, 5.30145946e-04f,
  -3.25851776e-02f, -2.99903397e-02f, 5.60749140e-05f, 8.73520821e-02f, -7.20569119e-02f, 2.82879807e-02f, 5.04134931e-02f, 4.06127460e-02f, 2.05670353e-02f, 4.50417139e-02f,
  2.68446356e-02f, 8.59653801e-02f, -7.45349750e-02f, -2.22923588e-02f, -4.27556001e-02f, -9.61420611e-02f, 1.23024909e-02f, -7.95182437e-02f, -1.90581344e-02f, -1.32770553e-01f,
  -2.32997686e-02f, -8.57166573e-02f, -3.02492436e-02f, -7.00514168e-02f, 6.22856580e-02f, 8.43286663e-02f, -1.95863079e-02f, -1.13691658e-01f, 1.15505874e-03f, -1.36012465e-01f,
  1.37030885e-01f, 6.95075020e-02f, -6.80608228e-02f, -6.76125735e-02f, 3.57347913e-02f, 5.52345663e-02f, 3.60210910e-02f, -2.53132526e-02f, -6.54144436e-02f, -1.12859719e-01f,
  1.12115398e-01f, 1.89189956e-01f, -8.90995562e-02f, -1.30775228e-01f, 1.02880877e-02f, -1.28221484e-02f, 1.16320373e-02f, -1.52468517e-01f, 1.26654282e-01f, 5.84708229e-02f,
  -9.58234146e-02f, -8.96326359e-03f, -5.01473844e-02f, -4.73177206e-04f, 5.77910841e-02f, 6.41524568e-02f, 2.37641614e-02f, 9.18384362e-03f, -9.69302934e-03f, -1.68163143e-02f,
  -1.29828885e-01f, -1.06564816e-02f, -3.33897099e-02f, -4.97908071e-02f, -1.42414019e-01f, -1.41105995e-01f, 7.44893700e-02f, -3.62481773e-02f, -2.93176193e-02f, 4.60765027e-02f,
  6.11458942e-02f, -1.84565902e-01f, -2.98858583e-02f, -3.05818230e-01f, -5.88437580e-02f, 1.22836083e-01f, -2.66258091e-01f, -5.80938533e-02f, -1.85304403e-01f, 4.71635163e-02f,
  -2.36279204e-01f, -1.56169996e-01f, -1.20181352e-01f, -2.88794041e-01f, 1.66851416e-01f, -5.93518652e-02f, -1.24572285e-01f, -2.44904175e-01f, -2.01764822e-01f, -3.11486483e-01f,
  -2.99262166e-01f, -2.90707916e-01f, -1.80591539e-01f, -5.54900318e-02f, -2.39849463e-01f, -7.22598238e-03f, 1.58545092e-01f, -2.51447529e-01f, -1.65803894e-01f, -8.25378671e-02f,
  -3.91106308e-02f, -1.03992008e-01f, -2.70812046e-02f, -3.06243654e-02f, 5.81499599e-02f, 2.25785896e-02f, -1.66648850e-02f, -1.05357595e-01f, -1.05932847e-01f, -6.14480041e-02f,
  -4.54920519e-04f, -9.07930732e-02f, -4.00279509e-03f, -1.27845451e-01f, -1.31612688e-01f, -5.50413765e-02f, -4.48577590e-02f, 8.65693465e-02f, -3.10544893e-02f, -7.21919490e-03f,
  -7.19707385e-02f, 6.57468438e-02f, 2.47201547e-02f, 8.01859796e-03f, -4.65842374e-02f, -3.60082164e-02f, 1.09496392e-01f, -7.71166245e-03f, 1.41366227e-02f, 1.84706777e-01f,
  3.47858742e-02f, 9.50696506e-03f, 2.28918046e-02f, -1.10371768e-01f, 6.54396927e-03f, -2.50112563e-02f, -6.43523857e-02f, -4.38866951e-02f, 7.94554949e-02f, -4.83354032e-02f,
  -1.46799181e-02f, -9.63980034e-02f, -1.11385271e-01f, -6.53601065e-02f, 1.79501344e-02f, 1.65508419e-01f, -3.43411416e-02f, -4.35954444e-02f, -1.26330271e-01f, 1.58430532e-01f,
  -1.37641355e-01f, -1.48816779e-02f, -2.92764809e-02f, -5.48657263e-03f, -1.90566275e-02f, -5.48729859e-03f, -2.42986958e-02f, -4.32619452e-02f, 1.56999364e-01f, -5.33936583e-02f,
  7.78025538e-02f, 1.41240895e-01f, -1.22530214e-01f, -1.46852911e-01f, -5.92716485e-02f, 5.08970693e-02f, -4.26927656e-02f, -4.52710167e-02f, -1.58768818e-02f, 8.54669586e-02f,
  -5.44200465e-02f, -1.33759588e-01f, 1.75133094e-01f, -4.86102179e-02f, -1.03988379e-01f, 5.89144789e-02f, -9.53622758e-02f, -1.99809615e-02f, 6.80909455e-02f, 3.01164687e-02f,
  -1.26279611e-02f, 2.64405515e-02f, -8.49078409e-03f, 3.86070125e-02f, -2.76322328e-02f, 2.25941613e-02f, 1.65651962e-01f, -1.00348011e-01f, -4.05596234e-02f, -1.06146568e-02f,
  4.28765006e-02f, -3.27407718e-02f, 3.14117849e-01f, -2.15086006e-02f, 2.58792996e-01f, 2.95568287e-01f, 1.19180754e-01f, 2.54255295e-01f, 3.85908872e-01f, -3.26526821e-01f,
  -2.48276055e-01f, -2.38781258e-01f, 2.87326351e-02f, -2.27871478e-01f, 2.61621088e-01f, 2.17680275e-01f, 1.11226074e-01f, -3.11446041e-02f, 1.80779561e-01f, -1.62956551e-01f,
  1.85253739e-01f, -2.46366009e-01f, -2.53500640e-02f, -1.16259098e-01f, -1.55022755e-01f, -2.75771171e-02f, -3.04487318e-01f, 4.97302040e-03f, -2.27779776e-01f, 9.80692878e-02f,
  -1.09840907e-01f, -5.89515083e-02f, -2.22226679e-01f, -8.92943442e-02f, -4.73620510e-03f, -1.85907073e-02f, -4.49647754e-03f, 5.98624088e-02f, 4.59873304e-02f, 1.27231539e-03f,
  -1.02188606e-02f, 3.47683951e-02f, -9.97581333e-02f, -4.62880544e-02f, 7.21061155e-02f, 3.30279693e-02f, 5.40175401e-02f, -6.21017553e-02f, -4.66451049e-02f, 1.74142390e-01f,
  1.30500020e-02f, -2.52747955e-03f, 5.69570512e-02f, 7.43527636e-02f, 5.61872870e-02f, -7.98535571e-02f, 7.54759759e-02f, 4.01949808e-02f, -1.37269488e-02f, -5.83547838e-02f,
  1.78618431e-01f, 1.83048069e-01f, -1.05804145e-01f, -4.23658006e-02f, -9.75733623e-02f, -1.37763266e-02f, 1.71924010e-02f, -6.88754544e-02f, -4.50000213e-03f, -1.30594550e-02f,
  -5.37506416e-02f, -8.95925686e-02f, 1.27876714e-01f, 6.12665489e-02f, -2.31537316e-02f, 5.82103059e-02f, -1.77752059e-02f, 2.71750484e-02f, -4.22028750e-02f, -7.25284815e-02f,
  2.14278325e-02f, 6.36369064e-02f, -6.83847368e-02f, 5.16786464e-02f, 6.31347671e-02f, -1.34451194e-02f, -1.54675860e-02f, 1.44494027e-01f, -4.48058620e-02f, -9.20655578e-02f,
  -1.64129272e-01f, -1.55184165e-01f, -9.90256444e-02f, -1.88298985e-01f, 3.23918252e-03f, -8.32246691e-02f, 4.55491021e-02f, 1.14662796e-02f, 1.24651939e-02f, 2.60530896e-02f,
  3.23656313e-02f, -1.90218948e-02f, -1.40844628e-01f, 6.27777120e-03f, -1.54301040e-02f, 1.47214411e-02f, -2.01633964e-02f, -9.19928849e-02f, -8.75603557e-02f, 3.43071595e-02f,
  -9.92937014e-02f, -6.53300136e-02f, 3.12782787e-02f, -3.81601900e-02f, -3.52967530e-02f, -8.25132132e-02f, -5.99598214e-02f, 2.37065624e-03f, 5.77812493e-02f, -5.60168810e-02f,
  -5.63727282e-02f, 3.43037516e-01f, -2.55157631e-02f, -1.41906738e-01f, -1.08979940e-01f, -5.10283887e-01f, -1.69564545e-01f, -5.26021309e-02f, 2.06233039e-01f, 1.80057943e-01f,
  -8.50375649e-03f, 3.06659311e-01f, 3.89649235e-02f, -1.05663771e-02f, -3.64526719e-01f, 6.98845163e-02f, -2.50952482e-01f, 2.22296733e-02f, 2.36610640e-02f, -1.06547058e-01f,
  -6.69511110e-02f, -1.60061598e-01f, -1.38882175e-01f, -1.20474674e-01f, -1.00233339e-01f, 4.99592759e-02f, -1.78095132e-01f, -1.45289004e-02f, -1.06437095e-01f, 4.18997742e-02f,
  -1.48468405e-01f, 6.82190284e-02f, 3.56064662e-02f, -1.30744055e-02f, -8.62231106e-02f, -1.51534313e-02f, -2.82078274e-02f, 6.88529713e-03f, -7.70692602e-02f, -9.73948240e-02f,
  4.41599404e-03f, 1.40431421e-02f, -1.28485877e-02f, 2.52412952e-04f, -1.05083123e-01f, -2.74332631e-02f, -6.24796201e-04f, -1.09664261e-01f, -7.27156596e-03f, 1.77628808e-02f,
  6.78504109e-02f, 1.93392299e-03f, -1.20174229e-01f, 3.19877006e-02f, -6.66835159e-02f, -6.38777688e-02f, -7.82261193e-02f, -2.46827714e-02f, -1.84084158e-02f, -7.03498051e-02f,
  3.12510319e-02f, -5.74334823e-02f, -5.33262491e-02f, 4.14727591e-02f, -4.88023050e-02f, 9.83581617e-02f, 1.60515495e-02f, 1.01152182e-01f, -5.17796241e-02f, -8.91828015e-02f,
  -1.48037933e-02f, 7.87005797e-02f, -2.77461447e-02f, -1.37306049e-01f, 5.29371342e-03f, -1.79537535e-02f, -4.34972085e-02f, 1.11854384e-02f, 1.97539218e-02f, -4.68369983e-02f,
  -8.87253496e-04f, -8.58373493e-02f, 4.35148068e-02f, 3.92278843e-02f, -5.52687123e-02f, 1.28365941e-02f, 5.85488565e-02f, 2.61832271e-02f, -6.27708957e-02f, -8.52066055e-02f,
  -3.58712763e-01f, -2.40954578e-01f, -4.69014458e-02f, 7.83764645e-02f, -3.61899137e-02f, -9.01896209e-02f, 7.61167780e-02f, -4.11377475e-02f, -1.12671807e-01f, -1.30039558e-01f,
  -3.12610455e-02f, -3.42942844e-03f, -1.09255254e-01f, -6.52622757e-03f, -7.28894621e-02f, -1.45010933e-01f, -4.15527560e-02f, -3.96956988e-02f, -1.83527201e-01f, -3.64768319e-02f,
  2.43431069e-02f, 3.51947248e-02f, 8.90908111e-03f, -7.72931427e-02f, -5.18475100e-02f, -3.49370912e-02f, 3.27123143e-02f, 7.48166144e-02f, -5.56845143e-02f, 2.72364393e-02f,
  2.75394142e-01f, -2.23445110e-02f, -6.27410039e-02f, -5.54173999e-02f, 1.46754850e-02f, -6.82806745e-02f, -1.24673001e-01f, -7.11131990e-02f, -2.68524319e-01f, -6.63940758e-02f,
  -6.12267256e-02f, 9.36891511e-02f, 1.53446011e-02f, 2.62524873e-01f, 3.50261539e-01f, 9.61059779e-02f, 5.44811077e-02f, -1.28230467e-01f, -4.41144258e-02f, 5.38435318e-02f,
  8.22183341e-02f, 1.73642203e-01f, 2.55705595e-01f, 2.28957817e-01f, 9.53354090e-02f, 2.38432176e-02f, 2.99855262e-01f, 1.22246973e-01f, 8.50236788e-02f, 1.56935051e-01f,
  -5.12096938e-03f, 5.78998029e-02f, 5.14937080e-02f, -1.36054516e-01f, 1.25602335e-01f, 4.96055707e-02f, 5.45140281e-02f, 6.07537478e-02f, -1.52056247e-01f, -5.41379973e-02f,
  -2.74385940e-02f, -1.39614955e-01f, -4.26860061e-03f, 8.78413543e-02f, -1.44502208e-01f, -1.47198111e-01f, -8.91418457e-02f, -1.15446538e-01f, -1.77939177e-01f, 1.69361383e-01f,
  -7.55325481e-02f, -1.57572940e-01f, -7.03400299e-02f, -7.57189691e-02f, -8.29207450e-02f, -1.22224800e-01f, 2.51014847e-02f, -2.25597178e-03f, -1.27393931e-01f, 7.66739100e-02f,
  1.16005003e-01f, -3.39535624e-02f, -5.96819408e-02f, -1.07898220e-01f, -1.38565116e-02f, -1.51850283e-02f, -2.19040643e-02f, -4.38996479e-02f, 3.72037217e-02f, 1.29380450e-02f,
  -1.69510230e-01f, 7.61322975e-02f, -1.06255405e-01f, -1.20327190e-01f, 8.61063972e-02f, 1.11055359e-01f, 6.99282363e-02f, 7.43338242e-02f, -4.35809381e-02f, 1.77306850e-02f,
  -3.01062502e-02f, -6.53175041e-02f, -5.41759878e-02f, -1.48673072e-01f, -1.42130494e-01f, -3.70353423e-02f, -2.86468230e-02f, 5.08547463e-02f, 4.45720553e-02f, 8.81119370e-02f,
  7.01128924e-03f, 1.91053748e-01f, -1.06045632e-02f, -1.48915455e-01f, 4.50020703e-03f, 1.40759751e-01f, 4.22358178e-02f, 2.99423803e-02f, -4.77298647e-02f, 1.16053782e-01f,
  2.17419099e-02f, -1.40993476e-01f, -5.87597452e-02f, 8.57011357e-04f, -1.77963749e-01f, 5.08469641e-02f, -1.90657321e-02f, -1.73099786e-01f, -7.96734542e-02f, 8.37897360e-02f,
  -4.46172506e-02f, -1.64300844e-01f, 1.02441059e-02f, -7.37576410e-02f, -4.18280214e-02f, -8.75102282e-02f, 1.37354076e-01f, 3.88196781e-02f, -5.23470230e-02f, 1.28038665e-02f,
  9.63807553e-02f, 3.72325301e-01f, 1.47289589e-01f, 2.12701038e-01f, 5.58618829e-03f, -4.81856614e-01f, -1.47401884e-01f, 3.43654156e-02f, 2.54863411e-01f, 1.34664670e-01f,
  -5.57374563e-07f, 2.69895256e-01f, -3.76450433e-03f, 2.48050205e-02f, -4.45007741e-01f, -2.51635779e-02f, -3.60617340e-01f, -6.25829846e-02f, 1.34276614e-01f, -4.72165160e-02f,
  -7.59557113e-02f, -1.56482682e-01f, -2.10409105e-01f, -2.67151501e-02f, 9.15352162e-03f, 2.11199582e-01f, -2.62961775e-01f, 4.88098599e-02f, -1.02687359e-01f, -1.62442267e-01f,
  -1.06776565e-01f, 3.45110565e-01f, 1.47977307e-01f, -3.98496501e-02f, -1.66640058e-01f, -1.10587850e-01f, -9.53074470e-02f, -1.48493433e-02f, 3.74014080e-02f, 7.98761472e-03f,
  3.22775841e-02f, 7.25102127e-02f, -5.11359498e-02f, 7.93338120e-02f, 6.46061301e-02f, 5.98188341e-02f, 5.44367693e-02f, 1.17771188e-02f, 1.59841850e-02f, 1.00437533e-02f,
  6.61017299e-02f, 7.03869900e-03f, -1.00651510e-01f, -6.54656217e-02f, -4.66791494e-03f, 1.31487682e-01f, -2.24204808e-01f, -8.77709314e-02f, -8.34866762e-02f, 3.81786563e-02f,
  1.83656514e-01f, -1.39537618e-01f, -9.73441824e-02f, 4.91806939e-02f, -6.53735641e-03f, -3.58751300e-03f, -3.96194197e-02f, -1.06620081e-01f, 5.15948199e-02f, -4.38283943e-02f,
  -3.47341560e-02f, 1.76623344e-01f, 6.05712198e-02f, 2.14639343e-02f, -6.03584908e-02f, -2.83330726e-03f, -4.65646572e-02f, 5.94748333e-02f, -1.56431183e-01f, 7.33658820e-02f,
  6.62190840e-02f, -2.13166416e-01f, 8.63073673e-03f, -1.24479368e-01f, -1.01812407e-01f, 1.51718095e-01f, -5.03945090e-02f, -1.00946845e-02f, -2.81382781e-02f, -1.39646560e-01f,
  -3.98347586e-01f, -8.26172978e-02f, 1.42922867e-02f, 2.11594366e-02f, 3.35204042e-02f, -7.74803162e-02f, 3.64302881e-02f, -2.76859403e-02f, 1.16562303e-02f, -1.40032368e-02f,
  -9.96145308e-02f, -7.94620365e-02f, -1.30905077e-01f, 2.48068618e-03f, -3.66237238e-02f, -1.35070784e-02f, 5.96811585e-02f, -5.63938767e-02f, -1.53938770e-01f, -6.12199455e-02f,
  4.20980761e-03f, 7.25856647e-02f, -8.00059214e-02f, -5.19036464e-02f, -6.98535219e-02f, -6.03034869e-02f, -1.31681310e-02f, 7.01857358e-02f, -1.87791530e-02f, 2.35289466e-02f,
  -2.98504859e-01f, 4.29464608e-01f, -1.91163719e-01f, 1.38849139e-01f, -9.32238922e-02f, 2.12943643e-01f, 1.84086561e-01f, 2.41668478e-01f, 8.20056498e-02f, 3.45602661e-01f,
  3.23348612e-01f, 5.22082299e-02f, 3.01686823e-01f, 3.40592742e-01f, 4.90499847e-02f, 2.99494296e-01f, 3.15880805e-01f, 1.06997102e-01f, 8.76988471e-02f, 1.07911430e-01f,
  1.10187128e-01f, 3.85330379e-01f, 1.64921850e-01f, 1.33896083e-01f, 1.50624275e-01f, -1.00290887e-01f, -4.43999656e-02f, -6.84495717e-02f, 4.55837883e-02f, 1.44883230e-01f,
  -8.57080426e-03f, 1.22661330e-01f, -1.64331585e-01f, -1.00736320e-01f, -6.53084666e-02f, -1.44651458e-01f, -9.74429995e-02f, -4.49783057e-02f, -1.25539079e-01f, 6.89429268e-02f,
  6.31889626e-02f, -1.27864338e-03f, 1.02088869e-01f, -3.28782164e-02f, -8.34102370e-03f, -9.50127319e-02f, 8.83056447e-02f, -1.94390174e-02f, 7.40238205e-02f, 9.05734301e-02f,
  3.22444402e-02f, 8.21686070e-03f, -3.61640602e-02f, 1.47428304e-01f, 7.46029839e-02f, 1.08656242e-01f, 7.00938553e-02f, 5.30059170e-03f, 7.35681504e-02f, 2.00498831e-02f,
  6.61261007e-02f, -4.76643397e-03f, 2.28648148e-02f, -7.62794986e-02f, 8.94413143e-03f, -2.94801258e-02f, 1.37449279e-02f, -6.22755252e-02f, -5.32095730e-02f, 2.94169597e-02f,
  -9.60031748e-02f, 3.44728269e-02f, -2.62506772e-02f, -5.46613745e-02f, 1.87692225e-01f, -7.26917898e-03f, -4.23901193e-02f, 5.39225340e-02f, -9.97452065e-03f, -5.08579165e-02f,
  2.22780686e-02f, 2.78093424e-02f, -3.01723778e-02f, -1.40831731e-02f, 3.62921245e-02f, 3.92768234e-02f, 1.09831728e-01f, 1.34415150e-01f, -6.92842826e-02f, 6.97759772e-03f,
  2.29857519e-01f, 3.56930494e-01f, 9.26584676e-02f, 2.43654251e-02f, -5.34885898e-02f, -2.27794666e-02f, 2.61469800e-02f, 4.72795144e-02f, 8.71075913e-02f, 4.03712690e-03f,
  2.00312529e-02f, -1.18812643e-01f, -9.26149711e-02f, -1.53202564e-01f, -2.85666306e-02f, 1.08336315e-01f, 7.06097558e-02f, -9.96934175e-02f, 4.15820070e-02f, 1.49393752e-01f,
  8.50583687e-02f, 2.38847993e-02f, -5.50915971e-02f, 4.92226332e-02f, 5.11935875e-02f, 1.13335758e-01f, -2.85294428e-02f, -5.88604156e-03f, 5.92719428e-02f, 3.06374021e-02f,
  -9.89933535e-02f, 6.72286823e-02f, -1.59005582e-01f, 3.54277492e-01f, -3.01363468e-01f, 1.87806055e-01f, 3.37759882e-01f, -7.60019645e-02f, 3.20886672e-01f, 2.44556710e-01f,
  2.90903181e-01f, -5.40796742e-02f, 2.13744700e-01f, 4.31646883e-01f, -1.30774334e-01f, 3.32577676e-01f, 3.71288389e-01f, 3.00198078e-01f, 6.08584397e-02f, 1.65333182e-01f,
  5.62022068e-02f, 2.86248595e-01f, -8.25817958e-02f, -1.78736478e-01f, -3.10886204e-02f, -2.11117163e-01f, -2.31644541e-01f, -1.87076777e-01f, 3.46849076e-02f, -1.76102117e-01f,
  2.82369144e-02f, 6.93023354e-02f, -8.28080177e-02f, -3.94855626e-02f, 3.36276367e-02f, -5.69456350e-03f, -4.21751775e-02f, -1.23359606e-01f, -2.65063699e-02f, 3.23282704e-02f,
  9.13423821e-02f, 6.80820877e-03f, 9.80904549e-02f, -8.60854164e-02f, -9.94512066e-03f, -5.53331226e-02f, 7.00579882e-02f, -1.03867732e-01f, -2.06272773e-04f, -7.71092996e-02f,
  4.44115251e-02f, -1.95441693e-02f, 5.12007996e-02f, 2.83647906e-02f, -6.77207336e-02f, 4.79936264e-02f, 5.52447140e-02f, -9.16959494e-02f, -1.34172495e-02f, -6.27918839e-02f,
  -6.09782971e-02f, 1.26074404e-01f, 4.70415875e-02f, -1.65115744e-02f, 1.27356465e-03f, -4.91958596e-02f, 7.58928806e-02f, 8.39889701e-03f, -2.74901837e-02f, 7.84278363e-02f,
  2.86415257e-02f, 3.35953594e-03f, 3.14894952e-02f, -4.17222083e-03f, 9.65353027e-02f, 3.27837770e-03f, -9.85608771e-02f, 2.26848070e-02f, 2.02174652e-02f, -1.17886893e-01f,
  4.52177133e-03f, 7.53755271e-02f, -3.10477912e-02f, -4.94055785e-02f, 6.86717257e-02f, -3.88955660e-02f, 1.69226795e-01f, -4.56069335e-02f, -6.67507015e-03f, -3.02829724e-02f,
  1.34586692e-01f, 1.09509431e-01f, 8.47055539e-02f, 3.71767581e-02f, 3.27056721e-02f, -3.09100542e-02f, 4.64650132e-02f, -6.13518395e-02f, -5.56235351e-02f, -4.13552709e-02f,
  1.32592348e-02f, 1.10246263e-01f, 5.89779280e-02f, -6.22795932e-02f, 4.25707810e-02f, -4.32090983e-02f, 1.97575539e-01f, -2.88655888e-02f, -3.57338525e-02f, -3.71391885e-02f,
  -2.06233584e-03f, 7.21463263e-02f, 3.94634232e-02f, -2.41767112e-02f, 2.65591294e-02f, 3.76440696e-02f, -3.88130099e-02f, -5.43869138e-02f, -2.70275697e-02f, 4.19540852e-02f,
  -3.43453400e-02f, 7.08988234e-02f, 1.74831063e-01f, 1.53228734e-02f, -2.88908958e-01f, -6.08798815e-03f, 2.21502379e-01f, -2.38883510e-01f, -8.77880007e-02f, 8.06213394e-02f,
  -2.32836455e-01f, 2.59875178e-01f, 4.03093882e-02f, -2.28745192e-02f, -9.94460136e-02f, 1.75688475e-01f, 6.41745403e-02f, 2.29173616e-01f, -2.06595451e-01f, -5.77426404e-02f,
  -5.23562282e-02f, -2.09639952e-01f, 1.39662385e-01f, -2.52656400e-01f, -9.90585834e-02f, -1.99125838e-02f, -1.53076857e-01f, -9.68565717e-02f, 1.71377603e-02f, -6.20507896e-02f,
  -1.16573289e-01f, -2.01434910e-01f, 6.10022992e-02f, -1.09789120e-02f, -7.37583637e-02f, 1.17747821e-01f, 1.63808480e-01f, 9.80943441e-02f, -5.59034236e-02f, -3.87413129e-02f,
  1.05445862e-01f, -8.74208733e-02f, -9.82425883e-02f, -1.92914568e-02f, 3.15078609e-02f, 1.09102344e-02f, 1.75519325e-02f, -2.48974282e-02f, 5.23252860e-02f, 4.31630351e-02f,
  7.17021823e-02f, -2.16148905e-02f, -3.08792870e-02f, 9.10913050e-02f, 5.99305816e-02f, -8.63276049e-02f, 1.84175313e-01f, 2.43092775e-01f, 5.91159575e-02f, -1.37431100e-01f,
  5.55971786e-02f, 3.71471979e-02f, 2.05592886e-02f, -6.06774837e-02f, -1.25028282e-01f, -1.14950843e-01f, 6.15500174e-02f, 7.90105853e-03f, 7.56000131e-02f, 6.85758307e-04f,
  -1.24500044e-01f, 1.35279214e-02f, -4.38147634e-02f, 7.24184588e-02f, -2.67569963e-02f, 8.03606957e-02f, 5.24969175e-02f, -2.77877506e-02f, -8.84496421e-02f, -1.02359198e-01f,
  5.97535223e-02f, 4.03221697e-02f, 5.84384277e-02f, 1.01982191e-01f, -1.00696553e-02f, 1.32875517e-01f, 6.28840998e-02f, 1.23599283e-01f, -1.92955479e-01f, -4.42073643e-02f,
  -1.85661584e-01f, -2.05988318e-01f, -5.06419763e-02f, -9.29825231e-02f, 4.28315327e-02f, 3.01074143e-03f, 5.52538559e-02f, 3.55236344e-02f, -4.23969664e-02f, -3.08641288e-02f,
  -3.03021236e-03f, 1.66444257e-01f, -9.53296025e-04f, 1.57954525e-02f, 5.56992069e-02f, 9.77031887e-03f, 1.78492337e-01f, -1.02324836e-01f, 3.46149728e-02f, -1.13232590e-01f,
  -3.11274570e-03f, -1.83975734e-02f, -4.85543162e-02f, -2.12281011e-03f, 9.73077565e-02f, -5.91509454e-02f, 5.41161634e-02f, 7.18998685e-02f, 6.01593815e-02f, 8.83287191e-02f,
  2.49940366e-01f, 1.03436634e-01f, -7.85352439e-02f, -7.51060024e-02f, 2.51957085e-02f, 2.06522439e-02f, -1.17241517e-01f, 7.38118310e-03f, -1.96915284e-01f, 6.78640674e-04f,
  1.85102716e-01f, -2.52694637e-01f, 9.10273492e-02f, 3.30302924e-01f, 3.63641605e-02f, 2.41015971e-01f, 1.08744346e-01f, -4.23152521e-02f, 1.74353394e-04f, 2.62516916e-01f,
  5.01893759e-02f, 3.15890074e-01f, 2.12433562e-01f, 1.94188580e-01f, 1.84905902e-01f, -1.18552661e-02f, 5.84891886e-02f, 1.53325582e-02f, 8.60148109e-03f, -2.03189813e-02f,
  1.09403916e-01f, 1.66881114e-01f, 1.27462044e-01f, -1.30730182e-01f, 1.80251434e-01f, 1.61898315e-01f, -5.74162863e-02f, -1.30049497e-01f, -2.28456929e-01f, -6.92983642e-02f,
  -1.61114052e-01f, -1.53102025e-01f, 2.78792530e-02f, 6.26754016e-02f, 6.13412298e-02f, -9.34720784e-02f, 5.89939021e-02f, -1.15836114e-01f, -1.51863351e-01f, 1.73414454e-01f,
  3.71696800e-02f, -8.71799514e-02f, -8.63147378e-02f, -8.51239562e-02f, -8.27796161e-02f, -2.43591219e-02f, -3.02824210e-02f, 7.27848010e-03f, -2.71298364e-02f, -7.59038851e-02f,
  7.53400847e-02f, -3.02237980e-02f, 1.76333696e-01f, -1.90534461e-02f, 9.61084105e-03f, 1.42588941e-02f, -1.12087213e-01f, 8.05204455e-03f, -7.66086653e-02f, 6.80025443e-02f,
  -2.05092907e-01f, -3.88317741e-03f, 4.35363837e-02f, -2.77332980e-02f, 4.51449901e-02f, -4.98876348e-02f, -6.06466904e-02f, -5.13912039e-03f, 3.91946398e-02f, -3.84739935e-02f,
  -5.66049814e-02f, 8.88658967e-03f, -2.60856170e-02f, -1.13206066e-01f, -1.52927665e-02f, -4.93930988e-02f, 1.56941280e-01f, 8.86681899e-02f, -7.94392824e-03f, 4.62469608e-02f,
  3.41035612e-02f, 1.35678664e-01f, 7.84264058e-02f, -1.36253804e-01f, 1.94941070e-02f, 1.93771750e-01f, 4.99846078e-02f, 1.60500146e-02f, -1.39137849e-01f, 6.83579817e-02f,
  -4.87833843e-02f, -1.27327234e-01f, -3.57672274e-02f, 5.23326583e-02f, -7.97195360e-02f, 8.62870961e-02f, -1.37385413e-01f, -2.24496335e-01f, -2.20901832e-01f, 1.04296230e-01f,
  -1.53117543e-02f, -3.52908000e-02f, -1.13775730e-01f, -3.29095386e-02f, -3.91691737e-02f, -8.97217244e-02f, 2.44740173e-02f, 1.44480020e-02f, 4.66647074e-02f, -2.85398588e-02f,
  2.75071412e-02f, 2.73062736e-01f, 2.39706293e-01f, 2.00428516e-01f, -3.80807281e-01f, 1.23952972e-02f, 2.32738748e-01f, -1.06623443e-02f, 1.32105932e-01f, 7.92387202e-02f,
  -1.80237845e-01f, 2.50607669e-01f, 8.99619460e-02f, -7.27638528e-02f, -7.77837187e-02f, 1.94490463e-01f, 2.24387929e-01f, 2.25111187e-01f, -3.04702986e-02f, 9.56998020e-02f,
  1.10239007e-01f, -5.00679389e-02f, -3.03794667e-02f, -1.22182302e-01f, 4.46382985e-02f, 5.48706427e-02f, -3.31604153e-01f, -1.12831302e-01f, -2.68471800e-02f, -9.48056057e-02f,
  -7.40430728e-02f, -5.05368114e-02f, 5.22912443e-02f, 5.92613257e-02f, -1.39248483e-02f, -2.47932747e-02f, 3.67143080e-02f, 2.72447038e-02f, -1.41071631e-02f, 4.42027263e-02f,
  1.68386340e-01f, 1.09066050e-02f, 5.30109033e-02f, -3.38211618e-02f, 2.52110511e-02f, -5.35926148e-02f, 7.77089596e-02f, -1.99999269e-02f, 5.73402643e-02f, -2.85553653e-02f,
  2.38201916e-02f, -3.31337564e-02f, 1.24168424e-02f, 1.56218991e-01f, 5.20223267e-02f, 1.49048846e-02f, 1.22567795e-01f, 5.23960926e-02f, 8.08971450e-02f, 3.22690718e-02f,
  4.25833166e-02f, 4.70804097e-03f, 2.30293884e-03f, -5.49162216e-02f, -3.36662754e-02f, -6.56465217e-02f, -4.33384925e-02f, -8.72584507e-02f, 2.51874514e-03f, 4.46250811e-02f,
  4.66936305e-02f, 2.34695561e-02f, -4.38497029e-02f, -5.46494350e-02f, 7.06969127e-02f, 3.10423784e-02f, -5.59786856e-02f, 6.85868487e-02f, 1.18185326e-01f, -6.78321673e-03f,
  -7.62859881e-02f, -1.54854031e-03f, -3.63301532e-03f, -8.66341311e-03f, -6.67667761e-02f, -2.08253991e-02f, -4.25048210e-02f, -8.64249393e-02f, -8.27013552e-02f, 2.52743866e-02f,
  5.51364720e-02f, 2.53006667e-01f, 4.22330014e-02f, 3.39091779e-03f, 4.97405753e-02f, -2.38283947e-02f, -6.53465791e-03f, 6.73561320e-02f, 1.59010589e-01f, 3.78707703e-03f,
  4.09916714e-02f, 1.18304551e-01f, 3.04193385e-02f, -1.87883273e-01f, 4.37342003e-02f, -4.12222967e-02f, 1.72173038e-01f, -1.90174114e-02f, 3.26798484e-02f, -4.11104448e-02f,
  -2.11583097e-02f, 1.15779750e-01f, 1.69063970e-01f, 5.58357909e-02f, 1.60693869e-01f, 1.52131304e-01f, -8.28459710e-02f, -3.09051033e-02f, 8.74158219e-02f, -6.26867544e-03f,
  2.41324529e-02f, -5.56238778e-02f, -1.59868836e-01f, 1.39069960e-01f, -2.04069868e-01f, 2.54045963e-01f, 4.16980952e-01f, -1.90603137e-01f, -2.21196756e-01f, 2.28133127e-01f,
  1.93910345e-01f, 4.76942286e-02f, 2.46807531e-01f, 3.87605399e-01f, 1.76727429e-01f, 1.91065937e-01f, 3.08504194e-01f, 2.68197626e-01f, -1.88883096e-01f, -4.78800870e-02f,
  -1.13913089e-01f, 3.24069828e-01f, 1.85953617e-01f, -1.45436436e-01f, 7.85906464e-02f, -2.55524009e-01f, 1.43012762e-01f, -1.46333843e-01f, 1.54708698e-01f, 1.49401084e-01f,
  1.21423282e-01f, -7.28539601e-02f, -9.52265635e-02f, 3.87363061e-02f, 2.11556125e-02f, 4.66714753e-03f, 7.78697729e-02f, 1.11356534e-01f, 6.53426629e-03f, -5.69292828e-02f,
  8.79180282e-02f, 5.22076152e-02f, 5.12985848e-02f, -4.14450243e-02f, -6.19035214e-02f, -6.82568103e-02f, -6.06828630e-02f, -9.30268764e-02f, -1.51652005e-02f, 3.58442105e-02f,
  -8.99384990e-02f, -8.87456462e-02f, -3.88637781e-02f, 6.99801743e-02f, -3.15064602e-02f, -3.53666954e-02f, 9.98915210e-02f, -7.08804131e-02f, -3.22231613e-02f, -3.55662033e-02f,
  2.79142205e-02f, 2.87851077e-02f, -1.62007716e-02f, 4.25371788e-02f, -5.39315771e-03f, 5.62816747e-02f, 5.83075881e-02f, 8.37934315e-02f, -8.09524059e-02f, 2.73383502e-03f,
  -5.21616228e-02f, -4.78668399e-02f, 4.80301380e-02f, 4.45770891e-03f, 3.21089104e-02f, -5.30983321e-02f, 3.46943773e-02f, -3.29760797e-02f, -2.50688083e-02f, -1.49523005e-01f,
  8.80281180e-02f, -3.74081265e-03f, -1.14942444e-02f, 1.19646244e-01f, 3.26638520e-02f, -6.97024539e-02f, 1.44145727e-01f, 2.94792857e-02f, 3.45864855e-02f, 4.50270576e-03f,
  2.88502173e-03f, -1.26743346e-01f, -8.53681937e-03f, 3.54815051e-02f, -3.57265510e-02f, -1.24506034e-01f, -7.20155425e-03f, -1.15685336e-01f, -6.77773282e-02f, -6.00797534e-02f,
  3.76899131e-02f, 2.19722688e-02f, 6.39558770e-03f, -1.30100297e-02f, -3.36875697e-03f, -8.27406496e-02f, 2.11406410e-01f, -8.67640600e-02f, 7.60980844e-02f, 4.27435786e-02f,
  6.74682036e-02f, 3.65609191e-02f, 9.29946452e-02f, 4.94007245e-02f, 8.09509680e-02f, 8.55821595e-02f, -7.79019594e-02f, -1.13322675e-01f, -2.32725986e-03f, 7.85493758e-03f,
  3.52735758e-01f, -2.86105096e-01f, 1.02661781e-01f, 5.31322837e-01f, 2.77964532e-01f, -1.52971238e-01f, 8.92547052e-03f, 2.23231584e-01f, 3.56333733e-01f, -2.49458238e-01f,
  1.99223071e-01f, -2.59794474e-01f, -1.03853814e-01f, 1.96908832e-01f, 3.26254398e-01f, -8.27801749e-02f, 1.91324607e-01f, -8.25051069e-02f, 9.13412794e-02f, 1.35156333e-01f,
  3.09440136e-01f, 1.66080773e-01f, 1.41337514e-01f, 2.75391564e-02f, 1.05713032e-01f, -7.50721246e-02f, 1.32160008e-01f, -6.85816780e-02f, -1.37075083e-02f, -6.19123392e-02f,
  2.01271987e-03f, 8.57784227e-02f, 1.41076818e-02f, -9.95784029e-02f, 1.17166966e-01f, -2.58466788e-02f, -1.37366563e-01f, 2.72044744e-02f, 1.00695007e-01f, 5.20794047e-03f,
  -6.20736666e-02f, 2.15988215e-02f, 5.38705774e-02f, 7.87466019e-03f, 9.86078456e-02f, 8.83257017e-02f, -2.39353087e-02f, -3.73940542e-02f, -2.43123956e-02f, -4.87881415e-02f,
  2.67502107e-02f, 3.31221661e-03f, 1.49662480e-01f, -8.69257674e-02f, 4.97233346e-02f, 6.88857734e-02f, -8.27409253e-02f, -9.00669843e-02f, -4.24285829e-02f, 4.89203036e-02f,
  -7.48219043e-02f, 5.17154438e-03f, 2.59667402e-03f, 5.60946465e-02f, 9.17100981e-02f, 1.05607286e-01f, 6.46422505e-02f, -6.29637912e-02f, -1.24703255e-02f, 6.77875802e-02f,
  1.07153557e-01f, 1.46902189e-01f, 1.15835935e-01f, 9.48276967e-02f, 4.02875803e-02f, -2.87063364e-02f, 8.85808319e-02f, -1.25958458e-01f, 5.53870872e-02f, 1.17315605e-01f,
  3.94694582e-02f, 7.89489225e-02f, 2.95120815e-04f, 3.40679800e-03f, -1.85389128e-02f, 3.92086394e-02f, 1.08073810e-02f, 3.58435267e-04f, -1.16810026e-02f, 1.12760793e-02f,
  -8.45014527e-02f, -1.55986086e-01f, 1.61291249e-02f, -7.97924101e-02f, -4.08414453e-02f, -2.95424950e-03f, -3.91722955e-02f, 3.24846730e-02f, -1.76696368e-02f, 6.10246509e-02f,
  1.70702934e-02f, 3.32073681e-02f, 2.01654490e-02f, 7.13095665e-02f, 4.91373166e-02f, 8.21228325e-02f, -3.36764823e-03f, -2.44038664e-02f, 4.02124077e-02f, -3.71701829e-02f,
  -3.29369977e-02f, -1.26610231e-03f, 4.44829427e-02f, 2.87080035e-02f, -1.52987782e-02f, -3.83330062e-02f, -1.23703450e-01f, 2.85695326e-02f, 4.72410070e-03f, 3.58427204e-02f,
  2.47760400e-01f, -2.72370249e-01f, -3.63646656e-01f, -3.44016582e-01f, 2.49281645e-01f, 4.72145706e-01f, -1.80908777e-02f, 5.21004871e-02f, -4.00754631e-01f, 2.16990873e-01f,
  1.24349117e-01f, -3.52770239e-01f, -3.37212384e-01f, -3.08870487e-02f, -6.92553073e-02f, -3.54371816e-01f, 2.07817063e-01f, 7.35055059e-02f, -1.50307551e-01f, 1.61188900e-01f,
  1.23702422e-01f, 3.80833864e-01f, -1.85846478e-01f, 3.99194002e-01f, 2.96860337e-01f, 1.04719818e-01f, 3.19948435e-01f, -1.69648032e-03f, 2.39940509e-01f, 9.12219733e-02f,
  -1.63727179e-02f, -1.30432785e-01f, -7.96337426e-02f, 3.68077047e-02f, 1.65514663e-01f, 1.78703949e-01f, 1.71328917e-01f, -3.35877761e-02f, -1.15947016e-01f, -1.03566542e-01f,
  -1.12860873e-02f, -3.68706733e-02f, 4.76600528e-02f, -2.34921947e-02f, 1.27988562e-01f, -4.43113931e-02f, -1.23022176e-01f, 1.70636345e-02f, -1.35927111e-01f, -3.67198549e-02f,
  -1.14206821e-01f, -4.36142161e-02f, 6.34411052e-02f, -1.02082789e-01f, -7.48080760e-02f, 6.32163733e-02f, 1.16994038e-01f, -3.08909570e-04f, 3.69298793e-02f, 5.68592027e-02f,
  1.58255830e-01f, 1.38979048e-01f, 9.72503796e-02f, -1.29790843e-01f, -1.16519354e-01f, -3.55809443e-02f, 3.88376266e-02f, -1.18858647e-02f, -1.16135374e-01f, -5.75621538e-02f,
  -1.36723682e-01f, -4.80778813e-02f, -5.47195114e-02f, 6.43514395e-02f, 2.73935888e-02f, 5.21525517e-02f, 4.19234112e-02f, 5.33583239e-02f, -7.08411112e-02f, -1.17313415e-01f,
  -8.40649679e-02f, 8.48019570e-02f, -1.56098410e-01f, 1.79653745e-02f, 3.19211558e-02f, -7.38639385e-02f, 1.51146963e-01f, 1.65047832e-02f, -9.23110172e-02f, 4.42808233e-02f,
  6.13874868e-02f, 1.05130188e-01f, -4.13872488e-02f, -5.73014952e-02f, -1.01261079e-01f, 6.54019043e-02f, 8.47746134e-02f, 1.61505938e-02f, -1.05828550e-02f, 3.14336196e-02f,
  1.43477574e-01f, -8.48174840e-03f, 2.12599128e-01f, -2.81626452e-02f, -4.65205871e-02f, 6.07617833e-02f, 4.74042892e-02f, -2.00822316e-02f, 2.46284772e-02f, 7.91795403e-02f,
  1.38017014e-01f, 9.09747109e-02f, -7.67324492e-03f, 7.36452192e-02f, 1.09755188e-01f, 2.34476831e-02f, 9.26428065e-02f, 3.88598330e-02f, 6.05877824e-02f, -5.33865839e-02f,
  -6.42628610e-01f, 1.71140224e-01f, 3.92131954e-01f, -3.55663538e-01f, 7.65803605e-02f, 2.01350480e-01f, 3.51017475e-01f, -9.49433446e-02f, -8.75887740e-03f, 6.68069646e-02f,
  2.33871099e-02f, 1.10469386e-01f, 3.62732261e-01f, -1.06442697e-01f, -1.49784133e-01f, 2.33533651e-01f, -1.87270895e-01f, 3.99464890e-02f, 1.19602166e-01f, -5.74246347e-02f,
  -3.89684252e-02f, -4.50054323e-03f, 4.64203954e-02f, 5.22010550e-02f, -7.00787976e-02f, -1.25638008e-01f, -1.27868399e-01f, 3.01254690e-01f, -2.36746013e-01f, 1.23113461e-01f,
  -2.91698128e-01f, -1.31791979e-01f, -1.15934342e-01f, -8.86354372e-02f, -1.51609734e-01f, 9.09728482e-02f, -1.26979724e-01f, 2.25030705e-01f, 4.76705879e-02f, -3.55315208e-02f,
  1.18871540e-01f, 3.72193828e-02f, -1.90964974e-02f, 1.98504031e-01f, -5.19761071e-02f, -1.88517664e-02f, 1.00172460e-01f, -1.04347877e-01f, 5.68082416e-03f, 2.07451023e-02f,
  7.47354701e-02f, -3.90680172e-02f, -1.74952038e-02f, -5.64213768e-02f, 6.87469989e-02f, 1.02056079e-01f, -8.06671977e-02f, 7.28704408e-02f, -1.41797110e-01f, -1.37907788e-01f,
  1.00569397e-01f, 6.59952983e-02f, 9.80405435e-02f, 1.64634939e-02f, 4.92544882e-02f, -1.20062731e-01f, -3.77996117e-02f, -3.59559320e-02f, -1.17661897e-02f, 5.41037992e-02f,
  -6.41372278e-02f, -1.64713655e-02f, -6.66037351e-02f, -7.62626976e-02f, 1.25720114e-01f, 6.17558733e-02f, 1.04857951e-01f, 1.12001412e-02f, -5.76531179e-02f, -9.63764638e-02f,
  2.58736871e-02f, 5.30579500e-02f, -9.07081738e-02f, -1.09863505e-01f, 7.52137601e-02f, -3.19859236e-02f, -5.27895838e-02f, -4.18754369e-02f, -9.86327156e-02f, 1.39243782e-01f,
  -2.98198372e-01f, -1.61172390e-01f, -3.48859914e-02f, -1.35667488e-01f, -9.68736261e-02f, 1.10221817e-03f, 6.05213642e-02f, -6.85788691e-02f, 2.93870978e-02f, 2.41724420e-02f,
  -3.96559611e-02f, -1.03149517e-02f, -1.05768904e-01f, 3.58547643e-02f, 1.36756480e-01f, -8.28930661e-02f, 1.69024363e-01f, -1.27156416e-03f, -5.10080606e-02f, 7.98584595e-02f,
  -4.54043634e-02f, 9.11735967e-02f, 1.56917781e-01f, -1.39003485e-01f, 9.53747928e-02f, 2.58738156e-02f, -1.18011720e-01f, 8.27146024e-02f, 9.33228284e-02f, 5.42131364e-02f,
  -3.99479210e-01f, 2.50495732e-01f, 1.65357620e-01f, -5.03815757e-03f, -2.39282131e-01f, 1.06579505e-01f, 9.07988772e-02f, -5.08351065e-03f, 1.53305247e-01f, 5.53742647e-02f,
  -6.46210462e-03f, -1.49497509e-01f, 1.68844283e-01f, 1.25940785e-01f, -2.89684504e-01f, 3.58489603e-01f, 2.12704718e-01f, 1.56813174e-01f, 3.82322855e-02f, -3.03693349e-03f,
  -2.94770245e-02f, -1.07572965e-01f, 1.25197202e-01f, -7.61168674e-02f, -1.79792393e-03f, 3.06256004e-02f, -2.43305251e-01f, -1.35441823e-02f, 7.07876263e-03f, -1.22089155e-01f,
  1.72255933e-01f, -1.07486352e-01f, 4.29268368e-02f, 1.70423910e-01f, 8.32568929e-02f, -5.24043255e-02f, 4.78533544e-02f, 2.36134827e-02f, 9.73624960e-02f, 7.19612017e-02f,
  3.93826067e-02f, 1.19491108e-01f, -7.99719244e-03f, -1.41375974e-01f, 5.24614193e-02f, 3.61567512e-02f, 1.85445696e-01f, 6.97227716e-02f, 3.18881273e-02f, -1.07840545e-01f,
  7.39754215e-02f, 1.58224255e-01f, 9.26935449e-02f, 3.53526957e-02f, 6.95560360e-03f, 6.62191361e-02f, 9.79099306e-04f, -1.13246299e-01f, 5.49147204e-02f, -1.56635627e-01f,
  -1.29022300e-01f, 8.96820351e-02f, 8.37263390e-02f, 6.98174685e-02f, 2.08889097e-02f, 8.16767737e-02f, 7.68855289e-02f, -2.89252922e-02f, 1.58511326e-02f, 9.91909131e-02f,
  6.80437237e-02f, 4.69122119e-02f, 1.45956367e-01f, 8.43110383e-02f, -7.68902339e-03f, -5.31246737e-02f, -6.93594106e-03f, 1.46532897e-02f, -4.89621200e-02f, -6.73253834e-02f,
  -2.25641336e-02f, 4.21912335e-02f, -2.50619240e-02f, 8.52174461e-02f, 1.59549505e-01f, 9.32854787e-02f, -5.89855164e-02f, -2.04946399e-02f, 8.45716745e-02f, -1.32804230e-01f,
  1.45599723e-01f, -1.11713655e-01f, 8.85370299e-02f, 2.38453448e-02f, 5.57071120e-02f, -1.01761468e-01f, -7.66391121e-03f, 7.05824420e-02f, 2.83648297e-02f, -1.35613203e-01f,
  -7.72770820e-03f, 2.78163016e-01f, 5.60775027e-02f, -6.25220463e-02f, 1.17829435e-01f, 1.45073645e-02f, 5.16755544e-02f, 6.18762635e-02f, -2.49661412e-02f, -9.00842473e-02f,
  8.93115178e-02f, 1.26229376e-01f, -1.03532476e-02f, 1.32355932e-02f, 5.99757582e-02f, 3.71519364e-02f, -1.76159382e-01f, -4.10043588e-03f, -4.06296887e-02f, 3.25884968e-02f,
  -1.01441316e-01f, -2.17732802e-01f, -1.54521465e-01f, -4.99433391e-02f, 3.64139378e-02f, -1.66167960e-01f, -5.42298853e-01f, 5.19036017e-02f, -2.12505311e-01f, -1.39594674e-01f,
  -6.81464153e-04f, -6.44838959e-02f, -3.63015234e-01f, 3.98989707e-01f, 3.34154636e-01f, 1.17760971e-01f, 2.14157179e-01f, 1.84238046e-01f, 1.16241448e-01f, 8.66286084e-02f,
  2.59095758e-01f, 3.50044429e-01f, 3.07098478e-01f, 3.77120197e-01f, 8.08873102e-02f, 4.88502048e-02f, 3.23091835e-01f, -1.13319904e-02f, 2.24352300e-01f, 1.45134211e-01f,
  5.59418797e-02f, 1.62963998e-02f, -6.75809160e-02f, 5.16150612e-03f, 1.60497427e-02f, -1.28490195e-01f, -2.78690122e-02f, -3.54326144e-03f, -2.51365528e-02f, -6.87740892e-02f,
  -6.18008561e-02f, 8.57321769e-02f, 8.19008350e-02f, 2.38327682e-02f, -2.61143856e-02f, -2.69918498e-02f, -8.33492130e-02f, 1.11069577e-03f, -1.09544814e-01f, -4.48686024e-03f,
  -7.19084889e-02f, 1.28381819e-01f, -1.05987325e-01f, 7.91630968e-02f, -1.47756085e-01f, -7.82700554e-02f, -1.19017743e-01f, -1.05191760e-01f, 3.30527611e-02f, -2.56868987e-03f,
  9.34346914e-02f, -7.53432140e-02f, -1.25951916e-01f, 1.35751609e-02f, -1.59282625e-01f, -9.03575122e-02f, 9.83528327e-03f, -2.64905915e-02f, -1.37017310e-01f, -8.71584192e-02f,
  -7.61658791e-03f, -5.34171946e-02f, -4.28583324e-02f, -3.63684297e-02f, -5.31953983e-02f, 9.77798700e-02f, 2.47715763e-03f, -1.26976240e-02f, -1.17480420e-01f, 4.46652770e-02f,
  6.97036237e-02f, -6.46557007e-03f, -1.15778983e-01f, 1.48887217e-01f, 7.62767866e-02f, -1.91706210e-01f, -4.56916541e-03f, -5.48252314e-02f, 2.57897191e-02f, 2.03977581e-02f,
  6.37736171e-02f, -2.50157597e-03f, -1.02019511e-01f, 3.56670432e-02f, -4.43638824e-02f, -2.69905962e-02f, 4.88126371e-03f, 5.34548722e-02f, -1.02182580e-02f, 6.65678689e-03f,
  8.31177533e-02f, -7.99862072e-02f, 1.05429694e-01f, 2.01819930e-02f, 1.74657941e-01f, -4.04280797e-02f, -9.61339325e-02f, -2.79539172e-02f, -1.90648306e-02f, 1.21015288e-01f,
  5.65737747e-02f, -3.08104116e-03f, -7.84678161e-02f, -6.00187555e-02f, 4.20898609e-02f, -1.21965811e-01f, -1.55887567e-02f, 4.67162803e-02f, 1.43049620e-02f, 9.58042964e-02f,
  -6.09968185e-01f, 9.35461819e-02f, 4.87846047e-01f, -4.56908435e-01f, 8.37430060e-02f, 4.11968589e-01f, -2.76878811e-02f, 8.70448425e-02f, -2.12261438e-01f, -1.37671217e-01f,
  -7.39765465e-02f, -1.10792316e-01f, 1.99442059e-01f, -6.97096288e-02f, 2.68942952e-01f, 1.97346732e-01f, -2.60893870e-02f, -6.02111667e-02f, -2.73842961e-02f, -1.60553217e-01f,
  -3.79004069e-02f, -1.86575949e-01f, 1.99180678e-01f, 5.72720543e-02f, -8.40094239e-02f, -1.09010875e-01f, -1.31796271e-01f, 1.57640725e-01f, 8.55991915e-02f, 1.68994054e-01f,
  -1.77806467e-01f, -2.18395561e-01f, -1.84600890e-01f, 7.72468597e-02f, 7.34907016e-02f, 4.76625524e-02f, -6.07161373e-02f, 8.04335698e-02f, -9.26843360e-02f, -1.63364056e-02f,
  6.41252324e-02f, 1.18266940e-01f, -6.36346564e-02f, 3.67391258e-02f, 2.80485749e-02f, 4.23762165e-02f, 1.70534775e-01f, -1.57623347e-02f, 3.07025183e-02f, 1.54692858e-01f,
  1.55483603e-01f, 8.68903771e-02f, 5.24458513e-02f, 4.78372984e-02f, 7.17188045e-02f, -3.93172866e-03f, 8.93383399e-02f, 8.78067762e-02f, 3.24205942e-02f, -4.10144329e-02f,
  9.44323540e-02f, 1.28460452e-02f, 5.02973013e-02f, -7.08779097e-02f, -6.81058615e-02f, 7.78946131e-02f, 9.80753228e-02f, -3.57135348e-02f, 4.47329180e-03f, -2.53017489e-02f,
  -1.12491824e-01f, -1.17525738e-02f, -5.80415726e-02f, 3.19837220e-02f, 4.15205136e-02f, -5.64898252e-02f, -3.73697914e-02f, 1.08233737e-02f, 6.59530936e-03f, -4.66219410e-02f,
  -4.53904532e-02f, 4.47987840e-02f, -2.50503197e-02f, -3.13628577e-02f, 4.40165997e-02f, 6.47682771e-02f, 1.97556391e-02f, 1.63113698e-02f, -1.86334208e-01f, 5.06086908e-02f,
  -2.36016437e-01f, -2.06528962e-01f, -1.68231532e-01f, -1.09148540e-01f, -2.27829907e-02f, 2.87461262e-02f, -1.65480445e-03f, 3.18569131e-02f, -1.52712613e-02f, -3.81657369e-02f,
  4.54142094e-02f, 8.88150632e-02f, -6.34619407e-03f, -9.38678719e-03f, 1.38050482e-01f, 8.60850606e-03f, 7.08236322e-02f, -6.29470944e-02f, -3.43607664e-02f, -1.75500126e-03f,
  1.46266334e-02f, -4.62118685e-02f, 1.49609342e-01f, 3.96431275e-02f, 2.37877183e-02f, -5.36608510e-02f, -2.41006222e-02f, 2.71265861e-02f, 1.26120970e-01f, 7.74661452e-02f,
  -3.51418369e-02f, 2.27550659e-02f, -1.12875849e-01f, 2.29807511e-01f, 3.94618154e-01f, -2.63453960e-01f, 1.74882948e-01f, 1.31591976e-01f, 1.75173938e-01f, 1.76378995e-01f,
  -1.56820104e-01f, -1.85708627e-01f, -1.79437041e-01f, -2.50278622e-01f, -7.13101983e-01f, -5.89198291e-01f, -3.11166376e-01f, -2.18435377e-01f, -1.17086068e-01f, 1.33816777e-02f,
  -7.61338621e-02f, 4.13640887e-02f, 3.73415202e-02f, 3.59624445e-01f, 3.66473049e-01f, 3.25709760e-01f, 1.35495007e-01f, 2.11677700e-01f, 1.03336498e-01f, 5.98812513e-02f,
  -9.26771834e-02f, 8.37572217e-02f, 1.50254861e-01f, 3.18516046e-02f, -4.89007011e-02f, 2.29793936e-02f, 1.28861861e-02f, 6.66547799e-03f, -3.74234803e-02f, 4.18042671e-03f,
  -1.26603087e-02f, 2.47335881e-02f, -3.31760459e-02f, -3.48099768e-02f, 1.38802782e-01f, -7.33779967e-02f, -1.54728577e-01f, 2.25012135e-02f, 9.49829910e-03f, -1.21946186e-01f,
  3.04841599e-03f, -9.26386416e-02f, -2.51645148e-02f, -5.99684678e-02f, 3.68260071e-02f, -3.35756224e-03f, -2.34386194e-02f, -2.17543207e-02f, -6.52507842e-02f, 1.50284842e-01f,
  -7.58917630e-02f, 8.02717209e-02f, 4.90063094e-02f, 8.20253789e-02f, 2.84238178e-02f, 1.14256777e-01f, 2.84547061e-02f, 4.65237834e-02f, 7.73504376e-02f, 4.07818099e-03f,
  1.87574066e-02f, 3.57803926e-02f, -7.19548091e-02f, 9.49594527e-02f, -6.86535193e-03f, 1.05739392e-01f, -4.47780080e-02f, -3.25717069e-02f, 9.39430371e-02f, -5.94280995e-02f,
  -4.04981636e-02f, 1.51439667e-01f, 1.81763358e-02f, -2.11811215e-02f, -1.29844770e-01f, 1.48914745e-02f, -2.22588088e-02f, -5.95810227e-02f, 4.21185642e-02f, -8.48530680e-02f,
  -1.39187798e-01f, -1.38800755e-01f, 9.03136954e-02f, 1.38721704e-01f, -3.28355171e-02f, -6.56067505e-02f, -4.82189395e-02f, -3.73253934e-02f, -7.17518330e-02f, -2.27426793e-02f,
  3.69814783e-03f, 1.05123155e-01f, -9.80030000e-02f, -9.33772996e-02f, 2.41541813e-04f, -4.22506668e-02f, 1.48530779e-02f, 3.02575473e-02f, 9.66645256e-02f, -3.60747352e-02f,
  4.95179333e-02f, -5.21649607e-02f, 4.40090783e-02f, 1.91836894e-01f, 9.18677822e-02f, 6.63703680e-02f, 3.79457907e-03f, 7.79726133e-02f, -1.97587293e-02f, -8.19282886e-03f,
  2.53431171e-01f, 4.43580985e-01f, 2.13787556e-01f, 1.95318669e-01f, 1.58359200e-01f, 2.59504497e-01f, 1.80749167e-02f, 6.81647882e-02f, 4.43840660e-02f, 2.01065287e-01f,
  1.25168376e-02f, 2.39404351e-01f, -1.11203767e-01f, 3.21289569e-01f, -1.83548242e-01f, -1.47626042e-01f, 1.44750744e-01f, 1.20908424e-01f, -1.16587207e-01f, 1.06287383e-01f,
  -1.50895402e-01f, -1.15934052e-01f, 4.28096764e-02f, -1.78919777e-01f, 1.24137230e-01f, -4.11821455e-02f, -1.97725251e-01f, -2.24193737e-01f, 6.65368885e-02f, -6.90579638e-02f,
  6.29722774e-02f, 2.42024604e-02f, 7.44521394e-02f, -1.21867061e-02f, 8.20798129e-02f, -7.92183541e-03f, -4.33234386e-02f, -9.02501196e-02f, -1.49652407e-01f, 1.05105653e-01f,
  5.44557050e-02f, -1.94962975e-02f, 7.26809874e-02f, -6.44110749e-03f, 6.58263266e-02f, 1.35919079e-01f, 6.63663000e-02f, 1.93545669e-01f, 1.57789528e-01f, 1.21238776e-01f,
  1.15544446e-01f, 1.29965544e-01f, 7.87561983e-02f, 5.55181457e-03f, 8.13430399e-02f, 8.11456144e-02f, -5.53810969e-02f, 1.11547194e-01f, 7.34097064e-02f, 1.70323938e-01f,
  -8.96525010e-02f, -6.26263693e-02f, 5.02090342e-02f, 2.16313787e-02f, 2.37336289e-02f, 8.77836421e-02f, -4.19841264e-04f, 7.04017058e-02f, -2.22575366e-02f, 1.38707384e-01f,
  -2.41903625e-02f, 8.95953849e-02f, -5.67970462e-02f, -8.09538085e-03f, -6.15405571e-03f, 4.39826166e-03f, 4.20483667e-03f, 1.46163478e-02f, 5.56914285e-02f, 5.01514822e-02f,
  -1.87992409e-01f, -9.93212610e-02f, -3.79503816e-02f, -9.02475119e-02f, -3.89544182e-02f, 9.43630747e-03f, -1.15158454e-01f, 8.86895806e-02f, 1.39000183e-02f, -9.46148485e-03f,
  -3.10142450e-02f, -1.85305968e-01f, -4.88513634e-02f, -3.78402583e-02f, 1.34634855e-03f, 3.89758758e-02f, -5.52213453e-02f, 7.58189708e-02f, -8.50084648e-02f, -9.08522680e-03f,
  8.31536725e-02f, -1.14031382e-01f, -8.90002549e-02f, 9.31574181e-02f, -7.14805499e-02f, 9.41677243e-02f, -1.53793111e-01f, 2.03529727e-02f, -7.08371401e-02f, 7.08579347e-02f,
  8.56736600e-02f, -1.85551271e-02f, 2.66014747e-02f, 1.35740340e-01f, 1.17035717e-01f, 8.05776101e-03f, 8.64476338e-03f, 6.49200529e-02f, -8.09401348e-02f, 7.25517869e-02f,
  -1.83253452e-01f, -5.77292204e-01f, 1.47214206e-02f, -8.76485184e-02f, 2.42650568e-01f, 2.57782757e-01f, 1.91026881e-01f, -2.07915276e-01f, -3.95550013e-01f, -2.27469102e-01f,
  6.76793307e-02f, -1.08586319e-01f, -1.20090723e-01f, -3.61943275e-01f, 2.36965746e-01f, -3.64532799e-01f, -1.87426656e-01f, 4.23560962e-02f, -1.90956578e-01f, 1.12823486e-01f,
  7.23645166e-02f, -7.11241663e-02f, 7.64344633e-02f, -1.59370061e-02f, -4.81577031e-02f, -1.91849247e-02f, 2.65925944e-01f, 3.02243918e-01f, 1.23529397e-01f, 1.14661209e-01f,
  -3.04011535e-02f, -2.27994308e-01f, -4.16889004e-02f, -7.05519840e-02f, 1.51646420e-01f, 1.15371808e-01f, 1.29939675e-01f, 8.64123181e-02f, 3.75234820e-02f, -4.71258871e-02f,
  5.38374446e-02f, 1.75628625e-02f, -1.93506882e-01f, 1.02356479e-01f, 1.20007461e-02f, -4.64870036e-02f, -1.03980199e-01f, -2.72249561e-02f, -2.45777443e-02f, -5.86176887e-02f,
  -5.96185513e-02f, -3.85809271e-03f, -9.43748429e-02f, -3.76757346e-02f, -3.48748080e-02f, -1.79592818e-02f, -5.32684252e-02f, 1.66169345e-01f, -8.13150331e-02f, 8.87500122e-02f,
  -2.91549973e-02f, -7.68058077e-02f, -6.48001134e-02f, -1.03606254e-01f, -6.51741847e-02f, -2.34183446e-02f, -8.77450034e-02f, -4.93817516e-02f, 7.41636455e-02f, 1.77908633e-02f,
  5.48730716e-02f, 3.35024446e-02f, -1.02659479e-01f, -1.18253501e-02f, -2.69962177e-02f, -2.33891740e-01f, 7.65521601e-02f, -2.23728288e-02f, 3.34390178e-02f, -1.71996895e-02f,
  -1.97086502e-02f, 2.69523766e-02f, 1.33549020e-01f, -2.89378799e-02f, -1.19545579e-01f, 3.87664549e-02f, -7.20966980e-02f, 6.41499236e-02f, -2.68017817e-02f, 1.20593928e-01f,
  5.43708317e-02f, -7.59434626e-02f, -8.05711970e-02f, 1.50386197e-02f, -4.80053164e-02f, 9.11867619e-03f, -7.07597286e-02f, -9.13330019e-02f, 3.12594734e-02f, -1.55658629e-02f,
  1.27342910e-01f, 1.57122426e-02f, -1.51832610e-01f, -6.08849293e-03f, 1.32149607e-01f, 3.60299088e-02f, 1.75122991e-02f, 6.01544827e-02f, 1.24123700e-01f, -4.52185795e-02f,
  2.96583883e-02f, 1.40753323e-02f, -1.14099681e-01f, -7.56270364e-02f, -7.86031485e-02f, 1.06800802e-01f, 8.49872595e-04f, 4.78270762e-02f, -7.85164442e-03f, -2.90296040e-02f,
  -4.78035212e-01f, -3.74809355e-02f, -2.39014849e-01f, -1.34992063e-01f, -2.44218022e-01f, -2.93561310e-01f, -1.11961298e-01f, -2.40060836e-01f, -7.76137188e-02f, 3.32373559e-01f,
  1.75886557e-01f, -1.25953332e-01f, 1.67058870e-01f, 2.29086690e-02f, -5.23286641e-01f, 2.40345523e-01f, 4.54449654e-02f, 1.02739334e-01f, 3.00742351e-02f, -1.23828411e-01f,
  -1.79461315e-01f, -5.49536385e-02f, -5.68689033e-02f, -3.89933400e-02f, -1.94781587e-01f, -8.77738371e-02f, 2.15635955e-01f, -1.05320863e-01f, -7.52022043e-02f, -7.90256932e-02f,
  -1.69000089e-01f, -8.93148333e-02f, 7.87642971e-02f, -3.64835374e-02f, -5.12976386e-02f, 1.62766993e-01f, 7.74787292e-02f, -1.26586584e-02f, 1.80221181e-02f, -6.81648031e-02f,
  -4.41407189e-02f, -1.26349106e-01f, -1.04132220e-01f, 7.13304952e-02f, -5.25701419e-02f, -1.50513142e-01f, -1.21343270e-01f, -4.87695523e-02f, -1.18125625e-01f, -7.12079927e-02f,
  -1.99895665e-01f, -2.32753120e-02f, -6.52256757e-02f, 3.58997174e-02f, -1.29253775e-01f, -1.79804768e-02f, 4.73092869e-02f, -4.41463254e-02f, -9.92502570e-02f, -5.22670336e-02f,
  -8.53588879e-02f, 7.30663985e-02f, 1.98168680e-02f, -5.11662215e-02f, -1.12434715e-01f, -7.41130635e-02f, -1.47767989e-02f, -7.39518879e-03f, 4.82809320e-02f, -1.15057521e-01f,
  -5.60750887e-02f, 1.69472594e-03f, 4.69214730e-02f, 5.35027422e-02f, 2.03299448e-02f, 4.26339731e-02f, 8.49086344e-02f, -7.76044875e-02f, -4.49460819e-02f, -1.29624484e-02f,
  -2.07648482e-02f, -5.27563738e-03f, -1.03857197e-01f, 6.21117875e-02f, 1.04406103e-02f, 1.38508799e-02f, 1.07717335e-01f, 4.76427115e-02f, -1.24455430e-02f, 5.73706962e-02f,
  -2.70526856e-01f, -2.07234174e-01f, -1.63338557e-02f, -7.99613968e-02f, 5.27954437e-02f, 1.04038201e-01f, 6.29002005e-02f, 5.08680083e-02f, -8.40584412e-02f, 3.95128038e-04f,
  -5.13167167e-03f, 3.31899188e-02f, -1.02251761e-01f, 7.99286664e-02f, -9.40121710e-03f, -5.21647409e-02f, -2.96675581e-02f, 5.53780347e-02f, -7.26162791e-02f, -1.81033555e-02f,
  -1.48153286e-02f, -7.97832161e-02f, -3.63543862e-03f, 1.31868258e-01f, 8.98342505e-02f, 9.33252554e-03f, -1.08989052e-01f, 2.08147485e-02f, -8.49637911e-02f, 5.74462861e-02f,
  9.07624885e-02f, 2.18281552e-01f, -1.80651560e-01f, 1.30027324e-01f, -1.21398643e-01f, 2.68216699e-01f, 1.80082187e-01f, -2.30044108e-02f, 1.72839403e-01f, 2.67615080e-01f,
  -6.32602647e-02f, 2.42277384e-01f, 1.19362539e-02f, 2.46595010e-01f, 1.85945377e-01f, 1.95028946e-01f, 4.08198208e-01f, 2.63528168e-01f, 5.29347062e-02f, 8.62179548e-02f,
  1.03488930e-01f, 3.07559788e-01f, -1.58498749e-01f, 5.02262488e-02f, -9.82421413e-02f, -2.19030425e-01f, -2.15438470e-01f, -1.72345653e-01f, 7.25153089e-02f, 3.12359594e-02f,
  1.33629586e-03f, 5.61292581e-02f, -8.97703990e-02f, 8.70823115e-02f, 1.08391163e-03f, 9.88192577e-03f, -6.00339007e-03f, -7.04937009e-03f, -5.01516424e-02f, 5.44062778e-02f,
  8.60207304e-02f, 1.53442889e-01f, 1.83780372e-01f, 2.31233053e-02f, 4.13433127e-02f, -3.75837870e-02f, 2.38672048e-02f, -1.37469307e-01f, 7.01817349e-02f, -1.35026500e-02f,
  -7.14641362e-02f, -3.84368971e-02f, -2.29509268e-02f, 9.15809944e-02f, 3.80535461e-02f, 9.44703296e-02f, 1.71393707e-01f, -9.00309086e-02f, 7.62163401e-02f, 4.87577878e-02f,
  2.38726288e-02f, 1.69358894e-01f, 3.62504348e-02f, -5.88613264e-02f, -5.53813484e-03f, -1.43199489e-01f, 3.86113673e-02f, -4.20657247e-02f, -9.06957164e-02f, 3.79942544e-03f,
  -4.39915471e-02f, -5.60573302e-02f, 3.69804315e-02f, 7.48243630e-02f, 1.67274028e-01f, 3.99248265e-02f, 2.34134751e-03f, 3.41082178e-02f, -5.96391261e-02f, -1.39198989e-01f,
  2.82424390e-02f, 3.06661539e-02f, -5.18590510e-02f, -4.75792624e-02f, 4.10277136e-02f, -2.95598172e-02f, 1.15651719e-01f, -8.60034451e-02f, -1.65306494e-01f, -1.42334087e-04f,
  1.35812595e-01f, 3.08266133e-01f, -2.27320250e-02f, 6.61482811e-02f, 4.38972414e-02f, 2.16384642e-02f, 7.05276281e-02f, 7.74959177e-02f, 1.30114347e-01f, 9.20245871e-02f,
  1.33533165e-01f, 1.04066208e-02f, 1.02941776e-02f, -1.48014367e-01f, 3.51841585e-03f, -1.14264851e-02f, 1.43506750e-01f, -4.05563675e-02f, 2.18424238e-02f, 1.82316620e-02f,
  -9.55999922e-03f, 8.84682685e-02f, 1.12426177e-01f, 7.26893842e-02f, 1.36785105e-01f, 3.94137241e-02f, -1.38758514e-02f, -3.10477279e-02f, -3.68879437e-02f, 7.18546882e-02f,
  1.97454184e-01f, -2.17302844e-01f, -7.23691806e-02f, -8.18587169e-02f, 4.97949719e-02f, -7.03777522e-02f, 2.48568691e-02f, -1.12823695e-01f, 1.21809490e-01f, -2.90376008e-01f,
  -2.00195044e-01f, 9.46760550e-02f, 2.54594922e-01f, -2.21024632e-01f, 3.46250534e-01f, 2.07648456e-01f, -1.74267337e-01f, -8.10723305e-02f, 1.73415214e-01f, -2.08612129e-01f,
  1.06549785e-02f, -2.05546483e-01f, 3.71924192e-02f, -1.98044077e-01f, -2.28358284e-01f, -2.59137958e-01f, -1.47491395e-02f, -5.35773262e-02f, -2.56393701e-01f, -9.46213398e-03f,
  1.11342696e-02f, -5.08771800e-02f, -6.26858026e-02f, -2.85627954e-02f, -7.25155100e-02f, -1.10869005e-01f, -9.85501409e-02f, 2.29096282e-02f, 7.87624642e-02f, 4.51243669e-02f,
  7.54829943e-02f, 1.13914318e-01f, -4.13249098e-02f, 9.24158543e-02f, -8.16115513e-02f, 1.72206145e-02f, 1.07698679e-01f, -4.56719920e-02f, 5.13977781e-02f, -1.13112442e-02f,
  9.70750079e-02f, 4.08816449e-02f, 6.68467805e-02f, 5.92069291e-02f, 1.27382353e-02f, -4.43903394e-02f, -4.96541262e-02f, 3.82521041e-02f, -6.55807648e-03f, 3.55992168e-02f,
  -5.60519882e-02f, 1.04755715e-01f, -2.37023942e-02f, -2.30978262e-02f, 2.59923190e-02f, 3.96458320e-02f, 3.52549069e-02f, -4.18628342e-02f, 8.82586315e-02f, -2.82122251e-02f,
  5.70480432e-03f, -9.38246101e-02f, 2.93633211e-02f, 3.88989933e-02f, 9.34614334e-03f, 1.00574233e-02f, 4.94019538e-02f, -4.57736962e-02f, -9.91870016e-02f, -1.24979103e-02f,
  6.32247552e-02f, 8.28600023e-03f, 5.27558476e-02f, -2.29317173e-02f, -3.13352980e-02f, 4.65721861e-02f, -2.44546141e-02f, -1.77284591e-02f, -1.34781571e-02f, 1.77070666e-02f,
  -6.47792146e-02f, -1.34737194e-01f, -3.39738801e-02f, -7.91364685e-02f, -4.03899737e-02f, -1.25671208e-01f, -7.60119855e-02f, -6.92183077e-02f, 1.01840263e-02f, -1.20495008e-02f,
  -1.11137167e-01f, 1.02674946e-01f, -1.50609883e-02f, -2.32955310e-02f, -1.22159999e-02f, -1.44004906e-02f, -2.38370262e-02f, 5.77892512e-02f, 7.11490884e-02f, -7.62575269e-02f,
  1.10157048e-02f, 1.38952389e-01f, 1.83626696e-01f, 1.18401080e-01f, -3.02354582e-02f, 4.39923815e-02f, 2.10779300e-03f, 3.12754512e-02f, 5.05977906e-02f, 1.04214624e-01f,
  -1.74825832e-01f, 9.78582278e-02f, 1.04092307e-01f, -2.31445312e-01f, -8.96287411e-02f, -6.44962937e-02f, -1.89913332e-01f, 7.16405883e-02f, 1.23995535e-01f, -9.99960229e-02f,
  -5.98934889e-02f, 4.33752430e-04f, 1.21217936e-01f, -2.37550899e-01f, 1.92508191e-01f, 2.57211506e-01f, -2.39587903e-01f, -1.38410479e-01f, 7.73883983e-02f, -2.61359096e-01f,
  -1.61145553e-01f, -2.94927031e-01f, -2.88818916e-03f, -1.31933972e-01f, -3.15271854e-01f, -4.09539193e-02f, -2.65674181e-02f, -6.95139170e-02f, -2.85930276e-01f, -2.23272275e-02f,
  7.22037107e-02f, 1.10835917e-01f, 9.92989391e-02f, 1.19470343e-01f, 3.93257756e-03f, -7.93937445e-02f, -1.11450538e-01f, 5.92655987e-02f, 1.24739163e-01f, -5.44169918e-02f,
  -9.40813348e-02f, 1.54574821e-02f, -4.00934704e-02f, -5.40732257e-02f, -1.11826740e-01f, -2.99053080e-02f, 6.63315430e-02f, 8.46532658e-02f, 8.64387378e-02f, -9.30008888e-02f,
  -7.04470500e-02f, 8.32984746e-02f, 2.29484402e-03f, 1.39201492e-01f, 4.03731503e-02f, 7.32570514e-02f, -4.70287800e-02f, 4.98499051e-02f, 1.12260357e-02f, 1.51587408e-02f,
  -1.11328691e-01f, -6.91373572e-02f, -6.85365871e-02f, -2.07715556e-02f, -1.62453298e-02f, 3.03820297e-02f, -9.68810767e-02f, 8.81712418e-03f, 1.30572751e-01f, -7.60787446e-03f,
  1.17380135e-01f, -7.74729066e-03f, 2.25732997e-02f, -4.21503894e-02f, -2.43445665e-01f, -5.71204573e-02f, 3.19457948e-02f, 6.35177270e-02f, -1.37544557e-01f, 1.01272061e-01f,
  1.90699715e-02f, 2.83106845e-02f, 1.01151928e-01f, -1.31583503e-02f, -7.27635100e-02f, -2.20125262e-02f, -1.27039567e-01f, -2.28449944e-02f, 1.12912163e-01f, -1.62182879e-02f,
  1.23723514e-01f, 4.51433472e-02f, 1.50548354e-01f, 1.50394395e-01f, 3.04568708e-02f, -3.61107998e-02f, -6.90648556e-02f, -8.20178315e-02f, 5.24515733e-02f, -4.22861241e-02f,
  -1.64622650e-01f, 7.58578777e-02f, -1.81764662e-02f, -7.81945046e-03f, 5.49343750e-02f, 4.01817076e-02f, -8.39238837e-02f, 5.13470508e-02f, 1.08003683e-01f, -8.41168612e-02f,
  1.54262288e-02f, 1.39790699e-02f, 9.23101977e-02f, -2.20129285e-02f, -4.82201427e-02f, -6.11818954e-03f, -4.05429415e-02f, 1.25807405e-01f, -2.00524125e-02f, -5.31718768e-02f,
  2.39769474e-01f, 1.65782049e-01f, 1.15994908e-01f, 2.75104702e-01f, 1.61563948e-01f, 1.37084618e-01f, 2.54974395e-01f, 9.42476168e-02f, 5.29331684e-01f, -5.09897992e-02f,
  -1.70723140e-01f, 2.25640208e-01f, -1.23908557e-01f, 8.34923983e-02f, -2.76810914e-01f, -3.65353338e-02f, 1.89182058e-01f, 2.61097699e-01f, 2.11492702e-01f, 8.96972865e-02f,
  9.80657861e-02f, -1.31820038e-01f, -2.19328403e-01f, -8.71549100e-02f, 1.61477905e-02f, 8.54829177e-02f, -4.81918335e-01f, 4.17261235e-02f, -1.24770343e-01f, 6.07581027e-02f,
  3.02206017e-02f, 2.03964829e-01f, -1.54501572e-01f, 9.77395382e-03f, 8.01316171e-04f, 7.65035534e-03f, -7.61351958e-02f, -2.03537643e-02f, 1.18446834e-01f, 7.27769881e-02f,
  7.42383972e-02f, -1.35435183e-02f, 1.35607766e-02f, -2.73211990e-02f, 1.61375746e-01f, 3.31911035e-02f, 1.08488902e-01f, 2.36235932e-02f, 3.99293117e-02f, 2.03240309e-02f,
  2.02864986e-02f, 3.31183970e-02f, 1.10881649e-01f, 1.16371691e-01f, 4.56016175e-02f, 1.50898412e-01f, 1.33208707e-01f, 1.25527605e-02f, 1.17856702e-02f, 7.84217715e-02f,
  -2.95661986e-02f, 8.46067145e-02f, 5.76407835e-02f, -4.56436463e-02f, 2.59434730e-02f, 3.80689511e-03f, 6.17006905e-02f, 3.66855203e-03f, 1.36012390e-01f, 1.10465791e-02f,
  -2.63398066e-02f, 4.52887863e-02f, 9.44070294e-02f, 1.07497618e-01f, 1.10515654e-01f, 7.56390840e-02f, -1.07294254e-01f, -3.68440375e-02f, 8.40661377e-02f, -6.51263520e-02f,
  -6.44216985e-02f, 4.27307124e-04f, -8.43984783e-02f, -3.81262740e-03f, -5.15217930e-02f, 7.26129264e-02f, -4.18383218e-02f, -8.16169940e-03f, -8.72875080e-02f, -4.45933416e-02f,
  2.66730227e-02f, 2.21621081e-01f, -1.34935621e-02f, -1.77520812e-02f, -6.60938956e-03f, -3.67505290e-02f, 4.62881401e-02f, 5.37992083e-02f, 8.66515785e-02f, -3.12463902e-02f,
  5.15043549e-02f, 1.10842809e-01f, -2.58155558e-02f, 2.42914844e-04f, 2.85932254e-02f, -1.17201351e-01f, 4.11649011e-02f, 7.24608079e-02f, -7.65745435e-03f, -1.27780050e-01f,
  -4.98477183e-02f, 1.83724135e-01f, 1.35196730e-01f, 9.94622707e-02f, 2.36102194e-02f, 1.70929320e-02f, -2.36571562e-02f, 9.51851625e-03f, 8.99720122e-04f, 2.66132317e-02f,
  3.85651052e-01f, 1.75979659e-01f, 2.33088091e-01f, 4.39876691e-02f, 9.98930931e-02f, 1.25496939e-01f, -1.57132775e-01f, 1.13207996e-01f, -3.39303017e-02f, 3.23347002e-02f,
  -2.42251277e-01f, -4.25297283e-02f, -2.63773054e-01f, 1.07511170e-01f, -2.45021775e-01f, -1.30404085e-01f, -1.74470112e-01f, -1.87560901e-01f, -4.90441546e-02f, -4.51245382e-02f,
  -7.35397041e-02f, -2.46209458e-01f, -5.64034171e-02f, -5.84045686e-02f, 2.88200855e-01f, 2.39337146e-01f, -7.75164291e-02f, -1.67966094e-02f, 1.04923278e-01f, -7.59486184e-02f,
  8.63775089e-02f, -4.75852042e-02f, 1.96533322e-01f, 9.48384702e-02f, 8.26456118e-03f, 9.22528952e-02f, 1.33885488e-01f, -1.45669416e-01f, -1.83371007e-02f, -8.83901492e-03f,
  5.40776290e-02f, 6.51756749e-02f, -5.82984323e-03f, -4.95932437e-02f, 1.54205456e-01f, 6.31321594e-02f, 2.46736825e-01f, 1.61558509e-01f, 1.45791266e-02f, 9.12822410e-02f,
  -1.02887908e-02f, 2.26486742e-01f, 1.15019925e-01f, -7.62185231e-02f, -7.03448057e-02f, -3.75995506e-03f, -6.06714673e-02f, 1.65917948e-02f, 6.31536692e-02f, 4.84934747e-02f,
  7.38917291e-02f, -6.17178530e-02f, -1.08592786e-01f, 1.18019678e-01f, -8.15631747e-02f, -3.03261280e-02f, -1.84112355e-01f, -2.76305452e-02f, -4.53514345e-02f, 1.58052612e-02f,
  5.50173596e-03f, 5.69690689e-02f, -2.99278107e-02f, -3.18033509e-02f, 3.58548015e-02f, 1.33444652e-01f, 3.07783149e-02f, -1.75631121e-02f, -8.97908881e-02f, 5.96601777e-02f,
  -4.53151576e-02f, -1.42998144e-01f, -1.15948111e-01f, 3.94902602e-02f, -2.35900432e-02f, -5.15743643e-02f, -1.80032104e-02f, 2.08862166e-05f, 5.06001785e-02f, -1.49627561e-02f,
  -2.07051292e-01f, -3.21189731e-01f, 3.04896086e-02f, -4.69235666e-02f, -1.77229539e-01f, 1.87220216e-01f, 8.24594125e-02f, -1.54440282e-02f, -9.01653171e-02f, -5.95677793e-02f,
  1.09733552e-01f, 5.01352958e-02f, -7.69687304e-03f, 5.45514040e-02f, -1.50443822e-01f, -8.19461271e-02f, -1.04658969e-01f, -3.36792916e-02f, 3.67928483e-02f, 1.58401709e-02f,
  5.31230010e-02f, 4.96993810e-02f, -1.55483959e-02f, -5.39735630e-02f, -1.35458186e-01f, -1.19740047e-01f, -1.68206189e-02f, -1.23672625e-02f, -1.29190842e-02f, -4.20291629e-03f,
  -4.53811377e-01f, -7.85465762e-02f, -1.75455719e-01f, 2.02128245e-03f, -1.07413046e-01f, -8.68791118e-02f, -1.17162660e-01f, -7.18161315e-02f, -1.47294709e-02f, 2.28995830e-01f,
  2.13472396e-01f, -1.12880476e-01f, -7.06709409e-03f, 4.01600510e-01f, -7.33714029e-02f, 1.89823136e-01f, 1.78162813e-01f, 1.41537160e-01f, 2.08731424e-02f, -6.94340095e-02f,
  -6.32150518e-03f, 3.33970115e-02f, 5.23140393e-02f, -1.30884528e-01f, -7.16467798e-02f, -1.55423090e-01f, 9.52801630e-02f, -1.31782636e-01f, 1.17186263e-01f, 4.51558791e-02f,
  -5.34819476e-02f, -6.55437112e-02f, -7.84911811e-02f, 3.46081480e-02f, -9.40412842e-03f, -1.20101474e-01f, -6.06620759e-02f, -3.93551961e-02f, -2.00304035e-02f, -6.94283023e-02f,
  -6.70021847e-02f, -8.43338072e-02f, 5.52588180e-02f, 8.84622186e-02f, -7.62772635e-02f, -7.43671581e-02f, 5.62482513e-02f, 8.68648291e-02f, 3.15763690e-02f, -9.37772077e-03f,
  2.42544785e-02f, 1.51392475e-01f, 8.36605206e-02f, 7.11942613e-02f, -1.39737746e-03f, 1.39976561e-01f, 1.69508010e-02f, -1.20573025e-02f, -1.57633200e-02f, 6.94135251e-03f,
  5.30211404e-02f, -9.97932814e-03f, -3.36390100e-02f, -1.56462081e-02f, 1.71380583e-02f, 1.35950282e-01f, 6.31269300e-03f, 3.05585451e-02f, -7.01918975e-02f, 1.21121351e-02f,
  6.71379268e-02f, 5.06664207e-03f, 2.53539206e-03f, -4.41614958e-03f, 2.00220067e-02f, 1.84769873e-02f, 1.72462629e-03f, 6.90555796e-02f, -1.17244171e-02f, 4.46115546e-02f,
  -1.40122548e-01f, -6.07036380e-03f, 1.37365991e-02f, 1.69832073e-02f, -4.06168252e-02f, -4.29801866e-02f, 2.10632458e-02f, -2.40470096e-03f, 3.37724127e-02f, -1.00139633e-01f,
  -2.71816164e-01f, -2.99261868e-01f, -1.36311501e-01f, 7.39927543e-03f, -6.98767463e-03f, -2.53519006e-02f, -3.91508406e-03f, -2.38177050e-02f, -1.63379982e-01f, -2.52594724e-02f,
  -1.57416817e-02f, -4.93419915e-02f, -6.20641299e-02f, 1.04530469e-01f, -5.73158674e-02f, -2.93212105e-02f, -4.24461477e-02f, -2.37656012e-02f, -1.04814626e-01f, -3.08058616e-02f,
  -1.17968628e-02f, -3.84545512e-02f, -8.77213851e-02f, 3.55239101e-02f, 9.46873948e-02f, 1.27707263e-02f, -7.29651004e-02f, 3.80369537e-02f, 2.80290674e-02f, 9.51956138e-02f,
  -6.29024148e-01f, -2.30010808e-01f, 3.78067382e-02f, -2.96477765e-01f, 1.42754138e-01f, 2.54194111e-01f, -9.66896042e-02f, -2.26168498e-01f, -3.49816382e-01f, -3.11327189e-01f,
  -1.93433508e-01f, -6.93101808e-02f, -1.44999430e-01f, 1.43515587e-01f, 3.47592235e-01f, 9.23694074e-02f, -6.17398322e-02f, 1.27377398e-02f, 9.10411701e-02f, -1.00323692e-01f,
  8.84062648e-02f, 8.09534267e-02f, 1.78190678e-01f, 2.38979682e-01f, -4.72041313e-03f, 7.40580782e-02f, 7.53056780e-02f, 2.02311635e-01f, 2.41780922e-01f, 2.68626362e-01f,
  -1.58716276e-01f, -3.19393814e-01f, -1.52217448e-01f, -3.40350010e-02f, -5.20636588e-02f, 5.76632544e-02f, 1.60620303e-03f, 1.60887823e-01f, -4.16767485e-02f, -4.31844927e-02f,
  7.62997642e-02f, 1.06294595e-01f, 1.01148605e-01f, 1.17733575e-01f, 2.58578416e-02f, -2.04723626e-02f, 5.74941002e-02f, -1.49840519e-01f, -2.95157079e-02f, -1.53170619e-02f,
  -2.15257611e-02f, -2.38686707e-02f, 1.29590770e-02f, 1.85927339e-02f, -1.31195458e-02f, -1.76189058e-02f, -1.94587058e-03f, 3.74384001e-02f, -3.94936837e-02f, -5.47891185e-02f,
  1.12539545e-01f, 8.64932612e-02f, 4.51707579e-02f, -9.12640840e-02f, 3.67398513e-03f, 4.27476205e-02f, 7.89745152e-02f, 5.14410324e-02f, 7.86165074e-02f, 4.71727662e-02f,
  -7.31517673e-02f, -6.97118193e-02f, -1.25344515e-01f, 2.29244633e-03f, 4.69669253e-02f, -5.58596663e-02f, 1.62991174e-02f, 9.27385991e-04f, 7.06538232e-03f, 3.53651568e-02f,
  -1.06123313e-01f, 5.05140461e-02f, -1.89706475e-01f, 2.59322897e-02f, 2.84770112e-02f, -4.05205674e-02f, 1.84653588e-02f, -7.50209317e-02f, -7.05862418e-02f, 2.23292187e-02f,
  -3.19712281e-01f, -3.02450716e-01f, 4.79489267e-02f, -1.39966771e-01f, 2.13510245e-02f, -7.17441924e-03f, 1.61720499e-01f, 5.13627641e-02f, -6.63880631e-02f, -1.09160997e-01f,
  7.84292724e-03f, 4.63592820e-02f, 2.77327886e-03f, -3.71910422e-03f, 1.98547155e-01f, -1.09645084e-01f, -9.51612741e-03f, -1.12154886e-01f, -8.71278197e-02f, 5.27874790e-02f,
  -2.01831982e-02f, 4.56525683e-02f, 1.62806019e-01f, 9.89410058e-02f, 1.15952538e-02f, -3.11870947e-02f, -1.61935553e-01f, 5.41837476e-02f, 1.10270888e-01f, 4.62390706e-02f,
  -1.62581205e-02f, 2.23851591e-01f, 2.51647323e-01f, 3.91844869e-01f, -2.47830421e-01f, -2.51465887e-01f, -2.20765635e-01f, -7.50324354e-02f, 6.96199597e-04f, -4.54333946e-02f,
  -1.19962364e-01f, 3.11346292e-01f, -4.00321364e-01f, 3.25208575e-01f, 1.27462894e-01f, -1.25928119e-01f, 2.19135404e-01f, 1.26955390e-01f, -3.62723656e-02f, 1.05737224e-01f,
  1.63830221e-01f, 6.30315691e-02f, 1.41689792e-01f, 1.23362608e-01f, 2.67046005e-01f, 3.17666054e-01f, 1.57430470e-01f, 5.90386475e-03f, 4.51175272e-01f, 1.10294171e-01f,
  -3.96541394e-02f, -6.16961271e-02f, 1.44909425e-02f, 1.85077824e-02f, -8.14948231e-02f, -9.12719890e-02f, -2.14155167e-02f, -4.78607491e-02f, -6.54969513e-02f, 5.92844225e-02f,
  2.27575619e-02f, 1.10597022e-01f, 7.97400624e-02f, -4.73976098e-02f, -1.16932373e-02f, 1.38742879e-01f, 5.35282865e-02f, 2.41875555e-02f, 1.14373721e-01f, 4.50986773e-02f,
  1.05653472e-01f, 2.69619208e-02f, 1.81176439e-02f, 1.39664575e-01f, 1.25291839e-01f, 5.73985875e-02f, 1.74233392e-01f, -5.24455914e-03f, 2.57116199e-01f, 1.00657523e-01f,
  -8.00866932e-02f, -4.34573786e-03f, 2.27972865e-02f, 4.48710844e-02f, 3.27076688e-02f, 2.15571113e-02f, 4.89923824e-03f, -1.85301919e-02f, 3.03648356e-02f, -4.79302928e-03f,
  9.21444520e-02f, 9.35737267e-02f, -1.07608531e-02f, 5.32560656e-03f, -2.30196342e-02f, 1.45334331e-02f, -1.42576829e-01f, 5.08670881e-02f, 9.36487243e-02f, 1.23581104e-02f,
  -3.68773267e-02f, -9.27817542e-03f, 1.99875012e-02f, -2.28810087e-02f, -7.47374967e-02f, 7.21636340e-02f, 5.58095574e-02f, 2.60720756e-02f, -7.44389072e-02f, -9.56156030e-02f,
  -4.38021719e-02f, 1.16481207e-01f, -3.72335850e-03f, -1.66715942e-02f, -4.30319039e-03f, 3.49331610e-02f, 1.60702057e-02f, 5.39527796e-02f, 9.30471942e-02f, 1.85511187e-02f,
  -2.53702048e-02f, -5.47793061e-02f, -3.70165184e-02f, 1.74295157e-02f, 3.77379619e-02f, 3.27496454e-02f, 3.20606865e-02f, 2.20240057e-02f, 6.18517064e-02f, 5.34648560e-02f,
  3.50924730e-02f, -8.46950412e-02f, 1.14563257e-01f, -5.91287389e-02f, 8.47435743e-02f, -3.31367142e-02f, -4.43605259e-02f, 2.79021971e-02f, 9.61916223e-02f, -3.07312254e-02f,
  -2.03814358e-01f, -4.09047585e-03f, -3.01609427e-01f, -2.10418463e-01f, 1.07674845e-01f, -3.48705709e-01f, -2.26921558e-01f, -8.78812373e-02f, 6.43434823e-02f, 2.36481979e-01f,
  1.82559981e-03f, 5.48573136e-02f, 1.55867592e-01f, -3.66082311e-01f, -4.50106531e-01f, -6.17724881e-02f, -4.21227932e-01f, -1.67712674e-01f, 1.07290186e-01f, -1.30987018e-01f,
  -8.72148573e-02f, -1.04217216e-01f, -2.23957807e-01f, 1.47579163e-01f, -1.36686921e-01f, 6.09056652e-02f, 2.55326748e-01f, 1.60605729e-01f, -5.59971370e-02f, -1.82317086e-02f,
  -1.26816288e-01f, 7.14460462e-02f, -3.94999720e-02f, -7.08576366e-02f, -1.19407885e-01f, 4.30470407e-02f, 2.49026716e-02f, -3.56474705e-02f, 1.35250658e-01f, 3.01913396e-02f,
  1.21709406e-02f, 1.30192205e-01f, -5.24566956e-02f, 9.47227478e-02f, -3.34877521e-02f, 2.72333641e-02f, 4.07059863e-02f, -2.15411987e-02f, 4.07682732e-03f, -1.22446224e-01f,
  -5.92751987e-02f, -4.64011133e-02f, 1.89364713e-04f, 3.74091305e-02f, -1.33629525e-02f, -2.94354595e-02f, -6.59276918e-02f, 2.41267234e-02f, 4.21466678e-02f, 5.81739992e-02f,
  -2.23677512e-03f, 3.02391760e-02f, -7.34221702e-03f, 1.70828905e-02f, 1.07549066e-02f, -3.83459069e-02f, -4.66823578e-02f, -6.91641048e-02f, 2.81047300e-02f, -2.22584661e-02f,
  4.67037968e-03f, -6.69868663e-02f, -1.20387264e-02f, -4.42313291e-02f, -1.06529795e-01f, -1.33822151e-02f, -4.71350811e-02f, 4.90386784e-02f, -8.89540315e-02f, 1.69207547e-02f,
  2.90730614e-02f, -6.61830455e-02f, 3.44194584e-02f, -3.35497782e-02f, -1.10644907e-01f, 9.46321040e-02f, 8.95949900e-02f, -1.71119310e-02f, 9.28886458e-02f, 3.58165838e-02f,
  -7.90297687e-02f, 1.94281302e-02f, -5.11108339e-02f, 4.39983644e-02f, 1.63208339e-02f, 3.75387967e-02f, -7.61545300e-02f, -2.01835632e-02f, 5.09719923e-02f, 1.13274843e-01f,
  -6.14678115e-02f, 9.54707116e-02f, 9.99958292e-02f, -6.08753189e-02f, -9.25249010e-02f, -1.21114418e-01f, 7.19019547e-02f, 1.49939239e-01f, -2.82223150e-02f, -4.50694785e-02f,
  1.02012955e-01f, 1.38406917e-01f, 3.39057408e-02f, 1.05391264e-01f, 5.96884713e-02f, 3.41321081e-02f, 6.14850633e-02f, 5.43790637e-04f, -2.71271239e-03f, 6.16333894e-02f,
  2.25755706e-01f, -1.66125238e-01f, 1.37362793e-01f, 4.30390567e-01f, 1.78801492e-01f, -2.62157351e-01f, 3.91457640e-02f, 5.98217621e-02f, 3.51101816e-01f, -4.07245278e-01f,
  -9.99963954e-02f, -2.70029664e-01f, -3.50739211e-01f, 2.18203396e-01f, 3.06776166e-01f, -1.79114968e-01f, 2.51016647e-01f, -3.27835269e-02f, 8.22439790e-02f, 5.89820035e-02f,
  3.03633660e-01f, 1.25685588e-01f, 2.01711264e-02f, 3.40909921e-02f, 1.26973018e-01f, 1.24871418e-01f, 8.88505280e-02f, 4.07645851e-02f, 6.97029531e-02f, 1.22505747e-01f,
  -2.20826995e-02f, 1.23080388e-01f, 4.30742465e-02f, 5.24053574e-02f, 1.16147241e-02f, -1.23422541e-01f, -6.80072084e-02f, 3.32736317e-03f, 1.21268503e-01f, -1.35130256e-01f,
  -3.89351137e-02f, 5.36957830e-02f, 1.53341461e-02f, 3.25439945e-02f, 2.23014385e-01f, 1.70816660e-01f, 3.59662585e-02f, 2.53098421e-02f, -1.81867853e-02f, -1.31002322e-01f,
  -4.98476848e-02f, 2.71554608e-02f, 1.20024987e-01f, 2.65897196e-02f, 1.16571039e-01f, 1.17723122e-01f, -2.74666809e-02f, -4.40413430e-02f, 3.04473527e-02f, 6.80715442e-02f,
  -3.64380367e-02f, -6.41912445e-02f, -8.61348957e-02f, -3.67850773e-02f, 4.09470573e-02f, 1.70787349e-01f, 4.39554006e-02f, -5.36191873e-02f, 5.79345524e-02f, 3.45528498e-02f,
  1.17185853e-01f, 9.55553725e-02f, 7.59819224e-02f, 4.84635271e-02f, 3.63226756e-02f, -1.00178421e-01f, -3.68272960e-02f, -7.84383938e-02f, 6.45444244e-02f, 1.23430528e-02f,
  -1.92322638e-02f, 7.05738962e-02f, -4.04640362e-02f, 6.67711049e-02f, 2.04949174e-02f, 5.99824041e-02f, -5.19464575e-02f, -1.23081431e-01f, -3.00878249e-02f, -9.92909223e-02f,
  -1.52250612e-02f, 2.75240038e-02f, -3.76520194e-02f, 5.15324175e-02f, -5.28244860e-03f, -2.74096485e-02f, 3.52356620e-02f, 5.69955967e-02f, 1.14968129e-01f, -1.05532505e-01f,
  1.99912861e-02f, 4.75567393e-02f, -6.60191402e-02f, 7.14504644e-02f, 1.32179514e-01f, -3.49456221e-02f, 1.05428009e-03f, 5.92701733e-02f, 1.30322799e-01f, -7.82633871e-02f,
  -4.72891703e-02f, -1.71603803e-02f, 1.77047681e-02f, 6.42874911e-02f, -6.79465430e-03f, -6.31366447e-02f, -8.25619549e-02f, 6.03254475e-02f, 4.87670414e-02f, -1.68784130e-02f,
  1.46250144e-01f, 2.00496182e-01f, 2.92197526e-01f, -1.34078577e-01f, -2.87072837e-01f, 1.69723570e-01f, -1.57429323e-01f, 1.98070616e-01f, 2.98919946e-01f, 9.11595225e-02f,
  -2.78521895e-01f, 2.58404315e-01f, 1.93270184e-02f, -2.59791136e-01f, 1.58855900e-01f, 8.43650103e-02f, -1.74838111e-01f, -8.65970403e-02f, 3.45602073e-02f, -5.06250225e-02f,
  -1.72685459e-01f, -4.02470767e-01f, -2.86662668e-01f, -1.10236414e-01f, -2.15678006e-01f, -1.59082916e-02f, -3.28052193e-01f, -1.74215272e-01f, -1.95233837e-01f, -8.79320428e-02f,
  -2.80960836e-02f, -8.51109177e-02f, -1.07261643e-01f, 2.97417343e-02f, 4.33171466e-02f, 5.44880554e-02f, -8.14983994e-02f, -1.60917237e-01f, -6.48996308e-02f, 2.51194946e-02f,
  5.49995378e-02f, -6.08576611e-02f, -8.76911879e-02f, -2.99640391e-02f, -8.21224824e-02f, 4.98920158e-02f, -7.24269077e-02f, -1.31693305e-02f, -7.98224881e-02f, 5.58359511e-02f,
  4.71632257e-02f, 8.07344168e-03f, 9.89850163e-02f, -2.33517364e-02f, -1.17236927e-01f, -1.50894551e-02f, 4.67578508e-02f, -3.43291014e-02f, -3.78864184e-02f, 5.58962338e-02f,
  -3.84982005e-02f, -1.18515668e-02f, -6.07644841e-02f, 4.36162539e-02f, 4.02317718e-02f, -1.45250950e-02f, 6.52019009e-02f, -4.50731181e-02f, 6.63988665e-02f, -6.79248273e-02f,
  -6.02520350e-03f, -9.32868496e-02f, 9.52475145e-03f, 1.25860879e-02f, -5.25504686e-02f, 1.17153399e-01f, -8.88062492e-02f, 1.35957226e-02f, 4.01118249e-02f, 1.66823670e-01f,
  -7.35687837e-02f, -7.88579956e-02f, 7.23489448e-02f, -4.81201783e-02f, -4.27600965e-02f, 5.35305291e-02f, 8.98684561e-02f, -3.11626028e-02f, -3.65019739e-02f, -6.40448928e-02f,
  6.00473806e-02f, 4.92760539e-02f, -5.98992668e-02f, -3.85963358e-02f, 6.37375563e-02f, 4.81163664e-03f, -9.88283902e-02f, -4.58971448e-02f, -2.48133019e-02f, 7.76801407e-02f,
  -5.25026023e-02f, -6.37064502e-03f, 9.54829454e-02f, 1.76374633e-02f, 2.66359895e-02f, 1.28297582e-02f, -1.77581161e-01f, -4.23028246e-02f, -8.09550062e-02f, -8.09297431e-03f,
  -1.40348583e-01f, -1.10600637e-02f, 6.73539564e-02f, -7.89888352e-02f, -1.09940514e-01f, 1.24544902e-02f, 2.89075989e-02f, -7.93408155e-02f, -5.49118593e-02f, 9.71122761e-04f,
  1.57935575e-01f, -2.19868898e-01f, -2.02805862e-01f, 7.38995969e-02f, 3.19498107e-02f, 1.06061332e-01f, -8.13988969e-02f, -3.63690332e-02f, -2.53609091e-01f, -7.09156469e-02f,
  9.47791934e-02f, 7.33709931e-02f, -1.83204040e-01f, 2.29481429e-01f, 3.79713178e-01f, -1.61409423e-01f, 3.28261703e-01f, 9.72186923e-02f, -1.62522033e-01f, 9.82947573e-02f,
  7.41198063e-02f, 3.13899666e-01f, -1.89508090e-03f, 2.14800581e-01f, 2.29266822e-01f, 1.04756996e-01f, 2.68455029e-01f, 7.60997310e-02f, 3.81507456e-01f, 2.03280851e-01f,
  1.93576869e-02f, -6.28144145e-02f, 2.38951463e-02f, 4.94882464e-02f, 5.25534414e-02f, 5.27682602e-02f, 6.26395643e-02f, 2.27759436e-01f, 2.67854575e-02f, 3.57325226e-02f,
  1.13491707e-01f, 9.14390981e-02f, 3.19551975e-02f, 7.53109232e-02f, 8.44831765e-02f, 3.45559977e-02f, -2.31792256e-02f, -8.63396302e-02f, -4.47570020e-03f, -5.38020581e-02f,
  -1.32800952e-01f, -5.91781884e-02f, -2.66306422e-04f, 4.39448133e-02f, 7.89128989e-02f, -1.42094307e-02f, -1.14895701e-02f, -1.83469709e-02f, -3.81424204e-02f, 6.56723902e-02f,
  5.23640029e-02f, -6.41762391e-02f, 7.46388063e-02f, -9.85328555e-02f, -2.01235265e-02f, -1.74719561e-02f, 3.99369486e-02f, -3.28892916e-02f, -2.06460711e-02f, 1.50344688e-02f,
  -1.13077916e-01f, 5.32357283e-02f, -4.06905711e-02f, -1.19312406e-02f, 4.28825170e-02f, -1.08761661e-01f, 3.25998589e-02f, 9.68716517e-02f, 1.57514289e-02f, -7.02191144e-03f,
  -1.73917860e-02f, 8.77657831e-02f, -1.02162004e-01f, -1.94189101e-02f, -9.54506099e-02f, 9.25248265e-02f, 9.35302228e-02f, 1.16780974e-01f, -1.04955144e-01f, 9.73313600e-02f,
  2.52636373e-02f, 8.59316066e-02f, 2.81646214e-02f, -1.12972362e-02f, -2.50258632e-02f, 8.52550194e-02f, 6.55513480e-02f, 1.48914024e-01f, 1.58964783e-01f, 6.23506233e-02f,
  1.07011169e-01f, -9.18725692e-03f, -7.39469426e-03f, 8.95210281e-02f, 7.34234899e-02f, -7.67596364e-02f, 2.22178772e-02f, 5.88512048e-02f, 2.43838523e-02f, 7.30519518e-02f,
  3.44384611e-02f, -4.41458076e-02f, 8.06001350e-02f, 5.30863889e-02f, 1.29488230e-01f, -3.24609503e-02f, 3.45819071e-02f, -4.56104763e-02f, 9.25832801e-03f, 1.79733541e-02f,
  8.41670483e-02f, -2.26990715e-01f, -3.63554776e-01f, -2.69577920e-01f, 5.13531491e-02f, -2.87410736e-01f, -4.51678149e-02f, -2.02825397e-01f, -9.45129544e-02f, 1.04236424e-01f,
  3.69899459e-02f, -1.31659200e-02f, 2.73222059e-01f, -1.65489167e-01f, -2.15608791e-01f, 1.69565350e-01f, -3.93074811e-01f, -1.59672707e-01f, -6.58424050e-02f, -6.21986613e-02f,
  -9.94430035e-02f, 8.25813189e-02f, -1.78924158e-01f, 3.64224724e-02f, 5.32135740e-03f, -5.47745749e-02f, 1.31578699e-01f, 2.96084821e-01f, -1.26830563e-01f, 6.34381473e-02f,
  1.14389211e-02f, 1.37568757e-01f, -9.20656770e-02f, -2.70792414e-02f, -1.16788484e-01f, 1.34650305e-01f, 2.90623140e-02f, 6.19450957e-02f, 2.72072889e-02f, -6.91141933e-02f,
  1.01628609e-01f, 1.82735726e-01f, -1.63202994e-02f, 1.18309222e-01f, 2.46513989e-02f, 1.03471251e-02f, 2.67192796e-02f, -9.35436413e-02f, 2.86381431e-02f, 4.83971164e-02f,
  3.44590805e-02f, -7.58098066e-02f, -2.75721252e-02f, 1.57629997e-02f, 2.54398175e-02f, 8.18487182e-02f, 6.02478310e-02f, 3.89323533e-02f, -3.55434380e-02f, -1.04549050e-01f,
  5.42879440e-02f, 1.65796146e-01f, 5.71644083e-02f, -1.58331558e-01f, -4.68884334e-02f, 2.99478453e-02f, 1.77111812e-02f, -1.26278371e-01f, -7.77428821e-02f, 4.09325846e-02f,
  -1.02227680e-01f, -1.07695222e-01f, 7.40399137e-02f, -4.49296571e-02f, 6.62029237e-02f, 1.17945097e-01f, 4.25619818e-02f, 3.97918113e-02f, -1.56431094e-01f, -2.12795496e-01f,
  1.43145397e-01f, -1.15932766e-02f, -1.06358370e-02f, 2.69940309e-02f, 1.84740815e-02f, -6.01620530e-04f, 5.01493849e-02f, -1.82637125e-02f, -9.99820381e-02f, -1.05574485e-02f,
  -1.27741814e-01f, 1.41695281e-03f, 1.22689661e-02f, -3.47375870e-02f, -2.22732611e-02f, -3.61150429e-02f, -1.19732181e-02f, -1.68067425e-01f, -5.29427230e-02f, -4.35384410e-03f,
  -8.58726427e-02f, 9.11616683e-02f, 4.62214127e-02f, -2.31619105e-02f, -4.63257618e-02f, -6.62975609e-02f, 2.27428034e-01f, -3.92676517e-02f, -3.66069600e-02f, 4.42771008e-03f,
  6.02153130e-02f, 6.79040551e-02f, 9.24830437e-02f, 1.91396922e-02f, 1.63025856e-02f, 6.92143589e-02f, 7.36086145e-02f, -1.69958044e-02f, 5.08368909e-02f, -4.08289991e-02f,
  -1.11876406e-01f, -2.35246941e-01f, -3.32213789e-01f, 6.28932491e-02f, 3.18207920e-01f, 3.17669719e-01f, 2.09260106e-01f, 9.30750370e-02f, -4.99233678e-02f, 1.10060714e-01f,
  3.47831249e-01f, -1.78132802e-01f, -3.61946113e-02f, 3.76209915e-01f, 1.43800691e-01f, -7.46887773e-02f, 1.72483906e-01f, 1.07094884e-01f, -1.15969673e-01f, -8.05720091e-02f,
  -4.69143093e-02f, 2.36616611e-01f, 5.93578853e-02f, -8.35500956e-02f, 1.11314118e-01f, -1.94898501e-01f, 1.11816503e-01f, -1.97302252e-01f, 1.53914034e-01f, 7.80301616e-02f,
  -1.35081066e-02f, -1.37927964e-01f, 5.22898510e-02f, -1.08457930e-01f, -5.73440734e-03f, -3.25902216e-02f, -1.13748364e-01f, -4.70380336e-02f, -1.53249539e-02f, 3.58627886e-02f,
  -1.00645959e-01f, -5.72715998e-02f, 1.17887028e-01f, 1.83838848e-02f, -7.65350908e-02f, -1.51337767e-02f, 6.77611157e-02f, 1.07201725e-01f, 4.28601168e-02f, -6.44593760e-02f,
  7.70983705e-03f, 6.22633435e-02f, -8.05577356e-03f, 4.50099930e-02f, 3.41577567e-02f, 6.66721985e-02f, -6.33628443e-02f, -2.17040051e-02f, 6.01319112e-02f, 1.36811450e-01f,
  -5.20414440e-03f, -1.49243474e-01f, 7.23074898e-02f, 4.04212885e-02f, -2.96357814e-02f, 1.05070591e-01f, -2.55746599e-02f, -3.05696093e-02f, -8.53018686e-02f, 1.66677050e-02f,
  5.18636256e-02f, 8.75870809e-02f, -3.80359851e-02f, -7.46817961e-02f, 4.71184496e-03f, -2.80911475e-02f, -6.03982247e-02f, 5.70635349e-02f, -1.02727693e-02f, 1.15943223e-01f,
  -7.66342282e-02f, -5.61870933e-02f, 1.09318130e-01f, 1.80689115e-02f, 5.41445613e-03f, -3.42657641e-02f, -6.91265911e-02f, 6.96030632e-02f, 5.48640825e-02f, 1.28512932e-02f,
  -1.94570571e-01f, -3.52369159e-01f, 3.74081023e-02f, 8.24859366e-02f, -1.06835172e-01f, -7.43306009e-03f, -4.55068499e-02f, -1.09028886e-03f, -9.76648331e-02f, -3.45314145e-02f,
  -7.38052353e-02f, -5.83425239e-02f, -2.49959528e-02f, -1.33698341e-03f, -2.58563906e-02f, 1.09697536e-01f, -1.12676740e-01f, 2.06783810e-03f, 6.87940717e-02f, -7.58379176e-02f,
  -3.56875546e-02f, 4.98923771e-02f, -4.01279256e-02f, 8.44485313e-02f, 5.41482568e-02f, 1.69847570e-02f, -2.93184799e-04f, -4.00670096e-02f, 3.52041349e-02f, 3.04301865e-02f,
  1.23740643e-01f, 4.45877075e-01f, 1.06977314e-01f, 8.14199001e-02f, -3.34861614e-02f, -4.18478251e-01f, -1.94308281e-01f, 5.39012961e-02f, -1.66909490e-03f, 1.88255101e-01f,
  7.48388376e-03f, 1.44672126e-01f, 1.16072260e-01f, 1.30280316e-01f, -4.97491241e-01f, -3.03591847e-01f, -3.36990058e-02f, -1.33262336e-01f, -1.60439000e-01f, 1.88374266e-01f,
  -9.50126722e-02f, 1.14538781e-01f, -1.49476334e-01f, 1.77915961e-01f, 2.02879280e-01f, 1.46597981e-01f, 1.80748567e-01f, 1.70362890e-01f, 2.63749175e-02f, -7.74678066e-02f,
  7.08301412e-03f, 2.10972667e-01f, -1.90391466e-02f, -1.23531464e-02f, -1.23664595e-01f, -3.35233882e-02f, -7.27565810e-02f, 7.06275851e-02f, -3.38720866e-02f, -8.06101039e-03f,
  7.97388554e-02f, 5.93583733e-02f, 3.12760025e-02f, -1.18789654e-02f, 1.52103305e-01f, 8.93620774e-02f, -2.49828678e-02f, -8.83988589e-02f, 3.70413326e-02f, 1.23638436e-01f,
  2.23990437e-02f, 7.91154429e-02f, 6.37219176e-02f, -3.47964354e-02f, -3.21878009e-02f, 2.20446289e-02f, 3.63306887e-02f, 2.00584866e-02f, 5.28645664e-02f, 3.30772786e-03f,
  1.68615058e-01f, 1.76060367e-02f, -3.90514173e-02f, -5.03967442e-02f, -5.55282980e-02f, 6.63427189e-02f, 1.01170354e-01f, -5.99601530e-02f, -5.71882725e-02f, 7.34827816e-02f,
  -1.97129212e-02f, -2.87725311e-03f, 1.14593960e-01f, -2.26923209e-02f, -6.50766073e-03f, 5.32662868e-02f, -3.03335730e-02f, 3.42162512e-03f, -1.89850461e-02f, -6.58846274e-02f,
  2.01720465e-02f, 2.88023204e-02f, -2.63155308e-02f, 9.64667574e-02f, -3.72408517e-02f, -3.96645535e-03f, 1.01374038e-01f, 9.08019138e-04f, -2.02220734e-02f, -1.15426816e-02f,
  -4.48636301e-02f, 1.13527291e-01f, -2.29055975e-02f, -4.50069942e-02f, -6.88344315e-02f, -6.51997700e-02f, -6.25971630e-02f, 2.30069403e-02f, 3.41780521e-02f, -5.58628961e-02f,
  8.29566717e-02f, -3.54307145e-02f, -1.35503381e-01f, 7.73752481e-02f, 5.68524674e-02f, 3.65700871e-02f, 5.98620512e-02f, -5.57640344e-02f, 3.51784788e-02f, 8.89051184e-02f,
  8.20975527e-02f, 1.35756522e-01f, -1.36000412e-02f, -8.11423957e-02f, 5.30969054e-02f, -4.53081392e-02f, 8.76466483e-02f, 1.21838301e-01f, 1.46379486e-01f, 2.49672662e-02f,
  -1.74747616e-01f, -5.79523087e-01f, 3.38252238e-03f, 1.80747896e-01f, 3.97261865e-02f, -1.40806790e-02f, -2.22460125e-02f, 3.63167226e-02f, -4.74726558e-02f, -2.74319172e-01f,
  -2.37955935e-02f, -2.79145777e-01f, -1.69565007e-01f, 1.95675924e-01f, 1.49982432e-02f, 1.22422352e-01f, 1.56514615e-01f, 8.91540945e-03f, 1.98679715e-01f, 8.10063258e-02f,
  2.10940659e-01f, 1.42211303e-01f, 1.01246908e-01f, 8.31312835e-02f, 6.34612218e-02f, 1.25269473e-01f, -2.72995085e-02f, -5.89875057e-02f, 1.35958925e-01f, -5.25545422e-03f,
  -4.88748960e-02f, 3.82399298e-02f, 5.29868156e-02f, -8.57314095e-04f, 3.31476368e-02f, -1.06344083e-02f, -3.28347273e-02f, 9.72945988e-03f, 9.75205526e-02f, -1.11430213e-01f,
  -9.90275219e-02f, 3.32732834e-02f, 1.32670298e-01f, 2.27707829e-02f, 7.59472623e-02f, -1.23386653e-02f, 3.70304324e-02f, 1.37424171e-02f, -4.65146340e-02f, -6.83245882e-02f,
  -9.68089178e-02f, -2.73562483e-02f, 5.48351519e-02f, 1.90366153e-03f, 6.85092211e-02f, -3.31798941e-02f, 1.27929807e-01f, -8.48596320e-02f, -5.97398123e-03f, -4.02419195e-02f,
  1.22189403e-01f, 6.90211914e-03f, -6.02245219e-02f, -4.27573770e-02f, -6.19774871e-02f, 5.69704883e-02f, -2.14789528e-02f, 6.75183088e-02f, 1.07781701e-01f, 2.08908208e-02f,
  3.69726643e-02f, 1.24462489e-02f, 1.59231320e-01f, 2.73401085e-02f, 4.86879908e-02f, 9.67465565e-02f, -7.15072965e-03f, 5.66440076e-02f, 2.72176806e-02f, 3.11864205e-02f,
  -1.52352899e-01f, -4.87358905e-02f, -5.65748587e-02f, 1.41882487e-02f, -9.98602957e-02f, -9.47698057e-02f, 1.53266311e-01f, 4.80354801e-02f, 2.45280880e-02f, -1.17133252e-01f,
  -5.00544906e-01f, -2.94998646e-01f, -9.98075027e-03f, 3.57606485e-02f, -8.20889622e-02f, -3.81839573e-02f, 7.23240525e-02f, -1.54024677e-03f, -1.21441469e-01f, -4.06763665e-02f,
  -9.11835022e-03f, 7.45238736e-02f, -4.14412096e-02f, 1.71434402e-01f, 3.71880382e-02f, -1.05323099e-01f, 7.00335717e-03f, -1.13864899e-01f, -2.21694425e-01f, -1.16829500e-02f,
  -9.42320675e-02f, -6.34815767e-02f, 1.78407356e-02f, 4.51701023e-02f, 1.02954522e-01f, -1.85237467e-01f, -9.43786502e-02f, -4.95668240e-02f, 4.54883873e-02f, -6.39336705e-02f,
  -3.49488884e-01f, -8.71447325e-02f, 2.39626229e-01f, -1.77684918e-01f, -6.23584613e-02f, 3.09408009e-01f, 3.28416675e-01f, -2.37631485e-01f, -2.85938501e-01f, -2.40703642e-01f,
  -1.23597473e-01f, 5.19666411e-02f, 1.48071542e-01f, -9.43053141e-02f, 3.98502588e-01f, 1.61407977e-01f, -2.73445901e-02f, -9.79495235e-03f, -7.01992065e-02f, -1.31285653e-01f,
  -9.94053259e-02f, -1.43531814e-01f, 3.35898519e-01f, -2.00171754e-01f, -1.10848941e-01f, 3.23737264e-02f, 1.47376098e-02f, 2.43937030e-01f, -1.23716138e-01f, 1.85609847e-01f,
  9.41393450e-02f, -2.57993788e-01f, -1.66166853e-02f, 5.10053523e-02f, -4.86777760e-02f, 6.71967342e-02f, 1.87749475e-01f, 2.66461343e-01f, 4.91780527e-02f, -3.87094244e-02f,
  -7.83307198e-03f, -1.75086353e-02f, -1.63312092e-01f, -2.20597945e-02f, -1.99645370e-01f, -7.94652700e-02f, -1.41285863e-02f, -5.32392412e-02f, 4.34963815e-02f, -4.84480970e-02f,
  1.62895788e-02f, -3.92346606e-02f, -1.41565442e-01f, 1.61505435e-02f, 1.11312512e-02f, -3.02532669e-02f, 7.15496168e-02f, 8.02845657e-02f, -7.83959627e-02f, -3.77825350e-02f,
  4.65163067e-02f, 1.99510641e-02f, -1.78226694e-01f, -5.68620227e-02f, -7.39496350e-02f, -4.05096523e-02f, -1.01930439e-01f, -9.22599435e-03f, 3.98540087e-02f, -4.23948728e-02f,
  -1.10969646e-02f, -5.15977181e-02f, -1.05741741e-02f, 2.14424990e-02f, -2.63736784e-01f, -1.18177027e-01f, 9.86800864e-02f, -2.36651418e-03f, -1.17304988e-01f, 1.93456486e-02f,
  -1.04860358e-01f, 9.55116525e-02f, 2.19006892e-02f, 3.36458837e-03f, 2.32361071e-02f, -2.51803119e-02f, 1.11107817e-02f, -5.09998156e-03f, 9.76804644e-02f, 7.51965493e-02f,
  1.98611572e-01f, -4.32607718e-02f, 2.82229614e-02f, 9.53807160e-02f, 6.91641793e-02f, -3.27763297e-02f, -4.05474147e-03f, -6.55027330e-02f, -1.22339372e-02f, -1.94262695e-02f,
  -1.47357002e-01f, 4.68056090e-02f, -4.21543941e-02f, 1.74491052e-02f, -2.12406311e-02f, 4.61123027e-02f, 1.52674258e-01f, -8.60468671e-03f, 1.06869832e-01f, -8.28673840e-02f,
  2.38044709e-02f, 2.05819476e-02f, -1.26931950e-01f, -1.07105620e-01f, -2.12571949e-01f, -3.41905132e-02f, -7.31058493e-02f, 5.52281179e-03f, -1.53812449e-02f, 7.83069283e-02f,
  4.36214119e-01f, -1.65129736e-01f, 2.32939392e-01f, 3.28290612e-01f, 1.08561747e-01f, -4.31168191e-02f, 3.97849500e-01f, -1.90586612e-01f, -7.53932521e-02f, -2.73134917e-01f,
  -1.70167536e-02f, 2.76889086e-01f, 1.84215486e-01f, -1.58655271e-01f, -5.22176139e-02f, -1.78327695e-01f, -5.49104996e-02f, 1.30689874e-01f, 1.12620024e-02f, 1.20045759e-01f,
  5.38560525e-02f, -2.71904916e-01f, 1.43210694e-01f, -3.82690012e-01f, 2.38813907e-01f, -3.84105672e-03f, -1.44389048e-01f, 1.79888427e-01f, -1.67060226e-01f, -1.88776795e-02f,
  8.09554104e-03f, -1.46451136e-02f, 1.08560711e-01f, -1.18666634e-01f, -3.09641715e-02f, 5.38918115e-02f, 7.87707567e-02f, 4.98900153e-02f, 4.41671237e-02f, 1.32384747e-02f,
  5.23399748e-02f, -5.92889376e-02f, 3.22620664e-03f, 9.81164817e-03f, 7.99867362e-02f, -1.53487278e-02f, -5.89079857e-02f, 1.23038806e-01f, 2.64347009e-02f, 8.09153616e-02f,
  1.08099267e-01f, 1.21979430e-01f, 1.25662565e-01f, 2.18438227e-02f, -4.06231079e-03f, 2.64474750e-02f, -1.74714811e-02f, 1.27781555e-01f, 5.69032952e-02f, 2.62588188e-02f,
  -1.28963724e-01f, 2.69246940e-02f, 1.23981778e-02f, -1.18758008e-02f, 4.89696302e-03f, 1.05646968e-01f, 3.66852246e-02f, -6.45198375e-02f, 7.03517720e-02f, -1.21830665e-02f,
  1.12696122e-02f, -4.14448604e-02f, -3.25860418e-02f, 3.21809873e-02f, 2.17066891e-02f, 2.17949003e-02f, 1.30669355e-01f, -6.21769466e-02f, 6.81977794e-02f, 1.92979928e-02f,
  4.60472777e-02f, 5.61749786e-02f, -4.65970486e-02f, 3.74370068e-02f, -1.81021132e-02f, 5.20713218e-02f, -1.30530950e-02f, 5.96616976e-02f, -5.24852909e-02f, 4.74056639e-02f,
  -1.91918954e-01f, -3.65246952e-01f, -6.19704053e-02f, -5.25796711e-02f, -7.80267715e-02f, -4.74443659e-02f, -9.58325863e-02f, -9.02628303e-02f, -4.96354066e-02f, -1.23706959e-01f,
  -2.27390919e-02f, 1.07248217e-01f, -2.01203916e-02f, 1.38528310e-02f, -3.35087553e-02f, -2.34205388e-02f, -6.19253144e-02f, -1.87770054e-02f, 6.99600279e-02f, -8.21167529e-02f,
  8.30835626e-02f, 2.54114717e-02f, 4.43136171e-02f, -7.43408920e-04f, -3.21272276e-02f, 7.00434819e-02f, -7.78009295e-02f, 2.52158586e-02f, -1.07473806e-02f, -2.42929403e-02f,
  3.22326064e-01f, -1.06734343e-01f, 1.49259940e-01f, 4.57875788e-01f, 4.09805737e-02f, -4.76559818e-01f, -2.39982083e-01f, 1.58431545e-01f, 4.42814082e-01f, -4.15845543e-01f,
  3.63881439e-02f, -5.59573621e-02f, -4.17508818e-02f, 8.16985127e-03f, 2.14190781e-01f, -5.07783480e-02f, 2.06865042e-01f, -1.03195153e-01f, 2.65144646e-01f, 1.35887325e-01f,
  1.20966256e-01f, -1.30590588e-01f, 2.00178415e-01f, -1.96542963e-01f, -1.51266353e-02f, 1.25596374e-01f, 2.10779518e-01f, -1.48116484e-01f, -9.37426090e-02f, -6.73973188e-02f,
  2.31277235e-02f, 1.88501239e-01f, -2.33484991e-03f, -6.63786605e-02f, 1.62493259e-01f, -1.61117390e-01f, -1.24426655e-01f, -1.19339280e-01f, 1.23498932e-01f, 1.33050447e-02f,
  2.91849654e-02f, 7.38190189e-02f, 1.87358372e-02f, 3.42196301e-02f, 1.43261075e-01f, 1.06549501e-01f, 1.74026355e-01f, 6.83127716e-03f, 7.46430531e-02f, -6.20057061e-02f,
  4.73772623e-02f, 1.05612352e-01f, 1.65747374e-01f, 8.28009993e-02f, 7.14757368e-02f, 2.15478893e-02f, -1.68906227e-01f, -1.79475937e-02f, 1.45980315e-02f, 8.81150365e-02f,
  9.98451561e-03f, -5.83641306e-02f, -1.13887772e-01f, 4.29138988e-02f, 4.13222164e-02f, 1.15206957e-01f, -2.16528811e-02f, -1.02577016e-01f, 2.82206573e-02f, 2.12384854e-02f,
  1.32447660e-01f, 2.93096192e-02f, 1.28187731e-01f, -5.84010333e-02f, -6.25705021e-03f, -2.22710762e-02f, -6.57435730e-02f, -1.26852497e-01f, 8.38213265e-02f, 3.66289206e-02f,
  9.29226428e-02f, -3.66465263e-02f, 2.56425831e-02f, 4.18267287e-02f, -6.34868369e-02f, 9.44600180e-02f, 2.08792649e-02f, -1.22689061e-01f, 8.14738795e-02f, 1.46747818e-02f,
  6.96965903e-02f, 1.81974098e-02f, -4.53597791e-02f, -4.92941774e-02f, -4.82029319e-02f, -1.29844844e-01f, -1.69972971e-01f, -3.75244929e-03f, 8.01973268e-02f, -9.61228162e-02f,
  -2.76355091e-02f, 1.05964132e-01f, 3.08273248e-02f, -1.08810724e-03f, 1.37191176e-01f, -1.86232682e-02f, -4.18563411e-02f, 1.14834279e-01f, 1.07136630e-01f, 2.77841650e-02f,
  -6.31802380e-02f, -5.40289842e-02f, 9.15782526e-02f, 3.28301452e-02f, 2.02080719e-02f, 8.74671862e-02f, -5.52058183e-02f, -9.68494161e-04f, 1.25031658e-02f, 4.91059572e-02f,
  -5.13424039e-01f, 3.41116935e-02f, -1.81615446e-02f, 1.75311774e-01f, -3.26837420e-01f, -1.32735580e-01f, 4.90508862e-02f, 3.97848710e-02f, -1.51966676e-01f, 3.37584555e-01f,
  1.84801310e-01f, -2.53365666e-01f, 2.33629778e-01f, -4.67437133e-02f, -3.60025972e-01f, 3.54798362e-02f, 2.27020249e-01f, 1.42309949e-01f, -1.70599356e-01f, 1.95596144e-01f,
  4.31080498e-02f, 8.26705247e-02f, 1.64884865e-01f, 2.17744466e-02f, 3.93038467e-02f, 1.01941921e-01f, 3.87067795e-01f, -5.87917194e-02f, 2.03328684e-01f, -2.43180320e-01f,
  -5.51399589e-02f, -1.18718751e-01f, -3.38410772e-02f, -2.66367365e-02f, 1.16941616e-01f, 4.19530049e-02f, 6.70993179e-02f, -1.30361289e-01f, -8.88918266e-02f, 4.99077439e-02f,
  3.81882787e-02f, 6.27995431e-02f, -2.67848708e-02f, -1.82289794e-01f, -1.17633916e-01f, -6.10750765e-02f, -1.70197561e-02f, 2.39882711e-02f, -4.81407344e-03f, -3.90927419e-02f,
  -5.34028374e-02f, 3.74356098e-02f, 1.21957004e-01f, 9.43374261e-02f, -4.10259552e-02f, 2.91102473e-02f, 2.83934306e-02f, 5.25800101e-02f, 3.96336652e-02f, -1.02914788e-01f,
  -1.13589622e-01f, 9.05382335e-02f, 5.56994379e-02f, 4.45254035e-02f, -2.43213084e-02f, 3.88876311e-02f, -3.89582142e-02f, -4.07538190e-02f, -1.08527303e-01f, 5.63018098e-02f,
  9.92610678e-02f, -2.97520179e-02f, 1.83471348e-02f, 2.66713463e-02f, 2.26570219e-02f, -1.23828694e-01f, -3.62026766e-02f, 1.70179587e-02f, 5.42701893e-02f, 8.66784900e-02f,
  -3.47247091e-03f, -2.88777798e-03f, 5.70835173e-02f, 1.42076880e-01f, -3.64206843e-02f, 2.47896388e-02f, 1.19749550e-02f, -5.70237599e-02f, 1.24881126e-01f, 3.75655517e-02f,
  1.47954479e-01f, 1.96427852e-01f, 5.67513071e-02f, -3.73969637e-02f, 7.24518448e-02f, 9.99279320e-03f, -1.52523622e-01f, -5.88100888e-02f, 1.43153528e-02f, -1.82884336e-02f,
  1.45721316e-01f, 1.50658578e-01f, 1.88554868e-01f, -7.98050091e-02f, 1.10388152e-01f, 8.76045749e-02f, 2.20278576e-01f, 8.26519504e-02f, 2.06367001e-01f, 4.98672388e-02f,
  1.84983224e-01f, 8.19371864e-02f, 1.01434946e-01f, 1.61372200e-02f, 1.40234321e-01f, 1.73811674e-01f, -1.71987265e-01f, -3.23391263e-03f, 5.54145984e-02f, 3.73011604e-02f,
  -8.39997292e-01f, 3.88099164e-01f, 9.49083269e-02f, -2.87434161e-01f, 2.52229851e-02f, 3.57885882e-02f, 5.89096509e-02f, 1.08637966e-01f, -4.15479802e-02f, 2.18442306e-01f,
  8.74441788e-02f, -1.66384444e-01f, 2.91773558e-01f, 1.55734912e-01f, -2.99045295e-01f, 3.40773463e-01f, -4.12111059e-02f, -3.15118395e-02f, 1.36276556e-03f, -1.56574085e-01f,
  -1.54239282e-01f, 2.57981778e-03f, 1.30037606e-01f, 1.44837424e-01f, 1.93478297e-02f, -4.11828123e-02f, -8.86443779e-02f, 1.51131287e-01f, -8.83400161e-03f, 1.05080254e-01f,
  -2.79312342e-01f, -2.86347687e-01f, -1.74268603e-01f, -8.48532170e-02f, -9.37777162e-02f, -5.80307283e-02f, -9.93379876e-02f, 1.12841435e-01f, -1.21501004e-02f, -5.11633307e-02f,
  2.54586674e-02f, 3.37250307e-02f, 8.35411847e-02f, 7.30841458e-02f, -1.01667233e-01f, -1.21789742e-02f, 1.67732462e-01f, -3.42519186e-03f, 1.25958428e-01f, 7.25827441e-02f,
  1.33856654e-01f, 6.37089908e-02f, -4.72670384e-02f, 5.19990213e-02f, -5.00328839e-02f, 1.39604742e-02f, 5.18714003e-02f, -5.81016392e-02f, -8.73130262e-02f, -5.05981296e-02f,
  7.23977983e-02f, -1.70740820e-02f, -1.11046909e-04f, -3.85080762e-02f, 3.68003808e-02f, 9.27644297e-02f, 7.14187026e-02f, -1.12659726e-02f, 6.72274316e-03f, -3.92609574e-02f,
  -7.35165179e-02f, -7.61680305e-02f, -9.40707773e-02f, 5.00725536e-03f, 4.58857864e-02f, -4.30646073e-03f, -6.72679320e-02f, -5.18489676e-03f, 2.97761448e-02f, -1.06807649e-01f,
  -5.58430701e-02f, -2.45697871e-02f, -4.38234098e-02f, 2.16610059e-02f, 5.14117740e-02f, -1.22619523e-02f, 5.56593649e-02f, 4.63881083e-02f, -9.16690603e-02f, -4.30368586e-03f,
  -4.60517853e-01f, -4.16989475e-01f, -9.99919996e-02f, -1.26151159e-01f, -8.22101608e-02f, -2.95830909e-02f, 1.26691191e-02f, -2.00957735e-03f, -1.19380705e-01f, -8.05379916e-03f,
  -1.99417602e-02f, 2.11202968e-02f, -8.31555426e-02f, 6.87995134e-03f, 2.78349333e-02f, -8.71929526e-03f, 7.45592546e-03f, -6.99573308e-02f, -2.14325413e-01f, -4.28285412e-02f,
  4.69882488e-02f, 7.98819296e-04f, 1.04196467e-01f, 7.51607493e-02f, -3.79002914e-02f, -8.00590366e-02f, -1.12500042e-01f, 9.30651836e-03f, 8.54713935e-03f, 9.23997983e-02f,
  -1.69223249e-01f, 2.41095752e-01f, -1.68737650e-01f, -1.81252584e-01f, -2.02180758e-01f, 4.94900420e-02f, -1.28164187e-01f, 7.82061815e-02f, 3.56667526e-02f, 1.54267401e-01f,
  -1.63108602e-01f, 1.50634930e-01f, 2.52761692e-01f, -1.92421630e-01f, 3.71320173e-02f, 2.03220353e-01f, -1.17551230e-01f, -6.19608983e-02f, 1.37199461e-02f, 5.20973876e-02f,
  -8.91553313e-02f, -1.36159509e-01f, -1.64386213e-01f, 1.60267889e-01f, -3.21429968e-01f, -1.80256173e-01f, -2.22249240e-01f, -1.58610478e-01f, -2.88969845e-01f, -1.64031431e-01f,
  -1.08736902e-01f, -2.10166350e-01f, -2.95147393e-02f, -2.79961992e-02f, -9.67981890e-02f, -6.17560893e-02f, -1.87292397e-01f, -9.38960016e-02f, -3.66177782e-02f, 1.19856680e-02f,
  1.16526812e-01f, 3.14441435e-02f, 7.58358417e-03f, 7.91486800e-02f, -3.02064158e-02f, -8.43842328e-02f, -1.66435093e-01f, -9.48106200e-02f, 2.88682170e-02f, -1.52387777e-02f,
  7.98689015e-03f, -3.15407328e-02f, -9.38182399e-02f, -1.04349643e-01f, -1.95979819e-01f, -1.00136966e-01f, -9.00537446e-02f, -9.72154886e-02f, -1.17184192e-01f, -7.96226189e-02f,
  -1.00220379e-03f, -3.70978191e-02f, 9.79293417e-03f, -5.68722337e-02f, 3.50159854e-02f, -7.13279471e-02f, -9.57227498e-03f, 1.72358099e-03f, -2.49965228e-02f, -2.14362312e-02f,
  4.12043137e-03f, -1.08378068e-01f, -4.08624560e-02f, -3.07649579e-02f, -3.10492553e-02f, 9.62573960e-02f, 2.13037319e-02f, 6.11443631e-02f, 5.27834408e-02f, 1.63801275e-02f,
  -1.96331386e-02f, -3.24540064e-02f, 3.68836969e-02f, -2.88687934e-05f, -2.75651719e-02f, -1.73129857e-01f, -1.22956201e-01f, -6.66143745e-02f, 4.73063737e-02f, 3.61236348e-03f,
  -7.06684217e-02f, -2.43260473e-01f, 6.56708330e-02f, -2.13778317e-02f, 7.30114849e-03f, 4.59953435e-02f, 3.01995501e-02f, -4.75622751e-02f, -8.16588774e-02f, 6.61544427e-02f,
  7.06899082e-05f, -1.22112166e-02f, -3.61672342e-02f, -1.00816995e-01f, 1.49414197e-01f, 2.94686351e-02f, -7.40464479e-02f, -8.12250227e-02f, -9.33302641e-02f, 2.06073528e-04f,
  2.01806538e-02f, 2.65758839e-02f, 3.45921554e-02f, -5.93869388e-02f, -3.25195119e-02f, -9.62627009e-02f, 1.10133067e-01f, 2.12704428e-02f, -1.59159273e-01f, 1.55135999e-02f,
  6.57396615e-02f, 2.47907281e-01f, 1.21019423e-01f, 1.60448879e-01f, 3.03390414e-01f, 4.18462694e-01f, 1.53005555e-01f, 3.68902564e-01f, 5.28971910e-01f, -8.01425725e-02f,
  -7.03668520e-02f, 2.38553062e-02f, -6.84727207e-02f, 8.27115029e-02f, -1.78118855e-01f, 4.35824459e-03f, 9.79443789e-02f, 1.19136609e-01f, 2.81274021e-01f, -9.79495049e-02f,
  1.41749298e-02f, -1.58487067e-01f, -3.21588367e-01f, -8.78665075e-02f, 1.67066097e-01f, 1.42328138e-03f, -3.27125162e-01f, -5.29430946e-03f, -8.13362747e-02f, 1.34149656e-01f,
  2.59074382e-02f, 1.59105331e-01f, 1.80047616e-01f, 1.06377572e-01f, 1.74778439e-02f, -1.12417312e-02f, -4.23026197e-02f, 1.79533325e-02f, -7.56138787e-02f, 1.50696605e-01f,
  -3.26521955e-02f, 3.88848186e-02f, 3.07625234e-02f, 1.38022080e-01f, 1.07833572e-01f, 1.52980417e-01f, 8.12095702e-02f, 1.50166497e-01f, 1.10390112e-01f, 2.51420308e-02f,
  -1.14530018e-02f, 8.68754014e-02f, 7.55449608e-02f, 9.24117193e-02f, 7.12298378e-02f, 1.47364780e-01f, 1.03411295e-01f, 7.26391971e-02f, 1.07183225e-01f, 1.47814959e-01f,
  6.48319125e-02f, 4.56303358e-02f, 2.93286312e-02f, -7.04635233e-02f, 3.04678399e-02f, -3.31590585e-02f, 3.18403691e-02f, -4.86057177e-02f, 1.45731091e-01f, 8.94431304e-03f,
  3.14844400e-02f, 1.08636960e-01f, 1.46509096e-01f, 1.49091169e-01f, 1.43775241e-02f, 4.87745777e-02f, -3.95865180e-02f, -2.32866919e-03f, 1.08900793e-01f, -7.78884906e-03f,
  -9.26310953e-04f, -1.32701039e-01f, -2.81143170e-02f, -1.99769530e-02f, -5.42796440e-02f, 2.58339327e-02f, 5.63500524e-02f, 5.20471483e-02f, -4.87084650e-02f, -1.35497317e-01f,
  3.07420827e-02f, 3.49039696e-02f, 7.01107681e-02f, 1.17532529e-01f, -8.72165412e-02f, 8.73044729e-02f, 1.14314228e-01f, 1.45502299e-01f, 4.39267382e-02f, 1.33313388e-01f,
  -8.97235796e-02f, 1.20747849e-01f, -1.00409046e-01f, 2.41211131e-02f, -1.04111902e-01f, 8.13981444e-02f, -1.18451394e-01f, 7.01971874e-02f, -6.93786098e-03f, -2.40204055e-02f,
  -3.96870263e-02f, -3.67552899e-02f, -9.44611579e-02f, 5.52433580e-02f, -7.47676892e-03f, -1.04236893e-01f, -4.59710658e-02f, -5.36707183e-03f, -1.09034061e-01f, 6.56474158e-02f,
  1.14425890e-01f, -2.65333742e-01f, -3.44880819e-01f, 2.68503334e-02f, 5.71762957e-02f, 1.85103282e-01f, 2.48025969e-01f, -1.95617586e-01f, -2.59017855e-01f, 2.38188058e-02f,
  4.23017830e-01f, -1.43682793e-01f, 1.18038833e-01f, 4.09621775e-01f, 2.17552289e-01f, 4.72378545e-02f, 2.72734582e-01f, 2.07110628e-01f, -4.54225391e-02f, 3.05584306e-03f,
  1.03687152e-01f, 3.79435837e-01f, 1.66776180e-01f, -1.34133726e-01f, 1.89575970e-01f, -2.83693701e-01f, 1.21844314e-01f, -1.08090214e-01f, 6.52822703e-02f, 8.33613425e-02f,
  1.45955145e-01f, 9.03484039e-03f, 4.50839810e-02f, -4.50083092e-02f, 2.78745610e-02f, 1.08354427e-01f, 2.68670861e-02f, 9.78727564e-02f, -9.09757707e-03f, 2.61680558e-02f,
  -5.23973331e-02f, -1.75569393e-02f, -6.50836229e-02f, -2.92121284e-02f, 4.19096053e-02f, -9.67402235e-02f, -4.13410403e-02f, 2.07376163e-02f, -1.61090400e-02f, 3.42793912e-02f,
  -3.09157297e-02f, 1.38919102e-03f, -9.91541147e-03f, -3.67140695e-02f, -6.12497404e-02f, -4.65398952e-02f, -4.95929122e-02f, -5.21336682e-02f, -6.80725351e-02f, -1.28582969e-01f,
  -6.90728649e-02f, 4.69006747e-02f, 5.91047853e-02f, 5.86680323e-02f, 5.48883490e-02f, 7.83965290e-02f, 5.60819991e-02f, 1.03181697e-01f, -1.60819456e-01f, 5.63481934e-02f,
  1.74710844e-02f, -2.80822683e-02f, -1.72528508e-03f, 1.50252329e-02f, 1.50031121e-02f, -8.89853761e-02f, 6.27863333e-02f, -3.19434516e-03f, -4.60210964e-02f, 3.16564180e-02f,
  7.03639686e-02f, -2.91235931e-02f, -5.47842272e-02f, 1.26353398e-01f, 8.99819583e-02f, -2.70632077e-02f, 1.04574896e-01f, 6.78842068e-02f, -3.53085361e-02f, 1.64759047e-02f,
  -6.78206328e-03f, -2.67126143e-01f, -7.30119199e-02f, 6.78846100e-03f, 2.09216494e-02f, -2.30872463e-02f, -3.71732470e-03f, -1.08357564e-01f, -5.62593378e-02f, -1.96169093e-02f,
  1.20104635e-02f, -5.11689447e-02f, -4.97595817e-02f, 2.16780342e-02f, -4.11956944e-03f, -6.72721863e-02f, 2.08434183e-02f, -2.87692677e-02f, -2.40189042e-02f, -5.15345344e-03f,
  2.02153884e-02f, -2.08406243e-02f, -3.33883241e-02f, 3.21427658e-02f, -4.17612270e-02f, 7.69016072e-02f, -4.87099737e-02f, -6.65455982e-02f, 1.65840089e-02f, -9.26797166e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  2.75638729e-01f, 3.35282624e-01f, 2.10469708e-01f, 2.62310863e-01f, 2.13546365e-01f, 1.76194340e-01f, 2.69092113e-01f, 1.52184561e-01f, 3.53653789e-01f, 1.73114017e-01f,
  2.02452138e-01f, 2.46096924e-01f, 3.53941143e-01f, 1.81999460e-01f, 3.61409783e-01f, 1.04213081e-01f, 2.41140172e-01f, 2.46249005e-01f, 2.45493770e-01f, 2.99822628e-01f,
  3.35968018e-01f, 2.48248100e-01f, 2.21757382e-01f, 2.21298620e-01f, 4.61653352e-01f, 2.76631773e-01f, 3.78932029e-01f, 2.42894515e-01f, 1.49687856e-01f, 2.86186814e-01f,
  1.64435104e-01f, 1.94284305e-01f, 3.02285910e-01f, 1.08195327e-01f, 2.92522222e-01f, 2.53658980e-01f, 2.01326445e-01f, 2.40988344e-01f, 2.42292911e-01f, 2.65818119e-01f,
  2.99480736e-01f, 1.92645952e-01f, 2.77697802e-01f, 2.21909925e-01f, 2.95424610e-01f, 2.64683336e-01f, 3.16560715e-01f, 2.93177515e-01f, 1.89474851e-01f, 1.64681286e-01f,
  3.04443538e-01f, 2.08943069e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  9.39497128e-02f, -1.69461012e-01f, -3.70633453e-01f, -1.25850543e-01f, 2.99501847e-02f, -1.31279960e-01f, -2.04929024e-01f, -1.31911308e-01f, -9.24610272e-02f, 8.06305259e-02f,
  -2.40706891e-01f, -2.79758155e-01f, -2.01298296e-02f, -4.01665680e-02f, 2.15656180e-02f, -4.91522476e-02f, -1.43107802e-01f, -2.73482054e-01f, -1.70311015e-02f, 4.46626097e-02f,
  -1.10017464e-01f, 8.20122585e-02f, -3.92798474e-03f, -1.73538223e-01f, 5.64538836e-02f, -1.52116627e-01f, -1.71172634e-01f, -2.60417908e-01f, -3.80190350e-02f, -2.01151893e-02f,
  -1.40276507e-01f, -1.02586925e-01f, 6.29709661e-02f, -8.74692872e-02f, -4.25600819e-02f, -3.46986651e-02f, 1.67962834e-01f, -1.35414124e-01f, 2.03348517e-01f, 2.52148330e-01f,
  3.52929771e-01f, -2.61186302e-01f, -1.21923489e-02f, 1.90564767e-01f, 3.48839499e-02f, 3.15146595e-02f, 3.52434546e-01f, -1.83875456e-01f, -1.66385531e-01f, -1.28274873e-01f,
  6.88391998e-02f, 2.92281687e-01f, 8.39849561e-03f, -3.45006466e-01f, -2.99440324e-01f, -2.92784721e-01f, 2.65848994e-01f, -8.52048993e-02f, -3.34546775e-01f, -1.71376869e-01f,
  2.49006316e-01f, 3.77852358e-02f, -9.66041535e-02f, 8.86147693e-02f, -5.95353730e-02f, 1.98415399e-01f, -9.94250029e-02f, -1.32606849e-01f, -5.70917986e-02f, 4.18487221e-01f,
  3.17473829e-01f, -1.55713931e-01f, -3.66451234e-01f, 3.25847298e-01f, 7.98296109e-02f, -4.20810804e-02f, -3.16745609e-01f, -3.21906000e-01f, -1.70080289e-01f, -1.87795609e-01f,
  -1.61529586e-01f, 1.07304260e-01f, 3.38957071e-01f, -2.02140465e-01f, -3.98480475e-01f, 2.27779076e-02f, -1.78690448e-01f, -2.25563720e-01f, 2.65179127e-01f, 4.50533062e-01f,
  3.22886974e-01f, 1.28058150e-01f, 1.54287340e-02f, 3.90472680e-01f, -1.59624934e-01f, -1.92474768e-01f, 7.91613013e-03f, 4.62928534e-01f, 6.04149327e-02f, -1.13924846e-01f,
  -2.45935485e-01f, -9.97813344e-02f, -2.05982700e-01f, 5.58093786e-01f, -2.76965760e-02f, -3.51833135e-01f, -2.47694608e-02f, -2.75976926e-01f, -1.97084591e-01f, 5.09369314e-01f,
  -1.45027041e-01f, -1.99300051e-01f, -2.98285782e-01f, -2.04534680e-01f, -3.72533351e-01f, -4.34182733e-01f, -7.93614164e-02f, 2.79636949e-01f, -1.85309455e-01f, 2.58213639e-01f,
  1.17429905e-01f, -1.45261392e-01f, -7.03623742e-02f, 4.45320249e-01f, 3.34185183e-01f, -2.15584785e-02f, -4.25879061e-01f, 2.59119332e-01f, -3.59838635e-01f, 4.27003801e-02f,
  1.14454702e-01f, -1.16970241e-01f, -1.17253125e-01f, -6.56865686e-02f, 2.09131896e-01f, -3.31696182e-01f, 9.54265520e-02f, -4.30106461e-01f, 1.33702010e-01f, 2.58788466e-01f,
  2.27918655e-01f, -1.84052259e-01f, 1.53040597e-02f, 6.71992823e-02f, -3.40091050e-01f, -2.36234337e-01f, 1.35138512e-01f, 5.98822385e-02f, 2.14058787e-01f, 2.75076807e-01f,
  -9.74074826e-02f, 4.09311116e-01f, -6.89931912e-03f, 1.20753758e-01f, -1.39039785e-01f, -1.00176446e-01f, -4.99993488e-02f, 1.93809807e-01f, -8.53661075e-02f, -1.71651334e-01f,
  -2.02107817e-01f, -6.15765378e-02f, -3.59631509e-01f, -6.15277030e-02f, 4.36808951e-02f, -9.54136103e-02f, 2.95114696e-01f, -2.83938825e-01f, 6.39838129e-02f, 4.75239307e-01f,
  -1.17191248e-01f, 2.71176785e-01f, -2.21300766e-01f, 2.35681713e-01f, -3.11754584e-01f, -4.32694793e-01f, -2.53661331e-02f, -4.05172825e-01f, -1.41264856e-01f, 1.79010749e-01f,
  -8.90935808e-02f, 5.86739928e-02f, -1.66175202e-01f, -1.12249509e-01f, -7.85109848e-02f, -1.69873953e-01f, -2.19870731e-01f, -1.20896190e-01f, -4.60992575e-01f, 2.75892675e-01f,
  -8.20138399e-03f, 1.76849887e-02f, 4.79709148e-01f, 3.04239482e-01f, -2.96111792e-01f, -1.79471329e-01f, -1.02272667e-01f, -4.76394802e-01f, -2.05666006e-01f, -2.47410551e-01f,
  3.18349332e-01f, -3.61278623e-01f, -2.73381472e-01f, -2.11656094e-01f, 1.96433395e-01f, -2.58815199e-01f, 1.92188188e-01f, -4.85966176e-01f, -4.65727225e-02f, 4.42233711e-01f,
  7.04501718e-02f, 1.00735597e-01f, -3.66298497e-01f, -3.02241713e-01f, 2.39813879e-01f, -1.99152038e-01f, 3.94287944e-01f, 1.08930774e-01f, -4.26478416e-01f, 3.38521600e-01f,
  -6.64200932e-02f, 2.59740919e-01f, -8.42950866e-02f, 4.60072041e-01f, -5.32717645e-01f, -3.05545717e-01f, 1.63976699e-01f, -4.29800123e-01f, -5.09931862e-01f, 3.10302228e-01f,
  -1.17319569e-01f, -6.34573400e-01f, 2.56496966e-01f, -6.83981106e-02f, -4.51099426e-01f, -1.55064791e-01f, 2.55649835e-01f, -5.66186905e-02f, -3.58318448e-01f, -1.34608254e-01f,
  -2.26030201e-01f, -3.18064630e-01f, -5.21921992e-01f, 2.20184743e-01f, 2.35152453e-01f, 3.97339016e-01f, 4.02046740e-02f, -5.23098528e-01f, -3.28995883e-01f, -1.41889632e-01f,
  -4.32312012e-01f, -2.89196223e-01f, -5.21212757e-01f, -1.51671007e-01f, 1.75369576e-01f, 2.55038530e-01f, -2.99574673e-01f, 4.72568944e-02f, -5.69391102e-02f, 4.33759429e-02f,
  -5.12777641e-02f, -1.03458062e-01f, -2.89126635e-01f, 1.30829990e-01f, -3.59111913e-02f, -2.36211494e-02f, -1.18406035e-01f, -1.74001679e-01f, -3.41204196e-01f, -2.32892744e-02f,
  -2.38963395e-01f, -1.77290495e-02f, 1.54440135e-01f, -1.96949393e-02f, -1.40883513e-02f, -1.39438525e-01f, 1.44534037e-01f, -1.40773952e-01f, -1.73963234e-02f, -2.45287031e-01f,
  -3.21345963e-02f, -4.75865714e-02f, -1.31163746e-01f, 1.63075879e-01f, -8.92930385e-03f, -2.54893273e-01f, -1.20878711e-01f, -1.34966955e-01f, -2.34125406e-02f, -7.73551911e-02f,
  -1.54064834e-01f, -3.49838763e-01f, -2.25288123e-01f, -6.58930093e-02f, 5.94133064e-02f, 7.78604895e-02f, -2.58567899e-01f, -2.18059734e-01f, 1.20171793e-01f, -1.94185093e-01f,
  3.75521630e-01f, 2.46902391e-01f, -2.11414441e-01f, -1.11835552e-02f, 1.40101865e-01f, 2.06514046e-01f, -1.66877329e-01f, 3.71982902e-02f, -2.95422584e-01f, 1.16100609e-02f,
  -1.42304286e-01f, 5.62173389e-02f, 3.55004072e-02f, 9.93722305e-02f, 1.09459057e-01f, 2.99487561e-01f, -2.97779869e-03f, -1.70211062e-01f, 2.82148004e-01f, -8.26091990e-02f,
  -3.97353470e-01f, -4.39293534e-02f, 8.16909149e-02f, -7.79576972e-02f, -2.06384718e-01f, -4.15001139e-02f, -2.21379757e-01f, 1.32943630e-01f, -2.52505392e-01f, -1.28795519e-01f,
  -3.85304540e-02f, 6.01269677e-03f, -3.78685921e-01f, -3.92492026e-01f, -2.75882810e-01f, -7.93870017e-02f, -1.98432952e-01f, 2.97912925e-01f, -3.47868115e-01f, -2.01327369e-01f,
  -2.80193895e-01f, -7.29756281e-02f, -5.30828759e-02f, -7.03634843e-02f, -4.86078501e-01f, -1.12169787e-01f, -2.79298723e-01f, -2.86440462e-01f, -1.75933704e-01f, 1.17023528e-01f,
  1.56020164e-01f, 2.30713040e-01f, -2.54022568e-01f, -7.02335238e-02f, 4.56121922e-01f, -1.77348614e-01f, 2.84169793e-01f, -1.47750765e-01f, 1.86459795e-01f, -1.89611092e-01f,
  8.11799541e-02f, -3.44265550e-01f, -6.02866933e-02f, -2.37025395e-01f, -3.06535903e-02f, 5.33274114e-02f, 4.31005657e-01f, 3.57010990e-01f, -1.16283715e-01f, 4.01286662e-01f,
  -1.16706029e-01f, 3.90795559e-01f, -3.67837936e-01f, 1.93049580e-01f, -2.00626314e-01f, 3.87920022e-01f, 4.58499752e-02f, -3.65104824e-01f, -2.25377157e-02f, -3.70418042e-01f,
  -1.77820265e-01f, -1.09329432e-01f, -2.23419651e-01f, 2.09563047e-01f, -3.03332895e-01f, -1.58856079e-01f, -4.45722640e-02f, 8.24112967e-02f, -3.17928828e-02f, -1.64012983e-01f,
  -4.77006771e-02f, 6.56603053e-02f, -9.51305255e-02f, 2.57534564e-01f, 2.05372665e-02f, -1.10932454e-01f, 1.30823314e-01f, -4.21772063e-01f, 1.71141140e-02f, -9.52801704e-02f,
  9.11526680e-02f, -1.27764374e-01f, -1.42077148e-01f, 1.00415900e-01f, -1.90642551e-01f, -1.61875069e-01f, 8.17489624e-03f, -3.03953558e-01f, 1.47428393e-01f, -1.70884743e-01f,
  -3.27281475e-01f, 1.07360385e-01f, 8.64109471e-02f, -2.85293758e-01f, -8.33514184e-02f, 1.84244275e-01f, -9.80215892e-02f, -7.79846460e-02f, -5.03012910e-02f, -1.92948148e-01f,
  -2.95927703e-01f, 1.10820852e-01f, -1.92792192e-02f, 2.45686233e-01f, 8.06912780e-02f, 2.32335627e-01f, -2.36325294e-01f, -2.81211466e-01f, -1.54987425e-01f, 6.04847781e-02f,
  3.24951142e-01f, -1.48432367e-02f, -4.32388186e-01f, 1.67622045e-01f, -2.11002648e-01f, -8.13497156e-02f, -1.26464531e-01f, -2.52250552e-01f, 2.34197930e-01f, 3.23329717e-01f,
  2.74654508e-01f, 2.60706425e-01f, -3.41206431e-01f, -2.45306343e-01f, 3.71968597e-02f, 1.07469641e-01f, -2.27458254e-02f, -2.45343652e-02f, 2.80934185e-01f, 1.29578009e-01f,
  -1.68664962e-01f, 1.67277217e-01f, -1.22556545e-01f, -1.55665755e-01f, 2.05468506e-01f, 3.96425009e-01f, 2.56435871e-01f, 2.25580111e-01f, -1.34541959e-01f, -1.72151953e-01f,
  -2.87116736e-01f, -2.80058142e-02f, -1.18637733e-01f, -4.18212503e-01f, -2.01393142e-01f, -1.67520016e-01f, 8.61638039e-02f, -4.62702513e-01f, -3.97299469e-01f, 4.26649064e-01f,
  -2.90195733e-01f, 6.14503205e-01f, 4.28546332e-02f, -1.06325522e-01f, -1.69022247e-01f, 6.81933910e-02f, -2.05552578e-01f, -2.06263438e-01f, -2.73119304e-02f, -5.72239220e-01f,
  4.01886702e-01f, -2.08373263e-01f, -2.24824280e-01f, -1.45074308e-01f, 4.32149619e-01f, -4.44781184e-01f, -5.76558828e-01f, 3.03558469e-01f, -8.15643445e-02f, -1.49209693e-01f,
  1.35891303e-01f, 1.25737175e-01f, -2.43796438e-01f, -1.04326554e-01f, 8.84985365e-03f, -2.76368618e-01f, 4.43691820e-01f, -4.13055904e-02f, -1.30613327e-01f, -2.80490518e-01f,
  4.44166511e-01f, -2.45466948e-01f, 4.13958043e-01f, -3.38348188e-02f, -3.28343242e-01f, -7.69737735e-02f, -2.70206481e-01f, -2.20070407e-01f, 3.66427273e-01f, 2.87044257e-01f,
  1.48919567e-01f, -1.72322839e-01f, 2.66919211e-02f, 1.88667942e-02f, 7.32624084e-02f, 1.98612601e-01f, 2.72566944e-01f, 2.88391650e-01f, 5.86332381e-02f, 5.66108078e-02f,
  1.94929942e-01f, 5.40441945e-02f, -1.65258273e-02f, -1.33278677e-02f, -1.03652388e-01f, 1.41536906e-01f, -1.57817658e-02f, 7.10544810e-02f, 2.48026818e-01f, 3.24896604e-01f,
  -1.64985538e-01f, 3.08604296e-02f, 2.43854105e-01f, 1.11220300e-01f, 1.26770198e-01f, 3.40219960e-02f, -3.68650630e-02f, -4.14055735e-02f, 4.45010178e-02f, -4.40358222e-02f,
  -1.22903839e-01f, 7.46248439e-02f, 1.60930436e-02f, 3.26034501e-02f, -5.27322814e-02f, -1.60241127e-02f, 3.10164809e-01f, 1.32732987e-01f, 1.70760095e-01f, 1.45584419e-01f,
  -3.86334985e-01f, 3.24935049e-01f, 2.27982819e-01f, -1.66978925e-01f, -5.08193612e-01f, 5.42090498e-02f, -3.10429156e-01f, -1.92293346e-01f, -9.31664407e-02f, 1.48023292e-01f,
  -3.00947458e-01f, -3.88855398e-01f, -8.63206852e-03f, -4.24710363e-01f, 2.13926315e-01f, 1.45531118e-01f, 2.57522672e-01f, -5.01230657e-02f, 2.41970733e-01f, -2.55920738e-01f,
  -7.92369433e-03f, -1.33197919e-01f, 9.30833369e-02f, 4.08376873e-01f, -5.79479709e-02f, -2.03784823e-01f, 2.09174529e-01f, 1.66332051e-01f, 4.10937816e-01f, 2.40504086e-01f,
  -2.64728636e-01f, -6.37661964e-02f, 2.64255971e-01f, 3.12944919e-01f, -2.04492763e-01f, 1.17470004e-01f, 5.17896414e-01f, 2.47564375e-01f, -3.21331263e-01f, 2.61105269e-01f,
  1.10414334e-01f, -1.43105403e-01f, -4.76514518e-01f, -3.24971229e-01f, -2.43133530e-02f, 2.34012410e-01f, 3.18964779e-01f, -1.13858894e-01f, 1.58449918e-01f, -3.05651039e-01f,
  7.93254282e-03f, -5.24726510e-01f, -5.55927828e-02f, 2.48930082e-01f, -2.12365821e-01f, -4.73149002e-01f, -2.74029970e-01f, 5.17628826e-02f, 3.47412437e-01f, 2.17217222e-01f,
  2.37607166e-01f, 6.56167150e-01f, -4.74865526e-01f, 3.68630923e-02f, -2.01317165e-02f, -1.52895734e-01f, -4.96151268e-01f, -1.30976932e-02f, 3.01990449e-01f, -2.45355979e-01f,
  1.59829125e-01f, 8.47653225e-02f, 5.12831092e-01f, -1.54409796e-01f, -3.12271088e-01f, -2.68170416e-01f, 2.66288251e-01f, -1.74350917e-01f, -2.77783126e-01f, -4.88583036e-02f,
  -4.42114383e-01f, 2.37502858e-01f, 2.83578336e-01f, -3.03127140e-01f, -3.67664844e-01f, -2.86668956e-01f, 4.91494656e-01f, 3.01329810e-02f, 2.51457036e-01f, -1.94782883e-01f,
  2.15134144e-01f, 7.98569098e-02f, 1.02112673e-01f, 1.95993125e-01f, 1.46569639e-01f, 3.47573757e-02f, -5.34331193e-05f, 2.99231559e-01f, 9.33895558e-02f, 4.08260673e-01f,
  -3.94092910e-02f, 4.28471975e-02f, -5.33651635e-02f, 1.39137715e-01f, 1.39101118e-01f, 5.51473089e-02f, 1.38219088e-01f, -9.48858112e-02f, 9.36081186e-02f, -1.69743150e-01f,
  -1.08537696e-01f, -4.32814658e-02f, 9.77116600e-02f, 4.83949520e-02f, 1.65016785e-01f, 2.56014943e-01f, 1.30905718e-01f, 2.43609592e-01f, 1.74160168e-01f, -1.54247969e-01f,
  1.76016107e-01f, 1.44399539e-01f, 2.55395234e-01f, 5.21156415e-02f, 1.00716069e-01f, 2.40132585e-01f, 2.02265501e-01f, 2.30800554e-01f, -1.60073057e-01f, -3.78612787e-01f,
  -1.51603088e-01f, 5.85467480e-02f, 2.52299994e-01f, 1.68938294e-01f, -2.47163456e-02f, 3.74903172e-01f, -2.63166279e-01f, -2.14191467e-01f, 1.67118698e-01f, 2.89332002e-01f,
  1.63065970e-01f, 2.00488076e-01f, 3.27691406e-01f, 4.49000418e-01f, -4.78466034e-01f, -3.74245644e-01f, -2.78863043e-01f, -1.81741580e-01f, 4.66209620e-01f, 2.47127131e-01f,
  -5.05159982e-02f, -9.36000571e-02f, -1.49967924e-01f, -1.27573516e-02f, -1.21743612e-01f, 3.35615017e-02f, -1.88385800e-01f, 4.10577506e-01f, 3.81691098e-01f, 2.66759247e-01f,
  -2.94703484e-01f, -1.56099066e-01f, -3.56583238e-01f, 5.37049659e-02f, -4.06957030e-01f, -5.18704876e-02f, 7.74895698e-02f, -5.13334930e-01f, -2.72600800e-01f, -5.02130054e-02f,
  1.04851611e-01f, -4.25018549e-01f, 4.45157409e-01f, 7.41615742e-02f, 2.48809025e-01f, -2.59350926e-01f, -2.20969841e-01f, -4.22769576e-01f, 1.48019373e-01f, 3.11892778e-01f,
  8.73612314e-02f, -3.57710451e-01f, 4.88885701e-01f, -5.36367185e-02f, -2.70602226e-01f, -3.30111206e-01f, 6.87284172e-02f, 2.04368487e-01f, -5.17258227e-01f, -1.97066352e-01f,
  -3.81938398e-01f, -7.13507235e-02f, -3.88910413e-01f, -3.00530612e-01f, 4.65985268e-01f, -3.62409763e-02f, 1.39838532e-01f, 4.85047072e-01f, -4.92412478e-01f, -2.64953136e-01f,
  -3.11488211e-01f, 2.20055670e-01f, -3.45232010e-01f, 1.40175834e-01f, 3.86218369e-01f, -6.46232069e-02f, -2.99850255e-01f, -4.60875958e-01f, -3.22664887e-01f, -4.59436834e-01f,
  1.46556169e-01f, -4.61408585e-01f, -1.44123062e-01f, -1.07080825e-01f, -3.68981540e-01f, 4.37363446e-01f, 3.50318074e-01f, -6.46584928e-01f, 6.58058971e-02f, -1.63837522e-01f,
  -8.80026668e-02f, -3.72365341e-02f, -1.32962108e-01f, -5.12855276e-02f, 2.15611920e-01f, 1.20581232e-01f, -3.24324578e-01f, -9.52208973e-03f, -8.53795707e-02f, -6.97138235e-02f,
  4.05267105e-02f, -4.19076607e-02f, 1.50173858e-01f, -1.27091840e-01f, 1.84721258e-02f, -3.12917680e-02f, 7.29301870e-02f, 7.24059492e-02f, -1.43297255e-01f, 6.46134689e-02f,
  -7.58593902e-02f, -2.23778293e-01f, 7.80344456e-02f, 5.40724955e-03f, -6.77514896e-02f, 3.44650708e-02f, -1.66286789e-02f, 1.24217123e-01f, -6.70470074e-02f, 5.71493991e-02f,
  -1.26191154e-01f, -4.52673212e-02f, 8.42065513e-02f, 1.20654330e-01f, -1.87934071e-01f, 1.71039417e-01f, 2.12539554e-01f, -3.71980667e-02f, -2.70863444e-01f, -2.41558880e-01f,
  1.78380266e-01f, 2.32243568e-01f, 6.66091517e-02f, -3.15155208e-01f, -1.94894522e-01f, 1.97382525e-01f, 3.87317091e-02f, 1.82842925e-01f, 1.85717657e-01f, -1.24064967e-01f,
  -8.79108757e-02f, -5.05809560e-02f, 1.90845206e-02f, 5.37760258e-01f, -1.67299248e-02f, -4.11482811e-01f, 1.05727546e-01f, 1.18973561e-01f, 2.65317768e-01f, -9.34931263e-02f,
  -2.64449030e-01f, -2.67062277e-01f, -1.21008106e-01f, -1.87153786e-01f, -1.21403247e-01f, -2.13392630e-01f, 3.00111175e-01f, -2.76237309e-01f, -2.85062075e-01f, 2.23536238e-01f,
  -1.42840505e-01f, -2.68008351e-01f, 6.48246035e-02f, -1.41447663e-01f, 5.29512227e-01f, 4.27082956e-01f, -2.15757519e-01f, -2.04000279e-01f, -4.33084697e-01f, -2.16806725e-01f,
  -3.16821247e-01f, -1.40961826e-01f, 4.39701974e-01f, -2.00353220e-01f, -3.60147983e-01f, -1.11332694e-02f, -4.65104491e-01f, 1.87874302e-01f, -2.93217421e-01f, 1.03753977e-01f,
  -1.66952148e-01f, -3.84587020e-01f, 6.07765198e-01f, -8.64395425e-02f, -4.47966248e-01f, -1.08266182e-01f, -3.64247113e-01f, -4.13946211e-01f, 4.57502693e-01f, 5.62253222e-02f,
  -2.50656635e-01f, -2.62444198e-01f, -2.22038761e-01f, 9.99160931e-02f, -2.18811721e-01f, 2.58925885e-01f, 1.84063166e-01f, 1.56264991e-01f, -4.92098987e-01f, -4.82599795e-01f,
  -1.24798194e-01f, 4.55978870e-01f, -5.45654222e-02f, -4.06575352e-01f, -3.12461376e-01f, 1.78861871e-01f, -3.54519010e-01f, 3.51643175e-01f, -5.98872542e-01f, 2.07226455e-01f,
  5.36325634e-01f, -2.28669479e-01f, -2.53394634e-01f, -4.07451838e-01f, 2.36719251e-01f, 5.74078038e-03f, 1.24463458e-02f, 3.06237899e-02f, 7.15635642e-02f, 9.95671824e-02f,
  -4.43557389e-02f, -1.06236488e-02f, -1.39690399e-01f, -2.54595578e-01f, -7.96115920e-02f, -2.79331565e-01f, -1.23644508e-02f, 4.23393138e-02f, -2.52717733e-01f, -1.73285171e-01f,
  -1.78231180e-01f, -6.93951473e-02f, -3.64994049e-01f, 7.83597156e-02f, -2.37406548e-02f, -8.91039222e-02f, -8.18805490e-03f, -1.83977336e-01f, -4.01879586e-02f, 6.01994172e-02f,
  -1.25473142e-01f, 1.93042364e-02f, 7.30238259e-02f, 6.25763163e-02f, -1.58309564e-01f, -6.59961849e-02f, 1.09928623e-01f, -1.72437076e-02f, 4.13878337e-02f, -4.51484807e-02f,
  -5.93960918e-02f, -1.96034491e-01f, 6.12676851e-02f, 4.26536538e-02f, -9.67603847e-02f, 1.15132101e-01f, -3.63977328e-02f, 7.54018426e-02f, 2.27807775e-01f, -3.01223770e-02f,
  1.89027354e-01f, -7.68142343e-02f, 1.74572691e-01f, 1.95172131e-01f, -1.36026129e-01f, 1.03041537e-01f, -4.57676090e-02f, 5.35288416e-02f, -2.48874202e-01f, 2.09305629e-01f,
  2.09380731e-01f, 1.51131183e-01f, -2.59987652e-01f, 3.67472321e-02f, 1.31416515e-01f, 1.21321075e-01f, 1.36511162e-01f, 1.51567971e-02f, 4.65859435e-02f, 1.99556023e-01f,
  -1.05859570e-01f, -2.96992987e-01f, -1.71797454e-01f, 9.74152163e-02f, -4.47932305e-03f, 2.79994696e-01f, 9.97862592e-02f, -2.31799841e-01f, 6.99186251e-02f, 2.31693730e-01f,
  4.87870052e-02f, 8.73293206e-02f, -1.59500360e-01f, -4.16746587e-02f, -1.36751533e-01f, -4.80789468e-02f, 5.20722032e-01f, -2.33846411e-01f, -2.56959110e-01f, 2.96595484e-01f,
  2.56637156e-01f, 3.98502588e-01f, 3.04332655e-02f, 1.21816568e-01f, -2.16036603e-01f, -1.82156518e-01f, 1.34400710e-01f, -1.72941297e-01f, -7.16976672e-02f, -2.89213568e-01f,
  -1.63593963e-01f, -3.48460585e-01f, -2.26359457e-01f, -2.36298040e-01f, 1.43730551e-01f, 5.84139377e-02f, -3.64771307e-01f, -1.59499064e-01f, -2.08098561e-01f, 2.77132064e-01f,
  3.48312110e-02f, 3.90215933e-01f, 3.89803976e-01f, -1.21679328e-01f, -2.92215645e-01f, 5.04453778e-02f, -3.43658179e-02f, 5.66553697e-02f, 2.61566222e-01f, -1.02570117e-01f,
  2.79128224e-01f, -1.42871410e-01f, 2.52197623e-01f, -1.52837127e-01f, -2.41057977e-01f, -1.32533312e-01f, -2.08385095e-01f, -2.40258992e-01f, 2.58068860e-01f, -2.66886950e-01f,
  -1.04651429e-01f, 2.58913517e-01f, -3.32320631e-01f, -1.79098472e-01f, 1.02763586e-01f, 4.41852696e-02f, -8.08760598e-02f, -1.72043771e-01f, -6.57849312e-02f, -7.60558294e-03f,
  -8.28603003e-03f, 2.30886508e-02f, -4.35241358e-03f, -5.02742678e-02f, -2.77206860e-02f, 1.03591746e-02f, -2.55407561e-02f, -1.63696334e-01f, 1.10202089e-01f, 5.22057852e-03f,
  -8.01632181e-02f, -3.73595320e-02f, -9.10677984e-02f, 1.46251395e-02f, -9.43868011e-02f, -3.16307932e-01f, -3.76739986e-02f, -1.55962467e-01f, -3.53003353e-01f, 2.88687889e-02f,
  1.64222762e-01f, -3.86312008e-01f, -7.30520710e-02f, 5.82484715e-02f, 3.27270851e-02f, -1.97653491e-02f, -4.86130863e-02f, 1.49366394e-01f, 8.41770396e-02f, 7.73392804e-03f,
  -8.37127566e-02f, -1.66805342e-01f, 3.59388590e-02f, 2.71778882e-01f, 2.88298815e-01f, 2.03880534e-01f, -1.43916801e-01f, -1.98354319e-01f, -1.90342382e-01f, -8.10592771e-02f,
  3.29070687e-01f, 9.20658633e-02f, 1.12376526e-01f, 3.64410609e-01f, -1.10552981e-01f, 2.46115893e-01f, 1.50638238e-01f, -2.61808068e-01f, -6.81331083e-02f, 2.74103247e-02f,
  -4.18816730e-02f, 1.07735120e-01f, -6.40584109e-03f, 3.30529183e-01f, 1.00962162e-01f, -2.91087031e-01f, 2.24297270e-01f, -1.50463298e-01f, 2.12205529e-01f, -2.38008678e-01f,
  -2.12251574e-01f, -1.20755151e-01f, -8.40788335e-03f, -4.76406477e-02f, 1.63573414e-01f, 6.98641241e-02f, 1.15116678e-01f, -7.87472650e-02f, -3.37960012e-02f, 1.73292235e-01f,
  -2.60303944e-01f, 6.57552704e-02f, 4.62673396e-01f, 5.12430966e-01f, -1.27380162e-01f, -3.99624884e-01f, 1.14159755e-01f, -4.07411642e-02f, -1.20503657e-01f, -1.83826387e-01f,
  3.46788198e-01f, 2.16616224e-02f, 2.69811720e-01f, -3.79603542e-02f, -2.43638292e-01f, 1.58360362e-01f, 1.44395992e-01f, -1.04870617e-01f, 3.03674877e-01f, -2.93286473e-01f,
  -1.78932473e-01f, -2.86816865e-01f, 3.04639399e-01f, -1.09459959e-01f, -1.35628194e-01f, -5.67937121e-02f, -1.03772670e-01f, -2.95324415e-01f, 1.12914322e-02f, -2.55388826e-01f,
  -5.83310202e-02f, -2.95118213e-01f, -2.62585670e-01f, -2.09204555e-01f, -3.13924313e-01f, 4.14307505e-01f, -2.52742648e-01f, 2.62729645e-01f, -1.24407582e-01f, 2.02569366e-01f,
  -2.80059844e-01f, -4.06816632e-01f, 3.06698382e-01f, -4.47294563e-02f, -2.32762516e-01f, -7.97036812e-02f, 4.57890421e-01f, 2.21083835e-01f, -1.28546491e-01f, -1.68364093e-01f,
  -2.66966015e-01f, -2.78492361e-01f, 1.39421284e-01f, 4.23346385e-02f, 8.55110437e-02f, -2.03881204e-01f, -6.62607932e-03f, -1.56357050e-01f, -1.47044510e-01f, -1.73011154e-01f,
  1.20810263e-01f, -1.31249085e-01f, 1.81866840e-01f, 2.40663532e-02f, 3.22334021e-02f, 4.70194779e-02f, 3.55169512e-02f, -1.33257493e-01f, 9.92851257e-02f, 1.98810741e-01f,
  1.53084487e-01f, -1.15358412e-01f, -5.11790663e-02f, -7.83775002e-03f, -1.22924156e-01f, 2.01599658e-01f, -1.86040327e-02f, 5.16013876e-02f, -3.82068194e-02f, -2.26608776e-02f,
  -2.07670331e-02f, 5.25440574e-02f, 2.12250620e-01f, 8.19709301e-02f, 5.19610234e-02f, 8.40022564e-02f, 4.61952649e-02f, 5.45271114e-02f, -1.66256025e-01f, -3.36452454e-01f,
  4.89702933e-02f, -2.72347867e-01f, 2.49108505e-02f, -1.74386680e-01f, 3.05983394e-01f, 5.54138385e-02f, -1.50867412e-03f, -3.28545451e-01f, -2.33177468e-01f, 3.24148595e-01f,
  1.87384024e-01f, 1.01978876e-01f, 2.40629911e-01f, 2.93384671e-01f, 8.39248523e-02f, 7.08170310e-02f, 4.34236795e-01f, -4.00900483e-01f, -1.07286952e-01f, 3.11392218e-01f,
  2.47977376e-01f, -2.67736614e-01f, 3.00748527e-01f, -2.85430700e-01f, -2.71400779e-01f, -2.62888789e-01f, -3.48608315e-01f, 2.07414210e-01f, 2.54588395e-01f, -2.62893885e-01f,
  3.87177438e-01f, 1.61267892e-01f, -2.04169691e-01f, -2.46724471e-01f, -1.11995563e-01f, -2.73084342e-01f, -3.92919898e-01f, 3.56030017e-01f, -2.02765793e-01f, 3.35637689e-01f,
  -3.18408221e-01f, -2.53899843e-01f, 3.04993093e-01f, 1.77577943e-01f, -4.85432982e-01f, -8.82769078e-02f, 7.98371583e-02f, -1.45546466e-01f, 1.58618391e-01f, -2.85877049e-01f,
  -2.94886976e-01f, -2.78257102e-01f, 3.20671052e-01f, -4.28765595e-01f, 5.43618053e-02f, 3.04819852e-01f, -1.10466711e-01f, -4.00245517e-01f, 4.38193321e-01f, -2.81058639e-01f,
  -4.94951487e-01f, 1.60884574e-01f, -5.00965536e-01f, -3.31218541e-01f, 4.92212027e-01f, -1.01727039e-01f, -4.34090257e-01f, 3.24800700e-01f, 2.06564189e-04f, -3.27138990e-01f,
  -3.99050683e-01f, -2.83403367e-01f, 2.65984625e-01f, -3.68585050e-01f, -2.77434796e-01f, -2.12820858e-01f, -1.89547509e-01f, 2.71058101e-02f, 1.79232150e-01f, -4.75030486e-03f,
  -1.12712055e-01f, -5.78001887e-02f, 6.63583875e-01f, 5.23177564e-01f, -2.84519404e-01f, -2.64721155e-01f, -1.54580712e-01f, -2.54936099e-01f, -6.56573117e-01f, 2.62449503e-01f,
  1.07990816e-01f, 1.45987183e-01f, 1.44229859e-01f, -1.64502546e-01f, -1.16354577e-01f, -7.92309120e-02f, 7.66510516e-02f, 5.86267486e-02f, -5.82142286e-02f, -8.19355249e-02f,
  9.94581729e-02f, -3.04254349e-02f, 1.33197010e-01f, 1.14037126e-01f, 1.98874056e-01f, -1.38897747e-01f, 1.59090936e-01f, 5.87063432e-02f, 9.86157134e-02f, 4.52546962e-02f,
  8.66890475e-02f, 4.29921485e-02f, -8.93784408e-03f, 1.40729457e-01f, 1.46539882e-01f, 1.59339100e-01f, 1.98874608e-01f, 8.30074549e-02f, 1.91273332e-01f, 1.54897690e-01f,
  9.37855393e-02f, 6.57542869e-02f, 1.68028682e-01f, 2.27365628e-01f, 1.50966451e-01f, 1.33704051e-01f, -1.15207896e-01f, 1.92321852e-01f, -1.39112398e-01f, -9.06566754e-02f,
  -3.74961868e-02f, 2.87041157e-01f, -2.57897168e-01f, -2.74520338e-01f, 1.96086809e-01f, 1.80048004e-01f, 4.02936399e-01f, -3.69784981e-01f, 3.37632447e-01f, -4.59127039e-01f,
  -2.43901290e-04f, -2.77352840e-01f, -6.62467629e-02f, -3.09152305e-01f, -2.49989107e-01f, 2.67820358e-01f, -2.33492523e-01f, 2.25047469e-01f, -1.61006823e-01f, -3.46463472e-01f,
  -1.98061675e-01f, 1.62230775e-01f, 3.08781236e-01f, 2.78437048e-01f, 1.16029128e-01f, -3.09754878e-01f, 3.30244929e-01f, 3.43232214e-01f, -3.54009241e-01f, -2.80361265e-01f,
  3.43506187e-02f, -2.79639482e-01f, 2.65138119e-01f, -1.48411974e-01f, 3.55730414e-01f, -1.06312446e-01f, -1.13867827e-01f, -4.10623074e-01f, -1.76542118e-01f, 3.16391319e-01f,
  -5.31853735e-02f, -1.42108649e-03f, -2.99320847e-01f, 3.40739936e-01f, -1.59501091e-01f, -4.34031606e-01f, -2.53087014e-01f, -4.62283820e-01f, -2.68546522e-01f, -2.52849698e-01f,
  -1.41334921e-01f, -2.46831670e-01f, -1.31973997e-01f, -1.67081520e-01f, -3.07695270e-01f, 6.21707439e-01f, -3.31786752e-01f, -2.68998872e-02f, -4.84842658e-01f, -2.07675993e-01f,
  3.31113786e-01f, -2.25105003e-01f, 6.59345031e-01f, 6.50144741e-02f, -1.45641193e-01f, -2.37416893e-01f, -3.23994190e-01f, -2.36393332e-01f, 7.05757290e-02f, -2.74401039e-01f,
  -1.45682991e-01f, -3.21229428e-01f, 3.30408722e-01f, -3.94053549e-01f, -1.58675447e-01f, 4.17076908e-02f, 2.22669676e-01f, -1.89769030e-01f, 1.87164858e-01f, -3.17277789e-01f,
  -5.30470014e-02f, -6.35182112e-02f, -2.38302857e-01f, 4.82720286e-01f, -4.41819757e-01f, -3.76714438e-01f, -1.92290902e-01f, -2.06709996e-01f, -9.08468366e-02f, -3.62141320e-04f,
  -1.74931437e-03f, -1.01665650e-02f, 9.40195918e-02f, 7.02807978e-02f, -3.20938006e-02f, 1.80802614e-04f, 7.30079785e-02f, -5.15625328e-02f, 1.33630857e-01f, 8.64771530e-02f,
  -2.00309474e-02f, 1.04654990e-01f, -2.26061791e-01f, 1.17313005e-01f, -9.39489994e-03f, 1.62603393e-01f, -1.40964575e-02f, 1.35027260e-01f, 2.48192567e-02f, -1.19744070e-01f,
  -7.06545636e-02f, 1.07877880e-01f, 7.07368925e-02f, -5.50193414e-02f, -5.04517853e-02f, 1.80200070e-01f, 9.77467671e-02f, 7.24228323e-02f, 1.58517528e-02f, -7.74004608e-02f,
  -1.99774858e-02f, -1.65568814e-01f, -7.82340989e-02f, 2.31425706e-02f, 7.27086365e-02f, -9.60722715e-02f, -1.65731862e-01f, -1.84604645e-01f, -2.26284519e-01f, -1.80558383e-01f,
  -7.64241740e-02f, -1.68155149e-01f, -2.45227084e-01f, 1.33037046e-02f, -2.77910322e-01f, 3.80422890e-01f, 1.83627736e-02f, 1.85154215e-01f, 5.66143952e-02f, -1.93802342e-01f,
  1.94730878e-01f, 1.35296345e-01f, 8.18303674e-02f, -1.49834126e-01f, -6.40825368e-03f, 1.18574321e-01f, -3.72705124e-02f, 4.04430777e-01f, -1.98896274e-01f, -2.61941671e-01f,
  1.74101859e-01f, 3.21976751e-01f, -3.66583437e-01f, 5.88341355e-02f, 1.19595967e-01f, -3.02968949e-01f, 6.42893985e-02f, 2.79077023e-01f, 2.42442116e-02f, 1.95738077e-01f,
  3.53051573e-01f, 2.07101867e-01f, 2.25245193e-01f, -3.59934598e-01f, 1.08575888e-01f, -3.17192554e-01f, 1.88030601e-01f, 3.99242461e-01f, -2.89876312e-01f, -1.31895393e-01f,
  -2.70638347e-01f, -3.24775219e-01f, -2.39925772e-01f, 3.10122579e-01f, -2.90152371e-01f, 4.60586965e-01f, -3.38920891e-01f, -2.98508823e-01f, 4.05586779e-01f, -1.95231885e-01f,
  2.72491634e-01f, -2.11807117e-01f, -4.28896815e-01f, -2.28975609e-01f, -1.22101441e-01f, 1.13901116e-01f, -3.04288507e-01f, -9.82414186e-02f, 1.55029848e-01f, 6.31974578e-01f,
  -3.34176809e-01f, -9.98454988e-02f, -1.84371397e-01f, -2.20255271e-01f, -1.62775964e-01f, 3.51579547e-01f, 5.62334418e-01f, -1.85592517e-01f, -2.05820635e-01f, 3.08747292e-01f,
  -9.68041271e-02f, -3.99176866e-01f, 2.19380334e-01f, -2.01108828e-01f, -3.29136133e-01f, -2.18352914e-01f, 3.20475161e-01f, -2.19453856e-01f, -3.33735198e-01f, 4.80058551e-01f,
  -6.56676218e-02f, -1.94359645e-01f, -2.86828756e-01f, -2.29459181e-01f, 2.55820602e-01f, -2.22141802e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -8.48217234e-02f, 3.00706588e-02f, -4.91914004e-02f, -1.22924102e-02f, 4.11834894e-03f, -5.73697239e-02f, -7.78668327e-03f, -9.10435766e-02f, -5.22329174e-02f, 2.73702145e-02f,
  1.28592700e-01f, 1.15349172e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    