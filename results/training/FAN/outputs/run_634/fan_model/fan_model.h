/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.61020708e-01f, 6.58000350e-01f, 7.87725747e-02f, 9.59872305e-02f, -1.32716596e-01f, -1.31988928e-01f, 1.77139133e-01f, 3.00944094e-02f, 2.00757999e-02f, 2.89416790e-01f,
  1.68792680e-01f, -1.88938484e-01f, -1.73998460e-01f, -1.94914266e-01f, -2.45493993e-01f, 1.91877738e-01f, -3.22639160e-02f, -1.43882632e-01f, -5.20429909e-01f, -2.95913488e-01f,
  -1.78831890e-01f, 1.27870888e-01f, 1.96000323e-01f, -4.15969975e-02f, 1.12102382e-01f, -7.78731480e-02f, 2.33481169e-01f, 2.38274261e-01f, 7.28852302e-02f, 1.79782033e-01f,
  2.09544152e-01f, 2.35763654e-01f, -2.33947307e-01f, -9.32548717e-02f, 8.49949941e-02f, -2.61290628e-03f, 4.88857180e-02f, -5.19084968e-02f, -5.64835221e-02f, 3.31860557e-02f,
  1.66835450e-02f, -9.25960112e-03f, -3.34505029e-02f, -5.78748016e-03f, 1.28562868e-01f, -6.64199516e-02f, -2.31089331e-02f, 1.37549099e-02f, -7.68771470e-02f, -3.06744669e-02f,
  -7.16220960e-02f, 2.45672055e-02f, 6.25456572e-02f, 1.59405440e-03f, -1.40367970e-01f, -1.88688621e-01f, 1.84716031e-01f, -2.37904396e-02f, -2.50239447e-02f, 3.13036233e-01f,
  5.47680855e-02f, 1.27582505e-01f, -4.46171276e-02f, 4.10968065e-02f, -1.13684461e-02f, -3.21128294e-02f, -6.22393973e-02f, 7.72324353e-02f, -9.80541762e-03f, -9.44559649e-03f,
  -1.53947277e-02f, 4.18933146e-02f, 1.81028284e-02f, 3.24288756e-02f, -1.95270050e-02f, 2.68790871e-02f, 6.60321035e-04f, 6.53806180e-02f, -2.35558432e-02f, 7.18992278e-02f,
  -3.77289169e-02f, -5.59696518e-02f, 2.86876205e-02f, -3.66444737e-02f, -1.24488667e-01f, -4.03385945e-02f, -3.53497313e-03f, -8.26098919e-02f, -2.49808468e-02f, 2.44027730e-02f,
  2.39898413e-01f, -2.56421328e-01f, 8.02390203e-02f, 5.91362454e-02f, 2.51595788e-02f, -2.56813802e-02f, 1.16886809e-01f, -5.92073146e-03f, 8.46860483e-02f, 6.65311841e-03f,
  -7.56958202e-02f, -1.27862366e-02f, 1.47187218e-01f, -9.00099892e-03f, -5.23787029e-02f, 1.27794838e-03f, 8.13236237e-02f, -9.97411832e-02f, 2.42969375e-02f, 1.88304096e-01f,
  8.59655440e-02f, 9.04048793e-03f, 1.44442578e-03f, 2.08299886e-02f, -8.35321918e-02f, -1.33520827e-01f, 9.38999280e-03f, 6.55593723e-02f, -5.32943234e-02f, 2.97079623e-01f,
  4.96800154e-01f, -3.75778824e-01f, -4.95936334e-01f, 3.85276794e-01f, 2.75735319e-01f, 6.15368932e-02f, -2.19571590e-01f, 6.78900108e-02f, 2.72485286e-01f, -1.25676855e-01f,
  3.97791639e-02f, 1.32336333e-01f, -1.13580614e-01f, -1.16274305e-01f, -2.62424588e-01f, -4.32559639e-01f, -5.61000228e-01f, -2.66588390e-01f, -8.16002637e-02f, 2.80935794e-01f,
  5.77871613e-02f, 1.89496547e-01f, 1.23284929e-01f, -4.17342931e-02f, 8.41677487e-02f, 2.08412372e-02f, -8.63315091e-02f, 7.97193572e-02f, -8.16193372e-02f, -4.88714367e-01f,
  -2.80736357e-01f, 3.75536419e-02f, 2.14768341e-03f, 6.23611212e-02f, -3.88785191e-02f, 8.43743458e-02f, 1.98498443e-02f, -2.25023217e-02f, 7.39907324e-02f, -4.65845168e-02f,
  3.51831429e-02f, 1.24516860e-01f, -4.16428335e-02f, 4.28517908e-02f, -2.88901851e-02f, 2.95700133e-02f, -8.33144858e-02f, -1.59460723e-01f, -5.48361391e-02f, 4.90760356e-02f,
  -4.29089703e-02f, 9.04601812e-02f, -4.48574610e-02f, -8.77832770e-02f, -6.85871616e-02f, 2.15665847e-02f, 1.77862160e-02f, 4.91707548e-02f, -6.23139553e-02f, -4.02752496e-02f,
  -5.90652600e-02f, -7.60017484e-02f, 3.31252366e-02f, -8.37508589e-03f, 3.68463248e-02f, 2.51918808e-02f, -8.31615552e-02f, -1.44325821e-02f, -2.62263454e-02f, 4.48945500e-02f,
  3.73231024e-02f, -4.83674370e-03f, -7.72349909e-02f, -7.40171000e-02f, -6.88748285e-02f, 1.22191757e-02f, -6.55681789e-02f, -7.53925964e-02f, -7.20339874e-03f, 2.19579767e-02f,
  5.94314858e-02f, -1.54914393e-03f, 5.46153300e-02f, -6.95368722e-02f, -8.64287838e-03f, -4.72291224e-02f, 7.21013471e-02f, 9.63476375e-02f, 1.16985753e-01f, 1.40147731e-01f,
  2.10369259e-01f, -1.05303168e-01f, -2.93979291e-02f, -2.52139531e-02f, 9.74601042e-03f, -4.55788076e-02f, 4.88120271e-03f, -2.13934071e-02f, 5.44806160e-02f, 6.23115040e-02f,
  2.14004293e-02f, -2.60769799e-02f, -4.73974049e-02f, -4.77669872e-02f, 7.77384490e-02f, 1.23577073e-01f, 5.61085194e-02f, 7.45316176e-03f, -6.60946891e-02f, 4.56991456e-02f,
  6.70626434e-03f, -4.15685996e-02f, 3.04376390e-02f, -9.19567794e-03f, 9.15688127e-02f, 2.19312720e-02f, -1.13453664e-01f, 3.67485583e-02f, -3.80353862e-03f, 4.93229926e-02f,
  -7.11430967e-01f, 5.12982905e-01f, 3.28787684e-01f, -3.73308539e-01f, 1.29940674e-01f, 1.29244700e-01f, 4.03762609e-01f, -1.70335606e-01f, -3.39117020e-01f, 5.01135476e-02f,
  2.64042497e-01f, -4.96839695e-02f, -1.15905628e-01f, -6.65423460e-03f, -5.50332256e-02f, 2.22544655e-01f, 2.55065590e-01f, -1.78244859e-02f, -3.58021319e-01f, -8.64274800e-02f,
  9.28281734e-05f, -1.19347200e-01f, -2.26805165e-01f, -1.64802030e-01f, 9.32326689e-02f, -2.38288462e-01f, 8.82571191e-02f, 1.43294230e-01f, 2.43390813e-01f, 4.37862813e-01f,
  3.20626915e-01f, 1.33611396e-01f, -2.08094254e-01f, -2.08155792e-02f, 1.40172113e-02f, -6.88701272e-02f, -2.34468710e-02f, -2.44506225e-02f, -7.79322833e-02f, -8.58638734e-02f,
  6.94445297e-02f, -3.89921591e-02f, 2.56455913e-02f, 8.58899578e-02f, -3.28817964e-02f, -1.73194576e-02f, -9.15371105e-02f, 3.84775586e-02f, -6.90493062e-02f, 1.89391598e-01f,
  1.96263447e-01f, 2.69155264e-01f, 1.26246676e-01f, -4.13338207e-02f, -4.30291705e-02f, -1.15428656e-01f, 2.28090510e-02f, -7.84742180e-03f, 1.73644139e-03f, -6.16764873e-02f,
  -1.14577055e-01f, -4.96766903e-03f, 2.99653132e-02f, 3.58535387e-02f, 4.31274325e-02f, -2.45433934e-02f, -2.74481997e-02f, -1.78027619e-02f, -1.67851746e-02f, 6.64076656e-02f,
  -1.50344111e-02f, 7.06206039e-02f, 4.02032845e-02f, 6.34454098e-03f, 5.61635941e-02f, 9.00539830e-02f, 6.68633208e-02f, -4.26865816e-02f, 8.78585204e-02f, 8.46547931e-02f,
  4.16910946e-02f, 1.11358063e-02f, -7.51805827e-02f, -2.67357659e-02f, 9.55688730e-02f, 1.12235090e-02f, -2.79277068e-04f, 1.04194939e-01f, -9.70639754e-03f, 7.04270005e-02f,
  -1.96339533e-01f, -6.65807677e-03f, 1.55799836e-02f, -8.03934932e-02f, 1.55957937e-02f, 2.55307443e-02f, -2.09922418e-02f, -5.11254258e-02f, 7.37130195e-02f, -1.30355638e-02f,
  -6.86762407e-02f, -1.05227299e-01f, 1.87441725e-02f, 8.02637450e-03f, -9.04065520e-02f, -5.20814657e-02f, 7.59706199e-02f, -3.15994062e-02f, -5.45600280e-02f, -3.23880166e-02f,
  -1.74399782e-02f, -1.47891268e-01f, -1.59654945e-01f, -1.57851931e-02f, -3.03324237e-02f, -7.68638104e-02f, 2.04367395e-02f, -3.82872745e-02f, -1.39550745e-01f, -2.30082273e-01f,
  -5.68643630e-01f, 1.56895891e-01f, -2.38360465e-01f, -3.19629192e-01f, 3.41248155e-01f, 3.84950191e-01f, 6.05361879e-01f, 1.29941180e-01f, -1.29844606e-01f, -1.46090565e-03f,
  -6.06078431e-02f, -2.34177932e-01f, -2.67729938e-01f, -1.46117628e-01f, -7.30490535e-02f, 3.38176936e-01f, 5.28496467e-02f, -3.41998428e-01f, 8.48681405e-02f, 3.35989624e-01f,
  3.66447061e-01f, -1.60270818e-02f, -1.88598424e-01f, -3.40897441e-02f, -2.85131261e-02f, 5.19661466e-03f, -2.32634321e-02f, -1.70195386e-01f, 1.16641060e-01f, -2.45167598e-01f,
  -3.78959775e-01f, -3.63052934e-01f, 1.44854680e-01f, 1.18427761e-02f, 1.03087137e-02f, -9.16600078e-02f, 1.07116938e-01f, -8.07886794e-02f, -2.22152118e-02f, -1.99474990e-02f,
  -1.23846911e-01f, -8.23918059e-02f, -8.54453519e-02f, -2.01114900e-02f, 4.41210531e-02f, -8.11585411e-02f, -1.30688190e-01f, -1.63386539e-01f, -1.32861853e-01f, -9.31886956e-02f,
  9.00909603e-02f, -3.52549274e-03f, -1.59018457e-01f, 1.21586420e-01f, -9.33499336e-02f, -6.48280978e-02f, -1.06823653e-01f, -9.04853269e-02f, -6.29956648e-02f, -9.04806331e-02f,
  4.00416330e-02f, -9.55639116e-04f, 9.24105793e-02f, 4.51834407e-03f, 1.21874876e-01f, -4.26158272e-02f, 6.31178543e-02f, 3.96206826e-02f, 8.12118277e-02f, 2.89118420e-02f,
  7.92171434e-02f, 1.80393811e-02f, 3.57883982e-02f, 2.31993757e-02f, 7.25418180e-02f, 2.83847451e-02f, 6.14461722e-03f, 3.50203589e-02f, -7.79796094e-02f, 3.70641984e-02f,
  -2.12211255e-02f, 2.13238187e-02f, -6.14762865e-02f, 6.79309145e-02f, 6.42505437e-02f, -1.92524865e-02f, 1.86907873e-02f, 3.65679637e-02f, 7.43661895e-02f, -8.92718695e-03f,
  1.80166811e-01f, 6.44160211e-02f, -9.17654261e-02f, -1.14503659e-01f, -3.34524661e-02f, -2.86666676e-02f, -1.18375093e-01f, -5.81012690e-04f, -8.15662816e-02f, -3.93928029e-02f,
  1.00323884e-02f, -8.00500587e-02f, -4.05049287e-02f, 8.57933536e-02f, 1.30320221e-01f, 4.57610935e-02f, 7.09898071e-03f, -8.24202746e-02f, 9.43663493e-02f, 2.46070642e-02f,
  4.45527434e-02f, 8.19725022e-02f, -8.29004683e-03f, 4.79921848e-02f, -6.78724349e-02f, -1.25990249e-02f, 1.01440184e-01f, -2.02054400e-02f, 7.23008765e-03f, 3.36476475e-01f,
  -8.46495330e-01f, 3.51769328e-02f, -1.14960998e-01f, -1.42461360e-01f, -4.16099317e-02f, -1.16557159e-01f, -1.84101015e-02f, 9.62717533e-02f, 1.51515424e-01f, -2.23074317e-01f,
  8.74158889e-02f, 4.14130747e-01f, 2.81311870e-01f, 3.29985201e-01f, 1.05571382e-01f, -6.41214848e-02f, -1.43802628e-01f, -1.02305606e-01f, 1.86675653e-01f, 2.28413403e-01f,
  3.28479230e-01f, 3.24143469e-02f, -2.22969517e-01f, 7.16100261e-02f, -2.49131098e-02f, 8.99638981e-02f, -1.74157292e-01f, -1.98138684e-01f, -1.38359025e-01f, -2.90568233e-01f,
  -2.61155844e-01f, -1.85655326e-01f, 1.35851830e-01f, 3.49888541e-02f, 1.06487684e-01f, -8.14221278e-02f, 3.31230238e-02f, -2.77888011e-02f, 5.26841506e-02f, -1.14994179e-02f,
  3.26029882e-02f, 1.27293998e-02f, 1.00523643e-01f, 1.00340724e-01f, -6.38103709e-02f, 7.06192851e-02f, -4.03835326e-02f, 5.68325669e-02f, 1.46135017e-01f, 1.44621907e-02f,
  1.08857537e-02f, -1.79499552e-01f, -1.50415659e-01f, 6.50052056e-02f, 1.23924151e-01f, 3.07033062e-02f, -8.97257472e-04f, -5.90995736e-02f, -4.28309618e-03f, -1.79912403e-01f,
  -1.54734358e-01f, -3.39106582e-02f, -1.07339527e-02f, -2.99846614e-03f, -4.56939489e-02f, 2.33423281e-02f, 3.85163864e-03f, 2.72493660e-02f, 3.88536826e-02f, 2.11632997e-02f,
  1.10518495e-02f, -1.84279121e-02f, 3.77938338e-02f, 1.50759509e-02f, 5.33311926e-02f, -1.06630869e-01f, -4.51151794e-03f, 1.63679780e-03f, -1.08039724e-02f, -7.82337710e-02f,
  4.93153110e-02f, -1.60609651e-02f, -1.49511388e-02f, 7.29700997e-02f, 3.86230126e-02f, 3.85191627e-02f, 1.80738941e-02f, 1.24173194e-01f, -1.80297941e-02f, -3.99889536e-02f,
  1.62614390e-01f, -8.57653003e-03f, -8.67532045e-02f, 8.13396126e-02f, -5.77140599e-03f, 1.00322150e-01f, 6.34553656e-02f, 7.29088485e-02f, 1.13181569e-01f, 2.28183921e-02f,
  1.45913973e-01f, 6.95403069e-02f, 9.74749550e-02f, 6.64083809e-02f, 4.66285869e-02f, 9.46549028e-02f, -2.86044292e-02f, 9.79364291e-02f, 5.76044731e-02f, 4.54504862e-02f,
  4.53449488e-02f, -4.52745846e-03f, 5.17180711e-02f, 8.86279270e-02f, 9.00081322e-02f, 5.25533669e-02f, 1.45231888e-01f, 7.54570514e-02f, -9.20286309e-03f, -3.98771018e-02f,
  -2.04160690e-01f, 3.43296885e-01f, -3.23658705e-01f, 1.48163885e-01f, 7.25394785e-02f, 5.67791536e-02f, 2.70858914e-01f, 1.42898649e-01f, -6.38206005e-02f, 2.04042897e-01f,
  4.50287640e-01f, 1.02756888e-01f, -1.33449659e-01f, -6.03448376e-02f, -1.60242036e-01f, -2.06608742e-01f, -4.80384231e-01f, -5.63209355e-01f, -3.71813089e-01f, 5.09954169e-02f,
  1.13388769e-01f, 3.35134892e-03f, -2.30253205e-01f, -1.89184263e-01f, 1.04287453e-01f, -6.68347031e-02f, -3.43204364e-02f, 5.12196384e-02f, 2.86244601e-03f, -1.64358810e-01f,
  -2.92588659e-02f, 4.46516409e-04f, 9.46452655e-03f, 1.08095907e-01f, -4.58057225e-02f, -5.01852371e-02f, -1.66041683e-02f, -1.26008481e-01f, 5.95171601e-02f, 1.03316102e-02f,
  1.16468862e-01f, -2.99349874e-02f, -9.35061648e-02f, 1.29886016e-01f, 2.85009332e-02f, 4.43281196e-02f, -7.63225853e-02f, -5.12416475e-02f, -1.38144985e-01f, 1.22406363e-01f,
  1.37336552e-01f, -4.39291373e-02f, -6.51025698e-02f, 4.08904068e-02f, 8.57935939e-03f, -1.51892304e-01f, 1.25534549e-01f, -3.13905030e-02f, -9.37073380e-02f, 1.57760173e-01f,
  -3.27454098e-02f, -4.91079241e-02f, -3.83218043e-02f, 5.43367304e-02f, -2.02843230e-02f, 3.70396562e-02f, 2.20339075e-02f, 1.52119109e-02f, 1.60484090e-02f, -2.88939802e-03f,
  5.70743047e-02f, 1.45000620e-02f, -1.86111555e-02f, -2.12099012e-02f, -7.89390504e-02f, -9.35879573e-02f, -7.72982687e-02f, 2.90288497e-02f, -8.19859579e-02f, -5.12280799e-02f,
  -2.44677532e-02f, 4.47308719e-02f, 5.82683347e-02f, 9.17428508e-02f, -2.24498101e-02f, -1.23654500e-01f, -1.06782064e-01f, 6.86367080e-02f, -4.65808116e-05f, -3.36119458e-02f,
  2.75500655e-01f, -1.07094489e-01f, -8.77215248e-03f, -1.15357684e-02f, -5.71746901e-02f, 1.98530275e-02f, 3.92514206e-02f, 2.01533753e-02f, 5.76115437e-02f, 6.67832717e-02f,
  1.26119569e-01f, 1.31994247e-01f, 4.59612943e-02f, 8.93384367e-02f, 3.14446688e-02f, 8.87367427e-02f, 1.92078546e-01f, 3.04562990e-02f, -7.83623010e-02f, 1.05448663e-01f,
  1.25331447e-01f, -8.84973165e-03f, 4.07913141e-02f, 7.57010281e-02f, -1.91808678e-02f, -1.33338585e-01f, 6.63330257e-02f, 1.37186861e-02f, -9.00612026e-02f, 1.93830848e-01f,
  -3.95922244e-01f, -3.79675061e-01f, -4.08976197e-01f, 2.89783888e-02f, 8.20141062e-02f, -2.46662676e-01f, -6.01063192e-01f, -9.43983197e-02f, 1.80661365e-01f, -3.26509148e-01f,
  -8.37887153e-02f, 3.93616796e-01f, 3.80990595e-01f, 2.08420530e-01f, -1.20122656e-01f, -4.42406952e-01f, -3.66349727e-01f, -2.49596864e-01f, 4.09310944e-02f, -2.31878497e-02f,
  2.75387093e-02f, -1.97784249e-02f, -1.38201296e-01f, -6.91925809e-02f, 7.66805634e-02f, 2.53535748e-01f, -1.45028293e-01f, -1.46272723e-02f, -1.82846054e-01f, -2.96334893e-01f,
  -1.32785842e-01f, -2.16764674e-01f, 1.04569383e-01f, 2.93354578e-02f, -1.11576341e-01f, -1.27250865e-01f, -1.81961775e-01f, -3.40850204e-02f, -9.25161168e-02f, -1.86901972e-01f,
  3.45151834e-02f, -5.31058088e-02f, 3.44364941e-02f, -7.49914199e-02f, -1.70850992e-01f, -1.14946917e-01f, -1.42548621e-01f, -2.24767745e-01f, -2.19196513e-01f, -2.01290190e-01f,
  -5.24568837e-03f, -2.45576948e-01f, -1.77677423e-01f, -1.01190515e-01f, -5.00660054e-02f, 8.08324218e-02f, -8.64858031e-02f, -1.70317143e-01f, -7.90184289e-02f, -1.45205766e-01f,
  -1.00162283e-01f, -5.48975123e-03f, -3.45468288e-03f, 2.63691377e-02f, 5.71399443e-02f, -1.89704038e-02f, 7.24082068e-02f, 5.76439500e-02f, 9.33008939e-02f, 1.07471146e-01f,
  -9.25497094e-04f, -4.56353948e-02f, 3.45078819e-02f, -4.63121152e-03f, 9.86353233e-02f, 9.51416697e-03f, -5.47995139e-03f, 6.89640120e-02f, 1.51148781e-01f, 7.67943077e-03f,
  6.13705218e-02f, 1.16327636e-01f, 6.14976473e-02f, 5.39620072e-02f, -1.17378021e-02f, -3.73528339e-02f, 4.13262583e-02f, 6.34829402e-02f, 6.30781949e-02f, -5.29913828e-02f,
  3.75956595e-01f, -8.23603794e-02f, -8.64110738e-02f, -1.80106908e-02f, 3.45888734e-02f, -9.64715183e-02f, 2.89613474e-02f, -8.93596262e-02f, -2.00597197e-02f, -7.06498623e-02f,
  -1.05620481e-01f, -8.42844099e-02f, -2.20911223e-02f, -7.83535540e-02f, -3.86898182e-02f, -2.55204439e-02f, -7.66932443e-02f, -1.74020268e-02f, -5.51760867e-02f, -1.13821998e-01f,
  -1.96908355e-01f, -4.00711522e-02f, 1.21488579e-01f, 3.14566754e-02f, 5.60804177e-03f, 6.54547065e-02f, 3.87655273e-02f, -3.81368287e-02f, -1.76598306e-03f, -1.28730059e-01f,
  -5.78748398e-02f, 2.72113502e-01f, -3.03690881e-01f, 3.92613679e-01f, 1.52568415e-01f, -2.30086476e-01f, 1.04990534e-01f, -3.59245762e-02f, 1.22759417e-01f, 1.17849126e-01f,
  1.95186604e-02f, -1.02983050e-01f, -1.95561633e-01f, -2.00223446e-01f, -2.56087959e-01f, 1.41597182e-01f, 2.48800799e-01f, -2.03611895e-01f, -5.15308619e-01f, -1.34565830e-01f,
  1.92177519e-01f, 2.14901611e-01f, 1.15997292e-01f, 7.03485236e-02f, 3.14634919e-01f, -5.43960072e-02f, 1.81749925e-01f, 1.70769975e-01f, -1.68258607e-01f, 5.86957693e-01f,
  -1.93717167e-01f, 1.17198884e-01f, -2.26272672e-01f, -3.91969308e-02f, -8.07174668e-02f, -1.88232407e-01f, -1.32609144e-01f, 2.02993094e-03f, -5.21372538e-03f, -2.26536542e-02f,
  8.21074937e-03f, -5.30406758e-02f, 1.05832614e-01f, -2.55358443e-02f, -4.03390191e-02f, -7.37130716e-02f, -2.98088156e-02f, -5.64791597e-02f, -1.69079542e-01f, -4.74036261e-02f,
  8.11009184e-02f, -3.33955069e-03f, -1.53548568e-01f, -9.40165743e-02f, -1.46803916e-01f, -1.16279349e-01f, -1.62990093e-01f, -4.59046960e-02f, -2.22203314e-01f, 1.62481725e-01f,
  3.39143723e-02f, -9.74107385e-02f, -9.75259393e-02f, 3.37188616e-02f, 7.84016401e-02f, -2.26727445e-02f, 2.54880507e-02f, 2.36022417e-02f, -5.74190058e-02f, 6.90905452e-02f,
  -4.14446667e-02f, -9.15563200e-03f, 1.15731126e-02f, -1.83433462e-02f, -4.96161310e-03f, -4.38160822e-02f, 5.29072210e-02f, -5.67982197e-02f, -6.82383031e-02f, 2.64870506e-02f,
  -4.65856269e-02f, -1.87525928e-01f, -9.21834782e-02f, -2.76267845e-02f, 3.69910896e-02f, -5.31456769e-02f, 2.71868575e-02f, 1.94852389e-02f, -7.15202326e-03f, 7.52368793e-02f,
  -8.49882439e-02f, -2.39399120e-01f, 6.79107532e-02f, -1.20075420e-02f, -5.76069094e-02f, 7.28393812e-03f, 1.39420340e-02f, 4.38352451e-02f, 4.10678051e-03f, -6.00029714e-02f,
  -3.08882706e-02f, 6.06393069e-03f, -1.12590217e-03f, 7.17403367e-02f, -8.46638810e-03f, -2.14307811e-02f, 2.15302641e-03f, 7.21657500e-02f, -5.02366498e-02f, 7.60429204e-02f,
  1.14259385e-01f, -4.34572324e-02f, -1.84998721e-01f, -1.12745427e-01f, -3.97657119e-02f, -2.91786611e-01f, -5.52081056e-02f, -1.46806851e-01f, -3.99798512e-01f, 9.41325948e-02f,
  -5.86324751e-01f, -2.09091142e-01f, -6.78827047e-01f, -2.66999483e-01f, 1.57198414e-01f, 2.83282585e-02f, -7.20937252e-02f, -3.98075841e-02f, 5.45864366e-02f, -1.74835920e-02f,
  2.19327673e-01f, 3.59139383e-01f, 5.11144362e-02f, 1.30248204e-01f, 5.12546375e-02f, -6.10312223e-02f, -1.13102853e-01f, -1.52858660e-01f, -2.97991000e-02f, 2.39628956e-01f,
  3.44672322e-01f, 2.52111293e-02f, -1.32241070e-01f, 7.26187453e-02f, -2.86091361e-02f, 2.19692335e-01f, -3.82519290e-02f, 4.18145284e-02f, 1.47330135e-01f, -2.93474291e-02f,
  -3.90568733e-01f, -3.43210310e-01f, 4.01431173e-02f, 3.18896808e-02f, -3.90475541e-02f, -3.96509282e-02f, -8.57357457e-02f, -3.37421820e-02f, -1.54735176e-02f, 8.62459838e-03f,
  4.43171225e-02f, 7.76833743e-02f, 9.26118419e-02f, 1.07856505e-01f, -4.51757982e-02f, -7.38349110e-02f, 9.24727470e-02f, -9.93363336e-02f, -1.94304641e-02f, 2.86820065e-02f,
  1.59687176e-01f, 8.21237490e-02f, -1.14906304e-01f, 2.47919224e-02f, -5.43477535e-02f, 1.50678745e-02f, -1.03354909e-01f, 8.76853317e-02f, 8.20898823e-03f, -1.92225315e-02f,
  -1.63977705e-02f, 3.51898670e-02f, -6.53424785e-02f, -4.76186909e-02f, 8.79390314e-02f, 3.22902948e-02f, 5.60050346e-02f, 7.07083195e-02f, 4.68556508e-02f, -5.51481061e-02f,
  -1.42711615e-02f, 3.41235697e-02f, -5.37206884e-03f, -5.57288043e-02f, 7.27879927e-02f, 3.16462778e-02f, -2.87435316e-02f, 4.35868576e-02f, 6.87522814e-02f, 5.04059903e-03f,
  -1.74688660e-02f, 2.99628302e-02f, 1.14007248e-02f, 1.43853005e-03f, -1.26664219e-02f, -6.22329907e-03f, -5.70223331e-02f, 6.67182654e-02f, 5.83708994e-02f, 5.85116111e-02f,
  1.92411300e-02f, 2.17265755e-01f, -1.09138899e-01f, 1.44705316e-02f, -6.68094605e-02f, 9.09124501e-03f, 2.76241843e-02f, -3.69519666e-02f, -3.50995958e-02f, -3.74016725e-02f,
  7.85286129e-02f, -3.59537192e-02f, 4.94337305e-02f, 8.06786343e-02f, 2.33854465e-02f, 5.72543517e-02f, 1.15353346e-01f, -2.84060240e-02f, 1.97153836e-02f, -1.79042276e-02f,
  1.05327338e-01f, -4.22171280e-02f, -1.62350610e-01f, -9.39170271e-02f, -2.08964627e-02f, -7.48807844e-03f, -1.55861601e-01f, -9.71666202e-02f, -8.84251148e-02f, -1.83923185e-01f,
  -7.45972335e-01f, 3.28620553e-01f, 4.21736389e-01f, -5.56979358e-01f, 2.69263893e-01f, 2.92240202e-01f, 5.42466760e-01f, 1.31439954e-01f, -1.82606205e-01f, -5.54094091e-03f,
  -2.26478539e-02f, -3.88345987e-01f, -2.95311570e-01f, -1.49978980e-01f, 1.19882956e-01f, 2.94974446e-01f, 2.90739268e-01f, 3.94816175e-02f, 6.70117140e-02f, 5.13086095e-02f,
  -9.07243565e-02f, -6.33707969e-03f, -3.15738827e-01f, -7.62693509e-02f, -2.29912978e-02f, -5.77558279e-02f, 1.42318234e-01f, -1.49181321e-01f, 1.38937607e-01f, -4.89315130e-02f,
  -7.73935616e-02f, -1.88153163e-02f, 1.64630443e-01f, -6.77213669e-02f, 1.48268580e-01f, -5.43502718e-02f, -1.79244503e-02f, -7.16730729e-02f, -5.03107486e-03f, 4.89430986e-02f,
  1.29971383e-02f, -3.45704556e-02f, -8.68100952e-03f, 7.70010650e-02f, 6.99714720e-02f, 4.48398218e-02f, -9.29825455e-02f, 5.53729087e-02f, 7.69123249e-03f, 1.98102221e-02f,
  -8.02535936e-03f, -3.61901289e-03f, 1.21969715e-01f, 4.98628579e-02f, 7.36372471e-02f, -7.42747076e-03f, 8.11026543e-02f, 1.07228504e-02f, 9.13186371e-02f, -1.64393619e-01f,
  7.44119147e-03f, -5.81919365e-02f, 2.35523991e-02f, 1.15871977e-03f, -5.49971648e-02f, -7.43586496e-02f, -9.22139094e-04f, 4.66005318e-02f, 3.89261246e-02f, -2.15845145e-02f,
  -1.38180028e-03f, 3.94897237e-02f, -4.35027741e-02f, -1.27467271e-02f, -5.29745296e-02f, 3.46689001e-02f, 1.78532116e-02f, 2.98591442e-02f, 1.89891104e-02f, 8.41006190e-02f,
  -6.51006550e-02f, 6.16181009e-02f, -9.70586836e-02f, 4.92286943e-02f, 2.20933873e-02f, 1.65086705e-02f, -5.62977828e-02f, 2.34304555e-02f, -3.80006321e-02f, 1.37794139e-02f,
  -2.54863948e-01f, 1.95509136e-01f, -1.48633644e-01f, -3.54745314e-02f, -1.59018543e-02f, -5.16413525e-02f, -1.25030440e-03f, 1.93573777e-02f, 2.32128464e-02f, -7.41696800e-04f,
  6.50401860e-02f, -2.16287468e-02f, 3.11758351e-02f, -1.09579982e-02f, 1.37094595e-02f, -1.28629515e-02f, -4.82189879e-02f, -6.94100708e-02f, 5.61712086e-02f, 3.82633843e-02f,
  9.00819246e-03f, -6.46108910e-02f, -2.03275323e-01f, -2.86869295e-02f, -3.66212940e-03f, -1.64661795e-01f, 9.01148617e-02f, -4.11663987e-02f, 7.87945464e-02f, -1.05699494e-01f,
  2.69627988e-01f, 1.94257557e-01f, -8.47545341e-02f, 1.91429287e-01f, 7.29626566e-02f, 8.79570246e-02f, 4.30832624e-01f, 9.24131423e-02f, 1.83455318e-01f, 2.95575768e-01f,
  -1.62006021e-01f, -3.00660022e-02f, 9.12654921e-02f, 2.60972306e-02f, 8.30167532e-02f, 5.52472234e-01f, 5.14104009e-01f, 1.70545578e-01f, -2.42884327e-02f, 1.20593458e-01f,
  3.19619507e-01f, 7.00757802e-02f, -1.25559151e-01f, 7.19340220e-02f, 2.47496262e-01f, -2.83092167e-02f, -7.60431662e-02f, -4.19913121e-02f, -6.68721423e-02f, 5.63784480e-01f,
  1.54686019e-01f, -7.07259402e-02f, 1.85239781e-02f, 5.68240024e-02f, -2.66274922e-02f, 1.15041755e-01f, 1.12682506e-01f, -2.84780096e-02f, 2.18674839e-02f, 1.38621926e-01f,
  3.33669968e-02f, 1.16128825e-01f, 1.09048381e-01f, 3.85649800e-02f, 3.86841185e-02f, 6.93033710e-02f, 6.90290108e-02f, -4.97861505e-02f, 1.76469497e-02f, 1.11040846e-01f,
  2.28550285e-02f, -4.10628952e-02f, -7.10665435e-02f, 3.23129222e-02f, -4.17737328e-02f, 1.50588313e-02f, -6.04707114e-02f, -7.11631849e-02f, -4.63297516e-02f, 1.89705133e-01f,
  2.77936440e-02f, -1.13553479e-01f, -6.27039522e-02f, -3.37447636e-02f, -3.78282629e-02f, -1.06366545e-01f, -2.60362457e-02f, -7.39123952e-03f, -3.01392023e-02f, -5.71881272e-02f,
  -1.33087158e-01f, 5.35661653e-02f, -8.01542848e-02f, 2.99442094e-02f, -4.36497033e-02f, -6.89003542e-02f, -4.72356491e-02f, 1.54271452e-02f, -1.04679115e-01f, -2.88117006e-02f,
  1.45316226e-02f, -5.48182912e-02f, -3.69862840e-02f, 5.15559036e-03f, -4.42154966e-02f, -7.95911476e-02f, -6.36493638e-02f, -6.46180585e-02f, -7.35666379e-02f, -7.98219964e-02f,
  1.91759720e-01f, -2.32943922e-01f, 3.78365815e-01f, 1.60352349e-01f, 1.03518769e-01f, 7.13339821e-02f, 1.02296166e-01f, 8.69007781e-02f, 7.91061074e-02f, 1.35566354e-01f,
  -2.27546059e-02f, 8.25959742e-02f, 6.25008345e-02f, 1.10783637e-01f, 1.51638940e-01f, 3.37806977e-02f, 1.96280599e-01f, 1.93619892e-01f, 7.92501867e-02f, 1.02464128e-02f,
  1.00178950e-01f, 2.82243282e-01f, 3.63326609e-01f, 1.57302409e-01f, 8.44883323e-02f, 2.11651698e-01f, 1.51120156e-01f, 1.34925678e-01f, 1.87347487e-01f, 4.68415499e-01f,
  -4.00460333e-01f, -5.86087350e-03f, -4.33919355e-02f, 2.53379226e-01f, 3.19090992e-01f, 4.76904511e-02f, 5.12428917e-02f, -5.22955954e-02f, 5.84195890e-02f, 1.97576940e-01f,
  -1.91134080e-01f, -1.62730634e-01f, -2.56580681e-01f, -2.19059989e-01f, -5.42493343e-01f, 1.71766669e-01f, 3.08502227e-01f, -2.43107811e-01f, -3.30916077e-01f, -5.85065782e-02f,
  1.37615219e-01f, 1.48045465e-01f, -2.83041000e-01f, -1.16520584e-01f, 2.17644274e-01f, 1.76680982e-01f, 1.56740040e-01f, 1.63022473e-01f, -1.56553745e-01f, 3.86449635e-01f,
  -2.94271316e-02f, -2.77200580e-01f, -1.86188892e-02f, -1.88280363e-02f, -2.63145613e-03f, -4.57882998e-04f, 1.71062145e-02f, 6.28320873e-02f, 4.88757342e-02f, 7.15621039e-02f,
  4.84486893e-02f, -4.15853634e-02f, -3.61605622e-02f, -3.53523227e-03f, 1.05398796e-01f, 8.08074232e-03f, 4.49889712e-02f, -1.17272951e-01f, -9.30134673e-03f, -4.74714227e-02f,
  1.24549039e-01f, 1.27134835e-02f, -5.10976166e-02f, -6.11270033e-02f, -1.26492575e-01f, -2.66691130e-02f, -2.06789766e-02f, -1.41244382e-01f, -9.66523588e-02f, 1.63218096e-01f,
  1.03757389e-01f, 7.22167715e-02f, -7.07502570e-03f, 3.81375924e-02f, 3.26338857e-02f, 3.03894095e-02f, 8.11823010e-02f, 1.62131824e-02f, 1.90354288e-02f, 4.70845439e-02f,
  -6.24849461e-02f, -2.63507683e-02f, 4.89022024e-02f, -6.82326332e-02f, 4.13228981e-02f, 1.72288250e-02f, -2.38984227e-02f, 2.81251278e-02f, -2.34147236e-02f, 1.04274806e-02f,
  -3.40953432e-02f, 2.26338543e-02f, 9.60154682e-02f, -1.33995130e-03f, -5.75250834e-02f, -7.81489238e-02f, -2.59487145e-02f, -5.24069071e-02f, 4.86191325e-02f, -3.28025338e-03f,
  2.16666862e-01f, -3.43813062e-01f, 3.72709967e-02f, -9.84623954e-02f, 9.36642513e-02f, -9.84807089e-02f, 6.90495223e-02f, 6.32551592e-03f, 5.07263169e-02f, -9.58864298e-03f,
  -1.59946084e-01f, -6.93484023e-02f, -4.32577945e-04f, 3.64523008e-02f, 2.81031206e-02f, 1.55758513e-02f, 4.16811332e-02f, -6.01543067e-03f, -4.12377119e-02f, 2.59481594e-02f,
  9.84564871e-02f, 1.29972801e-01f, 3.78052555e-02f, 6.35711923e-02f, 3.61510217e-02f, -2.35057413e-03f, 6.29025698e-02f, 7.75794983e-02f, -1.52243316e-01f, 2.66853243e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.19125807e+00f, 5.64298093e-01f, -2.46106442e-02f, 5.53777814e-01f, 5.39664030e-01f, 1.66370541e-01f, 1.82430118e-01f, -3.57353799e-02f, -6.65900018e-03f, 3.86767715e-01f,
  5.15566468e-01f, 4.50383067e-01f, 1.43717751e-01f, 1.09200422e-02f, -1.06815457e-01f, -1.11943386e-01f, -2.24618003e-01f, -5.96783310e-02f, -6.86092675e-02f, 3.60295236e-01f,
  5.25725484e-01f, 3.83397192e-01f, 2.58821338e-01f, 1.54655784e-01f, 4.34971035e-01f, 1.60793349e-01f, 7.72094913e-03f, 4.04938102e-01f, 3.67453575e-01f, 4.08654988e-01f,
  6.53019547e-01f, 3.71320039e-01f, -4.56821442e-01f, 9.00896043e-02f, 1.91943184e-01f, -1.44410655e-01f, 3.55376825e-02f, -2.26174533e-01f, 1.66085839e-01f, -1.43436179e-01f,
  1.35391414e-01f, 9.04507563e-02f, 1.86769456e-01f, -8.06004331e-02f, 1.22789736e-03f, -1.07454350e-02f, -1.27921134e-01f, -1.46956116e-01f, -8.02353919e-02f, -9.33721736e-02f,
  1.53157353e-01f, 1.36728063e-01f, -8.95429701e-02f, -2.37279803e-01f, -4.37624902e-02f, 2.12131860e-03f, -8.86411145e-02f, 5.46810739e-02f, -1.82754606e-01f, -2.56593190e-02f,
  4.90140282e-02f, 1.43832594e-01f, 3.74599665e-01f, 1.37376621e-01f, 2.49829695e-01f, -5.12116887e-02f, -3.64549309e-02f, 1.29637539e-01f, 1.96173608e-01f, 7.45218024e-02f,
  -1.53990507e-01f, 5.80676012e-02f, -1.14654645e-01f, -1.23000152e-01f, -2.71317251e-02f, 1.52115360e-01f, -6.11707158e-02f, -7.08904043e-02f, 5.57201244e-02f, -1.48504034e-01f,
  1.60993055e-01f, -2.78724760e-01f, 3.04646157e-02f, -7.90924951e-02f, -3.52675587e-01f, -1.09567456e-02f, 1.21028297e-01f, 1.62936494e-01f, 1.44076079e-01f, 2.01642916e-01f,
  -5.47446728e-01f, -2.41477236e-01f, -1.74819361e-02f, -1.97593018e-01f, 1.11182138e-01f, 2.84415781e-02f, 3.03065032e-01f, -4.24260013e-02f, 4.72012833e-02f, -1.83013320e-01f,
  -2.65450738e-02f, -7.57638067e-02f, 6.06040917e-02f, -8.14319029e-02f, -1.14914626e-01f, -1.19278193e-01f, 6.05975501e-02f, -1.99293509e-01f, -2.14657694e-01f, -1.76916823e-01f,
  -1.64584741e-01f, -3.19262296e-01f, -3.37202609e-01f, -3.73272419e-01f, -2.37878352e-01f, -1.38636157e-01f, -2.40842193e-01f, -2.41138563e-01f, -2.89285421e-01f, -3.79739910e-01f,
  -1.65617537e+00f, 3.55657458e-01f, 7.69304633e-01f, -8.37500453e-01f, 7.48479307e-01f, 2.87785500e-01f, -2.37309948e-01f, -6.17299616e-01f, -2.66922325e-01f, 4.52429444e-01f,
  7.83621550e-01f, -1.10965095e-01f, -7.97325671e-02f, -2.45537609e-01f, -1.30564702e+00f, -4.57870334e-01f, -4.17672098e-01f, -1.01038373e+00f, -1.15418768e+00f, -6.28976285e-01f,
  -2.69261122e-01f, -7.97527611e-01f, -1.05174267e+00f, -6.03930414e-01f, 4.26808476e-01f, 1.97227970e-02f, 5.06890178e-01f, 1.00891285e-01f, 5.67992449e-01f, 4.80050594e-01f,
  8.23199928e-01f, 2.99059004e-01f, -7.52712637e-02f, -1.55351505e-01f, 3.70301902e-01f, -2.19341472e-01f, -9.06371623e-02f, 1.00438021e-01f, -8.56031999e-02f, 1.05201483e-01f,
  3.34612727e-01f, 2.37630904e-01f, 4.22099326e-03f, 2.11891592e-01f, -2.67981023e-01f, -3.63283217e-01f, -2.65158415e-01f, -7.50211120e-01f, -5.61484337e-01f, -1.08610220e-01f,
  -3.92234176e-02f, 1.24744937e-01f, -1.16845876e-01f, 9.18647498e-02f, 5.23110032e-02f, -2.26579681e-01f, 2.10393742e-01f, 2.10632011e-01f, -9.36064695e-04f, -4.62918878e-02f,
  -4.16077450e-02f, 2.10773304e-01f, 1.42376304e-01f, 7.59247243e-02f, -2.00960070e-01f, 2.40408197e-01f, 1.22706600e-01f, -7.85965025e-02f, -6.08284585e-02f, -8.47753212e-02f,
  9.94660556e-02f, 1.65928174e-02f, -1.42746896e-01f, -2.31115654e-01f, -1.68336675e-01f, -4.02834788e-02f, 3.74060869e-02f, -3.47734153e-01f, -2.63228863e-01f, 2.06933706e-03f,
  -1.88621402e-01f, 1.36167616e-01f, 1.73993587e-01f, -2.09915191e-01f, 1.99824974e-01f, -8.43909010e-02f, 2.37000048e-01f, 7.78341666e-02f, -1.25824630e-01f, 9.72105637e-02f,
  -4.50182557e-01f, -3.45028229e-02f, -8.12746212e-02f, -3.61626625e-01f, 2.03294113e-01f, 2.50639349e-01f, 2.81560540e-01f, 4.18759063e-02f, 2.40925342e-01f, -4.14206147e-01f,
  -3.62214223e-02f, -3.04573536e-01f, 1.43006340e-01f, -2.36989912e-02f, -2.87281424e-02f, -1.33001924e-01f, -3.00773263e-01f, -3.22072394e-02f, -3.25760067e-01f, -2.30436642e-02f,
  -4.70194876e-01f, -7.07877517e-01f, -8.46620202e-01f, -3.29764992e-01f, -1.45790219e-01f, -5.15998363e-01f, -1.12367988e-01f, -1.94595121e-02f, -6.68426871e-01f, -9.11111176e-01f,
  -3.11607737e-02f, -1.12228775e+00f, -3.87047797e-01f, -9.66494560e-01f, -3.80502522e-01f, 4.19155419e-01f, 3.51606682e-02f, -3.16350996e-01f, -5.98628998e-01f, -5.87480783e-01f,
  -8.53523165e-02f, 7.87349284e-01f, 1.18609317e-01f, 3.10541809e-01f, 7.05140293e-01f, -6.28272474e-01f, -7.82493472e-01f, 4.77799714e-01f, 1.54560649e+00f, 9.66997206e-01f,
  7.22043142e-02f, -3.56747627e-01f, 1.23376332e-01f, 4.39161882e-02f, -9.19034660e-01f, 7.35651404e-02f, -1.13506401e+00f, -6.12191498e-01f, -4.79094610e-02f, -1.21353292e+00f,
  5.54150283e-01f, -6.25303388e-01f, 1.28182739e-01f, -1.48498237e-01f, -9.47890803e-02f, 1.39952809e-01f, 1.89521253e-01f, -3.26197714e-01f, -2.34309081e-02f, -3.39242280e-01f,
  -2.38591164e-01f, 1.02400906e-01f, -2.78417598e-02f, 8.71469006e-02f, 1.08398609e-01f, 1.07104685e-02f, -2.92739451e-01f, -1.31986305e-01f, -2.29515091e-01f, -6.88091069e-02f,
  -1.07149288e-01f, -6.60351962e-02f, -2.30146758e-02f, 6.75074873e-04f, -1.56550944e-01f, 1.36011139e-01f, -1.85070023e-01f, -1.15442112e-01f, 6.80284051e-04f, -5.24072111e-01f,
  8.67861137e-02f, 6.63015172e-02f, 1.17119886e-01f, -3.45896482e-02f, 1.08985268e-01f, -1.12497825e-02f, 9.32807550e-02f, 7.64115006e-02f, 9.44975168e-02f, 2.48557772e-03f,
  1.82732549e-02f, -2.84845047e-02f, -1.42077431e-01f, -1.28125712e-01f, -1.12252243e-01f, -1.40528902e-01f, 1.43603086e-01f, -6.51164949e-02f, -2.02123210e-01f, -1.58057008e-02f,
  -3.27568538e-02f, -1.46087334e-01f, -1.69375375e-01f, 6.86892867e-02f, -1.75751388e-01f, -2.20523626e-02f, -9.62162539e-02f, 5.47314137e-02f, -4.29417342e-02f, -1.33192986e-01f,
  2.82131303e-02f, 1.45303980e-01f, -6.17599487e-03f, 6.51578829e-02f, -5.88481948e-02f, -2.69379973e-01f, -1.19075604e-01f, 6.84239566e-02f, -1.22325800e-01f, 4.75665554e-02f,
  8.63143429e-02f, 3.23052406e-02f, -2.88835466e-01f, -5.58901317e-02f, 3.26472819e-01f, -3.39074545e-02f, -9.86655951e-02f, 1.99883506e-01f, -8.61263797e-02f, -8.64379331e-02f,
  -3.61029834e-01f, 2.39428252e-01f, 4.35282737e-01f, 2.57546991e-01f, -1.18430294e-01f, 4.27733630e-01f, 2.36376479e-01f, 2.10823834e-01f, 4.41342950e-01f, 4.78116833e-02f,
  1.34363317e+00f, -1.37004226e-01f, 2.35094801e-01f, 2.37379625e-01f, 3.91913265e-01f, 4.62761074e-01f, 5.76575339e-01f, 2.73158938e-01f, -6.76085204e-02f, 1.05028793e-01f,
  1.53118178e-01f, -5.41257821e-02f, -1.28172830e-01f, -1.67239130e-01f, -1.63969360e-02f, -3.52863371e-01f, -3.86292934e-01f, -9.75361168e-02f, 2.56715357e-01f, 1.23576678e-01f,
  -2.78052062e-01f, 2.86781751e-02f, 2.56410301e-01f, -3.10078897e-02f, -3.97251606e-01f, -1.83538675e-01f, -7.94315189e-02f, -8.77771899e-03f, -1.78537712e-01f, -7.95543075e-01f,
  -4.17943269e-01f, 4.13487673e-01f, -1.21736795e-01f, -1.13450304e-01f, 1.02372363e-01f, -3.88418064e-02f, -5.95726371e-02f, -7.46038556e-02f, -1.25744697e-02f, -2.16934413e-01f,
  -4.65452671e-03f, -6.58495650e-02f, 2.05672875e-01f, 6.13266714e-02f, 2.12644055e-01f, 7.65226930e-02f, 8.04372728e-02f, -5.90307564e-02f, -1.33122683e-01f, -1.84959903e-01f,
  -9.08771157e-02f, 1.16963640e-01f, 1.40348718e-01f, 1.07316867e-01f, 1.10861257e-01f, 1.20842874e-01f, 1.01752900e-01f, -3.55157182e-02f, 2.10106716e-01f, -6.67925458e-03f,
  -6.65319934e-02f, 5.88527620e-02f, -1.07181203e-02f, 1.05558053e-01f, 1.92462623e-01f, 2.73896530e-02f, -6.00441061e-02f, 2.19927207e-02f, 2.41784140e-01f, 2.74995565e-01f,
  -7.01801926e-02f, -3.04936133e-02f, 1.37133509e-01f, 4.71881293e-02f, -1.65478155e-01f, 2.91341059e-02f, -1.44965559e-01f, -1.93760097e-02f, 1.76789910e-01f, -1.74950212e-02f,
  1.06061913e-01f, -1.03238009e-01f, 1.43616013e-02f, -3.87397856e-02f, -4.54249904e-02f, -1.36611927e-02f, -5.41032143e-02f, -5.33727854e-02f, -3.02979201e-02f, -4.43141274e-02f,
  -1.77722976e-01f, 5.71722269e-01f, -2.33424932e-01f, -1.45676389e-01f, -1.15123466e-02f, -6.44255951e-02f, -1.16255749e-02f, -1.18646227e-01f, -2.63278335e-01f, -2.25352436e-01f,
  9.54196230e-02f, -1.03959918e-01f, 8.97567943e-02f, -1.90566722e-02f, 1.73086107e-01f, 1.23729080e-01f, 6.23847954e-02f, 9.28178877e-02f, -2.19232515e-01f, -2.07511112e-01f,
  -2.17751160e-01f, 1.61501467e-01f, 1.21619724e-01f, 7.47772753e-02f, 5.74386716e-02f, 9.57749505e-03f, -8.08234792e-03f, 6.17781058e-02f, 3.23959231e-01f, 1.29978046e-01f,
  8.15837309e-02f, 2.06573844e-01f, -1.91142333e+00f, 1.73434298e-02f, -9.07692790e-01f, -4.10997480e-01f, -4.66226190e-02f, 6.27611160e-01f, 5.51051021e-01f, -3.44680846e-02f,
  -2.32015371e-01f, -2.73102731e-01f, -6.79031670e-01f, -1.85227230e-01f, 4.11244072e-02f, -3.55346650e-01f, -6.89714313e-01f, -6.59558535e-01f, -4.89706904e-01f, 2.72169411e-01f,
  1.25678685e-02f, -3.21995139e-01f, -7.12642595e-02f, 1.04100630e-01f, -4.01495278e-01f, -7.54792929e-01f, -8.00483465e-01f, -6.09947443e-01f, -3.69737864e-01f, -1.16299891e+00f,
  -1.15072405e+00f, -3.14267188e-01f, -3.21322829e-01f, 6.86237961e-02f, -2.02979475e-01f, 3.31006467e-01f, 3.06901615e-02f, -2.63716400e-01f, 9.15766433e-02f, -1.06005624e-01f,
  -3.25903982e-01f, 7.69832684e-03f, -3.22800964e-01f, -1.01757683e-01f, -1.86556369e-01f, 5.99284656e-02f, -9.96737555e-02f, -4.85061891e-02f, -5.62115647e-02f, 1.64001539e-01f,
  1.04319528e-01f, -4.65661809e-02f, -2.43886754e-01f, 2.74280608e-01f, 2.92568415e-01f, -1.55969530e-01f, 6.49816021e-02f, -1.12343960e-01f, -1.65810555e-01f, -2.15075180e-01f,
  1.93495706e-01f, -1.23589687e-01f, -1.17791466e-01f, 1.83748156e-01f, 6.04268312e-02f, 8.75483081e-03f, 1.38925035e-02f, -3.51610384e-03f, 9.00926962e-02f, -9.25492570e-02f,
  -4.20977250e-02f, -8.75931606e-02f, 2.09176466e-02f, -1.11095548e-01f, -2.46843666e-01f, -1.41550243e-01f, 1.00778677e-01f, 2.45557457e-01f, 4.46652323e-02f, 4.81705554e-03f,
  -1.15833662e-01f, 3.17658521e-02f, -2.98954695e-01f, 5.94296865e-03f, 6.78231427e-03f, -1.77144930e-02f, 2.30002310e-02f, 1.89674258e-01f, -1.73978768e-02f, -1.53618902e-01f,
  -3.56561020e-02f, 7.30463862e-02f, -9.84730721e-02f, 1.65582001e-01f, -1.89831585e-01f, 5.47525957e-02f, -1.20388545e-01f, 1.50595218e-01f, -1.98046863e-01f, -1.85045525e-02f,
  -1.29158452e-01f, -8.30526557e-03f, -4.23764110e-01f, 3.70771475e-02f, -8.60387459e-02f, -1.93956807e-01f, 2.41539493e-01f, -3.60487878e-01f, 1.40608370e-01f, 1.67607859e-01f,
  1.58822104e-01f, 2.69098550e-01f, -6.92155063e-02f, -1.45167187e-01f, 1.12714112e-01f, -2.18695015e-01f, -4.91848230e-01f, -3.51364523e-01f, -1.26796111e-01f, 2.88496643e-01f,
  -7.50695407e-01f, -1.29297122e-01f, -1.48124486e-01f, 5.39453745e-01f, 4.71381485e-01f, 2.29050353e-01f, -2.49700341e-02f, -1.38912420e-03f, 1.45610273e-01f, 2.96532869e-01f,
  4.53742474e-01f, 7.18413949e-01f, 7.15937734e-01f, 4.93493676e-01f, 2.38228142e-01f, 4.50560451e-01f, 4.41639543e-01f, 1.80140920e-02f, -1.17006730e-02f, 2.44143218e-01f,
  4.57823783e-01f, -1.21836632e-01f, -4.91120815e-01f, 3.23412046e-02f, 3.24420542e-01f, 4.68056887e-01f, 1.38402089e-01f, 3.92826349e-02f, 1.06964014e-01f, 1.92732215e-01f,
  1.84161156e-01f, -3.33258212e-01f, 4.25771475e-01f, 6.93279952e-02f, -1.91010892e-01f, -3.34598929e-01f, -5.21106943e-02f, -2.29168668e-01f, -2.75978923e-01f, -1.28861234e-01f,
  -7.88808540e-02f, -1.97035074e-01f, -4.05580960e-02f, -1.31561339e-01f, -1.12960584e-01f, -1.61176637e-01f, -2.19666213e-01f, -2.65262468e-04f, 6.79007098e-02f, 1.23176098e-01f,
  2.58395791e-01f, 6.46275431e-02f, 8.70721564e-02f, 7.68402368e-02f, 2.60029417e-02f, 2.77409293e-02f, -5.31579070e-02f, -2.36655734e-02f, -2.50665750e-02f, -7.76654258e-02f,
  4.00540262e-01f, 3.53204101e-01f, 1.55861676e-01f, 1.95442036e-01f, -5.48370508e-03f, 1.44207746e-01f, 1.31377399e-01f, 6.34456798e-02f, 1.47160456e-01f, -3.96558642e-02f,
  7.67759308e-02f, 1.99690551e-01f, 8.58249366e-02f, 6.15509264e-02f, 2.57150710e-01f, 5.76945208e-02f, -1.92706242e-01f, 1.10202037e-01f, 1.02520734e-02f, 3.25167691e-03f,
  -1.31419510e-01f, -9.14996937e-02f, -1.88155562e-01f, -2.38954082e-01f, 3.38615365e-02f, 2.00608000e-01f, -5.28913327e-02f, 3.82676348e-02f, -1.80260576e-02f, -1.46077096e-01f,
  1.42433614e-01f, 2.58384436e-01f, 2.67455429e-01f, 1.06693782e-01f, -2.06825465e-01f, -3.78733099e-01f, 2.58120537e-01f, -1.01556875e-01f, -3.45682293e-01f, -8.22890848e-02f,
  -9.04423371e-02f, -2.52023101e-01f, -2.70177089e-02f, -1.67677522e-01f, -1.49108872e-01f, -1.41454175e-01f, -4.44872454e-02f, 1.37315854e-01f, 2.72251498e-02f, -8.01936090e-02f,
  -1.15990743e-01f, 1.22207105e-01f, 1.18237942e-01f, 1.32315442e-01f, 1.86860919e-01f, 1.50023207e-01f, 4.14085761e-02f, -6.44725859e-02f, -1.66835636e-01f, -1.33767784e-01f,
  1.90211847e-01f, -1.00739086e+00f, -9.78922695e-02f, 4.42606002e-01f, -1.67020395e-01f, -8.89344633e-01f, -1.39639950e+00f, -7.19007075e-01f, 4.33553718e-02f, -5.33458412e-01f,
  -3.86506796e-01f, 2.77350754e-01f, 1.17841680e-02f, 4.55406634e-03f, -4.90334868e-01f, -5.53819537e-01f, 2.14093164e-01f, 7.12948620e-01f, 4.93394554e-01f, 3.45184989e-02f,
  3.84028584e-01f, 6.39118791e-01f, 7.41589963e-01f, 3.79875273e-01f, 3.03364575e-01f, 5.39139472e-03f, 1.33220211e-01f, 4.39773500e-01f, -2.85578519e-01f, 5.97299933e-01f,
  7.44095147e-02f, -9.30875726e-03f, -1.12339787e-01f, 2.01870114e-01f, 3.31109464e-01f, 1.96896661e-02f, 6.32256046e-02f, 5.89070916e-01f, -1.00533538e-01f, -4.07313816e-02f,
  3.33476096e-01f, -6.00990318e-02f, 1.41465634e-01f, 1.30637199e-01f, 2.52035499e-01f, -9.46250409e-02f, 1.91266343e-01f, 2.30288535e-01f, -7.00529963e-02f, -2.55385339e-01f,
  3.08226049e-01f, 9.51122418e-02f, -4.02418852e-01f, -4.36373532e-01f, -1.75962284e-01f, 2.45346650e-01f, -3.53857607e-01f, 2.79756993e-01f, -4.75575477e-01f, -5.38860522e-02f,
  -6.21689372e-02f, 8.76709446e-02f, -2.24994719e-02f, -4.63771895e-02f, 7.07327276e-02f, -9.67031121e-02f, 2.53002107e-01f, -1.91113483e-02f, 1.15809441e-01f, -1.03900641e-01f,
  6.18420020e-02f, 1.59348398e-02f, 2.15918586e-01f, -3.14867087e-02f, 1.36824667e-01f, 1.51696295e-01f, 1.33240178e-01f, 4.62234244e-02f, -7.44391009e-02f, -1.43603347e-02f,
  -4.39074971e-02f, -3.14578861e-02f, 2.12151706e-01f, 2.44777203e-01f, -2.50274479e-01f, 8.15740749e-02f, 7.20782205e-02f, -6.55671656e-02f, 1.57098606e-01f, -2.62224376e-01f,
  -1.84959676e-02f, -1.78012073e-01f, -2.28809625e-01f, 1.03097849e-01f, -4.50327583e-02f, 3.28995436e-02f, 8.15410614e-02f, -1.66802421e-01f, 1.74255110e-03f, -4.12943393e-01f,
  -1.23004459e-01f, -3.32376659e-01f, -7.09857047e-02f, 2.43975110e-02f, -8.22413489e-02f, -2.49957815e-01f, -2.38185853e-01f, -3.06596905e-01f, -1.84058040e-01f, -8.99263695e-02f,
  7.25225806e-02f, -6.97877944e-01f, -9.75550592e-01f, -6.92546844e-01f, -1.07700944e-01f, -4.96870458e-01f, -5.12556911e-01f, -2.81876624e-01f, -1.00759149e+00f, -1.14164472e+00f,
  6.35585189e-01f, -4.48211670e-01f, 8.53241682e-01f, 3.85191470e-01f, 2.91241944e-01f, 5.56980729e-01f, 5.95604837e-01f, 5.23613632e-01f, 2.89327353e-01f, 7.60930404e-02f,
  -6.62798762e-01f, -5.03072321e-01f, -2.89423019e-01f, -2.46918321e-01f, 1.08417340e-01f, 3.72085690e-01f, 5.27256191e-01f, 5.05723834e-01f, 4.23072129e-01f, 2.82245725e-01f,
  -1.69858541e-02f, 2.75667369e-01f, 1.79140970e-01f, 4.77589190e-01f, 2.00525701e-01f, -5.77596873e-02f, 1.56327084e-01f, -7.17919543e-02f, -1.42963752e-01f, 3.68470818e-01f,
  -2.68561333e-01f, -6.54250160e-02f, -1.48426006e-02f, -5.00214458e-01f, -3.31694335e-01f, -1.25873208e-01f, 1.51050240e-01f, -7.84679502e-03f, -2.33976886e-01f, 7.65509903e-02f,
  -1.89852059e-01f, -1.67455852e-01f, -7.52560422e-02f, -1.01750351e-01f, 6.05947524e-02f, -8.42358172e-02f, 4.28765379e-02f, 2.83901453e-01f, 1.17860049e-01f, -1.46955222e-01f,
  -2.59052038e-01f, -1.48834214e-01f, 8.77410825e-03f, 1.30137071e-01f, 1.07523412e-01f, -2.22763166e-01f, -2.43641049e-01f, -8.69239569e-02f, 1.33466452e-01f, 2.25405339e-02f,
  -9.83883068e-03f, 3.65070216e-02f, 7.29565397e-02f, 1.74594060e-01f, 7.86552355e-02f, 3.46410237e-02f, 1.50262281e-01f, 5.58484942e-02f, 1.64128155e-01f, 1.94464684e-01f,
  2.38524333e-01f, 6.68172762e-02f, 1.35078445e-01f, 9.89109352e-02f, -2.06697419e-01f, 4.15849611e-02f, 3.99881303e-02f, -7.56878629e-02f, -3.49265933e-02f, 4.40323837e-02f,
  6.65953532e-02f, 1.24911577e-01f, -4.22674417e-02f, 1.81087688e-01f, 4.40447778e-02f, 9.78078097e-02f, 1.19006261e-01f, -2.38607958e-01f, -3.87344323e-02f, -1.52474701e-01f,
  -1.81910098e-01f, -2.57837236e-01f, 9.33848172e-02f, -2.59976834e-02f, 8.99046659e-03f, -1.27005562e-01f, 9.01679322e-02f, -1.76032573e-01f, -1.16583839e-01f, 1.46608263e-01f,
  -1.18701398e-01f, 2.41901483e-02f, -3.98624688e-03f, 1.56633526e-01f, 2.41694048e-01f, 6.16218410e-02f, -2.91777432e-01f, -7.39319101e-02f, -3.39600965e-02f, -8.74548256e-02f,
  -1.97335556e-01f, 1.22770615e-01f, 1.98986664e-01f, 1.68254137e-01f, -1.32802352e-01f, -2.02962309e-02f, -5.59063889e-02f, 1.58437267e-02f, 7.17272703e-03f, 3.60689610e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  8.30105782e-01f, 8.42355967e-01f, 1.25408196e+00f, 9.80367899e-01f, 1.00232816e+00f, 4.43813920e-01f, 9.23653245e-01f, 8.87485325e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -4.87197787e-01f, -1.30822051e+00f, -2.34756023e-01f, -1.37062401e-01f, -8.26278448e-01f, -5.45782149e-01f, -3.89976621e-01f, 2.32555270e-02f, -8.49340796e-01f, 3.81517202e-01f,
  -4.34730798e-01f, -2.04789072e-01f, -6.18118346e-01f, -2.77291507e-01f, -7.36190915e-01f, 4.61380929e-01f, 2.22095922e-01f, -2.10658669e-01f, -6.90963268e-02f, -2.83410758e-01f,
  6.79393485e-02f, -1.35758340e-01f, -2.15665475e-01f, -3.46304893e-01f, -6.14411354e-01f, -3.28207403e-01f, 1.52026579e-01f, 5.31061232e-01f, 3.75319630e-01f, -1.13330555e+00f,
  1.08144537e-01f, -6.89496756e-01f, -8.40060338e-02f, -1.23105429e-01f, -4.69087899e-01f, 4.78264466e-02f, 2.23791018e-01f, 3.44410896e-01f, -2.30271965e-01f, -3.56472313e-01f,
  2.89355636e-01f, -4.31366950e-01f, 2.55707912e-02f, -4.21823025e-01f, -7.02843606e-01f, 4.95264322e-01f, -4.57842529e-01f, -1.00484324e+00f, 2.26626843e-01f, -1.31796166e-01f,
  2.04945177e-01f, -4.29370463e-01f, -1.30346984e-01f, -5.55390656e-01f, -2.36447275e-01f, -8.20592463e-01f, 3.43533665e-01f, -1.83936954e+00f, 6.17307365e-01f, 5.00742555e-01f,
  1.06799081e-01f, 2.03139022e-01f, -1.14524257e+00f, 3.95890102e-02f, 8.58992487e-02f, 2.62357574e-02f, 1.17361970e-01f, 1.08453564e-01f, 2.86143303e-01f, -3.88433546e-01f,
  4.44523871e-01f, 3.39169502e-01f, 2.74194330e-01f, 3.80755574e-01f, -1.90655053e-01f, 1.30789101e-01f, -7.78003693e-01f, -7.86830485e-01f, -4.23094988e-01f, -3.70738298e-01f,
  2.52112985e-01f, -6.12833738e-01f, 9.46307406e-02f, -2.03070983e-01f, 3.89455855e-01f, 3.21100473e-01f, -4.78959650e-01f, -6.24336362e-01f, -1.46344340e+00f, -5.32609224e-01f,
  -1.64623678e-01f, 3.11188728e-01f, -1.09049582e+00f, -4.67744440e-01f, 1.15216267e+00f, -4.71453667e-02f, 7.27989301e-02f, 1.05041981e+00f, -6.64413273e-01f, -9.98766959e-01f,
  -2.38216713e-01f, 4.74278867e-01f, 4.90242630e-01f, 2.03258231e-01f, -4.29379731e-01f, -1.00760663e+00f, -1.43978687e-03f, 9.43380222e-02f, -8.71504426e-01f, -1.16384876e+00f,
  7.84076691e-01f, 1.65311337e+00f, 2.70127833e-01f, -1.97255611e-01f, -5.27162194e-01f, -2.49251038e-01f, 5.01743257e-01f, 1.71094978e+00f, -1.82590067e-01f, -1.80468589e-01f,
  -7.51534700e-01f, 5.63282669e-01f, -2.38741398e-01f, -7.74316251e-01f, 2.21733615e-01f, -1.17494471e-01f, -1.51116681e+00f, -7.23597109e-01f, -1.26391768e-01f, 3.08791012e-01f,
  6.34727001e-01f, 4.39899921e-01f, -1.59628034e-01f, -1.97617128e-01f, -1.53178602e-01f, -1.01668544e-01f, 5.45090318e-01f, 5.91840029e-01f, -2.44590819e-01f, -1.03767537e-01f,
  4.08768922e-01f, 5.28724551e-01f, 2.81115115e-01f, -1.16851151e+00f, 2.68807471e-01f, 4.07456249e-01f, 1.66177943e-01f, 6.66624159e-02f, 6.16258271e-02f, -5.26440203e-01f,
  -4.26186025e-01f, 4.84705329e-01f, -1.02623057e+00f, 6.58711612e-01f, -1.22590113e+00f, -1.20447879e-03f, 5.64928167e-02f, 3.13768625e-01f, -1.12718388e-01f, -2.41769385e-02f,
  1.46049723e-01f, 7.85958115e-03f, 1.74701959e-01f, 6.99543178e-01f, 4.95504975e-01f, -1.45148531e-01f, 2.14386538e-01f, 9.85927284e-01f, 9.67014432e-02f, -3.71952772e-01f,
  1.46876544e-01f, 6.42087579e-01f, 1.02769279e+00f, 1.16310596e+00f, -9.57122207e-01f, 8.08806598e-01f, -2.27438673e-01f, 7.80777574e-01f, 5.30773997e-01f, 7.31505275e-01f,
  1.41824946e-01f, -1.05387235e+00f, 7.05848992e-01f, 6.93797827e-01f, 2.64800251e-01f, -1.09976602e+00f, -4.08976048e-01f, 1.60605893e-01f, 5.17851233e-01f, -1.09392196e-01f,
  -6.90942645e-01f, -3.70842040e-01f, -2.97209561e-01f, -2.78065205e-01f, 2.11840004e-01f, -1.02265501e+00f, -5.46775341e-01f, -5.43276250e-01f, -6.78127527e-01f, -1.28816199e-02f,
  4.53037381e-01f, 2.51084983e-01f, 1.90984502e-01f, 1.19235605e-01f, 6.35461092e-01f, -6.18758082e-01f, -4.48097326e-02f, -5.90460002e-01f, -7.24689066e-01f, -5.07743239e-01f,
  -7.53789186e-01f, 1.76448449e-01f, -1.10453224e+00f, -5.16865492e-01f, 2.41048113e-01f, -8.42320442e-01f, 3.24933946e-01f, -1.42394638e+00f, -1.14668405e+00f, -1.00993657e+00f,
  -1.15107799e+00f, -9.14239466e-01f, 4.31636810e-01f, 4.35158014e-01f, -6.87661693e-02f, -2.84894407e-01f, -4.05613482e-01f, -4.88678008e-01f, 2.57461276e-02f, 2.72123963e-01f,
  2.03267083e-01f, -8.76392126e-01f, -3.99346858e-01f, -4.99150842e-01f, -4.05230016e-01f, -1.47738636e-01f, -2.78144449e-01f, -5.16627133e-01f, 4.15663153e-01f, 7.28649855e-01f,
  7.36260533e-01f, -2.99289048e-01f, 1.26143247e-01f, 2.89530307e-01f, 3.83927643e-01f, 5.65626502e-01f, 1.19275607e-01f, 7.74590909e-01f, -1.64495826e-01f, 3.26182723e-01f,
  -1.29870987e+00f, -8.29475999e-01f, -5.95642209e-01f, 5.57642162e-01f, 2.28113569e-02f, 6.84295595e-02f, 8.03938210e-01f, 4.18145627e-01f, -2.73525983e-01f, 1.45226613e-01f,
  2.12394953e-01f, -1.44609567e-02f, -1.29704550e-01f, 8.23207479e-03f, -3.72150749e-01f, 3.48712683e-01f, -2.14716554e-01f, -7.60209374e-03f, -3.38113576e-01f, 5.57944238e-01f,
  -4.77534354e-01f, 5.58927655e-01f, -7.17497885e-01f, -8.45711470e-01f, -3.72960359e-01f, -3.21198881e-01f, -3.16718400e-01f, 6.20547891e-01f, 3.61561835e-01f, 6.76450729e-01f,
  -9.00422633e-01f, -1.14406300e+00f, 8.44051242e-01f, 2.05535099e-01f, -1.49878550e+00f, -2.43070871e-01f, -4.79912043e-01f, 9.90742862e-01f, 2.96064883e-01f, 9.10537764e-02f,
  8.65028799e-02f, 3.56023520e-01f, 5.23560405e-01f, 5.21833599e-02f, 4.79524076e-01f, -5.53528309e-01f, 1.61929522e-02f, -1.78408876e-01f, 2.00436026e-01f, -4.03237231e-02f,
  4.19040844e-02f, 7.45388091e-01f, 4.08485860e-01f, -1.08621776e+00f, -5.87398946e-01f, 4.04860616e-01f, 2.98623204e-01f, 5.69195271e-01f, 7.08211720e-01f, -7.73799181e-01f,
  1.41834766e-01f, 5.07652521e-01f, 5.92898667e-01f, -1.52087293e-03f, -1.46780777e+00f, -1.33231986e+00f, -6.52656555e-01f, 1.16067640e-01f, 5.85092723e-01f, -1.19538879e+00f,
  6.09783053e-01f, -4.16528285e-02f, 3.43082041e-01f, 3.69188786e-02f, 2.33242661e-02f, -7.93020874e-02f, 7.30370171e-03f, -3.45489800e-01f, 3.07316750e-01f, 3.38012457e-01f,
  1.24156289e-01f, 7.16734305e-02f, 4.25342709e-01f, -6.26756668e-01f, 3.84510010e-01f, 6.21778011e-01f, 5.25164604e-01f, 3.71777207e-01f, 4.75753576e-01f, -6.08362079e-01f,
  -3.79374564e-01f, 3.21400255e-01f, 2.63987571e-01f, 5.70892274e-01f, -5.84176302e-01f, 1.91865981e-01f, 1.43385780e+00f, -1.29536128e+00f, -1.57622910e+00f, 2.11633086e-01f,
  -1.16194952e+00f, -1.02614319e+00f, -1.71975896e-01f, 3.44262213e-01f, -5.04727848e-02f, 7.34791398e-01f, -2.75770985e-02f, 4.36509699e-01f, -4.40154731e-01f, 3.63319188e-01f,
  -6.15832116e-03f, -1.74131751e-01f, 2.41969630e-01f, -9.74217523e-03f, 5.64764321e-01f, -1.91805258e-01f, 5.47433376e-01f, -1.96081951e-01f, -3.83295327e-01f, 8.18015635e-02f,
  -4.74098250e-02f, 3.54319304e-01f, -3.60826552e-01f, 7.89191365e-01f, -3.07881147e-01f, -9.12425458e-01f, 7.78206110e-01f, 1.69859529e-01f, -7.77873933e-01f, 6.51048005e-01f,
  -4.80773121e-01f, -9.41269338e-01f, -1.18818223e+00f, 1.37504995e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  3.01235504e-02f, -1.95290819e-01f, 5.22431374e-01f, -2.74258524e-01f, 2.33048618e-01f, 4.37112600e-01f, 6.93946123e-01f, 7.87389129e-02f, -2.94526994e-01f, -1.52428195e-01f,
  -3.91824543e-01f, -7.01014519e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    