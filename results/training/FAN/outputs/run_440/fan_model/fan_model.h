/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.70248699e-01f, 3.19796890e-01f, 2.63339847e-01f, -7.69135579e-02f, -2.18095213e-01f, -3.01400095e-01f, -3.63523930e-01f, 2.51866668e-01f, 1.71086267e-01f, 8.57170820e-02f,
  -2.76031554e-01f, 2.71045249e-02f, -4.61377650e-02f, -1.80436462e-01f, -4.48961437e-01f, 5.69866151e-02f, -2.05618143e-01f, -1.36814147e-01f, 1.51502863e-01f, -3.06426156e-02f,
  4.31322381e-02f, -2.44388938e-01f, -1.23233259e-01f, 2.82206744e-01f, -2.82502592e-01f, 2.97456414e-01f, -1.48208961e-01f, 1.29629076e-01f, -5.05538005e-03f, -5.02714813e-02f,
  -1.66845366e-01f, 1.54811189e-01f, 1.73441730e-02f, 1.12520717e-01f, -1.12899831e-02f, -1.44800097e-01f, 1.76664237e-02f, 6.08261209e-03f, -4.00966443e-02f, 6.07330799e-02f,
  -1.28070703e-02f, 4.65133414e-02f, 5.05926982e-02f, 2.58750119e-03f, -5.11764288e-02f, 5.08935079e-02f, -5.12513146e-02f, -9.45493504e-02f, 7.24507645e-02f, -8.56101140e-02f,
  -3.83267216e-02f, -3.61991674e-02f, -8.63416120e-02f, 4.49093096e-02f, 1.92615222e-02f, 3.96016948e-02f, 4.92130686e-03f, -6.29984885e-02f, -5.53233437e-02f, -4.22985759e-03f,
  -1.38134938e-02f, -5.69036417e-02f, -3.86436544e-02f, -2.54818127e-02f, -1.82778519e-02f, 2.46547274e-02f, -3.07286084e-02f, -5.38451001e-02f, 3.27870212e-02f, -7.92788863e-02f,
  -3.60788009e-03f, -4.50328104e-02f, 5.78104635e-04f, -3.87462750e-02f, -1.08452521e-01f, -1.23616764e-02f, -5.36851436e-02f, 7.81046376e-02f, -2.91302744e-02f, -8.38249773e-02f,
  3.32923494e-02f, -8.64735618e-02f, 2.96869548e-03f, -7.49973059e-02f, -2.90588439e-02f, -3.72252278e-02f, 5.59000969e-02f, 5.17649651e-02f, 2.73086913e-02f, -9.85655412e-02f,
  7.47901723e-02f, 2.09970459e-01f, 1.17189355e-01f, 4.92534824e-02f, 6.31558448e-02f, 4.41914052e-02f, 8.18027183e-03f, 1.78495524e-04f, 8.45809281e-02f, -3.09262518e-02f,
  -3.41650508e-02f, -6.15851395e-02f, -4.54788804e-02f, -6.56178296e-02f, 5.23255616e-02f, -3.89007479e-02f, -1.31283822e-02f, 9.46612060e-02f, -5.79861216e-02f, 2.42266953e-02f,
  -5.03443778e-02f, -6.41425923e-02f, 6.02945779e-03f, -8.39556456e-02f, -1.14517435e-02f, -5.57556264e-02f, 2.82574985e-02f, 8.61777812e-02f, -3.98929864e-02f, 7.34082982e-02f,
  3.14375103e-01f, 5.88115633e-01f, 1.55303523e-01f, 6.57455102e-02f, -1.72076255e-01f, 4.44045216e-02f, -7.47677684e-02f, 2.18416661e-01f, 2.12597832e-01f, 1.56615272e-01f,
  -2.18657166e-01f, 3.05254400e-01f, -1.64624318e-01f, 1.69927835e-01f, -3.02011192e-01f, -1.32304236e-01f, 1.34602889e-01f, 1.89845458e-01f, 6.73682764e-02f, 3.03923279e-01f,
  -9.62847695e-02f, 7.88065121e-02f, -3.65420252e-01f, 2.04747230e-01f, 2.04063226e-02f, 1.65843368e-01f, -1.26702026e-01f, 3.62759568e-02f, 9.64503959e-02f, -1.25052586e-01f,
  4.68775108e-02f, 1.21112347e-01f, -4.03955542e-02f, -1.57991163e-02f, -1.18457876e-01f, -1.55803844e-01f, 8.37912038e-03f, -5.10147177e-02f, -1.28338233e-01f, 5.71677648e-02f,
  3.11478600e-02f, 1.96155310e-02f, 3.78181674e-02f, 7.70631107e-03f, 1.25658596e-02f, 4.42671627e-02f, -4.25540656e-02f, -5.35632111e-03f, 5.32787591e-02f, -1.49662882e-01f,
  -8.20356086e-02f, -4.60310765e-02f, -2.02826470e-01f, 8.63266084e-03f, -1.04172952e-01f, -1.45881642e-02f, -4.67839390e-02f, -7.63509572e-02f, -7.18305781e-02f, 1.92025583e-02f,
  -6.30051494e-02f, 7.28714466e-03f, -3.65870632e-02f, 3.68631110e-02f, 3.62307206e-02f, -1.21124372e-01f, 5.78533709e-02f, -1.26910552e-01f, -3.64976609e-03f, -5.20684831e-02f,
  7.22926408e-02f, 8.32793862e-02f, -7.26181734e-03f, 2.05646642e-02f, 1.90404290e-03f, 3.90432104e-02f, -2.09374707e-02f, 1.06223695e-01f, 3.19000543e-03f, -6.41255314e-03f,
  5.64242564e-02f, 2.63427501e-03f, 1.15774032e-02f, -1.06273450e-01f, -1.39481807e-02f, 4.93956879e-02f, 8.97541270e-02f, -1.32267224e-02f, -2.33414136e-02f, -5.84866330e-02f,
  2.79345244e-01f, 6.00421846e-01f, -8.02698582e-02f, -3.84185538e-02f, 4.65945937e-02f, -3.52159217e-02f, 4.77768704e-02f, 1.05750645e-02f, 7.85039067e-02f, -3.51964757e-02f,
  -1.18297860e-02f, -1.09855138e-01f, -5.03582992e-02f, 4.96449322e-03f, 5.90684228e-02f, 1.54994195e-02f, -7.62182893e-03f, 1.38185427e-01f, 5.85979857e-02f, 6.91349804e-02f,
  -1.92595962e-02f, 6.24548532e-02f, -1.95970591e-02f, -9.97614935e-02f, -1.38305083e-01f, -3.91446240e-02f, 1.23211317e-01f, 3.05328090e-02f, 5.38276061e-02f, 2.96208616e-02f,
  -5.00626147e-01f, 2.62052208e-01f, -9.73414853e-02f, -3.26527581e-02f, 1.79896116e-01f, 8.65413025e-02f, 1.01815611e-01f, -5.30182868e-02f, 3.60911667e-01f, -1.43797576e-01f,
  -1.86220884e-01f, -1.95401162e-01f, -1.53755590e-01f, 2.06455767e-01f, -4.08603966e-01f, 1.92322955e-01f, 2.09628101e-02f, -1.49011333e-02f, 4.34766054e-01f, -1.62862703e-01f,
  7.19833747e-03f, 2.02609058e-02f, -2.49127537e-01f, 1.59178481e-01f, -1.46112740e-01f, -6.35819212e-02f, -2.78894842e-01f, 9.94832367e-02f, -2.31563076e-01f, 2.03364670e-01f,
  4.06143069e-02f, -1.44282445e-01f, -1.67764246e-01f, -1.43109545e-01f, -1.35436788e-01f, -1.29262537e-01f, 3.11607718e-02f, 8.28570127e-03f, 1.31554985e-02f, 1.07118310e-02f,
  -9.44067352e-03f, -3.77445072e-02f, 6.69624209e-02f, 5.84089644e-02f, -2.55428459e-02f, -1.03667989e-01f, 2.99335998e-02f, 7.07898438e-02f, 4.35835272e-02f, 4.22043689e-02f,
  -1.58138067e-01f, -2.75491979e-02f, -1.15176946e-01f, -6.66785240e-02f, -1.81321248e-01f, 1.29096940e-01f, 7.73264170e-02f, -2.26857677e-01f, -2.96404716e-02f, 2.12010220e-02f,
  1.99295599e-02f, 7.15604692e-04f, -7.93094561e-02f, 1.19898140e-01f, -3.10156289e-02f, -7.56999552e-02f, -5.43225892e-02f, -1.20843999e-01f, 3.79120968e-02f, 4.64234278e-02f,
  2.50877254e-02f, 1.06412973e-02f, 2.72048600e-02f, -9.31266472e-02f, 4.90873791e-02f, 7.01108500e-02f, 2.97328029e-02f, -2.29643211e-02f, -4.22175378e-02f, 3.25750001e-02f,
  8.86912495e-02f, -2.72636656e-02f, -2.07918406e-01f, 2.16657054e-02f, -5.65045699e-03f, -8.70894417e-02f, -2.65846215e-02f, 6.47616982e-02f, -3.57559584e-02f, 3.93612571e-02f,
  -1.24634445e-01f, -6.00822121e-02f, 5.96475452e-02f, -6.53278306e-02f, 1.41883537e-01f, 5.40856346e-02f, 1.83989868e-01f, 6.76979050e-02f, -6.80086240e-02f, 9.78391692e-02f,
  -5.21901101e-02f, -3.80888693e-02f, -1.77538872e-01f, 8.83553252e-02f, -1.00532927e-01f, -1.09084016e-02f, 2.51693316e-02f, -6.16087541e-02f, -8.80368724e-02f, -1.35056498e-02f,
  -8.58405232e-02f, -7.45091960e-02f, 1.70735896e-01f, -3.95501480e-02f, 1.46464226e-04f, -9.65658724e-02f, -2.61042058e-01f, -5.46462201e-02f, 1.31787986e-01f, -5.43563068e-03f,
  -7.18894720e-01f, 1.71555281e-01f, 1.81651831e-01f, -4.60400224e-01f, -3.26287478e-01f, -2.64044613e-01f, -1.56211853e-01f, -1.81973889e-01f, 2.18481794e-02f, 1.35618359e-01f,
  -3.02363634e-01f, 9.00836587e-02f, 1.65806249e-01f, -3.10306847e-01f, -4.99952674e-01f, 2.95089096e-01f, -3.71231854e-01f, -2.90049997e-04f, -2.29630247e-02f, -1.70375779e-01f,
  -8.91271457e-02f, -3.34491223e-01f, -8.16888362e-02f, -3.43686417e-02f, -2.33430013e-01f, 2.11126462e-01f, 4.43508551e-02f, 2.38825843e-01f, -1.90237537e-01f, -3.79169062e-02f,
  -1.06925055e-01f, -9.60432291e-02f, -4.14179079e-03f, 4.96506318e-02f, -9.25627872e-02f, 3.21909823e-02f, -1.40135819e-02f, 3.63273323e-02f, -4.64202352e-02f, -6.46561161e-02f,
  2.71368381e-02f, -1.37389794e-01f, -2.51168068e-02f, 4.28398065e-02f, -1.54180691e-01f, -3.04882117e-02f, -5.61826304e-02f, -1.37245506e-01f, -1.49312280e-02f, -1.81100667e-02f,
  -1.59444590e-03f, -1.34780901e-02f, -9.55101401e-02f, 3.07286484e-03f, 3.71607989e-02f, -3.35869230e-02f, 3.20505686e-02f, 9.36019793e-02f, -2.78433934e-02f, -4.63149622e-02f,
  -1.10964207e-02f, -4.91957143e-02f, 1.34069426e-02f, -9.39780176e-02f, -8.73056501e-02f, 1.30703149e-03f, -4.99554090e-02f, -6.09373562e-02f, 1.16519108e-01f, -7.66349584e-02f,
  -5.23020551e-02f, -4.84067667e-03f, -7.98075944e-02f, -3.39456019e-03f, -5.16282655e-02f, 4.12097113e-04f, -7.06020044e-03f, 9.47933644e-03f, 1.23809511e-02f, -1.21880826e-02f,
  -4.72916886e-02f, -2.25853529e-02f, 1.14530362e-02f, -1.36626035e-03f, -9.77955982e-02f, 3.42268683e-02f, -5.17604426e-02f, -3.05658579e-02f, -3.92707661e-02f, -2.02543717e-02f,
  2.91977189e-02f, 1.63662598e-01f, 6.46132603e-02f, -2.01292280e-02f, 1.28068388e-01f, 6.76168501e-02f, 4.77745943e-03f, -6.45350944e-03f, 7.65323639e-02f, -3.71973366e-02f,
  -2.80747265e-02f, 6.53154999e-02f, 8.45088288e-02f, -8.11757818e-02f, 2.41103359e-02f, 5.33679761e-02f, 6.11752607e-02f, 7.61887729e-02f, -6.76624402e-02f, -5.92407510e-02f,
  -5.91230094e-02f, 1.92972105e-02f, 3.07408068e-02f, -6.19668094e-03f, -5.43079823e-02f, -8.95144418e-03f, -4.37399112e-02f, 4.28485759e-02f, 9.37670190e-03f, 6.40603974e-02f,
  -3.47552598e-01f, 1.01150665e-03f, -2.39451423e-01f, -5.61521590e-01f, -1.60847642e-02f, 4.68872696e-01f, 4.28236753e-01f, -2.43067846e-01f, -2.21459687e-01f, 2.12597772e-01f,
  1.70068070e-01f, -2.69295275e-01f, 4.86708432e-01f, -1.54912814e-01f, 7.54259452e-02f, 3.56609523e-01f, -1.65435031e-01f, 4.80537601e-02f, -5.25330827e-02f, -1.27331108e-01f,
  -2.01028332e-01f, 5.50329462e-02f, -1.29886232e-02f, 9.28551052e-03f, -1.74132109e-01f, -2.54794896e-01f, -1.00118011e-01f, 5.75641282e-02f, -1.25811026e-01f, 6.71310872e-02f,
  3.84301320e-02f, 7.68856630e-02f, -1.79064333e-01f, -7.08006620e-02f, -1.37052620e-02f, 9.30417981e-03f, -9.81811732e-02f, 7.42679313e-02f, -8.59310925e-02f, -1.68714416e-03f,
  8.94657150e-02f, -7.53742456e-02f, -8.71338174e-02f, -2.41670366e-02f, -1.22756183e-01f, -1.39157409e-02f, -5.06395288e-02f, -1.61015820e-02f, -9.19789076e-02f, 4.22193250e-03f,
  3.92834768e-02f, -6.70598969e-02f, -7.38626644e-02f, -4.69514616e-02f, -1.65856034e-02f, -6.39096573e-02f, -4.31661271e-02f, -1.57368723e-02f, -2.54884437e-02f, -1.01409473e-01f,
  7.66831338e-02f, -1.16882287e-02f, 4.55937423e-02f, -1.89548787e-02f, 5.41851036e-02f, -6.02485649e-02f, 5.29849082e-02f, 2.89166309e-02f, -3.43956277e-02f, 6.21559359e-02f,
  1.11629684e-02f, -9.15746912e-02f, 4.22960259e-02f, -5.20967804e-02f, 2.32601520e-02f, -5.91237738e-04f, 3.24905105e-02f, 3.47885229e-02f, -1.09739400e-01f, -1.18780218e-01f,
  4.36821841e-02f, -3.72492298e-02f, -2.33974028e-02f, -1.19489869e-02f, 1.25494629e-01f, 7.31584337e-03f, -1.50472492e-01f, -5.68772666e-02f, -1.92668359e-03f, 1.08220011e-01f,
  1.68177441e-01f, 5.96260466e-02f, 9.98741388e-02f, 1.07388245e-03f, 8.70956331e-02f, -1.09593896e-03f, 2.43332461e-02f, -9.33571830e-02f, 7.63472021e-02f, -1.33927409e-02f,
  -4.83219326e-03f, -1.79820508e-02f, 2.76215728e-02f, 2.50672903e-02f, -2.05803514e-02f, 3.44807021e-02f, 3.00576352e-02f, -1.01723894e-01f, -3.50834541e-02f, -7.24440143e-02f,
  -4.30070050e-02f, 1.08736567e-01f, 3.09488866e-02f, 5.18669337e-02f, -3.65495831e-02f, 1.42179459e-01f, -9.39259026e-03f, 4.03204672e-02f, 1.08026072e-01f, 1.16345780e-02f,
  1.71803564e-01f, -1.35417983e-01f, 2.97648698e-01f, -4.80601266e-02f, 3.04047048e-01f, 3.38948160e-01f, 5.16919307e-02f, 6.01385757e-02f, -2.37722948e-01f, -1.85880035e-01f,
  -6.77297115e-02f, 1.15152128e-01f, -1.50711000e-01f, -1.02756068e-01f, -3.59194815e-01f, -2.61164993e-01f, -2.27059528e-01f, -8.61819834e-02f, -2.40465142e-02f, -2.48037446e-02f,
  1.85336739e-01f, -1.68184519e-01f, 2.31469065e-01f, -5.14081772e-03f, 3.79062086e-01f, 1.58253938e-01f, -3.06483477e-01f, 1.15758695e-01f, 1.28294714e-02f, -1.18509725e-01f,
  5.95680177e-02f, 9.47636813e-02f, 1.57518268e-01f, -1.03292121e-02f, 2.35645752e-03f, 9.24322680e-02f, 9.84473974e-02f, -3.00458670e-02f, 8.32244158e-02f, 1.64739750e-02f,
  3.09789944e-02f, 9.44441035e-02f, -9.14581046e-02f, -6.54381365e-02f, 8.45844969e-02f, 6.31303042e-02f, 1.98291287e-01f, 8.89209956e-02f, 9.93420184e-02f, 1.80913046e-01f,
  2.07053781e-01f, 1.23373330e-01f, 6.41739666e-02f, -5.24537172e-03f, 1.82418838e-01f, 4.78455722e-02f, 1.46972314e-01f, 1.51321888e-01f, -4.32561636e-02f, 1.40826628e-01f,
  -8.59670937e-02f, 1.90021135e-02f, -5.19180410e-02f, -3.60663272e-02f, -5.01965694e-02f, 5.09695448e-02f, -7.57951885e-02f, 2.48697195e-02f, -8.94657522e-03f, -1.77467614e-02f,
  7.51660764e-02f, -1.95203125e-02f, -5.25396280e-02f, 5.18595055e-02f, 6.95413575e-02f, -1.03480667e-02f, 7.15845590e-03f, -4.84030955e-02f, 3.67432795e-02f, 9.98743344e-03f,
  -1.36713415e-01f, -6.79308176e-03f, 5.11641428e-03f, -3.18296216e-02f, -8.79871026e-02f, 3.39228697e-02f, 6.51780590e-02f, 2.32877769e-02f, -5.96203655e-02f, 2.89048604e-03f,
  -1.97533920e-01f, -4.19123977e-01f, -8.39994382e-03f, 3.59729938e-02f, -1.48781091e-01f, 2.00364552e-03f, -1.51526898e-01f, -2.90399957e-02f, -4.44321148e-02f, -1.54500559e-01f,
  8.05875584e-02f, -2.98830494e-02f, -5.22805862e-02f, 4.52425666e-02f, -4.32719253e-02f, 9.97480191e-03f, -1.08476356e-01f, -1.22063585e-01f, -5.39681502e-02f, -1.84038151e-02f,
  -7.26888031e-02f, 6.93928599e-02f, 8.97180513e-02f, 1.36874944e-01f, 7.09619671e-02f, 7.16421008e-02f, -7.24460036e-02f, -4.28822115e-02f, 1.57944318e-02f, -1.25155831e-02f,
  -7.45490044e-02f, 6.21942699e-01f, 2.36126497e-01f, 1.73808277e-01f, -1.77040920e-01f, 2.07090601e-01f, 1.68238282e-01f, 1.71586543e-01f, 3.22306603e-01f, 1.59043401e-01f,
  1.58380643e-01f, -1.29336029e-01f, 2.30097204e-01f, 2.99393028e-01f, -3.37300599e-01f, 3.39114279e-01f, 1.57265276e-01f, 1.47554770e-01f, 2.94404626e-01f, -8.63107666e-02f,
  1.65988967e-01f, 9.05246511e-02f, 1.79920867e-01f, 1.24799117e-01f, 1.67157993e-01f, -7.25411773e-02f, -4.69814092e-01f, -5.34519814e-02f, -4.22014296e-01f, -3.94471288e-02f,
  1.16062410e-01f, 2.92036206e-01f, 1.21489421e-01f, 5.26667535e-02f, 8.17718953e-02f, -1.45802245e-01f, -1.46285951e-01f, -1.78861439e-01f, 1.32841822e-02f, 1.39176905e-01f,
  -8.42325687e-02f, -3.99942212e-02f, 9.98868197e-02f, -1.13618128e-01f, 3.70294787e-02f, -3.23516801e-02f, -6.28203675e-02f, 1.90523714e-02f, -1.93869583e-02f, 1.74199566e-02f,
  6.62189797e-02f, 5.77875003e-02f, -2.84695551e-02f, -8.70428905e-02f, -7.27831274e-02f, 1.58697292e-01f, 5.19100614e-02f, -1.62294209e-01f, -1.42529279e-01f, -4.55114245e-02f,
  -4.14270209e-03f, 5.10663651e-02f, 3.87044661e-02f, 3.20509002e-02f, -8.91259871e-03f, -4.90725301e-02f, -3.31705101e-02f, -7.76348589e-03f, -1.01713995e-02f, 5.09332691e-04f,
  -5.77841997e-02f, 3.56567651e-02f, -3.47447023e-02f, 2.58246884e-02f, 2.23636143e-02f, -6.80599269e-03f, -1.28807083e-01f, 4.90555614e-02f, -1.21500500e-01f, 6.06125128e-03f,
  -2.66480073e-03f, -6.68913051e-02f, 9.78795514e-02f, -1.61563084e-01f, 6.82850778e-02f, -6.50425395e-03f, -6.81997016e-02f, 9.30927694e-02f, -2.06902865e-02f, -1.35937825e-01f,
  2.18430497e-02f, -3.16294841e-02f, 4.27262299e-02f, -7.80731216e-02f, -2.96541918e-02f, -4.59682830e-02f, 9.40107182e-02f, 3.52952629e-02f, -9.24509913e-02f, -7.04167271e-03f,
  -4.09486294e-02f, 1.05629236e-01f, -1.18118718e-01f, -8.96531716e-02f, -1.12689458e-01f, -1.46215856e-02f, 1.21785682e-02f, -8.64639357e-02f, -2.14096949e-01f, -4.81721237e-02f,
  -6.24773242e-02f, 7.67576683e-04f, -8.53381585e-03f, 3.80116329e-02f, -5.40008470e-02f, -7.20364079e-02f, -6.33625761e-02f, 1.52909368e-01f, -1.41597673e-01f, -7.22153159e-03f,
  -1.98559746e-01f, 1.56618759e-01f, 1.32614195e-01f, 3.14806402e-01f, -3.17938596e-01f, -5.53706884e-01f, -2.57526904e-01f, 1.72829702e-01f, 8.29617754e-02f, -1.35597929e-01f,
  -2.37312257e-01f, 1.19384609e-01f, -2.27367759e-01f, 1.89300433e-01f, -2.36748621e-01f, 6.03205301e-02f, -1.79625265e-02f, 3.41685675e-02f, 2.09145457e-01f, 5.74733056e-02f,
  1.37923673e-01f, -1.53952107e-01f, 1.67414069e-01f, 1.81774367e-02f, -1.38057500e-01f, 2.55261660e-01f, -8.73938128e-02f, 5.10930493e-02f, -9.68959183e-02f, -1.13811009e-01f,
  -5.12534864e-02f, 2.33243510e-01f, 7.61944652e-02f, -1.00573851e-03f, -1.46171212e-01f, -6.00562505e-02f, -7.53297731e-02f, -1.87145025e-02f, 3.37686725e-02f, 4.14969586e-02f,
  -9.05641764e-02f, 4.67562079e-02f, 3.37516591e-02f, 5.43193333e-03f, -3.96252610e-02f, 3.54661010e-02f, 8.41660276e-02f, -1.41847339e-02f, 8.25408772e-02f, 3.46653014e-02f,
  3.23023461e-02f, 5.95429428e-02f, 3.72297131e-02f, 6.33357242e-02f, -8.27580877e-03f, 4.60384153e-02f, 2.90336348e-02f, -8.95408913e-02f, -1.86694749e-02f, -5.18242493e-02f,
  1.01273932e-01f, -3.09248324e-02f, -4.27003484e-03f, -9.58640128e-03f, 5.31438068e-02f, -7.90148377e-02f, -3.97299081e-02f, 1.72055699e-02f, -1.35664912e-02f, -3.42189856e-02f,
  -1.57753095e-01f, 3.10758352e-02f, 6.11869730e-02f, 2.62273122e-02f, 2.17197351e-02f, -1.91415442e-04f, -5.18992804e-02f, 8.32593068e-03f, 3.11374734e-03f, -4.77271192e-02f,
  8.18852633e-02f, 1.84009352e-03f, 9.00836289e-03f, -8.28258768e-02f, -5.21354638e-02f, 3.73886004e-02f, 7.04892129e-02f, 1.74988881e-02f, 1.06235102e-01f, -1.54029965e-01f,
  -4.08856928e-01f, -8.48934054e-02f, -8.35322589e-03f, -1.01746000e-01f, 9.15336981e-03f, -1.30271269e-02f, 8.93061515e-03f, -2.90282140e-03f, -8.22878908e-03f, -3.73489633e-02f,
  6.18457422e-02f, -7.63695911e-02f, -7.87070245e-02f, -1.03890877e-02f, 8.74778070e-03f, -6.22085743e-02f, -3.07622068e-02f, -4.49935235e-02f, -1.35207549e-01f, -7.20414817e-02f,
  -5.88761792e-02f, -1.02726668e-01f, 5.30264974e-02f, -4.63990420e-02f, -6.07177764e-02f, -1.15711398e-01f, -6.46631867e-02f, 1.30089879e-01f, -1.89398061e-02f, 7.57696554e-02f,
  1.18065849e-01f, 1.57522671e-02f, -1.74472705e-01f, -6.23526275e-01f, 2.54477739e-01f, 1.14678964e-02f, -5.06151795e-01f, 7.16619641e-02f, -3.67634781e-02f, -1.34194970e-01f,
  -1.67756304e-01f, 1.94455516e-02f, -9.57615897e-02f, -3.62324446e-01f, -1.29490003e-01f, -1.03494197e-01f, -4.79480654e-01f, -1.69679940e-01f, 1.85681224e-01f, -1.16967827e-01f,
  1.53611298e-03f, -1.16869815e-01f, -2.30378762e-01f, 3.63328397e-01f, -1.24826640e-01f, 3.63572761e-02f, -1.15715772e-01f, 1.48299813e-01f, -2.15837032e-01f, 1.14688262e-01f,
  -6.70826435e-02f, 9.92428511e-02f, -1.09571628e-01f, -1.58008058e-02f, -4.81700636e-02f, -6.06991462e-02f, -8.31610709e-02f, 2.50148550e-02f, 7.98751600e-03f, 3.90096866e-02f,
  2.99563631e-02f, 1.10706687e-01f, 1.16133504e-02f, 4.76323776e-02f, 1.46855950e-01f, 3.02025204e-04f, 1.66886806e-01f, -8.73939693e-02f, 1.33325472e-01f, 2.61959322e-02f,
  -2.50942260e-02f, -2.98911408e-02f, -1.92822292e-02f, 6.28029704e-02f, 5.71201406e-02f, -1.86061449e-02f, -1.11496180e-01f, -1.17181810e-02f, 9.40403119e-02f, 1.10044666e-01f,
  1.08056664e-01f, -6.96376786e-02f, 4.38654013e-02f, 9.90101695e-02f, 2.20350921e-03f, 2.80037522e-02f, 7.45960698e-02f, 3.70485745e-02f, 5.15668653e-02f, 2.20433176e-02f,
  2.79697608e-02f, 3.13293226e-02f, 3.26252356e-02f, -1.62271068e-01f, -9.64385644e-02f, -7.31021399e-03f, -4.97928355e-03f, 1.56491995e-02f, -5.67773692e-02f, 3.17247659e-02f,
  -1.08435433e-02f, -2.79280059e-02f, -1.03015602e-02f, 3.46176960e-02f, 3.35813197e-03f, -5.04901186e-02f, 3.49351205e-02f, 1.05438530e-02f, 1.47750061e-02f, -3.72937284e-02f,
  -4.97916900e-02f, -5.02375253e-02f, -3.06660663e-02f, 5.25214933e-02f, -9.00089964e-02f, 1.10735729e-01f, -1.19998001e-01f, 9.36408564e-02f, 8.77118707e-02f, 1.59280859e-02f,
  -6.70116395e-02f, -1.27195850e-01f, -2.67459843e-02f, 3.07928789e-02f, -5.00305742e-02f, 5.04489876e-02f, -1.35440409e-01f, -1.19064569e-01f, -1.17660396e-01f, 8.43544155e-02f,
  -1.08048562e-02f, 1.31750986e-01f, -9.21277031e-02f, 3.69795486e-02f, -8.63774586e-03f, -3.46204871e-03f, 1.52420908e-01f, -6.54152036e-03f, -2.86072399e-02f, -1.00384288e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.31370467e-01f, -5.33388913e-01f, 1.07768320e-01f, -6.92175210e-01f, 1.03669912e-01f, 3.43040049e-01f, -4.58899979e-03f, -3.03313166e-01f, -1.84219673e-01f, -6.42725885e-01f,
  -5.37307620e-01f, -1.44327164e-01f, 2.71337867e-01f, -4.66179848e-01f, 1.02011120e+00f, 4.20645237e-01f, -3.20706248e-01f, -6.48941159e-01f, 1.58118740e-01f, -5.04600942e-01f,
  -3.84554006e-02f, -5.34416080e-01f, 1.46255508e-01f, -5.16623616e-01f, -2.79406607e-01f, -4.43968743e-01f, -3.12418222e-01f, -8.75352770e-02f, -5.79650283e-01f, -6.72766492e-02f,
  -7.58299138e-03f, -4.58183512e-02f, 6.27353638e-02f, 7.64774159e-02f, 1.77515641e-01f, 6.49513677e-02f, -8.58983397e-02f, 5.27420864e-02f, 9.43425596e-02f, -2.88279634e-02f,
  1.43934954e-02f, 5.58265112e-02f, -1.95699051e-01f, 1.98222637e-01f, -1.27188146e-01f, -4.81183529e-02f, 5.60723916e-02f, 9.88887995e-03f, -7.11973011e-02f, 2.46080562e-01f,
  6.80384189e-02f, 6.60980195e-02f, -9.22210142e-02f, -1.68999389e-01f, -1.15049087e-01f, -1.39025420e-01f, 9.59415063e-02f, 1.10179365e-01f, -2.68220063e-02f, 2.78371647e-02f,
  -5.01029193e-02f, 1.97635502e-01f, 1.71599612e-01f, -6.64819703e-02f, 1.01082198e-01f, -1.00259006e-01f, -8.47949684e-02f, -3.95177864e-03f, 6.97532743e-02f, -5.33992006e-03f,
  -8.10923427e-02f, -2.18416616e-01f, 2.53038835e-02f, 5.79299852e-02f, 3.58919241e-02f, 1.69552546e-02f, 3.79420519e-02f, -9.84851047e-02f, 5.27632497e-02f, 1.37719274e-01f,
  -1.24000549e-01f, 1.19291639e-04f, -2.28581540e-02f, -1.91001847e-01f, 7.26246387e-02f, 9.92571469e-03f, -4.99692746e-02f, -3.83271948e-02f, 1.91562548e-01f, -1.66692808e-01f,
  -4.29465435e-02f, -2.43925169e-01f, -1.06654085e-01f, -1.66696891e-01f, -7.72749558e-02f, 1.56695083e-01f, 1.94670092e-02f, -2.62587160e-01f, -2.17201516e-01f, -2.83775851e-02f,
  -2.40529746e-01f, -2.73323566e-01f, -3.02513763e-02f, -7.44648650e-02f, -1.53886229e-01f, -5.23822755e-02f, -2.90620893e-01f, -9.82184336e-02f, -7.28031993e-02f, -9.74614769e-02f,
  -1.62465945e-01f, -1.41341910e-01f, -7.67024234e-04f, -1.94411159e-01f, -3.23787034e-01f, 1.40109090e-02f, 1.20421641e-01f, -9.84776691e-02f, -3.68566290e-02f, -1.65735502e-02f,
  4.24023718e-01f, 5.86293697e-01f, 9.67548117e-02f, 2.11360484e-01f, -7.58208156e-01f, -6.94087073e-02f, -3.27603966e-01f, -1.82808146e-01f, 4.75006193e-01f, 4.00561601e-01f,
  -6.47105992e-01f, 7.08067775e-01f, -2.89592564e-01f, -1.15282938e-01f, 1.38981253e-01f, 3.95980924e-01f, 1.48152992e-01f, 2.87883252e-01f, 2.06851169e-01f, -1.40397578e-01f,
  1.88176498e-01f, -4.32832301e-01f, -3.73194367e-01f, -4.48906600e-01f, -5.87476611e-01f, 2.99651101e-02f, -4.82439160e-01f, -4.11394238e-01f, -7.70459399e-02f, -1.74935564e-01f,
  -1.20022058e-01f, 3.91234607e-02f, -6.50871992e-02f, 2.22405061e-01f, -7.82934055e-02f, -8.15835297e-02f, -5.96723075e-05f, -9.67408046e-02f, -3.77581790e-02f, 1.04226604e-01f,
  2.33653635e-01f, 1.57542139e-01f, 1.72863036e-01f, -8.18111002e-02f, 1.31429555e-02f, 1.59457982e-01f, 1.94760151e-02f, 4.50151488e-02f, 1.20932803e-01f, -5.92441931e-02f,
  5.52301016e-03f, 1.56199902e-01f, -9.75147411e-02f, 3.22212458e-01f, 3.62759940e-02f, 1.19633395e-02f, 2.18772754e-01f, -3.29121277e-02f, 1.41143158e-01f, 2.22428530e-01f,
  3.01450454e-02f, 6.14944547e-02f, -8.72818679e-02f, -1.26061007e-01f, -1.04522631e-01f, -1.44537553e-01f, 2.32006144e-02f, -5.47795594e-02f, 1.46822706e-01f, -2.90374178e-03f,
  8.44427943e-02f, -3.96597534e-02f, -1.83206648e-01f, 9.35811698e-02f, -2.39499030e-03f, 1.64126962e-01f, -6.11001300e-03f, -1.87182135e-03f, 6.91721812e-02f, -3.57479081e-02f,
  -1.19815521e-01f, -2.92368289e-02f, -1.13253482e-01f, -1.27886608e-01f, -1.06613263e-01f, -1.30655915e-01f, 5.69756795e-03f, 4.40590782e-03f, -4.54776473e-02f, -1.39455482e-01f,
  9.91630480e-02f, 3.56510133e-01f, 1.83231577e-01f, 1.68331727e-01f, 5.81449457e-02f, -6.24727495e-02f, 9.30195898e-02f, 1.42427772e-01f, 1.67971268e-01f, 2.48967241e-02f,
  8.74596164e-02f, 1.70914829e-01f, -1.24291191e-02f, -1.82909504e-01f, 6.13627136e-02f, 4.64921817e-02f, 1.09276377e-01f, 1.76904008e-01f, 2.93251593e-02f, -6.37242272e-02f,
  -2.38319878e-02f, 1.39427006e-01f, 2.59671897e-01f, 1.15016796e-01f, 1.62906140e-01f, 9.35592726e-02f, 8.24545026e-02f, 1.65923238e-01f, -1.42905295e-01f, 6.38439506e-02f,
  -1.49479330e+00f, 1.91634089e-01f, 5.24076283e-01f, 1.31398574e-01f, -2.74180830e-01f, -3.48828882e-01f, -1.11396872e-01f, -7.34954774e-02f, -3.86208683e-01f, 2.03801617e-01f,
  4.06323105e-01f, -4.83259499e-01f, 3.70417446e-01f, 6.88467860e-01f, 7.29502887e-02f, 4.20869410e-01f, 5.94896115e-02f, -4.45601232e-02f, 1.00398853e-01f, -1.00204431e-01f,
  9.81623679e-02f, 3.73810232e-01f, 5.42580485e-01f, 3.00258130e-01f, 4.20827717e-02f, -9.07935109e-03f, 1.11632928e-01f, 3.40168029e-01f, 3.12475443e-01f, 2.72765029e-02f,
  -6.55872345e-01f, -2.64918625e-01f, -3.11388969e-02f, -2.28962511e-01f, -1.97480053e-01f, -1.12041496e-01f, -1.03430308e-01f, 9.38586425e-03f, 3.30547504e-02f, -6.24766499e-02f,
  -1.72491476e-01f, 1.16153192e-02f, 3.18464711e-02f, 2.98203807e-02f, -3.03130478e-01f, 4.23993133e-02f, -5.50291836e-02f, 8.45335051e-02f, 7.07847103e-02f, 3.21793817e-02f,
  1.06675558e-01f, 1.34910628e-01f, 1.09429071e-02f, 2.47272715e-01f, 6.71770498e-02f, 9.26354993e-03f, 2.60367785e-02f, -4.19946276e-02f, -2.15266928e-01f, -1.26495948e-02f,
  -2.32572742e-02f, 1.31436318e-01f, -5.66340843e-03f, 2.99899634e-02f, 6.46162182e-02f, -3.78480926e-02f, 1.23736165e-01f, -8.91041309e-02f, 2.03762166e-02f, 1.75241940e-02f,
  -1.17376469e-01f, -1.69517055e-01f, -7.44102299e-02f, -9.85506028e-02f, -3.09213120e-02f, -9.12213640e-04f, 6.01719394e-02f, -1.55051112e-01f, 4.93454747e-02f, 5.00029437e-02f,
  3.60643002e-03f, -4.93095927e-02f, 1.95760839e-02f, 3.87472808e-02f, -3.90900075e-02f, 5.46927787e-02f, -4.48023640e-02f, -1.03020191e-01f, -3.59375030e-02f, -2.15429980e-02f,
  -1.06892586e+00f, -4.47830915e-01f, 1.76785309e-02f, -2.29908869e-01f, 6.59553185e-02f, -1.24425292e-01f, 5.94167821e-02f, -7.67495036e-02f, -2.41385713e-01f, -1.78333282e-01f,
  -1.64274484e-01f, -1.42788468e-02f, -1.06987275e-01f, 9.76301543e-03f, 2.60505110e-01f, 6.20693006e-02f, -1.04839869e-01f, -7.98128173e-02f, -1.18710287e-01f, -3.75327803e-02f,
  1.41791822e-02f, -3.74691747e-02f, 1.28963202e-01f, 1.47172794e-01f, 2.26906780e-02f, -1.78069100e-02f, -1.57105789e-01f, -5.58054410e-02f, 6.72521517e-02f, 1.86534122e-01f,
  7.49658406e-01f, -8.13284889e-02f, -1.85229272e-01f, 1.46747142e-01f, 3.37277621e-01f, 2.61980236e-01f, -3.67385089e-01f, 4.42780584e-01f, 4.74361740e-02f, -3.68599921e-01f,
  1.51853055e-01f, -2.33397827e-01f, -6.17190957e-01f, 4.91393805e-01f, 8.86526287e-01f, -3.28729212e-01f, 6.86095953e-01f, 1.95728645e-01f, 1.91509336e-01f, 5.47731876e-01f,
  4.69847828e-01f, 8.60542178e-01f, -2.46370491e-02f, 5.98150551e-01f, 5.97129405e-01f, 5.28255925e-02f, 1.88170165e-01f, -3.13398749e-01f, 1.64939329e-01f, 2.85084635e-01f,
  -7.99373165e-02f, 3.04777585e-02f, 8.64134729e-02f, -9.09820870e-02f, 2.86697783e-02f, -1.10394493e-01f, -2.01644987e-01f, -1.81059450e-01f, 1.56922713e-02f, -6.80005029e-02f,
  -2.23809615e-01f, 2.93040220e-02f, 1.26388803e-01f, 8.11694190e-03f, 1.19425490e-01f, 1.13520697e-01f, 7.50854388e-02f, -4.76343930e-02f, -1.19636483e-01f, 8.84997919e-02f,
  5.66046452e-03f, -1.68544084e-01f, 1.35393560e-01f, -9.57091078e-02f, -2.78958641e-02f, 8.17986280e-02f, -1.68938398e-01f, -1.88443929e-01f, -1.65903047e-02f, 1.25625119e-01f,
  1.92094937e-01f, -8.12672004e-02f, 5.30704074e-02f, -6.20912947e-02f, 3.77981476e-02f, -6.20369101e-03f, 1.87622253e-02f, -5.02205193e-02f, 1.39568806e-01f, 2.60759424e-03f,
  -4.36597429e-02f, 8.06639809e-03f, 1.36655897e-01f, 1.03537878e-02f, 7.18681812e-02f, -3.63167026e-03f, -8.17551836e-02f, 3.32935117e-02f, 5.28418832e-02f, -1.02561690e-01f,
  -2.88403593e-02f, 6.89669549e-02f, 5.56353899e-03f, -1.97925359e-01f, -5.23502752e-03f, -4.42712158e-02f, 3.21463384e-02f, -9.53024533e-03f, -2.03183532e-01f, 5.21539301e-02f,
  3.96491028e-02f, 4.33210224e-01f, -1.56834594e-03f, -8.52966383e-02f, -6.03649765e-02f, 2.55032390e-01f, 3.67788337e-02f, 2.86023855e-01f, 1.10780507e-01f, 7.32376724e-02f,
  2.76232455e-02f, -1.06614992e-01f, -1.22561157e-01f, 6.91330817e-04f, 3.07186320e-02f, 1.28631517e-01f, -5.81162162e-02f, -1.27499014e-01f, -1.03455549e-02f, 1.29204333e-01f,
  -6.80094808e-02f, 5.79613522e-02f, 1.51083264e-02f, 1.09589621e-01f, 6.43857792e-02f, -1.72510982e-01f, 8.60010013e-02f, -8.61782730e-02f, 4.24965695e-02f, 7.88276866e-02f,
  7.99736500e-01f, 1.14755400e-01f, 9.75210667e-01f, 5.02284586e-01f, -2.24966947e-02f, 6.11444056e-01f, 8.59234273e-01f, 2.02666409e-02f, 9.27152216e-01f, -5.05053401e-01f,
  -7.54911244e-01f, 5.42861521e-01f, -5.40382043e-02f, -2.27304161e-01f, 3.06611836e-01f, 6.16831407e-02f, 1.98235512e-01f, 2.68352211e-01f, 1.31909579e-01f, 1.46895617e-01f,
  -6.53622951e-03f, -8.41371298e-01f, -1.84649318e-01f, -7.04820573e-01f, -1.45680204e-01f, 1.16429940e-01f, -8.88207495e-01f, 3.33977342e-01f, -6.69477403e-01f, -1.04397340e-02f,
  -2.08282158e-01f, -3.50192562e-02f, -2.14361623e-01f, -3.62627245e-02f, -8.61825496e-02f, 2.90806174e-01f, 1.71925128e-01f, 1.39732823e-01f, 9.70035642e-02f, -2.83621550e-02f,
  1.02767944e-01f, -1.32436380e-01f, -2.59060375e-02f, 1.22613922e-01f, 1.54808670e-01f, -8.50652456e-02f, 7.14485766e-04f, -1.02318875e-01f, -9.73626748e-02f, 1.56366736e-01f,
  9.61730629e-02f, 1.13055877e-01f, 6.18817471e-02f, 2.40422450e-02f, 6.83171824e-02f, 7.94062391e-02f, 2.80326873e-01f, 1.41840488e-01f, 7.82630965e-03f, 9.23609436e-02f,
  -8.52916315e-02f, 1.94560677e-01f, -3.58682731e-03f, -1.47209018e-01f, -6.82561472e-02f, -1.52779981e-01f, -1.36507796e-02f, -1.51566207e-01f, 8.92228261e-02f, -2.12664947e-01f,
  -1.31203607e-01f, -3.89325083e-03f, 7.46718720e-02f, 2.78597847e-02f, -1.28375754e-01f, 5.36277741e-02f, 5.92656620e-02f, -8.25361609e-02f, 1.54021429e-02f, -7.96955228e-02f,
  -5.34006283e-02f, 1.68720946e-01f, -7.18664527e-02f, 6.06726632e-02f, 5.75573966e-02f, 1.20502174e-01f, -1.22301206e-01f, 1.60548493e-01f, -2.48956438e-02f, -4.42012437e-02f,
  -5.35925552e-02f, 9.69493389e-02f, -1.44314960e-01f, -3.21506709e-01f, 6.72775730e-02f, -1.75926700e-01f, 1.01998836e-01f, -1.64982870e-01f, 1.58621550e-01f, -6.98181316e-02f,
  -1.07968874e-01f, -9.82943475e-02f, 9.38118324e-02f, 3.44208218e-02f, -3.01672291e-04f, -5.89314103e-02f, 9.89940390e-02f, -9.74888057e-02f, 1.01352632e-01f, -1.37964115e-01f,
  2.28739269e-02f, 5.38309179e-02f, 1.83247239e-03f, -2.50923425e-01f, -1.73799738e-01f, -1.76864162e-01f, 6.48208931e-02f, -2.05076840e-02f, 1.65821314e-02f, 2.05395650e-02f,
  -9.13075864e-01f, 8.59674454e-01f, -1.64602622e-01f, 1.83723986e-01f, -4.83962335e-02f, 1.23822296e+00f, 6.70686722e-01f, 4.43934053e-01f, 5.73960006e-01f, 5.61206877e-01f,
  2.61902004e-01f, -3.24144274e-01f, 3.31645012e-01f, 7.61452019e-01f, 2.83533096e-01f, 9.25370872e-01f, 6.48322523e-01f, 4.47691619e-01f, 8.89338106e-02f, 1.06808715e-01f,
  2.65068710e-02f, 2.84096092e-01f, 3.60028036e-02f, -1.45469159e-01f, -9.45184231e-02f, -5.10249197e-01f, -4.39981222e-01f, -2.73127705e-01f, -1.11089528e-01f, 1.07145078e-01f,
  -1.85246199e-01f, -5.05371630e-01f, -4.07254308e-01f, -7.87441134e-02f, -1.11944117e-01f, -1.80071697e-01f, -4.46386151e-02f, -7.48015344e-02f, -2.08703846e-01f, 2.04313807e-02f,
  -1.59415707e-01f, -1.30199110e-02f, 7.50656649e-02f, -3.82049792e-02f, 9.49842483e-02f, 1.76349320e-02f, 1.00037798e-01f, 4.01231386e-02f, 2.02748716e-01f, 1.24651127e-01f,
  1.28849849e-01f, 9.73606929e-02f, 1.20307073e-01f, 1.76593527e-01f, -8.14131349e-02f, 5.72331203e-03f, 4.11458127e-02f, -1.96243711e-02f, 5.40700965e-02f, 1.29345521e-01f,
  -7.10594282e-02f, -7.29464218e-02f, 6.16121180e-02f, -2.28018865e-01f, 8.55012015e-02f, -9.28414240e-02f, 1.04222903e-02f, 3.95002775e-03f, -9.41019282e-02f, 9.94457752e-02f,
  6.93036094e-02f, -1.82119548e-01f, 1.25836274e-02f, 8.56878906e-02f, -1.57599192e-04f, 2.95354724e-02f, 6.92208530e-03f, -2.84486469e-02f, 1.03318840e-01f, 5.63302413e-02f,
  -8.49681348e-02f, 2.47898921e-01f, 1.51568968e-02f, -5.68781234e-02f, 1.60425957e-02f, -3.36805359e-02f, 7.54536763e-02f, 1.99478030e-01f, -9.14362222e-02f, -1.21853031e-01f,
  4.49185908e-01f, -9.30841044e-02f, -9.94729325e-02f, -1.02975532e-01f, -1.50671393e-01f, 9.76891145e-02f, -5.80883361e-02f, 3.19027938e-02f, 1.34981185e-01f, 3.90838422e-02f,
  -1.09443367e-01f, -2.90367678e-02f, -1.93747953e-02f, 4.84968238e-02f, -3.20195715e-04f, 2.27805451e-01f, -8.25504661e-02f, -8.30855221e-02f, -8.38835612e-02f, -1.47663340e-01f,
  -2.47452542e-01f, -1.15161866e-01f, -4.20388319e-02f, -5.81179792e-03f, -3.24939601e-02f, -3.42240296e-02f, 2.29437021e-03f, -8.73290002e-02f, -5.97862266e-02f, 6.01431020e-02f,
  -3.41740608e-01f, 8.50503802e-01f, -3.78496379e-01f, 5.10137677e-01f, -4.04371887e-01f, -2.78930485e-01f, 3.05283397e-01f, -3.54610234e-02f, -1.00530297e-01f, 7.63055623e-01f,
  4.34313625e-01f, 2.80840490e-02f, 3.78235042e-01f, 9.55306351e-01f, -8.65302444e-01f, 1.49783641e-01f, 7.14362264e-01f, 4.96275693e-01f, -2.86571175e-01f, 3.54344159e-01f,
  -3.61619711e-01f, 5.39716780e-01f, -9.58379954e-02f, 4.27442417e-02f, 2.41033942e-01f, -8.75856653e-02f, 3.31193805e-01f, -3.16877395e-01f, 3.58511120e-01f, -3.22934896e-01f,
  1.49675369e-01f, 2.56159395e-01f, -2.32965704e-02f, -1.42151356e-01f, 6.13431074e-02f, 1.65381014e-01f, 6.74681365e-02f, -1.68328196e-01f, -3.00577611e-01f, 9.71325785e-02f,
  3.33572626e-02f, -7.68324658e-02f, 1.39200827e-02f, -1.02935664e-01f, 4.63807508e-02f, -5.69878556e-02f, 2.56900117e-02f, -4.90569919e-02f, 5.95063530e-02f, 1.24579839e-01f,
  -1.40538979e-02f, 2.07721312e-02f, 1.77176818e-01f, 2.38201711e-02f, -2.57827967e-01f, 3.38614620e-02f, 4.44070809e-02f, 2.51894873e-02f, 2.41816446e-01f, -2.15452928e-02f,
  7.31865391e-02f, -3.50443088e-03f, 2.95605678e-02f, -9.58152988e-04f, -9.10089836e-02f, 4.18328270e-02f, 6.33417219e-02f, 7.31680021e-02f, -1.50439978e-01f, 9.04603973e-02f,
  -2.03737959e-01f, -4.74896356e-02f, 1.47011384e-01f, 7.36877322e-02f, 5.23209088e-02f, 1.77099705e-02f, -1.86865285e-01f, -7.82471243e-03f, -5.70225343e-02f, -7.14510530e-02f,
  1.56537220e-02f, -6.65923581e-02f, 3.44815701e-02f, 3.71477231e-02f, 1.02598667e-01f, -1.04085617e-01f, 7.62458220e-02f, -3.70635316e-02f, 6.89776316e-02f, -5.03636375e-02f,
  2.58205503e-01f, 4.56121564e-01f, 1.16821863e-02f, -1.17038272e-01f, -2.42626797e-02f, -3.32518443e-02f, 7.43933842e-02f, -1.29838988e-01f, 1.87034935e-01f, -3.66390124e-02f,
  4.50943690e-03f, -4.92010489e-02f, 1.09180227e-01f, 7.47729167e-02f, -2.26018384e-01f, 1.79066598e-01f, 2.62328178e-01f, -2.13283405e-01f, 1.19560249e-01f, 1.17307641e-01f,
  1.46658510e-01f, -2.48569679e-02f, -1.18845716e-01f, 2.32098140e-02f, 6.88355267e-02f, 4.51991037e-02f, 5.08293733e-02f, -8.71009529e-02f, 3.44744418e-03f, 8.55012015e-02f,
  1.33234460e-03f, 3.91369522e-01f, -1.81030080e-01f, -1.24866506e-02f, -1.31622195e-01f, -1.05374932e+00f, -1.92708656e-01f, -2.74457455e-01f, 1.36770874e-01f, 2.65845984e-01f,
  7.61121139e-02f, 7.70056307e-01f, 3.16170484e-01f, -3.80234838e-01f, -6.58015013e-01f, -7.30611458e-02f, -7.60922670e-01f, -4.83993255e-02f, -3.80795375e-02f, -2.17958108e-01f,
  -2.77392387e-01f, -3.10654312e-01f, -1.61141559e-01f, -3.08421314e-01f, -1.10870771e-01f, 2.29118496e-01f, -3.07907641e-01f, 2.73284018e-01f, -4.32708502e-01f, 2.30981007e-01f,
  -2.18215287e-01f, 2.02433124e-01f, 1.73103675e-01f, -9.93199423e-02f, -4.21150327e-01f, 1.87218282e-02f, 2.15936694e-02f, 2.42635414e-01f, 2.59173792e-02f, -9.50682610e-02f,
  1.48364574e-01f, 8.06793757e-03f, -1.61580406e-02f, 2.60773897e-01f, 1.07699327e-01f, 1.22386955e-01f, 3.76922861e-02f, -8.74480456e-02f, 5.71447536e-02f, 1.25668392e-01f,
  5.45312054e-02f, -9.09149721e-02f, -1.53168991e-01f, 4.61381674e-02f, 2.09122915e-02f, 7.22289085e-02f, -1.53549597e-01f, 1.66956913e-02f, -9.81717780e-02f, -1.37924835e-01f,
  6.17627352e-02f, -1.32958442e-01f, -3.23162898e-02f, -8.83557089e-03f, -2.13979241e-02f, -4.00489829e-02f, -4.15642485e-02f, 1.62464827e-01f, 1.62525505e-01f, 2.62923185e-02f,
  -8.55034739e-02f, 1.42624229e-01f, 2.57873554e-02f, -1.23299010e-01f, -5.11516519e-02f, 2.28540868e-01f, -2.68094316e-02f, 2.11365968e-01f, -1.35759905e-01f, -2.27633622e-02f,
  1.21105336e-01f, -1.05429001e-01f, 9.09594968e-02f, -2.17899587e-02f, -3.73668596e-02f, 1.21572502e-01f, 9.44618210e-02f, 8.96725655e-02f, -1.20856063e-02f, -1.28342018e-01f,
  -6.48937285e-01f, -4.09032255e-01f, 8.32774416e-02f, 1.65371209e-01f, 3.12314760e-02f, -4.86274175e-02f, -1.18031964e-01f, -1.05228506e-01f, -2.07294554e-01f, -2.28418440e-01f,
  -2.15893283e-01f, 3.30851093e-04f, -3.55865598e-01f, 4.68707271e-02f, -4.39246111e-02f, -1.79004043e-01f, -2.36127507e-02f, -1.01586804e-02f, -2.01857761e-01f, -4.95726988e-02f,
  -5.87172285e-02f, 8.57505947e-02f, 7.86547810e-02f, -3.94986011e-02f, -4.62387912e-02f, -3.94859314e-02f, 3.62792425e-02f, 1.22467183e-01f, -1.51733309e-01f, -6.86897784e-02f,
  -9.82732713e-01f, 2.40070224e-01f, -5.71055949e-01f, -8.70451868e-01f, 2.86027223e-01f, -8.54457691e-02f, -3.54703516e-01f, 2.68766016e-01f, -4.59803760e-01f, 4.41341370e-01f,
  9.53194126e-02f, -8.09000671e-01f, 4.29950953e-01f, -8.34945500e-01f, -8.65357161e-01f, -2.83137769e-01f, -6.46154225e-01f, -5.95716953e-01f, -1.99001342e-01f, -2.38600969e-01f,
  -4.82632428e-01f, -2.56880552e-01f, -4.52952504e-01f, 6.50107503e-01f, -4.38650876e-01f, -4.25122300e-04f, 3.75916719e-01f, 5.43595612e-01f, -2.11536795e-01f, -1.58011243e-01f,
  -3.32681060e-01f, -2.31464487e-02f, -9.05489475e-02f, -6.44383207e-02f, -2.93631069e-02f, 7.72943720e-02f, -3.96550372e-02f, -2.38294452e-02f, -5.82670383e-02f, 1.37067530e-02f,
  -7.08478391e-02f, -1.50785118e-03f, -1.79337949e-01f, 7.73056075e-02f, 9.03621316e-02f, -7.81022310e-02f, -8.30632895e-02f, 5.72634228e-02f, -2.15021856e-02f, -1.80176765e-01f,
  -1.49509475e-01f, -1.30289793e-01f, -1.48631245e-01f, -1.53868467e-01f, -7.64551461e-02f, 1.17820666e-04f, -3.86908203e-02f, -5.83405886e-03f, -6.48726821e-02f, 1.82123091e-02f,
  -4.06067669e-02f, 4.21916209e-02f, 5.40726669e-02f, -2.31683832e-02f, -4.93522212e-02f, 4.75792624e-02f, -1.21477015e-01f, 4.96786414e-03f, 1.06230766e-01f, -4.51874025e-02f,
  -9.70087294e-03f, -8.27364996e-02f, 8.33197981e-02f, 1.38814170e-02f, -1.36522830e-01f, -1.29481778e-01f, -9.07759070e-02f, -2.66237427e-02f, -3.27321403e-02f, -1.06998689e-01f,
  -2.70061623e-02f, 9.00987014e-02f, 5.97493872e-02f, 4.91826497e-02f, -3.37181352e-02f, 3.35301198e-02f, 2.60913186e-02f, -4.78821481e-03f, 4.43805344e-02f, 7.78725594e-02f,
  2.01648638e-01f, 1.77555397e-01f, 1.10988989e-02f, 6.05864786e-02f, -4.72852886e-02f, 6.00785762e-02f, -8.34049061e-02f, -1.82095945e-01f, 1.50659010e-02f, -2.97955964e-02f,
  7.15811029e-02f, 3.11887730e-03f, 1.35073006e-01f, -9.27702636e-02f, -1.35193020e-02f, 3.07106338e-02f, -7.16335839e-03f, 2.23968588e-02f, 1.01662152e-01f, -1.26321369e-03f,
  1.02297463e-01f, 8.96454155e-02f, 2.63393559e-02f, 6.29121959e-02f, -6.87947050e-02f, 1.17943488e-01f, 6.53539822e-02f, 6.66440055e-02f, 9.59962420e-03f, 2.70822961e-02f,
  2.00673655e-01f, -5.41707993e-01f, -6.33327186e-01f, -4.31672394e-01f, 4.09178287e-01f, 5.24034142e-01f, -5.37707686e-01f, -1.50918335e-01f, -7.49656916e-01f, 7.97426328e-02f,
  1.50582314e-01f, -2.85111904e-01f, -7.85450161e-01f, 3.97839472e-02f, 4.71012807e-03f, -7.49343693e-01f, 4.77541655e-01f, 2.70821035e-01f, -2.39601344e-01f, 3.79393190e-01f,
  1.60653179e-03f, 5.58547735e-01f, -1.60738498e-01f, 5.53310990e-01f, 4.99874800e-01f, 3.28200936e-01f, 6.58247113e-01f, 2.52049044e-02f, 8.03289592e-01f, 2.98446447e-01f,
  -4.92739268e-02f, -2.22363606e-01f, -6.62839189e-02f, -1.58691809e-01f, 2.29152232e-01f, 2.50649542e-01f, 2.54189193e-01f, 6.49825037e-02f, -1.14114314e-01f, -1.79007873e-01f,
  3.79552543e-02f, 1.29480455e-02f, 9.48568434e-02f, -1.36150256e-01f, 1.89689714e-02f, -7.32290819e-02f, -1.37889385e-01f, -4.06193733e-02f, -3.18262726e-01f, -2.22236127e-01f,
  -3.68279308e-01f, 8.66510496e-02f, 1.37894871e-02f, 5.74445091e-02f, -9.08183530e-02f, -8.30508620e-02f, 6.49297312e-02f, 6.51236326e-02f, 5.23736104e-02f, 3.42207849e-02f,
  2.26383373e-01f, 1.82198450e-01f, -8.78431834e-03f, -1.61606178e-01f, -1.55679379e-02f, -1.73622832e-01f, -1.77837983e-02f, 8.04899435e-04f, -3.31592783e-02f, -8.97119343e-02f,
  1.80971492e-02f, -6.76582605e-02f, -1.33252844e-01f, 1.09551571e-01f, 7.19812140e-02f, 6.97078779e-02f, 9.78661999e-02f, 1.12335861e-01f, -8.12112242e-02f, -5.09341583e-02f,
  -1.96869612e-01f, -6.32024556e-02f, 6.31973322e-04f, 6.84985742e-02f, -8.24371800e-02f, -4.11808714e-02f, 1.09277405e-01f, -1.64055638e-02f, -2.02659778e-02f, 1.13048680e-01f,
  1.42341778e-01f, 3.19782197e-01f, -9.39119756e-02f, 6.31066859e-02f, -1.34345844e-01f, 1.53698921e-01f, -2.60375757e-02f, 4.46297936e-02f, 3.53537910e-02f, -5.07614873e-02f,
  3.53741735e-01f, 2.29631379e-01f, 2.30096400e-01f, -9.75423120e-03f, 3.13831642e-02f, 2.68677268e-02f, 6.90530837e-02f, 3.73726413e-02f, 1.68494925e-01f, 2.57612616e-01f,
  1.73331007e-01f, 2.14877889e-01f, 2.57160570e-02f, 5.81490854e-03f, 9.42248479e-02f, 1.04243524e-01f, 1.73733816e-01f, 7.06405044e-02f, 1.01167530e-01f, -1.18044570e-01f,
  4.40525323e-01f, -3.17809314e-01f, -7.92986527e-02f, 8.30806792e-01f, 3.47666591e-01f, -7.21670687e-01f, -5.58187068e-02f, 3.89269382e-01f, 9.36810434e-01f, -3.40991497e-01f,
  3.68327945e-02f, -4.85975534e-01f, -1.77838489e-01f, -4.39592063e-01f, -6.07592285e-01f, -4.84431893e-01f, 1.13036474e-02f, -2.87419915e-01f, 3.45740199e-01f, 2.88250566e-01f,
  5.35479724e-01f, -3.16963077e-01f, -1.95104703e-01f, -2.23760337e-01f, 3.06860059e-01f, 3.98581862e-01f, 2.61557817e-01f, -8.84136111e-02f, -3.71403843e-01f, -3.97415817e-01f,
  -1.62774384e-01f, 3.81801397e-01f, -2.46460410e-03f, -1.54576659e-01f, 3.88839543e-01f, -3.51268463e-02f, -1.22607507e-01f, -2.58281618e-01f, 4.99061821e-03f, -7.91904517e-03f,
  -2.90168654e-02f, -1.45049036e-01f, -8.90950300e-03f, -1.54480502e-01f, 2.40282640e-01f, 2.40559876e-02f, 1.62307665e-01f, 1.90701529e-01f, -3.93365957e-02f, -2.77798902e-02f,
  1.79091990e-01f, 1.65512174e-01f, 3.02611828e-01f, -1.58564709e-02f, 7.23199844e-02f, 8.26709792e-02f, -1.49448082e-01f, -1.12997852e-01f, -4.54072692e-02f, 3.10053732e-02f,
  7.52115771e-02f, 2.26491131e-02f, -1.80423886e-01f, 6.01399429e-02f, -1.35931866e-02f, 9.00943726e-02f, -2.05972185e-03f, -2.51804829e-01f, 1.63982883e-01f, -5.24795502e-02f,
  1.20499156e-01f, 8.58347956e-03f, 1.06965303e-01f, -3.66735905e-02f, 1.48121402e-01f, 6.88061938e-02f, -1.60041749e-01f, -9.30521265e-02f, 3.22792292e-01f, 9.83348861e-02f,
  -6.65226653e-02f, -3.18956152e-02f, -6.38421625e-02f, 7.42438883e-02f, -1.81100085e-01f, 2.79250164e-02f, -3.02457120e-02f, -7.49667967e-03f, 1.40811428e-01f, 4.48016413e-02f,
  4.75438423e-02f, 1.09301202e-01f, 7.11865276e-02f, -1.74205244e-01f, -4.38726246e-02f, -5.46776503e-02f, -1.40890673e-01f, 1.57791823e-02f, -5.78450132e-03f, -4.43212409e-03f,
  3.32979895e-02f, 2.79573221e-02f, 9.34687443e-03f, -2.16421355e-02f, -6.39373735e-02f, 1.14012882e-01f, -5.74443229e-02f, 3.81951556e-02f, 6.62580580e-02f, 7.50258639e-02f,
  1.01367973e-01f, 2.68113147e-02f, 8.36896598e-02f, 2.51261115e-01f, 4.92649339e-02f, 1.71608161e-02f, 1.84642477e-03f, 3.70890498e-02f, -1.06796594e-02f, -9.18698981e-02f,
  9.70720649e-01f, -1.25051761e+00f, 2.80953407e-01f, 7.59791732e-01f, 5.03101945e-01f, 1.55984491e-01f, 6.25120103e-01f, -8.00424293e-02f, 2.79773474e-01f, -8.46288860e-01f,
  -1.35530889e-01f, -7.95685127e-02f, -4.71437365e-01f, 6.30678087e-02f, 8.65897477e-01f, -3.25627774e-01f, 1.68580577e-01f, 7.09727630e-02f, 6.97488412e-02f, -2.16474780e-03f,
  5.30266464e-01f, 2.29803607e-01f, 1.91613838e-01f, -2.90461987e-01f, 6.72462955e-02f, 1.18189240e-02f, 2.10138522e-02f, -6.33453578e-02f, 1.42441496e-01f, 3.20441127e-01f,
  -3.79195213e-01f, 9.96039361e-02f, 2.70334575e-02f, -2.63759375e-01f, -1.71104267e-01f, -2.51863096e-02f, 4.98201922e-02f, 2.95705497e-01f, 2.91010559e-01f, 4.83770519e-02f,
  -4.29629013e-02f, 1.04893975e-01f, 6.99255541e-02f, 6.46486133e-02f, 2.13646740e-02f, 1.06639601e-02f, -1.36495024e-01f, -1.59373060e-01f, -2.68131066e-02f, 8.56402665e-02f,
  -8.49327147e-02f, 4.12516966e-02f, 5.91115057e-02f, -6.05353117e-02f, 7.43651986e-02f, 1.06843591e-01f, 1.96159035e-01f, 7.36394078e-02f, -1.17689632e-01f, 5.00824191e-02f,
  3.60472016e-02f, -9.98759419e-02f, -7.15547875e-02f, 7.87573867e-03f, 4.36976030e-02f, 8.24013054e-02f, 3.09532490e-02f, 3.82333882e-02f, -8.81169587e-02f, -1.41145289e-01f,
  9.53405276e-02f, 2.95906644e-02f, 2.31079478e-02f, -4.83805947e-02f, 1.72013380e-02f, 1.10839643e-01f, 8.66371170e-02f, -4.37130220e-02f, -7.55353495e-02f, 8.72299299e-02f,
  -8.70495588e-02f, 1.79208536e-02f, -1.98890269e-01f, 1.84663367e-02f, -8.73146877e-02f, -5.73578849e-03f, -1.68802768e-01f, 3.56256291e-02f, 4.62275036e-02f, 5.06479405e-02f,
  -1.34694123e+00f, -1.06204677e+00f, -1.53589323e-01f, -5.34227043e-02f, -1.81666508e-01f, -7.49887079e-02f, 9.92507413e-02f, 4.78363633e-02f, -2.59493709e-01f, 8.33444372e-02f,
  -1.17420472e-01f, 3.38449255e-02f, -1.61773562e-01f, 4.44262400e-02f, -1.19861938e-01f, 1.49230205e-03f, 6.58554956e-02f, -1.64436534e-01f, 1.01712896e-02f, -2.39944175e-01f,
  -9.59873646e-02f, -3.32052745e-02f, 5.73304594e-02f, 1.54475763e-01f, -7.45165125e-02f, 1.19145745e-02f, -2.46033035e-02f, 7.87646919e-02f, -4.83488254e-02f, -3.29080857e-02f,
  -4.21739101e-01f, 1.01844585e+00f, 9.60571527e-01f, -5.35223722e-01f, 3.79917294e-01f, 4.03036624e-01f, -4.05107588e-01f, 3.78967166e-01f, -1.62040457e-01f, -1.15339942e-01f,
  -4.76445615e-01f, 4.54321891e-01f, -5.50908297e-02f, -1.48560002e-01f, -6.54993057e-01f, -4.68498826e-01f, -3.99929643e-01f, -1.74605682e-01f, 4.18199785e-02f, -2.65719891e-02f,
  -2.56246507e-01f, -8.09249222e-01f, 1.58645183e-01f, 2.40710661e-01f, 4.77126509e-01f, 4.39948469e-01f, -6.42455578e-01f, 2.14861393e-01f, 1.50846034e-01f, -3.12774070e-02f,
  1.37473568e-01f, -2.48062126e-02f, 2.62996405e-01f, 2.07341358e-01f, 1.28162755e-02f, 2.98260562e-02f, 1.42518714e-01f, 7.80363381e-03f, -4.11715619e-02f, 1.32807076e-01f,
  6.37462139e-02f, 1.04950175e-01f, -1.07449200e-02f, 2.83317734e-02f, 2.26986915e-01f, 2.93700397e-01f, 3.81328642e-01f, 3.18788081e-01f, 1.56565294e-01f, 3.35422695e-01f,
  2.82070518e-01f, 3.46069187e-01f, 1.00753739e-01f, -3.63297909e-02f, 1.31537512e-01f, 1.84228774e-02f, -1.50432368e-03f, 1.81409866e-01f, 1.96703508e-01f, 1.01192161e-01f,
  -4.45475131e-02f, -2.10317686e-01f, 1.01310924e-01f, 1.11674108e-01f, -7.94495791e-02f, 1.94157451e-01f, -2.40794546e-03f, -6.71052337e-02f, -1.28443286e-01f, -1.35419313e-02f,
  -1.39497057e-01f, 9.99238417e-02f, -5.08531705e-02f, -9.24541354e-02f, -1.67764366e-01f, -2.47849450e-02f, 4.73581068e-02f, -6.92344010e-02f, -1.10217638e-01f, -1.01273945e-02f,
  -1.39584050e-01f, -1.88448295e-01f, -5.19284122e-02f, -4.92815524e-02f, -6.91005494e-03f, -6.88940510e-02f, 2.07263418e-02f, 2.79150367e-01f, -5.01756407e-02f, -1.40954956e-01f,
  -5.58726013e-01f, -9.92630243e-01f, -1.82330325e-01f, 8.39322135e-02f, -1.16877094e-01f, -4.31003496e-02f, -1.48605734e-01f, 1.78348631e-01f, -1.82535201e-01f, -8.42526257e-02f,
  6.14284277e-02f, -1.47225638e-03f, -4.56165969e-02f, -5.91771491e-02f, -1.29425824e-01f, -8.93440768e-02f, -3.30516696e-01f, -1.98662251e-01f, -1.69487357e-01f, 6.64166138e-02f,
  -6.47038175e-03f, -5.92810959e-02f, -7.83966407e-02f, -1.90003589e-02f, -4.49352228e-05f, 6.21187640e-03f, -1.38501972e-01f, 1.05590530e-01f, -1.02850176e-01f, -1.28714174e-01f,
  -4.50248867e-01f, -1.00599058e-01f, 7.13602006e-01f, -1.59573890e-02f, -1.60963774e-01f, -4.78201747e-01f, -3.80330682e-02f, -1.45017326e-01f, -4.69861746e-01f, -4.90015417e-01f,
  -2.75587201e-01f, 1.56039238e-01f, 5.43758869e-01f, -2.58597910e-01f, 1.11045909e+00f, 3.10323805e-01f, -2.08190441e-01f, 2.90116132e-03f, 2.75651425e-01f, 2.26622522e-01f,
  3.04465026e-01f, -1.90471902e-01f, 9.36144233e-01f, -1.73979715e-01f, 9.25355926e-02f, 1.44619703e-01f, 6.22456014e-01f, 4.34847862e-01f, -1.26599699e-01f, 1.39801756e-01f,
  -3.96738291e-01f, -2.35060841e-01f, -9.43500027e-02f, -6.09364621e-02f, 1.38268732e-02f, -1.13895148e-01f, 1.32052690e-01f, 2.73840368e-01f, 4.29745540e-02f, 3.74835334e-03f,
  8.13651085e-02f, 8.90348386e-03f, -2.46127039e-01f, 8.64777938e-02f, -2.29726121e-01f, -4.29530367e-02f, 3.04702893e-02f, -4.61255275e-02f, -1.97290797e-02f, 3.79364565e-02f,
  2.09396049e-01f, 3.14558893e-02f, -5.81267923e-02f, 2.03236695e-02f, 2.38197535e-01f, -2.41242141e-01f, -5.84125742e-02f, 2.08800688e-01f, -1.47429302e-01f, -1.64022982e-01f,
  -9.11216065e-02f, -2.63032280e-02f, 2.01056339e-02f, 3.89606915e-02f, -9.79603678e-02f, -1.85026541e-01f, 3.46266776e-02f, 2.86646709e-02f, -4.27724272e-02f, -3.53945442e-03f,
  -9.77759212e-02f, 1.41573161e-01f, -1.17231801e-01f, -1.28274351e-01f, -2.76653990e-02f, -2.99946040e-01f, 1.82700634e-01f, 7.94080868e-02f, 2.85125840e-02f, -2.39431821e-02f,
  6.15442768e-02f, -8.63169786e-03f, 9.59459841e-02f, -4.92728800e-02f, -1.87468842e-01f, 2.14129478e-01f, -2.70980727e-02f, -9.09315050e-03f, 3.46666537e-02f, 3.47250104e-01f,
  1.28695771e-01f, 4.04932112e-01f, 7.61144459e-02f, -1.94529712e-01f, 1.57682329e-01f, -2.67516579e-02f, 3.02123781e-02f, -5.03361970e-02f, 7.27241412e-02f, 6.68643862e-02f,
  2.18960904e-02f, 1.01334818e-01f, -8.46167728e-02f, -5.13821021e-02f, 1.74305648e-01f, 5.45468479e-02f, 1.87247857e-01f, -1.99278630e-02f, 7.83758983e-02f, 1.08122073e-01f,
  5.46798371e-02f, 1.81557480e-02f, 1.61486521e-01f, -1.61924139e-02f, -1.45361841e-01f, -2.76783220e-02f, -1.02096952e-01f, 3.35327052e-02f, 1.96574762e-01f, 9.43446010e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  7.99750388e-01f, 6.78096950e-01f, 7.79897273e-01f, 9.23378706e-01f, 1.05467510e+00f, 9.10078108e-01f, 9.62358773e-01f, 7.21745908e-01f, 7.54406214e-01f, 8.56947422e-01f,
  8.93288553e-01f, 3.10241789e-01f, 8.84354115e-01f, 7.73579895e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  3.44531894e-01f, 1.63773179e-01f, -4.86169988e-03f, 2.63697654e-01f, -4.27702308e-01f, -2.92998433e-01f, -2.66321748e-01f, 1.20202780e-01f, -8.99759650e-01f, -4.95809585e-01f,
  -7.92803705e-01f, 3.28286707e-01f, 3.44408125e-01f, 2.23075241e-01f, -5.38885832e-01f, 5.11677802e-01f, 2.44111419e-01f, -6.48341596e-01f, -6.45517111e-01f, -2.21584693e-01f,
  7.90159285e-01f, -1.23623514e+00f, -1.01360297e+00f, 5.94515920e-01f, 1.04177403e+00f, -1.68563500e-01f, -3.53868425e-01f, -2.76407868e-01f, -4.89305168e-01f, -6.13955736e-01f,
  -8.02072823e-01f, -5.60757279e-01f, -7.51449227e-01f, 2.88245469e-01f, 4.35486943e-01f, -8.82780075e-01f, 4.81640756e-01f, 1.73684880e-01f, 5.94055295e-01f, -7.45763481e-01f,
  2.84437567e-01f, -5.88631511e-01f, 8.08991253e-01f, -2.47611791e-01f, -5.63922465e-01f, 1.02965522e+00f, -4.36211526e-01f, 2.23008186e-01f, -8.45703840e-01f, 1.90009385e-01f,
  3.55345815e-01f, -4.37449366e-01f, -8.60327125e-01f, 7.25944817e-01f, -1.11651731e+00f, 6.09157085e-01f, 6.07468963e-01f, -5.74598432e-01f, -1.01542389e+00f, 5.29331625e-01f,
  -9.06664491e-01f, -7.78788090e-01f, -4.18743819e-01f, -9.13795173e-01f, -2.40460992e-01f, -6.99597299e-02f, 6.18534535e-02f, -5.83833635e-01f, -3.11297625e-01f, 1.41429290e-01f,
  -4.76518273e-01f, 1.92791015e-01f, 1.84297845e-01f, -4.89649475e-01f, -4.11106110e-01f, 3.13003391e-01f, 6.44445568e-02f, -6.91342235e-01f, -3.29168960e-02f, -6.60138011e-01f,
  2.48679280e-01f, -2.63863653e-01f, -9.18400764e-01f, -1.06014177e-01f, 2.52199858e-01f, 5.99590659e-01f, -8.73267412e-01f, -6.66471243e-01f, -9.63610172e-01f, -4.49939132e-01f,
  -4.67888683e-01f, 7.33592033e-01f, -8.11379492e-01f, 7.52102971e-01f, -3.55003893e-01f, -5.63463032e-01f, -7.35829413e-01f, -1.87272578e-01f, -1.37742266e-01f, -5.84494829e-01f,
  -5.25277518e-02f, 3.87946784e-01f, 3.21915179e-01f, 1.52872622e-01f, -5.84097981e-01f, 2.01346189e-01f, 2.96835899e-01f, 6.71580195e-01f, 2.50225812e-01f, 4.40202624e-01f,
  -1.54264569e-01f, 4.30842727e-01f, 6.64479375e-01f, 3.41950953e-01f, -1.00974596e+00f, -6.10543489e-01f, 4.97470498e-01f, -5.64835906e-01f, -8.90919328e-01f, -8.97386312e-01f,
  2.43395612e-01f, 9.12501752e-01f, 7.39410996e-01f, -1.43263924e+00f, 3.44535485e-02f, -2.62245864e-01f, 3.82030904e-01f, -7.27721334e-01f, 2.03496277e-01f, 3.24361444e-01f,
  -2.03134686e-01f, 2.28100374e-01f, 2.80556716e-02f, 1.36358514e-01f, 2.05899596e-01f, -1.45230666e-01f, 5.95356703e-01f, 6.05028152e-01f, -4.27336246e-01f, 6.92568719e-01f,
  8.72220039e-01f, 4.65602905e-01f, 7.29871213e-01f, 7.37314045e-01f, 3.49388897e-01f, 9.04335499e-01f, 5.33753872e-01f, -4.48397607e-01f, 6.33053422e-01f, 2.02431679e-02f,
  -5.20930849e-02f, 4.69015628e-01f, -1.07287014e+00f, -6.27470195e-01f, 6.68664500e-02f, -1.07026123e-01f, -9.14747775e-01f, -8.76025021e-01f, 7.42632449e-01f, 5.55264711e-01f,
  7.63673723e-01f, -1.90810457e-01f, -2.53754020e-01f, 1.02812278e+00f, 3.99871856e-01f, 1.72327489e-01f, -2.76939899e-01f, 5.06051481e-01f, 4.03639883e-01f, 4.46956068e-01f,
  9.61898685e-01f, 5.34178495e-01f, -1.65304840e-02f, 2.02786252e-01f, -8.18902254e-01f, 2.66470462e-01f, -4.90369529e-01f, -5.83301842e-01f, -2.07958966e-01f, 9.74410534e-01f,
  -9.74845707e-01f, 1.06839677e-02f, 7.66969800e-01f, 5.50656676e-01f, -1.17019854e-01f, -4.84351635e-01f, -8.47783864e-01f, -6.19321704e-01f, -4.60892729e-02f, -7.63111889e-01f,
  -1.10318553e+00f, -2.84037262e-01f, -2.03288391e-01f, 3.76398802e-01f, -9.16321427e-02f, -5.49951732e-01f, 3.46026272e-02f, 9.70187411e-03f, 1.91604584e-01f, 1.94016680e-01f,
  1.21670075e-01f, -3.64294350e-01f, -7.90300667e-01f, 2.34461874e-01f, -4.36264962e-01f, -7.81561494e-01f, 5.97553909e-01f, 5.63549161e-01f, 3.02317679e-01f, 9.64388251e-02f,
  1.16279349e-01f, -2.40182564e-01f, -1.00312114e+00f, 2.35007420e-01f, 3.16535354e-01f, -8.18891972e-02f, -9.39442992e-01f, -7.32687235e-01f, -4.59216416e-01f, -9.15024102e-01f,
  1.17867780e+00f, 6.94607139e-01f, -1.45710200e-01f, -1.11495316e+00f, 1.80988789e-01f, -4.72253233e-01f, 2.15373769e-01f, -4.36425000e-01f, -1.81269377e-01f, -5.19548178e-01f,
  -1.80961400e-01f, -3.12749147e-01f, -6.80093467e-01f, 3.42117280e-01f, -4.64118659e-01f, -2.87935227e-01f, 1.97298527e-01f, -2.57778257e-01f, -5.61703503e-01f, -6.19414091e-01f,
  3.95689279e-01f, 3.07357788e-01f, 5.91765583e-01f, 6.67272747e-01f, -4.56233591e-01f, -5.46381474e-01f, -1.69615954e-01f, -6.03982806e-01f, -9.72511649e-01f, 6.67435586e-01f,
  1.86409459e-01f, -3.31095755e-01f, 5.90726472e-02f, -4.69795913e-01f, -7.51195014e-01f, 4.59309369e-01f, -7.98391178e-03f, -3.96062911e-01f, -4.11084890e-01f, 3.83415937e-01f,
  -5.61618865e-01f, -3.10838342e-01f, 1.11061670e-01f, -5.69721580e-01f, -3.74061525e-01f, 7.81500876e-01f, 3.22126657e-01f, -5.94557464e-01f, -2.19320893e-01f, -6.79915667e-01f,
  -4.05422956e-01f, -4.30067033e-01f, 5.31207740e-01f, -3.14207345e-01f, -7.05207109e-01f, -9.96551514e-02f, 4.15062308e-01f, 4.42988873e-01f, -4.67695057e-01f, -8.99126410e-01f,
  4.51227635e-01f, -5.18042862e-01f, -5.97842097e-01f, 1.00150026e-01f, 4.23448265e-01f, -6.72105193e-01f, -6.02496624e-01f, 9.63893056e-01f, -7.57171869e-01f, -4.30921465e-01f,
  1.72186300e-01f, 5.19134164e-01f, 1.61380947e-01f, 2.87713200e-01f, -9.25319362e-03f, -5.98930605e-02f, 1.81693792e-01f, -5.67381799e-01f, -5.92614949e-01f, -7.25634813e-01f,
  -4.97274756e-01f, 8.80844831e-01f, 5.17271936e-01f, -7.96276927e-01f, -7.72895753e-01f, -4.75728273e-01f, 6.47957265e-01f, -1.04935122e+00f, 1.09106079e-02f, -9.00740087e-01f,
  6.11888587e-01f, -5.32727838e-01f, -7.07617939e-01f, 3.30690056e-01f, -8.35293710e-01f, -5.60289860e-01f, -1.22619629e+00f, 6.13499939e-01f, -5.19355536e-01f, 8.37894797e-01f,
  5.06938577e-01f, 3.50380272e-01f, 1.70970291e-01f, 1.38307467e-01f, 3.47536922e-01f, 4.53442894e-02f, -3.17268461e-01f, 3.51269022e-02f, 1.70604706e-01f, 4.53725278e-01f,
  1.37448132e-01f, -6.81266069e-01f, 7.35425711e-01f, 4.31812167e-01f, 3.54674041e-01f, -8.60077798e-01f, -8.18218529e-01f, 4.68596309e-01f, -5.94212294e-01f, -7.19257116e-01f,
  -9.41443980e-01f, -4.66539592e-01f, -6.04473293e-01f, -7.93814361e-01f, 2.68123537e-01f, -6.38798654e-01f, 8.44657779e-01f, 7.28901863e-01f, 5.74237168e-01f, -7.66517043e-01f,
  -1.05998755e-01f, -2.17883557e-01f, 1.32047966e-01f, -2.43954107e-01f, 1.67376280e-01f, 2.18715429e-01f, -4.48645681e-01f, -1.52105078e-01f, 1.01333946e-01f, 1.14237659e-01f,
  4.24290925e-01f, 3.81004572e-01f, 6.22442007e-01f, -6.34741366e-01f, 4.10486639e-01f, -7.98639059e-01f, 6.35100722e-01f, -4.12599035e-02f, 5.82535684e-01f, 3.06519661e-02f,
  -9.26697910e-01f, 4.85124737e-01f, -3.06098670e-01f, -4.96135265e-01f, 4.85412180e-01f, -1.07862163e+00f, 3.64913166e-01f, 6.44147217e-01f, -1.00634670e+00f, -3.24674904e-01f,
  1.26598850e-01f, -6.63003743e-01f, 9.60533023e-01f, -6.97859943e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.18196748e-01f, 1.87500745e-01f, 1.21441022e-01f, -5.28589003e-02f, 7.54000768e-02f, 1.81724533e-01f, -2.61299729e-01f, -2.61533111e-01f, 3.51658501e-02f, 7.39951879e-02f,
  -6.69000521e-02f, -3.07246614e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    