/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.19672477e-01f, 2.25473121e-02f, -1.43043920e-01f, 1.79680049e-01f, 2.11757764e-01f, -1.45481173e-02f, 2.74977952e-01f, 6.29967973e-02f, 6.94296136e-02f, 8.66830796e-02f,
  5.40878139e-02f, -2.28860006e-01f, 3.82336527e-02f, 9.69281718e-02f, 1.01756491e-02f, -1.18696287e-01f, 2.09358796e-01f, -7.33455420e-02f, -9.46340412e-02f, 1.51471402e-02f,
  -6.92695454e-02f, 1.10824719e-01f, 6.45982549e-02f, 6.00726157e-02f, 1.52870849e-01f, -1.97896019e-01f, 2.61528671e-01f, -8.66764113e-02f, 1.35195181e-01f, 7.92337209e-03f,
  2.46870276e-02f, -8.77692997e-02f, -9.39732566e-02f, -5.33653088e-02f, 5.34119047e-02f, 1.15232291e-02f, 2.84822173e-02f, -1.21310353e-01f, 1.36610484e-02f, -2.51054801e-02f,
  -2.32757758e-02f, -6.09890111e-02f, 6.76660389e-02f, -1.40046822e-02f, 3.92854363e-02f, -6.71509057e-02f, -1.91667303e-02f, -5.59896342e-02f, -2.44770795e-02f, 9.16838348e-02f,
  -4.99212965e-02f, 9.04744491e-03f, 4.62876260e-02f, 1.33768208e-02f, 4.93223704e-02f, 3.57881300e-02f, 6.07542396e-02f, -4.75366935e-02f, 5.72805107e-02f, 4.07090075e-02f,
  -5.01187146e-02f, 1.76086593e-02f, -3.71471867e-02f, -9.48469192e-02f, -6.63599148e-02f, -6.26476621e-03f, -2.24712621e-02f, -9.47026312e-02f, 7.10224807e-02f, -1.06814377e-01f,
  -8.92627984e-03f, 5.17021194e-02f, -5.36670722e-02f, 4.50212136e-02f, 9.68148112e-02f, 8.96894261e-02f, 1.49505772e-02f, -9.80094727e-03f, 1.13203876e-01f, 6.21313937e-02f,
  -6.44517597e-03f, -2.28851028e-02f, 1.91021059e-02f, 5.87781556e-02f, -1.10176653e-01f, 2.71207131e-02f, -6.03101104e-02f, 6.93729222e-02f, -5.02564609e-02f, 3.93968336e-02f,
  1.41601086e-01f, 1.74270168e-01f, -1.12763345e-02f, 1.75270718e-03f, 2.30191387e-02f, -7.11992458e-02f, -1.45542935e-01f, 6.42400701e-03f, 4.49811555e-02f, 5.87538965e-02f,
  -9.13282100e-04f, 9.71518084e-02f, -6.45503700e-02f, -1.41253872e-02f, 5.68526946e-02f, 7.83749744e-02f, 5.82250915e-02f, -6.34674281e-02f, 7.25328848e-02f, 1.30344048e-01f,
  1.03381202e-01f, -1.00514079e-02f, -8.66886973e-02f, 1.71418041e-01f, 1.44531995e-01f, 2.35675015e-02f, -4.84951250e-02f, 4.72324109e-03f, 1.13353468e-01f, 1.20796181e-01f,
  -2.16939658e-01f, -4.22651172e-02f, 2.43220076e-01f, -3.09016295e-02f, 3.71200554e-02f, 1.66402400e-01f, -2.57805921e-02f, 3.61609869e-02f, -2.52807409e-01f, -2.73480207e-01f,
  -8.59765112e-02f, -3.42801102e-02f, -5.42408116e-02f, 1.73112258e-01f, -4.16752324e-03f, 3.91171537e-02f, 2.03880686e-02f, 6.64788857e-02f, -1.83763206e-02f, -3.70593444e-02f,
  -4.04042052e-03f, -4.50346880e-02f, 2.03544959e-01f, -6.61325008e-02f, 6.23031445e-02f, -8.91902223e-02f, -9.48045030e-02f, 7.87367765e-03f, 1.41277671e-01f, 9.90214013e-03f,
  1.07287124e-01f, -4.63477075e-02f, 5.44140674e-02f, -2.94964984e-02f, 3.32367397e-03f, 7.95209035e-02f, -2.57740449e-03f, 5.47760166e-02f, 6.56151250e-02f, 1.11372441e-01f,
  -4.91125323e-03f, 5.43899648e-02f, -4.18482460e-02f, -9.72180627e-04f, -7.58295134e-02f, 1.12424803e-03f, 7.00287521e-02f, 2.05504611e-01f, 1.49716482e-01f, 1.38745001e-02f,
  -2.37183981e-02f, 1.54696569e-01f, 9.44640711e-02f, 3.65127213e-02f, 6.23246282e-02f, -2.89905444e-02f, 5.42520322e-02f, -2.98506804e-02f, 8.83011743e-02f, -3.67303975e-02f,
  -1.24403998e-01f, 2.46089753e-02f, 8.47476497e-02f, 1.19989276e-01f, -8.31105784e-02f, -2.75439955e-02f, 3.80543545e-02f, 7.16498718e-02f, -3.58039625e-02f, -3.93226929e-02f,
  1.12147205e-01f, 1.44955739e-01f, 4.91841100e-02f, 1.41574279e-03f, 2.89142486e-02f, -2.47142091e-02f, 5.12441099e-02f, 8.00959244e-02f, -1.90671496e-02f, -4.02377397e-02f,
  -5.75139783e-02f, -4.28696461e-02f, 1.46584153e-01f, 9.31273550e-02f, 3.60827930e-02f, 2.92089116e-02f, 2.72556022e-02f, 1.23602994e-01f, -2.59679422e-04f, 2.74407089e-01f,
  -1.74439222e-01f, -2.67019659e-01f, -5.05962633e-02f, -1.69066712e-02f, -1.25240341e-01f, 1.75511558e-02f, -9.76741463e-02f, 3.25247757e-02f, 3.27258296e-02f, -6.22363575e-02f,
  1.97878182e-02f, 3.06409802e-02f, 8.05438086e-02f, -1.20232262e-01f, 6.62476867e-02f, -4.31718454e-02f, -3.26281451e-02f, -5.45481741e-02f, 3.25270439e-03f, -4.14579660e-02f,
  -5.55238761e-02f, -5.92751354e-02f, 1.04884788e-01f, 1.22967578e-01f, -1.04251772e-01f, -2.06117108e-02f, -1.37502566e-01f, -1.40874116e-02f, -3.09788884e-04f, 4.73792804e-03f,
  3.71354580e-01f, 1.33702606e-01f, -3.59456539e-02f, 8.76582135e-03f, 1.52079299e-01f, 1.30028293e-01f, -5.64901195e-02f, 1.65202558e-01f, -6.98543116e-02f, 2.42370734e-05f,
  2.56708283e-02f, 1.30173683e-01f, -1.12153001e-01f, -4.00569066e-02f, 8.16571191e-02f, -3.02016348e-01f, 2.43543640e-01f, 7.26666823e-02f, -1.11241817e-01f, 1.53252274e-01f,
  -6.30066022e-02f, -7.91262556e-03f, -1.16499476e-02f, -6.00441732e-02f, 1.14703707e-01f, -6.37370721e-02f, -4.70520705e-02f, -1.25910658e-02f, 2.07911775e-01f, 3.39704603e-02f,
  1.20471343e-01f, -4.10915874e-02f, -5.55405580e-02f, -9.78562236e-02f, 7.35773668e-02f, 3.94526012e-02f, -4.94321063e-03f, -1.16509646e-01f, 1.35635231e-02f, -4.31177877e-02f,
  -8.32433328e-02f, 1.32643834e-01f, -4.34391908e-02f, -1.24397293e-01f, -1.20862178e-03f, 8.84021353e-03f, 2.42699012e-02f, 1.31749853e-01f, 2.32904125e-02f, -4.01281454e-02f,
  -8.89310762e-02f, -4.54204855e-03f, -5.21585625e-03f, -2.06260812e-02f, 6.03746809e-03f, 3.12817544e-02f, 4.96395491e-02f, 2.79291756e-02f, 7.40766749e-02f, 5.74384071e-02f,
  -1.26026198e-01f, 1.24852002e-01f, 5.54503612e-02f, 1.63601041e-01f, 2.75049694e-02f, 6.46717772e-02f, 2.78894845e-02f, 1.58002861e-02f, 2.46497318e-02f, 9.36553851e-02f,
  1.18373945e-01f, 1.14777520e-01f, 4.25661616e-02f, 4.32906598e-02f, 3.84041369e-02f, 1.02988882e-02f, 2.65724864e-02f, 6.60462603e-02f, 6.97108209e-02f, 4.02200334e-02f,
  4.18405719e-02f, -1.94517449e-02f, 4.85733636e-02f, 4.34523039e-02f, 6.32244302e-03f, 3.77297332e-03f, 1.65538881e-02f, -3.28828916e-02f, -4.80218455e-02f, -3.02781258e-02f,
  2.74350524e-01f, 2.29742572e-01f, -4.02773134e-02f, 3.54777686e-02f, -3.34642865e-02f, -2.15785485e-02f, -1.50811985e-01f, -1.41732737e-01f, -1.15567539e-02f, -1.14809750e-02f,
  8.25274587e-02f, -5.02462126e-03f, 3.69666256e-02f, -1.98095459e-02f, -1.68647356e-02f, 9.35972203e-03f, 7.42953047e-02f, 1.06681287e-01f, 2.04776078e-01f, 1.34485558e-01f,
  7.41999447e-02f, 2.09107287e-02f, 2.73145512e-02f, -2.16558874e-02f, 8.79343376e-02f, 1.19525596e-01f, 1.16782896e-01f, -6.60572723e-02f, 2.67069973e-02f, 3.84392366e-02f,
  -1.89732283e-01f, -2.99466163e-01f, -3.94617468e-01f, -2.43262202e-01f, 1.18985288e-01f, -2.78234571e-01f, -3.28493297e-01f, -9.08075422e-02f, 7.33216852e-02f, -6.78735450e-02f,
  6.84060082e-02f, -1.07301205e-01f, -3.38716432e-02f, -1.42405897e-01f, -1.83209792e-01f, -3.14360075e-02f, -1.93499401e-01f, 2.59517711e-02f, 1.42569616e-01f, -1.39965145e-02f,
  -1.02575622e-01f, 4.17156667e-02f, -3.38616937e-01f, 1.10935189e-01f, -8.79012123e-02f, -5.93978539e-02f, 1.05679579e-01f, 2.56490465e-02f, -2.04897951e-02f, 1.54590458e-02f,
  -3.83244269e-02f, 1.04036793e-01f, -1.23969369e-01f, -3.27990353e-02f, -1.93469636e-02f, -9.84928235e-02f, -7.68127590e-02f, -2.77833231e-02f, 4.50922772e-02f, 1.34741828e-01f,
  5.61541431e-02f, -3.68031487e-03f, 1.62562594e-01f, 2.33447179e-02f, 2.70386934e-02f, 4.64909747e-02f, 2.86048986e-02f, 1.95772983e-02f, -1.58864986e-02f, -8.29136670e-02f,
  -1.96944997e-02f, 7.81788211e-03f, 5.33327051e-02f, -1.85392480e-02f, 4.87088449e-02f, -5.98299019e-02f, -4.92275357e-02f, -3.25236266e-04f, 5.15779033e-02f, 5.46209281e-03f,
  3.95684540e-02f, -6.32774010e-02f, 7.83489924e-03f, -1.56979188e-02f, -7.49486499e-03f, -7.36479238e-02f, 3.19946073e-02f, 1.14254460e-01f, -1.15686273e-02f, 2.18632147e-02f,
  -2.91218609e-02f, 1.06303677e-01f, 1.08322516e-01f, 1.16232093e-02f, 5.09303324e-02f, -7.56571665e-02f, 5.30914851e-02f, -1.17127858e-01f, 2.01547928e-02f, -4.63940389e-02f,
  2.23428309e-02f, 2.54001450e-02f, -2.35604253e-02f, 9.67754945e-02f, 2.39980929e-02f, 1.23202235e-01f, 2.79672947e-02f, -3.65322605e-02f, -9.28613171e-02f, -1.62255168e-02f,
  5.02386354e-02f, -1.29591659e-01f, 1.13997161e-02f, -1.08056366e-02f, -2.74122402e-04f, -4.56295256e-03f, -7.10501671e-02f, 1.06531251e-02f, 1.36020765e-01f, 1.77621730e-02f,
  8.07593018e-02f, -3.97836231e-02f, 4.36170027e-02f, 5.27309813e-02f, 2.56906934e-02f, 5.08469790e-02f, -3.98145579e-02f, 1.22445645e-02f, -3.31562310e-02f, 5.33920061e-03f,
  -1.83316264e-02f, 1.13623492e-01f, 3.73398550e-02f, 4.22615744e-02f, 3.32403067e-03f, -4.60207723e-02f, -5.81660159e-02f, 3.45353857e-02f, 5.25000654e-02f, 4.20407839e-02f,
  -2.00029045e-01f, 3.88568759e-01f, -7.97289908e-02f, 5.88667579e-02f, -1.27318859e-01f, 4.72805053e-02f, 6.43050000e-02f, -5.89712299e-02f, -1.64566994e-01f, 2.97462761e-01f,
  -1.97801227e-03f, 7.59102255e-02f, 7.47322813e-02f, 1.83004573e-01f, -5.84426880e-01f, 9.51315835e-02f, -9.79594421e-03f, 7.73343891e-02f, -3.88633087e-02f, 1.00615192e-02f,
  -9.66020823e-02f, 2.21650004e-01f, -9.95262638e-02f, 3.66561078e-02f, -2.50882525e-02f, 2.96518728e-02f, -8.66649579e-03f, -1.31772026e-01f, 1.37892723e-01f, -2.96037216e-02f,
  -2.99118855e-03f, 6.42634481e-02f, -9.95892510e-02f, -6.04521297e-02f, -1.17195778e-01f, -2.68430766e-02f, 1.02443829e-01f, -4.06934284e-02f, -1.25342220e-01f, -1.62906013e-02f,
  7.60092363e-02f, 4.17992752e-03f, -1.61005538e-02f, -3.69131826e-02f, -4.42866422e-03f, -4.21813168e-02f, -2.93344841e-03f, -1.56024843e-01f, 2.33372673e-02f, 1.85866188e-02f,
  -8.53121132e-02f, -5.25705628e-02f, -3.53926718e-02f, 9.41225067e-02f, -3.75673138e-02f, -7.05111353e-03f, 4.83957455e-02f, 4.30559479e-02f, 8.63159522e-02f, -4.63091135e-02f,
  5.76810539e-02f, 1.86038073e-02f, -7.83541575e-02f, 1.71514917e-02f, 2.72787735e-03f, 3.60785648e-02f, 2.46969759e-02f, 1.14884786e-01f, -5.81440143e-02f, -6.12122267e-02f,
  -2.97615509e-02f, -4.77363281e-02f, -6.93859756e-02f, -2.04505231e-02f, 2.37123184e-02f, 4.71891463e-03f, -3.51230428e-02f, 1.06591940e-01f, -3.01083010e-02f, -9.57066417e-02f,
  -2.94670369e-02f, -6.68576658e-02f, -1.87671967e-02f, 8.43996033e-02f, 6.79626167e-02f, -9.40607861e-02f, 4.42895852e-02f, 8.68506357e-03f, -1.37659401e-04f, -4.00989652e-02f,
  9.91734639e-02f, 2.32394472e-01f, 4.66631614e-02f, 9.68989283e-02f, 5.34093473e-04f, -7.48372301e-02f, -3.84614468e-02f, 6.34425730e-02f, 7.57867694e-02f, -6.70891348e-03f,
  -1.09796831e-03f, 5.10321371e-03f, -3.77001427e-02f, -4.69170883e-02f, -5.85102625e-02f, -1.53902294e-02f, 6.35724738e-02f, -9.65264291e-02f, 9.58061032e-03f, 4.32887897e-02f,
  -5.33865504e-02f, -1.02684297e-01f, -6.95545897e-02f, 4.59205210e-02f, 1.60820857e-01f, -4.89987545e-02f, 4.47540283e-02f, -3.16428505e-02f, -9.65583846e-02f, 5.38078137e-02f,
  -4.81468111e-01f, -1.88637167e-01f, -1.04719959e-01f, -2.45826676e-01f, 4.81663756e-02f, -3.90615553e-01f, -3.54776829e-01f, -1.87372193e-02f, -1.38596609e-01f, -1.03798203e-01f,
  4.54692449e-03f, -1.81340247e-01f, -2.12797113e-02f, -3.09010923e-01f, -1.87179416e-01f, -6.92987293e-02f, -1.75674692e-01f, -6.28962517e-02f, 6.73508644e-02f, -8.07580203e-02f,
  -8.22128057e-02f, -1.44027635e-01f, -7.34277368e-02f, 9.02122259e-02f, -3.06340367e-01f, -2.59430744e-02f, 3.04963142e-01f, 1.46595910e-01f, 9.11002159e-02f, -1.24198031e-02f,
  2.17055175e-02f, -6.68963268e-02f, -8.99477974e-02f, 2.07095817e-02f, -3.21927154e-03f, 4.66268882e-03f, -1.55552616e-02f, -2.97411010e-02f, 9.12142098e-02f, 3.44270132e-02f,
  -6.96443543e-02f, -4.26106155e-02f, -8.51401091e-02f, 8.53321254e-02f, -1.93522610e-02f, 1.10056764e-02f, 9.65576712e-03f, 6.02936931e-02f, -6.03633113e-02f, -1.92074940e-01f,
  -9.99776945e-02f, 6.35068491e-02f, 3.83616239e-02f, -5.87458201e-02f, -5.60909510e-03f, -7.58705586e-02f, 4.09501605e-02f, 4.46060710e-02f, 7.52581656e-02f, -3.81968506e-02f,
  -5.19535169e-02f, 7.39333080e-03f, -2.27340255e-02f, 4.98505086e-02f, 3.39663401e-02f, 1.91905163e-02f, -3.19507730e-04f, 9.47670713e-02f, -2.69698650e-02f, 7.27971941e-02f,
  9.24913660e-02f, -1.57727897e-01f, 2.35906579e-02f, 2.71836314e-02f, -1.00000173e-01f, 3.21720727e-02f, 8.56887624e-02f, 3.68323810e-02f, -7.49364421e-02f, -2.91504115e-02f,
  5.49157821e-02f, -6.59269840e-02f, -2.04053596e-02f, 8.54932368e-02f, 3.00406050e-02f, 1.08015656e-01f, 3.67357768e-02f, 4.94230986e-02f, 9.27222520e-02f, -4.12913039e-02f,
  3.78813855e-02f, 2.28591226e-02f, -2.21965369e-02f, -6.70531718e-03f, 3.07332668e-02f, 1.36890626e-02f, -4.68524918e-02f, -1.14363715e-01f, 5.73885962e-02f, -1.00558937e-01f,
  1.92272868e-02f, 9.36895162e-02f, 8.06964934e-02f, 3.54129565e-03f, 4.23017852e-02f, -2.43529789e-02f, 5.57061248e-02f, 1.13363340e-01f, 3.76388989e-02f, 5.14727607e-02f,
  4.78038266e-02f, 9.12855789e-02f, 2.65247300e-02f, 1.85043272e-02f, -4.78288950e-03f, 4.11569066e-02f, -3.16152093e-03f, 4.87070270e-02f, 1.12294272e-01f, 3.09457723e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.90839410e-01f, 4.48532373e-01f, 4.25692081e-01f, 4.95769620e-01f, -2.38173515e-01f, -4.84672010e-01f, -3.53240013e-01f, -1.87319163e-02f, 4.86902632e-02f, 4.84776944e-02f,
  -2.65286773e-01f, 4.91602182e-01f, -6.88390881e-02f, 2.25348979e-01f, -1.68539032e-01f, -3.53971608e-02f, 2.03110254e-03f, -8.00392777e-02f, 4.11649123e-02f, 1.54248968e-01f,
  1.31969213e-01f, -1.75135836e-01f, 2.75733888e-01f, -7.99727365e-02f, 1.22202411e-01f, 4.09197479e-01f, 3.02022249e-01f, -3.44324559e-02f, 3.23837847e-01f, -4.40292098e-02f,
  -1.67766213e-01f, 2.48697206e-01f, 7.32506290e-02f, 1.10413190e-02f, 6.98333010e-02f, -1.68688551e-01f, -3.38480733e-02f, -4.21479680e-02f, -1.48376534e-02f, -5.62684536e-02f,
  4.05809134e-02f, -6.92770407e-02f, 6.95182458e-02f, 5.40652052e-02f, -5.21164723e-02f, 1.01699851e-01f, 6.15601577e-02f, -1.34358574e-02f, 1.79675251e-01f, 7.23886304e-03f,
  4.92982604e-02f, 1.73829217e-02f, 5.88531122e-02f, 2.87473977e-01f, 1.45908907e-01f, 7.10479124e-03f, -2.21605450e-02f, 9.20301676e-02f, 9.18240026e-02f, 2.09085587e-02f,
  2.97827981e-02f, -9.30405781e-02f, -1.08228527e-01f, -1.22352891e-01f, 3.99215631e-02f, -1.72859896e-02f, -4.62702662e-02f, -3.09802946e-02f, 2.54833642e-02f, 1.21244201e-02f,
  -1.38302028e-01f, -8.78849179e-02f, -1.20392144e-01f, -1.30886301e-01f, 1.95490308e-02f, -4.05638665e-02f, -3.09503376e-02f, 7.47670932e-03f, 1.69511810e-02f, -4.50557619e-02f,
  1.02956548e-01f, -3.64947282e-02f, 8.30250233e-03f, 4.37423922e-02f, -2.38847747e-01f, 8.42987224e-02f, 2.74805069e-01f, 2.28156652e-02f, -9.20109544e-03f, 6.13952475e-03f,
  5.30158654e-02f, 4.73347396e-01f, -3.40391658e-02f, -7.53329992e-02f, -3.81940650e-03f, -4.41083722e-02f, -4.01745550e-02f, 7.74693042e-02f, 1.07631758e-01f, -6.59211818e-03f,
  2.26750970e-02f, -5.46236038e-02f, -1.63200200e-02f, 4.59516719e-02f, 4.26621828e-03f, 7.01927440e-03f, 3.46294902e-02f, 8.27717185e-02f, 1.22030109e-01f, 2.02772185e-01f,
  1.44916708e-02f, -1.17328204e-01f, 4.39366288e-02f, -6.96214512e-02f, -2.24161334e-02f, 1.99981809e-01f, -1.19340401e-02f, -5.19477017e-02f, 6.70523718e-02f, 1.27299532e-01f,
  2.09667891e-01f, -1.93381712e-01f, -2.88177878e-01f, 7.20686913e-02f, 1.80060714e-01f, 7.74573535e-02f, -1.65110156e-01f, -1.09651312e-02f, -3.30868185e-01f, 7.10828304e-02f,
  8.29637423e-02f, -4.22148034e-02f, -2.30367884e-01f, 2.03383744e-01f, 2.47908756e-01f, -2.72204995e-01f, 3.62143159e-01f, 1.97418705e-01f, -2.33504653e-01f, 2.60800540e-01f,
  1.79608345e-01f, 4.84788805e-01f, -8.85819718e-02f, 3.64327908e-01f, 3.11371416e-01f, 8.85882452e-02f, 3.27540725e-01f, -6.79361727e-03f, 4.29708064e-01f, 2.55693227e-01f,
  -2.59172656e-02f, 1.78090651e-02f, -5.58137931e-02f, 4.89487648e-02f, 3.94817330e-02f, 9.26567800e-03f, 7.56757110e-02f, 1.22539617e-01f, -2.97075342e-02f, -7.37443864e-02f,
  7.43748099e-02f, 1.91834927e-01f, 5.03972434e-02f, -7.69192819e-03f, 8.39576647e-02f, -3.49089839e-02f, -1.71388209e-01f, -3.97952721e-02f, -1.98165566e-01f, 3.52496456e-04f,
  -1.30325422e-01f, -1.94553696e-02f, 1.29865455e-02f, -8.20017084e-02f, -8.13856348e-02f, 3.53180021e-02f, -2.88237650e-02f, -4.44446281e-02f, -7.23615214e-02f, 1.17806949e-01f,
  1.33269146e-01f, 1.28502786e-01f, 8.91135037e-02f, -3.98300104e-02f, -4.74865623e-02f, -2.52462886e-02f, 1.34284049e-01f, -9.62155461e-02f, 2.46319454e-03f, -1.48849487e-01f,
  -6.05236366e-02f, 5.87571599e-02f, -3.73547114e-02f, 1.14173114e-01f, 9.58997756e-02f, -1.15284674e-01f, -2.69069765e-02f, -2.57891160e-03f, -9.56232250e-02f, -6.52948171e-02f,
  -5.94936162e-02f, 3.41044888e-02f, -4.00142632e-02f, -2.55535077e-02f, -9.58914757e-02f, 3.60671468e-02f, 6.61136061e-02f, -8.26371182e-03f, -1.12385273e-01f, 6.95512518e-02f,
  8.72555599e-02f, 1.82016894e-01f, -1.06305577e-01f, 3.17713432e-02f, -1.51590586e-01f, 9.01447311e-02f, 1.19507648e-01f, -2.11055251e-03f, 1.55156195e-01f, 2.84459591e-02f,
  2.16406897e-01f, 7.67361000e-02f, -7.97490552e-02f, 1.35846511e-01f, -2.84595937e-02f, -6.57824567e-04f, 1.79310478e-02f, -1.79501902e-02f, -2.31370144e-02f, 5.40899262e-02f,
  6.15556352e-03f, -2.71299891e-02f, -9.83417965e-04f, -9.13875923e-02f, 4.51829284e-02f, -4.43281718e-02f, -1.39452675e-02f, 7.02017173e-02f, 4.05651219e-02f, 2.57817842e-02f,
  1.22111954e-01f, 2.72738021e-02f, -3.68677467e-01f, 8.95928219e-02f, -4.47006345e-01f, 3.76571745e-01f, 4.75104213e-01f, -1.52100250e-01f, 6.95317313e-02f, 5.26064932e-01f,
  2.38415077e-01f, -7.85739422e-02f, 4.01214927e-01f, 4.28340912e-01f, 4.73136455e-03f, 4.24343854e-01f, 2.52429724e-01f, 2.82221764e-01f, -1.80892691e-01f, 1.54175758e-01f,
  -5.44662215e-02f, 3.51113379e-01f, -1.44014031e-01f, -1.92422286e-01f, -8.91081691e-02f, -3.12815040e-01f, -1.81072369e-01f, -3.79844099e-01f, -7.08299205e-02f, -2.59491533e-01f,
  1.96724515e-02f, 4.08068635e-02f, -1.55401394e-01f, 1.33678988e-02f, -2.21438054e-02f, 4.19450663e-02f, -1.10739209e-01f, -6.23083338e-02f, -2.13110889e-03f, 1.14369996e-01f,
  1.42513037e-01f, 1.61186576e-01f, 8.09156597e-02f, -1.60848930e-01f, -2.03786399e-02f, -1.23643801e-01f, 1.07158227e-02f, -1.08958349e-01f, -3.99490334e-02f, -7.90649578e-02f,
  -1.36126494e-02f, 3.58213075e-02f, 4.58046086e-02f, 1.28822371e-01f, -1.73287272e-01f, 9.11611542e-02f, 1.02029890e-01f, -1.13461316e-01f, 6.33640885e-02f, -3.95261496e-02f,
  -4.14972194e-02f, 1.44457012e-01f, 8.79189521e-02f, 6.95556700e-02f, -7.76984319e-02f, 1.06930202e-02f, 4.35718335e-02f, 8.41898322e-02f, -2.44521499e-02f, 3.19061354e-02f,
  6.33822680e-02f, -8.03626701e-02f, -3.60707529e-02f, 5.92841394e-02f, 2.00630128e-01f, 1.35683760e-01f, -6.30100891e-02f, -1.11271918e-01f, -1.31714689e-02f, -1.29811570e-01f,
  -7.75628537e-03f, 1.07067272e-01f, 3.34742479e-02f, -8.55096243e-03f, 2.60605346e-02f, -6.55421987e-02f, 9.85253900e-02f, 7.44206691e-03f, 1.25742117e-02f, -5.70056885e-02f,
  4.58076522e-02f, 1.19076751e-01f, 1.59408022e-02f, 1.46294208e-02f, -1.14936501e-01f, 3.30087007e-03f, 4.61152233e-02f, -9.02033299e-02f, -2.86234599e-02f, 2.02534989e-01f,
  6.52620867e-02f, 2.23800614e-01f, -9.48364660e-03f, -1.40322462e-01f, -5.16631790e-02f, 7.65812397e-02f, 2.14544773e-01f, -1.78835616e-02f, -1.17030106e-01f, -2.01691493e-01f,
  -9.31584015e-02f, 1.67370826e-01f, 1.32152349e-01f, 1.82853378e-02f, 1.03876693e-02f, 1.14645064e-02f, -2.29272116e-02f, -3.83723788e-02f, -6.48351237e-02f, 6.36413991e-02f,
  -1.87418401e-01f, -7.09228590e-03f, -1.82668343e-02f, -3.88250649e-01f, 2.31046155e-01f, 2.53383398e-01f, -5.80510236e-02f, 1.21761620e-01f, -3.48295391e-01f, 3.23812515e-01f,
  -1.71410829e-01f, -7.49418437e-02f, -8.97508785e-02f, -4.11525518e-01f, -6.40840888e-01f, -5.45098901e-01f, -2.12005779e-01f, -2.05064476e-01f, -2.87955523e-01f, 7.56505728e-02f,
  -1.38975848e-02f, -3.49253744e-01f, -1.97254360e-01f, 2.50797331e-01f, 1.34980187e-01f, 3.96786213e-01f, 2.73461461e-01f, 3.80743220e-02f, 2.48719648e-01f, -9.19056535e-02f,
  -1.81613803e-01f, -3.05756122e-01f, -2.30078902e-02f, 2.29178146e-02f, 8.92282575e-02f, 1.11963525e-01f, 1.51478291e-01f, 3.93230058e-02f, -8.28893855e-02f, -4.11716700e-02f,
  8.68082568e-02f, 4.56070714e-02f, -3.55272437e-04f, -2.03537457e-02f, -1.30096808e-01f, -3.29958498e-02f, -1.11485362e-01f, 2.02756315e-01f, 6.42584190e-02f, -1.03064306e-01f,
  -6.21311404e-02f, 3.85916419e-02f, 2.51262803e-02f, 2.04424895e-02f, 4.02357355e-02f, -8.24424624e-02f, 9.92034823e-02f, 2.09324732e-01f, 1.28616363e-01f, 5.23432381e-02f,
  -6.48571551e-02f, 5.48235029e-02f, 1.04183995e-03f, -2.87975799e-02f, -6.65387288e-02f, -6.08883761e-02f, 1.63927376e-02f, 4.74424511e-02f, 1.07871227e-01f, -2.60765254e-02f,
  -2.06436985e-03f, -3.30590643e-02f, -1.20130703e-01f, 2.42924660e-01f, 6.88906983e-02f, 1.74234714e-02f, 1.47351399e-01f, 9.92661938e-02f, 7.35981241e-02f, 4.53113429e-02f,
  -2.37263087e-02f, 7.92450160e-02f, -6.21767230e-02f, 2.84511484e-02f, -1.48104712e-01f, -1.10956542e-01f, 8.55988860e-02f, 6.50453120e-02f, -1.04176790e-01f, 5.86233363e-02f,
  7.56759048e-02f, 4.26052362e-02f, -1.20136021e-02f, -1.34391993e-01f, -4.91552539e-02f, -1.05342446e-02f, 4.42430303e-02f, 1.52848721e-01f, -1.82379615e-02f, -6.17980286e-02f,
  2.10167229e-01f, 1.35397539e-01f, 1.40734658e-01f, -1.20699920e-01f, -1.15307584e-01f, 3.11314054e-02f, 6.20771125e-02f, 6.91499487e-02f, 1.69634745e-01f, -1.51613802e-02f,
  1.10779576e-01f, 2.98610162e-02f, -6.48718700e-02f, 1.21234007e-01f, 5.85520007e-02f, 8.57540071e-02f, 6.63798004e-02f, 9.33314562e-02f, -3.27285118e-02f, 4.79377285e-02f,
  3.62535715e-01f, -5.24734199e-01f, 2.48292863e-01f, 4.00349766e-01f, 3.24678868e-01f, 3.00445538e-02f, 2.35559583e-01f, -1.08100705e-01f, 2.06133369e-02f, -3.45449656e-01f,
  1.34545088e-01f, 9.85137820e-02f, -1.53762862e-01f, -1.47481769e-01f, 2.17524186e-01f, -2.65757471e-01f, 1.68183267e-01f, 2.21384630e-01f, -6.70254901e-02f, 1.94967180e-01f,
  9.82877687e-02f, -2.82040417e-01f, -3.41206305e-02f, -2.56868988e-01f, 1.94182560e-01f, -7.08414242e-02f, -2.87697534e-03f, 2.20390320e-01f, -7.55678415e-02f, -1.16940057e-02f,
  6.22959957e-02f, -1.64907649e-01f, -7.07616806e-02f, -3.64532694e-02f, -2.46162582e-02f, -6.33659959e-02f, 2.41212212e-02f, 3.29641961e-02f, 1.76057622e-01f, -1.95744969e-02f,
  7.48704970e-02f, 2.72929259e-02f, -1.12544447e-01f, 1.47448301e-01f, 2.33235918e-02f, 6.85402676e-02f, -7.91448634e-03f, 1.55312940e-01f, -1.46173760e-01f, -5.48894070e-02f,
  -3.32252234e-02f, 1.69829011e-01f, 1.14698246e-01f, 5.49928620e-02f, 3.92235033e-02f, 1.47859724e-02f, -2.78488379e-02f, 6.24701902e-02f, 8.02616868e-03f, -4.75287624e-03f,
  -1.39939010e-01f, -1.06779985e-01f, 1.92789510e-02f, 4.08708490e-02f, 1.00560643e-01f, -3.13895755e-02f, 9.29108337e-02f, 5.14715910e-03f, 2.27321327e-01f, 1.24383681e-01f,
  1.04774840e-01f, -3.58933359e-02f, 3.84441502e-02f, 1.75807420e-02f, -8.32643136e-02f, -7.70511553e-02f, 2.04453647e-01f, 2.58326661e-02f, -5.81683554e-02f, 1.84347655e-03f,
  -4.48893569e-02f, 1.07032463e-01f, 5.15258051e-02f, 3.35186794e-02f, -4.91431989e-02f, 1.06655076e-01f, -9.03086886e-02f, 1.80188119e-01f, 3.00700180e-02f, -6.00703107e-03f,
  2.78573912e-02f, -5.32334387e-01f, -1.96450248e-01f, 1.19111069e-01f, -2.79786028e-02f, 5.94452433e-02f, 1.01691494e-02f, -4.98749837e-02f, 3.32175270e-02f, -1.02591388e-01f,
  2.79008672e-02f, 1.55257002e-01f, -8.08996148e-04f, 2.05015674e-01f, -3.89083028e-02f, -6.59568682e-02f, -4.73193899e-02f, 4.40539569e-02f, -4.65457216e-02f, -2.42041331e-02f,
  6.87225983e-02f, 1.19404867e-01f, -1.67939346e-02f, 4.24773879e-02f, -1.35005778e-02f, 9.54899564e-03f, -9.07883197e-02f, 8.44236985e-02f, 6.97698891e-02f, -9.93072242e-03f,
  -1.45061519e-02f, 2.05247983e-01f, -4.06460017e-02f, 3.09943825e-01f, -9.31496322e-02f, -1.72505558e-01f, -5.59015572e-02f, 1.76261336e-01f, -1.27925470e-01f, 2.31514364e-01f,
  4.25712734e-01f, -4.28858176e-02f, 3.34828556e-01f, 4.79532450e-01f, 7.51478523e-02f, 3.17163080e-01f, 2.76791900e-01f, 1.28458217e-01f, 9.75529838e-04f, 1.89226210e-01f,
  1.29367247e-01f, 1.62162662e-01f, 4.11893308e-01f, 5.09195104e-02f, 1.52204767e-01f, 1.16362035e-01f, 2.48450741e-01f, 6.36448860e-02f, 2.37894535e-01f, -5.28653935e-02f,
  5.55285178e-02f, 8.04437548e-02f, 1.27328662e-02f, -1.61910221e-01f, 7.45319277e-02f, 1.77862216e-02f, -1.05717285e-02f, -5.76363988e-02f, -4.29897122e-02f, 7.21100867e-02f,
  -9.52569246e-02f, -1.09943934e-01f, -7.82278255e-02f, -2.90209502e-02f, -4.84535061e-02f, 2.73840670e-02f, -1.23599589e-01f, -4.00237367e-02f, -3.66395637e-02f, 5.71600907e-02f,
  -1.57723069e-01f, 5.81126884e-02f, 6.87094256e-02f, -1.89241441e-03f, -2.82834098e-03f, 6.25077486e-02f, -2.38330588e-02f, -8.01651552e-03f, -8.45171586e-02f, 2.29311939e-02f,
  -1.92562547e-02f, 1.91324763e-02f, -7.47245103e-02f, 7.01706670e-03f, -8.88668757e-04f, 3.09774764e-02f, -1.26741678e-02f, 1.01825006e-01f, -6.14856370e-02f, 8.12775269e-02f,
  8.47524926e-02f, 7.01426864e-02f, 1.02631291e-02f, -1.07375301e-01f, -6.65302053e-02f, -3.87163684e-02f, 3.76005098e-02f, 9.98838916e-02f, -3.64009105e-02f, 1.51710972e-01f,
  -2.66279746e-02f, -1.66581292e-02f, -1.99700310e-03f, 1.59310922e-01f, 3.19146328e-02f, 8.34673047e-02f, -3.52556556e-02f, 5.79664074e-02f, 1.37573585e-01f, -1.00673035e-01f,
  2.01720651e-02f, 2.18119234e-01f, 2.53693387e-02f, -2.20011752e-02f, 2.31093466e-02f, -5.09119257e-02f, -6.08840175e-02f, -7.60944784e-02f, 1.01663489e-02f, 4.92477342e-02f,
  3.04980949e-02f, 2.38926671e-02f, -1.36134252e-01f, 2.25581019e-03f, -4.63611856e-02f, 6.37361854e-02f, 5.42221665e-02f, -3.04254405e-02f, 6.90483749e-02f, 1.90322354e-01f,
  3.10149863e-02f, -2.59421561e-02f, 4.27075475e-02f, -1.42079920e-01f, -6.90236986e-02f, 1.44662529e-01f, -1.27881706e-01f, -1.01569429e-01f, 9.01277363e-02f, 5.25008067e-02f,
  -7.11425900e-01f, 3.71798515e-01f, -1.02156147e-01f, -2.37352792e-02f, 2.41013281e-02f, -5.90090394e-01f, 5.96131310e-02f, 1.20429099e-01f, -1.85633004e-01f, 4.75051492e-01f,
  3.17880154e-01f, -1.45642579e-01f, 2.81619281e-01f, -6.98195770e-02f, -7.68090308e-01f, -1.86529845e-01f, -2.79984295e-01f, 1.94373205e-02f, -2.42543489e-01f, 1.11952968e-01f,
  -1.76257074e-01f, 1.15632012e-01f, -6.30529746e-02f, 2.33591422e-01f, 4.28986773e-02f, 5.31325676e-02f, 3.59266251e-01f, 2.30133355e-01f, 1.06319897e-01f, -1.04525894e-01f,
  -1.64742440e-01f, 1.74941421e-01f, 1.11885652e-01f, -1.16149805e-01f, -7.75801912e-02f, 6.26344904e-02f, 3.23572271e-02f, -1.05672993e-01f, -5.29388823e-02f, -2.33383328e-02f,
  9.86416824e-03f, -3.34127322e-02f, -7.63622969e-02f, 3.65228616e-02f, 2.05675457e-02f, -4.36016247e-02f, -8.12253952e-02f, -2.54401490e-02f, -2.54390445e-02f, -1.37082726e-01f,
  -3.48769277e-02f, 3.13814878e-02f, -9.47961817e-04f, -5.19114956e-02f, -1.61957115e-01f, 5.71024194e-02f, -4.60491925e-02f, 1.69553887e-02f, -9.07643288e-02f, -1.18428707e-01f,
  -1.31939262e-01f, -7.14249536e-02f, -1.96327828e-02f, 1.25508979e-01f, 1.57962851e-02f, 9.98675302e-02f, -4.64219898e-02f, 4.82753105e-02f, -4.52317037e-02f, -2.74267816e-03f,
  1.67652480e-02f, -6.20351657e-02f, 1.14467099e-01f, -8.33154172e-02f, -2.86921971e-02f, -6.96260948e-03f, 9.03848335e-02f, -4.14752401e-02f, -1.13348559e-01f, -5.20437881e-02f,
  1.13493912e-01f, -4.35135067e-02f, 1.32444963e-01f, 7.31562302e-02f, -2.56675761e-02f, -1.37899490e-03f, -1.31475776e-02f, -2.85967737e-02f, 1.00303575e-01f, 1.11758811e-02f,
  1.71166956e-02f, 1.59249708e-01f, 4.95688319e-02f, 8.76488090e-02f, -2.51547098e-02f, -3.61686610e-02f, -1.24015607e-01f, -7.98462927e-02f, -5.76843508e-02f, -3.80091183e-02f,
  1.03375822e-01f, 1.13069698e-01f, -1.12622112e-01f, -2.91760955e-02f, 4.84801503e-03f, 1.95761258e-03f, 1.12208374e-01f, 4.44105007e-02f, 2.09126398e-02f, 4.57694270e-02f,
  1.65221944e-01f, 4.90954407e-02f, -4.64400984e-02f, 5.38987629e-02f, 1.16234357e-02f, 8.26836899e-02f, -1.26335263e-01f, 3.25445980e-02f, 5.12585193e-02f, 1.99525431e-02f,
  4.46447544e-03f, -1.12834997e-01f, -2.80552357e-01f, -1.37720061e-02f, 1.45081267e-01f, 1.18522532e-01f, -4.37239885e-01f, 2.21353486e-01f, -4.84185845e-01f, -2.03743190e-01f,
  7.89503530e-02f, -1.37711421e-01f, -2.46649399e-01f, 3.60491782e-01f, 4.23861265e-01f, -2.69348502e-01f, 3.50218654e-01f, 3.08259070e-01f, 1.12182066e-01f, 1.91627234e-01f,
  2.66817898e-01f, 4.41193372e-01f, 3.05062652e-01f, 5.94261467e-01f, 1.88466519e-01f, 3.72972608e-01f, 2.79452294e-01f, 1.36344537e-01f, 5.62271059e-01f, 2.18039036e-01f,
  -3.95316482e-02f, -4.19567116e-02f, -5.47014326e-02f, -1.18852280e-01f, 1.17514826e-01f, 3.63831818e-02f, 3.81193793e-04f, 1.66493863e-01f, 1.43447490e-02f, 2.69380137e-02f,
  -4.81443442e-02f, 1.42228663e-01f, 4.48839329e-02f, -3.11216190e-02f, 6.25294447e-02f, -2.02919766e-02f, 9.40803438e-04f, -1.19602397e-01f, -2.91121304e-02f, 2.36724429e-02f,
  -3.88208888e-02f, -1.01080224e-01f, -1.21493578e-01f, -4.14478406e-02f, 6.62703365e-02f, -1.57233234e-02f, -3.34917754e-02f, -1.02660090e-01f, 1.80280060e-02f, -1.82944089e-02f,
  1.78581327e-01f, -1.01050131e-01f, -1.12550221e-01f, -1.33036956e-01f, 4.33243141e-02f, -7.08874688e-02f, 1.12887397e-01f, 8.71359706e-02f, 9.17136203e-03f, -9.34640467e-02f,
  -9.61183235e-02f, 5.99061809e-02f, -7.64571577e-02f, 6.96416199e-02f, 1.08807743e-01f, -3.06368917e-02f, 5.73777361e-04f, 2.58471698e-01f, -5.84206209e-02f, 5.25062531e-02f,
  -1.06679350e-01f, 1.43632025e-01f, -1.83327973e-01f, 1.49613069e-02f, -2.99711563e-02f, -1.05621144e-01f, -7.96824470e-02f, -1.27637470e-02f, -1.26417987e-02f, 6.90361019e-04f,
  1.14543244e-01f, 2.29648858e-01f, -3.38311726e-03f, 8.84048175e-04f, 1.02137253e-02f, 6.13370053e-02f, 4.75176908e-02f, 1.91959336e-01f, 5.24909161e-02f, -4.97321598e-02f,
  2.59473976e-02f, 7.41956979e-02f, -1.47119164e-01f, 3.74470092e-02f, 9.80419517e-02f, -7.22993910e-02f, 4.62433547e-02f, -5.57108223e-02f, 4.42586988e-02f, 2.05240563e-01f,
  -2.07233969e-02f, -3.14387791e-02f, -8.86644721e-02f, 3.13413516e-02f, 9.43438187e-02f, -1.55331001e-01f, 7.43609667e-02f, -8.28053504e-02f, 1.05581380e-01f, 3.86288390e-02f,
  4.76012439e-01f, -2.42738035e-02f, -2.99100488e-01f, -2.33101144e-01f, 2.05028027e-01f, 3.48558515e-01f, -4.21795212e-02f, -2.24925950e-02f, -2.34036639e-01f, 2.12840468e-01f,
  1.94974542e-01f, -1.83690444e-01f, -1.46219432e-01f, 3.02502196e-02f, 1.65524781e-01f, -1.68188870e-01f, 1.20105356e-01f, -3.14799771e-02f, -1.03683256e-01f, 1.87334642e-01f,
  2.43173018e-02f, 5.31318963e-01f, -3.72780502e-01f, 1.72126457e-01f, 1.94526806e-01f, -1.90315574e-01f, -3.22538465e-02f, -9.48742181e-02f, 2.91360915e-02f, 1.32578919e-02f,
  -1.04384750e-01f, -8.18946026e-03f, -9.44506377e-02f, -8.26946869e-02f, 1.19727656e-01f, 1.32332578e-01f, -8.71166810e-02f, 4.54824455e-02f, -9.66885537e-02f, -3.35650519e-02f,
  -2.90050805e-02f, 3.66072506e-02f, -9.31112096e-03f, -1.22771084e-01f, 1.17204443e-01f, 2.45105475e-02f, -6.11373484e-02f, -1.61895365e-01f, -8.93703029e-02f, 1.64529607e-01f,
  4.56907898e-02f, 2.40602177e-02f, -5.85608482e-02f, -1.46878883e-01f, 5.75875863e-03f, 2.76070982e-02f, -1.19391575e-01f, -6.23277947e-02f, 2.93625542e-03f, 4.84254621e-02f,
  5.35252504e-02f, 4.38598469e-02f, 1.26740754e-01f, -1.39834061e-01f, 5.95459193e-02f, 8.40402022e-03f, -1.61646120e-02f, -9.14771035e-02f, -9.29471776e-02f, 6.02325052e-02f,
  1.32721220e-03f, 3.49976532e-02f, 4.37882170e-02f, 7.34575316e-02f, 1.33906677e-01f, -7.06495112e-03f, 2.37749685e-02f, -6.83662221e-02f, -5.39232278e-03f, -4.16431427e-02f,
  -1.88067868e-01f, 1.25113592e-01f, 1.30419779e-04f, -7.53273517e-02f, -4.87494878e-02f, -1.44857098e-03f, 1.60111666e-01f, 6.36286009e-03f, -1.21355407e-01f, -2.31128987e-02f,
  2.55337451e-02f, 1.66997716e-01f, -5.36526032e-02f, -8.04108828e-02f, -4.43646237e-02f, 2.29167491e-01f, -9.32399631e-02f, 4.07420620e-02f, -4.48780991e-02f, 1.55288965e-01f,
  2.15014040e-01f, -1.23678647e-01f, 5.85767440e-02f, 3.08186822e-02f, -1.77944511e-01f, 2.30229542e-01f, -6.06640913e-02f, -1.16410866e-01f, -1.30031765e-01f, 2.87773460e-02f,
  1.72194943e-01f, 1.40492529e-01f, -4.30459380e-02f, -4.07907963e-02f, 1.24394316e-02f, 3.50282192e-02f, -3.56120542e-02f, 1.55362068e-02f, 1.70835853e-01f, -1.20714679e-01f,
  2.20301807e-01f, -3.70940924e-01f, -3.12866978e-02f, -9.46632028e-02f, -1.13039911e-01f, -2.29400814e-01f, 2.58013904e-02f, -3.30703914e-01f, -4.54777032e-02f, -1.45783737e-01f,
  -1.19271062e-01f, 2.13848159e-01f, 3.43645006e-01f, -3.06208342e-01f, 4.75808829e-01f, 2.39410520e-01f, -3.74863714e-01f, 3.96455601e-02f, 7.91061521e-02f, -2.51643598e-01f,
  -7.95008317e-02f, -3.76491785e-01f, 1.64188027e-01f, -4.00258452e-01f, -3.41737956e-01f, -2.09290490e-01f, 5.83713800e-02f, 1.50880307e-01f, -2.56496280e-01f, 1.15097173e-01f,
  -3.07408541e-01f, -3.32610458e-01f, -1.25450149e-01f, 3.28317210e-02f, -1.59000680e-01f, 3.03382780e-02f, 1.76642939e-01f, 2.22662330e-01f, 3.33507396e-02f, 1.48005448e-02f,
  1.38949007e-01f, 3.29586975e-02f, -4.27584127e-02f, 1.57439739e-01f, -5.52603751e-02f, -1.04392610e-01f, -6.42402396e-02f, -2.38221914e-01f, -4.06184867e-02f, 7.63113573e-02f,
  2.12928597e-02f, -6.90999404e-02f, -4.44645174e-02f, -1.54789360e-02f, 7.57729337e-02f, -9.96383503e-02f, 6.75399825e-02f, 1.60696775e-01f, -9.25385114e-03f, -1.08856790e-01f,
  5.42480797e-02f, -6.30554035e-02f, 5.88232279e-02f, -1.23166954e-02f, -5.02910577e-02f, -1.02939911e-01f, -6.17017644e-03f, 1.12994365e-01f, 7.79152289e-02f, -5.14378212e-02f,
  -5.28032221e-02f, 5.81396595e-02f, -2.66001523e-02f, -1.50717096e-02f, -4.64844033e-02f, 2.55671591e-02f, 3.90915200e-02f, -1.01570725e-01f, -7.74196312e-02f, -5.61426990e-02f,
  3.23936269e-02f, 4.27612057e-03f, -1.25655621e-01f, 2.13438682e-02f, -6.07739910e-02f, 1.30474091e-01f, -7.80751929e-02f, -9.20417458e-02f, 7.24726915e-02f, 1.51872456e-01f,
  -2.36782044e-01f, -3.00085425e-01f, -2.64163800e-02f, -9.42618474e-02f, -7.31664374e-02f, 2.32862420e-02f, -1.52138239e-02f, -1.59726769e-01f, -6.57228231e-02f, -4.30581234e-02f,
  -1.07856788e-01f, -2.08152812e-02f, 6.09646328e-02f, 3.05357091e-02f, 4.94191907e-02f, -3.21361311e-02f, 5.63873723e-02f, 1.42888930e-02f, -6.62041977e-02f, -1.50481597e-01f,
  3.67982909e-02f, 1.36157662e-01f, 2.40293425e-02f, -7.10185021e-02f, 8.44115913e-02f, -7.24100843e-02f, -7.71603659e-02f, 4.63422760e-02f, 6.14515096e-02f, -3.64679210e-02f,
  -3.91626917e-02f, -1.28879115e-01f, -3.92790198e-01f, -8.34421515e-02f, -1.53329030e-01f, 9.21755284e-02f, 1.07241310e-01f, -2.47598797e-01f, -2.59385794e-01f, 3.60965163e-01f,
  2.61973709e-01f, -1.16033800e-01f, 1.52944908e-01f, 3.57610047e-01f, -8.20892751e-02f, 3.06259066e-01f, 2.42085367e-01f, 3.58045638e-01f, -1.12139717e-01f, 3.85612026e-02f,
  3.09981871e-02f, 3.80667120e-01f, 2.35344321e-01f, 2.08375249e-02f, 1.32728696e-01f, -2.20502406e-01f, 1.56736076e-01f, -1.96021959e-01f, 2.43236423e-01f, 1.59798145e-01f,
  9.59446728e-02f, -6.29685298e-02f, -7.31949508e-02f, -3.98019888e-02f, 3.54108587e-02f, 1.01605421e-02f, 6.74537644e-02f, -1.32274441e-02f, -1.37539506e-01f, -4.48115468e-02f,
  -4.70662266e-02f, 5.13575925e-03f, -1.58077836e-01f, -8.26874524e-02f, -1.20859660e-01f, -1.63125426e-01f, -4.87827137e-02f, -4.65994030e-02f, -6.05891198e-02f, -1.89911444e-02f,
  -1.80502400e-01f, 1.36724021e-02f, -7.39188865e-02f, 3.11224628e-02f, -7.69313350e-02f, 4.86701392e-02f, -4.51210923e-02f, -1.24950819e-02f, -2.31599305e-02f, -3.53876427e-02f,
  -4.00273092e-02f, 1.18246555e-01f, 1.51338307e-02f, 3.08954585e-02f, -6.89519569e-02f, 6.30944893e-02f, 4.30074595e-02f, 3.20110582e-02f, -1.11811191e-01f, 6.90331310e-02f,
  6.60079047e-02f, -1.36067137e-01f, 8.76762643e-02f, 1.13039848e-03f, -5.41893169e-02f, 3.02364267e-02f, -2.29785163e-02f, -1.70185007e-02f, 1.35107175e-03f, 3.84504125e-02f,
  5.26764244e-02f, -2.45345645e-02f, 3.62951197e-02f, 1.79335952e-01f, 8.79981518e-02f, 5.37157641e-04f, 1.16925709e-01f, -4.66120802e-02f, 8.82767886e-02f, -6.53308630e-02f,
  -3.78549914e-03f, -1.20051146e-01f, -7.35512301e-02f, -8.04396272e-02f, 8.69588628e-02f, -4.20091935e-02f, 2.53541488e-02f, -1.67324305e-01f, -1.15216725e-01f, -8.71166140e-02f,
  4.34999429e-02f, -1.43983830e-02f, 1.54299755e-02f, -1.01172021e-02f, -2.09065914e-01f, 7.14450926e-02f, 5.59842028e-02f, 7.20323771e-02f, -4.20025550e-02f, 4.94661182e-02f,
  -7.04183709e-03f, -5.47378547e-02f, 2.46587303e-02f, 1.50738470e-02f, 3.82665657e-02f, 1.97953716e-01f, -1.94061935e-01f, -5.50256185e-02f, -6.95056990e-02f, 2.39700209e-02f,
  -4.20535415e-01f, -8.98549259e-02f, -4.59127992e-01f, 1.82768464e-01f, 2.19803885e-01f, 2.74427265e-01f, 2.83594400e-01f, 1.38249278e-01f, -1.25032052e-01f, 2.44832084e-01f,
  4.37850326e-01f, -2.27581814e-01f, -1.14069171e-01f, 4.72867966e-01f, 1.52120993e-01f, 5.00988364e-02f, 3.41837227e-01f, 2.40778714e-01f, -1.44945577e-01f, -2.80063987e-01f,
  -1.59781724e-01f, 5.02347291e-01f, -3.54349948e-02f, -6.06502220e-02f, 4.85793687e-02f, -4.34567660e-01f, 3.00483834e-02f, -3.79495680e-01f, 4.26005572e-01f, 1.53160512e-01f,
  5.87705001e-02f, -3.23750198e-01f, 5.25262132e-02f, -1.10502407e-01f, -6.12429231e-02f, -5.96606731e-02f, -8.38500336e-02f, -6.68521971e-02f, -5.36855496e-02f, -9.96023715e-02f,
  -1.19510785e-01f, -1.28740251e-01f, 1.34599343e-01f, -3.16269882e-02f, 5.07640559e-03f, 5.48642613e-02f, 1.09470107e-01f, 1.64643869e-01f, 6.41637424e-04f, -5.69310822e-02f,
  -1.49911467e-03f, 2.82834191e-02f, 1.28133833e-01f, 4.07840945e-02f, 5.80444299e-02f, 1.27421752e-01f, -6.91516791e-03f, -4.76866178e-02f, 1.10852167e-01f, 9.18072686e-02f,
  2.29651500e-02f, -9.50716287e-02f, -2.50426400e-02f, 6.40202016e-02f, 7.03425035e-02f, 1.34814218e-01f, 4.36848328e-02f, -1.19433776e-02f, -1.29635930e-01f, 4.34599146e-02f,
  4.08232026e-02f, 8.72498378e-02f, 1.36300221e-01f, -1.34834781e-01f, -6.03502523e-03f, -2.85222149e-03f, -3.73375602e-02f, 1.90686900e-02f, 5.65914623e-02f, 1.38824165e-01f,
  -1.18782714e-01f, -1.11426286e-01f, 8.16029385e-02f, 2.85926703e-02f, -3.12634259e-02f, -1.54311374e-01f, -4.19211090e-02f, -6.38524964e-02f, -1.71536840e-02f, -3.37236226e-02f,
  -8.17387551e-02f, -4.10638273e-01f, -3.02149132e-02f, 2.38926142e-01f, -3.58037017e-02f, 5.84538989e-02f, -7.71952569e-02f, -2.22870391e-02f, -1.64904758e-01f, -1.07671402e-01f,
  7.84916729e-02f, 1.85432080e-02f, -8.31473321e-02f, -1.11214099e-02f, -3.09684337e-03f, 5.23939393e-02f, -1.45251602e-01f, 9.55030322e-03f, 2.41518006e-01f, 5.40822111e-02f,
  2.18186658e-02f, -4.20183986e-02f, -5.33457920e-02f, 5.69920875e-02f, 1.83255374e-01f, 6.05272874e-02f, -5.47777452e-02f, -2.91618705e-03f, 9.90825966e-02f, -4.45584133e-02f,
  -1.67230204e-01f, -1.73740178e-01f, 4.66262996e-01f, -2.77311653e-01f, 8.52847472e-02f, 4.41589922e-01f, 4.93538916e-01f, -2.97066629e-01f, -3.08000118e-01f, -2.20255405e-01f,
  -8.96887556e-02f, -7.67056271e-02f, 4.53079283e-01f, -3.69171143e-01f, 5.91084898e-01f, 2.43077025e-01f, -1.09415352e-01f, 5.19550405e-02f, -1.32619590e-01f, -3.29834759e-01f,
  -1.08936511e-01f, -3.56110901e-01f, 2.13350251e-01f, -4.05717909e-01f, -1.83120102e-01f, -2.74097711e-01f, -1.11164048e-01f, 2.20269844e-01f, -7.33287409e-02f, 1.97238505e-01f,
  -1.58110246e-01f, -4.70740438e-01f, -1.11344285e-01f, -7.75544271e-02f, -9.44047794e-02f, 9.43584591e-02f, 6.36726711e-03f, 2.03664973e-01f, -9.83875804e-03f, -1.05139967e-02f,
  4.52696998e-03f, -8.97995979e-02f, -1.49452716e-01f, 8.81990418e-02f, -8.97508487e-02f, -5.85622434e-03f, -8.86622965e-02f, -8.73164684e-02f, 1.11251101e-02f, -2.78156176e-02f,
  3.67940292e-02f, 6.38157353e-02f, -3.01819686e-02f, -1.92138050e-02f, 1.09219201e-01f, -3.45622376e-02f, 7.43285343e-02f, 8.22767913e-02f, 7.93806929e-03f, -1.32158129e-02f,
  -7.28955865e-02f, 4.45783623e-02f, 4.44072224e-02f, -3.91374603e-02f, -7.18300696e-03f, -3.07358857e-02f, -5.99347579e-04f, -1.91792212e-02f, 7.41722360e-02f, -9.30360779e-02f,
  -1.10345937e-01f, -7.94315115e-02f, -3.18714306e-02f, -1.50023988e-02f, -3.33489329e-02f, -1.19962759e-01f, 1.26214042e-01f, -4.93064635e-02f, -4.69878539e-02f, -5.08125685e-02f,
  -1.83570795e-02f, 5.94674796e-02f, 1.25132836e-02f, 5.48398308e-02f, 6.42532706e-02f, 1.12379357e-01f, -2.08824664e-01f, 1.07762232e-01f, -1.11061655e-01f, 1.61044940e-01f,
  -6.29373491e-02f, -2.55766362e-01f, -1.00343354e-01f, -1.18993007e-01f, 1.22850509e-02f, -3.88692319e-02f, -7.49027953e-02f, -3.17859799e-02f, 3.12060378e-02f, -9.58886072e-02f,
  -4.78853360e-02f, 6.21006936e-02f, 9.98501852e-02f, -6.37290701e-02f, 2.32157297e-02f, -4.52353396e-02f, 8.46161470e-02f, -2.51583662e-02f, 1.15066335e-01f, -1.05077319e-01f,
  -1.63474418e-02f, -5.18073589e-02f, 1.60706099e-02f, -1.50735617e-01f, -7.05434680e-02f, -4.47392929e-03f, -1.19536884e-01f, 3.76759954e-02f, 7.33426362e-02f, 4.34263935e-03f,
  -1.34892195e-01f, 1.88400522e-01f, -6.79430813e-02f, -3.25283147e-02f, -1.17409110e-01f, -4.96129036e-01f, -3.18890393e-01f, -8.26963317e-03f, 1.22949310e-01f, 2.49963790e-01f,
  -1.62067741e-01f, 4.35255200e-01f, -1.04494411e-02f, -2.62930661e-01f, -4.43629235e-01f, -1.16769150e-01f, -4.72455740e-01f, -3.99273224e-02f, 5.29624745e-02f, 7.20018595e-02f,
  -2.51140147e-01f, -3.19179952e-01f, -1.91412494e-01f, -9.91283208e-02f, -3.50034744e-01f, 7.95956776e-02f, -2.78553199e-02f, -2.04911932e-01f, -1.31101936e-01f, -5.98206706e-02f,
  -5.76035343e-02f, 2.08649009e-01f, 6.19122088e-02f, -2.96381935e-02f, -3.25942300e-02f, -6.20511286e-02f, -1.20768256e-01f, -5.95250279e-02f, -2.52480316e-03f, 5.21371402e-02f,
  1.94261074e-01f, -1.47121781e-02f, 6.61134794e-02f, -6.62984103e-02f, -7.76368827e-02f, 1.47477002e-03f, 1.67362049e-01f, 1.00508317e-01f, 1.01569287e-01f, 2.82181818e-02f,
  -3.46183032e-02f, 8.38445425e-02f, -1.32513404e-01f, 1.76913396e-01f, 3.13509591e-02f, 7.41521083e-03f, -2.10147202e-02f, 3.77266072e-02f, 5.86817451e-02f, -9.21807659e-04f,
  -2.42214948e-02f, -8.76853392e-02f, -4.90475744e-02f, -7.53906146e-02f, -1.00474276e-01f, 9.22290317e-04f, -1.18420638e-01f, 2.41606608e-02f, 7.13376212e-04f, 2.59802514e-03f,
  1.34066105e-01f, 4.17846479e-02f, -6.14817031e-02f, -1.13647088e-01f, 5.84488511e-02f, 4.27522361e-02f, -2.76707113e-02f, 1.10959589e-01f, 8.89108144e-03f, -8.17311779e-02f,
  9.93523449e-02f, -1.30342096e-01f, -2.74482071e-02f, 5.81024475e-02f, -1.49439842e-01f, 8.88624415e-02f, 5.52312993e-02f, -2.82342844e-02f, -2.19701063e-02f, -9.69731882e-02f,
  3.66884060e-02f, 2.31412306e-01f, 5.99226207e-02f, 2.03828245e-01f, -2.85426397e-02f, -1.21587105e-01f, -2.29546562e-01f, 2.42599230e-02f, -1.14746049e-01f, -4.02551405e-02f,
  3.06864511e-02f, -2.43494269e-02f, 8.94587338e-02f, -8.60138163e-02f, 1.05541527e-01f, -2.28768140e-01f, 2.00240258e-02f, 1.53691232e-01f, 5.00887539e-03f, 7.45662376e-02f,
  7.47028291e-02f, 4.00722027e-02f, 1.15533628e-01f, 6.30284771e-02f, 4.27751057e-02f, 1.56114832e-01f, -2.10463479e-02f, 5.79855032e-03f, -4.71972339e-02f, 5.30734025e-02f,
  5.41050732e-01f, 1.76184118e-01f, 4.24596548e-01f, 4.91216183e-01f, -1.82979271e-01f, -1.43977627e-01f, 1.16800204e-01f, 3.34613733e-02f, 4.55640823e-01f, 4.95070852e-02f,
  -2.56168276e-01f, 5.38959265e-01f, -2.60654867e-01f, 6.61505610e-02f, -1.86043620e-01f, -4.26645994e-01f, 8.19956884e-02f, 1.63771480e-01f, 3.28213200e-02f, 2.69525558e-01f,
  1.33014560e-01f, -2.77582169e-01f, -9.30345654e-02f, -1.50935993e-01f, 2.64371097e-01f, 2.26962104e-01f, -3.58375251e-01f, -2.36441448e-01f, 1.21922709e-01f, -2.60141373e-01f,
  -1.00894578e-01f, -1.13768034e-01f, -1.02614816e-02f, 9.02440175e-02f, 4.18217666e-02f, -6.42018244e-02f, -5.81120737e-02f, -1.87632903e-01f, -1.41748145e-01f, 7.70073757e-02f,
  1.24554530e-01f, 2.71425433e-02f, 2.39071362e-02f, -4.07244898e-02f, 2.34444831e-02f, 1.43325940e-01f, 1.03165954e-01f, 8.62227529e-02f, 1.52394369e-01f, 8.98937061e-02f,
  2.16744751e-01f, 1.82554841e-01f, 1.13755092e-01f, -5.34347370e-02f, 9.21811238e-02f, -2.52869390e-02f, 3.22500542e-02f, 1.00268964e-02f, 6.11492321e-02f, 5.68298139e-02f,
  -2.39962369e-01f, -2.16213569e-01f, -2.72363834e-02f, 4.71559353e-02f, 7.56967962e-02f, 3.80897126e-03f, 9.59508643e-02f, -6.03213795e-02f, 1.29897162e-01f, 3.16126570e-02f,
  9.71525088e-02f, -3.53051350e-02f, -3.79113220e-02f, 1.14621431e-01f, 6.81490675e-02f, 1.17740482e-01f, 1.19026555e-02f, 5.78769762e-03f, 1.16179794e-01f, 1.66460052e-02f,
  -9.17725265e-02f, -1.88377090e-02f, 1.32824481e-01f, 3.10110627e-03f, 1.21138878e-02f, 7.66020119e-02f, 2.32266709e-02f, 2.50734121e-01f, -2.69325823e-02f, 2.54982505e-02f,
  -6.55661002e-02f, -1.37862608e-01f, 6.88710511e-02f, -3.13796476e-02f, -2.28969958e-02f, 3.55486423e-02f, -2.66679097e-02f, 1.68300569e-01f, 4.14292477e-02f, -4.42965794e-03f,
  -7.78907835e-02f, 1.38568923e-01f, 1.36360889e-02f, -1.03997029e-01f, -2.75911372e-02f, 2.66196951e-02f, -4.84929234e-03f, -1.42179012e-01f, -6.97125569e-02f, -5.84401414e-02f,
  1.11488113e-02f, 3.73950750e-02f, 1.36122495e-01f, 6.38884977e-02f, 7.39789605e-02f, -1.90168232e-01f, 1.77257843e-02f, -1.78568009e-02f, -3.22056189e-02f, -4.83146496e-02f,
  -2.49750048e-01f, -3.21190447e-01f, -2.96246767e-01f, -2.00423375e-02f, 2.30753258e-01f, -4.01953422e-02f, -6.03924021e-02f, 2.84649432e-01f, 1.78552810e-02f, -9.82482135e-02f,
  -2.31431872e-01f, -5.16609550e-01f, -2.40853488e-01f, -3.04416925e-01f, -4.21018451e-01f, -4.16683644e-01f, -3.49782318e-01f, -3.60024124e-01f, -9.29235760e-03f, -3.53941709e-01f,
  -6.56041726e-02f, 2.25162789e-01f, -8.30416456e-02f, 4.66126204e-01f, 1.99992687e-01f, 2.38217264e-01f, 1.87784284e-01f, 1.87015638e-01f, 7.53153935e-02f, 1.09086029e-01f,
  -2.32286930e-01f, 2.49686670e-02f, 9.90560874e-02f, 1.71685785e-01f, -2.90992036e-02f, 6.32806495e-02f, -1.48749826e-02f, -1.18276086e-02f, -6.63715973e-02f, 2.75008138e-02f,
  -6.88337609e-02f, 3.93098406e-02f, 1.70195535e-01f, 8.42055082e-02f, 1.66846499e-01f, -5.87412380e-02f, -4.12747301e-02f, 1.47641338e-02f, 3.10241301e-02f, -9.13952440e-02f,
  -8.18343014e-02f, -6.35797456e-02f, -8.77161101e-02f, -1.29498795e-01f, -4.46265079e-02f, 5.11078276e-02f, 5.94892353e-02f, -3.91083956e-02f, -3.10325865e-02f, 8.83853287e-02f,
  1.24737233e-01f, 5.13347387e-02f, -7.41183907e-02f, 1.53773695e-01f, -1.06068552e-01f, 1.15269072e-01f, -3.98019627e-02f, -4.71844152e-02f, 5.63473590e-02f, -1.04853354e-01f,
  1.17820324e-02f, 3.21449898e-02f, -2.08487418e-02f, 3.99479177e-03f, -2.33839583e-02f, 2.42420405e-01f, -1.27758712e-01f, 4.88779247e-02f, 7.69771188e-02f, -7.65902922e-02f,
  9.97967925e-03f, -1.17375314e-01f, 9.42351297e-02f, 2.51358543e-02f, -1.35052249e-01f, 8.48972350e-02f, -1.07470490e-02f, -8.35458934e-02f, -6.05807491e-02f, 9.45630372e-02f,
  -3.85384232e-01f, -2.12613851e-01f, -2.31894478e-02f, -2.41185967e-02f, -1.17878951e-01f, 8.08212347e-03f, -1.49943963e-01f, 1.01782441e-01f, -5.53376190e-02f, -7.63154626e-02f,
  -2.80339662e-02f, 1.30020762e-02f, -6.77111279e-03f, -1.52327806e-01f, -9.43215042e-02f, -1.15632145e-02f, 2.00299211e-02f, 1.28304667e-03f, 1.50964111e-01f, 2.34834049e-02f,
  -5.63482149e-03f, -1.09060723e-02f, 1.49780028e-02f, 8.18134397e-02f, 7.82051757e-02f, 9.46005899e-03f, -9.92764533e-02f, -8.93376097e-02f, 6.92502782e-02f, 4.39920910e-02f,
  -1.58093214e-01f, 1.77113920e-01f, 2.16492161e-01f, 3.72355163e-01f, 5.20022750e-01f, 5.02001107e-01f, 3.63263041e-01f, 4.09051985e-01f, 8.08347940e-01f, -6.55132085e-02f,
  -8.43835324e-02f, -7.07545653e-02f, -2.15468660e-01f, 8.13802779e-02f, 8.97283331e-02f, 2.56037921e-01f, 3.63433838e-01f, 2.96650231e-01f, 2.34299943e-01f, -9.46626887e-02f,
  1.76619172e-01f, -1.81317376e-03f, -2.67080247e-01f, -2.09422871e-01f, -1.37926027e-01f, -5.75730354e-02f, -4.09723669e-01f, 3.57274562e-02f, -2.77486503e-01f, 2.04658702e-01f,
  -9.74460989e-02f, 3.01906168e-02f, -2.23367691e-01f, -6.08121604e-02f, -1.47249952e-01f, -5.45618571e-02f, -3.66664231e-02f, -2.74765361e-02f, -1.10446639e-01f, 1.29318452e-02f,
  -5.39046340e-02f, -5.79839684e-02f, 9.88350529e-03f, 4.25002165e-02f, 1.37490153e-01f, -5.13741970e-02f, -2.36654915e-02f, 7.69817233e-02f, -4.24682684e-02f, -9.28511918e-02f,
  -1.14275500e-01f, 4.67165448e-02f, 3.52844894e-02f, 1.60659790e-01f, 5.97126409e-02f, 1.56655431e-01f, 5.66016808e-02f, -2.80382205e-02f, 8.53944793e-02f, 1.62505090e-01f,
  3.56331542e-02f, 1.25911042e-01f, -9.77456421e-02f, -9.40363556e-02f, -6.68995976e-02f, -6.91822311e-03f, -7.64337648e-03f, -1.45587072e-01f, -1.73869170e-02f, -9.01752040e-02f,
  6.96504787e-02f, -4.83222492e-02f, 1.17267564e-01f, -3.51861417e-02f, 1.68053135e-02f, 1.17593235e-03f, 2.99877138e-03f, 3.75699326e-02f, 8.64253715e-02f, 2.24805791e-02f,
  1.07748315e-01f, -1.27060013e-02f, -7.46994168e-02f, 9.95223224e-02f, -1.63581781e-02f, -9.26314592e-02f, 6.42135590e-02f, -2.66837049e-02f, 7.55051523e-02f, -5.45054078e-02f,
  3.12106967e-01f, 3.33918303e-01f, -3.44866440e-02f, -6.06765188e-02f, -6.65417537e-02f, -7.90161416e-02f, 1.10022411e-01f, 3.54688577e-02f, 2.06896842e-01f, 3.39937173e-02f,
  3.03932689e-02f, -1.03352889e-01f, -2.84034088e-02f, 8.35155603e-03f, 3.56425494e-02f, 2.73044445e-02f, -1.11402750e-01f, 1.54755175e-01f, 1.60848945e-01f, -5.25760092e-02f,
  -1.44293368e-01f, -2.99118776e-02f, 1.68039668e-02f, -2.00695582e-02f, -5.30346967e-02f, 2.68306658e-02f, 1.08764455e-01f, -5.24950027e-02f, -3.89177166e-02f, 1.27358615e-01f,
  -9.11513925e-01f, 4.96530950e-01f, 1.19672334e-02f, -4.00444686e-01f, -1.57987550e-02f, -1.50841385e-01f, -2.58168429e-01f, 1.63116589e-01f, 2.13783700e-02f, 8.01800489e-02f,
  -1.29423022e-01f, -4.21305820e-02f, 2.89021909e-01f, -3.00328359e-02f, -1.35462269e-01f, 3.32479537e-01f, -2.90987402e-01f, -1.92306802e-01f, 9.51990038e-02f, -2.57575750e-01f,
  -4.53542136e-02f, -1.24978945e-01f, -7.90685266e-02f, 2.11003467e-01f, -1.33640125e-01f, -1.55587345e-01f, -1.04259767e-01f, 2.87322653e-03f, -1.10719793e-01f, 6.49567693e-02f,
  -4.73845243e-01f, -3.77201557e-01f, -2.70253092e-01f, -2.57301629e-01f, -2.74106205e-01f, -1.60683259e-01f, -8.28036144e-02f, 1.04090925e-02f, -1.19094186e-01f, -6.13246262e-02f,
  -3.83268557e-02f, 1.12483336e-03f, -1.23794235e-01f, -9.98537871e-04f, -1.02250025e-01f, -1.28655350e-02f, 8.95480141e-02f, 8.60172510e-03f, -5.82898334e-02f, 2.22486109e-01f,
  1.45165309e-01f, 7.34552965e-02f, -1.22504301e-01f, 4.85922173e-02f, -3.01174859e-05f, 1.98586993e-02f, -6.82774112e-02f, 4.19041067e-02f, -1.67207569e-02f, -9.31320265e-02f,
  -2.43496150e-02f, 3.35832685e-02f, -4.41547632e-02f, -1.14540383e-01f, 1.50790745e-02f, 8.60746205e-02f, -3.90506200e-02f, -2.21116915e-02f, 3.37507278e-02f, 1.13222554e-01f,
  5.49308099e-02f, -2.24783476e-02f, 3.26403044e-03f, -6.04832880e-02f, 4.94187549e-02f, -9.05746594e-03f, -5.24503961e-02f, -1.90079864e-02f, -7.67721161e-02f, -4.80156019e-02f,
  -1.49104102e-02f, -4.11448926e-02f, 8.74718577e-02f, -4.52177674e-02f, -6.96064346e-03f, -3.25279199e-02f, -5.38133420e-02f, 1.57280430e-01f, -1.47022069e-01f, -5.27514294e-02f,
  -7.10012436e-01f, -6.23777270e-01f, -1.70501098e-01f, -6.70522526e-02f, -2.59269122e-02f, -3.87896970e-02f, 1.19910397e-01f, -1.15418341e-03f, -1.51829705e-01f, -9.66737047e-02f,
  -2.82797255e-02f, 2.70556733e-02f, -1.57718584e-01f, -2.69804988e-02f, 7.67050982e-02f, -4.03319597e-02f, -1.22826099e-01f, -9.19501558e-02f, -2.61579812e-01f, 3.57225128e-02f,
  -9.67734121e-03f, 1.65255107e-02f, 8.40084553e-02f, -6.84244782e-02f, -9.22101513e-02f, -1.09890372e-01f, -7.27877989e-02f, 8.32711637e-04f, -9.85781774e-02f, 4.16614078e-02f,
  -8.58800173e-01f, 4.90318596e-01f, 4.77585465e-01f, -1.65853322e-01f, 1.15950149e-03f, 2.41631940e-01f, -4.32892442e-02f, 1.43271133e-01f, 2.78246850e-01f, 3.42238516e-01f,
  -6.13181926e-02f, -1.80623215e-02f, 1.59380913e-01f, 1.58012599e-01f, -2.45705932e-01f, 1.42576978e-01f, -3.32130976e-02f, -4.81152674e-03f, 1.61577553e-01f, -9.95150059e-02f,
  -1.51239544e-01f, -2.51378655e-01f, -1.60197560e-02f, 1.97358847e-01f, 7.95122385e-02f, -6.95005804e-02f, -2.66636163e-01f, 2.01280385e-01f, -1.18896160e-02f, 1.62478089e-01f,
  -3.35593373e-02f, 1.29766380e-02f, 5.21340147e-02f, 2.29825333e-01f, 9.89557207e-02f, -5.87771460e-02f, -3.15981023e-02f, 3.75464968e-02f, 4.88039665e-02f, 1.65213775e-02f,
  -1.15620822e-01f, 1.50678575e-01f, -1.68820009e-01f, 8.36145505e-02f, 5.28938398e-02f, 1.51386976e-01f, 9.16871503e-02f, -2.08879486e-02f, 1.31151557e-01f, 1.35531113e-01f,
  1.69695675e-01f, 1.36941656e-01f, -5.52166328e-02f, 1.72218919e-01f, 6.05730154e-02f, 1.48512781e-01f, 8.11042711e-02f, -9.53566656e-02f, 5.12484163e-02f, 9.22077894e-02f,
  -1.16754333e-02f, 5.29617257e-02f, 1.28227308e-01f, -8.52895752e-02f, 8.67835432e-02f, 1.26279160e-01f, 8.68024379e-02f, -1.97498381e-01f, 4.33812737e-02f, -1.11955084e-01f,
  -2.08822474e-01f, -2.48445533e-02f, -3.14372294e-02f, -4.40129489e-02f, -3.91354524e-02f, -2.32878719e-02f, -5.25444709e-02f, 3.35177183e-02f, -1.01588406e-01f, -5.68707399e-02f,
  8.43586284e-04f, 1.11447750e-02f, -3.52847166e-02f, -6.90089762e-02f, 1.07532345e-01f, 8.39112550e-02f, -2.96448879e-02f, 1.86536178e-01f, -4.00318131e-02f, -1.68361157e-01f,
  -1.84741318e-01f, -1.28011465e-01f, 6.66959062e-02f, 1.21533528e-01f, 1.06078438e-01f, 1.35387480e-02f, 1.09880261e-01f, -1.33587956e-01f, 3.24789099e-02f, 1.59531552e-02f,
  -1.13038138e-01f, 5.39485784e-03f, -1.07589401e-01f, -3.59303951e-02f, 5.33659151e-03f, -2.93695088e-02f, -1.33422971e-01f, -6.13447651e-02f, -7.14298412e-02f, 5.81570826e-02f,
  -1.30683640e-02f, -3.23992558e-02f, -3.95752527e-02f, -7.48386607e-02f, -7.13627785e-02f, -1.82116166e-01f, -1.52666017e-01f, 1.60373926e-01f, -4.58878204e-02f, 5.34169637e-02f,
  4.39173132e-01f, -6.24209821e-01f, 1.50957152e-01f, 5.94845474e-01f, 3.67335886e-01f, -1.98969513e-01f, 2.29695708e-01f, 1.40645549e-01f, 4.23754863e-02f, -6.58512235e-01f,
  -1.69170368e-02f, -2.71407932e-01f, -3.41002971e-01f, 2.40945384e-01f, 3.65366906e-01f, -2.19964728e-01f, 2.33833492e-01f, -1.76211998e-01f, 2.70933449e-01f, 4.89084683e-02f,
  4.07334894e-01f, 2.68996686e-01f, 2.89447755e-01f, 2.14189682e-02f, 1.16038984e-02f, 1.45873772e-02f, 5.95304556e-02f, -1.52246282e-01f, 9.12560523e-02f, 2.96789035e-02f,
  -2.40290955e-01f, 2.88078815e-01f, 1.24261633e-01f, -1.12392515e-01f, -2.95923725e-02f, -7.91770145e-02f, -1.95650421e-02f, 1.07425988e-01f, 1.16632998e-01f, -6.10096157e-02f,
  -1.49724111e-01f, 8.75842273e-02f, 6.18357286e-02f, -1.38354916e-02f, 9.84649882e-02f, -3.64551358e-02f, 1.04405418e-01f, 4.13829610e-02f, 9.96720716e-02f, 1.11816391e-01f,
  -2.53958777e-02f, -9.94599238e-02f, 1.23051323e-01f, -7.51890317e-02f, 7.93560818e-02f, 5.04423119e-02f, 1.97594203e-02f, 1.32279294e-02f, -4.74540666e-02f, 7.34404176e-02f,
  2.03532994e-01f, 3.06052640e-02f, -9.07865018e-02f, -9.57735442e-03f, 1.51718808e-02f, 2.37607025e-02f, -9.90793481e-02f, -1.55068198e-02f, -1.43278971e-01f, -8.78805071e-02f,
  -2.12469213e-02f, 9.85015482e-02f, -3.12301926e-02f, 6.30293563e-02f, 3.28453854e-02f, 1.74794212e-01f, -6.47444576e-02f, -3.97602394e-02f, -3.14537436e-02f, 1.71445999e-02f,
  7.57305743e-03f, 1.11108594e-01f, -1.18772097e-01f, -7.95618296e-02f, -7.70681575e-02f, -9.62641649e-03f, -3.96433212e-02f, -1.03248484e-01f, 1.21872231e-01f, -3.70739438e-02f,
  -7.52137721e-01f, -4.52627838e-01f, -1.27585053e-01f, -8.78105611e-02f, -1.97369933e-01f, -7.27112740e-02f, 1.41639356e-02f, 6.50633872e-03f, -1.62667304e-01f, -6.36121929e-02f,
  -9.24398825e-02f, -1.69910602e-02f, -1.29526690e-01f, -2.75622290e-02f, -3.89594734e-02f, 4.65453696e-03f, -5.46949683e-03f, -2.15522483e-01f, 5.12722321e-02f, -4.20604683e-02f,
  -3.85670476e-02f, 8.80721770e-03f, -5.87024260e-03f, 1.61791891e-01f, 3.95050459e-02f, -4.08810861e-02f, 1.63219068e-02f, -7.00970143e-02f, -4.76595014e-02f, -1.46379456e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  3.15384299e-01f, 3.24638277e-01f, 2.78733879e-01f, 3.68358374e-01f, 3.08355749e-01f, 3.25916559e-02f, 3.84134501e-01f, 4.05129254e-01f, 7.19566196e-02f, 2.86833704e-01f,
  2.39241421e-01f, 1.30633160e-01f, 3.98211300e-01f, 2.72077382e-01f, 3.69688153e-01f, 2.89580047e-01f, 3.30596447e-01f, 4.06125665e-01f, 5.29268384e-01f, 2.36385301e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.07815675e-01f, -1.29543319e-01f, 1.17670849e-01f, -1.17150217e-01f, 1.05364367e-01f, -2.40927815e-01f, -2.19848398e-02f, 4.59517241e-02f, 2.31506780e-01f, 8.84505361e-02f,
  1.42266586e-01f, 1.02883399e-01f, 2.31287137e-01f, 2.40378324e-02f, -1.37123600e-01f, 2.95675457e-01f, 2.59614065e-02f, 1.21271662e-01f, 2.08183601e-02f, 1.30429447e-01f,
  7.36579373e-02f, -2.48073176e-01f, 6.35503158e-02f, 4.43683229e-02f, -3.33714396e-01f, 1.08361565e-01f, 2.05585629e-01f, -6.57935441e-02f, -7.17659295e-02f, -2.47249261e-01f,
  -2.16287866e-01f, 2.46703606e-02f, 2.88322061e-01f, 4.47187908e-02f, 1.89806223e-01f, -2.08042050e-03f, 1.72019392e-01f, -1.30479738e-01f, 1.42849917e-02f, 2.31379330e-01f,
  9.63093862e-02f, -3.70475017e-02f, 5.45737818e-02f, 9.07719601e-03f, -1.11423969e-01f, 1.38066139e-03f, -4.00955796e-01f, 4.15072739e-01f, -3.11088539e-03f, -2.08997339e-01f,
  -1.43943042e-01f, 1.21295936e-01f, -2.99138248e-01f, 1.66556343e-01f, 1.02723828e-02f, -1.20662898e-01f, 2.17091948e-01f, 1.84793815e-01f, 1.20139748e-01f, 1.50048748e-01f,
  -2.06032827e-01f, 2.37857297e-01f, 4.96154353e-02f, -1.04579322e-01f, -2.59402711e-02f, 1.87377974e-01f, 7.69012943e-02f, 3.92595790e-02f, -9.71041694e-02f, 8.62473026e-02f,
  1.51584178e-01f, -1.29026473e-01f, 2.21002787e-01f, -1.07209636e-02f, -1.48792282e-01f, -1.94811001e-01f, -1.92195609e-01f, 1.79722220e-01f, 2.32067525e-01f, -8.18722323e-02f,
  2.40268946e-01f, 9.47628319e-02f, -2.02900186e-01f, -4.44054976e-02f, -4.31130491e-02f, 2.66959310e-01f, 1.72884271e-01f, 3.84544432e-01f, 4.29742038e-02f, -1.50639728e-01f,
  -1.47240117e-01f, 6.73178164e-03f, -3.28074768e-02f, -2.77863622e-01f, -1.87015668e-01f, -3.22866403e-02f, -1.28411531e-01f, -1.51915073e-01f, -2.53373999e-02f, -1.14422821e-01f,
  -2.03617513e-01f, 1.79937005e-01f, -5.71711585e-02f, 3.45544666e-01f, -3.31983358e-01f, -1.32448778e-01f, 1.38253672e-02f, 2.89843410e-01f, 1.64031014e-01f, 5.49069382e-02f,
  -4.67081890e-02f, -3.07968318e-01f, -5.45614539e-03f, 1.33175299e-01f, 1.22883961e-01f, 1.11342154e-01f, -2.04864964e-01f, 1.10340230e-01f, 2.32052933e-02f, 1.50294900e-01f,
  3.30854893e-01f, 1.20402232e-01f, -3.45392346e-01f, -1.17338151e-01f, -3.56590033e-01f, 3.08833301e-01f, 6.95113391e-02f, 1.38960302e-01f, 5.98448552e-02f, 4.49087694e-02f,
  2.66904254e-02f, 1.30498290e-01f, -2.30169110e-03f, -3.72039229e-02f, -1.93352371e-01f, 9.98943448e-02f, -2.33970452e-02f, -9.95780528e-02f, -5.08753695e-02f, -3.46063524e-02f,
  2.08640203e-01f, -1.85864508e-01f, -2.60676533e-01f, 5.40314615e-03f, 1.06852733e-01f, -8.39338377e-02f, 1.83303356e-01f, -6.60991203e-03f, -1.42444760e-01f, 2.14559361e-01f,
  -1.29593939e-01f, -3.72581959e-01f, 1.69104338e-01f, 2.56618679e-01f, 2.21139088e-01f, -5.43670356e-02f, -1.80517629e-01f, 1.85262695e-01f, -6.51483014e-02f, 2.49564610e-02f,
  1.88804016e-01f, -3.15431803e-02f, 8.74826871e-03f, -8.00292939e-02f, 7.03113452e-02f, 2.38922492e-01f, 2.47697175e-01f, 2.70037204e-01f, 6.51407987e-02f, -3.38874310e-01f,
  3.33265662e-01f, -3.20287436e-01f, 1.27755523e-01f, 6.76469132e-02f, 4.75936569e-02f, -1.08280048e-01f, -8.85604098e-02f, 2.37710133e-01f, 1.57553151e-01f, -1.49062216e-01f,
  -3.76498364e-02f, -5.45739643e-02f, 3.35736647e-02f, 6.24293201e-02f, 2.37238377e-01f, -1.55554295e-01f, 1.49363846e-01f, -3.22442710e-01f, 3.61723714e-02f, -1.62589118e-01f,
  3.40274796e-02f, -3.60015184e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.24682255e-01f, 5.93850054e-02f, 1.58719830e-02f, 2.03588068e-01f, 3.78624201e-02f, 5.25653958e-01f, -1.99157834e-01f, 4.09134150e-01f, -4.82865453e-01f, -4.73662972e-01f,
  4.68428433e-01f, -2.60312825e-01f, 6.45581722e-01f, -8.56457055e-02f, 1.42075971e-01f, -2.23654255e-01f, -1.90734997e-01f, 2.48534337e-01f, 5.20034373e-01f, -1.02396578e-01f,
  -3.97266477e-01f, -2.91365802e-01f, 1.21050246e-01f, -6.46774769e-02f, -2.78938399e-03f, 3.31083238e-01f, 5.70459485e-01f, -2.34043300e-01f, -8.96882117e-02f, 5.99361360e-01f,
  6.99915111e-01f, 1.04256727e-01f, 3.21267903e-01f, 3.74484390e-01f, 2.08643198e-01f, 1.45183295e-01f, 2.49095380e-01f, 8.21939856e-02f, 3.06772053e-01f, -2.60838032e-01f,
  7.24970162e-01f, -5.28066941e-02f, 1.53257251e-01f, -1.23203903e-01f, 4.63587314e-01f, 5.26399076e-01f, -8.43755975e-02f, 6.94810867e-01f, 9.98916551e-02f, -3.56757315e-04f,
  2.92015761e-01f, 4.16253179e-01f, 2.31768891e-01f, -2.06552714e-01f, 6.07827753e-02f, 1.74110103e-03f, -1.35027364e-01f, 5.72434515e-02f, 3.96511048e-01f, 3.80286537e-02f,
  3.36126298e-01f, -5.61819673e-01f, -2.38903999e-01f, -1.48632154e-01f, 3.51758271e-01f, 2.07108915e-01f, 2.91543812e-01f, 4.00143676e-02f, 3.36548269e-01f, 2.18589976e-01f,
  -7.69179091e-02f, -8.51297081e-02f, -2.97698408e-01f, 1.54337451e-01f, 4.22349125e-01f, 3.64833176e-01f, 4.15806711e-01f, 1.03439704e-01f, 2.75050133e-01f, 4.46634620e-01f,
  -3.81688029e-01f, -1.65468473e-02f, 4.36868578e-01f, 1.07854418e-01f, -2.41435356e-02f, 3.02009523e-01f, 2.28189707e-01f, -1.56149030e-01f, 1.35788202e-01f, 5.17723739e-01f,
  1.95701849e-02f, 1.51172429e-01f, 4.71800625e-01f, 5.76834917e-01f, 6.39125049e-01f, -4.42836255e-01f, 4.07388210e-01f, 4.55348194e-01f, 3.85897160e-01f, 3.67775708e-01f,
  3.29351515e-01f, 9.86724421e-02f, 2.57049888e-01f, -3.33491445e-01f, 3.83856177e-01f, 8.88707042e-02f, -1.84627011e-01f, -4.47659381e-02f, -1.53723778e-02f, 1.85515836e-01f,
  1.05616890e-01f, 6.10807598e-01f, 4.15715247e-01f, -1.33429274e-01f, 2.01543674e-01f, 1.51911452e-01f, 1.12723354e-02f, -1.85145095e-01f, -1.17646165e-01f, -1.51117980e-01f,
  -1.35052949e-01f, 2.88387183e-02f, 4.75908339e-01f, 3.91469419e-01f, 5.35278678e-01f, -5.40849626e-01f, -2.74505734e-01f, 3.05983394e-01f, 4.07221645e-01f, 1.77665174e-01f,
  1.87020540e-01f, 4.10761386e-01f, 8.00567642e-02f, 1.59708783e-01f, -6.15501776e-02f, -4.17923123e-01f, -1.41460285e-01f, -1.66771144e-01f, 2.41506491e-02f, -4.98358786e-01f,
  1.38779566e-01f, -4.48580265e-01f, 2.28474408e-01f, -2.34506633e-02f, 1.83550924e-01f, -5.14400959e-01f, 1.78937569e-01f, -6.82476640e-01f, -9.12133977e-02f, -1.04046799e-01f,
  -4.04018581e-01f, -4.08268064e-01f, -2.92568952e-01f, 4.34373409e-01f, 8.27005625e-01f, 3.83517921e-01f, 5.52316546e-01f, 2.90867090e-01f, 4.30727929e-01f, 2.93542027e-01f,
  1.52789831e-01f, 2.03933597e-01f, -4.94060628e-02f, 2.75429845e-01f, 3.18182319e-01f, -1.66739598e-01f, 2.86129385e-01f, -3.84063810e-01f, 1.47807136e-01f, 2.09540874e-01f,
  3.61035854e-01f, -3.34747314e-01f, -1.32600376e-02f, 1.83310837e-01f, 6.09236360e-01f, -3.84257257e-01f, -3.87785912e-01f, 1.09078623e-01f, -4.82985079e-01f, -2.87523791e-02f,
  3.11890632e-01f, 5.29012620e-01f, 4.87386614e-01f, 3.92383933e-01f, -6.18326999e-02f, -5.73636815e-02f, -1.43023178e-01f, -2.74162680e-01f, 6.02749825e-01f, 3.30123961e-01f,
  1.76926598e-01f, -7.46296644e-01f, 1.71648547e-01f, -1.31730050e-01f, 1.94141850e-01f, 2.70678490e-01f, 4.92235452e-01f, 4.24976051e-01f, -4.19031322e-01f, 5.32352507e-01f,
  -1.99340209e-01f, -4.00897086e-01f, -2.46391356e-01f, -8.71381983e-02f, 6.09101355e-01f, 1.37207821e-01f, -7.49969900e-01f, 2.35170648e-01f, 2.18569729e-02f, 1.89063758e-01f,
  -3.28916818e-01f, 5.08243263e-01f, -1.35778770e-01f, 3.58838648e-01f, 9.69174597e-03f, -3.42468530e-01f, 5.90512514e-01f, 4.15262282e-01f, 3.65441412e-01f, -3.68204504e-01f,
  -3.28988880e-01f, 4.69380051e-01f, 4.12279427e-01f, 1.38104185e-01f, 2.20938459e-01f, 1.11867718e-01f, 4.52325568e-02f, -3.40485632e-01f, -2.19625942e-02f, -2.28753954e-01f,
  -8.51642936e-02f, -2.65992969e-01f, -3.32171351e-01f, 4.50956345e-01f, 2.71204382e-01f, 2.02288494e-01f, 1.95710257e-01f, -1.61360905e-01f, 4.67576683e-01f, 5.37469313e-02f,
  -2.51644909e-01f, -2.50350889e-02f, 5.16777992e-01f, -3.53409410e-01f, -1.55088827e-01f, 4.57470983e-01f, 1.74252704e-01f, 1.64907381e-01f, 3.55495736e-02f, 5.21677911e-01f,
  -4.03784245e-01f, 3.80982369e-01f, -1.26077384e-01f, 4.23268646e-01f, -2.61430871e-02f, -1.41236722e-01f, -7.61038214e-02f, 1.77471817e-01f, 1.03105567e-01f, -4.40716445e-02f,
  8.39211419e-03f, 2.36459985e-01f, 1.40390351e-01f, 2.36857489e-01f, 1.57862827e-01f, -3.87411684e-01f, -4.52378504e-02f, -4.57282901e-01f, 3.75419915e-01f, 1.29171222e-01f,
  -7.05801100e-02f, -3.18295024e-02f, 6.01321518e-01f, 2.17098042e-01f, -2.11522087e-01f, 6.83474839e-02f, -1.00971699e-01f, 2.41700068e-01f, -9.33528692e-02f, 2.37814113e-01f,
  2.28827074e-01f, 1.21240996e-01f, 4.85057175e-01f, 5.13404943e-02f, -1.22127958e-01f, -4.25203025e-01f, -1.96967050e-01f, 6.57356203e-01f, 3.53807092e-01f, 6.64177686e-02f,
  7.82403052e-02f, 5.58515728e-01f, 6.44287229e-01f, 5.63264310e-01f, 6.89180568e-02f, 3.67601484e-01f, -3.49247567e-02f, -3.61251414e-01f, 1.79603830e-01f, 2.66612209e-02f,
  -3.63840580e-01f, 3.33958179e-01f, 5.56919388e-02f, -2.76593249e-02f, -1.42697409e-01f, 1.31679669e-01f, -4.00439411e-01f, 5.32452822e-01f, 3.28652978e-01f, 1.22561781e-02f,
  3.51617455e-01f, 3.57406348e-01f, 5.46415508e-01f, -4.81526822e-01f, -4.40755159e-01f, -2.95309603e-01f, 4.11043197e-01f, 1.45194665e-01f, 5.75570524e-01f, -4.50101823e-01f,
  -3.10869869e-02f, 6.63577989e-02f, 6.68238895e-03f, 3.14323418e-02f, 2.04142496e-01f, 7.54213706e-02f, 1.55899405e-01f, 9.49107409e-02f, -1.36928111e-01f, -1.36297733e-01f,
  -5.46637833e-01f, 3.46181422e-01f, 2.91155189e-01f, 3.87049824e-01f, 8.44163895e-02f, -3.90887499e-01f, 3.00384462e-01f, 4.76662368e-01f, -1.73057362e-01f, 3.56565326e-01f,
  1.54064223e-01f, 5.03976345e-01f, 2.45855376e-01f, 3.48086447e-01f, 3.77135068e-01f, 3.77651036e-01f, -3.42163503e-01f, 3.24988514e-02f, -2.14705378e-01f, 7.65358359e-02f,
  -3.90824795e-01f, 5.22644401e-01f, 3.28397065e-01f, 3.21787715e-01f, 3.06135893e-01f, -5.40331788e-02f, 1.36243582e-01f, -2.24419800e-03f, 6.02700002e-02f, -3.76166284e-01f,
  -2.26989731e-01f, -1.31520376e-01f, -1.89823568e-01f, -2.61880338e-01f, 5.46767414e-01f, -1.74981102e-01f, 4.37929481e-01f, -4.14488345e-01f, 1.60026431e-01f, -7.48525467e-03f,
  -3.50341469e-01f, -3.33779365e-01f, -3.39067072e-01f, 7.12104440e-01f, -4.99702292e-03f, -2.76329339e-01f, 4.81051832e-01f, 2.61898965e-01f, 1.75434187e-01f, -7.55932555e-02f,
  3.21200490e-01f, -8.09837878e-02f, -2.03117594e-01f, 2.25004822e-01f, 3.10698003e-02f, 1.78240955e-01f, -7.85457343e-02f, 4.30866927e-01f, 2.99290996e-02f, 2.52103537e-01f,
  -2.37429306e-01f, 4.92086887e-01f, -6.40007138e-01f, 1.82439595e-01f, 2.48041049e-01f, 4.14223492e-01f, -2.81375974e-01f, 5.69059994e-05f, -4.52644844e-03f, -4.31672484e-02f,
  -2.03789830e-01f, 6.24371357e-02f, 5.13669670e-01f, 3.12772751e-01f, -2.70039290e-01f, -3.89949411e-01f, 4.89990205e-01f, 6.34009778e-01f, -1.63460404e-01f, 1.01063818e-01f,
  -4.91398573e-01f, 3.96400869e-01f, -2.19562605e-01f, 5.78449011e-01f, 5.97825170e-01f, 4.72331196e-01f, -9.97140408e-02f, 1.61456153e-01f, 1.69717837e-02f, -2.03635842e-02f,
  3.09435762e-02f, 2.76412606e-01f, 4.05468017e-01f, 6.22350238e-02f, 2.68264860e-01f, -2.17649102e-01f, 2.52496600e-02f, 2.63638292e-02f, 2.01444477e-01f, 3.22009861e-01f,
  1.96523100e-01f, -3.72436136e-01f, 1.39715537e-01f, 5.03785849e-01f, 1.33872390e-01f, 4.30881292e-01f, 1.86573073e-01f, 3.17117214e-01f, 3.95626605e-01f, 4.02369022e-01f,
  3.75420153e-01f, -2.69600928e-01f, -4.13690925e-01f, -3.89834851e-01f, -3.98393534e-02f, -1.36541858e-01f, -2.92223040e-02f, 5.69337085e-02f, -4.99989130e-02f, 1.07515842e-01f,
  2.00758297e-02f, 4.03182954e-01f, 1.29861891e-01f, 6.69074710e-04f, 9.06681642e-02f, 2.97292173e-02f, -3.65680666e-03f, 2.77506769e-01f, -4.48934168e-01f, 3.85332257e-01f,
  -7.25504577e-01f, 2.68342674e-01f, -7.21543953e-02f, 4.54797298e-01f, 3.77182424e-01f, -2.09703594e-01f, 2.40891680e-01f, 3.24681938e-01f, 3.29442769e-01f, -4.11947399e-01f,
  6.93933293e-02f, 2.87785977e-01f, -4.03771460e-01f, -1.43700004e-01f, 4.54915911e-02f, 6.87435865e-01f, 1.76391691e-01f, 1.51281849e-01f, -3.02148640e-01f, 6.46050394e-01f,
  3.80750954e-01f, 2.39394605e-01f, 3.55363220e-01f, 3.57630730e-01f, 3.70722532e-01f, 2.17802316e-01f, -5.97879244e-03f, 1.46945387e-01f, -1.56542152e-01f, -3.38253379e-01f,
  -1.70666188e-01f, -2.50445604e-01f, -3.18590626e-02f, -2.42473677e-01f, 3.30864787e-01f, -7.20450878e-02f, -2.66888589e-02f, -1.41847715e-01f, -3.32969427e-01f, -1.56463012e-01f,
  -2.34296322e-01f, -2.93473639e-02f, -1.56133041e-01f, -3.76832396e-01f, 3.44832778e-01f, -1.47475570e-01f, 3.00115347e-01f, 2.03759186e-02f, 4.49017137e-01f, 1.65750504e-01f,
  3.63076687e-01f, 1.89674124e-01f, 2.84354270e-01f, 2.87935704e-01f, 1.96374416e-01f, 4.70975518e-01f, 2.11040601e-01f, 3.03660333e-01f, -3.37465793e-01f, 2.94317544e-01f,
  -9.57607999e-02f, -3.34439486e-01f, -4.77142483e-01f, -2.77168930e-01f, -1.36943460e-01f, 8.79295915e-02f, -3.69741648e-01f, 2.06941411e-01f, 6.52949750e-01f, -2.59017438e-01f,
  -3.84623498e-01f, 2.77920514e-01f, -4.39885855e-01f, 4.61162329e-02f, -3.72095928e-02f, 6.80585206e-02f, 1.80751294e-01f, -1.00340538e-01f, 4.68617857e-01f, 3.28528017e-01f,
  4.99091763e-03f, 1.18630737e-01f, 1.63144350e-01f, 7.18828022e-01f, 8.00225958e-02f, 3.42942812e-02f, 3.22368033e-02f, -1.65030994e-02f, 1.53763503e-01f, 1.52715370e-01f,
  1.95631608e-01f, -4.19403255e-01f, 3.32285643e-01f, -2.64598936e-01f, -2.28392482e-01f, -3.60598952e-01f, 4.88855809e-01f, 5.69325447e-01f, 1.63714319e-01f, -4.05728132e-01f,
  -1.94333166e-01f, 3.75992768e-02f, -4.32535231e-01f, 5.84411442e-01f, 2.75190115e-01f, -2.18862578e-01f, -1.28216386e-01f, 1.25041157e-01f, -1.78558305e-01f, -1.67651236e-01f,
  1.49668723e-01f, -2.95456909e-02f, 6.05740428e-01f, -2.61733115e-01f, -1.20419912e-01f, 9.01292041e-02f, 1.55739963e-01f, 3.92515242e-01f, 8.38543400e-02f, -8.88589118e-03f,
  -1.90954402e-01f, 1.20785013e-01f, 3.21830094e-01f, -2.03023300e-01f, 6.30877540e-02f, -1.55083328e-01f, 1.86569124e-01f, -8.08469579e-02f, -2.44218390e-02f, 2.45410323e-01f,
  4.50929493e-01f, 1.54673845e-01f, 2.63590634e-01f, 3.08778793e-01f, 3.48411292e-01f, 1.65414453e-01f, -1.72104537e-01f, -9.46028829e-02f, 3.39820683e-01f, 6.33178830e-01f,
  -1.83378056e-01f, -1.52990192e-01f, -5.70686813e-03f, 2.88206995e-01f, 9.12726745e-02f, -2.82987386e-01f, -1.49688482e-01f, 4.37591374e-01f, 1.06903955e-01f, 2.23727435e-01f,
  4.03299779e-01f, 2.82442302e-01f, 8.65857527e-02f, 3.95360023e-01f, 2.07790568e-01f, 8.53656530e-02f, -4.51794446e-01f, -3.94427210e-01f, -2.72950649e-01f, -2.74724990e-01f,
  -2.94446647e-01f, -3.86778176e-01f, 3.98329765e-01f, -2.13133812e-01f, 3.68035167e-01f, 6.24033175e-02f, -2.84731388e-01f, -4.51613307e-01f, -2.33765133e-02f, 3.93055528e-01f,
  2.63635606e-01f, 2.37175182e-01f, 4.70884770e-01f, -2.80775130e-01f, -7.12285936e-02f, 6.09744973e-02f, 3.57123375e-01f, 1.47340581e-01f, 1.63628310e-01f, 5.13389170e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  6.98666275e-02f, 4.84229289e-02f, 2.89010733e-01f, 3.18446398e-01f, 2.16785848e-01f, 2.71888703e-01f, 2.47313440e-01f, 1.05929933e-01f, 2.36199126e-01f, 5.00792086e-01f,
  1.28848776e-01f, 2.05250248e-01f, 1.54743001e-01f, 8.56922790e-02f, 1.87829331e-01f, 1.65771931e-01f, 1.30295500e-01f, 1.47051051e-01f, 1.47723421e-01f, 3.10458928e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -9.56236944e-03f, -2.63412204e-02f, 1.09535754e-02f, 3.30680818e-03f, -1.92829028e-01f, -3.46163720e-01f, -3.34829509e-01f, -3.38385344e-01f, 3.15043122e-01f, 3.02276462e-01f,
  -2.48986021e-01f, 3.46342087e-01f, 4.04420465e-01f, -5.67151427e-01f, 1.37135640e-01f, -6.58701479e-01f, -5.88564277e-01f, 2.64968216e-01f, -8.09282422e-01f, 1.64527789e-01f,
  -2.66446263e-01f, 1.78650841e-01f, 2.50910874e-03f, -8.22800994e-02f, 5.39229453e-01f, 2.08769083e-01f, -3.96982223e-01f, -1.77909043e-02f, -5.49902022e-01f, -4.84131843e-01f,
  3.92128885e-01f, 2.92921484e-01f, 2.84454435e-01f, -9.49247926e-02f, -2.58656412e-01f, 1.54399857e-01f, -3.05771321e-01f, -5.44219688e-02f, 1.44578651e-01f, -3.23430598e-01f,
  3.04804504e-01f, -3.81561846e-01f, -1.83409184e-01f, 3.26113582e-01f, -6.97537065e-01f, 3.08091521e-01f, -3.77763808e-01f, -1.62507892e-01f, -5.40941179e-01f, 6.06207907e-01f,
  -6.16344869e-01f, -4.62673813e-01f, -6.12985939e-02f, 4.89401400e-01f, 1.84387654e-01f, -4.69868749e-01f, -4.41066116e-01f, 3.98564219e-01f, 9.81071517e-02f, -3.25729281e-01f,
  -7.05052435e-01f, 4.15637970e-01f, 1.80503696e-01f, -1.19116925e-01f, 6.31662160e-02f, -8.80181566e-02f, -3.03022683e-01f, -1.22578822e-01f, -3.36320400e-01f, -6.55966923e-02f,
  1.14339054e-01f, 4.91897613e-02f, 1.68428630e-01f, 2.68394779e-02f, -2.04787001e-01f, -3.54332119e-01f, -7.24582613e-01f, 1.45315409e-01f, -7.95495033e-01f, -5.90121094e-03f,
  -6.42511487e-01f, -5.11204064e-01f, -2.19788894e-01f, -1.47633314e-01f, 2.38947332e-01f, -8.31988379e-02f, 2.74027854e-01f, -4.48203236e-01f, 3.40690941e-01f, -2.78781727e-02f,
  4.40979540e-01f, -5.04472554e-01f, 5.21045327e-01f, 1.80836722e-01f, 2.69502372e-01f, -3.58288735e-01f, 1.81271344e-01f, 1.14685476e-01f, -3.25566143e-01f, 6.51081800e-02f,
  -1.19209826e-01f, -8.78744423e-02f, -2.36296862e-01f, -8.47409517e-02f, -3.87671590e-02f, 3.26447546e-01f, 3.45610052e-01f, -9.69341546e-02f, 3.71622384e-01f, -5.35022974e-01f,
  4.68177408e-01f, -5.69093823e-01f, 4.09381151e-01f, -5.15525639e-01f, -3.86949837e-01f, 4.82547015e-01f, -2.29205012e-01f, -5.26308298e-01f, -4.79849786e-01f, -4.46157336e-01f,
  6.18256986e-01f, -3.19611251e-01f, 4.22766879e-02f, -4.61512983e-01f, -3.69629562e-01f, -7.28141144e-02f, -3.11977923e-01f, -5.54636359e-01f, 6.66587427e-02f, -2.04611551e-02f,
  1.65765777e-01f, 2.03456298e-01f, 2.85937786e-01f, 2.87166208e-01f, -1.60928160e-01f, 3.04709882e-01f, -6.07643902e-01f, 2.59124190e-01f, 2.18501985e-01f, -1.36230335e-01f,
  1.54378667e-01f, -4.12676543e-01f, 8.22854266e-02f, -3.34817111e-01f, -1.86583489e-01f, -8.92638043e-02f, 5.76536655e-01f, -4.77110952e-01f, -6.19797170e-01f, 7.81691432e-01f,
  -1.85107868e-02f, -6.54674649e-01f, 4.32679504e-01f, -2.74473965e-01f, 2.76718795e-01f, 3.94529700e-01f, 3.69365484e-01f, -3.03484082e-01f, -6.29590511e-01f, 1.46077618e-01f,
  -4.49331515e-02f, 2.89363921e-01f, 2.46323183e-01f, -1.73711136e-01f, 1.89030632e-01f, -4.82448488e-02f, -1.56412214e-01f, -3.37820560e-01f, 2.34364212e-01f, -2.86656618e-01f,
  -4.30068314e-01f, 3.07784706e-01f, -1.60136614e-02f, 1.95987105e-01f, 2.56522983e-01f, 8.13729763e-02f, 4.48655337e-01f, 3.89178395e-01f, -5.77898085e-01f, -2.28585098e-02f,
  -2.43992060e-01f, 2.14549154e-01f, -5.99132597e-01f, 5.70408046e-01f, -6.94887638e-01f, -3.91247004e-01f, -7.57449210e-01f, 4.98066664e-01f, -1.73016652e-01f, 4.52608824e-01f,
  -8.14376622e-02f, 9.67295170e-02f, 1.55622363e-01f, 1.22525692e-01f, 2.38652736e-01f, 1.26807973e-01f, 2.28415281e-01f, 7.48134777e-02f, -3.38661879e-01f, -2.35876665e-01f,
  3.05139750e-01f, -3.80826682e-01f, -5.19283535e-03f, -5.71683347e-01f, -2.24863425e-01f, -2.53347278e-01f, -7.43211806e-01f, 2.41433606e-01f, 5.86663127e-01f, -3.36190939e-01f,
  -6.67138338e-01f, -1.12924986e-01f, 2.54811347e-01f, -8.71161342e-01f, -1.06103636e-01f, 1.64226040e-01f, -1.98367089e-01f, -5.72003841e-01f, 5.95777035e-01f, 3.39566678e-01f,
  3.52627724e-01f, -8.61552358e-02f, 1.58964097e-01f, 4.75420088e-01f, -3.35182622e-02f, -2.36648440e-01f, 2.24671572e-01f, 6.50559887e-02f, -6.76912442e-02f, -1.20962292e-01f,
  1.24108262e-01f, 1.47049978e-01f, -1.35328338e-01f, 3.29005390e-01f, 1.29888371e-01f, -3.40819538e-01f, -5.13354778e-01f, -2.62762249e-01f, 4.16191220e-01f, -4.68759477e-01f,
  -1.83441058e-01f, 3.35635632e-01f, 3.31296444e-01f, 6.15532517e-01f, -2.12397590e-01f, -5.12921333e-01f, 5.28423727e-01f, 5.34761250e-01f, -3.59226316e-01f, -1.79030031e-01f,
  -3.24597538e-01f, -2.15529829e-01f, -2.95207411e-01f, -1.81667551e-01f, -4.26090419e-01f, -6.50566518e-02f, -4.38813061e-01f, 5.33993840e-02f, 9.36132967e-02f, -8.37021917e-02f,
  1.83347445e-02f, -2.36231685e-01f, 1.58875361e-01f, -3.12129527e-01f, -3.16059172e-01f, 2.70178348e-01f, 1.36295617e-01f, 2.45413169e-01f, 3.88346791e-01f, 3.69219810e-01f,
  -1.36447355e-01f, -1.27531260e-01f, -4.48033810e-01f, -5.67620993e-01f, 4.24734563e-01f, -4.60533887e-01f, 2.67923117e-01f, -4.18285906e-01f, 4.06322867e-01f, -1.01602478e-02f,
  -2.29456812e-01f, 2.35198051e-01f, -3.66865724e-01f, -3.54954779e-01f, -3.38969737e-01f, 4.12354678e-01f, 1.75288454e-01f, -4.85523999e-01f, -2.97376931e-01f, -1.19831666e-01f,
  -1.59193218e-01f, -1.80258319e-01f, -8.93157795e-02f, 1.26259416e-01f, -2.25989997e-01f, 3.03473324e-01f, 3.78962874e-01f, 6.43886805e-01f, 3.31455439e-01f, 2.76879817e-01f,
  -2.33666867e-01f, -4.04209018e-01f, -5.77102363e-01f, -2.59051293e-01f, -4.08300459e-01f, -4.53842223e-01f, 2.83810437e-01f, -4.12239254e-01f, 3.82912308e-01f, 1.22085959e-01f,
  5.00113726e-01f, 4.06125754e-01f, -5.20162463e-01f, 3.24472189e-01f, -5.55412292e-01f, 5.85941635e-02f, 3.40510994e-01f, -5.70658863e-01f, -2.21384093e-01f, 4.78947967e-01f,
  -1.20016195e-01f, -4.85647582e-02f, 2.10337862e-01f, -7.18184188e-02f, 1.24577284e-01f, 1.77041039e-01f, 3.97893906e-01f, 3.22356313e-01f, -4.90967035e-01f, -3.92724693e-01f,
  5.17167971e-02f, -1.52285188e-01f, -6.55511141e-01f, 6.46008193e-01f, 2.93234706e-01f, 4.89346683e-01f, -1.85346425e-01f, -4.07044917e-01f, -4.26278740e-01f, 1.28679857e-01f,
  -5.25264502e-01f, -7.75826648e-02f, -2.55567342e-01f, -2.90744722e-01f, -3.25159319e-02f, -2.35466316e-01f, 5.17331541e-01f, -3.09101820e-01f, -3.20795864e-01f, -5.98465204e-01f,
  2.87731707e-01f, -3.08272004e-01f, 2.18461066e-01f, -1.30254611e-01f, -1.37782358e-02f, 5.62098883e-02f, -2.54541099e-01f, -1.67046085e-01f, 4.11278367e-01f, 3.88199687e-01f,
  -3.27883363e-01f, -4.28777844e-01f, 3.94114614e-01f, 3.86884302e-01f, 5.48754454e-01f, 2.42768988e-01f, -1.22671016e-02f, -1.53381433e-02f, 5.34975350e-01f, -2.99125969e-01f,
  4.76345122e-01f, -4.99335349e-01f, 3.32972676e-01f, -4.79122460e-01f, -6.48272693e-01f, -1.62081316e-01f, -4.92652804e-01f, -5.55915594e-01f, -4.08611387e-01f, 6.15598597e-02f,
  2.95720667e-01f, -4.55312610e-01f, -2.98469871e-01f, -5.83519995e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.78456455e-01f, 3.69068272e-02f, -1.70045406e-01f, -5.37281148e-02f, 2.66441345e-01f, -5.13675250e-02f, -1.40239848e-02f, 7.67552778e-02f, 3.79043864e-03f, 2.76646577e-02f,
  7.16871545e-02f, 1.38954237e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    