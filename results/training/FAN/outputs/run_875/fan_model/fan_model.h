/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.42743030e-01f, 1.93975732e-01f, -1.06423199e-01f, -9.27895829e-02f, 5.60216680e-02f, 1.74775094e-01f, 3.05764824e-01f, 1.91234022e-01f, 3.58349495e-02f, 5.72660901e-02f,
  -1.82453305e-01f, -2.77429640e-01f, -1.88947007e-01f, -1.37512460e-01f, -1.42849088e-01f, 2.46295497e-01f, 1.80646509e-01f, -2.50247717e-01f, -1.34008124e-01f, -2.62920596e-02f,
  1.86224073e-01f, 5.77639826e-02f, -2.11074233e-01f, 3.44732739e-02f, 1.60478458e-01f, -8.53115022e-02f, 6.28739828e-03f, -5.28552867e-02f, 5.25910705e-02f, 1.23314865e-01f,
  -2.59352684e-01f, 1.52888104e-01f, -4.94366400e-02f, -1.04547389e-01f, -1.03699356e-01f, -5.77692129e-03f, 4.65155550e-04f, -8.80627632e-02f, -7.79851675e-02f, 6.54813871e-02f,
  -5.65900765e-02f, 5.55721000e-02f, 4.16042432e-02f, 1.32045686e-01f, 7.83998370e-02f, 5.82125038e-02f, 2.38741599e-02f, -3.01120449e-02f, -7.92324767e-02f, 2.88252104e-02f,
  5.61995693e-02f, 5.08437119e-02f, -1.04520217e-01f, -2.62156110e-02f, -2.06262805e-02f, -1.95580781e-01f, -8.37145187e-03f, 1.29434615e-01f, -7.20070302e-02f, 1.27466261e-01f,
  -1.18188020e-02f, -5.48504330e-02f, 1.03138236e-03f, -5.90694360e-02f, 7.35299587e-02f, -8.04787129e-02f, 8.31302628e-03f, -6.04287125e-02f, 9.12104733e-03f, 1.77414678e-02f,
  -1.35857323e-02f, -5.62445633e-02f, -4.96446006e-02f, -2.93910764e-02f, -5.29474765e-02f, -8.99791811e-03f, -7.69437850e-02f, 6.13698140e-02f, -6.48758560e-02f, -4.53356951e-02f,
  -6.24148920e-02f, -4.70602214e-02f, 5.28149046e-02f, -1.46374619e-02f, 5.27338460e-02f, 2.84770466e-02f, 3.83080877e-02f, 3.39084398e-03f, 3.54798213e-02f, 2.80691888e-02f,
  -9.42844003e-02f, -2.72245020e-01f, 1.41407186e-02f, 3.33842076e-02f, -2.32868306e-02f, 4.90652211e-02f, -5.72130904e-02f, -6.69851452e-02f, -2.46537011e-02f, -4.32439893e-02f,
  -3.09511758e-02f, -6.54714406e-02f, -5.74560575e-02f, 4.83788699e-02f, 3.58434990e-02f, -3.59209850e-02f, 2.74801217e-02f, -2.93965489e-02f, 3.43034118e-02f, 1.34272322e-01f,
  1.71922922e-01f, 6.63600210e-03f, -1.52751446e-01f, -3.01463287e-02f, 3.63819413e-02f, -1.15981944e-01f, -6.11383393e-02f, -2.75645463e-04f, -1.23703055e-01f, 1.86042160e-01f,
  -3.39916676e-01f, 3.11398178e-01f, 3.36168021e-01f, 1.23811126e-01f, 1.53523192e-01f, 9.20933858e-02f, 3.28408070e-02f, -1.55467451e-01f, -7.19459057e-02f, 5.69705516e-02f,
  1.18246213e-01f, -1.95058376e-01f, -2.45938018e-01f, -2.29279101e-01f, -2.29675382e-01f, 1.60281241e-01f, 1.99674651e-01f, -7.81574026e-02f, -3.44636112e-01f, -2.07794920e-01f,
  5.83692975e-02f, 6.79529533e-02f, -1.09403804e-01f, -1.37392804e-01f, 2.56594747e-01f, 4.46245372e-02f, 1.78089276e-01f, 2.25969210e-01f, 1.91771254e-01f, 4.78539526e-01f,
  9.61320940e-03f, 9.87054855e-02f, -1.90947101e-01f, -5.38429357e-02f, 6.75470456e-02f, -1.90525055e-02f, -4.35668826e-02f, 6.66905344e-02f, 6.20985031e-02f, -1.05551509e-02f,
  1.07027762e-01f, 4.77752015e-02f, 6.85906084e-03f, 7.74835888e-03f, -7.80769959e-02f, 2.92721856e-02f, 8.82003680e-02f, -1.26869036e-02f, -5.45676947e-02f, -4.92414385e-02f,
  7.58949593e-02f, 1.55557111e-01f, 1.01429276e-01f, -6.73273159e-03f, 3.90958525e-02f, -9.97226033e-03f, 4.75341221e-03f, -3.73573937e-02f, -4.38656732e-02f, -4.21601832e-02f,
  -8.43762420e-03f, 1.28233107e-02f, 3.60571295e-02f, -8.80022533e-03f, -7.19089210e-02f, 7.36174807e-02f, 1.30301528e-02f, 8.54407437e-03f, -4.07507978e-02f, 4.85793985e-02f,
  -3.32556665e-02f, 6.52938783e-02f, 2.45682094e-02f, 1.76069085e-02f, 3.02929971e-02f, 4.78266440e-02f, 1.69402473e-02f, 2.98583973e-03f, -2.85097603e-02f, -1.17705874e-02f,
  -6.16732612e-02f, 7.42161367e-03f, 3.16428356e-02f, 1.00921700e-03f, 2.87731327e-02f, 5.67599945e-02f, -7.18287379e-02f, -6.44849427e-03f, 4.49089818e-02f, 6.04117103e-02f,
  -2.70210087e-01f, -4.46185609e-03f, 4.09800969e-02f, -1.04859106e-01f, 4.82230559e-02f, -1.10696652e-03f, 4.84241247e-02f, -1.42159071e-02f, 5.53252026e-02f, -7.57270828e-02f,
  2.69496441e-03f, -1.07055075e-01f, 9.07084420e-02f, -3.25098746e-02f, -3.50888520e-02f, -2.55238079e-02f, 4.47258987e-02f, 4.90756519e-03f, -1.45059051e-02f, 5.00319786e-02f,
  8.43781531e-02f, -8.03785697e-02f, -2.74738044e-01f, -1.11240037e-01f, -9.47014168e-02f, -2.10603714e-01f, -1.34615377e-01f, -1.04854956e-01f, -2.11009383e-01f, -1.87071145e-01f,
  -3.69050890e-01f, -7.71499053e-02f, 1.68196529e-01f, -2.04777509e-01f, -7.91324154e-02f, 1.01416402e-01f, 7.24114850e-02f, 4.30596508e-02f, -8.30102786e-02f, -1.67734995e-01f,
  -1.49523526e-01f, -1.47188649e-01f, 3.07690650e-02f, 2.70177294e-02f, 1.35930911e-01f, 7.46220723e-02f, 1.55186862e-01f, 1.61614195e-01f, 1.00187823e-01f, -3.24706584e-02f,
  5.47179719e-03f, -6.83383346e-02f, -8.94092023e-02f, 1.28096521e-01f, -8.13979954e-02f, 5.76975755e-02f, 8.33097622e-02f, 4.01782431e-02f, 3.35647054e-02f, 1.88647509e-02f,
  2.20069569e-02f, 5.85479625e-02f, 2.00596694e-02f, -8.56568217e-02f, -1.37056619e-01f, -5.66268638e-02f, -1.15897015e-01f, 5.08036129e-02f, -3.36989351e-02f, 2.37565022e-02f,
  -1.27059549e-01f, -6.32179528e-02f, -5.59111945e-02f, -4.76460271e-02f, -1.07769161e-01f, -3.27047966e-02f, -5.03462255e-02f, 1.49905518e-01f, 2.78854202e-02f, -7.42913783e-02f,
  1.34069240e-02f, -7.94104636e-02f, -7.69942403e-02f, -1.62075367e-02f, 4.34111841e-02f, -1.13201462e-01f, -5.10353334e-02f, -2.60146074e-02f, 1.04900539e-01f, -8.64259452e-02f,
  1.36494637e-02f, 2.58143246e-02f, -2.35213302e-02f, 3.12278047e-02f, -9.45048705e-02f, 1.68882613e-03f, 1.13335541e-02f, 5.06770313e-02f, -2.80883815e-02f, -8.14514980e-02f,
  4.90762591e-02f, 3.96240428e-02f, -8.03782195e-02f, -6.86096773e-02f, 6.82691410e-02f, -3.03007048e-02f, 1.01842033e-02f, 1.85696892e-02f, 2.16657277e-02f, -1.17334770e-03f,
  -4.68367599e-02f, 3.43849175e-02f, -7.97265582e-03f, 2.03194842e-02f, -1.54921990e-02f, 7.88781568e-02f, -3.41313742e-02f, -3.42137031e-02f, -3.87881249e-02f, -2.62429789e-02f,
  -3.91586900e-01f, 1.42504111e-01f, -8.74514692e-03f, -2.47779209e-03f, -2.86845248e-02f, -1.15160914e-02f, 2.20658295e-02f, -1.73707940e-02f, 6.34642690e-02f, 3.80948335e-02f,
  3.30683403e-02f, 4.94081676e-02f, -4.97895069e-02f, -2.56231986e-02f, -4.52726521e-02f, 1.10038090e-02f, -1.53224751e-01f, -9.46147591e-02f, -2.78846435e-02f, -1.21762633e-01f,
  -1.41207784e-01f, -1.88573405e-01f, -1.45171657e-01f, -1.28492981e-01f, -1.80558413e-02f, -8.84960443e-02f, -2.43190471e-02f, -7.79596940e-02f, -1.70319036e-01f, -3.02758843e-01f,
  -3.14942479e-01f, -9.24640819e-02f, -1.89578608e-01f, -2.14425772e-01f, -1.08805336e-01f, -9.07235593e-02f, -1.42499477e-01f, 6.84097335e-02f, -4.33825552e-02f, -1.01558536e-01f,
  1.37183651e-01f, 1.01759367e-01f, 1.84943333e-01f, 1.28356025e-01f, 1.87785104e-01f, -1.14653379e-01f, -2.22246885e-01f, -1.19713575e-01f, -5.42226434e-03f, 1.62194952e-01f,
  7.03238174e-02f, -1.51900113e-01f, -6.89589381e-02f, 2.75857002e-02f, -1.06860928e-01f, -1.19632341e-01f, -2.04321787e-01f, -2.03605920e-01f, -5.70553280e-02f, -3.89916301e-01f,
  -2.16059566e-01f, 3.93191986e-02f, 1.20212538e-02f, 1.01567768e-01f, -3.08169276e-02f, 2.65771542e-02f, -1.12507284e-01f, -2.73907930e-02f, -1.38923395e-02f, -3.19888978e-03f,
  -1.18351970e-02f, 4.58875485e-02f, -4.54785191e-02f, 6.79196119e-02f, 1.16787879e-02f, 3.17992419e-02f, 1.30710274e-01f, 2.39386726e-02f, 5.62096015e-02f, 9.37381238e-02f,
  1.12734765e-01f, -3.65844294e-02f, -1.06287859e-01f, 1.44499734e-01f, 1.74792290e-01f, -2.71831155e-02f, -6.95795491e-02f, 5.33835329e-02f, -1.85983442e-02f, -1.62693515e-01f,
  -2.88987532e-02f, -5.34216948e-02f, -1.44959340e-04f, 2.96473745e-02f, -8.05805530e-03f, -2.15327721e-02f, -9.17292573e-03f, -5.26184440e-02f, 1.85303912e-02f, -5.11624813e-02f,
  4.12167124e-02f, 9.72824171e-03f, 2.73755491e-02f, -3.36551368e-02f, -1.91398652e-03f, -4.15508486e-02f, -2.40049325e-02f, 5.23937307e-02f, -9.70818568e-03f, 2.90992185e-02f,
  2.20612957e-04f, -2.60254685e-02f, -3.79357934e-02f, 5.70072606e-02f, 7.60328174e-02f, 3.04884743e-02f, -2.53511383e-03f, 2.54756957e-02f, 3.66782583e-02f, -1.38384160e-02f,
  -4.13634628e-02f, 1.99657783e-01f, -1.33839637e-01f, 6.87221736e-02f, -3.89578305e-02f, 5.72351664e-02f, -5.16635226e-03f, 3.49544510e-02f, 4.20634747e-02f, -1.69519167e-02f,
  1.09346502e-01f, 6.55869907e-03f, 1.71869732e-02f, 3.64965051e-02f, -1.16077652e-02f, 5.54940440e-02f, -3.44810309e-03f, -1.33417984e-02f, 8.29655379e-02f, 3.85887362e-02f,
  -1.96513403e-02f, -1.32071480e-01f, -1.24253608e-01f, -1.16036348e-01f, -9.03412998e-02f, -4.27649952e-02f, -6.50101155e-02f, -1.15952447e-01f, -1.48719966e-01f, -2.89095014e-01f,
  3.01219434e-01f, -1.38908833e-01f, 2.83053547e-01f, -6.21152371e-02f, -9.08742547e-02f, 1.29865527e-01f, -5.94714098e-02f, 2.38030218e-02f, -2.75755394e-02f, -1.27195746e-01f,
  -3.27471527e-03f, 4.18241248e-02f, 5.88200055e-02f, -2.79998090e-02f, 2.00981274e-01f, -1.35871381e-01f, 5.42481942e-03f, 1.92895249e-01f, 2.36725509e-01f, -4.99325655e-02f,
  -2.70538807e-01f, -5.10082692e-02f, 9.63677987e-02f, -3.45599614e-02f, -2.56924689e-01f, -1.85315669e-01f, -6.41281754e-02f, 2.11755410e-02f, 2.01113503e-02f, -2.89548188e-01f,
  7.06337169e-02f, 1.22904144e-01f, 7.24476427e-02f, 1.70961972e-02f, 4.92782332e-02f, 4.21592779e-02f, 2.22287476e-02f, -2.88093043e-03f, 4.93090451e-02f, -8.72575194e-02f,
  1.68250147e-02f, 5.24416082e-02f, 1.01450905e-01f, 5.77258179e-03f, -8.71946197e-03f, -5.69509193e-02f, 2.45073009e-02f, 1.10631481e-01f, 9.68565717e-02f, 4.21799682e-02f,
  -6.15105852e-02f, 5.05035222e-02f, 1.61482111e-01f, -2.51321085e-02f, 7.30355177e-03f, 1.40701637e-01f, -6.33864803e-03f, -5.07584289e-02f, 1.76466122e-01f, -2.30361328e-01f,
  -9.96432267e-03f, 7.55549781e-03f, -3.81086618e-02f, -5.19583821e-02f, -2.95035318e-02f, -4.92074387e-03f, -1.93154614e-03f, -8.53178725e-02f, -6.03306368e-02f, -3.79725434e-02f,
  5.10302298e-02f, -3.18379747e-03f, -3.01631112e-02f, -3.41836214e-02f, -8.01975280e-02f, 6.44416139e-02f, -7.36552849e-02f, -3.98322083e-02f, 7.53599033e-03f, 1.70494504e-02f,
  8.38611498e-02f, 1.17401285e-02f, -7.67122433e-02f, -6.26879856e-02f, 5.38589656e-02f, 3.75529937e-02f, -4.58999202e-02f, -8.16434715e-03f, 3.44117992e-02f, 5.63684963e-02f,
  -1.90401226e-01f, 4.21112955e-01f, -1.69422179e-02f, -6.17228169e-03f, 1.66612621e-02f, 3.98657843e-02f, -3.15000191e-02f, 2.18395479e-02f, 5.82047030e-02f, -3.93177830e-02f,
  -5.14424127e-03f, 5.34305014e-02f, -6.12487039e-03f, -5.73076308e-02f, 2.06012558e-02f, 7.81441806e-04f, -1.06978588e-01f, -6.16541505e-03f, 2.47511435e-02f, -3.72170955e-02f,
  -5.36395758e-02f, -1.36741931e-02f, 6.35621184e-03f, -1.70834307e-02f, -7.37089291e-03f, 9.38922465e-02f, 9.94856935e-03f, -4.43800464e-02f, 1.79484740e-01f, -2.96573073e-01f,
  4.27533984e-01f, -2.72081904e-02f, 4.60356861e-01f, -4.21843603e-02f, -1.29150555e-01f, 3.70943807e-02f, -3.84840332e-02f, 7.82776549e-02f, -4.41515036e-02f, -1.32254541e-01f,
  -1.57731488e-01f, -2.61955023e-01f, -9.25666392e-02f, -2.30935263e-03f, -4.26501269e-03f, 3.74634005e-02f, 9.52076353e-03f, 2.00424820e-01f, 1.75545096e-01f, -3.39431874e-02f,
  -2.15917885e-01f, -5.40607311e-02f, 1.01546481e-01f, 1.54158682e-01f, -6.06368557e-02f, -1.27333645e-02f, 1.94176674e-01f, 2.30978262e-02f, -9.25395489e-02f, -7.43562505e-02f,
  -3.98180727e-03f, 3.40719014e-01f, -7.47569501e-02f, -1.21474989e-01f, 9.04048830e-02f, 1.23272106e-01f, -9.73382033e-03f, 1.21772416e-01f, 9.96103212e-02f, 5.97336739e-02f,
  3.59976962e-02f, -5.58102392e-02f, 3.79683971e-02f, -4.65999767e-02f, 1.26690948e-02f, 1.05023041e-01f, 1.69978201e-01f, 1.56101763e-01f, 1.66136831e-01f, 1.16461562e-03f,
  -2.48035342e-01f, 2.19662786e-02f, 1.22350864e-01f, 5.42869642e-02f, 7.29205161e-02f, 3.85678262e-02f, 1.32850319e-01f, 8.39618891e-02f, 1.16876215e-01f, 4.20081802e-02f,
  -8.50308836e-02f, 9.36880037e-02f, 4.25743647e-02f, -3.65399085e-02f, 3.90359275e-02f, -2.04129554e-02f, -3.35765928e-02f, -3.69759724e-02f, 2.59846710e-02f, 4.56833467e-02f,
  4.64849407e-03f, 3.61401401e-02f, -1.06061492e-02f, 1.63848959e-02f, -6.41131699e-02f, 7.69446716e-02f, 4.89504784e-02f, 1.14894612e-02f, -5.58509454e-02f, 1.08105309e-01f,
  -8.08833353e-03f, 1.23013156e-02f, 8.53472725e-02f, 7.45942292e-04f, -1.45238768e-02f, 7.38110021e-02f, 4.21666391e-02f, -5.32084443e-02f, 1.04016848e-02f, 4.76066284e-02f,
  -2.82456040e-01f, 1.48929525e-02f, -7.25271180e-02f, -1.73642708e-03f, 8.75222962e-03f, -3.77060995e-02f, -1.15772471e-01f, 3.06490902e-02f, -7.63014928e-02f, 6.04691468e-02f,
  6.40101656e-02f, -2.33085025e-02f, 1.77232781e-04f, -3.42781260e-03f, 4.81475927e-02f, -2.58726999e-04f, -1.46867171e-01f, -6.59301132e-02f, -1.63582840e-03f, 1.90277994e-02f,
  -5.19459136e-02f, -4.17312197e-02f, -4.70124409e-02f, -7.91251585e-02f, 3.33409980e-02f, -6.16264120e-02f, -7.56728882e-03f, -3.92230377e-02f, -1.79962367e-02f, -1.25367925e-01f,
  -6.82251826e-02f, -1.10632919e-01f, -1.49010941e-01f, -2.68672198e-01f, -1.13521807e-01f, 7.89147243e-02f, -3.93820554e-03f, 4.82453145e-02f, -9.48660076e-02f, -5.50634302e-02f,
  -5.64783346e-03f, -1.92674994e-02f, 9.55620855e-02f, -1.23850955e-02f, 1.63851514e-01f, -1.26208022e-01f, -1.69139132e-01f, 4.81547676e-02f, 5.08024246e-02f, 4.51093959e-03f,
  -6.50945231e-02f, -8.52727666e-02f, -5.59214130e-02f, -1.35585964e-01f, -1.80867851e-01f, -1.01842441e-01f, -2.06948087e-01f, -6.21527769e-02f, -8.26382637e-02f, -3.98761362e-01f,
  -1.71241969e-01f, -1.53105855e-01f, 5.63910715e-02f, 8.00307915e-02f, 5.33295833e-02f, 3.18955444e-02f, 2.75690351e-02f, 7.28544816e-02f, 7.26004988e-02f, -6.65668100e-02f,
  -5.13635986e-02f, 2.91100610e-02f, 3.91715728e-02f, -6.72601461e-02f, 1.25065679e-02f, 4.88561653e-02f, 8.26127641e-03f, -1.77533049e-02f, 4.03916240e-02f, 4.15795483e-04f,
  -5.22609428e-02f, -1.63354184e-02f, 5.99720106e-02f, 1.26228228e-01f, 4.10752483e-02f, 7.00196698e-02f, 2.10718662e-02f, -8.76401588e-02f, 7.41122812e-02f, 5.25813375e-04f,
  -2.68113408e-02f, 4.42008628e-03f, -3.70042734e-02f, 6.14284128e-02f, -1.45996956e-03f, -1.85962487e-02f, 9.47120308e-04f, -4.95020710e-02f, 3.02763823e-02f, 3.58842351e-02f,
  3.37401442e-02f, -6.84303194e-02f, 1.68629680e-02f, 9.74645931e-03f, -2.27984358e-02f, 1.19673889e-02f, -3.49669978e-02f, 2.59454139e-02f, 2.64947545e-02f, -3.60648893e-02f,
  -2.81941555e-02f, 1.35497134e-02f, 1.73994619e-02f, -2.97061820e-02f, -6.30332064e-03f, 2.13280208e-02f, -5.15838414e-02f, 5.47479047e-03f, 4.18723077e-02f, -6.66811615e-02f,
  2.94399768e-01f, 1.60586491e-01f, -6.35278672e-02f, 8.58127773e-02f, -2.42948066e-02f, -3.18245068e-02f, -4.64325771e-02f, -1.12619959e-02f, -8.47758427e-02f, 1.60628539e-02f,
  -4.10627201e-03f, 4.66309115e-02f, 6.15386665e-02f, 6.40543103e-02f, -2.86693461e-02f, 5.54567799e-02f, 2.88496204e-02f, -2.52724253e-02f, -2.01247521e-02f, -3.93497050e-02f,
  -2.25407649e-02f, 1.70453608e-01f, 1.87698826e-01f, 7.19703734e-02f, 9.37387645e-02f, 9.56611261e-02f, 1.33293673e-01f, 1.57068565e-01f, 1.77005351e-01f, 1.71905205e-01f,
  4.06401694e-01f, 8.83904696e-02f, 1.64650038e-01f, 1.78564712e-01f, 2.87656840e-02f, 6.37559593e-02f, 6.98479861e-02f, -1.84042696e-02f, 1.90975800e-01f, 2.08837152e-01f,
  -1.66568950e-01f, -8.85180477e-03f, 7.68828839e-02f, 1.86218228e-02f, 5.17641380e-02f, 2.47557983e-01f, 2.04881981e-01f, 1.56311795e-01f, 6.78897724e-02f, 3.23257362e-03f,
  5.99772036e-02f, 9.08647105e-02f, 1.91523135e-01f, 7.19644642e-03f, 4.63356227e-02f, -5.55315148e-03f, 8.84446874e-02f, 1.06131405e-01f, 5.44039682e-02f, 1.45567432e-01f,
  1.04391694e-01f, 2.41282023e-02f, -6.50019124e-02f, -6.12066733e-03f, -1.16102435e-01f, 4.15796526e-02f, 5.14018908e-02f, 7.98244216e-03f, -2.83988584e-02f, 5.01935743e-02f,
  -6.01291806e-02f, 3.47268321e-02f, -6.39915615e-02f, 4.89925332e-02f, 9.54622403e-02f, 6.16740435e-04f, 1.12369239e-01f, 8.69590715e-02f, 8.25369358e-02f, -3.31009366e-02f,
  5.64606003e-02f, -2.66922452e-02f, -1.04567893e-01f, -1.85603984e-02f, -1.43544599e-02f, -1.08488314e-01f, -1.14099108e-01f, -6.58573722e-03f, -1.01270219e-02f, 6.33645877e-02f,
  -1.77450236e-02f, 2.43947515e-03f, -7.97213614e-02f, 3.57263237e-02f, -3.78903933e-02f, -6.17542909e-03f, -1.91824529e-02f, -6.96254382e-03f, 3.10494099e-02f, -3.06871012e-02f,
  7.16232741e-03f, 4.79468293e-02f, -3.95868644e-02f, 9.49806198e-02f, 1.26809878e-02f, 5.66250160e-02f, -6.56547248e-02f, 6.02037013e-02f, 5.88106103e-02f, -3.66598777e-02f,
  6.04773313e-02f, -2.03117337e-02f, -2.06827559e-02f, -1.14810327e-02f, 5.05329343e-03f, 5.51038124e-02f, -4.69546355e-02f, -3.17591466e-02f, -8.29755794e-03f, -8.12396221e-03f,
  1.17446864e-02f, -2.58937091e-01f, 9.22684520e-02f, 1.26122564e-01f, 6.87532425e-02f, -4.85143997e-02f, 1.81860290e-03f, -7.16924714e-03f, -1.38561828e-02f, 3.93087603e-02f,
  -9.94528830e-02f, 1.12660052e-02f, 7.54914284e-02f, -8.62838551e-02f, -9.01797861e-02f, 3.47695872e-02f, -1.26583008e-02f, -2.39850283e-02f, -3.57102789e-02f, 2.87039019e-02f,
  -5.82980849e-02f, 8.95094872e-02f, 3.86341028e-02f, 2.01392081e-02f, -3.87135893e-02f, -1.68143902e-02f, -9.45789292e-02f, -4.24477905e-02f, -8.09555054e-02f, 1.35722190e-01f,
  -6.94959331e-03f, 2.13534907e-02f, -5.19870315e-03f, 7.13553205e-02f, -1.77000105e-01f, -3.70434612e-01f, -4.90145326e-01f, -2.96636850e-01f, 4.94101532e-02f, -8.24750289e-02f,
  1.55317485e-01f, 1.81615695e-01f, 1.59379423e-01f, 4.38953303e-02f, -1.97373569e-01f, -1.83314383e-01f, -8.53308961e-02f, 1.54328719e-02f, -6.39555082e-02f, -1.88630983e-01f,
  -2.83358619e-02f, -2.00316999e-02f, 9.70117096e-03f, -3.15013938e-02f, 1.16434649e-01f, 2.07700476e-01f, 1.26124635e-01f, 1.65191814e-01f, -4.54076938e-02f, 2.52485126e-01f,
  3.83488595e-01f, 7.75775313e-02f, -7.37365559e-02f, 5.37600145e-02f, 8.86654258e-02f, -6.09832257e-02f, -5.54478504e-02f, 6.45878986e-02f, 4.78707661e-04f, -7.40911514e-02f,
  1.35138363e-01f, 6.23497479e-02f, 7.32183736e-03f, 2.69114077e-02f, 7.76748359e-03f, -1.90207660e-02f, 3.17048766e-02f, 6.77147061e-02f, -3.06894407e-02f, 2.44391132e-02f,
  4.69864858e-03f, -6.39712512e-02f, -3.18780094e-02f, -1.24762304e-01f, 5.21881245e-02f, -1.11820668e-01f, -5.57557121e-02f, 8.35165158e-02f, -4.63597812e-02f, 2.91185826e-02f,
  -8.76502618e-02f, 3.78879085e-02f, -5.31607568e-02f, -2.55015288e-02f, -3.26990671e-02f, 5.27864844e-02f, 2.41843192e-03f, -3.22685279e-02f, -6.33554682e-02f, 5.35975434e-02f,
  -8.53269361e-03f, 2.50489218e-03f, -1.91856362e-02f, 2.67568324e-03f, 3.50392573e-02f, -3.00905015e-02f, -5.02484366e-02f, -1.94196478e-02f, 1.23696387e-04f, 2.85243914e-02f,
  5.31185605e-02f, -2.50646677e-02f, 9.99486521e-02f, 3.98291498e-02f, -5.03336526e-02f, 2.75934543e-02f, 2.94345766e-02f, -3.58758494e-02f, 7.52670392e-02f, -1.06947804e-02f,
  1.68255016e-01f, -2.62179703e-01f, 6.52859733e-02f, -1.34793371e-02f, 7.51065761e-02f, 1.38194233e-01f, 9.08548459e-02f, 2.97555607e-02f, 7.87823647e-02f, -1.18137139e-03f,
  -6.00814670e-02f, 3.07213478e-02f, 1.27680182e-01f, 6.75398810e-03f, -4.32964303e-02f, -1.77206136e-02f, 7.86699727e-03f, -1.45266224e-02f, 2.64529977e-02f, 1.13569535e-01f,
  6.36891872e-02f, -1.21425509e-01f, -8.93233344e-02f, -1.53565640e-02f, -8.53069406e-03f, -8.55480880e-02f, -4.51994985e-02f, -4.46362756e-02f, -1.12457998e-01f, -1.86150953e-01f,
  1.00971490e-01f, 7.79073387e-02f, 1.91822633e-01f, -5.62020987e-02f, 2.49224842e-01f, 3.39014322e-01f, 5.05036354e-01f, 2.53240138e-01f, 7.99186379e-02f, 1.03616059e-01f,
  -6.69484138e-02f, -3.35535645e-01f, -2.26508200e-01f, -1.93467125e-01f, -5.05258851e-02f, 1.22245371e-01f, 7.61087313e-02f, -3.34502049e-02f, -7.00114891e-02f, 1.55643001e-02f,
  1.36546846e-02f, 6.77353097e-03f, -1.60358042e-01f, -1.74640357e-01f, -1.46991014e-01f, -1.04857080e-01f, -6.91478774e-02f, -2.65976368e-03f, -2.89712902e-02f, -2.76128888e-01f,
  -1.24948427e-01f, 1.36734739e-01f, 1.17356377e-02f, -1.73874602e-01f, -7.37880841e-02f, -5.11059985e-02f, -3.63041461e-02f, -4.43322323e-02f, -2.65549142e-02f, -3.55193764e-02f,
  3.77988821e-04f, -6.00984134e-03f, -7.97509328e-02f, -2.22398117e-02f, 7.05224648e-02f, 5.38612418e-02f, -9.31213051e-02f, -1.65959559e-02f, -1.71671342e-02f, 2.34562512e-02f,
  -9.99258980e-02f, -2.55542604e-04f, 9.78346094e-02f, 2.99862064e-02f, 6.86819032e-02f, -3.66916060e-02f, -3.00940070e-02f, 4.81836163e-02f, 1.10365205e-01f, 8.21369793e-03f,
  -4.57098931e-02f, -2.22193655e-02f, -6.47124872e-02f, 1.79252662e-02f, -2.61925235e-02f, 9.75999050e-03f, -1.89037491e-02f, 2.56451163e-02f, -4.29006992e-03f, -1.54515626e-02f,
  1.77442022e-02f, 3.99169745e-03f, 4.94614989e-02f, 1.01938937e-02f, -4.76911291e-02f, -8.15845747e-03f, 5.78323454e-02f, -8.11510906e-02f, 3.36998366e-02f, 3.81350331e-02f,
  4.06686887e-02f, -1.25408182e-02f, -5.93844429e-02f, 4.86438768e-03f, -7.72184059e-02f, -1.74757652e-02f, 1.25034833e-02f, 3.83434296e-02f, -1.02677811e-02f, 2.89614797e-02f,
  -7.22781867e-02f, -1.88515075e-02f, -6.98980018e-02f, -1.92542803e-02f, -4.11072373e-02f, 2.59023290e-02f, -8.46799836e-02f, -5.06209396e-02f, -2.43969113e-02f, 1.46737108e-02f,
  -2.32382007e-02f, 6.41442910e-02f, 4.65031862e-02f, 4.60442118e-02f, 9.69455540e-02f, 2.58435737e-02f, 2.19962373e-02f, -7.48303533e-02f, 2.76370766e-03f, 6.01990521e-02f,
  9.02164504e-02f, 1.46477699e-01f, 1.47938862e-01f, 1.05642751e-01f, 7.94189498e-02f, -4.56323400e-02f, 8.95586237e-02f, 1.31183853e-02f, 1.16930567e-01f, 1.25072151e-01f,
  1.85580462e-01f, -1.88506231e-01f, 2.36612141e-01f, 1.20853230e-01f, -5.81318066e-02f, -7.76808783e-02f, -7.84475431e-02f, -4.59432006e-02f, 1.16200343e-01f, -3.15689226e-03f,
  -1.96156546e-01f, -1.81775436e-01f, -9.22820345e-02f, -2.95769982e-02f, 4.19278741e-02f, 1.25376195e-01f, 2.02347785e-01f, 1.42809913e-01f, 2.30613038e-01f, 4.35810024e-03f,
  -1.01910353e-01f, 3.38283256e-02f, 1.53480589e-01f, 7.63931125e-02f, 6.00484498e-02f, -2.02248152e-02f, 4.41678986e-02f, 3.08124290e-04f, 6.26520067e-02f, 1.19866140e-01f,
  1.52820721e-02f, -1.08131580e-01f, 2.99027972e-02f, -5.56990802e-02f, -4.08477634e-02f, -3.22807990e-02f, -4.20355517e-03f, 6.16485029e-02f, -3.93738300e-02f, 3.33959796e-02f,
  -9.42116305e-02f, -2.35731043e-02f, -1.19279707e-02f, 6.05204813e-02f, 6.22482002e-02f, 6.09389618e-02f, -9.08633787e-03f, 1.44987494e-01f, 5.67883328e-02f, -5.82606345e-02f,
  -6.63284957e-02f, -1.22862943e-01f, -3.47618237e-02f, 2.90634204e-02f, 3.42009142e-02f, 3.71376276e-02f, 7.50408396e-02f, 3.20319347e-02f, 1.52752800e-02f, 1.85350001e-01f,
  3.83126084e-03f, -9.41311382e-03f, -2.40817647e-02f, 7.08068779e-04f, -3.00447047e-02f, 3.69160846e-02f, -2.24032477e-02f, 1.91525910e-02f, 4.88672638e-03f, 8.01849291e-02f,
  2.29062159e-02f, 1.03828004e-02f, -5.28106978e-03f, -2.20386628e-02f, 4.10030037e-02f, -1.17968423e-02f, -3.17357518e-02f, -3.29140015e-02f, -7.15555996e-02f, -1.04172770e-02f,
  2.90463865e-02f, -2.35013962e-02f, -5.16780987e-02f, 7.53468871e-02f, -2.53769998e-02f, 7.45410696e-02f, 4.38639522e-02f, -3.06718666e-02f, -4.35235584e-03f, 2.19852547e-03f,
  -4.88548912e-02f, -8.55039805e-02f, 2.22445503e-02f, 4.67402749e-02f, 8.20242763e-02f, -5.89510351e-02f, -7.47819245e-02f, -1.09007964e-02f, -1.11758709e-01f, -7.15673761e-03f,
  -3.41300219e-02f, 7.97230899e-02f, -1.10684440e-01f, -5.86124733e-02f, 7.04042315e-02f, 2.63521541e-03f, 4.00800779e-02f, -3.14879753e-02f, -2.42350250e-02f, -5.70363067e-02f,
  -4.03521992e-02f, 4.37255129e-02f, -4.20700982e-02f, 1.45918399e-03f, -1.79142077e-02f, -3.19004133e-02f, 9.31781456e-02f, 1.13285311e-01f, 6.10895306e-02f, 9.64595154e-02f,
  8.36615860e-01f, 5.63490903e-03f, -3.25630456e-02f, 2.58044451e-01f, -2.08673105e-01f, -3.76347527e-02f, -8.05695951e-02f, 7.82828331e-02f, 6.18264563e-02f, -8.84985402e-02f,
  -2.74474561e-01f, -2.09336162e-01f, -6.79043680e-02f, 2.45009433e-03f, 1.34104975e-02f, 8.20712000e-03f, 2.03783885e-01f, 2.04300910e-01f, 5.85587695e-02f, -2.91904267e-02f,
  4.24071355e-03f, 1.21137723e-01f, 2.90786862e-01f, 2.01687798e-01f, 6.96043447e-02f, -7.50215575e-02f, 7.23014399e-02f, -4.83845435e-02f, -7.96926990e-02f, 1.94463789e-01f,
  -1.59929007e-01f, 1.46661967e-01f, -4.87494282e-02f, -9.81986895e-03f, -8.89065042e-02f, 5.07559888e-02f, -1.51738673e-02f, -2.07754259e-04f, -6.33043796e-02f, 8.80170986e-02f,
  -9.34235230e-02f, 7.11947754e-02f, -4.31600735e-02f, -7.42273182e-02f, 1.75813877e-03f, 4.18426357e-02f, 5.49496934e-02f, 1.75918385e-01f, 5.16304560e-02f, -2.68825907e-02f,
  -1.68889478e-01f, 3.68870720e-02f, -5.33277616e-02f, -5.20292148e-02f, 5.73966326e-03f, -2.95950472e-02f, -1.55613407e-01f, 1.74311157e-02f, -4.63928990e-02f, 3.89967598e-02f,
  -3.62211540e-02f, 1.82000883e-02f, 1.82362925e-03f, 2.32952219e-02f, 3.48946787e-02f, -2.29800735e-02f, 2.37645488e-02f, -3.91374379e-02f, 2.12267712e-02f, 1.08215036e-02f,
  9.62493103e-03f, -1.09989762e-01f, 3.25948484e-02f, 4.22157720e-02f, -5.01874164e-02f, 2.60129049e-02f, 7.29958415e-02f, -5.36401346e-02f, -4.01183516e-02f, 2.79364511e-02f,
  -3.50475833e-02f, 3.77157256e-02f, -3.79970632e-02f, -4.13496867e-02f, 6.26568720e-02f, -3.09830066e-03f, 7.39078894e-02f, -6.99727312e-02f, -1.51705565e-02f, 1.10866539e-02f,
  -2.07754858e-02f, -1.16863966e-01f, 1.09213375e-01f, 5.79801090e-02f, -6.66258931e-02f, 1.78455189e-02f, -9.05621052e-02f, -1.87027978e-03f, 9.88188852e-03f, 4.61357906e-02f,
  -4.51736189e-02f, 3.63173448e-02f, -2.57804687e-03f, -1.70373078e-02f, 1.86651368e-02f, -4.14396971e-02f, 4.83878180e-02f, 2.79307161e-02f, 1.36374366e-02f, -3.80246080e-02f,
  3.24342176e-02f, 1.02628641e-01f, 8.89017582e-02f, -3.91566753e-03f, -1.14538521e-01f, -3.79847474e-02f, -7.04843029e-02f, 2.27495041e-02f, -8.00661335e-04f, 1.13319159e-01f,
  -1.91918075e-01f, -5.18987179e-01f, -2.23264307e-01f, 1.01552181e-01f, 1.28622912e-03f, -1.18446583e-02f, -1.54602781e-01f, 3.94381955e-03f, 1.26014084e-01f, -2.25389630e-01f,
  -1.35470197e-01f, 6.12581447e-02f, 8.25444162e-02f, -3.25275101e-02f, -6.72756210e-02f, -1.64982989e-01f, -2.62418855e-02f, 7.59632066e-02f, 2.72965461e-01f, 2.08046436e-01f,
  -6.86635450e-03f, 1.18387818e-01f, 1.34146929e-01f, 2.86279637e-02f, -5.14164977e-02f, 1.73476133e-02f, -7.34329075e-02f, -1.24771014e-01f, -2.53389210e-01f, -3.66750687e-01f,
  -4.60196733e-01f, -2.04062700e-01f, 1.92355543e-01f, 5.39996773e-02f, -1.59883406e-02f, -8.60246643e-03f, 1.45011675e-02f, 2.02838518e-02f, 3.24035883e-02f, 2.57450901e-02f,
  -4.23982479e-02f, 1.33925946e-02f, 2.72418223e-02f, -2.08076853e-02f, 3.33206058e-02f, -4.52945456e-02f, 7.58343413e-02f, -4.12520692e-02f, 1.94921289e-02f, -8.02616924e-02f,
  -8.79427418e-02f, -1.40036698e-02f, -1.19868375e-01f, -2.43726783e-02f, 3.20183672e-02f, 9.04457847e-05f, -1.02729820e-01f, -1.09450914e-01f, -1.29522473e-01f, -2.67592072e-01f,
  -2.16268599e-02f, 3.98127437e-02f, 9.80270468e-03f, 2.59598512e-02f, -4.32764068e-02f, 3.23847309e-03f, 4.78748651e-03f, -5.55628240e-02f, 2.60165501e-02f, 2.35275421e-02f,
  2.47668736e-02f, -7.24606141e-02f, -5.08678295e-02f, -9.40524228e-03f, -2.76039168e-02f, 3.01257335e-02f, -1.13150422e-02f, -4.09283936e-02f, 3.96821387e-02f, 5.17076962e-02f,
  -7.92083964e-02f, 2.36999094e-02f, 2.65009981e-02f, -1.70637686e-02f, -6.47714809e-02f, -2.50059944e-02f, -3.02643739e-02f, -1.89568028e-02f, 3.51714976e-02f, -1.27472376e-04f,
  1.02999985e-01f, 2.07291976e-01f, -1.93076566e-01f, -2.45832670e-02f, 4.93940823e-02f, 7.18364567e-02f, -7.32710809e-02f, 7.68243149e-02f, -1.77506637e-02f, -6.40596449e-02f,
  6.84632268e-03f, 1.21787628e-02f, -8.93810689e-02f, -1.00989407e-02f, 2.82873921e-02f, 6.62235692e-02f, 3.04846615e-02f, 1.34974122e-02f, 6.80424646e-02f, -1.11811515e-02f,
  5.13328388e-02f, -2.53393035e-02f, 1.94715932e-02f, 2.02267524e-02f, -1.47523060e-02f, 4.33794335e-02f, -1.89382821e-01f, -2.69609261e-02f, -5.26672666e-05f, -8.96121785e-02f,
  -3.45802009e-01f, -2.55324274e-01f, 4.04644161e-01f, -1.15961596e-01f, -1.71960160e-01f, -1.88734293e-01f, -4.12525177e-01f, -1.17239706e-01f, 2.26251185e-02f, -7.37400651e-02f,
  -2.01802254e-01f, -1.57189488e-01f, 2.59547215e-03f, 6.97676763e-02f, 1.41579406e-02f, 2.77228672e-02f, 2.31127292e-01f, 1.30149141e-01f, 1.77640989e-01f, -1.35051817e-01f,
  -1.73234597e-01f, 9.84829757e-03f, -5.19157685e-02f, 2.15786155e-02f, 1.56941980e-01f, 7.05154166e-02f, 9.96359140e-02f, 7.98766539e-02f, -7.64222816e-02f, 9.79086608e-02f,
  2.90056437e-01f, -1.67936087e-01f, 4.36840765e-02f, -9.32228863e-02f, -3.91855314e-02f, 9.45192054e-02f, 3.78533602e-02f, 9.49877501e-02f, -4.65511903e-02f, 1.04224525e-01f,
  -5.31290993e-02f, -9.30176005e-02f, -2.07098406e-02f, 4.74353544e-02f, -2.93502714e-02f, 3.32038440e-02f, 4.63794395e-02f, 1.61705583e-01f, 8.75747949e-02f, -3.50370407e-02f,
  -1.21961050e-01f, -2.25766391e-01f, -5.63712791e-02f, 7.59207532e-02f, 4.93956134e-02f, 3.35141234e-02f, -1.63027942e-02f, -9.72011033e-03f, 9.83283594e-02f, 8.73241276e-02f,
  -6.08219905e-03f, 6.23747706e-02f, 6.08134270e-03f, -2.42431592e-02f, -4.62732054e-02f, -4.84160241e-03f, -2.04604375e-03f, -1.57992970e-02f, 6.18498353e-03f, 1.13900351e-04f,
  -5.69344796e-02f, -4.41797562e-02f, -3.86924259e-02f, -3.86212394e-03f, 4.52650245e-03f, -1.79136973e-02f, -7.51297921e-02f, 5.32570407e-02f, 1.51329003e-02f, -7.06470907e-02f,
  -1.93480197e-02f, 6.41260445e-02f, -3.40479203e-02f, 8.58255178e-02f, -1.47023331e-02f, 1.24749457e-02f, 2.40019131e-02f, 2.19174800e-03f, 4.58861236e-03f, -2.21361928e-02f,
  -3.54059525e-02f, -8.83224756e-02f, 2.61912383e-02f, -1.02779614e-02f, 5.67649938e-02f, 6.04768284e-02f, -6.43744469e-02f, 6.33288771e-02f, -3.52787934e-02f, 3.25166062e-02f,
  -4.22690697e-02f, 2.56213769e-02f, -7.90510997e-02f, 8.79245251e-02f, -4.29280959e-02f, -3.91445309e-02f, -1.36063799e-01f, 3.95961143e-02f, 1.10113127e-02f, 7.05078319e-02f,
  3.17057222e-02f, -6.41144887e-02f, -8.53129923e-02f, 2.97794063e-02f, -1.52210230e-02f, -5.89552037e-02f, -2.11372636e-02f, 4.75483015e-02f, -5.14213517e-02f, -5.02807461e-02f,
  -9.26398411e-02f, 2.70633161e-01f, 3.00292343e-01f, -4.69863079e-02f, -8.81567746e-02f, -1.53403789e-01f, -1.88333597e-02f, -1.96692627e-03f, -4.61187512e-02f, -2.77032666e-02f,
  -3.19586173e-02f, -6.22498132e-02f, -5.98086715e-02f, 5.30843884e-02f, 1.16265364e-01f, 9.73906443e-02f, 7.89131224e-02f, 1.27853870e-01f, -1.55031040e-01f, -2.53910005e-01f,
  -7.44382739e-02f, -1.46861106e-01f, 5.20912632e-02f, 8.92818421e-02f, -7.15912208e-02f, -1.27428072e-02f, 7.87436962e-02f, 6.25677407e-02f, 3.95332538e-02f, 1.29890859e-01f,
  -9.99345211e-04f, 2.04498276e-01f, -5.76589219e-02f, 4.35775258e-02f, 9.90254134e-02f, 2.67364923e-03f, -5.08228652e-02f, 7.70790949e-02f, -3.08995508e-02f, 3.27219479e-02f,
  2.85423379e-02f, 1.38927214e-02f, 4.97000627e-02f, -5.21906503e-02f, -6.46112338e-02f, -4.08716425e-02f, -1.35712735e-02f, 5.46347983e-02f, 2.87463777e-02f, 1.60144866e-02f,
  -3.41698937e-02f, -1.24895927e-02f, -4.52545173e-02f, 3.94619396e-03f, 3.30034196e-02f, 9.88868531e-03f, 9.22583342e-02f, 6.51542172e-02f, 2.07311399e-02f, 1.66160036e-02f,
  -2.47473400e-02f, 3.06009408e-02f, 7.16759183e-04f, 3.99811752e-02f, -8.87408620e-04f, 3.39722796e-03f, 3.59800644e-02f, 1.21147837e-02f, 5.38714305e-02f, -1.00207794e-02f,
  1.95898749e-02f, -1.52809219e-02f, 1.15985237e-02f, -4.97003319e-03f, 3.21183680e-03f, 1.95003580e-02f, -2.04099547e-02f, -3.36140580e-02f, 3.55705768e-02f, -4.34292741e-02f,
  6.36659712e-02f, -6.45550117e-02f, 2.66144127e-02f, -2.20914967e-02f, 7.13502802e-03f, 2.84235254e-02f, 1.65555235e-02f, -4.66733947e-02f, -6.85529336e-02f, -2.36907490e-02f,
  -2.54592657e-01f, 1.60914242e-01f, -1.11960970e-01f, -9.44129005e-02f, -1.45583572e-02f, -2.80266237e-02f, 1.75948162e-02f, 8.32146704e-02f, 3.87138613e-02f, -2.44897753e-02f,
  -5.10043949e-02f, 2.75391992e-02f, -1.67940073e-02f, 4.47052307e-02f, -5.46790622e-02f, -6.04933463e-02f, -3.46732559e-04f, 1.06443819e-02f, -5.23152389e-02f, -5.95059060e-02f,
  3.83103937e-02f, -2.67184585e-01f, -3.06301832e-01f, -1.44406199e-01f, -1.46786615e-01f, -1.66582495e-01f, -1.26645848e-01f, -1.57643318e-01f, -2.40539193e-01f, -2.20585868e-01f,
  1.38374448e-01f, -8.06764811e-02f, -3.60946327e-01f, 1.17111124e-01f, -3.03499792e-02f, -1.11652195e-01f, -7.19925538e-02f, 1.28228255e-02f, 1.27307922e-01f, -5.27162068e-02f,
  -3.12441085e-02f, 1.27543077e-01f, 7.35636503e-02f, -1.86130255e-02f, 1.03591330e-01f, -6.60513490e-02f, 1.75746351e-01f, 4.38514762e-02f, 2.05888450e-02f, 5.07428404e-03f,
  1.91226035e-01f, 1.30695075e-01f, 2.35830396e-01f, 1.80708319e-01f, 6.32756799e-02f, 1.98289361e-02f, -4.70419489e-02f, 3.49091217e-02f, -6.68476894e-02f, 1.42016277e-01f,
  -3.62946600e-01f, -1.52362481e-01f, -3.33025567e-02f, 1.14944413e-01f, -1.45154461e-01f, -1.51617583e-02f, -1.24205165e-02f, -1.82853043e-02f, 9.04602483e-02f, 3.05351987e-02f,
  -1.39203982e-03f, -1.28274504e-02f, 7.72479502e-03f, -5.05575584e-03f, -8.54862109e-02f, -8.09009895e-02f, 1.23786762e-01f, -3.74641716e-02f, -5.67941666e-02f, -1.44146066e-02f,
  1.02398902e-01f, -3.96438763e-02f, -8.05838555e-02f, -1.04129434e-01f, -1.01465233e-01f, 2.64008977e-02f, -6.00766912e-02f, -9.42293853e-02f, -1.63907364e-01f, 2.61638183e-02f,
  -3.30190100e-02f, 9.14591714e-04f, -7.54600838e-02f, 5.75292222e-02f, 5.71758151e-02f, -4.51275930e-02f, 4.84217256e-02f, 6.67032376e-02f, 9.48900357e-03f, 1.05610201e-02f,
  -7.53634796e-03f, -6.84962515e-03f, 3.39472257e-02f, -4.41986043e-03f, -3.95990685e-02f, -2.60344241e-02f, 3.68719585e-02f, 4.03025895e-02f, 2.21148878e-02f, -2.71670427e-02f,
  8.87801312e-03f, -3.34503204e-02f, -3.71051654e-02f, 8.12080428e-02f, -9.65067465e-03f, 5.89235984e-02f, 6.41077980e-02f, -6.45903423e-02f, 2.42589461e-03f, 2.78841387e-02f,
  -1.30825013e-01f, -1.00428261e-01f, 9.21535715e-02f, 9.71615314e-02f, -6.04639761e-02f, -3.48906368e-02f, -1.51204579e-02f, 1.03221955e-02f, -1.32473018e-02f, -6.37442665e-03f,
  -8.88148621e-02f, 7.57071227e-02f, -1.23482803e-02f, 1.55469421e-02f, -2.10453942e-02f, -5.84949553e-03f, 5.25439642e-02f, 7.98543096e-02f, 8.25455785e-02f, -1.90291684e-02f,
  7.57395998e-02f, -3.47388089e-02f, -9.79298577e-02f, -1.09418750e-01f, 5.40480874e-02f, 2.77390517e-02f, -1.87082477e-02f, -1.17299557e-01f, -9.04102474e-02f, 4.30857654e-05f,
  1.51463866e-01f, -1.27933279e-01f, 2.13500395e-01f, 6.14093468e-02f, 7.55624101e-02f, 6.15415610e-02f, 6.67807534e-02f, -8.60224292e-02f, -6.50788844e-02f, -2.11123899e-02f,
  -1.48161858e-01f, -1.09875008e-01f, -1.38648702e-02f, 1.22467123e-01f, 1.38296559e-01f, 5.57862371e-02f, 2.17504293e-01f, 3.18773568e-01f, 3.95641029e-01f, 1.60475343e-01f,
  3.05612367e-02f, 2.01616719e-01f, 2.62139529e-01f, 1.60087556e-01f, 5.28608710e-02f, 5.91495931e-02f, 5.00146337e-02f, 4.81473394e-02f, 8.03636834e-02f, 6.68054819e-02f,
  -1.78108402e-02f, -3.87414955e-02f, 7.30362758e-02f, -1.01579331e-01f, -1.35427304e-02f, -1.03842476e-02f, -8.50875601e-02f, -7.20024807e-03f, -9.10270736e-02f, -6.44249916e-02f,
  1.58822928e-02f, 1.38837155e-02f, 3.53219956e-02f, 1.02605946e-01f, 1.24942660e-02f, 2.04946939e-02f, 1.85064934e-02f, 3.19508277e-02f, 9.95746348e-03f, -7.89938048e-02f,
  -1.19170686e-02f, 5.53704016e-02f, 7.11311325e-02f, -1.44467086e-01f, -4.88377549e-02f, 5.39586246e-02f, -1.42073214e-01f, -1.14504799e-01f, -2.95464825e-02f, -1.94030739e-02f,
  5.68502322e-02f, -3.71820256e-02f, -5.49823139e-03f, -4.42812443e-02f, -1.32480040e-02f, -3.18420753e-02f, -4.28679287e-02f, -8.25689454e-03f, 5.88505752e-02f, 6.02072710e-03f,
  -4.61050272e-02f, -3.70004550e-02f, 3.29673439e-02f, -1.47366673e-02f, -2.44069304e-02f, 1.42152458e-02f, -4.00761440e-02f, -3.71911898e-02f, 3.08787320e-02f, 2.78278422e-02f,
  -1.07798381e-02f, 1.35232611e-02f, 4.72684484e-03f, -1.45187583e-02f, -2.22792253e-02f, -6.19235374e-02f, 2.26528253e-02f, -4.40834723e-02f, 6.15392439e-02f, 5.77396937e-02f,
  -1.36719614e-01f, 1.08427875e-01f, -6.63889572e-02f, 7.16784373e-02f, 5.79331033e-02f, -8.34353939e-02f, -5.29488549e-03f, -2.23651007e-02f, -4.71920194e-03f, -4.93206177e-03f,
  -1.50935468e-03f, -6.27970472e-02f, 7.52052874e-04f, 4.90225526e-03f, 1.11001529e-01f, -2.51276903e-02f, -9.48325321e-02f, 7.74227455e-03f, 5.69561496e-02f, -3.39504480e-02f,
  -1.35471195e-01f, -6.73075020e-02f, -1.31625868e-02f, -4.14035246e-02f, 1.83957294e-02f, 1.01124324e-01f, 2.38407813e-02f, 3.34786437e-03f, 7.22765401e-02f, -9.68352258e-02f,
  -9.28420246e-01f, 8.41158479e-02f, 2.50144124e-01f, -2.14089915e-01f, 2.63896376e-01f, 1.79540247e-01f, 2.90896863e-01f, -6.99340031e-02f, -7.71504864e-02f, 9.01020914e-02f,
  -1.20209903e-02f, -2.23751485e-01f, -8.41396078e-02f, -1.47354335e-01f, -1.36689469e-01f, 1.14978373e-01f, 2.85520434e-01f, -8.96029547e-02f, -9.84605253e-02f, -6.46529719e-02f,
  1.45057142e-01f, -1.06208034e-01f, -2.37053633e-01f, -8.24154615e-02f, 7.42393136e-02f, 6.31863922e-02f, 2.21431881e-01f, 3.40190865e-02f, 8.58339518e-02f, 8.73755291e-02f,
  7.77042434e-02f, -2.76706725e-01f, 8.18124115e-02f, 1.18440194e-02f, 1.21033706e-01f, -9.62543041e-02f, -3.98440547e-02f, -6.44791052e-02f, -2.95846127e-02f, -3.88920195e-02f,
  8.67268909e-03f, -3.46521549e-02f, -8.64134654e-02f, 4.03093770e-02f, -9.05852839e-02f, -6.69928715e-02f, 1.65413804e-02f, -6.82106689e-02f, -4.52814326e-02f, -3.05796117e-02f,
  7.49782696e-02f, 1.18984580e-01f, -8.37415904e-02f, 3.64265929e-04f, -9.54239443e-02f, -2.00394355e-02f, -1.27498815e-02f, -6.03036359e-02f, 1.00630177e-02f, -7.78961778e-02f,
  1.42523861e-02f, 3.65771875e-02f, -3.32346782e-02f, -7.41327414e-04f, -6.10454082e-02f, 4.24605086e-02f, 2.47101784e-02f, 5.76629816e-03f, -3.93826105e-02f, -3.76615338e-02f,
  6.99856654e-02f, -1.43014537e-02f, 1.81152001e-02f, -7.79119581e-02f, -1.86441336e-02f, 1.43701248e-02f, 2.52383072e-02f, -5.93341514e-02f, 2.35715285e-02f, -2.48665735e-03f,
  -4.09490541e-02f, -2.92650573e-02f, 1.01021901e-01f, 1.63778067e-02f, 7.84394071e-02f, -3.62838656e-02f, 3.49130319e-03f, -1.96537171e-02f, -7.80260488e-02f, 4.07093093e-02f,
  -2.93089077e-02f, 7.23195001e-02f, -7.80690685e-02f, -1.48258418e-01f, 1.05259307e-02f, -5.25549939e-03f, 4.91600949e-03f, -1.04774772e-04f, -1.54516017e-02f, -5.02769612e-02f,
  -8.19840729e-02f, -1.23923950e-01f, 2.37744693e-02f, 2.10650284e-02f, 1.12055270e-02f, -8.97292122e-02f, 3.94218275e-03f, 1.05177267e-02f, 3.64126563e-02f, 9.65539292e-02f,
  6.33673817e-02f, -4.91442643e-02f, -5.71847009e-03f, 7.23518431e-02f, -3.30087170e-02f, -7.66866356e-02f, 1.72071084e-01f, 4.66800295e-02f, -2.84191184e-02f, 6.65685982e-02f,
  -3.63470227e-01f, -1.89364150e-01f, -6.93400577e-02f, -1.07775450e-01f, 9.10173059e-02f, -8.27232748e-02f, -2.43901059e-01f, -1.36187762e-01f, -3.42242159e-02f, -6.10679314e-02f,
  1.43143848e-01f, 2.14027211e-01f, 1.35207668e-01f, 1.99695736e-01f, -2.82750558e-02f, -1.29782781e-01f, 2.69559771e-02f, -2.10415386e-03f, 1.97553843e-01f, -7.18662469e-03f,
  1.05379209e-01f, 5.58439037e-03f, 3.39657106e-02f, -3.90698714e-03f, -6.13234355e-04f, 1.14363931e-01f, 7.29800612e-02f, 1.15586624e-01f, 3.57659906e-02f, 1.98393539e-01f,
  9.64998379e-02f, -1.52485237e-01f, 1.13385610e-01f, 1.03928529e-01f, 1.96074676e-02f, -1.33061737e-01f, -6.27276003e-02f, -1.23810098e-01f, -9.43522528e-02f, -1.10730873e-02f,
  1.41120851e-01f, 1.16599128e-02f, 1.30306050e-01f, 8.74807611e-02f, -1.96678210e-02f, 4.61964905e-02f, -1.63144127e-01f, -6.35896176e-02f, -2.65805628e-02f, -1.18575826e-01f,
  6.04999103e-02f, 7.17968270e-02f, 1.49547672e-02f, 9.90333129e-03f, 5.15883148e-04f, 1.88335344e-01f, -2.13561188e-02f, 1.79069936e-02f, -9.03192386e-02f, -1.63760349e-01f,
  -4.53915261e-02f, 3.52156162e-02f, -7.72248395e-03f, -2.06016488e-02f, -1.63399167e-02f, 1.63482956e-03f, 1.93484109e-02f, -1.23200752e-02f, 8.16216841e-02f, -8.73637274e-02f,
  -2.32036859e-02f, -1.23072080e-02f, -1.02902204e-02f, -4.33187596e-02f, 8.70347470e-02f, -4.71122861e-02f, 4.84235249e-02f, -3.83275338e-02f, -1.66428722e-02f, -5.04817069e-02f,
  4.36287373e-02f, -3.72131057e-02f, 7.72627769e-03f, 3.48492265e-02f, 2.43993886e-02f, 2.57424042e-02f, 2.34331973e-02f, 4.26160805e-02f, 7.13175014e-02f, -2.48127580e-02f,
  1.85739005e-03f, 2.09562987e-01f, -2.93696541e-02f, 6.75802976e-02f, 5.86608835e-02f, 2.32624542e-02f, 9.35481042e-02f, -3.86668704e-02f, 1.55819297e-01f, -1.91439560e-03f,
  7.25391731e-02f, 6.37366846e-02f, -1.19248722e-02f, -5.85752819e-03f, 3.13367322e-02f, -2.37486698e-02f, -8.82618129e-02f, 4.13030460e-02f, 6.37186691e-02f, 1.44254637e-03f,
  -1.39933433e-02f, -7.03062862e-02f, -1.49275273e-01f, -1.90661289e-02f, -1.31078297e-02f, 8.42839926e-02f, -6.68136775e-02f, -3.51026319e-02f, -3.08247842e-02f, -3.26206833e-01f,
  2.76023805e-01f, 3.23349565e-01f, 2.80371178e-02f, -8.12109783e-02f, -3.13409511e-03f, 9.57689423e-04f, 1.59389228e-01f, 1.35391846e-01f, 4.68610302e-02f, 1.65118665e-01f,
  2.82371014e-01f, -4.62840796e-02f, 2.06828341e-02f, -1.44131646e-01f, -9.83703434e-02f, -1.58823341e-01f, -3.16732079e-01f, -3.26066375e-01f, -3.61035049e-01f, -9.34383497e-02f,
  -8.91255736e-02f, -1.15674488e-01f, -8.19988027e-02f, -6.60195425e-02f, 5.56377275e-03f, -1.49329856e-01f, -2.61813821e-03f, 1.46745935e-01f, 2.68480293e-02f, -1.49636418e-01f,
  1.97454691e-01f, 4.56601888e-01f, -1.95256844e-01f, -7.04170242e-02f, 9.64964852e-02f, 1.87080186e-02f, 4.07878719e-02f, 5.26541360e-02f, -6.01080954e-02f, 9.10239480e-03f,
  -2.93246694e-02f, 2.35095844e-02f, 1.69343501e-02f, -8.43148306e-02f, 3.65842953e-02f, -3.85652445e-02f, -3.46908793e-02f, -6.20548613e-02f, 3.54881138e-02f, 5.49436919e-02f,
  -2.54584849e-02f, -1.33432280e-02f, 1.16280831e-01f, 5.83155127e-03f, 8.46926942e-02f, -5.78451939e-02f, 6.65180385e-02f, 7.20851347e-02f, 4.67548929e-02f, 1.30572706e-01f,
  -6.87601864e-02f, -2.58562211e-02f, -4.98828851e-02f, 9.23330858e-02f, -6.53613731e-02f, -2.02951021e-02f, -2.61704978e-02f, -3.33575420e-02f, -7.70197297e-03f, 1.48862144e-02f,
  -6.79474650e-03f, -1.00139603e-02f, 1.64872240e-02f, 3.99340130e-02f, -8.83077607e-02f, -5.24347462e-02f, -8.21311325e-02f, -2.95293564e-03f, -1.90168321e-02f, -8.61951057e-03f,
  1.89684089e-02f, 3.70770134e-02f, 4.50876132e-02f, 4.22990434e-02f, 1.72188431e-02f, -3.82073037e-02f, -7.99345225e-02f, -1.46211321e-02f, 9.19722095e-02f, 4.55247462e-02f,
  1.93688661e-01f, -1.23278033e-02f, 6.40074685e-02f, 5.10100648e-02f, -1.19177783e-02f, -3.73876877e-02f, 1.25793936e-02f, -8.63875262e-03f, 9.50580910e-02f, -1.95557973e-03f,
  7.66330659e-02f, -7.10913818e-03f, 6.84957057e-02f, -7.26437494e-02f, -5.23569807e-02f, 1.93018466e-02f, -3.85121033e-02f, -9.04053822e-02f, 8.51814449e-03f, 7.56868944e-02f,
  -6.21539690e-02f, -1.23811573e-01f, -8.82740170e-02f, 9.49112419e-03f, 9.94438827e-02f, -1.52472258e-01f, 7.51181170e-02f, -2.20599044e-02f, -7.31989965e-02f, 6.95018694e-02f,
  -3.03975523e-01f, 1.88136950e-01f, -4.85152341e-02f, 3.60158011e-02f, 2.18412846e-01f, 2.16914132e-01f, 2.39776492e-01f, -2.00713575e-02f, -1.21736199e-01f, 6.95230961e-02f,
  2.66008258e-01f, 3.83690000e-02f, -1.38307035e-01f, -1.60444558e-01f, -2.69916236e-01f, 4.25286628e-02f, -3.38786356e-02f, -2.72850782e-01f, -2.59239733e-01f, 5.56465127e-02f,
  1.05895258e-01f, -6.97030127e-02f, -2.34440744e-01f, -1.69107601e-01f, 1.98385403e-01f, 1.71991326e-02f, -1.49347940e-02f, 3.75237875e-02f, 1.74637735e-01f, 1.66497290e-01f,
  2.33180895e-01f, 1.33714303e-01f, -5.04271053e-02f, 3.62294284e-03f, 1.68892264e-01f, -1.06130734e-01f, 3.75493951e-02f, -4.06468920e-02f, 8.91088396e-02f, -2.18419414e-02f,
  1.24330766e-01f, 5.32800741e-02f, -1.61485486e-02f, 5.52453957e-02f, 6.17841706e-02f, 3.46037038e-02f, -1.13381423e-01f, -1.90006316e-01f, -1.75968617e-01f, 1.50142297e-01f,
  1.96388662e-01f, 1.64748490e-01f, 4.39242413e-03f, 6.28752336e-02f, -1.02592587e-01f, -3.93513702e-02f, 9.74096581e-02f, 2.16276310e-02f, -1.24037161e-01f, -5.63356979e-03f,
  -5.83329946e-02f, 1.55286156e-02f, -2.14145221e-02f, 8.99506453e-03f, -5.20122936e-03f, 1.48328124e-02f, -5.58334477e-02f, 9.52940360e-02f, -6.16083071e-02f, 7.13059008e-02f,
  -1.85228530e-02f, -8.29323605e-02f, -2.28651380e-03f, -9.78190377e-02f, 2.90288161e-02f, 1.00724660e-01f, 3.49793024e-03f, 1.86892841e-02f, 4.15447988e-02f, 3.36255729e-02f,
  6.35983096e-03f, 2.94197537e-02f, 3.42119597e-02f, -6.73579723e-02f, 2.50702221e-02f, -3.04601081e-02f, 1.22003416e-02f, 5.58995381e-02f, -3.23742554e-02f, -2.34434027e-02f,
  -2.37977445e-01f, -1.24119721e-01f, 2.56900620e-02f, -1.06882274e-01f, 1.24656953e-01f, -4.16667014e-03f, -3.35806957e-03f, -6.97124302e-02f, -2.17859130e-02f, 4.57070209e-02f,
  4.77068685e-02f, -7.54832551e-02f, -2.36151181e-02f, 2.11123042e-02f, -2.71938648e-03f, 3.38326730e-02f, 3.36694196e-02f, -8.37902874e-02f, -7.38009438e-02f, -2.19733845e-02f,
  -8.91893059e-02f, -2.80769635e-03f, -2.20912188e-01f, -1.62322164e-01f, 5.64074926e-02f, -1.99060053e-01f, 3.63611325e-04f, -9.31128338e-02f, -1.39571488e-01f, -1.59111232e-01f,
  2.17820611e-03f, -5.82919456e-03f, -1.12539390e-02f, 1.31766871e-01f, 2.88978994e-01f, 2.26511478e-01f, 1.89114392e-01f, 1.33166388e-01f, 4.87716272e-02f, 4.59952354e-02f,
  1.07695349e-01f, 1.59169614e-01f, 1.17792785e-01f, -7.62828765e-03f, 8.11743587e-02f, 5.42996377e-02f, 1.19848266e-01f, 1.98738743e-02f, 1.69396877e-01f, 3.00771356e-01f,
  2.24736080e-01f, 9.53347906e-02f, 1.16400741e-01f, -1.61091872e-02f, 1.61256969e-01f, 1.44069597e-01f, 1.73537042e-02f, 3.85146104e-02f, 1.09449498e-01f, 5.06287068e-02f,
  2.41048753e-01f, -5.84908687e-02f, 2.25099549e-03f, -9.49220881e-02f, 7.69619048e-02f, -1.12184808e-01f, -2.11440828e-02f, -8.78623500e-02f, -8.00369307e-02f, -6.07193522e-02f,
  -8.51705391e-03f, 1.10831168e-02f, -5.14747351e-02f, 2.84225550e-02f, -1.41596412e-02f, 4.68792543e-02f, -1.05946131e-01f, -6.52516484e-02f, -6.45927563e-02f, -4.52841520e-02f,
  6.31924644e-02f, 9.66061652e-03f, -2.63767596e-02f, -1.00675814e-01f, -1.09885953e-01f, -2.33036354e-02f, -1.11024469e-01f, -2.57616537e-03f, -1.93306267e-01f, 5.28283753e-02f,
  3.37188430e-02f, 4.83212173e-02f, 1.53573258e-02f, 1.90129951e-02f, -3.65943797e-02f, -8.07053521e-02f, 1.53746335e-02f, -5.85919097e-02f, 2.10515782e-03f, 2.64602117e-02f,
  -2.94594429e-02f, -1.02296490e-02f, 1.73350237e-02f, 7.00488836e-02f, 7.47190695e-03f, -6.55300617e-02f, 1.82122756e-02f, -1.68636739e-02f, -8.06897357e-02f, -3.20872217e-02f,
  -3.95121574e-02f, 5.21558058e-03f, -3.40341777e-02f, -3.65215205e-02f, -8.10133293e-02f, 2.64441483e-02f, 1.47789605e-02f, -4.19519097e-02f, -1.23637624e-03f, 4.90596667e-02f,
  4.80736457e-02f, -1.16928093e-01f, 3.46924551e-02f, -2.15432812e-02f, 1.98306255e-02f, -1.79044064e-02f, 1.96132548e-02f, -3.99408527e-02f, -7.63674676e-02f, 1.08142234e-01f,
  2.21762084e-03f, 1.58742256e-02f, 7.79683366e-02f, 5.75374626e-02f, 4.31955568e-02f, -2.85923798e-02f, 5.43184355e-02f, 6.41140062e-03f, -4.83987257e-02f, -2.59043928e-02f,
  -3.43892835e-02f, -1.20722540e-02f, -7.59637877e-02f, -1.95695143e-02f, 4.07646783e-02f, 5.57386689e-03f, 3.61284390e-02f, -6.25683218e-02f, -1.14125811e-01f, -2.10605245e-02f,
  -5.23533151e-02f, -9.62615386e-02f, 4.01754647e-01f, -8.15881323e-03f, -1.44471684e-02f, -5.03871776e-02f, 6.13597184e-02f, -1.34750128e-01f, -3.05051617e-02f, -5.61268181e-02f,
  -1.98666483e-01f, -8.03342983e-02f, 8.66317675e-02f, 1.12041377e-01f, 1.44959539e-01f, 1.72888532e-01f, 2.43237749e-01f, 3.46823275e-01f, 3.24028641e-01f, 7.00446069e-02f,
  -5.14635667e-02f, 4.68735322e-02f, 8.01784247e-02f, 2.71521835e-03f, -6.95076212e-02f, 2.90201493e-02f, 7.11469576e-02f, -4.78035659e-02f, 4.82531264e-03f, 7.87153244e-02f,
  2.20381975e-01f, -9.80088636e-02f, 1.39465749e-01f, -9.65484530e-02f, 6.60480857e-02f, 3.56949419e-02f, 4.35980894e-02f, 5.82959987e-02f, 6.82723802e-03f, 9.24895555e-02f,
  1.01821460e-02f, 1.46827605e-02f, 9.26175937e-02f, -3.18304561e-02f, -6.27048220e-03f, 1.18044298e-02f, 4.16436754e-02f, 1.55811697e-01f, 3.10107525e-02f, -3.62267233e-02f,
  -3.43823358e-02f, -3.79751809e-02f, 2.01567978e-01f, 5.55866212e-02f, -1.03982976e-02f, 4.28571925e-02f, 1.47314649e-03f, -6.99555948e-02f, 1.25822448e-03f, -3.47382724e-02f,
  -2.55143661e-02f, -1.94537006e-02f, -3.51567492e-02f, -3.48003618e-02f, -2.85893343e-02f, -2.56107561e-02f, 5.76812997e-02f, -1.53406309e-02f, 2.14859890e-03f, 1.17189642e-02f,
  3.76858227e-02f, -3.47000994e-02f, 4.14444543e-02f, -3.51795880e-03f, 5.49948402e-02f, -2.20868103e-02f, -4.08329964e-02f, -1.12232240e-02f, 3.16610001e-02f, -6.13113679e-02f,
  3.82677950e-02f, -3.56203616e-02f, 8.83738697e-02f, -7.03601390e-02f, 1.86038967e-02f, 2.41777152e-02f, 2.26320624e-02f, -5.45295365e-02f, 6.69841049e-03f, -2.10464429e-02f,
  7.46896630e-03f, 4.51985933e-02f, -1.74950361e-02f, 2.28911620e-02f, 1.11995162e-02f, 4.19171564e-02f, 1.25306910e-02f, 3.61694545e-02f, -2.64775306e-02f, -1.96746681e-02f,
  -1.40850600e-02f, 6.00939803e-03f, -2.46982998e-03f, -7.55089149e-02f, 4.69531752e-02f, 8.03856626e-02f, -3.08458880e-02f, 4.50010933e-02f, -1.65660447e-03f, -2.70490367e-02f,
  -3.05293556e-02f, 1.52913511e-01f, 1.47759214e-01f, 4.65030484e-02f, -3.70878428e-02f, 8.08155835e-02f, 1.19532861e-01f, -1.12753883e-02f, 7.16251656e-02f, 1.33494094e-01f,
  3.61845642e-01f, 1.09998010e-01f, -3.73425744e-02f, 4.02911425e-01f, 1.54225647e-01f, -1.92285448e-01f, -3.69062006e-01f, -1.43066168e-01f, 2.53560632e-01f, 9.41751227e-02f,
  1.13608718e-01f, -5.80552593e-02f, -1.04877010e-01f, -2.53359914e-01f, -3.49365860e-01f, -9.86981615e-02f, 4.31383438e-02f, -1.40622839e-01f, -3.76473844e-01f, -1.87817723e-01f,
  5.63139766e-02f, 2.53848821e-01f, 2.16608509e-01f, 6.91187754e-02f, 2.24697977e-01f, -3.50309834e-02f, 2.48502403e-01f, 1.51513651e-01f, -5.19657284e-02f, 1.68654069e-01f,
  -1.02446087e-01f, 5.56014702e-02f, -1.61838219e-01f, 9.81019065e-02f, 4.89954725e-02f, 4.40251417e-02f, -3.68831791e-02f, 7.81371891e-02f, 3.96870077e-02f, 3.87533475e-03f,
  6.81740716e-02f, 8.57527331e-02f, 2.51684096e-02f, -1.71061344e-02f, 6.92175701e-02f, -3.82694304e-02f, 1.70869790e-02f, 1.22255052e-03f, -1.33164942e-01f, -8.05977806e-02f,
  8.23402777e-02f, 1.72562957e-01f, -9.13844407e-02f, -2.87211705e-02f, -1.32875443e-01f, 6.57166541e-02f, -1.07106365e-01f, -9.00391117e-02f, -1.42666548e-01f, 1.74856931e-01f,
  5.96468821e-02f, 4.00440507e-02f, -1.87164620e-02f, 5.64868283e-03f, -3.06969658e-02f, 6.41564559e-03f, -2.52350401e-02f, 1.33196274e-02f, -7.84544870e-02f, 7.03918412e-02f,
  -3.60349156e-02f, -3.57039161e-02f, -4.01582569e-02f, 7.40731582e-02f, 2.09530909e-03f, 2.63150055e-02f, 1.06776003e-02f, -3.48842540e-03f, 6.43421803e-03f, 2.81574205e-02f,
  3.02399099e-02f, -7.93089420e-02f, 8.79465491e-02f, -8.92488882e-02f, 3.40231485e-03f, 2.93064443e-03f, -1.70911271e-02f, 6.45159977e-03f, 8.04980099e-02f, 1.02026381e-01f,
  9.28892940e-02f, -2.23650619e-01f, 4.04649563e-02f, -8.99092928e-02f, 9.35171247e-02f, 1.19480155e-02f, 2.77491454e-02f, -4.14857343e-02f, 4.94727157e-02f, -7.43411258e-02f,
  -9.79813561e-02f, -1.45282689e-02f, -3.79612818e-02f, 1.74593274e-02f, -8.95688012e-02f, 1.88668948e-02f, 1.10881932e-01f, -4.53060158e-02f, -6.35274425e-02f, -1.47191985e-02f,
  5.16367406e-02f, -5.68680465e-02f, -1.81982722e-02f, -1.42202333e-01f, 3.42658274e-02f, -5.32354265e-02f, -1.38495669e-01f, -4.84640189e-02f, -1.80196509e-01f, 1.02900282e-01f,
  -2.15193540e-01f, -1.65982619e-01f, -2.47723266e-01f, 8.33290666e-02f, 5.33962324e-02f, -1.45894229e-01f, -1.69167221e-01f, 1.43258674e-02f, 5.26444875e-02f, 3.40072811e-02f,
  -4.13870513e-02f, 1.77378565e-01f, 6.05458440e-03f, 5.51519357e-02f, -1.52201310e-01f, -2.20417287e-02f, -2.84634419e-02f, -1.46984577e-01f, 3.72972786e-02f, 6.29248144e-03f,
  1.82749689e-01f, -1.37808481e-02f, -8.62049162e-02f, 3.99692878e-02f, 7.24290982e-02f, 1.72167033e-01f, 6.58697635e-02f, -7.81457499e-02f, -4.76000905e-02f, 1.17998175e-01f,
  6.19661286e-02f, -2.06469610e-01f, 5.81153743e-02f, -3.42756808e-02f, 7.95793086e-02f, 1.07819065e-02f, 9.82817411e-02f, -6.05791770e-02f, 6.19708514e-03f, 3.99613492e-02f,
  4.69847247e-02f, -5.72455935e-02f, 7.55508915e-02f, -1.08531360e-02f, 3.95845585e-02f, 3.09194345e-02f, -6.74294233e-02f, -1.33302152e-01f, -1.15724243e-01f, 2.51566041e-02f,
  2.90604588e-02f, -1.13093592e-01f, -2.35852614e-01f, 2.65079588e-02f, -5.59119992e-02f, -1.10753879e-01f, 2.69181877e-02f, 8.57716706e-03f, -5.12084514e-02f, 1.08615309e-01f,
  8.64780769e-02f, -7.12863952e-02f, 2.38486361e-02f, -5.11473641e-02f, 1.80134755e-02f, 8.31449926e-02f, -5.36236688e-02f, 6.56321421e-02f, 2.56534908e-02f, 8.08396470e-03f,
  8.59719061e-04f, -6.10007718e-02f, -1.83899198e-02f, -1.66988298e-02f, 9.22625065e-02f, -5.02765402e-02f, -7.25444630e-02f, 2.83199418e-02f, 3.02549284e-02f, 3.92997526e-02f,
  2.02505961e-02f, -4.43625916e-03f, -4.98493835e-02f, -3.47250141e-02f, -6.24913536e-02f, -1.68237053e-02f, 7.95648023e-02f, -4.25769947e-02f, 3.10698319e-02f, 5.38682491e-02f,
  2.16074914e-01f, -1.77109614e-01f, 1.37172565e-01f, 9.20472220e-02f, -6.00270368e-02f, -5.59326215e-03f, -1.15950890e-02f, 6.61415532e-02f, 4.40603904e-02f, -7.80937299e-02f,
  -6.55703694e-02f, -3.25969346e-02f, 2.17747577e-02f, -1.03707295e-02f, 1.07418619e-01f, 4.15469781e-02f, -4.35592569e-02f, -6.62261099e-02f, -4.13125083e-02f, 2.89742909e-02f,
  -6.49746507e-02f, 6.38434570e-03f, 6.07187077e-02f, -5.73711880e-02f, 3.80728804e-02f, -1.28206732e-02f, 5.77359423e-02f, 7.07062036e-02f, -6.08844794e-02f, 1.43115312e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.41748995e-01f, 8.47854987e-02f, -2.93381512e-01f, -9.06088650e-02f, 4.10305001e-02f, 1.73672393e-01f, 1.81269139e-01f, 6.77044615e-02f, 7.73691535e-02f, -1.56064099e-03f,
  3.62424292e-02f, 1.53386682e-01f, 2.86165606e-02f, -2.66497657e-02f, 7.92926699e-02f, 1.70337874e-02f, 1.34631023e-02f, 3.69140767e-02f, -8.06636512e-02f, 1.15385585e-01f,
  7.25801960e-02f, 2.35775337e-02f, -1.28818586e-01f, 1.80052947e-02f, 1.10795490e-01f, 1.00971185e-01f, -1.07972220e-01f, -5.92328757e-02f, -2.57716198e-02f, 5.73793659e-03f,
  -1.92976549e-01f, -1.64723322e-01f, 3.61871198e-02f, 2.46060025e-02f, 1.91676207e-02f, -2.91523356e-02f, -7.31256753e-02f, -1.67163983e-01f, -1.50782922e-02f, -1.51724890e-02f,
  -8.43023434e-02f, 5.19836470e-02f, 1.20524084e-02f, -3.81543599e-02f, 3.66894789e-02f, 3.22872773e-02f, -1.22211516e-01f, -1.16851762e-01f, -2.37357412e-02f, -1.33406639e-01f,
  5.74063249e-02f, -9.49844941e-02f, -1.86913371e-01f, 1.87363327e-02f, -1.66950505e-02f, -1.47703392e-02f, -8.09365958e-02f, -1.63117200e-01f, -7.76531920e-02f, -8.62517208e-02f,
  9.90483314e-02f, 2.78412104e-02f, 5.22047700e-03f, -1.54420268e-03f, 2.47647632e-02f, -3.34719606e-02f, 1.55972317e-02f, 7.76250213e-02f, -6.81092888e-02f, 1.64861437e-02f,
  4.54977155e-02f, -5.10835238e-02f, -1.26231648e-02f, -1.06630996e-01f, 1.59968771e-02f, 4.82778139e-02f, 5.39615601e-02f, -6.41887337e-02f, -4.71569337e-02f, 5.71319759e-02f,
  -2.97644474e-02f, -8.37822631e-02f, -9.28724092e-03f, 4.45152335e-02f, -6.98178932e-02f, -6.28468022e-02f, -2.27216128e-02f, 1.14826364e-02f, 3.28297354e-02f, -6.46479204e-02f,
  2.43824124e-02f, -1.55928219e-02f, -8.86669606e-02f, -4.83975224e-02f, -2.38817576e-02f, -4.23580296e-02f, -1.59893313e-03f, -1.21526867e-02f, 4.15831879e-02f, -4.70887758e-02f,
  6.03113361e-02f, -5.22935092e-02f, -4.04274389e-02f, -4.25535440e-03f, 5.32829165e-02f, 6.11540042e-02f, 2.98976544e-02f, -3.34738642e-02f, -2.54896842e-02f, -1.26056656e-01f,
  6.39160648e-02f, -8.83408114e-02f, -8.68352428e-02f, -7.88794011e-02f, -5.39445393e-02f, -2.49663480e-02f, -1.71496421e-01f, -1.39718309e-01f, -1.88651029e-03f, -5.29218279e-02f,
  3.82920980e-01f, -7.51332939e-02f, -3.73332128e-02f, 6.60956502e-02f, -7.45631233e-02f, 1.39306309e-02f, 4.75264853e-03f, 6.43988177e-02f, 2.52914906e-01f, 1.06952377e-01f,
  4.85859104e-02f, 2.41174459e-01f, 2.62925953e-01f, 7.70105645e-02f, 1.81195468e-01f, 3.66118997e-02f, 7.72760883e-02f, 1.56639908e-02f, 1.51458874e-01f, 6.08834215e-02f,
  1.59057751e-02f, 2.30831876e-02f, 3.20777968e-02f, 1.77177340e-02f, -4.67046537e-02f, 6.79180995e-02f, 4.06240672e-02f, -3.12929787e-02f, -1.57462001e-01f, 2.61574481e-02f,
  -1.45946547e-01f, -1.98818091e-02f, 2.08505154e-01f, 7.56282285e-02f, -1.72352374e-01f, -1.13602625e-02f, -1.77646689e-02f, -2.38758456e-02f, -2.55099754e-03f, -9.34419632e-02f,
  -2.96437349e-02f, -1.05191767e-01f, -3.12725338e-03f, -3.52800973e-02f, -4.77699228e-02f, 1.94110367e-02f, 2.70536076e-02f, 4.51461673e-02f, 6.72089905e-02f, -1.08557887e-01f,
  -5.77609576e-02f, -1.35598043e-02f, -8.71768892e-02f, -2.14422978e-02f, 2.54677627e-02f, 6.64557740e-02f, -1.03977174e-01f, 4.78501208e-02f, -2.99883671e-02f, -2.87245284e-03f,
  8.59024748e-02f, 3.13250311e-02f, -5.19837588e-02f, 8.51777047e-02f, -3.05476915e-02f, 6.29645810e-02f, -7.37326825e-03f, -7.43557960e-02f, -3.21396403e-02f, -5.49523048e-02f,
  6.16863370e-02f, -5.67189902e-02f, -3.15990299e-02f, -2.77298912e-02f, 5.25268577e-02f, -5.63233681e-02f, -1.82678364e-02f, -5.52861467e-02f, -5.34897521e-02f, 1.08057922e-02f,
  5.42261451e-02f, -3.42105515e-03f, -2.55987812e-02f, -3.12410556e-02f, 4.06131111e-02f, 3.52694467e-02f, 6.27966449e-02f, 7.32149987e-04f, 8.54503550e-03f, 4.91868034e-02f,
  -4.82586101e-02f, 1.35859912e-02f, 2.23738834e-01f, 9.94707271e-02f, -7.89904147e-02f, 1.95319615e-02f, -5.23892157e-02f, -3.21804695e-02f, -1.62374392e-01f, -1.41222730e-01f,
  -1.02401420e-01f, 3.74724157e-02f, 2.15926692e-02f, -9.35691595e-02f, 2.62853298e-02f, -1.02981009e-01f, -3.03552486e-03f, -5.26748656e-04f, -1.21590411e-02f, -7.93814734e-02f,
  6.33670576e-03f, 1.19352162e-01f, 1.51558802e-01f, 1.32347122e-01f, 4.97928895e-02f, 2.05194756e-01f, -9.04601291e-02f, -1.22446015e-01f, 2.73160245e-02f, 1.67091891e-01f,
  -9.31339785e-02f, 1.93689000e-02f, -1.63421169e-01f, -1.53820947e-01f, -1.83352217e-01f, -4.47226129e-02f, -7.95374438e-02f, -1.25672475e-01f, -1.03978977e-01f, 4.87472378e-02f,
  5.05581386e-02f, -8.25744271e-02f, 2.57434100e-02f, -8.96468163e-02f, -4.98442315e-02f, -1.25433952e-01f, -4.11618985e-02f, -9.97095108e-02f, -2.11851537e-01f, -1.80946156e-01f,
  -1.24555551e-01f, -1.03211276e-01f, -5.94990663e-02f, -8.11316073e-02f, 4.22966527e-03f, -1.27216335e-03f, -1.13577053e-01f, -5.40010743e-02f, -1.15840606e-01f, -1.31353378e-01f,
  8.88864994e-02f, -1.65091723e-01f, 3.57874930e-02f, -2.15175804e-02f, 4.07694057e-02f, 5.91116808e-02f, -7.38440603e-02f, 4.17639501e-02f, 4.13709916e-02f, 4.09503691e-02f,
  2.69839335e-02f, -8.22204724e-02f, -4.17227335e-02f, -4.86824773e-02f, -6.45395815e-02f, 4.37868349e-02f, -7.85065070e-02f, -8.28447342e-02f, -4.78120707e-03f, -1.60119329e-02f,
  4.19535376e-02f, -7.45997429e-02f, 3.07604093e-02f, -2.46314742e-02f, 2.14673392e-02f, -1.12342767e-01f, 1.96264628e-02f, 6.37745559e-02f, -6.34704381e-02f, 2.76499484e-02f,
  4.42234166e-02f, 6.83548003e-02f, 3.40315439e-02f, 3.57911848e-02f, -2.29595620e-02f, 9.77416337e-02f, -2.75524724e-02f, 5.35195470e-02f, -4.19160016e-02f, 9.37223658e-02f,
  3.46772745e-02f, -7.72160664e-02f, -5.93891069e-02f, 1.01985112e-01f, -8.77149925e-02f, 5.74976169e-02f, -9.08572152e-02f, 7.81658068e-02f, -3.93158896e-03f, -5.15419990e-02f,
  3.69243026e-02f, 3.41017023e-02f, -8.18998963e-02f, 7.65833780e-02f, -4.99527380e-02f, 1.38595495e-02f, -6.43790141e-02f, 2.54051704e-02f, 3.73985134e-02f, -1.10383615e-01f,
  2.41325736e-01f, -1.19662523e-01f, 4.13994156e-02f, 4.69553769e-02f, -5.04876971e-02f, -6.63234852e-03f, 4.88254800e-02f, -7.31774569e-02f, 4.11712676e-02f, -1.01733217e-02f,
  5.38193174e-02f, 3.93896289e-02f, 9.49838907e-02f, -6.98763761e-04f, 8.62579718e-02f, 6.67067468e-02f, 1.10789374e-01f, 9.30155367e-02f, 4.28170785e-02f, 8.89952108e-02f,
  -3.10172085e-02f, 6.35803789e-02f, 6.75459132e-02f, 3.18482518e-02f, -1.16573405e-02f, 1.67653710e-02f, 7.71597996e-02f, 1.37941897e-01f, 6.71247542e-02f, 1.78063616e-01f,
  -4.24179882e-02f, -4.41077650e-02f, 1.69668477e-02f, 1.24283200e-02f, 2.28291109e-01f, 4.31592427e-02f, 1.61381751e-01f, 2.18076096e-03f, 1.11025251e-01f, -7.30842426e-02f,
  3.16676795e-02f, 6.48926944e-03f, -1.31125584e-01f, 1.74092501e-02f, 2.73691546e-02f, 4.98841330e-02f, 1.20800376e-01f, 3.73760164e-02f, 1.22346491e-01f, 1.02351896e-01f,
  -7.04593733e-02f, -7.46291596e-03f, 5.78671470e-02f, 1.75842755e-02f, 8.70551020e-02f, -3.17396149e-02f, -5.40489182e-02f, 8.97994116e-02f, -8.25338960e-02f, 3.34384926e-02f,
  -8.73973370e-02f, -1.04386047e-01f, -1.20395934e-02f, -7.07958415e-02f, 3.91115546e-02f, -1.00670867e-01f, -1.74765121e-02f, -5.82294054e-02f, 1.14710210e-02f, 5.15271798e-02f,
  -1.40158553e-02f, -6.53058365e-02f, 4.73181345e-02f, -1.12730406e-01f, -4.04277295e-02f, 2.61870939e-02f, -2.97005661e-02f, -1.21774234e-01f, -4.67291251e-02f, -2.32876223e-02f,
  -6.25067623e-03f, 5.64701036e-02f, 4.92511094e-02f, -2.49882471e-02f, 1.72430929e-02f, 9.05623659e-02f, 4.06377157e-03f, 2.80947182e-02f, -1.01434335e-01f, -1.37551397e-01f,
  -9.30168778e-02f, -1.13013955e-02f, 2.40112115e-02f, 6.70483187e-02f, 8.22782610e-03f, -1.99177302e-02f, 1.28723281e-02f, -5.07279076e-02f, 3.16202850e-03f, -5.85565753e-02f,
  2.17291545e-02f, 5.50035015e-02f, 2.22958792e-02f, -4.87066023e-02f, -6.58804402e-02f, -1.75059810e-02f, -7.27463886e-02f, -5.33700064e-02f, -6.70021996e-02f, 6.12622164e-02f,
  -5.91607988e-02f, -2.09495462e-02f, 1.99160837e-02f, 1.71531718e-02f, 6.37113675e-02f, 8.71847495e-02f, -8.36589709e-02f, -2.15371940e-02f, 1.67939942e-02f, 3.20279598e-02f,
  -9.81496181e-03f, 7.27523118e-02f, -8.92836973e-02f, -1.97179001e-02f, -2.90391576e-02f, 4.72070184e-03f, -1.08972602e-01f, -5.51404245e-02f, 7.40926042e-02f, 1.28158061e-02f,
  6.60709515e-02f, -6.85779080e-02f, 6.67268187e-02f, -2.97129247e-02f, 3.72916348e-02f, 7.90256932e-02f, -3.81414406e-02f, 5.81652522e-02f, 2.29600538e-02f, 4.51577269e-02f,
  1.76573172e-02f, 8.01506341e-02f, 1.08123258e-01f, -1.91366933e-02f, -1.46163227e-02f, 4.32744913e-04f, 3.58589701e-02f, -2.11441834e-02f, 2.55220886e-02f, 7.78041482e-02f,
  -3.19028348e-01f, -1.24999158e-01f, -5.99763766e-02f, 8.86110440e-02f, 1.12806737e-01f, 1.40990168e-01f, 7.91572407e-02f, 1.31514996e-01f, -2.68451646e-02f, 4.43680435e-02f,
  8.89044628e-02f, 1.89347975e-02f, 1.15483254e-01f, 1.20446108e-01f, 3.63130234e-02f, 8.40105712e-02f, 1.32712662e-01f, -3.66852246e-02f, 8.68109092e-02f, 6.95335038e-04f,
  1.03949495e-01f, 4.14049514e-02f, -1.00733608e-01f, -6.19257567e-03f, 9.50980410e-02f, 8.93129334e-02f, 5.19424975e-02f, 5.31841703e-02f, -5.65111451e-02f, 6.19220436e-02f,
  2.92792805e-02f, -1.03993073e-01f, 7.10348338e-02f, -4.05191369e-02f, -1.83184333e-02f, -7.82984272e-02f, -1.07084557e-01f, -4.40667011e-02f, -6.75835311e-02f, -6.86702281e-02f,
  4.03618887e-02f, -4.48852926e-02f, -6.74252212e-02f, -9.62495729e-02f, -5.96168935e-02f, 2.94787139e-02f, -1.10624276e-01f, -5.35673685e-02f, -1.66496150e-02f, -1.92265939e-02f,
  -2.32521910e-02f, -3.85287777e-02f, -9.18947533e-03f, 2.95622498e-02f, -2.94427201e-02f, 2.35938318e-02f, -6.45558387e-02f, -1.16585996e-02f, 3.69454995e-02f, 6.38215616e-03f,
  5.59608042e-02f, -4.43949699e-02f, 2.42088884e-02f, -1.58085860e-02f, 3.80228460e-02f, 9.42777321e-02f, 1.71452239e-02f, 3.17614432e-03f, 9.50833410e-02f, 5.19051263e-03f,
  -3.34353112e-02f, 2.34072413e-02f, -5.15359528e-02f, 2.16467641e-02f, -1.43998275e-02f, -9.05160978e-02f, 3.68879475e-02f, -5.31175025e-02f, -8.80888626e-02f, 1.22691859e-02f,
  -9.06483177e-03f, 7.30757937e-02f, -1.04842193e-01f, 3.85810584e-02f, 4.02181931e-02f, -4.18042913e-02f, 2.36653071e-02f, -4.48451079e-02f, 5.24741933e-02f, -9.99929756e-02f,
  9.60695595e-02f, -2.63378657e-02f, 1.25558242e-01f, 1.17052021e-03f, 1.25201689e-02f, 6.25072885e-03f, 3.50663587e-02f, -8.23764801e-02f, 3.96735892e-02f, 1.41382841e-02f,
  8.35357979e-02f, -1.85818728e-02f, 3.29033956e-02f, -8.36285651e-02f, 6.98927268e-02f, -7.39284791e-03f, 6.41916916e-02f, 5.47764031e-03f, -2.97034625e-02f, -7.05637038e-02f,
  8.95084962e-02f, -3.75412665e-02f, 1.76116209e-02f, 6.81954324e-02f, -2.81501487e-02f, 5.66040576e-02f, 5.50098019e-03f, -8.36588535e-03f, 9.68208537e-02f, -2.11983398e-02f,
  -2.68254697e-01f, 5.74891008e-02f, -4.16336302e-03f, -1.75765857e-01f, -9.16344002e-02f, 8.78532976e-02f, 1.88457388e-02f, 6.85729533e-02f, -6.82446584e-02f, -5.31846695e-02f,
  4.30768728e-02f, -3.29655670e-02f, -1.59104183e-01f, 4.59308969e-03f, 1.49761140e-02f, 1.05558656e-01f, -7.08432794e-02f, -8.81116241e-02f, -1.34847134e-01f, 5.42990752e-02f,
  -1.17413983e-01f, -2.40063712e-01f, -1.75751507e-01f, -2.83294022e-02f, -1.04385532e-01f, -5.73614202e-02f, -1.07304625e-01f, 9.81816091e-03f, 4.48439382e-02f, -1.74585655e-02f,
  1.25027642e-01f, -6.65053353e-02f, -4.68617529e-02f, -1.10218719e-01f, -3.94324102e-02f, -2.81162541e-02f, -9.35270265e-02f, 5.96777983e-02f, -4.59879963e-03f, -9.57659185e-02f,
  -2.20459532e-02f, 4.66555767e-02f, -7.51855671e-02f, 3.80877033e-02f, -7.34962225e-02f, 7.18523487e-02f, 7.74174780e-02f, 4.72826697e-02f, 1.32029708e-02f, 6.43088073e-02f,
  2.77358815e-02f, 3.81786563e-02f, -3.19240354e-02f, -4.07239273e-02f, 4.73263264e-02f, -4.13653888e-02f, -7.49645457e-02f, 3.18217315e-02f, 5.06320677e-04f, -6.36452511e-02f,
  -4.62519713e-02f, 7.71129131e-02f, 7.96706527e-02f, 4.92694639e-02f, -6.64230250e-03f, 6.93163350e-02f, -5.34720495e-02f, -8.18392783e-02f, 5.81491664e-02f, -9.79345962e-02f,
  1.93012469e-02f, -1.64709780e-02f, 5.07246517e-02f, 5.99737540e-02f, 3.32401507e-02f, -2.82888934e-02f, -3.60448100e-02f, 5.31299300e-02f, 4.54822406e-02f, 2.18311176e-02f,
  3.33681479e-02f, 8.95333961e-02f, -9.35543031e-02f, 2.37508975e-02f, 9.53707099e-02f, 2.24903636e-02f, -7.35007375e-02f, -3.15676555e-02f, 3.93282399e-02f, 1.38604315e-02f,
  -9.61889327e-02f, 2.97778938e-02f, -5.96169904e-02f, -2.96717081e-02f, -6.71535730e-02f, 7.62055665e-02f, -1.15513876e-02f, -2.17593722e-02f, -6.12548403e-02f, -7.00362632e-03f,
  -1.02369664e-02f, 3.93279530e-02f, -6.78873584e-02f, -3.53978644e-03f, -6.81265071e-02f, 4.71295230e-02f, -2.94155087e-02f, -1.06880568e-01f, 4.47062999e-02f, 5.74121773e-02f,
  -2.49544550e-02f, -2.66880561e-02f, -5.99959791e-02f, 4.51134965e-02f, 6.45419136e-02f, -7.79960304e-02f, 4.03692871e-02f, -7.18983961e-03f, -1.14595376e-01f, -1.65232167e-01f,
  -2.57241111e-02f, 1.39353514e-01f, -2.88088024e-02f, -1.17875889e-01f, 9.91176441e-02f, 1.53734922e-01f, 2.28912801e-01f, 1.04069978e-01f, -3.28167826e-02f, 1.42227009e-01f,
  1.28937781e-01f, -7.37384260e-02f, -2.98649725e-02f, 6.84122667e-02f, 2.93408968e-02f, 1.61718458e-01f, 1.15010843e-01f, -1.08057167e-02f, 1.63034555e-02f, 1.04491469e-02f,
  -6.22568205e-02f, 3.83971701e-03f, -1.44783676e-01f, -2.46907473e-02f, -1.28223047e-01f, -9.26735997e-02f, 6.40391856e-02f, 7.95571133e-03f, 3.71811278e-02f, -2.37039179e-02f,
  -1.15860678e-01f, 1.71041042e-01f, -5.07685356e-02f, -4.49627191e-02f, -3.56573574e-02f, 3.59313004e-02f, -1.35165192e-02f, -1.00363985e-01f, 4.72181514e-02f, 7.22013190e-02f,
  -9.39894319e-02f, -8.38654786e-02f, 9.39465836e-02f, -1.62346624e-02f, 6.85098441e-03f, 1.51307909e-02f, -4.90211369e-03f, 1.20181050e-02f, 1.01092480e-01f, 3.82667258e-02f,
  6.05427772e-02f, 9.79589298e-02f, 4.13636267e-02f, -5.11131296e-03f, 8.77122506e-02f, 3.21802720e-02f, 9.43766907e-02f, 8.87414292e-02f, 3.44805941e-02f, -1.06969684e-01f,
  -1.62306614e-02f, 3.02908779e-03f, -2.99944319e-02f, -1.11216512e-02f, -5.40524349e-02f, -9.19189304e-02f, 5.22487722e-02f, -4.12581339e-02f, -1.48310801e-02f, -2.89148738e-04f,
  8.50155875e-02f, -1.71514731e-02f, 8.15341175e-02f, -2.21347902e-02f, -6.62334487e-02f, -1.26917555e-03f, 2.65323408e-02f, 7.69384801e-02f, 2.56604645e-02f, -2.91175731e-02f,
  9.48382244e-02f, -2.04811078e-02f, -5.86656146e-02f, 8.79829898e-02f, -3.01503967e-02f, 5.29459342e-02f, 3.45647968e-02f, 2.65461132e-02f, -1.40873063e-02f, 1.57273784e-02f,
  -1.48660451e-01f, 1.45908713e-01f, -9.59786251e-02f, -9.25618708e-02f, -1.03972510e-01f, -4.17928956e-02f, 3.14927213e-02f, -7.20396787e-02f, -6.01046905e-03f, 1.92540921e-02f,
  2.32844427e-03f, -3.39830182e-02f, -4.84779179e-02f, 1.74393377e-03f, -1.16813868e-01f, -4.76406775e-02f, -1.65119246e-02f, -3.74237783e-02f, -3.37398686e-02f, -5.32539971e-02f,
  5.90891093e-02f, 3.37511636e-02f, -1.23083681e-01f, 3.26268189e-02f, 4.73516397e-02f, -5.26404381e-02f, -6.74966425e-02f, -9.77923423e-02f, -4.00764355e-03f, -1.75325200e-01f,
  4.19526726e-01f, 1.55146733e-01f, 3.96435112e-02f, 1.41225681e-01f, -1.10849097e-01f, -1.78763479e-01f, -6.48909733e-02f, 2.48634461e-02f, 3.51247229e-02f, 3.71039137e-02f,
  1.55197755e-01f, 4.19037379e-02f, 1.59920566e-03f, 8.36855471e-02f, -5.25920950e-02f, -8.35261643e-02f, -1.40185729e-02f, 6.18057512e-02f, 2.90312413e-02f, 6.55923691e-03f,
  1.42569050e-01f, 3.98163944e-02f, 2.05618218e-01f, 9.36355293e-02f, 3.51697505e-02f, 1.18002020e-01f, 5.93023226e-02f, 1.56590611e-01f, 4.03580032e-02f, 1.46119252e-01f,
  2.26368383e-02f, 1.78846672e-01f, -3.83488163e-02f, 5.59344813e-02f, 7.44449869e-02f, 1.18328847e-01f, -1.87415965e-02f, 7.16897845e-02f, -4.40123864e-03f, -9.32119638e-02f,
  7.60915652e-02f, 7.00696632e-02f, -8.11424702e-02f, 6.94843456e-02f, -3.71254534e-02f, -4.89123911e-02f, 2.31512785e-02f, 8.19283351e-02f, -6.50738478e-02f, 8.22801888e-02f,
  -3.29440460e-02f, -5.28304987e-02f, -1.01159737e-01f, -1.47464490e-02f, -2.02652309e-02f, 4.67810780e-02f, -6.02254011e-02f, 7.23601729e-02f, 3.47555690e-02f, 8.82556215e-02f,
  -3.92693505e-02f, 7.36340955e-02f, 3.69735770e-02f, -2.38045137e-02f, 3.81547771e-02f, -1.02245294e-01f, 7.08911791e-02f, 6.44403920e-02f, -8.13076422e-02f, -3.13054584e-02f,
  6.74498151e-04f, -2.08248217e-02f, -7.89372846e-02f, -4.32151966e-02f, -5.34340888e-02f, -2.84729563e-02f, 6.05894402e-02f, -7.83942640e-02f, 7.03367293e-02f, 6.73234388e-02f,
  -3.19702290e-02f, -6.81794137e-02f, 2.33205911e-02f, -2.98051797e-02f, 3.97479609e-02f, -1.21357134e-02f, -4.93680835e-02f, 9.51550305e-02f, -1.16722276e-02f, -4.66761999e-02f,
  -1.06161058e-01f, -1.22239478e-01f, 3.28852236e-02f, 5.23106642e-02f, -1.26079144e-02f, -4.84567322e-02f, 1.80169158e-02f, 7.89997820e-03f, -9.23395678e-02f, -2.68751998e-02f,
  3.62584591e-02f, -3.00465487e-02f, 3.34110558e-02f, -8.10200274e-02f, -6.46497458e-02f, -4.43365835e-02f, 2.28929501e-02f, 1.17993820e-02f, -3.81453224e-02f, -1.75097045e-02f,
  -1.10491946e-01f, -3.26389521e-02f, -3.37693468e-02f, -1.01208985e-01f, -2.42246538e-02f, 3.11649293e-02f, -1.02096424e-01f, 3.55024561e-02f, -7.71198794e-02f, -1.40124664e-01f,
  -1.31792203e-01f, 2.58693755e-01f, 2.41881907e-01f, 2.03448221e-01f, 3.32445800e-01f, 4.16567057e-01f, 4.93911296e-01f, 2.86385953e-01f, 8.93135667e-02f, 9.44853127e-02f,
  -3.71343717e-02f, -2.22328603e-02f, -3.10802925e-02f, 1.92952622e-02f, 1.86346799e-01f, 2.42505357e-01f, 1.77781418e-01f, 5.46593554e-02f, -6.69917837e-02f, -4.86747846e-02f,
  -6.25677183e-02f, -8.86580814e-03f, -3.65777053e-02f, 2.40823664e-02f, 5.74626178e-02f, -2.05522142e-02f, -1.88817419e-02f, 7.60827065e-02f, 5.31106815e-02f, -6.21773899e-02f,
  -1.37377933e-01f, 1.70953438e-01f, -5.73918782e-02f, -1.97088063e-01f, -7.13561699e-02f, -5.91721907e-02f, 2.52709594e-02f, -1.65911049e-01f, 1.82309449e-02f, -1.03692107e-01f,
  -8.15399140e-02f, 2.32257182e-03f, -1.72504727e-02f, -4.95248139e-02f, 4.20521833e-02f, -9.01107397e-03f, 1.98509805e-02f, -2.36580875e-02f, 9.04435962e-02f, -4.02586795e-02f,
  -8.54351446e-02f, 6.42712787e-02f, 1.24926984e-01f, 1.38417646e-01f, -1.74594659e-03f, -7.67306909e-02f, -3.63564417e-02f, -9.81773715e-04f, 4.89667337e-03f, -1.22016706e-01f,
  -4.98896763e-02f, 6.74031675e-02f, 6.10067658e-02f, -3.71048823e-02f, -5.09159565e-02f, 5.74765988e-02f, 4.76621389e-02f, 3.07645462e-02f, 9.63116586e-02f, -3.38726006e-02f,
  -4.72504832e-03f, -3.25413868e-02f, 8.93399061e-04f, -3.60370390e-02f, -2.69288439e-02f, 3.43579836e-02f, 2.36518923e-02f, 9.20976326e-02f, -6.94837719e-02f, 5.29171824e-02f,
  -5.48510663e-02f, 1.22696888e-02f, 3.59527245e-02f, 9.21737924e-02f, -7.22927507e-03f, -3.36618279e-03f, -8.44160542e-02f, 6.66065933e-03f, -1.69240776e-02f, 4.43649106e-02f,
  -1.35497808e-01f, 5.88051602e-03f, -1.45585403e-01f, 2.24903133e-02f, 5.41354716e-02f, -6.02975301e-02f, -1.15764113e-02f, 4.87799086e-02f, -2.33965907e-02f, 1.75500922e-02f,
  -2.18030903e-02f, -3.91206332e-02f, 9.14976150e-02f, 6.00922760e-03f, 1.98134333e-02f, -8.43182504e-02f, 2.36895513e-02f, 4.85540926e-02f, -6.41647652e-02f, 2.39296947e-02f,
  -2.05592602e-03f, -1.06654212e-01f, -5.71193956e-02f, 8.37938413e-02f, -1.48157380e-03f, -8.91816616e-02f, 3.08653582e-02f, 1.24180084e-03f, -1.07636303e-01f, -1.15766972e-01f,
  1.19688004e-01f, -2.72763640e-01f, 1.90271050e-01f, -8.01867060e-03f, 3.31823640e-02f, 1.82918310e-01f, 1.31043643e-01f, 4.36304957e-02f, -2.03736573e-02f, 5.64428195e-02f,
  -1.33497968e-01f, 5.57378447e-03f, 2.87554599e-02f, 1.80225517e-03f, 8.68445486e-02f, 1.13948397e-01f, 2.41255071e-02f, 1.31473437e-01f, 1.53271541e-01f, 2.68114428e-03f,
  2.93468349e-02f, -6.13572970e-02f, -1.14749245e-01f, -2.54271347e-02f, -1.35976390e-03f, 2.73625534e-02f, 8.25580582e-03f, -8.55263248e-02f, -1.29508466e-01f, -9.12250951e-02f,
  1.51122063e-01f, -1.04075694e-03f, 1.38560116e-01f, -1.35005057e-01f, 2.95529841e-03f, -3.55745591e-02f, -2.03830265e-02f, -8.46046880e-02f, -3.86624970e-02f, -9.21552479e-02f,
  -2.28577461e-02f, -6.66848794e-02f, -6.86998758e-03f, -9.02351737e-02f, -1.75660867e-02f, -1.38957622e-02f, -3.33296619e-02f, -9.57865492e-02f, 3.87105569e-02f, -1.63986161e-01f,
  -9.19303522e-02f, -3.12465858e-02f, 7.56116509e-02f, -3.76375467e-02f, -8.76507089e-02f, 4.35541496e-02f, -3.60687971e-02f, 4.67315279e-02f, -3.02292742e-02f, -1.44767657e-01f,
  2.83768103e-02f, 7.82152042e-02f, 4.11323532e-02f, -3.77145745e-02f, 3.56315710e-02f, -1.42740505e-02f, -9.82137024e-03f, 7.73946866e-02f, -4.98329476e-02f, -3.05700433e-02f,
  1.51788928e-02f, 4.27918732e-02f, -1.02977017e-02f, 5.91155849e-02f, -5.79561852e-02f, 5.87202162e-02f, -2.53574159e-02f, -2.44675688e-02f, 8.75496492e-02f, 8.09487253e-02f,
  3.31615023e-02f, 7.26739392e-02f, -6.48374707e-02f, 8.30118917e-03f, -3.19473892e-02f, 2.62253406e-03f, 3.70246992e-02f, -1.32281212e-02f, -5.94627224e-02f, 5.88332163e-03f,
  1.93896820e-03f, 4.72274199e-02f, 1.14128567e-01f, 3.01491264e-02f, -9.85786971e-03f, -7.91082755e-02f, 4.82849590e-02f, -1.21894263e-01f, -6.51840046e-02f, -3.67775969e-02f,
  -3.07853259e-02f, 6.13085367e-03f, 8.67882464e-03f, -9.79945958e-02f, 1.07888423e-01f, 1.27136067e-01f, -1.30265161e-01f, 4.01119590e-02f, -3.78992036e-02f, -1.35976911e-01f,
  -9.56249014e-02f, 1.15793772e-01f, 2.59235382e-01f, 1.63731009e-01f, -3.00004650e-02f, 2.96776116e-01f, 1.10017024e-01f, 1.61569402e-01f, 2.24760085e-01f, 3.69340219e-02f,
  1.37442678e-01f, -3.69311064e-01f, -4.09301162e-01f, 1.21182732e-01f, -9.17452499e-02f, -3.18797559e-01f, -4.82616723e-01f, -1.78114608e-01f, 1.21665411e-01f, -1.65098861e-01f,
  -2.17750408e-02f, 9.15880799e-02f, 9.44753885e-02f, -8.31923410e-02f, -2.63155907e-01f, -4.65404242e-01f, -3.38693827e-01f, -2.27511600e-02f, 7.69625278e-03f, 1.25405893e-01f,
  -4.83217835e-02f, 1.67717025e-01f, 5.21902554e-02f, 1.10520028e-01f, 9.50370282e-02f, 3.90395746e-02f, -1.24650136e-01f, -1.10974297e-01f, -1.53901741e-01f, -3.54587846e-02f,
  -2.59176075e-01f, -3.78773250e-02f, 4.69051972e-02f, 1.29834086e-01f, 9.41760615e-02f, 5.72354235e-02f, -1.32180259e-01f, -2.37507429e-02f, 1.07287765e-01f, -1.56553775e-01f,
  6.39101937e-02f, -6.60554785e-03f, 1.30243637e-02f, 1.05125509e-01f, -2.91937534e-02f, -7.92920589e-02f, -1.09157022e-02f, 3.03763635e-02f, -1.60067137e-02f, -2.59120055e-02f,
  -7.71574900e-02f, 3.48003879e-02f, -6.93358481e-02f, -1.16764612e-01f, 2.85015181e-02f, -1.10713569e-02f, 4.39072168e-03f, 5.07073663e-02f, -8.35887901e-03f, -2.24606562e-02f,
  -3.98726724e-02f, -3.67400236e-02f, -2.86026169e-02f, -1.50859002e-02f, 1.03954755e-01f, -4.71266769e-02f, -1.57810077e-02f, -1.95707288e-02f, 2.88834621e-04f, -4.84319106e-02f,
  3.79094630e-02f, -3.57336588e-02f, 4.10041884e-02f, -1.28508583e-02f, -9.52636003e-02f, 5.96471392e-02f, -7.10925534e-02f, -1.27862185e-01f, -6.17075861e-02f, -2.65826900e-02f,
  5.88204265e-02f, 3.21203843e-02f, 1.05928652e-01f, -1.19495308e-02f, 3.97738889e-02f, -5.54140471e-02f, -2.28289962e-02f, 3.83982109e-03f, 3.39280441e-02f, -1.40837757e-02f,
  1.03201762e-01f, -2.88787652e-02f, -6.22987412e-02f, 3.91518474e-02f, -7.37745836e-02f, -6.62174374e-02f, 4.51400839e-02f, -5.14734685e-02f, -5.70428371e-03f, -3.08388863e-02f,
  1.61529165e-02f, 4.26360965e-02f, -6.88285381e-02f, -6.10342175e-02f, 9.25287232e-02f, 2.19204128e-02f, -1.40014797e-01f, 3.86015065e-02f, -6.63625747e-02f, -1.69337131e-02f,
  -1.13027997e-01f, -1.02103040e-01f, -1.03323445e-01f, -5.47606908e-02f, -5.43494336e-02f, -8.08666053e-04f, -1.43596143e-01f, -1.20990291e-01f, -1.76226959e-01f, -2.77209640e-01f,
  1.67247653e-01f, -3.60764891e-01f, -2.65769511e-01f, -1.73030142e-03f, -9.66102332e-02f, -2.08532646e-01f, -2.58038551e-01f, -4.61771525e-02f, -5.69809116e-02f, -1.07559875e-01f,
  -1.71359241e-01f, -5.83718996e-03f, 1.08689303e-02f, -1.67107396e-02f, -4.96150646e-03f, -3.02293271e-01f, -2.91687399e-01f, -5.84174972e-03f, 1.30507693e-01f, 1.51811227e-01f,
  4.36229557e-02f, 8.44201967e-02f, 1.24604464e-01f, 7.84394145e-02f, -2.28825351e-03f, -1.32317562e-02f, -1.54136866e-01f, 4.77043465e-02f, -4.34715785e-02f, -5.10034040e-02f,
  -8.63167271e-02f, 2.44368017e-01f, -1.29061844e-02f, 1.20276831e-01f, -1.24212898e-01f, 1.53644485e-02f, -1.27640277e-01f, 9.29607376e-02f, 7.94311464e-02f, -8.74858163e-03f,
  -7.52672851e-02f, 4.35213447e-02f, 1.16297401e-01f, -3.91336298e-03f, 3.46656591e-02f, 1.04268253e-01f, -5.07274270e-02f, 1.28728434e-01f, -4.59177271e-02f, 2.71950141e-02f,
  -1.36734858e-01f, -1.03057168e-01f, 3.45478859e-03f, -4.34137508e-02f, 5.91390468e-02f, 8.25453773e-02f, 1.40192304e-02f, 9.69597176e-02f, 9.07178447e-02f, -8.19356516e-02f,
  -7.40988031e-02f, -3.42364945e-02f, 6.30584061e-02f, 5.82628511e-02f, -2.43415870e-02f, -2.64158789e-02f, 8.69062077e-03f, 1.39963496e-02f, 9.18385834e-02f, -4.30384614e-02f,
  1.65488087e-02f, -7.42405206e-02f, 2.01863050e-02f, 1.88516416e-02f, 1.41610880e-03f, 2.65456606e-02f, -3.59769650e-02f, 3.07665095e-02f, -1.04455734e-02f, 4.83587664e-03f,
  1.15415253e-01f, 3.73610184e-02f, -7.17716217e-02f, 8.90036523e-02f, -6.66489676e-02f, 3.05511840e-02f, 4.00866987e-03f, 8.48859325e-02f, 1.53650079e-04f, -3.04015111e-02f,
  -1.36555597e-01f, -1.09286606e-01f, -2.17615757e-02f, 8.99535641e-02f, 4.55444539e-03f, -1.00241281e-01f, -7.01817200e-02f, 3.45515013e-02f, 8.30831900e-02f, 3.08644064e-02f,
  4.61220928e-02f, -3.16974781e-02f, -6.42480180e-02f, 7.99923837e-02f, -4.31140549e-02f, -4.23641242e-02f, -5.78907281e-02f, -1.06250741e-01f, 1.72408056e-02f, -2.42299810e-02f,
  -9.09622088e-02f, -1.58780843e-01f, -7.64879063e-02f, -1.20186001e-01f, 6.70905858e-02f, -4.65462282e-02f, -1.13282099e-01f, -1.20181084e-01f, -2.03340530e-01f, -3.12969923e-01f,
  -2.59910464e-01f, -1.87748149e-01f, -2.67483085e-01f, -3.59621882e-01f, -6.58176020e-02f, 1.34295627e-01f, 1.58494022e-02f, -8.18074122e-02f, -1.81576163e-01f, -1.58271074e-01f,
  -7.54598826e-02f, 1.34876212e-02f, -1.24513097e-01f, 4.37453054e-02f, 1.82286222e-02f, -6.13859445e-02f, -2.30277851e-02f, 7.33087808e-02f, 2.16277361e-01f, 1.26883075e-01f,
  -1.95573904e-02f, -5.15139103e-02f, -1.75157320e-02f, 1.00744935e-02f, -2.24552318e-01f, -1.65091604e-01f, -2.53173590e-01f, -1.93734437e-01f, 3.65940966e-02f, -2.98809230e-01f,
  -1.45015642e-01f, -1.69960305e-01f, 9.05369744e-02f, 9.19851288e-02f, -1.22323707e-01f, 6.53474852e-02f, -3.04258671e-02f, -4.83016595e-02f, -1.30815148e-01f, -1.24188215e-01f,
  -1.03864923e-01f, -6.46935701e-02f, -3.39906216e-02f, -7.91930556e-02f, -3.89341563e-02f, -4.25163545e-02f, 2.22117398e-02f, -4.49669696e-02f, 2.40326338e-02f, 1.14592994e-02f,
  -4.57914136e-02f, 4.69803810e-02f, 5.29480651e-02f, -2.16292217e-02f, -9.33122076e-03f, 7.22946823e-02f, -9.63168070e-02f, 6.95631802e-02f, 1.19727671e-01f, -8.60865042e-02f,
  5.74919321e-02f, -1.07615320e-02f, 8.41697901e-02f, -3.62168401e-02f, 7.87748396e-03f, -3.03453524e-02f, 1.27351172e-02f, 2.66918130e-02f, 5.54856099e-02f, -4.55055647e-02f,
  -2.45089587e-02f, -4.61741127e-02f, 3.65056284e-02f, -9.04948451e-03f, -4.57084104e-02f, -8.02940503e-02f, 3.13555002e-02f, 3.77151631e-02f, -2.52121855e-02f, 3.57448161e-02f,
  1.06819741e-01f, 4.13310975e-02f, -4.20968980e-02f, -9.11296904e-03f, 3.90764996e-02f, 3.14061046e-02f, -8.34431592e-03f, 9.19956267e-02f, 3.46411876e-02f, 6.50494620e-02f,
  -2.62880802e-01f, 2.09463567e-01f, 1.10009145e-02f, 7.23339198e-03f, 1.72969066e-02f, -6.75720349e-02f, -4.75492030e-02f, -8.50554556e-02f, -6.29088581e-02f, -1.42410342e-02f,
  4.12755385e-02f, 3.91196012e-02f, -1.18412971e-01f, 3.15093175e-02f, 1.13224462e-01f, 2.31806189e-02f, 1.26654413e-02f, 3.11183836e-02f, 1.42842785e-01f, 1.97868943e-02f,
  -3.00885867e-02f, 1.67958289e-01f, 7.60006234e-02f, 3.15379463e-02f, 2.59080883e-02f, 4.01605144e-02f, 4.72623250e-03f, 1.14952840e-01f, 7.48539716e-02f, 1.63885839e-02f,
  -8.61731768e-02f, 2.35048998e-02f, 2.35803425e-03f, -8.24596211e-02f, 7.55560026e-02f, 6.53235242e-02f, 1.36982203e-01f, 1.03340060e-01f, 6.35602400e-02f, -2.90056281e-02f,
  -2.82303826e-03f, -4.84126545e-02f, -1.02297068e-01f, -9.78237540e-02f, -2.55315993e-02f, 1.39900863e-01f, 4.20361618e-03f, -6.79877177e-02f, -1.00488819e-01f, 5.32873087e-02f,
  4.46044020e-02f, 6.56539425e-02f, 3.21991406e-02f, -5.21181803e-03f, -4.42299694e-02f, -9.72216353e-02f, 4.51241769e-02f, 1.88925155e-02f, -1.71468337e-03f, 2.79458165e-02f,
  -8.19692202e-03f, -1.04669221e-01f, 1.29851419e-02f, 3.68397683e-02f, 8.27922523e-02f, 5.96600585e-02f, 2.33122222e-02f, -1.47501417e-02f, -5.94996251e-02f, -4.26445752e-02f,
  -1.36816259e-02f, -2.35448442e-02f, -7.81983733e-02f, 2.89582517e-02f, 6.73581958e-02f, 5.94200082e-02f, -1.03902584e-02f, -6.85261935e-02f, 3.88545170e-02f, -8.87032524e-02f,
  4.76868171e-03f, 1.10758103e-01f, -8.26072171e-02f, 4.20539547e-03f, -1.18278153e-01f, -5.28200753e-02f, -9.08674598e-02f, -8.84050876e-02f, -3.73681821e-02f, 9.34430305e-03f,
  -7.33926520e-02f, -4.19467278e-02f, -5.92365228e-02f, 7.18327835e-02f, -5.35135251e-03f, 5.11805154e-02f, 6.25959858e-02f, 7.55444616e-02f, -8.66905600e-03f, 9.25130695e-02f,
  8.92032087e-02f, -6.94547966e-02f, -6.98455870e-02f, 2.14371234e-02f, -4.06373627e-02f, 1.38685340e-02f, -2.04980392e-02f, -3.50277238e-02f, 6.18401915e-02f, 7.33293071e-02f,
  -1.53322732e-02f, -7.73002282e-02f, -1.98124978e-03f, 8.24328214e-02f, -2.75487714e-02f, 3.04274876e-02f, -8.99102315e-02f, 1.30775301e-02f, -2.75131539e-02f, 9.17589385e-03f,
  -1.21938333e-01f, 1.17125548e-01f, -2.63611954e-02f, -5.44169582e-02f, -6.70004711e-02f, 1.13689825e-02f, 8.87134578e-03f, 9.93476287e-02f, -2.98077650e-02f, -5.78006469e-02f,
  3.86000611e-02f, 5.70490304e-03f, 5.93417697e-02f, 7.32067004e-02f, 4.11881320e-02f, 7.52952173e-02f, -5.05704544e-02f, -3.45538668e-02f, -2.94845346e-02f, -3.93576138e-02f,
  7.05817193e-02f, 9.31365043e-02f, -5.19030541e-03f, 8.87363628e-02f, 2.86199227e-02f, 4.60828394e-02f, -5.91524579e-02f, 4.46106978e-02f, -2.40125246e-02f, 8.91178176e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.01007164e-01f, 1.61864266e-01f, 5.25040813e-02f, 3.55940387e-02f, 4.87855589e-03f, 6.84567466e-02f, 1.71195343e-01f, 1.09984688e-01f, 7.73379877e-02f, 2.52671361e-01f,
  1.58409417e-01f, 2.40620121e-01f, 2.32417017e-01f, 1.04529634e-02f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  2.90084835e-02f, -2.44531676e-01f, -4.93420521e-03f, -5.93556225e-01f, -7.54357055e-02f, -2.60152556e-02f, -2.18713969e-01f, -3.38468462e-01f, 1.34941652e-01f, -1.57474682e-01f,
  -1.60911560e-01f, 2.66044904e-02f, -8.06873739e-01f, 3.71940844e-02f, 1.62018970e-01f, -9.65485126e-02f, -2.99183819e-02f, -8.35535079e-02f, -1.82223059e-02f, -2.79570445e-02f,
  3.46660987e-02f, -9.56750102e-03f, -4.04617906e-01f, 5.54293133e-02f, -2.21888423e-01f, 9.10655260e-02f, -6.55367911e-01f, 7.67898038e-02f, 1.37085527e-01f, -5.38223162e-02f,
  -1.33880541e-01f, 1.07511006e-01f, -2.10983977e-01f, 6.95809200e-02f, -5.68930507e-02f, -8.28003362e-02f, -1.66174158e-01f, 9.61336419e-02f, -1.58495277e-01f, -3.38164419e-01f,
  1.22747757e-01f, -2.31730029e-01f, -3.83076400e-01f, 7.84769580e-02f, 5.37320562e-02f, -5.15852571e-02f, -1.39884697e-02f, -1.33221820e-01f, -2.35875398e-01f, 2.25504592e-01f,
  1.79569930e-01f, -2.12934196e-01f, 4.01257835e-02f, -9.79741439e-02f, -7.21036792e-02f, 2.10566241e-02f, -8.19059461e-02f, 8.88481066e-02f, -3.50990705e-02f, -2.04947501e-01f,
  7.25587368e-01f, 7.60206938e-01f, 3.21813405e-01f, -9.77503657e-02f, -2.28943169e-01f, -4.88001376e-01f, 1.97018296e-01f, 3.05211604e-01f, -4.27898318e-02f, 3.43246642e-03f,
  -3.35583866e-01f, -1.88274667e-01f, 2.67655887e-02f, 3.62471938e-01f, -7.27275759e-03f, 2.35687762e-01f, -2.29195207e-02f, -8.83185584e-03f, 8.17585811e-02f, 1.86885640e-01f,
  2.47966141e-01f, -3.87268394e-01f, 1.86618939e-01f, 2.67824471e-01f, -2.93294638e-01f, -4.57981199e-01f, 3.66185099e-01f, 7.54950643e-02f, 1.17733590e-01f, -7.57287025e-01f,
  -5.51800370e-01f, -3.51381660e-01f, 2.03337267e-01f, 6.26884043e-01f, 5.49765527e-02f, 7.58390427e-02f, -1.32816970e-01f, -2.10543796e-01f, -2.03820392e-01f, -9.59346071e-02f,
  2.48873845e-01f, 2.04731658e-01f, -2.18718201e-01f, -3.54673237e-01f, 5.60609102e-02f, -1.16386510e-01f, -7.47659266e-01f, 1.32961944e-01f, -1.16552070e-01f, -4.53818589e-01f,
  -4.19145338e-02f, 8.44958872e-02f, -4.43288326e-01f, -1.05369382e-01f, 1.19835101e-02f, 6.26827180e-01f, 4.37624641e-02f, -1.00110337e-01f, -1.25200069e-02f, -2.06869125e-01f,
  2.09392443e-01f, 1.47017643e-01f, 2.30451107e-01f, 2.59299934e-01f, 1.80084750e-01f, 1.73493236e-01f, 3.20174515e-01f, -2.13412821e-01f, -9.20318663e-02f, 2.44939774e-01f,
  -2.01374054e-01f, 2.77821183e-01f, 9.44444090e-02f, 9.90988910e-02f, 5.03179610e-01f, 3.06188285e-01f, 5.95375858e-02f, -1.48259237e-01f, -1.12541132e-02f, 3.06580663e-01f,
  -5.87425642e-02f, -7.89331868e-02f, -1.09856911e-01f, 3.08380891e-02f, 2.85548687e-01f, 1.79773226e-01f, -1.26087412e-01f, -2.76796848e-01f, -8.45125616e-02f, 2.04062834e-01f,
  3.55809569e-01f, 1.47866070e-01f, 9.65998396e-02f, -4.25363302e-01f, 1.17197499e-01f, 3.03004861e-01f, 4.31831926e-01f, 4.51164216e-01f, 3.28505963e-01f, -1.91509470e-01f,
  -1.86325356e-01f, 2.08592907e-01f, -3.57650518e-01f, 2.47970298e-01f, 1.03515312e-01f, 6.45350993e-01f, 5.16580999e-01f, 4.44697440e-01f, 1.25079438e-01f, 5.20818889e-01f,
  2.13739023e-01f, 2.80591100e-01f, -5.59424758e-01f, -5.44674814e-01f, -2.01947019e-01f, 3.10359269e-01f, -2.41415873e-02f, -1.84720933e-01f, -1.03614673e-01f, -1.39360517e-01f,
  -2.43168190e-01f, -1.69483721e-02f, -8.11074227e-02f, -6.00239113e-02f, -9.85919684e-02f, -7.74318576e-02f, -2.20035702e-01f, -1.24576189e-01f, 2.06806883e-01f, 1.86517864e-01f,
  6.88919425e-02f, -7.16318712e-02f, 6.26527444e-02f, 2.93563485e-01f, -3.89477938e-01f, -3.89291674e-01f, 1.69103563e-01f, 9.66640711e-02f, 1.72317222e-01f, -1.39377490e-01f,
  3.36367756e-01f, 1.55934572e-01f, -1.10637084e-01f, -3.33122581e-01f, 2.21583545e-01f, 2.17600465e-01f, -1.31187260e-01f, 3.09076179e-02f, 5.52006401e-02f, -1.51730329e-01f,
  2.87646335e-02f, 2.96369880e-01f, -2.34324977e-01f, 5.22929132e-02f, -1.31104961e-01f, -2.42947385e-01f, 6.37457594e-02f, 4.46638882e-01f, 2.63132125e-01f, 4.22663987e-01f,
  3.48163605e-01f, 1.13669038e-01f, -1.86663762e-01f, 6.65815920e-02f, -2.02579871e-01f, -4.34835047e-01f, 2.18648002e-01f, -2.80438483e-01f, -2.93256283e-01f, 1.80114761e-01f,
  7.53991976e-02f, 3.11791718e-01f, -4.11329806e-01f, -3.24429959e-01f, 7.16792643e-01f, 1.88371465e-02f, 5.09996153e-02f, 3.09516460e-01f, -1.34116828e-01f, -3.99978817e-01f,
  -6.68906808e-01f, -1.52236253e-01f, 2.08838627e-01f, -1.48530200e-01f, 2.05783285e-02f, -5.00845090e-02f, -2.18694787e-02f, 4.57053751e-01f, 2.53712088e-01f, -2.51209557e-01f,
  -1.73050240e-01f, -4.86942083e-02f, -5.17696559e-01f, -1.64497018e-01f, 5.78858197e-01f, 1.08658098e-01f, 3.76664624e-02f, 4.20579135e-01f, 1.20245971e-01f, -1.02847472e-01f,
  9.92136747e-02f, 1.45353511e-01f, 4.83744264e-01f, -1.71381496e-02f, -3.65530938e-01f, -1.78756993e-02f, 3.09961103e-02f, -9.90410428e-03f, 1.51971933e-02f, -2.03833699e-01f,
  -7.45643228e-02f, 2.93210819e-02f, -4.09534663e-01f, 3.10006350e-01f, 1.14388838e-01f, -3.35756153e-01f, 1.31745920e-01f, -2.49477312e-01f, -3.11540484e-01f, 1.71380714e-01f,
  -3.19320932e-02f, 6.87988708e-04f, 4.19613898e-01f, 1.14242613e-01f, 5.73121130e-01f, -1.85924590e-01f, 1.29052863e-01f, 3.68873738e-02f, -4.71859217e-01f, 6.25566661e-01f,
  -1.66687310e-01f, -1.44522280e-01f, -4.70749140e-01f, 1.47498295e-01f, 4.46278095e-01f, 2.88951635e-01f, -4.35846448e-01f, -4.80651319e-01f, 2.63120979e-01f, -1.36283681e-01f,
  5.65645874e-01f, 3.87434393e-01f, -3.58939409e-01f, -4.77898508e-01f, 5.81251621e-01f, 1.69385761e-01f, -1.92074746e-01f, 5.68810515e-02f, 2.02392310e-01f, -9.46813375e-02f,
  -9.46089998e-02f, 1.03890337e-01f, -1.56849995e-01f, 7.54646584e-02f, -8.64431262e-02f, -2.00740501e-01f, 3.17912251e-01f, 2.16277719e-01f, -4.73050117e-01f, -2.07618207e-01f,
  3.94444525e-01f, 3.13418686e-01f, -5.84963225e-02f, 3.86336595e-01f, 2.38600731e-01f, -9.29475874e-02f, 1.98304355e-02f, 1.96890086e-01f, 4.28216420e-02f, 2.48833477e-01f,
  1.75076440e-01f, 3.36979896e-01f, 3.30446362e-01f, 9.05339271e-02f, 2.15821877e-01f, 1.47462159e-01f, -1.36831582e-01f, 2.93213725e-01f, -3.44186246e-01f, 2.84390181e-01f,
  1.74866900e-01f, -8.64511803e-02f, 1.08894259e-01f, 2.38974690e-01f, 1.69195067e-02f, 2.24191695e-01f, -6.72859848e-01f, -6.13912702e-01f, -3.72666046e-02f, -5.74554980e-01f,
  -3.72847557e-01f, 4.21485871e-01f, 8.23485479e-02f, -2.67213643e-01f, 1.20731138e-01f, -1.16388224e-01f, 3.53483170e-01f, 1.66974127e-01f, -4.39028293e-01f, -5.54925025e-01f,
  3.47071737e-01f, -3.95393699e-01f, -3.22074801e-01f, -5.02407372e-01f, 3.18973750e-01f, -4.27935779e-01f, -3.03944379e-01f, -3.68398845e-01f, 6.05662286e-01f, 1.96915835e-01f,
  2.05895334e-01f, 2.15209365e-01f, 2.90780753e-01f, -3.60435285e-02f, -1.28152922e-01f, -9.77763608e-02f, -6.86985105e-02f, 2.08443031e-02f, -2.48651713e-01f, -3.09257895e-01f,
  -6.94922060e-02f, -2.80463427e-01f, -2.99924705e-02f, 8.54468942e-02f, 1.61140680e-01f, 8.63437913e-03f, 9.71675571e-03f, 9.85168442e-02f, 8.23776424e-02f, -2.63173372e-01f,
  -3.67852837e-01f, -3.50895226e-01f, 1.54451624e-01f, 1.05693236e-01f, -1.37536958e-01f, -6.01534426e-01f, -4.89795767e-02f, 2.85893176e-02f, -2.25150809e-01f, -3.21473517e-02f,
  -5.41658401e-02f, -2.46078536e-01f, 2.45555758e-01f, 2.22545549e-01f, 3.26563269e-01f, 2.99336404e-01f, 1.53877273e-01f, 7.78115243e-02f, -3.54218036e-02f, 2.56581873e-01f,
  2.67076910e-01f, 2.11199075e-01f, -2.72881031e-01f, -3.63618731e-02f, 4.87150371e-01f, -3.07177335e-01f, 5.35677671e-01f, 4.21677202e-01f, -3.17406803e-01f, 4.32293802e-01f,
  3.94357651e-01f, -6.26835108e-01f, 3.36276889e-01f, 3.53380471e-01f, 3.01354855e-01f, 3.59729409e-01f, -4.63338852e-01f, -2.33362958e-01f, -1.20163128e-01f, -2.22168297e-01f,
  3.79040748e-01f, 2.15253577e-01f, 2.18744025e-01f, -1.49140254e-01f, -2.29888469e-01f, 1.04389876e-01f, -2.15762496e-01f, -2.43168518e-01f, -3.02927613e-01f, 3.00918799e-02f,
  -2.65470669e-02f, 3.81029904e-01f, -1.74535334e-01f, -1.58126503e-01f, -2.83630788e-01f, 2.57608712e-01f, -2.21870661e-01f, -1.41669035e-01f, -3.04181427e-01f, -3.54599476e-01f,
  -1.49688631e-01f, 7.10167289e-02f, -2.86427855e-01f, -1.02767065e-01f, -2.69151777e-01f, -2.97508128e-02f, 5.75395264e-02f, -2.19919663e-02f, 1.72282308e-01f, 2.77142823e-02f,
  4.41097915e-02f, -1.17309783e-02f, -4.20799889e-02f, -4.39255357e-01f, 5.87686077e-02f, -1.48073167e-01f, -1.01084247e-01f, -4.90309745e-01f, -1.80828556e-01f, -3.81290197e-01f,
  1.49670824e-01f, -1.19352769e-02f, 9.86450911e-03f, 5.75590730e-01f, 3.57011795e-01f, 1.31164268e-01f, 2.90435292e-02f, -3.16127360e-01f, -3.71833295e-01f, -2.47922525e-01f,
  1.81076825e-01f, -4.91043538e-01f, -6.52903691e-02f, -7.58711472e-02f, -5.46021610e-02f, -2.26368234e-02f, -1.75531566e-01f, 1.27345473e-01f, 1.68887094e-01f, 3.64574730e-01f,
  4.81264800e-01f, 4.82573926e-01f, -3.80103737e-01f, 1.83429271e-01f, 2.62483180e-01f, 2.97165941e-02f, -1.19459569e-01f, 1.15876511e-01f, 4.58215117e-01f, 6.96987063e-02f,
  -7.41399229e-02f, 1.15987174e-01f, 3.42234731e-01f, -3.37177189e-03f, 2.07461670e-01f, -2.91033268e-01f, 5.28133035e-01f, -1.91030465e-02f, -8.38350225e-03f, -1.14286467e-01f,
  -1.41638428e-01f, 1.15596041e-01f, 8.32506195e-02f, 1.42236114e-01f, 1.43770635e-01f, -6.23009682e-01f, -4.08371119e-03f, 1.30754963e-01f, 1.61267385e-01f, 1.57571256e-01f,
  -2.92111129e-01f, -4.52142358e-01f, -3.65184546e-02f, -3.68029997e-02f, 2.58894771e-01f, 2.34140709e-01f, -2.57192135e-01f, 1.74047485e-01f, -2.39626551e-03f, 1.32814229e-01f,
  -5.14029600e-02f, -6.20411858e-02f, -2.04788987e-02f, 3.05708051e-01f, -1.57425135e-01f, 2.20609143e-01f, 1.73196226e-01f, 1.20605826e-01f, -1.98405772e-01f, -3.42864901e-01f,
  -5.52984953e-01f, 9.14018080e-02f, 4.04053569e-01f, 2.49527916e-01f, 3.61731678e-01f, -4.91712987e-01f, 4.65760022e-01f, 5.37055850e-01f, 3.37472141e-01f, -2.16660774e-04f,
  3.30517776e-02f, -4.64776516e-01f, -1.65655866e-01f, 3.64481807e-01f, 2.16458395e-01f, -2.52988905e-01f, -4.07746166e-01f, -2.09882587e-01f, 2.82528579e-01f, 5.31032145e-01f,
  -7.49156997e-02f, -3.69949006e-02f, -1.49900079e-01f, 6.88843876e-02f, -1.38009980e-01f, 2.46362090e-01f, 8.34355280e-02f, -2.27393746e-01f, -1.67389333e-01f, -2.51405358e-01f,
  3.06328908e-02f, 5.43730199e-01f, -3.14502329e-01f, -2.45875329e-01f, 1.79955035e-01f, 1.10927083e-01f, 7.92645663e-02f, -1.82212323e-01f, 3.84741910e-02f, 2.27735668e-01f,
  1.37770265e-01f, 3.64680022e-01f, -3.02434951e-01f, 2.66917557e-01f, -1.90726444e-01f, -3.78700525e-01f, 5.99277169e-02f, 4.31464106e-01f, 3.61504078e-01f, 3.33212197e-01f,
  3.75055708e-02f, -4.44257297e-02f, 1.92097455e-01f, 1.31327480e-01f, -2.21849665e-01f, 2.36315746e-02f, 3.72402892e-02f, -2.75030155e-02f, 8.53600800e-02f, -4.76935744e-01f,
  1.37991384e-01f, -1.51550800e-01f, 6.00366116e-01f, -9.93782207e-02f, -1.74287111e-01f, -3.92687351e-01f, -3.71425301e-01f, -2.87187397e-01f, 1.65168315e-01f, 6.74505591e-01f,
  -5.08705199e-01f, -1.59555197e-01f, 2.13889301e-01f, -2.79406965e-01f, -1.77828297e-01f, 1.60467774e-01f, 3.87698442e-01f, 4.49603125e-02f, 4.46933359e-02f, 5.03693879e-01f,
  -1.51670054e-01f, 5.96792400e-01f, 1.85660020e-01f, -2.03268319e-01f, 5.71112216e-01f, 2.78810710e-01f, 1.13560654e-01f, -9.50789601e-02f, -1.42313853e-01f, -1.98132172e-02f,
  4.73742746e-02f, -1.47893175e-01f, -1.85804293e-01f, 2.67574430e-01f, -3.47783059e-01f, -1.36483416e-01f, 3.61566007e-01f, 1.52635649e-01f, -2.72354752e-01f, 1.00942887e-02f,
  6.69392794e-02f, -1.62938699e-01f, 1.93507746e-01f, 3.03169280e-01f, 9.10465270e-02f, -8.38402361e-02f, -2.45923668e-01f, 3.77394371e-02f, 1.00130826e-01f, 1.93230838e-01f,
  1.87246166e-02f, -3.74228418e-01f, 1.93364993e-01f, -4.15675491e-02f, -1.03056796e-01f, -2.47908190e-01f, 2.05012649e-01f, -9.49786305e-02f, 2.01234460e-01f, 2.06552055e-02f,
  6.16134033e-02f, 3.05825412e-01f, 1.05581038e-01f, -2.95397013e-01f, -8.77870247e-03f, -2.51106113e-01f, -4.08660352e-01f, -2.78376907e-01f, -3.56696427e-01f, -3.20055902e-01f,
  -3.59292775e-01f, 2.94644445e-01f, -1.36154264e-01f, 4.02688295e-01f, -1.52094871e-01f, -4.08236682e-02f, -5.74141383e-01f, -5.17615378e-01f, 3.95947129e-01f, -4.75793302e-01f,
  -3.35456312e-01f, -2.99001396e-01f, 4.57091719e-01f, 1.39136210e-01f, 2.11804584e-01f, 8.63550405e-04f, 7.75217488e-02f, 4.76186723e-01f, -5.78696430e-01f, 4.63329554e-01f,
  -8.01769421e-02f, -1.91421956e-01f, 3.10881406e-01f, -1.14825927e-01f, 1.26562655e-01f, 1.70407388e-02f, -1.72327891e-01f, -2.93730766e-01f, -7.44574592e-02f, 2.64848441e-01f,
  -3.09547424e-01f, -2.73494214e-01f, 5.31429611e-03f, -4.92291339e-02f, 7.67694563e-02f, -1.86172664e-01f, 7.42220134e-02f, 1.91013291e-01f, 3.30680534e-02f, -1.02209501e-01f,
  1.20106794e-01f, 1.79257557e-01f, 1.44925371e-01f, -8.01106319e-02f, 4.50448655e-02f, 1.02109827e-01f, -1.39469132e-02f, -3.18003893e-01f, -8.54335427e-02f, 1.43110171e-01f,
  1.35934800e-01f, 4.76396047e-02f, 9.44728181e-02f, -1.04025900e-01f, 1.14168935e-02f, 1.88596949e-01f, 2.16471642e-01f, 1.05579257e-01f, -1.63847655e-01f, 1.21639065e-01f,
  3.78683835e-01f, -3.59675027e-02f, -2.53857940e-01f, 5.25043011e-01f, 4.94147152e-01f, -2.80228227e-01f, -2.57553570e-02f, -4.18994993e-01f, 5.44422269e-01f, -1.66655093e-01f,
  1.13022447e-01f, -4.90407258e-01f, -5.70448220e-01f, 2.44212449e-01f, -2.47301206e-01f, 1.52701288e-01f, -1.18475243e-01f, -2.26744160e-01f, 6.77927315e-01f, 4.39455181e-01f,
  5.86903505e-02f, 8.07320792e-03f, 1.26602277e-01f, -5.94393075e-01f, -1.92284528e-02f, -3.79549474e-01f, -1.94095731e-01f, 5.76966889e-02f, -2.12739274e-01f, -6.70697493e-03f,
  3.79982382e-01f, 6.25176355e-03f, 5.89076817e-01f, -6.95785731e-02f, -3.28793764e-01f, -1.73649147e-01f, -2.26306483e-01f, 7.55634233e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.08959021e-02f, -8.73971544e-03f, -2.71036159e-02f, 2.88806409e-02f, 1.01256937e-01f, -3.42756808e-02f, -1.46684319e-01f, 2.69488990e-02f, 3.41359600e-02f, 5.81082422e-03f,
  6.38815910e-02f, -7.85725340e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    