/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.40248173e-01f, 3.01459339e-02f, 6.07681684e-02f, -1.27959803e-01f, 3.22646722e-02f, -3.31288159e-01f, -2.61100173e-01f, 4.92975414e-02f, -5.91670126e-02f, -3.82699072e-03f,
  -8.31611082e-02f, -1.01076581e-01f, 1.96100309e-01f, -2.33524576e-01f, -2.08611310e-01f, 3.29235457e-02f, -3.55265915e-01f, -1.85236201e-01f, 1.46346465e-01f, 1.10154204e-01f,
  7.33731091e-02f, -6.30389303e-02f, -7.65237510e-02f, 1.56446651e-01f, -6.29706159e-02f, 1.46868974e-01f, 1.23799160e-01f, 1.96542576e-01f, -6.17636815e-02f, -1.19095929e-01f,
  -1.15726516e-01f, 1.18157618e-01f, -6.19704556e-03f, 5.84625825e-02f, -1.61860101e-02f, -5.18112350e-03f, -2.44326089e-02f, -6.02091737e-02f, 2.84738019e-02f, 3.75997461e-02f,
  7.18252063e-02f, 4.74889278e-02f, -2.22500078e-02f, 5.53060398e-02f, 4.16327678e-02f, -1.12380475e-01f, 5.38003333e-02f, -3.72379236e-02f, 8.43853056e-02f, 2.57622134e-02f,
  -6.57025957e-03f, 4.02261615e-02f, -2.34100153e-03f, 7.05114985e-03f, -5.88602573e-02f, 1.11867150e-03f, -4.98090535e-02f, -4.85636070e-02f, 1.72074866e-02f, -1.57661829e-02f,
  8.29812586e-02f, 2.62940470e-02f, 4.71716300e-02f, 6.29996210e-02f, 1.83316658e-03f, 7.45252520e-02f, 6.43420517e-02f, 3.10883187e-02f, 6.22019917e-02f, -2.80083343e-02f,
  3.60316373e-02f, -4.24918905e-02f, 6.05600700e-02f, -2.58622747e-02f, -6.19230382e-02f, -4.17928286e-02f, 8.71240627e-03f, 3.05739045e-02f, -3.00616156e-02f, -7.32997656e-02f,
  8.38827863e-02f, -1.02232108e-02f, -1.05060795e-02f, 4.38698754e-03f, -2.10855547e-02f, -2.03117654e-02f, 1.80930756e-02f, -2.21027955e-02f, -2.16889773e-02f, -7.84999207e-02f,
  1.73843727e-02f, 2.41211765e-02f, 2.50502396e-02f, -7.17649683e-02f, 8.66357535e-02f, -1.98984165e-02f, -4.71513383e-02f, -3.92297097e-02f, -1.02544641e-02f, 3.55476886e-02f,
  -3.41518596e-02f, -9.96809360e-03f, -1.76669415e-02f, -8.14050511e-02f, -2.18320545e-02f, -1.11630112e-02f, -6.66530197e-03f, 9.75086354e-03f, -9.67365429e-02f, 3.29443328e-02f,
  4.51333523e-02f, 1.86499692e-02f, -3.51487845e-02f, -4.82358225e-03f, -8.22754204e-02f, 7.23646060e-02f, -2.05035284e-02f, 3.14296298e-02f, -3.06234155e-02f, -1.76112875e-02f,
  -2.56969094e-01f, 3.67416888e-02f, 1.75140396e-01f, -2.22841650e-01f, 6.57943487e-02f, -1.64704084e-01f, 2.68469043e-02f, -3.63028608e-02f, 7.93382227e-02f, -3.72806974e-02f,
  -1.08640164e-01f, 7.77332783e-02f, 9.79691893e-02f, -2.20108464e-01f, 4.71854495e-04f, -5.72167188e-02f, -6.81047514e-02f, -1.36666875e-02f, 1.72699019e-01f, -6.88592941e-02f,
  2.16990951e-02f, -1.54855177e-01f, 4.14311700e-02f, 2.42269970e-02f, -9.59530994e-02f, -9.67052300e-03f, 2.87331194e-02f, 8.67534727e-02f, -1.10421389e-01f, 2.67795734e-02f,
  -1.30827874e-01f, 6.76941406e-03f, -7.10853934e-03f, 1.01535201e-01f, -4.02341336e-02f, 6.02347404e-03f, 1.16883658e-01f, 6.74125478e-02f, 5.95002584e-02f, -5.11095021e-03f,
  -5.54764159e-02f, -2.52437964e-02f, -6.56739026e-02f, 5.54629304e-02f, 3.38727571e-02f, 2.27806885e-02f, 6.72618020e-03f, -1.01458915e-01f, -2.33749300e-02f, -1.65870991e-02f,
  -2.62281448e-02f, -2.41717994e-02f, -5.74183390e-02f, -6.36729365e-03f, 2.32037753e-02f, 5.56436479e-02f, 5.19790687e-02f, -3.90109532e-02f, -9.08771381e-02f, 2.68883184e-02f,
  -9.90460743e-04f, 1.21448748e-01f, -1.40461586e-02f, -4.85057905e-02f, -8.44182894e-02f, -6.45452514e-02f, -4.73163426e-02f, -7.09075667e-03f, -7.74464458e-02f, -3.11245695e-02f,
  -1.62209913e-01f, -3.97683606e-02f, -7.31104612e-02f, 1.26517927e-02f, -1.00480050e-01f, -7.66574442e-02f, -8.14012159e-03f, 1.00968238e-02f, -5.14006875e-02f, 1.25762001e-02f,
  8.36594179e-02f, -5.27318642e-02f, -4.29434739e-02f, -6.36344543e-03f, -7.98847340e-03f, -3.04156747e-02f, 5.53828068e-02f, 8.16483125e-02f, 2.43335795e-02f, -1.02850810e-01f,
  -1.58972770e-01f, -6.35764450e-02f, 1.02484142e-02f, -4.71887998e-02f, -3.36842202e-02f, 6.43179789e-02f, -1.53730651e-02f, 2.48661898e-02f, -1.44090401e-02f, 2.17965171e-02f,
  3.35907452e-02f, -3.76777351e-02f, -5.99124953e-02f, -2.02717409e-02f, -4.98925522e-02f, 1.39857419e-02f, -5.67283332e-02f, 1.43078836e-02f, -7.05120191e-02f, 4.94396091e-02f,
  -6.74476773e-02f, 2.73247492e-02f, -5.22685312e-02f, -3.19155231e-02f, -1.05750915e-02f, 2.14655939e-02f, -6.08345419e-02f, 1.85906589e-02f, -2.43048947e-02f, -3.46253738e-02f,
  1.17245696e-01f, 2.77750611e-01f, 1.65622190e-01f, 2.50133306e-01f, -2.93312371e-02f, 3.04069012e-01f, 2.62296766e-01f, 1.41203791e-01f, 2.37237409e-01f, 1.69065565e-01f,
  3.13164890e-02f, 2.19974145e-01f, -1.67355418e-01f, 1.64102659e-01f, -4.51909862e-02f, -9.01095569e-02f, 9.27487761e-02f, 7.54580572e-02f, -9.09253061e-02f, 9.18399915e-02f,
  6.17863610e-02f, -6.29729703e-02f, -1.76987901e-01f, -3.63099948e-03f, -3.12285125e-02f, 5.33715636e-02f, -1.04276404e-01f, 5.77988103e-02f, 5.76876439e-02f, 8.85638595e-03f,
  -1.70944780e-02f, -3.61511372e-02f, -8.51513892e-02f, -5.65982573e-02f, -7.50802399e-04f, -3.61141860e-02f, 2.96605639e-02f, 1.64505802e-02f, 1.26018235e-02f, 1.72141455e-02f,
  -4.08847407e-02f, -1.18020759e-03f, 5.65742068e-02f, 6.65630996e-02f, 5.45696653e-02f, -4.32422236e-02f, -9.11729038e-02f, -4.35155220e-02f, 1.37862926e-02f, -6.51884750e-02f,
  6.39232749e-04f, 3.73463184e-02f, 2.09615231e-02f, 5.57035916e-02f, -7.98491687e-02f, 3.61084975e-02f, 6.37242720e-02f, -6.38235211e-02f, -3.61258723e-02f, 4.84099351e-02f,
  -3.28712165e-02f, 5.19830212e-02f, -1.73352251e-03f, 4.16139513e-02f, 6.47951216e-02f, -1.16143012e-02f, 5.97481392e-02f, -4.64767255e-02f, 3.78040411e-02f, -7.54349530e-02f,
  1.15347076e-02f, -2.24266592e-02f, -5.90234697e-02f, 1.99398212e-02f, -1.89994499e-02f, 4.58281115e-02f, -2.76411604e-02f, -6.47567287e-02f, 7.15794489e-02f, -1.02250047e-01f,
  -5.53244166e-02f, 4.34482694e-02f, -3.04632168e-02f, -5.82441464e-02f, -1.17748566e-02f, -2.90248487e-02f, 1.43592283e-02f, -1.30208461e-02f, -5.55011295e-02f, 7.92537257e-03f,
  9.31789577e-02f, 4.49981578e-02f, -1.04015134e-01f, -6.91403374e-02f, -8.19029734e-02f, -6.73304200e-02f, -9.98806767e-03f, -4.56789210e-02f, 5.25714159e-02f, -2.78242566e-02f,
  4.34068255e-02f, -1.36495074e-02f, 3.27627659e-02f, -8.54434446e-03f, 7.42132962e-02f, 6.55580163e-02f, 2.74146777e-02f, 4.84294109e-02f, 3.79105122e-03f, 3.75486724e-02f,
  -6.88065439e-02f, -5.06277345e-02f, 5.79426065e-03f, -4.08658311e-02f, 2.61578080e-03f, 1.11648459e-02f, 2.84862500e-02f, 3.89730707e-02f, -1.05166905e-01f, -7.38608418e-03f,
  -3.60056907e-01f, -1.79132700e-01f, -6.49840534e-02f, -1.37897536e-01f, -1.01504847e-02f, 1.10216923e-01f, -6.53792545e-02f, -1.21237338e-01f, 1.27319684e-02f, -1.90994367e-02f,
  -8.28789398e-02f, -9.01814476e-02f, 4.84276898e-02f, -1.49500087e-01f, -4.73859273e-02f, 6.13462515e-02f, -2.93012746e-02f, 1.24704535e-03f, 8.56957063e-02f, -9.43967998e-02f,
  -1.21877424e-01f, 4.81401570e-02f, -2.24895656e-01f, -2.96082273e-02f, -1.44492358e-01f, -3.87524813e-02f, 5.57252355e-02f, -1.92875303e-02f, -1.60547867e-01f, 7.54718184e-02f,
  5.51155284e-02f, -8.12557414e-02f, -8.66316929e-02f, 6.73316643e-02f, 5.37541024e-02f, -4.64484505e-02f, 4.75576483e-02f, 4.17612158e-02f, -4.52477261e-02f, -2.70071998e-02f,
  -1.25686955e-02f, -2.26869155e-02f, 5.69687709e-02f, -3.38630714e-02f, 3.40970904e-02f, -1.78237371e-02f, -3.95327844e-02f, 2.91154757e-02f, -5.34737622e-03f, -9.84632969e-03f,
  -1.25753423e-02f, 6.23925924e-02f, 1.15759857e-01f, 5.01973368e-02f, 2.50729956e-02f, -1.23682311e-02f, -1.14281066e-02f, -4.15960401e-02f, 1.30208194e-01f, 1.96518358e-02f,
  -9.05404687e-02f, 1.98549274e-02f, 3.71173732e-02f, 1.19654206e-03f, 4.54605371e-03f, -4.86944889e-04f, 8.92821550e-02f, -2.19189067e-04f, 1.16374984e-01f, -5.21676429e-02f,
  -4.45508584e-02f, -9.92873218e-03f, 1.41327634e-01f, -1.12444190e-02f, -3.16915661e-02f, -3.84452231e-02f, 4.72642109e-02f, 9.00274813e-02f, -4.99717556e-02f, -3.18249725e-02f,
  -2.08981410e-02f, 2.52201036e-02f, -6.15220144e-02f, -1.04484112e-04f, 1.33573050e-02f, 9.84442700e-03f, -2.34064255e-02f, 5.93139464e-03f, 3.10816839e-02f, 4.61813733e-02f,
  7.78351203e-02f, 1.19226001e-01f, -6.31909221e-02f, -2.60158256e-02f, 4.42170016e-02f, 1.49089340e-02f, 4.15948667e-02f, -2.53708642e-02f, 4.63474952e-02f, -2.46236548e-02f,
  5.15077682e-03f, 2.31697690e-03f, 9.81433466e-02f, 4.59567606e-02f, 7.12124305e-03f, -9.97639447e-03f, 7.52317235e-02f, 5.48619889e-02f, 3.86377871e-02f, 2.15533189e-02f,
  -3.42236087e-02f, 3.09900660e-02f, 1.86526868e-02f, -6.11366443e-02f, -4.09759693e-02f, 6.09278854e-04f, 4.42704521e-02f, 5.37982630e-03f, 2.50102580e-02f, 8.96308050e-02f,
  1.14694543e-01f, -4.35473949e-01f, -1.90618739e-01f, -1.81197137e-01f, 2.91404072e-02f, 2.00552657e-01f, 1.60405740e-01f, -3.08143981e-02f, -5.62292226e-02f, 1.92915261e-01f,
  2.90399998e-01f, -1.08422108e-01f, 9.84666198e-02f, 2.40649566e-01f, -6.95613772e-02f, -1.00957878e-01f, 2.85458267e-01f, 1.61899135e-01f, -1.65273160e-01f, 4.76981737e-02f,
  -9.31726992e-02f, 2.87889987e-01f, -1.03652082e-01f, -3.60009372e-02f, 4.50812094e-02f, -1.31479830e-01f, -9.75975126e-04f, -1.15593649e-01f, 1.13856226e-01f, 1.85491878e-03f,
  2.53316611e-02f, 1.68844629e-02f, -4.05255407e-02f, 3.58893983e-02f, 1.59262508e-01f, 1.60141468e-01f, 2.38035414e-02f, -3.11649852e-02f, 2.05178671e-02f, 3.40063013e-02f,
  3.33608780e-03f, -1.96332093e-02f, -4.57882397e-02f, 7.91257364e-04f, 4.50962409e-02f, -4.68543023e-02f, -3.97557355e-02f, -5.79212196e-02f, 2.28571333e-03f, 2.97033153e-02f,
  -5.42907640e-02f, 3.44418809e-02f, 5.81482127e-02f, 1.05612695e-01f, -5.95644079e-02f, 3.31303850e-02f, 4.80107926e-02f, 7.26206824e-02f, -2.89572440e-02f, 8.07889330e-04f,
  5.76550253e-02f, 1.03436932e-01f, -3.71525846e-02f, 5.03255501e-02f, -6.28062636e-02f, 1.76642928e-02f, -3.33687179e-02f, 6.12803549e-02f, -5.89377396e-02f, -1.86940376e-02f,
  -1.78709328e-02f, -6.55722320e-02f, 2.95374659e-03f, 1.03354547e-02f, -6.97430894e-02f, 2.51918919e-02f, 1.73293278e-02f, 5.41295521e-02f, -9.27956104e-02f, 2.75900704e-03f,
  9.11730006e-02f, -8.62480029e-02f, -6.95057511e-02f, -1.83579680e-02f, 2.90734656e-02f, -4.84310947e-02f, 4.43062112e-02f, -4.64096256e-02f, -9.25163403e-02f, -1.04009211e-01f,
  2.08929367e-02f, 1.98152587e-02f, -1.79982185e-02f, -3.15830037e-02f, -1.26598418e-01f, -2.41022281e-04f, -1.41776362e-02f, 2.93834340e-02f, -3.35027091e-02f, -3.92190227e-03f,
  5.80170937e-02f, 5.08897975e-02f, 2.69543882e-02f, 4.71997745e-02f, -3.67954150e-02f, 4.49003913e-02f, -1.51798816e-03f, 6.73380196e-02f, 4.18675132e-02f, 2.85738762e-02f,
  -1.37674306e-02f, 8.49468634e-04f, -4.92570037e-03f, 4.67194095e-02f, 8.72331187e-02f, 4.91053462e-02f, 3.19311884e-03f, -6.56555444e-02f, -1.05267465e-02f, -1.88972186e-02f,
  1.06586285e-01f, 1.98001787e-01f, -2.24043995e-01f, -3.44278887e-02f, 8.31520185e-02f, -2.45126322e-01f, -1.63202673e-01f, 7.42878914e-02f, -1.28074348e-01f, 2.46681944e-01f,
  7.28110969e-02f, 2.62844414e-01f, -6.36941195e-02f, 1.76368654e-01f, -2.56363273e-01f, -2.37479955e-01f, -7.37689883e-02f, 6.40357211e-02f, -3.14075761e-02f, 1.43465891e-01f,
  -7.75244087e-02f, 2.46411040e-01f, -1.20041579e-01f, 8.48619044e-02f, 2.40649935e-02f, 1.01068668e-01f, 1.87626481e-01f, -3.41361351e-02f, 1.39578149e-01f, 3.63091528e-02f,
  1.59903970e-02f, 1.57771736e-01f, 2.71547604e-02f, -1.36431586e-02f, -7.00396150e-02f, -6.68106154e-02f, 2.28733066e-02f, -7.21145123e-02f, -6.63589761e-02f, -2.44497862e-02f,
  1.10927917e-01f, 5.45184463e-02f, 3.62696461e-02f, 9.01881838e-04f, -7.43731186e-02f, -6.27832161e-03f, -5.27086891e-02f, -8.59689415e-02f, -3.34262401e-02f, -5.84348440e-02f,
  -3.20560671e-02f, 1.53342504e-02f, -1.11765213e-01f, -4.11414430e-02f, -1.06128871e-01f, 3.90056968e-02f, -1.81247108e-02f, 2.18020305e-02f, -1.75056532e-02f, 1.65198725e-02f,
  -6.37216046e-02f, -4.68485355e-02f, 7.04186112e-02f, -3.38707715e-02f, 3.79228629e-02f, 6.47942647e-02f, -1.58779640e-02f, 5.92256449e-02f, 3.90710309e-02f, 8.05540457e-02f,
  6.03092164e-02f, 4.22801971e-02f, 6.27796203e-02f, -5.25399484e-02f, 1.40381483e-02f, 6.74519837e-02f, -1.18026184e-02f, 6.23194501e-02f, -5.05768694e-02f, 3.01998612e-02f,
  5.01180738e-02f, -1.55673753e-02f, 2.35831309e-02f, -5.49398102e-02f, -5.75535968e-02f, -1.01616094e-03f, -9.28902905e-03f, -4.06425707e-02f, -2.87808552e-02f, 1.75927058e-02f,
  -1.56647414e-02f, 1.42746583e-01f, 3.28701921e-02f, 7.17303716e-03f, 8.72612372e-02f, 3.98195684e-02f, -4.38036248e-02f, 6.57138824e-02f, -5.48063926e-02f, 3.67716625e-02f,
  -5.44997193e-02f, -1.30812759e-02f, -6.22706302e-02f, 7.71947484e-03f, 1.14632985e-02f, 2.08593719e-02f, 4.55939621e-02f, 1.82425976e-02f, 2.34132558e-02f, 5.93411252e-02f,
  1.45096406e-02f, 4.33812477e-02f, 6.09182417e-02f, 4.90576439e-02f, 6.85437443e-03f, 8.28607194e-03f, 2.57431511e-02f, -2.71839164e-02f, 1.25820152e-02f, -4.48922552e-02f,
  4.44589466e-01f, -2.76561864e-02f, -3.78951728e-02f, 1.41899809e-01f, 1.77710906e-01f, -3.22315805e-02f, -2.29751751e-01f, 1.74933210e-01f, 1.62592873e-01f, -8.07700455e-02f,
  -1.18965581e-01f, -1.38790235e-01f, -1.76885664e-01f, 1.09732203e-01f, 9.99500379e-02f, -2.77430564e-02f, 1.78811505e-01f, -9.43239033e-02f, 8.79864544e-02f, 1.01157110e-02f,
  -4.55110101e-03f, 1.57641880e-02f, -4.69918586e-02f, 9.99863222e-02f, 6.86076656e-02f, 7.20675336e-03f, 2.82102041e-02f, -1.17309496e-01f, 4.25657779e-02f, 1.38937250e-01f,
  -2.54840888e-02f, 2.86873728e-02f, -2.15253271e-02f, -7.47151673e-02f, -2.93500703e-02f, -1.39297787e-02f, 5.31576350e-02f, -2.62802709e-02f, -1.95793137e-02f, -9.21313912e-02f,
  -1.23358801e-01f, 8.76663020e-04f, -2.84584686e-02f, 3.06274071e-02f, 3.99700850e-02f, -2.54238769e-02f, 4.60652374e-02f, -2.36712825e-02f, 4.90633696e-02f, -3.53775695e-02f,
  -7.22607896e-02f, -1.79680437e-02f, 3.05371303e-02f, 7.59868175e-02f, 7.83448294e-02f, 3.47335264e-02f, -4.32827435e-02f, -2.28102505e-02f, 5.19195050e-02f, 5.77096045e-02f,
  1.04704164e-02f, -1.06282607e-02f, -1.40654640e-02f, 3.98568325e-02f, -1.92371830e-02f, -3.79128475e-03f, 3.08281053e-02f, -3.36110182e-02f, 4.46417853e-02f, 3.85378604e-04f,
  1.27305491e-02f, -2.17543356e-02f, 7.95610901e-03f, -1.54468575e-02f, -5.31279445e-02f, -6.84051067e-02f, -7.93893859e-02f, 9.43400257e-04f, 2.84552816e-02f, 5.51994145e-03f,
  -8.77482295e-02f, 2.89344899e-02f, -2.91361827e-02f, -1.98424906e-02f, -7.44744837e-02f, 1.81346927e-02f, 3.11221424e-02f, 7.12819472e-02f, -8.28624293e-02f, -6.99753016e-02f,
  -7.94674978e-02f, -3.06192208e-02f, 2.08657440e-02f, -4.76046652e-02f, -4.27463790e-03f, 1.63430872e-03f, -1.78077612e-02f, -3.17962579e-02f, 4.08893898e-02f, -4.11359668e-02f,
  2.33688694e-03f, 4.70540933e-02f, 1.00154104e-02f, -9.12400708e-02f, -2.00972632e-02f, -2.46757958e-02f, 1.10000104e-03f, -6.43615872e-02f, 4.34311703e-02f, 1.60309561e-02f,
  4.13394608e-02f, 5.24623767e-02f, 7.39504024e-03f, -4.35532555e-02f, -4.04753909e-02f, -4.36228281e-03f, 7.89467022e-02f, -6.90986216e-02f, -1.00127086e-01f, -2.38042530e-02f,
  2.12451130e-01f, 1.93118919e-02f, 1.19058378e-01f, 1.36255071e-01f, -1.71287537e-01f, -2.47486785e-01f, -1.31904006e-01f, -5.01014329e-02f, -1.43282399e-01f, -4.38656099e-02f,
  -4.51716334e-02f, -5.12320139e-02f, -1.51449978e-01f, -6.01536967e-02f, -7.13765919e-02f, -2.74019092e-01f, -2.44905949e-02f, -7.05069229e-02f, -1.32289052e-01f, 1.21015385e-01f,
  3.21914180e-04f, -1.14084922e-01f, 5.75381368e-02f, 8.30473602e-02f, -3.27581912e-02f, 1.55410722e-01f, 2.81250715e-01f, 3.52077782e-02f, 1.95837006e-01f, -5.23404367e-02f,
  -1.43438403e-03f, -5.53882644e-02f, 4.08396358e-03f, -5.45519143e-02f, 5.16037978e-02f, 1.59752462e-02f, 8.31995681e-02f, -6.21927418e-02f, 2.94008739e-02f, -7.44315758e-02f,
  -2.62071434e-02f, -4.24322998e-03f, -1.09746624e-02f, -6.28670752e-02f, -3.91084999e-02f, -1.55283678e-02f, -7.51986867e-03f, 1.15780398e-01f, -4.48319204e-02f, -3.34567167e-02f,
  1.68048013e-02f, 4.99264076e-02f, 4.89821658e-02f, -6.41479641e-02f, 8.31816867e-02f, -2.77244262e-02f, 1.57988835e-02f, -8.25045444e-03f, -1.59865781e-03f, -1.46127390e-02f,
  2.24348735e-02f, -3.10725532e-02f, 6.09005615e-02f, -4.37746793e-02f, 1.70059074e-02f, -7.71767693e-03f, 3.31186783e-03f, -8.15183017e-03f, 6.30465597e-02f, -5.70797026e-02f,
  9.44480076e-02f, 8.76859762e-03f, -7.05428272e-02f, -3.46580185e-02f, 5.16338833e-02f, -9.46986768e-03f, 5.59473708e-02f, 5.15208058e-02f, 1.58037283e-02f, 3.34951095e-02f,
  -9.67267714e-03f, 1.06157027e-02f, -4.81449068e-02f, 8.91468197e-04f, -3.85407545e-02f, -3.96924205e-02f, -3.50158028e-02f, 1.34436768e-02f, -7.63753476e-03f, -3.49250510e-02f,
  2.89566200e-02f, -3.89872747e-03f, -1.16320252e-02f, -8.40074793e-02f, 2.46705152e-02f, 5.43850400e-02f, -7.78099289e-03f, 5.10542989e-02f, -2.23085564e-02f, 4.98523414e-02f,
  6.99592754e-02f, 4.57888506e-02f, 8.11285619e-03f, 3.74226980e-02f, 3.67374197e-02f, 3.51427915e-03f, -2.75640991e-02f, 6.02028295e-02f, 8.58905688e-02f, 2.32394170e-02f,
  2.06345525e-02f, -1.86992604e-02f, -8.32933374e-03f, 1.18986899e-02f, 6.38711825e-02f, -2.14004442e-02f, 6.44948259e-02f, -1.89428069e-02f, -1.64002422e-02f, -1.98616902e-03f,
  3.36917490e-01f, 1.74323618e-01f, 1.16895556e-01f, 9.12050381e-02f, -1.76815644e-01f, 1.67160943e-01f, 3.73947322e-01f, -1.15199342e-01f, 2.13534042e-01f, 3.25891888e-03f,
  -1.93919212e-01f, 1.34458899e-01f, 1.09348297e-01f, -8.48377421e-02f, -2.72814065e-01f, 9.34929848e-02f, -1.28547579e-01f, 1.00525469e-01f, 9.17215273e-02f, 8.35099965e-02f,
  3.19832936e-03f, -2.04529986e-01f, -3.43797021e-02f, -1.23228952e-01f, 1.11004494e-01f, 1.02062963e-01f, -2.44981959e-01f, 1.25741288e-01f, -1.47985563e-01f, -1.36749193e-01f,
  3.13379578e-02f, -2.26604939e-03f, 4.21597995e-02f, 3.43164727e-02f, -5.87700158e-02f, 5.71850948e-02f, 2.51976270e-02f, -4.83124964e-02f, -2.09821179e-03f, 1.46394214e-02f,
  4.39949185e-02f, -3.95671763e-02f, -3.14123519e-02f, -2.04438996e-02f, 3.41612566e-03f, -3.55858020e-02f, 1.16098411e-02f, 3.57783623e-02f, -1.24862685e-03f, 4.86593768e-02f,
  -1.71291213e-02f, -5.12345284e-02f, 7.80393332e-02f, -3.64404954e-02f, 3.66891958e-02f, 3.98643427e-02f, 1.18017811e-02f, 3.36028263e-02f, 3.31386141e-02f, -5.75901102e-03f,
  -2.95129269e-02f, 1.08780675e-01f, 4.08509709e-02f, 7.05506653e-04f, -6.73298491e-03f, -1.63239520e-02f, -2.38479837e-03f, -4.24072668e-02f, 3.55287455e-02f, -2.39563938e-02f,
  -1.14896540e-02f, -3.13732959e-02f, 9.31645371e-03f, 3.57850268e-02f, -1.28637692e-02f, 3.02688163e-02f, 4.23980318e-03f, 2.45947242e-02f, 1.97087694e-02f, -4.93435115e-02f,
  2.44452748e-02f, 1.07684555e-02f, 3.28513943e-02f, 5.63148744e-02f, -8.37916359e-02f, 2.84594335e-02f, 2.28605587e-02f, -1.86746276e-03f, -3.88019043e-03f, -1.24805523e-02f,
  -6.93439692e-02f, -3.64655554e-02f, 4.58141118e-02f, -2.20750719e-02f, 3.02103255e-02f, -5.35718054e-02f, -4.10109833e-02f, -4.75382991e-02f, -3.45813446e-02f, -9.84207168e-03f,
  1.92920323e-02f, 6.19735895e-03f, -1.04125543e-02f, -1.06339473e-02f, -4.76342291e-02f, 1.82574913e-02f, 8.00231844e-03f, 7.13717658e-03f, -1.51705788e-02f, -1.23272687e-01f,
  -1.62658598e-02f, 1.97568890e-02f, 1.13093224e-03f, 2.12211441e-02f, -8.03899951e-03f, -1.80021338e-02f, 2.84900516e-02f, 4.70744930e-02f, -2.61159223e-02f, 2.91249976e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.22077832e-01f, 1.50019586e-01f, 1.90601766e-01f, 6.56038970e-02f, -2.60192584e-02f, -1.71031088e-01f, -2.94185936e-01f, 3.55293527e-02f, -1.08209431e-01f, -2.21794635e-01f,
  -8.51502419e-02f, 7.70427287e-02f, -7.22871274e-02f, 2.10051626e-01f, 1.03596086e-02f, -1.10632561e-01f, 9.56211463e-02f, 6.53782859e-02f, 1.50172226e-02f, 2.04534203e-01f,
  1.76134437e-01f, 1.96764454e-01f, 2.20310822e-01f, 1.78486988e-01f, 1.19888544e-01f, 7.72425681e-02f, 1.53117195e-01f, 7.74485543e-02f, 1.25213251e-01f, -5.14837131e-02f,
  -3.52989845e-02f, 3.83651033e-02f, 2.10063830e-02f, 5.56245968e-02f, 2.10071132e-02f, -3.45082991e-02f, 6.71612844e-03f, 6.88765049e-02f, 7.66324205e-03f, 3.76950502e-02f,
  4.29665558e-02f, -1.07668899e-02f, 5.17757051e-02f, 1.63884871e-02f, 4.68922071e-02f, -3.18731107e-02f, -1.77748501e-02f, -3.18418145e-02f, 7.46460184e-02f, 8.15564021e-02f,
  4.89063077e-02f, -3.59816477e-02f, 1.17306165e-01f, -9.59430858e-02f, -3.40325981e-02f, -7.00579435e-02f, -5.93107101e-03f, -3.49940434e-02f, -4.49435934e-02f, 5.69311306e-02f,
  2.22521611e-02f, -4.52673398e-02f, 8.65637511e-03f, -7.29237497e-02f, 9.01284907e-03f, -6.07798621e-03f, 3.21232900e-02f, -2.95925513e-02f, 6.34276271e-02f, 1.46244876e-02f,
  -7.79941455e-02f, 5.73858153e-03f, -4.72246781e-02f, 5.26151340e-03f, -2.25042850e-02f, 4.20585014e-02f, 6.43262044e-02f, -1.01056893e-03f, -3.54043357e-02f, 2.62446553e-02f,
  2.24644393e-02f, 5.59616126e-02f, 1.44056324e-02f, 1.12257581e-02f, -6.07895292e-02f, 1.02293119e-02f, 5.46455234e-02f, -1.03430338e-01f, -1.06675765e-02f, -6.02313206e-02f,
  6.74757957e-02f, 1.06501423e-01f, 2.24705134e-02f, -3.81309241e-02f, -5.03465235e-02f, 4.58218344e-02f, 4.74859886e-02f, -4.57715429e-03f, 1.34816952e-02f, -1.94688067e-02f,
  5.61175458e-02f, -3.66466716e-02f, 8.18383843e-02f, 1.23793513e-01f, -2.83517526e-03f, 7.70101370e-03f, -1.00212052e-01f, -6.49536541e-03f, 3.12057454e-02f, -2.48081945e-02f,
  2.42407545e-02f, 4.68446240e-02f, -7.07963705e-02f, -3.13417725e-02f, 9.16854814e-02f, -5.70774451e-02f, 1.19759561e-02f, -3.11964545e-02f, -1.51815116e-02f, 4.23161350e-02f,
  1.51230931e-01f, 5.44134527e-02f, 6.65362477e-02f, -1.53046906e-01f, -1.50167465e-01f, -1.64912060e-01f, -2.29535982e-01f, -6.04932345e-02f, 3.19544505e-03f, 7.17307255e-02f,
  -9.07245949e-02f, 9.40762237e-02f, 4.86604758e-02f, -2.29288191e-01f, -2.46639788e-01f, 4.89094071e-02f, -3.28213066e-01f, -1.43757373e-01f, 4.15781513e-02f, -2.36476183e-01f,
  -4.36092354e-02f, -3.45692307e-01f, -2.03608960e-01f, -1.01813205e-01f, -2.25603595e-01f, 5.44141047e-02f, -1.23128600e-01f, 5.98585345e-02f, -5.91453873e-02f, -1.11090735e-01f,
  -1.22076184e-01f, 1.07168786e-01f, 5.31266704e-02f, 6.43163323e-02f, -6.19632266e-02f, -5.62371016e-02f, -4.96704243e-02f, -6.00353628e-02f, 4.57220078e-02f, 8.08996484e-02f,
  7.54927918e-02f, 5.68183251e-02f, 8.83421227e-02f, -1.78846400e-02f, 3.79374698e-02f, 1.00934580e-01f, 1.15285674e-02f, -4.20195162e-02f, -2.24755164e-02f, 3.19323055e-02f,
  1.29580647e-02f, 5.51696010e-02f, -5.85002042e-02f, 7.38911405e-02f, 1.69470627e-02f, 9.78824347e-02f, -8.37702602e-02f, 2.85294987e-02f, -5.00193052e-02f, 4.34664497e-03f,
  1.13716684e-01f, 6.02909401e-02f, 1.41639402e-02f, 1.11431852e-02f, -4.78646010e-02f, 3.38658574e-03f, -2.62427442e-02f, 1.06558017e-01f, 2.86980476e-02f, 6.44674897e-03f,
  -1.93359274e-02f, 3.18554007e-02f, -3.62022147e-02f, -2.74260193e-02f, -2.21040864e-02f, 5.60030043e-02f, 3.07270102e-02f, -2.22004857e-03f, -5.36207631e-02f, -4.20013219e-02f,
  -2.45439373e-02f, -8.87341946e-02f, 3.56520638e-02f, -6.36042207e-02f, -3.00066154e-02f, 1.00734264e-01f, 3.88014019e-02f, 7.05803633e-02f, 3.81391346e-02f, -4.46115695e-02f,
  -2.03789026e-02f, -8.30016732e-02f, 3.60976122e-02f, 4.83576842e-02f, 5.32258209e-03f, -5.50801754e-02f, -4.19204235e-02f, -3.39059643e-02f, -1.31309172e-02f, -8.47660229e-02f,
  -5.23082130e-02f, -2.43117101e-02f, -9.19484794e-02f, 1.18990857e-02f, -4.55833748e-02f, -4.01321091e-02f, -6.30560964e-02f, 6.69872835e-02f, -1.18837498e-01f, -3.20838694e-03f,
  -4.02641818e-02f, -3.43007990e-03f, 1.00832721e-02f, -8.96548033e-02f, -1.67680401e-02f, 1.98807307e-02f, 1.68380998e-02f, -1.71781227e-04f, 2.06972603e-02f, 2.58457456e-02f,
  3.29043686e-01f, 4.44409072e-01f, 1.26342714e-01f, 9.19073895e-02f, -1.04010604e-01f, -1.30457997e-01f, -7.06079677e-02f, -2.91046854e-02f, 6.80320561e-02f, 5.34725673e-02f,
  -2.90488154e-01f, 3.21298361e-01f, -1.99021325e-02f, -1.02072217e-01f, -3.48284543e-01f, -1.64477855e-01f, -1.86722025e-01f, 5.29016480e-02f, -1.15578687e-02f, -1.13909349e-01f,
  -8.12893584e-02f, -3.64948988e-01f, -5.26389070e-02f, -1.72263831e-01f, -4.44058739e-02f, 1.25154823e-01f, -3.27783585e-01f, -3.35984565e-02f, 1.84118114e-02f, -6.87262863e-02f,
  -1.51382148e-01f, -1.09873079e-01f, 1.02806605e-01f, -4.98242909e-04f, -3.44964080e-02f, 2.88026500e-02f, 6.62365705e-02f, -2.01985929e-02f, -5.02622388e-02f, 1.76458918e-02f,
  4.95464802e-02f, -4.88676783e-03f, 3.95830767e-03f, 1.00401409e-01f, -1.28696542e-02f, 3.02926190e-02f, -5.80151705e-03f, 2.85127833e-02f, 4.62120399e-02f, 8.41985717e-02f,
  4.05799337e-02f, 5.15262485e-02f, -1.78701282e-02f, -8.64843056e-02f, -2.82630511e-02f, -3.53532061e-02f, -9.82654281e-03f, 5.17886020e-02f, 1.83972158e-02f, 2.69797891e-02f,
  -4.82183369e-03f, -6.42960817e-02f, -7.47598894e-03f, 7.04207644e-02f, -4.75592874e-02f, -5.50293550e-02f, 1.06997639e-02f, -5.27296960e-02f, -6.72496716e-03f, -9.33764651e-02f,
  -2.85470486e-02f, 3.68243866e-02f, 5.44644855e-02f, 6.85036136e-03f, 1.29491091e-02f, -1.92986783e-02f, 3.25541608e-02f, 9.45827924e-03f, 2.95732561e-02f, 2.55086552e-02f,
  2.44826525e-02f, -3.46797183e-02f, 3.28191668e-02f, -1.16047040e-02f, -6.04294837e-02f, 7.11497152e-03f, -1.53656527e-02f, 3.39942127e-02f, -1.95365027e-02f, -1.16828047e-01f,
  -3.38202745e-01f, -3.70357782e-01f, -1.28820986e-01f, -6.90805912e-02f, -6.80959299e-02f, 1.87287983e-02f, -5.09045199e-02f, 1.08108722e-01f, -7.96594173e-02f, -6.32318482e-02f,
  2.18901187e-02f, -5.11168502e-02f, -5.83952330e-02f, 8.08429793e-02f, -3.17432731e-02f, 9.98144224e-03f, -4.43354622e-02f, -1.13400154e-01f, -9.11036730e-02f, 5.89696318e-02f,
  6.85326681e-02f, -2.28446312e-02f, -6.32149726e-02f, 2.00824272e-02f, 3.49813998e-02f, -3.89852673e-02f, 5.06255701e-02f, 1.23610094e-01f, 1.21119274e-02f, -2.66216695e-02f,
  1.46500647e-01f, -5.35298884e-01f, 8.57330114e-02f, 1.44699544e-01f, 2.26707876e-01f, -1.45338187e-02f, 2.15108514e-01f, -1.03271008e-01f, -7.80404434e-02f, -4.51150626e-01f,
  -6.91582635e-02f, -1.03280611e-01f, 3.72580998e-02f, -3.97757068e-02f, 2.61628181e-01f, -1.00320064e-01f, -2.49398891e-02f, -1.44336000e-01f, 2.17108168e-02f, -5.55206202e-02f,
  1.15970097e-01f, 1.75349577e-03f, 2.45060846e-01f, -2.30357815e-02f, 9.85164270e-02f, -3.34877744e-02f, 2.74916589e-02f, 1.14154264e-01f, -2.32702196e-02f, -1.30157467e-04f,
  -5.53283766e-02f, -1.46499500e-02f, 7.51969144e-02f, -5.17715402e-02f, -2.99654286e-02f, 2.96700802e-02f, 5.29406518e-02f, 5.51536530e-02f, 8.90737325e-02f, 2.87722368e-02f,
  -3.93552110e-02f, 1.24627147e-02f, 1.07714258e-01f, 1.11763351e-01f, 3.96960303e-02f, 8.22323337e-02f, -4.35357578e-02f, 3.57312895e-02f, -2.01234892e-02f, -3.68104801e-02f,
  4.69567850e-02f, 7.45427795e-03f, 1.89575832e-03f, -6.49097143e-03f, -1.30938133e-03f, -2.36909837e-02f, -1.13685464e-03f, -2.71062274e-02f, -4.31299489e-03f, 3.64335366e-02f,
  3.73270959e-02f, 7.48276263e-02f, 3.41747515e-02f, 6.10786341e-02f, -3.34203467e-02f, 8.80206227e-02f, 5.26215360e-02f, -7.09512876e-03f, -3.04814558e-02f, -7.93042034e-02f,
  -5.26142120e-03f, 3.76013778e-02f, 1.94651522e-02f, 2.60909111e-03f, 5.28152063e-02f, 4.99716364e-02f, 5.03383912e-02f, -5.40822558e-02f, -1.72881652e-02f, -9.12506715e-04f,
  -1.63630843e-02f, -7.38695171e-03f, -5.40428013e-02f, 3.89309488e-02f, 4.02055085e-02f, 9.85540152e-02f, -5.05896397e-02f, -7.50197545e-02f, 5.64315990e-02f, -1.25169358e-03f,
  -2.45744258e-01f, -2.85070419e-01f, -2.32870411e-02f, 2.85289362e-02f, -6.23026825e-02f, -1.20803192e-01f, -2.36015413e-02f, -3.45544443e-02f, -6.37163520e-02f, 3.25617008e-02f,
  -1.89957190e-02f, 5.25243804e-02f, -6.50229007e-02f, 1.61990291e-03f, 4.67853015e-03f, -6.76823547e-05f, -4.57755364e-02f, -7.98495263e-02f, 1.94217451e-02f, 4.55768639e-03f,
  -1.32703811e-01f, -2.14095376e-02f, 7.57740736e-02f, -3.75670120e-02f, -3.05103883e-02f, 6.14836775e-02f, -5.75653017e-02f, 8.66611153e-02f, -5.47764003e-02f, -8.30110908e-02f,
  3.76262516e-01f, -3.19260806e-02f, 1.53264493e-01f, 3.03573728e-01f, 1.25616223e-01f, 2.87849773e-02f, 1.04851127e-01f, 2.18569219e-01f, 3.27270150e-01f, -1.03524283e-01f,
  -9.33606848e-02f, 3.82761136e-02f, -1.00103937e-01f, 7.60409087e-02f, -5.46482354e-02f, -8.06629807e-02f, 8.36191401e-02f, 7.37763289e-03f, 1.00216135e-01f, 6.43612370e-02f,
  2.07187980e-01f, -8.07108134e-02f, 6.60506338e-02f, -1.18065745e-01f, -1.45304888e-01f, -2.13586967e-02f, -2.44661555e-01f, -2.19907865e-01f, -1.82482988e-01f, -5.38806878e-02f,
  -6.96472302e-02f, 2.07093179e-01f, -9.84388739e-02f, 3.50193344e-02f, -1.11689297e-02f, -8.15606937e-02f, -1.00368224e-01f, -4.93109971e-02f, 7.78179662e-03f, 8.32981989e-02f,
  -5.11199748e-03f, -1.18157817e-02f, 1.52795747e-01f, -3.22107747e-02f, 1.53735848e-02f, 6.09744824e-02f, 4.91995998e-02f, 1.53295528e-02f, 1.16446078e-01f, -3.85567062e-02f,
  7.27929249e-02f, 2.66026296e-02f, -2.78015602e-02f, -9.42066312e-03f, -4.22339514e-02f, 3.04641854e-02f, 6.25331178e-02f, -7.06909746e-02f, -8.29028934e-02f, 9.60163176e-02f,
  -2.34297179e-02f, 3.63494381e-02f, -6.46887720e-02f, -1.96523555e-02f, -6.47976324e-02f, -1.16588222e-02f, -4.71541211e-02f, 5.01925759e-02f, 7.65440911e-02f, 2.22047046e-02f,
  4.58002128e-02f, -1.37392990e-02f, 3.85813080e-02f, -3.72296497e-02f, 4.43781652e-02f, 1.06807366e-01f, 2.21091174e-02f, -6.59784228e-02f, -4.34096158e-02f, -4.35052477e-02f,
  6.28937781e-02f, -1.42694134e-02f, -9.06857252e-02f, 1.82506703e-02f, 1.54330907e-02f, 2.43291985e-02f, -7.88135976e-02f, 2.92769969e-02f, 5.04947752e-02f, 8.23802140e-04f,
  -2.80321717e-01f, -5.19959591e-02f, 2.27198713e-02f, 6.57645240e-02f, 6.97124796e-03f, -5.03882542e-02f, 1.13736123e-01f, 3.88057008e-02f, -8.71218964e-02f, 7.26064518e-02f,
  -3.56261358e-02f, 3.69081572e-02f, -7.99231827e-02f, 3.06962170e-02f, 6.79219216e-02f, -4.26643975e-02f, 1.71152726e-02f, -2.97614671e-02f, -4.62649465e-02f, -5.62094897e-02f,
  -8.09225962e-02f, 2.47392803e-02f, -6.62637874e-03f, 5.47853857e-02f, 4.90800776e-02f, -8.67593437e-02f, 2.85108797e-02f, -1.68504901e-02f, -1.66436955e-02f, -7.48976618e-02f,
  1.29903436e-01f, -2.69949466e-01f, -3.96376520e-01f, 5.06333681e-03f, 1.05353251e-01f, 1.72499657e-01f, -7.73216709e-02f, 1.05716728e-01f, -9.75357443e-02f, 7.24939629e-02f,
  1.22238971e-01f, -1.90485418e-01f, -1.82928100e-01f, -2.90063210e-02f, 4.01626416e-02f, -1.88939512e-01f, 1.28662959e-01f, 1.41255289e-01f, -1.30713852e-02f, 1.56137729e-02f,
  5.77810258e-02f, 2.14947164e-01f, -2.15370432e-01f, 2.10121915e-01f, 8.25409517e-02f, -1.28812373e-01f, 1.43947795e-01f, -6.50338456e-02f, 9.88288745e-02f, 1.05033368e-01f,
  5.55127226e-02f, -1.05242766e-01f, -5.50363795e-04f, 6.61328994e-03f, -5.94989350e-03f, 9.36515350e-03f, -5.93552813e-02f, -1.99598391e-02f, -6.60363361e-02f, 4.74856049e-02f,
  -8.95928070e-02f, -3.71344648e-02f, -4.11028154e-02f, 3.89995575e-02f, 1.62802003e-02f, -8.70900825e-02f, -2.69718375e-02f, -3.82321998e-02f, 4.93245423e-02f, -1.27769083e-01f,
  -1.80669561e-01f, -6.89546466e-02f, 3.24869379e-02f, -6.01488724e-02f, -8.04242939e-02f, -3.68409157e-02f, 6.15496486e-02f, -1.18575618e-01f, -4.57632504e-02f, 5.73886260e-02f,
  4.78074513e-02f, 9.98975039e-02f, 6.30104095e-02f, 5.25374375e-02f, 5.99938408e-02f, 4.17188928e-02f, 1.29653335e-01f, 6.29250705e-02f, 2.78197099e-02f, 3.29863317e-02f,
  2.32814625e-02f, 1.63567644e-02f, 8.49252641e-02f, 4.20195982e-02f, 1.04998238e-02f, -1.18161008e-01f, 7.80605152e-02f, 3.81943695e-02f, -7.92315304e-02f, -8.99565592e-02f,
  1.66858304e-02f, 2.43640728e-02f, -1.23848831e-02f, 4.68963906e-02f, -3.67771424e-02f, -2.80485414e-02f, 1.30591422e-01f, -4.23171930e-02f, 6.31681457e-03f, 1.45005854e-02f,
  1.80096515e-02f, -1.31169111e-01f, -2.91920435e-02f, -6.66035563e-02f, -1.13980256e-01f, 4.65782620e-02f, -4.00200374e-02f, -9.29768663e-03f, -7.54569620e-02f, 6.28962293e-02f,
  5.69883473e-02f, -4.09144238e-02f, 1.20695263e-01f, -4.41748276e-02f, 1.26512170e-01f, 5.11697382e-02f, -3.09639256e-02f, -1.46901691e-02f, 2.04142183e-02f, -1.16485665e-02f,
  -8.69594812e-02f, -7.31413960e-02f, 3.59762087e-02f, -3.14479619e-02f, -9.67528485e-03f, 2.91173719e-02f, -8.22681189e-02f, 1.01859666e-01f, 3.71934809e-02f, 4.17817496e-02f,
  -8.55416134e-02f, 6.36662915e-02f, 1.07872263e-01f, 1.80218682e-01f, -8.30490589e-02f, -2.51387417e-01f, -4.29379135e-01f, 1.20298728e-01f, -1.18385151e-01f, -2.37155899e-01f,
  -7.28113875e-02f, -1.55422548e-02f, 6.22622408e-02f, 8.84073973e-02f, 3.21464509e-01f, 1.84803419e-02f, 1.58185318e-01f, -5.90976514e-02f, 1.96147442e-01f, 1.28572464e-01f,
  1.95866019e-01f, 1.30523071e-01f, 3.99195552e-01f, 2.10795492e-01f, 1.90828413e-01f, 1.10201895e-01f, 3.04768950e-01f, 5.90494052e-02f, 1.19975388e-01f, -4.88226153e-02f,
  -8.99901763e-02f, -2.29234081e-02f, -3.83731946e-02f, -1.05875887e-01f, 1.05631679e-01f, -1.37212202e-01f, -7.21614361e-02f, -1.26452222e-01f, 1.28965043e-02f, -1.04030572e-01f,
  -4.88232225e-02f, 8.71601924e-02f, -5.63923158e-02f, 4.31782529e-02f, -3.31021249e-02f, 3.60067375e-02f, 9.26246792e-02f, -3.92268132e-03f, -7.19797835e-02f, 1.87699422e-02f,
  2.76744198e-02f, -1.13699948e-02f, 7.19736889e-02f, 2.51194965e-02f, 3.12367883e-02f, 7.09423497e-02f, -2.27055456e-02f, 3.65610942e-02f, 3.71379629e-02f, -2.41684616e-02f,
  -3.36892121e-02f, 6.51560053e-02f, -3.79813947e-02f, 1.02577507e-01f, -4.45040455e-03f, -2.66853869e-02f, -5.75432219e-02f, -1.35388291e-02f, 8.32171296e-04f, -2.78363656e-02f,
  2.27823015e-02f, -1.96917169e-02f, -6.88169897e-02f, -9.59114954e-02f, 1.37827278e-03f, 3.52981053e-02f, -1.16350979e-03f, 6.84502767e-03f, -4.92039286e-02f, -3.68831167e-03f,
  -3.41235548e-02f, -2.94199362e-02f, 3.54701490e-03f, 1.13691315e-02f, 1.58807772e-04f, 4.60022725e-02f, 1.64414458e-02f, 1.66867394e-03f, 6.21468872e-02f, 7.15451613e-02f,
  -7.86558241e-02f, 1.48948058e-01f, -5.68660833e-02f, -5.68223298e-02f, 1.66812301e-01f, 3.43832597e-02f, 2.29602885e-02f, -4.56409203e-03f, -2.20649540e-02f, 4.26543728e-02f,
  -4.17071171e-02f, -3.68106104e-02f, -5.90816028e-02f, -1.03492796e-01f, 2.74781920e-02f, 3.88605073e-02f, -4.41280715e-02f, 1.32895298e-02f, 1.67571455e-02f, 1.73362315e-01f,
  1.76184867e-02f, -2.38553453e-02f, 6.96657300e-02f, -5.64686814e-03f, -7.02942088e-02f, 1.11908431e-03f, 4.12675776e-02f, 1.86425857e-02f, 9.26307291e-02f, 1.39134526e-02f,
  2.30880499e-01f, -4.55075830e-01f, 1.55684933e-01f, 3.66130501e-01f, 1.43009767e-01f, -7.82021284e-02f, 6.12836108e-02f, -1.79021820e-01f, 4.98921387e-02f, -3.56479585e-01f,
  5.29005751e-02f, -4.55641076e-02f, -1.14056431e-01f, 4.09791321e-02f, 2.61988819e-01f, -8.26126114e-02f, -1.64495409e-02f, 3.72048430e-02f, 1.87655389e-02f, 8.90957341e-02f,
  1.92364797e-01f, 2.45076623e-02f, -7.64969885e-02f, -1.81197152e-01f, -7.80468434e-02f, -1.19882822e-02f, -8.45128968e-02f, 5.92083745e-02f, -3.28553133e-02f, 4.82816771e-02f,
  7.46737123e-02f, -8.00735578e-02f, 5.80239780e-02f, 4.05636057e-02f, -1.33264765e-01f, -2.33844239e-02f, 4.24801819e-02f, 1.57591011e-02f, 6.18663728e-02f, -7.08479732e-02f,
  1.89549606e-02f, 4.82161604e-02f, -1.29778897e-02f, 3.12129389e-02f, -1.16380760e-02f, 2.55905539e-02f, 5.80537245e-02f, -2.67277490e-02f, -4.23604883e-02f, 3.09861545e-02f,
  2.28938553e-02f, -1.75408050e-02f, 1.87613703e-02f, -1.12529169e-03f, 3.15207290e-03f, 4.32641618e-02f, -9.34029818e-02f, 2.15393677e-02f, -3.36490571e-02f, 5.45588136e-03f,
  -6.52420074e-02f, 2.51079760e-02f, -3.61072198e-02f, 5.56195416e-02f, 1.02845311e-01f, -4.85728085e-02f, 2.83320062e-02f, 9.16143972e-03f, 5.13304621e-02f, 2.84862760e-02f,
  1.40304836e-02f, -6.14366448e-03f, -1.60360485e-02f, 3.83806340e-02f, -2.73415763e-02f, -8.28841329e-02f, 4.12562266e-02f, 7.58580118e-02f, 1.78371612e-02f, -5.10496944e-02f,
  -8.49918090e-03f, 8.61135572e-02f, 3.44045907e-02f, -9.69309583e-02f, 5.53273894e-02f, -2.17780145e-03f, 7.79786031e-04f, 9.57048126e-03f, 5.24119064e-02f, 8.32493510e-03f,
  -4.51231934e-02f, -3.62548858e-01f, -6.17555082e-02f, 9.89454687e-02f, 3.27143967e-02f, -8.60788375e-02f, -6.72270581e-02f, -7.22661167e-02f, 7.82698840e-02f, -3.36992107e-02f,
  -6.03928566e-02f, 4.12548557e-02f, -1.04744390e-01f, 6.02877215e-02f, -4.24140804e-02f, -9.45420563e-02f, 2.54451670e-02f, -2.06763949e-02f, -5.62092774e-02f, 1.45914974e-02f,
  2.64472025e-03f, -3.92655134e-02f, 1.67985894e-02f, -5.56040704e-02f, -6.24620356e-02f, -9.35904607e-02f, -4.81895059e-02f, 1.69905424e-02f, -3.20959873e-02f, 2.83151455e-02f,
  -5.56438744e-01f, -4.36632428e-03f, -2.67249197e-01f, -2.20108941e-01f, -1.32665455e-01f, -1.97168529e-01f, -2.02047661e-01f, 8.93138126e-02f, -5.23422919e-02f, 7.86900967e-02f,
  9.46938153e-03f, -7.67620727e-02f, 4.86196540e-02f, -8.88744444e-02f, -2.29124576e-01f, 8.20708647e-02f, -2.27018163e-01f, -1.41512319e-01f, -7.58297648e-03f, -2.05296859e-01f,
  -1.88400567e-01f, -1.37479246e-01f, -1.76807046e-01f, -6.00912385e-02f, -1.73567072e-01f, -6.99993595e-02f, 4.49130461e-02f, -5.72968982e-02f, 2.05057971e-02f, -1.34970741e-02f,
  -1.97948545e-01f, -1.61315292e-01f, -4.77264971e-02f, -1.02866851e-01f, -1.13777526e-01f, 2.48375069e-02f, -7.25756660e-02f, -1.15048308e-02f, -1.39266038e-02f, -6.39086813e-02f,
  5.93840629e-02f, -7.38504231e-02f, -4.60742563e-02f, -2.25020247e-03f, -3.29907797e-03f, -2.02687383e-02f, 5.61794676e-02f, -3.19244452e-02f, 6.10024780e-02f, 3.09667606e-02f,
  -2.82923859e-02f, -1.12779476e-01f, -2.60795765e-02f, -3.88493724e-02f, 3.79546173e-02f, -4.92316522e-02f, 1.26112229e-03f, 5.57424352e-02f, -3.23122442e-02f, -1.09551877e-01f,
  -4.16246355e-02f, -3.79942507e-02f, 4.33917485e-05f, 1.70220267e-02f, 4.23800200e-02f, 1.32211801e-02f, 3.40451375e-02f, -5.45647293e-02f, -8.78973529e-02f, 4.44648694e-03f,
  -5.90654537e-02f, 4.90705743e-02f, -7.13873282e-02f, 5.74025959e-02f, -8.34350754e-03f, -2.58796588e-02f, 2.18459824e-03f, -9.39220935e-02f, 4.09353822e-02f, -2.05531400e-02f,
  1.86003577e-02f, 6.51347935e-02f, -1.53393310e-04f, -7.20825559e-03f, -6.66163415e-02f, 3.41782235e-02f, 7.89242089e-02f, 4.56424057e-03f, -5.82377873e-02f, -6.66574687e-02f,
  -3.46493602e-01f, -2.73274630e-01f, 5.79590015e-02f, -1.43402398e-01f, -3.64292189e-02f, -7.71871954e-02f, 5.45480568e-03f, -1.01978490e-02f, -3.25881615e-02f, -1.96271464e-02f,
  -3.02722845e-02f, 4.78029177e-02f, -5.78730833e-03f, 2.11233068e-02f, 1.32998573e-02f, 8.28329027e-02f, -8.97723436e-02f, 2.33370587e-02f, -1.45105273e-02f, -6.03509694e-02f,
  -7.71389604e-02f, -1.95246879e-02f, 2.74923705e-02f, 1.04661971e-01f, 1.00562386e-01f, -9.00262073e-02f, 3.91045352e-03f, 3.21139395e-02f, -1.04843816e-02f, 6.53532194e-03f,
  -4.50306296e-01f, -2.18170378e-02f, 2.25370437e-01f, -2.29138419e-01f, -1.69633880e-01f, 3.99372838e-02f, 2.10470036e-01f, -1.56102151e-01f, -2.47369155e-01f, -1.78014450e-02f,
  -3.10302842e-02f, 9.67568066e-03f, 1.87617198e-01f, 1.05470642e-01f, 2.54182607e-01f, 2.44215593e-01f, -1.88294332e-02f, -3.52668725e-02f, -5.98955825e-02f, -2.08903551e-01f,
  -1.14108309e-01f, -4.56557311e-02f, 2.98589617e-01f, -1.42562464e-01f, -4.66185175e-02f, -1.47509620e-01f, 1.33749591e-02f, 1.08484298e-01f, -5.31045273e-02f, 8.28269646e-02f,
  -1.18782602e-01f, -3.06828707e-01f, -2.45936289e-02f, -4.43514138e-02f, -4.59795222e-02f, -4.06860519e-04f, 6.83929250e-02f, 1.15951873e-01f, -1.05313800e-01f, -4.91441377e-02f,
  6.14862423e-03f, -1.02760475e-02f, -1.26673192e-01f, -9.70402956e-02f, -1.78141207e-01f, -7.65440166e-02f, 3.59657891e-02f, -2.90805586e-02f, 2.04140805e-02f, 6.34405762e-02f,
  1.19632304e-01f, 1.04941893e-02f, -3.29895169e-02f, 5.62262209e-03f, 5.73881008e-02f, -7.74424225e-02f, 3.03394701e-02f, 1.08953997e-01f, 1.80599317e-02f, -4.47342694e-02f,
  4.11746800e-02f, -1.62530073e-03f, 4.21766788e-02f, 2.80779526e-02f, 3.25841084e-02f, -2.89157610e-02f, -1.00416718e-02f, 2.96440497e-02f, 1.18934829e-02f, 5.11752144e-02f,
  -8.10819492e-03f, -3.46175320e-02f, 3.42151895e-03f, -9.95936105e-04f, 1.91979501e-02f, -1.18719470e-02f, 3.89393196e-02f, 1.87263228e-02f, 5.43359027e-04f, -4.00090404e-02f,
  -3.65797803e-02f, 4.73158993e-02f, 5.27815484e-02f, -3.19041684e-02f, -5.44845313e-02f, 6.07311986e-02f, -4.45521437e-02f, 7.95281008e-02f, -4.50782701e-02f, 1.49776053e-03f,
  -3.78721058e-01f, -4.06131208e-01f, -7.01005682e-02f, -5.86046875e-02f, -1.37908704e-04f, -7.76111558e-02f, -4.50298525e-02f, -2.44606491e-02f, -9.41758230e-02f, 4.99710348e-03f,
  -5.95098697e-02f, -8.78487527e-03f, 1.95181128e-02f, 3.24737430e-02f, 9.37792808e-02f, 4.38999236e-02f, -5.92942424e-02f, -1.50491953e-01f, -5.97323067e-02f, -2.39875377e-03f,
  3.73697169e-02f, 1.77377593e-02f, 5.16518280e-02f, -2.10129209e-02f, -8.19712654e-02f, -1.61155425e-02f, -1.49806023e-01f, -5.67751266e-02f, -5.07755280e-02f, 4.76523954e-03f,
  4.78357673e-02f, -1.96261555e-01f, -2.85664946e-01f, -3.09152722e-01f, -1.94054376e-02f, -2.54361451e-01f, -3.57918143e-01f, -1.51861429e-01f, -2.31745362e-01f, -1.91131786e-01f,
  -2.06219167e-01f, -7.06077293e-02f, 9.71562788e-02f, -3.07461470e-01f, 1.79070756e-01f, 1.22769244e-01f, -2.33479872e-01f, -1.71363100e-01f, -7.41867721e-03f, -1.35390908e-01f,
  1.21964738e-01f, -2.32530072e-01f, 9.80305136e-04f, -1.13982365e-01f, -1.19905226e-01f, -1.23837881e-01f, -1.86088551e-02f, -6.05505407e-02f, -2.26597935e-01f, -7.07036704e-02f,
  -3.17500113e-03f, -1.70630459e-02f, -5.71094453e-02f, 3.44537534e-02f, -1.23414665e-01f, -5.50427809e-02f, -6.71103075e-02f, -2.36746413e-03f, 2.21151765e-02f, 6.67625517e-02f,
  2.69859470e-02f, 3.08168773e-02f, -5.46056964e-02f, 1.13741912e-01f, -1.39856059e-02f, -8.36362913e-02f, 8.94964039e-02f, -1.02088163e-02f, -4.43891846e-02f, 7.50762224e-03f,
  -5.75369820e-02f, -1.18303986e-03f, -9.36194044e-03f, 2.75869519e-02f, -5.05824983e-02f, -1.27743229e-01f, -3.62236872e-02f, 3.92601527e-02f, -5.03308214e-02f, 8.03415291e-03f,
  -4.98301983e-02f, 4.16286513e-02f, -2.23214962e-02f, -5.78406751e-02f, -5.35934418e-02f, -6.90738186e-02f, -1.67788169e-03f, 3.82415354e-02f, -6.18917681e-02f, 5.58381304e-02f,
  3.34885940e-02f, 3.86583656e-02f, -2.61504911e-02f, -1.06544040e-01f, -3.68776056e-03f, 3.41115370e-02f, 3.06060724e-02f, 1.05101824e-01f, -5.52421948e-03f, 2.73896568e-02f,
  6.84866309e-02f, 5.50113767e-02f, -1.94419490e-03f, 3.24325413e-02f, 6.22454332e-03f, 3.94577794e-02f, -7.02923834e-02f, -5.93110733e-02f, 4.81627835e-03f, 4.80758697e-02f,
  -4.58044261e-02f, -2.38608181e-01f, -4.25760075e-02f, -9.67680365e-02f, 3.82361002e-02f, -2.70351861e-03f, 1.42623121e-02f, -7.36427829e-02f, -1.26071155e-01f, 9.17070266e-03f,
  -7.50860125e-02f, -3.62048671e-03f, 9.56520811e-03f, -1.01129249e-01f, 8.07155669e-03f, -1.20728627e-01f, -1.37757380e-02f, 2.47330721e-02f, -7.09976256e-02f, -1.18238516e-01f,
  -5.25216293e-03f, 1.02617532e-01f, 1.61740778e-03f, 1.15061942e-02f, 4.45889570e-02f, -1.14652151e-02f, 3.76736857e-02f, -1.50535768e-02f, -4.87585738e-02f, 4.20404598e-02f,
  -5.09452708e-02f, -4.74695005e-02f, -3.75376463e-01f, -7.77696371e-02f, 1.40101954e-01f, 9.87105910e-03f, -2.18951061e-01f, -1.68045573e-02f, -2.25849152e-01f, 1.60608172e-01f,
  7.84042031e-02f, -1.35464698e-01f, -1.61321491e-01f, -1.23027705e-01f, -2.44779006e-01f, -2.53744781e-01f, -2.15538181e-02f, -1.20368011e-01f, -3.98020558e-02f, 4.50547040e-02f,
  -1.18170224e-01f, 8.53622183e-02f, -2.27774993e-01f, 3.10076386e-01f, 4.94740009e-02f, 4.00177911e-02f, 2.44513735e-01f, 1.62121162e-01f, 1.45843029e-01f, 8.52684304e-02f,
  1.95936207e-02f, -1.16493143e-01f, -9.88795087e-02f, -3.54939816e-03f, 4.67382409e-02f, 2.78972238e-02f, 9.88300964e-02f, 9.83549096e-03f, 5.44860996e-02f, -6.82017058e-02f,
  -3.52453586e-04f, -3.43631878e-02f, 9.18225497e-02f, -1.35737777e-01f, 9.77352262e-02f, 3.65990922e-02f, -7.86728486e-02f, -7.24423453e-02f, -1.44767240e-01f, -6.29115030e-02f,
  -7.83200264e-02f, -3.92485522e-02f, 5.42322956e-02f, 3.49765234e-02f, -6.21541683e-03f, -8.11188743e-02f, 1.17823947e-02f, 1.96552593e-02f, 8.96366984e-02f, -5.97985415e-03f,
  7.47325644e-02f, 1.20979689e-01f, -1.14080012e-01f, -1.76719241e-02f, -7.41185620e-02f, -2.57695150e-02f, -1.31598031e-02f, 1.20533826e-02f, -1.02454431e-01f, -3.19640036e-03f,
  -1.69132445e-02f, -7.89390728e-02f, 5.01986034e-03f, -5.45304501e-03f, -1.10903298e-02f, 4.24895994e-02f, 5.69001958e-02f, -4.47330028e-02f, 3.13066803e-02f, -1.24664016e-01f,
  5.42734936e-02f, 2.58558500e-03f, -6.23309240e-02f, 7.25755394e-02f, 4.53880094e-02f, -1.22879744e-02f, -4.59890394e-03f, 1.46301452e-03f, -1.14066573e-02f, 5.63214533e-02f,
  8.71161968e-02f, 7.87172001e-03f, -8.81780908e-02f, 9.87431929e-02f, -2.35910043e-02f, 4.89507429e-02f, 8.59114006e-02f, 3.02574299e-02f, -3.07264421e-02f, -1.95571873e-02f,
  5.51142246e-02f, 9.06254724e-03f, 9.40983593e-02f, 9.57192481e-02f, -2.92140357e-02f, 2.49599144e-02f, 4.22813818e-02f, 5.66499354e-03f, -2.49779467e-02f, -1.72653385e-02f,
  1.16513528e-01f, 9.21257585e-02f, 1.49362236e-02f, 1.04144432e-01f, 8.48446041e-02f, 4.23652716e-02f, -1.32297352e-02f, 5.43841310e-02f, 3.91631341e-03f, -8.79948735e-02f,
  -6.08312964e-01f, 1.18868969e-01f, -1.62113458e-01f, 2.55706199e-02f, -2.25658730e-01f, -2.28170544e-01f, -7.41432384e-02f, -1.12229459e-01f, -7.43359402e-02f, 1.62609830e-01f,
  1.19317703e-01f, -1.81149751e-01f, 2.06861392e-01f, 2.08445340e-01f, -2.93157399e-01f, 1.32082373e-01f, 4.11270820e-02f, -4.21022903e-03f, -6.55538067e-02f, -1.65462837e-01f,
  -1.04183003e-01f, 1.22664338e-02f, 7.80891106e-02f, 1.10787332e-01f, -1.84113011e-02f, -9.43579152e-02f, -1.70122143e-02f, -9.87560749e-02f, -4.25011329e-02f, 5.51592559e-03f,
  -2.00294062e-01f, -4.17665206e-02f, -4.58423682e-02f, -3.08220461e-02f, -6.68371469e-02f, -1.01819485e-01f, 2.47047842e-03f, -4.79562348e-03f, -1.95043813e-02f, -1.08604960e-01f,
  -8.03884491e-02f, 6.95219859e-02f, 2.79621799e-02f, -3.06031872e-02f, 2.90492717e-02f, -8.46028794e-03f, -2.22581010e-02f, 5.38020469e-02f, 3.96362655e-02f, -1.96247883e-02f,
  2.68489122e-02f, -2.29854882e-02f, 6.24799095e-02f, 7.86757916e-02f, -4.37359624e-02f, -2.61914171e-02f, -1.97798498e-02f, -3.24107893e-02f, -6.00908361e-02f, 1.37286009e-02f,
  8.50814953e-02f, 1.31845102e-02f, 3.47092785e-02f, 6.97801858e-02f, 3.89609449e-02f, -1.14251655e-02f, -4.41264324e-02f, 4.84547503e-02f, 4.03689733e-03f, -9.17448662e-03f,
  1.82284825e-02f, -5.18454090e-02f, 2.20349617e-03f, 5.09920623e-03f, -2.23400556e-02f, 8.63173604e-02f, -2.90700682e-02f, 4.85358275e-02f, 4.77914289e-02f, -2.07794085e-02f,
  -2.86245893e-04f, -1.06509402e-01f, 7.20607787e-02f, 1.26535427e-02f, -2.49125734e-02f, -7.30831316e-03f, 4.09196392e-02f, 7.05774734e-03f, 5.64789586e-02f, -8.00654143e-02f,
  -2.17566147e-01f, -2.02501312e-01f, 1.22440169e-02f, 4.96410318e-02f, 1.10990889e-01f, -3.15475166e-02f, 3.36852744e-02f, -1.69484571e-01f, -3.15229259e-02f, 1.87307801e-02f,
  -6.26620874e-02f, -2.25666538e-02f, -8.89819190e-02f, 4.14191606e-03f, -6.74753189e-02f, 9.29911621e-03f, 3.54748443e-02f, -1.43742964e-01f, -5.23187034e-02f, -1.85609702e-02f,
  6.13536835e-02f, 5.33899665e-02f, -2.33325083e-02f, -4.30965014e-02f, -3.79262529e-02f, 3.57147902e-02f, -5.40741943e-02f, -7.81886932e-03f, -9.92160589e-02f, 2.24805847e-02f,
  -1.74232051e-01f, -3.04516137e-01f, -1.04272828e-01f, -9.45555270e-02f, 2.04752550e-01f, 7.56266266e-02f, 4.70982492e-02f, -1.30085647e-01f, -2.09432960e-01f, -1.20260380e-01f,
  -8.64643678e-02f, -1.60899207e-01f, -1.36368588e-01f, -3.94038320e-01f, -8.04497451e-02f, -3.18939865e-01f, -2.23654374e-01f, -1.44675687e-01f, -1.32378921e-01f, -2.49676183e-02f,
  -2.37572528e-02f, -1.38159305e-01f, -5.53634129e-02f, 1.38167605e-01f, 1.60925183e-02f, 1.96186587e-01f, 1.82457417e-01f, 1.43382818e-01f, 2.12992132e-02f, -1.14779495e-01f,
  -7.87561163e-02f, -1.60316646e-01f, -5.91076910e-02f, -3.44383232e-02f, 9.89020839e-02f, 8.66289809e-03f, 6.32958412e-02f, -3.48865725e-02f, -7.82899186e-02f, -1.72823053e-02f,
  7.58860086e-04f, -3.53086852e-02f, -1.16523504e-01f, 1.00813292e-01f, 4.08272669e-02f, -3.58014926e-02f, -1.01637192e-01f, -4.45988290e-02f, -8.35589916e-02f, 5.21088671e-03f,
  -7.96026364e-02f, 1.13238012e-02f, 2.56036222e-02f, -1.17544726e-01f, 8.21917597e-03f, 4.66911085e-02f, 4.66782115e-02f, 1.31930009e-01f, -5.53182978e-03f, 4.64606136e-02f,
  4.06330116e-02f, 2.80332491e-02f, -9.99600347e-03f, -7.27532953e-02f, -5.23958430e-02f, -6.32084087e-02f, -4.95761745e-02f, 4.20587836e-03f, -3.66959423e-02f, 8.92603472e-02f,
  3.18407193e-02f, 3.57715376e-02f, -4.59634066e-02f, 4.36175279e-02f, 1.77810099e-02f, -3.50277424e-02f, 3.88835892e-02f, 2.34896950e-02f, 8.63906071e-02f, 7.61958957e-02f,
  -9.17344019e-02f, -2.86288820e-02f, 9.04338509e-02f, -1.89459044e-02f, -7.73113295e-02f, 1.20626673e-01f, 8.52329582e-02f, -9.77041423e-02f, 5.46979457e-02f, 9.81771052e-02f,
  3.91417742e-02f, 1.09210558e-01f, -4.87972563e-03f, -2.41608825e-02f, -2.05798894e-02f, 6.36254549e-02f, -6.44207373e-02f, -7.32094273e-02f, 2.00227108e-02f, -8.47552344e-02f,
  1.91011369e-01f, 3.81422564e-02f, 1.16360523e-01f, -9.38481316e-02f, 1.28617343e-02f, -1.00789443e-02f, 5.33039160e-02f, 6.12470284e-02f, 9.54852179e-02f, 8.39119330e-02f,
  1.24228731e-01f, 1.07908159e-01f, -1.93081740e-02f, 7.97151998e-02f, 4.48729731e-02f, 6.93558455e-02f, 7.87457898e-02f, 7.96534196e-02f, 4.74485382e-02f, -2.76712961e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.07583523e-01f, 2.04389587e-01f, 2.07403228e-01f, 1.47911862e-01f, -2.31983215e-02f, 8.38354453e-02f, -1.46865575e-02f, -1.23710096e-01f, 7.18853474e-02f, 3.66985463e-02f,
  -7.02054054e-02f, 1.31317630e-01f, -9.04752389e-02f, -4.38429266e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.10888138e-01f, 7.78345168e-02f, 9.10658985e-02f, -2.80532986e-01f, 1.18496850e-01f, -9.35865268e-02f, 1.95245091e-02f, -1.73137903e-01f, -2.50990957e-01f, 2.07308307e-01f,
  7.01110810e-02f, -5.07257655e-02f, -4.51971069e-02f, 1.32540047e-01f, 1.07559621e-01f, 3.19160759e-01f, 3.36076647e-01f, -2.73142129e-01f, -5.48104942e-02f, 6.17571846e-02f,
  -3.88060883e-02f, 1.71755075e-01f, 1.95362121e-01f, 8.76072645e-02f, 2.21570041e-02f, 1.30076140e-01f, -6.23500235e-02f, -2.46504411e-01f, -2.77240217e-01f, 2.47647092e-01f,
  -3.01805466e-01f, 3.37047249e-01f, 1.13429323e-01f, -2.28431057e-02f, 2.69473821e-01f, 1.29634455e-01f, 7.69727081e-02f, 2.00759456e-01f, 5.63611761e-02f, -1.27106592e-01f,
  1.92559958e-01f, -1.42925665e-01f, -2.20118508e-01f, 1.95119634e-01f, -2.69660294e-01f, 2.14112222e-01f, 3.25813703e-02f, -9.27506983e-02f, 1.42102182e-01f, 3.90343845e-01f,
  4.28974517e-02f, -1.07875027e-01f, 1.17518492e-01f, 8.27000588e-02f, -8.12685583e-03f, 2.40628734e-01f, -2.13789433e-01f, 1.17937192e-01f, -1.42988741e-01f, 2.23150477e-02f,
  -2.02851832e-01f, 8.70879143e-02f, 1.73331842e-01f, 8.28538388e-02f, -6.84733838e-02f, -8.41130167e-02f, 9.40109789e-02f, -3.48692499e-02f, 8.11859220e-02f, 1.21053465e-01f,
  -1.65707409e-01f, -1.40738726e-01f, -2.03854710e-01f, -2.90612310e-01f, -1.16763897e-01f, 8.44155774e-02f, -2.29002088e-01f, 4.60358709e-02f, -2.22875431e-01f, 5.01670614e-02f,
  3.15678455e-02f, 6.00196496e-02f, 1.14772223e-01f, 4.72820327e-02f, 2.77847320e-01f, 5.24864122e-02f, 2.90594578e-01f, 1.40641734e-01f, 7.38650858e-02f, 1.67684808e-01f,
  -4.01796281e-01f, -2.45570555e-01f, -1.09370016e-01f, 6.89740926e-02f, -2.79778004e-01f, -7.71538019e-02f, 2.53273379e-02f, 2.08849803e-01f, -1.07283089e-02f, -1.39714777e-01f,
  1.89425781e-01f, -9.48133841e-02f, -1.05262980e-01f, -2.86261495e-02f, 2.24924356e-01f, 7.44212940e-02f, 1.48730472e-01f, 5.93203455e-02f, 2.41124243e-01f, -1.82774141e-01f,
  -8.52869544e-03f, -3.07305902e-01f, 2.89871655e-02f, 4.10966814e-01f, -2.07185626e-01f, -1.99462026e-01f, -1.79351971e-01f, -7.49553591e-02f, 1.22263208e-01f, -2.13780716e-01f,
  -1.53514341e-01f, -1.06080703e-01f, 2.46006578e-01f, -1.64235413e-01f, -2.23146543e-01f, 1.17247425e-01f, 4.68470305e-01f, 3.00726533e-01f, 2.60488540e-01f, 8.58579427e-02f,
  -1.23687789e-01f, -1.04015268e-01f, 1.39219001e-01f, -2.34953478e-01f, 1.13674670e-01f, -7.72615746e-02f, 1.71711385e-01f, -6.59470409e-02f, 2.29544938e-01f, 3.56079876e-01f,
  -5.26337773e-02f, -2.96457916e-01f, -5.33227801e-01f, 8.36253092e-02f, -1.46106392e-01f, 4.38329101e-01f, 1.53693959e-01f, 1.73441291e-01f, 2.93059826e-01f, 2.13851053e-02f,
  3.04148316e-01f, -2.63450056e-01f, 7.61623532e-02f, -3.24968472e-02f, -3.69952440e-01f, 1.30969156e-02f, 2.20461130e-01f, -3.58594120e-01f, -1.53004378e-01f, -9.48263258e-02f,
  1.21758379e-01f, 1.85458679e-02f, -2.90814698e-01f, -7.92025328e-02f, -1.64175525e-01f, -4.65174131e-02f, -2.04882190e-01f, 1.59898117e-01f, 2.04529986e-01f, -9.46540907e-02f,
  2.01348618e-01f, -7.18203336e-02f, 2.37425014e-01f, -4.87777740e-02f, -7.94755369e-02f, -3.35362971e-01f, -1.64349303e-01f, -3.63702893e-01f, 1.32024035e-01f, 1.67367049e-02f,
  -1.48745522e-01f, 1.20151848e-01f, -2.58530051e-01f, -1.35910809e-01f, 3.11740428e-01f, -5.86279221e-02f, 1.96253330e-01f, 4.68742758e-01f, 2.96442240e-01f, -1.35569498e-01f,
  -3.68154384e-02f, -1.65864930e-01f, -2.28712499e-01f, -5.52399643e-02f, 1.48170710e-01f, 3.61058824e-02f, -2.05988735e-01f, 2.11032256e-01f, -3.77656817e-02f, -1.27401799e-01f,
  -2.73002356e-01f, -2.66091108e-01f, -2.83379674e-01f, 1.64438725e-01f, -3.73576105e-01f, 2.51557767e-01f, 3.04131031e-01f, 1.51327541e-02f, 1.88362539e-01f, -2.22318962e-01f,
  1.84440270e-01f, -1.16449893e-01f, 3.19242895e-01f, 7.15032145e-02f, -1.53233215e-01f, 6.19652756e-02f, 1.46022379e-01f, 5.60399564e-03f, -1.64219603e-01f, -2.00209409e-01f,
  -4.55309808e-01f, 1.37473762e-01f, -3.15933198e-01f, -3.35913211e-01f, -2.41412044e-01f, 5.46371713e-02f, 2.36570939e-01f, 1.16525508e-01f, 7.71787297e-03f, 9.66284275e-02f,
  1.57705247e-01f, -2.12922841e-01f, -2.11383507e-01f, 1.45734427e-02f, -9.72696766e-02f, -6.82967082e-02f, 6.30054921e-02f, 1.13175862e-01f, 2.34469950e-01f, 3.75277072e-01f,
  1.71380699e-01f, -1.68732449e-01f, 6.99801221e-02f, 5.18958904e-02f, -2.84494665e-02f, 1.01266680e-02f, 1.91983625e-01f, 5.53295948e-02f, 1.64848790e-01f, 5.18610515e-02f,
  -2.24210396e-01f, -3.55062336e-01f, -2.18344644e-01f, 5.92489801e-02f, -3.06881875e-01f, -5.85243367e-02f, 8.11630636e-02f, -1.27456576e-01f, 1.11736253e-01f, 1.89052135e-01f,
  1.16959989e-01f, 1.36933640e-01f, -1.69118091e-01f, 6.57742396e-02f, 7.10303485e-02f, 1.63834363e-01f, -9.79019552e-02f, -3.76912683e-01f, -1.61836684e-01f, 1.30197406e-01f,
  -2.26320475e-02f, -7.09808394e-02f, 1.34588242e-01f, -3.05202425e-01f, -3.40409274e-03f, -2.06662133e-01f, -3.28896672e-01f, 3.19250345e-01f, 4.82862331e-02f, 1.13427781e-01f,
  1.40594155e-01f, 1.73043907e-01f, 1.11702383e-01f, 2.58905351e-01f, 4.62728515e-02f, 2.47463763e-01f, 3.46484900e-01f, 2.28723913e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.02442182e-02f, 1.36400864e-01f, 2.76381701e-01f, -4.76462916e-02f, -1.34626657e-01f, 2.49818861e-01f, 3.09034318e-01f, 7.37358406e-02f, -1.66471109e-01f, -2.52796620e-01f,
  -8.69510844e-02f, 1.18762538e-01f, -3.56976718e-01f, -2.62890961e-02f, 2.62080401e-01f, 2.65651137e-01f, 1.01486422e-01f, -1.09004408e-01f, 3.38052452e-01f, 8.57357010e-02f,
  3.41884911e-01f, -1.88484088e-01f, -1.13415495e-01f, 1.29120186e-01f, 3.01644951e-01f, 1.26369819e-01f, -3.67550373e-01f, -1.18736900e-01f, -1.84938893e-01f, 1.11618355e-01f,
  -2.81806290e-01f, -4.64628369e-01f, 3.17687958e-01f, 1.89066097e-01f, 1.93727881e-01f, 3.54897417e-02f, 7.46177733e-02f, -1.10036373e-01f, 1.97310820e-01f, 6.21764138e-02f,
  -1.01994276e-02f, 3.44132841e-01f, 3.30729514e-01f, -7.15637505e-02f, -7.93195665e-02f, -5.40608525e-01f, -3.32308076e-02f, 3.40863280e-02f, -1.19721070e-02f, -2.37926319e-01f,
  2.68092871e-01f, 4.36760008e-01f, 4.24544126e-01f, 1.05437726e-01f, -7.50537543e-03f, -3.63003731e-01f, 1.49998397e-01f, -4.47108895e-01f, 1.14226647e-01f, 5.16366176e-02f,
  2.65654951e-01f, -2.32316434e-01f, -1.78965107e-01f, 8.42193048e-03f, -3.46422405e-03f, 1.63022950e-01f, 5.21936342e-02f, 3.47758293e-01f, 2.16237366e-01f, 1.28141284e-01f,
  9.49364379e-02f, 2.57660091e-01f, 7.06076324e-02f, 1.67813510e-01f, -6.29365398e-03f, 7.12834373e-02f, 3.82226184e-02f, -1.40785560e-01f, 1.53142765e-01f, 5.95348850e-02f,
  -4.25865710e-01f, -1.64023429e-01f, 1.48844823e-01f, 4.02265102e-01f, 2.36193240e-01f, -2.71136791e-01f, -1.02856591e-01f, -5.42601421e-02f, 1.84852406e-01f, -2.99659461e-01f,
  2.83854336e-01f, -6.35161102e-02f, 1.66565105e-01f, -8.02968666e-02f, 2.99528658e-01f, -2.63724566e-01f, 8.82424936e-02f, 2.30371147e-01f, 3.06550831e-01f, 1.88373759e-01f,
  1.16613783e-01f, 2.71576822e-01f, -5.13462238e-02f, 2.14201376e-01f, 1.18357964e-01f, -1.95896253e-01f, -1.33302510e-01f, -2.55174547e-01f, 5.63115887e-02f, 2.52398819e-01f,
  -2.27938324e-01f, 1.82874024e-01f, 2.62911409e-01f, -1.71968818e-01f, -1.53337851e-01f, -7.15902597e-02f, -7.89426044e-02f, 5.55655360e-01f, 7.78983012e-02f, 4.35187280e-01f,
  -2.97182113e-01f, 6.14019930e-01f, 1.10735251e-02f, 2.74719059e-01f, 1.69269413e-01f, 2.48766601e-01f, -5.16055077e-02f, 5.05009651e-01f, 4.00129169e-01f, 1.00443907e-01f,
  1.81369945e-01f, 1.30215377e-01f, 4.66271937e-01f, 2.37113535e-01f, 2.09305242e-01f, 1.59436971e-01f, 1.54072031e-01f, -3.16929996e-01f, 1.64272282e-02f, -1.21924216e-02f,
  -1.02040939e-01f, 8.60170648e-02f, -1.76714242e-01f, -9.42074060e-02f, 1.71613246e-01f, 3.51535052e-01f, 5.02261892e-02f, 4.67928052e-02f, 2.68362075e-01f, 2.22018123e-01f,
  6.32142961e-01f, -4.34416533e-02f, -1.59644544e-01f, 2.56191462e-01f, -7.59499297e-02f, 3.31717134e-01f, -7.16264248e-02f, 7.73066580e-02f, 1.24282539e-01f, 5.28393626e-01f,
  -4.51517887e-02f, 5.18466607e-02f, 1.46146700e-01f, 1.41638532e-01f, 2.39016116e-02f, 5.91554940e-02f, 3.54626216e-02f, 3.27806652e-01f, 4.55351807e-02f, 3.67505819e-01f,
  2.72547573e-01f, -2.46605515e-01f, 2.09074780e-01f, -2.43303642e-01f, 2.20629439e-01f, 9.26210284e-02f, -1.10408083e-01f, -3.94605190e-01f, 2.66346216e-01f, 1.79001674e-01f,
  2.02268474e-02f, -4.00381954e-03f, -1.58139184e-01f, 7.19953775e-02f, 3.23809266e-01f, -1.58151761e-01f, 2.71367908e-01f, 4.00883257e-02f, 3.88891429e-01f, 1.04206074e-02f,
  3.40379596e-01f, 1.41144395e-01f, 3.35562155e-02f, -1.35807842e-01f, -2.00546339e-01f, 4.57716081e-03f, -1.82740111e-02f, -1.50744274e-01f, 1.96391717e-01f, 1.10119268e-01f,
  2.89033562e-01f, 2.23688588e-01f, 3.46309572e-01f, -2.62874991e-01f, 1.03010960e-01f, -1.12508222e-01f, -2.53222108e-01f, -2.06448227e-01f, -7.56107941e-02f, -2.51158118e-01f,
  1.33966938e-01f, 1.44255534e-01f, 2.31374390e-02f, 2.25493520e-01f, -2.87502080e-01f, -2.31553391e-01f, 1.37888104e-01f, 2.48370804e-02f, 3.66431832e-01f, 4.69616473e-01f,
  2.93229043e-01f, -2.84322649e-01f, 2.05072671e-01f, -1.19393915e-01f, -1.56943962e-01f, 4.50013801e-02f, 2.45246604e-01f, 1.22114003e-01f, -3.22887391e-01f, 5.93246929e-02f,
  1.99463084e-01f, 2.12323114e-01f, 3.97277474e-02f, 5.03617860e-02f, -4.14317310e-01f, -7.31798410e-02f, -1.87115386e-01f, 2.12469533e-01f, 4.71197873e-01f, 8.75219181e-02f,
  2.13006616e-01f, -1.52496606e-01f, 2.38129258e-01f, 4.57177669e-01f, 2.97523648e-01f, -2.36996248e-01f, -2.87738889e-01f, 5.34446120e-01f, 1.16741136e-01f, -7.62002990e-02f,
  5.39245494e-02f, -3.77542734e-01f, 3.03842664e-01f, 4.61116642e-01f, 2.78304722e-02f, -1.91675961e-01f, -9.24869329e-02f, 5.96729182e-02f, 5.95385209e-02f, 3.62763733e-01f,
  4.95595625e-03f, 9.95154232e-02f, 2.81879574e-01f, 1.66353613e-01f, 2.39814281e-01f, 5.58419004e-02f, 2.31467579e-02f, 3.11443299e-01f, 1.27250120e-01f, 9.44640338e-02f,
  1.25504971e-01f, 7.73219799e-04f, -2.78492302e-01f, 2.72150189e-01f, 5.75184301e-02f, 2.99923122e-01f, 5.79101205e-01f, -4.44328606e-01f, 4.54970226e-02f, 4.65135425e-02f,
  3.29862125e-02f, -2.69680470e-01f, 7.05581233e-02f, 5.85490987e-02f, 3.18547100e-01f, 2.36964092e-01f, 2.11806998e-01f, -2.90936321e-01f, -5.77903399e-03f, -2.10685492e-01f,
  -1.16601326e-02f, -6.15181327e-02f, -1.06758274e-01f, -1.46731809e-01f, 3.16767916e-02f, 1.12408303e-01f, 1.90161288e-01f, 2.82430708e-01f, 1.34399101e-01f, -1.29035786e-01f,
  6.45377859e-02f, -2.94344127e-01f, -9.09738317e-02f, -9.65634640e-03f, -3.27763557e-01f, -3.34530860e-01f, 1.16940804e-01f, 3.59043002e-01f, -1.88564677e-02f, 1.25307506e-02f,
  -1.24834783e-01f, 8.38549286e-02f, 4.10663217e-01f, -3.43571186e-01f, 3.34304482e-01f, 1.75585613e-01f, 1.44856334e-01f, 6.80828094e-02f, 2.35482290e-01f, -3.04039508e-01f,
  3.03911567e-01f, -3.18137705e-02f, -6.42814711e-02f, 1.17430061e-01f, 9.32146236e-02f, 1.11717395e-01f, 1.02517620e-01f, 4.13773209e-02f, 1.37225345e-01f, -1.09816439e-01f,
  -4.38553803e-02f, 3.72122973e-01f, 1.26990676e-01f, -1.09367870e-01f, 6.05405606e-02f, 3.12128365e-02f, 1.09419063e-01f, 2.96563283e-02f, 3.21858078e-01f, 3.37140799e-01f,
  2.65918046e-01f, -3.70591044e-01f, 1.37123287e-01f, -4.22213301e-02f, 3.51086020e-01f, -3.77017140e-01f, 2.09354624e-01f, -3.59630212e-02f, 3.78912091e-01f, -1.23046622e-01f,
  -2.09416285e-01f, -2.84098059e-01f, 1.08337164e-01f, 1.93711579e-01f, -4.83368727e-04f, -6.17396608e-02f, 1.71683535e-01f, -9.27966163e-02f, -1.11687994e-02f, -1.35877699e-01f,
  -1.98283553e-01f, 6.00808077e-02f, 4.72559556e-02f, 3.02885030e-03f, -1.36577398e-01f, -2.92642802e-01f, 6.77210167e-02f, 2.03882739e-01f, 9.71400663e-02f, -5.88303387e-01f,
  1.79205596e-01f, -4.89468165e-02f, -2.66448051e-01f, 1.85794070e-01f, -1.30364344e-01f, -1.81371659e-01f, 5.65984786e-01f, -8.77814591e-02f, -7.81430379e-02f, 1.93544596e-01f,
  3.11668999e-02f, 2.99763400e-02f, -8.21932182e-02f, -1.12946607e-01f, 1.35908246e-01f, 2.61878639e-01f, 1.09596528e-01f, -2.99046673e-02f, 4.50713262e-02f, 1.10774882e-01f,
  1.58558846e-01f, 1.48369625e-01f, 2.42314398e-01f, -4.27155703e-01f, 3.00387055e-01f, 2.26157397e-01f, -1.26819930e-03f, -2.25271404e-01f, -6.10325575e-01f, -3.43623459e-01f,
  -3.72341275e-02f, 8.39267969e-02f, -1.89761594e-01f, -3.11824024e-01f, -3.09007224e-02f, 3.52736324e-01f, 1.86948493e-01f, -2.56641120e-01f, 4.36868221e-02f, 8.63286033e-02f,
  -2.76562423e-02f, 5.18558979e-01f, -1.22818172e-01f, -4.46579754e-01f, 3.14363003e-01f, -8.99121910e-03f, 3.31203729e-01f, 2.79495686e-01f, 1.60684943e-01f, -4.16599959e-02f,
  2.65275240e-01f, 2.20821694e-01f, 1.62740096e-01f, -6.01647794e-02f, 4.40568775e-02f, 3.75207849e-02f, 7.63773322e-02f, 1.85642261e-02f, -2.53560748e-02f, -3.86840671e-01f,
  -4.50180650e-01f, 3.04692239e-01f, 2.17752412e-01f, 7.28391111e-02f, 3.26714188e-01f, 1.80023834e-01f, 1.92798555e-01f, 3.99836063e-01f, 2.67464489e-01f, 3.93658839e-02f,
  3.96784961e-01f, 2.70863801e-01f, -2.14213565e-01f, 7.51856714e-02f, -5.34416251e-02f, -1.48462012e-01f, -2.62605131e-01f, -1.09203160e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  9.43176597e-02f, 1.36414692e-01f, 7.98298866e-02f, 2.80677080e-01f, 7.92148635e-02f, 1.32886529e-01f, 1.11690842e-01f, 2.49410301e-01f, 1.75283983e-01f, 7.18417689e-02f,
  5.04490212e-02f, -1.02756366e-01f, 5.29363602e-02f, 2.56764144e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  4.97835204e-02f, 1.45753756e-01f, -1.21048801e-01f, 1.38408333e-01f, 8.62465650e-02f, 1.51593789e-01f, 7.43659660e-02f, 5.04575670e-02f, 6.27600402e-02f, -2.28292152e-01f,
  3.09482962e-02f, -3.54492694e-01f, 1.63215563e-01f, 2.36043008e-03f, 2.05728456e-01f, -8.52299333e-02f, -1.96645841e-01f, 8.39631930e-02f, 1.90756917e-02f, 1.78243741e-01f,
  3.11304659e-01f, -2.91237861e-01f, -5.26120625e-02f, 2.99876541e-01f, 2.40098238e-01f, -2.56315432e-02f, -4.31695431e-02f, 2.92657405e-01f, 2.17741892e-01f, 4.21463192e-01f,
  -1.96293533e-01f, -2.53145993e-01f, 2.08834812e-01f, -8.51999894e-02f, 2.68899649e-01f, -1.39545873e-01f, 5.81633225e-02f, 1.23017512e-01f, 1.35863990e-01f, -1.15897099e-03f,
  3.23197931e-01f, -4.36171353e-01f, 3.12446244e-02f, -2.27056324e-01f, -1.59412235e-01f, -4.09330567e-03f, -2.69355047e-02f, -8.74714479e-02f, -7.43800104e-02f, -1.56901225e-01f,
  1.21097036e-01f, -7.34344572e-02f, 2.01535642e-01f, -3.61391693e-01f, -2.27013752e-01f, 7.39104897e-02f, -6.09351173e-02f, 2.53402948e-01f, 3.58412564e-01f, 2.93951213e-01f,
  2.36743793e-01f, -9.88536477e-02f, -5.72160259e-02f, -1.05260044e-01f, -1.10153027e-01f, -1.18707500e-01f, -1.26621738e-01f, -1.02715239e-01f, 9.05872211e-02f, 9.20655858e-03f,
  8.31809714e-02f, -1.87336460e-01f, -5.13479970e-02f, 4.53145616e-02f, -2.99961716e-01f, -3.68371606e-01f, 1.16799966e-01f, 3.17071915e-01f, 3.41700286e-01f, -2.22306594e-01f,
  -1.29708678e-01f, -7.44750910e-03f, 9.35620666e-02f, 5.17609343e-02f, 2.28829786e-01f, -1.47624522e-01f, -2.21378788e-01f, 2.64366150e-01f, 9.18123722e-02f, -3.22411507e-01f,
  -4.28541973e-02f, 2.35044271e-01f, 1.40565738e-01f, 5.04041910e-01f, -9.19369757e-02f, -8.58542770e-02f, 1.62650466e-01f, -2.24097177e-01f, 5.16576767e-02f, 1.25615284e-01f,
  -1.44620268e-02f, -1.97353616e-01f, -1.55289575e-01f, 3.71076614e-02f, 1.69887498e-01f, 1.33762971e-01f, -3.03267747e-01f, 1.60248607e-01f, -5.19046485e-01f, 4.98191953e-01f,
  1.09497659e-01f, 3.05135995e-01f, 3.72654945e-02f, -1.09815545e-01f, 1.08234175e-01f, 3.29707116e-01f, -9.20382291e-02f, 1.68823585e-01f, -1.58390496e-02f, 1.57275470e-03f,
  1.71133742e-01f, -2.14423284e-01f, -2.01908037e-01f, 2.20541209e-02f, -5.78200147e-02f, 2.18321696e-01f, 1.24135703e-01f, 2.26610318e-01f, 1.53293442e-02f, -2.63145026e-02f,
  -1.01171590e-01f, -1.72433928e-02f, 1.65713131e-01f, 2.00340837e-01f, 2.52006769e-01f, 6.02540374e-02f, -1.28335655e-01f, -8.66403878e-02f, -6.06762730e-02f, -2.03152269e-01f,
  4.17478472e-01f, -3.11357170e-01f, -9.69166458e-02f, -3.13059479e-01f, 1.12296477e-01f, -6.95677474e-02f, 9.66540202e-02f, -2.57514924e-01f, 2.47204110e-01f, -1.65297240e-01f,
  9.96926501e-02f, 8.86924099e-03f, -1.30110472e-01f, 9.42004025e-02f, 2.68590003e-01f, -1.38017461e-01f, -1.15774699e-01f, -4.10450965e-01f, -1.88461095e-02f, -3.11204225e-01f,
  1.14656106e-01f, 1.85451120e-01f, 1.20415494e-01f, -5.47716580e-03f, -1.15997151e-01f, -8.05175602e-02f, -7.41828978e-02f, -1.49294168e-01f, -1.20184995e-01f, 3.39923799e-01f,
  2.15949476e-01f, 1.26352027e-01f, -5.97037822e-02f, -2.24172547e-01f, 3.93569730e-02f, -2.18456537e-01f, 1.94010749e-01f, 2.66395777e-01f, -9.42794532e-02f, -2.83450242e-02f,
  -2.32539982e-01f, 4.58058119e-02f, 1.51959918e-02f, 7.17117265e-02f, 1.35751098e-01f, -8.91481861e-02f, -2.45019048e-01f, -7.93954059e-02f, -1.60125479e-01f, 1.97452173e-01f,
  -1.19941652e-01f, 3.39166909e-01f, -1.36225253e-01f, 1.56159326e-01f, -2.62332201e-01f, -8.50240439e-02f, -1.79085489e-02f, 5.25471428e-03f, -1.92443907e-01f, -6.71352446e-02f,
  3.52174528e-02f, 9.97121185e-02f, -6.30985200e-02f, 1.86247185e-01f, -2.22020760e-01f, 2.14955673e-01f, 1.40828803e-01f, -1.10168695e-01f, 6.23887405e-02f, -2.04169452e-01f,
  1.89549178e-01f, 2.00949281e-01f, -1.78034052e-01f, -8.15859158e-03f, 1.98694870e-01f, 4.47999313e-02f, -8.08643773e-02f, -1.56488761e-01f, -2.41684355e-02f, -1.72616512e-01f,
  1.19820014e-01f, 3.56153220e-01f, -5.54613620e-02f, 3.52114797e-01f, 9.06100646e-02f, 5.27068600e-02f, -2.75811329e-02f, -1.51286259e-01f, 1.94760650e-01f, 6.65917471e-02f,
  -1.93553120e-01f, 1.37267232e-01f, 1.67636782e-01f, -1.95444152e-01f, -1.30600795e-01f, 2.57227778e-01f, -2.26803228e-01f, 2.12473810e-01f, -1.51078552e-01f, 7.24036172e-02f,
  7.31124505e-02f, -3.20082515e-01f, 1.72464103e-01f, 1.50447115e-01f, 1.82256997e-01f, -1.40364945e-01f, -1.47611186e-01f, -1.91815272e-02f, -1.28745452e-01f, 9.04159024e-02f,
  1.49836868e-01f, 2.51450717e-01f, 1.52705401e-01f, 2.24066619e-02f, -5.75964972e-02f, 1.70665443e-01f, -1.46483362e-01f, 3.00196707e-01f, 7.72827044e-02f, 5.34419417e-02f,
  -2.37332974e-02f, 1.56958401e-01f, 6.79548606e-02f, 1.41634801e-02f, 5.01282141e-02f, 8.66660848e-02f, 1.80829093e-01f, 2.95956045e-01f, 4.96370383e-02f, 1.74439684e-01f,
  -5.98031990e-02f, 2.33378336e-01f, 4.33979928e-02f, -1.86687633e-01f, 2.76890069e-01f, 3.88292521e-02f, -2.01791719e-01f, -3.90234105e-02f, 4.29521166e-02f, -2.94623703e-01f,
  -1.21881090e-01f, 8.25318545e-02f, -1.09454311e-01f, -1.11407086e-01f, 1.97225526e-01f, 3.64510357e-01f, 1.32109955e-01f, 3.03767622e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -3.20694558e-02f, 2.00365838e-02f, 2.51549035e-01f, -2.47388035e-02f, 2.47766852e-01f, 1.62834913e-01f, -2.04935530e-03f, -2.15288818e-01f, -3.28334332e-01f, -5.45832396e-01f,
  3.18792075e-01f, -2.16503426e-01f, -1.09017283e-01f, -1.76587000e-01f, 7.46479571e-01f, -2.94063807e-01f, -4.99270648e-01f, 2.37597615e-01f, -1.46840304e-01f, -5.97013831e-02f,
  -2.35388484e-02f, 3.53168882e-02f, 1.95668638e-01f, -1.53587371e-01f, 3.52412373e-01f, -9.46675092e-02f, -1.55946508e-01f, 5.24932407e-02f, -4.42649275e-02f, 1.46314994e-01f,
  4.07876462e-01f, 1.65367406e-02f, 2.21519932e-01f, 8.71808305e-02f, 2.04576746e-01f, 1.34401617e-03f, 1.58424884e-01f, 2.98880398e-01f, -8.47657099e-02f, 2.16782153e-01f,
  5.93490377e-02f, 3.81463796e-01f, 2.83383220e-01f, 2.22032323e-01f, -5.22308171e-01f, -3.51916373e-01f, 1.22334040e-03f, 6.11270726e-01f, 8.03184688e-01f, 2.91095108e-01f,
  5.99514246e-01f, 2.57580668e-01f, -9.34526324e-02f, 2.83861041e-01f, -1.30113035e-01f, 2.50314236e-01f, -9.86049250e-02f, 5.67092061e-01f, 7.50433877e-02f, -2.93799303e-02f,
  2.94859290e-01f, 5.79885542e-01f, -3.93539757e-01f, 3.23760778e-01f, 1.95801049e-01f, 1.19247794e-01f, 2.35334516e-01f, 3.12532961e-01f, 9.42792147e-02f, 1.56671047e-01f,
  1.60095617e-01f, 5.62987804e-01f, 2.13588536e-01f, 9.28189084e-02f, 5.82127333e-01f, 5.11518419e-01f, 2.63463687e-02f, 3.64855170e-01f, -7.41730332e-01f, 1.45340130e-01f,
  1.32508740e-01f, -2.30425879e-01f, 2.30126858e-01f, 1.42838255e-01f, 6.02767542e-02f, 3.31392050e-01f, 5.31318009e-01f, -4.38113302e-01f, -3.26494724e-01f, 4.32075918e-01f,
  4.07795995e-01f, -3.74397874e-01f, 2.08099872e-01f, -5.58177352e-01f, 8.08361620e-02f, 1.16929695e-01f, 6.42703474e-02f, -3.39738041e-01f, -1.48667246e-01f, -1.77992776e-01f,
  2.86063373e-01f, 4.10375148e-02f, -2.06109688e-01f, 1.64317284e-02f, 3.60880077e-01f, -4.17351462e-02f, -5.20684123e-01f, -1.77571386e-01f, -1.37738839e-01f, -1.98930711e-01f,
  1.90148443e-01f, 1.48049802e-01f, 2.66964972e-01f, -1.09484076e-01f, 5.73234372e-02f, 2.49962956e-01f, 3.28465998e-01f, 3.21430676e-02f, -3.16758364e-01f, 3.95997345e-01f,
  1.42467633e-01f, 3.19174826e-01f, 1.79418713e-01f, 1.65418461e-01f, 1.59130558e-01f, 2.23295063e-01f, -7.58386135e-01f, -3.39636028e-01f, 2.98331499e-01f, -1.23516038e-01f,
  1.59750447e-01f, 2.02890664e-01f, 3.00915986e-01f, 9.12624076e-02f, -2.14039102e-01f, 1.32779747e-01f, 4.47464526e-01f, -1.00911908e-01f, -3.15676272e-01f, -1.10654406e-01f,
  -5.28925538e-01f, 2.29778647e-01f, 2.70407587e-01f, 4.85299885e-01f, 5.05528934e-02f, -1.95261493e-01f, 5.06812871e-01f, 5.64315140e-01f, 3.46619457e-01f, -3.27358007e-01f,
  -2.89517790e-01f, 4.45588499e-01f, 4.08036202e-01f, 3.97983909e-01f, 2.92988151e-01f, 2.59205163e-01f, 3.55033785e-01f, 3.44006330e-01f, -2.11521730e-01f, 2.12091640e-01f,
  -1.49831623e-01f, -9.54239592e-02f, -1.01700068e-01f, 9.17185768e-02f, -1.06062628e-01f, -1.62733018e-01f, 1.64337717e-02f, 4.63709310e-02f, 3.68519165e-02f, 9.47894603e-02f,
  -4.23804894e-02f, 6.36813566e-02f, 4.20830362e-02f, 7.21298382e-02f, 1.73570365e-01f, 1.11957856e-01f, -1.03731193e-02f, -2.67118290e-02f, -4.22082134e-02f, 1.48458242e-01f,
  -7.19215944e-02f, -1.72497436e-01f, -1.58269882e-01f, -3.69901173e-02f, -1.28535390e-01f, -5.17433286e-02f, 6.67612180e-02f, -1.52324468e-01f, 3.34543549e-02f, -7.97340199e-02f,
  -1.59919709e-01f, -9.26777571e-02f, 3.89160126e-01f, 3.59937139e-02f, 4.81509209e-01f, 1.62026480e-01f, 4.18334484e-01f, -9.30161960e-03f, 4.71735410e-02f, -1.07425928e-01f,
  5.51915109e-01f, -4.81628627e-01f, -2.38099277e-01f, -2.04298466e-01f, -7.01925755e-01f, 3.79221380e-01f, 6.50452137e-01f, 2.96952486e-01f, -7.78257698e-02f, 1.91162735e-01f,
  1.88796312e-01f, 5.00450492e-01f, 1.03185937e-01f, -8.78821462e-02f, -1.67651742e-03f, 3.07869762e-01f, 5.30434787e-01f, 5.49281687e-02f, 1.48118421e-01f, 5.00898361e-01f,
  5.42376995e-01f, 3.86277676e-01f, 2.47528896e-01f, 3.66442442e-01f, 7.19192438e-03f, 1.49025574e-01f, 3.42636555e-01f, -6.99391663e-02f, 1.84358463e-01f, 3.68583024e-01f,
  5.24657965e-03f, 1.88752845e-01f, 1.03428818e-01f, -5.60864270e-01f, 2.82368779e-01f, -5.56127489e-01f, -1.29988968e-01f, -5.70668876e-01f, 4.57986146e-01f, -2.96944201e-01f,
  -4.15010422e-01f, 5.03687203e-01f, 4.63311151e-02f, -1.34588018e-01f, 4.40871298e-01f, 3.60031217e-01f, -9.60890055e-02f, 4.45386380e-01f, 2.27651969e-01f, 5.29387355e-01f,
  2.19943747e-01f, 2.24766374e-01f, 6.21097721e-02f, -3.86189491e-01f, 1.98946260e-02f, -3.85087103e-01f, 6.89562708e-02f, 2.56035924e-01f, 1.05858542e-01f, -4.84222136e-02f,
  -1.24024674e-01f, 3.75036150e-01f, -4.55654562e-02f, 2.33277529e-02f, 2.87333056e-02f, 5.59681058e-01f, 3.19035053e-01f, 2.13883519e-01f, -2.42457703e-01f, -4.40794468e-01f,
  -4.04957652e-01f, 1.86197028e-01f, 5.12185276e-01f, 6.64038122e-01f, 5.13200201e-02f, -1.04625046e-01f, -1.69584915e-01f, 2.86761016e-01f, 9.45542231e-02f, 3.63578856e-01f,
  -2.74308443e-01f, 1.36248201e-01f, -2.75375873e-01f, -5.14830649e-02f, -4.29556161e-01f, 3.37287486e-01f, -2.15914622e-01f, 3.38575661e-01f, -1.85723025e-02f, 1.27582386e-01f,
  -2.04827432e-02f, 1.55279428e-01f, 2.54744053e-01f, 5.53696901e-02f, -1.59186780e-01f, 8.84075090e-02f, 3.26248765e-01f, -2.17131048e-01f, -1.10923417e-01f, -1.55874908e-01f,
  3.39115947e-01f, 3.31806451e-01f, -1.30247111e-02f, -1.23360850e-01f, -8.18962827e-02f, -4.11126852e-01f, 1.97759584e-01f, 5.65400422e-01f, 6.21806979e-01f, -4.62121248e-01f,
  1.11131333e-01f, 4.72098678e-01f, 2.09680140e-01f, 1.79977193e-01f, 5.47566712e-01f, 4.89463031e-01f, 3.68882447e-01f, 2.66150385e-01f, -1.66378066e-01f, 7.62048289e-02f,
  6.63919467e-03f, 1.34128481e-01f, 1.15336910e-01f, 3.88328433e-01f, 3.21427494e-01f, 3.08245033e-01f, 1.56206191e-01f, 6.17696978e-02f, 1.51707128e-01f, -4.59598839e-01f,
  -6.24021366e-02f, -3.73956382e-01f, 4.24287111e-01f, 1.95148259e-01f, 5.46305954e-01f, -6.82650745e-01f, -5.99257767e-01f, 4.52648580e-01f, -1.71368048e-01f, 3.11532822e-02f,
  7.68876523e-02f, 1.75307408e-01f, 3.85736734e-01f, 1.68959841e-01f, 5.80160856e-01f, -4.19140786e-01f, 2.46756777e-01f, 1.86025232e-01f, -5.50196134e-03f, -2.99331713e-02f,
  6.62159801e-01f, 1.66707635e-01f, -1.69349164e-01f, -2.03535873e-02f, -2.21515059e-01f, 3.33053321e-02f, 2.46603694e-02f, 2.87088871e-01f, 2.23196447e-02f, 2.33064428e-01f,
  -9.48083252e-02f, 5.65417230e-01f, 6.90482631e-02f, 2.24232852e-01f, -4.34275627e-01f, -5.15350759e-01f, -3.47999394e-01f, 5.48476279e-01f, 4.66980129e-01f, 1.55565023e-01f,
  3.93736601e-01f, 2.94460624e-01f, 5.53446189e-02f, 4.41579223e-01f, 2.17475504e-01f, 2.81042248e-01f, -1.89737737e-01f, 3.67616624e-01f, 1.95388660e-01f, 1.02453552e-01f,
  -1.63865268e-01f, 1.33543849e-01f, -3.21910590e-01f, 8.08258131e-02f, 9.50733125e-02f, 3.36601555e-01f, 2.78291225e-01f, 2.89781898e-01f, 2.71788061e-01f, 3.42830449e-01f,
  1.76845476e-01f, 3.20038080e-01f, 3.13355252e-02f, -1.30234584e-01f, 2.31487021e-01f, -5.34142256e-01f, 5.87958813e-01f, 1.08386762e-01f, 1.72095060e-01f, -8.82791758e-01f,
  -5.38973927e-01f, 4.19201970e-01f, -4.53047961e-01f, -6.32968396e-02f, 1.84760928e-01f, 3.42135459e-01f, 2.44040072e-01f, 2.95080930e-01f, 2.22081885e-01f, -1.20317243e-01f,
  7.67305195e-02f, 1.68788448e-01f, -5.82231916e-02f, -3.42750371e-01f, 4.94796336e-01f, 7.71949738e-02f, 3.47567797e-01f, 1.86339512e-01f, 1.99772716e-02f, 3.89017731e-01f,
  -2.92122047e-02f, 1.02534197e-01f, 1.21894948e-01f, 4.67397153e-01f, 4.32306081e-01f, -2.64804810e-01f, -3.10626384e-02f, 3.64302546e-01f, 9.97082666e-02f, 6.65583849e-01f,
  -3.51479828e-01f, -2.83705324e-01f, -8.82850662e-02f, -3.89430106e-01f, 3.46129894e-01f, 5.92048347e-01f, 2.27607355e-01f, -9.89413168e-03f, 1.73516467e-01f, -7.45740309e-02f,
  2.13906225e-02f, 1.25320405e-02f, 3.45434040e-01f, -4.68922630e-02f, 3.09759527e-01f, -4.13253069e-01f, 2.04574078e-01f, 5.75564444e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  6.27073720e-02f, 1.26370892e-01f, 2.60786682e-01f, 1.91023484e-01f, 4.03456725e-02f, -1.38228849e-01f, 3.01309496e-01f, 3.59690964e-01f, 2.42033765e-01f, 3.41081679e-01f,
  7.08522946e-02f, 2.29153596e-02f, 1.11993447e-01f, 2.74308175e-01f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  5.83752543e-02f, 8.25433061e-02f, 1.99607670e-01f, -7.72643164e-02f, -1.01338483e-01f, 3.60147096e-02f, 2.83821602e-03f, 1.73945382e-01f, -1.46918610e-01f, -2.30927467e-01f,
  -1.68970630e-01f, -1.77176192e-01f, -7.94456974e-02f, -2.07579076e-01f, 2.01462448e-01f, 2.19174027e-01f, 1.25093892e-01f, 2.70702869e-01f, -1.58005416e-01f, -1.41737526e-02f,
  9.57521796e-02f, 3.50678265e-02f, -1.34193331e-01f, 8.94536078e-02f, 8.49239081e-02f, -2.33434141e-01f, 2.49799967e-01f, -7.37851486e-02f, 5.47007844e-03f, -1.79830939e-02f,
  -2.76831500e-02f, 1.75322175e-01f, -1.26411468e-01f, 2.84320623e-01f, -9.67889279e-02f, -8.68224055e-02f, 2.10243091e-01f, -9.45276171e-02f, 1.95996761e-01f, -1.13739498e-01f,
  3.93266529e-01f, 2.80981660e-01f, 1.14362411e-01f, 1.39571905e-01f, 1.01915441e-01f, -1.92244604e-01f, 6.91493526e-02f, -2.57957309e-01f, -1.18935183e-01f, -1.85556144e-01f,
  3.47626372e-03f, 1.99872889e-02f, -2.12415680e-01f, -1.70029789e-01f, 5.53758107e-02f, -9.43101272e-02f, 1.51967078e-01f, 9.84458253e-02f, 2.81153738e-01f, 7.37139676e-03f,
  5.49614429e-02f, -9.56335887e-02f, 3.25823724e-02f, -1.85580164e-01f, 1.93827972e-01f, 1.98923156e-01f, 9.03123170e-02f, 2.09013134e-01f, 2.25920856e-01f, 5.04509583e-02f,
  -5.94148936e-04f, 1.43386468e-01f, 1.15288191e-01f, 3.49503756e-02f, -1.88193783e-01f, -3.79315354e-02f, 1.09367669e-02f, -8.39209855e-02f, 3.32355462e-02f, -1.66247621e-01f,
  -2.90184528e-01f, 2.59629130e-01f, -2.36331280e-02f, -2.86856014e-02f, 7.56042525e-02f, -6.97878376e-02f, -1.66633695e-01f, -7.29220137e-02f, -9.47708040e-02f, 3.45095098e-02f,
  -2.81505845e-02f, -4.44944762e-02f, 1.80820465e-01f, -1.96825758e-01f, 2.91213959e-01f, 1.07376277e-01f, 4.51505780e-02f, 7.31610507e-02f, 1.57428131e-01f, 4.17951532e-02f,
  -2.83323657e-02f, -4.76484606e-03f, -1.52718872e-01f, 1.96903571e-01f, -1.08429968e-01f, -2.37393871e-01f, 1.78952515e-01f, -8.00984651e-02f, -1.20257802e-01f, -6.19042292e-02f,
  1.74072329e-02f, 3.36213261e-01f, 4.54258889e-01f, 8.98299888e-02f, -4.52351272e-02f, -4.45760880e-03f, 1.09189920e-01f, -2.83655226e-01f, 3.08132302e-02f, 1.17140695e-01f,
  -8.65505412e-02f, -1.35609452e-02f, -1.50261670e-01f, 6.83965683e-02f, -2.02363580e-01f, 2.28757009e-01f, -2.60571837e-01f, 1.89422637e-01f, -4.84108217e-02f, 1.42382026e-01f,
  9.74090472e-02f, -4.56656329e-02f, -1.77826863e-02f, -1.47490632e-02f, -5.39682917e-02f, -3.87389436e-02f, 4.53159697e-02f, 6.11186400e-02f, -3.24841827e-01f, -2.37515733e-01f,
  -1.73468068e-01f, -7.44603276e-02f, 4.03208673e-01f, 1.63466752e-01f, -3.93204987e-01f, 5.25869988e-03f, -4.06115269e-03f, 2.35904619e-01f, -1.74268618e-01f, -2.39649221e-01f,
  -2.15643227e-01f, 1.34361535e-01f, -4.66076955e-02f, 2.79240962e-02f, 1.41179129e-01f, -2.19892953e-02f, 1.83886483e-01f, 2.16507376e-03f, 7.06397444e-02f, -1.44141451e-01f,
  -9.38878208e-02f, 1.08564924e-02f, 4.57269177e-02f, 1.74753591e-01f, 3.84992100e-02f, 1.47471830e-01f, 2.09176615e-01f, 2.56889433e-01f, -5.22199133e-03f, -9.75863039e-02f,
  7.88608752e-03f, -7.75558352e-02f, 3.59141409e-01f, 1.10647902e-01f, -6.72143325e-02f, 5.47232293e-02f, 3.56559813e-01f, 1.95759654e-01f, -2.39243150e-01f, -2.41355211e-01f,
  1.61590651e-01f, 2.05072016e-02f, 5.54276593e-02f, 8.99609327e-02f, -1.17737815e-01f, -2.51671165e-01f, -5.75200953e-02f, -1.75585244e-02f, -7.36551583e-02f, 5.27480319e-02f,
  1.55778944e-01f, 2.72098333e-01f, 3.49930137e-01f, 1.66544825e-01f, 1.90126702e-01f, 1.87778473e-01f, 1.44146651e-01f, -4.82589677e-02f, 1.23044595e-01f, -5.69407828e-02f,
  -1.18079670e-01f, -1.53685793e-01f, 1.13477506e-01f, -4.47977245e-01f, -4.70292658e-01f, 2.36994192e-01f, 3.01335827e-02f, -6.12867773e-02f, -2.91890800e-01f, 1.17360123e-01f,
  1.63464770e-01f, 7.56688341e-02f, 9.29280818e-02f, -1.10676885e-02f, -2.16002554e-01f, -8.08030739e-02f, -6.97901547e-02f, 1.12710811e-01f, -7.32372627e-02f, 4.42854175e-03f,
  4.50053103e-02f, 1.55015126e-01f, -1.07651146e-03f, -1.48304671e-01f, -3.95410389e-01f, -7.37323463e-02f, 1.09267898e-01f, 1.08396560e-01f, -2.67850876e-01f, -3.42061222e-02f,
  -1.34892613e-01f, 1.53358683e-01f, -9.66815874e-02f, -2.39536446e-02f, -2.96087086e-01f, 3.06227356e-01f, -3.90239298e-01f, 2.81880200e-01f, -1.67338982e-01f, -1.59315720e-01f,
  3.47217992e-02f, -2.05522850e-01f, -1.81585457e-02f, 3.81645858e-02f, -2.59546965e-01f, -6.34901300e-02f, -5.18668927e-02f, -1.01418950e-01f, -1.89275369e-01f, 3.77635891e-03f,
  3.85306895e-01f, 2.95753717e-01f, -1.10227875e-02f, 1.00906648e-01f, 1.01277247e-01f, -2.42933184e-01f, 3.01593691e-02f, 5.81169203e-02f, 3.98612507e-02f, 7.44129121e-02f,
  -1.63735256e-01f, -2.92380638e-02f, -3.63580585e-02f, -2.18297094e-02f, -6.86543882e-02f, 7.55230337e-02f, 1.43837035e-01f, 1.95786506e-01f, 2.15052962e-01f, -8.75462666e-02f,
  -1.49414137e-01f, -7.60908946e-02f, 2.18553632e-01f, 9.42625329e-02f, 2.66077220e-01f, 5.98821230e-02f, -4.05180492e-02f, 5.37420399e-02f, 1.71755895e-01f, -1.11239947e-01f,
  6.20006490e-03f, -1.32156312e-02f, -3.30164403e-01f, 1.12549253e-01f, -1.76512286e-01f, -9.74441022e-02f, -2.43814871e-01f, 1.81487352e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  1.05864152e-01f, 2.67116427e-01f, 7.19243586e-02f, -9.47159156e-03f, -1.55146904e-02f, 1.85068622e-01f, 3.57628055e-02f, 3.31469297e-01f, -2.83990085e-01f, -2.35419840e-01f,
  -8.96122158e-02f, -1.80206627e-01f, -1.30332753e-01f, -2.13881340e-02f, 2.36860111e-01f, 1.42831221e-01f, -2.02003703e-01f, 1.86070830e-01f, -6.67967737e-01f, 2.88991064e-01f,
  6.30201161e-01f, -1.61637306e-01f, -3.06228958e-02f, 1.72789861e-02f, -3.54363739e-01f, -3.61607969e-01f, 4.40179557e-01f, 1.67679384e-01f, -7.99043924e-02f, 5.86183965e-01f,
  2.33731896e-01f, 4.73658234e-01f, 4.00936812e-01f, 2.84463912e-01f, 3.85465585e-02f, 3.59401405e-01f, 5.25904179e-01f, 2.39186719e-01f, 1.30369728e-02f, 1.18669026e-01f,
  2.85103153e-02f, 3.32953751e-01f, 7.48514891e-01f, -3.81969035e-01f, 1.69566035e-01f, -7.80120417e-02f, -6.23681784e-01f, 4.03990924e-01f, 6.35505259e-01f, 6.36281967e-01f,
  -1.37311831e-01f, 2.24907890e-01f, 6.19991243e-01f, -5.59537828e-01f, 1.70135498e-01f, 1.39465816e-02f, 1.55095711e-01f, -2.58582145e-01f, -4.25996453e-01f, 2.67151296e-01f,
  -1.11381456e-01f, -2.33426735e-01f, -1.72046334e-01f, 4.05775696e-01f, 2.05196619e-01f, -2.66725808e-01f, -3.04233074e-01f, -8.75382200e-02f, 1.06827132e-01f, -9.11764652e-02f,
  -2.54196413e-02f, -7.02742785e-02f, -1.30131096e-01f, -2.65361726e-01f, 9.91187245e-02f, -9.59966034e-02f, 2.66864914e-02f, 4.84175188e-03f, -3.75195533e-01f, -7.92088881e-02f,
  2.26038724e-01f, 8.57761726e-02f, -6.34073675e-01f, 1.79707602e-01f, 5.18881023e-01f, 6.22875750e-01f, 5.46529889e-01f, 7.08629703e-03f, 2.59138465e-01f, 4.43500094e-02f,
  7.40574151e-02f, 5.09312212e-01f, -2.27173239e-01f, 3.26887161e-01f, -3.77944976e-01f, 4.67624605e-01f, -9.77829173e-02f, -3.15275267e-02f, 1.15408950e-01f, -3.12139988e-02f,
  4.64782506e-01f, 6.69642463e-02f, 8.87475386e-02f, 8.23843628e-02f, 1.55778050e-01f, 2.14821007e-02f, -3.76099169e-01f, -1.85095385e-01f, 8.37275743e-01f, -7.32170343e-01f,
  2.89829850e-01f, 6.10418320e-01f, -1.05888620e-01f, 3.90703976e-01f, 1.37603683e-02f, -2.33550742e-01f, 2.83762008e-01f, -4.41313684e-01f, 1.98740959e-01f, -7.84585103e-02f,
  3.74355793e-01f, -2.12061539e-01f, -1.22379832e-01f, -5.84511261e-04f, 1.42035037e-01f, -6.57863319e-02f, 2.94930525e-02f, 4.87856925e-01f, -7.34314859e-01f, -2.68503308e-01f,
  -1.20785862e-01f, 3.69261503e-02f, -3.61237139e-01f, -3.64379846e-02f, -2.31836423e-01f, 4.04076397e-01f, 1.38102904e-01f, -2.38202974e-01f, -1.79487303e-01f, 2.29326203e-01f,
  9.97318566e-01f, -9.47194278e-01f, 6.39265180e-01f, 6.36482894e-01f, 2.48582721e-01f, 3.28662038e-01f, 3.02038550e-01f, 3.72018307e-01f, -1.18779220e-01f, -1.93995997e-01f,
  2.37668395e-01f, -1.62432134e-01f, 3.82529557e-01f, -2.92459458e-01f, 5.69790304e-01f, -2.28721410e-01f, 3.13987613e-01f, 2.09447041e-01f, -3.72970919e-03f, 9.23303515e-02f,
  -2.34903753e-01f, 1.67525381e-01f, 2.38130823e-01f, 1.49065778e-01f, 2.10755989e-01f, 2.15058133e-01f, 3.04140180e-01f, 2.16242403e-01f, 2.59145200e-01f, 2.77258694e-01f,
  2.04657167e-02f, 4.00480181e-01f, 6.43993691e-02f, 1.92759588e-01f, -1.83062837e-01f, -2.30849072e-01f, -1.66508645e-01f, -8.47928300e-02f, 4.84508187e-01f, -5.38437366e-01f,
  -1.01702750e-01f, -1.67652637e-01f, 1.07190020e-01f, -2.04320550e-02f, 4.31298643e-01f, 4.37334478e-01f, -5.64251661e-01f, 2.96081752e-01f, 5.39955556e-01f, -6.64751112e-01f,
  4.95968938e-01f, 3.14613730e-01f, 1.74929678e-01f, 1.32910997e-01f, -3.85620408e-02f, -3.64341199e-01f, -2.15770006e-01f, 6.30267411e-02f, -3.68002355e-01f, -4.56843615e-01f,
  -2.62015522e-01f, 1.44417301e-01f, 4.04148608e-01f, 2.14084700e-01f, 2.54537344e-01f, -3.33999008e-01f, 1.00286961e-01f, 1.14587203e-01f, -7.28543997e-02f, 2.18492955e-01f,
  -4.56840873e-01f, 5.45905530e-01f, -3.54057476e-02f, 2.16289476e-01f, 3.87454212e-01f, 7.06796125e-02f, 4.12970603e-01f, -1.53489411e-01f, 1.07410662e-01f, 5.64073175e-02f,
  -3.28369111e-01f, 1.40432552e-01f, -4.73915339e-01f, 3.09246778e-02f, 3.35581005e-01f, 2.33594283e-01f, 5.00464797e-01f, 4.48301405e-01f, 3.33384693e-01f, 6.56004012e-01f,
  5.13595819e-01f, 3.55968118e-01f, 5.17473221e-01f, 3.77562463e-01f, 3.81142855e-01f, -5.58466136e-01f, -7.62653887e-01f, 6.15201831e-01f, -2.40253910e-01f, -6.53935134e-01f,
  -3.77983421e-01f, 3.26029867e-01f, 5.71422756e-01f, 5.62894717e-02f, 4.77830082e-01f, -3.38984072e-01f, -1.19782373e-01f, 1.55019686e-02f, 1.87311888e-01f, 5.17893672e-01f,
  9.54008102e-02f, -1.27439201e-01f, 4.66235101e-01f, -2.13540316e-01f, 5.83687246e-01f, 1.98729098e-01f, 4.79617774e-01f, -9.48451236e-02f, -8.00571777e-03f, 3.10396492e-01f,
  3.10881615e-01f, 2.45410666e-01f, 2.68019319e-01f, 3.40661645e-01f, 3.54230285e-01f, -4.37371552e-01f, -3.56636286e-01f, -8.29897106e-01f, -1.99084535e-01f, -1.05247788e-01f,
  4.91335362e-01f, 1.08899735e-01f, -5.72804868e-01f, 5.02286196e-01f, 8.81344527e-02f, 3.90802383e-01f, 5.47625244e-01f, -2.01315522e-01f, -3.44401062e-01f, 1.50911152e-01f,
  -1.80669188e-01f, 3.07364404e-01f, 4.70064163e-01f, -4.62341249e-01f, 6.61692396e-02f, 5.72222054e-01f, 4.98015344e-01f, 8.46923813e-02f, -2.44816184e-01f, -1.63337976e-01f,
  -1.08102478e-01f, 6.54303804e-02f, -1.18079305e-01f, -2.42994651e-01f, -8.40400979e-02f, 7.83399940e-02f, -3.26011032e-01f, -1.37706906e-01f, -1.50936265e-02f, -8.04419070e-03f,
  5.92253566e-01f, -4.20281261e-01f, 1.58763483e-01f, 4.71723378e-01f, 2.81138361e-01f, 4.09459412e-01f, 4.01895195e-02f, 5.88945687e-01f, 6.18417561e-02f, -1.52356431e-01f,
  3.03508192e-01f, -2.58973204e-02f, 1.21537864e-01f, -1.91411659e-01f, 1.87017784e-01f, 1.50006726e-01f, -1.69674024e-01f, 4.00308967e-01f, -5.89548945e-01f, 3.96175720e-02f,
  -1.27168894e-02f, -2.58373559e-01f, -1.05861336e-01f, 6.23288788e-02f, -1.04085729e-01f, 1.13573320e-01f, 1.47929043e-01f, -1.36805847e-01f, 4.43107821e-02f, -1.06660053e-01f,
  3.46766919e-01f, 2.35360652e-01f, 2.52919868e-02f, -1.73979979e-02f, -4.30256099e-01f, -3.33157122e-01f, 6.37181222e-01f, -1.04712844e-01f, -3.75717163e-01f, 3.31211179e-01f,
  -1.79252222e-01f, 8.74126852e-01f, 6.17246628e-01f, -1.28979877e-01f, 3.01054716e-01f, 4.75719839e-01f, 1.10288318e-02f, 3.84215891e-01f, -1.19818509e-01f, 1.46513879e-01f,
  -4.73776460e-02f, 1.79175794e-01f, -2.61547536e-01f, 3.74498993e-01f, 3.21925074e-01f, 9.11438093e-02f, 1.50721418e-02f, 2.11874738e-01f, 1.49683848e-01f, 2.61894669e-02f,
  -4.96045277e-02f, 4.93855208e-01f, 2.77999610e-01f, 4.67318028e-01f, -3.68976370e-02f, 3.23798418e-01f, -3.26353788e-01f, -7.02879578e-02f, 2.64351845e-01f, 1.22387648e-01f,
  1.56024098e-01f, -1.92280635e-01f, -9.79397297e-02f, -1.48419477e-02f, 2.69514740e-01f, 5.07474393e-02f, 2.99258828e-01f, 2.00881392e-01f, -5.20100296e-01f, 7.27668047e-01f,
  4.38427538e-01f, -3.71483922e-01f, 3.77980798e-01f, 1.23724528e-01f, 2.52166688e-01f, 1.11109443e-01f, -3.44186053e-02f, 2.16836005e-01f, -1.28705874e-01f, 2.31139764e-01f,
  3.66731882e-02f, 1.36932023e-02f, 7.29618073e-02f, 1.35562085e-02f, 2.46092707e-01f, -3.12378675e-01f, -3.39702398e-01f, -1.56333908e-01f, 2.69591361e-01f, -2.84851253e-01f,
  2.29895189e-01f, 7.69707039e-02f, -2.28864893e-01f, 5.80544770e-01f, 2.23950490e-01f, -3.51309739e-02f, 1.83371082e-01f, 1.12604216e-01f, 8.42572302e-02f, 4.49188620e-01f,
  4.39788312e-01f, -1.32334590e-01f, -4.72778738e-01f, 5.58434308e-01f, -3.85869950e-01f, -4.30096626e-01f, 1.07190765e-01f, -4.96528968e-02f, -1.47433981e-01f, 2.63740364e-02f,
  -1.67198271e-01f, -7.37758586e-03f, -4.20776904e-02f, 8.88691097e-02f, 1.02935255e-01f, -1.45311892e-01f, 1.24839712e-02f, -5.90554215e-02f, -1.06755629e-01f, 6.86482564e-02f,
  -1.38724282e-01f, 9.95783433e-02f, 2.74834894e-02f, 6.14841804e-02f, -3.46463942e-03f, -1.13926060e-01f, -1.38406888e-01f, -6.48486540e-02f, 2.64024511e-02f, 1.10852845e-01f,
  -3.78097482e-02f, 1.00429758e-01f, 1.64120942e-02f, -1.36711463e-01f, -9.20643508e-02f, -3.47564444e-02f, 6.04861677e-02f, -7.80887082e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  2.69601703e-01f, 3.13269109e-01f, 2.75135953e-02f, -1.21377401e-01f, 1.11028008e-01f, 2.81017810e-01f, -8.58555585e-02f, 4.18436199e-01f, 2.84480393e-01f, 3.53456847e-02f,
  -2.11028401e-02f, 3.94540019e-02f, 1.71922192e-01f, -1.88902989e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -1.27840132e-01f, -2.01524869e-01f, -1.70809180e-01f, -3.01619828e-01f, 1.92082271e-01f, -1.78966478e-01f, -1.06494635e-01f, 2.20035717e-01f, 7.60342181e-02f, -3.84734660e-01f,
  4.18292880e-01f, 2.72071987e-01f, -9.50153992e-02f, 2.47153103e-01f, -5.19468129e-01f, 5.03987551e-01f, 4.52537060e-01f, -1.98351726e-01f, -5.02541244e-01f, -3.34201127e-01f,
  -7.83989131e-01f, -7.22407818e-01f, -1.33783424e+00f, 3.04020077e-01f, -2.18162283e-01f, 5.17373145e-01f, -1.27787709e-01f, -1.75110146e-01f, -3.40960205e-01f, 4.12950248e-01f,
  -1.56126708e-01f, 3.93897621e-03f, 2.51734555e-01f, 6.45642802e-02f, 1.29820675e-01f, 5.12916110e-02f, 2.88227320e-01f, 1.41654328e-01f, 1.36047333e-01f, 1.46246731e-01f,
  5.11454105e-01f, 6.70547858e-02f, -7.50569403e-02f, -1.60891935e-01f, 3.75830621e-01f, -5.92817008e-01f, 1.23190857e-01f, 4.71356481e-01f, -5.89258909e-01f, -3.36666405e-02f,
  -1.65671423e-01f, 1.12498641e-01f, 2.10273992e-02f, -1.49513692e-01f, -2.68929303e-01f, -3.72280002e-01f, -1.92211084e-02f, 1.02907971e-01f, 8.27698484e-02f, -9.19879898e-02f,
  1.89191580e-01f, -5.50519645e-01f, 4.15723294e-01f, -1.59862712e-02f, -1.68748170e-01f, 1.31239509e-03f, 2.16640726e-01f, 6.19611703e-02f, -1.10162057e-01f, -5.55632152e-02f,
  -2.93450914e-02f, 2.47223854e-01f, -6.05751760e-04f, 1.87799677e-01f, -1.72961488e-01f, -3.28359425e-01f, 4.67201501e-01f, 4.61675674e-01f, -1.20297141e-01f, 2.09734082e-01f,
  1.92385152e-01f, -1.47302359e-01f, 1.06486276e-01f, -8.70628417e-01f, -2.17619598e-01f, -1.75076216e-01f, 4.04764950e-01f, -2.92202771e-01f, -1.34371072e-01f, -6.71602070e-01f,
  2.12435916e-01f, 4.33316976e-01f, -3.91340703e-01f, -4.39504594e-01f, 3.71495128e-01f, -3.54178399e-02f, -1.37366736e-02f, 2.23500013e-01f, 3.86544645e-01f, 1.27788499e-01f,
  -4.14172053e-01f, -3.53824943e-02f, 1.23373792e-01f, 8.25617388e-02f, 2.42075950e-01f, -3.76440734e-01f, 3.26342182e-03f, -1.88184530e-01f, -2.90843576e-01f, -1.74462885e-01f,
  -6.39856756e-02f, -2.90859491e-01f, 7.30691373e-01f, 3.88912350e-01f, -1.06137052e-01f, -4.74343330e-01f, -2.42970679e-02f, -6.11841977e-01f, -9.76122499e-01f, 1.82950065e-01f,
  -5.37797809e-01f, -2.19820645e-02f, -2.82061160e-01f, -8.14447224e-01f, 3.85877788e-01f, 2.83642292e-01f, -1.99005619e-01f, -5.70658445e-02f, 1.94316030e-01f, -3.29185545e-01f,
  -1.48090065e-01f, -3.40552367e-02f, -5.15864268e-02f, 1.32547289e-01f, -1.51060298e-01f, 3.96003515e-01f, 2.65859812e-01f, -4.47935700e-01f, 2.39065304e-01f, 2.53053218e-01f,
  -3.43154162e-01f, 2.30664928e-02f, 1.28698304e-01f, -6.95646763e-01f, -3.55048597e-01f, 2.10390761e-01f, -7.79815316e-01f, 7.32850358e-02f, -3.93599480e-01f, 3.44213396e-01f,
  1.17188223e-01f, 3.02743256e-01f, -4.51317042e-01f, 1.08804405e-02f, -6.40153468e-01f, -2.21971825e-01f, -1.38964817e-01f, 3.16478848e-01f, -2.00033277e-01f, -5.84509000e-02f,
  2.62535572e-01f, -6.72398210e-02f, -2.89285511e-01f, 4.08675760e-01f, 8.20189342e-02f, -4.02227134e-01f, 1.07568726e-01f, -2.28805438e-01f, 4.60521936e-01f, 4.65747148e-01f,
  -3.64017755e-01f, 8.60960484e-02f, 2.27561131e-01f, -4.59709287e-01f, 2.26287767e-01f, 2.29602218e-01f, -3.39411758e-03f, 7.40080029e-02f, 1.12391807e-01f, 5.89496017e-01f,
  -1.92356259e-01f, 3.55306230e-02f, -7.31345415e-01f, 1.83330476e-02f, -5.22557318e-01f, 1.93476245e-01f, 1.81811173e-02f, -4.32509005e-01f, -2.96378881e-01f, 1.80197001e-01f,
  -4.03150648e-01f, 5.88892736e-02f, -3.17700893e-01f, -7.12067820e-03f, -1.06130391e-01f, 3.39834094e-01f, 3.57862145e-01f, -2.87991762e-01f, 1.64010987e-01f, 3.53171863e-02f,
  -1.65109441e-01f, 1.78555772e-01f, -4.75997120e-01f, 2.81006813e-01f, -9.02280062e-02f, 3.56450319e-01f, 2.61243254e-01f, -1.43927693e-01f, -2.81395525e-01f, -2.96194047e-01f,
  4.76192206e-01f, -1.88859329e-01f, -5.61164543e-02f, 4.09328133e-01f, 2.84714013e-01f, -4.27671224e-01f, -5.67982972e-01f, -9.00645107e-02f, 1.47842109e-01f, -2.09090561e-01f,
  -4.24183637e-01f, -6.20524585e-01f, -3.31922472e-01f, -1.55147895e-01f, -9.20558870e-02f, -2.61467397e-01f, -3.52910072e-01f, -2.89064616e-01f, -3.89787629e-02f, -8.23646933e-02f,
  -1.31527305e-01f, 6.29519746e-02f, -2.37946838e-01f, -2.56213874e-01f, 2.17102095e-01f, -3.82009536e-01f, -1.41353846e-01f, 2.14458406e-01f, -3.00247699e-01f, -2.30685756e-01f,
  -2.98874706e-01f, 1.61219791e-01f, -5.37893355e-01f, -2.18173534e-01f, 8.84614885e-02f, 4.17583063e-02f, -2.01727971e-01f, -1.19500019e-01f, 2.12515563e-01f, -5.80485642e-01f,
  -2.27733210e-01f, -1.48189679e-01f, 2.78521657e-01f, 1.28190249e-01f, -3.34514052e-01f, -1.78430885e-01f, 1.01743668e-01f, 5.13116978e-02f, -1.36245236e-01f, 1.64486319e-01f,
  1.66668743e-01f, -1.79552674e-01f, -5.27188778e-02f, -1.09443724e-01f, -2.70229846e-01f, 1.95997372e-01f, -1.47861362e-01f, -4.08382565e-02f, 3.44551325e-01f, -2.05373734e-01f,
  -3.42499256e-01f, -4.10923034e-01f, -2.87205297e-02f, 3.17859173e-01f, -1.80242911e-01f, 1.60901025e-02f, -1.13267891e-01f, -1.43074200e-01f, 2.52484024e-01f, -5.63156247e-01f,
  4.33731407e-01f, -6.01451218e-01f, -6.38367116e-01f, 2.21857324e-01f, 8.50531608e-02f, -1.10104524e-01f, 1.95982218e-01f, -1.58068344e-01f, 3.11312735e-01f, 3.31373572e-01f,
  -2.34292671e-01f, -4.07402396e-01f, -9.02354196e-02f, 9.80768204e-02f, 1.44873083e-01f, -2.70688146e-01f, -3.80576029e-02f, 4.15113270e-01f, -4.36379872e-02f, -1.99678585e-01f,
  -3.26997012e-01f, 2.62959629e-01f, 7.15689510e-02f, 2.90747672e-01f, -5.55762798e-02f, -2.03675315e-01f, -4.73155499e-01f, -5.18852055e-01f, -6.98803246e-01f, 3.75989705e-01f,
  1.44346096e-02f, 1.98680222e-01f, -1.91120625e-01f, 2.49734238e-01f, 4.00463015e-01f, -5.62191963e-01f, -6.66018248e-01f, -1.72170818e-01f, -2.74179906e-01f, -1.60824403e-01f,
  2.18073577e-01f, 1.97527334e-01f, -5.06315334e-03f, 6.29358813e-02f, 5.92263266e-02f, 8.36688280e-02f, -2.05789074e-01f, 3.23403507e-01f, -3.07990342e-01f, 3.22056450e-02f,
  3.57528836e-01f, 2.79486984e-01f, -2.70363361e-01f, 5.23217261e-01f, -2.19129384e-01f, 2.91937828e-01f, 4.40131307e-01f, -1.49417907e-01f, 3.60675931e-01f, -6.07054710e-01f,
  -1.83772460e-01f, -2.75716811e-01f, -8.01121533e-01f, -2.13528261e-01f, -6.58503950e-01f, 3.03209186e-01f, 4.30033535e-01f, -7.04373717e-01f, -2.16939718e-01f, -2.40048319e-01f,
  2.80976415e-01f, -6.39117882e-02f, 9.29263681e-02f, -4.93639112e-01f, 2.37143785e-01f, -2.72374362e-01f, -4.05765533e-01f, -2.69902468e-01f, 9.99103561e-02f, -1.17038168e-01f,
  -2.83692777e-01f, 4.97106388e-02f, -2.07839713e-01f, -4.86152709e-01f, 6.79965466e-02f, 3.30599517e-01f, 3.87988359e-01f, -2.00457633e-01f, 3.04699928e-01f, 2.68837541e-01f,
  1.68538690e-01f, 4.57291901e-01f, 1.69280916e-01f, 2.57692903e-01f, -5.41422188e-01f, -4.26006913e-01f, 9.69639570e-02f, -3.18718910e-01f, -4.14486825e-01f, 1.93659633e-01f,
  -1.68188781e-01f, -1.58754379e-01f, -5.78796118e-02f, -3.59133780e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  2.24871963e-01f, 7.74521157e-02f, -2.17184260e-01f, -1.55088603e-01f, -8.42345282e-02f, 3.09164859e-02f, -3.57785486e-02f, 6.35764673e-02f, 3.14158052e-02f, 5.22760525e-02f,
  1.39188036e-01f, -4.93605388e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    