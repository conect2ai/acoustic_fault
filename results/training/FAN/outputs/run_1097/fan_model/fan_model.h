/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.66417515e-01f, 9.06167701e-02f, 3.08438271e-01f, -3.74995470e-01f, 1.32317856e-01f, 1.67623758e-01f, 2.21800730e-01f, 1.51389716e-02f, -2.10362628e-01f, 1.00862913e-01f,
  -4.97196503e-02f, -2.54307866e-01f, -1.54130936e-01f, 8.97132158e-02f, 1.26412347e-01f, 2.13686123e-01f, 2.64849842e-01f, 3.15156244e-02f, 3.20186503e-02f, -6.76112156e-03f,
  3.16184089e-02f, -2.20110059e-01f, -2.09919035e-01f, -1.35790691e-01f, -1.18093476e-01f, -1.31856158e-01f, 2.09478214e-01f, 3.28601804e-03f, -2.30890489e-03f, 4.42949869e-02f,
  5.64880483e-02f, -2.07754940e-01f, 4.78373803e-02f, -4.90798056e-02f, -4.07541953e-02f, -1.06399357e-01f, -1.12974383e-01f, -7.02999160e-02f, -7.64468312e-02f, -2.81977002e-02f,
  -1.28279105e-01f, -3.28116640e-02f, -9.88054425e-02f, -1.90083627e-02f, -8.33049864e-02f, -3.70471328e-02f, -2.47326698e-02f, 7.72675918e-03f, 6.05981201e-02f, -6.13928027e-02f,
  -5.11607826e-02f, -1.11441925e-01f, -3.38419229e-02f, 1.51277520e-02f, 9.08270758e-03f, 4.74223983e-04f, 7.92643651e-02f, 1.36378184e-02f, 8.49463511e-03f, -6.98291436e-02f,
  2.31424253e-02f, 7.89502263e-02f, 1.19363517e-01f, 1.77965388e-02f, 2.75600050e-02f, 3.37640829e-02f, -4.62803207e-02f, 1.15810156e-01f, 2.45336834e-02f, 5.81199154e-02f,
  5.88379428e-02f, 1.06778882e-01f, 5.99482991e-02f, 6.11898229e-02f, 4.08301217e-04f, 1.65154207e-02f, 1.09804295e-01f, 5.86672127e-02f, -1.79828554e-02f, 3.70191596e-02f,
  -5.72918467e-02f, -2.04557590e-02f, 4.03288826e-02f, 1.86435115e-02f, 1.28498733e-01f, 2.20206771e-02f, 3.29004601e-02f, 5.32665700e-02f, 2.10646330e-03f, 1.41021639e-01f,
  -8.51963311e-02f, 5.44093661e-02f, -1.82413667e-01f, -5.19875810e-02f, 1.50810918e-02f, -1.95635296e-02f, -5.94630279e-02f, -2.69187838e-02f, -1.04108490e-01f, -6.45586178e-02f,
  -1.75222568e-02f, -2.01108586e-02f, -4.00156938e-02f, -7.46908179e-03f, 1.81297213e-02f, -1.78744569e-02f, -6.45538941e-02f, -1.05430797e-01f, -2.46395934e-02f, -9.50186551e-02f,
  -7.14355856e-02f, -5.81541322e-02f, -5.75292744e-02f, -6.38512224e-02f, -1.19107254e-01f, -6.12993352e-02f, 8.41466859e-02f, 5.05399629e-02f, 3.71730067e-02f, 3.21598761e-02f,
  -1.55821666e-01f, -3.95142026e-02f, 3.63608688e-01f, 1.11795552e-01f, 1.27111644e-01f, 1.69774115e-01f, 1.15951173e-01f, 8.76683369e-02f, 1.31489724e-01f, 1.52142793e-01f,
  8.31108168e-03f, 8.24576169e-02f, 1.70176625e-01f, 1.59646869e-01f, 3.39121670e-01f, 2.82765836e-01f, 4.00007397e-01f, 4.34197247e-01f, 4.98803645e-01f, 2.82913685e-01f,
  1.29901975e-01f, 2.35756904e-01f, 2.81851202e-01f, 2.01582119e-01f, 1.22941434e-01f, 1.51913866e-01f, 7.39024654e-02f, 6.64094090e-02f, 4.57245298e-02f, 5.42570129e-02f,
  2.58330971e-01f, 1.15982518e-01f, 9.16047320e-02f, 6.37098625e-02f, 1.31194979e-01f, 1.80358395e-01f, 8.43030736e-02f, 2.36456126e-01f, 1.73309401e-01f, 1.89084977e-01f,
  9.29631479e-03f, 5.88391386e-02f, 2.51384318e-01f, 1.59931600e-01f, 1.54883146e-01f, 1.09839633e-01f, 1.80967718e-01f, 3.06047231e-01f, 2.89839625e-01f, 2.44162858e-01f,
  4.59770598e-02f, 5.78909591e-02f, 2.21352577e-01f, 1.54184505e-01f, 2.61881232e-01f, 1.83934346e-01f, 1.88495889e-01f, 1.91693038e-01f, 9.59771052e-02f, 5.89239523e-02f,
  -1.81154273e-02f, -1.34438306e-01f, -7.99451619e-02f, -2.33585481e-02f, -1.85586020e-01f, -8.04813057e-02f, 5.87698678e-03f, 2.35421862e-02f, -4.47551794e-02f, 1.82804733e-03f,
  -9.12879780e-02f, -3.64857912e-02f, -3.81846679e-03f, -5.11069261e-02f, -5.90658337e-02f, 1.68968942e-02f, -1.02089383e-01f, -2.01920182e-01f, -7.98706189e-02f, -1.84843600e-01f,
  -3.28486003e-02f, -6.71893284e-02f, -1.32925257e-01f, 6.71338886e-02f, -7.35723600e-02f, -2.67157126e-02f, -1.22586563e-01f, -8.82374719e-02f, -1.49166584e-01f, -7.96200186e-02f,
  2.21218541e-01f, 2.08448529e-01f, 5.16022183e-02f, 1.20907269e-01f, 5.16393930e-02f, 1.53945580e-01f, 8.76483619e-02f, 2.35250920e-01f, 5.78237474e-02f, 1.81676373e-01f,
  5.42626753e-02f, 9.76466537e-02f, 5.03578447e-02f, 1.74467508e-02f, 1.60735577e-01f, 1.09023340e-01f, 5.70290275e-02f, 1.81142062e-01f, 2.21136063e-01f, 1.42847314e-01f,
  1.69195339e-01f, 1.86708272e-01f, 8.54583383e-02f, 2.13108420e-01f, 9.10142586e-02f, 1.24265119e-01f, 3.17591615e-02f, 6.79760054e-02f, 1.31831884e-01f, 9.01319161e-02f,
  -5.40584922e-01f, 2.18462080e-01f, 1.26865610e-01f, -1.89708650e-01f, 2.26356685e-01f, -2.92378906e-02f, 1.54195175e-01f, 5.03723323e-02f, -7.86127001e-02f, 7.28074908e-02f,
  1.06962696e-01f, 1.15761589e-02f, -2.96779722e-02f, 5.80774434e-03f, -1.84142336e-01f, 5.36924228e-02f, -1.50128640e-02f, -2.17211410e-01f, -2.42817938e-01f, 8.39558989e-02f,
  1.19576519e-02f, -2.10774973e-01f, -3.86707634e-01f, -7.99220651e-02f, 1.41823962e-01f, 1.75345689e-02f, 5.62085621e-02f, 9.52932462e-02f, 1.26547173e-01f, -6.31329045e-02f,
  6.91344365e-02f, 5.22741601e-02f, 5.58972545e-02f, -2.66557913e-02f, 1.14263080e-01f, -1.27324685e-01f, -1.09386884e-01f, -3.99240665e-02f, 5.40448800e-02f, -6.22137673e-02f,
  -3.29812989e-03f, 2.60855034e-02f, 1.29168052e-02f, 3.46490890e-02f, -2.40011066e-02f, -1.34732649e-02f, 8.22064355e-02f, -8.54871199e-02f, -2.36667786e-02f, 1.04523107e-01f,
  6.21209480e-02f, -5.96619397e-03f, -3.78165022e-03f, 2.35020220e-02f, 2.08183918e-02f, -1.03766071e-02f, 6.42158315e-02f, 1.11784458e-01f, 1.03474930e-01f, 2.13522391e-04f,
  2.60843746e-02f, 2.55562514e-02f, -4.99475002e-02f, -4.93101589e-02f, 1.03191184e-02f, 2.71911863e-02f, -6.88726455e-03f, 6.45922497e-02f, 3.65615003e-02f, -1.22303374e-01f,
  9.52851921e-02f, 1.09180234e-01f, -3.48371714e-02f, -1.04690060e-01f, 1.93299185e-02f, 4.19321805e-02f, -3.02699953e-02f, -2.26017963e-02f, 1.94442514e-02f, -1.23745203e-02f,
  -4.49958220e-02f, 3.39923650e-02f, -1.17703669e-01f, -7.43421912e-02f, -1.11841038e-02f, -6.11114539e-02f, 1.02129495e-02f, 7.94989169e-02f, -8.83493200e-02f, -1.44689373e-04f,
  -1.03426740e-01f, 5.20588532e-02f, -3.40912603e-02f, 5.46735041e-02f, -6.63837940e-02f, 3.11962739e-02f, 5.28230444e-02f, 6.06336743e-02f, -2.33989097e-02f, -1.05317291e-02f,
  5.86785264e-02f, 8.77364166e-03f, -3.27193886e-02f, -8.08174014e-02f, -5.00694402e-02f, 4.66711782e-02f, 5.53384982e-02f, 2.53304541e-02f, 3.70033272e-02f, 1.44415736e-01f,
  -1.94240119e-02f, -4.76725325e-02f, -1.26103655e-01f, 1.30070262e-02f, 5.31815365e-02f, -4.62083705e-02f, -3.81003395e-02f, -8.25822353e-02f, -1.43931163e-02f, -1.55534074e-01f,
  -2.66562849e-01f, -2.64745921e-01f, 5.88322207e-02f, 1.26860276e-01f, 4.74413484e-02f, -8.54971409e-02f, -2.68705457e-01f, -1.22597024e-01f, 9.83317345e-02f, 1.32897845e-03f,
  -1.89326033e-01f, 3.64848785e-02f, 7.42676109e-02f, 5.62245958e-02f, 6.26717322e-03f, 7.12967813e-02f, 3.36714596e-01f, 1.66103676e-01f, 8.18800181e-02f, -2.08121389e-01f,
  -8.22137371e-02f, -7.41318539e-02f, -2.35837884e-02f, -1.02856886e-02f, 6.03358969e-02f, 9.81163383e-02f, 5.88417538e-02f, -4.42509577e-02f, -4.69549261e-02f, 2.19263583e-01f,
  5.29455692e-02f, -2.40379527e-01f, -4.22049174e-03f, -6.13026060e-02f, 1.90745629e-02f, -3.36782858e-02f, 4.67099324e-02f, -8.76762066e-03f, -5.49651757e-02f, 4.67320308e-02f,
  -6.96472079e-02f, -1.34815976e-01f, -3.15634347e-03f, -8.11254457e-02f, -2.04965025e-02f, -1.28327021e-02f, -9.07940716e-02f, 2.10747123e-02f, 4.22909893e-02f, -1.46453425e-01f,
  1.14237918e-02f, -1.31731719e-01f, -1.28057078e-01f, -6.11497499e-02f, -3.48414555e-02f, 5.81933744e-02f, -1.45972386e-01f, -9.79817063e-02f, 5.34644015e-02f, -6.14491962e-02f,
  3.63567695e-02f, 3.53807732e-02f, -1.96318850e-02f, 4.84300926e-02f, 6.66079745e-02f, 5.74698634e-02f, 8.83908663e-03f, -1.10717956e-02f, 1.12497672e-01f, -9.14029926e-02f,
  6.52436540e-02f, 3.15650925e-02f, 3.71307395e-02f, 9.39671844e-02f, 1.02042831e-01f, -2.51684915e-02f, -8.08836371e-02f, 6.92736432e-02f, 7.79590011e-03f, 4.81694657e-03f,
  4.53699002e-04f, 5.17696925e-02f, 8.38724896e-02f, 8.07129592e-02f, 5.34873456e-02f, -1.52845550e-02f, 4.85364050e-02f, -1.47803845e-02f, 6.91005811e-02f, -5.37189394e-02f,
  4.09480296e-02f, -5.31085208e-02f, 9.97564569e-02f, 8.55990723e-02f, -2.27169804e-02f, -7.38455728e-02f, 8.40333924e-02f, 1.22641355e-01f, 8.80121067e-03f, -1.39393117e-02f,
  -9.38740075e-02f, -4.34087254e-02f, 2.47873757e-02f, -3.89592350e-02f, -9.02143642e-02f, 9.31583643e-02f, -9.17552635e-02f, 7.58173093e-02f, -6.90786913e-02f, -1.87904052e-02f,
  -1.54638570e-02f, 5.74204065e-02f, 7.40916580e-02f, -4.06278819e-02f, -5.97333070e-03f, 3.65710557e-02f, -4.13129032e-02f, 3.29787955e-02f, -3.97811271e-02f, 6.57737851e-02f,
  3.27520281e-01f, -1.07824288e-01f, -1.12137599e-02f, -2.01776195e-02f, -1.35360686e-02f, 2.58745402e-01f, 5.12217022e-02f, 1.57538518e-01f, 7.86149129e-02f, 1.73813235e-02f,
  1.31035641e-01f, 1.45722255e-01f, 6.53101355e-02f, 1.73247263e-01f, 2.20465183e-01f, -1.15139797e-01f, -2.60112494e-01f, 6.43032268e-02f, 2.73729026e-01f, 9.32246000e-02f,
  4.11998900e-03f, -2.61632521e-02f, -2.48692650e-02f, -5.03623635e-02f, -2.59423673e-01f, -4.36935127e-02f, -2.01754004e-01f, -5.25281057e-02f, 6.24177344e-02f, -3.75360131e-01f,
  9.05544907e-02f, 2.05676690e-01f, 1.89419717e-01f, 1.22518778e-01f, 5.68198301e-02f, 1.13501638e-01f, 9.39775556e-02f, 1.73451304e-02f, 6.37094676e-02f, 3.21159661e-02f,
  3.79543495e-03f, 6.74723387e-02f, 1.07662767e-01f, 1.05067976e-01f, 5.93342632e-02f, 8.89468268e-02f, -1.77519419e-03f, 6.97645992e-02f, 9.81293023e-02f, 1.11848824e-02f,
  -2.90500931e-02f, -4.29942645e-02f, 2.68766395e-04f, -2.73990911e-02f, 1.11463502e-01f, 1.90496922e-01f, -7.81556685e-03f, 3.77193317e-02f, 1.25549540e-01f, -6.79986998e-02f,
  -5.92925586e-02f, -2.74392255e-02f, 2.02309769e-02f, -7.18975365e-02f, -1.34703647e-02f, -1.51954368e-01f, -1.07263967e-01f, -5.69300167e-02f, 5.48650548e-02f, -1.08490191e-01f,
  7.80697092e-02f, -3.83017361e-02f, -1.41612425e-01f, 2.89723538e-02f, -6.07884824e-02f, -1.19234689e-01f, 2.16745883e-02f, -2.70695216e-03f, -6.95832372e-02f, 1.38421031e-02f,
  1.66208018e-02f, -6.58883005e-02f, -1.18168682e-01f, -5.07507399e-02f, -6.59136474e-02f, -3.62112112e-02f, -8.81207064e-02f, -1.64919287e-01f, 1.52200740e-02f, -4.26162668e-02f,
  1.65609196e-01f, 1.68585524e-01f, 6.91997930e-02f, 1.27529234e-01f, 1.30543977e-01f, 1.31708220e-01f, 4.04945277e-02f, 2.82755587e-02f, 3.84160578e-02f, 5.71714379e-02f,
  2.58119613e-01f, 8.54569301e-02f, 1.61641121e-01f, 2.72826757e-02f, 1.66304380e-01f, 3.46059203e-02f, 4.45071161e-02f, 8.28708410e-02f, 1.03713475e-01f, 6.18507154e-02f,
  5.24018668e-02f, 2.07534686e-01f, 2.20203802e-01f, 1.17058948e-01f, 1.90706611e-01f, 1.53087839e-01f, 1.53078422e-01f, 1.87760219e-01f, 2.04443380e-01f, 7.71459639e-02f,
  2.36128271e-02f, 2.43596241e-01f, 3.01023901e-01f, -1.93874240e-02f, 1.69989005e-01f, 1.48183122e-01f, 2.32109964e-01f, 6.38459846e-02f, -8.20432678e-02f, 1.51085779e-01f,
  1.87784601e-02f, -1.29675329e-01f, 3.83920707e-02f, 6.07391223e-02f, -1.00989323e-02f, 2.60340869e-01f, 3.10276717e-01f, 1.68613225e-01f, -1.19130267e-02f, -8.12335238e-02f,
  -1.27531469e-01f, -1.00939922e-01f, -4.13071960e-02f, -1.17709152e-01f, 4.94379662e-02f, -1.92489717e-02f, 1.75280020e-01f, -9.38385203e-02f, -8.28366652e-02f, 1.99671254e-01f,
  2.03930825e-01f, 2.08430320e-01f, 8.10240731e-02f, 5.29822968e-02f, 3.50852087e-02f, -3.18527631e-02f, 3.94947939e-02f, 1.16639219e-01f, -1.65574299e-03f, -8.66336282e-03f,
  6.26152083e-02f, 5.92150092e-02f, -4.22531813e-02f, -2.96367914e-04f, -3.52578796e-02f, 1.01425029e-01f, -2.42087767e-02f, 1.21686608e-01f, 1.54534988e-02f, 8.71767849e-02f,
  1.33454073e-02f, 1.57157667e-02f, 4.55703698e-02f, 1.13541581e-01f, 7.19163520e-03f, 1.28071364e-02f, 2.35520862e-02f, 5.85443228e-02f, 1.05268411e-01f, 9.74488631e-02f,
  4.05367613e-02f, -2.96698101e-02f, -4.55980487e-02f, -6.78933784e-02f, -1.03336200e-01f, -7.41516873e-02f, -4.48958809e-03f, -1.27701998e-01f, -5.44577800e-02f, -7.08232522e-02f,
  -1.47062484e-02f, 3.82755324e-02f, -9.67597216e-02f, -2.72762664e-02f, 3.85703556e-02f, -3.77499014e-02f, -6.24417700e-02f, -1.48444414e-01f, -1.09095052e-01f, -5.37126027e-02f,
  -8.70277882e-02f, -1.40303999e-01f, -1.36834592e-01f, -1.44741470e-02f, -6.22115750e-03f, -8.55312496e-03f, -3.84772271e-02f, -3.22646089e-02f, -1.26717702e-01f, -4.12513576e-02f,
  -8.40937644e-02f, -3.23554426e-02f, 6.79844022e-02f, -2.55690981e-02f, -1.17060907e-01f, -9.89007354e-02f, 2.52025258e-02f, -1.28265321e-01f, -5.20914309e-02f, 6.34212941e-02f,
  3.10411714e-02f, 4.45441827e-02f, 7.65467584e-02f, -4.95129265e-03f, 6.41855821e-02f, -2.18495983e-03f, -4.96272966e-02f, 2.33921353e-02f, -1.07678603e-02f, 7.83949997e-03f,
  8.11136514e-02f, 5.92527213e-03f, 3.35163809e-03f, 9.68593210e-02f, 4.69007492e-02f, -2.74590999e-02f, 7.20222071e-02f, 4.17723283e-02f, -4.57718186e-02f, 5.53924255e-02f,
  3.29626292e-01f, -3.69915627e-02f, 2.56033480e-01f, 2.62319893e-02f, -6.79443404e-02f, 1.81271091e-01f, 4.81425859e-02f, 8.72817487e-02f, 1.47551997e-02f, -1.67860419e-01f,
  -1.20207161e-01f, -7.58064017e-02f, -7.14680413e-03f, 7.50174299e-02f, 2.15821415e-01f, 1.53535128e-01f, 1.32209346e-01f, 1.49196073e-01f, 1.37748525e-01f, -6.40117675e-02f,
  -1.70449957e-01f, 1.83402542e-02f, -1.50320679e-02f, 8.67860690e-02f, -1.12237737e-01f, -1.67874381e-01f, -3.33309658e-02f, -8.12582225e-02f, -1.51213720e-01f, 1.17369816e-01f,
  1.07181959e-01f, 3.31303984e-01f, 1.29036322e-01f, 8.70499015e-02f, 2.25666183e-04f, 2.37889707e-01f, 2.05920011e-01f, 1.52481705e-01f, 1.71817049e-01f, 1.11250699e-01f,
  7.27377683e-02f, 1.03534244e-01f, 1.56105042e-01f, -1.44059248e-02f, 5.49353249e-02f, 1.35748833e-01f, 1.05653703e-01f, 1.05312593e-01f, 1.47063836e-01f, 1.90192953e-01f,
  -3.16754021e-02f, 7.31822997e-02f, 1.14023060e-01f, 8.59070718e-02f, 1.52754262e-01f, 1.68742239e-01f, 6.74022138e-02f, 5.39125390e-02f, 1.49756357e-01f, 1.09752737e-01f,
  5.23928693e-03f, -4.29948345e-02f, -1.03377841e-01f, -6.24064133e-02f, -5.34629002e-02f, -4.56277765e-02f, 1.17050181e-03f, -1.07055478e-01f, -8.41012895e-02f, -3.02673280e-02f,
  -4.17779610e-02f, -6.23500235e-02f, -5.67074269e-02f, 7.67902136e-02f, -2.84992103e-02f, -5.51823992e-03f, -2.71113683e-02f, 4.80004363e-02f, -6.96228370e-02f, -5.03625348e-02f,
  3.10186855e-02f, -9.86238010e-03f, -4.56641689e-02f, -8.75748917e-02f, -5.49575910e-02f, 4.39525358e-02f, 5.75196072e-02f, -1.39538065e-01f, -7.27247726e-03f, -1.65901147e-03f,
  -1.84352905e-01f, 2.65779734e-01f, 2.18935553e-02f, 2.32774075e-02f, 1.24720417e-01f, 4.90504801e-02f, 1.78393379e-01f, 9.91707593e-02f, 6.54526651e-02f, 1.56153999e-02f,
  1.35618970e-01f, 5.59426136e-02f, 7.50727132e-02f, 7.59722218e-02f, 3.78724597e-02f, 4.34331335e-02f, -3.24129090e-02f, 3.43092196e-02f, 4.82135192e-02f, 4.39830385e-02f,
  -7.68407881e-02f, 8.74657929e-02f, 1.53294593e-01f, 3.88338007e-02f, 5.39755933e-02f, 1.19598739e-01f, 1.31226815e-02f, -2.05342937e-03f, 8.82796869e-02f, -8.02843943e-02f,
  2.62829930e-01f, -9.79234651e-02f, 8.20003897e-02f, 1.98391765e-01f, -1.27579600e-01f, -3.34970534e-01f, -4.45071071e-01f, -1.42207235e-01f, -3.89080349e-04f, -2.57810634e-02f,
  -1.11092642e-01f, -1.16103642e-01f, 9.86934006e-02f, -3.25262658e-02f, 6.06223475e-03f, 9.53743979e-02f, 9.80862007e-02f, 9.95076299e-02f, -1.26572177e-01f, -3.31574947e-01f,
  -1.55549884e-01f, 1.28488570e-01f, 1.85614139e-01f, -4.02651578e-02f, 1.39175355e-01f, -8.92729908e-02f, 9.29103494e-02f, 7.04322234e-02f, -2.49264389e-02f, 1.91411048e-01f,
  2.20185712e-01f, -1.48478732e-01f, -2.23979331e-03f, -1.72002297e-02f, 5.39074317e-02f, -3.37079763e-02f, -1.45064548e-01f, 9.22782496e-02f, 1.76179390e-02f, 5.45263477e-02f,
  5.39178476e-02f, -1.07566118e-01f, -1.01577617e-01f, 8.84030387e-02f, -4.15099338e-02f, -8.56578276e-02f, 9.58807990e-02f, 1.23506654e-02f, 9.22496896e-03f, 2.45876872e-04f,
  -4.23301458e-02f, -5.25365956e-02f, -1.14691012e-01f, -1.33857995e-01f, -5.42395702e-03f, 4.50206436e-02f, 3.93347219e-02f, -6.88255951e-02f, -1.02665514e-01f, 1.37403026e-01f,
  -8.25163051e-02f, -5.16896881e-02f, -3.68912295e-02f, -3.60612907e-02f, -1.52414247e-01f, -7.95488991e-03f, -1.56298501e-03f, 1.10079199e-02f, -4.07051928e-02f, 6.12498447e-03f,
  -5.74724302e-02f, 7.96723962e-02f, -8.77627358e-02f, 7.10765868e-02f, -6.98596537e-02f, -1.94456503e-02f, -2.15381384e-02f, 3.89919542e-02f, -3.65704764e-04f, -4.94143516e-02f,
  -3.58311087e-02f, -4.08693589e-02f, 1.44515699e-02f, -4.46886569e-02f, -4.41967994e-02f, -4.83580343e-02f, 4.31286991e-02f, -1.04247183e-01f, 3.08136959e-02f, -8.03093165e-02f,
  1.07321583e-01f, -2.87737455e-02f, -2.91730985e-02f, 3.58462892e-02f, -1.30721778e-02f, -9.39002857e-02f, -5.67260459e-02f, 8.48541632e-02f, 3.10822390e-02f, 2.43323036e-02f,
  2.35336982e-02f, 1.08524278e-01f, -4.85288817e-03f, 3.43304276e-02f, -1.33000473e-02f, 1.78783620e-03f, 1.56081254e-02f, -5.33907078e-02f, -4.23151590e-02f, -2.39202864e-02f,
  2.20149551e-02f, -1.00008868e-01f, -9.74861309e-02f, 1.27992025e-02f, 3.86230946e-02f, -5.23879081e-02f, -3.09737027e-02f, 1.89148895e-02f, -1.72760189e-02f, 8.65740627e-02f,
  -2.53808588e-01f, 2.32162029e-01f, -9.28656235e-02f, 1.07250335e-02f, -6.90722140e-03f, -9.98216718e-02f, -1.43716007e-01f, -4.23076227e-02f, 1.92104235e-01f, 1.44056424e-01f,
  2.51818925e-01f, 3.15858155e-01f, 2.73440719e-01f, 1.12854533e-01f, -4.76441830e-02f, 4.18379232e-02f, 1.01938378e-02f, -1.16158456e-01f, -2.10359126e-01f, 2.07587220e-02f,
  2.16034353e-01f, -2.29478348e-02f, 6.75805584e-02f, -2.08935998e-02f, 9.98925492e-02f, 2.58027762e-01f, 1.70232087e-01f, 1.29423678e-01f, 1.91413626e-01f, 1.15236901e-01f,
  -3.91975716e-02f, -1.30500630e-01f, 4.93021570e-02f, 1.20191634e-01f, 1.25485837e-01f, 1.51066333e-01f, 2.42530107e-02f, 1.05120922e-02f, 1.46550298e-01f, 1.13004893e-01f,
  1.16407230e-01f, 8.81224722e-02f, 7.27135539e-02f, 2.72744056e-02f, 4.31778729e-02f, 1.10358782e-02f, 1.10782739e-02f, 6.97312057e-02f, 4.93330173e-02f, 6.19098265e-03f,
  1.71984076e-01f, 6.41929358e-02f, -8.62569362e-02f, 8.68089274e-02f, 7.19119236e-02f, 6.25495091e-02f, -1.76045505e-04f, -1.19907251e-02f, -1.35731325e-02f, -6.69312780e-04f,
  -2.51664664e-03f, 3.66340652e-02f, -1.02480263e-01f, -5.39153591e-02f, -7.86943436e-02f, 5.27191535e-02f, -2.15127058e-02f, 2.34334338e-02f, -1.05019264e-01f, -1.47678107e-01f,
  -3.89343463e-02f, -1.15747467e-01f, -1.93155203e-02f, -1.22638650e-01f, -1.48958340e-02f, -4.62632738e-02f, -2.81132180e-02f, -1.11684389e-01f, -2.78877560e-02f, 3.68491188e-02f,
  -4.15926911e-02f, -1.19441852e-01f, -7.17072785e-02f, -1.42000705e-01f, -7.36460611e-02f, -2.30286598e-01f, -7.35537931e-02f, -1.42360806e-01f, -8.16139281e-02f, -5.65558076e-02f,
  1.08070746e-01f, 5.19178957e-02f, 1.62571564e-01f, -6.08674921e-02f, 1.46396914e-02f, 2.21654251e-01f, 1.19273864e-01f, 9.42693204e-02f, 1.04083627e-01f, 9.68790576e-02f,
  -4.04661596e-02f, -1.86697915e-02f, 6.43721595e-02f, 8.90147835e-02f, 2.17547715e-02f, 6.01119176e-02f, 1.23362996e-01f, 4.29885164e-02f, 1.50653899e-01f, 6.36191145e-02f,
  1.27868295e-01f, 2.14658286e-02f, 5.04289791e-02f, 4.74502295e-02f, 7.84517080e-02f, 1.60061866e-01f, 9.85177327e-03f, 5.72119094e-02f, 3.47653665e-02f, -1.11889308e-02f,
  2.52163887e-01f, 3.15890282e-01f, -1.23075679e-01f, 2.19315574e-01f, 3.44294570e-02f, -1.27326816e-01f, -3.00026722e-02f, -4.53313217e-02f, 1.54665649e-01f, 1.75252065e-01f,
  9.14490670e-02f, 1.75772086e-02f, -9.55731869e-02f, -1.58940673e-01f, -6.54912144e-02f, -9.45452135e-03f, 7.65089318e-02f, -1.71335384e-01f, -4.31262612e-01f, -1.55189037e-01f,
  9.85261649e-02f, 1.38409957e-01f, 1.44162878e-01f, -5.45783676e-02f, 1.33361459e-01f, 1.38116134e-02f, 6.86802641e-02f, 1.15238383e-01f, 9.53689888e-02f, 2.72076637e-01f,
  1.27222061e-01f, 2.23704264e-01f, -6.59702644e-02f, -1.49526400e-02f, 7.56719410e-02f, 3.62188183e-02f, -7.91493710e-03f, 3.58536392e-02f, -5.53630525e-03f, -5.14562018e-02f,
  7.15290895e-03f, 5.89176118e-02f, -2.50328649e-02f, 4.96125370e-02f, -2.19203588e-02f, 3.25311832e-02f, 1.20897247e-02f, -6.85583800e-02f, -4.36954834e-02f, 1.83807046e-03f,
  1.39499037e-02f, 5.78627326e-02f, -6.85962662e-02f, -6.32029697e-02f, -9.83557571e-03f, -7.03837946e-02f, -5.06130792e-02f, 6.49347529e-02f, -1.53988689e-01f, 3.18910927e-02f,
  -1.44771012e-02f, -9.67938080e-03f, 9.07430984e-03f, 6.40316540e-03f, 1.06147053e-02f, -3.31729650e-02f, 7.13287219e-02f, 6.92368001e-02f, -6.14435785e-02f, -6.92660064e-02f,
  -7.69885555e-02f, -9.02446434e-02f, 3.04421633e-02f, 4.89422195e-02f, -3.01843788e-02f, 2.98403222e-02f, 4.95861061e-02f, 4.91701402e-02f, 5.11863418e-02f, 8.14108998e-02f,
  -8.92881211e-03f, -5.41265011e-02f, -1.97490770e-02f, -8.40467587e-02f, -3.95199805e-02f, -1.93207506e-02f, 1.20152393e-02f, -5.69457607e-03f, 6.86311573e-02f, -1.01105897e-02f,
  1.72315210e-01f, -1.55449167e-01f, 1.48353010e-01f, 6.27300367e-02f, -2.07199994e-02f, 6.81773350e-02f, 1.55979231e-01f, -1.62785444e-02f, 1.04279637e-01f, -2.79205125e-02f,
  9.98567343e-02f, 1.75543621e-01f, 1.11052416e-01f, 3.04829869e-02f, 4.26824838e-02f, -2.17821859e-02f, 8.04108903e-02f, 1.16851758e-02f, -5.32009825e-02f, 2.15263925e-02f,
  2.17017555e-03f, -5.71663491e-02f, 3.76662007e-03f, -4.31517735e-02f, -2.52266619e-02f, -4.93360721e-02f, 7.15705305e-02f, -1.19255083e-02f, -1.06169529e-01f, 8.46472085e-02f,
  4.43349928e-01f, -2.97605962e-01f, -1.69347882e-01f, -3.42732742e-02f, -1.76930100e-01f, -1.15271844e-01f, -3.88095528e-01f, -6.79076463e-02f, -2.80174147e-02f, -1.25170186e-01f,
  -5.84532507e-02f, 1.58720896e-01f, 1.62961274e-01f, 8.21588933e-02f, 1.32748246e-01f, -1.73288181e-01f, -1.42601758e-01f, 2.55309105e-01f, 2.45006293e-01f, -9.76510812e-04f,
  2.60554757e-02f, 1.41777664e-01f, 3.30366045e-01f, 8.22263584e-02f, -1.58670768e-01f, 1.83231428e-01f, -1.00020573e-01f, -4.18604501e-02f, -8.64176303e-02f, -1.21685922e-01f,
  3.95345911e-02f, -1.99842125e-01f, -4.57332805e-02f, -6.13313764e-02f, -1.67825371e-01f, -7.97175523e-03f, -9.17033777e-02f, -1.47213593e-01f, -1.40741304e-01f, -9.65138674e-02f,
  -1.44144714e-01f, -1.15318343e-01f, -3.49978381e-03f, -1.09616697e-01f, -1.80066094e-01f, -1.23266727e-01f, -4.07874621e-02f, 8.64116922e-02f, 1.63293891e-02f, -1.39240339e-01f,
  -1.00585058e-01f, -1.65586293e-01f, -1.30180761e-01f, -1.23442896e-01f, -4.65338752e-02f, 1.61852892e-02f, -1.96292430e-01f, 2.01849304e-02f, -1.12876654e-01f, -1.10073403e-01f,
  -8.45484138e-02f, 1.30446805e-02f, 6.24948032e-02f, 2.84711481e-04f, 5.69464676e-02f, -4.69061881e-02f, 1.14203745e-03f, 2.25901343e-02f, 5.71820252e-02f, 1.01152740e-01f,
  -2.37473119e-02f, 7.88893774e-02f, 4.72896695e-02f, -7.11194873e-02f, 7.38939345e-02f, -3.07252202e-02f, 5.29771671e-02f, 1.70287043e-02f, 5.18005267e-02f, 3.60070989e-02f,
  1.29096070e-02f, 5.91331273e-02f, 1.87676344e-02f, 9.30795297e-02f, 9.35206283e-03f, -2.83468030e-02f, 1.31692514e-01f, 1.24275098e-02f, 7.14660883e-02f, -1.46175567e-02f,
  3.34059000e-02f, -3.25543098e-02f, -4.84316088e-02f, -3.65366675e-02f, -3.11743356e-02f, -9.70978066e-02f, -1.95777174e-02f, -3.13884653e-02f, -6.98055848e-02f, 7.29837967e-03f,
  -9.49955806e-02f, 5.60571738e-02f, -3.52258347e-02f, -4.84107062e-02f, -1.08570442e-01f, -4.81915660e-02f, -9.58132148e-02f, 2.73180678e-02f, -1.83751751e-02f, -9.25928354e-02f,
  -1.29745767e-01f, -1.62025645e-01f, -8.23944435e-02f, -7.33903199e-02f, 1.69981830e-02f, 7.73222446e-02f, -9.72901955e-02f, -1.17472142e-01f, 3.25175561e-02f, -2.03214899e-01f,
  3.65210384e-01f, -8.77171382e-02f, -2.69344170e-02f, 7.89134484e-03f, -2.77986497e-01f, -1.67650729e-01f, -1.62115712e-02f, 2.18920074e-02f, -1.36086553e-01f, -3.96471322e-02f,
  -7.74843320e-02f, -2.36314330e-02f, -2.57832818e-02f, -4.10754941e-02f, 1.41276032e-01f, 4.32953937e-03f, -8.97332057e-02f, 1.24712482e-01f, -4.78378199e-02f, -1.05847292e-01f,
  -1.37641847e-01f, -1.50970384e-01f, 9.52982679e-02f, -8.15459192e-02f, -9.46006700e-02f, -1.46257862e-01f, -1.09528728e-01f, -5.27131893e-02f, -2.33540937e-01f, -1.61705002e-01f,
  3.44899371e-02f, -2.47523729e-02f, -1.41271576e-01f, -1.09626904e-01f, -2.05952540e-01f, -1.93485931e-01f, -2.42884099e-01f, -1.24254234e-01f, -2.74307489e-01f, -1.38819948e-01f,
  -1.97373495e-01f, -1.55012175e-01f, -1.27129406e-01f, -6.05039150e-02f, -1.53595895e-01f, -1.50553018e-01f, -1.16336577e-01f, -1.09314501e-01f, -7.67837241e-02f, -1.83883145e-01f,
  -1.23370938e-01f, -2.79921085e-01f, -1.34667560e-01f, -1.83076814e-01f, -9.24477652e-02f, -1.11295260e-01f, -2.21371368e-01f, -1.24649025e-01f, -9.90602151e-02f, -1.44582033e-01f,
  -2.27302723e-02f, 1.19065493e-01f, 9.72146466e-02f, 1.34262443e-01f, 1.63637653e-01f, 1.56580657e-01f, 1.63101062e-01f, 9.62323695e-02f, 1.47273600e-01f, 1.89121917e-01f,
  8.22871029e-02f, 6.98562488e-02f, 8.83751512e-02f, 7.17564970e-02f, 2.22360045e-01f, 1.92535147e-01f, 1.88703492e-01f, 1.02430098e-01f, 1.02240205e-01f, 1.14019550e-01f,
  1.46488309e-01f, 8.43028426e-02f, 9.30860266e-02f, 7.49059245e-02f, 2.29723468e-01f, 2.41258770e-01f, 2.12412313e-01f, 1.98847711e-01f, 1.62099659e-01f, 8.21740031e-02f,
  1.17198020e-01f, -6.66125044e-02f, -5.23406342e-02f, -2.04893887e-01f, -1.81989372e-01f, -1.20890081e-01f, 1.11904610e-02f, -1.19520001e-01f, -1.62453532e-01f, -1.53873578e-01f,
  -1.40905946e-01f, -4.28409129e-02f, -7.51973689e-02f, -1.35622576e-01f, -1.58487082e-01f, -1.46107212e-01f, -9.60234180e-02f, -7.20086098e-02f, -1.03956975e-01f, -2.00746328e-01f,
  -3.03691830e-02f, -5.69765531e-02f, 1.91164520e-02f, -2.40669847e-02f, -2.13952199e-01f, -1.13164999e-01f, -7.48554543e-02f, -2.89645549e-02f, 3.44449989e-02f, 3.73751447e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.83774853e-01f, 1.03071402e-03f, -2.99078971e-01f, 2.96038628e-01f, -4.52237623e-03f, -2.65753806e-01f, -2.56351441e-01f, -1.54260816e-02f, 1.56304896e-01f, -6.42457902e-02f,
  -1.76849514e-01f, -1.04063801e-01f, -1.21188499e-01f, -3.52917373e-01f, -5.65311372e-01f, -4.52245444e-01f, -2.51479030e-01f, -3.59396905e-01f, -4.42135990e-01f, -1.41571522e-01f,
  -8.07014033e-02f, -9.77688208e-02f, -1.44973278e-01f, -7.25288615e-02f, 1.32079825e-01f, -1.04226030e-01f, 4.84031476e-02f, 6.75393492e-02f, -4.01727706e-02f, 9.25992355e-02f,
  -2.25053534e-01f, 4.46532369e-02f, -1.62662283e-01f, -1.35171385e-02f, 3.35864536e-02f, 1.49021577e-03f, -6.80290684e-02f, -1.24267198e-01f, 3.35071571e-02f, -4.61649820e-02f,
  -1.53322205e-01f, 1.39545068e-01f, -2.73201466e-02f, -9.84906703e-02f, -2.02996418e-01f, -6.67156130e-02f, 2.80405618e-02f, -1.28015175e-01f, -1.49728850e-01f, 5.03770486e-02f,
  3.30075137e-02f, -2.67737418e-01f, -1.16572157e-01f, -3.29411142e-02f, -1.69938743e-01f, -1.21364847e-01f, 1.04255052e-02f, -2.23040618e-02f, -1.89276427e-01f, 2.53732115e-01f,
  1.49422884e-01f, 1.80413276e-02f, 4.83333925e-03f, 1.62690282e-01f, 2.68834690e-03f, -2.30163448e-02f, -3.42412665e-02f, 9.45366174e-03f, 3.55418101e-02f, -8.92625749e-03f,
  -8.35996214e-03f, -5.92468306e-02f, -3.80874686e-02f, 9.71154943e-02f, -7.52301738e-02f, -6.11744486e-02f, -6.08138442e-02f, -1.19239636e-01f, -3.18122283e-02f, -5.05976006e-03f,
  -3.42782997e-02f, 9.26761329e-02f, 5.80838248e-02f, 4.39413078e-03f, -1.54959694e-01f, 4.61739395e-03f, -9.41280872e-02f, -2.05711812e-01f, -2.41943691e-02f, -1.22472212e-01f,
  1.67573154e-01f, -3.81789804e-01f, -8.64221081e-02f, -9.73735824e-02f, -1.61548093e-01f, 2.84244888e-03f, -6.49732188e-04f, -4.98389378e-02f, 1.39968798e-01f, -1.29150704e-01f,
  -1.83248773e-01f, -1.71847120e-02f, -8.26189667e-02f, 1.16483331e-01f, 6.22571036e-02f, -8.72435346e-02f, -4.88797389e-02f, -1.00360081e-01f, -6.72748163e-02f, 8.08976516e-02f,
  1.40358340e-02f, -1.31062239e-01f, 7.54574016e-02f, 3.57345003e-03f, 1.18106797e-01f, -6.33998439e-02f, -2.77722161e-02f, -4.27070968e-02f, -2.13241428e-01f, 6.57067671e-02f,
  3.51285815e-01f, 1.41293347e-01f, 8.92694518e-02f, -7.35241454e-03f, -3.11475962e-01f, -4.54797000e-01f, -2.57788867e-01f, -2.17353866e-01f, -1.22802354e-01f, -8.93946066e-02f,
  -9.11962315e-02f, -1.18985079e-01f, 3.16565880e-03f, 2.92879809e-02f, 4.73419540e-02f, 2.22869471e-01f, 2.44704857e-01f, 1.25859961e-01f, 9.50487256e-02f, -1.38763577e-01f,
  -1.07074253e-01f, 2.09541824e-02f, 1.94059744e-01f, 7.37259388e-02f, 2.16572568e-01f, -1.20500438e-02f, 2.18653097e-03f, 5.11825010e-02f, -1.45522682e-02f, 3.50079715e-01f,
  9.40772444e-02f, 1.57853160e-02f, -8.44659433e-02f, 1.79209098e-01f, 3.64887752e-02f, 1.09105580e-01f, -6.16858602e-02f, 1.21697590e-01f, -1.45092994e-01f, -1.00138277e-01f,
  1.94094367e-02f, -3.50425541e-02f, 3.32014076e-02f, -3.19796801e-02f, -9.62515771e-02f, -2.31747590e-02f, 1.70890257e-01f, 8.46893042e-02f, 1.40541762e-01f, -3.58132496e-02f,
  -6.09842166e-02f, -9.44140553e-02f, -1.91489741e-01f, -1.69994578e-01f, -4.20533940e-02f, -9.35886800e-02f, -1.71105742e-01f, 4.70716171e-02f, -3.95454057e-02f, 3.88066806e-02f,
  -6.68768138e-02f, 9.21223983e-02f, 2.89546847e-02f, -1.10343412e-01f, -1.39034867e-01f, -1.95607916e-01f, -3.91975325e-03f, -1.17464162e-01f, -5.09466529e-02f, -4.45052944e-02f,
  2.27210950e-02f, 7.71903098e-02f, -7.98836201e-02f, -3.99676152e-02f, -6.81111291e-02f, 1.49761774e-02f, -8.01218301e-02f, -2.74130013e-02f, -4.11020368e-02f, -7.31493831e-02f,
  4.49560918e-02f, -1.49057480e-02f, -4.87112328e-02f, 7.04195648e-02f, -5.85749783e-02f, -5.14157824e-02f, -1.08758107e-01f, -1.19007483e-01f, 5.38537353e-02f, -3.63196991e-02f,
  -2.26416975e-01f, -3.20600927e-01f, 4.24627289e-02f, 2.49907315e-01f, 1.52056471e-01f, -7.70273479e-03f, 5.97393513e-02f, 1.19289771e-01f, -5.07575832e-03f, 2.71765515e-02f,
  1.09016672e-01f, 1.03785478e-01f, 6.18006587e-02f, 2.26888955e-02f, 1.89604349e-02f, -5.75942686e-03f, 1.38688058e-01f, 1.37102142e-01f, 8.16981047e-02f, -5.11830002e-02f,
  9.59343389e-02f, -1.71012267e-01f, -1.85308650e-01f, -9.15180445e-02f, -1.82418227e-02f, -1.78972960e-01f, -1.48126274e-01f, -1.29591689e-01f, -1.97113261e-01f, -1.41415030e-01f,
  6.14716625e-03f, -1.40382543e-01f, 2.93443114e-01f, 3.29830535e-02f, -1.77805379e-01f, -3.06602895e-01f, -5.76638758e-01f, -3.49970251e-01f, -1.68399155e-01f, -1.33866489e-01f,
  -2.01674610e-01f, -1.26822874e-01f, 7.04551339e-02f, -3.84108610e-02f, -1.14591578e-02f, 1.40812740e-01f, 3.58753622e-01f, 2.82203764e-01f, 7.15721101e-02f, -3.17232311e-01f,
  -8.33652690e-02f, 8.42725039e-02f, 2.46457547e-01f, 2.33357787e-04f, 4.35513370e-02f, 7.07905293e-02f, 1.90218508e-01f, 1.49162322e-01f, 9.42392051e-02f, 5.32023549e-01f,
  3.07581723e-01f, -8.81103203e-02f, 7.27673853e-03f, 9.95136574e-02f, 2.20788673e-01f, 7.36282468e-02f, 2.31065378e-02f, 3.08931291e-01f, -1.15281614e-02f, 4.75097895e-02f,
  1.67091146e-01f, -1.30623719e-02f, -6.11346401e-02f, 8.16622302e-02f, -3.59598473e-02f, -1.33310873e-02f, 1.21140011e-01f, 7.75024220e-02f, 2.60740876e-01f, -3.97193767e-02f,
  -1.88700408e-01f, -1.04812220e-01f, -1.51221111e-01f, -1.23403177e-01f, -1.49839548e-02f, 5.49311787e-02f, -9.07430872e-02f, -1.92175582e-02f, -4.10992019e-02f, 6.94453642e-02f,
  -2.00167596e-02f, 1.31015910e-03f, -1.27655233e-03f, 5.32678962e-02f, -1.33807316e-01f, -5.77906668e-02f, 6.37923852e-02f, 1.54416524e-02f, -3.06409523e-02f, -5.84451221e-02f,
  7.83989131e-02f, -5.76624321e-03f, -2.10215840e-02f, -6.09008111e-02f, 5.68913594e-02f, 1.25598058e-01f, -6.52597621e-02f, 1.92493454e-01f, -1.32854944e-02f, 2.83090230e-02f,
  1.86963957e-02f, 5.48285507e-02f, 1.09681539e-01f, -3.02717574e-02f, 4.20069210e-02f, 9.96196270e-02f, -1.56720653e-02f, 4.28429320e-02f, 1.07692279e-01f, 1.80005804e-02f,
  -1.13761760e-01f, -2.61081988e-03f, 8.91039819e-02f, 7.11759776e-02f, -4.19846773e-02f, 2.51380615e-02f, -2.70316079e-02f, 1.71496738e-02f, 8.07468221e-02f, -3.30958515e-02f,
  -1.40134901e-01f, -7.74862394e-02f, 6.04227511e-03f, -1.40709179e-02f, -4.62918878e-02f, 4.49877381e-02f, -1.21771038e-01f, -5.82254343e-02f, -1.11168601e-01f, -3.49328779e-02f,
  -8.73553008e-02f, -2.77772784e-01f, -4.05930489e-01f, -1.64703518e-01f, -1.04781926e-01f, -2.68545240e-01f, -1.09840371e-02f, -2.88452238e-01f, -1.99714512e-01f, -4.20519739e-01f,
  8.35884809e-02f, 3.01229179e-01f, 2.38374710e-01f, -1.71647102e-01f, 1.17937826e-01f, 5.56403138e-02f, 2.63208717e-01f, -1.51872281e-02f, -3.40082705e-01f, 1.34064019e-01f,
  7.50133768e-02f, -2.85215765e-01f, -6.86929226e-02f, -1.96133852e-01f, -8.57275277e-02f, 1.96196288e-01f, 4.08393256e-02f, -1.08102731e-01f, -3.12048972e-01f, -2.49821365e-01f,
  -1.38310939e-01f, -3.47704515e-02f, -2.19585132e-02f, -1.80419564e-01f, 1.04543500e-01f, -1.82671428e-01f, 1.09026127e-01f, 9.75594521e-02f, 1.30925313e-01f, 2.08887279e-01f,
  1.82104498e-01f, 4.66181487e-01f, -2.29245216e-01f, -2.06475899e-01f, 3.04134972e-02f, -1.28361583e-01f, 2.89909802e-02f, 1.54390752e-01f, 6.76449463e-02f, -3.57873328e-02f,
  1.26168653e-01f, -3.26399952e-02f, 1.22666381e-01f, 1.54056260e-02f, -1.12080097e-01f, -7.79586807e-02f, -1.03429660e-01f, -7.60654360e-02f, -7.99647346e-02f, -9.30289552e-02f,
  -1.02886893e-01f, 1.82763766e-02f, 1.97858259e-01f, 2.06735767e-02f, 1.68396290e-02f, -9.54688340e-02f, -2.58602127e-02f, 2.37628818e-02f, -2.01418903e-02f, -1.12373069e-01f,
  -5.63603938e-02f, 9.29441825e-02f, 4.42671664e-02f, 3.20147537e-02f, -1.30913302e-01f, -2.60540433e-02f, -1.91711001e-02f, -1.07452311e-01f, -3.55563015e-02f, -7.75103793e-02f,
  6.97883889e-02f, 4.58844714e-02f, -2.24346370e-02f, 9.29847062e-02f, 2.27452144e-02f, 4.48092185e-02f, -8.15136209e-02f, 7.49946292e-03f, 4.30350974e-02f, -1.60402119e-01f,
  -7.73869082e-02f, -2.80162524e-02f, 2.79411674e-03f, 1.88691132e-02f, -7.53989369e-02f, -3.26825902e-02f, 6.12623654e-02f, -6.72011673e-02f, -1.09779788e-02f, 1.70422688e-01f,
  -2.32081980e-01f, 2.59892680e-02f, -1.55281559e-01f, -6.70447275e-02f, 9.18517038e-02f, 3.63441296e-02f, 1.73257768e-01f, 1.62832409e-01f, 5.69896102e-02f, 5.97085357e-02f,
  1.13829859e-01f, 7.36736432e-02f, 6.76280335e-02f, -1.97360124e-02f, -9.22365636e-02f, 9.00332555e-02f, 1.24145309e-02f, -1.19311988e-01f, -1.92001939e-01f, -5.21276966e-02f,
  -8.79316106e-02f, -2.17378438e-01f, -1.35341346e-01f, -7.33589679e-02f, -1.34694964e-01f, -3.15186650e-01f, -4.96748537e-02f, -1.66656420e-01f, -6.58517182e-02f, -3.05749238e-01f,
  5.39475024e-01f, 2.05852911e-01f, 1.50245354e-01f, 1.37217328e-01f, -9.68731344e-02f, 5.22631817e-02f, 6.41824454e-02f, 4.17374708e-02f, -3.15778032e-02f, 3.78164127e-02f,
  1.00371480e-01f, 4.28652465e-02f, -9.45660099e-03f, 7.13282451e-02f, 1.28361508e-01f, -8.81292112e-03f, -9.40235853e-02f, 1.13038555e-01f, -5.46225905e-03f, 1.63185641e-01f,
  -1.01020873e-01f, -3.41255032e-02f, 2.15023413e-01f, 7.48135969e-02f, -1.10190688e-02f, 1.07778795e-02f, 1.44379763e-02f, 5.41060455e-02f, -3.66835408e-02f, 7.55887181e-02f,
  1.33200005e-01f, 2.17589051e-01f, -8.72895569e-02f, -2.01191425e-01f, -1.31881312e-01f, -1.51282638e-01f, 1.14851836e-02f, -1.55288249e-01f, -8.06140974e-02f, -1.52284540e-02f,
  -6.82078451e-02f, -5.74574992e-02f, -1.62262768e-01f, -2.05192957e-02f, -8.87509510e-02f, -4.82239649e-02f, -6.43590167e-02f, 1.43211409e-01f, 6.45207688e-02f, 5.44999652e-02f,
  1.59034673e-02f, -1.27155080e-01f, -9.70008522e-02f, 8.54839012e-03f, 1.47013944e-02f, -3.93690541e-02f, 1.73938442e-02f, 1.12204313e-01f, 8.30557495e-02f, 1.19473541e-03f,
  1.01446599e-01f, 9.22587588e-02f, 4.56711315e-02f, 1.60786778e-01f, 7.08207637e-02f, -2.20712218e-02f, -4.97044660e-02f, -7.13700522e-03f, 7.29857609e-02f, -4.83457651e-03f,
  2.58776713e-02f, 1.02186278e-01f, -2.77334843e-02f, 6.71346635e-02f, 6.85672611e-02f, 7.63503388e-02f, -1.43521726e-01f, 6.55530766e-02f, -3.00097335e-02f, -8.61404687e-02f,
  7.17386752e-02f, 2.73832697e-02f, -8.52313042e-02f, 9.57148001e-02f, 7.50706047e-02f, 1.28068635e-02f, -1.19194100e-02f, -1.79188848e-02f, -7.86121488e-02f, 5.75856538e-03f,
  -3.09244275e-01f, -2.08018303e-01f, 5.90448566e-02f, -6.31852150e-02f, -7.22606406e-02f, -1.83255658e-01f, -4.05594381e-03f, -5.92364296e-02f, -9.14582238e-02f, -9.36567858e-02f,
  6.06905334e-02f, 8.26085955e-02f, -6.80281147e-02f, -9.15239081e-02f, -1.31478816e-01f, -1.91016495e-01f, -9.70848501e-02f, -1.86426621e-02f, -2.76211817e-02f, -1.07840821e-02f,
  -9.46352109e-02f, 1.11223469e-02f, -3.86271253e-02f, 2.93846149e-03f, 4.70829830e-02f, -5.27880155e-02f, -1.58983305e-01f, -1.70305043e-01f, -1.45749614e-01f, 1.01163099e-02f,
  -4.28850800e-01f, 9.60915610e-02f, -3.01477145e-02f, -5.12328625e-01f, -3.54491174e-01f, -2.44076714e-01f, -6.35489747e-02f, -7.47359470e-02f, -3.74516994e-01f, -1.37937814e-01f,
  7.96790570e-02f, 2.32691959e-01f, 7.71879926e-02f, 2.59883106e-01f, 1.22008473e-01f, 2.51500886e-02f, -2.89386392e-01f, -1.43354952e-01f, 9.20936093e-02f, 5.42007461e-02f,
  -3.93467722e-03f, -9.66816396e-02f, -8.80026743e-02f, -3.34122851e-02f, -1.57305211e-01f, 3.86016667e-02f, -2.64344886e-02f, -2.35298216e-01f, -1.06008612e-01f, -2.73170114e-01f,
  3.70236099e-01f, -2.43670776e-01f, -8.38123709e-02f, -4.03062366e-02f, -1.56071121e-02f, -7.29886219e-02f, -2.51880866e-02f, -1.33638903e-01f, -2.06819344e-02f, 4.04434539e-02f,
  -1.25826761e-01f, -4.96844202e-02f, -1.33862265e-03f, 8.61454010e-02f, -3.98704708e-02f, -5.09285219e-02f, -5.36303781e-03f, -1.16654932e-01f, -1.22980170e-01f, 7.05381110e-02f,
  8.75339955e-02f, -6.50751144e-02f, -1.15245342e-01f, 2.37163361e-02f, -1.17920125e-02f, -1.14130475e-01f, 1.34492084e-01f, -4.17540930e-02f, -2.38723401e-02f, -9.24375188e-03f,
  3.64342406e-02f, -9.13303420e-02f, 4.53326032e-02f, -7.63421431e-02f, 1.09569179e-02f, 8.46743658e-02f, 4.59915772e-02f, 7.46111944e-02f, 1.00506224e-01f, 1.23805672e-01f,
  -4.50676866e-02f, -1.04767025e-01f, -1.02732897e-01f, -8.00926611e-02f, 2.90412437e-02f, -1.38573870e-01f, -8.42034221e-02f, -2.95771342e-02f, 8.83361045e-03f, -1.56295940e-01f,
  -1.50609419e-01f, -1.02223262e-01f, -7.80293718e-02f, -3.49121392e-02f, -2.02375785e-01f, -1.55432448e-01f, -6.83065057e-02f, -4.18191142e-02f, -8.64527673e-02f, -3.43250148e-02f,
  2.46364951e-01f, -1.59144342e-01f, -4.63065878e-02f, -1.30191101e-02f, -1.05405025e-01f, -1.31162003e-01f, -1.65231153e-02f, -7.69695640e-02f, -7.74957389e-02f, -1.57863665e-02f,
  -9.13041681e-02f, 6.04343005e-02f, 6.42510280e-02f, -1.09994272e-02f, -2.88199857e-02f, 6.09290600e-03f, -3.75637114e-02f, 9.84112546e-02f, 7.89944455e-03f, 4.37489934e-02f,
  -1.26309320e-02f, -8.15958679e-02f, 7.87945539e-02f, 6.99749887e-02f, 7.39931827e-03f, 7.42885098e-02f, 2.23972216e-01f, 1.08855098e-01f, 1.24353282e-01f, 1.26007095e-01f,
  -4.25947219e-01f, 5.73728792e-03f, 4.81645577e-02f, 9.39115807e-02f, 1.39917031e-01f, -1.05593324e-01f, -1.28264710e-01f, -1.82278663e-01f, -2.36010961e-02f, -1.21760502e-01f,
  -1.51593834e-01f, -1.11116104e-01f, -9.16526001e-03f, 8.65226611e-02f, -4.54487801e-02f, 1.65115342e-01f, 3.56919467e-01f, 1.89433604e-01f, 7.47812837e-02f, -3.11027765e-02f,
  5.42822480e-02f, 7.42216110e-02f, -9.18120146e-02f, 3.67074572e-02f, 1.08983837e-01f, 8.55803862e-02f, 5.29315397e-02f, 5.32412790e-02f, 3.59146148e-02f, 4.18873131e-01f,
  -2.19916716e-01f, -1.36851773e-01f, 1.05246216e-01f, 2.87956349e-03f, 6.57232851e-02f, -1.29092529e-01f, 1.73176806e-02f, 9.91793722e-03f, -4.13778946e-02f, -8.87337849e-02f,
  -3.51311825e-02f, -3.48767079e-02f, 4.09763632e-03f, 8.13034712e-04f, 7.43864011e-03f, 1.96379572e-02f, 4.44725119e-02f, 3.32062244e-02f, -2.24433616e-01f, -5.32391891e-02f,
  1.96501315e-01f, -7.44036660e-02f, -1.12583622e-01f, 4.38414961e-02f, -3.11675426e-02f, 3.13664030e-04f, -8.48111212e-02f, 9.90131404e-04f, -1.52021497e-01f, -6.47419691e-02f,
  9.95851904e-02f, 5.81145175e-02f, 8.78203511e-02f, 6.68769851e-02f, -7.26953847e-03f, 9.20756534e-03f, 2.16324806e-01f, 1.19048029e-01f, 1.00112788e-01f, 1.11305155e-02f,
  -8.85192119e-03f, -2.59735901e-02f, -1.07165895e-01f, 2.41035149e-02f, 9.02422071e-02f, -1.43347736e-02f, 1.99720114e-01f, 9.34116319e-02f, -3.10824951e-03f, 4.15567383e-02f,
  1.06468193e-01f, -3.68413283e-03f, 7.68158436e-02f, -2.27807257e-02f, 1.41935479e-02f, 9.19863805e-02f, 1.09837092e-01f, 3.19637991e-02f, -8.76637101e-02f, 4.88327891e-02f,
  -1.62619993e-01f, 5.59051782e-02f, 1.21773131e-01f, 7.66238496e-02f, 3.47898975e-02f, -3.34099419e-02f, 7.47647509e-02f, 4.84824739e-02f, 1.37765512e-01f, -1.17405698e-01f,
  -7.23835379e-02f, -3.03595290e-02f, -2.01731622e-02f, -8.22068453e-02f, -2.25850940e-02f, -9.37776417e-02f, 6.79818913e-02f, -1.21180061e-02f, -3.72060537e-02f, -3.23293731e-02f,
  -3.89015600e-02f, -1.81642488e-01f, -1.75818160e-01f, -7.00986311e-02f, -1.49438068e-01f, 1.43476687e-02f, -1.22744858e-01f, -2.81533506e-02f, -9.86592919e-02f, -1.35946915e-01f,
  -5.59088647e-01f, 1.03388883e-01f, 3.53330709e-02f, -2.97830284e-01f, 8.49719271e-02f, 1.59686983e-01f, 1.37263820e-01f, 4.38924432e-02f, 5.16158994e-03f, 8.30538478e-03f,
  1.73066095e-01f, -3.52295749e-02f, -6.67881668e-02f, 1.79829121e-01f, 7.18676969e-02f, 3.17273021e-01f, 1.36041000e-01f, -1.26787484e-01f, -8.02870616e-02f, -1.81231983e-02f,
  -3.83392684e-02f, -1.29124910e-01f, -3.71515751e-01f, -8.62452239e-02f, -3.24354880e-02f, -9.11937736e-04f, -8.78336057e-02f, -7.63120279e-02f, -6.70388415e-02f, -3.59332152e-02f,
  -1.16483897e-01f, -2.28574678e-01f, 7.97103792e-02f, -2.70326361e-02f, -7.00571537e-02f, -1.35588095e-01f, -1.74732715e-01f, -1.62361432e-02f, 9.21601355e-02f, -2.68901186e-03f,
  -3.38500738e-02f, -1.95324197e-02f, 2.93755531e-02f, 1.50255235e-02f, -8.81467909e-02f, -5.28993532e-02f, -9.36287083e-03f, 9.54477116e-02f, -1.88205601e-03f, 6.33443706e-03f,
  1.70872703e-01f, 4.53799516e-02f, -1.59749061e-01f, -5.39915860e-02f, 2.01493911e-02f, -1.21630453e-01f, -1.34793133e-01f, -7.06440732e-02f, -5.97066768e-02f, -2.66896397e-01f,
  5.91262802e-02f, -1.30849024e-02f, 1.19515352e-01f, -3.92496996e-02f, -1.04398631e-01f, -4.66653220e-02f, -8.68084058e-02f, -2.88385153e-02f, -5.15116528e-02f, -2.72940006e-02f,
  -7.50713050e-03f, 1.94561314e-02f, 3.71072590e-02f, 5.02946004e-02f, 3.19772027e-02f, -8.66973475e-02f, -9.57448110e-02f, -6.94960495e-03f, -4.20118570e-02f, 7.66339945e-03f,
  6.07863106e-02f, 4.54628170e-02f, -8.28627273e-02f, 1.08577192e-01f, -1.31747099e-02f, -1.00415803e-01f, -3.07302307e-02f, 7.51204118e-02f, -5.21327034e-02f, 4.24229018e-02f,
  -2.11898312e-01f, 2.63918042e-01f, -1.18964717e-01f, 5.38919531e-02f, -6.98677525e-02f, -1.02359876e-01f, -6.71577603e-02f, 6.01762831e-02f, 5.27881794e-02f, -1.39275072e-02f,
  -4.13406035e-03f, -4.76105288e-02f, -1.63203366e-02f, 1.27877221e-01f, 8.14720169e-02f, -2.50727497e-02f, 1.79142088e-01f, 2.08971035e-02f, 5.41265979e-02f, 2.56601870e-02f,
  1.86586946e-01f, -1.21453770e-01f, -2.01250255e-01f, -4.01992165e-02f, -2.05926493e-01f, -1.52471423e-01f, -1.11666448e-01f, -1.35101125e-01f, -2.09315404e-01f, -2.42285818e-01f,
  -4.33966726e-01f, -1.45559048e-03f, -9.10647139e-02f, -3.25001702e-02f, 6.96634352e-02f, -5.77595793e-02f, -9.77389365e-02f, -2.55884100e-02f, 9.91652347e-03f, -6.11826517e-02f,
  -5.10854274e-02f, 5.74576259e-02f, -1.96373649e-02f, 9.68950987e-02f, 1.25882523e-02f, 7.84402937e-02f, 2.59799093e-01f, 8.95364881e-02f, -1.23081908e-01f, -9.86799672e-02f,
  1.71439022e-01f, -3.32374834e-02f, -9.37573910e-02f, 5.77744469e-03f, 1.38216913e-01f, 9.27474499e-02f, 6.24898896e-02f, 1.33247703e-01f, 3.40991952e-02f, 3.49632084e-01f,
  -5.83095029e-02f, -1.34999573e-01f, -2.98344437e-02f, -6.95272759e-02f, 2.84893811e-02f, -1.02702498e-01f, 5.85040040e-02f, -8.01555440e-02f, 5.74323023e-03f, -8.21887031e-02f,
  5.72462799e-03f, -8.84870067e-02f, 1.85164943e-01f, 1.45127149e-02f, -1.37265146e-01f, -1.33554727e-01f, -9.40207392e-02f, -1.29234210e-01f, -2.01808095e-01f, -1.13632642e-01f,
  1.82961121e-01f, 3.41520421e-02f, -7.03291669e-02f, -1.84021629e-02f, 4.33661193e-02f, -2.94190980e-02f, -1.09601229e-01f, -8.70350003e-02f, -1.22475125e-01f, -6.60450980e-02f,
  -3.54980398e-03f, 3.98480855e-02f, -8.27634037e-02f, 3.13424915e-02f, 1.21028103e-01f, 1.26117632e-01f, 2.05276474e-01f, 1.59954190e-01f, 6.37271181e-02f, 2.33499426e-02f,
  4.25578952e-02f, 9.34381690e-03f, 7.02243298e-02f, -5.41362688e-02f, -3.56559306e-02f, 1.54175293e-02f, 1.87735423e-01f, 9.22070146e-02f, -7.33077452e-02f, -7.00499937e-02f,
  7.10850433e-02f, 4.62550931e-02f, 1.35957584e-01f, 8.90991986e-02f, 7.43236244e-02f, -2.03440059e-02f, 1.23984879e-02f, -1.11577265e-01f, -1.42412707e-01f, -5.91529645e-02f,
  -2.77974874e-01f, 9.17617604e-02f, -3.23300175e-02f, -5.09687178e-02f, 5.75293042e-02f, 4.43518646e-02f, 5.58242686e-02f, -5.15709585e-03f, -1.10351173e-02f, -2.18886077e-01f,
  -1.31756306e-01f, -8.11322927e-02f, -8.04045238e-03f, -5.48556782e-02f, -7.61578372e-03f, -9.25074443e-02f, -3.35575677e-02f, -2.38169003e-02f, 3.37366126e-02f, -5.25023565e-02f,
  4.12919670e-02f, -1.75380617e-01f, -1.45362452e-01f, -6.93899989e-02f, -4.56126891e-02f, -6.95056021e-02f, -1.57868698e-01f, -4.00774665e-02f, -2.52187103e-01f, -1.83915600e-01f,
  -6.08860493e-01f, 5.86588979e-02f, 2.15145305e-01f, -2.28343129e-01f, 1.16430394e-01f, -9.66565236e-02f, -8.62290114e-02f, -2.03354537e-01f, -9.55555364e-02f, 7.81157166e-02f,
  1.29575834e-01f, -2.45747566e-02f, 4.42420170e-02f, -3.10743172e-02f, -2.25764126e-01f, -6.29149750e-02f, -5.99200912e-02f, -2.23570898e-01f, -1.94706202e-01f, -1.37733510e-02f,
  2.13091131e-02f, -1.96521267e-01f, -2.52479970e-01f, -8.58010426e-02f, 1.73487872e-01f, 1.74602464e-01f, 1.52077511e-01f, 4.07849327e-02f, 2.16962263e-01f, 1.04609184e-01f,
  1.20990701e-01f, -1.40249282e-01f, 3.76186557e-02f, -4.86291647e-02f, 1.43273145e-01f, 1.00377155e-02f, 2.74100602e-02f, -3.71941403e-02f, -1.68349091e-02f, -8.94000977e-02f,
  3.34958769e-02f, -3.18122692e-02f, -1.43377930e-02f, -3.81943807e-02f, -3.06857258e-01f, -1.76704764e-01f, -1.68070912e-01f, -1.27208933e-01f, -6.76537380e-02f, 2.56186910e-02f,
  9.26402733e-02f, 1.35143518e-01f, -5.12160957e-02f, 2.28633806e-02f, -1.43506467e-01f, -1.00357709e-02f, 1.65113688e-01f, 8.31651688e-02f, 3.46432514e-02f, 5.25993481e-03f,
  -1.27418973e-02f, -1.09607624e-02f, 1.04732499e-01f, -8.25259164e-02f, -4.96368520e-02f, 6.31219223e-02f, -1.19269835e-02f, 3.37296352e-02f, 3.68465409e-02f, -1.27020434e-01f,
  1.42145054e-02f, 1.59019418e-02f, -3.18964832e-02f, -3.00695486e-02f, 1.00459255e-01f, 3.92773338e-02f, 7.67557765e-04f, 5.13484776e-02f, 1.02398977e-01f, 6.51947409e-02f,
  -7.85205513e-02f, 4.55732178e-03f, -1.68916676e-02f, -1.00870587e-01f, 1.94452796e-02f, 5.01149297e-02f, 3.82818766e-02f, 9.40374881e-02f, -3.88790444e-02f, -8.53177626e-03f,
  -1.29333362e-01f, 2.11452946e-01f, 3.10233627e-02f, -4.16020527e-02f, 5.25166541e-02f, 3.76294218e-02f, 1.32395685e-01f, -6.30426407e-02f, -7.61318803e-02f, -1.23358488e-01f,
  -1.34387299e-01f, -1.14444196e-01f, 8.30060095e-02f, 1.48539171e-01f, -1.01796351e-01f, 1.36775095e-02f, 4.84388396e-02f, 5.74675389e-02f, 1.04293056e-01f, -1.37357697e-01f,
  -1.36494324e-01f, -1.39080212e-01f, -2.79956996e-01f, -1.20171353e-01f, -4.83767968e-03f, -1.27497822e-01f, -6.12912998e-02f, 6.83307424e-02f, -1.15406156e-01f, -7.51032904e-02f,
  3.61432791e-01f, 3.74089688e-01f, -1.00002579e-01f, 4.61697169e-02f, 1.72554344e-01f, -4.09950726e-02f, -1.41450390e-01f, -1.74596503e-01f, -6.26951307e-02f, 9.04131383e-02f,
  1.07719526e-01f, 1.28774103e-02f, 1.43496115e-02f, -7.64743332e-03f, -8.72094482e-02f, -6.27990291e-02f, -1.41985472e-02f, -1.18774638e-01f, -2.92867988e-01f, -4.87847365e-02f,
  7.89954886e-02f, 8.54487717e-02f, 4.56392020e-02f, -1.27885610e-01f, 1.74185097e-01f, 6.86741024e-02f, 1.35746166e-01f, 3.77940893e-01f, 1.92950562e-01f, 3.06831390e-01f,
  1.58686027e-01f, 2.51217246e-01f, -1.77313641e-01f, 2.82051712e-01f, 1.45807937e-01f, -2.15615198e-01f, -8.72638971e-02f, -1.41133862e-02f, -6.08285144e-02f, -3.25354114e-02f,
  2.41748378e-01f, 5.19764312e-02f, 1.94577456e-01f, 6.29301146e-02f, -5.05668148e-02f, -1.30239666e-01f, -1.72439009e-01f, -1.28774166e-01f, -1.27477393e-01f, -1.16091222e-01f,
  9.57687944e-02f, 5.92499748e-02f, 2.08767392e-02f, -1.99957937e-01f, -6.06332393e-03f, -9.00697038e-02f, 8.38719681e-02f, 9.58632603e-02f, -8.89015198e-02f, 1.22902371e-01f,
  -1.38420969e-01f, -1.19212838e-02f, -1.79212652e-02f, 6.53168336e-02f, -8.01768526e-02f, 1.36868790e-01f, 4.54363078e-02f, 6.32499605e-02f, -1.16167277e-01f, 1.24100326e-02f,
  -8.65660235e-02f, -1.00114584e-01f, -5.75388335e-02f, -1.78462733e-02f, -1.60448998e-01f, 9.39257666e-02f, -7.81897530e-02f, -5.51467314e-02f, -2.89207883e-02f, -8.92631188e-02f,
  -1.35564257e-03f, -8.94144773e-02f, 1.22284763e-01f, 2.68856715e-02f, 2.62016449e-02f, -7.95746818e-02f, -6.23123720e-02f, -1.27432287e-01f, -5.44868521e-02f, 9.24385712e-02f,
  8.34882841e-04f, -1.40061945e-01f, -1.22290887e-01f, -6.72718510e-02f, 2.07769394e-01f, 6.29480407e-02f, -1.33144438e-01f, -1.77877575e-01f, 7.32858777e-02f, -2.17009649e-01f,
  1.01658419e-01f, -1.05122596e-01f, 1.76344514e-01f, -2.20538527e-02f, -1.26549840e-01f, -5.85060604e-02f, -5.10234833e-02f, -4.74654660e-02f, -1.67117357e-01f, -5.44310883e-02f,
  -1.21129677e-01f, -3.28279018e-01f, -1.26999244e-01f, -2.11789906e-01f, -1.65746555e-01f, -1.35577321e-01f, -9.50063542e-02f, 7.80693889e-02f, -1.84644133e-01f, -2.88477808e-01f,
  -1.27998978e-01f, -2.24766389e-01f, -2.72262126e-01f, -1.16168626e-01f, -6.08549379e-02f, 5.22311917e-03f, -2.44862750e-01f, 3.61443460e-02f, -4.81416695e-02f, -1.90265730e-01f,
  6.28002137e-02f, 2.74879485e-01f, 4.57097255e-02f, 1.28373325e-01f, 7.22839087e-02f, -2.92520970e-01f, -3.57656717e-01f, -1.57214135e-01f, 2.52649397e-01f, 2.51036197e-01f,
  1.88778788e-01f, -5.06401202e-03f, 9.02719572e-02f, 7.53266364e-02f, -2.19755992e-02f, 7.14098439e-02f, -1.18813485e-01f, -8.13568160e-02f, 5.58126010e-02f, -2.46323422e-01f,
  1.86606809e-01f, -1.61661685e-01f, 1.25718052e-02f, -3.10560316e-02f, 3.56393680e-02f, 6.71185330e-02f, -3.44048068e-02f, -9.49420407e-02f, -1.88759848e-01f, -2.38181259e-02f,
  -2.85886303e-02f, 4.55220640e-02f, 1.37683719e-01f, 1.66707829e-01f, -4.14610356e-02f, -1.07986396e-02f, -7.08388165e-02f, -1.42714620e-01f, -2.31457353e-01f, 5.29438928e-02f,
  9.84493420e-02f, -4.27544788e-02f, -7.20234588e-02f, -5.39806187e-02f, -1.07518293e-01f, 1.00464992e-01f, -7.95917027e-03f, 9.38134491e-02f, -6.88142702e-02f, -1.48068950e-01f,
  1.03519030e-03f, -1.23655133e-01f, -3.03926617e-02f, -4.27951134e-04f, -2.54750270e-02f, -6.76747337e-02f, -6.81858277e-03f, -8.74129236e-02f, 9.74083599e-03f, -5.36251143e-02f,
  -1.50739234e-02f, -5.23063391e-02f, 5.45330271e-02f, 1.15421833e-02f, -5.10352030e-02f, -1.42448783e-01f, -8.66852328e-02f, -1.19578198e-01f, -8.12978148e-02f, 3.77988927e-02f,
  6.01617247e-02f, 8.17058235e-02f, -1.36744291e-01f, 9.12097991e-02f, 2.97604147e-02f, 2.23795790e-02f, -6.74484149e-02f, -4.36121151e-02f, 1.21096976e-01f, -1.20629862e-01f,
  1.61657780e-01f, -1.21116221e-01f, -4.88191284e-03f, 5.16639464e-02f, -1.65135831e-01f, -1.27910927e-01f, -1.28130004e-01f, -5.13299294e-02f, -1.03606015e-01f, 1.40151158e-02f,
  2.09651627e-02f, -1.25033408e-02f, -6.19082665e-03f, -3.54655683e-02f, 1.12219833e-01f, 6.50880933e-02f, -5.48012406e-02f, 4.82894704e-02f, -1.76098034e-01f, -4.65784520e-02f,
  -9.84526426e-02f, -1.14204310e-01f, 5.78263998e-02f, 2.15415992e-02f, -1.20203137e-01f, 1.58888683e-01f, -4.05718543e-04f, 5.44746518e-02f, -8.82104933e-02f, -7.95953795e-02f,
  5.75177789e-01f, 1.98016480e-01f, 1.34445615e-02f, 1.67935833e-01f, -6.75003976e-02f, -1.78979263e-01f, -2.13890597e-01f, -9.19025391e-02f, 7.88331553e-02f, 9.87937674e-02f,
  1.38436347e-01f, 1.86882541e-01f, 1.28451094e-01f, 7.09271953e-02f, 1.79533795e-01f, -7.61629567e-02f, 8.02181009e-03f, 8.26322064e-02f, 1.08923167e-02f, -6.95782825e-02f,
  -4.21731882e-02f, -7.63263851e-02f, 1.58602655e-01f, 4.46288213e-02f, -2.21444648e-02f, 1.58244267e-01f, -1.14093661e-01f, 4.48008589e-02f, 7.99123198e-03f, 1.48932666e-01f,
  3.34192067e-01f, 2.41904721e-01f, 5.20079993e-02f, 1.14877895e-01f, 6.20556436e-02f, 4.03577238e-02f, 1.16206989e-01f, 8.92917253e-03f, 4.17662412e-02f, 5.94135420e-03f,
  4.49339822e-02f, -1.13552036e-02f, 2.95607410e-02f, 1.27149466e-02f, -4.67114672e-02f, -9.13146287e-02f, -9.85468365e-03f, 1.76711813e-01f, 3.86079103e-02f, 5.81969880e-02f,
  -1.32612526e-01f, 9.85942036e-02f, 9.51581821e-02f, 8.05654004e-03f, 4.78886813e-02f, 2.66186502e-02f, -3.99628952e-02f, 1.04754739e-01f, 5.63983098e-02f, 1.51866853e-01f,
  -2.03971311e-01f, -6.31751791e-02f, 8.94907266e-02f, -2.52501201e-02f, 2.56926902e-02f, 3.86527553e-02f, 1.72200911e-02f, -4.08160575e-02f, 8.53599459e-02f, -1.45370632e-01f,
  -5.03371358e-02f, 1.26724616e-01f, 6.68126866e-02f, 7.30737895e-02f, 1.60695776e-01f, 2.27638520e-02f, 9.51925963e-02f, 4.60737608e-02f, -1.08313672e-01f, 1.35134146e-01f,
  3.29181738e-02f, -1.33808300e-01f, -7.85325319e-02f, -1.78224027e-01f, -1.70895213e-03f, -8.85926094e-03f, 6.96940348e-02f, 3.44278179e-02f, -1.76729411e-01f, -9.69944149e-02f,
  1.44263595e-01f, 5.50593175e-02f, 1.00755118e-01f, 8.49239826e-02f, 2.95818876e-02f, 1.31201120e-02f, 4.97590341e-02f, 3.92049365e-02f, 6.43242151e-02f, 2.02890988e-02f,
  5.22531867e-02f, -1.34053538e-02f, -4.89678979e-02f, -8.41355473e-02f, -5.94120845e-02f, -3.94197032e-02f, 3.43205035e-02f, 2.29294956e-01f, 9.60897431e-02f, -8.54306668e-02f,
  -7.69931898e-02f, 1.46718487e-01f, 1.08813204e-01f, -1.31996479e-02f, 5.03475964e-02f, 1.01827085e-01f, 2.53319889e-02f, 1.76742598e-02f, -1.23016965e-02f, -1.17599182e-01f,
  1.46266684e-01f, 2.16222152e-01f, 2.13419497e-01f, 2.97545027e-02f, 1.79796562e-01f, 2.08352357e-01f, 4.02162492e-01f, 8.17351416e-02f, -1.39713541e-01f, 9.65992883e-02f,
  -1.04812376e-01f, -3.97925913e-01f, -3.05600911e-01f, -1.61641344e-01f, -2.58586872e-02f, 1.84497684e-01f, 1.28913358e-01f, -3.65659446e-02f, -9.86230746e-02f, -2.01650150e-02f,
  -3.62799615e-02f, 1.21692732e-01f, -7.67074749e-02f, -8.12512115e-02f, -5.58993332e-02f, -2.37860203e-01f, 9.68761817e-02f, 1.43997759e-01f, 1.47676066e-01f, -1.78460106e-01f,
  1.03759700e-02f, 4.26032335e-01f, -3.58952075e-01f, -7.25589246e-02f, 8.05167854e-02f, -5.35133518e-02f, -6.94158599e-02f, -5.62840607e-03f, -3.30567509e-02f, -8.77250955e-02f,
  -2.86234524e-02f, 6.66180328e-02f, 1.70179754e-01f, 5.57328612e-02f, 1.15588568e-01f, 1.03059396e-01f, 9.63624045e-02f, 1.65777057e-01f, -1.74657851e-02f, 7.87165537e-02f,
  -9.62563902e-02f, 1.40282527e-01f, 2.43847921e-01f, -2.13262253e-02f, 8.74103084e-02f, 1.81088701e-03f, 7.27138594e-02f, 1.10777266e-01f, -2.68506873e-02f, -2.64571663e-02f,
  -1.96374431e-01f, -4.55137454e-02f, 5.01622781e-02f, -2.52512321e-02f, 1.15142837e-01f, -6.95194155e-02f, -1.18549932e-02f, -4.43521366e-02f, -5.36345541e-02f, 7.61085525e-02f,
  -2.46148463e-02f, 7.52564147e-02f, 5.56918941e-02f, 1.86240189e-02f, -1.10149048e-01f, -1.31002059e-02f, 1.26040474e-01f, -7.72852264e-03f, 7.66969100e-02f, 7.27087930e-02f,
  -3.09284776e-02f, 2.40244269e-02f, 7.03701526e-02f, 4.10983479e-03f, -5.65154990e-03f, -3.06022801e-02f, 5.28684072e-02f, 9.65861306e-02f, 1.08697347e-01f, 1.16052948e-01f,
  -1.13642536e-01f, 1.32537827e-01f, -1.33954421e-01f, -6.47266582e-02f, 4.16327082e-02f, -5.06444201e-02f, -3.99742350e-02f, -2.87499763e-02f, -9.03708786e-02f, -1.26963064e-01f,
  -3.46077234e-02f, -9.90105495e-02f, 1.41396940e-01f, 1.15565218e-01f, -1.40354708e-01f, -3.21777165e-02f, -1.32233679e-01f, -5.81534617e-02f, -1.42945247e-02f, -6.16337247e-02f,
  -7.72633329e-02f, -1.40385404e-01f, -4.68569808e-02f, -1.28252178e-01f, -1.24555141e-01f, -3.35229129e-01f, -5.72453253e-02f, 2.82729138e-02f, -1.52730579e-02f, -1.62545085e-01f,
  5.99316359e-01f, -1.00202948e-01f, -3.39506529e-02f, 1.70169532e-01f, -1.52339535e-02f, 6.50758892e-02f, 7.08454521e-03f, 6.25197962e-02f, 1.70922309e-01f, 7.95744956e-02f,
  1.62995130e-01f, 2.91350871e-01f, 3.39622468e-01f, 2.46252984e-01f, 1.88508317e-01f, -8.45206454e-02f, 3.77859548e-02f, 8.32612067e-02f, 2.65215874e-01f, 2.51578353e-02f,
  -1.63223475e-01f, -6.84713945e-02f, 1.02831155e-01f, -8.94624442e-02f, -1.60575539e-01f, 4.29268442e-02f, -1.48807243e-01f, -1.10562421e-01f, -4.52595651e-02f, -1.60996929e-01f,
  9.05378256e-03f, -1.89395845e-02f, 3.98780517e-02f, -5.39576635e-02f, -2.62915362e-02f, 1.04014337e-01f, 6.38990998e-02f, -1.03353402e-02f, 6.03141971e-02f, -6.92173764e-02f,
  6.58896491e-02f, -1.74824044e-01f, 4.48371097e-02f, -2.42097061e-02f, -1.19215503e-01f, -3.62330023e-03f, -1.40277464e-02f, 8.92869309e-02f, 1.04670480e-01f, -9.10838023e-02f,
  -3.23752947e-02f, 7.11986199e-02f, 1.29678115e-01f, 2.32616495e-02f, 6.41913041e-02f, 1.32440314e-01f, 5.31295463e-02f, 3.43079097e-03f, 2.88564414e-02f, 1.16810026e-02f,
  1.05136689e-02f, 1.04349226e-01f, -1.35382609e-02f, 1.04406662e-01f, -2.27853600e-02f, 4.53703366e-02f, 5.01251605e-04f, 5.18645123e-02f, 1.26402795e-01f, -5.77283725e-02f,
  -1.67596634e-04f, 1.60869420e-01f, 9.01961699e-02f, -1.41033567e-02f, -1.68889053e-02f, 5.68657964e-02f, -1.13276526e-01f, -8.90500657e-03f, 6.77305683e-02f, -1.33074978e-02f,
  1.22667458e-02f, -1.07421026e-01f, -1.65567145e-01f, -1.29636541e-01f, 5.58732124e-03f, 1.56864211e-01f, -8.28206912e-02f, -8.57050791e-02f, 6.90858439e-03f, -2.26264000e-02f,
  8.25767890e-02f, 2.59913325e-01f, 1.89030450e-02f, -5.29187620e-02f, -1.47212625e-01f, -1.47299901e-01f, -2.04116274e-02f, -5.38961738e-02f, -1.50065109e-01f, 4.07981761e-02f,
  -2.69333143e-02f, -6.80987090e-02f, -7.18372315e-02f, -4.85173836e-02f, 3.16523835e-02f, 7.13323429e-02f, 9.88874678e-03f, 3.06758359e-02f, 6.83097243e-02f, -1.68478027e-01f,
  -1.13361560e-01f, 1.03896864e-01f, 2.02439860e-01f, 2.25449905e-01f, 4.96623926e-02f, 1.50611952e-01f, -8.21255669e-02f, -1.01884052e-01f, 8.74479786e-02f, -4.03115666e-03f,
  -4.15612549e-01f, 3.01719815e-01f, -7.73353204e-02f, -4.27176282e-02f, 7.68305436e-02f, 6.02920633e-03f, 5.29256873e-02f, 1.83059812e-01f, 4.17705141e-02f, 2.05394328e-02f,
  1.56832263e-01f, -9.29582566e-02f, -1.57705814e-01f, -2.15949655e-01f, -2.19632924e-01f, -2.02640146e-01f, -3.08685541e-01f, -3.63692254e-01f, -2.66092628e-01f, -1.09019764e-01f,
  -9.45780724e-02f, -3.69399399e-01f, -3.26799095e-01f, -2.14104816e-01f, 1.13916174e-01f, -4.72232960e-02f, 5.59687875e-02f, -2.22637188e-02f, 9.50798690e-02f, 3.40464637e-02f,
  -1.73861668e-01f, 1.91226020e-01f, 9.47919935e-02f, 4.44606505e-02f, 3.29748951e-02f, 1.10659175e-01f, 9.84389558e-02f, 7.93884620e-02f, 1.12502940e-01f, 1.03400528e-01f,
  7.06846118e-02f, 1.81905732e-01f, -1.34886622e-01f, -2.23372635e-02f, 8.50226805e-02f, 8.66769031e-02f, 9.28510800e-02f, 6.72966689e-02f, 2.17147954e-02f, 1.15429491e-01f,
  1.23965435e-01f, 1.46325320e-01f, 1.41592085e-01f, 1.90278247e-01f, 4.99929413e-02f, 9.23690200e-02f, 2.56652117e-01f, 1.37033775e-01f, 1.03612535e-01f, 1.93852246e-01f,
  8.09822325e-03f, -6.80507123e-02f, 3.38679855e-03f, -1.78052783e-02f, 3.50860995e-03f, -4.85079456e-03f, -5.38108647e-02f, -5.03363609e-02f, -1.11110836e-01f, -7.14932457e-02f,
  1.11790791e-01f, 4.70976382e-02f, -1.21551059e-01f, -5.24876490e-02f, 7.40047470e-02f, 4.06780429e-02f, -2.50353701e-02f, -6.08076751e-02f, 1.31445438e-01f, 9.20486152e-02f,
  3.15628499e-02f, -1.98721141e-03f, 1.04054064e-02f, 9.19822454e-02f, 2.19410285e-01f, 1.62133142e-01f, 6.34296834e-02f, 1.06096774e-01f, -2.66584400e-02f, -2.80197593e-03f,
  4.68239859e-02f, -1.05929293e-01f, -2.23125309e-01f, -8.61441344e-02f, -9.42617208e-02f, 8.68072882e-02f, -8.86183977e-02f, 6.57060295e-02f, 2.08882801e-02f, 3.88326682e-02f,
  1.07941754e-01f, -7.41209686e-02f, -1.41794190e-01f, 4.88787256e-02f, 8.94404277e-02f, 6.06212802e-02f, 1.33746713e-01f, -4.93124733e-03f, 2.50622025e-03f, 1.52274027e-01f,
  -8.70649889e-03f, 1.61911640e-02f, -7.15350360e-02f, 3.27359289e-02f, -2.46167574e-02f, -1.34070873e-01f, -5.88012300e-02f, 8.29274207e-02f, -8.82884488e-02f, 2.48659384e-02f,
  9.16579962e-02f, -2.22516045e-01f, -2.48743966e-01f, -1.32471874e-01f, -2.18289778e-01f, -1.84385344e-01f, -3.77681673e-01f, -1.32127047e-01f, -8.57268423e-02f, -2.85738826e-01f,
  -1.47551909e-01f, 2.13417217e-01f, 1.69498250e-01f, 8.19534287e-02f, 8.44039395e-02f, -4.31425691e-01f, -2.20258370e-01f, 1.33506730e-01f, 2.91280985e-01f, 3.57911512e-02f,
  -1.15944237e-01f, -4.98227018e-04f, 1.19457871e-01f, 1.65223703e-01f, -1.77277103e-01f, 1.16544224e-01f, -2.58084267e-01f, -2.88983583e-02f, -7.23992735e-02f, -3.43723506e-01f,
  -7.50393495e-02f, -1.45487905e-01f, -2.96811368e-02f, 8.99790227e-02f, -9.93092656e-02f, -3.63079160e-02f, -2.70544924e-02f, -1.60136506e-01f, -2.25127488e-02f, 1.02516953e-02f,
  -2.97015160e-02f, 3.12476549e-02f, 2.35359043e-01f, 2.67228801e-02f, 9.89409611e-02f, -1.42474547e-02f, 2.61318497e-02f, 1.37226000e-01f, -1.53224105e-02f, -1.31991014e-01f,
  -9.39523801e-02f, -1.17521055e-01f, -3.28490511e-02f, 1.54995238e-02f, 4.52590846e-02f, 1.15187801e-01f, -6.21232670e-04f, -8.57017264e-02f, 6.79315627e-03f, -6.05799742e-02f,
  -1.79075196e-01f, -4.89569604e-02f, -8.77619907e-02f, -5.74016571e-02f, -9.15400758e-02f, -4.02768850e-02f, 1.15786389e-01f, -2.78545395e-02f, 7.26195350e-02f, -1.55561268e-02f,
  -1.56857097e-03f, -5.40378764e-02f, 4.70754653e-02f, -1.03346586e-01f, -6.61015511e-02f, -1.18326843e-02f, 5.45943342e-02f, -2.79927650e-03f, 2.31274273e-02f, -2.07665451e-02f,
  6.53257445e-02f, -3.73257743e-03f, -4.04191390e-03f, 1.55224860e-01f, -1.38717405e-02f, -2.39796229e-02f, 9.76669714e-02f, 2.89297830e-02f, 2.46830452e-02f, -2.37157494e-02f,
  1.17206745e-01f, 2.01053638e-02f, -1.08382396e-01f, 7.87402764e-02f, -6.67062700e-02f, -3.74094695e-02f, -5.81668019e-02f, -9.35987663e-03f, 3.06486208e-02f, -1.03771456e-01f,
  -9.24058165e-03f, 1.98098626e-02f, 3.62572037e-02f, 7.24030659e-02f, -1.18229426e-01f, 7.27420673e-02f, -6.98215216e-02f, 7.83391595e-02f, -5.23404963e-02f, -1.27480045e-01f,
  -3.67018655e-02f, 1.00395363e-02f, 1.06192730e-01f, 8.80537853e-02f, -1.53079569e-01f, 7.16599748e-02f, 1.23554900e-01f, 1.14664687e-02f, 8.86199996e-02f, -6.43141568e-02f,
  7.08840847e-01f, 2.40019590e-01f, 3.11779767e-01f, 4.35858592e-02f, -1.40775725e-01f, 1.24733999e-01f, 2.35182375e-01f, 2.56954074e-01f, -5.18692099e-02f, 6.02789484e-02f,
  -3.75814810e-02f, -1.65432960e-01f, -9.12834555e-02f, -5.76522667e-03f, 2.35637620e-01f, 5.04037403e-02f, -6.31727353e-02f, 2.62827516e-01f, 2.76280433e-01f, -1.63006987e-02f,
  -7.76296705e-02f, 1.42030656e-01f, 2.84029037e-01f, 1.55658886e-01f, -4.76096682e-02f, -6.00492693e-02f, -2.80708307e-03f, 6.31540641e-02f, 1.76872145e-02f, -1.46892771e-01f,
  -2.16744259e-01f, 2.35328287e-01f, -5.52438619e-03f, -8.13657194e-02f, 1.36766508e-01f, 2.37038448e-01f, 1.28640056e-01f, 8.23481828e-02f, 7.63087869e-02f, -2.84442510e-02f,
  2.71542966e-02f, 1.34723112e-02f, -1.40348459e-02f, -1.62856728e-02f, 1.18951850e-01f, 7.75974542e-02f, 7.58336782e-02f, 1.85720846e-01f, 3.24173197e-02f, 5.95343783e-02f,
  -5.69535606e-02f, -7.56984428e-02f, -3.34513607e-04f, 7.52233639e-02f, 1.09048940e-01f, -1.51445940e-01f, 7.24561140e-02f, 5.17481118e-02f, 5.24535626e-02f, -3.66636328e-02f,
  -1.26409084e-01f, -3.60321403e-02f, 1.30245695e-03f, -1.11141212e-01f, 8.35931953e-03f, -8.61651078e-02f, -9.40374434e-02f, -2.89198458e-02f, 2.86058169e-02f, -4.83707106e-03f,
  2.05615442e-02f, -1.25983702e-02f, -3.46162803e-02f, 8.30680225e-03f, -1.03854626e-01f, -1.86507162e-02f, 1.26297055e-02f, -1.28339499e-01f, 3.30973528e-02f, -4.67671081e-02f,
  2.91992687e-02f, 8.12477544e-02f, -5.70639893e-02f, -6.30190969e-02f, -7.65420198e-02f, 1.76494662e-02f, -1.87032782e-02f, -6.88356683e-02f, 1.21853128e-02f, -5.33075966e-02f,
  -5.13701797e-01f, -2.04354078e-01f, -9.43154320e-02f, -3.73234898e-02f, -1.48186814e-02f, 6.11644872e-02f, -1.63906112e-01f, -1.62475452e-01f, -2.58100647e-02f, -7.43001699e-02f,
  -7.77725950e-02f, -9.83667746e-02f, -2.89064478e-02f, 4.85982187e-02f, 6.31197691e-02f, -5.66444471e-02f, -3.83444130e-02f, -1.43186599e-01f, -1.73497930e-01f, -1.87156633e-01f,
  -1.26086548e-01f, -5.88228926e-02f, -1.48122355e-01f, 2.39540581e-02f, -7.89528564e-02f, -1.54031873e-01f, -9.82455090e-02f, -3.29251923e-02f, 5.48191229e-03f, 5.87355681e-02f,
  2.71610111e-01f, -2.55196422e-01f, -2.88967222e-01f, 2.02192124e-02f, -4.97054402e-03f, -3.71514745e-02f, -1.94856659e-01f, 1.02254689e-01f, 1.40154898e-01f, -3.60293418e-01f,
  -1.05338201e-01f, 1.59914926e-01f, 7.15715289e-02f, -3.06590647e-02f, 2.20527444e-02f, -2.21204609e-01f, -3.01918656e-01f, -3.33027840e-02f, 3.28589290e-01f, 2.75725365e-01f,
  1.64056525e-01f, 8.13068729e-03f, 5.22409454e-02f, 3.16691399e-02f, -1.44881904e-01f, -5.47997914e-02f, -3.10749769e-01f, -1.55144215e-01f, -1.80490583e-01f, -1.82154492e-01f,
  -1.14281900e-01f, -6.54529454e-03f, -1.25973538e-01f, 1.12606600e-01f, -4.44635982e-03f, -7.98511580e-02f, -6.95392350e-03f, -8.19380134e-02f, 8.15383196e-02f, -7.70995244e-02f,
  6.43744916e-02f, -1.38195259e-02f, 2.01965440e-02f, -5.89402206e-02f, 5.00858724e-02f, 5.24769761e-02f, -9.45774913e-02f, -1.51062803e-02f, -1.62952486e-02f, 2.32202513e-03f,
  2.62080934e-02f, 1.02096669e-01f, 2.54569743e-02f, -4.51877750e-02f, -1.84752300e-01f, -7.35138059e-02f, -1.76092714e-01f, 2.32913555e-03f, -1.34909168e-01f, -1.89249590e-01f,
  -2.82610003e-02f, -4.60241660e-02f, -2.16895789e-02f, -6.70382306e-02f, 2.53375750e-02f, 7.20740855e-03f, 7.86849484e-02f, -7.92292356e-02f, -7.24786147e-03f, 5.55636883e-02f,
  2.90430505e-02f, -8.42073653e-03f, 1.04915075e-01f, -4.11592722e-02f, 1.69764161e-02f, 9.12031755e-02f, 1.67615429e-01f, -4.03198786e-02f, 6.73019290e-02f, 7.71458223e-02f,
  9.43946093e-02f, 1.50634527e-01f, 4.50830981e-02f, 1.88166574e-01f, -3.86648737e-02f, -3.46111394e-02f, -5.80207221e-02f, -1.00608952e-02f, 9.60593075e-02f, -1.62694720e-03f,
  7.37129673e-02f, -8.81868750e-02f, -1.34929568e-01f, 9.06379595e-02f, -2.89187003e-02f, -9.65610668e-02f, -1.34834200e-02f, -1.49591863e-01f, -1.17615971e-04f, -1.03342570e-01f,
  -3.02570164e-02f, -4.02497947e-02f, -2.04355102e-02f, 1.30567560e-02f, -2.61480026e-02f, -6.74689189e-02f, -3.90228592e-02f, 1.46370810e-02f, 1.97662264e-02f, 5.91844879e-02f,
  -9.29879695e-02f, 7.56182149e-02f, 9.17858407e-02f, -1.29092885e-02f, -1.09040730e-01f, -2.62730438e-02f, -9.44896415e-02f, -1.42821699e-01f, -1.34017449e-02f, -5.92762493e-02f,
  -2.54503340e-01f, -1.86308116e-01f, 2.92743333e-02f, -1.63310066e-01f, -2.25456133e-02f, 5.21320179e-02f, -9.14664473e-03f, -4.25883271e-02f, -7.99303055e-02f, -2.40705431e-01f,
  9.64142233e-02f, 2.63115740e-03f, -1.76241636e-01f, -5.70115335e-02f, -2.89075170e-02f, -2.22203940e-01f, -3.10637772e-01f, -7.66183436e-03f, 2.42000014e-01f, 3.23711008e-01f,
  -2.15041470e-02f, -1.09828733e-01f, 6.22172542e-02f, 1.53801903e-01f, -4.14795764e-02f, -1.46418251e-02f, -1.72100008e-01f, -1.92689076e-01f, -5.08490298e-03f, -1.72840655e-01f,
  -2.49690652e-01f, -9.05835722e-03f, 1.52437374e-01f, -2.36658659e-02f, -2.01596934e-02f, 6.87427223e-02f, 6.38184100e-02f, -1.00239344e-01f, -4.85451845e-03f, -1.44563690e-01f,
  -1.26986861e-01f, 6.05498441e-02f, -4.62296158e-02f, 7.01302812e-02f, 4.87199277e-02f, -6.75878674e-02f, 3.20465444e-03f, 1.57508805e-01f, 7.66714886e-02f, -7.68792927e-02f,
  -1.71781443e-02f, -8.42710137e-02f, -1.00842319e-01f, -4.63368148e-02f, -1.38562873e-01f, -9.58998352e-02f, 1.18475594e-01f, 4.79128249e-02f, 7.49224573e-02f, -6.12019859e-02f,
  8.04164261e-03f, 6.24318346e-02f, 1.82349682e-01f, 1.45644937e-02f, -2.11341977e-02f, -1.03609962e-02f, -9.10083354e-02f, -8.00578222e-02f, -8.57244432e-03f, -6.02447540e-02f,
  -3.40851699e-03f, -3.99711262e-03f, -5.32131344e-02f, -6.80184290e-02f, -5.25187850e-02f, 4.40086089e-02f, -3.40927206e-02f, -4.08138707e-02f, 6.74065202e-02f, 3.23721115e-03f,
  1.38833001e-01f, -6.58356398e-02f, -1.36393964e-01f, 9.29068327e-02f, -3.46620125e-03f, 5.99131435e-02f, 6.34048879e-02f, 3.52756530e-02f, 8.76698121e-02f, 6.73168749e-02f,
  -5.88534921e-02f, 5.63450940e-02f, -1.96743831e-01f, 6.05016872e-02f, -3.38136926e-02f, 8.12483728e-02f, 3.56079265e-02f, -1.20359613e-03f, -4.68230583e-02f, -1.14958137e-01f,
  7.31898919e-02f, -1.48439109e-01f, -1.79033235e-01f, -3.36055830e-02f, 5.54033294e-02f, 2.03932356e-02f, -1.00620247e-01f, -9.79908258e-02f, 1.77168056e-01f, 1.47621349e-01f,
  9.94178746e-03f, -1.34077415e-01f, -1.50578856e-01f, -3.13422754e-02f, 1.64051657e-03f, -3.31982896e-02f, 3.89433615e-02f, -2.13634428e-02f, 2.81589273e-02f, -2.93361433e-02f,
  -4.56037819e-01f, -2.14797743e-02f, 2.24498305e-02f, -1.96499705e-01f, 1.83239624e-01f, 2.74650514e-01f, 3.03729832e-01f, 1.73957974e-01f, 3.41695733e-02f, 1.48547903e-01f,
  -9.76582542e-02f, -1.76067039e-01f, -4.19038981e-02f, 8.61427933e-02f, -1.55305406e-02f, 2.30007693e-01f, 1.48569375e-01f, 2.69755838e-03f, -5.36978878e-02f, 6.15522563e-02f,
  9.78308097e-02f, -2.82901097e-02f, -3.62208277e-01f, -1.51456550e-01f, 8.98214232e-04f, -8.35861564e-02f, 9.70558897e-02f, -7.79456692e-03f, 1.78522408e-01f, 3.25613841e-02f,
  -2.25694120e-01f, -2.53401548e-01f, 9.26288664e-02f, 2.79255528e-02f, -2.23895729e-01f, -3.18386890e-02f, -8.48479122e-02f, -2.45740920e-01f, 3.86320092e-02f, -2.07487177e-02f,
  -8.81464109e-02f, -7.10557401e-02f, 5.26427776e-02f, -8.10014233e-02f, -2.10290551e-01f, -6.16585650e-02f, -4.98233624e-02f, -1.16999961e-01f, -1.30184278e-01f, -5.80605827e-02f,
  1.94243148e-01f, 1.36520952e-01f, -3.69455712e-03f, 5.83114848e-02f, 9.51718315e-02f, 6.67182878e-02f, -8.66656303e-02f, -6.73551932e-02f, 3.26906075e-03f, -1.44517958e-01f,
  -3.41937430e-02f, 4.44720499e-02f, -4.12617698e-02f, -1.27485231e-01f, 8.89599398e-02f, 7.91306347e-02f, -7.44321663e-03f, 9.24077779e-02f, 4.22501042e-02f, -9.94843915e-02f,
  5.81853203e-02f, 8.47780406e-02f, -4.09321440e-03f, -1.08000457e-01f, -1.81094483e-02f, 7.41580315e-03f, 6.46876022e-02f, -1.43838763e-01f, -1.97561607e-02f, -9.89723671e-03f,
  5.19049838e-02f, -3.59091628e-03f, -3.96856526e-03f, 8.40702578e-02f, 1.09512486e-01f, -2.88562980e-02f, 3.59729826e-02f, 4.85471785e-02f, -4.79054190e-02f, -1.10105118e-02f,
  -5.20559907e-01f, 6.24489821e-02f, -7.78490230e-02f, -4.27646488e-02f, -1.72253549e-02f, 3.03473533e-03f, -1.75820634e-01f, -5.04662357e-02f, 8.12558681e-02f, 6.45202175e-02f,
  8.81206468e-02f, -9.88023132e-02f, 6.44821674e-02f, 1.00053303e-01f, -7.91233927e-02f, 5.69600686e-02f, 1.02127194e-01f, 1.07410870e-01f, -3.21036465e-02f, 4.92799357e-02f,
  2.63482094e-01f, 1.67674065e-01f, 1.32548690e-01f, -4.43360116e-03f, 7.56834075e-02f, -4.07614969e-02f, 1.32203866e-02f, 6.90504313e-02f, -3.64900306e-02f, -1.72007084e-01f,
  2.81566940e-02f, 1.19688861e-01f, 3.44816983e-01f, -7.79188871e-02f, 1.57586157e-01f, 1.59786135e-01f, 3.08563560e-01f, 1.84867054e-01f, -6.92217574e-02f, 1.17587864e-01f,
  -2.14183658e-01f, -2.94554502e-01f, -2.93770492e-01f, -1.92601949e-01f, 8.86950195e-02f, 3.53479654e-01f, 2.52377748e-01f, 1.56854451e-01f, 1.89680040e-01f, 1.24514885e-01f,
  -4.61940803e-02f, 5.85596003e-02f, 1.32046968e-01f, 1.31534398e-01f, 4.29430455e-02f, -3.19827236e-02f, 4.07109112e-02f, 9.73265767e-02f, -2.34397016e-02f, 4.63762134e-02f,
  -2.03542739e-01f, -2.07287055e-02f, -6.71366602e-02f, -1.25859514e-01f, -1.30871594e-01f, -2.38252312e-01f, -6.68324390e-03f, -1.09608866e-01f, 9.43226274e-03f, -1.63004082e-02f,
  -7.71410987e-02f, -8.07840303e-02f, -1.33622177e-02f, -3.66535899e-03f, 5.44399172e-02f, 8.96547213e-02f, -4.07752991e-02f, 1.21285141e-01f, 6.65291622e-02f, 9.64490883e-03f,
  -6.24544807e-02f, 1.60700642e-02f, 1.00618064e-01f, 1.08887658e-01f, 1.26511157e-01f, -1.25680864e-01f, -1.43227503e-02f, -8.97443155e-04f, 6.25176579e-02f, -8.52102879e-03f,
  -9.65494215e-02f, 6.89575151e-02f, 1.75729319e-01f, 8.12477246e-02f, 8.62238370e-03f, 6.67635258e-03f, -1.85295846e-02f, -1.22412056e-01f, 1.33035704e-01f, 1.89752996e-01f,
  3.33257243e-02f, -6.00418523e-02f, -7.34627098e-02f, -4.59611304e-02f, -5.17679714e-02f, -8.88380781e-03f, 5.30453287e-02f, 1.10125721e-01f, -5.39858341e-02f, -3.14731225e-02f,
  3.71875167e-02f, 3.83283384e-02f, -1.70492887e-01f, 5.17113358e-02f, -2.25255806e-02f, -4.76574190e-02f, 1.08039696e-02f, 3.16857509e-02f, -2.59077479e-03f, -3.68070230e-02f,
  -3.62219006e-01f, -3.87279451e-01f, -1.87106982e-01f, 8.65949988e-02f, 6.77705035e-02f, -6.67450950e-02f, -1.09354697e-01f, -3.07329278e-02f, -3.33207585e-02f, -2.65276264e-02f,
  -5.61601408e-02f, -2.15481877e-01f, -1.33064240e-01f, -7.37545341e-02f, -1.00095592e-01f, 1.63463186e-02f, -1.36635918e-02f, 8.17772374e-02f, 1.20989438e-02f, -7.74675012e-02f,
  -2.07376871e-02f, 6.80724308e-02f, 1.79725021e-01f, 7.55238831e-02f, -8.87351334e-02f, -1.47552416e-01f, -2.99092829e-02f, 7.49553367e-02f, 1.39795020e-01f, 4.94576581e-02f,
  -3.83868486e-01f, 1.57061666e-01f, -6.30577207e-02f, 3.07650231e-02f, 6.06783293e-02f, -4.04884592e-02f, 2.88166385e-02f, -1.56377256e-01f, -1.24802738e-02f, -2.77592707e-02f,
  -4.43223342e-02f, 4.84639741e-02f, 4.43249494e-02f, 4.12602797e-02f, -1.44309038e-03f, 1.39791444e-01f, 3.05503905e-01f, -4.75744270e-02f, -1.45344168e-01f, 2.53362097e-02f,
  3.93177681e-02f, -1.36896104e-01f, -2.82846421e-01f, -1.07316524e-01f, 8.64954665e-02f, 7.52859265e-02f, 8.21104497e-02f, -1.79507770e-02f, 1.65412396e-01f, 3.75963956e-01f,
  6.87584048e-04f, -3.10721874e-01f, -7.16031492e-02f, 4.07360941e-02f, 2.06688535e-03f, -1.38964757e-01f, -8.08672085e-02f, -1.11030579e-01f, -8.99497047e-02f, -1.97848827e-02f,
  6.98178336e-02f, -1.46587148e-01f, 1.49546653e-01f, -1.38401985e-01f, -5.95136769e-02f, -1.66566342e-01f, -2.50443041e-01f, -9.80700776e-02f, -1.25138804e-01f, -5.45718558e-02f,
  2.46212170e-01f, 1.20145611e-01f, -1.46402001e-01f, 1.14194967e-01f, 8.36111326e-03f, -5.66662028e-02f, -1.32673487e-01f, -1.53945029e-01f, -2.80086815e-01f, -2.65599966e-01f,
  -4.16467153e-02f, -9.85421389e-02f, 4.54922542e-02f, -1.13866381e-01f, 4.06562313e-02f, 1.34201452e-01f, -1.92809198e-02f, 1.35059297e-01f, 5.71046546e-02f, -3.20143513e-02f,
  6.12832010e-02f, -1.18809596e-01f, -1.12070061e-01f, -1.39521405e-01f, -1.04901083e-01f, 2.62372047e-02f, -7.77362213e-02f, 9.45872720e-03f, -2.80611427e-03f, -9.84412134e-02f,
  6.35101125e-02f, 4.02156115e-02f, -2.00321171e-02f, 2.93692145e-02f, 1.23145938e-01f, -5.84745605e-04f, 4.85533811e-02f, 2.21561007e-02f, -8.28361884e-02f, 8.31754506e-03f,
  -3.13294560e-01f, -1.33227110e-01f, -1.11086600e-01f, -1.65461618e-02f, -1.22541152e-01f, 6.25989735e-02f, -3.38120386e-02f, 2.78902892e-02f, -1.52468771e-01f, -6.41144067e-02f,
  2.27523483e-02f, 4.30116095e-02f, 6.75141737e-02f, -2.43437104e-02f, 8.69849473e-02f, 2.55270638e-02f, -2.83114761e-02f, 3.22863646e-02f, 3.57705355e-03f, -1.61367983e-01f,
  1.05519064e-01f, -8.09033401e-03f, -1.36757419e-01f, -5.48054390e-02f, 3.16750109e-02f, -1.64975747e-01f, -1.06232867e-01f, -2.19612360e-01f, -3.28541040e-01f, -3.30724776e-01f,
  5.29235303e-01f, -4.67753410e-02f, 8.67544115e-02f, 1.74021393e-01f, -2.39210278e-01f, -1.89186752e-01f, -3.64967555e-01f, -1.55310050e-01f, 3.97373177e-02f, -1.69457532e-02f,
  1.83757752e-01f, 3.14344555e-01f, 3.00123841e-01f, 5.70661537e-02f, 1.56897381e-01f, -9.87575799e-02f, 6.94178492e-02f, 3.33817691e-01f, 3.29349101e-01f, 1.60598859e-01f,
  2.29558088e-02f, 2.30524670e-02f, 1.91709578e-01f, 1.06805883e-01f, 1.01744190e-01f, 6.95191473e-02f, 2.35727746e-02f, 5.67603111e-02f, 1.36153206e-01f, 2.81247288e-01f,
  7.32862428e-02f, 7.93998018e-02f, 9.00246799e-02f, 2.10814588e-02f, -8.48744437e-02f, -1.65853295e-02f, -1.22970842e-01f, -1.01675689e-01f, -7.82416686e-02f, -1.53155684e-01f,
  -6.31362418e-05f, 5.95093668e-02f, 4.58134785e-02f, -1.15522034e-01f, -3.05121224e-02f, -1.52699100e-02f, 3.46303657e-02f, 2.07272694e-02f, 2.60978169e-03f, -1.29568041e-03f,
  -3.89742255e-02f, -1.25778569e-02f, -1.30558357e-01f, -4.57964167e-02f, -3.94269116e-02f, 1.86820224e-01f, 6.77360743e-02f, 3.64289358e-02f, 1.00702919e-01f, 5.55829257e-02f,
  2.07177892e-01f, 1.23299412e-01f, 2.74536967e-01f, 6.21089824e-02f, 8.75091925e-02f, 7.01987296e-02f, 6.63824659e-03f, -3.64194848e-02f, 1.43500948e-02f, 9.53300893e-02f,
  1.18181512e-01f, 1.20664760e-01f, -1.38792791e-03f, -6.95651164e-03f, -6.50865659e-02f, -7.86259547e-02f, -5.43027110e-02f, -9.52615663e-02f, 8.49284157e-02f, -5.81625551e-02f,
  4.38777283e-02f, -4.65213954e-02f, 7.50400573e-02f, -4.13402431e-02f, 1.15490623e-01f, 1.12941280e-01f, 1.81838244e-01f, 1.12094574e-01f, 5.72067462e-02f, 7.51356035e-02f,
  -6.20991290e-01f, 1.13345593e-01f, 1.80865169e-01f, 1.59574166e-01f, -7.34381378e-02f, -1.14252672e-01f, 5.00839464e-02f, -6.10993132e-02f, -2.81896830e-01f, -1.10853270e-01f,
  -1.20909244e-01f, 1.33528322e-01f, -8.77825916e-02f, 1.36574311e-02f, -2.91951522e-02f, -7.98844546e-02f, 1.92222763e-02f, 6.25939965e-02f, 5.15724383e-02f, -4.31043170e-02f,
  -3.50059308e-02f, -1.13860697e-01f, -8.89644176e-02f, -1.10714599e-01f, -8.27698633e-02f, 2.41457764e-02f, 6.55391114e-03f, 5.82424477e-02f, 2.59596296e-02f, -1.15912743e-01f,
  4.63356853e-01f, -4.12453711e-01f, 3.84994686e-01f, 1.98479190e-01f, -1.54044762e-01f, 1.50624663e-01f, -3.95213813e-02f, 8.51367563e-02f, 4.26268205e-02f, -1.36440769e-01f,
  -2.81719655e-01f, -2.20433921e-01f, -1.59295827e-01f, -5.18706031e-02f, -9.32817161e-03f, 1.60427317e-02f, 1.38251677e-01f, 3.89815450e-01f, 3.91621649e-01f, 7.42500126e-02f,
  -1.13267675e-01f, 2.27551199e-02f, 2.13869229e-01f, 1.61900461e-01f, -1.63187727e-01f, -8.90879706e-03f, -1.53485648e-02f, -4.32404876e-02f, -9.34229419e-02f, -4.86182086e-02f,
  -6.92191124e-02f, 9.38274264e-02f, 6.73635229e-02f, -2.16241583e-01f, -1.56698555e-01f, 5.68586551e-02f, -7.65290931e-02f, -5.59783168e-02f, -1.01215497e-01f, 2.73426361e-02f,
  -1.48579508e-01f, -5.32801114e-02f, 2.28908192e-02f, -8.41290653e-02f, -8.95422790e-03f, -2.84971274e-03f, -8.93071368e-02f, 3.84444855e-02f, 1.81737188e-02f, -1.15565300e-01f,
  -1.95716023e-01f, -8.23104903e-02f, 1.12430394e-01f, 4.75935675e-02f, 1.01475842e-01f, 9.91487801e-02f, -1.22769989e-01f, -8.26848447e-02f, -4.35334258e-03f, 9.14075822e-02f,
  -2.50822920e-02f, -3.57225202e-02f, -5.99178039e-02f, 2.69931443e-02f, 9.48748738e-03f, 3.34423557e-02f, 3.46712992e-02f, -1.43051026e-02f, -1.22632228e-01f, -5.71788289e-03f,
  -3.12224887e-02f, 2.99873408e-02f, 2.90899165e-02f, -4.87074554e-02f, -8.39838237e-02f, 3.78249586e-02f, -7.86917508e-02f, -1.11425810e-01f, -6.49891198e-02f, -3.13140973e-02f,
  -1.21907808e-01f, -1.10454867e-02f, 1.98772270e-02f, -7.22831255e-03f, 4.66729030e-02f, -4.41968581e-03f, -2.42404249e-02f, -7.70689920e-02f, -4.82797697e-02f, -8.41924474e-02f,
  -2.84407884e-01f, -7.60843456e-02f, 6.70654029e-02f, 4.87192646e-02f, -1.30752549e-02f, -1.14973761e-01f, -5.10829687e-02f, -7.46072978e-02f, 2.16500107e-02f, 1.08756855e-01f,
  2.82902215e-02f, 9.18837115e-02f, -6.49078842e-03f, -1.66791424e-01f, 9.71635729e-02f, 7.52930483e-03f, -1.98147908e-01f, -8.33957046e-02f, -7.52730519e-02f, -3.65905836e-02f,
  -1.59452289e-01f, 1.15208402e-01f, 8.77527446e-02f, 2.67522559e-02f, -1.23732518e-02f, 5.22195697e-02f, 1.52176302e-02f, 5.77978268e-02f, 7.15425387e-02f, 1.33607566e-01f,
  -4.85179335e-01f, -2.32237056e-01f, -2.58727908e-01f, -9.13075879e-02f, 2.17231363e-01f, 2.26716682e-01f, 1.56801715e-01f, 2.28869934e-02f, -2.11688522e-02f, -1.78187173e-02f,
  4.95189875e-02f, 7.83991218e-02f, 4.12390009e-02f, 1.88549887e-02f, 3.43157735e-04f, 1.54050618e-01f, 1.21760435e-01f, -8.33194107e-02f, 1.87075883e-01f, 2.03288674e-01f,
  2.00464353e-01f, -1.31195381e-01f, -1.47493526e-01f, -5.45297712e-02f, -2.47579515e-02f, 1.00081488e-01f, -1.35687813e-01f, -5.25018163e-02f, 5.50621599e-02f, -1.27660275e-01f,
  -3.14991713e-01f, -1.94010258e-01f, 2.02288762e-01f, -1.26094930e-02f, -2.23449469e-01f, -1.32978976e-01f, -5.70828132e-02f, -2.29938328e-01f, -1.34081632e-01f, -1.30325049e-01f,
  -1.77250206e-02f, -4.52542752e-02f, -1.77201889e-02f, 1.08934136e-03f, -7.83935264e-02f, -4.02236208e-02f, -4.14159670e-02f, -1.47408441e-01f, -3.15124929e-01f, -2.60228723e-01f,
  1.08135223e-01f, -4.35388088e-02f, -2.22962573e-01f, -7.39820255e-03f, -1.46999732e-01f, -2.17097536e-01f, -1.49529830e-01f, -2.23334804e-01f, -9.17894766e-02f, -4.70239758e-01f,
  -3.28083746e-02f, -3.60053703e-02f, -1.00904882e-01f, 3.13386843e-02f, 8.59553441e-02f, 6.74757808e-02f, 9.79914665e-02f, 3.00819669e-02f, 7.65812993e-02f, -7.20964521e-02f,
  -4.27573770e-02f, 7.08321258e-02f, -2.35356507e-03f, -3.30214240e-02f, 2.50668656e-02f, 1.91870017e-03f, 5.26721589e-02f, -4.35349718e-02f, -4.55406234e-02f, -1.09162182e-02f,
  -4.55390736e-02f, -6.96470514e-02f, -1.91297624e-02f, -2.85483599e-02f, 8.45583305e-02f, 2.26591770e-02f, -2.64920015e-02f, 4.41157073e-02f, -1.00604417e-02f, -1.42150288e-02f,
  -3.18149745e-01f, 9.45009664e-02f, 1.71994530e-02f, 3.77690084e-02f, -7.36304969e-02f, -5.37351817e-02f, -1.11849152e-01f, 2.10391656e-02f, -1.26934737e-01f, -2.50016749e-02f,
  -5.18277697e-02f, -2.59882659e-02f, -5.52197099e-02f, -6.04139790e-02f, 1.35040835e-01f, -6.43196255e-02f, 1.03794076e-01f, 1.37503058e-01f, -7.65291378e-02f, -2.91223126e-03f,
  2.67506801e-02f, -4.90921596e-03f, -7.38291442e-02f, -8.25036690e-02f, -1.86798628e-02f, -8.54719207e-02f, -1.12750843e-01f, -6.97125494e-02f, 1.30129820e-02f, -1.77375048e-01f,
  -2.99243808e-01f, -2.98756331e-01f, 2.61000007e-01f, 1.09143399e-01f, 3.78991753e-01f, 2.83981323e-01f, 5.03431618e-01f, 9.39792991e-02f, -2.22608317e-02f, -5.89239085e-03f,
  -3.18112671e-01f, -2.75838852e-01f, -3.27249885e-01f, -6.28834665e-02f, -1.04690917e-01f, 4.15696591e-01f, 2.97315508e-01f, 1.63746849e-01f, 5.71252555e-02f, 1.69401735e-01f,
  -7.55277500e-02f, -5.39494492e-02f, -2.93833524e-01f, -1.23347089e-01f, -6.77948147e-02f, -5.62855676e-02f, 1.06357515e-01f, 1.33050606e-02f, 1.34105096e-03f, -1.73071157e-02f,
  -1.18062599e-02f, -8.68444741e-02f, 6.90549752e-03f, -1.79570436e-01f, -1.90025955e-01f, -1.79012343e-01f, 3.63968313e-03f, -8.47920999e-02f, -1.88250691e-01f, 7.17374031e-03f,
  -6.98039234e-02f, -4.80386727e-02f, -2.18404960e-02f, 1.28540739e-01f, 9.21479091e-02f, 6.95409849e-02f, -6.62081614e-02f, -1.62017494e-02f, 7.16900155e-02f, -8.24220106e-02f,
  -1.93123907e-01f, 1.25466064e-01f, 2.02458382e-01f, 1.46251321e-01f, 8.09696093e-02f, 2.62522567e-02f, -1.12811685e-01f, -6.08613454e-02f, 2.73399986e-02f, -3.73069160e-02f,
  -8.20688251e-03f, -9.73588228e-02f, 8.11394006e-02f, 8.16797651e-03f, -2.21368372e-02f, -3.59506160e-02f, 8.33974257e-02f, -5.22930315e-03f, 2.12256406e-02f, 2.08850368e-03f,
  -7.88288936e-02f, 5.25418334e-02f, 9.96341631e-02f, -3.48752476e-02f, -1.10805579e-01f, 8.94682705e-02f, 1.12083174e-01f, -3.99899036e-02f, 1.62681863e-02f, 1.22035155e-03f,
  3.87612060e-02f, -9.70586948e-03f, 1.36729209e-02f, 1.85494833e-02f, -4.25096266e-02f, 7.22991154e-02f, -1.07316218e-01f, -9.57130864e-02f, -1.18611954e-01f, 5.97148091e-02f,
  -6.95630088e-02f, 1.88488662e-02f, 7.56791458e-02f, 7.67802671e-02f, 6.53047264e-02f, -1.83528796e-01f, -4.36212383e-02f, -1.09408228e-02f, -1.01614811e-01f, -2.89373416e-02f,
  -1.16273046e-01f, -7.69053935e-04f, -5.40915951e-02f, -6.69198949e-03f, 4.11982387e-02f, -9.98198763e-02f, -8.56870506e-03f, 2.35822015e-02f, 9.86343324e-02f, -6.45400807e-02f,
  1.29312538e-02f, 1.80813879e-01f, 6.50254115e-02f, 7.35890940e-02f, 3.51204677e-03f, 1.70825645e-02f, 1.12339988e-01f, 1.21158160e-01f, 9.64546353e-02f, 6.90535083e-02f,
  -4.16174680e-01f, -3.98315072e-01f, 1.31430432e-01f, 2.41834104e-01f, 3.34433794e-01f, 1.41331553e-01f, 1.78298026e-01f, 1.72064096e-01f, 2.22593412e-01f, -6.74181134e-02f,
  -2.86161512e-01f, -3.81349064e-02f, -1.15924120e-01f, -1.65824555e-02f, -1.38916764e-02f, 2.92373836e-01f, 4.12873238e-01f, 2.63138205e-01f, 2.51380175e-01f, 1.59622550e-01f,
  5.35883717e-02f, 1.03499934e-01f, -4.27264273e-02f, 1.07806340e-01f, 7.14941008e-04f, 1.58748969e-01f, 1.73974171e-01f, 1.02370925e-01f, 2.35964097e-02f, 1.91034466e-01f,
  -2.92672366e-02f, -2.52586007e-01f, 5.98837947e-03f, -1.70989539e-02f, -1.15637526e-01f, -9.99815613e-02f, -6.50241747e-02f, 6.96865562e-03f, -7.60818273e-02f, 2.59975083e-02f,
  -6.40669614e-02f, -1.17074512e-01f, -8.12264904e-02f, -6.89934865e-02f, -8.93561319e-02f, -5.15878275e-02f, -1.53059602e-01f, -9.64144394e-02f, 1.23319395e-01f, -7.12508485e-02f,
  2.05130614e-02f, 9.34656486e-02f, 9.28673819e-02f, -5.42978123e-02f, -6.95080385e-02f, 1.90708674e-02f, -1.02474406e-01f, -9.74302441e-02f, -8.33600760e-02f, -1.04426570e-01f,
  1.30600214e-01f, -1.03666298e-01f, -1.54642537e-01f, 1.70482474e-03f, -2.24564523e-02f, -1.05840497e-01f, -2.76308786e-03f, 7.52078220e-02f, 6.77171052e-02f, -1.50450736e-01f,
  -1.28619179e-01f, 1.90312359e-02f, -5.96272945e-02f, -1.94221009e-02f, -1.53798293e-02f, 2.19112262e-02f, 3.12660225e-02f, -1.48588270e-01f, -2.23308370e-01f, -1.16678573e-01f,
  -9.19607058e-02f, 6.34295493e-02f, -3.46199796e-02f, -9.01259929e-02f, -1.01780817e-01f, -8.79524201e-02f, -6.93532173e-03f, -6.82422519e-02f, 4.28502262e-02f, -1.16586173e-02f,
  2.18154401e-01f, 5.26078194e-02f, -5.32168783e-02f, 2.98492517e-02f, 6.68443441e-02f, -8.72594342e-02f, -1.12507962e-01f, -1.60420854e-02f, 9.45730656e-02f, 6.70467019e-02f,
  -5.20771593e-02f, 3.95545550e-02f, -1.71031445e-01f, -1.21449850e-01f, 9.64169726e-02f, 4.64544930e-02f, -9.61413383e-02f, 1.26712948e-01f, 4.33786064e-02f, 2.71900669e-02f,
  -8.85317102e-03f, 4.45002280e-02f, 6.43562824e-02f, 2.98375115e-02f, 1.28142163e-01f, 1.45212069e-01f, 1.05540954e-01f, -1.28282318e-02f, 1.94064796e-01f, 6.20854236e-02f,
  7.91414008e-02f, -2.19981477e-01f, 3.60560328e-01f, -3.35965455e-02f, -1.13996319e-01f, -1.84269831e-01f, 6.56197174e-03f, -1.65012130e-03f, 2.32635643e-02f, -6.43425956e-02f,
  -1.00041576e-01f, -1.47498846e-01f, -7.61249429e-03f, 1.36152610e-01f, 1.35476798e-01f, 3.27917375e-02f, 4.35932316e-02f, 3.01545352e-01f, 2.14408427e-01f, -1.11139946e-01f,
  1.55852763e-02f, 7.75671825e-02f, 2.69667447e-01f, 1.01711251e-01f, -6.66058734e-02f, -8.08657259e-02f, 1.28370225e-01f, -7.64958188e-03f, 2.68392172e-02f, 6.95432350e-02f,
  -2.89090276e-01f, 1.54941291e-01f, 1.44726813e-01f, -7.97498971e-02f, 1.10237405e-01f, 1.80783510e-01f, -2.25118306e-02f, 5.88684939e-02f, 1.03577353e-01f, 7.40738809e-02f,
  -8.84610415e-02f, 5.05942181e-02f, 6.18458465e-02f, -4.55541313e-02f, -9.46895182e-02f, -1.92576498e-02f, 1.35299161e-01f, 1.14637241e-01f, 1.70362458e-01f, 5.51695982e-03f,
  -1.91994198e-02f, -1.67639822e-01f, -1.80242080e-02f, 7.60316849e-02f, 9.63106677e-02f, 6.01511300e-02f, 6.94534332e-02f, -7.83777535e-02f, -2.21301056e-02f, -5.50312223e-04f,
  4.21018749e-02f, -1.46282628e-01f, -1.01334147e-01f, 1.18594825e-01f, 6.49427176e-02f, 1.88060533e-02f, -1.15452148e-01f, -1.37465060e-01f, 3.14895585e-02f, 1.78645402e-02f,
  1.47476152e-01f, 7.53380954e-02f, 1.95155382e-01f, 6.58455342e-02f, -2.19281688e-02f, -1.22920126e-02f, 1.94330718e-02f, 1.17022544e-01f, 4.70902920e-02f, 5.32866828e-02f,
  1.61771730e-01f, 1.55357569e-01f, -1.16068691e-01f, 9.97123942e-02f, 1.25614852e-01f, 7.11485147e-02f, -1.19021209e-02f, -6.44240761e-03f, 9.43396837e-02f, -1.14416319e-03f,
  -2.04219192e-01f, 1.47742555e-01f, -1.88231617e-01f, -7.62266666e-02f, -1.95908800e-01f, -1.46460198e-02f, -1.49606973e-01f, 3.03353947e-02f, -6.50465190e-02f, -7.34735606e-03f,
  -1.30194217e-01f, -4.21506800e-02f, -3.58403549e-02f, -8.82297084e-02f, -8.66274908e-02f, -1.81329459e-01f, -1.68689653e-01f, 4.56217080e-02f, -4.24035974e-02f, -1.13972530e-01f,
  -8.43898673e-03f, -1.34977236e-01f, -1.96079105e-01f, -1.51330605e-01f, -2.06982687e-01f, -2.33453661e-01f, 6.48798933e-03f, -8.79314095e-02f, -6.09287573e-03f, 2.32648384e-02f,
  -4.32512879e-01f, -1.72414079e-01f, -2.09752411e-01f, -2.89461493e-01f, -1.52472809e-01f, 1.34215178e-02f, -5.91320358e-03f, 1.27493292e-01f, -5.56193553e-02f, -2.54286468e-01f,
  -1.54585510e-01f, 4.78441417e-02f, -1.93942294e-01f, -1.17562627e-02f, -6.23797663e-02f, -3.20026219e-01f, -1.99594378e-01f, -1.98915843e-02f, 2.59583861e-01f, 2.80540556e-01f,
  -4.72966358e-02f, -1.18280552e-01f, -4.58629318e-02f, -7.64905359e-04f, -6.81128055e-02f, -4.31814753e-02f, -2.92449445e-01f, -9.98459533e-02f, 7.32160918e-03f, -3.25759560e-01f,
  -3.46729532e-02f, 9.64544415e-02f, 4.26960438e-02f, 5.63350581e-02f, -4.21981253e-02f, -3.49338427e-02f, -9.64960232e-02f, 3.10512558e-02f, 6.66385144e-02f, -4.59136106e-02f,
  -4.61375304e-02f, 3.53085473e-02f, -9.64906439e-02f, 2.24714056e-02f, -1.65052041e-02f, 7.91964773e-03f, 1.82566997e-02f, 5.47525883e-02f, -1.07346680e-02f, 1.56269908e-01f,
  7.70327821e-02f, 6.76736236e-02f, 2.76423749e-02f, 1.68854162e-01f, 2.21365973e-01f, -2.85809450e-02f, 6.73302412e-02f, 1.12193651e-01f, 2.37463474e-01f, 3.48432548e-02f,
  8.40431973e-02f, -1.73028857e-02f, -4.58023772e-02f, 9.47140753e-02f, 2.43555917e-03f, 2.81953923e-02f, 6.33847192e-02f, -6.15554564e-02f, 9.29983407e-02f, -1.33615024e-02f,
  -5.46558388e-02f, -3.83191109e-02f, 2.14461703e-03f, -1.38121797e-02f, -1.21996224e-01f, -3.07185557e-02f, -8.65193307e-02f, -8.33307207e-02f, 6.51377738e-02f, -1.37106076e-01f,
  -2.72740088e-02f, 2.09117923e-02f, 1.24986088e-02f, 4.63365130e-02f, -7.77856335e-02f, 1.76985376e-02f, 3.23513001e-02f, 2.22360436e-02f, -4.85334024e-02f, -4.40800330e-03f,
  -1.73670143e-01f, 1.33940661e-02f, -1.89859927e-01f, 1.27265483e-01f, 1.32370945e-02f, -5.02310097e-02f, 5.51391542e-02f, 1.33874202e-02f, -8.57311860e-03f, 2.10688310e-03f,
  8.15525353e-02f, 2.35694218e-02f, -1.10477306e-01f, -5.92773072e-02f, -8.78986195e-02f, -2.96928417e-02f, -1.09557450e-01f, -8.61245245e-02f, 1.25525922e-01f, 2.65649310e-03f,
  1.38770089e-01f, 6.81197271e-02f, -8.82690921e-02f, 1.64336152e-02f, 1.52465925e-01f, 4.41466719e-02f, 9.04211923e-02f, 8.92295986e-02f, 7.57653788e-02f, -1.51813477e-01f,
  -1.54880822e-01f, -2.55980521e-01f, -3.05410653e-01f, 2.42755085e-01f, 2.81690001e-01f, -4.61633503e-02f, -2.40415514e-01f, 2.79611740e-02f, 2.38635466e-01f, -5.19557968e-02f,
  2.06020370e-01f, 3.39042753e-01f, 1.72755361e-01f, -2.53405757e-02f, -6.88776150e-02f, -2.64101177e-01f, -8.38709846e-02f, -1.76599517e-01f, -3.54837850e-02f, 1.31338805e-01f,
  2.37355486e-01f, 9.37744826e-02f, -4.33229506e-02f, 3.27461585e-02f, 5.23943417e-02f, 1.45746857e-01f, -5.83083220e-02f, 7.55276680e-02f, -5.46578802e-02f, -1.89383075e-01f,
  -3.48393470e-02f, -2.19078109e-01f, -6.45615831e-02f, 1.82178825e-01f, -4.45130765e-02f, -3.17398086e-02f, -5.14189899e-03f, -1.61789447e-01f, -9.29247141e-02f, -5.57729527e-02f,
  1.01161011e-01f, 2.94734277e-02f, 1.44486474e-02f, -4.67178486e-02f, -6.79749921e-02f, -4.17737775e-02f, -1.46375865e-01f, -3.36757749e-01f, -2.93473601e-01f, -2.59107202e-01f,
  -4.12598439e-03f, 7.23130405e-02f, -3.48314673e-01f, -3.07909399e-01f, -3.14423203e-01f, -1.08473919e-01f, -2.11095005e-01f, -3.12837124e-01f, -3.32493305e-01f, -3.47620100e-01f,
  -5.61998487e-02f, -1.80896409e-02f, -6.89018965e-02f, -5.03094867e-02f, 4.47881147e-02f, 1.10390238e-01f, -6.30854517e-02f, -3.01731527e-02f, 3.03195380e-02f, -1.00828052e-01f,
  1.18597969e-01f, -2.20489483e-02f, 5.34600541e-02f, 5.72504289e-02f, 1.23802744e-01f, -6.37640953e-02f, 1.11544440e-02f, -5.16641811e-02f, -2.63112411e-02f, -8.13782513e-02f,
  7.07248747e-02f, 1.05025768e-01f, 2.24348810e-02f, -4.35185060e-02f, -1.36967078e-01f, -4.66162339e-02f, -1.92800742e-02f, 1.72497388e-02f, 2.32861191e-02f, 1.23168565e-01f,
  2.85405040e-01f, -8.04350153e-02f, 5.61208166e-02f, 3.38671803e-02f, 2.28817817e-02f, -1.01487665e-02f, 7.63989165e-02f, -3.43224257e-02f, 1.26465827e-01f, -7.15469122e-02f,
  -1.57234952e-01f, -1.06250905e-01f, 7.19545484e-02f, -1.49104699e-01f, 6.12818152e-02f, 5.74649684e-02f, -5.74189723e-02f, -3.73575911e-02f, -3.24649811e-02f, 5.92632731e-03f,
  -2.11104110e-01f, -1.81504115e-01f, -1.77832663e-01f, -1.74849644e-01f, -2.38752142e-02f, 6.05917089e-02f, -9.39767137e-02f, -1.24170855e-01f, -1.63357243e-01f, -2.35868812e-01f,
  -8.95769656e-01f, -2.39935711e-01f, 5.14137745e-02f, -3.01050901e-01f, 3.67636979e-02f, 1.10831140e-02f, 3.48124234e-03f, 2.88033709e-02f, -1.13742910e-01f, 1.11901565e-02f,
  -1.60135329e-02f, -7.28734434e-02f, 1.73642319e-02f, -4.98003233e-03f, -7.28759095e-02f, 2.96037439e-02f, -8.82589072e-02f, -3.21102962e-02f, 5.62179796e-02f, 8.23332071e-02f,
  -3.50848548e-02f, -1.11017264e-01f, -2.08524227e-01f, -4.15210100e-03f, -9.47795659e-02f, 1.63736358e-01f, 9.89491493e-02f, -5.97399734e-02f, 8.52838010e-02f, -1.93670198e-01f,
  3.96639258e-01f, -2.88094103e-01f, -9.21183899e-02f, -1.01755090e-01f, -7.07123503e-02f, -4.85858470e-02f, -3.33055034e-02f, 3.98771092e-03f, -1.52731359e-01f, -3.45577896e-02f,
  -5.40042631e-02f, 3.15415561e-02f, -2.63401214e-02f, -1.13834590e-01f, -5.94658107e-02f, -3.43140811e-02f, -1.03636146e-01f, -6.02101013e-02f, -6.57371953e-02f, 1.63719475e-01f,
  6.23256750e-02f, 1.03811070e-01f, 1.20009780e-01f, 2.72815973e-02f, 3.51628140e-02f, -1.24655934e-02f, 4.49603535e-02f, 4.79802005e-02f, 2.65751742e-02f, 4.14698571e-02f,
  7.12197125e-02f, -1.32735297e-02f, -5.43253571e-02f, 2.17653271e-02f, -6.88698664e-02f, -6.57994077e-02f, -7.12240562e-02f, 5.84474355e-02f, 1.59455203e-02f, -7.75241330e-02f,
  3.65214236e-02f, 1.20487802e-01f, 2.92226505e-02f, 3.57309282e-02f, 1.91389788e-02f, 6.48773164e-02f, -6.78675398e-02f, 5.85589819e-02f, 6.06727153e-02f, -5.12256138e-02f,
  -1.97698157e-02f, 6.40769899e-02f, -1.82859242e-01f, 9.38659608e-02f, 5.47530837e-02f, -1.26165614e-01f, 2.65619121e-02f, -4.63504642e-02f, -1.17720384e-02f, -1.84546426e-01f,
  4.54022974e-01f, -2.12576594e-02f, -6.66588172e-02f, 2.12483648e-02f, 1.11845978e-01f, 2.42186803e-02f, -6.04694709e-02f, 1.29291955e-02f, 9.53556746e-02f, 8.14174488e-02f,
  1.22316651e-01f, -2.29683612e-02f, -9.48413312e-02f, 5.07760830e-02f, 1.40857384e-01f, 1.14644982e-01f, 1.25708338e-02f, 6.67953724e-03f, 1.94745854e-01f, 1.36879966e-01f,
  -1.90579053e-02f, 2.01792270e-02f, 1.51192605e-01f, 1.17236428e-01f, 1.61003724e-01f, 1.39549494e-01f, 1.46152481e-01f, 1.97764322e-01f, 1.51238590e-01f, 9.69604552e-02f,
  1.97674349e-01f, -2.75268137e-01f, -3.58091354e-01f, -2.35502109e-01f, -1.69985369e-01f, -1.13325939e-01f, -2.72462070e-01f, -1.00616127e-01f, -1.07582234e-01f, -4.07133251e-01f,
  -2.13736534e-01f, 1.04181819e-01f, -4.64575626e-02f, -6.40409589e-02f, 2.99860686e-02f, -2.73423880e-01f, -3.34542543e-01f, -4.28288765e-02f, 2.28854254e-01f, 4.67379801e-02f,
  -1.01804569e-01f, -9.96717289e-02f, 1.56275377e-01f, -1.10565750e-02f, -3.47069085e-01f, -1.28815979e-01f, -3.15624446e-01f, -2.04327255e-01f, -1.13411427e-01f, -3.10316533e-01f,
  -2.96003103e-01f, 1.61927298e-01f, 1.09488621e-01f, 1.45057201e-01f, 4.77713579e-03f, 1.12055741e-01f, -9.50794145e-02f, -4.61704843e-02f, 7.27479979e-02f, 1.67228710e-02f,
  8.99958536e-02f, -2.33643465e-02f, 1.65417455e-02f, 4.85008992e-02f, -6.31328579e-03f, 1.28909841e-01f, 1.18539907e-01f, 5.83136939e-02f, -5.04747257e-02f, 2.33854111e-02f,
  -8.31047595e-02f, 3.68673652e-02f, 4.74150777e-02f, 5.06403297e-02f, 1.64794773e-01f, 9.85068530e-02f, -1.63808931e-02f, 1.37309477e-01f, 1.56396963e-02f, -1.31834745e-01f,
  -1.47849843e-02f, 2.00255681e-02f, 2.41357386e-02f, 8.62193480e-03f, 6.38752580e-02f, 3.59811038e-02f, 7.27920160e-02f, -9.00015235e-03f, 1.19264528e-01f, 1.15689617e-02f,
  -1.14332892e-01f, -4.01277691e-02f, 5.58638014e-02f, -4.77373898e-02f, -1.89415470e-01f, -6.42918572e-02f, -4.03674878e-02f, -4.84830663e-02f, -6.17254637e-02f, 3.92818116e-02f,
  5.77551611e-02f, -9.97549016e-03f, -1.08319573e-01f, -6.51952922e-02f, -9.67564881e-02f, -5.85098043e-02f, -2.37190500e-02f, -7.24678338e-02f, -1.38005406e-01f, 4.80306484e-02f,
  -3.05404842e-01f, 1.36836097e-01f, -1.29874706e-01f, -2.79249772e-02f, 5.92252647e-04f, 6.91585839e-02f, -1.15778781e-01f, -3.80424038e-02f, 4.93636392e-02f, -1.82833597e-02f,
  1.39040902e-01f, -1.58580940e-03f, -1.08195193e-01f, 2.62112133e-02f, 1.64161608e-01f, 1.34142295e-01f, 7.06122518e-02f, 7.28005543e-02f, 9.98487994e-02f, -6.33264566e-03f,
  -5.30943321e-03f, 7.98231736e-02f, 1.69259906e-01f, 7.63373971e-02f, 1.81746140e-01f, 1.05588429e-01f, -2.43922858e-03f, 9.00010914e-02f, 4.17868197e-02f, -5.64112253e-02f,
  2.49523029e-01f, 1.23546265e-01f, -9.95958820e-02f, 5.31975888e-02f, -3.46650004e-01f, -2.49546632e-01f, -3.67650315e-02f, -2.83775330e-02f, -4.44923937e-02f, 9.45462659e-02f,
  -1.12896681e-01f, -5.04880324e-02f, 3.80126238e-02f, -1.63587734e-01f, 1.28997564e-02f, 1.63986489e-01f, 8.88758898e-03f, 5.53004630e-02f, -2.02459306e-01f, -3.08976471e-01f,
  7.00460235e-03f, 2.05045193e-01f, 2.17184752e-01f, -1.09806813e-01f, 6.09428510e-02f, -7.10804537e-02f, 1.02145620e-01f, 5.96211143e-02f, -1.36607751e-01f, 9.70325470e-02f,
  1.01014134e-02f, -2.80844659e-01f, -1.56306624e-01f, -1.99635103e-01f, -1.93555765e-02f, -1.88789163e-02f, -9.46600065e-02f, -2.51840334e-03f, -1.39969751e-01f, 5.51632978e-02f,
  -2.59201914e-01f, -2.38558561e-01f, -2.98668176e-01f, -1.61922395e-01f, -4.25381847e-02f, -5.44282841e-03f, 6.25300258e-02f, -8.92649963e-02f, 7.07395300e-02f, 5.68425693e-02f,
  -1.66385934e-01f, -1.85432345e-01f, -3.03061604e-02f, -9.99492034e-02f, -1.08457111e-01f, -1.77992389e-01f, -3.39111611e-02f, -2.26109803e-01f, -9.05548483e-02f, 3.33587110e-01f,
  3.38895246e-02f, -5.41121140e-02f, -6.12109676e-02f, 1.17664374e-01f, 1.28043115e-01f, 7.31453532e-03f, 9.59709100e-03f, 2.78429259e-02f, 3.24085169e-02f, 5.75599223e-02f,
  -2.84221806e-02f, 2.26364285e-02f, 6.80762082e-02f, 8.32713023e-03f, -1.76368013e-01f, -3.44404913e-02f, -1.93645097e-02f, 1.75406501e-01f, 8.64424556e-02f, 1.39346821e-02f,
  -7.63839260e-02f, -6.11861572e-02f, 5.60978390e-02f, -1.02233909e-01f, 2.17904355e-02f, -3.45606133e-02f, -7.33222738e-02f, -8.02401900e-02f, 5.16981483e-02f, -5.48088960e-02f,
  3.56154621e-01f, -2.70518780e-01f, 1.98279306e-01f, -6.09719902e-02f, -1.23035297e-01f, -4.55685034e-02f, 3.85967754e-02f, 3.09300032e-02f, -2.94075664e-02f, 7.26839602e-02f,
  -1.46930665e-01f, -1.53101400e-01f, 4.24838811e-02f, 1.73807703e-02f, 5.10334484e-02f, -5.34532443e-02f, 6.00855425e-02f, -4.07946445e-02f, 9.64539796e-02f, 2.16732472e-02f,
  1.67391628e-01f, 1.00764759e-01f, 2.58860111e-01f, 6.39522895e-02f, -4.37552575e-03f, 7.41661638e-02f, 2.01413482e-01f, -3.30468118e-02f, 1.57870471e-01f, 4.48302686e-01f,
  -4.32542637e-02f, -2.86108702e-01f, -1.61851421e-01f, -6.46282881e-02f, 5.47222644e-02f, 6.04823716e-02f, -6.27187043e-02f, 4.85023148e-02f, 6.70985058e-02f, -2.10382849e-01f,
  2.83604544e-02f, 1.04175448e-01f, -3.49952094e-02f, 1.88172430e-01f, 1.69773325e-01f, -2.55192578e-01f, -3.18407893e-01f, -9.24164429e-02f, 2.53984600e-01f, 2.28268012e-01f,
  1.68270692e-01f, -1.61706712e-02f, 6.86608553e-02f, 1.47970572e-01f, -3.84952277e-02f, -1.59863289e-03f, -2.50677109e-01f, -1.50664970e-01f, 6.07391670e-02f, -2.82177240e-01f,
  -1.14148825e-01f, 8.02188739e-03f, 1.16961278e-01f, 3.21962102e-03f, -2.28679609e-02f, 1.63940161e-01f, -2.99869999e-02f, -2.93919612e-02f, -1.26541741e-02f, 2.47126762e-02f,
  1.90208014e-02f, 2.75081545e-02f, -8.55657551e-03f, 8.56627151e-02f, 4.34834659e-02f, -3.47609259e-02f, -1.02783972e-02f, -6.71494380e-02f, -1.04216963e-01f, -8.09099823e-02f,
  -1.01080634e-01f, -1.43510833e-01f, -1.84299052e-02f, -9.98850167e-02f, 3.28799859e-02f, -1.31718218e-01f, 4.89266495e-05f, 1.87965520e-02f, 7.95783326e-02f, -1.16074316e-01f,
  -2.38572545e-02f, -6.73805997e-02f, 6.14894032e-02f, 7.73136616e-02f, -4.39918898e-02f, -5.98623343e-02f, -1.22662596e-01f, 5.21544293e-02f, 1.88388359e-02f, -7.98591375e-02f,
  -4.73922230e-02f, -6.07635938e-02f, -5.33515215e-02f, -8.78056064e-02f, -7.13836104e-02f, 7.98552018e-03f, 1.26148462e-02f, -2.26172861e-02f, 8.82710367e-02f, 1.04644626e-01f,
  -6.45636115e-04f, -2.01063547e-02f, -1.11009225e-01f, 1.65032715e-01f, 3.92423496e-02f, 7.73825124e-03f, -5.37030287e-02f, 3.77408750e-02f, 1.02573028e-02f, 1.42073864e-02f,
  -4.68743928e-02f, 1.87201221e-02f, -1.24704301e-01f, 7.46774301e-02f, -5.56988679e-02f, 7.45670358e-03f, -8.61079153e-03f, -1.89247951e-02f, 2.14180201e-02f, -1.71561409e-02f,
  1.02944434e-01f, -5.43232933e-02f, -1.30205229e-01f, -8.18677098e-02f, -1.69200636e-02f, -3.23757604e-02f, 4.86508943e-02f, 6.75582141e-02f, 1.04887888e-01f, 1.02627814e-01f,
  -9.52020809e-02f, -6.56767711e-02f, 1.67041905e-02f, 1.95321254e-02f, 1.71555821e-02f, 1.44964354e-02f, 5.96411414e-02f, 3.07964366e-02f, -1.21664822e-01f, -1.63734958e-01f,
  -4.02791351e-01f, -4.03146148e-02f, 1.36382272e-02f, 1.46051928e-01f, -2.06122454e-03f, -2.10444704e-01f, -2.41443560e-01f, -2.65864402e-01f, -5.60267903e-02f, -1.36146441e-01f,
  -8.14398006e-02f, 9.58019868e-02f, 1.19131170e-01f, 3.65640894e-02f, -8.51638913e-02f, 4.68521826e-02f, 3.29417199e-01f, 1.21031784e-01f, -7.50741214e-02f, -9.19521898e-02f,
  3.91763151e-02f, -9.12044197e-02f, -8.11087191e-02f, -2.26890971e-03f, 1.62557870e-01f, 4.02752571e-02f, 1.55105582e-02f, -2.25818977e-02f, 1.14175610e-01f, 4.11321670e-01f,
  9.89657547e-03f, -1.00242212e-01f, 4.29784916e-02f, 4.68827710e-02f, 5.85961826e-02f, -8.83201212e-02f, -1.16896473e-01f, -5.92363067e-02f, 8.65578838e-03f, -4.13476191e-02f,
  2.89700806e-01f, -6.07977994e-02f, 2.40234062e-01f, 7.02819079e-02f, -3.74494791e-02f, -1.40204191e-01f, 4.70158085e-03f, -8.53882954e-02f, -1.67796955e-01f, -1.24528557e-01f,
  2.38762230e-01f, 2.32305080e-02f, -9.57516879e-02f, -5.42639717e-02f, -4.79886271e-02f, 3.63156646e-02f, -1.16094403e-01f, -4.77410406e-02f, -2.32868552e-01f, -1.41302258e-01f,
  -5.02584614e-02f, -1.51926115e-01f, 3.71767464e-03f, -5.04162945e-02f, -3.31939640e-03f, 7.74206943e-04f, 1.02973320e-01f, -2.09929254e-02f, -4.65380475e-02f, -3.90301570e-02f,
  7.68278465e-02f, -1.26190111e-01f, 5.13869189e-02f, -7.03132525e-02f, 3.44682671e-02f, -1.22428499e-02f, -4.85063642e-02f, -2.51757223e-02f, -5.43597750e-02f, -1.01817481e-01f,
  3.59845683e-02f, 6.97126761e-02f, -6.94342181e-02f, 9.16188657e-02f, 4.79743518e-02f, 4.80738282e-03f, 3.12095545e-02f, -8.39842409e-02f, -7.33527988e-02f, 1.40490765e-02f,
  -5.39061427e-02f, 9.34032723e-03f, 4.93497215e-02f, 9.84384939e-02f, -1.57032251e-01f, -4.47122827e-02f, 2.12309137e-02f, -2.53271051e-02f, 7.79972039e-03f, -1.20855540e-01f,
  -5.92396669e-02f, -8.61157179e-02f, -3.41484137e-02f, 1.26319632e-01f, 2.12012511e-02f, 5.09267636e-02f, -1.51787121e-02f, 9.69943628e-02f, -5.85437231e-02f, -5.16849905e-02f,
  -8.45660642e-02f, -2.25691408e-01f, -9.39324498e-02f, -1.05247311e-01f, -1.53748766e-01f, -1.94165364e-01f, -1.58097073e-01f, -1.66942716e-01f, -3.67324501e-01f, -3.63440931e-01f,
  -5.59898674e-01f, 3.01690251e-01f, 2.68165588e-01f, -3.26670796e-01f, 7.37020839e-03f, 5.02017476e-02f, 1.00202449e-01f, -4.92921434e-02f, -2.15000749e-01f, 1.15624160e-01f,
  6.68595508e-02f, -1.55185908e-01f, 7.91565999e-02f, -1.87610965e-02f, -6.44311234e-02f, 2.53942590e-02f, -1.44750178e-01f, -1.07715003e-01f, -1.81388661e-01f, -1.21879399e-01f,
  -5.95374629e-02f, -3.26320201e-01f, -3.16443622e-01f, -2.24815369e-01f, -9.27477479e-02f, -9.49815065e-02f, -1.64979715e-02f, -7.85779804e-02f, 7.88904279e-02f, -2.62670219e-03f,
  2.66690046e-01f, 7.21060857e-02f, 1.67620674e-01f, -1.54732853e-01f, -4.40507196e-02f, -5.32392077e-02f, -1.73415184e-01f, 1.81031898e-02f, -5.12985624e-02f, -6.56604245e-02f,
  1.60960052e-02f, 8.82919431e-02f, -1.34995729e-01f, 2.29946021e-02f, -1.35571674e-01f, -1.17687471e-01f, -1.76240265e-01f, 8.31053928e-02f, 6.77816719e-02f, -1.24650132e-02f,
  -1.32692993e-01f, -9.40776318e-02f, -6.83309212e-02f, 1.04441665e-01f, 4.66678441e-02f, -8.84952620e-02f, 3.43262479e-02f, 3.35388407e-02f, 8.95779729e-02f, -1.21654980e-01f,
  3.40229496e-02f, 5.57840616e-03f, 1.43376142e-01f, -3.52309868e-02f, -4.67525050e-02f, 2.23360118e-02f, -5.06666265e-02f, -8.97335708e-02f, -3.53525542e-02f, -2.38274578e-02f,
  -1.19507890e-02f, 7.67559186e-02f, 9.77033656e-03f, 9.75169837e-02f, 6.93057850e-02f, 9.76797007e-03f, -1.27074003e-01f, -3.62348780e-02f, -3.08311917e-02f, -8.96039233e-02f,
  -9.87751037e-02f, 4.62271795e-02f, 6.47029206e-02f, 7.07182521e-03f, -2.47328542e-02f, -5.69363385e-02f, 4.49148528e-02f, -3.10812239e-02f, 1.19427964e-01f, -3.66576551e-03f,
  -1.94897681e-01f, 2.17424780e-01f, -1.57997251e-01f, -1.09535731e-01f, -1.46254227e-02f, 9.84484516e-03f, 2.35826466e-02f, -3.34931724e-02f, 1.08687971e-02f, -1.12355947e-02f,
  3.77548374e-02f, -9.70768705e-02f, -4.61456552e-03f, -7.93749560e-03f, -5.99572696e-02f, 1.16468314e-02f, -5.46839982e-02f, -9.65502560e-02f, -2.29876470e-02f, -1.83451176e-01f,
  -1.60890117e-01f, -1.25652552e-01f, -1.70028925e-01f, -1.38792604e-01f, -5.97627237e-02f, -2.47324064e-01f, -1.15228444e-01f, -8.20413902e-02f, -4.84184474e-02f, -1.82942167e-01f,
  3.73103231e-01f, -4.49043848e-02f, 5.40227368e-02f, 2.13278323e-01f, 1.06553890e-01f, 3.41434294e-04f, 9.25954990e-03f, 1.22649923e-01f, 1.01321712e-01f, -4.51998040e-02f,
  1.42589107e-01f, 2.81010628e-01f, 2.21074998e-01f, 8.98565948e-02f, 2.03602239e-01f, 4.81524616e-02f, 1.21329419e-01f, 1.78166747e-01f, 2.11213619e-01f, 1.01852089e-01f,
  2.48001851e-02f, -1.52548514e-02f, 7.50564039e-02f, 3.70703153e-02f, -4.29860838e-02f, -9.64608695e-03f, -1.81862563e-02f, -1.01455495e-01f, -3.81812006e-02f, 9.65758860e-02f,
  1.96533218e-01f, 1.11463748e-01f, 2.81814858e-03f, -7.59953335e-02f, -1.86956182e-01f, -4.81670313e-02f, -5.62106408e-02f, -1.65661499e-02f, -3.30568589e-02f, 5.76507999e-03f,
  -1.12824373e-01f, -1.39524648e-02f, 4.60064858e-02f, -5.65707963e-03f, -3.79479378e-02f, -1.61911309e-01f, -9.22177434e-02f, 3.43419239e-02f, 2.16773808e-01f, 7.94630870e-02f,
  -4.29937355e-02f, 6.05459847e-02f, 1.74415916e-01f, 1.16586037e-01f, 8.12717006e-02f, 1.06505178e-01f, 2.28404179e-02f, 9.55035351e-03f, 8.59074593e-02f, -3.33361290e-02f,
  1.58228844e-01f, 1.91337660e-01f, 1.02243975e-01f, 5.95622808e-02f, -2.03722846e-02f, -9.47328806e-02f, -3.81036848e-02f, -2.14386433e-02f, 7.95691907e-02f, -1.32481903e-01f,
  -4.45603505e-02f, 2.31992215e-01f, 2.05724269e-01f, 9.35875922e-02f, 1.21974751e-01f, 5.45979142e-02f, 1.06208620e-03f, 9.68408585e-02f, -3.65594178e-02f, -4.71905805e-02f,
  -1.83531945e-03f, -4.47383113e-02f, -7.32475072e-02f, 2.89563858e-03f, -4.61558662e-02f, 2.02094406e-01f, 4.82385717e-02f, 9.57361683e-02f, -8.35642666e-02f, -4.56606746e-02f,
  1.31287456e-01f, 2.89432406e-01f, 1.18470229e-01f, 3.55779491e-02f, -8.53519663e-02f, -1.25048935e-01f, 1.20289274e-01f, -4.39037867e-02f, -1.66977972e-01f, -9.73138511e-02f,
  -3.28257270e-02f, -3.90628353e-02f, -1.07724957e-01f, -8.11075047e-02f, -3.36317532e-02f, -1.31496117e-01f, 7.72675360e-03f, 4.54325974e-02f, -2.77599841e-02f, -9.62593108e-02f,
  -8.40759128e-02f, 9.55236331e-02f, 8.91649276e-02f, 1.47766680e-01f, 1.23605572e-01f, 9.93493721e-02f, -1.42343819e-01f, -1.16653591e-01f, -8.50268081e-02f, -1.66638255e-01f,
  7.43959323e-02f, -3.08920145e-01f, 3.26316863e-01f, -1.78736746e-01f, -4.23645712e-02f, 4.03231122e-02f, -4.29267809e-02f, -1.04852999e-02f, -9.74975899e-02f, -1.23742014e-01f,
  -1.36347637e-01f, -4.87198532e-02f, 8.18702281e-02f, 7.33311251e-02f, 1.05464645e-01f, -1.16253663e-02f, 1.33793488e-01f, 4.08859402e-01f, 2.97752708e-01f, -1.02840394e-01f,
  -1.20373398e-01f, 4.22879122e-02f, 1.40289724e-01f, 6.44104183e-02f, -4.19656008e-01f, 2.27150824e-02f, -3.02788857e-02f, -1.74586982e-01f, -1.73523605e-01f, -1.51150674e-01f,
  1.23377055e-01f, -1.50870249e-01f, 1.02431267e-01f, -6.89576119e-02f, 7.29325935e-02f, -6.91696182e-02f, 9.45709497e-02f, 2.67605036e-02f, -6.67830482e-02f, 1.62331387e-01f,
  -4.53166030e-02f, -1.81913078e-01f, 2.48612603e-03f, -1.50034070e-01f, -3.66136655e-02f, -2.05748603e-01f, -1.16266452e-01f, -1.33334056e-01f, -1.06059782e-01f, -1.26396358e-01f,
  -3.54703039e-01f, -8.19907486e-02f, 1.15301594e-01f, -5.52539807e-03f, -1.60800532e-01f, 5.63990287e-02f, 9.04918835e-03f, -3.24828848e-02f, 5.78426570e-03f, -1.22326046e-01f,
  -6.34136051e-02f, 1.06222160e-01f, 3.59413922e-02f, -4.21395153e-02f, -6.76847771e-02f, -4.70652357e-02f, -1.55843643e-03f, -2.11785212e-01f, -2.62550805e-02f, 7.63989985e-02f,
  9.31023210e-02f, 1.20058097e-02f, 1.03893476e-02f, 8.20339993e-02f, -2.03887429e-02f, -3.13835107e-02f, 7.12061524e-02f, -2.45874822e-02f, 4.36248295e-02f, 8.59827027e-02f,
  1.82971179e-01f, 9.75065529e-02f, 8.01837668e-02f, 1.27542019e-01f, 3.49351093e-02f, 3.23908105e-02f, 1.92521308e-02f, 1.02968350e-01f, -7.91022480e-02f, 2.18012724e-02f,
  2.66075879e-01f, 7.53310844e-02f, 1.29394203e-01f, -7.80767649e-02f, 7.11131915e-02f, -4.65094820e-02f, 1.47900999e-01f, 5.92722595e-02f, -5.51564433e-02f, 7.55077079e-02f,
  1.71554647e-02f, -1.48477495e-01f, 4.02504727e-02f, 7.08355233e-02f, 1.65867001e-01f, -2.33298615e-02f, 2.92530153e-02f, 8.70987996e-02f, -5.78782475e-03f, -8.82341713e-02f,
  -1.57465398e-01f, 1.09403767e-01f, 2.52674967e-01f, 1.38821334e-01f, -7.25073516e-02f, 1.05680048e-01f, 1.23770319e-01f, 1.53557524e-01f, 1.33881763e-01f, 2.90841877e-01f,
  -5.29388428e-01f, -2.22079873e-01f, -3.29245031e-02f, -3.31534415e-01f, -1.47442296e-01f, 3.80294211e-02f, -1.73710827e-02f, -7.31380656e-02f, -7.44622350e-02f, -2.65848696e-01f,
  -8.08111280e-02f, 6.23275409e-04f, -1.69688370e-02f, 1.66894183e-01f, 1.52954072e-01f, -2.55125493e-01f, -1.32143751e-01f, 1.26037300e-01f, 2.62378693e-01f, 3.06993425e-01f,
  1.93890974e-01f, 1.05439477e-01f, 1.50280250e-02f, 4.86110337e-02f, -1.38834611e-01f, -2.09147613e-02f, -1.98852941e-01f, -5.89751229e-02f, 2.26379745e-02f, -3.11637610e-01f,
  -3.62113118e-01f, -1.75872400e-01f, 1.51785180e-01f, -2.05370542e-02f, -6.35824800e-02f, 2.47765835e-02f, 1.32636661e-02f, -8.23838860e-02f, -2.87664793e-02f, 8.06902871e-02f,
  -1.16642691e-01f, 3.14974263e-02f, 2.04939470e-02f, -7.61471167e-02f, -4.28646877e-02f, -1.12311512e-01f, 1.32093281e-01f, 5.88910617e-02f, 1.31921470e-01f, 1.37729105e-03f,
  1.62413009e-02f, -6.27874583e-02f, -7.30370432e-02f, -5.58930300e-02f, -9.97295231e-02f, 7.43848011e-02f, -1.26982957e-01f, -8.10946971e-02f, 3.11844852e-02f, -3.43754798e-01f,
  -1.13165438e-01f, -9.69739035e-02f, 1.18862033e-01f, -4.14274223e-02f, 3.50240692e-02f, -1.42824382e-01f, -1.81930568e-02f, -2.04791203e-02f, -7.54002854e-02f, -3.44045684e-02f,
  2.75552683e-02f, -1.66657865e-02f, -7.94544145e-02f, -1.02326304e-01f, 8.52352902e-02f, -8.89415666e-03f, -4.66034040e-02f, -7.97916353e-02f, 4.59253825e-02f, -7.88518116e-02f,
  -4.25573811e-02f, 2.30012480e-02f, -1.04985319e-01f, -1.76958775e-03f, 1.37450220e-02f, 2.26794071e-02f, -1.50384959e-02f, -8.27564150e-02f, 6.97427914e-02f, -3.80351581e-02f,
  -1.46173820e-01f, 2.69763708e-01f, -1.38665751e-01f, 4.64810766e-02f, 1.22685269e-01f, 8.04348290e-02f, -7.83623978e-02f, 4.78014685e-02f, -1.95104312e-02f, 4.77358103e-02f,
  -2.44612526e-02f, -2.67747417e-02f, -1.23291939e-01f, -3.11111957e-02f, 3.88877653e-02f, -7.65784159e-02f, -1.75302513e-02f, 3.96774150e-02f, 2.09168181e-01f, 3.69058922e-03f,
  -7.13230669e-02f, -1.14168532e-01f, -1.17890187e-01f, -2.06487700e-01f, -1.43326923e-01f, -1.85535941e-02f, -9.00888145e-02f, -1.79864228e-01f, 5.85508570e-02f, -2.40866199e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  9.77955535e-02f, -2.44957300e-05f, 1.47061914e-01f, 1.82813644e-01f, -4.44427840e-02f, -2.75306404e-02f, 1.09475581e-02f, 3.54767665e-02f, -1.33310750e-01f, 1.12461470e-01f,
  1.73337236e-01f, 8.47601146e-02f, -1.33535773e-01f, 1.00122280e-01f, -9.73056629e-02f, -8.80592614e-02f, 1.64371341e-01f, 3.43507119e-02f, -9.16539133e-02f, -3.38554233e-02f,
  1.16180182e-01f, 2.16456458e-01f, 4.55329614e-03f, 1.96320355e-01f, 1.70829706e-02f, 5.44093512e-02f, 1.67262733e-01f, 1.78594352e-03f, 1.32287294e-01f, 1.09078608e-01f,
  7.54466653e-02f, 1.09917007e-01f, -1.44404098e-01f, 1.18266210e-01f, 3.44913751e-02f, 2.87150964e-02f, 1.04119375e-01f, 4.71682362e-02f, 1.95153490e-01f, 1.07373908e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -4.00116183e-02f, -1.32133290e-01f, 1.11378513e-01f, 4.25246730e-02f, -2.96636224e-02f, 1.53416889e-02f, 3.15256827e-02f, -3.25137074e-03f, 4.06510234e-02f, -9.59862843e-02f,
  9.27931443e-02f, 1.30811945e-01f, -3.34635466e-01f, 6.23622462e-02f, -8.86916816e-02f, 3.92614901e-02f, -9.85311940e-02f, 1.11407742e-01f, 3.77506837e-02f, 2.49084651e-01f,
  1.26140043e-01f, 1.58064485e-01f, 5.51866367e-02f, 4.30655703e-02f, 3.44451636e-01f, 2.34761182e-02f, 4.85277683e-01f, 6.48053288e-02f, -4.43399251e-02f, -4.62279618e-02f,
  -8.38496909e-02f, -7.43138120e-02f, 8.22345819e-03f, 4.82965559e-02f, -7.65490457e-02f, -3.17937396e-02f, 4.32387851e-02f, -1.14299901e-01f, -1.14799656e-01f, -3.95111889e-02f,
  1.26282290e-01f, -5.83148561e-02f, 4.52998579e-02f, 6.79272041e-02f, -3.75024468e-01f, -1.31595224e-01f, -2.18316451e-01f, 2.16042474e-01f, 1.20537682e-02f, -3.38430345e-01f,
  -2.34003097e-01f, -5.01167178e-02f, -6.33390546e-02f, -8.16967636e-02f, 1.25702277e-01f, -1.63807511e-01f, -8.87446180e-02f, 8.92018527e-02f, -1.83503166e-01f, 8.03524852e-02f,
  -5.47410734e-02f, -3.08768284e-02f, -4.58052754e-02f, -1.42353535e-01f, -2.90875294e-04f, -7.62022361e-02f, -1.34801045e-01f, -1.34267092e-01f, -1.29471421e-01f, -1.59253285e-03f,
  7.39810010e-03f, -5.12006059e-02f, 3.59650105e-02f, -6.53515607e-02f, 1.10652624e-02f, 6.05448671e-02f, 7.73679838e-02f, 1.46766856e-01f, -2.28494387e-02f, -2.54658461e-02f,
  -8.02628025e-02f, 5.79674467e-02f, 1.32073626e-01f, -1.24694601e-01f, -3.17139834e-01f, 8.20070356e-02f, -1.95025101e-01f, 2.29314715e-02f, -1.66239277e-01f, 4.93503287e-02f,
  5.38630858e-02f, 1.37625383e-02f, 3.11118532e-02f, -1.60960689e-01f, 7.30025768e-02f, 1.23422116e-01f, 7.35431165e-02f, -3.31864506e-01f, -1.58601537e-01f, -1.28891885e-01f,
  4.53836024e-02f, 2.73454875e-01f, 1.27429157e-01f, -1.62108243e-01f, -6.45050183e-02f, 2.30374098e-01f, 9.93785262e-02f, -1.25849620e-01f, -1.75894752e-01f, 1.57301843e-01f,
  -2.48723384e-02f, 8.73976126e-02f, 2.36537814e-01f, 1.15379587e-01f, 2.42113188e-01f, 1.66893765e-01f, 3.61099876e-02f, 4.72428603e-03f, -3.28196913e-01f, -1.47662163e-01f,
  -8.95510539e-02f, -1.54595584e-01f, -4.25490784e-03f, -7.39505282e-03f, 4.64710705e-02f, 2.14177385e-01f, -1.68938980e-01f, -1.25580579e-01f, -1.65346861e-01f, -2.00280666e-01f,
  -2.61325330e-01f, -5.63112721e-02f, -6.52662888e-02f, -1.28407866e-01f, -7.56741362e-03f, -9.91165042e-02f, -3.87972128e-03f, -2.30698258e-01f, 5.78906722e-02f, -2.22283062e-02f,
  3.32282521e-02f, 9.03212428e-02f, 6.77730739e-02f, -7.54272789e-02f, -4.66084182e-02f, -3.99257131e-02f, -9.26990658e-02f, -1.12052001e-01f, -5.43751307e-02f, -6.84333518e-02f,
  -2.93037504e-01f, 6.09996766e-02f, -3.64837311e-02f, -1.19417928e-01f, -1.17902808e-01f, -1.23518147e-02f, -9.28424895e-02f, 7.26775452e-02f, 4.53810506e-02f, 1.95580423e-01f,
  8.99916142e-02f, -2.10945606e-02f, -7.80328130e-03f, -2.97221154e-01f, 1.54652540e-02f, 9.55243632e-02f, -4.77711372e-02f, -6.36536703e-02f, -1.47940159e-01f, 9.16252006e-03f,
  -1.66191220e-01f, -1.22071721e-03f, 2.89110154e-01f, 2.69248486e-01f, 2.59339780e-01f, -2.78119087e-01f, 3.91132534e-02f, 1.25162512e-01f, 2.28813693e-01f, 1.90457150e-01f,
  -1.04226202e-01f, 3.86457704e-02f, -1.05271295e-01f, 1.32143535e-02f, -1.67529523e-01f, 1.10787511e-01f, -1.30890608e-01f, 1.54703543e-01f, -2.45660376e-02f, -1.00317605e-01f,
  -1.29050046e-01f, -1.09103568e-01f, -3.29595921e-03f, 1.21788479e-01f, -7.18351901e-02f, -8.53855461e-02f, 8.00188109e-02f, 1.49492726e-01f, 8.15536901e-02f, 4.14471366e-02f,
  -7.83247352e-02f, -1.12572141e-01f, 2.66383231e-01f, 1.88072249e-02f, -7.99012110e-02f, -5.18693551e-02f, 1.63557492e-02f, -7.48255998e-02f, -1.99572429e-01f, 1.49257377e-01f,
  -2.43067831e-01f, -1.01267755e-01f, 3.76562811e-02f, 2.66798079e-01f, -2.87271738e-01f, -2.01289393e-02f, 1.63142934e-01f, 2.28396043e-01f, 1.07537992e-01f, 2.09010497e-01f,
  5.46942018e-02f, -4.72864695e-02f, -4.19485979e-02f, -6.88034669e-02f, 3.59061919e-02f, 1.76454037e-01f, 2.80841410e-01f, -1.47256320e-02f, -1.61280155e-01f, 3.14680755e-01f,
  -2.22720131e-01f, 1.18011348e-01f, -1.78516567e-01f, 2.22291183e-02f, -4.63032499e-02f, -7.66204149e-02f, -4.35714163e-02f, 1.76953107e-01f, 1.75774917e-01f, 3.43900323e-02f,
  -1.37008503e-01f, -1.13546401e-01f, -4.61017750e-02f, -2.58198708e-01f, -1.80669222e-02f, -8.00204426e-02f, 5.14431559e-02f, 6.60832226e-03f, -2.15251043e-01f, 1.54520437e-01f,
  -1.74047157e-01f, 4.93177883e-02f, 1.38230413e-01f, -1.52884364e-01f, -1.13854051e-01f, -3.22084129e-01f, -6.30029570e-03f, 8.89866203e-02f, 1.82194673e-02f, 9.21467394e-02f,
  -2.74432041e-02f, 6.56661689e-02f, -5.47042824e-02f, 5.03056915e-03f, 1.26289681e-01f, -7.89055228e-02f, 5.99712655e-02f, 1.93947002e-01f, -1.89675063e-01f, -6.64782990e-03f,
  -7.28988275e-02f, 2.98405532e-02f, 1.13734245e-01f, -4.43078578e-02f, 1.02055147e-01f, 8.54956433e-02f, 1.01434141e-01f, 1.56831071e-01f, 2.70094573e-01f, -1.55198470e-01f,
  1.35097250e-01f, 3.32397292e-03f, 3.92801195e-01f, -1.27995491e-01f, -5.45100532e-02f, 6.47717342e-02f, 9.45912078e-02f, -1.37132749e-01f, 1.27111644e-01f, 1.24123186e-01f,
  -1.09907344e-01f, 4.04504612e-02f, -1.46244010e-02f, -1.62601918e-02f, -1.94038033e-01f, -3.47594321e-02f, 2.38707662e-01f, -9.12702903e-02f, 1.57937661e-01f, 2.00337306e-01f,
  -4.29860294e-01f, -2.21411094e-01f, -1.68314818e-02f, 7.57719576e-02f, -1.55067062e-02f, -7.63191432e-02f, -3.36264133e-01f, 9.12510790e-03f, -4.53127883e-02f, 1.82621136e-01f,
  1.03215445e-02f, 1.40968606e-01f, 3.10332656e-01f, 7.69339800e-02f, 2.79144228e-01f, 1.74764678e-01f, -7.58183897e-02f, -1.65861547e-01f, 1.48999482e-01f, 1.24025330e-01f,
  5.18494584e-02f, -2.20204182e-02f, -7.39680007e-02f, 1.19005598e-01f, 2.71460354e-01f, 9.12545472e-02f, 9.33916774e-03f, -4.36312594e-02f, 5.63899502e-02f, -3.70478481e-02f,
  7.43795708e-02f, 1.18035883e-01f, 1.94997728e-01f, -9.01865587e-03f, -7.13424012e-02f, -4.26924154e-02f, -2.01338436e-02f, -1.93735033e-01f, -6.44363277e-03f, -7.04400763e-02f,
  -6.68133497e-02f, -1.09154219e-02f, -7.56424889e-02f, -1.06950298e-01f, 3.54709551e-02f, 3.56662929e-01f, 9.74756628e-02f, 8.14651847e-02f, 2.83303186e-02f, -3.13645639e-02f,
  -6.66439161e-02f, -2.67881870e-01f, 4.07862011e-03f, 2.85455864e-02f, 3.02242041e-01f, -1.16404772e-01f, -4.85450812e-02f, 1.54400751e-01f, -1.67658299e-01f, 1.47209438e-02f,
  -1.67541623e-01f, 1.23271286e-01f, -1.44033879e-01f, 7.18503147e-02f, -9.06992629e-02f, 2.08726719e-01f, -5.74671291e-02f, 2.35650897e-01f, 7.91655947e-03f, -8.30896720e-02f,
  7.94774815e-02f, 3.82071510e-02f, -2.77763885e-02f, -3.27469851e-03f, -2.56728023e-01f, -2.66400486e-01f, 6.01042435e-02f, 1.86152518e-01f, -2.19342157e-01f, -5.61360754e-02f,
  -1.60743758e-01f, -1.61590008e-03f, -1.02382563e-01f, -1.31555796e-01f, -5.87776769e-03f, -5.19239381e-02f, -1.17115676e-01f, 1.24875322e-01f, 5.12858965e-02f, 7.43824393e-02f,
  -2.71160249e-02f, 1.00201800e-01f, -3.66658680e-02f, -1.35182649e-01f, -2.10644230e-02f, 6.59192204e-02f, 3.34534585e-01f, 1.61717519e-01f, -1.55720919e-01f, 2.84931194e-02f,
  1.32573575e-01f, -5.94253242e-02f, 1.81959998e-02f, 6.59501180e-02f, -7.25407973e-02f, -4.08116251e-01f, 2.57092446e-01f, -8.58242437e-02f, -2.92984456e-01f, -2.81909496e-01f,
  4.87756799e-04f, -5.38639836e-02f, -2.14449480e-01f, 2.34459579e-01f, -4.29851711e-02f, 6.93080425e-02f, 5.08023379e-03f, 2.50344634e-01f, -2.53199726e-01f, 1.39182985e-01f,
  -1.28781065e-01f, -2.69376278e-01f, 1.65795207e-01f, -1.30544931e-01f, 1.82411835e-01f, -2.98967324e-02f, 7.13915797e-03f, 1.66724995e-01f, 8.97709001e-03f, -6.34514168e-02f,
  1.76493526e-02f, 4.39031944e-02f, 1.43098474e-01f, 1.41964719e-01f, 1.77410394e-02f, 1.26319811e-01f, 1.78639710e-01f, 1.20478429e-01f, -2.35330705e-02f, 9.33277011e-02f,
  -9.02270600e-02f, -2.77464271e-01f, 1.17070630e-01f, -1.16152270e-02f, 3.87843810e-02f, 8.68795067e-02f, 2.87038684e-01f, 3.28957856e-01f, 2.11038776e-02f, 1.20908931e-01f,
  6.51231930e-02f, -2.24904884e-02f, -1.47038087e-01f, 1.07645448e-02f, 6.24286383e-02f, -4.51688515e-03f, -6.66065067e-02f, 5.55715188e-02f, -1.16341636e-01f, 4.33664247e-02f,
  7.94574842e-02f, -1.58602986e-02f, -3.22572216e-02f, -3.36873368e-03f, 2.29141667e-01f, -7.05890879e-02f, 1.08454153e-01f, -9.46437269e-02f, 7.83555061e-02f, -1.98526353e-01f,
  2.21960962e-01f, -2.74056438e-02f, -2.75343359e-01f, -1.27563000e-01f, -5.96650653e-02f, -3.59211326e-01f, -2.19978765e-01f, 6.94237873e-02f, 1.09981582e-01f, -2.11703265e-03f,
  -6.91347718e-02f, -1.21282019e-01f, -1.57460049e-01f, 1.28209427e-01f, -9.03878734e-02f, 2.18894854e-02f, -5.02863117e-02f, -1.89960405e-01f, 1.84668779e-01f, -1.29111782e-01f,
  1.68454915e-01f, 1.21479034e-01f, 1.36686713e-01f, -1.82219729e-01f, 3.60122025e-02f, 4.23461571e-02f, 6.21946193e-02f, 3.10649127e-01f, -9.14235488e-02f, 1.78815961e-01f,
  1.65067136e-01f, 3.98539659e-03f, -2.60144118e-02f, 1.75098255e-02f, 1.84235692e-01f, -2.77921021e-01f, 1.92117214e-01f, 1.12374969e-01f, 2.94044539e-02f, 7.60150235e-03f,
  9.25713927e-02f, 3.47974360e-01f, -7.84319714e-02f, -9.75026116e-02f, 6.36068210e-02f, -5.90585284e-02f, -8.08254406e-02f, -1.10297073e-02f, -1.37719736e-01f, -3.51199061e-02f,
  -3.92733607e-03f, 8.24639127e-02f, -5.30195087e-02f, -2.89531536e-02f, 3.09737343e-02f, -2.51185186e-02f, 1.05953859e-02f, -1.05082415e-01f, 9.75363851e-02f, -7.81240538e-02f,
  1.42626405e-01f, -1.70818985e-01f, -3.52348536e-02f, -5.37698492e-02f, -1.39012262e-01f, 5.47087602e-02f, -9.93326381e-02f, -4.31678668e-02f, -2.96466678e-01f, -1.85430989e-01f,
  -3.84763926e-02f, 5.93686514e-02f, -1.27543509e-01f, 4.33667786e-02f, -1.21952564e-01f, -7.30914772e-02f, -2.02306762e-01f, -1.43428639e-01f, 7.86910653e-02f, -1.11600265e-01f,
  4.77227420e-02f, 7.53821433e-02f, -3.55839878e-02f, -4.00429405e-02f, 9.94073823e-02f, 1.48573220e-01f, 9.14691985e-02f, 7.10188001e-02f, -1.31373882e-01f, -1.53244376e-01f,
  3.04166544e-02f, 2.07663238e-01f, 2.08274990e-01f, 5.12676034e-03f, -1.67349800e-01f, 8.80665928e-02f, 1.71227138e-02f, 1.69880807e-01f, 1.61981285e-01f, -9.85799357e-02f,
  -6.87569231e-02f, -1.49292767e-01f, -1.03345975e-01f, -3.27703170e-02f, 2.55794764e-01f, 9.41210054e-03f, 3.00971745e-03f, 1.18833706e-02f, 4.91760485e-03f, -5.46995290e-02f,
  -1.19485743e-01f, -9.80424285e-02f, -1.37787431e-01f, -1.17310353e-01f, 2.17480436e-02f, -5.51445503e-03f, -1.75425429e-02f, -3.88940610e-02f, -3.00320145e-02f, 1.01332545e-01f,
  6.18831068e-02f, 1.12342000e-01f, -8.15549269e-02f, -1.48671365e-03f, 6.09205626e-02f, 1.22790292e-01f, 1.17829870e-02f, 1.18886031e-01f, 4.82572913e-02f, -1.07588336e-01f,
  -5.09707667e-02f, 1.90152302e-01f, 3.60771000e-01f, -5.98816723e-02f, -1.63663015e-01f, -1.28603980e-01f, 1.20624758e-01f, -7.42457733e-02f, 1.67222589e-01f, -1.81262091e-01f,
  -1.91801637e-02f, 2.55191207e-01f, 2.21155241e-01f, -2.36383110e-01f, 1.23656429e-02f, -7.79363215e-02f, 2.57031675e-02f, -1.61312446e-01f, -1.81800961e-01f, -9.22951847e-02f,
  7.37907737e-02f, -2.96682678e-02f, 1.95425972e-01f, 1.29393980e-01f, 5.39263189e-02f, -4.63225059e-02f, -4.56919372e-02f, -1.46919519e-01f, 2.49071699e-02f, -2.11453736e-01f,
  8.60210601e-03f, -1.46641061e-02f, -4.77243066e-02f, -5.03840344e-03f, -1.54456005e-01f, 2.63734132e-01f, -2.72506773e-01f, 8.68889838e-02f, 5.56589663e-02f, -1.24902688e-01f,
  -6.51304051e-02f, 2.11128239e-02f, -8.96271989e-02f, -3.10160723e-02f, -7.84322619e-02f, 6.81202440e-03f, -1.31027073e-01f, -1.27168577e-02f, -5.10692261e-02f, 1.55702885e-02f,
  4.83513437e-03f, 8.94599035e-03f, 7.79230669e-02f, 1.22559011e-01f, 5.97188249e-02f, 1.53672576e-01f, -8.62351656e-02f, -6.50854781e-02f, -1.04125030e-01f, -4.98492047e-02f,
  -5.39143570e-02f, -1.14701107e-01f, 1.17171276e-02f, -1.12746298e-01f, -1.44103840e-01f, -1.24490626e-01f, 1.97191425e-02f, -2.84586370e-01f, -1.72449306e-01f, 1.89605981e-01f,
  1.52809396e-01f, 1.75752759e-01f, 1.03229403e-01f, 1.45794913e-01f, -2.50456899e-01f, 7.71454424e-02f, -1.70608148e-01f, -1.91426560e-01f, 2.40630214e-03f, -9.11319479e-02f,
  8.55933204e-02f, -6.72259033e-02f, 7.92078301e-02f, 1.40213862e-01f, 9.55534428e-02f, 2.50625730e-01f, 5.83285019e-02f, -1.03484362e-01f, 1.31351173e-01f, 1.35062814e-01f,
  1.41158387e-01f, 2.41694793e-01f, 1.62080377e-01f, 1.33230016e-01f, 7.38921314e-02f, 1.04906775e-01f, 8.71375725e-02f, -1.50500396e-02f, 6.35250807e-02f, 1.50351211e-01f,
  -5.34397885e-02f, -4.12464477e-02f, 3.21182132e-01f, 1.54894397e-01f, -3.33240703e-02f, -6.86866641e-02f, -9.26305205e-02f, 3.30305323e-02f, -1.64822221e-01f, 5.05954958e-02f,
  -1.09068099e-02f, -1.22181941e-02f, -3.60567980e-02f, 9.38303918e-02f, 1.96775720e-01f, 8.46154168e-02f, 2.20677957e-01f, -7.28331227e-03f, 7.22231194e-02f, 5.74224368e-02f,
  -1.91069562e-02f, 8.78414735e-02f, 8.80326424e-03f, 1.73764676e-01f, -1.14844143e-01f, -4.13430147e-02f, -1.38351023e-01f, 9.61945876e-02f, -8.60622227e-02f, 2.61914670e-01f,
  3.26789498e-01f, 1.07426874e-01f, 1.50245819e-02f, -4.56376784e-02f, 1.54055983e-01f, 1.58075601e-01f, 2.70504095e-02f, 1.53582484e-01f, 2.20028535e-01f, 3.79174203e-02f,
  -1.78345740e-02f, 1.08297095e-01f, -5.74405678e-02f, -1.30841702e-01f, -2.04280630e-01f, -2.22535238e-01f, -2.69260705e-01f, 2.90417224e-02f, 9.71571803e-02f, 3.77758354e-01f,
  1.18197516e-01f, 1.40124694e-01f, 1.15514249e-02f, -5.09255612e-03f, 2.12041572e-01f, 2.90480698e-03f, 1.95540562e-01f, 7.62377083e-02f, -2.21960664e-01f, 7.29083642e-02f,
  -8.80703237e-03f, -7.97004625e-02f, -1.11366257e-01f, 2.62707978e-01f, 8.62837955e-02f, -9.70986262e-02f, -2.54206569e-03f, 2.11214926e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.37512103e-01f, 6.14206642e-02f, 2.41064727e-02f, 9.47656706e-02f, 2.51175821e-01f, 1.49397552e-02f, 1.71750709e-01f, -1.88818574e-02f, 1.37657017e-01f, 1.22254446e-01f,
  2.34815463e-01f, 7.40987211e-02f, -1.68960944e-01f, -2.38553621e-02f, -2.16381282e-01f, -8.22126400e-03f, -2.15819672e-01f, 3.40642743e-02f, -1.73401553e-02f, 2.46455878e-01f,
  8.39742646e-03f, 2.78100967e-02f, 1.62591279e-01f, -8.79405811e-02f, 1.68000832e-01f, 1.48607641e-01f, 3.76343310e-01f, -1.07267633e-01f, 1.12689868e-01f, -8.45891312e-02f,
  1.85597137e-01f, 1.31189823e-01f, 1.47502273e-02f, -1.31030902e-01f, 3.34475078e-02f, -2.18235150e-01f, 1.10484920e-02f, -1.14769951e-01f, -3.99095751e-02f, -1.57998264e-01f,
  1.04018133e-02f, -9.41349864e-02f, 7.75397941e-02f, 1.37840241e-01f, 2.21534297e-02f, 5.61419427e-02f, 5.95607534e-02f, 6.59172684e-02f, 9.39079002e-02f, 3.00816763e-02f,
  -9.37850773e-02f, 4.12623100e-02f, 3.48846801e-02f, -1.44274265e-01f, -3.98166701e-02f, -3.14748555e-01f, 3.09184473e-02f, 8.91873837e-02f, -2.54413281e-02f, -4.09863740e-02f,
  -2.02648461e-01f, 7.36856386e-02f, 5.36130778e-02f, 1.54152587e-01f, 2.40537032e-01f, 1.62401125e-02f, 3.47154550e-02f, -5.65940421e-03f, -1.30177392e-02f, 4.05161716e-02f,
  1.74655035e-01f, -7.66957030e-02f, 2.20747292e-01f, 7.87621811e-02f, 2.03639790e-01f, 7.30023086e-02f, -1.61342591e-01f, -7.21522868e-02f, 1.59415662e-01f, 3.09260134e-02f,
  -3.82913537e-02f, -1.93930030e-01f, -2.24227592e-01f, 7.92809948e-03f, 1.16416834e-01f, 1.33770004e-01f, -1.58171535e-01f, -5.56587726e-02f, 2.43749201e-01f, 4.87667918e-02f,
  3.20835318e-03f, 1.23375542e-01f, -8.37666020e-02f, -6.16903277e-03f, 1.36716574e-01f, 3.68640646e-02f, 1.02972843e-01f, 1.27696559e-01f, 7.20523968e-02f, -5.08442521e-02f,
  -1.81287397e-02f, -1.86326548e-01f, -1.88035175e-01f, 1.53793424e-01f, -6.87039196e-02f, -3.79864097e-01f, 6.15208484e-02f, -1.77399758e-02f, 3.13227475e-02f, -5.15896976e-02f,
  1.70567572e-01f, 2.92345546e-02f, -3.42629045e-01f, 2.69863307e-02f, 2.56348262e-03f, 1.62685454e-01f, -7.91919008e-02f, 3.87821458e-02f, 1.84603438e-01f, 6.38925731e-02f,
  -1.64206903e-02f, -7.49512538e-02f, 3.48117314e-02f, 1.63444564e-01f, 9.50069427e-02f, -2.29204863e-01f, -1.75187096e-01f, -5.13894781e-02f, -1.65806472e-01f, -1.61145702e-01f,
  -1.01812728e-01f, -3.06103639e-02f, -5.33844978e-02f, 5.69866821e-02f, 4.93279509e-02f, 8.35583657e-02f, -6.23584092e-02f, -2.85441186e-02f, 7.09040463e-02f, 7.38085574e-03f,
  -2.21756384e-01f, -1.42353222e-01f, 2.16395874e-03f, 8.32706392e-02f, -1.80404037e-01f, -1.03475414e-01f, 3.50628756e-02f, 1.13680921e-01f, 1.82831258e-01f, 1.75875768e-01f,
  -1.47675946e-01f, -1.26250997e-01f, -4.02131397e-03f, -1.22766674e-01f, 1.34594515e-01f, -1.18055873e-01f, 6.62417114e-02f, -6.67858794e-02f, 2.45954648e-01f, -3.88079276e-03f,
  9.88992304e-02f, 6.79352134e-02f, 2.65165810e-02f, -1.25694022e-01f, 1.20913811e-01f, -1.97723910e-01f, -1.09182909e-01f, 1.84300207e-02f, -2.60807455e-01f, -2.84820527e-01f,
  -2.14026108e-01f, -2.34480754e-01f, 2.11243585e-01f, 5.61183281e-02f, 2.79186904e-01f, -5.63132949e-03f, -1.37645915e-01f, 1.34699881e-01f, 1.68289393e-01f, 2.62427151e-01f,
  -2.42322758e-02f, -2.20232174e-01f, 1.65179983e-01f, 2.22290158e-01f, -2.80452579e-01f, -4.02310103e-01f, -1.08821720e-01f, 1.91293359e-01f, -4.03036773e-01f, 1.14525199e-01f,
  1.21970950e-02f, -1.21737525e-01f, 7.25467131e-02f, -4.46866341e-02f, 1.18012294e-01f, 4.35973182e-02f, -1.40991136e-01f, 1.09198727e-02f, -9.06552374e-02f, 2.81701591e-02f,
  1.49182025e-02f, 2.71691903e-02f, 9.64454859e-02f, -1.10607229e-01f, 3.11554134e-01f, 1.64700761e-01f, 3.22834253e-01f, 9.88674760e-02f, -2.53421627e-02f, 1.59099951e-01f,
  -2.27136895e-01f, 8.41669291e-02f, 1.69469982e-01f, -9.12149474e-02f, 1.10687710e-01f, 2.84054391e-02f, -4.33818512e-02f, 1.29716083e-01f, 1.19687110e-01f, 1.35870948e-01f,
  -1.21097781e-01f, 3.86920154e-01f, -3.58489044e-02f, -1.91072915e-02f, 7.79134929e-02f, 1.40372872e-01f, -2.67271027e-02f, 1.73623696e-01f, -2.41862953e-01f, -3.36878777e-01f,
  -2.18789563e-01f, 2.25456014e-01f, 9.73579958e-02f, -3.65246266e-01f, -1.27299726e-01f, -3.26706059e-02f, -8.94905478e-02f, -1.66064471e-01f, -1.21341518e-03f, -2.69147843e-01f,
  -1.86265409e-01f, -1.25134289e-01f, -1.55555278e-01f, -1.79215536e-01f, 4.67883088e-02f, 1.91440329e-01f, -7.41356835e-02f, 4.10180539e-01f, -1.41841426e-01f, 1.33938028e-03f,
  -9.35151801e-02f, -8.59110430e-02f, 3.52793634e-01f, -2.38264769e-01f, 7.77878463e-02f, 9.60990563e-02f, 1.58606559e-01f, 1.85254052e-01f, 2.12371215e-01f, 1.86584458e-01f,
  8.08203891e-02f, -5.70295984e-03f, 1.45271838e-01f, 5.94570190e-02f, 1.80247784e-01f, 2.45651588e-01f, -3.33873853e-02f, 6.06384352e-02f, -2.03067109e-01f, -1.81551591e-01f,
  -8.79484713e-02f, -1.52964607e-01f, 2.90631801e-01f, -9.61204171e-02f, 5.43265929e-03f, -3.17160562e-02f, -2.25631967e-02f, -1.33785322e-01f, 2.40157247e-01f, 1.70988932e-01f,
  -9.13247988e-02f, -6.43626824e-02f, -9.18783545e-02f, -1.48691610e-01f, 8.47195163e-02f, 6.07072795e-03f, -1.76860064e-01f, -1.10448606e-01f, -2.17928123e-02f, -3.85384671e-02f,
  -1.54564735e-02f, 6.13693334e-02f, -3.29040028e-02f, -1.63716257e-01f, 1.36904530e-02f, -1.70128629e-01f, 1.50173038e-01f, 1.16131241e-02f, 1.01963557e-01f, 3.27742938e-03f,
  -1.15822934e-01f, -2.42178798e-01f, 9.63339861e-03f, 2.22290754e-01f, 6.37736544e-02f, 1.63457170e-01f, -1.97024375e-01f, -1.68459237e-01f, 4.37376909e-02f, 1.32412985e-01f,
  2.42119599e-02f, -2.02055007e-01f, 1.01179704e-01f, 7.93368444e-02f, 1.66579127e-01f, -1.54123217e-01f, -1.08175926e-01f, 9.03334841e-02f, 6.04114458e-02f, 1.51725575e-01f,
  -4.31656279e-02f, -1.11058921e-01f, 1.74845740e-01f, 6.15767315e-02f, -3.51928617e-03f, -3.68443243e-02f, 1.32583559e-01f, 1.15225628e-01f, 2.27001399e-01f, -4.19311300e-02f,
  2.12685063e-01f, 1.31494747e-02f, -2.75605559e-01f, -5.84820621e-02f, 9.15757418e-02f, -3.11353266e-01f, -9.20352936e-02f, -2.42185950e-01f, 7.07653631e-03f, -1.43132480e-02f,
  -9.27605778e-02f, 1.76114634e-01f, -4.94204387e-02f, 6.85105100e-03f, 3.36043626e-01f, -8.22851658e-02f, -1.22266337e-01f, 1.96609363e-01f, 2.62865098e-03f, -8.99261981e-02f,
  -8.12328756e-02f, -2.80651420e-01f, -1.54178932e-01f, -1.08172141e-01f, 1.44795701e-01f, 8.76665860e-02f, -3.10322661e-02f, 1.99861825e-01f, 1.61268055e-01f, 2.03651071e-01f,
  -5.27436137e-02f, -1.56245217e-01f, -7.33748032e-03f, -1.63232833e-01f, -9.04750600e-02f, -3.49211067e-01f, 1.52012676e-01f, 9.08014029e-02f, -1.68409705e-01f, 1.10821277e-01f,
  -1.67134538e-01f, -5.14979847e-02f, -1.04030147e-01f, -9.71775353e-02f, 2.10841089e-01f, 9.71326418e-03f, -3.41055751e-01f, 8.45152065e-02f, -7.20239356e-02f, 9.78793725e-02f,
  -1.03957854e-01f, 1.50304854e-01f, -1.65638059e-01f, -2.15277255e-01f, -7.13166520e-02f, -4.18850109e-02f, 6.10036999e-02f, -5.20244502e-02f, 4.59241979e-02f, 1.12478890e-01f,
  1.37816042e-01f, -6.85805753e-02f, 8.43983237e-03f, -1.81351556e-03f, -4.35127802e-02f, -2.16876678e-02f, -1.91263005e-01f, -1.70000970e-01f, 4.53794450e-02f, -3.91916223e-02f,
  -3.48771065e-02f, -6.26751333e-02f, -1.02132052e-01f, -1.79327011e-01f, 5.77913038e-02f, 7.79690742e-02f, -5.09006269e-02f, 1.49796829e-02f, 2.37488076e-01f, 8.08263496e-02f,
  1.57030746e-01f, 9.68989879e-02f, -1.73010498e-01f, -1.69564664e-01f, 2.37348750e-01f, 2.19353914e-01f, 2.27388412e-01f, 1.72663927e-01f, 1.12377465e-01f, 1.07946739e-01f,
  -2.00991273e-01f, -1.08122816e-02f, -2.43447468e-01f, 1.09416157e-01f, -3.89145836e-02f, -2.82127887e-01f, 5.39039411e-02f, 1.60759568e-01f, 3.63511592e-01f, -1.57755762e-02f,
  1.39050737e-01f, 4.72366661e-02f, -3.24366897e-01f, 2.96350241e-01f, -3.97739708e-02f, 1.42182887e-01f, -1.15978733e-01f, 2.09690720e-01f, 2.60083109e-01f, -1.81537271e-02f,
  1.09376788e-01f, -3.18727791e-01f, 8.57363492e-02f, 2.71138877e-01f, 1.72643811e-01f, -2.57504821e-01f, -1.75084561e-01f, 1.38076797e-01f, 1.99971333e-01f, 2.42697522e-02f,
  3.01594543e-03f, 8.66629332e-02f, 1.12145483e-01f, 1.93632826e-01f, 2.43188918e-01f, 2.16440260e-01f, 9.48778018e-02f, 1.77548572e-01f, 3.09832871e-01f, -3.52561995e-02f,
  2.42325127e-01f, 7.77055696e-02f, -5.16608208e-02f, 5.39572947e-02f, 1.69437587e-01f, -1.57862857e-01f, -2.50791699e-01f, -9.95684862e-02f, 2.33496428e-01f, 2.80245785e-02f,
  -1.94907207e-02f, -1.20126799e-01f, 8.39984789e-02f, -1.82550862e-01f, 1.00348718e-01f, -1.48172870e-01f, -1.03877306e-01f, 4.07917827e-01f, -1.84632521e-02f, 6.54865131e-02f,
  7.39841238e-02f, 2.54428059e-01f, -1.24463685e-01f, 1.12495974e-01f, -3.09112340e-01f, -1.52674437e-01f, -7.75291771e-02f, -4.25222442e-02f, 3.55624743e-02f, -8.92540142e-02f,
  -6.59777522e-02f, 8.59113932e-02f, 1.74462780e-01f, 1.11439951e-01f, -1.56894565e-01f, -9.72322449e-02f, -2.69919723e-01f, 1.12240147e-02f, -7.12856511e-03f, -1.14908531e-01f,
  1.03539795e-01f, 4.63430844e-02f, 1.98446423e-01f, 1.20463841e-01f, -3.86311263e-01f, 3.38092864e-01f, 7.32385088e-03f, -1.21119812e-01f, 1.78782299e-01f, -8.33080634e-02f,
  1.99447945e-01f, 1.07832007e-01f, 6.00885898e-02f, 1.23135045e-01f, 3.81134674e-02f, 2.01683581e-01f, 2.69517481e-01f, 8.91704783e-02f, 1.46191910e-01f, 4.81629372e-02f,
  9.98110399e-02f, 1.68349758e-01f, 2.29480520e-01f, 1.04946092e-01f, 3.91475052e-01f, 7.10359588e-02f, -1.47033125e-01f, 3.04995865e-01f, -3.94756353e-05f, -4.46716323e-02f,
  -7.71408528e-02f, -1.11064486e-01f, -7.34816939e-02f, -2.56024152e-01f, -1.60213023e-01f, -2.25023064e-03f, -2.09066957e-01f, 4.18861303e-03f, 2.61646092e-01f, 4.71961051e-02f,
  -1.02996938e-01f, 2.28226185e-02f, 2.43172765e-01f, 6.42035231e-02f, 2.07366407e-01f, 1.37206599e-01f, -1.43381879e-01f, -5.34022003e-02f, -2.36703560e-01f, 7.86453560e-02f,
  -1.02667175e-01f, -2.87813753e-01f, -6.93304241e-02f, 6.16257079e-02f, -1.98180035e-01f, 2.81610936e-02f, 5.03884163e-03f, 2.76034564e-01f, 8.92368183e-02f, -6.19029887e-02f,
  3.41809213e-01f, 5.70229627e-02f, 2.72038132e-01f, 2.08098248e-01f, 2.84467161e-01f, 1.77086666e-02f, -3.36091489e-01f, 8.25577378e-02f, -2.20795572e-01f, 1.66683778e-01f,
  9.51605570e-03f, -3.14540975e-03f, 1.46721289e-01f, -8.83041024e-02f, 2.31221721e-01f, 2.49503285e-01f, -3.16097848e-02f, -3.62135693e-02f, 5.47146983e-02f, 4.13002856e-02f,
  -5.35050333e-02f, 1.24697566e-01f, 9.34615508e-02f, 2.33735621e-01f, -8.31329599e-02f, -4.20670658e-02f, 2.24565357e-01f, 1.69932016e-03f, 3.01038653e-01f, -3.02200522e-02f,
  -1.31807595e-01f, 2.97880590e-01f, -7.69623742e-02f, 1.33742481e-01f, 6.72734976e-02f, -1.08627096e-01f, 6.58652410e-02f, 5.92838228e-03f, -2.23017842e-01f, 5.08111566e-02f,
  -1.85559347e-01f, -3.17287184e-02f, 1.40291052e-02f, -1.57198012e-01f, -4.38822359e-02f, 1.57109141e-01f, 1.86181799e-01f, 2.49041095e-01f, 1.44070700e-01f, 7.68100545e-02f,
  -7.37987012e-02f, -6.48475215e-02f, -1.27858222e-01f, 8.47915336e-02f, -7.19338357e-02f, -2.31641084e-01f, -1.90555200e-01f, -3.80490750e-01f, -1.36363849e-01f, -2.06785500e-01f,
  2.41253361e-01f, 2.78456211e-01f, 2.20655680e-01f, -1.78670466e-01f, 1.34589702e-01f, 2.76025385e-01f, 3.67546141e-01f, 2.64633536e-01f, -4.92541790e-02f, 1.90409422e-01f,
  -1.15913991e-02f, 3.21197271e-01f, -5.42103946e-02f, 1.48459636e-02f, -1.91350549e-01f, 1.81196809e-01f, -9.15367901e-02f, -2.80845817e-02f, 2.87746638e-01f, -1.14147879e-01f,
  -1.05180852e-01f, -1.05997108e-01f, 2.61325181e-01f, 1.73820615e-01f, -3.92497852e-02f, 2.95651462e-02f, 7.67809618e-03f, 2.72149324e-01f, 1.12378508e-01f, 1.82032004e-01f,
  3.89434397e-02f, -7.31921643e-02f, -8.52221027e-02f, 2.21896484e-01f, -2.42654104e-02f, 5.08676395e-02f, 2.32895195e-01f, 9.51773673e-02f, 1.32852286e-01f, -3.57361510e-02f,
  4.04207073e-02f, -9.85150486e-02f, 2.21384481e-01f, 9.06015113e-02f, -1.94352314e-01f, -1.34662420e-01f, -4.57698047e-01f, -2.76782393e-01f, -1.33482628e-02f, 3.34032148e-01f,
  -2.43912548e-01f, -2.79851675e-01f, -1.53879195e-01f, -4.21061739e-02f, -2.47349098e-01f, 2.69022077e-01f, -7.86938071e-02f, -2.48041630e-01f, 2.50452925e-02f, -3.71242851e-01f,
  3.46951187e-01f, -1.51765561e-02f, 2.80043662e-01f, 3.17829810e-02f, 1.42155513e-01f, -1.78393915e-01f, -2.41323501e-01f, 1.97480738e-01f, 3.55524361e-01f, -6.02432564e-02f,
  1.89418614e-01f, -5.44314533e-02f, -5.38494848e-02f, 2.19504684e-01f, 8.21775347e-02f, -2.73363311e-02f, 2.64541619e-02f, -5.78490049e-02f, 1.89016014e-01f, -2.32056886e-01f,
  -1.62685201e-01f, 1.28869727e-01f, 2.54573166e-01f, -1.54436007e-01f, -2.65545733e-02f, 1.78774074e-02f, 1.14334732e-01f, -4.88930847e-03f, -1.55014426e-01f, -1.41987532e-01f,
  5.33853509e-02f, 8.74106660e-02f, 3.96786034e-02f, 5.63080562e-03f, 1.21233203e-01f, -3.19172777e-02f, 1.61401659e-01f, -3.35764326e-02f, 1.37551427e-01f, -1.91569626e-01f,
  -1.33007586e-01f, 2.38760069e-01f, -2.15879711e-03f, -2.24956796e-01f, -1.64249480e-01f, -2.25079488e-02f, -2.82951444e-01f, -3.77182215e-02f, 1.16328001e-01f, -6.07932620e-02f,
  -7.16611370e-02f, 7.22708702e-02f, -6.04833178e-02f, -1.35824475e-02f, -2.53836140e-02f, 5.65787032e-02f, 8.60469341e-02f, 1.87184960e-01f, -7.85224438e-02f, -1.74565211e-01f,
  -3.00559569e-02f, -1.03262059e-01f, -1.85175955e-01f, 1.32729098e-01f, -6.14558756e-02f, -3.28182191e-01f, 5.17753474e-02f, 2.40504853e-02f, 1.14250937e-02f, 1.17049083e-01f,
  -1.55112565e-01f, 3.92922899e-03f, -1.13271825e-01f, 7.45444521e-02f, -8.42684954e-02f, -3.08655769e-01f, -1.76720694e-02f, 1.72672659e-01f, -1.76591620e-01f, 2.45661940e-03f,
  7.98963904e-02f, -2.78758943e-01f, -9.56659243e-02f, 1.44716948e-02f, 2.78523892e-01f, -1.48391902e-01f, -2.06762776e-01f, 1.44801721e-01f, -8.83295294e-03f, 6.09217538e-03f,
  8.90658647e-02f, -9.55801010e-02f, 7.16365874e-02f, -1.21097855e-01f, -1.08303599e-01f, 1.29265517e-01f, 6.04057610e-02f, -5.85580356e-02f, -2.18106881e-01f, 5.88600710e-02f,
  -2.10096687e-01f, 4.92106862e-02f, -5.90319708e-02f, 3.24945748e-02f, 1.75853670e-01f, -4.53060865e-02f, 3.76218855e-02f, -1.32330164e-01f, -2.15567444e-02f, -3.80448177e-02f,
  3.44907850e-01f, 6.59009442e-02f, 3.93281169e-02f, -2.48465329e-01f, -2.80984014e-01f, -1.80432484e-01f, 6.70402916e-03f, 4.52151112e-02f, -1.51044056e-01f, 9.41273104e-03f,
  6.72945008e-02f, 9.04792622e-02f, -9.60253105e-02f, 1.53645396e-01f, 9.78101715e-02f, -1.12728432e-01f, -2.42713653e-02f, 1.52826503e-01f, 6.89802021e-02f, 1.53081328e-01f,
  4.93227020e-02f, 1.75894693e-01f, 4.39850129e-02f, -1.54808030e-01f, -7.21439626e-03f, -5.06224297e-02f, 2.17118151e-02f, 8.55810344e-02f, -6.00903556e-02f, -1.30785346e-01f,
  -1.45868482e-02f, 9.58765149e-02f, 2.43602872e-01f, -2.58885436e-02f, 7.92216435e-02f, -1.63704276e-01f, 3.29900920e-01f, 6.74947575e-02f, -1.23688772e-01f, -5.79734147e-02f,
  2.52163503e-02f, 1.73964705e-02f, 9.55160558e-02f, 1.75546840e-01f, 6.05766624e-02f, 6.28855750e-02f, 1.12139210e-01f, 1.52930394e-01f, 8.10744017e-02f, -2.07071658e-02f,
  2.51526266e-01f, 1.94776967e-01f, 1.26759216e-01f, 1.16667569e-01f, -1.37997359e-01f, -1.19169464e-03f, -2.21050963e-01f, -1.74270347e-01f, 1.42213568e-01f, 7.57907256e-02f,
  8.18801597e-02f, 1.53462932e-01f, -2.27307022e-01f, 2.62167715e-02f, 1.18191026e-01f, 1.47447493e-02f, 6.50105551e-02f, 2.67488100e-02f, -4.50992882e-02f, 1.69923648e-01f,
  2.10157156e-01f, 2.26083368e-01f, -1.04428835e-01f, -1.03506580e-01f, -7.93939903e-02f, -2.50041753e-01f, 5.68336882e-02f, -1.21955939e-01f, 4.52072620e-02f, 9.12645012e-02f,
  4.74304631e-02f, -3.19213688e-01f, 7.60993510e-02f, 2.32378647e-01f, 4.82281186e-02f, -1.61262780e-01f, -1.19004935e-01f, 9.10783932e-02f, -1.40358001e-01f, 3.46180201e-01f,
  5.72980456e-02f, -3.18109661e-01f, 8.79416149e-03f, -1.88762516e-01f, 6.68433458e-02f, 1.04689837e-01f, -2.76664376e-01f, -3.39760423e-01f, 1.36274830e-01f, 2.55622357e-01f,
  -1.18780598e-01f, -5.28970957e-02f, 1.85298678e-02f, 1.73727095e-01f, 1.89882025e-01f, -4.45975140e-02f, -3.03496774e-02f, 5.88735789e-02f, 1.24644175e-01f, -1.43158674e-01f,
  -1.28226414e-01f, -5.34291305e-02f, 7.06292614e-02f, -3.20451446e-02f, 1.69733423e-04f, 9.89521295e-03f, 5.83419353e-02f, -7.76682347e-02f, 1.73176583e-02f, -7.81974196e-02f,
  1.40534043e-01f, -1.93222277e-02f, 8.06171149e-02f, 1.57215849e-01f, 1.72574930e-02f, 7.67190978e-02f, -4.49105632e-03f, -3.29704769e-02f, 2.61031669e-02f, 8.04239213e-02f,
  -4.06583995e-01f, -1.97658911e-01f, -3.64730805e-01f, -7.65120164e-02f, 1.64380178e-01f, -1.29312187e-01f, 7.15248436e-02f, 3.36824134e-02f, 2.71138251e-02f, -2.64666080e-01f,
  -1.12119198e-01f, -1.09943010e-01f, 8.77932087e-02f, -1.08896352e-01f, 1.66048795e-01f, -9.34235305e-02f, -3.17733586e-01f, 7.58160604e-03f, -6.88338727e-02f, -1.88527495e-01f,
  1.28196985e-01f, 9.51014310e-02f, 8.63567293e-02f, 9.35507789e-02f, 8.51919428e-02f, 3.20564002e-01f, 2.04943314e-01f, 1.15712494e-01f, -2.79602278e-02f, -1.53493002e-01f,
  2.01108500e-01f, -4.42034379e-02f, -4.98333961e-01f, -4.33123171e-01f, -5.72906062e-02f, 5.34668043e-02f, 8.38695778e-05f, 1.69909701e-01f, -1.27993286e-01f, 4.48404141e-02f,
  1.51667938e-01f, 1.00371942e-01f, 1.78441957e-01f, -5.81008531e-02f, 5.71754538e-02f, -8.62883925e-02f, 2.19010152e-02f, 5.09435236e-02f, 4.02264930e-02f, 1.15864180e-01f,
  3.99458483e-02f, -2.66247019e-02f, 1.22026242e-01f, -1.03142902e-01f, 3.26464742e-01f, -2.09428430e-01f, 2.52436757e-01f, 1.42860278e-01f, 5.27341142e-02f, -1.44401416e-01f,
  -2.25362986e-01f, -1.98841184e-01f, -2.42386758e-01f, -1.06212087e-02f, -2.15528801e-01f, -1.19715691e-01f, -4.15436506e-01f, 3.08346272e-01f, 3.78418118e-02f, -1.04867518e-01f,
  -1.09490462e-01f, 1.60056502e-01f, 1.82463191e-02f, -1.04897872e-01f, 1.53821716e-02f, 1.17946807e-02f, 3.42024006e-02f, 2.30079815e-01f, 3.23509686e-02f, -1.66195720e-01f,
  -2.71226525e-01f, -6.69471100e-02f, 4.25019637e-02f, -2.87956186e-02f, 1.73541561e-01f, 1.67619824e-01f, 7.75061473e-02f, -1.69353902e-01f, -1.02615938e-01f, 1.20632619e-01f,
  3.14150393e-01f, 8.81414637e-02f, -8.80912021e-02f, 7.50552341e-02f, -8.54977220e-02f, -2.26809122e-02f, -3.97019029e-01f, -4.00405169e-01f, 1.19480980e-03f, 5.09839170e-02f,
  1.30659223e-01f, 1.57388523e-01f, 2.45593619e-02f, -1.44518074e-02f, -6.75893128e-02f, 8.53193551e-02f, 3.68586257e-02f, -8.63538682e-02f, -1.03015564e-02f, -1.21465862e-01f,
  6.37243390e-02f, 1.28456131e-01f, 1.24200702e-01f, 1.23051062e-01f, 5.75819379e-03f, -3.03025474e-03f, -7.30758235e-02f, -4.39159647e-02f, -1.64855495e-01f, -1.43980205e-01f,
  1.81760341e-02f, -5.93385696e-02f, 4.94167302e-03f, -1.73703313e-01f, -1.56893563e-02f, 5.01612341e-03f, 5.52472565e-03f, -4.34860922e-02f, 9.82663557e-02f, 9.01598716e-04f,
  -3.65014881e-01f, -2.49988273e-01f, -1.13710808e-02f, 4.64322940e-02f, -3.32768001e-02f, -2.84032002e-02f, 5.17152762e-03f, -7.73994550e-02f, -3.08973521e-01f, 1.49410948e-01f,
  -1.69215187e-01f, -2.16953754e-01f, 7.78536052e-02f, 4.29820828e-02f, 6.18474418e-03f, 2.27740541e-01f, 2.18103141e-01f, 3.57743390e-02f, 6.50673583e-02f, -1.62934929e-01f,
  -8.22171494e-02f, -2.37537459e-01f, -7.76706859e-02f, 6.92018420e-02f, -1.56424493e-01f, -1.07658051e-01f, 1.88228890e-01f, 1.84852436e-01f, 1.53416499e-01f, -1.02340467e-01f,
  1.69395357e-01f, 1.18056953e-01f, 1.08314469e-01f, -3.20341557e-01f, 1.38794892e-02f, -2.41894051e-02f, -4.59990278e-02f, 4.44497690e-02f, -6.03496209e-02f, 2.22276617e-02f,
  -4.35428834e-03f, -1.91814780e-01f, -1.24313518e-01f, -1.32148758e-01f, -1.90619156e-02f, 1.52880885e-02f, 7.83459656e-03f, 4.17941399e-02f, -1.45024676e-02f, -5.11499755e-02f,
  -1.30393475e-01f, 2.99952906e-02f, 2.87487432e-02f, -1.25313997e-01f, 1.38109371e-01f, -1.05107643e-01f, -1.02070803e-02f, -2.18246862e-01f, -1.46005362e-01f, -1.73812509e-01f,
  1.59074485e-01f, -4.67576385e-02f, -2.14014538e-02f, -1.15688413e-01f, -2.23996073e-01f, 6.50232583e-02f, 6.90106526e-02f, -9.77479294e-02f, 5.19876741e-02f, 1.49942666e-01f,
  -1.63529254e-02f, 5.21124192e-02f, -2.40119896e-03f, 5.94868958e-02f, -7.79987425e-02f, 1.45361692e-01f, 7.77394176e-02f, 2.64273673e-01f, 1.49177253e-01f, -1.04009710e-01f,
  9.51488316e-02f, 7.61331618e-02f, 1.39969856e-01f, -2.18209364e-02f, -2.39735380e-01f, 1.51073039e-01f, 6.19117804e-02f, 2.34246165e-01f, -1.41284555e-01f, -2.78602272e-01f,
  8.06316137e-02f, 2.32662305e-01f, 3.09614629e-01f, -1.55596081e-02f, 1.45042405e-01f, -8.79682675e-02f, 8.82669911e-02f, -1.74289435e-01f, 3.19024660e-02f, 5.93011454e-02f,
  1.12792514e-01f, 1.35713473e-01f, 1.62616327e-01f, -4.27572504e-02f, 2.59817004e-01f, 6.80714250e-02f, 1.34776056e-01f, 1.78830132e-01f, 1.05447657e-02f, 1.53523773e-01f,
  9.62852985e-02f, 1.12717032e-01f, 2.76582718e-01f, 5.71130663e-02f, -2.97019005e-01f, -7.31602237e-02f, 7.35604949e-03f, -6.64342418e-02f, -1.13038540e-01f, -2.06560090e-01f,
  -2.14541107e-01f, 5.21243550e-02f, 3.31497610e-01f, 5.39691001e-03f, 4.47099730e-02f, -5.47056831e-02f, 3.02290022e-01f, -9.67861414e-02f, 6.97369799e-02f, -1.19059928e-01f,
  -1.33980021e-01f, 2.01984137e-01f, 1.00375071e-01f, -2.16624439e-01f, -1.39512299e-02f, 1.49698228e-01f, 2.04625204e-01f, 1.12608567e-01f, 8.52444395e-03f, -2.34945893e-01f,
  -1.09365456e-01f, 1.48752943e-01f, -1.26178265e-02f, -2.87159830e-01f, -3.97664681e-02f, -1.18616261e-01f, -6.66982755e-02f, -7.30020255e-02f, 1.40120760e-02f, 7.04221278e-02f,
  -3.47125590e-01f, 1.25390500e-01f, -1.19926594e-01f, -3.83872762e-02f, -2.22123027e-01f, -1.47649318e-01f, 4.20153290e-01f, 4.71829772e-02f, -1.65363625e-01f, 3.25270265e-01f,
  2.80406270e-02f, -5.93328513e-02f, -1.11583382e-01f, -1.43478543e-01f, -7.39104673e-02f, -3.86985727e-02f, 2.07070589e-01f, -4.48938385e-02f, 1.89876974e-01f, 1.12421297e-01f,
  2.10736156e-01f, 1.03545547e-01f, 8.04281086e-02f, 1.46909386e-01f, 7.75960758e-02f, 1.08350791e-01f, 2.51484185e-01f, 1.25107124e-01f, 9.72962454e-02f, -8.00696760e-03f,
  -4.39986028e-02f, -2.72367090e-01f, 1.62043214e-01f, -2.97544301e-01f, -2.12584630e-01f, -4.55643944e-02f, -4.92870109e-03f, 1.07317353e-02f, -2.93425590e-01f, -1.02747798e-01f,
  1.49500012e-01f, -9.74867046e-02f, -2.04630673e-01f, 2.36464843e-01f, 2.73395423e-02f, 1.32501975e-01f, -4.45667915e-02f, -2.35570706e-02f, -2.67720819e-01f, -1.93149999e-01f,
  6.48427382e-02f, 7.44291991e-02f, -1.37154341e-01f, 2.95381993e-01f, -7.41746649e-02f, 1.69267971e-02f, 8.94321408e-03f, 2.03973129e-01f, -1.23552950e-02f, -1.08352654e-01f,
  -2.35893596e-02f, -8.26829299e-02f, -2.64935464e-01f, 1.29951620e-02f, -2.08279744e-01f, 1.97662003e-02f, -6.19876944e-02f, -1.70072019e-01f, 4.79324684e-02f, 5.21267280e-02f,
  2.06170976e-01f, -2.65969992e-01f, -8.09860379e-02f, 2.69550204e-01f, -1.76318511e-01f, -3.41133118e-01f, -1.29944652e-01f, 6.86972514e-02f, -1.44650340e-02f, -2.35567436e-01f,
  2.57016063e-01f, 9.56842769e-03f, 2.46089652e-01f, 2.16913834e-01f, 2.28143930e-01f, 2.94158179e-02f, 2.22360060e-01f, -6.60901563e-03f, 6.31998181e-02f, 2.05268979e-01f,
  8.70750323e-02f, -1.72946285e-02f, -3.18171322e-01f, -2.09376857e-01f, -4.03988473e-02f, 3.63942795e-02f, -8.45019147e-02f, -3.35484773e-01f, 9.32734013e-02f, 5.37712127e-02f,
  2.11154342e-01f, 3.98104228e-02f, 2.57159442e-01f, 3.67688537e-02f, 3.05018723e-01f, 6.80924803e-02f, 4.06050026e-01f, -1.61614090e-01f, -1.56447992e-01f, -2.66640633e-01f,
  -4.00603563e-02f, 7.69254342e-02f, 1.40919415e-02f, -6.58872947e-02f, -1.25884991e-02f, 1.00122459e-01f, -6.49271980e-02f, -2.95443863e-01f, 5.97276315e-02f, -8.35993960e-02f,
  2.49543130e-01f, 1.62354838e-02f, 1.44351408e-01f, 2.88672391e-02f, -1.33501723e-01f, -2.65660793e-01f, -8.29777718e-02f, 8.72635096e-02f, 7.87364542e-02f, -5.31450026e-02f,
  -1.84356421e-01f, 1.04092114e-01f, -2.30458286e-02f, -2.23345421e-02f, 1.61176264e-01f, -3.12157422e-01f, 8.80854204e-02f, -2.03988850e-02f, -4.99090292e-02f, 1.84096247e-01f,
  -1.27435952e-01f, 2.98277289e-02f, 3.67952920e-02f, 2.34342292e-01f, 7.74108097e-02f, 6.26758710e-02f, 4.01916914e-02f, -2.70989724e-02f, -1.17646530e-02f, -2.05235891e-02f,
  6.04305975e-02f, -1.16025597e-01f, 1.17425784e-01f, 6.42438605e-02f, -1.14310138e-01f, 8.58546495e-02f, 2.34666467e-01f, -6.19416945e-02f, 1.65417209e-01f, -7.11472854e-02f,
  -1.01440601e-01f, -9.88840982e-02f, -1.50916174e-01f, -3.15719932e-01f, 1.83453709e-02f, -2.27259323e-01f, -2.48045981e-01f, -3.93243581e-02f, 2.50550546e-02f, -1.09044746e-01f,
  -1.67854995e-01f, 3.10669541e-02f, 2.00860016e-02f, -6.31758198e-02f, 3.45841907e-02f, 2.34799385e-01f, 1.42427692e-02f, 3.39919776e-02f, 7.87267834e-02f, -6.81800321e-02f,
  -3.08382452e-01f, 2.58995682e-01f, -2.48414174e-01f, 1.53451145e-01f, -6.36607185e-02f, -1.55873954e-01f, -8.32059886e-03f, 2.98482310e-02f, 3.42902184e-01f, 2.43445829e-01f,
  1.78796407e-02f, -2.35575214e-01f, -3.97097170e-02f, 2.33735770e-01f, 5.40831499e-02f, -5.01444414e-02f, -9.56427865e-03f, 2.00582087e-01f, 4.60756235e-02f, -4.46418002e-02f,
  1.93625353e-02f, -2.56432325e-01f, 9.73962471e-02f, -6.05035499e-02f, 2.45558303e-02f, 3.82537697e-03f, -1.92189664e-01f, 1.45669729e-01f, -4.69227470e-02f, -2.55490784e-02f,
  1.03186354e-01f, -5.27758971e-02f, -1.86933801e-01f, -6.40172586e-02f, -9.83301736e-03f, 7.21566528e-02f, -3.65059003e-02f, 1.00943923e-01f, -6.35750964e-02f, -6.46489412e-02f,
  -2.40147427e-01f, -1.47959575e-01f, 8.39502290e-02f, -1.34508342e-01f, 1.76927954e-01f, -1.64933130e-01f, 1.76625639e-01f, -3.14541548e-01f, -1.47852972e-01f, -3.34572420e-02f,
  2.26693839e-01f, 1.42250685e-02f, 3.78343277e-02f, -6.18181787e-02f, -3.27128470e-01f, -1.91335063e-02f, 8.70381966e-02f, -9.98864099e-02f, -9.85131934e-02f, -1.36847794e-02f,
  8.29198658e-02f, -5.62171862e-02f, -1.18183225e-01f, 5.20523377e-02f, -1.19536467e-01f, 7.21122772e-02f, -9.46942251e-03f, -1.11730158e-01f, 1.37920156e-01f, -8.54682922e-02f,
  2.43166253e-01f, 1.16376422e-01f, -1.11661546e-01f, -1.97514638e-01f, -2.79119551e-01f, 1.66301727e-02f, 1.25538111e-02f, 1.11019827e-01f, -2.12127239e-01f, -9.42729786e-02f,
  -9.91668403e-02f, 8.24765936e-02f, 1.78378224e-01f, -3.73764001e-02f, 1.22704379e-01f, -2.71134883e-01f, 2.17899367e-01f, 6.35598898e-02f, -2.73493864e-02f, 6.39658794e-03f,
  -1.86133891e-01f, 2.16367111e-01f, 9.82763618e-02f, 1.65616721e-01f, -2.26003248e-02f, 1.06313847e-01f, -4.52569313e-02f, 6.33140327e-03f, 1.53810397e-01f, 2.35039368e-02f,
  9.79147200e-03f, 1.24580808e-01f, -1.76411718e-01f, -7.07417652e-02f, -1.01460613e-01f, -6.01366395e-03f, -3.09304655e-01f, 2.58366503e-02f, -1.51511863e-01f, -1.08384140e-01f,
  6.43533319e-02f, 1.88164771e-01f, -3.19031738e-02f, -3.59161932e-04f, 3.16204667e-01f, 1.33469343e-01f, -1.94070384e-01f, 2.09992871e-01f, 1.53569475e-01f, 3.28361467e-02f,
  -1.23570710e-02f, -1.53915361e-01f, -5.40190004e-02f, 3.21211740e-02f, -2.44373195e-02f, -1.46317095e-01f, -1.45243615e-01f, -1.79483667e-01f, -1.84749708e-01f, -1.57936752e-01f,
  -2.30135843e-01f, -1.86874568e-01f, 6.67086840e-02f, 1.26587972e-01f, -2.94021163e-02f, 5.95281087e-02f, -2.21506387e-01f, 2.04370424e-01f, -1.09333195e-01f, -1.50899962e-03f,
  1.57785654e-01f, -2.43197128e-01f, -1.20646261e-01f, -2.02523753e-01f, 2.83173800e-01f, -1.65943485e-02f, -2.22813040e-01f, -1.42037526e-01f, 4.11733314e-02f, 8.76470655e-02f,
  5.48666529e-02f, 7.55153447e-02f, 5.14223054e-03f, -1.43277973e-01f, 4.95276134e-03f, 1.69830844e-01f, -9.75419208e-03f, 1.83691815e-01f, 1.18461557e-01f, 1.39549021e-02f,
  -7.21824765e-02f, 8.34270045e-02f, -3.54241282e-02f, 1.16697036e-01f, 2.52016261e-02f, 6.17449097e-02f, 1.73520848e-01f, 1.91914275e-01f, -2.73173656e-02f, 1.12349600e-01f,
  -1.33545816e-01f, -1.32638708e-01f, -1.09434284e-01f, 4.10341285e-02f, 2.73353029e-02f, 1.68284625e-01f, -2.79450357e-01f, 1.17689751e-01f, -2.41387561e-01f, 1.23135127e-01f,
  -1.65581360e-01f, 2.31228083e-01f, -1.13435797e-01f, 2.93435395e-01f, 1.98584348e-01f, 6.29048347e-02f, -7.18899965e-02f, -2.32418865e-01f, 4.65046279e-02f, -2.31950104e-01f,
  2.11577460e-01f, 9.98069495e-02f, -1.15364484e-01f, 2.78798997e-01f, 1.44706564e-02f, -3.06907058e-01f, -3.03044885e-01f, 1.38595179e-01f, 3.58379781e-02f, -2.58338660e-01f,
  -8.82630348e-02f, 2.83309907e-01f, 8.59233513e-02f, 2.10671544e-01f, 8.40170234e-02f, 4.55112271e-02f, 2.63905376e-01f, -1.40905991e-01f, -1.46225899e-01f, -1.18906526e-02f,
  -6.47911280e-02f, -7.01060817e-02f, -1.30441576e-01f, -1.04037516e-01f, -1.09145887e-01f, -3.77134643e-02f, 3.59903798e-02f, 8.59581158e-02f, 4.72029746e-02f, -3.75609100e-01f,
  1.06929585e-01f, -6.51326077e-03f, 7.16294050e-02f, 7.39917159e-02f, -4.66025174e-02f, 1.96983606e-01f, 7.36117410e-03f, -6.36735559e-02f, 7.10457191e-02f, -5.79036474e-02f,
  4.20102663e-02f, 1.41344756e-01f, -1.66960418e-01f, -8.16013888e-02f, 5.41714765e-03f, 9.48873311e-02f, -4.40926887e-02f, 6.19298331e-02f, 2.13105321e-01f, 9.86763984e-02f,
  2.26836935e-01f, 1.88481688e-01f, -1.99592281e-02f, 4.69252840e-02f, 7.12683126e-02f, 1.66743919e-01f, 4.30758148e-02f, -8.11287165e-02f, -5.60812391e-02f, -2.30674878e-01f,
  2.10757419e-01f, -4.90529230e-03f, 1.55051529e-01f, 9.13250819e-02f, 9.74973664e-02f, 2.24687681e-01f, 2.08790764e-01f, -1.87281728e-01f, 8.59675556e-02f, -5.72440289e-02f,
  4.58990000e-02f, -6.65467978e-02f, -7.14436779e-03f, 5.13270907e-02f, 5.88309811e-03f, -2.00714558e-01f, 2.13952631e-01f, 4.82175127e-02f, -1.94422916e-01f, 2.95738988e-02f,
  -7.39689320e-02f, 7.15561658e-02f, -1.39761224e-01f, -2.24854022e-01f, 2.53943264e-01f, 7.82061964e-02f, -2.60251850e-01f, -2.16885880e-01f, 8.70571062e-02f, 2.72895992e-01f,
  3.89052220e-02f, 1.55925855e-01f, -1.43300831e-01f, -6.78642886e-03f, -4.14968953e-02f, -1.41375484e-02f, 1.34923413e-01f, 2.33807731e-02f, -7.48640746e-02f, 1.43986985e-01f,
  7.69865811e-02f, -3.21019962e-02f, 8.59467015e-02f, -5.19293249e-02f, -2.11254403e-01f, -9.65946764e-02f, -1.39782503e-01f, -1.28514737e-01f, -4.41136695e-02f, -2.69440502e-01f,
  4.63988893e-02f, -1.41253948e-01f, 1.00946836e-01f, -1.35014325e-01f, 9.34910849e-02f, -7.14179352e-02f, 1.76023558e-01f, 9.78689045e-02f, 1.76807061e-01f, -4.80819643e-02f,
  -3.41509432e-01f, -2.00277194e-01f, 5.93476407e-02f, -5.00785094e-03f, -2.25402087e-01f, 6.84117004e-02f, -2.10954815e-01f, -1.20861463e-01f, -2.29451254e-01f, 1.54099129e-02f,
  2.25489408e-01f, -9.96932462e-02f, 1.65533215e-01f, 3.22638191e-02f, 2.58808196e-01f, 7.75011033e-02f, 2.53038406e-01f, 1.54211283e-01f, 1.06274366e-01f, -1.95420325e-01f,
  -1.33954987e-01f, 5.73939979e-02f, 1.40574306e-01f, 1.04695834e-01f, -1.75960269e-02f, 1.71879902e-01f, -1.39875039e-01f, 6.23512268e-02f, -3.00950315e-02f, 1.59748793e-01f,
  2.75378019e-01f, -7.66204670e-02f, 1.55210868e-01f, -6.66734576e-02f, -1.92787260e-01f, -1.59348212e-02f, 7.80459940e-02f, 1.65198684e-01f, 8.64101946e-02f, 3.29976864e-02f,
  1.48887575e-01f, 2.06989393e-01f, 2.59773377e-02f, 9.75199789e-02f, 1.70822874e-01f, -7.26236776e-02f, 1.31067589e-01f, 5.47538686e-04f, 1.99582428e-01f, 1.00391135e-01f,
  -4.28987034e-02f, 8.88278633e-02f, 4.02609110e-02f, 1.54462814e-01f, -3.60855669e-01f, -9.03251767e-02f, 5.69169186e-02f, 3.25014830e-01f, 3.07167768e-01f, 1.51725233e-01f,
  -6.63236976e-02f, -1.21851545e-02f, 1.60593823e-01f, 2.14518815e-01f, 3.55515510e-01f, 1.26133919e-01f, -8.77725780e-02f, -7.54319727e-02f, 2.03191280e-01f, 1.53110936e-01f,
  2.31808931e-01f, 2.17447057e-01f, 2.97727257e-01f, -9.15614367e-02f, -1.88222393e-01f, -4.21026908e-02f, -2.41501838e-01f, 8.25102441e-03f, 9.28480998e-02f, -3.25109400e-02f,
  -2.88553443e-02f, -1.28060076e-02f, -8.18099752e-02f, -6.10630326e-02f, 7.00342432e-02f, 2.43369743e-01f, -2.33463004e-01f, -2.07759552e-02f, -9.86015201e-02f, 5.44327050e-02f,
  1.30527392e-01f, -2.03217000e-01f, 1.43412068e-01f, -2.32863665e-01f, -3.62627185e-03f, 1.08796738e-01f, -1.49842143e-01f, 2.92823702e-01f, 9.35749561e-02f, -7.51753300e-02f,
  3.14714089e-02f, -1.03276158e-02f, -5.69424257e-02f, 1.08245462e-01f, 1.37336537e-01f, -2.78485958e-02f, -7.84944817e-02f, 5.02602123e-02f, 9.90281627e-02f, 1.29940271e-01f,
  5.86819127e-02f, 1.85520977e-01f, 5.68096153e-03f, -5.00109512e-03f, -3.21530282e-01f, -2.13122256e-02f, -1.24724992e-01f, 5.37322871e-02f, 1.41579658e-01f, -1.39917538e-01f,
  -8.73504728e-02f, -2.36767396e-01f, 6.73443750e-02f, 1.39263704e-01f, 3.14989597e-01f, 2.93092262e-02f, 1.39161170e-01f, -1.42578512e-01f, -5.17866552e-01f, -2.20741704e-01f,
  3.67495716e-02f, 1.01911962e-01f, -1.26821637e-01f, 1.76109616e-02f, -1.58728272e-01f, -1.78955451e-01f, -9.29457396e-02f, 7.09934011e-02f, -5.61580583e-02f, -2.24447072e-01f,
  1.35357961e-01f, -2.23424926e-01f, 2.21634656e-01f, -2.55625527e-02f, 1.75920933e-01f, 1.27020115e-02f, -1.24777474e-01f, -2.15122610e-01f, -8.90626982e-02f, 8.65802988e-02f,
  6.06120676e-02f, 1.35063782e-01f, -3.14868689e-01f, -3.02878693e-02f, -3.87261994e-02f, 1.35945186e-01f, 2.14964211e-01f, -2.29481116e-01f, 3.62016410e-02f, -4.15881351e-02f,
  4.11839187e-02f, -2.79073626e-01f, 4.33937870e-02f, 2.74365637e-02f, -5.62966987e-02f, 2.36442350e-02f, 5.00008091e-02f, 5.09177055e-03f, 3.29515412e-02f, 5.11614271e-02f,
  -2.27177719e-04f, 1.31131515e-01f, 1.14588782e-01f, -2.36290060e-02f, 1.45063892e-01f, 2.44048126e-02f, 9.57436785e-02f, -3.53229269e-02f, -4.73192781e-02f, 4.41916063e-02f,
  1.50279596e-01f, -1.12961814e-01f, -1.41496271e-01f, 1.14412308e-01f, -9.29517150e-02f, -7.85431191e-02f, -2.17649471e-02f, -6.89589530e-02f, -2.94421345e-01f, 1.02067769e-01f,
  8.05385634e-02f, -6.42622560e-02f, 6.84831366e-02f, 1.33007944e-01f, -6.77382797e-02f, -1.33122593e-01f, -1.81525704e-02f, 9.56619009e-02f, 8.50842670e-02f, 1.37366727e-01f,
  1.12762913e-01f, -9.19477642e-02f, 6.40962049e-02f, 2.07789361e-01f, -1.37493253e-01f, 2.01489389e-01f, -1.77543789e-01f, -3.52221102e-01f, 1.14919558e-01f, 1.64261475e-01f,
  1.25584885e-01f, -9.48870778e-02f, 1.39167756e-01f, 1.44149467e-01f, -2.37664178e-01f, -1.03573771e-02f, -1.14736743e-01f, -1.11401744e-01f, -5.42339683e-02f, 5.17834984e-02f,
  -5.82061261e-02f, 1.42379478e-01f, 7.11279437e-02f, -3.54537070e-01f, 4.41443585e-02f, 1.42529875e-01f, 1.51420653e-01f, 2.25140564e-02f, -2.31791422e-01f, 5.23489900e-03f,
  8.05844665e-02f, 8.62496719e-02f, -3.75406295e-02f, 1.51219919e-01f, -1.30875364e-01f, 1.23834670e-01f, 2.39019003e-02f, -8.37826580e-02f, 1.55019686e-01f, -4.44945171e-02f,
  3.22281308e-02f, 1.04663424e-01f, 7.62387086e-03f, 6.32727444e-02f, 1.08312175e-01f, 8.19391534e-02f, 1.71839800e-02f, 5.99340647e-02f, 1.97021395e-01f, 1.15075238e-01f,
  -3.81564349e-02f, -2.58259326e-01f, 1.73506871e-01f, -6.98963776e-02f, -6.45214617e-02f, 2.03717396e-01f, 9.38266292e-02f, -2.20267490e-01f, 1.76721305e-01f, -5.93713634e-02f,
  1.47984728e-01f, -8.79732072e-02f, 2.79575199e-01f, -1.58824414e-01f, -1.13163121e-01f, 8.38478003e-03f, 1.63819060e-01f, -1.38174728e-01f, 1.04937270e-01f, -3.06244195e-01f,
  3.26246351e-01f, 2.44627334e-02f, 8.35668817e-02f, -4.75135893e-02f, -1.48458391e-01f, 8.28474015e-02f, 1.72405198e-01f, 4.38399494e-01f, 9.01053473e-02f, -6.04583099e-02f,
  -1.13819912e-02f, -7.86384847e-03f, 2.80558076e-02f, 1.03873126e-01f, -1.22669205e-01f, -1.24308519e-01f, 1.32292733e-01f, -1.71862379e-01f, 3.62217873e-02f, 1.19710565e-01f,
  -2.41646960e-01f, 1.50214404e-01f, 8.04332942e-02f, 3.11727822e-01f, 3.42566520e-02f, 1.71640456e-01f, 1.27380025e-02f, 6.56969100e-03f, -3.46904323e-02f, -2.63081100e-02f,
  1.11477599e-02f, -1.43224791e-01f, -1.20061599e-01f, 5.58952801e-03f, -7.07878498e-03f, -7.17769265e-02f, 7.51834065e-02f, -7.94906318e-02f, 2.23949254e-01f, -7.41798207e-02f,
  1.04687542e-01f, -7.63270706e-02f, 2.53700577e-02f, -1.21875554e-01f, 6.55939057e-02f, -6.23574145e-02f, 1.27013962e-04f, -9.04147103e-02f, 1.69663668e-01f, -6.57022223e-02f,
  1.75455064e-01f, 7.04512820e-02f, -1.50266513e-02f, -9.98343006e-02f, -9.70511697e-03f, 4.12265062e-02f, 1.46585824e-02f, 1.96799114e-01f, 3.27495509e-03f, -2.69704815e-02f,
  -1.79064080e-01f, -1.48793668e-01f, -1.00335687e-01f, -2.80544674e-03f, 9.08392668e-02f, -1.19053088e-02f, 1.27116725e-01f, 1.61108032e-01f, 2.40721881e-01f, 3.30661312e-02f,
  -7.14926571e-02f, -1.54824853e-01f, 3.38759609e-02f, -5.09553142e-02f, -3.46934162e-02f, -1.23784319e-01f, 4.87649255e-02f, 2.01039359e-01f, 1.62443101e-01f, 2.42350195e-02f,
  1.45421354e-02f, -2.40689263e-01f, 1.25915244e-01f, -7.69842342e-02f, 1.28676623e-01f, 1.08199930e-02f, 3.17036249e-02f, 2.21971795e-01f, 2.28296325e-01f, 1.94286574e-02f,
  1.01262838e-01f, 2.91123509e-01f, 1.34841472e-01f, 7.80370981e-02f, 3.46695632e-02f, 1.14923470e-01f, 1.71153665e-01f, 1.21898040e-01f, 2.06397206e-01f, -4.00850065e-02f,
  2.07099780e-01f, 8.73178989e-02f, -1.96207851e-01f, -4.77683581e-02f, 6.57410994e-02f, -3.38966101e-02f, 1.46717399e-01f, 1.59898158e-02f, -9.93964598e-02f, -1.08604498e-01f,
  1.31049171e-01f, 3.73254567e-02f, -1.69246882e-01f, 2.15419590e-01f, 3.14489156e-01f, -1.36357889e-01f, 8.61568078e-02f, 2.76365697e-01f, 1.41525399e-02f, -1.64835155e-01f,
  -1.01625949e-01f, -1.26018897e-01f, -1.50374532e-01f, 6.82047801e-03f, 3.53047363e-02f, -1.51200667e-02f, -1.21274918e-01f, -2.11694553e-01f, 1.61140501e-01f, 2.00203240e-01f,
  7.41250440e-03f, -9.45537984e-02f, -8.24183226e-02f, 2.45025516e-01f, -1.09637216e-01f, 2.66808700e-02f, 2.56137460e-01f, -2.66090065e-01f, 1.71188980e-01f, 1.54174551e-01f,
  -3.97861116e-02f, -1.19662672e-01f, -3.99812967e-01f, 3.23526487e-02f, 7.43955895e-02f, 4.14572060e-01f, -3.39992642e-02f, -1.24752265e-03f, -2.40249902e-01f, -2.11714730e-01f,
  3.43511760e-01f, -1.50202364e-02f, 9.94015336e-02f, -3.33595648e-02f, 6.74322024e-02f, -1.77737132e-01f, 3.40189971e-03f, 2.74478309e-02f, 2.49899924e-01f, -1.13424733e-01f,
  2.04550028e-01f, -6.38440400e-02f, 1.04374923e-01f, 7.66085088e-02f, 5.08097038e-02f, -4.34237905e-02f, 1.87507167e-01f, -1.66544449e-02f, -1.31041929e-01f, 2.92627998e-02f,
  -5.81643768e-02f, -2.02612177e-01f, 1.30233198e-01f, -8.65851119e-02f, -2.15005085e-01f, -6.39245734e-02f, 3.92043404e-02f, -8.96947011e-02f, -2.05529869e-01f, 9.05610770e-02f,
  6.32099137e-02f, -6.00508973e-02f, -1.73367441e-01f, 2.35636249e-01f, 2.26012897e-02f, 8.95926878e-02f, 3.94582264e-02f, -1.10217363e-01f, -2.18609989e-01f, 2.06833959e-01f,
  -1.39912575e-01f, 4.75512743e-02f, -1.75405815e-01f, 2.57423911e-02f, 5.60938828e-02f, 1.39801696e-01f, 2.07054079e-01f, 4.37903367e-02f, 1.54359728e-01f, -1.62295967e-01f,
  -2.48515874e-01f, -7.97046423e-02f, 1.87360346e-01f, 6.69720098e-02f, -6.99224472e-02f, 2.45303899e-01f, -5.24482355e-02f, 4.82243858e-02f, -7.95965120e-02f, -1.61419705e-01f,
  -7.38929734e-02f, -7.13886693e-02f, 1.43260568e-01f, -5.18118702e-02f, -1.64162949e-01f, 9.99425128e-02f, 3.88887827e-03f, 7.21895173e-02f, -1.27961501e-01f, -4.07520421e-02f,
  1.61428139e-01f, 1.83512613e-01f, 1.33905727e-02f, 1.44723624e-01f, 5.91965578e-02f, 6.86796233e-02f, 3.79544161e-02f, 4.27366048e-02f, 3.05414438e-01f, 3.63206044e-02f,
  3.40136997e-02f, -1.61502004e-01f, 5.93185239e-02f, 2.96065118e-02f, -1.34840891e-01f, -4.26598877e-01f, 3.70277208e-03f, -2.35084489e-01f, -3.91720802e-01f, 2.86178384e-03f,
  -1.30806744e-01f, 4.24073078e-02f, -1.89690500e-01f, 2.06066221e-01f, 1.14754885e-01f, -9.12283547e-03f, 1.93661824e-02f, 8.90204832e-02f, -1.13078222e-01f, 1.10587858e-01f,
  -6.46614358e-02f, 2.41054799e-02f, -2.70522118e-01f, 2.54180253e-01f, -1.39620915e-01f, -1.16195880e-01f, -3.18486355e-02f, 5.87740727e-02f, -1.86005682e-01f, 2.88780052e-02f,
  3.69757533e-01f, 3.42830032e-01f, 4.05118056e-03f, -1.69468537e-01f, 2.16175646e-01f, 1.80892870e-01f, 4.17111218e-01f, -1.27224922e-02f, -4.90323976e-02f, -3.01705543e-02f,
  -9.93300676e-02f, 6.62892386e-02f, 4.12763469e-02f, -2.08594278e-01f, 5.10708466e-02f, -6.93962723e-02f, 2.31985182e-01f, -1.32230967e-01f, 1.68052167e-01f, -6.69349730e-02f,
  1.20079137e-01f, 1.47007048e-01f, 1.20489411e-01f, 1.88302010e-01f, 1.44780084e-01f, 6.55429065e-02f, 1.00407906e-01f, 1.46302998e-01f, 1.53813567e-02f, 2.73801051e-02f,
  1.99840084e-01f, 7.67582729e-02f, 4.81024310e-02f, -2.88593769e-02f, -1.24197654e-01f, -9.95056406e-02f, -1.21041417e-01f, 4.20355685e-02f, 5.03551699e-02f, 5.24521284e-02f,
  -2.44056970e-01f, 4.63474132e-02f, -4.88737039e-02f, -1.14042141e-01f, 1.60103112e-01f, 2.63435245e-01f, 3.01256210e-01f, 3.31036687e-01f, 1.27473116e-01f, -9.50766057e-02f,
  -1.14018090e-01f, -1.00438602e-01f, -1.28911272e-01f, 7.37353042e-02f, 1.32649437e-01f, -1.17237866e-01f, 6.06260486e-02f, 3.11971724e-01f, -2.57208049e-01f, -1.33043498e-01f,
  -1.04350887e-01f, 1.23173289e-01f, -1.21763356e-01f, -5.19722886e-02f, -8.60911682e-02f, 2.67626941e-01f, -1.61315173e-01f, -1.10862181e-01f, 3.76717821e-02f, -2.89434403e-01f,
  2.14262549e-02f, -5.67485578e-03f, 1.24356128e-01f, -1.32404253e-01f, -1.65979475e-01f, 1.32981181e-01f, -1.10647745e-01f, 2.46945962e-01f, -1.26300722e-01f, -1.66765079e-01f,
  2.02726930e-01f, -2.32902765e-01f, 5.97366393e-02f, -9.90582928e-02f, 4.87320237e-02f, 8.20106044e-02f, -8.37488472e-02f, 7.69302174e-02f, 1.63875714e-01f, 9.38794389e-03f,
  1.52335003e-01f, -3.09475325e-02f, 3.92125361e-03f, 5.27818576e-02f, 1.46004528e-01f, 2.31194228e-01f, 1.85208365e-01f, -1.65684626e-01f, -4.29885685e-02f, 1.50499657e-01f,
  -1.10052913e-01f, 3.76108214e-02f, -2.26530105e-01f, -5.74144395e-03f, -7.70242140e-02f, -1.15026124e-01f, -2.64810979e-01f, -1.18538821e-02f, -1.96324456e-02f, 2.71323830e-01f,
  4.24965583e-02f, 2.47706264e-01f, 6.73272759e-02f, -5.41184731e-02f, -6.04323298e-02f, 1.75167382e-01f, 1.22913539e-01f, 2.32848581e-02f, 2.66508818e-01f, -8.72099623e-02f,
  1.42635375e-01f, 1.61990434e-01f, -8.19326267e-02f, -1.02643140e-01f, -5.26980124e-02f, -3.23256552e-02f, -9.88626014e-03f, -7.03254864e-02f, -7.93078318e-02f, 8.09400976e-02f,
  8.89443327e-03f, -1.06146619e-01f, -2.61914223e-01f, -8.69502798e-02f, 1.37080088e-01f, 1.11843288e-01f, -7.93236047e-02f, -6.93665147e-02f, -8.91184360e-02f, -3.99873182e-02f,
  -1.27105504e-01f, -3.69592905e-02f, -1.04115523e-01f, -7.75177311e-03f, 1.18445218e-01f, -8.71544704e-04f, -7.12703764e-02f, 1.20421059e-01f, -9.69723463e-02f, 4.08632234e-02f,
  1.82779729e-01f, -2.29892461e-03f, 1.13427714e-01f, 7.47661516e-02f, -9.92541667e-03f, 1.24853142e-01f, 8.12769383e-02f, 2.45578159e-02f, 6.89519644e-02f, 9.45635512e-02f,
  -5.20596564e-01f, -1.35520548e-01f, 9.81448591e-03f, -2.44840160e-01f, -3.85484844e-02f, -2.02335969e-01f, -2.18032319e-02f, 6.45325170e-04f, 7.08597824e-02f, 2.61020362e-01f,
  -1.86944436e-02f, 1.44359842e-02f, 2.56925106e-01f, -2.17098780e-02f, 2.52626445e-02f, 6.91904724e-02f, -9.78650451e-02f, -5.51888309e-02f, -8.41675103e-02f, -3.18968892e-02f,
  6.37398884e-02f, 1.11622766e-01f, 2.03073040e-01f, 1.50452759e-02f, 5.08223958e-02f, 5.16174994e-02f, -2.40823746e-01f, 1.17102033e-02f, 1.17607132e-01f, -1.62069768e-01f,
  2.40563944e-01f, -1.43536460e-02f, -1.92631751e-01f, -2.36282945e-01f, -1.66915104e-01f, -8.09687376e-02f, -1.91352129e-01f, -1.84432659e-02f, 4.07669544e-02f, -1.17961824e-01f,
  -2.47862428e-01f, 7.27165192e-02f, 2.29340971e-01f, -1.12965196e-01f, 2.47558299e-02f, 8.41960609e-02f, 1.22324497e-01f, -2.06572339e-02f, -9.30187702e-02f, -3.96887064e-01f,
  -8.61396939e-02f, -9.63402390e-02f, 1.00797318e-01f, 3.01839318e-02f, 5.70132956e-02f, -6.84803054e-02f, -7.08659217e-02f, -7.38891289e-02f, 8.89203325e-02f, 2.51874663e-02f,
  -4.96182740e-02f, -1.20170198e-01f, -5.08125722e-02f, -1.31081110e-02f, 1.64721638e-01f, -1.14913303e-02f, 1.65826827e-01f, 3.02170634e-01f, 5.74274771e-02f, 3.33068445e-02f,
  -6.14505596e-02f, 1.21987695e-02f, -1.01312790e-02f, 8.16604719e-02f, -2.96698987e-01f, 9.97670293e-02f, -2.40811077e-03f, -1.23307802e-01f, 3.79615929e-03f, 1.78357884e-01f,
  -3.84571526e-04f, -8.44972730e-02f, 4.29892242e-02f, 2.31960803e-01f, 2.25335747e-01f, 1.23521753e-01f, -9.11724865e-02f, -3.05787235e-01f, -4.43615429e-02f, -1.02380067e-01f,
  -4.87757474e-02f, 4.92329672e-02f, -1.31169751e-01f, -3.03803653e-01f, -8.78342092e-02f, 3.49446712e-03f, 1.55315563e-01f, 8.45052749e-02f, 1.61725074e-01f, -2.62947768e-01f,
  -9.17213317e-03f, 2.22638756e-01f, 2.05839977e-01f, 6.31328747e-02f, -9.77556184e-02f, -6.68052398e-03f, 6.83658645e-02f, 1.16559066e-01f, -6.69654505e-03f, -1.75795943e-01f,
  -1.46276534e-01f, 1.06947996e-01f, 1.13832802e-01f, 1.36340380e-01f, -7.67548904e-02f, -2.87931878e-03f, 7.51244873e-02f, 1.28286719e-01f, 1.66887082e-02f, 9.00956839e-02f,
  1.30091369e-01f, 6.41230121e-02f, 2.18179315e-01f, 5.34082428e-02f, 2.29082834e-02f, -8.36833045e-02f, 6.66511133e-02f, 2.48840377e-01f, 3.58453244e-02f, -1.93229079e-01f,
  3.10730278e-01f, -2.17999574e-02f, -1.27905250e-01f, 1.78440940e-02f, -1.75634384e-01f, -1.06536195e-01f, 4.98073548e-02f, -5.29860072e-02f, -3.55064392e-01f, -1.70414701e-01f,
  -4.85513806e-02f, -1.53044045e-01f, 7.81314299e-02f, 2.40097299e-01f, -1.01165578e-01f, -2.45660171e-03f, -2.08979635e-03f, 2.41987929e-01f, 1.24138534e-01f, 2.42602602e-01f,
  1.11646995e-01f, -7.46174380e-02f, -2.45774403e-01f, 3.32394600e-01f, -9.07461345e-02f, 2.11265162e-01f, -1.72132209e-01f, -2.30917513e-01f, -1.65427864e-01f, -5.87442182e-02f,
  2.36049756e-01f, 1.74470738e-01f, 9.85757485e-02f, 1.74252503e-02f, -2.19841406e-01f, 5.94870448e-02f, 6.76995283e-03f, -1.00483716e-01f, 1.71338186e-01f, -3.67764123e-02f,
  -9.73302647e-02f, -5.10523655e-02f, -5.91857992e-02f, -2.93983668e-01f, -1.20138220e-01f, 9.60961878e-02f, 2.87055790e-01f, -2.78290529e-02f, -1.11332014e-02f, 1.44432381e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.14549682e-01f, 1.82363048e-01f, 3.54622416e-02f, 1.60774201e-01f, 2.71947589e-02f, 9.44329575e-02f, 1.37815326e-01f, 1.85636058e-01f, 1.44447699e-01f, 1.07038058e-01f,
  9.43799317e-02f, -1.07669391e-01f, -2.00506076e-01f, 1.42500639e-01f, -6.60108179e-02f, 2.19862238e-02f, 1.91147760e-01f, 5.33519052e-02f, 1.97870299e-01f, 2.61641830e-01f,
  2.03027338e-01f, 5.22134043e-02f, 5.44479564e-02f, 3.99816670e-02f, 1.49540797e-01f, 5.50165437e-02f, -2.17376366e-01f, 1.29965112e-01f, 1.87110379e-02f, 2.35354761e-03f,
  -9.79738832e-02f, 7.66330063e-02f, 1.36881366e-01f, 2.76551731e-02f, -2.79912204e-02f, 3.28063041e-01f, 2.89030056e-02f, -5.15816286e-02f, 1.79943264e-01f, 1.49983540e-01f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  3.30521166e-02f, -2.99085975e-02f, -2.50791870e-02f, 4.65927571e-02f, -2.02459931e-01f, 1.17840461e-01f, -6.32217675e-02f, -7.75450142e-03f, 3.11599188e-02f, 7.08121359e-02f,
  1.81998804e-01f, -8.07543620e-02f, 3.24993402e-01f, -1.65160045e-01f, -2.26750568e-01f, 2.92444620e-02f, 4.06303070e-02f, -4.39462215e-02f, -5.04477173e-02f, -1.20337024e-01f,
  -2.66685158e-01f, 9.90004838e-02f, -2.23663554e-01f, 5.02714328e-02f, 7.80925294e-03f, 1.35791883e-01f, 3.40497904e-02f, 2.31546149e-01f, 1.14984334e-01f, 1.34500220e-01f,
  -2.68855132e-02f, 8.70878771e-02f, -1.55968755e-01f, -2.51356989e-01f, 5.57656363e-02f, 7.77978823e-02f, 6.90985024e-02f, 1.23886921e-01f, -1.04887508e-01f, -1.13542408e-01f,
  -1.11034989e-01f, -7.65302703e-02f, 1.80232808e-01f, -8.63146782e-02f, 9.63516906e-02f, -1.51901856e-01f, 8.97142589e-02f, 1.64210856e-01f, -1.25358403e-01f, 2.05153659e-01f,
  7.40316212e-02f, 2.05758095e-01f, 8.85698795e-02f, 4.26778868e-02f, 1.60402969e-01f, -3.96330357e-02f, 7.90707581e-03f, -1.22531906e-01f, -3.27623069e-01f, -2.28155740e-02f,
  -1.16845533e-01f, 1.96563855e-01f, -1.43512145e-01f, -1.21810213e-01f, 1.40759766e-01f, -1.96670890e-02f, 2.97806319e-03f, 7.89609551e-03f, -1.05961282e-02f, 4.81207445e-02f,
  -4.26023826e-03f, -2.17093468e-01f, -1.04776107e-01f, 6.20866977e-02f, 1.01906702e-01f, -9.96652991e-02f, 4.03337300e-01f, 1.23451445e-02f, 3.18981521e-02f, -1.46221399e-01f,
  3.49448264e-01f, -5.32039721e-03f, 1.57929093e-01f, 1.43292814e-01f, 2.32016429e-01f, 2.73073792e-01f, 1.11360187e-02f, 1.31520927e-01f, 4.44041938e-02f, -8.42745155e-02f,
  1.46732613e-01f, -4.10639271e-02f, 1.53849095e-01f, -1.15278862e-01f, -8.30309540e-02f, -1.57062471e-01f, -1.85848624e-01f, -1.73249066e-01f, 2.20314637e-02f, -5.53279556e-02f,
  1.86553210e-01f, -5.68375960e-02f, -4.00333814e-02f, -5.89451753e-02f, -2.01393351e-01f, -9.78047848e-02f, -9.01016146e-02f, -3.90305966e-02f, 1.30967572e-01f, -1.94283783e-01f,
  1.87650342e-02f, -8.00049398e-03f, -8.85293111e-02f, 2.00651258e-01f, 2.29501694e-01f, 2.71037631e-02f, -4.15201932e-02f, -8.59383494e-03f, 1.51566222e-01f, 5.62780090e-02f,
  4.63637635e-02f, -1.60209730e-01f, -2.90637374e-01f, 7.70067647e-02f, 6.29121736e-02f, 5.56201078e-02f, -1.11939661e-01f, 4.52722050e-02f, 4.01181951e-02f, 1.07679889e-02f,
  -1.18041327e-02f, -9.16488096e-03f, 1.33712500e-01f, 8.49557295e-02f, -8.29320922e-02f, -2.78779189e-03f, -5.10961637e-02f, 2.13053487e-02f, 7.65842721e-02f, -2.82368227e-03f,
  3.06541681e-01f, 1.12614036e-01f, 2.28313301e-02f, 7.35269859e-02f, 1.43833965e-01f, 2.30416935e-03f, 1.59900829e-01f, -2.77836118e-02f, 5.59008718e-02f, 3.11849147e-01f,
  1.43881783e-01f, 1.52081057e-01f, 1.07907951e-01f, 2.57281084e-02f, 1.88192651e-01f, -2.38737136e-01f, 8.77777487e-02f, -1.68783337e-01f, -6.62377924e-02f, -1.64104983e-01f,
  5.99085167e-03f, 3.94127294e-02f, 4.13301885e-02f, -9.09447595e-02f, -3.78468223e-02f, -1.43924847e-01f, 5.44886515e-02f, 2.93457322e-02f, -7.77915120e-02f, -2.32761919e-01f,
  2.59470623e-02f, -1.04995593e-01f, 1.49840638e-01f, -4.97716153e-03f, 7.48715624e-02f, 1.24045670e-01f, 1.82299316e-02f, 1.43867761e-01f, 2.59978265e-01f, 1.03311248e-01f,
  1.06821397e-04f, -1.22608453e-01f, 1.69434786e-01f, -8.51954967e-02f, 1.47506306e-02f, -8.80901963e-02f, -2.72822604e-02f, -7.06991851e-02f, 2.29209140e-01f, -2.57086810e-02f,
  -5.42673171e-02f, -4.01629657e-02f, -2.87444536e-02f, -8.23491067e-02f, 7.68556222e-02f, 6.20219596e-02f, -1.38253003e-01f, 1.50614440e-01f, 5.97022027e-02f, -6.56104414e-03f,
  3.01396046e-02f, -1.09422751e-01f, 7.88491033e-03f, 7.21710101e-02f, -1.02722123e-01f, -1.89641073e-01f, 8.37185606e-02f, -9.87831317e-03f, 1.67689011e-01f, -1.48098037e-01f,
  -1.33596227e-01f, -4.22123913e-03f, -1.21671125e-01f, -2.64706105e-01f, 1.63348168e-01f, -1.30576134e-01f, -9.92508233e-02f, 3.91019396e-02f, -1.89762622e-01f, 1.20008558e-01f,
  -1.16976626e-01f, -6.20368719e-02f, -3.85739915e-02f, 9.40757394e-02f, -5.22845313e-02f, 1.07661020e-02f, 9.97674912e-02f, 7.27028847e-02f, 1.00743808e-01f, -6.98910877e-02f,
  -1.81900829e-01f, -1.17307253e-01f, 1.42714858e-01f, 2.36815624e-02f, 3.29251848e-02f, -5.02848215e-02f, -7.63854459e-02f, 1.52389333e-01f, -1.14322282e-01f, -4.96994033e-02f,
  -1.43378675e-01f, -2.29748532e-01f, -9.54157710e-02f, -1.22317066e-02f, 1.27768934e-01f, -7.59651139e-02f, -4.09729891e-02f, 1.16392419e-01f, -2.27790345e-02f, 1.31698787e-01f,
  1.61926121e-01f, -8.73972103e-02f, 9.28248558e-03f, 1.27478123e-01f, 4.78934571e-02f, -1.16464980e-02f, 1.56015507e-03f, -1.05045140e-02f, -9.16555449e-02f, 6.19345419e-02f,
  -4.58378457e-02f, 5.30461445e-02f, 1.91388145e-01f, -9.16811526e-02f, 1.87748387e-01f, -9.47653726e-02f, 3.14311951e-01f, 1.85870286e-02f, -5.05497009e-02f, -4.86398488e-01f,
  9.16292220e-02f, 2.08443776e-01f, 2.68183678e-01f, -1.34706527e-01f, 2.41630688e-01f, 2.18128376e-02f, 2.21621081e-01f, -5.42067736e-02f, -1.56175648e-03f, -6.52199313e-02f,
  -6.47177249e-02f, 1.09229788e-01f, 6.79420754e-02f, 2.13466763e-01f, 1.49123102e-01f, -1.72232419e-01f, -4.69963476e-02f, 7.05255046e-02f, -1.96085781e-01f, -7.88209662e-02f,
  -1.45474523e-01f, 1.90348461e-01f, 2.18464151e-01f, -8.39255750e-02f, -1.98362812e-01f, -2.68360943e-01f, 2.39482716e-01f, -2.88223475e-02f, 9.64753106e-02f, -1.04668871e-01f,
  -1.06662638e-01f, 3.97014134e-02f, 2.19268143e-01f, -8.09624493e-02f, -1.71320498e-01f, 3.92556004e-02f, 3.59390378e-02f, -4.99210581e-02f, 1.02900632e-01f, 1.16652653e-01f,
  3.92206237e-02f, 1.24385968e-01f, 1.16634309e-01f, 1.24636844e-01f, 2.76715960e-02f, 5.77678606e-02f, 1.26767620e-01f, 4.95407283e-02f, -5.32142706e-02f, -8.44129175e-02f,
  1.19880624e-01f, -1.31912410e-01f, -3.66247296e-02f, 2.13238284e-01f, 2.26383749e-02f, 1.10043943e-01f, -7.16027170e-02f, 2.63131559e-01f, -2.14556064e-02f, 8.23921561e-02f,
  -4.49737497e-02f, 9.87901315e-02f, -1.48052990e-01f, -1.99685395e-01f, -4.16778354e-03f, 2.17913687e-01f, -3.33954185e-01f, 2.12242767e-01f, 1.23856358e-01f, -2.43075162e-01f,
  2.39520550e-01f, -2.55913939e-02f, 1.01976812e-01f, 1.27406254e-01f, -1.44977681e-02f, -1.66780769e-03f, -2.05283090e-01f, -1.42793581e-01f, -1.99366704e-01f, 2.21693125e-02f,
  -1.32532045e-01f, -5.30980974e-02f, 2.75081187e-01f, -1.09929197e-01f, -4.18445915e-02f, 9.82943997e-02f, -1.76268741e-01f, 1.72747836e-01f, 8.14507008e-02f, -8.72354209e-02f,
  4.75420915e-02f, 1.06767088e-03f, -1.25637591e-01f, 1.79591682e-02f, 7.49602765e-02f, 6.89241439e-02f, -3.78966957e-01f, 1.91782564e-01f, -1.87201239e-02f, -1.30093902e-01f,
  -2.16729835e-01f, -1.02087907e-01f, -1.14529267e-01f, -5.32364100e-02f, 5.69989271e-02f, 8.03502277e-03f, 2.40929484e-01f, -9.27723795e-02f, 7.18555972e-02f, 2.32403591e-01f,
  8.92444029e-02f, 1.32713942e-02f, -1.49135470e-01f, -1.25872083e-02f, 7.25746080e-02f, 7.37532321e-03f, 7.77026415e-02f, 7.29046613e-02f, 1.72745287e-01f, -2.02775444e-03f,
  -3.70882638e-02f, 8.04220438e-02f, 2.20814243e-01f, -8.97037040e-04f, 4.04926799e-02f, -2.66022347e-02f, -1.93871722e-01f, -1.64616272e-01f, -1.96162179e-01f, 3.61676425e-01f,
  6.32622093e-02f, 4.15726788e-02f, -1.30176336e-01f, 6.94378242e-02f, 3.07992604e-02f, -2.15650633e-01f, 7.24859610e-02f, -1.27561122e-01f, -1.04200050e-01f, 6.06641499e-03f,
  1.58219561e-01f, 6.97015598e-02f, -3.19107398e-02f, 1.50312528e-01f, 3.18883024e-02f, 5.57327084e-02f, -7.44424984e-02f, 2.13988438e-01f, -1.13122545e-01f, -1.76591098e-01f,
  3.92330512e-02f, -1.51582330e-01f, -1.18846796e-01f, 2.95845922e-02f, 1.69608057e-01f, -2.66107377e-02f, 4.63127084e-02f, 2.02230826e-01f, -1.20254710e-01f, 3.68566848e-02f,
  -1.32956952e-01f, -8.20875689e-02f, 9.89774540e-02f, 1.13213263e-01f, 6.90668002e-02f, 1.39268804e-02f, -4.40020710e-02f, 1.67957395e-01f, -2.58350700e-01f, 2.39584036e-02f,
  -1.36603341e-01f, 5.80590479e-02f, 1.00512348e-01f, 2.09848080e-02f, -4.42277975e-02f, -6.70041740e-02f, 5.03413491e-02f, 1.36702776e-01f, -4.90138195e-02f, -1.44747883e-01f,
  2.96837687e-01f, -8.82528443e-03f, -3.78075391e-02f, 1.04379654e-01f, -6.30266890e-02f, 7.12808967e-02f, -9.69563648e-02f, 1.19583182e-01f, -7.34366998e-02f, 6.77676732e-03f,
  3.75147276e-02f, 6.98629767e-02f, 2.16571361e-01f, 1.61000803e-01f, 2.14443564e-01f, -4.09217440e-02f, -1.26515985e-01f, -2.60755688e-01f, -2.48688102e-01f, -1.49698645e-01f,
  -1.80346787e-01f, 1.10912085e-01f, 2.68165804e-02f, 1.30226448e-01f, -5.50402291e-02f, 1.76691085e-01f, -2.07573742e-01f, -1.83398142e-01f, 4.57041301e-02f, 1.02698572e-01f,
  2.66878307e-01f, 1.77195333e-02f, -7.63411224e-02f, 3.68729904e-02f, -2.02085838e-01f, 1.01288393e-01f, -1.77537173e-01f, 7.86696151e-02f, -5.61125465e-02f, -1.37308672e-01f,
  2.27099191e-02f, 1.80688761e-02f, 5.87320840e-03f, -2.97983568e-02f, -1.65391356e-01f, 3.18422243e-02f, -2.81671658e-02f, -1.47193402e-01f, 9.63740945e-02f, -9.25922170e-02f,
  -2.21241981e-01f, 4.17883173e-02f, -3.27061340e-02f, -3.32626812e-02f, 2.69784063e-01f, 7.34599456e-02f, 1.22768611e-01f, 2.97279418e-01f, 6.10578135e-02f, 5.46699483e-03f,
  -5.39552681e-02f, 1.27492219e-01f, -7.75709972e-02f, -6.19844086e-02f, -9.73807555e-03f, 4.55086492e-02f, -7.76094124e-02f, 1.65617123e-01f, 6.41568229e-02f, 1.26915857e-01f,
  -3.97160612e-02f, -1.31096095e-01f, 3.60260963e-01f, 2.12668374e-01f, -1.56249478e-01f, -1.73883711e-03f, -3.12811024e-02f, -9.75706708e-03f, 3.24347168e-02f, 1.17239110e-01f,
  -1.40661830e-02f, -1.79424390e-01f, 8.15842897e-02f, -1.91844717e-01f, -2.45002434e-01f, -2.69538648e-02f, -4.14991714e-02f, -1.38279572e-01f, 2.37582877e-01f, -1.54347271e-01f,
  -3.89946774e-02f, 1.99297234e-01f, 3.28330472e-02f, -1.33906931e-01f, -1.13767847e-01f, -1.95243850e-01f, -3.59444618e-02f, 5.08120991e-02f, -7.87213370e-02f, 2.82177925e-01f,
  1.30245283e-01f, 1.11419506e-01f, 3.93226482e-02f, -5.12239262e-02f, -6.16225153e-02f, 1.02042936e-01f, -7.32465610e-02f, 4.42448072e-02f, 2.74100620e-02f, -1.19679488e-01f,
  2.57280678e-01f, 5.77852270e-03f, 6.91624545e-03f, -1.18471906e-01f, -2.35301815e-02f, -6.58068210e-02f, 1.39835641e-01f, -1.02062911e-01f, 1.66261896e-01f, -9.60767716e-02f,
  2.83257425e-01f, -1.51142135e-01f, 1.19899191e-01f, 8.18320438e-02f, -1.55748174e-01f, 1.55194014e-01f, 5.81494905e-02f, 4.06894609e-02f, 7.41114020e-02f, 1.41440749e-01f,
  -9.64866206e-03f, -2.60208026e-02f, 1.21463649e-01f, 1.45587921e-01f, 9.61538497e-03f, 1.18114382e-01f, 2.92057153e-02f, 1.73199654e-01f, -1.57629415e-01f, 9.87956077e-02f,
  -7.84531981e-03f, 1.54619083e-01f, 2.29208261e-01f, 6.17910512e-02f, 2.51430813e-02f, -4.17124741e-02f, -8.36597905e-02f, -1.61050186e-01f, -1.59179494e-02f, 7.64892250e-02f,
  -5.67620620e-03f, -3.55233550e-02f, -7.99755305e-02f, 1.01475552e-01f, -1.36286661e-01f, -4.99791838e-02f, -1.77589357e-02f, 4.95190360e-03f, 5.24385795e-02f, 1.65031657e-01f,
  -1.55962229e-01f, 3.64415869e-02f, -5.36403805e-02f, 3.87777463e-02f, -2.02090323e-01f, -3.92152816e-02f, -1.23823673e-01f, -8.03205837e-03f, 5.82913049e-02f, 5.27170934e-02f,
  -1.80239603e-01f, 8.56907517e-02f, -2.24269643e-01f, -9.93601456e-02f, 1.45554170e-01f, -6.81974441e-02f, -1.81969762e-01f, 1.54957980e-01f, -2.55982220e-01f, 2.40664110e-02f,
  -6.46201745e-02f, -9.47749466e-02f, -5.69230244e-02f, 1.12296775e-01f, 7.58265853e-02f, 1.93345904e-01f, 8.00822377e-02f, 5.71815334e-02f, 1.92548469e-01f, 1.50389910e-01f,
  -8.01439434e-02f, -1.51335970e-01f, 1.08527452e-01f, 2.84989960e-02f, 1.95449293e-01f, -2.46208031e-02f, -1.50923312e-01f, 1.24140218e-01f, -1.89575955e-01f, 1.07741810e-01f,
  -1.24705531e-01f, -8.80012661e-02f, -2.77910590e-01f, 3.38521034e-01f, 1.76706165e-01f, 6.46479130e-02f, -2.50144824e-02f, -1.51447505e-01f, -1.48831382e-01f, -4.79252189e-02f,
  -2.20597118e-01f, -1.49537371e-02f, -1.66930884e-01f, -5.46214059e-02f, -5.76656349e-02f, 4.20265794e-02f, 2.08888101e-04f, 1.22020215e-01f, -1.74311355e-01f, -2.14716587e-02f,
  3.60675976e-02f, 7.07636625e-02f, 1.24280736e-01f, 1.62491083e-01f, 1.62202101e-02f, 8.62851460e-03f, -9.46194679e-02f, 8.42959955e-02f, 1.13889381e-01f, 1.77171916e-01f,
  -6.40458688e-02f, -8.20531771e-02f, -2.07715437e-01f, -1.51747242e-01f, -2.63320386e-01f, 3.72930355e-02f, -1.27434626e-01f, -3.43446657e-02f, 1.03496931e-01f, 9.01340693e-02f,
  -8.07303786e-02f, 6.27546683e-02f, -1.56550542e-01f, -1.70941800e-01f, -7.21557811e-02f, -7.71214664e-02f, -4.07825112e-02f, -6.41479529e-03f, 1.06801331e-01f, -2.91501991e-02f,
  1.21163115e-01f, -8.31395984e-02f, -3.07699461e-02f, -4.59010489e-02f, 9.72636975e-03f, 1.20645732e-01f, -1.29984021e-01f, -1.93869770e-01f, 4.26621921e-02f, -1.71115875e-01f,
  -9.16679874e-02f, -7.10562617e-02f, -1.25443295e-01f, -3.41034710e-01f, -4.71499674e-02f, -5.39341234e-02f, 2.05695466e-03f, -1.22677013e-01f, 1.63558409e-01f, 1.91968679e-01f,
  8.12771544e-02f, 1.04929104e-01f, -5.17847911e-02f, 2.00232282e-01f, -6.04395010e-02f, 1.27212748e-01f, 2.01890334e-01f, 2.77043104e-01f, -9.42737907e-02f, 3.03783324e-02f,
  1.48570821e-01f, 3.25332917e-02f, -3.71017382e-02f, -3.25762713e-03f, 2.54283279e-01f, -2.78654341e-02f, 3.90290879e-02f, 1.44349849e-02f, -2.16260001e-01f, -1.17880967e-03f,
  -3.55011225e-02f, -3.63303959e-01f, -2.11790919e-01f, -2.24587873e-01f, -1.39060125e-01f, 7.09669199e-03f, 3.43049467e-02f, -5.79158291e-02f, 1.47817299e-01f, 1.49599999e-01f,
  4.11521271e-02f, -1.22534856e-01f, -1.10812426e-01f, 4.25917134e-02f, 2.69014239e-02f, 1.76856760e-02f, -1.37117624e-01f, 7.56302401e-02f, -8.79869144e-03f, 1.04157694e-01f,
  -3.60715538e-01f, -3.57980840e-02f, -1.75886855e-01f, -1.11872993e-01f, 8.55011120e-02f, 7.63126090e-02f, 1.92264795e-01f, -3.43656950e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  8.98062885e-02f, 1.89471751e-01f, 8.17814693e-02f, 1.51554927e-01f, 8.45587347e-03f, 3.86995785e-02f, 8.15535486e-02f, 2.22274065e-01f, 1.64712980e-01f, 1.46985546e-01f,
  2.94817165e-02f, 1.15069866e-01f, -1.77839026e-01f, -2.93581009e-01f, -6.50797486e-02f, 2.27075636e-01f, 9.50245932e-02f, 1.29864529e-01f, -2.13889301e-01f, -1.41092479e-01f,
  -7.79249221e-02f, -2.19686151e-01f, 3.86114605e-02f, -9.87966359e-02f, 1.83486901e-02f, 2.71907300e-01f, 7.95798749e-02f, 3.62714052e-01f, -1.22956224e-01f, 1.84776127e-01f,
  1.35575905e-01f, 2.24199399e-01f, -1.30439222e-01f, 4.24192920e-02f, -3.67771834e-02f, 2.39848897e-01f, -9.01007652e-02f, -1.51496813e-01f, 2.17929315e-02f, -7.92523846e-03f,
  7.59827197e-02f, 1.38482720e-01f, 3.11322510e-01f, 2.51475751e-01f, -4.71683638e-03f, -5.02234548e-02f, -7.97601640e-02f, -2.92262763e-01f, -6.80226013e-02f, 7.00282631e-03f,
  -2.26925477e-01f, 1.47172853e-01f, 1.26200408e-01f, 2.52959400e-01f, -1.64112464e-01f, 1.59411386e-01f, -6.83733150e-02f, 2.56699950e-01f, 4.73886766e-02f, 1.82073638e-01f,
  4.98121753e-02f, 8.03813562e-02f, 2.29191601e-01f, 2.67894894e-01f, 7.83385336e-02f, 1.17353998e-01f, 2.91789882e-02f, 1.47167668e-02f, 1.21766832e-02f, 9.20275450e-02f,
  -1.20185457e-01f, 2.17658672e-02f, -7.18921274e-02f, 5.08353896e-02f, -1.07752224e-02f, -7.93077797e-03f, -1.45407215e-01f, -9.46828648e-02f, -1.28438160e-01f, 4.63620611e-02f,
  3.01788241e-01f, 3.32686789e-02f, 4.33712542e-01f, 2.85242051e-01f, -7.65815005e-02f, 1.53223366e-01f, 3.69835407e-01f, 1.74103320e-01f, 1.31183401e-01f, -3.94196995e-02f,
  -1.01337932e-01f, 2.93365985e-01f, 1.17843144e-01f, -3.48999441e-01f, -1.64339975e-01f, 1.28646910e-01f, 1.72592461e-01f, -1.18884817e-02f, 1.82583965e-02f, -5.18647395e-02f,
  -1.76247448e-01f, -4.40315157e-02f, -2.53820688e-01f, -1.00133039e-01f, -4.54625525e-02f, -1.11779667e-01f, -4.48708832e-02f, 1.19587615e-01f, 6.45892695e-02f, 9.86796916e-02f,
  -2.41586968e-01f, 2.65279233e-01f, 6.96264878e-02f, -1.82384789e-01f, -3.86230737e-01f, 1.31505057e-01f, -2.51486868e-01f, -7.20360354e-02f, -3.44766118e-02f, -4.99015599e-02f,
  2.63323575e-01f, 9.16095152e-02f, 2.19087198e-01f, 1.62248343e-01f, 2.92757377e-02f, -1.37280926e-01f, -1.27558544e-01f, 1.68987736e-01f, -2.83038206e-02f, 1.75655130e-02f,
  1.31224483e-01f, -2.98452936e-02f, -6.13388121e-02f, -6.27717227e-02f, -1.40588479e-02f, -1.27997711e-01f, -2.91491479e-01f, -2.59083718e-01f, -1.15533052e-02f, 7.45155960e-02f,
  2.21496820e-02f, 2.15783507e-01f, 6.52247220e-02f, 1.08669609e-01f, -5.82473278e-02f, 3.54460813e-02f, -6.27046973e-02f, -8.89130309e-02f, -5.68013750e-02f, 3.34630817e-01f,
  -3.86510849e-01f, -7.83524737e-02f, -5.04834130e-02f, 1.12539932e-01f, 1.70871466e-01f, 1.73412412e-01f, -4.82082106e-02f, 3.68886301e-03f, 1.64117664e-01f, -1.97879642e-01f,
  -1.83062032e-01f, 1.18826456e-01f, -1.74098909e-01f, 7.08190873e-02f, -1.60712376e-02f, -5.02079353e-02f, 6.42453060e-02f, 4.00774740e-02f, -8.23840275e-02f, -1.76628515e-01f,
  6.08728379e-02f, 4.53133993e-02f, 8.47302675e-02f, 1.26644149e-01f, 1.76378220e-01f, -1.41493946e-01f, 1.24847047e-01f, 1.57505706e-01f, -1.71466038e-01f, 1.80915505e-01f,
  -8.60131457e-02f, 3.81395780e-02f, -9.19958726e-02f, -1.14011823e-03f, -3.11832637e-01f, -3.93856363e-03f, -2.35075429e-02f, 2.18330156e-02f, 9.54706371e-02f, 2.23584279e-01f,
  1.64870307e-01f, 6.34505451e-02f, 1.33619988e-02f, 5.02906442e-02f, 2.95474470e-01f, 3.51737201e-01f, 2.30278969e-02f, 8.08712021e-02f, -3.97078060e-02f, 1.64688438e-01f,
  -3.24219689e-02f, 1.82078362e-01f, 9.20750946e-02f, 1.81591302e-01f, 1.58115357e-01f, -2.27071077e-01f, -2.25577131e-01f, 1.68603748e-01f, -1.05669528e-01f, -5.67117222e-02f,
  -1.84785128e-01f, -1.66450381e-01f, -3.98444116e-01f, -1.95145294e-01f, 8.04250091e-02f, -1.12046339e-01f, 8.52352902e-02f, 2.13577762e-01f, -2.66232580e-01f, 1.32068753e-01f,
  -1.59420690e-03f, 1.99333176e-01f, 7.12881610e-02f, 6.53260127e-02f, 1.21232443e-01f, -1.08569071e-01f, -4.61487658e-02f, 1.23361737e-01f, 9.19544920e-02f, -1.88949823e-01f,
  -2.13379100e-01f, -2.10875362e-01f, 1.87156901e-01f, 6.49990961e-02f, 2.84957469e-01f, 1.78481024e-02f, 8.71158540e-02f, -1.47390291e-01f, 7.97294453e-02f, -1.05178721e-01f,
  -1.56602889e-01f, 6.85510412e-02f, -1.63177475e-01f, 1.49715424e-01f, 1.18719988e-01f, -3.08482870e-02f, -1.44266292e-01f, -5.73696792e-02f, -1.09060947e-02f, -3.45861241e-02f,
  -2.43675798e-01f, 4.75221649e-02f, -6.96785599e-02f, 1.82943389e-01f, -7.25111589e-02f, -4.97026322e-03f, 1.04723334e-01f, 9.88051444e-02f, 2.70366669e-01f, 3.17163259e-01f,
  8.86232480e-02f, 1.76676422e-01f, -1.19931111e-02f, 1.46089166e-01f, -2.98480242e-02f, 9.90460888e-02f, 1.85259789e-01f, 1.89364552e-01f, 1.98362589e-01f, -3.67412299e-01f,
  -2.64111876e-01f, 2.29849413e-01f, 1.88170254e-01f, 1.19306982e-01f, -1.73966512e-01f, -6.11314131e-03f, 2.56939605e-02f, 4.67492454e-02f, -1.66664034e-01f, 7.24014342e-02f,
  1.18081287e-01f, 1.69418275e-01f, -6.68291152e-02f, -5.31185791e-02f, 9.06656384e-02f, 2.03789383e-01f, 1.09529972e-01f, 1.05831780e-01f, -4.00632620e-02f, -9.10002664e-02f,
  -2.00862154e-01f, 1.86476126e-01f, -3.22661400e-02f, -1.19136840e-01f, -2.88554311e-01f, -1.91336364e-01f, -6.31439835e-02f, -2.05844611e-01f, 3.17558050e-01f, 1.50673628e-01f,
  2.19366476e-01f, -9.62096527e-02f, 4.63601910e-02f, -1.03497751e-01f, -1.36808738e-01f, -7.92450309e-02f, -1.24444731e-01f, 1.03990488e-01f, 1.21744469e-01f, 1.43164188e-01f,
  -1.86685070e-01f, -5.70565537e-02f, -9.20997262e-02f, 8.38354006e-02f, -8.60788152e-02f, -7.85370544e-02f, 4.02592272e-02f, 2.70183355e-01f, -8.34581777e-02f, 3.19629051e-02f,
  5.56043610e-02f, 8.44909921e-02f, -6.65485393e-03f, 2.11479843e-01f, 5.47454618e-02f, 1.58498541e-01f, 2.69269533e-02f, 1.49553820e-01f, 1.17832743e-01f, 3.27818058e-02f,
  5.68329059e-02f, -2.32354123e-02f, -6.82160482e-02f, 2.06947862e-03f, -2.64779497e-02f, -1.28820762e-01f, 2.16822654e-01f, 1.32749211e-02f, 3.24377090e-01f, 2.39841610e-01f,
  -2.15602353e-01f, 4.98123914e-02f, 4.13056552e-01f, 2.43399084e-01f, 1.51586235e-01f, 8.88175592e-02f, 4.11779545e-02f, 1.31274581e-01f, 5.46261994e-03f, -2.95802802e-01f,
  9.17672366e-02f, 1.57128140e-01f, 3.81749988e-01f, 2.60219246e-01f, 2.34063976e-02f, -7.88427070e-02f, -1.72332287e-01f, -1.51293263e-01f, -1.83991473e-02f, 5.28536439e-02f,
  -1.59954011e-01f, -1.39363587e-01f, -8.37091953e-02f, -2.48343330e-02f, 9.01756510e-02f, 7.93716758e-02f, -2.98553199e-01f, 4.96334210e-02f, -1.49207592e-01f, -7.16364235e-02f,
  -3.67457479e-01f, 1.50420666e-01f, -2.47324526e-01f, -4.88011688e-02f, -1.17138728e-01f, 7.07370341e-02f, -1.83904916e-02f, 3.51652540e-02f, 2.04541877e-01f, -4.86728661e-02f,
  1.57699242e-01f, -2.26917095e-03f, 2.70413965e-01f, 2.96195686e-01f, 3.27434927e-01f, 1.98402107e-01f, 3.00981849e-02f, 1.90238491e-01f, 5.08183390e-02f, 1.25454679e-01f,
  1.84301645e-01f, 7.86756277e-02f, 3.73648226e-01f, 6.81842268e-02f, 2.00349063e-01f, -9.21629090e-03f, 4.07660484e-01f, 9.45971161e-02f, -3.02960694e-01f, 4.90096174e-02f,
  1.08136095e-01f, 3.14227968e-01f, -2.82708496e-01f, -1.67175189e-01f, 1.64215360e-02f, -5.13346307e-02f, -2.24176615e-01f, -3.69449198e-01f, 2.62674004e-01f, 8.10846761e-02f,
  -7.33001083e-02f, -1.58259705e-01f, 1.45933166e-01f, -1.69328794e-01f, 1.33399248e-01f, 2.97275297e-02f, -1.34506196e-01f, -2.91007340e-01f, -2.92148199e-02f, -1.01908796e-01f,
  1.03032701e-01f, 1.86247692e-01f, -2.98694223e-01f, -2.30316043e-01f, 2.51527578e-01f, -5.02471253e-02f, 6.18236996e-02f, 1.99098334e-01f, 3.24566901e-01f, 6.91805109e-02f,
  2.05606446e-01f, 1.59132898e-01f, -5.81186078e-02f, 3.61290574e-02f, 2.82485545e-01f, 1.89327955e-01f, 1.93382412e-01f, 8.34343303e-03f, -5.23912907e-02f, -1.25843361e-02f,
  2.17609424e-02f, -1.01950197e-02f, -3.54813963e-01f, 1.55467421e-01f, 2.81738713e-02f, 2.30852231e-01f, 5.11828847e-02f, -1.42520785e-01f, 4.02932800e-02f, 9.13182199e-02f,
  -3.89250845e-01f, -4.07630578e-02f, -5.91457598e-02f, 5.26808128e-02f, 2.33310834e-02f, -2.37919703e-01f, 1.61717340e-01f, -1.68139949e-01f, -3.42020035e-01f, -1.46283358e-02f,
  -1.09434642e-01f, -1.44768236e-02f, -5.47403917e-02f, -2.65237272e-01f, 3.00330529e-03f, 1.24596424e-01f, 2.27563813e-01f, 4.35012311e-01f, 4.54055965e-01f, 1.33930042e-01f,
  2.78068967e-02f, -6.26848545e-03f, 6.91197291e-02f, 1.50893643e-01f, -5.12953438e-02f, 1.00174814e-01f, 2.49292314e-01f, 5.99338412e-02f, 1.31191298e-01f, -6.57899976e-02f,
  -5.97840212e-02f, -1.47289276e-01f, 2.59168625e-01f, 3.16584371e-02f, 1.33007765e-01f, -3.98780145e-02f, -1.25826776e-01f, -1.39339685e-01f, 9.45345014e-02f, 2.71666735e-01f,
  -1.07135195e-02f, -6.86882585e-02f, 1.94326475e-01f, 4.71117608e-02f, 1.80837482e-01f, 3.04914266e-01f, -9.05305147e-02f, -5.42321764e-02f, 1.29447967e-01f, -2.01863691e-01f,
  5.78350760e-02f, 2.03745082e-01f, 1.14666574e-01f, 7.30906576e-02f, -8.64601061e-02f, 6.92286789e-02f, 2.22773701e-01f, -2.95448065e-01f, -7.95890391e-02f, -1.11841820e-01f,
  1.92866579e-01f, 4.84296270e-02f, -1.52873516e-01f, -9.77601409e-02f, 3.70673314e-02f, -2.13032305e-01f, 2.66256668e-02f, -8.69766697e-02f, 6.52582794e-02f, 9.88665223e-02f,
  -3.36391002e-01f, -1.30220383e-01f, 4.38681021e-02f, -3.28375548e-02f, -1.02105498e-01f, -1.44062694e-02f, 8.68471488e-02f, 1.96770146e-01f, -2.76073992e-01f, -8.26554522e-02f,
  -1.47178382e-01f, -1.18956361e-02f, -4.39148583e-02f, 7.79418051e-02f, 3.56891789e-02f, -4.60293181e-02f, 8.62851664e-02f, 1.64519340e-01f, 6.17638007e-02f, 2.43989658e-02f,
  2.26446558e-02f, 1.00914203e-01f, 1.93613693e-01f, -4.72844727e-02f, 2.85651647e-02f, 1.20840564e-01f, 2.39264709e-03f, 1.23555757e-01f, -9.59424675e-02f, -1.47227138e-01f,
  2.13838324e-01f, 2.99229383e-01f, 6.48141578e-02f, -1.24625437e-01f, 1.83955491e-01f, 7.66813830e-02f, 8.24082457e-03f, 2.15818435e-01f, 1.62583828e-01f, -3.66362542e-01f,
  7.68959150e-02f, 1.83892712e-01f, -1.04989177e-02f, 3.90478037e-02f, 8.29104427e-03f, -2.58415580e-01f, 9.68788117e-02f, 1.10763922e-01f, -3.93299639e-01f, 1.06759220e-02f,
  4.96245995e-02f, -2.13838756e-01f, 5.41726686e-02f, 1.60313398e-01f, 2.54856318e-01f, 2.02510253e-01f, 1.42799690e-01f, -8.59945938e-02f, -1.15560710e-01f, -3.87924276e-02f,
  -3.07902426e-01f, 1.95761155e-02f, 5.44177629e-02f, -1.35561883e-01f, -2.24676775e-03f, -1.87095832e-02f, -1.40195400e-01f, -5.91748990e-02f, 1.63827926e-01f, 1.58297420e-01f,
  -2.63161436e-02f, -1.64429918e-01f, -1.36371270e-01f, 1.29020125e-01f, 2.95465086e-02f, 1.32954389e-01f, 2.33683214e-01f, -1.13304392e-01f, -2.18378440e-01f, -4.24729399e-02f,
  2.83586979e-02f, 1.40243709e-01f, -1.34879366e-01f, -1.15251713e-01f, 1.75150007e-01f, -2.47371629e-01f, 2.08990633e-01f, -1.36975637e-02f, -3.62676114e-01f, -3.07464272e-01f,
  6.60643131e-02f, -7.32725710e-02f, 1.60845950e-01f, -9.33835208e-02f, -3.96737047e-02f, -1.28459364e-01f, 1.26838461e-01f, 2.01770291e-01f, -1.49866221e-02f, -3.95569652e-02f,
  2.74429440e-01f, 1.50589839e-01f, 2.67755717e-01f, 1.36364745e-02f, 1.79271683e-01f, -2.21653447e-01f, 7.68837854e-02f, 3.18476968e-02f, 1.43840939e-01f, -6.00804575e-02f,
  -2.82827288e-01f, 1.00699104e-01f, -3.67177427e-02f, -1.07907385e-01f, -2.47276664e-01f, -1.47242323e-01f, -4.70265560e-02f, 1.60985678e-01f, -1.37608454e-01f, -2.02933848e-01f,
  -6.27352521e-02f, 1.12780631e-02f, -8.35483000e-02f, -8.67707282e-02f, -3.22091818e-01f, -5.31973876e-02f, 2.98339929e-02f, -1.92230903e-02f, -1.65670872e-01f, 1.06087379e-01f,
  -1.32004797e-01f, -1.56064421e-01f, -2.15549376e-02f, -2.39426717e-01f, 1.20274991e-01f, 1.61517933e-01f, -1.73889548e-01f, 6.98890211e-03f, -1.19428247e-01f, -3.46660540e-02f,
  -1.49001986e-01f, -7.27980509e-02f, 1.78432707e-02f, 2.27240831e-01f, -1.29436399e-03f, 2.07324941e-02f, -7.39681069e-03f, 2.38632753e-01f, -1.02316298e-01f, 3.42676461e-01f,
  2.39072874e-01f, -4.34780382e-02f, -6.52238652e-02f, -2.57466555e-01f, -2.15304628e-01f, 2.31851146e-01f, 4.78060059e-02f, -1.92313820e-01f, 4.57261428e-02f, 1.77502036e-01f,
  -6.09159991e-02f, 2.25606576e-01f, 2.05678880e-01f, 8.96003395e-02f, 7.40612969e-02f, -2.08946154e-03f, 3.15191656e-01f, -3.06952924e-01f, 2.42306292e-02f, 6.74051195e-02f,
  2.89725307e-02f, 9.18851718e-02f, -4.78513055e-02f, 1.93642929e-01f, -2.31154427e-01f, 2.13462099e-01f, -2.63854295e-01f, 2.64022499e-01f, 1.10750562e-02f, 1.69884101e-01f,
  7.42096528e-02f, 1.08329430e-01f, 7.50857890e-02f, 3.16438586e-01f, 1.39096845e-02f, 9.79181528e-02f, 1.46714479e-01f, -3.58051322e-02f, -5.20531982e-02f, 2.72547957e-02f,
  4.16839980e-02f, -2.46031836e-01f, 3.01574111e-01f, -3.51809449e-02f, 1.01686276e-01f, 3.75196069e-01f, -9.98990387e-02f, 1.07973024e-01f, -2.02001318e-01f, 1.83450907e-01f,
  -2.80153811e-01f, 1.67841703e-01f, -2.82407224e-01f, -3.35040420e-01f, 7.87761360e-02f, -3.13663036e-02f, -5.38202405e-01f, 2.43134126e-01f, 1.15484990e-01f, -6.01054244e-02f,
  -1.55661941e-01f, -2.41929188e-01f, 1.08762518e-01f, 1.71274140e-01f, -1.28663644e-01f, -1.19322307e-01f, -2.04109699e-01f, -4.75832522e-01f, -2.43710622e-01f, -1.58123765e-02f,
  -1.01032153e-01f, 3.09301376e-01f, -4.72330935e-02f, 1.05964966e-01f, -4.03122693e-01f, 6.64756745e-02f, -1.96390659e-01f, 1.88834801e-01f, -1.47044957e-01f, 4.02893238e-02f,
  8.09755698e-02f, -3.76793072e-02f, 2.74729609e-01f, -5.86404130e-02f, -5.41274659e-02f, -4.46549654e-02f, -1.11588806e-01f, 3.00813109e-01f, -2.91698836e-02f, -7.00662807e-02f,
  -1.28055453e-01f, 8.38455930e-02f, 8.68775398e-02f, 2.71325856e-01f, 1.50852337e-01f, -8.00702944e-02f, -1.26967013e-01f, 2.44785085e-01f, 1.49483785e-01f, 1.15091264e-01f,
  2.00691760e-01f, 1.15946621e-01f, 4.35807072e-02f, -9.02857333e-02f, -4.20627296e-02f, -3.64954257e-03f, 4.03579362e-02f, 2.79094666e-01f, -3.74675430e-02f, 2.28006184e-01f,
  -1.13153516e-03f, 4.36660677e-01f, 4.18164730e-02f, 3.40101048e-02f, -1.26642212e-02f, 1.56254992e-01f, -1.51977055e-02f, -3.09328157e-02f, 8.67320597e-02f, -3.78690250e-02f,
  -6.09702095e-02f, 2.22476974e-01f, 2.17970251e-03f, -6.10341728e-02f, -9.88700241e-02f, -4.23517019e-01f, 1.36826098e-01f, 1.70093507e-01f, -3.46228629e-01f, 4.19030190e-02f,
  5.06773554e-02f, 5.00076562e-02f, -3.17035336e-03f, -2.89719164e-01f, -1.35127038e-01f, 2.04009920e-01f, -9.79262143e-02f, 1.93233848e-01f, -1.34146318e-01f, -1.27809932e-02f,
  -3.06563854e-01f, 1.96236029e-01f, -2.19520107e-02f, 9.43784863e-02f, -4.17507812e-02f, 2.85320124e-03f, 2.61680543e-01f, -4.72004898e-02f, -1.87274799e-01f, -6.64227754e-02f,
  -2.47187659e-01f, 1.15458228e-01f, -1.96611509e-02f, -3.52366239e-01f, 2.37969965e-01f, 3.81952897e-02f, 2.88460910e-01f, 2.37179846e-01f, 4.23000194e-02f, 3.47779617e-02f,
  9.94251147e-02f, 2.32658416e-01f, -1.30061107e-02f, -3.36575997e-03f, 3.77412558e-01f, 3.03563386e-01f, 7.75189474e-02f, 2.51748532e-01f, 7.12272748e-02f, 3.98478150e-01f,
  -1.23530053e-01f, 7.27870837e-02f, 2.37743720e-01f, 9.21496525e-02f, 2.26514563e-01f, -3.60175610e-01f, -1.25536069e-01f, 2.67611116e-01f, 2.84912676e-01f, 1.14009306e-02f,
  -2.83693910e-01f, -2.77070612e-01f, 8.77129554e-04f, 6.65833359e-04f, 5.42700179e-02f, 1.51884004e-01f, 1.57886092e-02f, 2.60253638e-01f, 1.37084499e-01f, 2.41212949e-01f,
  -1.04080528e-01f, 1.70648750e-02f, 1.24169648e-01f, 1.89398602e-01f, 8.82162303e-02f, 2.65092999e-01f, -1.10067062e-01f, 1.00605050e-02f, -2.52184182e-01f, -6.01260588e-02f,
  -1.35777995e-01f, -8.74501690e-02f, -9.30094421e-02f, -1.85138240e-01f, 3.08054239e-01f, 8.84558782e-02f, 1.01020671e-01f, 2.20785919e-03f, -3.30738455e-01f, -2.17206523e-01f,
  2.42055766e-02f, 9.88505855e-02f, -2.64878303e-01f, 2.79681116e-01f, -8.28178017e-04f, 1.85714275e-01f, -9.67112407e-02f, -3.80526334e-02f, 6.47420948e-03f, 8.49169269e-02f,
  -7.41962418e-02f, -2.48897355e-02f, 1.48276925e-01f, -4.96292114e-03f, 5.32740913e-02f, 1.19898960e-01f, -1.04089399e-04f, -9.34341252e-02f, 1.14214189e-01f, 3.09454054e-01f,
  -1.05985239e-01f, 5.93421385e-02f, 1.89504802e-01f, 2.33695641e-01f, 1.20110223e-02f, 2.63670236e-01f, 2.84552753e-01f, 2.30820492e-01f, 2.05378637e-01f, -3.96669328e-01f,
  -2.11847261e-01f, 8.54742900e-02f, 8.12502354e-02f, -8.11056793e-02f, -3.11448365e-01f, -2.42439955e-01f, -1.82761088e-01f, -2.90727466e-01f, 4.69911024e-02f, -1.95921242e-01f,
  8.15675929e-02f, 2.37901643e-01f, 4.03905734e-02f, 2.15860978e-01f, 9.52494070e-02f, 7.43894801e-02f, -2.31590830e-02f, 2.25190911e-02f, -2.62842566e-01f, -1.29602849e-01f,
  -8.85597840e-02f, -2.08333451e-02f, -3.66344675e-02f, -1.33974003e-02f, 8.38000178e-02f, -1.83592305e-01f, 1.09908730e-01f, -9.72773284e-02f, 2.31959313e-01f, 1.27025649e-01f,
  2.71899611e-01f, -2.13087812e-01f, -1.63471386e-01f, -2.64189720e-01f, 1.04048627e-03f, 8.43916014e-02f, -1.02593645e-01f, 1.52992949e-01f, 1.51946485e-01f, -5.39680012e-02f,
  -2.07961947e-01f, 3.40366848e-02f, 1.50859272e-02f, 9.47885960e-03f, -3.60649496e-01f, 7.19566718e-02f, -3.96507308e-02f, 2.46986434e-01f, -4.61991839e-02f, -3.83964665e-02f,
  7.94669911e-02f, 1.61349736e-02f, 6.24210387e-03f, 2.47249883e-02f, -1.13991268e-01f, 2.77487427e-01f, 3.12470078e-01f, 6.26059771e-02f, 2.55566120e-01f, 3.07827324e-01f,
  3.28089207e-01f, 1.56302258e-01f, -4.20016646e-02f, -2.30703801e-01f, -1.37263447e-01f, -1.03248537e-01f, -1.74545199e-01f, 3.49159315e-02f, -1.53054938e-01f, -2.29326293e-01f,
  1.42757609e-01f, -2.46752247e-01f, -3.06096882e-01f, -5.12393236e-01f, 1.07531622e-01f, -8.91380571e-03f, -1.56010106e-01f, 1.57055655e-03f, 8.26129541e-02f, 4.38277647e-02f,
  3.36361006e-02f, 1.16407625e-01f, -2.70801723e-01f, -4.34147030e-01f, 1.70794670e-02f, 8.14292505e-02f, 5.20775020e-02f, 2.38874301e-01f, 1.44272894e-01f, -4.62468117e-02f,
  2.49202311e-01f, 3.78421359e-02f, 9.91720706e-02f, 2.37612382e-01f, 1.50041208e-01f, 7.80338305e-04f, 2.73595273e-01f, -1.63526639e-01f, 5.65379374e-02f, -1.16947323e-01f,
  7.07491934e-02f, -4.53445986e-02f, 4.07955080e-01f, -8.36374611e-02f, -1.12211615e-01f, 1.38122097e-01f, -2.08293885e-01f, -8.28421265e-02f, -1.66881382e-01f, -1.10416077e-01f,
  -7.82835931e-02f, 2.62025535e-01f, 6.79136813e-02f, -1.28317863e-01f, -3.82870547e-02f, -6.40724227e-02f, 2.50379384e-01f, 1.66482791e-01f, 8.74658972e-02f, -2.11603250e-02f,
  -2.56903730e-02f, 1.46741480e-01f, -3.64843875e-01f, -1.99984655e-01f, 1.75227374e-01f, 6.77291527e-02f, -1.51685163e-01f, 4.40956384e-01f, 7.00833425e-02f, 6.11706078e-02f,
  -8.41149241e-02f, 3.59906964e-02f, -1.04383714e-01f, -3.37727457e-01f, 8.91528875e-02f, 4.06161726e-01f, -1.36499986e-01f, -7.12752417e-02f, 1.27673537e-01f, 3.26068029e-02f,
  2.53452092e-01f, -4.67304379e-01f, -1.91980779e-01f, -1.69851948e-02f, 2.58533925e-01f, -2.15152115e-01f, 1.06695406e-01f, 2.95537621e-01f, 7.21867308e-02f, -2.87969351e-01f,
  -1.09875292e-01f, -1.47087634e-01f, -8.01922828e-02f, 3.47629227e-02f, -4.58640635e-01f, -3.20357472e-01f, -1.24234363e-01f, -1.48676097e-01f, -2.03678370e-01f, 1.04782628e-02f,
  -1.99778244e-01f, -1.08353637e-01f, 1.03331231e-01f, 1.17238522e-01f, -1.37361586e-01f, 6.73363805e-02f, -1.40447825e-01f, 5.80426678e-02f, 2.99052931e-02f, -4.23973888e-01f,
  3.07540409e-02f, 6.07945360e-02f, 2.58967523e-02f, -3.85821774e-03f, 4.08959985e-02f, -4.63796370e-02f, 2.03016832e-01f, 7.11400732e-02f, 1.43710440e-02f, 1.71836272e-01f,
  -2.67354846e-02f, -1.28688544e-01f, 5.38229570e-02f, 4.52067964e-02f, 7.54862502e-02f, 4.17458341e-02f, 4.47720960e-02f, -1.11388907e-01f, -1.21776752e-01f, 1.88689351e-01f,
  -3.22158337e-01f, -1.25737667e-01f, 1.16352662e-01f, -1.38505623e-01f, -6.62238225e-02f, -1.94391474e-01f, 3.26491386e-01f, 2.61579990e-01f, 2.29703784e-01f, 1.97293367e-02f,
  6.52307495e-02f, 3.45872529e-02f, -2.22487450e-01f, -2.29504202e-02f, -2.35447899e-01f, 2.16036484e-01f, 1.41708076e-01f, -2.70882398e-01f, 9.80894938e-02f, 2.04231530e-01f,
  2.01270282e-02f, -5.56377927e-03f, 2.92769611e-01f, 1.15222022e-01f, 9.62031037e-02f, 2.78007444e-02f, 3.06734201e-02f, 1.97066545e-01f, 1.75230622e-01f, 4.65504155e-02f,
  1.58418223e-01f, 8.71339887e-02f, -6.93840384e-02f, 5.39727882e-02f, 1.04141913e-01f, -1.32412210e-01f, 1.58581614e-01f, -1.60175771e-01f, -1.92343667e-01f, -2.59847224e-01f,
  2.61459738e-01f, -4.40260358e-02f, -7.16481358e-02f, 1.84801832e-01f, 9.69838798e-02f, 1.28010780e-01f, 1.08583979e-01f, -1.43409848e-01f, -4.73510586e-02f, 1.23068467e-01f,
  -2.04251245e-01f, 1.11420669e-01f, 2.00542837e-01f, 1.62725180e-01f, 2.63113193e-02f, -4.30080853e-02f, 3.88594121e-02f, 3.55842650e-01f, 2.54605263e-01f, 1.16336532e-01f,
  1.96568310e-01f, 2.03366876e-01f, 1.91459041e-02f, -1.14149414e-01f, -3.42153036e-03f, -4.08535928e-01f, -1.63083509e-01f, -3.29380512e-01f, -1.10183880e-02f, -4.22876924e-01f,
  2.04098105e-01f, 2.28702009e-01f, 6.90671951e-02f, 1.96650013e-01f, 1.90814286e-01f, -2.39814088e-01f, 8.27720463e-02f, -1.21742591e-01f, -1.58197194e-01f, 1.93863794e-01f,
  -1.88004002e-02f, -3.66841219e-02f, -8.87619480e-02f, 1.13706030e-01f, 1.56122059e-01f, -1.72336683e-01f, 8.55477154e-02f, -2.65614569e-01f, -3.13541532e-04f, 1.16643183e-01f,
  2.39532590e-01f, 3.07699069e-02f, -1.31054372e-01f, 3.10764778e-02f, 2.17825934e-01f, 1.02882795e-01f, -6.28811773e-03f, -2.46838853e-01f, -2.35367149e-01f, 2.47150794e-01f,
  7.09597319e-02f, -2.97218468e-02f, -2.39727229e-01f, 6.36102930e-02f, 1.87586099e-01f, -2.33653724e-01f, 3.50419313e-01f, 6.16279505e-02f, -6.05928004e-02f, -9.03800800e-02f,
  -2.14297622e-01f, -2.64067173e-01f, -6.19048215e-02f, -4.59126979e-02f, -7.73676187e-02f, -2.46336699e-01f, 9.24330726e-02f, 1.77872613e-01f, -1.11317366e-01f, 1.84292439e-02f,
  -2.07460105e-01f, 2.86862254e-01f, 2.24407658e-01f, 1.62710194e-02f, 2.79429197e-01f, -6.30687177e-02f, -4.09796163e-02f, 2.37643030e-02f, 1.08152196e-01f, -7.47861713e-02f,
  -3.37988883e-02f, -1.97471127e-01f, -1.54232860e-01f, 9.57384184e-02f, 2.60682017e-01f, 3.05192918e-02f, 5.04288614e-01f, 3.56400982e-02f, -1.61651969e-01f, -2.32425854e-01f,
  -3.84512427e-03f, 1.27864880e-02f, -8.38517323e-02f, -1.62672568e-02f, 2.23404448e-02f, -6.15080595e-02f, 3.32746133e-02f, -2.85481364e-02f, -4.41501081e-01f, -2.18495756e-01f,
  2.63120651e-01f, -1.07298210e-01f, -3.26424539e-02f, 1.39566243e-01f, 4.42707837e-02f, -8.84108692e-02f, -6.37200370e-04f, -4.18804772e-02f, -1.03189424e-01f, 1.12356404e-02f,
  1.66455969e-01f, -1.55873805e-01f, 1.27372131e-01f, 1.17522277e-01f, -7.81916082e-02f, -1.38556346e-01f, 1.57497764e-01f, -9.37176943e-02f, 2.94181108e-01f, 2.98925396e-02f,
  8.83423984e-02f, -7.59496680e-03f, 1.25866756e-01f, -9.21082944e-02f, -2.03283370e-01f, -1.99239284e-01f, -3.04547787e-01f, 6.54453933e-02f, -1.27569601e-01f, -1.72942147e-01f,
  3.40334773e-02f, -6.10941015e-02f, -3.97456251e-02f, 1.48665190e-01f, 2.49300376e-01f, 5.82955368e-02f, -1.49976667e-02f, 1.64673492e-01f, -2.93683529e-01f, -4.32823807e-01f,
  1.50981754e-01f, 1.46238491e-01f, 1.82832137e-01f, 4.36359644e-01f, 6.00638166e-02f, 2.39721343e-01f, 3.75515103e-01f, 2.88666338e-01f, -2.09389210e-01f, -4.04206634e-01f,
  2.83954471e-01f, 4.03310686e-01f, -3.44316542e-01f, 5.89303523e-02f, 1.45701796e-01f, 3.11098080e-02f, 2.03060299e-01f, -1.32801563e-01f, -1.43284693e-01f, 4.26416732e-02f,
  -6.35161325e-02f, -3.10256928e-01f, -1.54956862e-01f, 7.07273930e-03f, -3.37111294e-01f, -1.84242934e-01f, -8.35574865e-02f, 3.51559445e-02f, -8.94244313e-02f, -1.32426247e-01f,
  -1.70181304e-01f, -1.07194148e-01f, 4.57930081e-02f, -1.93976149e-01f, 2.93013193e-02f, -5.00764430e-01f, -2.25628272e-01f, -8.29725638e-02f, 2.17805475e-01f, 2.26164863e-01f,
  -1.25705510e-01f, 9.00301859e-02f, -2.27926195e-01f, 8.51196125e-02f, 3.02121580e-01f, -4.27151561e-01f, 8.20401125e-03f, -2.92923093e-01f, -1.86774299e-01f, 1.88615322e-01f,
  1.25374228e-01f, 2.35429704e-02f, 8.95311683e-02f, -2.75801003e-01f, 7.13286027e-02f, 5.10905264e-03f, 1.77789375e-01f, 1.11342773e-01f, 1.44793540e-01f, -1.07335120e-01f,
  -8.13650563e-02f, -1.49787769e-01f, 2.07552090e-01f, -5.51080517e-02f, -2.22495813e-02f, 2.38542706e-02f, -2.39404976e-01f, 3.95051911e-02f, 9.67634916e-02f, 9.09706652e-02f,
  -1.81063011e-01f, 1.06711149e-01f, -2.79347450e-02f, 1.76572595e-02f, -5.16583212e-02f, -3.68689597e-01f, -1.18872803e-02f, 1.73830539e-01f, -2.04869434e-01f, 1.17203161e-01f,
  -3.03478986e-01f, 2.56302088e-01f, -2.84813140e-02f, 7.96431750e-02f, 1.50623769e-01f, 2.23806784e-01f, 4.38182168e-02f, -1.49442524e-01f, 2.63130711e-03f, 8.17086473e-02f,
  8.57793987e-02f, -2.54289787e-02f, -3.23188975e-02f, 2.05020532e-01f, 2.12990493e-01f, -3.24697793e-02f, 1.01956338e-01f, 1.31362140e-01f, -1.83103587e-02f, 1.42351568e-01f,
  2.60866612e-01f, -2.04142302e-01f, 2.04281390e-01f, -1.60508171e-01f, -1.07849143e-01f, -1.07410282e-01f, 3.37060867e-03f, 1.32049501e-01f, -2.39799365e-01f, 1.09410830e-01f,
  7.69447014e-02f, 2.56354243e-01f, 1.81011111e-01f, 2.74858385e-01f, -5.40312342e-02f, 9.27215815e-02f, -6.95129484e-02f, 4.69880067e-02f, 1.70760751e-01f, 1.47442475e-01f,
  5.93328550e-02f, 2.27940101e-02f, -1.53795108e-02f, 2.96272099e-01f, 2.11232692e-01f, -1.27450675e-01f, -5.62075712e-02f, -4.59075160e-02f, 1.29330335e-02f, 2.72709697e-01f,
  -7.96164870e-02f, 1.86711520e-01f, -5.79651594e-02f, 1.73051044e-01f, -2.37256307e-02f, 1.41391158e-01f, -2.13021517e-01f, -2.69514948e-01f, 1.89133331e-01f, 4.33728755e-01f,
  -5.26364088e-01f, 4.01089266e-02f, 3.12095508e-02f, 3.95193771e-02f, -4.98792492e-02f, -3.47818643e-01f, 1.28203988e-01f, -2.98414677e-02f, -1.28467202e-01f, -2.76886314e-01f,
  -4.22977954e-02f, -2.06018761e-02f, -7.01654851e-02f, -1.68173432e-01f, -1.97451845e-01f, 3.19815010e-01f, -4.68818434e-02f, -3.60697880e-03f, -4.57147896e-01f, 9.56753269e-02f,
  -1.07220262e-01f, 2.42772877e-01f, -1.51891813e-01f, 1.77166220e-02f, -8.18439275e-02f, -1.92555442e-01f, 1.57822564e-01f, 3.93508337e-02f, -6.86607435e-02f, -1.08808100e-01f,
  -3.09677310e-02f, 1.31403908e-01f, 1.07311077e-01f, -2.83919632e-01f, -1.24102555e-01f, 7.07292855e-02f, 1.18867055e-01f, 1.48458704e-01f, 2.41020873e-01f, 3.67426202e-02f,
  6.20671809e-02f, 2.39343673e-01f, 1.31503353e-02f, 2.23615523e-02f, 8.05352330e-02f, 1.70212954e-01f, -3.44509222e-02f, 2.60875821e-01f, -1.52214300e-02f, 5.74300475e-02f,
  -1.47647202e-01f, 2.61695415e-01f, -1.03172123e-01f, -5.82239144e-02f, -1.31569296e-01f, -1.22102685e-01f, -6.83247223e-02f, -2.46497616e-01f, 1.50974616e-01f, -1.12721480e-01f,
  3.37755054e-01f, 3.72027159e-01f, 1.31265922e-02f, 2.49650050e-02f, 1.99132040e-01f, 1.74500104e-02f, 2.22703695e-01f, -7.39110485e-02f, -2.15339944e-01f, 9.63533670e-03f,
  2.30896100e-01f, -1.94849715e-01f, -3.66487473e-01f, 2.59387612e-01f, 1.81233019e-01f, 9.96723399e-02f, 3.34082812e-01f, -3.34289849e-01f, -7.47595206e-02f, 4.10031416e-02f,
  -1.79620966e-01f, -2.33902689e-02f, 1.29519384e-02f, -1.88919723e-01f, 7.05970079e-02f, 1.17442265e-01f, 2.06000909e-01f, -1.77828968e-01f, 1.45464335e-02f, 8.97441879e-02f,
  -1.08978972e-02f, -1.41893655e-01f, -1.05512545e-01f, -1.42793860e-02f, 1.86925509e-03f, -1.53931767e-01f, -4.12887149e-02f, -1.41998678e-01f, 2.42184982e-01f, -2.10645884e-01f,
  4.29100208e-02f, 3.99349742e-02f, -1.42398462e-01f, -1.58143580e-01f, 3.13865580e-02f, 2.54666395e-02f, -3.35053564e-03f, 2.07538083e-01f, 7.41137611e-03f, -4.98721339e-02f,
  1.60789996e-01f, 1.55514076e-01f, -6.30960017e-02f, 6.18483387e-02f, -3.04151863e-01f, -3.81655991e-02f, 3.82120878e-01f, 1.11932725e-01f, 1.72427654e-01f, -1.15510277e-01f,
  -2.37900019e-01f, 7.30048642e-02f, 2.88692880e-02f, 8.23264476e-03f, -2.13604644e-01f, -1.82740197e-01f, 1.40775248e-01f, 2.08825171e-01f, -4.58046824e-01f, -2.55288519e-02f,
  8.39713141e-02f, 1.23748533e-01f, 1.26903411e-02f, -1.54903561e-01f, 5.74951731e-02f, 2.84277764e-03f, 1.23910345e-01f, -2.01840401e-01f, -7.66923055e-02f, 2.61275601e-02f,
  -8.43483806e-02f, -5.39646335e-02f, -8.45502317e-02f, 1.61898032e-01f, 2.42799316e-02f, 1.63260877e-01f, 2.71051358e-02f, -4.17597219e-02f, 1.01285189e-01f, -5.51858805e-02f,
  1.38945626e-02f, -2.64101755e-02f, 5.03371842e-02f, -2.08635196e-01f, 2.23222986e-01f, -5.84302507e-02f, -5.74204661e-02f, 3.67135480e-02f, 9.94481444e-02f, -7.23088831e-02f,
  1.19841054e-01f, -7.42001310e-02f, -1.47987932e-01f, 4.42258231e-02f, 7.08405301e-03f, -2.88049504e-02f, -3.65322269e-02f, 3.05662125e-01f, -8.04084539e-02f, 1.13197416e-01f,
  1.57249019e-01f, 9.10856668e-03f, -1.97725073e-01f, 1.82480484e-01f, -7.12752789e-02f, -1.16299435e-01f, 9.25429612e-02f, -3.45736027e-01f, 6.68652803e-02f, -1.62821725e-01f,
  -3.81968856e-01f, -7.60412440e-02f, -8.97639617e-02f, 2.41916999e-02f, -3.70966047e-02f, -8.23304951e-02f, 2.53851097e-02f, -8.05222616e-02f, -5.28591797e-02f, 3.71426344e-01f,
  2.52238274e-01f, 1.04224272e-01f, 2.18297184e-01f, 1.67018667e-01f, 5.47813717e-03f, 2.31638253e-01f, -1.52226359e-01f, 9.16166976e-03f, -1.13165779e-02f, -2.59834707e-01f,
  3.10768396e-01f, 5.35633974e-02f, 1.75914407e-01f, 2.12739855e-02f, -2.26942942e-01f, 6.47049770e-02f, 1.78838477e-01f, -1.40260696e-01f, -1.75918251e-01f, 2.22118665e-02f,
  1.27580523e-01f, 2.06457719e-01f, -5.66994026e-02f, -2.45601367e-02f, 2.22644478e-01f, 2.68099010e-01f, 2.71492422e-01f, 2.90446907e-01f, -1.13589086e-01f, -2.32302528e-02f,
  -3.59079391e-02f, 2.12675929e-01f, 2.71824952e-02f, 3.03817928e-01f, -2.23541081e-01f, 4.56569269e-02f, -2.28773564e-01f, 2.37142548e-01f, 1.99670866e-01f, -1.38232917e-01f,
  2.28918903e-02f, -5.04336208e-02f, 1.55078843e-01f, 8.64758119e-02f, 9.03048813e-02f, 1.55450553e-02f, 1.53034061e-01f, -9.72253904e-02f, 2.33031780e-01f, -8.20784792e-02f,
  3.13145593e-02f, -7.54655004e-02f, -5.29842824e-02f, -2.87961587e-02f, -3.32785368e-01f, -3.32603641e-02f, -7.86389709e-02f, 1.87058151e-01f, -2.12989509e-01f, 1.30863324e-01f,
  -1.60982043e-01f, 3.23780775e-02f, -2.57384747e-01f, 4.52523679e-03f, 2.20460013e-01f, 6.42447099e-02f, 1.13270255e-02f, 5.87645359e-02f, 2.00069956e-02f, -8.12739581e-02f,
  -2.57008880e-01f, 1.75253320e-02f, -4.82189981e-03f, 1.78368688e-01f, -3.32640350e-01f, -2.54440188e-01f, 9.96770039e-02f, 1.97383371e-04f, -2.27843851e-01f, -3.24092060e-01f,
  1.36897609e-01f, 6.51749149e-02f, -2.93762803e-01f, -7.58864880e-02f, -1.73428178e-01f, -2.37369947e-02f, -3.64481032e-01f, 1.83809027e-01f, -2.63137855e-02f, 5.35180643e-02f,
  -1.50719717e-01f, 2.93219239e-01f, 4.21873517e-02f, -2.19822582e-02f, -5.40546002e-03f, 7.15452135e-02f, -2.48548955e-01f, 1.96848169e-01f, 5.59997885e-03f, -8.35478827e-02f,
  1.82511270e-01f, 1.17711045e-01f, -3.33750471e-02f, 1.85989261e-01f, 1.38981670e-01f, -1.86184421e-01f, -3.34935784e-02f, 4.53279950e-02f, 1.60266519e-01f, 1.81340829e-01f,
  8.59362110e-02f, 2.46192247e-01f, -4.36749645e-02f, 2.09249258e-02f, 1.09393969e-01f, 1.22894339e-01f, -6.68479130e-02f, 6.71114326e-02f, 3.33764195e-01f, 2.20423788e-01f,
  2.91987598e-01f, -2.84015685e-01f, -2.83746094e-01f, 2.20185027e-01f, 2.14081541e-01f, 2.41555840e-01f, -3.52206677e-01f, -6.82357624e-02f, -2.06236959e-01f, 7.70748854e-02f,
  1.36747703e-01f, 2.16549799e-01f, 1.93335980e-01f, 1.48017809e-01f, -1.26153072e-02f, -7.69458190e-02f, 7.82714318e-03f, 5.92618920e-02f, -2.65029427e-02f, 6.88956454e-02f,
  8.15139562e-02f, -2.49355659e-01f, -3.20779175e-01f, -1.31270945e-01f, -9.34282318e-02f, 1.29846603e-01f, -2.30337426e-01f, -1.52578592e-01f, -8.49331990e-02f, -2.39834730e-02f,
  1.66020900e-01f, 1.17810898e-01f, 2.12702155e-01f, -1.98233426e-01f, -1.57569736e-01f, 1.25309452e-01f, 8.32213759e-02f, 8.01337957e-02f, -2.93184012e-01f, 3.33394408e-01f,
  -1.85678452e-01f, 1.79192901e-01f, 3.69057432e-02f, 7.24234805e-02f, 2.31262863e-01f, -9.37934220e-02f, -1.53425902e-01f, 1.50931761e-01f, 1.67996347e-01f, 1.82747647e-01f,
  -1.91040277e-01f, -1.00009944e-02f, 8.17332193e-02f, 3.55808772e-02f, -1.01979785e-01f, 1.33577526e-01f, 2.44550984e-02f, 1.29443571e-01f, 6.20615259e-02f, 1.32461503e-01f,
  -9.43888351e-02f, 5.79018705e-02f, 7.82229006e-02f, 2.14730576e-01f, 9.34943408e-02f, -2.54536748e-01f, -1.98091149e-01f, -2.04869583e-01f, 3.27035278e-01f, 1.55044766e-02f,
  2.90482268e-02f, 1.37634024e-01f, -2.15392336e-01f, 2.05992803e-01f, 1.91301763e-01f, 1.31944284e-01f, 8.78027920e-03f, 7.36027136e-02f, 1.40192330e-01f, 1.42351806e-01f,
  6.94976130e-04f, -2.21970677e-01f, 7.96984881e-02f, 1.00277938e-01f, 1.83181912e-01f, -1.31765798e-01f, -2.41744071e-01f, 1.56727120e-01f, 1.84040256e-02f, -8.40848908e-02f,
  -2.05642611e-01f, -3.23245406e-01f, -1.80073068e-01f, -1.59550123e-02f, 1.84923150e-02f, 5.80452457e-02f, 1.64312884e-01f, 1.18673354e-01f, -1.44295022e-01f, -1.34329095e-01f,
  -2.64227808e-01f, -9.39201564e-03f, -2.31877312e-01f, 3.06837589e-01f, -2.26008624e-01f, 2.38157243e-01f, 4.12351079e-02f, 1.97764188e-01f, -7.80707821e-02f, 1.39993876e-01f,
  7.91575164e-02f, -4.49641943e-02f, 3.01712342e-02f, -8.20970237e-02f, 2.63776511e-01f, 1.72128901e-01f, 5.05095497e-02f, 1.40747949e-01f, 3.47818248e-02f, 2.37910718e-01f,
  3.06668013e-01f, 1.14343561e-01f, -1.11259319e-01f, 2.26881146e-01f, -6.12825789e-02f, 5.48326150e-02f, 1.16353713e-01f, -1.05293393e-02f, 3.41446102e-01f, 1.17883079e-01f,
  -3.16868693e-01f, -9.17138606e-02f, 4.23523635e-01f, 1.63038835e-01f, -1.65786564e-01f, -3.52678411e-02f, -1.29776299e-01f, 3.36281955e-01f, -1.20682633e-02f, -1.07958749e-01f,
  3.44856143e-01f, 1.22199975e-01f, 1.52050987e-01f, -2.61417270e-01f, 4.46550064e-02f, -2.49782309e-01f, 5.53799421e-02f, 9.47400481e-02f, 2.23558217e-01f, 1.46078840e-01f,
  -1.08434021e-01f, -2.78369814e-01f, -5.12874350e-02f, 7.73409232e-02f, -2.25425616e-01f, -9.69603360e-02f, -8.56916830e-02f, -1.35131836e-01f, 1.26776800e-01f, -6.20570406e-02f,
  2.84029335e-01f, -2.15690449e-01f, -3.87646973e-01f, 3.01068336e-01f, -1.33033603e-01f, 1.57291919e-01f, 2.47261897e-02f, 1.61315203e-01f, -1.86037272e-01f, 2.36956030e-02f,
  1.21838329e-02f, -3.93018499e-03f, 2.02277705e-01f, -1.77726224e-01f, -1.79460227e-01f, 2.46576592e-02f, 4.79799509e-02f, -5.09638973e-02f, 1.26157746e-01f, -1.03882670e-01f,
  -2.92904563e-02f, -5.97068062e-03f, 1.03657790e-01f, 8.72941501e-03f, -6.92311004e-02f, 1.69004947e-01f, 7.86805376e-02f, -6.30133674e-02f, 6.79476559e-02f, 7.47793391e-02f,
  4.98060063e-02f, 2.33629510e-01f, -3.59295309e-01f, -9.85415354e-02f, 9.82641578e-02f, -1.73897281e-01f, -1.41245976e-01f, -3.09579223e-01f, 3.06334376e-01f, 8.22942182e-02f,
  1.07108735e-01f, -7.26793036e-02f, 1.91871747e-01f, -1.54905338e-02f, -1.46103175e-02f, 8.04355666e-02f, -9.99825355e-03f, 2.17255950e-01f, 1.73764005e-01f, -2.82054394e-01f,
  -2.79298276e-02f, 2.56109327e-01f, -3.88782867e-03f, 2.45215222e-01f, 2.31178954e-01f, -3.74421366e-02f, -1.06753536e-01f, -3.35518457e-02f, -1.32969052e-01f, -9.26649794e-02f,
  1.81873553e-02f, 1.47284478e-01f, 7.51854032e-02f, 8.13960806e-02f, 1.90837644e-02f, 1.08838506e-01f, 4.30233777e-02f, -2.34468728e-01f, 2.73356382e-02f, -1.58431485e-01f,
  -1.89508423e-01f, -2.29484290e-01f, 1.67303622e-01f, -1.65435538e-01f, 3.37066390e-02f, 1.69363856e-01f, 1.51739657e-01f, 2.83840802e-02f, 9.71917212e-02f, -7.04899281e-02f,
  -1.96708530e-01f, 2.23227609e-02f, -1.32777438e-01f, -3.67925428e-02f, 2.49437720e-01f, 1.19570330e-01f, 1.07749820e-01f, 1.20980553e-01f, 2.91515458e-02f, 3.00738126e-01f,
  7.19945952e-02f, -4.92075235e-02f, 1.87543198e-01f, 2.38306955e-01f, -3.29085961e-02f, 1.08781382e-01f, -1.02255940e-01f, 8.18498135e-02f, -1.40037656e-01f, -1.53313145e-01f,
  1.25733390e-01f, -8.06362033e-02f, 1.85485631e-01f, 1.68515220e-01f, 2.56605446e-01f, -1.43193053e-02f, 2.95618236e-01f, -6.40945211e-02f, 1.89337969e-01f, -4.25437726e-02f,
  -7.60396942e-02f, 2.24543381e-02f, 2.86984056e-01f, -1.18297845e-01f, -5.14154255e-01f, 8.63487795e-02f, 2.32867375e-01f, 7.34182149e-02f, 3.25397164e-01f, -2.85021782e-01f,
  -8.37777480e-02f, 3.34304273e-01f, -1.06725208e-01f, -4.01748046e-02f, 7.45666921e-02f, -1.36682004e-01f, -8.52317065e-02f, 2.15219542e-01f, 5.54341413e-02f, -1.80014625e-01f,
  -1.06050678e-01f, 2.16903716e-01f, 1.67598113e-01f, 2.76541710e-02f, 8.48526508e-02f, -4.53348793e-02f, 1.20027803e-01f, -1.12291649e-01f, 1.91286698e-01f, -1.68640181e-01f,
  1.30724326e-01f, -2.07997367e-01f, 5.97176366e-02f, 1.14565276e-01f, 1.84413239e-01f, -5.27576134e-02f, -3.09677497e-02f, -1.15503453e-01f, 7.58751556e-02f, -2.98865251e-02f,
  1.35290533e-01f, 1.40853614e-01f, 1.36886850e-01f, 2.16298074e-01f, 1.29190534e-01f, -6.49375767e-02f, -3.41105729e-01f, 1.75818428e-01f, -4.18026410e-02f, 1.59694061e-01f,
  -9.02240649e-02f, 4.20154721e-01f, -1.32090941e-01f, -1.85395032e-01f, -3.23816352e-02f, 1.71947896e-01f, -7.50252232e-02f, -1.63608883e-02f, 7.89224654e-02f, 3.53153288e-01f,
  -1.52841270e-01f, 8.81102905e-02f, 1.28375441e-01f, -4.03956063e-02f, 1.53431773e-01f, -5.20115733e-01f, 5.70220165e-02f, 9.50155854e-02f, 2.29796603e-01f, -3.33339304e-01f,
  1.92188978e-01f, 1.72333628e-01f, 5.74837951e-03f, -5.11700451e-01f, -2.03597754e-01f, -2.69407965e-03f, 2.05016062e-02f, 5.80135956e-02f, -5.65201581e-01f, 1.36321515e-01f,
  -2.03830212e-01f, -5.79171181e-02f, -2.25015935e-02f, 2.03198791e-02f, -1.65210247e-01f, -4.90165949e-02f, 3.72319669e-02f, 8.72407332e-02f, -2.38698676e-01f, 9.93854776e-02f,
  -1.03700608e-01f, 1.48383051e-01f, 1.82174250e-01f, -2.79279351e-01f, 4.56244349e-02f, -2.12060720e-01f, 5.24747260e-02f, 4.27256309e-04f, -1.83655247e-02f, -1.23527884e-01f,
  8.14861432e-02f, 1.84046611e-01f, 3.29082549e-01f, 8.83332565e-02f, 1.95580527e-01f, 1.83952138e-01f, 3.75824235e-02f, 4.28461820e-01f, 3.36253941e-02f, 2.61878312e-01f,
  1.90492868e-01f, 2.88649589e-01f, 3.19877043e-02f, -8.96127988e-03f, -2.50771046e-02f, -1.49839133e-01f, 4.75514308e-02f, -5.14053591e-02f, 7.96099473e-03f, -1.68629810e-01f,
  1.07723214e-01f, 1.90978780e-01f, 1.18666589e-01f, -7.11281411e-03f, 2.30294302e-01f, -2.79153109e-01f, 7.65353665e-02f, -1.72153905e-01f, -4.42160033e-02f, 1.03828043e-01f,
  -2.89024506e-02f, 9.65166986e-02f, -3.92765224e-01f, 1.64141908e-01f, 2.26273596e-01f, 1.57768250e-01f, 2.93270260e-01f, -1.43275499e-01f, -1.97624713e-01f, 2.07967758e-01f,
  1.27554283e-01f, 2.01485846e-02f, 1.15142770e-01f, -5.52729256e-02f, 6.26321808e-02f, 1.95507139e-01f, 2.66533792e-02f, -2.94455409e-01f, -2.73418099e-01f, -8.09632689e-02f,
  4.47781645e-02f, 3.66640575e-02f, -2.52005309e-01f, -5.39854988e-02f, 2.43021145e-01f, -3.67202371e-01f, 4.42360193e-02f, -1.14116497e-01f, 1.40595391e-01f, -1.48012131e-01f,
  1.02525003e-01f, -7.33326897e-02f, -1.59995228e-01f, -5.42955138e-02f, -1.92503124e-01f, -3.04723501e-01f, 2.17818990e-01f, -5.57376770e-03f, 6.15151562e-02f, 9.89733711e-02f,
  -1.71315610e-01f, 8.74362737e-02f, 1.79033324e-01f, 4.27641980e-02f, 2.52009422e-01f, 2.90673226e-01f, 1.37361497e-01f, 3.98242753e-03f, 6.31400123e-02f, -1.75790578e-01f,
  -2.09334552e-01f, -2.83700693e-02f, -1.17827766e-01f, 1.56979874e-01f, 2.74148136e-02f, -3.61248944e-03f, 3.69041979e-01f, -5.78325242e-02f, -1.59482196e-01f, -3.26018840e-01f,
  1.25583217e-01f, -1.97991598e-02f, 5.42877987e-02f, 4.03876901e-02f, 1.40492275e-01f, -3.66498018e-03f, 8.11806992e-02f, 2.26677775e-01f, -1.54430732e-01f, -5.37598170e-02f,
  3.36961418e-01f, -4.67907265e-02f, 1.33063391e-01f, 1.08792886e-01f, 2.26094440e-01f, 1.78770632e-01f, 1.39381960e-02f, 1.75530195e-01f, 2.75813162e-01f, 7.68993869e-02f,
  1.22992858e-01f, -6.47052526e-02f, 6.12769574e-02f, -1.28277943e-01f, 1.85688287e-02f, -4.07941043e-02f, 1.94024891e-01f, -1.76640332e-01f, 2.37780347e-01f, 2.42012180e-02f,
  -1.90766361e-02f, -4.51937914e-02f, -3.65558453e-02f, -1.37649849e-01f, -1.69015557e-01f, -2.96895415e-01f, -2.83461064e-01f, 1.35853186e-01f, -1.44038811e-01f, -2.91195631e-01f,
  -2.68754456e-02f, -1.95347577e-01f, 5.34081385e-02f, 2.15475131e-02f, -1.93626806e-01f, -4.87749241e-02f, 6.53578490e-02f, 1.22735746e-01f, -3.78703743e-01f, -1.49476334e-01f,
  5.16259633e-02f, -1.86676253e-02f, 2.20080882e-01f, 1.11268848e-01f, -1.43000826e-01f, 1.39896691e-01f, -1.09091341e-01f, -1.84175089e-01f, -1.20624423e-01f, -3.32765430e-01f,
  -1.06269255e-01f, 2.99374431e-01f, -2.97009289e-01f, 1.77368805e-01f, 8.49490287e-04f, 2.20705807e-01f, 1.29176423e-01f, 8.88319686e-02f, -1.87435448e-01f, 2.76750717e-02f,
  7.66397491e-02f, -9.49189141e-02f, -8.72756988e-02f, -7.83574283e-02f, -1.35186106e-01f, -4.80589718e-02f, -5.91889545e-02f, 5.73826991e-02f, 1.14694610e-01f, 5.69041893e-02f,
  -2.29424134e-01f, -1.95885003e-01f, 1.47532940e-01f, -6.62000179e-02f, 5.51267974e-02f, -1.85832918e-01f, 8.23097827e-04f, -2.62821853e-01f, 3.75144407e-02f, 1.31219447e-01f,
  -7.05984831e-02f, 7.10031018e-02f, -1.29443452e-01f, 9.38515812e-02f, 3.33016180e-02f, -6.38145283e-02f, -8.96846205e-02f, 1.17012672e-01f, -2.24524111e-01f, -6.22057728e-02f,
  -4.41996902e-02f, 2.06818670e-01f, 2.04062074e-01f, 9.92503241e-02f, 2.50681061e-02f, 1.90857485e-01f, 2.53221154e-01f, 1.75723821e-01f, 1.35192135e-02f, 2.28727665e-02f,
  9.66155306e-02f, -5.87749518e-02f, 1.74800098e-01f, 6.15103811e-04f, 2.19660044e-01f, 3.58478099e-01f, 2.49127205e-02f, -5.43376841e-02f, -2.26470441e-01f, 2.10101113e-01f,
  2.47257445e-02f, 3.50701362e-01f, -3.95070851e-01f, -3.18936914e-01f, -1.36616543e-01f, -2.00116500e-01f, -5.83626807e-01f, -1.50282577e-01f, 3.86180542e-02f, 4.88932617e-02f,
  -1.93203896e-01f, -3.46076757e-01f, 2.96627969e-01f, 1.79106817e-01f, -1.98144466e-01f, 2.19048634e-02f, 3.30868065e-02f, -3.85449857e-01f, -1.27782568e-01f, -7.94830024e-02f,
  -4.62044915e-03f, 1.05818756e-01f, -1.73608571e-01f, 5.33313788e-02f, 1.41685233e-01f, -4.49531786e-02f, 1.78050637e-01f, 3.00124675e-01f, 1.35802016e-01f, -4.84005325e-02f,
  5.79540096e-02f, 3.29978049e-01f, 1.86155245e-01f, -3.00099365e-02f, 5.33062033e-02f, -9.91952121e-02f, 2.06357285e-01f, 1.24106660e-01f, -1.04749873e-01f, -1.17996195e-02f,
  2.18145072e-01f, 1.20208375e-01f, 7.52089098e-02f, 3.06045443e-01f, 1.35002077e-01f, 2.35097110e-01f, -9.75415483e-02f, 6.65913671e-02f, -1.38837904e-01f, -1.08850989e-02f,
  2.83924729e-01f, 1.68380111e-01f, 2.76809365e-01f, 1.52196854e-01f, 1.00084625e-01f, 2.29728103e-01f, -2.56648272e-01f, -4.67311665e-02f, 8.28325003e-03f, -4.30159122e-02f,
  -3.80470216e-01f, 6.00599349e-02f, 8.19823965e-02f, -2.52310365e-01f, -1.63154863e-02f, -8.26323107e-02f, 3.48284423e-01f, 1.84813455e-01f, 2.37432659e-01f, 1.91094458e-01f,
  3.48719209e-01f, 1.10626690e-01f, -2.00890541e-01f, 8.93761367e-02f, 1.44995421e-01f, 1.06450811e-01f, -1.41406372e-01f, -7.76535366e-03f, 1.29315272e-01f, -3.33741233e-02f,
  2.85908729e-01f, 2.19294325e-01f, 3.47641408e-02f, 2.14505307e-02f, -1.43028900e-01f, -2.80608505e-01f, 1.84043441e-02f, 2.59174546e-03f, -1.15614526e-01f, -7.90340975e-02f,
  -1.20838210e-01f, -1.25584066e-01f, -2.02893734e-01f, 1.55891836e-01f, -1.38426960e-01f, -2.46562511e-01f, -5.43895289e-02f, -1.70943037e-01f, -3.69891562e-02f, 7.91134983e-02f,
  -5.00868857e-02f, 4.34575751e-02f, 1.71255451e-02f, -4.60342243e-02f, 7.21149296e-02f, 1.41214803e-01f, 3.15694720e-01f, -6.99281096e-02f, 6.28641620e-02f, -1.23739511e-01f,
  2.04541698e-01f, 2.10874230e-01f, 6.89349025e-02f, -4.30564024e-02f, -5.48491739e-02f, -2.61621028e-02f, 2.05505639e-01f, 2.39007935e-01f, 1.55390784e-01f, -1.58337623e-01f,
  -1.04529388e-01f, -1.31491333e-01f, -1.62830651e-01f, -8.02075490e-02f, -3.98884088e-01f, 1.07779182e-01f, 5.54165915e-02f, 2.96060164e-02f, 1.18318699e-01f, 9.93176550e-02f,
  2.97905087e-01f, 3.22035164e-01f, -2.05936022e-02f, 2.07123369e-01f, 2.65782088e-01f, 2.14429170e-01f, -5.51066510e-02f, 5.17631285e-02f, -1.05657704e-01f, -1.11431688e-01f,
  2.23950848e-01f, -1.19028725e-01f, 2.03093722e-01f, 1.10361971e-01f, 1.49757341e-01f, 1.36634370e-03f, -1.18976220e-01f, 1.77220404e-01f, -6.62453249e-02f, 2.24652253e-02f,
  -1.33159235e-01f, 9.22859162e-02f, -7.35627413e-02f, -5.37141748e-02f, -1.78658247e-01f, -1.34469215e-02f, -8.09236169e-02f, 7.26494491e-02f, -7.85225332e-02f, 6.34598956e-02f,
  -4.79705818e-02f, -1.47006914e-01f, -1.33817181e-01f, 1.49920598e-01f, -6.09356649e-02f, 1.54051319e-01f, 5.26418425e-02f, 5.43461964e-02f, 3.01311631e-03f, 2.36142412e-01f,
  1.53744623e-01f, -8.37584361e-02f, -9.02924389e-02f, -1.76267043e-01f, 2.18204662e-01f, 3.29234302e-01f, 3.83783318e-02f, 5.02063110e-02f, -1.43654868e-01f, -2.75336858e-02f,
  -1.57235667e-01f, 1.39610499e-01f, 1.06584594e-01f, -1.38655514e-01f, 2.10606724e-01f, -1.54411094e-02f, 1.48955196e-01f, 4.07585055e-02f, -6.84660766e-03f, 1.03164993e-01f,
  -1.85633063e-01f, -5.77234775e-02f, -2.97493428e-01f, 6.13116771e-02f, 2.26658553e-01f, 5.99752776e-02f, 4.61075753e-01f, 8.39938596e-02f, -2.51324207e-01f, -2.81895012e-01f,
  -1.01615354e-01f, -6.11457601e-02f, 6.37859926e-02f, -1.78183675e-01f, 1.86018392e-01f, 1.64240718e-01f, 1.54372398e-02f, -3.45056206e-02f, -3.92974764e-01f, -1.72857910e-01f,
  2.52325654e-01f, -1.33297164e-02f, -2.85331830e-02f, 7.44981319e-02f, 1.76596627e-01f, 1.93056554e-01f, 1.52417526e-01f, 1.17013983e-01f, -1.70958824e-02f, 7.60115981e-02f,
  1.55195937e-01f, -2.46171951e-02f, 2.32672334e-01f, -5.25336992e-03f, 1.78924836e-02f, 1.21911928e-01f, 1.38105422e-01f, -1.57720536e-01f, 2.12444544e-01f, 3.23448591e-02f,
  2.92183906e-01f, 9.77957547e-02f, -1.43443584e-01f, -1.60568301e-03f, -1.49662495e-01f, -3.01208943e-01f, -2.68762112e-01f, 7.44317248e-02f, 1.94759965e-01f, -2.40551993e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  1.79640338e-01f, -1.56641577e-03f, 1.55167252e-01f, 2.30187308e-02f, -6.72446862e-02f, -3.55718620e-02f, 6.93489462e-02f, -2.68947557e-02f, -4.80908006e-02f, -3.99374105e-02f,
  -1.09034121e-01f, 1.44355252e-01f, 2.10237317e-02f, 1.88703060e-01f, 9.72059369e-02f, 1.93825901e-01f, 7.78322145e-02f, -1.17323197e-01f, 1.31068856e-01f, -6.73834905e-02f,
  -1.55024864e-02f, -4.23069783e-02f, 1.70144185e-01f, 7.23574460e-02f, 3.33684236e-02f, -2.96085104e-02f, -8.86450633e-02f, 2.27968022e-01f, 6.95650093e-03f, 1.33906811e-01f,
  -5.39766401e-02f, 6.86519369e-02f, 1.57682791e-01f, 9.39608887e-02f, 5.33520095e-02f, 1.68017000e-01f, 1.69353575e-01f, 7.40772411e-02f, -3.90058607e-02f, 1.31821418e-02f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -3.57264817e-01f, -4.10078019e-02f, -5.88703416e-02f, -1.13853276e-01f, -7.47689456e-02f, 1.95370451e-01f, 2.60298401e-01f, 2.54268609e-02f, 1.01065703e-01f, -5.34544885e-02f,
  -1.30495066e-02f, 1.66700318e-01f, -1.36441439e-01f, 7.72966743e-02f, 8.90685990e-02f, 3.31240296e-01f, -7.41492063e-02f, -8.09459314e-02f, -9.17926282e-02f, -2.28028327e-01f,
  1.30850151e-01f, 4.61285561e-03f, 2.05693662e-01f, -1.28737822e-01f, -2.25181788e-01f, -1.35387987e-01f, 5.41711003e-02f, -1.83100030e-01f, -1.42010972e-01f, -8.40507299e-02f,
  -2.30017155e-02f, -2.16917731e-02f, 1.59943983e-01f, -1.34630188e-01f, -1.99691225e-02f, -1.93939582e-01f, -2.22390555e-02f, -6.03858456e-02f, -1.20201446e-02f, -1.36380449e-01f,
  1.65992990e-01f, 4.85132113e-02f, -8.52658749e-02f, 2.40075756e-02f, 1.82510510e-01f, -1.34072781e-01f, -7.35527650e-02f, 3.14824618e-02f, 1.77850634e-01f, -2.06055313e-01f,
  -6.37865812e-03f, -1.09967709e-01f, -1.43177271e-01f, 7.72091821e-02f, -1.88332405e-02f, 1.64430022e-01f, 8.40529799e-02f, 2.93292347e-02f, 6.96538687e-02f, 9.78206247e-02f,
  -1.50107548e-01f, 1.34153724e-01f, -4.65655997e-02f, 1.76085103e-02f, -1.34131953e-01f, 1.70470055e-04f, -6.21552207e-02f, 5.15356474e-02f, -2.02026032e-02f, -3.67644127e-03f,
  5.71080446e-02f, -5.91434278e-02f, -6.17623553e-02f, 2.92871464e-02f, 2.89603382e-01f, -1.12999722e-01f, -1.00710221e-01f, -8.74606334e-03f, -1.31084085e-01f, 1.30799100e-01f,
  1.09415792e-01f, 1.52355731e-01f, 6.64427504e-03f, 3.52764279e-01f, 1.49250692e-02f, 1.86605260e-01f, -1.06123224e-01f, 1.80995643e-01f, 1.17948148e-02f, 6.08393252e-02f,
  -5.05630299e-02f, -1.64809838e-01f, -1.48410338e-03f, -2.51193549e-02f, -9.53125656e-02f, 8.97352770e-02f, -1.11470394e-01f, -2.34852716e-01f, -5.40821217e-02f, -2.49356270e-01f,
  -1.60615429e-01f, 1.43717956e-02f, -1.20973520e-01f, -2.05043495e-01f, -1.07322603e-01f, -3.19905430e-02f, -2.59858351e-02f, -9.80886519e-02f, 6.83917478e-03f, 9.40570608e-02f,
  -1.77397192e-01f, 1.07910492e-01f, -7.75444359e-02f, -1.01837208e-02f, -2.49754563e-01f, -1.36161759e-01f, 4.95030396e-02f, -5.07599190e-02f, -4.49037217e-02f, 8.30467343e-02f,
  -6.46598265e-03f, 2.29250593e-03f, -1.32618248e-01f, -1.37907034e-02f, -1.43619701e-01f, 1.64245397e-01f, -1.67908687e-02f, -1.00739494e-01f, 9.65764597e-02f, 7.21881818e-03f,
  -1.34443995e-02f, 1.54176563e-01f, -2.37932168e-02f, -6.04250934e-03f, -2.53035516e-01f, -9.50882807e-02f, -1.02853306e-01f, -3.67280468e-02f, -3.15551758e-02f, -1.16500691e-01f,
  6.66754022e-02f, -2.56018471e-02f, -2.36609243e-02f, -5.11784852e-02f, 6.13555089e-02f, 1.10527486e-01f, 1.03025503e-01f, 2.61768371e-01f, 8.54812264e-02f, 5.74670024e-02f,
  -1.47118688e-01f, 2.83642318e-02f, -5.20803034e-02f, -1.11690857e-01f, 1.41640410e-01f, 1.00632809e-01f, 1.36798754e-01f, -9.46799889e-02f, 2.82965004e-01f, 1.37177542e-01f,
  -8.30501970e-03f, 2.14728132e-01f, 1.48596033e-01f, 1.08350039e-01f, -9.52987745e-03f, -1.04972683e-01f, 3.60493138e-02f, 1.03434049e-01f, 6.21322030e-03f, -1.34349599e-01f,
  -2.66877320e-02f, -1.13989063e-01f, 1.53461769e-01f, 5.12240315e-03f, 1.37046248e-01f, -1.07279912e-01f, 1.64811969e-01f, 5.27109466e-02f, 2.60104656e-01f, 1.85468554e-01f,
  7.12988973e-02f, 5.59169352e-02f, -5.17714433e-02f, -1.60960341e-03f, -6.68490604e-02f, -4.40724790e-02f, 2.42786869e-01f, 6.64894730e-02f, 3.15682411e-01f, -1.32601380e-01f,
  -2.23798513e-01f, 7.31875328e-03f, -9.48622264e-03f, -8.67737904e-02f, -1.11557350e-01f, -2.92859912e-01f, -7.12429881e-02f, -1.37896970e-01f, -1.68808997e-01f, 1.51474932e-02f,
  -1.40548497e-01f, 9.18106064e-02f, -2.87736684e-01f, -5.15301637e-02f, 1.28922373e-01f, 4.42035794e-02f, 4.92389143e-01f, -2.13671178e-01f, -1.62871137e-01f, -1.21448494e-01f,
  -6.87485188e-02f, 8.50897729e-02f, 5.24856441e-04f, 2.12868214e-01f, 1.01190165e-01f, 2.21309915e-01f, -1.10468246e-01f, 2.43568770e-03f, 1.12031505e-01f, -9.51459259e-02f,
  1.15424336e-03f, -8.61272216e-02f, 3.12851332e-02f, -3.58424261e-02f, -2.35625625e-01f, 1.26846125e-02f, 3.91413346e-02f, 1.13250040e-01f, 1.95471942e-01f, 4.36255485e-02f,
  4.42979522e-02f, -1.27627160e-02f, 1.72212958e-01f, -8.06957111e-02f, 2.04332918e-02f, -2.89544966e-02f, 1.14853084e-01f, -2.06240490e-01f, 4.72379215e-02f, -9.98229161e-02f,
  5.85458800e-02f, 7.43689835e-02f, 1.64115623e-01f, 8.76695812e-02f, -1.01497628e-01f, -1.55638129e-01f, -2.33559296e-01f, -1.24340370e-01f, 3.80781107e-02f, 5.23656085e-02f,
  -8.71125311e-02f, 1.38889670e-01f, 1.27728850e-01f, -1.01996645e-01f, -1.58777286e-03f, -7.95312747e-02f, -4.29321937e-02f, 2.12273467e-03f, 1.70255043e-02f, 1.21498359e-02f,
  -1.81389794e-01f, 9.24223065e-02f, 1.53918413e-03f, 7.90045708e-02f, 1.43441688e-02f, -4.57736030e-02f, -1.94167644e-01f, -1.96022436e-01f, -1.36535153e-01f, -2.64375091e-01f,
  -5.84170036e-02f, 2.29664266e-01f, 1.29642840e-02f, 1.48821637e-01f, -9.73790810e-02f, 1.01515323e-01f, 2.29618028e-01f, 7.42925406e-02f, 1.52292758e-01f, -1.68431982e-01f,
  -3.40498537e-02f, 6.44349977e-02f, -5.25266118e-02f, -1.37742326e-01f, 6.82284757e-02f, -1.39282495e-01f, 6.69763684e-02f, -1.27847334e-02f, -3.79006788e-02f, 8.86293203e-02f,
  6.02806872e-03f, 2.25907475e-01f, -6.73596486e-02f, -1.77902520e-01f, -1.09440289e-01f, 1.04298733e-01f, -4.30596620e-02f, 8.51300806e-02f, 1.25411615e-01f, 8.68084654e-02f,
  2.16294333e-01f, 6.02150969e-02f, 2.25189805e-01f, -1.62674651e-01f, 4.94759949e-03f, 1.81770567e-02f, -8.68506730e-02f, -1.47731781e-01f, -1.55907094e-01f, -1.16829813e-01f,
  -1.33259401e-01f, 1.52008785e-02f, 1.24107257e-01f, -3.96188861e-03f, 1.22429460e-01f, 1.36109948e-01f, 2.45644432e-02f, -1.07382819e-01f, 9.64036658e-02f, 2.33288690e-01f,
  -5.45354076e-02f, 1.72882482e-01f, 7.90391192e-02f, -5.74247539e-02f, 3.46251279e-02f, -1.57626450e-01f, 8.90806764e-02f, 1.05763718e-01f, 7.46559538e-03f, -6.02018982e-02f,
  1.19221687e-01f, 8.04159567e-02f, -2.38677382e-01f, -2.27900282e-01f, -2.09048703e-01f, 3.40843678e-01f, -2.55090594e-01f, 1.85058396e-02f, 1.42133221e-01f, -7.33694211e-02f,
  -1.44114792e-01f, 7.05043823e-02f, 1.93769529e-01f, 1.51563892e-02f, 1.46731377e-01f, 3.64077017e-02f, -1.57599524e-02f, 6.02919981e-02f, -2.33934019e-02f, 1.22258887e-01f,
  -1.34794861e-01f, -1.53772771e-01f, 2.04784378e-01f, 8.98530409e-02f, 4.75332439e-02f, -1.07185543e-01f, 1.36930093e-01f, 4.64799963e-02f, -4.28838097e-02f, 1.65923014e-01f,
  -2.43876785e-01f, 6.72220364e-02f, -8.68056640e-02f, -1.60988390e-01f, -1.74487308e-01f, 1.40672654e-01f, -1.67254254e-01f, -5.19897304e-02f, -1.83770875e-03f, -4.35467847e-02f,
  -9.76632088e-02f, -1.20623790e-01f, 2.34034248e-02f, -1.15174659e-01f, 4.05436940e-02f, 2.27605756e-02f, 2.06127260e-02f, 3.90871577e-02f, 1.26727536e-01f, 8.51685181e-02f,
  -6.79232404e-02f, 4.48347665e-02f, 1.31838620e-01f, 9.74996909e-02f, -1.11665679e-02f, -2.19447479e-01f, -1.03967607e-01f, -9.77342576e-02f, -3.16466466e-02f, 2.05637980e-02f,
  -6.69524819e-02f, -1.39564782e-01f, -1.96452677e-01f, -9.23325643e-02f, -1.65549591e-01f, -3.89461927e-02f, 2.39551604e-01f, 2.80052304e-01f, 3.68237436e-01f, -1.49423867e-01f,
  -1.10926412e-01f, -2.28570312e-01f, -7.63662383e-02f, -3.89383227e-01f, -1.16056658e-01f, -1.27451167e-01f, -1.94285959e-02f, 2.59258691e-02f, -2.22623855e-01f, 4.49196734e-02f,
  2.96970792e-02f, -1.69673517e-01f, -2.98018217e-01f, 8.79113674e-02f, 1.15045853e-01f, 8.05781037e-03f, 1.77591164e-02f, -1.65450737e-01f, -1.90898269e-01f, -9.31012705e-02f,
  -1.32479519e-01f, 4.94293310e-02f, -1.35689959e-01f, -1.55064955e-01f, 1.71284676e-01f, -1.53387114e-01f, 8.64380822e-02f, 1.53396055e-01f, 2.74639875e-01f, -2.64266431e-01f,
  -8.93658996e-02f, 3.51802185e-02f, -4.20320779e-02f, 8.98107439e-02f, 2.12789357e-01f, 3.77302505e-02f, -1.04311116e-01f, 9.62123647e-02f, -1.78315118e-01f, 9.97985005e-02f,
  5.97016662e-02f, 4.10510600e-02f, 9.85441357e-03f, -1.79168619e-02f, -1.70761049e-01f, 3.46503081e-03f, 5.98271452e-02f, 5.12258559e-02f, 2.40976680e-02f, -9.10285786e-02f,
  -8.14262331e-02f, -3.80066186e-02f, 3.83039042e-02f, -6.86563551e-02f, 1.13924071e-01f, 1.92832306e-01f, 5.84258214e-02f, 5.94797395e-02f, -5.40620126e-02f, 2.86524333e-02f,
  -8.86897668e-02f, 6.10540845e-02f, 3.77112511e-03f, -6.09549396e-02f, 4.79672551e-02f, 8.08882490e-02f, -1.61036819e-01f, 1.12262689e-01f, 6.33272305e-02f, 3.27065736e-02f,
  -2.29334105e-02f, 2.54508760e-02f, -2.30135471e-02f, -1.59417894e-02f, -3.67302150e-02f, -9.90061983e-02f, -1.71196729e-01f, 3.25801037e-03f, -2.53324240e-01f, -8.46620277e-02f,
  -6.84406534e-02f, -2.15854630e-01f, -1.12816297e-01f, 2.73960661e-02f, 2.96743307e-02f, 3.97513136e-02f, -1.26672104e-01f, 2.70277233e-04f, 3.59717041e-01f, -5.03331497e-02f,
  -3.38748336e-01f, -1.92003340e-01f, 3.55288982e-01f, 8.08633491e-02f, -1.25238979e-02f, -3.57846655e-02f, 7.45061459e-03f, -5.70563190e-02f, -2.64386721e-02f, -8.80029518e-03f,
  -9.04127210e-03f, 1.20976031e-01f, 3.05575579e-02f, -7.14702383e-02f, 2.08768994e-01f, -1.67327777e-01f, -1.76966667e-01f, -2.91163176e-02f, -6.07409440e-02f, -4.96984087e-02f,
  2.85064126e-03f, 2.22530973e-04f, -6.74240217e-02f, -1.12406231e-01f, -4.92475368e-03f, -1.04478352e-01f, 2.86459532e-02f, -6.56069741e-02f, 1.92770302e-01f, 4.01240624e-02f,
  1.98290870e-02f, 7.37485737e-02f, -1.58865005e-01f, -6.16778247e-02f, -2.16767758e-01f, 1.36199847e-01f, -1.66953318e-02f, -2.90210485e-01f, -8.42157751e-03f, -2.80648135e-02f,
  8.45381021e-02f, 1.44674703e-01f, -4.57269810e-02f, -6.02709576e-02f, 2.14327276e-01f, 8.36103857e-02f, 3.49699631e-02f, -1.75674167e-02f, 1.28808349e-01f, -4.05811332e-02f,
  -8.82434323e-02f, 9.85113531e-02f, -1.69678465e-01f, -1.46711275e-01f, 1.19246148e-01f, -1.67880297e-01f, 7.24939629e-02f, 1.03460446e-01f, 8.57525170e-02f, -2.96705659e-03f,
  5.33580706e-02f, -6.18704930e-02f, 1.84928536e-01f, -3.49765979e-02f, -5.39121255e-02f, -1.73363551e-01f, 1.43709257e-01f, 1.16302231e-02f, 2.12522119e-01f, -1.93836987e-01f,
  4.97152880e-02f, 7.73954466e-02f, 4.01332229e-02f, 1.13579772e-01f, 1.13461368e-01f, -1.52534649e-01f, -1.60716742e-01f, -5.98066486e-02f, 1.38267264e-01f, -1.13805600e-01f,
  -1.85029805e-01f, 4.36743675e-03f, 4.42239568e-02f, 9.59892944e-02f, 1.70417100e-01f, -7.72530884e-02f, 5.40610701e-02f, 1.71673566e-01f, -7.81713724e-02f, -7.50503018e-02f,
  -1.99706051e-02f, 1.41083449e-01f, 4.52746712e-02f, -2.70638764e-02f, 2.24485889e-01f, 1.54920354e-01f, 1.02330983e-01f, -8.86096880e-02f, -8.79459232e-02f, 4.49831299e-02f,
  1.27176329e-01f, -1.86519384e-01f, 4.11216281e-02f, -2.31345952e-01f, 6.18527569e-02f, -3.11100651e-02f, -2.10918725e-01f, 3.28686088e-02f, -7.23453052e-03f, -1.16199829e-01f,
  -1.36057720e-01f, 7.47936079e-03f, -1.17240667e-01f, -1.34069040e-01f, -2.26527661e-01f, 1.70591086e-01f, -1.88020602e-01f, -9.04440433e-02f, -2.39297092e-01f, -2.13126019e-01f,
  -7.26014823e-02f, -1.06608637e-01f, 2.54791081e-02f, 4.24802862e-02f, -1.79414332e-01f, -8.32611602e-03f, 1.19032986e-01f, 1.45269688e-02f, 2.95785554e-02f, -4.72650863e-02f,
  -2.18577534e-01f, -6.63338602e-02f, 9.48563498e-03f, 9.42252800e-02f, -1.64847180e-01f, -6.66939467e-02f, 2.13278040e-01f, 4.05828729e-02f, 2.57985517e-02f, 3.08780675e-03f,
  7.69225210e-02f, 9.13979206e-03f, -9.44322720e-02f, 7.41677806e-02f, 1.76728591e-02f, -2.08704665e-01f, -1.76459491e-01f, 2.00167120e-01f, -1.12095736e-01f, -2.01885909e-01f,
  -6.28091171e-02f, -2.58474439e-01f, -2.10499261e-02f, -1.20597698e-01f, -1.25076860e-01f, -1.02457248e-01f, -1.63509354e-01f, 1.43367633e-01f, 6.24761321e-02f, 2.14915469e-01f,
  -1.64359242e-01f, -7.61147887e-02f, 4.41225827e-01f, 3.19221914e-02f, 3.44462961e-01f, -2.35926732e-01f, 1.00047797e-01f, 2.31448561e-02f, -2.66438480e-02f, -2.20437676e-01f,
  3.63024287e-02f, 9.85180028e-03f, -1.19811567e-02f, 1.57914162e-01f, -7.14436546e-02f, -1.52027413e-01f, 2.45127063e-02f, -8.46380070e-02f, 1.66952480e-02f, 1.27860770e-01f,
  9.69468206e-02f, 8.63209888e-02f, -1.10113777e-01f, -6.87848106e-02f, -6.48397803e-02f, -9.01592523e-02f, -1.07667148e-01f, -3.84439453e-02f, 1.70781150e-01f, -7.70533681e-02f,
  1.11752421e-01f, -2.09765419e-01f, 1.70040488e-01f, 1.81244463e-02f, 3.99929434e-02f, -2.12146387e-01f, -4.42501791e-02f, 1.29303252e-02f, 2.59519853e-02f, 5.61762303e-02f,
  2.32878357e-01f, 1.32102549e-01f, 7.07513168e-02f, 1.49076939e-01f, -1.34424761e-01f, -5.77365272e-02f, -2.07838366e-05f, 8.48779455e-02f, 1.07853346e-01f, 2.21270412e-01f,
  -1.30993605e-01f, 7.26486221e-02f, -1.35944173e-01f, -3.39662768e-02f, -9.21767503e-02f, -1.07674142e-02f, -1.77593268e-02f, -3.44870612e-02f, 1.37201339e-01f, -1.09255277e-01f,
  1.16605036e-01f, -5.88777754e-03f, 6.98392615e-02f, 1.01952329e-02f, -6.55346885e-02f, 1.56874582e-01f, -1.71565190e-01f, 9.27950069e-02f, 2.17476472e-01f, -2.58979112e-01f,
  -3.03106248e-01f, 1.68992817e-01f, -1.90741658e-01f, 7.49676898e-02f, -6.92238286e-02f, -3.47764045e-02f, -1.04513153e-01f, -5.25714122e-02f, -1.25696197e-01f, 6.00102991e-02f,
  2.86709219e-02f, -2.04883307e-01f, -1.20755449e-01f, 7.74953216e-02f, -1.24679014e-01f, 1.16615206e-01f, -2.57204585e-02f, -1.09671459e-01f, 3.97526696e-02f, 3.14532407e-02f,
  1.97271034e-01f, -1.57239914e-01f, -1.98128223e-01f, -3.22639309e-02f, 4.42835357e-04f, -1.28180608e-01f, -9.35540125e-02f, -8.58407691e-02f, -1.30383216e-03f, 2.03632079e-02f,
  1.33959651e-01f, 1.10674709e-01f, 8.99684206e-02f, 3.63881402e-02f, 3.08511943e-01f, -1.00368954e-01f, 7.35263973e-02f, 5.66214882e-03f, -1.05859749e-01f, 8.48603398e-02f,
  5.55095747e-02f, -7.96293989e-02f, 3.25857801e-03f, 6.85931742e-02f, 1.13163695e-01f, 1.05090059e-01f, 2.49054879e-02f, 1.08880669e-01f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -9.10792947e-02f, 3.66371088e-02f, 1.68180123e-01f, 4.87225922e-03f, -1.01143122e-01f, -4.68231849e-02f, 1.04479432e-01f, 5.09916060e-02f, 1.34917304e-01f, 1.02133803e-01f,
  1.15650892e-02f, 1.67050645e-01f, -1.63387358e-01f, 4.02664691e-01f, 3.54215294e-01f, -3.67907286e-01f, -2.08133429e-01f, -1.64059997e-01f, -2.88601723e-02f, -1.40786409e-01f,
  4.98083271e-02f, -1.86515674e-01f, 1.50723904e-01f, -4.33880463e-02f, 1.73742533e-01f, 2.37290729e-02f, 2.22236440e-01f, -8.50147754e-02f, 1.19012572e-01f, 1.46686450e-01f,
  -1.80440158e-01f, -2.48053316e-02f, 2.26909831e-01f, 2.08500996e-02f, -4.62394468e-02f, -9.73908678e-02f, -7.46332482e-02f, 2.65672773e-01f, -2.92760637e-02f, -1.31832197e-01f,
  3.65564078e-01f, -2.91469302e-02f, -3.85002553e-01f, -4.60435525e-02f, 6.92800805e-02f, -8.70976076e-02f, 5.41514670e-03f, -3.92652005e-01f, 1.62465140e-01f, 3.15542184e-02f,
  -7.99311101e-02f, 6.04014425e-03f, 1.57728046e-01f, 5.22171669e-02f, -1.18868463e-01f, -3.56340736e-01f, 9.86979604e-02f, -1.85640946e-01f, 2.34520901e-02f, 2.16392830e-01f,
  -1.55107751e-01f, 2.36686334e-01f, 1.73362419e-01f, 1.46375358e-01f, -2.06560059e-03f, 7.48097152e-02f, 8.11620429e-02f, -5.93085191e-04f, 1.57493316e-02f, 4.25616316e-02f,
  -6.79799095e-02f, 1.22226588e-01f, -5.04629575e-02f, 3.13102230e-02f, -2.55357865e-02f, 2.03992710e-01f, 1.18502654e-01f, 1.18032768e-01f, 1.77376509e-01f, 7.62211010e-02f,
  -9.76557061e-02f, -1.16527200e-01f, -2.98729129e-02f, 6.55287877e-02f, -2.06323266e-01f, 2.75432050e-01f, 2.88362149e-02f, 1.22925855e-01f, 2.08551973e-01f, 8.62766504e-02f,
  1.38913244e-01f, 9.07111764e-02f, -1.04035046e-02f, 1.11411192e-01f, -1.98762521e-01f, -9.15572345e-02f, 4.84075025e-02f, -1.98646247e-01f, 1.76717281e-01f, 2.07703739e-01f,
  5.76017871e-02f, 1.36472806e-01f, 9.49525833e-02f, 4.48904596e-02f, 6.41870871e-02f, -6.19008169e-02f, -3.34965497e-01f, -2.88536936e-01f, 6.88990429e-02f, 4.33268361e-02f,
  6.95521981e-02f, -1.33665547e-01f, -1.61834896e-01f, 1.68590415e-02f, 2.92077839e-01f, 1.32436559e-01f, 9.13968775e-03f, -3.22553217e-02f, -1.30842760e-01f, -2.33106777e-01f,
  1.25405669e-01f, -3.78949195e-01f, -2.31890604e-01f, 1.00624733e-01f, 8.14180635e-03f, 1.69553518e-01f, 1.40483320e-01f, -1.73792049e-01f, -5.82312196e-02f, -2.14600433e-02f,
  2.79779248e-02f, -1.25073984e-01f, -1.34471759e-01f, 8.97997022e-02f, -3.12772729e-02f, 1.17245249e-01f, 2.98070963e-02f, -9.65057760e-02f, -2.29781434e-01f, -2.35209092e-01f,
  4.63303700e-02f, 2.05259938e-02f, 5.33279851e-02f, 1.38280928e-01f, 7.86226168e-02f, -8.44178423e-02f, -3.01284581e-01f, -2.48472691e-01f, -1.02106273e-01f, -1.51749253e-01f,
  1.40762404e-01f, -1.54258147e-01f, -6.09533675e-02f, -6.26003894e-04f, 1.56947926e-01f, -2.37901658e-02f, -1.06197543e-01f, -2.51649886e-01f, 2.05296084e-01f, 2.69135118e-01f,
  -1.34758949e-01f, 2.15172768e-01f, -8.41706544e-02f, 2.88922489e-01f, 8.13558996e-02f, -2.84046471e-01f, -2.90899090e-02f, 1.41835123e-01f, -4.11158465e-02f, 2.27589041e-01f,
  1.45346135e-01f, 1.66199148e-01f, 1.55225620e-01f, -1.94958914e-02f, 2.46176451e-01f, 1.27971858e-01f, -1.13215791e-02f, 6.29913285e-02f, 2.29456931e-01f, -1.75288364e-01f,
  -1.26023859e-01f, -1.28325626e-01f, 2.15917274e-01f, 5.05679250e-02f, 1.06490687e-01f, 1.37319356e-01f, 1.55305162e-01f, 2.97826882e-02f, 1.16665527e-01f, -1.02694064e-01f,
  -6.93740919e-02f, 9.93397012e-02f, 1.78453952e-01f, -8.48943144e-02f, 2.43707523e-01f, -1.06625840e-01f, 1.02850720e-01f, 1.03618549e-02f, 3.03711921e-01f, 3.38264465e-01f,
  1.93990022e-01f, 2.45755002e-01f, 2.48657688e-01f, 1.69046149e-01f, 1.67694762e-01f, -5.08852024e-03f, -1.01983108e-01f, 1.34623304e-01f, 2.97304302e-01f, 1.69551373e-01f,
  5.71390018e-02f, 2.58947313e-01f, 2.71863520e-01f, 2.25753561e-02f, -1.54732153e-01f, -1.23582043e-01f, 9.51460302e-02f, -1.42971337e-01f, 1.64826587e-01f, 6.29201755e-02f,
  3.17420483e-01f, -3.37743491e-01f, 3.22476268e-01f, -2.41983801e-01f, -2.11392418e-01f, -6.54906780e-02f, -1.44599766e-01f, 6.60807192e-02f, 1.30677566e-01f, 1.86903119e-01f,
  1.80339351e-01f, 1.27091721e-01f, -8.77178460e-02f, 3.46140154e-02f, -6.55322671e-02f, -1.24293737e-01f, 3.03605705e-01f, -2.08683815e-02f, 1.91913247e-01f, -1.14328921e-01f,
  1.62827224e-01f, -1.73520148e-02f, -2.12033987e-02f, 2.71643698e-01f, 3.44491489e-02f, 1.76666096e-01f, -9.53050628e-02f, 3.39010265e-03f, -8.52325652e-03f, 4.33241241e-02f,
  -3.59803513e-02f, 8.13584849e-02f, 2.91424066e-01f, -2.59395421e-01f, -1.02558881e-01f, -3.00411023e-02f, 5.49607305e-03f, 1.58437401e-01f, 1.23146564e-01f, 2.39981592e-01f,
  5.42660942e-03f, -1.19683251e-01f, 2.41309986e-01f, -9.44118351e-02f, 2.00205075e-04f, 8.52212608e-02f, 9.36977044e-02f, -1.20709620e-01f, -4.08170000e-02f, -1.54775843e-01f,
  -4.20694500e-02f, 1.34600386e-01f, -2.89745927e-01f, 3.56468409e-01f, -1.39390439e-01f, 3.74624878e-01f, 1.35673285e-01f, 8.48739445e-02f, 3.13743055e-01f, -2.64046967e-01f,
  -2.99605608e-01f, 2.70568486e-02f, -1.68371230e-01f, -5.53836487e-02f, -2.03294188e-01f, 9.66105983e-02f, 4.40981537e-02f, -2.65803605e-01f, -4.05371606e-01f, -1.71215460e-01f,
  -3.63911450e-01f, 4.37549204e-02f, 8.56158361e-02f, -7.81754702e-02f, -1.49876058e-01f, 1.14020556e-02f, -2.80921869e-02f, -1.85942277e-01f, -4.91619483e-02f, -4.25290167e-02f,
  5.29877394e-02f, -1.02267273e-01f, -7.65166571e-03f, 1.69453159e-01f, 2.76720338e-02f, -1.29018858e-01f, 1.92221552e-01f, 1.56440616e-01f, -1.97223127e-01f, 1.65030390e-01f,
  -5.16212471e-02f, 9.97814015e-02f, -9.24595073e-02f, 1.51219025e-01f, -8.90574828e-02f, 1.96630135e-03f, 3.05392325e-01f, -5.11388779e-02f, -8.27149302e-02f, -2.31016219e-01f,
  6.98943660e-02f, 1.44956857e-02f, 6.16483800e-02f, 3.31432633e-02f, 9.22206510e-03f, -1.81170657e-01f, -7.30537344e-03f, -2.66380757e-01f, -1.35053977e-01f, -2.18034405e-02f,
  1.79198638e-01f, 2.05316782e-01f, -6.11569062e-02f, -1.91183686e-01f, -1.95698455e-01f, -3.10149486e-03f, -1.63102765e-02f, 1.05314314e-01f, 3.02224129e-01f, -5.20173237e-02f,
  -2.05665484e-01f, 2.22136229e-02f, -2.52312332e-01f, 3.18510503e-01f, 8.73363689e-02f, -1.17005415e-01f, 4.10285927e-02f, 2.32313603e-01f, 1.21243060e-01f, 6.34042621e-02f,
  5.71112223e-02f, 2.93591827e-01f, 6.51586875e-02f, 1.56000465e-01f, 2.13612989e-01f, -3.60368460e-01f, -3.29604372e-02f, 1.69423401e-01f, 1.11866273e-01f, 2.17432231e-01f,
  -4.30940151e-01f, -6.18319586e-02f, 2.59752497e-02f, -1.16891257e-01f, -4.41260785e-01f, 2.42804959e-01f, -2.84625113e-01f, -1.00206524e-01f, 4.01688851e-02f, 4.42924947e-01f,
  -1.19857602e-01f, -9.40356869e-03f, 2.60699123e-01f, -1.10319741e-01f, -3.54037294e-03f, -3.11795235e-01f, -5.23949638e-02f, -2.03648806e-01f, 1.19753323e-01f, -9.45314579e-03f,
  -9.39260051e-02f, -8.64964817e-03f, 1.90667093e-01f, 1.26233682e-01f, 1.11148909e-01f, 3.16116571e-01f, 2.71202058e-01f, 2.42831990e-01f, 6.78726360e-02f, 2.58250758e-02f,
  4.46288958e-02f, -1.71945281e-02f, -4.34834957e-02f, 9.11890045e-02f, -2.47447461e-01f, 1.11097127e-01f, -3.00899833e-01f, -2.09707841e-01f, -7.61588812e-02f, -1.64665841e-02f,
  -1.09255634e-01f, 2.31275380e-01f, 3.30920964e-01f, -1.05513193e-01f, 2.06908360e-01f, 4.31871042e-02f, 9.14522260e-03f, 1.05247132e-01f, 2.53973991e-01f, -2.56516606e-01f,
  1.54966399e-01f, 1.84802949e-01f, 1.18929833e-01f, -5.64005002e-02f, -5.97893149e-02f, -5.40456846e-02f, 8.98622200e-02f, 9.07768160e-02f, 1.56369090e-01f, 2.11678207e-01f,
  3.50790215e-03f, 6.22828677e-02f, 2.52640098e-01f, 7.36310408e-02f, 1.04393624e-01f, 1.52636930e-01f, 4.27905694e-02f, 6.91618249e-02f, -3.08253113e-02f, 1.91111445e-01f,
  1.49319559e-01f, -1.55122489e-01f, 1.08724028e-01f, 1.03904113e-01f, -8.47109556e-02f, 1.53961971e-01f, -4.62060720e-02f, -1.52319029e-01f, -7.91770220e-02f, -2.84481615e-01f,
  1.91249289e-02f, -1.11506104e-01f, 2.29267046e-01f, 1.09803282e-01f, 2.99044728e-01f, -2.07658917e-01f, 1.61730479e-02f, 5.85974706e-03f, -2.81342000e-01f, -1.05027884e-01f,
  -2.99738586e-01f, 6.14893399e-02f, -3.59393284e-02f, 2.97398046e-02f, 4.10641506e-02f, 1.58165976e-01f, -1.75414637e-01f, -2.56046981e-01f, -6.18583448e-02f, -1.15938850e-01f,
  -8.50555599e-02f, 1.51428998e-01f, 2.55270183e-01f, 1.75647244e-01f, -3.89585942e-02f, 8.55456740e-02f, -1.36656135e-01f, -3.63437571e-02f, 1.92345679e-01f, 1.06466785e-02f,
  -5.55986539e-02f, 1.99189350e-01f, -6.83393190e-03f, -1.31020665e-01f, -1.84837785e-02f, -9.28532258e-02f, 1.29045611e-02f, 3.37714329e-02f, 1.95537582e-01f, 3.22343200e-01f,
  -3.46390754e-02f, 2.81748325e-01f, 2.22050473e-01f, -1.27730325e-01f, 6.33993074e-02f, -2.50505865e-01f, -2.80374624e-02f, 1.32836357e-01f, 9.15461332e-02f, 1.75859392e-01f,
  -3.29864249e-02f, 1.46575645e-01f, 1.58143327e-01f, 8.90697911e-02f, -9.28574279e-02f, -8.99498686e-02f, -1.67733103e-01f, 2.24807918e-01f, -1.21857494e-01f, -2.16385171e-01f,
  1.53294262e-02f, -6.84299245e-02f, 1.68121204e-01f, -9.25178900e-02f, 1.22663163e-01f, 1.02268137e-01f, 4.29058857e-02f, -1.45263225e-01f, -7.56484270e-02f, 8.17894861e-02f,
  1.53800458e-01f, 2.03292012e-01f, -7.32483268e-02f, 3.28027606e-01f, 2.96649039e-01f, -3.96319889e-02f, 1.12060830e-01f, 7.32322484e-02f, 2.72581547e-01f, 2.45897830e-01f,
  5.48243150e-02f, 6.87901750e-02f, -1.72529027e-01f, 1.09840818e-01f, 1.65729836e-01f, -2.37823963e-01f, -2.25792363e-01f, 1.20277353e-01f, -1.61143318e-01f, -3.56529318e-02f,
  3.34632427e-01f, -3.16673845e-01f, 1.14539489e-01f, -1.55040205e-01f, 6.24367185e-02f, -1.18730314e-01f, 5.87791577e-02f, -3.20662946e-01f, 1.92868814e-01f, 1.28537327e-01f,
  -6.17661746e-03f, -1.27152711e-01f, 1.18183210e-01f, -1.56827584e-01f, 2.59725958e-01f, 2.46101677e-01f, 3.62703614e-02f, -8.66558030e-02f, 1.58546418e-02f, 2.01369494e-01f,
  8.45380574e-02f, 2.05659017e-01f, 2.95008630e-01f, -9.74340066e-02f, 1.06920980e-01f, 7.04368055e-02f, 1.51319966e-01f, -3.41527276e-02f, 1.25913501e-01f, -2.72508830e-01f,
  6.43329024e-02f, 1.24071222e-02f, -2.30002284e-01f, 2.30876375e-02f, 3.99781354e-02f, 8.09420273e-02f, -6.83912337e-02f, -5.69372140e-02f, 5.77846542e-02f, 1.37903735e-01f,
  2.82421820e-02f, 1.07483871e-01f, -1.07502164e-02f, 6.12702146e-02f, -1.42050549e-01f, 1.51707023e-01f, 2.25356504e-01f, 2.97312915e-01f, 3.06488186e-01f, 1.49560481e-01f,
  2.39858553e-01f, 2.40842432e-01f, 1.07393168e-01f, -1.19849648e-02f, 1.18715437e-02f, 6.25819415e-02f, 1.69209346e-01f, 3.01660709e-02f, 2.83339143e-01f, 9.84190684e-03f,
  1.83829337e-01f, 1.05799019e-01f, 1.53233916e-01f, -1.09988777e-02f, 1.78272486e-01f, 8.82076658e-03f, -2.30295390e-01f, -1.29633307e-01f, -3.33024830e-01f, -3.96033406e-01f,
  -1.26797542e-01f, 2.44215921e-01f, -2.49051750e-01f, 7.93770999e-02f, -4.52643581e-05f, 2.91712850e-01f, 3.43533456e-02f, -1.85524061e-01f, -2.38720328e-01f, 1.75506044e-02f,
  -2.93271333e-01f, -1.36351496e-01f, -1.11501068e-01f, 2.16132458e-02f, 1.54930368e-01f, 1.90851450e-01f, -2.07625180e-01f, 2.91687027e-02f, 1.52091116e-01f, 1.77741900e-01f,
  -2.18517065e-01f, -7.72799850e-02f, -1.02455445e-01f, 2.81749904e-01f, -1.25809848e-01f, -2.64313757e-01f, -2.74529487e-01f, 7.94634670e-02f, 2.30894480e-02f, 2.22287774e-01f,
  5.16347326e-02f, 2.34337881e-01f, -9.16387215e-02f, 4.25492913e-01f, 2.47798517e-01f, -1.40549198e-01f, -1.60040557e-01f, -3.41259912e-02f, -1.73658431e-02f, 4.78351973e-02f,
  2.64630024e-03f, 6.65146625e-03f, 7.29989111e-02f, 1.06733330e-01f, 6.71817660e-02f, 1.27673864e-01f, 1.46367356e-01f, 2.08958507e-01f, 8.05686787e-02f, 3.67067069e-01f,
  5.76964915e-02f, 3.07727396e-01f, 1.18669234e-02f, 2.11879790e-01f, 1.88406318e-01f, -7.45309591e-02f, 2.44583771e-01f, -2.74046600e-01f, -8.77005327e-03f, 2.20062062e-01f,
  -1.89880371e-01f, 2.43287366e-02f, -1.30378470e-01f, 1.64041460e-01f, 1.62681639e-01f, 1.41663641e-01f, 2.50719897e-02f, 1.17551289e-01f, 2.07540914e-01f, 9.24434885e-02f,
  1.30373329e-01f, -2.05585048e-01f, 3.82932760e-02f, -1.82165980e-01f, -8.34283307e-02f, -2.08497364e-02f, -5.06196357e-02f, 3.54071975e-01f, 2.59303749e-01f, -2.80977115e-02f,
  1.04469903e-01f, -1.40802190e-01f, -7.99302086e-02f, -1.53446272e-01f, 1.65734723e-01f, -1.10323243e-01f, 9.06489119e-02f, -1.60494879e-01f, 1.69198498e-01f, 4.52134311e-02f,
  -6.26657605e-02f, 2.36864746e-01f, 1.85564354e-01f, 2.42709622e-01f, 9.33846924e-03f, -1.58621475e-01f, 1.09924771e-01f, 9.65152830e-02f, -1.75038829e-01f, 1.06777854e-01f,
  1.27983272e-01f, 1.55555397e-01f, 8.31003115e-02f, -3.06052744e-01f, 1.02817759e-01f, -9.29477215e-02f, 1.60157997e-02f, -3.09702694e-01f, -1.65429294e-01f, 7.49567598e-02f,
  2.61183977e-01f, 2.60436013e-02f, -1.56394482e-01f, -2.38935173e-01f, -2.04109773e-01f, -1.47249475e-01f, -6.51850328e-02f, 1.00219376e-01f, 1.80820435e-01f, -1.20976269e-01f,
  -2.12835968e-01f, -1.75027817e-01f, 7.83577636e-02f, -3.53301615e-01f, 1.59638330e-01f, -1.62147403e-01f, 2.97426302e-02f, -7.53678754e-02f, -1.46736383e-01f, -2.10434422e-01f,
  1.36624634e-01f, -1.23926319e-01f, -5.19253239e-02f, -2.30468810e-01f, -1.85426548e-02f, 3.70203853e-02f, 2.35229023e-02f, 1.62962735e-01f, 1.54484082e-02f, 3.13162237e-01f,
  5.39190881e-02f, -2.19916344e-01f, -4.03498597e-02f, 1.82778835e-01f, -1.29268449e-02f, 1.74965948e-01f, 1.76195666e-01f, 2.75812596e-01f, -1.23254597e-01f, 9.16305780e-02f,
  3.14949870e-01f, 1.37564480e-01f, 1.32065445e-01f, 1.17459454e-01f, 5.83760766e-03f, -2.75106162e-01f, 7.74706677e-02f, -2.43942514e-01f, 6.51938245e-02f, 1.55793250e-01f,
  7.61376321e-02f, 7.08958805e-02f, 1.04831256e-01f, -4.76841629e-02f, -1.81894097e-02f, -1.02522280e-02f, 1.07803777e-01f, 8.35405588e-02f, -7.39484131e-02f, -1.15527697e-01f,
  1.55876219e-01f, -1.40126362e-01f, 1.68312088e-01f, 1.53669208e-01f, 1.11594848e-01f, 2.62543291e-01f, 2.18560755e-01f, 1.24079019e-01f, 1.93952560e-01f, 4.80870754e-02f,
  3.04331690e-01f, 3.82136524e-01f, 3.13347787e-01f, 9.75205675e-02f, 3.67565840e-01f, -2.30915055e-01f, -3.38180400e-02f, -3.64503652e-01f, -5.36975488e-02f, -2.45973244e-01f,
  -1.87053218e-01f, -1.87155548e-02f, -2.20270559e-01f, -1.28213763e-01f, 1.42180488e-01f, -5.19258268e-02f, 1.39757738e-01f, -2.73579687e-01f, 1.88814864e-01f, -1.43875539e-01f,
  2.57575512e-02f, -1.00647464e-01f, -2.33429268e-01f, -1.71580851e-01f, 5.42702936e-02f, 1.03404887e-01f, 4.08017412e-02f, 1.56797320e-01f, 1.14710040e-01f, -5.14602959e-02f,
  2.14541033e-01f, 1.28671125e-01f, 1.79110855e-01f, -2.17813507e-01f, 1.26638666e-01f, 7.37882629e-02f, 9.32852104e-02f, -3.14592391e-01f, -4.76874858e-02f, 1.82254955e-01f,
  -4.83297333e-02f, 3.13640475e-01f, -5.10412566e-02f, 2.18675986e-01f, -6.89421454e-03f, 1.28738537e-01f, 1.52524590e-01f, 7.92162344e-02f, 6.24259636e-02f, -6.80787191e-02f,
  -3.78321745e-02f, 1.64567709e-01f, 3.02055508e-01f, 3.69758993e-01f, 4.50902671e-01f, 2.27877907e-02f, 6.57384619e-02f, 1.90286383e-01f, 1.81132272e-01f, 4.69301157e-02f,
  8.52112379e-03f, 2.38602441e-02f, 1.16646647e-01f, -1.51596749e-02f, -1.88941061e-01f, -3.12542409e-01f, -1.00994073e-01f, -7.40106106e-02f, -2.61626448e-02f, 3.49478334e-01f,
  2.11919188e-01f, 2.63577789e-01f, 1.23566404e-01f, -1.46382898e-02f, 8.44595656e-02f, -3.60040933e-01f, 7.97158554e-02f, 1.27505586e-01f, -3.42217892e-01f, 1.62518352e-01f,
  1.59599364e-01f, 8.26424137e-02f, 1.55255795e-01f, -3.31017643e-01f, -2.82324329e-02f, 1.09366506e-01f, -1.89709231e-01f, 1.54242041e-02f, 1.30254656e-01f, -4.62386459e-02f,
  1.42632231e-01f, 1.32299736e-01f, -2.90196668e-02f, 1.00592181e-01f, -3.71761881e-02f, 3.30019221e-02f, -4.73497659e-01f, 7.05268607e-02f, -8.50956794e-03f, 1.99127510e-01f,
  -1.91941932e-01f, -2.86629200e-01f, 6.49310788e-03f, 8.99695083e-02f, -2.51165658e-01f, -1.59192041e-01f, -1.51536968e-02f, 1.68764830e-01f, 3.56578082e-02f, 2.70898581e-01f,
  1.72858357e-01f, -2.80473143e-01f, 2.47864693e-01f, -1.34955332e-01f, -3.52811106e-02f, -7.50239342e-02f, -7.91186765e-02f, 7.91732743e-02f, -1.15863137e-01f, -8.50908011e-02f,
  -4.66669351e-02f, -7.09063858e-02f, -4.02321443e-02f, 7.29126334e-02f, -2.27184296e-02f, -1.74447313e-01f, -1.09760180e-01f, -3.21407139e-01f, 1.94454521e-01f, 1.35793045e-01f,
  4.33629692e-01f, 8.06107279e-03f, -2.60148823e-01f, -9.63100120e-02f, -3.00900549e-01f, -1.93452761e-01f, 8.07392225e-02f, -9.26268753e-04f, 9.24419612e-02f, -2.22820286e-02f,
  4.52066250e-02f, 6.61940947e-02f, 1.26045153e-01f, -9.19616669e-02f, -5.51119866e-03f, -6.62166998e-03f, 2.15044320e-01f, 3.04044962e-01f, 3.29132527e-02f, 1.16522573e-01f,
  -1.23514593e-01f, -5.20435721e-02f, -5.60095049e-02f, -2.78057128e-01f, -1.13631152e-01f, 7.25255683e-02f, 9.32821631e-02f, 1.29915789e-01f, -8.22648033e-03f, 2.36169353e-01f,
  -2.43525226e-02f, -7.76473507e-02f, 1.72453076e-01f, 1.64237723e-01f, 7.29709044e-02f, 2.71210045e-01f, 1.27009839e-01f, -1.60273820e-01f, 1.12170905e-01f, 5.01053110e-02f,
  2.50595231e-02f, 1.11645244e-01f, 9.11519974e-02f, -9.89055187e-02f, 1.23964027e-01f, -3.81733105e-02f, 1.27115265e-01f, 1.04213871e-01f, 1.45274743e-01f, 2.58296132e-01f,
  3.07160374e-02f, -2.02065378e-01f, -7.93605745e-02f, 1.99669302e-01f, 1.99362010e-01f, 5.76978251e-02f, 7.73088187e-02f, -1.13876425e-01f, -1.18788876e-01f, 1.17758915e-01f,
  2.11391851e-01f, 7.81308562e-02f, 6.35300428e-02f, 2.81924158e-01f, 2.36134946e-01f, -1.98498324e-01f, 1.08674161e-01f, -1.15732849e-01f, -1.00952536e-01f, 2.00156465e-01f,
  -1.28611505e-01f, -5.54676130e-02f, -1.47859722e-01f, -1.46331251e-01f, -7.91775156e-03f, 1.77878559e-01f, -9.78715811e-03f, -9.62618664e-02f, -2.38337800e-01f, 9.09664184e-02f,
  -2.16324344e-01f, 2.28546605e-01f, -1.70029476e-01f, -9.89794508e-02f, 1.88160762e-01f, 5.91254188e-03f, 7.95166194e-02f, -1.52674645e-01f, 5.67790121e-02f, -2.21395090e-01f,
  -1.02591880e-01f, 1.84551582e-01f, 8.78123417e-02f, 2.20915154e-02f, -7.70314112e-02f, 7.99055845e-02f, -5.24339974e-02f, 3.04026097e-01f, 3.25308368e-02f, -1.10596552e-01f,
  -2.41859388e-02f, -9.66809019e-02f, -7.29873553e-02f, -1.09052174e-01f, 1.46075189e-01f, 2.42576763e-01f, 1.16227023e-01f, 1.72314197e-01f, 1.06156036e-01f, 3.62822823e-02f,
  -1.09477527e-01f, 1.22866966e-01f, 1.71030164e-01f, 1.02332845e-01f, -2.37619400e-01f, 4.09803391e-02f, 4.34898697e-02f, -1.30537212e-01f, 1.28886551e-01f, 2.19545603e-01f,
  8.49643275e-02f, -7.27694714e-04f, 2.05437001e-02f, -1.94278926e-01f, 1.64733320e-01f, 3.10616177e-02f, 1.03294298e-01f, -3.71986926e-02f, -3.99218380e-01f, 2.92759538e-01f,
  1.03498913e-01f, 2.26567918e-03f, 1.10123448e-01f, 3.41138653e-02f, -2.47463912e-01f, 2.63555288e-01f, 1.07876509e-01f, -1.33811161e-01f, 2.20111161e-02f, 2.02774435e-01f,
  -6.19752295e-02f, 2.60084756e-02f, 8.04454610e-02f, 5.03199250e-02f, -3.27711374e-01f, -4.90719974e-02f, 2.97904927e-02f, -1.78825647e-01f, -5.30988872e-02f, 5.96713349e-02f,
  -2.62614209e-02f, 8.22123289e-02f, 3.10027041e-02f, 1.23914629e-01f, -2.95603096e-01f, 2.87732810e-01f, 2.54949898e-01f, 8.30045268e-02f, 3.75612043e-02f, 2.45265305e-01f,
  -1.15739323e-01f, 9.85934399e-03f, -7.57770762e-02f, 7.36342967e-02f, -2.68781543e-01f, -2.23086640e-01f, 9.51643810e-02f, -2.51349092e-01f, 1.13708004e-01f, -1.91948712e-02f,
  -3.12677383e-01f, 7.23251328e-02f, 1.25352472e-01f, -1.63935393e-01f, -2.12545805e-02f, 1.68320164e-01f, 4.17360440e-02f, -7.79032195e-03f, -1.07154153e-01f, -3.28938384e-03f,
  -1.31634504e-01f, 1.19934566e-01f, 4.89390716e-02f, 2.39311457e-01f, 1.32500812e-01f, 1.09964132e-01f, -7.74549097e-02f, 8.32090378e-02f, 9.75907445e-02f, -3.64796929e-02f,
  5.60685098e-02f, 2.24671841e-01f, 3.93381447e-01f, 1.68451592e-01f, -7.06958249e-02f, -1.71717614e-01f, -2.29021832e-01f, 2.05496877e-01f, 1.63791224e-01f, -7.97691792e-02f,
  -3.37572336e-01f, -1.89339742e-01f, -1.43002689e-01f, 2.28231531e-02f, -2.91372612e-02f, -1.26677558e-01f, -8.73618945e-02f, 1.70643583e-01f, 2.29880903e-02f, 1.84363186e-01f,
  -5.33617437e-02f, 7.11477473e-02f, 1.37762442e-01f, -7.06325844e-02f, 2.86167767e-02f, -2.55221099e-01f, 1.23241231e-01f, 2.21584693e-01f, -4.74528298e-02f, 6.01412430e-02f,
  1.92448616e-01f, 3.08596551e-01f, -3.88825759e-02f, -8.36732835e-02f, 9.32547674e-02f, 2.93716818e-01f, -4.79430147e-02f, -1.91193745e-01f, -2.16426790e-01f, -1.45800978e-01f,
  -2.06780225e-01f, 2.34914362e-01f, 1.76399052e-01f, 2.48269692e-01f, 1.25984684e-01f, 1.51200190e-01f, 2.12073267e-01f, 4.79032770e-02f, 7.66851977e-02f, 1.00973830e-01f,
  6.78825825e-02f, 3.08240384e-01f, -2.50747260e-02f, -2.20195532e-01f, 1.70358479e-01f, 5.86638786e-02f, 2.38933519e-01f, -1.19187385e-02f, -7.95439482e-02f, 2.14941189e-01f,
  1.64559379e-01f, 1.49119779e-01f, 2.56155550e-01f, 8.16821083e-02f, 4.50263739e-01f, 2.27847546e-01f, -4.40457650e-03f, -1.82023376e-01f, 2.76819438e-01f, 8.26386958e-02f,
  1.83091965e-02f, -1.77704245e-01f, -2.09042966e-01f, -2.79052585e-01f, -2.40063637e-01f, 1.60177797e-01f, -4.53852452e-02f, 2.15951636e-01f, 8.01553428e-02f, 2.78240770e-01f,
  2.45622382e-01f, -8.11343491e-02f, 3.63934666e-01f, -5.94839007e-02f, -1.96071565e-01f, 6.49390789e-03f, -2.11892545e-01f, -5.62283490e-03f, -1.54142678e-01f, 2.53408700e-01f,
  2.09665865e-01f, 1.24394372e-01f, -6.84384406e-02f, -1.70004860e-01f, 2.94255376e-01f, 1.24978824e-02f, 2.89784614e-02f, -7.09417239e-02f, 7.54793063e-02f, 3.98581624e-02f,
  6.71139210e-02f, 8.18444975e-03f, -4.24767733e-02f, 4.08670783e-01f, 6.61453530e-02f, 3.59622747e-01f, -1.80974856e-01f, 7.66862705e-02f, 1.25323683e-02f, 8.30310881e-02f,
  -6.15609251e-02f, 1.61159813e-01f, 2.30822250e-01f, -7.59873120e-03f, -2.59372853e-02f, 5.93580306e-02f, -1.39871389e-01f, 8.31685364e-02f, -1.01647586e-01f, -1.03402950e-01f,
  1.96332127e-01f, 2.60805190e-01f, -1.53739095e-01f, 7.80311078e-02f, -1.89744726e-01f, 1.43124267e-01f, 1.78806975e-01f, -3.34897451e-02f, 1.80479616e-01f, -1.27986014e-01f,
  -1.92422286e-01f, 8.93861577e-02f, 2.38497749e-01f, 3.91761363e-02f, 6.02051355e-02f, 2.11955011e-01f, -3.61902237e-01f, -2.93889157e-02f, -1.65757090e-01f, -8.79205987e-02f,
  1.90377504e-01f, 2.69338220e-01f, -8.60038623e-02f, 6.23126887e-02f, 7.35075995e-02f, 3.25715035e-01f, -1.80440828e-01f, 6.60458058e-02f, -1.92447677e-01f, -2.07634181e-01f,
  -1.35250911e-02f, -4.57481369e-02f, -2.97556847e-01f, 1.30581528e-01f, -5.09728491e-02f, 4.29756232e-02f, -3.55507314e-01f, 2.24560499e-01f, 2.27771446e-01f, -8.49542990e-02f,
  -3.00696969e-01f, 1.29534900e-01f, -4.88586314e-02f, 9.95374992e-02f, -2.10687220e-01f, 9.31559727e-02f, -9.03375745e-02f, 2.10128352e-01f, 2.15717509e-01f, 7.88681060e-02f,
  2.06015423e-01f, 8.77643228e-02f, -1.54032335e-01f, 1.32250234e-01f, 4.62978557e-02f, -1.16561092e-01f, -9.90169644e-02f, 1.47696659e-01f, 6.97739571e-02f, -4.26063865e-01f,
  1.69731110e-01f, 7.32761696e-02f, 1.08850390e-01f, 1.54317364e-01f, 1.86698705e-01f, 1.26417791e-02f, 2.77567152e-02f, 1.35025129e-01f, 8.15484449e-02f, 5.90864085e-02f,
  1.24054901e-01f, 1.43182978e-01f, 2.47238755e-01f, -1.79257691e-01f, -3.75065297e-01f, -1.47001907e-01f, 1.64843246e-01f, -1.92179948e-01f, 2.58584827e-01f, 1.93791818e-02f,
  -1.23822495e-01f, 5.39590865e-02f, -1.16356939e-01f, 1.26098156e-01f, 2.09960923e-01f, 1.66241378e-01f, 1.84157282e-01f, 1.39953554e-01f, 5.62133640e-02f, -3.38116176e-02f,
  2.91784793e-01f, -1.50728106e-01f, 6.64783791e-02f, 6.12192489e-02f, 6.20040894e-02f, 4.43514809e-02f, 1.89337447e-01f, 1.01888962e-01f, 1.49833962e-01f, 1.59136742e-01f,
  -8.69414434e-02f, -2.75197089e-01f, 4.87649115e-03f, -2.18319401e-01f, -3.34876716e-01f, -3.36700678e-02f, 2.24558432e-02f, 7.44486526e-02f, 4.01005782e-02f, 1.75459404e-02f,
  1.21093191e-01f, 4.06183004e-01f, 1.48050502e-01f, 1.26050919e-01f, -1.89664260e-01f, -7.60122910e-02f, -4.22955938e-02f, -1.07543789e-01f, 4.02983017e-02f, -6.83926195e-02f,
  2.08098650e-01f, -2.14414313e-01f, 1.19449601e-01f, -1.17667265e-01f, 1.24536641e-01f, 7.22319214e-03f, 1.00446351e-01f, -2.05675006e-01f, 1.21531524e-02f, 1.82268113e-01f,
  1.92842484e-01f, 2.00770929e-01f, 1.38933852e-01f, 9.54870805e-02f, 2.31856838e-01f, 6.36311844e-02f, -6.91618491e-03f, -3.19771111e-01f, -3.82332861e-01f, 1.26141280e-01f,
  2.54481047e-01f, -1.01522449e-02f, 2.94799507e-01f, 1.92742050e-01f, 5.91415577e-02f, 7.28397220e-02f, 5.28090261e-02f, 6.22969903e-02f, 1.37855396e-01f, 1.07444458e-01f,
  7.62309656e-02f, -4.50743660e-02f, -4.87944968e-02f, -1.93982691e-01f, 9.46711451e-02f, 3.94045115e-02f, -1.16689347e-01f, -2.18122318e-01f, -1.13831677e-01f, 3.78503650e-01f,
  1.11317739e-01f, 1.84414133e-01f, 8.52243453e-02f, 1.77558661e-02f, 4.16555777e-02f, 3.00317500e-02f, 2.04212010e-01f, -1.02534726e-01f, 2.39920869e-01f, 7.94772133e-02f,
  2.54904926e-01f, -5.18753082e-02f, 1.59595549e-01f, -3.54956120e-01f, -8.42933133e-02f, -4.96784598e-02f, -2.23099679e-01f, -1.11581020e-01f, 7.39532039e-02f, 1.51547596e-01f,
  -4.22020815e-03f, 9.66953561e-02f, 2.53514983e-02f, 1.09430477e-01f, 2.39575043e-01f, -8.21473747e-02f, -9.21824276e-02f, -5.06448522e-02f, 9.67051536e-02f, 1.36065692e-01f,
  1.40503928e-01f, 1.30492434e-01f, 3.98258343e-02f, -1.01387978e-01f, 1.75805330e-01f, 2.53171306e-02f, 9.27712992e-02f, 1.03034228e-02f, 1.97076753e-01f, -1.38402447e-01f,
  -4.98392172e-02f, -1.66672155e-01f, 5.94519787e-02f, 6.85310066e-02f, -6.39180392e-02f, 3.26531261e-01f, -1.46889731e-01f, 3.70252818e-01f, 2.79018700e-01f, 1.47702053e-01f,
  3.59225303e-01f, -1.73054561e-01f, -2.66341805e-01f, 6.49387017e-02f, -1.09306887e-01f, -3.48071188e-01f, -2.89877445e-01f, -1.20611057e-01f, 5.31292297e-02f, -1.53930485e-01f,
  -2.86292821e-01f, 2.31752265e-02f, -3.05130929e-01f, 6.24756068e-02f, 2.27935404e-01f, -4.90190722e-02f, -1.71685413e-01f, -1.29431933e-01f, 2.61981487e-01f, -2.89820749e-02f,
  -3.57886478e-02f, 3.83749530e-02f, 2.08933175e-01f, -1.66884631e-01f, 5.93242981e-02f, 1.37015998e-01f, -1.42824039e-01f, -1.57475099e-01f, 1.33907929e-01f, 2.93205436e-02f,
  -4.63381946e-01f, 1.29958555e-01f, -6.21299185e-02f, 1.33533001e-01f, 3.13288309e-02f, 1.67973533e-01f, -1.64087877e-01f, 7.28866979e-02f, 1.18324533e-01f, 6.56782687e-02f,
  -4.20923680e-02f, -1.96666464e-01f, -1.14251394e-02f, -1.31795287e-01f, 3.46027911e-02f, -6.23690449e-02f, 6.51882365e-05f, 1.33630693e-01f, 9.47890878e-02f, -1.67693552e-02f,
  -9.93114784e-02f, -2.06986979e-01f, 4.54351120e-02f, 1.44063830e-01f, -1.14707559e-01f, -1.36313438e-01f, -5.98601587e-02f, 1.29686266e-01f, -6.57131821e-02f, 1.42704949e-01f,
  2.73709875e-02f, 3.20811346e-02f, -1.80680156e-01f, 1.38738826e-01f, 1.41458243e-01f, -2.05910355e-02f, 1.68514088e-01f, 3.78884189e-02f, -1.62064284e-02f, 4.74638194e-02f,
  -8.80317762e-03f, 6.69509405e-03f, -2.88472980e-01f, 8.23630020e-04f, -4.36864831e-02f, 3.00499983e-03f, -7.49857426e-02f, -9.66862142e-02f, 1.02517553e-01f, -1.08399503e-01f,
  -1.02210239e-01f, -1.29640684e-01f, -2.52334654e-01f, 2.74269462e-01f, 1.39433756e-01f, -9.23714787e-02f, 2.23774269e-01f, 2.05747560e-01f, -1.51206493e-01f, 1.96515337e-01f,
  -2.97572911e-01f, 3.67657617e-02f, -6.19896315e-02f, -2.90200502e-01f, 1.05160691e-01f, -1.94315329e-01f, 1.74816221e-01f, 9.37023237e-02f, -1.55497253e-01f, 1.52272254e-01f,
  6.12832494e-02f, -2.29881629e-01f, -4.72453594e-01f, 2.01832086e-01f, 6.78172782e-02f, -1.13421857e-01f, -3.62631455e-02f, -8.00800771e-02f, -1.34115117e-02f, -5.51918671e-02f,
  -9.69150513e-02f, 2.08646983e-01f, 1.12752564e-01f, 1.55752361e-01f, 4.40675318e-02f, -1.08152203e-01f, -5.45636378e-02f, 7.36810640e-03f, -9.12087709e-02f, 1.05105333e-01f,
  1.22268023e-02f, -8.31123814e-02f, -2.58590579e-01f, 2.39893928e-01f, -1.08610027e-01f, 2.19209373e-01f, -1.47095993e-01f, 1.47929683e-01f, 1.67385161e-01f, -1.37380600e-01f,
  -1.94089815e-01f, 2.01823831e-01f, 2.46021822e-02f, 5.19100055e-02f, 2.18107179e-02f, 2.17264995e-01f, -1.02137856e-01f, 2.86068935e-02f, -1.06306449e-01f, 3.14850211e-02f,
  -2.05462739e-01f, 2.00286165e-01f, 2.13447288e-01f, 1.37514651e-01f, -2.30456486e-01f, -2.73168385e-01f, 5.79888374e-02f, -2.23350152e-01f, 2.81767212e-02f, -7.22668767e-02f,
  -3.05237342e-02f, -1.38601407e-01f, 1.99633479e-01f, 4.96745259e-02f, 7.69449174e-02f, -5.09278215e-02f, 9.83843356e-02f, 1.59544587e-01f, 1.60939366e-01f, 1.16886787e-01f,
  -3.73225636e-03f, 1.80248350e-01f, 2.63798386e-01f, 3.55172195e-02f, -3.21385115e-01f, -2.84863892e-03f, -4.36049998e-02f, -9.14015695e-02f, 1.16800629e-01f, -3.05490553e-01f,
  1.00599393e-01f, 1.79642096e-01f, -6.20660670e-02f, -5.48617803e-02f, -2.74506789e-02f, -1.11098267e-01f, 2.27197893e-02f, 4.58045825e-02f, -1.54311229e-02f, -1.53634744e-02f,
  1.91639904e-02f, 1.82349488e-01f, 2.97021925e-01f, -7.12036073e-01f, -5.38140059e-01f, 2.10902005e-01f, 1.67879369e-02f, 1.20234631e-01f, 3.59347939e-01f, -9.23229828e-02f,
  1.00757308e-01f, 1.83719769e-01f, 1.28520116e-01f, -1.97398011e-02f, 5.73886894e-02f, -2.79867221e-02f, -8.20334330e-02f, 2.19417199e-01f, 7.18283057e-02f, 4.44015395e-03f,
  1.58656552e-01f, -1.09460145e-01f, -2.44201366e-02f, 1.01057850e-01f, -9.57080275e-02f, -1.04090869e-01f, -5.90527467e-02f, 1.07688062e-01f, 2.47591004e-01f, -3.95335630e-02f,
  -8.46965834e-02f, -1.27437580e-02f, -2.71460339e-02f, 8.11214559e-03f, -2.76586413e-01f, 1.14933573e-01f, -1.26253411e-01f, 3.73851918e-02f, 5.53827323e-02f, -5.44652790e-02f,
  -6.53582737e-02f, -7.15344846e-02f, 1.32115215e-01f, 3.79811414e-02f, 1.81925632e-02f, -5.55112027e-02f, -3.97133738e-01f, 2.45187819e-01f, 2.32722223e-01f, 8.99513513e-02f,
  -6.60475045e-02f, -1.48055360e-01f, -1.22234128e-01f, 8.57107267e-02f, 2.18275953e-02f, -1.26180902e-01f, 4.33463082e-02f, -8.83158743e-02f, 2.94284821e-01f, -3.30212177e-03f,
  2.93623749e-03f, 6.86831698e-02f, 8.24285112e-03f, -1.95247084e-01f, 1.33063197e-01f, -1.77367881e-01f, 1.30167410e-01f, 3.68557543e-01f, 2.68727988e-01f, -1.12095751e-01f,
  -2.43274495e-01f, -2.31748372e-02f, -2.48117179e-01f, -2.13184819e-01f, -7.38726109e-02f, -2.05079034e-01f, -3.38711888e-02f, -2.06634700e-01f, -2.32995644e-01f, 5.23851141e-02f,
  2.03578785e-01f, -2.00385422e-01f, -3.40505749e-01f, 1.78160563e-01f, 1.85268506e-01f, -4.92953062e-02f, 1.42856702e-01f, -1.23516418e-01f, -3.30903679e-02f, 1.96542397e-01f,
  7.99743906e-02f, -2.29738444e-01f, -1.52545691e-01f, 4.79460247e-02f, 1.38470024e-01f, -6.02754019e-02f, 1.96742609e-01f, 3.18871737e-02f, 7.41346329e-02f, -1.81979477e-01f,
  1.45178869e-01f, 6.14781566e-02f, 4.11344953e-02f, -6.11866303e-02f, 1.93617135e-01f, 7.08558708e-02f, 3.78253646e-02f, 7.11203963e-02f, 3.62836430e-03f, 3.38403374e-01f,
  2.54233748e-01f, 3.30378488e-02f, 1.90506037e-02f, 2.34404936e-01f, 7.37894326e-02f, -1.20490836e-02f, 2.96490550e-01f, 2.42835015e-01f, -2.69903183e-01f, 1.10345215e-01f,
  -6.40461668e-02f, -7.95492157e-02f, -1.48565322e-01f, 5.04502207e-02f, 4.64818291e-02f, 7.38530308e-02f, 1.22168973e-01f, 9.76299122e-03f, 1.24035418e-01f, 3.02073568e-01f,
  -1.80785686e-01f, 1.72609255e-01f, 4.49932106e-02f, -9.55278927e-04f, 1.17784202e-01f, -3.64048243e-01f, 1.01950943e-01f, -5.66463095e-05f, 1.39230564e-01f, 1.70693010e-01f,
  -1.67259723e-01f, 3.70909154e-01f, 1.22198038e-01f, -9.34854671e-02f, 5.90953305e-02f, 3.90927568e-02f, 1.38354868e-01f, 1.19859047e-01f, -1.88996851e-01f, -4.34023999e-02f,
  1.88864954e-02f, -1.08336853e-02f, 2.06937850e-01f, -8.54287669e-02f, -2.09382884e-02f, 2.32975587e-01f, 1.77190825e-01f, 2.05842908e-02f, 7.34127834e-02f, 3.03945839e-02f,
  -2.01022699e-01f, -3.61435860e-01f, 1.28322914e-01f, 1.56824112e-01f, 7.20163137e-02f, -3.80212963e-01f, 1.40031978e-01f, -1.56599022e-02f, -2.49121770e-01f, 2.34869570e-02f,
  1.51042193e-01f, -9.01655108e-02f, -1.59493815e-02f, -4.90298420e-01f, 3.32829319e-02f, -2.19033629e-01f, -2.24173605e-01f, 2.13234618e-01f, -7.87178949e-02f, 1.75754264e-01f,
  1.71173066e-01f, -1.57143906e-01f, 1.24916002e-01f, 4.90412004e-02f, 4.47976552e-02f, 1.90487593e-01f, -2.74739731e-02f, 9.40016061e-02f, 4.24389727e-02f, 1.96055412e-01f,
  1.62230834e-01f, 2.94874609e-01f, 2.39082545e-01f, 1.88969135e-01f, 4.21068966e-01f, 1.59426451e-01f, -1.85322925e-01f, 2.08106741e-01f, 2.70553440e-01f, -2.09295332e-01f,
  2.51313061e-01f, 2.12698177e-01f, -1.49641514e-01f, -1.60823151e-01f, -3.06950629e-01f, -8.44220370e-02f, 2.31863204e-02f, 1.69085130e-01f, -6.91153705e-02f, 3.84057350e-02f,
  1.02682285e-01f, 1.80682138e-01f, 1.22616202e-01f, -1.56198770e-01f, -8.53258148e-02f, 4.49175946e-02f, -5.64791597e-02f, -6.80968910e-02f, -5.36754690e-02f, 1.28143579e-01f,
  1.99106842e-01f, 6.20731711e-03f, -8.73359013e-03f, -6.39244914e-02f, 1.86839804e-01f, 7.57052824e-02f, -4.40334976e-02f, -1.02187380e-01f, -1.14381820e-01f, 2.00608686e-01f,
  -8.14251304e-02f, -5.76490462e-02f, -1.60935685e-01f, 1.85914487e-01f, 1.71448290e-01f, 3.62155348e-01f, 1.11257106e-01f, -2.31725741e-02f, -2.15347968e-02f, 1.74126253e-01f,
  1.40487790e-01f, 1.55520022e-01f, 1.28852591e-01f, -1.44227073e-01f, -1.08052775e-01f, -1.73356012e-01f, 1.46745801e-01f, 3.93633574e-01f, 1.55660242e-01f, 1.44590229e-01f,
  7.15564936e-02f, 4.72839512e-02f, 2.74173319e-01f, -4.09493083e-03f, 1.03835203e-01f, 1.19105071e-01f, -1.65931825e-02f, -5.40848933e-02f, 1.05540030e-01f, -2.22735897e-01f,
  -1.21635363e-01f, 4.31107990e-02f, 1.48911819e-01f, 1.39752924e-01f, 1.82563663e-01f, 3.11337113e-01f, 4.17002887e-02f, -2.55723167e-02f, -2.29585856e-01f, -1.13563336e-01f,
  3.14712256e-01f, -6.79351315e-02f, -1.25938892e-01f, 2.82563955e-01f, 2.00938419e-01f, 9.88366306e-02f, -1.04621314e-02f, -1.18263163e-01f, -1.59526646e-01f, 1.15204416e-02f,
  -6.64738715e-02f, 2.05501374e-02f, -4.43882719e-02f, 3.45979542e-01f, 2.18209922e-01f, 1.19345859e-01f, -3.47659141e-01f, 5.57239540e-02f, -2.98299994e-02f, -1.73178837e-01f,
  -8.06618035e-02f, 3.22704494e-01f, 2.93654650e-02f, 3.74237895e-02f, 2.16083732e-02f, -3.13293450e-02f, -1.43526003e-01f, 6.97549060e-02f, -7.76107311e-02f, -3.18197720e-02f,
  2.13685585e-03f, -3.43104675e-02f, -2.16216430e-01f, -6.72321999e-03f, 8.54708850e-02f, -1.42928869e-01f, 3.26806694e-01f, -8.03225636e-02f, -7.44689852e-02f, -2.42352530e-01f,
  6.12857006e-02f, 2.30260789e-01f, 1.99549854e-01f, 2.99557209e-01f, 2.51923829e-01f, 7.55051672e-02f, 1.41432807e-01f, -4.45910133e-02f, 1.30505025e-01f, 5.07731140e-02f,
  1.35879591e-01f, 2.44370118e-01f, -1.32186443e-01f, -2.85215765e-01f, -4.10203636e-01f, -2.77303159e-02f, 8.49292204e-02f, 1.28500164e-01f, 4.70019370e-01f, 3.16956222e-01f,
  2.87386067e-02f, 2.77638137e-01f, 4.81049903e-02f, 2.05470826e-02f, 3.36809814e-01f, -3.90959755e-02f, 3.59183475e-02f, 1.74266160e-01f, 5.17652370e-02f, 7.55621716e-02f,
  4.45745960e-02f, -1.16710804e-01f, 3.65911871e-02f, -3.69767100e-02f, 2.86431611e-01f, 2.70297557e-01f, 6.34927154e-02f, 2.71545619e-01f, 2.27755979e-01f, 2.94606742e-02f,
  -2.61835694e-01f, 1.26710325e-01f, -1.59186378e-01f, -1.63440481e-01f, -2.76430342e-02f, 1.65263489e-01f, 6.42021149e-02f, 6.94146380e-02f, -1.70882605e-02f, -2.26971284e-01f,
  7.34906131e-03f, 1.70454517e-01f, 3.92872728e-02f, -2.64111608e-01f, 1.88302547e-01f, 4.49292026e-02f, -8.11648518e-02f, -3.90666649e-02f, 1.77030098e-02f, 1.27759531e-01f,
  6.95926175e-02f, -3.09910309e-02f, -8.11591521e-02f, 6.88937008e-02f, -3.40330065e-03f, -8.21419582e-02f, 1.03612944e-01f, -1.28605841e-02f, 1.26791280e-03f, -1.97593421e-01f,
  8.59635845e-02f, 2.11947873e-01f, -8.11535791e-02f, 7.41093904e-02f, 1.47012528e-02f, -6.93486631e-02f, -9.76406187e-02f, -2.10228726e-01f, -2.40615979e-01f, -1.88672021e-02f,
  -7.82089680e-02f, 3.31515610e-01f, -1.18286563e-02f, 3.35406870e-01f, 3.51308823e-01f, 9.36555862e-02f, 2.87198097e-01f, 9.71995592e-02f, -1.72758463e-03f, 1.00598060e-01f,
  -4.15175222e-02f, -1.46409601e-01f, -1.76639274e-01f, -2.08498657e-01f, 6.80590421e-02f, 1.84382685e-02f, -1.91892982e-01f, -1.73959151e-01f, -7.83948973e-02f, 2.21615851e-01f,
  2.67153710e-01f, -2.57837605e-02f, -2.80524164e-01f, -3.04268897e-02f, 9.10968035e-02f, 1.29054263e-01f, -1.08609162e-01f, -1.62197441e-01f, 8.87693018e-02f, 1.13440700e-01f,
  1.51803046e-01f, -4.10431251e-02f, -1.02017485e-02f, -8.68889019e-02f, 2.69307435e-01f, -6.44808263e-02f, -3.86426300e-01f, 4.14578617e-02f, -3.28790070e-03f, 1.59709737e-01f,
  -4.52006720e-02f, 3.75788510e-02f, -2.57513165e-01f, 5.29391356e-02f, 2.87695706e-01f, -1.32743776e-01f, 1.21502884e-01f, -5.42759560e-02f, -1.93958819e-01f, 1.02464832e-01f,
  1.23628937e-01f, -1.00936562e-01f, 9.02304500e-02f, 1.63207911e-02f, 1.73059061e-01f, 1.34342745e-01f, 1.77995458e-01f, -5.67762516e-02f, -8.13282281e-02f, -8.57833549e-02f,
  -3.81968290e-01f, 1.78834468e-01f, 2.49024823e-01f, 1.01938665e-01f, -2.12396786e-01f, 1.10416338e-01f, -2.75823355e-01f, 1.65328383e-01f, -3.49701941e-01f, 1.01505376e-01f,
  5.34426607e-02f, -6.67436719e-02f, 1.15486734e-01f, 2.98131794e-01f, -3.38291191e-02f, -1.92204472e-02f, -1.71876356e-01f, 1.83469713e-01f, -1.71648934e-01f, -1.43073007e-01f,
  4.20882180e-02f, -2.42212087e-01f, -2.52741762e-02f, -3.20330977e-01f, 8.68115574e-02f, 1.35331899e-01f, -2.52333134e-01f, -2.94650465e-01f, 1.24235563e-01f, 1.26991197e-02f,
  6.41805604e-02f, -5.68156950e-02f, -1.02610923e-02f, 1.03792613e-02f, -4.82054763e-02f, 1.16239995e-01f, -1.36638731e-01f, -4.87236725e-03f, -1.14236534e-01f, 4.85771596e-02f,
  -8.59198496e-02f, 1.84026375e-01f, 2.25208402e-01f, 1.82151094e-01f, 8.70942473e-02f, 7.29426444e-02f, -2.78636754e-01f, -1.52187943e-01f, -1.27783254e-01f, 3.34321976e-01f,
  2.06466451e-01f, -2.11899668e-01f, -4.75289635e-02f, 1.72559485e-01f, -5.42000532e-02f, -5.03876852e-03f, 1.42585039e-01f, 9.00107399e-02f, 1.52984619e-01f, 1.37980714e-01f,
  1.02533147e-01f, -2.91432738e-02f, -3.56248803e-02f, -5.73569164e-02f, 2.02059209e-01f, -3.83426011e-01f, -3.03319097e-01f, 4.71036732e-01f, -4.36122529e-03f, 8.91345441e-02f,
  1.96771443e-01f, -8.11957568e-02f, 8.24017003e-02f, -3.32714505e-02f, -3.60740870e-02f, -1.92622527e-01f, 4.87597920e-02f, -1.21512942e-01f, -3.05517833e-03f, 6.30566552e-02f,
  -4.32585478e-02f, -1.22374952e-01f, 2.91759312e-01f, 1.20267875e-01f, 1.76643732e-03f, 1.95273250e-01f, -4.28762734e-02f, 4.72331792e-02f, -6.69096634e-02f, 6.91424385e-02f,
  2.02277258e-01f, 2.68657774e-01f, 9.16140899e-02f, 1.64829120e-01f, 3.14889520e-01f, 1.25052586e-01f, -1.32953227e-01f, -2.05739383e-02f, 1.26634315e-01f, -4.63370718e-02f,
  -1.78404320e-02f, -8.06419626e-02f, -5.82126714e-02f, -1.98445544e-01f, -7.44926557e-02f, -1.06864087e-01f, 2.06708208e-01f, 7.08269477e-02f, -1.55444264e-01f, 2.03288376e-01f,
  1.74426094e-01f, -1.58519223e-02f, 1.28273413e-01f, -2.14789152e-01f, -1.90818593e-01f, -1.85321905e-02f, -1.01490006e-01f, -8.77447519e-03f, -1.03454098e-01f, -1.17507026e-01f,
  1.15189388e-01f, 4.80674915e-02f, -5.55114672e-02f, 1.58136278e-01f, 6.39786571e-02f, 4.78815101e-02f, -6.10038824e-02f, 1.49311811e-01f, -1.49198577e-01f, 2.94242322e-01f,
  4.48820978e-01f, -1.68123901e-01f, -2.98036039e-01f, -1.04773723e-01f, -1.13951722e-02f, -2.02803891e-02f, -4.33293939e-01f, 2.54868362e-02f, 8.92835557e-02f, -4.72267084e-02f,
  1.79196987e-02f, 1.34055421e-01f, 4.97323945e-02f, -1.74668431e-01f, -1.16805188e-01f, 3.09277922e-01f, -1.74731165e-01f, 2.48898417e-01f, -1.48079721e-02f, -9.50763673e-02f,
  -7.50726238e-02f, -3.06552559e-01f, 5.63620552e-02f, 2.37873361e-01f, -2.89121300e-01f, -3.72419477e-01f, 2.29513258e-01f, -8.97876397e-02f, 5.49974293e-02f, 7.58217124e-04f,
  -2.52803937e-02f, -1.38580233e-01f, -2.67456239e-03f, 2.45047525e-01f, -1.27469167e-01f, 2.22022906e-01f, 1.77389577e-01f, 4.05939072e-02f, 1.97319463e-01f, 1.97804376e-01f,
  1.38724118e-01f, 2.47061834e-01f, 2.43645415e-01f, -2.98101436e-02f, -5.78211360e-02f, 4.27678190e-02f, -1.06196985e-01f, 2.71449745e-01f, 2.61184573e-01f, -1.15176804e-01f,
  1.41071498e-01f, -6.79543689e-02f, -2.26507127e-01f, -8.09105635e-02f, -1.03099264e-01f, 2.35652849e-02f, -1.47614211e-01f, -1.59662768e-01f, -1.73041776e-01f, -7.25927748e-05f,
  -5.88698015e-02f, 1.78678364e-01f, -1.13998897e-01f, -2.10498542e-01f, -3.65008056e-01f, 2.42991769e-03f, -1.09959647e-01f, -7.88331702e-02f, 2.38243788e-01f, -9.27478448e-02f,
  -1.41150907e-01f, 1.58411235e-01f, 7.91911781e-02f, 2.57809043e-01f, 1.05870217e-01f, 2.20920771e-01f, 1.88911006e-01f, 5.89007884e-02f, 2.76019797e-03f, 2.71224473e-02f,
  -2.99065486e-02f, 2.76847035e-01f, 2.90418770e-02f, 2.18325570e-01f, 2.70262331e-01f, 2.92532891e-01f, 3.83841135e-02f, 1.16194636e-01f, 1.68647654e-02f, -5.02006942e-03f,
  -7.85005018e-02f, 2.06844375e-01f, -1.13360398e-01f, -1.57272354e-01f, -3.22163552e-01f, 2.61888564e-01f, -9.87280160e-03f, -1.83067009e-01f, -1.97303116e-01f, 3.96376073e-01f,
  1.72448382e-01f, 5.57471253e-02f, 1.05500244e-01f, -2.53785044e-01f, 1.31502897e-01f, -2.13642552e-01f, -9.91661623e-02f, -5.76423928e-02f, -7.54516870e-02f, 1.01394631e-01f,
  -5.43133263e-03f, -9.52690747e-03f, 9.05612484e-02f, -2.23075956e-01f, -2.21235499e-01f, 9.96283591e-02f, -1.74101591e-01f, -7.89130926e-02f, 3.41747925e-02f, 1.44634783e-01f,
  3.10106546e-01f, 1.96606264e-01f, 1.11338913e-01f, 9.53014418e-02f, 7.27825752e-03f, 6.97667971e-02f, 1.00270621e-02f, -1.22768231e-01f, 1.12634979e-01f, 1.92196127e-02f,
  -1.90319061e-01f, -2.59102911e-01f, 1.17260002e-01f, -1.07409790e-01f, 4.02886868e-01f, 3.46913002e-02f, 1.10576674e-01f, 1.18072294e-01f, 1.58995375e-01f, -1.50518581e-01f,
  1.53303638e-01f, -1.26071095e-01f, -6.39441162e-02f, 7.44012594e-02f, -4.99737225e-02f, -1.93518758e-01f, 3.69348794e-01f, -2.44949624e-01f, 2.21111029e-01f, 2.55882949e-01f,
  2.75222063e-01f, 1.11955620e-01f, -2.05087904e-02f, -6.94655851e-02f, 1.15495510e-01f, -1.74338087e-01f, -1.03656702e-01f, -9.08277109e-02f, 1.23711325e-01f, 1.72077492e-01f,
  3.43132883e-01f, -1.62073895e-01f, 2.66294122e-01f, -8.83366764e-02f, -3.82830054e-02f, -7.54501596e-02f, -4.06911299e-02f, 7.12890849e-02f, -6.91952854e-02f, -2.15805434e-02f,
  2.52050459e-01f, -3.15772519e-02f, 1.33720949e-01f, 1.92559630e-01f, 1.37191072e-01f, 9.19634327e-02f, 7.68570825e-02f, 2.35565439e-01f, -2.83470508e-02f, -5.29040359e-02f,
  -6.66520894e-02f, 9.94106103e-03f, 2.16501817e-01f, -4.85263541e-02f, -1.83556184e-01f, 2.98769102e-02f, 5.44610471e-02f, -5.64792939e-02f, -4.96741338e-03f, 1.29288435e-01f,
  6.45790696e-02f, 1.94906339e-01f, -6.85818344e-02f, -1.86211467e-01f, 2.72948574e-02f, 9.37840566e-02f, -1.37720779e-01f, -7.77757633e-03f, -2.71838784e-01f, 9.18815657e-02f,
  -2.36210716e-03f, 7.35465810e-03f, -1.46047860e-01f, 2.67852277e-01f, 4.97638322e-02f, 1.50516719e-01f, 3.38465311e-02f, -1.98669191e-02f, 2.01158166e-01f, 1.05039001e-01f,
  -2.13374108e-01f, -1.12177014e-01f, -2.65914083e-01f, -2.07848847e-02f, 1.91627443e-01f, 6.19882569e-02f, 7.38391355e-02f, -1.82533637e-01f, -1.80563435e-01f, -2.53279567e-01f,
  4.12165821e-02f, -2.34586507e-01f, 1.05595542e-02f, -2.01630354e-01f, 7.83824176e-02f, 4.46780622e-02f, 1.35023385e-01f, -6.82570646e-03f, 2.60417849e-01f, 3.49617273e-01f,
  1.32505119e-01f, 1.67923406e-01f, -2.51184672e-01f, 1.75089285e-01f, 4.32690307e-02f, -1.47531629e-01f, -1.22385144e-01f, -6.97073936e-02f, 7.37945363e-02f, -1.64892942e-01f,
  -1.29856300e-02f, -1.82787165e-01f, 1.80336554e-02f, 6.31280616e-02f, -1.25221938e-01f, -8.58547390e-02f, 7.12690055e-02f, -2.03632921e-01f, -1.16241612e-01f, -2.75179539e-02f,
  -2.14760557e-01f, 4.24562767e-02f, 2.94002686e-02f, 2.88970023e-01f, 7.28145316e-02f, -2.04700619e-01f, -7.74529055e-02f, -6.51329830e-02f, -1.18394680e-01f, -1.86996199e-02f,
  2.61928499e-01f, -1.13647200e-01f, -6.75302669e-02f, 1.32021412e-01f, 1.04838960e-01f, 3.90765399e-01f, 2.86908627e-01f, 1.56460494e-01f, 1.58068955e-01f, 2.29663074e-01f,
  1.08717807e-01f, 2.10678458e-01f, -2.78182149e-01f, 7.40127787e-02f, 1.89648300e-01f, 1.30368784e-01f, 2.79706717e-01f, -1.98084354e-01f, -2.19243288e-01f, 2.03273460e-01f,
  4.68060337e-02f, 5.46773560e-02f, -2.06411760e-02f, 1.71478540e-01f, -1.13482639e-01f, 5.63390180e-02f, -1.87477753e-01f, 9.52245668e-02f, -3.57193351e-01f, -2.66819764e-02f,
  -2.44305581e-01f, 2.62113035e-01f, -9.31629688e-02f, -1.02591403e-01f, 3.16969275e-01f, -5.25524095e-02f, 2.12496027e-01f, -1.45169571e-01f, -1.22447327e-01f, -1.31603599e-01f,
  1.72444470e-02f, 1.07845753e-01f, -3.83976549e-01f, 1.82079554e-01f, 2.90649589e-02f, 4.00758758e-02f, -9.55916792e-02f, 3.68924588e-02f, 1.40873510e-02f, 6.77445084e-02f,
  3.26566845e-02f, 6.23553842e-02f, 1.99685559e-01f, 1.77518204e-01f, 1.71065316e-01f, 1.76009864e-01f, 1.92487836e-01f, -6.34665489e-02f, -2.29623318e-01f, -6.57547936e-02f,
  2.89593220e-01f, -4.09533866e-02f, -2.49256805e-01f, 1.99263647e-01f, -1.76665038e-01f, 2.01249957e-01f, 2.88061172e-01f, 8.51025209e-02f, 2.85370201e-01f, -1.05328716e-01f,
  -3.55137378e-01f, 1.12846037e-02f, 4.70352694e-02f, -5.32678485e-01f, -4.06261802e-01f, 1.10756360e-01f, -9.86000448e-02f, -1.31756529e-01f, -8.61894414e-02f, -5.53536005e-02f,
  -2.72006691e-01f, 9.19484198e-02f, 2.87832499e-01f, 3.50746699e-03f, -2.56140590e-01f, -2.19532371e-01f, 2.69076437e-01f, 3.65721323e-02f, -2.66754359e-01f, -1.49249151e-01f,
  5.27092256e-02f, -1.22806393e-02f, 1.01333201e-01f, -3.85201052e-02f, 1.26095936e-01f, -6.51586130e-02f, 2.21562609e-01f, -3.86191122e-02f, -5.83432853e-01f, 2.74631064e-02f,
  -3.28626856e-02f, 1.98745921e-01f, 3.33140641e-02f, 1.68795362e-01f, -2.05894545e-01f, -5.94729856e-02f, 1.42683879e-01f, 1.04275107e-01f, -6.80029094e-02f, -1.65222764e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  -5.55434823e-02f, 1.61671504e-01f, -1.05425224e-01f, 6.19840808e-02f, -7.66009390e-02f, -5.26059978e-02f, -6.05038963e-02f, -1.65029407e-01f, 2.74233744e-02f, 1.02150161e-02f,
  1.24950252e-01f, -9.94921997e-02f, -5.29210828e-02f, 1.88609492e-02f, 1.34616308e-02f, 1.14197828e-01f, 1.52015433e-01f, 7.25400820e-02f, 2.24281535e-01f, -6.00453056e-02f,
  1.35693654e-01f, 1.68029770e-01f, 1.22752801e-01f, 1.00198716e-01f, 4.20733728e-02f, 1.81268722e-01f, 2.21976548e-01f, 9.89855081e-02f, -1.01700295e-02f, 5.46566769e-02f,
  4.44449969e-02f, 1.80524662e-01f, -1.75277921e-04f, -8.35026614e-03f, 1.01449363e-01f, 7.90288597e-02f, 1.09817266e-01f, 1.47389263e-01f, 1.35641411e-01f, 2.35777125e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -2.64840052e-02f, -9.57884267e-02f, -1.52536975e-02f, -2.45455485e-02f, -1.01367973e-01f, -5.81457803e-04f, -1.60073519e-01f, -3.24926645e-01f, -8.19043517e-02f, 1.56741381e-01f,
  -3.52980077e-01f, -2.62370706e-01f, -1.27876163e-01f, -1.41210556e-01f, -7.67732561e-02f, 2.19444752e-01f, 2.43446440e-01f, -1.13745116e-01f, -5.79208992e-02f, 1.65312365e-02f,
  9.31344107e-02f, -4.63390015e-02f, -2.35261202e-01f, -6.22258522e-02f, -6.42311573e-02f, -3.45485806e-01f, 2.90065676e-01f, -3.94601747e-02f, 1.07012622e-01f, 1.71670914e-01f,
  9.91359726e-02f, 1.89374283e-01f, 1.02286898e-01f, -1.90519780e-01f, -2.16979772e-01f, 2.38683179e-01f, -2.42018864e-01f, -5.26449122e-02f, 1.89425141e-01f, -1.34635344e-01f,
  5.39228134e-02f, -4.05310616e-02f, -1.72679752e-01f, -1.39814720e-01f, -7.22253919e-02f, -1.12647109e-01f, 3.41592878e-02f, 8.66834000e-02f, 3.25526968e-02f, 1.18838333e-01f,
  -3.60564291e-01f, -4.31630500e-02f, -1.29759863e-01f, 6.91215470e-02f, -7.46905282e-02f, -1.55517831e-01f, -1.04366742e-01f, 2.01772541e-01f, -1.24712333e-01f, 1.03253841e-01f,
  -3.40860605e-01f, -1.14229999e-01f, 1.07466623e-01f, 4.44470644e-02f, 8.58841166e-02f, 6.51779845e-02f, 5.29534481e-02f, 9.76887494e-02f, -1.02349706e-01f, 1.12186022e-01f,
  1.37261432e-02f, -6.13926649e-02f, -5.67019321e-02f, -2.40288582e-02f, -8.83564411e-04f, 1.90477803e-01f, 2.59813190e-01f, -1.85917646e-01f, -7.33964518e-02f, 2.36020330e-02f,
  1.56829625e-01f, -1.50750279e-01f, 2.86541551e-01f, -1.54599443e-01f, -5.40390164e-02f, -1.57745421e-01f, 1.76462740e-01f, 2.80638766e-02f, -3.28438990e-02f, -1.72012284e-01f,
  2.99784034e-01f, -3.15324025e-04f, -2.27999121e-01f, -3.53491277e-01f, -2.13930637e-01f, 9.79500562e-02f, 4.92863134e-02f, 1.36986136e-01f, -3.94931972e-01f, 2.81561702e-01f,
  2.20801711e-01f, -4.30304781e-02f, 1.88686982e-01f, 8.71843249e-02f, 4.59311940e-02f, 2.56550550e-01f, 4.55609038e-02f, -6.27987236e-02f, -1.36898801e-01f, -1.99676882e-02f,
  -1.63443267e-01f, -1.08484030e-01f, -7.33657628e-02f, -4.26770709e-02f, 2.04269931e-01f, -1.52405873e-01f, 1.11047722e-01f, -2.65255630e-01f, -5.15589774e-01f, -1.23769604e-01f,
  -1.92016467e-01f, 1.57258809e-01f, -1.54445410e-01f, -2.23158598e-01f, 1.55403346e-01f, -2.31084794e-01f, -3.87485206e-01f, -1.24466009e-01f, 1.11309424e-01f, 9.25875306e-02f,
  -8.29165131e-02f, 1.74357414e-01f, -6.84171543e-03f, 2.73781270e-03f, -2.63721764e-01f, -1.06620930e-01f, -8.53483975e-02f, 2.29966655e-01f, -2.27554977e-01f, 1.92583427e-01f,
  -2.34909371e-01f, -1.19345464e-01f, 1.69528291e-01f, 7.14498684e-02f, -2.63618499e-01f, -2.86563128e-01f, 3.08978349e-01f, -2.81934559e-01f, -2.36399040e-01f, -6.36389060e-03f,
  2.53124535e-01f, 1.59302995e-01f, -9.88111421e-02f, -4.14103568e-02f, -7.56689683e-02f, -1.48741305e-01f, 3.04492679e-03f, 1.83367506e-01f, -3.43247294e-01f, -9.80434101e-03f,
  -4.05680597e-01f, 1.56380206e-01f, 1.07223816e-01f, -5.85996434e-02f, 6.54999241e-02f, -1.00935198e-01f, 1.17940970e-01f, 2.23014027e-01f, -3.93352926e-01f, 3.61443199e-02f,
  2.25668490e-01f, 5.35656437e-02f, 1.27297968e-01f, -4.40848410e-01f, -3.37327123e-01f, -2.12164074e-01f, 1.92511708e-01f, -2.02566966e-01f, 1.69361919e-01f, -2.55239069e-01f,
  1.48539618e-01f, -1.40417069e-01f, -3.96691859e-01f, -3.76980901e-01f, 1.61427915e-01f, -2.44133994e-01f, 3.11579317e-01f, -6.56974176e-03f, -5.16824067e-01f, 3.09544295e-01f,
  1.31277040e-01f, -3.47607225e-01f, 4.01491821e-02f, -1.43098876e-01f, 2.44163126e-02f, -5.50286062e-02f, -8.69590789e-02f, -5.08006960e-02f, 7.34971762e-02f, 7.69237429e-02f,
  -1.23535663e-01f, -2.27961883e-01f, -1.76747218e-01f, 1.26504257e-01f, -1.47775561e-01f, 3.00614387e-01f, -2.00017825e-01f, 2.82309726e-02f, -1.36603042e-01f, 6.44785212e-03f,
  -9.18945819e-02f, 5.26251160e-02f, 1.93906531e-01f, 5.44323884e-02f, -1.94172069e-01f, -1.97095424e-01f, 1.14112400e-01f, 6.25118762e-02f, -1.75389707e-01f, -2.89413482e-01f,
  1.94115732e-02f, 9.98962298e-02f, -6.74751699e-02f, 1.32596955e-01f, -2.33015627e-01f, -3.72041762e-01f, 5.82510047e-02f, -4.57037427e-02f, -3.32925975e-01f, -3.44155669e-01f,
  4.59055081e-02f, 9.90150962e-03f, 1.78964406e-01f, -1.83236822e-01f, -5.29266536e-01f, 1.78662360e-01f, -2.72433192e-01f, -3.72764081e-01f, 3.15029398e-02f, 1.53707221e-01f,
  -1.37772530e-01f, -1.85094178e-01f, -5.30904830e-01f, 1.80415854e-01f, -2.16477901e-01f, 1.02843866e-01f, 1.94683503e-02f, -4.03390825e-03f, 9.94415656e-02f, -7.76066929e-02f,
  3.17568257e-02f, 1.27017766e-01f, -4.18528840e-02f, -5.95829934e-02f, 1.38434902e-01f, -1.03850663e-01f, -2.03178197e-01f, 3.00496012e-01f, 1.82098135e-01f, -6.49942830e-02f,
  1.26811877e-01f, -2.07415149e-01f, 2.11734157e-02f, 7.86503255e-02f, 2.45273039e-01f, 7.81208947e-02f, 3.26807231e-01f, 1.46340290e-02f, 2.53277183e-01f, -1.28211854e-02f,
  1.74847946e-01f, -3.14049661e-01f, -2.93135177e-02f, 4.05086130e-01f, -5.30829839e-02f, -1.75461203e-01f, -1.00212015e-01f, 2.63175339e-01f, -7.56114796e-02f, 7.80538321e-02f,
  -1.31195799e-01f, 3.47064324e-02f, -3.18569839e-01f, -2.92119384e-02f, -1.43376244e-02f, 1.77113086e-01f, 2.22840235e-02f, -5.31505980e-02f, 1.10113688e-01f, -1.26588315e-01f,
  8.31604153e-02f, -1.08502060e-01f, -2.03670248e-01f, -2.50733763e-01f, -1.07538350e-01f, -2.20418036e-01f, 5.24773151e-02f, -1.68602571e-01f, -1.45918489e-01f, 6.21806085e-02f,
  1.35054350e-01f, -7.85972029e-02f, -2.23112181e-01f, -8.37213397e-02f, -8.79255608e-02f, 1.77747890e-01f, 1.86425950e-02f, 1.20171815e-01f, 1.54027179e-01f, 1.37341231e-01f,
  1.09414883e-01f, -2.52830446e-01f, -3.46393198e-01f, 1.15637034e-01f, -3.80888820e-01f, 1.42474815e-01f, 6.97848275e-02f, -2.62631148e-01f, 1.61781624e-01f, -2.46696919e-01f,
  -6.53683841e-02f, 9.89354029e-02f, 9.99226794e-02f, -6.41816035e-02f, 1.94126979e-01f, 2.46445194e-01f, 9.54026133e-02f, -6.29120618e-02f, -1.52889460e-01f, 1.70041740e-01f,
  1.36102244e-01f, 1.11066423e-01f, -1.81166425e-01f, -2.00705931e-01f, 1.89758107e-01f, -2.32207730e-01f, 8.67067724e-02f, 1.22270130e-01f, -1.11541383e-01f, -1.76034018e-01f,
  -7.27452710e-02f, -2.17688322e-01f, 2.28304882e-02f, -2.06503421e-02f, -1.86075494e-01f, -3.05942148e-01f, -7.06160143e-02f, 2.24656582e-01f, 1.66950494e-01f, -2.37736274e-02f,
  -3.38445604e-03f, -1.15262859e-01f, 1.69932827e-01f, 1.98988244e-01f, -2.05608457e-02f, -1.67030096e-01f, 1.44047096e-01f, 2.76649207e-01f, -4.82203066e-02f, -2.04818979e-01f,
  -9.53347795e-03f, 6.75888872e-03f, 1.14939563e-01f, -3.34671251e-02f, 6.27258569e-02f, 9.32777300e-02f, 5.23273945e-02f, -1.93943635e-01f, -3.07534575e-01f, 1.18614763e-01f,
  -9.39289704e-02f, -3.98163140e-01f, 1.86590001e-01f, 2.71747887e-01f, -7.84128904e-02f, -3.96400392e-02f, -1.23896368e-01f, 1.68113261e-01f, -2.83016264e-01f, -3.00627142e-01f,
  -1.73756182e-01f, 3.95049225e-04f, -2.18186140e-01f, -1.17681526e-01f, 2.00017974e-01f, 5.58643639e-02f, 2.27710038e-01f, -1.37178570e-01f, 3.18858922e-02f, -1.45085528e-01f,
  7.43951201e-02f, -5.86925894e-02f, 1.18992075e-01f, -1.13598697e-01f, 2.25550495e-02f, 7.55901188e-02f, 2.90843874e-01f, 1.85385030e-02f, 9.14788321e-02f, -9.81610939e-02f,
  2.19472602e-01f, -8.84811394e-03f, 2.21768305e-01f, 2.33138978e-01f, 2.24816665e-01f, -7.96606615e-02f, 2.17077360e-01f, 1.67265963e-02f, -2.95534104e-01f, 7.96431080e-02f,
  9.95081961e-02f, 2.24115461e-01f, 2.22609565e-01f, -1.64533347e-01f, -3.70897174e-01f, -1.45032242e-01f, -8.34295079e-02f, -3.09618562e-01f, 8.67597088e-02f, -3.26031357e-01f,
  6.53418154e-02f, -2.50706255e-01f, -1.73746571e-02f, -9.88230780e-02f, -1.72065750e-01f, -1.85493037e-01f, 1.08828224e-01f, -3.18164021e-01f, -4.49448749e-02f, 6.92063421e-02f,
  2.98970670e-01f, -8.53484422e-02f, 1.10212773e-01f, 6.11753613e-02f, 1.81246817e-01f, -3.82443249e-01f, -4.04542834e-02f, -2.75844872e-01f, -2.61286885e-01f, 2.29284391e-01f,
  -6.32439852e-02f, -6.42294586e-02f, -3.15585472e-02f, -3.85525644e-01f, -5.76478615e-02f, 1.96602449e-01f, -7.37066641e-02f, 1.19557381e-01f, -2.56133318e-01f, -1.90398216e-01f,
  1.50123928e-02f, -1.48769636e-02f, 1.49893880e-01f, 1.33373037e-01f, -5.18740825e-02f, -5.27549870e-02f, 3.22935134e-02f, 4.82054353e-02f, 7.31143206e-02f, -1.86022058e-01f,
  1.90950453e-01f, -2.41460800e-01f, 5.31060770e-02f, 1.31921783e-01f, -8.14979896e-02f, 2.53418028e-01f, 4.63566214e-01f, 1.34560972e-01f, 3.66847590e-02f, 1.19273461e-01f,
  2.26009518e-01f, 8.60098004e-02f, 3.59790415e-01f, 1.78443924e-01f, -1.49014845e-01f, -2.73305774e-01f, -2.35141829e-01f, -1.32099047e-01f, 3.49753834e-02f, -6.87649101e-02f,
  2.46010482e-01f, -1.99722365e-01f, 1.15771241e-01f, 6.54741228e-02f, 3.75479795e-02f, -1.92984387e-01f, 9.59570929e-02f, -2.08107427e-01f, -4.72429603e-01f, -2.30038408e-02f,
  -1.69089586e-01f, -2.16856241e-01f, -5.98285981e-02f, -3.19147795e-01f, -3.41913328e-02f, -4.43785846e-01f, 3.93647440e-02f, -3.84963714e-02f, 1.24522761e-01f, 1.29066199e-01f,
  -3.20596218e-01f, -1.60795644e-01f, -1.14958763e-01f, -2.59190500e-01f, 1.47283837e-01f, -2.34367594e-01f, 2.08107054e-01f, -9.67987552e-02f, 2.15215683e-01f, -1.80423856e-01f,
  1.08625337e-01f, 1.61595941e-02f, 1.32099658e-01f, 1.49523154e-01f, -3.96501631e-01f, 1.45629272e-01f, -2.60040071e-02f, 1.52944207e-01f, 2.05818564e-01f, 1.43705562e-01f,
  2.20810905e-01f, -2.08640292e-01f, 1.82116866e-01f, -2.14093938e-01f, 3.99822503e-01f, 1.92878008e-01f, -2.12510824e-01f, -2.02095374e-01f, -1.39905751e-01f, 1.12537973e-01f,
  -8.62704515e-02f, 2.74377316e-01f, -3.81186754e-02f, 3.85321140e-01f, -1.43860415e-01f, 1.79033369e-01f, -2.31062295e-04f, -7.34976158e-02f, -8.28848928e-02f, -2.62660146e-01f,
  2.52087235e-01f, 6.08409941e-02f, -3.60567565e-03f, 2.31379241e-01f, -2.19344065e-01f, 7.68812969e-02f, -4.93583828e-02f, -1.46218583e-01f, -1.88802287e-01f, 1.45656720e-01f,
  5.70182949e-02f, 2.76224375e-01f, -3.01183850e-01f, 3.25083703e-01f, -2.06713453e-01f, -1.82416886e-01f, -2.50271082e-01f, -1.24389507e-01f, 2.25712612e-01f, -9.47559625e-03f,
  1.39550492e-01f, -3.09568286e-01f, 7.74754677e-03f, -1.19322382e-01f, 1.27263600e-03f, -2.22766817e-01f, 4.86261696e-02f, -1.07805785e-02f, 2.48259857e-01f, -2.08400205e-01f,
  1.74737647e-01f, -2.64912844e-01f, 7.16464892e-02f, -1.84412256e-01f, -3.50377406e-03f, 1.55847564e-01f, 1.46260574e-01f, -9.52857658e-02f, -1.50977494e-02f, -3.52145694e-02f,
  4.87911515e-02f, -1.19812809e-01f, -1.23939393e-02f, 6.60141744e-03f, 3.00129876e-02f, -4.66745906e-02f, -1.11912921e-01f, 1.61276385e-01f, -1.68644577e-01f, 1.02448858e-01f,
  -1.09340578e-01f, 3.04544151e-01f, -3.63325894e-01f, -2.38815486e-01f, -1.81924462e-01f, -3.76467556e-02f, 3.15109074e-01f, 8.41111764e-02f, 1.02695979e-01f, -1.89870015e-01f,
  1.35913417e-01f, 6.19224720e-02f, -3.22391450e-01f, 2.67526686e-01f, -2.98344135e-01f, -2.41973102e-01f, -2.64500584e-02f, -4.02311802e-01f, 1.05165489e-01f, -2.69795895e-01f,
  3.14279377e-01f, -3.41818810e-01f, 2.09155723e-01f, -3.41480076e-01f, -3.15394610e-01f, 1.07853830e-01f, -1.57058284e-01f, -1.54290482e-01f, 1.84562758e-01f, -4.86848712e-01f,
  6.43278807e-02f, 8.32793936e-02f, -3.02736275e-02f, -8.34379718e-02f, 8.39290954e-03f, -4.89733934e-01f, -8.80943835e-02f, 9.06439424e-02f, 8.32017884e-02f, 3.84259224e-02f,
  5.88422967e-03f, -1.64631575e-01f, -1.12145044e-01f, -4.00523633e-01f, -3.93513814e-02f, -2.29157254e-01f, 5.19174077e-02f, 2.28729378e-02f, -2.96093255e-01f, -4.74146456e-02f,
  7.51072690e-02f, 1.18418233e-02f, -2.40339056e-01f, 1.15061849e-02f, 1.22869257e-02f, -4.61604856e-02f, 3.91321667e-02f, -2.02334784e-02f, -5.49512170e-02f, -2.48992175e-01f,
  -1.23725049e-01f, 6.55226409e-02f, -2.61510238e-02f, 3.40890557e-01f, -7.76155591e-02f, 1.79802507e-01f, -1.33685544e-01f, 1.05577253e-01f, -2.26506311e-02f, -2.02686358e-02f,
  -1.23563983e-01f, 1.19844876e-01f, -1.04960218e-01f, -2.40475416e-01f, -4.08576518e-01f, -1.92321867e-01f, 5.51529266e-02f, -4.19352442e-01f, -1.66846365e-01f, -1.90945730e-01f,
  -2.71148920e-01f, -3.42594862e-01f, -3.72483581e-01f, 1.60094842e-01f, -1.36062741e-01f, 2.60357074e-02f, -9.07771438e-02f, 4.76505049e-02f, -3.93914729e-01f, 1.97075084e-01f,
  2.44035736e-01f, -4.23758151e-03f, -1.19479217e-01f, 2.35015392e-01f, -4.45706904e-01f, 1.81806535e-01f, -2.24635407e-01f, 2.90851951e-01f, -7.00977668e-02f, 1.30035922e-01f,
  -4.10376132e-01f, -2.24725351e-01f, 1.21435635e-01f, 8.61912370e-02f, 1.32507995e-01f, -1.36926785e-01f, 1.29173905e-01f, 6.04537427e-02f, 8.58588610e-03f, 4.60392796e-02f,
  -4.48289424e-01f, -1.07845686e-01f, 1.20792806e-01f, -3.31729263e-01f, -1.85976937e-01f, -2.47654781e-01f, -2.74116471e-02f, 2.76924800e-02f, -3.74442190e-02f, 1.57914177e-01f,
  -5.10528758e-02f, 9.16340277e-02f, -1.24612629e-01f, 1.38169244e-01f, 2.88606714e-02f, -1.51123419e-01f, -3.70003790e-01f, 2.40233205e-02f, 1.44606471e-01f, 3.05305541e-01f,
  8.89130682e-02f, -1.49944201e-01f, -4.03497398e-01f, -9.81730688e-03f, 2.61632562e-01f, -7.29154870e-02f, -3.04582059e-01f, 2.42527813e-01f, -2.38597870e-01f, 1.34994268e-01f,
  1.40760154e-01f, 5.25358506e-02f, 2.84277927e-02f, -2.68302679e-01f, 1.10007726e-01f, -2.45642036e-01f, -1.54579297e-01f, -1.99095920e-01f, -2.07999453e-01f, 2.10884899e-01f,
  -2.88773447e-01f, 1.99507207e-01f, -2.00384147e-02f, 1.01845294e-01f, 1.85629539e-02f, -3.05612981e-01f, -1.16429329e-01f, -2.54096746e-01f, 1.21647738e-01f, 1.78176761e-01f,
  2.30887495e-02f, -2.02423587e-01f, 1.28767699e-01f, -3.04578006e-01f, 1.01464115e-01f, -5.24444729e-02f, -4.61927265e-01f, -4.36253175e-02f, 2.07931891e-01f, 1.80100948e-01f,
  -2.58347929e-01f, 1.25738196e-02f, -1.95771128e-01f, 2.75056094e-01f, 1.21678911e-01f, 2.80421637e-02f, -2.18332499e-01f, 3.14770527e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -4.05859901e-03f, -1.35122603e-02f, -3.20581272e-02f, -1.50503963e-01f, -8.12560134e-03f, -9.77278650e-02f, -8.41269642e-02f, 6.79046810e-02f, -7.87132904e-02f, 7.24456608e-02f,
  -1.53929442e-01f, -6.21225908e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    