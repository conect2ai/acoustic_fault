/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.84612048e-01f, -1.95297554e-01f, 9.85069200e-02f, 8.44949558e-02f, -1.68753807e-02f, -1.63715348e-01f, 2.22757906e-02f, -8.67992565e-02f, 5.01167215e-02f, -2.24462971e-01f,
  -1.61945388e-01f, 1.96670011e-01f, -1.14119999e-01f, -2.03196034e-01f, 7.63222575e-02f, -1.11800879e-01f, -1.42374367e-01f, -2.15524789e-02f, 4.00814898e-02f, -2.08327882e-02f,
  -7.96435028e-03f, -1.90905705e-01f, -2.25549955e-02f, -1.29189342e-01f, -1.53722400e-02f, 5.81372418e-02f, -1.12525269e-01f, -2.07403265e-02f, -7.57682547e-02f, 3.61677147e-02f,
  -9.43236612e-03f, 1.69868544e-01f, 4.16194759e-02f, 6.68871477e-02f, -5.14572486e-02f, 3.49157373e-03f, 1.29480585e-02f, 1.05067734e-02f, 2.82405410e-02f, -1.08551001e-02f,
  6.34203181e-02f, -8.95842612e-02f, 8.17683861e-02f, 2.02187672e-02f, -3.09034027e-02f, 4.83481064e-02f, -8.75882283e-02f, -4.24039699e-02f, 5.16365133e-02f, -1.33622224e-02f,
  9.34821740e-03f, -6.24923632e-02f, -3.70705761e-02f, 5.71465082e-02f, 7.42941722e-02f, 3.45622711e-02f, 9.68698505e-03f, 2.36743484e-02f, -1.92987882e-02f, -3.17397602e-02f,
  5.27830645e-02f, -4.59133536e-02f, 4.66116983e-03f, 2.42543290e-03f, -9.80105177e-02f, 5.76292723e-02f, 1.28210494e-02f, 1.52411554e-02f, -3.49368080e-02f, -1.80737842e-02f,
  6.46254346e-02f, 6.18565716e-02f, 4.83120605e-02f, 6.02923110e-02f, -8.23263377e-02f, -3.74039076e-02f, 1.36727661e-01f, 2.65040249e-02f, 4.81513031e-02f, 3.60841639e-02f,
  -7.93610588e-02f, 1.54348984e-02f, 7.30245328e-03f, 3.86128761e-02f, -4.35675029e-03f, 4.14185263e-02f, 1.66791293e-03f, 1.12650059e-01f, 1.24727460e-02f, 5.04503287e-02f,
  -1.86940536e-01f, -1.39444426e-01f, 3.10302209e-02f, -4.09890525e-02f, -5.21103181e-02f, 2.47112792e-02f, -2.75186263e-02f, 2.31346022e-02f, -3.27667743e-02f, -1.03629999e-01f,
  -8.69478006e-03f, -1.10334959e-02f, -1.67619914e-03f, 3.46925929e-02f, 6.15702011e-03f, -9.85181332e-02f, -1.28082052e-01f, -4.31384966e-02f, -9.21015686e-04f, -6.26688674e-02f,
  8.72675609e-03f, -7.60216936e-02f, 5.42170666e-02f, -3.08203250e-02f, -1.76511072e-02f, -1.13871591e-02f, -1.38742421e-02f, 6.36871904e-02f, -1.61467027e-02f, -1.38216361e-01f,
  -8.92959628e-03f, 1.34680271e-01f, -1.77556425e-01f, 1.62712298e-02f, 9.95588079e-02f, -1.48907170e-01f, -3.47585566e-02f, 1.61835730e-01f, -1.18453905e-01f, 2.33014613e-01f,
  6.52241260e-02f, 5.56007214e-02f, -5.97026832e-02f, 3.67855765e-02f, -2.71504790e-01f, -2.49031216e-01f, 5.27768694e-02f, -2.33214647e-02f, -1.55305684e-01f, 2.00688779e-01f,
  -8.53561163e-02f, 1.42939135e-01f, -1.61518276e-01f, 3.48596424e-02f, 1.14712499e-01f, -1.11360184e-03f, 6.19848296e-02f, -6.18495755e-02f, 5.79794496e-02f, -5.44392355e-02f,
  6.58353940e-02f, 2.04046741e-01f, -3.93741298e-03f, -4.50904667e-02f, 5.45826107e-02f, -4.98602390e-02f, -5.93128875e-02f, -1.08393431e-01f, -9.18135867e-02f, -4.33032960e-02f,
  -1.14597887e-01f, 2.24631727e-02f, -9.42482725e-02f, 1.85874216e-02f, 2.21622586e-02f, -1.38046276e-02f, -4.50048000e-02f, -2.99600288e-02f, 7.59939626e-02f, -1.38916103e-02f,
  -1.82549027e-03f, -4.51163910e-02f, 2.13902406e-02f, -4.92850728e-02f, -5.17052151e-02f, -1.44504884e-03f, -1.91613249e-02f, -1.58559028e-02f, 1.54330572e-02f, -6.74962699e-02f,
  -7.59319868e-03f, 2.50418168e-02f, -1.45842284e-01f, 4.91763689e-02f, 2.62362212e-02f, 2.37905234e-02f, 8.29163939e-02f, 2.52867136e-02f, -6.74074963e-02f, 8.49716086e-03f,
  -7.23928288e-02f, 8.18785094e-03f, 8.96695405e-02f, -2.70096641e-02f, -1.06341310e-01f, -6.45132214e-02f, 2.10006069e-03f, 7.65733123e-02f, 1.69660454e-03f, -9.88550037e-02f,
  6.60972372e-02f, -1.14518674e-02f, 1.14989929e-01f, 4.82660346e-02f, -3.11271586e-02f, -1.90009512e-02f, -4.05921601e-02f, 8.93379450e-02f, 4.45488580e-02f, -7.83270672e-02f,
  1.05256803e-01f, 2.23105386e-01f, -8.16315636e-02f, 5.17886952e-02f, 2.72843447e-02f, -7.76165351e-02f, -1.32597163e-01f, -6.91069365e-02f, -9.80580151e-02f, 5.82637498e-03f,
  -3.42165120e-02f, 1.23729780e-01f, 6.07946701e-03f, -3.99952754e-03f, -1.20123088e-01f, -9.56706852e-02f, -2.42709834e-02f, -2.16793679e-02f, 2.56234184e-02f, 5.27013578e-02f,
  6.54446380e-03f, 1.46811130e-03f, 2.10011881e-02f, 1.22910358e-01f, -2.82594003e-02f, 1.18874395e-02f, -4.62942310e-02f, 4.16261656e-03f, -4.07824926e-02f, -7.59500265e-02f,
  -4.72621679e-01f, -1.66011959e-01f, -4.00919355e-02f, -2.27623656e-01f, -1.19721875e-01f, -2.86136884e-02f, 1.35366648e-01f, -1.25973940e-01f, -2.39653006e-01f, 6.01006299e-02f,
  8.41144472e-03f, -6.74670115e-02f, 2.00760141e-01f, -8.28814730e-02f, -8.51371363e-02f, 1.16352968e-01f, -6.69895634e-02f, -1.13276973e-01f, -6.76308423e-02f, -1.57917902e-01f,
  -1.23180464e-01f, -1.04952551e-01f, 1.04277082e-01f, -1.13907762e-01f, -8.11935291e-02f, -1.82115678e-02f, 1.34130582e-01f, 8.78304690e-02f, 3.06712056e-04f, 1.95261203e-02f,
  -1.44749343e-01f, -1.74835429e-01f, -1.23798451e-03f, 1.57864448e-02f, -4.32962291e-02f, 2.25739088e-02f, 1.97774470e-02f, 1.28688753e-01f, 5.40934391e-02f, -6.21387362e-02f,
  1.68009493e-02f, -6.84567988e-02f, -2.11086106e-02f, 2.63308641e-02f, -7.85031244e-02f, -5.76559640e-02f, 2.25839503e-02f, 4.88249511e-02f, -4.60754782e-02f, 2.31097210e-02f,
  -1.36103416e-02f, -4.20735814e-02f, 7.44483992e-02f, -4.97879134e-03f, 1.53695187e-02f, 9.16123856e-03f, 2.89167762e-02f, 6.39643297e-02f, -7.01799318e-02f, -8.92880410e-02f,
  -7.51846358e-02f, -1.20573100e-02f, -1.22697894e-02f, -5.48102846e-03f, -1.85904128e-03f, 3.93827967e-02f, 3.05090379e-02f, 3.15080471e-02f, 8.95910859e-02f, -5.46235479e-02f,
  5.36732050e-03f, 2.77965632e-03f, -6.42754361e-02f, -1.76030546e-02f, -3.08313332e-02f, -7.81152816e-03f, -3.57163362e-02f, -8.84816051e-02f, -8.39717628e-04f, 3.45965549e-02f,
  -9.54585243e-03f, -1.22553261e-03f, -3.05937771e-02f, 7.98176005e-02f, 3.24304625e-02f, 1.08390123e-01f, -1.67900249e-02f, -5.10754995e-02f, 2.59486549e-02f, 4.18377593e-02f,
  -1.09393910e-01f, -2.66233832e-01f, -3.04269348e-03f, 4.34584392e-04f, 7.34704286e-02f, -4.28211875e-02f, 1.79615635e-02f, -4.12248522e-02f, -4.08347026e-02f, -1.67787410e-02f,
  -3.49359550e-02f, 6.30727634e-02f, -1.11339629e-01f, 2.24048868e-02f, 7.18205869e-02f, -3.87676582e-02f, 3.59870121e-02f, -3.22259329e-02f, -2.52394546e-02f, -1.10869016e-03f,
  -6.92893043e-02f, -3.26918550e-02f, -9.81041696e-03f, -5.30197881e-02f, 1.58047024e-02f, -1.73939764e-02f, -6.32844344e-02f, -3.93552817e-02f, 2.98558711e-03f, 2.92670360e-04f,
  -5.28901033e-02f, -2.75991887e-01f, 1.08205736e-01f, 4.15012166e-02f, 4.22248542e-02f, 1.37806967e-01f, 8.62952769e-02f, 2.27457490e-02f, 8.39654654e-02f, -4.68938649e-02f,
  5.55339344e-02f, -2.37437412e-02f, -9.27478522e-02f, 7.14776218e-02f, 1.92907043e-02f, 3.30449045e-02f, 5.47043793e-02f, -3.90618071e-02f, -1.20939482e-02f, -7.36408085e-02f,
  7.79612139e-02f, 9.17240977e-02f, 3.05219665e-02f, -1.64159194e-01f, -4.93058041e-02f, -1.43134803e-01f, -2.08760440e-01f, -8.11646730e-02f, -1.89228763e-03f, 1.36263400e-01f,
  -7.79768378e-02f, -3.18054147e-02f, 3.15591581e-02f, 3.39252539e-02f, -5.71372584e-02f, 1.51022337e-02f, -1.43185323e-02f, -1.47415847e-02f, 2.79089157e-02f, -2.38526668e-02f,
  -1.24014989e-01f, 1.21697243e-02f, 1.17488429e-01f, -4.28586416e-02f, -7.26066828e-02f, -1.35274315e-02f, 2.01672129e-02f, -4.78848070e-02f, 6.28505182e-03f, -3.08701005e-02f,
  -4.22494076e-02f, -4.94871810e-02f, -1.13559909e-01f, -5.59828356e-02f, 3.08117103e-02f, -4.36667204e-02f, 2.79202070e-02f, 2.55688708e-02f, -1.78305302e-02f, 1.13967219e-02f,
  -3.22238281e-02f, -8.30288604e-02f, 2.91929245e-02f, 1.38802808e-02f, -4.89864573e-02f, 1.70099996e-02f, 3.26878615e-02f, 9.00699757e-03f, -9.00601386e-04f, -8.86472091e-02f,
  5.59800193e-02f, 7.51337409e-03f, -7.25695118e-02f, 6.57137781e-02f, -1.50160529e-02f, -2.33638901e-02f, -7.52208158e-02f, 1.70176215e-02f, -1.03683293e-01f, 6.10149503e-02f,
  -1.28737511e-02f, 6.96529597e-02f, 7.55878612e-02f, -3.03708203e-02f, -4.71789837e-02f, 4.64443453e-02f, 3.47985066e-02f, 3.99977341e-02f, 5.12742996e-02f, 3.99158932e-02f,
  -3.33072454e-01f, -2.16659412e-01f, -1.75001717e-03f, -1.21389270e-01f, -1.26822114e-01f, -1.24281809e-01f, 4.44431119e-02f, -1.69485975e-02f, -4.82529737e-02f, -3.98913920e-02f,
  1.71291903e-02f, -2.03042403e-02f, 1.89380832e-02f, -4.57912497e-03f, -3.45221758e-02f, 6.77791461e-02f, 2.45798025e-02f, -1.29189461e-01f, -1.63302235e-02f, -6.30703871e-04f,
  -1.13268435e-01f, -1.98337752e-02f, -6.18853644e-02f, 3.99732031e-02f, -2.61834270e-04f, -1.30346388e-01f, -3.82443517e-02f, 7.09552690e-02f, -1.52222635e-02f, -5.43368049e-02f,
  -3.00495028e-01f, 5.31631289e-03f, 5.17983586e-02f, -1.12278238e-01f, -1.39762819e-01f, -7.01646600e-03f, 9.07007903e-02f, -1.87382698e-01f, -3.58028279e-04f, 2.01110914e-02f,
  -1.18519142e-01f, 1.15350716e-01f, 1.70436278e-01f, -3.53391320e-02f, 1.10728748e-01f, 2.07174078e-01f, -1.92254782e-02f, -4.81392480e-02f, -2.65109595e-02f, -1.14055194e-01f,
  -4.02736701e-02f, -1.11100495e-01f, 1.26384988e-01f, -1.10479981e-01f, -3.61823477e-02f, -1.85220182e-01f, 3.22423177e-04f, 7.97683373e-02f, -2.96627115e-02f, -6.54630885e-02f,
  -7.03776721e-03f, -2.02686191e-02f, -5.60600357e-03f, -5.42845204e-02f, -5.95415570e-03f, -4.11209390e-02f, 7.52587318e-02f, 6.64238259e-02f, 2.47252882e-02f, 7.01929035e-04f,
  1.14020742e-02f, -1.65893976e-02f, 4.18239683e-02f, 6.00424185e-02f, 1.07166335e-01f, 7.75237903e-02f, 2.01145262e-02f, -4.54167882e-03f, 2.34916154e-02f, 7.10281059e-02f,
  1.04098327e-01f, 5.64725175e-02f, -6.51249662e-02f, -4.97125974e-03f, -8.92331824e-02f, -6.33703917e-02f, 7.87399635e-02f, 5.44770248e-02f, 1.48534551e-02f, 3.81023362e-02f,
  -4.94401567e-02f, 5.36680315e-03f, -1.09643685e-02f, 5.45403548e-02f, -1.39109371e-02f, -7.41693974e-02f, -3.57624963e-02f, -7.06054792e-02f, 1.24510154e-01f, 5.47119156e-02f,
  -3.93261462e-02f, -6.78902119e-02f, 1.65956020e-02f, 1.63719766e-02f, -2.39677653e-02f, -4.02298160e-02f, 2.80691292e-02f, -5.44678085e-02f, -1.30152721e-02f, 5.49799502e-02f,
  -1.84733011e-02f, -4.18665707e-02f, -4.03911155e-03f, 1.07003842e-03f, 2.13863924e-02f, -3.01692057e-02f, -2.46287212e-02f, -5.33652790e-02f, 5.48041724e-02f, -8.74789432e-02f,
  -1.06101565e-01f, -1.81005254e-01f, -7.44058862e-02f, -3.72979529e-02f, 7.38997338e-03f, 4.14000452e-02f, 5.38220927e-02f, -7.85076395e-02f, 5.04847569e-03f, 7.24618360e-02f,
  -4.75484766e-02f, -1.51276132e-02f, -5.90277389e-02f, 5.09828478e-02f, 6.16515987e-02f, -5.34057245e-03f, -6.44896254e-02f, -5.38417138e-02f, -6.35775849e-02f, -4.72773947e-02f,
  -2.39410382e-02f, -5.95606454e-02f, -3.91389467e-02f, -6.03233948e-02f, -7.31713846e-02f, 3.70018408e-02f, -4.97563370e-02f, 2.38874834e-02f, -6.79894239e-02f, 3.93396392e-02f,
  3.31053525e-01f, -9.41682607e-02f, -2.69411132e-02f, 1.11372173e-01f, -5.77617772e-02f, 5.58804385e-02f, 2.40809217e-01f, -1.42456487e-01f, 2.20876455e-01f, -7.44432444e-03f,
  -9.99750271e-02f, 1.10335074e-01f, 6.06271774e-02f, -7.88299516e-02f, 1.36535615e-01f, 3.72193307e-02f, -2.11926568e-02f, 5.14324196e-02f, 6.52463958e-02f, 4.16389145e-02f,
  7.20020309e-02f, -4.30687778e-02f, -4.69813310e-02f, -1.08900033e-01f, 1.66961495e-02f, -7.67340288e-02f, -1.96709827e-01f, -1.28534622e-02f, -6.92371204e-02f, 1.09081306e-02f,
  1.05245695e-01f, 7.03159943e-02f, -2.89007667e-02f, 6.68524951e-02f, -9.42908041e-03f, 4.10035960e-02f, 1.95224266e-02f, -4.88766916e-02f, 4.74848673e-02f, -3.96290310e-02f,
  4.02692631e-02f, 3.26600149e-02f, -1.11211754e-01f, 2.55598929e-02f, -1.25438049e-02f, 2.15610187e-03f, 2.56436337e-02f, -5.72888441e-02f, 5.31765446e-02f, -9.65126790e-03f,
  -1.05468139e-01f, -7.83714801e-02f, -5.27571365e-02f, -5.42334169e-02f, -8.08712468e-02f, -2.70828232e-02f, 2.10557003e-02f, -5.41752856e-03f, -2.43199673e-02f, 4.10239538e-03f,
  1.81352168e-01f, 5.92957176e-02f, 3.94330770e-02f, 6.27166629e-02f, -1.48781845e-02f, -5.29009625e-02f, -4.36561108e-02f, -4.52208146e-02f, 1.09021803e-02f, 2.83495560e-02f,
  5.99387884e-02f, -3.42421457e-02f, -1.07769862e-01f, -5.21860346e-02f, 1.38771888e-02f, -1.31778747e-01f, -5.82187884e-02f, -3.55722569e-02f, 4.48892899e-02f, -2.82729603e-02f,
  9.54235718e-03f, -1.13612926e-02f, -7.57872549e-05f, -4.24923375e-02f, -2.52911225e-02f, -5.76807335e-02f, -9.90894064e-03f, 9.51956492e-03f, -5.93991987e-02f, -7.46531934e-02f,
  2.89405999e-03f, 1.30500887e-02f, 4.53222096e-02f, 7.12749511e-02f, 4.97547037e-04f, -4.55577113e-02f, 1.04779184e-01f, 1.85972303e-02f, -2.85600480e-02f, -1.16938343e-02f,
  -2.70753913e-02f, 5.53011894e-02f, -4.20230627e-02f, 1.13144779e-04f, -3.92787158e-02f, -2.84911972e-02f, 1.59238931e-02f, 8.44997633e-03f, -4.94384319e-02f, -6.61303056e-03f,
  -5.96874766e-02f, 9.34579689e-03f, -2.05685832e-02f, 4.33306396e-03f, -1.01194188e-01f, 1.41925523e-02f, 8.06644037e-02f, 1.02746636e-01f, -5.56928180e-02f, 9.05552506e-03f,
  -3.75541985e-01f, -4.01345938e-02f, -9.37151611e-02f, -2.09638141e-02f, -4.44306843e-02f, 2.58141518e-01f, 2.87752479e-01f, -4.13596444e-02f, -1.38340712e-01f, 1.27886936e-01f,
  7.91085139e-02f, -1.07597180e-01f, 1.17249070e-02f, 1.66149318e-01f, 2.16434628e-01f, 1.14544764e-01f, 1.12999089e-01f, 1.29534500e-02f, -7.05659539e-02f, -5.27416803e-02f,
  -9.32547078e-03f, 1.49106488e-01f, 1.18787967e-01f, -5.41426726e-02f, 6.40619770e-02f, -1.69099107e-01f, 1.28110930e-01f, -1.59785114e-02f, 9.98938754e-02f, 8.38193372e-02f,
  -9.96954832e-03f, -3.03404123e-01f, -4.32124361e-02f, -2.43604463e-02f, -5.74664213e-02f, 1.70666911e-02f, 9.81600657e-02f, -1.80580129e-03f, -2.51001026e-02f, -4.63450775e-02f,
  8.28355402e-02f, 5.06448001e-02f, -7.53251165e-02f, -1.05660586e-02f, 6.70412555e-02f, 9.31945071e-03f, 7.93464109e-02f, 1.30344983e-02f, -1.28899096e-02f, 1.05413079e-01f,
  4.55743074e-02f, 5.97255267e-02f, 1.08069340e-02f, 7.25200400e-02f, 4.50599380e-02f, 6.28273115e-02f, -4.54237423e-04f, 1.89453866e-02f, 3.54214795e-02f, -3.94959673e-02f,
  9.65040848e-02f, -8.30635503e-02f, -2.67330091e-02f, -3.18420008e-02f, -9.49987918e-02f, 5.09007126e-02f, -9.50538740e-03f, 3.86448987e-02f, -1.05357952e-02f, 5.48047461e-02f,
  2.70361602e-02f, -9.89412144e-03f, 2.98610087e-02f, 3.97680514e-03f, 8.03030729e-02f, 8.53576418e-03f, -1.03666643e-02f, -4.96270843e-02f, 2.79449783e-02f, 5.14991395e-02f,
  -8.46773200e-03f, 1.50915487e-02f, 9.22027975e-03f, 6.49258271e-02f, 7.40566552e-02f, 2.65771337e-02f, 7.54550993e-02f, 3.21259610e-02f, -9.19705927e-02f, 5.66948690e-02f,
  -4.65391064e-03f, -2.26982728e-01f, -4.36433889e-02f, 2.83153746e-02f, 1.60793979e-02f, 1.04382388e-01f, -3.45051251e-02f, 5.64333685e-02f, -7.80828744e-02f, -3.28538418e-02f,
  3.69725786e-02f, -6.46496490e-02f, 4.65142243e-02f, 7.28817284e-02f, 4.25416976e-02f, 7.28108734e-02f, 9.12365504e-03f, 3.68157290e-02f, 2.05244552e-02f, -3.25496644e-02f,
  1.07188290e-02f, -1.92447603e-02f, -2.86308047e-03f, -1.46443024e-01f, 2.97303870e-02f, 2.77748909e-02f, -3.07779871e-02f, -3.82827371e-02f, -5.34926960e-03f, 4.82746325e-02f,
  2.45854016e-02f, 2.84734704e-02f, -2.67714620e-01f, -4.44920063e-02f, -1.78068742e-01f, 2.77946051e-03f, 1.35164201e-01f, -2.06588134e-01f, -8.79328176e-02f, 3.09934139e-01f,
  1.53390750e-01f, -4.28121015e-02f, 1.40953183e-01f, 1.42298236e-01f, -3.82999098e-03f, 1.33153215e-01f, 1.03157118e-01f, 1.33955544e-02f, -2.12046281e-01f, 6.61749691e-02f,
  -6.16853274e-02f, 2.71997750e-01f, -9.45563912e-02f, -7.89032653e-02f, 6.53570816e-02f, -1.63816437e-01f, 1.90290913e-01f, -2.72109568e-01f, -6.20125495e-02f, -4.61779498e-02f,
  9.86947194e-02f, -6.70403168e-02f, -6.86986968e-02f, -8.51555169e-02f, 1.19367063e-01f, -5.19343466e-03f, 1.51685448e-02f, -8.65513310e-02f, -9.35491920e-02f, 2.90326141e-02f,
  -4.65904847e-02f, 4.09589037e-02f, -2.72771269e-02f, -5.81103973e-02f, -7.33758807e-02f, -2.23646294e-02f, -9.55469832e-02f, -1.15070036e-02f, -9.92604941e-02f, -2.24275719e-02f,
  -3.24199833e-02f, -4.82294448e-02f, -1.59774087e-02f, 8.39251354e-02f, -8.17209706e-02f, -6.23662844e-02f, 5.65164015e-02f, -3.44797820e-02f, 4.10297513e-02f, 1.34753231e-02f,
  3.01799886e-02f, -1.49377182e-01f, -3.41256149e-02f, -6.76120967e-02f, 4.18640897e-02f, -8.31862260e-03f, -1.77784432e-02f, 5.25121987e-02f, -4.59081270e-02f, 1.64463036e-02f,
  -2.59792840e-04f, -6.58538118e-02f, -5.96601814e-02f, -1.53721139e-01f, -2.18808688e-02f, 4.47461121e-02f, -1.18625090e-02f, -3.91647592e-02f, -7.54356198e-03f, -8.31816867e-02f,
  6.27960935e-02f, 2.61124931e-02f, 8.76121819e-02f, 2.56381370e-03f, -2.21759882e-02f, -6.65081739e-02f, 2.85175219e-02f, -6.61977082e-02f, -4.74917442e-02f, 2.22921129e-02f,
  7.79538751e-02f, 5.74230291e-02f, 4.01156917e-02f, 4.17836085e-02f, 3.85308042e-02f, 1.44277036e-01f, -4.84725386e-02f, -4.78445739e-02f, -1.41068444e-01f, 4.33209836e-02f,
  -2.71960925e-02f, -2.26207413e-02f, 1.89866088e-02f, -5.83210140e-02f, -4.44192104e-02f, 3.27500179e-02f, 4.58258651e-02f, 1.13073848e-01f, 1.48611534e-02f, -2.07110308e-02f,
  5.16735837e-02f, 5.51755317e-02f, -5.77947497e-03f, 2.95607168e-02f, 4.50572930e-02f, 6.51483312e-02f, -3.32488418e-02f, -3.79854888e-02f, 8.26970935e-02f, -5.15485108e-02f,
  1.23787418e-01f, -3.85691747e-02f, -1.88602328e-01f, -9.05075222e-02f, 6.66167401e-03f, -3.96340728e-01f, -3.86424422e-01f, 2.43627443e-03f, -2.99230441e-02f, -3.03219706e-02f,
  -7.46616796e-02f, 1.26654327e-01f, -9.19744447e-02f, -1.45180643e-01f, -2.13930398e-01f, -2.04899967e-01f, -1.84377372e-01f, -6.15150109e-02f, 7.90096000e-02f, 3.37006641e-03f,
  -3.49428994e-03f, -2.49137506e-02f, -1.28405526e-01f, 1.14483930e-01f, -5.27209677e-02f, 2.07373068e-01f, 1.52169645e-01f, -1.63946103e-03f, 8.73858761e-03f, -4.50715050e-02f,
  -1.27291501e-01f, -1.63252857e-02f, 8.20692778e-02f, -3.53973806e-02f, -7.60567337e-02f, -1.25337057e-02f, -1.04741774e-01f, -4.50826203e-03f, -3.51544358e-02f, 3.10623795e-02f,
  -5.70652857e-02f, 4.05052826e-02f, -1.84143819e-02f, 3.31356525e-02f, -7.26017654e-02f, 2.73430403e-02f, -7.94989814e-04f, 8.26748461e-02f, 3.28647718e-02f, -4.47907522e-02f,
  1.88097693e-02f, -1.33420015e-02f, -4.70432593e-03f, -4.87828515e-02f, -5.24411015e-02f, 3.52976955e-02f, -7.86709413e-02f, 1.73345450e-02f, -2.54428778e-02f, -1.27223395e-02f,
  5.36383800e-02f, -2.52078623e-02f, -2.47466564e-02f, -8.38050526e-03f, 3.08816526e-02f, -2.70988010e-02f, 8.34583417e-02f, 6.77014515e-02f, 3.41050141e-02f, 4.87644300e-02f,
  -3.49980891e-02f, 6.75408319e-02f, 6.23846147e-03f, 7.53303990e-03f, 4.90751304e-03f, 3.68988514e-02f, 3.40983309e-02f, 1.27417400e-01f, -4.32223119e-02f, -4.01902534e-02f,
  -1.85549899e-03f, 8.97262394e-02f, 2.62729246e-02f, 4.71213423e-02f, -4.31623794e-02f, 9.45650637e-02f, -3.28826793e-02f, -1.72989035e-03f, -5.05900756e-03f, 2.55926736e-02f,
  -4.91417944e-02f, 8.32020268e-02f, 8.49196163e-04f, 2.50589028e-02f, -1.79476757e-02f, -5.00764288e-02f, -1.10333681e-01f, 6.11251332e-02f, -1.88181214e-02f, -4.52698395e-02f,
  -3.23515460e-02f, 2.60340385e-02f, -1.74990967e-02f, 6.52614385e-02f, -4.30763178e-02f, -2.66276468e-02f, -1.08055267e-02f, -3.34372744e-02f, 2.66795419e-02f, 1.77167151e-02f,
  7.20679015e-02f, 2.60851160e-02f, -6.53479993e-02f, 1.79567318e-02f, -2.85824127e-02f, -5.50665967e-02f, -3.49240862e-02f, 8.45578313e-02f, -9.79600381e-03f, -1.83438174e-02f,
  -1.51646793e-01f, 1.12676069e-01f, 1.64332181e-01f, -8.92729685e-02f, -1.65881425e-01f, -9.04719457e-02f, 1.08941972e-01f, -1.98779881e-01f, 9.59935039e-03f, 1.09816045e-01f,
  -1.52705312e-01f, 1.60430500e-03f, 3.18399817e-02f, -2.87416074e-02f, -2.01583624e-01f, 1.36095136e-01f, -3.51006240e-02f, -2.39032358e-02f, 9.78004467e-03f, -6.49816766e-02f,
  -1.68212578e-01f, -1.37005016e-01f, 1.86545346e-02f, -1.00238197e-01f, -4.58504818e-02f, -1.12830184e-01f, -1.79407641e-01f, -1.69541538e-02f, -1.66448399e-01f, 3.13005671e-02f,
  1.54434359e-02f, 4.92966548e-02f, -4.69268635e-02f, 1.02435209e-01f, -4.26889956e-02f, 5.57408147e-02f, 8.49288851e-02f, 2.50488594e-02f, 8.01851880e-03f, -3.18287425e-02f,
  -4.26254310e-02f, -3.39695364e-02f, -1.22983148e-03f, -1.34386672e-02f, 7.29938876e-03f, -3.45327780e-02f, -2.13668365e-02f, -6.52973130e-02f, -1.60611216e-02f, -1.43815763e-02f,
  7.37266615e-02f, 6.99969009e-02f, 1.27602443e-02f, 7.52299279e-02f, -5.50751090e-02f, 5.61008090e-03f, -1.49574399e-03f, -7.87517801e-03f, 3.41485743e-03f, 4.95452667e-03f,
  5.86602325e-03f, 1.74962223e-01f, 5.26717566e-02f, -9.52131115e-03f, -3.69798131e-02f, 3.17611173e-02f, -9.93319005e-02f, -1.03206545e-01f, -3.49437520e-02f, -5.80725900e-04f,
  -2.69082561e-02f, -1.48838997e-01f, -1.93065535e-02f, -4.33928333e-02f, 3.43668163e-02f, 5.59586398e-02f, -2.90793572e-02f, 4.20358032e-02f, 7.02630356e-03f, 1.71402271e-03f,
  3.68733257e-02f, -4.93561663e-02f, 1.16899349e-02f, 8.06213617e-02f, -2.14820113e-02f, -4.97118905e-02f, 2.13150997e-02f, 2.07083095e-02f, -2.97238249e-02f, -5.94687834e-02f,
  -3.37771475e-02f, -1.16383038e-01f, 3.31242383e-02f, 1.39502764e-01f, 1.75240412e-02f, 1.05451671e-02f, 1.28485098e-01f, 1.69263445e-02f, -8.44701454e-02f, 4.21539769e-02f,
  -7.19897002e-02f, 2.91357725e-03f, 8.61251354e-02f, 7.90228043e-03f, 2.22399458e-02f, -6.78988025e-02f, 2.56795622e-02f, -1.00180868e-03f, -8.15350413e-02f, -1.27431881e-02f,
  1.15387794e-02f, -1.47267152e-02f, 6.21430650e-02f, -6.62524849e-02f, 5.85971288e-02f, 6.33784384e-02f, -9.80509222e-02f, -5.87467328e-02f, -1.82076804e-02f, -3.87778729e-02f,
  2.97103971e-01f, -9.67375413e-02f, 4.66834716e-02f, 8.32182840e-02f, 7.18401596e-02f, -2.15458665e-02f, -1.48016900e-01f, 1.39687434e-01f, -1.94430754e-01f, -2.49696940e-01f,
  -7.23357275e-02f, -1.18861847e-01f, -1.38957098e-01f, -4.40423414e-02f, 1.20747276e-01f, -1.48346663e-01f, 5.07754162e-02f, -3.61490548e-02f, -2.31805164e-02f, 1.24201819e-01f,
  1.54221669e-01f, 8.13254490e-02f, 1.29238144e-01f, 1.26232103e-01f, 1.09805517e-01f, 1.49474561e-01f, 2.85123708e-03f, 2.62979288e-02f, 7.50945210e-02f, 2.43169311e-02f,
  -5.02664931e-02f, -3.08077075e-02f, 2.54312083e-02f, 4.61670151e-03f, 1.42172381e-01f, 1.47580817e-01f, 6.21080166e-03f, 3.83988507e-02f, 1.71735436e-02f, -8.66332464e-03f,
  -6.87215328e-02f, -6.08007945e-02f, 1.85079500e-02f, 2.64454633e-04f, -2.17364412e-02f, -3.81771028e-02f, -4.71584201e-02f, -7.27689639e-02f, -5.34675736e-03f, 3.94390337e-02f,
  -3.75395566e-02f, 9.83031020e-02f, -6.37802109e-02f, 9.68961976e-03f, 1.26159294e-02f, -2.28963066e-02f, -1.10766031e-02f, 2.99829077e-02f, -3.37204374e-02f, 1.99010348e-04f,
  5.54078817e-02f, -4.20517996e-02f, -8.13435856e-03f, -5.85229471e-02f, 5.67077734e-02f, -7.95726925e-02f, -7.34432340e-02f, 6.26839772e-02f, -2.17159130e-02f, 2.00919323e-02f,
  2.67484244e-02f, 4.59921733e-02f, -6.62333593e-02f, 2.05492061e-02f, 5.49520738e-02f, -8.82502347e-02f, -1.99563405e-03f, -1.90951098e-02f, -2.47259643e-02f, -3.44564170e-02f,
  -1.37588635e-01f, 9.13532153e-02f, 8.37174157e-05f, -1.09521590e-01f, 1.08478954e-02f, 9.62676257e-02f, 1.40898265e-02f, -2.71101743e-02f, 1.28818082e-03f, 4.73249666e-02f,
  -2.02888553e-03f, -1.85568780e-02f, -4.81991582e-02f, 2.62185652e-03f, -6.19457290e-02f, 3.69280018e-02f, 2.78581437e-02f, -1.86705980e-02f, -2.08031405e-02f, 5.24696559e-02f,
  5.80552183e-02f, -1.13255121e-02f, -1.98560972e-02f, 9.00848582e-02f, 4.58832718e-02f, 1.35770543e-02f, 1.05200047e-02f, -1.04701005e-01f, -5.11429049e-02f, -1.65834501e-02f,
  2.91115511e-02f, -1.87538732e-02f, -3.82585302e-02f, 5.77576086e-02f, -8.58466849e-02f, 9.83186066e-03f, 3.89482384e-03f, 1.93824396e-02f, 6.16558716e-02f, -1.84371062e-02f,
  2.85714895e-01f, 2.14199256e-02f, 1.01839945e-01f, 1.96704030e-01f, 1.70493692e-01f, 1.12220742e-01f, 1.59923270e-01f, 8.50593820e-02f, 2.89205998e-01f, -1.50561944e-01f,
  9.31795910e-02f, -1.62392557e-01f, 1.89200398e-02f, -1.09615676e-01f, -1.33186981e-01f, 1.75897521e-03f, -1.76116871e-03f, -4.57045473e-02f, 1.70283884e-01f, -1.42132580e-01f,
  7.01046661e-02f, -1.92997590e-01f, -1.33497082e-02f, -1.74688548e-01f, -5.57123777e-03f, -6.93089291e-02f, -3.36561382e-01f, -1.05149142e-01f, -2.04478085e-01f, -7.77365416e-02f,
  1.04829580e-01f, 1.06908279e-02f, 1.34720402e-02f, -6.38758857e-03f, -6.64992481e-02f, -1.27911801e-02f, -8.77799392e-02f, -6.88104555e-02f, 1.57797530e-01f, 1.37265557e-02f,
  -9.41503607e-03f, -1.02301314e-01f, -4.74294312e-02f, 1.43999374e-02f, 1.71871379e-01f, 3.18140276e-02f, -3.11463103e-02f, 5.35442680e-02f, 2.43627727e-02f, 2.75348481e-02f,
  5.42829297e-02f, 7.86551163e-02f, 7.76391923e-02f, -1.16425104e-01f, 5.20125329e-02f, 1.03585646e-02f, -8.03882033e-02f, -8.50802884e-02f, -8.49439949e-03f, -7.42214208e-04f,
  3.69688086e-02f, 7.98101723e-02f, -5.60605526e-02f, -2.26775799e-02f, 6.52110130e-02f, -2.71875095e-02f, 1.88065469e-02f, -6.26328140e-02f, 4.12686802e-02f, -3.48496176e-02f,
  -6.41706120e-03f, 6.45521842e-03f, 4.28978577e-02f, 1.31632000e-01f, 2.26986338e-03f, 1.68126670e-03f, 2.99300626e-03f, -6.49979934e-02f, 2.74696983e-02f, 2.40204018e-02f,
  -2.93671689e-03f, -8.35843459e-02f, -1.02857817e-02f, -8.27590935e-03f, 4.10476439e-02f, 6.07528426e-02f, 4.02736031e-02f, 7.79261962e-02f, 2.63926331e-02f, -9.55350623e-02f,
  -1.37214467e-01f, -2.65821546e-01f, -1.55794213e-03f, 6.71292990e-02f, -9.92388278e-03f, -7.38538131e-02f, 3.94981075e-03f, -2.15152316e-02f, -1.81395393e-02f, -4.72999886e-02f,
  -1.05590867e-02f, 7.56559595e-02f, 3.57223209e-03f, -1.95078142e-02f, 9.93625745e-02f, 2.58322507e-02f, 8.75488482e-03f, 5.72432205e-02f, 1.61796026e-02f, -1.73153784e-02f,
  6.27602264e-02f, -4.18943465e-02f, -3.88627946e-02f, 3.10585070e-02f, 3.47883478e-02f, -2.03801226e-02f, -1.93835534e-02f, 1.12337656e-02f, -1.63963158e-03f, -1.61514990e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.31183648e-01f, -1.15626104e-01f, -2.00450763e-01f, -2.14960910e-02f, -1.89517468e-01f, -2.85518169e-02f, -8.30214620e-02f, -1.79270580e-01f, 8.74555632e-02f, -8.95354897e-02f,
  -9.70472619e-02f, 7.22507611e-02f, 1.14306584e-01f, -9.62220281e-02f, 2.52871007e-01f, 1.69414550e-01f, -8.63965452e-02f, -1.45899085e-02f, 1.31087035e-01f, -9.17244330e-02f,
  4.75644283e-02f, -1.37413919e-01f, -1.47043169e-01f, -2.16410130e-01f, -2.70973355e-01f, -2.18720138e-01f, -1.06281616e-01f, -1.22190826e-01f, -2.37776741e-01f, -1.19336791e-01f,
  6.66070357e-02f, 1.13560088e-01f, -3.33705656e-02f, 1.34216070e-01f, 8.96295067e-03f, -9.35112312e-02f, -8.23798999e-02f, -8.26033205e-03f, 5.40949069e-02f, 8.32138509e-02f,
  9.93403345e-02f, 3.30917090e-02f, 8.53555650e-02f, -5.31917103e-02f, -1.17962956e-02f, -3.33272815e-02f, 7.62772486e-02f, -9.83690917e-02f, -8.68550837e-02f, -2.59655863e-02f,
  -3.32948864e-02f, 7.92902485e-02f, -2.95708794e-02f, -6.73171580e-02f, 3.37616690e-02f, 1.66506991e-02f, -8.12363699e-02f, 2.58769449e-02f, 4.01985236e-02f, 2.14909241e-02f,
  -8.81126523e-03f, -1.38263423e-02f, 2.02508457e-02f, -1.03483967e-01f, 2.64648646e-02f, -4.05137464e-02f, -6.05838150e-02f, -4.77990881e-02f, 4.44670059e-02f, -8.80441144e-02f,
  -9.56251621e-02f, -1.07038900e-01f, 1.05055282e-02f, -6.61339313e-02f, -1.58212725e-02f, -2.19186973e-02f, 4.79432754e-02f, -3.91233377e-02f, -5.56074046e-02f, -7.60047585e-02f,
  -1.89205892e-02f, -2.71921940e-02f, -2.93483734e-02f, -6.83171228e-02f, 1.71668306e-02f, 3.75793204e-02f, -5.27907014e-02f, -3.07136076e-03f, 4.90334667e-02f, -5.10720313e-02f,
  1.11378521e-01f, -1.49963424e-02f, 1.91737618e-02f, 2.93081515e-02f, -1.74187310e-02f, -1.08262347e-02f, 4.51831743e-02f, 7.09840804e-02f, 4.64593247e-02f, 1.58937708e-01f,
  -8.14108551e-02f, -4.42170985e-02f, 2.13893279e-02f, 4.49124636e-04f, 7.26224063e-03f, 4.61663604e-02f, 1.09922672e-02f, 9.33156013e-02f, -7.62398019e-02f, 3.90241556e-02f,
  -4.56351638e-02f, -7.75412284e-03f, 5.68210706e-02f, 1.40121534e-01f, -8.02625194e-02f, 3.68616395e-02f, -2.23456044e-02f, -3.64120342e-02f, 5.39591769e-03f, 2.84037460e-02f,
  -3.08010042e-01f, 6.28559813e-02f, 1.00619726e-01f, -2.47352868e-01f, 5.12600951e-02f, -4.34627086e-02f, -1.17186412e-01f, 2.01510377e-02f, 2.90123783e-02f, 8.17292407e-02f,
  -2.82157660e-02f, -3.29886302e-02f, 1.17812544e-01f, -9.64917690e-02f, -6.42495677e-02f, 8.34460333e-02f, -8.84018540e-02f, -9.19809043e-02f, -3.17257680e-02f, -1.72975570e-01f,
  -6.51884973e-02f, -1.58470184e-01f, 2.44827773e-02f, -6.72458932e-02f, -4.80639376e-02f, -8.43155235e-02f, -9.22721252e-02f, -9.41476598e-03f, -1.16502494e-01f, 9.94058102e-02f,
  1.27190337e-01f, 1.26882508e-01f, 1.10033415e-01f, 8.24276172e-03f, 7.42169842e-02f, 2.18010210e-02f, -5.61811030e-03f, 1.05926931e-01f, 8.48708376e-02f, -5.98473027e-02f,
  -5.73831163e-02f, 9.69035253e-02f, -8.33444223e-02f, -1.08748646e-02f, -1.06262498e-01f, 4.06060182e-02f, 3.86860073e-02f, -8.37295689e-03f, 6.67719617e-02f, 9.89503190e-02f,
  -2.02341285e-02f, 1.06117755e-01f, -4.13372070e-02f, -9.49600413e-02f, -7.49105513e-02f, 6.63175359e-02f, -1.95322875e-02f, 8.89035314e-02f, -4.74627428e-02f, -1.37296151e-02f,
  -9.39033702e-02f, -1.70245573e-01f, 5.57448231e-02f, 6.25549033e-02f, 4.75191101e-02f, -2.10688673e-02f, -8.40480328e-02f, 4.47401078e-03f, -2.64481697e-02f, 1.13571575e-03f,
  6.69343993e-02f, -1.93881430e-02f, 1.29969353e-02f, -4.49411646e-02f, -1.68650493e-01f, 1.02563433e-01f, -1.73418242e-02f, 1.63167879e-01f, -7.74671063e-02f, 2.14808434e-02f,
  1.10042468e-02f, -6.22841530e-02f, -3.42277326e-02f, 1.36608137e-02f, 1.52364329e-01f, 8.04222748e-02f, 2.29229592e-02f, 1.65123045e-01f, -4.37235124e-02f, -7.00721592e-02f,
  -4.37065959e-02f, -1.24430031e-01f, 6.76843151e-02f, 3.80282477e-02f, 1.07202701e-01f, -2.85148229e-02f, -5.69744036e-02f, -8.65266249e-02f, -8.73761028e-02f, -7.95052871e-02f,
  -1.74519807e-01f, 2.95218173e-02f, -1.34346277e-01f, -9.74811334e-03f, -4.05340977e-02f, 8.97070318e-02f, -3.26034753e-03f, -3.55220139e-02f, 3.39328907e-02f, 2.01685335e-02f,
  1.94616411e-02f, -9.47099850e-02f, -2.62247194e-02f, -1.20503381e-01f, -9.20906588e-02f, 1.66705158e-02f, 3.71943377e-02f, 4.46941331e-02f, -8.81601870e-02f, -9.50101297e-03f,
  -3.60488474e-01f, -4.55565713e-02f, 5.14490232e-02f, -1.51000813e-01f, -2.06557125e-01f, 7.44783506e-02f, 1.84773043e-01f, -1.30842462e-01f, -2.48989925e-01f, 1.03952333e-01f,
  9.13707912e-02f, -2.27441758e-01f, 2.00353220e-01f, 1.35776311e-01f, -2.31887363e-02f, 2.60254532e-01f, 1.41654909e-01f, -5.43935131e-03f, 4.92742918e-02f, -2.05352735e-02f,
  -1.79265831e-02f, 1.01427034e-01f, 2.48416796e-01f, 4.17796001e-02f, 8.62193778e-02f, -1.25592574e-01f, -9.70404521e-02f, -8.10714252e-03f, 1.43185603e-02f, -4.16167192e-02f,
  1.64086074e-01f, -1.56717449e-01f, 3.65453809e-02f, -5.73101155e-02f, 1.95424184e-02f, 8.86626716e-04f, -3.14524993e-02f, 1.48434530e-03f, -5.47689572e-02f, -9.16424468e-02f,
  -9.42321867e-03f, -8.12142640e-02f, 4.47905771e-02f, -4.21440462e-03f, -1.23425514e-01f, -7.10486919e-02f, -2.59525608e-02f, -7.01558813e-02f, 3.79245616e-02f, 2.86023412e-02f,
  7.54179582e-02f, -2.15497632e-02f, 2.80810203e-02f, 4.21084650e-02f, -4.99154814e-02f, -4.53625657e-02f, 7.13885054e-02f, -7.88905844e-02f, -4.43868861e-02f, -2.84021944e-02f,
  -6.23779632e-02f, 9.55211371e-03f, -7.54639506e-02f, -5.92188425e-02f, 4.71224971e-02f, 1.16856501e-03f, 3.84334438e-02f, -3.56878676e-02f, -9.89794731e-02f, 4.74623144e-02f,
  -2.25144289e-02f, -3.96463051e-02f, -5.43990843e-02f, 1.50731057e-02f, -7.38646388e-02f, 1.64511520e-02f, 2.06559941e-01f, -2.84464378e-03f, 7.06968680e-02f, 1.22721354e-03f,
  -4.59619835e-02f, -3.54892164e-02f, -1.20769493e-01f, 8.92429240e-03f, 4.24043685e-02f, 4.60418500e-02f, 2.82415077e-02f, 6.24322984e-03f, 9.45270211e-02f, 4.17490341e-02f,
  4.55138087e-02f, -2.40642130e-01f, 1.69247203e-02f, -5.12363613e-02f, -4.76648249e-02f, 8.72391649e-03f, 1.29062794e-02f, -4.46466208e-02f, -5.48221767e-02f, -1.35626644e-01f,
  -2.48521212e-02f, -7.28746578e-02f, -1.20378723e-02f, 8.68623331e-02f, -5.71944043e-02f, 4.67215143e-02f, -1.83463432e-02f, -2.39791721e-02f, -5.11285998e-02f, -2.45393254e-02f,
  -5.18573672e-02f, -1.01960905e-01f, 1.13919852e-02f, -6.87226057e-02f, -7.44196847e-02f, -6.98456308e-03f, -9.23878402e-02f, -4.35296707e-02f, -1.51661560e-01f, -2.95005254e-02f,
  -4.44369353e-02f, -2.38944832e-02f, -7.85923302e-02f, -3.87877412e-02f, -9.33718160e-02f, -1.58887386e-01f, -1.53379366e-01f, -4.98978607e-02f, -2.30114534e-02f, -6.80920258e-02f,
  -1.60137042e-01f, -5.67923347e-03f, 7.15856031e-02f, -1.15935080e-01f, 1.39388964e-01f, 1.73458040e-01f, -1.31201133e-01f, -4.12055254e-02f, -3.00013330e-02f, -1.42195657e-01f,
  4.73839827e-02f, -1.94180593e-01f, 1.31498441e-01f, -1.12536781e-01f, -2.17302218e-01f, -9.66396779e-02f, -1.58735234e-02f, -8.11166093e-02f, -9.39049870e-02f, -7.56708831e-02f,
  -5.95545247e-02f, -2.17329785e-02f, -9.82577577e-02f, 7.71466047e-02f, -8.79817456e-02f, -5.45226852e-04f, -2.33728103e-02f, 1.90712623e-02f, 2.49631926e-02f, 2.75788046e-02f,
  1.10775614e-02f, -1.96759333e-03f, -6.51284456e-02f, 3.44045535e-02f, -1.15679484e-02f, -1.52072757e-02f, 4.01902758e-02f, -1.28052374e-02f, 2.41567902e-02f, 8.57708417e-03f,
  -2.69989856e-02f, -8.56372342e-02f, -6.89832717e-02f, 7.80656412e-02f, 4.97570671e-02f, -8.75551850e-02f, 5.63152619e-02f, 8.79879445e-02f, 5.83489463e-02f, -2.13263743e-02f,
  4.09130044e-02f, 1.41948676e-02f, 8.49093720e-02f, -2.48707458e-02f, -2.56653037e-02f, 3.26643810e-02f, -7.72701576e-02f, 1.91793181e-02f, 1.01076895e-02f, 4.31770273e-02f,
  1.38688505e-01f, 9.46249217e-02f, 1.57853384e-02f, 4.05536219e-02f, -6.36661574e-02f, -2.16141529e-02f, -8.27330723e-02f, 1.24310013e-02f, 1.72207821e-02f, 5.01078032e-02f,
  -2.48679542e-04f, -1.04366504e-01f, -6.49766698e-02f, 8.58225599e-02f, 2.80090980e-02f, 8.81307796e-02f, 5.03890999e-02f, 1.41220922e-02f, 1.33468853e-02f, -4.32724655e-02f,
  -6.38878867e-02f, -7.73128271e-02f, -1.81689719e-03f, -3.89013253e-02f, 4.40537184e-03f, 8.46289992e-02f, 2.61027925e-02f, 1.02282446e-02f, -3.91146541e-02f, -1.50872702e-02f,
  -1.18840277e-01f, -8.54328051e-02f, -4.42657340e-03f, -5.80794774e-02f, 2.82229204e-02f, 7.11767096e-03f, -6.19936213e-02f, 5.08281030e-03f, -1.29708294e-02f, -9.73877311e-03f,
  1.46295805e-03f, 2.66867820e-02f, -3.59088071e-02f, -4.60680239e-02f, 2.95012593e-02f, -5.17820120e-02f, 9.57995728e-02f, 6.98141987e-04f, 2.81717181e-02f, -1.00315817e-01f,
  -9.14277434e-02f, -1.59122258e-01f, 6.31152168e-02f, -1.73091143e-01f, 5.14278896e-02f, -3.21785212e-02f, 3.77445519e-02f, -2.47706681e-01f, -1.96302414e-01f, -2.50061005e-01f,
  -4.49067168e-02f, 1.06855899e-01f, 2.54917681e-01f, -2.44791210e-01f, 4.71720606e-01f, 2.06552893e-01f, -9.13054198e-02f, -1.02468207e-01f, 5.88754378e-02f, -2.16699958e-01f,
  -5.39560914e-02f, -1.84829518e-01f, 1.30989119e-01f, -2.97836512e-01f, -1.96349204e-01f, -1.88814253e-01f, -2.97123287e-03f, 1.20047733e-01f, -1.95979550e-01f, 6.53498396e-02f,
  -1.57986749e-02f, 1.92991598e-03f, 2.51655262e-02f, 3.84463146e-02f, -1.03047311e-01f, 1.36567894e-02f, 1.19724713e-01f, 1.20260097e-01f, 5.73528558e-02f, -4.45235800e-03f,
  8.91642272e-02f, 3.38004211e-05f, -3.72713804e-02f, -1.61481537e-02f, -8.86848494e-02f, -7.03249723e-02f, -1.80121530e-02f, -6.98125735e-02f, 1.24631869e-02f, 7.94989690e-02f,
  1.30881695e-02f, 6.88052773e-02f, -3.19702178e-02f, -3.07681318e-02f, -5.60123986e-03f, -5.67881465e-02f, 5.51741607e-02f, 1.22096434e-01f, 5.96793741e-02f, -6.28721938e-02f,
  -7.31768906e-02f, -6.40601292e-02f, 7.84999412e-03f, -1.24516577e-01f, -8.54341984e-02f, -1.50428727e-01f, -1.19695500e-01f, -2.64366698e-02f, -7.21829757e-02f, -2.59434283e-02f,
  2.17446238e-02f, -4.31312546e-02f, 6.21934608e-02f, -1.12167029e-02f, -1.22235276e-01f, -2.89716013e-02f, 3.94652635e-02f, 4.54051010e-02f, -9.32236090e-02f, 6.91636577e-02f,
  -3.40761766e-02f, 4.42449972e-02f, 1.88068785e-02f, 6.87441528e-02f, 5.63491173e-02f, 1.05697319e-01f, 2.25731041e-02f, 1.30997878e-02f, 2.28548087e-02f, 5.53686358e-02f,
  -2.17338186e-02f, -1.52316600e-01f, -5.94381690e-02f, -3.04400269e-02f, 7.73789827e-03f, 9.75694284e-02f, 9.84073337e-03f, -1.30500555e-01f, -6.19954132e-02f, -4.62559126e-02f,
  -2.26660315e-02f, -5.67408316e-02f, 4.52928357e-02f, 2.27948762e-02f, -7.98760504e-02f, -9.01580751e-02f, -6.42818958e-02f, 8.95050615e-02f, -8.20508003e-02f, -3.70066538e-02f,
  -3.19437832e-02f, 1.56028531e-02f, -4.15678099e-02f, -5.93932234e-02f, -5.02987355e-02f, -7.90681094e-02f, 2.15195008e-02f, -9.39568970e-03f, 3.21283303e-02f, -6.57464890e-03f,
  -1.33607581e-01f, -1.65999979e-01f, -2.65697420e-01f, -1.60640955e-01f, -9.55193117e-02f, -3.52577895e-01f, -2.79431790e-01f, -3.61093436e-03f, 1.42340750e-01f, 1.64633244e-01f,
  3.50531600e-02f, -5.53727783e-02f, 1.62726268e-01f, -8.72039050e-02f, -1.60388544e-01f, 1.65773600e-01f, -2.81770319e-01f, -1.13720410e-01f, 4.20579724e-02f, -1.41624585e-01f,
  -9.31669325e-02f, -1.59181841e-02f, -5.29546328e-02f, 7.47922249e-03f, -2.00048476e-01f, -4.62842770e-02f, 1.23654120e-01f, 2.83825919e-02f, -1.87790468e-01f, 7.14750513e-02f,
  -1.20288260e-01f, 1.61680624e-01f, -9.31442436e-03f, -4.30188067e-02f, -4.46101502e-02f, -5.31534329e-02f, -1.00095667e-01f, 1.28919408e-01f, -1.24078849e-02f, -7.69484192e-02f,
  -1.86375808e-02f, 1.44819347e-02f, 3.80001147e-03f, 3.00448295e-02f, 6.67694723e-03f, -3.41456160e-02f, 4.72812019e-02f, -6.52450100e-02f, -1.76757369e-02f, -8.35941732e-02f,
  -6.68608025e-02f, -6.13212436e-02f, -8.96652415e-03f, 1.38495327e-03f, 1.94076505e-02f, 5.93857951e-02f, 5.93334204e-03f, 1.12834750e-02f, -9.41507369e-02f, -7.75771663e-02f,
  9.20140743e-02f, -5.57491705e-02f, -5.63556254e-02f, -1.33885024e-02f, -7.74431005e-02f, 3.33039947e-02f, 4.35539894e-02f, 6.36186600e-02f, 4.75137979e-02f, 4.09960141e-03f,
  -1.87233854e-02f, 4.52124421e-03f, 2.41752109e-03f, -8.12044926e-03f, -7.36925378e-02f, 2.69970465e-02f, 2.91114114e-02f, 2.33165771e-02f, -8.95932838e-02f, -7.21902177e-02f,
  1.43549457e-01f, -1.99764613e-02f, -3.40496600e-02f, 3.59841958e-02f, -4.51833718e-02f, 7.69424066e-02f, -3.20019759e-02f, 1.14200590e-02f, -3.44334473e-03f, -1.39398903e-01f,
  -2.24677697e-02f, -5.93181737e-02f, 1.05235398e-01f, 7.49194995e-02f, 2.98890900e-02f, -2.13062279e-02f, -4.80054580e-02f, -8.76291748e-03f, -5.36920652e-02f, 5.27286343e-02f,
  -1.44846782e-01f, 5.01461029e-02f, -1.86744615e-01f, 1.81529915e-03f, -7.75922672e-04f, -9.26706567e-02f, 2.76883785e-03f, -3.80779915e-02f, -7.70115992e-03f, 1.03990901e-02f,
  9.31946933e-03f, 8.01874995e-02f, 4.38665859e-02f, 5.65216877e-02f, 7.07440600e-02f, -1.08204708e-02f, -2.02019513e-02f, 3.03947274e-02f, -3.59775946e-02f, 2.70268992e-02f,
  -3.10437560e-01f, 1.78575478e-02f, -2.10532352e-01f, -9.86280814e-02f, 5.96575551e-02f, -1.62136286e-01f, -1.11506969e-01f, -4.73963916e-02f, 4.77306917e-02f, 1.84548721e-01f,
  2.47730408e-02f, 3.94617133e-02f, 6.70333281e-02f, -1.13383248e-01f, -3.57785732e-01f, -1.31722510e-01f, -2.37171069e-01f, -4.27309163e-02f, 1.81895401e-02f, -2.24291664e-02f,
  -7.66020194e-02f, 1.62153821e-02f, -2.01890349e-01f, 9.77684557e-02f, -2.37531662e-02f, 1.11331798e-01f, 2.40431592e-01f, 4.62067723e-02f, 1.97956525e-02f, 3.38194519e-02f,
  -8.84176716e-02f, 1.21072106e-01f, 3.08627710e-02f, -1.04243465e-01f, -8.09344575e-02f, 2.93555185e-02f, 4.43973169e-02f, 4.53407504e-03f, 2.68982984e-02f, 3.01374104e-02f,
  8.61670971e-02f, 3.01718824e-02f, 1.27898678e-01f, 2.52102260e-02f, -3.80582027e-02f, 7.06941485e-02f, -3.06951962e-02f, 6.60781143e-03f, -1.22019295e-02f, -9.26149338e-02f,
  4.13373765e-03f, -1.63271707e-02f, 5.07658999e-03f, 4.41804379e-02f, -5.94483204e-02f, 1.39559573e-02f, -4.29201759e-02f, 6.62091607e-03f, -7.02174753e-02f, -4.00400609e-02f,
  -5.84441014e-02f, 1.26122385e-01f, -2.33367328e-02f, -8.81505311e-02f, 7.41796941e-02f, -9.70579684e-04f, 3.62727419e-02f, 8.45765993e-02f, -1.45940557e-02f, 4.10157181e-02f,
  2.00373791e-02f, -6.43401444e-02f, 6.17942885e-02f, 3.00277863e-02f, -9.44385976e-02f, 4.76643890e-02f, -1.86331570e-02f, -2.04979368e-02f, -3.45551968e-02f, -8.65448862e-02f,
  8.50304887e-02f, 4.58041541e-02f, 2.56883190e-03f, 3.76976132e-02f, -4.03332710e-02f, 2.80783381e-02f, -1.18424752e-04f, -3.74985635e-02f, -6.45057112e-03f, 5.26187457e-02f,
  3.87691036e-02f, 1.04505211e-01f, 1.44718047e-02f, 7.69308433e-02f, 5.35746589e-02f, 5.28340191e-02f, -4.24074940e-02f, -5.87575324e-02f, 2.56602443e-03f, -3.51257250e-02f,
  3.82398777e-02f, -3.92802097e-02f, 1.59863550e-02f, 4.63025272e-02f, -5.58762923e-02f, -7.11197965e-03f, -3.83761525e-02f, 6.00017235e-02f, 1.14567876e-02f, 1.58434079e-04f,
  6.01411089e-02f, 7.41404742e-02f, 1.69684533e-02f, -9.53326351e-04f, 5.42720333e-02f, 6.25115559e-02f, 1.27146589e-02f, -6.12271018e-02f, 4.46410924e-02f, 6.11287504e-02f,
  1.87263891e-01f, -1.62846029e-01f, 2.22454503e-01f, 1.90347746e-01f, 1.46703854e-01f, -2.77790148e-02f, 1.37018457e-01f, -1.03448220e-01f, 6.49793446e-02f, -2.45545387e-01f,
  1.45190805e-01f, 9.03728232e-03f, -7.15669245e-02f, -1.19285574e-02f, 5.93415201e-02f, -8.06370601e-02f, -2.87718456e-02f, 2.75503639e-02f, -7.18533918e-02f, 6.91737905e-02f,
  -2.64114421e-03f, -1.35249987e-01f, -1.29342908e-02f, -2.44313389e-01f, 1.21569134e-01f, 4.80281301e-02f, 3.77249904e-02f, 5.75335547e-02f, -8.53866935e-02f, -9.06223524e-03f,
  6.41891956e-02f, -6.09029941e-02f, -1.51209489e-01f, -5.18515222e-02f, 4.27867472e-02f, 1.69547682e-03f, 1.25407111e-02f, 7.38649890e-02f, 8.04537907e-02f, -7.44939446e-02f,
  2.24559773e-02f, 1.92897208e-02f, 1.84257068e-02f, 4.79038060e-02f, -9.14546195e-03f, 1.32287864e-03f, 5.39035872e-02f, -2.38440894e-02f, -6.16002195e-02f, -6.56335242e-03f,
  -8.98173451e-03f, 9.15990770e-02f, 1.21298380e-01f, 1.25188408e-02f, 8.68753791e-02f, -4.84013073e-02f, -3.21050920e-02f, 9.53355283e-02f, -6.50939941e-02f, 1.09242229e-02f,
  -1.58761725e-01f, -5.94550036e-02f, -5.01654036e-02f, 9.33091529e-03f, 6.34451285e-02f, 6.19609356e-02f, 5.48641868e-02f, 8.09577201e-03f, 5.40544949e-02f, 1.81013327e-02f,
  4.51915525e-02f, 2.48271786e-02f, -1.28775509e-02f, 1.79850966e-01f, -7.65490904e-02f, -4.01886925e-02f, 6.60240203e-02f, 9.39722285e-02f, 5.49437478e-02f, -2.01101638e-02f,
  2.38317926e-03f, -4.10825498e-02f, 2.80398298e-02f, 1.54725775e-01f, 7.53780603e-02f, 2.86230072e-02f, 5.97916022e-02f, 8.80986527e-02f, -2.49180775e-02f, -6.98117465e-02f,
  -6.98011667e-02f, -3.41800809e-01f, -4.18047560e-03f, 5.20176291e-02f, -3.09362598e-02f, -8.50552619e-02f, 3.75768654e-02f, -2.98687555e-02f, -9.91290435e-02f, -1.85662676e-02f,
  5.83123304e-02f, 8.99007022e-02f, -2.05061063e-02f, 1.16660960e-01f, -3.65920700e-02f, -2.26686858e-02f, 7.02874288e-02f, -9.94046554e-02f, -2.03214913e-05f, -4.80724350e-02f,
  -2.35186461e-02f, -2.87386440e-02f, -2.93146651e-02f, -5.04028685e-02f, 7.07025528e-02f, -7.49092177e-02f, 1.07662685e-01f, -1.05411582e-01f, 2.93274187e-02f, -3.15821916e-02f,
  -4.84828740e-01f, 2.72042483e-01f, 1.28986642e-01f, -3.23815048e-01f, 1.93792909e-01f, 1.96130678e-01f, -9.66102257e-02f, 1.69862375e-01f, -1.95313826e-01f, 2.21584886e-02f,
  -1.18978947e-01f, -1.06214166e-01f, 2.46401168e-02f, -1.82268634e-01f, -2.72911549e-01f, -1.04037456e-01f, -1.48474827e-01f, -5.75977117e-02f, -4.32770923e-02f, -8.99008065e-02f,
  -9.00202394e-02f, -1.63600951e-01f, 3.38440500e-02f, 1.98067367e-01f, -4.09641303e-03f, 6.35160804e-02f, -7.28698000e-02f, 4.56826650e-02f, 4.61746901e-02f, -3.52955870e-02f,
  -5.10531329e-02f, 4.97397967e-03f, -4.00081277e-03f, 7.99995661e-02f, 3.77234741e-04f, 4.16619107e-02f, 9.98390373e-03f, 3.39076249e-03f, -5.17887324e-02f, 2.08840016e-02f,
  -1.16334772e-02f, 7.00977221e-02f, -8.70244280e-02f, 7.06259534e-03f, 5.19888476e-02f, 9.32367370e-02f, 2.00913727e-01f, 9.58255976e-02f, 4.41211239e-02f, 1.28019780e-01f,
  1.38555765e-01f, -2.30991747e-02f, -3.00121363e-02f, -1.15647405e-01f, 8.68498906e-02f, -2.34573316e-02f, 2.00518575e-02f, 4.94498126e-02f, 6.45089746e-02f, 2.27274690e-02f,
  -2.33072937e-02f, -4.74876724e-02f, 4.75126784e-03f, -2.19462663e-02f, -4.06049378e-02f, 5.25106117e-02f, 3.57019827e-02f, -1.02929519e-02f, 2.47996859e-02f, -6.53958321e-02f,
  -2.72727776e-02f, -3.20821926e-02f, -1.51836760e-02f, -6.58267662e-02f, 5.44736236e-02f, -1.05689369e-01f, 4.28664172e-03f, 7.18961433e-02f, 5.19257598e-02f, -2.61732079e-02f,
  -1.45988744e-02f, -1.74653176e-02f, 8.85252506e-02f, 4.27332334e-02f, -7.68755153e-02f, -8.58982205e-02f, 1.73356524e-03f, 5.55946641e-02f, -7.13203922e-02f, -6.05096817e-02f,
  -6.35645241e-02f, -9.51193422e-02f, -4.86533456e-02f, 9.35473666e-02f, -3.57089192e-02f, -1.27852550e-02f, 8.98402929e-03f, -2.08801460e-02f, -1.26576750e-02f, -1.86208989e-02f,
  5.99140525e-02f, -2.05526818e-02f, -2.00863034e-02f, -2.51387991e-02f, 4.98860143e-02f, 5.35450242e-02f, -5.04735410e-02f, -3.38520147e-02f, 5.18643968e-02f, 6.23174496e-02f,
  2.99987979e-02f, 1.89923253e-02f, 1.69607848e-02f, -6.62690774e-02f, 2.48724762e-02f, -4.44605947e-02f, -4.65691946e-02f, -2.72746943e-02f, 4.07971516e-02f, 2.05695909e-02f,
  2.79326737e-01f, 2.52062321e-01f, 7.68344626e-02f, 1.07099704e-01f, -1.70389354e-01f, -2.30913281e-01f, -3.37710753e-02f, -1.93537641e-02f, 1.71366408e-01f, 6.06836863e-02f,
  -2.33440593e-01f, 4.23040509e-01f, -1.52224034e-01f, 1.08842790e-01f, -2.19631314e-01f, -1.69466987e-01f, -1.05644137e-01f, 3.72769497e-02f, 2.61396747e-02f, -3.11466455e-02f,
  -1.21994186e-02f, -1.38200819e-01f, -7.67150223e-02f, -1.11173853e-01f, -8.06476027e-02f, 5.95581941e-02f, -3.09964538e-01f, -1.32933334e-01f, 1.51455775e-02f, -8.84558260e-02f,
  -1.30508557e-01f, 2.75731422e-02f, 6.47401512e-02f, -1.96649320e-02f, 4.62492136e-03f, 3.00961584e-02f, -3.00698578e-02f, -1.78401262e-01f, -8.85636881e-02f, 8.74359980e-02f,
  1.51000142e-01f, -3.10227070e-02f, -6.50518853e-03f, -1.26213521e-01f, 5.73426299e-02f, 8.95706704e-04f, 1.23390630e-01f, 7.54500553e-02f, -2.16663405e-02f, 5.50731383e-02f,
  2.39965729e-02f, 8.96799415e-02f, -2.35838164e-02f, -9.39660296e-02f, -5.15103452e-02f, 4.76840511e-02f, 2.88013704e-02f, 2.51438338e-02f, 2.30623744e-02f, 6.21290542e-02f,
  9.76731628e-03f, -1.50204804e-02f, 1.19043756e-02f, -3.05222720e-02f, -3.20864841e-02f, 2.82194708e-02f, -4.13582548e-02f, -6.01818748e-02f, 7.36961365e-02f, -2.41639875e-02f,
  -6.67075217e-02f, 7.43136406e-02f, -5.88167943e-02f, -9.42995586e-03f, 9.83277187e-02f, 2.10014153e-02f, 4.08620387e-02f, -2.33386308e-02f, 6.68750629e-02f, 5.70157282e-02f,
  4.63708490e-02f, -1.57692060e-02f, 4.39015701e-02f, -3.90189365e-02f, 6.42898679e-02f, -1.85335837e-02f, 4.70436998e-02f, 1.92389973e-02f, 2.55407263e-02f, -3.42196897e-02f,
  -1.87178075e-01f, -1.33383408e-01f, -1.71546806e-02f, 1.19818345e-01f, 4.14031781e-02f, 1.13290241e-02f, 4.43912260e-02f, -6.31780783e-03f, -9.67607126e-02f, 3.45016606e-02f,
  2.04709042e-02f, -1.19472034e-01f, 4.43864390e-02f, -1.07002266e-01f, 2.00772975e-02f, -8.82463530e-02f, 3.02654132e-03f, 2.38901563e-02f, -2.84315720e-02f, 2.91821621e-02f,
  5.89321293e-02f, 2.66936012e-02f, 3.67832221e-02f, 2.77880188e-02f, 3.41751799e-02f, 6.43076226e-02f, -2.35169437e-02f, 7.79101104e-02f, 2.33322661e-02f, -1.17104789e-02f,
  -2.60538667e-01f, 6.43252879e-02f, -1.23663425e-01f, -1.02777742e-01f, -1.00545205e-01f, -2.49354675e-01f, -1.79293737e-01f, -6.82457874e-04f, -4.70625870e-02f, 1.58793367e-02f,
  -1.31451368e-01f, 1.62422396e-02f, 8.02506730e-02f, -4.67380024e-02f, -5.60072139e-02f, 1.67502344e-01f, -8.92002061e-02f, -1.37732476e-01f, 7.95091167e-02f, -5.58204651e-02f,
  7.77816109e-04f, -1.43424533e-02f, -3.12732682e-02f, 2.00606342e-02f, -1.72991112e-01f, -9.94166732e-02f, -1.85673721e-02f, -1.07543141e-01f, -1.19974814e-01f, -8.66698548e-02f,
  -2.37553209e-01f, -8.83847624e-02f, -5.91398813e-02f, -1.19787015e-01f, -1.93643063e-01f, 2.67639058e-03f, -2.73225475e-02f, 6.26883563e-03f, -1.49836401e-02f, 4.75051813e-02f,
  7.49833733e-02f, 6.21846467e-02f, -1.94588266e-02f, 3.48065272e-02f, -1.44724632e-02f, -6.93522841e-02f, -6.40689060e-02f, 1.12123452e-02f, -7.10577965e-02f, 9.67523083e-03f,
  5.07762358e-02f, -5.72828725e-02f, -1.05259165e-01f, -4.37874906e-02f, 1.63031071e-02f, -1.04336612e-01f, -6.31082132e-02f, 3.21549959e-02f, -2.04199459e-02f, -3.58852968e-02f,
  -3.04956958e-02f, -3.01004853e-02f, -4.10771146e-02f, -1.40467072e-02f, 1.46047110e-02f, 1.91734824e-02f, 5.53848706e-02f, 7.27515817e-02f, 6.19019866e-02f, -8.72475207e-02f,
  -1.30563313e-02f, -9.29448660e-03f, -2.82177478e-02f, -2.92510334e-02f, 3.42577174e-02f, -9.45676789e-02f, -7.97801763e-02f, -8.58019218e-02f, 7.29525089e-02f, -6.24392033e-02f,
  -2.86322180e-02f, -1.59717798e-01f, 1.43825829e-01f, 9.08450484e-02f, -3.80304828e-02f, -3.42241973e-02f, 1.82057675e-02f, -1.02180457e-02f, 1.39380032e-02f, 5.64423241e-02f,
  -3.18109095e-01f, -2.17959851e-01f, -5.61000742e-02f, 1.95154399e-02f, -5.80794960e-02f, 1.44654932e-02f, -2.86701918e-02f, -4.14165109e-02f, -1.00377828e-01f, -1.30351018e-02f,
  1.75522156e-02f, -3.33406366e-02f, -3.70560661e-02f, 1.20307161e-02f, 9.53871310e-02f, -9.59010273e-02f, -1.29468858e-01f, -1.49769317e-02f, -1.53827399e-03f, -8.80049691e-02f,
  3.89039814e-02f, -2.06134208e-02f, 2.81446595e-02f, -3.11419331e-02f, 5.71313798e-02f, -6.50979355e-02f, -2.04605553e-02f, -4.90411706e-02f, -8.46096489e-04f, 9.05620586e-03f,
  1.56236559e-01f, -2.36499578e-01f, -1.07557535e-01f, -5.66511080e-02f, 7.60177523e-02f, 1.16175465e-01f, -1.04010878e-02f, -1.25152588e-01f, -3.07826847e-01f, -2.20226571e-01f,
  2.05333635e-01f, 7.44653493e-02f, 1.01585001e-01f, 3.45681347e-02f, 2.16551974e-01f, -1.24937333e-02f, 6.92159012e-02f, 1.21119142e-01f, -6.45789281e-02f, -2.76298318e-02f,
  -3.77436541e-02f, 1.41321629e-01f, 6.54380694e-02f, -2.38252699e-01f, -3.31007615e-02f, -1.63975194e-01f, -4.91240732e-02f, -6.37538731e-03f, 5.23839034e-02f, 3.75231020e-02f,
  -2.52340101e-02f, -4.13072743e-02f, -3.93501073e-02f, 1.36643630e-02f, -4.73305620e-02f, 3.21104676e-02f, 1.29170995e-02f, 3.14853825e-02f, 1.04116060e-01f, -4.03034166e-02f,
  -2.25618444e-02f, 1.12323642e-01f, 3.32662724e-02f, 3.77568267e-02f, 6.51782006e-02f, 2.57091895e-02f, -1.30242735e-01f, 5.85727170e-02f, -8.03552866e-02f, 4.26777340e-02f,
  -8.01380444e-03f, 4.56132889e-02f, 3.72979678e-02f, -3.01938541e-02f, 1.25868358e-02f, 1.81509163e-02f, -6.82843998e-02f, 1.08243087e-02f, -3.21402960e-02f, -5.79920970e-02f,
  -8.92257318e-02f, -1.91992316e-02f, -1.16418852e-02f, -4.21533734e-02f, 7.29024857e-02f, 4.70817573e-02f, 3.65735926e-02f, 8.02816376e-02f, -7.63583332e-02f, 8.38829875e-02f,
  1.28210008e-01f, 1.84056070e-02f, -1.80457868e-02f, 5.34383468e-02f, 1.43360803e-02f, 7.84201398e-02f, 8.04737881e-02f, -2.59388331e-02f, -9.05724093e-02f, 5.20578539e-03f,
  1.00090271e-02f, 7.65026286e-02f, 6.39708638e-02f, -1.67705864e-02f, -4.00127359e-02f, -6.20575473e-02f, -8.73794034e-02f, -8.10832828e-02f, 1.97549537e-02f, 1.33230269e-01f,
  -5.20553738e-02f, -2.03407437e-01f, -7.97720104e-02f, 6.20156750e-02f, -1.86539274e-02f, -1.28688067e-01f, -8.65998492e-02f, -5.92496917e-02f, 5.62870763e-02f, -2.76178848e-02f,
  2.54716519e-02f, -3.65445651e-02f, 6.17414527e-02f, -5.36250137e-02f, 1.74629949e-02f, 2.85573136e-02f, 6.57440275e-02f, -6.45695534e-03f, -4.92184125e-02f, 6.28178343e-02f,
  6.04569763e-02f, 3.21094058e-02f, -1.86049938e-02f, -1.70992070e-03f, -1.01901717e-01f, 2.93416139e-02f, -9.12875682e-03f, 3.88774872e-02f, 6.98650926e-02f, -1.22870445e-01f,
  -2.29342692e-02f, 1.87956721e-01f, 1.48842081e-01f, -5.06605767e-02f, -6.66642934e-02f, -2.87597161e-02f, -1.29384488e-01f, 8.71898830e-02f, 1.24392375e-01f, 1.95195720e-01f,
  -5.26120700e-02f, 1.31952897e-01f, 2.24805288e-02f, -5.11748865e-02f, -2.52994001e-01f, -4.23398204e-02f, -4.04819697e-02f, -1.76975392e-02f, -1.01186611e-01f, -1.09157182e-01f,
  -1.30294025e-01f, -2.18140155e-01f, -6.50351197e-02f, -2.48015169e-02f, 1.88753307e-02f, 1.12588726e-01f, -8.65851045e-02f, -2.60000993e-02f, 6.35537282e-02f, 6.40471578e-02f,
  -1.72794443e-02f, -4.59802188e-02f, 5.66664860e-02f, 7.56929070e-02f, 8.26010481e-02f, -2.07143929e-02f, 7.10530356e-02f, 1.65695380e-02f, 9.03635919e-02f, 1.42867759e-01f,
  7.07112253e-02f, 1.99496280e-02f, 1.98257901e-02f, -3.62829794e-03f, 8.99634585e-02f, 9.97485146e-02f, 1.84984971e-02f, 3.33144963e-02f, 4.22378965e-02f, -2.67042015e-02f,
  -6.91856295e-02f, 6.82891458e-02f, 2.39460869e-03f, 9.80714038e-02f, -9.07406807e-02f, -3.82782966e-02f, 2.33391188e-02f, 4.87851314e-02f, 2.03307532e-02f, -2.29951758e-02f,
  5.32051623e-02f, -9.49376151e-02f, 3.44463475e-02f, 1.21603362e-01f, -6.31949008e-02f, 4.12368067e-02f, 4.86256601e-03f, -2.61145588e-02f, 1.68742444e-02f, 5.95949404e-02f,
  5.58900274e-02f, -4.78784479e-02f, -4.11656648e-02f, 8.70102551e-03f, -7.36234412e-02f, 1.28201256e-02f, 8.01593065e-02f, 1.16622746e-02f, -8.42800885e-02f, 1.81864668e-02f,
  -6.60165995e-02f, -1.05362587e-01f, -8.85004550e-02f, -5.78218363e-02f, 8.61358121e-02f, 7.30326548e-02f, -4.97113802e-02f, 1.33397177e-01f, -4.33288096e-03f, 1.43420775e-05f,
  -1.13220811e-01f, -1.58170953e-01f, 4.01975736e-02f, -1.64165553e-02f, 4.91618318e-03f, -3.03172413e-02f, 4.88476679e-02f, 8.12071487e-02f, 1.31143322e-02f, 6.23420551e-02f,
  5.84391579e-02f, -6.15539029e-02f, -1.47381891e-02f, 3.59223597e-02f, -5.06634228e-02f, 3.78726721e-02f, 3.32200341e-02f, 3.26530002e-02f, -7.69307166e-02f, 4.17637778e-03f,
  -5.37339337e-02f, 7.04499334e-02f, 6.72158599e-02f, 1.03998780e-02f, 7.99653307e-03f, 5.08612953e-02f, -2.83321622e-03f, 3.77670489e-02f, 1.04753207e-02f, 1.21365990e-02f,
  -2.41181985e-01f, -1.39290988e-01f, -2.85502434e-01f, -3.01797867e-01f, 1.78621009e-01f, -2.97863130e-02f, -1.51056349e-01f, -8.05384829e-04f, -2.20492125e-01f, 1.44250318e-01f,
  1.01861551e-01f, -1.81268573e-01f, 1.31894229e-02f, -2.66224891e-01f, -4.22756374e-01f, -2.63797581e-01f, -3.27822834e-01f, -1.96222156e-01f, -1.41846061e-01f, -1.15245115e-02f,
  -1.92212388e-01f, 2.93146055e-02f, -3.15307826e-01f, 2.15085909e-01f, -1.80211719e-02f, 8.58299062e-02f, 1.92054018e-01f, 1.55388534e-01f, 7.83396438e-02f, 2.03705486e-02f,
  3.24637517e-02f, 3.75760719e-02f, 2.44523678e-02f, -2.77317520e-02f, 4.19278927e-02f, 4.94385324e-02f, 1.12049699e-01f, 3.19584012e-02f, -2.67093629e-02f, -1.19143263e-01f,
  9.14182290e-02f, -1.24912951e-02f, 1.05413549e-01f, -2.51793433e-02f, 5.04768118e-02f, -3.33984457e-02f, -5.62757738e-02f, 6.36185929e-02f, -7.55477846e-02f, 8.31716135e-03f,
  -7.02169910e-02f, -1.53639233e-02f, -9.25629735e-02f, -7.84718171e-02f, -1.45355649e-02f, -2.09092516e-02f, 1.81077160e-02f, 1.60233751e-02f, -8.95826146e-02f, -8.39094073e-02f,
  8.80250931e-02f, -2.81972010e-02f, -7.91589096e-02f, -5.31261228e-02f, -9.34240893e-02f, -5.67586115e-03f, -9.33592916e-02f, 1.35994345e-01f, -1.38048097e-01f, 6.04661368e-02f,
  6.00188831e-03f, -7.74958357e-02f, 4.76430133e-02f, -7.70411566e-02f, 2.00822135e-04f, 1.00250430e-01f, 3.49354446e-02f, 3.11571043e-02f, -6.26719296e-02f, -3.31416503e-02f,
  1.13662519e-01f, -1.17231440e-02f, -5.66005474e-03f, 1.39370352e-01f, -3.60242538e-02f, -2.46191099e-02f, -3.37061845e-02f, 5.82911856e-02f, -1.43518737e-02f, -2.69635245e-02f,
  8.63830000e-02f, 8.34094211e-02f, 1.50201647e-02f, 1.32983364e-02f, 9.06290784e-02f, 5.72882127e-03f, 2.40620486e-02f, -2.10792981e-02f, 2.97225546e-02f, 4.31018285e-02f,
  5.11846542e-02f, -2.20801290e-02f, 1.27872117e-02f, 1.85243953e-02f, -1.16665633e-02f, 3.00122369e-02f, 2.77468581e-02f, 4.79045585e-02f, 4.70323898e-02f, -2.86988504e-02f,
  5.92942126e-02f, 6.85824975e-02f, -1.02919571e-01f, -6.94081839e-03f, 1.74579229e-02f, 6.34709522e-02f, 4.23765667e-02f, 9.65217408e-03f, 4.47465330e-02f, -4.11508000e-03f,
  2.42876410e-01f, -1.40145317e-01f, -6.82577416e-02f, 1.18344791e-01f, 2.36245379e-01f, 1.58878908e-01f, 6.79207072e-02f, 1.32268384e-01f, 2.13647187e-01f, -1.01663597e-01f,
  2.50379592e-02f, -4.62580100e-02f, -1.51654214e-01f, 6.91399863e-03f, 1.65299386e-01f, -3.53971571e-02f, 1.33705094e-01f, 4.09393534e-02f, 3.71425971e-02f, -1.07364483e-01f,
  -3.53559740e-02f, 4.28472161e-02f, -9.14577097e-02f, -9.57114697e-02f, -4.93401289e-02f, -1.85764164e-01f, -1.02333665e-01f, -6.31550327e-02f, -7.18620718e-02f, 7.01751038e-02f,
  7.28834867e-02f, -1.21071516e-02f, -6.98788911e-02f, -3.54199521e-02f, -1.81028675e-02f, -9.06801298e-02f, -7.13052303e-02f, -5.26764840e-02f, 7.62469880e-03f, 1.09063247e-02f,
  -6.94557056e-02f, 5.02873696e-02f, 5.50012030e-02f, -3.95310000e-02f, 7.28842318e-02f, 5.84288836e-02f, -7.93066528e-03f, -2.41684150e-02f, -2.79578008e-02f, -7.35047786e-03f,
  3.86633836e-02f, 7.76287094e-02f, 2.78031174e-02f, -1.18947402e-01f, 2.98992377e-02f, -2.18243990e-02f, -8.32718760e-02f, -5.09149134e-02f, 8.38401541e-02f, -6.06741337e-03f,
  -4.27015461e-02f, -4.89989631e-02f, -1.57330520e-02f, -8.07743520e-02f, 5.49068116e-02f, -1.28129520e-03f, 2.38565560e-02f, 2.30820943e-02f, 9.92533937e-02f, 9.06019360e-02f,
  1.10373899e-01f, 2.68833134e-02f, 1.05764806e-01f, 4.96257506e-02f, -1.18626334e-01f, 1.43348239e-02f, -2.62022042e-03f, 2.61040479e-02f, -3.14075835e-02f, 8.87399260e-03f,
  -1.64156463e-02f, 4.53270450e-02f, 1.20100742e-02f, -4.82336581e-02f, 8.46835822e-02f, 3.74217927e-02f, -3.38544175e-02f, -2.57784612e-02f, -2.16484424e-02f, 4.99754883e-02f,
  -8.78977627e-02f, -2.93402374e-03f, 2.55566183e-02f, -7.03795105e-02f, -6.10063747e-02f, -7.84542859e-02f, -1.33928135e-02f, -9.97659634e-04f, 3.72812264e-02f, -2.20119264e-02f,
  -7.71698207e-02f, -6.31760806e-02f, -2.31719054e-02f, 9.36500542e-03f, -5.49458563e-02f, 8.77245422e-03f, -3.54530588e-02f, -4.66125011e-02f, 7.71180913e-03f, 4.44916449e-02f,
  2.23986134e-02f, 2.46358961e-02f, -1.82507541e-02f, 7.27887899e-02f, -4.88517955e-02f, -6.85229525e-02f, -8.96123350e-02f, 8.29315465e-03f, 2.13156976e-02f, -1.01540990e-01f,
  -2.07466051e-01f, 1.61264762e-01f, -1.27369598e-01f, -2.29736641e-02f, -1.61549926e-01f, 3.97941582e-02f, 2.86428422e-01f, -1.36976361e-01f, -4.16359194e-02f, 3.10555637e-01f,
  1.56443253e-01f, -6.75551817e-02f, 1.48475274e-01f, 2.80628115e-01f, -7.25485571e-03f, 2.34486416e-01f, 1.23766936e-01f, 1.55218780e-01f, -7.22360611e-02f, 3.88573785e-03f,
  -4.50042523e-02f, 1.70530930e-01f, 1.85724974e-01f, -2.89428923e-02f, -4.81317639e-02f, -2.40062699e-01f, -5.68065280e-03f, -1.86535358e-01f, 2.57727355e-02f, -8.04433525e-02f,
  1.00930855e-01f, -3.99102345e-02f, -6.12606518e-02f, 3.84056605e-02f, -2.76724659e-02f, -4.92506437e-02f, -1.54036712e-02f, 8.81707110e-03f, -6.08234107e-02f, 3.60542461e-02f,
  -2.60479860e-02f, -1.03324853e-01f, 3.02888616e-03f, -9.45624262e-02f, 1.71139482e-02f, 4.35902411e-03f, 5.10341441e-03f, 9.69159007e-02f, 4.41911519e-02f, -8.59465450e-03f,
  2.80728377e-02f, 2.19009463e-02f, 4.22191359e-02f, 4.54941057e-02f, 5.34237269e-03f, 6.07662387e-02f, 2.43630055e-02f, -5.44407107e-02f, 2.40143929e-02f, -7.59108514e-02f,
  -1.32140713e-02f, -8.05054232e-02f, 4.15383540e-02f, -1.90342125e-02f, 5.39589785e-02f, 1.24934532e-01f, -7.55834067e-03f, 8.46908055e-03f, -3.63725051e-02f, 1.34022627e-02f,
  7.23016411e-02f, 2.78768633e-02f, -4.00949009e-02f, 2.73064338e-02f, 2.96780895e-02f, -3.65980752e-02f, -7.54842237e-02f, -9.55000147e-02f, 3.39318924e-02f, -4.21373593e-03f,
  4.63629663e-02f, 2.78775338e-02f, 3.43680382e-02f, 2.01138165e-02f, -3.85732204e-02f, -7.76222274e-02f, 6.50085583e-02f, -5.65882735e-02f, 1.09563969e-01f, -5.68644628e-02f,
  5.85642681e-02f, -4.66434546e-02f, 1.11995805e-02f, -2.35529579e-02f, -2.19680090e-02f, -3.17964330e-02f, -6.40763119e-02f, 1.91309005e-02f, -3.85459624e-02f, 2.83730775e-02f,
  -6.07385896e-02f, -9.63309854e-02f, -2.98445132e-02f, -8.41854513e-02f, -9.45885554e-02f, 9.00737569e-02f, 3.26994620e-02f, -3.30374949e-02f, -7.79130869e-03f, -3.88593748e-02f,
  4.97899950e-02f, -4.79317689e-03f, -4.32999246e-02f, 2.92340592e-02f, 2.22548768e-02f, 5.64858243e-02f, -1.81964952e-02f, -7.24966973e-02f, 4.95555103e-02f, -1.92444418e-02f,
  2.67916173e-01f, 5.76953255e-02f, 2.11273566e-01f, 3.20533007e-01f, -1.49218306e-01f, -3.16056460e-01f, -1.32459909e-01f, 1.93099976e-01f, -4.62462194e-03f, -1.71005074e-02f,
  -1.38970753e-02f, 1.23511016e-01f, 2.54374812e-03f, -1.74606312e-02f, 1.13225721e-01f, -1.47350803e-01f, 1.27661854e-01f, -7.62151256e-02f, -3.93724516e-02f, 1.46898448e-01f,
  1.15593717e-01f, 8.76908153e-02f, 3.14165294e-01f, 2.83845514e-01f, 1.14119604e-01f, 1.09774120e-01f, 1.55572280e-01f, 1.39162108e-01f, 5.27866222e-02f, -1.81361120e-02f,
  -1.34172127e-01f, -4.68074605e-02f, 2.58935150e-02f, -6.80771843e-02f, 3.80054303e-02f, 3.56830135e-02f, 2.42297780e-02f, -8.33989829e-02f, -1.90315004e-02f, 9.46069136e-03f,
  -5.84515445e-02f, -1.45385172e-02f, -6.56920969e-02f, -4.23766226e-02f, 2.77580228e-02f, 3.54386717e-02f, -8.16681013e-02f, -5.84902242e-02f, -3.08304522e-02f, 1.14999255e-02f,
  -2.92380508e-02f, -1.31026402e-01f, 1.42334059e-01f, -5.86054139e-02f, 3.00240014e-02f, -5.66156395e-02f, 2.20113546e-02f, -2.32314388e-03f, -4.67471443e-02f, 1.21467166e-01f,
  -1.05126187e-01f, -6.92930771e-04f, 5.97158186e-02f, 7.63073191e-03f, 6.65859133e-03f, -8.53721276e-02f, 1.39146045e-01f, -2.04063981e-04f, 6.89797550e-02f, 6.04386367e-02f,
  -5.66831371e-03f, 6.63727298e-02f, 2.53306665e-02f, -6.16991818e-02f, 3.85361835e-02f, 2.61472389e-02f, 3.02575864e-02f, -7.37038478e-02f, -9.39558633e-03f, 2.99020968e-02f,
  1.52656967e-02f, -3.70131284e-02f, 7.34127546e-03f, -6.14124760e-02f, 8.68079904e-03f, -4.72002067e-02f, 2.08052322e-02f, -5.28504737e-02f, -2.52553402e-03f, 6.39033541e-02f,
  4.84822616e-02f, 1.25937849e-01f, 3.82705703e-02f, -1.10594131e-01f, -8.48296955e-02f, 5.11197597e-02f, -1.30573399e-02f, -9.00568590e-02f, 1.30028307e-01f, -4.79510007e-03f,
  -9.23217759e-02f, 1.34386178e-02f, -6.83008432e-02f, -7.16423765e-02f, -3.59663367e-02f, 8.07624087e-02f, -7.07872510e-02f, 2.40247510e-02f, -2.63383123e-03f, -2.18473971e-02f,
  1.76144782e-02f, -1.50333926e-01f, 1.06162332e-01f, -8.97905678e-02f, -7.67009854e-02f, -7.19731152e-02f, 4.69952412e-02f, 1.16830997e-01f, 9.77472067e-02f, -3.40799503e-02f,
  -3.28335971e-01f, 6.61117509e-02f, -1.81551307e-01f, -1.30103528e-01f, 1.49892652e-02f, -2.43583754e-01f, -1.16534539e-01f, 9.28068385e-02f, -6.98538795e-02f, -9.56427678e-03f,
  -6.64048046e-02f, 3.61021049e-02f, 2.46159509e-02f, -5.11706658e-02f, -1.45663619e-01f, 1.12602182e-01f, -2.03561202e-01f, -2.36777678e-01f, 8.62492248e-02f, -9.10687521e-02f,
  -7.48498142e-02f, 2.27537952e-04f, -4.60634343e-02f, 1.32850155e-01f, -2.04858974e-01f, -8.31421316e-02f, -1.91312984e-01f, 8.45633633e-03f, -2.05370143e-01f, 8.34204815e-03f,
  -9.91263315e-02f, 3.69157270e-02f, 1.73216164e-02f, -1.17248408e-02f, -1.81340933e-01f, -5.96877597e-02f, -1.41490335e-02f, 3.56007251e-03f, -1.43253151e-02f, -6.87554805e-03f,
  -2.57531516e-02f, 4.83344384e-02f, -7.04594254e-02f, 1.05350584e-01f, -4.11167853e-02f, -1.69405397e-02f, 3.61383744e-02f, -8.58710892e-03f, -5.55477105e-02f, -5.36855869e-02f,
  -4.84100282e-02f, 1.33740613e-02f, -4.86855991e-02f, -8.17900524e-02f, -6.93727508e-02f, 4.93798107e-02f, 3.31675187e-02f, 2.40288973e-02f, -5.68297356e-02f, -5.58441095e-02f,
  -1.16741052e-02f, -8.97376705e-03f, -2.62112590e-03f, -3.09877656e-02f, -5.51701570e-03f, 7.14105517e-02f, 6.50566593e-02f, -5.99933751e-02f, 6.39098212e-02f, -3.07498723e-02f,
  3.05314735e-02f, 1.93419363e-02f, 9.26593170e-02f, -6.61441535e-02f, -2.65522972e-02f, -5.92510477e-02f, -9.56574176e-03f, 7.17870938e-03f, 1.86065473e-02f, 4.07934748e-02f,
  5.21552227e-02f, 2.97330599e-02f, -1.51822735e-02f, 4.75028008e-02f, 2.94586271e-02f, -3.12708877e-02f, -3.68344001e-02f, -5.81696332e-02f, -7.09561780e-02f, 3.72535661e-02f,
  -1.49248630e-01f, -1.08980589e-01f, -1.09336886e-03f, 1.33876681e-01f, -9.65113342e-02f, 5.43446466e-02f, 4.18802612e-02f, -4.71301824e-02f, -3.48938704e-02f, 4.99880910e-02f,
  -2.98932511e-02f, -8.80257860e-02f, -1.45039484e-01f, 5.45077510e-02f, 5.62246554e-02f, -3.94357070e-02f, -5.88413887e-02f, 3.31356823e-02f, -6.52215481e-02f, -4.30945493e-02f,
  -1.41387628e-02f, 6.00058734e-02f, 1.67889334e-02f, 1.95621178e-02f, 8.80173594e-02f, -1.07197262e-01f, -9.25945956e-03f, -5.93085252e-02f, -3.63930054e-02f, -6.67750090e-03f,
  -6.18326962e-01f, 2.75280893e-01f, -4.76013124e-02f, -1.51309773e-01f, 1.01528890e-01f, 2.46815383e-02f, 4.31916956e-03f, -7.77660345e-04f, -1.33309558e-01f, 1.29555523e-01f,
  2.67949533e-02f, -1.60975352e-01f, 1.88026170e-03f, 2.70081665e-02f, -1.87827528e-01f, 8.43439996e-02f, 5.84068373e-02f, -1.68056995e-01f, -1.29172690e-02f, -9.94732976e-02f,
  -1.08247595e-02f, -3.42805199e-02f, 3.23689077e-03f, 1.86918378e-01f, -4.18506516e-03f, -1.00270733e-01f, 3.11678909e-02f, -2.00150274e-02f, 8.45234171e-02f, -7.44764460e-04f,
  -2.48564146e-02f, -1.84902087e-01f, -3.46498415e-02f, -1.31304726e-01f, -4.35943939e-02f, -7.14386255e-02f, -7.91912246e-03f, 9.56969522e-03f, -3.34767066e-02f, -9.86777768e-02f,
  -4.41343710e-02f, -2.91504543e-02f, 2.95404661e-02f, 4.19840850e-02f, 1.97537355e-02f, 5.37758395e-02f, 9.27455649e-02f, 4.08904925e-02f, -7.21134692e-02f, -3.22970301e-02f,
  1.43278372e-02f, -2.99284495e-02f, -4.66073081e-02f, 1.89771168e-02f, 4.07418869e-02f, 2.48697922e-02f, -3.82393487e-02f, -1.27848133e-01f, 5.21693341e-02f, 5.58140501e-02f,
  -5.60952257e-03f, -1.17042698e-01f, -1.15443189e-02f, 6.42019808e-02f, -5.63437380e-02f, 6.73274770e-02f, 1.70455016e-02f, -1.38930073e-02f, -2.25357302e-02f, -1.50879379e-02f,
  9.85189155e-03f, 4.93957475e-02f, 3.86812240e-02f, -3.18798348e-02f, -4.81874943e-02f, -3.46659794e-02f, -6.47576898e-02f, -4.98083094e-03f, 4.00412530e-02f, 4.29343656e-02f,
  3.72147188e-02f, 9.56696793e-02f, 5.67439646e-02f, 3.11517771e-02f, 5.06890984e-03f, 1.24901542e-02f, 2.99445186e-02f, 6.78198785e-02f, -1.16563449e-02f, -8.32466758e-04f,
  -8.97970200e-02f, -1.99151307e-01f, -1.97770912e-02f, 5.70811257e-02f, -1.71583071e-02f, -1.12528875e-02f, 5.89106465e-03f, 1.43206036e-02f, -4.96125706e-02f, -5.71652241e-02f,
  -5.80024309e-02f, -1.26973176e-02f, -3.10172647e-04f, -4.69880216e-02f, -2.41636150e-02f, 1.98473837e-02f, -5.65910786e-02f, 1.16037764e-02f, 3.64180356e-02f, -5.17987199e-02f,
  -1.63556989e-02f, -2.17426028e-02f, -1.05877593e-02f, -2.00029127e-02f, -5.14374338e-02f, -5.43932915e-02f, -1.63978375e-02f, -4.53141369e-02f, 1.14399157e-01f, 6.76621646e-02f,
  -1.67878613e-01f, 9.36673284e-02f, -9.18312594e-02f, 4.81420290e-03f, 1.27599761e-02f, -1.98723793e-01f, -1.13736391e-01f, 8.51891283e-03f, -4.23611253e-02f, 1.26801684e-01f,
  9.65772420e-02f, 6.13123402e-02f, -1.91791623e-03f, -5.71350455e-02f, -2.12622643e-01f, -5.90357855e-02f, -1.61586076e-01f, -1.30259246e-01f, -1.28022805e-02f, 9.26206931e-02f,
  -7.68924057e-02f, -2.64880061e-02f, -4.87275310e-02f, 9.62347463e-02f, -1.00465501e-02f, 4.94699888e-02f, 1.75719783e-01f, 1.24082670e-01f, 2.67967265e-02f, -6.10085540e-02f,
  -8.85028467e-02f, 5.03315777e-02f, 8.28106403e-02f, -1.05396569e-01f, -2.25196518e-02f, 1.34353628e-02f, 1.94422994e-02f, 3.44952964e-03f, -8.93908553e-03f, -5.35182506e-02f,
  -1.44987798e-03f, -7.60367662e-02f, 3.05618439e-02f, 2.08416115e-02f, -6.54151738e-02f, 7.68407714e-03f, -1.26907313e-02f, -3.28558125e-02f, -1.07873883e-02f, 2.33091041e-02f,
  -1.63086597e-02f, -7.42377490e-02f, 6.55372888e-02f, -3.35725606e-03f, -7.07189515e-02f, -4.18665335e-02f, -2.17618905e-02f, -5.10044135e-02f, -2.50793379e-02f, -3.94018069e-02f,
  -8.11206475e-02f, 4.79747318e-02f, 3.35390270e-02f, 2.07243674e-03f, -6.19575102e-03f, 4.45176587e-02f, 2.71416511e-02f, -1.45110041e-02f, 3.03168949e-02f, 7.54846260e-02f,
  9.70704667e-03f, 1.08777210e-02f, 1.02554567e-01f, -1.24208806e-02f, -2.54481900e-02f, 5.32251373e-02f, -9.95815452e-03f, 2.79758265e-03f, -7.84163848e-02f, -3.93290818e-02f,
  6.13280945e-02f, 1.38804782e-02f, -1.26587297e-03f, 6.70371950e-02f, -1.38974460e-02f, -3.92661011e-03f, -5.16913831e-02f, -2.65718680e-02f, 2.77795400e-02f, 7.12416023e-02f,
  1.21535407e-02f, 7.08699822e-02f, -5.71439101e-04f, -3.14602512e-04f, 3.73804197e-02f, -1.43255834e-02f, -2.70364862e-02f, -8.18279684e-02f, 9.62298177e-03f, 4.96499203e-02f,
  -5.14259338e-02f, -7.85484463e-02f, -2.32222155e-02f, -2.25330293e-02f, -5.81034794e-02f, -4.45831567e-02f, 5.54615557e-02f, 5.29948100e-02f, 3.17590460e-02f, 4.28348146e-02f,
  1.83520298e-02f, -3.60207520e-02f, -1.31807113e-02f, -5.68269305e-02f, 6.02418818e-02f, -6.63559586e-02f, 1.03101343e-01f, -1.03819266e-01f, 7.92960748e-02f, -1.86531786e-02f,
  -5.28703593e-02f, -6.40699491e-02f, 1.28738508e-01f, -1.10307215e-02f, 1.36818171e-01f, 2.39025548e-01f, -1.65336095e-02f, 1.72633618e-01f, 8.20708424e-02f, -4.97560017e-02f,
  -1.07116237e-01f, -3.67194936e-02f, -3.80795822e-02f, -1.17492983e-02f, 1.62132189e-01f, -1.39250085e-02f, -9.83413402e-03f, -5.10990955e-02f, 2.17372319e-03f, -2.76954584e-02f,
  1.52788998e-03f, -4.14383896e-02f, -3.74599248e-02f, -8.61381590e-02f, -1.88443158e-02f, -7.65603110e-02f, -6.70390725e-02f, 6.87499670e-03f, 4.25167121e-02f, 6.31447807e-02f,
  -1.51269883e-02f, -4.59160693e-02f, -9.87379774e-02f, 8.64240434e-03f, -6.57814965e-02f, -4.79096174e-02f, -6.61692843e-02f, 3.23431119e-02f, 6.91276044e-03f, 3.57014351e-02f,
  -8.50010961e-02f, 2.90751252e-02f, -6.83935061e-02f, -1.37141095e-02f, -9.65042692e-03f, 3.49400155e-02f, -1.65676307e-02f, -6.14490286e-02f, 6.93515241e-02f, 6.81416839e-02f,
  4.77344655e-02f, 1.31503548e-02f, -3.06653995e-02f, -4.40080948e-02f, -2.35811044e-02f, 4.09999788e-02f, 2.83833034e-02f, 3.85248177e-02f, 8.57956409e-02f, -4.20040824e-03f,
  -1.12857539e-02f, -6.82871714e-02f, -3.75597514e-02f, 2.29058675e-02f, 5.97710349e-02f, -5.94840907e-02f, 1.36886723e-02f, 7.44130984e-02f, 3.05188000e-02f, 6.49186447e-02f,
  3.17792082e-03f, 3.56189534e-02f, 1.32833654e-02f, 5.08478917e-02f, -7.31017143e-02f, -3.75457592e-02f, -4.66275029e-02f, 1.53100088e-01f, 8.32163263e-03f, -7.06777498e-02f,
  -4.21158709e-02f, 6.02594726e-02f, 7.13088810e-02f, 3.48111466e-02f, 3.18387598e-02f, 2.72883847e-02f, 1.51115851e-02f, 5.27440906e-02f, -4.66153584e-02f, -7.03764483e-02f,
  -5.48966117e-02f, -2.05642660e-03f, 2.50986740e-02f, -1.89536195e-02f, -3.00605576e-02f, -1.43367156e-01f, -1.25620425e-01f, 7.06563592e-02f, 2.89397724e-02f, 8.37028679e-03f,
  -3.79686654e-02f, -4.07185033e-03f, 5.23415059e-02f, 1.64728928e-02f, -2.30185390e-02f, 9.74388197e-02f, 4.09928933e-02f, 1.24617320e-04f, 1.26545234e-02f, 6.21314906e-02f,
  3.62857617e-02f, -4.02967371e-02f, -2.51807496e-02f, -3.85032371e-02f, -8.37273672e-02f, -1.90051328e-02f, -1.06190303e-02f, 9.30345710e-03f, 4.36268039e-02f, -1.83043573e-02f,
  -3.08119297e-01f, 4.18124311e-02f, -5.06101772e-02f, 1.55876592e-01f, 6.05677925e-02f, 2.43094549e-01f, 3.53504986e-01f, -6.90926835e-02f, 1.73473775e-01f, 2.15241030e-01f,
  1.54839277e-01f, 5.54233156e-02f, -9.28100385e-03f, 1.92339897e-01f, 1.48447016e-02f, 5.14164800e-03f, 7.83554539e-02f, 6.78265542e-02f, -1.09429792e-01f, -7.68437237e-02f,
  -3.39906663e-02f, 4.90116477e-02f, -2.61717886e-02f, -1.43981472e-01f, -2.10233200e-02f, -2.19894379e-01f, 7.20284879e-02f, -6.08400768e-03f, 7.56926537e-02f, 8.66435543e-02f,
  -6.56674653e-02f, -1.20151646e-01f, -3.10051646e-02f, -4.61560767e-03f, -1.36058837e-01f, -1.83287263e-01f, 1.24431802e-02f, 3.05035561e-02f, -3.60401645e-02f, 5.00907889e-03f,
  8.89252722e-02f, -9.94017199e-02f, 2.46327519e-02f, -3.01313344e-02f, -1.56684127e-02f, 8.89695436e-03f, 4.01259400e-03f, -5.40864374e-03f, -2.06430778e-02f, -9.13259313e-02f,
  3.22189666e-02f, 6.13306556e-03f, 4.99593131e-02f, -3.89107652e-02f, -3.03725265e-02f, 1.79842534e-03f, -3.01970709e-02f, -3.09929941e-02f, 9.36321989e-02f, 3.44056748e-02f,
  -3.59675176e-02f, -3.31818908e-02f, 2.41576671e-03f, 5.49188145e-02f, -3.76377366e-02f, -6.63208589e-02f, 4.21748683e-02f, -5.35915978e-02f, -1.34448614e-02f, -6.35962337e-02f,
  -7.36179873e-02f, 9.51521695e-02f, -6.30688444e-02f, -4.24591377e-02f, 1.43530726e-01f, 4.29353565e-02f, 6.95754662e-02f, -2.18086001e-02f, 4.09427620e-02f, 5.84036112e-02f,
  -5.86656071e-02f, -6.67128190e-02f, -2.37083286e-02f, -1.16660967e-01f, -1.01188749e-01f, -4.76327725e-02f, -5.18888831e-02f, -2.60980669e-02f, 8.04008991e-02f, 4.36996184e-02f,
  1.14713371e-01f, 1.34818628e-03f, 1.17590744e-02f, 1.26916468e-02f, -1.53763453e-02f, -1.03180066e-01f, 5.87190986e-02f, -4.23027389e-02f, 1.09310057e-02f, 7.35544339e-02f,
  -4.83600721e-02f, -5.08299423e-03f, -2.38566808e-02f, 4.58802506e-02f, -8.77213106e-03f, 9.18092132e-02f, -1.21032512e-02f, 1.37691069e-02f, 5.44367582e-02f, -1.16904499e-03f,
  4.62491401e-02f, -3.16614434e-02f, -3.71721089e-02f, -5.22691794e-02f, 7.60106146e-02f, 1.97670683e-02f, -9.16431397e-02f, 3.50654610e-02f, -7.61166662e-02f, 2.99992505e-02f,
  3.33881140e-01f, -2.88610786e-01f, -1.13988042e-01f, 3.05960387e-01f, 2.64501572e-01f, -3.77825350e-02f, 3.89180332e-02f, 1.94797546e-01f, 1.95935249e-01f, -1.30753055e-01f,
  -1.73877273e-02f, -2.04421267e-01f, -3.01283747e-01f, 2.12377571e-02f, 7.88607374e-02f, -1.56394199e-01f, 1.16588593e-01f, -1.35256037e-01f, 7.52779394e-02f, 1.50318479e-03f,
  9.05656070e-02f, 1.65737391e-01f, 9.82428640e-02f, 4.96501960e-02f, 1.43640354e-01f, -2.52287574e-02f, 8.25108774e-03f, -9.51714516e-02f, 7.20584542e-02f, -1.42952595e-02f,
  8.66926014e-02f, 4.01831940e-02f, 7.86011368e-02f, -2.37029586e-02f, 1.03233680e-02f, 3.43995425e-03f, -4.01277468e-02f, -5.53070679e-02f, 8.19687620e-02f, -8.21294785e-02f,
  -2.08272338e-01f, 2.92091779e-02f, 4.66048196e-02f, 2.12171711e-02f, 1.63981140e-01f, 6.73899427e-02f, 7.94106126e-02f, 5.08082919e-02f, -7.67841516e-03f, -1.03152186e-01f,
  -1.14412062e-01f, -1.34412512e-01f, 2.86704358e-02f, -7.23667592e-02f, -2.29723155e-02f, 4.19060700e-02f, -7.24669769e-02f, -7.59916976e-02f, -9.20119807e-02f, 1.65216669e-01f,
  1.13907354e-02f, -3.53103988e-02f, 1.72679145e-02f, 2.97199041e-02f, -1.57426167e-02f, 3.23578827e-02f, 7.98643976e-02f, -7.47402757e-02f, -3.87489349e-02f, -1.17272055e-02f,
  -1.14525668e-02f, -3.25712971e-02f, -3.46322618e-02f, 4.64114659e-02f, 2.04331428e-02f, 5.24372011e-02f, 3.31243803e-03f, 1.59324165e-02f, -7.21422583e-02f, 6.80510625e-02f,
  -1.82666983e-02f, -8.10329467e-02f, -7.47565553e-02f, 5.89200817e-02f, 1.36363739e-02f, -4.26650867e-02f, 7.25501105e-02f, -5.47207966e-02f, 6.15908280e-02f, -8.22705552e-02f,
  -3.72630246e-02f, -2.62442559e-01f, -5.79831116e-02f, -2.08250023e-02f, -4.94856872e-02f, 3.43594030e-02f, 3.64719182e-02f, 5.36536910e-02f, -5.24442829e-02f, -5.98223321e-02f,
  6.31974787e-02f, 2.85497233e-02f, -5.03904670e-02f, 3.98732647e-02f, 3.25837843e-02f, 5.70102595e-03f, -5.09888045e-02f, -1.02360975e-02f, 3.22079356e-03f, -1.13029055e-01f,
  -6.92972690e-02f, -6.35778606e-02f, -2.15881616e-02f, 6.60826266e-02f, -1.84716992e-02f, -1.34773314e-01f, -2.53600022e-03f, -6.88339174e-02f, -8.91699493e-02f, 1.55644417e-02f,
  2.90307373e-01f, -3.79523009e-01f, 8.09642822e-02f, 3.46223474e-01f, 3.41764987e-01f, 2.59864144e-02f, 9.54698697e-02f, 2.65208329e-03f, 2.94619083e-01f, -2.21652359e-01f,
  -1.44954026e-02f, -1.69529945e-01f, -9.18875784e-02f, 7.88336843e-02f, 1.20931424e-01f, -1.79099709e-01f, -1.19953062e-02f, -2.06321646e-02f, -6.82677003e-03f, 7.12944493e-02f,
  2.26498768e-01f, 1.11393258e-01f, 4.70197536e-02f, -9.02902856e-02f, 1.26639962e-01f, 6.55267686e-02f, 4.26158533e-02f, -1.46652430e-01f, 2.84276484e-03f, -1.01560121e-02f,
  3.82878445e-02f, 1.82831362e-02f, -1.10495605e-01f, -1.28763273e-01f, 3.27248685e-02f, -3.45851295e-02f, 2.52636317e-02f, -1.72239114e-02f, -3.14416252e-02f, -8.35613757e-02f,
  -4.82559577e-02f, 5.77103496e-02f, 4.67358232e-02f, 2.15901826e-02f, 4.13620379e-03f, 4.98900414e-02f, 3.19335759e-02f, 3.17785442e-02f, -2.43939180e-02f, -2.37799678e-02f,
  5.20713301e-03f, 1.78944543e-02f, -4.22091857e-02f, -2.55044177e-02f, 1.15061261e-01f, 3.46797518e-02f, 3.50218043e-02f, -1.10328294e-01f, -5.82412928e-02f, -4.83251251e-02f,
  -4.05741716e-03f, 1.07377749e-02f, -3.87257226e-02f, -6.63787499e-02f, 2.05788426e-02f, 5.54873906e-02f, 4.81092632e-02f, 9.80009064e-02f, -3.56497765e-02f, -2.04892509e-04f,
  -3.82519513e-02f, 8.08180217e-03f, 6.15274012e-02f, 4.22910377e-02f, -2.53664125e-02f, 7.71455988e-02f, 5.92563450e-02f, 4.74807471e-02f, -3.71748917e-02f, -7.20651150e-02f,
  -1.18250446e-03f, 4.51351777e-02f, -1.28958002e-01f, -2.24779733e-02f, -8.20576958e-03f, -7.02846646e-02f, 3.46088074e-02f, 1.37622226e-02f, 3.75873074e-02f, -6.00400865e-02f,
  -3.04318368e-01f, -1.94464996e-01f, -1.08767457e-01f, -6.47458881e-02f, -5.27317785e-02f, 1.56659435e-03f, -6.26031135e-04f, 4.41213101e-02f, -1.28243595e-01f, -2.18222290e-02f,
  -6.33742381e-03f, -2.68751639e-03f, -4.11015414e-02f, 5.70221767e-02f, -3.90708707e-02f, 2.01922115e-02f, 2.46760417e-02f, -9.43609253e-02f, -1.18402820e-02f, -7.20920265e-02f,
  -8.20319802e-02f, -1.15806079e-02f, -4.41752486e-02f, 1.03363313e-01f, -1.95300113e-02f, -6.75363243e-02f, 9.20153316e-03f, -3.35845426e-02f, -1.72366314e-02f, -5.37446626e-02f,
  2.81141642e-02f, 1.42568201e-01f, 5.42640733e-03f, 1.16096377e-01f, -6.06779568e-02f, -3.11588258e-01f, -1.41657814e-01f, -6.11348711e-02f, 7.89799616e-02f, 1.10770673e-01f,
  -2.54059844e-02f, 3.10510725e-01f, -1.34605244e-01f, 1.20943233e-01f, -2.68522292e-01f, -1.98748261e-01f, -1.17929436e-01f, -5.86435839e-04f, 8.39202628e-02f, -6.70795888e-02f,
  -1.22359328e-01f, -1.62492469e-01f, -7.71535337e-02f, -8.29101652e-02f, 1.16543621e-02f, 8.08032230e-02f, -7.88865387e-02f, -3.61688957e-02f, -1.81096531e-02f, -8.85499567e-02f,
  -6.34716526e-02f, 1.70089126e-01f, 1.49395064e-01f, 1.97636727e-02f, -8.57399851e-02f, -8.51024464e-02f, -6.29427433e-02f, -1.18028577e-02f, 2.01188903e-02f, 5.63665554e-02f,
  -1.03810886e-02f, -1.45375937e-01f, 6.05229214e-02f, -1.33206276e-02f, 2.05728188e-02f, 1.05590709e-01f, 4.38174009e-02f, -9.23069343e-02f, 3.67330350e-02f, 6.18439168e-02f,
  -3.95681038e-02f, 6.23865165e-02f, 5.44870943e-02f, -6.10949472e-02f, -1.79523751e-02f, 4.77375053e-02f, -5.13606183e-02f, -1.03250388e-02f, -3.01965605e-02f, 6.83995485e-02f,
  3.15219462e-02f, 6.48586527e-02f, 2.43585240e-02f, 8.97274688e-02f, -3.66180427e-02f, 2.49206610e-02f, -1.67027730e-02f, 1.29131526e-02f, -2.35782508e-02f, -9.80878174e-02f,
  -1.72780396e-03f, 7.22323954e-02f, 1.04783006e-01f, 6.14386611e-03f, 1.07430601e-02f, 9.80877504e-02f, -2.33718362e-02f, -1.10544264e-01f, -2.36321725e-02f, 1.15266489e-02f,
  3.54966372e-02f, -5.04922681e-02f, 1.23506635e-02f, 1.69863962e-02f, -6.23989068e-02f, 3.42536569e-02f, 2.29661781e-02f, -5.85521795e-02f, 3.17994803e-02f, 3.67531669e-03f,
  -1.30713850e-01f, -1.15542196e-01f, -2.56975684e-02f, -7.42702419e-03f, -4.20535877e-02f, 5.63079603e-02f, -2.39841361e-02f, -3.32500823e-02f, 1.23699838e-02f, -1.93243157e-02f,
  -7.83512741e-02f, -1.25823259e-01f, -6.60828054e-02f, -8.98563191e-02f, 3.51157449e-02f, -1.30129615e-02f, -5.28234877e-02f, -1.05474539e-01f, 4.76734750e-02f, 5.65258376e-02f,
  -2.14116219e-02f, 8.25366005e-02f, 6.25203624e-02f, 1.67344753e-02f, -6.29390962e-03f, 5.92052983e-03f, 4.70407717e-02f, -3.78119247e-03f, -1.34553174e-02f, -2.36145221e-02f,
  -2.05373704e-01f, 2.54840821e-01f, 1.64954215e-01f, -1.32715821e-01f, 1.34475350e-01f, -3.40163056e-03f, 3.77208814e-02f, 8.39347541e-02f, 8.22031796e-02f, -1.10070542e-01f,
  -1.47520378e-01f, 5.03846779e-02f, 3.49406675e-02f, -6.54565403e-04f, -1.19757034e-01f, 5.93176745e-02f, -1.28010586e-01f, -1.00823477e-01f, 7.77653530e-02f, -3.48621281e-03f,
  3.84698883e-02f, -1.83296949e-01f, -3.27448845e-02f, 4.67071012e-02f, -6.64583081e-03f, -7.25014508e-02f, -2.63922900e-01f, 2.01101638e-02f, 6.44967854e-02f, 8.95410255e-02f,
  -2.56043673e-02f, -5.61645813e-02f, 1.51344404e-01f, 2.95859277e-02f, -7.59128481e-02f, -3.28588486e-02f, 5.51009364e-02f, 4.30582650e-02f, 8.80130231e-02f, 4.54378650e-02f,
  -4.79472149e-03f, -1.18356876e-01f, 6.27925098e-02f, 2.07524318e-02f, 4.06568535e-02f, 5.97336330e-02f, -3.96723412e-02f, -1.87786911e-02f, 3.47822458e-02f, -4.55778576e-02f,
  2.17507221e-02f, 1.79026090e-02f, 3.33767757e-02f, -8.69978666e-02f, -5.11553399e-02f, -2.86504887e-02f, 5.84589317e-02f, -2.16324367e-02f, -1.93294361e-02f, -4.19448242e-02f,
  -4.76316512e-02f, -7.43428469e-02f, 5.21437824e-02f, 1.24389179e-01f, 4.74236384e-02f, 8.93205628e-02f, 2.56083906e-02f, -6.83028549e-02f, -3.97627568e-03f, -3.61041538e-02f,
  2.45161057e-02f, -5.97730465e-03f, 3.40171121e-02f, -9.23939496e-02f, -3.92739065e-02f, -3.08029242e-02f, 4.15375046e-02f, 2.74223760e-02f, 2.66505349e-02f, -8.41157660e-02f,
  -1.25672176e-01f, -3.06175314e-02f, -5.98581210e-02f, 4.13198769e-03f, 1.50447354e-01f, 6.81431906e-04f, -1.84320156e-02f, 4.48442698e-02f, -8.57428908e-02f, -6.54838383e-02f,
  -7.36875013e-02f, -2.36227900e-01f, 3.75075005e-02f, -1.44613395e-02f, -1.12187989e-01f, 1.66384522e-02f, 2.38878578e-02f, 4.24446985e-02f, 4.92240973e-02f, -5.31816250e-03f,
  -3.13450433e-02f, -4.70140614e-02f, -7.12681189e-02f, 2.33077947e-02f, -1.68110412e-02f, -7.71204103e-03f, -5.28226011e-02f, -5.40176891e-02f, -7.53433257e-02f, 2.26285011e-02f,
  -5.24311811e-02f, 8.90290271e-03f, -1.65793914e-02f, -1.35460943e-01f, 1.13578455e-03f, 3.14026028e-02f, 9.46930796e-03f, 3.72059643e-02f, -7.13891909e-02f, 3.02891657e-02f,
  -4.00305480e-01f, 1.68068722e-01f, -7.53402859e-02f, -1.84462979e-01f, -3.59638631e-02f, -2.13251263e-01f, -1.19024761e-01f, -2.94527449e-02f, -1.85938440e-02f, 4.92978729e-02f,
  2.09667627e-02f, -1.02768138e-01f, 1.31545946e-01f, 5.64669929e-02f, -1.65641323e-01f, 8.29580501e-02f, -9.54021439e-02f, -5.14397696e-02f, 1.12610742e-01f, -2.08835350e-03f,
  -8.79366919e-02f, 4.64326926e-02f, 4.54227300e-03f, 1.62472710e-01f, -5.68521991e-02f, -8.06751922e-02f, -5.15934005e-02f, 8.74920860e-02f, 2.77059134e-02f, -4.17133421e-02f,
  -2.02707902e-01f, -9.46796536e-02f, -1.52124181e-01f, -1.00886926e-01f, -1.52691543e-01f, -4.83953543e-02f, -1.01052336e-01f, 3.67704257e-02f, -1.16274349e-01f, 8.64862427e-02f,
  -1.02527281e-02f, 2.12264387e-03f, -3.29349563e-02f, 3.09051364e-03f, -1.25619024e-02f, -3.62853222e-02f, 3.32788415e-02f, -5.98882278e-03f, -5.48159182e-02f, -8.10182244e-02f,
  -1.42586359e-03f, -5.13139032e-02f, -3.29076312e-02f, 3.51071991e-02f, 5.88172674e-02f, 2.81918030e-02f, -6.00848496e-02f, 4.10944037e-02f, -1.12068832e-01f, -4.25892044e-03f,
  2.86401641e-02f, 1.20965368e-03f, -4.80940267e-02f, 2.32054833e-02f, -3.49365063e-02f, 3.29265022e-03f, -1.47250816e-02f, 2.00213585e-02f, -4.54412065e-02f, -8.56898129e-02f,
  2.57557184e-02f, -4.81820703e-02f, 6.17688447e-02f, -1.79027356e-02f, 3.04137226e-02f, -4.90312427e-02f, 8.04688036e-02f, 4.27807961e-03f, -2.54865270e-02f, 5.53363971e-02f,
  8.10429081e-02f, 5.41180447e-02f, -5.09494618e-02f, -8.10429454e-02f, -3.77087630e-02f, 8.24928284e-02f, 2.70892289e-02f, -1.84324048e-02f, -3.27047259e-02f, 2.71980651e-02f,
  -3.20002288e-01f, -2.96553195e-01f, -6.05806671e-02f, -6.57347590e-02f, 2.15503369e-02f, -1.25737250e-01f, -3.73734087e-02f, -1.80354938e-02f, -6.86004609e-02f, 1.04022734e-02f,
  -6.19279817e-02f, -4.63200510e-02f, -9.28836986e-02f, -3.99651639e-02f, -3.05167977e-02f, -5.76955527e-02f, 3.63346701e-03f, 6.88310191e-02f, -4.32768203e-02f, -1.00979291e-01f,
  -3.48118171e-02f, -1.12124393e-02f, 3.92551348e-02f, -5.85943907e-02f, 3.71213444e-02f, -4.64053862e-02f, -5.99776618e-02f, -8.95532891e-02f, 2.94381771e-02f, 1.03376843e-02f,
  -1.14251241e-01f, -3.38502377e-01f, 3.19407165e-01f, -1.52843967e-01f, 1.52806655e-01f, 1.34290740e-01f, 1.85065288e-02f, -3.97103429e-02f, -2.77574360e-01f, -2.32270345e-01f,
  -7.06252754e-02f, -4.63182256e-02f, -3.56491692e-02f, -1.21013828e-01f, 3.68413657e-01f, 1.74003094e-02f, -1.35003021e-02f, -2.71108616e-02f, 8.17028135e-02f, -3.32941972e-02f,
  5.06170616e-02f, -1.40180904e-03f, 2.23431587e-01f, 3.45172547e-02f, 6.42294362e-02f, -1.73034538e-02f, -4.71396744e-02f, 1.55513287e-01f, 1.33226737e-01f, 2.42501453e-01f,
  -1.22365601e-01f, -2.02968627e-01f, -8.03445950e-02f, -4.48373668e-02f, 9.94512811e-02f, -4.55538258e-02f, -4.18808758e-02f, 1.05234191e-01f, -3.12914327e-02f, 2.89991945e-02f,
  9.72634852e-02f, -3.87376882e-02f, -1.40259753e-03f, 4.22279462e-02f, -6.43712133e-02f, 8.83066282e-03f, 2.03817394e-02f, -1.56859588e-02f, 5.67025840e-02f, 1.58137716e-02f,
  5.00226989e-02f, -3.21679264e-02f, -1.04814537e-01f, 3.77233326e-02f, 3.39926258e-02f, 4.09256555e-02f, 4.45959484e-03f, 1.00313149e-01f, -1.16242180e-02f, 1.94359403e-02f,
  8.77209231e-02f, 6.66996911e-02f, -3.03014182e-02f, -1.66173484e-02f, 1.35584213e-02f, -1.12961745e-02f, -3.11579276e-02f, 2.03979425e-02f, -1.26028750e-02f, -8.35157558e-03f,
  3.59636024e-02f, -1.67276915e-02f, -1.04195863e-01f, -1.56664774e-02f, 5.47629707e-02f, -4.38734107e-02f, 1.58531275e-02f, -7.12565929e-02f, 1.09768949e-01f, 9.51680541e-02f,
  -5.90336137e-02f, 6.58398345e-02f, -2.14422820e-03f, 5.45014115e-03f, -3.04291118e-02f, -6.58895299e-02f, -1.04946002e-01f, -6.63595423e-02f, -8.72726813e-02f, 9.35114697e-02f,
  -4.20695245e-01f, -3.73211205e-01f, 4.47056219e-02f, -4.32199314e-02f, -6.68336675e-02f, -1.47583485e-01f, -3.89251597e-02f, -5.39331138e-03f, -8.54485929e-02f, 3.36000025e-02f,
  -6.13510842e-03f, 6.60310835e-02f, -1.04419507e-01f, 8.54875296e-02f, 8.25703368e-02f, -1.17469169e-01f, -1.08643278e-01f, -4.22780961e-02f, -1.22134246e-01f, -3.93508784e-02f,
  -5.05109206e-02f, -3.89888175e-02f, 9.95572135e-02f, 4.70640026e-02f, 2.06568204e-02f, -3.82239707e-02f, -1.36350689e-03f, -8.62936303e-02f, 1.30335495e-01f, 1.31917847e-02f,
  2.74236381e-01f, -8.01173002e-02f, -6.48232698e-02f, 6.25422895e-02f, 1.04348987e-01f, 9.42103118e-02f, 9.31560919e-02f, 9.13887694e-02f, 4.67526307e-03f, -1.18708469e-01f,
  -6.20081723e-02f, -8.45232010e-02f, -6.55982867e-02f, 1.48500716e-02f, 2.22065121e-01f, -9.55671519e-02f, 1.20799482e-01f, 9.50374827e-03f, -1.18331723e-01f, -4.31486219e-02f,
  4.31288406e-02f, 1.58229351e-01f, -6.12934828e-02f, 1.18132360e-01f, 1.50852457e-01f, 1.00885242e-01f, 4.97352332e-02f, 7.70692080e-02f, 5.95932268e-02f, 1.13013387e-02f,
  3.42033319e-02f, 1.80695690e-02f, -1.22089824e-02f, -1.94545165e-02f, 1.06779588e-02f, 2.03016177e-02f, -7.47141391e-02f, 3.92320976e-02f, 1.67673137e-02f, -2.75911521e-02f,
  1.45997964e-02f, -5.57119139e-02f, 4.62464765e-02f, 7.21412003e-02f, -2.35660914e-02f, -2.92802155e-02f, -1.15152068e-01f, -8.07315931e-02f, 4.11728723e-03f, -5.43304197e-02f,
  -3.95464897e-02f, -5.94559088e-02f, -4.58715670e-02f, 1.78148318e-02f, 4.21601646e-02f, 2.03746594e-02f, 1.13534294e-02f, -3.91581766e-02f, -3.96828400e-03f, -5.13197780e-02f,
  1.41210258e-01f, -3.56076378e-03f, -5.53960577e-02f, -9.47921947e-02f, -7.46925175e-02f, -1.02738872e-01f, -1.76681280e-02f, -5.37381023e-02f, 4.48745675e-02f, 2.31109597e-02f,
  -1.02355219e-01f, 1.95097011e-02f, -5.45723364e-02f, 4.94262241e-02f, -1.64590403e-02f, 6.68086484e-03f, -7.59044960e-02f, -6.57621259e-03f, 3.08030173e-02f, -6.60930201e-02f,
  1.34271346e-02f, 1.96305495e-02f, -5.67223057e-02f, 1.71923416e-03f, 1.66203290e-01f, -1.42902164e-02f, -2.62446217e-02f, -8.10675099e-02f, -4.51814719e-02f, -7.65868127e-02f,
  1.47896702e-03f, 2.20404826e-02f, 4.95091565e-02f, -1.32651487e-02f, -8.08672234e-03f, -5.21493629e-02f, -1.69915501e-02f, 2.51482036e-02f, -9.14378762e-02f, -5.86733222e-02f,
  7.65228495e-02f, -4.99668419e-02f, 4.12075035e-02f, 4.79803570e-02f, 9.56740789e-03f, -7.27138892e-02f, 4.13829535e-02f, 1.82209872e-02f, 3.47548313e-02f, -2.91178748e-02f,
  2.92634033e-03f, 4.99164201e-02f, -2.99195573e-02f, 1.26396511e-02f, 6.41169325e-02f, -5.90430514e-04f, 2.82218885e-02f, 2.75952499e-02f, 4.84343804e-03f, -4.26729992e-02f,
  2.28449464e-01f, 9.98704061e-02f, 9.57242548e-02f, 2.70950913e-01f, 5.24331164e-03f, -9.63817835e-02f, -2.36787289e-01f, 1.64356172e-01f, 1.98440969e-01f, -1.75839394e-01f,
  5.34999445e-02f, -4.37840037e-02f, -2.52765715e-02f, 2.31449664e-01f, 1.68415815e-01f, 5.08142225e-02f, 1.43655956e-01f, 6.65761828e-02f, 1.03578538e-01f, 1.48699462e-01f,
  3.08322996e-01f, 1.51380673e-01f, 5.78212999e-02f, -4.70981933e-02f, 2.60283914e-03f, 4.94169742e-02f, -5.14625534e-02f, -1.29677996e-01f, 3.90290958e-03f, -2.17154436e-02f,
  -4.58573848e-02f, 1.37342885e-01f, 3.24169137e-02f, 5.35834208e-03f, -2.79069990e-02f, -1.39046088e-01f, -5.06209880e-02f, -6.65480271e-02f, -7.35594854e-02f, 1.72897689e-02f,
  -1.48307206e-02f, 1.34052020e-02f, 3.53768244e-02f, 3.14199179e-02f, -9.87536088e-02f, 6.31583631e-02f, 7.26492032e-02f, 7.12647587e-02f, 6.92151710e-02f, 9.85203162e-02f,
  4.84152026e-02f, -4.89230044e-02f, -6.79625496e-02f, -3.16094607e-02f, 1.65669352e-01f, 7.50939772e-02f, 9.13582928e-03f, -1.76513400e-02f, -1.14241466e-01f, 5.02019785e-02f,
  4.06986922e-02f, -1.24742381e-01f, -1.25249624e-01f, -1.07929826e-01f, 1.36565398e-02f, -8.89438689e-02f, 2.95556672e-02f, -2.86439694e-02f, -7.37875029e-02f, -5.44728860e-02f,
  -3.93548757e-02f, 3.18890139e-02f, 2.98085380e-02f, -6.95273951e-02f, 1.79441720e-02f, 3.92972492e-03f, -9.27075297e-02f, 7.04348162e-02f, 9.62013472e-03f, 3.47170345e-02f,
  -2.13694945e-02f, -1.06477244e-02f, 3.47522944e-02f, -6.17281683e-02f, 1.41274435e-02f, 1.70666985e-02f, 3.96089405e-02f, -3.21763866e-02f, 4.90009934e-02f, 6.21557273e-02f,
  -2.89569534e-02f, 1.94690496e-01f, 1.32664414e-02f, 1.94756351e-02f, -6.02188297e-02f, -7.13972896e-02f, 1.15814311e-02f, 1.36676043e-01f, -6.13212772e-02f, 2.95896996e-02f,
  1.11836279e-02f, 1.06634700e-03f, -2.01482568e-02f, 4.27669138e-02f, -3.68752964e-02f, 4.54026349e-02f, 1.20254643e-01f, 5.55027574e-02f, -3.23634706e-02f, 1.24246977e-01f,
  -1.00256605e-02f, -1.62174702e-02f, 8.33603088e-03f, 5.14794365e-02f, 1.05402470e-01f, -2.80247014e-02f, -5.03890477e-02f, -3.94304190e-03f, 2.77578626e-02f, 5.32295592e-02f,
  -1.24607332e-01f, -1.69550255e-02f, 8.18203166e-02f, -6.58091605e-02f, 6.44831657e-02f, -5.29247783e-02f, -2.51171105e-02f, 1.74501523e-01f, 5.25287949e-02f, 5.69931865e-02f,
  8.53284001e-02f, 8.15948769e-02f, 5.06408252e-02f, -3.00146826e-02f, -7.96374753e-02f, -5.47268428e-02f, -2.19176203e-01f, -1.57423154e-01f, 2.44305227e-02f, -7.87702128e-02f,
  -2.46161312e-01f, -1.75536469e-01f, -4.47997898e-02f, -9.76945832e-02f, 4.85434942e-02f, 3.54977348e-03f, -1.88707262e-01f, 1.86742827e-01f, -3.74177657e-02f, 2.20355734e-01f,
  9.95261893e-02f, 8.24665278e-02f, 9.47959870e-02f, 6.98481798e-02f, -6.47137910e-02f, -4.17234302e-02f, 1.58205368e-02f, 2.42733136e-01f, 2.29052771e-02f, -5.07856049e-02f,
  -3.23935933e-02f, 2.04951614e-02f, 2.46903114e-03f, 4.70448062e-02f, 3.50179784e-02f, 1.01094574e-01f, 6.65696189e-02f, 4.31531854e-02f, 2.74669062e-02f, 5.88632263e-02f,
  -2.71224342e-02f, 2.19794139e-02f, 1.57357547e-02f, -1.41796276e-01f, 2.44281348e-02f, 6.81434870e-02f, -8.32339674e-02f, 3.65337692e-02f, -3.41355354e-02f, -8.67182203e-03f,
  -1.11691907e-01f, -1.66629419e-01f, -6.85281381e-02f, 6.01590164e-02f, 3.14640179e-02f, 5.30984811e-02f, -2.47918181e-02f, -1.29813254e-02f, -1.11214347e-01f, -3.71170938e-02f,
  1.44371577e-02f, 2.54231375e-02f, -5.87203391e-02f, -1.05015516e-01f, -8.88319835e-02f, 4.57515242e-03f, -8.76221731e-02f, 7.84100518e-02f, -1.57481894e-01f, 1.23264939e-02f,
  1.33755624e-01f, 8.06645751e-02f, 5.64155281e-02f, -6.44293725e-02f, -4.67486866e-02f, -5.05385995e-02f, -1.99738685e-02f, -3.57380658e-02f, 6.75674453e-02f, -8.38108510e-02f,
  7.08449036e-02f, -5.33201359e-02f, 3.42920832e-02f, 7.97047615e-02f, 1.44281331e-02f, 8.49365722e-03f, -9.52180475e-03f, 3.45983244e-02f, -5.38270734e-02f, 9.47092287e-03f,
  -1.66903231e-02f, -2.12276876e-02f, -1.40487537e-01f, 3.41031961e-02f, -1.00681465e-03f, 7.80131221e-02f, -3.92125584e-02f, -4.23809625e-02f, -7.26274103e-02f, 1.26323968e-01f,
  -4.67756465e-02f, 2.07150355e-02f, 3.85233052e-02f, -7.90962726e-02f, -7.54085854e-02f, 3.94378193e-02f, 6.64267391e-02f, -6.68165684e-02f, -2.88002938e-02f, -2.23647803e-02f,
  -7.59131014e-02f, 1.74196020e-01f, 2.64970399e-03f, 1.67654023e-01f, 2.13736802e-01f, 3.18300456e-01f, 2.52749443e-01f, 1.78343549e-01f, 4.08925176e-01f, 1.74995109e-01f,
  2.03434657e-02f, 1.48125365e-01f, -1.09588221e-01f, 1.58789515e-01f, 1.20732971e-01f, 4.52890843e-02f, 2.68962443e-01f, 1.94198668e-01f, 1.33432522e-01f, -1.56645309e-02f,
  7.48719722e-02f, 1.08588494e-01f, -2.35898286e-01f, -1.84635684e-01f, -1.17976457e-01f, -2.70726323e-01f, -2.95090437e-01f, -1.53218254e-01f, -1.14903659e-01f, 9.20817554e-02f,
  -2.02022912e-03f, 3.98110226e-02f, -1.27366319e-01f, -5.84363639e-02f, -2.26497240e-02f, -8.06493312e-03f, -1.60062667e-02f, 1.93731152e-02f, 1.02914295e-04f, -3.64839397e-02f,
  -7.53171567e-04f, 9.55976453e-03f, 6.61890060e-02f, 1.66417416e-02f, 7.30069354e-02f, -5.48849478e-02f, 2.71087401e-02f, -5.74012212e-02f, 5.93078732e-02f, -6.99307323e-02f,
  -6.16410412e-02f, -5.64578082e-03f, -1.83225032e-02f, -3.64211723e-02f, -8.99119005e-02f, 1.42047657e-02f, 8.15352798e-02f, 1.21251922e-02f, 1.15175106e-01f, 7.57422149e-02f,
  6.22114539e-03f, 6.45026639e-02f, -6.72363564e-02f, -4.62425966e-03f, -2.35279254e-03f, -1.14427567e-01f, -6.47985842e-03f, 4.95866407e-03f, -4.32656854e-02f, -7.07693696e-02f,
  -1.16453608e-02f, -6.29741251e-02f, 1.74522344e-02f, -1.77359600e-02f, 1.34979546e-01f, 3.54091898e-02f, -4.40430902e-02f, 6.84263632e-02f, -1.10481894e-02f, 4.49202955e-02f,
  1.53801767e-02f, 6.46032915e-02f, -3.35402004e-02f, -1.03951171e-02f, 6.14691786e-02f, -3.66187617e-02f, -7.53158033e-02f, 1.06024127e-02f, 5.70995100e-02f, 3.44124213e-02f,
  1.46452487e-01f, 2.14186251e-01f, 4.35878746e-02f, -1.45758511e-02f, 3.21243927e-02f, 7.05564721e-03f, 8.94865245e-02f, 5.41506596e-02f, 2.05422286e-02f, -5.91268726e-02f,
  -6.27944916e-02f, 3.01370695e-02f, 1.89911034e-02f, -1.08794551e-02f, -3.89290787e-03f, 7.88157955e-02f, -3.12417261e-02f, 3.76276821e-02f, 1.07287489e-01f, -2.24321261e-02f,
  -9.99331847e-02f, 3.31918783e-02f, 2.45288089e-02f, -6.18078373e-02f, -9.46682617e-02f, -2.27526072e-02f, 4.43242900e-02f, -3.36716622e-02f, 2.66253650e-02f, 3.56556997e-02f,
  -2.43448809e-01f, 3.23034525e-01f, 4.27164063e-02f, -3.21293026e-02f, 9.74077657e-02f, 9.20796096e-02f, 1.18306084e-02f, 1.12717211e-01f, 2.08392143e-02f, -1.01769552e-01f,
  -1.84993222e-01f, 7.76308700e-02f, -1.18414693e-01f, 6.14638347e-03f, 2.62735840e-02f, -6.10096715e-02f, 8.08436126e-02f, -2.10488643e-02f, 5.48270009e-02f, 1.68794300e-02f,
  1.42501676e-02f, -2.21316218e-02f, -4.38954085e-02f, 7.52692446e-02f, -2.30060183e-02f, -2.14874297e-02f, -1.32262871e-01f, 1.13360129e-01f, -2.84223016e-02f, 5.10711968e-03f,
  -6.94751218e-02f, -1.16494000e-01f, -4.72881570e-02f, -5.53968400e-02f, -1.31784216e-01f, -5.60370646e-02f, 3.47385481e-02f, -1.99656468e-02f, -3.93011561e-03f, 1.31680956e-02f,
  -7.82797858e-02f, -2.33600065e-02f, -5.72446398e-02f, 1.92181598e-02f, -6.67855470e-03f, 3.53775099e-02f, 3.25125903e-02f, 7.69759864e-02f, -8.11572373e-02f, 3.78863402e-02f,
  6.99138343e-02f, 6.07610941e-02f, -2.16683466e-02f, 4.80255764e-03f, -4.11889097e-03f, 4.52871136e-02f, 8.61468613e-02f, 7.08407015e-02f, 5.80998845e-02f, 5.66332974e-03f,
  5.67728281e-02f, -1.20539658e-01f, -4.74927425e-02f, 1.33197708e-02f, 2.67603695e-02f, 1.93453468e-02f, 7.34588504e-03f, -1.20235123e-02f, 1.44998692e-02f, -1.64121352e-02f,
  -4.05341312e-02f, 1.01117618e-01f, -5.53942472e-03f, 4.03447123e-03f, 4.59600016e-02f, -7.58398026e-02f, -4.91594672e-02f, 7.48470947e-02f, 1.44420890e-02f, -2.88476981e-02f,
  6.20741658e-02f, 5.42427972e-02f, 3.58367674e-02f, 3.47349495e-02f, -3.80769148e-02f, -3.85237439e-03f, -5.58519252e-02f, -3.23385969e-02f, 2.31309813e-02f, 6.33214861e-02f,
  1.35311753e-01f, 8.47107247e-02f, -7.93077983e-03f, -2.77424268e-02f, 1.44669805e-02f, 1.71539951e-02f, 4.88447994e-02f, -3.93832698e-02f, 6.72873110e-02f, -5.33179119e-02f,
  -3.85918655e-02f, 1.74056180e-02f, -7.60499611e-02f, 4.45645899e-02f, -6.60465732e-02f, 1.15516946e-01f, -6.89219162e-02f, 1.07614733e-01f, -1.05215469e-02f, -4.26131673e-03f,
  -1.22263259e-03f, 2.65775416e-02f, 4.63705808e-02f, 5.48293069e-02f, -4.66047376e-02f, 3.78931947e-02f, 4.73652594e-02f, 1.78431962e-02f, -1.27303153e-02f, 6.57127798e-02f,
  1.88618630e-01f, 2.72134066e-01f, 2.66910940e-01f, 3.00582856e-01f, -3.18636686e-01f, -2.85909742e-01f, -2.79485136e-01f, 7.24758059e-02f, 5.78264855e-02f, -7.01963678e-02f,
  -2.79949363e-02f, 1.77118436e-01f, 1.05875619e-01f, 1.35721624e-01f, -2.76181772e-02f, -3.97751480e-02f, 7.52702430e-02f, -1.38441212e-02f, -1.64470132e-02f, 1.84961587e-01f,
  8.21178332e-02f, 1.97164211e-02f, 2.91950077e-01f, 1.17702223e-01f, 1.32470667e-01f, 9.87591445e-02f, 1.16757132e-01f, -8.89588613e-03f, 1.44367218e-01f, -6.11649863e-02f,
  -8.15863013e-02f, -6.59482414e-03f, 5.97029105e-02f, 6.08607661e-03f, -5.31099662e-02f, -6.65387139e-02f, -5.53927347e-02f, -3.12710330e-02f, -5.52233718e-02f, 2.59364452e-02f,
  1.40962899e-02f, 9.79194511e-03f, -1.45706302e-02f, 6.69874996e-02f, -3.68758254e-02f, 1.46448955e-01f, 5.40721370e-03f, 3.01637836e-02f, 2.02748124e-02f, 3.89405936e-02f,
  1.38897493e-01f, -2.73081306e-02f, -3.40096615e-02f, -7.60068223e-02f, 2.04625577e-02f, -1.33879650e-02f, 8.46099034e-02f, -6.71306252e-03f, 3.04296724e-02f, 2.74548531e-02f,
  -6.25759363e-02f, -6.98538870e-02f, -5.49187548e-02f, 9.41824093e-02f, 7.12330490e-02f, 9.67433397e-03f, -9.58450884e-03f, -8.36200342e-02f, -3.75170745e-02f, -3.85152735e-02f,
  -4.75934185e-02f, 2.20691040e-02f, 7.39956349e-02f, 5.81887253e-02f, 2.84044277e-02f, -4.53124344e-02f, -5.29090613e-02f, 9.09522641e-04f, -8.82039890e-02f, 3.77722713e-03f,
  -6.60100281e-02f, -6.76920041e-02f, 9.25624296e-02f, -5.01664951e-02f, 1.23095317e-02f, 2.10923012e-02f, 4.57685366e-02f, -1.78192314e-02f, 1.02894858e-01f, 1.25626018e-02f,
  -2.41178256e-02f, 1.20349504e-01f, 2.85980180e-02f, -5.89379221e-02f, -1.32862061e-01f, 8.19833204e-03f, -5.09080179e-02f, 5.95311895e-02f, -1.09584732e-02f, 3.56351980e-03f,
  -7.87244067e-02f, -8.44926480e-03f, -1.25100136e-01f, 2.14614663e-02f, 1.60652567e-02f, -6.19943545e-04f, 5.25051244e-02f, 1.17299492e-02f, -4.11948189e-02f, 9.61893052e-02f,
  1.44980833e-01f, -7.20582306e-02f, -6.77558407e-02f, -9.62109566e-02f, 1.09605379e-01f, -2.45620087e-02f, -2.14000717e-02f, 5.65998107e-02f, 1.28580645e-01f, -3.15049221e-03f,
  2.17486531e-01f, -2.45810881e-01f, -2.64187247e-01f, -3.12800780e-02f, 1.07870355e-01f, 2.36401781e-01f, -1.71770249e-02f, -1.50136158e-01f, -2.26408318e-01f, -1.16049036e-01f,
  1.36889324e-01f, 6.36260211e-02f, -1.23960219e-01f, 1.89028502e-01f, 2.68699557e-01f, -8.44051987e-02f, 1.25970706e-01f, 7.45601505e-02f, -2.33623415e-01f, -2.20299084e-02f,
  -8.79931357e-03f, 3.13893735e-01f, 9.54330247e-03f, 1.77494407e-01f, 1.63700700e-01f, -5.90202212e-02f, 6.89167157e-02f, 4.29214612e-02f, 9.68208238e-02f, 1.87689796e-01f,
  8.71569365e-02f, -1.21421763e-03f, 3.03638652e-02f, -4.18468714e-02f, -5.71098365e-02f, 1.24658763e-01f, 5.95725141e-02f, 1.32335663e-01f, 2.62313224e-02f, -7.94408694e-02f,
  1.80597641e-02f, -1.25987660e-02f, 1.27643510e-03f, 5.34336269e-02f, -4.58739772e-02f, -1.38850212e-01f, -2.33454816e-02f, -3.76746990e-02f, -1.25835419e-01f, 1.82319675e-02f,
  -1.20564103e-01f, -6.46971092e-02f, -6.43546358e-02f, 4.09395285e-02f, 3.76910530e-02f, 1.33725221e-03f, -1.86029524e-02f, 2.57684905e-02f, -1.16387881e-01f, 2.14846376e-02f,
  6.83282614e-02f, 3.53048518e-02f, -4.68721613e-02f, -3.25904228e-02f, -5.21814786e-02f, -2.63402332e-02f, -1.69725195e-02f, 3.61599028e-03f, 1.77682173e-02f, 2.18050219e-02f,
  -1.36914728e-02f, 1.63315237e-02f, 1.48628270e-02f, 9.67909545e-02f, 6.87839836e-02f, 1.67251769e-02f, -3.01892031e-02f, 9.04128179e-02f, 3.92036289e-02f, -9.57327057e-03f,
  -2.91319229e-02f, -3.39385904e-02f, -1.97961759e-02f, -1.21707730e-02f, -1.29014915e-02f, 3.55516300e-02f, -6.41775026e-04f, -2.52606906e-02f, 5.40274084e-02f, 6.49935901e-02f,
  -3.17410342e-02f, -1.69015139e-01f, -2.46925447e-02f, 7.07182959e-02f, -1.69035196e-02f, -2.29070596e-02f, 6.09687492e-02f, -1.48504134e-02f, 3.24879959e-02f, -4.22623754e-02f,
  5.55172563e-03f, -6.96546808e-02f, 2.76128273e-03f, 7.75869116e-02f, -2.27474831e-02f, 1.69170965e-02f, 1.47914607e-02f, -9.37827379e-02f, 2.13360731e-02f, 1.08471476e-01f,
  1.31106332e-01f, -3.61823887e-02f, 7.70974234e-02f, -1.20756207e-02f, 2.00709961e-02f, 1.78099368e-02f, -1.88205123e-03f, -5.23444675e-02f, -8.17940012e-02f, -4.32496518e-02f,
  -1.09954119e-01f, -3.60927045e-01f, -2.70390362e-01f, -8.38750377e-02f, 2.76428282e-01f, 2.15462789e-01f, -1.76989481e-01f, 1.11556947e-01f, -2.00155526e-01f, -1.18000790e-01f,
  5.35686798e-02f, -1.31627113e-01f, -3.61416876e-01f, 5.57236746e-02f, 1.48560122e-01f, -2.14131072e-01f, 6.31861985e-02f, 1.46044016e-01f, -1.89062357e-01f, -3.77105772e-02f,
  7.41309347e-03f, 2.97912419e-01f, -3.95717621e-02f, 2.21960858e-01f, 1.33565754e-01f, 5.43657131e-02f, 1.23601899e-01f, -9.55807716e-02f, 2.53306001e-01f, 9.87852439e-02f,
  8.30232650e-02f, -1.47274703e-01f, -6.88417852e-02f, -9.62263625e-03f, -8.48259330e-02f, 1.09675400e-01f, 4.21030633e-02f, 1.71724092e-02f, 6.91793784e-02f, -2.52292734e-02f,
  -8.43042433e-02f, 4.62370813e-02f, 9.91282705e-03f, -7.70032080e-03f, 1.05871782e-02f, 8.22985247e-02f, 1.04928883e-02f, -6.03308342e-02f, -2.38794517e-02f, -1.03464730e-01f,
  -1.32747769e-01f, 6.27486631e-02f, -7.17158914e-02f, 1.03812225e-01f, -5.23949042e-02f, 7.98130855e-02f, -5.50885201e-02f, 5.12567982e-02f, -3.65237915e-03f, 1.35310600e-02f,
  2.81150155e-02f, 6.77250326e-02f, 1.54075015e-03f, 4.34482284e-02f, 2.72232504e-03f, 6.45841053e-03f, 6.88097104e-02f, 3.57491337e-02f, -1.39250821e-02f, -3.41636650e-02f,
  2.05717515e-02f, 1.84574183e-02f, -1.26702935e-01f, 2.44753920e-02f, 4.47017141e-02f, -7.27895275e-02f, 7.75334239e-02f, 6.46917596e-02f, -4.51908354e-03f, 4.22910638e-02f,
  -5.49218878e-02f, 4.09706943e-02f, 5.76463491e-02f, 3.83061320e-02f, 3.94209335e-03f, 1.54920155e-02f, -2.38322187e-03f, -8.19597691e-02f, -1.94027442e-02f, 5.18228151e-02f,
  -5.46966121e-02f, -1.63104534e-01f, -4.56714891e-02f, 6.37786239e-02f, 4.47937474e-02f, 2.45555509e-02f, -6.05706163e-02f, 1.31678833e-02f, 4.38069738e-02f, -2.77918633e-02f,
  9.70087051e-02f, 3.45592387e-02f, 5.39571606e-02f, -2.67956089e-02f, 8.74029920e-02f, 2.66293287e-02f, 3.01279817e-02f, 7.30520487e-02f, 7.53039122e-02f, 1.10453419e-01f,
  3.30204107e-02f, 3.99024375e-02f, 1.10928968e-01f, 7.26402551e-02f, 5.67674562e-02f, -2.47422769e-03f, 5.33048771e-02f, -1.75969023e-02f, 9.60352272e-02f, -9.98859853e-02f,
  2.31830825e-04f, 7.07348958e-02f, 8.36061686e-03f, 1.08077228e-01f, -7.24229291e-02f, -1.15886025e-01f, -1.06477894e-01f, -3.35775763e-02f, 4.01566066e-02f, 5.33899963e-02f,
  -8.31546634e-02f, 1.18575215e-01f, 1.24769151e-01f, -1.81792855e-01f, 5.45194149e-02f, 1.48963943e-01f, -7.13272169e-02f, 2.10114885e-02f, 2.95457151e-02f, -5.52447885e-02f,
  -7.05701783e-02f, -1.61341861e-01f, -5.01000024e-02f, -7.97905996e-02f, -2.33533844e-01f, -1.39550447e-01f, -6.71103299e-02f, -9.00711194e-02f, -9.96074826e-02f, -1.65714808e-02f,
  -4.74143168e-03f, 4.93016466e-02f, -1.99808463e-01f, -8.18867460e-02f, -8.00203830e-02f, -1.20494783e-01f, -3.77753712e-02f, -4.97475150e-04f, -4.38336395e-02f, -2.25890819e-02f,
  1.45094991e-01f, 5.91085711e-03f, -1.73394606e-02f, 6.78852946e-02f, 8.50881040e-02f, 1.44318752e-02f, 1.95019320e-02f, -7.57069066e-02f, 5.56958318e-02f, 7.48012662e-02f,
  5.20192832e-02f, -7.50900665e-03f, -4.97220121e-02f, -1.72584746e-02f, -1.45611152e-01f, -4.98564467e-02f, 2.78819203e-02f, 5.58752790e-02f, 6.10859320e-02f, 5.04865870e-02f,
  -5.67807406e-02f, 4.55041789e-02f, 2.68715899e-02f, 2.96476725e-02f, -7.97070488e-02f, 4.22363803e-02f, -3.95291187e-02f, -5.50380573e-02f, -3.29321995e-02f, 1.47339124e-02f,
  3.97299007e-02f, -1.91147532e-02f, 2.93433983e-02f, 1.18182423e-02f, -6.73730150e-02f, 4.95874975e-03f, -1.49155427e-02f, 2.58626733e-02f, 1.64334420e-02f, 4.68842387e-02f,
  -1.30597297e-02f, -9.86865982e-02f, 3.13876383e-02f, -6.26194701e-02f, 8.41918737e-02f, -4.69608009e-02f, 7.14762211e-02f, 1.48240821e-02f, -1.95690468e-02f, -7.77642876e-02f,
  3.05847060e-02f, -8.93036574e-02f, -5.68321049e-02f, -1.02692910e-01f, 1.68028530e-02f, -5.42280115e-02f, 9.46971308e-03f, -7.57128373e-02f, -3.83447073e-02f, -3.09007596e-02f,
  -8.35294947e-02f, -1.39253614e-02f, 5.14730178e-02f, 7.27577135e-02f, 1.15225576e-01f, 5.30867390e-02f, -2.23016385e-02f, 1.09011680e-01f, -2.63332166e-02f, 9.69709083e-02f,
  3.99882719e-02f, -1.84230581e-02f, -1.47139691e-02f, -7.76513666e-02f, -1.13691948e-02f, 1.22128092e-02f, -4.58968021e-02f, -4.93284650e-02f, -1.40424836e-02f, 1.63179189e-02f,
  -2.63459235e-02f, -2.37096008e-02f, -2.14701161e-01f, 9.67844576e-02f, -1.75862089e-01f, -1.01217836e-01f, 9.44316462e-02f, -6.54399171e-02f, -1.63325042e-01f, 1.21544056e-01f,
  2.34674022e-01f, -6.05246499e-02f, 8.93233344e-02f, 3.98832351e-01f, 4.82085124e-02f, 1.10165693e-01f, 2.55803913e-01f, 1.41914025e-01f, -1.16085773e-02f, 1.26899257e-01f,
  1.18704051e-01f, 3.49177718e-01f, 1.46617219e-01f, 1.21403106e-01f, 1.33452564e-01f, 4.16051932e-02f, 1.79899618e-01f, -1.03815898e-01f, 1.83609530e-01f, -1.27548441e-01f,
  4.50526662e-02f, 3.16163450e-02f, 2.98682181e-03f, 7.84259290e-03f, -5.72649017e-02f, 1.15288645e-02f, -3.25855315e-02f, -2.86567118e-03f, -4.05827425e-02f, -3.85592245e-02f,
  -6.99949339e-02f, -2.11956147e-02f, 4.24137674e-02f, -5.59100099e-02f, -6.63675889e-02f, -3.37925996e-03f, -2.34631449e-02f, 1.94514189e-02f, -3.08152661e-02f, 4.54209149e-02f,
  -2.50598360e-02f, -2.80808173e-02f, -3.14225778e-02f, 1.99103635e-02f, 1.15212156e-02f, 2.90177464e-02f, -2.91486084e-02f, -4.57597263e-02f, 1.20896650e-02f, 8.21385384e-02f,
  2.02244744e-02f, 1.91571452e-02f, 1.63003445e-01f, -3.87894958e-02f, 1.80393760e-03f, 4.25596796e-02f, 4.82307896e-02f, -5.43417735e-03f, -3.35212387e-02f, 1.08178355e-01f,
  8.92661104e-04f, 2.16692849e-03f, 3.37586692e-03f, 2.94611026e-02f, 5.26803620e-02f, -4.63582501e-02f, -9.90213677e-02f, 5.68876974e-02f, -1.01676404e-01f, -1.49498014e-02f,
  6.29859269e-02f, -6.48277402e-02f, -3.00250147e-02f, 3.17526609e-02f, -3.61803430e-03f, 3.54309678e-02f, 3.90669256e-02f, -2.86519844e-02f, -2.45292783e-02f, -1.85915716e-02f,
  6.79882336e-03f, 8.30975771e-02f, -3.76282893e-02f, -5.83003100e-04f, -6.03655465e-02f, 4.18004952e-02f, 2.48196870e-02f, 7.38334209e-02f, 3.69094014e-02f, 2.51552928e-02f,
  -9.76768322e-03f, -1.17287189e-02f, 3.86064537e-02f, 2.41522137e-02f, 9.80935153e-03f, -2.75714882e-02f, 4.70507666e-02f, -5.05257472e-02f, -1.36064384e-02f, -1.39543321e-02f,
  -7.16460571e-02f, -1.26511101e-02f, 5.80844618e-02f, -5.45084625e-02f, 5.75843751e-02f, 5.44931293e-02f, 6.65344484e-03f, -8.70567709e-02f, -2.36766804e-02f, 6.62180111e-02f,
  1.09602459e-01f, 2.41037399e-01f, 2.06996053e-01f, 7.58370757e-02f, -1.54467106e-01f, -2.35403970e-01f, -4.98162061e-02f, 3.09620183e-02f, -3.22023928e-02f, 1.43253326e-01f,
  -1.59346193e-01f, 9.93103832e-02f, -4.67151776e-02f, -3.70420478e-02f, -1.77959159e-01f, -1.47177890e-01f, 4.99216793e-03f, -4.79356870e-02f, -4.00450900e-02f, 2.48577520e-01f,
  -1.33590782e-02f, -9.04065594e-02f, 1.99499026e-01f, -1.46942521e-02f, 4.63272780e-02f, 1.62272617e-01f, 9.76216719e-02f, 1.52808353e-02f, 9.76933390e-02f, -8.04243237e-02f,
  -5.82597554e-02f, 3.94808641e-03f, 1.05244972e-01f, -8.57303143e-02f, 8.69387388e-02f, -6.91045895e-02f, 1.03000388e-01f, 3.36884521e-02f, -3.73427407e-04f, 2.12425236e-02f,
  3.78348380e-02f, -4.11066748e-02f, 1.46100651e-02f, 8.99688900e-03f, 7.37870438e-03f, 1.23147808e-01f, 1.38794854e-01f, 1.32188827e-01f, -2.07464006e-02f, -9.56308912e-04f,
  1.66922733e-02f, -8.21411051e-03f, 2.57917605e-02f, 8.06334540e-02f, 6.09011129e-02f, 2.81855538e-02f, 4.19423990e-02f, 1.05976626e-01f, 4.17702273e-02f, 7.04748463e-03f,
  -3.10805608e-02f, -4.34469692e-02f, -3.56079787e-02f, -3.64895840e-03f, 6.15572138e-03f, -1.68850385e-02f, 2.79805367e-03f, -5.99619001e-02f, 2.51815040e-02f, -2.27177907e-02f,
  2.26951167e-02f, 6.81402385e-02f, -6.33742735e-02f, 1.26908213e-01f, 2.82708704e-02f, -1.02481246e-01f, 5.86438179e-02f, 3.97884473e-02f, -8.12794194e-02f, -3.05247456e-02f,
  -1.37992203e-01f, -6.40466213e-02f, -5.76654524e-02f, -5.86012416e-02f, -9.48963091e-02f, 1.13759726e-01f, 3.29659805e-02f, -2.94165295e-02f, 4.58632559e-02f, 2.79243067e-02f,
  3.39535065e-02f, 1.13999307e-01f, 6.15429059e-02f, -1.27989464e-02f, -1.96283963e-02f, -2.93716490e-02f, 1.09391275e-03f, -1.95799358e-02f, -4.92501147e-02f, 1.56595241e-02f,
  3.66349868e-03f, 8.32723640e-03f, -5.00576980e-02f, -1.71291698e-02f, 6.98505938e-02f, 4.76269387e-02f, 1.05190687e-01f, 9.57597867e-02f, -4.71058078e-02f, -9.45136324e-03f,
  9.12138373e-02f, 2.73994915e-03f, -2.73091774e-02f, 5.30278310e-02f, -3.32938395e-02f, 5.08422777e-02f, -7.96256810e-02f, 1.45629659e-01f, -3.00235134e-02f, 2.98843719e-03f,
  1.89808980e-01f, -1.58446386e-01f, -1.57223821e-01f, -1.11044860e-02f, 4.97522615e-02f, 7.54665360e-02f, -1.09623671e-01f, 4.04487997e-02f, -2.41017818e-01f, -6.57524392e-02f,
  7.04420209e-02f, -4.01166603e-02f, -1.68915525e-01f, 1.49229869e-01f, 2.81731755e-01f, -1.17247842e-01f, 8.12009871e-02f, 2.51120403e-02f, -1.76018514e-02f, 1.88216974e-03f,
  5.59293479e-02f, 2.78977871e-01f, -6.49800301e-02f, 1.40211076e-01f, 1.26873016e-01f, -3.55500691e-02f, 8.95502493e-02f, -3.95946205e-02f, 1.78237483e-01f, 1.46758959e-01f,
  3.62468213e-02f, 4.23728488e-02f, -3.17017175e-02f, -6.11535534e-02f, -6.81926310e-02f, 4.22030799e-02f, 5.26361391e-02f, 4.79352959e-02f, 7.72378035e-03f, 6.80672098e-03f,
  -5.30584604e-02f, 8.77698138e-03f, 6.45597503e-02f, 9.48139746e-03f, 6.27269670e-02f, 2.54811859e-03f, -1.45549312e-01f, -9.80068520e-02f, -6.81023747e-02f, 1.02611572e-01f,
  -5.80916069e-02f, 5.77219436e-03f, -5.89263029e-02f, -7.05125108e-02f, -2.18664948e-02f, 5.63696548e-02f, -9.89009440e-03f, 2.35102940e-02f, 8.58441517e-02f, -8.03204104e-02f,
  3.53140989e-03f, -6.60339464e-03f, 1.43754836e-02f, -5.81188090e-02f, -2.49884259e-02f, 3.64200887e-03f, -4.31985362e-03f, -5.01025692e-02f, 2.19560973e-02f, -3.94602586e-03f,
  2.39552557e-02f, 8.54752550e-04f, -4.04818207e-02f, -2.20034365e-02f, 9.63584557e-02f, 9.91592463e-03f, -4.71892394e-03f, 9.30685550e-03f, -9.31202173e-02f, -2.31197104e-02f,
  6.27338560e-03f, 2.05458794e-02f, -4.34754677e-02f, 2.18396354e-02f, -2.08746418e-02f, -4.19646055e-02f, -4.44899611e-02f, -1.07338175e-01f, -5.24935545e-03f, 1.01730622e-01f,
  2.68663559e-02f, -6.02061525e-02f, -7.44656920e-02f, -8.22454400e-04f, 3.25799063e-02f, 2.30666925e-03f, 1.03582600e-02f, 3.11135780e-02f, 4.89958934e-02f, 2.70501152e-02f,
  -3.75984609e-02f, 1.37862854e-03f, 1.27456367e-01f, 1.13025233e-02f, 6.04870953e-02f, -2.40207352e-02f, -4.25802693e-02f, -7.25498423e-02f, -4.43983860e-02f, 3.45703587e-02f,
  1.52333081e-02f, 2.73184422e-02f, 6.36837706e-02f, 3.99786513e-03f, -3.21476185e-03f, 1.56877341e-03f, 2.95228232e-02f, 4.26559150e-03f, 1.25462532e-01f, -1.80221885e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.00640908e-01f, 6.13809675e-02f, 4.91715707e-02f, -4.33186218e-02f, 1.33708358e-01f, -2.00955514e-02f, 1.12967841e-01f, 6.32148385e-02f, 1.95952177e-01f, 6.46591708e-02f,
  4.51406948e-02f, -2.54847598e-03f, 3.46295424e-02f, 4.52432968e-02f, 1.09021798e-01f, 2.93503534e-02f, 4.35446529e-03f, 1.20458670e-01f, 1.53808624e-01f, 1.23008117e-02f,
  6.25846311e-02f, -1.78950373e-02f, -7.30576878e-03f, 1.59286393e-03f, -6.62761333e-04f, 1.25172079e-01f, 4.39007068e-03f, 1.28487363e-01f, 1.14166923e-01f, -1.86834149e-02f,
  -3.61895151e-02f, 9.36335698e-02f, 1.57280207e-01f, 1.99901336e-03f, 6.67709410e-02f, 4.07415032e-02f, 2.73486506e-02f, 5.94032705e-02f, -1.09919412e-02f, 7.15600401e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  4.03751582e-02f, -6.53310269e-02f, 2.73675676e-02f, -6.83017820e-02f, 6.26371130e-02f, -3.85563672e-02f, -4.45237458e-02f, -6.07750416e-02f, -8.70783404e-02f, 5.90143278e-02f,
  9.83977765e-02f, 3.43101397e-02f, -7.90593680e-03f, -1.05796270e-01f, -6.99367151e-02f, 9.55793187e-02f, 1.00270011e-01f, 1.60634339e-01f, 1.53388306e-01f, 1.41962431e-03f,
  -1.38531774e-01f, 4.30407785e-02f, -2.04718918e-01f, 6.55436935e-03f, 2.88091987e-01f, 4.02837507e-02f, 7.69085884e-02f, 1.24404328e-02f, 2.02615827e-01f, 9.37952101e-02f,
  6.44112006e-02f, 2.92431060e-02f, -8.69266540e-02f, -7.30431974e-02f, 6.25024214e-02f, 1.25259921e-01f, -1.47340804e-01f, 1.36145711e-01f, 1.20424047e-01f, 1.70775816e-01f,
  -1.79491401e-01f, 4.55896333e-02f, 6.66915998e-02f, -5.30274548e-02f, 1.33610055e-01f, 2.21680328e-01f, -9.46900919e-02f, -4.94267046e-02f, -1.54261038e-01f, 1.00681871e-01f,
  6.59359097e-02f, -5.89345433e-02f, 4.54318564e-04f, 5.12583852e-02f, 1.58647709e-02f, 3.02043825e-01f, 4.96760868e-02f, -1.77849755e-01f, 1.49128595e-02f, -1.31858498e-01f,
  9.12766382e-02f, -6.90738261e-02f, -1.18527249e-01f, 4.29939441e-02f, -4.25184984e-03f, 1.38649598e-01f, -5.56905083e-02f, -9.26628802e-03f, 2.20909100e-02f, -4.54170145e-02f,
  -8.49424228e-02f, -1.04208224e-01f, 1.06502123e-01f, -8.36300850e-02f, -9.63880345e-02f, -7.20183030e-02f, -1.92234531e-01f, 5.23905344e-02f, 1.10645473e-01f, -8.00196358e-05f,
  1.25220895e-01f, -1.10145167e-01f, 1.40725240e-01f, 4.08625118e-02f, -1.20175816e-01f, -3.99916731e-02f, 4.07268591e-02f, -3.87372039e-02f, 1.29946582e-02f, -1.89747754e-02f,
  7.02125281e-02f, -5.92684280e-03f, 1.42860143e-02f, -1.39904454e-01f, -1.03349634e-01f, -5.80711178e-02f, -3.39219533e-02f, -2.05415606e-01f, -6.48571998e-02f, 4.01576646e-02f,
  -2.34249234e-02f, -1.03406538e-03f, -1.62182692e-02f, 1.38963863e-01f, 1.48370937e-01f, -1.33509696e-01f, -7.20064342e-03f, 3.97493951e-02f, 8.47504195e-03f, 9.23612490e-02f,
  9.47855935e-02f, 1.87796634e-02f, -1.55553043e-01f, -3.52572724e-02f, -1.07651919e-01f, 5.36371954e-02f, 3.31830084e-02f, 1.18975438e-01f, -8.00264850e-02f, 9.42410007e-02f,
  -1.31359464e-03f, 3.62986475e-02f, 9.39209759e-02f, 1.08165279e-01f, -4.67106216e-02f, 2.15197504e-01f, -3.42650972e-02f, 1.07325524e-01f, 4.42991108e-02f, -4.52191047e-02f,
  5.23260050e-02f, -3.80130522e-02f, 6.31340966e-02f, -6.36654347e-02f, -1.05654476e-02f, 7.77712371e-03f, -6.26724139e-02f, -5.64806424e-02f, -5.02426326e-02f, 1.46722561e-02f,
  2.32681945e-01f, -1.21190779e-01f, -3.62211689e-02f, -5.96808530e-02f, -4.25852425e-02f, 1.68238848e-01f, 7.07449066e-03f, 1.17893759e-02f, 1.02880538e-01f, -7.97216296e-02f,
  2.78062504e-02f, 1.63139701e-02f, 2.33486205e-01f, -1.09022103e-01f, -1.40599579e-01f, 1.78489983e-01f, 2.84295619e-01f, 1.43674389e-02f, -8.30424055e-02f, 1.86425135e-01f,
  -2.42315546e-01f, -2.49959249e-02f, 1.83880962e-02f, 1.45763516e-01f, -5.71921431e-02f, 9.79962666e-03f, 1.82499774e-02f, -1.19940266e-01f, 3.35667133e-02f, -7.94299468e-02f,
  -2.91931748e-01f, 3.11330277e-02f, -1.21262684e-01f, -2.26985198e-02f, 1.68844476e-01f, 1.84397355e-01f, -7.04717487e-02f, -1.46445557e-01f, -2.03831553e-01f, 9.35274288e-02f,
  1.81065977e-01f, -4.96273376e-02f, -6.26757145e-02f, -2.01104619e-02f, -1.50580421e-01f, -9.06120837e-02f, 2.20993087e-01f, 8.61550942e-02f, -5.74580953e-03f, -1.50547072e-01f,
  -8.79518762e-02f, 1.89157784e-01f, -1.11444198e-04f, -6.78300485e-02f, -2.48469096e-02f, 9.88930538e-02f, 3.51981334e-02f, 9.57466811e-02f, -1.10803716e-01f, -5.35493456e-02f,
  -2.38964334e-02f, 8.48500580e-02f, 1.14713488e-02f, 8.30192938e-02f, -7.66562745e-02f, -4.53525335e-02f, 2.28000402e-01f, 9.35126618e-02f, 5.89747876e-02f, -9.82129872e-02f,
  5.60464524e-02f, -1.30816568e-02f, -5.66890836e-03f, 3.34560052e-02f, -2.07104329e-02f, -1.31170467e-01f, 3.50481202e-03f, 1.91561952e-01f, 1.49420813e-01f, -2.69724932e-02f,
  1.57008156e-01f, 1.80878878e-01f, 8.07605013e-02f, -7.51820877e-02f, 7.41145238e-02f, -2.03972548e-01f, 1.69377197e-02f, 2.13160157e-01f, -3.77157070e-02f, 2.32189834e-01f,
  -5.89733683e-02f, 3.00658513e-02f, -1.70031622e-01f, 6.41640201e-02f, 1.83371425e-01f, -4.37900089e-02f, 4.79287878e-02f, 3.61134857e-02f, -1.03360988e-01f, -9.68495607e-02f,
  -1.12088591e-01f, -3.60302441e-02f, 9.62859988e-02f, 1.89146161e-01f, 6.40648082e-02f, -1.35472670e-01f, 5.67517541e-02f, -1.57354176e-01f, -3.13551202e-02f, -1.72149464e-01f,
  1.80725709e-01f, 2.03768030e-01f, 4.16445583e-02f, 9.80746821e-02f, -1.19994998e-01f, 1.77413195e-01f, -3.05334409e-03f, 2.76841223e-02f, -7.71418586e-02f, -3.02622057e-02f,
  -8.45428929e-02f, -8.79171714e-02f, 3.42669003e-02f, -4.89383824e-02f, 5.52727096e-02f, -5.23596257e-02f, -7.12751895e-02f, -1.11371174e-01f, 1.29616242e-02f, 5.38618974e-02f,
  -2.28372231e-01f, -6.94423392e-02f, -1.35479823e-01f, -8.62523466e-02f, 2.29473580e-02f, 1.08983979e-01f, 5.81467412e-02f, -9.04739350e-02f, 1.45932391e-01f, 2.64317226e-02f,
  5.88383600e-02f, -1.40925065e-01f, -1.86909690e-01f, 1.54391471e-02f, -2.08872452e-01f, -1.17511392e-01f, -4.71530743e-02f, 6.07584231e-02f, -3.60556953e-02f, -1.44097637e-02f,
  -1.45468384e-01f, -2.78207939e-03f, 3.62613238e-02f, 5.50343953e-02f, 9.02028941e-03f, -1.57741476e-02f, 1.61210671e-01f, -1.41302422e-01f, -1.01771794e-01f, -6.04858948e-03f,
  1.26841525e-02f, 1.58196483e-02f, 2.31080905e-01f, 1.57010779e-01f, 2.31020451e-02f, -1.65347345e-02f, -1.45463184e-01f, -6.27808422e-02f, 8.79300758e-02f, 2.10445270e-01f,
  -1.20776363e-01f, 1.29268080e-01f, -4.62599024e-02f, 6.46210536e-02f, 1.11427389e-01f, 1.94691196e-01f, 2.66423821e-02f, 5.73315881e-02f, 3.28623168e-02f, 5.16657904e-02f,
  -7.71821216e-02f, -3.20381508e-03f, -4.03548814e-02f, -1.29110657e-03f, -7.77851939e-02f, -2.86861155e-02f, -3.90949696e-02f, -7.87803978e-02f, -4.75449115e-02f, 7.36053586e-02f,
  1.25680296e-02f, -2.61031874e-02f, -5.93949556e-02f, 5.26414551e-02f, 5.74200302e-02f, -3.01715061e-02f, -7.62282982e-02f, -5.94028737e-04f, -5.99081721e-03f, 4.30851541e-02f,
  6.80470690e-02f, 3.85623798e-02f, -1.09527312e-01f, -5.99171221e-02f, 5.91130592e-02f, 4.86850105e-02f, 1.03838705e-01f, 2.68881097e-02f, 1.31317992e-02f, 2.22019255e-01f,
  9.14357081e-02f, -1.24116927e-01f, 3.63307260e-03f, -7.68567696e-02f, 1.08404353e-01f, -3.74704152e-02f, -1.12096727e-01f, 2.72921711e-01f, -8.90236348e-02f, 2.18586586e-02f,
  -1.71045259e-01f, 1.46453589e-01f, 1.00269929e-01f, 3.69701050e-02f, 1.64096057e-02f, 9.57974605e-03f, -1.51186064e-01f, -1.91360116e-01f, -8.06347188e-03f, -3.71040814e-02f,
  1.49220437e-01f, -1.54016763e-01f, 3.97468023e-02f, -6.22651838e-02f, -2.25706063e-02f, -7.56979957e-02f, 5.22907125e-03f, -1.51942432e-01f, 2.52482248e-03f, -2.90562473e-02f,
  1.05627766e-02f, -6.14383398e-03f, -6.01273663e-02f, -5.78131899e-02f, -2.62323804e-02f, -1.02717429e-01f, -5.02399541e-02f, 6.27143830e-02f, 1.81485303e-02f, -9.10578445e-02f,
  -4.15241905e-02f, 7.56314471e-02f, -7.20725209e-02f, 5.22926338e-02f, -7.96066830e-04f, -1.21855866e-02f, -4.26241197e-02f, 8.03573653e-02f, -9.16326270e-02f, -2.06348777e-01f,
  -2.83699427e-02f, 9.77980569e-02f, -1.40605345e-01f, -1.00956313e-01f, 1.03603378e-01f, 2.53601260e-02f, -1.00696281e-01f, -1.12429053e-01f, -1.46153346e-02f, -1.08323753e-01f,
  -1.33758530e-01f, 7.13051111e-02f, -1.26570135e-01f, 2.09306851e-01f, 1.86447605e-01f, -1.85076475e-01f, -2.68009957e-02f, 1.21885039e-01f, 1.09115519e-01f, -2.00206429e-01f,
  1.67608913e-02f, 7.37434253e-02f, -1.04872450e-01f, -1.45459369e-01f, 3.58731076e-02f, 9.70228016e-02f, -4.12735119e-02f, 6.21522702e-02f, -6.90498203e-02f, -3.83377485e-02f,
  -2.09787354e-01f, -1.49056226e-01f, 1.24729402e-01f, 4.92993183e-02f, 8.46912339e-02f, -2.58280694e-01f, -6.66937232e-02f, 6.76827356e-02f, 6.66962788e-02f, 2.36765910e-02f,
  -2.44740229e-02f, 7.81415477e-02f, -1.01942062e-01f, -1.17089890e-01f, 5.98042719e-02f, -6.17846064e-02f, 1.62761316e-01f, -3.64470929e-02f, -1.10899597e-01f, -5.72528839e-02f,
  -5.25904186e-02f, 4.35165167e-02f, 4.61158752e-02f, 2.60317102e-02f, -1.57460168e-01f, -6.38357550e-02f, 1.37943616e-02f, 4.14232630e-03f, -4.04174402e-02f, 1.58122227e-01f,
  -1.92216523e-02f, -3.96123342e-02f, 7.06701502e-02f, 1.05427520e-03f, 6.43662438e-02f, 4.40753810e-02f, 6.52526841e-02f, 4.97954106e-03f, -1.18489459e-01f, 7.25096166e-02f,
  -6.64081946e-02f, -3.67571190e-02f, 8.84913579e-02f, 1.54432908e-01f, 1.07696824e-01f, 5.86925410e-02f, 2.44236454e-01f, 1.21234305e-01f, 7.11360201e-02f, -8.95483345e-02f,
  -7.69667327e-02f, -1.05576575e-01f, 8.67900923e-02f, -1.15353232e-02f, -2.33003199e-02f, -9.45245549e-02f, 2.84223352e-02f, 1.12319790e-01f, -1.41679674e-01f, 4.18424793e-02f,
  5.95732741e-02f, -8.01231936e-02f, 7.57354870e-02f, 1.30626082e-01f, -1.45328045e-01f, -1.51026562e-01f, -6.52533993e-02f, 2.35029738e-02f, 1.80557407e-02f, 3.08491196e-02f,
  -5.53494804e-02f, -1.58341452e-01f, -6.04897030e-02f, 7.40934685e-02f, 6.55106977e-02f, -3.19905952e-02f, -1.12422474e-01f, -1.30273044e-01f, 4.03911397e-02f, 5.48533425e-02f,
  -2.66217142e-02f, 3.03354207e-02f, -2.91534550e-02f, -3.71795930e-02f, -6.10493608e-02f, 4.92708161e-02f, -3.00882244e-03f, -3.64003778e-02f, -1.25746816e-01f, -4.67776433e-02f,
  4.49597947e-02f, -8.72820020e-02f, -4.52714190e-02f, 2.09147781e-01f, -1.77868217e-01f, 6.81064650e-03f, 1.65647969e-01f, -8.47431924e-03f, 1.36083767e-01f, -1.58838868e-01f,
  1.27201036e-01f, -2.30721422e-02f, 7.34051913e-02f, -8.33954662e-03f, -6.07592501e-02f, -1.91757306e-01f, -7.81465992e-02f, 9.08063427e-02f, 1.79936305e-01f, -6.01150002e-03f,
  2.65812427e-01f, 1.49568096e-01f, 1.15656622e-01f, -3.23518701e-02f, 1.13095284e-01f, -2.43676141e-01f, 8.81417692e-02f, 9.81887206e-02f, -1.34035125e-01f, 2.48525679e-01f,
  -4.36806902e-02f, 2.12418055e-03f, -2.31507659e-01f, 8.80975947e-02f, 1.87858149e-01f, 3.86384092e-02f, -2.55281869e-02f, 4.47464474e-02f, -1.75525799e-01f, -1.04854532e-01f,
  -1.22637950e-01f, -4.47686017e-02f, 3.28973569e-02f, 2.29971170e-01f, 2.38192882e-02f, -1.33569822e-01f, 1.13836654e-01f, -1.40023068e-01f, 3.07646655e-02f, -1.67560562e-01f,
  2.75899082e-01f, 2.49717787e-01f, -3.29890102e-02f, 9.32409763e-02f, -1.88390076e-01f, 1.67168885e-01f, 3.46329324e-02f, 8.18771310e-03f, 1.73592959e-02f, -5.16786799e-02f,
  6.41223229e-03f, 3.55980359e-02f, 9.55193713e-02f, -7.60028735e-02f, -7.89024085e-02f, -5.05179614e-02f, -6.00264333e-02f, -7.36994296e-02f, 1.34132147e-01f, -1.21041507e-01f,
  -6.75247014e-02f, 3.15805562e-02f, -8.93907808e-03f, 1.06720202e-01f, 9.98114981e-03f, 1.55875176e-01f, -5.26876748e-02f, -6.43609017e-02f, -5.58560677e-02f, 1.02454893e-01f,
  2.60432690e-01f, -1.09327370e-02f, -7.48290271e-02f, 3.39348316e-02f, 1.62004039e-01f, 3.81469764e-02f, -5.11650704e-02f, 1.29861161e-01f, -1.84069991e-01f, -6.13807477e-02f,
  -2.27689873e-02f, 1.78038448e-01f, -1.45543024e-01f, -6.04784451e-02f, 1.22891247e-01f, 3.35620493e-02f, -7.58376345e-02f, -8.45440850e-02f, -1.06990494e-01f, -4.04649898e-02f,
  -6.56095566e-03f, 9.86992866e-02f, 1.55961365e-01f, 1.80488855e-01f, -1.12903051e-01f, -9.01540965e-02f, -8.41082707e-02f, -3.68987806e-02f, 1.97025746e-01f, 3.58316042e-02f,
  4.09084335e-02f, 3.90389524e-02f, -5.84901385e-02f, -1.56613767e-01f, 2.04043746e-01f, 1.30882442e-01f, 8.52431953e-02f, -1.11928058e-03f, -1.36691228e-01f, 1.73125193e-01f,
  -3.23435366e-02f, 5.14305383e-02f, -2.01875735e-02f, -9.34243649e-02f, -7.70685375e-02f, -1.02493733e-01f, -1.42509252e-01f, -1.20612353e-01f, -6.24404810e-02f, -1.39649743e-02f,
  -6.57794997e-02f, -1.04664356e-01f, -2.22526222e-01f, 8.81523639e-02f, -4.50875908e-02f, -6.14417456e-02f, -1.16247633e-04f, -5.12567051e-02f, 6.82467967e-02f, 1.55792996e-01f,
  -7.62915388e-02f, 2.20288802e-02f, -1.32011930e-02f, -6.60830289e-02f, 3.32595073e-02f, -1.27183303e-01f, 1.92526020e-02f, -5.33030480e-02f, -1.11083522e-01f, -2.06898060e-02f,
  -7.06202164e-02f, -1.23544864e-01f, -1.57437429e-01f, -1.49430126e-01f, -5.76770008e-02f, 1.59236286e-02f, -5.05086146e-02f, -1.48084402e-01f, -8.00372381e-03f, 1.35062873e-01f,
  5.22864945e-02f, -1.50784224e-01f, -5.47186323e-02f, -1.80282295e-02f, -6.91015646e-02f, 1.29284948e-01f, -4.58605215e-02f, -8.44485164e-02f, -1.36981577e-01f, -1.08141504e-01f,
  -5.42038493e-02f, -2.25840822e-01f, 3.87040190e-02f, 1.17759705e-01f, -2.42653400e-01f, 2.40581229e-01f, 1.13015454e-02f, 1.67528763e-01f, 1.49233900e-02f, -1.43918410e-01f,
  -3.69038358e-02f, 1.24375246e-01f, 1.07889893e-04f, 3.19213979e-02f, 1.34448007e-01f, -3.40673476e-02f, 8.40190127e-02f, -7.77175277e-02f, 1.55533375e-02f, 1.65599734e-02f,
  1.42953396e-01f, 5.63027821e-02f, 7.36082420e-02f, -4.09394689e-02f, 6.79426268e-02f, -3.21055725e-02f, 8.37149248e-02f, -6.99625462e-02f, -1.82510410e-02f, 6.79056719e-02f,
  5.98384701e-02f, 5.36413789e-02f, -2.21859869e-02f, 1.45145124e-02f, -3.97642665e-02f, -6.09382540e-02f, 1.53084427e-01f, 7.51314536e-02f, -8.16747323e-02f, 1.14087174e-02f,
  -6.64614365e-02f, -5.98553866e-02f, 6.72044903e-02f, -2.25252375e-01f, -3.70748714e-02f, 1.65111780e-01f, 1.92680582e-02f, -2.51726508e-02f, -1.32947803e-01f, 1.14731178e-01f,
  6.18483834e-02f, -1.46341383e-01f, 4.96706143e-02f, -5.47593199e-02f, 2.02600926e-01f, -8.29154402e-02f, -7.81732127e-02f, 2.02844534e-02f, 5.12005249e-03f, -5.06151319e-02f,
  1.78084478e-01f, 2.54577368e-01f, 1.76841859e-02f, -2.02006511e-02f, -1.35649011e-01f, 1.89895228e-01f, -1.40032740e-02f, 9.29291248e-02f, -2.23909244e-02f, -8.74223784e-02f,
  -7.79131651e-02f, 1.24810353e-01f, 1.57058332e-02f, 9.34624374e-02f, -7.09888041e-02f, 2.81317513e-02f, 4.40704785e-02f, 4.71617212e-04f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.14209773e-02f, 3.89012508e-02f, 2.46305554e-03f, -2.95324400e-02f, 3.48432846e-02f, -3.06452345e-02f, -8.47697407e-02f, 3.26527506e-02f, 4.11783010e-02f, -6.60954118e-02f,
  -7.12728277e-02f, 4.38130274e-03f, -1.64058506e-01f, 1.45928562e-01f, -5.69223575e-02f, -1.43396571e-01f, -7.77333323e-03f, -8.04540068e-02f, 7.30756521e-02f, 1.34832934e-01f,
  2.68882625e-02f, -1.43830180e-01f, 1.36248171e-01f, -1.36982545e-01f, -2.32787672e-02f, -9.01052654e-02f, 1.95091870e-02f, 1.17997325e-03f, -1.21251360e-01f, 8.39666724e-02f,
  -2.87597198e-02f, -7.20859915e-02f, -7.19439313e-02f, -1.44581333e-01f, -7.42940828e-02f, 6.67316699e-03f, -4.90883589e-02f, -8.19025747e-03f, -1.70847792e-02f, 1.09845325e-01f,
  2.87645966e-01f, -7.12622479e-02f, -4.03294191e-02f, 8.73395354e-02f, -4.54257317e-02f, 6.23441562e-02f, 1.36361960e-02f, -3.97775210e-02f, -8.19932893e-02f, -1.08043723e-01f,
  -8.32103640e-02f, -3.79484482e-02f, 8.61380547e-02f, 1.35106340e-01f, -1.33502364e-01f, 8.94178003e-02f, -2.25473829e-02f, 3.05771112e-01f, 1.86304688e-01f, 1.26473844e-01f,
  3.50414924e-02f, 2.43806601e-01f, 1.48267616e-02f, 1.24749348e-01f, 1.54081639e-02f, 2.88205948e-02f, 1.28195271e-01f, 1.62450060e-01f, 3.80419083e-02f, 1.00127608e-01f,
  6.30574375e-02f, 1.34584650e-01f, -1.85775943e-02f, 8.56831670e-02f, 1.86193749e-01f, 8.19531307e-02f, 6.46671886e-03f, 7.86825083e-03f, -6.14436623e-03f, -5.68285249e-02f,
  2.48738844e-02f, 7.69905373e-02f, -6.72653466e-02f, -9.44019109e-03f, 5.32920845e-02f, 1.07151523e-01f, -5.37406318e-02f, 2.02803477e-03f, 5.62363975e-02f, 2.68181507e-02f,
  -3.83933075e-02f, 6.11256622e-03f, -7.50171840e-02f, 1.82294115e-01f, 1.85838208e-01f, -6.68775812e-02f, -1.63163152e-02f, 1.31969392e-01f, 1.46815464e-01f, -1.51836455e-01f,
  9.41892937e-02f, 1.01295680e-01f, -4.92272489e-02f, -5.90261668e-02f, -2.58771647e-02f, 1.55355439e-01f, 4.74919006e-02f, 4.42619883e-02f, -2.08191779e-02f, 5.30529581e-02f,
  -1.61461830e-01f, -1.63412482e-01f, 9.87213477e-02f, 6.94174469e-02f, 1.34124711e-01f, -1.86724097e-01f, -3.77905034e-02f, -2.42323838e-02f, -1.45668471e-02f, 1.48419261e-01f,
  6.63176998e-02f, 9.54027325e-02f, -1.45535752e-01f, -8.72380938e-03f, 6.23182766e-02f, 6.92819012e-03f, 3.68830040e-02f, -9.94130671e-02f, 1.72839805e-01f, 1.21644817e-01f,
  1.35926321e-01f, -1.84780862e-02f, 6.81842342e-02f, 5.61340973e-02f, 1.34359851e-01f, 1.30890384e-01f, 1.66686028e-01f, 5.70192412e-02f, 1.16449587e-01f, -8.34141374e-02f,
  6.04430586e-02f, 5.89553546e-03f, -1.10593535e-01f, 1.27341956e-01f, 2.16319580e-02f, -3.90794873e-02f, 2.70296335e-02f, -5.52027300e-02f, -7.40068182e-02f, -3.92052718e-02f,
  1.67620972e-01f, 6.91041648e-02f, -1.66988429e-02f, -1.61959778e-03f, -4.35149744e-02f, 1.64656341e-02f, -7.28280023e-02f, -1.96960166e-01f, -9.16494578e-02f, 8.44403729e-02f,
  2.09233582e-01f, 4.01372015e-02f, -1.04795165e-01f, -4.65108939e-02f, 6.83929771e-02f, -3.64352688e-02f, 9.32102427e-02f, -1.00425154e-01f, 1.74685180e-01f, -2.51873909e-03f,
  -1.56707801e-02f, 8.60531814e-03f, 3.49813811e-02f, -9.79278386e-02f, 2.13516220e-01f, 1.82185650e-01f, -5.11763729e-02f, 5.23541197e-02f, -5.01051471e-02f, 2.75932908e-01f,
  -1.26841683e-02f, 1.38990983e-01f, 1.07259981e-01f, 5.07592820e-02f, 6.16653748e-02f, 6.14869297e-02f, 1.71712667e-01f, 2.99744368e-01f, 2.15570995e-04f, -2.66608838e-02f,
  4.79538552e-02f, 8.56153369e-02f, 4.54529747e-02f, 1.00169748e-01f, 1.99232250e-02f, 6.16504699e-02f, 1.29602114e-02f, 2.84971539e-02f, -4.57638390e-02f, -2.60438267e-02f,
  4.17378508e-02f, 2.41986709e-03f, 3.63162346e-02f, 1.33185282e-01f, -2.87569642e-01f, 1.08665302e-01f, -1.29461184e-01f, -8.46686065e-02f, 1.49544952e-02f, -2.57816780e-02f,
  1.33440956e-01f, 1.64761931e-01f, -1.59891337e-01f, 3.83214206e-02f, -1.41248882e-01f, -7.48726502e-02f, 5.81766032e-02f, -8.18751827e-02f, 1.63400397e-01f, 1.00196704e-01f,
  -9.11411941e-02f, 9.63576697e-03f, -6.00196384e-02f, -1.47450015e-01f, -8.30350369e-02f, -1.09558590e-01f, 1.49865355e-02f, -3.13919820e-02f, -2.79530883e-02f, -4.88977171e-02f,
  3.67157049e-02f, 2.58739859e-01f, 4.37792689e-02f, -3.78441438e-02f, 8.98191705e-02f, 1.73484404e-02f, 3.44630666e-02f, 2.31738895e-01f, -6.29821718e-02f, -2.33309865e-01f,
  -1.28570035e-01f, -3.86786908e-02f, -6.71394095e-02f, -2.29546875e-01f, 8.73666704e-02f, 7.99133256e-02f, -9.92771313e-02f, 2.64461726e-01f, 1.50435433e-01f, 7.70003274e-02f,
  1.03582650e-01f, -1.16990551e-01f, 7.81667382e-02f, 2.80614614e-01f, 1.83161360e-03f, 6.59564510e-02f, -8.57448671e-03f, 9.73476097e-02f, -2.58696731e-02f, 1.61484778e-02f,
  3.96110304e-02f, 4.10332084e-02f, -1.08462602e-01f, 1.50582148e-03f, 6.00121403e-03f, 4.22836691e-02f, 1.04023013e-02f, 1.79792911e-01f, -6.70933723e-02f, 1.16592623e-01f,
  3.99649180e-02f, -1.17607646e-01f, -6.35067970e-02f, -1.89382285e-02f, -2.09501442e-02f, 1.16596967e-01f, 2.20173225e-02f, -3.52176540e-02f, -9.52231362e-02f, -5.83836287e-02f,
  1.53554082e-01f, 3.62330489e-02f, 1.13739446e-01f, 5.17069697e-02f, 6.18186183e-02f, 1.75080463e-01f, 1.34377092e-01f, -7.62682259e-02f, -3.58158015e-02f, -6.81581646e-02f,
  2.89648548e-02f, 1.41244531e-01f, -4.76722829e-02f, 1.20486848e-01f, 2.16325391e-02f, 1.13713957e-01f, -1.01536281e-01f, 4.92754057e-02f, 4.68691178e-02f, 3.03724241e-02f,
  3.32176313e-02f, 1.78643525e-01f, -6.85896818e-03f, -9.93384570e-02f, -3.41170691e-02f, -5.31720184e-02f, 6.61697760e-02f, -9.21709538e-02f, 6.74958453e-02f, -9.41514671e-02f,
  4.47179228e-02f, 8.58192667e-02f, -3.47105823e-02f, -7.81350434e-02f, 1.47126377e-01f, 1.11974068e-01f, 8.21825489e-03f, 8.80476534e-02f, -8.06751549e-02f, 1.72627196e-01f,
  3.94468829e-02f, 7.05468794e-03f, 9.91423056e-02f, 9.43757128e-03f, 1.30847871e-01f, 9.98293161e-02f, 1.19383343e-01f, 1.06539451e-01f, 3.82821225e-02f, 2.48759426e-02f,
  1.06760807e-01f, 7.19865561e-02f, 1.99530367e-02f, 1.20142601e-01f, -2.50976477e-02f, -1.09582253e-01f, -4.75352108e-02f, -9.34949964e-02f, -8.76448080e-02f, -9.08701941e-02f,
  1.44752219e-01f, -7.26769939e-02f, 5.23737371e-02f, -7.37423152e-02f, -2.04342932e-01f, 2.51294691e-02f, -8.30770582e-02f, -2.71946769e-02f, -2.02801138e-01f, -2.93639954e-03f,
  1.29256964e-01f, 1.31093208e-02f, 2.00617015e-01f, 1.24062672e-01f, 8.92006382e-02f, -1.45807460e-01f, 8.24249908e-02f, 2.16795847e-01f, -1.38394386e-01f, -1.67883009e-01f,
  5.82337342e-02f, 7.55121559e-02f, 1.21556826e-01f, 4.21997868e-02f, -4.96122316e-02f, -1.70664757e-01f, -2.93411445e-02f, 4.52552289e-02f, 1.16419517e-01f, 9.67235118e-02f,
  1.04625098e-01f, 5.88223524e-02f, -5.51867709e-02f, -3.81484926e-02f, 9.19355452e-02f, -2.24135399e-01f, 8.88170302e-02f, 1.61370523e-02f, -1.02391146e-01f, 6.09735660e-02f,
  -6.37916699e-02f, -5.92362396e-02f, 1.25751868e-01f, -5.92924729e-02f, 9.40066669e-03f, 5.37319817e-02f, 1.01188503e-01f, 1.44718260e-01f, 7.25925192e-02f, 7.13810846e-02f,
  6.02867343e-02f, -3.64131182e-02f, 1.40772060e-01f, 5.34135997e-02f, 8.30356628e-02f, 7.00593591e-02f, -1.64483920e-01f, -1.44344196e-01f, 2.35308677e-01f, 1.26194194e-01f,
  1.78842664e-01f, -1.66342426e-02f, 1.17926553e-01f, 1.02399081e-01f, -1.40530363e-01f, -1.31566748e-02f, -1.04937986e-01f, -2.15627421e-02f, -3.24141141e-03f, 1.42519265e-01f,
  2.50532180e-01f, 1.13437459e-01f, 2.22365260e-01f, 6.04863316e-02f, -7.14307129e-02f, -3.66503373e-02f, -5.36298268e-02f, -1.01372160e-01f, 4.02939916e-02f, 6.82817027e-02f,
  -4.60093059e-02f, -1.73294753e-01f, 1.39411055e-02f, 2.62304813e-01f, -9.45592746e-02f, 8.89036153e-03f, 1.49495423e-01f, -2.29602754e-02f, 1.20865628e-01f, 9.79966819e-02f,
  -1.62687987e-01f, -1.78933963e-01f, -5.79208918e-02f, 3.94812189e-02f, 1.27209961e-01f, 1.60961300e-01f, 6.23315759e-02f, -7.22723156e-02f, -2.39763707e-02f, 4.26439159e-02f,
  1.78158879e-02f, -7.32159540e-02f, -3.70850116e-02f, 1.28787933e-02f, -3.62098813e-02f, 1.80872574e-01f, -1.20431617e-01f, -2.46421881e-02f, -2.72894884e-03f, -2.35925186e-02f,
  5.04967906e-02f, 4.41398397e-02f, 1.00930691e-01f, 7.55870640e-02f, 1.27282321e-01f, 1.71636969e-01f, 9.17548314e-02f, 1.81721047e-01f, 9.97142047e-02f, 1.47638679e-01f,
  3.18631046e-02f, 9.69594941e-02f, 4.23423834e-02f, 4.62081609e-03f, 8.98985844e-03f, -7.88512677e-02f, -2.51520332e-02f, -1.72603533e-01f, 7.56219178e-02f, 2.18349490e-02f,
  1.76469404e-02f, -6.75043911e-02f, -1.24619655e-01f, 1.56209901e-01f, 1.72739569e-02f, -4.58139181e-03f, -6.93206564e-02f, -2.20261235e-02f, 1.16176464e-01f, 3.22603360e-02f,
  2.88720995e-01f, 1.45196095e-01f, 6.11945093e-02f, -7.24105239e-02f, 1.57651931e-01f, 3.17479819e-01f, -4.96639609e-02f, -1.47862673e-01f, -1.57260165e-01f, 1.35602877e-02f,
  2.01269776e-01f, 9.73055372e-04f, -6.69232523e-03f, -1.15937136e-01f, -1.63277671e-01f, -9.82355848e-02f, 1.51825398e-01f, 1.51709318e-01f, 9.95740667e-02f, 5.60351312e-02f,
  -4.73740175e-02f, -9.60980356e-02f, 1.27638921e-01f, -6.05561472e-02f, 1.38014510e-01f, -2.03404538e-02f, -7.27128014e-02f, 2.55053397e-02f, -9.31646966e-04f, -1.51438802e-01f,
  6.46692291e-02f, -7.63004571e-02f, 1.20846912e-01f, 7.61940628e-02f, 7.94771127e-03f, 2.78907493e-02f, 1.31235085e-02f, -2.22806055e-02f, 6.32908717e-02f, 6.31305277e-02f,
  -3.06738187e-02f, 4.15052101e-02f, 6.76894709e-02f, 4.81673852e-02f, -6.99269399e-02f, -6.15290217e-02f, -1.77386701e-01f, -1.24042057e-01f, -2.91236397e-03f, 1.70468956e-01f,
  2.53701042e-02f, -1.51226223e-02f, -1.85005367e-01f, 8.12685788e-02f, -8.15422758e-02f, 1.11185402e-01f, 5.24191409e-02f, -6.91832155e-02f, -7.93960541e-02f, -9.66896955e-03f,
  -1.34552093e-02f, -1.02842294e-01f, 4.15049344e-02f, -8.84345919e-02f, -1.44854143e-01f, 4.22097230e-03f, -3.32941040e-02f, -1.24682181e-01f, 1.62904654e-02f, -6.27522618e-02f,
  6.51036501e-02f, 6.40910119e-02f, 7.94488285e-03f, -9.96564887e-03f, -8.86990353e-02f, -7.96045586e-02f, 4.47953679e-02f, 1.27773374e-01f, 7.86698610e-03f, -3.78772803e-02f,
  -9.64026600e-02f, 5.86755238e-02f, -6.91717565e-02f, -1.85231209e-01f, 9.00698230e-02f, 6.35964200e-02f, 4.81979968e-03f, 3.01537246e-01f, 5.64309955e-02f, 7.14661274e-03f,
  3.39843892e-02f, -9.35825780e-02f, 1.12634055e-01f, -4.92973253e-02f, -2.60648783e-02f, -1.65382754e-02f, -1.54505327e-01f, -4.90551330e-02f, -3.95646729e-02f, 2.43685115e-02f,
  4.16375697e-02f, 2.31634006e-02f, -1.44655928e-01f, -6.15856610e-03f, -1.23527437e-01f, 2.33075321e-02f, 3.82671095e-02f, 6.21542148e-02f, 2.85989270e-02f, -5.85698010e-03f,
  5.44596501e-02f, -7.18145296e-02f, 1.38552915e-02f, 1.00847613e-02f, -1.44874111e-01f, 5.73069863e-02f, 1.47098839e-01f, 4.73102555e-02f, -7.09768757e-02f, -4.69168089e-02f,
  1.22673690e-01f, 6.98964447e-02f, 1.24210797e-01f, 1.51043743e-01f, 1.36907265e-01f, 3.00700843e-01f, 7.59887248e-02f, -6.85139447e-02f, -1.34701535e-01f, 2.90281009e-02f,
  2.16253027e-01f, 5.89556396e-02f, -7.51247481e-02f, -2.21789647e-02f, -6.82216957e-02f, 1.35926515e-01f, -3.09931077e-02f, 1.58940628e-01f, 2.70930100e-02f, 4.12449799e-02f,
  -6.99329376e-02f, 2.17098054e-02f, -4.16489802e-02f, -1.97073817e-02f, 8.98376480e-02f, -4.51480458e-03f, 1.78479329e-01f, -1.62571028e-01f, 1.86456356e-03f, 6.97477628e-03f,
  8.94722939e-02f, -6.49611950e-02f, -1.12160183e-01f, 1.72966179e-02f, -3.73384394e-02f, -1.11461841e-01f, 1.14755653e-01f, 1.57401532e-01f, -4.83969450e-02f, 4.87167686e-02f,
  5.67258969e-02f, -4.57359105e-03f, 9.57268924e-02f, 6.88383356e-02f, -3.22350953e-03f, 8.94231275e-02f, 1.34879164e-02f, 1.25042930e-01f, 1.35414684e-02f, 4.15652432e-02f,
  6.58322647e-02f, 1.51040092e-01f, 5.80266975e-02f, -1.62655264e-01f, 1.29709411e-02f, -2.41177306e-02f, 1.01307772e-01f, 8.43284205e-02f, -4.82183248e-02f, -7.90521353e-02f,
  -3.50565836e-02f, 8.16642344e-02f, -7.42108002e-02f, 3.36659029e-02f, 1.28559887e-01f, 1.51325360e-01f, 3.27736959e-02f, 6.26617223e-02f, 1.71999410e-01f, 3.20403241e-02f,
  -3.63595895e-02f, 3.54574509e-02f, -7.28314295e-02f, 1.38817010e-02f, 3.42960283e-02f, -1.56053230e-02f, -4.71327230e-02f, 3.40324119e-02f, -2.24971562e-03f, 1.78784300e-02f,
  -1.00520015e-01f, 7.15963989e-02f, -7.72959962e-02f, -1.72761884e-02f, 3.73754501e-02f, 4.46253344e-02f, -1.32261574e-01f, -6.18016198e-02f, 7.63142994e-03f, 8.62030908e-02f,
  5.79071827e-02f, 5.37782535e-02f, -5.21739870e-02f, -1.16015211e-01f, -1.28385443e-02f, 3.04149035e-02f, 4.66623902e-02f, -5.30204885e-02f, -4.34862338e-02f, -2.00885788e-01f,
  6.65101558e-02f, -4.42147739e-02f, -1.40284626e-02f, -1.33083574e-02f, 1.43782869e-01f, 1.15066811e-01f, 3.93570261e-03f, 6.23945780e-02f, 4.29389849e-02f, 3.20908166e-02f,
  -2.26276070e-02f, -2.95166634e-02f, 3.72313336e-02f, 2.07346678e-02f, 9.41343885e-03f, 5.30123077e-02f, -1.33419961e-01f, -2.10677125e-02f, -2.18163893e-01f, -7.61265382e-02f,
  3.54324584e-03f, 3.37650045e-03f, 7.02023506e-02f, 4.62808721e-02f, -1.07943751e-01f, -3.57174836e-02f, 3.02179474e-02f, 5.34250308e-03f, 1.95661023e-01f, -1.23717012e-02f,
  -6.47199620e-03f, 8.07512105e-02f, 9.06860176e-03f, -1.80091001e-02f, -5.26643880e-02f, -1.30701229e-01f, -6.24095798e-02f, -7.35014006e-02f, -9.38702747e-03f, -3.94218527e-02f,
  2.65125046e-03f, -4.78803702e-02f, 8.08875561e-02f, 1.11453898e-01f, 1.37281075e-01f, -7.62622757e-03f, 7.44676590e-03f, -7.41202906e-02f, 8.96103904e-02f, 1.52070850e-01f,
  6.89567700e-02f, -1.99938342e-02f, -1.27793878e-01f, 6.59072325e-02f, -4.69146110e-02f, -6.52929842e-02f, 1.06965885e-01f, 1.37535095e-01f, -4.15497050e-02f, 3.33856344e-01f,
  1.02003835e-01f, 1.19101048e-01f, 8.63292664e-02f, -4.23453897e-02f, 1.05148107e-01f, 1.05133317e-01f, -1.67239811e-02f, 4.57608141e-02f, 1.68621644e-01f, 1.21430591e-01f,
  7.82487467e-02f, 4.42462638e-02f, 1.02160424e-01f, 1.37794307e-02f, 5.83976321e-02f, 7.88307115e-02f, 9.92971733e-02f, -3.75526287e-02f, 3.60244289e-02f, -7.67310634e-02f,
  3.85079794e-02f, 6.57726675e-02f, -1.32715134e-02f, -1.12486519e-01f, -7.59744644e-02f, -8.90531614e-02f, -2.18012929e-02f, 9.45566148e-02f, 6.41578361e-02f, -1.23033591e-01f,
  1.79487452e-01f, -9.08718929e-02f, -1.76849723e-01f, -8.70951936e-02f, -1.10657819e-01f, -7.22064227e-02f, -2.50658453e-01f, -1.18427137e-02f, 1.24073148e-01f, 1.88114326e-02f,
  3.59315984e-02f, -8.73506814e-03f, -1.55688152e-01f, -3.28863673e-02f, 6.70299456e-02f, 1.37084022e-01f, 7.10505620e-02f, -9.05650109e-02f, 1.99546963e-01f, -1.58707842e-01f,
  -2.12201979e-02f, 1.33551434e-01f, -8.83933157e-02f, -8.78973976e-02f, 6.72328547e-02f, 2.06747994e-01f, -1.21674761e-02f, -1.07859768e-01f, -1.85479119e-01f, -2.70641036e-02f,
  4.16214438e-03f, 1.36470526e-01f, -1.71905503e-01f, -2.92285457e-02f, -9.64134373e-03f, 2.15777069e-01f, 2.39844117e-02f, 1.33294597e-01f, 8.36903462e-04f, 7.84369782e-02f,
  1.49376363e-01f, 8.78365487e-02f, 5.66832013e-02f, 1.63369905e-02f, 9.68224779e-02f, 7.75202969e-03f, 1.02752335e-02f, 1.11832500e-01f, 1.86964989e-01f, 7.63115659e-02f,
  8.87857378e-02f, 4.14947830e-02f, 1.12476438e-01f, 1.50891568e-03f, 1.83001697e-01f, -1.31553978e-01f, 1.04432315e-01f, 7.16579482e-02f, 8.18312913e-02f, 4.41188924e-02f,
  5.07648438e-02f, -1.08667456e-01f, -1.07911661e-01f, 4.36795987e-02f, 8.04974511e-02f, 1.35046244e-01f, -3.71663645e-02f, 1.24101631e-01f, 7.74589032e-02f, -8.26027766e-02f,
  1.51083067e-01f, -1.92522407e-01f, -9.50416327e-02f, 2.13557661e-01f, 1.23611704e-01f, 4.20317240e-02f, -6.38835728e-02f, 3.56523879e-02f, 1.23555891e-01f, -1.47094190e-01f,
  3.80428582e-02f, -8.04230124e-02f, -4.77978922e-02f, -5.81949651e-02f, -2.46110335e-02f, -9.03635770e-02f, 1.89516842e-02f, -3.88259403e-02f, 1.31987110e-01f, 1.33356810e-01f,
  4.19408502e-03f, 5.96819483e-02f, -3.79765802e-03f, 2.94555843e-01f, 7.77475834e-02f, -7.93630779e-02f, 5.08556105e-02f, -9.13747400e-02f, 1.43381516e-02f, -8.82361531e-02f,
  3.85051891e-02f, 4.03799564e-02f, -1.42867619e-03f, -1.26226008e-01f, -3.68464622e-03f, -2.70912182e-02f, -6.64043501e-02f, 2.70778369e-02f, -3.14620435e-02f, -1.86388253e-03f,
  1.02839023e-02f, 8.98180157e-02f, -1.03088655e-01f, -7.80683979e-02f, 7.34010711e-02f, 3.33225615e-02f, -6.14013001e-02f, 1.00579873e-01f, -4.33724336e-02f, -5.60598560e-02f,
  2.61516005e-01f, 7.84180835e-02f, 6.02860153e-02f, 1.93619933e-02f, 1.34996682e-01f, 7.18676448e-02f, -5.79221621e-02f, 3.92948166e-02f, -4.52745259e-02f, 7.85119012e-02f,
  -7.81588405e-02f, 1.37435392e-01f, 2.24526912e-01f, 3.31219994e-02f, 1.09218098e-01f, 2.86532063e-02f, -7.65217692e-02f, 8.75520110e-02f, -2.11564582e-02f, -1.22783676e-01f,
  1.05751688e-02f, 1.01433098e-01f, -7.30124256e-03f, -3.59444320e-02f, 1.18946461e-02f, 2.25684658e-01f, -3.73362447e-03f, -5.77088520e-02f, 9.59685445e-02f, -3.21104825e-02f,
  -1.60492472e-02f, 1.39494181e-01f, -8.53798464e-02f, -8.22749287e-02f, -4.71898504e-02f, -5.81996776e-02f, 5.55843338e-02f, 1.38996646e-01f, -2.23626066e-02f, -1.26902133e-01f,
  1.84529554e-02f, -1.48699190e-02f, -4.02111746e-02f, -6.65824413e-02f, 6.54851273e-02f, -4.52343039e-02f, -9.20661315e-02f, 1.85410693e-01f, -5.45490757e-02f, -5.03650261e-03f,
  1.45218313e-01f, 2.36900542e-02f, 9.98570621e-02f, -1.27909286e-02f, 8.10621399e-03f, 3.89351174e-02f, 1.28032565e-01f, 2.30121631e-02f, 1.30882174e-01f, 2.56471410e-02f,
  -1.33628352e-02f, 4.50097695e-02f, 1.54302716e-01f, -6.76497221e-02f, 1.96450576e-02f, 1.49681926e-01f, 6.01291237e-03f, 2.67582014e-02f, 2.28975508e-02f, -2.16862317e-02f,
  -6.64722361e-03f, -1.03744492e-01f, 9.57540572e-02f, 9.84018445e-02f, 1.13270909e-01f, -3.39928828e-02f, -5.14411591e-02f, -6.43092543e-02f, 1.52062908e-01f, -1.07205562e-01f,
  -2.02059224e-02f, 9.41121429e-02f, 1.35030868e-02f, -1.08482696e-01f, -1.06765211e-01f, 5.33259660e-02f, -4.35758419e-02f, -4.42270152e-02f, 1.25014514e-01f, 3.94958258e-02f,
  -1.30187079e-01f, -5.89850359e-02f, -5.02488054e-02f, -4.06985655e-02f, 1.33517943e-02f, 4.50248607e-02f, 1.83507800e-01f, 1.98279724e-01f, -5.76853789e-02f, -3.23894843e-02f,
  -5.64133711e-02f, 2.26412997e-01f, 2.54830178e-02f, 2.51265038e-02f, 7.82021042e-03f, -1.15854152e-01f, -4.02062647e-02f, -1.56652331e-01f, 1.68498844e-01f, 1.81223914e-01f,
  -7.50187859e-02f, -7.03257024e-02f, -1.09311238e-01f, 7.45119154e-02f, 8.95668417e-02f, 8.31844956e-02f, 1.30691722e-01f, 4.91691940e-02f, 1.08848788e-01f, 5.27456030e-02f,
  4.81552221e-02f, 9.53950062e-02f, 2.06486601e-02f, 1.25951871e-01f, 1.08967543e-01f, 8.08800682e-02f, -2.46415231e-02f, 2.72152363e-04f, 1.69698019e-02f, 5.80767915e-03f,
  1.62416659e-02f, -4.80744392e-02f, -4.01898474e-02f, -1.94734916e-01f, 3.42816561e-02f, 2.71008108e-02f, -8.80296621e-03f, -7.40308538e-02f, -6.94550872e-02f, 6.23766072e-02f,
  1.03554286e-01f, 8.35547224e-02f, -4.04345952e-02f, 1.29759591e-02f, 8.16587135e-02f, -1.19484188e-02f, 2.11631864e-01f, 1.00260496e-01f, 1.45598516e-01f, -9.59313735e-02f,
  5.56903668e-02f, 1.29275784e-01f, -2.70130038e-02f, -8.73367265e-02f, -2.06721928e-02f, 1.37018889e-01f, 1.69002369e-01f, 4.95926738e-02f, 1.89953949e-02f, -8.27539787e-02f,
  -1.77437991e-01f, -1.51686594e-01f, 1.32859170e-01f, 1.57606199e-01f, 1.40860245e-01f, 2.75928900e-02f, -1.49039909e-01f, 8.28723889e-03f, 5.72850779e-02f, -2.48276982e-02f,
  1.60086095e-01f, 9.12642106e-02f, -1.83858067e-01f, -9.69809145e-02f, 6.02012351e-02f, 6.03027418e-02f, 1.17732361e-01f, -6.53084666e-02f, 1.67597905e-01f, 1.03536144e-01f,
  1.10776864e-01f, 2.15232983e-01f, 1.47044897e-01f, 3.86785865e-02f, 1.05347268e-01f, 8.53446051e-02f, 1.12539418e-02f, 1.69912368e-01f, 1.71516135e-01f, 8.30170587e-02f,
  1.53936669e-01f, -1.65047407e-01f, -1.35881498e-01f, -8.86958614e-02f, -1.43559286e-02f, 2.59382516e-01f, -1.52527750e-01f, -1.21842034e-01f, -9.06678662e-02f, 1.43944293e-01f,
  -9.24092606e-02f, 6.61245212e-02f, 1.75866202e-01f, -1.85954608e-02f, -2.04866081e-01f, 1.92212760e-02f, 2.00825743e-02f, 5.32290563e-02f, 2.25606039e-02f, 9.55630690e-02f,
  -1.48290917e-01f, 1.84962854e-01f, 1.44426916e-02f, -6.86461478e-02f, 8.45379606e-02f, -3.12974788e-02f, 6.25191182e-02f, -7.92347193e-02f, 3.71738225e-02f, 6.35435805e-02f,
  -2.41938010e-01f, -6.10527955e-02f, -7.31879333e-03f, 5.63575663e-02f, -3.97400633e-02f, 1.16136685e-01f, 5.26160859e-02f, 6.54427484e-02f, -1.21305287e-01f, -1.83931679e-01f,
  1.01992667e-01f, 1.19969651e-01f, -9.46585089e-02f, 1.35526478e-01f, -3.31526585e-02f, 8.67761001e-02f, -1.62398085e-01f, -2.46469513e-01f, 1.42917737e-01f, -9.76513773e-02f,
  6.52663112e-02f, -1.43788010e-01f, 8.51757452e-02f, 4.45609353e-02f, 8.02269652e-02f, 1.82516202e-02f, -3.13296728e-02f, 1.09237574e-01f, 1.92527231e-02f, 6.93758056e-02f,
  1.18720889e-01f, 3.74714807e-02f, 2.89655570e-02f, 1.26122788e-01f, 1.85434446e-02f, -1.03081167e-01f, 1.24630749e-01f, 4.03638706e-02f, 9.35420915e-02f, 4.65610959e-02f,
  5.01757972e-02f, 4.11109701e-02f, -6.87286481e-02f, 1.52988769e-02f, -1.45111764e-02f, 5.34372032e-02f, 9.40198600e-02f, 6.49305806e-02f, 1.14767164e-01f, -1.99202052e-03f,
  3.07572573e-01f, -6.38597608e-02f, -6.94465414e-02f, 5.12590352e-03f, 5.43052051e-03f, -9.07636955e-02f, -4.89972085e-02f, 1.59609139e-01f, -1.74019039e-02f, -1.55599013e-01f,
  1.21507272e-01f, 5.95826991e-02f, -1.18990608e-01f, -3.85880545e-02f, -2.84711681e-02f, -3.64458114e-02f, -1.67980306e-02f, 8.39337185e-02f, -1.20583670e-02f, -6.74522594e-02f,
  -9.36461240e-02f, -1.13202455e-02f, -2.97297835e-02f, 1.08265877e-01f, 1.08147316e-01f, -1.55887201e-01f, 2.78850067e-02f, 5.87577149e-02f, -2.25073453e-02f, -1.43506050e-01f,
  1.30998194e-01f, 3.81382182e-02f, 2.47081593e-02f, 1.45179527e-02f, -7.71902502e-02f, 7.22475722e-02f, 7.40199164e-02f, 2.36286130e-02f, 5.57108186e-02f, 1.64182022e-01f,
  1.30397603e-01f, 1.25662461e-01f, 1.01556666e-01f, 8.60782340e-02f, 9.46700051e-02f, 1.92016587e-01f, 1.42803043e-01f, 6.25184327e-02f, -3.72276530e-02f, -6.08886890e-02f,
  3.89917456e-02f, -4.71659154e-02f, 1.23270340e-01f, 8.69868919e-02f, -6.05974346e-03f, -2.21994072e-01f, 6.25120178e-02f, 1.21609315e-01f, -1.43290430e-01f, -7.57351518e-02f,
  1.50702104e-01f, 1.37359664e-01f, 1.11658685e-01f, 3.22218463e-02f, 9.19260010e-02f, 1.04783632e-01f, 1.39920905e-01f, -4.13538069e-02f, 1.52920082e-01f, 1.40349180e-01f,
  1.33404970e-01f, -1.18262835e-01f, 8.21456984e-02f, 1.54357791e-01f, -6.19667359e-02f, -1.02697074e-01f, -1.68185532e-01f, 1.58338830e-01f, 9.57748592e-02f, -6.75373850e-03f,
  6.95152953e-02f, -2.13940013e-02f, -1.63544074e-01f, -1.21762171e-01f, 3.31400521e-02f, 1.18217610e-01f, 1.64648101e-01f, -3.31579596e-02f, -7.71362931e-02f, -9.79790315e-02f,
  9.20305997e-02f, 1.12650827e-01f, 1.47611067e-01f, -2.29224171e-02f, -2.04830170e-01f, -6.60530552e-02f, 4.64663021e-02f, -1.22518979e-01f, 6.78990632e-02f, -5.79796657e-02f,
  7.58281499e-02f, 4.11998900e-03f, 2.92429924e-02f, 7.10832980e-03f, 3.32165472e-02f, 1.08257689e-01f, 7.15810284e-02f, 9.68712419e-02f, 1.07695833e-01f, 5.09127304e-02f,
  7.73505867e-03f, 2.60075256e-02f, 1.18646681e-01f, -1.70766801e-01f, 1.34500563e-01f, 1.86249167e-01f, 1.41136572e-01f, -5.58026694e-02f, 9.04423818e-02f, -1.80002928e-01f,
  -7.72910491e-02f, 1.19890636e-02f, 9.83192623e-02f, 8.61889347e-02f, 2.05132384e-02f, 1.50872290e-01f, 1.64623439e-01f, 2.99939350e-03f, 1.78114593e-01f, -1.12596653e-01f,
  -1.74637869e-01f, 1.17417164e-01f, 1.24997929e-01f, -6.34812564e-02f, -1.31514436e-02f, 8.42085201e-03f, 4.07580053e-03f, -4.90985736e-02f, 9.18632559e-03f, -3.80036607e-02f,
  -4.74251211e-02f, -1.08245388e-02f, 9.57902521e-02f, -5.23954481e-02f, 4.26563621e-02f, -9.98760536e-02f, 5.38232289e-02f, 8.97869840e-02f, -5.97781576e-02f, 6.48886561e-02f,
  1.77389421e-02f, 2.52307743e-01f, -1.28798997e-02f, -8.23497847e-02f, -3.07084830e-03f, -1.49653628e-01f, 1.03971772e-01f, -9.18315351e-02f, 6.62185103e-02f, 5.84048778e-02f,
  5.52329840e-03f, -2.89735533e-02f, -2.62227487e-02f, -5.76704666e-02f, 4.75127697e-02f, 1.65752843e-02f, 4.28015040e-03f, 3.74583788e-02f, 3.77061330e-02f, 1.45777129e-02f,
  -7.41516575e-02f, 4.50790413e-02f, 1.33808970e-01f, 1.96243022e-02f, 3.54057364e-02f, 6.32808134e-02f, -1.48264900e-01f, 1.58175491e-02f, 1.98376164e-01f, 1.32044733e-01f,
  1.93460081e-02f, -1.88915823e-02f, 7.42320940e-02f, -3.83104943e-02f, -8.88804868e-02f, 3.43549848e-02f, -5.55545352e-02f, 2.30282526e-02f, -1.66974992e-01f, 1.28640756e-01f,
  1.60020187e-01f, -1.08622283e-01f, -3.22004370e-02f, 4.15357314e-02f, 4.18079607e-02f, -3.76351774e-02f, 8.07501301e-02f, -1.22512110e-01f, 6.07187934e-02f, 9.39719193e-03f,
  -3.15190256e-02f, 4.13334630e-02f, -3.06146801e-03f, 1.59105182e-01f, -1.13865316e-01f, 1.76903829e-02f, 1.57147393e-01f, -6.13613660e-03f, 8.20759088e-02f, 5.85504360e-02f,
  -1.35682836e-01f, -8.69868249e-02f, -7.98682217e-03f, 7.21040042e-03f, 1.71075583e-01f, 2.51556537e-03f, -1.62004121e-02f, -1.11847542e-01f, 1.28572658e-01f, 8.23800787e-02f,
  8.43239799e-02f, -7.38590732e-02f, -6.59847260e-02f, -5.28257452e-02f, -2.33220365e-02f, 1.73187494e-01f, -5.88171035e-02f, -8.22698995e-02f, 5.57195581e-02f, -4.97482456e-02f,
  8.81255232e-03f, 7.75658386e-03f, 1.25145996e-02f, 4.91645411e-02f, 2.39484925e-02f, 4.30786284e-03f, 5.85931279e-02f, 1.30015821e-03f, -1.34233898e-02f, -2.70734597e-02f,
  1.70878768e-01f, -6.71025366e-02f, 5.20351082e-02f, 4.01268788e-02f, 1.23221362e-02f, 7.61530921e-02f, -7.05735683e-02f, 2.43006852e-02f, -1.10323615e-02f, 2.61053313e-02f,
  -7.34413834e-03f, 7.15758204e-02f, -2.64875777e-02f, 6.90047117e-03f, -2.62873471e-02f, -1.26650259e-02f, 1.67714506e-01f, -6.36064727e-03f, 3.35332491e-02f, 1.38458252e-01f,
  -5.55275828e-02f, -4.51765656e-02f, -4.06604260e-02f, 9.59292948e-02f, -2.16311496e-02f, -7.60851502e-02f, 1.64917316e-02f, -2.06733439e-02f, -7.30389282e-02f, -3.05150710e-02f,
  -1.11351646e-01f, -1.28729381e-02f, -7.43205845e-02f, -1.75871812e-02f, 5.84503859e-02f, 6.77715093e-02f, -2.97105778e-02f, -6.86908364e-02f, -9.33893546e-02f, 7.49415159e-02f,
  1.98533367e-02f, -2.63811871e-02f, -1.33101381e-02f, -5.36811762e-02f, -7.16240332e-02f, -1.25941992e-01f, 4.56233807e-02f, 4.77612484e-03f, -2.34803502e-02f, -4.49742600e-02f,
  -4.74611260e-02f, -2.54322067e-02f, 2.19295397e-01f, 1.18177548e-01f, 1.24276854e-01f, 1.38915554e-01f, 1.84138775e-01f, 1.32526129e-01f, 1.35311976e-01f, 1.42670110e-01f,
  1.05060972e-01f, 1.45180836e-01f, 1.33566707e-01f, 2.20019042e-01f, -2.37429693e-01f, 9.90534648e-02f, 4.99991216e-02f, -9.29407179e-02f, -1.33885341e-02f, -3.86809744e-02f,
  6.59188032e-02f, -8.78319666e-02f, -7.72269517e-02f, -5.33663146e-02f, -3.61486562e-02f, -1.69322863e-01f, -2.06890509e-01f, 4.72289734e-02f, 1.64685417e-02f, -9.84760746e-02f,
  -1.28341809e-01f, -1.23966426e-01f, 1.63302734e-01f, -1.43730029e-01f, 2.39426553e-01f, -3.78064439e-03f, -8.40312615e-02f, -1.46466658e-01f, 5.04310578e-02f, 2.67650485e-01f,
  4.15489823e-02f, -4.03361432e-02f, -1.88471340e-02f, 4.34250161e-02f, 1.98215902e-01f, 1.27507430e-02f, 1.30196139e-01f, 1.38772549e-02f, -1.80649802e-01f, -1.78018123e-01f,
  -1.02378875e-01f, 5.90680800e-02f, 1.99237037e-02f, -3.24268416e-02f, -1.61327291e-02f, -2.33723689e-03f, 2.93657873e-02f, 2.43480608e-01f, 1.76160410e-01f, -5.21288440e-02f,
  6.44973340e-03f, 1.09761015e-01f, 2.59336904e-02f, -1.86051223e-02f, 5.01377471e-02f, 2.40998454e-02f, 2.14606181e-01f, 1.37757391e-01f, 1.41397327e-01f, 6.56454861e-02f,
  8.10243338e-02f, 1.11508658e-02f, 1.65140599e-01f, 1.20606482e-01f, 1.49843633e-01f, 2.93874945e-02f, 1.26744911e-01f, -4.98956814e-02f, 1.72329769e-01f, -3.09403781e-02f,
  -3.27849299e-01f, 7.13326633e-02f, 1.74729656e-02f, 2.39191875e-01f, -1.17575981e-01f, -1.14188112e-01f, -9.55259427e-02f, 1.25867035e-02f, -6.74664974e-02f, 2.33751655e-01f,
  1.07285477e-01f, -7.13999718e-02f, -1.17462054e-01f, -5.44542894e-02f, -9.67808142e-02f, -2.15267465e-01f, -1.11793734e-01f, 4.68241423e-02f, -3.62820588e-02f, 2.20312580e-01f,
  -5.00332899e-02f, -7.29629248e-02f, 1.13404423e-01f, -2.60161370e-01f, 1.42636493e-01f, 3.78634445e-02f, 1.45659909e-01f, -3.96692790e-02f, -2.22558379e-01f, -4.98139821e-02f,
  8.84129703e-02f, 1.20777022e-02f, 1.43147469e-01f, 2.01541901e-01f, 6.14842363e-02f, 1.30079716e-01f, -1.82464093e-01f, -1.50485277e-01f, 9.96252373e-02f, 1.19995914e-01f,
  1.77857466e-02f, 3.03460270e-01f, 5.21873049e-02f, 1.22656211e-01f, -1.92144930e-01f, -1.77806601e-01f, 5.58100268e-02f, -6.82622492e-02f, 1.74391285e-01f, -7.51855746e-02f,
  -6.14700988e-02f, -8.88916105e-02f, 6.22229576e-02f, 2.47812700e-02f, 4.35642637e-02f, 4.01348025e-02f, 7.12941065e-02f, 5.93112372e-02f, 7.69808143e-02f, 1.07157022e-01f,
  4.25789058e-02f, 4.14720438e-02f, -2.45468821e-02f, 8.62724558e-02f, 3.78873721e-02f, 6.76494837e-02f, -1.27617614e-02f, -1.35390475e-01f, -5.45300357e-02f, -1.98392361e-01f,
  1.34871826e-01f, -5.65948673e-02f, 6.57278299e-02f, -3.09255905e-02f, 3.15558910e-02f, 1.16316423e-01f, 1.36511400e-01f, -2.81511974e-02f, -4.54852358e-02f, 1.58560872e-01f,
  1.46705210e-01f, -7.61639103e-02f, 2.23951578e-01f, 1.26193240e-01f, 9.90085378e-02f, -8.83176643e-03f, 5.92264086e-02f, 2.92376429e-01f, -6.11363873e-02f, -1.62377596e-01f,
  -1.28513351e-01f, 1.39340103e-01f, 2.11429209e-01f, 1.20123222e-01f, 6.79410622e-02f, -1.39781430e-01f, -8.69239122e-02f, -4.35859561e-02f, 1.59706473e-01f, 1.50546342e-01f,
  1.76475465e-01f, 1.18107021e-01f, -2.79823765e-02f, -6.81086555e-02f, 1.21840656e-01f, -1.45163625e-01f, 1.29123181e-01f, -1.07294563e-02f, -1.31060546e-02f, 8.19664076e-02f,
  2.86003519e-02f, -1.41574398e-01f, 4.24719229e-02f, -5.20119332e-02f, 2.21062973e-01f, 1.57480240e-01f, 1.41015157e-01f, -3.40196304e-03f, 9.02670026e-02f, 1.63055316e-01f,
  4.07416187e-02f, 1.09950155e-01f, 1.62938669e-01f, -2.77554337e-02f, 1.17705646e-03f, 1.34735480e-01f, -8.14323500e-02f, -7.68125281e-02f, -5.71999140e-02f, 6.80480301e-02f,
  3.43059115e-02f, 3.28841954e-02f, 1.55305207e-01f, 9.65194404e-02f, -1.63828880e-01f, -4.69084829e-02f, 4.12106775e-02f, 1.96365416e-02f, -4.59785089e-02f, 6.36286288e-03f,
  8.20165053e-02f, -4.41253372e-03f, 1.49695262e-01f, -1.56600863e-01f, 2.15587839e-02f, 5.84762543e-02f, 5.88200688e-02f, -7.27655515e-02f, -5.61256595e-02f, 1.55053839e-01f,
  1.41998678e-02f, -6.44766353e-03f, 1.39280751e-01f, 1.26828492e-01f, -4.16558534e-02f, -7.51696452e-02f, 1.37632983e-02f, -7.92522356e-02f, 5.39831668e-02f, 1.57073066e-01f,
  1.68107495e-01f, 5.77574931e-02f, -1.53211400e-01f, -3.63095254e-02f, -5.75194024e-02f, 1.94753572e-01f, 1.46455139e-01f, 4.61139865e-02f, 1.65376551e-02f, 1.80001691e-01f,
  6.44374117e-02f, -7.81541467e-02f, 2.92367041e-01f, 2.81994820e-01f, 5.15519008e-02f, 7.85235539e-02f, -1.22289039e-01f, 9.31425318e-02f, 1.40047610e-01f, 1.52242228e-01f,
  3.77472187e-03f, -7.51565397e-02f, 9.61754248e-02f, 5.62081113e-02f, 9.44819069e-04f, 8.72167125e-02f, 1.05540417e-01f, -9.53145623e-02f, 5.80808409e-02f, 4.99652140e-02f,
  -1.89777017e-01f, 2.63575405e-01f, -1.65832222e-01f, -1.42743886e-01f, -1.86272457e-01f, -1.21920303e-01f, -2.95100976e-02f, 1.97591066e-01f, 1.07272707e-01f, -2.14597180e-01f,
  1.95602283e-01f, -2.64351755e-01f, -2.04865467e-02f, -2.55331337e-01f, -5.88935204e-02f, 4.92666066e-02f, -1.19694330e-01f, -2.19936706e-02f, 6.40519559e-02f, -1.74564235e-02f,
  -1.43449763e-02f, -2.31371924e-01f, -2.22239509e-01f, 6.80049732e-02f, -1.16079204e-01f, 1.86124295e-01f, 9.47331190e-02f, -4.96405363e-02f, 2.34602869e-01f, -1.70677409e-01f,
  -1.06681548e-02f, 6.37882575e-02f, 9.06162080e-04f, 8.93658772e-02f, 1.33526102e-01f, 4.40970697e-02f, -1.35554940e-01f, -1.81581065e-01f, -2.19972476e-01f, -1.16434112e-01f,
  5.12664057e-02f, 1.50463820e-01f, -1.71081811e-01f, 1.56934895e-02f, 3.18037756e-02f, 1.80079430e-01f, 2.27518082e-01f, 3.30505341e-01f, -8.50027502e-02f, 1.91478848e-01f,
  1.76483486e-02f, 2.10316733e-01f, 1.11870944e-01f, 6.64992332e-02f, 9.00108144e-02f, 1.67116302e-03f, 1.27756996e-02f, 1.61088705e-01f, 1.53407887e-01f, 7.70851374e-02f,
  7.20585212e-02f, 8.46415013e-02f, 2.73783822e-02f, -4.65734154e-02f, 7.63993412e-02f, -1.86137006e-01f, 4.30315472e-02f, 1.81547880e-01f, 1.53407127e-01f, 1.64756905e-02f,
  6.10899143e-02f, -1.49098828e-01f, -1.19350635e-01f, -5.83701394e-02f, 1.01308711e-01f, 1.77860230e-01f, -4.11222465e-02f, 1.03855163e-01f, 4.35047857e-02f, 5.42801693e-02f,
  2.33182758e-01f, -2.08250165e-01f, -1.75191283e-01f, 1.34903491e-01f, 1.61714658e-01f, -8.09586942e-02f, 1.45514067e-02f, 7.15856627e-02f, 5.34609109e-02f, -1.54139072e-01f,
  1.29063696e-01f, -1.03231192e-01f, -8.54199305e-02f, 8.67279805e-03f, 6.05793037e-02f, -1.16877235e-01f, 6.45933747e-02f, 1.89439021e-02f, 1.83207870e-01f, 1.91963896e-01f,
  -7.67984390e-02f, 2.48300005e-02f, -5.05484939e-02f, 3.11016411e-01f, 9.07631889e-02f, -3.71596366e-02f, 1.93469319e-02f, -6.19767494e-02f, 7.65434876e-02f, -1.67613372e-01f,
  9.17970315e-02f, 1.09510213e-01f, 9.52643454e-02f, -8.04544017e-02f, -8.71557519e-02f, 2.16147229e-02f, 9.72057506e-03f, 3.29012908e-02f, -1.91547927e-02f, 2.73899864e-02f,
  7.47989714e-02f, -1.69457053e-03f, 8.55522305e-02f, 1.35730088e-01f, 1.05613239e-01f, 4.57919985e-02f, -5.73349139e-03f, 1.01870090e-01f, 2.28481274e-02f, 2.15305284e-01f,
  6.35411441e-02f, -1.40542522e-01f, -5.87299280e-02f, -1.28347769e-01f, -1.69415340e-01f, -7.41148219e-02f, 1.79814771e-01f, -7.68018588e-02f, 9.42384377e-02f, -1.15969345e-01f,
  -2.38550499e-01f, -5.73489405e-02f, -6.73862398e-02f, -7.71759376e-02f, -2.24154890e-01f, 1.08611549e-03f, 1.84236616e-01f, 7.22325072e-02f, 1.59389570e-01f, 1.52720615e-01f,
  2.77666133e-02f, -1.29341975e-01f, 1.21984065e-01f, 1.24261603e-01f, -2.09163368e-01f, -1.69140100e-01f, 1.39550567e-01f, 3.63015011e-02f, 1.47351495e-03f, 1.28483340e-01f,
  -1.40017450e-01f, -1.77401811e-01f, -1.31824702e-01f, -6.24128804e-02f, 1.15150645e-01f, -1.27818892e-02f, 6.07944727e-02f, -1.23919419e-03f, -1.50766984e-01f, 7.92272687e-02f,
  -8.42952449e-03f, -2.12753147e-01f, 6.88814446e-02f, 2.09744751e-01f, -1.03429273e-01f, -3.37521061e-02f, -6.60404861e-02f, -1.82800870e-02f, 7.02300295e-02f, -7.47965351e-02f,
  1.03045115e-02f, 4.66289036e-02f, 4.69861403e-02f, 1.62140861e-01f, 1.64531559e-01f, 1.14501633e-01f, 1.50116295e-01f, 1.73093215e-01f, 5.37258852e-03f, 1.18958496e-01f,
  1.58975542e-01f, -3.61631326e-02f, 2.99953699e-01f, -2.26240844e-01f, -7.13639185e-02f, -7.85207096e-03f, 7.78816491e-02f, 9.08903033e-02f, -1.11345574e-01f, -1.33228637e-02f,
  -7.76303336e-02f, 1.28567159e-01f, -1.47000980e-03f, 1.18321978e-01f, 1.94188505e-01f, 1.51194647e-01f, 2.50524767e-02f, 7.45335594e-02f, 2.68651426e-01f, 4.69670482e-02f,
  -7.57945031e-02f, 1.18537121e-01f, -6.20547347e-02f, 1.57418743e-01f, 5.31096980e-02f, 8.19750354e-02f, 8.16214308e-02f, -7.82289654e-02f, 1.72858298e-01f, -5.68023250e-02f,
  -6.46031350e-02f, 5.21047786e-02f, -1.49779215e-01f, -9.85252261e-02f, 2.41020583e-02f, -1.32879857e-02f, 8.96292180e-02f, 1.91097736e-01f, 6.79909363e-02f, 8.99421573e-02f,
  -1.52235841e-02f, 1.48497848e-03f, 3.06659713e-02f, 2.64558219e-03f, 5.61518259e-02f, -1.36730280e-02f, 7.72386324e-03f, -5.09206951e-02f, -1.30709969e-02f, -2.36405596e-01f,
  1.73014835e-01f, -1.84963524e-01f, 2.84089427e-02f, -1.44045368e-01f, 1.18222341e-01f, -2.15569492e-02f, 5.85465468e-02f, 5.56845665e-02f, 5.07401973e-02f, 1.02355950e-01f,
  1.73749059e-01f, 1.46650195e-01f, 9.93658528e-02f, -2.24705487e-02f, 2.72861253e-02f, 3.39757912e-02f, 1.45524601e-02f, 6.35319017e-03f, 2.86053326e-02f, 5.82877211e-02f,
  7.36147016e-02f, -1.02741331e-01f, 6.72812387e-02f, -1.52408212e-01f, 6.06332496e-02f, -7.21508414e-02f, 1.52888790e-01f, -2.44140327e-02f, -1.05449013e-01f, 5.43010160e-02f,
  6.53764680e-02f, 9.06716380e-03f, -4.39531961e-03f, -1.57180265e-01f, 1.81356296e-02f, 8.37801863e-03f, 2.51380324e-01f, 6.03730278e-03f, -1.31075485e-02f, -2.54903808e-02f,
  5.59376925e-02f, 1.44777611e-01f, -3.30872387e-02f, -1.94175869e-01f, 2.96470318e-02f, 1.82046760e-02f, 9.35941860e-02f, 1.50096649e-02f, 3.19980122e-02f, -1.52867883e-01f,
  5.08264117e-02f, 4.79107872e-02f, -2.94289342e-03f, 3.58586870e-02f, -1.42291626e-02f, 2.53936529e-01f, -2.11562980e-02f, -2.26240959e-02f, 1.29059836e-01f, -1.56687990e-01f,
  9.14354846e-02f, -1.31816398e-02f, 5.59858307e-02f, 2.33287528e-01f, -7.82352313e-03f, -3.15218493e-02f, 2.94482969e-02f, 5.54911308e-02f, -3.16728167e-02f, -6.63369149e-02f,
  4.51869257e-02f, 4.14763726e-02f, 3.69790606e-02f, 3.27140801e-02f, 1.27809182e-01f, 1.35530964e-01f, 5.77008389e-02f, 9.68417227e-02f, 5.35872839e-02f, -3.34351510e-03f,
  1.43217517e-03f, 4.66642343e-02f, 4.16129120e-02f, -4.70927581e-02f, 5.25835576e-03f, -1.19402990e-01f, 3.05659398e-02f, -1.91657603e-01f, 1.44484594e-01f, 7.60992840e-02f,
  6.26156405e-02f, -8.21947381e-02f, -3.91800776e-02f, 8.23806301e-02f, 2.38796249e-02f, 3.33762215e-03f, -2.06193384e-02f, 4.44204360e-02f, 7.78966099e-02f, -8.05002898e-02f,
  2.37379715e-01f, 1.21954799e-01f, 7.48586804e-02f, -1.67447597e-01f, 1.17093213e-01f, 2.47451827e-01f, -7.40428045e-02f, -8.25318545e-02f, -3.55627015e-02f, 1.16002396e-01f,
  1.42714068e-01f, 8.79995823e-02f, 3.88846397e-02f, -1.41153321e-01f, -1.04326963e-01f, -5.08998893e-02f, 1.71738580e-01f, 1.49167687e-01f, 1.43180907e-01f, 1.38141558e-01f,
  -6.07187860e-02f, -4.77961041e-02f, 1.53437391e-01f, -1.08622290e-01f, 1.20722592e-01f, 2.06022542e-02f, -1.03203185e-01f, -7.01432396e-03f, -2.76532602e-02f, -1.12841651e-01f,
  7.01678395e-02f, 1.05746854e-02f, -9.75114033e-02f, -3.36066335e-02f, -1.60362590e-02f, 1.12710565e-01f, 3.02940700e-02f, 1.16699534e-02f, -4.59856400e-03f, 8.07830989e-02f,
  -3.56282257e-02f, 7.55133405e-02f, 4.79277186e-02f, 3.92423198e-02f, 7.40752444e-02f, -9.34065413e-03f, -4.36268263e-02f, -8.92154947e-02f, 4.01939042e-02f, -5.36503568e-02f,
  -1.86052844e-01f, -2.63433121e-02f, 1.04018800e-01f, 5.55533208e-02f, -2.60254238e-02f, -6.57913089e-02f, 1.83288500e-01f, -3.62842269e-02f, -8.17372054e-02f, 1.12107560e-01f,
  4.04632464e-02f, 2.69529313e-01f, 9.39978734e-02f, -9.78759378e-02f, -1.00438476e-01f, 1.87997267e-01f, 1.27147809e-01f, -1.64512843e-01f, 6.75661415e-02f, 4.07527275e-02f,
  -1.67906985e-01f, -4.69033755e-02f, 2.41575986e-01f, 1.46213174e-01f, -5.55624031e-02f, 7.66149759e-02f, -9.51023474e-02f, -8.89704823e-02f, -1.18505150e-01f, -2.56150346e-02f,
  1.01354688e-01f, 1.18582090e-02f, 1.90185681e-02f, -1.53058514e-01f, -4.60738204e-02f, 2.55962044e-01f, 3.17392834e-02f, -1.51815549e-01f, -3.75148989e-02f, 3.02334517e-01f,
  -2.32090391e-02f, -2.25881651e-01f, 1.32168233e-01f, 5.20058759e-02f, 8.71637464e-02f, -3.51789594e-02f, 1.50828481e-01f, 2.03926419e-03f, 6.79757968e-02f, 1.03219353e-01f,
  1.60269469e-01f, 9.90043506e-02f, 1.50281563e-01f, 1.73563778e-01f, 1.65847600e-01f, 2.74529327e-02f, 1.19159177e-01f, -6.41425997e-02f, 1.81519464e-01f, -1.96727261e-01f,
  -1.02905869e-01f, 1.20336354e-01f, 7.60225728e-02f, 4.46847975e-02f, -1.06165996e-02f, -1.43057629e-01f, -6.42379001e-02f, 8.83167610e-02f, 1.03680328e-01f, 1.11441270e-01f,
  2.17066437e-01f, 8.26038867e-02f, -4.40523550e-02f, 1.18524536e-01f, 1.66307703e-01f, -4.34704311e-03f, -1.50504142e-01f, 4.32523526e-02f, 2.75337212e-02f, 1.17826156e-01f,
  3.33476886e-02f, -2.93323081e-02f, 1.25373498e-01f, -2.01710135e-01f, 1.50268033e-01f, -3.58627066e-02f, 1.69590041e-01f, 2.03983043e-04f, -5.39333411e-02f, -4.83964570e-02f,
  7.35880435e-02f, -9.68761221e-02f, 1.80662110e-01f, 1.96904540e-01f, 3.98772620e-02f, 8.69662315e-02f, -5.64173721e-02f, 1.39551565e-01f, 9.00803357e-02f, 1.44773304e-01f,
  6.85352013e-02f, 1.71315614e-02f, 8.11275840e-02f, 1.28347442e-01f, -9.95589793e-02f, -2.87113860e-02f, 1.78637087e-01f, -9.36067700e-02f, 6.06492087e-02f, 1.74464993e-02f,
  3.01290909e-03f, -5.41477511e-03f, 6.98506236e-02f, 3.66466977e-02f, 8.16763192e-02f, 8.54836851e-02f, 1.09833502e-03f, -2.36514509e-02f, 5.54839596e-02f, 9.12609622e-02f,
  7.82823265e-02f, 2.36385360e-01f, -2.00315520e-01f, 5.05120344e-02f, 1.92221776e-01f, 1.06462076e-01f, -1.20195737e-02f, -4.89558093e-02f, 9.04647186e-02f, -5.40104136e-02f,
  -5.20539060e-02f, -7.01297224e-02f, -6.69290423e-02f, -8.12276676e-02f, -1.67576790e-01f, 1.07592292e-01f, 2.31826961e-01f, -1.12800673e-02f, 1.37818446e-02f, -4.67163995e-02f,
  8.54654424e-03f, 5.80249541e-02f, 1.62985981e-01f, -5.99770285e-02f, 4.77992706e-02f, -2.92073190e-03f, -5.15447557e-02f, 2.32021481e-01f, 1.36374692e-02f, 1.28602386e-01f,
  -4.36913185e-02f, 2.79615466e-02f, 2.66549528e-01f, 2.64505856e-02f, 5.63305467e-02f, 6.64137900e-02f, -6.50893301e-02f, -5.50775081e-02f, -6.92670606e-03f, -8.28176551e-03f,
  1.46250695e-01f, 1.64615244e-01f, -5.60763068e-02f, -1.10007487e-01f, 1.34680435e-01f, -1.15504928e-01f, 2.40394156e-02f, -7.61608779e-02f, 9.90777314e-02f, 1.28544837e-01f,
  -1.50179848e-01f, 1.43415615e-01f, -2.84576211e-02f, 1.11968651e-01f, -8.87553990e-02f, 5.70004955e-02f, 5.22163622e-02f, 1.10788703e-01f, 7.87223130e-02f, 1.64074674e-01f,
  -1.45717338e-02f, 1.18744992e-01f, -3.05609987e-03f, 1.74707904e-01f, 5.34165651e-02f, 1.68267712e-01f, 1.29985929e-01f, -2.07830936e-01f, 1.80682510e-01f, 1.59536496e-01f,
  1.97923824e-01f, 1.14993170e-01f, -6.66184351e-02f, -1.58367157e-01f, -7.60011673e-02f, 1.70905411e-01f, -8.87797400e-02f, 1.10784963e-01f, 5.32706529e-02f, 2.40310997e-01f,
  1.49609327e-01f, 1.46949381e-01f, 3.13892037e-01f, 1.33663654e-01f, -7.84021243e-02f, 1.33554459e-01f, 1.13862194e-01f, 8.01343843e-02f, 2.19753414e-01f, 4.33097361e-03f,
  9.96392891e-02f, -1.56594858e-01f, -1.81787815e-02f, 1.14793845e-01f, -5.49701676e-02f, 9.63776633e-02f, 2.46075541e-02f, 3.90933678e-02f, 1.08523011e-01f, -5.00567742e-02f,
  -6.88665584e-02f, 2.76684146e-02f, 8.30221996e-02f, 1.21537074e-01f, 2.02609152e-01f, 1.21309988e-01f, -1.53709790e-02f, -9.41830128e-02f, 4.69928756e-02f, -1.00064047e-01f,
  8.05729926e-02f, -4.41812947e-02f, -9.25757363e-02f, -2.00409740e-01f, 5.67342527e-02f, 4.32162546e-02f, -4.58947010e-02f, -1.08253248e-01f, -1.11619689e-01f, -7.48675913e-02f,
  4.46081385e-02f, 3.38776149e-02f, 6.59404248e-02f, 1.75643470e-02f, -3.41103971e-02f, 5.52199818e-02f, -9.61115137e-02f, 8.70231688e-02f, 5.28225973e-02f, 9.66154858e-02f,
  7.23695159e-02f, -9.86329764e-02f, 7.21817836e-02f, 2.70060897e-02f, 5.95313236e-02f, 8.40300247e-02f, -5.22473641e-02f, -6.09253049e-02f, 2.94119827e-02f, 3.97323184e-02f,
  -9.96430684e-03f, -1.61182564e-02f, 7.36785829e-02f, 1.00468464e-01f, 1.11113779e-01f, 8.77492651e-02f, 1.81034505e-01f, 2.63177454e-01f, 5.82679659e-02f, 1.29830120e-02f,
  -4.28165235e-02f, -3.19788717e-02f, 1.47708133e-01f, 1.01459824e-01f, -7.81466067e-02f, -5.00729047e-02f, -5.20607159e-02f, 5.53623624e-02f, -8.73410851e-02f, 1.42412648e-01f,
  -1.84592810e-02f, 1.67609341e-02f, -1.47323404e-02f, 2.65405551e-02f, -5.80160357e-02f, -5.06678522e-02f, 8.36617500e-02f, -1.24296080e-02f, 1.63088098e-01f, 4.72489335e-02f,
  -3.43485512e-02f, -9.83380526e-02f, 8.76634419e-02f, -1.49540976e-01f, -6.10656254e-02f, -5.04970513e-02f, -3.78130339e-02f, -1.52123362e-01f, 8.32215771e-02f, 1.39205549e-02f,
  -7.69484416e-02f, 2.61336770e-02f, 1.35847285e-01f, 9.86394435e-02f, 4.92512248e-02f, 5.53848669e-02f, 6.90681711e-02f, 8.49629045e-02f, 1.07882470e-01f, 9.25947055e-02f,
  1.36926457e-01f, 6.77090660e-02f, 3.26402709e-02f, -1.65996939e-01f, 1.13326184e-01f, 2.08365940e-03f, -2.41243318e-01f, 1.25970528e-01f, -4.90838848e-02f, 3.65336724e-02f,
  -1.34261116e-01f, -1.08514223e-02f, -6.87089190e-02f, -5.02352417e-02f, 1.17237881e-01f, 1.91515267e-01f, 9.34807435e-02f, -4.49548848e-02f, -1.31896541e-01f, -5.92823587e-02f,
  -1.64664447e-01f, -1.75925136e-01f, -5.43783270e-02f, 1.74922094e-01f, -8.40968788e-02f, 1.91758722e-01f, -9.70291272e-02f, -2.29531731e-02f, 1.27674684e-01f, -2.73318857e-01f,
  8.05314481e-02f, -2.90807639e-03f, 1.74987674e-01f, -9.72792506e-02f, -1.77775726e-01f, -1.13577545e-02f, 4.97442186e-02f, -7.60601535e-02f, 2.74919182e-01f, 2.23459125e-01f,
  1.42816707e-01f, 4.98823673e-02f, -1.01468600e-01f, 7.37776086e-02f, -1.13438945e-02f, 2.22416341e-01f, -7.41854161e-02f, 1.14137530e-01f, -1.65015385e-02f, 2.23831102e-01f,
  -8.04432929e-02f, -2.21908186e-02f, 7.34252483e-03f, 2.97007919e-03f, 1.63974047e-01f, -4.46025580e-02f, -1.06050782e-01f, -1.24913335e-01f, -9.85161960e-03f, 1.72764994e-02f,
  3.79028916e-03f, -4.37011793e-02f, 2.30351370e-03f, -6.68734021e-04f, -6.45766109e-02f, 1.11566624e-02f, 1.14668220e-01f, 3.18863541e-02f, 1.42967254e-01f, -4.15121280e-02f,
  -9.28088203e-02f, 1.13502163e-02f, -6.32655527e-03f, 1.81912556e-02f, -1.11138225e-01f, -1.06028147e-01f, 1.54763997e-01f, 1.05406921e-02f, -6.94785342e-02f, -7.47983158e-02f,
  1.93886831e-01f, 1.23104036e-01f, -3.88917997e-02f, 3.79608236e-02f, 3.24239321e-02f, 1.12989970e-01f, -3.31983832e-03f, -3.67389098e-02f, 1.04300573e-01f, 1.27484620e-01f,
  7.63706118e-02f, -1.16271123e-01f, 5.60749844e-02f, 5.52987773e-03f, -1.32605331e-02f, -6.07017688e-02f, -1.46713600e-01f, 1.00899883e-01f, 4.98804338e-02f, 7.01912493e-02f,
  3.69562628e-03f, -3.53849009e-02f, -5.93934245e-02f, 1.27089787e-02f, 1.71604067e-01f, 6.06009997e-02f, 9.82763693e-02f, -2.71021239e-02f, -5.23929521e-02f, 2.03412380e-02f,
  6.84502348e-02f, -1.21768616e-01f, 5.38687408e-03f, -7.77120963e-02f, -1.11246109e-01f, -9.80471596e-02f, 4.18275855e-02f, -7.94019625e-02f, -1.09087424e-02f, -3.71705927e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  8.97958055e-02f, 1.74889550e-01f, 1.70722410e-01f, 1.60328656e-01f, 6.74783513e-02f, 5.41962199e-02f, 7.94266816e-03f, 2.39477325e-02f, 2.54448410e-02f, -1.28646763e-02f,
  1.84011273e-02f, 7.12065995e-02f, 1.31485790e-01f, 1.32121280e-01f, 9.32794623e-03f, 1.08830899e-01f, 1.72447376e-02f, 1.50626406e-01f, 3.97144705e-02f, 1.02963276e-01f,
  -3.41112316e-02f, 9.83877704e-02f, -4.61942814e-02f, 1.22210056e-01f, 4.89699095e-02f, 1.06238708e-01f, 1.12281486e-01f, 5.82121424e-02f, 1.04009420e-01f, 9.20024887e-02f,
  5.81644997e-02f, 5.72166257e-02f, 1.14273489e-01f, 3.42277624e-02f, 1.52018562e-01f, 5.47701530e-02f, 1.18924886e-01f, 7.05129504e-02f, 1.33834571e-01f, 5.98426089e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -5.60006499e-02f, -4.82047759e-02f, 7.28714317e-02f, -5.90748489e-02f, -4.14357744e-02f, -6.71483204e-02f, -2.65670810e-02f, -3.53149101e-02f, -3.66293266e-02f, -7.00790156e-03f,
  -5.58506362e-02f, -8.09625685e-02f, -1.11815773e-01f, -3.13667655e-02f, -1.30122513e-01f, -4.65395711e-02f, 1.34624271e-02f, -2.23736465e-02f, 1.14157960e-01f, -7.74920732e-02f,
  -9.32225809e-02f, -1.31536141e-01f, 1.75008718e-02f, 1.04113501e-02f, 1.51827540e-02f, 9.41319987e-02f, -8.68488010e-03f, 1.16892457e-02f, -1.13044612e-01f, 1.22120000e-01f,
  -6.10732809e-02f, 9.71692279e-02f, -3.95590775e-02f, -4.72931378e-02f, -9.08894464e-02f, -4.84127998e-02f, 5.04190177e-02f, -6.25473447e-03f, -4.38477024e-02f, -1.16919018e-01f,
  1.11790702e-01f, -6.59105405e-02f, -1.67424574e-01f, -2.14547534e-02f, -4.08159345e-02f, 1.18697425e-02f, -6.92102686e-02f, 8.15961882e-02f, -1.64965168e-02f, 5.17274290e-02f,
  -8.27713087e-02f, -4.73304801e-02f, -8.99489895e-02f, 1.64886937e-01f, -1.11600809e-01f, 8.15216526e-02f, 8.25308636e-02f, 3.93072842e-03f, -1.98831465e-02f, 3.71942781e-02f,
  -3.32100093e-02f, -5.27147949e-02f, 6.62714690e-02f, -6.93942187e-03f, 1.42247053e-02f, -9.43358466e-02f, -7.20534241e-04f, -6.10469431e-02f, 3.07861436e-02f, -4.95091602e-02f,
  -8.42859671e-02f, 3.64323594e-02f, -6.26016930e-02f, 5.48601486e-02f, -6.49358779e-02f, -4.43505906e-02f, -1.65250094e-03f, -3.31996903e-02f, -1.44368438e-02f, -4.54491042e-02f,
  -3.90499644e-03f, 9.68427509e-02f, 7.19077885e-02f, 2.25042515e-02f, -8.78695212e-03f, 4.26301593e-03f, 1.04439102e-01f, -1.01732180e-01f, 2.56629661e-02f, 8.86961967e-02f,
  -1.54839799e-01f, 6.86568692e-02f, 1.71351597e-01f, 3.32926884e-02f, -7.13178217e-02f, 4.33480367e-02f, 1.85221713e-02f, 9.48918462e-02f, -2.93097384e-02f, 5.10739675e-03f,
  -1.02749290e-02f, -1.32307246e-01f, -1.90410912e-02f, -1.30322054e-01f, 6.95241988e-03f, -3.23650986e-02f, -4.05108146e-02f, 9.30615366e-02f, -1.44165069e-01f, 4.82393727e-02f,
  -7.73769319e-02f, -2.78249420e-02f, -1.53730378e-01f, 3.70682813e-02f, -5.27699254e-02f, 2.31332500e-02f, -1.84812248e-01f, 9.03480873e-02f, -1.30402908e-01f, 1.09603135e-02f,
  -6.97413599e-03f, 7.91390911e-02f, -1.81367218e-01f, 6.12575002e-02f, -8.70947838e-02f, 2.62230448e-02f, -1.51081532e-01f, 2.85442714e-02f, 2.10743118e-02f, 1.30711764e-01f,
  -6.86041079e-03f, 4.25949832e-03f, 1.83001440e-02f, 9.89152417e-02f, 8.65406618e-02f, -1.78235378e-02f, 9.78376716e-02f, 6.67408630e-02f, 7.62795508e-02f, 5.37772998e-02f,
  3.32591906e-02f, 1.37772769e-01f, 4.32912931e-02f, 1.44441053e-01f, 1.61525831e-02f, -3.23169306e-02f, -1.78463608e-01f, 7.90317208e-02f, 9.59688500e-02f, 7.74649680e-02f,
  2.30044276e-02f, 5.74648306e-02f, 2.75406614e-02f, -1.09376624e-01f, 9.97210816e-02f, 1.11782007e-01f, 7.38293231e-02f, -1.05261452e-01f, 1.68931484e-01f, -1.03123583e-01f,
  2.09563300e-02f, -4.52871136e-02f, -4.44649309e-02f, 1.16888940e-01f, -3.72725129e-02f, 1.24758974e-01f, 1.49771065e-01f, 1.21589012e-01f, 7.72175193e-03f, -9.76620391e-02f,
  8.76752287e-02f, -1.98616413e-03f, 8.40627700e-02f, 9.12222862e-02f, 4.32660468e-02f, 1.48027875e-02f, 3.58099900e-02f, -1.14231266e-01f, 1.68395728e-01f, 4.97712530e-02f,
  1.55799568e-01f, -1.56781644e-01f, 1.77387067e-03f, -1.02796340e-02f, -5.86642772e-02f, -1.47327632e-01f, 1.51933534e-02f, 3.76729518e-02f, -4.51655313e-02f, -5.12244701e-02f,
  1.45665137e-02f, -4.37979884e-02f, 2.47273985e-02f, -8.09209645e-02f, -8.66265595e-02f, 1.82861532e-03f, -2.17292812e-02f, -1.33821424e-02f, -7.54452571e-02f, 4.22892198e-02f,
  3.40168029e-02f, -4.02431227e-02f, -6.96450248e-02f, -2.12881230e-02f, 1.37508914e-01f, 4.20070365e-02f, -2.09892392e-02f, 1.87709555e-01f, -7.11904541e-02f, 9.20493975e-02f,
  -8.72611552e-02f, 2.45847506e-03f, 1.98568180e-01f, 1.08950585e-02f, -1.05765015e-01f, -9.37428847e-02f, -2.92429756e-02f, -5.19860610e-02f, 7.15501457e-02f, -1.34039652e-02f,
  7.90304132e-03f, 3.57824378e-02f, 8.77355859e-02f, 1.01304300e-01f, -9.35003757e-02f, -3.70545201e-02f, -5.24775200e-02f, -8.16721395e-02f, -9.35005099e-02f, 2.05998197e-02f,
  4.80479002e-02f, 7.86339119e-02f, 3.40607613e-02f, -1.89867631e-01f, 2.44763624e-02f, 3.20904925e-02f, 1.05384840e-02f, 1.19236208e-01f, -2.22365372e-02f, 1.94449678e-01f,
  -2.36191675e-01f, 9.12595242e-02f, 8.86414722e-02f, 6.68285266e-02f, -7.30310427e-03f, 2.84024440e-02f, -1.87085867e-01f, 1.35155186e-01f, 1.67159587e-02f, -1.44660041e-01f,
  -2.24868450e-02f, 1.92568704e-01f, -8.11500177e-02f, -5.11804521e-02f, -1.29782751e-01f, -3.25628296e-02f, 1.20352633e-01f, 7.75932297e-02f, -4.39940840e-02f, 7.90471304e-03f,
  -5.17315343e-02f, 6.47163689e-02f, 4.20842543e-02f, -1.31941289e-02f, 7.41799399e-02f, 1.70608312e-02f, 9.20350477e-03f, -1.71090048e-02f, 6.72340244e-02f, 7.14545697e-02f,
  4.03048880e-02f, 2.01015159e-01f, -6.12379164e-02f, -1.16513390e-03f, -1.29268497e-01f, 1.02437371e-02f, 2.29590699e-01f, 5.89836799e-02f, -7.38666533e-03f, 5.53331226e-02f,
  1.65711548e-02f, -1.33730143e-01f, 3.06525007e-02f, 6.93614769e-04f, 1.97817627e-02f, -1.13726802e-01f, 1.06906570e-01f, -1.13020279e-02f, -5.30019701e-02f, -8.59491602e-02f,
  4.51064948e-03f, -2.73490250e-02f, -3.95789444e-02f, 5.25830388e-02f, 7.46585056e-02f, 8.99073407e-02f, -3.39552201e-02f, -1.11714825e-01f, 9.51046422e-02f, -8.21472108e-02f,
  1.07110851e-01f, 1.87386461e-02f, 2.19597612e-02f, 5.61009981e-02f, -2.17742816e-01f, -7.85093680e-02f, 2.15021856e-02f, 1.16164126e-02f, 4.62066121e-02f, -1.64669275e-01f,
  -7.77096599e-02f, 1.12294905e-01f, -7.85910264e-02f, -1.95595741e-01f, -1.07499205e-01f, 3.96896079e-02f, -2.42545381e-02f, -5.12870066e-02f, -1.57060996e-01f, -1.20133020e-01f,
  -7.05865994e-02f, -2.62361374e-02f, 4.34832051e-02f, -5.60457669e-02f, -3.00526116e-02f, -6.15867749e-02f, -7.33392611e-02f, -1.87255982e-02f, -1.24665918e-02f, -5.85332289e-02f,
  1.32882465e-02f, -3.95745486e-02f, -3.30719203e-02f, -8.23704302e-02f, 8.29989165e-02f, -1.57405466e-01f, -1.70418657e-02f, -2.95755416e-02f, 9.77713689e-02f, -3.35210636e-02f,
  -1.89001411e-01f, 3.48693132e-02f, -1.17494687e-02f, 5.03277732e-03f, -3.86313461e-02f, 6.72606006e-02f, -7.92123284e-03f, 3.54057760e-03f, -4.35192958e-02f, 5.54318391e-02f,
  -1.21850632e-01f, -1.86423026e-02f, 3.24607752e-02f, 5.22686057e-02f, 5.49091846e-02f, -4.38362686e-03f, 2.29424890e-02f, 1.63486097e-02f, -6.01268634e-02f, -4.67717350e-02f,
  -3.34197022e-02f, 1.07351743e-01f, -4.44736257e-02f, 5.27608208e-02f, -6.15424253e-02f, -4.80431132e-02f, 2.37332862e-02f, -9.16696638e-02f, 1.95626125e-01f, 6.73463419e-02f,
  -8.56480747e-02f, -8.44263509e-02f, -6.38984367e-02f, 2.69441586e-02f, 9.74094346e-02f, -9.21974778e-02f, 2.27208789e-02f, 1.37362018e-01f, 6.11971915e-02f, -1.06652610e-01f,
  -2.79404465e-02f, 6.04172871e-02f, 1.82629481e-01f, 9.79743898e-02f, -3.70793208e-03f, -4.94975708e-02f, -1.06568160e-02f, -1.46892918e-02f, -1.03893936e-01f, -4.11744267e-02f,
  -5.71758933e-02f, 4.75984216e-02f, -3.82228605e-02f, -3.39185563e-03f, -3.40792574e-02f, 7.38238823e-03f, 5.37565574e-02f, -4.84656021e-02f, -5.30635864e-02f, -9.11754742e-02f,
  -2.96210349e-02f, 4.87189479e-02f, 1.37196362e-01f, 4.25004736e-02f, -8.34792703e-02f, -5.74715734e-02f, 7.98443798e-03f, -9.33270082e-02f, -3.57711059e-03f, 1.11070246e-01f,
  -7.06408173e-02f, -2.80981511e-02f, -2.11158302e-02f, 6.44822717e-02f, 1.77633781e-02f, -8.93490762e-03f, 3.26123292e-04f, 1.12637594e-01f, 6.05353229e-02f, 5.02187833e-02f,
  -4.70187999e-02f, -1.27596036e-01f, -7.94535875e-02f, -9.79506671e-02f, 1.36369616e-01f, 3.91940512e-02f, -1.11953989e-01f, 1.54313385e-01f, -7.38895983e-02f, 1.71980634e-02f,
  -6.66218475e-02f, -4.70919274e-02f, 5.91318235e-02f, 1.23571411e-01f, -1.39949679e-01f, -6.02385737e-02f, -1.22366793e-01f, 7.12517798e-02f, 5.81022389e-02f, -2.58785002e-02f,
  1.12044722e-01f, 1.61694765e-01f, 8.67501423e-02f, -8.17456767e-02f, 2.87735276e-02f, 1.12044379e-01f, -6.83496182e-04f, 7.85319656e-02f, 4.38863710e-02f, -5.64525537e-02f,
  -3.42970341e-02f, 2.15192921e-02f, -5.74325435e-02f, -2.02655457e-02f, -5.56368120e-02f, -3.06895357e-02f, 4.54590283e-02f, 5.35752289e-02f, -8.44768658e-02f, -2.35231332e-02f,
  2.84918547e-02f, -4.84690964e-02f, -6.51223958e-02f, 4.06647809e-02f, -1.54192641e-01f, -3.14591615e-03f, 3.64265554e-02f, 1.33139789e-01f, 2.70281825e-02f, -1.06070101e-01f,
  -8.01081732e-02f, -4.96970043e-02f, -6.53178915e-02f, 3.50270271e-02f, -5.88568859e-02f, 4.40181196e-02f, -9.67891440e-02f, -8.28366131e-02f, 1.47627667e-01f, 7.51713887e-02f,
  -8.80283415e-02f, 1.12829529e-01f, 2.56245956e-02f, -9.00844019e-03f, -1.93010896e-01f, 8.67658481e-02f, 1.05555244e-01f, -1.01328656e-01f, 7.26579279e-02f, 4.26308066e-02f,
  -9.15898159e-02f, 8.40531439e-02f, 9.40131769e-02f, 3.11878324e-02f, -2.49557178e-02f, -3.97746004e-02f, -1.56493768e-01f, 1.08561814e-02f, -2.70824078e-02f, -2.62556762e-01f,
  -2.65770536e-02f, -1.01698495e-01f, 1.04038380e-01f, 1.37832202e-02f, 2.51829624e-02f, 9.92317051e-02f, 8.73367116e-02f, -2.24762913e-02f, 1.82592109e-01f, 1.21523939e-01f,
  -1.27563611e-01f, 6.86466554e-03f, -5.97420670e-02f, 1.19806156e-01f, 1.06263652e-01f, 6.91378908e-03f, 1.17074877e-01f, -6.13502320e-03f, 9.12080482e-02f, -2.97159632e-03f,
  1.85740385e-02f, 1.13883339e-01f, 2.79278029e-02f, 1.06258720e-01f, 8.00765529e-02f, 1.00386843e-01f, -8.17534328e-02f, -1.49760349e-02f, 2.54680701e-02f, 5.99467605e-02f,
  4.25335467e-02f, 4.29963656e-02f, -1.97976697e-02f, 3.36454585e-02f, 1.58719793e-01f, -1.14343278e-01f, 1.38165936e-01f, 6.58342019e-02f, -5.18466569e-02f, 1.50638685e-01f,
  -1.08609786e-02f, -1.06606528e-01f, 1.31422207e-01f, -1.25050962e-01f, 9.64201242e-02f, -7.09478278e-03f, 9.87180602e-03f, 2.62642540e-02f, 4.95465137e-02f, -1.55777067e-01f,
  9.85030830e-02f, -1.19040914e-01f, -3.94240841e-02f, 4.17935010e-03f, -5.57606854e-02f, -3.12199350e-02f, -7.09133595e-02f, 3.55924293e-02f, -3.11043747e-02f, 1.41444802e-01f,
  -3.74706015e-02f, -1.62442163e-01f, 1.09241791e-01f, 1.48435578e-01f, -1.65816605e-01f, 7.31510073e-02f, -1.43632919e-01f, -8.69328678e-02f, -1.08564787e-01f, -6.56869113e-02f,
  -1.62438095e-01f, -1.81036498e-02f, -1.15993842e-01f, -4.67018932e-02f, -7.05785677e-02f, -9.43263769e-02f, 2.99607702e-02f, 8.44608173e-02f, -2.21882444e-02f, 1.70507766e-02f,
  6.70408178e-03f, 5.40013947e-02f, 3.22415791e-02f, 2.36599194e-03f, -1.01165799e-02f, -3.91779020e-02f, 4.63610925e-02f, -1.63904727e-02f, 5.15280515e-02f, 3.72152999e-02f,
  2.55002230e-02f, 4.23061512e-02f, 3.78682092e-02f, -3.41970287e-02f, -9.28768888e-02f, -2.76819486e-02f, 1.54312886e-02f, 7.67180175e-02f, -4.80163395e-02f, 6.09038137e-02f,
  -2.42263246e-02f, -1.46798894e-01f, 9.65720788e-02f, -8.68942880e-04f, 1.28342928e-02f, -7.56786913e-02f, 2.36354135e-02f, -8.30258727e-02f, 3.50321978e-02f, -9.96948928e-02f,
  -9.18335863e-04f, -3.92223746e-02f, 4.14544120e-02f, 8.50723013e-02f, 3.60209569e-02f, 9.76085961e-02f, -2.21701916e-02f, -5.41099980e-02f, 6.52183816e-02f, -7.53242150e-02f,
  5.54287098e-02f, 2.04639062e-02f, 6.74229860e-02f, 7.08882185e-03f, 4.77965139e-02f, -7.88269863e-02f, 1.42751291e-01f, 2.78705228e-02f, 1.16886631e-01f, -1.24480166e-01f,
  -3.59043106e-02f, 2.48165540e-02f, -5.52243888e-02f, -1.45189300e-01f, -2.01638322e-02f, -3.35565917e-02f, -1.01094857e-01f, -6.59887567e-02f, 1.81873254e-02f, -6.52870163e-02f,
  -5.65424412e-02f, 4.93278131e-02f, -9.18612629e-02f, -4.84266132e-02f, -2.43944023e-02f, -4.97171506e-02f, -6.06188364e-02f, -6.53238520e-02f, -1.36954524e-02f, -1.22555174e-01f,
  -6.79364726e-02f, -1.20720915e-01f, -5.87086054e-03f, 2.63990834e-02f, 2.27096274e-01f, 5.38330078e-02f, 1.04093730e-01f, -3.14958184e-03f, -8.98799226e-02f, -5.74526824e-02f,
  5.53151481e-02f, 1.55094564e-01f, -4.48774099e-02f, 9.60604697e-02f, -4.87702200e-03f, -1.62438273e-01f, -5.52646555e-02f, -1.24514766e-01f, 6.23223670e-02f, -1.19551897e-01f,
  4.11688015e-02f, -1.29251778e-01f, -8.92549008e-02f, 3.47136520e-02f, -3.39796841e-02f, -5.01542352e-02f, -5.40699102e-02f, 5.47980610e-03f, 2.88352929e-02f, 1.63098633e-01f,
  -1.50026962e-01f, -1.01451278e-01f, 3.96217965e-02f, -1.15933083e-01f, 7.15340897e-02f, -8.91381651e-02f, 9.65006649e-02f, -1.44977808e-01f, -8.30070376e-02f, -7.06951693e-02f,
  -4.63824254e-04f, 1.35856820e-02f, 4.20017466e-02f, -1.90775752e-01f, 7.63116330e-02f, 4.76323515e-02f, -1.01106219e-01f, -5.96822202e-02f, 1.02357389e-02f, -6.02968447e-02f,
  2.48321854e-02f, 3.52756344e-02f, -1.71302035e-02f, -1.60039179e-02f, 2.01599877e-02f, 2.17283797e-02f, -8.59311689e-03f, -3.61683071e-02f, -5.95777296e-02f, 2.91979704e-02f,
  5.76112419e-02f, -3.69306356e-02f, 1.91543810e-02f, 9.14061666e-02f, 9.12718009e-03f, -4.14192565e-02f, -3.89117301e-02f, 1.17117405e-01f, -1.67552099e-01f, 4.23358195e-02f,
  5.40505908e-02f, 1.17869433e-02f, -3.05758882e-02f, 3.01083531e-02f, 1.13171786e-01f, -1.08888149e-02f, 8.14807937e-02f, -2.07398217e-02f, 2.14773431e-01f, 1.43960286e-02f,
  4.15961631e-02f, 1.88568130e-01f, 2.64332257e-03f, -7.57448701e-03f, 7.87666515e-02f, -1.04522154e-01f, -8.00065324e-03f, 2.54946873e-02f, -1.05491713e-01f, 3.20391078e-03f,
  1.75266251e-01f, -1.11622497e-01f, 8.99180472e-02f, -1.79124326e-02f, 4.72024679e-02f, -2.13118792e-01f, 2.61755697e-02f, -1.40961427e-02f, 2.28037089e-02f, 9.63377506e-02f,
  -7.24518672e-02f, 2.99193673e-02f, -1.74496010e-01f, 1.16766142e-02f, 4.52377833e-02f, 2.10777938e-01f, -4.08384018e-02f, -2.68752640e-03f, -2.16408029e-01f, 5.55039346e-02f,
  -4.17887047e-02f, 4.04952057e-02f, -6.06855042e-02f, 1.21072374e-01f, -9.06261131e-02f, -3.03339567e-02f, -2.32611168e-02f, -1.05576783e-01f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -9.60328802e-03f, 8.83199926e-03f, 1.27978297e-02f, -8.05025361e-03f, 9.30958688e-02f, 3.17168534e-02f, 4.82157655e-02f, 7.17275962e-03f, 2.87070908e-02f, -4.01661405e-03f,
  9.64719728e-02f, -2.73169316e-02f, 3.54596823e-02f, -1.08656667e-01f, 1.54774085e-01f, -8.13156068e-02f, -3.61687243e-02f, -7.15575814e-02f, 2.30002240e-03f, 2.58112047e-02f,
  -1.53303996e-01f, 3.44319679e-02f, -1.25955999e-01f, 2.94468906e-02f, -2.16858745e-01f, 6.81179166e-02f, 3.79141457e-02f, -9.54074711e-02f, 4.44181859e-02f, 1.74915157e-02f,
  1.95376482e-02f, 6.71571344e-02f, 8.45550969e-02f, 5.93544804e-02f, 1.73024178e-01f, 1.64340679e-02f, -7.10384399e-02f, 8.84704739e-02f, -3.19906250e-02f, 8.23160410e-02f,
  3.43275331e-02f, 2.76537836e-01f, 6.63241521e-02f, 1.34758145e-01f, 9.98202413e-02f, -1.03579760e-01f, 6.16042465e-02f, -1.86868310e-01f, 2.16463730e-01f, 9.60894674e-03f,
  -3.80328633e-02f, -2.06942439e-01f, 1.74414590e-01f, -6.02069162e-02f, 3.30931455e-01f, 3.15342844e-02f, 8.00602213e-02f, 6.15865774e-02f, 2.27885842e-01f, -8.88535902e-02f,
  2.44507015e-01f, 1.29993454e-01f, 8.56891051e-02f, 1.74410537e-01f, 4.34489064e-02f, 5.98814115e-02f, 2.51252621e-01f, 1.02619775e-01f, 1.42220438e-01f, 9.80268419e-02f,
  1.52008176e-01f, 1.64988220e-01f, 1.07082300e-01f, 1.85351461e-01f, 1.05416901e-01f, 2.33962819e-01f, 2.01412782e-01f, 3.46451029e-02f, -8.68240092e-03f, -5.96146993e-02f,
  1.21029187e-02f, 4.60460037e-02f, 2.79580429e-02f, 7.69625083e-02f, -3.01025417e-02f, 1.57599911e-01f, 1.64093226e-01f, -7.74080902e-02f, 5.93008175e-02f, 1.45518526e-01f,
  -1.36623219e-01f, 3.34916025e-01f, 1.74954161e-01f, -8.84981379e-02f, 7.30447546e-02f, -8.30371976e-02f, 2.88267583e-01f, 3.15360129e-02f, 2.48393156e-02f, 1.45617619e-01f,
  -1.72332060e-02f, -7.96709955e-02f, 3.93067971e-02f, -2.89181061e-02f, -5.07250316e-02f, 1.23846918e-01f, 4.92276065e-02f, 6.14904203e-02f, -1.80862650e-01f, 1.08209275e-01f,
  -6.75022379e-02f, 2.68170655e-01f, 6.84887990e-02f, -2.15142921e-01f, 9.01218653e-02f, 5.78012429e-02f, -6.14522882e-02f, -3.55721489e-02f, -1.11879177e-01f, -1.19148523e-01f,
  -1.51586249e-01f, -3.42195295e-02f, -1.91501766e-01f, -4.67579737e-02f, -1.80295900e-01f, -9.64972079e-02f, -1.69404209e-01f, -8.84099826e-02f, -3.64437327e-03f, -1.47868395e-01f,
  -1.37091488e-01f, -5.68710677e-02f, -8.11169222e-02f, -1.04156636e-01f, -1.45103201e-01f, -4.97996695e-02f, -2.81676892e-02f, -2.32298933e-02f, -6.10630885e-02f, -1.40587658e-01f,
  6.03740551e-02f, -6.22882433e-02f, 7.60327280e-02f, 9.48353391e-03f, -1.19880162e-01f, 1.58404067e-01f, 5.47276996e-02f, 9.56085771e-02f, 8.85389466e-03f, 3.58554535e-02f,
  5.83297946e-02f, -1.50500029e-01f, -1.38266350e-03f, 1.30793646e-01f, -2.49530658e-01f, 5.81020452e-02f, 2.09644839e-01f, 3.63448486e-02f, 1.22558266e-01f, -6.36655986e-02f,
  -2.53451187e-02f, 3.22706163e-01f, 5.82534336e-02f, -3.13672982e-02f, -1.71771944e-01f, -1.93927497e-01f, 6.50648996e-02f, -9.02173296e-02f, 1.07771613e-01f, 5.39528877e-02f,
  3.25629786e-02f, 1.42424228e-02f, -8.18250924e-02f, 7.92927444e-02f, 8.85471702e-03f, -7.91308954e-02f, -1.66633144e-01f, 8.97097662e-02f, -1.24114603e-01f, -1.47348672e-01f,
  -1.76622823e-01f, 5.13952114e-02f, -1.13803828e-02f, -1.07784353e-01f, 4.49411273e-02f, 1.48243323e-01f, -9.93493646e-02f, 9.91707016e-03f, 1.74936339e-01f, 1.86069787e-01f,
  -1.24461837e-01f, 1.22813612e-01f, 4.87837084e-02f, 6.19997233e-02f, -4.71330388e-03f, 6.21671267e-02f, 1.37972506e-02f, 6.69242293e-02f, 3.83061320e-02f, 3.40323187e-02f,
  1.41579553e-01f, 7.42005482e-02f, 2.96908077e-02f, 7.76949152e-02f, 1.23483546e-01f, 1.50351170e-02f, -1.95747614e-02f, 8.74138698e-02f, -9.68941376e-02f, 3.57900336e-02f,
  -6.33802488e-02f, 1.23043962e-01f, 1.38320476e-01f, 8.57826620e-02f, 4.31416221e-02f, -4.38146405e-02f, 5.55899478e-02f, 1.87891368e-02f, -1.00837193e-01f, 1.59651309e-01f,
  6.58513904e-02f, -1.16972148e-01f, 2.34073460e-01f, -3.50460373e-02f, 7.43824430e-03f, 1.39093339e-01f, 8.51478875e-02f, 1.49650738e-01f, -1.36239529e-01f, 5.15945591e-02f,
  1.22023925e-01f, 7.07238689e-02f, 5.89845553e-02f, 5.18558100e-02f, 1.78002879e-01f, 3.21667418e-02f, 5.10118529e-02f, 1.42653480e-01f, 2.09537279e-02f, 2.42785811e-02f,
  -4.92035523e-02f, -2.36772411e-02f, 6.80402480e-03f, -2.31570075e-03f, 1.76924579e-02f, -1.64782703e-01f, 1.63349323e-02f, 5.01058437e-02f, -5.14517948e-02f, 6.82606250e-02f,
  2.59925686e-02f, 1.23255774e-01f, 1.26977935e-01f, 1.22796848e-01f, -1.46205693e-01f, -2.89037302e-02f, -2.62289774e-02f, -2.10633166e-02f, 1.20409861e-01f, -2.78847814e-02f,
  3.55979018e-02f, 9.74289700e-03f, 4.56371158e-02f, 4.68316339e-02f, -8.46878737e-02f, 4.55780737e-02f, -7.97966123e-03f, -1.75358541e-02f, -1.23420559e-01f, 4.66538535e-04f,
  -1.21171899e-01f, -9.52400714e-02f, 6.72439039e-02f, -7.45971352e-02f, 6.33960143e-02f, -1.18058994e-01f, -1.07628576e-01f, -1.24469236e-01f, 1.94389205e-02f, 7.06357360e-02f,
  9.50784311e-02f, 1.25252288e-02f, 1.56754643e-01f, 4.60221618e-02f, -4.30389494e-02f, 1.57095030e-01f, -7.92678893e-02f, 1.46116912e-01f, 1.74003802e-02f, -1.54126391e-01f,
  -4.39540893e-02f, 4.78048623e-02f, 1.53238803e-01f, -6.30479725e-03f, -8.43277350e-02f, -6.03135079e-02f, 1.49551794e-01f, -2.93170684e-03f, -1.01639599e-01f, 7.27260858e-02f,
  -2.16931105e-02f, -1.48831224e-02f, -2.55965497e-02f, 1.64982930e-01f, 7.38992169e-02f, 7.62089938e-02f, -5.78914694e-02f, 1.17858805e-01f, -1.83193455e-03f, 1.63771823e-01f,
  -5.59935831e-02f, 1.68167681e-01f, 1.41234457e-01f, 3.10707814e-03f, 7.18143508e-02f, 2.55589690e-02f, -1.27010539e-01f, -1.32853016e-01f, 1.34122640e-01f, -5.25470600e-02f,
  -7.92310759e-02f, -1.98184587e-02f, 2.27589700e-02f, -5.72032481e-02f, -3.29104476e-02f, -8.37673396e-02f, -9.95021896e-04f, -8.38764235e-02f, -1.45915568e-01f, -7.02402601e-03f,
  5.34645431e-02f, -1.00030586e-01f, -2.55971819e-01f, 1.61642749e-02f, -1.24210920e-02f, -2.44908139e-01f, 1.31922185e-01f, -1.22018784e-01f, -4.69337311e-03f, -7.57582858e-02f,
  -3.06719214e-01f, -9.56710801e-02f, 7.21392930e-02f, 8.71177092e-02f, 1.23837501e-01f, 1.22983083e-02f, 1.36021554e-01f, 6.28762180e-03f, -1.08358368e-01f, 3.75169814e-02f,
  -8.38975906e-02f, -8.39538127e-02f, -2.41445415e-02f, 1.67178959e-02f, -7.26141557e-02f, 6.59081712e-02f, 1.46547467e-01f, 4.78198119e-02f, -2.56549083e-02f, 6.77032098e-02f,
  5.55057786e-02f, 1.39397413e-01f, -6.97736889e-02f, -9.01296660e-02f, -8.83237831e-03f, -4.08226065e-02f, -2.20200978e-02f, -1.01072378e-01f, 2.92250007e-01f, -5.14900349e-02f,
  -4.72004563e-02f, 5.68017364e-02f, -1.64228622e-02f, 1.45897180e-01f, 6.20685332e-03f, 5.49736712e-03f, 1.27365794e-02f, 1.31465420e-01f, 8.58268291e-02f, -9.80808586e-02f,
  4.84732203e-02f, -6.70760497e-02f, 3.44319910e-01f, 1.92352035e-03f, -1.57572050e-02f, 3.51370759e-02f, -1.37236584e-02f, 5.43803051e-02f, -4.45805537e-03f, -2.39498802e-02f,
  -2.26631127e-02f, 4.14078124e-02f, -1.13587938e-02f, -8.20628852e-02f, 1.00856163e-02f, -3.63398083e-02f, -6.61178008e-02f, 1.06967136e-01f, 7.19019994e-02f, 1.20679513e-01f,
  1.02181874e-01f, -1.42739505e-01f, -1.21291213e-01f, -4.98133488e-02f, 1.73828468e-01f, 1.09233782e-01f, -3.17824222e-02f, 9.50500295e-02f, 2.05179155e-01f, -1.21079206e-01f,
  2.03189626e-01f, 3.98094282e-02f, 7.23323971e-02f, -3.16200405e-02f, 9.33351293e-02f, -1.25462234e-01f, -6.07249141e-02f, 2.46436484e-02f, -1.32214371e-02f, 4.93550114e-02f,
  1.20278858e-01f, 4.38362472e-02f, 4.25298251e-02f, 8.71621966e-02f, -2.29318980e-02f, -1.29355431e-01f, 5.45416735e-02f, -1.29252106e-01f, 1.37427986e-01f, -6.86074495e-02f,
  1.41293192e-02f, -5.27459243e-03f, -9.73330140e-02f, 1.58650335e-02f, 2.08897755e-01f, 2.77580529e-01f, 1.57237753e-01f, 2.96989398e-04f, 3.47130299e-02f, 2.06996918e-01f,
  3.03510018e-02f, 4.73650917e-02f, 1.25385970e-01f, 7.80712515e-02f, 1.40612638e-02f, 6.14753440e-02f, 8.80771354e-02f, 4.12993878e-03f, 8.96014795e-02f, 7.67809898e-03f,
  1.91776622e-02f, -3.49288546e-02f, 4.10726033e-02f, -4.40458796e-04f, -6.03081100e-02f, 5.26462235e-02f, -2.76780017e-02f, 5.24972081e-02f, -7.79681206e-02f, 1.00955954e-02f,
  -1.65907502e-01f, -1.30610004e-01f, -1.26744568e-01f, -3.35803418e-03f, -2.89328955e-02f, 3.62129360e-02f, 1.16862908e-01f, -2.11496517e-01f, 4.90865018e-03f, -1.45275652e-01f,
  -8.40186700e-02f, 1.71297509e-02f, 1.49078807e-02f, 5.39114140e-02f, 7.48452768e-02f, -1.81339607e-01f, 5.90463318e-02f, 2.64493704e-01f, -9.25486013e-02f, 2.54767716e-01f,
  -1.45026401e-01f, -9.11595598e-02f, -6.29858747e-02f, -1.70587510e-01f, 2.04742283e-01f, -2.46925857e-02f, -6.57921359e-02f, -2.90080365e-02f, 1.54973924e-01f, 3.01892627e-02f,
  -1.59927115e-01f, 4.84206863e-02f, -3.38756405e-02f, -2.86088837e-03f, 1.46931959e-02f, 2.18715653e-01f, -4.07123342e-02f, 1.81855053e-01f, -1.55389324e-01f, 1.34571299e-01f,
  -1.51533335e-01f, 2.75637060e-01f, -7.94820562e-02f, 1.44218415e-01f, 2.03554213e-01f, 5.75186796e-02f, -8.73743370e-02f, 1.71069011e-01f, -6.11307248e-02f, -1.87195707e-02f,
  -2.92323492e-02f, -2.43167253e-03f, -1.27214594e-02f, -5.15599586e-02f, -3.89755890e-02f, -3.49788591e-02f, 1.39124319e-02f, -9.52021405e-03f, -4.72607017e-02f, -2.80506331e-02f,
  -7.91199692e-03f, -3.43032852e-02f, -2.67550722e-03f, -4.63520288e-02f, 2.21264586e-02f, -6.97680786e-02f, 4.83102500e-02f, 5.35393599e-03f, -1.23949766e-01f, -4.54656556e-02f,
  -2.27599647e-02f, 9.46511179e-02f, -2.45001353e-02f, -3.52884494e-02f, -5.22268452e-02f, 2.15030201e-02f, -8.59283730e-02f, 1.99360959e-03f, -9.70282108e-02f, -3.72803584e-02f,
  -1.41909709e-02f, -5.04843220e-02f, 1.31225809e-01f, 7.57708168e-03f, -5.17867506e-03f, 9.40074623e-02f, 7.16333836e-02f, -4.81085069e-02f, -1.84334129e-01f, 5.05662784e-02f,
  7.97740519e-02f, 1.66925173e-02f, 1.17376886e-01f, 5.05462177e-02f, 9.06305462e-02f, 1.45112529e-01f, 1.14713497e-01f, 1.18644573e-02f, 2.18427740e-02f, -2.35335175e-02f,
  -6.32369425e-03f, 2.71435324e-02f, -6.76150322e-02f, -2.55947530e-01f, 7.54936635e-02f, -1.39392633e-02f, 1.80871055e-01f, 3.36020887e-02f, 4.64674979e-02f, 6.35076240e-02f,
  1.72801659e-01f, 5.33826128e-02f, 2.49141186e-01f, 1.11602247e-01f, 2.04686429e-02f, 7.42836297e-02f, 4.79859114e-03f, 3.39662805e-02f, 6.56075329e-02f, 7.25177303e-02f,
  4.62818965e-02f, 8.83126482e-02f, 3.15216370e-02f, 6.02158159e-02f, 1.30139396e-01f, 1.45558506e-01f, 3.57867554e-02f, 3.91339771e-02f, 2.06624717e-01f, 4.76753898e-02f,
  7.56289810e-02f, -2.07154099e-02f, -2.90409140e-02f, 4.69741337e-02f, -4.64349128e-02f, 1.11379020e-01f, 5.08737266e-02f, 1.45935342e-01f, 1.32221833e-01f, -9.20282900e-02f,
  7.97878727e-02f, 1.37537807e-01f, -1.70302466e-01f, 2.87938684e-01f, 2.13016510e-01f, -1.68583110e-01f, 2.27998748e-01f, -5.89604452e-02f, 9.37814638e-02f, 2.14037076e-01f,
  8.98054838e-02f, 1.16937801e-01f, -1.00933567e-01f, -1.91194378e-02f, 1.35486394e-01f, 4.01919847e-03f, -5.54942302e-02f, 5.85013852e-02f, 9.52613354e-02f, 1.08891182e-01f,
  -1.68569144e-02f, 1.24971583e-01f, 3.67388614e-02f, 1.91183221e-02f, 3.21771093e-02f, -1.62885606e-01f, 1.17952168e-01f, 4.57583368e-02f, -1.55353115e-03f, -1.44120499e-01f,
  4.74028252e-02f, -1.42681509e-01f, -1.30332842e-01f, 5.63566610e-02f, -3.19814123e-02f, 5.89965656e-02f, 1.56589031e-01f, 1.30571425e-01f, -7.52391145e-02f, 3.23155560e-02f,
  3.10759898e-02f, 3.71385142e-02f, 1.12643242e-01f, 2.24506147e-02f, 5.91159388e-02f, -1.03112718e-03f, 1.95085462e-02f, 2.63669565e-02f, -1.79642253e-02f, 1.46832978e-02f,
  1.15139678e-01f, 2.37414148e-02f, -1.41445138e-02f, -1.12117656e-01f, 1.61102563e-01f, -1.52558506e-01f, -5.53355590e-02f, -6.07966781e-02f, 5.21337762e-02f, 6.61294237e-02f,
  -2.69599646e-01f, 5.29226512e-02f, -7.59996772e-02f, 5.44984713e-02f, -1.47037774e-01f, 1.50208503e-01f, -5.25296666e-03f, -1.10599466e-01f, 1.03542684e-02f, -7.76809780e-03f,
  6.82486407e-03f, 2.49975212e-02f, 1.63938239e-01f, 1.21558309e-01f, 2.20440537e-01f, -1.47807458e-02f, -1.04049277e-02f, 1.05066165e-01f, -9.11063999e-02f, 1.20438198e-02f,
  1.16789386e-01f, 3.54902327e-01f, 1.16984040e-01f, 1.57622099e-01f, 5.46811940e-03f, -1.02946989e-01f, 6.44910857e-02f, -8.68736878e-02f, 2.65009761e-01f, -5.37501946e-02f,
  -3.75642702e-02f, -2.18071669e-01f, 8.44853744e-02f, -2.46808510e-02f, 2.50830770e-01f, -2.23738886e-02f, -6.35527447e-02f, 1.08943999e-01f, 2.17755094e-01f, -1.73481107e-01f,
  2.11056665e-01f, 9.82377231e-02f, 2.51993895e-01f, 1.10692106e-01f, 6.32401332e-02f, 1.33636713e-01f, 1.21281095e-01f, 9.25910249e-02f, -2.19897330e-02f, 2.47141179e-02f,
  1.48512825e-01f, 4.29910868e-02f, 9.14095417e-02f, 5.18151894e-02f, 8.28027427e-02f, 2.46563405e-02f, -4.55069952e-02f, 1.05321832e-01f, -9.13014561e-02f, -1.36114601e-02f,
  1.44390032e-01f, -1.07841574e-01f, -7.96287432e-02f, -4.53242809e-02f, -8.16704184e-02f, 6.19784417e-03f, 4.54963297e-02f, 9.73689780e-02f, 1.77642256e-01f, -3.02548036e-02f,
  2.98668504e-01f, 7.97560439e-02f, -4.93529625e-02f, 1.11865826e-01f, -5.45477048e-02f, -1.78269278e-02f, 6.26304671e-02f, -1.54533386e-01f, -5.72155155e-02f, 2.15657592e-01f,
  2.05881163e-01f, 2.34522354e-02f, -9.14037526e-02f, 1.47020012e-01f, 6.40278310e-02f, 5.78001142e-02f, 9.15850922e-02f, -8.99269655e-02f, 7.93936551e-02f, -5.71539775e-02f,
  -1.37333563e-02f, 2.28378668e-01f, 1.81937099e-01f, -7.77916759e-02f, 2.02605233e-01f, 3.38038415e-01f, 2.24370629e-01f, 1.29309312e-01f, 1.28577026e-02f, 2.21061662e-01f,
  -9.38467775e-03f, -1.67634916e-02f, 2.34217376e-01f, 1.95723735e-02f, 1.99216534e-03f, -1.03535905e-01f, 2.43445382e-01f, -1.04140051e-01f, -1.88296381e-03f, 1.31425723e-01f,
  1.42570540e-01f, 7.78502077e-02f, 9.87665579e-02f, 1.06104068e-01f, 1.13615282e-01f, 5.68695031e-02f, 3.33920568e-02f, 1.73395630e-02f, 9.95684490e-02f, 1.16695583e-01f,
  1.10830493e-01f, -1.75980963e-02f, 1.00082889e-01f, -5.62588759e-02f, 6.07530028e-03f, -5.92414476e-02f, 5.85005470e-02f, -5.68070263e-03f, -1.32227719e-01f, 5.57227097e-02f,
  -4.74133715e-02f, 1.11159086e-02f, -1.16504073e-01f, 6.55203834e-02f, 7.93208107e-02f, -3.41670625e-02f, 6.06526509e-02f, -3.06484289e-02f, -7.15246201e-02f, 5.24107628e-02f,
  1.93238646e-01f, -1.06877461e-01f, 1.02213018e-01f, 9.55768153e-02f, -3.04684378e-02f, 5.27949743e-02f, -6.44361526e-02f, 8.73206928e-02f, -2.25475691e-02f, 1.75055683e-01f,
  1.67535692e-01f, 1.37248501e-01f, 5.07922322e-02f, -7.87083656e-02f, 9.43339989e-03f, 8.30292106e-02f, 2.71594465e-01f, -7.97768384e-02f, 7.15936795e-02f, 5.30580468e-02f,
  6.32476956e-02f, -1.23885229e-01f, 1.25201106e-01f, 1.26084127e-03f, 4.01204481e-04f, -9.10470262e-02f, 5.93922101e-02f, -1.58295766e-01f, -3.45079340e-02f, -5.09978347e-02f,
  5.86093888e-02f, -2.13137781e-03f, -7.29726553e-02f, -1.06909856e-01f, -8.42912644e-02f, -9.45071951e-02f, -7.01292828e-02f, -1.50402591e-01f, -1.02217831e-01f, -1.09310914e-02f,
  -7.78286606e-02f, -6.06260151e-02f, -8.68990198e-02f, -7.59916008e-02f, -3.63063142e-02f, -7.48931244e-02f, 1.36651456e-01f, -5.87801561e-02f, -1.81445144e-02f, 5.26168905e-02f,
  9.07476842e-02f, 3.86641012e-03f, -6.40424192e-02f, 3.58389132e-02f, -1.78539138e-02f, -3.24589573e-02f, -3.69443297e-02f, 7.02731088e-02f, -1.22071385e-01f, -6.65989220e-02f,
  1.58493727e-01f, 4.70764749e-02f, -8.36570784e-02f, -4.79586907e-02f, -3.40186022e-02f, 1.94987938e-01f, 3.57083492e-02f, 2.17594542e-02f, -6.59337863e-02f, -1.50293306e-01f,
  -7.29489550e-02f, -6.52536452e-02f, 7.85234571e-02f, 2.92160325e-02f, -5.92176728e-02f, 1.19907811e-01f, -7.73064345e-02f, -5.71567565e-02f, 8.49953096e-04f, -5.80149181e-02f,
  -6.06423952e-02f, 1.12044133e-01f, -1.52193144e-01f, -7.38348588e-02f, -1.08847260e-01f, 2.60060877e-02f, 1.15895793e-01f, 9.48469527e-03f, 2.14726068e-02f, 1.81416094e-01f,
  1.29876370e-02f, -7.10877255e-02f, 6.26790375e-02f, 1.59587339e-01f, -3.87635231e-02f, 9.23531055e-02f, 6.74039572e-02f, 9.05313641e-02f, -2.28895544e-04f, 3.12886722e-02f,
  6.94937930e-02f, 1.19633093e-01f, 5.80527484e-02f, 2.84381825e-02f, 6.89503551e-02f, 4.65290882e-02f, 2.37252284e-02f, 6.54898658e-02f, 1.81382783e-02f, -8.41441005e-02f,
  -9.56611335e-02f, 1.05645426e-03f, -1.65870011e-01f, -2.84796003e-02f, -2.45342217e-02f, 8.68461654e-02f, -3.10251899e-02f, -4.44313474e-02f, -1.13725923e-01f, -3.82240154e-02f,
  -1.42923087e-01f, 6.25419170e-02f, -5.99255711e-02f, -9.95815545e-03f, 3.05695180e-02f, 3.42141613e-02f, 1.02529578e-01f, 9.24018174e-02f, -4.78139147e-02f, -2.01254692e-02f,
  1.15564130e-01f, 7.59170577e-02f, -1.63052633e-01f, 9.50938910e-02f, 3.86980847e-02f, -6.76020831e-02f, 1.11493997e-01f, 6.03150949e-02f, 1.29729612e-02f, 1.83118224e-01f,
  1.48613155e-01f, 4.00334746e-02f, -1.63005423e-02f, -1.10133290e-02f, 6.73051253e-02f, 5.69676980e-02f, -1.34333698e-02f, -2.41426945e-01f, 9.98083279e-02f, -4.06093635e-02f,
  9.83378291e-02f, 1.15872614e-01f, 1.24821655e-01f, -2.39754468e-03f, 1.33382767e-01f, 7.09830746e-02f, 2.11705253e-01f, 5.00605628e-02f, -4.57965806e-02f, 2.36944966e-02f,
  1.49559611e-02f, 9.00625512e-02f, 9.93893519e-02f, 2.82263048e-02f, 3.96479778e-02f, 4.11069132e-02f, 7.18978196e-02f, -2.69850274e-03f, 9.22065601e-03f, 5.21949381e-02f,
  3.93928327e-02f, 3.18802102e-03f, 2.14582030e-02f, 3.70452292e-02f, -2.54076663e-02f, -4.94851395e-02f, 5.18439636e-02f, -3.77425328e-02f, 1.43999700e-02f, -1.64703245e-03f,
  -7.88043216e-02f, -8.07177159e-04f, 5.96219413e-02f, -3.02942842e-03f, 9.35195014e-02f, 4.72778827e-02f, 1.05829298e-01f, 1.46888539e-01f, 7.54052773e-02f, 4.44420651e-02f,
  3.14412192e-02f, -3.74387242e-02f, 8.95226970e-02f, -5.94167374e-02f, -4.28602323e-02f, 1.28980860e-01f, 1.18480839e-01f, -2.94499975e-02f, 3.30883451e-03f, 3.85989621e-02f,
  2.24174932e-02f, 6.42492846e-02f, 3.48417498e-02f, -5.49620427e-02f, 1.28241498e-02f, 4.62433323e-02f, -2.28909273e-02f, 1.11627020e-01f, 1.05316445e-01f, -1.26863286e-01f,
  1.46902159e-01f, 1.74953103e-01f, 3.07775009e-02f, -5.79313887e-03f, -8.84873793e-02f, -1.71850193e-02f, -6.15583137e-02f, -4.86746207e-02f, 5.40240072e-02f, 3.44766341e-02f,
  -4.94045801e-02f, -8.77518952e-02f, 1.04659006e-01f, -9.59097967e-02f, 4.04418483e-02f, 2.07529627e-02f, 3.15392278e-02f, 4.01807576e-02f, 1.25974398e-02f, 4.12392803e-02f,
  7.19117075e-02f, 2.28852630e-02f, 3.64020304e-03f, 6.27223998e-02f, -2.53686830e-02f, 4.70112041e-02f, 1.67421959e-02f, -3.87271717e-02f, -2.15962127e-01f, 6.52490407e-02f,
  -7.20598996e-02f, 1.09645776e-01f, -4.49365331e-03f, 1.37886228e-02f, 1.36807278e-01f, -1.00564726e-01f, -9.45968702e-02f, -4.73248586e-02f, 3.39443088e-02f, 9.91482064e-02f,
  1.24013266e-02f, 1.13170095e-01f, 1.20971121e-01f, 1.82302013e-01f, 1.43872365e-01f, 2.13093221e-01f, -6.54637516e-02f, -2.88357604e-02f, -1.04023442e-02f, 2.48232633e-02f,
  2.50107925e-02f, 5.74657992e-02f, 3.50836031e-02f, -8.69530812e-02f, 1.84225395e-01f, -1.26929596e-01f, -2.27476936e-04f, 1.58553362e-01f, 8.51614997e-02f, 1.94040805e-01f,
  -4.28608097e-02f, 2.53331959e-01f, -1.71023086e-01f, 1.76800251e-01f, -2.90801302e-02f, 2.06764545e-02f, 3.13695483e-02f, 1.24547608e-01f, -7.60884061e-02f, 1.75048262e-01f,
  2.03068748e-01f, -6.45867828e-03f, -6.11905307e-02f, 2.16519579e-01f, 9.42944959e-02f, -3.32459509e-02f, -7.62203708e-02f, 1.83948129e-02f, 5.44124469e-03f, 6.46837875e-02f,
  -6.20035175e-03f, 3.89239863e-02f, 3.96520598e-04f, 6.98995814e-02f, 6.84241280e-02f, -5.15113659e-02f, -5.83110452e-02f, 6.56979457e-02f, 1.00748045e-02f, 5.77215552e-02f,
  -1.08114280e-01f, -4.51383777e-02f, -7.45031610e-02f, -1.23166122e-01f, -1.94349606e-02f, -1.57556638e-01f, -6.12352639e-02f, -9.15635470e-03f, -1.95604622e-01f, -9.19675231e-02f,
  -1.19826131e-01f, 8.66614878e-02f, -4.00562212e-02f, -3.20301130e-02f, 1.75422624e-01f, -1.25134662e-01f, -2.18423352e-01f, 8.50085616e-02f, -5.76109327e-02f, 8.06796923e-02f,
  3.79718617e-02f, -1.16075151e-01f, 2.52170712e-02f, -1.71506833e-02f, 8.22008476e-02f, 2.04898909e-01f, -5.09559922e-02f, 3.77713107e-02f, 6.39654920e-02f, 9.20206383e-02f,
  2.79094800e-02f, 5.56389391e-02f, 1.40445530e-01f, 4.43433784e-02f, 8.44814349e-03f, -6.63791820e-02f, 2.71918952e-01f, -5.16401976e-02f, 8.44454840e-02f, -1.28440440e-01f,
  1.71317324e-01f, 4.68283817e-02f, 1.02123737e-01f, 5.93310818e-02f, 1.36240171e-02f, -8.44923183e-02f, 1.85164154e-01f, -9.76331979e-02f, 1.96997151e-01f, -4.18350585e-02f,
  2.43267864e-01f, -5.79811186e-02f, 4.92401831e-02f, 1.03204392e-01f, 4.34122570e-02f, 8.74407068e-02f, 2.91584618e-02f, 2.99369711e-02f, 6.33300617e-02f, -2.81201117e-02f,
  1.77461263e-02f, 5.76454364e-02f, 1.14696696e-01f, -4.56449203e-03f, 1.08388022e-01f, -5.28069213e-02f, 1.26878977e-01f, -3.09347715e-02f, -8.83855075e-02f, 5.45865344e-03f,
  -1.24320099e-02f, 1.35580942e-01f, -8.85739475e-02f, 6.84381649e-02f, -4.12440374e-02f, -3.89558561e-02f, -1.46012709e-01f, 1.66424699e-02f, -1.94738600e-02f, 1.17382251e-01f,
  8.59417841e-02f, -1.23600379e-01f, 8.38219002e-02f, -8.58369693e-02f, 9.42800418e-02f, 5.86547367e-02f, 9.72557664e-02f, 7.54719377e-02f, -8.15543905e-02f, 3.28359902e-02f,
  1.81827266e-02f, 1.02894284e-01f, 1.14142410e-02f, 1.25843197e-01f, 1.28704369e-01f, 5.20042181e-02f, 9.60858762e-02f, -4.87562735e-03f, 4.87803183e-02f, -9.69828516e-02f,
  1.99718222e-01f, -9.90279093e-02f, 1.51185587e-01f, -1.66559786e-01f, 1.78412348e-01f, -2.11804777e-01f, 1.41302601e-01f, -6.15637265e-02f, -4.11783978e-02f, 3.88512500e-02f,
  1.84666634e-01f, -1.03198454e-01f, 1.46887600e-01f, 7.29889646e-02f, 1.98632441e-02f, 3.78767550e-02f, 8.11689198e-02f, 1.30606681e-01f, 2.87037101e-02f, 4.00529727e-02f,
  1.41209336e-02f, 1.15718625e-01f, 3.15969475e-02f, -1.50299342e-02f, 1.09548541e-02f, 7.25508258e-02f, 3.51774618e-02f, 9.08526778e-02f, -2.49599591e-02f, -5.98049089e-02f,
  -4.19177627e-03f, 4.54184487e-02f, -1.21522509e-01f, -6.62385747e-02f, -5.48528470e-02f, -7.79051334e-03f, 1.40889054e-02f, -3.22541371e-02f, -1.41160399e-01f, 8.47525075e-02f,
  -1.17913827e-01f, -1.32445954e-02f, 1.42954633e-01f, -1.90434724e-01f, -9.87988263e-02f, 5.88553734e-02f, -4.02416959e-02f, 1.41960159e-01f, -4.45161648e-02f, -1.12091124e-01f,
  5.55703416e-02f, 1.19376443e-02f, -5.58490306e-02f, 1.93525791e-01f, -3.19940187e-02f, 8.78471211e-02f, 9.80119556e-02f, 3.25979702e-02f, 6.26161247e-02f, 1.15152776e-01f,
  1.07850507e-01f, -2.23924015e-02f, 8.37436691e-03f, 5.37380353e-02f, 8.83901864e-02f, 6.34213090e-02f, 9.22482386e-02f, -1.79628119e-01f, 1.45100549e-01f, -5.09738922e-02f,
  8.54737461e-02f, 1.14333324e-01f, 6.94882199e-02f, -1.03289656e-01f, 1.04781471e-01f, 5.10742702e-02f, 1.56914636e-01f, 1.54007385e-02f, 3.49403471e-02f, 6.46630954e-03f,
  1.50052324e-01f, 6.36173412e-02f, -4.41227034e-02f, 1.99581366e-02f, -1.43953273e-02f, 3.81081626e-02f, 2.93120705e-02f, 1.03958979e-01f, 1.46445185e-01f, 4.45256084e-02f,
  -6.56747445e-02f, 8.74267071e-02f, 8.43810141e-02f, -1.95689127e-02f, -1.06645003e-01f, 2.29904309e-01f, -2.89816014e-03f, 1.14868201e-01f, -4.72495183e-02f, -4.35981899e-02f,
  3.31994563e-01f, 1.94224101e-02f, -1.52614996e-01f, 2.91735642e-02f, 5.81031851e-02f, -1.73171107e-02f, 1.50701165e-01f, -5.35962507e-02f, 1.52609393e-01f, 1.72508284e-01f,
  8.74902233e-02f, 1.83868796e-01f, -9.92977917e-02f, -1.28283769e-01f, -9.28910971e-02f, -1.38364835e-02f, 4.11316790e-02f, 2.39074361e-02f, 3.99919190e-02f, 8.69382620e-02f,
  1.02821462e-01f, -1.68202773e-01f, 1.31994382e-01f, 8.09897706e-02f, 5.95783144e-02f, 6.79802969e-02f, -1.57003440e-02f, 2.60694087e-01f, -2.15211734e-01f, 1.39990985e-01f,
  2.23951355e-01f, 1.76932663e-01f, 2.44912356e-02f, 4.48306166e-02f, -1.55580476e-01f, 2.45490491e-01f, 6.13301285e-02f, -1.96650773e-01f, -1.81781501e-01f, 2.77968436e-01f,
  -1.42071739e-01f, -2.84316540e-02f, -2.19160274e-01f, -3.64641026e-02f, 1.20828666e-01f, 8.06115344e-02f, 4.56548780e-02f, 9.41231474e-02f, 5.71203865e-02f, 4.77023013e-02f,
  5.21997772e-02f, 8.85557756e-02f, 9.01818871e-02f, 5.70357107e-02f, 8.21328014e-02f, 4.74938676e-02f, 2.45668329e-02f, 1.99858304e-02f, 7.36620501e-02f, 8.30713436e-02f,
  -6.05348572e-02f, -7.17652813e-02f, -9.65199545e-02f, 1.50920427e-03f, 6.25851154e-02f, 4.82325777e-02f, -9.92597491e-02f, 9.90792587e-02f, -1.24519842e-03f, -1.30388346e-02f,
  1.43217117e-01f, 4.51003201e-02f, 2.31195763e-02f, 1.25111248e-02f, 7.61665925e-02f, 4.08570878e-02f, 7.70842284e-02f, -1.38492808e-01f, 8.10799077e-02f, 1.37990797e-02f,
  8.37033838e-02f, 1.99874192e-01f, 3.47835533e-02f, 1.53440446e-01f, -8.61093253e-02f, 9.32895243e-02f, 1.42025396e-01f, 5.14957532e-02f, 1.30588874e-01f, 1.91714093e-02f,
  3.37646753e-02f, 8.80787671e-02f, 1.39043465e-01f, -1.17516614e-01f, 2.69013703e-01f, 8.32561031e-02f, 1.53759733e-01f, -8.33151639e-02f, 2.76777726e-02f, 1.84885249e-01f,
  -2.93876715e-02f, -1.62149712e-01f, 6.38072118e-02f, 4.54445742e-02f, -4.52228170e-03f, -6.59407750e-02f, 3.00275460e-02f, -5.33274561e-02f, -1.57866254e-02f, 7.54818413e-03f,
  1.75053403e-01f, 1.73918940e-02f, 8.77877176e-02f, 2.04411484e-02f, 1.11673705e-01f, 7.50954449e-02f, -1.57267507e-02f, -7.90719129e-03f, 3.45429219e-02f, 1.99752878e-02f,
  -1.39273435e-01f, 7.51011372e-02f, -8.91089290e-02f, -8.03693905e-02f, 1.86113298e-01f, -9.64704677e-02f, -6.43581059e-03f, -1.30935445e-01f, -1.25670627e-01f, -6.16729185e-02f,
  4.40845564e-02f, 7.58346915e-02f, 1.81657240e-01f, -1.50618125e-02f, 1.84288055e-01f, 6.88482299e-02f, 4.67125811e-02f, 4.37953956e-02f, -1.62154719e-01f, 2.57709362e-02f,
  3.87687422e-02f, -1.32417172e-01f, -1.23965040e-01f, 1.86772868e-01f, 2.72448510e-01f, -1.91147663e-02f, -1.09011784e-01f, -1.53219532e-02f, 2.14378582e-03f, -1.78200647e-03f,
  -3.71979438e-02f, -6.85495883e-02f, 5.00500575e-03f, -1.09802291e-01f, -5.77852391e-02f, 1.61267921e-01f, 2.11675242e-01f, -7.86415115e-02f, 1.20041735e-01f, 2.70548880e-01f,
  3.02299503e-02f, 1.25488311e-01f, -1.02427781e-01f, 1.47137657e-01f, 4.07788828e-02f, 8.00391883e-02f, 9.54403728e-02f, -4.41712737e-02f, -2.36638412e-01f, -1.62822232e-01f,
  1.41986117e-01f, -4.83538024e-02f, 6.30701007e-03f, 2.72883214e-02f, 1.19050168e-01f, 2.67418381e-02f, 9.05732438e-02f, 2.35029124e-02f, 8.43627378e-02f, 5.07933348e-02f,
  -4.96937074e-02f, 2.70405337e-02f, 6.43815994e-02f, 7.59835467e-02f, 4.93444651e-02f, -8.97700042e-02f, -1.61507726e-01f, -8.51682872e-02f, -8.39212760e-02f, 3.24857533e-02f,
  1.51502639e-01f, -3.34358588e-02f, -1.21616252e-01f, -1.54583946e-01f, -2.29829364e-03f, -5.20853959e-02f, -3.18641402e-03f, 2.14086950e-01f, -2.13297419e-02f, 3.11215799e-02f,
  1.19858859e-02f, 1.05716944e-01f, -3.96598838e-02f, 2.56184131e-01f, 6.80056438e-02f, -2.85004023e-02f, 6.59215227e-02f, 6.20015804e-03f, 3.45923081e-02f, -4.00129408e-02f,
  -6.23246506e-02f, -1.45051733e-01f, 2.05900669e-01f, 5.01297116e-02f, 1.25191757e-03f, 2.54928768e-01f, -4.28594053e-02f, 1.13781586e-01f, -8.53514150e-02f, 2.57256150e-01f,
  9.09746364e-02f, 2.07751185e-01f, 3.17519158e-02f, 9.56595689e-03f, -1.55134544e-01f, 2.50886649e-01f, -1.07502379e-02f, 1.74517594e-02f, 2.08193466e-01f, 9.10275355e-02f,
  -6.95809498e-02f, 9.28059071e-02f, 5.80203012e-02f, -2.49985941e-02f, -1.84249841e-02f, 5.36211357e-02f, 3.92771289e-02f, 7.70143196e-02f, -1.34702966e-01f, 4.74722423e-02f,
  -5.14442474e-02f, 4.32322994e-02f, 3.92472632e-02f, -2.98731029e-02f, 8.76908153e-02f, 2.23753974e-02f, -6.68745935e-02f, -1.87365781e-03f, 4.57769595e-02f, 7.40004480e-02f,
  -8.27230066e-02f, 1.76948786e-01f, -1.31652147e-01f, -1.81054920e-02f, -1.38458908e-01f, 3.76744196e-02f, 2.40603730e-01f, -3.12064495e-02f, -3.75708081e-02f, 7.13972896e-02f,
  5.92949614e-02f, -1.25041813e-01f, 9.29267891e-03f, 3.48385349e-02f, -3.18517238e-02f, -8.20480138e-02f, 1.18301660e-01f, 1.71888899e-02f, -7.41243884e-02f, -7.61770159e-02f,
  -3.93938599e-03f, -4.32273783e-02f, -6.37902319e-02f, 1.04276471e-01f, 1.19923443e-01f, 8.20184872e-02f, 3.61944176e-02f, -1.61047786e-01f, 4.96513620e-02f, -9.06171277e-02f,
  1.39432713e-01f, 6.46182746e-02f, 3.38847712e-02f, 3.65642994e-03f, -1.84268340e-01f, 8.04628059e-03f, 4.42691669e-02f, -5.36260270e-02f, 1.82952806e-01f, -6.12194799e-02f,
  1.12768356e-02f, 1.70409858e-01f, 3.50785479e-02f, -1.38219759e-01f, 2.90464573e-02f, 1.59278035e-01f, 1.54464662e-01f, -1.94448009e-02f, -1.50147751e-01f, -6.71486557e-02f,
  9.13012102e-02f, 2.18936317e-02f, 2.10993122e-02f, 3.01435962e-02f, 3.75739634e-02f, 3.81735414e-02f, 4.49139103e-02f, 6.43673688e-02f, 1.44349739e-01f, 1.34787768e-01f,
  4.33649197e-02f, 8.84203836e-02f, 1.93328798e-01f, 1.50985075e-02f, -3.61291431e-02f, 9.64524671e-02f, -1.39700517e-01f, 2.14648675e-02f, 1.35481600e-02f, 6.38634190e-02f,
  1.66344002e-01f, 8.19929838e-02f, -1.58725074e-03f, -4.52764817e-02f, 3.95482965e-02f, 6.41956478e-02f, -4.85601760e-02f, 1.69413194e-01f, 1.45025671e-01f, -1.03720352e-01f,
  1.82393163e-01f, -3.09368987e-02f, 1.62056834e-02f, 9.38671231e-02f, 1.18269674e-01f, 6.30586147e-02f, -6.82110488e-02f, 7.00036436e-02f, 1.21727735e-01f, -9.16558420e-05f,
  6.77408800e-02f, 3.15093994e-02f, 9.41630229e-02f, 5.08116595e-02f, 2.22673733e-02f, 1.05160244e-01f, 5.02892062e-02f, 1.61973193e-01f, -3.75821590e-02f, -3.56834754e-03f,
  3.51042934e-02f, -8.48985165e-02f, 4.44046445e-02f, -1.03749938e-01f, 8.29809904e-02f, 4.62633409e-02f, -1.65753849e-02f, 1.23545537e-02f, -2.89631598e-02f, 1.29463181e-01f,
  1.27230242e-01f, 9.99988839e-02f, -2.00614050e-01f, -4.88724411e-02f, 1.42651066e-01f, 5.28959036e-02f, -1.83391217e-02f, 7.69896954e-02f, 5.52822240e-02f, 1.13031514e-01f,
  1.89823266e-02f, 1.08751453e-01f, 1.27765715e-01f, 1.12918854e-01f, 5.32603078e-02f, 5.88023849e-02f, 1.51326075e-01f, 2.08942890e-02f, -1.02409609e-01f, 1.93603739e-01f,
  -1.01512291e-01f, 1.08902030e-01f, -6.04445115e-03f, 4.81448881e-02f, 2.32962847e-01f, -5.02641350e-02f, -9.35460031e-02f, -6.77986667e-02f, 1.12879686e-02f, 5.99897802e-02f,
  1.12843728e-02f, 1.30796611e-01f, 1.10738434e-01f, 2.79805753e-02f, 1.97778061e-01f, 1.53547421e-01f, -6.40807897e-02f, 2.21688375e-02f, 1.04608469e-01f, 1.12416349e-01f,
  -6.10644408e-02f, 5.23757525e-02f, 1.48637697e-01f, -1.25351539e-02f, 9.33550149e-02f, -1.05093405e-01f, 5.52803427e-02f, 1.28001541e-01f, 1.16079062e-01f, 1.68372542e-01f,
  -2.35433839e-02f, 1.99575543e-01f, -1.86025366e-01f, 1.00111797e-01f, 1.05322137e-01f, 3.59909907e-02f, 1.15467519e-01f, -6.42527863e-02f, -8.45731348e-02f, 4.89846617e-02f,
  1.13683760e-01f, -5.14392629e-02f, -1.83480307e-02f, 1.68575883e-01f, 1.60706311e-01f, 5.62955774e-02f, -1.85495317e-01f, 3.43484432e-02f, 6.85892701e-02f, 3.01839262e-02f,
  -2.14776665e-01f, -4.58129356e-03f, -1.37967682e-02f, -2.37233266e-02f, -5.88897914e-02f, 2.71983296e-02f, -2.02418119e-02f, -9.51141939e-02f, -4.36213054e-02f, -9.96519178e-02f,
  -9.21298340e-02f, -4.74184528e-02f, 8.23446065e-02f, 1.25916153e-01f, -1.10728396e-02f, -6.28020540e-02f, -6.50622621e-02f, -9.43468139e-02f, 1.06895678e-02f, 3.86004858e-02f,
  -2.82046616e-01f, 1.51447117e-01f, -1.43124506e-01f, -1.04539283e-01f, 2.24650502e-01f, -2.85293490e-01f, -7.87510276e-02f, 1.42714992e-01f, -8.79982412e-02f, 8.37947577e-02f,
  -1.32586256e-01f, -1.38787910e-01f, 2.91057676e-02f, -3.70966084e-02f, 6.01372449e-03f, 2.33492270e-01f, -6.51216060e-02f, 2.14677513e-01f, -3.27373967e-02f, -7.35825449e-02f,
  7.55569059e-03f, 3.36980969e-02f, 1.91281125e-01f, -3.19560915e-02f, 5.10768928e-02f, -5.48877344e-02f, 4.36341874e-02f, 1.30958632e-01f, 1.26948565e-01f, -1.90587845e-02f,
  1.88022807e-01f, -4.46003443e-03f, 1.00029618e-01f, 1.14947326e-01f, 1.51420832e-01f, -1.58425987e-01f, 8.04487094e-02f, -1.07244747e-02f, 1.29338682e-01f, 2.87450086e-02f,
  1.08764537e-01f, 3.61019932e-02f, -3.22940648e-02f, -4.09830436e-02f, 5.79871759e-02f, -3.07470411e-02f, 3.75862047e-03f, 2.90400460e-02f, 2.74737459e-03f, -5.43468110e-02f,
  8.53404216e-03f, -8.15946460e-02f, 2.54735183e-02f, -7.57742822e-02f, -3.17672715e-02f, 1.59577414e-01f, 8.57474729e-02f, -4.47861478e-02f, 3.06650013e-01f, -1.43225044e-01f,
  -1.36931047e-01f, -1.04179248e-01f, 1.73882931e-03f, 6.48022071e-02f, 1.09656960e-01f, 9.48605835e-02f, 2.57558644e-01f, -1.37386113e-01f, 2.52380311e-01f, 6.41575083e-02f,
  1.29514039e-01f, -2.19644308e-02f, -4.83307280e-02f, -2.05036700e-01f, 5.01900725e-03f, 4.80042733e-02f, -9.12983716e-02f, 2.34420404e-01f, 1.92734018e-01f, -9.49778631e-02f,
  -1.41935023e-02f, 1.74334466e-01f, -1.04125202e-01f, -1.35921627e-01f, -3.32201719e-02f, -2.69188493e-01f, -4.52084579e-02f, -1.28922403e-01f, -2.38614399e-02f, -5.69119155e-02f,
  -1.69536546e-02f, -6.35420084e-02f, 1.76901713e-01f, 2.99010336e-01f, -3.40077537e-03f, 4.48536277e-02f, -1.08796865e-01f, 1.30963251e-01f, -9.48509723e-02f, 1.15189128e-01f,
  1.31041050e-01f, -1.13632986e-02f, -2.00744152e-01f, -4.40882519e-02f, 1.47963539e-01f, -3.92950512e-02f, 1.20873950e-01f, 3.04230154e-02f, -7.38662407e-02f, 1.05672024e-01f,
  2.74971668e-02f, 5.18739317e-03f, -4.46904041e-02f, -1.29363071e-02f, 3.57789136e-02f, -1.86739415e-02f, 8.29960629e-02f, -7.62645379e-02f, -8.74398947e-02f, -2.23779697e-02f,
  2.21447662e-01f, 1.88777167e-02f, -2.10431106e-02f, -1.03892162e-01f, -9.95609611e-02f, -5.18192649e-02f, -1.10755218e-02f, 1.33449733e-01f, -1.79240420e-01f, 1.32459417e-01f,
  -1.49183959e-01f, -7.56829754e-02f, 7.06422031e-02f, -2.30262876e-01f, -6.15570471e-02f, 4.31777202e-02f, -5.65967001e-02f, -1.91714447e-02f, -1.14093432e-02f, -4.94600907e-02f,
  7.24743679e-02f, -4.97479253e-02f, 2.01634895e-02f, 2.49171734e-01f, 1.55648794e-02f, 2.38432199e-01f, -1.25198454e-01f, 1.59557477e-01f, 1.50687039e-01f, -1.03503577e-02f,
  1.40196890e-01f, -8.04229155e-02f, 1.37477100e-01f, -7.85275847e-02f, 1.77766368e-01f, -5.91535866e-02f, 8.82201642e-02f, -5.87563962e-02f, 1.75028399e-01f, -7.86438882e-02f,
  2.55178213e-01f, 1.21010795e-01f, -5.53578287e-02f, -1.03039362e-01f, 1.52474999e-01f, -1.14868492e-01f, 1.30426869e-01f, 4.53333594e-02f, 1.56156451e-01f, -1.64250247e-02f,
  -3.09064239e-02f, -8.00655857e-02f, -1.79224133e-01f, -5.57012260e-02f, -4.50623669e-02f, -9.46556628e-02f, -9.44777131e-02f, -3.44762690e-02f, -9.46049392e-02f, -1.52109489e-01f,
  -4.93460372e-02f, -1.17975317e-01f, -1.59690261e-01f, -8.04922730e-02f, 1.36256188e-01f, -4.38820012e-02f, 3.06009576e-02f, -7.40981102e-02f, -5.99040999e-04f, -6.45975173e-02f,
  -4.88285199e-02f, 2.71961093e-03f, -1.37076482e-01f, 8.88766795e-02f, -3.61709706e-02f, -2.92324182e-02f, 8.62669125e-02f, -1.69222996e-01f, 5.90128191e-02f, 2.26881877e-02f,
  -6.96865693e-02f, 4.81420755e-02f, -1.07970841e-01f, 7.60647878e-02f, 9.03993472e-03f, -6.45289645e-02f, -7.18180137e-03f, 8.67879242e-02f, -4.27284241e-02f, 8.67446363e-02f,
  -6.96904911e-03f, 7.65864477e-02f, -1.70159806e-02f, -4.27083969e-02f, 4.51888554e-02f, -9.49666351e-02f, 4.73712385e-02f, -1.38505027e-01f, 2.72033159e-02f, 7.95373097e-02f,
  -1.20647456e-02f, -6.39653429e-02f, 7.56269693e-02f, 5.14620058e-02f, 1.53994709e-01f, 1.14924148e-01f, 6.24093786e-02f, 1.30096436e-01f, 1.18482009e-01f, -2.34527811e-02f,
  1.28484979e-01f, 9.47708786e-02f, 1.38110459e-01f, 1.13248765e-01f, 8.59425887e-02f, -3.26855443e-02f, -4.95401882e-02f, -4.86746803e-02f, -7.27499574e-02f, 5.50388843e-02f,
  -5.71691059e-02f, 1.58114955e-02f, 8.64461213e-02f, 4.41731997e-02f, -1.01175107e-01f, -1.92534290e-02f, 9.37988609e-02f, -1.94972102e-02f, -1.34525374e-01f, 1.10644788e-01f,
  -2.07458779e-01f, -9.52433422e-03f, -1.25554904e-01f, 1.40870810e-01f, 1.59628004e-01f, -1.34261906e-01f, -9.44474041e-02f, -1.76138654e-02f, -6.82915971e-02f, 1.31296795e-02f,
  3.24146450e-03f, -1.47134904e-02f, -1.93639342e-02f, -3.26426998e-02f, 1.15588419e-01f, -1.92049462e-02f, -7.07774684e-02f, 4.33338098e-02f, 4.87898290e-03f, -8.86378512e-02f,
  -2.34892264e-01f, 9.12666768e-02f, 1.73723146e-01f, -7.48964632e-03f, 1.06660075e-01f, -1.51681572e-01f, 1.22263290e-01f, 1.32294834e-01f, 1.98854521e-01f, 1.86151430e-01f,
  4.04064544e-02f, -5.61352149e-02f, -1.59357041e-01f, 6.60057589e-02f, 2.11473145e-02f, -2.68084943e-01f, 1.62042320e-01f, -7.06638619e-02f, -3.19833830e-02f, -1.09251132e-02f,
  1.53594827e-02f, -7.54391775e-02f, 7.37916380e-02f, 1.90745488e-01f, 2.71423519e-01f, 1.02055751e-01f, -1.92020088e-01f, -1.38370814e-02f, 1.08985215e-01f, 8.49176422e-02f,
  1.11597374e-01f, 3.32323164e-02f, 1.07352458e-01f, 7.88617879e-02f, 1.29928023e-01f, 4.19228189e-02f, 1.02828458e-01f, 7.16154799e-02f, 8.79871324e-02f, 1.07421055e-01f,
  2.08887234e-01f, 5.88127375e-02f, 8.44985694e-02f, 1.94553733e-02f, 2.53025368e-02f, 4.84502278e-02f, -1.05394065e-05f, 8.52805898e-02f, 6.28754273e-02f, 1.62980527e-01f,
  8.99108127e-02f, -7.76341856e-02f, 8.25535655e-02f, 9.89209637e-02f, -5.01633622e-02f, 2.22462907e-01f, 1.92523167e-01f, -8.65647644e-02f, 1.96405798e-01f, -1.28127247e-01f,
  1.19927093e-01f, 7.61432052e-02f, 8.98526460e-02f, 2.14891627e-01f, -3.10018361e-02f, -4.20878567e-02f, 6.72327578e-02f, 2.51119379e-02f, -5.80672584e-02f, 1.33472919e-01f,
  2.21705362e-01f, -1.18409796e-02f, -5.80750704e-02f, 1.11216567e-01f, 1.65003128e-02f, 6.89334944e-02f, -5.93939126e-02f, -1.76483020e-01f, 2.32286409e-01f, 2.23355010e-01f,
  -3.14461663e-02f, -9.86689851e-02f, -1.03282832e-01f, -6.49564713e-03f, -1.00711979e-01f, -1.26845036e-02f, 1.54537112e-02f, 4.98976149e-02f, -6.69869334e-02f, 2.51624379e-02f,
  -1.19391046e-01f, -7.18384981e-02f, 8.35489035e-02f, 8.54210928e-02f, 3.66411568e-03f, 6.56646043e-02f, -1.17769428e-02f, 7.90670291e-02f, 3.24935690e-02f, -2.06674472e-03f,
  5.23660034e-02f, 8.77226528e-04f, 2.39468832e-02f, -1.79482549e-02f, 5.63057140e-02f, 5.99755533e-02f, -1.89702399e-03f, 1.85822725e-01f, -2.32908837e-02f, -3.52306403e-02f,
  -1.23795085e-01f, 4.02398817e-02f, 1.99211553e-01f, 2.50282437e-02f, -1.43381506e-01f, 4.56036143e-02f, -2.44901776e-02f, -1.28461540e-01f, 1.02642670e-01f, 7.45861605e-03f,
  2.97834110e-02f, -1.01202466e-01f, 1.37954980e-01f, -1.17568905e-02f, -5.60863465e-02f, -9.66347083e-02f, 2.86882669e-02f, 9.59545523e-02f, -1.13350619e-02f, 1.76351294e-01f,
  8.04153681e-02f, 1.34308532e-01f, -1.04221990e-02f, -1.25675634e-01f, 1.68820426e-01f, -9.68991295e-02f, 1.28810599e-01f, 2.52040867e-02f, 2.67693847e-02f, 8.00480321e-02f,
  -5.18543199e-02f, -1.27338003e-02f, 2.43217930e-01f, 3.51089984e-02f, 2.97510177e-01f, -1.64923489e-01f, -1.80225179e-03f, 6.18983768e-02f, 1.41566740e-02f, -1.60287276e-01f,
  1.68454260e-01f, 6.66404292e-02f, 8.90327767e-02f, -3.15666199e-02f, -9.83978063e-03f, -4.68382314e-02f, -6.31507039e-02f, 1.27855733e-01f, 2.43769050e-01f, -1.05072027e-02f,
  4.26099785e-02f, 1.25386724e-02f, 5.12238815e-02f, -1.01047428e-02f, 1.33107165e-02f, 1.19252652e-01f, 4.40593101e-02f, 6.22095577e-02f, -1.12462774e-01f, -1.36840940e-02f,
  -1.35973454e-01f, -2.88872778e-01f, 6.69686943e-02f, -8.75564516e-02f, 1.09093748e-01f, 1.58485107e-03f, -2.69105643e-01f, -8.16969723e-02f, 1.14389732e-01f, -1.27403587e-02f,
  4.02056947e-02f, 1.88697875e-01f, -2.06497014e-02f, 7.90407360e-02f, -1.39114127e-01f, 2.10527261e-03f, -6.94736317e-02f, 6.03942722e-02f, 9.86887440e-02f, -2.17770394e-02f,
  2.28266362e-02f, 1.22470982e-01f, 7.10774139e-02f, 3.88195589e-02f, -1.29509181e-01f, -2.07710981e-01f, 1.51511043e-01f, 2.57889688e-01f, -8.02989975e-02f, 1.82918146e-01f,
  3.67182009e-02f, -4.95516956e-02f, -5.40149882e-02f, 8.16370398e-02f, 3.04664284e-01f, -2.06719749e-02f, -1.05802119e-01f, 6.99441880e-02f, -4.24501598e-02f, 1.48724332e-01f,
  6.20460659e-02f, 1.94375645e-02f, 5.34254722e-02f, 1.96319818e-01f, 1.04532197e-01f, -8.97010043e-02f, 6.26713037e-02f, -6.54230788e-02f, 1.19318046e-01f, 1.03501994e-02f,
  3.11127733e-02f, 4.80936430e-02f, 2.51886970e-03f, 6.25031814e-02f, 3.09171472e-02f, 2.75519639e-02f, 1.01382971e-01f, 1.30889148e-01f, 5.15508987e-02f, 1.22159617e-02f,
  1.00365039e-02f, 1.50805369e-01f, -3.34601826e-03f, -8.04799423e-02f, -1.67835668e-01f, 3.96976992e-02f, -7.88688064e-02f, 9.42414813e-03f, 7.53143802e-02f, -8.60063434e-02f,
  -5.81663214e-02f, -1.53683677e-01f, -1.76545575e-01f, -6.53579235e-02f, -1.54993236e-01f, 5.23571670e-02f, 3.61028910e-02f, -1.63710624e-01f, -1.04916831e-02f, 1.71765983e-01f,
  -8.17342773e-02f, 3.23695958e-01f, 8.47572833e-03f, -1.21064201e-01f, 1.06911376e-01f, -8.89894441e-02f, -3.96095365e-02f, 5.64840287e-02f, -1.55001402e-01f, -7.66321421e-02f,
  1.81084350e-01f, 3.12623121e-02f, -4.58915979e-02f, 2.15507790e-01f, 8.83320794e-02f, -5.90214645e-03f, -9.44945142e-02f, 2.28968859e-01f, -1.13220764e-02f, 2.84878850e-01f,
  -1.18468851e-01f, -5.71655929e-02f, 5.61448634e-02f, 1.60497293e-01f, -7.48224184e-03f, 1.53956801e-01f, 2.74644166e-01f, -6.78923680e-03f, 8.58005658e-02f, 3.53854112e-02f,
  6.84118792e-02f, -1.44435717e-02f, -3.62689346e-02f, 1.34960487e-01f, 1.14862889e-01f, 8.84350203e-03f, -3.79125364e-02f, 3.36693078e-02f, 1.18011152e-02f, 6.47147745e-02f,
  -4.09076102e-02f, 2.43014954e-02f, 6.21476620e-02f, 4.64576855e-03f, 2.85843629e-02f, 1.55228423e-02f, 4.73886542e-02f, -7.87225515e-02f, -8.73552412e-02f, 8.55589509e-02f,
  -1.29482582e-01f, 6.92130104e-02f, 5.97818606e-02f, 4.46456969e-02f, 1.48103073e-01f, -1.20645881e-01f, -9.44215879e-02f, -1.53371003e-02f, -7.36838579e-02f, 8.64633769e-02f,
  6.39825873e-03f, -3.48474160e-02f, 2.88843252e-02f, 6.52624741e-02f, 3.53344679e-02f, 1.39722362e-01f, -8.16815495e-02f, 3.43321227e-02f, 6.27283007e-02f, -5.00668809e-02f,
  -6.39864579e-02f, -4.42645662e-02f, 4.28622663e-02f, 2.05793697e-02f, 1.04131430e-01f, 4.90192557e-03f, 6.15540950e-04f, 1.50390670e-01f, 9.54390466e-02f, 1.12350754e-01f,
  8.06705095e-03f, 1.56885058e-01f, -1.41104102e-01f, 1.35706380e-01f, -5.03200665e-02f, -1.13708399e-01f, 5.63910790e-02f, 7.97425117e-03f, 4.69283722e-02f, 1.72638699e-01f,
  1.10350698e-01f, -2.91108824e-02f, -2.10971069e-02f, 1.48234189e-01f, 1.11174688e-01f, 6.59391433e-02f, -1.79255337e-01f, 9.74200144e-02f, -4.04217094e-02f, 1.03518374e-01f,
  1.26020610e-01f, 6.31994307e-02f, -4.58255038e-02f, 5.44537343e-02f, 4.23709974e-02f, -2.20332351e-02f, 7.75610507e-02f, 9.77502391e-02f, 6.40791953e-02f, 9.45912227e-02f,
  1.50425166e-01f, 3.16573791e-02f, 1.22084720e-02f, -6.19888753e-02f, 2.08288915e-02f, -3.67025137e-02f, -4.18567061e-02f, 1.50638774e-01f, -5.86459972e-02f, 4.14875038e-02f,
  1.30769029e-01f, -2.28142124e-02f, 6.58298805e-02f, -5.90176461e-03f, 6.09882642e-04f, 2.55619258e-01f, 6.78641796e-02f, -9.73511487e-02f, 1.70477018e-01f, -1.34481102e-01f,
  1.78601682e-01f, 1.13621816e-01f, 8.55798647e-02f, 2.88673550e-01f, -1.25249311e-01f, -3.87924276e-02f, 4.17770781e-02f, -3.04420628e-02f, 6.31564409e-02f, 5.36530912e-02f,
  7.67038390e-02f, 7.82311857e-02f, 2.64478400e-02f, -6.19369745e-03f, -1.15207415e-02f, 2.17778403e-02f, 1.63608044e-01f, -9.12050307e-02f, 8.34215432e-02f, 5.01752496e-02f,
  8.01964104e-02f, -1.96236745e-01f, 1.62402645e-01f, -5.47319986e-02f, -7.70466998e-02f, 1.05883501e-01f, 1.76732257e-01f, -1.08902134e-01f, 1.36939391e-01f, 5.74667379e-02f,
  3.07846982e-02f, 6.84054792e-02f, -3.78918229e-03f, 7.59292319e-02f, 1.77617759e-01f, -2.30858382e-02f, 8.65898952e-02f, 3.85166071e-02f, 4.58862409e-02f, -2.58062687e-02f,
  -9.38861072e-02f, 6.92622736e-02f, 1.04908377e-01f, -1.68292448e-02f, -1.17845766e-01f, -9.77061391e-02f, -2.93648187e-02f, -2.64293283e-01f, 9.42312554e-02f, -9.64047164e-02f,
  1.86879635e-01f, -1.03782110e-01f, -3.31710488e-01f, -9.43371803e-02f, -1.86680332e-02f, 4.56530862e-02f, 4.26747538e-02f, 9.61091816e-02f, -2.48976387e-02f, -2.90879644e-02f,
  1.01862270e-02f, 1.58105671e-01f, -1.82191804e-01f, 1.13309279e-01f, 2.79583819e-02f, -7.64276832e-02f, -7.68660149e-03f, 4.99337167e-02f, 1.86832488e-01f, -3.76556143e-02f,
  -1.34138778e-01f, -1.42012224e-01f, 1.53199881e-01f, 2.40282550e-01f, -5.83118163e-02f, 1.06064230e-01f, -1.31305322e-01f, -9.98761579e-02f, -3.46532464e-02f, 1.90549016e-01f,
  2.97552139e-01f, 6.95949513e-03f, -5.11597283e-03f, -2.03278754e-02f, -5.64969815e-02f, 1.58571541e-01f, 1.19972356e-01f, 1.16344169e-02f, 9.75302905e-02f, 1.44153014e-01f,
  5.76895289e-02f, -1.26741201e-01f, -7.28566572e-02f, -9.65344086e-02f, 1.50238335e-01f, 2.10129693e-02f, 8.10319185e-03f, 1.85699891e-02f, 5.65084293e-02f, 5.87280318e-02f,
  -1.20142167e-02f, 7.67207593e-02f, 8.12295154e-02f, 8.53533372e-02f, 6.62135631e-02f, 1.00583225e-01f, 4.98550199e-02f, 5.09441085e-02f, 1.25776857e-01f, -8.70683696e-03f,
  -2.00796396e-01f, -2.82664560e-02f, -1.24583423e-01f, 1.15903839e-01f, 1.11045174e-01f, 4.04024757e-02f, -1.52364764e-02f, -8.30760747e-02f, 1.03662759e-02f, -1.44821361e-01f,
  -3.32112014e-02f, 1.71163455e-01f, -2.75983270e-02f, 1.81505635e-01f, 1.05412565e-01f, 9.26203951e-02f, 1.24861605e-01f, 1.82258055e-01f, 8.90056863e-02f, 4.19332981e-02f,
  5.86980544e-02f, 1.28784493e-01f, -8.81000012e-02f, -1.46562234e-01f, -1.34851113e-02f, -1.23006940e-01f, 2.10447952e-01f, 1.18546724e-01f, -6.93536848e-02f, 2.46173844e-01f,
  -3.29185091e-03f, 1.65306553e-01f, -1.23496130e-01f, 2.42937550e-01f, -6.18832037e-02f, 1.76514164e-01f, -2.62973737e-03f, -9.72666219e-02f, -3.98741737e-02f, 1.19703030e-02f,
  2.35303063e-02f, 3.37593295e-02f, 1.71569750e-01f, 5.41760074e-03f, 7.29920641e-02f, 1.31469503e-01f, 1.13358341e-01f, 1.93032268e-02f, -6.38359040e-02f, 6.10017516e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  5.47483377e-02f, 2.26757023e-02f, 1.85982082e-02f, -6.40674989e-05f, 3.38167702e-05f, -3.18411849e-02f, -2.89839460e-03f, 3.25412601e-02f, 3.76603901e-02f, 6.64887130e-02f,
  5.84434383e-02f, 5.12671955e-02f, 9.02140513e-02f, -9.50721744e-03f, -1.90623756e-02f, 7.99260959e-02f, 7.66893476e-02f, 7.49205202e-02f, 4.56187949e-02f, 5.13515435e-02f,
  1.79640278e-02f, 1.50668388e-02f, 8.78298208e-02f, 6.79636896e-02f, -3.18037160e-02f, 5.17089777e-02f, 5.57841510e-02f, -1.67038701e-02f, 1.09801874e-01f, 6.29218072e-02f,
  1.10985013e-02f, -6.06495366e-02f, 1.22857690e-01f, -2.51761097e-02f, 2.58364249e-02f, 3.91223989e-02f, 2.82379314e-02f, 4.33028080e-02f, 2.86495499e-02f, -1.24810990e-02f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -1.81786576e-03f, -4.12960909e-03f, 2.58157495e-02f, 8.38591624e-03f, 4.01499718e-02f, 5.03837690e-02f, 8.01594704e-02f, -6.02259999e-03f, 7.28337690e-02f, 5.93340723e-03f,
  9.09545124e-02f, 4.23058122e-02f, -7.03809112e-02f, -3.95873152e-02f, 5.65640181e-02f, 2.20904686e-02f, 3.05689704e-02f, -5.39246798e-02f, -5.74721470e-02f, 2.25622095e-02f,
  5.47135845e-02f, 7.05232993e-02f, -7.69944070e-03f, -1.98125839e-02f, -2.38655079e-02f, 6.21734820e-02f, 5.36406748e-02f, 1.23651274e-01f, -6.97104111e-02f, -8.21902305e-02f,
  2.74272449e-02f, 7.89861381e-03f, 2.05130819e-02f, 1.08461700e-01f, 1.79923885e-02f, -1.06629737e-01f, 1.02557745e-02f, 6.29041344e-02f, 3.16846631e-02f, -2.85649970e-02f,
  1.57247426e-03f, -3.99215072e-02f, 3.33667849e-03f, 9.64436010e-02f, 7.54749998e-02f, 8.01625699e-02f, -1.17937982e-01f, 2.17888225e-02f, -2.39576977e-02f, 1.18479051e-01f,
  1.06522232e-01f, -1.03364084e-02f, -8.87704045e-02f, 5.62672727e-02f, 3.65991555e-02f, 4.63747187e-03f, 1.27383217e-01f, -8.37024823e-02f, -4.91743833e-02f, -9.82814655e-02f,
  9.02136564e-02f, 4.09261361e-02f, 1.65677927e-02f, 9.70834494e-02f, -8.79080128e-03f, 7.43701756e-02f, -4.82141133e-03f, -5.34702800e-02f, 8.84301364e-02f, 4.71185707e-02f,
  3.77289243e-02f, 6.81469589e-02f, 4.02913019e-02f, 7.93082491e-02f, 2.88246386e-03f, 1.82638522e-02f, -1.21621117e-02f, -5.85637875e-02f, 5.70736490e-02f, 2.78965990e-06f,
  -1.34232882e-02f, -7.73415389e-03f, 3.60781476e-02f, -5.49064279e-02f, 8.19835514e-02f, 1.84446704e-02f, -1.13850683e-01f, 8.66573900e-02f, -4.65246513e-02f, 4.68836650e-02f,
  -4.40334715e-02f, -2.31071748e-02f, 6.29285276e-02f, 8.66263807e-02f, 1.03749866e-02f, -2.54364014e-02f, -7.09030479e-02f, 1.03596663e-02f, 1.62286647e-02f, 1.41824692e-01f,
  7.19443485e-02f, -6.77060634e-02f, 4.14324962e-02f, 1.19971164e-01f, 5.77650107e-02f, 4.13148701e-02f, 1.53609831e-02f, -7.96710514e-03f, 2.73781400e-02f, 6.73764572e-02f,
  4.65770289e-02f, 9.14096907e-02f, -5.62756658e-02f, -2.20168270e-02f, -3.23232487e-02f, -9.06607136e-04f, 9.35356766e-02f, -5.32544497e-03f, -1.02119304e-01f, -3.47554833e-02f,
  2.88204588e-02f, -6.42178068e-03f, 1.09741449e-01f, -4.99533452e-02f, 1.43713979e-02f, 5.26654124e-02f, 1.55054063e-01f, -3.52127180e-02f, 6.61781281e-02f, -2.62160767e-02f,
  1.81849729e-02f, 2.20869072e-02f, -1.90913696e-02f, 8.22848380e-02f, -3.53122763e-02f, -4.85504139e-03f, -5.20169884e-02f, -1.58114138e-03f, -1.44704625e-01f, -1.85621658e-03f,
  6.66426420e-02f, 6.93401247e-02f, -9.96973515e-02f, -2.59565306e-03f, -5.00331968e-02f, -1.66278072e-02f, 6.35346025e-02f, -2.54063606e-02f, -2.69496739e-02f, -1.22887269e-01f,
  -3.10753509e-02f, -3.26329805e-02f, 6.94764182e-02f, -6.50154054e-02f, -8.19753483e-02f, -1.30185366e-01f, 7.48373643e-02f, 3.08858473e-02f, -5.08972183e-02f, 1.30687013e-01f,
  -5.61788902e-02f, -1.36094660e-01f, -3.18829864e-02f, 1.25957936e-01f, -1.39456184e-03f, -7.30083287e-02f, -6.70795739e-02f, 3.47921588e-02f, 3.97676742e-03f, 6.77334368e-02f,
  -1.50363758e-01f, -4.25380543e-02f, -3.54915597e-02f, -6.14849590e-02f, 1.13297313e-01f, 2.32535414e-02f, -4.27180678e-02f, -1.18771613e-01f, -1.28268981e-02f, 2.09030770e-02f,
  -2.21612975e-02f, -7.08578005e-02f, -2.78926101e-02f, 3.64858881e-02f, -1.34204015e-01f, -1.10298097e-01f, 8.11956525e-02f, 1.08256452e-01f, -4.31517884e-02f, -8.59587044e-02f,
  1.03720285e-01f, -1.08250730e-01f, 9.29397792e-02f, -2.89596952e-02f, 1.37952432e-01f, -5.48090693e-03f, -5.83697073e-02f, -7.08265156e-02f, -2.97397487e-02f, -5.78425229e-02f,
  -1.95854157e-02f, -4.52649221e-02f, -1.78324804e-01f, 8.59963223e-02f, 1.15532674e-01f, -1.45875905e-02f, -7.04052448e-02f, 1.60920224e-03f, -4.58489470e-02f, 3.71253565e-02f,
  1.29279003e-01f, 1.89669132e-01f, -1.27981409e-01f, -1.10503852e-01f, -6.66275620e-02f, -1.13586783e-01f, 8.98581743e-02f, -9.29075778e-02f, 2.04875297e-03f, -3.87478955e-02f,
  -1.66880971e-04f, -7.12665915e-02f, -1.81811452e-01f, 1.07135102e-01f, 1.26159251e-01f, -5.79458214e-02f, 7.38833398e-02f, -2.04911262e-01f, -1.06291883e-01f, 4.99377660e-02f,
  9.05941427e-02f, -1.10473245e-01f, 4.02933583e-02f, 1.26322433e-01f, -8.11403990e-02f, 6.72124550e-02f, 2.96453247e-03f, -8.93167183e-02f, -9.78118405e-02f, 3.98904867e-02f,
  6.12606071e-02f, 3.74123664e-03f, 7.46674137e-03f, -3.61074172e-02f, -2.53403157e-01f, -9.96718556e-02f, 4.63875420e-02f, 1.25086978e-01f, -6.42870516e-02f, -9.86370146e-02f,
  -4.96390164e-02f, 1.31953195e-01f, -1.42588827e-03f, -6.35888278e-02f, 1.05268627e-01f, -3.12441718e-02f, -6.13939725e-02f, -1.58571266e-02f, -6.61927760e-02f, -6.40113130e-02f,
  -1.63984504e-02f, -8.19878578e-02f, -1.08847812e-01f, 5.73897175e-03f, -2.95942388e-02f, -1.17405280e-01f, -3.79466675e-02f, -4.12711594e-03f, -7.27470638e-03f, -2.63737980e-03f,
  3.61337699e-02f, 1.62217561e-02f, 1.13990799e-01f, -7.31412694e-03f, -2.19081864e-02f, -2.62916535e-02f, -3.60018648e-02f, 3.04047484e-02f, 1.85107782e-01f, -6.04529791e-02f,
  6.87557913e-04f, -1.41272068e-01f, -7.57956728e-02f, -9.25078541e-02f, -1.92501754e-01f, -7.15616420e-02f, -8.13345518e-03f, -9.65805948e-02f, -3.92613783e-02f, -1.92428797e-01f,
  -3.57181020e-02f, -8.53109211e-02f, -3.65285315e-02f, -3.95473652e-02f, -6.75287992e-02f, -2.18829010e-02f, -1.35842368e-01f, -7.84599110e-02f, 4.43829596e-02f, -4.16653752e-02f,
  -5.54023646e-02f, 6.78948760e-02f, -5.22164628e-02f, -1.87602296e-01f, -5.39341606e-02f, -1.48891777e-01f, -1.48770243e-01f, 4.39720638e-02f, -6.03338480e-02f, 3.93409580e-02f,
  -5.21511063e-02f, -2.85518356e-02f, -5.67591041e-02f, -4.75101843e-02f, -2.17681691e-01f, -1.54819235e-01f, -1.07872998e-02f, -6.13715090e-02f, -2.39150450e-01f, -6.05693869e-02f,
  1.46903377e-02f, 9.96972807e-03f, -7.09015206e-02f, -1.07064061e-02f, -1.65568963e-02f, 8.23170766e-02f, -1.20075434e-01f, -4.30671461e-02f, -8.44805688e-02f, -1.61062434e-01f,
  -1.55366603e-02f, 6.83182254e-02f, 6.47373672e-04f, 2.05375463e-01f, -1.04488470e-01f, -9.71647575e-02f, -1.32845148e-01f, 6.96271434e-02f, -3.73973586e-02f, 7.85572082e-02f,
  5.45696542e-02f, -2.31439825e-02f, -4.21220213e-02f, -2.11307332e-02f, 8.47421736e-02f, 2.05030963e-01f, 1.76344365e-01f, 3.47099490e-02f, -3.43491584e-02f, -8.80270824e-03f,
  -1.25832170e-01f, 9.43553746e-02f, 1.24398448e-01f, 1.00636348e-01f, 1.75496429e-01f, -1.64466381e-01f, 2.38222140e-03f, 1.56062722e-01f, 2.45675421e-03f, -5.66039681e-02f,
  9.10550728e-02f, -8.91282856e-02f, 9.99198779e-02f, -3.21254618e-02f, 2.02475823e-02f, 5.20241447e-02f, 9.78874136e-03f, 1.43439636e-01f, -9.85124484e-02f, 1.27001062e-01f,
  1.19198635e-01f, -8.46546814e-02f, -1.99255690e-01f, 2.24111322e-02f, -8.83957604e-04f, -3.32255363e-02f, 1.38601199e-01f, -9.08639506e-02f, 2.60307547e-02f, 8.35694447e-02f,
  -6.75670290e-03f, 2.85984445e-02f, 1.08739369e-01f, 4.85538617e-02f, 2.94899736e-02f, 3.91382426e-02f, -9.33364332e-02f, 4.86834161e-02f, 7.56090507e-02f, 7.90814236e-02f,
  4.43613715e-02f, 6.10052496e-02f, -5.67436591e-02f, 8.50325357e-03f, -1.45304753e-02f, -6.85385708e-03f, -1.41412482e-01f, 1.24589605e-02f, 3.16020511e-02f, 1.44864768e-01f,
  1.47666544e-01f, -1.39522344e-01f, -1.92924857e-03f, 7.69558400e-02f, 5.86454272e-02f, 1.85827985e-02f, 1.24904038e-02f, 6.21433817e-02f, -5.67156449e-03f, 6.21003360e-02f,
  6.39308468e-02f, 7.03990906e-02f, 6.26903586e-03f, 1.36674661e-03f, 1.37050092e-01f, -4.25785035e-03f, -4.52667894e-03f, 7.66514614e-02f, -3.04269921e-02f, 1.16359048e-01f,
  -4.71005328e-02f, -4.94286455e-02f, 1.45063266e-01f, 9.12213027e-02f, 1.25290260e-01f, -2.91805808e-02f, 5.11574075e-02f, 6.43656477e-02f, 1.88426420e-01f, 1.38720974e-01f,
  8.86977762e-02f, 1.92096177e-03f, 2.05742583e-01f, 1.42933741e-01f, 1.77556068e-01f, 1.53500929e-01f, 1.24687806e-01f, 1.33796111e-01f, 3.38286348e-02f, 1.30500942e-01f,
  2.01755166e-01f, 1.60040081e-01f, -3.95515040e-02f, -5.73912486e-02f, 6.71888590e-02f, 1.04947016e-01f, -7.57374689e-02f, 1.77638054e-01f, -4.61305119e-02f, -4.97223288e-02f,
  4.67206864e-03f, 7.39583820e-02f, 1.52739203e-02f, 1.74718216e-01f, 5.21253571e-02f, 6.04416393e-02f, 1.57747447e-01f, -4.90054768e-03f, -2.09309515e-02f, 1.40601456e-01f,
  -7.19438344e-02f, 1.81041029e-03f, 3.37980725e-02f, -2.25960743e-02f, -3.73897105e-02f, -2.97136307e-02f, -2.17903946e-02f, -6.59657419e-02f, 2.54952703e-02f, 8.54453370e-02f,
  -6.59450665e-02f, 7.99807906e-02f, 2.02952288e-02f, 1.41275212e-01f, -1.37606058e-02f, 3.03351693e-02f, 1.43157884e-01f, 1.41341060e-01f, 6.45777136e-02f, 9.70790684e-02f,
  6.08959682e-02f, 2.31139492e-02f, 1.12997301e-01f, 8.75471458e-02f, 1.15124553e-01f, 1.25122843e-02f, 1.14302099e-01f, 1.33215040e-01f, 7.35161453e-02f, 2.07030445e-01f,
  5.24408594e-02f, 1.30971953e-01f, 1.05328530e-01f, 1.84577554e-01f, 1.38361007e-01f, 1.33947566e-01f, 5.80229610e-02f, 7.90352300e-02f, -4.10272777e-02f, 1.34347826e-01f,
  6.01557717e-02f, 1.56302124e-01f, 4.82874587e-02f, 1.35051040e-02f, 8.00778493e-02f, 8.02599713e-02f, 1.01110414e-01f, 6.75708205e-02f, 2.62116790e-02f, -1.29336622e-02f,
  9.19489190e-02f, -6.58219233e-02f, 1.52955353e-02f, -6.16217172e-03f, -3.37314866e-02f, 4.27095667e-02f, 2.14597974e-02f, -3.93488184e-02f, 1.72989164e-02f, 7.40352795e-02f,
  1.05668575e-01f, 4.98479344e-02f, -2.61823293e-02f, 9.29312631e-02f, 4.61581573e-02f, -1.22833580e-01f, 5.86674102e-02f, 1.24527782e-01f, 8.49209949e-02f, -6.66798577e-02f,
  -1.23535926e-02f, 9.60116014e-02f, 1.84180997e-02f, 5.54036908e-02f, -9.05573443e-02f, -2.23719347e-02f, 1.56167224e-02f, -1.21357152e-03f, -9.16309282e-02f, 4.39405292e-02f,
  -2.64182035e-02f, -4.89344858e-02f, -6.81327432e-02f, -2.01646425e-02f, -3.10850702e-02f, -6.52896166e-02f, -7.21831173e-02f, 5.95139377e-02f, -5.03675975e-02f, -1.22567102e-01f,
  3.18150711e-03f, 1.04147932e-02f, 1.23018868e-01f, 9.30760130e-02f, -1.67717263e-02f, 1.73276961e-01f, 1.02000572e-01f, 9.87076312e-02f, -1.09814316e-01f, 1.73862278e-02f,
  7.97639117e-02f, 5.70484810e-02f, 8.76225680e-02f, 4.70714979e-02f, -8.18593800e-02f, 2.58061029e-02f, -2.73651239e-02f, 1.58335477e-01f, -2.05623023e-02f, 1.19465748e-02f,
  -9.10831019e-02f, 4.30672169e-02f, 1.22293308e-01f, 1.64436288e-02f, 2.91090719e-02f, 2.63539068e-02f, 3.20676267e-02f, 4.83006537e-02f, 1.98976826e-02f, -5.31332148e-03f,
  1.42424358e-02f, -3.16459574e-02f, 5.60555095e-03f, 1.08829476e-02f, -2.85642799e-02f, -6.09811358e-02f, 9.55282152e-03f, 9.44361687e-02f, -8.34711641e-03f, -8.86629000e-02f,
  -2.03033201e-02f, -2.73653083e-02f, 1.57109611e-02f, 5.11895679e-02f, 4.34904592e-03f, 9.95369330e-02f, 1.25698233e-02f, 6.09943233e-02f, -1.02769956e-01f, -5.23461215e-02f,
  -8.41344148e-03f, 5.19554988e-02f, -2.46257931e-02f, -1.00766541e-03f, -6.15620948e-02f, -1.84209906e-02f, -1.33089691e-01f, -7.81764388e-02f, -1.28250930e-03f, -2.69122701e-03f,
  1.02775402e-01f, -6.29259571e-02f, -2.90075857e-02f, -8.47809389e-02f, 4.70985956e-02f, 5.38899153e-02f, 2.86668297e-02f, 1.07555777e-01f, 3.44546922e-02f, -4.70125563e-02f,
  -4.28728499e-02f, 5.89827448e-02f, -9.65666398e-02f, 1.08839236e-01f, -5.29943444e-02f, -3.42942253e-02f, 5.97044788e-02f, -7.16104954e-02f, -1.82143852e-01f, 5.35759963e-02f,
  -3.17616314e-02f, 1.13352820e-01f, -1.31850958e-01f, -1.16282757e-02f, 1.03796974e-01f, -1.59190614e-02f, 1.20707117e-01f, 9.97075066e-03f, -4.60386369e-03f, 1.28552377e-01f,
  4.61903885e-02f, 1.24896660e-01f, 1.71595477e-02f, -8.50369707e-02f, -2.28215568e-02f, -1.04423866e-01f, 7.39669725e-02f, -2.95132063e-02f, 6.61378503e-02f, -5.69918100e-03f,
  -2.81911958e-02f, -8.54367837e-02f, -2.97126751e-02f, -2.43868157e-02f, 8.59795064e-02f, 1.09413154e-02f, 8.47798586e-02f, -7.08847493e-02f, -1.46069331e-02f, -7.86955431e-02f,
  9.95566994e-02f, -6.16213642e-02f, 2.45050918e-02f, 1.00816391e-01f, -1.71269309e-02f, 1.28955826e-01f, 4.18512113e-02f, -6.58283159e-02f, -4.45315316e-02f, -4.55101058e-02f,
  -1.29661784e-01f, -1.15039319e-01f, 3.75239295e-03f, 1.15120649e-01f, -7.57734478e-02f, -5.11154421e-02f, -5.89385740e-02f, -6.87533095e-02f, -1.08619295e-01f, 9.12101492e-02f,
  -1.42160915e-02f, -8.41839090e-02f, 2.77674943e-03f, 1.84687935e-02f, -7.96225816e-02f, -2.45491005e-02f, -8.45663548e-02f, -6.39971942e-02f, -7.92810461e-04f, -9.44105312e-02f,
  4.78720339e-03f, -1.41067967e-01f, -4.94966805e-02f, -3.76754850e-02f, -8.32832754e-02f, -7.40605742e-02f, 1.00221872e-01f, -1.60581793e-03f, -8.36458281e-02f, -9.69430357e-02f,
  -1.13901105e-02f, 3.79776470e-02f, -6.15105703e-02f, -3.57228145e-03f, -6.57624677e-02f, 4.77274284e-02f, 2.95880754e-02f, 2.57958807e-02f, -9.77766234e-03f, -4.98104515e-03f,
  -1.27134868e-03f, -5.00103682e-02f, 4.00969982e-02f, -2.36814041e-02f, 2.04000194e-02f, 1.26091568e-02f, -2.84563145e-03f, -2.40292344e-02f, 1.26955146e-02f, 2.01279540e-02f,
  8.82174149e-02f, -3.90985236e-02f, -3.26872170e-02f, 1.01148017e-01f, 2.17327662e-02f, 3.34648117e-02f, 1.35704074e-02f, 2.38085147e-02f, 5.19268066e-02f, 1.46218995e-02f,
  4.18631136e-02f, 8.94401371e-02f, -9.34511870e-02f, -5.88373281e-02f, -4.38088365e-02f, -8.77839178e-02f, 7.54985660e-02f, 7.96103328e-02f, -1.50437877e-02f, -6.93855435e-02f,
  -2.17472315e-02f, 1.47123728e-02f, 1.85931399e-02f, -3.44540253e-02f, 6.98454529e-02f, -1.10962130e-01f, -3.59132290e-02f, -9.47009996e-02f, -2.92148739e-02f, -9.81853604e-02f,
  -8.81511420e-02f, -1.18755382e-02f, 1.04128964e-01f, -1.05943298e-03f, 6.75508901e-02f, 5.39751351e-03f, -1.44214518e-02f, -5.14492989e-02f, 8.29133485e-03f, 1.13835856e-01f,
  3.73955555e-02f, 7.76593573e-03f, -4.96690199e-02f, -3.58756259e-02f, 8.36552829e-02f, 8.72310251e-02f, -1.16960280e-01f, 4.07286249e-02f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  3.50147136e-03f, 4.32303585e-02f, -3.49352621e-02f, -5.93174947e-03f, -1.26048282e-01f, -2.75187800e-03f, -8.28176923e-03f, 5.42843416e-02f, -6.36018962e-02f, 1.30533688e-02f,
  -1.42574951e-01f, -9.95155349e-02f, 1.51958078e-01f, 5.17067239e-02f, -1.88391730e-01f, -7.26890564e-02f, -6.95386827e-02f, 2.27821339e-02f, 5.55666424e-02f, -1.47853568e-02f,
  -1.42220054e-02f, -6.29506186e-02f, -4.24031764e-02f, 1.90582518e-02f, -4.87635322e-02f, -7.83089325e-02f, 2.62624547e-02f, -1.41143113e-01f, 1.32422358e-01f, 1.19532295e-01f,
  -3.42701264e-02f, 2.06202775e-01f, -8.67891312e-03f, -1.60537362e-01f, -1.94303952e-02f, -5.02832569e-02f, -1.00865051e-01f, 4.24820744e-02f, -6.78856522e-02f, -3.24205123e-02f,
  9.61806327e-02f, 7.43361264e-02f, -2.02929914e-01f, -3.49282213e-02f, -1.00276805e-02f, -1.41032591e-01f, 1.88701719e-01f, 2.00519785e-01f, -1.30540043e-01f, -1.24987207e-01f,
  -1.11634046e-01f, -7.90833458e-02f, 6.72482327e-02f, -1.09560780e-01f, 4.20793444e-02f, -8.62004012e-02f, -1.36862680e-01f, -1.59691006e-01f, 1.60802990e-01f, 5.28373197e-02f,
  -4.69012931e-02f, -1.59136459e-01f, 2.29983583e-01f, 2.93346755e-02f, 5.00718094e-02f, -2.82466654e-02f, -1.61992863e-01f, -1.24386050e-01f, 3.38296406e-02f, -4.28236313e-02f,
  -8.37590545e-02f, 3.87998968e-02f, 1.13353869e-02f, -9.46189985e-02f, -6.47782013e-02f, 1.22723980e-02f, 9.10713449e-02f, 1.94120646e-01f, -7.72559047e-02f, 1.44880280e-01f,
  7.44385505e-03f, -7.29675293e-02f, -8.88129994e-02f, -3.14777829e-02f, 5.29975891e-02f, -8.21490027e-03f, -3.15310135e-02f, 3.50302756e-02f, -1.56304538e-01f, 7.65717849e-02f,
  8.87714252e-02f, -6.32946342e-02f, 8.52184221e-02f, -9.49196368e-02f, -1.61472693e-01f, 2.55187571e-01f, -1.43436924e-01f, -9.28657800e-02f, -1.75092325e-01f, -1.44564301e-01f,
  -2.70313136e-02f, 7.51308054e-02f, -8.41779709e-02f, -2.03962978e-02f, 1.63477004e-01f, -1.57141671e-01f, -3.11685115e-01f, 2.09226664e-02f, 2.19395071e-01f, -7.66842738e-02f,
  -6.66875169e-02f, 2.12233663e-01f, -3.38015929e-02f, -1.37959132e-02f, 2.59544961e-02f, -4.35505807e-02f, -5.41153960e-02f, -1.79390147e-01f, -6.35351390e-02f, -8.92473087e-02f,
  -6.48708269e-03f, -2.08594874e-01f, 1.84209272e-02f, 1.58248737e-01f, 1.09167337e-01f, -3.07347775e-01f, 8.58250773e-04f, 1.05646834e-01f, 2.50901654e-02f, 4.34474833e-03f,
  1.30481899e-01f, -2.46409718e-02f, -5.75274043e-03f, -2.15870906e-02f, 9.52140912e-02f, -1.05630292e-03f, 4.83797379e-02f, 1.16158701e-01f, -4.01822180e-02f, 5.69554344e-02f,
  1.34137110e-03f, -1.24430016e-01f, 7.67776296e-02f, 2.26821918e-02f, 4.23331149e-02f, -4.74101007e-02f, 1.04115739e-01f, -8.86900164e-03f, 4.46179658e-02f, 1.11434597e-03f,
  -1.89226568e-02f, 7.25069121e-02f, -1.23486295e-01f, -2.61760522e-02f, -1.84320435e-01f, -5.11789061e-02f, 1.29041806e-01f, 5.62834702e-02f, 1.15101956e-01f, 4.70394753e-02f,
  -2.27927305e-02f, -6.10441826e-02f, -4.76439930e-02f, 2.50288695e-01f, 9.56312567e-02f, -1.49641514e-01f, 4.74560633e-02f, 1.47664294e-01f, 1.01145826e-01f, 1.49765223e-01f,
  2.86959019e-02f, -3.25529017e-02f, 6.08386509e-02f, 1.29577845e-01f, 1.44603759e-01f, 1.08203813e-02f, 7.20185488e-02f, 5.22453897e-02f, -2.78268605e-02f, 2.23689936e-02f,
  1.26474380e-01f, -4.26339023e-02f, -6.68022931e-02f, 1.64559148e-02f, 1.40088573e-02f, 1.48601621e-01f, 8.26632231e-02f, 2.64488794e-02f, -1.04965828e-01f, 5.94226979e-02f,
  4.62366920e-03f, -6.00469522e-02f, 9.47617646e-03f, 2.39396021e-02f, 1.08956404e-01f, 9.55366120e-02f, 1.05444215e-01f, 5.05623817e-02f, 1.65828258e-01f, 6.35353178e-02f,
  1.55259892e-01f, 1.64373457e-01f, -1.50852101e-02f, 1.45807907e-01f, -1.00153148e-01f, -1.25624314e-01f, 1.03274405e-01f, 8.95266533e-02f, 7.92372227e-02f, -9.02170390e-02f,
  1.05176456e-01f, -3.04796845e-02f, 1.32618517e-01f, -5.28615899e-03f, -1.24562040e-01f, 6.32060617e-02f, 6.51003942e-02f, 1.58179000e-01f, -2.59499609e-01f, -9.37624127e-02f,
  9.78178717e-03f, -8.81331787e-02f, -9.52350125e-02f, -5.26528631e-04f, -7.18594790e-02f, -2.16533747e-02f, 6.76111653e-02f, 1.88142657e-01f, 1.26154423e-01f, -1.44009769e-01f,
  -2.02265456e-02f, 1.02396034e-01f, 6.68222755e-02f, 7.39352629e-02f, 7.95457885e-03f, 9.58953574e-02f, 4.06476632e-02f, 1.81931049e-01f, 1.33395091e-01f, 1.04286149e-02f,
  3.60166188e-03f, 8.99956897e-02f, 3.02937962e-02f, -6.77892193e-02f, -2.03494728e-01f, 1.79753695e-02f, -1.78933471e-01f, -6.81991130e-02f, 7.16171339e-02f, 1.96050838e-01f,
  1.33540154e-01f, 6.38938695e-02f, 6.91251783e-03f, -1.61680928e-03f, 1.21335395e-01f, 1.11581637e-02f, 3.74768004e-02f, 1.23345345e-01f, 1.40003592e-01f, 1.03642032e-01f,
  -8.23918544e-03f, 8.26399624e-02f, 8.04359540e-02f, 7.09433705e-02f, 6.60528392e-02f, 9.61482152e-02f, 1.19628021e-02f, 6.40870780e-02f, -5.60844950e-02f, -2.82374416e-02f,
  -5.61387045e-03f, -5.24980910e-02f, -2.17718650e-02f, -5.78509979e-02f, 2.88886782e-02f, 1.77724212e-02f, 1.03191800e-01f, -6.27936330e-03f, -4.17990014e-02f, 4.75617722e-02f,
  1.41479736e-02f, 2.78031260e-01f, -5.07430173e-02f, 6.89043030e-02f, -2.08765585e-02f, -3.09957583e-02f, 1.14715084e-01f, -3.68647128e-02f, 2.44107582e-02f, 2.51428097e-01f,
  3.90503667e-02f, 1.49755925e-01f, -1.90883167e-02f, 8.27273447e-03f, 4.26395908e-02f, 8.43349770e-02f, 1.59833021e-02f, -5.98061308e-02f, 7.32472241e-02f, -3.40413488e-02f,
  1.47296237e-02f, 1.03869036e-01f, 1.16455257e-01f, 7.07559586e-02f, -7.31801905e-04f, 1.32927850e-01f, -6.68358058e-03f, -1.82451487e-01f, 4.04014438e-02f, -1.33396000e-01f,
  -6.20938130e-02f, 2.46133395e-02f, 2.30188102e-01f, -8.70258361e-03f, 7.78865740e-02f, -7.26793781e-02f, -8.78421739e-02f, 1.98764741e-01f, 7.94345960e-02f, 1.34419324e-02f,
  5.97529560e-02f, 8.69382266e-03f, -4.20426428e-02f, 3.15522291e-02f, -6.70916354e-03f, 9.06983092e-02f, -1.97904017e-02f, 6.43310547e-02f, 6.65007010e-02f, 1.69955436e-02f,
  -6.12073243e-02f, 1.84277654e-01f, -3.57759930e-02f, -9.32594948e-03f, -1.10901736e-01f, -6.58849487e-03f, 7.42607843e-03f, 1.53699629e-02f, 1.02129309e-02f, 5.86342178e-02f,
  -1.92000363e-02f, -4.83218879e-02f, -1.23009063e-01f, -2.01793611e-02f, 1.90205634e-01f, 4.32379842e-02f, 1.06904870e-02f, -3.53501663e-02f, 4.90489826e-02f, -1.22110814e-01f,
  -1.14526659e-01f, 1.88250631e-01f, 1.21422425e-01f, -3.35018300e-02f, 1.06305949e-01f, -1.22037143e-01f, 9.71218944e-02f, 1.37035534e-01f, 1.35093033e-01f, -5.54898428e-03f,
  6.62096068e-02f, 5.01336195e-02f, 4.70248200e-02f, 1.59237966e-01f, 1.00144207e-01f, -4.22853641e-02f, -2.28667874e-02f, 1.39252990e-01f, -3.69334146e-02f, 1.20700300e-01f,
  4.84415628e-02f, 9.61605683e-02f, -2.64722794e-01f, -7.41287023e-02f, 3.94858420e-03f, 2.70005129e-02f, 5.06751873e-02f, -1.10132188e-01f, 1.60696626e-01f, 2.12541685e-01f,
  2.12005436e-01f, -5.36646992e-02f, 1.76294863e-01f, 2.29580224e-01f, -8.95108730e-02f, -1.52098690e-03f, -2.35610493e-02f, 2.04586640e-01f, 5.71698397e-02f, 8.19521472e-02f,
  -6.98284581e-02f, 3.66561934e-02f, 6.60439655e-02f, -1.01093270e-01f, 5.58032170e-02f, 6.70017451e-02f, -1.19112447e-01f, -9.87571031e-02f, 1.90411191e-02f, -1.44475922e-01f,
  6.87309131e-02f, 2.85329763e-02f, -7.83950314e-02f, 1.47132725e-01f, 1.07409693e-01f, 1.15226172e-01f, -5.82130253e-02f, -9.15617794e-02f, 4.68365438e-02f, 2.22134411e-01f,
  1.55813098e-01f, 2.54689366e-01f, -7.12940767e-02f, -1.49309576e-01f, 1.60339102e-02f, -1.78625882e-01f, 1.27683461e-01f, 3.01032305e-01f, 1.35368183e-01f, -6.58304021e-02f,
  3.61724235e-02f, 7.36311302e-02f, 1.45908669e-01f, 5.70537299e-02f, -1.10960065e-03f, 5.01095727e-02f, 3.80158462e-02f, 3.66685018e-02f, -8.08606520e-02f, -5.92442229e-02f,
  -1.92936912e-01f, 1.00427963e-01f, 1.04155608e-01f, 2.68338919e-01f, 1.32588550e-01f, -6.01547360e-02f, -1.11260869e-01f, 8.84852856e-02f, -8.08390528e-02f, 2.25272208e-01f,
  2.19433635e-01f, 7.16887936e-02f, -3.44013982e-02f, 6.51222467e-02f, 8.76649395e-02f, 1.33036450e-01f, -8.69172737e-02f, 2.24219099e-01f, 4.63402197e-02f, -9.73237120e-03f,
  2.95622796e-02f, -4.19600196e-02f, 5.85312082e-04f, -1.73273422e-02f, 2.06601378e-02f, -1.02911428e-01f, -1.13625638e-01f, 4.20338139e-02f, 1.85297150e-02f, -6.67409003e-02f,
  2.82466393e-02f, 5.02774268e-02f, -2.39670699e-04f, 1.74494699e-01f, 1.22943008e-02f, -8.68601203e-02f, 1.84864011e-02f, -3.52231860e-02f, -7.12783262e-02f, -2.29963288e-02f,
  1.07968068e-02f, 1.18335575e-01f, -1.14426285e-01f, -4.21364754e-02f, -1.23398174e-02f, 3.11487373e-02f, 1.50842369e-01f, -2.64703259e-02f, 1.23595692e-01f, 2.15176567e-01f,
  -7.84337968e-02f, -8.56835991e-02f, -2.03495830e-01f, 7.96082392e-02f, -1.19682886e-01f, 5.99861592e-02f, -3.12791541e-02f, 5.81490211e-02f, 2.44524777e-01f, -1.35870120e-02f,
  -2.14135125e-01f, -7.15539381e-02f, 3.11888993e-01f, -7.90748224e-02f, 1.63360283e-01f, 9.52432454e-02f, 1.45528987e-01f, 7.35708103e-02f, 1.53268874e-01f, 1.25481233e-01f,
  2.25092664e-01f, -1.60517812e-01f, 3.86429168e-02f, 9.26150605e-02f, 7.97318444e-02f, -4.76531498e-03f, -2.22229064e-02f, 1.32118106e-01f, 1.39045149e-01f, -5.63410446e-02f,
  -4.25060913e-02f, 7.72621930e-02f, 5.12052514e-02f, 4.14750585e-03f, 8.53176415e-03f, 7.23709241e-02f, 4.56463918e-03f, 5.35783824e-03f, 5.47718443e-02f, 3.39225819e-03f,
  4.86937538e-02f, 6.84918836e-02f, -6.08425885e-02f, 5.56559674e-02f, -2.47782301e-02f, -2.30593085e-02f, -4.17429470e-02f, 5.21643907e-02f, 5.50525151e-02f, -3.76171023e-02f,
  5.09431623e-02f, 1.77733779e-01f, 1.13915391e-02f, -4.00255024e-02f, -5.63663170e-02f, 1.52817369e-02f, -2.12303642e-02f, -4.42169346e-02f, 3.88391279e-02f, 1.24906957e-01f,
  3.59578952e-02f, -1.17726229e-01f, -1.23739123e-01f, 3.17328200e-02f, 1.56542540e-01f, 8.80530328e-02f, -6.36085272e-02f, -1.67302400e-01f, -1.93460484e-03f, -5.05676754e-02f,
  2.15489089e-01f, 4.03656997e-03f, 2.31570944e-01f, 5.20417616e-02f, 3.74176279e-02f, 6.58262894e-02f, 1.54744089e-02f, -1.03984021e-01f, -1.09382086e-01f, 1.54404297e-01f,
  1.45621300e-01f, 1.54513747e-01f, 8.98548588e-02f, -5.24709411e-02f, -2.59862661e-01f, -1.87218785e-02f, -2.64401454e-02f, 2.28468567e-01f, 2.14840588e-03f, 1.00776859e-01f,
  3.60958800e-02f, 5.90896979e-02f, 1.87344655e-01f, -9.71429888e-03f, -5.49845211e-02f, 8.59901905e-02f, -2.01401375e-02f, 2.93481648e-02f, 4.30658832e-02f, 2.77977418e-02f,
  4.26723026e-02f, -6.91814022e-03f, 1.07124582e-01f, 1.27172656e-02f, 6.92320019e-02f, 3.75480019e-02f, 1.06393702e-01f, 1.00227408e-01f, -6.34583309e-02f, -1.09754451e-01f,
  6.87065050e-02f, -1.50133789e-01f, -3.99256796e-02f, 1.59705669e-01f, -1.67781431e-02f, 7.19317719e-02f, -6.55386671e-02f, -4.59987065e-03f, -7.48818442e-02f, -1.36284381e-01f,
  3.54422420e-01f, 2.14936510e-02f, 7.72796124e-02f, 1.03983961e-01f, -1.29817218e-01f, 6.86519295e-02f, -8.21717978e-02f, -1.69518933e-01f, 2.09378466e-01f, 6.46624193e-02f,
  3.93283904e-01f, 2.68563554e-02f, 1.49738267e-01f, 7.27807060e-02f, 2.47780263e-01f, -2.12289598e-02f, -3.77461985e-02f, 2.46572733e-01f, 2.07346082e-01f, 1.56783998e-01f,
  -2.39244372e-01f, -1.54074878e-02f, -1.48045540e-01f, -3.82709987e-02f, -5.34483343e-02f, 4.61728349e-02f, 7.16420189e-02f, 9.42173041e-03f, -2.15567708e-01f, 1.42161012e-01f,
  8.32027122e-02f, 1.32563546e-01f, 1.23935044e-02f, 2.62840968e-02f, 1.69433013e-01f, 1.19963378e-01f, -5.41414600e-03f, 1.69972837e-01f, 8.83318931e-02f, 1.35159910e-01f,
  -2.76474245e-02f, 9.10264701e-02f, 7.67946541e-02f, 3.12363897e-02f, 3.02327722e-02f, 2.42358632e-02f, 1.36861727e-01f, -4.36116606e-02f, 4.90800664e-02f, 6.47935420e-02f,
  8.94544348e-02f, 6.43782392e-02f, -1.03226729e-01f, -3.83893363e-02f, 8.34904239e-02f, -2.44006768e-01f, -1.38209164e-01f, 1.22168534e-01f, 1.33128790e-02f, -1.13271676e-01f,
  8.42525363e-02f, 1.15276929e-02f, -9.03310925e-02f, -3.05120703e-02f, 1.72417641e-01f, 1.35947511e-01f, 3.28935124e-02f, -1.98490359e-02f, 6.22884184e-02f, 2.10527688e-01f,
  -8.49610269e-02f, -5.11767566e-02f, 3.13271396e-02f, 1.11950748e-01f, 2.18705386e-01f, 1.40250981e-01f, 2.07577884e-01f, 9.90691334e-02f, 6.37359098e-02f, 1.03897065e-01f,
  -1.01692140e-01f, 1.13359600e-01f, 1.04696706e-01f, -8.67190864e-03f, -3.54528815e-01f, -9.74532403e-03f, 4.31030653e-02f, 8.78104419e-02f, -2.08302796e-01f, 2.54057199e-02f,
  -1.09358191e-01f, -1.09786838e-01f, -4.06714603e-02f, 3.66074815e-02f, -4.39935550e-02f, -1.40346706e-01f, -3.73977497e-02f, -1.54926583e-01f, 2.98226804e-01f, -7.15427333e-03f,
  -1.64448574e-01f, 1.92783311e-01f, 2.47180790e-01f, -7.45206513e-03f, 1.14308046e-02f, -4.09849696e-02f, -2.82711331e-02f, -4.49747741e-02f, -1.69745013e-01f, -1.30152807e-03f,
  -8.04610029e-02f, -4.93107885e-02f, -6.72492012e-02f, -2.18033008e-02f, -4.09379937e-02f, -1.43163353e-01f, 6.02841042e-02f, 1.44761603e-03f, -9.18411762e-02f, -1.51784182e-01f,
  -1.15745567e-01f, 1.07439496e-01f, -1.16330013e-02f, -2.01462340e-02f, -1.12334654e-01f, -8.25325698e-02f, 2.44839303e-02f, -7.63454195e-03f, 1.45188674e-01f, -3.26122016e-01f,
  2.12470457e-01f, -8.91909450e-02f, 1.20852962e-01f, 3.67794186e-01f, 1.95177481e-01f, 3.94675098e-02f, 1.51516348e-01f, -6.37212023e-02f, 1.62677675e-01f, 1.85841992e-01f,
  -5.51485270e-02f, 1.40355498e-01f, -6.95368871e-02f, 5.39358035e-02f, -6.97897300e-02f, 1.14183009e-01f, 3.97844836e-02f, 5.64112402e-02f, -1.68382049e-01f, -1.83147360e-02f,
  1.47964835e-01f, -1.05239404e-02f, -3.78680006e-02f, -1.11199431e-01f, -1.25501111e-01f, 1.03687622e-01f, 1.44867152e-01f, 1.44784093e-01f, 2.66545147e-01f, -2.74641346e-02f,
  -6.07461184e-02f, -1.11900307e-01f, 1.80954710e-01f, -4.78598103e-02f, -3.99770662e-02f, 4.71265763e-02f, 1.45514682e-01f, -4.96441014e-02f, -3.29010263e-02f, -9.55807939e-02f,
  -1.00652628e-01f, -5.55807985e-02f, -7.29716644e-02f, -4.09426913e-03f, -1.51587322e-01f, -6.84966668e-02f, -6.31397963e-02f, -6.20440766e-02f, 1.09766740e-02f, -1.45778200e-02f,
  3.08464244e-02f, 3.31789404e-02f, -1.13860302e-01f, -5.66639081e-02f, -7.49080926e-02f, 6.24893717e-02f, -3.11422385e-02f, 2.50527319e-02f, -1.03823386e-01f, -1.17853591e-02f,
  3.32098082e-02f, -8.12298432e-02f, 1.28505290e-01f, -1.70338392e-01f, 1.36691824e-01f, -3.85185927e-02f, -9.15442407e-03f, -1.85503662e-02f, -8.28289092e-02f, 7.69006237e-02f,
  1.13407403e-01f, -1.04543623e-02f, 4.37285528e-02f, -2.03534186e-01f, -7.95332417e-02f, 1.35498866e-01f, 1.28144562e-01f, -1.74170539e-01f, 8.80778879e-02f, -7.76500627e-02f,
  -4.12801020e-02f, 2.20511556e-02f, -7.30490535e-02f, -1.88101858e-01f, -1.20511994e-01f, 5.68203107e-02f, -6.37280867e-02f, 5.09674735e-02f, -1.22235883e-02f, 1.87512711e-02f,
  1.53447445e-02f, -1.37095172e-02f, 1.05001874e-01f, 3.80787812e-02f, -8.75529572e-02f, -1.42236486e-01f, -3.11543513e-02f, 1.39564812e-01f, 1.09507114e-01f, -5.51490486e-02f,
  2.28093043e-02f, 3.87592316e-02f, 1.07223950e-02f, 7.81858489e-02f, 1.32906158e-02f, -1.16572892e-02f, 1.28230050e-01f, 7.11923977e-03f, 7.45822266e-02f, -2.82241963e-02f,
  1.16217211e-01f, -1.26538295e-02f, 4.09362167e-02f, 6.75188377e-02f, -2.64281761e-02f, -4.51510772e-02f, -1.57153197e-02f, 7.18167331e-03f, -5.73314987e-02f, -2.35518869e-02f,
  8.94265622e-03f, -1.89485520e-01f, 1.25854522e-01f, 4.27249260e-02f, -3.92764471e-02f, 2.00381242e-02f, -6.53025433e-02f, 2.39768505e-01f, -9.71963629e-02f, -1.63266465e-01f,
  1.47163719e-01f, -4.40709945e-03f, -4.29386785e-03f, 5.15777469e-02f, -1.54506534e-01f, 1.39291761e-02f, -7.43590295e-02f, 1.60420015e-01f, 2.18899682e-01f, -5.95649704e-02f,
  1.25914402e-02f, 2.06530690e-01f, 4.93837940e-03f, -1.06417820e-01f, 2.96012312e-02f, -5.25294896e-03f, 1.20991431e-01f, 1.27138227e-01f, 2.33962253e-01f, 7.14164600e-02f,
  -9.71361250e-02f, -2.32960079e-02f, -1.02499478e-01f, -5.06160557e-02f, 1.37966484e-01f, -4.26191557e-03f, -8.87567475e-02f, -2.37481609e-01f, 2.05288589e-01f, 5.29440679e-02f,
  8.48181546e-02f, 2.86945887e-02f, -3.19524482e-02f, 4.94958200e-02f, 2.01562658e-01f, -1.22459084e-02f, 2.98411073e-03f, 3.00932652e-03f, 1.58304330e-02f, 2.77963490e-03f,
  -2.07711924e-02f, -1.37245711e-02f, 1.74667370e-02f, -7.97015876e-02f, -1.91176124e-02f, 2.16652127e-03f, 5.40712923e-02f, 5.65553457e-02f, -4.16391790e-02f, -5.91944195e-02f,
  1.08051775e-02f, -9.25418660e-02f, -6.41812906e-02f, 7.90143609e-02f, 2.34701764e-02f, 2.74975784e-02f, -3.60151418e-02f, -1.15663530e-02f, -4.85940278e-02f, -6.76378310e-02f,
  1.72253057e-01f, -5.55499680e-02f, 4.87348177e-02f, -3.55485268e-02f, 5.08788675e-02f, 1.15226641e-01f, -8.06315690e-02f, -1.15477396e-02f, 5.41425608e-02f, -3.66338827e-02f,
  1.36744246e-01f, -7.90222958e-02f, 7.09525868e-02f, 1.05770633e-01f, 1.18635193e-01f, 4.52835520e-04f, -3.57527705e-03f, 9.80349109e-02f, 8.23342353e-02f, 6.05311319e-02f,
  -1.39313743e-01f, -7.27720410e-02f, 1.92733277e-02f, 1.02191195e-01f, -1.10085651e-01f, -1.01263583e-01f, -6.41267225e-02f, -2.44031334e-03f, -2.42849030e-02f, -4.77129072e-02f,
  4.36055660e-02f, 4.26302589e-02f, -5.46778589e-02f, 3.54575831e-03f, 1.76647797e-01f, 1.77673891e-01f, -9.40142479e-03f, 9.93680283e-02f, 9.96782854e-02f, 1.30704254e-01f,
  -1.86050963e-02f, 5.46175167e-02f, 6.86857477e-02f, 7.09008202e-02f, 8.31306726e-02f, 3.51729803e-02f, 1.03157915e-01f, 1.30871562e-02f, -1.96829382e-02f, 7.42221028e-02f,
  4.35118228e-02f, -1.19376011e-01f, 8.94061849e-03f, 5.13429902e-02f, -2.35095825e-02f, -3.48086432e-02f, -2.72332393e-02f, -2.17625946e-02f, -3.74756716e-02f, -1.70139045e-01f,
  1.64721206e-01f, 4.93170023e-02f, -3.87514047e-02f, 1.26635909e-01f, -2.21716061e-01f, 2.39873588e-01f, -1.02296926e-01f, 9.17337984e-02f, 3.62509452e-02f, 2.24987064e-02f,
  3.53045128e-02f, 9.43803787e-02f, -1.82558104e-01f, 1.45325080e-01f, -1.90702111e-01f, 2.41158381e-02f, -1.62392501e-02f, -4.02398407e-02f, -1.58892825e-01f, 2.02019215e-01f,
  2.13977247e-02f, -9.53786150e-02f, -6.17975108e-02f, -1.88275322e-01f, 1.04956970e-01f, -2.28119623e-02f, 2.09804296e-01f, 8.90679583e-02f, -6.89953938e-02f, 1.18319327e-02f,
  6.41192347e-02f, -1.89458877e-01f, 1.52465478e-01f, -2.18742147e-01f, -1.16129950e-01f, -1.27967104e-01f, 1.86133221e-01f, -7.14141726e-02f, 1.56924754e-01f, -6.26036003e-02f,
  -6.60496205e-02f, 1.05766617e-01f, 9.87468138e-02f, 6.21010847e-02f, -4.74093668e-02f, -1.02592539e-02f, -1.07087018e-02f, 2.65088081e-02f, 5.35794497e-02f, 3.85263786e-02f,
  6.42685918e-03f, -3.77205876e-03f, 2.51032342e-03f, -4.74742167e-02f, 9.10080820e-02f, -3.58922104e-03f, -5.80492094e-02f, 3.31083052e-02f, 4.47537191e-02f, 9.39176884e-03f,
  -4.23882948e-03f, -5.26175043e-03f, -1.39547745e-02f, -6.30934760e-02f, -6.20362796e-02f, 1.40453456e-02f, 7.35146180e-02f, -8.04175064e-03f, 6.82181567e-02f, -2.11200323e-02f,
  -8.73863057e-04f, -9.19696968e-03f, -6.87774420e-02f, 5.66457063e-02f, 1.96355090e-01f, -1.15327127e-01f, -4.85440306e-02f, -4.15729685e-03f, -3.79303135e-02f, 1.51615381e-01f,
  9.07415152e-02f, 4.28649038e-02f, -6.50129542e-02f, 5.27337901e-02f, -8.34488124e-02f, 1.19754516e-01f, 6.05625696e-02f, 6.83335960e-02f, 1.28130587e-02f, 1.72384739e-01f,
  1.32394612e-01f, -1.62037984e-01f, -1.60941128e-02f, -9.03470516e-02f, -1.46994829e-01f, 1.84694156e-01f, 2.36657113e-01f, 1.94917709e-01f, 3.40249687e-02f, -1.24253675e-01f,
  3.03135179e-02f, 1.43904030e-01f, -1.07069530e-01f, -9.27536190e-02f, -1.54007405e-01f, 8.29286501e-02f, 6.56933431e-03f, -1.71173841e-01f, 4.46524844e-02f, 5.86821558e-03f,
  3.04019991e-02f, -4.84507568e-02f, -8.66203606e-02f, -4.93943132e-02f, 3.16132084e-02f, 2.89546661e-02f, -6.43865839e-02f, 2.10850779e-02f, -5.10000624e-02f, -6.72842469e-03f,
  5.57583980e-02f, -3.62189719e-03f, -5.74985817e-02f, -4.76917252e-02f, -7.27102757e-02f, 6.09043762e-02f, 4.73736450e-02f, 3.22249047e-02f, -7.76232183e-02f, -3.28095891e-02f,
  -3.58776115e-02f, -3.71562801e-02f, 1.29981056e-01f, -1.53273121e-01f, 1.10113220e-02f, -9.40585136e-03f, 1.60310596e-01f, 1.35113582e-01f, -3.31320576e-02f, 1.68887481e-01f,
  6.93429038e-02f, -1.39501020e-01f, 1.10464051e-01f, -5.21871634e-03f, -8.73318873e-03f, 1.04247376e-01f, 9.70812067e-02f, 4.04188670e-02f, 1.37321860e-01f, 6.93666860e-02f,
  -1.05301045e-01f, -4.31939028e-03f, -8.07246640e-02f, -1.43202096e-01f, -4.23197169e-03f, 1.70294881e-01f, 3.72127220e-02f, -6.93779886e-02f, -2.28315797e-02f, 4.86427024e-02f,
  1.25714513e-02f, -7.62668438e-03f, 9.67784971e-02f, 3.86047103e-02f, -1.90695107e-01f, -1.48335963e-01f, 1.70893326e-01f, 2.29696378e-01f, 5.68298325e-02f, -1.76722985e-02f,
  1.93798736e-01f, 9.25574899e-02f, -4.03748862e-02f, 5.64626306e-02f, 5.58267832e-02f, 2.76875626e-02f, 6.77888915e-02f, -8.19024723e-03f, 4.30343114e-02f, -3.93809658e-03f,
  4.74073775e-02f, 2.31567509e-02f, 5.37072048e-02f, 1.11029044e-01f, -3.50183360e-02f, 9.15063359e-03f, -1.32344291e-02f, -1.31569758e-01f, -5.60170487e-02f, 5.08370921e-02f,
  2.71594226e-02f, -3.87561470e-02f, 2.93622036e-02f, -2.82571036e-02f, -8.48827660e-02f, -3.26296911e-02f, 5.22225834e-02f, 1.43112108e-01f, -3.92382704e-02f, 4.66259429e-03f,
  8.57678056e-02f, 2.55265497e-02f, -5.00762612e-02f, -3.27134132e-02f, 1.78246722e-02f, -2.14637648e-02f, 1.61681846e-01f, 2.76212003e-02f, 9.00186747e-02f, 7.31780306e-02f,
  2.66935094e-03f, 2.21106485e-02f, 6.44900575e-02f, -1.46468431e-02f, 6.10993132e-02f, -2.27083713e-02f, -2.66208034e-02f, -8.99011418e-02f, 8.83141905e-02f, 1.35132656e-01f,
  -7.78517649e-02f, 3.24032791e-02f, -3.46011221e-02f, -5.25718406e-02f, -4.85742912e-02f, -5.88883758e-02f, -2.92875133e-02f, -1.12883911e-01f, -7.51459152e-02f, -1.70442685e-02f,
  1.62120432e-01f, 1.71597987e-01f, 7.94501826e-02f, 5.72463162e-02f, 1.94816634e-01f, 1.46972165e-01f, -4.85922582e-02f, -1.23583242e-01f, -7.92717189e-02f, -4.92147505e-02f,
  2.93111298e-02f, -3.09639312e-02f, -6.78058341e-02f, 4.55293767e-02f, 4.31803651e-02f, -6.19736835e-02f, 4.02543545e-02f, -3.96693125e-02f, -1.06638791e-02f, 8.47329013e-03f,
  -2.01842864e-03f, 2.89348159e-02f, 2.84909941e-02f, 3.80274616e-02f, -9.23638046e-02f, 4.15916275e-03f, -1.37614295e-01f, 4.40019667e-02f, 1.85945660e-01f, -6.49598762e-02f,
  1.33778483e-01f, -2.61698335e-01f, -3.73289436e-02f, -5.05969189e-02f, -1.46118328e-01f, 6.50141761e-02f, 1.02262259e-01f, -3.79182771e-02f, 3.47517170e-02f, -6.32788688e-02f,
  1.09932758e-02f, 1.37805864e-01f, -3.76447104e-02f, -4.70710695e-02f, -6.10716408e-03f, 8.38567689e-02f, -1.70810491e-01f, 2.31060721e-02f, 1.03451855e-01f, 7.85304606e-02f,
  6.95808679e-02f, 7.40996450e-02f, 1.22735728e-04f, -3.18436414e-01f, 3.60881053e-02f, -7.20734596e-02f, -1.30785123e-01f, 2.10009366e-01f, 1.16856858e-01f, 2.56000549e-01f,
  1.11886524e-01f, 6.93548238e-03f, -7.10226670e-02f, 1.54483929e-01f, -2.72736043e-01f, -1.46373212e-01f, -6.26655295e-02f, -3.77687216e-02f, -1.19706206e-01f, -3.18316638e-01f,
  -6.91441968e-02f, -2.72108074e-02f, -3.41527984e-02f, 7.54245371e-02f, -3.74890789e-02f, 5.35111055e-02f, -8.25925265e-03f, 1.12536147e-01f, -5.38753234e-02f, -4.08034846e-02f,
  1.26740197e-03f, -8.79334733e-02f, -4.33080830e-03f, 1.02623913e-03f, 8.31592903e-02f, -1.05120711e-01f, 6.70342296e-02f, 2.70243138e-02f, -1.08648591e-01f, 3.91352437e-02f,
  1.43426526e-02f, 7.28393346e-02f, 1.16207041e-01f, -6.36163652e-02f, 5.86239770e-02f, 1.00358434e-01f, 8.14027116e-02f, 1.00540273e-01f, -1.77550912e-01f, 2.88295094e-02f,
  3.18051726e-02f, -1.60646915e-01f, 1.05844937e-01f, 1.40034959e-01f, 9.12595466e-02f, -9.04739723e-02f, -1.33640850e-02f, -3.16683017e-02f, 5.35939634e-02f, 1.90897379e-02f,
  -1.68687358e-01f, 2.93069240e-02f, 1.66179866e-01f, 6.88654110e-02f, -3.54164839e-02f, 1.54159263e-01f, -1.61748901e-01f, -2.15788215e-01f, 1.37991980e-01f, 1.26183033e-01f,
  -6.52187988e-02f, 1.04225218e-01f, -1.38975799e-01f, 1.86271176e-01f, 2.84417197e-02f, 1.96475573e-02f, 1.29013062e-02f, -2.51161586e-02f, -1.40899897e-01f, -2.86558032e-01f,
  -5.24306819e-02f, -2.08994299e-02f, -4.45487909e-02f, -6.76321462e-02f, 4.27766442e-02f, 9.08411574e-03f, -1.04034692e-01f, -5.48456237e-02f, -2.06731707e-02f, -7.76167288e-02f,
  -1.06170118e-01f, -3.63638848e-02f, -7.18481094e-02f, -9.42377672e-02f, 6.01043031e-02f, -2.02467684e-02f, 1.50761392e-03f, 9.42356959e-02f, -3.41443047e-02f, -3.75400931e-02f,
  -2.33458262e-02f, 7.61602819e-02f, -6.32676110e-02f, 1.45411864e-01f, 3.37860584e-02f, -2.57794671e-02f, 2.54409965e-02f, 1.37285795e-02f, 9.50816460e-03f, -6.50665583e-03f,
  4.22637701e-01f, 1.22244328e-01f, -1.74352154e-01f, -2.46848073e-02f, -1.03322797e-01f, -1.43274304e-03f, 1.68632627e-01f, 2.10462555e-01f, 6.73078047e-03f, -3.16045672e-01f,
  -2.16083378e-01f, 1.56569153e-01f, 4.00070362e-02f, -5.16240671e-02f, 1.76334247e-01f, -1.76700607e-01f, 7.31848627e-02f, -1.14905752e-01f, -6.54060543e-02f, -1.18827872e-01f,
  -3.25351655e-01f, 1.35953307e-01f, 8.88406858e-02f, 1.89188302e-01f, 1.46728292e-01f, -1.92308977e-01f, -1.92913234e-01f, -1.24489643e-01f, 4.66763750e-02f, 1.69957384e-01f,
  6.60990700e-02f, -1.02134869e-01f, 8.14806484e-03f, -1.15369558e-01f, 1.06539428e-01f, 1.65354639e-01f, -7.97905028e-02f, 1.69542179e-01f, 1.51308654e-02f, -2.37038545e-02f,
  -2.59803776e-02f, -9.44965482e-02f, -1.10072300e-01f, 8.41934513e-03f, -6.71189949e-02f, 1.61414668e-02f, -5.61714135e-02f, -6.03476651e-02f, -7.76526630e-02f, -4.52443920e-02f,
  1.29611731e-01f, 1.75426885e-01f, -1.70306742e-01f, -3.33078988e-02f, -5.31011671e-02f, 1.95416566e-02f, 1.22150360e-02f, -5.54993153e-02f, 7.03116730e-02f, -3.97575311e-02f,
  -6.35091169e-03f, 7.92446956e-02f, -1.35156050e-01f, -2.38585491e-02f, 6.54609501e-02f, -9.32143778e-02f, 9.10985395e-02f, 1.03793651e-01f, -1.06158048e-01f, 2.64618397e-01f,
  -8.64721611e-02f, -1.18910730e-01f, -8.10237825e-02f, 2.46649422e-02f, -1.53586254e-01f, 9.27772466e-03f, -1.09653443e-01f, -1.11728776e-02f, 1.61261648e-01f, -1.02779314e-01f,
  -3.06901783e-01f, -1.61630750e-01f, 5.24604321e-02f, -1.53282076e-01f, 1.50052235e-01f, 1.58904478e-01f, -1.69092059e-01f, -1.00080743e-02f, 3.11716422e-02f, -9.22558159e-02f,
  -1.17566269e-02f, -1.60615683e-01f, 9.55647044e-03f, -4.15695570e-02f, -4.90167476e-02f, -2.56108284e-01f, 1.38852552e-01f, 7.28490800e-02f, -5.11505492e-02f, -2.38425136e-01f,
  1.89779833e-01f, 8.72122198e-02f, -6.52565360e-02f, -3.76472622e-02f, -8.46747980e-02f, -2.42799092e-02f, 3.77349816e-02f, 2.13282425e-02f, -7.74323270e-02f, 3.11221778e-02f,
  5.69566116e-02f, -9.70675945e-02f, 8.13349932e-02f, -4.10749204e-02f, -6.68577999e-02f, 1.60048101e-02f, 5.54406233e-02f, -7.74611309e-02f, -5.01735881e-03f, 5.70131727e-02f,
  -1.16215482e-01f, -8.97035822e-02f, -5.76173291e-02f, 3.42131406e-02f, 1.53045624e-01f, -1.17452115e-01f, 1.84062392e-01f, -9.76480544e-03f, 3.68973985e-02f, 3.56435962e-03f,
  -1.19360805e-01f, -2.01316681e-02f, 1.68147877e-01f, -1.67169094e-01f, 1.77113432e-02f, 2.74014324e-02f, 1.18022151e-01f, 7.13324994e-02f, 1.27454519e-01f, 5.46807162e-02f,
  -2.88481005e-02f, 1.58375576e-01f, -1.17734171e-01f, 3.64711396e-02f, 2.56201118e-01f, 5.25743850e-02f, -9.01911035e-02f, 1.18220992e-01f, 5.32264598e-02f, -2.92547524e-01f,
  -4.66171391e-02f, -9.52796042e-02f, -1.83309317e-01f, 2.31229767e-01f, 1.30548671e-01f, 2.43835345e-01f, 5.46403639e-02f, -9.74241197e-02f, 1.28247291e-01f, 1.91410556e-01f,
  -1.99669152e-01f, -1.71592370e-01f, -1.49226561e-01f, 6.72815591e-02f, -4.85069640e-02f, -2.63608694e-01f, 2.98134796e-02f, -5.58325127e-02f, -7.98268989e-02f, -6.94749728e-02f,
  -1.05003558e-01f, -5.46473451e-02f, -1.01994410e-01f, 4.98979772e-03f, -6.91030398e-02f, -4.98480685e-02f, -5.12806438e-02f, -2.77243694e-03f, 4.71056625e-02f, -1.06732761e-02f,
  -1.16605848e-01f, -3.47321294e-02f, -2.28078514e-02f, 5.07888310e-02f, -6.22487348e-03f, 5.75338714e-02f, -1.21458583e-01f, -3.48968729e-02f, -3.42354598e-03f, -7.98967108e-02f,
  1.38675183e-01f, -2.16484010e-01f, 7.24631697e-02f, -3.55760045e-02f, 6.59099296e-02f, 1.38916355e-02f, -8.71304274e-02f, 1.36421129e-01f, 1.44201174e-01f, -9.76070017e-02f,
  9.53579396e-02f, -1.56199917e-01f, 1.63533036e-02f, 1.13608226e-01f, 3.66405509e-02f, -1.00482650e-01f, 8.75819921e-02f, -8.44993908e-03f, -9.22538489e-02f, 1.48775512e-02f,
  -2.38082092e-02f, -1.67030483e-01f, -9.93862152e-02f, 1.49251670e-01f, 9.28727072e-03f, -4.55055833e-02f, 6.42606616e-02f, 9.15993452e-02f, -8.41695294e-02f, 5.29922433e-02f,
  1.42225280e-01f, 1.03698187e-01f, -2.05013096e-01f, -1.07435517e-01f, 8.43295529e-02f, 1.80568188e-01f, 1.45860106e-01f, -5.70489019e-02f, 4.01261374e-02f, 9.63349789e-02f,
  -7.17377886e-02f, 9.78381261e-02f, 9.14498642e-02f, 6.22145049e-02f, 7.31915236e-02f, -4.54168096e-02f, 7.85999000e-02f, 1.40834162e-02f, -6.26325794e-03f, 8.46669003e-02f,
  8.66277367e-02f, 5.92093877e-02f, -1.41946673e-01f, -7.22976476e-02f, 1.39785662e-01f, 7.15468973e-02f, 2.09441766e-01f, -1.34845614e-01f, -6.32054433e-02f, -9.68277752e-02f,
  6.02837689e-02f, 3.05735786e-02f, 9.21894312e-02f, 2.83541288e-02f, -2.56854147e-02f, 1.31708339e-01f, -2.36351594e-01f, 1.26512453e-01f, -1.80346563e-01f, -2.61625081e-01f,
  1.47179917e-01f, -1.55119061e-01f, -2.00569700e-03f, 1.20041050e-01f, -1.23998217e-01f, 1.40709519e-01f, 1.57483608e-01f, -7.43464231e-02f, 1.38300300e-01f, 1.56796090e-02f,
  2.84213591e-02f, -5.92583455e-02f, 1.61218181e-01f, 4.16353568e-02f, 1.74893722e-01f, 1.96483150e-01f, -1.63276289e-02f, -1.41508564e-01f, 2.31622189e-01f, 1.71183094e-01f,
  1.79837719e-01f, 4.61402237e-02f, 3.03582363e-02f, 1.74363435e-03f, -4.82525192e-02f, 6.96582645e-02f, 2.44563267e-01f, 2.36647844e-01f, -1.27590552e-01f, 4.71479297e-02f,
  8.57256949e-02f, 1.86238423e-01f, -7.95690939e-02f, -1.11981165e-02f, -7.93463737e-02f, 1.95381772e-02f, -1.50092961e-02f, 1.61331192e-01f, -5.75352982e-02f, 4.31306064e-02f,
  1.42472666e-02f, 4.24148180e-02f, -7.11706728e-02f, 2.54311915e-02f, 2.24749334e-02f, -7.91455209e-02f, 2.81117279e-02f, -9.03147757e-02f, 6.33003265e-02f, 1.22794345e-01f,
  1.52754575e-01f, -1.16421662e-01f, -6.50237650e-02f, 6.41935840e-02f, 1.45903341e-02f, 5.36448061e-02f, 5.53002432e-02f, 3.37410234e-02f, -2.95612705e-03f, 6.02378994e-02f,
  -6.13798909e-02f, 1.83618531e-01f, -1.21126458e-01f, -2.08945826e-01f, 1.72890037e-01f, -9.32426602e-02f, 7.78437704e-02f, 7.93300644e-02f, -1.14550330e-01f, -3.32811363e-02f,
  -4.54476802e-03f, -7.32870027e-02f, 1.32185863e-02f, 1.22890912e-01f, 1.81190908e-01f, -1.43206865e-01f, -3.36994231e-02f, 1.02126040e-01f, 2.07593143e-01f, 6.52536973e-02f,
  -5.92128895e-02f, -1.75557047e-01f, 1.66108698e-01f, 2.23598897e-01f, 2.52797574e-01f, 2.80449502e-02f, 8.91879871e-02f, 5.47614098e-02f, -1.96524449e-02f, 2.75779009e-01f,
  6.36527166e-02f, 2.05905840e-01f, -2.72031307e-01f, -5.62886819e-02f, 1.05687082e-01f, 2.58107986e-02f, -2.99098015e-01f, -7.78676346e-02f, 5.94794424e-03f, -9.63076353e-02f,
  -3.91639061e-02f, 4.06580083e-02f, -6.22785501e-02f, 2.99495999e-02f, -6.50059134e-02f, 8.77221301e-02f, 8.65531713e-02f, -3.32635902e-02f, -9.61485878e-02f, 6.42951652e-02f,
  5.02397828e-02f, -9.25129279e-03f, -8.38290974e-02f, 1.70687571e-01f, 4.72312197e-02f, -6.32591173e-02f, 7.68179297e-02f, 4.73700501e-02f, -1.36072755e-01f, -2.81259008e-02f,
  3.96245047e-02f, -8.80965963e-02f, 7.06058666e-02f, -2.07665414e-01f, -1.84531748e-01f, -9.40043405e-02f, 6.61806464e-02f, -1.43727094e-01f, 1.53482482e-01f, 1.60712510e-01f,
  1.29683446e-02f, -2.19504967e-01f, -2.67110225e-02f, 2.84161121e-02f, 5.97491004e-02f, -5.36128990e-02f, 1.85761265e-02f, -7.76732415e-02f, 7.84226581e-02f, 7.53564909e-02f,
  -1.18912905e-01f, 1.89584881e-01f, 3.50055277e-01f, 1.86356843e-01f, -1.98679678e-02f, 1.37016863e-01f, 1.93877384e-01f, 5.52328192e-02f, 1.50698677e-01f, 3.27555627e-01f,
  -4.92902435e-02f, 1.04194924e-01f, 1.23131998e-01f, 7.09238574e-02f, -3.87459695e-02f, -1.34850061e-02f, -1.53196499e-01f, 2.87560284e-01f, 9.73364487e-02f, -2.23408267e-01f,
  -3.16718295e-02f, 2.59253923e-02f, 4.74101789e-02f, -1.08588442e-01f, 6.55418411e-02f, -5.33609930e-03f, -5.82480840e-02f, -6.57081278e-03f, -2.35523395e-02f, -1.49127329e-02f,
  4.01540063e-02f, 2.49539837e-02f, -4.16957065e-02f, 1.36168990e-02f, 2.19817068e-02f, -1.56125620e-01f, 8.16761237e-03f, -5.58066182e-04f, 1.21009406e-02f, 6.77162679e-05f,
  1.08020008e-01f, 1.13848351e-01f, -1.93557814e-01f, -7.21964240e-02f, 6.18099682e-02f, -5.32532372e-02f, 1.25207290e-01f, -2.55817026e-01f, -1.65055752e-01f, -1.18036143e-01f,
  8.60539824e-02f, 1.60844654e-01f, 2.32548401e-01f, 2.29694974e-02f, 1.41491592e-01f, -1.21632755e-01f, 4.84336652e-02f, 2.25534081e-01f, 4.31055166e-02f, -1.24850981e-01f,
  -5.56003209e-03f, 5.77163696e-02f, 4.97632362e-02f, 2.79271156e-01f, -4.77277972e-02f, 1.16246387e-01f, 5.65643460e-02f, 2.03959391e-01f, 1.38248533e-01f, -3.56285344e-03f,
  1.70192480e-01f, -1.10451661e-01f, -8.64828825e-02f, 2.09497616e-01f, 1.09133884e-01f, 2.38953888e-01f, 1.34241849e-01f, 7.96003118e-02f, -1.86709359e-01f, 2.26123080e-01f,
  4.17116210e-02f, 4.67619970e-02f, 1.63665824e-02f, -9.30268783e-03f, -7.10413326e-03f, -9.45660993e-02f, -3.05360015e-02f, -2.01921761e-02f, 7.25808069e-02f, 2.81438846e-02f,
  4.84773591e-02f, 2.84600481e-02f, 8.03397521e-02f, -2.01952048e-02f, 5.42620234e-02f, 5.37873954e-02f, 8.31075460e-02f, 1.15402386e-01f, -3.05981562e-02f, -1.20799646e-01f,
  6.30687848e-02f, -1.73319086e-01f, -8.13262686e-02f, 6.38603494e-02f, -5.38633787e-04f, -7.45193064e-02f, 1.01844110e-01f, 6.90272525e-02f, -5.41201122e-02f, -6.00681035e-03f,
  2.56516319e-02f, 1.49400547e-01f, -1.37277124e-02f, 1.02838613e-02f, 8.42892006e-02f, 1.87614113e-01f, 6.35445060e-04f, -1.23145618e-01f, -8.53859857e-02f, -2.02207058e-03f,
  1.77559733e-01f, 1.86575830e-01f, 6.66777566e-02f, -6.88027311e-03f, -1.35347933e-01f, 1.56270787e-01f, -9.45577696e-02f, 7.74819627e-02f, 1.17517725e-01f, -2.38501187e-02f,
  -1.81145042e-01f, 7.43109211e-02f, 1.98875472e-01f, -1.46500561e-02f, -1.29653960e-01f, 4.88745086e-02f, -1.32885590e-01f, -4.89555001e-02f, 9.01364461e-02f, -5.29586971e-02f,
  -6.55878782e-02f, -1.71909899e-01f, 1.60433546e-01f, -5.40143326e-02f, 1.19903482e-01f, -1.82477802e-01f, -2.12052539e-01f, 1.45516887e-01f, 1.76260307e-01f, -4.12885174e-02f,
  1.62795521e-02f, -2.13900506e-02f, 6.20125234e-03f, -7.74819180e-02f, -1.74899418e-02f, -9.69943330e-02f, -4.70293574e-02f, -7.07926452e-02f, -7.91458115e-02f, 2.10159924e-02f,
  -4.54370305e-02f, -1.73003018e-01f, 4.31506559e-02f, 9.77331027e-02f, -6.74620867e-02f, 2.51595646e-01f, 3.67492102e-02f, -1.31535396e-01f, 1.24819875e-02f, -1.08703457e-01f,
  1.73441190e-02f, -8.38964581e-02f, 3.57308164e-02f, 1.88523829e-01f, -3.09671968e-01f, -4.29896675e-02f, -4.64179590e-02f, 8.25538561e-02f, 9.94954407e-02f, -9.30690616e-02f,
  2.40788147e-01f, 1.57271802e-01f, -1.61026433e-01f, 3.80621478e-02f, -4.16334480e-01f, 1.26570329e-01f, -1.60268649e-01f, 1.56934466e-02f, -5.55969514e-02f, 3.11880428e-02f,
  1.86400220e-01f, -9.09057334e-02f, -7.65529945e-02f, -7.58575350e-02f, 1.96262464e-01f, -3.03666499e-02f, 7.74535164e-02f, 7.19033927e-02f, 4.69346270e-02f, 8.06946754e-02f,
  1.84366107e-01f, 7.20409378e-02f, 2.53389537e-01f, -1.03647649e-01f, -7.95386080e-03f, -3.14624645e-02f, 4.30032611e-02f, 1.17605343e-01f, -8.91844705e-02f, 2.45454572e-02f,
  1.74597763e-02f, -1.17010705e-01f, 5.61165670e-03f, -2.36225221e-02f, 7.65629932e-02f, 5.38767176e-03f, -1.06513947e-02f, -5.60750514e-02f, 3.97828631e-02f, -2.17247289e-02f,
  -1.96259115e-02f, 4.99032624e-02f, 3.39456275e-02f, 6.24348484e-02f, -9.90593061e-03f, 9.95482504e-02f, 2.39376109e-02f, -3.53591591e-02f, -4.26222198e-02f, 1.02383606e-01f,
  -1.58937182e-02f, -8.76726676e-03f, 3.79247665e-02f, 6.07345346e-03f, -1.00486524e-01f, -5.93339913e-02f, -1.71634797e-02f, -6.60596117e-02f, 4.06491272e-02f, -1.48946911e-01f,
  -1.52216926e-01f, -1.44622207e-01f, 9.83279943e-02f, -8.82701427e-02f, -9.23952088e-03f, 2.12952316e-01f, 4.03975770e-02f, -1.56802028e-01f, -6.15297705e-02f, -2.88744736e-02f,
  3.64978388e-02f, -1.80926472e-02f, 1.73230588e-01f, 7.35155167e-03f, 2.37596542e-01f, 9.22577530e-02f, -7.52801225e-02f, 1.89857915e-01f, 2.91294843e-01f, -1.91836394e-02f,
  4.67726439e-02f, 1.00287825e-01f, -2.98494902e-02f, 3.26938112e-03f, 1.13013312e-01f, 2.71096051e-01f, -9.08569321e-02f, 4.48229909e-02f, 9.61717591e-02f, -1.88923795e-02f,
  -1.98124275e-01f, -1.85509957e-02f, 4.80911881e-03f, 3.20151269e-01f, 1.78228989e-01f, -2.26063326e-01f, 8.26544538e-02f, 7.20135681e-03f, 5.62290475e-02f, -1.04751505e-01f,
  9.61157456e-02f, 3.14399190e-02f, 1.02265617e-02f, 4.78781164e-02f, 8.88713971e-02f, 6.32143542e-02f, 5.85468076e-02f, 1.12874426e-01f, -2.80280113e-02f, 1.52896166e-01f,
  4.12786705e-03f, -1.27797425e-01f, 5.67575432e-02f, -9.20218527e-02f, -6.71622111e-03f, 5.56128323e-02f, 4.48430441e-02f, 8.05725008e-02f, -1.53506726e-01f, -2.02959701e-02f,
  -2.64985710e-02f, -1.75503865e-01f, 2.06585959e-01f, -1.56829208e-01f, -2.11227491e-01f, -7.73897171e-02f, 1.01744369e-01f, 1.59081876e-01f, -1.36839980e-02f, -2.62754597e-02f,
  1.62715286e-01f, -2.13676602e-01f, 2.31634036e-01f, 1.10629298e-01f, 1.78671107e-01f, -1.70099229e-01f, 5.80772907e-02f, 9.02361646e-02f, -2.84091663e-02f, 3.70211601e-01f,
  1.16537966e-01f, 2.65386939e-01f, -1.30574942e-01f, 2.21482679e-01f, 9.67788398e-02f, 8.18903521e-02f, 1.23875819e-01f, -5.19970171e-02f, -9.28730890e-02f, 2.70802975e-01f,
  -1.16605200e-01f, 2.34826535e-01f, 9.33306441e-02f, 5.39230891e-02f, -1.03071198e-01f, 3.01593542e-02f, 6.50590584e-02f, 5.90811521e-02f, -3.19623463e-02f, -3.45794596e-02f,
  1.15773492e-01f, 6.29568100e-02f, -1.56382564e-02f, -3.24517079e-02f, -1.28044546e-01f, -1.02162585e-01f, 1.94887612e-02f, -1.20110847e-02f, -1.25800878e-01f, -3.98014151e-02f,
  3.64903547e-02f, -1.06442668e-01f, -7.33726844e-03f, 4.27254960e-02f, -6.51528873e-03f, 1.27492487e-01f, -4.00904566e-02f, 2.35771090e-02f, -3.16624790e-02f, -1.00088038e-01f,
  3.36464588e-03f, -5.90943620e-02f, 2.12087288e-01f, 2.88118678e-03f, -4.27209400e-02f, 1.35690853e-01f, -1.10862561e-01f, 2.94448853e-01f, 1.32213920e-01f, 2.03936175e-02f,
  9.60275382e-02f, -5.25711849e-02f, -2.72675715e-02f, 1.35915220e-01f, -5.67004867e-02f, 1.63430125e-01f, -7.07814693e-02f, 5.42241335e-02f, 1.16880089e-01f, 1.00298285e-01f,
  -1.44223705e-01f, 1.45740777e-01f, 8.66968110e-02f, -2.06045866e-01f, 5.38220182e-02f, -1.80846363e-01f, 1.54579490e-01f, 1.34894140e-02f, 8.06426406e-02f, 1.62800059e-01f,
  -4.23685834e-02f, 3.99414301e-02f, 4.45067557e-03f, -1.53417155e-01f, 1.55374497e-01f, -2.82931495e-02f, -1.10120356e-01f, 4.81340289e-03f, 1.63739800e-01f, -1.01849206e-01f,
  2.61247959e-02f, -6.56088069e-02f, 5.24622984e-02f, -2.52575204e-02f, 7.42239282e-02f, 1.56636253e-01f, 1.34174228e-01f, 3.55158783e-02f, 2.38606078e-03f, -8.47507045e-02f,
  7.03363344e-02f, 1.74637455e-02f, 8.27056766e-02f, -1.44240540e-02f, 4.18698713e-02f, 9.73535925e-02f, 4.67897905e-03f, 7.31478259e-03f, -9.94808692e-03f, -4.61923517e-02f,
  4.59646285e-02f, 1.49264559e-01f, -4.89893220e-02f, -8.17724913e-02f, 4.17261980e-02f, 6.93461075e-02f, 7.21274763e-02f, -2.53349878e-02f, -1.00682214e-01f, 1.22718275e-01f,
  -2.00077787e-01f, 1.67317122e-01f, -3.96605693e-02f, 1.36018381e-01f, 1.39666796e-01f, 2.67577041e-02f, 6.22451045e-02f, 5.36797307e-02f, -5.31103574e-02f, 9.88086909e-02f,
  -1.84952497e-01f, 1.09429382e-01f, -5.93172088e-02f, -1.70384750e-01f, 6.68497384e-02f, 1.98410034e-01f, 2.15222195e-01f, 4.64606769e-02f, -1.63817983e-02f, -4.22954261e-02f,
  2.43613452e-01f, 8.01539272e-02f, 1.35402635e-01f, 1.32068902e-01f, 5.14179766e-02f, 5.56018762e-02f, 2.16453820e-01f, -9.24483612e-02f, 6.64364919e-02f, -1.68441594e-01f,
  -1.27686948e-01f, 1.24984875e-01f, 5.66426218e-02f, 9.87065583e-02f, 1.65525734e-01f, 1.95462443e-02f, 1.41917551e-02f, 1.66626051e-02f, 9.14877430e-02f, 2.07139388e-01f,
  1.11125693e-01f, 1.63534041e-02f, 4.92041223e-02f, -9.38411579e-02f, -1.76425315e-02f, -5.70090339e-02f, 1.14455484e-02f, -4.46153283e-02f, -3.16391997e-02f, 4.59154621e-02f,
  1.45632597e-02f, -4.46561212e-03f, -1.01830103e-02f, 2.64087059e-02f, -3.72474454e-02f, 1.20468214e-01f, -3.40431482e-02f, -5.31893270e-03f, 5.65808378e-02f, 1.04687601e-01f,
  -2.78923884e-02f, -1.11130578e-02f, -9.05337408e-02f, -1.77434902e-03f, -5.86270876e-02f, -1.22595742e-01f, -3.65053141e-03f, 4.37004790e-02f, 9.48473811e-02f, -9.47933123e-02f,
  -7.31515139e-02f, 5.16708978e-02f, 2.81295218e-02f, -2.81473771e-02f, -2.00720847e-01f, -3.23795751e-02f, -1.23177871e-01f, 1.91651247e-02f, 1.18135393e-01f, -3.08106635e-02f,
  1.13474473e-01f, 1.85698960e-02f, -5.69952913e-02f, 1.10196225e-01f, 1.51863158e-01f, -1.43778503e-01f, -1.08305156e-01f, 1.63548082e-01f, 1.32439565e-02f, -2.89974548e-02f,
  1.46539062e-01f, 1.05704546e-01f, -1.09886676e-01f, -7.95583874e-02f, -1.94893125e-02f, 1.79716974e-01f, -4.80704494e-02f, 4.46630605e-02f, -7.93198124e-02f, 2.19435856e-01f,
  8.67756978e-02f, -5.20943478e-02f, -6.46217540e-02f, 2.18437716e-01f, 6.71666265e-02f, 6.54238090e-02f, 2.08721176e-01f, 8.66781771e-02f, 5.90407327e-02f, -2.32001301e-02f,
  1.53489321e-01f, -9.17458236e-02f, 9.10053700e-02f, 1.57907128e-01f, 3.20136175e-02f, 3.56156938e-02f, -6.57758340e-02f, -1.15892299e-01f, 3.09836268e-02f, 6.65689111e-02f,
  2.13024393e-02f, -1.28593266e-01f, 1.37552932e-01f, -8.54372531e-02f, 1.56239972e-01f, 3.41763683e-02f, -1.77420691e-01f, 1.61611736e-01f, -2.04202771e-01f, 2.49971956e-01f,
  -2.30243534e-01f, 1.13001369e-01f, 1.41050145e-01f, -7.22999498e-02f, 6.40384182e-02f, 2.61755101e-02f, -2.63977163e-02f, 8.26070905e-02f, -2.05250859e-01f, 1.86373949e-01f,
  7.79609308e-02f, -6.10078685e-02f, -4.11918275e-02f, 9.32456255e-02f, 1.14138816e-02f, -4.13495898e-02f, 1.01880677e-01f, 4.86775003e-02f, 2.22041309e-01f, 6.93912581e-02f,
  1.73524499e-01f, 1.43124536e-01f, 9.16985944e-02f, 1.24902474e-02f, 1.86764374e-01f, -1.53070226e-01f, 1.30145490e-01f, -2.33411521e-01f, -2.32423007e-01f, 7.40635619e-02f,
  1.98523208e-01f, 4.67752181e-02f, 1.86689213e-01f, -2.23135911e-02f, -4.39297296e-02f, 2.12797001e-01f, 6.39907420e-02f, 1.81620657e-01f, 8.02307576e-02f, 6.41713217e-02f,
  6.43007981e-04f, 2.31632218e-02f, 1.37854535e-02f, -4.45740968e-02f, 1.18643604e-03f, 6.53745010e-02f, 2.08565276e-02f, 3.01477648e-02f, 1.32884122e-02f, 7.56552294e-02f,
  -1.16948634e-02f, -1.22631518e-02f, -4.90437821e-02f, 9.99215245e-02f, 4.55616415e-02f, -8.02275240e-02f, 4.23248149e-02f, 1.81530908e-01f, -4.67808992e-02f, -1.72645468e-02f,
  -6.23388961e-02f, 1.88040119e-02f, -7.37259537e-02f, -1.01274319e-01f, -3.68737690e-02f, 5.99494353e-02f, 5.08968867e-02f, -1.28899872e-01f, -1.60687596e-01f, 1.00828864e-01f,
  4.25131917e-02f, -3.31925154e-02f, -9.94949937e-02f, -1.34074092e-01f, -2.14475617e-02f, -2.93505136e-02f, 1.92462966e-01f, 4.11731899e-02f, 2.61185825e-01f, 4.00031544e-02f,
  1.78121999e-02f, 1.13057740e-01f, 1.09668523e-01f, -5.57426251e-02f, -8.03005397e-02f, 7.26154447e-02f, 1.47296712e-01f, 3.70640904e-02f, 1.27776399e-01f, 6.78416118e-02f,
  -2.16722399e-01f, -5.86894304e-02f, -3.18125375e-02f, 2.47597173e-01f, -6.21311218e-02f, -1.41691118e-02f, -6.12851866e-02f, 1.61474735e-01f, 1.95803240e-01f, 1.87132675e-02f,
  -5.55248335e-02f, 1.94685593e-01f, 3.67096486e-03f, 1.22339882e-01f, 8.08643326e-02f, 1.97075576e-01f, 1.14810787e-01f, 7.03048781e-02f, 3.90754789e-02f, -6.40920922e-02f,
  7.04537034e-02f, -1.13889622e-02f, 8.42173547e-02f, 1.14294186e-01f, -1.45178214e-01f, -1.35843918e-01f, 1.24896690e-01f, -5.52866608e-02f, -3.14149284e-03f, -2.95851659e-02f,
  1.53371412e-02f, 3.56324613e-02f, 3.73706445e-02f, 9.79188755e-02f, -5.71920536e-02f, 4.06024465e-03f, 8.12024325e-02f, 2.53531814e-01f, 3.48019190e-02f, 2.64188766e-01f,
  -1.49655208e-01f, -1.50569037e-01f, -1.03207445e-02f, -2.46651024e-01f, 8.70856419e-02f, 2.82929689e-01f, 1.12060696e-01f, -5.72914118e-03f, 1.17517568e-01f, 7.64790773e-02f,
  1.95316434e-01f, 2.26769671e-02f, 1.28492683e-01f, -9.87766385e-02f, 2.26545140e-01f, 7.63769001e-02f, -5.01754470e-02f, 9.59180370e-02f, -3.80909294e-02f, 1.41194882e-03f,
  7.46765137e-02f, 2.47827992e-01f, 1.22454762e-01f, -8.59814584e-02f, -8.84854198e-02f, -3.62408236e-02f, -1.06413603e-01f, 2.11554676e-01f, 1.25006512e-01f, -2.00754404e-03f,
  5.95691018e-02f, -2.75771506e-02f, 1.39675602e-01f, 3.08739066e-01f, -9.15348828e-02f, 1.46233752e-01f, -2.39735506e-02f, -5.71387894e-02f, -1.93945672e-02f, -1.34905858e-03f,
  1.98950060e-03f, 3.70229594e-02f, 1.13823451e-02f, 1.24184452e-01f, 1.44640962e-03f, -1.12784021e-02f, -5.05315736e-02f, 1.25668896e-02f, 2.02814862e-02f, 4.69332747e-02f,
  -6.23802468e-02f, -1.14090376e-01f, -6.16298281e-02f, 3.32972482e-02f, -3.23961899e-02f, -2.20879484e-02f, -3.82141471e-02f, 2.12759487e-02f, 1.02753658e-02f, -1.01751469e-01f,
  1.45017862e-01f, -6.31463900e-02f, -2.09084917e-02f, -9.79673862e-02f, 5.54634333e-02f, 7.31499419e-02f, -1.30911455e-01f, 1.51953787e-01f, 1.46875709e-01f, -1.05305158e-01f,
  1.88326344e-01f, -5.91565445e-02f, 1.48498923e-01f, 5.09721600e-02f, 1.07695699e-01f, 3.16622294e-02f, -3.22083719e-02f, 2.12517619e-01f, 1.09626658e-01f, 1.34607613e-01f,
  -8.35435390e-02f, -4.75554541e-02f, 6.56289682e-02f, 1.14729390e-01f, -9.83442087e-03f, -5.18421084e-02f, -2.74072699e-02f, 9.52402875e-02f, -9.99594182e-02f, 1.83369994e-01f,
  8.96626860e-02f, 1.05753532e-02f, -9.88795534e-02f, -1.02674000e-01f, 1.07298255e-01f, 1.38886973e-01f, -4.94507654e-03f, -5.12131713e-02f, 2.21940160e-01f, -2.54107434e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  -3.60761359e-02f, -2.86058951e-02f, 2.05486305e-02f, 8.15361738e-02f, 6.00321777e-02f, 1.40229444e-04f, 6.99011758e-02f, 3.44789028e-02f, -2.16076821e-02f, -8.29827134e-03f,
  5.90063557e-02f, 3.72938924e-02f, -6.64299354e-02f, 8.61252658e-03f, -1.86344720e-02f, 3.29303555e-02f, -3.01693939e-02f, -2.24001631e-02f, -3.23688239e-02f, -6.43246099e-02f,
  -2.31276825e-02f, -9.92471818e-03f, 3.01173679e-03f, 5.64498566e-02f, -3.28437239e-02f, 7.89479092e-02f, 4.20700982e-02f, -8.32735933e-03f, 1.34209907e-02f, 7.36399367e-02f,
  -3.13214213e-02f, 4.99020256e-02f, -6.29543094e-03f, 7.01891035e-02f, 2.71094288e-03f, 2.31110584e-02f, 7.10101724e-02f, 2.07581073e-02f, 2.83858869e-02f, 1.20771090e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -9.32714567e-02f, -5.88969886e-02f, 8.46631266e-03f, -2.80280504e-02f, 8.21579024e-02f, 3.63857299e-02f, -8.54790211e-02f, -1.01837382e-01f, -1.61329284e-01f, 1.20721318e-01f,
  1.09955825e-01f, 6.40359987e-03f, -3.47754508e-02f, -1.48799986e-01f, 3.18023749e-02f, 1.14884607e-01f, 1.36125805e-02f, -6.23992793e-02f, 1.85647368e-01f, -5.70760742e-02f,
  2.44107824e-02f, 1.45066455e-01f, 1.16300344e-01f, 6.48958832e-02f, -5.32613993e-02f, -3.32291946e-02f, 1.89850163e-02f, -2.67096963e-02f, 8.62879455e-02f, -1.46582350e-01f,
  1.07210368e-01f, 3.11638825e-02f, 1.79767609e-01f, -3.15812677e-02f, -2.36302346e-01f, -8.88170078e-02f, -5.63164875e-02f, -2.18593389e-01f, -1.82805195e-01f, 8.60967562e-02f,
  -1.66650236e-01f, -3.07375252e-01f, -9.24570709e-02f, -2.46114507e-02f, 3.33289243e-02f, 3.50017995e-01f, -7.89897516e-02f, -1.07523836e-01f, -2.07239389e-01f, 1.37740478e-01f,
  1.84423000e-01f, -2.53463656e-01f, -3.30205828e-01f, -2.24691302e-01f, 6.30600527e-02f, -2.34726638e-01f, -3.05993557e-01f, 1.43599259e-02f, 2.00129271e-01f, 6.87707663e-02f,
  6.30687401e-02f, 1.20244905e-01f, 1.60112455e-01f, -3.59629065e-01f, 9.20700803e-02f, 1.62608534e-01f, 5.37914410e-02f, 2.08465867e-02f, -1.63597949e-02f, 1.37538284e-01f,
  -1.94374230e-02f, -1.29629299e-01f, 1.40646204e-01f, -7.85753801e-02f, 3.99254113e-02f, 9.70189944e-02f, 1.12362355e-01f, 2.01413408e-02f, -6.07452262e-03f, -1.32055700e-01f,
  6.83604479e-02f, -8.61193836e-02f, 6.29670620e-02f, -1.20978825e-01f, -4.80619147e-02f, -2.43340377e-02f, 1.30256936e-01f, -9.13245883e-03f, -2.62891412e-01f, -9.23564881e-02f,
  4.14475277e-02f, -9.10100248e-03f, 2.17981726e-01f, -3.23535919e-01f, -7.11097196e-03f, 1.95101518e-02f, -2.74491459e-01f, -3.37013781e-01f, -8.61244649e-02f, -4.70766008e-01f,
  -5.60226813e-02f, 1.92849874e-01f, -1.25403374e-01f, 3.48706782e-01f, 4.69918400e-02f, -1.72631994e-01f, -2.51573743e-03f, -1.13420747e-01f, -9.73760113e-02f, -2.68031865e-01f,
  -1.84332892e-01f, 2.95668785e-02f, -3.97148468e-02f, 2.52602637e-01f, 1.13005958e-01f, -2.18892336e-01f, -1.97071567e-01f, 7.45375827e-02f, 1.26980513e-01f, -1.78139985e-01f,
  -4.38182205e-01f, 1.51796415e-01f, 4.97534685e-02f, -2.28019282e-01f, 2.73819298e-01f, -2.81995803e-01f, 1.40829802e-01f, -2.49600992e-01f, -3.34249511e-02f, 8.32033455e-02f,
  -2.65134629e-02f, -1.83451846e-01f, -5.28398529e-02f, -1.11648500e-01f, -3.46664600e-02f, 3.02372146e-02f, -7.77064040e-02f, -9.64767262e-02f, -5.27103664e-03f, -9.47289243e-02f,
  -9.33875516e-03f, 1.79261863e-01f, 8.17335118e-03f, -8.05959255e-02f, 1.22061595e-01f, 1.07776083e-01f, 1.12530328e-01f, -1.43353999e-01f, 9.43016410e-02f, 8.46804008e-02f,
  2.30974890e-02f, -8.75293612e-02f, 5.00803739e-02f, -1.69753462e-01f, 1.10257983e-01f, 1.35783246e-02f, -2.35585459e-02f, -2.61159539e-01f, -3.46002936e-01f, 7.94436038e-02f,
  -2.08766103e-01f, -3.03604573e-01f, -4.01162386e-01f, 7.64273256e-02f, 1.62308686e-03f, 9.18716118e-02f, -2.37821743e-01f, -2.39558652e-01f, 1.18195325e-01f, -1.18968479e-01f,
  -2.44253203e-01f, 2.20726565e-01f, -1.49077386e-01f, -4.45981920e-02f, -2.28453744e-02f, 1.57366723e-01f, 4.11067717e-02f, 4.42063175e-02f, 4.24605981e-02f, 2.55046457e-01f,
  2.03587875e-01f, -1.97866559e-02f, 2.51438051e-01f, -3.28193158e-02f, -6.70833979e-04f, 8.32279101e-02f, 4.06353287e-02f, -1.17019922e-01f, 6.17096648e-02f, -1.74492985e-01f,
  -1.92139030e-01f, -2.44448408e-01f, -1.81542020e-02f, 6.09559007e-02f, 1.88658297e-01f, -4.09600586e-02f, -1.87310249e-01f, 1.07113220e-01f, 6.35828450e-02f, 7.11252987e-02f,
  -9.43130031e-02f, -8.26067924e-02f, -1.05281048e-01f, 8.62299502e-02f, 5.76865114e-02f, -2.74615120e-02f, -7.68488124e-02f, -6.00465089e-02f, 1.30742535e-01f, 5.56212515e-02f,
  -1.12981610e-02f, 4.62347642e-02f, 6.75679045e-03f, 9.44325030e-02f, 4.83050272e-02f, 6.26331568e-02f, 5.42764850e-02f, 2.56734550e-01f, -2.67882645e-01f, -3.52383882e-01f,
  -4.23830152e-01f, 1.58719078e-01f, 7.83560425e-02f, 1.47993445e-01f, 9.00185555e-02f, -2.28159249e-01f, -1.89993411e-01f, -1.11148432e-01f, 1.94440573e-01f, -3.16314310e-01f,
  3.91276255e-02f, -2.79092312e-01f, -2.21434385e-02f, 1.02978073e-01f, -5.44164926e-02f, 7.78816193e-02f, 6.28096536e-02f, 1.76153630e-01f, 1.17007606e-01f, -1.69173125e-02f,
  1.66202724e-01f, -3.32922041e-01f, -1.50020897e-01f, 1.87075153e-01f, -2.19804391e-01f, -4.06759530e-02f, -6.22102208e-02f, 1.23661362e-01f, -1.49397999e-01f, 5.32344356e-02f,
  -1.00058154e-03f, 1.63956836e-01f, -2.34570488e-01f, 9.43233222e-02f, -6.42157570e-02f, 3.82195599e-02f, 1.41882300e-01f, 4.89721075e-03f, 4.65406589e-02f, -8.59175771e-02f,
  1.61702618e-01f, -2.35649168e-01f, 5.17445765e-02f, -4.08793613e-02f, 2.58295164e-02f, -8.26627240e-02f, -1.12060132e-02f, 9.45340917e-02f, 5.76629303e-02f, -1.36524728e-02f,
  -1.80901214e-01f, -3.45419832e-02f, 1.93169210e-02f, -8.50486085e-02f, 1.68002650e-01f, -8.60472023e-02f, -2.25051761e-01f, -8.75755865e-03f, -2.38322794e-01f, 1.03695177e-01f,
  -3.16674113e-01f, -3.19968730e-01f, 1.11691274e-01f, 7.97264203e-02f, -7.12665915e-02f, 6.08446524e-02f, 1.65464692e-02f, 1.02824278e-01f, 1.51988283e-01f, 3.34305428e-02f,
  -1.51824489e-01f, -1.55172795e-01f, 5.05069867e-02f, -1.55352935e-01f, 1.06491178e-01f, -1.75632447e-01f, -1.31217495e-01f, 4.43387702e-02f, 5.68325482e-02f, -2.40340278e-01f,
  -3.09893548e-01f, -1.08750284e-01f, -3.42089891e-01f, -3.50042969e-01f, 9.90713108e-03f, 1.49475783e-01f, 4.98392507e-02f, 1.87895834e-01f, 1.60058737e-01f, -2.07026169e-01f,
  -4.76749567e-03f, 1.61590144e-01f, 1.96616560e-01f, -2.62989968e-01f, 5.48300296e-02f, 2.07411245e-01f, 1.45669356e-01f, 1.81469336e-01f, 1.40600711e-01f, -3.67292836e-02f,
  8.58125165e-02f, 8.51385519e-02f, 2.12226838e-01f, 1.22836672e-01f, -3.58170085e-02f, 7.58129433e-02f, 8.40991444e-04f, 2.50454918e-02f, -1.39519319e-01f, 1.24480218e-01f,
  -3.97405177e-02f, -5.28970100e-02f, 2.96905963e-03f, 4.30172235e-02f, -1.37803823e-01f, 1.71545684e-01f, 2.59976655e-01f, 1.39556572e-01f, -8.26319903e-02f, -4.12732884e-02f,
  4.33492213e-02f, 1.79272011e-01f, 1.31451786e-01f, -6.15357347e-02f, -2.65048206e-01f, -1.24250442e-01f, 5.28640412e-02f, 2.17401996e-01f, 1.23577684e-01f, 6.94445595e-02f,
  2.04851896e-01f, -4.74842697e-01f, 6.15253113e-02f, 1.28534302e-01f, 1.99613973e-01f, -2.58085787e-01f, -1.40208989e-01f, 1.47754669e-01f, 7.00646639e-02f, -4.67159301e-02f,
  -8.10782909e-02f, -1.28583997e-01f, 1.26019791e-01f, -2.65344203e-01f, -3.77499200e-02f, 6.09691394e-03f, -2.12252781e-01f, -5.39195053e-02f, -3.45793962e-01f, 6.20649196e-03f,
  -1.86138153e-01f, -3.05352122e-01f, -1.52115047e-01f, 1.99283928e-01f, -3.38196814e-01f, -2.81650424e-01f, 1.16862558e-01f, 1.20271027e-01f, 4.66102036e-03f, -1.31256059e-01f,
  1.82277009e-01f, -4.44191433e-02f, 2.01257542e-01f, 3.63362730e-02f, 1.99582633e-02f, -9.70661193e-02f, 1.11818053e-01f, 1.18225798e-01f, -3.57097574e-02f, -3.92148979e-02f,
  -1.00413539e-01f, -5.24500348e-02f, 4.67252843e-02f, 8.67162831e-04f, 2.47395393e-02f, -3.76364216e-02f, -8.96476656e-02f, 5.85091561e-02f, 5.93764521e-02f, -8.09464976e-02f,
  -5.30202128e-02f, -1.41263410e-01f, -1.31888494e-01f, -2.46096533e-02f, -1.21610798e-02f, -9.15690511e-02f, 4.57319580e-02f, 1.58872604e-02f, -1.54965341e-01f, 2.31989697e-02f,
  4.00962122e-02f, -2.65838914e-02f, -1.14144251e-01f, -1.88533738e-01f, -2.60409743e-01f, -2.11767852e-01f, -1.76696092e-01f, 9.95000154e-02f, 1.30576581e-01f, 1.21922821e-01f,
  -1.57746315e-01f, 8.79721716e-02f, 9.56499204e-02f, -2.55364418e-01f, 1.92145571e-01f, -1.01119746e-02f, -2.10089013e-02f, 2.23613352e-01f, 7.14359283e-02f, -6.91796616e-02f,
  -1.52522236e-01f, 2.41928026e-01f, -1.71392918e-01f, -8.48480538e-02f, -3.92379373e-01f, -1.10046029e-01f, 9.14516971e-02f, 1.30084053e-01f, -2.82980859e-01f, -7.04564080e-02f,
  2.43575156e-01f, -2.38623679e-01f, -3.22134763e-01f, -2.42461227e-02f, -3.70086730e-01f, -2.67918408e-01f, -1.62477240e-01f, 1.63018346e-01f, -1.27335146e-01f, 3.99785638e-02f,
  -6.46445528e-02f, -4.12705913e-02f, 1.30772367e-01f, -4.79047261e-02f, 2.76182014e-02f, -6.21522479e-02f, 1.66512400e-01f, 5.90755045e-02f, 1.45949438e-01f, 8.28890726e-02f,
  4.13784534e-02f, -1.05455525e-01f, -3.77083384e-02f, 4.86684144e-02f, -2.64387075e-02f, 1.32759765e-01f, -1.03116065e-01f, -2.43964270e-02f, -1.37939557e-01f, 1.06682703e-01f,
  1.19815208e-02f, 1.20064855e-01f, -1.77090138e-01f, -2.69185513e-01f, -3.56320024e-01f, -3.21846187e-01f, -6.33570254e-02f, 1.63435742e-01f, 1.72429159e-01f, -2.14892939e-01f,
  4.43956777e-02f, 2.44287565e-01f, 9.30807292e-02f, 2.23989546e-01f, 1.82339430e-01f, -2.08309606e-01f, 1.75323457e-01f, -2.53479138e-05f, -1.24934696e-01f, 5.89719005e-02f,
  1.19751088e-01f, -1.23534031e-01f, 8.41275528e-02f, 2.79426128e-01f, -2.90466785e-01f, 1.18651185e-02f, 1.11659676e-01f, -5.92474639e-02f, -1.62539750e-01f, -2.72598863e-01f,
  -2.74357289e-01f, -7.44889602e-02f, -3.49208266e-01f, -9.99599025e-02f, -1.46467030e-01f, -2.54698209e-02f, -3.87749732e-01f, -1.16074808e-01f, -3.08369875e-01f, -7.57100210e-02f,
  1.93136781e-01f, 4.72036824e-02f, -1.49653658e-01f, 2.37793718e-02f, -1.04297198e-01f, -2.37081256e-02f, 9.75976065e-02f, -1.03436962e-01f, -1.03606224e-01f, -5.52452542e-02f,
  6.21305481e-02f, -9.92381126e-02f, -7.42345601e-02f, -5.04339263e-02f, -2.52983961e-02f, -4.88612093e-02f, -3.67772765e-02f, -1.90210566e-01f, -7.34195784e-02f, -1.10381015e-01f,
  -8.14140067e-02f, 2.21254639e-02f, -1.66942909e-01f, -1.20780416e-01f, -1.33945450e-01f, -3.88790742e-02f, 2.63069391e-01f, -2.06954360e-01f, 1.39502212e-01f, -5.80160916e-02f,
  7.55081028e-02f, -1.85295448e-01f, -3.90915796e-02f, 1.62563503e-01f, -1.64564312e-01f, -3.50431800e-01f, 1.32800087e-01f, 3.36868465e-01f, -6.89159334e-02f, 1.15432916e-02f,
  -2.75041144e-02f, 2.35698447e-01f, -1.16001591e-01f, 9.15696472e-02f, 2.37437002e-02f, -1.96567744e-01f, 9.13442373e-02f, 1.99420769e-02f, 2.61910200e-01f, -2.75366545e-01f,
  -1.33657679e-01f, -3.00555021e-01f, -3.21409374e-01f, -3.37160677e-01f, 4.37187739e-02f, 1.94826201e-01f, 1.11349531e-01f, -2.55453408e-01f, -5.16941324e-02f, 9.25439894e-02f,
  1.09790444e-01f, -2.23729312e-01f, 1.65671170e-01f, -3.21513534e-01f, -2.68588722e-01f, 7.00703543e-03f, -3.14676166e-02f, 6.73011392e-02f, -6.18576109e-02f, 1.15268596e-01f,
  -9.86267775e-02f, 4.75953482e-02f, 1.00345373e-01f, 7.81429857e-02f, -1.80385083e-01f, 7.70280138e-02f, -9.95479524e-02f, 1.34666920e-01f, 1.86507776e-01f, 6.52017593e-02f,
  -5.21355197e-02f, 9.65567864e-03f, 1.21700317e-02f, -1.08268686e-01f, 3.91994342e-02f, -1.40790895e-01f, 7.10282922e-02f, -3.65735218e-02f, 1.97741047e-01f, -1.83661520e-01f,
  7.95943215e-02f, 6.84585720e-02f, -2.45027021e-02f, 3.79281268e-02f, -1.43993376e-02f, -7.94887468e-02f, 1.68075219e-01f, -4.33879435e-01f, 6.31571487e-02f, 3.65660712e-02f,
  -2.14202031e-01f, -1.18716784e-01f, -1.28332153e-01f, -1.43761352e-01f, -1.47900864e-01f, -2.94456840e-01f, 1.05505027e-02f, -2.36549631e-01f, -2.17580184e-01f, 1.70674637e-01f,
  3.16655934e-01f, -1.74999982e-01f, 2.67659537e-02f, 1.57460898e-01f, -1.20536841e-01f, 1.71890035e-01f, 2.66342282e-01f, 2.16628522e-01f, 9.91200954e-02f, -1.09444678e-01f,
  -1.66398525e-01f, -8.19714814e-02f, 1.85540959e-01f, -2.68188804e-01f, -3.13721448e-01f, -2.14906499e-01f, -2.83132762e-01f, -5.68748824e-02f, 4.76467013e-02f, 7.44451210e-02f,
  1.06996611e-01f, -4.34449501e-02f, -1.18249424e-01f, 2.20806431e-02f, -1.99218281e-02f, 9.34853181e-02f, 2.62281243e-02f, -7.45153204e-02f, -1.10807262e-01f, 1.51334599e-01f,
  -9.70402434e-02f, 1.44774532e-02f, -2.00103559e-02f, 9.70255509e-02f, 1.29502073e-01f, 2.01030895e-01f, -5.08937240e-02f, -9.47250612e-03f, -1.86593264e-01f, 9.26000476e-02f,
  1.62676498e-01f, -5.38407713e-02f, -8.34958851e-02f, -7.81983435e-02f, 9.47865993e-02f, 2.79010206e-01f, -9.85536352e-03f, 1.23255827e-01f, -8.89069811e-02f, 1.19211018e-01f,
  -2.31026873e-01f, 2.08041862e-01f, 3.42926532e-02f, -3.53109628e-01f, -9.00002643e-02f, -3.72777104e-01f, -4.93647978e-02f, 1.44484416e-01f, -1.24878116e-01f, 2.27651834e-01f,
  -3.15264583e-01f, -5.38152903e-02f, 1.15760803e-01f, -1.69755176e-01f, 3.46446759e-03f, -3.03998053e-01f, 1.96798250e-01f, -1.44983873e-01f, -4.79315855e-02f, 3.93373780e-02f,
  -1.24602839e-01f, 1.64080188e-01f, -2.28388727e-01f, -2.67108411e-01f, 1.92534715e-01f, 1.80920735e-01f, -1.06031515e-01f, 1.67037293e-01f, 1.12406045e-01f, 3.45491730e-02f,
  1.85296953e-01f, 2.72052269e-02f, -2.05547169e-01f, 4.13888656e-02f, -1.24527607e-02f, -8.14135224e-02f, -1.22611433e-01f, -1.03078075e-01f, 2.09551692e-01f, 2.14490178e-03f,
  -4.04173620e-02f, 7.46660978e-02f, 6.71905873e-04f, -5.17486557e-02f, 4.44711819e-02f, -1.63868427e-01f, -2.44975477e-01f, 2.03280374e-02f, 2.11582303e-01f, 1.79535761e-01f,
  -5.17492481e-02f, 1.10540152e-01f, -6.21326230e-02f, 1.56397507e-01f, 1.01592699e-02f, 6.61495924e-02f, -1.20539539e-01f, -4.28023525e-02f, 3.05419385e-01f, -1.15718104e-01f,
  1.46525456e-02f, 4.10626456e-02f, 6.10905117e-04f, 1.33124724e-01f, -2.21273780e-01f, -8.92203227e-02f, 3.86765152e-02f, 3.99013497e-02f, 5.90275638e-02f, 1.68071911e-01f,
  -5.50865792e-02f, -7.17824250e-02f, 1.58979982e-01f, -1.79365814e-01f, -1.87248245e-01f, 2.31870785e-01f, 6.23616055e-02f, -2.38148361e-01f, -2.14546084e-01f, -2.56020278e-01f,
  2.21555438e-02f, -2.58592248e-01f, 1.14642672e-01f, -3.88745517e-01f, -3.19289297e-01f, 4.60305549e-02f, 1.43412665e-01f, -6.91215470e-02f, -3.11135530e-01f, 1.35219917e-01f,
  2.28081033e-01f, -1.98189333e-01f, -9.02650580e-02f, -9.90687683e-02f, -1.66867733e-01f, 4.95126285e-02f, -1.94918677e-01f, 1.72842234e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.44765433e-02f, 1.21119142e-01f, -1.05545193e-01f, -3.33955884e-02f, -4.74178307e-02f, -1.24600725e-02f, -2.71406639e-02f, 1.35611175e-02f, -4.19885591e-02f, 9.93168652e-02f,
  -6.50052354e-02f, 1.04252741e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    