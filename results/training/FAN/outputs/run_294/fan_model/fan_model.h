/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.82506466e-01f, 6.18602037e-02f, -3.53560708e-02f, -1.75830975e-01f, -1.37171000e-01f, 2.56059378e-01f, 3.68864685e-01f, -6.34862185e-02f, -4.34613414e-02f, 2.21796319e-01f,
  2.15184554e-01f, -3.09901893e-01f, 3.75786275e-01f, 3.40390839e-02f, -6.06783200e-03f, 3.45642775e-01f, -6.75363000e-03f, -4.85982839e-03f, -5.21508679e-02f, -3.44572496e-03f,
  -8.01961720e-02f, 7.44373128e-02f, -2.71548815e-02f, -3.43741849e-02f, -5.47195114e-02f, -2.62574732e-01f, -1.41675279e-01f, 7.89375827e-02f, -1.83142558e-01f, -8.17231089e-02f,
  7.81872422e-02f, -6.45943582e-02f, 9.06932261e-03f, -1.22809121e-02f, -4.07175720e-02f, -2.22803000e-03f, -4.59626094e-02f, 3.21222022e-02f, -5.09580187e-02f, -1.34568205e-02f,
  3.57791148e-02f, -5.14345951e-02f, -2.33298484e-02f, 3.86880301e-02f, -7.53518417e-02f, -8.51988569e-02f, -6.25541508e-02f, -3.25733982e-02f, -4.32206951e-02f, 1.33780427e-02f,
  3.69706959e-03f, -3.75370681e-02f, 1.48641141e-02f, -2.12061610e-02f, -1.89650506e-02f, -5.77047933e-03f, -3.46988551e-02f, -7.15445131e-02f, -4.38150801e-02f, -8.90778080e-02f,
  8.29973817e-03f, 2.94443946e-02f, 4.90185134e-02f, 3.37146521e-02f, 1.62859093e-02f, 2.20574606e-02f, 1.60245169e-02f, 3.96477170e-02f, -1.35382079e-02f, 6.85043857e-02f,
  -7.81190023e-03f, -4.27086726e-02f, -1.34266127e-04f, -3.76115041e-03f, 1.59257092e-02f, 1.72747374e-02f, -5.00000501e-03f, -6.24637958e-03f, 7.74065824e-03f, -6.78434223e-03f,
  6.61342666e-02f, 1.62248907e-03f, 1.27791651e-02f, 2.72656512e-02f, 1.66114625e-02f, -3.36953774e-02f, 6.05662726e-03f, -4.51303236e-02f, 4.39575166e-02f, 2.53464971e-02f,
  -4.21221219e-02f, 1.18221134e-01f, -1.93330143e-02f, -3.40484194e-02f, 9.71733313e-03f, 2.19631055e-03f, 9.19130370e-02f, -2.82601602e-02f, -3.92286889e-02f, 5.07514440e-02f,
  -9.03054979e-03f, -3.41697261e-02f, -4.79786396e-02f, -2.28776168e-02f, -1.75102782e-02f, 3.22116353e-02f, 7.05042630e-02f, -5.66482581e-02f, -3.14697847e-02f, -4.12143730e-02f,
  -2.53519621e-02f, 6.36877120e-02f, -3.49407271e-02f, -1.81352589e-02f, -1.21595142e-02f, -1.44943465e-02f, -1.29232379e-02f, 3.34487185e-02f, -2.32410766e-02f, -1.54040484e-02f,
  -1.71004534e-01f, 8.98873135e-02f, -1.29522800e-01f, -3.54081154e-01f, -1.89861804e-02f, 1.49749920e-01f, -1.78213030e-01f, -4.76065986e-02f, -2.64740825e-01f, 8.52319151e-02f,
  1.02945846e-02f, -6.12067841e-02f, -6.65233433e-02f, 1.44640338e-02f, -9.74658504e-02f, -4.42318916e-02f, 1.10968733e-02f, 5.83369546e-02f, -1.95030272e-01f, 2.07658336e-02f,
  -3.37711014e-02f, 4.71141040e-02f, -1.20675554e-02f, 2.22810239e-01f, 7.32002333e-02f, -3.56935449e-02f, -4.47450653e-02f, 1.45001383e-02f, 2.72369206e-01f, 1.88876763e-02f,
  1.11453459e-02f, -1.53491497e-01f, 1.17278419e-01f, 5.74516542e-02f, -1.88529696e-02f, -3.75088979e-03f, -5.68559319e-02f, -5.79825090e-03f, -8.14670175e-02f, 2.49923859e-02f,
  4.48362082e-02f, 2.27522408e-03f, 4.70699109e-02f, -1.04633567e-03f, -3.41634788e-02f, 8.98809284e-02f, -4.92581492e-03f, 5.51705295e-03f, 2.11132262e-02f, -8.42387415e-03f,
  -4.12349403e-02f, -1.44662866e-02f, -3.77084911e-02f, 1.23874322e-02f, -3.17449160e-02f, 1.22276857e-03f, -7.18083456e-02f, 4.41340590e-03f, -2.67801397e-02f, 6.70867972e-03f,
  3.32330242e-02f, 1.07984599e-02f, -2.92232223e-02f, -6.51584065e-04f, 6.15186393e-02f, 2.63504963e-02f, 5.20444326e-02f, -1.18696298e-02f, -8.75729043e-03f, 7.68789202e-02f,
  4.37887944e-02f, 2.21869033e-02f, 2.81525571e-02f, -7.37895072e-02f, -1.49213728e-02f, -7.72618502e-02f, 6.54651597e-02f, 2.25055087e-02f, -1.00921690e-01f, 5.94226606e-02f,
  -2.87658582e-03f, 6.33535460e-02f, -5.60967065e-02f, -4.90398966e-02f, -4.82136086e-02f, 3.84882529e-04f, -1.90632809e-02f, 5.42777441e-02f, -8.70149285e-02f, -5.36334664e-02f,
  -3.24716568e-02f, -9.34647769e-02f, 1.65980589e-02f, 5.37577569e-02f, -2.08819117e-02f, 1.28233433e-01f, -1.05730640e-02f, 2.17968263e-02f, -6.29416779e-02f, 3.53667922e-02f,
  6.34598285e-02f, -7.11263046e-02f, 4.83633541e-02f, 2.12544855e-02f, -2.69030724e-02f, -4.60469089e-02f, -6.18475443e-03f, -6.01980463e-02f, -6.86364099e-02f, 6.45274371e-02f,
  5.23988754e-02f, 1.98352989e-02f, -2.25224314e-04f, -1.00409740e-03f, 1.21652856e-02f, -7.69108087e-02f, 4.25723791e-02f, -4.01805080e-02f, 1.02601573e-02f, 1.20737553e-02f,
  -4.00787860e-01f, 1.27872244e-01f, -2.86216140e-01f, -6.96229562e-02f, 1.19099237e-01f, 5.89848123e-02f, -1.07583441e-02f, 2.20778927e-01f, 1.03924140e-01f, 3.73880625e-01f,
  8.03909451e-02f, -4.68287095e-02f, -1.25297397e-01f, 1.06699727e-01f, -6.81010932e-02f, 5.93181849e-02f, 1.51770324e-01f, 5.80178201e-02f, -4.26557213e-02f, 8.34732354e-02f,
  -3.90876550e-03f, 2.66020238e-01f, -1.49263814e-01f, 1.58988133e-01f, -7.95979053e-02f, -6.63365051e-02f, 4.57327142e-02f, -1.49819434e-01f, 1.50580704e-01f, -3.74017768e-02f,
  -5.83688123e-03f, -3.60392942e-03f, -2.44794227e-02f, -2.78836414e-02f, -6.98399991e-02f, -1.79624464e-02f, -7.69844055e-02f, -6.31957874e-02f, -1.94717404e-02f, -6.18425235e-02f,
  -1.04326457e-01f, -1.70051213e-02f, 5.26417829e-02f, 4.33341227e-02f, -2.22348087e-02f, -5.85010648e-02f, -4.98470441e-02f, -4.50999774e-02f, -1.55059081e-02f, -4.71836440e-02f,
  -6.71950206e-02f, 2.92729884e-02f, 8.42663366e-03f, -3.57252918e-02f, 3.80311012e-02f, -5.17103495e-03f, 2.65546907e-02f, -6.55599982e-02f, 8.25662538e-02f, 8.70040432e-02f,
  3.16661149e-02f, -6.12746086e-03f, -4.52981740e-02f, -5.23273833e-02f, -3.25356610e-03f, -7.96612799e-02f, 5.71216680e-02f, -8.68461095e-03f, -8.20453838e-03f, 4.12287861e-02f,
  4.72257771e-02f, -9.42554884e-03f, 4.22604010e-02f, 3.64559777e-02f, -2.11577546e-02f, 4.12434228e-02f, -3.13271061e-02f, 3.42591070e-02f, 3.49247083e-02f, -3.93400565e-02f,
  -1.64439194e-02f, 7.23277703e-02f, 2.90319715e-02f, 4.74916659e-02f, 1.30833872e-02f, -3.51436920e-02f, 9.44338553e-03f, 3.70167047e-02f, -1.02890916e-02f, -2.57065836e-02f,
  1.98590651e-01f, 2.95837760e-01f, 7.47013986e-02f, -1.01710996e-02f, 1.39982719e-02f, 5.28514422e-02f, 9.49883310e-04f, 1.13495393e-02f, -2.72781700e-02f, 6.15654066e-02f,
  5.71020916e-02f, 5.75938523e-02f, 3.16912085e-02f, -3.13603804e-02f, 2.59373598e-02f, 1.30821019e-01f, 5.69405220e-03f, 2.57452372e-02f, 7.88707379e-03f, 3.27585824e-02f,
  1.15465308e-02f, 2.78238934e-02f, -1.97565220e-02f, 6.97947964e-02f, 3.08277700e-02f, -2.74452902e-02f, 4.55286577e-02f, 2.01710612e-02f, -6.31694198e-02f, 4.30299640e-02f,
  3.39904092e-02f, 2.39855677e-01f, -1.11528382e-01f, 5.70783466e-02f, -8.56906548e-02f, -2.80334502e-01f, -4.73625481e-01f, 4.86611649e-02f, -2.98334181e-01f, -3.13974023e-02f,
  -7.73656219e-02f, 2.20359713e-02f, -1.45988867e-01f, 1.70667708e-01f, -1.71931446e-01f, 1.57489702e-02f, 8.23227391e-02f, 5.00223525e-02f, 1.33869439e-01f, 1.04027456e-02f,
  1.41262919e-01f, 5.12346737e-02f, 1.41676128e-01f, 1.97222367e-01f, 1.10018753e-01f, 1.28241166e-01f, 4.98301499e-02f, -1.53157622e-01f, 1.75110951e-01f, -4.93003875e-02f,
  1.20997131e-01f, 3.18554305e-02f, -3.09714652e-03f, 1.13285650e-02f, -1.95903014e-02f, -7.84978122e-02f, -3.11881164e-03f, -2.80434713e-02f, -1.81140546e-02f, 2.74718809e-03f,
  -2.21924484e-02f, 6.21653069e-03f, 6.65857941e-02f, -6.24280572e-02f, -3.05497069e-02f, -7.90718477e-03f, 1.09367721e-01f, 7.31938630e-02f, 4.66507822e-02f, 4.73821722e-02f,
  2.45781895e-02f, 6.77378029e-02f, 2.40493063e-02f, 5.75721040e-02f, -3.97493355e-02f, -5.84746748e-02f, 2.30650534e-03f, -1.17275799e-02f, 2.96316873e-02f, -4.40432653e-02f,
  -5.75335734e-02f, -2.14422904e-02f, -4.27939296e-02f, 6.33354438e-03f, 1.41640464e-02f, 1.60530210e-02f, 2.50715297e-02f, -1.25924172e-02f, 2.99000032e-02f, 3.40239555e-02f,
  1.77380480e-02f, 4.20196988e-02f, 1.04405945e-02f, -2.15222165e-02f, 2.50521931e-03f, -3.90755944e-03f, 2.13860702e-02f, -5.54995518e-03f, 1.42841106e-02f, 4.29060683e-02f,
  -4.32674326e-02f, -1.51264276e-02f, -3.59175429e-02f, 5.26100546e-02f, -2.67216340e-02f, 5.71577577e-03f, 3.11614871e-02f, -7.08697783e-03f, 6.35183603e-02f, -2.24863160e-02f,
  -7.62013048e-02f, -9.37312916e-02f, -5.52344136e-02f, 2.12557591e-03f, -4.90759760e-02f, -5.48111945e-02f, -2.26662308e-03f, 3.96234868e-03f, -4.56659086e-02f, -7.90882707e-02f,
  3.41336206e-02f, -1.53285777e-02f, -6.20671771e-02f, 1.58525836e-02f, 1.63837038e-02f, -7.44953975e-02f, -5.13445213e-02f, -3.49768586e-02f, -7.32629374e-02f, 8.56757313e-02f,
  -5.41752912e-02f, -1.53204584e-02f, 2.57796180e-02f, -6.88309781e-03f, 6.23740181e-02f, 5.50132766e-02f, -4.13817465e-02f, 3.00136767e-02f, 8.25783685e-02f, 1.67653933e-02f,
  -7.14294314e-02f, 6.55730739e-02f, 1.90224022e-01f, -1.07468523e-01f, -3.51523198e-02f, 1.41059244e-02f, 2.91930069e-03f, 9.81785581e-02f, 2.38568261e-01f, -3.80697846e-02f,
  -3.79573293e-02f, -1.93678178e-02f, 1.48338795e-01f, -2.13934302e-01f, -1.33022532e-01f, 1.01356760e-01f, -1.28134057e-01f, -8.36969838e-02f, 1.04875632e-01f, -2.19223976e-01f,
  -6.31257333e-03f, -3.34111899e-01f, -1.73986062e-01f, -2.72295773e-01f, -1.04096673e-01f, -4.24333438e-02f, -1.98404938e-01f, -1.59675628e-02f, -2.66222179e-01f, -7.42775528e-03f,
  8.30888748e-02f, 3.76869217e-02f, -3.44456024e-02f, 5.11491895e-02f, -4.18273211e-02f, -2.72512473e-02f, -2.60950625e-03f, 2.66134124e-02f, 6.47132471e-02f, -2.06736326e-02f,
  2.48122364e-02f, -4.58702222e-02f, -3.59567814e-02f, 4.99856770e-02f, 4.28058393e-02f, -8.66891257e-03f, -1.86415073e-02f, 3.83069292e-02f, -6.12685271e-03f, 7.41754696e-02f,
  3.75403315e-02f, 5.85937724e-02f, -1.96607970e-02f, 9.29009693e-04f, 3.27643566e-02f, 1.58999357e-02f, -1.42268743e-03f, 1.18763736e-02f, 4.22243923e-02f, -1.58326037e-03f,
  1.28728030e-02f, 7.12128505e-02f, -1.79229472e-02f, 3.10000218e-03f, -2.20281612e-02f, 4.61752154e-02f, -2.17683744e-02f, -2.47743409e-02f, 3.80776711e-02f, -2.48939954e-02f,
  -5.40672094e-02f, 4.39367965e-02f, 6.29916228e-03f, 7.79419988e-02f, -4.16977815e-02f, 3.37661393e-02f, 9.01492219e-03f, -3.06143966e-02f, 2.70329919e-02f, -6.05981424e-02f,
  2.73805466e-02f, -2.41773203e-02f, -4.79355594e-03f, -2.00271755e-02f, -1.07226474e-03f, 2.69978051e-03f, 2.38167844e-03f, 2.68047415e-02f, -7.22198235e-03f, -3.54300216e-02f,
  -9.68933478e-02f, 1.53098647e-02f, 2.68037114e-02f, -4.08868911e-03f, 6.38895780e-02f, 2.21918914e-02f, -2.73259860e-02f, -2.56779920e-02f, -3.68497036e-02f, 3.82667929e-02f,
  -5.09603173e-02f, 1.29030412e-03f, -2.59346850e-02f, 5.97746111e-03f, 7.83083087e-04f, -7.50331068e-03f, -4.14382666e-02f, -2.53039766e-02f, 3.80765763e-03f, -5.18327393e-02f,
  -4.81991433e-02f, -5.98545894e-02f, -1.45703098e-02f, -9.20195058e-02f, -8.70699435e-02f, -2.84480322e-02f, 3.90281226e-03f, 5.75207956e-02f, -4.05731350e-02f, 5.22979572e-02f,
  -4.61852439e-02f, -2.85316333e-02f, -1.09262541e-02f, -1.97912946e-01f, -2.45158419e-01f, -4.76329207e-01f, -1.75636396e-01f, -9.89806056e-02f, -1.08907826e-01f, 1.43409967e-01f,
  7.09158182e-02f, -3.70448753e-02f, 3.64373356e-01f, -1.85991079e-01f, -2.00998396e-01f, 1.07091136e-01f, -3.41331601e-01f, -1.17084004e-01f, 3.74688059e-02f, -4.79007885e-02f,
  -5.28315678e-02f, -9.03894156e-02f, 9.77243856e-02f, 4.69299816e-02f, -1.18524686e-01f, -2.41441396e-03f, 1.62714839e-01f, 2.45937198e-01f, -1.28294066e-01f, -1.07233142e-02f,
  -1.23017885e-01f, 8.18026662e-02f, -1.98757369e-02f, 6.05073161e-02f, -7.69200101e-02f, -4.50182930e-02f, -1.90415718e-02f, 3.49523053e-02f, -2.94798445e-02f, 8.19665100e-03f,
  -1.42818075e-02f, -1.34474654e-02f, -5.06000258e-02f, 6.49556741e-02f, -5.55195995e-02f, -8.28365982e-03f, -5.16150333e-02f, -8.06658342e-02f, 1.90656986e-02f, -3.96640599e-02f,
  -5.25541157e-02f, -5.19996136e-02f, -4.83383611e-02f, -4.58625890e-02f, 3.42208855e-02f, 7.21080415e-03f, -6.96461229e-03f, -5.22074662e-02f, -1.09022625e-01f, -3.89339104e-02f,
  1.93574035e-03f, 5.22781275e-02f, 1.52988713e-02f, 3.92324757e-03f, -2.33243126e-02f, -1.46761560e-03f, -2.66935024e-03f, 1.84159521e-02f, 4.80923764e-02f, -3.59780639e-02f,
  -1.21471006e-02f, -2.13349834e-02f, 2.92925555e-02f, -2.41245721e-02f, -6.02133274e-02f, -2.62365658e-02f, 4.28903811e-02f, 3.88040133e-02f, -4.26154919e-02f, -2.30424609e-02f,
  6.50295988e-02f, 6.08968176e-03f, 3.08222622e-02f, 1.91751234e-02f, 1.40085807e-02f, 2.88350377e-02f, 7.76494145e-02f, 4.22864445e-02f, 3.41685265e-02f, -1.95148233e-02f,
  -1.08084418e-01f, 7.62478486e-02f, 1.36128040e-02f, -3.20489146e-02f, -2.06117562e-04f, -3.76313366e-02f, -3.69013101e-02f, -5.06849103e-02f, 1.41791003e-02f, 5.55396918e-03f,
  1.50768450e-02f, -4.78149317e-02f, -1.08587723e-02f, 1.03984588e-04f, -3.38671874e-04f, 3.07648629e-02f, 9.56380144e-02f, -4.05650996e-02f, -7.97126070e-02f, 7.23449886e-02f,
  3.45334900e-03f, -6.22717012e-03f, -2.33322736e-02f, -2.12584883e-02f, -3.44840959e-02f, -7.87044689e-03f, -8.10688436e-02f, 2.84173600e-02f, 9.41701159e-02f, -3.50745115e-03f,
  7.89658055e-02f, -3.33353169e-02f, -1.17409959e-01f, 1.25899464e-01f, 2.12125212e-01f, -1.62958801e-01f, 1.86582096e-02f, 1.41345367e-01f, -1.38592929e-01f, 1.27336457e-01f,
  1.62208781e-01f, -2.31011882e-01f, -2.35223733e-02f, 1.31765738e-01f, -2.73359329e-01f, -2.88263351e-01f, 1.77459344e-02f, -5.61664030e-02f, -1.86660022e-01f, 1.93517923e-01f,
  -6.64200485e-02f, 2.82156885e-01f, -4.56778668e-02f, 1.30594864e-01f, 3.01583260e-01f, 1.59454513e-02f, 2.81625599e-01f, -3.43798939e-03f, 1.50987893e-01f, -1.36427945e-02f,
  -1.37563005e-01f, 2.10575815e-02f, 6.59064874e-02f, -7.99531266e-02f, 2.32028794e-02f, 5.83724156e-02f, -1.31737646e-02f, 4.21348065e-02f, -5.60404882e-02f, -2.11675595e-02f,
  4.25106809e-02f, 2.25065518e-02f, -1.27717508e-02f, 4.35879193e-02f, -6.96075941e-03f, 5.10248803e-02f, -5.94672561e-02f, 3.62865776e-02f, 2.51953062e-02f, -3.29972878e-02f,
  1.39391953e-02f, -2.71254070e-02f, 3.19821909e-02f, -5.85914217e-02f, -7.53349951e-03f, -3.03144399e-02f, -7.66532943e-02f, 3.78168747e-02f, -3.59364972e-02f, -7.80954286e-02f,
  2.77861916e-02f, 5.38051827e-03f, 6.48282543e-02f, 1.69661567e-02f, -1.41175352e-02f, 7.19978362e-02f, -2.47720759e-02f, 5.59321232e-02f, -4.78681624e-02f, 4.78956588e-02f,
  8.34351219e-03f, 4.43048850e-02f, 2.65844725e-02f, 4.04068343e-02f, 3.47282179e-02f, -4.36025625e-03f, 1.14349294e-02f, 4.60966229e-02f, -5.52802486e-03f, -6.69484437e-02f,
  8.10085982e-02f, -5.37721440e-02f, 1.21341310e-02f, -5.44825103e-03f, -1.51896393e-02f, 4.36690561e-02f, 7.36959875e-02f, 1.32253366e-02f, 5.93288951e-02f, 7.49180689e-02f,
  -5.92733100e-02f, 1.12133838e-01f, -2.78753061e-02f, -5.10419197e-02f, -4.56709974e-03f, 4.02077623e-02f, -6.54366091e-02f, -8.05711672e-02f, -4.35527712e-02f, 2.63635814e-02f,
  1.21091632e-02f, -3.40871178e-02f, -4.12071608e-02f, -4.11331467e-02f, -5.00117019e-02f, -5.11176838e-03f, 6.10389672e-02f, -5.75842783e-02f, 4.95061614e-02f, 2.89033521e-02f,
  4.81026918e-02f, 5.44028431e-02f, -2.44197808e-02f, 8.33960902e-03f, -1.70971081e-02f, 3.33215296e-02f, 1.14364934e-03f, -6.19627386e-02f, 9.62201506e-03f, -2.15252843e-02f,
  -1.78533807e-01f, -1.02696441e-01f, -3.42386693e-01f, -2.90624201e-01f, 9.10336059e-03f, 2.53485650e-01f, -4.28019203e-02f, -1.30779192e-01f, -3.35494548e-01f, 2.52799839e-01f,
  2.86707357e-02f, -1.24441877e-01f, -8.25834051e-02f, 1.13751970e-01f, 1.34780332e-01f, 4.64693317e-03f, 2.07733154e-01f, 1.48427755e-01f, -2.07956403e-01f, -1.34609252e-01f,
  -1.09404229e-01f, 1.98046744e-01f, -1.01372957e-01f, 1.40656754e-01f, 3.35760191e-02f, -1.19437419e-01f, 4.71097343e-02f, -1.38418600e-01f, 2.32268095e-01f, 9.32011306e-02f,
  -1.90348215e-02f, -1.41312689e-01f, -1.19502500e-01f, 1.58719346e-02f, 5.43074906e-02f, 7.99136683e-02f, 8.66373777e-02f, -5.64904884e-02f, -7.20621720e-02f, -7.72648230e-02f,
  3.13702114e-02f, -2.87589189e-02f, 5.96291982e-02f, 1.55975185e-02f, -6.25587255e-02f, -2.39224383e-03f, -6.83787242e-02f, -1.82286631e-02f, -7.98450559e-02f, -3.28230374e-02f,
  -5.20032905e-02f, 4.32006344e-02f, -6.29400685e-02f, 6.39020726e-02f, 9.74769425e-03f, -4.06071022e-02f, 3.35797183e-02f, 4.36488725e-02f, 2.75861565e-02f, -2.30470542e-02f,
  1.33045033e-01f, 4.41883206e-02f, -1.75462756e-02f, -5.62086552e-02f, 1.07657248e-02f, -1.10428631e-02f, 4.44119424e-02f, 9.11614299e-02f, -1.67582687e-02f, 2.20532399e-02f,
  -8.29054788e-02f, -6.09838367e-02f, -1.14581576e-02f, 3.03483680e-02f, -2.34432258e-02f, 3.59864794e-02f, 2.12498568e-02f, 1.66992694e-02f, 2.29363795e-03f, -4.71553728e-02f,
  -6.79939240e-02f, 2.59012282e-02f, 2.97670178e-02f, 7.49791339e-02f, 2.70870496e-02f, -5.25986850e-02f, 5.46404608e-02f, -1.44197568e-02f, -1.15866889e-03f, 3.96749377e-02f,
  1.49825305e-01f, 2.61111502e-02f, -3.06248460e-02f, 8.73670913e-03f, 4.28871140e-02f, 6.72204569e-02f, -4.41543385e-03f, 3.19824032e-02f, -1.73710361e-02f, 2.80576516e-02f,
  4.04345691e-02f, 3.70105579e-02f, -3.99981961e-02f, 2.94913091e-02f, 4.01298068e-02f, 2.74153873e-02f, 3.45163494e-02f, 5.52036539e-02f, 1.81861948e-02f, 5.37444055e-02f,
  3.61778401e-02f, -7.79714156e-03f, -2.94138175e-02f, 1.39715867e-02f, 4.49214764e-02f, 3.57248485e-02f, 8.39345064e-03f, 4.57914509e-02f, 8.68080631e-02f, -3.01203169e-02f,
  6.70468360e-02f, -4.00842249e-01f, -1.77853048e-01f, 1.43117696e-01f, 2.59157419e-01f, -2.08155648e-03f, -2.65244190e-02f, 6.65133893e-02f, -2.14489445e-01f, -2.05897704e-01f,
  2.80451983e-01f, -2.80633062e-01f, -9.08692703e-02f, 3.26402229e-03f, 3.37091446e-01f, -1.85057908e-01f, 6.26026317e-02f, -1.82855241e-02f, -8.06349516e-02f, 9.92211998e-02f,
  1.17155902e-01f, 3.23464274e-01f, 8.83569866e-02f, 1.57287300e-01f, 1.08108111e-01f, -2.88006943e-02f, 2.50812620e-01f, 4.76249084e-02f, 1.32780060e-01f, 7.41089433e-02f,
  -3.30639593e-02f, 4.91823535e-04f, -2.24937759e-02f, -5.34461960e-02f, 6.24131523e-02f, 8.12859312e-02f, 1.81735549e-02f, 3.83848771e-02f, 2.52632350e-02f, -7.23367482e-02f,
  -5.70513122e-02f, 2.57542450e-02f, -2.03289874e-02f, -2.87030265e-02f, 6.72453195e-02f, -5.16043305e-02f, 2.69061740e-04f, 4.82630916e-03f, -4.59459089e-02f, -9.96491592e-03f,
  -9.37177837e-02f, -4.77722064e-02f, 7.22338557e-02f, 5.68375643e-03f, 2.75315456e-02f, 1.31261330e-02f, -2.35885214e-02f, -2.93481309e-04f, -7.24839568e-02f, 7.17562996e-03f,
  7.38720149e-02f, 1.11196199e-02f, -1.11280177e-02f, -4.47182208e-02f, 4.73812930e-02f, 1.18944515e-02f, 4.44753878e-02f, 2.04678401e-02f, 1.78555548e-02f, 2.19037030e-02f,
  1.35247288e-02f, -2.66447005e-05f, 2.44414397e-02f, 1.41850235e-02f, 3.58911715e-02f, -3.94224897e-02f, 5.22564352e-02f, -1.81758348e-02f, -2.76094377e-02f, 3.96265537e-02f,
  -4.22778204e-02f, 5.64488769e-02f, -3.38463895e-02f, 3.01675685e-02f, -1.13074128e-02f, 1.33118324e-03f, 1.49780912e-02f, -3.33272479e-02f, -1.26712630e-02f, 5.27890772e-02f,
  5.66500537e-02f, -1.10035520e-02f, -1.99166872e-02f, -4.59638936e-03f, -7.57269263e-02f, 4.22541387e-02f, -1.91829205e-02f, -4.91006263e-02f, 3.53484601e-02f, 1.79238170e-02f,
  6.73591718e-02f, 1.19023006e-02f, -6.97831810e-03f, 5.75259477e-02f, 3.20686772e-02f, 3.12155224e-02f, 5.48019968e-02f, 8.42313096e-03f, 9.89197865e-02f, 5.32083213e-02f,
  8.75931308e-02f, 4.69231606e-02f, -3.50512378e-02f, 2.54299454e-02f, 7.53286332e-02f, -4.81869979e-03f, -1.88787456e-03f, -3.16644795e-02f, 8.06445926e-02f, -6.93284869e-02f,
  4.28652763e-01f, -3.35249007e-01f, -1.85923323e-01f, 3.88203323e-01f, 6.00501783e-02f, -5.06292284e-03f, 1.12257637e-02f, 6.28438443e-02f, 1.05910338e-01f, -1.66635975e-01f,
  2.19115645e-01f, -1.21919550e-01f, -1.41904220e-01f, 8.51336047e-02f, 2.90692210e-01f, -3.10639199e-02f, 1.55017197e-01f, 5.15282005e-02f, -5.84927090e-02f, 4.60301600e-02f,
  1.73926935e-01f, 2.50221461e-01f, -5.07812612e-02f, -7.52677247e-02f, 9.60262418e-02f, -7.48530626e-02f, 1.68574780e-01f, -1.86744258e-01f, 3.85721289e-02f, -1.25833750e-02f,
  1.12482786e-01f, 1.33123755e-01f, -2.40293536e-02f, -8.61528218e-02f, -1.61369145e-02f, -7.16664642e-02f, -1.86992846e-02f, -2.10118741e-02f, -6.23619324e-03f, 8.61683395e-03f,
  -7.56196007e-02f, -2.72604376e-02f, -3.71908094e-03f, 2.99281999e-03f, -6.34806678e-02f, -5.15686236e-02f, -2.13296320e-02f, -2.81207990e-02f, -4.81391549e-02f, -1.50279962e-02f,
  -3.99848334e-02f, -4.34397794e-02f, -2.87943031e-03f, -2.81515587e-02f, 4.21028491e-03f, -6.16695881e-02f, -1.42114572e-02f, 1.91465486e-02f, -9.72605404e-03f, 4.79375646e-02f,
  -1.32754473e-02f, -3.36557953e-03f, -9.65953432e-03f, -3.27043678e-03f, 1.17550036e-02f, 7.76637346e-02f, -2.92930175e-02f, 2.06445977e-02f, -5.81623726e-02f, 2.27596071e-02f,
  5.69686340e-03f, 2.67539266e-02f, 2.13177893e-02f, -4.34720777e-02f, 4.37520705e-02f, 2.68834457e-02f, 1.17668519e-02f, 3.08492165e-02f, -4.35248716e-03f, 2.27689780e-02f,
  -3.46925221e-02f, -1.64119862e-02f, 1.56691615e-02f, 2.66015101e-02f, -2.84767915e-02f, 3.32363844e-02f, 1.54304886e-02f, -2.65743420e-03f, 2.57720035e-02f, 3.42336372e-02f,
  3.63545790e-02f, 1.00871541e-01f, 3.15007493e-02f, 1.19109126e-02f, 1.77999940e-02f, 5.06546684e-02f, 4.24129032e-02f, 1.57178603e-02f, -6.95100278e-02f, 4.36473405e-03f,
  3.04291155e-02f, 2.21063700e-02f, 1.56901143e-02f, -3.48082222e-02f, 2.93367058e-02f, -8.35923385e-03f, 1.79149825e-02f, 5.95629066e-02f, 7.15556890e-02f, 5.52459210e-02f,
  1.99801009e-03f, 1.39673483e-02f, 2.61529647e-02f, 4.59724478e-02f, 1.72754973e-02f, 7.25061744e-02f, 8.27184618e-02f, -3.23427916e-02f, -1.93372946e-02f, -9.01751667e-02f,
  1.31206751e-01f, -2.83527106e-01f, -1.98264256e-01f, 2.48310596e-01f, -4.24946696e-02f, 1.65761828e-01f, 1.11952245e-01f, 5.80213368e-02f, 2.30634212e-01f, -1.72522198e-02f,
  1.27034830e-02f, -4.80289534e-02f, -2.62219399e-01f, 2.70844609e-01f, 6.53366148e-02f, -1.46866098e-01f, 3.39809656e-01f, 8.80964398e-02f, -1.54276285e-02f, -3.83085199e-02f,
  1.05939806e-01f, 1.51761755e-01f, -6.98092133e-02f, 1.09203495e-02f, 8.18068758e-02f, 9.51530645e-04f, -5.09649888e-02f, -2.39691034e-01f, 1.62309080e-01f, -1.24488296e-02f,
  6.78782612e-02f, -5.18608578e-02f, -6.89227693e-03f, 6.46763295e-02f, 1.81956682e-02f, -3.07175815e-02f, 1.88614186e-02f, -1.00053195e-02f, 1.50008700e-05f, 3.95078473e-02f,
  3.47152986e-02f, -2.10654531e-02f, 4.27295603e-02f, 2.41799392e-02f, 8.32111761e-02f, 1.21227568e-02f, -8.69292319e-02f, -6.32898659e-02f, -2.87684258e-02f, -8.03216398e-02f,
  -1.03761191e-02f, -3.43094207e-02f, 2.32454091e-02f, 2.92853396e-02f, 2.63615213e-02f, 5.95725849e-02f, -1.50785092e-02f, -7.72679597e-02f, -4.87599410e-02f, 8.02107155e-02f,
  7.58935604e-03f, 6.79069534e-02f, -8.09963513e-03f, 4.71278019e-02f, 8.02094955e-03f, 8.05463176e-03f, -4.10395041e-02f, 1.23762023e-02f, -6.04819693e-02f, 2.65203211e-02f,
  1.32794986e-02f, 1.66830216e-02f, 6.79469109e-02f, 3.44061665e-02f, -8.00673850e-03f, 4.23555188e-02f, -2.42572427e-02f, 7.81784952e-03f, 5.25008030e-02f, 5.02805598e-02f,
  -6.58422187e-02f, 6.18009940e-02f, -3.43957730e-02f, -3.70366424e-02f, 3.96539718e-02f, -1.40209543e-02f, -6.53236406e-03f, -5.37719354e-02f, -1.86594930e-02f, 2.40323110e-03f,
  -2.72718351e-02f, -3.23926583e-02f, -1.36667425e-02f, 3.10672773e-03f, -3.91848795e-02f, 3.88289653e-02f, 1.19842729e-02f, -1.99346598e-02f, 9.98953208e-02f, -7.48943910e-03f,
  4.55782898e-02f, 5.08308485e-02f, 7.85742924e-02f, -7.27930106e-03f, -1.51654461e-03f, 1.51070068e-02f, 4.03069593e-02f, 5.43580540e-02f, -2.47621583e-03f, -3.81920487e-02f,
  -3.41771208e-02f, -4.50565480e-03f, 1.75065342e-02f, 3.09708752e-02f, -1.03519727e-02f, -4.83757444e-03f, -2.40094326e-02f, 4.04390581e-02f, -2.16737259e-02f, -5.40693244e-03f,
  6.22216582e-01f, -1.70675725e-01f, 1.40717655e-01f, 1.99121073e-01f, 3.37921903e-02f, -4.78185415e-02f, 9.54178646e-02f, 6.44106567e-02f, 3.07074398e-01f, -1.22172482e-01f,
  -1.46607995e-01f, 1.24118894e-01f, -1.06720015e-01f, -1.28002033e-01f, 4.27826233e-02f, -1.71777561e-01f, -2.08732281e-02f, 5.08549251e-02f, 6.47019036e-03f, 2.03495100e-01f,
  1.25839218e-01f, -2.46401906e-01f, -1.00331455e-01f, -2.00930595e-01f, 1.31672874e-01f, 9.53656733e-02f, -1.53516293e-01f, -4.66965288e-02f, -9.78698507e-02f, -1.92141518e-01f,
  4.77737002e-02f, 3.58642220e-01f, 1.06012598e-01f, 7.62264505e-02f, 1.04552239e-01f, 9.81646851e-02f, 5.04688919e-02f, -7.11086020e-02f, 2.51430497e-02f, 1.41619742e-02f,
  4.01092507e-02f, 3.38895805e-02f, 2.72533856e-02f, -4.34903279e-02f, 5.38879782e-02f, 2.80512739e-02f, -4.74853367e-02f, -1.72252022e-02f, 1.58699062e-02f, 3.38633619e-02f,
  5.70928957e-03f, -2.29860898e-02f, 2.09362302e-02f, -3.61342095e-02f, 2.30694581e-02f, -2.14901678e-02f, -7.74460705e-03f, -3.64461429e-02f, 1.11251185e-02f, 2.69084368e-02f,
  5.50232492e-02f, 6.37025237e-02f, -4.98157367e-02f, 1.56841930e-02f, -2.31401995e-02f, -6.97395578e-02f, -2.28311997e-02f, -6.91217259e-02f, -6.80667115e-03f, 1.97546706e-02f,
  2.24696379e-03f, 4.34364118e-02f, 8.46534222e-03f, 3.74970119e-03f, 2.61574537e-02f, 3.39447707e-02f, 6.06698589e-03f, 1.93335267e-03f, 3.83866392e-02f, 3.50285135e-03f,
  -9.31885187e-03f, 3.48499976e-02f, -1.35543104e-02f, 2.50114445e-02f, -4.54729199e-02f, -2.56501120e-02f, -2.58857645e-02f, 4.67726728e-04f, -3.63876447e-02f, -1.33643718e-02f,
  8.09218362e-02f, 1.45203039e-01f, -7.04148263e-02f, -1.31864371e-02f, -1.53495803e-01f, -4.70321439e-02f, -5.28461486e-02f, 1.60757117e-02f, -4.56166714e-02f, 2.90640108e-02f,
  2.33689863e-02f, 7.55673414e-03f, -1.98534913e-02f, -2.18843259e-02f, -4.98328581e-02f, -8.56400561e-03f, -2.35607792e-02f, 4.94477293e-03f, 9.57897864e-03f, -6.31036460e-02f,
  8.13133828e-03f, 4.28399816e-02f, -3.28310989e-02f, 3.08344290e-02f, -1.62694231e-02f, 5.59386332e-03f, 2.73819659e-02f, 4.38764021e-02f, -3.69273163e-02f, -1.09816035e-02f,
  3.18572782e-02f, -2.63589352e-01f, 1.46543518e-01f, -1.32833468e-02f, 2.45482340e-01f, 2.56874025e-01f, -1.86887830e-02f, 1.38402730e-02f, 6.36919402e-03f, -2.62971491e-01f,
  -1.73321426e-01f, -1.35547474e-01f, -2.71263838e-01f, -1.57235593e-01f, 6.26154542e-02f, -2.55963862e-01f, 6.41169958e-03f, -8.21386129e-02f, 2.77753957e-02f, 3.53515558e-02f,
  7.83369914e-02f, -2.02772126e-01f, -7.98561797e-02f, 8.67329314e-02f, 8.50912184e-02f, 8.43789056e-02f, -1.71398580e-01f, 7.45469034e-02f, -5.04785925e-02f, -5.96377114e-03f,
  1.18580915e-01f, -5.35613075e-02f, 3.92694585e-02f, 1.31006716e-02f, 5.37320487e-02f, 8.15820396e-02f, 4.59165052e-02f, 9.30692535e-03f, 3.89487296e-02f, 8.02123453e-03f,
  -2.94354595e-02f, 1.69328302e-02f, -2.44760495e-02f, 9.57080536e-03f, 3.70688029e-02f, 2.68008336e-02f, 2.64760144e-02f, 4.26229201e-02f, 1.97017263e-03f, 5.65357096e-02f,
  7.05874115e-02f, 6.15220964e-02f, 5.58959767e-02f, -6.25644252e-02f, 4.41467164e-05f, 2.18983497e-02f, -1.51828360e-02f, -1.23719312e-02f, -5.84009150e-03f, 2.83982027e-02f,
  -1.28884679e-02f, -1.74273495e-02f, 1.57008674e-02f, 4.73378738e-03f, 4.91994321e-02f, 4.02319320e-02f, -6.98738173e-03f, 3.16676684e-02f, -2.21012663e-02f, 3.17569710e-02f,
  5.03569283e-02f, -3.16268280e-02f, 3.38366367e-02f, 2.89989244e-02f, -4.90536354e-02f, 1.13863749e-02f, -3.47337686e-03f, -5.52831814e-02f, 3.80675271e-02f, -8.05432908e-03f,
  -2.78205983e-02f, 4.53597382e-02f, -4.09294590e-02f, 2.85540894e-02f, -9.43494681e-03f, 1.03731258e-02f, -2.12230012e-02f, 3.58869284e-02f, 1.99909713e-02f, 3.08199823e-02f,
  -8.35717097e-02f, -3.14481139e-01f, -5.36504947e-02f, -6.48227800e-03f, 1.87541824e-02f, -5.01922257e-02f, -2.68846401e-03f, 4.87115234e-02f, -5.33880182e-02f, -2.54626144e-02f,
  -2.30392651e-03f, 2.40366329e-02f, 4.07125875e-02f, 6.39945851e-04f, 4.18551676e-02f, -7.51927793e-02f, -8.47634599e-02f, -2.00540926e-02f, -6.00270415e-03f, -5.95530346e-02f,
  -1.54120866e-02f, 1.69010796e-02f, 2.82333493e-02f, 3.01278178e-02f, 3.48640904e-02f, -1.54558914e-02f, 2.68063298e-03f, 3.61157544e-02f, -3.22890617e-02f, -2.66830511e-02f,
  1.17915338e-02f, 3.94450352e-02f, 3.05352211e-01f, 2.01041073e-01f, -2.58419424e-01f, -3.70349646e-01f, -1.00376941e-01f, -1.06660195e-01f, 2.01686732e-02f, 1.33209256e-02f,
  -1.14057519e-01f, 2.40911856e-01f, 1.44067958e-01f, 1.22192457e-01f, 1.07561782e-01f, 2.40953654e-01f, -2.69193035e-02f, 1.70766357e-02f, -3.95365134e-02f, -2.00541150e-02f,
  -5.78394122e-02f, -8.23049918e-02f, 2.25430921e-01f, -1.42742395e-01f, -8.68761241e-02f, 2.60624383e-02f, -2.88156010e-02f, -2.48350445e-02f, -9.30110272e-03f, -4.04466912e-02f,
  -1.47391811e-01f, 1.40610814e-01f, 1.52185619e-01f, -5.75943142e-02f, -3.21221389e-02f, -1.83659848e-02f, 1.96743216e-02f, 4.24753539e-02f, 2.61819512e-02f, -3.50849181e-02f,
  2.00644620e-02f, -1.76450773e-03f, 3.34215090e-02f, 1.09072544e-01f, -6.72102347e-02f, 4.72144186e-02f, 2.68351510e-02f, -2.09363867e-02f, 9.64255352e-03f, 3.01042590e-02f,
  1.20170027e-01f, 1.69658083e-02f, 3.99239920e-02f, 4.06280607e-02f, 1.05015021e-02f, -1.75343566e-02f, 2.88450741e-04f, 8.71903524e-02f, -8.15634523e-03f, -6.38747290e-02f,
  -4.72108796e-02f, -4.68101278e-02f, 5.40626571e-02f, 2.37218626e-02f, -1.55815817e-02f, -3.28307524e-02f, 1.70546211e-02f, -8.71108286e-03f, 6.01668749e-03f, 1.46821346e-02f,
  -2.27251276e-02f, 1.23284198e-03f, -3.05093341e-02f, 9.62596852e-03f, 4.88367304e-03f, 2.52257083e-02f, 3.34221609e-02f, -2.67556999e-02f, 1.88655928e-02f, -1.46231549e-02f,
  1.86035025e-03f, -1.93854906e-02f, 4.72908951e-02f, -1.00497622e-03f, 2.17786878e-02f, 6.99526491e-03f, 2.12820489e-02f, 1.05337419e-01f, -1.30123394e-02f, -3.21326219e-02f,
  -2.94000804e-01f, -1.56359211e-01f, -6.37093782e-02f, -2.10184846e-02f, -2.01967489e-02f, -1.06293531e-02f, -1.56920205e-03f, 4.71833199e-02f, -4.49308045e-02f, -2.73559187e-02f,
  -3.42971012e-02f, -4.37657759e-02f, -1.26771063e-01f, -1.83056872e-02f, 4.59224656e-02f, 3.59591804e-02f, -4.45923842e-02f, -2.87479144e-02f, -1.08087562e-01f, -5.66301234e-02f,
  -3.71257998e-02f, -5.98413907e-02f, 6.02171086e-02f, -5.67167215e-02f, 2.15824675e-02f, -1.91644747e-02f, -6.41797706e-02f, 2.38497294e-02f, -8.65401328e-03f, 1.32055078e-02f,
  1.34069309e-01f, 8.85095224e-02f, -1.08329214e-01f, 1.48193063e-02f, -1.77940443e-01f, -2.27075666e-01f, -3.12411875e-01f, -2.81322398e-04f, -7.60380775e-02f, 1.96606100e-01f,
  -1.42175658e-02f, 4.22955751e-02f, -2.33535692e-02f, -1.22639738e-01f, -3.40433687e-01f, -1.37159824e-01f, -1.80666193e-01f, -1.38899878e-01f, -1.62192583e-02f, 9.81980860e-02f,
  1.90208573e-02f, 3.25719304e-02f, -9.40289497e-02f, 7.56238177e-02f, -5.21117486e-02f, 2.41679430e-01f, 1.61627620e-01f, -3.36045697e-02f, 8.28657523e-02f, -1.21012963e-01f,
  7.97873437e-02f, 1.33111343e-01f, -5.72003536e-02f, 4.30579744e-02f, -4.09129336e-02f, 3.35906819e-02f, -1.55162346e-02f, -7.76506588e-02f, -3.91046070e-02f, 4.54736454e-03f,
  1.91663075e-02f, 3.95183489e-02f, -1.61337517e-02f, -6.20626621e-02f, 1.59375574e-02f, 2.11469433e-03f, 5.07728802e-03f, -6.01430461e-02f, -8.91989155e-04f, -1.04632862e-01f,
  -1.37591315e-02f, 1.96010995e-04f, 2.14248914e-02f, 1.11952331e-02f, -6.95350841e-02f, -7.78095983e-03f, -2.98004057e-02f, -1.62685458e-02f, 6.58503175e-02f, -7.69132376e-02f,
  2.87475269e-02f, -1.29246758e-02f, -2.25980096e-02f, -8.90914630e-03f, -3.09028220e-03f, 6.22884370e-02f, -1.30914347e-02f, -5.17754443e-03f, -6.83883030e-04f, -2.20263358e-02f,
  -4.78903130e-02f, 1.99568216e-02f, 4.31057140e-02f, 1.86782405e-02f, 1.18623693e-02f, 3.11370846e-02f, 4.26937779e-03f, 3.64048555e-02f, 1.96508821e-02f, -4.69396040e-02f,
  5.54459617e-02f, 9.90962260e-04f, 6.53845444e-03f, 1.80873238e-02f, -2.62949746e-02f, -1.46979392e-02f, 7.57631958e-02f, 1.47596607e-02f, -2.49335617e-02f, -4.62795831e-02f,
  1.01140514e-01f, 3.18938643e-01f, 2.18335930e-02f, 9.55777057e-03f, 3.78796645e-02f, -2.04218216e-02f, -2.45729126e-02f, -7.35298637e-03f, 7.73989409e-02f, 2.96871737e-02f,
  1.92520989e-03f, -2.07477044e-02f, 2.75102500e-02f, 2.95100380e-02f, 3.91476750e-02f, -1.41071975e-02f, 5.08523621e-02f, 7.14743882e-02f, -1.74265611e-03f, 1.05565935e-01f,
  9.65035856e-02f, 5.70771322e-02f, -4.54316549e-02f, 4.35699103e-03f, 2.62247454e-02f, 1.54696880e-02f, 4.48414236e-02f, -3.92231271e-02f, 1.63766133e-04f, -2.50995229e-03f,
  4.91137713e-01f, -2.76048511e-01f, 7.01447576e-02f, 1.87124521e-01f, -4.34546806e-02f, 1.19529933e-01f, 1.32168368e-01f, -1.04600370e-01f, 2.37805828e-01f, -3.59118909e-01f,
  -7.69081563e-02f, 1.39396608e-01f, -6.57433942e-02f, -1.36764301e-02f, 6.62174821e-01f, 1.77453622e-01f, 1.50658190e-01f, 2.04811133e-02f, 9.86626372e-02f, 2.32170355e-02f,
  1.40370071e-01f, -5.85078374e-02f, -1.88241564e-02f, -1.96034148e-01f, -1.02201171e-01f, -1.19421355e-01f, -8.14556479e-02f, -1.00299612e-01f, -1.19652174e-01f, 5.35428412e-02f,
  -2.49906424e-02f, -7.54584596e-02f, -2.25550793e-02f, 8.38315394e-03f, 2.40385234e-02f, -4.28220704e-02f, -2.80628167e-02f, 5.26525304e-02f, 3.17278109e-03f, 2.95470022e-02f,
  2.80922167e-02f, 2.72200722e-02f, 4.99247722e-02f, 4.82570101e-03f, -1.86536387e-02f, -1.12714795e-02f, 2.45626010e-02f, -2.74496190e-02f, -9.20096412e-03f, -1.97875090e-02f,
  -2.55047735e-02f, -4.24206406e-02f, -3.88286775e-03f, 9.22504463e-04f, 7.46340584e-03f, 3.15146148e-02f, 1.72211267e-02f, 1.43563543e-02f, 4.71556298e-02f, 7.51599595e-02f,
  1.20148147e-02f, 2.66320109e-02f, -1.51520930e-02f, -4.07075137e-02f, 2.68845260e-02f, -4.30002809e-02f, 1.11236293e-02f, -2.66272202e-02f, 3.54716033e-02f, 5.57746133e-03f,
  4.99326503e-03f, 9.94626153e-03f, -3.49021778e-02f, -2.34698523e-02f, -1.41464863e-02f, 2.08712555e-03f, 8.75848532e-03f, -2.65558288e-02f, 1.02764722e-02f, 2.45216526e-02f,
  -4.10086587e-02f, 4.66986187e-02f, -6.87335953e-02f, -8.26373976e-03f, -2.56109908e-02f, 3.31233777e-02f, -4.23031151e-02f, -1.68016646e-02f, -3.03694252e-02f, 6.84488490e-02f,
  4.12841775e-02f, -1.54850995e-02f, -7.04433843e-02f, -5.22073917e-02f, -4.56224419e-02f, -1.79164950e-02f, 6.28855228e-02f, 5.43277292e-03f, 3.98239121e-02f, 2.38478817e-02f,
  -3.40674445e-02f, -3.32578644e-02f, -4.03097756e-02f, 3.09066717e-02f, 1.81187391e-02f, 6.81081554e-03f, -3.64601128e-02f, -2.14037690e-02f, 1.14006400e-02f, -6.63956115e-03f,
  -2.76080482e-02f, 1.81987565e-02f, 4.78829518e-02f, -8.20330158e-03f, -7.86988251e-03f, -4.59647812e-02f, 1.07012233e-02f, -1.16289714e-02f, -2.50163451e-02f, -2.04775929e-02f,
  -3.85294110e-01f, -3.19674283e-01f, -1.81525096e-01f, -3.45444173e-01f, 2.70344540e-02f, 1.54457912e-01f, 7.69816712e-02f, -1.19105421e-01f, -2.58952677e-01f, 8.43442008e-02f,
  8.68602991e-02f, -3.60440403e-01f, 1.85146600e-01f, -2.63646334e-01f, 8.44715685e-02f, 9.94685963e-02f, -4.52436917e-02f, 1.14004416e-02f, -7.37540945e-02f, -1.31712332e-01f,
  -4.04522792e-02f, -4.73461561e-02f, 7.24071860e-02f, -1.13898337e-01f, -1.55859694e-01f, -1.81100816e-01f, 1.67505458e-01f, 5.69265452e-04f, -6.10536672e-02f, -2.89546456e-02f,
  7.47235045e-02f, -1.74010813e-01f, -6.25918731e-02f, -6.26399890e-02f, 6.31796420e-02f, 1.75711084e-02f, 3.20439935e-02f, 7.39547005e-03f, -2.13447791e-02f, -3.13130533e-03f,
  -7.87645355e-02f, 1.85723230e-02f, -5.68767935e-02f, -2.01037107e-03f, -2.53010727e-02f, -9.87004489e-02f, -1.33786863e-02f, 5.83380535e-02f, -9.38608274e-02f, -7.27970945e-03f,
  9.38412640e-03f, 2.05999073e-02f, 1.45090222e-02f, 6.65337294e-02f, 7.27630965e-03f, 4.96014208e-03f, 5.87994233e-02f, 5.38578108e-02f, 3.28933112e-02f, -3.07315961e-02f,
  2.32315194e-02f, 4.11872659e-03f, 3.70999984e-03f, -2.15261318e-02f, -9.91152413e-03f, -6.89296890e-03f, 4.33654748e-02f, 3.12033352e-02f, -1.15928799e-02f, 5.09322099e-02f,
  -1.57761406e-02f, -4.53661010e-02f, -3.84024251e-03f, 1.53394109e-02f, 1.94320455e-02f, -2.33932026e-03f, 1.96217448e-02f, -5.00732921e-02f, 6.89977184e-02f, 8.18642229e-03f,
  3.08224987e-02f, -1.74365211e-02f, -3.43001671e-02f, 8.89171138e-02f, 5.37409522e-02f, 4.69058417e-02f, -4.30972315e-02f, -2.84815747e-02f, -7.23564206e-03f, 4.33079265e-02f,
  1.12599112e-01f, -2.63786744e-02f, -3.34642716e-02f, 7.12156072e-02f, -2.19767038e-02f, 9.99230333e-03f, 2.27423832e-02f, -5.56552857e-02f, -2.43857633e-02f, -3.51813398e-02f,
  9.71937478e-02f, -3.65891657e-03f, 1.75034087e-02f, -4.13672514e-02f, -3.21370848e-02f, 8.09578970e-02f, 7.12794764e-03f, -3.12348381e-02f, 5.76613136e-02f, 4.29908419e-03f,
  -5.33463340e-03f, 6.32751361e-03f, 6.93054125e-02f, 7.11253518e-03f, 3.93508561e-02f, 8.38147029e-02f, -9.92035419e-02f, -3.06091662e-02f, 1.64410975e-02f, 1.58417094e-02f,
  4.88403946e-01f, -1.84021294e-01f, 2.11521059e-01f, 5.14794588e-02f, 2.49434665e-01f, 1.43534705e-01f, -1.03321284e-01f, 8.48371536e-02f, 5.15154079e-02f, -2.17997447e-01f,
  -1.60571396e-01f, 1.09643981e-01f, -2.70843118e-01f, -1.06972292e-01f, -2.31293365e-02f, -3.09509099e-01f, -1.68740958e-01f, -2.71892250e-02f, -2.63974406e-02f, 8.68945196e-02f,
  6.94651669e-03f, -1.77443877e-01f, -9.80895013e-02f, -9.50686485e-02f, 1.40196055e-01f, 1.09578848e-01f, -2.04500765e-01f, -7.33381808e-02f, -7.35579757e-03f, -2.06822697e-02f,
  2.83502955e-02f, -4.03902456e-02f, -9.76962317e-03f, 5.89094162e-02f, -6.03845716e-02f, 3.82044800e-02f, -5.87833230e-04f, 2.43539140e-02f, 8.40401873e-02f, 3.18790949e-03f,
  3.43006402e-02f, 6.82625622e-02f, 1.88618358e-02f, 2.66450495e-02f, 1.12900078e-01f, 6.39641732e-02f, 6.09855354e-02f, 9.18881521e-02f, 1.83468945e-02f, 5.06022051e-02f,
  4.48537767e-02f, 4.72968929e-02f, 6.61466494e-02f, 9.00923088e-03f, 5.91548868e-02f, 7.50116492e-03f, -2.31985524e-02f, -3.43693830e-02f, 7.95695931e-03f, -2.33787801e-02f,
  8.60835367e-04f, -5.66613935e-02f, 3.87326144e-02f, 1.81487873e-02f, 4.04383466e-02f, -2.88156569e-02f, 4.64545488e-02f, -4.65091830e-03f, 7.80747905e-02f, -1.67877078e-02f,
  4.81726155e-02f, 3.41695212e-02f, 2.21712403e-02f, 4.73020449e-02f, -9.66965500e-03f, 3.33592258e-02f, -1.38755393e-04f, 3.06927934e-02f, -3.25072482e-02f, 3.63480821e-02f,
  2.77288083e-04f, 1.69894041e-03f, -1.33946929e-02f, -1.50882052e-02f, 2.79407464e-02f, -6.87499791e-02f, 1.41679291e-02f, 3.21583413e-02f, 1.69592500e-02f, -3.67628150e-02f,
  -1.03750810e-01f, -2.23888218e-01f, -4.21829224e-02f, 3.26778814e-02f, -2.73471978e-02f, 3.06430329e-02f, -3.02267596e-02f, -2.34300198e-04f, -8.55022892e-02f, 1.60833411e-02f,
  1.53826959e-02f, 4.72760834e-02f, 1.10887503e-02f, 2.01182924e-02f, -1.09547682e-01f, -2.59808730e-02f, -2.13797968e-02f, -6.00549579e-02f, -8.24728683e-02f, 2.59078592e-02f,
  -4.56000753e-02f, 2.77488362e-02f, -7.39303008e-02f, 2.25841757e-02f, -5.34802582e-03f, -1.70339812e-02f, 3.84626314e-02f, -1.71799604e-02f, 2.23994050e-02f, -4.05846126e-02f,
  -2.24540234e-01f, -1.85628533e-01f, 1.40922263e-01f, -1.03464223e-01f, -7.29708970e-02f, 8.97673741e-02f, 2.80552387e-01f, -2.08555385e-01f, -1.24623254e-01f, -6.11552782e-02f,
  -4.14827168e-02f, -6.93137944e-03f, 1.51736081e-01f, 4.04502116e-02f, -3.93753797e-02f, 5.87041266e-02f, -6.88735992e-02f, -9.99113917e-03f, -5.61734848e-02f, -1.74406528e-01f,
  -1.22653477e-01f, -1.25470638e-01f, 2.45639935e-01f, -1.33580118e-01f, 2.31393427e-03f, -4.20879535e-02f, -1.17818527e-01f, 1.13324180e-01f, -7.81456381e-02f, 4.03495729e-02f,
  -3.49340169e-03f, -1.63836822e-01f, 1.06828928e-01f, 1.13892518e-02f, -4.73454036e-02f, 6.97710225e-03f, 3.72861251e-02f, 1.30842075e-01f, 1.75885838e-02f, 5.83547726e-02f,
  9.53466073e-03f, -2.08511222e-02f, -3.58487293e-02f, 4.45949547e-02f, -6.91873534e-03f, -1.49329035e-02f, 2.47798022e-02f, -2.48454325e-02f, 1.86307933e-02f, -4.52512130e-03f,
  7.92632774e-02f, -4.86948304e-02f, 3.34593728e-02f, 4.88421284e-02f, -6.61563948e-02f, 2.49043815e-02f, 3.85699496e-02f, 7.23877698e-02f, -3.72034796e-02f, -1.41088981e-02f,
  -1.87657704e-03f, 2.85396688e-02f, -1.27490507e-02f, 1.39953410e-02f, -1.40000014e-02f, 2.91002057e-02f, -3.56331728e-02f, 1.99493188e-02f, 2.52251234e-02f, -1.05672227e-02f,
  -3.73272449e-02f, -1.49410004e-02f, -6.31560385e-03f, -7.97838904e-03f, 3.36922295e-02f, 3.16564366e-03f, 4.79340255e-02f, -2.05602124e-02f, 1.06407385e-02f, 2.24471837e-02f,
  5.59940077e-02f, -3.35496105e-02f, 3.06956507e-02f, 2.97445226e-02f, -9.05886106e-03f, 3.92875560e-02f, -7.48871714e-02f, -4.72673997e-02f, 1.45006590e-02f, 3.84954363e-02f,
  -3.36498916e-01f, -4.50098097e-01f, -1.64228812e-04f, 7.88030867e-03f, 3.72145139e-02f, -2.00136751e-02f, -6.63519744e-03f, -2.20011547e-02f, -4.22218069e-02f, -5.48320971e-02f,
  -2.52935961e-02f, 3.93931046e-02f, -7.80085772e-02f, -2.69753002e-02f, -2.25180797e-02f, -7.44773149e-02f, -3.79716940e-02f, -1.47121144e-03f, -4.21567187e-02f, -2.47322153e-02f,
  -2.72190124e-02f, 3.43625061e-02f, 1.96636701e-03f, -5.11951111e-02f, 1.78403175e-03f, 6.20760676e-03f, -4.28198613e-02f, -2.11159773e-02f, -3.42484936e-02f, -2.29854602e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.09209213e-02f, -3.64282914e-03f, -1.63364321e-01f, 4.38275747e-02f, 1.40121102e-01f, -1.34548858e-01f, -9.96050462e-02f, 1.65347993e-01f, 1.41635522e-01f, -9.22595486e-02f,
  9.53539684e-02f, -1.54956222e-01f, -5.68239205e-02f, -1.22717723e-01f, -1.79002121e-01f, 3.67415417e-03f, -1.68223172e-01f, -1.41498014e-01f, 2.69597899e-02f, -7.36916661e-02f,
  -4.81725410e-02f, 2.97913654e-03f, -1.73346058e-01f, -3.93804871e-02f, -5.71568385e-02f, 2.26075351e-02f, -7.36239403e-02f, 1.35783702e-01f, -2.14425206e-01f, -7.51600638e-02f,
  -1.09321356e-01f, 1.35169685e-01f, -2.68115848e-02f, -6.30438374e-03f, -6.01893216e-02f, 2.87512392e-02f, -6.59718290e-02f, -3.86888571e-02f, -7.08104437e-03f, 9.07874182e-02f,
  -9.64679122e-02f, 8.63387510e-02f, -4.94299494e-02f, 4.75804955e-02f, 9.79717374e-02f, -3.56591530e-02f, 5.77969216e-02f, -5.64271286e-02f, -7.25699887e-02f, -9.60893482e-02f,
  -3.83243933e-02f, -1.20899081e-01f, -2.59104185e-02f, -8.71227682e-02f, -2.30657011e-02f, 4.62241359e-02f, -8.21256414e-02f, -3.67943607e-02f, -9.84101295e-02f, -1.53475292e-02f,
  9.96774957e-02f, 7.47175217e-02f, 7.39074796e-02f, 1.32824099e-02f, -5.68309948e-02f, -4.16575409e-02f, 6.76765963e-02f, 4.65946980e-02f, -6.17607757e-02f, -6.97639957e-02f,
  8.33686907e-04f, 2.82281749e-02f, 7.10570998e-03f, -1.84001494e-02f, -3.68692912e-04f, 5.50036170e-02f, 5.64360544e-02f, 7.69785838e-03f, -4.11249027e-02f, -3.63814342e-03f,
  9.06533673e-02f, 7.88358152e-02f, 4.47809175e-02f, -5.74137345e-02f, 2.97395065e-02f, 4.39920910e-02f, 6.13386296e-02f, -1.86434779e-02f, -1.89730003e-02f, 3.90709341e-02f,
  3.44477547e-03f, -8.53540972e-02f, -1.11455759e-02f, 1.49171948e-02f, -6.47040382e-02f, -7.44471997e-02f, -7.45375007e-02f, 5.12699895e-02f, -1.79560240e-02f, -2.51997020e-02f,
  -8.67992118e-02f, -6.87723532e-02f, -1.17294654e-01f, 3.12227979e-02f, 3.51429060e-02f, 6.82860240e-02f, -3.78486933e-04f, -5.22474796e-02f, -7.98793230e-03f, -3.91903371e-02f,
  -5.20459451e-02f, 4.92225438e-02f, 2.13944148e-02f, 8.92710686e-02f, -7.79883191e-02f, -1.30168051e-02f, -4.10021320e-02f, -1.04595274e-01f, -5.97129501e-02f, 1.23431971e-02f,
  7.32357129e-02f, -3.84815261e-02f, -3.93038839e-01f, 7.76081979e-02f, 2.82779732e-03f, 2.17113093e-01f, 1.88261434e-01f, -8.02549124e-02f, -9.52194557e-02f, 1.52335703e-01f,
  3.10801029e-01f, -4.83878106e-02f, 1.94739010e-02f, 4.20591980e-01f, 1.28290638e-01f, 5.67349046e-02f, 2.83307791e-01f, 2.99872339e-01f, -1.27626911e-01f, 1.09712936e-01f,
  3.91571000e-02f, 3.89514536e-01f, -6.49391487e-02f, -7.20408279e-03f, 1.37561753e-01f, -1.68855831e-01f, 3.34620290e-02f, -2.20436454e-01f, 1.24938995e-01f, 8.00513774e-02f,
  1.59539983e-01f, 4.60336395e-02f, -7.42472932e-02f, -3.23661678e-02f, 4.73479368e-02f, 5.73834963e-02f, 3.87296849e-03f, -2.87696272e-02f, -4.40279394e-02f, 3.91418561e-02f,
  -8.91216248e-02f, -4.17253524e-02f, 2.70482916e-02f, -4.59327027e-02f, 2.03356389e-02f, -8.89883265e-02f, -2.49701161e-02f, -5.84270060e-02f, -1.59358676e-03f, 1.61161814e-02f,
  -2.50084442e-03f, 3.76053937e-02f, -1.49206929e-02f, 4.06998135e-02f, -5.01022004e-02f, 4.28660363e-02f, -5.85973561e-02f, -8.25860798e-02f, 1.68502089e-02f, 1.80367869e-03f,
  2.80995667e-02f, -2.44822018e-02f, 3.54155079e-02f, 6.77988008e-02f, -1.76398735e-02f, 6.19558990e-02f, -3.15183774e-02f, -2.86149848e-02f, -1.01294920e-01f, -9.14672576e-03f,
  -1.94402840e-02f, 4.40434813e-02f, 9.96162742e-03f, 4.13267389e-02f, -3.83121241e-03f, 8.26553777e-02f, 4.74767480e-03f, -3.30160223e-02f, 3.09289582e-02f, 2.55493205e-02f,
  3.37074660e-02f, -9.51339141e-04f, 2.15286650e-02f, -3.38629335e-02f, 3.67078334e-02f, -9.57156420e-02f, 1.46178082e-02f, -2.63848919e-02f, -6.51716962e-02f, 2.09800489e-02f,
  8.83319601e-02f, -1.97231412e-01f, -2.36323122e-02f, 3.43389669e-03f, -8.58190730e-02f, 4.71619032e-02f, 2.65238620e-02f, 4.90682498e-02f, -6.62908703e-02f, -4.80977669e-02f,
  -6.82750866e-02f, 8.71357322e-03f, -4.93698800e-03f, 3.56777124e-02f, -7.33166859e-02f, 8.18100721e-02f, 5.77377453e-02f, -8.95480886e-02f, -2.87158675e-02f, -6.47232980e-02f,
  -5.09924255e-02f, -4.29189429e-02f, -2.34462065e-03f, -9.80080478e-03f, -5.60203046e-02f, -1.49446754e-02f, -7.94021636e-02f, -1.21035464e-01f, -5.72744794e-02f, -6.45373017e-02f,
  -8.42467174e-02f, 1.68803871e-01f, 9.31791216e-02f, 8.77386853e-02f, 1.73613448e-02f, -6.23503588e-02f, -1.87236797e-02f, 6.46056831e-02f, 7.08039701e-02f, 7.70304799e-02f,
  -1.07022308e-01f, 6.40084967e-02f, -6.81735128e-02f, 1.21193767e-01f, -1.04643524e-01f, -1.06994770e-01f, 5.09308949e-02f, -6.52428344e-02f, 3.17939632e-02f, 2.48555802e-02f,
  1.18200267e-02f, -8.22357386e-02f, 2.77671851e-02f, -2.22971570e-03f, 1.73330177e-02f, 5.68552911e-02f, -1.15420245e-01f, 1.45122525e-03f, -3.87849696e-02f, 1.63157638e-02f,
  -8.64954442e-02f, -7.86869135e-03f, 5.53266108e-02f, 5.47736790e-03f, -9.79014859e-02f, 1.24463784e-02f, -1.89799145e-02f, -4.77460437e-02f, 9.45897922e-02f, -3.69533449e-02f,
  -4.00454551e-02f, -6.94289953e-02f, 4.05735113e-02f, 3.39686461e-02f, -2.60333885e-02f, 4.25099917e-02f, 8.40807781e-02f, 9.85215753e-02f, -5.60789183e-03f, 2.64346767e-02f,
  -3.90938669e-02f, 3.88916731e-02f, 2.24692491e-03f, 3.61416936e-02f, -7.00856000e-02f, -4.61683199e-02f, 8.97739679e-02f, -4.41449620e-02f, -5.48238158e-02f, -2.95895431e-02f,
  3.42667960e-02f, -5.17659634e-02f, -8.17216262e-02f, -1.14961416e-01f, -1.09472992e-02f, 1.85488462e-02f, 4.20782231e-02f, 3.14575024e-02f, -3.07517014e-02f, -8.49544406e-02f,
  -2.39147209e-02f, -3.55544426e-02f, -5.46010062e-02f, 1.79504808e-02f, 4.04482335e-02f, -3.94194871e-02f, 6.44320697e-02f, 8.66268650e-02f, -5.87904677e-02f, 3.02990060e-02f,
  5.88116795e-02f, 4.84551489e-02f, 2.47672461e-02f, 5.59501126e-02f, -6.94736242e-02f, -2.31835134e-02f, 2.50142384e-02f, 1.33923003e-02f, -3.10306735e-02f, -1.22142874e-03f,
  -9.70260277e-02f, 7.00654462e-02f, -1.04674287e-02f, -2.13356391e-02f, 5.75293265e-02f, -4.38588224e-02f, 7.59643018e-02f, -7.06725866e-02f, -5.16937301e-02f, 3.08681484e-02f,
  -9.99398232e-02f, -6.66214302e-02f, 4.01456542e-02f, -2.24533230e-02f, -4.90033776e-02f, -7.13566095e-02f, 2.60946751e-02f, -3.85877229e-02f, -9.15507302e-02f, 5.04634380e-02f,
  -7.05072954e-02f, 2.15720627e-02f, -3.27642225e-02f, -9.37626138e-03f, -7.48699578e-03f, 1.95893031e-02f, -5.14223799e-02f, -3.74803208e-02f, -3.37526202e-02f, -4.56710905e-02f,
  -8.03617686e-02f, 9.20735970e-02f, 1.15845293e-01f, 5.78854531e-02f, 1.44725114e-01f, -3.73960361e-02f, -9.62720513e-02f, 2.80717164e-01f, 1.49861827e-01f, -2.24850550e-01f,
  -1.06543340e-01f, -2.55991042e-01f, -1.97186787e-02f, -2.70035234e-03f, 1.26930028e-01f, 5.78021631e-02f, 1.00754865e-01f, -1.39559507e-01f, 2.67266780e-01f, 9.74524207e-03f,
  2.28647709e-01f, -3.57528776e-02f, 2.44421273e-01f, 1.73657626e-01f, 5.43458872e-02f, 6.94087222e-02f, 1.71635188e-02f, 5.00639901e-02f, -6.84046596e-02f, -1.32362753e-01f,
  -4.75551322e-04f, 1.69520408e-01f, 1.07158698e-01f, 6.43726364e-02f, 1.60393327e-01f, -1.65130496e-01f, -8.52909610e-02f, -1.26286790e-01f, -1.71187315e-02f, 2.65535656e-02f,
  2.20960584e-02f, -7.48931915e-02f, 4.25949283e-02f, -6.75321296e-02f, 1.12413615e-01f, 8.64566937e-02f, 6.37251064e-02f, 1.04059733e-01f, -4.62945327e-02f, 5.10644615e-02f,
  -6.70628389e-03f, -4.90675941e-02f, -9.61678401e-02f, -8.32300410e-02f, 4.54229349e-03f, -7.32007399e-02f, -6.30248711e-02f, -7.32694045e-02f, 3.14343385e-02f, 7.59426318e-03f,
  -8.85228887e-02f, 6.84702769e-02f, -4.42618690e-02f, 6.84143901e-02f, 7.69854933e-02f, 1.07256345e-01f, -3.73172611e-02f, -1.02774547e-02f, 1.07824907e-01f, 4.99149822e-02f,
  6.64070845e-02f, 7.43493363e-02f, 6.61932454e-02f, 4.71261144e-02f, -2.60165259e-02f, -1.54669229e-02f, -2.24743541e-02f, -5.69043681e-02f, 7.98803344e-02f, 1.22818220e-02f,
  5.15029058e-02f, -7.01954663e-02f, 4.74858508e-02f, -8.82322565e-02f, 2.24223938e-02f, 7.78370397e-03f, 2.53629107e-02f, -1.03913188e-01f, 5.69863245e-02f, 1.26114180e-02f,
  9.95792896e-02f, 6.71808347e-02f, 4.48459126e-02f, 6.01995252e-02f, 8.23443606e-02f, -3.76639403e-02f, 7.02261403e-02f, 4.96955737e-02f, 1.17286153e-01f, 4.52539288e-02f,
  4.60439771e-02f, 7.91374594e-02f, -1.17892148e-02f, 2.98925489e-02f, -5.63740954e-02f, 6.94281682e-02f, -5.25423326e-02f, 4.02408428e-02f, -6.59703612e-02f, -5.01819998e-02f,
  -8.54567587e-02f, 7.09458813e-03f, 4.60180342e-02f, 8.33771843e-03f, -2.09291019e-02f, 1.65055860e-02f, 3.95797975e-02f, -3.02493200e-02f, -7.75208250e-02f, 5.24548255e-02f,
  -6.53923005e-02f, 7.12277964e-02f, -9.35251713e-02f, -3.33226211e-02f, 7.39017129e-02f, 2.01706260e-01f, 1.34419486e-01f, -2.36320253e-02f, 9.73880664e-02f, -1.77849468e-03f,
  -4.41710604e-03f, 7.76231810e-02f, 1.00133851e-01f, -4.45086546e-02f, 9.35041085e-02f, 1.52538881e-01f, 1.12597473e-01f, 9.85254254e-03f, -5.17089814e-02f, 1.02105379e-01f,
  5.07390723e-02f, 2.45249048e-02f, -1.25718042e-01f, -1.66888848e-01f, -1.31038502e-01f, -1.40329555e-01f, -1.35993183e-01f, -1.22197740e-01f, -2.11678185e-02f, 9.34883282e-02f,
  -7.96966553e-02f, -3.59629467e-02f, -3.37421149e-02f, -3.69799929e-03f, 4.95314151e-02f, 3.64665464e-02f, -6.57685846e-02f, 9.11575481e-02f, -4.44988273e-02f, 4.59366525e-03f,
  8.41418207e-02f, -3.24528776e-02f, 7.88732618e-02f, -3.64876129e-02f, 7.06261322e-02f, -3.31606641e-02f, -4.99625579e-02f, -1.39944270e-01f, -5.84490448e-02f, -7.95180723e-02f,
  4.53987308e-02f, -6.57670274e-02f, -6.81863129e-02f, 3.46179679e-02f, -9.02527720e-02f, -7.46095106e-02f, 5.65799773e-02f, -1.50213279e-02f, 5.20217940e-02f, -1.87785588e-02f,
  -6.04422353e-02f, 2.67840605e-02f, -4.06601429e-02f, -4.03525271e-02f, -3.84441242e-02f, 2.43207272e-02f, 2.94750221e-02f, 4.75416593e-02f, 7.68504292e-03f, 7.08953366e-02f,
  3.01625468e-02f, -4.82100807e-02f, 3.56660224e-02f, -6.53668568e-02f, 7.93443099e-02f, 1.25239221e-02f, -5.56220450e-02f, -6.07869476e-02f, -1.12003898e-02f, -8.01170319e-02f,
  -1.57253854e-02f, -4.59183492e-02f, 6.81335405e-02f, -4.37841825e-02f, 4.76196408e-02f, -1.52211878e-02f, -2.68765911e-03f, 1.21410266e-02f, -1.56576093e-02f, -6.25123754e-02f,
  5.48027009e-02f, 5.89828864e-02f, -7.57589713e-02f, 5.78685626e-02f, 7.86042288e-02f, -2.16034297e-02f, 3.44565734e-02f, -1.47612514e-02f, 1.26175225e-01f, 1.08881295e-01f,
  -1.08722523e-02f, -1.06953077e-01f, -7.04903156e-02f, 2.08585393e-02f, 8.94194618e-02f, 1.21151097e-01f, 7.42202997e-02f, 2.91711241e-02f, -3.83252427e-02f, -2.75467522e-03f,
  -1.70345288e-02f, 1.90657116e-02f, 3.85793522e-02f, -6.67276010e-02f, -3.26016694e-02f, 4.36537862e-02f, 6.16659373e-02f, -2.58508325e-02f, 4.59242389e-02f, -4.50154580e-02f,
  -3.28163862e-01f, 2.64773250e-01f, -2.21718892e-01f, -2.57528991e-01f, -3.36921737e-02f, -1.79146662e-01f, -2.25855500e-01f, 3.12865898e-02f, 6.40642866e-02f, 1.02912843e-01f,
  -1.12319784e-02f, -1.45674363e-01f, 2.49534458e-01f, -8.76551345e-02f, -1.75747201e-01f, 6.07022345e-02f, -3.18988204e-01f, -2.00254783e-01f, 7.38715529e-02f, -2.31048897e-01f,
  -7.38419741e-02f, -1.92787480e-02f, -1.37020677e-01f, 9.13937017e-02f, -1.26735553e-01f, -4.68610376e-02f, -1.26746818e-01f, 1.79640517e-01f, -8.02427605e-02f, -6.56950433e-05f,
  -1.82416961e-01f, -1.69381112e-01f, -2.05579266e-01f, -1.19121455e-01f, -2.04371303e-01f, -9.30295587e-02f, -1.64087504e-01f, 5.36581650e-02f, -9.62154567e-03f, -3.32050282e-03f,
  -6.46291748e-02f, 3.99544314e-02f, -3.90452828e-04f, 4.77897860e-02f, 5.57708647e-03f, 4.10802849e-02f, -3.55068296e-02f, -8.75044167e-02f, 5.32878861e-02f, -4.23636772e-02f,
  1.94847621e-02f, 3.07648089e-02f, -5.21595143e-02f, 3.04110665e-02f, -7.14230984e-02f, 1.98600199e-02f, -1.21798784e-01f, -6.20030537e-02f, -8.33627656e-02f, 2.97892559e-02f,
  2.04739142e-02f, -2.03028619e-02f, -3.48148085e-02f, 3.62091698e-02f, 8.06761310e-02f, 8.51601083e-03f, -7.68431053e-02f, 4.88865599e-02f, -3.47745009e-02f, 6.44628182e-02f,
  1.72882602e-02f, 4.47658449e-02f, 1.46771325e-02f, 2.41964478e-02f, 2.05319114e-02f, 3.79533879e-02f, -2.01042369e-02f, 6.24957345e-02f, 1.49924280e-02f, -9.32384934e-03f,
  -2.33661737e-02f, 5.03514754e-03f, -1.81779712e-02f, 2.49008518e-02f, 1.18292794e-02f, -1.09061943e-02f, 1.19642066e-02f, 1.85359232e-02f, 5.66308871e-02f, 3.52463908e-02f,
  -2.86488175e-01f, -1.98358044e-01f, -4.51407395e-02f, -1.16931903e-03f, -7.50633776e-02f, 1.90000888e-02f, -9.50976857e-04f, -8.56620682e-06f, -6.97772354e-02f, -9.30283160e-04f,
  -1.56857166e-02f, 2.39598211e-02f, -7.76510984e-02f, -1.79429017e-02f, -2.13125255e-02f, -1.17784120e-01f, -4.20947336e-02f, -2.58401502e-02f, -7.52754882e-02f, -6.78548515e-02f,
  1.82571132e-02f, -4.36614975e-02f, 3.05006076e-02f, -9.62976888e-02f, -3.49211060e-02f, 1.42407240e-02f, -1.25860825e-01f, 7.67418742e-02f, 1.97655745e-02f, -8.30750465e-02f,
  -5.28821312e-02f, 1.09945737e-01f, -1.01362407e-01f, 8.94720480e-02f, -3.34159344e-01f, -5.70279779e-03f, 1.12053148e-01f, -1.60700634e-01f, 4.04176721e-03f, 3.22571635e-01f,
  7.36990422e-02f, -6.80556195e-03f, 1.20985597e-01f, 1.25210777e-01f, -1.16403021e-01f, 1.14831626e-01f, 9.45548564e-02f, 2.63951898e-01f, -1.21507570e-01f, -2.02582907e-02f,
  -1.54695362e-02f, -8.53628069e-02f, -7.70246461e-02f, -6.50007203e-02f, -4.94861975e-03f, -1.47005811e-01f, -1.40022159e-01f, -1.47942498e-01f, -6.53140545e-02f, -1.11148737e-01f,
  1.36282737e-03f, -1.36568159e-01f, -1.61999278e-02f, 1.07828774e-01f, 5.84342889e-02f, 7.53646195e-02f, 1.59475468e-02f, -8.98419619e-02f, -1.04400024e-01f, -5.38057685e-02f,
  4.55614664e-02f, 1.86119117e-02f, -5.82749769e-02f, -1.31452948e-01f, -4.00975841e-04f, -1.36925066e-02f, 1.16765583e-02f, -3.93634662e-03f, 2.08314322e-02f, -7.36337900e-02f,
  2.04500686e-02f, 1.04780540e-01f, -5.01191765e-02f, 1.02086097e-01f, 6.85213059e-02f, -5.31219169e-02f, 2.82588415e-02f, -2.26399843e-02f, 6.95612431e-02f, -3.87254357e-02f,
  -2.50619482e-02f, 7.54818693e-02f, 7.20270053e-02f, -1.97305791e-02f, -1.12588229e-02f, 9.14380141e-03f, 4.09788638e-02f, -2.79067475e-02f, 5.26106097e-02f, -8.62006843e-03f,
  -5.67756034e-02f, -1.34670045e-02f, 8.35170876e-03f, 1.98344477e-02f, 9.82884597e-03f, 8.65853503e-02f, -6.78928278e-04f, -5.60663678e-02f, -5.50518511e-03f, -1.15388762e-02f,
  -1.63926128e-02f, -8.04840997e-02f, 1.67730357e-02f, 5.55652119e-02f, 3.23690437e-02f, -2.13255044e-02f, 1.48939574e-02f, -2.14615762e-02f, 6.94697350e-02f, -6.31290898e-02f,
  3.54725644e-02f, 1.65763441e-02f, -3.26773189e-02f, -2.02547144e-02f, 8.52498636e-02f, 3.00595071e-02f, 6.00175224e-02f, -3.38099971e-02f, -9.12952051e-02f, -2.29005683e-02f,
  7.10658804e-02f, -1.78396702e-02f, 6.34656549e-02f, -5.17705083e-02f, 2.27255486e-02f, -2.02350672e-02f, 1.00998297e-01f, 8.83577839e-02f, 5.26662320e-02f, -8.36427659e-02f,
  -1.50554823e-02f, 5.21200448e-02f, 3.87972221e-03f, 8.62060338e-02f, 1.05190709e-01f, 5.41381501e-02f, 4.92321625e-02f, -1.05421022e-02f, -9.65144392e-03f, 6.88576922e-02f,
  -1.56504065e-01f, -7.55031034e-02f, -2.31873438e-01f, -1.08499341e-01f, 4.08784859e-02f, -4.05748904e-01f, -1.73367068e-01f, -1.24582142e-01f, 1.12128481e-01f, 1.28812015e-01f,
  5.84667660e-02f, -6.48360029e-02f, 1.97721913e-01f, -3.32800090e-01f, -3.13470155e-01f, -8.04602914e-03f, -2.98394263e-01f, -8.42593238e-02f, -9.50426236e-02f, -3.12447548e-02f,
  -1.78376332e-01f, -7.76344612e-02f, -2.53537774e-01f, 6.64253831e-02f, -1.39825061e-01f, 4.39435095e-02f, 1.39916867e-01f, 7.08231926e-02f, -1.58354118e-01f, -6.36166707e-02f,
  -6.88461438e-02f, 5.20436419e-03f, -1.31696299e-01f, -1.16518840e-01f, -6.34397715e-02f, -7.75433630e-02f, 4.68838885e-02f, -3.34410109e-02f, -4.80466001e-02f, 1.94863894e-03f,
  -9.90449730e-03f, -1.38540789e-02f, -4.17798720e-02f, 8.79382715e-02f, 1.35172508e-03f, 9.12399683e-03f, -7.50952438e-02f, 5.70047982e-02f, 5.35747968e-02f, -3.98050621e-02f,
  -1.03788003e-01f, 2.44434476e-02f, -8.08800608e-02f, 5.08124344e-02f, -6.22794516e-02f, -4.40466516e-02f, -7.34228492e-02f, -4.97850180e-02f, 7.34884068e-02f, -2.90943831e-02f,
  5.05672321e-02f, 6.60489202e-02f, -5.14858495e-03f, 5.70935570e-02f, -6.42564818e-02f, 7.89770186e-02f, -4.81687374e-02f, 9.22353119e-02f, 4.93341088e-02f, -3.30178812e-02f,
  2.52515953e-02f, -4.23323512e-02f, 9.25270934e-03f, -7.34246820e-02f, -1.49213825e-04f, 5.74373454e-02f, -5.24847955e-02f, 8.93153076e-04f, -4.37973142e-02f, -2.24378761e-02f,
  9.23027173e-02f, -8.02132413e-02f, -2.05327738e-02f, 6.93184659e-02f, -5.56801073e-02f, 9.88402292e-02f, 2.07489673e-02f, -9.38238949e-02f, 5.21373115e-02f, -6.03005476e-02f,
  -2.02028127e-03f, 1.16534524e-01f, 8.25204104e-02f, 1.21789441e-01f, 3.73228714e-02f, -4.37759496e-02f, -4.42127772e-02f, -1.13884792e-01f, -9.08067375e-02f, 2.85233147e-02f,
  4.47246879e-02f, -1.00415358e-02f, 7.04217106e-02f, 2.62454338e-02f, -1.87645815e-02f, -3.95020470e-02f, -8.67486000e-03f, 8.20192620e-02f, 2.39320798e-03f, -5.17860912e-02f,
  8.49026591e-02f, 8.00740272e-02f, 2.31987070e-02f, 3.53352614e-02f, 4.66526300e-02f, 2.16812845e-02f, 3.98798808e-02f, 6.42125085e-02f, 8.21241923e-03f, -3.49902064e-02f,
  -1.59011260e-01f, 1.72934249e-01f, 3.77871543e-01f, -2.69510657e-01f, 2.57342517e-01f, 2.37797916e-01f, 4.17930745e-02f, 1.72021747e-01f, -7.10757375e-02f, -1.98514476e-01f,
  9.53281205e-03f, -1.28040388e-01f, 7.72775859e-02f, -1.53066143e-01f, 1.52845785e-01f, 1.59251213e-01f, 3.88024747e-02f, -1.19483836e-01f, 6.80203661e-02f, -4.82659880e-03f,
  -4.12174687e-02f, -6.05161488e-02f, 9.03200209e-02f, 7.26195201e-02f, 5.22173643e-02f, -1.14952452e-01f, -2.55907297e-01f, 5.10303974e-02f, -6.57209083e-02f, -1.62204895e-02f,
  3.52471508e-02f, -1.40445039e-01f, 2.87718792e-02f, 1.07071310e-01f, -1.55966356e-02f, 2.52750702e-02f, -7.49053583e-02f, 1.95124056e-02f, -8.82406756e-02f, -3.12831141e-02f,
  -4.76541370e-02f, 5.98836131e-02f, -7.27785006e-02f, -4.32490855e-02f, -4.89101969e-02f, 3.48600298e-02f, 1.15733773e-01f, 2.83291452e-02f, 8.99427980e-02f, 1.22628771e-01f,
  6.22800514e-02f, 7.15415999e-02f, 1.03476569e-02f, 2.29642410e-02f, 1.18271738e-01f, 2.13723537e-02f, -1.58574283e-02f, 3.36993895e-02f, 1.02258017e-02f, 3.05863731e-02f,
  5.01987599e-02f, 6.08041026e-02f, 1.01361930e-01f, -2.27243323e-02f, -3.70098874e-02f, 7.36938715e-02f, -8.92814100e-02f, -2.07517128e-02f, -4.18393686e-02f, -7.10856766e-02f,
  -6.62993342e-02f, -6.89936131e-02f, 4.75357324e-02f, 3.69911641e-02f, -1.25840837e-02f, -6.09620437e-02f, 6.32234439e-02f, 3.67750414e-02f, -1.15103573e-02f, -6.12358637e-02f,
  -6.00231215e-02f, 5.35627566e-02f, -3.74927409e-02f, -7.67640173e-02f, 5.26529178e-02f, -8.24048836e-03f, 4.83402722e-02f, 1.12759776e-01f, -3.61553766e-02f, 1.29090045e-02f,
  -1.02224410e-01f, -1.82027787e-01f, 2.20056511e-02f, -3.14867012e-02f, -2.46981084e-02f, -2.61177495e-02f, 4.27622497e-02f, 1.60763040e-02f, 4.65210117e-02f, 4.73457202e-03f,
  -5.61071411e-02f, -3.83946411e-02f, 6.70049563e-02f, -2.10412126e-03f, -1.18843408e-03f, 1.70176793e-02f, -1.12191267e-01f, -5.05762510e-02f, -3.05139422e-02f, 2.70273052e-02f,
  9.81400535e-03f, -1.73529983e-02f, 3.72127071e-02f, -4.02452573e-02f, -1.44944102e-01f, -6.38850406e-02f, -1.47483107e-02f, 1.42868673e-02f, 3.41867730e-02f, -1.25045851e-02f,
  -1.55459359e-01f, 2.60377884e-01f, 6.40529618e-02f, 1.64294690e-01f, -2.74771810e-01f, 1.11323982e-01f, 2.89580196e-01f, -5.31535596e-02f, 2.04534203e-01f, 1.81348622e-01f,
  -2.00226232e-02f, 1.20973960e-01f, 1.25169262e-01f, 6.76574260e-02f, 3.19996253e-02f, 9.87436622e-02f, 2.95636028e-01f, 2.48090670e-01f, 8.89410898e-02f, 7.27215409e-02f,
  9.38773528e-03f, 3.33052501e-02f, -1.46398991e-02f, -1.41756251e-01f, -6.39048591e-02f, -7.23149329e-02f, -2.32625246e-01f, -1.45166457e-01f, -7.21527264e-02f, -8.76839086e-02f,
  2.90323887e-02f, 2.46587954e-02f, -7.35884309e-02f, 6.28717467e-02f, -5.12283035e-02f, -8.56455881e-03f, -3.24396975e-02f, -7.39103407e-02f, -9.96704027e-03f, 8.23311806e-02f,
  9.24026743e-02f, 6.38356945e-03f, 8.12649950e-02f, -7.78441876e-02f, -3.81976850e-02f, -7.90420845e-02f, 1.72840222e-03f, -8.18664804e-02f, 7.26144910e-02f, -1.23453967e-01f,
  -3.59118432e-02f, -6.06376072e-03f, 7.05169048e-03f, 1.36106446e-01f, 6.49252757e-02f, -1.72926858e-02f, 7.38382107e-03f, -3.73416618e-02f, 3.90480161e-02f, 1.00658825e-02f,
  4.96708453e-02f, -5.31073706e-03f, 6.31318837e-02f, -1.30948082e-01f, -4.92569171e-02f, 4.15259413e-02f, -9.36580524e-02f, 3.06501165e-02f, 5.23334481e-02f, -4.05212212e-03f,
  7.83096030e-02f, 7.05611110e-02f, -3.15758474e-02f, 7.53581449e-02f, 2.87412964e-02f, -8.08844995e-03f, 3.64748463e-02f, 2.47352254e-02f, 8.76717716e-02f, -7.41068572e-02f,
  7.30966404e-02f, 8.16084296e-02f, -5.67818210e-02f, -2.46205013e-02f, 7.82741085e-02f, -6.27457723e-02f, 2.68488694e-02f, 8.74099880e-03f, 2.42576804e-02f, 5.38286790e-02f,
  1.53779700e-01f, 2.77385831e-01f, 8.67224708e-02f, 6.12449832e-02f, 1.07715055e-01f, -2.45879106e-02f, 6.74497336e-02f, 1.09710367e-02f, 4.12132544e-03f, 1.02594875e-01f,
  6.64335042e-02f, -2.49955505e-02f, 6.05231263e-02f, -6.29936978e-02f, 2.29106899e-02f, -3.45572010e-02f, 1.16847984e-01f, 3.92092578e-02f, 5.45229651e-02f, 2.20454112e-02f,
  -9.07790065e-02f, 9.11280662e-02f, 1.20524734e-01f, 4.55875769e-02f, -2.63637658e-02f, 6.81169555e-02f, 4.20349613e-02f, 2.07323693e-02f, 5.31914309e-02f, 6.81517273e-02f,
  3.95883508e-02f, -1.67209163e-01f, 1.39816061e-01f, 3.28007966e-01f, -1.66609306e-02f, -2.65614480e-01f, -1.75102398e-01f, 5.49387261e-02f, 1.16544239e-01f, -3.57743114e-01f,
  -1.34830236e-01f, -1.27358228e-01f, -2.92027563e-01f, 1.53816164e-01f, 2.48896897e-01f, -6.21789098e-02f, 1.45341545e-01f, -3.94252613e-02f, 1.28525034e-01f, 2.10505188e-01f,
  3.51466626e-01f, 1.63944453e-01f, 2.50609607e-01f, 1.42784134e-01f, 8.73626098e-02f, 1.45084038e-01f, 1.89488694e-01f, 3.00148930e-02f, 2.11156085e-01f, 4.84376587e-02f,
  -8.92759934e-02f, 7.68275633e-02f, -3.33804153e-02f, 4.64387750e-03f, 3.03071346e-02f, -3.55439112e-02f, -1.10391274e-01f, -8.23112391e-03f, 1.10518197e-02f, -2.63332985e-02f,
  -1.19268619e-01f, 6.35439530e-02f, 1.29794821e-01f, 2.61226296e-02f, -6.56747669e-02f, 6.60946667e-02f, 2.99425703e-02f, -3.96213010e-02f, 3.01829837e-02f, 3.89462598e-02f,
  -2.74361074e-02f, -4.57302034e-02f, 3.36380117e-02f, 3.51800174e-02f, 8.71212259e-02f, 4.17646766e-02f, 3.83573323e-02f, -2.43591871e-02f, -1.45577090e-02f, 1.24419689e-01f,
  -7.93083664e-03f, -2.29790397e-02f, -4.80222255e-02f, 6.71812473e-03f, -4.84746546e-02f, -4.75595705e-02f, -3.50844152e-02f, 3.23775932e-02f, -5.72597049e-02f, -1.50864916e-02f,
  3.79503891e-02f, 2.35750657e-02f, 5.93249388e-02f, 3.36906407e-03f, 2.90789530e-02f, 2.25762036e-02f, -2.74825376e-02f, 2.66579073e-02f, 4.53756861e-02f, 7.47010782e-02f,
  5.68516925e-02f, 7.29666976e-03f, 1.68861039e-02f, 3.14899273e-02f, -5.26891323e-03f, -3.90781350e-02f, -1.65167041e-02f, -7.12561905e-02f, 2.85781324e-02f, 4.65650074e-02f,
  -1.97980627e-01f, 1.37642294e-01f, -6.52268529e-02f, -3.79179828e-02f, -3.12431548e-02f, 1.20224608e-02f, -3.15798372e-02f, 3.30833867e-02f, 5.31801432e-02f, 4.73734774e-02f,
  -2.97736526e-02f, -4.60362025e-02f, -8.22183639e-02f, 3.08439080e-02f, 7.09779412e-02f, -2.95051783e-02f, 4.05085161e-02f, 3.17422003e-02f, -3.66742946e-02f, 4.74685133e-02f,
  3.30359079e-02f, -9.63828042e-02f, -5.89382544e-04f, 8.59796181e-02f, 4.53855582e-02f, -5.60277738e-02f, 3.31023848e-03f, 7.80066624e-02f, 1.33620659e-02f, -1.28072305e-02f,
  8.24939460e-02f, -1.82226822e-01f, 7.82991201e-02f, -1.88062862e-01f, -1.40541017e-01f, -4.01729979e-02f, 5.08428514e-02f, -2.14744434e-01f, -2.48340592e-01f, -3.71117145e-01f,
  -2.32621223e-01f, 3.59135196e-02f, 2.24380299e-01f, -2.14078665e-01f, 5.13947785e-01f, 2.61252046e-01f, -1.02791555e-01f, -9.94380563e-02f, 1.11205066e-02f, -1.70305088e-01f,
  -4.70329635e-02f, -1.80566177e-01f, 1.19942583e-01f, -2.58220077e-01f, -2.44044363e-01f, -9.38501954e-02f, 8.06613564e-02f, 8.10980350e-02f, -2.63313830e-01f, 1.26544917e-02f,
  -9.23590288e-02f, -6.93957880e-02f, -5.06663546e-02f, -2.12132186e-02f, -4.60142754e-02f, -5.62689193e-02f, 4.80873547e-02f, 1.29494876e-01f, 6.10827841e-02f, 5.79943433e-02f,
  2.23580636e-02f, 6.26904741e-02f, -1.55070797e-01f, 2.90884811e-04f, -1.17086954e-02f, -1.17008604e-01f, 1.59603748e-02f, -6.79371087e-03f, 4.28756662e-02f, 8.96672904e-02f,
  4.58819047e-02f, 2.91670859e-02f, -8.32735673e-02f, -7.19231144e-02f, -2.59814207e-02f, -4.37415391e-02f, 7.73684233e-02f, 2.63493657e-02f, -7.05030337e-02f, 6.34987280e-02f,
  -6.38550380e-03f, 4.80174907e-02f, 9.12912097e-03f, -2.97116507e-02f, -2.37214100e-02f, -1.19416475e-01f, -2.49317884e-02f, 5.04106022e-02f, -6.20706007e-03f, -3.66297439e-02f,
  -9.27610323e-03f, -6.21269457e-02f, 6.17088042e-02f, 3.20502669e-02f, -8.37609395e-02f, -8.52475986e-02f, -2.38189716e-02f, 2.49647982e-02f, 2.65279226e-02f, -4.17340398e-02f,
  -1.17024938e-02f, 6.96021505e-03f, -6.90597445e-02f, -6.37899041e-02f, -8.80684517e-03f, -1.70231052e-02f, 3.46284383e-03f, -2.01195925e-02f, -1.51674906e-02f, 1.07113823e-01f,
  1.47165672e-03f, -2.09288020e-02f, -6.68172985e-02f, 3.50215212e-02f, 5.67271411e-02f, 5.12541234e-02f, -6.27362132e-02f, -9.67749134e-02f, -3.35535519e-02f, -5.44140488e-02f,
  1.47118317e-02f, -8.23822618e-03f, 4.80277091e-03f, 4.43412084e-03f, -4.53477958e-03f, -8.23808536e-02f, 2.71274019e-02f, 5.11108488e-02f, -5.04316352e-02f, -5.00974953e-02f,
  -1.50783658e-02f, -2.22985283e-03f, 4.12870310e-02f, -1.78756118e-02f, -1.87077411e-02f, 1.79566052e-02f, -2.67008748e-02f, 5.23933098e-02f, 2.61197649e-02f, -4.80915718e-02f,
  1.67688280e-01f, -2.92673498e-01f, 2.86713183e-01f, 2.58891612e-01f, 9.56551582e-02f, 1.28391609e-01f, 2.44940132e-01f, 8.28619152e-02f, 7.40498006e-02f, -9.17008966e-02f,
  2.86017414e-02f, -9.03259590e-02f, -1.09862089e-01f, -4.60227765e-02f, -3.89951691e-02f, -9.90051627e-02f, -3.46417166e-02f, -6.73177391e-02f, 2.77785566e-02f, 2.76474617e-02f,
  1.12396702e-01f, -9.83572155e-02f, 7.45009482e-02f, -2.01754227e-01f, 5.18800132e-02f, -3.11686378e-02f, -1.22708470e-01f, -1.31295234e-01f, -1.17851846e-01f, -6.86405450e-02f,
  5.37736677e-02f, -5.98711483e-02f, -4.01179641e-02f, -4.35590744e-03f, -1.10028656e-02f, 2.00994667e-02f, -7.02385157e-02f, -6.79441122e-03f, 8.00532922e-02f, 6.80390745e-02f,
  2.59435028e-02f, -7.02301413e-02f, -4.24881056e-02f, -9.80138406e-03f, 2.54373588e-02f, 2.61184480e-02f, 8.19946080e-02f, 7.25765750e-02f, 1.56577248e-02f, 3.46705094e-02f,
  7.87559748e-02f, 3.16953696e-02f, 7.59006888e-02f, -8.41717571e-02f, 1.09561995e-01f, 7.83720240e-02f, 8.53249729e-02f, 1.81628410e-02f, -1.79022830e-02f, 1.14903441e-02f,
  -8.43011588e-02f, -7.99392816e-03f, 3.36572640e-02f, -1.24906907e-02f, 2.19359566e-02f, -7.78881251e-04f, -2.78918017e-02f, 2.02137176e-02f, 5.54974377e-02f, -1.71053372e-02f,
  -5.68347946e-02f, 3.06006242e-02f, -5.42756505e-02f, 1.23930257e-02f, 3.74177396e-02f, -3.29236463e-02f, 2.66656168e-02f, -1.76073611e-02f, -1.53772263e-02f, -4.32858169e-02f,
  -7.48584867e-02f, -4.19717282e-02f, -5.66603243e-02f, 6.75594085e-04f, -3.02176774e-02f, -5.04314490e-02f, -2.61518117e-02f, 6.95504323e-02f, 1.24657154e-02f, -8.49897414e-02f,
  -2.14097485e-01f, -3.01551849e-01f, 2.46002078e-02f, -1.56651475e-02f, -5.51800132e-02f, 2.77138203e-02f, -4.37426940e-02f, -9.49729457e-02f, -9.39735025e-02f, -6.56410307e-03f,
  2.95916721e-02f, 4.06861305e-02f, -6.41949624e-02f, -3.55380252e-02f, -1.07063644e-01f, 3.73849384e-02f, -2.74424721e-03f, -3.88456248e-02f, -9.14883688e-02f, -8.94193798e-02f,
  4.07720879e-02f, 4.54396382e-02f, 2.68652048e-02f, 8.70976672e-02f, -2.01785173e-02f, 2.00682636e-02f, -3.05896681e-02f, -1.66461226e-02f, 2.73669250e-02f, -5.00614680e-02f,
  -8.38969275e-02f, 4.75503117e-01f, 1.80346429e-01f, 4.63578589e-02f, -8.94022584e-02f, -2.65073497e-02f, 2.98653673e-02f, 7.55596831e-02f, 2.41978973e-01f, 1.47869632e-01f,
  -9.35827568e-03f, 3.84155899e-01f, -1.12074375e-01f, 1.84291545e-02f, -3.32860619e-01f, -1.01086907e-01f, -3.17591988e-02f, 4.82371040e-02f, 1.53473824e-01f, -1.03418827e-02f,
  -2.31953055e-01f, -1.41572475e-01f, -2.83840537e-01f, 1.45054767e-02f, 8.03767294e-02f, 7.96488300e-02f, -2.32067287e-01f, 1.34911006e-02f, 1.90330278e-02f, 8.20500702e-02f,
  -5.55336103e-02f, 1.59160942e-01f, 1.28390655e-01f, 2.52467357e-02f, -7.19916821e-02f, 2.11824588e-02f, 3.65201905e-02f, -6.05413970e-03f, 2.68266797e-02f, 6.54170848e-03f,
  1.93373859e-02f, -3.64001021e-02f, 1.78449333e-03f, -1.66479852e-02f, 1.09063007e-01f, 7.12957382e-02f, 2.28903666e-02f, 3.91302407e-02f, 4.30083945e-02f, 9.46994647e-02f,
  1.15984924e-01f, 6.00159876e-02f, 4.04982921e-03f, -3.29854675e-02f, -7.69972801e-02f, 7.96445981e-02f, 9.07759517e-02f, 8.44356790e-02f, -1.70863084e-02f, 1.01985291e-01f,
  -4.39147763e-02f, -2.18589921e-02f, 1.61071285e-03f, -5.07332757e-02f, 5.48867844e-02f, -7.44808093e-02f, 7.65863508e-02f, 1.97964739e-02f, 2.06524562e-02f, -7.45792091e-02f,
  -7.80275390e-02f, -4.48758295e-03f, 5.52920066e-03f, -1.37846339e-02f, 4.52013407e-03f, 1.24491043e-02f, -8.85856971e-02f, 1.22221815e-03f, 4.65730838e-02f, -2.99145151e-02f,
  2.27227937e-02f, 2.23293304e-02f, -3.83542553e-02f, -3.32120135e-02f, -6.05666116e-02f, 2.71648951e-02f, 3.70145105e-02f, -5.08921221e-02f, -1.83764156e-02f, -1.45128947e-02f,
  1.15543723e-01f, 1.33266330e-01f, -1.43111553e-02f, 1.10366978e-01f, 3.23153213e-02f, -8.24543461e-02f, 7.64702260e-02f, 8.87107700e-02f, -6.16070535e-03f, 3.62180062e-02f,
  1.13019291e-02f, 4.35302742e-02f, 3.38492282e-02f, 3.59717794e-02f, -5.97891174e-02f, 3.36653702e-02f, -1.58051290e-02f, 3.44821960e-02f, 3.03219613e-02f, -1.42039568e-03f,
  2.24544201e-02f, 8.32675323e-02f, 4.46899198e-02f, 5.23353666e-02f, 9.63043123e-02f, -5.74436523e-02f, -5.95240155e-03f, 9.52966437e-02f, -4.10797447e-02f, 1.65026039e-02f,
  -3.77118409e-01f, 1.91084325e-01f, -8.76546577e-02f, -2.96695866e-02f, -2.02967390e-01f, 2.31982693e-01f, 1.57277569e-01f, 6.65820539e-02f, 1.49336576e-01f, 2.93895781e-01f,
  -1.73550099e-02f, -7.83280563e-03f, 1.36315733e-01f, 2.26079077e-01f, 1.55224875e-01f, 2.42411688e-01f, 2.53188312e-01f, 2.18358710e-01f, 2.99415812e-02f, -7.26305544e-02f,
  3.29141505e-02f, 4.65174243e-02f, 2.54965406e-02f, -1.15491480e-01f, -2.03667611e-01f, -1.34570062e-01f, -1.87044457e-01f, -1.61427081e-01f, -5.54510765e-02f, -5.03952950e-02f,
  -1.42610431e-01f, -6.59303889e-02f, -1.69924408e-01f, -9.09319296e-02f, -1.23001680e-01f, -2.07648966e-02f, 3.57273244e-03f, -7.13335946e-02f, 8.28719698e-03f, -3.35358121e-02f,
  -5.12793325e-02f, -6.11564815e-02f, 2.50708722e-02f, 2.86372714e-02f, -4.98890691e-02f, 2.54919566e-02f, 3.97249050e-02f, 6.04400504e-03f, 4.74933051e-02f, 3.26837152e-02f,
  6.36952519e-02f, 9.64784771e-02f, 5.95987402e-02f, 3.49063016e-02f, -7.22699761e-02f, 3.51113118e-02f, 6.19501732e-02f, 1.59705114e-02f, -2.10617650e-02f, 7.67666250e-02f,
  5.93418479e-02f, 5.06675839e-02f, -4.37140130e-02f, 3.73215973e-02f, -3.18925902e-02f, 1.41752595e-02f, 1.01850489e-02f, -1.65103041e-02f, -7.83553198e-02f, -4.22818027e-02f,
  -2.22981302e-03f, -1.10714003e-01f, -3.47224646e-03f, 4.47765589e-02f, -3.60764451e-02f, 9.27035883e-03f, 2.03167531e-03f, 4.67111245e-02f, 6.29800512e-03f, 8.25079381e-02f,
  6.17801547e-02f, 4.79749925e-02f, 4.18306887e-02f, -5.18916175e-03f, 3.97661477e-02f, 3.64498943e-02f, 5.35745285e-02f, 8.51130486e-02f, -7.23626688e-02f, -4.07714583e-02f,
  4.57159244e-02f, 4.11449224e-02f, -1.17423996e-01f, -1.28818184e-01f, -5.65539002e-02f, -7.80404732e-03f, -5.77508137e-02f, -6.56827986e-02f, 5.79816699e-02f, -5.11172451e-02f,
  -1.02176830e-01f, -4.14059777e-03f, -6.57279193e-02f, 1.09016837e-03f, 8.39769840e-02f, 2.39569340e-02f, 1.46429464e-02f, 5.63850217e-02f, -7.15775415e-02f, 3.20503749e-02f,
  -5.01881689e-02f, 2.23658010e-02f, -7.60445697e-03f, -4.20890823e-02f, 3.93524021e-02f, 1.58212110e-02f, -2.61163153e-02f, -9.91567075e-02f, -3.67759019e-02f, 5.68917627e-03f,
  3.40753794e-01f, -1.08461618e-01f, -1.63820356e-01f, -8.14119652e-02f, -3.94078009e-02f, -3.28120321e-01f, -2.39249155e-01f, -1.63631871e-01f, 5.68153001e-02f, -1.28461182e-01f,
  -1.83841601e-01f, 7.22208247e-02f, 2.81314198e-02f, -3.07952583e-01f, 5.78110479e-02f, 1.23191662e-01f, -2.75114149e-01f, -2.22586393e-02f, 1.11856438e-01f, -1.72495455e-01f,
  -4.25629653e-02f, -1.91469744e-01f, -4.58999835e-02f, -2.40815759e-01f, -1.61986485e-01f, -7.45218024e-02f, 3.71356905e-02f, -3.86858024e-02f, -1.17349096e-01f, -1.87474657e-02f,
  -6.58854842e-02f, 5.76935597e-02f, -5.11964187e-02f, 6.36613891e-02f, -4.64414731e-02f, 1.55927828e-02f, -6.31105751e-02f, -2.83821132e-02f, 1.05684415e-01f, -5.51260188e-02f,
  1.06596716e-01f, 8.96588142e-04f, -1.37381898e-02f, -2.64580678e-02f, 4.42491658e-02f, -1.12852201e-01f, -5.02811894e-02f, -5.70019595e-02f, -8.19670036e-02f, 1.82256452e-03f,
  3.02473139e-02f, -5.28258085e-02f, -4.10322398e-02f, -3.01875956e-02f, 5.51172718e-02f, 1.53555516e-02f, 6.30128160e-02f, -2.92229708e-02f, -7.16496259e-02f, 1.03910500e-02f,
  3.43023129e-02f, 7.70093352e-02f, 3.65314856e-02f, 2.70503256e-02f, 1.08693942e-01f, 2.45480631e-02f, 5.32573995e-06f, -2.90137213e-02f, -6.20051585e-02f, -3.35438326e-02f,
  1.21591259e-02f, -1.66759249e-02f, 6.02487288e-02f, -2.42947042e-02f, -3.00552603e-02f, 6.27322271e-02f, 9.14208740e-02f, -3.17709260e-02f, 8.65949877e-03f, -1.67748127e-02f,
  -5.50734205e-03f, -6.28037229e-02f, 2.09448487e-02f, -4.12602760e-02f, -7.18093617e-03f, 2.58701555e-02f, 5.52762449e-02f, -5.74109368e-02f, 8.25249553e-02f, 4.20107506e-02f,
  -1.29493669e-01f, -2.05036804e-01f, -5.90985222e-03f, 5.37838861e-02f, 1.20597817e-02f, -7.44945034e-02f, -3.59214004e-03f, -3.71122360e-02f, -1.15330227e-01f, -4.07097042e-02f,
  7.11834617e-03f, 8.17837194e-02f, 5.82775213e-02f, -2.26212908e-02f, -5.55947423e-02f, -5.02106473e-02f, -5.26606962e-02f, -2.23799646e-02f, 2.34961007e-02f, -7.02932104e-02f,
  -4.73110229e-02f, 8.91356915e-03f, 4.75613885e-02f, 6.56740740e-02f, 1.65948234e-02f, -5.83810993e-02f, 7.00327829e-02f, -3.34398374e-02f, -6.08767644e-02f, -5.74569218e-02f,
  -5.12344874e-02f, -2.36842558e-01f, 1.24911197e-01f, 1.42991364e-01f, 8.08821023e-02f, 1.80951416e-01f, 1.72762290e-01f, -1.94730952e-01f, -1.27624109e-01f, -3.07223886e-01f,
  6.50176853e-02f, -8.82474780e-02f, 6.85360581e-02f, -1.27576599e-02f, 2.41515771e-01f, 9.60529223e-02f, 1.21486627e-01f, 6.39768392e-02f, 6.93544149e-02f, -8.94453898e-02f,
  1.17083877e-01f, -2.49909703e-02f, 1.11486800e-01f, 8.15878622e-03f, 1.08778305e-01f, -2.74705254e-02f, -1.25744045e-02f, 5.08161411e-02f, 4.06631716e-02f, 1.10975221e-01f,
  -1.34763628e-01f, -1.02570355e-01f, -2.61175837e-02f, 5.84142059e-02f, 2.62111779e-02f, 2.52961018e-03f, 1.75125506e-02f, 1.50461331e-01f, 6.32549748e-02f, 2.05344334e-02f,
  5.01463637e-02f, -5.91749996e-02f, 5.14651127e-02f, 7.91187584e-02f, -4.46750000e-02f, 1.63597632e-02f, -6.84833527e-02f, -6.79556141e-03f, -7.57034728e-03f, -5.01321629e-02f,
  -5.99625073e-02f, 3.02379411e-02f, -4.00128886e-02f, -6.71852827e-02f, -4.87632751e-02f, -7.32234940e-02f, 6.46487996e-02f, -3.33862975e-02f, -1.11052118e-01f, -1.10126786e-01f,
  -5.83559722e-02f, -6.32032007e-02f, -8.14531073e-02f, -4.89725098e-02f, -4.01379243e-02f, -4.61032242e-02f, 8.77779871e-02f, 1.87202264e-02f, 2.30939798e-02f, 3.38183790e-02f,
  -5.21611460e-02f, -2.01366749e-02f, -4.17900607e-02f, -5.12622744e-02f, -5.19920550e-02f, 1.00488495e-03f, -1.01580052e-02f, -7.37136789e-03f, 4.92319744e-03f, 2.84870097e-04f,
  -3.62022184e-02f, 6.28606975e-02f, 1.52959842e-02f, -4.00138311e-02f, -3.08220033e-02f, 2.80772010e-03f, 9.15782433e-03f, 2.94620059e-02f, 3.16092633e-02f, -1.93303414e-02f,
  -1.99719787e-01f, -1.35715768e-01f, -3.48008843e-03f, -1.01178333e-01f, -1.11790091e-01f, -1.13711223e-01f, -8.13418850e-02f, -8.61383900e-02f, -4.04770970e-02f, 6.40295818e-02f,
  -3.23813334e-02f, 7.55756944e-02f, 1.94344763e-02f, 1.91305876e-02f, 5.24241757e-03f, -3.73763754e-03f, -7.58911222e-02f, -7.97859952e-02f, -7.43274540e-02f, -7.41030723e-02f,
  -1.12539232e-01f, 7.73329288e-03f, 3.22538018e-02f, -7.87646472e-02f, -8.56583193e-02f, -2.20463071e-02f, -1.53697934e-02f, -3.92530710e-02f, -7.11493045e-02f, -3.25211659e-02f,
  7.27965310e-02f, 1.68120295e-01f, 3.02773178e-01f, 2.79007465e-01f, -1.66656956e-01f, -2.09568560e-01f, -1.26021102e-01f, 5.72566390e-02f, -7.00799599e-02f, -5.27747013e-02f,
  -9.55467671e-02f, 2.43359342e-01f, 9.62057151e-03f, 4.24152948e-02f, 1.08804762e-01f, -8.11081976e-02f, 5.23010790e-02f, 3.74224447e-02f, -4.76603210e-02f, 1.08952120e-01f,
  1.01380810e-01f, -6.28641322e-02f, 1.32067963e-01f, 6.62494525e-02f, 7.43371844e-02f, 1.08685650e-01f, 2.95781307e-02f, 8.55694637e-02f, 1.38423771e-01f, -3.75878735e-04f,
  1.12256957e-02f, 1.06459580e-01f, 1.26890451e-01f, -3.51862088e-02f, 5.04704341e-02f, 1.36409765e-02f, 9.96040404e-02f, 8.09305236e-02f, 5.21499924e-02f, -2.02413015e-02f,
  3.21411900e-02f, -2.16380972e-02f, 4.04936224e-02f, 7.13977367e-02f, -1.42770642e-02f, 2.18227822e-02f, -3.35003026e-02f, -4.00390103e-02f, 3.65578011e-02f, 1.45185608e-02f,
  1.76517308e-01f, 5.50382659e-02f, 3.41434479e-02f, -4.87560518e-02f, 1.24908499e-01f, -3.52659933e-02f, 1.02890857e-01f, 1.08723469e-01f, 7.88382515e-02f, 5.06257825e-02f,
  1.84863303e-02f, -6.36636466e-02f, -6.68975189e-02f, 5.06238304e-02f, 2.51076147e-02f, 6.52411282e-02f, -1.97188444e-02f, 4.34835069e-02f, -6.21381998e-02f, -7.22781271e-02f,
  -2.55795456e-02f, -1.14561040e-02f, -6.97623119e-02f, -5.57507426e-02f, 5.96601106e-02f, -9.60342702e-04f, 9.71468389e-02f, -6.47023395e-02f, -6.54752366e-03f, -2.64139604e-02f,
  -5.28903753e-02f, -3.93433459e-02f, 4.38420512e-02f, 6.91324696e-02f, -9.94937941e-02f, 3.46268974e-02f, -2.04147361e-02f, -1.13892481e-02f, -7.84340501e-02f, 1.10806702e-02f,
  3.86765227e-02f, 1.10379130e-01f, 6.64874017e-02f, 5.47510460e-02f, 2.04543397e-02f, -4.38446216e-02f, 3.01444177e-02f, 9.92762763e-03f, 2.74818316e-02f, -7.22536892e-02f,
  7.52379373e-02f, -6.75429329e-02f, -1.49616804e-02f, -5.65598235e-02f, 3.76084894e-02f, -4.43303399e-02f, 7.14454949e-02f, 3.69211957e-02f, -2.05072444e-02f, 1.59027606e-01f,
  2.50000879e-02f, -5.01336418e-02f, 1.13300741e-01f, -5.48190922e-02f, -5.78582026e-02f, -5.88690154e-02f, -7.55830705e-02f, 3.97318155e-02f, -3.52890640e-02f, 4.32391241e-02f,
  -1.39368713e-01f, 2.39259303e-01f, 5.77083044e-02f, -1.17856972e-01f, -4.82146740e-02f, -6.99614435e-02f, -2.84392796e-02f, 1.39863998e-01f, 3.08520347e-02f, 7.17793703e-02f,
  2.83834934e-02f, 5.98203726e-02f, 1.36666670e-01f, -3.29219699e-02f, -2.65565038e-01f, -7.64316842e-02f, -1.09319709e-01f, -1.17008202e-01f, -1.85629856e-02f, 2.43688636e-02f,
  -3.06401066e-02f, 5.48755117e-02f, -1.20182037e-01f, 1.32685184e-01f, -7.80531690e-02f, 2.84503996e-02f, 1.34023651e-02f, 1.68701723e-01f, 3.84402052e-02f, -3.16435546e-02f,
  1.08176272e-03f, 9.34693664e-02f, 4.06050198e-02f, 9.70659181e-02f, 1.99768450e-02f, -9.57058668e-02f, -6.88925907e-02f, -7.88894221e-02f, -3.03645656e-02f, -6.40533641e-02f,
  6.28347620e-02f, 6.97647780e-03f, 6.21667430e-02f, 3.05511465e-04f, 7.28589818e-02f, -5.53730084e-03f, 7.55330771e-02f, -9.47103277e-02f, 4.43279138e-03f, -1.37178199e-02f,
  -2.01012585e-02f, -5.86979464e-02f, -1.44556013e-03f, -3.19530144e-02f, -1.00846522e-01f, 5.99114865e-04f, -6.10219613e-02f, -9.76063386e-02f, -5.23424149e-02f, -8.72540995e-02f,
  -2.72606574e-02f, -6.86854795e-02f, -5.33464625e-02f, -7.08849281e-02f, -5.69512434e-02f, -3.41001595e-03f, 9.59752966e-03f, -8.22451860e-02f, -8.14866796e-02f, -6.50451779e-02f,
  4.40400727e-02f, 6.18054764e-03f, 6.31981343e-02f, -8.70074704e-02f, -6.51950985e-02f, -4.27736379e-02f, -7.62570277e-02f, -1.06729734e-04f, 3.97063419e-02f, -2.74511371e-02f,
  -4.30183820e-02f, -4.34498228e-02f, -4.46862914e-03f, -5.36952466e-02f, 2.12571584e-02f, 1.10387197e-02f, 8.38900506e-02f, 5.74086094e-03f, -7.25473464e-02f, 3.13498639e-02f,
  -4.50705327e-02f, 4.41881567e-02f, 9.55917016e-02f, 8.59485120e-02f, 9.00000706e-02f, 7.98021555e-02f, 7.39766210e-02f, -5.64774126e-02f, -2.95828246e-02f, 1.13215996e-02f,
  4.41482998e-02f, 6.06667064e-02f, 6.28574118e-02f, -7.53916502e-02f, -3.10087930e-02f, 5.11074215e-02f, -2.59191431e-02f, -4.30988520e-02f, -6.57371478e-03f, -2.19637416e-02f,
  1.18434899e-01f, -1.67477913e-02f, -8.90745521e-02f, -1.41918648e-03f, 5.14042452e-02f, -8.58193543e-03f, -2.66867131e-03f, -1.91730093e-02f, -4.06504571e-02f, 6.75536543e-02f,
  1.67509481e-01f, 6.59390539e-02f, -2.79817730e-01f, -8.78541768e-02f, -4.28824611e-02f, 1.39812469e-01f, 1.63556173e-01f, -1.51968330e-01f, 3.58313024e-02f, 7.55386353e-02f,
  4.23677005e-02f, 1.55477813e-02f, 1.11898117e-01f, 1.67353004e-01f, 8.96306038e-02f, 1.62418410e-01f, 9.50493589e-02f, 2.37159878e-01f, 5.40004112e-02f, -9.73351672e-02f,
  2.03774776e-02f, 1.60532176e-01f, -1.24416851e-01f, -4.32366319e-02f, -9.77365151e-02f, -2.54365414e-01f, 6.23053350e-02f, -1.63197428e-01f, -1.38603449e-01f, -1.12769455e-02f,
  7.09362924e-02f, 6.97293654e-02f, -1.16569862e-01f, 6.83300048e-02f, -5.72055345e-03f, -5.24841882e-02f, -2.49330103e-02f, 5.90060391e-02f, -5.62707707e-02f, 1.61077399e-02f,
  -1.90898906e-02f, 7.54900277e-03f, 6.26855269e-02f, -2.78645791e-02f, 3.13576832e-02f, -7.09338263e-02f, -1.17217243e-01f, 1.07063062e-03f, -1.15746796e-01f, -4.80865799e-02f,
  -1.25049695e-01f, -4.97257859e-02f, 4.73201349e-02f, -6.27833307e-02f, -1.24323592e-01f, -2.62444653e-02f, -5.66714220e-02f, -8.08425918e-02f, 4.15642820e-02f, 4.56638969e-02f,
  -7.30452612e-02f, 2.38005444e-02f, 1.10212676e-01f, 1.37055875e-03f, -6.26857718e-03f, -5.38614430e-02f, -4.97218966e-02f, 7.46463845e-03f, -1.48125198e-02f, -1.42553486e-02f,
  -1.21792238e-02f, 4.82874399e-04f, -5.16989268e-02f, -4.86773886e-02f, 8.83611664e-02f, -6.93180338e-02f, -3.98577079e-02f, 6.45508841e-02f, -1.09059982e-01f, -1.88280381e-02f,
  -9.16892104e-03f, 3.04043181e-02f, -3.97908017e-02f, -8.29816386e-02f, -5.72507866e-02f, -7.84380548e-03f, 7.55912736e-02f, 1.49428407e-02f, -4.70077656e-02f, 1.29813813e-02f,
  2.13167891e-02f, 8.84947404e-02f, 3.25145051e-02f, -2.47070044e-02f, -7.54274130e-02f, -2.28272562e-04f, 1.89165361e-02f, 8.30717105e-03f, 7.49279037e-02f, -3.45453434e-02f,
  7.92255029e-02f, 2.49788701e-03f, 4.86643985e-02f, -1.08911330e-02f, 1.12302722e-02f, 6.13394566e-02f, 3.39211058e-03f, -8.50953162e-04f, 3.51392129e-03f, -1.08559998e-02f,
  3.13702896e-02f, 4.17966656e-02f, 3.40334699e-02f, -2.90236417e-02f, 5.43915257e-02f, -7.45006558e-03f, 1.90735832e-02f, -3.52781229e-02f, -6.99258521e-02f, 2.48861630e-02f,
  -5.30544743e-02f, -2.75666505e-01f, -4.77553122e-02f, 9.18787643e-02f, 2.43171826e-02f, 1.00333489e-01f, 5.10949790e-02f, -2.09031880e-01f, -4.21791166e-01f, -5.06902263e-02f,
  5.05644530e-02f, 5.96937016e-02f, -1.18005484e-01f, -6.38386235e-02f, -4.33345698e-02f, -2.33541429e-01f, 1.59657001e-02f, 2.14702208e-02f, -1.66430160e-01f, -2.45966874e-02f,
  -1.65303070e-02f, -3.33690434e-03f, -5.83960935e-02f, 7.72358701e-02f, 1.70696035e-01f, 1.26344964e-01f, 3.12964201e-01f, 1.46787703e-01f, 3.05259943e-01f, 1.25287056e-01f,
  -1.14464760e-01f, -1.53404415e-01f, 2.79275384e-02f, -3.24418284e-02f, 4.25592549e-02f, 5.96848316e-02f, 1.58535749e-01f, 1.82559341e-01f, 6.33882955e-02f, -7.61614740e-02f,
  7.50898942e-02f, -2.08616890e-02f, 1.49816822e-03f, -3.91281992e-02f, -2.81357160e-03f, -3.96133475e-02f, -1.02995098e-01f, -3.20473611e-02f, 5.71028050e-03f, -1.12654984e-01f,
  -5.08636832e-02f, 6.23441208e-03f, 7.51257762e-02f, 6.51774481e-02f, -1.50537509e-02f, 3.67936604e-02f, 2.89746970e-02f, 1.41658947e-01f, 7.91928768e-02f, 2.71792663e-03f,
  -3.18335705e-02f, 1.18448086e-01f, 4.96585220e-02f, -8.24110433e-02f, 1.08753704e-02f, 9.20844004e-02f, 3.09390370e-02f, -2.93149911e-02f, 4.49807756e-02f, -3.16527821e-02f,
  3.91007811e-02f, 2.63828710e-02f, -6.13512993e-02f, 8.67506769e-03f, 3.55981179e-02f, -3.35380770e-02f, 8.09836611e-02f, 6.68669939e-02f, -5.00256009e-02f, 1.16737131e-02f,
  -2.91437525e-02f, 3.11439577e-02f, -2.85726842e-02f, 1.50790606e-02f, -8.75836611e-02f, -1.57100204e-02f, 8.22219029e-02f, -5.75539749e-03f, 4.53649275e-02f, 1.14271410e-01f,
  -2.74991281e-02f, 9.58815143e-02f, -6.38744086e-02f, -5.98407071e-03f, -4.37827688e-03f, 2.21833773e-02f, 3.19996104e-03f, -4.39718775e-02f, -5.18658422e-02f, 1.46269435e-02f,
  1.20847046e-01f, 1.01235732e-01f, 9.50543955e-02f, 5.36876135e-02f, -5.37927169e-03f, -2.16349177e-02f, 9.32810158e-02f, 9.60654207e-03f, 1.19987153e-01f, 6.68414682e-02f,
  4.89148386e-02f, 6.64279386e-02f, -3.34488004e-02f, 4.89936396e-02f, 6.87006712e-02f, 1.34511054e-01f, 4.12332527e-02f, -3.70600335e-02f, 6.85877427e-02f, 1.36078130e-02f,
  2.80142486e-01f, 5.32952137e-04f, -1.98523477e-01f, -2.10871056e-01f, 5.54163940e-02f, 7.01040030e-02f, 6.55681267e-02f, 4.76848483e-02f, -2.44581625e-01f, 7.00539127e-02f,
  1.63017139e-01f, -4.93879057e-02f, 1.09838232e-01f, 4.98489700e-02f, 1.07053630e-01f, 3.47667895e-02f, 1.27604172e-01f, 1.11598656e-01f, -6.79476261e-02f, 1.92018196e-01f,
  1.83242355e-02f, 9.86055136e-02f, 3.35296951e-02f, 9.07192826e-02f, 1.95015535e-01f, -3.97137664e-02f, 1.33127317e-01f, -8.25506228e-04f, 8.92591253e-02f, -1.25135938e-02f,
  -2.67014429e-02f, 4.01455909e-02f, -3.77811901e-02f, -4.42415960e-02f, 3.72332372e-02f, 9.66868177e-02f, 4.00819518e-02f, -5.52997217e-02f, -4.40361723e-02f, 4.22305614e-02f,
  6.38271794e-02f, -5.35878120e-03f, 6.16596416e-02f, -8.18488970e-02f, -1.12278024e-02f, -6.14869818e-02f, 3.39516364e-02f, 2.28398032e-02f, -6.70802966e-02f, 4.99454178e-02f,
  3.96088287e-02f, 5.83826825e-02f, -4.26129401e-02f, -3.17780152e-02f, -1.44312292e-01f, 3.84085365e-02f, 3.39447372e-02f, 8.16736966e-02f, 3.12469956e-02f, 9.12452489e-02f,
  1.00015603e-01f, 5.92705570e-02f, 7.25152716e-02f, -2.31501330e-02f, 1.51240686e-02f, -4.90892306e-02f, -7.22299591e-02f, -2.24085394e-02f, -9.83040035e-02f, 9.55183804e-02f,
  1.31958853e-02f, -2.75932495e-02f, 8.79659411e-03f, 3.79391275e-02f, 6.44915104e-02f, -3.52576673e-02f, -4.40398492e-02f, 5.68163116e-03f, 9.44185909e-03f, -5.18704467e-02f,
  -3.62096131e-02f, 3.54196392e-02f, 6.77145869e-02f, 1.51794031e-02f, 6.69332147e-02f, 4.41216901e-02f, 8.75771940e-02f, 1.21575482e-02f, -8.25703219e-02f, 6.81584422e-03f,
  1.38151988e-01f, 1.94578752e-01f, -5.76208830e-02f, -2.93018986e-02f, 3.18562835e-02f, 3.45024653e-02f, -4.37430032e-02f, 7.71232769e-02f, 9.99966487e-02f, 7.35877156e-02f,
  1.33176073e-01f, -3.80173326e-02f, 5.96841238e-03f, -3.40375639e-02f, -9.06601027e-02f, 1.50252536e-01f, -5.18977940e-02f, -1.68611892e-02f, 2.17020046e-02f, 1.11095300e-02f,
  2.19498500e-02f, 7.88352918e-03f, 8.68242420e-03f, -6.08061478e-02f, 5.67877702e-02f, 9.04102549e-02f, 9.25612971e-02f, 5.50029948e-02f, -1.41980289e-03f, 2.60280501e-02f,
  -2.45546140e-02f, -1.94511965e-01f, 2.10161567e-01f, 7.53809661e-02f, -2.73428112e-03f, 6.61457479e-02f, 2.41374999e-01f, -1.89160705e-01f, -2.37421229e-01f, -3.01844869e-02f,
  5.02933525e-02f, 1.05501905e-01f, 7.79887587e-02f, -7.32550174e-02f, 1.44529149e-01f, -1.31065752e-02f, -8.07061642e-02f, 1.11469835e-01f, -1.02214217e-01f, 1.11351743e-01f,
  3.50664519e-02f, -1.52394712e-01f, 1.29002675e-01f, -9.97901410e-02f, -4.50183228e-02f, 4.46855500e-02f, 8.00323114e-02f, 2.85620123e-01f, 1.25187606e-01f, 9.36041176e-02f,
  -1.06943779e-01f, -9.08688307e-02f, -8.08332860e-02f, 4.16974761e-02f, 2.77749840e-02f, 9.76196527e-02f, 1.40561670e-01f, 9.12445039e-02f, -2.77399551e-02f, -9.27692875e-02f,
  -4.03093733e-02f, 3.73817645e-02f, -7.11467341e-02f, 3.97959352e-02f, -9.47760865e-02f, 1.30784838e-02f, 1.64620318e-02f, 8.57241731e-03f, -6.69390634e-02f, 3.20901647e-02f,
  3.21276151e-02f, -1.10850833e-01f, -3.54644023e-02f, -4.68365327e-02f, 1.08093493e-01f, -9.60430875e-02f, -6.74710274e-02f, 9.56014097e-02f, -1.02761902e-01f, -3.03257443e-02f,
  -1.27130207e-02f, 7.30967149e-02f, -5.23433276e-02f, 7.59182870e-02f, 1.71648036e-03f, 2.76324470e-02f, -5.58481477e-02f, -2.00270899e-02f, -5.86011261e-02f, 2.47527249e-02f,
  7.97590539e-02f, 1.47877317e-02f, -1.05100580e-01f, 4.28019911e-02f, 1.40295317e-02f, 6.49399906e-02f, 1.05260581e-01f, -6.89056665e-02f, 4.90052067e-02f, -7.06431791e-02f,
  -1.74343996e-02f, 4.85395342e-02f, 8.40627775e-02f, 6.71468750e-02f, -4.77996841e-02f, 6.73775673e-02f, -1.24565609e-01f, -1.08105913e-02f, -3.50156538e-02f, 6.06847815e-02f,
  -2.28610057e-02f, 1.12046354e-01f, -7.25856870e-02f, -7.85953999e-02f, 1.99487638e-02f, -8.08878615e-02f, 3.29376496e-02f, -5.24959154e-02f, -4.96385898e-03f, -1.00549519e-01f,
  -2.23549511e-02f, 4.06193435e-02f, 6.88366964e-02f, 5.20426035e-02f, 1.19864486e-01f, -6.72802851e-02f, 8.14754665e-02f, -5.52564226e-02f, -4.70066704e-02f, 3.69599499e-02f,
  -8.60070884e-02f, 6.33576885e-04f, -3.78668518e-03f, -2.01489571e-02f, -9.39685330e-02f, -1.18615273e-02f, 3.93737704e-02f, 7.62806311e-02f, 6.23132214e-02f, -3.40704620e-02f,
  1.21716000e-01f, 2.17197780e-02f, 6.43085390e-02f, -2.96736276e-03f, -7.38580823e-02f, -5.66162467e-02f, 1.12135731e-01f, -1.20961657e-02f, -5.62438257e-02f, 1.16905468e-02f,
  1.47878960e-01f, 6.48549721e-02f, 4.79308218e-02f, 1.43291354e-01f, 1.54636338e-01f, 7.06435144e-02f, 8.33237097e-02f, 3.81718427e-02f, -7.11695254e-02f, 3.19788828e-02f,
  3.76369879e-02f, 1.52225062e-01f, 1.22072659e-01f, -6.66044056e-02f, 5.31626232e-02f, 9.42888334e-02f, 1.06419578e-01f, 1.17390424e-01f, -3.43392529e-02f, 6.87997490e-02f,
  6.11134283e-02f, 1.00943357e-01f, 4.08517383e-02f, -3.24544460e-02f, -5.71262464e-02f, -3.20584290e-02f, 6.20641634e-02f, -9.04375501e-03f, 7.22171962e-02f, 6.73258230e-02f,
  3.49982940e-02f, 5.04092313e-02f, -6.46052277e-03f, 1.22625269e-02f, 3.10236719e-02f, -6.55318331e-03f, -8.36715400e-02f, -6.02131523e-02f, -8.02703649e-02f, 4.52394038e-02f,
  7.63059705e-02f, 1.55411391e-02f, -1.51846465e-02f, 1.15999300e-02f, -7.30382744e-03f, -1.14760650e-02f, -5.98230213e-02f, -8.15783814e-03f, 4.74305190e-02f, -7.47249052e-02f,
  9.23931822e-02f, 3.40369120e-02f, 4.11144868e-02f, -5.42194322e-02f, 4.31705825e-02f, 1.12253502e-02f, 4.85452600e-02f, 3.66343232e-03f, 2.52540186e-02f, 7.12127388e-02f,
  -7.06427321e-02f, 3.67556065e-02f, 4.79192138e-02f, 7.75840059e-02f, -1.86290883e-03f, 7.13176355e-02f, 6.68795481e-02f, 6.33986145e-02f, -9.16759856e-03f, -7.99327493e-02f,
  1.21923508e-02f, -5.68962172e-02f, -4.80653420e-02f, -2.11140774e-02f, 5.74661642e-02f, -4.87220287e-02f, -4.51901145e-02f, -5.98357618e-02f, -4.76794168e-02f, -3.41484249e-02f,
  -2.40342375e-02f, 1.58823133e-01f, -1.22370366e-02f, -7.09113628e-02f, -4.41483147e-02f, 1.66619588e-02f, -6.52376888e-03f, -2.95703346e-03f, 5.26988395e-02f, -5.73734380e-02f,
  -7.53515884e-02f, -5.80612049e-02f, -4.20235209e-02f, 5.18388115e-02f, -7.67667145e-02f, -3.25541850e-03f, -5.13192378e-02f, 4.25371565e-02f, 5.61989285e-03f, 4.22604159e-02f,
  9.08233896e-02f, 7.41157979e-02f, 9.39154178e-02f, -3.03750914e-02f, 4.15557027e-02f, 8.73540491e-02f, -8.49227160e-02f, 3.63964564e-03f, 8.65201354e-02f, 7.19721168e-02f,
  1.57399755e-02f, 3.70049514e-02f, 1.05267458e-01f, -1.98619649e-01f, -3.20165395e-03f, 9.57639609e-03f, -5.58109730e-02f, 8.04157928e-02f, -1.41437620e-01f, 1.72917321e-01f,
  3.29766162e-02f, 2.08731685e-02f, -7.73032084e-02f, -1.40381500e-01f, -2.77842045e-01f, -1.31140515e-01f, -4.81527112e-02f, -8.04440901e-02f, -6.54183701e-02f, -1.45414192e-02f,
  -6.93127289e-02f, -1.41179278e-01f, -4.56084497e-02f, 1.51112556e-01f, 4.57569771e-02f, 2.00093552e-01f, 1.37713641e-01f, 1.97894797e-02f, 1.36195049e-01f, 2.73289271e-02f,
  5.97594632e-03f, -8.22530016e-02f, 8.51920545e-02f, -1.75114907e-03f, 1.23807788e-01f, 1.51609659e-01f, 1.78119913e-02f, -1.29683718e-01f, -8.02371353e-02f, -5.15798479e-02f,
  1.19595595e-01f, -2.06648707e-02f, 5.56893740e-03f, -8.77697319e-02f, 6.17864588e-03f, -5.17651103e-02f, 7.50439838e-02f, 7.53122941e-02f, 6.81096092e-02f, 7.96134025e-02f,
  -5.76600097e-02f, 8.53949487e-02f, 1.06357016e-01f, -9.06111747e-02f, -2.96534281e-02f, 5.41473851e-02f, 6.22865092e-03f, 5.40744029e-02f, 8.75790268e-02f, -6.47614524e-02f,
  1.06536493e-01f, -6.21992983e-02f, -5.28691895e-03f, 1.58951245e-02f, -9.22103301e-02f, -2.15753391e-02f, 2.89322920e-02f, 9.50101689e-02f, -7.53315315e-02f, -2.65771579e-02f,
  -3.35257947e-02f, 5.33082448e-02f, -7.64730126e-02f, 6.59462512e-02f, -6.24472760e-02f, 3.83002497e-02f, 8.59735906e-02f, -2.26292480e-02f, -2.67491899e-02f, 6.75820485e-02f,
  -3.40911709e-02f, -5.05108722e-02f, 3.21809202e-03f, 1.80211477e-02f, -5.09566069e-03f, 3.14949267e-02f, -4.92167734e-02f, 3.96364182e-02f, -5.67339845e-02f, -5.68030365e-02f,
  8.46442357e-02f, 1.48166791e-01f, 5.44851692e-03f, 3.37935202e-02f, 6.10162616e-02f, 1.21472128e-01f, 4.68175039e-02f, 2.18621339e-03f, 3.30441445e-02f, 3.45164612e-02f,
  5.72014749e-02f, 6.06913082e-02f, -4.50144522e-02f, 6.00117967e-02f, 4.83364463e-02f, 1.96430162e-02f, -3.66050825e-02f, 2.79596280e-02f, 6.20730408e-02f, 2.17872877e-02f,
  7.95790751e-04f, 1.12763671e-02f, -4.84206602e-02f, -3.62977162e-02f, -5.74104562e-02f, -2.62809806e-02f, 6.57413974e-02f, -1.95354987e-02f, 3.53285670e-02f, -9.50206537e-03f,
  -2.67202314e-02f, -3.19859162e-02f, 1.95122033e-01f, -1.54055264e-02f, -1.31250173e-01f, 8.54663625e-02f, 3.75206508e-02f, -9.23167262e-03f, -6.92291409e-02f, 4.82976325e-02f,
  7.70213977e-02f, 5.07270806e-02f, 1.81845292e-01f, -2.12100327e-01f, -9.79509801e-02f, -7.36694634e-02f, -1.42326981e-01f, -6.47139773e-02f, -1.20809056e-01f, 7.30365813e-02f,
  -1.40688762e-01f, -1.70968264e-01f, 8.87803384e-04f, -9.85406619e-03f, -6.42007068e-02f, 1.84212755e-02f, 9.95703231e-05f, 4.52430584e-02f, 4.86920215e-02f, -4.00780998e-02f,
  -1.39576182e-01f, -2.67753880e-02f, 3.72806340e-02f, 3.92111577e-02f, 3.49258855e-02f, 5.93110062e-02f, 4.11371179e-02f, -7.43884221e-02f, 1.14503056e-02f, 6.40435964e-02f,
  3.69757377e-02f, 2.28193644e-02f, -1.09501425e-02f, -7.51165375e-02f, -7.47397989e-02f, -9.84677821e-02f, -3.89810316e-02f, 3.73836868e-02f, -2.74775904e-02f, -3.62201929e-02f,
  5.70936389e-02f, 3.07186716e-03f, 8.28380883e-02f, 1.15711287e-01f, 5.18008247e-02f, 7.47358100e-03f, 4.39807624e-02f, 1.17029801e-01f, -3.76829542e-02f, 4.65711346e-03f,
  -3.52941919e-03f, 2.71316376e-02f, 8.33752602e-02f, -3.05199474e-02f, 6.40245378e-02f, -7.37238973e-02f, -6.26564175e-02f, -9.39023942e-02f, -3.89157189e-03f, 3.50189619e-02f,
  6.18669316e-02f, 3.82253081e-02f, 3.87336351e-02f, 1.27305463e-02f, -5.76605611e-02f, -1.64259002e-02f, 1.09257586e-01f, -3.20579335e-02f, -3.46574895e-02f, 2.53921151e-02f,
  1.07998902e-03f, -3.73197272e-02f, 4.13204096e-02f, 7.61098936e-02f, 3.21095437e-02f, 3.91981639e-02f, 5.61159179e-02f, -4.30529080e-02f, -5.76522350e-02f, -2.86701345e-03f,
  -9.93475839e-02f, 1.60507970e-02f, -4.51824367e-02f, -3.14777419e-02f, -9.79416370e-02f, 1.63868070e-02f, -9.32147056e-02f, 5.02854846e-02f, 1.24483733e-02f, -4.90604490e-02f,
  -6.82836473e-02f, -2.23288499e-02f, -6.81911260e-02f, -9.10763741e-02f, -1.98750421e-02f, -5.15563115e-02f, -5.50043322e-02f, -7.25763738e-02f, 2.95495149e-02f, -5.12966812e-02f,
  6.54481398e-03f, 2.08602361e-02f, 7.67314658e-02f, 8.16109478e-02f, 1.97086260e-02f, 2.99888570e-02f, 8.14344510e-02f, 3.18404734e-02f, 7.00613251e-03f, 2.36165319e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.51042104e-01f, 1.12325698e-01f, -9.76726320e-03f, 1.60247535e-01f, 4.10380326e-02f, 2.25213885e-01f, 7.94216245e-02f, 2.02919573e-01f, 2.03675821e-01f, 1.62347868e-01f,
  2.56690770e-01f, 3.14026624e-01f, 2.50808418e-01f, 2.73169041e-01f, 1.48688197e-01f, 1.51899189e-01f, 1.14505820e-01f, 7.02508986e-02f, 8.17559510e-02f, 2.31801063e-01f,
  3.43894303e-01f, 1.24145389e-01f, 5.75540438e-02f, -1.25829102e-02f, 9.45693031e-02f, 1.87752336e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -4.82059449e-01f, -4.01964597e-02f, -6.57472387e-02f, -3.03534139e-02f, 2.29160488e-01f, 1.96620107e-01f, 1.37009650e-01f, -1.34856939e-01f, 1.50749147e-01f, 2.56038066e-02f,
  1.32088764e-02f, -5.01963913e-01f, -2.49287814e-01f, 8.63723904e-02f, 4.40972336e-02f, -6.52424917e-02f, -1.81029037e-01f, -5.50343156e-01f, -1.62201360e-01f, 4.57843035e-01f,
  4.93735336e-02f, 2.48043835e-01f, -5.64281270e-03f, -1.02405936e-01f, 2.50900537e-02f, 6.82906434e-02f, 3.41104686e-01f, -2.83085883e-01f, -1.95761591e-01f, 9.64830741e-02f,
  -4.70514894e-01f, -4.94514555e-01f, 2.67444551e-01f, -1.68320060e-01f, -4.65734750e-01f, 4.17294502e-01f, -3.73232156e-01f, 3.84286016e-01f, -2.07424268e-01f, 4.36425477e-01f,
  -2.28042342e-02f, -1.51239544e-01f, -3.99837233e-02f, 2.65228674e-02f, 5.05022526e-01f, -4.35383879e-02f, -2.26843238e-01f, 2.98922211e-01f, -1.80580944e-01f, -2.53310263e-01f,
  9.05457139e-02f, -7.15468898e-02f, 5.90396166e-01f, -1.82738230e-01f, 1.27113640e-01f, -1.22600533e-01f, -6.79098116e-03f, 1.98566362e-01f, -1.01780407e-01f, -5.12716249e-02f,
  -2.99622416e-02f, -2.22583045e-03f, -7.92637989e-02f, 6.69494458e-03f, 3.75548601e-01f, 1.02431543e-01f, -3.65051687e-01f, -5.76859005e-02f, 1.79138146e-02f, -3.82438093e-01f,
  1.80512801e-01f, -2.57591933e-01f, 6.83006793e-02f, -1.29348621e-01f, 2.79205833e-02f, 6.59952760e-02f, -1.47570660e-02f, 1.53324567e-02f, -7.60910735e-02f, 2.13878289e-01f,
  1.44429505e-01f, 1.25065893e-01f, -2.26262942e-01f, 3.56373608e-01f, 2.64091223e-01f, 2.04306722e-01f, -2.76003964e-02f, -4.60873127e-01f, -2.40731835e-01f, 4.05712277e-01f,
  4.83354986e-01f, 5.33158481e-01f, 3.99012387e-01f, 2.00305209e-01f, -1.38414904e-01f, -3.25186789e-01f, -6.49616063e-01f, -4.92645539e-02f, 2.55459368e-01f, -6.48087561e-02f,
  -2.01487586e-01f, -5.46824753e-01f, -4.43245620e-02f, 6.98652685e-01f, -1.93884969e-01f, -2.71549851e-01f, 1.55077606e-01f, -3.20153356e-01f, -4.29990552e-02f, -1.98162213e-01f,
  -2.24798638e-02f, -4.14021732e-03f, -3.30471307e-01f, 1.11804288e-02f, -2.40760431e-01f, 2.88018174e-02f, 1.27405182e-01f, 2.12901101e-01f, -1.57984436e-01f, -1.39608532e-01f,
  -1.04583204e-01f, 4.21623468e-01f, -1.15616649e-01f, 5.77769339e-01f, -2.16463864e-01f, 1.40173808e-01f, 2.68599764e-02f, -2.82979190e-01f, -2.87760407e-01f, 1.29858941e-01f,
  1.76353246e-01f, 1.42977372e-01f, -3.54941189e-01f, -2.78164476e-01f, -1.35591850e-01f, 4.07549832e-03f, -5.70429027e-01f, -1.90652221e-01f, -3.91474336e-01f, 1.11582242e-01f,
  -7.37989619e-02f, -3.14372852e-02f, 5.42392880e-02f, -1.61969483e-01f, 4.47749160e-02f, 1.01784967e-01f, 2.08631516e-01f, -4.65812147e-01f, 2.79973269e-01f, 1.03875391e-01f,
  4.19774860e-01f, -4.76944506e-01f, -5.03753185e-01f, -3.95784760e-03f, 3.43848795e-01f, 3.10836345e-01f, 3.42782557e-01f, 3.99069220e-01f, -2.57517606e-01f, 4.90296483e-01f,
  -1.28807485e-01f, -8.86940286e-02f, 1.33093804e-01f, -1.97615638e-01f, 3.66142154e-01f, 1.48751144e-03f, -5.94875328e-02f, 2.39117712e-01f, 4.99177761e-02f, -4.09525447e-02f,
  -1.77912027e-01f, -1.62541389e-01f, -1.62791207e-01f, -1.90115109e-01f, -2.36025751e-01f, -2.52374858e-01f, 5.02904117e-01f, -4.39495854e-02f, -5.12296893e-02f, -2.45025575e-01f,
  5.22173895e-03f, -1.74718738e-01f, 2.55795091e-01f, 5.75776994e-02f, -1.52479663e-01f, -5.41447401e-02f, 4.06042129e-01f, -1.39939353e-01f, 8.79864022e-03f, -8.55028108e-02f,
  -7.88946263e-03f, -2.38698810e-01f, 1.99899033e-01f, -1.21761940e-01f, -6.83715343e-02f, 1.69478059e-01f, 1.93550795e-01f, -4.21952039e-01f, 2.20804196e-02f, -1.37597891e-02f,
  -2.36372650e-02f, -2.14890078e-01f, -2.96534896e-01f, -2.04703793e-01f, -7.65086859e-02f, 3.39258537e-02f, 4.75641638e-02f, -5.46646655e-01f, 2.54597515e-01f, 2.18077749e-01f,
  -6.49982840e-02f, 3.14821512e-01f, 4.85057756e-02f, 1.33458018e-01f, -5.22955880e-02f, 3.26187193e-01f, 5.02085209e-01f, 2.36850321e-01f, -2.78903514e-01f, -1.81541979e-01f,
  -2.53921688e-01f, -2.69653022e-01f, -3.45541298e-01f, -1.89517871e-01f, 4.26352918e-02f, 2.33824998e-01f, -3.49228472e-01f, -2.15463325e-01f, -2.05693081e-01f, 1.11015975e-01f,
  3.96268755e-01f, -1.76492751e-01f, 1.44182760e-02f, 5.18833287e-02f, -1.47899121e-01f, 6.61339343e-01f, -1.78369403e-01f, 5.16411662e-01f, -9.97461304e-02f, -1.47805125e-01f,
  -1.86034590e-01f, -4.62360442e-01f, -2.19232276e-01f, 3.67551148e-01f, -3.11004251e-01f, 5.56246229e-02f, -2.08804265e-01f, -2.35256240e-01f, 4.57309276e-01f, -1.08170129e-01f,
  -3.36199284e-01f, -2.69614577e-01f, -1.85699925e-01f, -9.17452797e-02f, 4.85586189e-02f, 9.92422625e-02f, 2.74935663e-01f, 2.66562589e-02f, 2.64715195e-01f, -9.97882336e-03f,
  -1.66039154e-01f, 3.12280566e-01f, 3.72135155e-02f, 1.95722446e-01f, 7.63548985e-02f, -2.06263512e-01f, 7.34636560e-02f, 2.12908834e-02f, 7.54140690e-02f, 8.82293954e-02f,
  9.10605192e-02f, 5.88411987e-01f, 1.55985311e-01f, 9.41606984e-02f, -1.47586346e-01f, 5.14104664e-01f, 3.43985587e-01f, -9.06006172e-02f, 1.13642149e-01f, 1.50485456e-01f,
  2.37140469e-02f, -3.88686180e-01f, -7.04127625e-02f, -2.00087517e-01f, -6.74881458e-01f, -4.77834463e-01f, -5.91706634e-01f, 3.72423500e-01f, 9.11571607e-02f, -4.92385596e-01f,
  -3.64792138e-01f, 3.37762088e-01f, -3.31757218e-02f, 3.87259334e-01f, -3.28433774e-02f, -2.96745300e-01f, 1.33003602e-02f, 3.17148805e-01f, -7.14856610e-02f, 3.45498294e-01f,
  -2.17706785e-01f, -3.36345404e-01f, 7.21743882e-01f, -2.48091310e-01f, 4.97250557e-02f, 1.44463181e-01f, 6.73583150e-02f, 2.07735058e-02f, 2.07546875e-01f, -2.29036361e-01f,
  1.60564929e-01f, -2.59198360e-02f, 1.00642942e-01f, -2.11090550e-01f, -2.95866102e-01f, 4.52235378e-02f, -1.07084131e-02f, -1.59949780e-01f, 1.39039814e-01f, 1.74834043e-01f,
  1.19503975e-01f, -1.14352211e-01f, 2.55428463e-01f, -1.37984201e-01f, -6.06540367e-02f, 4.93891761e-02f, -9.98654068e-02f, 2.52346367e-01f, -1.13860529e-03f, 3.84966969e-01f,
  1.07806757e-01f, 3.22812647e-01f, 7.29236901e-02f, 7.43287310e-05f, 8.69395062e-02f, 1.49645016e-03f, 1.12629063e-01f, 3.45536590e-01f, 1.76181793e-01f, 1.55565903e-01f,
  -2.99791545e-01f, 4.26682174e-01f, -4.81012374e-01f, 2.73982942e-01f, -3.38756084e-01f, -4.52042758e-01f, -5.37399203e-02f, -4.72786963e-01f, -1.22681193e-01f, 3.06253105e-01f,
  5.20195782e-01f, -1.99106708e-01f, -1.68086156e-01f, -1.00292154e-01f, 6.92630053e-01f, -2.82418907e-01f, -2.83164561e-01f, -2.56374896e-01f, 9.19926167e-03f, -2.35508397e-01f,
  4.27496582e-02f, 6.90725073e-02f, 2.95665145e-01f, -1.97803885e-01f, 2.30008274e-01f, -8.77422094e-02f, -1.04779668e-01f, 6.83487892e-01f, -7.25203454e-02f, 1.96281411e-02f,
  -2.27011383e-01f, 3.28496456e-01f, 3.81733924e-01f, -1.88924745e-01f, -1.59555644e-01f, -1.13756880e-02f, 8.46190006e-02f, 2.01785222e-01f, -1.50050387e-01f, -1.96400769e-02f,
  4.51448597e-02f, -2.17781961e-02f, -2.09608898e-01f, -1.23455981e-02f, 1.53321102e-01f, -1.26212716e-01f, 1.15873516e-01f, 2.02488363e-01f, 1.61885604e-01f, -1.22999899e-01f,
  9.52816382e-02f, -1.92319244e-01f, 2.38507077e-01f, -7.70798922e-02f, 3.42402868e-02f, -4.64657754e-01f, -3.39772612e-01f, 2.80750580e-02f, -1.94106083e-02f, -2.25440666e-01f,
  2.38304704e-01f, -3.15068811e-01f, 1.73307508e-01f, -1.23708621e-01f, -3.80483210e-01f, -1.75021902e-01f, -3.73412967e-01f, 1.82657853e-01f, -3.91117215e-01f, 9.92870107e-02f,
  -6.20734036e-01f, 2.99243271e-01f, 4.53735501e-01f, 4.91157234e-01f, 6.21766627e-01f, 4.82478172e-01f, 1.79951116e-02f, -2.26499185e-01f, 2.92763740e-01f, -3.59845310e-01f,
  4.61975664e-01f, 7.41043761e-02f, 3.15582842e-01f, 6.06427342e-02f, -6.73297420e-02f, 3.65321994e-01f, -1.01268709e-01f, -1.07246630e-01f, -1.89830199e-01f, -1.07670680e-01f,
  6.37515634e-02f, -1.18303612e-01f, 2.94554353e-01f, -1.56654939e-01f, 6.16001666e-01f, -3.08321089e-01f, -2.45390050e-02f, 1.09056197e-01f, 1.67314455e-01f, -2.23445017e-02f,
  -1.39466971e-01f, -2.40810569e-02f, -4.30773824e-01f, -1.93559244e-01f, -2.83165008e-01f, -1.55057847e-01f, -7.96245486e-02f, -1.51131585e-01f, -3.40296686e-01f, 6.87722340e-02f,
  5.91020510e-02f, -2.34386116e-01f, -2.24441960e-01f, -1.66069403e-01f, -3.26508045e-01f, -1.10275194e-01f, -1.45830393e-01f, 8.79911035e-02f, -2.30494529e-01f, 9.99453813e-02f,
  -1.42367870e-01f, -1.33601487e-01f, 7.65324906e-02f, -1.27101941e-02f, -2.90279478e-01f, -2.80244984e-02f, 7.43294507e-02f, -2.11864144e-01f, -1.67267740e-01f, -1.30426258e-01f,
  1.47178859e-01f, 2.35288560e-01f, 3.53926688e-01f, -3.34531456e-01f, -9.69263259e-03f, -2.57477164e-01f, 8.16750601e-02f, -1.24158300e-01f, 1.24756144e-02f, -3.00555825e-01f,
  3.23024571e-01f, 1.60937667e-01f, 3.59616041e-01f, 9.49406400e-02f, -7.07162768e-02f, -9.32615101e-02f, 2.12594062e-01f, -1.79913759e-01f, -1.36704415e-01f, -9.47724879e-02f,
  2.62639299e-02f, 3.39782804e-01f, 1.01699792e-01f, 5.00020504e-01f, -8.93733799e-02f, -1.90905184e-01f, 2.10951455e-02f, 5.24238884e-01f, -9.46205556e-02f, -2.18211502e-01f,
  -8.30234736e-02f, 7.26769626e-01f, -1.61358893e-01f, -3.03286277e-02f, -1.46332338e-01f, 1.15389824e-01f, -1.66642234e-01f, -9.23675969e-02f, -9.81920362e-02f, -1.81824297e-01f,
  -7.76070133e-02f, 1.43051177e-01f, 2.09911317e-02f, -4.69750650e-02f, 5.16880900e-02f, -8.57081339e-02f, -1.88058496e-01f, 1.25468448e-01f, -2.15025872e-01f, -1.00000344e-01f,
  -1.94460437e-01f, -6.55561592e-03f, 9.55979303e-02f, 8.48151445e-02f, -1.58876762e-01f, -1.00254985e-02f, -1.87509120e-01f, 2.24466756e-01f, -1.78791434e-01f, -4.57583070e-02f,
  -4.16718960e-01f, -3.21886361e-01f, -1.21459015e-01f, 1.07724644e-01f, 2.82339782e-01f, -2.12331295e-01f, 3.55377614e-01f, 3.20525467e-01f, -3.57890815e-01f, 2.61795878e-01f,
  3.29059333e-01f, -1.27029896e-01f, 2.46962178e-02f, -4.86616015e-01f, 4.20756757e-01f, 4.62758094e-01f, 1.11536838e-01f, -3.75208288e-01f, -3.60061944e-01f, -4.17814612e-01f,
  -1.18361585e-01f, -1.06078744e-01f, 2.34704558e-02f, 2.94997275e-01f, -2.08754346e-01f, -1.86961204e-01f, -1.85836703e-01f, -1.05623983e-01f, -2.01413199e-01f, 7.90968314e-02f,
  6.11240387e-01f, 1.91418342e-02f, -1.59901440e-01f, -4.42683250e-02f, -4.18700129e-02f, -2.50008881e-01f, -1.66201163e-02f, 5.21189630e-01f, 1.02968462e-01f, -2.35685140e-01f,
  1.15784489e-01f, 1.65886924e-01f, 1.24747127e-01f, 2.47146070e-01f, 1.20411359e-01f, 9.19037126e-03f, 6.08107224e-02f, -4.93400916e-03f, -2.87126958e-01f, -1.45927101e-01f,
  1.37853727e-01f, 3.87916178e-01f, 4.71685380e-02f, 4.48194332e-02f, 2.28808850e-01f, 3.42714310e-01f, 7.88527504e-02f, 3.11465532e-01f, 1.64578967e-02f, -4.51867431e-02f,
  -2.07651064e-01f, -2.71520585e-01f, -2.91509777e-02f, 1.33457884e-01f, -4.09502000e-01f, 2.92937934e-01f, -1.36468515e-01f, -5.39823234e-01f, -5.25432825e-01f, 1.38278171e-01f,
  -1.13335863e-01f, -1.33729413e-01f, -1.38957351e-01f, 3.04354012e-01f, 1.62402079e-01f, -1.92709893e-01f, 1.77518860e-01f, 2.21957907e-01f, 2.77829677e-01f, -3.94074351e-01f,
  4.34739858e-01f, 2.26784065e-01f, 1.58378020e-01f, 4.99944687e-01f, -1.19615100e-01f, -5.01594171e-02f, -2.44679928e-01f, -4.14838195e-01f, 2.97796857e-02f, -3.93837631e-01f,
  -1.36223942e-01f, -1.33863777e-01f, 8.71826634e-02f, -5.29714040e-02f, -2.02288359e-01f, 6.55845165e-01f, 2.20176846e-01f, -2.68338174e-01f, -2.45598376e-01f, 1.62611797e-01f,
  4.65836108e-01f, 1.27393588e-01f, -1.28620625e-01f, -4.56394628e-02f, 2.21897647e-01f, 1.33870533e-02f, 5.41433334e-01f, 1.22742504e-01f, -1.63489923e-01f, 1.90233171e-01f,
  1.49847284e-01f, -9.33801830e-02f, 3.08627021e-02f, 2.50425667e-01f, 2.94767529e-01f, 3.39353979e-01f, -4.38268948e-03f, 3.18881199e-02f, 1.10729352e-01f, 2.41597027e-01f,
  8.20405632e-02f, 1.38565853e-01f, 2.33170673e-01f, -2.58430421e-01f, -1.09706856e-01f, -3.60827267e-01f, -6.98506311e-02f, 6.00280501e-02f, 7.81998113e-02f, -1.66951250e-02f,
  1.19791701e-01f, 3.38073790e-01f, -1.49197966e-01f, -1.56152174e-01f, 2.65376151e-01f, 4.85029340e-01f, 2.96819329e-01f, 4.26625520e-01f, -1.58097669e-01f, -1.32148370e-01f,
  -1.97435357e-03f, 2.95088202e-01f, -6.04446352e-01f, 6.09693885e-01f, -6.54567242e-01f, 4.72521216e-01f, 4.53235619e-02f, -3.55623960e-01f, 7.29684858e-03f, -1.93672493e-01f,
  -1.57151207e-01f, -1.64681658e-01f, -1.48059189e-01f, -1.17058404e-01f, 1.62723623e-02f, 3.59080315e-01f, -1.80552855e-01f, -1.70276791e-01f, -3.34761053e-01f, -2.66495645e-01f,
  -3.91162895e-02f, -4.57190797e-02f, -2.59772450e-01f, -1.20369829e-01f, -1.07874848e-01f, -9.39258412e-02f, 1.36820763e-01f, -1.39723122e-01f, 5.05342126e-01f, 1.43354267e-01f,
  1.75695062e-01f, -1.22731812e-01f, 4.63421613e-01f, 1.90699354e-01f, -6.39047474e-02f, 5.88303022e-02f, -1.08045503e-01f, 2.20084503e-01f, 2.12672681e-01f, 9.72055197e-02f,
  2.22882539e-01f, -3.25693958e-03f, -2.55015731e-01f, 8.33357945e-02f, 1.29987523e-01f, -4.03979905e-02f, 1.25458360e-01f, -6.79187849e-02f, 2.45581776e-01f, 6.86250702e-02f,
  -3.48547816e-01f, -2.88653195e-01f, 1.06967106e-01f, -6.35151446e-01f, 9.69913825e-02f, -1.98854625e-01f, 3.68841618e-01f, 2.52613634e-01f, -1.51124105e-01f, -6.85204491e-02f,
  -3.16821188e-01f, -6.14572287e-01f, -5.27027369e-01f, -1.70277014e-01f, 4.99276340e-01f, 1.71767175e-01f, 4.00010377e-01f, 3.65881234e-01f, -3.30112725e-01f, -5.40984035e-01f,
  5.05210698e-01f, 9.07471851e-02f, -2.13636145e-01f, -1.74468145e-01f, 1.75314680e-01f, -2.46287361e-01f, -2.34365195e-01f, -1.31544486e-01f, 1.91932738e-01f, -1.42324984e-01f,
  -2.92879343e-03f, 8.92809853e-02f, -1.61486343e-01f, -2.72880614e-01f, 1.65698826e-01f, 6.64761782e-01f, -1.55970305e-01f, 9.96995270e-02f, -1.91713840e-01f, 3.50298762e-01f,
  1.29354164e-01f, -3.21338862e-01f, 1.90154240e-02f, -8.65092278e-02f, 1.98301990e-02f, -5.83163016e-02f, 2.75887936e-01f, 2.23756224e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.99671853e-02f, 5.19934967e-02f, -7.53476694e-02f, 3.42397131e-02f, 2.04724241e-02f, -7.49886930e-02f, 1.23375311e-01f, -1.25641152e-01f, -1.24671996e-01f, -1.13265425e-01f,
  1.00065827e-01f, 1.43254086e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    