/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.60537556e-01f, -6.62006140e-02f, -1.09790392e-01f, -9.05319229e-02f, 1.69986084e-01f, 3.65604073e-01f, -9.67627019e-02f, 6.79347292e-02f, -2.98169941e-01f, 4.55078930e-02f,
  8.41714740e-02f, 6.74285972e-03f, -3.16467196e-01f, 8.06852207e-02f, -3.66940536e-02f, -2.92341411e-01f, 1.54249236e-01f, 1.13098837e-01f, -1.50520831e-01f, 4.76638786e-02f,
  -3.73142920e-02f, 6.69240803e-02f, -6.41224310e-02f, 1.19776018e-01f, 1.09909497e-01f, 3.10840681e-02f, 5.37601523e-02f, -8.68201852e-02f, 3.84581983e-01f, 5.52910976e-02f,
  3.93623933e-02f, -1.66026980e-01f, 4.39859591e-02f, -1.66121982e-02f, 3.04904152e-02f, 1.09124877e-01f, 7.31968135e-02f, 1.59870703e-02f, 1.42118940e-02f, -1.60711575e-02f,
  -8.15587118e-03f, 2.26889346e-02f, 4.77088802e-02f, -3.24548148e-02f, 1.79729108e-02f, 2.47010440e-02f, 4.62480485e-02f, 5.21168597e-02f, -1.86732244e-02f, 1.72497705e-02f,
  -2.16568150e-02f, 6.38246834e-02f, 2.64945254e-02f, 3.23898010e-02f, -4.73884195e-02f, -1.13563119e-02f, -1.27316061e-02f, 3.28694098e-02f, 7.62944296e-02f, 3.01436633e-02f,
  8.90185013e-02f, -1.11929048e-03f, -2.82503702e-02f, -6.59153890e-03f, -8.50885455e-03f, 1.84520669e-02f, 7.24998675e-03f, 7.87416287e-03f, -4.51815575e-02f, 1.51037779e-02f,
  -1.93365123e-02f, -5.68714691e-03f, 2.24918197e-03f, 1.65443439e-02f, 1.83914695e-02f, -5.18315891e-03f, 6.35809824e-02f, 1.03273802e-02f, 1.16929458e-02f, 2.84627806e-02f,
  -8.72979686e-02f, 9.62231122e-03f, 1.56810265e-02f, 4.45125848e-02f, -9.01794713e-03f, -3.47936861e-02f, 2.53970958e-02f, 1.50879733e-02f, -5.53884208e-02f, 3.08003742e-02f,
  6.85422122e-02f, -9.04413834e-02f, -4.39414270e-02f, 3.25378031e-02f, 9.78557160e-04f, 8.54475498e-02f, -3.59456278e-02f, 2.47240104e-02f, -6.85535744e-02f, -2.69106850e-02f,
  2.81400420e-02f, 2.65096966e-02f, -1.36298193e-02f, 4.57637049e-02f, 2.56682280e-02f, 2.12260075e-02f, -6.78266436e-02f, -2.44296603e-02f, 6.84201494e-02f, 7.34277815e-02f,
  3.13411318e-02f, 7.48928450e-03f, -1.94092561e-02f, -6.47916971e-03f, 6.48808330e-02f, -1.76685769e-02f, 6.60421923e-02f, -1.29377353e-03f, 1.45634674e-02f, -2.11078674e-02f,
  2.79324293e-01f, -2.17617169e-01f, 2.87684053e-01f, -3.61490436e-02f, -1.30061090e-01f, -1.52392387e-01f, 8.67885128e-02f, -9.06175449e-02f, 2.17431217e-01f, -1.38959676e-01f,
  -1.39169544e-01f, 1.77469224e-01f, 3.59687172e-02f, -2.00873852e-01f, -1.03546940e-01f, 2.10283790e-02f, -2.77330995e-01f, -1.98754054e-02f, 4.74325083e-02f, -2.39996970e-01f,
  4.09615003e-02f, -3.68662745e-01f, 6.06020056e-02f, -3.23941231e-01f, -1.71407126e-02f, 5.34392782e-02f, -2.89592296e-01f, 4.51863781e-02f, -2.13501468e-01f, -5.72298802e-02f,
  9.07627866e-03f, 1.41930729e-01f, 1.49112850e-01f, 1.06874831e-01f, -6.56835884e-02f, 3.06667723e-02f, 2.05050278e-02f, 7.68766999e-02f, 6.46902025e-02f, 2.16714982e-02f,
  9.12709832e-02f, -1.56698879e-02f, -1.83675699e-02f, -1.82977796e-03f, 4.44981307e-02f, 6.38122410e-02f, 6.88866898e-02f, 3.13769169e-02f, 6.75467923e-02f, 2.19066273e-02f,
  7.15100616e-02f, 1.24732545e-02f, -1.59971584e-02f, -6.70886338e-02f, 4.47051227e-02f, 3.23455152e-03f, -2.24633422e-02f, 5.79731055e-02f, -2.31349953e-02f, -5.25687672e-02f,
  -5.98399825e-02f, -2.16763001e-03f, -1.84921697e-02f, 3.06277014e-02f, -4.02820036e-02f, -1.47535643e-02f, -4.47058044e-02f, -2.79458091e-02f, 6.91363439e-02f, -5.68328388e-02f,
  -1.04746968e-02f, 1.15488656e-02f, -1.19393878e-02f, 1.76359266e-02f, -2.29682829e-02f, 1.05606634e-02f, 1.33209843e-02f, -1.15896240e-02f, 2.47609131e-02f, 1.03290631e-02f,
  1.70840938e-02f, -4.28199023e-02f, 1.22387111e-02f, -3.01910602e-02f, -1.10518308e-02f, -8.60298611e-03f, -4.97629046e-02f, -7.69278035e-03f, 9.33121238e-03f, -3.31833810e-02f,
  -1.62793919e-01f, -3.67379397e-01f, 2.44643949e-02f, 8.73384532e-03f, -1.66827086e-02f, -3.62595059e-02f, -2.00175215e-03f, -9.36361551e-02f, -3.71590592e-02f, -2.99720578e-02f,
  -4.04351950e-02f, 4.77851145e-02f, -5.49604744e-02f, 9.16964840e-03f, -7.50848129e-02f, -4.25467677e-02f, -6.20125048e-02f, -6.23274222e-03f, -9.74168852e-02f, -9.39228386e-02f,
  -9.32010114e-02f, -4.88590449e-02f, 1.58316698e-02f, 1.28927659e-02f, -7.59964585e-02f, -9.59710311e-03f, 3.31512565e-05f, 4.06101346e-03f, -6.25739768e-02f, -1.13606518e-02f,
  -9.01281610e-02f, 4.33959931e-01f, 3.60062033e-01f, 1.47808954e-01f, 2.09462866e-01f, 8.55356231e-02f, -1.95715055e-01f, 2.69195855e-01f, 4.83814985e-01f, -2.22700477e-01f,
  -4.76109609e-02f, -1.94530524e-02f, -6.04730137e-02f, 4.02122661e-02f, -2.68065631e-01f, 4.83912043e-02f, 1.29882654e-03f, -1.52605912e-02f, 3.08155537e-01f, 1.20637476e-01f,
  9.54386443e-02f, -4.90984097e-02f, 4.51264903e-03f, 6.44519106e-02f, 1.18813604e-01f, 9.55956131e-02f, -3.31532449e-01f, 1.26462519e-01f, -8.85985717e-02f, -3.07334885e-02f,
  -1.26260623e-01f, 1.34925351e-01f, 1.73955807e-03f, 5.71620539e-02f, 3.34774517e-02f, -1.15501648e-02f, -7.54147917e-02f, -1.29513502e-01f, 6.06081411e-02f, 4.18463089e-02f,
  -7.07036108e-02f, -3.95256057e-02f, 2.10995730e-02f, 2.41404083e-02f, 1.37373343e-01f, 3.40319686e-02f, 6.99915141e-02f, 8.98896828e-02f, 3.53504904e-02f, 5.44452704e-02f,
  3.79863754e-02f, 7.31238648e-02f, 4.27989885e-02f, 2.74014138e-02f, 9.18330916e-05f, 7.03376532e-02f, 1.92698487e-03f, -2.46674884e-02f, 2.18130685e-02f, 5.87623045e-02f,
  3.86021310e-03f, 7.53030777e-02f, -3.15103354e-03f, -1.29873622e-02f, 2.32118629e-02f, -1.21894721e-02f, 4.88551371e-02f, -7.38409311e-02f, 5.25038205e-02f, -5.92751727e-02f,
  3.36860567e-02f, 1.73683539e-02f, 6.96913600e-02f, 2.55895406e-02f, 1.04217669e-02f, -2.91877445e-02f, -4.06415090e-02f, -1.72425434e-02f, 4.73544113e-02f, -2.51777526e-02f,
  1.94332213e-03f, -1.29598044e-02f, -2.47696470e-02f, -4.96278517e-02f, 2.62645893e-02f, 1.79352071e-02f, 3.31957266e-02f, -1.52566619e-02f, 6.84227562e-03f, -6.76417723e-02f,
  7.62961134e-02f, 2.97049642e-01f, 1.08677102e-02f, -7.94497356e-02f, -4.67013493e-02f, -2.73270644e-02f, 3.75697762e-02f, 4.50190417e-02f, 2.80306619e-02f, -4.41206479e-03f,
  -1.50017496e-02f, 1.99813209e-03f, -6.15545223e-03f, 1.34580722e-02f, -3.21923047e-02f, -4.86516654e-02f, -3.19733731e-02f, -1.03439018e-02f, 2.24887505e-02f, 5.11591556e-03f,
  -2.68484466e-03f, 4.11305651e-02f, -4.28421609e-03f, -1.91681609e-02f, -8.70022327e-02f, -5.53659946e-02f, -1.86438989e-02f, -4.58960384e-02f, 6.90608611e-03f, 4.35061427e-03f,
  -3.72344136e-01f, 3.09039682e-01f, -4.02597524e-03f, -9.57701653e-02f, -2.57762372e-01f, 6.99551404e-02f, 2.41067037e-01f, -6.21046275e-02f, -4.40139771e-01f, 1.77943006e-01f,
  1.99361816e-01f, -1.78517997e-01f, 2.77757883e-01f, 1.89098805e-01f, -2.54347548e-02f, 9.71336514e-02f, 2.46741772e-01f, 9.72718894e-02f, -8.97509530e-02f, -3.92342992e-02f,
  -9.21163484e-02f, 1.24995768e-01f, 2.74527669e-01f, 5.97039871e-02f, 6.70280308e-02f, -1.86090320e-02f, 1.46586627e-01f, 7.34024048e-02f, 1.38597459e-01f, 5.98919019e-02f,
  3.96260098e-02f, -1.94634572e-02f, 1.45827040e-01f, 1.22238426e-02f, 2.49171164e-02f, 2.19741426e-02f, 8.34580958e-02f, 3.87530923e-02f, -6.94418922e-02f, -3.49247307e-02f,
  -3.65726128e-02f, -7.90637881e-02f, -1.39839593e-02f, -4.91901562e-02f, -8.37402493e-02f, 2.81746779e-03f, -5.02334200e-02f, -8.07342026e-03f, 1.08315991e-02f, -5.87653071e-02f,
  -4.29131724e-02f, 7.17053562e-02f, 4.40819748e-03f, 3.69938500e-02f, -1.04495538e-02f, -3.40526141e-02f, 2.96280114e-03f, 6.02946011e-03f, 1.73251797e-02f, -3.68679576e-02f,
  2.06166916e-02f, 5.72450981e-02f, -1.92642212e-02f, -1.40959620e-02f, -5.25687821e-02f, -3.83731630e-03f, -2.43664905e-02f, -1.48324091e-02f, -4.16553207e-02f, 1.45740598e-03f,
  -2.25280598e-02f, -8.19638092e-03f, -1.47676207e-02f, 4.12735865e-02f, -3.45089473e-02f, -1.80855137e-03f, 2.25476045e-02f, -2.96408348e-02f, 5.21285124e-02f, -1.52963493e-02f,
  -2.85624620e-02f, 6.97030453e-03f, -1.09955464e-02f, -2.83075832e-02f, 1.43517759e-02f, 9.21071507e-03f, 2.39428133e-02f, -6.76643010e-03f, 3.91043536e-03f, 4.37616035e-02f,
  9.30470228e-03f, 7.14890584e-02f, 4.21418846e-02f, -3.29667673e-05f, -9.16820299e-03f, 1.14045897e-02f, 3.79655100e-02f, -3.63678932e-02f, 8.74317437e-03f, 1.25572458e-02f,
  3.49722989e-02f, 2.09555984e-03f, 1.09530045e-02f, 1.50150182e-02f, 7.51164034e-02f, -3.46397944e-02f, -9.90007538e-03f, 6.18126430e-02f, 6.44834861e-02f, 8.27766806e-02f,
  6.85528889e-02f, -3.47301401e-02f, -3.55914831e-02f, -2.96187475e-02f, 1.29894344e-02f, 6.96075112e-02f, -7.30076805e-02f, 4.79052104e-02f, -1.25691490e-02f, 5.62260207e-03f,
  -2.55848318e-01f, 4.56842363e-01f, 1.14888242e-02f, 1.50386021e-01f, -4.03087109e-01f, -4.17408496e-01f, -2.30865911e-01f, -4.80458234e-03f, 8.19483548e-02f, 3.01569611e-01f,
  -1.22458667e-01f, 1.75996676e-01f, 1.24236792e-01f, 8.85486826e-02f, -4.46882159e-01f, 2.18161806e-01f, -4.91924062e-02f, 3.86718996e-02f, 3.59441452e-02f, -8.00526440e-02f,
  -7.30281174e-02f, -1.30448982e-01f, 1.30928112e-02f, -5.81707396e-02f, -1.51953757e-01f, 4.34808545e-02f, -7.55982846e-02f, -7.90692493e-02f, -1.15111843e-02f, -6.24601319e-02f,
  4.17190678e-02f, 1.08472794e-01f, 1.37004666e-02f, 6.56709820e-02f, -1.02387123e-01f, -3.81591991e-02f, -9.46951192e-03f, -4.44422811e-02f, -5.07694781e-02f, 1.84533149e-02f,
  5.01763746e-02f, -6.03546575e-02f, 5.48433885e-02f, -4.39611375e-02f, -8.71116221e-02f, 3.53982672e-02f, 1.19606080e-02f, -5.88427123e-04f, 2.83698235e-02f, -2.85373665e-02f,
  -3.05180941e-02f, 2.65282765e-02f, -2.24590767e-02f, 5.17757870e-02f, -1.84895401e-03f, 2.37927772e-02f, -1.30081847e-02f, -3.86893079e-02f, 9.82571617e-02f, -1.31223053e-02f,
  -4.76628803e-02f, -2.70501319e-02f, 1.57391988e-02f, 3.58319767e-02f, -3.00909225e-02f, 1.82132032e-02f, -6.26424178e-02f, 1.29441766e-03f, -1.27828885e-02f, -1.18675083e-02f,
  -3.51728871e-02f, -1.67593583e-02f, -1.83020979e-02f, -4.21191826e-02f, -2.11913437e-02f, 3.13102379e-02f, -2.70536635e-02f, 5.03903292e-02f, -3.71290953e-03f, -3.57539840e-02f,
  5.90477735e-02f, -4.67435606e-02f, 1.00997100e-02f, 1.38483588e-02f, -8.82859400e-04f, -6.93078851e-03f, 2.21673865e-02f, 2.96716802e-02f, 1.74349057e-03f, -5.04775010e-02f,
  -6.83335513e-02f, 7.75874928e-02f, 4.29685861e-02f, -5.43996468e-02f, 1.02388024e-01f, -1.63537473e-03f, 3.63321938e-02f, -1.67019723e-03f, 4.85018604e-02f, -4.64639217e-02f,
  -7.78257921e-02f, 9.22704302e-03f, -4.69351932e-02f, -4.64313524e-03f, 1.80464145e-02f, -2.36857384e-02f, 1.06349792e-02f, -6.53777644e-03f, -7.54403099e-02f, -1.32488478e-02f,
  -2.29591541e-02f, -6.30094260e-02f, 7.82664586e-03f, -4.73187268e-02f, -2.47096196e-02f, -2.56488640e-02f, -5.60028367e-02f, 5.01886271e-02f, -1.73419807e-02f, 5.59717789e-02f,
  4.85677719e-01f, -6.07473366e-02f, -1.17703706e-01f, 4.52166855e-01f, 1.54425159e-01f, 1.52932450e-01f, 4.27046567e-02f, 1.57688230e-01f, 2.55112588e-01f, -1.01737557e-02f,
  5.44878170e-02f, 2.11309399e-02f, -3.52606893e-01f, 2.04437256e-01f, -3.71166086e-03f, -3.23160172e-01f, 3.07900816e-01f, 6.83871657e-02f, 8.70288536e-03f, 2.14219123e-01f,
  9.54616070e-02f, 1.69125214e-01f, -1.90173879e-01f, -1.71768293e-03f, 1.77759066e-01f, 6.09967075e-02f, -4.61358912e-02f, -1.45582840e-01f, 8.48352388e-02f, -5.71189746e-02f,
  1.03925588e-03f, -2.04535499e-02f, 3.94100510e-02f, -4.98190895e-03f, 4.38017100e-02f, 5.94120063e-02f, 9.16262437e-03f, -4.59791906e-02f, 7.66181806e-03f, 6.10701628e-02f,
  1.47482078e-03f, -3.41347163e-03f, 9.85739902e-02f, -2.90673855e-03f, 1.07719183e-01f, 1.97449680e-02f, 1.30955093e-02f, 1.81824528e-02f, -3.61914784e-02f, -5.60118593e-02f,
  -1.88956093e-02f, 1.71389859e-02f, 7.35704899e-02f, 1.10217622e-02f, -1.07979886e-02f, 1.65652875e-02f, -2.04353929e-02f, -5.24957143e-02f, 2.60507818e-02f, 8.28003213e-02f,
  4.88321371e-02f, 3.38089140e-03f, -7.23573240e-03f, 1.67651251e-02f, 1.42486133e-02f, 7.33502442e-03f, 1.19271837e-02f, -7.31516555e-02f, 1.34001160e-02f, 5.29907737e-03f,
  1.90932639e-02f, 5.35056219e-02f, 4.71270941e-02f, 3.68421040e-02f, 4.33320701e-02f, 7.47799594e-03f, -2.29407437e-02f, -5.63071258e-02f, 9.30970088e-02f, -6.52588264e-04f,
  -4.75233756e-02f, -8.43116455e-03f, -3.45687158e-02f, -3.20923142e-02f, 6.64909510e-03f, -2.84606870e-02f, 3.73838544e-02f, -4.67639416e-02f, -1.90982316e-02f, 4.89552179e-03f,
  -2.24396605e-02f, 2.26787347e-02f, 6.85476512e-03f, -1.90725375e-03f, -3.19181569e-02f, 1.06558027e-02f, 1.23442831e-02f, 4.97521050e-02f, 1.32372193e-02f, 2.16735732e-02f,
  1.77662577e-02f, 5.00314534e-02f, -7.77423987e-03f, -1.08287139e-02f, 1.18310889e-02f, -1.04026282e-02f, -3.98035832e-02f, 2.41094716e-02f, 7.32749477e-02f, 2.48557720e-02f,
  7.59736681e-03f, 2.48140600e-02f, 2.62200995e-03f, 3.73643562e-02f, 2.70582959e-02f, 3.74316587e-03f, 4.56241630e-02f, -1.98458880e-02f, -5.12101501e-02f, -2.51979996e-02f,
  -2.29776099e-01f, -8.06669518e-02f, -5.05404592e-01f, -3.61834794e-01f, 5.26196137e-02f, 4.12555605e-01f, 5.45258075e-02f, 5.02660275e-02f, -1.03345156e-01f, 3.06444347e-01f,
  1.63320094e-01f, -2.56813854e-01f, 1.72293410e-02f, 1.99282438e-01f, -1.66667387e-01f, 1.27061874e-01f, 1.46287188e-01f, 8.23882073e-02f, -8.88499543e-02f, -9.63135436e-02f,
  -1.26527458e-01f, 3.46746892e-01f, -2.20947176e-01f, 2.50703216e-01f, -6.63727224e-02f, -1.80122972e-01f, -5.72354756e-02f, -5.77760069e-03f, 7.36101270e-02f, 6.97765797e-02f,
  -1.03380876e-02f, 4.88654338e-02f, -8.66648555e-02f, 2.18822937e-02f, 7.60157034e-03f, -2.33366713e-02f, -1.44890137e-02f, -1.17525235e-02f, -7.40178078e-02f, 1.11500183e-02f,
  -1.57312341e-02f, 2.66773216e-02f, 3.62641960e-02f, 2.04679929e-03f, 4.45064195e-02f, -5.67135997e-02f, -1.72377843e-02f, -3.59930731e-02f, -3.20086628e-02f, -5.27788848e-02f,
  -6.51260167e-02f, -8.16082675e-03f, -3.34568173e-02f, 4.29834463e-02f, -5.44718578e-02f, 6.41596410e-03f, -2.48703510e-02f, -7.07889646e-02f, -1.30252462e-04f, 4.85943742e-02f,
  1.08509615e-01f, 4.64901626e-02f, 3.37830223e-02f, -3.56988534e-02f, 1.18026871e-03f, -1.35417823e-02f, -3.17295751e-04f, 4.08763736e-02f, -5.43421283e-02f, 7.10324710e-03f,
  3.02770045e-02f, -1.00340322e-01f, 6.36890382e-02f, -3.30960266e-02f, 3.99988443e-02f, -2.69137230e-02f, -2.71959342e-02f, 3.18183824e-02f, 6.58518169e-03f, -5.79129979e-02f,
  1.50805516e-02f, 2.23854929e-02f, 3.27303410e-02f, 1.49026457e-02f, 4.92793396e-02f, -3.65210660e-02f, 3.59117873e-02f, -3.36051881e-02f, -3.27539966e-02f, -2.97526699e-02f,
  1.17083341e-01f, 1.20732740e-01f, 7.11488202e-02f, 6.92451722e-04f, -8.68100580e-03f, 5.57517484e-02f, 4.84493524e-02f, 1.47093181e-02f, 5.41952532e-03f, 6.22319393e-02f,
  -1.76101737e-02f, -6.70893043e-02f, 3.67464498e-02f, 6.22819783e-03f, -2.63468791e-02f, 3.90712284e-02f, 1.65594071e-02f, -2.05646940e-02f, 3.48888859e-02f, 1.11938100e-02f,
  -1.83745089e-03f, 3.69650982e-02f, -2.05835123e-02f, -1.35604851e-03f, 3.40669043e-03f, 7.31445709e-03f, 3.48306797e-03f, -1.54780550e-02f, 7.08766505e-02f, 3.91983911e-02f,
  -2.26851389e-01f, 1.41528904e-01f, 1.33381739e-01f, -2.35824343e-02f, 2.68989265e-01f, -1.70071110e-01f, -1.60814464e-01f, 2.88262069e-01f, -1.73674554e-01f, 1.23531610e-01f,
  7.35824630e-02f, -3.73191565e-01f, 8.45673457e-02f, -1.06825866e-02f, -3.92116874e-01f, -1.22511044e-01f, -1.86599612e-01f, -2.35265002e-01f, -1.31494671e-01f, 2.29571573e-03f,
  -1.80885140e-02f, 8.09554756e-02f, 1.69759795e-01f, 2.37624615e-01f, 2.56879836e-01f, 8.99287090e-02f, 2.12062672e-01f, 1.69962466e-01f, 1.10190272e-01f, -1.01145066e-01f,
  7.56276846e-02f, 3.95351760e-02f, 1.03200115e-01f, -5.69512732e-02f, 2.58326512e-02f, 6.63269833e-02f, -3.13881375e-02f, -5.81145957e-02f, -3.54507403e-03f, 2.19826158e-02f,
  -8.58065858e-02f, -4.85232435e-02f, -1.07276991e-01f, 1.26469880e-02f, 1.10692158e-02f, -1.56083854e-03f, 5.19329645e-02f, 6.28267378e-02f, 2.08824631e-02f, 3.95348445e-02f,
  2.30994560e-02f, -3.80644053e-02f, -5.79203181e-02f, -1.28747880e-01f, -1.78505806e-03f, -1.86457485e-02f, -3.23858745e-02f, 3.62721309e-02f, 2.09530331e-02f, -7.79847354e-02f,
  -6.51907325e-02f, -2.72252434e-03f, 3.42476293e-02f, 4.16842625e-02f, -1.99638698e-02f, 7.89545476e-02f, -4.91636097e-02f, -4.75216620e-02f, 1.12627458e-03f, -1.48638543e-02f,
  2.81493273e-02f, 3.23648266e-02f, -5.53397753e-04f, 4.35053743e-02f, -3.45508978e-02f, 4.66186889e-02f, -2.52591539e-02f, -7.25666666e-03f, 1.87173449e-02f, 7.77840167e-02f,
  3.91049758e-02f, -6.73244614e-03f, 3.96970548e-02f, 2.67434139e-02f, -5.95859066e-03f, 7.22230691e-03f, 5.81454039e-02f, 6.47319257e-02f, 5.12154289e-02f, -3.32418382e-02f,
  -1.18269175e-01f, -4.71619703e-02f, 2.48680227e-02f, -5.74080739e-03f, -9.69281606e-03f, 3.00970883e-03f, -8.70203152e-02f, -1.08069470e-02f, -6.41692802e-02f, -2.27945950e-02f,
  2.96189617e-02f, 1.80894490e-02f, -4.85082902e-03f, -5.46698570e-02f, -3.76109146e-02f, -1.06186960e-02f, -4.22865972e-02f, -3.42359915e-02f, -1.98727399e-02f, -7.74795283e-03f,
  7.06004649e-02f, -3.19855884e-02f, -2.71469895e-02f, 3.56121883e-02f, -6.55911043e-02f, -5.98884635e-02f, -5.39404824e-02f, -2.56199334e-02f, -6.22043237e-02f, 1.38256792e-02f,
  3.12841594e-01f, 1.32239521e-01f, -1.49917066e-01f, 2.82545984e-01f, -6.76447451e-02f, 3.10614314e-02f, 9.69017372e-02f, 1.14079662e-01f, 2.12790623e-01f, 3.18867028e-01f,
  -3.77587751e-02f, -7.44649246e-02f, -1.92514166e-01f, 1.93487838e-01f, -5.32819927e-02f, -9.42364410e-02f, 4.57634538e-01f, 2.13280231e-01f, -2.53703422e-03f, 1.27283067e-01f,
  5.36977910e-02f, 1.35464028e-01f, -7.29167536e-02f, -7.84406513e-02f, 1.43307149e-01f, -3.13379206e-02f, -1.14621771e-02f, -3.28737497e-01f, 1.32719994e-01f, -1.42348900e-01f,
  1.39087230e-01f, 1.41842412e-02f, -4.18758914e-02f, 1.21660624e-02f, 4.40807045e-02f, 4.32288833e-03f, -3.99074592e-02f, -1.54582769e-01f, -1.67308431e-02f, 7.87604786e-03f,
  -1.31214149e-02f, -3.91592607e-02f, 1.36860367e-02f, -3.86140347e-02f, 8.05058703e-02f, -5.66455361e-04f, -1.20864215e-03f, 2.09899377e-02f, -2.68270317e-02f, -1.27437627e-02f,
  -4.10649329e-02f, 8.12343135e-03f, -2.65193591e-03f, 3.96815501e-02f, -4.00296636e-02f, -2.39214748e-02f, -8.05030670e-03f, -6.01965301e-02f, 8.28493312e-02f, 4.66428772e-02f,
  -1.18271559e-01f, 4.10975404e-02f, -2.97112912e-02f, 1.14387590e-02f, -1.13679618e-02f, -2.07946785e-02f, -1.36962219e-03f, -2.68472526e-02f, 1.30094849e-02f, -3.96822020e-03f,
  4.43229005e-02f, 6.42611757e-02f, -1.56776756e-02f, 4.63006943e-02f, 3.56697254e-02f, 6.37462512e-02f, -1.94606204e-02f, 2.73805987e-02f, 5.56802154e-02f, 3.67751308e-02f,
  -6.96707750e-03f, 2.40240078e-02f, 1.89455114e-02f, -4.77119023e-03f, -1.38577167e-02f, -1.23999072e-02f, 2.67890878e-02f, 2.48885322e-02f, -3.08165345e-02f, -1.61161888e-02f,
  3.25945199e-01f, 2.39128843e-01f, -2.97195427e-02f, 1.76874679e-02f, 1.50855025e-02f, 1.84855964e-02f, 2.67853942e-02f, 1.54812699e-02f, 2.05504112e-02f, 2.81920377e-02f,
  4.90669273e-02f, 6.61558434e-02f, 6.24591601e-04f, -9.41010378e-03f, -5.79340979e-02f, 4.81752791e-02f, 2.31795330e-02f, 5.35617769e-02f, 5.90247139e-02f, 2.71693673e-02f,
  3.81339937e-02f, -4.83504720e-02f, -4.83909771e-02f, 2.63228342e-02f, 2.09972821e-02f, 1.99818872e-02f, 1.72413960e-02f, 8.96208175e-03f, -5.61699830e-02f, 4.90751266e-02f,
  -8.79443958e-02f, 2.68797670e-02f, -1.26741126e-01f, -2.42645089e-02f, -1.21454135e-01f, -1.72227919e-01f, -6.61555156e-02f, -1.36867017e-01f, -2.86148041e-01f, 6.88186884e-02f,
  1.61620006e-01f, 1.04227051e-01f, 1.63358480e-01f, 2.08986983e-01f, 1.81119621e-01f, 2.48559415e-01f, 2.92284507e-02f, 1.46825597e-01f, 1.24273058e-02f, -1.07664783e-02f,
  3.39001790e-02f, 3.72287542e-01f, 2.16003761e-01f, 7.76336640e-02f, 7.69384429e-02f, -1.25610545e-01f, 2.38304809e-01f, -1.53702451e-02f, 4.14075889e-02f, -6.47009760e-02f,
  7.71469399e-02f, 3.56281362e-02f, 5.07207103e-02f, -5.82244210e-02f, -2.02237206e-05f, -9.44799483e-02f, -2.29165349e-02f, 4.69603315e-02f, -2.90659778e-02f, -5.22487983e-02f,
  3.96098532e-02f, -3.08034047e-02f, 1.32144091e-03f, 8.15812405e-03f, -1.28343239e-01f, -5.19670546e-02f, -5.53799272e-02f, 6.89409068e-03f, -4.19759601e-02f, -3.55590321e-02f,
  -6.01138920e-02f, -2.95524057e-02f, -1.08604781e-01f, 7.38906441e-03f, 5.27942181e-02f, -7.19497576e-02f, 5.44990820e-04f, 3.78346373e-03f, -5.34581160e-03f, -3.64383906e-02f,
  -4.48130928e-02f, -8.00686404e-02f, 4.49270085e-02f, 1.90265141e-02f, 5.99760376e-02f, -2.33928096e-02f, 2.19343274e-04f, 6.06182776e-03f, 8.63810652e-04f, 2.70430986e-02f,
  5.62865064e-02f, -1.61065031e-02f, -4.06564772e-02f, -1.08705230e-01f, 7.11795613e-02f, -2.84078456e-02f, 3.92720327e-02f, -4.61268649e-02f, -5.02429567e-02f, -1.12786237e-02f,
  4.99370694e-02f, -1.40846372e-01f, 1.05170764e-01f, -1.06908884e-02f, -7.34299840e-03f, 2.18377206e-02f, -3.16994004e-02f, -6.03871383e-02f, -1.36833936e-02f, 5.42662703e-02f,
  7.05666021e-02f, 5.78123964e-02f, 2.11926475e-02f, -1.58114433e-02f, 2.58344375e-02f, 6.44546747e-02f, 9.76358075e-04f, 2.88509158e-03f, -3.70616950e-02f, 4.59423698e-02f,
  -3.31306607e-02f, -1.58644579e-02f, 3.93060893e-02f, -2.30013747e-02f, -1.75012611e-02f, 1.32919494e-02f, -1.94691424e-03f, -4.17718627e-02f, 5.09714261e-02f, -3.82287167e-02f,
  5.14294915e-02f, 2.64171250e-02f, 6.52066693e-02f, 7.29778484e-02f, -6.96294308e-02f, 1.76318586e-02f, -5.42525388e-02f, -5.41858524e-02f, 3.40701044e-02f, 7.73086725e-03f,
  5.47967374e-01f, 2.20791511e-02f, 1.15313686e-01f, 4.06534940e-01f, -1.20408304e-01f, 4.14563455e-02f, 4.56469506e-01f, -2.06160583e-02f, 1.48623511e-01f, -6.01342060e-02f,
  1.61784813e-01f, 1.41610280e-01f, 9.87794623e-02f, 2.32049003e-01f, 2.97294199e-01f, 1.30618930e-01f, 3.03351879e-01f, 1.78661019e-01f, -7.85303339e-02f, 1.25134766e-01f,
  1.23238884e-01f, 1.70612205e-02f, 1.29587486e-01f, -3.39331239e-01f, 8.42279866e-02f, -7.27159530e-02f, -9.14843529e-02f, -7.73708671e-02f, -5.83451651e-02f, -9.70770866e-02f,
  -1.25810327e-02f, 8.38693902e-02f, 2.58965828e-02f, -1.08784959e-01f, 8.52186978e-02f, 4.05280367e-02f, 2.66666450e-02f, -3.77050564e-02f, 9.06185061e-03f, -6.22809818e-03f,
  6.83557242e-03f, -1.11063384e-02f, -7.28872940e-02f, -3.58822085e-02f, -5.93201593e-02f, -4.60114963e-02f, -8.80030543e-03f, 3.27181332e-02f, -2.14438979e-02f, 1.82649493e-02f,
  3.78316529e-02f, 6.94876304e-03f, 2.30350420e-02f, 2.20810529e-03f, -2.17805710e-02f, -8.35171062e-03f, -3.39077637e-02f, -5.63370110e-03f, 6.23089001e-02f, -6.05504727e-04f,
  4.69166860e-02f, -3.97918113e-02f, 2.84567848e-03f, -6.32811710e-03f, 2.90996209e-02f, -7.94329792e-02f, -4.71053552e-03f, -2.29508281e-02f, -4.64889128e-03f, 3.93296182e-02f,
  5.58879338e-02f, 2.09392719e-02f, -1.73565298e-02f, 1.25577403e-02f, -5.48587646e-03f, -7.58660678e-03f, 1.54203186e-02f, 1.21783987e-02f, 2.74620373e-02f, 9.37471446e-03f,
  -3.19494493e-02f, 1.48926638e-02f, -1.87777355e-02f, 2.78087496e-03f, -2.84736622e-02f, -1.14556577e-03f, -5.65964356e-02f, 1.61548294e-02f, 7.56752118e-03f, 5.51659688e-02f,
  1.27479583e-01f, 2.92429984e-01f, -3.93344574e-02f, 3.73097020e-03f, -3.74124572e-02f, 1.05402630e-03f, -2.21673418e-02f, -6.10654913e-02f, 2.78399251e-02f, 4.73485403e-02f,
  -1.48537289e-02f, -1.37716271e-02f, 3.49953100e-02f, -3.92606109e-02f, 2.60663219e-02f, 5.56653962e-02f, 8.92358124e-02f, -8.38123076e-03f, 5.44078276e-02f, -3.54100801e-02f,
  4.71889712e-02f, 4.98370873e-03f, -1.31163569e-02f, -1.85168069e-02f, -2.98304800e-02f, 9.25531518e-03f, 7.94607028e-02f, -2.82300785e-02f, 9.12140775e-03f, -1.14987744e-02f,
  1.69789076e-01f, -4.56686318e-01f, 8.73035192e-03f, 1.30641475e-01f, 4.19307984e-02f, -8.67910609e-02f, 2.79754221e-01f, -2.64313072e-01f, -1.56598873e-02f, -7.96986967e-02f,
  1.46008447e-01f, 2.35580690e-02f, -5.15698828e-02f, 2.00864166e-01f, 1.23315655e-01f, 6.18331917e-02f, -6.79916441e-02f, 3.65763120e-02f, -1.28858373e-01f, -1.21166326e-01f,
  -8.11329409e-02f, 2.50170857e-01f, 1.03909492e-01f, -1.32257476e-01f, 2.89255790e-02f, -9.40463394e-02f, -4.63169254e-02f, -4.92724543e-03f, -1.17289722e-02f, 9.05132294e-02f,
  3.29673737e-02f, -6.24487326e-02f, 8.85551348e-02f, -4.67123426e-02f, 2.43248325e-02f, 6.77988082e-02f, 5.87479360e-02f, 1.19343489e-01f, 9.78569016e-02f, -2.69313920e-02f,
  -7.45398970e-03f, -7.73071451e-03f, 2.78679710e-02f, 9.31777433e-03f, -2.18101349e-02f, -3.29497606e-02f, 6.44726213e-03f, 1.70871820e-02f, -3.84429991e-02f, 6.52160794e-02f,
  2.78025791e-02f, 9.58694145e-03f, 1.54248979e-02f, -1.87589228e-02f, -7.70322233e-03f, -3.19327824e-02f, 4.52318639e-02f, -1.96748618e-02f, -4.41221595e-02f, 2.64366157e-02f,
  -9.92959831e-03f, -3.44799878e-03f, 2.66807526e-02f, 6.75471202e-02f, -5.74891195e-02f, -3.80584300e-02f, 3.14336903e-02f, 2.25735344e-02f, -1.35118347e-02f, 1.07071903e-02f,
  1.25336519e-03f, 1.44944163e-02f, 3.28175910e-02f, 4.09871861e-02f, 1.94046590e-02f, 1.29469186e-02f, 3.69383115e-03f, -2.14589648e-02f, 7.10232602e-03f, 1.38910627e-02f,
  -3.18439826e-02f, -3.27487686e-03f, -1.37344170e-02f, 4.44286950e-02f, -6.15155324e-03f, 6.33043656e-03f, -3.86251770e-02f, -9.54905078e-02f, 3.61852087e-02f, 2.08856203e-02f,
  -5.17216980e-01f, -5.34905195e-01f, -5.10805845e-02f, 1.23533979e-02f, -7.24297157e-03f, -1.20910313e-02f, -6.17713854e-03f, -8.80094916e-02f, -1.16238989e-01f, -4.92360815e-02f,
  -1.06822886e-02f, 3.88687216e-02f, -4.66912426e-02f, 4.94673550e-02f, 1.55478439e-04f, -5.40805273e-02f, 5.63109033e-02f, -2.55454704e-02f, -1.11770602e-02f, -4.54552658e-02f,
  2.05955636e-02f, 4.45918180e-02f, 6.50174543e-02f, -5.48762679e-02f, -6.52057631e-03f, 5.90878315e-02f, -7.33243525e-02f, 4.33033034e-02f, 1.27191115e-02f, -6.36026859e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.30460101e-01f, -2.81725526e-01f, -5.03957987e-01f, -3.49284470e-01f, -5.22628613e-02f, -1.00985207e-01f, -2.63672024e-01f, -2.24406809e-01f, -2.42080450e-01f, -4.75851223e-02f,
  7.25067332e-02f, -1.13984704e-01f, -1.94586832e-02f, -2.79272377e-01f, -9.39389039e-03f, -7.33959153e-02f, -1.48884982e-01f, -6.40249401e-02f, -1.47259355e-01f, -8.01607072e-02f,
  3.95281017e-02f, 1.07154600e-01f, -1.11124724e-01f, 2.53334865e-02f, -3.37989740e-02f, 1.24286450e-01f, 3.38165402e-01f, -4.53979261e-02f, 1.33343618e-02f, -4.37133992e-03f,
  -4.82872054e-02f, -7.25412220e-02f, -1.04484059e-01f, -1.04376055e-01f, 8.48971754e-02f, 9.29459929e-02f, 3.58560793e-02f, 7.20248967e-02f, -2.88123284e-02f, -2.14274903e-03f,
  1.18965156e-01f, -5.19569963e-02f, -5.74275218e-02f, 1.41989328e-02f, -1.59073435e-02f, -5.41091822e-02f, -9.99871716e-02f, -5.07114232e-02f, -1.85671031e-01f, 9.56058968e-03f,
  -1.29576087e-01f, -7.03267455e-02f, -1.40134552e-02f, -3.23626585e-02f, -8.92688055e-03f, 2.86751869e-03f, 3.98084298e-02f, 6.97691441e-02f, 6.59019276e-02f, -5.09353615e-02f,
  1.81000382e-01f, 6.27849624e-02f, 3.62442732e-02f, -6.50051907e-02f, 1.11995721e-02f, -2.99214628e-02f, 5.63246831e-02f, -7.38778710e-02f, -2.93697491e-02f, 5.99899143e-02f,
  -1.81661211e-02f, -1.07538223e-01f, -4.27671522e-02f, 7.76753351e-02f, 6.59192502e-02f, -1.06398351e-02f, 4.37675364e-04f, 6.13558777e-02f, -1.05060458e-01f, -8.70313272e-02f,
  2.25157309e-02f, 3.49265859e-02f, -6.41612187e-02f, -1.20054395e-03f, -1.26638459e-02f, -6.83200359e-02f, 4.86939773e-02f, -4.48146909e-02f, 9.47623514e-03f, -1.41270543e-02f,
  -4.77833295e-04f, 1.49867803e-01f, -1.33717239e-01f, -1.28683284e-01f, -2.96863280e-02f, 1.16466373e-01f, -2.03505103e-02f, -6.43819869e-02f, 3.21122445e-02f, 5.01701515e-03f,
  6.55390397e-02f, -1.46826841e-02f, 1.40750855e-01f, 7.03405514e-02f, -6.13886379e-02f, 1.06470935e-01f, 1.34777024e-01f, 7.20904171e-02f, -8.06423500e-02f, 5.80664128e-02f,
  -9.03102942e-03f, 1.28819764e-01f, 2.67741084e-02f, -1.04123466e-01f, -5.90843484e-02f, 3.05281226e-02f, 2.55143829e-03f, -5.67799155e-03f, 1.65219437e-02f, -6.78393804e-03f,
  5.27418628e-02f, -1.72705755e-01f, 2.55946428e-01f, 4.69087273e-01f, 3.61027569e-02f, -2.92152107e-01f, -4.70424332e-02f, 1.41171172e-01f, 2.11222634e-01f, -2.29158193e-01f,
  -1.14338502e-01f, -1.35010540e-01f, -1.86691418e-01f, 1.16115235e-01f, 5.65003008e-02f, -2.29893535e-01f, -4.02846634e-02f, -1.34109780e-01f, 1.78573299e-02f, 8.99372771e-02f,
  2.32412860e-01f, 2.20396891e-01f, 2.44401306e-01f, 2.83116728e-01f, 1.50582477e-01f, 3.16856712e-01f, 2.83292919e-01f, 3.16598527e-02f, 8.55339542e-02f, -7.78218955e-02f,
  -1.52045101e-01f, 1.90546960e-01f, -3.63671244e-03f, -3.58109847e-02f, -2.50196084e-02f, -8.74040201e-02f, -9.56334993e-02f, 3.58196124e-02f, 1.16489828e-01f, -1.10474387e-02f,
  -8.83029178e-02f, -5.31151146e-02f, 1.31770968e-01f, 8.03806335e-02f, 3.59991193e-02f, 2.39226166e-02f, 4.47611324e-02f, 4.35573198e-02f, 5.16487546e-02f, -8.57047588e-02f,
  5.04689068e-02f, -2.51771137e-02f, 3.19252349e-02f, -4.32766490e-02f, 1.08632736e-01f, 1.19955428e-01f, 6.12247400e-02f, -7.39995018e-02f, -5.98438159e-02f, 7.42305368e-02f,
  2.79294257e-03f, -2.63437483e-04f, -3.90672404e-03f, -7.55017065e-03f, 3.31593342e-02f, -4.83104177e-02f, 4.72350232e-02f, -3.57733108e-02f, 4.79745120e-02f, -4.08115387e-02f,
  2.38217748e-04f, 3.70659237e-03f, -2.11501289e-02f, 3.09602451e-02f, 1.44367456e-03f, 1.41812311e-02f, -6.10636957e-02f, 3.47178504e-02f, 1.93275232e-02f, -1.71866324e-02f,
  6.65377006e-02f, 3.06341778e-02f, -1.53804489e-03f, 1.15012517e-02f, -2.61433944e-02f, 2.55422704e-02f, -2.59236507e-02f, 4.15017568e-02f, 6.01062551e-02f, 1.34892901e-02f,
  -9.92632061e-02f, 8.08794424e-02f, 5.83098382e-02f, -9.91340429e-02f, 9.33732614e-02f, -4.59676906e-02f, -4.09084149e-02f, -7.95282423e-02f, 3.58694941e-02f, 5.05571477e-02f,
  7.63526768e-04f, -4.36532199e-02f, -5.26451170e-02f, -2.15634946e-02f, 2.94641964e-02f, -2.55632028e-03f, -2.47062333e-02f, -1.81673490e-03f, 1.03565082e-01f, 3.74011211e-02f,
  -2.34222189e-02f, -2.42968164e-02f, 1.00870535e-01f, 1.91205200e-02f, -3.33850924e-03f, -1.23381782e-02f, -5.94217330e-02f, 7.09237307e-02f, 3.65690812e-02f, -1.50497595e-03f,
  2.05669433e-01f, 3.05701327e-02f, -1.30034834e-01f, 8.50460678e-02f, -7.87518024e-02f, -3.32089275e-01f, -4.94605452e-01f, 3.88407968e-02f, -2.61312604e-01f, -3.17856252e-01f,
  1.86324600e-04f, 6.78455606e-02f, -3.60873610e-01f, 3.19006503e-01f, 3.12398225e-01f, -1.53394550e-01f, 2.42743611e-01f, 5.38847819e-02f, 1.49041086e-01f, 1.80544004e-01f,
  3.63754332e-01f, 3.64936799e-01f, 3.60559374e-01f, 3.94419253e-01f, 1.64076000e-01f, 2.93711454e-01f, 2.61225045e-01f, -3.72998696e-03f, 3.04869056e-01f, 1.97227612e-01f,
  -6.88232407e-02f, -1.01684025e-02f, -5.49665019e-02f, 8.39559212e-02f, -9.08122733e-02f, -9.01444256e-02f, -4.19854932e-02f, 7.45785981e-03f, -6.10196441e-02f, -5.33935148e-03f,
  -5.80763854e-02f, 1.32856488e-01f, 6.71739504e-02f, 1.52031649e-02f, 3.95881571e-02f, 6.90699369e-02f, 2.91895755e-02f, -6.72621131e-02f, -2.80931983e-02f, 5.91214076e-02f,
  -5.63978627e-02f, 5.97631931e-03f, -1.54480217e-02f, 4.63900575e-03f, -1.12245381e-02f, 3.01298313e-02f, -4.30992320e-02f, 2.39394624e-02f, 8.54412168e-02f, 2.41239509e-03f,
  1.47617608e-01f, -7.81019181e-02f, -3.23084965e-02f, 8.76355916e-03f, -4.43735458e-02f, 2.59317514e-02f, 5.07877208e-02f, 5.01541160e-02f, 3.05128600e-02f, 2.46907584e-02f,
  -1.37881120e-03f, 5.34972660e-02f, -7.47966813e-03f, -2.57058945e-02f, 2.04773825e-02f, -5.82969654e-03f, -9.68321227e-03f, 6.22496419e-02f, 1.13966363e-03f, 8.34667981e-02f,
  1.45502191e-03f, -3.56307551e-02f, -6.08171523e-02f, -1.84821442e-03f, -5.51840588e-02f, 4.26638080e-03f, 2.48602051e-02f, -3.29288095e-02f, -1.78253502e-02f, 6.61805719e-02f,
  7.92734176e-02f, 5.56857511e-02f, 1.96073228e-03f, -5.56490803e-03f, 6.41823234e-03f, -1.66397095e-02f, 2.88479123e-02f, 1.30082928e-02f, 7.36761987e-02f, -8.83442238e-02f,
  -2.22665984e-02f, -8.88510607e-04f, -3.16989236e-02f, 8.65708441e-02f, 9.04073790e-02f, 6.49430044e-03f, 7.40629435e-02f, 3.78919356e-02f, 1.25167686e-02f, 1.08532816e-01f,
  -3.05075645e-02f, -1.12106606e-01f, -1.10004200e-02f, 3.76745775e-05f, 7.14687034e-02f, -4.90738004e-02f, 3.75042744e-02f, 2.45706625e-02f, -5.82585623e-03f, -4.81558993e-04f,
  -2.94960588e-01f, -2.60891199e-01f, 1.09935179e-01f, 1.18385307e-01f, 1.48831710e-01f, 1.91607207e-01f, 9.06552672e-02f, 7.27319419e-02f, -1.59801580e-02f, -3.13974470e-01f,
  -1.30464360e-01f, -4.01034951e-01f, -6.40149415e-02f, 1.27149865e-01f, 1.60113260e-01f, 1.76250190e-01f, 2.30314970e-01f, 8.11118558e-02f, 2.01983169e-01f, -1.16227649e-01f,
  2.23436862e-01f, -8.10706690e-02f, 3.09740394e-01f, -3.32559310e-02f, -7.70697743e-02f, -4.75371927e-02f, -1.70722738e-01f, -2.92682927e-02f, -7.19671547e-02f, -4.15977165e-02f,
  -1.53994739e-01f, -2.15597838e-01f, -2.14486077e-01f, -2.88365018e-02f, -6.12144135e-02f, -1.08214833e-01f, -5.05124517e-02f, 3.36987968e-03f, 2.54558604e-02f, 4.26736325e-02f,
  -9.56921056e-02f, 7.92717040e-02f, -1.29985921e-02f, -4.43738773e-02f, 1.96484774e-02f, 7.50831608e-03f, 2.83769369e-02f, 1.48792446e-01f, 7.22794607e-02f, 5.94263263e-02f,
  1.98841654e-02f, 6.32619262e-02f, 4.59067076e-02f, 7.88729042e-02f, 1.12037532e-01f, 1.16519863e-02f, 7.73161352e-02f, 1.75379049e-02f, 2.08906531e-02f, -7.23994002e-02f,
  2.73053651e-03f, -7.10860863e-02f, -1.31127119e-01f, 5.31423651e-03f, -2.04242859e-03f, 4.90472019e-02f, -6.98897392e-02f, 2.09288858e-02f, -2.99938004e-02f, 4.71055917e-02f,
  6.56259954e-02f, -8.23962241e-02f, 2.94533521e-02f, 5.46329729e-02f, -9.44781862e-03f, 1.10499738e-02f, 3.41862664e-02f, 4.63721808e-03f, 5.96203580e-02f, 5.12127466e-02f,
  1.20043522e-02f, -6.25575036e-02f, -3.88211891e-04f, -5.23523940e-03f, -8.73756483e-02f, 9.13549289e-02f, -6.51487336e-02f, 2.55939532e-02f, -3.30398642e-02f, 7.75803998e-03f,
  -3.84383172e-01f, -5.12913823e-01f, -6.85276464e-02f, -9.70313028e-02f, -1.39789969e-01f, -6.24997802e-02f, -1.10179195e-02f, -2.78706923e-02f, -1.72357738e-01f, -5.03302030e-02f,
  -5.37927598e-02f, -8.51327553e-03f, -1.32206902e-01f, -1.13162482e-02f, -2.40513794e-02f, -4.21280041e-03f, -1.52825732e-02f, -1.41534761e-01f, -1.98837847e-01f, -5.68507388e-02f,
  -2.54822560e-02f, -1.96473580e-02f, -2.39055473e-02f, 2.38937419e-02f, -3.95818905e-04f, -5.56819476e-02f, -1.07877597e-01f, -1.07256658e-01f, -5.88045316e-03f, 1.31487660e-02f,
  -8.64600897e-01f, 5.13142943e-01f, -2.08831683e-01f, -2.45036274e-01f, -1.61486328e-01f, 2.27520272e-01f, 2.28417233e-01f, 8.68053585e-02f, 2.29369313e-01f, 5.96696496e-01f,
  2.62170404e-01f, -1.48278158e-02f, 3.86339277e-01f, 2.97314376e-01f, -2.97534794e-01f, 2.79983222e-01f, 1.99803710e-01f, 1.09059811e-01f, 5.84679320e-02f, -2.14791996e-03f,
  -2.36605361e-01f, 1.85272574e-01f, -2.15539467e-02f, 1.21439546e-01f, -1.68523923e-01f, -2.80412376e-01f, -1.17345855e-01f, -2.10836239e-04f, -9.90829468e-02f, 4.14396301e-02f,
  -1.08661421e-01f, -2.96063125e-01f, -1.23512328e-01f, -1.65495381e-01f, -2.05747947e-01f, -1.06973335e-01f, -1.90864801e-01f, -3.38604972e-02f, -9.63409469e-02f, 2.47639492e-02f,
  -6.83107972e-02f, -1.87510252e-02f, 1.35135502e-02f, 8.09426904e-02f, 1.62287578e-02f, -6.18882440e-02f, 1.98244513e-03f, -5.46899363e-02f, 4.34761489e-04f, -6.07211143e-02f,
  6.56409264e-02f, -5.68305701e-02f, 2.15280205e-02f, 2.93258056e-02f, -8.28682035e-02f, 5.50990626e-02f, 1.84062291e-02f, -2.47534569e-02f, -1.15527205e-01f, -2.71815546e-02f,
  1.33893518e-02f, 3.05685978e-02f, 4.07242700e-02f, -3.23599961e-04f, -1.78744290e-02f, -1.74734090e-02f, 5.95638491e-02f, -3.79987955e-02f, 2.84086633e-02f, 4.51616757e-02f,
  -4.85095344e-02f, -6.23380169e-02f, -1.15349786e-02f, -1.10404575e-02f, 2.25839708e-02f, 2.46924218e-02f, -6.35090321e-02f, 2.31589302e-02f, 1.66590177e-02f, 1.30290827e-02f,
  3.22425477e-02f, 1.35694016e-02f, -1.97064527e-03f, 8.32306687e-03f, 1.10348826e-02f, -1.90553199e-02f, 2.00254135e-02f, 3.83067355e-02f, 3.93745750e-02f, -8.04149136e-02f,
  -8.81705880e-02f, -2.29337141e-01f, -8.92419927e-03f, -9.78007098e-04f, 2.46258695e-02f, -5.02311811e-02f, 8.15529004e-02f, -4.68369499e-02f, 6.02421537e-02f, -1.02078496e-02f,
  -5.31776808e-02f, -2.09104866e-02f, -5.71922287e-02f, -1.78040061e-02f, 3.25547978e-02f, 1.29599720e-01f, 6.15092926e-02f, 7.32317101e-03f, 2.70551089e-02f, -9.62862466e-03f,
  -5.93274459e-02f, -2.92370152e-02f, -2.78421361e-02f, 9.05407779e-03f, 5.63344955e-02f, 3.29901353e-02f, -1.05543785e-01f, -7.52205029e-02f, -9.47223008e-02f, 1.83735583e-02f,
  -2.21292615e-01f, 6.08889423e-02f, -4.27823305e-01f, -2.22323924e-01f, 5.74167930e-02f, -5.44941783e-01f, -4.97710675e-01f, -8.95847455e-02f, 3.02815307e-02f, 2.80137151e-01f,
  -8.08425620e-02f, 1.39764607e-01f, 3.48795354e-02f, -6.91963851e-01f, -7.80321896e-01f, -3.61976981e-01f, -5.47667921e-01f, -1.74695417e-01f, -9.29116011e-02f, -9.11286697e-02f,
  -1.92118913e-01f, -2.98153222e-01f, -4.39745337e-01f, 8.41227248e-02f, -1.63271040e-01f, 2.09009871e-01f, 3.10562164e-01f, 1.89050168e-01f, -1.60357654e-02f, -1.88630745e-01f,
  -2.42829427e-01f, -2.39334330e-02f, 3.67134996e-02f, -6.18441515e-02f, -4.52088490e-02f, 9.69771743e-02f, 3.13440822e-02f, -4.28847559e-02f, -3.94145921e-02f, -6.83602644e-03f,
  3.40397879e-02f, 2.79698018e-02f, -1.19044036e-01f, 1.93153471e-02f, 1.23350494e-01f, 2.71957070e-02f, -5.25096729e-02f, 1.79105010e-02f, 4.00189236e-02f, -8.16207007e-02f,
  -1.30479455e-01f, 4.14247345e-03f, -1.67823620e-02f, 8.74555111e-02f, -4.18375991e-02f, 2.59765498e-02f, -9.18185106e-05f, 5.16060255e-02f, 2.73026507e-02f, 9.65168420e-03f,
  4.62880656e-02f, 8.48208070e-02f, -3.55327055e-02f, -7.18479306e-02f, -4.04379889e-02f, -4.04004473e-03f, 1.67614501e-02f, 1.93065498e-02f, 5.08859791e-02f, -3.12233102e-02f,
  3.53599750e-02f, -9.41130100e-04f, 2.26748995e-02f, 1.54863568e-02f, -4.05674204e-02f, 6.56938879e-03f, 3.26048620e-02f, 4.38639447e-02f, -2.87351254e-02f, -3.66941839e-02f,
  1.45780640e-02f, -6.23286404e-02f, 2.76812837e-02f, -7.28560239e-03f, -8.66622180e-02f, 8.39395374e-02f, 4.47616205e-02f, 2.51562502e-02f, 2.77164057e-02f, 1.91341210e-02f,
  -9.11700912e-03f, 5.65885529e-02f, -5.10101765e-02f, 1.17843546e-01f, 5.37150763e-02f, -8.69125724e-02f, -5.30317873e-02f, -4.78488989e-02f, -5.01777185e-03f, -2.67723519e-02f,
  6.65008351e-02f, 7.05276653e-02f, 4.51630987e-02f, 1.18964934e-03f, -2.11690329e-02f, -4.73164693e-02f, 7.68576413e-02f, 1.83284599e-02f, 7.83621296e-02f, 1.81724573e-03f,
  1.67295828e-01f, 8.47603232e-02f, 2.38591749e-02f, 4.83542122e-02f, 8.50497931e-02f, 5.55337407e-02f, 1.20506929e-02f, -2.22867331e-03f, 2.81941071e-02f, -3.24877910e-02f,
  -1.17615266e-02f, 6.54815674e-01f, 5.21833777e-01f, -4.51704338e-02f, -1.65958926e-01f, -6.25855327e-02f, -1.81331411e-01f, 1.30786330e-01f, -5.96104702e-03f, 2.06424639e-01f,
  -1.67046115e-01f, 4.11490887e-01f, 1.08541304e-03f, 2.37672571e-02f, -6.00250840e-01f, -3.23303521e-01f, -1.29376322e-01f, 2.31900085e-02f, -9.80910510e-02f, -2.93552857e-02f,
  -1.84718072e-01f, -3.67831439e-01f, 1.49464197e-02f, 3.41244717e-03f, 1.92386732e-01f, 2.85315812e-01f, -3.44795734e-01f, 9.27322451e-03f, 1.23472534e-01f, -1.66117270e-02f,
  -1.80364400e-02f, 4.83726040e-02f, 1.31569251e-01f, 8.67944360e-02f, -9.95315332e-03f, -3.69747616e-02f, 2.74541378e-02f, -4.18416448e-02f, -8.51950794e-02f, 1.11981099e-02f,
  4.87205200e-02f, 7.90438876e-02f, 2.88105886e-02f, -4.05360833e-02f, 3.40672582e-02f, 9.62311253e-02f, 1.67216748e-01f, 1.33113205e-01f, 1.01811282e-01f, 1.41648889e-01f,
  1.57183290e-01f, 1.89792141e-01f, -1.65599883e-02f, 7.09990263e-02f, -7.66580971e-03f, 6.11187667e-02f, 5.77835254e-02f, 3.48521695e-02f, 5.88624887e-02f, 5.82205914e-02f,
  -2.30644364e-02f, -1.16763063e-01f, 1.02945911e-02f, -3.43920067e-02f, -2.38419604e-02f, -2.34108139e-03f, 2.21474445e-03f, -3.44724655e-02f, -1.72904283e-02f, -2.67488174e-02f,
  2.43361462e-02f, 9.71646979e-03f, -2.92150397e-02f, 1.30854426e-02f, -2.71194801e-02f, 2.47048456e-02f, -6.26747217e-03f, 6.95670024e-02f, -2.73142196e-03f, 4.21630256e-02f,
  -5.17872795e-02f, -6.65842518e-02f, -7.09643448e-03f, -3.53615507e-02f, -5.53419925e-02f, -2.74211001e-02f, 7.56631866e-02f, 9.04710591e-02f, -6.32131763e-04f, -7.93852434e-02f,
  -1.35017335e-01f, -1.97301269e-01f, 2.48627886e-02f, 5.99539876e-02f, -1.65832601e-02f, 7.29441494e-02f, -2.08250750e-02f, 6.34091273e-02f, -6.62580580e-02f, 2.51774583e-03f,
  1.20021508e-03f, -8.57244655e-02f, 9.13272798e-03f, 6.84349146e-03f, 7.13053392e-03f, 6.56461855e-03f, -1.00794978e-01f, -1.74659658e-02f, -3.10670622e-02f, 4.06091474e-02f,
  1.15699142e-01f, -1.06676832e-01f, -3.32012661e-02f, -2.66211852e-02f, -1.52764854e-03f, -2.74029933e-02f, -6.20755665e-02f, 1.18233703e-01f, 2.97429785e-02f, -1.44285597e-02f,
  -2.77552614e-03f, 1.22396864e-01f, 2.77249962e-01f, -3.44978124e-01f, -1.69651639e-02f, 3.55487883e-01f, 1.65281538e-02f, 6.86460780e-03f, 9.32921693e-02f, -2.03811258e-01f,
  -4.12371516e-01f, 9.70108435e-02f, 1.77358717e-01f, -3.15830618e-01f, 4.58918571e-01f, 3.91933084e-01f, 2.74150223e-02f, -4.40170132e-02f, 1.29636094e-01f, -2.47959167e-01f,
  -3.71045582e-02f, -3.78243029e-01f, 1.64509527e-02f, -3.05807769e-01f, -4.01547134e-01f, -3.31372678e-01f, -3.54840308e-01f, 2.23280881e-02f, -3.23170036e-01f, -8.54935090e-04f,
  -9.32898372e-02f, -1.60931572e-01f, 3.37122343e-02f, 7.18206987e-02f, 6.78802580e-02f, 4.12986428e-02f, -4.84810257e-03f, 5.95624223e-02f, 4.47096005e-02f, 8.12355801e-02f,
  -3.52990031e-02f, 4.43570726e-02f, -3.75288241e-02f, 3.70095074e-02f, -7.46980608e-02f, -5.84463775e-02f, -3.17160375e-02f, -4.28413190e-02f, 4.99403179e-02f, 2.03439258e-02f,
  1.11871762e-02f, 7.54374191e-02f, -2.53357925e-02f, 3.78801078e-02f, 3.92980576e-02f, -8.43825005e-03f, 7.17932954e-02f, 5.42302653e-02f, -1.79251116e-02f, 7.57036135e-02f,
  -4.49309982e-02f, 2.58708056e-02f, 2.94533428e-02f, -9.44724232e-02f, -4.28970195e-02f, -9.17084515e-02f, -4.22007926e-02f, -7.51447231e-02f, -2.75025815e-02f, -5.51708601e-02f,
  -4.77977693e-02f, -7.84171224e-02f, -8.95942841e-03f, 7.31113255e-02f, -5.84196113e-02f, -6.48429245e-02f, 4.37973766e-03f, -2.72946376e-02f, 4.50432897e-02f, -3.13936244e-03f,
  -1.28143728e-01f, 5.40191866e-02f, -1.15911597e-02f, -2.76044719e-02f, 6.09081797e-02f, 1.84350908e-02f, -4.56850640e-02f, 3.82747538e-02f, -1.72594432e-02f, -3.44544556e-03f,
  9.89248827e-02f, 7.22299740e-02f, 7.61566218e-03f, 3.13294269e-02f, 8.12286064e-02f, -5.09309322e-02f, 1.11777276e-01f, 2.89729377e-03f, -5.30624809e-03f, 4.57725413e-02f,
  -6.49902672e-02f, -5.79675771e-02f, 8.06963630e-03f, -1.00663930e-01f, 6.18485622e-02f, -3.94641720e-02f, 3.67009477e-03f, -4.05097939e-02f, 6.90401793e-02f, -1.88577324e-02f,
  5.07295597e-03f, -2.57214736e-02f, 2.45172214e-02f, 5.69846900e-03f, -9.04219672e-02f, -4.16669883e-02f, 2.60601174e-02f, 8.25072005e-02f, 7.30631575e-02f, 1.11068659e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.31582165e-01f, 2.07400903e-01f, 2.19901755e-01f, 4.35097635e-01f, 4.58393991e-01f, 4.19812143e-01f, 2.86258280e-01f, 5.70378244e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  2.08813906e-01f, 1.10575587e-01f, -9.70418975e-02f, -6.45009875e-01f, -5.88107891e-02f, 1.30098999e-01f, -3.26748282e-01f, -4.03747186e-02f, 1.00346223e-01f, -2.70285904e-01f,
  2.71703042e-02f, 5.10246120e-02f, -1.29555643e-01f, -2.21683204e-01f, -5.42641938e-01f, 5.72063684e-01f, 6.21206880e-01f, -4.95640934e-01f, 5.39687037e-01f, 1.13653526e-01f,
  5.65553844e-01f, 1.56541124e-01f, 8.21111724e-02f, 3.99857908e-01f, -2.03882635e-01f, -1.35512734e-02f, -4.90090847e-01f, 3.34211081e-01f, 9.83147025e-01f, -4.34196711e-01f,
  -1.02591164e-01f, -3.03791612e-01f, -6.98703974e-02f, -5.43220162e-01f, 6.33794516e-02f, 1.97289065e-01f, 2.42747843e-01f, -4.35751304e-02f, -6.48249567e-01f, 3.28498751e-01f,
  -4.57353055e-01f, 9.88106579e-02f, -1.28007933e-01f, 4.18019980e-01f, 7.52134979e-01f, -5.65853238e-01f, -1.66430861e-01f, 4.06599820e-01f, -7.25363314e-01f, 4.82985526e-01f,
  8.27655256e-01f, -4.46015656e-01f, 7.25147367e-01f, 5.61341643e-01f, 6.08614564e-01f, -1.76069587e-01f, 6.36177361e-01f, -3.79237771e-01f, 1.90963045e-01f, -3.32633913e-01f,
  3.14272732e-01f, -3.65164369e-01f, -3.13086450e-01f, -1.88356370e-01f, -6.38518691e-01f, -7.26486593e-02f, -7.05626160e-02f, 2.29985744e-01f, -4.92228359e-01f, -3.78815204e-01f,
  3.64723414e-01f, -2.59300262e-01f, 3.20664883e-01f, 2.50621110e-01f, 5.32413572e-02f, -2.84820259e-01f, 4.94979143e-01f, -6.67704940e-01f, -3.32067490e-01f, -1.67053923e-01f,
  -5.65203607e-01f, 4.83753026e-01f, 1.43154845e-01f, -7.60043859e-02f, 3.98546010e-02f, 1.02069594e-01f, -4.73656327e-01f, 6.77419245e-01f, -1.00303320e-02f, 4.24183190e-01f,
  7.51179338e-01f, 2.05060452e-01f, -4.11273956e-01f, -2.55202472e-01f, -1.71294853e-01f, -4.20202672e-01f, -3.74762341e-02f, 4.20412868e-01f, 2.82641947e-01f, 8.39602873e-02f,
  -2.00606301e-01f, -1.19796224e-01f, 4.44560610e-02f, -2.88210064e-01f, -3.23843300e-01f, 2.36856535e-01f, -4.60323274e-01f, -1.27263844e-01f, -4.49639231e-01f, 2.78050601e-01f,
  3.37692797e-01f, -1.89257592e-01f, 7.71094918e-01f, -4.67202991e-01f, 3.38408351e-01f, 1.94229648e-01f, -6.03713632e-01f, -3.07518132e-02f, -2.38847047e-01f, 1.72598734e-01f,
  -2.41216630e-01f, -3.41979228e-03f, -2.33415812e-01f, -3.76805484e-01f, 5.42909443e-01f, 8.76090407e-01f, 2.48342812e-01f, -5.22498012e-01f, 3.08649063e-01f, 1.89301252e-01f,
  1.65814266e-01f, 2.86915191e-02f, 1.80686623e-01f, 1.74554866e-02f, 3.74364406e-01f, 3.00057173e-01f, 3.25405896e-02f, -1.65115416e-01f, 2.29581326e-01f, 3.29599649e-01f,
  -2.72047520e-02f, 2.93869525e-02f, 5.54711103e-01f, 1.49430454e-01f, -1.25676036e-01f, -9.81183648e-01f, 1.48867399e-01f, 5.00707090e-01f, -8.74193132e-01f, -1.80901542e-01f,
  -9.80738342e-01f, -2.01665461e-01f, -1.86984077e-01f, -2.08583698e-01f, 1.75657943e-01f, 4.80298281e-01f, 3.59722257e-01f, -5.47822356e-01f, 3.68411869e-01f, 5.41487515e-01f,
  2.40375340e-01f, 5.37085474e-01f, -2.71940440e-01f, 2.71872491e-01f, 5.16229689e-01f, 3.94449979e-01f, 3.41391385e-01f, -3.69083852e-01f, 2.80448180e-02f, 2.01225147e-01f,
  3.77990725e-03f, 2.86406457e-01f, -3.00469309e-01f, -6.56148717e-02f, 5.92498183e-01f, -2.15318799e-01f, 1.53531402e-01f, 3.01594675e-01f, 4.55215544e-01f, -7.82853544e-01f,
  6.65839612e-01f, -4.41997588e-01f, 7.64222920e-01f, -7.06677496e-01f, -3.05690795e-01f, -6.59871250e-02f, -2.35547498e-01f, -3.70687813e-01f, 3.05805892e-01f, -2.10914642e-01f,
  -2.26171076e-01f, 6.53373599e-01f, 1.58174098e-01f, 2.49605641e-01f, 2.48333439e-01f, -4.98718709e-01f, -1.66643992e-01f, -2.71681398e-01f, 1.09037571e-01f, 2.67386407e-01f,
  5.55281401e-01f, -3.01983375e-02f, 3.41257430e-03f, 1.11214615e-01f, -1.65259078e-01f, 7.75218666e-01f, 6.24623477e-01f, -7.15911210e-01f, -6.94708228e-01f, 8.03653419e-01f,
  -5.52407861e-01f, 2.65748978e-01f, 3.56947631e-01f, -4.80044305e-01f, 1.94987833e-01f, 4.45842683e-01f, -3.12589467e-01f, 4.63527411e-01f, -2.13231519e-01f, 5.44802904e-01f,
  -5.10257006e-01f, -2.15550512e-01f, -2.93078452e-01f, 3.58949206e-03f, -3.15724194e-01f, -2.56784916e-01f, -2.60575861e-01f, -4.19187427e-01f, -3.39833558e-01f, -4.34642911e-01f,
  -1.91323785e-03f, 2.59876102e-02f, 1.04812816e-01f, -2.17181638e-01f, -5.55626974e-02f, 7.70117864e-02f, -4.73040432e-01f, 2.72692829e-01f, -5.31787813e-01f, -3.07879239e-01f,
  4.59868133e-01f, -3.79264116e-01f, -3.41956586e-01f, -4.58794177e-01f, -1.83211535e-01f, -5.61269037e-02f, -3.60514164e-01f, -4.46068719e-02f, 4.80900675e-01f, -2.65390843e-01f,
  1.48127839e-01f, -9.38731357e-02f, -3.73703778e-01f, 7.79601574e-01f, -3.54779482e-01f, 5.02960443e-01f, 6.72316626e-02f, -4.16656971e-01f, 2.01881956e-02f, 4.05501910e-02f,
  -3.15812416e-03f, 2.01570153e-01f, -2.78431654e-01f, -2.45175600e-01f, -5.34902401e-02f, -1.42762572e-01f, -6.54593483e-02f, -1.67094976e-01f, -1.15917474e-01f, -3.88903826e-01f,
  4.12924260e-01f, 2.74377197e-01f, 2.00443730e-01f, 1.71059325e-01f, -6.63724244e-01f, 4.27140236e-01f, 4.01681066e-02f, 5.69846332e-01f, 4.99801725e-01f, -6.95739329e-01f,
  -1.23472838e-02f, 6.40046597e-01f, 8.19504023e-01f, -2.43768454e-01f, -3.17841679e-01f, -1.51507929e-01f, 7.78371766e-02f, -2.98674017e-01f, 3.47896367e-01f, 7.62704611e-02f,
  2.69735783e-01f, 2.60054260e-01f, -3.43040615e-01f, 5.69846511e-01f, 1.55618295e-01f, 3.33122522e-01f, -9.39054638e-02f, 3.25313658e-01f, 1.58182353e-01f, -5.78445375e-01f,
  -1.85345024e-01f, 5.80683589e-01f, -6.57220602e-01f, 5.61550558e-02f, -7.23608911e-01f, -5.66388965e-01f, -4.80951816e-01f, -4.93198931e-01f, -8.42411816e-01f, 1.06892407e-01f,
  5.83477855e-01f, 7.15302527e-01f, -9.70044732e-02f, -2.09190503e-01f, -4.04909492e-01f, 2.34915420e-01f, -3.43312472e-01f, -3.63905430e-01f, -2.80117124e-01f, 4.83815312e-01f,
  -7.39924535e-02f, 9.64598432e-02f, 1.31230772e-01f, 1.48787066e-01f, 3.22279185e-01f, 4.00683403e-01f, 2.11338207e-01f, -9.99438837e-02f, 3.26423556e-01f, 3.53652835e-01f,
  1.59951121e-01f, -6.11242354e-02f, 6.42025948e-01f, -5.80992937e-01f, -2.43107021e-01f, 3.26141939e-02f, -3.59646559e-01f, 1.45521164e-01f, 3.57989371e-01f, 3.46332550e-01f,
  5.52931540e-02f, -2.76692718e-01f, -7.05019414e-01f, -6.19017720e-01f, 3.59871000e-01f, -1.11964859e-01f, -2.26620436e-01f, -5.57434797e-01f, -4.32877362e-01f, 9.27821875e-01f,
  -9.43091214e-02f, -4.47018355e-01f, -3.42026539e-02f, -2.46949717e-01f, -6.48465902e-02f, 1.62141193e-02f, -1.36157542e-01f, 3.12351793e-01f, -4.30491388e-01f, 2.04791337e-01f,
  1.86042875e-01f, 2.23400444e-02f, 2.97784060e-01f, 2.37897813e-01f, 3.76544505e-01f, 3.66830707e-01f, 2.41350234e-01f, -2.33229756e-01f, 6.40114903e-01f, 2.77173907e-01f,
  -7.49107838e-01f, 7.51132071e-02f, 7.45121837e-02f, -3.02238792e-01f, -2.46546753e-02f, -8.08622763e-02f, -4.61175859e-01f, -7.72999823e-02f, -1.26461275e-02f, -3.71617615e-01f,
  -4.67374355e-01f, 3.02277058e-01f, 1.19021475e+00f, -1.93555444e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  9.79627892e-02f, 2.95965344e-01f, 2.12678388e-02f, -1.79017514e-01f, 5.53374141e-02f, 5.78845330e-02f, 1.18187346e-01f, -1.60146341e-01f, -1.47735983e-01f, 1.37110660e-02f,
  1.96094401e-02f, 6.00935053e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    