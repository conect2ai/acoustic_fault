/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.54162461e-01f, 3.81076112e-02f, -1.70513213e-01f, 2.04194501e-01f, 7.54992142e-02f, -1.87583435e-02f, 2.29787320e-01f, 3.06619070e-02f, 5.62847443e-02f, 1.73874468e-01f,
  9.89546031e-02f, 1.20738726e-02f, -2.54325345e-02f, 2.71874100e-01f, -3.20644319e-01f, -1.09189630e-01f, 6.66885599e-02f, 7.56347254e-02f, 5.00919558e-02f, -8.96549318e-03f,
  7.38372281e-03f, 2.18032017e-01f, -9.90588441e-02f, 1.49926841e-01f, 2.07539603e-01f, -8.39082804e-03f, -5.51866032e-02f, 6.03912920e-02f, -8.56250711e-03f, 8.94906186e-03f,
  -6.58410490e-02f, 1.01282775e-01f, 2.63787210e-02f, -7.74233118e-02f, 3.54685076e-02f, -4.80137318e-02f, -9.88687947e-02f, 7.32789235e-03f, -4.85732965e-03f, -6.79738671e-02f,
  2.35692654e-02f, -7.82681182e-02f, 4.87159044e-02f, 3.76282670e-02f, 1.05783537e-01f, -5.52673824e-02f, -2.07327250e-02f, -1.81908701e-02f, -7.12489942e-03f, -2.41369028e-02f,
  1.09848708e-01f, 1.05372760e-02f, 2.95462962e-02f, -6.55219778e-02f, -1.38626233e-01f, 1.52085006e-01f, -7.99197853e-02f, -6.95143864e-02f, -7.01006055e-02f, 4.28396761e-02f,
  2.68396009e-02f, 2.53685731e-02f, 9.42188427e-02f, 7.71239549e-02f, 3.52953281e-03f, 2.95338295e-02f, 4.37140763e-02f, -3.47227417e-02f, -9.88913700e-03f, 6.39714003e-02f,
  -3.11019253e-02f, -3.44861113e-03f, 8.25009495e-02f, 2.41912389e-03f, -1.77168474e-02f, 1.55909196e-01f, -4.31302153e-02f, -2.82038972e-02f, 5.66102862e-02f, -2.25547608e-02f,
  1.25378132e-01f, -7.22701922e-02f, 1.04509722e-02f, -5.46321422e-02f, -2.71780882e-02f, -1.45033091e-01f, 7.65166245e-03f, 2.40566004e-02f, 3.45976427e-02f, -2.41528839e-01f,
  -1.90089300e-01f, -1.90833002e-01f, 1.13190385e-02f, -3.79462652e-02f, -1.75028446e-03f, 1.26383239e-02f, 2.09568571e-02f, -1.06850103e-01f, -4.53685224e-02f, 6.25530705e-02f,
  -2.73511503e-02f, -6.13296730e-03f, -6.13742284e-02f, 1.62281301e-02f, -1.00759558e-01f, -9.99615788e-02f, 1.82638690e-02f, -3.17428960e-03f, -1.20142348e-01f, -1.18296817e-02f,
  1.88349932e-02f, 7.50410259e-02f, -6.20847791e-02f, -8.33882391e-02f, -1.13521457e-01f, -5.53398253e-03f, -4.85250019e-02f, 3.49449404e-02f, -1.27131402e-01f, -6.16263635e-02f,
  3.91642094e-01f, -2.47599304e-01f, -2.16774911e-01f, -8.59463215e-02f, 1.38638645e-01f, -8.13555196e-02f, -1.31664976e-01f, -4.02791537e-02f, 7.95235187e-02f, -1.68694034e-01f,
  5.18034101e-02f, -2.28014842e-01f, -1.23766989e-01f, -8.46263766e-02f, 1.54516725e-02f, -3.43426824e-01f, -1.22737378e-01f, -1.55503765e-01f, -6.30951226e-02f, 1.13107853e-01f,
  5.31085841e-02f, 1.17244937e-01f, -2.06236348e-01f, 4.32628952e-02f, 2.50134654e-02f, -7.69765824e-02f, -2.13748917e-01f, -7.78162181e-02f, -7.58658722e-02f, -2.12369621e-01f,
  1.76562399e-01f, 7.82004595e-02f, 8.45235661e-02f, 4.82084714e-02f, 1.40655696e-01f, 1.05423264e-01f, 5.84666384e-03f, -2.89083198e-02f, 1.20365933e-01f, -5.03451899e-02f,
  -1.44308224e-01f, 4.34391648e-02f, -8.39293674e-02f, -8.81225336e-03f, 1.76524460e-01f, -2.05980632e-02f, -1.21460957e-02f, 3.83411720e-02f, -4.82521243e-02f, -1.21065557e-01f,
  -1.08892933e-01f, 3.61568993e-03f, 3.05051990e-02f, -1.71365246e-01f, -9.32835862e-02f, -5.40753752e-02f, -1.15731418e-01f, -1.35600209e-01f, -9.83860195e-02f, -1.13263980e-01f,
  -1.26793057e-01f, -1.57941673e-02f, -2.38373280e-02f, 1.16874889e-01f, 1.03260323e-01f, 1.22720845e-01f, 9.42192152e-02f, 2.43666433e-02f, 8.83030817e-02f, 1.22027218e-01f,
  1.45554051e-01f, 8.94767269e-02f, 6.45925328e-02f, 7.27781430e-02f, 2.67695989e-02f, 5.43214893e-03f, 6.61566034e-02f, -1.58108957e-02f, 9.14532170e-02f, 4.60255034e-02f,
  4.62601334e-02f, 6.24852665e-02f, 8.13322812e-02f, 1.77191161e-02f, -1.16365757e-02f, -6.91572279e-02f, 6.33887947e-02f, 2.01206859e-02f, 2.96982117e-02f, 3.24854231e-03f,
  5.23525327e-02f, -7.32841715e-02f, 8.90209153e-02f, 1.09317251e-01f, 1.51967052e-02f, 7.26812035e-02f, 5.73305115e-02f, 4.90824990e-02f, -1.22703053e-02f, -8.14090855e-03f,
  -5.89109771e-02f, 3.64069864e-02f, 7.13005662e-02f, 5.67172915e-02f, -2.84633432e-02f, -2.11191727e-04f, 5.58373258e-02f, -4.16204520e-02f, -1.19965717e-01f, -6.55950084e-02f,
  1.26619320e-02f, 5.43532372e-02f, -3.63223925e-02f, -7.53073171e-02f, -9.47369188e-02f, -1.04864268e-02f, -1.61161497e-02f, -4.87323180e-02f, 2.76069324e-02f, -9.71313864e-02f,
  -2.38142505e-01f, -5.61608970e-02f, 1.43087894e-01f, 2.16137711e-02f, -5.68439718e-03f, -1.74419165e-01f, 1.77398836e-03f, -4.30900529e-02f, -5.36419265e-03f, -3.13748047e-02f,
  -3.22175235e-03f, 4.42771688e-02f, -3.43251936e-02f, -4.56669591e-02f, -2.34327689e-01f, 1.22839987e-01f, -1.40919462e-01f, 1.67662390e-02f, 1.49117380e-01f, -2.35484704e-01f,
  -2.09113322e-02f, -8.48805010e-02f, 1.04654193e-01f, 6.29653558e-02f, -4.90429439e-02f, 1.12671234e-01f, -1.50549700e-02f, 9.11503136e-02f, -1.08084911e-02f, 1.00748148e-02f,
  -7.88023993e-02f, 9.84044969e-02f, 1.19764790e-01f, 5.88781061e-03f, -1.40440166e-01f, -2.64790840e-02f, 5.84714934e-02f, 1.15211889e-01f, 1.37844551e-02f, 3.37167010e-02f,
  -2.93665733e-02f, 3.06506939e-02f, -1.91838406e-02f, 1.09885991e-01f, 6.63453266e-02f, 1.37136877e-01f, 3.61538939e-02f, -4.19296026e-02f, 1.29962936e-01f, 5.07031418e-02f,
  -3.09768226e-03f, -2.53950469e-02f, 7.48670101e-02f, -4.76367064e-02f, 8.85351151e-02f, 1.88068077e-02f, 4.38444689e-02f, 2.94530280e-02f, -1.90498717e-02f, -5.30583188e-02f,
  -7.14319613e-05f, -9.07149538e-02f, -1.77134387e-02f, -2.08571590e-02f, -9.62089896e-02f, 7.55912960e-02f, -2.09370274e-02f, 4.83240224e-02f, 5.23898043e-02f, -2.04778779e-02f,
  -5.47255315e-02f, 7.78840035e-02f, 5.76419421e-02f, 1.89635381e-02f, 4.05571610e-02f, -8.06065127e-02f, 5.33097833e-02f, -3.10836569e-03f, -3.90723310e-02f, 6.71050027e-02f,
  -2.48746295e-02f, -8.76498595e-02f, -4.01048809e-02f, 6.24185465e-02f, 5.50251938e-02f, -2.77639013e-02f, -2.74230763e-02f, 3.24624591e-02f, 5.92770837e-02f, 1.11624151e-01f,
  -2.74405718e-01f, -1.51143312e-01f, -8.10535904e-03f, -5.76955406e-03f, -7.80693395e-03f, 3.65774557e-02f, 1.11200675e-01f, 8.12327936e-02f, -8.58958438e-02f, -6.86095729e-02f,
  4.81734872e-02f, -7.95905106e-03f, -1.83835000e-01f, -4.87656245e-04f, 5.38308248e-02f, 6.01643287e-02f, -3.28386165e-02f, -1.48318158e-02f, 4.49674204e-03f, -9.99228209e-02f,
  -6.03487454e-02f, -3.87918502e-02f, -3.75211763e-04f, -4.40914556e-02f, 7.16947839e-02f, 5.75908693e-03f, -4.99176793e-02f, 7.28376135e-02f, -5.29216928e-03f, 2.94529945e-02f,
  -5.10862052e-01f, -1.19704023e-01f, -1.35694563e-01f, -1.81569114e-01f, 5.18439300e-02f, -2.82999694e-01f, -3.85200530e-01f, 1.27960518e-01f, -1.22553699e-01f, 2.28106882e-02f,
  1.02389790e-01f, -1.92798197e-01f, 7.12041482e-02f, -1.50200754e-01f, -1.30865887e-01f, 6.93086535e-03f, -1.69119239e-01f, -3.62989213e-03f, -5.97737506e-02f, -1.45801708e-01f,
  -5.57461753e-02f, 8.10516626e-02f, -1.79739874e-02f, 1.80516884e-01f, -1.47580981e-01f, 2.41719354e-02f, 2.77197212e-01f, 2.00804509e-02f, 4.78301793e-02f, 8.00806135e-02f,
  -6.95448741e-02f, -4.79063988e-02f, -1.85968634e-02f, -2.87960414e-02f, -3.86548154e-02f, -1.33299321e-01f, -3.77777629e-02f, 7.52410367e-02f, 6.20998349e-03f, -3.69148031e-02f,
  2.58490629e-02f, 7.11038336e-02f, 5.95998392e-02f, 1.18529670e-01f, 6.79507330e-02f, 2.87889857e-02f, -4.85865921e-02f, 2.05427147e-02f, 2.21331064e-02f, -7.73987845e-02f,
  -3.79756801e-02f, 5.05061597e-02f, 3.33180428e-02f, 5.17314561e-02f, 8.31895173e-02f, 6.64604083e-02f, -5.47121987e-02f, 4.26088423e-02f, 5.80937080e-02f, -1.28506958e-01f,
  3.58561845e-03f, -8.71896818e-02f, -1.16618872e-01f, -2.04333779e-03f, -6.13425039e-02f, -2.03264356e-02f, -6.60124272e-02f, -3.22059467e-02f, -1.39117464e-01f, -6.64241090e-02f,
  -4.55367975e-02f, -2.03626342e-02f, 2.60768160e-02f, 1.50159467e-04f, -2.74396297e-02f, 6.63692737e-03f, 5.18721044e-02f, 4.75825518e-02f, 2.19355132e-02f, 2.46550608e-02f,
  -4.82302271e-02f, -7.03620091e-02f, -1.61597505e-02f, 1.07007019e-01f, 3.76407504e-02f, 2.48536766e-02f, -1.26109016e-03f, -3.41195799e-02f, -4.73401546e-02f, -7.69401086e-04f,
  8.93910707e-04f, 1.40048964e-02f, -6.25946447e-02f, -4.11901809e-03f, -2.72640456e-02f, -2.70313025e-02f, -5.95174022e-02f, 6.19683377e-02f, 6.38746982e-03f, -7.51879886e-02f,
  5.43082468e-02f, 3.72802801e-02f, 1.32640796e-02f, 1.05767690e-01f, 1.71508223e-01f, -5.75268529e-02f, -1.18415169e-01f, 1.56442858e-02f, 3.50818597e-02f, 3.89581211e-02f,
  7.85569623e-02f, 3.82468365e-02f, -1.44181922e-02f, -3.17543745e-02f, 1.17067739e-01f, 2.76506059e-02f, -5.55167235e-02f, 2.77104359e-02f, 7.42188469e-02f, 7.13520870e-02f,
  -1.09991990e-01f, 1.39364183e-01f, -2.76892006e-01f, 1.02060601e-01f, 9.59156901e-02f, 1.31401226e-01f, 1.98235903e-02f, 1.29685000e-01f, 3.28220502e-02f, 3.35227311e-01f,
  7.61938840e-02f, -5.09265549e-02f, -4.86958399e-02f, 2.83285111e-01f, -1.36091381e-01f, -1.30558476e-01f, 1.94469616e-01f, 3.36368829e-02f, -4.91608679e-02f, 8.67187232e-02f,
  -4.13751826e-02f, 2.72869319e-01f, -8.05946365e-02f, 2.08262071e-01f, 8.46389085e-02f, -5.76571114e-02f, 6.15098737e-02f, -1.59493312e-01f, 1.98569804e-01f, -4.68785986e-02f,
  -3.11311893e-02f, -4.45041135e-02f, 3.11779808e-02f, -1.22616187e-01f, 1.24209207e-02f, -7.84119070e-02f, -3.68319340e-02f, -1.63883388e-01f, -2.02357839e-03f, -3.04128304e-02f,
  -1.77492782e-01f, 2.23232955e-02f, 2.28368025e-02f, -1.97665337e-02f, -7.07474947e-02f, -4.25938070e-02f, 2.28332579e-02f, 7.96223432e-02f, -2.51273811e-02f, -3.57410498e-02f,
  -1.03707775e-01f, 3.81166600e-02f, 1.83401052e-02f, 2.38411641e-03f, 2.46939510e-02f, -1.19832316e-02f, 5.61278649e-02f, -2.89125890e-02f, -1.32878432e-02f, 1.16368905e-01f,
  -3.22544202e-02f, 4.34393734e-02f, 8.41939002e-02f, 1.21007012e-02f, 2.51145605e-02f, -3.86186317e-02f, 1.03622302e-01f, -4.29167971e-02f, 7.88985286e-03f, 4.39589582e-02f,
  5.14637493e-02f, -4.10782322e-02f, -7.37060159e-02f, 8.04451704e-02f, 1.34563595e-01f, 4.20808941e-02f, -6.34057224e-02f, 8.45922604e-02f, 5.32389544e-02f, 8.05078298e-02f,
  -2.53924113e-02f, 2.44334247e-02f, 9.29017887e-02f, -9.01592374e-02f, -4.89883162e-02f, -5.83953150e-02f, 7.72868320e-02f, 3.63883190e-02f, 3.35272700e-02f, -3.49554271e-02f,
  1.58073053e-01f, 2.03521669e-01f, 9.87133849e-03f, -4.35324907e-02f, -1.00593381e-01f, -8.78863782e-02f, -5.91463335e-02f, 8.01735278e-03f, -1.10777870e-01f, 4.79722731e-02f,
  -1.03791945e-01f, 4.36450467e-02f, -4.38723043e-02f, 3.86110768e-02f, 5.43333218e-02f, 7.57012665e-02f, -3.89704071e-02f, -1.52906831e-02f, -6.37304038e-02f, 6.27155751e-02f,
  3.88874747e-02f, 4.19593696e-03f, -1.34844156e-02f, 1.96433570e-02f, 9.73153785e-02f, -5.49535863e-02f, 1.22745201e-01f, -1.29115153e-02f, 5.49685247e-02f, 9.12076831e-02f,
  -3.84080261e-01f, -9.30297524e-02f, 1.03522748e-01f, 3.50716226e-02f, 1.00941323e-01f, 1.12754339e-02f, -1.52882114e-01f, 7.39690289e-02f, -1.40608385e-01f, 2.02990714e-02f,
  2.94178277e-01f, -1.16383016e-01f, -5.00768423e-02f, 1.81630030e-01f, -1.66129544e-01f, 2.14111842e-02f, -5.23563623e-02f, 8.81551430e-02f, -6.05151020e-02f, -9.16985795e-02f,
  2.50676530e-03f, 7.85353333e-02f, 4.31790687e-02f, 1.55554891e-01f, 2.24858411e-02f, 1.39781563e-02f, 6.67336658e-02f, 4.04978245e-02f, 2.44251117e-01f, 2.41453145e-02f,
  -2.98883170e-02f, -2.05802262e-01f, -9.72996186e-03f, -1.84476525e-02f, -7.59563819e-02f, -5.01078961e-04f, 7.00467154e-02f, -1.43474080e-02f, 6.50674105e-02f, -2.09408030e-02f,
  -9.13925022e-02f, 4.30965461e-02f, 3.29091423e-03f, 7.05217496e-02f, 7.42328465e-02f, 5.61666638e-02f, 3.03107854e-02f, 1.50498420e-01f, 6.35680035e-02f, 7.45810894e-03f,
  -5.82680153e-03f, 5.42720929e-02f, 3.60901728e-02f, 5.51010529e-03f, -5.27904928e-02f, 1.30140642e-02f, -1.95598658e-02f, -4.17403094e-02f, -5.12449183e-02f, -1.12177327e-01f,
  -1.40464110e-02f, -1.61432510e-03f, 8.49327911e-03f, -3.53213027e-02f, -1.14713341e-01f, -7.31822997e-02f, 1.18405521e-02f, -9.35913846e-02f, -1.64460659e-01f, -4.78344262e-02f,
  2.07408220e-02f, 5.02481777e-03f, -4.19995673e-02f, -4.63324226e-02f, -3.13132778e-02f, 8.62713961e-04f, 1.22340150e-01f, -4.96528819e-02f, -5.69472201e-02f, 1.41099215e-01f,
  9.09536928e-02f, -2.86301002e-02f, -1.00809615e-02f, 1.23650255e-02f, 5.13037629e-02f, -6.17672354e-02f, -3.73655371e-02f, 3.54759879e-02f, 4.61753383e-02f, 3.42573635e-02f,
  -1.43719092e-01f, -3.30908865e-01f, -5.14001884e-02f, -5.50422557e-02f, -1.47997569e-02f, 8.93077720e-03f, -1.45791695e-04f, 1.34732630e-02f, -9.36754420e-03f, -7.57301152e-02f,
  -3.21308970e-02f, 2.41462793e-02f, 2.15775203e-02f, 6.62802830e-02f, 1.15845144e-01f, 3.17306519e-02f, 7.51072355e-03f, 1.26330005e-02f, 3.72956842e-02f, 6.27766550e-02f,
  1.17467396e-01f, 1.01942651e-03f, -5.29263653e-02f, -4.28243726e-02f, -3.05130146e-02f, -3.50443870e-02f, 5.51483175e-03f, -3.64005119e-02f, -6.12725131e-02f, 2.69526318e-02f,
  2.59530451e-03f, 3.01130146e-01f, 1.09487057e-01f, 1.78544998e-01f, -1.07244983e-01f, -1.40459970e-01f, -1.25087500e-01f, 7.23832250e-02f, 4.54564318e-02f, -4.55318950e-02f,
  -2.71807581e-01f, 2.57610291e-01f, -1.40776739e-01f, 7.19403476e-02f, -2.70929396e-01f, -9.06658545e-02f, 1.25327911e-02f, -1.16200531e-02f, 1.31636173e-01f, 1.25147894e-01f,
  7.02208877e-02f, -1.51186645e-01f, -4.05471064e-02f, 1.07339941e-01f, 8.50015786e-03f, 9.21901241e-02f, -1.50380984e-01f, 1.07744224e-01f, 5.20369560e-02f, -1.00702778e-01f,
  -1.22203819e-01f, 8.29130225e-03f, 2.04229429e-02f, -1.33153154e-02f, -6.13012165e-02f, -3.99360433e-02f, -1.26794606e-01f, -1.00628428e-01f, 2.93622296e-02f, -3.81263159e-02f,
  -3.42523158e-02f, -9.65199247e-02f, 1.18168585e-01f, -3.86199504e-02f, -1.91956162e-02f, 6.11271486e-02f, 3.37690935e-02f, -1.13147289e-01f, 2.69400403e-02f, 2.45084800e-02f,
  8.10789317e-02f, -1.07429296e-01f, 1.78146586e-02f, -5.56156710e-02f, -9.78320464e-02f, -1.88581515e-02f, -1.16341440e-02f, -1.02959812e-01f, -4.76252586e-02f, 3.53555083e-02f,
  -2.05438584e-02f, 8.48202035e-02f, 9.40418318e-02f, -9.88571793e-02f, -1.28445411e-02f, -6.25991076e-02f, 7.62213543e-02f, -6.31370321e-02f, 9.51186270e-02f, -4.13953848e-02f,
  -8.26909766e-02f, 7.08116889e-02f, -1.53070278e-02f, 1.88095253e-02f, 6.35316521e-02f, 2.39925198e-02f, -1.16343831e-03f, 1.03841033e-02f, -2.53916867e-02f, 2.91426741e-02f,
  -1.00964503e-02f, -3.59296650e-02f, -8.17723051e-02f, -1.28854424e-01f, -2.40533650e-02f, 3.00527439e-02f, 1.07377566e-01f, 2.80945916e-02f, -6.80854470e-02f, 4.51402552e-02f,
  -1.42468899e-01f, 1.37655765e-01f, 1.55273043e-02f, -8.27509537e-02f, 6.13874644e-02f, -5.82738258e-02f, -3.72023545e-02f, 1.91012211e-02f, 5.17563447e-02f, -5.10529391e-02f,
  -3.01346928e-02f, -2.68004946e-02f, -1.78408045e-02f, -5.64778782e-02f, -8.60249475e-02f, 4.72777896e-02f, 1.69401262e-02f, -5.42878313e-03f, -1.56999797e-01f, -1.21424980e-02f,
  -5.03069237e-02f, -7.18196332e-02f, 7.66130537e-02f, -5.74027076e-02f, -6.78744689e-02f, 4.67353675e-04f, -1.90717205e-02f, 3.67034227e-02f, -3.86006571e-02f, 3.61797139e-02f,
  -2.24063233e-01f, 1.32748872e-01f, 4.93339412e-02f, -1.36275887e-01f, 1.33060813e-01f, -1.67936891e-01f, -1.60974905e-01f, 1.43262222e-01f, -3.39141749e-02f, 1.69650689e-01f,
  -3.07015061e-01f, -8.46265256e-02f, 1.21321459e-03f, -3.09214503e-01f, -4.38320756e-01f, -1.69262409e-01f, -3.55176628e-01f, -2.40568802e-01f, 1.50288409e-02f, -1.08434834e-01f,
  -1.48250908e-01f, -1.19287476e-01f, 8.91321152e-03f, 1.88858315e-01f, 1.45973966e-01f, 2.14878902e-01f, 4.46985625e-02f, 9.16859508e-02f, -3.19255330e-02f, 1.24249458e-02f,
  -1.62842814e-02f, 4.37429547e-02f, 1.44254789e-01f, 6.58111274e-02f, -2.47164033e-02f, -5.23245819e-02f, -9.22010913e-02f, 5.01878746e-02f, -3.68732996e-02f, 3.74640971e-02f,
  -4.30148877e-02f, -6.22204281e-02f, 2.40097195e-02f, 4.08356190e-02f, -3.89259607e-02f, 5.31425439e-02f, -1.61199216e-02f, -7.89019689e-02f, 2.33041700e-02f, -3.08968797e-02f,
  -6.13384396e-02f, -5.50388657e-02f, -1.03774883e-01f, -3.49514708e-02f, 6.00196235e-03f, -5.74274547e-02f, 2.23541092e-02f, 9.78532527e-03f, -1.82176067e-03f, 2.57355790e-03f,
  5.59451953e-02f, -2.11968198e-02f, 8.37639570e-02f, 4.26344983e-02f, -2.58638356e-02f, 3.20093296e-02f, -6.70402348e-02f, 4.06085663e-02f, -6.52800966e-03f, -3.62412110e-02f,
  -5.04714996e-02f, 6.76608980e-02f, -1.00766845e-01f, -1.20634306e-02f, -4.62664142e-02f, 8.57567266e-02f, -9.67028514e-02f, 7.17647746e-03f, 9.52028483e-03f, -3.74167003e-02f,
  3.99466092e-03f, -1.00589052e-01f, 2.34698579e-02f, -3.11765890e-03f, -9.45597440e-02f, 2.72972491e-02f, -2.28428245e-02f, 1.52562987e-02f, -6.91190129e-03f, -4.76886630e-02f,
  -1.31178066e-01f, -4.89154086e-02f, 5.92462756e-02f, -5.49162589e-02f, -3.59486118e-02f, -5.84278330e-02f, -5.84026100e-03f, 5.03708348e-02f, 5.72177246e-02f, 7.66181871e-02f,
  -2.45841313e-02f, -7.08668008e-02f, -9.23312828e-03f, 9.60463099e-03f, -7.01320842e-02f, 4.77192700e-02f, -2.00909480e-01f, -1.84634216e-02f, 1.13734202e-02f, -8.22343156e-02f,
  1.10977124e-02f, 5.50982654e-02f, -2.64618974e-02f, 5.45630641e-02f, -5.20434678e-02f, -1.51365949e-02f, 3.40746492e-02f, 1.33924289e-02f, -1.41243571e-02f, -7.50218844e-03f,
  1.62400961e-01f, 1.33643568e-01f, -1.60058439e-01f, 5.23986295e-02f, -4.49473970e-02f, 3.45633067e-02f, 1.63491685e-02f, 1.42389871e-02f, -5.73070347e-02f, 2.63124168e-01f,
  -3.31275240e-02f, 1.37374140e-02f, -7.90321603e-02f, 1.94623560e-01f, -2.01650932e-01f, -2.56446749e-01f, 2.12892801e-01f, 7.40020871e-02f, -1.20406568e-01f, 1.47175804e-01f,
  -5.32067977e-02f, 2.58141667e-01f, -1.82646751e-01f, 2.27649920e-02f, 1.09888278e-01f, -8.46877601e-03f, 1.26915410e-01f, -1.17509507e-01f, 1.37448996e-01f, -9.54038277e-03f,
  -6.56143203e-02f, -3.95851284e-02f, -1.27022378e-02f, 8.08125548e-03f, 7.03286007e-02f, 1.70239713e-03f, -1.79778319e-02f, -5.13471551e-02f, -9.70690995e-02f, 8.13451782e-02f,
  5.69772013e-02f, 2.04331633e-02f, 1.47139221e-01f, 5.74601740e-02f, 3.57329436e-02f, -5.23233861e-02f, -6.08425215e-02f, 2.32940516e-03f, -8.31344444e-03f, -2.03911331e-03f,
  -6.48048446e-02f, 6.98683113e-02f, 7.43621886e-02f, 1.39775202e-01f, -3.52179212e-03f, -7.70943016e-02f, 1.68742202e-02f, 6.63049370e-02f, 4.01357338e-02f, 5.50434440e-02f,
  9.17690992e-02f, 3.52666005e-02f, 4.26498614e-02f, -6.33909181e-02f, 1.04693417e-03f, -2.01206598e-02f, 1.19405910e-02f, 2.52620857e-02f, -3.32578039e-03f, 4.66369987e-02f,
  -4.69459072e-02f, -3.52237634e-02f, -2.44732015e-02f, 1.95140745e-02f, 1.35038659e-01f, -7.92063121e-03f, -3.18568014e-02f, 1.76707283e-02f, 4.66022119e-02f, -8.54004994e-02f,
  7.42774783e-03f, -1.05270423e-01f, -1.90258045e-02f, 3.52121480e-02f, -2.21458096e-02f, 1.25123588e-02f, 3.06744371e-02f, 3.19607630e-02f, -4.75208610e-02f, 1.65677462e-02f,
  -3.68221365e-02f, 1.26916155e-01f, -6.09460240e-03f, -9.09521133e-02f, 3.52805341e-03f, 4.71700579e-02f, 2.55264435e-02f, 1.14581294e-01f, -1.72776412e-02f, 4.25516106e-02f,
  7.69233853e-02f, 5.22068329e-02f, 7.16038048e-02f, -1.84882153e-02f, -3.12080458e-02f, -1.32987536e-02f, -3.18317711e-02f, -9.80744045e-03f, 9.62398127e-02f, 1.10248677e-01f,
  1.19541109e-01f, 8.27948377e-02f, -2.98655275e-02f, 9.05406028e-02f, 7.98386410e-02f, 6.86123073e-02f, 4.92266864e-02f, -3.61193381e-02f, 1.38592958e-01f, 7.33896345e-02f,
  1.89786121e-01f, -3.11812460e-01f, 3.31355244e-01f, 1.75797150e-01f, -5.25915995e-02f, -7.33311027e-02f, 5.57594420e-03f, -1.39334381e-01f, 1.04125455e-01f, -2.95147657e-01f,
  -2.06900939e-01f, 1.49950668e-01f, -2.23459870e-01f, -1.30215481e-01f, 1.88884497e-01f, 3.04547604e-02f, 4.78797816e-02f, 2.15417296e-02f, 5.94156720e-02f, -1.24362214e-02f,
  4.22145054e-02f, -2.39576340e-01f, 7.07846358e-02f, -9.35728401e-02f, -9.13283899e-02f, 1.25103042e-01f, -3.26709729e-03f, 7.12942705e-02f, 1.23168360e-02f, -2.13161204e-02f,
  -1.06937788e-01f, -6.60210624e-02f, -7.67070428e-02f, -1.68621317e-02f, -5.56182191e-02f, -1.54098617e-02f, 1.03032559e-01f, 8.87054577e-02f, 5.20933932e-03f, 2.25858726e-02f,
  -4.91290446e-03f, -3.37885171e-02f, 8.82495847e-03f, 7.82742649e-02f, -3.45373638e-02f, 8.02421123e-02f, 1.28793076e-03f, -3.85868065e-02f, -8.77618194e-02f, 4.62751091e-02f,
  -6.00084588e-02f, -5.06090792e-03f, -5.69774285e-02f, 6.60304725e-02f, 2.42984407e-02f, -9.22414884e-02f, 8.68757740e-02f, 5.44081368e-02f, 6.64216094e-03f, -3.16485241e-02f,
  6.19276538e-02f, -6.67531788e-02f, -7.67605454e-02f, -1.34922132e-01f, -2.89861709e-02f, -4.60096672e-02f, -3.98698896e-02f, -3.68271470e-02f, 1.83336362e-02f, -1.26870096e-01f,
  -9.05847698e-02f, -7.66053572e-02f, -7.70776570e-02f, 3.34440731e-02f, -1.13184132e-01f, -1.20906733e-01f, 2.19897870e-02f, 1.15475301e-02f, -3.90413068e-02f, 2.25328747e-02f,
  -2.06974847e-03f, -1.93221271e-02f, -1.09210677e-01f, 3.75629961e-02f, 4.26970795e-02f, -1.31979678e-02f, -1.29839359e-02f, 6.00447766e-02f, -2.23220065e-02f, 5.95235936e-02f,
  -2.20871702e-01f, -1.01575360e-01f, -1.06270917e-01f, -1.21198691e-01f, -5.28767481e-02f, -1.28085092e-01f, 1.06447309e-01f, 5.29792160e-02f, 2.29307655e-02f, -7.38370046e-02f,
  -5.42603396e-02f, -5.83088100e-02f, 1.05406810e-02f, 1.72444552e-01f, -1.31659340e-02f, 3.51602510e-02f, -1.02077559e-01f, -1.06121354e-01f, -4.31342348e-02f, -1.51001275e-01f,
  -1.11957893e-01f, 2.63577397e-03f, -1.17718140e-02f, -1.87400635e-02f, 6.38365000e-02f, -5.67121804e-02f, 9.70741585e-02f, 7.26655796e-02f, -7.79850269e-03f, -8.29991475e-02f,
  -1.70543030e-01f, 1.87906325e-01f, -2.04246521e-01f, 1.73980713e-01f, -1.02080084e-01f, -5.04062586e-02f, 2.41890937e-01f, 7.26227537e-02f, 2.90726393e-01f, 2.99714565e-01f,
  1.22873433e-01f, 1.13151394e-01f, 2.06969261e-01f, 1.01653636e-01f, -3.09148699e-01f, 2.56444484e-01f, 7.55961984e-02f, 1.91234887e-01f, 3.95412333e-02f, -1.49279401e-01f,
  -4.64252345e-02f, 4.55104560e-02f, -9.29382741e-02f, -5.04217297e-03f, -1.50567563e-02f, -4.23204452e-02f, 1.06865831e-01f, 1.45019649e-03f, -5.96303008e-02f, 5.82269393e-02f,
  -1.10743664e-01f, 6.08253963e-02f, -4.17080671e-02f, -9.36433673e-03f, -1.46059170e-01f, -1.17271699e-01f, -5.73213249e-02f, 3.41036133e-02f, -1.11509688e-01f, 1.40636060e-02f,
  6.59570098e-02f, -1.78730842e-02f, 6.29580095e-02f, 6.51847422e-02f, -1.92554127e-02f, 1.38830196e-03f, -6.45529330e-02f, 1.55097246e-02f, 6.87534735e-02f, -3.52059193e-02f,
  -3.02030612e-02f, 7.36217648e-02f, 2.78076958e-02f, 9.09255370e-02f, -4.22575511e-03f, 5.37272217e-03f, 9.26504135e-02f, -6.22317158e-02f, 7.51157925e-02f, -1.53901735e-02f,
  5.66682499e-03f, 1.31048575e-01f, -1.78949442e-02f, 4.27362835e-03f, 7.45493127e-03f, 4.06318437e-03f, 3.10832337e-02f, 2.31178384e-02f, -6.18562326e-02f, -1.77860670e-02f,
  -9.83597636e-02f, -5.85423317e-03f, 9.29094031e-02f, 8.45100433e-02f, 1.36855030e-02f, 1.41322017e-01f, -2.38823742e-02f, 4.68390323e-02f, -1.06131092e-01f, -4.95947190e-02f,
  1.00974329e-01f, -1.14960320e-01f, -2.36146636e-02f, 5.37099913e-02f, 9.75649282e-02f, 3.63620445e-02f, 9.23921727e-03f, 1.32298199e-02f, -7.99565539e-02f, 6.66958988e-02f,
  -3.34389769e-02f, 9.31876004e-02f, -1.26324550e-04f, -5.25651425e-02f, -6.89484412e-03f, -1.38756335e-01f, 8.22090879e-02f, -8.05586576e-02f, -3.31289531e-03f, 4.91613224e-02f,
  3.07714078e-03f, 2.13115718e-02f, 3.62424366e-02f, -5.00246622e-02f, -5.03279604e-02f, -2.98584942e-02f, 1.96190719e-02f, 5.67433573e-02f, 4.90648858e-02f, -4.59947204e-03f,
  2.56693698e-02f, 4.87939939e-02f, 4.94379215e-02f, 2.02478468e-02f, 8.02283064e-02f, 4.02053110e-02f, 5.19244149e-02f, 4.17143144e-02f, -4.32982221e-02f, 1.09273128e-01f,
  5.16723655e-02f, -3.93007882e-02f, -6.37607276e-02f, 1.54464975e-01f, 1.04108706e-01f, -1.01603918e-01f, 1.04235500e-01f, 9.05092433e-02f, 3.12467694e-01f, -3.44759412e-03f,
  -8.71600881e-02f, 8.13918486e-02f, -3.64249609e-02f, -3.51937898e-02f, -2.20875099e-01f, 8.50609839e-02f, -9.76417437e-02f, -6.15639724e-02f, 1.56560168e-01f, 3.43626481e-04f,
  5.22469133e-02f, 6.89941179e-03f, -6.38506338e-02f, 1.20527282e-01f, 8.23359191e-02f, 2.46887803e-02f, -1.53701767e-01f, 5.81755415e-02f, -1.45520747e-01f, 6.70739785e-02f,
  -1.11429542e-01f, 2.83697322e-02f, -3.45574021e-02f, -7.18472078e-02f, -1.04233749e-01f, -5.55545986e-02f, -1.38995513e-01f, -4.04035412e-02f, -2.45910902e-02f, -5.75775467e-03f,
  1.75391790e-02f, 3.34927812e-02f, 1.45846844e-01f, 5.75007945e-02f, 1.11418448e-01f, 7.63119534e-02f, -4.28225473e-02f, -8.56205747e-02f, 5.36271110e-02f, 2.67417058e-02f,
  7.71952942e-02f, 6.07640855e-03f, -1.00691551e-02f, 7.27308616e-02f, -5.34686493e-03f, 1.56995028e-01f, 6.84941411e-02f, 9.28797643e-04f, 4.20111679e-02f, 7.42457658e-02f,
  6.08457290e-02f, -4.08670716e-02f, -1.15977628e-02f, -1.90835465e-02f, -6.04000315e-03f, 5.83031680e-03f, -1.50485307e-01f, -3.27808969e-02f, -1.50896786e-02f, -9.08901766e-02f,
  -1.12805270e-01f, -1.16387382e-01f, -1.11067019e-01f, -2.64951047e-02f, 4.63103736e-03f, 1.06117532e-01f, -9.86673087e-02f, 2.76569966e-02f, 3.41222137e-02f, 2.46234518e-02f,
  8.13800469e-03f, 1.05561716e-02f, -1.14851199e-01f, -7.38817155e-02f, 1.86452530e-02f, 3.32132764e-02f, -1.13844335e-01f, -4.33805324e-02f, -1.65004898e-02f, -4.97749113e-02f,
  -1.58953503e-01f, -6.85128123e-02f, 3.95306014e-02f, -4.92144078e-02f, -6.62616566e-02f, -3.36183645e-02f, -4.20293510e-02f, -5.14986292e-02f, -4.98906374e-02f, -2.31901370e-02f,
  -1.29053211e-02f, -1.25425756e-01f, 4.26086690e-03f, 2.75856396e-03f, -6.86760694e-02f, -6.86737224e-02f, -6.14772141e-02f, -4.25007120e-02f, 6.51677314e-04f, -3.49412896e-02f,
  5.06854691e-02f, 5.79786897e-02f, 4.22669202e-02f, 1.41468674e-01f, -8.58953130e-03f, -1.28786557e-03f, -2.67940052e-02f, 8.72313753e-02f, -2.41498812e-03f, -1.72816589e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.07509562e-01f, -1.65828019e-01f, -3.20492744e-01f, -1.00196190e-01f, 2.91663975e-01f, 1.52996629e-01f, -8.27130303e-02f, 4.67058346e-02f, -1.71216056e-01f, 1.32869676e-01f,
  -2.78134458e-03f, -2.75095344e-01f, -1.32003620e-01f, -2.76060373e-01f, -2.30529144e-01f, -3.68959516e-01f, -6.98302314e-02f, -9.28674862e-02f, -2.37470195e-01f, -7.41630644e-02f,
  -3.29693928e-02f, 8.70262682e-02f, -3.08555305e-01f, 1.95530474e-01f, 1.54049814e-01f, 9.73873213e-02f, 3.12816530e-01f, 8.00880510e-03f, 1.47722632e-01f, 1.78779161e-03f,
  -1.27003968e-01f, -2.43504569e-01f, -5.49753867e-02f, -1.66419037e-02f, 4.64308001e-02f, 7.90951028e-02f, 1.50740206e-01f, -3.70779186e-02f, 3.90824862e-03f, -1.14307985e-01f,
  8.19011033e-02f, 1.05387811e-02f, -6.24236241e-02f, -1.81094240e-02f, 5.14533035e-02f, 9.65620726e-02f, -8.74952823e-02f, 5.47048673e-02f, -1.49239635e-03f, -1.80777952e-01f,
  -1.75941050e-01f, 6.29762039e-02f, 9.51476917e-02f, -1.55161982e-02f, -1.61044095e-02f, 7.24249333e-03f, -2.26411875e-02f, 4.53952253e-02f, 6.43721670e-02f, -1.08057030e-01f,
  4.26108725e-02f, 7.92897046e-02f, -2.33020894e-02f, -9.54542086e-02f, -1.08292326e-01f, 7.20985234e-02f, -2.11295355e-02f, -4.39781658e-02f, -8.99438411e-02f, 3.33840288e-02f,
  6.39833510e-03f, -8.80276710e-02f, -8.80398080e-02f, 5.97006157e-02f, -3.49388756e-02f, -9.93234068e-02f, 5.00674509e-02f, 1.58446226e-02f, -3.69633473e-02f, 3.16999033e-02f,
  5.31785265e-02f, -1.43959159e-02f, 9.95117575e-02f, 1.37746334e-01f, -1.56704746e-02f, -5.52506978e-03f, 7.35046640e-02f, -1.01574033e-01f, -2.34500226e-02f, 6.10119775e-02f,
  1.39179975e-01f, 9.37428325e-02f, -6.95344359e-02f, -1.67147294e-02f, 2.48921551e-02f, 5.69460914e-03f, 2.21377593e-02f, 8.75394642e-02f, 7.72474334e-02f, -6.13890179e-02f,
  9.44046006e-02f, 1.40391245e-01f, 2.26677820e-01f, -4.39853780e-03f, 7.88478181e-02f, 5.06607406e-02f, 7.25291371e-02f, 1.38941169e-01f, 2.66295373e-01f, 7.74587877e-03f,
  1.17264926e-01f, 9.06512812e-02f, 4.22981493e-02f, 2.85380837e-02f, 1.10544793e-01f, 1.14743620e-01f, 4.05563116e-02f, -1.12199455e-01f, 5.91856465e-02f, -3.06367641e-04f,
  -6.73044026e-01f, 3.04101110e-01f, -7.25689903e-02f, -8.58902335e-02f, 3.98665555e-02f, 3.57128203e-01f, 2.15640798e-01f, 1.18795261e-01f, -2.48715468e-02f, 2.78143138e-01f,
  2.67465144e-01f, -2.54946798e-01f, 1.53987467e-01f, 2.38490373e-01f, -7.33499676e-02f, 1.85612991e-01f, 1.38914943e-01f, 1.33736730e-01f, -6.51973039e-02f, -1.54614389e-01f,
  -9.89267454e-02f, 2.13392019e-01f, 8.73917118e-02f, -1.52575253e-02f, -8.25886503e-02f, -2.15059966e-01f, 1.70458499e-02f, -5.73899969e-02f, 2.40413193e-02f, -5.36513291e-02f,
  -8.32481012e-02f, -2.89390713e-01f, -3.37084346e-02f, -1.62806109e-01f, -1.18646391e-01f, -6.73797727e-02f, -1.92388371e-02f, 1.56270210e-02f, -5.30133992e-02f, -5.15358225e-02f,
  -7.15342239e-02f, 4.74086031e-02f, -2.89565492e-02f, -7.92454407e-02f, -9.60445628e-02f, -5.21411709e-02f, 9.90815163e-02f, 4.50694636e-02f, 5.22210784e-02f, 5.57633005e-02f,
  7.47812837e-02f, 1.51164442e-01f, 1.21095799e-01f, 9.32125375e-02f, 9.64023098e-02f, -1.91572122e-02f, -1.88624952e-02f, -3.77508663e-02f, 3.42075601e-02f, -3.83090377e-02f,
  1.87512692e-02f, 1.02603763e-01f, 7.66620561e-02f, 5.89136072e-02f, -2.07848791e-02f, -7.74567798e-02f, -1.38146495e-02f, -1.01065658e-01f, 3.64980288e-02f, 3.21644358e-02f,
  -1.61329135e-02f, -1.20795351e-02f, -7.20964372e-02f, 9.90299881e-03f, 3.76596823e-02f, -1.09457068e-01f, -1.83166265e-02f, -4.58844490e-02f, 4.67163809e-02f, 2.98496932e-02f,
  2.01195572e-02f, 4.06553416e-04f, 1.48168042e-01f, 7.45734796e-02f, -3.53637934e-02f, -5.46524301e-02f, -1.23262657e-02f, 7.97420964e-02f, 4.57412489e-02f, -3.82265188e-02f,
  -9.54894572e-02f, -2.58994609e-01f, 4.35785204e-02f, -9.56795365e-02f, -9.58972350e-02f, -5.58569729e-02f, -4.79304679e-02f, 6.27362030e-03f, -7.53447339e-02f, 2.96375155e-02f,
  1.59539785e-02f, 7.60866608e-03f, -1.03620172e-01f, -2.57417150e-02f, -5.05000390e-02f, 1.00841977e-01f, -1.87431611e-02f, -8.14864337e-02f, 7.98196718e-02f, -7.04060134e-04f,
  -9.80828404e-02f, -8.55230391e-02f, 3.43174599e-02f, 6.19814061e-02f, 2.32395455e-02f, -2.89129280e-02f, -8.10139701e-02f, -3.90668074e-03f, -4.31813784e-02f, 3.61571983e-02f,
  -3.31713438e-01f, 1.53857738e-01f, -2.83325076e-01f, -2.25063190e-01f, -2.65420437e-01f, -3.13916087e-01f, -1.87352940e-01f, 3.00263185e-02f, 7.30503052e-02f, 2.41681829e-01f,
  1.11165851e-01f, 1.69869382e-02f, 2.73840904e-01f, 6.68571815e-02f, -1.75729543e-01f, 2.65852451e-01f, -1.87943265e-01f, -6.25565127e-02f, 5.80951385e-02f, -5.72880022e-02f,
  -2.80089807e-02f, -5.72334118e-02f, -2.19751820e-01f, -3.44793648e-02f, -2.91416049e-01f, -1.11385994e-01f, 3.21587995e-02f, -7.16561750e-02f, -2.20072389e-01f, -1.28900334e-01f,
  -3.63186806e-01f, -1.28256574e-01f, 1.59399782e-03f, -1.17383040e-01f, -1.01225406e-01f, -1.16264105e-01f, -7.18843341e-02f, 6.01413921e-02f, -1.29871303e-02f, -3.79362404e-02f,
  -6.18527690e-03f, -3.23732644e-02f, -3.37306783e-03f, 4.37827967e-02f, -7.85838217e-02f, -1.45055041e-01f, -1.13457173e-01f, -7.76215419e-02f, -4.34452929e-02f, -4.47511859e-02f,
  -1.47612154e-01f, 4.00470644e-02f, -1.10674217e-01f, -3.22409943e-02f, -1.53329268e-01f, -5.91513254e-02f, -5.36285415e-02f, 6.46994403e-03f, -1.66003823e-01f, -2.11553156e-01f,
  9.01283696e-02f, -7.26244897e-02f, -4.09944095e-02f, 6.10154010e-02f, 5.59778884e-03f, -2.97793560e-02f, -6.30811453e-02f, 6.53098524e-02f, 3.30209546e-02f, -5.68552315e-02f,
  -4.07088883e-02f, 4.92610037e-02f, -2.25061011e-02f, -3.07239294e-02f, 3.03251538e-02f, 2.39122361e-02f, 5.10493927e-02f, -1.80831514e-02f, 6.95820674e-02f, -3.15312371e-02f,
  5.43615632e-02f, 2.23933011e-02f, 5.08468114e-02f, 6.31663948e-02f, -1.19199619e-01f, -3.26573886e-02f, 3.45798954e-02f, 5.88191971e-02f, -1.51962098e-02f, -9.77735370e-02f,
  -4.96478200e-01f, -3.63797545e-01f, -2.34874859e-02f, -5.58491014e-02f, 9.67756733e-02f, -4.22622524e-02f, 7.45274276e-02f, 6.55630454e-02f, -1.11213252e-01f, -6.75497577e-02f,
  -6.38914630e-02f, 1.13738505e-02f, -1.34057641e-01f, 1.24350796e-02f, 6.63015768e-02f, -4.16846946e-02f, 1.41115366e-02f, 1.26193026e-02f, -1.47465169e-01f, -4.48149517e-02f,
  -8.83889273e-02f, 1.36698574e-01f, -2.64289603e-02f, -7.01905638e-02f, 2.57138088e-02f, -8.60962793e-02f, 2.46757735e-03f, 6.61103353e-02f, -1.15123592e-01f, -4.51321006e-02f,
  4.24955934e-01f, -1.33141130e-01f, 5.43799140e-02f, 2.14316845e-01f, 1.30958468e-01f, 2.76549399e-01f, 4.26562041e-01f, -4.08300199e-02f, 2.68335104e-01f, 1.87942642e-03f,
  -5.03001176e-02f, 1.11638129e-01f, 4.11579721e-02f, 5.47203720e-02f, 1.72941685e-01f, -1.04079703e-02f, 9.85884517e-02f, 6.21687397e-02f, 9.25837159e-02f, 1.40965849e-01f,
  1.42119989e-01f, 7.02136680e-02f, -1.72734767e-01f, -1.48975179e-01f, 7.11294636e-02f, -1.41171128e-01f, -2.40720317e-01f, -1.40570002e-02f, -1.25160202e-01f, 1.34088937e-03f,
  -8.56206268e-02f, -2.28452086e-02f, -4.50099185e-02f, -9.70276725e-03f, -3.49092670e-02f, -4.19792049e-02f, -2.04536598e-02f, -3.79403867e-02f, -4.16171663e-02f, 8.17968547e-02f,
  8.71795267e-02f, 3.96821797e-02f, 1.33767873e-01f, -5.10003418e-02f, -3.67873721e-03f, 4.71046604e-02f, -5.68963811e-02f, -8.91624466e-02f, -1.11606650e-01f, 2.47018319e-02f,
  1.25007212e-01f, -2.88574062e-02f, 1.00588888e-01f, -3.50782163e-02f, -2.45081242e-02f, 7.71451043e-04f, 1.79982744e-02f, -7.56978542e-02f, -3.06750685e-02f, 6.17312230e-02f,
  -1.94145963e-02f, 6.99564442e-02f, 1.57953680e-01f, -5.88858407e-03f, 1.16988055e-01f, 1.56013221e-02f, 7.57634714e-02f, 1.00740120e-02f, 1.09952070e-01f, 9.18064415e-02f,
  3.68166640e-02f, 1.79615188e-02f, -4.70146686e-02f, 4.73232046e-02f, 9.50968415e-02f, 6.90782517e-02f, 6.32880954e-04f, 5.90684125e-03f, 2.50344928e-02f, 6.05409034e-02f,
  -2.01317109e-02f, 1.95209645e-02f, 5.75987399e-02f, -7.97498226e-02f, -7.12619200e-02f, 1.03053086e-01f, -4.29045670e-02f, -1.18173575e-02f, -3.74148302e-02f, 9.00815278e-02f,
  1.68757550e-02f, -3.11523750e-02f, -4.83808517e-02f, -9.15285479e-03f, -7.87802320e-03f, -7.36162588e-02f, -9.55318939e-03f, -6.04337081e-02f, -1.00260070e-02f, 9.28909630e-02f,
  -1.28546981e-02f, 5.89988306e-02f, 5.26794754e-02f, -7.70459846e-02f, -8.30494761e-02f, 9.26745906e-02f, -4.21565678e-03f, -9.43689421e-03f, -1.08408011e-01f, -1.42450333e-02f,
  -8.38886539e-04f, 1.09651014e-01f, 1.31539524e-01f, 1.58532515e-01f, 3.65778320e-02f, -1.33819990e-02f, -8.11281335e-03f, -6.16401322e-02f, 4.02633175e-02f, -8.28403886e-03f,
  -1.68296024e-01f, 3.11233103e-01f, 2.47405812e-01f, 1.58767387e-01f, 1.24519430e-01f, 2.43217289e-01f, 1.53013796e-01f, 1.62652954e-01f, 3.44770193e-01f, -1.99432783e-02f,
  -8.91407579e-02f, 8.81900340e-02f, -8.19408298e-02f, -1.37371883e-01f, 6.84640333e-02f, 1.42568171e-01f, 1.58002377e-01f, 1.47059813e-01f, 2.19600931e-01f, -1.14074305e-01f,
  1.98837463e-02f, -1.22738317e-01f, -1.11531109e-01f, -1.56610206e-01f, -1.47257254e-01f, 2.18217149e-02f, -1.95875749e-01f, 1.17084071e-01f, -8.61004693e-04f, 1.43095747e-01f,
  -9.82803181e-02f, -6.79016695e-04f, -1.58807725e-01f, 3.55275273e-02f, -1.46760762e-01f, 2.49716416e-02f, -1.47464247e-02f, -2.33051386e-02f, 1.43834660e-02f, -6.95871096e-03f,
  2.00254973e-02f, -5.76704480e-02f, 1.04173180e-02f, 6.85820729e-02f, 5.31895719e-02f, 3.43018621e-02f, 1.94530543e-02f, -9.61458459e-02f, -2.14695986e-02f, 1.57186482e-02f,
  -1.42768070e-01f, -4.80566584e-02f, -1.29937381e-01f, 1.15162775e-01f, -7.33146444e-02f, 6.74595311e-02f, 1.33300379e-01f, -1.74740311e-02f, 5.91104887e-02f, 1.67656504e-02f,
  2.62579061e-02f, 2.13124424e-01f, -6.47626370e-02f, -6.25099093e-02f, 7.44874356e-03f, -1.83201954e-02f, -1.40239261e-02f, -2.53231544e-02f, -3.33345197e-02f, -7.94371963e-02f,
  1.89494658e-02f, -4.10281168e-03f, -8.17718450e-03f, 4.20352817e-02f, 6.83827922e-02f, 3.73238549e-02f, -5.03779501e-02f, 4.55573574e-02f, -1.31456047e-01f, -1.45716444e-01f,
  2.24787015e-02f, 7.28415400e-02f, -1.22935429e-01f, 2.63757985e-02f, 5.39567173e-02f, 1.17786424e-02f, 1.72205642e-02f, -3.79927941e-02f, -3.92053090e-02f, 4.13608290e-02f,
  1.46238640e-01f, 3.97367239e-01f, -1.20804287e-01f, -1.49278224e-01f, 2.50715315e-02f, -3.44930924e-02f, 9.31231752e-02f, 1.46765290e-02f, 2.05547169e-01f, 4.80828248e-02f,
  8.18316489e-02f, -4.60860804e-02f, -2.51823608e-02f, 2.60778535e-02f, -2.85039041e-02f, -3.88999470e-02f, 3.53201814e-02f, 9.82484743e-02f, 1.18803717e-01f, -1.86345670e-02f,
  -1.64260238e-01f, 2.37913616e-02f, -7.09937280e-03f, -1.98756568e-02f, -3.81234381e-03f, -7.42377937e-02f, -1.70562603e-02f, 1.13516552e-02f, -4.15689647e-02f, 1.79787558e-02f,
  -1.03017595e-02f, -5.01298904e-02f, -6.67697191e-02f, -3.94968614e-02f, -2.14730009e-01f, 8.76064505e-03f, 7.47817976e-04f, -1.65395185e-01f, 1.26968706e-02f, 3.18512805e-02f,
  -4.44895066e-02f, 4.47493047e-03f, 3.35697055e-01f, -1.84943765e-01f, 2.62383640e-01f, 3.63240451e-01f, 2.86241081e-02f, 3.71403396e-02f, 1.06498227e-01f, -1.89275682e-01f,
  -1.44809544e-01f, -2.21050784e-01f, 7.53361508e-02f, -1.41232446e-01f, -2.16985047e-01f, -8.88924077e-02f, -4.18946110e-02f, -6.16334453e-02f, -2.54391998e-01f, -1.01274140e-01f,
  1.15215302e-01f, -4.68939506e-02f, 4.83029000e-02f, 8.86216089e-02f, 5.45538478e-02f, 3.56379412e-02f, -3.25605832e-02f, 5.42106330e-02f, 5.91326542e-02f, 1.11298285e-01f,
  -2.31627207e-02f, 8.37049559e-02f, -2.48139128e-02f, -4.33043949e-02f, -2.74642229e-01f, -6.45786449e-02f, 1.25963479e-01f, 3.25723030e-02f, 6.74715191e-02f, -6.05350249e-02f,
  3.10532823e-02f, 4.59179953e-02f, -4.88508530e-02f, 5.82891256e-02f, -8.21295287e-03f, 3.64267752e-02f, 5.88576347e-02f, 6.81747347e-02f, 6.49405420e-02f, 8.02853107e-02f,
  -5.82042783e-02f, 1.12743482e-01f, 1.35497242e-01f, -6.95045339e-03f, -1.69179719e-02f, 5.71685396e-02f, -2.76354179e-02f, 6.11706674e-02f, -6.95649907e-03f, -3.96440327e-02f,
  3.61422077e-02f, -2.54918449e-02f, 2.43431255e-02f, 2.87394319e-02f, -7.07189515e-02f, -3.48529555e-02f, 2.27536429e-02f, -4.81827967e-02f, -4.29388694e-02f, 6.82078749e-02f,
  8.28211680e-02f, 5.20323217e-02f, 3.99367884e-02f, -2.34609973e-02f, 7.28342906e-02f, 8.87914747e-02f, -5.85695282e-02f, -6.15895502e-02f, 1.02837600e-01f, -4.57028300e-02f,
  4.00262624e-02f, -4.30885796e-03f, 8.36989358e-02f, 1.28243268e-01f, 7.43256733e-02f, 1.59873569e-03f, -3.66940275e-02f, -1.59737080e-01f, -2.13610064e-02f, -4.48302962e-02f,
  -8.11945945e-02f, 2.93870792e-02f, -1.18475799e-02f, -6.72873259e-02f, -1.20245531e-01f, -2.93224789e-02f, 6.48083836e-02f, 3.67642753e-02f, 3.00175902e-02f, -5.35018742e-02f,
  8.18272084e-02f, 1.48796782e-01f, 9.03323144e-02f, 5.27654290e-02f, -1.67415347e-02f, 1.00329369e-02f, 3.98253910e-02f, -1.29007048e-03f, -1.18904561e-02f, 1.42623242e-02f,
  1.95473060e-01f, -2.52860814e-01f, -3.85304600e-01f, -8.76076519e-02f, 4.86770794e-02f, 2.61913061e-01f, 1.36428550e-01f, -1.49298292e-02f, -1.15151852e-01f, 3.04709345e-01f,
  3.05465192e-01f, 5.74392602e-02f, -1.51814684e-01f, 3.88670206e-01f, 2.28468940e-01f, 6.71368539e-02f, 1.38378441e-01f, 1.99561834e-01f, -1.35693669e-01f, 3.84850688e-02f,
  1.75198521e-02f, 3.27950895e-01f, 2.18404103e-02f, 1.85304835e-01f, 2.59372264e-01f, -2.60601074e-01f, 1.22459263e-01f, -9.73257571e-02f, 3.23386699e-01f, 2.09481820e-01f,
  2.96196900e-02f, -1.03956029e-01f, 4.88831922e-02f, -5.14463782e-02f, -7.45520070e-02f, -8.46511200e-02f, -7.57190660e-02f, 7.31895864e-03f, -4.73729484e-02f, -6.16674237e-02f,
  -1.04518905e-02f, 4.49231379e-02f, 4.81856652e-02f, -9.23757330e-02f, -7.57519305e-02f, -1.33879453e-01f, -8.33596885e-02f, -2.08857320e-02f, -1.21414185e-01f, -3.88909206e-02f,
  -1.85157835e-01f, -8.17473307e-02f, 7.68254884e-03f, -1.88557338e-02f, 3.75526659e-02f, -2.40125414e-02f, -3.23281139e-02f, -4.15243953e-02f, -9.68366116e-03f, 4.84298766e-02f,
  -2.87074503e-02f, 9.76212323e-02f, 1.51993427e-02f, 2.72838417e-02f, -2.21485104e-02f, 1.03550985e-01f, 1.02247514e-01f, 4.72835673e-04f, -1.81377791e-02f, -2.43282542e-02f,
  3.42346575e-05f, -1.75675731e-02f, 5.22315912e-02f, 2.58416943e-02f, 1.42910972e-01f, 4.24406417e-02f, -2.71999110e-02f, 3.48920263e-02f, 2.82932147e-02f, -5.78969382e-02f,
  2.21428956e-04f, 4.53155078e-02f, 6.22456633e-02f, -2.78606229e-02f, -5.74012920e-02f, -4.59902436e-02f, 1.27089977e-01f, 5.18240929e-02f, -1.62727162e-02f, -8.32531154e-02f,
  2.34503411e-02f, -8.85529220e-02f, -3.70173156e-02f, -5.55398837e-02f, -1.21866316e-01f, 8.98487307e-03f, -1.67189185e-02f, -5.78374900e-02f, -5.39852269e-02f, -1.20913628e-02f,
  5.08826897e-02f, -1.15187861e-01f, 1.32053634e-02f, -3.61248627e-02f, -6.67698011e-02f, 1.27501696e-01f, -2.60931179e-02f, -2.54527889e-02f, -1.41327195e-02f, 5.15710413e-02f,
  2.42892746e-02f, -1.68554336e-02f, -5.20251989e-02f, 1.32798590e-02f, -3.67285497e-02f, -5.34591787e-02f, 3.72638293e-02f, -1.99854579e-02f, 1.09812617e-02f, -1.67388842e-03f,
  1.75933018e-01f, 1.74957544e-01f, -1.44675523e-01f, -2.91889068e-02f, -9.25866589e-02f, -5.40246479e-02f, -4.05413024e-02f, 3.74710117e-03f, -3.74867618e-01f, 1.31769285e-01f,
  1.38848156e-01f, -1.77896380e-01f, 1.64003000e-01f, 2.54522383e-01f, -3.14712115e-02f, 2.69036889e-01f, 7.55465180e-02f, 2.16216315e-02f, 6.05436862e-02f, 2.85174489e-01f,
  9.82501954e-02f, 2.41643533e-01f, 2.54689157e-01f, 2.97690392e-01f, 2.18968928e-01f, -6.23864261e-03f, 1.24311700e-01f, 7.97125250e-02f, 7.10842460e-02f, -1.09207788e-02f,
  5.30037954e-02f, 6.18321225e-02f, 4.36666831e-02f, -1.18452102e-01f, 1.03474237e-01f, 1.17511384e-01f, -2.00811252e-02f, -1.17402725e-01f, -1.45363599e-01f, -3.89865786e-02f,
  -5.22905029e-02f, 2.26776917e-02f, -1.13685266e-03f, -5.53229265e-02f, -3.63487415e-02f, -1.75847813e-01f, -1.40194519e-04f, -2.05066219e-01f, -1.06455408e-01f, 1.11788198e-01f,
  4.67798160e-03f, -8.19045231e-02f, -7.87556097e-02f, -3.34489085e-02f, -6.03866130e-02f, -3.30927484e-02f, 2.73011681e-02f, 8.70273914e-03f, -5.63606136e-02f, -3.15856151e-02f,
  8.06940943e-02f, -2.48185359e-02f, 1.54401630e-01f, 1.58019550e-02f, 2.64600441e-02f, -5.42894416e-02f, 4.62850928e-03f, -3.09091024e-02f, -5.95558584e-02f, 1.77131325e-01f,
  -6.77604601e-02f, -2.97562163e-02f, -2.94030197e-02f, -2.22795010e-02f, 6.08127713e-02f, 3.17061134e-02f, -2.40417384e-02f, 5.51572628e-02f, -9.92439967e-03f, -3.87745313e-02f,
  -1.46785021e-01f, 5.52035011e-02f, 1.91072989e-02f, 5.64239454e-03f, -3.53134498e-02f, -6.65928721e-02f, 6.45841286e-02f, 5.77345565e-02f, 3.08898259e-02f, -8.48638192e-02f,
  4.82241847e-02f, 1.81305155e-01f, -2.64130700e-02f, -9.19893757e-02f, -4.18716390e-03f, 8.96546692e-02f, 1.63518831e-01f, -9.21727940e-02f, -1.05857320e-01f, 6.40691444e-02f,
  3.78325693e-02f, -9.10458639e-02f, -6.79253116e-02f, -9.42493603e-02f, -1.63123176e-01f, 1.11306636e-02f, 6.73628598e-02f, -2.01165617e-01f, -1.59721449e-01f, 4.58212495e-02f,
  -5.13372533e-02f, -7.03836009e-02f, -9.78223607e-02f, 3.16668972e-02f, -4.50101085e-02f, 1.27231264e-02f, 2.36589815e-02f, 1.85061041e-02f, 6.58464432e-02f, -3.16729434e-02f,
  -2.82539755e-01f, -1.74626820e-02f, -1.27387002e-01f, -2.12837234e-01f, -2.26315275e-01f, -8.79192725e-02f, -2.14050919e-01f, -1.06268585e-01f, -3.92757580e-02f, 1.24771059e-01f,
  -2.05426469e-01f, -2.16123546e-04f, 2.03262761e-01f, -1.47322550e-01f, -2.34176815e-02f, 3.10015798e-01f, -1.38665056e-02f, -4.27111201e-02f, 4.58860584e-02f, -5.22659980e-02f,
  -3.65552641e-02f, -7.66007006e-02f, -7.43547454e-02f, 8.34255591e-02f, -3.62868160e-01f, -2.21280679e-01f, 4.82731173e-03f, -1.15930110e-01f, -2.21222922e-01f, -1.90532893e-01f,
  -9.53399390e-02f, -1.13518611e-01f, -1.08091094e-01f, -9.04521346e-02f, -9.72024426e-02f, -6.02117553e-02f, -3.96450162e-02f, -1.70052186e-01f, -2.10654229e-01f, 2.12862343e-02f,
  -2.65976191e-02f, -4.66008065e-03f, 1.27094546e-02f, 6.45085704e-03f, -1.03977412e-01f, -1.61268309e-01f, 1.05971750e-03f, -1.67938531e-03f, -1.16792604e-01f, 7.64570432e-03f,
  -2.42975187e-02f, -7.62423081e-03f, -1.15236685e-01f, 9.09251743e-04f, -7.61000291e-02f, -6.36966527e-02f, 9.59067717e-02f, 3.64285372e-02f, -9.10535976e-02f, -7.44776726e-02f,
  -2.09089313e-02f, -4.32427227e-03f, -2.49519642e-03f, -8.57138447e-03f, 2.99630724e-02f, 3.91664244e-02f, -5.98338153e-03f, 3.60213406e-02f, 1.81456171e-02f, 8.23394116e-03f,
  -9.13423598e-02f, -8.08369443e-02f, -5.76590048e-03f, 2.34066099e-02f, 2.92807780e-02f, 6.93561509e-02f, 1.91448033e-02f, -6.86097220e-02f, 5.81656136e-02f, -1.14123709e-01f,
  -7.96574876e-02f, -2.55784974e-03f, 3.13864276e-02f, 4.53764088e-02f, -2.62551121e-02f, 4.84315008e-02f, 6.95200339e-02f, 3.67835127e-02f, -1.15412630e-01f, -6.96521103e-02f,
  -1.11191258e-01f, -1.31020606e-01f, -1.05312429e-01f, -1.46361977e-01f, 3.95821147e-02f, -3.55335698e-02f, -2.64553744e-02f, -4.01160382e-02f, -1.87821239e-01f, -5.16756661e-02f,
  -4.94649187e-02f, -2.16318835e-02f, 1.52397957e-02f, -3.89807150e-02f, 9.18940678e-02f, -7.52119347e-02f, -1.37318477e-01f, 1.32178972e-02f, -1.47441342e-01f, -3.74306627e-02f,
  4.57706454e-04f, 1.77977756e-02f, -6.31170766e-03f, -1.27789944e-01f, -6.47376478e-02f, -6.74748346e-02f, 5.34251239e-03f, -2.11052038e-02f, -1.90508179e-02f, -1.72569398e-02f,
  -3.42151642e-01f, 1.37137115e-01f, -4.15566787e-02f, 3.89250629e-02f, -3.39310080e-01f, 2.65872836e-01f, 2.16514453e-01f, 3.21911611e-02f, 2.35026985e-01f, 2.62211680e-01f,
  -8.68201405e-02f, 7.80479470e-03f, 1.54033691e-01f, 9.62781087e-02f, 1.55661017e-01f, 3.38272393e-01f, 1.46521419e-01f, 7.92338699e-02f, -7.29019716e-02f, -4.64285165e-03f,
  -7.43857697e-02f, -4.35943231e-02f, -1.04012094e-01f, -2.07730964e-01f, -3.43778968e-01f, -1.49333507e-01f, -1.62974700e-01f, -1.15072265e-01f, -1.25921696e-01f, 1.11064687e-03f,
  -1.09812744e-01f, -6.93515921e-03f, -9.65589434e-02f, 1.30745292e-01f, -7.82001112e-03f, 1.13132067e-01f, -4.16323589e-03f, -8.29973519e-02f, -4.93506901e-02f, 1.17809949e-02f,
  1.23466775e-01f, -5.59793115e-02f, 8.53865594e-02f, -4.02265452e-02f, 4.34997492e-02f, 5.55922724e-02f, -4.17832918e-02f, -1.41252354e-01f, -5.30662872e-02f, -3.41004580e-02f,
  -5.31565137e-02f, -9.03787687e-02f, -1.03132389e-01f, 4.33542132e-02f, -1.79551005e-01f, -1.74400900e-02f, 1.00412704e-01f, -8.65502506e-02f, -7.26220161e-02f, 5.48952669e-02f,
  -3.03715821e-02f, 5.99439703e-02f, 7.31860399e-02f, -3.58170867e-02f, 9.00166556e-02f, -5.90322316e-02f, 5.36026545e-02f, 7.17688128e-02f, 5.64739071e-02f, -8.31135374e-04f,
  -2.11915616e-02f, 1.33292526e-02f, -7.92182051e-04f, -4.63547076e-05f, 4.17032950e-02f, 1.04000442e-01f, -3.50997448e-02f, -5.90068027e-02f, -1.74753722e-02f, 3.31118493e-03f,
  7.33780563e-02f, 1.41457766e-01f, -3.85289430e-03f, 3.79912113e-03f, 4.25659306e-02f, 5.30285463e-02f, 7.77067291e-03f, -5.97895645e-02f, 7.66549679e-03f, -4.24373746e-02f,
  1.10861808e-01f, 1.81965679e-01f, -2.23184749e-02f, 6.56795278e-02f, 4.86035496e-02f, 3.38749634e-03f, 6.04242571e-02f, -1.05427377e-01f, 1.77483752e-01f, 8.04859474e-02f,
  4.10109460e-02f, -2.14124303e-02f, 1.87032856e-02f, -3.77317481e-02f, -2.16923039e-02f, 1.13341719e-01f, 2.05368072e-01f, 1.11341747e-02f, 1.89277679e-02f, -3.12769450e-02f,
  -9.66884289e-03f, -1.09398551e-01f, 2.10062042e-02f, -5.62048964e-02f, -3.25666443e-02f, -3.29219811e-02f, -6.99008778e-02f, -9.82117280e-02f, -6.39923513e-02f, 3.45196761e-02f,
  -6.27310202e-02f, -1.76747128e-01f, 2.72308588e-01f, -2.86367595e-01f, 1.91365749e-01f, 2.26344228e-01f, 2.81348258e-01f, -1.61356702e-01f, -2.41388723e-01f, -2.41068989e-01f,
  6.69754818e-02f, 1.41497821e-01f, 3.46368074e-01f, -2.19303951e-01f, 5.02098382e-01f, 1.82751864e-01f, -1.70055851e-01f, -4.76376452e-02f, -9.46053043e-02f, -1.32588282e-01f,
  -1.68532386e-01f, -2.36091554e-01f, 2.34773472e-01f, -2.89216638e-01f, -5.16999513e-02f, -1.62252083e-01f, -2.58423090e-02f, 2.10810915e-01f, -2.62805343e-01f, 1.38547406e-01f,
  -8.93438160e-02f, -1.97065696e-01f, 1.00513533e-01f, 1.64260883e-02f, -1.70725156e-02f, -1.27252741e-02f, -3.52683589e-02f, 2.29529902e-01f, -5.33172078e-02f, 5.19625284e-02f,
  3.66409980e-02f, -5.37155941e-02f, -2.81654447e-01f, 1.50949329e-01f, -1.14118695e-01f, -9.09266770e-02f, -7.43307620e-02f, 2.20369874e-03f, -1.88070368e-02f, 9.02536437e-02f,
  3.38481143e-02f, -3.50182503e-02f, 3.15030292e-02f, -7.88294375e-02f, 2.41510663e-02f, -1.56384837e-02f, -8.98663420e-03f, 1.68867156e-01f, -7.00488314e-02f, -2.19176747e-02f,
  -7.39212856e-02f, 1.11932894e-02f, 8.91914219e-02f, 5.20916432e-02f, 8.40228125e-02f, -7.35151172e-02f, -1.72022711e-02f, 7.26508349e-02f, 4.16278876e-02f, 3.90786082e-02f,
  -1.90024730e-02f, -4.38288460e-03f, -3.67364148e-03f, -9.22813341e-02f, -1.10938944e-01f, -3.87420841e-02f, 1.11435652e-01f, -5.43528683e-02f, -5.04052155e-02f, -4.28616330e-02f,
  9.65053856e-04f, -2.89732143e-02f, -3.03490716e-03f, 6.61613867e-02f, -1.12004858e-02f, 1.54419899e-01f, -1.23077244e-01f, 4.33299541e-02f, -2.05392465e-02f, 1.08103000e-01f,
  -9.07738432e-02f, -2.63598621e-01f, -2.76085343e-02f, -9.39908251e-02f, -1.82573348e-02f, -2.04698853e-02f, -4.15166467e-02f, -1.50565043e-01f, -1.48724303e-01f, 5.13471588e-02f,
  -4.69655804e-02f, 3.56064849e-02f, -3.42176780e-02f, 2.17919424e-02f, -7.58018494e-02f, -1.08652236e-02f, 4.62066643e-02f, -9.87731107e-03f, 1.42116770e-02f, -4.79313284e-02f,
  -9.18615535e-02f, 1.08721331e-02f, 3.28519046e-02f, -9.34778452e-02f, -9.54483673e-02f, 6.27625510e-02f, -4.87031862e-02f, -3.59268188e-02f, 3.15238051e-02f, 3.61294337e-02f,
  2.91969985e-01f, -1.14662521e-01f, -3.85409027e-01f, -4.67124246e-02f, 2.15683818e-01f, 2.13258490e-01f, -6.98179826e-02f, 8.29149634e-02f, -1.41862258e-01f, 6.86278567e-02f,
  1.84810415e-01f, -1.37745142e-01f, -3.09571803e-01f, 2.41450757e-01f, 2.80423760e-01f, -1.79588482e-01f, 1.70045689e-01f, 8.34497362e-02f, -5.65075651e-02f, -6.23007957e-03f,
  5.93285561e-02f, 3.83234620e-01f, -2.55708009e-01f, 1.83115482e-01f, 2.07768381e-01f, -2.28402182e-01f, 9.43419263e-02f, -1.64406493e-01f, 2.20852554e-01f, 7.64424205e-02f,
  9.32981595e-02f, -1.34202093e-02f, -1.70281250e-02f, -2.70395856e-02f, 7.27165416e-02f, 2.89935432e-02f, -2.95262150e-02f, -4.26515825e-02f, -3.55762765e-02f, -7.30224997e-02f,
  -1.10085092e-01f, -5.06869256e-02f, 3.85928303e-02f, 7.42704123e-02f, 9.05810595e-02f, -1.47563014e-02f, -4.92183566e-02f, -2.56392434e-02f, -1.16919577e-01f, 3.81226442e-03f,
  -1.24312341e-01f, -4.23287712e-02f, 3.81844044e-02f, -5.81085011e-02f, 1.19286152e-02f, -4.30086302e-03f, 5.68255130e-03f, -1.22460477e-01f, 2.10873932e-02f, -3.91535601e-03f,
  7.79968500e-02f, 1.59782916e-02f, 2.74848845e-02f, -1.77312270e-03f, 9.29457992e-02f, -2.13233959e-02f, 1.07538819e-01f, -3.26328464e-02f, -6.63699880e-02f, 9.56964865e-03f,
  5.14187897e-03f, -1.39966570e-02f, 6.71739727e-02f, 4.62571718e-02f, 5.38283996e-02f, 1.58757437e-02f, 2.44999994e-02f, -7.46694347e-03f, -5.19145876e-02f, 3.36546898e-02f,
  -3.28895003e-02f, 3.08834314e-02f, 5.87176681e-02f, 3.12318280e-02f, 8.14324711e-03f, -2.96452194e-02f, 1.19851388e-01f, 8.67416561e-02f, -3.93317677e-02f, -4.19010073e-02f,
  -6.46813214e-02f, -5.84582351e-02f, -9.42084789e-02f, -4.12929393e-02f, -5.66504039e-02f, 1.06838100e-01f, 3.28649059e-02f, 3.40282321e-02f, -4.91031930e-02f, 5.61535433e-02f,
  -3.50116985e-03f, -1.01204745e-01f, 4.36809137e-02f, -2.88986322e-02f, -5.49612055e-03f, 2.36869175e-02f, -9.09351781e-02f, -4.04921621e-02f, -4.94884998e-02f, 1.12937860e-01f,
  -1.34789767e-02f, 2.63705291e-03f, -2.55199745e-02f, 7.74873141e-03f, -5.31659164e-02f, -3.83500643e-02f, 6.15272112e-02f, -7.11735934e-02f, 3.93554308e-02f, -4.15754467e-02f,
  1.37793958e-01f, -7.89375529e-02f, 8.58687907e-02f, 8.50625113e-02f, -5.12612909e-02f, -1.04025185e-01f, 5.45470677e-02f, -2.73243189e-01f, 2.20230985e-02f, -2.71671981e-01f,
  -9.32713747e-02f, 1.90201640e-01f, 2.66791791e-01f, -2.55250424e-01f, 3.68637025e-01f, 1.42627090e-01f, -4.94685210e-02f, 7.94537552e-03f, -6.56005591e-02f, -1.70513019e-01f,
  -9.40184072e-02f, -3.35485727e-01f, 6.32121265e-02f, -4.33012366e-01f, -2.49448255e-01f, -1.53475136e-01f, 6.27378598e-02f, 2.27687508e-02f, -2.90763289e-01f, 1.22487202e-01f,
  -1.18462786e-01f, -5.48141189e-02f, -6.51957095e-02f, -9.18337107e-02f, -5.96561022e-02f, -6.96126521e-02f, 3.38628441e-02f, 1.06360801e-01f, -4.20988128e-02f, -7.26121217e-02f,
  7.54929185e-02f, -6.75892606e-02f, -1.35590449e-01f, 8.36171582e-02f, -8.43889937e-02f, -8.17641243e-02f, -6.80722445e-02f, -2.17961352e-02f, -2.55737770e-02f, 1.29123226e-01f,
  -2.20826287e-02f, -4.47515510e-02f, 1.98876373e-02f, 5.22423163e-02f, 9.50665921e-02f, -4.40150797e-02f, 4.47598100e-02f, 2.86593556e-01f, -1.05451280e-02f, 4.35520783e-02f,
  4.80063222e-02f, -1.27978707e-02f, -3.52604091e-02f, -7.12769255e-02f, -1.71344385e-01f, -6.88774372e-03f, -4.42684442e-03f, 4.62600663e-02f, -1.30646983e-02f, -2.03773510e-02f,
  -8.85695145e-02f, 5.20393923e-02f, -1.01517036e-03f, 2.08286894e-03f, -7.11407661e-02f, -4.20309156e-02f, 6.53935522e-02f, -3.11515518e-02f, -1.66750010e-02f, -8.70132446e-02f,
  -3.38731967e-02f, -1.45025272e-02f, 5.99313714e-03f, 1.28302187e-01f, 8.85079522e-03f, 1.54046252e-01f, -7.56889880e-02f, -3.06509826e-02f, 4.07162681e-03f, 8.15198794e-02f,
  5.75817563e-02f, -9.62184966e-02f, -8.74802768e-02f, -7.73861632e-02f, 6.08604727e-03f, -4.87668067e-02f, -9.17304084e-02f, 2.31583547e-02f, -1.13317490e-01f, -1.08202249e-01f,
  -8.31484050e-02f, -4.54770066e-02f, -3.61816064e-02f, 8.58902116e-04f, 1.06917834e-02f, -1.48330972e-01f, 5.08963875e-02f, -1.31275773e-01f, 1.25058740e-01f, -5.99162243e-02f,
  -3.76515724e-02f, 3.28916684e-02f, 1.78332794e-02f, -1.00295125e-02f, 2.54455376e-02f, 2.40022421e-01f, 7.11908285e-03f, 7.76136741e-02f, 3.37144658e-02f, 7.82332048e-02f,
  -6.28858209e-02f, 3.61431956e-01f, 4.43814844e-02f, -1.14443533e-01f, 1.12105168e-01f, -1.29974306e-01f, 6.27122298e-02f, 9.64785665e-02f, 1.75665930e-01f, 2.63488054e-01f,
  -1.22822821e-01f, 1.19414233e-01f, -2.51415931e-02f, -1.75869197e-01f, -4.42127615e-01f, -1.88270643e-01f, -3.41765642e-01f, -1.18858032e-01f, -5.81788197e-02f, -1.13512196e-01f,
  -1.68216899e-01f, -1.60923570e-01f, -3.37913111e-02f, 1.08361714e-01f, 2.33368143e-01f, 1.75443575e-01f, -1.50676444e-01f, 1.66532964e-01f, 6.07487839e-03f, 1.24973962e-02f,
  2.33264156e-02f, 1.38599038e-01f, 1.59938678e-01f, 1.25545040e-01f, -9.73764881e-02f, -3.13626081e-02f, -1.45165592e-01f, 1.06936738e-01f, 8.35786536e-02f, -3.88312079e-02f,
  -7.81977177e-02f, 3.74540919e-03f, -1.49859786e-01f, -1.67333726e-02f, 1.64874718e-01f, 1.70394732e-03f, 7.81790633e-03f, -2.80950889e-02f, 1.28080726e-01f, -1.78416644e-03f,
  2.47981381e-02f, 4.62456457e-02f, 6.73699006e-02f, -2.05164123e-02f, -3.18814665e-02f, 8.97382721e-02f, -6.66981786e-02f, -1.03941001e-03f, 1.46532385e-02f, 4.54708524e-02f,
  -4.47880961e-02f, -1.14751138e-01f, 9.39163268e-02f, 9.77985337e-02f, 4.35630381e-02f, 1.69067547e-01f, 6.66705146e-02f, -3.59273218e-02f, 2.04025544e-02f, 8.10503364e-02f,
  4.49381247e-02f, 7.37554505e-02f, -3.31205432e-03f, 2.24555582e-02f, 2.89477524e-03f, -2.45687552e-02f, -1.87125653e-02f, 5.34435734e-02f, -8.81235823e-02f, -5.72606102e-02f,
  5.34745976e-02f, -1.34340733e-01f, 5.51468842e-02f, 3.88294198e-02f, -4.84334491e-02f, 8.32221657e-02f, -4.10471223e-02f, 1.60089776e-01f, -3.91737297e-02f, 5.05004190e-02f,
  -1.55378506e-01f, -1.15042374e-01f, -2.96772905e-02f, 5.71594387e-02f, -3.43327112e-02f, -3.02354079e-02f, -7.47522563e-02f, 1.05274580e-01f, -3.75181921e-02f, -1.67703703e-02f,
  -3.36901583e-02f, 1.96633004e-02f, -2.03297198e-01f, -6.60765022e-02f, -1.08832475e-02f, -8.82277042e-02f, -1.14021907e-02f, -4.00105268e-02f, -7.49165639e-02f, -8.89488310e-02f,
  5.49253598e-02f, 2.41895914e-02f, -2.20721532e-02f, 6.77806661e-02f, -3.97651792e-02f, -2.26934953e-03f, 8.35156254e-03f, 3.70046906e-02f, -9.63678025e-03f, -1.06911458e-01f,
  6.88085109e-02f, -2.53638715e-01f, -6.97554126e-02f, 2.92777549e-02f, 4.04522903e-02f, -4.96092252e-02f, -2.06678778e-01f, -3.74647826e-02f, -1.92978814e-01f, -2.54664540e-01f,
  -9.24350619e-02f, -1.03888504e-01f, -2.41485164e-01f, 3.29165384e-02f, 2.36921728e-01f, -2.49390021e-01f, 1.66766554e-01f, -7.89101887e-03f, -1.28160864e-02f, 1.12091474e-01f,
  1.70034915e-01f, 1.55630514e-01f, 2.01464653e-01f, 3.38984311e-01f, 6.52249008e-02f, 1.10606998e-01f, 1.91545218e-01f, 1.40705496e-01f, 1.87298223e-01f, 1.10245809e-01f,
  2.17075627e-02f, -1.15628861e-01f, 2.96123466e-03f, -2.41916794e-02f, -7.22931791e-03f, 6.00882061e-02f, 1.26983240e-01f, 6.76158397e-03f, 6.04570359e-02f, -9.37087908e-02f,
  -6.96501806e-02f, 4.74693216e-02f, -8.12608451e-02f, 1.72989756e-01f, 1.72988534e-01f, 8.03293008e-03f, -1.45286128e-01f, 8.79278630e-02f, -1.05442926e-01f, -9.70319957e-02f,
  -9.19467658e-02f, -7.83240199e-02f, 3.03902682e-02f, -7.09665492e-02f, -1.57173812e-01f, -9.79560614e-02f, -1.17077567e-02f, -7.98908770e-02f, -9.89240259e-02f, -1.71991773e-02f,
  -7.54883885e-03f, -1.22757740e-02f, -1.15703799e-01f, -1.22890763e-01f, -3.83053124e-02f, 1.84105486e-02f, 1.66179594e-02f, -1.20231047e-01f, 5.26199304e-02f, 3.11632291e-03f,
  -1.15228064e-01f, 1.39762079e-02f, 5.52768037e-02f, 6.05248548e-02f, 4.94021922e-02f, 7.15893358e-02f, 1.73958510e-01f, -5.59368031e-03f, -8.66815150e-02f, -1.08505758e-02f,
  -1.51746925e-02f, 1.04155831e-01f, -3.24458033e-02f, -2.63992660e-02f, 3.90935242e-02f, -7.08180061e-03f, 9.85224247e-02f, 2.92568351e-03f, 5.06151617e-02f, 1.26454443e-01f,
  -1.49938846e-02f, -4.46595475e-02f, 1.93602429e-03f, 4.68541384e-02f, 2.00003968e-03f, 5.31396382e-02f, 6.70270324e-02f, -5.83918691e-02f, -7.82981701e-03f, -1.42401516e-01f,
  6.91904351e-02f, 1.37103006e-01f, 1.08167930e-02f, 5.37133738e-02f, 1.41972154e-01f, -4.99333479e-02f, -1.41802296e-01f, 1.85442790e-02f, -1.86216533e-02f, 1.72870513e-02f,
  -7.38602951e-02f, -4.77861576e-02f, -1.87999196e-02f, -8.64507332e-02f, -1.18759826e-01f, -7.38261119e-02f, 3.29794586e-02f, 7.40912557e-02f, -1.18669756e-01f, -5.67183681e-02f,
  -2.10747957e-01f, 8.78685191e-02f, -2.45906636e-01f, 2.75913388e-01f, -2.08026469e-02f, -1.10826775e-01f, -6.42455742e-02f, 6.78327978e-02f, -1.06109753e-01f, 1.73455819e-01f,
  2.45890647e-01f, -8.90445188e-02f, -3.30617838e-02f, 4.25880045e-01f, 1.95696235e-01f, -2.75715366e-02f, 3.83631378e-01f, 1.83907658e-01f, -5.45685105e-02f, 1.10846333e-01f,
  2.09030360e-02f, 4.12318349e-01f, 1.78752288e-01f, 1.06441341e-01f, 9.22994390e-02f, -9.56799090e-02f, 2.00351357e-01f, -1.42277613e-01f, 3.83324564e-01f, 6.95190653e-02f,
  1.43018186e-01f, 3.89768705e-02f, -3.91787849e-02f, -1.41779065e-01f, -3.94460186e-02f, -4.51032482e-02f, -6.16866499e-02f, -3.90820168e-02f, -2.88038608e-02f, 1.02162231e-02f,
  -1.30938843e-01f, 3.51171419e-02f, 1.28953785e-01f, -1.16374139e-02f, -4.23042513e-02f, -7.43490607e-02f, -2.57775839e-02f, 1.83371920e-02f, 8.29506386e-03f, 5.75598143e-02f,
  -4.36475575e-02f, 1.04741186e-01f, 2.91090123e-02f, 9.07652155e-02f, 7.03561604e-02f, -1.13796303e-02f, -2.74717677e-02f, 2.21771443e-05f, 2.77515426e-02f, -4.52239588e-02f,
  3.18336524e-02f, -1.00962654e-01f, -1.15246080e-01f, 2.28198934e-02f, -3.19264061e-03f, 7.38950670e-02f, -5.38500724e-03f, 7.09830038e-03f, -1.08054362e-01f, 1.69947185e-02f,
  1.71028655e-02f, -7.77918845e-02f, 3.42698880e-02f, -5.21624461e-02f, 2.99165957e-03f, -1.05269887e-02f, -5.64461201e-02f, 5.11258096e-02f, 7.53926039e-02f, 6.84185550e-02f,
  1.06328567e-02f, -5.25340065e-02f, -6.25270233e-02f, 3.11189555e-02f, 2.47667134e-02f, -8.61961469e-02f, 1.65108405e-02f, -2.30931565e-02f, 4.01152410e-02f, -8.87654796e-02f,
  1.15355313e-01f, 4.24763896e-02f, -8.76293927e-02f, 3.91588472e-02f, 1.58490743e-02f, -2.05350332e-02f, -3.51208113e-02f, -1.54936370e-02f, -3.30010569e-03f, -6.55371994e-02f,
  -3.47954296e-02f, -7.94964656e-02f, -6.99643278e-03f, -1.39966924e-02f, 2.58187186e-02f, -4.48728725e-02f, 1.08886827e-02f, -1.01238616e-01f, 4.58403444e-03f, 1.54810920e-01f,
  -1.11302326e-03f, 3.43402987e-03f, -1.01675883e-01f, 3.41767743e-02f, 8.57248232e-02f, 3.54683809e-02f, -2.67292280e-02f, -6.17261278e-03f, 9.42153335e-02f, 2.28628796e-02f,
  -5.36677241e-01f, -1.13193337e-02f, -1.01200446e-01f, -4.18868005e-01f, 1.57454640e-01f, 5.69338314e-02f, -1.08806215e-01f, 1.84255391e-01f, -1.29075214e-01f, 2.42351934e-01f,
  -8.92409123e-04f, -2.38782659e-01f, 2.92806476e-01f, -4.19703364e-01f, -3.98409545e-01f, -1.31929398e-01f, -3.89320284e-01f, -2.47950986e-01f, -1.37147814e-01f, -1.46770939e-01f,
  -2.62479424e-01f, -2.06076548e-01f, -1.52869314e-01f, 2.81673104e-01f, -6.99225217e-02f, 4.19368632e-02f, 6.10116646e-02f, 1.41597688e-01f, -1.25039980e-01f, -5.16338833e-02f,
  -8.07789192e-02f, 8.84722322e-02f, 5.85099906e-02f, -6.15376933e-03f, 2.49286015e-02f, 4.20980565e-02f, -3.92491408e-02f, -3.56992185e-02f, 2.23947950e-02f, 1.22792926e-02f,
  -9.98844355e-02f, -3.73375602e-02f, -1.82046905e-01f, -7.93504994e-03f, -2.01653503e-02f, -2.24940777e-02f, -6.25595218e-03f, 4.05598357e-02f, 3.00077768e-03f, -3.62892039e-02f,
  -1.21886976e-01f, -1.08656123e-01f, 7.74462149e-02f, -3.15891057e-02f, -5.52244410e-02f, 4.73224334e-02f, 5.28854318e-03f, -6.42822497e-03f, -6.43286705e-02f, -7.59186894e-02f,
  -1.20871909e-01f, 6.35333061e-02f, 9.43077579e-02f, -3.71812582e-02f, 5.58945164e-02f, 6.20463043e-02f, -9.37745720e-03f, 6.88741952e-02f, 5.93252406e-02f, -5.56780584e-02f,
  -7.89119974e-02f, -2.86564510e-02f, -8.17544162e-02f, 1.37604633e-02f, 1.68525130e-02f, -3.46756056e-02f, -6.17336258e-02f, 1.48620608e-03f, -1.00393660e-01f, 1.17084384e-02f,
  -9.10346489e-03f, -1.69583037e-02f, 6.87184408e-02f, -3.30669582e-02f, 6.62122592e-02f, -2.17972305e-02f, 1.13056600e-01f, -2.91782543e-02f, -8.78342520e-03f, 2.77277399e-02f,
  -2.43237428e-02f, 1.12173446e-01f, 3.47074829e-02f, -2.07112189e-02f, 3.03544546e-03f, 3.27934138e-02f, -1.08482055e-01f, -8.01258460e-02f, 1.00701287e-01f, 9.73900128e-03f,
  -4.60678898e-02f, -2.45505925e-02f, -8.02207962e-02f, -3.52568589e-02f, -5.24994405e-03f, 4.42137234e-02f, -1.01211242e-01f, -4.15056162e-02f, -4.45773080e-02f, 7.19012246e-02f,
  2.02537999e-02f, -1.91624742e-02f, -2.47148448e-03f, -7.69275278e-02f, -1.63848735e-02f, 3.15516554e-02f, 2.19265297e-02f, 1.11426093e-01f, 5.58517985e-02f, -4.22516242e-02f,
  -1.26520053e-01f, 2.67866254e-01f, 2.96117246e-01f, -3.31719279e-01f, 2.62254387e-01f, 3.90833855e-01f, 6.17021918e-02f, 3.17050338e-01f, 2.21554115e-01f, -2.23048806e-01f,
  -1.72624886e-01f, -2.19180807e-01f, -1.73203219e-02f, -1.54656604e-01f, 2.17296612e-02f, 2.13952363e-01f, 1.28025547e-01f, -2.13401675e-01f, 2.87356675e-01f, -7.81559572e-02f,
  8.37389193e-03f, -2.18346655e-01f, 6.95910454e-02f, 1.22031152e-01f, 3.56669985e-02f, -3.50213200e-02f, -3.02420139e-01f, -3.73301730e-02f, -3.32004517e-01f, 1.11620247e-01f,
  4.93167229e-02f, 5.33033069e-03f, 1.28303275e-01f, -7.78887933e-03f, 6.01358674e-02f, -8.83130506e-02f, -9.41050425e-02f, 3.09797805e-02f, -4.08004075e-02f, 5.20646106e-03f,
  -6.19835481e-02f, -1.40685976e-01f, -1.29895248e-02f, -2.46675778e-02f, -6.46404084e-03f, 5.13155684e-02f, 4.88118045e-02f, 7.40975514e-02f, 1.27075523e-01f, 5.63886166e-02f,
  9.70697701e-02f, -2.95600556e-02f, -1.11933490e-02f, -7.17208907e-02f, -1.06433425e-02f, -1.06863389e-02f, 8.45293552e-02f, -7.31010363e-02f, 3.31056044e-02f, -3.98367457e-02f,
  -3.54910940e-02f, 6.78653568e-02f, -5.31083234e-02f, -1.19989194e-01f, -1.55369360e-02f, 1.32015213e-01f, -9.46839005e-02f, 4.50748354e-02f, 1.52609706e-01f, 1.51838101e-02f,
  -6.77951202e-02f, -6.86984602e-03f, 8.43197033e-02f, -1.56578831e-02f, -2.96224356e-02f, -2.48477682e-02f, -7.76618868e-02f, -4.40108916e-03f, -3.32382955e-02f, 3.75106633e-02f,
  -1.39019623e-01f, -6.22040182e-02f, -7.79837966e-02f, -4.52551693e-02f, 6.47555590e-02f, 4.18373384e-02f, -1.09824963e-01f, -6.49929494e-02f, -1.53445648e-02f, 5.43048866e-02f,
  -4.88982676e-03f, 3.60410437e-02f, 1.55607849e-01f, -4.53102253e-02f, 4.45412006e-03f, 7.74218049e-03f, -4.83617745e-02f, 3.63923237e-02f, 4.95453365e-02f, 5.24760270e-03f,
  2.68942434e-02f, -7.54728243e-02f, -3.83284315e-02f, -8.51895586e-02f, 1.98516017e-03f, 1.26484632e-01f, -1.58387557e-01f, 1.84355155e-02f, -4.61062454e-02f, -3.42052393e-02f,
  1.05297088e-03f, -4.14657108e-02f, -2.26207525e-02f, 2.45028436e-02f, 4.05836627e-02f, -9.44500044e-02f, -1.72677021e-02f, 4.78908494e-02f, -1.65322796e-02f, -2.34773010e-03f,
  -2.90484011e-01f, -3.57521147e-01f, 1.17128789e-01f, -1.30326748e-01f, -1.69889946e-02f, 5.92710935e-02f, -1.07384406e-01f, -2.77035445e-01f, -3.75949800e-01f, -3.20481837e-01f,
  -1.38151675e-01f, 2.06520855e-01f, -1.98879972e-01f, 4.70283628e-02f, 3.35412025e-01f, -5.06463610e-02f, -5.93592040e-03f, 7.51689970e-02f, 2.09444582e-01f, -7.00323563e-03f,
  1.09878615e-01f, 8.44684988e-02f, 1.26158953e-01f, 2.00934157e-01f, 2.54659634e-02f, 2.54276413e-02f, 1.57942120e-02f, 6.04188554e-02f, 1.48152635e-01f, 2.11668462e-01f,
  -1.04124166e-01f, -2.26178065e-01f, -1.15261823e-02f, -1.07818849e-01f, -4.45706174e-02f, -6.92991465e-02f, 6.45707622e-02f, 1.21417522e-01f, 5.09401038e-02f, 1.37720117e-02f,
  -1.50840161e-02f, -6.94665685e-02f, 3.48878652e-02f, 1.55191179e-02f, -7.48659000e-02f, -1.45939544e-01f, -4.95996363e-02f, 3.44021432e-02f, -6.29701391e-02f, -7.42327347e-02f,
  -7.65062794e-02f, 2.87261251e-02f, -1.04937002e-01f, 3.04715484e-02f, 2.76789237e-02f, -7.95822963e-02f, -4.75666206e-03f, 7.05429465e-02f, 8.77572298e-02f, -5.59383743e-02f,
  1.10325158e-01f, 1.10606469e-01f, -3.14122029e-02f, 4.78952266e-02f, -1.64960027e-02f, -6.58722362e-03f, 1.30084977e-01f, 9.87840816e-02f, 1.38032749e-01f, -1.35828957e-01f,
  -2.54435204e-02f, 5.08892685e-02f, -2.86945961e-02f, -1.12828933e-01f, 2.88729183e-02f, -7.54854083e-02f, 1.25651166e-01f, -3.43605988e-02f, -4.52971533e-02f, 6.63585290e-02f,
  2.97429767e-02f, -4.15651426e-02f, -4.97642905e-02f, -2.17381748e-03f, -9.98015702e-02f, -2.11728103e-02f, 9.47875087e-04f, -1.35308221e-01f, -1.80230178e-02f, 9.55857337e-02f,
  -3.52260351e-01f, -2.79225796e-01f, 9.86260176e-03f, -1.05585732e-01f, 1.54998421e-03f, -6.99542183e-03f, 6.84825480e-02f, -1.21059287e-02f, -8.85282159e-02f, -2.30974145e-02f,
  -7.55284652e-02f, -4.63841967e-02f, -1.30109838e-03f, 1.33896153e-02f, 8.94488320e-02f, -1.28617600e-01f, -5.09202667e-02f, -1.15860507e-01f, -1.19962908e-01f, 3.42252925e-02f,
  -3.95328961e-02f, 5.50787896e-02f, 5.50179929e-02f, 8.88361782e-02f, 4.48019244e-02f, -7.00786039e-02f, 1.54125141e-02f, -4.36551757e-02f, 1.63797230e-01f, 9.33718458e-02f,
  2.13142717e-03f, -2.98250169e-01f, -7.86741376e-02f, -1.85223043e-01f, 1.61255091e-01f, 1.49435312e-01f, -4.42483313e-02f, -3.78735922e-02f, -2.87304133e-01f, 4.86298539e-02f,
  -7.41858333e-02f, -2.10707620e-01f, -2.33877435e-01f, -2.77854949e-01f, -1.65280730e-01f, -2.21839041e-01f, -5.12092374e-02f, -4.46585789e-02f, -2.30901197e-01f, 1.64866224e-01f,
  1.10997990e-01f, -1.00931510e-01f, -2.70424895e-02f, 9.00295600e-02f, -2.99881934e-03f, 2.36952856e-01f, 2.55654603e-01f, 7.08044618e-02f, 2.22573951e-01f, -3.94599549e-02f,
  -6.45788312e-02f, -2.01387361e-01f, -5.07784747e-02f, -7.92988986e-02f, 1.37863770e-01f, 8.62388611e-02f, 1.03025772e-01f, -1.64882094e-01f, -4.96662483e-02f, 4.65688929e-02f,
  -9.55505073e-02f, -3.54364403e-02f, 3.01200133e-02f, -3.82644944e-02f, 9.19189379e-02f, 6.82015531e-03f, -9.65325087e-02f, -6.56994805e-02f, -7.08738863e-02f, -2.20707618e-02f,
  -4.08960739e-03f, -2.70408727e-02f, 1.08380355e-01f, 1.85753703e-02f, -4.96183485e-02f, 3.12325340e-02f, 1.39937088e-01f, 1.70309946e-01f, -6.22370392e-02f, 1.97010115e-02f,
  9.22493413e-02f, 2.24019885e-01f, 3.17837149e-02f, -9.82399508e-02f, -4.37729619e-03f, -8.22029561e-02f, -8.54504257e-02f, -8.68786722e-02f, -1.15609497e-01f, -2.93499865e-02f,
  -1.68884285e-02f, -3.10721230e-02f, -1.97100803e-01f, 1.29362509e-01f, 1.74049184e-01f, 1.02657169e-01f, 5.62062114e-02f, 4.78013605e-02f, -9.89812892e-04f, -4.60004807e-03f,
  -1.56149939e-01f, -3.32328901e-02f, 7.48995021e-02f, -7.39883855e-02f, -2.35824916e-03f, 7.32911676e-02f, 1.91488877e-01f, -3.68616980e-04f, 3.54370661e-02f, -1.72372852e-02f,
  4.89795506e-02f, 9.34621468e-02f, -6.68336228e-02f, -5.87634929e-02f, -5.03379703e-02f, 5.45693003e-03f, -1.28208160e-01f, -1.26464322e-01f, -6.87133968e-02f, -3.27805206e-02f,
  7.67196715e-02f, 7.69213513e-02f, 1.76370323e-01f, -5.17198481e-02f, -8.33059028e-02f, 1.07415646e-01f, 8.21325481e-02f, -7.49255791e-02f, -9.72667634e-02f, 9.36786085e-02f,
  1.28327698e-01f, 6.78565353e-02f, -2.22940575e-02f, -3.62967215e-02f, -6.20453991e-03f, 8.02415162e-02f, 9.60364267e-02f, 6.55787736e-02f, -2.11712092e-01f, -1.23111442e-01f,
  2.69813299e-01f, -4.75650787e-01f, -7.00555742e-02f, 3.07680368e-01f, 2.26121411e-01f, -1.32049963e-01f, -2.02440813e-01f, 1.06519669e-01f, 1.63326487e-01f, -2.91341066e-01f,
  2.39987671e-02f, -6.24620430e-02f, -3.60133618e-01f, 1.47572130e-01f, 1.71100408e-01f, -1.01172134e-01f, 8.47044364e-02f, 3.79989184e-02f, 1.08555824e-01f, -4.32118177e-02f,
  2.58376807e-01f, 9.58760902e-02f, -4.43982929e-02f, 7.59734660e-02f, -3.19941752e-02f, 1.21082529e-01f, -4.60783951e-02f, -2.06531897e-01f, 1.51793167e-01f, 3.27215567e-02f,
  -8.65776539e-02f, -4.33230065e-02f, -6.12672716e-02f, -2.04293616e-02f, -6.00767136e-02f, -5.09093702e-02f, -7.91341588e-02f, -3.75270769e-02f, 9.04069766e-02f, -8.33960250e-03f,
  -9.91689414e-02f, 1.07800655e-01f, 4.61633690e-02f, 6.88269828e-03f, -4.11595497e-03f, -5.47215007e-02f, 1.53699413e-01f, 4.94485684e-02f, 1.01168873e-02f, 7.24191442e-02f,
  -1.24324840e-02f, 1.40738294e-01f, -1.62804518e-02f, 2.39841025e-02f, 4.22019213e-02f, 1.17650948e-01f, 7.28085265e-02f, -1.79298893e-02f, 2.01322958e-02f, 9.68361571e-02f,
  7.58591220e-02f, -1.00093642e-02f, -9.32011828e-02f, -4.03341018e-02f, -6.77241012e-02f, -3.73861566e-02f, -1.36804804e-02f, -5.97431660e-02f, -3.23848948e-02f, -1.08103722e-01f,
  6.53485283e-02f, 8.87620170e-03f, 1.25462692e-02f, -3.92339826e-02f, 7.88092241e-03f, 5.29592903e-03f, -1.61346532e-02f, 3.69046703e-02f, -3.06971278e-02f, 8.79770219e-02f,
  6.03393912e-02f, 1.00483187e-02f, -9.43463892e-02f, 5.81259131e-02f, 1.84095372e-02f, -5.73772490e-02f, -7.75355250e-02f, -6.64615780e-02f, -2.69107465e-02f, -8.25038704e-04f,
  -4.87078190e-01f, -3.87170792e-01f, -2.83704679e-02f, -7.08400011e-02f, -7.94771686e-02f, -2.56015211e-02f, -2.26360373e-02f, 5.75043187e-02f, -1.27900243e-01f, -9.01760086e-02f,
  -1.23890013e-01f, 6.92360550e-02f, -3.71619873e-02f, -2.51167361e-02f, -6.10104539e-02f, -7.50165731e-02f, -8.68435577e-03f, -3.96926478e-02f, -8.60737339e-02f, 9.00658593e-02f,
  7.58964121e-02f, -2.26706546e-02f, 5.39576747e-02f, 7.47905076e-02f, 6.37791604e-02f, 9.17576998e-02f, -3.61712789e-03f, 8.34040940e-02f, -5.77680813e-03f, -3.92507166e-02f,
  -2.50560999e-01f, 1.35492787e-01f, -2.41482452e-01f, -1.34686321e-01f, 1.75626963e-01f, -3.78624111e-01f, 4.57500555e-02f, 2.84459051e-02f, -5.32552265e-02f, 3.26513916e-01f,
  4.78598215e-02f, 3.26323360e-02f, 1.65225834e-01f, -1.76371992e-01f, -4.49281842e-01f, -7.44788125e-02f, -3.70473564e-01f, -1.82751775e-01f, -8.50252584e-02f, 6.76167756e-02f,
  -2.08729923e-01f, -3.29030640e-02f, -1.54169783e-01f, 2.32472897e-01f, 9.82632190e-02f, 7.29784518e-02f, 1.88870132e-01f, 2.05416337e-01f, 5.91695085e-02f, 2.12399010e-02f,
  3.27725783e-02f, 1.59949720e-01f, -2.94083804e-02f, -1.22981675e-01f, -5.36700059e-03f, 5.53148873e-02f, -4.99872193e-02f, -4.11505401e-02f, 1.16383852e-02f, -4.86453958e-02f,
  -2.18789629e-03f, 4.07493524e-02f, -2.84747556e-02f, -2.32840572e-02f, 6.72174618e-02f, -3.33713293e-02f, -1.62072293e-02f, -7.97820464e-02f, 5.00261746e-02f, -8.79951343e-02f,
  -3.64058353e-02f, -1.04132267e-02f, 6.47452287e-03f, -5.88474162e-02f, -9.71741378e-02f, 5.63913994e-02f, -6.51330501e-02f, -2.18024999e-02f, 4.56887297e-02f, -1.61381960e-02f,
  4.78926906e-03f, -5.56791089e-02f, -3.67230289e-02f, 6.14071712e-02f, 3.47811505e-02f, 1.46752283e-01f, -9.55067202e-03f, -4.08682004e-02f, -1.81627497e-02f, 5.39248511e-02f,
  4.09340337e-02f, -5.54700233e-02f, 3.95134538e-02f, -6.08187132e-02f, -7.25777894e-02f, 4.06898819e-02f, -6.98922351e-02f, 3.35610770e-02f, -6.94567338e-02f, 9.27749276e-03f,
  1.87623695e-01f, 3.87073494e-02f, 4.29860093e-02f, -1.90818552e-02f, 1.78302377e-02f, -3.98305543e-02f, -1.06419161e-01f, -8.91017988e-02f, 6.96980655e-02f, -6.31191954e-02f,
  -3.70402867e-03f, 7.18648136e-02f, 3.94726060e-02f, 6.27359971e-02f, 6.11775890e-02f, -1.00168511e-01f, -1.01411656e-01f, -1.02344714e-01f, -4.77051083e-03f, 4.31722179e-02f,
  -6.50440380e-02f, -2.30530705e-02f, -5.76965918e-04f, -3.14048231e-02f, -6.68101886e-04f, -4.40050364e-02f, 1.66222349e-01f, 5.14202937e-02f, -2.27221586e-02f, -3.11956573e-02f,
  1.28553819e-03f, 1.57225251e-01f, -8.68707150e-03f, 1.09115429e-02f, -8.41548853e-03f, 9.78142470e-02f, -1.50947534e-02f, 8.45613554e-02f, 2.82024760e-02f, 5.83772957e-02f,
  3.75517190e-01f, 9.82911214e-02f, 6.71036914e-02f, 3.19777101e-01f, 2.53215253e-01f, 1.71228737e-01f, 1.68303266e-01f, 2.30411261e-01f, 5.55149913e-01f, -3.19365799e-01f,
  -8.11894089e-02f, -2.72453427e-01f, -1.96670070e-01f, 1.01830199e-01f, -8.27769414e-02f, 4.15338501e-02f, 2.23260313e-01f, 1.45508405e-02f, 2.92986900e-01f, -4.13055345e-02f,
  2.63953488e-02f, -9.29558128e-02f, -2.58036911e-01f, -8.23200345e-02f, 2.83372006e-03f, -6.24099113e-02f, -3.89743477e-01f, -9.00413468e-02f, -2.71743119e-01f, -3.98821682e-02f,
  -4.40628119e-02f, 4.07591574e-02f, -2.21207663e-02f, -4.56985272e-02f, 4.63214144e-02f, 2.00692993e-02f, -1.50311783e-01f, -1.71782255e-01f, 5.55265918e-02f, -5.72248660e-02f,
  -8.43773037e-02f, -1.65814415e-01f, 2.54233610e-02f, -5.66233918e-02f, 5.40494062e-02f, 1.26928926e-01f, 3.54658626e-02f, 1.36973560e-01f, -3.98617312e-02f, 3.48530598e-02f,
  1.31225279e-02f, 9.35364887e-03f, 1.99116454e-01f, 9.77298841e-02f, 1.19025242e-02f, 4.32940833e-02f, 4.47194725e-02f, -5.71612567e-02f, 1.40754553e-02f, 7.31574744e-02f,
  -8.05523694e-02f, 1.82514533e-01f, 2.14217202e-04f, -6.94622025e-02f, 8.22970793e-02f, -6.26191497e-02f, 2.07126047e-02f, -6.52424665e-03f, 1.44169986e-01f, 3.77339609e-02f,
  3.57653759e-02f, 3.47423330e-02f, 7.75302202e-02f, -9.11774766e-03f, 6.84921369e-02f, 5.04577048e-02f, -1.30585045e-01f, 3.94251570e-02f, 1.14138611e-01f, 7.33226612e-02f,
  -2.71665677e-02f, -2.03628652e-02f, 2.74215126e-03f, -1.05461046e-01f, 3.18407454e-02f, 4.81857033e-03f, 3.36566344e-02f, -4.88935597e-03f, -1.14054773e-02f, -4.02354151e-02f,
  9.78133976e-02f, 6.93121552e-02f, -7.18160719e-02f, -9.04466063e-02f, -1.02644432e-02f, 9.69482120e-03f, 2.86620930e-02f, -1.02281859e-02f, 9.85998660e-02f, 6.50821477e-02f,
  -8.95352215e-02f, -2.77695544e-02f, -4.34265584e-02f, -3.84507664e-02f, 2.14929460e-03f, -2.05242429e-02f, -1.86999515e-01f, 1.16877109e-02f, 1.46943992e-02f, 1.82751864e-02f,
  -6.74858689e-02f, -1.14497999e-02f, 1.24381125e-01f, 1.25101537e-01f, 7.72667080e-02f, -1.18660543e-03f, -1.93239357e-02f, 5.34946322e-02f, -7.05656223e-03f, 6.28056526e-02f,
  4.61669981e-01f, -2.11653516e-01f, 1.55302942e-01f, 4.49464560e-01f, 2.82453418e-01f, 3.97989638e-02f, 3.34712267e-01f, -4.38696295e-02f, 3.74277055e-01f, -3.20696592e-01f,
  -2.85072625e-02f, -9.82755050e-02f, 7.87865222e-02f, -1.74960241e-01f, 1.58476099e-01f, -5.69545627e-02f, -4.42037033e-03f, -5.95636293e-02f, 1.05308197e-01f, 3.04272324e-02f,
  2.15490341e-01f, -1.46769002e-01f, 1.16621934e-01f, -1.89446837e-01f, 1.13984078e-01f, 3.39879990e-02f, -2.09244341e-01f, 4.13633697e-03f, -2.57613868e-01f, -1.20024607e-01f,
  -8.97923931e-02f, 7.55639970e-02f, 5.35567775e-02f, -1.41664043e-01f, -6.36625215e-02f, 4.28490788e-02f, -6.19110353e-02f, -3.46469171e-02f, 3.15083340e-02f, -4.61548045e-02f,
  3.38398144e-02f, -8.76928642e-02f, -7.76915327e-02f, -4.96581756e-02f, 7.18446914e-03f, -1.18483072e-02f, 4.71766777e-02f, 1.76198296e-02f, 2.71730237e-02f, 5.29740155e-02f,
  1.39883727e-01f, 7.73163454e-04f, 3.96111347e-02f, -2.11504281e-01f, -3.90498228e-02f, -2.84472643e-03f, 9.01442990e-02f, 1.38716977e-02f, -8.55479911e-02f, 1.25039257e-02f,
  7.05473451e-03f, 1.19954854e-01f, 1.43515402e-02f, 1.67561956e-02f, 9.23710316e-02f, 2.17758939e-02f, -3.26504745e-02f, 3.92623693e-02f, -3.45082730e-02f, 3.83949615e-02f,
  8.35345313e-02f, -4.79299650e-02f, 4.85434756e-03f, 4.63265413e-03f, -7.49089103e-03f, 1.05203077e-01f, -6.65245205e-02f, 8.51551630e-03f, -2.71170546e-04f, -1.12237215e-01f,
  1.60196214e-03f, -2.86122356e-02f, -3.95268947e-02f, 1.20854862e-01f, -8.43998492e-02f, 4.27209288e-02f, -5.42177334e-02f, -2.11907029e-02f, 9.76746529e-02f, -5.12622669e-02f,
  -2.99630523e-01f, -3.72490615e-01f, -5.29027395e-02f, -3.26807238e-02f, -6.13340661e-02f, -2.13077739e-01f, -3.32726017e-02f, -1.09107919e-01f, -1.71076208e-01f, -1.02250157e-02f,
  -5.46197109e-02f, 3.89183639e-03f, -3.78959216e-02f, 3.76109481e-02f, -9.03108045e-02f, -2.80435812e-02f, -6.20244704e-02f, -4.58962955e-02f, -1.59299280e-02f, -8.31039771e-02f,
  -5.09496517e-02f, -2.32166555e-02f, 2.63686310e-02f, -4.10974436e-02f, -8.90689418e-02f, 1.15852050e-01f, 6.59964010e-02f, -2.31526457e-02f, -6.14358559e-02f, -9.10317078e-02f,
  7.23064244e-02f, 7.71834478e-02f, 2.68571258e-01f, 3.19631010e-01f, -5.54030202e-03f, -3.23268503e-01f, -1.21915929e-01f, 1.54821724e-01f, 6.29683509e-02f, -2.97682732e-01f,
  -8.12880620e-02f, -5.97577393e-02f, 4.66639511e-02f, 4.43257280e-02f, 1.14928268e-01f, -1.63138900e-02f, 2.16882333e-01f, -7.09040165e-02f, 7.29219466e-02f, 1.00580558e-01f,
  2.26735741e-01f, -1.38620418e-02f, 2.91164249e-01f, 2.43886858e-02f, 5.54556474e-02f, 1.54005453e-01f, 1.33981586e-01f, 4.00111154e-02f, 7.34706670e-02f, 2.27562487e-02f,
  -6.12319335e-02f, 9.76189747e-02f, 9.85269099e-02f, 2.64757825e-03f, 8.36604759e-02f, -1.07700586e-01f, -2.85782181e-02f, -3.90429311e-02f, -4.96379435e-02f, -1.22021504e-01f,
  -1.79022271e-02f, -7.34090880e-02f, 7.59763420e-02f, 6.37834072e-02f, 6.54318109e-02f, 9.44865793e-02f, -3.09847072e-02f, 1.63502786e-02f, 8.17808732e-02f, 6.47657365e-02f,
  6.07120022e-02f, 3.84005196e-02f, 1.03329740e-01f, 4.82104234e-02f, 8.63229558e-02f, 4.25518584e-03f, -1.26727857e-02f, 9.63463411e-02f, 1.75384432e-02f, 2.62809414e-02f,
  4.80850413e-02f, -7.04630911e-02f, -1.48256868e-01f, -6.86176270e-02f, -6.65952191e-02f, -1.00200422e-01f, -3.27397659e-02f, -5.25139086e-02f, -1.94654148e-02f, 9.46466345e-03f,
  6.38104826e-02f, -8.94128252e-03f, -1.68999881e-02f, -8.92748591e-03f, -7.60632008e-02f, 1.48702329e-02f, -2.03379523e-02f, 5.64263910e-02f, 5.96524104e-02f, 9.99118946e-03f,
  -3.20118037e-03f, -9.34416354e-02f, -5.32967038e-04f, 6.70889765e-02f, -1.51094601e-01f, 1.99184995e-02f, -1.27362581e-02f, -2.09596604e-02f, -3.18064578e-02f, 1.28029048e-01f,
  -3.52158807e-02f, 2.01787367e-01f, 1.56198135e-02f, -2.99526844e-02f, -7.23235384e-02f, -1.08458176e-01f, -1.60259176e-02f, 3.67279090e-02f, 2.53753476e-02f, -2.77971216e-02f,
  8.08483288e-02f, -6.31327182e-02f, -4.87285070e-02f, 5.07917069e-02f, 6.13124259e-02f, 2.38056369e-02f, -5.17038703e-02f, -2.58218925e-02f, 1.54077306e-01f, 2.89622955e-02f,
  2.90800002e-04f, -1.39485300e-01f, -2.43537407e-02f, -1.55422892e-02f, 2.12011319e-02f, 1.28822014e-01f, -1.11340679e-01f, 1.05865993e-01f, 5.17253242e-02f, -2.58450676e-02f,
  4.49459940e-01f, 3.03274095e-01f, 4.22450043e-02f, 6.89817145e-02f, -1.63626716e-01f, 8.96493644e-02f, -7.59030413e-03f, 4.82134558e-02f, -4.66089472e-02f, 2.66294256e-02f,
  -1.19617149e-01f, 2.01380536e-01f, 7.73319155e-02f, 1.14522904e-01f, 1.24039350e-03f, -1.47621604e-02f, 1.86833501e-01f, -1.88588519e-02f, -3.33617888e-02f, 2.78902382e-01f,
  1.75379544e-01f, 1.73684567e-01f, -2.01832186e-02f, -9.67723783e-03f, 7.72117898e-02f, 1.12394944e-01f, -1.31775260e-01f, -7.28596821e-02f, 6.11316524e-02f, -8.20058510e-02f,
  -6.33490905e-02f, -3.33836302e-02f, 2.70645451e-02f, 2.66653765e-02f, 5.66956252e-02f, 1.09912222e-02f, -5.25822453e-02f, -8.98556132e-03f, -6.66817799e-02f, 9.68602225e-02f,
  5.14156818e-02f, -8.44164193e-03f, 1.62018836e-01f, -6.51959181e-02f, 2.73684263e-02f, 8.69595930e-02f, 4.01033014e-02f, -3.09177674e-02f, -6.22068474e-04f, 1.08852193e-01f,
  1.89290315e-01f, -4.75601219e-02f, 8.42578411e-02f, 9.22599956e-02f, 1.08495029e-02f, 1.00939408e-01f, 7.97801018e-02f, 2.92227753e-02f, -1.28957420e-03f, 1.58629969e-01f,
  7.16528296e-02f, 6.14079461e-02f, 1.46938875e-01f, -5.19502610e-02f, 8.44147131e-02f, -8.48545358e-02f, -1.83994584e-02f, -1.10125700e-02f, -8.21145996e-03f, 5.72909117e-02f,
  -1.08301505e-01f, -5.63791059e-02f, -7.41224140e-02f, -3.17295687e-03f, 9.73307863e-02f, 2.22557168e-02f, -4.53230590e-02f, -8.26325864e-02f, 4.60690306e-03f, -8.12482238e-02f,
  -1.28753260e-01f, -1.13289887e-02f, -3.95572782e-02f, -1.28512949e-01f, -9.49378386e-02f, 4.40737978e-02f, 6.44507334e-02f, 3.42886858e-02f, -1.21121705e-01f, -3.10831200e-02f,
  -4.04878929e-02f, 2.14300334e-01f, 3.08258999e-02f, -3.12546035e-03f, 7.55546018e-02f, 8.96701515e-02f, 9.18235257e-02f, 1.34786651e-01f, 5.14965430e-02f, 1.02118567e-01f,
  5.82496859e-02f, -1.11880917e-02f, 4.10000049e-03f, -7.83153474e-02f, -9.26295295e-02f, 2.61529475e-01f, 3.98069099e-02f, -3.05438899e-02f, -8.33820328e-02f, 6.15436658e-02f,
  6.96288794e-02f, 3.64683717e-02f, 1.40927494e-01f, 1.05881095e-01f, 1.23201296e-01f, -1.85701996e-02f, -2.00670287e-02f, -9.77760553e-02f, -6.43745763e-03f, 1.68787241e-02f,
  -7.76353240e-01f, 3.00283611e-01f, 6.21627234e-02f, -2.70481735e-01f, 5.02337292e-02f, -2.73891352e-03f, 5.74651696e-02f, 5.13987280e-02f, 1.22565497e-02f, 8.32157731e-02f,
  1.87028259e-01f, -1.30222082e-01f, 2.80714601e-01f, 2.37091165e-02f, -2.25418448e-01f, 1.73074156e-01f, -2.16666564e-01f, -7.87167475e-02f, 2.69814786e-02f, -1.13268338e-01f,
  -1.92554116e-01f, -7.35572949e-02f, -6.65936694e-02f, 1.48824826e-01f, -6.68525025e-02f, -1.08523630e-01f, -2.58725863e-02f, 3.17570493e-02f, -7.53273368e-02f, 8.69741365e-02f,
  -7.99521282e-02f, -9.76157933e-02f, 1.03705972e-01f, -3.52436975e-02f, -2.78563686e-02f, -1.26174034e-03f, -1.16918266e-01f, 8.71167518e-03f, 7.80791417e-02f, 1.83238182e-02f,
  -6.17318265e-02f, -6.63624108e-02f, -1.04608491e-01f, 4.18447815e-02f, -2.14249082e-02f, 7.53167421e-02f, 1.93423331e-02f, -2.85137240e-02f, 7.81406835e-02f, 2.76234392e-02f,
  1.17058516e-01f, -4.57479618e-02f, 1.50743788e-02f, -1.21227838e-01f, -4.30744477e-02f, 9.21049118e-02f, -1.12758158e-03f, -1.25718787e-01f, -7.89640099e-02f, -6.53039142e-02f,
  -4.18335348e-02f, 3.24820206e-02f, 1.34986117e-01f, 4.59906310e-02f, 1.51007725e-02f, 7.97406659e-02f, 2.76491791e-03f, -8.45582969e-03f, 4.37860340e-02f, 2.04520989e-02f,
  -1.26125172e-01f, -4.39430177e-02f, -3.10530066e-02f, -8.02878812e-02f, -2.01627277e-02f, 9.73581150e-02f, 5.26231565e-02f, 1.05671547e-01f, -1.59073293e-01f, -1.33780748e-01f,
  3.48610654e-02f, -7.05305720e-03f, -6.04666360e-02f, -1.06047824e-01f, 3.11528202e-02f, -4.16699834e-02f, -1.53145399e-02f, 6.64806217e-02f, -4.41295728e-02f, -1.54242814e-01f,
  -3.16748440e-01f, -4.05316979e-01f, 7.57009834e-02f, 2.65668556e-02f, 4.72712927e-02f, 2.96370941e-03f, 6.04631901e-02f, 4.10606712e-02f, 7.04521313e-02f, -1.88186150e-02f,
  1.21016772e-02f, -8.10138434e-02f, -1.40964925e-01f, 2.92967428e-02f, 4.29074503e-02f, -2.19474323e-02f, -5.10670952e-02f, -1.15368878e-02f, -6.46589771e-02f, 1.47615131e-02f,
  -5.93928918e-02f, 1.21299224e-02f, -7.02392235e-02f, -1.74123794e-01f, -7.40878284e-02f, 3.84472534e-02f, -6.12202063e-02f, -3.51444408e-02f, -7.92241693e-02f, -4.80378270e-02f,
  -1.63178146e-01f, 1.82959646e-01f, 3.57720733e-01f, 3.69134039e-01f, -1.30763814e-01f, -4.44505572e-01f, -3.09176445e-01f, 1.57495365e-01f, 6.70344308e-02f, -5.91326468e-02f,
  -1.36639448e-02f, -1.30417589e-02f, 7.89885521e-02f, 1.77860260e-01f, 9.54101086e-02f, 1.86165154e-01f, -6.29244663e-04f, -1.34900734e-01f, 7.62754232e-02f, 6.64566010e-02f,
  1.73215225e-01f, 7.24113286e-02f, 2.93388903e-01f, 2.10733309e-01f, 2.12749429e-02f, 8.95350352e-02f, 1.95505157e-01f, 1.85894668e-01f, 1.12770066e-01f, -1.10409185e-01f,
  -1.92491785e-01f, 5.34040630e-02f, 4.83076647e-02f, -7.51195922e-02f, 6.43828362e-02f, -1.58487484e-01f, -1.02944374e-01f, 7.92125762e-02f, 2.76820865e-02f, -5.55131063e-02f,
  -1.01054795e-01f, -5.40109389e-02f, 2.85465419e-02f, 4.63038646e-02f, -1.12939872e-01f, 4.69704233e-02f, 6.27418458e-02f, -1.18666336e-01f, -6.81352392e-02f, 8.27650167e-03f,
  9.89979133e-02f, 4.72873030e-03f, -3.61831263e-02f, 2.58669946e-02f, -4.74050567e-02f, -7.19010159e-02f, -3.50995958e-02f, 2.47590430e-02f, 6.29697368e-02f, 4.18281779e-02f,
  1.32943168e-02f, 8.19134936e-02f, 7.71365222e-03f, 1.74372140e-02f, -3.38784456e-02f, -3.00555509e-02f, -3.89760137e-02f, -1.53806493e-01f, -2.04612277e-02f, 3.04638874e-02f,
  7.58128688e-02f, 1.70449749e-01f, -2.13628262e-02f, 3.21535254e-03f, 8.47507492e-02f, -2.06761230e-02f, 1.14409635e-02f, 1.38256419e-02f, -6.20699227e-02f, 4.69772480e-02f,
  1.19699351e-01f, 2.45071854e-03f, -3.59347463e-02f, -9.14675072e-02f, -5.33448271e-02f, 4.66146693e-02f, -2.96855159e-02f, 1.24228997e-02f, 6.92075416e-02f, 1.80726256e-02f,
  -5.56126656e-03f, 3.09792578e-01f, -2.96152327e-02f, -7.99711943e-02f, 4.95682918e-02f, 1.01192228e-01f, 2.04915535e-02f, 4.71754558e-02f, 6.43348470e-02f, 5.88670820e-02f,
  -2.10941136e-02f, 2.53184922e-02f, -6.75996393e-02f, -1.05047502e-01f, 1.31933950e-02f, 1.59324944e-01f, 8.62347335e-02f, -4.49164510e-02f, 2.50055809e-02f, 9.83558223e-03f,
  1.48627773e-01f, -4.34052125e-02f, -2.67223883e-02f, -9.56597105e-02f, -1.42930120e-01f, -4.11596633e-02f, -1.53218629e-02f, 2.38112174e-02f, 1.47486657e-01f, -2.43640002e-02f,
  1.38722345e-01f, -1.61603317e-01f, 1.07172035e-01f, 3.28938931e-01f, 1.97745040e-02f, -2.60162592e-01f, -1.38631433e-01f, 2.08816394e-01f, 5.24328910e-02f, -1.84982419e-01f,
  -7.58095086e-02f, 2.73252409e-02f, -1.12782232e-01f, 8.73837993e-02f, 1.66828364e-01f, -8.02812353e-02f, 9.12751704e-02f, -6.52230680e-02f, 1.32502601e-01f, 1.18252665e-01f,
  2.35680565e-01f, 1.37727782e-01f, 3.92501831e-01f, 3.53714108e-01f, 7.66422972e-02f, 3.05042297e-01f, 2.16515049e-01f, 1.12138472e-01f, 1.93912655e-01f, 9.17585418e-02f,
  -3.60739417e-02f, -8.67220610e-02f, 9.89763141e-02f, 1.95832606e-02f, 2.91813109e-02f, 2.70451903e-02f, -4.69018593e-02f, 3.40886489e-02f, -2.73499880e-02f, 3.99424247e-02f,
  -1.08971134e-01f, -1.87865943e-02f, 1.21840373e-01f, -6.69793561e-02f, 1.55804772e-02f, -3.22337933e-02f, -2.99699754e-02f, -4.64432221e-03f, -3.80518939e-03f, 6.99919183e-03f,
  4.92293760e-02f, 1.47770019e-03f, 4.40323763e-02f, 1.17605980e-02f, 9.39269513e-02f, -1.27950618e-02f, 8.48022401e-02f, 3.74209993e-02f, -1.69232171e-02f, 1.29650563e-01f,
  -8.95135105e-02f, 8.00450519e-02f, 9.19575617e-02f, 1.23630166e-02f, 3.34197655e-02f, -5.53737918e-04f, -1.59585625e-02f, 5.08254655e-02f, 5.73337637e-03f, -1.02616787e-01f,
  -5.04723862e-02f, 1.31018518e-03f, -1.07121676e-01f, -9.63198096e-02f, 1.60790384e-01f, -2.23264694e-02f, 4.29286361e-02f, 5.84249683e-02f, 6.14201687e-02f, 2.47188900e-02f,
  -6.42296970e-02f, 1.13192247e-02f, -6.63106292e-02f, -6.63277358e-02f, -6.10505193e-02f, 5.87459765e-02f, 3.25631760e-02f, -1.11836269e-01f, 5.33653535e-02f, 6.92190677e-02f,
  -1.85488790e-01f, -3.41817848e-02f, 5.10502160e-02f, -1.95618384e-02f, 1.33611308e-02f, 2.09001172e-02f, -9.28092152e-02f, -2.44405027e-02f, -1.09202407e-01f, 6.74797595e-02f,
  -4.43707258e-02f, -3.81581150e-02f, 6.05348200e-02f, -5.53398905e-03f, 1.05492227e-01f, 3.69243249e-02f, 3.02398838e-02f, -4.17720638e-02f, 1.19531244e-01f, 1.47801526e-02f,
  6.51319623e-02f, -7.94936940e-02f, 1.42918183e-02f, 4.34076004e-02f, 8.16854909e-02f, 2.54431143e-02f, 7.21631348e-02f, -2.89232563e-03f, 3.34685482e-02f, 1.78657491e-02f,
  -4.72730324e-02f, -1.98077217e-01f, -5.95506392e-02f, 4.23654467e-02f, 3.39975834e-01f, 3.56329799e-01f, 1.99571505e-01f, 1.27743781e-01f, 4.62889299e-02f, -5.72147146e-02f,
  7.68313929e-02f, 3.67254228e-03f, -1.54923514e-01f, 7.36893639e-02f, 3.33743781e-01f, -6.12556003e-02f, 6.35486841e-02f, 4.17860411e-02f, -7.29514509e-02f, -4.08997312e-02f,
  1.94428209e-02f, 1.68453991e-01f, 1.33442255e-02f, 4.63031903e-02f, 8.57574418e-02f, -5.04014492e-02f, -2.40467973e-02f, 2.16816179e-02f, 1.80505872e-01f, 1.92897886e-01f,
  2.88622342e-02f, -2.52915651e-01f, -4.59026136e-02f, -1.37339339e-01f, 4.49519381e-02f, -6.16876967e-02f, -9.30866376e-02f, 8.94136913e-03f, 7.42580043e-03f, 1.21063292e-02f,
  -4.23010029e-02f, 6.10215440e-02f, 8.87314677e-02f, 9.76019260e-03f, 5.53288870e-03f, -8.31760690e-02f, 4.70086075e-02f, -3.16472650e-02f, 2.01642141e-02f, -4.61070240e-02f,
  -1.23457192e-02f, 4.25036736e-02f, -9.16835964e-02f, 2.06926465e-02f, 9.99079794e-02f, 9.98729840e-02f, -1.19335636e-01f, 1.67018279e-01f, 8.85072947e-02f, 1.68874457e-01f,
  1.22599520e-01f, 1.00782281e-02f, -2.41567288e-02f, -2.68973093e-02f, -7.69170448e-02f, -2.19006948e-02f, -5.70237525e-02f, 1.15761673e-03f, -9.28361528e-03f, -1.18436050e-02f,
  3.00029083e-03f, 6.80282805e-03f, -1.06482785e-02f, -2.91344840e-02f, -2.71281041e-03f, -1.25096813e-01f, -5.16046658e-02f, -3.93183604e-02f, 7.96484947e-02f, 9.70408916e-02f,
  4.68928367e-02f, 3.48580023e-03f, 1.23336360e-01f, 5.56111662e-03f, -3.68574485e-02f, -1.08819557e-02f, -2.67358646e-02f, 2.57980283e-02f, -5.90559058e-02f, 3.00118010e-02f,
  -4.95995320e-02f, -1.92073837e-01f, 2.23183595e-02f, -1.21096475e-02f, -1.43394610e-02f, -2.38614343e-03f, -1.10784970e-01f, 9.18589979e-02f, -8.72941017e-02f, -4.99168178e-03f,
  -4.42901812e-02f, -8.03782716e-02f, -4.60682698e-02f, -1.57823414e-02f, 4.67424653e-02f, -4.89548557e-02f, -4.20204410e-03f, -4.94484045e-02f, 6.63072467e-02f, 5.26247583e-02f,
  -4.61372845e-02f, -6.72324523e-02f, 3.99234928e-02f, 3.46970856e-02f, 1.57950558e-02f, 5.04776016e-02f, -1.47341073e-01f, 9.22656581e-02f, 6.56544417e-02f, 8.29089805e-02f,
  9.44854990e-02f, -3.35815042e-01f, -2.00437695e-01f, -1.07534580e-01f, -1.67788602e-02f, -3.33201379e-01f, -5.94643205e-02f, -2.97610432e-01f, -1.08899429e-01f, -1.05887905e-01f,
  -5.45613505e-02f, 1.43347725e-01f, 3.12533468e-01f, -2.72664934e-01f, 2.76149392e-01f, 2.51086295e-01f, -3.02265555e-01f, -6.84762895e-02f, -1.80955732e-03f, -2.27380574e-01f,
  -1.69453576e-01f, -2.64646083e-01f, -4.98231165e-02f, -1.60140216e-01f, -2.54219826e-02f, -1.26192838e-01f, 2.38762330e-02f, 7.40540475e-02f, -2.67592221e-01f, 1.21560544e-01f,
  -1.24789938e-01f, 1.81422353e-01f, 2.07181089e-02f, -4.81394678e-02f, -1.10003375e-01f, 6.44170716e-02f, -5.12251593e-02f, 2.35391289e-01f, 1.31306022e-01f, 4.30572666e-02f,
  8.63276422e-02f, 2.89068446e-02f, -1.21767312e-01f, 7.30054528e-02f, -8.27120766e-02f, -4.22453471e-02f, -7.57478774e-02f, -8.49485695e-02f, 1.69935301e-02f, 6.86445683e-02f,
  -1.82809681e-02f, -1.47668980e-02f, -1.71644032e-01f, -7.62239471e-03f, 1.16336262e-02f, -4.96686772e-02f, -4.12966572e-02f, 1.08522633e-02f, -4.57060039e-02f, 2.65855179e-03f,
  1.16654979e-02f, 3.93627994e-02f, 1.21067658e-01f, -8.34910646e-02f, -8.75453874e-02f, 4.04989161e-03f, 6.61650151e-02f, 8.64713639e-02f, 4.01572064e-02f, 1.46677913e-02f,
  -1.78313218e-02f, 8.47020820e-02f, 5.65935969e-02f, -6.14975616e-02f, -7.04078972e-02f, 1.89376194e-02f, 6.66903257e-02f, -3.75281684e-02f, -1.42508447e-01f, -8.13748837e-02f,
  1.24547683e-01f, -2.02674959e-02f, 3.84233668e-02f, 5.19917123e-02f, -1.06554434e-01f, 6.64375350e-02f, -1.42147914e-01f, -5.33241890e-02f, 2.45502032e-03f, 4.67931852e-02f,
  -1.05533808e-01f, 3.30175296e-03f, 2.21533161e-02f, 9.29416791e-02f, 6.08872324e-02f, 1.82109158e-02f, -4.52373475e-02f, -7.99963996e-02f, 7.08115920e-02f, -8.26634988e-02f,
  -4.03228067e-02f, 3.97630110e-02f, -5.57529554e-02f, -3.14045846e-02f, 1.97287276e-02f, -1.29558161e-01f, 1.67444333e-01f, 7.76390806e-02f, 1.10752368e-03f, -8.47859588e-03f,
  6.55356003e-03f, 1.77105650e-01f, 9.96419787e-02f, 4.60973755e-02f, -7.30866790e-02f, -2.74150795e-03f, -4.14610244e-02f, -1.21538177e-01f, 1.19107395e-01f, 4.71477993e-02f,
  -5.68005264e-01f, 4.17641364e-02f, -6.40131235e-02f, 9.99489799e-02f, -1.97462142e-01f, 1.23959839e-01f, 3.07925314e-01f, -9.82309505e-02f, -8.40716958e-02f, 3.49297494e-01f,
  2.66694635e-01f, -1.48962840e-01f, 1.35065123e-01f, 2.06390977e-01f, 1.22665772e-02f, 1.28522530e-01f, 1.88027337e-01f, 1.74771443e-01f, -1.19486593e-01f, -2.92596251e-01f,
  -1.19582392e-01f, 3.27599272e-02f, 1.77596867e-01f, -9.19896141e-02f, -8.36644843e-02f, -1.18985198e-01f, 1.97594628e-01f, -4.72732186e-02f, 7.54329041e-02f, 4.11070921e-02f,
  -5.72969988e-02f, -2.63923466e-01f, -5.48742935e-02f, -5.95875047e-02f, -3.67319770e-03f, -1.75655093e-02f, 2.74073724e-02f, 8.82855617e-03f, 1.84950908e-03f, -3.62600610e-02f,
  -7.08713606e-02f, -6.49977624e-02f, -5.78871891e-02f, -3.22344303e-02f, -1.59857959e-01f, -1.19250506e-01f, -1.60131790e-02f, 5.40245138e-03f, -3.38617601e-02f, -3.34636681e-02f,
  5.45275025e-02f, 9.94555429e-02f, 1.11053444e-01f, 9.62915570e-02f, 9.38919783e-02f, 6.65162131e-02f, 1.19885327e-02f, -7.87601471e-02f, 4.61697616e-02f, 6.87180320e-03f,
  -3.28964069e-02f, 7.48612583e-02f, -6.54700492e-03f, -1.92843862e-02f, -2.93036047e-02f, 4.26638797e-02f, 4.23361361e-02f, -6.84594065e-02f, 5.56069314e-02f, -3.86698730e-02f,
  -8.97501037e-02f, -6.01362577e-03f, 9.11598206e-02f, 6.66989535e-02f, -4.63939831e-02f, 1.41931390e-02f, 1.16232343e-01f, -1.47772180e-02f, 5.49856164e-02f, 5.63712828e-02f,
  1.06013287e-02f, -1.13748223e-01f, 8.29583332e-02f, 5.49599379e-02f, 4.61926684e-02f, 4.90952991e-02f, -6.17125817e-02f, 1.18964016e-01f, 5.82646914e-02f, -5.26357442e-02f,
  -2.15868130e-01f, -1.57311112e-01f, 5.71914576e-02f, 9.32908035e-04f, 1.18595604e-02f, -3.54354568e-02f, 1.25378584e-02f, -5.19773699e-02f, -8.25249851e-02f, -7.98023418e-02f,
  -4.28528897e-02f, 9.37932730e-02f, -8.39717686e-02f, 1.71679277e-02f, -1.09964855e-01f, 1.76550765e-02f, -4.13715020e-02f, -4.00567278e-02f, -3.17768231e-02f, -3.53082269e-02f,
  5.06245606e-02f, 3.57150920e-02f, 6.37293607e-02f, 1.07084870e-01f, 9.45546255e-02f, 6.85368711e-03f, -1.28728330e-01f, -1.17279135e-01f, -1.11069120e-01f, 8.51476416e-02f,
  -6.25936985e-02f, 4.13441598e-01f, 2.67872721e-01f, 2.08609566e-01f, -1.73339382e-01f, 1.37300670e-01f, 8.21212232e-02f, 1.09340265e-01f, -5.20714968e-02f, 2.53196567e-01f,
  -1.43075109e-01f, 2.09028095e-01f, 5.47396718e-03f, 1.74090460e-01f, -3.64565104e-01f, -4.54284921e-02f, 1.59452617e-01f, 1.70803726e-01f, -1.59411281e-01f, 1.83771387e-01f,
  -1.49409458e-01f, -1.58515632e-01f, 8.72856006e-02f, -2.11066931e-01f, 1.29342020e-01f, 6.88730925e-02f, -9.79964361e-02f, -9.42821950e-02f, 1.54634595e-01f, -1.44159734e-01f,
  1.17611766e-01f, 4.11761664e-02f, 1.55349359e-01f, 9.14087221e-02f, 5.98728508e-02f, 5.81930280e-02f, 1.26189664e-01f, -1.17040560e-01f, -1.85573176e-01f, 5.30305803e-02f,
  1.39606260e-02f, -6.97995871e-02f, 1.52791113e-01f, -1.55858070e-01f, -3.52644324e-02f, 1.43595621e-01f, 6.62895516e-02f, 3.98821384e-03f, 9.21870694e-02f, 9.61563215e-02f,
  1.83924481e-01f, 1.47580966e-01f, 6.58873171e-02f, 1.12306833e-01f, -6.75312802e-02f, -5.18486202e-02f, 1.12380363e-01f, -1.87575556e-02f, 1.52467400e-01f, -7.38326041e-03f,
  -1.04829468e-01f, 9.36025456e-02f, 1.58078894e-01f, 5.94073310e-02f, 1.38855884e-02f, -3.84294167e-02f, -4.53901291e-02f, -1.18636839e-01f, -1.85348392e-01f, 3.03874444e-02f,
  -3.64180794e-03f, 3.29403952e-02f, -8.86025205e-02f, 6.49241582e-02f, -4.24546152e-02f, -1.36153428e-02f, -8.13341513e-02f, 1.16605707e-01f, 1.02625340e-02f, -4.47116494e-02f,
  -1.26774743e-01f, -4.83470410e-02f, -5.24840467e-02f, -2.68176906e-02f, 2.81820563e-03f, -1.33198500e-02f, -4.02326100e-02f, -3.60731706e-02f, 1.18520156e-01f, 2.37198900e-02f,
  8.17335472e-02f, -7.85477534e-02f, 1.50431218e-02f, 1.92864742e-02f, -1.97711773e-02f, 7.07217231e-02f, -1.80879496e-02f, 4.95366491e-02f, -6.06463403e-02f, 1.47247631e-02f,
  -1.51122101e-02f, 3.15769911e-02f, 1.31290525e-01f, -8.31192285e-02f, -1.24680877e-01f, 7.41535202e-02f, 4.25320603e-02f, 5.30460989e-03f, -3.18539478e-02f, 6.10273052e-03f,
  8.93578529e-02f, 5.95194139e-02f, 3.72443385e-02f, 1.20427370e-01f, 7.93186724e-02f, -2.38856580e-02f, -6.51739538e-02f, -6.11798558e-03f, 3.39747891e-02f, 5.46105718e-03f,
  1.95907488e-01f, 1.12323284e-01f, 2.89292969e-02f, 3.60420272e-02f, -2.49117449e-01f, -1.44009322e-01f, -9.66990143e-02f, 1.62712752e-03f, 2.77987808e-01f, 3.77949066e-02f,
  -3.46680969e-01f, 3.17125559e-01f, -6.01737574e-02f, -1.69597492e-01f, -7.70111904e-02f, -2.91233938e-02f, 2.07092874e-02f, -3.91116254e-02f, 3.21128108e-02f, -7.57256348e-05f,
  -8.08446035e-02f, -2.86512017e-01f, -1.38645515e-01f, -2.75774539e-01f, -2.59926915e-01f, 1.02197073e-01f, -2.27258787e-01f, -8.96964371e-02f, -1.32194936e-01f, -6.12484477e-02f,
  -3.93751897e-02f, 1.01556011e-01f, 8.61620903e-03f, 1.39547750e-01f, 1.74752809e-02f, -2.05967277e-02f, 1.27219865e-02f, -3.71294878e-02f, 1.01590687e-02f, 8.83516222e-02f,
  1.01422653e-01f, 3.62513587e-02f, 4.40977626e-02f, -1.65824085e-01f, 1.17348500e-01f, 8.61461982e-02f, 6.73757046e-02f, 1.76891056e-03f, 1.44102708e-01f, -5.99408895e-02f,
  -4.97896932e-02f, 6.68330723e-03f, 1.13949709e-01f, 1.09802470e-01f, 8.90858471e-02f, 4.88498434e-02f, -4.55498137e-02f, -7.60895535e-02f, 6.63876086e-02f, 1.67015150e-01f,
  -8.73688050e-03f, -1.69838015e-02f, -5.79325594e-02f, -3.74600813e-02f, 2.86658276e-02f, -4.81017791e-02f, -7.88506418e-02f, 6.21317234e-03f, 1.05440645e-02f, -8.28678012e-02f,
  -1.42247258e-02f, 8.69570598e-02f, -9.35380235e-02f, -2.77455691e-02f, -6.53082877e-02f, 6.14363253e-02f, 1.40853701e-02f, -5.45014627e-02f, -1.12808449e-02f, 8.71032625e-02f,
  -1.50952274e-02f, -5.06795850e-03f, -4.53117266e-02f, -1.25929967e-01f, -2.95739807e-02f, 1.34585388e-02f, -5.93624599e-02f, 4.91140597e-02f, -6.62800344e-03f, 4.76253517e-02f,
  -4.46771979e-02f, 7.71249980e-02f, 1.10827245e-01f, 9.55951363e-02f, -3.17076147e-02f, -7.21722692e-02f, -8.74466356e-03f, 1.22333795e-03f, 1.16479799e-01f, 2.65035522e-03f,
  7.86219761e-02f, 4.38512787e-02f, 1.07141428e-01f, -8.93910453e-02f, 1.17574871e-01f, -5.62048256e-02f, 5.86032905e-02f, 1.44031197e-01f, 1.27030969e-01f, -4.97598760e-02f,
  -7.58566856e-02f, 3.13589536e-02f, 1.56499103e-01f, 1.68615982e-01f, 1.74573287e-02f, 1.12536252e-01f, -1.51315434e-02f, 6.34108707e-02f, -9.37430337e-02f, 3.67060676e-02f,
  -5.68186760e-01f, 2.18481421e-01f, 3.54204088e-01f, -3.48765075e-01f, 1.90749705e-01f, 2.34150723e-01f, -2.05302328e-01f, 1.56994075e-01f, -1.45487890e-01f, -4.53169234e-02f,
  -2.74280459e-01f, 8.30406789e-03f, -1.95043698e-01f, -8.61535147e-02f, 2.14588847e-02f, -1.02685139e-01f, -8.28619674e-02f, -3.35013270e-01f, 7.64658153e-02f, -2.00468730e-02f,
  1.09056205e-01f, -4.26242501e-02f, 5.62735386e-02f, 2.61163741e-01f, -1.96212213e-02f, -6.38813972e-02f, -1.51068792e-01f, 1.58784539e-01f, 3.93055426e-03f, 2.19353721e-01f,
  -1.90459192e-01f, -2.98187882e-01f, -3.94370526e-01f, -8.55287090e-02f, -3.14849578e-02f, -1.00744560e-01f, -4.61294241e-02f, -5.03330901e-02f, -1.52262479e-01f, -8.07405710e-02f,
  -1.21200852e-01f, 7.06847385e-02f, -5.98244593e-02f, -9.20173675e-02f, -7.92711899e-02f, 9.69498008e-02f, 1.78624421e-01f, 4.02587429e-02f, 1.74296238e-02f, 5.26638143e-02f,
  7.93950036e-02f, 1.36907427e-02f, -3.38713527e-02f, -3.99229713e-02f, 1.04084119e-01f, -7.83033669e-02f, 3.51746008e-02f, 6.24569952e-02f, 3.73807363e-02f, 3.42447162e-02f,
  1.15214407e-01f, -2.81784032e-02f, 4.38082851e-02f, -1.20713105e-02f, 1.77423283e-02f, 3.79703008e-02f, 1.83476452e-02f, -1.29017662e-02f, 1.64182449e-03f, 5.52607849e-02f,
  6.26303703e-02f, 2.94968933e-02f, -8.12365301e-03f, -5.15759829e-03f, 2.21693963e-02f, -5.67799956e-02f, 1.92646272e-02f, -7.00282976e-02f, -3.41527723e-02f, 4.09481749e-02f,
  -1.00419171e-01f, -4.00335155e-02f, 2.34302543e-02f, -5.38691804e-02f, -5.56651829e-03f, 2.86752768e-02f, 2.16483265e-01f, 5.17113879e-02f, -3.52405906e-02f, 1.96917467e-02f,
  -3.54677051e-01f, -3.29853266e-01f, -2.43671373e-01f, -8.69858190e-02f, -4.87929657e-02f, -7.48387501e-02f, -2.01641601e-02f, -6.00112453e-02f, -1.01898737e-01f, -7.09945932e-02f,
  -6.63696826e-02f, -3.90775613e-02f, -2.54838336e-02f, -1.32622764e-01f, 6.04191013e-02f, 8.02987628e-03f, -5.24239987e-02f, -1.23015277e-01f, -6.00849688e-02f, 7.25239590e-02f,
  5.66171892e-02f, -8.73532444e-02f, 5.04433103e-02f, -7.31017217e-02f, -9.03073624e-02f, 4.17931676e-02f, 8.49905715e-04f, 3.54009531e-02f, 8.26012641e-02f, -2.65327282e-02f,
  1.86704949e-01f, 1.27449825e-01f, 2.05849573e-01f, 2.81606883e-01f, -8.56296197e-02f, -2.89846987e-01f, -1.00273341e-01f, 6.79669678e-02f, 2.75869608e-01f, -2.31646180e-01f,
  -5.36963232e-02f, 9.09140930e-02f, -1.93091884e-01f, -3.62272263e-02f, -2.97372788e-01f, -1.50860697e-01f, 1.58812672e-01f, 8.29430446e-02f, 1.26303777e-01f, 1.04473390e-01f,
  1.00825734e-01f, -1.98589504e-01f, 8.01542997e-02f, -2.36862481e-01f, 8.16243142e-02f, 1.97381198e-01f, -4.31573205e-02f, -6.08071424e-02f, -3.30384076e-02f, -7.04669654e-02f,
  -7.12342709e-02f, 1.60012797e-01f, 9.14241746e-02f, -5.63616604e-02f, 9.99340415e-03f, 2.15562042e-02f, -8.82212725e-03f, -1.50698602e-01f, -1.05943553e-01f, 1.73906283e-03f,
  7.06619117e-03f, 4.13329573e-03f, 4.15504612e-02f, -7.78379366e-02f, 4.66198251e-02f, 5.26419543e-02f, 9.06169638e-02f, 1.13816813e-01f, 2.17097383e-02f, 1.83433309e-01f,
  1.22806661e-01f, 3.48886685e-03f, 1.10180669e-01f, -3.12108174e-02f, 1.06010243e-01f, -7.79819302e-03f, -1.93630848e-02f, 4.51411214e-03f, 1.94613654e-02f, 5.24891503e-02f,
  1.08225182e-01f, -6.46719262e-02f, -3.03456709e-02f, -1.82632469e-02f, -6.02447391e-02f, 8.42690642e-04f, -4.19271141e-02f, -9.26367473e-03f, 7.33595341e-02f, 8.93907971e-04f,
  -4.21652459e-02f, -6.25311816e-03f, -3.35325338e-02f, -7.60289952e-02f, 1.31312758e-02f, 2.85045877e-02f, -9.36389193e-02f, -1.20193027e-02f, 3.68525460e-02f, 2.51066722e-02f,
  -4.67467941e-02f, -6.49917424e-02f, -4.45755310e-02f, 5.11196740e-02f, -1.54447407e-01f, 7.29981884e-02f, 1.07402593e-01f, -2.06939168e-02f, -6.08680882e-02f, 1.15272976e-01f,
  3.41744237e-02f, 7.38342777e-02f, -4.95156646e-02f, -1.31871879e-01f, -9.75448340e-02f, 4.05030418e-03f, -2.32547726e-02f, -1.21863578e-02f, 3.28346640e-02f, 1.79705545e-02f,
  -5.31305298e-02f, -2.53473837e-02f, -3.02047934e-02f, 3.18633802e-02f, -3.66940834e-02f, -5.03399931e-02f, -1.59438208e-01f, 1.49714984e-02f, 2.76468378e-02f, 1.21961229e-01f,
  2.46305261e-02f, -1.31697282e-01f, 3.15887388e-03f, -5.23563623e-02f, 4.75357212e-02f, 5.29138632e-02f, -1.60486493e-02f, 5.34854382e-02f, 2.62139048e-02f, 6.65766671e-02f,
  2.60257334e-01f, 1.95682883e-01f, 2.49607116e-01f, 2.63458699e-01f, 1.69756394e-02f, -9.82896462e-02f, -6.30415380e-02f, -1.14800334e-01f, -3.98398377e-02f, -3.33915129e-02f,
  -2.27593377e-01f, 3.78686249e-01f, -3.06203038e-01f, 1.14055321e-01f, -3.12993556e-01f, -3.88310641e-01f, 1.82836533e-01f, 2.02620640e-01f, -1.24871038e-01f, 1.83227658e-01f,
  2.30911374e-02f, -1.05839528e-01f, 9.37372819e-02f, -1.34602621e-01f, 1.39502257e-01f, 9.84102264e-02f, -1.08391881e-01f, 4.30938206e-04f, 2.65454888e-01f, 1.36630908e-01f,
  7.69984424e-02f, -6.16078302e-02f, 6.97803423e-02f, 2.29073800e-02f, -6.34407848e-02f, 6.73068967e-03f, 1.70418724e-01f, -8.60062614e-02f, -1.09720826e-01f, -4.12011817e-02f,
  -2.90591344e-02f, 4.30289656e-02f, -1.32725909e-02f, 2.68519279e-02f, 2.15791449e-01f, 1.00545779e-01f, 3.73675972e-02f, 5.31471744e-02f, 9.43219736e-02f, 2.90180184e-02f,
  3.74598242e-02f, 1.62775561e-01f, 5.89622520e-02f, 9.29852128e-02f, -2.55762730e-02f, -3.74187753e-02f, 3.65682356e-02f, 1.33175611e-01f, 1.02722697e-01f, 3.56815755e-02f,
  -2.62082703e-02f, -1.19678378e-01f, -1.42650351e-01f, -1.12476815e-02f, -2.57606078e-02f, -1.78719573e-02f, -5.64156882e-02f, -4.51611280e-02f, -5.79428896e-02f, -2.42312290e-02f,
  -5.27655566e-03f, 4.10276093e-02f, -3.85715179e-02f, 4.94253002e-02f, -2.80243028e-02f, -2.05558408e-02f, 6.23435639e-02f, 1.71411503e-02f, 2.99699716e-02f, -3.41238827e-02f,
  -6.75648004e-02f, 3.48555706e-02f, 1.23821171e-02f, 7.46887550e-03f, -6.73728511e-02f, -8.19119290e-02f, -5.86772151e-02f, 6.50503710e-02f, -3.93387526e-02f, -5.89616373e-02f,
  3.77910696e-02f, -2.23405540e-01f, -7.83145204e-02f, 1.03457242e-01f, -3.61024849e-02f, -2.93959212e-02f, -3.61557677e-02f, 2.82489434e-02f, -4.61183563e-02f, -1.29981786e-01f,
  1.97481234e-02f, -1.27677470e-02f, 8.12360719e-02f, 7.70518035e-02f, 7.01270178e-02f, -1.48165211e-01f, -3.42581160e-02f, 3.91255468e-02f, 1.11594148e-01f, -2.34785452e-02f,
  2.10382789e-02f, -9.28569660e-02f, -1.20246888e-03f, 1.57357752e-02f, 9.79226977e-02f, -1.28195612e-02f, -1.02365268e-02f, 3.35567556e-02f, -5.95653839e-02f, 3.90438959e-02f,
  1.15328439e-01f, 3.60898495e-01f, 3.37627649e-01f, -1.75649136e-01f, -1.40629783e-01f, 9.98087004e-02f, -8.42625201e-02f, 2.49545202e-01f, 1.92006186e-01f, 1.89066336e-01f,
  -9.88723710e-02f, 2.68998474e-01f, -6.64852634e-02f, -4.77064997e-02f, -1.74320191e-01f, -2.25772306e-01f, -1.19675748e-01f, -2.23353468e-02f, -1.58448324e-01f, -1.45781577e-01f,
  -1.92301154e-01f, -3.60381454e-01f, -1.07967801e-01f, -2.54790068e-01f, 1.34611335e-02f, 1.15996845e-01f, -2.08969086e-01f, -4.45485562e-02f, 1.18159661e-02f, 5.06837517e-02f,
  5.63263781e-02f, -2.80266516e-02f, 1.36566177e-01f, 9.64873061e-02f, 2.03058738e-02f, 1.56037556e-02f, 4.31420952e-02f, 4.00551483e-02f, -1.06141172e-01f, 1.05826788e-01f,
  -1.23669401e-01f, -7.34843174e-03f, -1.24133611e-02f, 7.58807138e-02f, 5.55837341e-02f, 7.78629854e-02f, -3.12928371e-02f, 2.59812679e-02f, 1.38767704e-01f, 8.03808793e-02f,
  5.07744476e-02f, 1.65265977e-01f, 1.46621261e-02f, -4.60149534e-02f, 2.40829587e-02f, -2.34241714e-03f, 1.65230278e-02f, 9.34308991e-02f, 6.73538297e-02f, -5.44629619e-02f,
  3.42110209e-02f, -1.57137409e-01f, -6.07617386e-02f, 9.53422934e-02f, -9.07947868e-03f, -6.64863363e-03f, -8.07963833e-02f, -3.97992767e-02f, -1.17536582e-01f, -5.91308437e-02f,
  1.05900019e-02f, 6.46093860e-02f, -8.17459077e-02f, 4.97832596e-02f, -1.54832885e-01f, 2.47457456e-02f, 6.25344738e-02f, 8.57241675e-02f, -1.47421136e-01f, -6.83177859e-02f,
  -7.68260360e-02f, -7.41823763e-02f, -1.65616825e-01f, -1.54361492e-02f, -9.47512537e-02f, -2.52023712e-02f, 9.44400057e-02f, 5.43827079e-02f, -1.01152705e-02f, -1.46457478e-01f,
  1.51485763e-02f, -2.09096193e-01f, 2.92857084e-03f, 6.45345077e-02f, -6.53939769e-02f, 1.11863008e-02f, -6.00549169e-02f, 1.37450621e-01f, -8.79610479e-02f, 3.84499016e-03f,
  2.32070088e-02f, 2.58161519e-02f, -3.11894491e-02f, 9.60279629e-02f, -5.01911864e-02f, 3.55541334e-03f, -2.51992494e-01f, -1.14755191e-01f, 1.90526322e-02f, 5.64816315e-03f,
  5.51631302e-02f, -1.26756147e-01f, -3.49570513e-02f, -9.56033990e-02f, 9.11146495e-03f, 3.17353830e-02f, -5.76418750e-02f, 1.31421655e-01f, -7.41552711e-02f, -6.15886524e-02f,
  -1.66840240e-01f, 4.90665324e-02f, 1.05095930e-01f, 4.73895818e-02f, -8.00143108e-02f, -2.49104857e-01f, -2.50890821e-01f, 1.64492488e-01f, -7.75282308e-02f, 3.27217462e-03f,
  1.70825161e-02f, -7.16577545e-02f, 1.70077741e-01f, -1.72405511e-01f, -1.53179795e-01f, -1.69077694e-01f, -1.37186488e-02f, -1.92500334e-02f, -1.25887305e-01f, 1.52162850e-01f,
  1.13927238e-01f, -4.03520539e-02f, 1.36430442e-01f, 1.55459583e-01f, 6.35407679e-03f, 1.94091290e-01f, 1.76454961e-01f, 6.71858490e-02f, 8.11745003e-02f, 2.35810746e-02f,
  -7.59726018e-02f, 2.34688483e-02f, 3.27361599e-02f, -1.16219014e-01f, 4.77960110e-02f, -3.03008198e-03f, 1.62545685e-02f, -4.44339663e-02f, -7.68285096e-02f, 6.96872128e-03f,
  4.14145142e-02f, -1.19191715e-02f, 9.48957503e-02f, -5.53894490e-02f, 1.72257051e-02f, 6.30469099e-02f, -1.56392828e-02f, 2.92030089e-02f, -7.15743229e-02f, 8.71627256e-02f,
  3.71771641e-02f, 2.00414211e-02f, 7.03281015e-02f, 5.80721684e-02f, 7.17793256e-02f, 3.21162455e-02f, -6.31887652e-03f, 1.47338256e-01f, 1.48414066e-02f, -4.73700836e-02f,
  9.17730778e-02f, -3.12522575e-02f, -1.24631613e-01f, -8.19604993e-02f, -3.17600518e-02f, -8.44570547e-02f, -6.03836812e-02f, -2.99551804e-02f, -5.14337942e-02f, -1.45855481e-02f,
  4.02961634e-02f, -4.56007011e-02f, -9.99834239e-02f, 4.73529845e-02f, -1.34343198e-02f, 3.16405855e-02f, -1.96533613e-02f, 3.92820798e-02f, 5.72339594e-02f, -3.20331752e-02f,
  -6.51544034e-02f, -5.45020886e-02f, -1.76053122e-03f, 7.14373142e-02f, -1.12517841e-01f, 8.71336162e-02f, 7.14874193e-02f, -7.68751949e-02f, 3.24553996e-02f, 3.53941731e-02f,
  1.24374010e-01f, 2.14461148e-01f, -1.42536592e-02f, -9.96946618e-02f, 1.66922028e-03f, -9.92447045e-03f, -1.13739029e-01f, 2.39388901e-03f, 9.42648724e-02f, -6.17894053e-04f,
  1.30491138e-01f, 1.84870407e-03f, 6.39173463e-02f, 5.65157272e-02f, 2.70765889e-02f, 1.05345868e-01f, -3.97899933e-02f, -6.86872229e-02f, 7.26409182e-02f, 2.26040125e-01f,
  1.20247021e-01f, -6.61008507e-02f, 1.82054099e-02f, -1.07698053e-01f, 9.39486101e-02f, 4.47826162e-02f, -3.84519286e-02f, 1.15797304e-01f, 4.04873006e-02f, -4.27933112e-02f,
  7.81540424e-02f, 2.49837384e-01f, -1.57654241e-01f, -1.08819731e-01f, -9.22566578e-02f, -2.51869023e-01f, -3.44305009e-01f, 4.44909036e-02f, 1.79992944e-01f, 1.01204194e-01f,
  -1.79788306e-01f, 2.72901475e-01f, 1.18422098e-01f, -2.15893775e-01f, -1.22573283e-02f, 8.13503638e-02f, -2.02116802e-01f, -9.87813771e-02f, 1.46374866e-01f, -1.79783836e-01f,
  8.31978917e-02f, -1.99894205e-01f, -1.64262220e-01f, -8.45163688e-02f, -3.13550085e-01f, -6.16993867e-02f, 1.22119533e-02f, -4.14443985e-02f, -1.14247710e-01f, -4.31887768e-02f,
  -1.25415802e-01f, -4.22769487e-02f, -7.78524876e-02f, 4.95721772e-03f, -7.40750134e-02f, -1.23063825e-01f, -6.62327185e-02f, -1.04915842e-01f, -1.36957362e-01f, 7.19600171e-02f,
  7.19162598e-02f, 6.44756481e-02f, -2.64442875e-03f, 4.68217880e-02f, -4.78182957e-02f, 7.28431493e-02f, 1.95315908e-04f, 7.96307717e-03f, 2.80328579e-02f, 7.60363340e-02f,
  9.88486260e-02f, 7.81257674e-02f, -2.67935614e-03f, 6.87441826e-02f, -4.81496602e-02f, -1.06957264e-01f, 5.71862571e-02f, 7.06083849e-02f, 5.44698499e-02f, 9.30876434e-02f,
  -8.55231732e-02f, -1.87064297e-02f, 2.93621253e-02f, 5.89829171e-03f, 6.78278655e-02f, 9.61378291e-02f, 1.03746958e-01f, 2.71905549e-02f, 2.98535731e-03f, -2.25879233e-02f,
  -5.27249612e-02f, 1.51314214e-02f, -3.59050930e-02f, -5.30053899e-02f, -1.00252479e-01f, -4.72214259e-02f, -2.62532420e-02f, 2.11495161e-01f, -3.69522162e-02f, -5.89417778e-02f,
  -6.86066151e-02f, -1.44442827e-01f, 1.53604731e-01f, -6.62797764e-02f, -1.19777963e-01f, 1.59158595e-02f, 9.90158767e-02f, 5.71440421e-02f, -7.00999573e-02f, -1.33951958e-02f,
  -9.77556184e-02f, -2.29077578e-01f, -1.14854753e-01f, 4.81381565e-02f, -6.41573966e-03f, -1.69685073e-02f, 9.51303020e-02f, 1.75153352e-02f, -1.77214220e-01f, -8.04762393e-02f,
  4.32277955e-02f, -7.54242092e-02f, -4.21015210e-02f, 7.42670596e-02f, -1.27512841e-02f, -1.09102381e-02f, -1.83463469e-01f, 1.02255665e-01f, -9.03729275e-02f, 5.38818613e-02f,
  3.34050171e-02f, -8.67573358e-03f, -1.45923030e-02f, -1.02757916e-01f, -3.72605026e-02f, -2.74041537e-02f, 8.16239938e-02f, 2.10551582e-02f, -7.10913986e-02f, 5.50504476e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  2.68125534e-01f, 2.06887498e-01f, 1.81195050e-01f, 2.88258106e-01f, 7.90352598e-02f, 1.55596033e-01f, 1.31947786e-01f, 1.51131600e-01f, 1.86974525e-01f, 2.40363687e-01f,
  2.37125605e-01f, 2.03415990e-01f, 2.71654159e-01f, 2.75307715e-01f, 1.91945180e-01f, 1.48102805e-01f, 2.71592468e-01f, 2.21477434e-01f, 2.27121875e-01f, 1.56943604e-01f,
  1.46552011e-01f, 1.49085760e-01f, 1.97782591e-01f, 1.79479435e-01f, 1.32537425e-01f, 2.55083114e-01f, 1.41798735e-01f, 4.68399823e-02f, 1.58973262e-01f, 3.14388007e-01f,
  2.52511412e-01f, 8.16772953e-02f, 1.91482633e-01f, 1.84232444e-01f, 2.04305694e-01f, 2.29147479e-01f, 2.71648794e-01f, 1.51202142e-01f, 1.67742878e-01f, 1.82717577e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -3.56657133e-02f, 9.74711701e-02f, -2.23250464e-02f, -1.75536834e-02f, -3.09609622e-02f, -3.47418524e-02f, -1.93073265e-02f, 9.34752971e-02f, 1.08627661e-03f, 1.04722418e-01f,
  4.00939547e-02f, 2.29408629e-02f, 1.05883896e-01f, -2.23232340e-02f, -2.41248429e-01f, -1.06608547e-01f, 1.17307387e-01f, -4.28687260e-02f, 5.61847948e-02f, -2.92833168e-02f,
  1.34665757e-01f, -1.18039630e-01f, -2.75221821e-02f, -3.06896437e-02f, -1.14301592e-01f, -4.74916026e-02f, -1.79174691e-01f, 1.10189974e-01f, 1.69400007e-01f, -8.18467140e-02f,
  5.33228293e-02f, 1.36569962e-01f, -8.28788504e-02f, -6.80969656e-03f, -1.38806060e-01f, 6.81373477e-02f, -4.32457821e-03f, -5.25162071e-02f, -2.00246312e-02f, -6.14311993e-02f,
  -1.79765269e-01f, 3.69468778e-02f, -2.06860393e-01f, 5.88937066e-02f, 4.99124778e-03f, -1.38110295e-01f, 2.03245997e-01f, 1.00894749e-01f, 1.85246050e-01f, 2.97890842e-01f,
  -2.28046626e-01f, 1.06413580e-01f, 6.27770498e-02f, -3.25836823e-03f, -6.52213469e-02f, -1.59474149e-01f, 9.73245874e-02f, 1.80218190e-01f, -6.78284615e-02f, 1.30195066e-01f,
  1.26852721e-01f, 7.01854005e-02f, 1.18478201e-03f, -4.85513620e-02f, -5.48977666e-02f, -1.24736719e-01f, 2.53717732e-02f, 5.55972867e-02f, -7.39193559e-02f, -3.92820127e-02f,
  6.70827404e-02f, 1.00393914e-01f, -5.25198244e-02f, -4.71498333e-02f, 1.14098610e-02f, 5.32856956e-02f, 2.41636038e-02f, -8.28900337e-02f, -1.38996243e-02f, 4.22307849e-02f,
  -6.20987527e-02f, -6.46416619e-02f, -1.48236752e-01f, -4.05891538e-02f, -1.16750188e-01f, 1.22211464e-02f, 5.39912097e-02f, -6.74111955e-03f, -1.45340979e-01f, 2.21489593e-01f,
  1.47387058e-01f, 5.91482744e-02f, 2.88546644e-02f, 5.67804277e-02f, -1.18991412e-01f, 6.19882019e-03f, 1.06257088e-01f, 1.30250081e-01f, 1.84750453e-01f, -1.39576912e-01f,
  2.02378586e-01f, -1.64302543e-01f, -7.03293458e-02f, -1.05122961e-01f, -1.10539049e-01f, 1.00041218e-01f, -7.97093511e-02f, -1.83417737e-01f, -8.49858671e-02f, -1.99186146e-01f,
  1.70209240e-02f, 2.26202384e-01f, 1.70952395e-01f, -1.05795652e-01f, 8.89610127e-02f, 1.64955333e-01f, 1.48214743e-01f, 2.07981635e-02f, 1.71327367e-01f, 1.27118647e-01f,
  -4.03864831e-02f, -3.75130102e-02f, -5.40849194e-03f, -4.65850271e-02f, -2.23998398e-01f, -7.61229396e-02f, -1.00975614e-02f, 4.12419401e-02f, -1.16641484e-01f, -5.35860285e-03f,
  7.63719380e-02f, 7.52881244e-02f, -1.41597271e-01f, -6.21147826e-02f, -8.31438228e-02f, 1.44168392e-01f, -5.33055663e-02f, 1.39642134e-01f, 1.13159232e-02f, 4.38777171e-03f,
  -1.67764470e-01f, -1.34990364e-01f, -5.53212538e-02f, 3.36676352e-02f, 1.43960685e-01f, 5.67091219e-02f, 1.48688525e-01f, -2.93416582e-04f, 3.82944196e-02f, -1.02991290e-01f,
  -1.01134725e-01f, -7.11016133e-02f, -8.70070755e-02f, 1.03650719e-01f, -6.96550906e-02f, -1.31975159e-01f, 4.19810601e-02f, 1.21983752e-01f, 1.54469579e-01f, 1.33826852e-01f,
  -2.42175851e-02f, 1.29430652e-01f, -1.38618514e-01f, 1.05132096e-01f, -4.40158090e-03f, -8.98327753e-02f, 1.00595556e-01f, 2.11602703e-01f, -1.73914075e-01f, -2.43411046e-02f,
  3.97684909e-02f, -6.83663832e-03f, -3.92820267e-03f, -1.05904721e-01f, -3.11304573e-02f, -2.04254717e-01f, 6.85121045e-02f, 7.69709274e-02f, -1.30897881e-02f, 1.60499901e-01f,
  8.44669566e-02f, 2.62223557e-02f, 3.58720310e-02f, 9.43279192e-02f, 2.33936176e-01f, 3.20270807e-02f, -3.26435291e-03f, 1.21080883e-01f, 1.13067009e-01f, 1.27965361e-01f,
  2.75906883e-02f, 8.31207782e-02f, -8.55105817e-02f, -6.96827173e-02f, -4.64587845e-02f, -1.39366025e-02f, -6.01617023e-02f, -2.91134473e-02f, -8.93136412e-02f, -1.38147339e-01f,
  1.13639265e-01f, -2.81244610e-02f, -1.76945060e-01f, -7.91988149e-02f, 1.70260519e-01f, -4.92887758e-02f, -1.50816202e-01f, -1.91136189e-02f, 1.21573925e-01f, -2.48447303e-02f,
  1.77624188e-02f, -1.94574744e-02f, 1.12450048e-01f, -2.48778373e-01f, 1.96283340e-01f, 7.83614889e-02f, -1.33050203e-01f, 1.70193821e-01f, 1.54455304e-01f, -3.62762846e-02f,
  3.41315866e-02f, -2.42014956e-02f, 1.44543529e-01f, 1.87050521e-01f, -4.08313088e-02f, 2.08678022e-02f, -1.13541983e-01f, 6.40773475e-02f, -5.90561777e-02f, 1.62675586e-02f,
  -1.13273881e-01f, 1.73744395e-01f, -1.18775852e-01f, -1.07716076e-01f, -1.45282045e-01f, -1.65856481e-01f, -1.45899922e-01f, 1.28918260e-01f, -1.26156330e-01f, -1.18444726e-01f,
  -8.08083192e-02f, 4.67623472e-02f, 1.63570642e-01f, -6.05543703e-02f, -1.95010811e-01f, -2.08573528e-02f, 1.05778642e-01f, 9.64049324e-02f, 1.08065777e-01f, 7.43073691e-03f,
  -7.49494657e-02f, -8.20715129e-02f, 8.95297795e-04f, -1.08942790e-02f, -4.67654318e-02f, -2.33917926e-02f, 1.38455082e-03f, 3.54702249e-02f, -4.69527580e-02f, -6.63196221e-02f,
  -1.79068819e-02f, -1.42381206e-01f, -6.17455728e-02f, -6.83779195e-02f, -8.78068656e-02f, 3.37973498e-02f, 5.87396510e-02f, -9.05545503e-02f, -5.58619164e-02f, -1.08997956e-01f,
  1.19545469e-02f, -1.59693777e-03f, -1.06567882e-01f, -5.35808392e-02f, 1.03847191e-01f, -2.11104155e-01f, -3.43481936e-02f, 2.23943889e-01f, 3.89398895e-02f, 3.52595635e-02f,
  -7.42990524e-02f, -1.12242565e-01f, 1.14699274e-01f, -4.99053597e-02f, 9.07886028e-02f, 8.38470086e-02f, -4.95010316e-02f, -5.35089970e-02f, 1.62629202e-01f, 6.28356934e-02f,
  1.13004781e-01f, -1.32244587e-01f, 1.67201832e-01f, -2.61418045e-01f, -4.67415750e-02f, 2.99217813e-02f, -2.39812985e-01f, -1.55056998e-01f, 3.15589271e-02f, -7.81202316e-02f,
  -2.30255839e-03f, -1.54770762e-01f, -1.69792742e-01f, 5.64713590e-02f, 1.55294448e-01f, -3.43942158e-02f, -3.23688462e-02f, 1.93433195e-01f, 1.22869268e-01f, -4.72179279e-02f,
  3.81115861e-02f, 3.10746580e-02f, -1.85804099e-01f, -7.78528377e-02f, -1.09119646e-01f, -1.51061071e-02f, 3.38516315e-03f, -1.99445605e-01f, 3.74887809e-02f, -2.07170248e-02f,
  1.07023949e-02f, 9.07320809e-03f, 6.88613653e-02f, 1.19035207e-01f, -3.67363133e-02f, 9.40075219e-02f, 2.58671977e-02f, 9.65459198e-02f, 4.00029384e-02f, -1.69803891e-02f,
  -4.69736457e-02f, 8.75817388e-02f, 3.62476408e-02f, -1.16355918e-01f, 8.45110044e-02f, 3.20133637e-03f, -7.00848177e-02f, -3.45017165e-02f, -5.04472889e-02f, 7.08086938e-02f,
  -2.79897936e-02f, -3.22280787e-02f, 3.38133723e-02f, -7.75793120e-02f, -5.15125245e-02f, 1.58777326e-01f, 2.16781735e-01f, -2.01603416e-02f, -1.81905553e-02f, 6.07856996e-02f,
  -9.57798883e-02f, -9.31834243e-03f, 1.45561486e-01f, 1.32540762e-01f, 2.45072693e-01f, -1.94641754e-01f, 2.30684921e-01f, 1.46068931e-01f, -1.20582446e-01f, -1.75006807e-01f,
  1.98391601e-01f, 6.26650974e-02f, 8.84023979e-02f, 3.83739658e-02f, -1.76314428e-01f, -2.91749515e-04f, -1.84651688e-01f, 1.68212727e-02f, -8.41977596e-02f, -1.00644834e-01f,
  2.38103464e-01f, -2.16706157e-01f, -1.35349289e-01f, -1.70474984e-02f, 1.33096397e-01f, 1.96529627e-01f, 7.67491832e-02f, 6.71767071e-03f, 1.30536586e-01f, -1.31160736e-01f,
  -8.11691508e-02f, 1.53054163e-01f, 1.70496628e-02f, 7.28135109e-02f, 4.48393710e-02f, -3.01445369e-02f, -5.88618256e-02f, 6.82594301e-03f, -1.57102957e-01f, -1.00221913e-02f,
  -2.29704659e-02f, -1.89428732e-01f, -2.95307487e-02f, -6.75419569e-02f, -7.73287117e-02f, -1.62566155e-02f, -1.53277621e-01f, 9.05168056e-02f, 1.83557980e-02f, 1.22363977e-02f,
  -1.14154540e-01f, 3.46694142e-02f, -2.15001613e-01f, -6.55880347e-02f, -1.26416668e-01f, 5.25754830e-03f, -5.87320030e-02f, -2.51099793e-03f, 6.12360463e-02f, -9.68462899e-02f,
  -9.84012112e-02f, 4.07440588e-02f, -1.50727481e-01f, 1.21624149e-01f, 2.09545746e-01f, 7.67187178e-02f, -8.43381211e-02f, -6.92110136e-02f, 7.37872943e-02f, 2.02574238e-01f,
  1.42394170e-01f, -1.31144762e-01f, 2.22983614e-01f, 1.66276768e-01f, -1.65930599e-01f, -8.65259469e-02f, 6.80117011e-02f, -5.91189712e-02f, 1.55941337e-01f, -2.18532681e-02f,
  -5.35851195e-02f, 7.69044980e-02f, 8.90486464e-02f, -2.73022521e-02f, -3.66942100e-02f, 1.19272359e-01f, 1.81312010e-01f, 8.71029794e-02f, 1.97251052e-01f, -2.43948097e-03f,
  -2.15059310e-01f, 3.31357643e-02f, -2.22852573e-01f, -2.41497718e-03f, 1.30968252e-02f, -1.55847520e-01f, 7.49296229e-03f, 1.63512323e-02f, 1.16216287e-01f, -6.03392608e-02f,
  1.80336013e-02f, -6.48926049e-02f, 7.83384293e-02f, -4.64841798e-02f, -3.15851495e-02f, -2.14605071e-02f, 3.50804776e-02f, -5.89694567e-02f, -4.34167944e-02f, 1.98600683e-02f,
  -3.87349389e-02f, 1.60292730e-01f, 7.04452842e-02f, 7.69654959e-02f, -4.34968919e-02f, 1.16434179e-01f, -7.75537044e-02f, 2.86239404e-02f, -4.53238413e-02f, 5.91095956e-03f,
  -7.43911937e-02f, 4.86487187e-02f, 1.91389039e-01f, -4.37164828e-02f, -1.29439637e-01f, 4.50779051e-02f, -1.52182847e-01f, -1.12055928e-01f, 1.00975662e-01f, -4.76435535e-02f,
  -1.27150446e-01f, -1.32145509e-01f, -3.61746848e-02f, 1.08285673e-01f, -1.17264256e-01f, 1.00613855e-01f, 1.27906770e-01f, 1.42484874e-01f, -9.51293390e-03f, 1.18848328e-02f,
  7.92965591e-02f, 1.04212128e-02f, 2.38661125e-01f, 4.79307771e-02f, 9.19798836e-02f, 1.33801803e-01f, 5.74211106e-02f, -5.84876090e-02f, -9.60548371e-02f, 1.32474482e-01f,
  1.90754741e-01f, 5.83142973e-02f, -1.96205214e-01f, -6.60920143e-02f, -1.35024175e-01f, -5.70046715e-02f, -9.09524411e-02f, 7.13829175e-02f, -7.21819848e-02f, -2.04103217e-01f,
  3.31454575e-02f, -1.12689637e-01f, -4.35554460e-02f, -5.40675335e-02f, 3.71309929e-02f, -1.15853501e-02f, 1.21956587e-01f, -7.01938570e-02f, -7.10930899e-02f, 6.31216913e-02f,
  -7.41608292e-02f, -1.66622959e-02f, 1.13207012e-01f, -9.99047384e-02f, -5.14372326e-02f, 5.53823858e-02f, 1.76040068e-01f, -3.96098942e-02f, -2.03959987e-01f, -6.23776428e-02f,
  8.98084566e-02f, 7.64704868e-02f, -1.62364438e-01f, 2.99814373e-01f, -8.53762180e-02f, 2.67361989e-03f, -1.32984789e-02f, -1.40357092e-01f, 4.96713072e-02f, 4.50082123e-02f,
  -5.32485954e-02f, 6.83095828e-02f, -1.48531646e-01f, -1.91571787e-01f, 1.22190312e-01f, -9.25608501e-02f, 1.06499396e-01f, -9.88528207e-02f, 1.33438170e-01f, 8.16754531e-03f,
  -1.02339819e-01f, -1.22604430e-01f, -1.80623718e-02f, -4.77039395e-03f, 5.55104725e-02f, -2.49146055e-02f, 1.93555169e-02f, -1.49925826e-02f, -1.03479279e-02f, 2.37023845e-01f,
  1.41854495e-01f, -6.66262358e-02f, -3.62926982e-02f, 1.64730668e-01f, 1.28898457e-01f, -1.05994083e-01f, 6.98096901e-02f, -1.17578536e-01f, -3.91986631e-02f, 2.13209018e-02f,
  1.78561602e-02f, 1.42056078e-01f, -2.54123528e-02f, 6.34842291e-02f, 5.90039603e-02f, 1.63934112e-01f, -5.98088792e-03f, 3.68575528e-02f, 2.41389014e-02f, 8.70110542e-02f,
  -3.70445736e-02f, 5.46984700e-03f, -1.67711191e-02f, -7.38469660e-02f, -7.10592568e-02f, 6.03367724e-02f, -5.38950227e-02f, -7.47697428e-02f, -1.34752229e-01f, 7.47576430e-02f,
  1.59605779e-02f, -1.10789165e-01f, -8.08520094e-02f, -1.06055206e-02f, -1.99155807e-01f, -1.76978961e-01f, -3.33431177e-02f, 4.35964055e-02f, -1.35312080e-01f, -1.90222859e-02f,
  7.08154663e-02f, -6.61241338e-02f, -2.31966987e-01f, 1.60342455e-01f, -1.59742564e-01f, 1.48887679e-01f, 2.10921302e-01f, 7.80179501e-02f, -1.51121512e-01f, -2.52092294e-02f,
  1.41476944e-01f, 1.90413654e-01f, 4.58463505e-02f, -1.62730381e-01f, 2.28618398e-01f, 2.05701545e-01f, -1.79939032e-01f, -1.31347012e-02f, 1.55520290e-01f, 1.29195051e-02f,
  1.18895493e-01f, -8.36996362e-02f, -2.47583203e-02f, 9.88520458e-02f, 6.18046448e-02f, 7.34767914e-02f, -1.62053809e-01f, 8.24162364e-02f, 2.06464991e-01f, 7.79360309e-02f,
  -9.37984977e-03f, 7.15263980e-03f, -6.89498186e-02f, -8.64108652e-02f, -1.78049862e-01f, -1.36815605e-03f, 1.07282616e-01f, -6.87116385e-02f, 2.37029772e-02f, -1.13483697e-01f,
  3.93073168e-03f, 3.80810909e-02f, -3.35811414e-02f, 6.39591143e-02f, -1.66686475e-01f, 7.90493935e-02f, -9.07630920e-02f, 6.05720133e-02f, -9.53037217e-02f, 2.39481172e-03f,
  3.45853716e-02f, -4.07251082e-02f, -1.51428506e-01f, -7.10721239e-02f, -1.85050189e-01f, 6.76221997e-02f, 2.28701923e-02f, 1.04433140e-02f, 6.53704479e-02f, 9.57836583e-02f,
  -5.53749967e-03f, -1.77336574e-01f, -1.21072665e-01f, -1.57345347e-02f, 4.86771204e-02f, -1.10592274e-02f, -2.34692618e-01f, -1.13743655e-01f, -2.36730315e-02f, -1.81330070e-01f,
  1.25491574e-01f, 1.37167260e-01f, -4.29530926e-02f, -1.13271929e-01f, 3.42724994e-02f, 1.39055818e-01f, -3.31082791e-02f, 1.14342459e-02f, 5.36851212e-02f, 3.12112104e-02f,
  8.80426820e-03f, 1.09968092e-02f, 6.57260930e-03f, 1.75667673e-01f, -1.34294733e-01f, -1.22397289e-01f, -6.61983490e-02f, -2.14471847e-01f, -6.43436760e-02f, 7.86400586e-02f,
  -8.75148624e-02f, -1.75491646e-02f, -2.81933546e-02f, -2.82368381e-02f, 1.20994151e-02f, -1.19604722e-01f, 1.01887090e-02f, -5.00660986e-02f, 1.50709733e-01f, -3.95170338e-02f,
  -8.76732543e-02f, 9.81930122e-02f, 9.90464985e-02f, -1.44917518e-03f, 9.77904201e-02f, 1.06464550e-01f, 1.52277082e-01f, 1.27757996e-01f, -7.15468749e-02f, 7.73681980e-03f,
  2.60243472e-03f, 1.19049385e-01f, -8.19564909e-02f, 1.05004385e-01f, 6.21740632e-02f, 4.75738794e-02f, -1.96161017e-01f, -1.48083061e-01f, 3.19879949e-02f, 4.21521701e-02f,
  3.02325748e-02f, 2.50705052e-02f, -4.81655635e-03f, -1.32925183e-01f, -1.78219820e-03f, -1.24614827e-01f, -1.11224517e-01f, -9.01091248e-02f, 1.61221191e-01f, 1.70963407e-01f,
  -1.59326211e-01f, -4.05755360e-03f, -7.00089782e-02f, -6.45495802e-02f, 6.71816617e-02f, 1.47363469e-01f, -5.52289700e-03f, 2.59666368e-02f, 2.72536397e-01f, -1.05573153e-02f,
  2.85939444e-02f, -5.47950435e-03f, 8.59305561e-02f, 2.22540766e-01f, 8.22754949e-03f, -3.06893289e-02f, 2.78315425e-01f, 2.51361541e-02f, -1.14571936e-01f, -3.92775871e-02f,
  -2.18389884e-01f, -1.19031481e-01f, 1.11381309e-02f, -1.53329605e-02f, 7.72415921e-02f, 1.26365900e-01f, 7.08289668e-02f, 7.56876543e-02f, -1.22488827e-01f, 1.72836468e-01f,
  6.72624856e-02f, -1.98137760e-01f, 1.28183112e-01f, -2.65718363e-02f, -4.82178703e-02f, -2.29852889e-02f, 1.72147617e-01f, -1.55877158e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  4.88068355e-04f, 1.12902865e-01f, 4.63175252e-02f, 1.56730443e-01f, 6.62412345e-02f, 7.06243366e-02f, 1.76783148e-02f, 1.98347017e-01f, 1.63067132e-02f, 1.00149296e-01f,
  4.63336669e-02f, 1.18771188e-01f, -5.30807637e-02f, -1.24345563e-01f, 1.07955180e-01f, 1.33378180e-02f, -3.17932814e-02f, -4.19326350e-02f, 1.33526027e-01f, 2.21662167e-02f,
  -1.69682533e-01f, 1.00185908e-01f, 1.16626872e-03f, 4.14340049e-02f, -3.28058511e-01f, 2.83228815e-01f, 2.56698489e-01f, -1.21476591e-01f, 2.43732974e-01f, 1.37572154e-01f,
  -1.51521504e-01f, -3.43985222e-02f, 2.41081879e-01f, 2.07988620e-01f, 1.56231284e-01f, -1.68205336e-01f, 8.62828493e-02f, 4.19874527e-02f, -6.90700710e-02f, -7.86172897e-02f,
  1.42382830e-01f, 2.24832162e-01f, 2.06015944e-01f, -1.01922192e-01f, -8.64052847e-02f, -2.09757034e-02f, -9.59191397e-02f, -2.02224642e-01f, -3.68454717e-02f, -8.65739435e-02f,
  3.01165879e-01f, -6.52415212e-03f, -7.52119347e-02f, 6.29324317e-02f, 9.21622440e-02f, 1.37523890e-01f, 9.01135057e-02f, 6.63488135e-02f, 3.00672740e-01f, -7.35215470e-02f,
  -6.51467815e-02f, 3.27690929e-01f, -1.54657051e-01f, 1.67440072e-01f, 9.31567997e-02f, 3.26004438e-02f, -5.21742962e-02f, 3.28361653e-02f, 1.95629373e-02f, 5.76633438e-02f,
  2.43094459e-01f, -7.26109967e-02f, 1.94846794e-01f, 8.77876133e-02f, 6.21488206e-02f, 1.93090230e-01f, 1.65913507e-01f, 7.77683109e-02f, -2.84880996e-01f, -7.94099122e-02f,
  1.76433504e-01f, -6.02679849e-02f, -1.57495558e-01f, -7.85749033e-02f, 1.85581297e-01f, -2.33216435e-01f, 1.15919515e-01f, 1.38576761e-01f, 2.02552795e-01f, -3.18490043e-02f,
  -1.98581368e-01f, 2.27461964e-01f, 2.03589976e-01f, 9.95685682e-02f, 2.03020230e-01f, 6.89635500e-02f, -1.48296013e-01f, 2.24202082e-01f, -2.39701182e-01f, 1.62159324e-01f,
  -1.73347652e-01f, -4.84172590e-02f, 1.04139656e-01f, 4.21549305e-02f, 3.36433649e-02f, 1.53041631e-01f, -1.63888931e-01f, 1.66635215e-01f, 2.03005537e-01f, -2.28122957e-02f,
  3.24527591e-01f, 1.58654209e-02f, -1.18710890e-01f, 1.38173684e-01f, -2.42871270e-01f, -2.89051712e-01f, 5.51757216e-02f, 2.34746590e-01f, -1.47025675e-01f, -9.64631215e-02f,
  -6.51486311e-03f, 8.92515481e-02f, -1.61737442e-01f, -1.21952340e-01f, 4.45336364e-02f, -1.36573225e-01f, -1.10840261e-01f, -8.30324888e-02f, 1.32657468e-01f, 1.06345847e-01f,
  9.42343250e-02f, 7.82216154e-03f, 1.30562976e-01f, 9.41103399e-02f, 2.00909272e-01f, -3.84309962e-02f, 9.73776206e-02f, 3.57456617e-02f, 2.05197871e-01f, 8.73724073e-02f,
  -4.91929278e-02f, 1.16460815e-01f, -4.04654667e-02f, -3.08727957e-02f, -1.33099258e-01f, -1.79289147e-01f, -1.56781241e-01f, -8.80867839e-02f, 5.05826063e-02f, 2.09074855e-01f,
  2.65105572e-02f, -1.13990856e-02f, 2.59107798e-01f, -1.78312048e-01f, 4.07447778e-02f, 2.08781153e-01f, 1.05063327e-01f, 1.61124691e-01f, -1.09177418e-01f, -1.97668135e-01f,
  2.10422993e-01f, 8.76060724e-02f, 2.25799084e-01f, -1.05012484e-01f, 3.54972780e-01f, -1.24907441e-01f, -6.79632947e-02f, -1.66088507e-01f, 2.18056336e-01f, -5.41196950e-03f,
  -3.47171053e-02f, 2.65289575e-01f, 4.58241627e-02f, 8.88293386e-02f, 1.31597415e-01f, 2.72711575e-01f, 6.06597029e-02f, 3.58837582e-02f, -1.92312106e-01f, -1.26624769e-02f,
  8.49771649e-02f, 2.23155376e-02f, 2.48903245e-01f, -6.83171228e-02f, -1.24152511e-01f, 1.06355585e-01f, -2.89797574e-01f, -1.04057067e-03f, -5.80935627e-02f, -1.66078150e-01f,
  1.52503386e-01f, 1.41867280e-01f, 2.58784592e-01f, 1.18064769e-01f, 2.19844460e-01f, 4.47163805e-02f, 1.19759560e-01f, 2.78835118e-01f, -1.03587350e-02f, 1.41587079e-01f,
  1.82455197e-01f, 7.83466101e-02f, 2.46339142e-02f, 1.08406067e-01f, -6.60874601e-03f, -7.19454838e-03f, 1.26437202e-01f, 1.41776919e-01f, -5.05574839e-03f, 1.30713746e-01f,
  9.02406350e-02f, 3.82186621e-01f, -7.29980618e-02f, -1.84425816e-01f, -2.77339704e-02f, 7.91235343e-02f, 1.64128810e-01f, -3.85137722e-02f, 1.11010052e-01f, -1.90539345e-01f,
  -7.04322308e-02f, -1.57320678e-01f, -1.66705877e-01f, -1.78043486e-03f, 1.39784873e-01f, -2.60821134e-01f, -1.27566475e-02f, -5.58633134e-02f, -1.68931708e-01f, 4.82711196e-01f,
  2.39586690e-03f, -3.11513692e-01f, 4.89468008e-01f, 1.63719967e-01f, 7.83105940e-02f, 2.61833608e-01f, -2.40165275e-02f, 2.82297790e-01f, -4.18268256e-02f, -8.11322033e-02f,
  -1.90292776e-01f, -2.18777090e-01f, 2.03214020e-01f, -1.22850381e-01f, -2.04792723e-01f, -1.33802474e-01f, 1.82994660e-02f, -9.16687176e-02f, 1.62832886e-01f, 1.31801605e-01f,
  4.19239491e-01f, 5.34673370e-02f, 1.17944300e-01f, 3.53368312e-01f, 8.83787647e-02f, 1.44373640e-01f, 1.61261767e-01f, 1.72187313e-01f, -7.84800276e-02f, 1.34140917e-03f,
  6.21273462e-03f, 1.23982161e-01f, 2.38574445e-01f, -1.04883485e-01f, 2.53862381e-01f, 2.14649364e-02f, 4.89883758e-02f, 1.01825558e-01f, 2.23714828e-01f, 1.85794711e-01f,
  -2.50862211e-01f, 5.24705909e-02f, 1.01641200e-01f, -1.50732800e-01f, -2.28842854e-01f, -4.95096929e-02f, 1.08441196e-01f, -2.47868493e-01f, 2.05883250e-01f, 2.28381813e-01f,
  1.78448617e-01f, -5.72241805e-02f, 1.45145148e-01f, 2.56915152e-01f, 1.69097200e-01f, 2.75830179e-02f, 8.13300461e-02f, 7.43392855e-02f, -3.73375462e-03f, -8.08658637e-03f,
  -1.17344327e-01f, 1.75321370e-01f, 3.86132672e-02f, 3.08543351e-02f, -6.41511083e-02f, -1.09962068e-01f, 2.52579629e-01f, 2.18421251e-01f, -3.62435758e-01f, 5.03162332e-02f,
  5.06948680e-02f, 1.37972787e-01f, 3.48375708e-01f, 2.29642540e-01f, -1.59060620e-02f, 2.26706862e-01f, -8.31787810e-02f, -2.49210358e-01f, -6.06163107e-02f, 1.02679737e-01f,
  2.26129979e-01f, -3.20799798e-01f, -2.13835850e-01f, 2.26643965e-01f, -1.74109802e-01f, -4.03171256e-02f, -2.03087837e-01f, -1.06291957e-01f, 4.56696860e-02f, 9.19736922e-02f,
  -4.77556624e-02f, -8.97602458e-03f, 2.75075492e-02f, -6.18509166e-02f, -5.10228910e-02f, -1.27119243e-01f, -8.10415000e-02f, 2.80829556e-02f, -5.35017103e-02f, -9.28800777e-02f,
  -7.06117367e-03f, -7.12794289e-02f, -1.44047976e-01f, -7.20246509e-02f, 2.58319199e-01f, 2.81327099e-01f, -9.02405679e-02f, 1.20334320e-01f, 1.31212071e-01f, 8.35742801e-02f,
  -1.54988781e-01f, 4.97891866e-02f, 5.34055680e-02f, 2.17125788e-02f, -6.99269772e-02f, 1.61605343e-01f, 3.13073963e-01f, -1.95460498e-01f, -6.50736317e-02f, 2.46943370e-01f,
  2.21557338e-02f, 2.03855529e-01f, 1.66536704e-01f, 8.87034014e-02f, -9.67608094e-02f, -1.30968122e-03f, -1.90357696e-02f, 3.67804011e-03f, 5.49550429e-02f, 2.75017232e-01f,
  1.56341389e-01f, -5.89033449e-03f, 9.04410928e-02f, -8.48824009e-02f, 5.35572097e-02f, 1.73851058e-01f, -9.39612612e-02f, -2.67017007e-01f, 2.12501779e-01f, -1.30838171e-01f,
  3.61250699e-01f, 3.64469826e-01f, 1.91130951e-01f, -1.33516759e-01f, 2.39322558e-01f, 1.11810885e-01f, -1.24954879e-01f, 5.14118485e-02f, 9.38376561e-02f, 1.36065975e-01f,
  -1.12981878e-01f, 3.41376327e-02f, 1.28045171e-01f, 3.26487005e-01f, 1.32609412e-01f, 9.40054804e-02f, 6.52223080e-02f, 1.47301123e-01f, 2.61864308e-02f, 1.55463442e-01f,
  3.49954143e-02f, 1.39951408e-01f, 1.21509850e-01f, 9.16220620e-02f, -8.24242481e-04f, 1.30240411e-01f, 1.15897194e-01f, -1.48674026e-01f, -9.27258581e-02f, -1.70118272e-01f,
  4.71399948e-02f, -7.81032518e-02f, -2.47147251e-02f, -1.46672651e-01f, 6.52647913e-02f, -1.59612805e-01f, 1.06895879e-01f, -8.04379731e-02f, -2.49135256e-01f, 3.30706984e-01f,
  2.84182370e-01f, 9.60355327e-02f, 1.31219178e-01f, 7.39868507e-02f, 1.12695172e-01f, 2.16257885e-01f, 1.36550158e-01f, 2.31236368e-01f, 2.52011955e-01f, -8.91335309e-02f,
  1.56141952e-01f, -5.01782708e-02f, -1.23909950e-01f, 9.00189951e-02f, -1.00265689e-01f, -2.93196123e-02f, 5.01854755e-02f, -1.43885478e-01f, -2.83465236e-01f, -3.94602418e-02f,
  -1.40799865e-01f, 7.60565652e-03f, 3.41759413e-03f, 1.04989834e-01f, 1.72375083e-01f, 1.37112830e-02f, -5.38037270e-02f, 5.22080921e-02f, 1.91255033e-01f, 2.09876254e-01f,
  1.83191776e-01f, -5.37287965e-02f, 9.47323665e-02f, -1.11620747e-01f, 7.52618834e-02f, 1.23949639e-01f, -3.74046043e-02f, -2.61219544e-03f, 2.94393096e-02f, -8.88775140e-02f,
  1.30553648e-01f, -3.28527056e-02f, 2.22910047e-01f, 9.55001730e-03f, 9.68230814e-02f, 1.33489937e-01f, 1.21655218e-01f, 4.65804115e-02f, -8.25023837e-03f, -1.75731871e-02f,
  3.67990106e-01f, -3.18725780e-02f, -1.71350501e-03f, -2.53270894e-01f, 1.04202583e-01f, -3.83741893e-02f, 1.96149930e-01f, 5.89085482e-02f, 3.85912284e-02f, 2.72738673e-02f,
  8.80079642e-02f, 3.08328792e-02f, -2.40675360e-01f, 1.85928419e-01f, 1.14292406e-01f, 1.89556047e-01f, 1.02882937e-01f, 9.78220925e-02f, -2.04183117e-01f, 1.77815035e-02f,
  1.64653867e-01f, 2.41842434e-01f, -2.76653051e-01f, -1.66970566e-01f, -1.07576726e-02f, 1.16155915e-01f, -1.60634786e-01f, -8.73702951e-03f, -1.90597713e-01f, 6.66636750e-02f,
  -2.58398175e-01f, -1.30148781e-02f, 8.48156288e-02f, -1.38028981e-02f, 3.46363932e-01f, 2.01471642e-01f, 1.15578897e-01f, 1.68439090e-01f, 1.51783638e-02f, -1.27484491e-02f,
  1.59955733e-02f, -6.17690533e-02f, -2.70423532e-01f, 2.48634368e-01f, 4.19920921e-01f, 2.33873144e-01f, -9.72663835e-02f, 1.97504148e-01f, 3.34438354e-01f, 1.98089510e-01f,
  -7.73428530e-02f, 2.72555090e-02f, 5.61777242e-02f, -2.95426184e-03f, 1.80161312e-01f, 8.85799676e-02f, 1.93394683e-02f, 1.45266112e-02f, 8.36011842e-02f, 1.59879059e-01f,
  -8.55445638e-02f, -1.27926022e-01f, 2.92336987e-03f, -6.41977927e-03f, -1.67124748e-01f, 1.10837914e-01f, 3.11050415e-01f, 5.19728437e-02f, -2.38537654e-01f, 5.45504354e-02f,
  -2.07633257e-01f, 1.09937429e-01f, -2.59954214e-01f, 3.22450697e-01f, -2.34538600e-01f, -3.64016853e-02f, 4.50625978e-02f, 2.07550749e-01f, -1.33085791e-02f, 1.20252315e-02f,
  -2.41830826e-01f, 2.86003351e-01f, 9.95061621e-02f, -2.04932224e-02f, 8.16977546e-02f, 2.00088113e-03f, 2.07855552e-01f, 1.11930363e-01f, 7.00369179e-02f, -6.35472536e-02f,
  2.07105815e-01f, 1.24979109e-01f, -4.31997366e-02f, 1.16310090e-01f, 3.29541206e-01f, -7.56336469e-03f, 2.74402499e-01f, -1.85552835e-01f, 9.43026841e-02f, 1.43557534e-01f,
  -6.58439249e-02f, -2.79170036e-01f, 1.61427200e-01f, -1.29893169e-01f, 1.62564650e-01f, 1.80921495e-01f, 7.63676837e-02f, 1.74779519e-01f, -3.43275554e-02f, -9.76965353e-02f,
  1.98969841e-01f, -1.75196137e-02f, -7.60232508e-02f, -1.53323710e-02f, -1.03995711e-01f, 5.88093288e-02f, -1.79519169e-02f, 9.27578434e-02f, 1.22584857e-01f, 1.28002569e-01f,
  -5.75183518e-02f, 1.88178346e-01f, 1.22105554e-01f, 2.04448774e-01f, 1.02048829e-01f, 2.39027396e-01f, 4.44536917e-02f, 1.02833703e-01f, -7.95156211e-02f, -1.82844415e-01f,
  -2.41999745e-01f, -3.49150673e-02f, 1.10236377e-01f, -1.68715864e-01f, -1.02218173e-01f, -1.10781617e-01f, 1.12396106e-01f, -2.07345918e-01f, 1.09812960e-01f, -2.87279766e-02f,
  -1.29548028e-01f, 2.42997125e-01f, 1.49246961e-01f, 2.93797646e-02f, 3.42754215e-01f, 1.80887789e-01f, 4.24144343e-02f, 2.37936094e-01f, 2.27878824e-01f, 3.63910079e-01f,
  6.85940459e-02f, 5.08107580e-02f, 1.90479338e-01f, -2.71725357e-01f, -1.37859918e-02f, 9.86207798e-02f, -6.00858852e-02f, 3.42624895e-02f, -1.31712705e-01f, 8.47256407e-02f,
  -2.58709550e-01f, -1.80513889e-01f, -3.21493223e-02f, -2.18152612e-01f, 3.04086599e-02f, 1.86862305e-01f, -3.46770370e-03f, 6.98988661e-02f, -5.63678853e-02f, 1.07494503e-01f,
  2.55551845e-01f, 1.62490517e-01f, 9.76130664e-02f, 3.60212140e-02f, -5.83916008e-02f, -1.76451936e-01f, -1.65030301e-01f, -3.33219171e-02f, -1.07268877e-02f, 9.26962644e-02f,
  1.25890272e-02f, 1.49050966e-01f, 5.68435863e-02f, 2.80493461e-02f, -1.73032850e-01f, 2.35364903e-02f, -2.32168026e-02f, 2.34032180e-02f, 5.07370085e-02f, 3.30783166e-02f,
  7.53364563e-02f, 1.49946675e-01f, 1.14227820e-03f, -2.54735630e-02f, -8.71733502e-02f, -2.28268370e-01f, -9.40753967e-02f, -3.10022198e-02f, -9.83627141e-02f, -1.21505685e-01f,
  5.95475771e-02f, 5.95429689e-02f, -6.32734746e-02f, -2.24667732e-02f, 2.42192950e-02f, -9.98288691e-02f, -1.88808236e-02f, 9.96231064e-02f, -1.38313591e-01f, 7.45874345e-02f,
  3.60063881e-01f, -7.69876316e-02f, -9.20596346e-03f, -2.77641583e-02f, 2.77982861e-01f, 1.98533848e-01f, 2.41921306e-01f, 4.97274362e-02f, 6.06515184e-02f, 1.12717398e-01f,
  -2.40550205e-01f, -2.77617365e-01f, 2.45126471e-01f, 7.10110366e-02f, 8.40960741e-02f, -5.75556681e-02f, -2.51180172e-01f, -3.49461380e-03f, -1.86618119e-01f, 8.14223140e-02f,
  -1.28954396e-01f, -1.95384771e-01f, -8.06416944e-03f, 1.02761112e-01f, 3.22322607e-01f, 8.66212025e-02f, 2.06707343e-01f, 1.28031239e-01f, -4.40532677e-02f, -2.73520574e-02f,
  3.61498505e-01f, 4.80365567e-02f, -8.50989148e-02f, 1.89686581e-01f, 9.03037265e-02f, 5.78493625e-02f, 7.66222253e-02f, 9.15078372e-02f, 1.90889359e-01f, 1.13394886e-01f,
  2.53571123e-01f, 1.78062990e-02f, 1.10371165e-01f, 3.65772680e-03f, -1.38558010e-02f, 2.25933760e-01f, 8.36324245e-02f, 3.81337032e-02f, 2.23539080e-02f, 8.13981518e-02f,
  1.13268629e-01f, 1.13690205e-01f, -1.31970234e-02f, 3.46266963e-02f, 2.35389546e-02f, -6.94621801e-02f, 9.49529633e-02f, 9.00363773e-02f, 2.02947885e-01f, 5.30360080e-02f,
  -3.52105917e-03f, 4.06904556e-02f, 5.07206321e-02f, 7.17705255e-03f, 9.24232304e-02f, -8.82859230e-02f, 3.09172813e-02f, 7.64851049e-02f, -1.24446720e-01f, 1.03596881e-01f,
  -2.20492154e-01f, 1.76060066e-01f, 6.41771033e-02f, 2.94070039e-02f, 3.03679466e-01f, 1.47170320e-01f, 9.14717019e-02f, 3.89726833e-02f, 5.89341745e-02f, 1.47821665e-01f,
  2.03065902e-01f, -2.32007682e-01f, -1.45964608e-01f, -4.28868383e-02f, -4.38874448e-03f, -1.61220580e-01f, 3.55041842e-03f, 1.51180789e-01f, -2.35262811e-01f, 1.37220975e-02f,
  -1.23132758e-01f, -8.69369358e-02f, 1.02121420e-01f, -1.58585086e-01f, -1.03697903e-01f, -7.08558634e-02f, -8.70802179e-02f, -8.06112736e-02f, -5.34375496e-02f, 1.85942724e-01f,
  -1.18153375e-02f, 1.52422730e-02f, 7.31693879e-02f, -1.34833485e-01f, -6.73582181e-02f, -8.61319005e-02f, 7.71451369e-02f, -2.24806461e-02f, 9.55527276e-02f, 7.41145238e-02f,
  1.01977788e-01f, -1.35786861e-01f, 2.68381655e-01f, 1.88388377e-01f, 8.94121267e-03f, 1.25102058e-01f, 3.78051490e-01f, -5.58410026e-02f, -2.24480163e-02f, 9.66146961e-02f,
  1.74759075e-01f, 5.57536744e-02f, -3.68290767e-02f, -2.85071023e-02f, 3.66106302e-01f, -1.19944036e-01f, 8.16747453e-03f, 2.46619303e-02f, -1.46535784e-02f, -3.67606655e-02f,
  2.48369366e-01f, 4.13775146e-02f, -1.66857168e-01f, -1.02516420e-01f, 4.23596129e-02f, 2.75829554e-01f, -1.21857217e-02f, 2.80676365e-01f, 6.78542182e-02f, -2.67433614e-01f,
  2.01983020e-01f, -2.14240164e-01f, 2.09968776e-01f, 3.84994537e-01f, -1.41910434e-01f, -7.47007504e-02f, 2.70860881e-01f, 5.93279637e-02f, 3.20617080e-01f, 5.08870244e-01f,
  2.94111252e-01f, -1.83135778e-01f, 1.38434738e-01f, 1.09686069e-01f, 1.62711829e-01f, 1.67097598e-01f, 7.44465441e-02f, 3.58486921e-01f, 3.61301869e-01f, 1.76652879e-01f,
  2.03659177e-01f, 2.64768690e-01f, 1.21964388e-01f, 4.36906405e-02f, 5.17809205e-02f, 1.44289777e-01f, -1.04831479e-01f, 2.19896287e-01f, 5.79414368e-02f, 1.39579102e-01f,
  2.08142549e-02f, 1.68708258e-03f, -3.71020995e-02f, 8.57711807e-02f, -2.35029906e-02f, -2.45646592e-02f, -1.29476935e-01f, -6.86695501e-02f, -5.27129229e-03f, 5.69378491e-03f,
  -2.49844417e-01f, -3.71892303e-02f, -3.96019556e-02f, -2.86246330e-01f, -6.03470616e-02f, -8.39415491e-02f, -1.31403893e-01f, 2.80788481e-01f, -1.21276580e-01f, 3.65536176e-02f,
  -4.08924296e-02f, 8.29604715e-02f, 2.44093910e-01f, 2.70018518e-01f, -1.08573906e-01f, 5.79599850e-02f, 3.37493241e-01f, 2.02266291e-01f, 4.40251045e-02f, -8.29397440e-02f,
  1.17310457e-01f, 5.24198823e-02f, -7.53805935e-02f, 1.48776397e-01f, 1.35817319e-01f, 4.14860435e-02f, -7.90309086e-02f, -1.73285663e-01f, -4.16137204e-02f, 1.57798473e-02f,
  -1.53919503e-01f, -1.85857825e-02f, 8.04180652e-02f, -2.65007734e-01f, -1.02520287e-01f, 1.84205040e-01f, 7.87400380e-02f, 2.25351676e-01f, 8.78333151e-02f, -2.25708738e-01f,
  2.23830387e-01f, -2.17648655e-01f, -1.78132221e-01f, 3.33858803e-02f, -1.01036727e-01f, -1.78551510e-01f, 6.09655119e-02f, 1.42360374e-01f, -1.06937900e-01f, 1.87213011e-02f,
  -5.48616424e-02f, 4.05092537e-02f, 2.48099625e-01f, 1.01988606e-01f, 2.60757543e-02f, 1.24550171e-01f, 2.37769872e-01f, 7.76140913e-02f, 6.12488911e-02f, 1.28762545e-02f,
  -2.85705417e-01f, -9.78046283e-02f, -8.34749341e-02f, -1.78087503e-01f, -1.24870092e-01f, -1.56718254e-01f, -7.60386558e-03f, 1.42329842e-01f, 6.75655082e-02f, 4.01939787e-02f,
  -1.39676929e-02f, -1.30888328e-01f, 5.41077331e-02f, 1.89218715e-01f, 1.35852039e-01f, 1.27120256e-01f, 7.53770098e-02f, -9.94204134e-02f, 1.55375497e-02f, -7.13731302e-03f,
  1.71484351e-01f, 6.62136748e-02f, 4.10961509e-01f, -1.43305600e-01f, 4.47086692e-02f, -3.58097330e-02f, -2.26148084e-01f, -2.20546853e-02f, -3.07657141e-02f, -9.79370531e-03f,
  1.94719300e-01f, -2.06847847e-01f, 1.73887774e-01f, 3.33761781e-01f, 2.61198223e-01f, 1.47571728e-01f, -2.72467345e-01f, 1.03143536e-01f, 2.97278881e-01f, 2.04396501e-01f,
  1.95299730e-01f, -1.34986654e-01f, -2.30406284e-01f, 1.31031975e-01f, -1.80965424e-01f, 2.51011383e-02f, 3.13068903e-03f, -1.57341421e-01f, -2.05370020e-02f, 6.70237020e-02f,
  4.27128598e-02f, 9.85788330e-02f, 4.50119786e-02f, 1.82132617e-01f, 1.23769119e-01f, 7.56106526e-02f, 7.87645876e-02f, 1.70445696e-01f, 3.08446232e-02f, 1.68686241e-01f,
  1.09840892e-01f, 1.29731130e-02f, 7.18530267e-02f, -7.59725124e-02f, -2.80337650e-02f, -1.77131742e-01f, 5.94597943e-02f, -8.34207609e-02f, 1.24776296e-01f, 6.08002581e-02f,
  -5.83259501e-02f, 2.30621756e-03f, -7.44407997e-02f, -3.39901112e-02f, -2.03103170e-01f, 1.75714478e-01f, -8.28266293e-02f, 6.02599606e-02f, 1.63936704e-01f, -7.30543956e-02f,
  -1.25171006e-01f, 1.01116791e-01f, 6.03724644e-02f, 4.22763340e-02f, 1.23677626e-02f, -3.88556011e-02f, -8.19517206e-03f, -5.92827471e-03f, 4.14186195e-02f, -5.52170910e-02f,
  -1.46450981e-01f, 2.38749385e-01f, -2.30438937e-03f, -4.11539897e-02f, -4.94663268e-02f, -1.74536929e-01f, 1.15158848e-01f, 6.94587156e-02f, 1.47896811e-01f, 1.68476045e-01f,
  1.03905862e-02f, 1.17800668e-01f, 3.41128148e-02f, 1.06820144e-01f, -1.34209812e-01f, -7.83625431e-03f, 1.75231084e-01f, 5.91460019e-02f, 2.21407503e-01f, 7.18313754e-02f,
  1.60340741e-01f, 2.65573502e-01f, -2.19255537e-02f, -7.70110413e-02f, 7.09146336e-02f, 1.28997192e-01f, 5.05164117e-02f, 1.83795333e-01f, 1.84232071e-01f, 2.38947138e-01f,
  1.08778909e-01f, 3.16747308e-01f, 1.05280869e-01f, 1.18657686e-01f, 1.74418420e-01f, 9.85860676e-02f, 2.52755787e-02f, 5.04406132e-02f, -7.98504949e-02f, -2.44852781e-01f,
  -8.97430405e-02f, -2.16144904e-01f, -3.01239360e-02f, 4.04036529e-02f, -1.28938869e-01f, 1.97729886e-01f, -1.15798339e-01f, 3.41476053e-02f, -2.58267909e-01f, 7.14930743e-02f,
  -1.09155849e-01f, 1.78146467e-01f, 1.48146361e-01f, -3.99922431e-02f, -1.55226424e-01f, -2.16605458e-02f, -1.16616236e-02f, -4.41136062e-02f, 3.06293309e-01f, -2.97512673e-02f,
  1.44035429e-01f, 1.56523287e-02f, 5.33232987e-02f, -2.90056229e-01f, -1.51001036e-01f, 3.15177858e-01f, 7.27609769e-02f, -5.98943643e-02f, -6.68724179e-02f, -2.25481391e-01f,
  1.91816077e-01f, 2.64317006e-01f, 1.90530449e-01f, 1.25162512e-01f, -7.14558885e-02f, -1.84625797e-02f, -2.42859051e-02f, 2.03535989e-01f, -8.32254514e-02f, -8.68935287e-02f,
  2.33647581e-02f, 3.67773958e-02f, 3.26191336e-01f, 3.48424055e-02f, 5.14190271e-02f, 2.90873319e-01f, -7.42561817e-02f, -3.37944329e-02f, 1.15359895e-01f, 1.59767598e-01f,
  1.87961978e-03f, 5.92043474e-02f, -1.49905905e-01f, 7.89753497e-02f, 1.93202235e-02f, 5.92774823e-02f, -2.77764350e-02f, 5.72976694e-02f, 3.49339843e-02f, 7.51580223e-02f,
  -1.11201711e-01f, -3.22619155e-02f, -2.08150908e-01f, 2.16501206e-01f, 1.24390014e-01f, 1.12159230e-01f, -6.19158112e-02f, -3.77970338e-02f, 1.07234120e-01f, -2.49960586e-01f,
  -1.21319517e-01f, -1.89390220e-02f, 4.24270749e-01f, -1.21448830e-01f, -3.35867435e-01f, -4.19527851e-02f, -5.58740161e-02f, -6.23301007e-02f, 3.19836944e-01f, 1.50538117e-01f,
  -1.68004200e-01f, -9.32092443e-02f, -7.14074373e-02f, 3.37199807e-01f, -1.63929939e-01f, -6.87370598e-02f, 3.17650795e-01f, 1.63041294e-01f, 8.89930204e-02f, -1.16504729e-01f,
  1.44318640e-01f, 3.30574363e-01f, 8.10350403e-02f, 1.77314188e-02f, -2.71212887e-02f, -2.52491057e-01f, -1.01669356e-01f, 1.00648724e-01f, -2.26805136e-01f, 1.76110286e-02f,
  1.37101352e-01f, 1.51243061e-01f, -7.59048685e-02f, -9.99966413e-02f, -5.99373244e-02f, -1.42085612e-01f, -8.58327597e-02f, -5.68249710e-02f, -8.32847953e-02f, -1.50268495e-01f,
  1.64830148e-01f, -1.07083693e-01f, 2.57811397e-02f, -3.34137864e-02f, 1.16187253e-03f, 3.37777324e-02f, -4.26444449e-02f, 3.30288634e-02f, 9.58620906e-02f, -2.45803650e-02f,
  1.41987473e-01f, 4.63037454e-02f, -4.75684218e-02f, -3.42783495e-03f, 1.61400735e-01f, -1.28004625e-02f, -2.70310581e-01f, -1.25702009e-01f, 1.71047539e-01f, -1.15142569e-01f,
  -2.09427714e-01f, -1.66421682e-01f, 1.71099693e-01f, -2.50163525e-01f, 1.86527044e-01f, 1.66480076e-02f, -1.45376712e-01f, 1.97542563e-01f, 9.52679440e-02f, 1.70233831e-01f,
  1.56280607e-01f, 2.17150882e-01f, 1.57162681e-01f, 2.93798000e-01f, -2.69029234e-02f, 3.00275832e-01f, -3.56778763e-02f, 1.52647540e-01f, 1.64825693e-01f, -3.45150560e-01f,
  -4.88336645e-02f, 1.20984040e-01f, -2.98869640e-01f, -4.38811351e-03f, -3.23457867e-01f, -9.22449864e-03f, -2.69418471e-02f, -1.16129577e-01f, 2.35048532e-01f, 2.65495211e-01f,
  -1.54977283e-02f, 2.43185312e-01f, -1.51178017e-01f, -1.04351245e-01f, -5.77573404e-02f, 1.09357119e-01f, 1.28604546e-01f, 1.29194498e-01f, 1.01291254e-01f, 9.30277035e-02f,
  -3.97055089e-01f, -5.16021661e-02f, -5.11200726e-03f, -1.84852690e-01f, -6.69216514e-02f, -1.10872343e-01f, 1.03009105e-01f, 7.49348253e-02f, 4.36722711e-02f, 3.72138470e-02f,
  -1.58441767e-01f, 3.32252309e-02f, -3.00013442e-02f, -4.77175787e-02f, -3.60210240e-02f, -1.20708004e-01f, 2.73730848e-02f, 4.75193858e-02f, 2.38446053e-02f, 1.12335786e-01f,
  -1.04245126e-01f, -1.33780330e-01f, -9.64784026e-02f, 5.98973632e-02f, -2.33222678e-01f, -1.13998190e-01f, -5.00424169e-02f, -2.77505582e-03f, -1.30827054e-01f, 1.22898649e-02f,
  6.10734299e-02f, 2.63597611e-02f, -2.19696805e-01f, 2.40502596e-01f, -2.84035236e-01f, 4.15972881e-02f, 3.23277414e-01f, 1.60093512e-02f, -2.25153729e-01f, -9.55371633e-02f,
  2.99794912e-01f, 3.53109837e-01f, 1.28447205e-01f, -1.57006793e-02f, 1.85458392e-01f, 2.19313741e-01f, -2.91713864e-01f, -1.55174926e-01f, 1.89978048e-01f, -2.84115225e-02f,
  2.78144121e-01f, -1.61684558e-01f, 8.03345069e-03f, 2.87353575e-01f, -3.89215946e-02f, 3.72448843e-03f, -1.70923725e-01f, -5.39495274e-02f, 1.43461004e-01f, 2.07807690e-01f,
  6.09265305e-02f, 8.24581534e-02f, -3.45063917e-02f, -1.75373554e-01f, -5.87476082e-02f, 5.27637964e-03f, 7.14125782e-02f, -1.74114347e-01f, -2.29830071e-02f, -1.26029626e-01f,
  1.97291672e-01f, 1.30047008e-01f, 1.74424469e-01f, 1.26170695e-01f, 2.51128133e-02f, 1.72624394e-01f, 6.62822574e-02f, 2.01964691e-01f, 2.83431187e-02f, 2.05449253e-01f,
  1.15064643e-01f, 1.08210638e-01f, -1.52933002e-01f, 3.61907259e-02f, -1.21117689e-01f, -1.28190130e-01f, -1.00514956e-01f, 3.75390761e-02f, -3.87391075e-02f, 3.68285291e-02f,
  -2.34955717e-02f, 8.41652676e-02f, -2.14829445e-01f, -1.76989343e-02f, 1.49396986e-01f, -2.45059393e-02f, -2.73696512e-01f, 8.25286806e-02f, -9.04272571e-02f, -4.72616442e-02f,
  1.46545157e-01f, -2.98860744e-02f, -8.22230577e-02f, -1.69853553e-01f, 2.95242161e-01f, 1.96108952e-01f, -5.97407818e-02f, 8.43646154e-02f, 2.48594910e-01f, -2.01130193e-02f,
  -2.67546512e-02f, 5.86943999e-02f, 1.68392837e-01f, 2.32752517e-01f, 4.52957079e-02f, -8.59305337e-02f, 7.43066967e-02f, 1.16982266e-01f, 1.12886913e-02f, 5.30804917e-02f,
  -1.65230200e-01f, 1.87257081e-02f, 9.86079797e-02f, 1.59917668e-01f, -1.06890000e-01f, -7.11899623e-02f, 6.15348034e-02f, 4.90370253e-03f, 2.49164358e-01f, 8.57129395e-02f,
  9.74434540e-02f, 1.04111046e-01f, 3.61885577e-02f, -8.53271708e-02f, 1.99394479e-01f, 1.95922643e-01f, 7.00586662e-02f, 1.59036443e-01f, -7.56399557e-02f, 1.60080686e-01f,
  -1.72979403e-02f, 2.18386441e-01f, -5.12702502e-02f, 1.49378136e-01f, 1.26081303e-01f, 3.20734605e-02f, -4.48306389e-02f, -1.40152887e-01f, -1.21615045e-01f, -1.44240215e-01f,
  -6.75571263e-02f, -1.31147588e-02f, 4.28590318e-03f, -1.30035669e-01f, 5.25698327e-02f, -1.72605395e-01f, -7.36487284e-02f, -1.41451389e-01f, -9.81266722e-02f, 2.13311970e-01f,
  -1.45698786e-01f, 2.50524288e-04f, -2.55241315e-03f, -4.71404418e-02f, 5.93503863e-02f, 2.38915950e-01f, -2.00903453e-02f, -6.10991381e-02f, 3.92704368e-01f, -9.29441154e-02f,
  3.17315578e-01f, 2.40086336e-02f, -9.76384152e-03f, 4.98349704e-02f, -1.62184760e-01f, -5.24299331e-02f, 4.38080664e-04f, -1.11375945e-02f, -2.67078698e-01f, -5.79471849e-02f,
  -2.10752681e-01f, 1.81226328e-01f, 1.50492966e-01f, 1.17897332e-01f, 2.58733947e-02f, 1.73166707e-01f, 5.31967506e-02f, -4.73879352e-02f, 1.70605823e-01f, 2.08352789e-01f,
  2.74283111e-01f, -1.35950416e-01f, 1.22955449e-01f, 5.24931736e-02f, 2.89197508e-02f, 1.47418573e-01f, 2.30893791e-01f, -1.04700379e-01f, 1.06476784e-01f, 1.58518031e-01f,
  2.70997174e-02f, 9.22401026e-02f, -2.45804768e-02f, 1.00622527e-01f, 3.62976044e-02f, 3.40727940e-02f, 9.18094516e-02f, 1.24604926e-01f, 2.78194137e-02f, 8.45181104e-03f,
  -4.02700305e-02f, -1.10108115e-01f, -1.24123491e-01f, 2.48725712e-01f, 1.27123669e-01f, 7.29332119e-02f, -7.86488280e-02f, 6.84132576e-02f, 8.88847411e-02f, -4.59475607e-01f,
  6.17190972e-02f, -9.63217616e-02f, 1.89553335e-01f, 2.15439126e-01f, -6.38594627e-02f, -5.69968596e-02f, -7.42899533e-03f, -1.05510511e-01f, 1.70813188e-01f, 3.57476801e-01f,
  -6.02925122e-02f, 1.04218848e-01f, 2.85974890e-02f, 5.68740703e-02f, -1.07194623e-02f, 1.72357187e-02f, 3.43196765e-02f, 1.98726624e-01f, 1.85249016e-01f, -9.50849578e-02f,
  -2.17233226e-01f, 2.36616656e-01f, -2.48093352e-01f, 1.93592802e-01f, -3.66582870e-02f, -1.20241493e-01f, 1.08140141e-01f, 5.13904318e-02f, 6.74046203e-02f, 1.55781627e-01f,
  -1.23886261e-02f, -5.37599064e-02f, 4.79438081e-02f, 2.03494951e-01f, 1.30663291e-01f, -1.61847085e-01f, -1.37599275e-01f, 3.16874832e-02f, -2.12412536e-01f, -1.09046131e-01f,
  2.52533346e-01f, -1.05217263e-01f, -5.91821522e-02f, 1.33140773e-01f, -1.49933146e-02f, -9.87560451e-02f, 1.67179912e-01f, 2.01847628e-02f, -5.62090520e-03f, -7.19169900e-02f,
  2.11827844e-01f, 2.41340720e-03f, 9.70402434e-02f, 1.40874818e-01f, 3.48180264e-01f, 1.07004419e-02f, 8.95065069e-02f, -1.06044091e-01f, 2.24045198e-02f, -1.70753255e-01f,
  3.07224572e-01f, 1.00943290e-01f, -1.94740836e-02f, 2.04955980e-01f, 2.24661887e-01f, 1.73712119e-01f, -2.58297592e-01f, -7.96911120e-02f, 4.20553476e-01f, 1.40418440e-01f,
  2.39699185e-01f, -1.55963039e-03f, -2.09819987e-01f, -4.70213220e-02f, 1.45048127e-01f, 1.12989277e-01f, -2.96093404e-01f, -1.13903880e-01f, 5.07062301e-02f, 2.78038025e-01f,
  -1.70689747e-01f, -1.29605740e-01f, 4.50451709e-02f, 1.13485113e-01f, -1.84903324e-01f, -2.86548406e-01f, 1.55211523e-01f, 2.07483619e-01f, 2.39411846e-01f, 1.94401070e-01f,
  1.74662501e-01f, 1.94685876e-01f, 1.58652633e-01f, 8.80334377e-02f, 5.17799612e-03f, -1.06683217e-01f, 9.80247408e-02f, -1.87300652e-01f, 5.73749542e-02f, 3.11003834e-01f,
  9.67000797e-03f, 2.49847010e-01f, 3.18573475e-01f, 2.70634443e-01f, -1.00495212e-01f, 3.32616270e-01f, 1.31897163e-02f, 5.27154766e-02f, 6.87384307e-02f, 1.47541061e-01f,
  -4.98733334e-02f, 6.96755722e-02f, 2.33250093e-02f, -4.73570684e-03f, 5.26152439e-02f, -5.03098890e-02f, -4.62120697e-02f, 9.88910124e-02f, -6.33448884e-02f, 1.18751507e-02f,
  1.65567577e-01f, 1.53456032e-01f, 3.23915295e-02f, 2.24036038e-01f, -4.01531011e-02f, 1.66174233e-01f, -9.93463323e-02f, -1.62970811e-01f, -2.22712196e-03f, -4.52788323e-02f,
  -1.11948855e-01f, 2.85616785e-01f, 1.63173333e-01f, -1.08916402e-01f, -1.29135966e-01f, 1.29253998e-01f, 1.68270931e-01f, 2.75387108e-01f, 8.88744276e-03f, 3.84257920e-02f,
  -1.41373351e-02f, 2.24066779e-01f, -2.39328280e-01f, 1.16176799e-01f, 1.95979595e-01f, 2.85489023e-01f, 1.53947279e-01f, 2.09009618e-01f, 2.58423597e-01f, -1.73760623e-01f,
  8.83192867e-02f, 6.91637583e-03f, -7.49810934e-02f, -3.29544395e-01f, -1.55018002e-01f, -1.73440799e-01f, 3.20796788e-01f, -2.22252369e-01f, -1.17835931e-01f, 2.58570492e-01f,
  -7.77022690e-02f, 2.26431713e-01f, -5.79919433e-03f, -1.88788474e-01f, 3.34622890e-01f, -2.28722826e-01f, -1.61114231e-01f, 1.27640679e-01f, -1.00094579e-01f, 1.54443551e-02f,
  -2.31127138e-03f, 3.53363529e-02f, 1.65519100e-02f, -8.18897039e-02f, 1.66363046e-01f, 4.90471981e-02f, -1.73179491e-03f, -7.31229112e-02f, 1.31071554e-02f, -2.24626914e-01f,
  1.36495560e-01f, -8.71100836e-03f, 3.49468440e-02f, 2.09282562e-01f, 2.96513259e-01f, 6.43591508e-02f, -1.95537031e-01f, 9.32802409e-02f, -5.22266701e-02f, 1.34774640e-01f,
  -2.77714133e-01f, 3.01908851e-01f, -7.04853907e-02f, 1.28181994e-01f, 7.98975467e-04f, -7.13896304e-02f, 2.66235352e-01f, 1.12778686e-01f, -3.03588480e-01f, 1.08279146e-01f,
  -5.06769959e-03f, -9.57918912e-02f, 7.72778094e-02f, -2.04622179e-01f, 1.46820635e-01f, 5.03002629e-02f, 2.41831578e-02f, 1.82121083e-01f, 1.09843343e-01f, 3.90433334e-03f,
  1.17882796e-01f, 1.50219277e-01f, 2.55989254e-01f, -2.57338345e-01f, 4.47424173e-01f, 1.75096303e-01f, 1.53131247e-01f, 2.65506506e-01f, 7.17489347e-02f, -2.59343922e-01f,
  2.27394626e-01f, 6.58423752e-02f, 2.16730207e-01f, 1.30681008e-01f, 1.34009942e-01f, -1.39064625e-01f, -3.66362989e-01f, 7.68432468e-02f, 2.02377424e-01f, 9.65100676e-02f,
  -7.75139779e-02f, -8.44553858e-03f, -8.77569318e-02f, 2.23782331e-01f, 1.60987794e-01f, 1.17681094e-01f, 5.71826622e-02f, 1.93219870e-01f, 2.21882999e-01f, 1.32437900e-01f,
  1.58957675e-01f, 1.48867548e-01f, 1.59440026e-01f, 1.63666561e-01f, 1.99511394e-01f, 1.62827522e-01f, -1.05001777e-01f, 3.10792811e-02f, 2.01700628e-02f, -2.24693209e-01f,
  -8.81543532e-02f, -1.63021877e-01f, -5.66980988e-03f, -1.79861769e-01f, -9.94736627e-02f, 3.03071350e-01f, -5.06795831e-02f, -1.37242477e-03f, -8.73101652e-02f, -5.98893426e-02f,
  -8.35322365e-02f, 1.34014606e-01f, 2.47614384e-01f, 2.57177986e-02f, 2.36663874e-02f, -1.40511960e-01f, 1.31041640e-02f, 9.60231870e-02f, 3.10950965e-01f, -3.25792506e-02f,
  1.14712335e-01f, -5.08893132e-02f, 1.01479486e-01f, -1.11818381e-01f, -8.93849880e-02f, 1.72360778e-01f, 2.83854663e-01f, -5.95738851e-02f, -9.97504219e-03f, -1.20049529e-01f,
  -9.09639639e-04f, 5.14663123e-02f, 2.16031424e-03f, 3.78563106e-02f, -5.65669872e-02f, -3.42185162e-02f, 4.87057306e-02f, 1.69605717e-01f, -7.74130672e-02f, -9.19765905e-02f,
  -6.93336055e-02f, -9.82072484e-03f, 2.62976766e-01f, -1.15456372e-01f, 5.93184158e-02f, 1.23600572e-01f, -1.36262447e-01f, -6.75685182e-02f, 1.10755749e-01f, 9.05019343e-02f,
  1.62341401e-01f, 7.03843087e-02f, 1.52824730e-01f, 2.27413312e-01f, 2.02631336e-02f, 1.13886639e-01f, 7.11033344e-02f, 8.15227479e-02f, 5.65233007e-02f, 1.49053782e-01f,
  -1.01916291e-01f, -1.59846358e-02f, 1.26021758e-01f, 2.13548124e-01f, 4.98089604e-02f, 8.06012936e-03f, 2.45626137e-01f, 2.84508079e-01f, -3.71725205e-03f, -7.48934969e-02f,
  -2.15530004e-02f, 2.28311494e-02f, 9.95161906e-02f, 1.25990376e-01f, 1.65531427e-01f, -9.39508975e-02f, 1.77207515e-01f, -4.86062840e-02f, -1.84586629e-01f, 3.28964256e-02f,
  2.26868957e-01f, 1.10548370e-01f, -6.00125939e-02f, -7.64235109e-02f, -8.85353982e-02f, 2.45988697e-01f, -1.03295185e-01f, -1.70802817e-01f, 4.45091873e-01f, 2.33517155e-01f,
  2.28995271e-02f, 2.19307035e-01f, -1.64435536e-01f, 2.19886184e-01f, 3.82341295e-02f, -2.42710277e-01f, -1.06663376e-01f, -6.92163855e-02f, 2.03278244e-01f, -9.04235244e-02f,
  -2.46651500e-01f, -9.87170786e-02f, 1.02609042e-02f, -4.91394736e-02f, 1.49613976e-01f, 1.73106253e-01f, 3.00928771e-01f, -1.69665571e-02f, -8.51092339e-02f, 3.07559341e-01f,
  8.64541978e-02f, 1.79158255e-01f, -3.90770435e-02f, 1.04398519e-01f, 7.26628155e-02f, 1.27167851e-01f, 8.15559924e-02f, 7.27538078e-04f, 8.36615637e-02f, 2.46761501e-01f,
  3.54237333e-02f, 2.90767670e-01f, 1.33915678e-01f, 1.87852159e-02f, -1.90770745e-01f, -1.98038235e-01f, -1.52815944e-02f, -1.32532537e-01f, -5.29086664e-02f, -1.98932841e-01f,
  2.68365711e-01f, -7.47618377e-02f, -5.43497270e-03f, 2.49478489e-01f, 2.13156138e-02f, -5.29654138e-02f, -1.77981824e-01f, -9.77753773e-02f, 1.20396331e-01f, -2.02010721e-02f,
  3.22728425e-01f, 1.23957396e-01f, -2.20838651e-01f, -4.94401231e-02f, 2.76581585e-01f, 1.69098467e-01f, 6.14028834e-02f, -2.12688446e-01f, 2.08339944e-01f, -1.12717390e-01f,
  -7.94574842e-02f, -2.50206105e-02f, -6.86793178e-02f, 9.10404101e-02f, 3.04694343e-02f, 2.50592418e-02f, -1.48758888e-01f, -1.45241216e-01f, 3.22741480e-03f, -1.14902921e-01f,
  1.62048697e-01f, 1.77614376e-01f, 3.45435040e-03f, 3.15687865e-01f, 1.32390663e-01f, -8.60281065e-02f, 3.00674140e-02f, 2.52284724e-02f, 2.28292808e-01f, 2.35863894e-01f,
  8.23455676e-02f, 1.63657591e-01f, 1.90558165e-01f, 2.42479488e-01f, 1.10648774e-01f, 2.74543107e-01f, 1.76273704e-01f, 1.00373589e-01f, 7.52186477e-02f, 1.24345846e-01f,
  1.20635055e-01f, 7.58332238e-02f, 2.89615095e-01f, 1.38416529e-01f, 1.18194027e-02f, 2.40909755e-01f, 2.32172444e-01f, 1.15243010e-01f, -1.80525288e-01f, -3.14594276e-04f,
  -2.00526118e-01f, 1.18129246e-01f, 3.60954627e-02f, -5.94196692e-02f, -3.45286709e-04f, -1.48685873e-01f, -6.22796360e-03f, 1.21393591e-01f, -3.81216295e-02f, 5.06309904e-02f,
  2.23544687e-01f, -7.32788891e-02f, -1.28698453e-01f, 1.64108783e-01f, 2.26472035e-01f, -7.00462386e-02f, 3.86390300e-03f, 7.79774860e-02f, 4.47110832e-02f, 1.28046540e-03f,
  1.37584507e-01f, 1.23603836e-01f, 9.52010676e-02f, -8.84254053e-02f, 2.43838415e-01f, 3.81051041e-02f, 9.55703333e-02f, 2.15549633e-01f, -5.43588996e-02f, 1.48044258e-01f,
  5.86229302e-02f, -7.25997686e-02f, 2.87464321e-01f, 7.89431185e-02f, 3.48953426e-01f, 1.97447717e-01f, -1.32124335e-01f, 3.66106004e-01f, 2.70381570e-01f, 1.36622593e-01f,
  -1.17271736e-01f, -1.31259486e-01f, -2.33018160e-01f, 2.23011225e-02f, -2.32662968e-02f, 1.05426773e-01f, -2.02996731e-01f, -1.45496801e-01f, 2.50365943e-01f, -1.20765083e-02f,
  7.86067918e-02f, 6.87982142e-02f, 8.16977769e-02f, 1.17519028e-01f, 1.12305850e-01f, 5.56321032e-02f, 4.06293422e-02f, 1.51169896e-01f, 8.60807300e-02f, 2.43110694e-02f,
  1.02704406e-01f, 8.51377025e-02f, -3.03926151e-02f, -1.99881569e-01f, 1.20367989e-01f, 2.61701964e-04f, -7.35783651e-02f, -1.01088891e-02f, 1.38531506e-01f, -7.71704242e-02f,
  -1.33114055e-01f, 1.56081840e-01f, 1.25221059e-01f, -2.18614866e-03f, -2.26195008e-01f, 1.94333076e-01f, 3.00791949e-01f, -6.19742312e-02f, 2.17321232e-01f, 1.10098295e-01f,
  -1.95840716e-01f, -6.12019747e-02f, 3.16369802e-01f, 2.60201603e-01f, 2.44003043e-01f, -3.08788687e-01f, 2.66192347e-01f, -1.58183705e-02f, -2.36920372e-01f, -1.04429975e-01f,
  6.81577027e-02f, 4.23572510e-02f, 1.60821110e-01f, -1.78968862e-01f, -1.79678693e-01f, 8.58789831e-02f, -2.02689156e-01f, -3.25374231e-02f, 4.54107784e-02f, -1.18483856e-01f,
  2.48496249e-01f, 1.36067256e-01f, -1.05505437e-02f, -1.56267397e-02f, 1.69755936e-01f, 2.56565154e-01f, 1.42440572e-01f, 2.97118258e-02f, 1.28883719e-01f, -1.50155975e-02f,
  -5.39913066e-02f, 1.49220064e-01f, -5.55390529e-02f, 8.46449509e-02f, 6.17959015e-02f, 4.62688431e-02f, 7.52225369e-02f, -4.25259545e-02f, 1.38617083e-02f, -2.10283697e-02f,
  4.02896106e-02f, 5.63983768e-02f, 8.40829536e-02f, -3.01990169e-03f, 1.60055324e-01f, 8.17924738e-02f, -4.97279428e-02f, 1.57957882e-01f, 1.15031237e-02f, -7.01177642e-02f,
  -8.73473361e-02f, -4.54992428e-02f, 4.18932103e-02f, 1.08966500e-01f, 3.23838517e-02f, 2.74183542e-01f, -1.22073039e-01f, 3.49163660e-03f, 3.56273562e-01f, -4.03578639e-01f,
  4.08549532e-02f, 1.31242141e-01f, -2.27591410e-01f, 1.14762910e-01f, -2.23699845e-02f, -2.75452226e-01f, 1.56737462e-01f, -1.90769508e-01f, -5.49060591e-02f, 6.22586161e-02f,
  1.56684890e-01f, 1.19067162e-01f, 7.50317946e-02f, -1.03627913e-01f, 9.67097953e-02f, -1.92452475e-01f, 9.78439823e-02f, 3.38832855e-01f, 3.35257322e-01f, 9.15246457e-02f,
  1.93000630e-01f, 2.74634719e-01f, -1.63404066e-02f, -5.99440467e-03f, -2.03263104e-01f, -8.48681573e-03f, 1.72441125e-01f, -1.76516082e-02f, 1.35703325e-01f, -1.44237280e-01f,
  1.31544921e-05f, 1.82688043e-01f, -2.10195944e-01f, 2.37240404e-01f, 3.32564563e-01f, -3.76542681e-03f, 7.90083706e-02f, 3.31441492e-01f, 1.33438036e-01f, 5.50809912e-02f,
  1.67655766e-01f, 6.67016879e-02f, -7.14081386e-03f, 2.72950381e-02f, 1.13054849e-01f, 2.87599228e-02f, 1.02298468e-01f, -4.08122912e-02f, 3.76456864e-02f, 1.79590315e-01f,
  -6.04026876e-02f, -1.22456253e-01f, 1.25751421e-01f, -5.41468970e-02f, -7.33033642e-02f, 5.35742678e-02f, -8.14769343e-02f, -1.26867846e-01f, -4.46263701e-02f, 2.24487372e-02f,
  -5.81211708e-02f, -4.74648625e-02f, 1.33055210e-01f, 1.09901987e-01f, -2.74206977e-02f, 9.02235415e-03f, -7.20684379e-02f, 2.08612114e-01f, 2.42452592e-01f, -1.33171827e-01f,
  1.03963226e-01f, 1.79309830e-01f, 2.75654137e-01f, -4.83093737e-03f, 1.20390996e-01f, -1.25012800e-01f, 1.59848496e-01f, 2.08666265e-01f, 3.95309832e-03f, -1.79082289e-01f,
  3.60682875e-01f, 8.78803134e-02f, 8.06899071e-02f, -1.04188733e-03f, -2.67000705e-01f, -1.53886229e-01f, -1.78061441e-01f, -1.85833141e-01f, 7.43219927e-02f, -1.52063593e-01f,
  1.40357288e-02f, 1.71557054e-01f, 7.01059848e-02f, 2.96251923e-01f, 1.54184364e-02f, -1.81551352e-01f, -1.45800626e-02f, -2.03940153e-01f, 3.82427834e-02f, -1.85060278e-01f,
  -8.47074017e-02f, -9.96782258e-02f, 2.44981185e-01f, 6.45140260e-02f, 1.55702293e-01f, 1.58800948e-02f, 1.25081897e-01f, 1.25219032e-01f, 7.98556507e-02f, 1.89928651e-01f,
  7.08684027e-02f, -7.93736354e-02f, 1.96959704e-01f, 8.40131268e-02f, -2.34143678e-02f, 1.58449501e-01f, 1.58833936e-01f, 5.65703250e-02f, -2.43397444e-01f, -7.07354099e-02f,
  -1.80721983e-01f, 1.49915785e-01f, -2.30087936e-01f, 1.27869979e-01f, -1.17538773e-01f, 1.16900802e-01f, 1.15324475e-01f, -6.03424981e-02f, 8.36309567e-02f, 1.19684130e-01f,
  -1.71573117e-01f, 7.50651956e-02f, -2.41322726e-01f, 3.93840997e-03f, 5.63873947e-02f, -2.41693184e-01f, 3.48863065e-01f, -1.23607084e-01f, 1.63508072e-01f, 1.17601663e-01f,
  -1.03104331e-01f, -2.75157034e-01f, 2.84198940e-01f, 2.30206877e-01f, 1.19766071e-01f, -4.64031734e-02f, 4.37156521e-02f, 1.88686162e-01f, 1.44203315e-02f, 3.33437234e-01f,
  3.96279525e-03f, -2.81262577e-01f, 1.39250845e-01f, -7.89524764e-02f, -4.88950871e-02f, 9.92656946e-02f, 2.04042852e-01f, -1.15262181e-01f, -1.49026945e-01f, -3.62175032e-02f,
  2.52328843e-01f, 2.53457371e-02f, -2.55106181e-01f, 1.74376503e-01f, 1.18413426e-01f, 4.76456918e-02f, -9.38494690e-03f, -1.79171339e-02f, 1.65821150e-01f, 3.63289155e-02f,
  1.45147920e-01f, -5.36648259e-02f, 9.46092512e-03f, 6.18802086e-02f, -4.61840332e-02f, 6.97211400e-02f, 8.33997801e-02f, 9.31524299e-03f, 2.29528230e-02f, 1.50231704e-01f,
  9.95513201e-02f, 6.18497916e-02f, 2.87984945e-02f, 1.94266796e-01f, 2.30375975e-01f, 1.93669736e-01f, -9.20215808e-03f, 1.77710354e-01f, -1.91746011e-01f, 4.11308184e-02f,
  2.56867290e-01f, -2.88321078e-01f, -2.02001259e-01f, 1.12405885e-02f, -2.33295649e-01f, -1.04741797e-01f, -8.81421193e-02f, -1.31146148e-01f, -8.02446604e-02f, -2.54832804e-01f,
  -2.08050415e-01f, 4.32464946e-03f, -9.86493528e-02f, 1.39065832e-01f, 2.07402676e-01f, 1.47457168e-01f, -5.31776845e-02f, -6.29146248e-02f, 4.76312190e-02f, 2.00924993e-01f,
  4.05439824e-01f, 4.83956151e-02f, 1.70486107e-01f, 2.47251585e-01f, 2.36688092e-01f, 2.75627207e-02f, -2.06984654e-01f, 3.57167721e-01f, 2.52530158e-01f, -2.64438689e-02f,
  -3.58951837e-01f, -1.77489221e-01f, 8.04216787e-02f, 1.16893150e-01f, -9.11152810e-02f, 3.49792540e-01f, 2.56622970e-01f, 2.14454234e-02f, 2.11382911e-01f, 4.37402911e-02f,
  1.81995556e-01f, 1.23246670e-01f, 1.36607453e-01f, 1.56647131e-01f, 1.63550854e-01f, 8.14144090e-02f, 1.03106633e-01f, 1.41486794e-01f, -1.34244673e-02f, 1.04195587e-01f,
  1.34014025e-01f, 7.12785795e-02f, -2.15007395e-01f, 5.24147637e-02f, 1.72175661e-01f, 3.24280649e-01f, -1.26510793e-02f, 2.50448704e-01f, 1.68069407e-01f, 1.83325320e-01f,
  -1.40432999e-01f, -1.56649593e-02f, -2.00187728e-01f, -2.98357266e-03f, 2.22226784e-01f, 8.85941386e-02f, -1.35911599e-01f, -2.73870885e-01f, 7.40419049e-03f, -2.21691504e-01f,
  -1.61096588e-01f, 1.20440789e-01f, 2.72370465e-02f, -1.63196757e-01f, -1.58391017e-02f, -8.05534702e-03f, -2.59340435e-01f, 2.37920344e-01f, 1.94743887e-01f, -4.76709194e-02f,
  3.69963288e-01f, 2.49877304e-01f, 1.18389361e-01f, 1.98586106e-01f, 5.83931133e-02f, 9.40770358e-02f, -5.26853232e-03f, -1.36968955e-01f, 2.04666808e-01f, -1.04911812e-01f,
  1.36937007e-01f, 2.91589648e-01f, 1.48194313e-01f, 2.31141932e-02f, -2.34577954e-01f, -7.66147077e-02f, -4.98937666e-02f, -1.22116968e-01f, 3.49700987e-01f, 1.11971751e-01f,
  -1.26960784e-01f, 9.94718447e-02f, 2.23386928e-01f, -5.46385124e-02f, 1.33972853e-01f, 2.89090108e-02f, 1.27413645e-01f, 1.84646342e-02f, 9.49064866e-02f, -1.12652943e-01f,
  -8.09468254e-02f, -1.35237232e-01f, 1.06069982e-01f, -1.14488387e-02f, -9.34166685e-02f, -5.52661382e-02f, 1.04219303e-01f, -6.47978634e-02f, 9.86594185e-02f, 2.71804899e-01f,
  9.52749252e-02f, 1.80586517e-01f, 1.29167035e-01f, 3.74572203e-02f, 1.54146105e-01f, -2.97310412e-01f, 1.40720412e-01f, -1.05966367e-01f, 2.64134675e-01f, 1.24794587e-01f,
  1.75720379e-01f, -1.43992662e-01f, -1.60025090e-01f, -1.78246677e-01f, 7.79890195e-02f, 1.27358273e-01f, -5.48658147e-02f, 8.30314830e-02f, -1.11640096e-01f, -8.42123702e-02f,
  -1.04410760e-01f, 2.37721086e-01f, -6.68914765e-02f, 3.27755511e-01f, 2.43774042e-01f, -2.87730604e-01f, -1.82056084e-01f, 9.13892537e-02f, -1.05685771e-01f, 3.94921869e-01f,
  -2.15564817e-01f, -1.49344444e-01f, 1.45564228e-01f, -1.35759935e-02f, 2.38606945e-01f, 2.97955275e-01f, 1.00264356e-01f, -2.80385733e-01f, -5.28279580e-02f, 3.18295211e-01f,
  1.81147546e-01f, -8.83901864e-02f, -2.50649482e-01f, 1.74222395e-01f, 7.89267272e-02f, -8.03082213e-02f, 2.80950665e-01f, -1.15262359e-01f, 1.50203913e-01f, 6.83528036e-02f,
  2.61353999e-02f, 1.10669084e-01f, -5.15894592e-02f, 1.72832876e-01f, 1.64349258e-01f, 1.45909702e-02f, 1.07613206e-01f, 1.73324183e-01f, -2.93496959e-02f, 1.23448603e-01f,
  4.25100438e-02f, -1.31625339e-01f, -3.50276142e-01f, 3.14829163e-02f, 2.86734194e-01f, -3.46745960e-02f, -1.39949411e-01f, -1.09981142e-01f, 2.86465257e-01f, -4.12626505e-01f,
  9.03946906e-02f, -2.24274267e-02f, 2.07652658e-01f, 2.07089961e-01f, -1.56687260e-01f, 1.50005639e-01f, 2.29787156e-01f, 7.17531145e-02f, 2.50546962e-01f, 1.46003887e-01f,
  -2.14592498e-02f, 3.17659020e-01f, -1.64711118e-01f, 2.08255231e-01f, -2.93255672e-02f, -1.50936812e-01f, 1.62017755e-02f, 1.41061991e-01f, 2.09308881e-02f, -1.50414761e-02f,
  -1.83456123e-01f, 1.81971908e-01f, -1.44224375e-01f, 6.33063540e-02f, 1.21899508e-01f, -2.00594455e-01f, -9.35968608e-02f, 2.06444114e-01f, -8.27984288e-02f, -1.45213112e-01f,
  -6.61014691e-02f, 1.35631725e-01f, -9.90987718e-02f, 2.04998121e-01f, 2.26805359e-01f, -1.78721529e-02f, -2.40526915e-01f, -1.92741960e-01f, -2.72177104e-02f, -9.80127305e-02f,
  -1.10794762e-02f, -1.86915621e-01f, -1.00519530e-01f, -8.08802620e-02f, 1.00242626e-02f, 6.64675981e-02f, 4.78897318e-02f, -2.49824133e-02f, 7.91887864e-02f, 1.41209930e-01f,
  5.39534986e-02f, 1.07047856e-01f, 3.41845416e-02f, 1.44905411e-02f, 4.42111976e-02f, -2.03904212e-02f, 1.52444886e-03f, -9.74702984e-02f, 1.42521122e-02f, -1.31511062e-01f,
  1.27633074e-02f, 2.11782642e-02f, -4.14905325e-02f, 8.03505629e-02f, 6.28359392e-02f, 6.62501678e-02f, -2.92885602e-01f, 1.50742158e-01f, 1.66092291e-01f, 1.11355782e-01f,
  1.85319021e-01f, 2.98262954e-01f, -1.47840187e-01f, -1.43766357e-02f, 2.47511044e-01f, 2.70515144e-01f, -1.77741244e-01f, -5.35242036e-02f, 9.79293138e-02f, -1.82557195e-01f,
  -7.61219952e-03f, -2.21931022e-02f, -1.28125966e-01f, 2.74222851e-01f, -1.94787130e-01f, -2.56924834e-02f, 7.35092834e-02f, -1.18476987e-01f, 2.84567356e-01f, 1.28710032e-01f,
  6.46931827e-02f, 1.16318882e-01f, 1.45761389e-02f, 3.06580160e-02f, 7.55155832e-02f, 5.85842505e-02f, 4.82632034e-02f, 1.09533086e-01f, 1.31022558e-01f, 1.65158659e-01f,
  -1.84064377e-02f, 4.45908308e-03f, -5.17111048e-02f, 1.14693098e-01f, -1.26419768e-01f, 1.24959216e-01f, 4.12894189e-02f, 1.13982916e-01f, 1.38937101e-01f, 7.46800825e-02f,
  -8.66253078e-02f, 8.72989595e-02f, -6.17908910e-02f, 1.69735625e-02f, 2.11317241e-02f, 6.58118874e-02f, 3.34291160e-02f, 9.15904567e-02f, 3.18472572e-02f, 5.96761052e-03f,
  -1.91375539e-01f, -3.67165683e-03f, 5.96197024e-02f, 1.78055987e-01f, 3.94800231e-02f, 1.03012845e-01f, 1.24513030e-01f, -1.29665375e-01f, -1.41823769e-01f, 4.42236699e-02f,
  2.62191027e-01f, -1.04852982e-01f, -2.64026225e-01f, 7.96452463e-02f, -1.65304556e-01f, -1.59397587e-01f, 2.32805282e-01f, 4.70068725e-03f, -1.64975271e-01f, -1.13406807e-01f,
  -1.89083368e-01f, 3.04825336e-01f, -1.91258177e-01f, 1.44493923e-01f, 1.67971522e-01f, 2.05826521e-01f, -1.49482153e-02f, -1.42621368e-01f, 3.20410617e-02f, 3.04463804e-01f,
  2.36809656e-01f, 4.53917757e-02f, 1.60811707e-01f, -3.58233862e-02f, -1.39847919e-01f, 1.28202304e-01f, -1.77900538e-01f, -5.21641523e-02f, 8.94102231e-02f, 1.13256253e-01f,
  -1.81184515e-01f, -1.79414991e-02f, 2.39564672e-01f, 2.03646831e-02f, -1.71150696e-02f, 1.29622534e-01f, 2.91455477e-01f, 5.72901554e-02f, 1.56790093e-02f, 5.75989624e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  2.70941127e-02f, 5.12280352e-02f, 1.43015355e-01f, 1.25889033e-01f, 1.41621009e-01f, 1.17995357e-02f, 1.57988835e-02f, 9.91557539e-02f, 6.65288717e-02f, 3.17959525e-02f,
  4.98739630e-02f, 8.07066113e-02f, 9.59079713e-02f, 8.88717026e-02f, 8.66965801e-02f, 4.89186458e-02f, 9.12235677e-02f, 5.61704626e-04f, 1.23468213e-01f, 5.39193302e-02f,
  1.21213771e-01f, 6.24497868e-02f, 6.40671626e-02f, 1.11025259e-01f, -1.59865059e-02f, 6.18055575e-02f, 7.59765804e-02f, 1.15321092e-01f, -1.35722300e-02f, 1.53189972e-01f,
  5.46539538e-02f, 2.18802206e-02f, 1.85109489e-02f, 9.10245851e-02f, 2.97683142e-02f, 8.85275975e-02f, 3.65291797e-02f, 5.86682372e-02f, 1.09618373e-01f, 2.83798156e-03f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -2.39837281e-02f, -5.20184636e-02f, -2.25169271e-01f, -1.61974713e-01f, 5.69343530e-02f, -1.51985124e-01f, 1.11496061e-01f, -1.15757175e-01f, -1.48694694e-01f, 1.28085315e-01f,
  -1.47775218e-01f, -1.39727086e-01f, -1.91626281e-01f, 1.27163753e-01f, 8.66467357e-02f, 2.40196615e-01f, -2.42614504e-02f, 1.74560651e-01f, -9.36346874e-02f, -1.75763637e-01f,
  -1.01174213e-01f, -1.60097793e-01f, -1.61965787e-01f, 2.23046660e-01f, 5.06472364e-02f, -3.28070000e-02f, -3.87484014e-01f, -3.52658123e-01f, -4.86773103e-01f, 1.91753164e-01f,
  2.84386009e-01f, 3.63032550e-01f, 1.53365001e-01f, 2.07633778e-01f, -2.53123865e-02f, 4.69279923e-02f, 1.53736725e-01f, 2.30004817e-01f, -4.10590738e-01f, -1.26482537e-02f,
  -4.78977531e-01f, -2.97205389e-01f, 2.52990812e-01f, -9.04569626e-02f, -3.01545620e-01f, 9.24195573e-02f, 2.16110140e-01f, -2.78823882e-01f, 2.90263772e-01f, -2.64124662e-01f,
  -3.88819098e-01f, -1.51993334e-01f, -1.37824714e-01f, -5.82173109e-01f, 2.36988276e-01f, -3.18079084e-01f, 3.26397508e-01f, -4.22008395e-01f, -8.61120448e-02f, -3.71618569e-01f,
  3.75978619e-01f, 2.33264714e-01f, 1.36397302e-01f, -1.23217553e-01f, 1.33664891e-01f, 1.79290488e-01f, -7.56567642e-02f, 8.49591270e-02f, -6.95226118e-02f, 1.87994033e-01f,
  6.77095950e-02f, 2.69342482e-01f, -2.73856968e-01f, -9.40645263e-02f, -2.58842167e-02f, 5.98724075e-02f, 2.77725041e-01f, -1.29569350e-02f, 7.48638883e-02f, 3.18763137e-01f,
  -1.20788932e-01f, -1.97618052e-01f, 5.54526709e-02f, 1.46608604e-02f, -1.30038306e-01f, 3.14163297e-01f, 2.79016137e-01f, 1.72853813e-01f, -3.17884684e-01f, 3.48204404e-01f,
  -2.51658946e-01f, -1.54831901e-01f, 2.89532423e-01f, -2.68796802e-01f, 1.12426467e-01f, -2.31467992e-01f, -2.38320604e-01f, 1.92946374e-01f, 1.74726263e-01f, 5.52054830e-02f,
  -5.73114038e-01f, 3.91037494e-01f, 1.37949690e-01f, 1.01509457e-02f, -6.65107816e-02f, 3.09798360e-01f, 3.09999526e-01f, 2.78963238e-01f, 1.38329789e-01f, 1.32665753e-01f,
  2.41001397e-01f, -5.47181666e-01f, 1.03244014e-01f, -4.21183586e-01f, -1.12398475e-01f, -3.18052977e-01f, -3.01426262e-01f, 4.80101407e-02f, -4.66314435e-01f, -3.02896410e-01f,
  -4.38824631e-02f, -2.03418121e-01f, -4.33562458e-01f, -2.47495055e-01f, -1.47940502e-01f, 3.49929959e-01f, -1.15331858e-01f, 2.12906271e-01f, 4.65199873e-02f, -9.76090357e-02f,
  -9.48245004e-02f, -1.38306260e-01f, 3.35411280e-02f, 1.68890078e-02f, -2.14020282e-01f, -1.91762328e-01f, -5.45941480e-03f, -1.89374864e-01f, 1.40151575e-01f, 1.05543308e-01f,
  -9.00691450e-02f, -2.66351014e-01f, 1.70157626e-01f, -2.09947258e-01f, 1.56875961e-02f, -2.17839509e-01f, 1.22328863e-01f, 1.33310467e-01f, -1.94173381e-01f, -3.12460624e-02f,
  -1.74937081e-02f, 1.05238013e-01f, -1.14360631e-01f, 1.76130727e-01f, -2.03739509e-01f, -2.10974470e-01f, -4.34558123e-01f, -1.24576986e-01f, -3.54806244e-01f, -3.35124522e-01f,
  3.27213347e-01f, -4.23213601e-01f, 2.34867558e-01f, 2.09762037e-01f, 1.70964841e-02f, -1.87124852e-02f, 8.88769627e-02f, -4.39283438e-02f, -1.22395456e-01f, 2.85468131e-01f,
  -3.39942902e-01f, 3.14225107e-01f, 1.97126418e-01f, -4.61987883e-01f, -4.39543754e-01f, -2.51841217e-01f, 2.31757343e-01f, 2.19847441e-01f, 1.59934089e-01f, -3.34179521e-01f,
  -2.60411829e-01f, 4.76053506e-02f, -2.23565415e-01f, 1.85141400e-01f, 2.96489179e-01f, -4.95991379e-01f, 2.69830137e-01f, 5.54682836e-02f, -2.31436670e-01f, -7.47902542e-02f,
  -9.25971568e-02f, 2.88996875e-01f, -1.14471316e-01f, 2.34373182e-01f, -9.40416902e-02f, -9.39902142e-02f, -4.03860491e-03f, 6.84687942e-02f, -3.67147988e-03f, 1.76685289e-01f,
  5.34708463e-02f, -1.34687811e-01f, 2.91573424e-02f, 6.78144544e-02f, -2.04902172e-01f, -6.00189976e-02f, -2.95388013e-01f, 3.58357191e-01f, -1.96149990e-01f, 1.18926585e-01f,
  -3.84218059e-02f, 4.48712939e-03f, -5.18094264e-02f, 2.66970024e-02f, -1.83852553e-01f, -1.54131040e-01f, 9.09631401e-02f, -3.04921448e-01f, -1.90322459e-01f, 3.05602759e-01f,
  3.00277948e-01f, 2.65540153e-01f, -7.51430169e-02f, -3.54977518e-01f, -2.95997679e-01f, -3.31194043e-01f, -3.96936238e-01f, 1.07488789e-01f, 4.19745177e-01f, -3.20277333e-01f,
  -1.61130607e-01f, -3.34818840e-01f, -4.62960094e-01f, -6.29627705e-01f, -1.11513399e-01f, 1.25392647e-02f, -5.07224858e-01f, -3.55224341e-01f, 8.69364738e-02f, 3.62343580e-01f,
  2.76543200e-01f, 4.12551463e-01f, -3.85218441e-01f, 1.99684992e-01f, -4.61657196e-01f, -3.75667959e-01f, 1.97603956e-01f, -2.35365048e-01f, -1.07832663e-01f, 2.29980037e-01f,
  -3.67933571e-01f, 1.84899896e-01f, 3.34475607e-01f, -4.24776345e-01f, -5.18111944e-01f, -4.76782441e-01f, 1.88091621e-01f, 1.44304410e-02f, 4.36416566e-02f, 1.03781492e-01f,
  6.52996525e-02f, -6.06249236e-02f, -4.59500812e-02f, -8.43094587e-02f, 1.16934627e-01f, -3.19985673e-02f, 1.59183383e-01f, -1.70498490e-02f, -2.56935626e-01f, 3.20936412e-01f,
  1.32962570e-01f, -2.22301409e-01f, -2.69585699e-01f, 1.84808418e-01f, -2.11983293e-01f, -1.46064172e-02f, -3.15652490e-02f, 5.75219886e-03f, 5.75878322e-02f, 7.21449107e-02f,
  3.74431044e-01f, -2.29443341e-01f, -3.29264045e-01f, 1.14017062e-01f, -4.05245692e-01f, 3.65757942e-02f, 3.87943834e-02f, -1.46538496e-01f, 3.34492058e-01f, 5.08570708e-02f,
  -5.12090802e-01f, 9.09115449e-02f, -4.03373599e-01f, 2.72774994e-01f, -4.50388402e-01f, 2.61593044e-01f, 2.74358481e-01f, 3.58679928e-02f, -4.89900738e-01f, -3.49098921e-01f,
  1.98570177e-01f, 8.32509771e-02f, -6.75288588e-02f, -2.46424794e-01f, 3.99454504e-01f, 9.63189155e-02f, 1.53037623e-01f, 2.92148769e-01f, 8.83619860e-02f, -4.05174331e-04f,
  2.25030795e-01f, -4.99354035e-01f, -3.14300396e-02f, 1.98497295e-01f, -2.58015603e-01f, 3.87126684e-01f, -4.02364910e-01f, -2.47612789e-01f, 4.88179959e-02f, -2.98297316e-01f,
  -6.53537214e-02f, 8.09653010e-03f, 6.97291642e-02f, 1.85924217e-01f, 3.11615579e-02f, -1.05254129e-01f, 7.57926377e-03f, -1.32346094e-01f, 2.37586081e-01f, 1.92544833e-01f,
  -9.81878862e-02f, 2.49298468e-01f, 1.73650444e-01f, 5.55652045e-02f, 1.41702190e-01f, 2.52591539e-02f, 1.23658784e-01f, -7.09396452e-02f, -3.29019248e-01f, -1.86856031e-01f,
  -3.09845567e-01f, -2.25773752e-01f, -1.14232309e-01f, -1.25191092e-01f, 9.32815224e-02f, 3.06900769e-01f, 9.36200842e-02f, -5.43251991e-01f, 2.38425434e-01f, -3.94150943e-01f,
  1.39761508e-01f, 2.91433781e-01f, -5.30211687e-01f, 2.74221569e-01f, -2.17835829e-01f, 6.86092302e-02f, -1.97261915e-01f, -1.62696674e-01f, 1.86080739e-01f, 2.08274409e-01f,
  1.83419600e-01f, -3.49074006e-01f, 2.34685838e-01f, -5.72219729e-01f, -6.55636489e-02f, -7.98104554e-02f, -2.19307885e-01f, 3.08797717e-01f, -4.02953565e-01f, -5.01467824e-01f,
  2.70640463e-01f, 1.06670661e-02f, 3.97313207e-01f, 2.00737774e-01f, 1.97419509e-01f, -1.73424467e-01f, -1.84935838e-01f, -4.22810435e-01f, -2.98794508e-01f, -3.61758441e-01f,
  -4.19030488e-01f, 1.92872018e-01f, 2.72447020e-01f, -2.77187169e-01f, -3.04302387e-02f, -6.68572187e-02f, 1.44627944e-01f, -5.41960075e-02f, 1.37106538e-01f, 1.63288593e-01f,
  1.19647339e-01f, -1.08618714e-01f, 1.61325291e-01f, 7.69427866e-02f, -2.23227575e-01f, 1.04470626e-01f, 3.28350961e-01f, 3.33467275e-01f, -2.64135540e-01f, -1.84514776e-01f,
  -8.80209878e-02f, -2.18351647e-01f, 2.49541670e-01f, 2.43475109e-01f, 2.27604121e-01f, 3.71070176e-01f, -1.13121733e-01f, -4.36446130e-01f, -5.21191776e-01f, 2.34249309e-01f,
  1.75649822e-01f, -2.73075372e-01f, 4.24421161e-01f, -1.75154820e-01f, -3.05712014e-01f, 2.99974173e-01f, 1.71349034e-01f, -5.40576994e-01f, -2.98447132e-01f, -5.66213913e-02f,
  -4.04818952e-01f, -1.28935635e-01f, 3.29900384e-01f, 7.84427151e-02f, 1.97003320e-01f, -3.67920280e-01f, 2.11670473e-01f, 2.20467091e-01f, 1.03992656e-01f, -3.47568333e-01f,
  -2.86660016e-01f, 2.46691614e-01f, -2.98354864e-01f, 4.40243036e-01f, -4.50538397e-02f, -3.84605974e-01f, -3.43170196e-01f, 2.38857642e-01f, -4.04300600e-01f, 3.17346424e-01f,
  -5.42437077e-01f, 1.29460588e-01f, 3.76237750e-01f, -3.22405063e-02f, -1.41889557e-01f, -2.76403695e-01f, 2.00017229e-01f, -6.81652725e-02f, -7.21438369e-03f, -3.81264538e-02f,
  9.41290930e-02f, 1.23444069e-02f, 1.50798500e-04f, 4.52302583e-02f, -7.11537078e-02f, -1.75851390e-01f, -1.68254703e-01f, 7.10094571e-02f, 2.35829856e-02f, -1.62599534e-01f,
  -1.79074511e-01f, 6.85661286e-02f, 1.15453444e-01f, 7.16967210e-02f, 2.52750248e-01f, 2.01305356e-02f, 2.89179474e-01f, -1.22805774e-01f, 7.19540790e-02f, -1.61769271e-01f,
  -4.93510813e-02f, -2.26466060e-01f, 1.40859097e-01f, -1.74125984e-01f, 3.71787697e-01f, -1.20474942e-01f, 1.75557315e-01f, 4.21628267e-01f, -2.21626703e-02f, -4.14421856e-01f,
  1.81893528e-01f, 2.05031157e-01f, 2.20235780e-01f, -3.74458551e-01f, 2.10228413e-01f, -2.90318817e-01f, 7.52261952e-02f, -5.32528639e-01f, -4.63496476e-01f, -1.01500988e-01f,
  2.76708174e-02f, -1.78319976e-01f, -4.20386314e-01f, -2.58480936e-01f, -2.75756836e-01f, 1.85848564e-01f, -6.44328818e-02f, 3.62625480e-01f, -4.13312525e-01f, 9.59585309e-02f,
  2.42977604e-01f, -3.52897286e-01f, 2.12711841e-01f, 4.27875549e-01f, 3.91706675e-02f, 1.16490342e-01f, -1.83231026e-01f, -3.72620344e-01f, -4.66207772e-01f, -2.52562970e-01f,
  1.45612493e-01f, -1.97324887e-01f, 1.01406104e-03f, -1.80420093e-02f, -2.48645425e-01f, 4.36083153e-02f, 4.90964204e-02f, -2.08211094e-01f, -4.91680279e-02f, -1.56103194e-01f,
  2.52196211e-02f, -1.30328402e-01f, -3.69984172e-02f, -2.12036178e-01f, 1.60455450e-01f, 1.59878269e-01f, -1.49932886e-02f, -7.76336193e-02f, 3.11404258e-01f, -1.02311850e-01f,
  1.30825937e-01f, 1.86678603e-01f, 6.00929521e-02f, 2.75446884e-02f, 1.46751523e-01f, 1.36222094e-01f, -2.32431546e-01f, -3.41309518e-01f, -2.32137293e-01f, -4.03259099e-01f,
  -2.97001123e-01f, 2.70664454e-01f, -6.29225373e-02f, -1.73873737e-01f, -2.25488707e-01f, 5.21865813e-03f, -1.24219529e-01f, -3.47274840e-01f, 4.11040395e-01f, -2.42650941e-01f,
  1.07701376e-01f, 6.07678145e-02f, -8.87001976e-02f, 1.63360000e-01f, -1.02536060e-01f, 3.87435853e-02f, 1.46688119e-01f, 3.18191350e-01f, 2.67429441e-01f, -8.40854049e-02f,
  -3.55142891e-01f, -1.21878386e-01f, -1.78140730e-01f, -2.44522691e-01f, 2.23184705e-01f, 3.72631520e-01f, -1.55027898e-03f, -6.04010709e-02f, -2.61256486e-01f, -1.83720931e-01f,
  3.10003489e-01f, 2.12925494e-01f, 3.07611227e-01f, -3.61867398e-02f, -1.39571950e-01f, 7.73831755e-02f, 8.80219340e-02f, -1.99192643e-01f, 4.87074181e-02f, -2.66190805e-02f,
  2.95988861e-02f, -1.24629721e-01f, -4.33507338e-02f, 4.85881194e-02f, -6.81050196e-02f, -1.66507095e-01f, 2.98712999e-02f, 7.78693259e-02f, -1.78508490e-01f, 1.20580286e-01f,
  -3.33767176e-01f, -1.64471716e-01f, 3.50160241e-01f, 2.35044375e-01f, 3.25208992e-01f, -9.24103931e-02f, 2.86053061e-01f, 2.09225401e-01f, -2.26655379e-01f, 3.49549472e-01f,
  -9.20044407e-02f, -3.63948405e-01f, 3.07055175e-01f, -4.74633366e-01f, -2.18324319e-01f, -4.60528731e-01f, 1.85136795e-01f, -4.86893117e-01f, 2.37094656e-01f, -1.32108748e-01f,
  3.00589144e-01f, -1.94173962e-01f, -3.60570192e-01f, 2.33005926e-01f, 2.68020242e-01f, -4.40254547e-02f, 2.24059656e-01f, -2.47498125e-01f, -1.78052992e-01f, 3.28948706e-01f,
  1.90249622e-01f, 4.06278282e-01f, -3.22752506e-01f, -3.91108334e-01f, -3.07150364e-01f, 1.72838584e-01f, 3.61081839e-01f, -5.07358491e-01f, -3.71452756e-02f, 9.61956196e-03f,
  2.75084347e-01f, 2.23159734e-02f, 2.54413664e-01f, 3.32233369e-01f, -4.70163703e-01f, -4.76291448e-01f, -2.69069150e-02f, -3.76912683e-01f, -2.21009210e-01f, -4.85486746e-01f,
  1.83364153e-01f, -6.18654713e-02f, 1.71028256e-01f, -1.66213512e-02f, -9.90636051e-02f, 2.26213455e-01f, -3.15076075e-02f, 9.09617022e-02f, 1.31575823e-01f, 2.08077759e-01f,
  6.14997111e-02f, 1.23735540e-01f, -1.79479599e-01f, -3.38624120e-01f, -2.58881897e-01f, -2.42366120e-01f, -1.71956465e-01f, 9.45901275e-02f, -2.40772963e-01f, 1.87600747e-01f,
  -1.33638903e-01f, -3.71279180e-01f, 1.47402599e-01f, 1.04912974e-01f, -3.29094291e-01f, 1.69678807e-01f, 3.48233670e-01f, 3.43957365e-01f, 1.70944855e-01f, -3.02003682e-01f,
  -3.48621041e-01f, -1.02442831e-01f, -1.81622729e-01f, -8.99292231e-02f, -2.86911726e-01f, 2.09838808e-01f, -2.35425055e-01f, -9.44994614e-02f, -3.24171633e-01f, -3.06004375e-01f,
  -2.83613056e-01f, 3.08865488e-01f, -3.05016041e-01f, -4.03203398e-01f, 1.06556363e-01f, -5.34740686e-02f, 3.59704852e-01f, -4.09786224e-01f, -2.83225000e-01f, -3.74755025e-01f,
  -2.15679705e-01f, 2.93449968e-01f, -1.41824797e-01f, 1.29477382e-01f, -1.47537053e-01f, 3.16094846e-01f, 8.46053511e-02f, 1.11540996e-01f, 1.30523801e-01f, 2.62773693e-01f,
  2.76822537e-01f, 2.59231836e-01f, -2.84949362e-01f, 1.95376709e-01f, -8.20020214e-02f, -6.02629706e-02f, -3.30588445e-02f, 2.79139858e-02f, -2.49010678e-02f, 1.42925173e-01f,
  -1.93929806e-01f, 9.95379165e-02f, 1.00672781e-01f, 1.16362467e-01f, 6.28354251e-02f, 7.65189007e-02f, 2.51297683e-01f, -2.82598794e-01f, 1.26384825e-01f, -4.58841808e-02f,
  -3.14339578e-01f, -1.66122243e-02f, -2.94268698e-01f, -1.80081233e-01f, 2.85991877e-02f, -3.17518711e-01f, 1.61985129e-01f, -1.51245847e-01f, -9.11098272e-02f, -2.68256515e-01f,
  -3.78831327e-01f, 3.84319603e-01f, -3.44027400e-01f, -4.80078757e-01f, 6.40339404e-03f, 4.67778593e-01f, -4.07293051e-01f, -3.53171378e-01f, 3.89104396e-01f, -2.86894321e-01f,
  3.03716630e-01f, -2.38435447e-01f, -2.64511079e-01f, 2.32799143e-01f, 1.53422639e-01f, -2.64579773e-01f, -3.90876353e-01f, -1.55912653e-01f, 2.17089102e-01f, 2.03234643e-01f,
  -2.54268736e-01f, 4.23806846e-01f, -3.08123767e-01f, -2.19551429e-01f, -8.31448510e-02f, 1.64734080e-01f, 2.57069141e-01f, -5.16412258e-01f, -1.99068319e-02f, 3.30689520e-01f,
  -2.59084940e-01f, -1.96897864e-01f, 2.31081694e-01f, -1.08224116e-01f, -9.82415974e-02f, -2.98635066e-01f, -1.66475803e-01f, 3.08822304e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  2.49528103e-02f, -1.77612044e-02f, -1.14805467e-01f, 3.03112715e-03f, -2.16271058e-02f, -2.20101383e-02f, -1.84652545e-02f, 2.27397010e-02f, -8.49633105e-03f, -1.77558586e-02f,
  1.28234342e-01f, 6.61463216e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    