/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.48849446e-01f, -7.42102265e-02f, 2.95138136e-02f, 5.71717247e-02f, 1.62587509e-01f, 2.05164611e-01f, 3.01878691e-01f, -3.26645076e-02f, 5.13435639e-02f, -8.58265087e-02f,
  1.12427860e-01f, 1.82418242e-01f, 6.06289692e-02f, -2.92832106e-01f, 2.21979618e-01f, -2.07203597e-01f, -6.75239712e-02f, -1.68268234e-02f, -1.95446685e-02f, 2.55710304e-01f,
  -1.77343488e-02f, 4.56876457e-02f, -9.30438042e-02f, -4.63022590e-02f, 2.05894873e-01f, 4.82920483e-02f, -1.05263077e-01f, 1.38802961e-01f, -3.05672809e-02f, -1.19604832e-02f,
  5.19333482e-02f, 6.23017773e-02f, -1.85242612e-02f, -6.86917454e-03f, 1.38684139e-01f, 5.25916256e-02f, 4.90645543e-02f, -2.39053722e-02f, 4.40514982e-02f, 8.64047706e-02f,
  -6.18876554e-02f, 2.98477393e-02f, 3.09157930e-02f, -5.35872690e-02f, 1.01935510e-02f, -2.41806693e-02f, -1.34030627e-02f, -9.70243663e-02f, -7.78173134e-02f, -9.26332697e-02f,
  -6.69441223e-02f, 1.85461026e-02f, -9.43648890e-02f, 2.91827824e-02f, -6.04748838e-02f, 3.39236632e-02f, -1.37012705e-01f, 7.95608386e-02f, -3.65424678e-02f, 1.42613556e-02f,
  8.47773254e-02f, -4.94595952e-02f, -6.62031174e-02f, -7.04416335e-02f, 1.21330116e-02f, -2.97769848e-02f, -8.30884650e-02f, -3.52305435e-02f, -3.57130133e-02f, -1.35743599e-02f,
  7.05727413e-02f, -1.13817491e-02f, -4.37043756e-02f, 5.46423569e-02f, -1.24569938e-01f, -4.23157662e-02f, -8.12161788e-02f, -3.36110666e-02f, 2.08317712e-02f, -8.05285349e-02f,
  -1.92854796e-02f, 1.29871042e-02f, 1.32738188e-01f, 2.60521714e-02f, 2.07043309e-02f, 1.30189713e-02f, -1.36778325e-01f, -7.12119490e-02f, 4.29658704e-02f, 2.52101906e-02f,
  2.15752155e-01f, 1.29853413e-01f, -4.70314961e-04f, 1.18793780e-02f, 9.18206107e-03f, -8.09955001e-02f, -1.06501408e-01f, -8.15089121e-02f, 6.67011142e-02f, 1.38257379e-02f,
  -4.83560935e-02f, 6.20452575e-02f, 1.51837185e-01f, 9.85694677e-02f, 2.60620192e-03f, 5.87675683e-02f, 9.54137519e-02f, 4.67100143e-02f, 3.41539904e-02f, -5.99719491e-03f,
  6.87633082e-02f, 1.65805951e-01f, -1.71974096e-02f, 1.85922720e-03f, -1.35132849e-01f, 8.80372971e-02f, 2.85667256e-02f, -4.52735610e-02f, -6.70309812e-02f, -1.18520871e-01f,
  2.32898369e-01f, -1.28250748e-01f, 1.76943824e-01f, 2.78060794e-01f, -1.91293016e-01f, 2.32981518e-01f, 2.74082869e-01f, 1.17075250e-01f, 1.89302981e-01f, -8.56274143e-02f,
  1.05455354e-01f, 8.41999948e-02f, 5.99711166e-05f, 3.11387241e-01f, 3.58349562e-01f, 2.58806944e-01f, 3.74411285e-01f, 1.83188483e-01f, 3.79388072e-02f, 4.84298207e-02f,
  1.40685245e-01f, 9.18682590e-02f, 1.61674753e-01f, -1.98333830e-01f, -8.12438801e-02f, -8.15920830e-02f, -1.21210031e-01f, -1.63191393e-01f, 9.26339179e-02f, -3.46571803e-02f,
  -9.00901109e-02f, -1.23294622e-01f, -9.03775021e-02f, -3.14123109e-02f, 4.05765288e-02f, -1.37641773e-01f, -1.11858748e-01f, -9.23884735e-02f, 5.40865548e-02f, 7.42665455e-02f,
  3.09560541e-02f, -8.26834962e-02f, 1.65453508e-01f, 4.80057225e-02f, 1.14234313e-02f, 4.28378880e-02f, -2.27964260e-02f, 4.33049649e-02f, -1.12899439e-02f, 1.14011139e-01f,
  6.17069416e-02f, 4.86876145e-02f, 1.25423595e-01f, 6.73035309e-02f, 7.42770433e-02f, 1.09889753e-01f, 1.27154496e-02f, -9.76302028e-02f, 7.34392479e-02f, 1.79251302e-02f,
  1.21504463e-01f, 1.22533441e-02f, -2.32064053e-02f, -5.04528061e-02f, -1.03655577e-01f, -1.65617898e-01f, 1.99513268e-02f, -1.46039352e-01f, -1.68279946e-01f, -5.90492152e-02f,
  -6.13963455e-02f, -8.96059256e-03f, 1.49963880e-02f, -4.92393412e-02f, 2.73539051e-02f, -7.26471171e-02f, -6.37161732e-02f, 1.03691895e-03f, 3.86720449e-02f, -3.94178145e-02f,
  -1.18266873e-01f, -8.36987197e-02f, -3.73211466e-02f, -9.06844996e-03f, 8.22107792e-02f, 5.71390092e-02f, 2.18816511e-02f, 4.93042134e-02f, -1.63643714e-02f, 5.10520265e-02f,
  -4.11703289e-02f, 3.43151763e-02f, -6.73949998e-03f, -1.11220263e-01f, -7.04189017e-02f, -1.15568526e-01f, 2.86130933e-03f, 2.43149474e-02f, 5.92510067e-02f, 3.24826986e-02f,
  5.89343309e-02f, -5.30814491e-02f, 9.52629931e-03f, -6.86610267e-02f, 4.35766838e-02f, 9.87858791e-03f, 6.56613261e-02f, -1.15252407e-02f, 2.56573521e-02f, 2.43699159e-02f,
  2.84036212e-02f, 9.96294841e-02f, 8.60893726e-02f, -7.39385784e-02f, 5.78348562e-02f, 8.88366718e-03f, 7.37983212e-02f, 3.12303789e-02f, -6.27307668e-02f, -1.05363846e-01f,
  3.88135225e-01f, -3.73083234e-01f, -2.25309640e-01f, 6.00938089e-02f, 2.34406307e-01f, -1.05323508e-01f, -1.17257610e-01f, -3.39578055e-02f, 2.11370185e-01f, -3.45590472e-01f,
  -9.91801247e-02f, -1.23258427e-01f, -2.33012304e-01f, -1.09849393e-01f, 3.84278864e-01f, 5.89188561e-02f, -5.60781434e-02f, -7.60410130e-02f, 1.72046843e-04f, -8.53596777e-02f,
  8.55641663e-02f, 1.21896546e-02f, -4.51958328e-02f, 7.26138204e-02f, -8.51301476e-02f, -3.78928962e-03f, 5.10721430e-02f, -8.29426348e-02f, 2.44603958e-04f, -1.36137307e-02f,
  -4.22170646e-02f, -5.11433259e-02f, -2.53198035e-02f, 9.57229640e-03f, -2.80036889e-02f, -3.38339694e-02f, -5.46661355e-02f, -8.45209789e-03f, 1.10313952e-01f, -6.55828491e-02f,
  1.53677547e-02f, 2.60416437e-02f, 2.59303823e-02f, 4.61624600e-02f, 4.77495752e-02f, -3.22249047e-02f, 4.74647582e-02f, 2.27349438e-02f, -3.21709439e-02f, -7.65311792e-02f,
  7.78090721e-03f, -9.20056328e-02f, -1.05341794e-02f, -9.80919506e-03f, 1.43089062e-02f, 7.56570231e-03f, -9.63041633e-02f, -6.73252568e-02f, -5.35475984e-02f, -3.04638129e-02f,
  -1.74952503e-02f, 3.67226452e-02f, 7.24548921e-02f, -5.57698645e-02f, 3.03044692e-02f, 3.11337169e-02f, 1.26123786e-01f, -3.31277750e-03f, -5.87175004e-02f, -1.67252906e-02f,
  9.13740322e-02f, 4.40229438e-02f, -7.61922821e-02f, -2.68429350e-02f, -1.19985929e-02f, -7.16670305e-02f, -2.00278405e-02f, -2.43894234e-02f, -6.86906949e-02f, 4.46078591e-02f,
  1.29333660e-01f, 5.53053506e-02f, -4.02610078e-02f, -1.13877892e-01f, 3.92303877e-02f, -2.55395044e-02f, 4.29703817e-02f, -7.74916485e-02f, -8.52636397e-02f, -5.46213426e-02f,
  -7.16968551e-02f, -1.27354428e-01f, -2.08216552e-02f, -4.84210886e-02f, 3.93867726e-03f, 1.62689609e-03f, -1.89995840e-02f, 1.41834319e-02f, 7.87270591e-02f, -5.11005754e-04f,
  -6.93585202e-02f, 2.16160789e-02f, 8.75430368e-03f, 1.18417675e-02f, 1.36840791e-02f, -7.13700727e-02f, 5.79793565e-02f, 8.67514834e-02f, -4.27832492e-02f, -3.84483747e-02f,
  9.13399234e-02f, 4.96343523e-02f, 7.90336430e-02f, 2.72463504e-02f, 1.63811818e-02f, -7.00306371e-02f, 8.16573724e-02f, -7.42332712e-02f, -6.09633252e-02f, -1.36963293e-01f,
  -3.20962846e-01f, -1.73316047e-01f, 2.34118611e-01f, 2.87738014e-02f, 2.12691545e-01f, 3.37089121e-01f, 2.65481114e-01f, 9.99752730e-02f, 1.20485397e-02f, -1.02996103e-01f,
  9.33863595e-02f, -1.40102684e-01f, -2.10538924e-01f, 1.41503066e-01f, 2.32064545e-01f, 2.21589636e-02f, 1.12698935e-01f, 5.41407615e-02f, -6.24564327e-02f, -1.90074906e-01f,
  -3.35306525e-02f, -5.88664319e-03f, 1.73519179e-01f, -4.58342582e-02f, 1.11882575e-01f, -2.85041891e-02f, 2.53265575e-02f, 3.33817936e-02f, 2.74569094e-01f, 1.52174339e-01f,
  -1.00576282e-01f, -2.15053841e-01f, 6.42996207e-02f, -1.12811133e-01f, 6.98875915e-03f, -4.70112041e-02f, -3.95669006e-02f, -2.10106056e-02f, -4.27514911e-02f, -5.71325161e-02f,
  -1.18295006e-01f, -1.21702828e-01f, 5.38500436e-02f, -7.77839497e-02f, 3.12529393e-02f, -6.65818676e-02f, 1.06302112e-01f, 1.65705621e-01f, 5.63493092e-03f, 9.11317617e-02f,
  1.68908805e-01f, 6.09365068e-02f, 1.35978460e-01f, 9.45110098e-02f, 5.65096624e-02f, 6.70987740e-02f, 5.49849533e-02f, 6.89809322e-02f, 3.00702360e-02f, 4.87416387e-02f,
  1.34555236e-01f, -1.49932504e-01f, -2.64608301e-02f, -1.67487815e-01f, -1.62974283e-01f, -6.45315498e-02f, 3.08588725e-02f, -1.56164411e-02f, -7.14514405e-02f, -7.45103881e-02f,
  8.41186789e-04f, 3.24991494e-02f, -8.69004056e-02f, -9.21793878e-02f, -8.20178352e-03f, -6.45283833e-02f, -8.40510055e-02f, -6.57944232e-02f, 8.93730670e-03f, 8.67663100e-02f,
  -9.25237611e-02f, -1.75880305e-02f, -9.96583626e-02f, -7.92981759e-02f, -4.08187229e-03f, 3.97796109e-02f, 1.85129512e-02f, -1.16346199e-02f, -2.90150475e-02f, -1.45767881e-02f,
  -1.07864052e-01f, -1.23377196e-01f, -1.13116577e-01f, -5.88690415e-02f, -5.94488122e-02f, -5.38519816e-03f, -2.68041864e-02f, -4.07731272e-02f, 1.29797012e-02f, -9.45923179e-02f,
  -5.35918698e-02f, -9.58699957e-02f, 3.41242924e-02f, -1.10085927e-01f, -4.85085547e-02f, 9.13904384e-02f, 1.59485843e-02f, -3.01395170e-02f, 1.19937574e-02f, -1.46539919e-02f,
  2.59525292e-02f, -4.77387523e-03f, 7.58971497e-02f, 4.17644717e-02f, -1.26781780e-02f, 7.00475052e-02f, 4.93113324e-02f, -1.69649832e-02f, -5.64698130e-02f, -9.66973528e-02f,
  -8.20055455e-02f, 5.26506379e-02f, -3.53755057e-02f, -3.82538706e-01f, 1.11503340e-01f, 5.50629675e-01f, -1.63913310e-01f, 1.62512451e-01f, -3.32219005e-02f, 8.66165385e-02f,
  -2.97458589e-01f, 1.15676410e-01f, -1.99173912e-01f, -1.82706967e-01f, 2.42928475e-01f, 1.38773699e-03f, 4.51288559e-02f, -4.58487077e-03f, -2.36175675e-02f, -5.80189414e-02f,
  4.82300408e-02f, -1.47543728e-01f, -2.38224745e-01f, 8.41145515e-02f, -1.12599321e-01f, -1.08501121e-01f, 6.74356446e-02f, -1.22266531e-01f, -1.83638614e-02f, 1.22514650e-01f,
  -1.51357561e-01f, -3.04899246e-01f, -1.06734589e-01f, -2.69599631e-02f, -7.05845002e-03f, 1.05950725e-03f, 7.18393188e-04f, -1.15404008e-02f, -1.70899704e-01f, -3.98496352e-02f,
  5.38218394e-02f, -2.95966417e-02f, -5.55725433e-02f, 3.38476598e-02f, 3.27460319e-02f, 6.75811479e-03f, 5.36036082e-02f, 2.66628452e-02f, 1.20035969e-02f, 7.83738941e-02f,
  -9.47922654e-03f, 5.30954227e-02f, 4.93922196e-02f, -5.94353164e-03f, 1.65178448e-01f, 7.40291798e-05f, 1.72947794e-01f, 9.62278768e-02f, 8.79625306e-02f, 1.41312569e-01f,
  1.16157390e-01f, -6.49970816e-03f, -5.27561130e-03f, -5.72261624e-02f, 3.01539581e-02f, -1.23365574e-01f, 4.24947403e-02f, 9.63174645e-03f, 3.99125032e-02f, 6.48663342e-02f,
  -1.76571533e-02f, -3.64071876e-02f, 5.10643944e-02f, 5.34745678e-02f, 1.40828937e-01f, 8.27134475e-02f, 1.03304669e-01f, -6.52545244e-02f, 2.04227623e-02f, -4.21948843e-02f,
  -1.19735420e-01f, 6.45001829e-02f, -2.87460797e-02f, -2.27975249e-02f, -8.91287625e-02f, 7.52557293e-02f, 5.17211817e-02f, 6.97253272e-02f, -1.63130894e-01f, 7.60935247e-02f,
  1.53910983e-02f, 1.16928898e-01f, -7.10246712e-02f, -4.34297808e-02f, -1.10022075e-01f, 1.38088912e-01f, -6.15305640e-02f, 6.87952712e-02f, -6.99289888e-02f, 1.61473617e-01f,
  6.20113090e-02f, -6.63240626e-02f, -4.10170779e-02f, -2.30627991e-02f, 1.13659380e-02f, 3.11586056e-02f, -1.32788107e-01f, 1.92267932e-02f, 6.59317300e-02f, 1.53977126e-01f,
  5.57870157e-02f, -1.09318599e-01f, 1.02752723e-01f, 3.65763940e-02f, 1.70469090e-01f, -2.76894346e-02f, 4.62724753e-02f, 9.16885138e-02f, 2.15390250e-02f, 2.19255034e-02f,
  -1.16977260e-01f, 1.69380799e-01f, -2.35917583e-01f, 2.36466616e-01f, 5.65324090e-02f, 3.21011782e-01f, 2.26652697e-01f, 2.01301202e-01f, 1.62290350e-01f, 1.95227996e-01f,
  1.33811578e-01f, -1.45772463e-02f, 1.15444437e-02f, 4.46820438e-01f, 2.63140798e-01f, 9.80523601e-02f, 3.38290125e-01f, 1.04327910e-01f, -2.44163722e-02f, 1.19983383e-01f,
  1.18266486e-01f, 3.48715246e-01f, -4.44159582e-02f, 1.82540730e-01f, 2.82902699e-02f, -1.36621356e-01f, 1.90172195e-01f, -1.60378247e-01f, 1.42444700e-01f, 2.80313361e-02f,
  -2.34096125e-02f, -1.39894709e-01f, -1.18324764e-01f, -1.48701534e-01f, -4.23655249e-02f, -1.25486910e-01f, -1.46013558e-01f, -5.42312451e-02f, -1.69109121e-01f, 2.75028013e-02f,
  -4.13123332e-02f, -5.12827784e-02f, 2.36022212e-02f, 7.07911551e-02f, 1.33885592e-02f, 4.97634001e-02f, -1.48535803e-01f, -3.54724824e-02f, 4.76533361e-02f, 7.06809685e-02f,
  6.06593676e-03f, 2.17229426e-02f, 9.22495686e-03f, 5.64732514e-02f, 3.86651158e-02f, 7.38583952e-02f, 8.98923203e-02f, 1.12153944e-02f, 1.14805654e-01f, 1.42679736e-01f,
  6.94312379e-02f, 8.34505334e-02f, 2.04783119e-02f, -1.87899843e-02f, 2.95575857e-02f, -7.76982456e-02f, 4.99383770e-02f, -1.25692710e-01f, -8.17515329e-02f, 9.73481089e-02f,
  -4.94724289e-02f, -1.95006561e-02f, 5.10051772e-02f, 1.42937871e-02f, 1.16033629e-01f, 8.33687633e-02f, 4.84229103e-02f, 4.15436476e-02f, 1.23574119e-02f, -1.42523190e-02f,
  -1.02638677e-01f, 6.72606900e-02f, -4.76063753e-04f, -1.69450082e-02f, -7.13134243e-04f, 2.06894707e-02f, 4.45173644e-02f, 8.72038454e-02f, 4.14202921e-02f, 1.50729129e-02f,
  1.71145156e-01f, 1.45310193e-01f, -2.25841682e-02f, -6.47913888e-02f, -1.55686259e-01f, -5.65604828e-02f, 1.23996707e-02f, -8.63451604e-03f, -8.30655694e-02f, 1.12111375e-01f,
  -1.32452082e-02f, -7.69338906e-02f, -5.68036400e-02f, -4.12068702e-02f, 3.73331085e-02f, 1.44870058e-01f, -1.30577967e-01f, -4.49260958e-02f, 4.91849184e-02f, 9.52295363e-02f,
  8.34725611e-03f, -2.63545103e-02f, -1.54324472e-01f, 6.42028973e-02f, 6.04791613e-03f, -7.80802965e-02f, 1.23430461e-01f, -3.87925166e-03f, -1.41115719e-02f, 1.12442009e-01f,
  2.16392860e-01f, -2.46459574e-01f, 6.54110610e-02f, -1.80064902e-01f, 2.53423482e-01f, 4.29656208e-01f, 1.94727495e-01f, 1.34244695e-01f, 2.47069404e-01f, -2.37021610e-01f,
  -4.46629226e-02f, -1.93669811e-01f, -3.05809081e-02f, -1.56620041e-01f, 3.77862781e-01f, 2.76739985e-01f, -6.45185560e-02f, 1.59709863e-02f, 1.04114808e-01f, -9.42932293e-02f,
  7.03344643e-02f, -1.48542851e-01f, -3.26336883e-02f, -3.07731517e-02f, -5.70598282e-02f, -8.50165039e-02f, -2.21185744e-01f, 7.06474632e-02f, -2.09092036e-01f, -6.57292735e-03f,
  6.30131662e-02f, -5.88258579e-02f, -6.61220923e-02f, -1.02857783e-01f, 1.66376214e-02f, -2.99262032e-02f, -5.10688350e-02f, -4.16300260e-03f, 9.11023915e-02f, -3.25041078e-02f,
  -1.38385832e-01f, -2.98258569e-02f, -3.86599381e-03f, 5.69857433e-02f, 8.30079764e-02f, -1.04054645e-01f, 3.84846665e-02f, 5.81414327e-02f, -1.07121803e-01f, 8.97940323e-02f,
  7.12821484e-02f, -2.44149957e-02f, 1.74413472e-02f, -9.12784263e-02f, -3.60681489e-02f, -1.41450460e-03f, 8.61300249e-03f, 1.93632394e-02f, 1.07174451e-02f, 5.43777011e-02f,
  6.70263451e-03f, 8.31388012e-02f, 1.09919280e-01f, -3.42501588e-02f, 4.27183881e-02f, -3.73163782e-02f, 1.40994620e-02f, -4.01025936e-02f, -1.65459830e-02f, -2.65183691e-02f,
  -1.46001950e-02f, 1.37140760e-02f, 4.14422564e-02f, 1.29300053e-03f, -2.81011648e-02f, -1.13441512e-01f, 3.83261009e-03f, -7.06995558e-03f, -7.83127323e-02f, 6.70924112e-02f,
  -1.48237413e-02f, -2.16459874e-02f, -4.92896698e-02f, -1.21706337e-01f, 7.60618076e-02f, -2.44630990e-03f, -5.32382801e-02f, 6.34232629e-03f, 1.99567080e-02f, -1.08782697e-04f,
  -2.74403933e-02f, -8.34791139e-02f, -5.15178554e-02f, -9.40414891e-02f, -5.21055982e-02f, -6.23364300e-02f, 3.42768021e-02f, -7.68560497e-03f, 5.31717688e-02f, -5.05067110e-02f,
  -8.99092704e-02f, -6.44597113e-02f, 6.38153357e-03f, 2.45445874e-03f, -3.45536764e-03f, 2.93271765e-02f, -4.35030535e-02f, 2.46684067e-03f, -6.89672977e-02f, -8.89635831e-02f,
  2.42601354e-02f, 3.74395512e-02f, 3.60599868e-02f, -1.93654038e-02f, -7.87348896e-02f, -6.53178096e-02f, 1.25827283e-01f, -3.23933437e-02f, -5.45947552e-02f, -1.22562565e-01f,
  4.13526207e-01f, -1.88721150e-01f, -3.13873589e-01f, 1.60522819e-01f, 1.71682224e-01f, -6.93388134e-02f, 3.57311442e-02f, -3.42378169e-02f, 5.92755452e-02f, -1.66368917e-01f,
  3.77377309e-02f, -3.18759531e-02f, -1.49959493e-02f, -1.90560564e-01f, 1.55227333e-01f, -2.04493240e-01f, -7.47150974e-03f, 3.57421488e-02f, -6.93431199e-02f, 9.21617597e-02f,
  7.99493641e-02f, 1.89852551e-01f, -1.51747912e-01f, -8.90251845e-02f, 3.00698038e-02f, -9.30105671e-02f, 3.44720930e-02f, -1.46454066e-01f, -5.57400584e-02f, 6.13758713e-02f,
  4.79739718e-02f, 1.12537006e-02f, -1.07023530e-01f, -8.96083042e-02f, 1.04436846e-02f, 9.27696005e-03f, 2.96382494e-02f, -8.10267478e-02f, -5.13768271e-02f, 1.40496087e-03f,
  4.24307734e-02f, 1.11696847e-01f, -3.06506082e-03f, -1.14363864e-01f, 5.33190109e-02f, -6.90318570e-02f, 3.39323422e-03f, -1.52281702e-01f, -2.16818377e-02f, -1.04024947e-01f,
  -6.94434941e-02f, 3.17920111e-02f, -3.65291461e-02f, -1.56166898e-02f, -4.97833034e-03f, 2.04662941e-02f, -8.94936025e-02f, -5.92981046e-03f, 7.17669725e-02f, -3.04768477e-02f,
  -5.06908335e-02f, 4.84832563e-02f, -7.76166320e-02f, 3.06977462e-02f, 3.63566689e-02f, -9.09880362e-03f, -6.69348314e-02f, 2.26367712e-02f, 4.98347450e-03f, 1.17427230e-01f,
  1.50330529e-01f, 3.79289985e-02f, 4.55049761e-02f, -3.59114334e-02f, 6.49518566e-03f, 1.89402662e-02f, 2.76250057e-02f, 4.10142151e-04f, 4.50054333e-02f, -6.04168475e-02f,
  -4.89698583e-03f, 5.06779812e-02f, 8.06386396e-02f, 2.31416076e-02f, 1.31591968e-02f, 3.75465490e-02f, -2.63296384e-02f, -1.14301652e-01f, -4.05447371e-02f, 1.87145192e-02f,
  2.07118437e-01f, 1.45785958e-01f, 2.81541492e-03f, 8.37473720e-02f, -1.93757508e-02f, -3.82433236e-02f, -1.31905884e-01f, -6.76084533e-02f, -5.75830787e-02f, 3.59833017e-02f,
  1.33482385e-02f, 8.33090544e-02f, 9.16784480e-02f, 1.54399518e-02f, 1.48126967e-02f, -8.99504498e-03f, 1.07788652e-01f, 9.11731832e-03f, 1.30955622e-01f, 2.15519611e-02f,
  -1.44663360e-03f, 2.42786463e-02f, 3.30755785e-02f, 5.15441550e-03f, 1.37620019e-02f, 1.33248776e-01f, -9.95875336e-03f, -4.87246290e-02f, 2.63295658e-02f, 1.49924457e-02f,
  1.50080264e-01f, -1.58788115e-01f, 4.39108796e-02f, 4.20172140e-03f, 3.65356177e-01f, 9.54515859e-02f, -2.99816187e-02f, 1.95861212e-03f, -1.68919899e-02f, -2.50033677e-01f,
  -9.87670384e-03f, -2.18187243e-01f, -2.59715617e-01f, -1.15529194e-01f, 1.84770003e-01f, -2.49472484e-01f, 1.45335183e-01f, -7.94119239e-02f, -2.10785344e-02f, 9.58752856e-02f,
  1.04083449e-01f, 7.71230906e-02f, 1.29618794e-01f, 8.83984268e-02f, 2.39085585e-01f, 2.67637432e-01f, 2.23217830e-01f, 1.15113370e-01f, 2.16953263e-01f, 9.14151669e-02f,
  1.52666166e-01f, -1.09912492e-01f, -3.99379805e-02f, -5.95610999e-02f, 1.25233099e-01f, 5.12316413e-02f, 5.54463491e-02f, -1.64935678e-01f, -2.29419805e-02f, -7.06916228e-02f,
  -1.88544005e-01f, 5.85077964e-02f, 4.38082553e-02f, -1.07573070e-01f, -1.51969707e-02f, 4.59600873e-02f, 2.89103258e-02f, 4.40598167e-02f, -2.54991055e-02f, -4.81094345e-02f,
  -1.27160758e-01f, 4.46794517e-02f, -1.28790662e-02f, 2.68222857e-03f, 3.22386324e-02f, 2.85173841e-02f, 3.13070193e-02f, 9.33992267e-02f, -7.33746514e-02f, 1.47459388e-01f,
  -1.11059055e-01f, 3.63277681e-02f, -5.08198440e-02f, -3.67801562e-02f, -8.23695883e-02f, 3.67485471e-02f, -1.04365170e-01f, 1.99275576e-02f, -1.34785734e-02f, 7.26145059e-02f,
  1.41412362e-01f, -2.25028526e-02f, -6.18450567e-02f, -1.28498459e-02f, -5.22755785e-03f, -1.05634285e-02f, -4.69089337e-02f, -1.57123998e-01f, 1.10373698e-01f, -2.75919326e-02f,
  -4.63128351e-02f, 7.72697479e-02f, 7.92170912e-02f, 1.23453930e-01f, -7.93846138e-03f, 1.65158361e-02f, -4.79418859e-02f, -5.53163737e-02f, -9.01314616e-02f, -1.64327119e-02f,
  2.22226098e-01f, 1.54437780e-01f, -5.57606220e-02f, 1.25272041e-02f, -4.79919184e-03f, 3.48777063e-02f, -8.60889405e-02f, -1.07934549e-01f, 1.15708716e-01f, -1.03131332e-01f,
  -7.88177997e-02f, -4.82882373e-03f, 1.70404702e-01f, 1.08188823e-01f, -2.51763966e-02f, 8.57540965e-02f, 3.49181518e-02f, 2.86213271e-02f, 7.77297541e-02f, 3.30851711e-02f,
  -7.74233043e-02f, 6.58741295e-02f, -7.48509467e-02f, 1.58853441e-01f, -1.50038064e-01f, 7.06486702e-02f, -5.29299080e-02f, 2.33340450e-02f, -3.90273742e-02f, -1.34109985e-02f,
  -3.46248835e-01f, 3.13640654e-01f, 6.02184385e-02f, 1.48888960e-01f, -1.47276714e-01f, -9.55117047e-02f, -1.05745569e-01f, 8.35597515e-02f, -1.51425362e-01f, 2.34595999e-01f,
  6.64410368e-02f, -9.54197906e-03f, -4.45837639e-02f, 1.76011577e-01f, -4.45178777e-01f, -1.33701518e-01f, 1.32240683e-01f, 1.09746791e-01f, -9.82910767e-02f, 5.71081936e-02f,
  -8.08580741e-02f, -5.94539428e-03f, -2.87613235e-02f, 3.70118506e-02f, 7.14065731e-02f, 1.32523745e-01f, 1.52123734e-01f, 5.69705218e-02f, 2.96582162e-01f, -2.19714977e-02f,
  -2.94850506e-02f, 4.90146801e-02f, -8.02704599e-04f, 3.51797324e-03f, 7.27070868e-02f, 2.38069296e-02f, 4.73260731e-02f, -8.68652165e-02f, -1.12384051e-01f, 3.97524424e-02f,
  -6.50120676e-02f, -6.40222058e-02f, 1.19601581e-02f, -9.90490317e-02f, 1.54343639e-02f, 3.72366980e-02f, -4.22229432e-02f, 1.64509267e-02f, 2.91579217e-02f, 3.53474682e-03f,
  8.72909185e-03f, 5.08849621e-02f, 6.50775433e-02f, 1.08864963e-01f, -4.96939868e-02f, 5.08852815e-03f, -5.19408435e-02f, 6.77732527e-02f, 5.49965873e-02f, 2.02838797e-02f,
  2.77699847e-02f, -6.87227771e-02f, -1.23743676e-01f, -9.82856080e-02f, -1.09683499e-01f, -6.83379918e-02f, -8.02669600e-02f, -5.95642254e-02f, 1.72725935e-02f, 8.46578041e-04f,
  -3.20449956e-02f, -3.55921276e-02f, 7.40212621e-04f, 3.59015241e-02f, 1.88840497e-02f, -5.00922017e-02f, -1.20090187e-01f, -4.58220094e-02f, 7.29724839e-02f, -4.95683253e-02f,
  -6.85423538e-02f, -3.24660093e-02f, 6.34074258e-03f, 1.65839940e-01f, -1.11551257e-02f, 2.14288998e-02f, 2.82493257e-03f, 5.35428822e-02f, -3.24584730e-02f, -7.56629452e-04f,
  1.39061466e-01f, 2.71550268e-01f, -2.11900137e-02f, 3.35062146e-02f, 4.12011892e-03f, 7.40769356e-02f, 3.89017425e-02f, 7.68155418e-03f, 4.87264544e-02f, 2.40674131e-02f,
  6.26437739e-02f, -2.71009207e-02f, 8.73689726e-02f, 1.40083596e-01f, -2.35395562e-02f, 8.95517617e-02f, -1.97895858e-02f, -1.24321617e-02f, 1.30491018e-01f, 3.97460684e-02f,
  2.33747158e-02f, -9.61515084e-02f, -9.77139845e-02f, -2.09982395e-02f, 4.03739624e-02f, 5.74850552e-02f, -4.33336794e-02f, 2.92451065e-02f, 7.45698363e-02f, 1.46074831e-01f,
  9.66981798e-02f, 1.67991281e-01f, -6.99426085e-02f, 1.46149129e-01f, 1.20956011e-01f, -2.14286402e-01f, -9.20939669e-02f, 1.38508037e-01f, 1.80575147e-01f, 2.39243403e-01f,
  1.55999795e-01f, -8.52075294e-02f, 6.62799403e-02f, -1.58805549e-02f, -3.86832088e-01f, -9.55667123e-02f, -1.82409972e-01f, -9.25393254e-02f, 7.28376061e-02f, 9.81884599e-02f,
  2.53420509e-02f, 1.47887930e-01f, -1.28242865e-01f, 2.63023436e-01f, 9.00225639e-02f, 1.04977831e-01f, 1.22753337e-01f, 1.30400266e-02f, 1.07022576e-01f, -1.38736144e-01f,
  -1.41929001e-01f, 2.09671199e-01f, -3.70522984e-03f, -7.14579746e-02f, 3.07251904e-02f, 4.70067859e-02f, -1.03430033e-01f, -7.05667138e-02f, -4.08388935e-02f, 1.97854750e-02f,
  -6.22412972e-02f, -5.08161709e-02f, 7.27910623e-02f, 1.13664947e-01f, 1.64202228e-02f, 8.56049638e-03f, -3.59600224e-02f, -3.93070206e-02f, -7.94289913e-03f, 1.19126877e-02f,
  2.63214521e-02f, -1.37784317e-01f, -2.18930212e-03f, -2.44579427e-02f, -4.01424840e-02f, 1.06479740e-02f, -3.98987234e-02f, -9.30694342e-02f, -3.95811759e-02f, 3.14194672e-02f,
  1.15526579e-01f, -5.74853979e-02f, 8.24359283e-02f, -7.04246834e-02f, -2.27794964e-02f, 1.00656962e-02f, 1.12868950e-01f, -1.23023968e-02f, -9.49705765e-02f, -3.78169790e-02f,
  -5.51536940e-02f, 6.74239844e-02f, 3.91100608e-02f, 8.82775895e-03f, 7.57598784e-03f, -3.14570172e-03f, -7.89959729e-02f, 5.21518141e-02f, 3.67278308e-02f, 1.41549967e-02f,
  -3.39186154e-02f, -8.74230713e-02f, -4.58422787e-02f, -5.91554120e-02f, -4.20822650e-02f, 1.30768120e-02f, 9.33121070e-02f, 8.77515599e-02f, -3.88435237e-02f, 9.67969745e-03f,
  -1.02342792e-01f, 1.34861529e-01f, -4.11987789e-02f, -1.59134474e-02f, -3.83033119e-02f, 4.46374863e-02f, 9.48856957e-03f, 5.69961667e-02f, 3.69831026e-02f, 4.66605499e-02f,
  4.98830667e-03f, -5.26013412e-02f, 1.17481844e-02f, 3.45172291e-03f, -1.01302393e-01f, 8.70562643e-02f, -3.87189575e-02f, 1.11621255e-02f, 1.23878354e-02f, -2.71669705e-03f,
  1.04254127e-01f, 7.02320412e-02f, 3.64336111e-02f, 8.24638605e-02f, 1.36446636e-02f, -4.40477841e-02f, 5.44014610e-02f, 7.48966355e-03f, -6.23591885e-04f, -9.14557725e-02f,
  1.11228228e-01f, 3.28074038e-01f, -1.32246632e-02f, -3.74324203e-01f, -2.83751965e-01f, -1.77376881e-01f, -2.75062114e-01f, -1.11545332e-01f, 3.24666165e-02f, -1.99782811e-02f,
  -3.83463562e-01f, 1.93846881e-01f, 4.69589680e-02f, -2.54001290e-01f, -2.78874874e-01f, 8.65703076e-03f, -2.02753425e-01f, -6.80644512e-02f, 7.35123083e-02f, -6.60659894e-02f,
  -2.14606076e-01f, -1.93928495e-01f, -2.49507055e-01f, -7.70942643e-02f, -1.11220926e-01f, 1.26398072e-01f, -1.06418945e-01f, -9.25675929e-02f, -1.62209108e-01f, 5.00709750e-03f,
  -5.90039641e-02f, 1.32824704e-01f, 1.04632162e-01f, 1.97645277e-01f, -2.97785271e-03f, 5.16333468e-02f, 8.41821432e-02f, 7.83788338e-02f, -1.62443928e-02f, 2.60842033e-02f,
  4.86718751e-02f, 2.82789208e-02f, -4.87648882e-02f, -4.09385152e-02f, -7.55209327e-02f, 1.35730393e-02f, -1.99521706e-03f, 1.71167776e-02f, 1.96653511e-02f, -1.02756515e-01f,
  1.58271976e-02f, -4.79388870e-02f, -4.41175289e-02f, -6.68457672e-02f, 6.93541616e-02f, -1.03314102e-01f, 2.92412192e-02f, -2.41256529e-03f, 6.37970418e-02f, -3.17962188e-03f,
  -8.70697573e-02f, 8.25333446e-02f, 1.14853300e-01f, 1.18371774e-03f, 8.14744458e-02f, 2.76035462e-02f, 6.32563159e-02f, 8.52298439e-02f, 9.42305326e-02f, -7.67895114e-03f,
  -5.19666411e-02f, 5.12331799e-02f, -6.46006763e-02f, 3.99835519e-02f, 2.62973476e-02f, 1.71380304e-02f, 1.30044669e-02f, 1.45196661e-01f, -4.75333966e-02f, -2.94981729e-02f,
  -9.09958314e-03f, 1.79731883e-02f, 4.59216125e-02f, -8.06780085e-02f, -2.85839979e-02f, -9.08894464e-02f, 7.29096383e-02f, 3.01494319e-02f, -8.49407837e-02f, 6.63388893e-02f,
  1.25361964e-01f, 4.17322934e-01f, 1.53353989e-01f, 5.51716648e-02f, 1.26197323e-01f, 9.63899419e-02f, 1.07994787e-01f, 1.79173484e-01f, 5.31769060e-02f, -1.32373739e-02f,
  -3.39790322e-02f, 1.00665437e-02f, -7.39311948e-02f, -6.41583577e-02f, -3.88378240e-02f, -3.93542554e-03f, -2.86659393e-02f, 6.10044412e-02f, 8.26046430e-03f, -4.29938436e-02f,
  2.62689162e-02f, -1.45624489e-01f, 8.03084970e-02f, 1.51365045e-02f, 9.78295505e-02f, -7.84457102e-02f, 8.42688754e-02f, -3.02860904e-02f, 3.48416977e-02f, 6.48530573e-02f,
  1.34534881e-01f, 2.51586854e-01f, 1.23791108e-02f, 3.55820283e-02f, -2.83270180e-01f, 3.31442654e-02f, -5.77132814e-02f, -1.06556125e-01f, -3.36219817e-01f, 1.67863935e-01f,
  -1.01022841e-03f, 1.65513515e-01f, 8.43010917e-02f, -2.89627742e-02f, 1.02257594e-01f, -3.70090976e-02f, 6.58916607e-02f, 9.97850671e-02f, -2.42543563e-01f, -5.34514757e-03f,
  1.45054460e-02f, -1.09543033e-01f, 1.06158793e-01f, -1.33655429e-01f, -1.56781282e-02f, 1.61862113e-02f, 2.94414014e-01f, -2.97792763e-01f, 1.54525310e-01f, -8.62184837e-02f,
  2.91845715e-03f, -2.53508657e-01f, -4.21701968e-02f, -4.89208885e-02f, -5.71009377e-03f, -3.36485021e-02f, 4.36347462e-02f, -7.52682090e-02f, -9.22256410e-02f, 3.39186341e-02f,
  2.05363989e-01f, -1.23541452e-01f, 1.83279009e-03f, -6.61854595e-02f, -6.68634567e-03f, 1.96238756e-02f, -7.11969612e-03f, -3.07609867e-02f, 8.45546648e-02f, 1.89590044e-02f,
  9.80726629e-02f, 2.65880842e-02f, 4.95601296e-02f, 6.19161353e-02f, 6.37750700e-02f, 3.62240039e-02f, -1.43797044e-02f, 8.16576332e-02f, 1.38074294e-01f, -1.12322951e-02f,
  2.60668062e-03f, -2.11551357e-02f, 3.65406759e-02f, 2.60903826e-03f, 1.76595822e-02f, -6.42864332e-02f, 4.16086353e-02f, -1.42467860e-02f, -8.25593099e-02f, 1.19619906e-01f,
  -1.05370805e-02f, -2.40752995e-02f, -5.25284186e-02f, -8.79325941e-02f, 2.88501270e-02f, 4.19820659e-02f, 1.13079377e-01f, -3.14808525e-02f, -2.53376942e-02f, 8.12275708e-03f,
  -7.13019073e-02f, 2.01712381e-02f, 1.21279377e-02f, 7.23513961e-03f, 7.52902776e-02f, 4.43358533e-02f, -2.08465885e-02f, -1.20099448e-03f, 6.52547693e-03f, 8.39314386e-02f,
  1.04512408e-01f, -1.76984459e-01f, -6.23335280e-02f, 1.44887930e-02f, -3.92219573e-02f, 3.96396592e-02f, -1.33159354e-01f, -5.52400500e-02f, -1.49694486e-02f, -7.16250017e-02f,
  5.69986142e-02f, -4.63734567e-02f, 8.93107150e-03f, -1.26942977e-01f, 8.98800120e-02f, -7.28230597e-03f, 3.39722298e-02f, 3.85904945e-02f, 1.40475214e-01f, 1.17943153e-01f,
  1.48028716e-01f, -1.25905797e-01f, 3.84420417e-02f, -4.46905643e-02f, 1.09823376e-01f, 1.18029915e-01f, 1.27307847e-01f, 1.50985003e-03f, -2.73844115e-02f, 2.79796012e-02f,
  -1.82437431e-02f, -7.92879239e-02f, -3.20585847e-01f, 2.24424084e-03f, 3.21002573e-01f, -1.63351014e-01f, -1.12347364e-01f, -2.95320004e-02f, -3.84323150e-01f, -1.81464657e-01f,
  2.11727485e-01f, -5.80332913e-02f, 3.87036093e-02f, -4.95507717e-02f, -2.99239270e-02f, -2.40104198e-01f, 1.55298654e-02f, 9.64482427e-02f, 4.47032414e-02f, 1.83069095e-01f,
  1.10361151e-01f, 2.45314062e-01f, 1.75074920e-01f, 1.25402689e-01f, 2.24542245e-01f, 9.54473242e-02f, 2.44352669e-01f, -6.12592604e-03f, 1.29821926e-01f, 5.77856749e-02f,
  1.21440053e-01f, -3.96523252e-02f, 3.08615398e-02f, -7.85246566e-02f, 5.93931340e-02f, -6.28425553e-02f, -1.23256375e-03f, 1.43205188e-02f, -1.09919510e-03f, 6.25672489e-02f,
  7.76493223e-03f, 1.19257286e-01f, -1.27677619e-03f, -1.31016806e-01f, -1.21897332e-01f, -1.13037061e-02f, 1.19632572e-01f, -2.51736064e-02f, 7.65375122e-02f, -6.45512566e-02f,
  -3.26668844e-02f, 9.22325253e-02f, -1.01776429e-01f, -1.99247636e-02f, 5.75045757e-02f, 7.10685849e-02f, -7.61096403e-02f, 2.09078528e-02f, 5.50781488e-02f, -3.85027304e-02f,
  -4.33263965e-02f, -1.56858191e-02f, -3.30473706e-02f, -6.75652847e-02f, -3.54423486e-02f, -3.56467925e-02f, -1.58541486e-01f, 1.65758692e-02f, 2.76026204e-02f, 1.27832457e-01f,
  6.61661029e-02f, 9.47270542e-03f, -3.64796259e-02f, -9.45657343e-02f, 3.62471165e-03f, -4.62683327e-02f, 4.52872254e-02f, -6.07865304e-03f, -4.45893183e-02f, -3.88954096e-02f,
  -1.01144075e-01f, 1.59160942e-02f, 1.42973870e-01f, 6.16580620e-02f, -7.65310675e-02f, 6.42947182e-02f, -6.70626685e-02f, -1.25962913e-01f, 8.34781080e-02f, 1.30999386e-01f,
  1.17419198e-01f, -7.26124225e-03f, 9.91353020e-02f, 9.04516578e-02f, 1.64506789e-02f, 7.41930529e-02f, -7.19317347e-02f, -1.49686420e-02f, -4.86894138e-02f, -1.59369707e-02f,
  5.91790490e-02f, 1.04100518e-01f, -3.74256447e-02f, -4.00891826e-02f, 5.19563816e-03f, -1.78978089e-02f, 6.65774494e-02f, 3.64459120e-02f, 1.16993010e-01f, 1.08202696e-01f,
  1.23818941e-01f, 1.00796767e-01f, -5.77291213e-02f, 5.67809716e-02f, 5.35328239e-02f, 4.74349111e-02f, -4.83703837e-02f, 2.72891740e-03f, 4.04147431e-02f, -2.48422921e-02f,
  3.55376929e-01f, -3.52175802e-01f, -2.89937824e-01f, 1.14299625e-01f, 3.34293321e-02f, -2.91596264e-01f, 3.59995931e-01f, -2.37210676e-01f, 1.89246565e-01f, 6.23649582e-02f,
  7.81902149e-02f, 4.09679674e-02f, 2.50630945e-01f, -2.67879725e-01f, -1.44316018e-01f, 1.11762784e-01f, -1.65220231e-01f, -2.68474817e-02f, 2.10157126e-01f, -2.33368780e-02f,
  9.18242633e-02f, 3.70802432e-02f, -8.25930312e-02f, -1.38413817e-01f, 8.63997042e-02f, 5.79411574e-02f, 4.62887995e-02f, 1.66484922e-01f, -2.87829608e-01f, -7.65809231e-03f,
  -6.52475376e-03f, 3.23169641e-02f, 1.95547510e-02f, -1.82842351e-02f, -1.38087422e-02f, 7.90483057e-02f, 5.92985637e-02f, 3.52202505e-02f, -2.21852716e-02f, -9.17045996e-02f,
  5.86021468e-02f, -1.21543473e-02f, 6.85338750e-02f, 2.28301771e-02f, 5.07583544e-02f, -9.39394236e-02f, 4.83633764e-03f, -1.16115250e-01f, -8.94951001e-02f, -2.17988417e-02f,
  4.66124788e-02f, -9.94840860e-02f, -5.96834794e-02f, 1.75965913e-02f, -4.11682948e-03f, -2.71603093e-02f, -5.46022505e-02f, 5.63306361e-02f, 1.86793711e-02f, -4.59518097e-02f,
  1.20921671e-01f, -1.33179903e-01f, -6.16207682e-02f, -7.74727091e-02f, -9.04996470e-02f, 1.34645253e-02f, -3.17361578e-02f, -2.56643649e-02f, 5.46778254e-02f, -9.94129628e-02f,
  -6.10447824e-02f, -8.09575766e-02f, -3.94887812e-02f, -5.20190112e-02f, -8.76154378e-02f, -7.24809840e-02f, -7.15085045e-02f, 3.60888056e-02f, 7.16541186e-02f, -5.66957667e-02f,
  -1.72969401e-02f, 5.54627227e-03f, 2.54915040e-02f, 3.81566398e-02f, -5.78184351e-02f, -3.79068367e-02f, -4.49266694e-02f, -2.97586359e-02f, 1.69759598e-02f, -9.83715616e-03f,
  -1.01458982e-01f, -1.57735959e-01f, 8.82724822e-02f, 1.54539272e-02f, 1.01336157e-02f, 3.51057714e-03f, 6.72744662e-02f, -1.85462143e-02f, -3.79464291e-02f, -1.30497128e-01f,
  -8.36373195e-02f, 1.06111363e-01f, 3.27522159e-02f, -4.64141518e-02f, -4.20962684e-02f, 3.47743160e-03f, 1.41941518e-01f, 4.40473855e-03f, 9.89195146e-03f, -1.42276987e-01f,
  -3.63886952e-02f, 8.70054588e-02f, -4.51796968e-03f, -5.45421541e-02f, -1.16843265e-03f, 8.04937407e-02f, -3.34669016e-02f, 1.79097988e-02f, 4.15340662e-02f, -2.81299409e-02f,
  -1.61445379e-01f, 2.06680357e-01f, -2.53845751e-01f, -8.26299414e-02f, 2.08618298e-01f, 4.87832306e-03f, -3.54232341e-01f, -6.11951947e-02f, -2.28263885e-01f, -6.15812615e-02f,
  -1.16862252e-01f, -7.35001117e-02f, -1.44806921e-01f, -1.49353892e-01f, -8.94876793e-02f, -1.47423178e-01f, -1.75497577e-01f, -1.48127198e-01f, 1.36343017e-01f, -6.54787198e-02f,
  -1.38773804e-03f, 1.24796465e-01f, -1.62845999e-01f, 1.55097961e-01f, -5.68196215e-02f, -1.13873146e-02f, -5.37463510e-03f, -1.01862289e-02f, -1.12160379e-02f, 1.06980212e-01f,
  2.05433853e-02f, -1.55705467e-01f, -1.81533605e-01f, -8.92932937e-02f, -3.27465311e-02f, -5.24205044e-02f, -6.97717741e-02f, 1.02158822e-02f, -3.47039141e-02f, 6.24710210e-02f,
  6.16821349e-02f, 1.51289910e-01f, 2.83089150e-02f, -1.24506168e-01f, -6.71276748e-02f, 3.22024352e-05f, 6.58945888e-02f, -9.66124311e-02f, 2.45369468e-02f, 9.01400372e-02f,
  -3.91480327e-02f, 3.49688418e-02f, -7.06818625e-02f, -4.13591713e-02f, -3.21811326e-02f, 4.76257205e-02f, 7.90240318e-02f, 7.09939823e-02f, 3.89056429e-02f, 6.41515031e-02f,
  6.69209752e-03f, -1.79874115e-02f, 8.01694952e-03f, -3.06287631e-02f, -3.50343920e-02f, 9.37139168e-02f, -7.67784640e-02f, 7.79100284e-02f, 7.54067451e-02f, 6.89402362e-03f,
  6.91932142e-02f, 2.64760964e-02f, 4.91626188e-02f, -1.14747368e-01f, -3.71982865e-02f, -2.19982360e-02f, -1.00928918e-01f, -6.03429340e-02f, 2.51316614e-02f, -6.15283772e-02f,
  -1.08961672e-01f, 1.18126059e-02f, 5.13711460e-02f, 9.74805653e-02f, -4.65076752e-02f, -7.57284230e-03f, -3.79594304e-02f, -7.68817365e-02f, -6.63395524e-02f, 8.18755925e-02f,
  -9.29361582e-02f, -2.83242255e-01f, -8.45295787e-02f, 5.50789349e-02f, 4.05966416e-02f, 3.83910052e-02f, 3.44035961e-02f, 6.03898466e-02f, -1.19214684e-01f, -7.20715299e-02f,
  5.30648194e-02f, -1.25477742e-02f, 4.28098142e-02f, -2.09868308e-02f, -2.62100827e-02f, -1.20886760e-02f, -4.32314724e-02f, -1.36721522e-01f, -4.59241383e-02f, 2.18707789e-02f,
  -1.63537070e-01f, -6.49688914e-02f, 5.72064705e-02f, 1.05533274e-02f, -3.86008248e-02f, 1.91891491e-02f, -1.72238305e-01f, 1.44319147e-01f, 1.01226166e-01f, 2.24498734e-01f,
  -3.57855797e-01f, 2.08408032e-02f, -1.88922882e-01f, -3.54097262e-02f, 7.75629357e-02f, 3.93598601e-02f, 1.70387074e-01f, 9.35504064e-02f, 1.26475856e-01f, 9.60758105e-02f,
  2.53899425e-01f, 3.21728624e-02f, 2.07113251e-01f, 2.23493338e-01f, 2.12945834e-01f, 2.18654171e-01f, -8.13508630e-02f, 1.96029134e-02f, -1.04432568e-01f, 8.11216515e-03f,
  -2.44919304e-02f, 1.89121738e-01f, -7.21314400e-02f, -8.31941550e-04f, -5.71242953e-03f, -2.08121359e-01f, -1.82862319e-02f, 1.49413481e-01f, -2.07454953e-02f, 9.27255973e-02f,
  -1.30999908e-01f, -1.28447767e-02f, -4.26693410e-02f, -6.07565418e-03f, -4.18382213e-02f, -9.68424082e-02f, -1.75835446e-01f, 4.24893349e-02f, 1.70624569e-01f, 1.39325157e-01f,
  -5.56157343e-02f, 2.12742873e-02f, -1.04478106e-01f, -6.40477762e-02f, -6.17976487e-02f, -2.86285765e-02f, 1.40661839e-02f, -1.41926259e-01f, 5.16060516e-02f, -1.01557150e-01f,
  3.65188383e-02f, -7.35971183e-02f, -6.54436797e-02f, 8.90714154e-02f, -5.56103513e-02f, -5.80101041e-03f, -1.95945967e-02f, -1.50375500e-01f, -2.52615996e-02f, -4.37903330e-02f,
  4.33678776e-02f, 5.97786270e-02f, 2.69084759e-02f, -1.01065114e-01f, 1.26743495e-01f, -9.00485292e-02f, 1.21060245e-01f, -8.06469694e-02f, -7.51906708e-02f, 2.99629843e-04f,
  -7.82807469e-02f, -7.16727301e-02f, -8.69191736e-02f, -1.23372868e-01f, -4.15975824e-02f, -5.67400753e-02f, -4.18028496e-02f, 3.36258160e-03f, -2.22709730e-01f, -8.46867487e-02f,
  6.64013699e-02f, 5.68140224e-02f, 9.59674120e-02f, -8.76101255e-02f, 1.82054102e-01f, 5.66217154e-02f, -6.26401156e-02f, -2.89407112e-02f, 1.15165241e-01f, -4.27810028e-02f,
  8.90991017e-02f, 1.12079285e-01f, 2.14394480e-02f, 4.61546555e-02f, 1.29405454e-01f, -3.42147090e-02f, -5.53725883e-02f, -9.09302309e-02f, 8.43406394e-02f, 1.01359673e-01f,
  -2.67766178e-01f, -4.52064909e-02f, -5.76052181e-02f, -3.84316668e-02f, 8.54960233e-02f, -9.73800849e-03f, 1.03482120e-01f, 5.07271588e-02f, -4.24142182e-02f, -8.17643479e-02f,
  8.33548009e-02f, 9.19604897e-02f, 1.08311944e-01f, -4.68387008e-02f, -2.71278266e-02f, -2.10453440e-02f, 7.51598477e-02f, -1.04515843e-01f, -1.04513995e-01f, -6.36378080e-02f,
  -4.99041140e-01f, 2.86912292e-01f, -2.89410323e-01f, 1.76351488e-01f, 4.22668271e-03f, 1.83045343e-02f, -6.81315213e-02f, 1.58255935e-01f, -5.74184433e-02f, 3.34836602e-01f,
  2.52481997e-01f, -1.26369312e-01f, 9.09184664e-02f, 3.71953666e-01f, -2.61414021e-01f, 7.84452483e-02f, 8.63145739e-02f, -5.60282124e-03f, -1.70382168e-02f, 1.47187859e-01f,
  2.29587103e-03f, 4.16484863e-01f, 8.69864821e-02f, 3.52584422e-01f, 3.56459953e-02f, -1.39572963e-01f, 1.64038733e-01f, -3.57961357e-02f, 1.83889389e-01f, 4.76156212e-02f,
  9.57039930e-03f, 1.01451360e-01f, 1.97412516e-03f, -6.34922981e-02f, -7.12722316e-02f, -7.31888041e-03f, 2.31704954e-02f, -8.42409655e-02f, -1.37059763e-01f, -1.30397584e-02f,
  -1.11816727e-01f, 1.23656720e-01f, -4.90492247e-02f, 1.88334826e-02f, 2.25449000e-02f, -4.49118689e-02f, -6.95407316e-02f, 3.52626815e-02f, 4.68381867e-02f, -5.93111888e-02f,
  -7.45679364e-02f, -7.08788335e-02f, -3.05285584e-02f, 2.86120735e-02f, -8.50682333e-02f, -3.61138135e-02f, -1.36080505e-02f, -5.55161051e-02f, -5.36336713e-02f, 6.64936677e-02f,
  -7.61764720e-02f, 4.98664333e-04f, 8.74443632e-03f, -2.25056475e-03f, 3.92052578e-03f, 8.62550884e-02f, 4.63842526e-02f, 3.06137484e-02f, -5.96423149e-02f, 4.76099504e-03f,
  2.24675816e-02f, -3.77270132e-02f, 1.25897946e-02f, 6.45675436e-02f, 2.98370421e-02f, 1.70103982e-02f, -7.80466124e-02f, 1.79827660e-02f, -2.05991026e-02f, 9.04828496e-03f,
  3.54508646e-02f, 1.96017325e-02f, -9.45087597e-02f, 2.52875127e-02f, 5.38566150e-03f, -1.13397740e-01f, 1.54631525e-01f, 2.75271200e-02f, -8.11895877e-02f, 1.72531176e-02f,
  1.13746665e-01f, 2.09288612e-01f, 2.06367020e-02f, 7.29946271e-02f, 3.54522839e-02f, 2.13045273e-02f, 2.52368790e-03f, -2.72843037e-02f, 2.09278706e-02f, 1.06522769e-01f,
  -3.72715294e-03f, -1.85573176e-02f, -6.88769892e-02f, 8.99398103e-02f, -3.81054170e-02f, 2.86800824e-02f, -1.76583081e-02f, -4.01751399e-02f, -3.73435244e-02f, 4.25402680e-03f,
  2.99952701e-02f, -7.70799741e-02f, -1.70850661e-02f, 7.75029212e-02f, 1.10423006e-02f, -2.99905408e-02f, -7.65096173e-02f, -2.11733170e-02f, 1.46125639e-02f, 2.57336423e-02f,
  -3.53644311e-01f, -8.54711682e-02f, -1.04255646e-01f, -3.73334944e-01f, -2.07318112e-01f, 8.20327103e-02f, 1.52221277e-01f, -1.84159368e-01f, -1.27995238e-01f, 1.65428430e-01f,
  2.18877885e-02f, -5.74889667e-02f, 2.39528149e-01f, -6.35368936e-03f, -2.41200671e-01f, 2.60591924e-01f, -2.33908355e-01f, 3.24619040e-02f, 4.15738858e-03f, -1.93903655e-01f,
  -1.75078958e-01f, -1.21447749e-01f, -1.36502594e-01f, 3.22459731e-03f, -2.12300912e-01f, -6.34336472e-02f, 1.02378108e-01f, 8.53470862e-02f, -6.46300428e-03f, 2.85174996e-02f,
  -5.98229021e-02f, -1.00230344e-01f, 6.51549399e-02f, 3.32275666e-02f, -1.23170629e-01f, 6.39768764e-02f, 2.97452020e-03f, 1.08728684e-01f, 1.96878929e-02f, -4.90311347e-02f,
  1.36527091e-01f, -1.83387026e-01f, -3.78313102e-02f, 1.50988832e-01f, -6.05014227e-02f, -7.12357834e-02f, -9.42847282e-02f, 3.06891818e-02f, -1.49114374e-02f, 3.58000211e-02f,
  -2.53339782e-02f, -1.85448378e-01f, -2.37525422e-02f, 3.62896100e-02f, 2.44545005e-02f, -1.67280044e-02f, 4.29191850e-02f, -2.87628770e-02f, -1.40092999e-01f, -1.02090031e-01f,
  3.12681645e-02f, 9.93630961e-02f, 8.30791295e-02f, 1.49344802e-02f, 2.11991905e-03f, -6.71698304e-04f, 1.32317200e-01f, -4.00747359e-02f, -2.00570747e-02f, -3.51384021e-02f,
  -5.62312678e-02f, 6.44474551e-02f, -6.17950223e-02f, 4.77349237e-02f, 4.50983979e-02f, 1.77296232e-02f, 8.96104425e-02f, 1.31273523e-01f, -3.29998359e-02f, 4.77285571e-02f,
  4.92017418e-02f, -6.84006885e-02f, -4.54121642e-02f, -1.43862814e-01f, -5.66727389e-03f, -6.07277341e-02f, 7.76120052e-02f, 2.74268333e-02f, 5.25258295e-02f, 5.97776175e-02f,
  -9.01127905e-02f, -1.53172240e-01f, 1.26592182e-02f, -7.55563080e-02f, 3.54250260e-02f, -3.99220176e-02f, 8.18903893e-02f, 9.69673917e-02f, 1.74320932e-03f, -1.67637505e-02f,
  -2.67962422e-02f, -6.45217150e-02f, -1.07764296e-01f, 2.01208107e-02f, -1.24892220e-02f, 2.47745439e-02f, -4.52331789e-02f, 8.77281204e-02f, -1.34346813e-01f, 2.54810657e-02f,
  5.23806140e-02f, -2.63552889e-02f, -4.67999205e-02f, -9.11019444e-02f, 4.87608090e-02f, -1.01315953e-01f, 3.59239280e-02f, -3.83885168e-02f, 1.06719825e-02f, -2.12764293e-02f,
  4.27050032e-02f, -7.98730832e-03f, -2.82804877e-01f, 6.55393526e-02f, 2.04025105e-01f, 1.66784450e-01f, 2.12071426e-02f, 8.33749920e-02f, -8.58035833e-02f, 5.72608002e-02f,
  5.24189919e-02f, -1.29262656e-01f, -9.73016173e-02f, 6.83348030e-02f, -8.56034383e-02f, -2.48019665e-01f, 2.33177856e-01f, 5.97478412e-02f, -8.02938789e-02f, 2.11781472e-01f,
  -6.84948564e-02f, 2.70447224e-01f, -1.46246612e-01f, 1.79716453e-01f, 1.18727021e-01f, -7.13182688e-02f, 4.95720133e-02f, -1.52381524e-01f, 1.33459866e-01f, 5.87870777e-02f,
  1.53156012e-01f, -4.54747640e-02f, -4.25037332e-02f, -6.52403682e-02f, 1.01950124e-01f, 8.08225647e-02f, -4.02746350e-03f, -1.67968459e-02f, -1.16158076e-01f, -3.08995713e-02f,
  1.00176305e-01f, -4.52752598e-02f, 9.30598080e-02f, -5.72452955e-02f, -1.99326519e-02f, -7.58065805e-02f, 1.84194986e-02f, -3.94495167e-02f, -3.56783271e-02f, -1.34438112e-01f,
  -1.28407985e-01f, -4.37318273e-02f, -3.70627083e-02f, -4.40277718e-02f, -7.96932280e-02f, 4.22622226e-02f, -1.40512371e-02f, 2.02740449e-02f, 9.99166369e-02f, 2.39600614e-03f,
  -3.19538973e-02f, -1.29887518e-02f, -5.62542193e-02f, 1.05174765e-01f, 4.37822454e-02f, 2.33105849e-02f, -2.91832760e-02f, 2.78211143e-02f, 3.62855494e-02f, 6.50990158e-02f,
  1.49271518e-01f, -1.49754416e-02f, 8.09287429e-02f, -1.26579190e-02f, 5.97030297e-02f, 1.27945453e-01f, 6.80095479e-02f, -2.08500642e-02f, 9.71347094e-02f, -1.27561549e-02f,
  -5.30009419e-02f, 4.14593741e-02f, 7.75032118e-02f, 1.08810915e-02f, -9.33962688e-02f, -3.48835327e-02f, -6.39201179e-02f, -9.27214772e-02f, 1.69107206e-02f, 5.56780398e-02f,
  2.71059662e-01f, 2.30657220e-01f, 2.84652580e-02f, 1.94833670e-02f, 9.03646350e-02f, 4.16788459e-02f, -3.23490798e-02f, 3.89102846e-02f, -5.84040843e-02f, 1.46872904e-02f,
  1.56337872e-01f, 6.48237253e-03f, 1.62792578e-02f, 3.74903604e-02f, -2.20670793e-02f, -5.16596660e-02f, 5.19963987e-02f, 5.61384000e-02f, 1.53814480e-01f, 1.67387232e-01f,
  -5.02186455e-03f, 5.41321076e-02f, -2.83852704e-02f, -1.34676378e-02f, 1.64490417e-02f, 1.20558307e-01f, -1.85640678e-02f, 9.42566898e-03f, 2.06805579e-02f, 8.54253247e-02f,
  -1.84508950e-01f, -7.78280348e-02f, -1.09484047e-01f, -2.97290295e-01f, 1.78561136e-01f, -1.10571064e-01f, -1.51465505e-01f, 1.47275463e-01f, -1.58977047e-01f, 6.47671372e-02f,
  -1.69422120e-01f, -3.19846928e-01f, -1.09515898e-01f, -4.14287448e-01f, -3.83392781e-01f, -1.22118525e-01f, -4.76567119e-01f, -3.06644291e-01f, -5.23667634e-02f, -2.02815682e-01f,
  -6.90063089e-02f, -1.33797480e-02f, -3.50314341e-02f, 2.97465026e-01f, 1.69657841e-01f, 2.43410945e-01f, 1.88978091e-01f, 2.38609686e-01f, 4.51406538e-02f, 3.59409824e-02f,
  -1.15763448e-01f, 1.74340070e-03f, 7.75801614e-02f, 2.72800941e-02f, 3.85886244e-02f, 3.52623221e-03f, -3.55525687e-02f, 5.98839344e-03f, 2.51749884e-02f, -1.27896797e-02f,
  -9.50800553e-02f, 1.95277017e-02f, -3.03565580e-02f, 6.97988123e-02f, 7.29446784e-02f, -2.91537847e-02f, -1.71015896e-02f, 9.12296493e-03f, 7.10364105e-03f, -4.14946973e-02f,
  -1.15939729e-01f, -8.87189209e-02f, -4.71253879e-02f, -4.95047448e-03f, -1.06855817e-02f, -8.38063136e-02f, 4.46774140e-02f, -8.39327425e-02f, -4.57827337e-02f, 1.12767197e-01f,
  1.03465766e-01f, 5.83366454e-02f, 4.51930948e-02f, -5.11001088e-02f, -2.35445779e-02f, -2.05561351e-02f, -4.72289976e-03f, 3.49190906e-02f, 8.76674708e-03f, -6.63134009e-02f,
  -5.02543785e-02f, 8.40707347e-02f, -6.71956390e-02f, -3.57140303e-02f, -6.92010997e-03f, -7.27601796e-02f, -4.83998097e-02f, 7.90818781e-02f, -4.78635393e-02f, 2.83357203e-02f,
  4.03524190e-02f, -1.16391212e-01f, 5.53221516e-02f, 4.75177094e-02f, -6.77116513e-02f, 3.65253389e-02f, 1.08282268e-01f, 5.06008603e-02f, -1.02985509e-01f, -1.58368908e-02f,
  -9.65481177e-02f, -1.79962795e-02f, 4.04287502e-02f, 6.52416646e-02f, -5.65387867e-02f, -7.41761178e-02f, -1.05885550e-01f, 3.21201384e-02f, 8.57217461e-02f, 2.84948666e-02f,
  -1.19776107e-01f, 6.17755577e-03f, 3.82118933e-02f, 2.47143279e-03f, -4.15696055e-02f, 1.43372372e-01f, -2.01271176e-02f, -1.89326368e-02f, 1.86912939e-02f, -1.10990806e-02f,
  3.74675691e-02f, -7.11769611e-02f, 1.07548431e-01f, 1.45343035e-01f, 5.97580932e-02f, -1.58037245e-02f, 3.92356887e-02f, -7.86408037e-02f, 3.11248912e-03f, -1.46343723e-01f,
  3.34025323e-01f, 4.80010435e-02f, 1.87586322e-01f, 3.57302636e-01f, -7.24652708e-02f, 2.28399187e-01f, 3.82699132e-01f, 5.64866373e-03f, 7.85870105e-02f, 1.19461857e-01f,
  4.95734327e-02f, 2.53354371e-01f, 1.01982215e-02f, 3.69467676e-01f, 3.86230424e-02f, 5.59625961e-02f, 2.73450315e-01f, 2.65291661e-01f, -1.33402899e-01f, 1.48273021e-01f,
  5.09628691e-02f, 1.02370635e-01f, 2.77561337e-01f, -1.96659654e-01f, 2.03440145e-01f, -9.07900706e-02f, -1.24430239e-01f, -1.52717978e-01f, 1.62194639e-01f, 9.82030667e-03f,
  5.97159602e-02f, -5.61936423e-02f, 2.64617149e-02f, -7.80021027e-02f, -2.91750208e-03f, 2.34248769e-02f, 9.90281850e-02f, -1.95212346e-02f, -1.36400595e-01f, 8.00821651e-03f,
  7.30295777e-02f, -6.10355884e-02f, 6.98365718e-02f, 4.69684862e-02f, 3.14523242e-02f, -2.08840407e-02f, 5.40326303e-03f, 6.92140386e-02f, -1.27480249e-03f, 1.39948174e-01f,
  4.75296564e-02f, 1.43297672e-01f, 6.89555034e-02f, 4.00157981e-02f, 2.56676525e-02f, 9.62348282e-02f, 2.47595217e-02f, 9.24006477e-02f, 3.50722708e-02f, 4.90527181e-03f,
  9.18683931e-02f, -1.40711039e-01f, -7.93236196e-02f, 1.45303784e-02f, -1.56432480e-01f, -1.67598911e-02f, -7.53299519e-02f, -3.91417146e-02f, -8.97423998e-02f, -7.61909084e-03f,
  -5.36026433e-02f, -2.52047628e-02f, 5.14259860e-02f, 6.44628853e-02f, -4.48253530e-04f, 4.72655930e-02f, -4.28071432e-02f, -1.35106239e-02f, 1.16068013e-01f, -4.29092273e-02f,
  -1.22599669e-01f, -9.87039432e-02f, -6.65857941e-02f, 1.03664093e-01f, -5.20295911e-02f, 9.84313246e-03f, -2.61975806e-02f, 2.84431372e-02f, 4.62879837e-02f, 2.21481286e-02f,
  -3.86518426e-02f, -1.99698612e-01f, -1.27553374e-01f, -9.09999982e-02f, -1.52389526e-01f, -4.66657430e-02f, 5.15217781e-02f, 1.14715546e-02f, -6.45924956e-02f, -4.94034588e-02f,
  1.78851306e-01f, -1.47508103e-02f, 4.68133166e-02f, 5.34853600e-02f, -3.00205825e-03f, -1.62818730e-02f, 7.45792612e-02f, -1.75955389e-02f, 3.23812328e-02f, -5.35221882e-02f,
  4.77333181e-03f, 9.15336385e-02f, -1.04116544e-01f, 4.31824010e-03f, 3.02333552e-02f, 1.05823107e-01f, 2.38029892e-03f, 9.89136472e-02f, -2.37872242e-03f, 2.89474409e-02f,
  -5.79663634e-01f, 1.06648572e-01f, -1.43325806e-01f, -1.96818203e-01f, -5.49588613e-02f, -2.18387365e-01f, -2.55399734e-01f, 6.55980483e-02f, -1.67342067e-01f, 1.80674493e-01f,
  1.17327437e-01f, -2.05092400e-01f, 2.18957677e-01f, -2.29874983e-01f, -3.54654253e-01f, -1.35293389e-02f, -2.15187490e-01f, -1.49877235e-01f, -4.59911488e-02f, 5.50546078e-03f,
  -6.03556335e-02f, -1.53093114e-02f, -5.52337766e-02f, 1.21733025e-01f, -1.64823979e-01f, 2.63763294e-02f, 1.00135520e-01f, 6.88128397e-02f, -1.01230070e-01f, -4.32108268e-02f,
  -1.16151161e-01f, 1.01247266e-01f, -1.52874226e-02f, 6.77394820e-03f, 3.65239158e-02f, 1.50356339e-02f, -5.76085709e-02f, -8.13608989e-02f, -1.21020013e-03f, 3.81212309e-02f,
  -4.11549471e-02f, 3.53670046e-02f, 1.28520012e-04f, -8.66170749e-02f, -1.14123046e-01f, -5.26946597e-02f, 7.21827224e-02f, -6.12346902e-02f, 5.57257943e-02f, -1.36156112e-01f,
  -1.84359085e-02f, 1.04956236e-02f, -3.51230316e-02f, 1.05747087e-02f, -5.10733835e-02f, -1.35038840e-02f, -7.13872239e-02f, -2.20547058e-02f, -1.26507860e-02f, -1.25476554e-01f,
  5.78097673e-03f, 1.18463747e-02f, -4.63477001e-02f, -2.67031658e-02f, -4.10167128e-02f, -1.47845224e-02f, -8.06729943e-02f, -1.86825786e-02f, -1.01118639e-01f, 1.68103240e-02f,
  4.70127910e-02f, -5.00489399e-02f, 1.35510927e-02f, -6.86838254e-02f, -4.44990173e-02f, -1.25648873e-02f, -4.76253256e-02f, -1.43356549e-04f, -5.54058887e-02f, -1.16021387e-01f,
  1.44034401e-02f, 1.25333285e-02f, 6.80247694e-02f, 8.52043107e-02f, 8.00697424e-04f, 3.48708853e-02f, 7.33987137e-04f, -6.16145507e-02f, 3.24407518e-02f, -4.49470393e-02f,
  6.64983764e-02f, 1.48557961e-01f, 6.58663064e-02f, -6.20843610e-03f, 3.01311780e-02f, -2.39807405e-02f, -9.70862135e-02f, -1.22605845e-01f, -2.50248332e-02f, -2.44560409e-02f,
  -1.55048333e-02f, 9.03162826e-03f, 9.19263735e-02f, -3.09921782e-02f, 1.03406503e-03f, -3.84649038e-02f, 7.81648681e-02f, 2.71193739e-02f, 1.41230673e-01f, 6.70437291e-02f,
  3.30867879e-02f, 1.74094811e-02f, -3.15666832e-02f, -7.30552375e-02f, -5.18693812e-02f, 1.01635896e-01f, -9.52353925e-02f, 2.59343777e-02f, 4.35366528e-03f, 6.51392192e-02f,
  -4.37705249e-01f, 1.66138455e-01f, -2.10458353e-01f, -2.50012338e-01f, 8.73596966e-02f, 9.95157734e-02f, -1.84461083e-02f, 6.59154654e-02f, -3.58822078e-01f, 2.05377206e-01f,
  6.83353767e-02f, -3.06310236e-01f, 1.53463869e-03f, 1.58190206e-01f, -2.50427991e-01f, -1.05893277e-01f, -2.44740248e-02f, 3.98464091e-02f, -2.02295765e-01f, -9.93393436e-02f,
  -1.60348400e-01f, 2.81633079e-01f, -5.07613644e-04f, 1.83433443e-01f, 2.30626315e-02f, -7.60892183e-02f, 6.10437989e-02f, 5.31152226e-02f, 1.38839141e-01f, 1.10899068e-01f,
  1.15006939e-01f, -4.16992232e-02f, -2.56338548e-02f, -2.74782628e-02f, -6.20329119e-02f, 4.26203422e-02f, 5.26557639e-02f, 4.96103540e-02f, -9.88451615e-02f, -1.98038202e-02f,
  -1.02415858e-02f, 8.17361996e-02f, -2.61954335e-03f, -4.30306606e-02f, 6.76248595e-02f, -3.95138375e-02f, -2.02816669e-02f, -6.93417937e-02f, -7.48906508e-02f, -1.16721950e-02f,
  -1.41775340e-01f, 9.41175446e-02f, -5.54849510e-04f, 4.89906892e-02f, -3.37031297e-02f, -3.84760574e-02f, 1.57717112e-02f, 5.63621223e-02f, -3.70452292e-02f, -8.44566524e-02f,
  -1.77673958e-02f, -4.49871384e-02f, -3.39101143e-02f, 1.09092608e-01f, 1.48767140e-03f, 9.05088987e-03f, -1.11359790e-01f, 6.03224486e-02f, -1.02418438e-01f, -2.86025386e-02f,
  -7.44803762e-03f, -9.26581100e-02f, 6.90704957e-02f, -3.87722962e-02f, -1.82511080e-02f, 2.90360153e-02f, -3.22575239e-03f, 3.78324650e-02f, -9.05283317e-02f, -1.08181953e-01f,
  -4.04483862e-02f, 4.91304733e-02f, 1.62816234e-02f, 1.05050266e-01f, 6.11590035e-02f, -2.01796517e-02f, -3.99599709e-02f, -1.01432391e-02f, 3.77665050e-02f, -1.02633469e-01f,
  -1.20002618e-02f, -1.22121595e-01f, -3.85276005e-02f, 1.90796088e-02f, -9.01599824e-02f, -5.32736555e-02f, -4.81513999e-02f, -4.27124090e-02f, -1.13736898e-01f, -3.02522127e-02f,
  6.92609772e-02f, 2.26566438e-02f, -2.91833971e-02f, -3.81416976e-02f, 8.95221606e-02f, -6.34579062e-02f, 1.55573850e-02f, -1.09633297e-01f, 3.45560047e-03f, 1.70134159e-03f,
  7.70828081e-03f, -9.80057716e-02f, 6.82760729e-03f, -5.69925718e-02f, 3.52754518e-02f, 1.26494646e-01f, -2.73936950e-02f, 5.32849096e-02f, 1.04434580e-01f, -2.74712290e-03f,
  1.36920676e-01f, 2.02811137e-01f, -1.25310272e-01f, 5.04405238e-02f, 3.04242015e-01f, -8.45031440e-02f, -3.45905796e-02f, 2.64594018e-01f, -8.54914561e-02f, -4.13435139e-02f,
  2.33974025e-01f, -2.96619952e-01f, 1.07747996e-02f, -1.73101965e-02f, -3.41023445e-01f, -2.78240085e-01f, -6.05653636e-02f, -1.03534594e-01f, -3.98283750e-02f, 1.31655946e-01f,
  1.31904706e-01f, 1.48830220e-01f, 6.94269910e-02f, 1.41972944e-01f, 3.51236731e-01f, 2.22174957e-01f, 8.77343640e-02f, 1.22679910e-02f, 2.69643161e-02f, -7.20139593e-02f,
  9.65363905e-02f, 4.65081632e-02f, 1.37970254e-01f, 8.47130790e-02f, 1.52499512e-01f, -6.44718185e-02f, -9.50614661e-02f, -4.20295745e-02f, 2.18536463e-02f, 1.25498073e-02f,
  6.69742748e-02f, 8.81657302e-02f, -9.31160897e-03f, -7.01541752e-02f, -1.80664491e-02f, 7.92494565e-02f, 1.21066503e-01f, 9.99971107e-02f, 1.00683853e-01f, -7.21718594e-02f,
  3.75723280e-02f, 7.78559968e-02f, -6.36634976e-02f, -9.30740032e-03f, 4.09917161e-02f, 3.14398040e-03f, -1.26626045e-01f, -4.83892262e-02f, 9.28075314e-02f, -5.56151643e-02f,
  -1.35582257e-02f, -9.59393084e-02f, -9.31219235e-02f, -1.33473366e-01f, 1.45997778e-01f, 7.30554685e-02f, -1.73213840e-01f, -2.80584749e-02f, -5.52665219e-02f, 1.38524488e-01f,
  8.09414685e-02f, 8.37137271e-03f, 4.15031239e-02f, 1.52134687e-01f, -8.26486275e-02f, 6.32676929e-02f, 5.11511005e-02f, 8.40902328e-03f, 4.78740074e-02f, -5.13000472e-04f,
  2.48451270e-02f, 1.39946312e-01f, 1.33389384e-01f, -6.41297475e-02f, 1.17325038e-02f, 1.23161823e-01f, -2.46567503e-02f, 1.82609670e-02f, -6.85544759e-02f, -1.33616542e-02f,
  2.48575732e-02f, 2.80123744e-02f, 1.44949809e-01f, 1.38581246e-01f, -4.86340448e-02f, -5.77256083e-02f, -1.10180587e-01f, -9.26407725e-02f, -6.57211170e-02f, 4.37259674e-03f,
  2.75130030e-02f, 2.04941094e-01f, 5.13806343e-02f, -4.88421842e-02f, 5.38162608e-03f, 2.59594396e-02f, 4.68774587e-02f, 1.61425937e-02f, 7.37898350e-02f, 8.95884559e-02f,
  1.70112774e-01f, 4.76384424e-02f, -1.25920326e-01f, -6.99613169e-02f, 1.85881350e-02f, -8.08482431e-03f, -8.06755945e-02f, -3.09803225e-02f, 2.99321935e-02f, -5.28669953e-02f,
  1.73198789e-01f, -4.15305853e-01f, -4.60566906e-03f, 1.52640492e-01f, 1.48709267e-01f, -1.64356038e-01f, -5.55131352e-03f, -6.18265122e-02f, -7.76781961e-02f, -3.26451033e-01f,
  -5.16739823e-02f, 1.66133046e-02f, -2.78891474e-01f, -4.26349014e-01f, -4.99387048e-02f, -3.41054440e-01f, -2.88165540e-01f, -1.49268776e-01f, -7.76169747e-02f, -2.84379832e-02f,
  1.04670852e-01f, -2.37775430e-01f, 1.76480822e-02f, -9.33151171e-02f, -1.20658176e-02f, 2.43734479e-01f, 1.25210479e-01f, 7.73519427e-02f, 3.39999869e-02f, -6.64213970e-02f,
  -1.04514539e-01f, -5.05265109e-02f, 5.55521138e-02f, -7.25560188e-02f, 4.07960489e-02f, 3.62681933e-02f, -2.76285224e-02f, -1.14799760e-01f, 1.84243694e-01f, -2.36249138e-02f,
  -1.67484075e-01f, 2.67942324e-02f, -3.12930942e-02f, -1.55462557e-02f, 9.69351642e-03f, 3.26205902e-02f, -8.32565501e-02f, 2.33938056e-03f, -4.83440571e-02f, 6.22901246e-02f,
  -1.09646823e-02f, -4.46306542e-03f, 2.68455930e-02f, 2.31545158e-02f, 1.36549190e-01f, 1.50676602e-02f, 1.30640045e-01f, 9.18588787e-02f, -3.46952491e-02f, 1.24260701e-01f,
  1.94541682e-02f, 1.08465567e-01f, 6.71340004e-02f, -1.60426721e-01f, 3.48164071e-03f, -1.24511449e-03f, -1.15362071e-01f, 9.93285980e-03f, 1.94735732e-02f, -7.89830908e-02f,
  4.82936203e-02f, 6.51622564e-02f, -2.02123106e-01f, 5.10855578e-03f, 7.43548498e-02f, -2.48055346e-02f, -3.91079411e-02f, -3.25891376e-02f, -3.59728863e-03f, 2.68689264e-02f,
  -5.67232221e-02f, -5.53656816e-02f, -6.03130832e-02f, -8.66530056e-04f, -1.44831389e-01f, 1.32535607e-01f, 2.06260346e-02f, -2.04411764e-02f, -8.04670677e-02f, -9.47927125e-03f,
  -2.07757682e-01f, -7.21479133e-02f, 3.28381024e-02f, -1.82123575e-02f, -7.54235014e-02f, -4.91143055e-02f, -1.23780102e-01f, -1.15153097e-01f, 6.44295849e-03f, 5.66399517e-03f,
  -1.24389697e-02f, 7.25776628e-02f, 1.76464133e-02f, 1.13447700e-02f, -4.23171856e-02f, 1.20933734e-01f, 1.25334673e-02f, 1.52447456e-02f, 3.93173955e-02f, 1.42693277e-02f,
  7.45659024e-02f, 3.27517428e-02f, -1.49671100e-02f, 1.17992319e-01f, 8.71640444e-02f, -3.92333865e-02f, 9.26032439e-02f, -4.48069312e-02f, -5.72798513e-02f, -1.03888050e-01f,
  5.86673796e-01f, -4.92991298e-01f, -2.18044683e-01f, -1.38567351e-02f, 1.90413237e-01f, 2.43101910e-01f, 1.03117734e-01f, -5.31300046e-02f, -1.62654277e-02f, -1.69009447e-01f,
  9.34665278e-02f, -9.53066573e-02f, -1.78722441e-01f, -1.05975188e-01f, 3.53799582e-01f, -9.73963216e-02f, 1.23430297e-01f, -2.11113412e-02f, 3.33549678e-02f, 3.15857902e-02f,
  9.87271369e-02f, 2.60324813e-02f, -5.47957830e-02f, -8.84303674e-02f, 2.88453028e-02f, -8.62288699e-02f, 2.17547198e-03f, -8.09334591e-02f, 8.19726363e-02f, 5.58105297e-02f,
  1.80545282e-02f, -2.94318404e-02f, -1.89285334e-02f, -1.15213379e-01f, 7.04414621e-02f, 7.95165077e-02f, 6.06904626e-02f, 2.86202878e-02f, 1.08722962e-01f, -2.08275225e-02f,
  4.11479324e-02f, -1.20794728e-01f, -1.83410645e-02f, 1.20263770e-01f, 4.66738380e-02f, 3.50382999e-02f, -7.81038925e-02f, 9.58533958e-02f, -9.75764692e-02f, 3.80698889e-02f,
  -2.72448920e-02f, -6.38875589e-02f, -1.59760769e-02f, -5.60569540e-02f, -1.09203365e-02f, -1.00226909e-01f, -5.40031865e-02f, -8.73953626e-02f, -1.36765325e-02f, 6.63921535e-02f,
  6.53460473e-02f, -3.51848379e-02f, 2.31673964e-03f, 1.54055040e-02f, -4.67222892e-02f, -3.08205769e-03f, 5.84424920e-02f, 7.28133414e-03f, -5.71866557e-02f, 4.77943495e-02f,
  1.01808729e-02f, 7.20409676e-02f, 9.66109708e-03f, 7.66898543e-02f, 8.02127197e-02f, -4.59199287e-02f, 5.39969876e-02f, 5.33617921e-02f, 7.54292831e-02f, 8.52944180e-02f,
  1.04404790e-02f, -9.76915881e-02f, -1.52074978e-01f, -4.45196703e-02f, -6.50915951e-02f, -4.51119952e-02f, 3.19956355e-02f, 4.31695543e-02f, -5.21899983e-02f, 1.21610366e-01f,
  -2.24746708e-02f, -2.20153138e-01f, -6.77734762e-02f, 9.77619435e-04f, -4.55634072e-02f, 6.96742237e-02f, 4.45249584e-03f, 8.33905488e-03f, 1.20917307e-02f, 3.57297547e-02f,
  1.02621444e-01f, -8.81343931e-02f, -3.32184881e-02f, 2.18272097e-02f, 2.74802442e-03f, -2.75341198e-02f, -1.08930722e-01f, 5.24633750e-02f, -1.04359714e-02f, 1.93515141e-03f,
  2.52942201e-02f, -1.51314322e-04f, 2.79972069e-02f, 8.53620693e-02f, 8.61039199e-03f, -2.58193668e-02f, 1.63782295e-02f, 4.27125953e-03f, -1.20152254e-02f, -6.10513017e-02f,
  -2.55296916e-01f, -3.09304297e-01f, -1.49521068e-01f, -2.52368659e-01f, 1.21809421e-02f, 2.66164541e-01f, 1.71867326e-01f, -1.36202186e-01f, -3.69997382e-01f, 2.68612504e-02f,
  7.95995165e-03f, -2.67525256e-01f, -2.59649940e-02f, -1.27544263e-02f, 1.21189430e-01f, 1.73452664e-02f, 8.60911831e-02f, 1.14515007e-01f, -2.28480101e-01f, -2.24488556e-01f,
  -1.29972041e-01f, 1.47373034e-02f, 7.39839673e-02f, -1.78333014e-01f, -1.38603032e-01f, -2.35017568e-01f, 4.82002944e-02f, -5.65016195e-02f, 1.17167607e-02f, 1.73502102e-01f,
  6.90762326e-02f, -2.08247319e-01f, -1.10929504e-01f, -3.92247885e-02f, 3.87454256e-02f, 5.16529158e-02f, 1.01807900e-01f, 3.86873260e-02f, -1.19413370e-02f, 3.11804693e-02f,
  -8.20218921e-02f, 2.64621116e-02f, -1.70033962e-01f, -6.89309388e-02f, 3.49929929e-02f, -1.56591505e-01f, -4.64534573e-02f, 2.17769276e-02f, -6.77672550e-02f, -5.98205673e-03f,
  -1.48669317e-01f, -2.92178374e-02f, 1.27966896e-01f, 5.73605709e-02f, -1.32699702e-02f, -2.93656141e-02f, 1.57750119e-02f, 4.13219035e-02f, -2.34975219e-02f, -9.33523849e-02f,
  3.42699699e-02f, -2.91937720e-02f, -1.02499992e-01f, -9.23217013e-02f, 2.36137901e-02f, 3.28994560e-04f, 4.95102117e-03f, 4.15019058e-02f, 9.77098569e-02f, 1.50600318e-02f,
  7.54193345e-04f, 7.76083721e-03f, -1.24540273e-03f, -5.78373149e-02f, -2.29786476e-03f, 6.24636598e-02f, 1.04650989e-01f, -8.05822313e-02f, -9.29467678e-02f, 1.05005759e-03f,
  -6.09608889e-02f, 7.53388032e-02f, -3.27578187e-02f, 1.15038916e-01f, 1.92785298e-03f, -5.06977551e-02f, -4.53961529e-02f, 6.33473229e-03f, -1.01071507e-01f, 1.52711561e-02f,
  2.94618495e-02f, -1.22178636e-01f, -5.88109270e-02f, -6.16020635e-02f, -2.03841496e-02f, -7.38188177e-02f, -1.00198314e-01f, -5.75545840e-02f, -4.71226275e-02f, 3.20831984e-02f,
  8.20815489e-02f, -4.60234657e-02f, -6.00169636e-02f, 1.23252552e-02f, 6.65729940e-02f, -4.64459823e-04f, -3.10150236e-02f, -8.94494429e-02f, 1.09927736e-01f, 4.23152633e-02f,
  -1.15740061e-01f, -1.06409550e-01f, 4.20044959e-02f, -6.96971714e-02f, 7.12227598e-02f, 1.05442904e-01f, -8.87250751e-02f, 1.05727836e-02f, 6.68898746e-02f, 4.91959564e-02f,
  7.34942630e-02f, -7.18026906e-02f, -1.91326201e-01f, 1.95801839e-01f, -1.76289871e-01f, 7.26082772e-02f, 2.26095617e-01f, -4.57520522e-02f, -4.02429625e-02f, 3.48143369e-01f,
  1.34839937e-01f, -8.80116895e-02f, -2.37824526e-02f, 2.79375881e-01f, -1.58160284e-01f, -6.60465062e-02f, 2.17312723e-01f, 1.76871151e-01f, -6.86239153e-02f, 2.56340861e-01f,
  -2.74862838e-03f, 2.04188913e-01f, -2.99966801e-02f, -1.81991365e-02f, 9.34984386e-02f, -1.32279973e-02f, 1.02740407e-01f, -9.87224132e-02f, 2.32070416e-01f, -1.87619388e-01f,
  6.29793182e-02f, -8.23627412e-02f, 3.15445736e-02f, 3.60799246e-02f, 1.33062631e-01f, 4.56622578e-02f, 1.86710730e-01f, -9.66660082e-02f, 1.70211785e-03f, -2.88871415e-02f,
  1.15660079e-01f, -2.91284434e-02f, 1.01026051e-01f, -8.50353688e-02f, -1.05739541e-01f, -3.00064515e-02f, 1.86878350e-02f, 2.58316062e-02f, -1.11154236e-01f, -5.27197570e-02f,
  -7.83985332e-02f, 2.47068517e-03f, -2.89463103e-02f, 3.97184491e-03f, -1.12531722e-01f, -6.71997964e-02f, 1.43889841e-02f, 4.20715772e-02f, 2.83459667e-02f, -5.14417365e-02f,
  -9.11387801e-02f, -9.49472841e-03f, 3.92570533e-02f, 8.95551033e-03f, -2.47335397e-02f, 1.06966071e-01f, 7.32176565e-03f, 3.82264331e-02f, 1.39012113e-02f, 2.39272490e-02f,
  6.41076192e-02f, -2.55365595e-02f, 8.29888284e-02f, 9.69367549e-02f, 4.09569107e-02f, -6.01752102e-02f, -9.21469182e-02f, 8.35584477e-02f, 1.35903180e-01f, 1.17619503e-02f,
  -5.00270864e-03f, -2.27011666e-02f, -4.48289774e-02f, 6.83317557e-02f, 1.56503581e-02f, -2.20012404e-02f, 3.69881839e-02f, -3.84433195e-02f, 1.33736178e-01f, -7.88123235e-02f,
  9.32288915e-02f, 7.65512362e-02f, -4.45193658e-03f, 9.70470905e-02f, 5.53840771e-02f, 3.87091078e-02f, 2.30871439e-02f, -1.95821673e-02f, -3.80934291e-02f, -7.72748888e-02f,
  1.97183251e-01f, 1.46240816e-01f, 1.36822328e-01f, -2.28901561e-02f, -8.66769105e-02f, -2.97940336e-03f, 1.78080186e-01f, 6.33101538e-02f, -1.86715908e-02f, -1.05430789e-01f,
  -3.19784344e-03f, 1.19781896e-01f, -1.22524232e-01f, 3.84952277e-02f, -8.49864446e-03f, 1.12697035e-02f, -4.50146943e-02f, -6.84769526e-02f, 2.60235602e-03f, -7.79354479e-03f,
  1.20104728e-02f, 6.09410517e-02f, 3.20054181e-02f, -6.68654218e-02f, -2.78001279e-01f, 1.88715413e-01f, 2.50202984e-01f, -3.31876539e-02f, -5.41585833e-02f, 2.95024365e-01f,
  -1.61417454e-01f, 1.29914045e-01f, 6.81603327e-02f, -1.65977970e-01f, 1.94835991e-01f, 2.12897494e-01f, 1.43524021e-01f, 1.44318849e-01f, -2.52687801e-02f, 1.53052032e-01f,
  -4.88151014e-02f, -1.20009348e-01f, 5.28822988e-02f, -1.28249079e-01f, -5.62964864e-02f, -9.32295248e-02f, 8.77970308e-02f, -9.30903926e-02f, -1.59282796e-02f, -9.95050743e-02f,
  -1.79432571e-01f, -7.67562091e-02f, 1.70361053e-03f, 6.41424954e-02f, 1.22648828e-01f, 9.94033813e-02f, 1.04375839e-01f, -5.73967472e-02f, -1.43055812e-01f, 7.70820826e-02f,
  1.49023443e-01f, -1.63215294e-01f, 3.56772752e-03f, -1.55994818e-02f, -4.06924374e-02f, -5.61624542e-02f, -6.58430085e-02f, -6.91099316e-02f, -2.24845726e-02f, 1.18679546e-01f,
  -3.04891709e-02f, -4.24524536e-03f, 3.18807364e-02f, 1.19602501e-01f, 6.09348230e-02f, -6.88733533e-02f, 1.79202184e-01f, 8.72824863e-02f, 1.28424019e-01f, 8.46944451e-02f,
  5.44806197e-02f, 3.36676501e-02f, 7.11332113e-02f, -1.55130565e-01f, -8.41703117e-02f, -8.02212879e-02f, 1.17446899e-01f, -6.77944869e-02f, -5.81220351e-02f, -2.41740290e-02f,
  -2.56149899e-02f, 1.85446173e-01f, 1.96964989e-04f, 3.57388593e-02f, 7.61484280e-02f, 5.42724617e-02f, -9.71853454e-03f, -3.53663526e-02f, 9.40751880e-02f, -1.84746310e-02f,
  -8.24304447e-02f, -4.58548665e-02f, 3.77442762e-02f, -9.62269725e-04f, 9.67329666e-02f, 1.09914485e-02f, 3.35064381e-02f, 1.05442502e-01f, -3.70690487e-02f, 8.87578726e-02f,
  5.98731227e-02f, 3.49714041e-01f, 2.34686229e-02f, 4.07290235e-02f, 8.93126428e-02f, 1.05991192e-01f, -1.20695112e-02f, 9.03647467e-02f, 4.40116376e-02f, 5.63109107e-02f,
  -2.93961074e-02f, 1.34294182e-01f, 1.60921291e-02f, -4.52469289e-02f, -4.15368006e-02f, 1.00822993e-01f, 5.47243096e-02f, 4.38128039e-02f, 1.62980165e-02f, 6.68128803e-02f,
  -4.33422402e-02f, -2.08159704e-02f, 8.10092315e-02f, 1.83567286e-01f, 5.75365424e-02f, -5.11097498e-02f, -6.46917075e-02f, -9.96591896e-03f, 6.01200536e-02f, 3.78728099e-02f,
  1.51423186e-01f, 1.36339158e-01f, 3.95230353e-01f, 1.80705637e-02f, 4.73756753e-02f, 2.47889996e-01f, 1.21926978e-01f, -6.07332634e-03f, 2.02154797e-02f, -2.15559125e-01f,
  -3.67280804e-02f, 1.83288664e-01f, 4.76638526e-02f, -1.19458489e-01f, 4.33260202e-02f, 8.84355158e-02f, -1.47233680e-01f, -4.16065268e-02f, 8.06038156e-02f, -6.50098324e-02f,
  7.64073282e-02f, -1.59959301e-01f, 7.84793273e-02f, -6.23241104e-02f, 1.32932767e-01f, 1.14273205e-01f, -4.04515147e-01f, 1.75008968e-01f, -8.07660520e-02f, 1.13064013e-02f,
  9.95619521e-02f, 1.07628535e-02f, 3.16907838e-02f, 6.98569790e-02f, -1.27166824e-03f, -3.00690364e-02f, -3.62982713e-02f, -8.21389898e-04f, 1.12230837e-01f, 7.90958256e-02f,
  8.99500307e-03f, 2.96478532e-02f, 7.78442696e-02f, 4.04379936e-03f, 9.69926789e-02f, 9.98280793e-02f, 7.93657824e-02f, 4.02592272e-02f, -4.61641420e-03f, 1.27958193e-01f,
  1.35420978e-01f, 6.58704266e-02f, 4.28507430e-03f, -4.62834947e-02f, 9.28796008e-02f, 3.96500379e-02f, -4.92878221e-02f, 5.03447950e-02f, 3.98783386e-02f, -1.93233937e-02f,
  -3.97693366e-02f, -5.01839370e-02f, 5.84334088e-03f, -2.46504582e-02f, 5.08958697e-02f, -1.91274527e-02f, -9.91860125e-03f, -7.67134130e-02f, 5.78369200e-02f, -2.56928038e-02f,
  -9.95857082e-03f, 2.26676725e-02f, -4.95762005e-02f, -1.40188914e-02f, -1.03167057e-01f, -1.26373723e-01f, -4.80240993e-02f, 2.48644240e-02f, 2.78494917e-02f, 2.29142467e-03f,
  -8.58186558e-02f, -8.23628902e-02f, 1.82462633e-02f, 3.66547192e-03f, 4.29775473e-03f, 4.79202867e-02f, -6.82303533e-02f, 7.92084187e-02f, -1.31133959e-01f, 7.65407383e-02f,
  -1.79307193e-01f, -2.03829855e-01f, 3.81625928e-02f, -3.82144377e-02f, 2.72711087e-02f, 3.56748700e-02f, -8.79927445e-03f, 6.32377639e-02f, 3.44273895e-02f, -3.04475613e-02f,
  -1.80599932e-03f, 1.47065008e-02f, -3.30735184e-03f, -2.36749873e-02f, 8.41925815e-02f, 3.86145688e-03f, -6.69980943e-02f, -2.29101945e-02f, -8.78071636e-02f, -9.30031464e-02f,
  2.33340785e-02f, 5.25947250e-02f, 1.15566917e-01f, 6.37154058e-02f, -3.35079916e-02f, -1.44997397e-02f, -5.53584583e-02f, 2.55340990e-02f, 2.01084046e-03f, -5.81350103e-02f,
  7.00847656e-02f, 2.26904809e-01f, 2.49315202e-01f, -1.88524097e-01f, -1.27820432e-01f, -3.35021690e-03f, 1.17063612e-01f, -8.53671432e-02f, 1.10451363e-01f, -9.46184471e-02f,
  -2.85370916e-01f, 4.36617672e-01f, 1.92781091e-01f, -2.84316927e-01f, 1.97482601e-01f, 5.09009957e-02f, -1.73734441e-01f, 2.78108306e-02f, 2.22625509e-01f, 3.89767736e-02f,
  -5.09080887e-02f, -3.51220429e-01f, -1.54519957e-02f, -1.77105099e-01f, -1.85361490e-01f, 1.28207505e-01f, -2.53411472e-01f, 4.70159054e-02f, -2.10541770e-01f, 1.23810239e-01f,
  -3.61977257e-02f, -1.10427346e-02f, -2.73542274e-02f, 4.86570708e-02f, -8.98839068e-03f, -4.50466089e-02f, 5.47981495e-03f, 1.24707408e-01f, -6.77096248e-02f, 6.58205226e-02f,
  1.26011238e-01f, -5.65093271e-02f, 9.42975879e-02f, -9.04148892e-02f, -1.06762953e-01f, -1.12757385e-01f, 5.20659164e-02f, -8.46119970e-02f, 5.21989577e-02f, 5.30560203e-02f,
  1.19194565e-02f, 6.50918633e-02f, -1.42743617e-01f, -6.78988025e-02f, 4.71147709e-02f, 4.08381708e-02f, 3.66347134e-02f, 2.07033232e-01f, 3.74641531e-04f, -4.33815084e-03f,
  -5.51593527e-02f, -2.19039619e-02f, -1.11131370e-01f, 5.19453622e-02f, 6.50045127e-02f, -2.21133176e-02f, -1.59570932e-01f, 2.85674296e-02f, 7.52388462e-02f, 2.65813041e-02f,
  -3.84837538e-02f, 2.96470579e-02f, 9.23223644e-02f, -1.03280418e-01f, -8.24495926e-02f, 1.22190006e-01f, 3.77120860e-02f, -7.91320726e-02f, 6.77230135e-02f, -5.28548984e-03f,
  8.72137845e-02f, 9.20306072e-02f, 1.16948463e-01f, -4.56796549e-02f, -4.45531011e-02f, 9.89951789e-02f, -1.91838309e-01f, -6.40509650e-02f, 1.01698443e-01f, -1.20983332e-01f,
  -1.50762293e-02f, 7.44813979e-02f, 5.46472147e-02f, 5.19512109e-02f, 2.36025061e-02f, -4.86010537e-02f, -3.21082808e-02f, 8.58084336e-02f, -1.04007892e-01f, -7.16007175e-03f,
  3.27497199e-02f, -1.15289569e-01f, -4.97972127e-03f, -1.45251840e-01f, -7.22808465e-02f, -9.14754495e-02f, 6.57463074e-02f, -1.16891311e-02f, -3.72829847e-02f, 1.02055751e-01f,
  -5.77907264e-02f, -4.19417955e-02f, -5.68555072e-02f, -1.16156578e-01f, -1.57084450e-01f, 1.00755475e-01f, 2.01296061e-02f, 1.00056976e-01f, -5.51825948e-02f, -2.90913302e-02f,
  -4.13310111e-01f, 1.31285742e-01f, -1.82723388e-01f, -1.35564571e-03f, -2.27863900e-02f, -6.18150756e-02f, -1.21162631e-01f, -6.79078102e-02f, -3.73942584e-01f, 1.81032106e-01f,
  1.13144077e-01f, -2.86163419e-01f, 7.79592022e-02f, 3.46048400e-02f, -1.41639814e-01f, 2.78378762e-02f, 1.15862869e-01f, 8.49897042e-02f, -1.03591986e-01f, 2.62248013e-02f,
  2.24393383e-02f, 2.51668155e-01f, 1.10625304e-01f, 1.96267232e-01f, 3.61646228e-02f, 5.14467433e-03f, 3.28078657e-01f, 1.02348588e-01f, 1.89553067e-01f, -4.38869968e-02f,
  1.43152734e-04f, -1.61124393e-01f, -1.01964921e-01f, -1.11878343e-01f, 5.28241768e-02f, 8.18680879e-03f, 9.20839608e-02f, -1.20767150e-02f, -5.57726957e-02f, -1.01567507e-01f,
  -3.05508599e-02f, 3.97679582e-02f, -1.44395074e-02f, -1.09146416e-01f, -1.14113413e-01f, -5.89966401e-03f, -4.08416912e-02f, -7.53162205e-02f, -7.56570995e-02f, 1.93562789e-03f,
  -1.27139315e-01f, -1.47601226e-02f, -1.02729844e-02f, 2.01193485e-02f, 1.40371202e-02f, -1.47435609e-02f, 4.13167551e-02f, 1.85354706e-02f, 1.91355757e-02f, -8.73370171e-02f,
  7.61323199e-02f, 1.16914501e-02f, 1.12727433e-02f, -7.29489559e-03f, -2.60357857e-02f, 7.74813667e-02f, -4.22886014e-02f, -8.30043666e-03f, -8.03630129e-02f, 3.79079916e-02f,
  -4.81651351e-02f, -1.16216213e-01f, -7.41231814e-02f, -2.55548749e-02f, 2.63000000e-03f, -1.10213002e-02f, -3.17010805e-02f, 3.08149471e-03f, -4.98652048e-02f, 1.79808661e-02f,
  1.99380573e-02f, 2.54897177e-02f, 1.58572756e-02f, 3.60633060e-02f, 8.55332240e-02f, -4.03428450e-02f, 3.15059163e-02f, 9.52191837e-03f, 3.77875082e-02f, 5.17260171e-02f,
  1.23243980e-01f, 1.97658330e-01f, -2.68288236e-02f, 1.00695677e-02f, 3.63996848e-02f, -6.64834231e-02f, 7.29872519e-03f, -5.47747314e-02f, 3.33250649e-02f, -3.56011428e-02f,
  -4.02364023e-02f, 1.55415973e-02f, 4.52621728e-02f, -6.52236789e-02f, 4.69438024e-02f, 8.87111500e-02f, 1.21899121e-01f, -1.29998475e-01f, 8.14960077e-02f, 9.06501263e-02f,
  4.94333953e-02f, -4.17139754e-02f, -1.64879113e-02f, 3.47902551e-02f, 2.43693590e-02f, 1.17631620e-02f, 1.68095976e-02f, -4.92705852e-02f, 1.49152845e-01f, 7.68073276e-02f,
  -2.20326513e-01f, 2.46551469e-01f, 2.02223793e-01f, -1.62112247e-02f, 1.08793020e-01f, -2.13758469e-01f, -2.83335388e-01f, 3.13170403e-02f, -1.09267570e-01f, -2.73356915e-01f,
  -2.39644840e-01f, 6.18364960e-02f, -2.21313149e-01f, -2.00478405e-01f, -1.55525044e-01f, -2.59875685e-01f, -8.92535672e-02f, -6.04401901e-02f, 2.35274639e-02f, 4.13892977e-02f,
  7.62352198e-02f, -1.55872881e-01f, 6.22984692e-02f, 2.23158479e-01f, 8.42165947e-02f, 2.18138933e-01f, 7.00377161e-03f, 1.91673547e-01f, 2.85302699e-02f, 4.06962559e-02f,
  -4.30225655e-02f, -2.04776302e-01f, 6.57195374e-02f, 6.85778484e-02f, -3.77968028e-02f, -9.10810828e-02f, 4.88082953e-02f, 9.93141830e-02f, -3.46972197e-02f, -5.39075658e-02f,
  1.12336993e-01f, 7.26788267e-02f, 1.48046985e-02f, -9.96720269e-02f, 2.61305496e-02f, 3.67606878e-02f, 6.42598271e-02f, -5.60779832e-02f, 2.72521488e-02f, -1.79969221e-02f,
  -3.36323096e-03f, 4.76976186e-02f, -9.20837652e-03f, 3.67664285e-02f, 5.98378479e-02f, -2.81766932e-02f, 4.30072434e-02f, 4.38950360e-02f, -2.54535843e-02f, -1.74597397e-01f,
  -7.77529702e-02f, 1.67991444e-02f, -2.30294671e-02f, 8.73846784e-02f, 4.58567068e-02f, 6.20647185e-02f, -6.50357530e-02f, 3.25253196e-02f, 6.22141408e-03f, -4.33706853e-04f,
  -1.47220287e-02f, 6.85021952e-02f, -4.79056016e-02f, -5.85490838e-02f, -6.85397983e-02f, -2.05979124e-03f, 7.55268708e-02f, -3.79240066e-02f, 7.66316354e-02f, 3.58791389e-02f,
  4.20134179e-02f, 8.21105912e-02f, -6.37926236e-02f, -3.88479494e-02f, -2.22548395e-02f, 2.30489094e-02f, 2.96335556e-02f, -5.23650739e-03f, 1.03130512e-01f, -7.50784054e-02f,
  -7.18108341e-02f, -1.96627602e-01f, -2.01158915e-02f, 2.35476978e-02f, 5.97080439e-02f, -9.26337317e-02f, -1.44297285e-02f, 4.14753072e-02f, -8.32491070e-02f, -1.77196875e-01f,
  1.30605668e-01f, 6.69454038e-02f, 5.62176015e-03f, -8.84746041e-05f, 1.78982630e-01f, -6.02255948e-02f, 3.84627134e-02f, 1.04409149e-02f, 2.23486815e-02f, 3.16550732e-02f,
  4.16829214e-02f, -3.37695517e-02f, 1.07842810e-01f, -2.18712036e-02f, 8.54448974e-02f, -3.85533236e-02f, -3.61859985e-02f, -3.31068039e-02f, 1.97935048e-02f, -9.82604828e-03f,
  -6.90754503e-02f, -1.96997210e-01f, -2.99706440e-02f, -1.62168935e-01f, -3.45780283e-01f, 1.50293604e-01f, 5.33074215e-02f, -1.16709784e-01f, 1.13759808e-01f, -5.68123050e-02f,
  7.31407404e-02f, 2.31601208e-01f, 6.47656769e-02f, 9.18824375e-02f, 4.65826809e-01f, 4.50303137e-01f, 2.27088600e-01f, 1.44481987e-01f, 1.63664520e-01f, -1.01073325e-01f,
  3.99363451e-02f, -1.57858700e-01f, -4.28524911e-02f, -2.38881901e-01f, -2.72937328e-01f, -2.55009949e-01f, -2.82833129e-01f, -1.55177981e-01f, -1.62905589e-01f, 3.96951772e-02f,
  -1.82914902e-02f, -2.32531540e-02f, -5.86508177e-02f, 2.86475066e-02f, -4.89012152e-02f, -4.01873142e-02f, -6.39022142e-02f, 4.22197357e-02f, 1.29474699e-01f, -7.00649768e-02f,
  -1.26282405e-03f, 4.14220951e-02f, 6.13631271e-02f, -1.59721952e-02f, -3.92831676e-02f, -5.35067692e-02f, 3.43885794e-02f, 7.01398477e-02f, 2.22084261e-02f, 2.32624859e-02f,
  -3.53112211e-03f, -4.78814803e-02f, 1.25855878e-01f, 4.08203937e-02f, 5.41863171e-03f, 6.63906708e-02f, -3.62182744e-02f, -1.18160047e-01f, 1.36964312e-02f, -1.34790009e-02f,
  2.23675743e-02f, 6.67526126e-02f, 7.76881203e-02f, -5.59713058e-02f, -7.49981701e-02f, -1.08463824e-01f, 7.49159008e-02f, -2.82795541e-02f, -1.09914757e-01f, -3.27293389e-02f,
  1.20531414e-02f, 1.39783584e-02f, -6.12251759e-02f, -7.82568008e-02f, 3.26287746e-02f, -1.11752540e-01f, 4.37041745e-02f, 5.34977429e-02f, -1.75080344e-01f, 1.22453254e-02f,
  2.82794493e-03f, 2.89643556e-02f, -1.09881517e-02f, -7.72754699e-02f, 1.24777548e-01f, -7.68099725e-02f, -1.07308915e-02f, -6.67637959e-02f, 4.74045910e-02f, -1.47250155e-02f,
  -1.34048641e-01f, 1.53576462e-02f, 2.93121021e-02f, 1.22943381e-02f, 5.63751720e-02f, -3.04983016e-02f, 3.28488089e-02f, -3.20603028e-02f, 6.29371926e-02f, 2.13584583e-02f,
  -1.10699855e-01f, -2.10393183e-02f, 2.01500002e-02f, -9.28516313e-02f, -2.82502659e-02f, 2.04168074e-02f, 1.31686121e-01f, 2.37180442e-02f, -2.97990311e-02f, -1.93708409e-02f,
  3.14352065e-02f, -3.42589729e-02f, 1.40391946e-01f, -4.44531292e-02f, 2.86119301e-02f, 2.50048451e-02f, 2.98188850e-02f, -1.28855675e-01f, -6.67060241e-02f, -1.21234253e-01f,
  5.23600698e-01f, 2.05875505e-02f, -3.75445448e-02f, 4.03721541e-01f, 5.17071337e-02f, -1.66936144e-02f, 2.52934754e-01f, 7.21782371e-02f, 1.99821636e-01f, 1.31228209e-01f,
  -4.58049551e-02f, 1.83163702e-01f, -2.01314926e-01f, 3.22943568e-01f, 1.51396647e-01f, -1.67698771e-01f, 4.05473799e-01f, 1.29808068e-01f, 4.56604697e-02f, 2.23698631e-01f,
  1.28780141e-01f, 2.61724174e-01f, 4.45723049e-02f, -1.67204460e-04f, 1.88716039e-01f, 5.45862950e-02f, 1.09507702e-01f, -2.03643978e-01f, 1.29421085e-01f, -6.67463392e-02f,
  -1.03596456e-01f, 6.88117370e-02f, 8.22538882e-02f, -5.17401546e-02f, 9.14189443e-02f, 1.47937788e-02f, 4.40359227e-02f, -1.22409482e-02f, -5.89977577e-02f, -2.04879455e-02f,
  7.21980929e-02f, -4.47331332e-02f, 7.49704093e-02f, 3.11987996e-02f, 5.55069372e-02f, 3.97645421e-02f, -7.23817721e-02f, -6.33014143e-02f, -8.43830779e-02f, 1.20881982e-01f,
  1.48132518e-02f, -9.68881696e-02f, 9.10610259e-02f, 4.83250841e-02f, 2.27419417e-02f, 1.66710839e-02f, 6.28595576e-02f, -1.21775623e-02f, 7.28731393e-04f, 1.00705996e-01f,
  9.83563364e-02f, -1.74936652e-02f, 2.90539879e-02f, -6.74982965e-02f, -8.05206820e-02f, 3.44811417e-02f, 5.67957871e-02f, -1.16311125e-02f, 5.44273877e-04f, -3.33344936e-02f,
  -6.36730194e-02f, 4.16140333e-02f, 9.65951476e-03f, 3.91111411e-02f, 8.33971649e-02f, 3.41226609e-04f, -3.64367617e-03f, -2.61994991e-02f, 9.42677110e-02f, -3.18025537e-02f,
  -3.26995701e-02f, -3.13103162e-02f, -1.11429676e-01f, -1.35830464e-02f, -4.12266590e-02f, -5.25715686e-02f, 9.21646282e-02f, 4.71667536e-02f, -3.32959630e-02f, 1.76370610e-02f,
  1.22986909e-04f, 9.54326838e-02f, -4.69148718e-02f, 1.31945815e-02f, -5.56075275e-02f, 6.43548369e-02f, 1.09059520e-01f, 1.18476391e-01f, -3.33843157e-02f, 1.55663723e-03f,
  1.16241999e-01f, 3.70688662e-02f, -1.81337968e-02f, -7.34989392e-03f, -6.81973547e-02f, 6.27236590e-02f, -6.69283094e-03f, -3.56421508e-02f, 3.47207263e-02f, 3.23567609e-03f,
  -2.31844955e-03f, 1.21918367e-03f, 3.06854025e-02f, 8.32606480e-02f, 6.55847415e-02f, -3.56134288e-02f, 7.10287020e-02f, 2.92343087e-03f, -1.76267661e-02f, 1.50964344e-02f,
  4.07774866e-01f, -1.07971787e-01f, 1.03309238e-02f, 1.59083575e-01f, -6.66390434e-02f, -1.09406106e-01f, 2.76589245e-02f, -5.78470156e-02f, -8.42736736e-02f, -3.64421196e-02f,
  -1.69471502e-01f, 2.58001745e-01f, -3.14569771e-01f, 1.61677524e-01f, 1.90576255e-01f, -1.57957420e-01f, 1.05266415e-01f, 1.64921656e-02f, -8.04726556e-02f, 1.60350397e-01f,
  1.61119580e-01f, 1.39532283e-01f, 1.39490897e-02f, 1.12582467e-01f, 2.46286809e-01f, 1.35874003e-01f, 2.88192987e-01f, 4.30132709e-02f, 2.90217906e-01f, 9.10176858e-02f,
  5.08789793e-02f, 1.36734232e-01f, -6.73734918e-02f, -1.42002804e-02f, -6.94035832e-03f, -1.32073313e-01f, 2.30013896e-02f, -9.22664180e-02f, 3.69280986e-02f, -5.00070304e-02f,
  -4.79791202e-02f, -5.91768473e-02f, 6.51677996e-02f, 5.91371022e-02f, 7.40389079e-02f, 6.08465336e-02f, -6.22545034e-02f, 3.43404897e-02f, -8.90600532e-02f, 2.85145082e-03f,
  7.54606202e-02f, 3.97496149e-02f, 4.19975594e-02f, 1.19235568e-01f, 9.58553702e-02f, 2.40431372e-02f, 1.36251256e-01f, -1.60239693e-02f, 1.04699560e-01f, 5.78842089e-02f,
  5.62556498e-02f, -1.64603725e-01f, -6.95058554e-02f, -1.04446650e-01f, -7.26400986e-02f, -4.09287997e-02f, 8.69884416e-02f, -7.55663365e-02f, -6.97540194e-02f, -6.28734753e-02f,
  -1.29302591e-01f, 2.38691960e-02f, -1.66657418e-02f, -4.22442816e-02f, -3.96825895e-02f, -1.55719325e-01f, -1.08996324e-01f, 5.34179434e-02f, 2.02963389e-02f, -4.49505709e-02f,
  -2.50866869e-03f, -3.99961621e-02f, -1.27907202e-01f, -7.07470253e-02f, -4.79756668e-02f, 3.49047557e-02f, 7.95546696e-02f, 3.36692706e-02f, -1.49923354e-01f, -3.95857580e-02f,
  1.52831450e-01f, 3.27389389e-01f, -5.63557819e-02f, -4.33192737e-02f, -9.73321721e-02f, -1.34817675e-01f, 1.21917045e-02f, -6.07833546e-03f, 8.86342376e-02f, 2.48752646e-02f,
  -1.10151894e-01f, 1.13304984e-02f, 1.19574666e-01f, -9.31870043e-02f, -3.47373933e-02f, 1.27080083e-01f, -5.64314723e-02f, 6.62669167e-02f, -1.09222753e-03f, -2.95046289e-02f,
  1.54293597e-01f, 4.24095541e-02f, -8.03784877e-02f, 9.81651843e-02f, 5.05275913e-02f, -8.57198611e-02f, 2.09086463e-01f, 1.50607855e-04f, 3.48057807e-03f, -5.69938794e-02f,
  7.05085546e-02f, 3.06305051e-01f, 2.00877506e-02f, -5.24734147e-02f, -5.61000593e-02f, -5.98643580e-03f, -3.00764829e-01f, 2.66914815e-01f, -1.79333702e-01f, 2.51325160e-01f,
  1.58858702e-01f, 8.00565910e-03f, -1.08162798e-01f, 3.61342669e-01f, -2.54354626e-01f, -2.27053925e-01f, 1.35461884e-02f, -9.74876210e-02f, -3.82520221e-02f, 1.23451911e-01f,
  2.64703319e-03f, 1.97995812e-01f, -2.31483914e-02f, 1.51228011e-01f, 1.45522103e-01f, 2.25527473e-02f, -1.37962187e-02f, -1.03826761e-01f, 2.89274722e-01f, -3.96666229e-02f,
  5.64157739e-02f, 1.11013077e-01f, -2.45474707e-02f, -7.40300566e-02f, 1.19883260e-02f, 1.46499472e-02f, 3.13351415e-02f, -6.70902282e-02f, -7.22373128e-02f, 3.71896550e-02f,
  7.74533628e-03f, 2.69030575e-02f, -8.52162838e-02f, -3.09142680e-03f, 4.08003256e-02f, 5.00478335e-02f, -5.33413664e-02f, 2.55671479e-02f, -1.78066660e-02f, 1.25707641e-01f,
  -1.28073320e-02f, -2.85068881e-02f, 7.48207152e-04f, -4.70861308e-02f, 1.44992163e-02f, -1.31375566e-01f, -1.47262976e-01f, -1.02882944e-01f, -2.98739946e-03f, 7.70054683e-02f,
  1.85066853e-02f, -6.71539754e-02f, 9.05168056e-02f, 2.52351519e-02f, 1.12819839e-02f, 3.67153645e-03f, 3.12219057e-02f, 1.52804516e-02f, -8.76390338e-02f, 2.93657705e-02f,
  2.13478808e-03f, 9.64058936e-02f, -9.84604191e-03f, -3.70895974e-02f, 9.34884548e-02f, -6.03929907e-03f, 5.03841862e-02f, 1.33592218e-01f, 3.68961431e-02f, 6.01077899e-02f,
  7.18693808e-02f, -6.49839491e-02f, -8.21629018e-02f, -3.61181386e-02f, -1.70580875e-02f, -1.00345716e-01f, 1.40261099e-01f, 9.38226655e-02f, 5.21627553e-02f, 4.29767296e-02f,
  3.74464504e-02f, 3.71628217e-02f, 4.47166990e-03f, 5.57094580e-03f, -1.45275323e-02f, 7.70230442e-02f, -1.65055692e-03f, 1.48298994e-01f, 5.61465807e-02f, 1.21731550e-01f,
  9.44713503e-02f, -1.82962671e-01f, -7.26083145e-02f, -9.39520821e-02f, -3.64949070e-02f, 1.61185190e-02f, -1.15121946e-01f, -2.61328220e-02f, -7.81514421e-02f, 7.61420056e-02f,
  6.60369545e-02f, -7.46909454e-02f, -9.43714008e-02f, -1.29465209e-02f, 4.20545228e-02f, -1.62076324e-01f, 5.94056360e-02f, -1.19725056e-02f, 4.10141132e-04f, -6.47789761e-02f,
  1.73384041e-01f, -3.12779993e-01f, -1.42243221e-01f, -2.02087656e-01f, 1.23551823e-01f, -2.80269653e-01f, -1.77388325e-01f, -2.28381515e-01f, -1.95216045e-01f, 7.03661982e-03f,
  -4.99796644e-02f, 2.03056738e-01f, -1.11090332e-01f, -2.19767675e-01f, -7.49496371e-02f, -2.83300728e-01f, -1.53820902e-01f, -2.77341064e-03f, -1.42529935e-01f, -5.06194960e-03f,
  -1.05011694e-01f, -4.30502407e-02f, -2.75586247e-01f, 1.16161637e-01f, -6.80581257e-02f, 1.91437155e-01f, 1.87181994e-01f, 1.13609314e-01f, 1.15141355e-01f, 1.60757918e-02f,
  -1.30678177e-01f, -1.95037257e-02f, 9.43668187e-02f, 8.41854587e-02f, -7.35599175e-02f, 7.00566173e-02f, 2.13331287e-03f, -1.41295884e-02f, 5.84207475e-02f, -7.55332261e-02f,
  1.22314557e-01f, 2.24558846e-03f, 4.98143025e-02f, 1.30386323e-01f, 1.02110110e-01f, 8.41831118e-02f, -7.42906481e-02f, -8.83703679e-02f, -1.00952648e-01f, -3.96001153e-03f,
  1.98779106e-02f, 2.15505604e-02f, -6.09975792e-02f, 2.21952796e-02f, 1.13441702e-02f, -1.78404022e-02f, -6.30618334e-02f, 8.08259193e-03f, 5.24608791e-03f, -5.57706319e-02f,
  9.98099148e-02f, -1.48189262e-01f, -4.28246483e-02f, -5.91263063e-02f, -8.51597935e-02f, -1.43456087e-02f, 4.21008058e-02f, 1.83579344e-02f, -4.40423824e-02f, -8.50841329e-02f,
  -2.48667952e-02f, 5.63034639e-02f, -6.52426854e-02f, -1.34651931e-02f, -7.41695091e-02f, -6.79167286e-02f, 6.00361452e-03f, 4.46072454e-03f, 3.04921586e-02f, -1.47090228e-02f,
  -1.86611600e-02f, -2.93353982e-02f, -4.01688851e-02f, -4.44752490e-03f, -4.83602919e-02f, 9.70383957e-02f, -3.17256711e-02f, -4.46317680e-02f, -4.16033305e-02f, -1.78903039e-03f,
  -1.14201672e-01f, -2.04854742e-01f, -8.97840634e-02f, 7.17449933e-02f, -1.44836982e-03f, 9.30836704e-03f, -2.54688840e-02f, 8.31831153e-03f, -3.55594456e-02f, -1.22312211e-01f,
  4.45680656e-02f, 5.37219783e-03f, 3.00619826e-02f, 3.93713303e-02f, 7.29099289e-02f, -6.04474582e-02f, 3.27108689e-02f, 7.77260065e-02f, -4.16848697e-02f, 6.90681394e-03f,
  1.60265386e-01f, 1.30838394e-01f, 5.19172549e-02f, 9.91972629e-03f, 3.58230621e-02f, 3.94062996e-02f, 1.56448528e-01f, -5.03263064e-03f, 3.42838913e-02f, -6.42464980e-02f,
  -3.33985656e-01f, 3.12384553e-02f, 6.29127696e-02f, -2.86963880e-01f, 6.84508234e-02f, -7.18570054e-02f, -2.37229526e-01f, 2.70985305e-01f, -1.88433453e-01f, -5.99531410e-03f,
  -3.00315887e-01f, 3.64108123e-02f, -1.30634099e-01f, -4.20834899e-01f, -7.13315085e-02f, -1.39209017e-01f, -9.96966884e-02f, -1.99274436e-01f, 5.21650165e-03f, -8.02582353e-02f,
  -6.41082972e-02f, -1.63511798e-01f, 4.25950289e-02f, 2.73741573e-01f, -1.02033064e-01f, 1.20616294e-01f, 2.13704154e-01f, 1.19913615e-01f, -3.20166275e-02f, 8.73843133e-02f,
  -1.27893656e-01f, -2.09535599e-01f, 4.08007065e-03f, 4.15715910e-02f, -4.04781336e-03f, 2.94133723e-02f, 5.29560223e-02f, -2.73166224e-02f, -1.36541743e-02f, 8.97844881e-03f,
  -5.64603731e-02f, -2.73087807e-02f, -7.42768943e-02f, 7.63647631e-02f, -1.04129151e-01f, -2.34095640e-02f, -1.29516162e-02f, 4.11854573e-02f, 1.29091218e-01f, -3.65104936e-02f,
  -6.79157600e-02f, -1.78868830e-01f, 2.41162144e-02f, -3.82411806e-03f, -7.01184347e-02f, -7.83120748e-03f, 1.34271085e-01f, 8.23008940e-02f, -4.79721138e-03f, -4.96679824e-03f,
  3.91744338e-02f, 1.62413076e-01f, 9.33377743e-02f, -7.06273317e-02f, -4.34977263e-02f, -6.85377866e-02f, -3.74328718e-02f, 3.58522795e-02f, 5.21908663e-02f, -1.92173675e-03f,
  9.08741821e-03f, 1.08825695e-02f, 6.68862322e-03f, 1.02758091e-02f, 4.35000621e-02f, 8.85504019e-03f, 1.13288105e-01f, 1.72299333e-02f, -7.95445144e-02f, 1.03911817e-01f,
  -2.33440381e-02f, -3.16327922e-02f, 2.01918315e-02f, 5.54180220e-02f, -1.57168973e-02f, -4.13291082e-02f, 4.61720601e-02f, -7.79615808e-03f, 1.89379752e-02f, 8.37020874e-02f,
  1.17366455e-01f, 1.66810304e-01f, -3.65836844e-02f, -4.49940711e-02f, -6.75812811e-02f, -7.74813965e-02f, -5.42224608e-02f, 2.73310207e-02f, 7.46851861e-02f, 5.98084740e-02f,
  8.64064842e-02f, 3.84893417e-02f, 6.70714527e-02f, 2.58185063e-02f, -1.48847587e-02f, 1.14035822e-01f, -3.24045680e-02f, 4.37469222e-02f, 1.15711182e-01f, 1.03248827e-01f,
  4.58303839e-02f, -7.90930390e-02f, -6.29661081e-05f, 2.69439090e-02f, 1.48213841e-02f, -3.86143923e-02f, -6.75057992e-03f, -4.68747951e-02f, -4.48054411e-02f, -6.06325194e-02f,
  -2.31677487e-01f, 3.59163612e-01f, -3.37331742e-01f, 1.98634784e-03f, -8.20216760e-02f, 3.55276614e-01f, -7.46012554e-02f, 3.08492910e-02f, -5.97812608e-03f, 1.90033704e-01f,
  -1.68281072e-03f, 6.64606318e-02f, -4.91569526e-02f, 3.74078929e-01f, -3.08112279e-02f, 1.16259595e-02f, 2.37782896e-01f, 1.54358432e-01f, 1.00046992e-01f, 3.02028004e-02f,
  -1.57005459e-01f, 2.56991237e-01f, -3.69339138e-02f, 1.40824497e-01f, -2.51514204e-02f, -8.28158781e-02f, -2.00893819e-01f, -2.31159702e-01f, 1.65471464e-01f, 5.49264811e-02f,
  -6.05594926e-03f, -1.72058448e-01f, -5.13070300e-02f, 7.21340179e-02f, -3.51920687e-02f, 7.20717339e-03f, -3.82128619e-02f, -6.22404888e-02f, 2.41133920e-03f, 3.56750889e-03f,
  2.00688913e-02f, 5.76603487e-02f, -1.12165390e-02f, -2.19611954e-02f, -1.14926668e-02f, -1.14145903e-02f, 1.23428077e-01f, 2.42451653e-02f, 9.52192694e-02f, -1.50580496e-01f,
  -3.08100916e-02f, 6.00879602e-02f, -6.98047057e-02f, 1.59263611e-02f, -1.22416094e-01f, 9.82499123e-03f, -8.71334970e-02f, -6.10872209e-02f, 3.83757725e-02f, 5.39892316e-02f,
  -8.65323469e-02f, -3.35695893e-02f, -5.34389764e-02f, 9.30430889e-02f, 1.29736755e-02f, -2.37430222e-02f, 5.49684577e-02f, 7.94103667e-02f, 2.62634698e-02f, 5.54485284e-02f,
  1.45633206e-01f, 3.32365953e-03f, 9.22920406e-02f, 3.90662514e-02f, -2.44363397e-03f, 1.66627131e-02f, 3.98253314e-02f, -5.81644848e-02f, 5.93383163e-02f, -6.02366179e-02f,
  5.26827648e-02f, 9.60306153e-02f, 2.79788468e-02f, -1.14555746e-01f, 1.63697952e-03f, -7.21436366e-02f, 5.44662736e-02f, -7.29330182e-02f, 5.65639185e-03f, -7.02158213e-02f,
  1.32071733e-01f, -5.23364954e-02f, 5.28051555e-02f, 1.01595148e-01f, 1.06617540e-01f, 1.16904356e-01f, 4.20325855e-03f, 3.20768282e-02f, 7.39951134e-02f, 2.53543891e-02f,
  2.86206026e-02f, -1.33626223e-01f, -2.10590567e-02f, 5.83777539e-02f, 2.30108039e-03f, -1.33908018e-01f, 4.04072329e-02f, 3.22858579e-02f, 8.20271969e-02f, 7.43687246e-03f,
  -1.10984042e-01f, -6.03295118e-02f, -2.15607118e-02f, -9.56520066e-02f, -7.79330432e-02f, 3.67978662e-02f, -1.19670555e-01f, 2.13243160e-02f, -8.39362741e-02f, 6.39224127e-02f,
  2.22011611e-01f, -3.25839251e-01f, -2.78669655e-01f, 1.75114512e-01f, -6.11724295e-02f, 8.59784037e-02f, 2.91418761e-01f, -1.49702445e-01f, 1.17047302e-01f, 1.58360973e-01f,
  3.71056736e-01f, -1.73583701e-01f, 7.25045204e-02f, 4.18765575e-01f, 3.04009706e-01f, 2.56545365e-01f, 9.28255469e-02f, 1.95275635e-01f, -2.55389847e-02f, 1.01270907e-01f,
  -1.42023619e-02f, 2.81669736e-01f, -3.71429771e-02f, -3.11011583e-01f, -2.19718851e-02f, -3.30271035e-01f, 9.17236134e-02f, -2.09188864e-01f, 8.50724205e-02f, -1.14132665e-01f,
  3.84985469e-02f, 5.70137762e-02f, -9.32036259e-04f, -1.67078048e-01f, 6.18366487e-02f, 4.09554243e-02f, 7.23862872e-02f, -7.24178255e-02f, 5.84158637e-02f, -2.22806837e-02f,
  -4.10769954e-02f, -8.01658928e-02f, -2.34549306e-03f, 1.45858545e-02f, -1.14010304e-01f, -1.11081384e-01f, -1.25526041e-02f, 4.36343104e-02f, -1.29059151e-01f, 1.04876840e-02f,
  2.10882574e-02f, -8.41077343e-02f, 3.89812849e-02f, -3.35593037e-02f, -6.44845590e-02f, 2.99406443e-02f, -1.02382056e-01f, -1.13407098e-01f, -9.52633098e-03f, 7.75989890e-02f,
  6.12111948e-02f, -7.23248273e-02f, -2.64351461e-02f, -4.56138626e-02f, -1.16519175e-01f, -6.94665685e-02f, 2.22079027e-02f, -7.37960413e-02f, -6.83103949e-02f, -7.69558772e-02f,
  1.96532831e-02f, 1.57914981e-02f, 4.07777634e-03f, -3.73177305e-02f, 7.79283941e-02f, -1.00315750e-01f, -8.74029696e-02f, 7.40537047e-02f, 3.35391983e-02f, 1.84386838e-02f,
  -8.81354064e-02f, -4.54696082e-02f, -2.62211468e-02f, -1.25024496e-02f, 3.28238308e-02f, -8.81266817e-02f, -2.82654390e-02f, -1.91436149e-02f, 7.90208429e-02f, 7.38958716e-02f,
  1.30091503e-01f, -4.20699129e-03f, -2.59557832e-02f, -7.05239624e-02f, -7.64583424e-02f, 9.44184512e-02f, -1.13584632e-02f, -2.28474159e-02f, -6.84890244e-03f, 6.30124807e-02f,
  -5.31107523e-02f, -3.28673981e-03f, -4.58333045e-02f, -1.70534886e-02f, -8.37319270e-02f, 1.08525649e-01f, 8.68097618e-02f, 5.95455542e-02f, -4.30604666e-02f, -1.11995570e-01f,
  -7.79065490e-03f, 1.77058093e-02f, -4.44203019e-02f, -3.83883938e-02f, -5.86254224e-02f, -2.49224231e-02f, 1.90779809e-02f, -7.05408081e-02f, 1.67962629e-02f, -2.27653272e-02f,
  -4.54883367e-01f, -1.89436615e-01f, 2.66090478e-03f, -2.16436028e-01f, -1.08384706e-01f, 3.16787153e-01f, 7.50797391e-02f, -2.29917079e-01f, -2.01843217e-01f, 1.25652924e-01f,
  1.50544208e-03f, -1.86105967e-01f, 2.85022736e-01f, -1.92523390e-01f, 1.68842703e-01f, 3.61760378e-01f, -1.07001960e-01f, -1.27036467e-01f, 7.08552897e-02f, -2.65299737e-01f,
  -8.89173150e-02f, -5.24651147e-02f, 7.31765106e-02f, 3.10813691e-02f, -8.86981264e-02f, -3.17664966e-02f, 1.31599642e-02f, 1.78898290e-01f, -3.52847949e-02f, 1.11034282e-01f,
  -5.76457903e-02f, -2.14544311e-01f, 3.46499644e-02f, 1.23920506e-02f, 5.34774289e-02f, 6.58544153e-02f, 6.56069815e-02f, 1.74319103e-01f, 1.57800354e-02f, -4.33777496e-02f,
  2.52356641e-02f, -4.47552726e-02f, 5.37036657e-02f, 1.29903406e-01f, -2.60743871e-02f, -1.96214784e-02f, 6.97345808e-02f, -2.01475061e-02f, -1.27735227e-01f, 4.27263863e-02f,
  -1.44571066e-02f, 1.11552149e-01f, 1.10320505e-02f, 6.82732672e-04f, -2.26014089e-02f, 2.93172933e-02f, -2.34149415e-02f, 1.01590261e-01f, -1.40064757e-03f, -1.57038886e-02f,
  8.78983885e-02f, -9.09235328e-02f, -2.51347274e-02f, -9.25781764e-03f, -4.52982225e-02f, 5.82606271e-02f, 2.62807347e-02f, 3.16673256e-02f, 1.36936516e-01f, -7.56553188e-02f,
  -4.62139305e-03f, -6.85716122e-02f, -4.09075730e-02f, 9.15922970e-02f, 3.06039974e-02f, -1.22328795e-01f, 1.32733341e-02f, 1.22446753e-02f, 1.65711045e-02f, 6.90679438e-03f,
  -1.96977444e-02f, 1.62368398e-02f, -3.12782824e-02f, -4.54022102e-02f, -7.86262229e-02f, 4.76410910e-02f, -4.73679714e-02f, 1.91382617e-02f, -3.07962392e-02f, 4.00981531e-02f,
  -1.00272335e-01f, -2.82082289e-01f, 5.70039358e-03f, -1.16588436e-02f, 6.30753636e-02f, 1.32643551e-01f, 4.28135134e-02f, 4.07042913e-02f, -1.48627311e-02f, -3.50702484e-03f,
  2.34171152e-02f, -2.30572335e-02f, -5.61353378e-03f, 1.16292462e-02f, -4.96861339e-02f, 6.49697671e-04f, -1.87760103e-03f, -3.40413488e-02f, -8.54302347e-02f, -6.61490932e-02f,
  -9.50038210e-02f, -1.56095168e-02f, 3.32293436e-02f, -8.53497535e-02f, -8.64187256e-02f, 4.87646572e-02f, -1.57419845e-01f, 2.35409988e-03f, 1.22568190e-01f, 9.37658772e-02f,
  3.52042913e-02f, 5.15908599e-01f, 1.20206252e-01f, 2.56512277e-02f, -1.81803584e-01f, -3.23500723e-01f, -2.81770408e-01f, 3.45415995e-02f, 9.63578746e-02f, 1.53014679e-02f,
  -2.57416576e-01f, 2.95545995e-01f, -1.12194791e-01f, -6.03165105e-02f, -5.89627549e-02f, 2.78672781e-02f, -2.69966453e-01f, -1.64211392e-01f, 3.90238501e-02f, -8.21010619e-02f,
  -6.50649816e-02f, -2.44094595e-01f, -1.65421322e-01f, -6.69633374e-02f, -2.12122709e-01f, 6.57976046e-02f, -1.24489978e-01f, -2.22156215e-02f, -5.45302555e-02f, -2.94844490e-02f,
  -7.17766061e-02f, 1.02928758e-01f, -2.46450156e-02f, 1.85686164e-02f, -1.51347622e-01f, -1.07512347e-01f, -1.02679498e-01f, -2.92672329e-02f, -1.69059597e-02f, -2.97673345e-02f,
  -6.32459298e-03f, 1.62270498e-02f, -5.14070056e-02f, -1.03548756e-02f, -5.26227988e-02f, 7.06311017e-02f, 4.99631129e-02f, -7.28741661e-02f, 1.25325158e-01f, 4.95327376e-02f,
  6.54121190e-02f, -5.21234944e-02f, -9.07662064e-02f, -5.20369075e-02f, 7.16635808e-02f, 8.00351724e-02f, 2.10960403e-01f, 3.36449966e-02f, -5.13504073e-03f, 4.58979085e-02f,
  -5.93137220e-02f, 1.12270005e-01f, 5.50631694e-02f, -4.11879085e-02f, 1.75384283e-01f, -3.49649377e-02f, -2.34347805e-02f, 6.00944310e-02f, 9.33045596e-02f, 1.06011610e-02f,
  -5.61090559e-02f, -5.25063509e-03f, -6.74313447e-03f, -1.15819454e-01f, -2.52832100e-03f, -3.79032530e-02f, -3.37528847e-02f, 5.07467426e-02f, -1.09819964e-01f, -2.28175092e-02f,
  1.38188927e-02f, 9.64575037e-02f, 2.35803127e-02f, -7.66179115e-02f, 4.15963726e-03f, 6.59896061e-02f, 1.23103663e-01f, -2.37296708e-02f, 7.15354981e-04f, -8.09280723e-02f,
  4.64309976e-02f, 2.63283819e-01f, -8.25326424e-03f, -1.78524256e-02f, 6.91995537e-03f, -8.62658396e-02f, -6.15541749e-02f, -5.03278635e-02f, -2.42377073e-02f, -2.12517474e-02f,
  -4.36908081e-02f, -6.45416379e-02f, -6.01204447e-02f, -1.64603353e-01f, 4.88507859e-02f, 6.69512600e-02f, 6.09836392e-02f, -4.33999375e-02f, -1.87246539e-02f, 7.19362795e-02f,
  3.54623012e-02f, -1.20854579e-01f, -1.27715210e-03f, -1.17561385e-01f, 2.28360128e-02f, -8.64213556e-02f, 1.26498416e-01f, 7.39879534e-02f, -7.87816197e-03f, -5.82299335e-03f,
  1.89936489e-01f, -2.43705586e-01f, 1.42668104e-02f, 1.40554726e-01f, 2.82102334e-03f, 2.22123325e-01f, 9.91277695e-02f, -9.58456248e-02f, -2.70543128e-01f, -1.16024375e-01f,
  -5.72430752e-02f, 2.15498075e-01f, -1.91574961e-01f, 1.49448395e-01f, 5.47431231e-01f, -1.92246422e-01f, 1.12095252e-01f, 3.47123817e-02f, -1.44801602e-01f, 1.80027261e-01f,
  5.19171543e-02f, 2.23864853e-01f, 1.22477621e-01f, 1.38274759e-01f, 9.90014002e-02f, -1.04090691e-01f, 2.29979843e-01f, 1.97064839e-02f, 2.41397649e-01f, 3.95563729e-02f,
  4.50773463e-02f, -1.50453970e-01f, -3.17681767e-02f, 8.44441913e-03f, -8.51801783e-02f, 3.96102704e-02f, 6.03366978e-02f, 7.15568364e-02f, 4.49335622e-03f, -8.41285586e-02f,
  -5.72628854e-03f, 3.19815017e-02f, -1.40305953e-02f, 1.55453607e-01f, 2.96010785e-02f, 1.12640113e-01f, -1.56408504e-01f, -2.66956855e-02f, -3.27123292e-02f, 6.26619533e-02f,
  -2.89894789e-02f, -1.24293007e-01f, 4.10939008e-03f, -4.90139723e-02f, -2.44851932e-02f, -1.47865608e-01f, 3.25027667e-02f, 3.83534171e-02f, -1.71904881e-02f, 2.01716591e-02f,
  -2.70287283e-02f, -2.64620967e-02f, 5.46398871e-02f, 1.00404238e-02f, 3.35955843e-02f, -3.42745259e-02f, 1.12409875e-01f, 6.09080680e-02f, 3.58862034e-03f, -2.16373876e-02f,
  -7.25455955e-02f, 3.64788696e-02f, -8.52755830e-02f, 7.71463811e-02f, 8.16997588e-02f, -1.38904816e-02f, 5.51855043e-02f, 2.07738467e-02f, -9.04841628e-03f, 1.40560180e-01f,
  6.25760183e-02f, -1.86417196e-02f, -1.05349794e-01f, -6.02140687e-02f, -2.07571369e-02f, -3.64682637e-02f, 8.34332705e-02f, 7.27301687e-02f, -1.25062421e-01f, 1.11861996e-01f,
  -4.55819219e-02f, -9.94258970e-02f, -8.89707357e-02f, -2.13982817e-02f, -6.89780787e-02f, 3.05090640e-02f, 7.89472461e-02f, 7.09960004e-03f, 4.25777808e-02f, 5.33673540e-02f,
  3.17293964e-02f, -5.21814339e-02f, -3.18628959e-02f, 5.96309677e-02f, 5.69933057e-02f, 2.53228787e-02f, -8.62397328e-02f, -9.44070369e-02f, -3.93725745e-02f, 2.49819667e-03f,
  6.06061444e-02f, -3.84479091e-02f, -2.59855669e-03f, 1.71028972e-02f, 2.87339315e-02f, -5.33259474e-02f, 7.13813677e-02f, -7.62481466e-02f, 6.06539249e-02f, -4.97038811e-02f,
  -6.99472241e-03f, 1.92382708e-01f, 2.65725940e-01f, 2.44347692e-01f, -1.22152932e-01f, -2.81872153e-01f, -1.64600790e-01f, 9.07383859e-02f, 1.59108073e-01f, -2.15877950e-01f,
  -3.11366796e-01f, 2.53541946e-01f, -1.59757122e-01f, -1.20445220e-02f, -1.21082194e-01f, -6.86107129e-02f, 1.87537253e-01f, 6.93594292e-02f, 1.04276560e-01f, 1.46120802e-01f,
  1.10590816e-01f, -1.05135053e-01f, 1.95221856e-01f, 8.29545632e-02f, 4.22678851e-02f, 1.81736693e-01f, -2.16977298e-01f, 1.55716566e-02f, 3.44623737e-02f, -1.70013984e-03f,
  -1.95222478e-02f, -3.82863879e-02f, 3.02330367e-02f, 7.70709068e-02f, -9.15802270e-02f, -9.92368609e-02f, 2.02342384e-02f, -4.37147059e-02f, 6.31938949e-02f, -1.26156192e-02f,
  3.17815021e-02f, 1.37011364e-01f, -4.79118247e-03f, -1.02339461e-01f, 3.12748365e-02f, 4.65427190e-02f, 1.79345325e-01f, -2.47394685e-02f, 1.71178013e-01f, -2.03585960e-02f,
  4.26820628e-02f, 5.94129153e-02f, 6.93965852e-02f, 9.11898464e-02f, 6.06655106e-02f, 3.85070704e-02f, -4.85250503e-02f, -4.53892313e-02f, 4.31488976e-02f, -3.40556838e-02f,
  -9.67269987e-02f, -1.89016033e-02f, -7.41498545e-02f, 2.65063066e-02f, -8.74071419e-02f, -8.23770836e-02f, -6.69677034e-02f, 6.42603554e-04f, 1.15830541e-01f, 1.40335911e-03f,
  8.57782811e-02f, 2.57210396e-02f, 6.99974224e-02f, 1.95470713e-02f, -3.10403556e-02f, -3.55950929e-02f, 2.29302831e-02f, -3.23673524e-02f, 6.50048256e-02f, -1.16923347e-01f,
  9.83807910e-03f, 1.00544721e-01f, -9.63049359e-04f, -1.18687870e-02f, -6.76963404e-02f, 4.93147485e-02f, 7.17542917e-02f, -6.42013475e-02f, 1.65780522e-02f, -3.34535390e-02f,
  -8.90945122e-02f, 5.49746379e-02f, 3.54888663e-02f, 8.46574008e-02f, -1.44768888e-02f, -4.70487459e-04f, -4.09797393e-02f, 2.14043912e-02f, 5.12607321e-02f, -1.73798129e-02f,
  7.45025426e-02f, 1.21498130e-01f, -3.05037815e-02f, -1.94344521e-02f, 5.64909726e-02f, -1.55708075e-01f, 1.22740060e-01f, -4.77630505e-03f, 1.51814103e-01f, -1.71549004e-02f,
  -3.34160142e-02f, -3.44725437e-02f, 1.22257955e-01f, -3.98337506e-02f, 1.09940127e-01f, 3.15851942e-02f, -1.19275823e-01f, 2.91286428e-02f, 2.29252540e-02f, 5.39335944e-02f,
  -2.14250758e-01f, -1.90964386e-01f, -2.68957138e-01f, -2.12962851e-01f, -6.35352135e-02f, -1.01058604e-03f, 1.00726664e-01f, -7.95998871e-02f, -2.03595757e-01f, 2.30036706e-01f,
  2.82675564e-01f, -9.63156670e-02f, 2.60754049e-01f, 3.85086164e-02f, 9.85820368e-02f, 2.22625062e-01f, -1.02577932e-01f, -8.75381306e-02f, -1.45397708e-01f, 1.75793041e-02f,
  -9.81461853e-02f, 2.71417171e-01f, 2.72168149e-03f, -4.60625216e-02f, -5.54188155e-02f, -2.41818488e-01f, 3.22427392e-01f, -1.25827622e-02f, -6.62207324e-03f, 1.15271220e-02f,
  -8.87622237e-02f, 5.66636473e-02f, -6.06779046e-02f, -5.34820519e-02f, 4.77784872e-02f, 7.41578341e-02f, -1.87762007e-02f, 1.15103638e-02f, -7.18316669e-03f, -2.79659703e-02f,
  8.41767117e-02f, -5.75773092e-03f, 1.08685447e-02f, 9.10103247e-02f, -4.84287106e-02f, -9.11829025e-02f, -9.36473310e-02f, 1.37517890e-02f, 1.89402862e-03f, 1.55249666e-02f,
  -8.85723680e-02f, -1.30529895e-01f, 6.06404990e-02f, 4.76180017e-02f, -3.64862233e-02f, -8.90919641e-02f, -1.34022027e-01f, -3.56920948e-03f, -6.19533472e-02f, 3.98944579e-02f,
  1.39636502e-01f, 5.50988987e-02f, 5.13580441e-02f, -1.37145758e-01f, -1.63044930e-01f, -5.85746616e-02f, 7.90564865e-02f, 1.69590898e-02f, -1.58121929e-01f, -2.69471221e-02f,
  -8.18422437e-02f, 2.14133784e-03f, -3.91600537e-04f, -5.61411045e-02f, 8.45785886e-02f, -2.62526199e-02f, 1.73056778e-02f, 5.11273928e-02f, 1.75919626e-02f, 6.95905974e-03f,
  1.22130401e-01f, -1.76437974e-01f, -5.19470312e-02f, 6.49761707e-02f, -2.37180982e-02f, -2.32724659e-02f, 6.09847531e-02f, -6.49296632e-03f, -6.85822293e-02f, 1.75587654e-01f,
  1.16302334e-01f, 1.97811499e-01f, -6.70741685e-03f, -1.12752080e-01f, 8.35699029e-03f, 4.88466434e-02f, 1.42330686e-02f, -2.16228608e-02f, 1.17166325e-01f, 7.32214525e-02f,
  -7.43003860e-02f, -8.30630362e-02f, 7.76101351e-02f, 3.40047665e-02f, -2.78268624e-02f, 7.04952851e-02f, 2.79498827e-02f, 5.04180565e-02f, 5.80207109e-02f, 5.09793125e-02f,
  1.97504740e-02f, 2.63596959e-02f, 2.57755388e-02f, 8.44020694e-02f, -3.70863974e-02f, 5.60969338e-02f, -6.82375878e-02f, -1.13776669e-01f, -7.41077028e-03f, -1.61742475e-02f,
  1.03990212e-01f, -1.31612763e-01f, -3.53126824e-01f, 9.95472074e-02f, 5.27342185e-02f, -3.31595629e-01f, -8.57988372e-02f, 3.22418511e-02f, -5.05724698e-02f, -7.41844205e-03f,
  1.79813713e-01f, -1.29327998e-01f, 1.07844789e-02f, 1.68007180e-01f, -1.14827946e-01f, -1.34653002e-02f, -1.26339808e-01f, -7.82794878e-03f, 3.07319760e-02f, -1.44932475e-02f,
  -1.92562938e-02f, 1.13472365e-01f, -5.46662025e-02f, 8.71689320e-02f, -9.04322714e-02f, 5.36112525e-02f, 3.39912534e-01f, -7.08465055e-02f, 7.73587823e-02f, 7.17881545e-02f,
  -4.52750316e-03f, 2.02929735e-01f, 2.58109998e-02f, -3.96726727e-02f, 3.52598615e-02f, -1.71863046e-02f, -5.98779246e-02f, 8.41813907e-02f, 8.63920450e-02f, -4.82820980e-02f,
  -1.92172267e-02f, -9.45175067e-02f, 4.66762558e-02f, -8.25441107e-02f, -1.88857824e-01f, 1.28912961e-03f, -8.93629938e-02f, -5.48916273e-02f, 5.05999736e-02f, -9.65589285e-02f,
  -7.67932311e-02f, -1.40997499e-01f, -6.20556846e-02f, -1.16595905e-02f, 6.26197504e-03f, 3.41899022e-02f, -2.30806712e-02f, -4.62397411e-02f, -1.04475722e-01f, -7.71051720e-02f,
  1.24367578e-02f, -6.25484735e-02f, 9.80939865e-02f, -3.28680351e-02f, 1.04774192e-01f, 6.93836585e-02f, 6.98341653e-02f, 5.25246300e-02f, 2.95458827e-02f, -3.71488184e-02f,
  1.14390682e-02f, 5.97413853e-02f, -3.10060345e-02f, -6.17250875e-02f, -8.06441437e-03f, 9.68338572e-05f, 8.75357818e-03f, -7.69998133e-02f, -1.39308691e-01f, 1.46250769e-01f,
  9.71803665e-02f, -1.01684071e-01f, 5.72811514e-02f, -1.76816210e-02f, -5.68395071e-02f, 4.49929386e-02f, -5.94207421e-02f, -8.25069565e-03f, 1.66010074e-02f, -1.04218528e-01f,
  -1.18834339e-01f, -2.38497555e-02f, 9.55966860e-02f, -1.50952153e-02f, 4.97798622e-02f, -6.31820932e-02f, -4.86684255e-02f, 2.33342480e-02f, -8.34946409e-02f, -4.96962816e-02f,
  -8.88763219e-02f, 2.41439696e-02f, -1.39547303e-01f, -3.39888930e-02f, -1.43446773e-01f, 1.84627678e-02f, -7.13350326e-02f, 3.23749259e-02f, 7.58084329e-03f, 6.63928390e-02f,
  1.03239663e-01f, -3.40616331e-02f, -7.72986561e-02f, -3.04690213e-03f, 7.77205965e-03f, -5.18462202e-03f, 5.10541759e-02f, -1.15392707e-01f, -5.47150560e-02f, -1.96977872e-02f,
  -2.90845305e-01f, -1.79804623e-01f, -4.87272106e-02f, -2.34313816e-01f, -1.65651679e-01f, 2.15295509e-01f, 1.13858595e-01f, -1.58643126e-01f, -4.15189862e-01f, 1.11251585e-01f,
  7.27211237e-02f, -8.36052150e-02f, 1.17971674e-01f, 8.47268254e-02f, 3.10331315e-01f, 1.43906981e-01f, 1.34215415e-01f, 3.81002091e-02f, -1.99751496e-01f, 1.56035824e-02f,
  -7.44705722e-02f, 3.08503836e-01f, 1.71682969e-01f, 2.23302320e-01f, -4.58845533e-02f, -1.95766106e-01f, 2.28145093e-01f, 6.12717718e-02f, 1.12863839e-01f, 6.71546906e-02f,
  -2.80305389e-02f, -1.74754471e-01f, -8.59248564e-02f, -3.84686254e-02f, -4.01439071e-02f, -4.08539623e-02f, 1.54380739e-01f, 1.02682911e-01f, -1.12805255e-01f, 5.97455688e-02f,
  -3.77467871e-02f, 4.99341339e-02f, 2.29826085e-02f, 1.18259132e-01f, -7.37110004e-02f, 4.89704404e-03f, -2.84356087e-01f, -4.87129837e-02f, -8.76073763e-02f, 2.82596275e-02f,
  -7.89555311e-02f, -8.12196806e-02f, 1.13514941e-02f, -6.88559096e-03f, 9.50300600e-03f, -1.13959856e-01f, 6.21085651e-02f, 1.40904352e-01f, 6.16199151e-02f, 1.82478447e-02f,
  4.27377746e-02f, 2.68212613e-03f, 7.42332339e-02f, -1.59889795e-02f, 3.76126282e-02f, 4.03986173e-03f, 4.98256832e-02f, 3.40106525e-02f, -6.87184334e-02f, 5.73606640e-02f,
  -4.11016904e-02f, -3.94988395e-02f, 4.09820257e-03f, -2.40643676e-02f, 2.53816117e-02f, 5.07792644e-03f, 9.81808007e-02f, 5.41268028e-02f, -6.56097755e-03f, 7.77051747e-02f,
  -7.21960887e-02f, -4.24899943e-02f, -1.56461969e-02f, 6.04567900e-02f, 2.80236620e-02f, 3.87280881e-02f, -6.46443143e-02f, 2.15639807e-02f, -1.20775938e-01f, 1.31922096e-01f,
  5.91145642e-02f, 6.58509582e-02f, -5.06597981e-02f, -9.44429711e-02f, 3.80262844e-02f, 3.72171029e-02f, -2.59747002e-02f, 2.70633167e-03f, 1.51690859e-02f, 5.80303408e-02f,
  1.82408802e-02f, -4.73585092e-02f, 5.49533963e-02f, 6.93304986e-02f, 2.68715695e-02f, 1.31622404e-01f, -9.35769305e-02f, -6.31424189e-02f, 1.31988507e-02f, 3.39168273e-02f,
  -4.24806029e-02f, 1.01103066e-02f, 2.46608839e-03f, 4.71332744e-02f, -4.10708077e-02f, -5.48296683e-02f, -3.09544820e-02f, -4.83820327e-02f, 8.12690519e-03f, 6.01880997e-02f,
  -8.23100805e-02f, 3.32131296e-01f, -2.20152050e-01f, -2.32752711e-02f, -3.83507684e-02f, -3.29584002e-01f, -1.98982179e-01f, 2.43992568e-03f, -2.46846139e-01f, 2.67382741e-01f,
  5.48552945e-02f, 2.57007718e-01f, 4.21871766e-02f, 1.74156249e-01f, -2.57294714e-01f, -2.43159123e-02f, 6.00513741e-02f, 9.56765488e-02f, 1.86089575e-02f, -7.89348502e-04f,
  -1.61550671e-01f, 1.05800927e-01f, -3.77320945e-02f, 4.46591973e-02f, 1.83283389e-01f, 6.85173944e-02f, 1.66636482e-01f, 9.10875108e-03f, 5.22564799e-02f, 3.29876691e-02f,
  -2.18117144e-02f, 4.06638812e-03f, 2.36716866e-02f, -1.13502055e-01f, 8.94727781e-02f, 4.14672345e-02f, -3.72895263e-02f, -2.45399792e-02f, -7.80052915e-02f, -7.98216909e-02f,
  1.16450787e-01f, -8.62538964e-02f, 1.06144771e-01f, -1.13014676e-01f, -1.00000482e-02f, -1.43052354e-01f, 4.20139655e-02f, -1.38908952e-01f, -4.63240184e-02f, -8.29902440e-02f,
  -7.60471374e-02f, 3.94276902e-02f, 2.18432862e-02f, -4.81504947e-02f, -1.41532466e-01f, -3.91806625e-02f, -1.60795912e-01f, 7.16066584e-02f, -2.12073904e-02f, -5.44741973e-02f,
  -3.95327387e-03f, -1.33836353e-02f, -5.71307018e-02f, 3.55174951e-02f, 2.64155939e-02f, -9.80222449e-02f, -4.65679169e-02f, 4.47262973e-02f, -5.26384562e-02f, 8.70019943e-03f,
  9.73866805e-02f, 1.67639013e-02f, 9.60754752e-02f, -9.69515145e-02f, 4.40150276e-02f, 9.23312735e-03f, -3.63911353e-02f, 6.23664744e-02f, 4.47986610e-02f, -4.61171046e-02f,
  -1.50255850e-02f, -5.17267361e-02f, 1.38957143e-01f, -1.12117343e-01f, 2.17670817e-02f, 4.42565344e-02f, -8.22928324e-02f, -4.35693637e-02f, -1.44795664e-02f, -5.70121743e-02f,
  1.35699511e-01f, 2.00836092e-01f, 4.86464016e-02f, -7.25639611e-03f, 3.04416176e-02f, 7.17101395e-02f, -1.07448041e-01f, -9.93612483e-02f, -2.70916317e-02f, -5.07945530e-02f,
  -6.40631514e-03f, -1.17467269e-01f, 9.32120308e-02f, -1.10790044e-01f, -2.08490435e-03f, -1.01355530e-01f, 1.04457982e-01f, -2.27959603e-02f, 1.53855711e-01f, 1.12756759e-01f,
  -7.31211975e-02f, 1.81460101e-03f, 8.10596254e-03f, -1.56529605e-01f, -1.85765307e-02f, 2.21268773e-01f, 6.77622855e-02f, -1.19440891e-02f, 7.30578229e-02f, -2.45991740e-02f,
  3.82431388e-01f, -2.81865448e-01f, -6.08546324e-02f, 5.89464866e-02f, 1.84927657e-01f, 3.61079901e-01f, 2.40091890e-01f, -1.93363559e-02f, 3.04571986e-02f, -2.84738123e-01f,
  -1.33358538e-01f, -5.53995408e-02f, -2.06109658e-01f, 7.58887902e-02f, 5.35341620e-01f, 4.17164676e-02f, 1.73013791e-01f, 5.12285307e-02f, -8.37368239e-03f, -4.80481535e-02f,
  8.04646984e-02f, 7.48903677e-02f, -4.39270586e-02f, -1.23965219e-02f, 5.29400744e-02f, -3.97385657e-02f, 5.00002056e-02f, -3.61096002e-02f, 1.09054288e-02f, 3.73440795e-02f,
  1.97147224e-02f, -1.33381978e-01f, -4.17253897e-02f, 2.10297108e-02f, -3.73090953e-02f, -3.32052261e-02f, 1.86883882e-02f, 3.46007906e-02f, 5.42881191e-02f, -8.88738930e-02f,
  -1.25337131e-02f, 7.83967674e-02f, 5.75971464e-03f, 5.77531643e-02f, 1.12834036e-01f, -3.93297412e-02f, -1.45961242e-02f, 7.12576672e-04f, -1.47594586e-01f, 1.20003866e-02f,
  -3.26301716e-02f, -7.36922398e-02f, 3.10367011e-02f, -4.39265296e-02f, 1.30518078e-04f, 1.32705718e-02f, 3.37178111e-02f, -2.40848288e-02f, -5.62261790e-02f, 2.54995525e-02f,
  -1.67808682e-02f, 2.56892238e-02f, 4.32553403e-02f, -6.99910074e-02f, 6.37211725e-02f, 1.63079740e-03f, 5.39753623e-02f, 1.18839061e-02f, 2.00877134e-02f, -8.43598545e-02f,
  -2.53989734e-02f, -1.19928448e-02f, -9.31699015e-03f, 5.83414733e-02f, -2.20711604e-02f, -1.08936034e-01f, 6.13649702e-03f, -2.88964007e-02f, -3.99792083e-02f, 5.31025678e-02f,
  -3.44934836e-02f, 3.47470529e-02f, -5.48554026e-02f, -4.95324694e-02f, 3.84111293e-02f, -1.25684673e-02f, 2.57105157e-02f, -1.26753645e-02f, -3.58133353e-02f, 4.99683013e-03f,
  7.90160894e-03f, -9.62234810e-02f, -1.07083686e-01f, -1.97741073e-02f, -9.78964940e-02f, 7.42046535e-03f, 3.04582696e-02f, 5.71935773e-02f, 4.35971394e-02f, 8.49851314e-03f,
  2.79216021e-02f, -1.14690438e-02f, -9.22876410e-03f, 1.23600122e-02f, 2.64524352e-02f, 2.49411408e-02f, -3.54039632e-02f, -3.63443755e-02f, -8.47466365e-02f, -1.04729749e-01f,
  7.79773667e-02f, 5.68552874e-04f, 6.90190569e-02f, 6.85880193e-03f, 5.61079234e-02f, -5.85815273e-02f, 1.55870438e-01f, -6.71244115e-02f, 1.29006859e-02f, -1.42204404e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.19936416e-01f, -3.31170112e-01f, 3.16473484e-01f, 5.08115962e-02f, 3.17011952e-01f, 3.22844476e-01f, 1.55924916e-01f, 1.71499234e-02f, -1.68654233e-01f, -2.83919275e-01f,
  -6.86091334e-02f, -3.17246914e-02f, -1.71416640e-01f, -1.17092311e-01f, -4.99330573e-02f, -2.85432070e-01f, -6.99870959e-02f, -2.09755763e-01f, -1.66906580e-01f, -7.44074807e-02f,
  -1.23307062e-03f, -1.35280088e-01f, 1.33591980e-01f, -1.97068363e-01f, 1.54134914e-01f, -1.15259970e-02f, -1.51368901e-01f, -7.25642964e-02f, 2.22831056e-03f, 1.06869720e-01f,
  1.18090976e-02f, 5.32532446e-02f, -1.26950047e-03f, 6.88021034e-02f, 1.54137686e-01f, 1.14406049e-01f, 6.68416992e-02f, -2.20229048e-02f, 1.65841609e-01f, 6.67630881e-02f,
  4.88434397e-02f, 9.16140750e-02f, -2.77535878e-02f, -3.03666983e-02f, -4.65005338e-02f, -5.84464613e-03f, 1.36689171e-01f, 6.82026967e-02f, -1.84550378e-02f, 1.50276363e-01f,
  8.46372470e-02f, 7.75777772e-02f, 4.06065583e-02f, -2.11275481e-02f, 1.13317572e-01f, 1.40635118e-01f, 1.05135977e-01f, 8.50853696e-02f, 1.80118792e-02f, 7.74393454e-02f,
  1.66973285e-02f, -4.11462113e-02f, -5.59776416e-03f, 3.08997575e-02f, -3.91526632e-02f, 4.67941537e-02f, -1.95905697e-02f, -3.77284735e-02f, -1.81508102e-02f, -6.38308451e-02f,
  1.24638174e-02f, -4.14128043e-03f, 2.45655589e-02f, 1.00235799e-02f, 6.65508062e-02f, 1.03808247e-01f, 5.94666693e-03f, -1.69819463e-02f, -1.16279197e-03f, -8.39936733e-02f,
  -7.78098404e-02f, -1.64371673e-02f, -1.43876811e-02f, -1.41191867e-03f, -5.80548197e-02f, 2.54260693e-02f, -2.00811476e-02f, 2.32202727e-02f, 2.38895342e-02f, -6.84455037e-02f,
  -3.53830874e-01f, -3.00368965e-01f, -1.22057818e-01f, 5.57783060e-02f, -2.84051076e-02f, 5.81502132e-02f, -8.24958310e-02f, -1.24470256e-02f, -6.20125122e-02f, -6.35432526e-02f,
  1.33675307e-01f, 1.44957351e-02f, -1.31324738e-01f, -4.29838933e-02f, -5.33854291e-02f, -6.09268062e-03f, 3.33386324e-02f, -3.52944210e-02f, -2.19635759e-03f, 1.12842524e-03f,
  4.15852442e-02f, -3.81365940e-02f, 9.92081389e-02f, 2.42436361e-02f, 3.64148282e-02f, -9.16152224e-02f, -9.31790322e-02f, -2.22866014e-02f, -8.16940740e-02f, 2.85153259e-02f,
  2.78287858e-01f, -8.00921917e-02f, -2.26109132e-01f, -2.95639038e-01f, 2.10602880e-01f, 4.52701837e-01f, 3.41526419e-02f, -7.17998967e-02f, -3.27688783e-01f, 5.02248891e-02f,
  8.05834904e-02f, 5.81517592e-02f, -1.33050531e-01f, 3.29089880e-01f, 3.75364393e-01f, 1.13989450e-01f, 1.19450279e-01f, 1.74543589e-01f, 6.03749827e-02f, 1.37218162e-01f,
  8.52184072e-02f, 4.40626174e-01f, -9.59823560e-03f, 3.66600484e-01f, 2.06282556e-01f, -2.35971466e-01f, 2.83592269e-02f, -3.52855399e-02f, 1.22994721e-01f, 2.61226803e-01f,
  1.08691424e-01f, 7.91620370e-03f, 2.73110736e-02f, 1.27047105e-02f, 2.87343655e-02f, 8.48985612e-02f, 4.76022847e-02f, 1.52934462e-01f, -1.36628747e-01f, -8.53744671e-02f,
  -8.20694938e-02f, -1.08092859e-01f, 7.01079145e-02f, 6.21597543e-02f, 3.96543145e-02f, -5.84025569e-02f, -1.97179630e-01f, 9.50605702e-03f, -2.49038234e-01f, 1.37210861e-01f,
  -1.59237668e-01f, -2.21683234e-01f, -1.22309975e-01f, -4.28409092e-02f, -1.06005706e-01f, -1.08890623e-01f, -1.04134843e-01f, -6.99288249e-02f, -1.14229321e-01f, 1.97932087e-02f,
  1.28475025e-01f, -2.90088709e-02f, 8.78266692e-02f, 7.87949339e-02f, 3.55637819e-02f, 1.88436005e-02f, 4.60913144e-02f, 2.56258808e-02f, -1.30485833e-01f, -1.11084068e-02f,
  -1.89862162e-01f, -7.96231776e-02f, -3.27547491e-02f, -2.04477236e-02f, 7.62745962e-02f, -9.70910192e-02f, 3.96281704e-02f, 5.09986393e-02f, -1.26225814e-01f, -2.11892258e-02f,
  -4.46450897e-02f, -7.09657446e-02f, -2.56497748e-02f, -1.02077357e-01f, -1.00631239e-02f, -5.24763996e-03f, 7.20065758e-02f, 4.93338294e-02f, 3.73718888e-02f, 1.63480956e-02f,
  -5.32933101e-02f, 3.40411440e-02f, -4.62042317e-02f, -1.34577230e-02f, -2.59865485e-02f, 1.35989621e-01f, 1.54791042e-01f, 1.20985411e-01f, -2.03813240e-03f, 9.39742625e-02f,
  2.43729111e-02f, -1.80708826e-01f, -7.64040798e-02f, 2.28632987e-02f, -1.70239702e-01f, 1.13915265e-01f, -8.81680995e-02f, -8.77659619e-02f, -1.99764833e-01f, -4.30790223e-02f,
  -1.67021528e-02f, -4.21977453e-02f, -5.20420261e-02f, 5.87589517e-02f, -3.46928835e-02f, -1.41880676e-01f, 1.97041750e-01f, -1.57014616e-02f, 6.63264189e-03f, -2.00355813e-01f,
  -4.80247378e-01f, -2.57730097e-01f, 1.30921125e-01f, -2.10010543e-01f, -2.54867166e-01f, 1.04232328e-02f, 3.22692335e-01f, -2.80656695e-01f, -3.67513776e-01f, 7.13097081e-02f,
  5.20724915e-02f, 3.84903587e-02f, 4.17126358e-01f, -1.31876633e-01f, 1.62614137e-01f, 3.97186220e-01f, -6.13225922e-02f, 3.84155773e-02f, -1.77109972e-01f, -2.21337304e-01f,
  -1.34160325e-01f, -1.29660502e-01f, 3.29866737e-01f, -3.38181883e-01f, -2.60209084e-01f, -3.00448835e-01f, -3.64221893e-02f, -8.95651057e-03f, -2.76591510e-01f, -1.01263210e-01f,
  -2.24282786e-01f, -2.42140606e-01f, 1.22177809e-01f, -1.27197998e-02f, -1.08274385e-01f, 7.62287006e-02f, 8.38301480e-02f, 1.69920936e-01f, 5.01607284e-02f, 4.11589369e-02f,
  -1.34488102e-03f, -1.90463603e-01f, -1.71213970e-01f, 7.38647059e-02f, -1.83005095e-01f, -1.94336370e-01f, -3.67071554e-02f, -3.68844159e-02f, 1.55347893e-02f, 6.93505583e-03f,
  5.64445294e-02f, -1.59252563e-03f, -6.16128892e-02f, -6.83296844e-02f, 2.22608186e-02f, 2.30195951e-02f, 9.69622284e-02f, 2.84998734e-02f, 1.29738776e-02f, -1.71512514e-01f,
  -4.51102890e-02f, 4.69928980e-03f, 1.00942954e-01f, -6.89646751e-02f, -1.37908176e-01f, -5.81839196e-02f, 7.30382875e-02f, 9.62855443e-02f, -1.04411715e-03f, -5.12305414e-04f,
  -6.47016913e-02f, 1.65626276e-02f, -5.01126908e-02f, 2.57687494e-02f, -1.28806695e-01f, 1.32877165e-02f, 1.81644753e-01f, -1.40042573e-01f, -1.41438887e-01f, -4.33929749e-02f,
  1.06895603e-01f, -4.91406210e-02f, -1.20002002e-01f, 9.84355435e-02f, -2.22438592e-02f, 1.23478018e-01f, -5.23077883e-02f, -7.31404126e-02f, 5.61879016e-02f, 1.09802678e-01f,
  -3.72116029e-01f, -3.16927910e-01f, 5.69205172e-02f, 2.87718456e-02f, 8.35109577e-02f, -3.96706313e-02f, 2.37426627e-02f, -1.42673567e-01f, -9.11578760e-02f, -5.58859669e-02f,
  -1.16860159e-01f, -5.74558079e-02f, -8.63254815e-02f, -5.79618812e-02f, 1.77739058e-02f, -5.66837452e-02f, 3.17291059e-02f, -1.21428277e-02f, 2.98605356e-02f, -1.64701506e-01f,
  1.09476477e-01f, 2.73764972e-02f, 3.51464711e-02f, -4.10796963e-02f, 1.56686693e-01f, 5.23425080e-02f, -1.45977020e-01f, -6.07013330e-02f, -7.16982782e-02f, -1.53444754e-02f,
  -4.91560763e-03f, -6.46649301e-02f, -2.73341805e-01f, -8.39314535e-02f, 1.54669508e-01f, 6.38106018e-02f, 1.60874892e-02f, 1.19449366e-02f, -8.42097849e-02f, 2.43008316e-01f,
  8.44033435e-02f, 8.49751104e-03f, -1.82442963e-01f, -8.96534622e-02f, -3.66271615e-01f, -3.30138654e-01f, -1.35017157e-01f, -2.48075724e-02f, -1.98219836e-01f, -2.26796325e-02f,
  -1.43629715e-01f, 9.65510160e-02f, -3.03223044e-01f, 3.45695049e-01f, 2.15981260e-01f, 1.53578803e-01f, 2.42634520e-01f, 2.34893486e-01f, 1.58421114e-01f, 1.29457235e-01f,
  -7.08451271e-02f, -8.26501623e-02f, -7.31260702e-02f, -1.78262070e-02f, -9.93607193e-02f, 1.63627431e-01f, 1.00907013e-01f, -3.72073241e-02f, -3.82711668e-03f, -8.68605971e-02f,
  1.50170000e-02f, 7.34210536e-02f, 1.06434830e-01f, 1.28558531e-01f, 2.29342371e-01f, 1.22052148e-01f, -9.02361348e-02f, -3.48599739e-02f, -2.04228479e-02f, -1.74530856e-02f,
  -1.59669966e-01f, -7.04074204e-02f, 1.01723626e-01f, -1.09062433e-01f, -1.58512771e-01f, 2.74126288e-02f, 2.18412597e-02f, 2.42373049e-02f, 8.82786661e-02f, -1.50936767e-02f,
  1.35797590e-01f, 4.01473381e-02f, -6.92581981e-02f, -8.59010443e-02f, -6.98123202e-02f, -3.67741995e-02f, 5.50002034e-04f, -8.45150128e-02f, 8.51524994e-02f, -3.00264023e-02f,
  6.37370497e-02f, 4.40787338e-03f, 1.26676187e-01f, 3.08734551e-02f, -2.89041195e-02f, 3.49945761e-02f, 2.93249041e-02f, -3.94653156e-02f, -1.14798211e-01f, -9.16819870e-02f,
  1.11230507e-01f, 1.08015500e-02f, 4.80124764e-02f, 9.32434276e-02f, -9.55978632e-02f, 6.80523068e-02f, -2.47780234e-02f, -4.06638272e-02f, -3.60543467e-02f, 3.01759783e-02f,
  -4.56060469e-02f, -2.00707596e-02f, -7.79288784e-02f, 5.04795089e-02f, -4.53175455e-02f, 1.18025653e-01f, -2.14522351e-02f, -8.25655647e-03f, 6.79313317e-02f, 5.93460687e-02f,
  2.73041502e-02f, 8.54607671e-02f, 6.14160970e-02f, 1.20047331e-01f, 6.34313896e-02f, -4.48564105e-02f, 2.42770873e-02f, 7.00464621e-02f, 2.96205208e-02f, 4.27522063e-02f,
  1.33362666e-01f, 1.19306713e-01f, -1.26139279e-02f, 2.21780390e-02f, -3.22142914e-02f, 7.55097484e-03f, 2.90133487e-02f, 1.94356684e-02f, -5.11903651e-02f, -2.49546468e-02f,
  4.15411592e-01f, -4.56536561e-01f, -3.25821668e-01f, -1.06856814e-02f, 1.85876489e-01f, -7.79908150e-02f, -2.38835499e-01f, -1.61365233e-02f, -1.15254745e-01f, -1.54801443e-01f,
  3.98123153e-02f, 1.53501898e-01f, -3.08885008e-01f, 3.47645253e-01f, 4.78276402e-01f, -4.36366014e-02f, 2.04953969e-01f, 9.69925076e-02f, -2.60972474e-02f, -5.14500886e-02f,
  1.51193514e-01f, 3.72581780e-01f, 1.51247993e-01f, 1.71125814e-01f, 1.59188747e-01f, -1.14189155e-01f, 2.13643402e-01f, -1.24103539e-01f, 2.02082053e-01f, 3.14641684e-01f,
  4.16870452e-02f, 8.25103521e-02f, 2.01245286e-02f, 5.52205406e-02f, -2.24794336e-02f, 7.23368302e-03f, 6.11304864e-03f, 8.69671404e-02f, 1.30244680e-02f, -1.76816639e-02f,
  -7.74980336e-02f, 3.89849544e-02f, 9.03997719e-02f, 1.38100833e-01f, -7.64357522e-02f, -6.07726276e-02f, -8.53444636e-02f, 1.46190628e-01f, -1.31585538e-01f, 8.00551549e-02f,
  -9.65745747e-02f, -8.58911723e-02f, 6.52943105e-02f, -1.59873033e-03f, -9.45672691e-02f, -3.03355064e-02f, -9.05773714e-02f, -1.05199724e-01f, -9.32104588e-02f, 7.10246712e-02f,
  3.78241017e-02f, 4.39084359e-02f, 4.42194156e-02f, -3.17462869e-02f, -1.31938547e-01f, -5.10692932e-02f, 8.92765671e-02f, -4.34066989e-02f, -1.18927620e-01f, -1.13698445e-01f,
  -1.46571815e-01f, 3.19809467e-02f, 5.46907708e-02f, -2.72914339e-02f, 8.04967731e-02f, 1.24140657e-01f, -2.46797353e-02f, 6.50899578e-03f, -1.40413374e-01f, -2.72773765e-02f,
  1.51408091e-01f, -2.59412155e-02f, -1.88219711e-01f, 2.25189216e-02f, 2.13486073e-03f, -8.18277821e-02f, 1.07629679e-01f, 7.70225050e-03f, -1.49611030e-02f, -2.35707927e-02f,
  -4.67306599e-02f, -6.30511567e-02f, -1.25622556e-01f, 4.35590139e-03f, -1.35572612e-01f, -3.53135727e-03f, 4.53412645e-02f, -1.15089249e-02f, 7.02039227e-02f, 3.04423682e-02f,
  -2.03961860e-02f, -1.18536197e-01f, 5.83531819e-02f, 1.01191401e-01f, 2.81147510e-02f, -4.51648049e-02f, -5.74288853e-02f, 5.98322451e-02f, -3.28343883e-02f, -4.66688611e-02f,
  -2.03850456e-02f, -1.07038461e-01f, 2.79874038e-02f, -6.42268434e-02f, -1.94291007e-02f, -4.82114926e-02f, 6.37212992e-02f, 9.40592960e-03f, -1.79157835e-02f, -5.98859042e-02f,
  -9.42286015e-01f, 2.49090075e-01f, -9.52910781e-02f, -1.65654093e-01f, -3.01452279e-01f, -1.46030575e-01f, -6.83553815e-02f, -5.25284708e-02f, 1.76319666e-02f, 2.62413293e-01f,
  5.44468462e-02f, -1.47626489e-01f, 2.75676578e-01f, 5.88532761e-02f, -2.37217441e-01f, 4.24728453e-01f, -8.49312246e-02f, 5.25422692e-02f, 1.24050781e-01f, -2.91248322e-01f,
  -1.76946133e-01f, -1.14197038e-01f, -6.08790964e-02f, 6.57401467e-03f, -2.59642631e-01f, -1.72835067e-01f, -2.68538557e-02f, 5.94466273e-03f, -3.27159688e-02f, 2.62453146e-02f,
  -3.33837360e-01f, -2.50519305e-01f, -2.15486050e-01f, -1.62550434e-01f, -2.07610354e-01f, -1.08400151e-01f, -7.32296333e-02f, -6.61146566e-02f, -5.68965115e-02f, -8.61461014e-02f,
  -7.90544078e-02f, -2.79204138e-02f, 7.73385838e-02f, 1.18424557e-01f, -1.41444878e-04f, 3.86642888e-02f, 5.29186949e-02f, -2.66720019e-02f, -1.84077378e-02f, 2.25288011e-02f,
  5.86439818e-02f, 6.19233102e-02f, -4.84232157e-02f, 2.00874358e-02f, -9.12344921e-03f, 1.83674390e-03f, 9.19864699e-02f, -1.58429053e-02f, 2.54946649e-02f, -1.05667554e-01f,
  4.67595384e-02f, -7.10281059e-02f, -1.10588059e-01f, -4.23050672e-02f, -1.72241707e-03f, 9.08384025e-02f, 3.94790806e-02f, -2.85090227e-02f, -3.70884985e-02f, -5.62562570e-02f,
  9.53505654e-03f, -6.36383519e-02f, -1.08125834e-02f, -5.89851337e-03f, 1.24721210e-02f, 5.55282086e-03f, -3.57132629e-02f, 1.36843752e-02f, 1.00694373e-01f, -1.20152915e-02f,
  -3.77196446e-02f, 5.10520935e-02f, 9.53588635e-03f, 3.96432504e-02f, -4.21923697e-02f, 3.00803967e-03f, -1.07329164e-03f, 3.07900291e-02f, -6.80454746e-02f, -6.65019304e-02f,
  -5.44062793e-01f, -4.62829739e-01f, -2.02925816e-01f, -1.16608478e-01f, -1.08722612e-01f, 8.80370382e-03f, 8.53450596e-02f, -7.33761042e-02f, -9.28552896e-02f, -1.00701168e-01f,
  -1.10244833e-01f, 2.24015731e-02f, -2.69661248e-02f, -5.01535553e-03f, -2.65480322e-03f, 2.18208376e-02f, -1.41408786e-01f, -2.99231298e-02f, -2.08635464e-01f, -5.03855199e-02f,
  8.73937830e-02f, -3.77332233e-02f, 2.03540362e-02f, -3.01365904e-03f, 5.85124735e-03f, -7.23823532e-02f, -4.89493161e-02f, 3.97191606e-02f, -1.20599478e-01f, 6.69175386e-02f,
  -6.88472271e-01f, 1.87049255e-01f, -2.89060146e-01f, -1.59017190e-01f, -3.19304287e-01f, -3.57013732e-01f, 2.26859958e-03f, 5.55077419e-02f, 1.81800887e-01f, 3.66115659e-01f,
  1.09861329e-01f, 1.62881106e-01f, 3.25838357e-01f, 5.54927029e-02f, -3.27339321e-01f, 4.17487413e-01f, -2.11500958e-01f, 7.97680020e-02f, 5.61775938e-02f, -1.31714761e-01f,
  -1.65655822e-01f, -3.69116329e-02f, -1.76922649e-01f, -3.91401798e-02f, -4.17840660e-01f, -1.79675162e-01f, -1.90293804e-01f, -9.13012996e-02f, -1.71819061e-01f, -6.36427104e-02f,
  -3.97695482e-01f, -7.31810331e-02f, -9.71213579e-02f, -1.24564193e-01f, -2.26380810e-01f, -1.03888281e-01f, -1.00412913e-01f, -4.46798168e-02f, -2.69860867e-02f, -5.69867063e-03f,
  5.60369678e-02f, -3.68429385e-02f, 3.94824371e-02f, 1.94216907e-01f, -8.24528094e-03f, 5.08033764e-03f, -1.15667135e-01f, -3.59173864e-02f, 2.13809647e-02f, -7.13641569e-02f,
  -1.41857238e-02f, -6.56318367e-02f, -6.80123568e-02f, 1.45988325e-02f, -1.46247640e-01f, -5.14113493e-02f, 6.99832430e-03f, -5.57570048e-02f, -7.24553391e-02f, -1.53833181e-01f,
  -3.23402844e-02f, -8.37380737e-02f, -5.44858724e-03f, 5.63477129e-02f, 7.47731850e-02f, -1.38304280e-02f, -4.12214501e-03f, 6.91039069e-03f, -6.10559098e-02f, -7.56937638e-02f,
  -2.76437849e-02f, 2.78622359e-02f, -7.59291574e-02f, -8.85215625e-02f, 2.21391339e-02f, 1.62015840e-01f, 3.65774892e-02f, -8.30254704e-02f, 7.51297129e-03f, 2.13356074e-02f,
  9.27783094e-06f, -7.55636021e-02f, 4.67781797e-02f, 4.94509563e-02f, -4.91862036e-02f, -1.55268647e-02f, 2.39444617e-03f, -2.69495510e-03f, -5.74405976e-02f, -1.46097928e-01f,
  -5.11029005e-01f, -3.89836848e-01f, -5.92788421e-02f, -9.56071690e-02f, -3.62233818e-02f, -3.20773497e-02f, 5.48516624e-02f, -1.74458146e-01f, -1.75918907e-01f, -2.81952806e-02f,
  -9.91082117e-02f, 1.39501803e-02f, -7.86694065e-02f, 3.22707109e-02f, 1.37525409e-01f, 7.99930841e-02f, -2.21052039e-02f, 1.14055928e-02f, -1.49665892e-01f, -5.82573675e-02f,
  4.67086136e-02f, 1.77597310e-02f, 8.60357285e-02f, 7.86761288e-03f, 4.88182120e-02f, -3.67480256e-02f, -2.45360583e-02f, -1.25905983e-02f, -2.21706688e-01f, 2.79153232e-02f,
  -8.01975355e-02f, 4.42548633e-01f, 6.20939361e-04f, -4.53039035e-02f, -6.13684580e-02f, 4.29747045e-01f, 6.89014271e-02f, 2.09398419e-02f, -5.92623167e-02f, 3.96294326e-01f,
  1.46008268e-01f, 3.11641023e-02f, 4.35747169e-02f, 4.16910350e-01f, -1.92983061e-01f, 1.14483975e-01f, 2.66029656e-01f, 2.14902937e-01f, -1.17459565e-01f, 3.98504362e-02f,
  -1.04923174e-01f, 1.36477634e-01f, 5.31924479e-02f, -1.27102897e-01f, 1.26231715e-01f, -1.44648820e-01f, -1.76649213e-01f, -3.56009871e-01f, 1.81404218e-01f, -6.40709251e-02f,
  2.13012025e-01f, 1.75243877e-02f, 6.98040351e-02f, 8.57069045e-02f, 1.32403582e-01f, 6.82621896e-02f, 1.28768235e-01f, 1.89310554e-02f, -2.67387778e-01f, 7.69205540e-02f,
  -4.64977697e-02f, -7.25911418e-03f, -4.46827747e-02f, -1.17518470e-01f, -5.59114590e-02f, 4.08998951e-02f, -1.80514809e-03f, 1.37875944e-01f, 1.14486367e-01f, 1.68641061e-02f,
  -2.96926945e-02f, 1.18779339e-01f, -8.63118321e-02f, -5.57119101e-02f, -4.62995246e-02f, -3.86195555e-02f, 1.60566166e-01f, 6.13933355e-02f, 5.57491295e-02f, 8.07772484e-03f,
  -6.56993613e-02f, 9.79513898e-02f, 6.41278848e-02f, 1.31801039e-01f, 1.13346338e-01f, 2.47955672e-03f, -7.29545280e-02f, 3.80403996e-02f, -7.37943575e-02f, 5.36048710e-02f,
  4.40057144e-02f, -8.15409198e-02f, 1.03484482e-01f, 6.13136441e-02f, 6.92864656e-02f, 1.08789362e-01f, -3.65414806e-02f, 3.13330106e-02f, -3.38621661e-02f, -5.07888291e-03f,
  -1.15625136e-01f, 4.34166454e-02f, 8.42523053e-02f, 2.26161592e-02f, 3.05001661e-02f, -7.10244551e-02f, -1.64701324e-02f, 2.77298521e-02f, 1.12117961e-01f, -1.23811960e-01f,
  2.37164751e-01f, 1.68709066e-02f, 3.77230234e-02f, 9.12524760e-02f, -7.79360533e-02f, 1.73482541e-02f, 3.68198752e-02f, 6.45767823e-02f, -2.66268104e-02f, 1.95977604e-03f,
  2.73183044e-02f, -5.02416566e-02f, 3.65027301e-02f, -8.86371806e-02f, -1.08640328e-01f, -3.05454172e-02f, 1.55476118e-02f, -7.05844462e-02f, -6.11856803e-02f, -6.35812357e-02f,
  3.96263562e-02f, -6.30550683e-02f, -1.03774168e-01f, -2.59408988e-02f, 2.82571148e-02f, 2.06709057e-02f, 3.56574953e-02f, 1.05067424e-01f, 8.24032817e-03f, 7.98377991e-02f,
  -1.72506839e-01f, 7.97825828e-02f, -2.47781035e-02f, -2.25473240e-01f, 1.43532874e-03f, 2.27795318e-02f, -8.02481249e-02f, 2.19208166e-01f, 3.07560682e-01f, -5.09358123e-02f,
  -2.24013433e-01f, -9.81232747e-02f, 3.63506079e-02f, -4.35991019e-01f, -1.25760809e-01f, 6.30417094e-02f, -1.71818942e-01f, -1.40529066e-01f, 1.78911075e-01f, -5.17273620e-02f,
  -5.87868206e-02f, -3.43163401e-01f, -2.88052440e-01f, -4.19699140e-02f, -1.60531357e-01f, 1.87632307e-01f, -2.96018571e-01f, 9.49171707e-02f, -3.11781794e-01f, -3.98484766e-02f,
  -1.62892148e-01f, 4.32299823e-02f, -1.08106256e-01f, 3.81766707e-02f, 1.38534233e-02f, 4.88433354e-02f, 4.93298844e-02f, -1.15721397e-01f, 9.18817446e-02f, 4.91430610e-02f,
  -4.93456200e-02f, -1.41533807e-01f, -2.65244022e-02f, -7.04156607e-02f, -4.15069684e-02f, -1.41175315e-01f, -2.47446112e-02f, -5.91860227e-02f, -1.25991866e-01f, 5.25119528e-03f,
  -1.52316511e-01f, -9.60911810e-03f, 1.75709371e-02f, 4.59584109e-02f, -1.02361841e-02f, -2.81284992e-02f, 1.10153481e-01f, -1.48165748e-01f, 1.23484023e-02f, 1.30262142e-02f,
  1.08279817e-01f, 1.22515492e-01f, -8.13782588e-02f, -1.11435421e-01f, -4.39759530e-02f, 4.41497676e-02f, -2.49423720e-02f, 2.59544719e-02f, 7.60488436e-02f, -1.08055487e-01f,
  -1.07928813e-01f, -4.19293903e-02f, 2.33703945e-02f, -7.47009218e-02f, 5.36895581e-02f, -1.02975711e-01f, -1.10529125e-01f, -2.66433712e-02f, 2.18038037e-02f, 6.24412335e-02f,
  1.24293186e-01f, 2.37823110e-02f, -7.50496462e-02f, 6.70100898e-02f, -2.44347621e-02f, -1.89757650e-03f, 8.30540434e-02f, -1.82368726e-01f, 7.80239329e-02f, 2.83307899e-02f,
  1.84535950e-01f, 2.85444736e-01f, 8.39272067e-02f, -4.40025590e-02f, 1.75081551e-01f, -6.76903054e-02f, -1.62667371e-02f, 2.53287014e-02f, 1.44336417e-01f, -2.82217450e-02f,
  -4.20714505e-02f, 5.28957397e-02f, 6.37435690e-02f, -4.17066924e-02f, 1.08002372e-01f, 1.14855312e-01f, 6.50256593e-03f, 8.75339434e-02f, 1.32257774e-01f, 7.81373829e-02f,
  -9.85934585e-02f, 4.82344739e-02f, 8.03912729e-02f, -1.20564122e-02f, 4.20850627e-02f, -1.00351922e-01f, 9.36693177e-02f, -1.17556013e-01f, 5.12820818e-02f, 1.27558216e-01f,
  3.04492921e-01f, -6.73677400e-02f, -2.28510588e-01f, 1.74570277e-01f, 1.74754709e-01f, 4.09292877e-01f, 1.34150505e-01f, 1.67300507e-01f, 2.02585474e-01f, 1.71602517e-01f,
  3.88246924e-02f, -1.47985294e-01f, -2.59328127e-01f, 3.83676827e-01f, 2.67000973e-01f, -7.45596439e-02f, 4.49419886e-01f, 1.80588290e-01f, 4.19684984e-02f, 2.12487966e-01f,
  1.39784357e-02f, 3.49087059e-01f, -3.93224031e-01f, 1.20327629e-01f, 3.58507149e-02f, -1.15851693e-01f, -9.97546911e-02f, -2.81960368e-01f, -8.86155441e-02f, 4.28996235e-02f,
  2.57103965e-02f, -4.00249213e-02f, 5.53303165e-03f, -1.07038803e-01f, 1.16623184e-02f, 1.14025492e-02f, -6.12543523e-02f, -6.43089563e-02f, -1.44723013e-01f, -2.71570366e-02f,
  -4.36142692e-03f, -1.38637856e-01f, 1.74784139e-01f, 3.70937474e-02f, 1.28957510e-01f, 2.70513240e-02f, -1.10925257e-01f, -8.38002190e-02f, -4.25252505e-02f, -4.88761067e-02f,
  -1.88056991e-01f, -1.03546090e-01f, 1.83804259e-01f, 5.63064553e-02f, 2.32122727e-02f, 7.18263118e-03f, -3.95707153e-02f, -4.28306647e-02f, 4.16602306e-02f, 1.29657730e-01f,
  9.20625255e-02f, 5.30094802e-02f, -5.88380434e-02f, -1.12471193e-01f, -9.12302581e-04f, 5.55389524e-02f, 9.76455808e-02f, 4.80003431e-02f, 6.16569109e-02f, 6.65683001e-02f,
  2.36725155e-02f, 3.59656662e-02f, 1.40361324e-01f, -5.11378162e-02f, 6.30274042e-02f, 5.37921563e-02f, 3.48262675e-02f, 3.47148553e-02f, 5.01745977e-02f, -8.42540488e-02f,
  -7.92582110e-02f, 1.38870673e-02f, -1.39064804e-01f, -8.22551250e-02f, 6.50558323e-02f, -1.05110690e-01f, 1.52021706e-01f, 2.89443824e-02f, -1.21676244e-01f, 7.25850016e-02f,
  1.02225699e-01f, 1.97575048e-01f, -3.41763273e-02f, -1.12595214e-02f, -3.78756896e-02f, 1.65886417e-01f, 9.32222381e-02f, 2.12543011e-01f, -5.91067364e-03f, 9.20466036e-02f,
  2.14440629e-01f, -1.05541773e-01f, -2.49121133e-02f, -7.47420639e-02f, 1.57062914e-02f, 1.85100973e-01f, 6.40668580e-03f, 8.28347355e-02f, 1.00637011e-01f, -5.98953888e-02f,
  -6.25302121e-02f, -6.77878456e-03f, 1.36034265e-01f, 1.17037214e-01f, 1.88222051e-01f, -1.20007601e-02f, 3.42536457e-02f, -6.55690581e-03f, 3.56371179e-02f, 5.18720634e-02f,
  -3.82663846e-01f, -2.34671474e-01f, 6.65511712e-02f, 2.81908989e-01f, -1.14919946e-01f, -2.74175733e-01f, -1.25172094e-01f, 1.67564869e-01f, -1.20316014e-01f, -8.72920826e-02f,
  -1.87955126e-02f, -1.67306200e-01f, -1.26265734e-01f, -1.73343837e-01f, 4.22860086e-02f, -8.85652900e-02f, 1.30982682e-01f, -6.62588105e-02f, 5.22522219e-02f, 7.70595297e-02f,
  3.04707289e-01f, 9.26349312e-03f, 2.49710992e-01f, 2.06642359e-01f, -8.57631341e-02f, 3.42241377e-01f, 4.81174171e-01f, 1.76501691e-01f, 4.00415480e-01f, -4.10112329e-02f,
  -2.33150631e-01f, -8.96150693e-02f, 2.79816147e-02f, -1.66988984e-01f, 2.50016987e-01f, -4.67612706e-02f, 1.64500326e-02f, 7.12833460e-03f, 7.87249729e-02f, 1.34920686e-01f,
  -8.81569013e-02f, 9.79948938e-02f, 7.01128691e-02f, -4.46623191e-02f, -4.20520343e-02f, 3.62329893e-02f, -1.36455484e-02f, -2.85456367e-02f, -4.45156172e-02f, -2.21821982e-02f,
  1.61192473e-02f, -3.74742821e-02f, 8.64422601e-03f, 8.20829496e-02f, 5.63019924e-02f, 3.15617658e-02f, 9.52765569e-02f, 9.15303752e-02f, 5.48743876e-03f, 1.17479779e-01f,
  -9.93510336e-02f, 1.19245425e-01f, 8.60387012e-02f, -8.60726833e-02f, 6.54215813e-02f, -2.10534949e-02f, -2.57504378e-02f, -1.15196789e-02f, -8.12588632e-02f, -8.17522481e-02f,
  5.27502038e-02f, -7.28708226e-03f, -2.24558935e-02f, -4.65937424e-03f, -5.07934876e-02f, -8.49469155e-02f, 3.51104960e-02f, -4.57885824e-02f, 2.89583262e-02f, -1.93917584e-02f,
  -2.24984717e-02f, -5.87725528e-02f, 1.07680716e-01f, -3.42444070e-02f, -6.03411496e-02f, 1.48892492e-01f, -4.32252325e-02f, -1.50497258e-02f, 1.00404266e-02f, -3.41434330e-02f,
  -8.71515945e-02f, 2.29729220e-01f, 1.29760327e-02f, -1.46144614e-01f, 2.45814789e-02f, -1.26725331e-01f, -1.41513929e-01f, -4.51512448e-02f, -5.59500866e-02f, -2.79371478e-02f,
  3.39568295e-02f, 7.55423382e-02f, -2.55633774e-03f, -6.45767152e-02f, 1.27516046e-01f, 1.29427567e-01f, 9.43829417e-02f, -2.74676252e-02f, 1.04614161e-01f, 4.81137894e-02f,
  -6.46732189e-03f, -4.25915495e-02f, 7.41202682e-02f, -1.19313069e-01f, 7.09595485e-03f, 8.65678936e-02f, 3.81703326e-03f, 1.57930925e-02f, 5.88897541e-02f, -1.26114469e-02f,
  3.41580033e-01f, 3.24945182e-01f, 1.44576237e-01f, 3.49812865e-01f, 2.39091009e-01f, -2.80086875e-01f, 2.54407793e-01f, 3.24968070e-01f, 6.01191103e-01f, 8.89821385e-04f,
  9.58399754e-03f, 2.07748249e-01f, -1.12396263e-01f, 1.46148235e-01f, -4.81377751e-01f, -1.54972583e-01f, -1.47892192e-01f, -7.28768408e-02f, 1.66784301e-01f, 6.87169731e-02f,
  9.22427177e-02f, -1.69644490e-01f, -1.20942611e-02f, -9.60345939e-02f, 2.40203232e-01f, 2.02359483e-01f, -3.19969207e-01f, 7.74820969e-02f, -1.43981636e-01f, -5.67437485e-02f,
  -1.58429760e-02f, 3.99291277e-01f, 1.79675296e-01f, 1.32698612e-02f, -1.25194356e-01f, -4.82691601e-02f, -9.37327668e-02f, -2.10265573e-02f, 9.19721499e-02f, 3.81482095e-02f,
  2.45281383e-02f, -9.21379849e-02f, -6.43562805e-03f, 1.07741050e-01f, 2.11764663e-01f, 9.04695019e-02f, 1.61987189e-02f, 5.19625582e-02f, 1.59194663e-01f, 1.27148032e-01f,
  1.19119398e-02f, -1.88505575e-02f, -1.68897724e-03f, -2.27556117e-02f, 4.26755957e-02f, 8.40873718e-02f, -1.03249691e-01f, -1.17435507e-01f, -5.51232807e-02f, 1.21181915e-02f,
  1.81066692e-01f, -6.22979701e-02f, -3.12632509e-02f, -2.66545285e-02f, -3.34005840e-02f, 6.56565232e-03f, 3.29711586e-02f, -1.37617916e-01f, -7.99989402e-02f, -2.73073744e-02f,
  -1.06429262e-02f, 8.47109482e-02f, 9.53417197e-02f, 5.39358892e-02f, 7.21002519e-02f, 1.29115239e-01f, -3.48958708e-02f, -1.04801103e-01f, 4.76495217e-04f, -6.39628852e-04f,
  4.44843732e-02f, -9.54911634e-02f, 1.28620665e-03f, -4.54440676e-02f, -6.20307922e-02f, -3.74461114e-02f, 1.28786545e-02f, 7.89416432e-02f, 9.26602632e-02f, -1.36447502e-02f,
  -4.25029457e-01f, -3.16347152e-01f, 8.61673802e-02f, 1.55290335e-01f, -7.93881565e-02f, -8.77526253e-02f, -9.10908207e-02f, 1.86238997e-02f, -6.49669096e-02f, 7.52393231e-02f,
  -2.18386203e-02f, -5.37716933e-02f, -2.12914601e-01f, 3.64689552e-03f, -6.26661927e-02f, -3.50635201e-02f, -1.43931910e-01f, 2.60370150e-02f, -1.20637342e-01f, -5.02914153e-02f,
  -8.54775496e-03f, -7.39106834e-02f, -9.09335017e-02f, 1.09728314e-01f, 2.35085208e-02f, -6.09922409e-02f, 3.14351084e-04f, 4.55555245e-02f, -9.35515240e-02f, -6.03963546e-02f,
  -3.47846448e-01f, -2.78006017e-01f, 2.05529943e-01f, 2.63058305e-01f, 9.81718749e-02f, -9.69743952e-02f, 1.61159709e-01f, -3.48138034e-01f, -3.61586004e-01f, -2.48038858e-01f,
  1.03647308e-03f, 1.37727812e-01f, -4.11069617e-02f, -1.39692880e-03f, 4.73853111e-01f, -2.39957824e-01f, 1.63048618e-02f, 8.01333860e-02f, 9.19198431e-03f, 3.17636803e-02f,
  1.63295448e-01f, -1.08075872e-01f, 2.60845155e-01f, -2.58886106e-02f, 1.93313118e-02f, 2.05811128e-01f, 3.97717506e-01f, 4.39825088e-01f, 3.24222207e-01f, 2.91526556e-01f,
  -9.57729965e-02f, -2.54817456e-01f, -4.14256640e-02f, 4.11098190e-02f, -8.33562464e-02f, -3.34107280e-02f, 1.49217084e-01f, 3.81932020e-01f, 2.35189810e-01f, -3.21135037e-02f,
  1.07694797e-01f, 1.62531018e-01f, -1.61468610e-01f, 1.12574704e-01f, -7.11138025e-02f, 1.28153935e-02f, 5.69174662e-02f, -1.23101391e-01f, 1.04775861e-01f, -4.84927334e-02f,
  -2.18529515e-02f, -4.33211923e-02f, -5.77336922e-02f, 1.28579676e-01f, 1.55389979e-01f, -7.03865197e-03f, 2.31020376e-02f, 1.24063067e-01f, 3.70109342e-02f, 1.22549217e-02f,
  -1.52367279e-01f, -9.49118473e-03f, -1.10783383e-01f, 5.23084309e-03f, 2.47378238e-02f, 6.91143051e-02f, -1.10483885e-01f, -3.72262746e-02f, 1.07795142e-01f, 3.21789160e-02f,
  4.05955911e-02f, 2.96170097e-02f, -5.05172759e-02f, 1.01960324e-01f, -4.05451190e-03f, -2.17593759e-01f, 2.00646162e-01f, 6.57943711e-02f, -1.97359994e-02f, -9.61010009e-02f,
  3.61189097e-02f, 2.02675894e-01f, 9.04679894e-02f, -5.22195697e-02f, -1.62538454e-01f, -4.52821143e-02f, -1.61325801e-02f, 6.63183182e-02f, -1.19931512e-02f, 1.30378112e-01f,
  1.20249145e-01f, 7.85666630e-02f, 1.33242309e-02f, 1.35347053e-01f, -5.00041507e-02f, -5.59905581e-02f, 4.20872532e-02f, -2.28077155e-02f, 7.12452680e-02f, -6.83685392e-02f,
  1.14856459e-01f, 1.48020923e-01f, -8.94816592e-02f, 8.36628452e-02f, 1.59456819e-01f, -4.94541526e-02f, 1.46426424e-01f, 1.09038346e-01f, 5.56167439e-02f, 4.97873016e-02f,
  9.80860218e-02f, -2.38994267e-02f, -6.09983392e-02f, -7.19077289e-02f, -6.45391494e-02f, 5.03484383e-02f, -1.48534894e-01f, -4.48590666e-02f, 1.60190463e-01f, 2.04011083e-01f,
  2.87162334e-01f, -5.09900808e-01f, 3.30314279e-01f, -5.56826852e-02f, 3.84202421e-01f, 2.17940137e-02f, 6.53981119e-02f, 8.17832276e-02f, 2.41027072e-01f, -4.05243158e-01f,
  -1.53304219e-01f, -2.05741689e-01f, 1.92720130e-01f, -4.19237971e-01f, 5.44436932e-01f, 1.76012114e-01f, -1.38769820e-01f, -2.73233145e-01f, 1.39528394e-01f, -2.14959130e-01f,
  4.63739894e-02f, -3.97826552e-01f, 1.65287554e-01f, -4.20823187e-01f, -1.52519777e-01f, -1.65808082e-01f, -1.14016704e-01f, -5.89689948e-02f, -3.80949229e-01f, 3.02471276e-02f,
  -9.83788297e-02f, -1.10224776e-01f, -1.46488339e-01f, -8.75661448e-02f, 1.44391404e-02f, -5.67793772e-02f, 2.09026150e-02f, 4.83068936e-02f, -1.31454775e-02f, 1.67959016e-02f,
  -5.57636172e-02f, 5.49662039e-02f, -1.54447168e-01f, 6.63760444e-03f, -2.89583579e-02f, -2.69007534e-02f, 9.65835247e-03f, -3.87808233e-02f, 1.08109593e-01f, 1.77380219e-01f,
  4.80458001e-03f, 3.75299565e-02f, 5.70727512e-02f, -6.33552894e-02f, 1.45456433e-01f, -1.41093349e-02f, 9.21926349e-02f, 1.19396694e-01f, -2.92076636e-03f, 2.76423916e-02f,
  -6.86507449e-02f, -4.13175412e-02f, 6.71260431e-02f, 1.51324589e-02f, -1.12157553e-01f, 8.58972445e-02f, -2.96896845e-02f, -6.58513308e-02f, 7.52224252e-02f, 3.58103625e-02f,
  3.30374725e-02f, -4.40731049e-02f, 1.10167623e-01f, 8.45725983e-02f, -6.62260130e-02f, 6.80910274e-02f, 3.11967116e-02f, 5.39121255e-02f, 1.23447903e-01f, -2.53268331e-02f,
  -2.35971529e-02f, -2.92397346e-02f, 2.23769750e-02f, 7.39707947e-02f, -5.29127009e-02f, 2.26523820e-02f, -8.11559781e-02f, 1.87830567e-01f, 4.38293479e-02f, 8.21073633e-03f,
  -3.93099397e-01f, -5.32928586e-01f, -1.64741203e-01f, -4.88959625e-02f, -1.63252234e-01f, -6.30578026e-02f, -3.23967300e-02f, 6.94142357e-02f, -8.52658898e-02f, 7.98343346e-02f,
  5.13349324e-02f, -6.77292123e-02f, -8.95726979e-02f, 1.15655614e-02f, -1.20013580e-01f, -2.59738546e-02f, -1.59898162e-01f, -1.77618682e-01f, -4.18852791e-02f, -5.60591370e-02f,
  -9.28729996e-02f, -1.11056902e-01f, -2.72387899e-02f, -7.37130269e-02f, -3.79761085e-02f, -6.01668935e-03f, -4.18235734e-02f, 5.81817888e-02f, 4.98063071e-03f, -3.84809636e-02f,
  -4.26408695e-03f, 3.80270511e-01f, 4.76278096e-01f, -8.34749937e-02f, -6.97317421e-02f, 2.59497073e-02f, 5.88942505e-02f, 7.03984573e-02f, -1.43983096e-01f, -6.69811741e-02f,
  -8.15448463e-02f, 4.36781973e-01f, -1.11245215e-02f, -2.66223252e-02f, -2.50852078e-01f, -1.77084804e-01f, -1.80518284e-01f, 3.53018790e-02f, 7.71732852e-02f, 7.27027580e-02f,
  -6.88620284e-02f, -2.52083898e-01f, 1.00286163e-01f, -1.83044955e-01f, 1.66200489e-01f, 1.07586883e-01f, -3.04007947e-01f, 2.80831397e-01f, -4.17364575e-02f, 2.38393452e-02f,
  5.46218939e-02f, -1.53168783e-01f, 1.81210801e-01f, 1.62945334e-02f, -6.66284487e-02f, 1.63727682e-02f, 1.58386514e-01f, -2.48908978e-02f, -1.34737462e-01f, 4.74342816e-02f,
  4.21380028e-02f, -4.04707389e-03f, -3.46355326e-02f, 4.52134758e-02f, 8.72367695e-02f, -6.94406393e-04f, 2.96588484e-02f, 1.88130066e-01f, 1.06962800e-01f, 2.14720994e-01f,
  1.69030398e-01f, 1.81429774e-01f, 3.78520302e-02f, 1.66384429e-02f, 5.89606054e-02f, -2.98881754e-02f, 1.24245528e-02f, 1.49233103e-01f, 9.01432782e-02f, 1.90174673e-02f,
  -1.04483403e-02f, -1.01059631e-01f, 3.38117518e-02f, -1.51213575e-02f, -1.75857712e-02f, 5.10477759e-02f, 5.72041981e-02f, 8.79084691e-03f, -5.89540713e-02f, -4.48082313e-02f,
  -6.66599348e-02f, 1.29090548e-01f, -5.91118783e-02f, -8.13836753e-02f, -3.13403308e-02f, -2.86407899e-02f, 4.03448492e-02f, -7.64479581e-03f, -2.01117005e-02f, 2.66155787e-02f,
  -2.48943157e-02f, -6.63539302e-03f, -3.06613203e-02f, 1.68221463e-02f, -1.40297506e-03f, 7.23497244e-03f, -1.98714752e-02f, 2.87916251e-02f, -5.21949530e-02f, 4.14325036e-02f,
  -2.80134171e-01f, -4.40932661e-01f, -7.80450404e-02f, 6.12459704e-02f, -9.89960134e-02f, 1.97221879e-02f, -6.39202073e-03f, -9.17807780e-03f, -8.09042156e-02f, -3.98071855e-02f,
  -2.79892236e-02f, -7.74618834e-02f, 3.14170010e-02f, 4.33370881e-02f, -2.81930808e-03f, -2.97739394e-02f, -2.82633416e-02f, -4.27688137e-02f, -6.94512799e-02f, 3.75095732e-03f,
  8.65542796e-03f, 3.82734532e-03f, -4.58840001e-03f, -2.23094560e-02f, 3.41461338e-02f, 5.62309623e-02f, -4.00009155e-02f, 8.43781140e-03f, 3.61241326e-02f, -3.51528637e-03f,
  7.08188117e-02f, -7.57205933e-02f, -1.87522560e-01f, -2.92778194e-01f, 9.71670598e-02f, -3.51624072e-01f, -3.69850516e-01f, -1.52751550e-01f, -7.13810250e-02f, 2.44396538e-01f,
  -1.88681975e-01f, 2.44608939e-01f, -6.60923198e-02f, -3.86351168e-01f, -6.42598510e-01f, -1.75653532e-01f, -5.21434486e-01f, -1.43452093e-01f, -7.49307945e-02f, -1.97037399e-01f,
  -2.40414977e-01f, -2.90526599e-01f, -3.99515033e-01f, -3.09613924e-02f, -1.19080119e-01f, 1.25170842e-01f, 6.62064701e-02f, 1.85824051e-01f, -2.77046598e-02f, -4.18069810e-02f,
  -1.40177459e-01f, 1.36196032e-01f, 8.11211020e-02f, -2.96723973e-02f, -9.35808644e-02f, 1.84488557e-02f, 2.72025093e-02f, -8.23444948e-02f, 6.42004609e-02f, 4.98536415e-02f,
  1.74158849e-02f, 9.19779763e-02f, -9.67752859e-02f, 7.04249889e-02f, 7.58828297e-02f, 9.28622559e-02f, -3.67438607e-03f, 1.20606564e-01f, 8.57843310e-02f, -1.45123359e-02f,
  2.44824979e-02f, 5.44059724e-02f, 1.79651100e-02f, -2.12380122e-02f, -1.38809914e-02f, 1.79507714e-02f, 1.07540060e-02f, 5.21114469e-02f, 3.57494466e-02f, 9.32531357e-02f,
  -5.60301282e-02f, 1.30637109e-01f, 7.63471425e-02f, -2.40994580e-02f, 7.65047371e-02f, -8.79552886e-02f, 2.06988528e-02f, 5.50466478e-02f, 8.74019787e-02f, -3.74179669e-02f,
  1.43235631e-03f, -3.99419814e-02f, -6.55823871e-02f, -5.31708300e-02f, 6.12141937e-03f, -2.87472606e-02f, 2.68939435e-02f, 6.77232370e-02f, -1.59881711e-01f, -4.59156074e-02f,
  3.36759500e-02f, 1.01223579e-02f, 1.25338407e-02f, -6.02331273e-02f, -1.31849378e-01f, 9.66943502e-02f, 1.14726514e-01f, 5.33373319e-02f, -9.37651545e-02f, -3.52341495e-02f,
  -8.30801949e-02f, 4.30880152e-02f, -1.97018180e-02f, 3.69775109e-02f, 2.31289249e-02f, 1.12065831e-02f, -1.43888250e-01f, -2.57529080e-01f, 3.18442588e-03f, -5.85635751e-03f,
  -8.79587755e-02f, 1.48562044e-02f, 9.33270231e-02f, 4.13308963e-02f, -3.59932557e-02f, -9.29858908e-02f, 5.76886646e-02f, 1.31852135e-01f, 5.39765060e-02f, 6.12950064e-02f,
  1.34660468e-01f, 6.77339509e-02f, 1.34725804e-02f, -7.77841266e-03f, -1.48155969e-02f, -8.49677529e-03f, 1.03006899e-01f, 1.86587051e-02f, 8.55138805e-03f, 3.60223353e-02f,
  1.82852939e-01f, 1.21278524e-01f, -1.81253441e-02f, 2.57399753e-02f, -2.54975438e-01f, -5.34768403e-01f, -5.12709916e-01f, -7.94729441e-02f, 2.25744918e-02f, -7.09328353e-02f,
  -1.28916085e-01f, 1.39236614e-01f, 1.79170251e-01f, -1.46520406e-01f, 2.65929788e-01f, 2.60143548e-01f, -1.15078293e-01f, -1.91733301e-01f, -2.53203195e-02f, 2.79979371e-02f,
  1.41591564e-01f, 1.67854559e-02f, 1.06174305e-01f, -1.22175990e-02f, -2.33549654e-01f, 9.89196077e-03f, 1.14987344e-01f, -2.46389866e-01f, -8.24498460e-02f, -8.65828991e-02f,
  -1.76736325e-01f, 1.97311863e-01f, 1.52657842e-02f, 7.48067647e-02f, 5.14342524e-02f, -4.43312973e-02f, -1.74174547e-01f, 5.36376014e-02f, 6.38713688e-02f, 2.64812335e-02f,
  1.60440117e-01f, 3.87644097e-02f, 8.61310512e-02f, -4.80964547e-03f, -1.61548361e-01f, -3.05001251e-02f, 1.07385725e-01f, -1.17256790e-01f, 5.99191859e-02f, -3.87959145e-02f,
  1.26353696e-01f, 4.84028943e-02f, -4.94906632e-03f, 1.99859068e-01f, 1.52567729e-01f, 8.92342255e-03f, -3.29238176e-03f, -9.14997235e-02f, 3.56302448e-02f, 1.42582208e-01f,
  1.14829823e-01f, -1.17892943e-01f, -6.45926893e-02f, -1.70513779e-01f, 1.08474037e-02f, 7.15709897e-03f, 9.70975757e-02f, 7.53404200e-02f, 4.84231561e-02f, -2.71052811e-02f,
  -6.07651323e-02f, 6.63145306e-03f, -2.13870127e-02f, -8.84089917e-02f, 1.64777960e-03f, -4.76403767e-03f, -6.63930476e-02f, -5.44239320e-02f, 3.44140851e-03f, -2.28086440e-03f,
  -1.35125881e-02f, 5.54053150e-02f, 2.47281566e-02f, -1.52924165e-01f, -2.50704765e-01f, 3.32970656e-02f, 5.50149269e-02f, 4.99892086e-02f, -1.65324256e-01f, 1.37675004e-02f,
  8.84692594e-02f, 3.36132079e-01f, 6.61033019e-02f, 9.44114476e-02f, 5.61491288e-02f, 5.60360029e-02f, 2.28348076e-02f, 1.14142902e-01f, 1.34109750e-01f, -1.13153039e-03f,
  -6.09105006e-02f, -5.10457531e-02f, -2.22793091e-02f, -8.45801085e-02f, 3.86348292e-02f, 1.30075052e-01f, 3.09686884e-02f, 4.68358174e-02f, 7.85783380e-02f, -1.33969411e-02f,
  9.04537961e-02f, 1.03414871e-01f, 1.68432727e-01f, -2.78516449e-02f, 1.54615000e-01f, -1.71557777e-02f, 1.84882041e-02f, -1.52535951e-02f, 1.92445040e-01f, 9.67056826e-02f,
  3.33838165e-01f, 7.98485726e-02f, 1.57614365e-01f, -9.73717347e-02f, 3.71066928e-02f, 2.95758158e-01f, -2.03129929e-03f, -4.69046133e-03f, -1.46324873e-01f, 3.42192173e-01f,
  -1.21765457e-01f, 1.73425958e-01f, -2.81456083e-01f, -8.72473791e-02f, -2.24943876e-01f, -1.18685231e-01f, 5.23452647e-02f, 6.70803189e-02f, -2.32911289e-01f, 1.50697641e-02f,
  -2.46540174e-01f, -1.34269521e-01f, -2.25524962e-01f, -5.88953868e-02f, 1.56038478e-01f, 9.93924960e-02f, 9.77425724e-02f, -1.22086525e-01f, 2.41176233e-01f, -1.30625024e-01f,
  -3.26473229e-02f, -1.17370255e-01f, -3.13352980e-02f, 3.08039989e-02f, 1.11323915e-01f, 1.45530909e-01f, 1.03525884e-01f, -2.56758891e-02f, -6.77148029e-02f, -5.81626259e-02f,
  1.16466179e-01f, -2.07721636e-01f, 1.86512601e-02f, 1.36778727e-02f, 3.93686257e-02f, 3.38778086e-02f, -7.09091872e-02f, 2.00633228e-01f, 1.08817972e-01f, 1.69695728e-02f,
  5.82992360e-02f, 5.78235276e-02f, 7.53117874e-02f, 8.37414637e-02f, 2.47477856e-03f, -4.75144461e-02f, 1.17259428e-01f, 1.51296467e-01f, 1.15536414e-01f, 1.16919704e-01f,
  8.64044130e-02f, 2.06054270e-01f, 1.31381243e-01f, -5.16342325e-03f, -1.16910189e-02f, -4.75600548e-02f, 2.25044060e-02f, -2.25316342e-02f, -4.28455509e-02f, -8.24862272e-02f,
  -2.57618278e-02f, 2.77973013e-03f, -1.11574747e-01f, 8.32558647e-02f, 1.00390300e-01f, -7.28265345e-02f, -6.35703728e-02f, 3.56710963e-02f, 8.50529782e-03f, 1.02118991e-01f,
  -1.57450035e-01f, -4.86184247e-02f, -8.42771381e-02f, -2.18177121e-02f, -7.40614012e-02f, -8.56855139e-02f, 5.11368774e-02f, 1.08564146e-01f, -6.04194403e-02f, 4.33985628e-02f,
  8.31178203e-02f, 7.15333521e-02f, -1.58116937e-01f, -1.11736737e-01f, -6.32281005e-02f, 1.94065943e-01f, 5.59683964e-02f, 1.83569238e-01f, 2.78399494e-02f, 3.60399559e-02f,
  1.19745165e-01f, -1.04558863e-01f, 2.02185273e-01f, -1.72951873e-02f, -6.06095083e-02f, -5.63308503e-03f, 7.89120910e-04f, 3.25829014e-02f, 1.39395278e-02f, 6.21993206e-02f,
  1.50004491e-01f, -2.70100515e-02f, -2.43955906e-02f, 1.13663219e-01f, 2.10774653e-02f, 6.05559461e-02f, 9.20534208e-02f, 1.90725382e-02f, -2.99692415e-02f, 3.79865728e-02f,
  2.13297203e-01f, -3.62202853e-01f, -5.60137117e-03f, 4.41459805e-01f, 2.54403442e-01f, -1.34936824e-01f, -2.61142820e-01f, 1.67096108e-01f, 3.95530164e-01f, -5.11880040e-01f,
  -5.68142124e-02f, -3.73199850e-01f, -4.65131491e-01f, 6.49851784e-02f, 1.93282813e-02f, -3.34068388e-01f, 2.44955018e-01f, 2.22399198e-02f, 1.89728290e-01f, -9.90512893e-02f,
  2.47592732e-01f, 8.92785564e-02f, -4.39278781e-02f, 8.37467462e-02f, 5.95181473e-02f, 2.00739697e-01f, -1.51237905e-01f, -1.40065059e-01f, 7.85161555e-02f, -1.40731419e-02f,
  8.22375119e-02f, 9.57004800e-02f, 1.16608985e-01f, 1.31577641e-01f, 1.17870457e-02f, -4.79993038e-02f, -3.68893892e-02f, -1.69342339e-01f, 1.81639254e-01f, -4.45123389e-02f,
  -8.02869126e-02f, 9.71895605e-02f, 5.14250621e-02f, -1.20489642e-01f, 1.96639627e-01f, 1.05977185e-01f, 1.69952899e-01f, 6.06602728e-02f, -1.63754802e-02f, -1.99569911e-01f,
  -1.97126833e-03f, 9.41811651e-02f, 1.28009915e-01f, 3.20624746e-02f, 9.93125290e-02f, 1.17645338e-01f, -7.27315200e-04f, -1.29975438e-01f, 8.61569792e-02f, 1.62625127e-02f,
  -1.87029883e-01f, -2.56866775e-03f, -1.14527099e-01f, 1.17061421e-01f, 1.10666513e-01f, 1.14340752e-01f, -6.31906763e-02f, 3.05193048e-02f, 7.12979138e-02f, -8.53678584e-03f,
  1.51855886e-01f, -4.65583391e-02f, 1.24414697e-01f, 4.68587391e-02f, -5.14524579e-02f, 1.51993096e-01f, -3.59626636e-02f, -6.03274368e-02f, 6.61141872e-02f, -2.20034998e-02f,
  3.21508534e-02f, 1.03227109e-01f, -1.06361341e-02f, 5.28300516e-02f, 4.47219387e-02f, -5.69274127e-02f, 4.55282591e-02f, -9.24182311e-02f, 9.17014182e-02f, -1.17136657e-01f,
  -1.47505164e-01f, -4.04302180e-01f, -2.43410785e-02f, 1.02912813e-01f, -6.14914075e-02f, -1.57847442e-02f, -1.59516521e-02f, -1.69828869e-02f, -8.98878798e-02f, -1.40853068e-02f,
  5.59103265e-02f, 9.29909796e-02f, -1.54506769e-02f, 6.01089522e-02f, 1.15311071e-01f, -1.48729235e-01f, 1.35520687e-02f, 4.87300642e-02f, 6.12200424e-02f, 1.35093182e-03f,
  -3.08169182e-02f, -7.85379484e-02f, 6.58985302e-02f, 3.42973061e-02f, 9.74522159e-02f, -1.73974205e-02f, -3.67493555e-02f, -3.20878923e-02f, -6.62285322e-03f, 2.57901149e-03f,
  -1.70778349e-01f, 3.06804627e-01f, 1.07066363e-01f, 2.21009851e-01f, 1.61216408e-01f, 2.86654085e-01f, 2.96581805e-01f, 2.01877356e-01f, 5.15472174e-01f, 7.31623992e-02f,
  -2.15221897e-01f, 2.07966238e-01f, -1.07347608e-01f, -6.31868392e-02f, -1.93706285e-02f, 4.76304069e-02f, 2.78503776e-01f, 3.19611847e-01f, 3.54319990e-01f, 6.68976754e-02f,
  -1.20904565e-01f, -9.63690802e-02f, -3.48293483e-01f, -6.54508024e-02f, -2.05279991e-01f, -2.79562008e-02f, -2.80312300e-01f, 1.82712376e-02f, -1.11121565e-01f, 1.51827633e-01f,
  -7.95223340e-02f, 9.51016694e-02f, -1.52279049e-01f, 1.43385148e-02f, -7.39842206e-02f, -1.23290986e-01f, 2.40030582e-03f, 2.50959564e-02f, 3.65527836e-03f, 1.35849088e-01f,
  8.11324865e-02f, -1.08179159e-01f, 1.72950383e-02f, 8.16280916e-02f, 6.13455884e-02f, -8.79447628e-03f, -8.62557366e-02f, -8.90622362e-02f, -1.21085523e-02f, 4.00228612e-02f,
  -1.77755311e-01f, -5.59337474e-02f, -2.39987429e-02f, 1.04857199e-01f, -3.08127198e-02f, 1.51197627e-01f, 1.85509339e-01f, 4.88381740e-03f, -2.58481037e-02f, 1.76628500e-01f,
  4.32537161e-02f, 2.73652732e-01f, 4.69366368e-03f, -2.55203284e-02f, -6.85206801e-02f, -1.19087785e-01f, 2.26257239e-02f, -1.01110779e-01f, 1.72297638e-02f, 2.79598124e-02f,
  -3.56719531e-02f, 5.98880760e-02f, 6.07213899e-02f, 1.10259345e-02f, 1.14988968e-01f, 1.50569296e-02f, -1.34965489e-02f, 7.62501433e-02f, 7.76612237e-02f, -4.42390628e-02f,
  -2.32619606e-02f, -1.07322887e-01f, -9.36025754e-02f, -4.14089449e-02f, 2.77660731e-02f, 1.67514160e-02f, -7.95211568e-02f, -9.81595069e-02f, 4.76046046e-03f, 1.26253814e-02f,
  1.88299149e-01f, 4.37604696e-01f, -2.45581171e-03f, -4.62919325e-02f, 5.96766286e-02f, -1.13316938e-01f, 1.29630551e-01f, 8.99428427e-02f, 2.25537762e-01f, 7.36996308e-02f,
  8.17335546e-02f, -4.31577004e-02f, -7.59691000e-02f, -6.75868765e-02f, 2.70841438e-02f, 4.35207635e-02f, -3.85009907e-02f, 1.63287327e-01f, -1.51364496e-02f, 1.93731766e-02f,
  -1.56089485e-01f, 1.00980148e-01f, 6.37430847e-02f, 2.80640479e-02f, 3.92405950e-02f, 1.11960731e-02f, 7.57597461e-02f, 5.90496771e-02f, -1.19627759e-01f, 1.14896871e-01f,
  3.24871331e-01f, -8.12585801e-02f, 3.99174750e-01f, 5.23501813e-01f, -7.28057399e-02f, -4.27135289e-01f, -1.20548025e-01f, -5.44340238e-02f, 2.54445314e-01f, -2.58640617e-01f,
  -1.74190775e-01f, 3.75401080e-01f, -4.01832491e-01f, 2.74415940e-01f, 1.87541824e-02f, -3.37332666e-01f, 8.86542052e-02f, -3.99625897e-02f, 9.84915197e-02f, 4.67220619e-02f,
  1.83358684e-01f, -1.87193245e-01f, 1.78572848e-01f, -3.32976691e-02f, 2.03536585e-01f, 2.78238684e-01f, 2.06070747e-02f, -3.08473036e-02f, 2.59945363e-01f, 7.56993145e-02f,
  -1.16084628e-01f, 1.10690318e-01f, 6.93832934e-02f, -5.18863611e-02f, -7.81112537e-02f, -8.56069773e-02f, -1.75634306e-02f, -3.08516901e-02f, 9.13712829e-02f, 9.44187418e-02f,
  -8.65680873e-02f, -3.28031480e-02f, 6.08702451e-02f, 7.55376071e-02f, 9.15312544e-02f, 6.44337982e-02f, 7.16408640e-02f, 7.45715350e-02f, -2.19325535e-02f, 1.10407323e-01f,
  1.28311843e-01f, -1.60061102e-02f, 6.57044053e-02f, 8.80139172e-02f, -7.14199841e-02f, 7.34340549e-02f, 5.54353371e-02f, -2.07289215e-02f, 6.34553954e-02f, 1.56591415e-01f,
  5.79370111e-02f, -8.84072334e-02f, 6.25995174e-02f, 3.74173857e-02f, -8.26451853e-02f, 5.15324213e-02f, 1.04066290e-01f, -9.33389664e-02f, -3.94070446e-02f, -1.37195647e-01f,
  -3.37143429e-02f, -3.51888426e-02f, 5.35423271e-02f, 7.99422618e-03f, 5.74109377e-03f, -3.40283588e-02f, 1.31821176e-02f, 5.36821298e-02f, 1.78698134e-02f, 1.00858295e-02f,
  -3.42295319e-03f, -9.51631144e-02f, -5.58343455e-02f, -2.38144863e-02f, -6.30098656e-02f, -7.89150149e-02f, -3.20775285e-02f, 4.55262624e-02f, -7.59132728e-02f, -5.03325276e-02f,
  -3.37923497e-01f, 2.01206859e-02f, -1.64332576e-02f, 4.27682791e-03f, 4.09905203e-02f, -1.09101191e-01f, 4.80147414e-02f, 4.19909284e-02f, -7.13045290e-03f, -7.55465415e-04f,
  -1.20013937e-01f, 5.82427997e-03f, -2.14734357e-02f, 8.27935264e-02f, -3.92425619e-02f, -1.56322047e-02f, -1.77950449e-02f, 6.79161996e-02f, 2.90038716e-03f, 9.36436933e-03f,
  -4.74973209e-02f, -2.56644916e-02f, -3.86270247e-02f, 7.14329258e-02f, -9.81376320e-02f, 2.29551457e-03f, 7.99931178e-04f, 8.30693468e-02f, -3.16631235e-02f, 5.15271612e-02f,
  -3.50765347e-01f, 2.97845937e-02f, -1.23837925e-01f, -8.10848270e-03f, 1.30865633e-01f, -6.94603194e-03f, -4.50885266e-01f, 1.79448172e-01f, -3.10277194e-01f, -2.06163928e-01f,
  -3.59556153e-02f, -8.36178437e-02f, -2.09969774e-01f, 3.95118773e-01f, 4.82693881e-01f, 1.11816771e-01f, 3.36886823e-01f, 1.57494619e-01f, 2.65940607e-01f, 2.12974519e-01f,
  2.26880237e-01f, 4.41355616e-01f, 4.52950716e-01f, 5.39203465e-01f, 2.91902691e-01f, 1.47589847e-01f, 2.03944653e-01f, 9.46331620e-02f, 3.08052927e-01f, 1.85161650e-01f,
  2.94944160e-02f, -3.67261134e-02f, -1.55396432e-01f, -8.45683143e-02f, 2.52329577e-02f, -5.73737137e-02f, -1.00557227e-02f, 4.74845655e-02f, -1.71261251e-01f, -4.13528942e-02f,
  -5.75365946e-02f, 6.52205050e-02f, 6.81726038e-02f, 3.52972783e-02f, -6.08696491e-02f, -3.03212684e-02f, 9.46957991e-03f, -3.03340573e-02f, 2.63112201e-03f, 3.66983972e-02f,
  -1.23145885e-03f, 9.77115333e-02f, 2.68926974e-02f, 1.30779147e-02f, -4.71358886e-03f, -1.00408085e-01f, -1.74939875e-02f, -5.89350276e-02f, 6.99239373e-02f, -7.90789127e-02f,
  -4.99312095e-02f, -1.87358297e-02f, 1.28544509e-01f, 7.49919266e-02f, 3.04532088e-02f, -5.40862158e-02f, 1.62607990e-02f, 7.30372965e-02f, 2.65661906e-02f, -3.25961038e-02f,
  2.81074271e-02f, 4.33051065e-02f, -5.62652610e-02f, -9.15235281e-02f, 3.63434888e-02f, 1.74774043e-02f, 1.27533093e-01f, 6.95435256e-02f, 9.65669453e-02f, 1.02551408e-01f,
  -1.91164750e-03f, 2.32820846e-02f, -1.28779352e-01f, 4.72789630e-03f, -4.76628952e-02f, -1.06095374e-01f, 6.73423037e-02f, -6.44865781e-02f, 5.88775566e-03f, 4.36508320e-02f,
  -1.17456708e-02f, 4.41553853e-02f, -4.78805937e-02f, -6.37792647e-02f, 2.12232228e-02f, 1.32653028e-01f, 4.13463674e-02f, 6.34579062e-02f, -2.46371496e-02f, -6.20522499e-02f,
  2.99295057e-02f, -9.03586596e-02f, -8.65717977e-02f, 9.60903913e-02f, 1.80288196e-01f, -1.98390171e-01f, -8.68242383e-02f, -1.41548321e-01f, -3.25147323e-02f, 1.57775611e-01f,
  -3.29969823e-02f, 4.50618118e-02f, 5.73917814e-02f, 1.37368843e-01f, 8.99886806e-03f, -8.56875777e-02f, 3.59817967e-02f, -1.28466124e-02f, 1.45104915e-01f, 5.68111427e-02f,
  -9.87019539e-02f, -3.39794815e-01f, 3.07505161e-01f, 2.55629957e-01f, -8.66913423e-02f, -3.00783843e-01f, -6.53402284e-02f, -4.04971868e-01f, -1.42958373e-01f, -3.41175199e-01f,
  -1.62397608e-01f, 2.53090680e-01f, -3.47792625e-01f, 2.10415512e-01f, 4.12724346e-01f, -1.18289225e-01f, -7.56857917e-02f, 9.50686540e-03f, 8.83867741e-02f, -1.71988904e-01f,
  5.35286367e-02f, -3.48105021e-02f, 2.44318396e-01f, -3.07289567e-02f, -6.64766356e-02f, 1.03558995e-01f, 3.11835051e-01f, 1.24191023e-01f, 2.40307346e-01f, 3.05677921e-01f,
  -1.87494159e-01f, -7.65079036e-02f, -3.02550010e-02f, -4.57584718e-03f, -1.59117699e-01f, -6.07750285e-03f, 1.32408395e-01f, 1.26777261e-01f, 5.30894510e-02f, -5.45469485e-02f,
  -6.01617806e-02f, -1.19545939e-03f, 3.35128121e-02f, 5.64801395e-02f, -4.68464829e-02f, -5.48206717e-02f, -3.30687463e-02f, -5.84769323e-02f, -1.22933969e-01f, 7.78603405e-02f,
  -1.59726501e-01f, -5.10918498e-02f, -6.35598823e-02f, 1.20563984e-01f, -1.37888221e-02f, -1.43608704e-01f, 1.82056770e-01f, 1.60683207e-02f, 2.22139340e-02f, 1.23197123e-01f,
  2.47499533e-03f, 1.00183442e-01f, -3.84645164e-02f, 7.44165704e-02f, -1.30890995e-01f, 2.75873709e-02f, 1.99140459e-02f, 8.98465980e-03f, -1.37951775e-02f, -1.18476242e-01f,
  -1.46371303e-02f, -6.73494712e-02f, -5.15137948e-02f, -1.13823578e-01f, -1.25167131e-01f, -5.36034405e-02f, -2.05353256e-02f, -2.88179871e-02f, -6.51736781e-02f, 1.16009703e-02f,
  7.22723156e-02f, -1.98336914e-02f, -1.12710573e-01f, -2.96364073e-02f, 2.47052428e-03f, 9.54915595e-04f, -2.43315585e-02f, -3.25742066e-02f, -8.17903057e-02f, 5.72657883e-02f,
  -2.60440737e-01f, 3.75992358e-02f, 2.53821369e-02f, -6.85276762e-02f, 7.48782903e-02f, -1.52398020e-01f, 8.56503546e-02f, -4.25230339e-02f, -1.28028557e-01f, -7.25998431e-02f,
  -8.98757949e-02f, -1.10573910e-01f, -3.84592600e-02f, 1.17156282e-02f, 4.60035205e-02f, -1.22298725e-01f, 3.53876986e-02f, 5.29824235e-02f, -2.82342695e-02f, 1.73559114e-02f,
  -7.54104480e-02f, -1.45779746e-02f, 9.50720720e-03f, -2.24032979e-02f, -4.17781100e-02f, -1.14759067e-02f, -3.94685147e-03f, 6.33778935e-03f, 7.92110935e-02f, 7.94727206e-02f,
  -5.85961044e-01f, 2.82660723e-02f, 9.36889127e-02f, -4.55512404e-01f, 3.72074425e-01f, 5.19854665e-01f, -1.29525408e-01f, 2.71667033e-01f, -7.95139298e-02f, 1.14629097e-01f,
  1.14691593e-02f, -1.26262128e-01f, -6.17899299e-02f, -1.54287398e-01f, -1.10982276e-01f, -1.82670921e-01f, -1.64828777e-01f, -1.72716141e-01f, -2.97429767e-02f, -6.09612465e-02f,
  -1.18304186e-01f, -8.40149447e-02f, -1.53327286e-01f, 3.40662509e-01f, -4.61719409e-02f, -3.39755081e-02f, -5.55712357e-03f, 1.95215285e-01f, 7.13233054e-02f, 1.40010938e-01f,
  -4.67296317e-02f, -1.97394136e-02f, -1.08297616e-02f, 9.09322053e-02f, 1.08604126e-01f, 8.89142081e-02f, -2.11842917e-02f, 3.74875814e-02f, -1.05865978e-01f, 4.41150665e-02f,
  4.81658019e-02f, 7.69871622e-02f, -2.49166507e-02f, 8.72709155e-02f, 7.04078972e-02f, 6.51603192e-02f, 2.15986688e-02f, 1.90824475e-02f, 1.34222731e-01f, 6.64052069e-02f,
  -1.08127408e-01f, 1.21041117e-02f, 9.23863128e-02f, -1.00112155e-01f, 3.38576660e-02f, 2.25363895e-02f, -2.92133316e-02f, 4.63552624e-02f, -2.19864324e-02f, 4.11829427e-02f,
  3.09820529e-02f, 7.09143057e-02f, 5.45068681e-02f, -3.45028937e-02f, 1.43732701e-03f, 2.30800249e-02f, 3.15519460e-02f, 2.88250055e-02f, 4.11786251e-02f, 2.00634245e-02f,
  -7.96761140e-02f, 2.59374641e-03f, -7.49880495e-03f, 6.09303676e-02f, -5.01050148e-03f, 2.96827834e-02f, 4.64732610e-02f, -4.66928296e-02f, -2.14395840e-02f, 2.51193773e-02f,
  -9.97475684e-02f, -9.47704762e-02f, -8.06158781e-02f, -4.87901606e-02f, -3.18372138e-02f, -9.87038668e-03f, 1.08163781e-01f, 9.85715166e-02f, -6.20347038e-02f, -1.63747892e-02f,
  9.21208188e-02f, 1.31377995e-01f, 1.22667989e-02f, -5.99101223e-02f, 2.20971331e-02f, 1.49109036e-01f, -2.10367180e-02f, 5.82802519e-02f, 8.88898671e-02f, 7.05937669e-02f,
  1.39391333e-01f, -4.81645390e-02f, 4.64139655e-02f, -2.36225384e-03f, -1.54756289e-02f, 8.69841874e-03f, -9.56163630e-02f, 4.26193606e-03f, 8.81635845e-02f, 1.19901963e-01f,
  1.74828954e-02f, -4.39972170e-02f, -1.44685969e-01f, 5.68337478e-02f, -3.67008373e-02f, -1.39994277e-02f, -2.41194014e-02f, 8.11393000e-03f, -9.73217338e-02f, 6.37241155e-02f,
  4.08201456e-01f, 1.81365758e-01f, 2.66999185e-01f, 8.95842239e-02f, -2.65032411e-01f, -3.58252108e-01f, -1.91518366e-01f, -1.30803242e-01f, -2.03497574e-01f, 1.82182842e-03f,
  -2.60588557e-01f, 2.47975469e-01f, 7.95289502e-02f, 1.30966008e-01f, 8.56946781e-03f, 7.60847107e-02f, -2.31251791e-02f, 3.96120995e-02f, 1.21916436e-01f, 2.18315840e-01f,
  1.02585480e-01f, -1.23895831e-01f, 2.70775616e-01f, 1.85975414e-02f, 2.88321614e-01f, 2.47263104e-01f, 1.66735888e-01f, 1.33526608e-01f, 9.82386172e-02f, -1.09962784e-01f,
  -4.58345711e-02f, 6.22458383e-02f, 1.36070117e-01f, -2.12933701e-02f, 2.50645336e-02f, 5.15440516e-02f, 1.30191267e-01f, 4.73006703e-02f, -1.62586179e-02f, -5.80254495e-02f,
  -1.47638302e-02f, -4.86962572e-02f, -5.14691100e-02f, -6.42750561e-02f, 7.76376054e-02f, -1.45674879e-02f, -6.94065019e-02f, 6.26269877e-02f, -1.14560030e-01f, 2.32269287e-01f,
  7.68392533e-02f, 2.85123363e-02f, 8.02656114e-02f, 4.24918756e-02f, -8.79784375e-02f, -1.37827605e-01f, 1.61614567e-02f, 1.18179008e-01f, -5.69902919e-02f, 2.91004423e-02f,
  1.38211250e-01f, -8.82267356e-02f, -7.48231858e-02f, -8.93262997e-02f, -8.06619152e-02f, -2.92117801e-02f, -9.76744387e-03f, -1.50459623e-02f, -7.18889609e-02f, -5.82094640e-02f,
  -1.33934006e-01f, 2.80234031e-02f, -1.08790897e-01f, -1.67673290e-01f, 5.79326004e-02f, 1.52969721e-03f, -1.13986153e-02f, 5.23082726e-02f, -1.99553706e-02f, -4.04152013e-02f,
  -4.35498767e-02f, -8.78068581e-02f, -1.57289863e-01f, -4.16912362e-02f, -6.96615800e-02f, -3.26871164e-02f, 7.11881891e-02f, 8.62732679e-02f, -3.02096270e-02f, -3.60321961e-02f,
  -1.69083700e-02f, 2.71289703e-02f, -5.20708710e-02f, -1.95210293e-01f, -8.91712960e-03f, 5.20699844e-02f, 3.21621634e-03f, -4.67435904e-02f, 5.21405488e-02f, -1.14777662e-01f,
  -2.95916386e-02f, -3.18007693e-02f, -1.48246773e-02f, 1.51586607e-02f, -1.04894176e-01f, -4.17545959e-02f, -2.25476120e-02f, -5.50361611e-02f, -6.65387213e-02f, 7.34849200e-02f,
  1.92845501e-02f, -8.18850771e-02f, 3.41967456e-02f, -1.81135356e-01f, -4.65332046e-02f, -9.94944051e-02f, 1.05783314e-01f, -3.30231972e-02f, 3.66891213e-02f, -2.34697293e-02f,
  -7.72543773e-02f, 2.95616299e-01f, 1.10928774e-01f, 1.10301696e-01f, -1.69836119e-01f, -3.32705408e-01f, -3.58479142e-01f, 4.25602458e-02f, -9.87501070e-02f, -2.56540716e-01f,
  -1.41949490e-01f, -5.21562956e-02f, 1.70878410e-01f, -1.59049049e-01f, 8.71288702e-02f, 1.88830838e-01f, 1.26995638e-01f, -1.27073914e-01f, 2.36985058e-01f, 1.14908263e-01f,
  1.54760584e-01f, -2.08688024e-02f, 3.71623963e-01f, 2.55228374e-02f, -6.73478178e-04f, 1.14365540e-01f, 7.40499645e-02f, 1.07389510e-01f, -1.41858965e-01f, -3.70303802e-02f,
  1.63170099e-02f, 1.50258824e-01f, 7.85023794e-02f, -2.18108110e-02f, 1.31063342e-01f, -1.97187915e-01f, -1.64037406e-01f, -4.44007851e-02f, -5.99899031e-02f, -3.55480835e-02f,
  -5.28143048e-02f, -8.73642787e-02f, 2.85847113e-02f, -1.54721439e-01f, -1.73497304e-01f, -7.41316229e-02f, 1.64773926e-01f, 3.59467813e-03f, 6.92300871e-02f, 3.77361886e-02f,
  8.29392225e-02f, 1.04545534e-01f, 7.92375058e-02f, 1.81005169e-02f, 1.04212351e-01f, -3.18894424e-02f, -7.19825923e-02f, 6.30856156e-02f, 4.71486226e-02f, -9.12588164e-02f,
  5.05830273e-02f, -1.57044232e-02f, -8.88432786e-02f, -8.61838534e-02f, 4.70558088e-03f, -4.83364165e-02f, -1.66086227e-01f, -6.93176128e-03f, 5.69206802e-03f, 6.63334727e-02f,
  1.86741985e-02f, 5.71267400e-03f, 5.58577701e-02f, -1.35282636e-01f, -4.35742810e-02f, -8.72844458e-03f, -3.50552313e-02f, -7.15039819e-02f, 7.26939086e-03f, -7.31518678e-03f,
  -3.74922901e-02f, -1.27328232e-01f, 1.42401278e-01f, 6.35621399e-02f, -8.69025439e-02f, 4.54924181e-02f, -8.66730139e-02f, -2.58786343e-02f, 1.69765592e-01f, 3.08101531e-02f,
  1.22157298e-01f, 3.11045498e-01f, 1.16903670e-01f, -5.73002622e-02f, 1.23624325e-01f, -7.35416543e-03f, 1.87180750e-02f, -6.22791760e-02f, 4.60479334e-02f, -8.09790939e-02f,
  -5.06933965e-02f, -7.73821622e-02f, 9.90217030e-02f, -5.67380637e-02f, 3.31110917e-02f, 1.84797961e-02f, 2.17532665e-02f, 4.02242132e-02f, 1.57885462e-01f, 3.43632661e-02f,
  -6.68605464e-03f, -1.44317579e-02f, 6.78813308e-02f, -4.21354510e-02f, -6.61370680e-02f, 9.20935795e-02f, -4.25157994e-02f, 2.72295270e-02f, 3.78572731e-04f, 3.40146646e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.59285617e-01f, 1.30503356e-01f, 2.60734081e-01f, 3.65317762e-01f, 2.58525848e-01f, 2.40074262e-01f, 2.41997123e-01f, 5.04576504e-01f, 3.46105337e-01f, 3.71242523e-01f,
  1.81704894e-01f, 4.58078623e-01f, 3.34744841e-01f, 3.69231254e-01f, 4.15012121e-01f, 4.29537922e-01f, 2.62780011e-01f, 2.31823474e-01f, 1.01266138e-01f, -4.24119132e-03f,
  4.53966200e-01f, 2.38645226e-01f, 2.33097047e-01f, 3.99297208e-01f, 2.47482851e-01f, 1.03458039e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -3.11916023e-01f, 7.02570602e-02f, -1.66027173e-01f, 8.42111709e-04f, 1.61384284e-01f, -1.22347683e-01f, 1.41273096e-01f, -5.54390065e-02f, -1.06041834e-01f, 2.71791480e-02f,
  3.93552259e-02f, 4.97057810e-02f, 6.74867108e-02f, 1.58684462e-01f, 7.62893632e-02f, 4.71012518e-02f, -1.05222955e-01f, -3.73051852e-01f, -1.48106351e-01f, -2.58191526e-02f,
  -8.00596699e-02f, 3.55800986e-03f, 4.47035879e-02f, -2.38193393e-01f, -5.03578186e-02f, -2.87694097e-01f, -1.75366044e-01f, -2.96752125e-01f, -6.34619072e-02f, 6.99753640e-03f,
  -1.71798393e-01f, 2.44323313e-02f, -3.34183350e-02f, -1.87932670e-01f, -1.11834608e-01f, 2.26063669e-01f, 4.85659838e-02f, 8.32073689e-02f, -1.44501269e-01f, -5.60898036e-02f,
  -2.90427506e-01f, -2.02044114e-01f, 3.44417281e-02f, 2.99302414e-02f, 1.21642567e-01f, 6.89700618e-02f, -8.20594206e-02f, -9.59391668e-02f, -2.05873832e-01f, -2.23991759e-02f,
  9.14058387e-02f, -3.53799492e-01f, 1.74743399e-01f, -3.53590697e-01f, 2.71603733e-01f, -3.28968316e-01f, 2.66198277e-01f, -3.57731789e-01f, -3.71030569e-01f, -3.95562768e-01f,
  3.93879563e-01f, -8.82515237e-02f, -2.88705498e-01f, 3.76382589e-01f, -2.85383463e-01f, -1.03411861e-01f, -2.25023434e-01f, 5.44360839e-03f, 1.95317224e-01f, 3.47178131e-01f,
  -1.02122933e-01f, -3.58068913e-01f, 2.81535894e-01f, 3.00885290e-01f, 2.74239868e-01f, -1.29628822e-01f, -1.05024159e-01f, -2.44942665e-01f, 1.86430544e-01f, 4.17101324e-01f,
  1.22207336e-01f, -3.53485435e-01f, -4.14479584e-01f, 3.98687989e-01f, -3.11174959e-01f, 7.74598345e-02f, -8.70504379e-02f, -3.80632281e-01f, 3.22331823e-02f, -3.01537156e-01f,
  -2.35123143e-01f, 1.17842123e-01f, 2.97681689e-01f, 3.58017981e-01f, -2.22067058e-01f, -1.71232834e-01f, -2.01541230e-01f, 3.31971854e-01f, 1.47392288e-01f, 2.61978924e-01f,
  7.55309463e-02f, -3.15870225e-01f, -7.20852315e-02f, -1.58948258e-01f, 5.29217482e-01f, -2.62271643e-01f, -3.04698974e-01f, 5.63780427e-01f, 4.92389739e-01f, 4.53270435e-01f,
  -5.79416394e-01f, -9.74626020e-02f, 9.14314315e-02f, -2.14657828e-01f, -1.67962134e-01f, -5.10863662e-01f, -2.71042496e-01f, -3.14597577e-01f, -4.03973579e-01f, -4.59086373e-02f,
  -1.57469898e-01f, -1.45732209e-01f, -1.57897189e-01f, -1.45222843e-01f, 3.22564617e-02f, -4.73940343e-01f, -9.30604264e-02f, 3.45020816e-02f, -6.98167160e-02f, 9.49018076e-03f,
  1.99660569e-01f, -1.33066505e-01f, -6.34874329e-02f, -4.52329576e-01f, 2.19492689e-01f, -1.45735309e-01f, 1.95990384e-01f, 1.24185316e-01f, 1.52320802e-01f, -4.29906370e-03f,
  -1.54628009e-01f, -4.87996899e-02f, -1.12449273e-01f, 2.80639250e-03f, -2.13651001e-01f, 2.43749972e-02f, 1.50512541e-02f, -2.54117757e-01f, 1.12358712e-01f, -9.32220463e-03f,
  1.68019354e-01f, 1.35558024e-01f, 1.44252613e-01f, -4.56511192e-02f, 1.36184916e-01f, 1.53998986e-01f, 3.39294299e-02f, 1.01393916e-01f, -4.77992813e-04f, 3.71505804e-02f,
  5.07103354e-02f, -3.13577116e-01f, 1.31957784e-01f, 2.85843369e-02f, 1.62785530e-01f, 1.54375717e-01f, 6.74230307e-02f, -5.72754331e-02f, -2.45901302e-01f, -3.02565485e-01f,
  2.27088016e-02f, -9.56712849e-03f, 2.19534695e-01f, 4.33682203e-02f, 4.61857207e-02f, 3.20079066e-02f, 3.37398574e-02f, -5.54689988e-02f, 4.39534429e-03f, 2.44820744e-01f,
  3.31598669e-01f, 9.18297470e-03f, 7.20514208e-02f, 3.31598848e-01f, 4.94783968e-02f, 7.76667222e-02f, 3.43972385e-01f, 4.41879988e-01f, 1.09513462e-01f, -4.83954139e-02f,
  -2.93253958e-01f, 1.40135795e-01f, 4.68522787e-01f, -2.05639645e-01f, 1.96448304e-02f, 8.74791741e-02f, 4.76329625e-01f, -3.86997998e-01f, 2.90540546e-01f, -1.56243175e-01f,
  2.60283381e-01f, -2.61726767e-01f, 4.13140565e-01f, 4.36181337e-01f, -3.84778440e-01f, 1.82511687e-01f, 3.58868539e-01f, 2.96269506e-01f, 8.40582177e-02f, -2.04228804e-01f,
  -2.79706389e-01f, 1.89479858e-01f, -3.27393144e-01f, 2.45488673e-01f, 3.81895214e-01f, 2.50414789e-01f, 3.30980003e-01f, -1.71394929e-01f, -2.19996214e-01f, 2.38281041e-01f,
  2.28118360e-01f, -3.06734413e-01f, -2.32167482e-01f, 4.19614315e-01f, -3.79725873e-01f, 2.81368017e-01f, 1.76043957e-01f, 3.09571654e-01f, 3.64487171e-01f, 3.80095184e-01f,
  -2.26842716e-01f, 6.27098322e-01f, -4.62987542e-01f, 1.38302058e-01f, 3.33373934e-01f, -5.81772149e-01f, -5.66211760e-01f, 3.41757268e-01f, -4.82440442e-01f, 3.81414711e-01f,
  -4.99214649e-01f, -3.37536335e-01f, -6.04271770e-01f, -3.31884831e-01f, -1.91660210e-01f, -1.35894254e-01f, -1.18477568e-01f, 1.14003718e-01f, -4.02587473e-01f, -4.89608236e-02f,
  -7.45392025e-01f, 7.87442178e-02f, -6.97981775e-01f, 8.46316442e-02f, 2.26836562e-01f, -2.44556800e-01f, 9.97574031e-02f, -9.76712555e-02f, -1.73618361e-01f, -2.10690871e-01f,
  -1.42398383e-02f, 1.46183833e-01f, 1.05885990e-01f, -6.10923283e-02f, -2.58315921e-01f, 1.44258276e-01f, -1.56703427e-01f, -2.99705207e-01f, -1.63446611e-03f, -1.34885043e-01f,
  -2.11156067e-02f, -1.45812333e-01f, 3.49643305e-02f, 1.94176823e-01f, -1.16509674e-02f, -8.78349021e-02f, -2.20337480e-01f, 1.00800946e-01f, -1.32429928e-01f, -7.22168908e-02f,
  -1.03240661e-01f, -1.18176423e-01f, -1.53791979e-01f, -3.97021603e-03f, 6.02454282e-02f, -7.41297156e-02f, -3.18353958e-02f, -2.26722777e-01f, 1.52208179e-01f, 4.47728597e-02f,
  -1.95800245e-01f, 1.81877464e-02f, -2.39032403e-01f, -5.92767447e-02f, 1.18940815e-01f, -2.28326619e-02f, 6.51200861e-02f, 7.53816497e-03f, 2.66803429e-02f, -1.38150975e-01f,
  -3.44251335e-01f, 9.60062519e-02f, 1.49775341e-01f, 3.21154147e-02f, -1.26073901e-02f, 7.56999701e-02f, -2.63543099e-01f, -3.09316907e-02f, -1.05332360e-01f, 2.61682034e-01f,
  2.62492865e-01f, -4.21700552e-02f, 6.74968734e-02f, -1.26746982e-01f, 8.94324481e-02f, 7.40783894e-03f, -3.79439257e-02f, -1.79948434e-01f, -1.09082030e-03f, -1.30869104e-02f,
  1.75380215e-01f, -1.69593677e-01f, 4.00247961e-01f, -8.03598762e-02f, 3.39266732e-02f, -2.16357931e-01f, 1.42591462e-01f, 1.02255546e-01f, 7.54530504e-02f, -1.30430117e-01f,
  3.21922749e-01f, -2.84212142e-01f, 2.67228067e-01f, 2.54753411e-01f, 1.02265500e-01f, 1.10077508e-01f, -2.03908086e-01f, -1.02662258e-01f, -1.72557727e-01f, 1.78744942e-01f,
  2.30994388e-01f, 1.05906673e-01f, 1.22255616e-01f, 6.30848929e-02f, -1.08560119e-02f, 2.88087219e-01f, 2.38439590e-01f, 2.04140753e-01f, 1.63071491e-02f, 1.55205401e-02f,
  -2.19898686e-01f, 1.18765324e-01f, 1.69574142e-01f, -1.97911426e-01f, 2.67856121e-01f, 1.93345636e-01f, 5.86526543e-02f, 2.10781068e-01f, 1.07050970e-01f, 7.74851367e-02f,
  -3.21276277e-01f, 2.84135371e-01f, 4.24420536e-01f, -2.31691718e-01f, -2.05063447e-01f, -2.41946921e-01f, -2.63203949e-01f, 1.65160224e-01f, 7.25022182e-02f, -3.06720227e-01f,
  3.63990575e-01f, -5.44195354e-01f, -3.12610805e-01f, -2.96964377e-01f, -3.41137528e-01f, -2.13041946e-01f, 4.46224779e-01f, -3.54017526e-01f, 2.66098976e-01f, 3.71558040e-01f,
  4.60066617e-01f, -3.59170139e-02f, -5.73131204e-01f, -5.87005138e-01f, -8.59779045e-02f, -3.76227528e-01f, 2.81522553e-02f, -1.38849899e-01f, -8.04803371e-02f, -5.72600728e-03f,
  5.68674989e-02f, -1.03234015e-01f, -1.46023333e-01f, 1.05304740e-01f, -4.08397853e-01f, -5.41318320e-02f, -2.16098532e-01f, 2.05606252e-01f, -2.79527586e-02f, -3.02054018e-01f,
  5.00519834e-02f, -2.00792417e-01f, -3.86287898e-01f, 3.04218978e-01f, -3.47774476e-01f, -2.82390326e-01f, -3.75358611e-01f, -5.76524287e-02f, 3.82312611e-02f, 1.83342725e-01f,
  -3.26601952e-01f, -4.92848922e-03f, 3.34400386e-02f, -3.11741471e-01f, 1.84938252e-01f, 1.29431020e-02f, 1.92657590e-01f, -1.92549184e-01f, 1.00854985e-01f, -3.24040830e-01f,
  -2.87066638e-01f, -6.66996688e-02f, 1.62784785e-01f, 1.45094365e-01f, 2.09423550e-03f, -2.01030418e-01f, 1.02172174e-01f, -1.97465271e-02f, -2.13522777e-01f, 1.56249940e-01f,
  1.24961985e-02f, 6.41711280e-02f, 4.30721864e-02f, 1.32647887e-01f, -4.26289946e-01f, -1.47922680e-01f, -2.74535026e-02f, -1.30474105e-01f, -3.25467199e-01f, -4.03665394e-01f,
  -2.48713166e-01f, -3.39583486e-01f, -2.01393783e-01f, -5.60436130e-01f, 2.87911054e-02f, 2.85779864e-01f, 8.01135376e-02f, -2.69216001e-01f, -9.71006379e-02f, 3.51002544e-01f,
  2.15722442e-01f, 4.08898532e-01f, 4.11900282e-01f, 2.14348584e-01f, -1.73776686e-01f, 2.49878928e-01f, -2.42337570e-01f, 1.84014454e-01f, 2.63900846e-01f, 1.72373176e-01f,
  -2.38967612e-01f, -3.33259761e-01f, -4.21420634e-01f, -3.63986582e-01f, -4.09881949e-01f, 3.73839475e-02f, 7.84262940e-02f, 7.37029593e-03f, 1.25795692e-01f, -4.56140280e-01f,
  -2.19450682e-01f, -2.49320224e-01f, 2.49315992e-01f, 3.77396971e-01f, 4.73838300e-02f, 1.26668677e-01f, -1.07366569e-01f, 1.31079838e-01f, 2.94867039e-01f, -1.68071330e-01f,
  -9.15832072e-03f, 7.52845481e-02f, 3.60224545e-01f, -1.88574195e-01f, 3.55072737e-01f, -1.45258367e-01f, -3.42459649e-01f, -1.84986532e-01f, -2.46663410e-02f, 2.99377501e-01f,
  -2.07441241e-01f, 3.42989296e-01f, 5.21082819e-01f, -5.09015679e-01f, 1.14571981e-01f, -4.79113013e-01f, -4.79945362e-01f, 4.08279628e-01f, -3.68385792e-01f, -4.50873703e-01f,
  1.56447783e-01f, 3.81752521e-01f, 8.45422447e-02f, -5.54384589e-01f, -2.61307865e-01f, 1.33839384e-01f, -1.45009562e-01f, -9.92622972e-02f, -1.72614768e-01f, 2.55444765e-01f,
  -4.82398927e-01f, -1.51743427e-01f, 1.41448751e-01f, 3.97854477e-01f, 1.03693023e-01f, -2.64407136e-02f, 7.24468147e-03f, 3.03021014e-01f, 6.55934736e-02f, -2.76744306e-01f,
  1.63184106e-01f, 2.85111964e-01f, 1.99246004e-01f, 1.43118337e-01f, -1.25609264e-01f, -2.74978518e-01f, -4.08443175e-02f, -8.82406458e-02f, 2.03109048e-02f, 2.71123618e-01f,
  1.92213446e-01f, -1.55770019e-01f, 4.73087400e-01f, 1.84553370e-01f, 1.79177478e-01f, 2.07113355e-01f, -2.36222558e-02f, 9.79751498e-02f, 1.28364384e-01f, 1.50238812e-01f,
  -4.81758676e-02f, 1.46158770e-01f, -7.88462982e-02f, 1.34304941e-01f, -5.12612201e-02f, 1.40802845e-01f, 3.35845232e-01f, -3.40731442e-01f, -1.71095118e-01f, 9.21379924e-02f,
  7.74740800e-02f, 2.25877836e-01f, 1.35798588e-01f, 5.10064662e-02f, -3.03528935e-01f, 7.84910843e-02f, 6.80402294e-02f, -7.60020241e-02f, 1.95790201e-01f, -1.72893390e-01f,
  -6.82358593e-02f, 2.05099620e-02f, 2.15445101e-01f, -3.92031342e-01f, -3.54711264e-01f, -1.94182917e-01f, 5.63302875e-01f, 3.92889172e-01f, -1.83813527e-01f, 5.12336075e-01f,
  -4.81235147e-01f, 3.79865803e-02f, -1.50273010e-01f, -3.59695375e-01f, 9.79704931e-02f, -3.48244458e-01f, 3.34790014e-02f, -4.74110335e-01f, 4.28144753e-01f, 2.70131826e-02f,
  -9.53891352e-02f, 1.67584255e-01f, -3.57866317e-01f, 4.14689779e-01f, -4.45855856e-01f, 3.35153043e-01f, 2.51482695e-01f, 3.69395278e-02f, -3.23606372e-01f, -3.78435075e-01f,
  8.35900009e-02f, -4.11890745e-01f, -1.84499189e-01f, 4.24403518e-01f, 2.03976944e-01f, 1.45796537e-01f, 2.85949081e-01f, 2.89737523e-01f, -4.83466506e-01f, -1.91031352e-01f,
  3.43538150e-02f, -4.69163448e-01f, 2.49455869e-01f, 2.69723833e-01f, -6.43318713e-01f, 3.48707020e-01f, 9.03557688e-02f, -6.61651790e-02f, 6.66762665e-02f, -1.22479603e-01f,
  -3.92151207e-01f, 1.45647645e-01f, -4.24636602e-01f, 1.50137069e-02f, 2.66410619e-01f, 2.28206620e-01f, 7.55489022e-02f, -5.81290603e-01f, -2.53456771e-01f, 3.26173544e-01f,
  -5.78318685e-02f, 8.79826173e-02f, 5.61443120e-02f, -6.60165787e-01f, -7.34663680e-02f, -1.09972782e-01f, -1.89140767e-01f, 2.00194314e-01f, 2.15514824e-01f, -3.07929009e-01f,
  -3.26864243e-01f, -1.16187163e-01f, -1.71983033e-01f, -2.84624487e-01f, -5.14226496e-01f, 5.25936723e-01f, -2.00395048e-01f, 4.68170732e-01f, 4.42551225e-02f, 2.51709610e-01f,
  1.57725841e-01f, -2.44555082e-02f, 1.40349388e-01f, 3.47908810e-02f, -1.02751896e-01f, 9.87016857e-02f, -6.49553835e-02f, 1.06090441e-01f, -2.26756975e-01f, 1.65489420e-01f,
  1.20664909e-01f, 2.58769214e-01f, -1.03429250e-01f, -2.37037703e-01f, 2.83731252e-01f, -1.56345189e-01f, 1.96588978e-01f, 4.10662740e-01f, 2.44715080e-01f, 2.55805165e-01f,
  -3.25052768e-01f, 1.59090415e-01f, 9.62498784e-02f, 2.02026993e-01f, -4.86522466e-02f, -5.94032109e-02f, 2.89117396e-01f, 1.94646105e-01f, 6.35118857e-02f, -1.78817600e-01f,
  2.38896072e-01f, 1.09711796e-01f, 2.15914771e-01f, 1.07289394e-02f, -1.99129522e-01f, 1.59218058e-01f, -6.98114708e-02f, 2.76884884e-02f, -1.46697715e-01f, 1.32245287e-01f,
  1.72553346e-01f, 3.58392477e-01f, 2.41480932e-01f, 3.20502371e-01f, 7.32731400e-03f, 1.98951289e-01f, 1.28688321e-01f, -9.04241353e-02f, 1.40762210e-01f, 2.29061633e-01f,
  1.59493938e-01f, 3.26547831e-01f, 3.34763497e-01f, 8.44051540e-02f, -2.05456346e-01f, 2.79688776e-01f, 4.78996724e-01f, 1.13017432e-01f, 1.86473615e-02f, 1.22414548e-02f,
  -7.98128825e-03f, -1.22971199e-01f, 4.87165987e-01f, -2.53256828e-01f, -5.05157888e-01f, -3.84937786e-02f, -2.71952808e-01f, 4.36940551e-01f, -7.63970613e-02f, 1.49432076e-02f,
  1.53117269e-01f, -5.08007705e-01f, 1.03825383e-01f, -2.01225191e-01f, -5.23316205e-01f, -5.30120432e-01f, -2.91319191e-01f, -2.09620267e-01f, -2.55417764e-01f, -2.13537365e-02f,
  3.06414813e-01f, 1.13485977e-01f, 5.35484433e-01f, -3.47915322e-01f, -4.05802846e-01f, 2.54470646e-01f, 3.37969720e-01f, 1.95196196e-01f, -2.18607202e-01f, -1.19616069e-01f,
  -2.46420652e-01f, 4.89932954e-01f, 3.41764510e-01f, -1.80993006e-01f, 3.72959584e-01f, -1.95926860e-01f, 2.08031341e-01f, -2.09664255e-01f, -3.96254420e-01f, -1.70205399e-01f,
  -2.34719351e-01f, 1.68501005e-01f, -6.01123512e-01f, -2.81808287e-01f, -9.39739645e-02f, -3.58466923e-01f, -5.50941467e-01f, -2.46258333e-01f, 1.73927739e-01f, 1.79895125e-02f,
  4.52154309e-01f, 2.14247510e-01f, -1.91421852e-01f, -1.72698982e-02f, 1.67194337e-01f, -5.65823674e-01f, -2.80682325e-01f, -3.92647296e-01f, 2.67638445e-01f, 3.86028215e-02f,
  -2.65880942e-01f, 7.60457873e-01f, -4.61520441e-03f, -6.25954509e-01f, 1.14246920e-01f, -1.07198909e-01f, -3.97029310e-01f, 9.44211613e-03f, 1.00625739e-01f, -1.58107001e-02f,
  -9.78006050e-02f, 8.20996165e-02f, 5.64141050e-02f, 2.23055571e-01f, -2.55589485e-01f, 3.09691597e-02f, -1.91243906e-02f, -1.57861680e-01f, 1.07826248e-01f, -5.64216897e-02f,
  -2.24953309e-01f, 1.87769011e-01f, -1.04014017e-02f, 5.38979508e-02f, 2.06411585e-01f, 1.46816690e-02f, -1.32438630e-01f, 5.26750125e-02f, -1.39275670e-01f, -4.96965572e-02f,
  -1.73032701e-01f, -1.15258865e-01f, 5.22973202e-02f, -1.45158440e-01f, -1.93886504e-01f, 2.15691239e-01f, -8.07776749e-02f, 6.35316521e-02f, 5.61428331e-02f, 4.77326512e-02f,
  -1.49527311e-01f, -2.07196828e-03f, 1.14118010e-01f, -1.80119231e-01f, 2.44303271e-01f, 1.79036230e-01f, 5.55086583e-02f, -3.27709764e-01f, 2.27730558e-03f, -1.98166966e-01f,
  1.06353521e-01f, 1.57608703e-01f, 2.12381929e-01f, 5.51341027e-02f, -2.17801765e-01f, 1.62959382e-01f, -1.77570879e-01f, -2.81225860e-01f, -5.48271015e-02f, 1.78270519e-01f,
  1.16559818e-01f, 4.07951891e-01f, 1.74139798e-01f, -3.54536533e-01f, 8.46163481e-02f, 3.24026495e-01f, 2.01666772e-01f, 2.14474335e-01f, -5.69903910e-01f, 1.38589799e-01f,
  -3.91894102e-01f, -2.95381844e-01f, -5.57746924e-03f, 4.23556566e-01f, -1.24249235e-01f, -2.17102975e-01f, -3.40917140e-01f, -2.91168064e-01f, -8.44808817e-02f, 3.37845594e-01f,
  1.15575623e-02f, -2.64904827e-01f, -2.78570414e-01f, 3.82418275e-01f, 3.00865561e-01f, 5.48462570e-01f, -3.67163986e-01f, -8.48134682e-02f, -3.70695233e-01f, 1.96482480e-01f,
  -2.96862960e-01f, -3.43163460e-01f, -1.03332065e-01f, -3.45944613e-01f, 2.59571642e-01f, 1.37132347e-01f, -3.32777500e-01f, -3.41689974e-01f, -1.29932035e-02f, -3.83482128e-01f,
  2.60647479e-02f, -5.11457086e-01f, -3.03518087e-01f, -4.98319417e-02f, -4.86773029e-02f, -2.98481673e-01f, 8.45576301e-02f, -5.46399236e-01f, -2.30319977e-01f, 1.97698340e-01f,
  3.24052930e-01f, -3.85624468e-01f, -6.38100564e-01f, -2.53655970e-01f, -1.03471667e-01f, -1.61263600e-01f, -3.63571703e-01f, -2.98474848e-01f, -2.12113652e-02f, 2.88164020e-01f,
  -3.34000252e-02f, 5.48097312e-01f, -5.01336575e-01f, 5.19261897e-01f, -1.60976678e-01f, -4.74312931e-01f, -2.20749244e-01f, -3.22414696e-01f, 5.38244486e-01f, -5.10170981e-02f,
  2.78713405e-01f, -4.06585246e-01f, -1.67643100e-01f, -1.75225154e-01f, -2.67291278e-01f, 1.34513667e-02f, -6.61690831e-02f, 1.26938568e-02f, -3.22657585e-01f, -2.56327838e-01f,
  4.02698182e-02f, -3.44361633e-01f, 1.03434026e-01f, 1.54859915e-01f, -7.82457069e-02f, -2.04405218e-01f, 1.47059709e-01f, -1.65526539e-01f, -1.75179794e-01f, -8.64825994e-02f,
  -3.33829165e-01f, 4.28340845e-02f, -3.10885102e-01f, -1.80257902e-01f, -1.49282306e-01f, -2.23055094e-01f, 1.23990588e-01f, -2.64968693e-01f, 2.53619775e-02f, -1.46747008e-01f,
  -1.09434843e-01f, -8.59425127e-05f, 1.26553386e-01f, 1.41210028e-03f, -3.90718132e-02f, 1.03812650e-01f, -5.72134182e-02f, -9.19562504e-02f, 1.24408994e-02f, 3.57226729e-02f,
  -6.19383110e-03f, -1.34095550e-01f, -7.50257671e-02f, -4.57679369e-02f, -1.00518398e-01f, -5.25946245e-02f, -2.15301767e-01f, 1.24060191e-01f, 3.06438953e-02f, -1.84392810e-01f,
  -1.77006721e-01f, -3.07346225e-01f, -2.38591470e-02f, 1.20072328e-01f, 3.40766553e-03f, -1.75158516e-01f, 1.63948298e-01f, -1.97579563e-01f, -1.75006479e-01f, 3.89389992e-01f,
  -1.85539261e-01f, 1.87988922e-01f, -2.73723036e-01f, 9.97504126e-03f, 2.30976373e-01f, -1.59835935e-01f, -3.48190874e-01f, -3.76499654e-03f, 2.31495216e-01f, 2.52876699e-01f,
  1.34831712e-01f, 3.58086556e-01f, 4.25117284e-01f, -3.88913095e-01f, -2.98828959e-01f, -3.24281049e-03f, -2.14188278e-01f, 1.16852067e-01f, -1.26225263e-01f, 2.38622382e-01f,
  -1.94758698e-01f, -2.20358565e-01f, 1.07531659e-01f, 1.36760369e-01f, -1.58937082e-01f, -8.57153460e-02f, 1.69416606e-01f, -2.03765839e-01f, 2.21215710e-01f, -2.24279195e-01f,
  1.31406099e-01f, 2.87372738e-01f, -1.36325166e-01f, 1.95003748e-01f, -2.83083379e-01f, 2.26175129e-01f, 1.68411091e-01f, -2.62473315e-01f, -4.13959809e-02f, 2.21559361e-01f,
  2.86311179e-01f, -2.11077884e-01f, -1.24930255e-01f, 1.94972411e-01f, 2.13002209e-02f, -1.41230479e-01f, 1.17702566e-01f, -1.08883053e-01f, -3.01096380e-01f, -2.68845230e-01f,
  1.56744719e-01f, -2.82909870e-01f, 1.89400226e-01f, 2.85373241e-01f, 3.23862314e-01f, -2.85636932e-01f, 2.07633466e-01f, -2.83378035e-01f, -1.03484333e-01f, -4.36564326e-01f,
  -1.77591249e-01f, 4.46637690e-01f, -3.89013499e-01f, 4.13697392e-01f, 5.00577569e-01f, -1.05353490e-01f, -2.06273824e-01f, -1.93513706e-01f, 8.85925442e-03f, -6.32504076e-02f,
  2.55858868e-01f, -2.94617504e-01f, 2.15380136e-02f, 2.08740711e-01f, 1.89514294e-01f, 4.74879071e-02f, 1.66945845e-01f, 2.28431702e-01f, -7.85389617e-02f, -7.17809126e-02f,
  -2.04696864e-01f, 2.26454139e-02f, -5.96711636e-02f, -2.19043866e-01f, -9.72868428e-02f, 5.84067591e-02f, -2.30925865e-02f, -5.39924540e-02f, -1.58439383e-01f, 6.85776472e-02f,
  8.31877738e-02f, -2.66621083e-01f, -3.04474503e-01f, 5.32395542e-02f, -8.93037580e-03f, 1.02782875e-01f, 7.52257407e-02f, -1.06953479e-01f, -1.32026775e-02f, -2.90937927e-02f,
  -7.54906423e-03f, -1.66988507e-01f, -5.51798046e-02f, -1.42193452e-01f, -2.34915078e-01f, -1.68305300e-02f, -1.47298202e-01f, 1.03949577e-01f, -1.91030651e-01f, -2.91474909e-01f,
  -3.62134576e-01f, -2.18003348e-01f, -5.47608398e-02f, -1.89398363e-01f, -8.11524503e-03f, 1.25144303e-01f, -3.15983325e-01f, -5.62443398e-02f, -4.62543629e-02f, -2.79669434e-01f,
  -3.74409631e-02f, -6.80521503e-02f, 5.30266315e-02f, -1.36503920e-01f, 1.24641575e-01f, 4.66601588e-02f, 1.78562850e-01f, -1.19820081e-01f, -1.83937043e-01f, -3.41988713e-01f,
  1.88927785e-01f, -2.52100140e-01f, -8.51856768e-02f, 1.93589747e-01f, 2.98798174e-01f, 2.90546924e-01f, -4.37202938e-02f, 2.55266488e-01f, 7.09341988e-02f, -2.02487394e-01f,
  -3.54066908e-01f, 1.27303749e-01f, 2.84596115e-01f, -1.45725787e-01f, -2.58737039e-02f, -1.09526314e-01f, 9.90020111e-02f, 4.80055884e-02f, -1.30849242e-01f, 1.72074512e-01f,
  1.15817040e-01f, -2.65346825e-01f, -2.95361400e-01f, -1.01583436e-01f, 1.36339478e-02f, 1.33160530e-02f, -1.97704032e-01f, 2.03674570e-01f, 2.93381363e-01f, -2.47227043e-01f,
  2.47725189e-01f, -5.82595430e-02f, 2.48188391e-01f, -2.77189642e-01f, 3.20114106e-01f, -1.98115766e-01f, -1.76708505e-01f, -2.48417392e-01f, 2.33263388e-01f, 2.09657863e-01f,
  3.11838657e-01f, 5.01703955e-02f, 1.55156046e-01f, 1.66652605e-01f, 1.61011264e-01f, -1.88176826e-01f, -3.44513744e-01f, -3.66764337e-01f, -2.61973560e-01f, -1.59680560e-01f,
  5.60298152e-02f, -1.88459471e-01f, -2.85983860e-01f, -3.93919438e-01f, 2.16341354e-02f, 3.07474062e-02f, 5.25921762e-01f, -6.21502809e-02f, 2.47914836e-01f, -2.28854895e-01f,
  -2.09678382e-01f, -5.21928132e-01f, 3.76215219e-01f, -1.53679103e-01f, -2.54982680e-01f, -1.09452277e-01f, 3.35580409e-01f, 3.68765771e-01f, 1.46799043e-01f, -3.34459573e-01f,
  3.67352188e-01f, 4.24780667e-01f, -1.30829774e-02f, 1.25428736e-01f, 1.13982908e-01f, 1.29191935e-01f, 9.39972047e-03f, 1.16978250e-01f, -9.48186517e-02f, 1.20187394e-01f,
  1.90997884e-01f, -3.24064255e-01f, -3.59238178e-01f, 1.17826253e-01f, 2.03150392e-01f, 1.45669043e-01f, 3.33874300e-02f, 1.43884480e-01f, -6.17532409e-04f, -3.42018247e-01f,
  1.44940063e-01f, -2.75301486e-02f, 9.03296247e-02f, 3.56548578e-02f, -2.12207474e-02f, 1.46766111e-01f, 4.76121418e-02f, -7.18102558e-03f, -1.62785918e-01f, -1.11952253e-01f,
  -1.25576733e-02f, -1.59733128e-02f, -2.80360617e-02f, -2.91391890e-02f, 1.35106429e-01f, 2.46035978e-01f, -3.62365022e-02f, 2.11073592e-01f, 1.19205713e-01f, -3.78687978e-01f,
  9.82511044e-02f, 1.77004382e-01f, -3.77093665e-02f, 1.50796100e-01f, 6.51071817e-02f, -8.13191058e-04f, -3.10587864e-02f, 8.59735757e-02f, 1.00081526e-01f, -1.10336199e-01f,
  2.37961024e-01f, -3.43602262e-02f, -1.71722800e-01f, 3.60101551e-01f, 1.73442829e-02f, -2.27874480e-02f, 2.11985543e-01f, -1.02117002e-01f, -3.82113963e-01f, 1.75716057e-01f,
  1.86420739e-01f, -4.82218247e-03f, -2.01024234e-01f, -3.50188792e-01f, -2.59166509e-01f, 9.23462287e-02f, 7.99676627e-02f, 4.53868836e-01f, -2.98221767e-01f, 4.15971354e-02f,
  -3.57899427e-01f, 2.32644096e-01f, -2.44040683e-01f, -4.06987309e-01f, 2.59910017e-01f, -3.86878729e-01f, -2.48093396e-01f, -4.29256290e-01f, 3.40357333e-01f, 2.78726578e-01f,
  4.24124032e-01f, -1.86938137e-01f, 1.05911262e-01f, 2.52781838e-01f, 3.74617904e-01f, -2.99280256e-01f, -1.16778284e-01f, 3.42208713e-01f, -2.87410527e-01f, -1.52322844e-01f,
  -2.71137238e-01f, 7.64607117e-02f, -3.44587207e-01f, -5.03244162e-01f, 2.10434034e-01f, 4.45784748e-01f, -1.90442860e-01f, 4.35311466e-01f, -2.30088800e-01f, 1.75754443e-01f,
  -1.21730171e-01f, 3.89619648e-01f, -2.34717682e-01f, 2.03916907e-01f, 2.79730707e-01f, -2.63194926e-02f, 6.09895706e-01f, -6.93763420e-02f, -3.87926176e-02f, -5.48847079e-01f,
  -3.04792881e-01f, -4.08505589e-01f, -3.16592932e-01f, -5.38764477e-01f, -3.75171781e-01f, -4.07833904e-01f, 6.23907387e-01f, 4.05422062e-01f, 2.88113117e-01f, -6.82822764e-02f,
  -1.53196886e-01f, -1.90923005e-01f, -5.40045619e-01f, -4.91809100e-01f, -1.22786291e-01f, -3.78232896e-01f, 3.66141737e-01f, -4.29378986e-01f, 4.52242456e-02f, -1.85837343e-01f,
  4.76352274e-02f, -1.84198707e-01f, 1.56067654e-01f, 1.99237689e-01f, 1.45847306e-01f, 2.61783868e-01f, 1.28262028e-01f, 1.76863492e-01f, 2.29562640e-01f, -1.03030987e-01f,
  9.46164355e-02f, 1.06759340e-01f, 2.82808989e-01f, -1.10114902e-01f, 1.46586895e-02f, 2.69105554e-01f, 1.39732331e-01f, 8.68373066e-02f, 1.61440566e-01f, -6.54334649e-02f,
  -9.71677750e-02f, 1.29705399e-01f, -2.28479251e-01f, -2.86220703e-02f, -8.21119845e-02f, 1.58158801e-02f, 3.45164202e-02f, 1.33408727e-02f, -4.15381491e-02f, 2.47652620e-01f,
  -7.59628564e-02f, -2.96399985e-02f, -9.10584182e-02f, 9.41416696e-02f, -1.10944584e-01f, 2.32164562e-01f, 3.44421893e-01f, 1.11619189e-01f, -7.33122006e-02f, -1.20355658e-01f,
  9.29259583e-02f, 1.21894732e-01f, 1.86819404e-01f, 1.44586936e-01f, -1.77041329e-02f, -8.77969936e-02f, -1.45613542e-02f, -4.55416217e-02f, 2.28936542e-02f, -1.97516568e-03f,
  1.16349705e-01f, 1.61430061e-01f, -4.11406070e-01f, -1.26409277e-01f, -1.88259155e-01f, 3.50117743e-01f, -1.68289632e-01f, -2.21935213e-01f, 2.06654921e-01f, 4.48941022e-01f,
  3.18298697e-01f, 3.59486818e-01f, -1.07291996e-01f, 1.91711068e-01f, 3.86569321e-01f, 1.50408223e-01f, 8.71885195e-02f, -3.39877307e-01f, 1.73671126e-01f, 2.53204316e-01f,
  4.61096615e-01f, 3.45077366e-01f, -4.09554869e-01f, 4.26221997e-01f, 2.19802648e-01f, 2.46751711e-01f, 4.89992499e-01f, 1.17958836e-01f, 2.66017944e-01f, 2.43991986e-01f,
  2.09749773e-01f, -4.31098610e-01f, -3.92196476e-01f, 4.16098982e-01f, 1.68888405e-01f, -1.97735637e-01f, -2.16812789e-01f, 1.14774808e-01f, 7.11916238e-02f, 3.86529833e-01f,
  4.03207898e-01f, -3.10156494e-01f, -9.17861704e-03f, 9.66037884e-02f, -2.78873682e-01f, -1.56012893e-01f, -1.32276922e-01f, 2.97855824e-01f, 2.17735954e-02f, 1.43704459e-01f,
  2.49030560e-01f, -2.19523311e-01f, 4.83266450e-02f, -2.35054880e-01f, -2.97799617e-01f, 4.48649764e-01f, -3.69332492e-01f, -4.28727925e-01f, -5.68721831e-01f, -3.23738977e-02f,
  1.86630338e-01f, 1.21469431e-01f, 4.72620815e-01f, -5.52511811e-01f, 2.65965521e-01f, -2.64285773e-01f, -2.29867548e-01f, 3.83551925e-01f, -4.78761345e-01f, 4.44841146e-01f,
  -2.24492192e-01f, -2.24485710e-01f, -4.64621812e-01f, -4.12619829e-01f, -3.56584996e-01f, 4.56653088e-01f, -2.24236310e-01f, -3.66481304e-01f, 8.31641033e-02f, 1.62430584e-01f,
  2.99449321e-02f, 1.05442651e-01f, 5.20300567e-02f, -9.96651500e-02f, -2.96526812e-02f, -3.12387710e-03f, 1.40226245e-01f, 1.53136207e-02f, 2.09177464e-01f, -1.11658126e-02f,
  2.30624732e-02f, 5.62247932e-02f, -1.34104230e-02f, -1.95988528e-02f, -1.76108420e-01f, -6.14163131e-02f, 1.45625889e-01f, 1.09325320e-01f, 2.93188184e-01f, -7.71745443e-02f,
  4.17438969e-02f, -6.99521825e-02f, 9.33876932e-02f, 2.03125668e-03f, 1.16221145e-01f, -1.56188011e-01f, 7.11425096e-02f, -4.72826287e-02f, -1.07262380e-01f, -1.01175057e-02f,
  -1.38711497e-01f, -6.12400584e-02f, 1.02797225e-01f, 9.92517248e-02f, 1.77246466e-01f, -1.99343706e-03f, 1.07188463e-01f, 1.44117907e-01f, 1.24014027e-01f, -1.73629820e-01f,
  -1.90323874e-01f, -1.23775467e-01f, -4.41293279e-03f, -2.36626655e-01f, -3.81218970e-01f, 1.02552520e-02f, -2.88397610e-01f, 1.26623854e-01f, -6.79527819e-02f, -4.74741384e-02f,
  -1.47757083e-01f, -2.74439603e-01f, -1.34885848e-01f, -1.40634194e-01f, -2.24979728e-01f, -3.12565297e-01f, -3.56729299e-01f, -1.89874738e-01f, 3.21306169e-01f, 1.11627817e-01f,
  3.49272162e-01f, 3.06242198e-01f, -2.95589179e-01f, -1.39429599e-01f, -7.97254313e-03f, -4.42423075e-01f, -2.46013686e-01f, -2.99349036e-02f, -2.73812622e-01f, -1.71934515e-01f,
  4.92470860e-01f, -3.39932382e-01f, -1.93336129e-01f, 1.18933931e-01f, 1.70707688e-01f, -2.23304302e-01f, -1.06674716e-01f, 1.95510611e-01f, 1.96529329e-02f, 3.02991003e-01f,
  2.10757434e-01f, -2.80540615e-01f, 3.94363046e-01f, -3.15518558e-01f, 2.83082634e-01f, 1.99120149e-01f, 3.63517255e-01f, 2.65192062e-01f, -1.24126486e-01f, -9.91689861e-02f,
  -3.30263048e-01f, -2.14060917e-01f, 2.75781780e-01f, 2.44746897e-02f, 3.69050562e-01f, -3.40927124e-01f, -2.55723685e-01f, -1.14539012e-01f, 2.18492240e-01f, -2.38415569e-01f,
  2.55438209e-01f, -3.23101938e-01f, -2.83794433e-01f, 1.18575040e-02f, -3.66377831e-01f, -3.37255269e-01f, -2.18597010e-01f, 1.32357970e-01f, -1.41945601e-01f, -4.32680100e-01f,
  -3.81488740e-01f, 5.35642326e-01f, -3.41034323e-01f, -3.37252051e-01f, 5.81210434e-01f, 2.41230130e-01f, -9.49360579e-02f, 4.21342015e-01f, -1.68630317e-01f, -1.68118477e-02f,
  4.54257071e-01f, -4.12266463e-01f, -1.83292657e-01f, -3.30220491e-01f, 3.63718152e-01f, -2.40399137e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.60694043e-02f, 4.57873084e-02f, -1.49399161e-01f, 4.04705517e-02f, -1.33211985e-02f, -1.94592196e-02f, 2.50121299e-02f, -2.37307921e-02f, -7.41405115e-02f, -2.26097181e-02f,
  2.38436125e-02f, -7.93332905e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    