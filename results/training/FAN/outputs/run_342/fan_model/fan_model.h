/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.25943312e-01f, -4.06418979e-01f, 4.32696715e-02f, 1.84636816e-01f, -2.89164968e-02f, 1.72424659e-01f, 2.77350575e-01f, -9.16044042e-02f, 2.30054304e-01f, -3.77780139e-01f,
  -1.23420522e-01f, -3.61087173e-02f, -1.02515584e-02f, -4.67006490e-02f, 2.80360192e-01f, 1.88748851e-01f, -2.97526401e-02f, 2.42557898e-02f, 9.27379429e-02f, -1.74208358e-01f,
  4.32317555e-02f, -1.66805133e-01f, 7.97045529e-02f, -2.52874970e-01f, -8.89923945e-02f, 1.77975371e-02f, -2.08970338e-01f, 3.88918184e-02f, -1.72839746e-01f, -1.13362707e-02f,
  4.80654463e-02f, 4.16990072e-02f, -5.26357852e-02f, -2.11520717e-02f, 3.96257313e-03f, -4.41416688e-02f, 1.55373560e-02f, 6.49182945e-02f, 1.24233998e-01f, -2.77081188e-02f,
  -2.80231629e-02f, -1.70221385e-02f, -4.76827435e-02f, 1.97600387e-02f, 5.61486594e-02f, -6.10974245e-02f, -4.35110070e-02f, 4.59590591e-02f, -1.41068746e-03f, 6.01812964e-03f,
  2.10264493e-02f, -7.51030967e-02f, 1.06057059e-02f, -4.67620380e-02f, 6.89403191e-02f, 1.76620465e-02f, 2.93583069e-02f, 1.92114357e-02f, -5.36139980e-02f, 6.49121478e-02f,
  -8.72670859e-02f, -3.83376665e-02f, 1.54707711e-02f, -4.29432082e-04f, -3.75625258e-03f, -3.62239890e-02f, -3.65668759e-02f, -1.55656310e-02f, 2.15547942e-02f, -1.12366006e-02f,
  1.18209757e-02f, -1.37549790e-03f, -7.39000179e-03f, -1.21461172e-02f, -4.74843606e-02f, 5.36794625e-02f, -6.55441498e-03f, -7.36601129e-02f, 2.65937112e-03f, 8.02433118e-03f,
  3.15494202e-02f, -8.70606920e-04f, 1.12743443e-02f, -5.45822009e-02f, -4.53772536e-03f, -4.30777902e-03f, -9.21839774e-02f, -4.37685614e-03f, 7.88267981e-03f, 7.29479045e-02f,
  -9.21709016e-02f, -3.02633137e-01f, 5.78166321e-02f, 3.51985656e-02f, -3.58510278e-02f, -4.98667061e-02f, -5.60025265e-03f, -4.67005149e-02f, -3.99418548e-02f, -1.13011468e-02f,
  -6.18264489e-02f, 4.66684252e-02f, -4.21934202e-02f, -4.00988664e-03f, -2.33706478e-02f, -1.12080770e-02f, -2.67731547e-02f, -3.89778763e-02f, -1.66017227e-02f, -7.81041384e-02f,
  -2.81617381e-02f, -9.67927836e-03f, 2.40113959e-02f, 2.86422614e-02f, -2.69862469e-02f, -4.34308089e-02f, 8.14393256e-03f, 2.83748540e-03f, -5.99732343e-03f, -1.82912368e-02f,
  -1.43970907e-01f, -4.64605764e-02f, -9.98003036e-02f, 2.57018898e-02f, 9.77643859e-03f, -5.51727377e-02f, -1.03366878e-02f, -4.58415933e-02f, -1.96296605e-03f, 9.89818797e-02f,
  9.55870096e-03f, -1.36104986e-01f, -6.09492995e-02f, 1.10251896e-01f, -4.81922701e-02f, 1.04977928e-01f, 2.68200785e-03f, -3.09056398e-02f, 5.71339466e-02f, -4.25693430e-02f,
  6.79608434e-02f, 1.18771091e-01f, 5.14822863e-02f, 2.90716942e-02f, -9.43613201e-02f, 4.85543311e-02f, -6.20364696e-02f, 2.51692813e-02f, 8.27255249e-02f, 6.63993508e-02f,
  -7.28065819e-02f, -9.59180892e-02f, -1.22481845e-01f, -4.78055328e-02f, -1.06292844e-01f, 3.24609503e-02f, -8.37588683e-02f, -7.87648410e-02f, -2.00829078e-02f, -3.90573628e-02f,
  -7.07941204e-02f, -8.93717259e-02f, 2.95042619e-02f, -6.02039360e-02f, 6.21549189e-02f, 1.70569308e-02f, 6.79262578e-02f, -2.79648397e-02f, 1.12721873e-02f, -5.70005514e-02f,
  -6.48248643e-02f, 2.03570481e-02f, 3.37302126e-02f, 7.06488639e-02f, -2.85249297e-02f, -3.67355272e-02f, 6.78470582e-02f, -5.39718792e-02f, -6.74292669e-02f, 3.99157703e-02f,
  8.22864994e-02f, 8.21865872e-02f, -4.91245240e-02f, -3.09613217e-02f, -2.38474607e-02f, 6.47818521e-02f, -3.41122597e-02f, -7.34453350e-02f, 7.93569684e-02f, 5.57787195e-02f,
  -5.71680851e-02f, 5.40143922e-02f, -4.28955769e-03f, -5.24233803e-02f, 2.81839743e-02f, 2.38853861e-02f, 5.71376309e-02f, 2.18698587e-02f, 6.69143125e-02f, 6.46590739e-02f,
  -4.56885025e-02f, 2.05483232e-02f, -4.43489067e-02f, -4.59474232e-03f, 2.17859950e-02f, -8.70267302e-02f, -4.75332215e-02f, 5.06627746e-02f, -1.12520009e-02f, 8.01007915e-03f,
  -1.23951033e-01f, -2.32491270e-01f, 2.08413284e-02f, -8.16027001e-02f, 2.74010859e-02f, -1.08985947e-02f, 6.18769154e-02f, 7.19373077e-02f, -4.12448496e-02f, 4.19550277e-02f,
  -5.18572740e-02f, -2.83008218e-02f, -3.89851034e-02f, -6.16143271e-02f, -2.77988077e-03f, -1.57137234e-02f, -8.37292895e-02f, -1.00456305e-01f, -6.48874789e-02f, 9.11391899e-03f,
  -7.98411816e-02f, 2.40460262e-02f, 5.31624071e-02f, -5.13585880e-02f, 2.15631165e-02f, -7.54887750e-03f, -8.34255517e-02f, -6.41938150e-02f, -5.23487281e-04f, -5.04989475e-02f,
  5.89294545e-03f, -1.35339707e-01f, 9.42461118e-02f, -2.19999939e-01f, 1.57508180e-01f, 2.52358671e-02f, 7.99405947e-02f, -5.79459481e-02f, -3.66327912e-02f, -9.34296474e-02f,
  6.83220774e-02f, -1.27719253e-01f, 2.04759017e-01f, -8.82011056e-02f, 1.94052532e-01f, 1.13092184e-01f, -6.55592531e-02f, -1.75676778e-01f, 2.81746848e-04f, -2.01806441e-01f,
  -4.05852832e-02f, -1.46540135e-01f, 2.42332648e-02f, -1.19858660e-01f, -2.99256723e-02f, -1.36061296e-01f, -3.11775617e-02f, 3.69584896e-02f, -1.67881832e-01f, 1.01548582e-02f,
  -7.53402188e-02f, -1.82608470e-01f, -7.20994771e-02f, -5.60088269e-02f, -8.57011154e-02f, -7.25391135e-02f, -5.22858314e-02f, 4.40314785e-02f, -2.16235388e-02f, 1.61634274e-02f,
  2.29758695e-02f, 4.07697819e-02f, -8.42390209e-02f, 1.97355617e-02f, -4.06343043e-02f, -1.24423513e-02f, 6.17124550e-02f, -9.90692433e-03f, -6.01350255e-02f, 1.13703877e-01f,
  -1.31444186e-02f, -3.10181379e-02f, 4.23688665e-02f, -1.01950625e-02f, 2.59077409e-03f, -3.62780131e-02f, -8.13481882e-02f, -3.25209983e-02f, -7.47673139e-02f, -1.77686289e-02f,
  -4.22911085e-02f, -2.34838892e-02f, 6.78252578e-02f, -4.87757213e-02f, 3.56808230e-02f, -3.30001898e-02f, -8.51577986e-03f, -2.87552532e-02f, -5.08815004e-03f, 7.17022270e-02f,
  -7.21007958e-02f, -1.49755599e-02f, 1.88325830e-02f, -1.52799173e-03f, -1.50606073e-02f, -2.15516351e-02f, -8.94355401e-03f, -3.86600196e-02f, 4.00824249e-02f, -2.51709856e-02f,
  -4.38453928e-02f, 4.09022756e-02f, 1.91372093e-02f, -8.15926399e-03f, 2.38621910e-03f, 4.95957211e-02f, -1.00524545e-01f, -1.45781143e-02f, -6.31936565e-02f, 3.64974067e-02f,
  -2.82124244e-03f, -3.05918396e-01f, 4.09965254e-02f, -8.24200436e-02f, 1.84432452e-03f, -1.87338551e-03f, 3.13205854e-03f, 1.23041961e-02f, -5.30149788e-02f, -5.79040423e-02f,
  -2.12559327e-02f, -7.68309906e-02f, -5.98899722e-02f, 2.77875103e-02f, -4.16870303e-02f, -2.99955253e-02f, 1.59591381e-02f, -1.90389175e-02f, -1.03414450e-02f, 1.52300643e-02f,
  -5.64323403e-02f, -2.23915521e-02f, 3.60892452e-02f, 6.13061525e-03f, -2.86716688e-02f, -1.05643691e-02f, 3.24852392e-02f, -1.22089265e-02f, 2.66618617e-02f, -7.93981627e-02f,
  -2.28926018e-02f, 1.95846092e-02f, -9.58052501e-02f, -1.21632002e-01f, 1.27966898e-02f, -4.42800701e-01f, -1.34158209e-01f, -1.06180117e-01f, 1.57055721e-01f, 5.42674288e-02f,
  -4.40997072e-03f, 1.13436971e-02f, 2.01689273e-01f, -2.78359115e-01f, -2.87080079e-01f, 1.73247363e-02f, -3.44078690e-01f, -1.56385452e-01f, 8.63333568e-02f, -4.38705273e-02f,
  -4.14714813e-02f, -1.02873608e-01f, 1.31751494e-02f, 1.98865160e-02f, -6.03366643e-02f, 4.52936850e-02f, 4.27920260e-02f, 2.24347815e-01f, -1.68629095e-01f, -2.37488337e-02f,
  -3.62497084e-02f, 1.87955469e-01f, -1.14545319e-02f, 1.49983652e-02f, -6.77602887e-02f, -2.85328459e-02f, -7.27729574e-02f, 8.74574296e-03f, 5.48041426e-02f, 3.17439288e-02f,
  -3.28367166e-02f, -1.04361856e-02f, -2.97200307e-02f, 7.36380145e-02f, 5.08687831e-02f, 2.72944923e-02f, 3.79500128e-02f, -4.56379391e-02f, 3.72140296e-02f, 3.48211564e-02f,
  5.91678470e-02f, -4.62051444e-02f, -3.92667623e-03f, 1.05974283e-02f, -4.81462255e-02f, 2.81993230e-03f, -5.43230362e-02f, -8.13805591e-03f, 4.63352911e-03f, -5.67374192e-02f,
  3.64744924e-02f, -1.52279288e-02f, 2.24085152e-02f, 3.16889770e-02f, -2.20931675e-02f, 8.32722783e-02f, -5.62711395e-02f, 6.65684268e-02f, 7.62468725e-02f, -5.28911576e-02f,
  4.87623997e-02f, -1.37396930e-02f, 5.90577461e-02f, -1.94770452e-02f, -2.83723697e-02f, 2.67276708e-02f, -2.69782613e-03f, -3.36676911e-02f, -5.65932468e-02f, -1.52781317e-02f,
  4.92711402e-02f, -6.35043578e-03f, 4.41255700e-03f, 1.03987940e-02f, -4.01423089e-02f, 5.79988435e-02f, 7.23626465e-02f, -3.61386612e-02f, 6.41755834e-02f, -1.22291278e-02f,
  -1.63567126e-01f, -1.26265794e-01f, 7.53815696e-02f, 1.00667635e-02f, -1.53006278e-02f, -3.35659608e-02f, 1.68308616e-02f, -6.76062852e-02f, -2.01196447e-02f, 5.54495677e-03f,
  -6.71431422e-02f, -1.69629622e-02f, -7.33519197e-02f, 2.34049968e-02f, -6.46201074e-02f, -3.05563509e-02f, -3.04791611e-02f, 2.50978116e-02f, -6.90983161e-02f, -8.45891088e-02f,
  9.83962044e-03f, -2.39764620e-02f, -8.93355347e-03f, -3.03987563e-02f, -1.45526435e-02f, -4.28890809e-02f, -7.69989714e-02f, 2.15794612e-02f, -8.17440599e-02f, 3.82736395e-03f,
  -5.12330346e-02f, -2.15885803e-01f, -5.68180494e-02f, 1.63542658e-01f, -2.01711953e-01f, -9.33382884e-02f, 4.93759550e-02f, -2.70204157e-01f, 7.97162876e-02f, -1.11453561e-02f,
  -4.40487936e-02f, 1.84476152e-01f, -7.00329095e-02f, -2.86677815e-02f, 6.88606650e-02f, 5.05114757e-02f, -9.08465311e-02f, 6.13359474e-02f, 5.83082922e-02f, -1.41489059e-01f,
  -6.63035586e-02f, -1.29645005e-01f, 1.07485102e-03f, -1.28481805e-01f, -1.20755069e-01f, 5.23003452e-02f, -7.80712208e-03f, -5.94758354e-02f, 5.20842932e-02f, 5.90691268e-02f,
  1.90538783e-02f, -4.84346710e-02f, -4.39039199e-03f, 7.13584274e-02f, -9.14167389e-02f, -1.26528032e-02f, 1.00423992e-01f, 5.03508784e-02f, 5.08149602e-02f, -4.55511212e-02f,
  7.21839024e-03f, 8.74678865e-02f, 7.01614395e-02f, -1.45585807e-02f, -4.44007851e-02f, -2.13032626e-02f, 2.03106483e-03f, 2.18195040e-02f, 6.87634274e-02f, -1.33852720e-01f,
  -5.33030145e-02f, -3.57502885e-02f, 3.38481776e-02f, 6.69152737e-02f, 3.55605409e-02f, 9.68956668e-03f, 4.24411632e-02f, -2.73468662e-02f, -7.09274933e-02f, 3.43926288e-02f,
  -7.85841048e-02f, 5.74943284e-03f, -1.42084081e-02f, -1.32526848e-02f, 2.05557123e-02f, -6.09056130e-02f, 1.10038491e-02f, -7.05670752e-03f, 3.90533470e-02f, -1.05425701e-01f,
  3.14722769e-02f, -2.84766965e-02f, 3.91379781e-02f, 2.44663153e-02f, 5.10326475e-02f, 7.69543126e-02f, 7.02545419e-03f, -5.41856103e-02f, -6.63196966e-02f, -1.93910506e-02f,
  3.87988836e-02f, -5.13745546e-02f, -9.00378078e-03f, 6.75803632e-04f, 4.26347973e-03f, -2.27716863e-02f, -5.54326773e-02f, -9.32208002e-02f, -9.58841265e-05f, -4.91473377e-02f,
  -1.31642535e-01f, -1.06656611e-01f, -1.24717867e-02f, 4.80083972e-02f, 6.59529343e-02f, -1.32168725e-01f, 3.99828665e-02f, 2.65784585e-03f, 5.61576970e-02f, -3.84486504e-02f,
  2.33908910e-02f, -3.24744657e-02f, -5.87902963e-02f, 2.41809692e-02f, 3.64027061e-02f, -1.22993484e-01f, 1.13402553e-01f, 1.15031637e-01f, 6.44261241e-02f, -2.85917819e-02f,
  4.17217053e-02f, 2.50788741e-02f, 4.81464155e-02f, 8.13421234e-03f, 9.88184810e-02f, -2.44058166e-02f, 6.77111298e-02f, 5.78569956e-02f, 4.41062860e-02f, -4.95803766e-02f,
  -1.48015246e-01f, 1.95646375e-01f, 2.12246855e-03f, 1.47307068e-01f, -5.37983468e-03f, 7.16188923e-02f, 1.42449617e-01f, 1.10004447e-01f, 1.70704722e-01f, 2.43093848e-01f,
  -2.18542945e-02f, 1.80505067e-01f, 6.14703447e-02f, 2.21051484e-01f, -1.10425398e-01f, 9.09659117e-02f, 2.18774647e-01f, 1.85512155e-01f, 1.00852484e-02f, 1.54819125e-02f,
  -5.64278662e-02f, 2.64519081e-02f, -6.01399876e-02f, -1.41614452e-02f, 3.02812401e-02f, 9.00527835e-03f, -2.05376029e-01f, -1.10641673e-01f, 6.64610863e-02f, 2.52969489e-02f,
  7.18149543e-02f, 2.95108426e-02f, -1.30412821e-02f, -6.28352910e-02f, -7.98470378e-02f, -4.37666960e-02f, -1.13319770e-01f, -1.92858316e-02f, -3.24430782e-03f, -8.09508003e-03f,
  8.68419127e-04f, 3.60076618e-03f, -3.17637995e-03f, -1.43208718e-02f, 3.64823118e-02f, 9.49862506e-03f, 6.37208298e-03f, 8.08909833e-02f, 1.06073931e-01f, 2.57828683e-02f,
  6.72326386e-02f, -2.37929244e-02f, -5.84935350e-03f, 9.82416868e-02f, -5.21622272e-03f, -2.83502806e-02f, 6.74402714e-02f, -2.84771658e-02f, 5.84307089e-02f, 3.55180614e-02f,
  -5.43947853e-02f, -4.63674553e-02f, -3.02492883e-02f, -2.35440172e-02f, -7.18174651e-02f, -5.46851009e-03f, 8.07592869e-02f, -3.60572748e-02f, 9.11412109e-03f, -9.03197192e-03f,
  1.08301640e-02f, 2.90787835e-02f, -2.50182413e-02f, 6.35252148e-02f, 5.92654534e-02f, 3.51728909e-02f, -3.89078557e-02f, -2.47853808e-02f, 4.61115316e-02f, -1.29767451e-02f,
  3.83903622e-03f, 1.11459452e-03f, -2.80296691e-02f, -3.33603695e-02f, 1.60168130e-02f, -1.81420743e-02f, -2.17596721e-02f, 3.60123254e-02f, -1.35109145e-02f, 4.20304685e-04f,
  1.15943640e-01f, 1.55080825e-01f, 1.12275392e-01f, 2.47182343e-02f, -7.38205248e-03f, -2.83281859e-02f, 1.90169681e-02f, 4.81513962e-02f, 7.20043480e-02f, -3.73328738e-02f,
  2.24148133e-03f, -4.69307154e-02f, -6.27646670e-02f, -3.60661596e-02f, -5.36562428e-02f, 4.63105813e-02f, 3.88549529e-02f, -5.16141839e-02f, -9.14452784e-03f, -5.36360033e-02f,
  -2.54749358e-02f, -3.93757187e-02f, -4.08101715e-02f, 2.73582749e-02f, -3.37491073e-02f, -1.27524370e-02f, -2.35312730e-02f, 1.44142378e-02f, -8.29630643e-02f, 9.04520079e-02f,
  -3.57693017e-01f, 1.49713874e-01f, -4.91112769e-02f, -4.02147621e-01f, 5.05005866e-02f, 2.95740608e-02f, -2.07294196e-01f, 7.51932263e-02f, -7.42377192e-02f, 1.69977695e-01f,
  -1.37547150e-01f, -7.58603811e-02f, 9.35195759e-02f, -1.87030017e-01f, -2.09324896e-01f, -1.52344059e-04f, -2.45381474e-01f, -6.71297163e-02f, 1.06663316e-01f, -1.96059570e-01f,
  -1.24544352e-01f, -2.14350864e-01f, -1.01471245e-01f, 1.58883408e-01f, -8.27269629e-02f, 4.25885282e-02f, -1.33498654e-01f, 1.07972145e-01f, -5.87656200e-02f, 6.73551485e-02f,
  6.56955093e-02f, -1.04847014e-01f, -2.55218684e-03f, 6.19916767e-02f, -5.49588911e-02f, -7.65348524e-02f, -5.45440242e-02f, 3.24406214e-02f, -2.76416335e-02f, 1.23085426e-02f,
  -4.06995490e-02f, 7.10553452e-02f, 4.53853756e-02f, -2.01930217e-02f, 3.52406017e-02f, 5.86858951e-02f, 3.49043421e-02f, 2.36435588e-02f, 2.61949003e-02f, 1.12023018e-01f,
  4.13631760e-02f, -5.47437288e-04f, -2.32273471e-02f, 2.73699779e-02f, -4.90878075e-02f, -2.09386125e-02f, 3.04297619e-02f, -2.64579076e-02f, 1.22623695e-02f, -1.75957277e-03f,
  -1.71919782e-02f, 2.42280005e-03f, -1.66282617e-02f, 2.78253574e-02f, -1.52748022e-02f, 4.34066355e-03f, 2.31177378e-02f, 3.45211886e-02f, -4.00038399e-02f, -1.09327747e-03f,
  -3.69629497e-03f, -3.46242785e-02f, 2.24454701e-02f, 2.78687980e-02f, -2.97912154e-02f, -8.12176242e-03f, -4.02043834e-02f, 4.01894860e-02f, -2.07359008e-02f, 1.14221210e-02f,
  6.20853230e-02f, -4.45392095e-02f, -3.38251777e-02f, 2.72437464e-02f, 6.59226105e-02f, -2.02568267e-02f, -5.30656194e-04f, -9.44196898e-03f, -1.07924659e-02f, -3.94993648e-02f,
  -9.75835323e-02f, -8.88827890e-02f, 3.51729169e-02f, 5.18665761e-02f, 6.77511701e-03f, 5.73612526e-02f, 3.83599102e-02f, -4.61450964e-02f, 7.11218314e-03f, 1.29429204e-02f,
  -4.84454120e-03f, -5.58381043e-02f, -4.51597795e-02f, 2.42473260e-02f, 2.12649927e-02f, 2.72537023e-02f, -1.46076888e-01f, -5.94929904e-02f, -1.25713766e-01f, -3.58415805e-02f,
  -7.23299831e-02f, -4.15894762e-03f, -7.23569989e-02f, -5.03140921e-03f, 4.52113450e-02f, -5.41853271e-02f, -4.20374162e-02f, 2.39212438e-02f, -4.34419364e-02f, -1.61714188e-03f,
  -8.17727074e-02f, -1.24839820e-01f, 5.11904899e-03f, 1.44899622e-01f, 1.22576512e-01f, 4.47381847e-02f, -8.30739066e-02f, 6.59084097e-02f, 5.84319606e-02f, -2.34002694e-01f,
  -7.43515491e-02f, -1.09675102e-01f, -1.74148425e-01f, 6.57305196e-02f, 3.32468867e-01f, -6.34092912e-02f, 1.81544200e-01f, -1.06563874e-01f, 1.33818433e-01f, -4.31971848e-02f,
  1.58811912e-01f, 9.19712558e-02f, 8.19099024e-02f, 1.27013177e-01f, 2.01907922e-02f, 5.60703166e-02f, 1.66644216e-01f, -8.44341982e-03f, -1.30617283e-02f, -1.38847791e-02f,
  -4.37286682e-02f, -4.47791517e-02f, -5.92035018e-02f, 3.31591032e-02f, 3.75308879e-02f, -2.33891401e-02f, -3.09149437e-02f, 2.74121836e-02f, 6.69378787e-02f, 3.87684405e-02f,
  -7.50989746e-03f, 6.32461160e-02f, 6.91364706e-02f, 8.12031422e-03f, -2.59532663e-03f, 8.22171047e-02f, 4.02600132e-02f, -8.29992592e-02f, -7.13218302e-02f, -4.92765643e-02f,
  -1.03044271e-01f, 2.20436063e-02f, 3.61092351e-02f, -3.78532782e-02f, 9.10258591e-02f, 8.73338804e-03f, 3.49532254e-02f, -4.88326065e-02f, -2.28602830e-02f, 2.42722500e-02f,
  -1.38559705e-02f, 5.53868897e-02f, -9.03271791e-03f, 2.09349878e-02f, 3.21460888e-02f, 5.47541939e-02f, -9.08183586e-03f, -2.78813243e-02f, 7.57005671e-03f, -8.26263651e-02f,
  4.16268449e-04f, 3.29120159e-02f, 9.35060158e-03f, -3.21179926e-02f, -4.47252467e-02f, -2.41018347e-02f, -3.88231874e-02f, 4.07993421e-02f, 8.18398874e-03f, 1.63015127e-02f,
  -6.28190022e-03f, 3.61371562e-02f, 2.72989515e-02f, -5.91297075e-02f, 6.00269400e-02f, -6.87608719e-02f, 2.66636871e-02f, -1.80360321e-02f, 7.05375150e-02f, -3.76236849e-02f,
  3.70582938e-02f, -2.44414043e-02f, -2.88303196e-03f, 2.32501123e-02f, 3.49104889e-02f, -9.54793952e-03f, -1.84662677e-02f, 1.13369469e-02f, 8.16650167e-02f, -9.83523484e-03f,
  1.92655586e-02f, -3.49467434e-02f, 4.09367010e-02f, 3.39352973e-02f, 7.20264167e-02f, -5.61137721e-02f, -6.26248941e-02f, 7.86899999e-02f, 5.81823476e-02f, 6.16709469e-03f,
  3.40133756e-02f, -1.80595368e-02f, 4.36039083e-02f, -4.57606018e-02f, -7.82546699e-02f, 3.36135142e-02f, -4.63285148e-02f, 2.46346975e-03f, -6.13095239e-02f, 4.31012399e-02f,
  5.10305390e-02f, -1.79498151e-01f, -2.72087276e-01f, 2.50954777e-01f, 3.56865823e-02f, -2.00388834e-01f, -1.42270610e-01f, 1.76873691e-02f, 1.78776477e-02f, 1.06687635e-01f,
  1.54216975e-01f, -4.91946824e-02f, -2.90842533e-01f, 2.01732159e-01f, -2.37596378e-01f, -2.47739226e-01f, 1.22028865e-01f, 9.70962942e-02f, -1.03070728e-01f, 5.84920906e-02f,
  7.51410723e-02f, 2.83086389e-01f, -1.05811983e-01f, 3.84481922e-02f, 8.35186020e-02f, 1.24442555e-01f, 1.82028189e-01f, -1.82241127e-01f, 1.92045048e-01f, -6.99310973e-02f,
  -7.03608394e-02f, 4.25085723e-02f, -1.65298283e-02f, 4.18586805e-02f, -4.60498296e-02f, 4.61353958e-02f, 7.66435936e-02f, -5.58394566e-02f, -4.57745604e-03f, -3.22081707e-02f,
  -2.75760833e-02f, 8.95514432e-03f, 6.36032969e-03f, -3.83546054e-02f, -1.25183463e-02f, -1.14017976e-02f, -1.00776013e-02f, -4.05580737e-03f, -1.35832643e-02f, 5.70353912e-03f,
  -2.63301469e-03f, -1.80465076e-02f, 6.25270456e-02f, 1.33576267e-03f, -4.47165929e-02f, -1.48934405e-02f, -4.59598489e-02f, -7.75002036e-03f, 4.79474440e-02f, 3.00651230e-02f,
  3.87147106e-02f, -2.98702549e-02f, -9.60179884e-03f, 4.16332446e-02f, -6.68780506e-02f, 2.40906384e-02f, -1.86418071e-02f, 1.77217759e-02f, -5.13773859e-02f, 2.79153790e-02f,
  -1.16916036e-03f, -1.69307776e-02f, 3.24124396e-02f, 1.46361953e-03f, 1.21395607e-02f, 1.62161626e-02f, 3.99484150e-02f, 1.98014211e-02f, 7.47690769e-03f, -2.37029009e-02f,
  -8.40622373e-03f, -4.38010916e-02f, -4.63601835e-02f, 1.86756272e-02f, -7.46821389e-02f, -5.37915044e-02f, 8.06224123e-02f, -2.63658091e-02f, -4.58339676e-02f, -1.04137994e-02f,
  5.51221780e-02f, 1.11432537e-01f, -3.99034433e-02f, 2.90701482e-02f, -3.91649306e-02f, 1.06374349e-03f, -5.30964248e-02f, -4.62640747e-02f, -4.91505936e-02f, -5.08889481e-02f,
  5.71722314e-02f, 1.03447229e-01f, 1.18301734e-02f, 4.09078486e-02f, 1.12680309e-02f, -5.07969130e-03f, 6.38369694e-02f, 6.71152994e-02f, 6.26375154e-02f, -1.51062775e-02f,
  9.68615562e-02f, 1.97849032e-02f, -5.78072527e-03f, 8.89368951e-02f, 1.05686292e-01f, 4.97531630e-02f, 3.54872234e-02f, -4.16957540e-03f, 1.29912179e-02f, -9.22238901e-02f,
  -2.39400253e-01f, 1.06774978e-01f, 1.29592836e-01f, -1.25153325e-02f, -2.03043535e-01f, 3.07914227e-01f, 2.20349506e-01f, -1.27129078e-01f, 4.31672707e-02f, 2.23669603e-01f,
  -3.64397354e-02f, 1.21027410e-01f, 1.45496175e-01f, 1.48203284e-01f, 8.06971788e-02f, 2.19343185e-01f, 1.51773781e-01f, 7.42449090e-02f, -3.87347080e-02f, -5.77483028e-02f,
  -1.26304001e-01f, -1.29346162e-01f, 6.90330053e-03f, -1.41706705e-01f, -6.77379370e-02f, -1.69532210e-01f, -1.76407173e-01f, -1.02675650e-02f, 8.29863944e-04f, 4.90176454e-02f,
  -6.28720447e-02f, -1.60050035e-01f, -9.58612189e-02f, 3.26648951e-02f, -2.75936201e-02f, -9.90940630e-03f, 2.98661031e-02f, 3.63577716e-02f, -4.20938581e-02f, -1.19501660e-02f,
  -8.11471324e-03f, -7.94016868e-02f, 2.70985067e-02f, 3.93635221e-02f, -9.95686371e-03f, -5.79581670e-02f, -1.24597698e-02f, -4.16706838e-02f, -2.50005648e-02f, 7.77156139e-03f,
  4.03224789e-02f, 5.14968671e-02f, 7.19053149e-02f, 5.16312718e-02f, 6.08224533e-02f, 9.12155863e-03f, 1.29151084e-02f, 5.50374165e-02f, 1.52744399e-02f, -8.17664992e-03f,
  -6.50612265e-02f, 5.95128946e-02f, -4.35406668e-03f, -8.48987233e-03f, 7.92027079e-03f, -8.22686478e-02f, 2.57253852e-02f, -4.50386200e-04f, 1.57619398e-02f, 1.69986170e-02f,
  -4.30424698e-02f, 2.65811905e-02f, -8.02947730e-02f, 5.45046516e-02f, -9.04694200e-03f, -6.15093112e-02f, 4.24737372e-02f, -6.03504591e-02f, 1.67988781e-02f, 1.59156416e-02f,
  1.01520708e-02f, 2.28134319e-02f, 3.29291075e-02f, -3.08750886e-02f, -2.45983135e-02f, -2.15351339e-02f, 9.09094606e-03f, -8.44175275e-03f, 2.91924085e-02f, -1.88494232e-02f,
  -5.84104508e-02f, -1.23959064e-01f, -6.36694431e-02f, -2.33050324e-02f, -4.62278444e-03f, -3.20371091e-02f, 4.62067872e-02f, -1.45287737e-02f, 7.56696314e-02f, -1.02672242e-02f,
  -6.72504655e-04f, 3.01024914e-02f, -4.36366275e-02f, 6.72614435e-03f, 9.20610875e-03f, -4.65418734e-02f, 1.41124325e-02f, 3.32403220e-02f, 5.60461581e-02f, 5.03038336e-03f,
  -9.21470951e-03f, -4.37257402e-02f, 9.00948513e-03f, -3.82664055e-02f, -5.58384061e-02f, -6.17891327e-02f, -2.42616832e-02f, 2.86946837e-02f, 1.96031258e-02f, 8.37385505e-02f,
  -5.27698576e-01f, 1.16140798e-01f, -3.00417910e-03f, -2.15480536e-01f, -5.29854335e-02f, -8.24003220e-02f, 4.38158214e-02f, -3.22021134e-02f, -1.10211223e-01f, 5.15652671e-02f,
  1.14395902e-01f, -9.31693390e-02f, 2.16943935e-01f, 9.70081985e-02f, -4.62153181e-02f, 2.83157110e-01f, -5.37594222e-02f, 3.84952649e-02f, 2.71157194e-02f, -4.70804498e-02f,
  -5.36223873e-02f, 1.52090073e-01f, 7.24813789e-02f, 1.50874227e-01f, -1.80145532e-01f, -1.44338876e-01f, 3.76525382e-03f, 1.05585441e-01f, -4.57905531e-02f, 1.07261270e-01f,
  -1.55311450e-01f, -1.66998968e-01f, 1.76992326e-03f, -9.31443796e-02f, 7.75604695e-03f, -6.89012781e-02f, -2.62551904e-02f, 3.69383469e-02f, 4.46153171e-02f, -2.36305501e-02f,
  -2.02754363e-02f, -2.38184538e-02f, 1.24779474e-02f, 7.40670180e-03f, -1.07837163e-01f, 1.58837419e-02f, -5.61273322e-02f, 1.90192070e-02f, -3.53968479e-02f, -7.18784146e-03f,
  1.05789658e-02f, 2.82103699e-02f, 2.49231942e-02f, -2.44437214e-02f, 4.15654890e-02f, -1.82367861e-02f, -2.45160181e-02f, 3.19357440e-02f, -7.89408907e-02f, -3.05056833e-02f,
  -4.92963120e-02f, -4.55532782e-02f, 6.02649413e-02f, -1.37479678e-02f, 3.17142531e-02f, 5.33177666e-02f, 3.60322744e-02f, 2.95625031e-02f, 7.58737000e-03f, -2.33385526e-02f,
  -6.36239275e-02f, -4.89172004e-02f, -1.33627653e-02f, -4.75951321e-02f, -3.97498421e-02f, -4.84800339e-02f, 4.37097549e-02f, -2.76787760e-04f, -1.13726417e-02f, -2.15303879e-02f,
  -5.55526698e-03f, 2.59654187e-02f, -1.68055063e-03f, 4.84297983e-02f, -2.25103591e-02f, -2.95407660e-02f, 9.25252307e-03f, -5.88110723e-02f, 3.78403775e-02f, -6.90355059e-03f,
  -1.36619240e-01f, -8.15265328e-02f, 3.02194171e-02f, 1.91594511e-02f, 5.99626964e-03f, -7.70419836e-03f, 2.37177480e-02f, -3.77188697e-02f, 4.21966892e-03f, 7.33553572e-03f,
  6.57402503e-04f, -5.19922115e-02f, -3.03201750e-02f, -2.38474123e-02f, -2.63461639e-04f, -5.06227538e-02f, -1.13270176e-03f, 1.04288885e-03f, -3.63733955e-02f, 1.03991283e-02f,
  4.46815193e-02f, -5.29779419e-02f, -7.80064613e-03f, -7.51293600e-02f, -7.50867054e-02f, -5.16766049e-02f, 3.70280514e-03f, 5.33068599e-03f, -1.21589592e-02f, -4.10991814e-03f,
  6.08180128e-02f, -2.51180142e-01f, -1.84979931e-01f, -1.28415242e-01f, 2.05620766e-01f, 8.05896595e-02f, 1.72796175e-01f, 4.73660640e-02f, 8.51688981e-02f, -3.65574728e-03f,
  4.55842353e-02f, -2.64161408e-01f, -2.93910559e-02f, -2.03976661e-01f, 3.07189096e-02f, 4.59522847e-03f, -6.20701201e-02f, 3.50622348e-02f, -4.98652533e-02f, -4.30833828e-03f,
  2.31055114e-02f, -7.86397234e-02f, -1.82328761e-01f, -1.94186270e-02f, -3.46670090e-03f, -1.03840284e-01f, 9.09034833e-02f, -6.11044690e-02f, -1.94411948e-01f, -7.94393718e-02f,
  -1.12587184e-01f, 2.43442375e-02f, 3.69967297e-02f, -7.15824142e-02f, 1.51113272e-01f, 1.28070608e-01f, -3.59680280e-02f, -6.69922903e-02f, -2.43099406e-02f, -5.31579778e-02f,
  -2.03771908e-02f, 3.13990898e-02f, -5.82685843e-02f, 7.06093851e-03f, 6.85689077e-02f, 1.28077064e-02f, -8.45298842e-02f, 2.10528169e-02f, -7.92531297e-02f, -3.38705368e-02f,
  -6.14939332e-02f, -3.45598273e-02f, 6.09336160e-02f, 4.20880970e-03f, 2.72973645e-02f, -3.38180596e-03f, 5.65008149e-02f, -5.16746901e-02f, -7.56519660e-02f, -6.08343370e-02f,
  6.03806563e-02f, 9.53585729e-02f, -4.37298268e-02f, -2.37289723e-02f, -3.89703698e-02f, 4.23295163e-02f, -4.43203188e-02f, -4.72303480e-03f, -1.43471789e-02f, 6.94386708e-03f,
  5.10551892e-02f, 5.55073051e-03f, -3.56659144e-02f, 1.02079816e-01f, 6.94774184e-03f, 5.52263930e-02f, 2.18593217e-02f, 4.22487892e-02f, 9.64465886e-02f, -3.12510505e-03f,
  8.78791884e-03f, -4.60414961e-03f, -7.25065246e-02f, -3.08899339e-02f, -4.83320132e-02f, -3.14607173e-02f, 2.26977933e-02f, -1.09928151e-04f, 3.70959900e-02f, 9.54841450e-03f,
  1.58511445e-01f, 8.53204355e-02f, -7.76137337e-02f, -8.39657634e-02f, -1.20373704e-02f, 3.93729955e-02f, 7.83002377e-03f, -1.23987906e-02f, -1.29359663e-02f, 5.14425412e-02f,
  1.26915574e-01f, 2.17271829e-03f, 7.65922740e-02f, 2.75614988e-02f, -3.28967012e-02f, -4.87041585e-02f, 7.85873085e-03f, -4.82492968e-02f, 5.83158433e-02f, 1.87959254e-03f,
  5.12190014e-02f, 1.03397764e-01f, 1.10996254e-02f, 4.46160249e-02f, -7.43970051e-02f, 5.17954528e-02f, 3.42466757e-02f, 9.98615474e-03f, 2.77522542e-02f, 4.22281474e-02f,
  -1.56721789e-02f, -3.07588100e-01f, -1.12432931e-02f, 4.22139764e-02f, -6.99685439e-02f, 1.66421160e-02f, -1.60875320e-02f, -1.86990604e-01f, -1.21999159e-01f, -1.08016156e-01f,
  -2.92836986e-02f, -4.83602146e-03f, 1.02091301e-02f, 1.49063334e-01f, 2.24650353e-01f, 1.06271021e-01f, 1.13373481e-01f, 4.15427424e-02f, -1.30208522e-01f, -9.66056734e-02f,
  3.55364494e-02f, 7.76136592e-02f, 2.73534268e-01f, -4.53668199e-02f, 8.25540274e-02f, -1.35278866e-01f, 1.08282842e-01f, -1.25445828e-01f, 1.12274364e-01f, 4.32174467e-02f,
  -6.52138069e-02f, -1.47010148e-01f, -6.73416909e-03f, -1.74615737e-02f, 2.05083862e-02f, -4.42212559e-02f, -2.85366885e-02f, 1.66238341e-02f, -8.55616108e-03f, -1.40720038e-02f,
  4.69164830e-03f, -3.44750658e-02f, -5.31738661e-02f, 6.22769296e-02f, -2.16528717e-02f, 1.62811950e-03f, 8.22454840e-02f, -1.75641142e-02f, -3.26752141e-02f, 3.51466462e-02f,
  5.82035407e-02f, 6.16981499e-02f, -4.46527079e-02f, 3.98236960e-02f, -3.17987055e-02f, -4.96298149e-02f, -3.71087976e-02f, 6.03764169e-02f, -2.43098512e-02f, 1.33367721e-02f,
  -1.22803301e-02f, -4.24321964e-02f, 3.11569329e-02f, 2.36138776e-02f, 3.97605414e-04f, 5.77104231e-03f, 6.03609160e-02f, 4.89101931e-02f, -2.05511749e-02f, -6.25518337e-02f,
  3.62863578e-02f, -2.08901558e-02f, 2.27370812e-03f, 3.50179002e-02f, 3.53716500e-02f, -2.16826443e-02f, 3.12898774e-03f, -2.28767451e-02f, 2.14601811e-02f, 8.74115825e-02f,
  -5.28517291e-02f, -4.45883088e-02f, 4.30116095e-02f, -1.55556772e-03f, 4.18049283e-02f, -1.31425187e-02f, -9.29505285e-03f, -5.60157448e-02f, 2.01545749e-02f, 2.35925503e-02f,
  -3.37210268e-01f, -4.12133425e-01f, 9.26526822e-03f, -6.00387901e-02f, -1.42129231e-02f, 6.11980446e-02f, 1.26881488e-02f, -6.47069290e-02f, -1.57289639e-01f, -2.03056335e-02f,
  -2.41473317e-02f, 3.44437063e-02f, -3.13864648e-03f, -4.71578389e-02f, 2.53606141e-02f, -1.14765447e-02f, -2.02099606e-02f, 1.49257369e-02f, -7.53319189e-02f, -2.11498551e-02f,
  8.16329848e-03f, -1.38477841e-02f, 7.78988004e-02f, -5.25743328e-02f, -3.99292447e-02f, 8.93338118e-03f, -1.32639529e-02f, -2.24174876e-02f, 9.41972435e-03f, 1.57180540e-02f,
  2.69982070e-01f, 5.34230843e-03f, 9.89940092e-02f, 5.92597947e-02f, 3.71607766e-02f, 2.17879757e-01f, 2.08174676e-01f, 3.60228517e-03f, 1.20621808e-01f, -6.81363121e-02f,
  -3.28034125e-02f, 1.79615051e-01f, 9.57356989e-02f, 2.18077358e-02f, 3.14902365e-01f, 1.02936909e-01f, 1.00194439e-01f, 9.47037637e-02f, -3.64855565e-02f, 1.66978315e-01f,
  8.57565999e-02f, -5.78186214e-02f, 5.67639656e-02f, -1.88729838e-01f, -6.91071674e-02f, -1.74099267e-01f, -1.07037477e-01f, -2.26477981e-02f, -8.67100358e-02f, -4.06404957e-02f,
  1.94962859e-01f, -2.14118510e-02f, -2.75126472e-02f, -4.14989144e-03f, -2.83326041e-02f, 3.02262511e-02f, 4.87734377e-02f, 2.90153492e-02f, -5.53786419e-02f, 6.97838366e-02f,
  -1.95222441e-02f, -8.52561276e-03f, 5.60990497e-02f, -2.56078020e-02f, 5.69927059e-02f, 4.82421368e-03f, 3.90010178e-02f, -3.33451964e-02f, -3.49383019e-02f, 3.74405161e-02f,
  -4.01987918e-02f, 3.10396142e-02f, -4.16860692e-02f, -3.39523926e-02f, -4.38056700e-03f, -1.45806903e-02f, 2.13651937e-02f, 7.31500750e-03f, 5.56288473e-02f, 1.10943289e-02f,
  -2.13014707e-02f, -7.21017122e-02f, 4.15961035e-02f, -7.67035857e-02f, 5.03439941e-02f, 5.57359904e-02f, -1.75045636e-02f, -3.67679559e-02f, 1.16224010e-02f, -4.52189818e-02f,
  4.37159203e-02f, -6.90746233e-02f, -4.99111414e-02f, 4.07322198e-02f, -7.63057619e-02f, 3.52484100e-02f, 4.37061489e-02f, 1.31610287e-02f, -4.01530750e-02f, 5.73726790e-03f,
  -9.79515072e-03f, 1.42142344e-02f, -7.50648230e-03f, -2.19155308e-02f, -2.37075780e-02f, 1.57295987e-02f, 3.34694306e-03f, 4.45816070e-02f, -4.58904430e-02f, 5.68546280e-02f,
  2.34021485e-01f, 1.60201281e-01f, -1.78022543e-04f, 5.56399263e-02f, 5.75293787e-02f, -4.85603623e-02f, -4.42003123e-02f, 2.84745190e-02f, 1.16695732e-01f, 2.88178828e-02f,
  -2.20560506e-02f, 9.61356051e-03f, 6.79801311e-03f, -2.20503565e-02f, -7.07984269e-02f, 6.99480325e-02f, -1.07815024e-02f, 3.35382367e-03f, -2.87813861e-02f, -3.23224142e-02f,
  -5.90266241e-03f, -1.18018081e-02f, -7.58864731e-02f, -7.85453096e-02f, 1.88946687e-02f, -2.07532831e-02f, -3.50303538e-02f, -1.47217708e-02f, -6.24503493e-02f, 6.89575588e-03f,
  9.50334743e-02f, -3.13343823e-01f, -2.96714664e-01f, -9.91743132e-02f, 4.74900566e-02f, 1.12504296e-01f, 1.04414873e-01f, -1.33706778e-01f, -2.37921387e-01f, -1.65425897e-01f,
  1.74919412e-01f, -7.14215562e-02f, -3.08473501e-02f, 6.22351561e-03f, 3.18324566e-01f, 7.61299357e-02f, 8.56640562e-02f, 4.85117994e-02f, -1.99718159e-02f, 9.43620279e-02f,
  8.02100301e-02f, 2.63250768e-01f, 1.15090787e-01f, -9.67426877e-03f, 9.80854779e-02f, -9.54685137e-02f, 2.35670775e-01f, 8.09316896e-03f, 3.30162235e-02f, 7.39137679e-02f,
  5.29516228e-02f, -1.27317697e-01f, -6.01328947e-02f, -1.10185385e-01f, -7.35752331e-03f, 5.37642883e-03f, 1.59309246e-02f, 1.97375077e-03f, 8.61883443e-03f, -7.79576227e-02f,
  2.60768719e-02f, -2.02910863e-02f, -2.97334492e-02f, -3.43478322e-02f, -9.96844769e-02f, -2.70597171e-02f, -1.57769863e-02f, -4.79019210e-02f, -1.08649574e-01f, -8.93475115e-02f,
  -3.75669822e-02f, -7.60024190e-02f, -5.84817901e-02f, -3.05027347e-02f, 1.15443105e-02f, -1.19374052e-01f, -1.37514919e-02f, 3.35101187e-02f, -4.53746505e-02f, -5.13299629e-02f,
  1.68218073e-02f, 2.94361599e-02f, 1.39833251e-02f, -3.96112502e-02f, 4.36459780e-02f, -1.79497823e-02f, 1.49882706e-02f, 6.18640445e-02f, 2.47447137e-02f, -1.16393585e-02f,
  -3.74527015e-02f, 5.24610607e-03f, 2.83120424e-02f, -4.46243882e-02f, 1.41318999e-02f, -4.67456914e-02f, -9.88391973e-03f, -8.45623761e-03f, -3.36428806e-02f, 8.36526304e-02f,
  8.38571414e-02f, 8.95011425e-03f, -3.18204127e-02f, -3.09020150e-02f, 2.88880877e-02f, -6.41337130e-03f, -9.07328818e-03f, -1.00837395e-01f, -1.81008503e-02f, 9.30689275e-02f,
  5.28179482e-02f, 7.37676173e-02f, 2.18413919e-02f, -2.90493630e-02f, 5.65574989e-02f, 8.47169459e-02f, 1.93494651e-02f, -3.69501188e-02f, -6.82254555e-03f, 1.67797953e-02f,
  -3.08576282e-02f, 1.25710238e-02f, -9.76660103e-03f, -7.68408412e-04f, 6.35974035e-02f, -8.45235493e-03f, 1.04241278e-02f, -1.20828031e-02f, 8.48273411e-02f, 8.40755478e-02f,
  2.68340688e-02f, -8.83691665e-03f, -1.69830639e-02f, -3.77482325e-02f, 4.75020595e-02f, 6.95619732e-02f, 2.13249549e-02f, -8.59224796e-02f, 7.91554451e-02f, 4.16342132e-02f,
  8.47424716e-02f, -6.29285499e-02f, 1.97703212e-01f, 8.80349651e-02f, 8.90918374e-02f, 6.39500767e-02f, -6.42949417e-02f, 1.15441587e-02f, -8.17077309e-02f, -2.61515111e-01f,
  -1.27606779e-01f, 1.48595333e-01f, -1.94419265e-01f, -1.40809193e-01f, 2.49215424e-01f, -2.31342137e-01f, -5.35042137e-02f, -1.28217060e-02f, -2.87526613e-03f, 9.52924713e-02f,
  1.08053207e-01f, -5.92114702e-02f, 1.55033946e-01f, -3.75216007e-02f, 8.40875283e-02f, 1.21841088e-01f, 6.31768256e-02f, 1.48495659e-01f, 7.27776587e-02f, 8.10000449e-02f,
  -6.63541779e-02f, -3.12347393e-02f, 2.05639731e-02f, 6.54221997e-02f, 1.02518246e-01f, 4.84360009e-02f, 1.67916878e-04f, 2.11090650e-02f, 3.73175479e-02f, 1.03798151e-01f,
  2.97915433e-02f, 1.68194734e-02f, 5.07448688e-02f, 2.27207933e-02f, 8.62051621e-02f, 8.51145163e-02f, 4.07502912e-02f, 6.96035922e-02f, 5.46994358e-02f, 6.62488267e-02f,
  4.53094840e-02f, 6.12787493e-02f, 7.19046295e-02f, 4.58308198e-02f, 4.89100218e-02f, -3.13119702e-02f, 3.26058939e-02f, 1.13076083e-01f, 3.63911539e-02f, 6.06857706e-03f,
  2.22302461e-03f, 2.70128492e-02f, -7.43169570e-03f, -6.16407506e-02f, -5.96780479e-02f, -5.51066846e-02f, 3.60744521e-02f, 3.80792543e-02f, 7.69953663e-03f, 1.24392929e-02f,
  1.21712303e-02f, -3.61613594e-02f, -1.35368071e-02f, 4.04310003e-02f, -1.07393796e-02f, -5.96437752e-02f, 5.19982912e-02f, -2.59517264e-02f, 4.57955524e-02f, -3.06136049e-02f,
  -6.70181662e-02f, 1.85404699e-02f, -2.12059226e-02f, -4.36691456e-02f, -1.95626896e-02f, 3.45985917e-03f, 4.52366583e-02f, -3.49028371e-02f, -1.77400764e-02f, -1.42332288e-02f,
  -5.38465977e-02f, -1.16221271e-02f, -9.88870263e-02f, -4.28361595e-02f, -9.67724100e-02f, -3.81967449e-03f, 4.62001786e-02f, -2.52818149e-02f, 2.67048087e-03f, -1.47866160e-02f,
  5.44165540e-03f, -5.52084893e-02f, -2.25003175e-02f, 9.70163662e-03f, -4.28146161e-02f, -6.24873191e-02f, -5.21798339e-03f, -4.61664312e-02f, 8.76399204e-02f, -1.69666596e-02f,
  4.32878509e-02f, -8.55335221e-02f, 4.97191995e-02f, 1.51588051e-02f, 1.48536777e-02f, -3.80394422e-02f, 3.67106050e-02f, 9.22266394e-03f, -2.79000401e-02f, 7.71516785e-02f,
  -2.35572755e-02f, 5.71878329e-02f, 3.09087545e-01f, 2.05072924e-01f, -2.81911884e-02f, -2.83531487e-01f, -7.67071024e-02f, -4.79935259e-02f, -3.61498408e-02f, -1.69889942e-01f,
  -5.46024330e-02f, 2.25634858e-01f, -1.94165632e-02f, 7.01319287e-03f, -4.24895845e-02f, -7.10258782e-02f, -1.04351372e-01f, -3.69819067e-02f, 3.99197936e-02f, 5.93903940e-03f,
  -4.20770608e-03f, -1.81681216e-01f, 1.47117212e-01f, -7.29591995e-02f, 4.79403278e-03f, 1.89415023e-01f, -8.06765333e-02f, 1.21332563e-01f, 4.06845659e-02f, -2.31552608e-02f,
  -4.48877290e-02f, 7.79709220e-02f, 9.38826650e-02f, -4.43089679e-02f, -1.10757828e-01f, -2.53174305e-02f, -2.34170370e-02f, -3.85948308e-02f, 1.06522068e-01f, -3.62770855e-02f,
  -1.49738905e-03f, -1.86159685e-02f, 4.76311520e-02f, 2.56627682e-04f, -4.81819548e-02f, 3.14428546e-02f, -5.20843528e-02f, -9.98538639e-03f, 8.56527239e-02f, 7.55597726e-02f,
  -1.49050436e-03f, 1.48193818e-02f, 5.48475981e-02f, -4.27891761e-02f, 4.53905724e-02f, -5.19970991e-03f, -2.75644870e-03f, -4.35848162e-02f, -1.14713706e-01f, 1.42132370e-02f,
  5.30453622e-02f, 3.14274640e-03f, -6.49221912e-02f, -2.07674857e-02f, -9.35206115e-02f, 2.14667004e-02f, -5.81302643e-02f, -5.44074513e-02f, -2.84625739e-02f, -9.38285328e-03f,
  -1.13228261e-02f, -1.41574489e-02f, -7.43336305e-02f, 2.26013735e-02f, -3.24300304e-02f, 3.57930958e-02f, -2.17485800e-02f, -2.15289779e-02f, 7.10833222e-02f, 6.63323998e-02f,
  8.44007954e-02f, -4.45720516e-02f, 1.79273747e-02f, -2.99918894e-02f, 1.02196606e-02f, -4.98408526e-02f, -4.86370660e-02f, -1.22398082e-02f, 5.04932180e-02f, -2.81390436e-02f,
  -1.34029493e-01f, 2.90228520e-02f, -4.57762852e-02f, -6.80029318e-02f, 2.56974585e-02f, -3.02404128e-02f, -4.84797545e-02f, 7.56327584e-02f, -5.50489053e-02f, -7.21567124e-02f,
  1.13355573e-02f, -3.07889450e-02f, -6.44303560e-02f, -4.02876316e-03f, 5.81082217e-02f, -2.26971656e-02f, 3.56448218e-02f, 5.22949696e-02f, -4.76231016e-02f, 2.23136526e-02f,
  3.90606895e-02f, -6.29134253e-02f, -4.21533734e-02f, -3.65419537e-02f, 1.40865119e-02f, -8.39671120e-03f, -1.34752411e-02f, 8.99333805e-02f, -1.06611010e-02f, 2.85147056e-02f,
  1.06144518e-01f, -7.22085498e-03f, 1.13158353e-01f, -2.84249187e-02f, 1.61667988e-01f, 8.67960751e-02f, -1.07987970e-01f, 2.09834740e-01f, 1.92686051e-01f, -2.78150976e-01f,
  -1.23930149e-01f, -2.14509536e-02f, -6.84805214e-02f, -2.24130958e-01f, 1.27131209e-01f, 1.26339987e-01f, -2.08782908e-02f, -1.56915650e-01f, 1.48498833e-01f, 5.96574619e-02f,
  1.11469299e-01f, -2.31466576e-01f, 5.25153764e-02f, -1.67548433e-02f, -1.64439890e-03f, 7.96774626e-02f, -1.61321819e-01f, 2.28137113e-02f, -1.34331837e-01f, -2.97443452e-03f,
  -3.84062678e-02f, 1.63127054e-02f, -4.30000089e-02f, 6.95045814e-02f, -3.59971263e-02f, 5.11226058e-02f, -1.70459375e-02f, 9.89353843e-03f, -2.20567975e-02f, -3.25752869e-02f,
  -1.07934892e-01f, -4.09499779e-02f, -4.44978327e-02f, -3.71738411e-02f, 7.98701495e-02f, -7.70767033e-02f, 4.66932841e-02f, -2.41451208e-02f, -7.24834204e-02f, 5.27445897e-02f,
  7.16757029e-02f, -7.55792204e-03f, 6.09883778e-02f, 1.79603137e-02f, 7.04818740e-02f, -3.85487527e-02f, 4.28218246e-02f, 5.13848662e-02f, -1.52758658e-02f, -8.71381443e-03f,
  2.34866142e-03f, 5.36120757e-02f, -3.81861180e-02f, 3.60130370e-02f, 5.89408986e-02f, -1.99833587e-02f, 5.87474043e-03f, 1.37700997e-02f, 5.21788634e-02f, -1.91989299e-02f,
  4.92424890e-02f, -1.78204700e-02f, 1.02475829e-01f, -1.49672143e-02f, 2.68333424e-02f, 1.30864596e-02f, 3.31936893e-03f, -1.18710473e-03f, 7.98371434e-02f, 3.63598876e-02f,
  2.81638769e-03f, -1.10574635e-02f, 1.85803566e-02f, -7.47329071e-02f, 1.68605465e-02f, -3.48256193e-02f, -6.48077205e-02f, -6.34194240e-02f, -3.03839613e-02f, -7.30836317e-02f,
  1.12288706e-01f, 8.64624158e-02f, 3.64432186e-02f, 3.87800336e-02f, -1.82013456e-02f, -6.69558570e-02f, -2.21527871e-02f, -3.86868231e-02f, 1.03461944e-01f, 5.88487312e-02f,
  3.69245298e-02f, -7.72607103e-02f, -5.79383038e-02f, 3.33465673e-02f, 4.24800403e-02f, -3.60049531e-02f, -5.35374731e-02f, -3.25786956e-02f, 1.31316052e-03f, -3.06392610e-02f,
  -9.48684588e-02f, -8.00294429e-02f, -2.56190747e-02f, 1.20248692e-02f, 2.33988501e-02f, -3.98347825e-02f, -5.07355630e-02f, 3.85912247e-02f, 2.89455652e-02f, 5.59416320e-03f,
  1.91996485e-01f, 9.53489840e-02f, 4.60962579e-02f, 1.60663664e-01f, -2.17288490e-02f, -2.26771444e-01f, -3.08413297e-01f, 8.46474171e-02f, 1.27383128e-01f, -1.40853658e-01f,
  -1.56555772e-01f, 1.62104234e-01f, -1.89451307e-01f, -4.85379770e-02f, -1.23165444e-01f, -9.64846835e-02f, -2.38615237e-02f, -3.52828205e-02f, 8.19457397e-02f, 1.08995117e-01f,
  7.29134530e-02f, -3.93684879e-02f, 4.33916152e-02f, 7.68624991e-02f, -1.22625716e-02f, 1.28157824e-01f, 5.37323318e-02f, -1.10955246e-01f, 1.52695626e-01f, -6.07676208e-02f,
  -9.51848403e-02f, 1.28202029e-02f, 2.78454740e-02f, 5.50510585e-02f, 5.13614342e-02f, -2.23075282e-02f, -3.18570361e-02f, -4.12336327e-02f, 7.93239176e-02f, -1.45125401e-03f,
  6.70024427e-03f, 1.93172004e-02f, 1.97953731e-02f, -2.50269584e-02f, 1.86105855e-02f, 3.53179574e-02f, 9.82625335e-02f, 6.34226277e-02f, 6.43950999e-02f, -4.91854809e-02f,
  -6.93180934e-02f, 3.47495228e-02f, 7.31747076e-02f, 8.51587132e-02f, 7.44916573e-02f, -3.70827802e-02f, 2.38540508e-02f, -2.19877735e-02f, 9.34716538e-02f, 5.60864396e-02f,
  -5.65032614e-03f, -9.34113935e-03f, -3.60850878e-02f, 2.68159695e-02f, 6.28087344e-03f, 7.77803808e-02f, -4.27537933e-02f, 1.46827074e-02f, 3.86402644e-02f, -3.76149788e-02f,
  4.13273238e-02f, 5.86513765e-02f, -6.02272078e-02f, 7.53011601e-03f, 9.94917355e-04f, -4.91530225e-02f, -2.05395650e-02f, -3.20794284e-02f, 3.61462906e-02f, 9.46820676e-02f,
  -1.34204794e-03f, -4.60261516e-02f, 1.29978312e-02f, 4.18795533e-02f, -1.03094943e-01f, 2.74851285e-02f, 3.88758965e-02f, -1.80070326e-02f, -2.95401961e-02f, 3.70451733e-02f,
  -3.35639082e-02f, 1.08170316e-01f, 2.74368059e-02f, -6.13332503e-02f, -3.10037043e-02f, 1.58291515e-02f, -3.23616378e-02f, 1.01486649e-02f, 2.99952347e-02f, -1.30140437e-02f,
  6.54004738e-02f, 5.80287166e-02f, 3.91359515e-02f, -5.49242832e-02f, 6.41195476e-03f, -1.56003982e-02f, -8.70120674e-02f, 4.50183041e-02f, 2.02151667e-02f, 3.80401611e-02f,
  5.78651354e-02f, 3.16320360e-02f, -6.32172823e-02f, -5.85954376e-02f, -5.16032204e-02f, -1.73875841e-03f, -1.59783680e-02f, -9.80466884e-03f, -1.60702225e-02f, 1.41678415e-02f,
  1.59176081e-01f, 1.68089345e-01f, 1.13495765e-02f, 1.08239725e-01f, -1.75177068e-01f, -6.55646026e-02f, -7.00987503e-02f, 7.16709346e-02f, 3.32428455e-01f, 7.08803982e-02f,
  -1.25796810e-01f, 8.81935880e-02f, -2.29480825e-02f, -4.95228842e-02f, 1.72442749e-01f, 1.84518784e-01f, 1.70469612e-01f, 1.92669872e-02f, 1.04956590e-01f, 7.78949214e-03f,
  1.12367883e-01f, -3.38855125e-02f, 4.26807180e-02f, -1.64019838e-01f, -1.23203985e-01f, 1.56267472e-02f, -8.36668909e-02f, -8.19806084e-02f, -4.81620952e-02f, -1.11042708e-01f,
  -1.29871517e-01f, 1.36417598e-01f, -2.41971221e-02f, 3.54168029e-03f, 7.63970315e-02f, -9.35253054e-02f, -1.08572692e-02f, -1.13890946e-01f, -4.58952785e-02f, 2.68737730e-02f,
  -8.12146962e-02f, 1.66134816e-02f, -7.95134623e-03f, -5.04422449e-02f, 2.75318902e-02f, -1.61069147e-02f, -1.06354663e-02f, -8.78275782e-02f, 2.18000226e-02f, 4.36329171e-02f,
  1.44088790e-02f, -7.45413825e-02f, -3.33880857e-02f, 5.21789975e-02f, -4.61531915e-02f, -6.21168949e-02f, -3.02856285e-02f, 6.21220097e-03f, 8.67082551e-03f, 5.34472652e-02f,
  6.26270287e-03f, -1.46818170e-02f, -1.17011629e-02f, -1.03856530e-02f, 1.89124923e-02f, -9.14142579e-02f, 2.55376995e-02f, 2.15615202e-02f, -4.03165072e-02f, 4.50860709e-02f,
  -4.91614267e-02f, 1.09816308e-03f, 5.43041937e-02f, -1.84567999e-02f, 7.73033351e-02f, -5.45410346e-03f, -4.72397991e-02f, -2.94968840e-02f, 1.19438142e-01f, -5.67696579e-02f,
  8.15080013e-03f, -6.81110322e-02f, -4.96209450e-02f, -3.72353829e-02f, -9.97809134e-03f, -6.24645017e-02f, 2.60475781e-02f, 3.75963673e-02f, -5.39792217e-02f, -6.05202839e-02f,
  1.09886499e-02f, 2.53805906e-01f, -3.49347480e-02f, -6.26285523e-02f, 1.23063857e-02f, -1.61199626e-02f, 3.43876705e-02f, 8.33457410e-02f, 3.83137949e-02f, 4.72605452e-02f,
  -1.43050291e-02f, 2.78193131e-02f, 2.40289625e-02f, 6.72405809e-02f, -2.14239359e-02f, 8.60536247e-02f, 1.72718652e-02f, 5.71954958e-02f, -1.22456783e-02f, -2.73898095e-02f,
  -8.09719637e-02f, -3.83734144e-03f, 4.67494093e-02f, 5.17889448e-02f, -6.20988235e-02f, 5.00520766e-02f, 3.04624457e-02f, 1.67217031e-02f, 3.41945402e-02f, -3.83101124e-03f,
  -1.84160680e-01f, -2.60353666e-02f, 1.97891593e-01f, -6.63365573e-02f, 3.80103998e-02f, -2.81028718e-01f, -3.17548811e-01f, 9.80585814e-02f, -8.23876075e-03f, -1.17339455e-01f,
  -1.38186350e-01f, 1.46270826e-01f, 2.41463333e-02f, -2.21293032e-01f, -1.07740000e-01f, -1.28948735e-02f, -2.90643126e-01f, -1.69618100e-01f, 7.93276653e-02f, -9.32102054e-02f,
  6.51652738e-02f, -2.72061229e-01f, 4.09953333e-02f, 1.88181605e-02f, -1.33275911e-01f, 1.78096399e-01f, 4.24025059e-02f, 4.19681817e-02f, -9.83472541e-02f, -1.67485140e-02f,
  3.49822314e-03f, 2.41790097e-02f, 2.61478610e-02f, -6.08298630e-02f, -4.68546934e-02f, -8.51850584e-02f, -3.65048572e-02f, 1.30894687e-02f, 1.32932076e-02f, -3.17652039e-02f,
  -4.06605043e-02f, -4.70124977e-03f, -2.46142298e-02f, -5.14707267e-02f, 1.18905157e-02f, 1.66476481e-02f, 5.61222881e-02f, 6.94002211e-02f, -2.02010609e-02f, 1.62044838e-02f,
  2.23719794e-02f, -9.25536174e-03f, -2.58142836e-02f, -1.56187767e-03f, 3.28139262e-03f, 1.35756861e-02f, -5.21680049e-04f, -3.54126841e-02f, 1.45805059e-02f, -1.14701521e-02f,
  2.57730167e-02f, -2.05930807e-02f, -5.90185858e-02f, -7.68598318e-02f, -3.71442288e-02f, -9.35794692e-03f, 5.92968501e-02f, -4.20989841e-02f, 2.19017919e-03f, -5.00427149e-02f,
  -4.69834637e-03f, -4.98346228e-04f, -2.25335862e-02f, -3.63176432e-03f, -3.06091458e-02f, 1.30831199e-02f, 2.04737633e-02f, -3.37615572e-02f, 4.38011624e-02f, 2.55823079e-02f,
  -5.44593073e-02f, 1.97797790e-02f, -2.18778923e-02f, -3.27160731e-02f, -4.78138886e-02f, -4.48341370e-02f, -3.04031465e-02f, 1.63567271e-02f, 4.07396816e-02f, -6.57932013e-02f,
  3.34466808e-02f, -7.29857907e-02f, -1.18711656e-02f, 6.16263188e-02f, 8.77665058e-02f, 1.70320328e-02f, 1.05318250e-02f, 1.61343142e-02f, 4.42637131e-02f, -2.60096230e-02f,
  -2.34303586e-02f, 4.83113602e-02f, 7.59212747e-02f, 7.34133124e-02f, 2.66284365e-02f, -5.70601143e-04f, -2.76370570e-02f, 4.41133939e-02f, -1.23072220e-02f, -1.15750106e-02f,
  9.63453483e-03f, -2.06363592e-02f, 1.55911101e-02f, 2.66440492e-02f, 4.26583290e-02f, -5.72168361e-03f, 1.07268533e-02f, 1.06167629e-01f, -1.21694952e-02f, 5.17108710e-03f,
  1.15741873e-02f, -1.21333890e-01f, 2.12349281e-01f, 1.07653692e-01f, -3.11805401e-02f, -1.75998092e-03f, -3.29925232e-02f, 2.18086615e-02f, -2.37124249e-01f, -1.98421150e-01f,
  -6.70224279e-02f, 1.10235307e-02f, -1.15723707e-01f, 6.25165328e-02f, 4.33085710e-02f, -1.51114404e-01f, 7.88153857e-02f, 6.86181411e-02f, -1.03962220e-01f, 1.01076327e-01f,
  7.23818243e-02f, -1.23147070e-02f, 1.18729062e-01f, -7.25454511e-03f, 1.65960282e-01f, 8.53901058e-02f, 9.57807600e-02f, 2.81553064e-02f, 1.91641524e-01f, 6.06865920e-02f,
  4.57422845e-02f, -1.16288140e-01f, 1.31912202e-01f, -2.44025141e-02f, 1.06747031e-01f, 7.41537288e-02f, 8.58713984e-02f, 5.62052019e-02f, -4.39323187e-02f, -6.73263222e-02f,
  3.65124666e-03f, 5.81613295e-02f, 5.12368837e-03f, -7.70511627e-02f, 4.94678505e-02f, -2.56735478e-02f, -7.48487981e-03f, 3.11470614e-03f, 8.30427930e-02f, 7.10768476e-02f,
  8.54031071e-02f, 8.39077830e-02f, 2.99183577e-02f, 8.03921074e-02f, 2.43619252e-02f, -2.24327948e-02f, 1.98455844e-02f, 9.57236066e-02f, -3.30169462e-02f, -9.75613855e-03f,
  -2.75058486e-02f, -3.44710648e-02f, -2.67507266e-02f, -1.83656812e-02f, 2.84003690e-02f, -6.69790292e-03f, -2.70407740e-02f, 2.62519456e-02f, 2.86422446e-02f, -6.90912679e-02f,
  2.61941254e-02f, -1.38828726e-02f, -5.80380633e-02f, 4.29935083e-02f, 8.44008029e-02f, 3.73797379e-02f, -1.83635168e-02f, -9.45539866e-03f, 1.80843826e-02f, 2.27880590e-02f,
  -6.68699443e-02f, -2.63431370e-02f, -7.28190616e-02f, 5.44380471e-02f, -3.10848113e-02f, -6.05251603e-02f, 1.14946840e-02f, -3.89184393e-02f, 3.30032245e-03f, 3.09334639e-02f,
  -5.09497002e-02f, -1.17916040e-01f, -6.02195486e-02f, -6.15324825e-02f, -8.15584809e-02f, -3.05322073e-02f, 2.70138532e-02f, 5.95821217e-02f, -1.37949269e-02f, 1.53419655e-02f,
  1.17374882e-02f, 7.01105446e-02f, -7.43583366e-02f, 9.13505256e-02f, 3.53549831e-02f, -7.99124837e-02f, 6.22248044e-03f, -4.97041047e-02f, 1.97916161e-02f, 1.77726932e-02f,
  4.79231216e-03f, -9.21538025e-02f, -5.38418218e-02f, 4.71953601e-02f, -7.17008114e-03f, -1.29096780e-03f, -1.19109266e-02f, -8.84000584e-02f, 7.92042390e-02f, -8.99867937e-02f,
  -3.20025504e-01f, 1.80715576e-01f, -1.09608896e-01f, -1.31433353e-01f, 3.23712416e-02f, -4.94911596e-02f, -1.73163697e-01f, -9.33369547e-02f, -1.38382867e-01f, 1.09383598e-01f,
  -2.00829934e-02f, -1.20933587e-02f, 5.86592481e-02f, -1.08510084e-01f, -1.89801306e-01f, 3.36575881e-02f, -2.29202434e-01f, -8.30529556e-02f, -8.79085287e-02f, -4.70467620e-02f,
  -1.81609601e-01f, -1.91584993e-02f, -4.03232612e-02f, 6.60184398e-02f, -7.11190328e-02f, 6.12694733e-02f, 1.36052594e-01f, 7.64585435e-02f, 2.93096583e-02f, 3.39975208e-02f,
  -1.01929963e-01f, -3.16102616e-02f, 1.01873456e-02f, 8.34012590e-03f, -4.22710441e-02f, 4.94622290e-02f, 2.69485489e-02f, 4.52876315e-02f, -3.23738456e-02f, 2.83496883e-02f,
  4.17950302e-02f, 3.60798612e-02f, 2.91437916e-02f, 6.12257384e-02f, -2.35632882e-02f, -9.17449743e-02f, 4.38879877e-02f, -3.82874254e-03f, -4.67284098e-02f, -1.69744492e-02f,
  -6.69974135e-03f, -8.45274329e-03f, -9.27017033e-02f, -9.06390324e-03f, -5.95554039e-02f, -2.94843409e-02f, 6.91302717e-02f, 1.75620951e-02f, -4.18902598e-02f, -6.94254339e-02f,
  7.09854662e-02f, -1.67167913e-02f, 3.30572836e-02f, -1.04779780e-01f, 2.36853398e-02f, -6.21431088e-03f, 7.48032182e-02f, -9.69652832e-03f, 2.31766757e-02f, -4.52309512e-02f,
  -3.27993557e-02f, -1.31649496e-02f, -3.25450413e-02f, -1.73493158e-02f, -1.58469900e-02f, 4.36386801e-02f, -3.30560113e-04f, 1.56574864e-02f, -1.01543546e-01f, -2.45405041e-04f,
  -1.77959744e-02f, -2.39934921e-02f, 2.80887056e-02f, -2.22300068e-02f, -4.59240116e-02f, -3.87231587e-03f, 2.86683757e-02f, -2.09733639e-02f, -1.70298405e-02f, -9.40755755e-03f,
  4.83537801e-02f, 3.85143831e-02f, -3.74571444e-03f, -3.68078775e-03f, 2.49967854e-02f, 9.95924789e-03f, -8.92169587e-03f, 9.27395839e-03f, -3.63522582e-03f, -8.83769302e-04f,
  -3.32767889e-02f, 7.64739886e-02f, -2.51429193e-02f, -4.88882698e-02f, -3.63587514e-02f, -1.39282132e-02f, 3.86666134e-02f, 5.85338026e-02f, -4.27517109e-02f, -2.76909843e-02f,
  9.36420634e-03f, 1.04920175e-02f, 3.84124406e-02f, 2.31592190e-02f, 4.26324643e-02f, 5.64022996e-02f, 3.90370078e-02f, 5.78531958e-02f, 6.07999191e-02f, 2.74084532e-03f,
  -1.33378923e-01f, -7.32774884e-02f, -7.40584955e-02f, 5.64471558e-02f, -1.37838349e-02f, 3.01519427e-02f, 1.26102239e-01f, 1.67050675e-01f, -6.55128509e-02f, 1.17621899e-01f,
  2.19561905e-01f, -2.03907534e-01f, 9.39669758e-02f, 7.73792788e-02f, 1.05093770e-01f, 7.70499557e-02f, 9.16036591e-02f, -1.13988966e-02f, 2.37741340e-02f, 1.20773360e-01f,
  7.16760084e-02f, 1.70895219e-01f, 5.35248406e-02f, 1.35518655e-01f, 9.85652953e-02f, -1.17563292e-01f, 1.45128667e-01f, 7.16471598e-02f, -3.46710570e-02f, 9.76430923e-02f,
  -2.38361023e-02f, 1.55893480e-03f, -5.20291687e-05f, -1.21476501e-01f, 7.19866604e-02f, -4.70197722e-02f, 1.84525121e-02f, -4.64018285e-02f, -4.63320911e-02f, -3.29273455e-02f,
  -6.92175552e-02f, -3.19130048e-02f, -1.33152003e-03f, -6.43064007e-02f, -8.96118581e-04f, -5.78987226e-02f, 1.10094026e-02f, 1.19329039e-02f, 6.05879314e-02f, -6.03512041e-02f,
  9.82973166e-03f, -1.04580604e-01f, 5.25824912e-03f, 3.42677087e-02f, 1.05869872e-02f, 2.96299290e-02f, 2.02462208e-02f, -8.23802873e-02f, -3.81174684e-02f, -9.81030148e-03f,
  -4.33420241e-02f, 6.30286708e-03f, -2.32717339e-02f, -2.50370223e-02f, -6.81816880e-03f, 2.47344319e-02f, 4.31032665e-02f, 1.40473014e-03f, 1.35358528e-03f, 7.92818982e-03f,
  -1.00510959e-02f, -4.87637594e-02f, -5.41872680e-02f, -1.23405724e-03f, -2.49978807e-02f, -8.06167796e-02f, -8.84428099e-02f, -4.36225906e-02f, -1.46388896e-02f, -2.66206823e-03f,
  5.75541705e-02f, 5.58656044e-02f, 3.40021104e-02f, 3.22413221e-02f, -5.05588166e-02f, -4.37278934e-02f, -4.51395847e-02f, -7.77842775e-02f, -2.21500099e-02f, 7.03396602e-03f,
  7.50911310e-02f, 2.33674511e-01f, 7.83121213e-02f, -3.99738923e-02f, -2.94364989e-03f, 4.76197675e-02f, -2.21826546e-02f, 1.84271559e-02f, 6.11867085e-02f, 8.26217309e-02f,
  -3.00645120e-02f, 3.53969038e-02f, 5.86842149e-02f, 6.71721101e-02f, 3.75598371e-02f, 4.28787656e-02f, 3.19187716e-02f, -7.90187437e-03f, -1.36701332e-03f, -4.78355251e-02f,
  -5.04735298e-03f, -3.16117182e-02f, 1.37470393e-02f, 2.91521158e-02f, 1.82633456e-02f, -4.49419208e-02f, -4.48492058e-02f, 3.09607238e-02f, 8.89650956e-02f, 4.34916727e-02f,
  1.36246026e-01f, 3.18396896e-01f, -1.28284514e-01f, 3.29838432e-02f, -1.41856492e-01f, -1.98927492e-01f, -9.22075734e-02f, -7.14242691e-03f, 2.22262546e-01f, 1.47364661e-01f,
  1.31405576e-03f, 1.06031716e-01f, -2.04075314e-02f, 4.09149453e-02f, -1.46351159e-01f, 5.35151921e-03f, 8.59212428e-02f, 5.28925695e-02f, 8.21110830e-02f, 4.77446280e-02f,
  -4.05546948e-02f, -7.37146810e-02f, -2.58028239e-01f, -1.39770225e-01f, -7.92482719e-02f, 8.01123679e-02f, -1.42526150e-01f, -2.22574651e-01f, -3.84106375e-02f, -4.51097377e-02f,
  1.21865086e-01f, 9.25476104e-02f, 3.00217588e-02f, -1.63178220e-02f, -6.12976477e-02f, 1.08699370e-02f, -1.24467470e-01f, -1.00604683e-01f, -2.68853921e-02f, -5.67635745e-02f,
  3.44250426e-02f, -8.11663270e-02f, 5.51856458e-02f, 1.37677528e-02f, 1.27889207e-02f, 6.44897968e-02f, -2.22386420e-02f, -3.89847415e-03f, -2.06332244e-02f, -1.22018725e-01f,
  2.07731277e-02f, 8.22389126e-03f, -2.38630809e-02f, -4.16251691e-03f, -8.62810910e-02f, 4.22728471e-02f, -8.10874104e-02f, -7.19210645e-03f, 4.04640771e-02f, -9.78435855e-05f,
  4.66626659e-02f, -7.04053789e-03f, -1.42088868e-02f, 3.61330993e-02f, 2.44685560e-02f, 6.12667277e-02f, -3.95140611e-02f, 4.10243534e-02f, 6.20589145e-02f, 1.33089749e-02f,
  5.66702895e-03f, 1.01209281e-03f, 5.45496568e-02f, 5.23391441e-02f, 1.48173571e-02f, 4.36320491e-02f, -3.36770415e-02f, 4.69953306e-02f, -6.22299388e-02f, -8.79197102e-03f,
  -4.59280349e-02f, 5.10870703e-02f, 3.71933193e-03f, -3.00878081e-02f, 5.01347706e-02f, 1.01407699e-03f, -3.44071700e-03f, 2.08863150e-03f, -1.26023311e-02f, -8.43959628e-04f,
  7.98369646e-02f, 1.60323128e-01f, -7.37640727e-03f, 4.20149453e-02f, 9.06776171e-03f, -3.91636379e-02f, 5.58313243e-02f, 6.76511899e-02f, -9.70327295e-03f, 6.18505180e-02f,
  -1.01822950e-01f, -4.91170771e-02f, 6.14704676e-02f, 5.87650388e-02f, -4.78132367e-02f, -1.46762440e-02f, -4.41878132e-04f, 2.93021780e-02f, 8.88989773e-03f, 2.17375625e-02f,
  -8.10546055e-02f, 1.32541833e-02f, -5.86653464e-02f, 2.44706254e-02f, -4.02177647e-02f, 1.26888650e-02f, 5.80305867e-02f, -1.57362241e-02f, -3.48452739e-02f, 4.97552915e-04f,
  1.40086919e-01f, -3.12527828e-02f, -1.71696007e-01f, -6.66947628e-04f, 3.35151196e-01f, 8.95305425e-02f, 5.37758181e-03f, 8.96764845e-02f, 9.01198685e-02f, -1.84933022e-02f,
  2.00621458e-03f, -1.20730512e-02f, -1.25244617e-01f, -1.83931336e-01f, -3.20501983e-01f, -3.31407458e-01f, -1.12762108e-01f, -1.19090132e-01f, -6.48574531e-02f, -1.12746535e-02f,
  -8.97652060e-02f, 1.54875042e-02f, -9.98386517e-02f, 1.89609066e-01f, 1.33679494e-01f, 1.40927553e-01f, 3.52512975e-03f, 1.12818643e-01f, 5.10819219e-02f, -1.93736963e-02f,
  -6.62374310e-04f, -5.76511659e-02f, -5.00744209e-02f, 4.80327122e-02f, 4.75235432e-02f, 1.03628926e-01f, -1.62542313e-02f, -4.54138815e-02f, 6.79176152e-02f, -2.93351635e-02f,
  -4.41891588e-02f, -7.64753064e-03f, 8.00396577e-02f, 6.74077496e-02f, 1.08583711e-01f, -1.10251540e-02f, 1.30656799e-02f, -1.40307201e-02f, 2.88462685e-03f, -6.62477538e-02f,
  -6.54066205e-02f, -1.74921826e-02f, -1.86651926e-02f, -1.02387019e-01f, -8.96094739e-02f, -1.15675079e-02f, -8.09593499e-02f, -5.65876625e-02f, 3.18018533e-02f, -1.30573297e-02f,
  1.77004393e-02f, 2.85000000e-02f, -5.17735630e-02f, 5.77331260e-02f, 3.91360745e-02f, 3.16779241e-02f, -1.92201566e-02f, 1.17093334e-02f, -4.15925570e-02f, -4.66901772e-02f,
  1.61635000e-02f, -2.84310337e-02f, -2.14577885e-03f, -4.83683450e-03f, -1.33304168e-02f, 2.50066351e-02f, 3.70083004e-02f, -3.69846858e-02f, 5.68232872e-02f, 1.24016153e-02f,
  1.42680677e-02f, 2.01536324e-02f, 9.48628187e-02f, -1.29204085e-02f, 1.38072753e-02f, -4.86614406e-02f, 2.02532876e-02f, 2.44078673e-02f, 3.39700766e-02f, -4.11588959e-02f,
  -1.65975690e-02f, -1.57573938e-01f, 7.39759803e-02f, 7.42753744e-02f, -3.51495780e-02f, 1.04166660e-02f, -7.25757284e-03f, 2.40071621e-02f, -6.90279156e-02f, 2.45421343e-02f,
  -1.07968366e-02f, -3.43024470e-02f, -7.78412959e-03f, -6.10012673e-02f, 4.85002995e-02f, 1.53973317e-02f, 1.20911561e-02f, 2.09329557e-02f, 4.94235791e-02f, 4.33920547e-02f,
  9.14294571e-02f, 3.52131277e-02f, -5.18491492e-03f, 1.57867242e-02f, 2.22528353e-02f, 1.70443784e-02f, 3.16606835e-02f, 7.97465444e-02f, -5.31960018e-02f, -2.72414088e-02f,
  -2.07320750e-01f, 1.18209861e-01f, 2.09637672e-01f, -1.60687268e-01f, -1.53538465e-01f, -1.44820020e-01f, -2.84685850e-01f, -4.49892133e-02f, -2.70155132e-01f, -1.78382039e-01f,
  -1.76474392e-01f, 8.08080211e-02f, 1.89148441e-01f, -1.60448506e-01f, 9.66716856e-02f, 1.74467921e-01f, -2.25408494e-01f, -1.12918131e-01f, 3.72606032e-02f, -5.28940335e-02f,
  -7.39519447e-02f, -1.61201641e-01f, 1.99252099e-01f, -5.34121804e-02f, -1.42234474e-01f, 8.54434818e-03f, 7.27072882e-04f, 1.89311191e-01f, 4.69543636e-02f, 9.42823514e-02f,
  1.48968603e-02f, -2.91770045e-02f, 4.28129639e-03f, 1.21349040e-02f, -7.32495487e-02f, -3.25192474e-02f, 1.84152219e-02f, 1.15869947e-01f, 7.40642250e-02f, -4.17941771e-02f,
  4.81029339e-02f, -1.83022618e-02f, -4.58999239e-02f, -1.43094116e-03f, -9.51602831e-02f, 6.04488216e-02f, 3.42673548e-02f, 2.31831986e-02f, 1.57753751e-02f, 1.05940057e-02f,
  -3.41797583e-02f, -4.69497219e-03f, -4.83252555e-02f, -6.62699938e-02f, -2.38271654e-02f, -1.13543924e-02f, -1.36838872e-02f, 1.09179042e-01f, -1.03768660e-02f, -8.29598755e-02f,
  1.54003454e-02f, -4.99534011e-02f, 7.57471798e-03f, 4.61537912e-02f, -2.76158843e-02f, 4.92354147e-02f, -1.17780885e-03f, 9.43569094e-02f, -4.19928171e-02f, 1.68899447e-02f,
  -7.34493881e-02f, 5.43093774e-03f, -6.31078705e-02f, -2.60750242e-02f, -3.95490602e-02f, -5.53501546e-02f, 6.05680533e-02f, -9.86610074e-03f, -3.01381480e-02f, -6.02408918e-03f,
  7.52971992e-02f, 9.33051168e-04f, -1.07680177e-02f, -3.62033732e-02f, 8.39252677e-03f, 5.50012179e-02f, -1.72951288e-04f, 5.33067249e-02f, -9.26814321e-03f, 6.30346239e-02f,
  -7.89945796e-02f, 3.15136164e-02f, -1.11131379e-02f, 2.01213527e-02f, 5.92799149e-02f, -4.29890119e-02f, -5.41994497e-02f, -5.02381753e-03f, -2.10570339e-02f, -5.21714836e-02f,
  -7.46484250e-02f, 1.59700010e-02f, -1.47954673e-02f, 3.82620506e-02f, 2.82962155e-02f, -8.65723789e-02f, 5.10414802e-02f, -7.29027167e-02f, 1.89267844e-02f, 1.15365967e-01f,
  -3.25580575e-02f, -7.32896384e-03f, 2.35494003e-02f, -8.49123392e-03f, 1.84762347e-02f, -1.03335157e-02f, -3.15291770e-02f, 3.39415632e-02f, 1.09273084e-01f, 7.58573925e-03f,
  9.35646519e-02f, 8.96095186e-02f, 1.05237752e-01f, 5.52182160e-02f, 9.68318731e-02f, -2.50796258e-01f, -2.52339810e-01f, 1.21099383e-01f, 2.39983991e-01f, -1.50744796e-01f,
  -1.42672181e-01f, 1.41952828e-01f, -1.28304586e-01f, 1.28032779e-03f, -1.77043974e-02f, -1.74406856e-01f, -1.22752585e-01f, -4.88939583e-02f, 1.34939849e-01f, 1.01003289e-01f,
  7.84082115e-02f, -9.73341838e-02f, -1.07386149e-01f, 1.22056447e-01f, 1.83392204e-02f, 1.35576367e-01f, -3.05978451e-02f, 5.85788265e-02f, -9.72029269e-02f, 5.08055203e-02f,
  -4.44277525e-02f, 1.47723630e-01f, 5.76966032e-02f, -4.29731458e-02f, -2.27798847e-03f, -7.33481199e-02f, -8.79341438e-02f, 4.43872474e-02f, -2.12505069e-02f, -3.77793796e-02f,
  6.55855460e-04f, 9.07821059e-02f, -7.38872029e-03f, 5.52624948e-02f, 9.23590139e-02f, 5.34741394e-02f, 4.22983319e-02f, -4.07667197e-02f, 8.39209706e-02f, 2.64378712e-02f,
  7.33245537e-02f, 1.09634390e-02f, 2.67301779e-02f, -4.56716828e-02f, -3.06817535e-02f, 1.58165698e-03f, 4.34108488e-02f, -6.91027269e-02f, 4.24905382e-02f, 7.82674626e-02f,
  -1.26386918e-02f, 1.90091766e-02f, 4.55429181e-02f, -8.48826542e-02f, 3.14486250e-02f, -3.79315466e-02f, -2.78037824e-02f, -7.49871284e-02f, 6.87107258e-03f, -1.59330461e-02f,
  -4.06770930e-02f, -1.25568062e-02f, 1.08392024e-02f, -2.67021321e-02f, -8.62981193e-03f, -4.63946015e-02f, -1.49892066e-02f, -4.05498706e-02f, -5.32709733e-02f, 6.39328808e-02f,
  3.64572592e-02f, 2.01214291e-02f, -1.89881306e-02f, -3.81794237e-02f, 2.90742926e-02f, -3.45058739e-04f, 4.04154286e-02f, 2.68317927e-02f, 2.01614760e-02f, -4.96970788e-02f,
  5.09642530e-03f, 9.77277681e-02f, 7.37566054e-02f, 1.89324692e-02f, -7.15259239e-02f, -2.60979664e-02f, 4.85668071e-02f, -1.58585925e-02f, 5.47131412e-02f, 9.70434844e-02f,
  -9.16586667e-02f, -5.13611808e-02f, -2.66879015e-02f, -3.95873375e-02f, -2.48775166e-02f, -2.07081307e-02f, -1.36359474e-02f, 3.96493301e-02f, 4.45953682e-02f, 8.03052559e-02f,
  -4.13047858e-02f, -5.33050150e-02f, -3.78157459e-02f, 7.01254383e-02f, 1.90477185e-02f, -5.40546514e-02f, -8.27667303e-03f, 4.23389450e-02f, -5.44736488e-03f, -2.09013987e-02f,
  -2.54437923e-01f, 2.56164730e-01f, -7.23695233e-02f, -1.53688967e-01f, -1.73408046e-01f, -1.21948652e-01f, -1.16578471e-02f, -1.43742666e-01f, -9.39085931e-02f, 1.58097476e-01f,
  -2.54477784e-02f, 1.31347720e-02f, 3.12105119e-01f, -3.42205800e-02f, -1.17394283e-01f, 2.77693659e-01f, -8.42145979e-02f, -5.63200610e-03f, 2.27677934e-02f, -1.12511009e-01f,
  -9.00680944e-02f, -8.32223296e-02f, 9.70649868e-02f, -7.83637911e-02f, -2.11685330e-01f, -4.26071398e-02f, 8.54658708e-02f, 3.21530439e-02f, -1.01122677e-01f, 2.70517245e-02f,
  -1.76117942e-02f, -3.61962542e-02f, -1.07063152e-01f, 4.36002538e-02f, -7.01265931e-02f, -5.73686026e-02f, -6.64126649e-02f, 7.80624226e-02f, -4.67060171e-02f, 3.02572902e-02f,
  2.59289052e-02f, -7.66428262e-02f, -6.70760572e-02f, -1.02409814e-02f, -5.27117141e-02f, -5.70419282e-02f, -3.25474739e-02f, -1.35496166e-02f, -2.50030626e-02f, -7.35078752e-02f,
  -1.33351246e-02f, 5.55754900e-02f, -1.92225873e-02f, 1.85470190e-02f, -4.80382070e-02f, -1.21398401e-02f, -1.46766603e-02f, -5.13008190e-03f, -1.47660617e-02f, -5.88758402e-02f,
  -1.60846524e-02f, 9.27811489e-02f, 5.75295500e-02f, -3.53999669e-03f, -3.18082161e-02f, -7.11451620e-02f, 4.37069908e-02f, -1.25511810e-02f, -1.12415245e-02f, -2.09750384e-02f,
  -3.24118845e-02f, -5.37625514e-02f, -1.46827707e-02f, -1.72430314e-02f, 4.19466756e-02f, -3.65829691e-02f, 2.13614516e-02f, 1.98983517e-03f, -5.56332283e-02f, -5.13198525e-02f,
  5.36326393e-02f, -2.37736921e-03f, 4.08139899e-02f, -5.07723279e-02f, -2.40541492e-02f, 1.89457182e-02f, 2.50823442e-02f, 4.56000231e-02f, 2.89281774e-02f, -1.07976058e-02f,
  1.44930691e-01f, 2.55993724e-01f, 1.93409696e-02f, -3.94884348e-02f, 6.49019377e-03f, -2.43479218e-02f, 3.35766189e-02f, -7.00125471e-02f, 7.85527453e-02f, -4.21296880e-02f,
  7.80509436e-04f, -5.28334314e-03f, 3.19814645e-02f, 3.86403278e-02f, 4.07415852e-02f, 3.99614982e-02f, 3.38471122e-02f, -5.05242907e-02f, -2.56573018e-02f, -9.78900958e-03f,
  2.96064951e-02f, -3.95748913e-02f, -7.60004390e-04f, -1.67664550e-02f, 3.72159295e-02f, -1.79817653e-04f, -4.59750183e-02f, 1.68683566e-02f, 1.34058334e-02f, 5.71558811e-03f,
  -8.40727054e-03f, 4.33659375e-01f, 1.01766579e-01f, -7.29354620e-02f, -1.49819419e-01f, -6.22909749e-03f, 6.73707277e-02f, 9.72818062e-02f, -6.06205463e-02f, 9.84160677e-02f,
  -2.81883832e-02f, 2.46204540e-01f, 1.10900149e-01f, 2.46609841e-02f, -1.68135226e-01f, 4.39301766e-02f, -4.50462074e-04f, 8.42407271e-02f, -2.72678845e-02f, 5.22396788e-02f,
  -1.24090932e-01f, -6.88560978e-02f, 9.09624696e-02f, -6.05342910e-02f, -2.08971668e-02f, -8.62221867e-02f, -2.66121000e-01f, 2.15238873e-02f, -2.78140791e-02f, -4.85074893e-02f,
  -3.46702375e-02f, 6.02336749e-02f, -3.13307531e-02f, 2.09680367e-02f, 1.10253645e-02f, -5.02816103e-02f, 2.84102056e-02f, 2.79871635e-02f, -8.43616500e-02f, 5.36005187e-04f,
  1.99987888e-02f, 2.92542577e-02f, 5.32692624e-03f, 2.47222744e-02f, -8.49791095e-02f, 4.10842672e-02f, -4.29240391e-02f, 6.54850006e-02f, 7.58714825e-02f, 1.27190009e-01f,
  1.02688260e-01f, -3.22062708e-02f, 1.49240866e-02f, 2.03110967e-02f, -6.10483661e-02f, -6.33160993e-02f, 5.29266074e-02f, -3.70488130e-03f, -3.02941520e-02f, 4.81949858e-02f,
  -7.14187548e-02f, 7.41178356e-03f, 4.87330928e-03f, -1.06980680e-02f, 1.68289766e-02f, -8.28774124e-02f, 3.11804805e-02f, -4.61339727e-02f, -1.17472617e-03f, -5.83574027e-02f,
  -3.22017185e-02f, 1.08678481e-02f, -6.68976754e-02f, -1.01435304e-01f, 2.54065823e-02f, -4.88701500e-02f, 2.43212916e-02f, 5.28718010e-02f, -4.33161594e-02f, -3.89450155e-02f,
  5.12226261e-02f, -3.55945416e-02f, -1.79481314e-04f, -3.43766101e-02f, 4.72634239e-03f, -5.61666451e-02f, 2.71972064e-02f, 5.95218688e-02f, 5.05203381e-02f, -8.63802284e-02f,
  3.40160355e-02f, -1.32690176e-01f, 5.81073426e-02f, -3.95572260e-02f, 1.43836988e-02f, -7.74238072e-03f, -2.76817419e-02f, -2.47080214e-02f, -4.44045849e-02f, 2.02680323e-02f,
  -7.87829086e-02f, -2.34754551e-02f, 1.01423496e-02f, -4.96734083e-02f, 2.11440697e-02f, -5.42526245e-02f, -4.81067002e-02f, -9.52315629e-02f, -1.09496787e-02f, -4.96949777e-02f,
  3.96621116e-02f, -9.22374800e-03f, -4.19235267e-02f, -1.13989249e-01f, -5.51313125e-02f, 2.46149721e-03f, -4.33971249e-02f, -4.46562143e-03f, -5.14359325e-02f, -1.83744438e-03f,
  2.37161174e-01f, -1.67001382e-01f, -1.94725037e-01f, 4.80948500e-02f, 1.11510485e-01f, 1.70186814e-02f, -1.41217530e-01f, 8.72427300e-02f, 7.48336464e-02f, -2.23304808e-01f,
  2.43869785e-04f, -7.39835054e-02f, -1.21230714e-01f, 4.36911732e-02f, 2.63919294e-01f, 1.09781638e-01f, 1.05529927e-01f, -1.19129427e-01f, 1.05592534e-01f, -5.76206110e-02f,
  1.58893988e-01f, 1.79964930e-01f, -6.70192167e-02f, 2.98738983e-02f, -4.93310690e-02f, -6.27342239e-02f, -2.13001352e-02f, -5.52325584e-02f, -8.11361000e-02f, 4.29094881e-02f,
  1.56886852e-03f, 4.39834222e-02f, -8.11031684e-02f, 1.51421158e-02f, -1.00385994e-01f, -1.00862376e-01f, -6.61507696e-02f, -8.02991074e-03f, 2.20731553e-02f, 8.08462128e-02f,
  -5.77565953e-02f, -1.83384549e-02f, 4.32357863e-02f, -1.15097389e-02f, 6.63268268e-02f, -4.88226861e-02f, 5.01599461e-02f, -3.89343686e-02f, -1.02669269e-01f, 4.03224118e-03f,
  -1.70000142e-03f, -9.59753394e-02f, -1.76781416e-02f, 2.22509168e-03f, -3.72135527e-02f, 6.02662638e-02f, 4.08879220e-02f, -7.24754557e-02f, -6.63047805e-02f, 6.20491244e-02f,
  4.33400646e-02f, 1.04620550e-02f, 5.26465699e-02f, -4.38080449e-03f, 6.69484288e-02f, 5.13862595e-02f, -4.27832082e-03f, -6.14434108e-02f, 1.88566782e-02f, -2.82219294e-02f,
  8.86170268e-02f, -3.15085351e-02f, 2.32821126e-02f, 5.40505089e-02f, 7.43546784e-02f, -5.09372400e-03f, -2.57150270e-02f, -5.78856692e-02f, -3.47814821e-02f, 2.20524371e-02f,
  -3.52604389e-02f, 8.29956494e-03f, -7.22825434e-03f, -7.08801625e-03f, 3.91528271e-02f, 5.15405163e-02f, 1.45880440e-02f, -2.75305193e-02f, -4.56362143e-02f, -1.18561753e-03f,
  -6.35141805e-02f, 2.23381221e-02f, -2.76581831e-02f, -3.52244638e-02f, 9.51532274e-05f, -3.22158001e-02f, 1.96900740e-02f, 4.25402168e-03f, 1.83520541e-02f, -2.76700817e-02f,
  -5.65146357e-02f, 1.14223529e-02f, 1.19808828e-02f, 9.58577543e-02f, 1.18632326e-02f, -2.17339434e-02f, -1.04231916e-01f, -3.42759527e-02f, 1.43606644e-02f, -2.84961890e-02f,
  -5.14183976e-02f, 5.54137863e-03f, -5.25975451e-02f, 7.98814818e-02f, 1.14674354e-02f, -5.01570106e-02f, 1.52095072e-02f, -3.79227735e-02f, 5.25458902e-02f, -7.16172755e-02f,
  -1.43512348e-02f, 1.66224599e-01f, -2.42646754e-01f, -1.12339742e-01f, -7.34437481e-02f, 2.20026746e-01f, 1.13483280e-01f, -4.50890362e-02f, -1.11364342e-01f, 1.90129369e-01f,
  1.31794259e-01f, -8.33372474e-02f, 4.98255156e-02f, 1.95441619e-01f, 9.16349981e-03f, 1.34956390e-01f, 2.58572072e-01f, 1.80025205e-01f, -1.13234341e-01f, -5.23072435e-04f,
  -4.07230295e-02f, 2.92581916e-01f, -8.45442116e-02f, 1.03233397e-01f, 2.41490416e-02f, -9.39557850e-02f, 1.75579432e-02f, -1.52575048e-02f, 8.30535665e-02f, 2.30533611e-02f,
  4.06641550e-02f, -1.27867209e-02f, -9.51713175e-02f, -9.99618545e-02f, -9.14834999e-03f, 3.54504562e-03f, 1.81455128e-02f, 2.24649757e-02f, -5.06678335e-02f, -3.35602002e-04f,
  -4.16945219e-02f, 1.90769192e-02f, 2.29749195e-02f, 4.28997390e-02f, -3.14381458e-02f, -6.44452721e-02f, -4.26366217e-02f, -7.14780912e-02f, -9.07628015e-02f, 2.95410631e-03f,
  -8.35203845e-03f, 1.41201032e-04f, -2.08156276e-02f, 5.53261861e-02f, -3.07729859e-02f, -3.80867161e-02f, 2.49040108e-02f, 2.61387578e-03f, 1.37644280e-02f, -4.09624837e-02f,
  7.00204447e-02f, 7.19820186e-02f, -6.25782385e-02f, -3.99213992e-02f, -6.21037073e-02f, -3.91906947e-02f, 2.55406573e-02f, 6.08744323e-02f, 1.57057252e-02f, -5.41828573e-02f,
  -9.63863730e-03f, -6.93390220e-02f, 1.71195101e-02f, 3.88946831e-02f, 2.38583237e-02f, 4.43996638e-02f, 1.40900342e-02f, 1.96880307e-02f, 1.28137954e-02f, -3.88539769e-02f,
  -1.94298849e-02f, -2.13728398e-02f, 6.03853688e-02f, 2.37081591e-02f, 2.87844688e-02f, -3.24143935e-03f, 7.95500204e-02f, -1.61349848e-02f, 2.07188427e-02f, -1.50935473e-02f,
  7.92418495e-02f, 1.63660794e-01f, -3.30095477e-02f, 5.03235497e-02f, 4.81091738e-02f, 5.67070805e-02f, 2.32434273e-02f, 1.34610422e-02f, -1.36326095e-02f, 4.43995185e-02f,
  9.43271220e-02f, -1.77073013e-03f, -1.54740140e-02f, -2.50723846e-02f, -3.59255895e-02f, 3.06301229e-02f, -1.74202509e-02f, -7.02671055e-03f, 8.85216892e-02f, 3.01674791e-02f,
  4.69011888e-02f, 3.73029001e-02f, -4.50005420e-02f, 3.64854671e-02f, 1.75231397e-02f, 2.41200346e-02f, 9.35461372e-03f, 4.04199697e-02f, 7.88611993e-02f, 4.72597703e-02f,
  4.55270588e-01f, -2.55144596e-01f, -5.42592779e-02f, 5.80339730e-02f, 8.97059776e-03f, 2.59188637e-02f, 3.05610210e-01f, -1.60245344e-01f, 1.40978172e-01f, -1.73420474e-01f,
  -6.89739510e-02f, 2.53880829e-01f, 3.82553749e-02f, -2.19622210e-01f, 2.86015660e-01f, 6.84976429e-02f, -7.64468908e-02f, 9.10543129e-02f, 7.78253973e-02f, -3.31701376e-02f,
  -8.79963487e-03f, -7.82937407e-02f, -1.05648749e-01f, -3.27990234e-01f, 2.83823200e-02f, -1.08922429e-01f, -1.89558789e-02f, -3.80138010e-02f, -2.68675387e-01f, -4.41033505e-02f,
  -2.46822909e-02f, -5.28572574e-02f, -1.98300295e-02f, -6.50106296e-02f, -1.95656884e-02f, 5.66252600e-03f, 9.41537973e-03f, 5.50096296e-02f, -1.95546728e-02f, 5.05839400e-02f,
  1.27297163e-01f, -1.66042112e-02f, -4.37581986e-02f, -6.59971684e-02f, -1.17281647e-02f, -4.89828885e-02f, 1.26168747e-02f, 4.67392243e-03f, 2.70040054e-02f, 3.34158482e-04f,
  -9.19154007e-03f, -1.14528229e-02f, 3.46064083e-02f, -5.10585569e-02f, -2.26754993e-02f, -3.00933383e-02f, 5.47649749e-02f, 2.62206197e-02f, 3.61495838e-02f, 2.35836897e-02f,
  1.14367567e-01f, 2.39968821e-02f, -7.15217888e-02f, -5.61974533e-02f, -2.20740698e-02f, -2.54761688e-02f, 2.30247881e-02f, -2.58613937e-02f, 1.15429272e-03f, 4.58427519e-02f,
  1.32983131e-03f, 1.45001318e-02f, -1.34674972e-02f, 3.19586694e-02f, 4.58461568e-02f, 5.58210537e-03f, 5.60741834e-02f, 2.08960916e-03f, 7.14117894e-03f, -3.86696346e-02f,
  -7.19138887e-03f, 9.20392852e-03f, -4.20210771e-02f, -1.40012410e-02f, -3.77313569e-02f, -3.17802862e-03f, -4.82771322e-02f, -1.80176459e-02f, -1.46917440e-02f, 5.75030502e-03f,
  5.60837910e-02f, -7.90074002e-04f, -4.91782976e-03f, -5.58007918e-02f, 9.50782932e-03f, -1.72531046e-02f, 1.45212179e-02f, 6.25895569e-03f, 4.01518345e-02f, -5.79606295e-02f,
  -4.01999615e-02f, 5.33555932e-02f, 1.65286381e-02f, 1.64514333e-02f, 4.30958606e-02f, -1.30523359e-02f, -6.97140442e-03f, -1.18611995e-02f, -1.74176805e-02f, 8.51278193e-03f,
  2.28298176e-02f, 4.09252867e-02f, 2.32745688e-02f, 7.12190643e-02f, 3.43319289e-02f, 6.65966943e-02f, 1.16820484e-02f, -2.13777293e-02f, -4.53393124e-02f, 2.12569460e-02f,
  5.69607578e-02f, 1.22291006e-01f, -2.06545249e-01f, 1.29297942e-01f, 1.30525589e-01f, 2.09715009e-01f, 1.80175036e-01f, 1.41354650e-01f, -2.74794623e-02f, 9.73644331e-02f,
  1.79889545e-01f, -5.43384440e-02f, 1.33123500e-02f, 1.21764585e-01f, 1.84724554e-01f, 5.70098907e-02f, 2.92835981e-01f, 1.15899585e-01f, -5.46017177e-02f, 1.20534413e-01f,
  1.00315921e-01f, 1.94056302e-01f, 6.10373951e-02f, 1.51047960e-01f, 1.75859958e-01f, -4.73609269e-02f, 9.23595056e-02f, -9.47795510e-02f, 1.73480660e-01f, 9.50653404e-02f,
  -2.03777105e-02f, -6.22369088e-02f, -8.32979903e-02f, -1.30281791e-01f, 2.91859079e-02f, -6.33202307e-03f, -6.92957491e-02f, 3.06658670e-02f, -2.65786126e-02f, 1.95420310e-02f,
  8.49802699e-03f, -2.83366218e-02f, 1.03907147e-02f, 2.71753091e-02f, 5.96280843e-02f, -6.44452125e-02f, 1.92976333e-02f, -1.72066335e-02f, 1.42440684e-02f, 9.72921122e-03f,
  -6.49596751e-02f, 4.64101210e-02f, 3.07623539e-02f, 2.52940948e-03f, 2.94205695e-02f, 4.56124684e-03f, 2.94694118e-02f, -8.65231734e-03f, 3.13337334e-03f, 1.00466542e-01f,
  2.37407107e-02f, 1.74274691e-03f, -5.48574142e-02f, -5.36943115e-02f, 2.86376867e-02f, -3.98236178e-02f, 1.45160267e-03f, 3.25540192e-02f, -1.10388026e-02f, -1.01547991e-03f,
  9.47457083e-05f, -9.78477765e-03f, -1.29633807e-02f, 1.48792320e-03f, 1.06072232e-01f, -7.26443753e-02f, 1.57113913e-02f, -4.92161512e-02f, 1.59556866e-02f, -4.89188768e-02f,
  3.21082883e-02f, 7.59490579e-02f, 2.24271957e-02f, -8.49182233e-02f, 4.74879955e-04f, 1.08873835e-02f, -1.58232991e-02f, -4.01230156e-02f, 7.56405815e-02f, -1.67386644e-02f,
  2.22042188e-01f, 1.48204476e-01f, 6.61989616e-05f, -4.95973453e-02f, 6.67135173e-04f, 4.50711604e-03f, 5.27331047e-02f, -3.22175585e-02f, 4.25971672e-02f, -3.05963866e-02f,
  -5.72945736e-03f, -3.26077640e-02f, 7.53204450e-02f, -1.53394993e-02f, -3.44147719e-02f, 8.65668356e-02f, 7.36467242e-02f, 2.15508603e-02f, 4.40477878e-02f, 2.85069961e-02f,
  -5.14839683e-03f, 6.18856773e-02f, -4.21291813e-02f, 7.39726573e-02f, 2.44960114e-02f, -3.46263945e-02f, 6.92145079e-02f, 8.44777375e-03f, 7.06430972e-02f, -4.54678684e-02f,
  8.32664222e-02f, -1.66596606e-01f, -7.33561590e-02f, 1.35872299e-02f, -1.26443699e-01f, -1.46882823e-02f, 1.17289856e-01f, -2.10828453e-01f, 2.48656496e-01f, -7.40634501e-02f,
  1.45397829e-02f, 1.70939371e-01f, 1.53937012e-01f, 1.07799798e-01f, 4.47301418e-01f, 3.38620812e-01f, 1.40689284e-01f, 1.67334467e-01f, 1.31815657e-01f, -6.20045811e-02f,
  7.93262944e-02f, 5.47242863e-03f, -2.36210544e-02f, -2.38391563e-01f, -2.49848127e-01f, -2.42829666e-01f, -1.76845685e-01f, -1.64305851e-01f, -7.45459199e-02f, 9.26786214e-02f,
  -2.31144484e-02f, 6.08123131e-02f, -7.76258335e-02f, 3.12869474e-02f, -4.30695787e-02f, -9.90675837e-02f, -6.23663552e-02f, 1.18755298e-02f, 6.05823509e-02f, -2.46245191e-02f,
  -2.33427268e-02f, 2.80214939e-02f, 7.12248757e-02f, 2.60293167e-02f, -1.07630298e-01f, -2.37627071e-03f, -3.39820944e-02f, -2.12674178e-02f, -2.45552137e-02f, 4.27190810e-02f,
  -4.22363840e-02f, 2.09752545e-02f, -9.34092142e-03f, 6.63740784e-02f, 8.65740608e-03f, 4.52937447e-02f, -3.04662604e-02f, -3.80896255e-02f, 2.52792928e-02f, 7.17328191e-02f,
  -8.41968320e-03f, -2.38554105e-02f, -3.50788720e-02f, 3.11711524e-02f, 4.59163822e-02f, -4.23133671e-02f, 5.03466949e-02f, 8.69864039e-03f, 4.40945439e-02f, 5.99211501e-03f,
  3.35872918e-03f, -2.69740280e-02f, 7.71045238e-02f, -3.48197259e-02f, -9.88861918e-03f, -8.47082958e-03f, -4.06316258e-02f, 7.25329854e-03f, -6.48585288e-03f, -3.80266383e-02f,
  1.75168663e-02f, 8.28452408e-03f, 2.00113258e-03f, -2.28020921e-02f, 7.45727494e-02f, -1.63016189e-03f, -2.04608589e-02f, -3.29764299e-02f, -4.78575528e-02f, -5.36989160e-02f,
  8.93019363e-02f, -6.29988983e-02f, 1.37953963e-02f, -9.69418418e-03f, -6.95196353e-03f, 2.54197815e-03f, 3.66094783e-02f, 2.10644063e-02f, -1.39784804e-02f, 8.46927464e-02f,
  -1.09134972e-01f, -6.82365820e-02f, -1.11792022e-02f, 2.99376175e-02f, 6.16695806e-02f, 5.95609471e-02f, -2.14552116e-02f, 8.22357927e-03f, -5.20901978e-02f, -6.93261549e-02f,
  -5.00711501e-02f, -9.69642121e-03f, 6.39115274e-02f, -7.39407837e-02f, -2.10993309e-02f, -4.90548834e-02f, 2.89297905e-02f, -1.10814897e-02f, -4.73826081e-02f, -2.95142066e-02f,
  -2.23288566e-01f, 4.17280793e-01f, 1.43875163e-02f, -1.61425680e-01f, -2.12902397e-01f, 2.08296664e-02f, 1.21466495e-01f, 4.87090833e-02f, 8.43304172e-02f, 3.00197661e-01f,
  2.26135813e-02f, 8.97127911e-02f, 2.69539416e-01f, -2.72466391e-02f, -2.96430767e-01f, 2.25239843e-01f, 9.26861074e-03f, 1.24361239e-01f, -4.02865224e-02f, -2.57644746e-02f,
  -1.57504961e-01f, -1.47673339e-01f, -1.16792053e-01f, 3.54116298e-02f, -1.06179215e-01f, -1.10931553e-01f, -1.46459803e-01f, 2.05705855e-02f, -9.50056762e-02f, -8.97161290e-02f,
  -1.57141328e-01f, -4.70300727e-02f, 3.73483337e-02f, 8.34290907e-02f, 3.75491311e-03f, -3.92546244e-02f, -9.41965962e-04f, -3.74478176e-02f, -8.11421126e-03f, 1.98766217e-02f,
  4.69709970e-02f, 1.66803002e-02f, -1.25859119e-02f, 1.90876331e-02f, 2.88585089e-02f, 1.71276815e-02f, 4.97809262e-04f, -8.70611612e-03f, 4.07279693e-02f, 4.03537706e-04f,
  4.56256513e-03f, -3.18191312e-02f, -2.86056404e-03f, 4.57776934e-02f, -2.71201190e-02f, -6.39819503e-02f, -6.78471476e-03f, -2.63007544e-02f, -2.92613432e-02f, -7.48745352e-02f,
  2.15221830e-02f, -3.39841433e-02f, 1.74271129e-02f, -5.35778627e-02f, 3.94941382e-02f, 2.68337666e-04f, 3.18637304e-02f, -6.60836026e-02f, -3.49402148e-03f, -6.31252900e-02f,
  -4.19639684e-02f, -6.50986657e-02f, -4.72231433e-02f, -1.56418812e-02f, -2.98267156e-02f, 3.88373211e-02f, -5.93619002e-03f, -1.97084863e-02f, 2.52482854e-02f, -1.01514846e-01f,
  -1.17304381e-02f, -2.17312556e-02f, -1.49276843e-02f, -7.33352974e-02f, 9.26366635e-03f, -6.15490973e-03f, -1.55962873e-02f, -7.86470529e-03f, -2.58446243e-02f, -2.90717762e-02f,
  -9.26438347e-02f, -1.56906486e-01f, 3.80069353e-02f, -4.99597788e-02f, -9.31543857e-03f, -2.82689556e-02f, -5.64074442e-02f, 2.72464566e-02f, -5.32257790e-03f, -4.11727652e-02f,
  3.93457077e-02f, -2.10262276e-02f, -2.34743650e-03f, 2.13238914e-02f, 5.20313531e-02f, 1.02638686e-03f, -4.38442547e-03f, -8.25368427e-03f, -1.01007424e-01f, -3.73405218e-02f,
  8.46682861e-03f, 3.66904773e-02f, -2.80863140e-02f, -4.47404273e-02f, 3.20748892e-03f, 1.90352164e-02f, 1.40748490e-02f, -3.67193222e-02f, 1.54913384e-02f, 7.15063699e-03f,
  -3.72282505e-01f, 1.06109746e-01f, -1.00806408e-01f, -1.85144037e-01f, 1.43918857e-01f, -1.20363824e-01f, -7.87496492e-02f, 1.07815355e-01f, -1.89429611e-01f, 2.00448677e-01f,
  1.65005878e-01f, -1.28777057e-01f, 1.66964114e-01f, 8.45123157e-02f, -2.31429115e-01f, 1.78604107e-02f, -5.29777296e-02f, -1.24903627e-01f, -9.72792804e-02f, 7.50067905e-02f,
  -1.29526839e-01f, 2.22581506e-01f, 5.46800308e-02f, 1.96423873e-01f, 5.52288406e-02f, 1.66355651e-02f, 3.05470973e-01f, 1.14254355e-01f, 1.28848270e-01f, -5.26848296e-03f,
  -2.50003524e-02f, 2.36651413e-02f, 3.69051215e-03f, -7.81952441e-02f, 4.62086201e-02f, -1.08083701e-02f, -8.39792043e-02f, -3.32297944e-02f, -2.26091724e-02f, 2.10711099e-02f,
  -1.08784191e-01f, 9.68757644e-03f, -6.68612644e-02f, 1.87084563e-02f, -3.67869134e-03f, -3.74812819e-02f, -3.29737850e-02f, -6.41127452e-02f, 4.06107046e-02f, -5.06458804e-02f,
  -9.12252367e-02f, 4.99090478e-02f, -3.57484482e-02f, -7.98308402e-02f, -2.33777445e-02f, -4.11495604e-02f, -2.83761118e-02f, -5.24421409e-02f, -1.88215114e-02f, -2.67128590e-02f,
  -8.40684995e-02f, -4.83600870e-02f, -4.33741398e-02f, 2.66892891e-02f, -1.08264331e-02f, 2.62585282e-02f, 3.32524888e-02f, 6.41770486e-04f, -2.69214865e-02f, 4.20584567e-02f,
  3.70138511e-02f, 2.43769139e-02f, 5.14856316e-02f, 6.12052754e-02f, 2.13947408e-02f, 5.65396138e-02f, -3.30193564e-02f, 4.27066982e-02f, -7.22234771e-02f, -1.77779049e-02f,
  4.70984727e-02f, -4.00184356e-02f, -1.26856314e-02f, 4.26326580e-02f, 2.32403558e-02f, -2.14576460e-02f, 5.48735522e-02f, -6.24433421e-02f, 4.53556292e-02f, 1.71079189e-02f,
  -1.48201957e-02f, 1.18530519e-01f, 4.75655030e-03f, -3.51414038e-03f, -2.62562409e-02f, 3.96513194e-02f, 1.78352334e-02f, -1.97366811e-02f, -2.78249811e-02f, -2.50320304e-02f,
  2.36743800e-02f, -3.78847644e-02f, -5.35276048e-02f, 3.36901844e-02f, -1.91989411e-02f, 5.98933212e-02f, 2.85850875e-02f, 5.12446202e-02f, 2.14006491e-02f, 6.80791810e-02f,
  3.25705633e-02f, -1.63692702e-02f, 1.05318418e-02f, 2.12577805e-02f, -1.53442018e-03f, 3.86357903e-02f, -4.50352952e-02f, -1.68520566e-02f, -5.67716314e-03f, 1.52074872e-02f,
  8.05766806e-02f, -3.80928516e-02f, 1.45654857e-01f, 3.91901471e-02f, 3.89478765e-02f, 2.51795024e-01f, 1.84531480e-01f, -1.39359534e-01f, -1.02146260e-01f, -1.82900950e-01f,
  -1.71266608e-02f, 5.59412725e-02f, -8.34273100e-02f, -1.05261177e-01f, 1.30969346e-01f, 2.46757511e-02f, 1.49428961e-03f, 5.08786291e-02f, -1.18831038e-01f, -3.20344120e-02f,
  -8.72209594e-02f, -1.26703218e-01f, -7.03234449e-02f, -1.34414770e-02f, -2.57580914e-02f, -1.51044101e-01f, -4.24671099e-02f, 1.14778407e-01f, -2.97873020e-02f, 9.79216099e-02f,
  -3.55560333e-02f, -1.48363903e-01f, -5.38843125e-02f, 3.02476250e-02f, -7.24883899e-02f, 9.23789339e-04f, 5.55854067e-02f, 1.26902282e-01f, 2.75822598e-02f, -3.82342860e-02f,
  3.18907201e-02f, 1.85743673e-03f, -9.81450919e-03f, 9.92209464e-02f, -4.34714369e-02f, 4.80563045e-02f, 3.82006504e-02f, 4.15436290e-02f, -3.03955842e-02f, -4.91824448e-02f,
  2.44291201e-02f, 4.66014892e-02f, -7.58332163e-02f, 4.58851792e-02f, 2.50336304e-02f, 4.23997343e-02f, 9.36749429e-02f, -5.79239540e-02f, -3.10522057e-02f, 4.78786370e-03f,
  4.50782329e-02f, 4.57770787e-02f, -6.98620155e-02f, -1.92081984e-02f, -2.08558924e-02f, -2.73861438e-02f, -3.42742912e-02f, -5.50866798e-02f, 2.38982514e-02f, 4.70440648e-02f,
  1.36914523e-03f, 6.33196682e-02f, 3.93590629e-02f, -9.93936509e-02f, -2.98049506e-02f, 3.38860229e-02f, -2.85078362e-02f, 3.45572904e-02f, 3.31900939e-02f, -7.88603351e-02f,
  -6.02112450e-02f, -2.40265895e-02f, -4.94625159e-02f, -2.49240287e-02f, 1.29934736e-02f, 4.52483222e-02f, 3.34676877e-02f, 5.44769689e-02f, -1.82315856e-02f, 1.08059563e-01f,
  -7.68855661e-02f, -7.42168054e-02f, 6.08220436e-02f, 5.34677040e-03f, 8.01219270e-02f, 1.58374570e-02f, 3.47440355e-02f, -1.35073299e-02f, 3.41570452e-02f, -1.80880036e-02f,
  -3.02744489e-02f, 4.48575281e-02f, 5.71083874e-02f, 4.38930914e-02f, 6.13252074e-02f, -7.20457360e-02f, 2.10443456e-02f, -2.40240153e-02f, -3.45463566e-02f, -2.85049956e-02f,
  -7.77105689e-02f, -1.67251285e-02f, 2.60999496e-03f, 1.49634657e-02f, -2.75948588e-02f, 8.44399035e-02f, -4.42252420e-02f, -2.02487372e-02f, 8.56265053e-02f, 1.95181742e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.56741127e-01f, -4.34458405e-02f, -2.24289134e-01f, 3.19407731e-02f, -1.13631319e-02f, -2.11043321e-02f, 7.20506534e-03f, 7.90159777e-02f, -7.87924454e-02f, 1.95940696e-02f,
  -2.31136978e-02f, 5.52077442e-02f, -1.62982196e-01f, 1.23955764e-01f, 1.04633972e-01f, -9.62183326e-02f, 1.62988484e-01f, 1.19887523e-01f, -3.87224667e-02f, 1.41066030e-01f,
  1.67165324e-02f, 1.86816320e-01f, -2.28855461e-02f, 1.68510571e-01f, 1.15189098e-01f, -9.85009689e-03f, 1.56563506e-01f, -1.38001665e-01f, 8.92353058e-02f, 1.01959839e-01f,
  3.84704173e-02f, 6.97368234e-02f, -2.35814927e-03f, -5.51412888e-02f, 2.58566272e-02f, 1.99987367e-02f, 1.83166210e-02f, 3.88988070e-02f, -9.70275421e-03f, 6.16226122e-02f,
  -1.69747528e-02f, 3.79158533e-03f, 1.02189310e-01f, -1.49796354e-02f, -4.58900481e-02f, -6.32372350e-02f, -4.26796526e-02f, 2.25234637e-03f, -2.38814950e-02f, -7.93416500e-02f,
  -1.44185990e-01f, -1.71367824e-02f, -2.99532432e-03f, 5.58510534e-02f, -7.82058090e-02f, -1.90208610e-02f, -4.80306707e-02f, 5.89349493e-03f, 3.76465581e-02f, 9.91581306e-02f,
  -4.91687562e-03f, 1.11525327e-01f, -5.50362915e-02f, -4.49926928e-02f, -8.63396004e-02f, -1.06154472e-01f, 3.68450710e-04f, -5.01627196e-03f, -1.07206605e-01f, 2.64921524e-02f,
  5.19374833e-02f, -2.70615462e-02f, -5.29436348e-03f, 6.79670200e-02f, -2.12771203e-02f, -4.31837961e-02f, 2.10452192e-02f, 4.41012904e-03f, -4.07148674e-02f, -5.91215529e-02f,
  -6.03185855e-02f, -1.81468334e-02f, 4.28965539e-02f, 5.43776117e-02f, -3.63756791e-02f, -4.63427464e-03f, -4.06576172e-02f, 3.43201905e-02f, -2.00699046e-02f, 6.06670603e-02f,
  9.87608917e-03f, -6.99901860e-03f, -4.09861887e-03f, 6.37536123e-02f, -8.66835862e-02f, -4.43170853e-02f, -9.46372561e-03f, -1.63893905e-02f, -1.19892685e-02f, 2.45887991e-02f,
  4.18428443e-02f, 2.73762494e-02f, 4.56637470e-03f, -5.49593801e-03f, 8.00207928e-02f, 6.79111034e-02f, 6.56565204e-02f, 3.49001549e-02f, 3.83458771e-02f, 6.35666996e-02f,
  3.17705311e-02f, -6.88300282e-03f, 4.61504050e-02f, -8.44046026e-02f, -5.92463277e-02f, -9.78671014e-03f, 4.66022715e-02f, 5.61295450e-02f, -5.67931980e-02f, 8.34811330e-02f,
  -1.86315700e-01f, -5.19672111e-02f, 5.52069806e-02f, -2.08484426e-01f, -6.01930730e-02f, 7.54425228e-02f, -1.18806154e-01f, 8.32474008e-02f, -1.59837548e-02f, -6.47962838e-02f,
  1.44948252e-02f, -1.38978258e-01f, 1.72235832e-01f, -2.17190920e-03f, 7.05422387e-02f, 1.58646822e-01f, -1.05613910e-01f, 4.45870534e-02f, -1.95966521e-03f, -1.64207175e-01f,
  -4.05071564e-02f, -1.83342367e-01f, 4.29141186e-02f, -5.91399297e-02f, -1.41308025e-01f, -1.30362079e-01f, 1.94365326e-02f, -1.22272037e-01f, -1.40028924e-01f, -7.92855304e-03f,
  -6.90333545e-02f, -1.76063284e-01f, -5.98652475e-02f, -1.89213287e-02f, 1.95421521e-02f, 5.47063053e-02f, -7.15311766e-02f, 2.81132143e-02f, -2.13809386e-02f, 3.54883149e-02f,
  -1.02839798e-01f, -6.09343573e-02f, -2.46136822e-02f, 2.91019902e-02f, -5.22039458e-02f, 1.51191801e-02f, 6.49931952e-02f, -6.59767464e-02f, 3.90151292e-02f, -1.86819378e-02f,
  4.80836816e-03f, 7.07340688e-02f, -5.78039549e-02f, 1.36959410e-04f, 3.77716497e-02f, -6.44661784e-02f, -4.47296239e-02f, 4.97742407e-02f, 4.63775247e-02f, 2.09286585e-02f,
  -8.09052363e-02f, 2.05112109e-03f, 2.59391200e-02f, -2.33078338e-02f, -4.26688045e-02f, -1.44338263e-02f, -4.62545268e-02f, -5.67331687e-02f, -1.86956674e-02f, -6.53963014e-02f,
  -1.13972281e-04f, -1.05704591e-01f, 1.96145824e-03f, 9.47195441e-02f, 6.64885342e-02f, 1.65020917e-02f, -7.22070932e-02f, 4.22080830e-02f, 5.31420931e-02f, 1.00343833e-02f,
  1.70011725e-02f, -4.82643433e-02f, -8.74273181e-02f, 1.55244283e-02f, -4.54448536e-02f, -8.81876145e-03f, 6.91272393e-02f, 9.24147815e-02f, -5.70478141e-02f, -9.63362530e-02f,
  -1.95291758e-01f, -1.83399037e-01f, -5.59263043e-02f, -7.75912777e-02f, -5.03217243e-02f, -2.85954960e-02f, -8.53857622e-02f, 4.84585389e-02f, -4.40593921e-02f, -7.33007863e-02f,
  5.70434220e-02f, 7.99004510e-02f, 2.34705694e-02f, -3.48677449e-02f, 4.92936075e-02f, 4.14423160e-02f, -3.31148244e-02f, -2.01895218e-02f, 2.99080703e-02f, 4.75149276e-03f,
  5.11416681e-02f, -1.01064138e-01f, -2.53627710e-02f, 9.16850846e-03f, 2.07923260e-02f, -1.11651532e-01f, 5.33603430e-02f, 3.87374014e-02f, 2.15112697e-02f, -9.45766177e-03f,
  -1.85062990e-01f, -1.09130353e-01f, -7.08971843e-02f, 6.35906160e-02f, -1.30746976e-01f, -1.50898352e-01f, -1.15896026e-02f, -2.39612740e-02f, -1.17577784e-01f, 1.63124025e-01f,
  1.97823644e-01f, -1.08178280e-01f, -2.47574057e-02f, -2.67215203e-02f, 1.50018772e-02f, 1.13257244e-01f, -7.53538497e-03f, 7.86267892e-02f, 4.85057421e-02f, -5.76564223e-02f,
  -5.20973094e-02f, 7.04398006e-02f, 3.05246171e-02f, -1.88330766e-02f, 3.75699289e-02f, 9.25895050e-02f, 9.19205770e-02f, -3.58354151e-02f, 8.76282901e-02f, -6.77356422e-02f,
  -5.22242766e-03f, -6.99233115e-02f, 1.06122242e-02f, 1.84632987e-02f, -1.76360831e-02f, -1.56190228e-02f, 8.51882920e-02f, -3.55209522e-02f, -4.54393625e-02f, 3.80974188e-02f,
  2.83642709e-02f, 4.79693897e-02f, -5.96820563e-03f, 4.79198210e-02f, 7.86456689e-02f, -2.94788703e-02f, -1.91749679e-03f, 3.91870365e-02f, -1.40131470e-02f, 1.07615264e-02f,
  -7.14929625e-02f, -8.00234526e-02f, -1.98408235e-02f, 1.40656289e-02f, 2.57433802e-02f, -6.00638315e-02f, 8.01360756e-02f, 4.69333492e-02f, -1.03408068e-01f, -1.66290607e-02f,
  3.56448255e-02f, -5.03650196e-02f, 6.55332720e-03f, -3.22795324e-02f, -7.02078035e-03f, 8.05890560e-02f, 7.77566880e-02f, -6.94410279e-02f, 3.67723517e-02f, -2.63017341e-02f,
  8.63296539e-02f, -5.61496764e-02f, 5.21648042e-02f, -2.81361286e-02f, 6.50804490e-02f, -6.10301681e-02f, -4.08001207e-02f, -2.24701632e-02f, 5.65111004e-02f, 3.43152620e-02f,
  6.79499377e-03f, 4.76552397e-02f, 5.22802956e-02f, 8.47512390e-03f, -2.33908575e-02f, 3.25897783e-02f, 6.51447326e-02f, 8.35627839e-02f, -9.43762995e-03f, -5.96393012e-02f,
  5.92813045e-02f, 8.42389613e-02f, -3.91939692e-02f, -7.47580007e-02f, 6.24882802e-03f, -8.49059001e-02f, -8.66755098e-02f, 2.66526807e-02f, -8.97208881e-03f, -1.16293877e-01f,
  -5.96652180e-02f, 2.46497802e-02f, -8.20715651e-02f, -3.31153534e-02f, -6.08117990e-02f, 7.80009180e-02f, -5.41512147e-02f, -1.94814503e-02f, 4.99892645e-02f, -4.51540016e-02f,
  7.91015476e-03f, -7.27096424e-02f, -2.64880266e-02f, -9.59848464e-02f, -2.47956943e-02f, -1.33723803e-02f, 5.48420474e-02f, -7.79048428e-02f, -3.49198431e-02f, -1.41400760e-02f,
  1.31904110e-01f, 1.00642711e-01f, 8.83126482e-02f, -3.99668850e-02f, -8.29288736e-02f, -1.48374751e-01f, -1.31985918e-01f, -2.35805660e-02f, 5.56633547e-02f, 7.37146810e-02f,
  -9.22157466e-02f, 1.98199810e-03f, -3.21137756e-02f, 6.89907139e-03f, -1.50693268e-01f, -6.24622144e-02f, -1.83697324e-02f, 2.78768153e-03f, -4.59759459e-02f, -3.27994078e-02f,
  5.49465902e-02f, 3.46169509e-02f, -6.59846812e-02f, -1.10055720e-02f, 5.99444285e-02f, 7.68784508e-02f, -3.20236497e-02f, 5.84007539e-02f, 3.99743505e-02f, -7.66327754e-02f,
  -6.44006627e-03f, 1.37377203e-01f, 1.07696436e-01f, 5.89782931e-02f, 6.26596510e-02f, -7.32263476e-02f, -1.27204051e-02f, -5.08177802e-02f, 5.20713925e-02f, 1.77615986e-03f,
  4.32072021e-02f, -4.75745611e-02f, -1.61987171e-02f, 2.82056946e-02f, -2.63578985e-02f, -1.40067609e-02f, 2.28847377e-02f, -6.38325810e-02f, 7.40077049e-02f, 6.12614825e-02f,
  -4.01078239e-02f, -1.94218177e-02f, -2.02985499e-02f, -7.83655792e-02f, 4.38117087e-02f, -5.03186248e-02f, -1.19637745e-02f, -6.79838359e-02f, 1.13080991e-02f, -6.91274405e-02f,
  7.92153366e-03f, -8.83284211e-02f, 3.10057821e-03f, 4.42059077e-02f, 8.08998719e-02f, -6.11034371e-02f, -2.52820347e-02f, -6.89768940e-02f, -6.92457333e-02f, 1.23392278e-02f,
  -8.95850360e-03f, -3.11692245e-02f, 2.73410082e-02f, -2.44857688e-02f, 9.75277461e-03f, 2.14696415e-02f, 3.61470841e-02f, 1.85809433e-02f, -1.15726213e-03f, -4.69981171e-02f,
  5.62787354e-02f, 1.89360138e-02f, -6.26536459e-02f, 5.32350875e-02f, -3.51169929e-02f, -8.02623779e-02f, 3.88395749e-02f, 7.67474845e-02f, -1.10437209e-02f, -9.03810784e-02f,
  -5.83149716e-02f, -3.49103473e-02f, -2.63840705e-02f, -4.78215925e-02f, 1.42567642e-02f, 7.66223818e-02f, -7.54775703e-02f, -8.24947730e-02f, -1.67289134e-02f, -3.20667922e-02f,
  -7.90539086e-02f, 8.28790665e-02f, -2.53520813e-02f, 9.34780091e-02f, -4.65914272e-02f, -5.37531897e-02f, -1.25145735e-02f, 2.88077034e-02f, -3.77398990e-02f, 7.94526786e-02f,
  2.42298022e-02f, -7.51370937e-03f, -6.90004528e-02f, 7.98198953e-02f, 1.60668343e-02f, -9.37109590e-02f, 9.20553878e-02f, -2.65051126e-02f, 1.97732542e-02f, -4.56497492e-03f,
  -6.12578206e-02f, -3.10404729e-02f, 3.12968194e-02f, 6.72925934e-02f, -2.04986148e-02f, -6.77684546e-02f, 2.54083127e-02f, -5.88910729e-02f, -1.14968270e-01f, 1.05373345e-01f,
  1.97942127e-02f, 1.03756800e-01f, 3.35750217e-03f, -1.66115820e-01f, -2.64227092e-01f, -2.25619048e-01f, -1.09505847e-01f, 3.90208215e-02f, 9.06172022e-03f, 5.03035961e-04f,
  -5.41191502e-03f, -4.92291190e-02f, -4.91870288e-03f, -1.03871390e-01f, 6.19001538e-02f, 1.72762752e-01f, 1.19647607e-01f, 9.07420143e-02f, 1.41297355e-01f, -1.17490858e-01f,
  -5.51464073e-02f, 1.54303666e-02f, 8.00832585e-02f, 5.37815727e-02f, -1.15473261e-02f, 3.52515280e-02f, -3.72157991e-02f, -1.50922807e-02f, -5.87102920e-02f, -2.20722407e-02f,
  1.30088463e-01f, 5.75623624e-02f, -7.95250945e-03f, -8.48849267e-02f, -1.27188070e-02f, -6.01455010e-02f, -5.31087257e-02f, 2.24640463e-02f, -1.80634242e-02f, 1.02405138e-01f,
  4.47561927e-02f, 9.56987143e-02f, -3.12744938e-02f, -2.60905121e-02f, -8.28304440e-02f, -2.77695507e-02f, 1.00303859e-01f, 3.40449773e-02f, -3.80070806e-02f, -2.72387005e-02f,
  9.77154076e-03f, -5.58834746e-02f, -1.40071157e-02f, 2.84552816e-02f, 3.20617706e-02f, 4.57842834e-02f, 3.56173478e-02f, -2.87371781e-02f, 4.20140289e-02f, -8.65669176e-02f,
  6.98140915e-03f, 1.89624391e-02f, 7.00992346e-02f, 4.18746136e-02f, -3.71606089e-02f, -9.08427034e-03f, -6.59717992e-02f, 2.10129339e-02f, 1.46737434e-02f, -4.98293862e-02f,
  2.27962229e-02f, -5.16492948e-02f, 7.98476934e-02f, 1.08235054e-01f, 4.46119756e-02f, -8.50129426e-02f, -7.54822940e-02f, 6.79296330e-02f, -1.23968618e-02f, -4.51019816e-02f,
  -6.54333271e-03f, -1.63498670e-02f, 8.41708388e-03f, -2.59414054e-02f, 6.75447583e-02f, -3.02375332e-02f, -4.15968196e-03f, -2.82550883e-02f, 4.16068658e-02f, 7.23146554e-03f,
  -4.01533581e-03f, 1.57496259e-02f, -9.92359780e-03f, 5.00717312e-02f, 8.20744708e-02f, -8.87225643e-02f, -6.42740726e-02f, 6.30087778e-03f, -6.50316700e-02f, 1.02571331e-01f,
  -3.74053828e-02f, 4.87851957e-03f, 3.37717384e-02f, 9.13611584e-05f, 6.60552159e-02f, -1.16046919e-02f, -5.68559356e-02f, 4.64978106e-02f, 1.11092933e-01f, 4.09230404e-02f,
  3.83069143e-02f, -2.60689020e-01f, -1.31114915e-01f, 2.89826351e-03f, 1.22573495e-01f, -2.04419419e-02f, -4.70049009e-02f, -6.50193766e-02f, -4.41426560e-02f, -1.27500206e-01f,
  1.00379050e-01f, -6.84140483e-03f, -1.52865812e-01f, 1.42148301e-01f, 1.86300680e-01f, 1.95374805e-02f, 1.18033335e-01f, 5.59923686e-02f, 8.85338560e-02f, 3.24635133e-02f,
  1.40834332e-01f, 1.64328858e-01f, 1.72537155e-02f, 6.19470440e-02f, 4.15043831e-02f, -9.03137997e-02f, -2.89090024e-03f, -1.37162924e-01f, 7.16805533e-02f, 1.58445001e-01f,
  8.18231702e-02f, 6.18874766e-02f, -4.02697772e-02f, 2.79285177e-03f, -3.15985531e-02f, -5.30152209e-02f, 5.40900603e-02f, 1.70739219e-02f, -7.90065154e-02f, -3.25515978e-02f,
  -4.50960398e-02f, 7.43785873e-02f, -1.16174277e-02f, 7.89793581e-02f, 7.43538514e-02f, 4.58100550e-02f, 5.24955131e-02f, 3.44636291e-02f, -3.55843827e-02f, 1.30445398e-02f,
  -7.50996396e-02f, 6.92598745e-02f, 1.91022400e-02f, 8.95732155e-05f, -2.51205321e-02f, -5.59059121e-02f, -5.91174103e-02f, 3.96682508e-02f, -9.92314517e-03f, -1.42760202e-02f,
  5.09252436e-02f, 7.67529830e-02f, -6.27995133e-02f, 1.03749052e-01f, 6.64569903e-04f, 8.80994126e-02f, 9.01955366e-02f, 6.42082021e-02f, 1.30961221e-02f, -7.63259530e-02f,
  3.95079318e-04f, -9.61079001e-02f, -1.15791941e-02f, -6.05847575e-02f, -7.26629272e-02f, -3.73718701e-02f, 3.19733992e-02f, 8.03230330e-02f, -7.65960887e-02f, -6.30039023e-04f,
  -2.94101872e-02f, -5.05761104e-03f, -2.14194357e-02f, 1.89898163e-02f, -1.62404850e-02f, 4.89164740e-02f, 6.84770197e-03f, 8.55982155e-02f, 7.60724917e-02f, 2.90416814e-02f,
  3.88251245e-02f, -1.51195318e-01f, 4.01016399e-02f, 4.81933355e-02f, -8.34612027e-02f, 4.98272367e-02f, -8.64884481e-02f, 2.27326397e-02f, 3.55364829e-02f, 5.19298874e-02f,
  -8.58628750e-02f, 5.28402440e-02f, 1.13137256e-04f, -1.10214250e-02f, 1.36571219e-02f, 7.62230381e-02f, -5.71343265e-02f, 1.05098831e-02f, 5.07781096e-02f, 1.96119603e-02f,
  -8.86924341e-02f, -1.02900378e-01f, 4.89691133e-03f, 2.74833478e-02f, 7.26670325e-02f, -7.02697486e-02f, -4.13684268e-03f, 3.21277641e-02f, -6.29304945e-02f, -9.94287953e-02f,
  1.78265855e-01f, -1.99519455e-01f, 8.67767930e-02f, 9.72456113e-02f, 1.19238511e-01f, -2.51564551e-02f, 3.15146931e-02f, -3.17959674e-02f, -5.46097793e-02f, -2.60966659e-01f,
  -2.69846134e-02f, -2.72275531e-03f, -2.42186468e-02f, -2.03166958e-02f, 1.33336946e-01f, 5.64671233e-02f, -1.26388848e-01f, 4.16462682e-02f, 3.72735932e-02f, 2.70371009e-02f,
  6.34719729e-02f, -9.26050171e-02f, 6.16978444e-02f, -1.88206673e-01f, -3.66536453e-02f, -9.11146253e-02f, -3.94310094e-02f, -1.60875823e-02f, 3.17581091e-03f, -2.41890419e-04f,
  -4.96760048e-02f, -1.08184072e-03f, 7.41149187e-02f, 3.24227698e-02f, -8.39128122e-02f, -6.87185153e-02f, 1.69439260e-02f, -3.39652635e-02f, 2.72005945e-02f, 4.99737561e-02f,
  -7.23737627e-02f, 3.70911621e-02f, 1.43758357e-02f, -8.18525441e-03f, -1.82822291e-02f, 4.45725434e-02f, -3.30072381e-02f, 1.14346303e-01f, 6.75006211e-02f, 3.36859934e-02f,
  2.69031767e-02f, -4.89107100e-03f, 1.06859431e-02f, -3.30385827e-02f, 6.47632778e-02f, 5.49706332e-02f, -3.72501574e-02f, -3.05739418e-03f, -1.09501295e-01f, -5.87379895e-02f,
  -2.47300006e-02f, -4.21764776e-02f, 6.00245409e-02f, 1.23328105e-01f, 2.51202714e-02f, 1.62337236e-02f, 7.28466287e-02f, -1.14751179e-02f, -7.48338699e-02f, -9.15590860e-03f,
  2.40410622e-02f, -3.68053862e-03f, -1.02568800e-02f, -4.78147343e-03f, 8.11008513e-02f, 5.97884692e-03f, 4.89128344e-02f, 2.33431831e-02f, -5.05056605e-02f, -6.38895035e-02f,
  -2.79913172e-02f, 1.90367661e-02f, -4.94991876e-02f, 4.17560944e-03f, -6.85407594e-02f, 8.15792009e-02f, -2.65920553e-02f, 7.91655555e-02f, 9.77080017e-02f, -5.21749780e-02f,
  -4.92798090e-02f, -1.78337827e-01f, 1.58081986e-02f, -3.10351662e-02f, -8.21639448e-02f, -5.32890204e-03f, -1.01119116e-01f, 1.10297706e-02f, -7.39133656e-02f, -9.36831981e-02f,
  5.23383096e-02f, 6.30642995e-02f, -9.18579474e-02f, 3.88370231e-02f, -1.04263119e-01f, -4.02666368e-02f, -5.21586426e-02f, 3.19520310e-02f, 3.74311171e-02f, 3.59243224e-03f,
  -3.32619324e-02f, 1.15696248e-02f, -3.10978368e-02f, -1.71202395e-04f, -8.33390206e-02f, 2.74621192e-02f, -1.13120720e-01f, -3.44870389e-02f, -9.02568996e-02f, -1.14222709e-03f,
  -2.28989199e-01f, 2.43016612e-02f, -2.36970350e-01f, -3.52102444e-02f, 9.68553126e-02f, -1.93173274e-01f, -9.03327316e-02f, 8.04959089e-02f, -3.49840298e-02f, 1.45220637e-01f,
  6.83207363e-02f, -1.66360587e-01f, 9.44948494e-02f, -1.17087513e-01f, -3.29426050e-01f, -1.05423175e-01f, -2.30644971e-01f, -9.77195725e-02f, -1.07256062e-01f, -3.84936780e-02f,
  -5.58831170e-02f, 1.00725375e-01f, -1.36393651e-01f, 2.01388136e-01f, 6.83120489e-02f, -6.38629869e-03f, 5.22217490e-02f, 1.72738522e-01f, -2.10818313e-02f, 8.79756138e-02f,
  -8.17689076e-02f, 1.36382088e-01f, -8.84527341e-02f, 5.68978041e-02f, -1.08615629e-01f, -3.67148481e-02f, -5.70626222e-02f, 4.54259068e-02f, 3.32518853e-02f, 5.13086319e-02f,
  5.44736907e-02f, 5.78133613e-02f, -2.58437824e-02f, -5.07210335e-03f, -4.05013375e-02f, -4.23478149e-02f, -4.18258421e-02f, 2.90142670e-02f, -3.26987635e-03f, -1.15308322e-01f,
  -8.73230025e-02f, -8.64465237e-02f, -4.97351103e-02f, 2.03637481e-02f, -5.83775043e-02f, -5.43029346e-02f, -1.53028397e-02f, -4.04827446e-02f, -5.32859974e-02f, 3.10042836e-02f,
  3.44327837e-02f, 8.30049627e-03f, -1.12175923e-02f, 2.97040101e-02f, 8.41863826e-02f, -5.40428087e-02f, 8.29553679e-02f, -1.44265313e-02f, 1.63091812e-02f, -4.76335809e-02f,
  1.99022815e-02f, 6.42154887e-02f, 1.84084252e-02f, -9.15687010e-02f, -7.25805461e-02f, -3.10613420e-02f, -6.57593226e-03f, -1.35667445e-02f, 5.70545159e-03f, -7.30255544e-02f,
  6.36253282e-02f, -7.54096583e-02f, 1.64028835e-02f, -6.39690906e-02f, 8.10397565e-02f, -1.93650704e-02f, -6.53197169e-02f, 5.13425805e-02f, 2.06866069e-03f, -4.26860712e-02f,
  -1.12648912e-01f, 3.24609410e-03f, -5.61666861e-02f, 1.07426219e-01f, -1.70335150e-03f, -9.60380398e-03f, 1.83358938e-02f, 5.70091326e-03f, -8.69768020e-03f, -1.68711469e-02f,
  -3.71294282e-02f, -4.88696545e-02f, 1.28081627e-02f, -1.64002478e-02f, -1.14997271e-02f, -1.96424909e-02f, -4.43328395e-02f, -5.25395237e-02f, -2.23503616e-02f, 6.12122640e-02f,
  1.54459067e-02f, 9.27626565e-02f, -7.81855509e-02f, 4.31230143e-02f, 4.89061549e-02f, 4.13317839e-03f, 1.79869253e-02f, -2.47027390e-02f, 5.12533784e-02f, 8.43781512e-03f,
  2.75356174e-02f, 4.81156297e-02f, -1.11328237e-01f, -1.50063217e-01f, -8.61640647e-02f, -8.78413469e-02f, 6.36099139e-03f, -6.63645044e-02f, -1.60628840e-01f, -4.69283760e-02f,
  -1.01953626e-01f, 4.81837080e-04f, -5.04089892e-02f, -1.79611459e-01f, -1.85681269e-01f, -1.06621936e-01f, -4.70946990e-02f, 3.14833932e-02f, -4.52694371e-02f, 1.37250358e-02f,
  1.46112568e-03f, -6.67462870e-03f, -1.30718067e-01f, 5.56200407e-02f, 8.39975551e-02f, -9.13664792e-03f, 7.30964690e-02f, 5.54581396e-02f, 1.23601931e-03f, -1.11663051e-01f,
  -1.23891085e-02f, 5.28026484e-02f, 8.12148005e-02f, -1.90960523e-02f, 2.77662128e-02f, 8.26766863e-02f, 7.08054230e-02f, -1.78092513e-02f, -2.45184638e-02f, 5.48001006e-02f,
  -1.09737804e-02f, -2.75590345e-02f, -5.51745668e-02f, -5.61090037e-02f, 8.47297311e-02f, -8.03642794e-02f, 8.33470225e-02f, 1.71201825e-02f, -9.96347219e-02f, 3.63682173e-02f,
  -6.24286535e-04f, -2.58209351e-02f, 9.79819670e-02f, -2.94572916e-02f, -1.53967422e-02f, -2.00682562e-02f, -4.52800430e-02f, 5.63872308e-02f, 3.15840021e-02f, -1.09920315e-02f,
  1.00318506e-01f, -1.34450952e-02f, 6.75300648e-03f, 5.12013100e-02f, 2.18589548e-02f, -3.72290127e-02f, -3.06019112e-02f, 2.77759805e-02f, 3.76850031e-02f, 1.36965252e-02f,
  -2.84249187e-02f, -7.01983348e-02f, -9.22147781e-02f, -4.16442007e-02f, 4.35724668e-02f, 5.20427786e-02f, -2.09180564e-02f, 6.70972764e-02f, 1.33678000e-02f, 6.14079721e-02f,
  -9.11305472e-02f, -3.17079797e-02f, 2.39185356e-02f, 1.94448745e-03f, 5.70421014e-03f, 2.29108054e-03f, 4.08541895e-02f, 3.57853272e-03f, 1.91705152e-02f, 7.06890672e-02f,
  9.10483971e-02f, -1.71051677e-02f, 6.73052762e-03f, 1.56469867e-02f, -1.26649439e-02f, -2.00233404e-02f, -1.35811586e-02f, -1.02283813e-01f, -7.82077312e-02f, 6.07227301e-03f,
  -3.60681936e-02f, 3.63180526e-02f, -1.01766344e-02f, -6.44962937e-02f, -5.42072207e-03f, 9.30082649e-02f, -5.32083400e-02f, 7.45610148e-02f, -3.22316960e-02f, 2.49928292e-02f,
  3.25670987e-02f, 6.72818422e-02f, -5.36615811e-02f, 9.09804925e-03f, -3.20342905e-03f, -1.24186799e-02f, 7.25454465e-02f, -1.73354968e-02f, 6.57406375e-02f, -5.91649674e-02f,
  7.19689578e-02f, -1.19190663e-01f, -1.46478163e-02f, 1.00173846e-01f, 8.99553895e-02f, 8.21740702e-02f, -1.25018433e-02f, 8.85199904e-02f, 5.10894321e-02f, -6.03024289e-02f,
  -5.05736694e-02f, -6.42342865e-02f, -1.45137534e-01f, 4.83893938e-02f, 3.93580459e-02f, -6.44022226e-02f, 1.44305587e-01f, 1.18160006e-02f, 1.07349485e-01f, 5.30752800e-02f,
  1.62287559e-02f, 6.95065111e-02f, -1.10910498e-01f, -6.89102560e-02f, -2.18429305e-02f, -5.77955358e-02f, -9.86090451e-02f, -4.41458039e-02f, -5.49134575e-02f, -6.84329942e-02f,
  6.68507675e-03f, -4.05246988e-02f, -1.08572960e-01f, 6.76589534e-02f, 2.94150822e-02f, 2.18222849e-03f, -1.10080995e-01f, -9.78601128e-02f, 6.55262321e-02f, 6.55351728e-02f,
  -7.18994886e-02f, 3.43379714e-02f, -2.57935692e-02f, -7.29506165e-02f, -7.32997805e-02f, 5.84361292e-02f, -3.30601297e-02f, -5.19046746e-02f, -4.25623544e-02f, -9.30202717e-04f,
  1.36072515e-02f, 5.40070236e-02f, 4.18212973e-02f, 6.78361803e-02f, 7.91747123e-02f, -1.55284554e-02f, -4.83445823e-02f, -3.92796919e-02f, -5.62287569e-02f, -5.63106723e-02f,
  -4.74635661e-02f, 6.95542572e-03f, -4.85655963e-02f, -6.10181317e-02f, 7.29727745e-02f, 7.93345496e-02f, -4.82548773e-02f, 5.09505672e-03f, 8.49207565e-02f, -4.21203859e-02f,
  1.07201058e-02f, -3.23339738e-02f, 2.87418701e-02f, -4.80120778e-02f, 4.22644354e-02f, 5.20942360e-02f, -4.77499299e-04f, 8.62500891e-02f, -6.79806992e-02f, -4.58140187e-02f,
  6.73197061e-02f, -6.77420646e-02f, -4.56824601e-02f, 3.91649604e-02f, -5.81193976e-02f, 3.62985656e-02f, 9.20516625e-02f, -1.86350569e-03f, 4.31447178e-02f, -3.35409679e-02f,
  5.78592531e-02f, 6.80277124e-02f, 1.37509564e-02f, 6.80581033e-02f, -8.56431574e-02f, -5.84221184e-02f, 1.70974713e-02f, 7.58454949e-02f, -4.45903512e-03f, -7.12398498e-04f,
  1.55289494e-03f, -4.12614346e-02f, -5.22617325e-02f, -4.95926440e-02f, 4.33849022e-02f, -1.74305250e-03f, 1.02665927e-02f, 6.94172308e-02f, 6.04635030e-02f, 6.30267784e-02f,
  6.23133630e-02f, -7.62934610e-03f, -7.95277134e-02f, 3.96497315e-03f, 9.43874493e-02f, -9.27064121e-02f, -6.69203848e-02f, -8.05283785e-02f, -8.95473361e-03f, -6.55221343e-02f,
  -7.47826472e-02f, 1.40177250e-01f, 1.10026240e-01f, 7.23966304e-03f, -4.90404405e-02f, -9.15198103e-02f, -6.25263527e-02f, 6.49985969e-02f, 4.57651615e-02f, 1.62017439e-02f,
  -3.72282951e-03f, -9.88811105e-02f, 1.37559429e-01f, -4.77314740e-02f, 1.33052856e-01f, 1.67395860e-01f, 2.70421803e-02f, -7.81787187e-02f, 7.66231492e-02f, -8.30304995e-02f,
  3.66547592e-02f, -8.06686431e-02f, 1.12229876e-01f, 4.94601652e-02f, -7.40500093e-02f, 1.28621170e-02f, -4.88272980e-02f, 8.19324553e-02f, -1.23000152e-01f, -6.91859722e-02f,
  6.87808590e-03f, 4.70557176e-02f, 6.20421432e-02f, 5.42499423e-02f, 9.61680189e-02f, -6.79699257e-02f, 1.20807849e-02f, 3.66409793e-02f, 5.60859777e-02f, 4.67729941e-02f,
  -4.63869087e-02f, 6.21274151e-02f, 6.42929599e-02f, 8.29449445e-02f, 4.34769038e-03f, 7.24157393e-02f, 8.36311579e-02f, -5.31055219e-02f, -2.32075285e-02f, -5.13837021e-03f,
  -6.71630353e-02f, 2.52130926e-02f, -8.83153155e-02f, -3.46568525e-02f, -4.99138562e-03f, -3.27054188e-02f, -2.50901617e-02f, -6.07535765e-02f, -3.73290218e-02f, -4.06585485e-02f,
  -1.05902590e-01f, -1.05920723e-02f, 5.56977391e-02f, 4.65610959e-02f, 7.20261037e-02f, -3.93564031e-02f, -3.21092047e-02f, -6.95588961e-02f, -2.53732800e-02f, 4.36115973e-02f,
  7.62786865e-02f, -3.55169401e-02f, 8.09646919e-02f, -3.88862975e-02f, -9.63106826e-02f, -5.07713761e-04f, -4.23927978e-02f, 1.03884429e-01f, 4.90603819e-02f, 2.33759955e-02f,
  -7.64840661e-05f, 4.64286134e-02f, 1.33786546e-02f, 6.57896996e-02f, 5.73035963e-02f, 4.31801975e-02f, -9.03806165e-02f, -2.14321706e-02f, -3.04817827e-03f, 3.00011057e-02f,
  1.06142968e-01f, -1.01401610e-02f, -3.62770222e-02f, -8.31318833e-03f, -5.05532231e-03f, -2.60055419e-02f, 2.54311729e-02f, -7.59891495e-02f, -5.41950390e-02f, -5.04069477e-02f,
  -3.72272134e-02f, 2.15026061e-03f, -6.20692633e-02f, -1.20436147e-04f, -7.67447695e-04f, 5.03691882e-02f, -3.31738926e-02f, 9.71692055e-03f, -6.54507577e-02f, -3.04733403e-02f,
  7.89392740e-02f, -9.96125266e-02f, 2.55124178e-02f, 2.16911640e-02f, 4.58360948e-02f, -6.05819523e-02f, -7.17128068e-02f, -2.80814096e-02f, -3.73370573e-02f, -4.37451042e-02f,
  -2.08114013e-02f, -5.64706363e-02f, 5.61256111e-02f, -1.36371627e-01f, -2.77845506e-02f, 1.33237422e-01f, 4.30546924e-02f, 4.70985770e-02f, -3.08566652e-02f, 7.17005599e-03f,
  9.12621096e-02f, -1.33978873e-01f, 7.18970820e-02f, -2.89694574e-02f, 1.11945562e-01f, 7.64426440e-02f, -3.29127684e-02f, 5.66923618e-02f, 2.99666766e-02f, -8.68573487e-02f,
  8.49102717e-03f, -9.45686251e-02f, -1.21378815e-02f, -1.71304226e-01f, -9.05714631e-02f, -9.53952596e-02f, -1.33688813e-02f, -7.59155676e-02f, -1.05662033e-01f, -9.67582762e-02f,
  9.79803652e-02f, -2.30931938e-02f, 3.91980261e-02f, 8.63395706e-02f, -6.99189007e-02f, 1.08082108e-02f, 4.07582112e-02f, -1.89586096e-02f, 3.90375406e-02f, -8.91996473e-02f,
  -7.23999217e-02f, 1.19173052e-02f, -7.57257268e-02f, 4.72891070e-02f, 2.32739076e-02f, -1.09184884e-01f, -7.66437575e-02f, 4.65840772e-02f, 5.90234436e-02f, 5.54854162e-02f,
  -8.85310546e-02f, -5.46846259e-03f, -1.74559187e-03f, 5.54264896e-02f, -8.11491832e-02f, -9.45313945e-02f, 3.96050923e-02f, 2.08274201e-02f, 9.18569788e-03f, 8.79201889e-02f,
  -1.11183748e-01f, -1.75609179e-02f, 1.81650035e-02f, -5.00392802e-02f, -7.82771260e-02f, -1.14021524e-04f, -2.33888701e-02f, 5.10106757e-02f, 1.02175735e-02f, -8.26105475e-02f,
  5.55497073e-02f, -8.47346485e-02f, 3.89506929e-02f, 1.09802801e-02f, -4.00607008e-03f, -3.42382467e-03f, -4.54531424e-03f, -9.23765451e-02f, -5.95978349e-02f, 7.17277545e-03f,
  9.47947875e-02f, 1.30244670e-02f, -1.69603825e-02f, 3.40402015e-02f, 9.82792005e-02f, -2.06716042e-02f, -7.50601664e-02f, 7.15214610e-02f, 6.07888736e-02f, -6.04468100e-02f,
  1.23636708e-01f, -3.91967148e-02f, 8.81646946e-02f, -4.99754027e-02f, -2.54091937e-02f, 6.94484264e-02f, 2.24191044e-02f, 4.35564034e-02f, 4.64321002e-02f, -7.87550360e-02f,
  5.33762686e-02f, -2.24417541e-02f, -3.55658792e-02f, 6.70428127e-02f, -8.62279385e-02f, -9.14161950e-02f, -8.73995125e-02f, -2.82912962e-02f, 1.15901958e-02f, -4.73084562e-02f,
  -6.79923892e-02f, -7.00617731e-02f, -4.17335778e-02f, 1.27779273e-02f, 4.88301255e-02f, 4.81266864e-02f, 8.53808373e-02f, -1.05202653e-01f, -6.90478981e-02f, 7.99689349e-03f,
  -1.59818977e-01f, -4.68315706e-02f, -7.02537820e-02f, -1.77756712e-01f, -1.03381038e-01f, 1.70678303e-01f, -5.80939651e-02f, 9.08918157e-02f, 1.39604136e-02f, 1.86863258e-01f,
  2.12681547e-01f, -1.39189720e-01f, 8.80994946e-02f, 1.59511566e-01f, 5.43302223e-02f, 1.84342965e-01f, 6.21419102e-02f, 1.17710702e-01f, 5.01633435e-02f, 3.09743863e-02f,
  1.08112507e-01f, 1.03792906e-01f, 8.19081888e-02f, 3.76717374e-02f, 5.27928248e-02f, 4.81936485e-02f, 2.62044966e-02f, 1.52843818e-02f, 6.76512867e-02f, -3.21868211e-02f,
  -4.77157440e-03f, -3.44972387e-02f, 2.62075812e-02f, 1.05017135e-02f, 7.18357116e-02f, 5.58185987e-02f, -2.71695219e-02f, -3.93147841e-02f, -9.45183076e-03f, -7.62775838e-02f,
  4.20050062e-02f, -1.15164844e-02f, 2.08928678e-02f, -1.45633146e-02f, -5.63794784e-02f, 1.32818539e-02f, 7.00246170e-02f, 9.66094062e-02f, 2.63166633e-02f, 2.88386475e-02f,
  9.21290889e-02f, 7.05545545e-02f, -4.83431555e-02f, 1.05397880e-01f, 5.77096129e-03f, 2.83108708e-02f, 2.96345353e-02f, -5.38156368e-02f, 9.27274488e-03f, 8.75652730e-02f,
  2.05531400e-02f, 9.83540565e-02f, 1.54205214e-03f, -9.67912376e-03f, -3.23443003e-02f, -7.05413334e-03f, -3.47897154e-03f, -9.53972712e-02f, -2.84394864e-02f, -3.51763293e-02f,
  -1.13760578e-02f, 1.06088985e-02f, -6.26088977e-02f, -5.44921085e-02f, 3.69165950e-02f, 1.33364387e-02f, 4.21749651e-02f, -4.80407625e-02f, 1.35147609e-02f, 6.93083107e-02f,
  -3.32774110e-02f, -5.59355728e-02f, -6.88502863e-02f, 4.02261987e-02f, 1.61445066e-02f, 2.04585516e-03f, 4.74183494e-03f, -4.09088247e-02f, -1.62207638e-03f, 9.20064375e-03f,
  3.53031382e-02f, 3.73171153e-03f, 1.01859368e-01f, -4.01702262e-02f, 3.75921093e-02f, 6.98122662e-03f, -4.73274849e-02f, 1.42670823e-02f, 8.38891119e-02f, 4.41996865e-02f,
  -2.80909985e-02f, -6.13454953e-02f, 2.83760298e-02f, -8.53063837e-02f, 3.56295519e-02f, 1.04007788e-01f, -4.13113786e-03f, -2.64491104e-02f, -6.41852170e-02f, 3.22035402e-02f,
  6.55585304e-02f, -8.45685229e-02f, 1.09764021e-02f, 8.74985568e-03f, 8.81824940e-02f, -9.44052339e-02f, -5.39361723e-02f, 4.01696041e-02f, -2.42255107e-02f, 6.49889559e-02f,
  -2.82496028e-02f, -2.22655591e-02f, 1.38040558e-01f, 1.11129656e-01f, -3.44605073e-02f, -6.01201169e-02f, 3.41924392e-02f, -6.01656847e-02f, 2.42850669e-02f, 3.07711568e-02f,
  -1.07852546e-02f, 1.05746284e-01f, -1.06943585e-01f, 8.36419165e-02f, -1.91124469e-01f, -1.58032328e-01f, -1.48169249e-02f, -2.90215388e-03f, -2.46738717e-02f, -6.23699352e-02f,
  1.36645483e-02f, -1.63836345e-01f, -3.06709819e-02f, 4.96740863e-02f, 1.28031820e-01f, 1.38103202e-01f, 8.83593410e-03f, -6.66622296e-02f, 9.76931006e-02f, -7.38981962e-02f,
  -6.67454898e-02f, 1.22563215e-02f, -1.30059086e-02f, -3.31867412e-02f, 2.81477291e-02f, 6.11946210e-02f, 6.22762367e-03f, 2.73509361e-02f, -4.36884873e-02f, 9.17374417e-02f,
  -6.00307845e-02f, -6.12570271e-02f, 2.26585101e-02f, 2.88292002e-02f, -1.76107772e-02f, 3.60830054e-02f, 4.53532487e-03f, 3.32559063e-03f, 5.03054587e-03f, 5.99970333e-02f,
  1.65255275e-02f, 6.73525557e-02f, 1.40475435e-02f, 1.19995527e-01f, -8.15662518e-02f, 2.30610576e-02f, 1.05024755e-01f, 9.44857597e-02f, 9.28995684e-02f, 8.04979801e-02f,
  -7.12303668e-02f, -6.92321779e-03f, 9.02970359e-02f, 7.50263259e-02f, -1.15363924e-02f, -7.51920864e-02f, 9.85731464e-03f, -5.01483977e-02f, 6.25604438e-03f, -3.44035728e-03f,
  -5.26141264e-02f, 9.45000276e-02f, 6.33878186e-02f, -1.35561526e-02f, 2.76410878e-02f, 1.35408305e-02f, 5.06299455e-03f, 6.41880929e-02f, -5.13083190e-02f, -5.87430634e-02f,
  2.60800924e-02f, 4.75547053e-02f, -1.64001081e-02f, 2.18632985e-02f, -6.83317613e-03f, 4.43920419e-02f, -6.72328249e-02f, 2.44379062e-02f, -1.14474315e-02f, -2.13444419e-02f,
  -2.61563323e-02f, 4.28648330e-02f, 9.90416706e-02f, 2.18465868e-02f, -2.10718606e-02f, -4.48906869e-02f, 3.17489170e-02f, -6.23562932e-02f, -7.22957402e-02f, -4.31665815e-02f,
  -7.90596157e-02f, -5.73248789e-02f, -3.81600372e-02f, -1.80903357e-02f, 1.17578255e-02f, -2.57623140e-02f, -5.94286099e-02f, 6.82614148e-02f, -6.84685633e-02f, 1.03697039e-01f,
  2.27168240e-02f, 3.45473341e-03f, 8.03446174e-02f, -3.67102176e-02f, 3.68704721e-02f, -4.79144454e-02f, 3.88599969e-02f, 6.59016669e-02f, 4.87654582e-02f, 4.81605493e-02f,
  2.22630855e-02f, -3.48614939e-02f, 1.19139977e-01f, 1.62496835e-01f, 5.13973571e-02f, -5.27616069e-02f, 6.52400404e-02f, -7.16365501e-02f, 6.82228652e-04f, -8.34464356e-02f,
  6.64693639e-02f, 1.05382316e-01f, 1.11394394e-02f, -9.73769929e-03f, 4.68759388e-02f, 6.38420656e-02f, -1.31998196e-01f, -1.33911923e-01f, 2.08900701e-02f, 1.07268319e-01f,
  1.43749230e-02f, 4.41686623e-02f, 8.13510567e-02f, 6.99912980e-02f, 2.83497814e-02f, 3.74419056e-02f, 7.90462345e-02f, 1.48672368e-02f, -1.05958112e-01f, 4.55533480e-03f,
  -8.29903260e-02f, 7.13766664e-02f, -6.08843006e-02f, 1.83666078e-03f, -5.56485094e-02f, 2.23499257e-02f, 8.08660686e-02f, 2.62365062e-02f, -7.02713355e-02f, 8.00977200e-02f,
  -5.08754328e-02f, 6.25972729e-03f, 5.08407988e-02f, 4.76594344e-02f, -2.37083528e-02f, 8.05335566e-02f, 7.84587041e-02f, -9.31868479e-02f, -7.68685639e-02f, -9.19912104e-03f,
  9.50730368e-02f, -3.25899497e-02f, -5.09808026e-02f, 5.14559075e-02f, -4.02115807e-02f, -9.93065257e-03f, 5.86693920e-02f, 6.13063341e-04f, -5.88204302e-02f, -7.41020814e-02f,
  2.92457286e-02f, 7.06979781e-02f, 2.03881208e-02f, -1.72833782e-02f, -1.26716010e-02f, 3.26031744e-02f, -1.79358176e-03f, -7.64638186e-02f, -1.34689556e-02f, -7.41434544e-02f,
  1.20016076e-02f, 9.33646783e-02f, -8.02249908e-02f, 7.53070489e-02f, -7.28738382e-02f, -8.01486522e-02f, 4.32882942e-02f, 7.01907650e-02f, -6.98798299e-02f, -3.31250355e-02f,
  4.53394605e-03f, 3.35572585e-02f, 6.79343194e-02f, -2.45815497e-02f, 3.41096036e-02f, -7.92126302e-05f, 6.83818609e-02f, -5.26971370e-02f, -7.86592811e-02f, -6.09468706e-02f,
  -9.61723700e-02f, 1.20424971e-01f, 6.10511899e-02f, -6.24099597e-02f, -4.11014743e-02f, 1.78742763e-02f, 1.40700620e-02f, 5.22799231e-03f, -3.87048163e-02f, 6.72185272e-02f,
  -2.99584828e-02f, 7.62319118e-02f, 3.97932008e-02f, 5.09123020e-02f, -2.50363983e-02f, -3.76264341e-02f, 4.53044884e-02f, -4.97962087e-02f, -1.54249454e-02f, -4.00792137e-02f,
  3.37142572e-02f, -2.33506430e-02f, 9.06385183e-02f, -3.31433155e-02f, -7.95123354e-03f, 3.26183215e-02f, 3.65447253e-02f, -1.95888206e-02f, 2.84165163e-02f, -1.22157326e-02f,
  2.06141606e-01f, 1.74386010e-01f, -4.94071096e-02f, -5.96746393e-02f, -2.62933876e-02f, -1.14055425e-01f, -1.79963224e-02f, -3.56285721e-02f, -1.83888942e-01f, -8.73492211e-02f,
  -2.38299761e-02f, 1.22705862e-01f, -7.14683011e-02f, 1.57091156e-01f, 1.73390761e-01f, -7.52193406e-02f, 7.08418638e-02f, -3.80394310e-02f, 2.09054034e-02f, 2.14579664e-02f,
  1.00939654e-01f, 8.94894227e-02f, 9.41470116e-02f, 6.75691441e-02f, 3.13950293e-02f, -1.35189984e-02f, 9.04306546e-02f, 8.67921580e-03f, 1.05180055e-01f, 2.94252690e-02f,
  -9.23041999e-02f, 6.65394589e-02f, -8.85149539e-02f, -7.74323568e-02f, 1.12464558e-02f, 1.09667554e-02f, 2.54460592e-02f, 6.66084373e-03f, -7.08110183e-02f, 2.38702819e-02f,
  9.66380090e-02f, -4.91012707e-02f, -3.15018669e-02f, 1.16498461e-02f, 5.79494461e-02f, -4.84213047e-02f, 2.04093140e-02f, -6.57529980e-02f, -4.49287370e-02f, -1.35780200e-02f,
  4.78219204e-02f, 2.65302062e-02f, -8.66669789e-02f, -5.69231622e-02f, 5.53716123e-02f, 7.56796077e-02f, -5.39440811e-02f, 1.00122944e-01f, 1.04416408e-01f, 2.77354028e-02f,
  -4.28134203e-02f, 6.57010302e-02f, -1.63751505e-02f, 3.16325687e-02f, 1.02847070e-01f, -1.00475818e-01f, 4.35547158e-02f, -3.67325842e-02f, -9.52566415e-02f, -2.35389415e-02f,
  5.98631799e-02f, -5.41385151e-02f, 1.52076315e-03f, 3.46625820e-02f, -3.50960493e-02f, 4.84573543e-02f, 3.58788967e-02f, -5.25034294e-02f, 2.34319475e-02f, 2.43069418e-02f,
  -1.01374529e-01f, -5.46562821e-02f, -9.44094639e-03f, 3.26379649e-02f, -3.09690516e-02f, 4.89660027e-03f, -4.40884009e-02f, 2.80057080e-02f, -1.05213737e-02f, -4.69924733e-02f,
  7.38250911e-02f, 5.80436736e-02f, -4.70066182e-02f, 5.84314279e-02f, -8.34956616e-02f, 1.71458293e-02f, 6.48563281e-02f, 4.35158191e-03f, 4.95946184e-02f, 5.70981763e-02f,
  -5.50229922e-02f, -4.74453829e-02f, -2.85004415e-02f, -7.16355219e-02f, 3.06654721e-02f, -6.38671517e-02f, -4.70682457e-02f, -3.13366391e-03f, 3.98143344e-02f, 1.15205988e-01f,
  -5.14220856e-02f, 3.15032862e-02f, 8.63176212e-02f, -1.18465219e-02f, 1.50472037e-02f, -9.38892514e-02f, 5.74620664e-02f, -7.16606081e-02f, -2.65902523e-02f, -3.60479504e-02f,
  2.37921044e-01f, -2.51732841e-02f, 1.92893803e-01f, 2.71471679e-01f, -5.65567147e-03f, -4.92044315e-02f, 1.09690264e-01f, 1.10147007e-01f, 3.85560274e-01f, -7.34270662e-02f,
  -3.63545790e-02f, 1.36545986e-01f, -1.56675860e-01f, 8.64867344e-02f, -1.81380883e-01f, -8.19877684e-02f, -6.48942068e-02f, 6.96264729e-02f, 1.12442680e-01f, 1.49323121e-01f,
  8.63307044e-02f, -6.25006109e-02f, -5.03890626e-02f, -2.20284343e-01f, 2.85291043e-03f, 3.13880946e-03f, -2.97654301e-01f, -2.96985228e-02f, -5.30088022e-02f, -1.51847273e-01f,
  1.15218740e-02f, 5.88300601e-02f, -5.15867025e-02f, 3.48884724e-02f, 5.41875064e-02f, -6.53998554e-02f, 2.22260151e-02f, -1.10105723e-01f, -1.43809700e-02f, 3.14202458e-02f,
  8.91363248e-02f, -7.25479722e-02f, 1.14323106e-02f, 3.19812745e-02f, 3.16463038e-02f, 5.47177382e-02f, 6.77302182e-02f, 4.41872552e-02f, 2.09317040e-02f, -1.14149619e-02f,
  3.62757631e-02f, 7.85364956e-02f, -7.20909215e-04f, -5.67156412e-02f, 4.80269156e-02f, -5.76134883e-02f, -6.85055107e-02f, -5.29266894e-02f, 1.24282958e-02f, 3.32630239e-02f,
  -7.95464069e-02f, -1.68695431e-02f, 6.69785440e-02f, -1.33925853e-02f, 4.81754653e-02f, -9.94111979e-05f, 9.35648829e-02f, 5.61077669e-02f, -2.92921513e-02f, -8.61829147e-02f,
  -2.96859965e-02f, 1.22210383e-02f, 4.19846773e-02f, -4.72797602e-02f, 6.96479976e-02f, 6.49162531e-02f, -6.38857037e-02f, 6.21741638e-02f, 8.15614909e-02f, 3.95963639e-02f,
  -8.07584226e-02f, -4.82591242e-03f, -7.89874420e-02f, -5.49412072e-02f, 1.86112393e-02f, 4.54052389e-02f, -7.30801895e-02f, 9.20439288e-02f, 3.05084195e-02f, -4.19503488e-02f,
  2.93986257e-02f, -7.00288638e-02f, -3.21466215e-02f, -3.44011635e-02f, -5.46669178e-02f, -3.83475460e-02f, 6.89373910e-03f, -6.23948639e-03f, -5.24900556e-02f, 9.06667020e-03f,
  1.41183240e-02f, 1.12145640e-01f, 2.35178005e-02f, -5.55769019e-02f, 8.66800547e-03f, -1.00027397e-02f, -6.90048793e-03f, -1.04953863e-01f, -1.90771595e-02f, -8.65261853e-02f,
  4.05861735e-02f, 3.13073173e-02f, 1.65250339e-02f, 8.58969614e-02f, -7.58791342e-02f, 1.36713940e-03f, 6.65440857e-02f, -4.94224280e-02f, 9.55511816e-03f, -6.68235570e-02f,
  -1.57206636e-02f, -1.03702754e-01f, 2.09637046e-01f, 1.96329355e-01f, 6.80378079e-02f, -5.70704900e-02f, -1.08615058e-02f, 1.54233396e-01f, 1.83390260e-01f, -6.43847585e-02f,
  -3.41312028e-02f, -1.48803353e-01f, -3.22832423e-03f, 9.62006822e-02f, -2.42876168e-03f, -5.90082295e-02f, -2.93716807e-02f, -9.17433649e-02f, 1.28845662e-01f, -1.52889574e-02f,
  7.96678588e-02f, -1.17587820e-01f, 6.68678507e-02f, -7.56585225e-02f, 5.47459200e-02f, -5.19197732e-02f, -1.14145130e-01f, -9.98063013e-02f, -7.37971514e-02f, -1.13859840e-01f,
  -3.24147791e-02f, 9.00168270e-02f, 4.53096591e-02f, 4.17608321e-02f, 2.97003170e-03f, -7.10473806e-02f, 1.69436110e-03f, -9.28951353e-02f, 9.20232758e-02f, 2.02058032e-02f,
  -9.15095285e-02f, 4.62590158e-02f, 2.39873286e-02f, -4.84715812e-02f, 3.51087898e-02f, 5.79820909e-02f, 1.19541936e-01f, 8.09061006e-02f, 5.31720966e-02f, 8.42819586e-02f,
  6.38127420e-03f, 8.05223957e-02f, -8.96388013e-03f, -4.34098728e-02f, 9.89161059e-02f, 8.43809247e-02f, 2.72277351e-02f, -7.80189782e-02f, -6.16542846e-02f, 1.83195341e-03f,
  -7.83710182e-02f, -1.61510054e-02f, -4.73753959e-02f, -2.39002090e-02f, -1.22022359e-02f, 1.54279610e-02f, 3.83883491e-02f, -5.02528362e-02f, 9.11244228e-02f, -7.81694502e-02f,
  -8.72439444e-02f, 7.05470070e-02f, 5.34968413e-02f, -7.21042305e-02f, -5.75288944e-02f, 3.64333354e-02f, 1.34326657e-02f, 4.13097776e-02f, -7.67066926e-02f, 7.17912093e-02f,
  8.28367472e-02f, -5.61821237e-02f, -9.47347879e-02f, 1.38033256e-02f, 2.99932342e-02f, 6.33115843e-02f, 5.69394454e-02f, -5.20281643e-02f, 4.52795215e-02f, 4.94715013e-02f,
  -3.29937451e-02f, 3.13083977e-02f, -1.23038618e-02f, -3.15818377e-02f, 8.84930938e-02f, -2.10530567e-03f, 6.93702251e-02f, 6.22439794e-02f, -3.78703699e-02f, -5.90131059e-02f,
  -6.40698895e-02f, -6.85879290e-02f, 2.39897743e-02f, -5.57316951e-02f, -1.00907788e-01f, -5.27019333e-03f, -3.65949608e-02f, -8.85290354e-02f, 3.06710526e-02f, -9.44573283e-02f,
  -1.73963103e-02f, 5.38743148e-03f, 4.02190629e-03f, -2.23211711e-03f, -6.11787662e-02f, -1.79146100e-02f, 2.06373017e-02f, 3.03227603e-02f, -2.21720077e-02f, 5.64005284e-04f,
  -8.52427930e-02f, 1.78031102e-02f, 3.89777832e-02f, 2.37382632e-02f, 1.47342563e-01f, 1.68337420e-01f, -3.34913544e-02f, 9.13745090e-02f, -3.62157784e-02f, -8.37924182e-02f,
  -1.96002468e-01f, -1.39151558e-01f, -2.17280060e-01f, -5.16059324e-02f, -6.53663948e-02f, -1.56601563e-01f, -7.53618404e-02f, -1.34150103e-01f, 1.03439733e-01f, -1.36027625e-02f,
  2.46550553e-02f, 2.72573698e-02f, 6.44079670e-02f, 1.81249648e-01f, -3.55137140e-02f, 1.08126186e-01f, -5.99970147e-02f, 6.25501126e-02f, 1.31598651e-01f, 6.29614741e-02f,
  -2.96477065e-03f, -1.40088320e-01f, -5.68214022e-02f, -1.04505653e-02f, 1.05414428e-02f, -8.11914802e-02f, -7.79390112e-02f, 4.36127512e-03f, -1.08557486e-03f, 9.94420797e-02f,
  -6.04592636e-02f, 6.98979050e-02f, 7.00281002e-03f, 5.00922501e-02f, 4.81367894e-02f, 4.85550798e-02f, 9.08655673e-02f, 1.07123233e-01f, 7.16324225e-02f, -2.85084825e-02f,
  9.67016965e-02f, 1.10330008e-01f, -3.69187221e-02f, -7.93628618e-02f, 1.60123035e-02f, 1.24444151e-02f, 1.08109377e-02f, 2.62640342e-02f, 3.67860943e-02f, -4.28329222e-02f,
  -5.60560897e-02f, -4.21513757e-03f, -5.30084446e-02f, -1.35267302e-02f, 6.82026669e-02f, 1.33924894e-02f, -7.17083961e-02f, 6.04331940e-02f, 9.19770971e-02f, 4.43929993e-02f,
  -5.82573712e-02f, -9.26107615e-02f, 6.00064062e-02f, 8.15659091e-02f, 1.59259234e-02f, -5.54619469e-02f, 7.93586224e-02f, -2.00423598e-02f, 3.74433100e-02f, -8.89503688e-04f,
  -3.89033332e-02f, -4.85878363e-02f, -7.77476132e-02f, -4.64090630e-02f, -3.84097546e-02f, 5.13075292e-02f, 6.92000091e-02f, 1.28141679e-02f, -5.83322020e-03f, 4.36162092e-02f,
  -1.14989698e-01f, -1.60765946e-01f, 6.26309291e-02f, 6.27542883e-02f, -5.34613617e-02f, 7.29194097e-03f, 4.20672894e-02f, 1.50106521e-02f, -1.01451121e-01f, -4.62869294e-02f,
  -1.15970522e-02f, -1.44386385e-02f, -8.49447548e-02f, 1.23634813e-02f, -8.11284408e-02f, -3.11415344e-02f, 6.77845627e-03f, -7.78181255e-02f, -2.28667166e-02f, 8.25713277e-02f,
  4.99424189e-02f, -5.53802680e-03f, -8.05673376e-02f, 8.71650800e-02f, -1.60498067e-03f, -8.88407603e-02f, -3.17657702e-02f, 6.85055554e-02f, 4.01901379e-02f, 7.33512640e-02f,
  -1.92469135e-01f, -1.42732605e-01f, 9.12351087e-02f, -1.75108433e-01f, 1.94383208e-02f, 1.55437812e-01f, 6.00870252e-02f, 7.77954469e-03f, -1.67431086e-01f, -7.22505972e-02f,
  4.21153232e-02f, -3.68990935e-02f, 1.93771664e-02f, -1.17803082e-01f, -1.74339656e-02f, -1.09835230e-01f, 5.55703826e-02f, 2.17841677e-02f, -3.63659151e-02f, -7.43874982e-02f,
  -8.73634871e-03f, 6.79957941e-02f, 4.90846299e-02f, 9.12825093e-02f, -6.01465181e-02f, -1.02552019e-01f, -4.86932099e-02f, 5.70125654e-02f, 6.90406784e-02f, 1.08003005e-01f,
  -7.25185424e-02f, 3.07170115e-02f, 2.14235857e-02f, -1.52274854e-02f, 7.82705396e-02f, 9.55169722e-02f, 1.83053706e-02f, 8.63033608e-02f, -2.86717955e-02f, 9.62695107e-02f,
  -3.35867032e-02f, 3.76195312e-02f, -1.04850316e-02f, 8.32592621e-02f, -7.59116933e-02f, -3.80202308e-02f, 3.54092531e-02f, -6.38167635e-02f, -4.84963097e-02f, 8.39602500e-02f,
  7.48872086e-02f, 8.85853693e-02f, -1.02256546e-02f, 4.06133709e-03f, 6.77577704e-02f, -5.10501079e-02f, 4.33661267e-02f, 2.13125488e-03f, -5.55828251e-02f, -1.14787612e-02f,
  3.51531291e-03f, 2.04934785e-03f, -2.90696062e-02f, -2.08289698e-02f, -3.06775756e-02f, 2.63126101e-03f, -3.71238552e-02f, 3.94471027e-02f, 6.75700903e-02f, -6.41702861e-02f,
  8.42885897e-02f, -3.78614441e-02f, 5.14893048e-02f, 1.38982730e-02f, -4.37496267e-02f, -1.26623577e-02f, 2.61530653e-02f, -4.71500643e-02f, -3.84729356e-02f, -3.23924795e-02f,
  5.87766729e-02f, 5.98597154e-02f, -7.12592602e-02f, -6.28191531e-02f, 7.05195665e-02f, 6.11162037e-02f, -8.18741322e-02f, 2.14623548e-02f, -3.27813588e-02f, -8.57001022e-02f,
  -3.80332470e-02f, -1.22503750e-01f, 3.58610228e-02f, -3.46410722e-02f, -9.62649100e-03f, 6.41294271e-02f, -5.02525009e-02f, 4.79816794e-02f, -6.60397634e-02f, -5.86796626e-02f,
  -3.90372761e-02f, 3.91512625e-02f, 1.51631208e-02f, 6.73364569e-03f, 9.78571642e-03f, 6.44300878e-02f, -6.19868934e-02f, -6.55835196e-02f, 5.49907424e-02f, 2.47233431e-03f,
  -1.63652953e-02f, -2.53826752e-02f, 5.26307561e-02f, -7.16758296e-02f, -6.79505467e-02f, 7.77589902e-02f, 2.22675633e-02f, 8.71813819e-02f, -8.93881265e-03f, -7.14554191e-02f,
  -5.58235347e-02f, -1.11603856e-01f, 1.43507421e-01f, -1.13616101e-01f, 4.76003215e-02f, 1.03499621e-01f, 6.97802454e-02f, -9.98668745e-02f, -1.89207777e-01f, -1.75952300e-01f,
  -3.22317258e-02f, -2.71717086e-02f, 1.02629893e-01f, -1.21791949e-04f, 2.97734290e-02f, 1.05597138e-01f, -8.46025795e-02f, -8.90086815e-02f, 6.17824905e-02f, 9.54553783e-02f,
  1.60042532e-02f, 4.77684289e-02f, 6.46291897e-02f, 9.93239954e-02f, -5.58346175e-02f, -9.31655690e-02f, -1.41390547e-01f, 6.05587708e-03f, -1.15837846e-02f, 6.38392791e-02f,
  2.21638251e-02f, 3.22811492e-02f, 1.79104065e-03f, 9.05338079e-02f, -6.03181943e-02f, 1.68252327e-02f, 2.92737167e-02f, -4.51285504e-02f, -6.71420023e-02f, 8.57938975e-02f,
  -7.03856051e-02f, -7.29128122e-02f, -8.12512338e-02f, -8.78839791e-02f, -7.04740873e-03f, -3.03580537e-02f, 2.06592679e-02f, -5.60727976e-02f, 7.30501413e-02f, 7.78648481e-02f,
  -5.42518273e-02f, -1.32265547e-02f, -5.15815392e-02f, -1.14234030e-01f, 2.36511547e-02f, -1.22489631e-01f, -6.63916469e-02f, 9.58733112e-02f, 3.62237059e-02f, -3.25292870e-02f,
  9.78676826e-02f, 2.19062977e-02f, 4.30092216e-02f, -1.06571019e-02f, 2.40630452e-02f, -5.88001348e-02f, -7.07188770e-02f, 4.75425869e-02f, 6.80944473e-02f, -2.67521963e-02f,
  4.77538072e-02f, -3.59702744e-02f, -2.46508271e-02f, -2.82295402e-02f, -7.90448338e-02f, -6.02693111e-02f, -1.87845193e-02f, -3.58468778e-02f, -3.20353210e-02f, -4.19603288e-03f,
  -8.93294290e-02f, -3.46188131e-03f, -7.15390816e-02f, -1.14132846e-02f, 8.02218691e-02f, -2.93432139e-02f, -2.41509676e-02f, -5.87910181e-03f, -1.98588632e-02f, -1.20949596e-02f,
  4.88026924e-02f, -1.20427750e-01f, -5.13672307e-02f, -2.01151444e-04f, -6.14718758e-02f, -5.53975031e-02f, -4.74150144e-02f, -4.41153497e-02f, 9.20743942e-02f, 4.75339182e-02f,
  -6.34199679e-02f, -9.32435244e-02f, -4.46071625e-02f, 7.56607130e-02f, 7.41750523e-02f, 4.64784727e-02f, -6.37455657e-02f, 7.56997988e-02f, 1.08644031e-02f, -5.93057908e-02f,
  5.78864291e-02f, 3.45115596e-03f, 2.94913631e-02f, -2.12171935e-02f, -5.91815785e-02f, -1.25962913e-01f, -7.56331459e-02f, -3.89814377e-02f, 1.73509549e-02f, 1.06523337e-03f,
  -8.66663605e-02f, 4.81916741e-02f, 1.19627900e-01f, -2.73008272e-03f, 4.56685349e-02f, -1.36105999e-01f, -2.28137989e-02f, 8.67806450e-02f, 1.72175076e-02f, 8.55757669e-02f,
  3.75421457e-02f, 2.24756822e-03f, 7.37858936e-02f, -6.66638762e-02f, -2.23057747e-01f, 2.13105604e-03f, -1.27703371e-02f, -3.30508277e-02f, 6.06590137e-02f, 2.13275431e-03f,
  -7.19130263e-02f, -6.90274537e-02f, 5.15342280e-02f, 1.71870682e-02f, 1.25620663e-01f, -4.97268327e-02f, -1.02423634e-02f, 4.18288335e-02f, -2.69709900e-02f, -7.71606341e-02f,
  9.64354575e-02f, 7.24887848e-02f, -1.52027337e-02f, 3.25164385e-02f, -1.31519232e-02f, 5.33682406e-02f, 4.38191034e-02f, -1.28618404e-02f, -7.54533485e-02f, -7.91005567e-02f,
  5.19500487e-03f, 4.35289554e-02f, 7.83366188e-02f, 1.14791142e-02f, 8.78314674e-02f, 4.68129963e-02f, 7.97673836e-02f, -6.06487133e-02f, 9.44256559e-02f, 9.06124488e-02f,
  -6.23338902e-03f, -6.70912191e-02f, -1.29615432e-02f, 7.84596577e-02f, 9.26834121e-02f, 1.02954671e-01f, -9.18488204e-02f, -4.05848473e-02f, -3.75285149e-02f, 8.26064218e-03f,
  -9.90214422e-02f, 5.00959530e-03f, -7.67815709e-02f, 9.79289412e-02f, 2.87916064e-02f, 7.36652091e-02f, 9.00106318e-03f, -7.17035756e-02f, 3.03877778e-02f, 7.97554106e-02f,
  6.13777712e-02f, -3.93386148e-02f, 1.54104540e-02f, 6.79137409e-02f, 5.20135313e-02f, 3.45025472e-02f, 7.05092475e-02f, 4.08424102e-02f, -3.08369230e-02f, 4.54534404e-03f,
  2.83949059e-02f, 6.52537644e-02f, 8.02435502e-02f, -3.40426192e-02f, 5.72630316e-02f, 5.03580943e-02f, 4.46158946e-02f, -5.43161184e-02f, -1.29508367e-02f, -3.42996581e-03f,
  -8.02921578e-02f, -1.57508954e-01f, -3.64732854e-02f, -5.85142802e-03f, -4.74706329e-02f, -1.99670997e-02f, -8.52418244e-02f, -5.48743121e-02f, -5.71091920e-02f, 3.45266797e-02f,
  -5.92166670e-02f, 7.47321993e-02f, 2.54241982e-04f, 7.63763711e-02f, 6.19032495e-02f, 5.06298207e-02f, -1.04599535e-01f, -6.46807700e-02f, 9.46501270e-03f, 2.50685792e-02f,
  3.30849588e-02f, 8.83107409e-02f, 7.91832581e-02f, -6.53404072e-02f, -3.21343169e-02f, 6.95749968e-02f, -1.08075343e-01f, -1.42555800e-03f, -8.28910768e-02f, -8.66847932e-02f,
  5.46069350e-03f, 9.44766849e-02f, 3.55951823e-02f, -4.18183915e-02f, -6.37952313e-02f, -1.99194714e-01f, 3.22397836e-02f, 1.88625436e-02f, 1.38004035e-01f, -8.25339109e-02f,
  -1.05606660e-01f, 1.21742927e-01f, 8.52060765e-02f, -8.97512585e-02f, -1.09821772e-02f, -7.86075182e-03f, -1.80034041e-01f, 6.09319285e-02f, 8.52505565e-02f, -3.92805897e-02f,
  1.10327015e-02f, -1.01752736e-01f, -5.70801087e-02f, -1.14068404e-01f, -3.81545648e-02f, -7.56965280e-02f, -8.25657323e-02f, -5.38813546e-02f, -9.49160021e-04f, 4.57259156e-02f,
  -1.06784202e-01f, -4.39115316e-02f, 4.13486846e-02f, 7.46045634e-02f, -9.23033506e-02f, 8.32613632e-02f, 3.72471325e-02f, -1.29736271e-02f, -5.23071848e-02f, -4.58185971e-02f,
  7.84685612e-02f, -5.53797893e-02f, -7.32897148e-02f, 9.38189998e-02f, 3.44602317e-02f, -2.83648353e-02f, -1.94180515e-02f, 1.85018498e-02f, -3.28024700e-02f, -6.45096526e-02f,
  2.15169787e-02f, -3.70560028e-02f, -6.67027086e-02f, 5.40568270e-02f, 5.82779832e-02f, -4.92335036e-02f, 4.98524159e-02f, -2.02015340e-02f, 3.91981564e-02f, 3.78221050e-02f,
  -1.92396007e-02f, 8.42514932e-02f, -7.76589140e-02f, -9.11353752e-02f, -5.05644903e-02f, 3.81578431e-02f, 9.08762217e-02f, -3.81375998e-02f, 1.23309123e-03f, 4.32577021e-02f,
  -9.16267652e-03f, -4.24087606e-02f, -9.92818177e-03f, -3.06428820e-02f, 6.57606870e-02f, 4.03032042e-02f, -7.90554211e-02f, 2.69945543e-02f, -6.27042446e-03f, -2.84922533e-02f,
  2.79204641e-03f, 5.47938459e-02f, 2.42577810e-02f, -2.45292485e-02f, -9.91020575e-02f, 7.00286478e-02f, 1.02575766e-02f, 8.04142281e-02f, 6.81379363e-02f, -4.51469794e-02f,
  -4.00098078e-02f, 4.27820459e-02f, 8.72544199e-02f, 8.49143192e-02f, 9.61403176e-02f, -3.44586149e-02f, 3.82938609e-02f, 2.28388272e-02f, 3.78378620e-03f, -1.08073023e-03f,
  3.57966684e-02f, 7.81153291e-02f, 4.48828787e-02f, 2.89920066e-02f, -1.25859836e-02f, 2.30505913e-02f, 9.12326798e-02f, -5.88666201e-02f, 7.08729122e-03f, 7.98303932e-02f,
  8.31789225e-02f, 5.75042590e-02f, 1.63106471e-02f, -3.80810201e-02f, -3.26960608e-02f, -8.53348970e-02f, -2.53086463e-02f, 1.02840841e-01f, 2.35206988e-02f, -7.76306763e-02f,
  -3.91578227e-02f, -2.81883627e-01f, 1.71139315e-01f, -2.12305393e-02f, 1.49635270e-01f, 1.07374929e-01f, 5.29416092e-02f, 2.25999821e-02f, -1.28899980e-02f, -1.99214280e-01f,
  1.49295060e-02f, -8.95479769e-02f, -8.14565718e-02f, -9.29567218e-02f, 3.44640613e-02f, -3.20859700e-02f, -9.59095135e-02f, -3.87397557e-02f, 3.97796929e-02f, 8.58512297e-02f,
  -3.76812071e-02f, -4.78494987e-02f, 2.38763895e-02f, -9.92105156e-02f, 2.92513985e-02f, -9.42367222e-03f, -4.98283505e-02f, 1.35311624e-03f, 1.62401032e-02f, 1.95860378e-02f,
  -1.06078558e-01f, -5.71475849e-02f, 1.90179199e-02f, -5.62465116e-02f, 9.71664339e-02f, -6.47032633e-02f, 4.15587798e-02f, -3.83336737e-06f, -4.10972014e-02f, 2.96191517e-02f,
  -8.53501558e-02f, -4.04424360e-03f, -6.33257478e-02f, 1.49222212e-02f, -5.41510694e-02f, 4.99228798e-02f, 8.99971928e-03f, 2.31437851e-02f, 1.36911301e-02f, -2.26450432e-02f,
  6.94768503e-02f, -7.71870390e-02f, -7.66973048e-02f, 2.33482625e-02f, -4.55085263e-02f, 2.56035253e-02f, 1.50600215e-02f, 4.29020822e-02f, -2.70732418e-02f, -1.73324049e-02f,
  4.80661504e-02f, 6.16877154e-02f, 5.33089265e-02f, 3.73043269e-02f, -9.68189072e-03f, 1.01027682e-01f, 3.80951762e-02f, -5.94479777e-02f, -2.49777269e-02f, 7.17429817e-02f,
  -8.51682574e-03f, -2.14778557e-02f, -6.80811629e-02f, 3.93728949e-02f, -6.52644038e-02f, 1.05198538e-02f, -2.53938474e-02f, -9.11656693e-02f, -2.18052766e-03f, -8.77010971e-02f,
  -5.26555404e-02f, -3.34537737e-02f, 1.90767471e-03f, 8.38491768e-02f, 6.80368245e-02f, -8.53807945e-03f, -5.00317216e-02f, -9.49655753e-03f, 9.37537253e-02f, 4.92284708e-02f,
  -1.51498303e-01f, -9.53952596e-02f, -6.04756810e-02f, 4.32811342e-02f, -4.89004962e-02f, -7.51641691e-02f, 6.19428009e-02f, -3.50283198e-02f, 2.41978727e-02f, 4.43333760e-02f,
  7.71465749e-02f, 4.81930226e-02f, -4.58116904e-02f, 6.43946156e-02f, 3.91490869e-02f, 6.52513728e-02f, -7.10947886e-02f, -1.00265406e-01f, 5.32493033e-02f, -5.94077222e-02f,
  2.25404594e-02f, 6.74512982e-02f, -5.72024882e-02f, -3.00930790e-03f, 3.64045240e-03f, 4.13885415e-02f, -6.27330244e-02f, 4.35227193e-02f, -5.28906435e-02f, 1.25946179e-02f,
  -4.51127738e-02f, -6.22226410e-02f, -7.30006248e-02f, 1.51461512e-01f, -1.11751378e-01f, -1.89954460e-01f, -1.23507179e-01f, -8.70849937e-03f, 5.48222288e-03f, 8.61736238e-02f,
  4.24871147e-02f, 4.82479110e-02f, 5.92317581e-02f, -1.06321964e-02f, 1.01253010e-01f, 8.76334906e-02f, 1.22063443e-01f, 2.75292899e-03f, 7.51076564e-02f, 4.38580103e-02f,
  4.52297069e-02f, -8.07450563e-02f, 1.38534009e-01f, -1.39062956e-01f, -9.25844610e-02f, 2.11912934e-02f, 1.29960373e-01f, -1.05794713e-01f, -7.81712234e-02f, -3.68740186e-02f,
  -6.66619539e-02f, -8.75656605e-02f, -9.56743062e-02f, 4.37907409e-03f, -3.40067297e-02f, -6.73905909e-02f, 3.88926715e-02f, 5.46739809e-03f, -5.31214736e-02f, -3.46610732e-02f,
  -3.31116542e-02f, -5.78561500e-02f, 9.64318439e-02f, -4.04950716e-02f, 2.41030077e-03f, 2.73530278e-02f, 2.19597248e-03f, -6.49026036e-02f, 1.48083065e-02f, -5.32730147e-02f,
  -5.40124215e-02f, 2.15414502e-02f, 8.61189887e-02f, -4.83034290e-02f, -5.17643578e-02f, 5.42350337e-02f, 1.12153608e-02f, 5.58010638e-02f, -8.40447396e-02f, -2.02357881e-02f,
  -4.81599085e-02f, 2.21766811e-02f, -6.54198080e-02f, -1.12712122e-02f, -7.79715716e-04f, -5.49522974e-02f, 1.43016484e-02f, 7.24097490e-02f, -1.46027692e-02f, 1.24730552e-02f,
  5.13679460e-02f, 9.91646852e-03f, 1.87938809e-02f, -4.52178121e-02f, -5.23175625e-03f, -3.34932655e-02f, -3.88891399e-02f, 1.13719851e-02f, -2.28752568e-02f, 4.63530645e-02f,
  -2.23508514e-02f, -1.02450795e-01f, 1.69687551e-02f, -1.31299626e-02f, 5.71209267e-02f, 3.14544179e-02f, 5.67558147e-02f, -7.26314485e-02f, 8.96246582e-02f, 4.10079919e-02f,
  -9.74290669e-02f, 5.02404496e-02f, 4.45285887e-02f, -3.27691473e-02f, 2.36960407e-02f, -7.58659327e-03f, 5.01277559e-02f, -6.75436631e-02f, 3.37278377e-03f, -4.75126244e-02f,
  -7.61607513e-02f, -3.45861465e-02f, -3.94634455e-02f, 4.14021686e-02f, 5.48006557e-02f, 6.14314079e-02f, -4.16157357e-02f, -4.84074205e-02f, -4.51329425e-02f, 4.01271060e-02f,
  -7.50485994e-03f, -6.78906292e-02f, 9.46133807e-02f, -9.45505593e-03f, 1.05713531e-01f, -4.58685085e-02f, -6.53964207e-02f, 1.38065647e-04f, -6.84169456e-02f, -1.37519715e-02f,
  -1.70586750e-01f, 5.72991669e-02f, -7.77373686e-02f, 4.33731563e-02f, -1.79894730e-01f, 2.99810171e-02f, 1.45320654e-01f, 1.01246396e-02f, -2.71756109e-02f, 2.09728643e-01f,
  1.75953150e-01f, -4.70959656e-02f, 6.88392669e-02f, 2.71444559e-01f, 2.99121384e-02f, 1.50858641e-01f, 2.68681198e-01f, 2.41540492e-01f, 4.52976823e-02f, -2.10797996e-03f,
  -5.63236251e-02f, 1.37843922e-01f, 8.91548619e-02f, 3.45372548e-03f, 4.67240661e-02f, -1.06103212e-01f, -5.11563122e-02f, -9.61668342e-02f, 1.73835047e-02f, 1.15233194e-02f,
  1.01445101e-01f, 6.12204242e-03f, -6.30112290e-02f, -3.00693093e-03f, 1.13697723e-02f, 1.09116035e-02f, -7.09513761e-03f, 6.08931947e-03f, -5.37296049e-02f, 2.92185005e-02f,
  -5.89603521e-02f, -7.83792436e-02f, -9.43690445e-03f, 1.12098195e-02f, 4.82973307e-02f, -4.03540544e-02f, 3.76854837e-02f, -3.84570658e-02f, 6.17866255e-02f, -3.83053236e-02f,
  4.16114479e-02f, 3.83702628e-02f, 2.21256390e-02f, 4.42486703e-02f, -2.21181531e-02f, 6.40519662e-03f, 3.05774547e-02f, -6.17566109e-02f, -5.70398457e-02f, -1.54558206e-02f,
  3.04880757e-02f, -2.97028683e-02f, 9.29474309e-02f, -7.00621977e-02f, 2.60463748e-02f, 2.82746311e-02f, -1.52831413e-02f, 6.55796602e-02f, -7.02875033e-02f, 6.78475425e-02f,
  1.85909495e-02f, -9.96759627e-03f, 6.11865371e-02f, 6.58403784e-02f, 2.64373701e-02f, 4.93746772e-02f, -5.01836389e-02f, 5.14760090e-04f, 2.75281966e-02f, 6.98605850e-02f,
  -4.50244173e-02f, -2.18007453e-02f, 1.79228541e-02f, 1.79615635e-02f, -1.56120257e-02f, 3.14866230e-02f, 5.23705892e-02f, -6.96565211e-02f, -5.77075593e-02f, -6.38433471e-02f,
  5.28793260e-02f, -1.79496557e-02f, 4.51854244e-02f, 3.63192125e-03f, -1.08824102e-02f, -1.13699473e-02f, 3.52295348e-03f, -2.88442392e-02f, 5.16096763e-02f, 3.13818417e-02f,
  -9.08563584e-02f, 8.77040103e-02f, 4.81900908e-02f, -3.95724699e-02f, -2.24433653e-02f, -1.72343396e-03f, 6.31778613e-02f, 2.40309201e-02f, -4.88269404e-02f, -2.79214885e-02f,
  -8.00011680e-02f, 9.17311478e-03f, -7.23250359e-02f, -3.16591598e-02f, -4.30536456e-02f, -5.45623936e-02f, -7.04676844e-03f, 1.99174583e-02f, -4.45976779e-02f, -5.51023409e-02f,
  -6.27214238e-02f, 2.96333078e-02f, 3.74608673e-02f, 5.42619862e-02f, -7.85036534e-02f, -2.78143793e-01f, -1.13181040e-01f, 9.24972519e-02f, 6.64859638e-02f, 5.20872846e-02f,
  5.94628640e-02f, 3.21234725e-02f, 7.96779152e-03f, 9.20723155e-02f, -1.64412018e-02f, 6.57319929e-03f, -1.44988298e-01f, -1.37931839e-01f, -7.17451572e-02f, -3.41420583e-02f,
  -3.98845337e-02f, 1.14368409e-01f, 4.62228172e-02f, 1.14809684e-01f, 7.45185763e-02f, 5.36996350e-02f, 3.95396017e-02f, 5.09975739e-02f, -4.72352002e-03f, -8.58962461e-02f,
  -4.72875237e-02f, 1.83879375e-01f, -2.97036977e-03f, -1.89111680e-02f, 4.86331731e-02f, 2.89417077e-02f, 4.97274809e-02f, -1.47978533e-02f, 2.70486735e-02f, -5.21461777e-02f,
  4.47575748e-02f, 4.06026356e-02f, 4.39627953e-02f, 3.51424031e-02f, 7.48346671e-02f, -5.87869156e-03f, -1.21408459e-02f, -8.00016802e-03f, 2.14156834e-03f, 3.49233076e-02f,
  1.55357374e-02f, -8.83489251e-02f, 7.53713772e-02f, -3.68800908e-02f, 6.52430803e-02f, -1.64118165e-03f, -8.55544880e-02f, -1.63184348e-04f, -2.86531206e-02f, 6.59041330e-02f,
  6.11218251e-03f, -8.50691348e-02f, -2.78903116e-02f, -3.30316648e-02f, 4.28700494e-03f, -2.25766953e-02f, -4.53640595e-02f, 2.93685012e-02f, -4.46865633e-02f, -2.25654542e-02f,
  -8.99839997e-02f, 5.28849289e-02f, -5.06163649e-02f, -1.81185491e-02f, -5.29542267e-02f, -5.40959649e-02f, -8.39802027e-02f, 1.50578488e-02f, 2.27932837e-02f, -7.05580786e-02f,
  4.46261577e-02f, -5.90863191e-02f, 6.59745187e-02f, 6.99085519e-02f, -6.73151761e-02f, 1.89244151e-02f, -5.94226569e-02f, 6.64179102e-02f, 6.28077388e-02f, -7.70369992e-02f,
  -3.88067635e-03f, 1.21764287e-01f, 4.47131246e-02f, 2.57618856e-02f, -4.66002263e-02f, -2.12177075e-02f, -5.77424187e-03f, -9.10193622e-02f, 8.96785483e-02f, -8.19728449e-02f,
  4.90748673e-04f, -1.93619286e-03f, -7.91300461e-02f, -4.36627865e-02f, -2.97645982e-02f, -7.09849820e-02f, -1.36947129e-02f, -9.26068872e-02f, -1.06010621e-03f, 2.57120263e-02f,
  7.27794170e-02f, 4.52671237e-02f, -2.22584195e-02f, -3.97058684e-05f, -6.72639087e-02f, 2.90390309e-02f, -5.96735105e-02f, -3.25816013e-02f, 5.94683699e-02f, -2.72294804e-02f,
  -1.43274993e-01f, 8.38781446e-02f, 1.35869294e-01f, -6.31666137e-03f, -5.34433946e-02f, 1.36398673e-01f, 1.13544136e-01f, -8.81146581e-04f, -5.85143194e-02f, -1.18019558e-01f,
  -1.18346401e-01f, -4.33411673e-02f, 1.52493209e-01f, 5.83390379e-03f, 1.04228310e-01f, -1.70925190e-03f, 5.76765388e-02f, -7.34484941e-02f, 6.53924271e-02f, 5.80850057e-02f,
  -1.03648059e-01f, 2.07347590e-02f, 4.43417765e-02f, -9.09125805e-02f, -7.74477124e-02f, -3.64956148e-02f, -1.43871024e-01f, 6.04590736e-02f, -2.84861252e-02f, 7.77469277e-02f,
  3.38006578e-02f, 2.99983509e-02f, 3.67327221e-02f, 9.18347389e-02f, -2.93768980e-02f, 3.68048949e-03f, -7.26397894e-03f, -5.32224961e-02f, 1.59286261e-02f, -1.29874498e-02f,
  6.87152743e-02f, 7.02365786e-02f, -1.41765957e-03f, -4.86275293e-02f, -6.17322437e-02f, -2.35310178e-02f, -3.82055365e-03f, -2.06933096e-02f, -7.61694601e-03f, -1.77179370e-02f,
  5.20946123e-02f, 8.80747885e-02f, 4.59625348e-02f, 5.41411079e-02f, -3.53632309e-02f, -2.73632188e-03f, -6.74986094e-02f, 6.42921180e-02f, 5.78494258e-02f, 2.46595386e-02f,
  -1.53386453e-02f, -7.81293064e-02f, 5.85488006e-02f, 5.12203164e-02f, -7.06005655e-03f, -7.98134208e-02f, 3.84112331e-03f, 5.51274754e-02f, -9.36745405e-02f, 2.71843523e-02f,
  -4.12614420e-02f, -3.10917888e-02f, -3.29389200e-02f, 6.39696270e-02f, -7.14294787e-04f, 1.04637770e-02f, 7.70605030e-03f, -1.88353937e-02f, 6.57578707e-02f, 8.60591456e-02f,
  -4.17447574e-02f, -4.85679209e-02f, 9.02776718e-02f, -8.99527147e-02f, -1.07925795e-02f, 1.11218235e-02f, 4.13969997e-03f, -4.68212739e-02f, -9.77955908e-02f, 1.44473733e-02f,
  -6.66092262e-02f, -3.49860713e-02f, 3.91495265e-02f, 7.16705546e-02f, 3.41683030e-02f, -3.90917510e-02f, 6.20588772e-02f, 2.87105329e-02f, -1.52929444e-02f, 2.29884870e-02f,
  -8.78651142e-02f, 5.39554544e-02f, 8.39526951e-02f, -4.77390410e-03f, 8.54513049e-02f, -8.71349499e-02f, 6.38142519e-05f, -8.86177178e-03f, -6.54401109e-02f, 5.57457155e-04f,
  8.93877819e-02f, -5.86466081e-02f, 4.51597087e-02f, -1.11231238e-01f, 4.56001721e-02f, 5.88558801e-02f, 1.28267650e-02f, -3.44247706e-02f, 2.46090945e-02f, -4.65301424e-03f,
  2.62812644e-01f, 5.37915640e-02f, -1.67886987e-01f, -1.37103349e-03f, 1.42083364e-02f, 6.44538179e-02f, -7.05840364e-02f, -3.76668572e-02f, -4.90558445e-02f, -2.83717755e-02f,
  1.35579824e-01f, 1.33775698e-03f, -1.28530011e-01f, 1.07017778e-01f, 1.03234917e-01f, -5.65794371e-02f, 1.27026200e-01f, 1.30311191e-01f, -4.84659933e-02f, 1.49505481e-01f,
  1.04125910e-01f, 1.36578798e-01f, -1.19447649e-01f, 1.07487261e-01f, 3.85805890e-02f, -1.18608095e-01f, -1.12973861e-01f, -1.30288318e-01f, -2.09418368e-02f, 1.90723445e-02f,
  1.03618847e-02f, 1.08061351e-01f, -6.07913733e-02f, -8.13158378e-02f, 7.20047653e-02f, 9.36126113e-02f, -6.43350556e-02f, -1.02165250e-04f, -1.00988401e-02f, 7.49929771e-02f,
  3.86726931e-02f, -1.18182898e-02f, 3.03105116e-02f, 3.60748172e-02f, -4.14290018e-02f, 1.30521655e-02f, 6.28576800e-02f, 1.34794097e-02f, -1.31380428e-02f, 5.57424054e-02f,
  -7.27965087e-02f, 4.64510992e-02f, 7.03594834e-02f, -1.05146989e-01f, 4.52231914e-02f, -4.75966223e-02f, -1.01715915e-01f, -1.02732509e-01f, 5.66917984e-03f, 2.94313636e-02f,
  9.88767818e-02f, -3.18341069e-02f, 5.60989305e-02f, 1.09777562e-01f, -1.72218680e-02f, 1.59970648e-03f, 2.87386030e-02f, -1.33694168e-02f, 1.95088759e-02f, 4.29897681e-02f,
  -6.25595823e-02f, 7.95841068e-02f, -5.45664281e-02f, -4.08438332e-02f, 3.03715300e-02f, -4.81643714e-02f, -5.75285815e-02f, -6.46025985e-02f, -4.91035394e-02f, -5.80147766e-02f,
  1.89112290e-03f, 2.63042301e-02f, -5.04638553e-02f, -9.44290608e-02f, -7.32392594e-02f, -8.67125019e-02f, 1.37992930e-02f, -3.29304561e-02f, -5.31123616e-02f, -5.66674843e-02f,
  6.36990070e-02f, 1.82203222e-02f, -1.03202812e-01f, -2.30771359e-02f, 5.89326508e-02f, 9.95356515e-02f, 2.08571181e-02f, 9.15904716e-02f, 6.24440722e-02f, 6.48889085e-03f,
  -2.62600090e-02f, 1.34098651e-02f, 4.84435298e-02f, 9.50087011e-02f, 4.74703237e-02f, 9.42907855e-02f, 5.47886651e-04f, 9.55207855e-04f, 4.03401218e-02f, 6.53611822e-03f,
  3.85329612e-02f, -1.28612127e-02f, 2.01881323e-02f, 3.04602534e-02f, 1.06437646e-01f, 3.17545165e-03f, 2.47229841e-02f, -7.44548663e-02f, -6.17660917e-02f, 1.70659684e-02f,
  -3.00532505e-02f, -3.64620052e-02f, 1.06090538e-01f, 2.49095429e-02f, 2.39640862e-01f, -7.63045251e-02f, 8.91489163e-03f, 1.46500945e-01f, 3.06656003e-01f, -1.13128476e-01f,
  1.78361014e-02f, -1.62041962e-01f, -3.36804166e-02f, -9.18322578e-02f, -1.62464529e-01f, -9.92022902e-02f, -3.24550755e-02f, -4.34081117e-03f, 1.74055710e-01f, 7.45823085e-02f,
  -6.14644475e-02f, -9.51247960e-02f, -4.24063988e-02f, -4.17887010e-02f, 7.10957795e-02f, 2.04490293e-02f, -3.73768397e-02f, 1.20374233e-01f, -1.53362468e-01f, -9.04133171e-03f,
  1.81241296e-02f, -7.04723150e-02f, 1.11316731e-02f, -8.85223672e-02f, 4.61540818e-02f, -9.44969710e-03f, -9.66357365e-02f, 4.55108993e-02f, -1.66005008e-02f, 9.38373730e-02f,
  -7.40326867e-02f, -5.41295763e-03f, 6.54364526e-02f, 1.26178548e-01f, -1.53547870e-02f, 7.14068487e-02f, -2.81466506e-02f, 2.44085789e-02f, 2.52946392e-02f, 1.88499670e-02f,
  3.87128741e-02f, -2.55449098e-02f, -5.19569293e-02f, -1.03321426e-01f, -3.70500460e-02f, -4.89758514e-02f, -6.30270317e-02f, -1.07071092e-02f, -8.33891109e-02f, 3.49629968e-02f,
  6.28129914e-02f, 1.84448920e-02f, 2.85363868e-02f, 1.02726355e-01f, -2.10435055e-02f, 4.03156830e-03f, -5.87870087e-03f, 1.24710416e-02f, -3.82438228e-02f, -8.15990418e-02f,
  7.45367631e-02f, -1.90483406e-03f, -3.93122397e-02f, 7.85689279e-02f, -7.54957029e-04f, 1.52843203e-02f, 5.23739553e-04f, 1.79472696e-02f, 6.13948777e-02f, -2.73840204e-02f,
  4.56200317e-02f, -4.84936051e-02f, -3.72435562e-02f, 6.52594715e-02f, 2.39824783e-02f, 3.76461484e-02f, 8.31219032e-02f, 6.13808865e-03f, -1.61651671e-02f, 6.38686791e-02f,
  -1.33703336e-01f, -7.92669952e-02f, -3.17881033e-02f, -3.85259874e-02f, -1.56639330e-02f, 2.31850464e-02f, -4.05462235e-02f, 1.32112755e-02f, -9.78358835e-02f, 7.34317377e-02f,
  5.23409108e-03f, 6.45198748e-02f, -7.52026290e-02f, -2.17685406e-03f, -5.26504964e-02f, -4.39424738e-02f, 8.16507265e-03f, -1.06610537e-01f, -7.36989155e-02f, 4.65498976e-02f,
  6.35639485e-03f, 5.78794144e-02f, 9.34534799e-03f, -1.50507260e-02f, -3.98252383e-02f, -8.28588605e-02f, -3.81410867e-02f, -1.14758667e-02f, 1.69855934e-02f, -1.72823090e-02f,
  3.32303703e-01f, 1.22179398e-02f, 1.64985925e-01f, 2.79448003e-01f, -9.65127200e-02f, -3.10181051e-01f, -9.80711579e-02f, 8.23298097e-02f, 9.92370248e-02f, -5.25218658e-02f,
  -6.76412368e-03f, -4.40016463e-02f, -9.42701548e-02f, 2.18903542e-01f, 1.11771487e-01f, -5.09568900e-02f, 4.59222123e-02f, 1.94615673e-03f, 1.43408269e-01f, 1.46647066e-01f,
  2.41757900e-01f, 1.35977268e-01f, 2.33525962e-01f, 9.93282571e-02f, 2.25234509e-01f, 1.96965352e-01f, 1.57791048e-01f, -1.02871500e-01f, 1.04805209e-01f, -1.15377143e-01f,
  5.92692755e-02f, 1.81305811e-01f, 8.43918100e-02f, 4.30588834e-02f, 6.84839636e-02f, -4.72287126e-02f, -1.09948970e-01f, -1.66319292e-02f, 5.24202548e-03f, 4.07555848e-02f,
  1.63655467e-02f, -1.65753793e-02f, 6.79277554e-02f, 4.34586108e-02f, 4.32905629e-02f, 9.38207805e-02f, 8.29401538e-02f, -2.56749876e-02f, 1.55282514e-02f, 6.26116693e-02f,
  4.50310414e-04f, -2.40105484e-02f, -3.66194621e-02f, -9.61295813e-02f, 2.09198818e-02f, -2.58192737e-02f, 1.49407182e-02f, -3.53408605e-02f, 6.18076734e-02f, 6.57875091e-02f,
  1.06584735e-01f, -2.79168878e-02f, -7.19537884e-02f, -5.19864596e-02f, -5.04814535e-02f, -7.31978044e-02f, 3.38426325e-03f, -9.25543457e-02f, 4.58817706e-02f, -7.19229132e-02f,
  5.65499160e-03f, 6.05359152e-02f, 3.19978036e-02f, -3.34611572e-02f, 1.12554710e-02f, -3.22568836e-03f, 1.32901166e-02f, -1.10201435e-02f, 5.95630594e-02f, -2.34747510e-02f,
  -2.57422570e-02f, 6.18778961e-03f, -7.54906610e-02f, 1.79177020e-02f, -6.22712960e-03f, -1.02688763e-02f, 8.40753615e-02f, 7.36011937e-02f, -1.90333370e-02f, -4.52813059e-02f,
  -6.51252344e-02f, 3.85703817e-02f, -6.81357011e-02f, -9.69147459e-02f, -5.93161508e-02f, -6.38666824e-02f, 1.14722375e-03f, -2.50925999e-02f, 6.86655641e-02f, 1.55186076e-02f,
  3.44852023e-02f, -9.16610882e-02f, -6.83025643e-02f, -2.51100790e-02f, -1.02070235e-02f, 7.87083209e-02f, 1.19413119e-02f, -8.15083832e-02f, -9.16300565e-02f, 1.10787503e-01f,
  9.96066779e-02f, 2.77362950e-02f, 3.19480151e-02f, -6.29359782e-02f, -6.99099675e-02f, -4.33138646e-02f, 4.62692156e-02f, 2.26475466e-02f, -1.88247375e-02f, 6.88537210e-03f,
  -1.34725729e-03f, -1.09218128e-01f, 1.52077571e-01f, -1.11628607e-01f, -5.67195676e-02f, -3.48113813e-02f, 9.47215557e-02f, -6.47581592e-02f, -1.51224598e-01f, -9.24858972e-02f,
  -2.13606618e-02f, -1.04023024e-01f, 7.27696270e-02f, 3.74395587e-02f, 1.64058387e-01f, 1.23949960e-01f, -3.56264412e-02f, -5.93955442e-02f, 3.58128697e-02f, 3.20688449e-02f,
  -1.31630013e-02f, 8.54311213e-02f, 1.46958590e-01f, -3.17995623e-02f, 2.06260663e-02f, -6.61206022e-02f, 1.03182711e-01f, 3.67561728e-02f, 6.47652298e-02f, 3.74409556e-02f,
  6.53655902e-02f, 5.50496541e-02f, -5.38742840e-02f, 6.34066835e-02f, 1.04646213e-01f, 5.87366223e-02f, 1.00304097e-01f, 7.35734329e-02f, -7.71768987e-02f, -8.43890011e-02f,
  5.89341410e-02f, -6.20742328e-02f, -2.32701413e-02f, 3.62769142e-02f, 1.35801537e-02f, 1.69737190e-02f, -8.93281698e-02f, -4.48752008e-02f, 6.78164661e-02f, 4.12080698e-02f,
  -6.44808635e-02f, 5.44298217e-02f, -8.97573307e-02f, 2.90865004e-02f, -8.80373269e-02f, 4.20271559e-03f, -8.31994787e-02f, -7.15526715e-02f, -3.37252505e-02f, -7.20569417e-02f,
  -5.22381924e-02f, -3.04248612e-02f, -1.98783763e-02f, 3.80572677e-02f, -3.79410200e-02f, 2.57267561e-02f, -5.06058075e-02f, -6.13165163e-02f, 7.71645904e-02f, -3.96332927e-02f,
  -6.86302828e-03f, 7.20955385e-03f, 5.75215705e-02f, 5.73482178e-02f, 5.61365150e-02f, 5.49144782e-02f, 8.13976675e-02f, 1.86872687e-02f, -8.20195675e-02f, 4.43101637e-02f,
  -8.07133391e-02f, 6.33930489e-02f, -2.17553484e-03f, 7.98856318e-02f, 1.48038445e-02f, 3.67128477e-02f, -8.43106061e-02f, -4.33850698e-02f, -3.87932509e-02f, -5.46769537e-02f,
  3.86315659e-02f, -4.29579578e-02f, 3.56101580e-02f, -1.56232528e-02f, -1.82344411e-02f, -6.32991865e-02f, -4.60689664e-02f, -5.14254011e-02f, -2.75685526e-02f, 7.08219968e-03f,
  -7.37422472e-03f, -5.52294254e-02f, 1.23483948e-02f, 4.59230021e-02f, -3.09702791e-02f, -2.18261648e-02f, -8.85347556e-03f, -5.74001670e-02f, -6.92637786e-02f, -1.36115598e-02f,
  7.29818791e-02f, 7.75150955e-02f, -2.03873124e-02f, 4.06863317e-02f, -2.39042956e-02f, -9.10425931e-02f, -2.38457937e-02f, -2.32042596e-02f, -7.33115673e-02f, 7.14529306e-02f,
  -6.58151284e-02f, 1.20865665e-02f, 6.82688802e-02f, -8.75931606e-03f, -9.26165804e-02f, -3.06563010e-03f, 1.70275755e-02f, -1.77942570e-02f, 2.66456097e-01f, 4.39932831e-02f,
  -1.01834714e-01f, 7.56330118e-02f, -1.05517767e-02f, -8.89740065e-02f, 7.96909034e-02f, -2.11049151e-02f, 2.53594723e-02f, 4.18401882e-02f, 1.23268820e-01f, -3.46168852e-03f,
  -5.63360285e-04f, -5.74655384e-02f, -1.66429237e-01f, -8.20316747e-02f, -6.92151412e-02f, -9.31251645e-02f, -1.27622753e-01f, 6.87649399e-02f, -1.61964729e-01f, -4.55115587e-02f,
  -1.47865610e-02f, 1.37991846e-01f, -2.48817913e-02f, -4.40449081e-02f, -3.19060348e-02f, -1.15787692e-01f, 6.20198734e-02f, 1.86550580e-02f, 2.48263404e-02f, -4.07294109e-02f,
  8.85511413e-02f, 2.84835491e-02f, 2.13598832e-02f, -2.22869478e-02f, -2.53859069e-02f, -6.53315037e-02f, -7.24891201e-02f, 1.20911328e-03f, -5.43074943e-02f, -5.51151522e-02f,
  -1.18250303e-01f, 6.80827424e-02f, 2.58378368e-02f, 2.92696655e-02f, 2.98420489e-02f, -6.05852716e-02f, 8.25237203e-03f, 3.89454514e-02f, -5.40951118e-02f, 8.22685882e-02f,
  -5.32828793e-02f, -6.84299693e-02f, -6.86515793e-02f, 4.50850874e-02f, 5.68750873e-02f, -5.89471119e-06f, -4.78639752e-02f, -2.58844905e-03f, 4.88537736e-02f, -1.29347411e-03f,
  7.55556673e-02f, -9.26962271e-02f, -3.38306800e-02f, -5.34803048e-02f, 6.62011877e-02f, -5.18147945e-02f, 5.14452904e-02f, -6.57122284e-02f, -4.80604649e-04f, 4.23097685e-02f,
  1.20789872e-03f, 6.71752766e-02f, -5.49031384e-02f, 2.08035624e-03f, 6.55301884e-02f, -1.98017824e-02f, 5.34165353e-02f, -9.23428219e-03f, -1.27026383e-02f, -4.43141237e-02f,
  7.79811814e-02f, 2.27482811e-01f, 6.47111610e-02f, 1.00710606e-02f, 7.38236681e-02f, -4.54983339e-02f, 5.10514118e-02f, 2.95350198e-02f, 8.56796056e-02f, -2.92842817e-02f,
  -7.00466484e-02f, 4.14143726e-02f, -2.36346703e-02f, -7.43358657e-02f, 1.11204714e-01f, 3.37637099e-03f, -4.86423774e-03f, 4.41924259e-02f, -3.83564755e-02f, -1.81980655e-02f,
  -1.28496423e-01f, 4.86438088e-02f, -1.72022469e-02f, 5.19354455e-02f, -7.87996277e-02f, 1.33185247e-02f, 3.89712723e-03f, -6.75071925e-02f, 6.79039583e-03f, -2.67433207e-02f,
  1.43229485e-01f, 1.08022606e-02f, -1.22462586e-01f, -1.15036462e-02f, -7.53033394e-03f, -4.89587449e-02f, 6.14675274e-03f, 5.53605556e-02f, -1.64942056e-01f, 1.24410421e-01f,
  -1.53774563e-02f, -1.21927343e-01f, -1.39428964e-02f, -1.06072150e-01f, -1.01684779e-01f, -5.63355200e-02f, -1.03087030e-01f, 4.76845689e-02f, -4.23787162e-02f, 8.92147608e-03f,
  -5.11735193e-02f, 4.76956777e-02f, -6.48510754e-02f, 4.00159806e-02f, -3.50149311e-02f, -3.05346344e-02f, 6.93044066e-02f, 6.61506280e-02f, 1.05323121e-01f, -6.88790753e-02f,
  4.88651171e-02f, -4.49780822e-02f, 1.92193650e-02f, 6.68643694e-03f, -1.98953152e-02f, 5.38967885e-02f, 1.41913276e-02f, -7.58911064e-03f, -4.81478944e-02f, -8.74230117e-02f,
  -2.35629827e-02f, 2.35980805e-02f, -2.58833990e-02f, -6.40788898e-02f, 4.16832156e-02f, 2.21106363e-03f, -1.91690028e-02f, -8.44676271e-02f, -4.38508345e-03f, 7.54552754e-03f,
  -1.11743912e-01f, 5.86118959e-02f, -8.93170685e-02f, 4.22981381e-02f, -1.54350884e-02f, -9.08501446e-02f, -7.16468766e-02f, -2.43332493e-03f, -6.72285929e-02f, -6.79365173e-02f,
  2.57647019e-02f, 5.30130416e-02f, 2.74428651e-02f, 4.55899443e-03f, 5.04310317e-02f, -7.66260847e-02f, 4.27214541e-02f, 9.77933450e-05f, 2.96232253e-02f, -4.02016379e-02f,
  -6.02717884e-02f, 4.10636142e-02f, -6.66669756e-02f, -4.42760810e-02f, -4.33795042e-02f, 3.66359465e-02f, -3.70590924e-03f, -7.20960554e-03f, 7.15950802e-02f, -3.75097804e-02f,
  -7.16247484e-02f, -1.44855883e-02f, -1.15088595e-03f, -7.18105733e-02f, -5.13951480e-02f, -3.61411683e-02f, -4.92437109e-02f, -5.97971044e-02f, -3.55370604e-02f, 1.92602593e-02f,
  2.06152741e-02f, 6.83689117e-02f, -3.08036599e-02f, 6.46496341e-02f, 4.93440144e-02f, 2.80546304e-03f, -4.27185232e-03f, 6.18165135e-02f, -8.19080919e-02f, -4.96208891e-02f,
  3.27024683e-02f, 3.03738508e-02f, 2.28466149e-02f, 7.53825828e-02f, -1.04454972e-01f, 5.92295229e-02f, 6.14488171e-03f, 2.57643815e-02f, 5.04254140e-02f, -7.43795186e-02f,
  -6.14965260e-02f, -8.02917853e-02f, -1.56646855e-02f, 3.42375152e-02f, -3.86887565e-02f, 7.38434047e-02f, 3.68859526e-03f, 6.71394318e-02f, 1.90955810e-02f, -9.61380973e-02f,
  1.20842181e-01f, -6.11950830e-02f, 6.71977401e-02f, 3.83930542e-02f, -8.51553604e-02f, -5.30291647e-02f, 5.29207215e-02f, -2.41762236e-01f, -5.25195338e-02f, -1.40362173e-01f,
  -1.34956151e-01f, 1.22453831e-01f, 6.94279373e-02f, 2.07125824e-02f, 6.94403350e-02f, 1.03886984e-01f, -1.31723970e-01f, 1.67627186e-02f, -4.55041304e-02f, -1.26482412e-01f,
  2.75650453e-02f, -1.73963487e-01f, -2.91248243e-02f, -2.30676949e-01f, -5.72614446e-02f, -3.45874839e-02f, -4.79361266e-02f, 4.60952446e-02f, -1.35556515e-02f, 4.12960015e-02f,
  -1.44332200e-01f, -6.62918463e-02f, 7.30136633e-02f, 2.10492350e-02f, -6.30576015e-02f, 4.04480956e-02f, 8.77824426e-03f, 7.57579133e-02f, 7.46511072e-02f, 8.53575617e-02f,
  1.02912681e-03f, -7.79584944e-02f, -7.83280432e-02f, 2.51122676e-02f, -3.03622819e-02f, -3.49453650e-02f, -7.62605518e-02f, 3.99194509e-02f, 4.22560722e-02f, 9.27809346e-03f,
  7.42086917e-02f, 8.88885409e-02f, 7.80125409e-02f, 5.60501888e-02f, 8.65932107e-02f, -9.78493541e-02f, 7.80001134e-02f, 1.24952197e-01f, -1.05545623e-02f, 8.29092879e-03f,
  6.60171062e-02f, -1.56407449e-02f, 2.06203759e-02f, -4.30469587e-02f, 7.08701983e-02f, 1.50547177e-02f, -4.43202518e-02f, -5.97104430e-02f, 3.83144207e-02f, -7.66463503e-02f,
  5.20672537e-02f, -4.49664406e-02f, -1.20775346e-02f, 3.13815586e-02f, -7.21554011e-02f, 4.04841686e-03f, 2.37063020e-02f, 3.78402248e-02f, 8.09149146e-02f, -8.42756331e-02f,
  1.03935525e-02f, 3.20396759e-02f, -8.23928416e-02f, 4.38403003e-02f, -1.87131502e-02f, 7.09125325e-02f, 3.67326662e-02f, -5.01927547e-02f, 1.47226444e-02f, 5.87638691e-02f,
  -1.77211300e-01f, -6.13439567e-02f, -5.73825985e-02f, 5.89326955e-02f, -7.99501017e-02f, 2.31463313e-02f, 4.46524769e-02f, 1.24835446e-02f, 2.77286358e-02f, -1.04058580e-02f,
  -4.41645458e-02f, 3.80782746e-02f, 3.79509255e-02f, 6.12406321e-02f, 5.97370788e-02f, -7.40138367e-02f, 5.12875989e-02f, -2.86458526e-02f, -3.47325839e-02f, 5.05825095e-02f,
  8.50341283e-03f, 7.85627738e-02f, -3.42394449e-02f, -5.57871424e-02f, -1.35386977e-02f, -3.59338932e-02f, 1.43978139e-03f, -3.89761999e-02f, 6.06039129e-02f, 1.32766329e-02f,
  1.19306117e-01f, -1.05382703e-01f, -2.04293534e-01f, -9.86973867e-02f, -1.86847840e-02f, -1.51663765e-01f, -2.47696161e-01f, -1.65202633e-01f, -1.58918407e-02f, -1.03406824e-01f,
  -9.31548551e-02f, 5.42619377e-02f, 7.84671605e-02f, -2.24900246e-01f, 9.10730660e-02f, 1.49987027e-01f, -1.65765002e-01f, -6.73578382e-02f, -6.68727756e-02f, -1.81927308e-01f,
  -1.03314541e-01f, -7.32323676e-02f, -4.93728481e-02f, -2.61423737e-02f, -1.23629913e-01f, -1.06598988e-01f, 8.88271555e-02f, -2.02734601e-02f, -1.63328901e-01f, -1.13056719e-01f,
  2.12680958e-02f, 1.85270030e-02f, -4.43738028e-02f, 7.18127638e-02f, -1.73991304e-02f, 7.10604861e-02f, 7.59658813e-02f, -5.73164560e-02f, -3.25154401e-02f, -6.25532586e-03f,
  4.06050570e-02f, 5.52727357e-02f, 3.43630388e-02f, 4.30716872e-02f, 4.63831462e-02f, -9.97866690e-02f, -8.01125020e-02f, -2.65751518e-02f, -7.39399344e-02f, -6.94337534e-03f,
  -7.82883912e-02f, 1.06058829e-02f, -6.92367274e-03f, -1.45790586e-02f, -8.79920553e-03f, -8.04277062e-02f, -6.72173593e-03f, -1.83146484e-02f, -4.03296910e-02f, 2.90070940e-02f,
  -2.85443217e-02f, -1.60666257e-02f, 8.19067806e-02f, -4.79769595e-02f, 1.88396848e-03f, 6.86700568e-02f, -7.04665482e-02f, -4.21194285e-02f, 4.92271148e-02f, -6.57187402e-02f,
  -3.84345278e-02f, -2.66361013e-02f, -4.31761555e-02f, 4.21825983e-02f, 1.17345469e-03f, 1.33057940e-03f, 6.72551543e-02f, -3.71792950e-02f, -1.00624771e-03f, 5.87663390e-02f,
  -3.33601683e-02f, -2.45668720e-02f, -8.30004865e-04f, -9.45067499e-03f, -5.22462316e-02f, -7.06890300e-02f, 6.02241270e-02f, 9.44486819e-03f, 5.98971453e-03f, 9.77256894e-03f,
  -1.08875260e-01f, -1.10657848e-01f, -8.85741264e-02f, -2.51866337e-02f, 7.18018934e-02f, 7.21924901e-02f, 4.81799208e-02f, 1.54105714e-02f, 4.69908826e-02f, -3.39847170e-02f,
  7.03430101e-02f, -1.54557480e-02f, -1.55888237e-02f, 1.59706827e-02f, -7.94182718e-02f, 2.04434488e-02f, 1.21110631e-02f, 1.08216638e-02f, 7.15062693e-02f, -5.31184413e-02f,
  5.31760380e-02f, -5.90630956e-02f, 8.45976993e-02f, 6.18823292e-03f, -7.56605640e-02f, -6.99867010e-02f, 7.03332201e-02f, -3.96488346e-02f, 4.63669226e-02f, 6.96017519e-02f,
  1.64499477e-01f, -3.11673909e-01f, 7.77184144e-02f, 1.47545159e-01f, 1.87250763e-01f, -1.62427910e-02f, 1.46610349e-01f, -1.40449256e-02f, -4.02567275e-02f, -2.79448211e-01f,
  -1.48598831e-02f, -4.98233475e-02f, -2.69057322e-02f, -6.89571202e-02f, 1.37874857e-01f, 2.00151689e-02f, -1.10868193e-01f, 6.88452944e-02f, 1.48045355e-02f, 5.44164702e-02f,
  5.89177608e-02f, -9.80885583e-04f, -5.54989651e-02f, -2.06106603e-01f, -8.45059901e-02f, -1.20765768e-01f, -6.72919676e-02f, 9.46747661e-02f, -1.58322796e-01f, 6.80307597e-02f,
  -2.26350762e-02f, 3.12472042e-02f, 3.89213338e-02f, -9.68425125e-02f, -1.30300354e-02f, 2.75069326e-02f, -2.19197124e-02f, 6.10457361e-02f, 7.79661834e-02f, 3.86499725e-02f,
  1.23095978e-02f, 6.41554743e-02f, 8.92527681e-03f, -5.26821464e-02f, -2.88797300e-02f, -9.76177827e-02f, -5.92227280e-02f, -5.06693274e-02f, 7.45888874e-02f, 7.04856515e-02f,
  6.31968305e-02f, -3.88820134e-02f, 5.91389090e-02f, -1.03708267e-01f, 1.07827626e-01f, -4.94494252e-02f, -2.70443968e-02f, 1.23541392e-02f, -2.06134915e-02f, -8.37183446e-02f,
  2.90734041e-02f, 2.79238932e-02f, -2.98685208e-02f, 2.95609776e-02f, -4.77143116e-02f, -4.15048264e-02f, 5.72898760e-02f, -3.57242674e-03f, 5.59224337e-02f, 3.71705294e-02f,
  -7.77261257e-02f, 8.53499845e-02f, -1.53567977e-02f, 2.63437051e-02f, 8.44347030e-02f, -6.49717683e-03f, -1.73224881e-02f, -8.34411010e-02f, -3.86738777e-02f, 5.04894480e-02f,
  -8.62485915e-03f, -1.73739549e-02f, 2.87568234e-02f, 5.63339144e-02f, -7.19102249e-02f, 2.94679888e-02f, -9.48590983e-04f, -2.62362435e-02f, 1.02446243e-01f, -1.10011604e-02f,
  -2.00180545e-01f, -1.11768186e-01f, -9.24507082e-02f, 5.58864810e-02f, -7.00843483e-02f, -1.02346465e-01f, -5.00249937e-02f, -1.65441055e-02f, -8.16735849e-02f, 5.92495650e-02f,
  -4.09654006e-02f, -7.26305544e-02f, 1.99118778e-02f, -8.35311040e-02f, -8.05933923e-02f, 5.90654053e-02f, 5.56403622e-02f, -9.50384811e-02f, -1.00725874e-01f, -9.14729238e-02f,
  -9.48664472e-02f, -8.56901519e-03f, -6.70256317e-02f, 5.09428978e-02f, -9.83880758e-02f, -7.65511591e-04f, 1.83338951e-03f, 1.02277519e-02f, 2.00881399e-02f, 2.64898650e-02f,
  -1.07393295e-01f, 1.24333568e-01f, 8.85663629e-02f, -2.72461027e-02f, -9.52701736e-03f, 6.06312975e-02f, 1.62237901e-02f, -5.58701809e-03f, -3.43492106e-02f, -1.01644741e-02f,
  -1.18579336e-01f, 4.07689363e-02f, -1.02157131e-01f, -9.82708647e-04f, -1.21113077e-01f, 5.68830483e-02f, 9.17635113e-02f, -2.34397072e-02f, 2.39685159e-02f, 5.94327692e-03f,
  -3.78502114e-03f, -5.16066626e-02f, -3.03029623e-02f, 2.84010153e-02f, 7.75784701e-02f, 1.11234732e-01f, -1.56713426e-02f, -8.77407286e-03f, 1.24021970e-01f, 2.91089881e-02f,
  5.70783243e-02f, -1.70000661e-02f, -4.06278707e-02f, 3.63562629e-02f, -5.27457707e-02f, -7.49454573e-02f, 5.44495918e-02f, -9.32964459e-02f, 2.59813038e-03f, 4.19804873e-03f,
  -5.06265983e-02f, -3.87214571e-02f, 9.06649232e-03f, -7.88650140e-02f, -7.76494071e-02f, 8.17753449e-02f, 1.94301121e-02f, -1.43413935e-02f, -7.83368871e-02f, 2.01476365e-03f,
  9.25592259e-02f, 4.61615138e-02f, -6.84246346e-02f, 7.68943354e-02f, -9.20461025e-03f, -6.86282963e-02f, 2.94746994e-03f, 5.12894168e-02f, 5.81970699e-02f, 6.69224858e-02f,
  -4.71449234e-02f, -1.54993543e-03f, -2.21856916e-03f, 4.61178795e-02f, 1.79694425e-02f, 3.92175987e-02f, -2.74401363e-02f, 5.04492410e-02f, -6.52417094e-02f, -1.90258995e-02f,
  6.61297292e-02f, -1.51447197e-02f, 6.36777803e-02f, -5.07627949e-02f, 1.13735371e-03f, -4.42151725e-02f, -5.03544882e-02f, 3.90186347e-02f, -3.02895401e-02f, 7.85237364e-03f,
  -4.83360291e-02f, -6.81964904e-02f, 4.63922769e-02f, 8.70981440e-02f, -5.54492362e-02f, 7.51267150e-02f, 1.59401074e-02f, 2.39913110e-02f, -3.33408304e-02f, 3.87094393e-02f,
  3.63332406e-02f, 5.62231578e-02f, -2.75189746e-02f, 6.38493970e-02f, -5.47163188e-02f, 2.86977068e-02f, 4.93376963e-02f, -6.64289966e-02f, 8.65470245e-02f, 9.54977274e-02f,
  4.93493453e-02f, -7.14115202e-02f, 7.52987638e-02f, -9.51814428e-02f, -8.27053860e-02f, -7.68303424e-02f, -6.78813756e-02f, 4.72933687e-02f, 2.03529745e-02f, 1.03857387e-02f,
  -6.16741180e-02f, 7.40365079e-03f, 6.35292083e-02f, -7.44493902e-02f, 4.77816537e-02f, -7.85457864e-02f, 1.00819282e-01f, 9.43775009e-03f, -1.07690906e-02f, -5.82974125e-03f,
  6.82198554e-02f, 1.73902377e-01f, 1.49191201e-01f, 1.86789274e-01f, -1.70943424e-01f, -2.19163001e-01f, -1.20797992e-01f, -1.45299202e-02f, 9.60217491e-02f, -5.03251851e-02f,
  -1.53911188e-01f, 3.23073924e-01f, -1.52732143e-02f, 3.59210074e-02f, -7.24592954e-02f, -1.08866639e-01f, 4.73522730e-02f, -3.83345634e-02f, -1.09168626e-02f, 1.06232770e-01f,
  -4.45679091e-02f, -1.29397094e-01f, 1.37554407e-01f, -8.83569419e-02f, 2.45982222e-02f, 8.72726291e-02f, 5.67714684e-03f, -7.10701570e-02f, 9.87350717e-02f, 4.90158722e-02f,
  -6.58726096e-02f, 7.31230900e-02f, 1.95004279e-03f, 7.43790418e-02f, -1.21870562e-02f, 7.89426044e-02f, 7.31706768e-02f, -1.75322313e-02f, -6.38483688e-02f, 4.76076966e-03f,
  4.42227572e-02f, 1.18343653e-02f, 2.41863001e-02f, -4.87082303e-02f, -3.77581045e-02f, 8.88205916e-02f, 2.86108516e-02f, -4.10252623e-02f, 1.14425667e-01f, 6.09554201e-02f,
  4.59906310e-02f, -2.01177672e-02f, 2.14024982e-03f, 3.11720576e-02f, 7.95565918e-02f, -8.62168893e-02f, 9.08872187e-02f, 1.99221056e-02f, 1.24939062e-01f, 9.09457728e-02f,
  -1.07391454e-01f, -2.81960480e-02f, 3.12447753e-02f, -5.89139685e-02f, 6.98964149e-02f, -5.53361885e-02f, -2.53803972e-02f, -5.06758951e-02f, 4.89669628e-02f, -5.04800864e-02f,
  2.26236451e-02f, -6.76416792e-03f, -5.44909909e-02f, 5.32577261e-02f, 1.57789979e-02f, -4.11109328e-02f, 7.60812759e-02f, 1.75744034e-02f, -9.53091029e-03f, -3.10535002e-02f,
  6.41252398e-02f, 1.37794325e-02f, 1.77079234e-02f, -1.09885134e-01f, 2.27074418e-02f, -4.41810265e-02f, 4.38116454e-02f, -6.64541721e-02f, 6.36431016e-03f, 6.09796084e-02f,
  -7.18245581e-02f, 1.49772927e-01f, 5.41476049e-02f, -4.47315909e-03f, 5.97907193e-02f, -6.41331682e-03f, 2.38853619e-02f, -4.61401977e-02f, 1.10969851e-02f, 7.70745873e-02f,
  -2.01626848e-02f, -2.88697705e-02f, 6.15047943e-03f, -5.91370054e-02f, -2.87405960e-02f, 1.94817397e-03f, -4.85098325e-02f, 9.70882084e-03f, 4.76406403e-02f, -1.23558659e-02f,
  9.18673500e-02f, -1.18281636e-02f, -2.15113927e-02f, 3.96626107e-02f, 6.54170103e-03f, -5.15179243e-03f, 3.68131772e-02f, 8.26165602e-02f, 8.93546864e-02f, 7.49454647e-02f,
  -5.25003262e-02f, 9.61398780e-02f, -9.74211395e-02f, -3.40860933e-01f, 1.71126351e-02f, -2.32636854e-01f, -3.15827608e-01f, 2.38200296e-02f, -1.45918746e-02f, -1.12545215e-01f,
  -6.61150515e-02f, -5.46648679e-03f, 1.84897229e-01f, -2.65182346e-01f, 7.44344890e-02f, 1.35752678e-01f, -2.73083329e-01f, -1.21270493e-01f, 6.05133846e-02f, -2.19987482e-01f,
  -8.48379359e-02f, -2.14466751e-01f, 6.45572832e-03f, -1.07246656e-02f, -2.35991120e-01f, -1.39000192e-01f, -5.96628850e-03f, 3.27934064e-02f, -1.44605175e-01f, 4.97159101e-02f,
  -2.08152942e-02f, -7.98094273e-02f, -2.03074608e-02f, 4.91516180e-02f, -9.76983234e-02f, -6.06844723e-02f, -8.48995522e-02f, -1.84119958e-02f, -7.54304230e-02f, 2.25877631e-02f,
  -8.78386479e-03f, 3.84029001e-02f, 2.46032085e-02f, 6.03904873e-02f, 2.59456150e-02f, 4.52536047e-02f, 3.92811671e-02f, 1.63967833e-02f, 5.45582436e-02f, 8.17576721e-02f,
  6.37304112e-02f, -7.07156286e-02f, -1.25493288e-01f, 3.78657728e-02f, -4.05602567e-02f, -1.03455493e-02f, 1.69723835e-02f, -5.79381771e-02f, -1.26708355e-02f, 8.13961553e-04f,
  2.33034361e-02f, 1.89322978e-02f, -2.98045836e-02f, 6.02258109e-02f, 5.28457109e-03f, 3.64498310e-02f, -4.28568125e-02f, 6.89322501e-02f, 1.52421510e-02f, 3.19673792e-02f,
  4.66595069e-02f, 1.06284383e-03f, 1.14114042e-02f, -9.01811272e-02f, -7.61366561e-02f, -6.32490069e-02f, -7.08093867e-03f, 3.12336199e-02f, 1.26734162e-02f, -7.09089041e-02f,
  3.86591218e-02f, -6.40797168e-02f, 7.76943341e-02f, 2.48514768e-02f, 1.01221092e-02f, 2.02721898e-02f, 5.01870885e-02f, 5.26249297e-02f, 6.29865825e-02f, 3.83851416e-02f,
  -8.39561671e-02f, -1.81707684e-02f, -5.52391410e-02f, -5.44210114e-02f, -4.43610325e-02f, 1.62315536e-02f, 1.26381777e-02f, -4.95168939e-02f, -9.93953198e-02f, -7.22862259e-02f,
  1.18786423e-02f, -4.08940651e-02f, -9.78788733e-02f, -6.24316335e-02f, -3.40058678e-03f, -6.74613640e-02f, -7.35075697e-02f, -3.46998088e-02f, 6.29255036e-03f, 6.46304935e-02f,
  -1.00910086e-02f, -2.88601033e-03f, -4.11774367e-02f, -5.45358025e-02f, -3.41532230e-02f, -2.60817148e-02f, 1.82800961e-03f, 6.19527735e-02f, -4.67682537e-03f, 5.26852384e-02f,
  1.01178132e-01f, 1.74833443e-02f, -5.31182215e-02f, 8.03711861e-02f, 1.51403702e-03f, 8.80570114e-02f, 9.12086740e-02f, 9.69031975e-02f, 1.79370239e-01f, 1.53313829e-02f,
  -1.82798710e-02f, 1.48061424e-01f, -3.50799896e-02f, 4.39597527e-03f, 2.63554435e-02f, 6.23486787e-02f, 8.58949944e-02f, 7.07154125e-02f, -4.70515825e-02f, 1.14812888e-01f,
  2.62023043e-02f, 6.79713413e-02f, -3.84030901e-02f, -1.21920690e-01f, -8.51249415e-03f, 2.18975749e-02f, -1.49768531e-01f, -1.07682481e-01f, 8.08183849e-02f, 2.12878995e-02f,
  6.47655651e-02f, 5.06537519e-02f, -3.53881977e-02f, -2.67661419e-02f, 3.38459797e-02f, -3.51773240e-02f, -8.77999701e-03f, 3.28801363e-03f, 6.70042485e-02f, 7.20952898e-02f,
  9.58198681e-02f, -4.99734096e-02f, 6.19183034e-02f, 3.72167639e-02f, -9.39497782e-04f, 1.55645879e-02f, 5.93400076e-02f, 4.05220427e-02f, -5.49137555e-02f, 4.13101912e-02f,
  -3.52312438e-02f, 2.82887761e-02f, 1.27587831e-02f, -6.98001310e-02f, 7.21212551e-02f, 3.97768430e-03f, 8.29142854e-02f, 2.34800298e-02f, 4.96824756e-02f, 1.60801876e-02f,
  -1.68353803e-02f, 8.60394463e-02f, -5.54673113e-02f, -7.07484931e-02f, -5.83460703e-02f, -1.75988637e-02f, 4.66331840e-02f, 5.65741882e-02f, -3.79498452e-02f, -2.79945657e-02f,
  -2.37782355e-02f, 5.22230193e-02f, 4.72309217e-02f, 1.98596227e-03f, -3.92342061e-02f, -5.98677173e-02f, -7.31404722e-02f, -4.96285129e-03f, 8.24644789e-03f, 2.18064571e-03f,
  -4.22186814e-02f, 8.73687789e-02f, -6.29415289e-02f, -1.11433506e-01f, 5.04091606e-02f, -7.05668926e-02f, 9.73505378e-02f, -3.46689075e-02f, 2.51495056e-02f, 1.35029862e-02f,
  8.00738931e-02f, -9.12765507e-03f, 4.73296456e-02f, 1.47822564e-02f, -2.34414488e-02f, 8.52118805e-02f, 6.56086281e-02f, -6.48738444e-02f, -5.26401028e-02f, -9.55376960e-03f,
  9.14009511e-02f, -5.49412984e-03f, -6.44547343e-02f, -9.14189778e-03f, 2.54545035e-03f, 7.14869276e-02f, 9.36163291e-02f, -9.07552019e-02f, -1.09507581e-02f, -9.62310378e-03f,
  5.48798665e-02f, 4.34614345e-02f, 6.79332539e-02f, -6.76851645e-02f, 7.45574534e-02f, -2.72506345e-02f, 7.08209947e-02f, 7.14584365e-02f, 6.07829653e-02f, 6.72413483e-02f,
  -4.02248055e-02f, 6.68666586e-02f, 9.93074253e-02f, 1.92999586e-01f, 6.13572896e-02f, 1.66604191e-01f, 1.60120115e-01f, 5.32791689e-02f, 2.61841953e-01f, -1.13015205e-01f,
  -6.55413941e-02f, -1.17474981e-02f, -3.97127271e-02f, 5.30076139e-02f, 3.93073447e-02f, 1.11779287e-01f, 2.53281482e-02f, -3.79708037e-02f, 7.28999004e-02f, 2.05070097e-02f,
  5.65625392e-02f, 1.20768830e-01f, -1.06744166e-03f, -8.16463381e-02f, -9.73041430e-02f, -5.68340458e-02f, -2.40523145e-02f, -1.30573198e-01f, -9.99092907e-02f, 1.80624723e-02f,
  5.52530251e-02f, 6.58891499e-02f, -1.03977442e-01f, 4.35419902e-02f, -4.56894040e-02f, 1.38985282e-02f, 1.26628838e-02f, -1.08510524e-01f, 2.73293443e-02f, -5.76082803e-03f,
  3.58480439e-02f, -5.69164939e-02f, 8.25862065e-02f, 6.89563751e-02f, 2.94503924e-02f, 4.41319831e-02f, -4.95454893e-02f, -7.02379569e-02f, -1.20862350e-02f, -2.56865369e-05f,
  1.82579942e-02f, 4.27622944e-02f, -2.24825162e-02f, -6.96013421e-02f, -1.04982136e-02f, -6.26795590e-02f, -1.86214987e-02f, -5.47614042e-03f, -7.93242678e-02f, 8.19090381e-02f,
  5.34217320e-02f, -1.11835375e-02f, 1.02814816e-01f, 5.19726463e-02f, 9.08961147e-02f, -4.97110300e-02f, -4.46255505e-02f, 7.75340013e-03f, 1.55101418e-02f, 2.91050375e-02f,
  -3.11384834e-02f, 3.62841375e-02f, 9.55064818e-02f, -2.40727402e-02f, 4.48214374e-02f, 8.76138955e-02f, 1.68352798e-02f, 3.21112201e-02f, 6.71743974e-02f, -1.85645148e-02f,
  7.54096955e-02f, 9.22550336e-02f, 7.92481005e-03f, 1.94290318e-02f, -2.54565924e-02f, -5.29325679e-02f, 5.64312153e-02f, -5.50902113e-02f, -1.60563234e-02f, -3.80215235e-03f,
  1.33898318e-01f, 9.37704518e-02f, -5.73004782e-02f, -4.03176546e-02f, -3.27849612e-02f, 4.60764021e-02f, -2.83257067e-02f, 5.14839180e-02f, -4.04854352e-03f, 7.19237700e-02f,
  3.67051773e-02f, -1.34438714e-02f, -6.47538155e-02f, -6.95504025e-02f, -9.50798988e-02f, -1.67461187e-02f, -4.34114374e-02f, 7.46938586e-02f, -5.45855649e-02f, 3.09518501e-02f,
  -2.12962553e-02f, -1.26525313e-02f, 4.45108712e-02f, -3.17772776e-02f, 6.33324087e-02f, -5.32538584e-03f, -1.17872935e-02f, -2.49809003e-03f, 5.38472980e-02f, 6.09550364e-02f,
  1.19747870e-01f, -2.34472051e-01f, -1.58172384e-01f, -2.54584337e-03f, 1.98696107e-01f, 1.52222335e-01f, 1.02440089e-01f, -7.42138028e-02f, -1.18904330e-01f, -1.61821872e-01f,
  1.33396491e-01f, 6.51651099e-02f, -8.50429237e-02f, 4.20376509e-02f, 2.45269388e-01f, -1.07805684e-01f, -9.56328295e-04f, 1.46990329e-01f, -9.09615010e-02f, -4.01811471e-04f,
  -6.15465678e-02f, 2.03906566e-01f, 1.90826021e-02f, -4.24276628e-02f, 1.47795483e-01f, -3.07801664e-02f, 1.03115827e-01f, 1.63910817e-02f, 4.22328636e-02f, 1.50053546e-01f,
  7.98895136e-02f, 1.61125027e-02f, -4.38727140e-02f, 7.96067789e-02f, 5.28788343e-02f, -2.54244227e-02f, 1.93209387e-02f, 3.82886529e-02f, -2.43388657e-02f, -9.86887217e-02f,
  4.84623853e-03f, -3.50033306e-02f, 8.42180997e-02f, -4.64460738e-02f, 3.77440713e-02f, -2.94189770e-02f, -8.69304761e-02f, -6.86825886e-02f, -7.66332150e-02f, -1.35078700e-02f,
  -9.01315510e-02f, -5.58092631e-02f, 5.21099269e-02f, 3.83528396e-02f, -1.08602941e-01f, -8.58536828e-03f, -8.27229172e-02f, 6.46473095e-02f, -2.33539920e-02f, -1.20291822e-02f,
  -2.66005080e-02f, 3.85910310e-02f, 3.90542448e-02f, -1.04130702e-02f, 6.56988099e-02f, 4.88738380e-02f, 4.58281040e-02f, -5.40507063e-02f, -3.76375392e-02f, 6.57286420e-02f,
  -4.13709991e-02f, -8.93578902e-02f, -3.03688645e-02f, -2.91929469e-02f, -3.65965031e-02f, -2.36202851e-02f, 8.51442888e-02f, 6.87972680e-02f, -5.11312895e-02f, 2.80036661e-03f,
  5.05167916e-02f, -4.98652197e-02f, -3.87336388e-02f, -6.48038313e-02f, 6.62746727e-02f, -9.08192694e-02f, -1.69295184e-02f, -4.10031006e-02f, -4.81928103e-02f, 2.05793474e-02f,
  -4.67790775e-02f, -1.65986210e-01f, -1.05112784e-01f, 2.34185178e-02f, -4.10844162e-02f, 4.39390913e-03f, 3.26228403e-02f, 4.88527827e-02f, 8.33996236e-02f, 1.23006024e-03f,
  2.60896720e-02f, 2.70435642e-02f, 2.66152471e-02f, -5.01268394e-02f, -4.86444309e-02f, 2.35362183e-02f, -3.72418948e-02f, -2.24305969e-02f, -4.89482470e-02f, 5.47446162e-02f,
  -1.97293307e-03f, -6.44744262e-02f, 9.13692415e-02f, -1.87742133e-02f, -7.86473677e-02f, -6.31572530e-02f, -1.00750856e-01f, -6.05449080e-02f, 3.78077924e-02f, -1.05716355e-01f,
  1.26809075e-01f, 3.31464550e-03f, 4.45504934e-02f, -2.02113092e-02f, 7.55679011e-02f, 1.38323354e-02f, -1.19995810e-02f, 8.85436758e-02f, 6.51232153e-02f, -1.54958770e-01f,
  -1.02231048e-01f, -1.89831723e-02f, 5.60462624e-02f, 2.44025816e-03f, 2.58504376e-02f, -8.34861994e-02f, 2.03802288e-02f, -3.94891389e-02f, 5.41030094e-02f, -4.36567254e-02f,
  1.02298967e-04f, 4.65431437e-02f, 5.40379547e-02f, 1.00428183e-02f, 1.05180033e-01f, -5.80015080e-03f, -3.97905596e-02f, 3.31662633e-02f, -8.07351526e-03f, 1.17233060e-02f,
  3.21492627e-02f, 1.06619531e-03f, 1.13721989e-01f, -2.27131285e-02f, -1.89819653e-02f, 1.18706869e-02f, -1.67812183e-02f, 9.45615917e-02f, 8.01454764e-03f, 7.08919838e-02f,
  -3.68382186e-02f, -8.60056430e-02f, 7.11490363e-02f, -4.72357543e-03f, 1.24142971e-02f, 1.99424457e-02f, 1.33322943e-02f, 1.07159838e-01f, -7.65268505e-02f, 4.51897085e-03f,
  7.42206126e-02f, 5.50012402e-02f, 9.89494771e-02f, 4.81084473e-02f, -1.90722514e-02f, 4.40428630e-02f, -5.14448732e-02f, 5.84575795e-02f, 2.68018581e-02f, -3.58751155e-02f,
  1.09090451e-02f, -9.35449526e-02f, 4.01806943e-02f, -7.15791211e-02f, -3.75131927e-02f, 9.25981030e-02f, -4.03911062e-02f, 4.33905832e-02f, -4.62417901e-02f, -9.63583291e-02f,
  5.67957498e-02f, -2.97705252e-02f, -5.83175058e-03f, -7.99708143e-02f, -4.59666699e-02f, 1.64080393e-02f, 4.88298610e-02f, -3.59005630e-02f, -7.95156956e-02f, 3.51330154e-02f,
  -1.41184069e-02f, 4.79836576e-02f, 5.13806678e-02f, -2.63490528e-02f, -6.63414448e-02f, -9.54060331e-02f, -1.58018768e-02f, -7.80436173e-02f, 5.42212315e-02f, 6.65492192e-02f,
  -5.90321515e-03f, -1.13911361e-01f, 6.26865253e-02f, -3.10917366e-02f, -4.75979671e-02f, -4.96201627e-02f, -4.85630007e-03f, 1.93491355e-02f, 4.80145775e-02f, 8.57308656e-02f,
  -2.13314611e-02f, 1.36753414e-02f, 3.02671231e-02f, -2.14610528e-03f, 4.03041318e-02f, -7.15104416e-02f, -7.67528340e-02f, -1.38853639e-02f, -5.32227755e-02f, -6.51466399e-02f,
  -5.67013584e-03f, 3.67559493e-02f, 1.00768982e-02f, -2.28058193e-02f, -7.25946501e-02f, -1.08336926e-01f, -4.52292617e-03f, -8.06732103e-02f, -1.03046127e-01f, -1.31247919e-02f,
  -2.66873360e-01f, 2.02632576e-01f, -1.06251620e-01f, -2.00329766e-01f, 5.71677834e-02f, -1.03407748e-01f, -2.21992861e-02f, 1.17179304e-01f, 1.50790170e-01f, 4.99638990e-02f,
  9.36002806e-02f, -4.94215973e-02f, 1.78113192e-01f, -8.02626610e-02f, -2.41897449e-01f, -3.17723043e-02f, -1.32285416e-01f, -6.13954887e-02f, 5.40795922e-02f, 6.04971461e-02f,
  -7.40808770e-02f, 4.52162065e-02f, -1.16551422e-01f, 2.18378976e-02f, -1.27001390e-01f, 9.59536899e-03f, -1.25805259e-01f, 1.11508146e-01f, -7.88729712e-02f, -4.72241864e-02f,
  1.04058096e-02f, 6.96932990e-03f, -1.21204406e-01f, -6.32964969e-02f, -8.96039307e-02f, -1.14240803e-01f, 2.66485829e-02f, -4.67383899e-02f, -9.31801796e-02f, -3.12772878e-02f,
  -7.69962743e-02f, -3.10601629e-02f, 2.63544470e-02f, -4.19211015e-02f, 4.98057678e-02f, 3.10805049e-02f, 4.06106301e-02f, -5.63241318e-02f, -7.72574693e-02f, -6.37584031e-02f,
  -1.10159673e-01f, 3.22686210e-02f, -7.27704838e-02f, 1.41647039e-02f, -3.93267013e-02f, 9.44309458e-02f, -1.01931483e-01f, -4.05170470e-02f, -2.20143795e-02f, 3.96848917e-02f,
  2.06638202e-02f, 8.83652419e-02f, 7.93725327e-02f, -4.91111726e-02f, 7.48565570e-02f, -7.16306120e-02f, -3.08892112e-02f, 4.36781235e-02f, -1.42733855e-02f, -5.32634929e-02f,
  -6.05467707e-02f, -5.87830879e-02f, -5.55044524e-02f, 1.22596547e-02f, 1.57153700e-02f, 4.68642451e-04f, -2.59497929e-02f, 4.70027253e-02f, 1.59848090e-02f, -3.28062698e-02f,
  4.02422026e-02f, -7.89661482e-02f, -6.17622677e-03f, -4.72343862e-02f, -2.51824316e-02f, -9.60540399e-03f, 7.30672255e-02f, 3.42654511e-02f, 6.04558587e-02f, 4.79858182e-02f,
  -7.37889707e-02f, -5.79734482e-02f, 3.33006829e-02f, 8.75549018e-02f, 8.50302801e-02f, 4.41772826e-02f, -2.21362729e-02f, -3.12751830e-02f, -1.19333190e-03f, 3.04655032e-03f,
  2.86950115e-02f, -2.67021023e-02f, -1.01816334e-01f, -3.30946296e-02f, 6.46998687e-03f, -7.82641023e-02f, 5.27594686e-02f, -3.17023210e-02f, 4.22772840e-02f, 1.01609668e-02f,
  6.80423677e-02f, 2.83934772e-02f, 7.77681619e-02f, 7.95852244e-02f, 4.94451597e-02f, -3.68796736e-02f, -9.69317108e-02f, -2.38070413e-02f, 6.43669441e-02f, 7.96622410e-02f,
  -1.58148617e-01f, 6.47245534e-03f, 9.98301432e-02f, 3.86420190e-02f, -3.82926874e-02f, 8.68138894e-02f, 7.43029416e-02f, -6.00974187e-02f, -1.69455394e-01f, -1.22378848e-01f,
  3.79373245e-02f, -1.12170070e-01f, 9.61906239e-02f, -8.09795503e-03f, 1.41727226e-02f, 1.12634197e-01f, -3.42736803e-02f, 1.41106742e-02f, 1.36655331e-01f, 1.15657091e-01f,
  1.34453878e-01f, 3.57098356e-02f, 2.35745832e-01f, 1.28574803e-01f, 9.35684741e-02f, -4.28007729e-02f, -3.23164184e-03f, 1.45428315e-01f, -9.43680704e-02f, -9.36099514e-02f,
  -1.16991073e-01f, -9.97280180e-02f, -3.77810337e-02f, -7.25127533e-02f, -4.53073643e-02f, 3.10995448e-02f, 4.18950841e-02f, 2.19458099e-02f, 3.95376720e-02f, 1.98597349e-02f,
  -8.08676407e-02f, 5.44318780e-02f, -6.71546757e-02f, 2.04740949e-02f, -5.41559770e-04f, 6.33748323e-02f, -2.37451196e-02f, -1.96235124e-02f, -4.06461172e-02f, -3.26717272e-02f,
  6.94786850e-03f, -1.72221642e-02f, -2.42768158e-03f, 3.24455276e-02f, 8.80824775e-02f, 2.60907840e-02f, -6.71996027e-02f, 4.30009793e-03f, 5.81139252e-02f, -8.21351185e-02f,
  8.77576396e-02f, -1.30582750e-02f, 3.38961072e-02f, -2.03165077e-02f, -6.61212532e-03f, 3.74126658e-02f, -6.28044829e-02f, 6.96767196e-02f, 3.79926451e-02f, -2.59496383e-02f,
  -8.04685950e-02f, -4.43688706e-02f, 9.45068374e-02f, 7.88856521e-02f, 2.12226100e-02f, 3.97280753e-02f, 5.03479503e-02f, -1.17697697e-02f, 6.63750432e-03f, 3.99588682e-02f,
  -5.56827672e-02f, -4.59467843e-02f, 3.98300253e-02f, 1.98264793e-02f, -3.61019336e-02f, 8.87640938e-02f, 6.24818802e-02f, 4.53507714e-02f, 1.87016781e-02f, 3.97625118e-02f,
  4.41406518e-02f, -1.62356775e-02f, -3.60460132e-02f, 1.19381705e-02f, -7.12082312e-02f, -8.30297023e-02f, 9.22335610e-02f, -7.01034889e-02f, -3.54959965e-02f, -8.51872668e-04f,
  2.72351317e-02f, 1.02176726e-01f, -7.55534321e-02f, 3.98700051e-02f, -3.44155207e-02f, -6.32307976e-02f, 1.61301270e-02f, -6.27625138e-02f, -4.23367582e-02f, 1.22284703e-03f,
  -6.00773143e-03f, 6.32698312e-02f, 1.25114946e-02f, 9.32399631e-02f, -8.77038985e-02f, 1.00814337e-02f, -6.95498511e-02f, 7.40096569e-02f, -3.20340693e-02f, -3.39419246e-02f,
  -9.61695425e-03f, 5.53529756e-03f, 9.16715525e-03f, 1.32429585e-01f, -2.05723979e-02f, 5.86539619e-02f, 1.98358297e-02f, -8.33033770e-02f, -8.12648237e-02f, -1.95020009e-02f,
  6.64131790e-02f, -3.54663208e-02f, -5.20882420e-02f, 5.65769933e-02f, 2.41103768e-02f, -6.53306618e-02f, -7.19380751e-03f, -3.99663858e-02f, 3.09176184e-03f, 1.15979472e-02f,
  7.09841549e-02f, 3.75864357e-02f, 1.31030241e-03f, 9.10894051e-02f, 6.57912418e-02f, -4.41016778e-02f, 9.76753756e-02f, -9.42906067e-02f, 2.35566292e-02f, 4.14136425e-03f,
  -6.23922609e-02f, -1.21241221e-02f, 3.43674608e-02f, -3.84768681e-03f, 8.28836933e-02f, 9.40702409e-02f, 5.64442687e-02f, 7.29802623e-02f, -9.89258289e-03f, -1.03056379e-01f,
  -1.14454404e-02f, -4.78972122e-02f, -5.39015010e-02f, -4.96610515e-02f, -6.12146147e-02f, 9.63476449e-02f, -3.04181222e-02f, -3.31332572e-02f, -1.04835026e-01f, 6.30913973e-02f,
  -1.03206515e-01f, 7.20164701e-02f, 7.82642514e-02f, 7.45646805e-02f, -4.34087701e-02f, -1.44907478e-02f, 5.18199131e-02f, -4.66347818e-04f, 4.54357266e-02f, -4.74559516e-03f,
  5.81969805e-02f, -4.64754663e-02f, 2.68290155e-02f, -3.07403672e-02f, 8.61781314e-02f, 5.87184094e-02f, 7.11628143e-03f, 3.22615989e-02f, -6.38393452e-03f, 8.09145272e-02f,
  -2.67000888e-02f, -7.33029544e-02f, 2.05747448e-02f, 4.34503444e-02f, -7.15852603e-02f, 4.80546765e-02f, -3.66829224e-02f, -8.31955150e-02f, -4.49945554e-02f, -4.40227166e-02f,
  2.63024773e-02f, 2.72524096e-02f, -6.72698840e-02f, -7.80398250e-02f, -5.60747758e-02f, 1.14280777e-02f, -6.49784952e-02f, -7.03057721e-02f, 2.21095309e-02f, 4.60946709e-02f,
  -3.69014628e-02f, -2.09677983e-02f, -5.40063344e-02f, -1.60200137e-03f, -3.11502945e-02f, 1.51330670e-02f, -1.43664209e-02f, -2.64308900e-02f, -1.49629554e-02f, 5.54291473e-04f,
  -7.75949657e-02f, -1.88203398e-02f, 6.93371221e-02f, -5.14225475e-02f, -7.05385283e-02f, 8.88604373e-02f, 1.38193108e-02f, -3.94569933e-02f, 1.13474037e-02f, 1.01990439e-01f,
  1.42680379e-02f, 4.51583862e-02f, 7.41551071e-02f, 7.59947151e-02f, 9.97555330e-02f, 4.87990752e-02f, 6.30210107e-03f, -4.35310192e-02f, -6.25835955e-02f, 2.59279311e-02f,
  -1.65037319e-01f, 4.33101952e-02f, -6.01068363e-02f, 2.84452699e-02f, 6.36618361e-02f, 1.44909769e-01f, 1.97911263e-02f, -3.96890603e-02f, -1.05809048e-01f, -1.27429128e-01f,
  -8.23836122e-03f, -1.43009275e-01f, -3.86479236e-02f, 1.55216232e-01f, 2.74940953e-02f, 6.59427047e-02f, 1.14287622e-01f, -8.02410990e-02f, 1.24477781e-01f, -9.82086733e-02f,
  8.64429548e-02f, 2.79390626e-02f, 1.19684644e-01f, 2.30030287e-02f, 2.11348496e-02f, 7.09422827e-02f, 3.16839293e-02f, -1.68259144e-02f, -1.74736530e-02f, -2.90662628e-02f,
  -3.19671407e-02f, -1.17412275e-02f, -6.11267053e-02f, -2.01055836e-02f, -1.04940966e-01f, -1.12949193e-01f, 1.75907202e-02f, -2.90261339e-02f, -1.39824196e-03f, -1.94812343e-02f,
  2.02911925e-02f, 5.45529611e-02f, -4.43675518e-02f, 8.13330412e-02f, 7.77397351e-03f, -3.05727534e-02f, 8.19403529e-02f, 3.92227396e-02f, -3.69293280e-02f, 2.00137738e-02f,
  -1.96735915e-02f, 2.64297631e-02f, -7.22750649e-02f, -6.92579150e-02f, 4.20757718e-02f, 1.41434716e-02f, 7.78879300e-02f, -5.96806966e-02f, 2.47413497e-02f, -9.28172749e-03f,
  1.09009847e-01f, 6.80231750e-02f, -6.30429387e-02f, 4.30855714e-03f, -7.15298951e-02f, 4.32717912e-02f, -7.68582150e-02f, 3.08131278e-02f, 8.73611961e-03f, 8.16377476e-02f,
  8.41551349e-02f, -4.81964946e-02f, 3.51352841e-02f, 4.61408198e-02f, -1.97408218e-02f, -1.70139018e-02f, -6.69818791e-03f, 4.90205325e-02f, 1.40539557e-02f, 8.14201757e-02f,
  3.52339819e-02f, -9.88949370e-03f, 8.64296407e-02f, -6.78594336e-02f, -6.27965778e-02f, 6.15335293e-02f, -1.45238126e-03f, 3.90098058e-02f, 1.60889737e-02f, -2.46184859e-02f,
  -2.21217379e-01f, -1.29449666e-01f, 2.37630885e-02f, -4.14156355e-02f, -1.63093861e-02f, -9.12781525e-03f, -5.33332750e-02f, 8.29736590e-02f, -5.00379317e-02f, 3.55129167e-02f,
  -1.02271251e-01f, 4.69564646e-02f, -4.89053726e-02f, 3.49004418e-02f, 1.48389256e-04f, -8.64291657e-03f, -7.94274136e-02f, 6.44220691e-03f, -5.14527187e-02f, -7.59726912e-02f,
  -5.92546761e-02f, -5.50305210e-02f, 2.84567103e-03f, 5.62572293e-02f, 2.03267820e-02f, -6.25192970e-02f, -1.19132787e-01f, 1.93021689e-02f, 7.43589401e-02f, -8.94112587e-02f,
  1.72486022e-01f, -1.99509397e-01f, -2.03464359e-01f, 3.60093266e-02f, 6.28229603e-02f, 1.86178200e-02f, 1.55261029e-02f, 3.91826518e-02f, -9.16385129e-02f, -6.78344592e-02f,
  1.42053142e-01f, -1.68709196e-02f, -8.88161585e-02f, 1.47844389e-01f, 2.86705583e-01f, -1.10737346e-01f, 2.04530001e-01f, 8.59141275e-02f, -4.65819463e-02f, 5.27406633e-02f,
  -2.30654366e-02f, 2.84219712e-01f, 3.42270359e-02f, 8.48953724e-02f, 5.95370568e-02f, -3.13709192e-02f, 1.68766797e-01f, 5.35420105e-02f, 2.52172709e-01f, 2.10624233e-01f,
  -7.52838030e-02f, 4.09835093e-02f, -4.35734428e-02f, -4.35323231e-02f, -3.03629283e-02f, 6.10686578e-02f, 7.59050101e-02f, 6.59132376e-02f, -2.97028050e-02f, -1.60385072e-02f,
  -1.73182990e-02f, 1.25632170e-04f, 9.11633968e-02f, 4.96667176e-02f, -4.91533568e-03f, -5.31812124e-02f, -8.02939013e-02f, -4.03946526e-02f, -3.31375971e-02f, -5.67617528e-02f,
  -1.17414258e-02f, -9.60273743e-02f, -4.46295813e-02f, 4.16436419e-02f, -6.77001476e-03f, 2.45972387e-02f, -2.52752937e-02f, -3.38528268e-02f, 6.42938837e-02f, 6.07905574e-02f,
  8.40800703e-02f, -6.23153448e-02f, -4.06878889e-02f, 4.23875861e-02f, 3.07827890e-02f, 2.89749075e-02f, 1.37543194e-02f, -7.35110044e-02f, -4.62110601e-02f, 3.39372270e-02f,
  -3.51808853e-02f, 7.96426609e-02f, 1.38267828e-03f, 7.30972588e-02f, -2.87179416e-03f, -2.38679033e-02f, -1.87900271e-02f, 1.20361149e-01f, -4.47711423e-02f, -2.16671396e-02f,
  -5.16816415e-02f, -1.04737477e-02f, 1.05594145e-02f, -7.17990771e-02f, -9.56482533e-03f, 6.09075427e-02f, 6.15666062e-02f, 1.00159824e-01f, -6.96966797e-02f, -6.56574732e-03f,
  7.52963051e-02f, -7.93968514e-03f, 5.79116046e-02f, -5.26447073e-02f, 1.88578349e-02f, -2.97179352e-03f, 6.49985373e-02f, 1.28611084e-02f, -2.54413951e-02f, -6.66116402e-02f,
  -1.61566362e-02f, 4.95162085e-02f, 5.99141493e-02f, -5.88483037e-03f, -1.18629579e-02f, -2.65818350e-02f, -6.24486655e-02f, -5.88488430e-02f, 1.04060173e-01f, 7.81468153e-02f,
  -5.13253175e-02f, 1.92461945e-02f, -5.20218909e-02f, -6.47381246e-02f, 2.06373930e-02f, 1.78392082e-02f, 5.75042553e-02f, 5.20887272e-03f, 3.68759744e-02f, -6.45972416e-02f,
  1.38940495e-02f, -1.91376999e-01f, 1.25601643e-03f, 4.97169979e-02f, 5.43589443e-02f, 4.66209911e-02f, -1.00074388e-01f, -1.69316977e-02f, -4.85509820e-02f, -1.24264970e-01f,
  7.60283619e-02f, -7.08929822e-02f, -1.90456226e-01f, 9.88499895e-02f, 4.80599664e-02f, -7.46869892e-02f, 1.45344153e-01f, -3.20339501e-02f, -4.34384607e-02f, -4.68808506e-03f,
  1.85849294e-02f, 1.07714050e-01f, -1.88433733e-02f, 1.02390572e-01f, 4.81979251e-02f, 6.44205734e-02f, 6.18844703e-02f, -9.94722918e-03f, 2.03405634e-01f, 5.50858043e-02f,
  -5.29619642e-02f, -7.11935386e-03f, -6.00716136e-02f, -1.65570080e-02f, 5.29809631e-02f, -7.09899813e-02f, -9.91000757e-02f, 2.35798769e-02f, 5.64527996e-02f, -7.44642019e-02f,
  -2.78071892e-02f, 7.54559860e-02f, 1.09964363e-01f, 8.89353231e-02f, -2.18739156e-02f, 1.17790617e-01f, -3.95260453e-02f, 3.68855684e-03f, -6.70699328e-02f, -9.38140228e-02f,
  6.09796457e-02f, 8.62165540e-03f, -7.94059932e-02f, -2.21334361e-02f, 8.92857537e-02f, 8.23290423e-02f, 2.42541246e-02f, 4.94872984e-05f, 9.83959138e-02f, -5.47017716e-02f,
  -7.41430968e-02f, -1.50796017e-02f, 7.27143586e-02f, 2.04005023e-03f, -7.06025958e-02f, 7.14156255e-02f, 6.53697550e-02f, 5.89879565e-02f, -2.60838103e-02f, 1.19471531e-02f,
  3.42779569e-02f, 3.35054323e-02f, 5.59366085e-02f, -1.99648254e-02f, 2.20636781e-02f, 5.69471046e-02f, 4.79943678e-02f, -2.58542802e-02f, 7.62127936e-02f, -7.22156987e-02f,
  -6.51120394e-02f, 9.38510597e-02f, -8.96570012e-02f, -3.96387614e-02f, 3.38895991e-02f, -1.36256302e-02f, -4.59570065e-02f, 2.99315508e-02f, 5.73314875e-02f, -3.05891186e-02f,
  -3.23928222e-02f, -1.21531904e-01f, 4.97070327e-02f, -6.47079721e-02f, 6.46222085e-02f, 2.82683633e-02f, -7.28817508e-02f, 5.28103262e-02f, -5.67078777e-02f, -4.97107506e-02f,
  -6.85808957e-02f, 2.24762000e-02f, 2.90228408e-02f, -2.01994404e-02f, 9.10424367e-02f, 2.57137381e-02f, 3.19780759e-03f, -5.17545417e-02f, -4.49852347e-02f, -6.39207810e-02f,
  -3.16647589e-02f, -9.33394060e-02f, 4.84286472e-02f, 2.80621815e-02f, 6.37688339e-02f, 2.92913187e-02f, -6.57304525e-02f, -8.40959772e-02f, -6.88094646e-02f, 6.31702393e-02f,
  -2.08696887e-01f, 1.92024499e-01f, 1.37189955e-01f, 4.12915386e-02f, -6.47439361e-02f, 5.90536855e-02f, 8.83243456e-02f, 4.05224487e-02f, 6.23626299e-02f, 1.85176492e-01f,
  -6.29974827e-02f, 6.34713545e-02f, 1.06038727e-01f, 9.31144878e-02f, -6.93531707e-02f, -3.08575132e-03f, 1.63592488e-01f, 1.48297310e-01f, -4.58801277e-02f, -6.27224520e-02f,
  -1.58815682e-02f, 4.56109382e-02f, 1.20196819e-01f, -6.65396973e-02f, -6.70120046e-02f, -6.95617720e-02f, -1.62997529e-01f, -1.18481621e-01f, -8.92343745e-02f, -1.34586006e-01f,
  -6.58074543e-02f, -1.12483427e-01f, -7.05602542e-02f, -7.47115910e-02f, 1.40421616e-03f, 4.66381796e-02f, 6.40047491e-02f, -7.43508711e-02f, 8.66324734e-03f, -7.77418464e-02f,
  -1.46663236e-02f, -2.21327469e-02f, 7.04220682e-03f, -8.41567591e-02f, 5.96552528e-03f, -7.61595592e-02f, 6.73281923e-02f, -8.53480250e-02f, 3.91215533e-02f, -1.70088578e-02f,
  -3.30675654e-02f, -1.19047211e-02f, 7.24014193e-02f, 9.80931241e-03f, -4.64551337e-02f, 2.87485737e-02f, 7.22600073e-02f, 5.07610701e-02f, 4.22993526e-02f, -1.71184242e-02f,
  -1.01157809e-02f, 4.88863029e-02f, -4.40757796e-02f, 5.78869209e-02f, -3.63944285e-02f, 5.91170639e-02f, -4.94848676e-02f, -8.72988328e-02f, -7.32622817e-02f, -4.52947430e-02f,
  -8.25445056e-02f, -2.27688700e-02f, 2.31206324e-03f, 2.22929101e-02f, 2.94674858e-02f, 4.26325127e-02f, 7.25281844e-03f, -8.44962373e-02f, -3.69887985e-02f, 4.39997297e-03f,
  2.32169367e-02f, 5.85415140e-02f, -1.54450047e-03f, -3.05229276e-02f, 9.00303829e-04f, 1.34386914e-02f, -1.37411535e-03f, 2.71816179e-02f, 7.37727135e-02f, 5.63361496e-02f,
  1.29314205e-02f, -1.56457759e-02f, -3.38179395e-02f, -3.35080810e-02f, -4.93464060e-02f, -2.00981963e-02f, 2.94495970e-02f, -9.22598392e-02f, -5.75078391e-02f, 5.19091077e-03f,
  -9.07634348e-02f, -3.67354532e-03f, -5.93267344e-02f, -1.29034240e-02f, -1.24679552e-03f, -6.41094428e-03f, 1.97283868e-02f, 4.15365733e-02f, 3.99301760e-02f, 3.24475467e-02f,
  -5.93615603e-03f, 9.53556038e-03f, -6.35148510e-02f, 5.44493236e-02f, -3.17190811e-02f, -1.10785849e-02f, -1.38794007e-02f, -1.20265419e-02f, -9.73332673e-02f, 1.75989643e-02f,
  -9.22671035e-02f, 1.33806422e-01f, 7.01821595e-02f, 9.12609398e-02f, -4.31837179e-02f, -1.93779260e-01f, -7.51126930e-02f, 5.67669561e-03f, -1.12657808e-01f, 1.14129171e-01f,
  8.15922320e-02f, 6.81240708e-02f, 3.83678414e-02f, -1.12530656e-01f, -1.28493354e-01f, -1.59219176e-01f, -6.25240207e-02f, -1.07532218e-01f, -1.81942880e-02f, 2.04323009e-01f,
  3.18927430e-02f, -2.83333175e-02f, -3.81191932e-02f, 2.46382151e-02f, 8.62769634e-02f, 1.36546046e-01f, 3.20809245e-01f, 1.66252241e-01f, 1.24324828e-01f, 3.38125788e-02f,
  -1.37312457e-01f, 6.90380782e-02f, -2.74660178e-02f, -1.11065894e-01f, 2.84748599e-02f, 9.90024302e-03f, 8.11844785e-03f, -6.71915635e-02f, 1.37403412e-02f, 2.04153471e-02f,
  -5.38664078e-03f, -5.83550110e-02f, -2.09707161e-03f, 4.59282808e-02f, -7.86453136e-04f, 9.74820480e-02f, -3.60277593e-02f, -6.74407557e-02f, 4.84654307e-02f, -2.93968432e-02f,
  -2.08776128e-02f, 3.66521254e-02f, 5.92569783e-02f, 1.30890841e-02f, 1.14759631e-01f, -5.62683269e-02f, -1.70538444e-02f, 2.23028641e-02f, 1.17901400e-01f, 2.90791001e-02f,
  2.07256805e-03f, 4.85647246e-02f, 1.41292224e-02f, -1.57187313e-01f, -2.56330823e-03f, 4.56128158e-02f, -2.13051010e-02f, 5.92394397e-02f, -6.88369479e-03f, 2.67945472e-02f,
  -6.89305132e-03f, 1.40023688e-02f, -9.57933515e-02f, -2.37199441e-02f, -1.70575231e-02f, -2.66027097e-02f, 3.25909331e-02f, 3.57432961e-02f, 3.25840451e-02f, -6.44749328e-02f,
  8.53208005e-02f, 5.93995559e-04f, 2.78975237e-02f, 2.07989421e-02f, 1.20745006e-03f, 3.11768590e-03f, 7.19155325e-03f, 2.85397675e-02f, -2.83464417e-02f, 1.01569653e-01f,
  1.51830778e-01f, 3.91891241e-01f, 1.21221624e-01f, 2.45231614e-02f, 6.63403049e-02f, -2.88049057e-02f, -1.31894071e-02f, 2.09140051e-02f, 1.37686372e-01f, 3.61524001e-02f,
  9.42867994e-02f, 8.90842602e-02f, 4.98660840e-02f, -6.85100779e-02f, 2.32741367e-02f, -5.88980364e-03f, 8.90813917e-02f, 6.36025369e-02f, 8.84532630e-02f, 8.49210471e-02f,
  9.74133760e-02f, 7.37300217e-02f, 1.18326386e-02f, 6.76956177e-02f, 7.66624287e-02f, 3.02465074e-02f, -3.35466489e-02f, -1.67025216e-02f, -1.67848412e-02f, 9.58975703e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.72864035e-01f, 1.24662228e-01f, 1.42614514e-01f, -3.44214402e-02f, 1.01780131e-01f, 1.12273380e-01f, 1.18373320e-01f, 1.58469036e-01f, 2.02459339e-02f, 9.35640782e-02f,
  1.28297031e-01f, 3.93494070e-02f, 1.34957626e-01f, 6.74721301e-02f, 1.26512259e-01f, 1.40792176e-01f, 1.69921413e-01f, 5.27356453e-02f, 1.75240055e-01f, 1.55366451e-01f,
  5.83047345e-02f, 3.77763645e-03f, -9.55626369e-03f, 1.62776962e-01f, 8.04076865e-02f, 8.43783915e-02f, 4.34313109e-03f, 4.77049947e-02f, 1.25639141e-01f, 1.28670096e-01f,
  1.90610871e-01f, -3.04810284e-03f, 1.54475728e-02f, 5.49206138e-02f, 3.83500755e-02f, 2.78591830e-02f, 7.04258308e-02f, 1.29119053e-01f, 4.14151773e-02f, 1.92971483e-01f,
  3.85317691e-02f, 1.45309627e-01f, 6.13519140e-02f, -3.23503837e-02f, 1.33938164e-01f, 6.82417452e-02f, -2.03239452e-02f, 4.58766781e-02f, 8.61805603e-02f, -2.99476907e-02f,
  7.64637887e-02f, 2.62665659e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.60439797e-02f, -1.52801603e-01f, 9.56091285e-02f, 9.52659249e-02f, -5.64681552e-03f, -9.57735181e-02f, 1.50326982e-01f, 6.78915232e-02f, 2.10040659e-01f, -4.16531086e-01f,
  -2.56542802e-01f, 3.42265852e-02f, 2.47988920e-03f, 1.47241116e-01f, 9.86227766e-02f, -2.81328797e-01f, 8.23449902e-03f, -1.03042558e-01f, -5.79685718e-02f, 2.16269605e-02f,
  -1.07504606e-01f, 8.78874213e-02f, 4.58158180e-02f, 5.75027056e-03f, 6.76840171e-02f, -2.03851998e-01f, -2.36779358e-02f, -2.96539724e-01f, -9.22779217e-02f, 2.36493088e-02f,
  -7.32705519e-02f, -1.50203690e-01f, 5.67887910e-02f, 8.64585936e-02f, 5.80213740e-02f, -3.15045565e-01f, 5.75268120e-02f, -4.83889319e-02f, -1.13514431e-01f, 1.95254788e-01f,
  2.61544641e-02f, -1.57518625e-01f, 7.63289779e-02f, 2.70938456e-01f, 1.83979189e-03f, -1.86346322e-01f, 1.18171357e-01f, 4.14055556e-01f, 4.17294890e-01f, -8.08810741e-02f,
  3.62705857e-01f, -1.34246230e-01f, 4.47826423e-02f, -3.63583505e-01f, -2.34936357e-01f, -3.83555382e-01f, -2.78810740e-01f, 3.03966925e-03f, -3.57153654e-01f, -1.08339801e-01f,
  2.58508176e-02f, 1.85126036e-01f, 2.16413010e-02f, -2.59003878e-01f, -1.37419835e-01f, -3.70761395e-01f, 3.91438782e-01f, 1.14104308e-01f, -1.95989594e-01f, 3.88501078e-01f,
  -3.07457656e-01f, 1.30958930e-01f, 1.39677644e-01f, 3.63482267e-01f, 1.98291749e-01f, -9.31587666e-02f, -4.57623079e-02f, 1.78866774e-01f, 2.23500490e-01f, -8.18680599e-02f,
  -9.29209441e-02f, -1.41143790e-02f, -2.83197891e-02f, -6.52397936e-03f, -1.15502469e-01f, -2.80731078e-02f, 1.06074564e-01f, 1.93740994e-01f, 3.06321710e-01f, 2.79000960e-02f,
  -1.59067035e-01f, -1.73699975e-01f, -8.08485597e-02f, -3.29404436e-02f, -2.10675493e-01f, 1.15122087e-02f, -8.47388878e-02f, 8.21874589e-02f, -1.26377255e-01f, -6.78886622e-02f,
  1.99601978e-01f, 5.00865757e-01f, -8.42131525e-02f, 4.35889959e-02f, -7.14653209e-02f, -2.16356218e-01f, -2.44440451e-01f, 6.81148767e-02f, -1.14383258e-01f, -4.79526035e-02f,
  3.42848990e-03f, -1.29023194e-01f, -1.63871706e-01f, -1.12576708e-02f, -1.11597702e-01f, -2.19872132e-01f, -8.05679932e-02f, -6.12096153e-02f, -1.30195588e-01f, -1.55756399e-01f,
  8.40626433e-02f, 8.76167566e-02f, 1.51530281e-02f, 1.66602448e-01f, -1.21287763e-01f, -3.28825176e-04f, 3.21713746e-01f, -9.01878774e-02f, 1.66676968e-01f, 4.91735488e-02f,
  1.00923188e-01f, -2.34771699e-01f, 1.49869947e-02f, -2.86976218e-01f, 3.23367827e-02f, 1.20709062e-01f, 7.15626776e-02f, -2.29820493e-03f, 1.41339064e-01f, -9.16808322e-02f,
  2.17054859e-01f, -5.23653105e-02f, -1.43044069e-01f, 5.16849458e-02f, -1.92757830e-01f, 2.48690527e-02f, 1.09649204e-01f, 1.24935195e-01f, -2.72191972e-01f, 9.58048776e-02f,
  3.38231549e-02f, -7.40072653e-02f, 1.30944550e-01f, 1.84807703e-01f, -3.32229108e-01f, 1.13324173e-01f, 5.44487238e-02f, 1.43786758e-01f, 1.83126237e-02f, -2.34788284e-01f,
  2.12518051e-01f, -4.52679306e-01f, 6.47163242e-02f, 2.89849520e-01f, 5.64685240e-02f, 1.93465725e-02f, -2.75230855e-01f, -1.50950551e-01f, -1.08309984e-01f, -2.05798924e-01f,
  -4.06653702e-01f, 1.33268118e-01f, -2.63187617e-01f, -7.09179938e-02f, 3.06282818e-01f, 1.43228602e-02f, -5.17462976e-02f, 9.40002054e-02f, -5.80423847e-02f, 3.23722601e-01f,
  2.26840407e-01f, -2.68034518e-01f, -4.27251428e-01f, -1.47431031e-01f, -1.97139233e-01f, 1.71007104e-02f, -4.27726895e-01f, -7.35985488e-02f, -1.55651674e-01f, 1.51738077e-01f,
  2.34598517e-01f, 5.86561747e-02f, -1.78779572e-01f, -2.00004235e-01f, -1.21585786e-01f, -1.06520895e-02f, 2.52905220e-01f, 4.48042035e-01f, 3.00365034e-02f, 2.63193011e-01f,
  1.15394749e-01f, -1.06510788e-01f, 1.00595273e-01f, -9.42208022e-02f, 3.28370780e-01f, -1.58112988e-01f, -2.59324200e-02f, 9.16717872e-02f, -9.01167691e-02f, 1.31514177e-01f,
  -4.44792258e-03f, -1.16352685e-01f, 1.22474372e-01f, 4.30298261e-02f, -1.94334894e-01f, -1.21415900e-02f, 1.46856174e-01f, -2.06528366e-01f, -1.60174802e-01f, 2.38775119e-01f,
  -1.91193610e-01f, -2.35535130e-01f, -2.44451270e-01f, -3.74622643e-02f, 8.33720416e-02f, -9.68757272e-02f, -1.48836106e-01f, -2.12168783e-01f, -1.79211870e-01f, 1.91163570e-01f,
  -1.69124492e-02f, -6.52145818e-02f, 4.33003545e-01f, -2.17502430e-01f, 1.23459712e-01f, 7.66538903e-02f, -2.04448566e-01f, 1.70744166e-01f, -2.08096057e-01f, 5.27516119e-02f,
  -6.86784387e-02f, -4.50825542e-02f, -1.49777815e-01f, 1.54667031e-02f, 1.68388143e-01f, 1.24696225e-01f, 2.71413684e-01f, 1.54589294e-02f, -5.35036325e-02f, -1.63225651e-01f,
  8.42133984e-02f, -1.26880199e-01f, 3.24281514e-01f, 1.92790572e-02f, -1.17198259e-01f, -1.53088987e-01f, 2.25688219e-01f, -5.54887243e-02f, 8.47340822e-02f, -2.56221056e-01f,
  1.45279719e-02f, 4.43073809e-02f, 3.79265510e-02f, -2.86590695e-01f, -2.06537008e-01f, -3.17821791e-03f, 6.30433783e-02f, 1.99291185e-02f, -2.72050291e-01f, -8.12231600e-02f,
  -1.68832615e-01f, 1.94807199e-03f, 1.20117217e-01f, 1.02781653e-02f, 1.14109956e-01f, -1.45988464e-01f, 7.97059834e-02f, -1.46458834e-01f, -1.01253375e-01f, 2.59043090e-03f,
  -1.10808514e-01f, -3.94259505e-02f, 3.00639104e-02f, -1.82968117e-02f, -2.77812749e-01f, -1.94477513e-01f, -4.51223776e-02f, 6.49096593e-02f, -4.22308072e-02f, 2.41423137e-02f,
  -1.64054275e-01f, -3.90541643e-01f, 5.11089340e-02f, 9.79271159e-02f, 8.28089118e-02f, 1.91754535e-01f, -2.02002153e-01f, -2.90254325e-01f, 2.47987494e-01f, -1.49385378e-01f,
  -1.35215342e-01f, 3.61313999e-01f, 3.32257003e-01f, -1.74746349e-01f, -1.25942916e-01f, -2.21262082e-01f, 3.92528355e-01f, -2.42368191e-01f, 2.25487709e-01f, 2.95586288e-01f,
  -4.43388559e-02f, -1.11494228e-01f, 1.40107065e-01f, -2.44555026e-01f, -1.13580562e-01f, 3.77332628e-01f, -3.01652700e-02f, 1.64302848e-02f, -1.95282787e-01f, 1.70711741e-01f,
  -8.89394730e-02f, 2.11380813e-02f, -3.15232456e-01f, -2.61007160e-01f, 3.27376604e-01f, 2.12003086e-02f, -2.46728420e-01f, 1.80855453e-01f, -7.41902692e-03f, -3.38224888e-01f,
  -7.30205998e-02f, 1.62159190e-01f, 2.85640001e-01f, -1.12097681e-01f, 4.35587503e-02f, -8.95370468e-02f, -6.10119253e-02f, 3.84569347e-01f, 3.86636890e-02f, 1.27290234e-01f,
  -1.75981596e-01f, 1.08337954e-01f, -2.31123194e-02f, 5.50045120e-03f, -1.13069765e-01f, 8.99644196e-02f, -5.18306196e-02f, 5.68025820e-02f, -1.76769271e-01f, -1.31003886e-01f,
  2.24406987e-01f, 8.52873474e-02f, -1.30157862e-02f, -2.98104901e-02f, -5.60715683e-02f, 9.12848637e-02f, 7.48340636e-02f, 4.01428714e-02f, -8.33916813e-02f, -9.63150859e-02f,
  1.27205804e-01f, -1.71401232e-01f, 9.15699527e-02f, 2.31630169e-02f, -3.97566445e-02f, -1.08635416e-02f, -3.28392237e-02f, -6.69116229e-02f, 7.72307813e-03f, 2.44241375e-02f,
  -9.60114375e-02f, -1.69221595e-01f, 2.00912841e-02f, -1.04316257e-01f, 3.18373948e-01f, 8.22559092e-03f, -8.43626112e-02f, -1.06667146e-01f, 1.07679576e-01f, 1.73667833e-01f,
  4.31952149e-01f, 4.11592752e-01f, -1.20869182e-01f, -2.08409697e-01f, -3.08971126e-02f, -5.95669262e-02f, 5.05625792e-02f, -6.22625768e-01f, 5.04279509e-02f, 1.08813591e-01f,
  -2.25563005e-01f, -9.62402150e-02f, 1.95096042e-02f, 1.67509630e-01f, -2.28277415e-01f, 1.48900568e-01f, -9.81191993e-02f, -2.10676894e-01f, -6.87556565e-02f, -8.05923343e-02f,
  1.01273786e-02f, 4.45390306e-03f, 6.18947595e-02f, 2.65117250e-02f, -9.98141542e-02f, -5.50500602e-02f, -2.15000197e-01f, 5.27743772e-02f, -2.62245312e-02f, -1.00933045e-01f,
  5.38641773e-02f, -5.63103370e-02f, -1.67070106e-02f, -2.34289654e-02f, -1.11599884e-03f, 5.13580106e-02f, -5.60587570e-02f, -1.41952008e-01f, 1.15919150e-01f, -2.55113631e-01f,
  -2.23424062e-01f, 5.93639649e-02f, -3.00512344e-01f, 1.05756126e-01f, 1.39253452e-01f, 4.49947238e-01f, 9.18560196e-03f, -4.07267250e-02f, 3.02902371e-01f, -1.74707443e-01f,
  2.68921780e-04f, -1.65750906e-01f, 3.11158597e-01f, -1.34885758e-01f, -2.27992579e-01f, -2.01199785e-01f, -3.81628066e-01f, -3.48298371e-01f, 1.23251185e-01f, -6.72974363e-02f,
  -4.07881066e-02f, -2.03398556e-01f, 1.84155226e-01f, -4.02555346e-01f, 2.55116284e-01f, 3.62323076e-02f, 1.07625671e-01f, 2.95892686e-01f, 1.58439666e-01f, 2.41602302e-01f,
  2.49249637e-01f, 1.76628456e-01f, -6.79928586e-02f, -1.16058171e-01f, -2.84922749e-01f, -3.20922226e-01f, -3.70655507e-01f, 1.83355108e-01f, 3.63573343e-01f, -1.41943172e-01f,
  -1.89556852e-01f, 1.39571400e-03f, 5.45037389e-02f, 1.50589496e-01f, 2.79094111e-02f, -7.09471330e-02f, -2.79772226e-02f, 5.49447358e-01f, 3.02910875e-03f, -1.34061992e-01f,
  7.80216977e-02f, -1.72751084e-01f, -1.29650086e-01f, 2.40269769e-02f, 1.11210689e-01f, -1.15893826e-01f, -5.98496310e-02f, -2.27218475e-02f, 3.72963883e-02f, 7.40796607e-03f,
  3.42988968e-02f, 2.54128456e-01f, 1.08676113e-01f, -1.57117750e-02f, -9.71380174e-02f, -1.35027066e-01f, 2.95180917e-01f, -1.75482091e-02f, -3.33852731e-02f, 2.24725366e-01f,
  -1.00849807e-01f, 1.73658866e-03f, 8.13501626e-02f, -7.95685407e-03f, -1.77479371e-01f, -4.69264574e-02f, -3.59739847e-02f, -3.80655192e-02f, -1.57932155e-02f, 2.47691900e-01f,
  -1.53746992e-01f, -8.17090571e-02f, -7.36587569e-02f, -2.25131549e-02f, 4.87229586e-01f, 3.12447418e-02f, -1.25655860e-01f, 3.89579982e-02f, -4.37675938e-02f, 2.47581862e-02f,
  -6.56021833e-02f, 1.11512005e-01f, 3.75362366e-01f, -1.15650184e-01f, -9.94222835e-02f, 4.20841962e-01f, 7.12291598e-02f, 9.64103267e-03f, -1.84190899e-01f, 1.01896510e-01f,
  -3.13748538e-01f, -1.03151537e-01f, -8.50352198e-02f, 6.25850782e-02f, 1.07721202e-01f, 1.53119177e-01f, -2.04465792e-01f, 1.17741711e-01f, 1.17069192e-01f, 1.57460794e-02f,
  1.10384025e-01f, 1.22275166e-01f, 2.14158326e-01f, 1.87224355e-02f, 9.26868170e-02f, 3.31567880e-03f, -9.91640836e-02f, 2.26756051e-01f, -4.62775875e-04f, 9.50405747e-02f,
  1.27889797e-01f, -3.68252173e-02f, 2.10782234e-02f, 9.20138434e-02f, 2.54257292e-01f, 2.76686554e-03f, 3.23608637e-01f, 7.20337033e-02f, 3.10485214e-01f, 7.96993673e-02f,
  1.26597971e-01f, 1.27792835e-01f, 3.09465408e-01f, -6.38661673e-03f, -3.54835391e-01f, -4.12614346e-02f, 5.53767025e-01f, 9.57794562e-02f, -5.30809999e-01f, 2.73394674e-01f,
  3.26523751e-01f, -1.21524855e-01f, 9.53898355e-02f, -3.99648765e-04f, -2.37142488e-01f, 9.59387124e-02f, -8.48985743e-03f, 2.93976158e-01f, -1.73566669e-01f, -1.31630719e-01f,
  2.68001437e-01f, 2.09003668e-02f, 7.10536540e-02f, -1.41339721e-02f, -3.38285893e-01f, -5.55287190e-02f, 3.81332368e-01f, -2.87587699e-02f, 1.07647896e-01f, 1.92952782e-01f,
  -7.89931882e-03f, -6.15685955e-02f, -3.64560694e-01f, -1.34355918e-01f, -4.37182263e-02f, 2.35695451e-01f, 4.58148727e-03f, 1.33741766e-01f, -1.08131424e-01f, 3.17713737e-01f,
  -1.53990462e-01f, 1.98281743e-02f, -1.46145210e-01f, -2.36653369e-02f, 1.99486930e-02f, -1.24792479e-01f, 6.05288558e-02f, -5.13037480e-02f, 2.19774708e-01f, 1.67756185e-01f,
  2.02803075e-01f, -6.44193515e-02f, -8.69247317e-02f, 5.92480227e-03f, -1.33960336e-01f, 1.22300826e-01f, 3.08267683e-01f, 2.45541409e-01f, 2.63534635e-01f, 5.42936698e-02f,
  -1.06450751e-01f, 1.77659839e-01f, -1.40598431e-01f, -1.07496813e-01f, -4.97660525e-02f, 1.98541552e-01f, -6.21846393e-02f, 4.30254787e-02f, -1.66530997e-01f, 1.80570826e-01f,
  -2.12932676e-02f, -1.07211567e-01f, -1.44781321e-01f, -1.17256381e-01f, -6.28814101e-02f, 1.28356636e-01f, -1.02308445e-01f, 1.83122367e-01f, -1.46840006e-01f, -2.41623688e-02f,
  -1.56170473e-01f, 5.26460931e-02f, 7.88790211e-02f, 2.99373180e-01f, -9.22141448e-02f, 2.55917102e-01f, -1.79199427e-01f, -6.55205324e-02f, 1.01295508e-01f, -2.29667485e-01f,
  2.16351241e-01f, 1.12439148e-01f, 1.03940137e-01f, 9.59291011e-02f, 1.21075232e-02f, -6.78006038e-02f, 2.16879636e-01f, 6.23997003e-02f, 1.00972883e-01f, -2.17526127e-02f,
  7.25486577e-02f, -5.78305349e-02f, -2.92898975e-02f, -7.90593103e-02f, 2.49962896e-01f, 9.13409963e-02f, 3.56516540e-02f, 3.36554311e-02f, 1.28641799e-01f, -2.38580093e-01f,
  8.32515359e-02f, 6.29088469e-03f, 1.53156206e-01f, 1.13781154e-01f, 8.92880745e-03f, 3.31606045e-02f, 3.77120487e-02f, 1.49032250e-01f, 1.05064914e-01f, 8.94815102e-03f,
  1.09964676e-01f, 2.39105240e-01f, 1.80933569e-02f, 1.24205671e-01f, -6.61435798e-02f, -3.99944894e-02f, 2.75708083e-03f, 1.19809829e-01f, 3.39825332e-01f, -1.42189085e-01f,
  -2.20663339e-01f, -3.63388926e-01f, 1.42196670e-01f, 3.88669878e-01f, -7.05417842e-02f, 8.15692768e-02f, -2.57193506e-01f, 3.21854770e-01f, -1.52558759e-01f, 2.63039377e-02f,
  -4.31267142e-01f, 4.54854876e-01f, -2.71276891e-01f, -6.10523820e-02f, -7.81869218e-02f, 2.52707183e-01f, -1.20043689e-02f, 4.33042318e-01f, -1.99056223e-01f, -3.08572471e-01f,
  -2.33004525e-01f, 5.96792549e-02f, 3.38201016e-01f, -1.62089854e-01f, -2.48498186e-01f, 1.06931336e-01f, 1.63734943e-01f, 8.67506713e-02f, 7.60745853e-02f, 3.06570828e-01f,
  3.57546747e-01f, 1.44104153e-01f, 4.85125840e-01f, 2.71216244e-01f, -4.44009155e-01f, 1.31606191e-01f, 1.14742117e-02f, -6.26385361e-02f, -1.00491598e-01f, -3.38731147e-02f,
  -1.41336426e-01f, -2.35788047e-01f, -2.78957754e-01f, -1.74213395e-01f, -9.56460014e-02f, 1.32052451e-01f, 8.89234915e-02f, 7.40334690e-02f, -1.07976072e-01f, 3.35846804e-02f,
  3.35242115e-02f, -2.33268216e-02f, 2.01943085e-01f, 2.35720770e-03f, -2.04709724e-01f, -1.23136006e-01f, -9.55128968e-02f, -1.96308836e-01f, 1.08885951e-01f, -7.26303831e-02f,
  9.12858546e-03f, 4.30803970e-02f, -1.62380397e-01f, 1.32816344e-01f, 1.53347868e-02f, 3.99704725e-02f, -1.76904246e-01f, -1.25599444e-01f, 3.91103327e-01f, -1.24399237e-01f,
  -2.75293197e-02f, -9.76409465e-02f, -1.60336018e-01f, 8.56364816e-02f, 1.41959131e-01f, -1.61376297e-01f, 2.03816622e-01f, 2.81438798e-01f, -1.81656733e-01f, -1.19149253e-01f,
  1.16469674e-01f, -1.23387218e-01f, -1.17280297e-01f, -1.60486951e-01f, -7.97022730e-02f, -4.39300686e-02f, 1.98666796e-01f, 1.06843673e-01f, -3.69799107e-01f, 8.92035961e-02f,
  1.93653926e-01f, 9.93311554e-02f, -5.26967645e-02f, 7.91856200e-02f, -9.12468433e-02f, 6.32674024e-02f, 2.49678001e-01f, 8.23241472e-03f, -9.37151462e-02f, 2.48955283e-03f,
  1.72001719e-01f, -5.92777766e-02f, 1.45731553e-01f, 8.33315179e-02f, 9.11871567e-02f, -1.40542716e-01f, 1.28049448e-01f, 3.67369317e-02f, 1.64411575e-01f, 3.32012884e-02f,
  -2.59687275e-01f, -2.50094663e-02f, 4.29410189e-02f, -1.37939557e-01f, -1.27554595e-01f, 8.70798305e-02f, -2.82706380e-01f, 3.51448283e-02f, -2.78791282e-02f, 1.62251405e-02f,
  -2.24968884e-02f, 2.30744332e-01f, -3.26268934e-02f, -2.56035589e-02f, -1.20545827e-01f, 5.48322946e-02f, 4.07088965e-01f, 6.85256943e-02f, 1.47178516e-01f, 4.95574027e-02f,
  -8.39548558e-02f, -2.70265918e-02f, -1.79395437e-01f, 2.63097674e-01f, 9.54218805e-02f, -3.07235479e-01f, -4.44313198e-01f, 3.24143857e-01f, 1.14824623e-01f, 2.25858893e-02f,
  -1.68639377e-01f, 7.44306520e-02f, 1.02705620e-01f, 2.91595966e-01f, 1.31413549e-01f, 1.16680130e-01f, -4.48226146e-02f, 2.52662413e-02f, -3.48375767e-01f, 8.70256103e-04f,
  -1.39572378e-02f, 2.75659025e-01f, -4.99776334e-01f, 1.84206739e-01f, -4.45676774e-01f, -2.80284345e-01f, 3.40030134e-01f, -3.68851185e-01f, 3.16883415e-01f, -2.70791184e-02f,
  -7.68291205e-02f, -3.08895886e-01f, -2.37372801e-01f, -8.07257220e-02f, -7.63715282e-02f, -2.55129002e-02f, -1.42149270e-01f, -1.10188592e-02f, -1.51640907e-01f, 5.67055047e-02f,
  2.68789977e-01f, -5.22714183e-02f, -6.30883500e-02f, 2.37933338e-01f, 3.10645513e-02f, 4.96392101e-02f, -7.04479069e-02f, -3.32726538e-02f, 7.44501501e-02f, -1.48893878e-01f,
  4.68594283e-01f, 3.13698411e-01f, 1.47152200e-01f, -1.16721958e-01f, -9.27214921e-02f, 9.92473811e-02f, -8.52764398e-02f, 2.25720078e-01f, -4.47196364e-02f, -1.08510725e-01f,
  1.35034134e-04f, -8.72224867e-02f, 1.19896986e-01f, 3.44292343e-01f, 1.84465200e-01f, -1.14477359e-01f, 6.20611385e-02f, -7.15368018e-02f, -6.24401495e-02f, -1.52178228e-01f,
  3.60569298e-01f, -1.23899937e-01f, -1.29697233e-01f, -1.94532827e-01f, 1.29817516e-01f, 2.09684655e-01f, -1.96044091e-02f, 1.70673221e-01f, -1.49751186e-01f, -2.07006317e-02f,
  -2.60315835e-02f, 8.84857401e-02f, -1.62412181e-01f, 7.95428827e-02f, -1.10497013e-01f, -2.71471232e-01f, 9.99781024e-03f, 1.20843947e-01f, -2.08186328e-01f, -1.62707895e-01f,
  -6.15592189e-02f, -7.76647106e-02f, -1.07440867e-01f, -6.58405721e-02f, -1.37512758e-01f, 2.87140049e-02f, 1.24816068e-01f, -7.29983300e-03f, -4.21762504e-02f, -4.22334410e-02f,
  1.47147089e-01f, -7.49383122e-02f, 9.37564448e-02f, -1.05040781e-01f, -2.58347522e-02f, -9.54741687e-02f, -2.33732522e-01f, -8.76263157e-02f, 2.71380581e-02f, -1.77052066e-01f,
  -5.07347845e-02f, -1.81151647e-02f, -1.49044365e-01f, -1.04259990e-01f, -1.07731566e-01f, 9.35594514e-02f, -6.57607662e-03f, -7.29079172e-02f, -1.62862375e-01f, -2.28613511e-01f,
  -7.32212514e-02f, 2.52290610e-02f, -3.01444251e-02f, -9.12784189e-02f, 1.67748168e-01f, 2.48918440e-02f, 1.48861736e-01f, 2.89102167e-01f, 2.05792084e-01f, -3.94448906e-01f,
  2.08148196e-01f, -2.58754659e-02f, 2.60059698e-03f, -9.41943452e-02f, 5.14827408e-02f, 4.65505645e-02f, 1.45433098e-01f, -6.63387105e-02f, 1.19998259e-03f, -9.33550224e-02f,
  2.41870787e-02f, 1.63231760e-01f, 2.10648656e-01f, 1.81961223e-01f, 3.48826379e-01f, -2.13604882e-01f, 1.25906110e-01f, -2.50506967e-01f, 2.10760489e-01f, -1.77864596e-01f,
  2.71139324e-01f, 6.48759976e-02f, 3.03131253e-01f, -4.39914130e-02f, 2.25435048e-01f, -1.73952967e-01f, 2.37298355e-01f, -2.63076067e-01f, 3.70075166e-01f, 4.19245213e-02f,
  -1.78890035e-01f, -4.92010713e-02f, 1.22337248e-02f, 3.15753430e-01f, 1.74987521e-02f, 7.95917287e-02f, -2.78624371e-02f, 1.36574283e-02f, 1.15086414e-01f, -6.90962712e-04f,
  9.90689248e-02f, -3.83650176e-02f, 1.61869705e-01f, 1.64173454e-01f, -4.83254641e-02f, -1.19474813e-01f, -5.31556383e-02f, 4.91671115e-02f, -2.21326072e-02f, -7.53446296e-02f,
  -1.15874223e-01f, -9.59974229e-02f, -2.44316068e-02f, -1.90470014e-02f, 1.63280725e-01f, -3.24740075e-02f, 2.08496779e-01f, -5.21909446e-02f, 4.38830964e-02f, -1.00062065e-01f,
  -1.86669715e-02f, -2.65137069e-02f, 1.56137049e-02f, -3.14635225e-02f, 1.52607039e-01f, 1.87694039e-02f, 2.12828919e-01f, 5.20434201e-01f, 8.11301917e-02f, -9.89895910e-02f,
  1.22500859e-01f, 6.19400561e-01f, -6.48585707e-02f, -1.02136090e-01f, -1.40573174e-01f, -3.77185196e-02f, 6.15696646e-02f, -1.33646384e-01f, -1.98230576e-02f, -7.10095540e-02f,
  -1.20454870e-01f, -9.36875716e-02f, -1.73288897e-01f, -9.70993191e-02f, -2.93104678e-01f, -3.76822017e-02f, -1.17974177e-01f, 1.06737755e-01f, -6.03571720e-02f, 8.47248435e-02f,
  -3.03957254e-01f, -6.13205805e-02f, -3.60595696e-02f, -4.02134992e-02f, 1.11984402e-01f, -1.05093114e-01f, 1.25809401e-01f, 9.52466875e-02f, 5.72012290e-02f, -2.36412622e-02f,
  -1.36254504e-01f, -9.59300175e-02f, -2.04088569e-01f, -4.40470092e-02f, -4.87678535e-02f, -2.02998258e-02f, -5.50828986e-02f, -1.69666827e-01f, 7.41184950e-02f, -1.44576132e-02f,
  -2.31844410e-02f, -8.23890697e-03f, 5.15936092e-02f, -3.29543045e-03f, 8.88119265e-02f, -4.13123183e-02f, -2.37421140e-01f, -4.26030792e-02f, 6.52033165e-02f, -2.95189675e-02f,
  -1.00394644e-01f, -2.03997456e-02f, -2.60599971e-01f, -8.99518505e-02f, -1.52181715e-01f, -1.44846141e-01f, -1.33287370e-01f, -1.15284584e-02f, -3.62297714e-01f, 2.27063239e-01f,
  2.42819861e-01f, -3.38814497e-01f, 2.91640945e-02f, -2.53900915e-01f, -1.32827222e-01f, -2.74047032e-02f, 4.46909703e-02f, 2.45715946e-01f, 2.68059641e-01f, 9.26753879e-02f,
  2.06197560e-01f, 2.39713907e-01f, 1.28457770e-01f, 2.44950354e-01f, -3.15337069e-02f, 2.01564059e-01f, -1.11209854e-01f, -3.22356552e-01f, 2.83905804e-01f, 2.15461329e-01f,
  7.13241026e-02f, -6.54521659e-02f, 4.51097377e-02f, -6.50876686e-02f, -2.89444685e-01f, 1.96718872e-01f, -2.02164799e-01f, -2.50263214e-01f, 2.55235791e-01f, -2.40227148e-01f,
  1.40054464e-01f, -1.45288259e-01f, 1.23657614e-01f, 3.41496468e-02f, -4.82847095e-02f, -6.51385114e-02f, 4.77973521e-02f, -9.18194652e-02f, -8.95384252e-02f, 1.83588006e-02f,
  1.20158330e-01f, -1.32754952e-01f, 1.07431695e-01f, -1.65412501e-02f, 1.51119038e-01f, 2.26362899e-01f, -1.02333345e-01f, 8.74463916e-02f, -9.62540731e-02f, -1.87383398e-01f,
  -2.21630931e-02f, -8.81354213e-02f, -4.00652736e-02f, -8.44543353e-02f, 1.98708862e-01f, 4.35200706e-02f, 2.49117479e-01f, -5.82056791e-02f, 2.88731307e-02f, -1.22827426e-01f,
  6.32453978e-01f, 9.41243619e-02f, -3.00838985e-02f, -1.85136851e-02f, -9.82852057e-02f, -1.88545451e-01f, -1.29396230e-01f, 3.49843614e-02f, 2.69176304e-01f, -1.00126676e-01f,
  -1.19218491e-02f, 3.69777083e-02f, -1.67518064e-01f, 4.54425812e-03f, -1.32030517e-01f, 1.84688255e-01f, 8.35937187e-02f, -1.58327632e-02f, 1.53520465e-01f, 4.86866646e-02f,
  1.03002489e-02f, 4.59281147e-01f, -3.55051070e-01f, 8.03200752e-02f, -1.57802984e-01f, 1.98040798e-01f, 5.90330996e-02f, 5.22856191e-02f, 1.63216665e-01f, 9.74518806e-02f,
  -2.23765187e-02f, 7.29046091e-02f, 1.07468456e-01f, 3.76836360e-02f, -4.16666344e-02f, -3.30909295e-03f, 1.20713692e-02f, 1.21025005e-02f, -4.72749472e-02f, 1.02284789e-01f,
  -1.43436313e-01f, 3.28666531e-02f, 1.55209959e-01f, 8.79685022e-03f, 8.12855512e-02f, -5.68617508e-02f, -1.74595058e-01f, -3.08092553e-02f, 1.88589141e-01f, 6.45281933e-03f,
  2.05377191e-01f, 7.73387551e-02f, 9.29710269e-02f, 4.90695573e-02f, -2.96623260e-01f, 4.35957722e-02f, 6.72395229e-02f, 1.86539203e-01f, 4.75892648e-02f, -2.45581567e-01f,
  3.61789048e-01f, -1.80009261e-01f, 3.17251652e-01f, -8.48755315e-02f, 2.84090966e-01f, -2.51563609e-01f, -3.16033125e-01f, -5.13616726e-02f, -4.40553337e-01f, 2.55253404e-01f,
  4.50079367e-02f, 3.16879004e-02f, 3.70833367e-01f, 3.25330973e-01f, 4.02780026e-01f, 1.73278123e-01f, 1.34124875e-01f, -8.99498235e-04f, -2.74150133e-01f, -2.58888632e-01f,
  -6.32914975e-02f, 2.42600575e-01f, -8.98465440e-02f, -6.44836575e-02f, -4.28768605e-01f, -7.66141713e-02f, 2.83975095e-01f, -2.21195579e-01f, -6.48223162e-02f, -4.17627729e-02f,
  -5.19260541e-02f, -1.61418840e-01f, 5.09816170e-01f, -1.39151484e-01f, 3.36472988e-01f, -2.36914769e-01f, -2.73913175e-01f, 2.51089215e-01f, -2.00112075e-01f, 3.27594057e-02f,
  -4.58945371e-02f, -1.67687848e-01f, -1.85517706e-02f, -2.12061014e-02f, 3.19240212e-01f, -4.43230979e-02f, -8.52837637e-02f, -1.38724387e-01f, -7.06968829e-03f, 9.25302356e-02f,
  -2.01114118e-01f, -8.88178125e-03f, 1.07969470e-01f, -3.40539403e-02f, -1.47278532e-01f, -1.57235146e-01f, -1.72590300e-01f, 1.32238254e-01f, 2.67687708e-01f, 9.83600598e-03f,
  4.17183414e-02f, 2.58132458e-01f, -4.65447456e-02f, -1.12707116e-01f, 4.67835506e-03f, 1.81113452e-01f, -2.04825416e-01f, -1.51269853e-01f, -2.10218415e-01f, 1.95762545e-01f,
  -5.15710264e-02f, -1.40061244e-01f, 3.17646801e-01f, 2.46100947e-02f, 4.27109033e-01f, -1.67388529e-01f, -1.42932078e-02f, -7.00372085e-02f, -3.06763686e-02f, -8.17088336e-02f,
  2.46812180e-01f, 3.98578048e-02f, -2.12672666e-01f, 1.41536683e-01f, -1.98428966e-02f, -4.60392274e-02f, 8.47738460e-02f, -7.02753738e-02f, -1.20344460e-01f, -9.40997005e-02f,
  -1.84531853e-01f, 6.32664636e-02f, 5.83210327e-02f, 3.08070689e-01f, 6.76829601e-04f, -1.22941500e-02f, 2.50408202e-01f, 1.79178089e-01f, -7.43981749e-02f, 7.39334375e-02f,
  1.14553712e-01f, -1.45218536e-01f, -5.50598167e-02f, 5.27010672e-02f, 2.51450986e-01f, 4.15345542e-02f, -6.02626577e-02f, 1.10024601e-01f, 9.87793282e-02f, -9.81561467e-02f,
  1.33858144e-01f, 9.19618383e-02f, -4.06590365e-02f, 6.16902485e-02f, -2.23124810e-02f, -1.07273459e-01f, 7.10518062e-02f, 1.27139598e-01f, 1.40068352e-01f, 3.47543806e-02f,
  -5.83829805e-02f, 5.03031239e-02f, 1.55755386e-01f, 1.08980842e-01f, -3.69533896e-01f, 2.95316964e-01f, -8.56830627e-02f, 1.05361134e-01f, -4.23331678e-01f, -1.27752975e-01f,
  -1.25289187e-01f, 1.68312222e-01f, -1.03873871e-01f, -2.43938774e-01f, 2.76138037e-01f, -1.26188055e-01f, 3.67790580e-01f, -2.97057569e-01f, -1.75377324e-01f, 4.28334445e-01f,
  -4.50779259e-01f, -2.90099382e-01f, -3.39220501e-02f, 5.23025729e-02f, -1.71536699e-01f, -1.04437299e-01f, 6.46291971e-02f, -2.13097662e-01f, 1.31294757e-01f, -1.55419447e-02f,
  3.07753235e-01f, 6.57232553e-02f, -1.57918319e-01f, 3.74765337e-01f, -1.43448472e-01f, -8.68487433e-02f, -1.32712405e-02f, -2.55335540e-01f, -2.67477423e-01f, 3.19936536e-02f,
  -1.81107879e-01f, 4.18137312e-02f, -3.49759877e-01f, -1.26474157e-01f, 2.30615541e-01f, -8.96333158e-02f, 2.99686473e-02f, -1.44720495e-01f, 1.32046521e-01f, -3.58279161e-02f,
  2.31766462e-01f, -2.06390381e-01f, -1.58090383e-01f, 1.88648224e-01f, 2.63542414e-01f, 4.33521457e-02f, -1.93027958e-01f, -6.81806952e-02f, 4.95102897e-04f, 3.01940292e-02f,
  -7.49753267e-02f, -1.59715831e-01f, -2.61190444e-01f, -1.29347548e-01f, 4.18886207e-02f, 1.13236420e-01f, -1.51106402e-01f, -4.64356504e-02f, -1.08558856e-01f, 1.04656599e-01f,
  -6.78761005e-02f, -1.19350441e-01f, -5.95064722e-02f, -1.66542947e-01f, -6.95700049e-02f, -7.62011856e-02f, -3.13908070e-01f, -6.19115904e-02f, -6.63609579e-02f, 1.63824975e-01f,
  -1.70128286e-01f, -9.91016254e-03f, -6.16797954e-02f, 4.65878807e-02f, -1.19623579e-01f, -1.60645306e-01f, -4.43258062e-02f, -2.15852320e-01f, -4.34911437e-02f, -1.73956141e-01f,
  5.48439212e-02f, 4.33951616e-02f, 2.05419445e-03f, -2.16806620e-01f, -5.53700561e-03f, -3.88769247e-02f, -9.15582925e-02f, 4.13291216e-01f, 1.92464203e-01f, -1.15380511e-02f,
  2.29581781e-02f, 2.05500603e-01f, 5.75220212e-03f, 5.58798574e-02f, 1.87160730e-01f, -6.06208369e-02f, 6.33799732e-02f, 2.35693663e-01f, -7.76869655e-02f, -6.24669604e-02f,
  6.53468594e-02f, 9.46675688e-02f, -2.76766717e-01f, 9.88657251e-02f, -9.93096083e-02f, 1.35255828e-01f, -4.73620221e-02f, 1.60779655e-01f, 1.77536178e-02f, 5.70840351e-02f,
  2.37778258e-02f, -2.12529421e-01f, 4.90571521e-02f, 1.36430562e-01f, 1.41622990e-01f, -7.55546689e-02f, 3.89078893e-02f, -7.63357505e-02f, -1.38685435e-01f, -1.02270037e-01f,
  1.53618962e-01f, 2.78015602e-02f, 7.55119994e-02f, 1.67078048e-01f, -2.09224373e-02f, -3.32110301e-02f, -2.30075985e-01f, -1.10736504e-01f, -2.28821710e-01f, 2.24469248e-02f,
  9.43140164e-02f, 2.50609338e-01f, 1.41664430e-01f, -2.89618552e-01f, 4.67282198e-02f, 6.76186010e-02f, -3.83271575e-01f, -3.81109834e-01f, -1.03957929e-01f, -1.61132198e-02f,
  -3.64457458e-01f, 2.08082885e-01f, 3.73261780e-01f, -2.62082778e-02f, 3.42050970e-01f, 7.85158668e-03f, 2.21062258e-01f, 2.27772579e-01f, -2.87613180e-02f, -4.42095071e-01f,
  2.90458798e-01f, 2.11276531e-01f, 2.20388900e-02f, 1.53796583e-01f, -1.80435613e-01f, 4.66269583e-01f, -3.36262226e-01f, -2.02181250e-01f, 1.33523243e-02f, -3.39548826e-01f,
  -3.49355996e-01f, 3.01936567e-01f, -3.23472381e-01f, 3.00078038e-02f, -7.88443610e-02f, -1.81897059e-01f, -1.14595152e-01f, 2.10457370e-01f, 2.63796121e-01f, -1.97778657e-01f,
  1.91395842e-02f, -2.48530686e-01f, 9.62352753e-02f, -1.16474740e-01f, -9.91187841e-02f, -1.93789557e-01f, -1.45071551e-01f, 3.20005298e-01f, -2.47953515e-02f, 3.85586061e-02f,
  3.53376627e-01f, 5.33284247e-02f, 8.20781514e-02f, -9.69613865e-02f, -4.71652113e-02f, 1.51553243e-01f, 1.65691346e-01f, -7.13305697e-02f, 2.92943474e-02f, -9.35156550e-03f,
  5.01787215e-02f, 3.20712919e-03f, 3.27594131e-02f, -3.45781259e-02f, 1.10405080e-01f, -1.58004984e-01f, -2.68982220e-02f, -6.17970116e-02f, 1.42763048e-01f, -6.67028874e-02f,
  -1.11129239e-01f, 1.16505198e-01f, 4.22952771e-01f, -1.88198030e-01f, 1.15364209e-01f, -1.24752492e-01f, -1.47569627e-01f, 4.70273197e-02f, -1.19702555e-01f, -1.26136452e-01f,
  2.03343853e-02f, -1.24045350e-01f, -2.27460802e-01f, 1.11349765e-02f, 9.65727270e-02f, -1.82518568e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.68805714e-02f, 6.67489544e-02f, -8.98238122e-02f, -9.39975604e-02f, 7.90934265e-02f, 8.44572708e-02f, 3.36524891e-03f, -6.14168996e-04f, 2.38467567e-02f, -8.59160274e-02f,
  8.03050846e-02f, 7.55451173e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    