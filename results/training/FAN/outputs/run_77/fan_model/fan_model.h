/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.53715515e-01f, 1.14565432e-01f, -3.57184798e-01f, 4.59775291e-02f, 1.98382676e-01f, -2.45078459e-01f, -1.70457974e-01f, 1.86539367e-01f, -2.58024722e-01f, 2.73456663e-01f,
  1.30521625e-01f, -2.05575868e-01f, -1.63672209e-01f, 2.19860122e-01f, -2.59696513e-01f, -1.30378813e-01f, 1.19986720e-01f, 1.12326704e-01f, -1.05024472e-01f, 6.36328384e-02f,
  -1.97859451e-01f, 2.28651226e-01f, 4.38170023e-02f, 1.87165275e-01f, 7.45028183e-02f, -9.02110487e-02f, 2.69779384e-01f, -8.70461315e-02f, 2.52464145e-01f, 9.41290706e-02f,
  6.40484393e-02f, 6.17188169e-03f, -7.70927593e-02f, -3.65623236e-02f, 7.36778006e-02f, 3.95178981e-02f, -7.37446174e-02f, -1.06671877e-01f, -1.01304881e-01f, 7.23329233e-03f,
  -1.02078933e-02f, -4.62101288e-02f, 1.04363829e-01f, -8.07582587e-03f, 3.87616903e-02f, 2.58303192e-02f, 6.90008774e-02f, 8.94780681e-02f, -3.49979928e-05f, 2.36389320e-02f,
  -8.36856738e-02f, -4.69985120e-02f, -7.83491805e-02f, 4.66952361e-02f, -1.72887862e-01f, -5.12504503e-02f, -8.95369127e-02f, 6.99934140e-02f, -6.87881857e-02f, -3.88856675e-03f,
  7.09506497e-03f, -1.58464015e-01f, -1.33859232e-01f, 1.28650963e-01f, -3.97353061e-02f, 1.46240681e-01f, -7.41505623e-02f, -2.65987720e-02f, -5.28221987e-02f, -5.56926727e-02f,
  4.90181781e-02f, -6.08736351e-02f, 8.42636302e-02f, -4.91109025e-03f, -1.76076237e-02f, 6.90385252e-02f, 5.10328971e-02f, 5.59508093e-02f, 2.51145102e-02f, 8.60291272e-02f,
  1.08948722e-03f, -6.97413981e-02f, 3.59842516e-02f, -3.87345403e-02f, -6.64339736e-02f, -1.09471425e-01f, -6.12749392e-03f, 1.33609623e-02f, 4.37371545e-02f, -7.72326291e-02f,
  1.01682425e-01f, -2.27227546e-02f, -1.23432837e-02f, 4.23723981e-02f, 7.28454515e-02f, 5.76052144e-02f, -1.10194378e-01f, 6.07178621e-02f, -1.63757414e-01f, -4.27142568e-02f,
  1.24547288e-01f, 7.06938207e-02f, -6.36612475e-02f, 8.77748132e-02f, -1.20952941e-01f, -1.03224507e-02f, -9.55347717e-02f, 2.30645891e-02f, 1.37583837e-02f, 1.93159565e-01f,
  1.87356561e-01f, -2.54508164e-02f, -7.34925941e-02f, 1.50280632e-02f, 2.24700626e-02f, 7.65427500e-02f, -1.09912679e-02f, 6.97989541e-04f, 7.60486769e-03f, 1.99142788e-02f,
  3.42690229e-01f, -7.31408969e-02f, -4.49052751e-02f, 1.19152278e-01f, 3.92590575e-02f, 4.58722711e-02f, 1.25191987e-01f, -1.52940869e-01f, 6.60760626e-02f, -7.24942982e-02f,
  -1.23250987e-02f, 1.97358221e-01f, 2.84095798e-02f, 2.92981300e-03f, 2.89124429e-01f, -1.28383532e-01f, 2.17320286e-02f, 7.92404190e-02f, -1.09536521e-01f, -9.40916501e-03f,
  9.37174782e-02f, 1.89688671e-02f, 7.57909194e-02f, -1.23315923e-01f, 6.31013885e-02f, -3.37332510e-03f, -9.92514845e-03f, 2.80342121e-02f, -4.35113534e-02f, 5.39730862e-03f,
  -3.15486714e-02f, -9.21452641e-02f, -1.17310598e-01f, -8.46185833e-02f, 3.27296220e-02f, -5.32538295e-02f, -5.04543334e-02f, 7.48355761e-02f, 3.02964821e-02f, 2.34063063e-02f,
  1.33066282e-01f, 1.82508249e-02f, -7.67140239e-02f, 9.63857248e-02f, -1.35178957e-02f, -4.93239649e-02f, -2.76662391e-02f, 4.67063673e-02f, -5.20236380e-02f, 8.48743021e-02f,
  -4.68011107e-03f, -3.73543985e-02f, -1.09015843e-02f, -5.46330810e-02f, 6.44718185e-02f, -6.54891133e-02f, -1.02465451e-01f, 5.50642461e-02f, -1.63694676e-02f, -3.30214724e-02f,
  6.23792969e-02f, 3.32301036e-02f, 1.74981318e-02f, -5.46138398e-02f, 3.48866582e-02f, -1.50641471e-01f, 7.74780512e-02f, -4.87509109e-02f, 1.30997254e-02f, 7.23031014e-02f,
  5.81234619e-02f, 5.03453687e-02f, -1.50460303e-02f, 2.62021795e-02f, 1.04885250e-01f, 2.94310991e-02f, 5.00714406e-02f, -3.44216377e-02f, -1.55481268e-02f, 6.82800487e-02f,
  1.39930435e-02f, 3.11692655e-02f, -8.93922076e-02f, 2.47086473e-02f, -3.85710560e-02f, 6.43567592e-02f, -1.06412113e-01f, 4.47481126e-03f, -6.02901466e-02f, 1.09946966e-01f,
  -4.57094423e-02f, -6.51829988e-02f, -2.50190794e-02f, -1.91025622e-02f, -1.35942847e-01f, -1.97954737e-02f, -3.00030261e-02f, -3.64794508e-02f, 1.05233639e-02f, 3.42296250e-02f,
  9.72313136e-02f, 9.22455862e-02f, 1.21962996e-02f, 1.05756223e-01f, 1.18772484e-01f, -1.05282441e-01f, -3.16348225e-02f, 1.02236252e-02f, -2.98243249e-03f, -2.50144452e-02f,
  3.22932610e-03f, 8.11006352e-02f, -5.37673980e-02f, -2.91152578e-02f, -1.12969205e-02f, -7.49106286e-03f, -8.81597307e-03f, -5.79075841e-03f, -7.03728572e-02f, -6.95024058e-02f,
  -1.32457037e-02f, 2.11249694e-01f, 1.21726006e-01f, 1.80910066e-01f, 1.82038322e-01f, -5.29934047e-03f, -4.31869887e-02f, 3.10180783e-01f, 1.71116948e-01f, 2.42377445e-02f,
  -6.91139996e-02f, -7.64460266e-02f, -9.88478288e-02f, -8.17125663e-02f, -2.34796405e-01f, -1.05801992e-01f, -1.66064501e-01f, -1.39828632e-02f, 1.18873194e-02f, 9.62344334e-02f,
  8.73297527e-02f, 6.25089854e-02f, 9.86793265e-02f, 2.19368204e-01f, 2.24782392e-01f, 2.36869618e-01f, -6.55200623e-04f, 3.56457420e-02f, 6.33671805e-02f, -5.76301180e-02f,
  -1.91772863e-01f, -5.01427539e-02f, -2.14266162e-02f, -3.24374549e-02f, -1.04007460e-02f, -9.21245143e-02f, -1.20043522e-02f, 1.66920684e-02f, -5.88313937e-02f, -1.08901568e-01f,
  -7.95767084e-03f, -4.14667055e-02f, 1.90665759e-02f, 4.44836495e-03f, -2.78483387e-02f, -6.13955148e-02f, -1.41180241e-02f, -2.52224319e-02f, -3.23079377e-02f, 1.81658333e-03f,
  4.09654006e-02f, -5.57729369e-03f, -8.61718208e-02f, 8.48118495e-03f, -2.03040950e-02f, -1.85583029e-02f, 2.49082353e-02f, 4.54384014e-02f, 2.47697672e-03f, 2.06574164e-02f,
  1.15071431e-01f, -6.68178052e-02f, -7.58823156e-02f, -8.77755135e-02f, -5.48920557e-02f, -6.13638386e-02f, -1.07085563e-01f, -1.27455786e-01f, -2.56215129e-02f, -7.33456714e-03f,
  1.88159645e-02f, -5.47717065e-02f, 1.48705556e-03f, 7.65524630e-04f, -6.84396699e-02f, 6.04128689e-02f, 5.64124100e-02f, -2.33863592e-02f, 4.56162728e-02f, -1.43469032e-02f,
  -6.96052909e-02f, 1.17124179e-02f, 4.75400463e-02f, -5.11848032e-02f, -1.09390616e-01f, -3.98584604e-02f, 1.72069902e-03f, 2.34309044e-02f, 1.73724130e-01f, -6.25285953e-02f,
  3.30091156e-02f, 1.85486469e-02f, -8.18770155e-02f, -4.28762585e-02f, -7.00829923e-02f, -4.75408100e-02f, -6.73474595e-02f, 8.63318145e-02f, -3.88117023e-02f, 6.83389045e-03f,
  7.56300017e-02f, -1.01379715e-01f, -3.53024714e-02f, -5.40198088e-02f, -2.32115351e-02f, -1.55064883e-03f, -1.45178273e-01f, 1.91354938e-02f, -3.29952054e-02f, 9.26533528e-03f,
  6.06130734e-02f, -4.20238636e-03f, -3.48788500e-02f, 6.72660321e-02f, -1.38529446e-02f, 5.25146117e-03f, 6.84361234e-02f, 1.47190914e-01f, -8.73467550e-02f, -2.68225484e-02f,
  2.11615160e-01f, -4.47415113e-01f, -8.17440227e-02f, -1.17953643e-01f, 9.51447934e-02f, 1.25986040e-02f, 9.52118412e-02f, -1.04995035e-01f, -2.56727278e-01f, -1.87267452e-01f,
  7.15877488e-02f, -1.01222880e-01f, -6.69625625e-02f, -9.34750959e-02f, 2.04093337e-01f, -1.96961030e-01f, -3.45198736e-02f, -9.73760560e-02f, -6.96898773e-02f, -2.03691609e-02f,
  -5.38571775e-02f, 5.11368252e-02f, -1.70090254e-02f, -2.48947064e-03f, 7.01606944e-02f, -7.41545530e-03f, 9.05418098e-02f, 2.94300243e-02f, 6.57590628e-02f, -4.82506119e-02f,
  2.18850583e-01f, 1.23998635e-02f, 9.91119817e-02f, 2.76041310e-02f, 1.47892743e-01f, 2.13981345e-01f, 1.51736826e-01f, 1.12150632e-01f, 1.27824366e-01f, 5.92329651e-02f,
  1.14168301e-01f, 6.82852939e-02f, -4.43231352e-02f, -7.67316967e-02f, -8.30007866e-02f, 3.70405465e-02f, 1.29519790e-01f, 5.41395582e-02f, -2.88523491e-02f, -9.36843082e-02f,
  -9.56258923e-03f, -4.23962139e-02f, -1.09581448e-01f, -1.23640433e-01f, 4.42885095e-03f, -5.58295846e-02f, -1.78555682e-01f, -3.11388299e-02f, -8.20125490e-02f, -4.27223966e-02f,
  -6.00259900e-02f, 7.35535659e-03f, 5.95686063e-02f, 5.31747416e-02f, 6.04077838e-02f, 1.39227360e-01f, 8.94572958e-02f, 1.00346707e-01f, 8.04884136e-02f, 4.57421094e-02f,
  7.00497255e-02f, 2.91619487e-02f, 1.60833616e-02f, 5.75532727e-02f, 4.92735729e-02f, -4.75462489e-02f, 9.34417301e-04f, 3.24074365e-02f, 2.58343667e-02f, -4.55594920e-02f,
  4.80190590e-02f, 7.01299235e-02f, 7.99737200e-02f, 3.40720564e-02f, 8.58609676e-02f, 4.33645621e-02f, -8.19920450e-02f, 8.16938374e-03f, 4.71433625e-02f, 7.69533962e-02f,
  2.20689029e-02f, -1.08909324e-01f, 4.32604440e-02f, 5.16058095e-02f, -6.86324609e-04f, 1.20037697e-01f, 2.99748741e-02f, 2.47476529e-02f, -1.03120161e-02f, 7.37308860e-02f,
  8.39229152e-02f, 4.38289046e-02f, -7.42895603e-02f, 7.10204765e-02f, -3.98946665e-02f, -3.26749012e-02f, 1.04036354e-01f, -4.63707112e-02f, 9.98986363e-02f, 9.04158782e-03f,
  -4.25971206e-03f, -3.81198861e-02f, -9.54077318e-02f, -7.77438134e-02f, 4.40098532e-02f, -4.84382249e-02f, -9.87395085e-03f, -4.22488153e-02f, 4.81272824e-02f, -7.16500655e-02f,
  -5.22592105e-02f, -6.00899868e-02f, 2.18451619e-01f, 4.10275646e-02f, -4.80487347e-02f, 5.44668660e-02f, 9.38147008e-02f, -1.25896782e-01f, 5.30840605e-02f, -1.83385774e-01f,
  -3.44936401e-02f, 1.59503836e-02f, -2.57022330e-03f, -2.59055011e-03f, -1.33155361e-01f, 2.83656210e-01f, -7.74130225e-02f, 1.22749485e-01f, 2.37626716e-01f, -1.40222996e-01f,
  -7.97663555e-02f, -2.14235142e-01f, -2.07004510e-02f, -1.29013285e-01f, -4.59274352e-02f, 6.61123693e-02f, -3.20303887e-01f, 4.67337482e-02f, -1.56602547e-01f, 2.58785486e-02f,
  -2.79493444e-02f, 4.54378361e-03f, 2.52445601e-02f, -5.24445623e-03f, -3.65999900e-02f, 3.22639085e-02f, -5.06524555e-02f, 1.45238414e-01f, 5.82291447e-02f, 5.56859300e-02f,
  7.37974122e-02f, -2.39349883e-02f, 7.10860565e-02f, 4.87972610e-02f, -4.89768460e-02f, 8.85464922e-02f, 1.23321727e-01f, 5.61124198e-02f, -3.44514586e-02f, 9.34252515e-02f,
  4.85590957e-02f, 2.39232332e-02f, 2.86483690e-02f, 1.62411649e-02f, 1.00925155e-01f, 1.40645519e-01f, 4.73067760e-02f, 7.02587655e-03f, 1.87302437e-02f, 1.60567425e-02f,
  6.43611923e-02f, -3.73419523e-02f, 6.87683597e-02f, 4.84919511e-02f, -2.28639822e-02f, 3.95853408e-02f, 2.42336560e-02f, -1.81300193e-02f, 3.51519324e-02f, -8.48937854e-02f,
  -6.73213229e-02f, -3.60181183e-02f, 6.79851249e-02f, 2.06826814e-02f, 4.99989046e-03f, -3.80130187e-02f, -1.08438972e-02f, 6.53094500e-02f, -2.32508779e-02f, 6.32481836e-03f,
  -4.97630686e-02f, -5.96067756e-02f, -3.73048000e-02f, -2.18524225e-02f, 2.38055009e-02f, -2.62935571e-02f, 1.26845362e-02f, 4.81651276e-02f, 6.05013408e-02f, -1.51381046e-02f,
  -2.35246673e-01f, -3.95536691e-01f, 5.50401723e-03f, 3.72349657e-02f, 1.11215517e-01f, 1.27889495e-02f, 9.75581035e-02f, 1.01907022e-01f, -4.73960713e-02f, -6.83032500e-04f,
  2.49457806e-02f, -7.08841309e-02f, -9.62965563e-02f, -2.28482615e-02f, 1.81599800e-02f, -8.32234975e-04f, -6.62755817e-02f, 6.33736886e-03f, -9.74667445e-02f, -1.72339771e-02f,
  -8.31318498e-02f, -2.66613933e-04f, 1.28000202e-02f, -5.52558564e-02f, -1.04005588e-02f, -7.32126692e-03f, -1.29029781e-01f, 4.65028919e-02f, -5.65814879e-03f, 1.43942470e-02f,
  -5.66765666e-01f, -2.20825270e-01f, -1.41169116e-01f, -2.01259777e-01f, 2.27532275e-02f, -1.27112955e-01f, -1.66485503e-01f, -1.09559536e-01f, -2.76854128e-01f, -2.53697857e-02f,
  3.75531092e-02f, -2.84839988e-01f, 4.70475107e-02f, -6.70418218e-02f, -1.73483133e-01f, 3.00736576e-02f, -1.23936363e-01f, 1.73357024e-03f, 6.87917247e-02f, -1.55627698e-01f,
  -2.38368083e-02f, 1.37365147e-01f, -2.25715786e-02f, 7.46619105e-02f, -6.09685779e-02f, -8.71849731e-02f, 8.53874460e-02f, 8.47651139e-02f, 5.67226410e-02f, 2.51267403e-02f,
  -1.18818201e-01f, -7.76028484e-02f, -4.74112071e-02f, -1.74054373e-02f, -4.82776295e-03f, 6.21190928e-02f, -4.66185100e-02f, 7.28818402e-02f, -2.66610291e-02f, -6.69220753e-04f,
  -8.68978202e-02f, -1.20387793e-01f, 1.92933585e-02f, 6.04662783e-02f, 2.61844154e-02f, 4.59186472e-02f, 1.51552320e-01f, 3.36897746e-02f, -2.08603293e-02f, 4.72862870e-02f,
  3.94385755e-02f, -1.19749075e-02f, 1.33809552e-01f, 7.57148117e-03f, 2.33803354e-02f, -7.77150388e-04f, 4.14981246e-02f, 4.38418984e-02f, -3.02151833e-02f, -1.57416519e-02f,
  -6.48735324e-04f, -6.37091994e-02f, 8.05781707e-02f, 1.73208192e-02f, 5.34236319e-02f, 2.84106247e-02f, 1.01164222e-01f, 7.93942437e-02f, 6.64526671e-02f, -5.31377234e-02f,
  -2.93589160e-02f, -2.94477548e-02f, 6.48472235e-02f, -1.63571145e-02f, -2.97700837e-02f, -8.32072422e-02f, 5.81622981e-02f, -2.15259083e-02f, -6.23426512e-02f, -1.15675656e-02f,
  -3.19871046e-02f, -6.30004853e-02f, 4.84706014e-02f, 8.82830843e-03f, -6.95703970e-03f, -4.94599110e-03f, -4.85652052e-02f, -5.60147874e-02f, -6.05830550e-02f, 4.28286754e-02f,
  -1.07221484e-01f, -1.41784221e-01f, -5.87643497e-02f, -3.04925367e-02f, 9.30463895e-02f, 9.69192758e-02f, 1.34203285e-02f, 3.01823746e-02f, -1.90329440e-02f, -8.57171416e-02f,
  -2.15927102e-02f, -7.92067684e-03f, -2.92850602e-02f, 5.07121161e-02f, -6.25413954e-02f, -2.06004865e-02f, -4.30760570e-02f, -6.30606264e-02f, 3.60392891e-02f, -7.46406540e-02f,
  5.07154614e-02f, 5.87237962e-02f, 7.86716193e-02f, 1.53550683e-02f, 1.40309762e-02f, 3.76991630e-02f, -6.51809201e-02f, 1.64545923e-02f, 1.16138205e-01f, -1.29727684e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.94758520e-01f, -6.62178695e-01f, 2.27597691e-02f, 2.18488038e-01f, 3.62266660e-01f, -1.77359134e-02f, 2.48813599e-01f, -9.30836350e-02f, -1.32916868e-01f, -4.34445441e-01f,
  4.23191264e-02f, 1.70347646e-01f, -2.89051738e-02f, -1.12535276e-01f, 3.98101211e-01f, -4.59381342e-02f, 7.98925906e-02f, 4.80193645e-02f, 4.08210568e-02f, -1.40114725e-01f,
  1.46601573e-01f, 1.42441452e-01f, 2.90732622e-01f, -3.94609496e-02f, 1.27053529e-01f, -4.21359800e-02f, 3.38254613e-03f, 1.47703201e-01f, 5.83234727e-02f, 2.52740026e-01f,
  -2.12522760e-01f, -1.67629376e-01f, 3.30615416e-02f, -1.36201605e-02f, -7.45536163e-02f, -5.25716878e-02f, 7.43500963e-02f, 1.21173635e-01f, 2.24630460e-02f, -1.45046301e-02f,
  1.73082277e-02f, 6.17694966e-02f, 4.18937691e-02f, -3.00617306e-03f, -2.31063962e-02f, -7.69109502e-02f, 3.87820937e-02f, -1.08858142e-02f, 9.46589410e-02f, 6.25931025e-02f,
  1.49111254e-02f, -5.85228615e-02f, -3.66424695e-02f, 1.14345402e-02f, -1.44554907e-02f, 4.72436026e-02f, 1.15731560e-01f, 1.11926489e-01f, -3.10491882e-02f, 1.12061873e-01f,
  1.09768413e-01f, 1.07983105e-01f, -5.37082925e-02f, -1.09817423e-01f, -1.02632605e-01f, -7.59001747e-02f, -9.95316729e-02f, 3.11451089e-02f, -3.71987261e-02f, -6.99655041e-02f,
  1.12630948e-02f, -6.91557899e-02f, 8.88436362e-02f, -7.73008689e-02f, 1.68852463e-01f, -4.75349240e-02f, 1.15481041e-01f, -7.68763274e-02f, -7.92599693e-02f, 5.90209179e-02f,
  -5.39535284e-03f, -3.63758206e-02f, -9.27413721e-03f, -7.34591251e-03f, -7.90720284e-02f, 1.46983620e-02f, -4.00775485e-02f, -4.75115590e-02f, 1.48290843e-02f, 1.10526390e-01f,
  -6.60904050e-01f, -5.71179569e-01f, -2.29804739e-02f, -4.02859133e-03f, -7.51259252e-02f, -2.07724869e-02f, 5.63796982e-03f, 1.89464856e-02f, -1.56712234e-01f, 2.94899363e-02f,
  2.59742048e-02f, 1.09342232e-01f, -8.24060813e-02f, 1.66381542e-02f, 1.13783471e-01f, -6.06346354e-02f, 3.99777405e-02f, -1.10569507e-01f, 2.35711094e-02f, -9.94815379e-02f,
  -5.77139743e-02f, -1.07022032e-01f, 9.44250301e-02f, 5.31370081e-02f, 7.93985873e-02f, -5.55184521e-02f, -8.56684521e-02f, 1.07063539e-01f, -1.35827856e-02f, 1.00684622e-02f,
  2.53404140e-01f, -7.05859438e-02f, -2.73180425e-01f, 6.10740520e-02f, 1.81243360e-01f, 1.46346629e-01f, -9.76335257e-02f, 3.06216870e-02f, -1.76941320e-01f, 1.07793279e-01f,
  2.33582333e-01f, -1.25154043e-02f, -1.26166418e-01f, 2.99250513e-01f, 2.51379579e-01f, -1.37256160e-01f, 3.02231312e-01f, 1.24421984e-01f, -1.41074777e-01f, 2.10600719e-01f,
  1.26650468e-01f, 3.57804298e-01f, 6.53864304e-03f, 1.56338513e-01f, 1.49400517e-01f, -1.25710383e-01f, 2.33775780e-01f, -1.99719056e-01f, 2.52162635e-01f, 1.37201443e-01f,
  2.99760010e-02f, 4.97718900e-02f, -8.12683254e-02f, -5.69825321e-02f, 1.50860175e-02f, -4.45163287e-02f, -7.34941363e-02f, 6.96339235e-02f, -7.60810822e-02f, 7.83768520e-02f,
  3.82845141e-02f, -7.29234964e-02f, 2.50233039e-02f, 6.37757778e-02f, -3.49743590e-02f, 1.07106216e-01f, -7.94432089e-02f, -1.64663136e-01f, -8.49877447e-02f, 1.54350847e-01f,
  -1.29179014e-02f, -1.65615510e-02f, -2.14564335e-02f, -9.19446629e-03f, 7.27564096e-02f, 6.82690740e-02f, -2.56873257e-02f, -6.58308640e-02f, -5.57414182e-02f, 9.90013182e-02f,
  1.53447419e-01f, 4.79497574e-02f, 1.15646705e-01f, 3.34449336e-02f, 3.73323006e-03f, -1.18405044e-01f, 5.20308577e-02f, -6.83707371e-02f, -6.46281540e-02f, 7.95010850e-02f,
  -5.71888201e-02f, 1.53480232e-01f, -3.83533128e-02f, 7.46663436e-02f, 1.83098182e-01f, -4.06947657e-02f, -8.86553228e-02f, 7.97074810e-02f, 5.71756624e-02f, 3.97002138e-03f,
  -1.07746154e-01f, 6.45087138e-02f, 1.29239336e-02f, -1.78840999e-02f, 1.44527080e-02f, 1.75840855e-01f, 2.00949550e-01f, 8.44614580e-02f, -8.58003944e-02f, -4.90637757e-02f,
  9.57116559e-02f, 1.96339220e-01f, -8.08431953e-02f, 5.12744747e-02f, -1.38920128e-01f, -2.96791848e-02f, -1.54662291e-02f, 4.24254388e-02f, 5.82684539e-02f, 7.94019774e-02f,
  9.20736119e-02f, -5.82021065e-02f, -3.75631079e-02f, 1.75486226e-03f, -4.06146571e-02f, 2.00570151e-01f, 1.41980154e-02f, -1.44196749e-01f, -6.26643822e-02f, 7.97193646e-02f,
  1.30273044e-01f, -4.15100008e-02f, -1.05319254e-01f, -1.32505804e-01f, 1.10863056e-02f, -1.27606792e-02f, -5.60856126e-02f, -1.77306533e-02f, 6.91547766e-02f, 3.70854847e-02f,
  1.46115050e-01f, 2.05408446e-02f, -3.17625910e-01f, 3.27856950e-02f, -4.01769459e-01f, -2.56137222e-01f, -1.49038404e-01f, -1.58484653e-01f, -6.53748587e-02f, 3.20143461e-01f,
  -1.50421798e-01f, 3.64780240e-02f, 2.81707525e-01f, 9.04580951e-02f, -1.28744272e-04f, 4.17770863e-01f, 3.92725356e-02f, 6.35259449e-02f, 9.30095986e-02f, 1.32611608e-02f,
  8.30429569e-02f, 1.72838256e-01f, 1.80833600e-02f, -4.05984148e-02f, -1.93753600e-01f, 7.58801475e-02f, 1.60053685e-01f, -2.64844745e-01f, -7.38588274e-02f, -2.18488306e-01f,
  -9.69941244e-02f, 7.42663965e-02f, -3.70407663e-02f, -2.10522190e-02f, 7.19365999e-02f, -3.35100740e-02f, 2.04257481e-02f, -4.66382429e-02f, -7.36099631e-02f, 5.55759892e-02f,
  1.34087671e-02f, 1.14700072e-01f, -3.63457687e-02f, -5.42876427e-04f, -8.53844881e-02f, -1.04489163e-01f, -1.52400043e-03f, -2.22185031e-01f, 3.62651236e-02f, 4.74053388e-03f,
  -1.31907523e-01f, -2.04245858e-02f, 4.77380827e-02f, 6.94021136e-02f, -3.33287157e-02f, -7.98377991e-02f, 3.95638123e-02f, -3.64110023e-02f, -7.50924796e-02f, 8.41352418e-02f,
  -1.52649339e-02f, 8.09324905e-02f, 6.71285614e-02f, -7.48946220e-02f, 4.07101475e-02f, 1.56972501e-02f, 9.70151182e-03f, 5.72820678e-02f, 2.59716641e-02f, 8.63450915e-02f,
  -1.53812142e-02f, -7.23978952e-02f, -1.18412497e-02f, 9.95367169e-02f, 1.46817103e-01f, -3.55054736e-02f, -1.53493166e-01f, -6.20471872e-03f, -1.86119840e-01f, -1.30457550e-01f,
  8.48117918e-02f, 5.56881204e-02f, -1.09674549e-02f, 1.74044389e-02f, -1.08077861e-01f, 4.91409898e-02f, 1.12052076e-01f, 5.21353893e-02f, -8.06125551e-02f, -4.28406149e-03f,
  1.95623860e-02f, 2.11816400e-01f, 2.59687416e-02f, -7.93448389e-02f, -3.26940082e-02f, 3.67483012e-02f, 6.61588013e-02f, 6.67614713e-02f, 2.46529914e-02f, 1.21474870e-01f,
  4.96911630e-02f, 2.49666944e-02f, 4.46398258e-02f, -1.01039775e-01f, -1.30071655e-01f, 5.52921779e-02f, 1.53464824e-01f, -1.99165512e-02f, -8.98842141e-03f, 7.91050680e-03f,
  -5.34681370e-03f, 6.55316189e-02f, 1.74002677e-01f, 7.02057825e-03f, 1.65284917e-01f, -2.40284447e-02f, -4.90378700e-02f, -5.59624434e-02f, -3.95473503e-02f, 8.99760649e-02f,
  5.59460223e-01f, 1.78137228e-01f, 1.36454850e-01f, 4.13004339e-01f, 1.63814664e-01f, 1.66001424e-01f, 1.95689797e-01f, 2.13078156e-01f, 7.17951894e-01f, -7.15766996e-02f,
  -7.44547695e-02f, 1.31947666e-01f, -2.62615860e-01f, 1.94130495e-01f, -2.05891550e-01f, 2.33873799e-02f, 2.04646721e-01f, 1.35411516e-01f, 2.67071187e-01f, 1.31600425e-02f,
  1.11864768e-01f, -1.60264298e-01f, -3.62369776e-01f, -3.19495440e-01f, -2.30062865e-02f, 5.16241603e-03f, -5.37252784e-01f, -1.53949380e-01f, -1.75322384e-01f, -8.86049420e-02f,
  7.84393176e-02f, 1.34126469e-01f, -3.89599614e-02f, 8.53324383e-02f, 2.39712838e-02f, -5.41589074e-02f, -1.21337041e-01f, -7.87221566e-02f, 7.18848556e-02f, 6.96954727e-02f,
  2.02404875e-02f, -2.06686128e-02f, 1.01716585e-01f, -7.08600357e-02f, 1.66244909e-01f, 3.88722531e-02f, 8.77037644e-02f, 6.65577725e-02f, -5.84295811e-03f, 5.19099459e-02f,
  1.97044704e-02f, 5.35427630e-02f, 1.63600996e-01f, 2.70281639e-02f, 1.12236626e-01f, 7.32985586e-02f, 6.57056794e-02f, -3.89245674e-02f, -1.26588400e-02f, 1.43910199e-01f,
  1.72986705e-02f, 7.26020187e-02f, -1.20093599e-01f, -1.36613160e-01f, -6.52310997e-02f, -4.28790301e-02f, -1.45980306e-02f, 3.98895098e-03f, 7.46703893e-02f, -1.54511770e-03f,
  -2.82421671e-02f, 8.70764256e-02f, 1.32096142e-01f, 3.72421518e-02f, 8.48155171e-02f, -5.20404205e-02f, -3.49437110e-02f, 1.47548672e-02f, 1.31823689e-01f, 3.33532989e-02f,
  5.63919591e-03f, 3.48056331e-02f, -1.40254706e-01f, 2.38952157e-03f, 3.87174916e-03f, -5.52673377e-02f, -1.07291918e-02f, 6.80918619e-02f, -3.66354398e-02f, 1.56493008e-03f,
  6.03694879e-02f, 1.25954345e-01f, -9.08254273e-03f, -1.65105779e-02f, -2.39824168e-02f, 8.09484813e-03f, 8.39056149e-02f, 9.79341492e-02f, 1.06814839e-01f, -6.48861332e-03f,
  -4.27142833e-04f, 9.79228988e-02f, 1.26955174e-02f, -3.13236304e-02f, 3.86690274e-02f, -5.90900006e-03f, -4.50167060e-02f, -2.77722217e-02f, -1.50498087e-02f, -7.87286609e-02f,
  -1.17412366e-01f, 6.40272796e-02f, 5.47755249e-02f, 3.61791961e-02f, 1.17234729e-01f, -9.57406089e-02f, 3.30899172e-02f, 1.97072886e-02f, -7.03202486e-02f, 2.61002164e-02f,
  -3.54437865e-02f, 8.20615217e-02f, -3.05125028e-01f, -1.11429937e-01f, -1.60793200e-01f, -4.11457002e-01f, -3.34194809e-01f, -5.78968413e-02f, 1.85760558e-01f, 1.79571256e-01f,
  -1.01752341e-01f, 2.02015132e-01f, -1.10092694e-02f, -1.91645265e-01f, -1.43962473e-01f, 1.88907869e-02f, -2.98931062e-01f, -1.76735055e-02f, 7.31469039e-03f, -1.58967897e-01f,
  -1.36165529e-01f, -1.71041995e-01f, -2.64969528e-01f, -7.94950426e-02f, -1.94754779e-01f, 1.63538270e-02f, 6.67718351e-02f, -1.11382686e-01f, -2.05457315e-01f, 3.30843441e-02f,
  -3.12227290e-02f, 4.77185510e-02f, -7.04305321e-02f, -3.78536731e-02f, -1.73325062e-01f, 8.31408717e-04f, -8.99833590e-02f, -6.26959875e-02f, -3.86387436e-03f, -1.06789861e-02f,
  -3.79826464e-02f, 3.35792676e-02f, 3.75880711e-02f, 2.11238749e-02f, 1.28989145e-02f, 9.83846486e-02f, -1.24492623e-01f, -9.69226435e-02f, -2.70450525e-02f, 4.14748378e-02f,
  -1.12951607e-01f, -5.71903437e-02f, -7.95924142e-02f, -2.07538661e-02f, -9.52825416e-03f, -3.56813185e-02f, 3.28590199e-02f, 3.33727859e-02f, -5.66600189e-02f, 2.73000896e-02f,
  -3.85471694e-02f, -6.64967149e-02f, 8.30024555e-02f, -1.34913391e-02f, 1.13032445e-01f, -2.52134986e-02f, 1.09570563e-01f, 3.63163603e-03f, 1.40446369e-02f, 2.83284318e-02f,
  5.76718785e-02f, 7.37098455e-02f, -2.26019621e-02f, -9.60081741e-02f, -5.57485111e-02f, 1.20017283e-01f, 8.05625245e-02f, 2.30624098e-02f, 5.43247163e-02f, -3.88650084e-03f,
  3.42360772e-02f, -3.53665873e-02f, 1.31078288e-01f, -8.40609372e-02f, 1.68479327e-02f, -2.73923837e-02f, 1.88017469e-02f, 7.70273134e-02f, -2.94922590e-02f, -6.96383789e-02f,
  -2.29589641e-01f, -5.53443506e-02f, 1.79305319e-02f, 7.61420578e-02f, 4.19892929e-02f, -6.24390803e-02f, -8.47099423e-02f, -2.61327755e-02f, -6.61255419e-02f, -1.83095828e-01f,
  -3.18793766e-02f, 1.04809627e-01f, -9.74024385e-02f, 3.44709381e-02f, 5.31804487e-02f, -8.43875259e-02f, -1.07793160e-01f, -4.29028571e-02f, -6.01326376e-02f, 1.40343562e-01f,
  1.43069271e-02f, 1.10016242e-01f, 6.45485967e-02f, 2.25530732e-02f, -9.79295373e-02f, 4.42130677e-03f, 4.79056835e-02f, 5.19701019e-02f, -1.77119270e-01f, -8.64552334e-02f,
  -3.47791731e-01f, 2.87148744e-01f, 2.86485374e-01f, -2.02174321e-01f, 5.04209585e-02f, -6.24873079e-02f, -2.58417040e-01f, 4.45551097e-01f, 1.99600741e-01f, 1.33841351e-01f,
  1.03201538e-01f, -6.74660578e-02f, 2.46883959e-01f, -3.91588323e-02f, -1.27870634e-01f, -3.29239741e-02f, -2.97105372e-01f, -2.25272968e-01f, 8.42664465e-02f, 8.58797133e-02f,
  -1.35035394e-02f, 1.19311988e-01f, 7.70900622e-02f, 3.14794272e-01f, 2.37515092e-01f, 1.23125531e-01f, -1.71444550e-01f, 1.32186562e-01f, -9.03612226e-02f, 2.68483274e-02f,
  -1.74064949e-01f, 2.35062674e-01f, 1.32302210e-01f, 6.53269589e-02f, 5.84886074e-02f, -1.07632793e-01f, 7.64921382e-02f, -2.33857408e-02f, 1.44304885e-02f, -3.77430432e-02f,
  4.24805796e-03f, 1.47340581e-01f, 4.64711664e-03f, 1.58407211e-01f, -3.62394191e-02f, 2.00920720e-02f, 1.52144790e-01f, -5.33211455e-02f, 8.59890133e-02f, 1.08876169e-01f,
  1.19381845e-01f, 6.84143081e-02f, -3.26912925e-02f, -2.04223424e-01f, -4.62764315e-02f, -5.84300980e-02f, -7.18344450e-02f, -1.25726834e-01f, 1.79012343e-02f, -6.34729713e-02f,
  6.88956082e-02f, 1.53203517e-01f, -3.37955058e-02f, 1.41820386e-01f, -6.12137355e-02f, -7.62966126e-02f, 6.52342662e-02f, -8.81437734e-02f, -6.08833283e-02f, 2.54620258e-02f,
  -1.69483379e-01f, 1.46037247e-02f, -6.87658712e-02f, -1.61326211e-02f, 1.61915610e-03f, 6.38674796e-02f, -1.40254408e-01f, 8.93519167e-03f, -4.78612594e-02f, -2.88748536e-02f,
  1.07093960e-01f, -1.27090886e-01f, -3.16526555e-02f, -9.46826264e-02f, -8.16670135e-02f, 9.19636711e-02f, 2.17936456e-01f, -1.16778277e-01f, 7.75804743e-02f, -2.76430659e-02f,
  -3.01903188e-01f, 1.59639731e-01f, -3.24912779e-02f, 4.23381664e-02f, -8.74104444e-03f, -3.80238332e-02f, 6.28070086e-02f, -8.98399428e-02f, 1.63036818e-03f, 3.92509401e-02f,
  3.13371932e-03f, -8.53447542e-02f, -2.01953933e-01f, -1.24760091e-01f, -5.26837595e-02f, -1.14927053e-01f, -7.08149970e-02f, -9.30314437e-02f, -2.28569508e-02f, 3.55677903e-02f,
  5.48291579e-02f, 3.95517163e-02f, -4.11661863e-02f, -4.92706150e-02f, -8.87316167e-02f, -1.58276558e-01f, -3.45055088e-02f, -1.33127552e-02f, -5.18274419e-02f, -4.16890904e-02f,
  -7.37352371e-02f, 4.66866344e-01f, -8.56576934e-02f, -5.95564805e-02f, 1.32921308e-01f, -2.68532544e-01f, -7.14417025e-02f, 2.51861922e-02f, -1.11825846e-01f, 1.80928782e-01f,
  -9.71185341e-02f, 2.98240840e-01f, -1.56854957e-01f, -2.14038998e-01f, -5.91840804e-01f, -4.07963336e-01f, -3.37384105e-01f, -1.14178419e-01f, 6.22125678e-02f, 9.21413898e-02f,
  -1.55494496e-01f, -1.64434850e-01f, -1.51261479e-01f, 2.49986261e-01f, 2.95866430e-01f, 2.39558905e-01f, 2.49323286e-02f, 2.14709148e-01f, 2.34193459e-01f, 4.80052456e-02f,
  -1.62362099e-01f, -9.66456681e-02f, 1.97945237e-01f, -1.18754685e-01f, -1.25705302e-01f, 1.42289355e-01f, -1.49643058e-02f, -4.33734134e-02f, 2.82318648e-02f, 6.44919351e-02f,
  5.17994575e-02f, 3.00893188e-02f, -4.80123907e-02f, -5.35510713e-03f, 4.42595687e-03f, 8.02750736e-02f, -5.79460002e-02f, 2.27024890e-02f, 6.82653114e-02f, 1.54281808e-02f,
  -1.53803945e-01f, 6.83855116e-02f, 8.78821611e-02f, -3.74732129e-02f, -1.31141305e-01f, 1.95016470e-02f, 8.76103714e-03f, 4.60858047e-02f, 4.61082086e-02f, 8.86448175e-02f,
  -6.49303347e-02f, -1.68141425e-02f, 1.50279719e-02f, -3.03731263e-02f, -4.18333523e-02f, 4.39728871e-02f, -1.88844372e-02f, -3.18829305e-02f, 4.39424254e-02f, -6.24826690e-03f,
  7.81956762e-02f, 1.33426338e-01f, -3.63666825e-02f, 1.09000161e-01f, 7.17517803e-04f, 6.18542023e-02f, -5.65700568e-02f, -8.28137249e-02f, -1.11359864e-01f, 5.32813929e-02f,
  -8.50475878e-02f, -1.03129894e-01f, 1.62117019e-01f, 7.12345690e-02f, 3.28898989e-02f, -1.19743580e-02f, 8.80916566e-02f, 1.00860886e-01f, -2.36946251e-03f, -1.00275874e-01f,
  -1.34488285e-01f, -1.00000642e-01f, 1.23828836e-01f, 1.68368742e-01f, -4.60526198e-02f, 3.67020816e-02f, -1.58779308e-01f, -3.81364636e-02f, -4.62385528e-02f, 5.05023748e-02f,
  6.10194542e-02f, 8.27194676e-02f, 6.60643429e-02f, -1.02006689e-01f, -4.62723263e-02f, -6.73407838e-02f, -9.56700817e-02f, -3.06746531e-02f, 3.05486582e-02f, 4.20605801e-02f,
  3.09740063e-02f, -1.02523886e-01f, -9.40965302e-03f, 5.42225391e-02f, -3.12041957e-04f, 1.62952598e-02f, 5.71135581e-02f, -5.99122494e-02f, 4.27712919e-03f, -3.85201871e-02f,
  -9.65593085e-02f, -9.07741040e-02f, -3.07938010e-01f, -2.16828093e-01f, 1.18592493e-01f, -5.49929500e-01f, -4.11504984e-01f, -1.31421208e-01f, 1.13136498e-02f, 1.64114401e-01f,
  -4.52361628e-02f, -1.26160206e-02f, -6.40461892e-02f, -4.48424041e-01f, -4.58643347e-01f, -1.98256046e-01f, -3.85210603e-01f, -1.99199811e-01f, -8.97973403e-02f, -1.55276418e-01f,
  -1.49560317e-01f, -1.15404159e-01f, -3.98074210e-01f, -6.34219199e-02f, -2.12210611e-01f, 1.32477611e-01f, 1.29559040e-01f, 3.87553759e-02f, -1.34113044e-01f, -7.63618350e-02f,
  -1.02932684e-01f, 1.72169045e-01f, 8.23833570e-02f, -4.69461530e-02f, -5.72394952e-02f, 6.54624179e-02f, -5.79528026e-02f, -3.89780663e-02f, 9.85651091e-02f, -1.33483797e-01f,
  9.09368787e-03f, -2.53926329e-02f, -6.16757236e-02f, 4.16823626e-02f, 1.48135975e-01f, 9.07205492e-02f, 4.10260558e-02f, 3.75207886e-02f, 9.31290560e-04f, -1.52807921e-01f,
  -2.12821528e-01f, 3.39888223e-02f, 3.54016237e-02f, 3.59421559e-02f, -1.11339219e-01f, -4.01436053e-02f, -8.52119774e-02f, -1.65533032e-02f, -8.60825647e-03f, -1.78053323e-02f,
  3.22843939e-02f, -3.22103389e-02f, -1.09372191e-01f, -4.77216132e-02f, -1.10823743e-01f, -8.74180696e-04f, -2.17889473e-02f, 5.08495085e-02f, 1.46197090e-02f, 7.43476525e-02f,
  -6.20399192e-02f, -2.58744098e-02f, 1.25361905e-02f, -1.40421586e-02f, -1.16348095e-01f, 4.89451103e-02f, -8.25441778e-02f, -3.24689550e-03f, -1.00909986e-01f, -1.57928348e-01f,
  5.78978062e-02f, -8.60150382e-02f, -7.26411641e-02f, 7.47752264e-02f, -3.06179877e-02f, 2.67593167e-03f, 1.42446905e-01f, 6.69372901e-02f, -2.60993149e-02f, -1.21506043e-01f,
  -2.13206559e-02f, 8.41840636e-03f, -7.21840262e-02f, 8.89021233e-02f, 3.75697133e-03f, -2.96343584e-02f, -7.66984597e-02f, -3.66173536e-02f, 1.35089874e-01f, -6.41106367e-02f,
  6.30811031e-04f, 9.69874673e-03f, -3.49497460e-02f, 3.84700298e-02f, 6.38797805e-02f, 1.24153169e-02f, 7.81677198e-03f, 9.94333103e-02f, -2.22611539e-02f, 1.96192153e-02f,
  1.50900573e-01f, 6.53298274e-02f, 9.11050104e-03f, 4.62563671e-02f, -7.25563541e-02f, 1.20373987e-01f, -2.45641507e-02f, -1.18816299e-02f, 3.60027812e-02f, 8.41970816e-02f,
  -7.81731069e-01f, 4.82108563e-01f, -1.46121949e-01f, -2.75088370e-01f, -2.84314770e-02f, -4.72623156e-03f, 4.40101065e-02f, 2.06643060e-01f, -1.61055416e-01f, 1.02996565e-01f,
  6.48735762e-02f, -2.33832076e-01f, 2.31540933e-01f, 1.00419205e-02f, -1.99538827e-01f, 8.38433430e-02f, -1.39680877e-01f, -1.45232558e-01f, -3.36165316e-02f, -3.91775593e-02f,
  -6.77464604e-02f, -8.97985175e-02f, -4.57616635e-02f, 2.74836451e-01f, -4.99393791e-02f, -5.52140214e-02f, -1.00171030e-01f, 1.02950051e-01f, -1.63194269e-01f, 9.95505154e-02f,
  -2.17388108e-01f, -4.45708483e-01f, -1.05559669e-01f, -2.46391252e-01f, -1.79336920e-01f, 9.11180377e-02f, -7.81915188e-02f, -5.35803661e-02f, -8.38941485e-02f, -1.91311426e-02f,
  -7.73532465e-02f, 2.87917294e-02f, -1.01434320e-01f, 6.25508875e-02f, 3.93462144e-02f, -1.83123071e-02f, 9.90783423e-02f, -4.06830274e-02f, 2.72822510e-02f, 8.77908766e-02f,
  5.63387014e-02f, 5.67617407e-03f, -2.25176830e-02f, -5.01258262e-02f, 9.12730992e-02f, 6.76383823e-02f, -1.50538320e-02f, 1.30738867e-02f, -1.11812361e-01f, -8.22330490e-02f,
  7.78548867e-02f, -6.74577057e-02f, 4.72637191e-02f, -6.56423569e-02f, 5.32181710e-02f, -1.40866376e-02f, -5.84475249e-02f, -5.20137930e-03f, -4.08345610e-02f, 8.72998834e-02f,
  2.07706122e-03f, -1.23327142e-02f, -9.56045389e-02f, -3.20531242e-03f, 4.51672357e-03f, -1.53244631e-02f, -2.37573031e-02f, 3.38178617e-03f, 9.23704356e-02f, 2.45779585e-02f,
  -1.81075428e-02f, 1.92650408e-02f, 5.78260496e-02f, -4.27967384e-02f, 3.73334140e-02f, 8.28199089e-03f, 2.54957378e-02f, 9.14863218e-03f, -8.83498192e-02f, 8.60160962e-03f,
  -6.50334179e-01f, -5.66841543e-01f, -1.05563104e-01f, -1.15916051e-01f, -2.14401409e-01f, -4.45559882e-02f, 2.25924905e-02f, -3.83396186e-02f, -8.33159164e-02f, -1.35000184e-01f,
  1.95615534e-02f, 2.08201464e-02f, -6.37108311e-02f, -2.12296899e-02f, 7.12300884e-03f, -5.68452384e-03f, -7.16216639e-02f, -9.20563564e-02f, -1.12587035e-01f, 3.82759646e-02f,
  -8.56100321e-02f, -8.96824598e-02f, 8.42830017e-02f, -3.56434993e-02f, -7.29435906e-02f, -4.87199537e-02f, -1.29185036e-01f, 1.23206351e-03f, -8.64798054e-02f, 5.57288863e-02f,
  2.96194643e-01f, 2.38417223e-01f, 2.70589828e-01f, 3.11230838e-01f, -2.50444338e-02f, -2.83400565e-01f, -1.17676571e-01f, -6.39975742e-02f, -5.28184548e-02f, 4.93593886e-02f,
  -1.07305862e-01f, 4.52854872e-01f, -2.19928220e-01f, 9.48359147e-02f, -2.90988654e-01f, -3.47964346e-01f, 1.44085631e-01f, 1.27050072e-01f, -2.60042418e-02f, 2.84099966e-01f,
  1.37560919e-01f, -2.37755150e-01f, 1.26839310e-01f, 4.64730039e-02f, 3.06087315e-01f, 4.91561890e-01f, 9.87553000e-02f, -1.24768622e-01f, 4.45248902e-01f, -2.24323124e-01f,
  -1.13606036e-01f, -3.64625901e-02f, 9.05991420e-02f, -3.50398161e-02f, 1.11805124e-03f, 7.47778416e-02f, 1.20032847e-01f, -9.21636820e-02f, -5.00023700e-02f, -1.22268431e-01f,
  -2.70266980e-02f, -1.06047757e-01f, -3.14015034e-03f, -5.98394200e-02f, -8.72676447e-02f, 8.41195956e-02f, 8.33369717e-02f, 2.06399426e-01f, 1.19731545e-01f, 8.79153237e-02f,
  2.13237956e-01f, 8.13517421e-02f, 1.15816742e-02f, -2.49402504e-02f, 4.69562085e-03f, 8.92219506e-03f, 3.49000469e-02f, 1.53966352e-01f, 1.33524537e-01f, 5.37676848e-02f,
  -8.63234922e-02f, -5.55112623e-02f, -8.42528716e-02f, 6.89543411e-02f, 1.42992698e-02f, 2.64965780e-02f, -4.31553498e-02f, 3.18421312e-02f, -5.52012138e-02f, -8.42464268e-02f,
  8.40338506e-03f, -2.19528321e-02f, -9.46713686e-02f, 1.55747339e-01f, 4.91466708e-02f, 1.59448981e-01f, 1.48352177e-03f, 1.58665448e-01f, -6.48036692e-03f, 8.38008597e-02f,
  2.55945139e-03f, -5.69982156e-02f, 1.19740851e-02f, 2.17859987e-02f, -1.36669338e-01f, 4.06790935e-02f, 5.98574206e-02f, 1.05965227e-01f, 9.36613530e-02f, -6.11170754e-02f,
  -1.04272343e-01f, 5.33675589e-03f, 2.91753095e-02f, -3.25621441e-02f, -2.55968980e-02f, 6.97687268e-02f, -6.93702102e-02f, -6.92887651e-03f, -4.32300121e-02f, -3.46772410e-02f,
  1.45933807e-01f, 1.48294102e-02f, -4.53829914e-02f, 1.12581860e-04f, -1.28031611e-01f, 3.78069952e-02f, 4.62035835e-02f, -5.85382693e-02f, 1.66255776e-02f, -7.27881258e-03f,
  1.47319615e-01f, -2.81474423e-02f, -8.48083869e-02f, 9.78993550e-02f, -8.19080789e-03f, 6.05759956e-02f, -3.11126336e-02f, 1.62113965e-01f, 1.88996885e-02f, -1.36989832e-01f,
  3.83870125e-01f, -3.81357104e-01f, 1.71384469e-01f, 4.08253789e-01f, 2.76799470e-01f, -4.85899945e-05f, 1.47988632e-01f, 1.04578830e-01f, 1.98030144e-01f, -3.66768986e-01f,
  2.74345037e-02f, -1.95803732e-01f, -1.43320858e-01f, -1.10271826e-01f, 1.69418633e-01f, -4.72477712e-02f, 1.16213642e-01f, -7.57423714e-02f, 1.65997773e-01f, 1.53810307e-01f,
  1.67857289e-01f, -4.84118145e-03f, 1.09133415e-01f, -1.25736043e-01f, 1.39688537e-01f, -1.15335159e-01f, -1.38416260e-01f, 2.80961134e-02f, -1.52165398e-01f, -1.90339640e-01f,
  8.24876577e-02f, 5.77947535e-02f, -9.64748263e-02f, -9.87808332e-02f, 2.28984356e-02f, -1.07252389e-01f, -2.28797957e-01f, -2.78538149e-02f, 1.50143862e-01f, 8.46443623e-02f,
  -1.08330339e-01f, 2.12791413e-02f, -1.11597084e-01f, -1.01281675e-02f, 4.05992102e-03f, 1.19514741e-01f, 1.30948350e-01f, -3.82558443e-02f, 3.67195867e-02f, 5.94342016e-02f,
  1.27743855e-01f, 1.37395784e-02f, 7.66461417e-02f, -1.49534822e-01f, -4.85972613e-02f, 6.96737468e-02f, 1.56534812e-03f, -9.72480141e-03f, 1.28526082e-02f, 4.35810946e-02f,
  -1.88418150e-01f, -1.56434193e-01f, 1.27516747e-01f, 1.02999009e-01f, 1.24415748e-01f, 1.33025199e-01f, -1.18720112e-02f, 3.69176753e-02f, 6.18775561e-02f, 1.26277842e-03f,
  1.27126530e-01f, 3.15164239e-03f, 1.48756877e-01f, 7.48803765e-02f, -8.23706686e-02f, 4.18134453e-03f, 4.86788079e-02f, 8.61409865e-03f, -8.51363242e-02f, -2.61582341e-02f,
  4.37060837e-04f, 3.69970575e-02f, -2.75939354e-03f, 8.87027085e-02f, 9.22168512e-03f, -2.49539427e-02f, -5.62726073e-02f, 2.10061222e-02f, 5.72330169e-02f, 8.15564673e-03f,
  -2.41850063e-01f, -4.45785761e-01f, -7.57526457e-02f, -1.84908193e-02f, -6.09878637e-02f, 4.37424937e-03f, -9.88172963e-02f, -1.01845367e-02f, -8.24121535e-02f, -4.04053256e-02f,
  -3.98984961e-02f, 1.39385998e-01f, -5.05977273e-02f, 5.32095395e-02f, -1.00416221e-01f, -4.15068902e-02f, -4.88771647e-02f, -2.06018865e-01f, -9.59421322e-02f, -5.26978560e-02f,
  -3.92520912e-02f, 4.25304584e-02f, 1.98745281e-02f, 9.97727737e-02f, -1.03707880e-01f, -1.93314794e-02f, -1.27267698e-02f, -1.28602441e-02f, -3.46638002e-02f, -9.40586813e-03f,
  2.60534525e-01f, -8.55749696e-02f, -2.87019193e-01f, -2.38071848e-02f, -3.87356095e-02f, 2.48405710e-01f, 1.64810866e-01f, -1.00324631e-01f, -2.59538382e-01f, 1.99501321e-01f,
  1.36896655e-01f, -1.52531549e-01f, -7.10278302e-02f, 1.92263931e-01f, -2.29409695e-01f, -3.87311652e-02f, 2.86937445e-01f, 8.00538436e-02f, 2.23712157e-02f, 1.06824003e-01f,
  -4.99936715e-02f, 3.17120880e-01f, -2.38635123e-01f, 1.18828617e-01f, 2.00055137e-01f, -1.86686918e-01f, 9.40079167e-02f, -1.03664503e-01f, 1.00943722e-01f, 6.76135421e-02f,
  -1.02547859e-03f, 2.21013576e-02f, -5.17826043e-02f, -7.80554488e-02f, 4.49129380e-02f, 1.76049665e-01f, -2.54320237e-03f, -2.57397797e-02f, -1.47518948e-01f, -4.74550314e-02f,
  1.08654447e-01f, 1.37318010e-02f, -6.11048518e-03f, -8.75518322e-02f, 2.04796400e-02f, 6.04657270e-03f, -1.21120727e-02f, -6.81945980e-02f, -1.04052953e-01f, 4.92562689e-02f,
  -5.26490062e-02f, -3.22670713e-02f, 4.80047576e-02f, 1.31985908e-02f, -2.13684887e-02f, -6.23067282e-02f, 2.93292268e-03f, -3.20959687e-02f, 1.55475691e-01f, 2.60158423e-02f,
  6.81975409e-02f, 1.75927788e-01f, 9.61963758e-02f, -7.22462460e-02f, -8.38511512e-02f, 3.41120027e-02f, 6.47468641e-02f, -7.72948330e-03f, -6.26685396e-02f, 1.42014936e-01f,
  -7.10794479e-02f, 2.10152543e-03f, -8.32957998e-02f, -6.56495243e-02f, 1.52690247e-01f, 8.31221417e-02f, 1.97854219e-03f, 7.54327402e-02f, -2.45011207e-02f, -1.64146066e-01f,
  -2.75552943e-02f, 1.62560698e-02f, -2.29376741e-02f, 8.91184136e-02f, 5.29411668e-03f, -5.21153696e-02f, 6.96157217e-02f, -6.77571306e-03f, -1.75980687e-01f, 5.09814695e-02f,
  6.77775368e-02f, 1.46011740e-01f, 6.14211150e-03f, 1.42536061e-02f, -2.88911946e-02f, 8.17434210e-03f, 5.94785586e-02f, 7.73368701e-02f, 6.42078146e-02f, 1.63601816e-01f,
  8.39430392e-02f, 1.07791286e-03f, 1.06025346e-01f, -6.09450340e-02f, -8.31673369e-02f, 8.23624209e-02f, 8.42179209e-02f, -1.60392359e-01f, -3.64859328e-02f, -5.92353158e-02f,
  7.51426890e-02f, 4.54695635e-02f, 4.72364873e-02f, -8.28356482e-03f, 6.31938726e-02f, 9.11603589e-03f, -5.58455568e-03f, 2.96142627e-03f, 4.23191115e-02f, -8.69896337e-02f,
  -5.23202214e-03f, -2.15882197e-01f, -4.42725867e-01f, -1.66584983e-01f, 1.83050945e-01f, 1.59554407e-01f, -1.07253000e-01f, 1.28354989e-02f, -3.56632143e-01f, 1.00129001e-01f,
  -2.59226561e-02f, -1.94637373e-01f, -2.59609461e-01f, -2.03138039e-01f, -2.29663685e-01f, -3.42309117e-01f, 1.26862032e-02f, -1.13944709e-03f, -1.90096974e-01f, -2.72426493e-02f,
  1.01878187e-02f, 1.20669916e-01f, -2.16810167e-01f, 2.54809499e-01f, 2.36982018e-01f, 1.45526499e-01f, 3.56472194e-01f, -1.90826673e-02f, 1.96360439e-01f, -3.73499491e-03f,
  -2.67654415e-02f, -1.41626164e-01f, -1.37222111e-01f, -1.09806292e-01f, 9.00498852e-02f, 2.28056625e-01f, 1.41519323e-01f, 1.95482187e-03f, -4.30044346e-02f, -6.75876960e-02f,
  6.11127820e-03f, 3.36476415e-02f, -1.25046344e-02f, 9.16507393e-02f, 1.13176808e-01f, -8.96984190e-02f, -3.17580886e-02f, 1.29630625e-01f, -2.00673923e-01f, -1.58661120e-02f,
  -8.25312510e-02f, 1.87455714e-02f, 1.17295370e-01f, -5.19132428e-03f, -4.34125215e-02f, 3.55951069e-03f, 3.09674423e-02f, 4.48346995e-02f, 1.07564248e-01f, -3.50939692e-03f,
  1.09016255e-01f, 5.22000268e-02f, 2.50630919e-03f, -6.53812885e-02f, -6.83541447e-02f, -6.88849539e-02f, 2.64204219e-02f, -5.15409857e-02f, -6.40823087e-03f, -8.10295492e-02f,
  -2.30936520e-02f, 5.38169593e-02f, -9.21723396e-02f, 5.32569848e-02f, 3.92748676e-02f, -5.46091162e-02f, 1.31810203e-01f, 4.49521989e-02f, 4.42164205e-02f, -2.59549469e-02f,
  -3.74548212e-02f, -1.03338119e-02f, -9.74915549e-03f, 7.17497095e-02f, -9.39750522e-02f, 7.54651427e-03f, 4.36685979e-03f, -4.62863520e-02f, -2.50804462e-02f, 5.88755421e-02f,
  4.27866820e-03f, 3.12523730e-02f, -5.31330965e-02f, -1.00178182e-01f, 2.27830354e-02f, 1.98349580e-02f, -1.51897306e-02f, -7.61249512e-02f, 3.70055437e-02f, 2.68645324e-02f,
  6.09108247e-02f, 1.72526449e-01f, 2.06915408e-01f, 3.79742905e-02f, 3.11128907e-02f, 1.38389943e-02f, 6.85999468e-02f, 7.00106844e-02f, 1.09671310e-01f, 4.85100895e-02f,
  1.03742629e-01f, 1.19686209e-01f, 5.42739294e-02f, -5.54267019e-02f, 5.22145852e-02f, 5.97070307e-02f, 1.19712114e-01f, -1.03714587e-02f, 7.71562532e-02f, -4.09726240e-02f,
  3.96375448e-01f, -3.21771830e-01f, -1.92687381e-02f, 3.30357850e-01f, 2.31618688e-01f, 2.93261707e-02f, -1.07058734e-01f, 3.48591246e-02f, 1.21711619e-01f, -3.57747376e-01f,
  4.77582812e-02f, -2.21042767e-01f, -1.82512864e-01f, 1.59629226e-01f, 4.09046113e-01f, -2.02155381e-01f, 1.28037289e-01f, -3.56969945e-02f, -7.84227252e-02f, 4.72873561e-02f,
  2.49162659e-01f, 2.15647593e-01f, 1.63562912e-02f, 1.01865619e-01f, 1.15479849e-01f, -1.57313719e-02f, 6.26696870e-02f, -1.06389485e-01f, 7.05964640e-02f, -3.13532315e-02f,
  1.13082178e-01f, 5.05373850e-02f, 1.17803961e-01f, -7.96281397e-02f, -7.23091960e-02f, -3.00494824e-02f, -3.37981246e-03f, 1.37422550e-02f, 7.45297447e-02f, -1.15355514e-01f,
  -7.59354159e-02f, -2.34561395e-02f, -1.80288199e-02f, 1.24006696e-01f, 5.49055524e-02f, 8.00857469e-02f, -5.22210859e-02f, 4.95428964e-02f, -1.03381738e-01f, -6.65016323e-02f,
  -2.67626103e-02f, -9.83206630e-02f, 8.77290592e-03f, -1.84564628e-02f, 3.90889458e-02f, -5.05862422e-02f, -1.89232886e-01f, -1.05617620e-01f, -5.12804389e-02f, -4.27494980e-02f,
  -5.87867834e-02f, -4.37869877e-03f, -3.80842760e-02f, 6.01773970e-02f, 2.06744345e-03f, -3.79394218e-02f, 4.60478328e-02f, -5.71006835e-02f, -4.63204272e-02f, 3.19495723e-02f,
  -6.40826598e-02f, 3.69997323e-02f, -3.19812261e-02f, 2.22165808e-02f, 7.04506338e-02f, 1.21431932e-01f, -2.34068613e-02f, -5.30465357e-02f, 5.90078235e-02f, 8.05698917e-04f,
  6.83906078e-02f, 3.48736309e-02f, -6.66854978e-02f, -1.44559428e-01f, 1.64298678e-03f, -2.79888865e-02f, 2.47233384e-03f, -4.22597118e-02f, 2.68623754e-02f, -1.15664311e-01f,
  -1.31572604e-01f, -2.17421666e-01f, -7.23877177e-02f, 3.03929206e-02f, -3.40918042e-02f, 5.14086969e-02f, 2.13556807e-03f, -8.94442722e-02f, -4.95885871e-02f, 9.55207832e-03f,
  -1.57882906e-02f, 2.29560509e-02f, -1.26846105e-01f, 1.44873574e-01f, 8.70006979e-02f, -3.19101214e-02f, -7.89901018e-02f, 6.12497367e-02f, -1.93996765e-02f, -9.44272205e-02f,
  1.82904601e-02f, -1.19258031e-01f, 5.62913790e-02f, 6.46620393e-02f, -7.48594925e-02f, -1.11357972e-01f, 6.45156875e-02f, 4.11242479e-03f, -1.22200906e-01f, -1.30163640e-01f,
  -4.32196915e-01f, 1.57247752e-01f, -1.09134004e-01f, 1.04621418e-01f, -3.12787622e-01f, 3.74685287e-01f, 5.62256217e-01f, -1.94791444e-02f, 9.04299542e-02f, 4.43456918e-01f,
  1.89609587e-01f, -5.34613915e-02f, 3.23631555e-01f, 5.76768696e-01f, -5.57301706e-03f, 2.95637757e-01f, 2.63102144e-01f, 2.82486081e-01f, -9.59682539e-02f, -3.33589725e-02f,
  -4.41669896e-02f, 2.41718665e-01f, 1.69797495e-01f, -2.02939838e-01f, 9.32494700e-02f, -1.97192952e-01f, -5.01513220e-02f, -2.01560915e-01f, 6.31194264e-02f, 3.34856398e-02f,
  2.31150940e-01f, -4.93742637e-02f, -7.81407505e-02f, -7.88048133e-02f, -7.14566931e-02f, -1.12617977e-01f, 3.58109400e-02f, -8.37610886e-02f, -1.53014734e-01f, -3.82520445e-02f,
  -3.79602462e-02f, -5.65425195e-02f, 7.93768167e-02f, -4.71664667e-02f, -1.12636968e-01f, -7.91185349e-02f, -2.25386024e-02f, 3.89141664e-02f, 1.21564388e-01f, -5.32625616e-02f,
  -1.48291886e-02f, -6.18012771e-02f, -5.88778779e-03f, 1.27226293e-01f, -9.38042477e-02f, 8.44280869e-02f, 6.26274571e-02f, -5.16188927e-02f, 6.02043932e-03f, -2.36414988e-02f,
  -6.24223948e-02f, -1.75837183e-03f, -7.21935853e-02f, 4.08492871e-02f, 3.17229554e-02f, 4.75855060e-02f, -1.51096573e-02f, 8.74782279e-02f, -2.41712350e-02f, 8.35810155e-02f,
  2.17416007e-02f, 1.67889670e-02f, -6.11626990e-02f, -2.63459347e-02f, 6.37162924e-02f, 7.79654458e-02f, -9.14540142e-02f, 6.23191521e-02f, 1.02727771e-01f, 8.86405110e-02f,
  1.49790540e-01f, -2.13259980e-02f, 3.28829628e-03f, 5.70155494e-02f, 1.12237390e-02f, -6.63921237e-02f, -1.77537557e-02f, 5.18076643e-02f, 4.41330336e-02f, -7.53203779e-03f,
  1.23325266e-01f, -5.17006293e-02f, 5.71682602e-02f, 4.53928392e-03f, -5.60701117e-02f, -1.70809582e-01f, 4.35276926e-02f, -8.36549699e-02f, 3.99292186e-02f, -2.67809746e-03f,
  -8.24961215e-02f, -5.29993065e-02f, -6.05312102e-02f, -3.89741138e-02f, -5.27488068e-02f, 1.18567243e-01f, 9.67509300e-02f, 2.43538041e-02f, 9.20649022e-02f, -2.47447174e-02f,
  -2.34465543e-02f, -8.49442407e-02f, 5.14909327e-02f, -6.75037354e-02f, -6.08830638e-02f, 4.55985554e-02f, -1.44382849e-01f, -5.39584383e-02f, -5.17531335e-02f, 5.34138381e-02f,
  -5.67856841e-02f, 7.47878850e-02f, -6.09093206e-03f, 2.02842683e-01f, 2.28910930e-02f, -5.63373685e-01f, -3.35404456e-01f, -4.31006029e-02f, 3.60729210e-02f, -2.96720415e-02f,
  -1.01287946e-01f, 1.84010208e-01f, -3.84073891e-02f, 4.64922778e-04f, -1.39393032e-01f, -2.24533267e-02f, -1.53308511e-01f, -9.71825644e-02f, 1.22414201e-01f, 4.06520581e-03f,
  3.04019414e-02f, 1.95094161e-02f, 1.45559624e-01f, -3.23181413e-02f, -1.33230135e-01f, 1.82535902e-01f, 1.47837713e-01f, -2.24468440e-01f, -5.20565510e-02f, -7.16082752e-02f,
  -9.18483287e-02f, 1.94329441e-01f, 9.36361253e-02f, -1.04891025e-01f, -1.11995466e-01f, -1.12580821e-01f, -3.89078297e-02f, -8.56253132e-02f, -4.27987501e-02f, -1.67491823e-01f,
  8.81149918e-02f, 3.00301262e-03f, 6.80473149e-02f, 4.18068096e-02f, -1.05883069e-01f, -8.67512450e-02f, 1.07459895e-01f, 4.62283455e-02f, 3.15461121e-02f, 2.12854594e-02f,
  6.83989078e-02f, -2.00818479e-02f, -6.67650625e-02f, 9.96018052e-02f, 2.14320362e-01f, 5.54989576e-02f, -1.13356836e-01f, 1.00498073e-01f, -6.25423761e-03f, 1.07314996e-01f,
  1.90330222e-01f, -2.52178945e-02f, -7.52454773e-02f, -6.25850186e-02f, -4.18052040e-02f, -5.82680888e-02f, -3.11893485e-02f, -2.46084947e-02f, -1.59623221e-01f, -1.24142237e-01f,
  -3.74173112e-02f, 1.83211286e-02f, -2.61671841e-02f, -4.20485176e-02f, -5.11301681e-02f, 9.60076824e-02f, -3.86007465e-02f, 8.31698552e-02f, -5.14014140e-02f, 6.92079365e-02f,
  4.01935801e-02f, -5.96996360e-02f, -3.98538969e-02f, -9.75035653e-02f, -2.63652980e-01f, 2.07215082e-02f, 1.12977326e-01f, -7.56742433e-02f, 5.95688336e-02f, -9.76556614e-02f,
  -2.00326853e-02f, 1.80664688e-01f, -5.83919929e-03f, 3.74236284e-03f, 2.43125614e-02f, -1.37317091e-01f, -1.33452071e-02f, -8.69937912e-02f, -6.95022568e-02f, -1.17446788e-01f,
  1.47274416e-03f, -8.84422213e-02f, -5.99115677e-02f, -3.95798171e-03f, 8.70839208e-02f, -1.06541157e-01f, 6.88855797e-02f, 2.14394554e-02f, 8.36496707e-04f, 4.83770370e-02f,
  3.47495303e-02f, -2.90864632e-02f, -3.94142270e-02f, -8.52457136e-02f, 4.59188893e-02f, 6.62903637e-02f, -3.69550511e-02f, 8.26857537e-02f, 9.94490162e-02f, -7.73866922e-02f,
  4.42754000e-01f, -1.35924563e-01f, -3.79679233e-01f, 1.28324002e-01f, 3.35459143e-01f, 2.52746254e-01f, -1.22523597e-02f, 1.82011828e-01f, 7.45253786e-02f, -4.85184118e-02f,
  1.30105332e-01f, -2.03291222e-01f, -2.70661682e-01f, 1.66664198e-01f, 1.89365625e-01f, -2.16611281e-01f, 2.23120570e-01f, 3.56622897e-02f, 1.83845812e-04f, 2.59679593e-02f,
  1.05609447e-01f, 3.30976695e-01f, -3.35977912e-01f, 7.85875097e-02f, 9.90529656e-02f, -1.39049038e-01f, 4.55752350e-02f, -2.79863864e-01f, 3.01350723e-03f, 3.86367068e-02f,
  1.79715082e-02f, -5.01473434e-02f, 6.68482929e-02f, -5.86692020e-02f, 2.38242652e-02f, 6.54280484e-02f, -1.04737487e-02f, -1.20473154e-01f, -9.60223973e-02f, 2.45845485e-02f,
  4.98552201e-03f, 1.27556518e-01f, 2.27653868e-02f, -2.03835294e-02f, 1.48316696e-01f, -1.77139975e-02f, 8.95155966e-03f, -1.31418288e-01f, 2.20643915e-02f, -1.85148220e-03f,
  -5.07613309e-02f, -4.86916266e-02f, -1.28236106e-02f, -3.03947441e-02f, -8.64658505e-02f, 4.39452715e-02f, -9.51746181e-02f, -1.40872926e-01f, 9.49032083e-02f, 1.48057237e-01f,
  1.26868129e-01f, -4.91512790e-02f, -5.83718643e-02f, -1.57282576e-02f, 7.10613374e-03f, 5.02781458e-02f, 1.33185193e-01f, -2.94166077e-02f, 9.98695195e-02f, 1.62257869e-02f,
  -1.62355173e-02f, 9.62598622e-02f, 3.28344442e-02f, -5.03268242e-02f, 4.83868346e-02f, 7.84784928e-02f, -5.53326346e-02f, 3.89518961e-02f, -8.10481310e-02f, -9.63471364e-03f,
  -2.81154979e-02f, -2.29590293e-02f, -8.71210024e-02f, 8.34183320e-02f, -9.53175277e-02f, 5.19423783e-02f, 8.49973932e-02f, -1.48534495e-02f, -9.65585709e-02f, 5.57754710e-02f,
  -5.71913086e-02f, -1.49493605e-01f, -3.63493524e-02f, -4.64755856e-03f, -9.09975246e-02f, 9.53383595e-02f, 2.69143563e-02f, 9.62310061e-02f, -2.79058535e-02f, -3.69764911e-03f,
  8.77611525e-03f, -4.27274704e-02f, 2.22730730e-02f, -7.24875033e-02f, 5.80657423e-02f, -6.35788441e-02f, -3.52064148e-02f, -1.88469980e-02f, 6.36655912e-02f, 7.08643720e-02f,
  -6.68739527e-02f, 6.94508255e-02f, 7.15800747e-02f, 6.49898797e-02f, 5.59509061e-02f, -1.74975947e-01f, 4.86612879e-02f, -1.70858741e-01f, 1.44162113e-02f, 3.98035832e-02f,
  2.80277818e-01f, -5.48712425e-02f, 2.62144115e-02f, -1.50675938e-01f, -2.06659853e-01f, -1.31002694e-01f, -1.25079587e-01f, -2.34113529e-01f, -2.24240310e-02f, -1.84545293e-01f,
  -2.49097660e-01f, 3.65918726e-01f, 1.67025954e-01f, -3.14358711e-01f, 4.07975912e-01f, 1.45268217e-01f, -3.77716124e-01f, 6.15257137e-02f, -1.60487950e-01f, -1.35037839e-01f,
  -1.05980419e-01f, -5.83558679e-01f, 1.00868285e-01f, -3.57879430e-01f, -3.86837184e-01f, -6.28645048e-02f, -1.42591521e-01f, -1.34862944e-01f, -2.28123635e-01f, -7.25459009e-02f,
  -7.10133761e-02f, -2.14115251e-02f, 2.55526360e-02f, 3.11313942e-02f, -9.35764834e-02f, -1.08943293e-02f, -8.13055634e-02f, 3.10588609e-02f, 7.23182708e-02f, 1.07030027e-01f,
  7.37252086e-02f, 7.95367509e-02f, -5.35409935e-02f, 5.41908108e-02f, -9.81609300e-02f, -3.70259732e-02f, -7.18587190e-02f, 2.12013125e-02f, 4.18586284e-02f, 7.66463429e-02f,
  1.36009648e-01f, 2.71121226e-02f, 8.64752978e-02f, 1.27048686e-01f, 5.72808422e-02f, -1.52019367e-01f, 8.60495865e-02f, 2.01263711e-01f, 1.41739562e-01f, 1.84832104e-02f,
  1.32227372e-02f, -7.91183412e-02f, -1.53055629e-02f, -6.50906935e-02f, -8.92748907e-02f, -1.18038617e-01f, -3.26693617e-02f, 8.67884699e-03f, -3.69371660e-02f, -4.55796979e-02f,
  -4.03885730e-03f, 5.04588261e-02f, 9.47044790e-02f, 1.01383990e-02f, -1.50088578e-01f, 6.73313662e-02f, 8.31195414e-02f, 2.91840583e-02f, 2.57283561e-02f, -5.18245064e-02f,
  -3.45445350e-02f, 1.26623707e-02f, 2.74349526e-02f, -1.01815285e-02f, -3.13222185e-02f, 8.89776349e-02f, 8.81277099e-02f, 9.19948220e-02f, -7.33956769e-02f, -1.82695650e-02f,
  -9.27460343e-02f, -2.44426116e-01f, -8.49055052e-02f, 7.80748157e-03f, 1.02094516e-01f, -1.95105802e-02f, -4.24345210e-02f, 7.13505223e-02f, -9.62285176e-02f, -4.04398143e-02f,
  -1.60123959e-01f, 4.83878851e-02f, -3.65370065e-02f, 2.92947479e-02f, 2.77219303e-02f, -9.12446007e-02f, -3.80647592e-02f, -8.45388882e-03f, -2.96331905e-02f, 1.82905085e-02f,
  -2.19779890e-02f, 9.04314741e-02f, 2.12971136e-01f, -3.39618474e-02f, -2.78514018e-03f, 3.77991609e-02f, 8.09311196e-02f, 1.81883313e-02f, 1.38262622e-02f, -4.67605181e-02f,
  -4.51440737e-02f, -1.88881561e-01f, 4.48240340e-02f, 1.39730811e-01f, -9.91904214e-02f, -3.23598891e-01f, -3.95224780e-01f, 1.19247124e-01f, -2.12126940e-01f, -2.48708561e-01f,
  2.33110692e-02f, 1.07008656e-02f, -1.27489865e-01f, 3.47066849e-01f, 4.33373868e-01f, -6.61286637e-02f, 2.48655990e-01f, 9.11670923e-02f, 6.94422647e-02f, 1.31352037e-01f,
  2.63289690e-01f, 2.17485607e-01f, 3.61602753e-01f, 3.06926697e-01f, 1.28566297e-02f, 2.11007819e-01f, 3.07352573e-01f, 6.17728345e-02f, 2.53328562e-01f, 6.54628500e-02f,
  -3.83254513e-02f, -5.08661233e-02f, -8.01243633e-02f, 6.16526697e-03f, 1.89682879e-02f, -5.31115159e-02f, 1.58485007e-02f, -5.16607519e-03f, 5.55518940e-02f, -6.36790469e-02f,
  -4.96486574e-02f, 8.75776634e-02f, 3.27061117e-02f, 8.85178987e-03f, 7.57452566e-03f, -1.93342548e-02f, -1.44615293e-01f, 2.02699155e-02f, -6.62134811e-02f, -6.51286095e-02f,
  -1.53729543e-01f, 6.64661452e-02f, -5.64435646e-02f, 1.58548262e-02f, -1.37090296e-01f, -7.01802671e-02f, -4.46817391e-02f, -7.06935674e-03f, -8.51436052e-03f, -1.09819472e-01f,
  -8.22063610e-02f, 5.77231236e-02f, -1.15641385e-01f, 3.18680890e-02f, 7.66387489e-03f, -5.33020645e-02f, -5.61767779e-02f, 8.41931403e-02f, -1.35022663e-02f, -7.99174234e-03f,
  1.85960606e-02f, 3.01890727e-02f, 5.89077361e-02f, 2.50048302e-02f, -2.09938711e-03f, 3.42264362e-02f, 1.39056653e-01f, 8.01264718e-02f, -2.40622740e-02f, 3.81642208e-02f,
  1.30381644e-01f, 7.74832442e-02f, -4.11956832e-02f, 3.59059237e-02f, 4.88369465e-02f, -7.38518778e-03f, 6.00360334e-02f, -7.50327557e-02f, 2.59815268e-02f, -5.36696948e-02f,
  5.13016619e-02f, 6.71179593e-02f, -2.50973143e-02f, -1.33908764e-02f, 9.33365244e-03f, -2.19671689e-02f, 7.12831095e-02f, -1.21780589e-01f, 7.44941831e-02f, -3.66577804e-02f,
  7.21242130e-02f, 2.47362070e-02f, 7.95790181e-02f, 5.29208668e-02f, 1.62817240e-01f, -1.25036553e-01f, 3.47762480e-02f, 6.66442439e-02f, -8.01978931e-02f, 1.31092846e-01f,
  1.07795475e-02f, -1.33754894e-01f, 3.35148945e-02f, -9.77095291e-02f, 3.94081138e-02f, -8.16481188e-02f, 6.26155064e-02f, -7.26906583e-02f, 9.27955732e-02f, -2.66606901e-02f,
  1.31358504e-01f, 2.05583617e-01f, 1.12365745e-01f, 2.69055635e-01f, -2.04696983e-01f, -3.11480373e-01f, -4.19291675e-01f, 1.53694198e-01f, -1.04430601e-01f, -1.35040209e-01f,
  -8.98673907e-02f, 1.00892916e-01f, -1.15161485e-04f, 1.53810635e-01f, 2.83617973e-01f, -1.75111234e-01f, 2.42791489e-01f, -1.47035882e-01f, -1.93842966e-02f, 1.48192495e-01f,
  1.66958079e-01f, 1.86625525e-01f, 2.11426288e-01f, 2.44924203e-01f, 6.46731779e-02f, 1.84918195e-01f, 3.11468691e-01f, -1.09911844e-01f, 1.86203510e-01f, -1.02553152e-01f,
  -1.74698517e-01f, 6.14430830e-02f, 1.36685446e-02f, -1.03501372e-01f, 1.02272339e-01f, -3.82482111e-02f, 8.50417744e-03f, -1.15489131e-02f, 5.41499294e-02f, -6.89265504e-02f,
  8.00061692e-03f, 8.90856832e-02f, -1.63619407e-02f, 1.46933012e-02f, -2.30760407e-02f, 5.61788529e-02f, 3.57676484e-02f, -5.69872111e-02f, 8.88533667e-02f, 1.01222128e-01f,
  8.80507231e-02f, -1.09930828e-01f, 8.73443782e-02f, 5.56086488e-02f, 1.27685830e-01f, 7.94548616e-02f, 3.99422422e-02f, 3.38334702e-02f, 3.65555286e-02f, 9.42610651e-02f,
  1.21342368e-01f, -8.74628350e-02f, -4.87571917e-02f, -2.26999577e-02f, -6.79054391e-03f, -5.04257251e-03f, -3.40573164e-03f, -1.09049037e-01f, -3.26968841e-02f, -5.83193405e-03f,
  -5.61588369e-02f, 2.40930337e-02f, -5.45912199e-02f, -1.29293770e-01f, 2.56466139e-02f, -4.94837686e-02f, -1.54789627e-01f, 1.38658541e-03f, -2.77848858e-02f, 8.50654021e-02f,
  -1.27802759e-01f, 3.61323357e-02f, -1.22405160e-02f, 2.33299024e-02f, 1.79060940e-02f, -4.46028970e-02f, 4.26421221e-03f, 7.06454143e-02f, -1.65453423e-02f, 7.22576380e-02f,
  9.29510742e-02f, 2.10591942e-01f, 9.83319655e-02f, -2.17698757e-02f, -4.60278988e-02f, 2.34364141e-02f, -5.44214547e-02f, 5.26671521e-02f, 1.28826916e-01f, -1.22531420e-02f,
  1.23765208e-01f, 1.56525814e-03f, -1.20899647e-01f, 3.18553783e-02f, 6.04638755e-02f, 5.72593100e-02f, -3.64862080e-03f, -3.42567116e-02f, 2.30023071e-01f, 1.89222679e-01f,
  4.28634770e-02f, -5.67526855e-02f, 8.57352838e-02f, -7.99863562e-02f, 1.19895846e-01f, -1.06837884e-01f, -2.61172783e-02f, 2.45678108e-02f, 1.28007397e-01f, 7.52678588e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  2.48624027e-01f, 1.26387760e-01f, 2.02853963e-01f, 3.83634329e-01f, 5.17825000e-02f, 3.23646754e-01f, 1.49418831e-01f, 1.70782611e-01f, 2.46423230e-01f, 1.57925680e-01f,
  3.09386611e-01f, 1.80297703e-01f, 1.25164390e-01f, 2.77754843e-01f, 2.02391058e-01f, 3.57445069e-02f, 3.02561760e-01f, 1.85022593e-01f, 7.55199194e-02f, 3.29777710e-02f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  8.07545632e-02f, 7.76643008e-02f, -5.79490624e-02f, -8.95915367e-03f, 4.86752428e-02f, 1.12348594e-01f, 5.41245267e-02f, 1.37122363e-01f, 8.78338665e-02f, 9.14199278e-02f,
  -4.36215149e-03f, -1.56043321e-01f, 1.32284686e-01f, 1.19405255e-01f, 3.68485488e-02f, 1.63688466e-01f, -2.11987540e-01f, -6.46930039e-02f, -8.58784914e-02f, -1.39489323e-01f,
  -1.23770744e-01f, -1.63228303e-01f, 1.06729820e-01f, 8.90024602e-02f, 8.29770491e-02f, 3.23880047e-01f, 2.85149515e-01f, -2.15101242e-01f, 2.95424938e-01f, -8.36170092e-02f,
  -1.02187343e-01f, -2.52749532e-01f, 2.64620602e-01f, 3.21388952e-02f, 1.17042921e-01f, 1.22399487e-01f, -1.04816705e-01f, -1.46625638e-01f, 1.22628890e-01f, -3.66911036e-03f,
  3.23386133e-01f, -5.38464785e-02f, -1.30039304e-01f, -2.13764504e-01f, -2.06866652e-01f, 8.39142054e-02f, 1.63059339e-01f, 3.02712113e-01f, -1.42573640e-01f, 1.00967519e-01f,
  1.61859587e-01f, 6.14738129e-02f, 5.07690907e-02f, -1.68673262e-01f, 5.03581502e-02f, 2.80400962e-01f, 1.65530130e-01f, 2.13663336e-02f, 5.02083302e-02f, 2.60159513e-03f,
  2.93900430e-01f, -1.98066607e-01f, -2.71290332e-01f, -1.86181180e-02f, 1.16509898e-02f, -1.39215201e-01f, 2.83459406e-02f, 3.72960977e-02f, -7.14057013e-02f, -8.29077736e-02f,
  8.46149102e-02f, -7.29611665e-02f, -3.54571082e-02f, -1.85695201e-01f, 1.59165576e-01f, 9.82748047e-02f, -1.60561502e-01f, -6.90626875e-02f, 2.06402689e-01f, -3.50114182e-02f,
  2.27482408e-01f, -2.08382104e-02f, -2.34507732e-02f, 1.48926958e-01f, 1.10146239e-01f, -1.30497282e-02f, -1.79720074e-01f, -7.61392042e-02f, 2.52608187e-03f, -1.25425786e-01f,
  1.10520624e-01f, 2.10983545e-01f, -2.03043520e-01f, -2.13888884e-02f, -3.07102259e-02f, 4.82199453e-02f, -1.75593778e-01f, -1.86470836e-01f, 1.24726065e-01f, -1.15490705e-01f,
  7.60395378e-02f, 1.40258502e-02f, -4.21056570e-03f, 1.06179575e-02f, -1.68163553e-01f, -1.39056206e-01f, 8.30657110e-02f, 1.55407980e-01f, 5.42884581e-02f, 1.07083157e-01f,
  -4.38417122e-03f, -1.10974476e-01f, 1.39783040e-01f, 1.12221241e-01f, -1.42641112e-01f, 2.32197329e-01f, 1.19378597e-01f, -1.72518954e-01f, -6.81989267e-02f, 1.41537994e-01f,
  -1.70433700e-01f, -7.70903453e-02f, 7.12860897e-02f, 2.11101510e-02f, -5.02529889e-02f, 1.03583269e-01f, 1.84265330e-01f, 2.78051719e-02f, -3.77350077e-02f, 7.92997554e-02f,
  1.87961116e-01f, 2.99087018e-02f, 2.39874646e-01f, -2.46666241e-02f, 4.10500653e-02f, 2.57453378e-02f, -1.37287229e-01f, -6.93640560e-02f, 1.39599694e-02f, -2.08403692e-02f,
  -2.38311782e-01f, 2.02637658e-01f, 9.11406428e-02f, -1.40987402e-02f, 2.80861318e-01f, 1.67354643e-01f, 1.08923957e-01f, 2.29970336e-01f, 1.06040843e-01f, -9.01121870e-02f,
  -2.08007082e-01f, 2.74642736e-01f, 8.11653882e-02f, -1.39080584e-01f, 2.28104115e-01f, -1.44760753e-03f, -7.96498358e-02f, 5.79659976e-02f, -2.47269511e-01f, -1.97192416e-01f,
  6.56281933e-02f, -7.46556558e-04f, 1.34255752e-01f, -8.50561168e-03f, 5.45616411e-02f, -2.23717555e-01f, -1.36494771e-01f, 3.36302072e-02f, 7.24230558e-02f, -3.33343558e-02f,
  9.50511992e-02f, -1.17707238e-01f, -9.76087600e-02f, -1.02279775e-01f, -3.00110597e-02f, 1.72453210e-01f, 2.84974992e-01f, 7.68034831e-02f, 6.66825473e-02f, 2.23620668e-01f,
  1.98170051e-01f, -3.71980928e-02f, 1.15869388e-01f, 1.58868298e-01f, -1.07488170e-01f, -5.72069490e-04f, -9.77367386e-02f, 1.89707503e-01f, 1.35851160e-01f, 1.99257985e-01f,
  -2.85962939e-01f, -2.13604212e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.56772526e-02f, 1.46250218e-01f, 8.16749111e-02f, 3.14533971e-02f, 2.17622519e-01f, 1.59913212e-01f, 4.33177471e-01f, -1.76532000e-01f, 4.06772792e-02f, -5.51063493e-02f,
  -4.56270903e-01f, 3.37238431e-01f, 9.51481834e-02f, 2.84699887e-01f, 4.64516729e-02f, -3.10452394e-02f, -1.81494039e-02f, 3.65070403e-02f, 3.64515185e-01f, 3.24696243e-01f,
  1.13606674e-03f, 3.51948515e-02f, -1.80187270e-01f, 2.28912458e-01f, 4.75873858e-01f, 9.02252495e-02f, 4.94771861e-02f, 1.20594665e-01f, 3.88975799e-01f, -2.88980544e-01f,
  1.21075772e-01f, 5.12271561e-02f, 2.95705140e-01f, 2.48193920e-01f, 4.25856680e-01f, 1.65385470e-01f, 2.83811122e-01f, 1.93213925e-01f, -1.40586421e-01f, 3.65585536e-02f,
  -1.17077388e-01f, -4.44195658e-01f, -1.89561039e-01f, -4.65021282e-01f, -4.98396039e-01f, 2.78823763e-01f, 4.99612182e-01f, 2.28415325e-01f, 1.42379120e-01f, -1.18111521e-01f,
  -5.17766118e-01f, -2.63044178e-01f, -5.90514299e-03f, -2.88388669e-01f, -4.61844146e-01f, 4.07357723e-01f, 4.51569259e-02f, -1.91275492e-01f, 6.88518643e-01f, -2.08194152e-01f,
  1.40428916e-01f, 1.05786882e-01f, -1.05329871e-01f, -5.59596829e-02f, 1.69261888e-01f, 1.62368551e-01f, 2.47229636e-01f, 1.06484711e-01f, 1.04131483e-01f, 1.13951445e-01f,
  -7.54210427e-02f, 1.57934189e-01f, -1.73662648e-01f, -1.03531621e-01f, 2.34056756e-01f, -2.65756458e-01f, 1.76414624e-01f, -1.94089368e-01f, 2.42878020e-01f, 1.69656470e-01f,
  3.92030686e-01f, -2.25589853e-02f, 7.77938664e-02f, 4.11670417e-01f, 5.10763787e-02f, 3.00922483e-01f, 7.79006258e-02f, -6.69099614e-02f, -1.66187584e-01f, -1.13508582e-01f,
  -1.52451739e-01f, 3.63750637e-01f, -2.81024445e-02f, 5.72529554e-01f, -1.48623675e-01f, 8.19536000e-02f, 4.16690618e-01f, 2.21441627e-01f, 1.57712370e-01f, 2.44096830e-01f,
  6.15665242e-02f, -1.23667389e-01f, -3.18130732e-01f, 4.07393686e-02f, 3.47244680e-01f, -4.44972366e-02f, 1.41435593e-01f, -2.35178128e-01f, 9.18453000e-03f, -3.12535256e-01f,
  -2.22901300e-01f, 5.10426283e-01f, 3.64693291e-02f, 4.23785925e-01f, 4.65513796e-01f, 1.61334705e-02f, 3.34981441e-01f, 2.02885494e-01f, 1.76034763e-01f, -3.28707211e-02f,
  -1.76479921e-01f, 2.34041497e-01f, -1.85636878e-01f, 1.08191706e-02f, 1.22997604e-01f, -2.35543877e-01f, -2.10404992e-01f, -1.47545487e-01f, 1.87699243e-01f, 2.70231873e-01f,
  1.62131444e-01f, 2.49147192e-01f, 1.05292894e-01f, 2.37773404e-01f, 1.07815355e-01f, 2.39153996e-01f, -2.50303489e-03f, 1.36686012e-01f, -3.71962517e-01f, -2.71790624e-01f,
  3.62489313e-01f, 2.60340929e-01f, -1.62955411e-02f, 2.98283607e-01f, -1.49362132e-01f, -3.68373618e-02f, 3.54456127e-01f, 1.18349686e-01f, -4.07752186e-01f, 3.39732707e-01f,
  3.66724133e-01f, 1.10363141e-01f, 3.29030782e-01f, 3.23033124e-01f, -1.14247389e-01f, 5.67088649e-02f, 3.00892651e-01f, 2.39748910e-01f, 9.78669748e-02f, 2.21533954e-01f,
  2.97511935e-01f, 1.49039969e-01f, 1.68128625e-01f, 3.10847580e-01f, 4.75826710e-02f, 1.26632407e-01f, -4.15687501e-01f, 1.39663577e-01f, 1.41029015e-01f, -2.41513461e-01f,
  -1.39088985e-02f, -4.00476068e-01f, -2.38970324e-01f, -1.94533229e-01f, 1.99552253e-01f, 5.10259092e-01f, -2.37625539e-02f, 2.55743325e-01f, 2.98513710e-01f, -2.77084231e-01f,
  -1.69465259e-01f, 3.91774565e-01f, 1.00893304e-01f, -1.41633376e-01f, -3.05688828e-01f, 5.08624762e-02f, -6.33875877e-02f, 1.22384496e-01f, -1.23124786e-01f, 1.33449972e-01f,
  -1.08427228e-02f, 3.52897346e-01f, 2.03541577e-01f, 2.97837526e-01f, 8.57341588e-02f, 2.55088121e-01f, 3.63966487e-02f, 1.32203713e-01f, 4.96334970e-01f, -5.67599088e-02f,
  1.40818551e-01f, 1.43644229e-01f, -5.13587534e-01f, 3.36892903e-01f, 3.84675339e-02f, 3.59526098e-01f, -1.86626706e-02f, -7.44251255e-03f, -1.84078719e-02f, -4.56772745e-02f,
  9.43711698e-02f, 1.96475133e-01f, -8.32074508e-02f, -6.07982352e-02f, -4.10751812e-02f, 1.81361556e-01f, 4.87335533e-01f, 2.34986812e-01f, 1.00600213e-01f, -5.44270463e-02f,
  4.05318022e-01f, -3.66057098e-01f, 1.59986317e-01f, 9.59960371e-02f, 6.44450560e-02f, 1.33010790e-01f, 7.91586488e-02f, 8.62204731e-02f, -5.48397452e-02f, -6.66550249e-02f,
  1.29137650e-01f, -1.92670003e-01f, 2.53458858e-01f, -1.19327359e-01f, -1.13579482e-02f, 2.64194638e-01f, 3.15551370e-01f, 3.49656969e-01f, 1.81335926e-01f, 1.79050080e-02f,
  -1.70088843e-01f, 3.23175967e-01f, -8.19296204e-03f, 7.84205124e-02f, 2.88117118e-02f, 3.33353914e-02f, 3.37408006e-01f, 8.84221345e-02f, -2.10617661e-01f, 3.18355531e-01f,
  -2.95904458e-01f, 2.10332334e-01f, 1.10787898e-01f, -7.29848295e-02f, 4.14844036e-01f, 4.22752619e-01f, 6.73942715e-02f, 2.28636295e-01f, 2.86018819e-01f, 2.50093758e-01f,
  1.14630930e-01f, 2.69963205e-01f, -1.78404987e-01f, 1.31162047e-01f, -5.02319783e-02f, 1.71918944e-02f, -2.64362432e-02f, -2.29426935e-01f, 2.90688664e-01f, 2.51352966e-01f,
  -3.16139348e-02f, 2.08261743e-01f, -1.40805483e-01f, 9.79227945e-02f, -3.01789790e-01f, -2.29538471e-01f, 1.55552238e-01f, -3.43269885e-01f, 4.76757467e-01f, 2.14141861e-01f,
  2.09454354e-02f, 3.92137796e-01f, 4.48957950e-01f, -2.36537963e-01f, 2.08774924e-01f, 2.38786768e-02f, 9.37157944e-02f, -1.05674922e-01f, 1.30673468e-01f, 2.93279380e-01f,
  3.18620242e-02f, 1.52360514e-01f, 2.68538535e-01f, 2.16182724e-01f, -1.34418055e-01f, 3.15937638e-01f, -5.36095798e-02f, 2.36049831e-01f, 1.75713956e-01f, -4.27061059e-02f,
  4.42722917e-01f, -2.53538787e-03f, -2.66254485e-01f, 3.03034455e-01f, -1.27740115e-01f, -2.50274967e-03f, 2.52386332e-01f, 4.34610918e-02f, -1.51807934e-01f, 3.43742073e-01f,
  4.39835817e-01f, -6.88455626e-02f, -1.77358110e-02f, 4.06221509e-01f, -1.38131201e-01f, -4.58561964e-02f, 1.88572988e-01f, 2.06814349e-01f, 1.64591655e-01f, 1.19933143e-01f,
  1.84767589e-01f, 1.74971014e-01f, 3.56985956e-01f, 2.74363130e-01f, 2.05595568e-01f, 6.44474402e-02f, 2.32404426e-01f, -2.61965364e-01f, -2.71116905e-02f, 8.21186677e-02f,
  -8.64684284e-02f, 2.83536017e-01f, -2.45898757e-02f, 4.77576479e-02f, -7.39921033e-02f, 6.54296353e-02f, 2.93723732e-01f, 2.34649569e-01f, 5.63030481e-01f, 6.70762897e-01f,
  1.99424908e-01f, 5.08363605e-01f, -1.90885410e-01f, -6.80718347e-02f, 4.13394272e-01f, -3.95794570e-01f, -4.38919365e-01f, 2.62705147e-01f, -6.53848574e-02f, -1.48023870e-02f,
  -3.32342207e-01f, -1.43715173e-01f, 1.59853578e-01f, 2.51375914e-01f, 3.37091684e-01f, 3.50996047e-01f, 3.60429585e-01f, 7.56498799e-02f, -3.24819654e-01f, -1.32974014e-01f,
  -4.41768356e-02f, -8.19858834e-02f, 4.11279202e-01f, -7.39060575e-03f, -2.53421105e-02f, -2.36986920e-01f, -1.53873071e-01f, 3.52281868e-01f, 8.17025546e-03f, 4.03965324e-01f,
  1.49699152e-01f, -1.72246799e-01f, 4.30913150e-01f, -4.63034734e-02f, 1.21776789e-01f, 1.56101715e-02f, -1.43570051e-01f, -1.85040217e-02f, 1.08339772e-01f, -1.97446600e-01f,
  -2.26150960e-01f, 1.31935969e-01f, 8.27936083e-03f, -1.80111676e-01f, -3.95323150e-02f, 3.93944681e-02f, 2.19952658e-01f, 6.07973933e-02f, 3.16103399e-01f, 1.59037381e-01f,
  -5.71404062e-02f, -1.55720547e-01f, -1.50824487e-01f, 4.49749604e-02f, 5.81296921e-01f, 4.21325356e-01f, 3.77091050e-01f, -2.30292901e-01f, 1.71940163e-01f, -4.41694945e-01f,
  3.52175772e-01f, 1.66270792e-01f, -1.49629086e-01f, 2.92876720e-01f, 6.14871025e-01f, -2.12582931e-01f, 1.32542297e-01f, 3.65314796e-03f, -2.93459803e-01f, 4.89426292e-02f,
  5.11944532e-01f, 8.02959204e-02f, -4.11929160e-01f, 2.18148425e-01f, 3.42266589e-01f, -2.73692816e-01f, 3.01374584e-01f, 3.49908948e-01f, 1.37400866e-01f, 2.34575823e-01f,
  1.45934463e-01f, 1.41551539e-01f, -3.71206820e-01f, 1.88303381e-01f, 2.20112681e-01f, -4.11355406e-01f, -1.08698085e-01f, -5.42530715e-01f, -3.43704075e-01f, 2.06405893e-01f,
  2.84316421e-01f, 6.60034537e-01f, 1.30802644e-02f, 9.71750449e-03f, -1.72828157e-02f, -9.96013433e-02f, -4.36166584e-01f, 3.22454900e-01f, 3.55999060e-02f, 9.23458263e-02f,
  -1.62026018e-01f, 1.24312721e-01f, -4.25496176e-02f, 2.54689395e-01f, 2.03347772e-01f, 1.70443743e-01f, -1.00643910e-01f, 4.11488861e-01f, -6.02854714e-02f, -3.34216282e-02f,
  1.83070451e-01f, 1.32213414e-01f, 1.62268370e-01f, 5.81972227e-02f, -5.25522269e-02f, -1.78696901e-01f, 5.58654703e-02f, 6.51779994e-02f, 2.86604613e-01f, 1.87970296e-01f,
  8.50703418e-02f, -5.45676053e-02f, -3.18171903e-02f, -1.90176398e-01f, 2.89138496e-01f, 3.37098658e-01f, 1.38340965e-01f, 3.20201010e-01f, 3.66506130e-01f, -2.22824156e-01f,
  -9.88776237e-03f, -9.48698521e-02f, -3.08217436e-01f, 7.97055513e-02f, -2.33326644e-01f, 2.93595105e-01f, -4.84718196e-02f, -1.18908137e-02f, 3.87587883e-02f, -8.47681910e-02f,
  6.00959919e-03f, 2.63112299e-02f, 3.24992120e-01f, -3.27209185e-04f, 2.43743479e-01f, 1.69402748e-01f, 4.07166660e-01f, 7.94143677e-02f, -1.54630780e-01f, 4.15110402e-02f,
  -3.12997401e-01f, 5.31863719e-02f, -1.28038540e-01f, 1.77294135e-01f, 1.84530601e-01f, -1.84716776e-01f, -1.00387402e-01f, -1.40529871e-01f, -4.92085097e-03f, -1.04848206e-01f,
  -1.41836539e-01f, -1.43103793e-01f, -7.64917135e-02f, 3.13137352e-01f, 3.74420792e-01f, 9.88709182e-02f, 5.41429281e-01f, -1.91459686e-01f, 2.03652844e-01f, -1.27879262e-01f,
  -5.91958314e-02f, -1.41730994e-01f, 1.30808920e-01f, 6.82692975e-02f, 2.76402384e-01f, 2.40236819e-01f, 1.36446297e-01f, 1.40024155e-01f, -6.79281279e-02f, -4.29001123e-01f,
  2.88558751e-01f, -6.71041906e-02f, 6.21862449e-02f, 3.12710136e-01f, -1.22277327e-02f, 1.19673409e-01f, -5.04518710e-02f, 2.63122413e-02f, 9.22763487e-04f, 5.53977907e-01f,
  2.71203965e-01f, -3.76771577e-02f, 4.96945679e-01f, -2.61804163e-01f, -2.59285117e-03f, -9.94918123e-02f, -1.11608014e-01f, 1.92833245e-01f, -1.74425561e-02f, 2.74683945e-02f,
  -1.42955393e-01f, -4.09877628e-01f, 4.67292517e-01f, 2.27270842e-01f, 1.57734826e-01f, 1.60537049e-01f, 1.79369897e-02f, 1.09170899e-01f, -1.43082859e-02f, 1.22987339e-02f,
  6.26475960e-02f, -2.90512247e-03f, 1.55555576e-01f, -1.37154505e-01f, -1.36596933e-01f, -1.40437722e-01f, 1.85252894e-02f, 2.26094425e-01f, 7.53410459e-02f, 4.85988289e-01f,
  -1.33587956e-01f, 3.65015753e-02f, 1.22294389e-01f, -1.11794464e-01f, -2.80691534e-01f, 4.32291538e-01f, 2.00558111e-01f, -1.30966663e-01f, -1.08705677e-01f, 1.32740006e-01f,
  -2.61239577e-02f, 2.10029170e-01f, 3.25720310e-02f, -1.59359396e-01f, 1.69680580e-01f, 3.02090108e-01f, -2.81371158e-02f, 1.37763366e-01f, 2.05544963e-01f, 2.75708586e-01f,
  3.50396454e-01f, 3.30197603e-01f, -3.06666136e-01f, 2.55559236e-01f, -1.91240534e-01f, 1.90437868e-01f, 2.78846174e-01f, -2.17737947e-02f, 6.46630049e-01f, -6.19482202e-03f,
  -2.45889053e-01f, 1.39399290e-01f, -5.11452444e-02f, 1.52145550e-01f, -1.11355036e-01f, -1.85446739e-01f, 2.95660626e-02f, -2.88479567e-01f, 5.11001766e-01f, -6.83336630e-02f,
  1.31845370e-01f, 3.43388289e-01f, 8.61965120e-02f, -2.41489202e-01f, 2.10358143e-01f, 2.29518354e-01f, -1.32317901e-01f, -1.68054506e-01f, 5.74126691e-02f, 1.83860436e-01f,
  3.92949700e-01f, 2.97270883e-02f, 2.41840959e-01f, 4.31329340e-01f, -2.66246591e-02f, 5.39444871e-02f, -2.35824004e-01f, 3.87586057e-02f, 1.16424516e-01f, 6.35304227e-02f,
  3.06385696e-01f, 2.91129410e-01f, 2.48683006e-01f, -2.95250833e-01f, 1.34942323e-01f, -7.91582912e-02f, -2.84802258e-01f, -4.14646566e-02f, 2.75763541e-01f, -1.48522303e-01f,
  -7.34965950e-02f, 5.08316532e-02f, 1.40832355e-02f, 1.19291104e-01f, 4.91165638e-01f, 1.84251294e-02f, 1.94127206e-02f, 4.28667754e-01f, 3.49120826e-01f, 6.57831877e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  1.51581392e-01f, 2.10072353e-01f, 2.97170505e-02f, 1.02713846e-01f, 2.80964404e-01f, 2.63425708e-01f, 9.45147201e-02f, 9.31907147e-02f, 2.78737038e-01f, 1.93621531e-01f,
  8.37670639e-02f, 4.57215220e-01f, 1.82910576e-01f, 8.82135555e-02f, 1.51378125e-01f, 6.76555112e-02f, 2.57646739e-01f, 1.65906586e-02f, 3.19109797e-01f, 2.55094290e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -6.15787692e-02f, 9.07558203e-02f, 7.62017742e-02f, 1.48954794e-01f, -5.53161986e-02f, 2.33819392e-02f, 8.58159959e-02f, -1.21400200e-01f, -7.03752786e-02f, 1.84310734e-01f,
  2.32406378e-01f, -4.81543392e-02f, -1.52596846e-01f, 2.68429816e-01f, 1.68916732e-02f, -3.27874720e-01f, -2.20321883e-02f, -1.13589905e-01f, 1.06484452e-02f, -3.40272263e-02f,
  7.01050684e-02f, -4.73430641e-02f, -1.71474516e-01f, 1.46327525e-01f, 2.75619805e-01f, -2.92236470e-02f, -1.45527301e-03f, 1.04863599e-01f, -4.12444733e-02f, -7.04938173e-02f,
  8.21215212e-02f, 1.86820567e-01f, 4.45110425e-02f, 9.46403295e-02f, 3.70049141e-02f, -6.41914308e-02f, 1.07241109e-01f, 6.77134395e-02f, 1.39794558e-01f, -7.19179809e-02f,
  -1.31116092e-01f, 1.22044325e-01f, 5.39770164e-02f, -9.85453725e-02f, 1.98785201e-01f, -5.84929250e-02f, -1.37834623e-01f, -6.65080771e-02f, -4.77739982e-02f, -1.56850964e-01f,
  1.60722539e-01f, -1.84458196e-01f, 1.27036348e-01f, 3.57154682e-02f, 6.46483600e-02f, -1.19045146e-01f, 2.65365448e-02f, -3.16197366e-01f, -1.58283398e-01f, 5.52496463e-02f,
  -1.04648978e-01f, -8.63920152e-02f, 2.09394366e-01f, 1.09799735e-01f, -2.60271698e-01f, -1.36761531e-01f, -2.13674665e-03f, 5.10956207e-03f, -1.24293147e-02f, -8.83381069e-02f,
  -6.05790280e-02f, 2.95720971e-03f, 1.01750076e-01f, 7.93547481e-02f, 5.50874434e-02f, -2.22275220e-02f, -1.20865321e-03f, 1.25837252e-01f, 2.19509080e-01f, 7.54910260e-02f,
  1.16993077e-01f, 9.36468169e-02f, -3.60943265e-02f, 8.69637951e-02f, 5.83031354e-03f, -1.54973954e-01f, 8.86272416e-02f, -1.21601835e-01f, -1.67929113e-01f, 2.22093523e-01f,
  7.07997801e-03f, 3.66036184e-02f, -1.12198479e-02f, 1.17115043e-01f, -1.63913652e-01f, -4.42683548e-02f, 1.04076073e-01f, 1.62813708e-01f, 9.20820013e-02f, -8.07777271e-02f,
  1.35411084e-01f, 3.34701359e-01f, 6.66171089e-02f, 1.16745956e-01f, -1.16096668e-01f, -1.84864566e-01f, 1.21973693e-01f, 1.15355216e-01f, 1.65482350e-02f, 3.25883597e-01f,
  -2.24500010e-03f, 1.12643637e-01f, 1.06390342e-01f, 6.73497422e-03f, -5.38296513e-02f, -1.06093027e-02f, 1.21019706e-01f, 2.54995078e-02f, -4.28345278e-02f, 1.79510310e-01f,
  -8.31884518e-02f, 6.89696372e-02f, -3.22815239e-01f, 1.14660643e-01f, -2.11971015e-01f, -1.50839873e-02f, 8.57996866e-02f, 3.87845263e-02f, 2.77245909e-01f, -6.36991486e-02f,
  -2.01582424e-02f, 1.16211087e-01f, 1.87644675e-01f, 1.69393763e-01f, 1.13716811e-01f, -1.27379537e-01f, 1.43704489e-02f, 1.07254058e-01f, 2.53354162e-01f, 6.15966879e-02f,
  -2.24956796e-01f, 2.79300153e-01f, 1.52221441e-01f, -1.49557948e-01f, -9.58104804e-02f, 6.00187592e-02f, -1.38337566e-02f, 5.55650033e-02f, 9.36107188e-02f, -2.95108110e-01f,
  -1.59089893e-01f, 2.33233973e-01f, 5.22599220e-02f, -1.39370501e-01f, 1.55697450e-01f, 1.07412025e-01f, 1.14247575e-02f, -1.08310081e-01f, 1.33406281e-01f, 1.47218287e-01f,
  3.26599851e-02f, 1.71726625e-02f, 9.65310857e-02f, -2.02482361e-02f, 8.10359344e-02f, 7.53821880e-02f, 6.33825809e-02f, 2.66867191e-01f, 2.53598019e-02f, -2.43611615e-02f,
  6.89690635e-02f, 1.52406260e-01f, -9.68228951e-02f, 1.53018683e-01f, -6.42937273e-02f, 1.04977921e-01f, -1.01992283e-02f, -6.04941733e-02f, 1.84488706e-02f, -4.71277721e-02f,
  2.11389929e-01f, -1.74565211e-01f, -4.15918589e-01f, 1.19765259e-01f, -1.26608893e-01f, 4.32291441e-02f, -9.97262374e-02f, 1.46169066e-01f, 5.84242726e-03f, -5.22500277e-02f,
  1.18959412e-01f, -2.66254283e-02f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -3.45318347e-01f, -9.55476761e-02f, -1.33924961e-01f, -1.29851356e-01f, -2.51812905e-01f, -2.21606418e-01f, -3.03987544e-02f, 2.90416092e-01f, 3.36212032e-02f, -1.76270887e-01f,
  -2.27250591e-01f, -4.76511084e-02f, 4.86876786e-01f, -3.41090292e-01f, -2.91226339e-02f, 3.52281243e-01f, 3.86839688e-01f, -7.78847188e-03f, 4.71400052e-01f, 3.29275519e-01f,
  1.42749846e-01f, 3.08062017e-01f, 3.34083229e-01f, -3.66480425e-02f, -2.20837817e-01f, 1.66720077e-01f, 9.08898041e-02f, -2.51543336e-03f, 2.99306542e-01f, 3.03837538e-01f,
  -5.40699512e-02f, -1.53662711e-01f, -1.92525964e-02f, 2.18602479e-01f, -6.29645889e-04f, 1.16407454e-01f, 1.83486030e-01f, -2.70394117e-01f, -2.38423809e-01f, 1.34923970e-02f,
  1.16891146e-01f, 1.48043275e-01f, -1.30365312e-01f, 1.44395873e-01f, -8.89044404e-02f, -4.40973967e-01f, -3.16284001e-02f, 4.50635046e-01f, -1.05388783e-01f, 2.12705359e-01f,
  -1.35122359e-01f, 5.42786241e-01f, -6.95651844e-02f, -1.60004627e-02f, 4.37814742e-02f, 3.79631937e-01f, 2.42544249e-01f, 1.90366447e-01f, 3.21408451e-01f, -3.60231310e-01f,
  6.33734822e-01f, 1.90507337e-01f, -1.47757605e-01f, 5.51525056e-02f, 4.11112010e-01f, 3.02011997e-01f, 4.51863468e-01f, 1.96892276e-01f, 4.41780955e-01f, 1.39089018e-01f,
  -1.21164836e-01f, 1.64238131e-03f, -2.10983187e-01f, -7.27711022e-02f, -4.88438271e-02f, 7.64278471e-02f, -4.74323243e-01f, -1.25074640e-01f, -2.05187649e-01f, 4.41838890e-01f,
  2.15647202e-02f, 5.18591642e-01f, -2.87610680e-01f, 3.28351408e-01f, 2.39470109e-01f, 1.90512329e-01f, -1.99703589e-01f, 3.41867715e-01f, -2.25949753e-02f, 2.11281940e-01f,
  5.67139015e-02f, -5.29327095e-01f, 4.54832137e-01f, 8.68996978e-02f, 1.67885274e-01f, -9.52666849e-02f, -6.16056807e-02f, -1.05877273e-01f, 1.52401730e-01f, 1.03395522e-01f,
  7.39235356e-02f, 5.71424067e-02f, -1.72847114e-03f, 2.44725704e-01f, -7.00828433e-02f, 6.11647330e-02f, 8.58314261e-02f, -6.47464544e-02f, 4.52151775e-01f, 1.12264536e-01f,
  -1.09249398e-01f, -7.84501806e-02f, 2.74783164e-01f, -8.58872905e-02f, 4.90594029e-01f, 3.20052177e-01f, 3.16437364e-01f, -9.88648087e-02f, 1.64532483e-01f, -2.45327234e-01f,
  -3.10197681e-01f, 1.45961553e-01f, 1.21453702e-01f, 2.20270038e-01f, 3.99440289e-01f, 1.75761804e-01f, -2.16558129e-01f, 1.99958622e-01f, 1.74544886e-01f, 1.48006454e-01f,
  1.65061638e-01f, 2.62580514e-01f, -3.97441052e-02f, 8.59443471e-02f, 2.16027081e-01f, 3.33195150e-01f, 1.62169620e-01f, 1.18486129e-01f, 2.05370262e-01f, 2.13409781e-01f,
  5.10693341e-02f, 2.93143481e-01f, -1.02907531e-01f, 2.03764006e-01f, -3.99850994e-01f, -1.10591516e-01f, 7.20288903e-02f, -4.61143218e-02f, 3.35955620e-01f, -2.14701250e-01f,
  1.87270135e-01f, 4.74480867e-01f, 2.87350863e-01f, -1.63512439e-01f, 2.37385124e-01f, 8.69249851e-02f, 4.71289486e-01f, -2.02232912e-01f, 2.11449817e-01f, 2.34712791e-02f,
  2.04830945e-01f, 2.51889229e-01f, 3.39282483e-01f, 2.60580212e-01f, 2.40840584e-01f, 2.40463745e-02f, -3.11793208e-01f, 2.05224812e-01f, 1.77976519e-01f, -1.82823285e-01f,
  1.48748055e-01f, 1.42875642e-01f, 1.04729950e-01f, -2.29066871e-02f, 3.32953721e-01f, 2.42044285e-01f, 2.20048949e-01f, 5.07561386e-01f, -1.49933949e-01f, 8.87159035e-02f,
  -2.34565333e-01f, -3.31190675e-02f, 5.17089128e-01f, 2.24610373e-01f, -2.06121784e-02f, 4.99591231e-01f, 1.08792238e-01f, -3.02506447e-01f, 2.76539773e-01f, 3.08171451e-01f,
  -2.61419982e-01f, 2.27319282e-02f, 6.31485693e-03f, 2.36820430e-02f, 1.98386416e-01f, 3.59570608e-02f, 2.76830018e-01f, 2.79378891e-01f, 3.62325549e-01f, 2.73160875e-01f,
  -1.94152176e-01f, -2.56828904e-01f, 2.11813331e-01f, 2.35092238e-01f, -2.76354283e-01f, 4.06280875e-01f, 1.63486332e-01f, 4.08145815e-01f, 3.12381953e-01f, 5.11873364e-01f,
  -3.10918272e-01f, -3.41217816e-01f, 2.86731333e-01f, 2.35346735e-01f, -2.03934163e-01f, 3.27953786e-01f, -3.32503825e-01f, 4.88041878e-01f, -2.33556435e-01f, -5.47327437e-02f,
  -3.77104342e-01f, 5.93165867e-02f, 3.88568342e-01f, -1.23247243e-01f, -1.08000502e-01f, 1.66929781e-01f, -9.51511115e-02f, 7.78483972e-02f, -8.38461518e-03f, -7.93880448e-02f,
  -2.30364501e-01f, 1.69803828e-01f, 1.17958389e-01f, 8.00575018e-02f, 7.10328817e-02f, 1.11445487e-01f, 1.10771909e-01f, -2.34879807e-01f, 1.13214552e-01f, 1.83197647e-01f,
  -1.78662762e-01f, -1.33717805e-01f, 6.66739792e-02f, 1.39555365e-01f, -8.31388682e-02f, -1.29478201e-01f, 4.14867043e-01f, 3.03810984e-01f, 4.95214164e-01f, -1.72283500e-01f,
  4.12598193e-01f, -2.03949362e-02f, 3.63175154e-01f, -1.01343438e-01f, -1.96201995e-01f, 1.41929895e-01f, -1.00020312e-01f, 1.69676483e-01f, -1.46730244e-01f, 7.71860704e-02f,
  -2.08338629e-02f, -1.30371258e-01f, 1.09108768e-01f, -1.16036600e-02f, 2.48410076e-01f, 1.27263159e-01f, -1.13628469e-01f, 1.75816938e-01f, -3.25534523e-01f, 3.67232680e-01f,
  4.79119092e-01f, 3.42588305e-01f, -1.39281616e-01f, 3.53964090e-01f, -3.87875527e-01f, 4.20700409e-04f, 1.10460527e-01f, 5.62069975e-02f, 2.32609324e-02f, 3.50043446e-01f,
  5.53770542e-01f, 2.29545668e-01f, 2.99395531e-01f, -1.91809982e-01f, 2.37383902e-01f, -7.58764446e-02f, 2.02575788e-01f, 1.59585252e-01f, -2.14774460e-02f, -1.47689700e-01f,
  2.02156529e-02f, -3.58995348e-02f, -6.12128042e-02f, 1.01998001e-01f, -8.11306015e-02f, 1.79882243e-01f, -5.02617732e-02f, -2.50127981e-03f, 1.35518104e-01f, -7.06616566e-02f,
  3.06037724e-01f, 5.65511584e-01f, -1.44422576e-01f, -1.88857377e-01f, 2.04310969e-01f, 1.64626509e-01f, 4.00247097e-01f, 2.42754579e-01f, 1.80011123e-01f, -2.80562788e-01f,
  -1.93964422e-01f, -5.36863878e-02f, -4.98177148e-02f, 4.06892061e-01f, -2.36674666e-01f, 1.96915239e-01f, 2.54804760e-01f, 2.65005827e-01f, -1.23795897e-01f, 2.37215012e-01f,
  -1.61344454e-01f, -8.29214901e-02f, -6.34738058e-02f, 2.22397357e-01f, 3.85924913e-02f, -1.27856329e-01f, 1.21047512e-01f, 5.50120957e-02f, -3.02183658e-01f, -2.13559475e-02f,
  -2.01573014e-01f, -1.35960683e-01f, 1.13758810e-01f, 1.03928402e-01f, 2.55905967e-02f, -2.11298130e-02f, 2.87392497e-01f, 1.91556394e-01f, 1.94287881e-01f, 3.24223936e-01f,
  3.97344232e-01f, 3.59746486e-01f, -4.91983891e-01f, -1.83550313e-01f, -3.75864297e-01f, 5.63450813e-01f, -1.28710300e-01f, 1.60674110e-01f, -1.32958293e-01f, 1.65582329e-01f,
  3.24922740e-01f, 2.41443798e-01f, 2.10299920e-02f, -8.37723464e-02f, -1.71365231e-01f, -2.54096657e-01f, -1.77805290e-01f, -2.03064054e-01f, -3.36956590e-01f, -2.58791745e-01f,
  2.55815327e-01f, 5.28254882e-02f, -1.36674523e-01f, -2.00218230e-01f, 2.28188321e-01f, -4.32534777e-02f, 5.48429489e-01f, -1.47295117e-01f, 2.01303601e-01f, 2.32325822e-01f,
  -4.70017493e-02f, 2.00595811e-01f, -4.55969095e-01f, 9.11091492e-02f, 5.10466516e-01f, -2.63755340e-02f, 7.81692266e-02f, 3.15516174e-01f, 9.33066681e-02f, -7.49218315e-02f,
  -1.57661185e-01f, 3.08315098e-01f, -5.63505471e-01f, 2.50097424e-01f, 4.12227400e-02f, 1.80208400e-01f, -4.73304931e-03f, 7.63842389e-02f, 2.33333468e-01f, 4.62147854e-02f,
  3.27765375e-01f, -4.69682753e-01f, -2.62518615e-01f, 1.93658963e-01f, -1.39602184e-01f, -6.30824119e-02f, -5.26124798e-02f, -1.54518396e-01f, 1.41129211e-01f, -2.80180901e-01f,
  3.14097494e-01f, -2.86487788e-01f, 3.01474296e-02f, 2.98937112e-01f, 4.52362955e-01f, 2.61433333e-01f, -1.79207265e-01f, 9.55398008e-02f, 6.32308424e-01f, -3.76254410e-01f,
  1.37305126e-01f, 1.86038986e-01f, -1.21964529e-01f, -2.71589339e-01f, 5.68896592e-01f, 5.97173750e-01f, 1.86833516e-01f, -1.83014758e-02f, 2.82705158e-01f, 2.05281645e-01f,
  3.10527142e-02f, 3.23021531e-01f, 1.16925985e-01f, 3.85568321e-01f, 1.61761522e-01f, 6.33249208e-02f, 4.67908680e-01f, 8.75293389e-02f, 2.33542085e-01f, 6.47682846e-01f,
  1.04376204e-01f, -2.42724851e-01f, -1.13102175e-01f, -2.73150690e-02f, 2.48533189e-01f, -4.29767400e-01f, 1.72056809e-01f, -3.20291609e-01f, 1.88767284e-01f, 1.08272612e-01f,
  2.50458211e-01f, 3.10107559e-01f, -4.62486297e-02f, 4.25882638e-01f, -1.27453819e-01f, -1.92916736e-01f, -6.77647591e-02f, 3.08949769e-01f, 3.18065494e-01f, 2.92394400e-01f,
  2.00021297e-01f, 2.54096091e-01f, 2.30653644e-01f, 2.42356792e-01f, -2.48640016e-01f, 7.29289725e-02f, 1.08308753e-03f, -2.39720806e-01f, 2.23101914e-01f, 1.42689198e-01f,
  2.02673033e-01f, -3.50953430e-01f, -1.52215496e-01f, 4.56072003e-01f, 2.95962095e-01f, 1.47963673e-01f, 2.64675260e-01f, -1.42101437e-01f, -1.43585622e-01f, 3.03484589e-01f,
  5.23656309e-01f, 3.31948042e-01f, -1.65269002e-01f, -1.64326448e-02f, 8.57047085e-03f, -1.95800886e-01f, 2.06805125e-01f, 1.22193567e-01f, 2.53434777e-01f, -6.37489483e-02f,
  -2.33051911e-01f, 6.76782615e-03f, -1.80947646e-01f, -7.62671679e-02f, -6.90691024e-02f, -5.99651001e-02f, -1.02337964e-01f, -1.65067032e-01f, -8.75624493e-02f, -2.41727456e-01f,
  -5.22065401e-01f, -1.38208523e-01f, -2.39036586e-02f, -5.05643427e-01f, 1.96622908e-02f, 3.38429585e-02f, 2.88187265e-01f, 1.74386308e-01f, 1.63968652e-01f, 4.49198157e-01f,
  1.66446239e-01f, 4.55170959e-01f, -1.93388283e-01f, -1.85735196e-01f, 1.86585672e-02f, 1.25704393e-01f, -8.80827159e-02f, -3.67750078e-01f, -4.62592952e-02f, 3.63420546e-01f,
  1.99585140e-01f, -4.92242612e-02f, -3.14038061e-02f, 2.65062973e-02f, -3.00523583e-02f, 8.28137696e-02f, 1.33551553e-01f, 2.24992275e-01f, 1.34567082e-01f, 1.36365831e-01f,
  -1.80689782e-01f, -1.80194348e-01f, 8.14804621e-03f, 9.36991945e-02f, 3.41948718e-01f, -3.13525617e-01f, -2.73253061e-02f, 1.03547938e-01f, 4.21474785e-01f, -2.62320310e-01f,
  5.28454840e-01f, 2.33369693e-01f, 3.26960623e-01f, 3.13461900e-01f, -3.01891342e-02f, -2.60531008e-01f, -2.44862258e-01f, -2.01375499e-01f, 1.27252685e-02f, 2.84752339e-01f,
  -1.36492640e-01f, -1.35937765e-01f, 2.57738978e-01f, -1.09783620e-01f, 2.60915458e-01f, 2.44490027e-01f, 2.49256909e-01f, 5.28298579e-02f, 1.98140424e-02f, 1.32153556e-01f,
  2.01312721e-01f, -2.23318368e-01f, -1.60412461e-01f, 2.56912470e-01f, 2.50796705e-01f, -9.77354050e-02f, -8.62355307e-02f, 3.91979694e-01f, 1.06023423e-01f, -3.93248379e-01f,
  -9.90668833e-02f, -2.17126533e-01f, 2.86707152e-02f, -2.09732670e-02f, 3.16579759e-01f, 8.03798735e-02f, -3.63762766e-01f, 3.04630995e-01f, 4.54604685e-01f, -3.13644737e-01f,
  2.66745128e-02f, 3.79044145e-01f, 4.35286835e-02f, -3.04299116e-01f, 2.71847785e-01f, 5.85637748e-01f, 2.26530377e-02f, 1.50522992e-01f, 1.78385165e-03f, -7.77655840e-02f,
  4.66104075e-02f, -6.74195588e-02f, -1.06311567e-01f, -9.13634226e-02f, 6.60692528e-02f, -4.18976275e-03f, 5.97532876e-02f, 9.00872722e-02f, 5.11513837e-02f, -4.03745502e-01f,
  4.05104786e-01f, 2.95155883e-01f, 5.19988127e-02f, 9.55706090e-02f, -1.81564063e-01f, 3.95278931e-02f, -1.49169311e-01f, 3.14390779e-01f, 3.89315158e-01f, 2.01575473e-01f,
  2.83782274e-01f, -8.87215286e-02f, 3.49149585e-01f, -1.65771648e-01f, 5.30409478e-02f, -2.89589167e-03f, 1.49193004e-01f, 4.24434654e-02f, 1.94481403e-01f, 1.27364248e-01f,
  1.37964711e-01f, 2.00891659e-01f, 3.10122728e-01f, 3.11454654e-01f, 2.00898170e-01f, 1.41063556e-01f, -1.91993013e-01f, -1.02874279e-01f, 2.46531412e-01f, 2.24652752e-01f,
  -2.72556573e-01f, 2.00283870e-01f, 4.37659115e-01f, 3.30594242e-01f, 3.34633470e-01f, 3.30921888e-01f, -1.57718614e-01f, -3.54079723e-01f, 1.50929853e-01f, 3.15098584e-01f,
  6.49508536e-02f, 3.11249882e-01f, -1.49995148e-01f, 4.67791617e-01f, -5.71087226e-02f, -9.11574215e-02f, -4.34557617e-01f, -2.29454432e-02f, 3.13002527e-01f, 9.11048278e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  3.38885970e-02f, 6.51203245e-02f, 3.02955061e-01f, -5.64189702e-02f, 6.60301894e-02f, 1.09605335e-01f, 1.70630351e-01f, 1.59195408e-01f, 2.06064403e-01f, -7.44361579e-02f,
  4.07308526e-02f, -3.85558382e-02f, 2.46669754e-01f, 2.27254763e-01f, 1.29746512e-01f, -6.98810145e-02f, 8.41027722e-02f, 1.98235139e-01f, -1.25777060e-02f, 1.30445927e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -2.56385088e-01f, 6.12954535e-02f, -5.28266020e-02f, -1.15672559e-01f, 4.30544317e-02f, -6.76414371e-02f, -5.98271862e-02f, 2.37748295e-01f, -1.29492089e-01f, 2.47644484e-02f,
  9.70347077e-02f, 2.16585189e-01f, -5.46751916e-01f, -4.50098693e-01f, -4.43713903e-01f, -2.82216985e-02f, 4.01295751e-01f, -5.27460277e-01f, -1.70857400e-01f, -1.34412378e-01f,
  1.33351535e-01f, 1.89172655e-01f, -3.54502261e-01f, -2.86548257e-01f, 1.47863656e-01f, 3.50753665e-01f, -6.06458783e-01f, -2.12018922e-01f, -4.13781017e-01f, 4.96578753e-01f,
  -2.95925617e-01f, -2.79547542e-01f, 1.18564427e-01f, 1.56249285e-01f, 8.07287320e-02f, -1.99301496e-01f, 6.51587220e-03f, -1.11919448e-01f, 2.05895767e-01f, 2.34385952e-01f,
  -1.09968558e-02f, 1.37583792e-01f, 3.31567585e-01f, 1.37625486e-01f, -5.30614592e-02f, -8.79399702e-02f, -4.36338395e-01f, 4.26553428e-01f, -2.25588933e-01f, -2.85130322e-01f,
  6.58868402e-02f, -3.00565690e-01f, -6.07398272e-01f, 3.28305095e-01f, 3.28365743e-01f, -1.95964292e-01f, -1.32965762e-02f, 1.21089101e-01f, -4.28839684e-01f, -5.61025441e-01f,
  2.24191234e-01f, 1.95902228e-01f, -1.57309264e-01f, 1.12210736e-01f, 6.07025884e-02f, 5.73274456e-02f, -2.36693427e-01f, 1.53784990e-01f, -8.61239433e-02f, 4.80102487e-02f,
  -2.14268357e-01f, 2.18660191e-01f, -1.16017573e-01f, 1.52790055e-01f, -2.38308311e-01f, -7.61405304e-02f, 3.95039797e-01f, -1.50917679e-01f, -2.15953827e-01f, 1.75575927e-01f,
  -3.93218994e-01f, -4.99743909e-01f, -5.73156297e-01f, -2.04154938e-01f, -3.87184799e-01f, -9.25088972e-02f, 2.86015272e-01f, -2.16380641e-01f, 2.73944378e-01f, -6.48661375e-01f,
  8.59649852e-02f, 3.54868859e-01f, 2.73040444e-01f, 6.37101084e-02f, -1.03044458e-01f, -4.20953065e-01f, 1.34520471e-01f, -3.26539427e-01f, -2.76635379e-01f, -9.21277851e-02f,
  1.94098085e-01f, -2.06566215e-01f, 1.52269840e-01f, -1.46230578e-01f, 1.60486996e-01f, -4.67075646e-01f, -3.34830433e-02f, -1.23114035e-01f, 2.51278490e-01f, 4.51705039e-01f,
  -2.35984534e-01f, -2.74791420e-02f, 2.20302224e-01f, 1.17627658e-01f, -4.36766267e-01f, 3.71316105e-01f, 2.01442122e-01f, -3.34086120e-01f, -1.12302102e-01f, -2.08619386e-02f,
  -5.92253506e-01f, -2.80036688e-01f, 5.00011034e-02f, -8.42759088e-02f, -4.64299262e-01f, -5.39077163e-01f, 2.93359011e-01f, -6.21097267e-01f, 1.98717192e-01f, 3.95554304e-02f,
  5.44501431e-02f, 5.03500402e-01f, -1.25365883e-01f, 4.75876421e-01f, 3.00415814e-01f, -9.57975984e-02f, -2.99358308e-01f, 2.02155858e-01f, 3.63706529e-01f, 1.69827834e-01f,
  -3.47738832e-01f, 3.34003448e-01f, 5.68612218e-01f, -1.23266935e-01f, 2.69957244e-01f, 1.17300913e-01f, -2.42455408e-01f, 8.94099101e-02f, 1.46578804e-01f, -3.31499994e-01f,
  -5.53339720e-01f, -6.89090848e-01f, -5.34307037e-04f, -1.53511494e-01f, 1.91530600e-01f, -2.79353231e-01f, -1.29249664e-02f, 2.23925561e-01f, 9.74886119e-02f, -1.53825969e-01f,
  2.09291309e-01f, 1.65668309e-01f, 2.60483652e-01f, -1.62721485e-01f, -7.26248547e-02f, -1.85271893e-02f, 5.18398285e-02f, -2.53122896e-01f, -8.19140747e-02f, -1.50179178e-01f,
  1.83426403e-02f, 3.04380655e-01f, -2.59308398e-01f, -4.17023659e-01f, 2.78625488e-01f, -1.55932680e-01f, 1.65834680e-01f, 9.89334732e-02f, 5.11918604e-01f, -5.64875126e-01f,
  3.32444072e-01f, 3.68136801e-02f, 1.12115704e-01f, -1.74206331e-01f, -4.63539898e-01f, 1.38096154e-01f, -1.00628011e-01f, -3.91542345e-01f, -4.15537596e-01f, -2.98515186e-02f,
  -5.00780106e-01f, 3.34849715e-01f, -6.55483678e-02f, 1.98007673e-01f, 6.55675158e-02f, -7.98701867e-02f, 1.26603857e-01f, -1.98542401e-01f, -4.16020066e-01f, -2.48889312e-01f,
  -3.07611287e-01f, -1.24141097e-01f, -3.88729155e-01f, 2.90717691e-01f, 3.01879317e-01f, -2.88939197e-02f, 8.21346268e-02f, -1.62866026e-01f, -1.63879067e-01f, -3.67245257e-01f,
  2.91505218e-01f, -1.51402429e-01f, 3.17816511e-02f, -2.22410217e-01f, 1.17032163e-01f, -5.06394207e-01f, -1.73091277e-01f, -4.04097080e-01f, 4.30520438e-02f, 4.42378163e-01f,
  3.65703374e-01f, -4.59560513e-01f, -4.92050592e-03f, 2.35295802e-01f, -2.57671595e-01f, -1.32826433e-01f, -8.51036832e-02f, 1.15030892e-01f, -3.73278782e-02f, -1.87698767e-01f,
  1.24326773e-01f, -2.73790002e-01f, 3.08083594e-01f, 1.64971303e-03f, 9.54253599e-02f, -9.52519029e-02f, -2.42668256e-01f, -1.41036257e-01f, -6.05554819e-01f, -9.67834219e-02f,
  -3.65952373e-01f, 1.13950551e-01f, -2.82787800e-01f, 4.54317033e-02f, 3.45033377e-01f, -1.55562416e-01f, -1.90787122e-01f, 5.47130466e-01f, 1.93249121e-01f, 1.06191441e-01f,
  -4.51202601e-01f, -7.00313300e-02f, -1.44775555e-01f, 4.09094244e-02f, 2.49450773e-01f, 1.37350336e-01f, 6.73554912e-02f, -1.11703672e-01f, 1.72759786e-01f, 1.33999527e-01f,
  8.79046619e-02f, -4.21493966e-03f, -1.94022074e-01f, -2.49391288e-01f, 1.13573037e-01f, -2.94645995e-01f, -2.42411867e-01f, -2.12048978e-01f, 1.22152492e-01f, 3.09837669e-01f,
  3.14950079e-01f, 2.38438934e-01f, -3.78855884e-01f, 2.16713026e-01f, -4.04383868e-01f, -1.99491769e-01f, -2.25850523e-01f, 3.69775683e-01f, 1.72861159e-01f, 4.46557909e-01f,
  -2.71578550e-01f, -2.95659155e-01f, -2.65026212e-01f, 3.40893447e-01f, -2.54667014e-01f, -2.99418688e-01f, -3.19089085e-01f, -3.50364059e-01f, 1.84003729e-02f, -4.10415754e-02f,
  -2.46165290e-01f, 2.31927052e-01f, 1.08735822e-02f, 1.49826318e-01f, 4.43966627e-01f, 3.31386626e-01f, -1.31336153e-01f, 1.55103877e-01f, 3.78457099e-01f, 3.30888177e-03f,
  -3.91663522e-01f, -5.49628496e-01f, 8.32762197e-02f, -5.69686055e-01f, -9.06588286e-02f, -5.98303556e-01f, 1.93073988e-01f, -4.45977569e-01f, -5.81933185e-02f, -5.95456600e-01f,
  4.42739204e-02f, -5.02639599e-02f, 5.98453760e-01f, -3.04133326e-01f, -8.81367475e-02f, 8.57445970e-02f, 1.78585082e-01f, 3.23548317e-01f, 7.24361390e-02f, 2.40002036e-01f,
  -3.62076201e-02f, -1.13785444e-02f, 3.02499086e-01f, 3.11914802e-01f, 1.62641212e-01f, -2.30599046e-02f, -2.40266860e-01f, 1.65988296e-01f, 2.92419672e-01f, 2.45741054e-01f,
  -2.50273019e-01f, -3.38237099e-02f, 1.83970854e-01f, -4.35093611e-01f, -3.55940819e-01f, 3.09823275e-01f, 1.31339118e-01f, 1.82650074e-01f, -4.03585225e-01f, 1.93942320e-02f,
  -5.66169739e-01f, -1.32576085e-03f, -5.46916187e-01f, -1.03635956e-02f, -4.45396930e-01f, 2.17469588e-01f, 4.79199797e-01f, -4.32315379e-01f, 3.16346705e-01f, -4.49611694e-01f,
  -7.32902884e-02f, -1.98150545e-01f, -1.64277628e-02f, -7.70802870e-02f, 4.49093059e-02f, -2.28126094e-01f, 5.46724275e-02f, -7.78292567e-02f, -1.24316826e-01f, -9.53238979e-02f,
  2.75521815e-01f, 1.87461406e-01f, -3.78091842e-01f, -3.23294193e-01f, 2.98162457e-02f, -8.95906016e-02f, 1.20893277e-01f, -4.05695021e-01f, -5.92860103e-01f, 2.81063706e-01f,
  3.25179577e-01f, -2.81229705e-01f, -1.09786361e-01f, -3.32136571e-01f, -3.05270880e-01f, 3.24773759e-01f, -7.24031091e-01f, -3.45589727e-01f, 3.79306346e-01f, -8.83838013e-02f,
  -2.64043540e-01f, -3.59812975e-01f, 1.78304240e-01f, 3.07492167e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.17452294e-01f, -2.15744637e-02f, -9.05215889e-02f, -1.64878726e-01f, 1.49840236e-01f, -1.50713891e-01f, -1.11624941e-01f, 6.81319460e-02f, -7.47400969e-02f, -2.86144111e-02f,
  2.04767928e-01f, -1.27683952e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    