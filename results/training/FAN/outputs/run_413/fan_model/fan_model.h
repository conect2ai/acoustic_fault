/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.99866647e-01f, -1.82965696e-01f, -2.24217415e-01f, 3.60156000e-02f, 1.98324382e-01f, 9.79568437e-02f, 1.02270968e-01f, 1.81152865e-01f, -1.38162777e-01f, -5.60697280e-02f,
  1.06452368e-01f, -3.45206708e-02f, -8.87912512e-02f, -9.57293734e-02f, 6.82999045e-02f, -2.40248948e-01f, 1.03367111e-02f, 2.27639657e-02f, -8.06262717e-02f, -9.70461033e-03f,
  7.08672702e-02f, 4.85202000e-02f, -3.84716429e-02f, -5.57398684e-02f, 4.90523055e-02f, 1.90973561e-02f, 6.41268566e-02f, -7.60410652e-02f, -1.00983800e-02f, 4.07767557e-02f,
  -2.73183994e-02f, -1.56800061e-01f, 3.12539712e-02f, -5.33188954e-02f, 1.65896339e-03f, 7.99947083e-02f, 1.43740982e-01f, 4.11232002e-02f, -1.31895542e-02f, -8.59334916e-02f,
  -1.72266215e-02f, 9.38381702e-02f, -1.85861383e-02f, -1.55638214e-02f, -8.38292316e-02f, -5.42235374e-02f, -5.61318099e-02f, 2.21741665e-02f, 1.18460748e-02f, 6.79379031e-02f,
  -4.79772016e-02f, 3.58473323e-03f, -2.35815234e-02f, -4.60510346e-04f, 7.04377368e-02f, 5.00190929e-02f, -6.75741732e-02f, -9.92858782e-03f, 3.23371068e-02f, -1.66189228e-03f,
  4.26281914e-02f, -4.13545631e-02f, 2.73972824e-02f, 5.21521308e-02f, -6.31296039e-02f, 1.15034908e-01f, -4.79802489e-03f, -8.66687074e-02f, -1.39174210e-02f, -2.28463467e-02f,
  3.05712670e-02f, -7.41089555e-03f, 2.92703975e-02f, 7.90386554e-03f, 3.78532000e-02f, 1.69357490e-02f, 5.76348342e-02f, 3.91923897e-02f, -3.46718244e-02f, 7.98554122e-02f,
  -1.04211513e-02f, 1.54937785e-02f, -1.36051364e-02f, 6.30515143e-02f, -6.32550195e-02f, -8.32430087e-03f, -5.46350330e-03f, -5.65135553e-02f, -5.75082414e-02f, 9.66627225e-02f,
  -7.40836039e-02f, -1.00040391e-01f, -8.69942680e-02f, -7.67623819e-03f, -1.20187089e-01f, 2.33204160e-02f, -2.29867408e-03f, 2.87010521e-02f, -8.06293562e-02f, -3.15871164e-02f,
  7.56871402e-02f, 3.94823924e-02f, -2.32088882e-02f, -4.29474674e-02f, 4.02917564e-02f, 8.43046326e-03f, -2.20857244e-02f, 3.00024673e-02f, 9.56744403e-02f, -1.32339390e-03f,
  4.14859429e-02f, 1.14478084e-04f, 2.26047728e-02f, 8.77196267e-02f, 6.57796562e-02f, 1.64950807e-02f, 6.52363896e-02f, -5.74374944e-02f, 3.88620533e-02f, 4.26095165e-02f,
  2.75756847e-02f, 3.70578433e-04f, 2.37583462e-02f, 3.84165235e-02f, -6.27722265e-03f, 2.31262088e-01f, 1.27237618e-01f, -1.30975060e-02f, 1.15794875e-01f, -6.67219684e-02f,
  7.15123415e-02f, -2.40863770e-01f, 9.49203819e-02f, -1.61730200e-01f, 3.29466581e-01f, 1.10929824e-01f, 7.02632591e-02f, -6.92973584e-02f, -3.24698165e-02f, 3.07340380e-02f,
  7.97069892e-02f, 5.05227316e-03f, 9.50850770e-02f, 3.65572199e-02f, -5.28733730e-02f, -6.73560947e-02f, -6.74892440e-02f, -5.43704219e-02f, -5.73247112e-02f, -5.02993688e-02f,
  6.19208477e-02f, 8.48376900e-02f, -7.01140389e-02f, -5.53084945e-04f, 5.36092855e-02f, -4.21721861e-03f, 5.26147522e-02f, 5.84360659e-02f, 6.12582406e-03f, -2.39720335e-03f,
  1.61373224e-02f, 6.72753677e-02f, 1.92600284e-02f, 3.38397808e-02f, 2.46939808e-02f, 4.31931857e-03f, -7.77523443e-02f, -2.25464720e-02f, -2.05924623e-02f, -2.41738139e-03f,
  -4.89846170e-02f, -1.14068585e-02f, -4.08479609e-02f, 3.47967371e-02f, 4.70311195e-02f, 3.36916372e-02f, 2.59468555e-02f, -2.30232384e-02f, 6.23031706e-02f, 3.44489031e-02f,
  5.73587231e-02f, 3.54223489e-03f, -4.55236211e-02f, -6.22723363e-02f, -1.07247271e-02f, -2.30388325e-02f, -5.91042005e-02f, -2.89135147e-02f, -3.41643654e-02f, 1.32568916e-02f,
  -6.48164079e-02f, -3.85406911e-02f, -3.94608788e-02f, 5.03220782e-02f, -8.82494077e-03f, 3.38274166e-02f, -2.63506789e-02f, 2.93756519e-02f, 5.33603225e-03f, -2.46674772e-02f,
  -2.58349571e-02f, 1.68717001e-02f, -4.37584333e-02f, -2.57881843e-02f, 3.78619581e-02f, -1.47250742e-02f, 2.16200314e-02f, -2.49433853e-02f, 2.07313430e-02f, -3.78974085e-03f,
  1.01813830e-01f, 1.51427895e-01f, 3.70590873e-02f, -1.42680770e-02f, -9.86693278e-02f, -1.89816430e-02f, -1.90996621e-02f, 1.30476337e-02f, 6.96797967e-02f, 3.41127031e-02f,
  2.15665326e-02f, -2.76709236e-02f, -1.04800574e-02f, 1.26343528e-02f, 8.74078125e-02f, 3.78918052e-02f, 4.93199602e-02f, 1.67503729e-02f, 3.03147137e-02f, -2.00192071e-02f,
  5.01224473e-02f, -3.47556695e-02f, 6.19521458e-03f, -5.98988831e-02f, -2.17979327e-02f, -3.60414758e-02f, 4.21008468e-02f, 1.00870309e-02f, -5.74684935e-04f, 4.30901684e-02f,
  -8.81517604e-02f, 3.73547286e-01f, -1.80291519e-01f, 1.55230999e-01f, -1.34780362e-01f, 1.14592358e-01f, 2.65853912e-01f, 3.02185137e-02f, 2.01817393e-01f, 4.21649128e-01f,
  8.52639973e-02f, 1.51482373e-01f, 2.17574865e-01f, 2.13835493e-01f, 2.62734182e-02f, 2.47214973e-01f, 8.53681341e-02f, 2.15427890e-01f, 2.42662150e-02f, 3.09766736e-03f,
  -5.26232012e-02f, 7.03614205e-02f, -2.32056350e-01f, -1.35048730e-02f, -2.98115220e-02f, -9.27822217e-02f, -2.13576891e-02f, -7.33255967e-02f, -4.55824062e-02f, 6.80460259e-02f,
  6.64280728e-02f, 9.09219980e-02f, -2.24650487e-01f, -8.87346864e-02f, -1.28274217e-01f, -1.41702011e-01f, -8.83237720e-02f, -4.04902883e-02f, -5.20552211e-02f, 9.36419144e-03f,
  2.67480146e-02f, -1.00149766e-01f, -6.86921459e-03f, -2.07624305e-03f, -2.74318736e-02f, -5.68691976e-02f, 3.66149470e-02f, 3.46325408e-03f, 1.23304594e-02f, -6.54527470e-02f,
  -7.95169100e-02f, -1.35306688e-03f, 2.67504938e-02f, 1.17450627e-02f, -9.84192714e-02f, 7.18886405e-03f, 6.32047886e-03f, -1.03315145e-01f, 8.50325301e-02f, -3.30853797e-02f,
  -1.15686301e-02f, -5.50263049e-03f, -2.07203217e-02f, 3.85685340e-02f, 9.36391950e-02f, -7.96741247e-02f, 1.76408127e-01f, -6.57349229e-02f, 3.49122174e-02f, 3.73807363e-02f,
  -1.96192926e-03f, 6.08470440e-02f, 1.27277477e-02f, 1.07229417e-02f, 6.84226379e-02f, -3.82143222e-02f, -1.98521912e-02f, -2.68143718e-03f, -2.70664822e-02f, 6.70199282e-03f,
  1.58198345e-02f, 2.60219686e-02f, 2.63903011e-02f, -3.61551158e-02f, 2.59505659e-02f, -1.42615912e-02f, 2.39107735e-03f, 2.20945366e-02f, -5.62259331e-02f, 9.01083986e-04f,
  1.88755080e-01f, 2.74694651e-01f, 9.93790179e-02f, -7.82306716e-02f, 9.17802528e-02f, 2.23449804e-02f, 5.32272831e-02f, -9.80928820e-03f, 9.07483920e-02f, 2.42623012e-03f,
  -1.25025004e-01f, 3.92823387e-03f, 3.83730046e-02f, -7.04149157e-02f, 2.33554151e-02f, 4.94775660e-02f, 2.70837694e-02f, 5.30333333e-02f, 5.66628091e-02f, 3.29707144e-03f,
  -2.63888109e-03f, 4.65676142e-03f, 2.15209629e-02f, -1.24137245e-01f, -6.07524067e-03f, 6.59122970e-03f, 5.47440723e-03f, -1.27954539e-02f, 5.50694875e-02f, 1.60981104e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.43119311e-01f, 2.22496465e-01f, -2.51336247e-01f, -4.85307932e-01f, 6.22633472e-02f, -3.93097430e-01f, -2.64114976e-01f, 4.10178639e-02f, -3.31688225e-01f, 5.07491529e-01f,
  1.67774111e-01f, -2.19640091e-01f, 1.70407608e-01f, -4.63556379e-01f, -7.16701627e-01f, -2.83421099e-01f, -3.78076553e-01f, -1.48887187e-01f, -2.64729112e-01f, -1.62358978e-03f,
  -2.72095203e-01f, -2.12547109e-01f, -3.39230746e-01f, 3.34042639e-01f, 1.18787423e-01f, 3.67322773e-01f, 4.99151915e-01f, 3.35432559e-01f, 1.13300234e-01f, -9.02297944e-02f,
  -1.16109759e-01f, -9.13693011e-02f, 1.46017093e-02f, -1.36713982e-01f, -7.00108614e-03f, 1.17360212e-01f, 1.16124533e-01f, -5.97812943e-02f, -4.63578366e-02f, -8.32504258e-02f,
  1.03763610e-01f, -1.91592649e-01f, -1.64231241e-01f, 8.82310644e-02f, 4.87319231e-02f, -2.93557998e-02f, -3.57486196e-02f, -1.14109730e-02f, -5.31032719e-02f, -2.01803535e-01f,
  -1.23396695e-01f, -2.49256007e-02f, -4.09742002e-04f, -7.93445557e-02f, -5.48798442e-02f, 4.71311715e-03f, -7.25474358e-02f, 4.59268130e-02f, -9.64953937e-03f, 4.43317415e-03f,
  1.98884811e-02f, -1.24091189e-02f, -6.68918714e-02f, -2.36161817e-02f, 2.70248968e-02f, 7.07553420e-03f, -7.10376874e-02f, 2.70720627e-02f, 7.14110881e-02f, 5.17463163e-02f,
  -1.88169163e-02f, -7.74741545e-02f, -3.23603973e-02f, -3.38887377e-03f, 3.89874317e-02f, -1.76659618e-02f, 3.28113884e-02f, 5.66822365e-02f, -3.09417639e-02f, -7.24904910e-02f,
  8.78078789e-02f, -2.53313910e-02f, 2.97669563e-02f, 4.06930149e-02f, -4.52432819e-02f, -3.63845192e-02f, 4.18402813e-02f, -5.30619845e-02f, 9.41662863e-02f, 1.54167116e-01f,
  3.05878878e-01f, 4.24676120e-01f, 5.58313541e-02f, -1.06263332e-01f, 8.25200230e-02f, -4.86061983e-02f, -1.06283151e-01f, -3.11508700e-02f, 5.11483364e-02f, -2.78610159e-02f,
  1.56496298e-02f, 2.36526281e-02f, 1.90421641e-01f, -9.90351215e-02f, -5.53093664e-03f, 2.94146035e-02f, 4.65732031e-02f, 5.52206077e-02f, 1.05137013e-01f, 8.66210461e-02f,
  1.39617622e-01f, -1.45205238e-04f, -8.61873999e-02f, -7.19621703e-02f, -5.45904040e-02f, 1.24263972e-01f, 6.57345876e-02f, 7.83062130e-02f, 7.13561326e-02f, 2.54050177e-02f,
  -8.37172389e-01f, 2.84183472e-02f, -1.26451895e-01f, -6.75180554e-02f, -3.28359306e-01f, 7.53272772e-02f, 2.58267969e-01f, -1.13640293e-01f, -1.88070342e-01f, 4.09116298e-01f,
  3.02631915e-01f, -1.56405687e-01f, 2.69017667e-01f, 2.35280946e-01f, -7.07957894e-02f, 1.63427383e-01f, 4.52707857e-02f, 8.37041289e-02f, -8.87608379e-02f, -2.52494186e-01f,
  -1.06834397e-01f, -4.65653650e-02f, 1.75815985e-01f, -2.37046137e-01f, -1.32412985e-01f, -2.91759204e-02f, 9.10039246e-02f, 6.26742393e-02f, 6.47149011e-02f, -5.21551482e-02f,
  -4.23587382e-01f, -4.20452386e-01f, -9.98570994e-02f, -1.05460463e-02f, -3.80141474e-02f, -1.68575887e-02f, 8.82028937e-02f, -1.90024376e-02f, -7.34304041e-02f, -1.12651326e-02f,
  4.43030298e-02f, -1.55784667e-01f, -2.32714228e-02f, 2.09570536e-03f, -1.20721318e-01f, 1.15370972e-03f, -1.55691523e-02f, 3.79990526e-02f, 6.47894144e-02f, 3.58498842e-02f,
  1.76261067e-01f, 1.58294030e-02f, 5.27294204e-02f, 7.71816522e-02f, 6.27909452e-02f, 3.09360884e-02f, -1.37868691e-02f, 4.69896831e-02f, -8.72978717e-02f, -1.20980993e-01f,
  -3.17413881e-02f, -1.88164618e-02f, 1.09919429e-01f, 1.09139606e-02f, 4.67046462e-02f, 3.87370996e-02f, 4.50532921e-02f, 2.67324653e-02f, -7.76384445e-03f, -3.68874483e-02f,
  -3.36392112e-02f, -1.34699479e-01f, -1.03967443e-01f, 8.78463238e-02f, -4.82469751e-03f, -4.29877155e-02f, 6.13641776e-02f, -5.80039024e-02f, 6.88893422e-02f, 2.01362204e-02f,
  1.07810795e-01f, -2.32888386e-02f, 3.97439636e-02f, 1.48052678e-01f, -3.37898955e-02f, 6.22865856e-02f, 1.50700640e-02f, 1.03912270e-02f, 4.76555228e-02f, 6.87273741e-02f,
  -3.46059084e-01f, -4.82658505e-01f, 1.35142043e-01f, -2.40207333e-02f, -1.59310196e-02f, -1.16957642e-01f, 8.62921849e-02f, 1.97762288e-02f, -3.53483520e-02f, -1.04831174e-01f,
  6.78943470e-02f, 2.44899988e-02f, -1.10993758e-01f, 4.08884510e-02f, 4.15699072e-02f, -5.27210198e-02f, -9.97634456e-02f, -3.03252880e-02f, 8.18384532e-03f, -1.99386925e-02f,
  6.54004067e-02f, 5.28328307e-03f, -4.14713845e-02f, 7.89222717e-02f, 1.03579842e-01f, 1.09310187e-01f, -7.73094520e-02f, 3.80139984e-02f, -6.55035377e-02f, 2.49108416e-03f,
  -9.39545572e-01f, 5.59916347e-02f, 1.33995116e-01f, -4.99865144e-01f, 4.58686739e-01f, -7.03532994e-02f, -1.82457104e-01f, 3.71837258e-01f, -4.08054553e-02f, -2.41711382e-02f,
  1.80773929e-01f, -6.21334434e-01f, 3.01326841e-01f, -3.42742950e-01f, -5.00622511e-01f, -2.15435550e-01f, -6.27752423e-01f, -3.34521651e-01f, -6.66240975e-02f, -9.24905017e-02f,
  -1.02213576e-01f, -2.21736841e-02f, -8.64100233e-02f, 4.78302002e-01f, 7.98115209e-02f, 3.38631094e-01f, -1.98041260e-01f, 4.19525594e-01f, -2.86727935e-01f, 2.36348438e-04f,
  -2.16937646e-01f, 2.40447626e-01f, 1.58505112e-01f, 1.12064108e-01f, -1.36676598e-02f, 1.14198923e-01f, -1.23388238e-01f, 1.00771680e-01f, 9.99099985e-02f, 6.09682910e-02f,
  -1.15528561e-01f, 1.73850209e-02f, -7.36375973e-02f, 2.26151794e-01f, 1.88307017e-01f, 1.53527886e-01f, -2.43725460e-02f, 4.08503003e-02f, 8.77951160e-02f, 5.53653622e-03f,
  -2.45191474e-02f, -4.51122336e-02f, 6.09667785e-02f, -1.14772573e-01f, 9.77358781e-03f, 9.43278149e-02f, -6.97110817e-02f, -2.54236143e-02f, -3.93150523e-02f, -2.38461345e-02f,
  2.43589468e-02f, -4.36714105e-02f, -3.19101289e-02f, 1.49383247e-01f, -1.31594688e-01f, 1.09557234e-01f, 1.03020117e-01f, -1.64006531e-01f, -6.56236894e-03f, 5.64460196e-02f,
  -1.52329504e-01f, -4.04487876e-03f, -5.08189872e-02f, -1.29770290e-03f, 2.46568248e-02f, -8.41913447e-02f, -4.04435284e-02f, -1.84231419e-02f, -1.83742762e-01f, -8.32139775e-02f,
  2.46195532e-02f, -7.50942379e-02f, 2.13208944e-02f, 5.34202121e-02f, 1.69830203e-01f, 1.88107067e-03f, 1.22196198e-01f, 8.25935509e-03f, -1.39587959e-02f, -5.29792346e-02f,
  -1.88833281e-01f, -8.37665871e-02f, 1.11999035e-01f, 1.06227569e-01f, -1.21470638e-01f, 6.13240292e-03f, -2.28674915e-02f, 6.12328127e-02f, -1.28048398e-02f, 5.09142801e-02f,
  2.25792453e-02f, -1.40884072e-01f, -1.74712852e-01f, 4.64334805e-03f, -1.09942697e-01f, 1.37662394e-02f, -7.80391097e-02f, -1.25044391e-01f, -1.53518347e-02f, -3.79002616e-02f,
  -1.09957844e-01f, 5.76592097e-03f, -6.08503073e-02f, 8.75498205e-02f, 1.09478049e-02f, -7.00922385e-02f, -1.58894777e-01f, -9.44111198e-02f, -8.40786994e-02f, -2.14985646e-02f,
  9.80682597e-02f, 3.22473735e-01f, -4.83336508e-01f, 1.36692569e-01f, 1.40469104e-01f, 2.25501865e-01f, 2.49831900e-01f, 1.57574475e-01f, -4.16093171e-01f, 3.76730919e-01f,
  5.07467449e-01f, -2.06429318e-01f, 1.72814071e-01f, 7.42372215e-01f, 1.44298971e-01f, 1.89693838e-01f, 4.85785633e-01f, 3.50620568e-01f, -1.58927605e-01f, 2.61513799e-01f,
  -7.25253075e-02f, 7.50044048e-01f, 2.28191927e-01f, 3.38893056e-01f, 4.19117212e-01f, -1.93930328e-01f, 2.82458156e-01f, -7.99217671e-02f, 2.56994396e-01f, 2.53283143e-01f,
  8.56844410e-02f, 9.05408710e-02f, -2.00301204e-02f, -1.18678898e-01f, 4.50987481e-02f, 1.27376035e-01f, -9.84901004e-03f, -5.93063831e-02f, -1.31977558e-01f, -3.33479047e-02f,
  -6.53848052e-02f, -2.03219075e-02f, -9.43201333e-02f, -5.27769253e-02f, -6.52428642e-02f, -6.45663813e-02f, -7.47903511e-02f, -3.58503982e-02f, 2.57414859e-02f, 2.21868847e-02f,
  -1.91155449e-01f, -3.35412286e-02f, -7.25126341e-02f, -4.94357478e-03f, -1.65771782e-01f, -3.77775989e-02f, -7.45464563e-02f, 9.12998058e-03f, -2.58560479e-02f, -2.93758381e-02f,
  1.29447877e-01f, -6.27340451e-02f, 1.20055370e-01f, 7.78134316e-02f, 2.86574475e-02f, 1.11257784e-01f, 6.52248859e-02f, 4.24584001e-02f, -1.25416324e-01f, 1.75745621e-01f,
  8.16500187e-02f, -2.85961516e-02f, 1.40999317e-01f, -3.82690504e-02f, 3.12815420e-02f, 3.56887132e-02f, -6.76311925e-02f, 3.67874801e-02f, -7.10410774e-02f, -6.90687746e-02f,
  -2.44645309e-02f, -3.90696228e-02f, 9.44801718e-02f, 1.10162035e-01f, 1.47484131e-02f, -4.37919796e-02f, 1.28408343e-01f, 5.09800427e-02f, -3.25677730e-02f, 4.56535220e-02f,
  1.64492413e-01f, 1.13206387e-01f, -5.01818806e-02f, 3.33112590e-02f, -8.33471864e-02f, 2.06141874e-01f, -2.89135496e-03f, -3.80908279e-03f, -1.34044379e-01f, 6.00651726e-02f,
  7.28409830e-03f, -3.63125280e-02f, 1.76260341e-02f, 3.25868092e-02f, -1.24692649e-01f, 1.15310840e-01f, 6.44449219e-02f, -1.45905659e-01f, -6.47420809e-03f, 1.31264076e-01f,
  9.56879035e-02f, 3.37376352e-03f, -9.07566324e-02f, -9.73565951e-02f, -4.71549556e-02f, 1.16638772e-01f, -2.75889691e-02f, -1.04449473e-01f, 8.45208541e-02f, 2.42140726e-03f,
  2.35756025e-01f, -4.57901388e-01f, 5.56169599e-02f, -3.84119689e-01f, 5.53765222e-02f, -4.94607836e-01f, -1.46237895e-01f, -4.27165240e-01f, -5.89140654e-01f, -4.91063744e-01f,
  -2.25271970e-01f, 8.59215632e-02f, 3.23901653e-01f, -5.34700811e-01f, 3.81923258e-01f, 2.04248250e-01f, -4.81142551e-01f, -1.26055464e-01f, -8.74111056e-02f, -1.40868604e-01f,
  3.06375679e-02f, -3.32511127e-01f, 2.28999555e-01f, -1.34447142e-01f, -2.75154442e-01f, -1.11479551e-01f, 2.85129637e-01f, 2.25155473e-01f, -4.54456210e-01f, 7.98405260e-02f,
  -5.92651358e-03f, 3.13345157e-02f, -3.23674572e-03f, 1.20369736e-02f, -7.29741082e-02f, 3.61538492e-02f, 7.93110803e-02f, 2.74851710e-01f, -1.31566413e-02f, 2.83728428e-02f,
  3.04803476e-02f, 6.48794919e-02f, -1.11273706e-01f, 5.64865768e-02f, 3.72665562e-03f, -3.08985244e-02f, -5.47061265e-02f, -6.57207891e-02f, -6.57760277e-02f, 1.56034082e-01f,
  -9.03948769e-02f, 1.44962929e-02f, -1.49841204e-01f, -3.10565438e-03f, -2.00376008e-02f, -5.23796901e-02f, 5.16118407e-02f, 7.69236386e-02f, -4.85382006e-02f, -3.16828378e-02f,
  1.00459985e-03f, 9.65910703e-02f, 9.68920514e-02f, -1.36141360e-01f, 1.99334398e-02f, -1.82583798e-02f, -2.91136093e-02f, 8.91206134e-03f, -1.03246361e-01f, -7.67898140e-03f,
  -2.68588811e-01f, -1.78136632e-01f, -1.64763164e-02f, 1.92229990e-02f, -5.27899899e-02f, -8.12383927e-03f, 1.22175857e-01f, -1.97078660e-03f, -1.20850600e-01f, -1.86006397e-01f,
  5.16543016e-02f, -3.52388173e-02f, -1.98214240e-02f, 1.86208058e-02f, 3.88013124e-02f, -3.78701393e-03f, -6.13868535e-02f, -6.21144213e-02f, -4.70471270e-02f, 9.66444686e-02f,
  -1.52617201e-01f, 6.95593879e-02f, -1.40516758e-01f, -6.67799637e-02f, -1.37953768e-02f, 1.09375818e-02f, -2.00310536e-02f, -2.20214099e-01f, -2.96018068e-02f, -1.78653374e-02f,
  2.59683980e-03f, -2.45233085e-02f, -2.75462540e-03f, -6.33211508e-02f, -5.33473156e-02f, -1.41330600e-01f, 9.36579779e-02f, 8.03696290e-02f, -1.11821257e-01f, 5.61104564e-04f,
  -7.38128880e-03f, -9.69079323e-03f, 1.14416577e-01f, -1.13179080e-01f, -6.12138472e-02f, 3.91330495e-02f, -1.06192857e-01f, 3.92627269e-02f, 1.64288834e-01f, -1.59707256e-02f,
  5.14297374e-02f, -1.30157813e-01f, -2.59260446e-01f, 3.44446987e-01f, 5.51039428e-02f, 1.19652599e-02f, -4.47079033e-01f, 1.43503428e-01f, -2.11223260e-01f, -1.63987055e-01f,
  3.86851847e-01f, -5.41162118e-02f, -2.24643707e-01f, 5.72050631e-01f, 4.22151387e-01f, -3.72669160e-01f, 3.68399203e-01f, 4.04192630e-04f, -9.30455029e-02f, 2.68201381e-01f,
  2.18736365e-01f, 5.42511880e-01f, 4.43851739e-01f, 5.39793968e-01f, 1.04759961e-01f, 2.92323887e-01f, 5.06880522e-01f, 2.35334128e-01f, 6.77473605e-01f, 4.39797997e-01f,
  -1.15631916e-01f, 4.95867580e-02f, -1.10766768e-01f, -8.06714520e-02f, 1.43582806e-01f, -5.67991054e-03f, -1.60909295e-01f, 1.48762748e-01f, 4.26317416e-02f, 2.43882276e-02f,
  -2.03748494e-01f, 9.95996967e-02f, 2.16685813e-02f, 2.37730727e-01f, 5.69404140e-02f, -5.69817387e-02f, -2.22686157e-02f, 5.00442274e-02f, -2.22931594e-01f, -3.11376210e-02f,
  -5.41357994e-02f, -5.14408275e-02f, -8.00571591e-02f, 2.26929784e-02f, 1.34901758e-02f, 2.45976485e-02f, -8.98213163e-02f, -7.70969689e-02f, -3.98213454e-02f, -6.56094179e-02f,
  1.14960700e-01f, -6.97132275e-02f, -1.37542337e-01f, 1.34063084e-02f, 1.66097030e-01f, -2.06211172e-02f, 1.14606004e-02f, 6.63504377e-02f, -1.59776676e-02f, 1.10725611e-01f,
  -2.12833751e-02f, -6.72476068e-02f, -7.86861181e-02f, 3.95023450e-03f, -3.51518914e-02f, -1.88321233e-01f, -8.24451223e-02f, 7.46291727e-02f, -4.32287492e-02f, -6.99855313e-02f,
  -2.97878846e-03f, 8.81617367e-02f, 6.30992791e-03f, -1.81133419e-01f, 1.93008240e-02f, 6.63250238e-02f, 1.69857278e-01f, -8.46663304e-03f, -7.96389021e-03f, -5.50542586e-02f,
  1.24757297e-01f, 3.65877807e-01f, -1.19510926e-01f, -5.14319688e-02f, -4.57153283e-02f, -5.71903065e-02f, 4.21280488e-02f, 1.52755693e-01f, 1.98417783e-01f, 4.13286984e-02f,
  1.93102419e-01f, -8.33968371e-02f, -1.20016690e-02f, 1.71985865e-01f, 1.42300949e-01f, 9.85488519e-02f, -5.18839583e-02f, 1.03050634e-01f, 1.73867226e-01f, 7.49097317e-02f,
  9.94116887e-02f, -5.93010336e-02f, 3.35045680e-02f, 1.74246784e-02f, 1.20180614e-01f, -1.48303360e-01f, 3.53741944e-02f, -2.26387195e-02f, 1.68395396e-02f, 5.63519187e-02f,
  -1.17300081e+00f, 4.81742740e-01f, 7.83442259e-02f, -5.31863749e-01f, 1.43020421e-01f, -2.22701222e-01f, -4.03400630e-01f, 1.39951915e-01f, -6.40984401e-02f, -1.56596676e-01f,
  -1.79478392e-01f, 1.03861816e-01f, 3.53905648e-01f, -1.61407679e-01f, -1.61729783e-01f, 2.61483878e-01f, -1.53045222e-01f, -2.59207726e-01f, 4.34390247e-01f, -1.12729408e-01f,
  -1.19860778e-02f, -1.32921077e-02f, 8.55435617e-03f, 4.13575917e-01f, -2.00053737e-01f, -3.92456092e-02f, -1.53496951e-01f, 2.59820282e-01f, -1.87511072e-01f, 1.96707755e-01f,
  -4.60937023e-01f, -3.18869412e-01f, -2.77321815e-01f, -1.46401227e-01f, -2.46579409e-01f, -5.82392439e-02f, -6.94843456e-02f, -7.33231902e-02f, -1.01098672e-01f, 2.59379726e-02f,
  -1.24609634e-01f, 1.09017909e-01f, -5.32792360e-02f, 7.33437836e-02f, -2.51006503e-02f, -5.57894073e-02f, 6.01836219e-02f, -3.45978588e-02f, 4.80385534e-02f, 1.64706558e-01f,
  6.44210204e-02f, 2.57744770e-02f, -2.75073946e-01f, 3.06901392e-02f, -4.55901921e-02f, -6.64810166e-02f, -6.84846565e-02f, 4.02027145e-02f, 1.76970810e-02f, -1.53693199e-01f,
  7.71520808e-02f, 4.75652143e-03f, 4.78765741e-02f, -3.04359058e-03f, 7.12850168e-02f, -9.07379091e-02f, -1.08262420e-01f, 1.43420380e-02f, -4.09306996e-02f, -2.97465976e-02f,
  -8.32285434e-02f, -6.82461485e-02f, 1.01263031e-01f, -2.24227626e-02f, -1.23874687e-01f, -5.06465547e-02f, -5.85997812e-02f, 5.34551730e-03f, 7.86320399e-03f, 1.34881018e-02f,
  -2.37763263e-02f, 1.56719182e-02f, 2.93273721e-02f, -7.42209703e-02f, -1.29755348e-01f, 5.70707619e-02f, 1.05927810e-01f, 1.33041248e-01f, -8.45979378e-02f, 3.79362889e-03f,
  -3.50149035e-01f, -2.08583310e-01f, -1.11830503e-01f, -2.84565222e-02f, -1.47446617e-01f, -3.97762768e-02f, 9.43905488e-02f, -3.90997855e-03f, -4.90077659e-02f, -3.37343067e-02f,
  3.37216184e-02f, -5.86581305e-02f, -1.17773801e-01f, -1.41026601e-02f, -4.62686196e-02f, -7.46526662e-03f, -5.48090674e-02f, -2.48065568e-03f, -1.58948407e-01f, 9.41661894e-02f,
  -4.42789197e-02f, -1.39342891e-02f, 3.62347555e-03f, 8.65605772e-02f, -4.12031822e-02f, -1.83929697e-01f, 1.32254556e-01f, 2.14887634e-02f, 8.18230659e-02f, -1.73615851e-02f,
  3.66701156e-01f, 8.31750810e-01f, 7.90933132e-01f, 5.18166780e-01f, -2.27476016e-01f, -7.33105004e-01f, -3.88497919e-01f, 3.63311797e-01f, -1.88838631e-01f, -5.69079295e-02f,
  -2.76876301e-01f, 4.53368485e-01f, 1.12784363e-01f, 3.54049653e-01f, -2.55818903e-01f, -1.56129673e-01f, 7.23564625e-02f, 1.68714840e-02f, 3.87942865e-02f, 1.93730101e-01f,
  1.10300474e-01f, -2.56931901e-01f, 4.68723565e-01f, -1.39714420e-01f, 1.62505537e-01f, 4.87847090e-01f, 2.21800320e-02f, 1.32804304e-01f, 1.88109070e-01f, -2.45002612e-01f,
  -1.71865374e-01f, 1.49006113e-01f, 1.42654791e-01f, 1.19362408e-02f, -4.63329256e-02f, -2.28787772e-02f, 3.51241650e-03f, -5.20118475e-02f, -2.32751258e-02f, 6.16229586e-02f,
  4.82789194e-03f, 2.74056382e-02f, 7.24792033e-02f, -4.83157970e-02f, -6.82847649e-02f, 1.04028583e-01f, 1.32670283e-01f, 5.19644655e-03f, 1.12741061e-01f, 2.25255087e-01f,
  1.73237652e-01f, 1.57780856e-01f, -2.99847648e-02f, -2.08173655e-02f, 1.42023578e-01f, -9.24925040e-03f, 5.98361716e-02f, 3.85920927e-02f, 4.85384539e-02f, -1.36218918e-02f,
  7.53693329e-03f, -9.68203098e-02f, 1.07208088e-01f, 5.13523333e-02f, 1.13565452e-01f, -8.61555338e-02f, 7.96934664e-02f, -5.17592058e-02f, -8.11320916e-02f, -1.00309059e-01f,
  -1.89329218e-02f, 1.54762883e-02f, -4.67420854e-02f, -4.90482822e-02f, 7.02533051e-02f, 4.42884080e-02f, -8.43903199e-02f, 1.90986432e-02f, -5.35279810e-02f, 5.80875725e-02f,
  -2.13142019e-02f, -3.66680026e-02f, 1.61649808e-02f, -1.67640932e-02f, -7.78348967e-02f, 8.40846598e-02f, -1.76020022e-02f, 1.28671467e-01f, 7.60343065e-03f, -1.05234616e-01f,
  -6.44859970e-02f, 1.60623237e-01f, 4.71635982e-02f, 1.12977186e-02f, 1.70312393e-02f, -7.88073838e-02f, -1.43625721e-01f, 2.49388535e-02f, 1.03839701e-02f, -1.19072631e-01f,
  2.39963084e-02f, 4.94972840e-02f, -1.75283074e-01f, -3.33160236e-02f, -2.37825774e-02f, -8.04218277e-02f, -5.93737550e-02f, -3.32106426e-02f, 3.75845619e-02f, 1.10577397e-01f,
  3.01878266e-02f, -8.81001204e-02f, -5.55097498e-02f, -1.01544961e-01f, -5.16109355e-02f, 1.41664017e-02f, -6.89438581e-02f, 1.10661313e-01f, 2.98820827e-02f, -3.22499834e-02f,
  -3.01512927e-01f, -1.52466372e-01f, -1.07469425e-01f, -3.17228496e-01f, -3.97379790e-03f, -4.78762686e-01f, -3.53667647e-01f, -1.98229671e-01f, 8.12079385e-02f, -1.66069761e-01f,
  1.82585511e-02f, 6.23741234e-03f, 3.23885977e-01f, -3.78856719e-01f, 1.46546051e-01f, 2.18137175e-01f, -5.54452777e-01f, -1.92062333e-01f, 4.00972478e-02f, -4.08346951e-01f,
  -1.25185594e-01f, -3.31179559e-01f, 1.29766032e-01f, -7.27069378e-02f, -2.82798618e-01f, -7.90601671e-02f, 2.02309072e-01f, 6.25827909e-02f, -1.10960618e-01f, 1.70555323e-01f,
  -1.12386256e-01f, 2.88516341e-04f, -1.25700936e-01f, 1.22824587e-01f, -1.11338049e-01f, -8.17324370e-02f, -4.54160944e-02f, 2.08671406e-01f, 3.88495834e-03f, -8.17716345e-02f,
  -6.83323573e-03f, 1.65311903e-01f, -9.30987950e-03f, 1.72749851e-02f, -1.35551736e-01f, 3.24448533e-02f, 1.40360817e-01f, -1.37458652e-01f, -1.21146962e-02f, -3.80075760e-02f,
  2.64697126e-04f, 5.48425782e-03f, -6.03139065e-02f, 3.67078222e-02f, 7.04913512e-02f, 1.94440987e-02f, 2.05746107e-02f, 6.16681539e-02f, -1.31700173e-01f, -1.83843613e-01f,
  -6.82461485e-02f, -1.91222448e-02f, -1.07548453e-01f, 8.17069560e-02f, -7.17414543e-02f, 2.26295311e-02f, 1.51959853e-02f, 1.21939741e-01f, 3.41035053e-02f, -9.34882555e-03f,
  1.03125423e-01f, 2.07727626e-01f, -2.25715898e-02f, -1.63092151e-01f, -3.16297375e-02f, 1.16793383e-02f, 5.57106407e-03f, -6.39459863e-02f, -1.34125188e-01f, 7.89912641e-02f,
  -2.51644477e-02f, 1.55922603e-02f, 7.09798783e-02f, -1.22130960e-01f, -8.45359266e-03f, 1.11403413e-01f, -4.52975510e-03f, 2.94876564e-02f, 9.64537039e-02f, -9.35242176e-02f,
  -2.02718273e-01f, -1.26012743e-01f, 4.45488803e-02f, 3.99774015e-02f, 2.94460040e-02f, 1.17373560e-02f, -6.87075704e-02f, -1.26396462e-01f, 5.46075962e-02f, -1.07940175e-01f,
  -1.87133446e-01f, 8.82554799e-02f, -6.64991215e-02f, 3.41796577e-02f, 1.04393721e-01f, -1.60058171e-01f, -9.02475715e-02f, 4.09578085e-02f, -1.05626725e-01f, -7.52444342e-02f,
  -5.36844507e-02f, 3.88868488e-02f, 4.88965847e-02f, -9.72593669e-03f, -8.60383064e-02f, -3.27149406e-02f, -9.23293680e-02f, -1.10418173e-02f, -6.47590607e-02f, 6.34942949e-02f,
  1.09618707e-02f, -5.89832008e-01f, 5.62248349e-01f, 1.43685564e-02f, 3.41884673e-01f, 3.48501086e-01f, 7.31984794e-01f, -5.68438359e-02f, -2.31280044e-01f, -4.60554510e-01f,
  1.02132903e-02f, 1.06962230e-02f, 1.43918902e-01f, -1.77621678e-01f, 7.07441866e-01f, -5.30921482e-02f, -4.28535640e-02f, 1.70904845e-02f, -8.79267231e-02f, -1.37219936e-01f,
  -6.51890039e-02f, -2.18183860e-01f, 4.65835601e-01f, -3.54189396e-01f, 1.61963031e-01f, 1.76101942e-02f, 1.36653513e-01f, 4.30333942e-01f, -2.48325989e-01f, 1.47373945e-01f,
  -4.11785580e-03f, -1.44300848e-01f, -2.28353783e-01f, -1.00801654e-01f, 3.90597135e-02f, 5.35393395e-02f, 1.34539697e-02f, 3.31521034e-01f, 1.42955527e-01f, 6.37336150e-02f,
  -8.14475790e-02f, 2.75266748e-02f, -4.09301408e-02f, 1.54690802e-01f, 2.96054855e-02f, -7.53174424e-02f, 7.45418668e-02f, -4.83796522e-02f, -6.08275943e-02f, 6.64648712e-02f,
  -1.59257534e-03f, -6.97876327e-03f, -2.30126176e-02f, -1.67046353e-01f, 8.06262717e-02f, 2.61266828e-02f, -1.39055378e-03f, 1.25671729e-01f, -1.42646715e-01f, -4.97991554e-02f,
  -2.86042206e-02f, -2.06510630e-02f, 4.73250970e-02f, -6.39025941e-02f, -7.80954398e-03f, 4.92646731e-03f, 5.86844012e-02f, 2.46532597e-02f, 1.15874866e-02f, 2.05601864e-02f,
  2.07964946e-02f, 2.87479199e-02f, 6.34399280e-02f, -5.87295257e-02f, -1.01937950e-02f, -1.17783360e-01f, -2.83014914e-03f, -6.54843524e-02f, 2.51561496e-03f, -5.20579033e-02f,
  -3.73417437e-02f, 5.10656126e-02f, 4.45293039e-02f, 3.44210267e-02f, 3.21109779e-02f, 1.00164793e-01f, -7.56317228e-02f, -1.35229295e-02f, 7.28769302e-02f, 5.93228973e-02f,
  -6.03033304e-01f, -5.77371240e-01f, -2.46696435e-02f, -6.90255538e-02f, 3.34914513e-02f, -7.82517791e-02f, -4.53947075e-02f, -2.52743244e-01f, -3.05944234e-02f, -2.38419324e-02f,
  -1.55750304e-01f, 2.11034771e-02f, -4.23977897e-02f, -1.12301167e-02f, -1.00491732e-01f, 3.39149684e-02f, -5.87784052e-02f, -1.11837417e-01f, -1.18062325e-01f, -3.23105603e-02f,
  -4.95038517e-02f, 7.97335580e-02f, 2.25860141e-02f, -1.08062826e-01f, -1.92930996e-01f, 7.55654573e-02f, -1.08316146e-01f, 9.61224269e-03f, 8.05582628e-02f, 2.16182861e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  3.86153251e-01f, 1.06452793e-01f, 7.09622622e-01f, 3.39955926e-01f, 1.11243809e-02f, 3.43179256e-01f, 4.85196471e-01f, -5.71385100e-02f, 1.01323567e-01f, 8.06131601e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -6.50172308e-02f, -1.73866138e-01f, 6.50742203e-02f, 5.29538155e-01f, -4.10997927e-01f, -5.60053408e-01f, 3.16353917e-01f, -4.29893374e-01f, -2.81975865e-01f, -4.07738626e-01f,
  -9.69506055e-03f, 2.61948615e-01f, -2.18781799e-01f, 4.15060371e-01f, -3.41451228e-01f, 2.75363863e-01f, 1.54761285e-01f, 2.25906760e-01f, 3.33235919e-01f, 5.81755161e-01f,
  1.25056744e-01f, -7.41709709e-01f, 3.19384098e-01f, -4.37200099e-01f, -3.18358317e-02f, -2.99845785e-01f, -6.21260926e-02f, 5.46244532e-02f, -1.41392678e-01f, -5.29710233e-01f,
  -4.10949856e-01f, 4.12753850e-01f, 1.64209485e-01f, -3.34501892e-01f, 3.06216460e-02f, -4.04965818e-01f, -9.19745713e-02f, 9.81302634e-02f, -3.36612016e-01f, 4.31934178e-01f,
  -1.72934219e-01f, -3.90634805e-01f, 4.80920643e-01f, -9.26130414e-02f, -8.91203135e-02f, -2.37145871e-01f, 2.43111968e-01f, 2.36088634e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.88183141e-01f, 5.52524209e-01f, 6.78501308e-01f, 4.10402119e-01f, -7.96068430e-01f, -8.44728053e-01f, 9.30779397e-01f, -2.03808844e-01f, 7.36597776e-01f, -2.94015594e-02f,
  -5.35502732e-01f, 1.60866871e-01f, 5.51922739e-01f, 6.40919685e-01f, -3.36290389e-01f, -4.20517568e-03f, 3.48091304e-01f, 8.63784492e-01f, 2.70984888e-01f, -6.26393557e-01f,
  7.75270820e-01f, 2.48456538e-01f, 2.49604687e-01f, 9.24623489e-01f, 3.79705906e-01f, 5.23710847e-01f, -5.77517636e-02f, -4.60002050e-02f, 7.67523944e-01f, -6.17934525e-01f,
  1.76095009e-01f, 8.58352840e-01f, 6.03579637e-03f, 5.82350075e-01f, -2.47937575e-01f, 2.88449913e-01f, 4.34495211e-01f, 2.52804160e-01f, -3.22129786e-01f, 5.58206260e-01f,
  -1.37465701e-01f, 5.96334040e-01f, 6.53127968e-01f, 8.76838982e-01f, -5.22057489e-02f, 1.34776030e-02f, 6.23968422e-01f, 2.75527596e-01f, 3.50304633e-01f, 7.31529534e-01f,
  -2.87901074e-01f, -5.49784064e-01f, 6.70661211e-01f, 1.10332382e+00f, -2.53194332e-01f, 6.04502559e-01f, 2.19251648e-01f, 7.16992557e-01f, 5.76349378e-01f, 5.58706820e-01f,
  4.31978732e-01f, 4.58912224e-01f, 2.04025209e-01f, -4.04474825e-01f, 3.46880794e-01f, 6.07951880e-01f, 2.75394134e-02f, 6.59546614e-01f, 3.58664036e-01f, -8.47713426e-02f,
  -9.52040792e-01f, -7.80299127e-01f, 8.00433904e-02f, 2.55935878e-01f, -1.06629491e+00f, 6.33930385e-01f, -2.39740968e-01f, -3.98548186e-01f, -1.03521073e+00f, 3.50816883e-02f,
  2.31702536e-01f, 5.48381925e-01f, -4.22623277e-01f, 1.04608572e+00f, 1.31634310e-01f, -2.26187974e-01f, 1.33857340e-01f, -5.21210790e-01f, 8.18627998e-02f, 2.04354525e-01f,
  3.77002060e-01f, 4.55066174e-01f, -2.39088356e-01f, -6.03180051e-01f, -4.48722452e-01f, 5.35089314e-01f, 6.45859718e-01f, 7.49523520e-01f, 1.20494336e-01f, -3.23442221e-01f,
  9.87481713e-01f, 2.65138745e-01f, -6.86308086e-01f, -4.10325766e-01f, 6.23395562e-01f, -6.77311599e-01f, -9.56124663e-01f, -1.05009871e-02f, 7.75789738e-01f, -2.46329591e-01f,
  -6.87568069e-01f, 3.26791108e-01f, 2.90491670e-01f, 6.16614878e-01f, 7.55715072e-01f, 7.71484256e-01f, -7.75129274e-02f, -7.33042598e-01f, 5.63223898e-01f, -2.22555488e-01f,
  1.79309174e-01f, 1.14926681e-01f, -1.87263221e-01f, 6.15932703e-01f, -1.05689958e-01f, 5.89942932e-01f, -2.80833364e-01f, 8.89733374e-01f, 2.51984894e-01f, -2.76445858e-02f,
  1.97625592e-01f, 3.07163328e-01f, -5.64883888e-01f, -3.11132371e-01f, -1.02985285e-01f, -5.91298819e-01f, -9.57283452e-02f, 2.81509280e-01f, 1.09706804e-01f, 4.40215260e-01f,
  -2.71751553e-01f, 9.30155337e-01f, -3.42014074e-01f, -2.56832838e-01f, 3.67342651e-01f, -1.93060756e-01f, 7.66345620e-01f, -3.46333653e-01f, -2.64915496e-01f, -3.25799793e-01f,
  7.62407362e-01f, 1.80626996e-02f, 9.38461363e-01f, -3.88873309e-01f, 5.32742560e-01f, 6.51967600e-02f, 9.00347531e-01f, -6.58399045e-01f, 9.41275179e-01f, -1.66662559e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  4.22260046e-01f, 6.92434490e-01f, 2.77539670e-01f, 4.08001751e-01f, 8.60643566e-01f, 4.60673302e-01f, 1.03244340e+00f, 4.86960828e-01f, 3.31997901e-01f, -1.37200877e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.49639684e-01f, -2.15374887e-01f, -7.87156969e-02f, 4.20885384e-01f, -2.04163596e-01f, -9.43699107e-02f, 2.52799541e-01f, -2.84255922e-01f, -2.97655493e-01f, -9.79712233e-02f,
  2.29905218e-01f, -2.04237998e-02f, 1.21680088e-01f, 2.38810331e-01f, 1.05934709e-01f, 2.45399345e-02f, 2.47311652e-01f, 1.85881242e-01f, 4.54288632e-01f, -5.34403086e-01f,
  1.15783080e-01f, -1.21909566e-01f, 1.57332644e-01f, 1.28005501e-02f, -3.17820936e-01f, 1.09841637e-01f, 2.77302742e-01f, 4.90017980e-01f, 3.28228980e-01f, -2.47304574e-01f,
  -1.54187396e-01f, 3.08108479e-02f, -2.61499196e-01f, -4.80565369e-01f, -4.06414956e-01f, 2.18598813e-01f, 2.61176050e-01f, -4.64072675e-02f, -8.63943025e-02f, 2.14581430e-01f,
  3.63274276e-01f, -3.54032934e-01f, -6.02617748e-02f, 1.70287564e-01f, -1.39655471e-01f, -3.07939678e-01f, -6.68840930e-02f, -1.60611540e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  5.64940929e-01f, -2.50977576e-01f, 2.37701863e-01f, 1.54556453e-01f, 6.24351323e-01f, -4.42439854e-01f, 1.11286044e+00f, 3.89754623e-01f, -9.34185207e-01f, -5.57553113e-01f,
  -4.81647193e-01f, -6.04480624e-01f, 4.34900582e-01f, 8.47042322e-01f, 2.64967442e-01f, 5.87084115e-01f, -5.00056922e-01f, -3.65989596e-01f, 2.73516387e-01f, 8.83514285e-02f,
  -5.03398061e-01f, 3.85708004e-01f, -2.75162101e-01f, 6.15195692e-01f, 1.01946004e-01f, 4.28778708e-01f, -6.02229536e-01f, -8.57317388e-01f, -4.68792319e-01f, -6.08563542e-01f,
  -4.23992038e-01f, -5.83696723e-01f, 4.79825705e-01f, 1.69941261e-01f, 8.79029334e-01f, -4.05429244e-01f, 3.62803400e-01f, 7.79371142e-01f, -4.59725529e-01f, 9.55030262e-01f,
  2.12211773e-01f, 3.31705600e-01f, 5.87354116e-02f, 2.82680035e-01f, 1.13607895e+00f, 3.90666485e-01f, -9.56456900e-01f, -4.61714864e-01f, 5.82964085e-02f, -6.04105353e-01f,
  7.10750893e-02f, 9.40484762e-01f, 6.51850998e-01f, -3.74587983e-01f, 1.05540419e+00f, 1.26850009e-01f, -6.18751459e-02f, -2.04871953e-01f, 6.49971217e-02f, -6.04977384e-02f,
  3.80208269e-02f, 1.05786824e+00f, 3.57220113e-01f, 4.83962417e-01f, -1.48551568e-01f, 8.38424504e-01f, -2.62057632e-01f, -5.15265465e-01f, -1.12700999e+00f, -2.02138543e-01f,
  -1.10829279e-01f, -2.02945426e-01f, 5.37692070e-01f, 8.34058821e-01f, 6.25090659e-01f, -1.12067953e-01f, -2.97406819e-02f, -8.30950812e-02f, 6.03306413e-01f, 4.53508615e-01f,
  -3.52731019e-01f, 4.00613070e-01f, 5.51194787e-01f, 2.72876501e-01f, -5.95477939e-01f, -2.83030570e-01f, 4.67938334e-01f, -3.50178242e-01f, 3.93636793e-01f, 8.50676477e-01f,
  5.51085174e-01f, -2.21501127e-01f, -4.61560845e-01f, 4.77250576e-01f, 1.09582293e+00f, -6.67607069e-01f, 5.75843453e-01f, -3.33296955e-02f, 6.08441293e-01f, 6.86202109e-01f,
  1.06568074e+00f, -8.09841335e-01f, 5.44876635e-01f, -1.93817735e-01f, -1.62411422e-01f, -7.64390886e-01f, 8.96590650e-01f, 3.69087070e-01f, 5.90073347e-01f, 3.43965203e-01f,
  8.26597884e-02f, -3.37448984e-01f, 6.43653512e-01f, 4.12128419e-01f, 7.24289775e-01f, -1.47701710e-01f, 3.05729687e-01f, -1.74726069e-01f, -1.16912767e-01f, 4.82665628e-01f,
  6.41013026e-01f, 3.86627197e-01f, 1.06062829e+00f, 9.16846335e-01f, 7.33777165e-01f, 4.36443239e-01f, 1.77747130e-01f, -6.10875428e-01f, -3.45947146e-01f, 8.53717387e-01f,
  4.99811769e-01f, -8.81456554e-01f, -4.71244603e-01f, 3.03820401e-01f, 2.23959476e-01f, 6.53119147e-01f, 7.07869902e-02f, 6.71123028e-01f, 5.84719218e-02f, -8.59414637e-01f,
  8.61764193e-01f, -5.96422493e-01f, -4.23451096e-01f, 8.62553060e-01f, -2.65771806e-01f, -7.36087859e-01f, -1.11673725e+00f, 1.12601385e-01f, 1.11894570e-01f, 1.01060763e-01f,
  1.44961253e-01f, 5.77277839e-01f, 1.08665490e+00f, 6.91627800e-01f, -2.57849991e-01f, 1.83165401e-01f, -9.36779797e-01f, 2.92327166e-01f, -2.69011647e-01f, 5.95664799e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  4.05834377e-01f, 2.19096318e-01f, 3.76658648e-01f, 2.48129293e-01f, 4.00927126e-01f, 3.16200435e-01f, 2.48432010e-01f, 2.78389513e-01f, 5.19415438e-01f, -2.95264255e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -3.68158847e-01f, 2.75042802e-01f, 1.58725053e-01f, 3.38687263e-02f, -5.15947819e-01f, 3.05791438e-01f, -6.49001539e-01f, 1.21682382e+00f, 3.27509731e-01f, -5.90380132e-01f,
  -2.93662310e-01f, 1.86481521e-01f, -5.81199676e-02f, -4.83866245e-01f, 7.67103359e-02f, 4.04661119e-01f, -2.98873782e-01f, 1.01133220e-01f, 3.71706396e-01f, -6.43630862e-01f,
  5.15926778e-01f, -1.32728532e-01f, -6.22076511e-01f, -7.04776406e-01f, -2.72499502e-01f, -9.78603303e-01f, 3.98110241e-01f, 3.63782495e-01f, -8.87765169e-01f, 2.51292408e-01f,
  -2.96947926e-01f, 3.49635273e-01f, 2.11546794e-01f, 3.63004416e-01f, 5.38596392e-01f, 2.92500943e-01f, -3.20141464e-01f, 1.52645335e-01f, -9.25231695e-01f, 3.28346223e-01f,
  -4.74451452e-01f, 2.92619914e-01f, -1.43337488e-01f, 1.98929161e-01f, 5.34271419e-01f, 4.19237763e-01f, -7.16674566e-01f, -2.77763784e-01f, 3.36914092e-01f, -4.27684933e-01f,
  -3.61471064e-02f, 4.01006639e-01f, 6.38191449e-03f, 6.84924185e-01f, 3.32617283e-01f, -2.11201429e-01f, -4.91682202e-01f, 3.04472893e-01f, -2.90382765e-02f, -5.68688810e-01f,
  -8.05568218e-01f, -1.63856936e+00f, 5.27527809e-01f, -4.40749936e-02f, 2.20936723e-02f, -2.45428994e-01f, -1.51421249e-01f, -4.18032318e-01f, 3.24849904e-01f, -5.13515472e-01f,
  1.95882961e-01f, -5.52926421e-01f, 4.61227536e-01f, -6.25693873e-02f, -4.16581422e-01f, -7.84793556e-01f, 5.55509254e-02f, -2.89943635e-01f, 5.18746674e-01f, -3.96121927e-02f,
  4.38744277e-01f, -2.26823464e-01f, -1.59098759e-01f, -4.22173232e-01f, 3.69774669e-01f, -7.18698084e-01f, -8.21745336e-01f, -1.58522446e-02f, 7.24232078e-01f, -9.76623654e-01f,
  4.38008681e-02f, -1.98329031e-01f, -7.09782448e-03f, 4.09314990e-01f, 5.95021605e-01f, -1.06285214e+00f, -7.26081710e-03f, -2.97739893e-01f, 5.42130172e-01f, 5.65438390e-01f,
  3.97222340e-01f, -1.81180179e-01f, 1.44968480e-01f, 9.12403595e-03f, 2.68708289e-01f, 2.70925939e-01f, -7.63396621e-01f, -6.38973534e-01f, 7.93199003e-01f, 4.18558598e-01f,
  -5.08182406e-01f, -1.24487126e+00f, 2.13587824e-02f, 2.10238874e-01f, 2.15499729e-01f, -5.02087884e-02f, -8.15177977e-01f, 9.47322845e-02f, -4.60962892e-01f, -4.89017516e-01f,
  -7.10174620e-01f, -3.43502700e-01f, 5.10700941e-01f, -5.93542814e-01f, -3.65327001e-01f, -1.06534624e+00f, 5.46457291e-01f, 5.42993844e-01f, -1.40841084e-03f, -3.37607682e-01f,
  -7.34200418e-01f, 2.37024471e-01f, -8.12992036e-01f, 2.62923002e-01f, -4.62113470e-01f, 1.10864222e-01f, -1.31654286e+00f, 2.24791631e-01f, 4.52650875e-01f, 3.64076823e-01f,
  -7.80704677e-01f, 5.28224967e-02f, -8.75377715e-01f, 1.93699077e-01f, 2.95675278e-01f, 3.97220224e-01f, 2.48711333e-01f, -4.30966288e-01f, -9.93226916e-02f, 5.67272842e-01f,
  -3.21854115e-01f, -2.48218507e-01f, 6.16830111e-01f, 1.19731329e-01f, -9.07063663e-01f, -7.68634975e-01f, -4.76386011e-01f, 7.10989833e-02f, -8.32356691e-01f, 6.09565854e-01f,
  -3.10638785e-01f, 3.91533285e-01f, -2.82098979e-01f, 2.54703283e-01f, -6.82940409e-02f, -2.20519423e-01f, 4.48977113e-01f, 3.15984935e-01f, -7.49055982e-01f, 4.53462541e-01f,
  -9.65672553e-01f, -6.01248503e-01f, 1.45313784e-01f, -4.50421751e-01f, -4.38506246e-01f, 5.38090110e-01f, 2.09892970e-02f, 2.94879854e-01f, -5.37669539e-01f, 4.09844577e-01f,
  -4.48969692e-01f, -3.30619752e-01f, 4.39946443e-01f, -4.44377363e-01f, -7.29715526e-01f, 4.04035538e-01f, -2.89823383e-01f, 6.09043956e-01f, 2.93382168e-01f, -3.55253875e-01f,
  -4.55424756e-01f, -1.15608871e+00f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -4.11585672e-03f, 9.01865214e-02f, -1.08117491e-01f, -2.81890333e-01f, -1.10241733e-02f, 8.80091786e-02f, 9.03415009e-02f, -8.41681957e-02f, -1.70166701e-01f, 1.29824221e-01f,
  -2.50869483e-01f, 4.01585847e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    