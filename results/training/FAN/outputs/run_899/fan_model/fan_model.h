/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.33964524e-01f, -1.71901092e-01f, -8.87720510e-02f, -9.56760570e-02f, 6.44766837e-02f, 2.82131601e-03f, 2.45595351e-02f, -4.52162363e-02f, -1.81271825e-02f, 4.01926460e-03f,
  4.07569930e-02f, 6.56579435e-03f, -3.64447758e-02f, -1.04821660e-02f, -5.63917868e-02f, -1.05968818e-01f, -2.71673631e-02f, 7.40606636e-02f, 4.62445021e-02f, 1.84562569e-03f,
  4.83266003e-02f, 8.91808569e-02f, -1.12162940e-02f, 6.58056587e-02f, -4.35255840e-02f, 8.41277987e-02f, -7.92108104e-02f, -6.02786168e-02f, -8.38589519e-02f, 1.15592532e-01f,
  -1.77426741e-01f, 2.13500746e-02f, -1.74310412e-02f, -1.88548695e-02f, -5.03591970e-02f, 5.64261153e-02f, -5.54519482e-02f, 3.80583829e-03f, 5.99329881e-02f, -6.02150224e-02f,
  8.42682049e-02f, -1.45804286e-02f, -6.25663176e-02f, 3.47339213e-02f, -5.47584407e-02f, -7.88501725e-02f, -1.01107128e-01f, 1.97363794e-02f, -5.00669219e-02f, 3.73134539e-02f,
  1.16272576e-01f, -3.02652568e-02f, -1.65459812e-01f, -9.18449238e-02f, 7.61074647e-02f, 5.51331835e-03f, -1.42384022e-01f, 8.83958675e-03f, -1.59052804e-01f, -1.90526649e-01f,
  -4.24781106e-02f, 9.58019570e-02f, -7.63939098e-02f, -8.31463337e-02f, 3.02502383e-02f, 1.33980410e-02f, 3.14940955e-03f, -8.02660547e-03f, -4.05077711e-02f, -5.17095253e-02f,
  3.15314680e-02f, 9.61102545e-02f, 4.35945317e-02f, -7.96009228e-03f, 5.93202538e-04f, -2.53011491e-02f, 1.09771974e-01f, 2.78513841e-02f, -6.81081340e-02f, 1.05167113e-01f,
  3.25202495e-02f, -4.17183340e-02f, 4.85640429e-02f, 8.47648755e-02f, 6.73434436e-02f, -8.06537271e-02f, 7.82668218e-02f, -2.10767165e-02f, -1.16982207e-01f, -1.05420239e-01f,
  -2.05693603e-01f, -4.73001599e-03f, 4.59604971e-02f, -1.69779770e-02f, 1.83664802e-02f, -2.52899174e-02f, -1.07005583e-02f, -3.21051106e-02f, 7.37333819e-02f, -3.60823460e-02f,
  2.02193856e-02f, -5.32329232e-02f, -9.55752656e-02f, 3.93653922e-02f, -4.39537689e-03f, 4.31460477e-02f, -6.87105581e-02f, -4.24956903e-02f, 4.95969690e-02f, 5.67277297e-02f,
  -9.67692211e-02f, 1.69607252e-02f, -6.38910681e-02f, 1.94906332e-02f, 9.85594466e-02f, -7.49053434e-02f, -3.02249920e-02f, -3.38668078e-02f, -2.22810358e-01f, -3.00882459e-01f,
  6.46814048e-01f, -3.67253236e-02f, -4.03645039e-02f, 2.73706138e-01f, -2.41252575e-02f, -1.14547998e-01f, -9.51171070e-02f, 9.52454433e-02f, 1.07351176e-01f, -6.67957962e-02f,
  -1.58536881e-01f, -1.12782545e-01f, -1.06095728e-02f, -9.59304199e-02f, -4.14979979e-02f, 2.07200553e-02f, -7.74554759e-02f, 2.56201942e-02f, 8.24113563e-02f, -5.97918145e-02f,
  -3.46412137e-02f, 1.09297909e-01f, 2.88992554e-01f, 2.28142887e-02f, -6.24453425e-02f, -4.96159419e-02f, -7.77572617e-02f, 4.38299365e-02f, -1.34259373e-01f, -8.58513042e-02f,
  -2.28530198e-01f, 7.90041089e-02f, -7.35751465e-02f, 5.53085245e-02f, -8.43203366e-02f, 2.98055215e-03f, -1.09756766e-02f, -2.38971934e-02f, 7.43721947e-02f, 2.79365573e-02f,
  -6.50652945e-02f, 5.72413355e-02f, 4.74181660e-02f, -3.82572673e-02f, 3.50524746e-02f, 4.49736305e-02f, -3.28917158e-05f, 1.03552036e-01f, 7.26613961e-03f, -1.69385690e-02f,
  -1.58432961e-01f, 4.34714705e-02f, 4.03903015e-02f, -4.17251438e-02f, 4.29804213e-02f, -6.34148791e-02f, 3.67057398e-02f, 2.75144214e-03f, -4.10640016e-02f, 8.43759850e-02f,
  4.39521521e-02f, -5.41322380e-02f, -5.04810661e-02f, 5.27239107e-02f, 3.89556885e-02f, -2.45349500e-02f, -4.14591692e-02f, 5.85834263e-03f, 1.83389913e-02f, 7.37259630e-03f,
  1.07123293e-02f, -1.47416918e-02f, 4.70484927e-04f, 7.45584220e-02f, -5.35032339e-02f, -2.65570190e-02f, 5.60079850e-02f, 2.63843331e-02f, -1.37590161e-02f, 5.54292202e-02f,
  2.09297296e-02f, -3.18097211e-02f, 5.13124466e-02f, 3.43477614e-02f, -2.57548373e-02f, -2.52653044e-02f, 2.93010008e-03f, -9.26100016e-02f, -8.16846266e-02f, 1.51681630e-02f,
  4.85962033e-02f, -1.34108245e-01f, 4.42591347e-02f, -4.45115827e-02f, 1.11854143e-01f, -1.17034363e-02f, 7.82944486e-02f, 3.32606249e-02f, 7.68489987e-02f, 7.23227933e-02f,
  8.59848782e-03f, 1.15677714e-01f, 3.19699608e-02f, -3.05202138e-03f, 9.27615836e-02f, 3.56882140e-02f, 1.68164987e-02f, -2.09534378e-03f, -5.81259876e-02f, -2.89521012e-02f,
  -1.00948417e-03f, 1.00926057e-01f, 6.95474371e-02f, 1.25153351e-03f, -8.66178498e-02f, 6.28481731e-02f, -3.86512317e-02f, -3.77414376e-02f, 1.21486010e-02f, 2.47976616e-01f,
  6.70402572e-02f, -6.40301853e-02f, -1.22023582e-01f, 8.12529698e-02f, -1.40372589e-01f, -6.00944385e-02f, -2.71376848e-01f, -4.29925919e-02f, 1.69830490e-02f, -8.59071091e-02f,
  -7.08982125e-02f, 2.51915336e-01f, 1.32794276e-01f, 1.49995506e-01f, 5.10635376e-02f, -1.75891846e-01f, -1.80772498e-01f, 4.51742634e-02f, 7.67246038e-02f, 9.64509696e-03f,
  1.81458090e-02f, 1.04970653e-02f, 1.33930892e-01f, 6.35185018e-02f, -6.72286842e-03f, 1.07721992e-01f, 1.36786699e-02f, 4.63187173e-02f, -2.82459948e-02f, -5.26662974e-04f,
  2.26296484e-02f, -8.98415223e-02f, -4.28048298e-02f, 6.74624816e-02f, 3.71512678e-03f, -5.27097546e-02f, 2.86851265e-02f, -7.46513605e-02f, -4.64614369e-02f, 5.90708964e-02f,
  2.44832169e-02f, 5.84729649e-02f, 7.06086680e-02f, -3.16790156e-02f, -2.56303768e-03f, -1.98033024e-02f, 5.02866469e-02f, -3.87867466e-02f, 4.87960279e-02f, 9.80516151e-03f,
  5.99277653e-02f, -1.08245658e-02f, 2.34825108e-02f, 2.54093204e-03f, -3.90272178e-02f, 1.49674445e-01f, -6.37536868e-02f, 8.03911611e-02f, 5.33035025e-02f, 5.93918301e-02f,
  7.28468448e-02f, -6.76655397e-02f, 2.88872477e-02f, 4.33937088e-02f, 1.69813130e-02f, 8.04283768e-02f, -2.13691983e-02f, -5.91031648e-02f, 7.13490322e-02f, -2.72545218e-03f,
  7.69250616e-02f, 4.95865615e-03f, -5.79589643e-02f, -2.08107568e-02f, -7.60156959e-02f, -1.83664858e-02f, -1.06058372e-02f, -4.18461747e-02f, 5.87223656e-02f, -1.57978125e-02f,
  9.72501785e-02f, 1.95220746e-02f, -3.54736298e-03f, 4.27947305e-02f, -2.19033728e-03f, 6.97754845e-02f, -7.16078132e-02f, 6.12015910e-02f, -4.54601310e-02f, 1.25505980e-02f,
  1.28618374e-01f, 8.29018354e-02f, -6.39585182e-02f, 3.17445286e-02f, 1.80593878e-02f, 3.85583541e-03f, -8.30111578e-02f, 4.63542454e-02f, -5.96874356e-02f, -2.15946604e-02f,
  -3.57929803e-02f, -5.54517284e-02f, -9.29993615e-02f, 5.26299933e-03f, 1.78303234e-02f, 4.26387787e-02f, -3.25874276e-02f, 5.71589097e-02f, -6.15994148e-02f, -5.78497835e-02f,
  3.15592960e-02f, -7.90997595e-03f, 1.61811449e-02f, 4.99843098e-02f, 2.07205359e-02f, 3.83009501e-02f, 4.79244553e-02f, -6.27785921e-02f, 1.62600316e-02f, -1.58257306e-01f,
  2.33324468e-02f, -3.17539126e-02f, 7.18698949e-02f, -4.60668016e-05f, -8.28726143e-02f, -8.53538290e-02f, -7.99454376e-02f, -4.52427454e-02f, -2.78866962e-02f, -1.34755477e-01f,
  -3.10244597e-02f, 1.33060917e-01f, -2.28320621e-02f, 1.01984553e-01f, 3.34096365e-02f, -6.93139583e-02f, -9.83025432e-02f, 5.04191928e-02f, 2.10686341e-01f, -2.23837746e-03f,
  -4.71471660e-02f, -5.27772047e-02f, 4.20547239e-02f, 6.45610839e-02f, -1.08269483e-01f, -9.16224942e-02f, -1.29012048e-01f, -9.32997316e-02f, -1.07064039e-01f, -2.06146747e-01f,
  -6.35973066e-02f, -2.96180882e-02f, -4.00586501e-02f, -1.69537012e-02f, -4.27886359e-02f, -3.43306898e-03f, 4.88949381e-02f, 5.80135211e-02f, 5.88814728e-02f, -7.39871860e-02f,
  -3.51873599e-02f, 4.37127277e-02f, -2.86888033e-02f, -4.86570783e-02f, 6.20607622e-02f, -1.14049176e-02f, -4.81603853e-02f, -2.51023807e-02f, 9.94158238e-02f, -7.96499848e-02f,
  -1.01044979e-02f, -1.03573695e-01f, -1.84402224e-02f, -1.16443321e-01f, -5.20108230e-02f, 9.34164599e-03f, -3.61053050e-02f, -5.85125647e-02f, -7.79615268e-02f, -1.65905923e-01f,
  -1.93032771e-02f, -4.24870998e-02f, -3.51692513e-02f, -1.57570690e-02f, -3.58928517e-02f, 8.31429614e-04f, 1.14397947e-02f, 5.26520088e-02f, 3.27871405e-02f, 6.69480208e-03f,
  -2.14377549e-02f, -5.93701191e-03f, -6.01115152e-02f, -1.91419479e-02f, -5.06103225e-02f, -4.65233810e-02f, -1.77927855e-02f, -1.15305297e-01f, -1.18013918e-02f, 2.40830760e-02f,
  -3.22378017e-02f, 7.71045908e-02f, -6.90445453e-02f, 7.10499436e-02f, -5.17365076e-02f, 4.41694222e-02f, -3.44716758e-02f, -3.62905907e-03f, 9.01603028e-02f, -7.40515953e-03f,
  -1.40632182e-01f, 1.32498354e-01f, -4.71742079e-03f, 6.00156449e-02f, 9.27850977e-02f, -3.08344979e-02f, -8.79863277e-02f, 7.61590973e-02f, 5.90390563e-02f, 4.13272604e-02f,
  -3.07066143e-02f, -2.10127123e-02f, -3.02174557e-02f, -7.11602122e-02f, 9.38870460e-02f, -4.01922129e-02f, -6.82415348e-03f, 5.48288524e-02f, 2.46660560e-02f, 6.57469481e-02f,
  -1.09989736e-02f, -3.58498394e-02f, -1.60648562e-02f, -7.73526579e-02f, -8.57324153e-02f, 5.87193295e-02f, -3.30614336e-02f, -7.74591044e-02f, -6.04741797e-02f, -2.24930689e-01f,
  -4.26973365e-02f, -2.62265295e-01f, -3.53740871e-01f, 1.06222048e-01f, 1.44129530e-01f, 8.39247853e-02f, 1.10546373e-01f, 8.21215585e-02f, 1.45347893e-01f, -1.14922293e-01f,
  -5.06450757e-02f, 1.37291044e-01f, 1.96040086e-02f, 1.18606962e-01f, 8.20522010e-02f, -4.86974008e-02f, -4.04375158e-02f, 3.60935256e-02f, 1.27205759e-01f, 2.36737192e-01f,
  4.44014780e-02f, 3.93508561e-02f, -1.77493885e-01f, 2.66827438e-02f, -3.15472716e-03f, 1.95452318e-01f, -1.71833262e-01f, -1.92711592e-01f, -3.18426713e-02f, -1.69858858e-01f,
  -1.06384151e-01f, -3.52607280e-01f, 6.36940151e-02f, 7.27455914e-02f, -1.31177977e-01f, -2.67045721e-02f, -2.42121052e-02f, 4.37030895e-03f, -6.51909113e-02f, -1.22965030e-01f,
  -1.12244286e-01f, 5.01431599e-02f, -3.87139767e-02f, 4.41331863e-02f, 5.77434860e-02f, -3.78858820e-02f, -1.00151151e-01f, -1.14916071e-01f, -1.70563757e-01f, -2.66861562e-02f,
  -6.64534643e-02f, -2.87332963e-02f, -1.00033969e-01f, -7.18002394e-02f, -4.71761860e-02f, 6.49477765e-02f, -8.96226764e-02f, -9.82838795e-02f, -1.51611492e-01f, -7.80721158e-02f,
  7.28937015e-02f, -5.90413325e-02f, 6.23560045e-03f, -2.14203298e-02f, 3.92805003e-02f, 1.67281553e-02f, -4.68885712e-03f, 8.65622386e-02f, -5.83482254e-03f, 1.61792077e-02f,
  -3.78619581e-02f, 1.01100253e-02f, -1.80232655e-02f, -5.09329773e-02f, -1.50635112e-02f, 2.52690655e-03f, 4.57619764e-02f, -5.39821722e-02f, 4.92373435e-03f, 7.42637645e-03f,
  -3.44137959e-02f, -7.15794787e-02f, -5.22307158e-02f, 6.30112514e-02f, -1.11276053e-01f, 1.72271449e-02f, 2.43488867e-02f, 5.18271234e-03f, 1.72185209e-02f, 7.92523250e-02f,
  1.64466858e-01f, -1.71235025e-01f, 8.96339118e-02f, 3.38796079e-02f, 2.12896708e-02f, -6.40480146e-02f, 2.66940612e-02f, -9.55965817e-02f, 1.95437437e-03f, -1.12508778e-02f,
  -5.70127890e-02f, 8.02963879e-03f, -2.01696921e-02f, -1.17119923e-01f, 2.30178814e-02f, 1.15633860e-01f, 6.36223480e-02f, 1.07157685e-01f, -1.66327041e-02f, -8.52298923e-03f,
  -2.18971577e-02f, 1.79914653e-01f, 1.75747260e-01f, 1.53544158e-01f, 2.44960468e-02f, 2.22000375e-01f, 1.88693687e-01f, 1.06954440e-01f, 9.44915563e-02f, 3.20873111e-01f,
  8.25251713e-02f, 1.88250378e-01f, -4.18731533e-02f, 1.09856792e-01f, 4.11507748e-02f, 1.78934373e-02f, 2.48024479e-01f, -1.01192430e-01f, -9.85790640e-02f, 6.31497353e-02f,
  -8.27127099e-02f, -2.45660558e-01f, -1.99785635e-01f, -2.26741850e-01f, -5.61540723e-02f, 1.49320543e-01f, 1.98482648e-01f, -9.50439498e-02f, -2.34528825e-01f, -1.45074338e-01f,
  -7.55636245e-02f, -4.06351648e-02f, -2.79784426e-02f, -4.14964408e-02f, 2.05260858e-01f, -8.74633715e-02f, 9.71540213e-02f, 1.38556063e-01f, 5.88488355e-02f, 2.41934627e-01f,
  1.23147488e-01f, 4.25493009e-02f, -3.44543755e-02f, 2.07630545e-02f, -7.03093549e-03f, -1.70825217e-02f, 2.57913824e-02f, -2.75865104e-02f, -7.36280810e-03f, -7.19664246e-02f,
  8.32043737e-02f, -6.32408708e-02f, -4.18601595e-02f, -1.11791370e-02f, -6.65083453e-02f, -5.46075255e-02f, 1.77714918e-02f, -4.83142547e-02f, -1.12210065e-01f, -7.18234107e-02f,
  8.52091983e-02f, 1.19566508e-01f, 5.76640591e-02f, -1.18599217e-02f, 5.40114008e-03f, 6.30483329e-02f, 8.17155000e-03f, 1.84411481e-02f, -2.59990525e-02f, 1.14430673e-01f,
  -2.63137091e-02f, 1.58094969e-02f, 4.95905764e-02f, 6.43959418e-02f, 6.41587898e-02f, 7.54883233e-03f, -6.98360950e-02f, 5.49932979e-02f, 5.20082526e-02f, -3.39352638e-02f,
  3.93261155e-03f, 3.44733074e-02f, -2.42791642e-02f, -3.60794961e-02f, -1.02075763e-01f, 2.14937106e-02f, -8.14966485e-02f, -1.86542030e-02f, 1.20064372e-03f, 4.21506390e-02f,
  -4.41226587e-02f, 1.28513547e-02f, 4.29746918e-02f, -2.87584439e-02f, -9.81668569e-03f, -4.61468101e-03f, 3.18611301e-02f, -4.28386591e-02f, -6.09034188e-02f, 3.12291160e-02f,
  -8.94335285e-02f, -2.11211815e-01f, 3.75773385e-02f, 2.35410314e-02f, 4.44224216e-02f, 3.94702107e-02f, 2.36808062e-02f, -5.16581796e-02f, -2.11329944e-02f, -1.79424547e-02f,
  -1.46892354e-01f, -4.27041389e-02f, -3.22270878e-02f, 5.90465916e-03f, -3.66324261e-02f, -2.72787381e-02f, 1.22104958e-01f, -5.57767078e-02f, -2.41147727e-02f, 7.97495898e-03f,
  7.73248868e-03f, -1.42957717e-02f, -2.87315752e-02f, 4.58064228e-02f, -7.59437978e-02f, -1.13862537e-01f, -6.06835671e-02f, -8.65183771e-03f, 4.96180095e-02f, -1.10787256e-02f,
  -4.07322705e-01f, -2.70288493e-02f, -1.79817036e-01f, 1.35339111e-01f, 1.56744927e-01f, 5.34074567e-02f, -1.02086358e-01f, 3.48095559e-02f, 8.74437839e-02f, 5.78878708e-02f,
  1.16520204e-01f, 2.63147622e-01f, 1.29056647e-01f, 1.24674171e-01f, -1.66272938e-01f, -2.90028080e-02f, -1.01116054e-01f, -2.57474095e-01f, -1.04007244e-01f, -1.32522173e-02f,
  1.25239238e-01f, -8.92779082e-02f, -1.62559092e-01f, 3.61908153e-02f, 9.83853415e-02f, 2.18406208e-02f, 4.72071283e-02f, -1.08405408e-02f, 8.08989629e-02f, 3.88035551e-02f,
  -4.48606014e-02f, -3.06420978e-02f, 9.10234526e-02f, 3.29566151e-02f, -7.54908472e-02f, -4.57570851e-02f, 6.60802647e-02f, -2.25176085e-02f, 7.67741203e-02f, -5.62553555e-02f,
  9.12836045e-02f, 2.90054101e-02f, -6.60135001e-02f, -1.67160612e-02f, -4.65966910e-02f, -4.52526733e-02f, 4.21508186e-04f, -6.80543110e-02f, -9.04274806e-02f, -1.09639779e-01f,
  1.34911880e-01f, 1.35850087e-01f, -1.17890805e-01f, 2.53356993e-02f, -5.27383164e-02f, -3.71404998e-02f, -1.12232462e-01f, -3.53372544e-02f, -9.00665149e-02f, -5.04851788e-02f,
  2.17839330e-02f, 1.19836011e-04f, 1.20790200e-02f, -2.68335659e-02f, -1.87599994e-02f, -1.83920879e-02f, 1.30955316e-02f, -2.24124603e-02f, 3.88666764e-02f, -9.96641368e-02f,
  2.88012382e-02f, -8.53999052e-03f, 1.71495788e-02f, -5.37217781e-02f, 1.16046742e-01f, -4.63282205e-02f, -3.65086496e-02f, -2.38481555e-02f, 1.09755419e-01f, -9.47022345e-03f,
  -5.78359514e-02f, 3.28359567e-02f, -2.27189660e-02f, 3.17289531e-02f, -1.56196272e-02f, -4.89461236e-02f, 4.16342095e-02f, 5.93234263e-02f, 6.71355650e-02f, 3.89210284e-02f,
  2.51138420e-03f, -1.96938347e-02f, 1.93082634e-02f, -3.95753570e-02f, 7.93626904e-03f, 6.42850101e-02f, 6.93056500e-03f, -2.26978622e-02f, 5.06475717e-02f, -4.11061533e-02f,
  -7.73102790e-02f, -6.34751394e-02f, -2.57346854e-02f, 8.54058787e-02f, -5.26320189e-02f, 1.10993758e-02f, -1.04401316e-02f, -5.93651831e-02f, -2.50700098e-02f, -5.61273471e-02f,
  -3.79498228e-02f, -3.09511796e-02f, -3.26325954e-03f, -5.68646416e-02f, -3.08150947e-02f, -2.90319528e-02f, -2.37332880e-02f, -5.71836345e-02f, -1.18436210e-01f, -1.77164167e-01f,
  4.50443029e-01f, -2.70420074e-01f, -1.43484883e-02f, 1.69871449e-01f, -6.96743205e-02f, -4.60977061e-03f, -2.20114395e-01f, 5.32338582e-02f, 1.72122762e-01f, -5.32842949e-02f,
  -1.23222828e-01f, 1.39675161e-04f, 1.70636520e-01f, 8.67426209e-03f, 1.15605719e-01f, -9.93404090e-02f, 1.98094193e-02f, 1.13885388e-01f, 1.11371346e-01f, -4.51270491e-02f,
  -5.99273369e-02f, 6.76887333e-02f, 2.00632036e-01f, 1.17252477e-01f, -1.95284814e-01f, -4.40302566e-02f, -8.00386816e-02f, -5.50147966e-02f, -1.75082788e-01f, -7.05018118e-02f,
  -5.45514412e-02f, 9.19986516e-02f, 4.33911830e-02f, -3.91517766e-02f, -1.02553228e-02f, 4.43467647e-02f, 5.36023527e-02f, 8.72345716e-02f, -1.90189406e-02f, -2.16164812e-02f,
  2.22721379e-02f, 2.38443026e-03f, 2.74551436e-02f, -1.25473337e-02f, -4.82708178e-02f, -1.10372799e-02f, 4.90490198e-02f, 9.42542870e-03f, 2.39645094e-02f, -6.92554116e-02f,
  2.28736957e-04f, 2.75030471e-02f, 7.43467957e-02f, -2.96712201e-02f, 1.16488896e-01f, 4.28545028e-02f, -5.01229763e-02f, 1.42766787e-02f, 5.95387332e-02f, -9.31477770e-02f,
  -4.21155989e-02f, 3.71502601e-02f, 3.15658413e-02f, 3.98519747e-02f, 2.05332283e-02f, -3.72848175e-02f, -1.12103336e-02f, -7.54768327e-02f, 4.89417240e-02f, -2.27739699e-02f,
  2.17683986e-02f, -5.42679690e-02f, 1.35126477e-02f, -4.12613712e-02f, -9.01493803e-02f, 7.41740316e-02f, -5.55882156e-02f, -1.02972435e-02f, -2.85487268e-02f, 1.03276018e-02f,
  -2.77660731e-02f, 1.88663863e-02f, 1.65828094e-02f, -4.02018763e-02f, -2.65761241e-02f, -2.68271249e-02f, 7.45078102e-02f, -1.74652431e-02f, 7.87150115e-03f, 1.00273952e-01f,
  -8.47973600e-02f, 1.01247676e-01f, -1.07160360e-02f, 3.68450023e-03f, -5.59123270e-02f, 5.44982925e-02f, 2.60519739e-02f, -6.70959428e-02f, -1.33443438e-02f, -3.16820443e-02f,
  -1.96979735e-02f, 7.19322637e-02f, -4.17754240e-02f, -8.17749500e-02f, 1.19592724e-02f, -2.60861218e-02f, -1.08460307e-01f, -2.09810282e-03f, 2.56246775e-02f, -4.96224388e-02f,
  -9.41610113e-02f, 4.55008410e-02f, 3.13383341e-02f, 6.86773732e-02f, -2.34657973e-02f, 6.17009625e-02f, -1.37843519e-01f, 2.17096675e-02f, 6.37062639e-02f, -7.03483149e-02f,
  -1.94223836e-01f, 2.81819776e-02f, -3.10625434e-01f, -1.58867210e-01f, -1.79544374e-01f, -1.82417482e-01f, -1.27268702e-01f, -6.34733005e-04f, 4.11357135e-02f, 1.67839993e-02f,
  5.87391220e-02f, 8.80252197e-02f, -4.65042749e-03f, -2.87107620e-02f, 4.04029675e-02f, -2.01150075e-01f, -1.29956141e-01f, -1.48911253e-01f, -7.05038831e-02f, -9.76949930e-02f,
  9.42699015e-02f, -9.28536728e-02f, -1.33050039e-01f, -2.46803612e-02f, -7.58370012e-02f, 6.28518015e-02f, -7.22649917e-02f, -1.10140078e-01f, 7.27610141e-02f, -4.39429581e-02f,
  4.85254079e-02f, -8.26647729e-02f, -1.44960269e-01f, -7.75801390e-03f, 8.72914679e-03f, 4.55705486e-02f, -4.95570116e-02f, -5.35002723e-02f, 1.39061743e-02f, 6.39094561e-02f,
  -6.63254261e-02f, 3.57860848e-02f, 4.34761643e-02f, 7.13305324e-02f, -9.40791294e-02f, -2.30108965e-02f, 5.53703830e-02f, -4.00909670e-02f, -1.11717116e-02f, -1.96384569e-03f,
  3.10342591e-02f, 1.60199571e-02f, -5.87072559e-02f, -5.23246638e-02f, 4.08073068e-02f, -3.46987583e-02f, -4.81273904e-02f, 1.45806847e-02f, -3.38153355e-02f, -9.31576639e-03f,
  -1.80914421e-02f, 1.01135023e-01f, 5.22602312e-02f, 9.61240605e-02f, 6.15032203e-02f, 1.85191426e-02f, -3.41312625e-02f, 9.66342762e-02f, -7.30504394e-02f, 5.09000830e-02f,
  3.49295661e-02f, -9.24131572e-02f, 6.25474676e-02f, -7.26882666e-02f, 3.47869247e-02f, -5.96919912e-04f, 3.38721368e-03f, 1.26907015e-02f, -5.53274043e-02f, -1.93010103e-02f,
  4.48669679e-03f, 3.65544260e-02f, -1.07870577e-02f, 4.77029644e-02f, -6.48366362e-02f, -2.69288961e-02f, -2.79539526e-02f, 1.77858118e-02f, -3.17776576e-02f, -4.99809124e-02f,
  1.22040704e-01f, -1.49489909e-01f, 3.71756777e-02f, -3.79886664e-02f, 2.78983004e-02f, 1.01986274e-01f, 2.33140178e-02f, 4.87386733e-02f, -1.70265771e-02f, -4.29355204e-02f,
  -3.88474949e-02f, 1.70198921e-02f, 3.31261046e-02f, -2.34370995e-02f, -6.40789345e-02f, -2.69512050e-02f, 7.43166953e-02f, 6.99034184e-02f, -4.49061452e-04f, 1.31274825e-02f,
  1.30486917e-02f, 5.02614640e-02f, 3.32656875e-02f, 2.19916124e-02f, 5.00572771e-02f, -2.36242991e-02f, -4.16881926e-02f, -6.08886629e-02f, 3.20287161e-02f, 1.02398291e-01f,
  -2.95363013e-02f, 1.68547072e-02f, 9.46123526e-02f, -1.15380093e-01f, 1.54623762e-01f, 2.35974059e-01f, 3.55494529e-01f, 7.61259198e-02f, -1.01361252e-01f, 1.44993901e-01f,
  -3.26068513e-02f, -3.90122943e-02f, -4.33853567e-02f, -6.74709585e-03f, 1.74570337e-01f, 2.44563758e-01f, 1.35312945e-01f, 1.35223582e-01f, 9.97844934e-02f, -3.22395787e-02f,
  -7.94198271e-03f, 1.39401830e-03f, -1.04280479e-01f, 5.52253872e-02f, -9.51972008e-02f, -2.70813033e-02f, 1.07959598e-01f, 6.46708012e-02f, -7.37127587e-02f, 1.09999403e-02f,
  1.52050406e-01f, 1.24764867e-01f, -5.62174432e-03f, -1.04852632e-01f, -4.55321260e-02f, -9.82816680e-04f, -6.58565238e-02f, 2.13508084e-02f, 2.05792971e-02f, -1.03821941e-01f,
  -8.18293095e-02f, 6.82576653e-03f, -9.77043733e-02f, 4.86178836e-03f, 5.62248342e-02f, -1.67765655e-02f, -5.71040763e-03f, 7.90773854e-02f, 3.94320004e-02f, -5.94243668e-02f,
  -2.09068283e-02f, -7.99571946e-02f, -5.96561991e-02f, 7.26607367e-02f, 2.53897607e-02f, -8.98093358e-02f, -4.41286191e-02f, -5.30804731e-02f, 8.86671990e-02f, -8.27286988e-02f,
  -4.89398353e-02f, -2.88717374e-02f, 7.27412403e-02f, 3.51044275e-02f, 6.82876771e-03f, -6.72306418e-02f, 3.54031622e-02f, 1.57709531e-02f, 2.30250023e-02f, -5.38605861e-02f,
  -1.17901631e-01f, -7.39700049e-02f, -2.07616091e-02f, -7.98436031e-02f, 6.59781247e-02f, -3.72288674e-02f, -9.53809917e-03f, -9.02852267e-02f, -1.20495716e-02f, -2.89120600e-02f,
  -4.76706773e-02f, -1.95241310e-02f, -1.96577869e-02f, -3.67072597e-02f, 5.91620989e-03f, 7.57302390e-03f, -4.01322767e-02f, 7.46810529e-03f, -6.00374341e-02f, 4.14324831e-03f,
  -3.80291380e-02f, 2.33995933e-02f, 5.44717088e-02f, 7.19894841e-02f, -2.44954228e-03f, -8.11815336e-02f, -1.07206134e-02f, 9.69132688e-03f, -1.14556015e-01f, -1.68760214e-02f,
  -7.16720596e-02f, -1.47401383e-02f, -5.27520441e-02f, 2.79593170e-02f, -2.79882699e-02f, 4.38588448e-02f, -4.43404466e-02f, 1.11335829e-01f, 2.49152929e-02f, -3.61804925e-02f,
  -9.73441377e-02f, -5.34713157e-02f, -3.33700255e-02f, 1.40582444e-02f, -4.42886986e-02f, 6.83537573e-02f, 4.22501042e-02f, -1.23031568e-02f, 6.72539547e-02f, -6.22002920e-03f,
  2.98216313e-01f, 2.71769494e-01f, 9.38862935e-02f, -8.41221660e-02f, 2.68049147e-02f, 2.30913356e-01f, 3.64994049e-01f, 1.64557174e-01f, -1.67458013e-01f, 4.66158614e-02f,
  1.09051719e-01f, -1.25740662e-01f, -2.08765697e-02f, -7.32158050e-02f, 1.43142924e-01f, 9.63500291e-02f, -1.06330536e-01f, -1.27823606e-01f, 6.08486235e-02f, 4.10276987e-02f,
  -1.42863750e-01f, 1.20944940e-02f, -3.87532413e-02f, -2.48609036e-02f, -8.35392326e-02f, -1.34254768e-01f, -5.05897328e-02f, -6.59346506e-02f, 7.82358348e-02f, -2.65841454e-01f,
  8.05150624e-03f, 1.57653354e-02f, -8.97350833e-02f, 5.36330938e-02f, 4.86929826e-02f, 9.20744427e-03f, 1.43214792e-01f, -1.52418956e-01f, 5.92602156e-02f, 2.93956622e-02f,
  -9.92139354e-02f, -3.34659033e-03f, 9.98634752e-03f, -8.61669239e-03f, -2.14263354e-03f, -4.30264287e-02f, 3.33795100e-02f, -7.20199198e-02f, -4.30053240e-03f, -3.72034460e-02f,
  -7.64642283e-02f, -1.33000724e-02f, 1.43852323e-01f, 9.53220204e-02f, 1.26678392e-01f, -2.46799132e-03f, -5.59038483e-02f, 6.57019913e-02f, 1.58620954e-01f, -1.23024192e-02f,
  -1.41190812e-02f, -4.28513251e-02f, 6.41884953e-02f, -3.20026018e-02f, 3.01860366e-02f, -5.92071116e-02f, -1.74293846e-01f, -9.91659425e-03f, 2.75499746e-02f, 6.52889758e-02f,
  7.87512865e-03f, 3.16949785e-02f, -1.07740037e-01f, 6.44465908e-02f, -5.41765131e-02f, 1.79901421e-02f, 3.10906377e-02f, 1.59395505e-02f, -2.88198162e-02f, -4.25177626e-03f,
  -4.42542285e-02f, 4.82043577e-03f, -3.22401896e-02f, 1.11308387e-02f, 3.69545557e-02f, -2.26302166e-03f, -6.92682387e-03f, 6.75288364e-02f, 8.19368511e-02f, 1.15025319e-01f,
  1.41883418e-02f, 4.03520502e-02f, -3.47758480e-03f, -1.57688418e-03f, 9.85808391e-03f, 3.03594451e-02f, 1.44148134e-02f, -2.29281280e-03f, 4.24607284e-02f, 4.57024053e-02f,
  7.40140527e-02f, -2.81707402e-02f, -1.72548555e-02f, -2.82586198e-02f, 2.55452599e-02f, 5.36888316e-02f, 4.03327644e-02f, -2.56084837e-03f, 9.00322478e-03f, 5.39029278e-02f,
  5.13756946e-02f, 1.92232765e-02f, 4.39207293e-02f, 5.15368395e-02f, 5.20362779e-02f, 6.33685365e-02f, 8.13189968e-02f, 1.07845172e-01f, 2.37924919e-01f, 2.39918247e-01f,
  -3.23043138e-01f, -1.87721997e-01f, 4.70000356e-02f, -1.02644555e-01f, 1.82946190e-01f, 2.12793291e-01f, 2.35585824e-01f, -1.30187394e-02f, -4.87321727e-02f, 1.86827239e-02f,
  6.24481365e-02f, -2.79745609e-02f, -8.96077752e-02f, 2.01122072e-02f, 8.32822695e-02f, 1.48609534e-01f, 9.47391316e-02f, -5.00021614e-02f, 6.59733415e-02f, 1.48398191e-01f,
  1.56442165e-01f, -9.06609651e-03f, -1.71303302e-02f, -2.38348059e-02f, 4.05143276e-02f, 1.72223568e-01f, -4.45063338e-02f, -5.03882132e-02f, 1.50744244e-01f, -1.65085092e-01f,
  -8.71836841e-02f, -6.57683611e-02f, 1.81784593e-02f, -1.49452221e-02f, 6.55441778e-04f, -2.22486872e-02f, -5.76373860e-02f, -9.76811945e-02f, -5.35836518e-02f, 1.72189847e-02f,
  2.90080085e-02f, 4.07392457e-02f, -5.77687174e-02f, -1.44323418e-02f, -7.32564032e-02f, -3.04616801e-02f, -1.04219176e-01f, -2.33771931e-03f, 7.12865070e-02f, 4.11851192e-03f,
  2.95043346e-02f, 2.84980331e-02f, 4.27473411e-02f, 1.74692627e-02f, 8.99172295e-03f, 4.25977297e-02f, 3.42479721e-02f, -8.81624296e-02f, -1.56780297e-03f, -1.36970848e-01f,
  4.55696657e-02f, -4.41426644e-03f, 8.43328536e-02f, -1.13779204e-02f, -7.40175089e-03f, 4.92918082e-02f, -1.61901079e-02f, 6.63470179e-02f, 5.03116734e-02f, -9.06591862e-02f,
  2.25925371e-02f, -1.38595356e-02f, 3.62090804e-02f, -3.51133198e-02f, -1.31132975e-02f, 9.78743061e-02f, 1.81976054e-02f, 6.44143671e-02f, -5.19959852e-02f, -1.07293218e-01f,
  -5.38866334e-02f, 2.44660694e-02f, 7.01854602e-02f, 2.92142760e-02f, 3.28119211e-02f, -4.84685302e-02f, 5.24366880e-03f, -4.04001353e-03f, -3.74302045e-02f, 1.90112423e-02f,
  -4.84323762e-02f, 1.88522767e-02f, 2.18469203e-02f, 8.33812058e-02f, -4.74477783e-02f, -2.23043729e-02f, -1.92857999e-02f, 2.02079117e-02f, -9.25137922e-02f, 3.37632224e-02f,
  8.08399022e-02f, 2.48900913e-02f, 3.47293019e-02f, -1.58234797e-02f, 3.55371349e-02f, 4.68333252e-02f, -2.08817031e-02f, 4.30803634e-02f, -1.05838859e-02f, -3.87789756e-02f,
  -1.20176850e-02f, -6.46507069e-02f, -8.33176896e-02f, 9.41607431e-02f, -7.17124119e-02f, -3.08084395e-03f, 6.98881373e-02f, 1.78326853e-02f, 5.85868023e-02f, 2.98993699e-02f,
  -5.21539561e-02f, 4.66723330e-02f, 1.43072605e-01f, -5.12705073e-02f, 1.19884066e-01f, 8.01418349e-02f, 2.39942912e-02f, 6.05455004e-02f, -9.14955810e-02f, 1.48149533e-02f,
  1.55525923e-01f, 6.62429929e-02f, 1.64449260e-01f, 7.84773752e-02f, 1.37617305e-01f, 8.06052908e-02f, 8.60481337e-02f, 9.44308415e-02f, 4.81717177e-02f, 1.36510640e-01f,
  6.41543940e-02f, -6.87019303e-02f, 7.39276484e-02f, 7.58342221e-02f, -4.83174026e-02f, 7.99956918e-02f, -6.25790283e-02f, -7.24985376e-02f, 1.02666818e-01f, -8.91558230e-02f,
  1.80288762e-01f, -7.64160305e-02f, 1.43518880e-01f, 5.63994795e-02f, 9.86678973e-02f, -3.94071490e-02f, -2.57393774e-02f, -4.42572217e-03f, -8.25785398e-02f, -8.64691436e-02f,
  -4.42763381e-02f, 5.65713383e-02f, 9.55046937e-02f, 5.31298332e-02f, -1.42466007e-02f, 2.05118097e-02f, -1.08605281e-01f, -3.56593430e-02f, 9.45024472e-03f, -1.41663263e-02f,
  3.38271931e-02f, -2.39001010e-02f, -2.37922575e-02f, -1.26619101e-01f, 7.17081828e-03f, 2.34567169e-02f, 2.61879489e-02f, -1.03276633e-01f, -6.61225468e-02f, -6.23073988e-02f,
  -8.64364430e-02f, -5.17865084e-02f, -8.21839087e-03f, -1.07754841e-02f, -1.32359164e-02f, -4.72183377e-02f, -9.65440795e-02f, 2.94543803e-02f, -1.81204006e-02f, -2.66378764e-02f,
  -2.58976873e-02f, 5.83031401e-02f, 4.34068143e-02f, -3.00618517e-03f, 6.41208142e-02f, -6.00073077e-02f, -5.20170219e-02f, -2.33035106e-02f, -7.14665372e-03f, -1.87227130e-03f,
  2.28265710e-02f, -1.29974276e-01f, 2.20630690e-02f, 2.69069243e-02f, -7.12889731e-02f, -6.55120984e-02f, -6.90338165e-02f, 4.76241577e-03f, 3.29192495e-03f, -1.31038968e-02f,
  2.36963809e-01f, 1.14177868e-01f, 1.07402995e-01f, -2.43272446e-02f, 1.13160156e-01f, -1.96622647e-02f, 7.53057599e-02f, 4.13633737e-04f, -8.68342966e-02f, 9.36529562e-02f,
  2.88412757e-02f, -2.14201715e-02f, 1.03737898e-01f, -2.81037390e-02f, 5.50108403e-02f, 8.07319507e-02f, -4.37586680e-02f, -2.06146482e-02f, -1.10968694e-01f, -3.26748863e-02f,
  -5.62427826e-02f, -1.35107767e-02f, 1.06211014e-01f, 6.95545375e-02f, 2.40577292e-02f, -4.37858235e-03f, 1.02779336e-01f, 1.18374610e-02f, 2.22051013e-02f, 8.61730799e-02f,
  1.01715669e-01f, -5.39667420e-02f, -2.27521837e-01f, 5.16876876e-02f, -8.42072889e-02f, -1.81101367e-01f, -3.14194798e-01f, -3.90839763e-02f, 1.81692392e-01f, -1.58537209e-01f,
  -8.65798295e-02f, 1.72317863e-01f, 1.97920635e-01f, 4.88630533e-02f, -2.12344271e-03f, 5.72418235e-03f, 3.42557877e-02f, 1.96432089e-03f, -9.06207114e-02f, -1.24869950e-01f,
  1.20581582e-01f, 1.09613590e-01f, 1.70393527e-01f, 1.13496467e-01f, 1.26258880e-01f, 2.15476714e-02f, -1.09699979e-01f, -5.65434843e-02f, -1.28587514e-01f, 1.63228422e-01f,
  -1.82820782e-01f, -1.53329238e-01f, -5.63582312e-03f, 1.86625179e-02f, -1.06133312e-01f, -5.58657497e-02f, 4.10645790e-02f, 9.80768055e-02f, 6.32003099e-02f, -3.80264781e-02f,
  -9.95895490e-02f, 2.28946912e-03f, -1.14594745e-02f, -3.07464115e-02f, 2.58926023e-02f, -6.72598779e-02f, 9.91237462e-02f, 1.31608367e-01f, 1.29770422e-02f, -7.38020092e-02f,
  1.15559220e-01f, -3.21894437e-02f, 9.52200405e-03f, 9.18175839e-03f, -8.97237659e-02f, -5.88261336e-02f, -1.05295189e-01f, 5.60323969e-02f, 1.52346212e-02f, -1.24801612e-02f,
  -2.64985505e-02f, 7.45490044e-02f, 3.04905679e-02f, -2.30007190e-02f, 1.09793074e-01f, -1.06029414e-01f, 1.93697158e-02f, -1.95864774e-02f, 9.31594968e-02f, 1.78844482e-02f,
  -4.84248959e-02f, -1.65996738e-02f, 7.81550352e-03f, -3.79285626e-02f, 4.32549790e-02f, 2.21262779e-02f, -6.52970299e-02f, -1.24811493e-02f, 1.58483863e-01f, -1.06939906e-02f,
  -3.85108553e-02f, -1.87676884e-02f, -4.65818755e-02f, 8.84032026e-02f, 3.57413478e-02f, -2.89132949e-02f, -3.80874332e-03f, -5.16584106e-02f, 6.43460229e-02f, 7.62198195e-02f,
  7.80298114e-02f, -1.75918475e-01f, -2.47630216e-02f, -4.07594666e-02f, -4.73199673e-02f, 4.11210349e-03f, -7.47229829e-02f, 5.45397028e-02f, 2.34452765e-02f, -1.14824951e-01f,
  -1.13098271e-01f, -3.52163650e-02f, -2.83752405e-03f, 3.37039903e-02f, -2.45376565e-02f, 1.78642571e-02f, -1.24287000e-02f, -1.21856574e-02f, 9.71036032e-02f, 2.01168284e-02f,
  -6.90477788e-02f, -9.38736126e-02f, -4.12191153e-02f, -6.32386208e-02f, -7.22020119e-02f, -7.18424320e-02f, -1.58774212e-01f, -1.38123557e-01f, -4.31059934e-02f, -1.20451838e-01f,
  -1.19207188e-01f, 2.47367963e-01f, -1.76461875e-01f, 8.94965008e-02f, 1.78857014e-01f, 8.13965872e-02f, 1.24004170e-01f, 2.75531430e-02f, 8.78692269e-02f, 6.07683621e-02f,
  1.20043062e-01f, -6.37081265e-02f, -1.36630058e-01f, -1.88347384e-01f, -2.23090559e-01f, 1.99963450e-02f, -6.65887743e-02f, -2.78315753e-01f, -3.28731745e-01f, 1.69819724e-02f,
  2.83206161e-02f, -5.08683547e-03f, -8.41011330e-02f, -8.80521238e-02f, 1.71689987e-01f, 1.06947543e-03f, 1.03102196e-02f, 2.45445464e-02f, -2.71974336e-02f, 9.90892053e-02f,
  -7.37167895e-03f, 1.26261592e-01f, -5.30585013e-02f, 2.92822486e-03f, 4.95684221e-02f, 6.61958605e-02f, -1.13601536e-02f, -7.80743584e-02f, 6.79002926e-02f, 1.91217870e-03f,
  -4.22061309e-02f, 2.85069421e-02f, -8.42837393e-02f, 4.79664654e-02f, 8.61551091e-02f, -6.62801713e-02f, 3.11412103e-02f, -1.28872871e-01f, -1.57503277e-01f, 1.11925818e-01f,
  1.07677869e-01f, 6.39260784e-02f, -7.04904050e-02f, -1.83332860e-02f, -7.66076222e-02f, -1.03441708e-01f, 7.87130594e-02f, -1.82372052e-02f, -1.02745242e-01f, 6.56588674e-02f,
  1.69793926e-02f, -1.62022710e-02f, -7.09764734e-02f, 1.37703894e-02f, 5.51744290e-02f, 4.21403758e-02f, -3.08255684e-02f, 3.52497622e-02f, -1.73363704e-02f, 2.18725912e-02f,
  6.06808290e-02f, -6.56701252e-02f, -6.45241290e-02f, -1.85770243e-02f, -7.48423561e-02f, -3.27443401e-03f, -1.73814166e-02f, -3.34273614e-02f, -4.60089790e-03f, 5.14898226e-02f,
  4.34772819e-02f, 4.91500972e-03f, 9.59523991e-02f, -1.83633342e-02f, -3.70547734e-02f, -1.34469047e-01f, 2.24321429e-03f, 4.16843779e-03f, 8.45744926e-03f, 1.14444822e-01f,
  1.56631649e-01f, -2.53656119e-01f, -1.90207660e-02f, 2.51906756e-02f, -3.15517820e-02f, 7.76626752e-04f, 7.88442120e-02f, -1.98487137e-02f, 3.74052264e-02f, 2.05076132e-02f,
  4.47688699e-02f, 1.12596015e-02f, 6.51275665e-02f, -4.72430177e-02f, -1.63605791e-02f, 5.29120415e-02f, 4.38237265e-02f, -4.24573570e-02f, -1.24921706e-02f, 9.85564142e-02f,
  4.57596332e-02f, 1.26837601e-03f, 1.28016705e-02f, -8.56633559e-02f, -1.40833342e-02f, -3.93561125e-02f, 3.88583988e-02f, 3.66279595e-02f, -1.21529005e-01f, 1.17355980e-01f,
  2.24362925e-01f, 4.12837006e-02f, -3.62820663e-02f, 3.49643566e-02f, -7.39222690e-02f, -2.26397365e-01f, -2.20534235e-01f, -1.30585715e-01f, -3.83256935e-02f, -1.01241410e-01f,
  6.89281747e-02f, 1.28239244e-01f, 8.39550868e-02f, 1.38683900e-01f, -6.59583509e-03f, -2.89165862e-02f, 6.86296355e-03f, -8.20383057e-03f, -2.17660666e-02f, -1.25543773e-01f,
  6.04408383e-02f, 1.10615760e-01f, 1.24033786e-01f, -1.94005333e-02f, -3.78645696e-02f, -6.32076245e-03f, -1.01116635e-02f, 1.29754208e-02f, -6.26247227e-02f, 1.97765350e-01f,
  2.18038082e-01f, 8.90545622e-02f, -1.13330796e-01f, -3.73650678e-02f, 5.20785078e-02f, -1.08401934e-02f, 1.90759711e-02f, -4.85159233e-02f, 8.19020998e-03f, -1.59299653e-02f,
  7.28673860e-02f, 7.90286958e-02f, 1.31296879e-02f, 1.54247016e-01f, -4.46915701e-02f, 5.53263985e-02f, -4.41972204e-02f, 1.23345666e-01f, 4.38486226e-02f, 7.60379583e-02f,
  -3.82851586e-02f, 7.98829272e-02f, 3.81927826e-02f, 2.88776811e-02f, 4.06029895e-02f, -3.43973376e-03f, 1.60831511e-02f, 9.55605209e-02f, 8.86113867e-02f, 1.05261073e-01f,
  8.38219076e-02f, 1.96975954e-02f, -2.95667723e-02f, 2.94615123e-02f, -5.93748689e-03f, 5.06651849e-02f, 3.58381383e-02f, 3.19718458e-02f, -8.74872506e-02f, 3.23111601e-02f,
  1.48117067e-02f, -1.54376375e-02f, 5.26071563e-02f, 4.95733991e-02f, -5.31925634e-02f, 4.23614169e-04f, -7.11391643e-02f, 1.66208961e-03f, -6.90483078e-02f, -9.59831849e-02f,
  -9.21334177e-02f, -4.45014834e-02f, 1.82957705e-02f, -1.15878403e-01f, -1.06732741e-01f, -2.02242583e-02f, 1.55293457e-02f, -7.47641101e-02f, 5.35032451e-02f, 5.56338318e-02f,
  1.10221520e-01f, 1.56521332e-03f, 4.71466854e-02f, 6.70718029e-02f, 4.20768522e-02f, -7.83042796e-03f, 4.94945049e-03f, -2.83094887e-02f, -5.23778237e-02f, 3.11827939e-02f,
  -6.00237735e-02f, 1.32180778e-02f, 8.07815269e-02f, 5.80862798e-02f, 9.96334031e-02f, 1.03082977e-01f, 7.01345205e-02f, 3.77715379e-02f, 8.80155712e-03f, -7.15054125e-02f,
  -1.43680470e-02f, -8.74234363e-02f, -4.74872552e-02f, 2.24543344e-02f, -1.98322050e-02f, -1.02281138e-01f, -3.76486070e-02f, -8.64154622e-02f, 3.28354468e-03f, -6.79089502e-02f,
  -1.36145502e-01f, 2.66907871e-01f, -2.40669325e-02f, 9.20434073e-02f, -3.12765874e-02f, -1.19388081e-01f, -3.65825221e-02f, 2.23771911e-02f, -5.43774245e-03f, 1.16034180e-01f,
  6.56779036e-02f, -1.17280558e-01f, -9.77192000e-02f, -1.81737822e-03f, -1.08406529e-01f, 1.37726709e-01f, 1.79751188e-01f, -1.01238616e-01f, -3.60138655e-01f, -9.59266648e-02f,
  1.03110641e-01f, -3.24774324e-03f, -8.05537328e-02f, -7.18677044e-02f, 2.17902422e-01f, -8.31420869e-02f, -1.93550549e-02f, 6.98459744e-02f, 8.42755511e-02f, 3.82744819e-01f,
  -2.23911237e-02f, 2.26043910e-02f, -1.91793963e-01f, -4.39610630e-02f, -6.29920289e-02f, 4.37381379e-02f, -7.53726736e-02f, -5.00199609e-02f, -2.75700893e-02f, -2.91687138e-02f,
  1.64931510e-02f, 4.36594449e-02f, -2.13559135e-03f, 4.05719467e-02f, 2.77615953e-02f, 4.51773498e-03f, -1.78792719e-02f, -5.49148135e-02f, 4.71269973e-02f, 3.61652635e-02f,
  1.61372367e-02f, 5.82052059e-02f, -4.52421904e-02f, 2.50232243e-03f, 1.62085388e-02f, -4.68786247e-02f, 7.47339576e-02f, 4.12972234e-02f, 9.06473026e-03f, 2.76079401e-02f,
  3.44569199e-02f, -1.21094668e-02f, 5.75048337e-03f, 1.64058264e-02f, -2.62292046e-02f, 3.22245546e-02f, -4.77970168e-02f, 8.09015855e-02f, -5.23336083e-02f, 6.99588982e-03f,
  1.01629697e-01f, 2.33811010e-02f, 6.35254756e-02f, -4.10543345e-02f, 5.03165796e-02f, 7.83204567e-03f, 1.85092706e-02f, 2.66024433e-02f, -4.69598686e-03f, -1.38506126e-02f,
  -9.81435762e-04f, 1.97527483e-02f, 2.88768634e-02f, 1.23746321e-02f, 1.43757835e-02f, 6.74620122e-02f, 2.53429189e-02f, 3.57625671e-02f, 4.91320528e-02f, -6.36702850e-02f,
  8.23151134e-03f, -1.50198683e-01f, 1.04061980e-02f, -9.70106572e-02f, -3.03750504e-02f, 1.55606866e-02f, 4.86233979e-02f, 2.79826019e-02f, -2.11254507e-02f, -4.54894342e-02f,
  -2.35772114e-02f, 4.51440748e-04f, 2.72985045e-02f, 4.48400639e-02f, -1.00873046e-01f, 4.06891480e-02f, -8.96284543e-03f, 4.38557472e-03f, -1.79779381e-02f, 2.22875960e-02f,
  1.45795807e-01f, -5.77092767e-02f, -1.41587034e-01f, -1.59412753e-02f, 4.72819386e-03f, -2.06417236e-02f, -7.15882406e-02f, -8.74529108e-02f, -1.05056010e-01f, -4.90135439e-02f,
  6.52035400e-02f, -1.50035933e-01f, -5.47087416e-02f, -6.56390116e-02f, -6.87863827e-02f, 1.47585019e-01f, 1.80099145e-01f, 1.38240084e-01f, 2.11910252e-02f, 1.82799471e-03f,
  -3.22920308e-02f, -1.80833340e-01f, -8.92364830e-02f, 1.04058078e-02f, 6.71674386e-02f, -4.92681935e-02f, -2.25399479e-01f, -1.23921022e-01f, 1.11324944e-01f, 1.11992545e-02f,
  -2.90069617e-02f, -5.72177581e-03f, -7.14954436e-02f, 4.82153632e-02f, -1.84345141e-01f, -7.63729811e-02f, -8.48639682e-02f, -7.67209530e-02f, -3.93441133e-02f, -3.96947294e-01f,
  -9.18911994e-02f, 1.57068759e-01f, -3.39759998e-02f, -1.00862354e-01f, 5.18043935e-02f, 6.50918484e-02f, -6.70423135e-02f, -2.12868955e-02f, -6.34848773e-02f, -4.43585031e-03f,
  2.34589279e-02f, 6.73631951e-03f, -7.29780570e-02f, -4.69000116e-02f, 8.28618482e-02f, 9.50907394e-02f, -1.94841567e-02f, 7.63402507e-02f, 8.52195621e-02f, 8.13816637e-02f,
  1.27890809e-02f, -6.90485984e-02f, 1.26988873e-01f, 3.63987535e-02f, 5.61220683e-02f, -6.53945953e-02f, 2.56976648e-03f, -1.06773153e-02f, -3.88682038e-02f, -5.93389533e-02f,
  -4.81858589e-02f, 8.52543954e-03f, 5.92425652e-02f, -6.06984347e-02f, -4.60539050e-02f, 7.01860785e-02f, -8.85684043e-02f, -8.74841064e-02f, -1.17411250e-02f, -6.66699409e-02f,
  4.22640294e-02f, 7.90739991e-03f, -8.38239864e-03f, 1.38518475e-02f, 5.30888066e-02f, -9.61598009e-03f, 8.85149930e-03f, 9.51051246e-03f, 4.54082601e-02f, 5.18074408e-02f,
  -1.30325323e-03f, 1.80164855e-02f, 2.77767871e-02f, -4.58170325e-02f, -6.32141009e-02f, 1.81125372e-03f, 4.80051152e-02f, 2.12880485e-02f, 7.76830390e-02f, 2.21423768e-02f,
  5.09201996e-02f, 1.89174369e-01f, -1.22730613e-01f, -3.23076285e-02f, 7.82304853e-02f, 3.27364728e-02f, -6.91382866e-03f, 4.08976190e-02f, -3.56567353e-02f, 7.85219893e-02f,
  7.87156671e-02f, -3.06128394e-02f, 2.69789975e-02f, 6.78946972e-02f, -4.02401015e-02f, 2.91078668e-02f, -6.00815192e-02f, -7.96604529e-02f, 5.32935336e-02f, 1.10200472e-01f,
  5.23947813e-02f, 1.71553612e-01f, 1.43113732e-01f, 8.81768763e-02f, 8.08499902e-02f, 1.40057541e-02f, 2.13778149e-02f, 8.90487060e-02f, 1.50508374e-01f, -7.29524046e-02f,
  -6.01283424e-02f, -1.34115979e-01f, 2.11451878e-03f, -1.34840593e-01f, -8.78103524e-02f, 2.70534977e-02f, -1.98850065e-01f, 3.10724992e-02f, 2.25907526e-04f, -1.31708026e-01f,
  -1.58022102e-02f, 1.48115024e-01f, 2.30587628e-02f, 1.18693024e-01f, 2.66887844e-02f, -1.28906921e-01f, -1.09598398e-01f, 8.47520530e-02f, 7.75847733e-02f, 1.15508310e-01f,
  -7.55660422e-03f, -5.67527488e-02f, 7.06761181e-02f, -5.72239235e-02f, -1.43553779e-01f, 1.04131132e-01f, -6.58598244e-02f, -4.37750779e-02f, 6.56025857e-02f, -1.50429964e-01f,
  4.58183326e-02f, -1.02442034e-01f, 1.54358074e-01f, 8.90810564e-02f, 5.54751381e-02f, 2.85039749e-02f, -9.60851368e-03f, 1.49992164e-02f, 2.24635955e-02f, 3.14486623e-02f,
  4.24387194e-02f, -8.84233266e-02f, -5.85300289e-02f, -4.58400957e-02f, -9.53071788e-02f, -3.86959240e-02f, -7.76329562e-02f, -2.61544250e-02f, -2.62451340e-02f, -3.10746878e-02f,
  -1.02180414e-01f, -6.87612072e-02f, 3.45459431e-02f, 1.35724423e-02f, 1.82092637e-02f, -6.26040921e-02f, -9.46531296e-02f, 3.90765630e-03f, -3.09626851e-02f, -6.52191117e-02f,
  6.91842809e-02f, 2.57793516e-02f, 7.11448044e-02f, -4.06972356e-02f, 6.01336397e-02f, -3.16485278e-02f, -3.50065753e-02f, 4.43194509e-02f, 2.54518818e-02f, 3.12265139e-02f,
  6.00152314e-02f, -3.26240547e-02f, 2.53774207e-02f, 6.63939267e-02f, 1.51978098e-02f, -7.44881928e-02f, -3.51611748e-02f, 3.10864188e-02f, 2.73204427e-02f, 5.43358643e-03f,
  1.11419400e-02f, -4.70675481e-03f, 3.92864598e-03f, 7.95201398e-03f, 5.82476938e-03f, -4.99228612e-02f, -4.54677157e-02f, -1.93332303e-02f, -1.68042630e-02f, 1.94470352e-03f,
  4.17970009e-02f, 3.96684706e-02f, -1.30205676e-02f, -5.74467555e-02f, -1.84279792e-02f, 2.35927943e-02f, 2.97420546e-02f, 4.40841205e-02f, -3.82190607e-02f, -4.38312888e-02f,
  -5.93060143e-02f, -1.96445826e-02f, -8.19760468e-03f, -2.34715752e-02f, 7.66097605e-02f, 5.20949624e-02f, 4.81226183e-02f, -3.22261117e-02f, -4.82303798e-02f, 2.04563085e-02f,
  3.01008467e-02f, -3.59550193e-02f, -1.61157139e-02f, -5.26277907e-02f, 5.01971096e-02f, 1.76887214e-02f, 1.12349510e-01f, -2.13164166e-02f, 1.09244026e-01f, 2.93221837e-03f,
  1.18937545e-01f, 9.71772075e-02f, 5.72433621e-02f, 7.59890527e-02f, 3.64986919e-02f, 1.05198935e-01f, 7.07959756e-02f, 3.67272608e-02f, 1.94083489e-02f, 1.54206917e-01f,
  7.16031119e-02f, -5.09207398e-02f, -1.05020339e-02f, -3.02473847e-02f, -4.23779935e-02f, 1.15689486e-01f, 1.16463922e-01f, 8.51152167e-02f, 2.99507231e-02f, -3.34024690e-02f,
  5.40360808e-02f, 9.56304073e-02f, 4.24394943e-02f, -1.00273397e-02f, -5.21335416e-02f, 6.35251403e-02f, 1.16163820e-01f, 2.54332204e-03f, 7.19032763e-03f, 3.51058803e-02f,
  5.12906462e-02f, -6.89113662e-02f, -8.01359713e-02f, -5.98503277e-02f, -1.34909386e-02f, 1.82189271e-02f, 4.72562760e-02f, -1.28505873e-02f, 4.12889607e-02f, 9.55882296e-02f,
  3.50431763e-02f, -8.95607769e-02f, -3.23464386e-02f, -4.91053797e-02f, -4.66989800e-02f, 2.76883543e-02f, 7.83614293e-02f, 1.51267573e-02f, 1.08112150e-03f, 9.75416973e-03f,
  -7.32164159e-02f, 6.26420323e-03f, 6.78349892e-03f, -8.05534348e-02f, -8.95443931e-02f, -1.26433566e-01f, 3.30006294e-02f, -3.88710317e-03f, -9.11387801e-03f, 1.03725269e-01f,
  -5.40882759e-02f, -1.30502721e-02f, 2.58267745e-02f, 8.22794065e-02f, -1.69078447e-02f, 1.17309555e-01f, 5.96159883e-02f, 7.19972849e-02f, -1.39872981e-02f, 9.10909921e-02f,
  -5.52615151e-02f, -1.86413452e-02f, 1.94390453e-02f, 9.29373652e-02f, -3.17181903e-03f, -4.89950441e-02f, 9.55624357e-02f, -2.70971972e-02f, 2.06532348e-02f, -4.10101376e-03f,
  -2.13880818e-02f, -2.53116712e-02f, 5.68228923e-02f, -6.67214692e-02f, -4.05189358e-02f, 3.73908766e-02f, 7.16336071e-02f, 3.62303443e-02f, -6.27146512e-02f, 2.42199507e-02f,
  1.11258492e-01f, -1.55302927e-01f, 4.61539850e-02f, 4.56332974e-02f, 2.18378361e-02f, -5.09807914e-02f, 1.50283519e-02f, 5.25661446e-02f, -3.14958915e-02f, -6.94866553e-02f,
  3.77841182e-02f, 4.22769189e-02f, 8.62869322e-02f, -9.96432267e-03f, -3.23555097e-02f, 1.17876157e-01f, 1.51605085e-01f, -2.52187289e-02f, 1.11624878e-02f, 4.68101576e-02f,
  6.06205910e-02f, -1.27219572e-03f, 1.07267693e-01f, -7.25902170e-02f, -6.40001372e-02f, 7.14530125e-02f, 8.01215768e-02f, 5.80125861e-02f, -1.61516871e-02f, 2.66631216e-01f,
  4.90162283e-01f, -1.03844173e-01f, -1.01712286e-01f, 1.16832688e-01f, -1.64926544e-01f, -1.65816694e-01f, -3.95411164e-01f, -1.74550951e-01f, 4.11952287e-02f, -9.55269858e-02f,
  1.35617126e-02f, 2.03062385e-01f, 1.66489676e-01f, 8.78717303e-02f, 5.32845445e-02f, -2.21856803e-01f, -2.74629503e-01f, -1.75657272e-02f, 1.52610272e-01f, 7.70190358e-02f,
  -8.57770443e-02f, 8.59869346e-02f, 2.41425201e-01f, 8.96527320e-02f, -1.13326246e-02f, -1.08679412e-02f, -2.75480207e-02f, 4.96002883e-02f, 3.43326405e-02f, 3.18291709e-02f,
  9.44271013e-02f, 4.05152999e-02f, -2.96981656e-03f, 1.09815612e-01f, -3.51674296e-02f, 1.36610717e-01f, 1.07088368e-02f, 4.01789993e-02f, -6.89131953e-03f, -6.81745484e-02f,
  3.76365632e-02f, 6.56052902e-02f, 5.54459244e-02f, 2.98915710e-02f, -2.66635846e-02f, 4.55710851e-02f, -4.35210168e-02f, 6.35103881e-02f, -6.48543760e-02f, -4.29887250e-02f,
  -1.05095342e-01f, -2.85715535e-02f, -1.32626191e-01f, -1.65232211e-01f, -4.16722707e-03f, 3.91847678e-02f, 2.49842089e-03f, 5.63646965e-02f, 1.37606999e-02f, 5.82900979e-02f,
  -8.02767202e-02f, -1.82819664e-02f, -1.43437693e-02f, -4.71970811e-02f, -8.19589384e-03f, 9.55830980e-03f, -4.33804952e-02f, 1.58985367e-03f, -8.66514980e-04f, -7.29814731e-03f,
  1.26835033e-02f, 9.91844106e-03f, 4.55788802e-03f, -1.37715861e-02f, 1.78557951e-02f, -9.85848680e-02f, 3.84008661e-02f, 7.90353790e-02f, -4.79519367e-02f, 1.09845391e-02f,
  -4.29582298e-02f, 9.57599189e-03f, 2.87627317e-02f, 2.22085677e-02f, -5.32958023e-02f, -6.33214181e-03f, 1.99734643e-02f, 3.21516544e-02f, -4.96446434e-03f, -9.78600457e-02f,
  6.99788332e-02f, -2.07345724e-01f, 1.12826124e-01f, 6.12655021e-02f, -3.20408866e-02f, -2.46337969e-02f, -5.35139032e-02f, -3.73416990e-02f, 5.72082400e-02f, 7.16147274e-02f,
  -3.49829393e-03f, 3.39269936e-02f, 7.78040476e-03f, -5.54850698e-02f, -1.17029371e-02f, -1.62304007e-02f, -5.11182193e-03f, -3.12722661e-02f, -8.26286823e-02f, -1.00313956e-02f,
  7.02909380e-02f, -7.55688176e-02f, -4.74782735e-02f, 4.67552170e-02f, 5.46168163e-03f, 3.46804112e-02f, -6.36530221e-02f, -1.53338313e-02f, -7.13128373e-02f, 4.78479974e-02f,
  -3.06082487e-01f, 1.18932784e-01f, 1.85171917e-01f, -1.71766445e-01f, 8.68688822e-02f, 8.24643597e-02f, 1.79195836e-01f, -9.72540155e-02f, -4.22377475e-02f, 3.03961933e-02f,
  6.85116798e-02f, -9.71990377e-02f, -1.84345394e-01f, 2.16755718e-02f, 8.17396864e-03f, 1.82631478e-01f, 7.73853958e-02f, -4.81790816e-03f, -1.33375973e-01f, -7.55833313e-02f,
  -2.54367162e-02f, 2.58058142e-02f, -5.91638200e-02f, -7.10535273e-02f, 4.10493743e-03f, -1.24902144e-01f, 7.42791174e-03f, 9.93241072e-02f, 1.06221279e-02f, 1.36067882e-01f,
  2.93531902e-02f, -1.02755819e-02f, 6.27635606e-03f, 4.29282710e-02f, 1.40506431e-01f, -5.67010604e-02f, 3.87303717e-02f, 8.79752263e-02f, 2.58906819e-02f, 4.06445712e-02f,
  -2.69736014e-02f, 6.21773638e-02f, -4.86838967e-02f, -2.59235092e-02f, 3.38341966e-02f, 3.93828712e-02f, -4.76091467e-02f, 4.57795411e-02f, 8.03820565e-02f, 9.92161185e-02f,
  4.03372571e-02f, 1.25228334e-03f, 4.77776304e-02f, -2.23400183e-02f, -2.34830147e-03f, -1.78073607e-02f, -5.07523492e-02f, 7.98375756e-02f, -9.58311651e-03f, -9.11356881e-02f,
  2.33663563e-02f, 1.09411450e-02f, -2.94627044e-02f, 7.47129880e-03f, -8.31327122e-03f, -5.16676120e-02f, -6.46546809e-03f, -6.57421723e-02f, -5.25869755e-03f, 6.89237192e-02f,
  6.56442866e-02f, -1.48223871e-02f, -3.83067876e-02f, -3.31755169e-02f, -5.94881177e-02f, 5.91563955e-02f, 4.09828760e-02f, -1.05101857e-02f, -1.63382397e-03f, -3.71542089e-02f,
  -7.96404555e-02f, 5.45465276e-02f, -2.96351891e-02f, 1.74073037e-02f, -1.82248354e-02f, -4.39715087e-02f, -3.72854918e-02f, 1.50311803e-02f, 9.10321474e-02f, 9.22437981e-02f,
  -2.27343485e-01f, 8.94924402e-02f, -1.62816532e-02f, -1.81089900e-02f, 5.15571907e-02f, 3.10054105e-02f, -3.41879167e-02f, -3.12985131e-03f, 1.04163714e-01f, -2.13574711e-02f,
  -5.87752163e-02f, -5.74787557e-02f, 3.76933143e-02f, -7.05095008e-02f, -1.12926411e-02f, -6.54335842e-02f, 1.02388650e-01f, -4.97315712e-02f, 2.65849405e-03f, -3.11461762e-02f,
  -6.61374012e-04f, -9.19473693e-02f, -3.17135797e-04f, 9.42831766e-03f, 5.55446930e-03f, -4.83438522e-02f, 2.70819124e-02f, -6.32486269e-02f, 1.75122209e-02f, -5.47154760e-03f,
  3.49619627e-01f, 3.93669307e-02f, 1.01386778e-01f, 1.67672075e-02f, -8.61184448e-02f, -4.08730150e-04f, 1.14215389e-01f, -4.13452089e-02f, -1.19817210e-02f, 8.96311849e-02f,
  5.26397415e-02f, -7.28106126e-02f, -8.61921087e-02f, -1.48800882e-02f, 1.22188754e-01f, 1.00597061e-01f, -4.67995144e-02f, -2.45916881e-02f, 1.07994594e-01f, 8.31874385e-02f,
  1.83550036e-03f, -7.83275068e-02f, 1.27147377e-01f, 8.00943747e-02f, -1.47975057e-01f, -5.19630872e-02f, -1.33151129e-01f, -1.25868797e-01f, -2.01402046e-02f, -3.12914491e-01f,
  2.35632528e-02f, -4.77906279e-02f, 7.00983703e-02f, -6.99473843e-02f, -7.33602718e-02f, -2.14476492e-02f, 1.30646331e-02f, -4.51841354e-02f, -7.24354247e-03f, -7.77601525e-02f,
  -1.03234837e-03f, -7.37844184e-02f, 5.51661141e-02f, -8.78722370e-02f, -5.67679070e-02f, 5.41917868e-02f, -3.45611796e-02f, 2.60195024e-02f, 5.78814857e-02f, 9.75387096e-02f,
  -8.56186971e-02f, -8.77848044e-02f, -2.79738437e-02f, 4.79734503e-02f, 3.38939391e-02f, 1.42356642e-02f, -1.04472451e-01f, -8.20721909e-02f, 5.36746159e-02f, -6.83181137e-02f,
  -3.83553468e-02f, 1.40797524e-02f, -3.37141789e-02f, -1.32302623e-02f, 8.75474885e-02f, 1.95125677e-02f, -1.94900651e-02f, -5.23896143e-02f, -5.70441596e-02f, 5.20182997e-02f,
  4.92721163e-02f, 1.06478997e-01f, -1.12823918e-02f, -9.45835635e-02f, -9.51787382e-02f, -3.90195251e-02f, -3.18369903e-02f, -5.04893512e-02f, 1.25570297e-02f, -4.51305509e-02f,
  -2.70399302e-02f, 1.63973682e-02f, 7.16688335e-02f, -3.09529882e-02f, -1.52629903e-02f, -1.24911033e-01f, 1.38053717e-02f, -4.00239117e-02f, -2.18041753e-03f, -1.07366359e-03f,
  1.52557120e-01f, -2.03335643e-01f, 4.84055802e-02f, 1.20236792e-01f, -3.61418799e-02f, 3.95550253e-03f, -2.77268682e-02f, -2.86646634e-02f, -6.76233396e-02f, 8.58677644e-03f,
  8.00865218e-02f, 3.28373089e-02f, 1.47920549e-02f, 9.31644291e-02f, 4.82669547e-02f, 6.46466836e-02f, 1.38629317e-01f, 2.09008995e-02f, 2.48103123e-02f, -2.44347230e-02f,
  1.77700713e-01f, 1.94667041e-01f, 1.99049816e-01f, 1.33577645e-01f, 2.74134129e-02f, 1.11794256e-01f, 1.23469487e-01f, -4.99187363e-03f, 1.05110615e-01f, 3.17296356e-01f,
  -2.20571429e-01f, 1.78290661e-02f, -1.36513382e-01f, -9.22596678e-02f, 4.63002361e-02f, -6.20570742e-02f, -1.07284114e-01f, 3.90157625e-02f, -3.18931900e-02f, -3.59738581e-02f,
  -1.66524071e-02f, 2.04081535e-01f, 1.35364935e-01f, 1.90594152e-01f, 1.15512855e-01f, 7.12321186e-03f, 1.27663553e-01f, -1.55559853e-02f, -3.31901610e-02f, 1.77613832e-02f,
  3.40447538e-02f, -7.79939219e-02f, -8.90202671e-02f, -4.92548719e-02f, 8.02885890e-02f, 3.03216726e-02f, 1.78290643e-02f, -8.14719275e-02f, -2.03728885e-03f, 2.57358879e-01f,
  -6.40553012e-02f, -6.69360310e-02f, 4.40543480e-02f, 8.13869573e-03f, -5.19040860e-02f, -1.84699968e-02f, -1.91680957e-02f, -9.78526920e-02f, 6.14410378e-02f, 7.54241198e-02f,
  1.07881337e-01f, 1.33955523e-01f, 6.26351461e-02f, 4.37607877e-02f, -6.10456355e-02f, -1.18208826e-02f, 7.53719453e-03f, -8.44509527e-02f, -5.03305756e-02f, -9.14411694e-02f,
  4.24862951e-02f, -1.36739016e-01f, -1.57394364e-01f, 1.84330624e-02f, -6.10093549e-02f, 1.19746141e-01f, -1.78147685e-02f, -7.56490529e-02f, -9.26202722e-03f, -5.20975292e-02f,
  -5.10032922e-02f, 9.28285271e-02f, -2.65727490e-02f, 9.21853911e-03f, 5.98944761e-02f, 1.51850376e-02f, 4.85886894e-02f, 8.02430436e-02f, 3.00586801e-02f, -3.95970009e-02f,
  4.63990979e-02f, -2.39677392e-02f, -8.00935179e-03f, -8.27287883e-02f, -1.38659272e-02f, -3.62432189e-02f, 5.23892678e-02f, -2.73841061e-02f, -3.79333347e-02f, 1.02209859e-01f,
  -7.21100792e-02f, -2.19866214e-03f, -1.01064496e-01f, 9.19983629e-03f, -1.54680694e-02f, 6.76301196e-02f, 3.24808955e-02f, -1.79663654e-02f, 7.34252972e-04f, 6.44557551e-02f,
  -2.18600318e-01f, 7.28767067e-02f, 1.27059951e-01f, 5.97710349e-02f, 1.22135114e-02f, 6.97289640e-03f, 6.05050810e-02f, -1.11020356e-02f, 6.37658164e-02f, -8.69286135e-02f,
  3.56881171e-02f, 7.24102110e-02f, 5.16709089e-02f, -1.10734981e-02f, -7.50650764e-02f, -4.76865731e-02f, -5.17353155e-02f, 6.57063946e-02f, 3.99767458e-02f, -7.86774307e-02f,
  -1.03434958e-01f, -1.15340717e-01f, -1.01601332e-01f, -6.34559467e-02f, 8.50669667e-02f, 3.44593413e-02f, -1.14654489e-01f, 1.11821545e-02f, -3.86303701e-02f, -2.22977072e-01f,
  2.07205683e-01f, -4.02255990e-02f, 2.94110179e-01f, 1.50208339e-01f, -1.54023573e-01f, -1.34013623e-01f, -1.15294665e-01f, -1.50806561e-01f, -1.54508531e-01f, -5.49026858e-03f,
  1.22095384e-01f, 1.32877856e-01f, 9.29338709e-02f, 1.27358153e-01f, 3.52885127e-02f, 1.20519236e-01f, 2.29605213e-01f, 1.15712613e-01f, 6.83396533e-02f, -1.06361590e-01f,
  -9.22091082e-02f, 5.25209121e-02f, 1.14890493e-01f, 1.32770864e-02f, -5.67023084e-02f, -1.17247021e-02f, 5.88938706e-02f, 4.80704419e-02f, -3.97228170e-03f, 1.08149230e-01f,
  2.90189743e-01f, 4.88281213e-02f, 8.39469507e-02f, 5.64292148e-02f, 1.24024320e-02f, 1.92729197e-02f, 6.38724938e-02f, -2.03459151e-02f, -8.13678280e-02f, 1.13347948e-01f,
  1.05744265e-01f, 6.77317455e-02f, 1.18536479e-03f, 7.01749846e-02f, -1.23425974e-02f, 3.91651466e-02f, 4.68267128e-03f, 4.29304056e-02f, 9.69026312e-02f, 2.78665628e-02f,
  -1.43104764e-02f, 3.83186527e-02f, 4.74630818e-02f, -2.43246667e-02f, -1.78573292e-03f, 1.48748886e-02f, 4.71631810e-03f, -3.86923365e-02f, -6.00002781e-02f, -1.01808362e-01f,
  2.86661126e-02f, 7.94818550e-02f, -2.50600707e-02f, -7.39660906e-03f, -2.22140141e-02f, 6.00231998e-02f, -1.28763244e-02f, 9.79221836e-02f, -6.54968917e-02f, 1.35583151e-02f,
  -4.66678180e-02f, -6.91463472e-03f, -2.81814728e-02f, -4.37275395e-02f, 1.45093799e-01f, 1.81459095e-02f, -1.55923711e-02f, 3.12533118e-02f, 9.86576155e-02f, -5.44394888e-02f,
  1.89620554e-02f, 3.60734090e-02f, 4.70160581e-02f, 4.11269767e-03f, 1.82292480e-02f, 4.73818816e-02f, -1.24889584e-02f, -1.87702905e-02f, 1.39893452e-03f, 5.10102287e-02f,
  -5.81471883e-02f, 4.25884277e-02f, 1.46424159e-01f, -1.37881013e-02f, 9.42559913e-02f, -5.23005240e-03f, 9.88520831e-02f, 5.71078174e-02f, 6.18674867e-02f, 3.39803845e-02f,
  5.51783927e-02f, 8.32759514e-02f, 4.14221920e-02f, -9.24481079e-02f, 4.31354679e-02f, 1.54727334e-02f, -4.27972004e-02f, 8.96199495e-02f, -8.08856040e-02f, 4.85438630e-02f,
  2.03823056e-02f, 2.60444526e-02f, 1.57639980e-02f, -9.60261226e-02f, -5.18214069e-02f, 7.50118494e-02f, -1.43632675e-02f, -1.01959489e-01f, 3.64451669e-02f, -1.72337517e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.06861241e-01f, -1.76639445e-02f, 1.26748487e-01f, 2.41012022e-01f, 2.43464410e-01f, 2.09904686e-01f, 1.13891318e-01f, 1.04379036e-01f, 1.45209566e-01f, -9.49448999e-03f,
  -3.43417302e-02f, 5.12586311e-02f, -3.93928625e-02f, 6.66107535e-02f, 8.71390030e-02f, 1.30341807e-02f, 5.35552911e-02f, 5.40273525e-02f, 7.93019831e-02f, 5.72944060e-02f,
  -1.91244055e-02f, -4.79812175e-02f, -6.19796105e-03f, 9.89545137e-02f, 1.08447663e-01f, 1.23576924e-01f, 2.23700167e-03f, 5.02610169e-02f, -5.89231253e-02f, 7.92028233e-02f,
  -2.05557682e-02f, 1.06969373e-02f, 8.72329921e-02f, -7.82597139e-02f, -3.99966799e-02f, 5.49004711e-02f, 3.98660079e-02f, 1.74464546e-02f, -6.26733452e-02f, 3.78741510e-02f,
  -7.09941685e-02f, -1.05006561e-01f, 6.26358315e-02f, 1.70496069e-02f, -1.88613050e-02f, 5.16146868e-02f, -1.10706709e-01f, 4.32800204e-02f, 8.89963582e-02f, -3.04654278e-02f,
  -7.57874595e-03f, 3.41576012e-03f, 1.61666162e-02f, -1.57019321e-03f, -7.76070496e-03f, -1.53052900e-02f, -3.12721021e-02f, 6.08329587e-02f, -3.93108390e-02f, -3.77502479e-02f,
  -3.76045741e-02f, 1.03140093e-01f, 7.14292899e-02f, 5.39166369e-02f, 1.01645917e-01f, -4.59546745e-02f, 2.70231552e-02f, -2.80065909e-02f, 9.21195298e-02f, -2.67835567e-04f,
  7.45258704e-02f, -5.81980199e-02f, 5.46832047e-02f, 6.87737837e-02f, 7.20138401e-02f, -4.71808352e-02f, -1.50557570e-02f, 9.18419624e-04f, -1.12305686e-01f, -1.37380110e-02f,
  5.81289195e-02f, -3.59424874e-02f, 8.81299302e-02f, -2.56527588e-02f, -2.67453883e-02f, -4.86520352e-03f, -1.53282443e-02f, 7.58630186e-02f, 9.26824510e-02f, -1.40651707e-02f,
  -9.56097022e-02f, -8.45847651e-02f, 7.45697320e-02f, -1.10751882e-01f, -5.24714822e-03f, 1.98546331e-02f, -7.47968778e-02f, -1.14785656e-01f, 4.72517386e-02f, -6.70236871e-02f,
  -5.45964157e-03f, -8.78710225e-02f, -1.25657450e-02f, 2.64704917e-02f, 1.00857422e-01f, 2.23292061e-03f, -1.22043625e-01f, 7.12406114e-02f, -6.98876614e-03f, -4.96318974e-02f,
  3.98246311e-02f, 1.02520958e-01f, 1.12534530e-01f, 4.56896052e-02f, 7.55529385e-03f, 1.06955245e-01f, -5.93277663e-02f, 9.07303616e-02f, 1.06710993e-01f, -5.14325611e-02f,
  -6.87246621e-02f, -1.00449724e-02f, -4.27569672e-02f, 3.20015736e-02f, 9.43332091e-02f, 8.71339440e-02f, 7.62385642e-03f, -6.33475631e-02f, -2.36172155e-02f, 6.46162033e-02f,
  9.78889540e-02f, -2.99324305e-03f, 5.68598621e-02f, -1.00031450e-01f, -9.45271179e-02f, -5.08427853e-03f, -9.69754234e-02f, 9.94199514e-03f, -5.13644256e-02f, 6.86488450e-02f,
  -4.25056182e-02f, -1.41362026e-02f, 1.72944216e-04f, -1.68870259e-02f, -3.52799334e-02f, 1.87268704e-02f, -8.11055303e-02f, 3.41990329e-02f, -6.40378147e-03f, -5.34228757e-02f,
  3.81564051e-02f, 4.98516671e-02f, -7.40043670e-02f, 9.68657061e-02f, 7.99915269e-02f, -7.29431659e-02f, 1.49015393e-02f, 8.06665607e-03f, -4.35416438e-02f, 4.64973971e-02f,
  -4.21839803e-02f, -5.59812710e-02f, 3.15445736e-02f, 5.64692393e-02f, -3.35614607e-02f, 5.35504892e-02f, 2.37348787e-02f, -5.89332506e-02f, 3.81365232e-02f, 5.72148785e-02f,
  7.46525228e-02f, 3.05411723e-02f, -8.73179361e-02f, 2.24877708e-02f, -5.78759722e-02f, -6.85490295e-02f, 5.66947125e-02f, -7.63052478e-02f, -8.71316567e-02f, -8.69859606e-02f,
  1.29938656e-02f, 3.12043965e-04f, 5.73406294e-02f, 1.95653532e-02f, 4.56332564e-02f, 1.13745933e-04f, 4.37305644e-02f, 4.66484912e-02f, 7.53118172e-02f, -2.91102566e-03f,
  2.13696007e-02f, 1.52503829e-02f, 8.29995349e-02f, 1.80336535e-02f, -7.35893175e-02f, 5.53855784e-02f, -6.19317107e-02f, 7.46235922e-02f, -8.00634623e-02f, -7.25832582e-02f,
  5.79014346e-02f, -8.60664696e-02f, 8.61558393e-02f, 9.30549651e-02f, -8.55598785e-03f, -9.40225646e-03f, -2.36365292e-02f, 8.61496553e-02f, -6.77883178e-02f, -1.98075511e-02f,
  -7.45314285e-02f, 3.94093692e-02f, 7.45741948e-02f, 9.23305452e-02f, 6.41748384e-02f, 8.63049999e-02f, 3.09195854e-02f, 9.19428840e-02f, 9.59589034e-02f, 8.97596497e-03f,
  -4.14193496e-02f, -8.87976438e-02f, -8.71539488e-02f, 2.02747509e-02f, -3.86812463e-02f, 5.87565601e-02f, 1.13969356e-01f, 2.96080634e-02f, 1.26077665e-03f, 1.11475820e-02f,
  3.01869214e-02f, 2.67333090e-02f, -6.38323948e-02f, 2.85763927e-02f, -8.29361472e-03f, -3.18179745e-03f, -3.76342377e-03f, -6.33024564e-03f, -3.70987654e-02f, -1.44287482e-01f,
  -1.31683871e-01f, -1.35721788e-01f, 5.08384891e-02f, 1.09867059e-01f, 1.36140376e-01f, 1.44500837e-01f, 2.28884652e-01f, 1.98977098e-01f, 1.14992097e-01f, 9.01293606e-02f,
  6.23825416e-02f, 7.20724836e-02f, -2.16054786e-02f, -5.81652333e-04f, 1.84844602e-02f, 6.22511841e-02f, 1.52466357e-01f, 1.73358455e-01f, 1.19394399e-01f, 1.58120602e-01f,
  3.19820293e-03f, 6.15309961e-02f, 4.12544049e-02f, 4.73388396e-02f, 1.71586365e-01f, 1.38872117e-01f, 8.80700573e-02f, 1.14558190e-01f, 9.08265039e-02f, 8.43833685e-02f,
  -6.22152761e-02f, -3.12532410e-02f, 1.12258561e-01f, 4.50434396e-03f, -9.75849107e-02f, -7.76247978e-02f, 1.56276654e-02f, -1.20705284e-01f, -7.25294724e-02f, -6.25312608e-03f,
  4.64882469e-03f, 3.73528376e-02f, -7.24718347e-02f, 2.16531996e-02f, 4.81848679e-02f, -1.00076899e-01f, -7.43434280e-02f, -2.30726339e-02f, 5.95746562e-03f, 5.17067872e-02f,
  1.19456127e-01f, -4.42335531e-02f, -3.28092016e-02f, 1.50392121e-02f, 6.18939362e-02f, 7.05176406e-03f, -1.00704968e-01f, -6.11342788e-02f, -9.04120505e-02f, -5.38631380e-02f,
  8.62557720e-03f, -1.82512309e-02f, 4.47233655e-02f, 1.71432905e-02f, -5.63903339e-02f, 6.98764473e-02f, 5.26136020e-03f, 9.72260982e-02f, 7.40408152e-02f, 1.67921111e-02f,
  -9.88893881e-02f, 2.38208044e-02f, 4.86031286e-02f, 4.96575870e-02f, -8.44838172e-02f, -2.23222040e-02f, 7.97707587e-02f, -8.24021250e-02f, -8.69148821e-02f, -3.15593742e-02f,
  4.61152010e-02f, 8.61002889e-04f, 5.26234247e-02f, 7.04297572e-02f, -8.05400833e-02f, -7.67148938e-03f, -2.07546931e-02f, -5.33614904e-02f, 3.21018547e-02f, -1.68824494e-02f,
  -4.90114503e-02f, 3.38820033e-02f, 1.46906469e-02f, 5.87462448e-02f, 1.77520663e-02f, -8.36517960e-02f, -1.00168809e-01f, 4.90961643e-03f, -1.33747652e-01f, 4.16278578e-02f,
  2.59939171e-02f, -1.00857385e-01f, 5.03829401e-03f, 2.78589670e-02f, 3.41022871e-02f, 2.15509087e-02f, 3.51592973e-02f, 1.30652055e-01f, -6.18227497e-02f, -5.80540998e-03f,
  2.58343238e-02f, 1.20557835e-02f, 1.20333284e-02f, -5.96113130e-02f, 1.01251833e-01f, 4.68253419e-02f, 6.50119409e-02f, 8.67713615e-02f, 7.48027787e-02f, -8.64944011e-02f,
  -1.36331946e-01f, -4.77695651e-02f, -1.11622572e-01f, -1.97636466e-02f, 1.33488923e-02f, 6.76253214e-02f, -1.25421315e-01f, 1.92644019e-02f, 3.51071954e-02f, -4.77896258e-02f,
  7.23316241e-03f, -5.91967367e-02f, 6.37647435e-02f, -5.41785434e-02f, -8.26531500e-02f, -1.26420200e-01f, -9.97228697e-02f, 1.65385613e-03f, -6.87949061e-02f, -4.83125597e-02f,
  1.24358805e-02f, 7.26611093e-02f, 7.17407763e-02f, -6.25012293e-02f, 5.54728881e-02f, 3.98259871e-02f, -8.53159279e-02f, -3.27432044e-02f, 4.01918106e-02f, 1.15438268e-01f,
  -5.66662215e-02f, 1.03625851e-02f, -1.90573484e-02f, -2.96243001e-02f, -3.22834291e-02f, 1.36573855e-02f, -2.61238201e-05f, 5.10046482e-02f, -8.72676894e-02f, -5.25401570e-02f,
  -1.49184652e-03f, -4.23802920e-02f, -5.19499481e-02f, -3.92314568e-02f, -7.95971379e-02f, 1.04439473e-02f, -5.48261367e-02f, -3.75551172e-03f, 7.89973810e-02f, -1.25275122e-03f,
  -2.27008834e-02f, 7.85287395e-02f, 5.02927266e-02f, 7.24657997e-02f, -3.01103517e-02f, 9.45395008e-02f, 1.30147617e-02f, 1.35733023e-01f, 2.72925477e-02f, 4.97200526e-02f,
  -2.98084039e-02f, 3.75173129e-02f, 1.50830541e-02f, -5.80968410e-02f, 1.49496300e-02f, 5.75257204e-02f, -2.08173133e-02f, 1.51271699e-03f, -3.67893390e-02f, -7.48427510e-02f,
  -3.00717391e-02f, 2.93075833e-02f, 7.68575519e-02f, -8.74527991e-02f, -4.21140976e-02f, -6.93090446e-03f, -6.12930618e-02f, 3.06024007e-03f, 6.19589314e-02f, -4.21902500e-02f,
  3.69957760e-02f, 3.89236510e-02f, -5.29008433e-02f, -6.37680516e-02f, -5.21685816e-02f, 7.71588907e-02f, -3.86081822e-02f, 4.92809042e-02f, -1.39736838e-03f, 9.82565656e-02f,
  -3.29718925e-02f, 4.52369228e-02f, 3.06005180e-02f, 4.45946679e-02f, -7.51925334e-02f, -2.62646116e-02f, -7.11839795e-02f, 2.84825359e-02f, 3.20810527e-02f, 4.41049710e-02f,
  7.02807009e-02f, -7.37577081e-02f, 1.12593770e-02f, 1.00067392e-01f, -3.37182656e-02f, 3.54344733e-02f, 1.35822175e-02f, 6.61598742e-02f, -4.76950314e-03f, 1.10853761e-01f,
  -3.59845944e-02f, -6.60636202e-02f, 9.01531987e-03f, -5.88667020e-02f, 8.99409596e-03f, -4.01821407e-03f, -2.12754216e-02f, 4.14952040e-02f, -1.00663483e-01f, 1.92059518e-03f,
  6.91517815e-02f, 2.09730696e-02f, 1.22115605e-01f, 9.12883058e-02f, -1.23097017e-01f, -1.27780631e-01f, -1.36111230e-01f, -7.28241652e-02f, 1.11309089e-01f, 1.94111411e-02f,
  7.88049698e-02f, 7.97340181e-03f, 5.88301383e-02f, 1.56158715e-01f, 8.33930597e-02f, 6.73040673e-02f, -3.18293795e-02f, 2.57947557e-02f, 5.98479025e-02f, -1.51567813e-02f,
  -1.39216036e-02f, 7.99152106e-02f, 6.75238669e-03f, 7.84503743e-02f, 3.06994710e-02f, 1.10004134e-01f, 3.72272134e-02f, 1.17710255e-01f, -1.66952293e-02f, 2.21325643e-03f,
  6.61654547e-02f, 9.67917070e-02f, 8.01297724e-02f, -2.61095054e-02f, -5.95119260e-02f, 7.01646656e-02f, 4.24767844e-03f, 2.99005099e-02f, 5.08881956e-02f, 7.75887817e-02f,
  -5.89823052e-02f, -2.80717667e-03f, 2.48980578e-02f, -3.42205502e-02f, 4.51771393e-02f, 6.00150153e-02f, 1.18918180e-01f, 1.35347217e-01f, -6.63480605e-04f, 1.02971315e-01f,
  -1.28510278e-02f, 4.52259630e-02f, -1.79806333e-02f, -1.99155454e-02f, 9.63445927e-04f, 4.41375747e-02f, 3.19607407e-02f, -1.91745199e-02f, -3.91724426e-03f, -1.81900058e-02f,
  1.26524776e-01f, 3.90607193e-02f, 1.21762760e-01f, -1.67628247e-02f, 3.23983021e-02f, -2.09227987e-02f, -4.58771959e-02f, -3.78700010e-02f, -4.58383821e-02f, -7.53436089e-02f,
  3.43479849e-02f, -2.22985186e-02f, 4.60358076e-02f, 7.04091787e-02f, -4.54336368e-02f, 8.07704031e-02f, 6.90963492e-02f, 3.45949568e-02f, 1.17205888e-01f, 9.63123590e-02f,
  5.03342003e-02f, -6.02710759e-03f, -1.62270684e-02f, 1.00216053e-01f, -1.70342494e-02f, -5.10001779e-02f, 1.18762357e-02f, -3.13526765e-03f, 4.81663272e-02f, 7.47741610e-02f,
  -4.82344404e-02f, -3.64925228e-02f, -2.88885590e-02f, 8.50049034e-03f, 3.17620039e-02f, 1.06379561e-01f, 4.15798239e-02f, -4.16537523e-02f, 2.38465425e-03f, -2.54800748e-02f,
  4.86889482e-03f, 7.09459484e-02f, 4.07555141e-02f, 3.64427753e-02f, -7.16738626e-02f, -5.63448742e-02f, 4.73917350e-02f, 7.11114034e-02f, 1.12451486e-01f, 8.35858956e-02f,
  -1.08692637e-02f, 7.76426913e-03f, 6.52205944e-02f, -2.36387402e-02f, 6.00326248e-02f, -2.91053299e-02f, 1.69985928e-02f, 4.33982164e-02f, -1.68585218e-02f, 3.45507413e-02f,
  1.13005027e-01f, -3.70836556e-02f, 1.44047234e-02f, 6.67746365e-02f, 3.07387523e-02f, -5.81757575e-02f, -1.05474778e-01f, -2.59620026e-02f, 6.08805753e-02f, 1.05456952e-02f,
  2.13496527e-03f, -3.34000327e-02f, 2.63691731e-02f, 8.58318247e-03f, 1.24627590e-01f, -9.40687656e-02f, 4.44473103e-02f, 8.45688358e-02f, -3.44284698e-02f, 6.15405254e-02f,
  5.07558659e-02f, -2.22059712e-02f, -1.22771580e-02f, 6.00748733e-02f, -3.40034254e-02f, -6.69571683e-02f, -5.78167923e-02f, -6.15755562e-03f, 5.85684925e-02f, -1.51263792e-02f,
  -9.54147242e-03f, 4.34902720e-02f, 6.15532361e-02f, -8.08927137e-03f, 5.28602749e-02f, 5.92912175e-03f, -3.89066376e-02f, 1.78736579e-02f, 5.88119738e-02f, -5.99782728e-02f,
  7.86280185e-02f, -4.85264324e-02f, -3.82193476e-02f, 1.06035676e-02f, -1.60266105e-02f, 9.47407186e-02f, -2.13155001e-02f, -6.39024377e-02f, 2.56500803e-02f, -6.50596842e-02f,
  -3.80317755e-02f, -6.71034828e-02f, -2.02989927e-03f, -7.71451443e-02f, 5.98593019e-02f, 1.93133801e-02f, 3.63140255e-02f, 1.08179808e-01f, 8.76703039e-02f, 8.13774988e-02f,
  -1.14912830e-01f, -2.25983243e-02f, -5.19120693e-02f, -5.03742211e-02f, 4.55507375e-02f, -3.39465104e-02f, 6.31876737e-02f, 4.48005227e-03f, 2.97692362e-02f, -3.75124887e-02f,
  -4.92632687e-02f, 2.32115481e-02f, 6.34700879e-02f, -5.34488708e-02f, 5.60538433e-02f, 4.61750850e-03f, -8.34530666e-02f, 8.59893393e-03f, -3.07861604e-02f, 8.09190795e-02f,
  1.65121034e-02f, -4.62209322e-02f, -2.49092504e-02f, 8.77665505e-02f, -5.97184338e-02f, -9.14274435e-03f, -2.05786135e-02f, 5.38204610e-02f, -6.10910282e-02f, -2.38730293e-02f,
  -2.29813177e-02f, 6.51476234e-02f, -6.14231192e-02f, 8.77826586e-02f, -3.53735615e-03f, 3.20750847e-02f, 1.81103703e-02f, 6.73410371e-02f, 2.22558957e-02f, 3.03577762e-02f,
  -2.40198486e-02f, -5.49799986e-02f, 1.68300383e-02f, 3.62057723e-02f, -6.15051463e-02f, -7.28700832e-02f, 7.91613534e-02f, 2.14355066e-02f, 2.42658090e-02f, -6.54338226e-02f,
  -3.44177932e-02f, 5.48726283e-02f, 8.71680975e-02f, -4.77553569e-02f, 5.95125882e-03f, 1.81819983e-02f, 9.44139287e-02f, -7.53340796e-02f, 3.13003920e-02f, -1.61099096e-03f,
  -7.06076324e-02f, 4.13294975e-03f, -1.95336074e-01f, 4.77085002e-02f, 6.29141033e-02f, 1.78857278e-02f, -2.98645422e-02f, 7.50072747e-02f, 1.62508234e-01f, -4.92839478e-02f,
  3.32208499e-02f, -1.53529560e-02f, -1.24308184e-01f, -1.28083363e-01f, -1.34073958e-01f, -1.58100650e-01f, -1.35083258e-01f, -1.57504946e-01f, -8.03524703e-02f, 2.85026133e-02f,
  2.19356269e-02f, -1.18766867e-01f, -1.52004853e-01f, -9.09681991e-02f, -9.26657673e-03f, -5.53042553e-02f, -1.18478745e-01f, -1.14270791e-01f, -7.49477819e-02f, -1.79559156e-01f,
  -1.63376212e-01f, 7.25439042e-02f, -2.40791421e-02f, 4.20170985e-02f, 9.01305452e-02f, 2.99881715e-02f, 2.67247222e-02f, -2.92965807e-02f, 2.95722131e-02f, 4.32248600e-02f,
  -3.06148622e-02f, 6.37603775e-02f, -5.18453941e-02f, 4.81760167e-02f, 7.02185258e-02f, 1.83156841e-02f, 5.83989173e-02f, -6.05329201e-02f, -4.91487840e-03f, 1.88809875e-02f,
  -7.09046051e-02f, -9.57993716e-02f, -5.31354100e-02f, 1.57135874e-02f, -4.64531220e-03f, 4.27844701e-03f, -5.05746938e-02f, 5.30529171e-02f, 1.96501482e-02f, 1.46313440e-02f,
  -5.96159026e-02f, 4.27183211e-02f, -7.35066682e-02f, 7.75949238e-03f, -3.25190313e-02f, -5.17434478e-02f, -8.85022432e-02f, -1.00431636e-01f, -1.19356558e-01f, 1.28856571e-02f,
  -2.84162145e-02f, 1.66803766e-02f, 7.73210600e-02f, -1.01465121e-01f, 1.45375831e-02f, -8.83027539e-03f, -6.65282086e-02f, -9.19868127e-02f, -9.54142660e-02f, -9.41154081e-03f,
  -3.51940878e-02f, -7.36358091e-02f, 7.07776472e-02f, -4.64124419e-03f, -6.82706237e-02f, -7.68389106e-02f, -2.23684926e-02f, 7.90467486e-02f, -1.35669755e-02f, 1.33160487e-01f,
  -2.67124083e-02f, -7.42451921e-02f, -5.54530807e-02f, -5.37845166e-03f, -3.67680914e-03f, -2.28357799e-02f, -5.12282662e-02f, -5.19580506e-02f, -5.13157167e-04f, 7.27624893e-02f,
  -5.57685569e-02f, 5.04239760e-02f, -6.95616677e-02f, 8.85648374e-03f, 7.10641369e-02f, -3.20566148e-02f, -4.07471973e-03f, -1.34176552e-01f, 3.56746763e-02f, 1.38065457e-01f,
  -6.72289506e-02f, -1.34300008e-01f, -1.24153204e-01f, -4.05066013e-02f, -3.77960652e-02f, -7.55264461e-02f, -1.26232743e-01f, 8.63744020e-02f, -3.78759503e-02f, -1.43824413e-01f,
  -3.82353485e-01f, 8.42104256e-02f, 3.94985303e-02f, -3.15795094e-01f, -6.28285902e-03f, 7.20469281e-02f, 3.90661806e-02f, -1.28120601e-01f, -1.88168764e-01f, -1.02852158e-01f,
  -2.32813153e-02f, -2.52031931e-03f, -5.37597723e-02f, 8.93131271e-02f, 4.09499928e-02f, -3.63455936e-02f, -1.12700425e-01f, -7.00625256e-02f, 1.44928098e-01f, 1.74076572e-01f,
  6.61318526e-02f, -1.37603819e-01f, -1.52779326e-01f, 1.94212757e-02f, -4.40184735e-02f, 5.86808249e-02f, 2.73481738e-02f, -4.21701148e-02f, 8.41088220e-02f, -1.70092523e-01f,
  2.64871985e-01f, -1.84142634e-01f, -5.04282564e-02f, -1.91462506e-02f, -4.06511314e-02f, 4.02245633e-02f, -1.87442508e-02f, -7.22967833e-02f, 8.13269895e-03f, -2.00706795e-02f,
  -3.81988138e-02f, 8.01850036e-02f, 4.81893681e-02f, 7.61308447e-02f, 2.72752605e-02f, -6.91701025e-02f, 6.94816932e-02f, -5.98949566e-02f, 2.68344786e-02f, 7.81085044e-02f,
  1.29748687e-01f, 6.04605041e-02f, -5.59749901e-02f, 1.78607047e-01f, -9.63300525e-04f, -8.78835469e-02f, 3.77717731e-03f, 6.21206500e-02f, 1.23086341e-01f, 1.19625837e-01f,
  3.16463672e-02f, -1.54581768e-02f, 6.32704496e-02f, 4.45616543e-02f, 3.80971581e-02f, 1.75419338e-02f, -1.26467934e-02f, 5.14742453e-03f, 9.03873518e-02f, -8.28810856e-02f,
  3.31041366e-02f, -2.76629459e-02f, 9.20794532e-02f, -2.19297297e-02f, -9.34528485e-02f, -7.83476159e-02f, -1.15384281e-01f, -7.79706752e-03f, -2.89641041e-03f, 1.95567235e-02f,
  -4.61757407e-02f, -1.48165777e-01f, 3.44148353e-02f, -7.35080056e-03f, -2.89109480e-02f, -4.10525203e-02f, 3.34097072e-02f, 6.61993027e-02f, 5.02452813e-02f, 2.49730656e-03f,
  6.64611235e-02f, -9.14155543e-02f, -1.10418737e-01f, 2.56196968e-02f, -7.22784698e-02f, -1.34542305e-02f, -4.09961790e-02f, -3.97890434e-02f, -7.73568684e-03f, -1.75484661e-02f,
  -2.41122395e-02f, 2.94370111e-02f, -5.16926087e-02f, 4.26174141e-02f, 9.68389660e-02f, -3.67803797e-02f, 5.69404997e-02f, -1.63223781e-02f, -1.07963672e-02f, -7.53690004e-02f,
  -1.32961115e-02f, -2.76460149e-03f, 7.40623102e-02f, 1.23630300e-01f, 5.43749891e-02f, 7.80327171e-02f, 3.86440307e-02f, 8.71747583e-02f, 5.89620061e-02f, 9.50056463e-02f,
  -1.54696956e-01f, 1.66325361e-01f, -1.49538025e-01f, 1.22685544e-01f, 1.06476650e-01f, -4.63744551e-02f, -1.08594172e-01f, 5.84893152e-02f, 5.91514334e-02f, 1.23651236e-01f,
  1.32161006e-01f, 2.78913695e-03f, 6.41902313e-02f, 5.76724634e-02f, -1.39723912e-01f, -3.73980515e-02f, -6.98178038e-02f, -1.52702898e-01f, -2.32224539e-01f, 4.76261461e-03f,
  1.06333956e-01f, 1.01148589e-02f, -1.29298463e-01f, -7.86014125e-02f, -5.45294816e-03f, -9.14757047e-03f, 3.79362963e-02f, -4.27347459e-02f, 8.30082372e-02f, 1.11965045e-01f,
  -1.18397223e-02f, -1.31506287e-02f, 3.97300497e-02f, 2.82419436e-02f, 7.20750317e-02f, -6.96382523e-02f, -3.19371521e-02f, -8.92710164e-02f, -2.37983745e-02f, 3.56619656e-02f,
  -6.95769340e-02f, -5.93284443e-02f, -5.49397692e-02f, -8.51409659e-02f, -1.03257254e-01f, -8.46744999e-02f, -1.28095299e-01f, -7.86200762e-02f, -3.65803298e-03f, -8.76025185e-02f,
  6.23213686e-02f, -2.75093392e-02f, 2.59336382e-02f, 5.11747301e-02f, 1.59249187e-03f, -9.43694040e-02f, -9.95563194e-02f, -9.54731461e-03f, -4.47872579e-02f, -5.66713773e-02f,
  -3.07240672e-02f, -9.42061469e-02f, 2.39007976e-02f, -7.96522647e-02f, -9.84450057e-02f, -2.82263625e-02f, -8.62417221e-02f, -3.08557786e-02f, -3.48936464e-03f, 1.05295377e-02f,
  -3.18419933e-02f, -1.18189208e-01f, -6.63052574e-02f, 5.57846501e-02f, -6.16831193e-03f, -5.23001887e-02f, -7.25645795e-02f, -8.77361000e-02f, -2.77217459e-02f, -3.73743265e-03f,
  -7.86037967e-02f, -5.12088537e-02f, 8.84687062e-04f, 5.98909967e-02f, -8.16293657e-02f, -1.02210537e-01f, -7.62044862e-02f, -7.30843470e-02f, 1.61185805e-02f, 4.02227677e-02f,
  2.28782129e-02f, -8.21083263e-02f, 6.71079606e-02f, -5.96691854e-02f, 4.55427952e-02f, 9.41243917e-02f, 3.60760204e-02f, 7.61273950e-02f, -6.60462352e-03f, 6.90701418e-03f,
  -6.00814528e-04f, -1.30684137e-01f, 2.45496482e-02f, -4.12600338e-02f, -1.59099530e-02f, -4.61823829e-02f, 9.61943157e-03f, -8.80355239e-02f, -2.66734455e-02f, -8.73868465e-02f,
  1.25957793e-02f, -7.69082829e-02f, 5.17395958e-02f, -4.55263369e-02f, 2.77025960e-02f, -2.83224173e-02f, -1.26669988e-01f, -5.39867654e-02f, -5.60821481e-02f, -2.07984857e-02f,
  -1.60856955e-02f, 1.34631902e-01f, -2.14259569e-02f, 1.77377701e-01f, 6.30431622e-02f, -1.05542451e-01f, -2.05887511e-01f, -8.95412490e-02f, 1.34161711e-01f, 1.45406604e-01f,
  3.09739783e-02f, -1.52982411e-03f, -5.12713492e-02f, -8.58711377e-02f, -1.10427313e-01f, -1.00545332e-01f, -6.30740374e-02f, -1.37634873e-02f, -1.66652754e-01f, 1.44929374e-02f,
  1.67525619e-01f, 4.54542004e-02f, -2.62056999e-02f, -7.57072568e-02f, 1.25680283e-01f, -1.87142733e-02f, 1.14903770e-01f, 1.13320380e-01f, 1.34599730e-01f, 2.79159069e-01f,
  1.82998195e-01f, 2.96381544e-02f, -1.16323791e-01f, 1.18457049e-01f, 5.51459044e-02f, -9.10953805e-03f, -9.62418243e-02f, 7.96235874e-02f, -4.82138656e-02f, 7.71118030e-02f,
  4.33552042e-02f, -3.67076285e-02f, 5.67596145e-02f, -6.38566911e-02f, 1.91896912e-02f, -6.53719157e-02f, -8.09898414e-03f, -3.64477597e-02f, -6.85442463e-02f, -3.55991349e-02f,
  7.09501132e-02f, 6.42080605e-02f, -1.75479930e-02f, -1.20516211e-01f, -1.13383822e-01f, -4.09867689e-02f, -6.70898193e-03f, 8.66934508e-02f, 9.04586818e-03f, 5.42313084e-02f,
  -1.14438877e-01f, -1.13201194e-01f, 6.77728280e-02f, 5.11102863e-02f, -4.71971482e-02f, -1.03097782e-01f, -1.43759120e-02f, 2.54357303e-03f, -3.39411274e-02f, 2.76299547e-02f,
  -7.76061937e-02f, -4.70146351e-02f, -7.47102126e-02f, -2.08010413e-02f, -6.67461753e-02f, 6.48830906e-02f, 4.33609858e-02f, -3.54944877e-02f, -5.68973981e-02f, 3.90214399e-02f,
  5.53084575e-02f, -4.41505499e-02f, 1.67291390e-03f, -6.93630651e-02f, 9.68229622e-02f, -9.00894694e-04f, -5.98223247e-02f, -1.83865540e-02f, -7.52093494e-02f, -1.65119562e-02f,
  1.19085908e-01f, -1.75835893e-01f, 1.02711715e-01f, 2.73793489e-02f, 2.46772524e-02f, -6.20446987e-02f, 2.23399457e-02f, -2.19882857e-02f, -5.38328774e-02f, 7.29292259e-02f,
  3.21874954e-02f, -6.45709559e-02f, -2.80743949e-02f, -5.61335385e-02f, 5.31232916e-02f, 5.43433316e-02f, 1.70024671e-02f, -7.21209571e-02f, 7.66273811e-02f, 7.41621256e-02f,
  8.10749829e-02f, -1.07968822e-01f, 1.98953878e-02f, -1.00106575e-01f, 4.02774028e-02f, 2.73559298e-02f, -1.04778752e-01f, -1.28118619e-02f, -1.21603854e-01f, -9.83571112e-02f,
  -2.35590205e-01f, -4.37281057e-02f, 3.75128649e-02f, -2.82959908e-01f, 5.74791990e-02f, -3.63331810e-02f, 1.22582182e-01f, 2.53361790e-03f, -1.50590390e-01f, -5.24734445e-02f,
  -3.92105132e-02f, 7.90563300e-02f, -7.07199574e-02f, 2.01507355e-03f, 3.06844916e-02f, 6.74217567e-02f, -1.55668944e-01f, 2.08686292e-02f, 4.73651476e-02f, 8.17600414e-02f,
  6.87569082e-02f, -8.29235315e-02f, -1.55827060e-01f, 2.28994582e-02f, -8.26056525e-02f, 2.12923232e-02f, 1.48757143e-04f, 1.06922034e-02f, 1.08703203e-01f, -1.80894509e-01f,
  1.82912618e-01f, -1.32737622e-01f, 9.77407321e-02f, -5.56888431e-02f, -2.35061981e-02f, -4.29806113e-02f, 5.42717651e-02f, 1.58486627e-02f, 2.54411008e-02f, 1.32914586e-02f,
  -8.61084927e-03f, -3.05359010e-02f, -8.00031349e-02f, 1.04422197e-01f, -1.57793332e-02f, 1.31304646e-02f, -1.73001532e-02f, -2.89509650e-02f, -9.18131396e-02f, -4.86651324e-02f,
  -1.22858137e-02f, -1.30484506e-01f, -6.35825321e-02f, -4.33227159e-02f, 7.25538880e-02f, -2.56805532e-02f, -2.52847057e-02f, 4.15945100e-03f, 6.57761544e-02f, -5.05079739e-02f,
  -4.24878933e-02f, -1.41974688e-02f, -4.23935661e-03f, -8.36691931e-02f, -3.10261752e-02f, 2.15395838e-02f, -6.51014075e-02f, 3.60363424e-02f, 6.69140071e-02f, 8.86550471e-02f,
  5.16615994e-02f, 5.59224412e-02f, -5.60156442e-02f, 3.64054367e-02f, 3.05600036e-02f, -4.59887311e-02f, 2.09350772e-02f, 6.49921745e-02f, 1.50704174e-03f, 2.45199744e-02f,
  8.00439566e-02f, 1.86893847e-02f, 3.01571526e-02f, -2.27924939e-02f, 5.13704494e-03f, -7.63250887e-02f, -1.05720740e-02f, 1.65538415e-02f, 6.51608873e-03f, -6.80450574e-02f,
  5.69041912e-03f, -1.19358666e-01f, -2.32355110e-03f, -6.41759336e-02f, -6.99622259e-02f, -7.64317364e-02f, 3.53829819e-03f, 2.69132368e-02f, -8.48559011e-03f, -1.74949691e-02f,
  1.16896570e-01f, 3.47008444e-02f, 8.02542716e-02f, -1.48078687e-02f, 5.92915788e-02f, -1.68799292e-02f, -6.26822188e-02f, 2.06634839e-04f, 8.56527537e-02f, -5.96193597e-03f,
  -3.44000235e-02f, 6.95132241e-02f, -1.20792538e-01f, 6.47730902e-02f, -5.91759086e-02f, -9.82183218e-02f, 3.42559814e-02f, 1.01970181e-01f, -3.06351390e-03f, 6.95890784e-02f,
  -1.59013029e-02f, -1.21435955e-01f, 1.92852486e-02f, -2.51302123e-02f, 1.14115357e-01f, 1.04508661e-01f, -3.24617289e-02f, -4.73091900e-02f, -3.24249454e-02f, 3.93001623e-02f,
  4.96241031e-03f, -7.99876973e-02f, 5.73337898e-02f, -5.61108515e-02f, 2.00920869e-02f, -3.83431017e-02f, -3.46393101e-02f, 1.09693184e-01f, 6.78966567e-02f, -4.29703481e-02f,
  -2.09027939e-02f, -8.12269896e-02f, -3.83640118e-02f, 3.83666530e-02f, -3.57940607e-02f, -2.71332990e-02f, 1.50634591e-02f, -6.45364299e-02f, 1.80636756e-02f, 3.93183678e-02f,
  2.66897697e-02f, 1.65285636e-02f, -2.90263686e-02f, -8.27673674e-02f, -1.77242812e-02f, 3.32798585e-02f, 9.57281440e-02f, 7.70877600e-02f, 1.15780495e-01f, 1.03709020e-01f,
  -4.96583581e-02f, 4.96373698e-02f, -3.74945886e-02f, 1.12999149e-03f, 3.91679909e-03f, -7.83792958e-02f, -1.55593352e-02f, -3.21638733e-02f, -5.88332943e-04f, -5.07417209e-02f,
  -5.44712581e-02f, 4.41809036e-02f, 5.24778664e-02f, -3.03704608e-02f, -2.79892478e-02f, -3.25588845e-02f, -1.08584221e-02f, 4.43674922e-02f, -5.22046164e-02f, 2.01114267e-02f,
  6.58672750e-02f, -1.20608229e-02f, -3.99307460e-02f, -4.91868891e-02f, 7.83748180e-02f, 8.40063542e-02f, -8.32316130e-02f, -5.99273108e-02f, -8.96304026e-02f, 3.81920896e-02f,
  4.49974686e-02f, -7.76733179e-03f, -8.93416926e-02f, 6.84922114e-02f, -1.54928407e-02f, -2.48130783e-02f, -4.37815022e-03f, -1.93667840e-02f, -8.53347126e-03f, 1.51639897e-02f,
  -3.28417099e-03f, -5.34776561e-02f, -1.81773044e-02f, 8.56133550e-03f, -3.27401534e-02f, 3.51377856e-03f, 4.61311191e-02f, 4.95703630e-02f, -9.49841812e-02f, -1.01802997e-01f,
  -2.68281475e-02f, -2.67251097e-02f, 7.35822991e-02f, -3.75709608e-02f, 3.03973183e-02f, -2.20226683e-02f, 2.11126674e-02f, -2.53485478e-02f, 2.13321894e-02f, 8.25926811e-02f,
  5.55400401e-02f, 9.82855186e-02f, 7.06882775e-02f, 6.49627447e-02f, 1.21067457e-01f, -9.32142511e-03f, 7.17143416e-02f, 1.68510471e-02f, -2.25472059e-02f, -5.97875044e-02f,
  6.84337169e-02f, 1.40796483e-01f, 1.72914132e-01f, -1.04698595e-02f, 5.42804301e-02f, 1.15776032e-01f, 7.76332570e-03f, 9.44196582e-02f, 1.40758812e-01f, 1.04490444e-01f,
  -1.05794042e-01f, -5.56963263e-04f, -1.08655155e-01f, -1.00052677e-01f, 1.33762449e-01f, 8.90960991e-02f, -6.09935410e-02f, -5.27580734e-03f, -1.15192756e-02f, -6.02058806e-02f,
  -9.98940878e-03f, -9.18965042e-03f, -1.36530876e-01f, -7.37457536e-03f, -1.30665183e-01f, -2.21949115e-01f, -1.92523137e-01f, -2.51721442e-01f, -1.37612879e-01f, 5.52012436e-02f,
  -5.43131642e-02f, -2.44150683e-03f, -5.42645939e-02f, -7.71030039e-03f, 1.39699802e-01f, 1.17104903e-01f, -9.31695551e-02f, -1.98618621e-02f, 1.93696581e-02f, -9.90623236e-03f,
  -1.88054621e-01f, 9.20315087e-02f, 8.82015824e-02f, -7.75244310e-02f, 3.90393920e-02f, -1.14707360e-02f, -5.68941012e-02f, -7.28265271e-02f, 9.97585729e-02f, -5.72165139e-02f,
  4.65683192e-02f, 6.99506551e-02f, -3.69849913e-02f, -3.15952525e-02f, -6.58380613e-02f, 5.02976775e-02f, 6.47714734e-02f, -4.01387103e-02f, 2.95199696e-02f, 7.77781829e-02f,
  7.70567581e-02f, -5.14624529e-02f, -4.14806642e-02f, 9.80808027e-03f, 2.87414938e-02f, -9.46354046e-02f, 1.50050089e-01f, 1.12187102e-01f, 8.67397059e-03f, 1.28752232e-01f,
  -6.70370925e-03f, -6.19760007e-02f, 1.11685716e-01f, 4.94096018e-02f, 4.49047908e-02f, 1.81654170e-02f, 3.67271863e-02f, -2.97750626e-02f, -1.63201410e-02f, 4.16810140e-02f,
  -5.17018735e-02f, -3.98766510e-02f, -6.36764839e-02f, -5.42114116e-02f, 2.10118610e-02f, 5.54777160e-02f, 7.57493898e-02f, -3.94033566e-02f, 6.56763539e-02f, -5.75070793e-04f,
  -1.13096070e-02f, 6.96744919e-02f, 5.32657746e-03f, 8.52901265e-02f, 9.38229635e-02f, 5.05413450e-02f, 9.29611176e-02f, -7.43817315e-02f, -5.90302125e-02f, -2.65185237e-02f,
  2.94052735e-02f, -8.13371986e-02f, -6.61484823e-02f, 5.88919483e-02f, -1.69324260e-02f, 5.23241311e-02f, 6.52818605e-02f, 4.97938469e-02f, -5.84968701e-02f, 3.56616974e-02f,
  9.84046906e-02f, -5.41531928e-02f, -3.02743521e-02f, 7.07013905e-02f, -1.87827777e-02f, 7.23455974e-04f, -5.95158376e-02f, 1.04385868e-01f, 7.08066896e-02f, 7.35833123e-02f,
  5.37657328e-02f, 5.25341593e-02f, 2.60935910e-02f, 2.10488643e-02f, 1.57955270e-02f, -1.14691444e-01f, -5.52623197e-02f, -1.70852058e-03f, 3.85129964e-03f, -7.28921443e-02f,
  2.31469870e-02f, 5.29696196e-02f, 5.79594634e-03f, 3.19418055e-03f, 4.08200407e-03f, 8.57217163e-02f, -5.50031364e-02f, 1.99320372e-02f, 5.24618365e-02f, 3.48708443e-02f,
  -5.12777120e-02f, -1.54443616e-02f, -4.58603427e-02f, 4.08660956e-02f, -9.24582332e-02f, 1.17480502e-01f, 1.22962873e-02f, 6.74400404e-02f, -6.15449920e-02f, -7.04610795e-02f,
  6.82152808e-02f, -1.22013902e-02f, 4.76129167e-02f, -2.90400125e-02f, 3.57056446e-02f, -4.31251563e-02f, -3.13917845e-02f, -4.66949120e-02f, 3.33231091e-02f, 1.14701137e-01f,
  -5.23018762e-02f, 8.82585347e-02f, -7.80595019e-02f, 2.62814108e-02f, 9.04392917e-03f, -1.44487303e-02f, -1.04847901e-01f, -9.16019157e-02f, -5.73490895e-02f, -5.17497100e-02f,
  4.61096987e-02f, -5.92878573e-02f, 4.56930622e-02f, -4.45095152e-02f, -7.86330402e-02f, 2.63928599e-03f, 4.42431793e-02f, -6.65819198e-02f, 1.32477889e-02f, -4.13445532e-02f,
  6.99941590e-02f, -5.56659102e-02f, 9.37641710e-02f, -7.10610747e-02f, 1.51536835e-03f, 1.59364715e-02f, -3.44361737e-02f, -2.44836509e-02f, 1.23104500e-02f, 5.67073748e-03f,
  -2.14130301e-02f, 7.06705451e-02f, 1.35663934e-02f, -6.44416809e-02f, -2.72994600e-02f, 8.74624588e-03f, -3.78780975e-03f, -4.07813489e-02f, -7.09400102e-02f, 8.86928141e-02f,
  -5.04508317e-02f, -3.72577943e-02f, -4.88576330e-02f, 2.07503662e-02f, 5.54523841e-02f, -1.03424881e-02f, -3.08631752e-02f, -8.68273526e-02f, 9.16834176e-02f, -5.50164506e-02f,
  7.51632324e-05f, 3.41376625e-02f, -9.38603878e-02f, -5.54772615e-02f, 6.15937710e-02f, -4.48098555e-02f, -1.54797435e-02f, 2.74990499e-02f, -5.68120331e-02f, -6.47824854e-02f,
  -3.46611440e-02f, -1.21488638e-01f, -3.90585884e-02f, 3.80750932e-02f, -3.23675238e-02f, -8.03241134e-02f, -6.68668523e-02f, 2.75055692e-02f, -6.26810789e-02f, -1.58102047e-02f,
  -7.28820562e-02f, -3.70248668e-02f, -7.95073733e-02f, 4.80586961e-02f, -6.47662431e-02f, -7.17466027e-02f, 3.48773263e-02f, -6.97116256e-02f, -8.88211727e-02f, 4.23958115e-02f,
  3.00494432e-02f, -6.40161484e-02f, -6.20041555e-03f, 6.08355589e-02f, 7.70321041e-02f, -8.55884328e-03f, -8.40426683e-02f, -6.68061227e-02f, -1.45380935e-02f, 6.51294962e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -2.96119833e-03f, -2.99731502e-03f, 2.29347907e-02f, 1.67208053e-02f, -3.38479578e-02f, -1.18699204e-02f, 9.48684514e-02f, 9.21005234e-02f, 8.22028965e-02f, 1.49856880e-01f,
  1.23516671e-01f, -6.05370104e-03f, 9.09714252e-02f, 4.98924330e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  5.97812831e-02f, -7.87688419e-02f, 1.36714559e-02f, -1.10331602e-01f, 3.88740450e-02f, -5.23648672e-02f, -3.93714085e-02f, 1.14130648e-02f, 3.90333608e-02f, 3.66181321e-02f,
  6.22413196e-02f, -1.38738202e-02f, 2.94634495e-02f, -1.07576102e-01f, 4.63625602e-02f, 7.03256130e-02f, 9.58788693e-02f, -8.86532888e-02f, 1.08574845e-01f, 9.62633491e-02f,
  -1.09568343e-01f, -3.24411504e-02f, -4.86976057e-02f, -6.70322031e-02f, -6.51332960e-02f, 1.05931915e-01f, 6.54267445e-02f, 4.17652763e-02f, 1.09705016e-01f, 4.93688524e-01f,
  -1.87860504e-01f, 7.06411600e-02f, -9.79233459e-02f, 1.95636764e-01f, 1.57399401e-01f, 2.38252953e-02f, 1.43860266e-01f, 3.13526802e-02f, 3.09964083e-02f, -1.07442036e-01f,
  -2.17670888e-01f, -1.00272954e-01f, -1.90468151e-02f, 2.91368570e-02f, 3.58674191e-02f, 3.90944071e-02f, -1.40830815e-01f, 2.33277991e-01f, 1.08205497e-01f, -2.57476062e-01f,
  5.57614379e-02f, -8.37466940e-02f, 1.72275528e-01f, -1.97942704e-02f, -5.02483658e-02f, -3.74678932e-02f, 8.41426775e-02f, 9.94104296e-02f, -8.73241667e-03f, -1.02296524e-01f,
  7.73158371e-02f, 1.60577390e-02f, -6.33314531e-03f, -1.32717146e-02f, -1.79904103e-01f, -1.91940457e-01f, -1.48821428e-01f, 2.98417434e-02f, -6.21982440e-02f, 7.44492486e-02f,
  -1.03870623e-01f, -5.90190813e-02f, -1.05509773e-01f, -1.35966465e-01f, 1.40336886e-01f, -1.00720830e-01f, 1.35608716e-03f, -1.52784079e-01f, 8.89076293e-02f, -2.15332443e-03f,
  -1.33642003e-01f, -9.04264227e-02f, -9.73535851e-02f, -1.33315027e-01f, -7.70656615e-02f, -8.69641677e-02f, 7.81537890e-02f, -2.07409397e-01f, 1.73952281e-01f, 1.27360478e-01f,
  -2.06704810e-01f, -4.59846966e-02f, -1.14479460e-01f, 2.20695794e-01f, 3.92184593e-02f, 7.97978267e-02f, -1.34526357e-01f, -4.90152836e-02f, 2.04183131e-01f, 2.46018134e-02f,
  2.28926450e-01f, 6.78022653e-02f, -2.27690548e-01f, -1.33806346e-02f, -1.97186694e-01f, -1.49866641e-01f, 3.13643441e-02f, 9.57693830e-02f, 5.26564419e-02f, -3.23600829e-01f,
  2.03717083e-01f, -4.08479460e-02f, 1.08065799e-01f, -1.34046197e-01f, 1.24732144e-01f, 1.45729231e-02f, 1.15035459e-01f, -3.76552157e-02f, -1.99620873e-01f, 2.64053140e-02f,
  -5.59884608e-02f, 2.13289380e-01f, -7.84488469e-02f, -6.31830245e-02f, 1.82102129e-01f, -4.15745527e-02f, 7.82637671e-02f, -2.61639860e-02f, 3.42093920e-03f, -1.21716745e-01f,
  2.63496228e-02f, 3.52842286e-02f, 5.90635054e-02f, 1.07103750e-01f, -8.85286257e-02f, -7.88355339e-03f, -1.54760815e-02f, 5.69534348e-03f, -1.84591375e-02f, 6.65538460e-02f,
  1.01684786e-01f, -5.65760843e-02f, -8.07164311e-02f, -1.12704247e-01f, -5.75009696e-02f, 2.85333786e-02f, -1.11688524e-01f, -1.65322982e-03f, -1.11626051e-01f, -1.08965263e-01f,
  -1.57211959e-01f, -2.47434378e-02f, 1.10232905e-01f, 1.01185396e-01f, -1.85872450e-01f, -1.02885656e-01f, -1.29734039e-01f, -3.98839861e-01f, 2.36129090e-01f, -5.94879240e-02f,
  -2.47624621e-01f, -1.33262664e-01f, -2.66343765e-02f, -1.86921716e-01f, -9.83550102e-02f, -1.00106463e-01f, 1.18379116e-01f, 6.92780986e-02f, 6.37031868e-02f, 3.07240576e-01f,
  -6.88220188e-02f, -2.16530442e-01f, 3.42248082e-02f, -2.87769735e-01f, 2.76321232e-01f, -2.56813198e-01f, 1.90539181e-01f, -2.13734377e-02f, 7.08518475e-02f, 7.51506910e-02f,
  8.35823342e-02f, -2.34088749e-02f, 6.88958855e-04f, 2.64304262e-02f, 6.63273316e-03f, -6.41155913e-02f, 1.39608383e-01f, 1.20901167e-01f, -9.62583944e-02f, -1.32065669e-01f,
  -1.53694406e-01f, 1.42586783e-01f, -5.14102764e-02f, 7.12290108e-02f, -1.30743645e-02f, 2.72348914e-02f, -1.11860529e-01f, -8.09394270e-02f, -3.48047987e-02f, -1.31641002e-02f,
  -4.15813737e-02f, 1.76622719e-01f, 1.03035793e-01f, -7.66801536e-02f, 1.04916222e-01f, -1.31493196e-01f, 2.21460257e-02f, 1.30552471e-01f, 1.52068108e-01f, 2.30745420e-01f,
  8.78495872e-02f, 5.10018691e-03f, 8.07961971e-02f, -6.23079799e-02f, 1.62996605e-01f, 8.78615491e-03f, 1.41363412e-01f, -1.77840233e-01f, 1.78791016e-01f, -1.35412142e-01f,
  -1.04305997e-01f, -1.50925413e-01f, 1.77648687e-03f, -2.35120475e-01f, -2.12141499e-02f, -8.46933387e-03f, -3.36134546e-02f, 2.12142870e-01f, 9.82297398e-03f, -1.53271749e-03f,
  8.73717200e-03f, -8.52242932e-02f, -2.33775545e-02f, -1.46154270e-01f, 7.91154504e-02f, 6.38877526e-02f, 1.32107958e-01f, 7.91407302e-02f, 2.89283674e-02f, 2.47222140e-01f,
  -2.00329795e-01f, -2.56915092e-02f, -7.30753466e-02f, -6.23004586e-02f, -7.54800513e-02f, -9.23071653e-02f, -1.21290833e-01f, 9.72655341e-02f, -1.87519804e-01f, 1.10433631e-01f,
  -1.60046741e-01f, -2.49718986e-02f, 1.20138213e-01f, -6.78636208e-02f, -2.12264434e-01f, -7.86613747e-02f, -3.87889221e-02f, -1.10145018e-01f, -6.71061948e-02f, 7.08501264e-02f,
  -9.65761095e-02f, -4.23160903e-02f, 1.10406689e-01f, -1.10780463e-01f, -1.65932387e-01f, 1.74525157e-02f, -1.72038563e-02f, -3.21181342e-02f, -8.91713053e-02f, -1.53640464e-01f,
  9.23306718e-02f, 3.03615667e-02f, -7.46019930e-02f, 9.36065540e-02f, -1.56189159e-01f, -8.42792448e-04f, 8.47180560e-03f, 5.16325310e-02f, 6.65351078e-02f, -1.30806595e-01f,
  1.52782664e-01f, -1.24100819e-01f, 2.82056540e-01f, -1.50264144e-01f, -6.82465062e-02f, 1.92034051e-01f, 9.84769315e-02f, -1.79377273e-01f, 8.08098540e-02f, -5.25005598e-05f,
  8.66450183e-03f, 1.88250132e-02f, 4.88413312e-02f, 1.26763120e-01f, -8.20285268e-03f, 7.99544379e-02f, -3.03156544e-02f, -1.02622829e-01f, -8.56481120e-03f, 3.70802954e-02f,
  1.39970481e-01f, 8.21223781e-02f, -9.64209437e-02f, 1.98723212e-01f, -4.87266257e-02f, 8.65217820e-02f, 9.01955962e-02f, 6.53178915e-02f, 7.41651729e-02f, -6.00363016e-02f,
  -1.05627842e-01f, 3.61483619e-02f, -1.87870234e-01f, -1.37697846e-01f, -9.82390791e-02f, -4.87377159e-02f, -1.35681465e-01f, 5.95913455e-02f, -1.87987983e-02f, 7.42012933e-02f,
  1.46509096e-01f, 5.50628118e-02f, 2.36258823e-02f, 1.80480272e-01f, -2.90667508e-02f, 4.82694106e-03f, -9.20519456e-02f, 1.79216504e-01f, 3.83874103e-02f, -1.07050046e-01f,
  -1.14741631e-01f, -1.40246272e-01f, 1.14006124e-01f, -8.13608766e-02f, 8.59297439e-02f, -7.43019506e-02f, 5.39137237e-02f, -1.50976956e-01f, -1.86093580e-02f, 1.06928103e-01f,
  -3.29062380e-02f, -6.87753260e-02f, 6.14389628e-02f, -4.67565767e-02f, -6.91083968e-02f, -2.38382956e-03f, 2.41185993e-01f, 6.68655708e-03f, -2.63029307e-01f, 7.29726031e-02f,
  2.93447137e-01f, 4.54192981e-02f, -9.51586291e-02f, -1.55636549e-01f, 9.21596512e-02f, -1.41731631e-02f, -1.95323870e-01f, -4.99528870e-02f, 1.30939826e-01f, 2.46917903e-01f,
  2.49424186e-02f, 2.30394498e-01f, -4.41089608e-02f, -4.74018194e-02f, 2.12255448e-01f, 1.40889939e-02f, 2.83108838e-02f, -7.52785206e-02f, -1.01808123e-01f, -2.49773860e-02f,
  9.59731266e-02f, 2.15347502e-02f, 1.57929584e-01f, -6.29786849e-02f, 3.19138281e-02f, -9.46766287e-02f, -5.97840473e-02f, -2.64255643e-01f, 1.31709948e-01f, 1.86046571e-01f,
  -2.01097667e-01f, -5.06572649e-02f, 1.25713286e-03f, -2.76945401e-02f, 2.26006415e-02f, 2.82123331e-02f, 3.42827812e-02f, -2.01320443e-02f, 3.61483451e-03f, -3.82210165e-02f,
  -1.54078409e-01f, -1.43439043e-03f, 1.18441887e-01f, -1.73019469e-01f, -4.11010608e-02f, -1.87327623e-01f, 2.78799050e-02f, -8.25201496e-02f, -1.75105795e-01f, -6.57392964e-02f,
  -8.31741318e-02f, -2.24426806e-01f, -3.22456956e-02f, -8.24060366e-02f, -1.29916161e-01f, 2.10832488e-02f, -1.03975870e-01f, -9.44003835e-02f, -3.95004544e-03f, -2.17304658e-02f,
  6.60636276e-02f, 1.04747772e-01f, 9.30267200e-02f, -1.88500047e-01f, -1.88830607e-02f, -2.82852501e-02f, 5.59653789e-02f, -3.44146825e-02f, -1.52058750e-01f, -1.52076915e-01f,
  -3.08305062e-02f, -1.67322475e-02f, 7.37764165e-02f, -3.29795144e-02f, 1.20260485e-01f, 5.10063507e-02f, -3.08726858e-02f, 1.39617287e-02f, 3.52974199e-02f, 1.04646944e-02f,
  6.76789954e-02f, -1.26117244e-01f, 1.78654730e-01f, 4.55802493e-02f, -1.05768912e-01f, -9.87906605e-02f, -3.08921020e-02f, 1.45399272e-01f, -5.10457717e-02f, 8.76966715e-02f,
  -5.78532331e-02f, -9.26508605e-02f, 1.18295804e-01f, 9.51885954e-02f, -1.30950078e-01f, 6.69773892e-02f, 8.70950297e-02f, 8.12849998e-02f, 1.67168491e-02f, -5.91486804e-02f,
  1.42224729e-01f, 1.13876741e-02f, -1.67529970e-01f, 1.38312519e-01f, 1.96555749e-01f, -2.74768844e-02f, 7.79973343e-02f, 1.74057841e-01f, 1.61894277e-01f, 4.57107686e-02f,
  -1.46928234e-02f, -6.20324127e-02f, -6.20520534e-03f, 1.11137526e-02f, -9.12293345e-02f, 1.63436979e-01f, -2.39572134e-02f, 9.94052440e-02f, 1.82413414e-01f, -4.84970883e-02f,
  -2.33587380e-02f, 4.29581665e-02f, 2.83226818e-02f, 4.24869135e-02f, -2.91005801e-02f, -5.77058420e-02f, 2.52198189e-01f, 1.24126673e-01f, -1.67071685e-01f, -7.68314153e-02f,
  -4.36904654e-02f, -9.22031105e-02f, 8.73157978e-02f, 9.26019177e-02f, -8.74958858e-02f, 1.66569740e-01f, -2.21940526e-03f, -2.99230307e-01f, -4.30496708e-02f, -6.50305301e-02f,
  -4.15459983e-02f, 1.41365513e-01f, -5.55315465e-02f, 3.69877852e-02f, 4.76618297e-02f, 2.35885933e-01f, 8.44738185e-02f, -9.33604594e-03f, 1.00752555e-01f, -1.33886099e-01f,
  9.39249098e-02f, -9.19248164e-02f, 7.12916106e-02f, -6.10634647e-02f, -1.31366119e-01f, 1.27126127e-01f, -1.36613354e-01f, -2.19052374e-01f, 1.77524015e-01f, 2.09673822e-01f,
  -2.00205311e-01f, -7.92795718e-02f, -1.33106031e-03f, -8.16637948e-02f, 3.69210467e-02f, -1.31434575e-01f, 7.88192973e-02f, 3.20542566e-02f, -6.64305463e-02f, 6.99777454e-02f,
  -1.12667032e-01f, -1.70408025e-01f, -4.29859646e-02f, -1.41464815e-01f, -1.08801521e-01f, 4.23808396e-02f, -3.63962427e-02f, -1.43318206e-01f, 5.15919589e-02f, 6.77700434e-03f,
  -9.85509064e-03f, -1.00200966e-01f, -2.57376321e-02f, -1.92930046e-02f, -1.75667718e-01f, -7.03658834e-02f, -2.10754603e-01f, 6.24123216e-02f, -5.17473929e-03f, 1.19069710e-01f,
  -1.22006945e-01f, 2.38277435e-01f, 8.49326178e-02f, 2.33073458e-01f, -1.33870989e-01f, 1.78429484e-01f, -7.67471315e-03f, -6.63231164e-02f, -5.55616356e-02f, -7.49209942e-03f,
  6.11376762e-02f, 1.05633840e-01f, -2.96799298e-02f, 9.02492628e-02f, -8.70565772e-02f, -1.40647441e-01f, 9.12300721e-02f, -6.78853784e-03f, -1.74562812e-01f, -1.11339930e-02f,
  -8.17417260e-03f, -2.37213567e-01f, 1.07026979e-01f, 1.05321601e-01f, 1.26917288e-01f, 5.93176894e-02f, -4.13857363e-02f, 7.39032254e-02f, 2.22231969e-01f, -1.14967294e-01f,
  1.02633484e-01f, 1.80144817e-01f, -2.54604891e-02f, 1.99202425e-03f, 9.74080414e-02f, -1.05080634e-01f, -2.62721237e-02f, -6.54704198e-02f, 1.09321006e-01f, -4.72441092e-02f,
  2.17421930e-02f, 6.41475767e-02f, -1.19647928e-01f, 6.35250509e-02f, 1.30844861e-01f, -4.21309611e-03f, -7.20285326e-02f, 4.45291027e-02f, 1.06868953e-01f, 2.72298674e-03f,
  8.74349028e-02f, -1.06550463e-01f, -1.92780524e-01f, -2.18351528e-01f, -4.32517119e-02f, 4.01851237e-02f, -2.66292900e-01f, -8.27904604e-03f, 1.04307733e-01f, -1.73221812e-01f,
  1.08265961e-02f, 1.39054358e-01f, -6.05389737e-02f, -4.02294509e-02f, -1.64175361e-01f, -3.63153592e-03f, 1.17213324e-01f, 5.10691926e-02f, -3.27255167e-02f, -1.57185763e-01f,
  -3.23827786e-04f, -3.24846357e-01f, 4.65997644e-02f, -8.52892846e-02f, 2.64705926e-01f, -7.49140605e-02f, 2.01231956e-01f, 2.55353954e-02f, -1.66926458e-01f, 2.22611055e-02f,
  -3.68923098e-02f, 4.41572815e-02f, 1.85013011e-01f, -2.89118558e-01f, 2.82479733e-01f, 1.96961537e-01f, -8.11812803e-02f, 1.13592390e-02f, 7.60404393e-02f, 8.96081626e-02f,
  -1.23912038e-03f, -9.59819108e-02f, -1.42097831e-01f, -1.76938415e-01f, 1.47203282e-01f, 8.65994319e-02f, -1.57223746e-01f, 9.32072382e-03f, -1.27249107e-01f, 3.55579816e-02f,
  -8.71093795e-02f, 8.87208432e-02f, -1.22931823e-02f, 1.39856599e-02f, 1.98592797e-01f, 5.53015061e-02f, -1.00616686e-01f, -3.56177986e-02f, 1.27177402e-01f, -5.15315086e-02f,
  -1.49924466e-02f, -3.53611894e-02f, 1.06064357e-01f, 4.21700478e-02f, 6.28337041e-02f, -4.58507389e-02f, 1.14292450e-01f, -2.31325194e-01f, 1.73052266e-01f, -1.47353768e-01f,
  1.49981240e-02f, 6.91420957e-02f, -1.24814987e-01f, -9.82226878e-02f, -1.60444334e-01f, 1.07909255e-02f, -1.38586164e-01f, 1.44474715e-01f, -3.62615474e-02f, -7.58930668e-02f,
  -7.22494572e-02f, 2.83623457e-01f, -2.12487802e-01f, 1.76562518e-01f, -1.85372844e-01f, -1.31859049e-01f, 1.18794978e-01f, -4.48151939e-02f, 1.43356798e-02f, 1.89504385e-01f,
  -7.74182603e-02f, -3.29190604e-02f, -4.68760282e-02f, 1.08208686e-01f, 2.42955424e-02f, -5.47813345e-03f, 9.17791799e-02f, -8.96612108e-02f, 1.63711697e-01f, -1.66235387e-01f,
  -2.65980903e-02f, 1.27403647e-01f, -1.50542399e-02f, 4.69198599e-02f, 7.86833018e-02f, 1.05217062e-02f, 2.09344760e-01f, 1.07635885e-01f, 1.90728202e-01f, 1.29773483e-01f,
  5.86945526e-02f, -2.65110172e-02f, 1.85385197e-01f, 1.23141080e-01f, -1.04498222e-01f, 8.97762999e-02f, 6.03553802e-02f, -1.83739856e-01f, -6.47305921e-02f, 9.73452404e-02f,
  -6.74667656e-02f, -1.58864349e-01f, -7.76433051e-02f, 2.28736717e-02f, 1.10004349e-02f, -2.96812877e-02f, -1.42733166e-02f, -6.73619360e-02f, -5.06011583e-02f, 9.22968537e-02f,
  -1.76116684e-03f, 1.08479775e-01f, 3.54858674e-02f, 3.49725448e-02f, 1.89390719e-01f, 2.30164398e-02f, -9.23665687e-02f, 1.78705156e-01f, -8.36180374e-02f, -6.39892416e-03f,
  1.74399227e-01f, 1.41037136e-01f, 1.82511598e-01f, 2.40084901e-01f, -2.36994013e-01f, -9.49154515e-03f, 1.80522352e-01f, 1.18202686e-01f, -2.18376014e-02f, 3.37114036e-02f,
  8.85002762e-02f, -8.82876962e-02f, -4.56113787e-03f, 5.55298990e-03f, -1.16597869e-01f, -1.74626887e-01f, 2.48386160e-01f, 2.79991589e-02f, -4.69194585e-03f, 2.43195802e-01f,
  -5.72388209e-02f, 1.60018861e-01f, -1.24827541e-01f, -3.99679542e-02f, 1.38475627e-01f, -1.24164578e-03f, -7.58394748e-02f, -4.06933483e-03f, -5.98740205e-02f, -2.19911541e-04f,
  1.85531661e-01f, 6.20127879e-02f, -8.13297331e-02f, -2.15545908e-01f, -3.08012068e-02f, 1.21353410e-01f, -1.29806567e-02f, 3.12989317e-02f, 1.35916799e-01f, -1.39467791e-01f,
  1.57116622e-01f, 1.27492920e-01f, -1.15077987e-01f, -8.77285898e-02f, -1.17138259e-01f, 2.19626024e-01f, -1.05934711e-02f, 8.43239948e-02f, -7.54049271e-02f, 1.11722924e-01f,
  1.37045786e-01f, 8.14538598e-02f, 1.68188483e-01f, -1.64284560e-04f, 1.42345190e-01f, 3.19304764e-02f, 1.70449510e-01f, 8.23625624e-02f, -8.25026557e-02f, 3.88648845e-02f,
  -3.01818550e-02f, 4.45171772e-03f, 1.25823438e-03f, 2.29963399e-02f, -6.74982369e-02f, -2.17055231e-01f, -1.23163380e-01f, -2.30680913e-01f, 3.25316787e-01f, 8.94206390e-02f,
  -2.34327078e-01f, -1.38367504e-01f, 4.82996367e-02f, 8.55979621e-02f, -1.69540197e-01f, -2.28486627e-01f, 3.05722887e-03f, 2.60509312e-01f, -3.11243162e-02f, 2.91893989e-01f,
  2.46167853e-02f, -2.34675542e-01f, -7.37771019e-02f, -1.98675662e-01f, 1.53301999e-01f, -1.76974475e-01f, -1.16534777e-01f, -1.48106843e-01f, -3.53654176e-02f, -9.33671296e-02f,
  -1.29451957e-02f, -5.58651574e-02f, 6.75454214e-02f, -1.93499774e-02f, 8.62995535e-02f, -8.50275606e-02f, 1.92719117e-01f, 7.32293352e-02f, -1.20148748e-01f, 7.89689124e-02f,
  1.81659348e-02f, 1.40090987e-01f, -3.85328494e-02f, -3.18894982e-02f, -4.94297631e-02f, 9.18375254e-02f, -1.87903449e-01f, -6.34530652e-03f, -6.40712352e-03f, 7.22763166e-02f,
  -1.65356547e-02f, -1.16465397e-01f, 1.86936371e-02f, -1.44329816e-01f, -1.42586762e-02f, -5.24653047e-02f, 1.63182110e-01f, -1.60310358e-01f, -1.30100846e-01f, 1.87507831e-02f,
  -1.78205207e-01f, -1.14011448e-02f, -1.57747462e-01f, -1.67231530e-01f, 3.25893797e-02f, -1.73152357e-01f, -4.95926710e-03f, 5.69815487e-02f, 1.22836465e-03f, -1.56291381e-01f,
  -2.16769040e-01f, 1.28877282e-01f, 1.59715235e-01f, -8.69484171e-02f, -1.03043996e-01f, -2.13019431e-01f, 2.79308856e-01f, 2.02554539e-01f, 4.95495424e-02f, 7.87646603e-03f,
  -1.23827785e-01f, 1.06001087e-01f, -1.73381031e-01f, -2.02881694e-02f, 2.14663893e-02f, -1.38606697e-01f, 1.76679149e-01f, -2.46071756e-01f, 1.94949791e-01f, 8.40502754e-02f,
  -1.74862355e-01f, 6.87849754e-03f, 1.96972732e-02f, 8.88210833e-02f, -3.48831937e-02f, 1.82718746e-02f, -1.27162501e-01f, -7.62827322e-02f, 6.87059667e-03f, -9.68479142e-02f,
  7.93858916e-02f, -1.28305525e-01f, 7.48729408e-02f, 5.59846871e-02f, -1.81571674e-02f, 1.11029051e-01f, -7.10201040e-02f, 6.77421503e-03f, 1.47862688e-01f, 2.14807107e-03f,
  2.37156432e-02f, 1.02079920e-01f, 9.27164331e-02f, 1.15475371e-01f, 6.40998408e-02f, 1.91633254e-01f, -9.54355393e-03f, 1.63264215e-01f, 1.26751393e-01f, 1.17924944e-01f,
  1.06465429e-01f, 1.10303760e-01f, 5.64438626e-02f, 9.49129984e-02f, 6.53044060e-02f, -1.74333081e-02f, -4.16940190e-02f, -1.14445202e-02f, -1.55308442e-02f, -3.25546563e-02f,
  1.21494718e-01f, 9.76201668e-02f, 1.52187884e-01f, -1.60120785e-01f, -1.14039764e-01f, -1.00656962e-02f, 2.01601878e-01f, -2.15220883e-01f, -7.10043460e-02f, -4.64693829e-02f,
  1.85394496e-01f, -9.10610855e-02f, 1.09677836e-01f, -3.12610865e-02f, -1.60041019e-01f, 1.40173510e-01f, -1.27383575e-01f, 5.83119616e-02f, 1.33867813e-02f, -1.90554008e-01f,
  1.39831975e-01f, -1.57337368e-01f, 2.59616911e-01f, -1.33692130e-01f, -6.78635463e-02f, 5.95129095e-02f, -1.08299375e-01f, 8.75534192e-02f, 9.54778567e-02f, -2.23868024e-02f,
  -9.16660577e-02f, 4.16283719e-02f, -1.73962131e-01f, 6.85370266e-02f, -1.11466214e-01f, 1.43783495e-01f, 5.17864935e-02f, -5.77054657e-02f, -1.59825355e-01f, 9.70384479e-02f,
  -3.86882722e-02f, -1.62791222e-01f, -2.69397162e-02f, -9.81400087e-02f, 1.70770273e-01f, 1.48567900e-01f, 2.54859943e-02f, -3.46871503e-02f, 1.70336053e-01f, 1.48995221e-01f,
  1.74335968e-02f, 8.92375484e-02f, -8.13888460e-02f, 4.21390980e-02f, 1.03028886e-01f, -6.83897287e-02f, 8.00927132e-02f, 2.18181863e-01f, 1.26822859e-01f, -9.56370588e-03f,
  7.55500272e-02f, -3.20596360e-02f, 1.07054695e-01f, 3.23156384e-03f, 3.54641750e-02f, -5.97954988e-02f, -2.17878565e-01f, 1.09251708e-01f, 2.88814437e-02f, 7.97846392e-02f,
  -1.15982749e-01f, 2.68309683e-01f, -2.55737841e-01f, 2.45453060e-01f, -1.22970104e-01f, 6.43345490e-02f, 6.54070228e-02f, 3.83992568e-02f, -1.01851024e-01f, 2.96316296e-01f,
  1.20996445e-01f, 3.95223200e-02f, -1.95125001e-03f, 1.28608588e-02f, 1.03821233e-01f, -1.01670809e-03f, -2.77706273e-02f, -1.14679858e-01f, 8.59751627e-02f, -2.09093392e-02f,
  -1.73266411e-01f, 7.67812729e-02f, -1.47288293e-01f, 7.60494024e-02f, 3.09923161e-02f, 5.72871491e-02f, 1.90248460e-01f, 1.24687284e-01f, 1.83535218e-01f, 1.33616909e-01f,
  2.29247048e-01f, -3.34026553e-02f, 1.97449848e-01f, -4.29385714e-02f, -1.34348661e-01f, -1.66042641e-01f, 1.07189931e-01f, -2.83911675e-02f, -8.50854628e-03f, -8.36800188e-02f,
  5.65595888e-02f, 1.04708783e-01f, 7.59147154e-03f, 1.22768037e-01f, 1.09917499e-01f, 1.33924568e-02f, -4.35189381e-02f, 7.88936466e-02f, 8.69163945e-02f, -1.33615315e-01f,
  -1.19223390e-02f, -9.20453668e-02f, 1.06533304e-01f, 7.80664459e-02f, -9.71703082e-02f, 3.61691751e-02f, -4.44071777e-02f, -6.36864454e-02f, 4.97345068e-02f, -1.91005431e-02f,
  -3.38052988e-01f, -7.44836852e-02f, -2.76750829e-02f, 1.42782822e-01f, -6.84633180e-02f, 2.45588884e-01f, -3.09409827e-01f, 9.00631398e-02f, -2.80054938e-02f, -9.87505317e-02f,
  2.46704608e-01f, 1.76970571e-01f, 4.65412028e-02f, 1.46774739e-01f, -1.12240776e-01f, 1.91736177e-01f, -7.65732080e-02f, -2.25154571e-02f, -1.44812698e-02f, -3.11098900e-02f,
  1.15873896e-01f, -1.05231129e-01f, 3.43272835e-02f, -2.05137044e-01f, -1.02131546e-01f, 1.31767035e-01f, -9.83091630e-03f, -4.63808924e-02f, -1.49994105e-01f, -1.09937094e-01f,
  7.01021031e-02f, 1.63117558e-01f, 3.20821144e-02f, 1.31841332e-01f, 1.17482617e-01f, -2.47032747e-01f, 8.71057063e-02f, -9.77187380e-02f, -2.39031669e-03f, -3.77039798e-02f,
  -1.12960465e-01f, -1.41658336e-01f, -2.38161329e-02f, -4.58879881e-02f, 5.43404371e-02f, -1.23104386e-01f, -1.13527708e-01f, -7.37164617e-02f, -8.22040588e-02f, 4.34241779e-02f,
  -9.04188007e-02f, -9.71924514e-02f, -1.74993932e-01f, 1.57668535e-02f, -7.84958899e-02f, 4.95247468e-02f, -7.69666210e-02f, 8.98635834e-02f, 1.24536581e-01f, 8.31000879e-02f,
  7.60766715e-02f, 7.27603883e-02f, 2.82736924e-02f, -2.15512495e-02f, -3.39508839e-02f, 2.66172200e-01f, -2.39790771e-02f, 1.80738375e-01f, -1.91410601e-01f, -5.79929352e-02f,
  7.05601498e-02f, 1.01611860e-01f, -1.88172627e-02f, -1.24795221e-01f, -1.08439416e-01f, 1.98430017e-01f, -3.70357893e-02f, 3.69905457e-02f, 1.78094525e-02f, -2.07818896e-01f,
  -1.30394310e-01f, 2.07330450e-01f, 4.29901201e-03f, 2.51913369e-01f, -2.51504898e-01f, 2.04352420e-02f, -2.22822707e-02f, 6.91790432e-02f, 6.16633855e-02f, -6.59719631e-02f,
  -1.56566635e-01f, 6.55192286e-02f, 4.90779541e-02f, 6.87331706e-02f, -5.18029295e-02f, -4.62834127e-02f, 3.84107605e-02f, 1.10920034e-02f, 1.18519358e-01f, -2.48867664e-02f,
  1.22979157e-01f, -1.15230702e-01f, 1.76749960e-01f, 1.88274875e-01f, -8.48283172e-02f, 6.39048219e-02f, -1.63805515e-01f, -1.12344297e-02f, -1.00338928e-01f, 1.32798791e-01f,
  -1.25097051e-01f, -4.52754088e-02f, -1.35636136e-01f, -1.14718281e-01f, -4.97054867e-02f, -1.95113301e-01f, -8.38182420e-02f, 4.11584862e-02f, -1.99052066e-01f, -9.97569636e-02f,
  -1.00751571e-01f, -7.54808635e-02f, -9.58172902e-02f, 2.01937910e-02f, 5.34162633e-02f, 3.25434916e-02f, 1.13700651e-01f, -1.43757015e-01f, 3.46007228e-01f, 1.15705542e-01f,
  1.07459836e-01f, -1.23041153e-01f, 1.19553767e-01f, -2.22220123e-01f, 1.42503589e-01f, -1.79064110e-01f, 1.45369589e-01f, 1.69422686e-01f, -5.93521595e-02f, -8.75808373e-02f,
  6.25466704e-02f, -2.00636983e-01f, 3.39236744e-02f, -1.39991415e-03f, 9.72439870e-02f, -1.54545724e-01f, -2.10130662e-02f, 2.13170543e-01f, -1.28319323e-01f, 1.66593567e-01f,
  -6.78020157e-03f, 4.08917367e-02f, 1.16948061e-01f, -1.40408695e-01f, -1.32488772e-01f, -1.39648080e-01f, 1.21132381e-01f, 1.59217298e-01f, -9.78348628e-02f, -2.65004516e-01f,
  -1.26239464e-01f, -1.02072164e-01f, -8.13825950e-02f, -1.67766567e-02f, -1.62759185e-01f, 1.27227277e-01f, -2.64440663e-02f, -2.73088127e-01f, -9.52345505e-02f, -5.72178923e-02f,
  5.87058701e-02f, 7.15660751e-02f, -7.61977136e-02f, -1.02430038e-01f, 8.80165622e-02f, 3.74283479e-03f, 1.84228253e-02f, 6.00464791e-02f, 9.89378840e-02f, -4.21318337e-02f,
  -3.94263454e-02f, 2.09326278e-02f, 5.49645126e-02f, 1.03242725e-01f, -1.85791273e-02f, 6.56436617e-03f, -3.97763848e-02f, 2.56463550e-02f, -5.91810644e-02f, -1.68449923e-01f,
  2.09948450e-01f, -2.30436791e-02f, -2.53574789e-01f, -3.00807089e-01f, -6.20796047e-02f, -4.35624495e-02f, 1.78822026e-01f, 7.20597506e-02f, -2.17422649e-01f, -1.04870170e-01f,
  2.66171694e-01f, 3.75746042e-02f, 2.86106110e-01f, 8.40943009e-02f, -3.35220784e-01f, 5.02103418e-02f, -2.58203238e-01f, -8.73142108e-02f, 1.16949558e-01f, 4.99928743e-02f,
  1.82623342e-01f, -4.48082477e-01f, 1.54787928e-01f, -7.14891357e-03f, 3.72835658e-02f, -7.92236552e-02f, 1.31267861e-01f, 9.51915309e-02f, 1.15417957e-01f, -5.71868233e-02f,
  -1.80015326e-01f, -1.62893042e-01f, -8.72482285e-02f, 2.19352245e-01f, 7.18439445e-02f, -1.22715823e-01f, 1.56411946e-01f, 7.08047822e-02f, 8.08125287e-02f, -6.71226084e-02f,
  -1.45793200e-01f, -1.26379013e-01f, -1.01822942e-01f, 2.02949122e-02f, 1.04570433e-01f, -9.90402699e-03f, 1.08559027e-01f, -1.30420357e-01f, 8.61889217e-03f, -1.67714972e-02f,
  -3.92577425e-03f, 6.13178983e-02f, -1.46298841e-01f, 1.24819830e-01f, 8.96714404e-02f, 1.50301754e-02f, 7.05654770e-02f, 1.47703633e-01f, 1.09797111e-02f, -3.48047055e-02f,
  1.16271771e-01f, 7.04673538e-03f, 1.05940685e-01f, -3.09566073e-02f, -3.94275412e-02f, 2.37420537e-02f, 1.73785221e-02f, -1.67925015e-01f, -1.50116071e-01f, 5.67181781e-02f,
  -1.81112606e-02f, 5.70974313e-02f, -2.54949600e-01f, 2.00863242e-01f, -1.05872266e-01f, 2.01158822e-01f, 2.34952290e-02f, -5.49407899e-02f, -1.32600322e-01f, 2.00422287e-01f,
  -6.24348670e-02f, -1.14878133e-01f, 1.99561626e-01f, 1.29498959e-01f, -5.75253144e-02f, -1.89980820e-01f, 1.42016679e-01f, -3.05248480e-02f, -4.88329083e-02f, -2.90823340e-01f,
  -1.48187011e-01f, 1.98375829e-03f, -2.47772649e-01f, 8.73128697e-02f, 7.58426590e-03f, -1.32827684e-01f, 1.39230549e-01f, 1.36267290e-01f, 1.14709161e-01f, -9.94458199e-02f,
  7.04095215e-02f, 6.45381026e-03f, 1.84742123e-01f, 5.18293604e-02f, -2.70975102e-03f, -1.10155204e-02f, -1.94793846e-02f, 1.61907658e-01f, -4.82199341e-02f, -1.00244731e-01f,
  -7.74613395e-02f, 1.33961245e-01f, 1.23756945e-01f, -1.00997277e-01f, -1.77662984e-01f, 9.38518271e-02f, 1.69320986e-01f, 7.61131197e-02f, -2.30910648e-02f, 2.52075978e-02f,
  -2.76930127e-02f, 8.82653669e-02f, -6.14358857e-03f, 1.13433942e-01f, 3.85353044e-02f, 5.74587546e-02f, 9.06191096e-02f, -3.41837220e-02f, 1.67962998e-01f, 4.95227277e-02f,
  -3.21734138e-02f, -7.18532950e-02f, 2.61145160e-02f, -3.70883882e-01f, 2.49802202e-01f, -8.69852602e-02f, -1.08773105e-01f, -1.28709257e-01f, -4.36315238e-02f, -1.40337065e-01f,
  -7.64404088e-02f, -8.37251097e-02f, 1.02419399e-01f, 1.49756879e-01f, 1.87958598e-01f, 1.98323682e-01f, -1.82983950e-01f, -1.72546878e-01f, -1.51006937e-01f, -2.25695908e-01f,
  1.82980239e-01f, -1.29680544e-01f, -1.07127745e-02f, 1.80542037e-01f, -1.46290973e-01f, 4.37295152e-04f, 6.78278180e-03f, -3.09418142e-02f, 1.27423495e-01f, 1.13829114e-02f,
  -5.87756224e-02f, -1.20040461e-01f, 1.40702903e-01f, 2.08940119e-01f, -4.20921780e-02f, -4.73934785e-02f, 6.05874881e-02f, 1.20066181e-01f, 6.37812465e-02f, -6.71935454e-02f,
  2.15793829e-02f, 8.47168081e-03f, 6.73601925e-02f, 1.09292241e-02f, -3.50010991e-02f, 8.36881921e-02f, -1.27277970e-02f, 1.21126316e-01f, 2.19705943e-02f, -2.07257047e-02f,
  2.55985875e-02f, -9.74737480e-02f, 1.61148518e-01f, -6.94061741e-02f, 7.88201913e-02f, -1.58594898e-03f, 1.27650872e-01f, 9.30310935e-02f, 1.81099921e-02f, 3.38376649e-02f,
  -7.96871930e-02f, -1.48263246e-01f, -5.67238033e-03f, 1.09977268e-01f, 8.13547522e-02f, -8.63478705e-02f, -6.85472116e-02f, 2.00286925e-01f, 7.12957829e-02f, 7.52095953e-02f,
  -1.06732197e-01f, -1.02380604e-01f, 1.76806584e-01f, 8.30959994e-03f, 2.03409165e-01f, 1.30440161e-01f, -1.21565364e-01f, -3.91952097e-02f, -8.00735429e-02f, 9.62576419e-02f,
  8.09855759e-02f, -7.40179941e-02f, 2.89831869e-02f, -1.69006273e-01f, -3.50003503e-02f, 1.13650650e-01f, -1.05655052e-01f, -9.25074071e-02f, 1.34530723e-01f, -3.63886473e-03f,
  1.41255371e-02f, -6.86279610e-02f, -1.30949318e-01f, -4.52815630e-02f, -1.32939354e-01f, 1.15995228e-01f, 1.51036158e-01f, -8.89200792e-02f, 1.40534371e-01f, 1.10664889e-01f,
  -1.15422063e-05f, 8.46005529e-02f, -1.96078852e-01f, 1.75420061e-01f, -1.04845511e-02f, -5.05654477e-02f, 1.62795726e-02f, -6.85613081e-02f, -5.28166369e-02f, 1.21829771e-01f,
  1.16570421e-01f, 3.47120985e-02f, -2.33124778e-01f, -3.76413465e-02f, 8.49818364e-02f, 2.81231385e-02f, -1.21801116e-01f, 1.71772279e-02f, -1.32139251e-01f, -3.05686772e-01f,
  1.24057107e-01f, -1.69193074e-01f, -3.96016017e-02f, 1.19366191e-01f, -6.96600601e-02f, 1.40897766e-01f, -1.86134249e-01f, 1.33761466e-01f, 3.78675051e-02f, 2.29353592e-01f,
  1.96329564e-01f, -1.48037329e-01f, -2.16309056e-01f, 7.45790675e-02f, 2.75647968e-01f, 3.82621214e-02f, -2.79471695e-01f, -1.46692649e-01f, -1.91134423e-01f, 8.23185369e-02f,
  2.32169941e-01f, -2.01811343e-01f, 1.85791761e-01f, -8.98881555e-02f, 9.56901237e-02f, 1.47778302e-01f, -2.38669604e-01f, 1.52601466e-01f, -9.41578820e-02f, -2.30646223e-01f,
  1.26729369e-01f, 1.72385171e-01f, -6.08584508e-02f, 1.28775865e-01f, 9.08803493e-02f, 1.92583367e-01f, 1.45150244e-01f, 8.33460838e-02f, 2.13158309e-01f, -1.66529745e-01f,
  -1.40384063e-01f, -6.59454474e-03f, -7.42959827e-02f, -7.24848732e-02f, 1.22256100e-01f, -6.68614581e-02f, -1.78418010e-01f, 5.55757284e-02f, 2.86153089e-02f, -6.87436536e-02f,
  -1.11446425e-01f, -1.33651227e-01f, 1.15256675e-01f, -1.09290607e-01f, -6.20426796e-02f, 1.46180168e-01f, 1.03817485e-01f, -7.09235519e-02f, -1.28473595e-01f, -1.12143019e-02f,
  1.04938308e-02f, 3.15824486e-02f, -2.64610015e-02f, 1.03170909e-01f, 8.31186548e-02f, -1.13317564e-01f, -1.41724804e-02f, -6.46030381e-02f, -7.90249184e-03f, 6.40131906e-02f,
  -1.07741892e-01f, 1.82201937e-02f, -1.46361992e-01f, -4.56436425e-02f, -1.90939978e-02f, 1.22145340e-01f, -2.89578259e-01f, -2.13932134e-02f, -8.49395469e-02f, 1.61423653e-01f,
  -6.69225380e-02f, 1.31205574e-01f, 2.27077350e-01f, 3.97629626e-02f, 1.51045220e-02f, -4.90136482e-02f, 6.92321779e-03f, -2.71095455e-01f, 1.73479781e-01f, 2.16312572e-01f,
  -1.11291260e-01f, 1.19400341e-02f, -9.29915309e-02f, 8.02750140e-03f, 8.20740834e-02f, 4.89453599e-02f, -9.80013516e-03f, 4.06627283e-02f, 3.40117216e-02f, -2.27365606e-02f,
  1.24554066e-02f, 9.99121219e-02f, -3.15370001e-02f, 1.16808102e-01f, -1.61805619e-02f, -1.81034759e-01f, 8.23872536e-02f, -5.04193716e-02f, 1.83277532e-01f, 4.79040369e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -8.44738036e-02f, 8.89469776e-03f, 9.29651558e-02f, 6.05443902e-02f, 9.23992544e-02f, 1.45868406e-01f, 1.21470779e-01f, 2.12570354e-01f, -2.72684600e-02f, 3.83943901e-03f,
  -8.37481022e-03f, 2.44796630e-02f, -5.40558323e-02f, 7.60718510e-02f, -1.51866749e-02f, 1.16686195e-01f, 4.59697545e-02f, 6.40348047e-02f, 1.21090755e-01f, 2.44803894e-02f,
  -2.06111576e-02f, 7.13300630e-02f, 8.50500315e-02f, 1.21579960e-01f, -3.74132395e-02f, -3.01535726e-02f, 4.67867181e-02f, 1.34161383e-01f, -8.25157836e-02f, -1.36069477e-01f,
  -1.00892134e-01f, 1.06142364e-01f, 7.28540272e-02f, -4.80221137e-02f, -7.25201145e-02f, -4.54625487e-02f, -1.19029835e-01f, -1.05508670e-01f, 3.45000960e-02f, 1.11833699e-02f,
  1.92645207e-01f, 4.30865586e-02f, -3.67310196e-02f, -1.17457844e-01f, 7.10787773e-02f, 2.91177966e-02f, 1.24372821e-02f, -1.15782388e-01f, 8.15531686e-02f, -7.49075487e-02f,
  -1.15091003e-01f, 3.79019938e-02f, -1.33270115e-01f, -1.66247860e-02f, -5.53133748e-02f, 1.28378801e-03f, 8.91626477e-02f, -1.83089226e-01f, 7.58256903e-03f, 1.15834862e-01f,
  1.72024369e-02f, -4.47786562e-02f, -2.70372126e-02f, 1.23893909e-01f, -1.16392337e-01f, -1.07196029e-02f, 8.81724060e-02f, 5.46444990e-02f, -1.12139866e-01f, -2.10685097e-03f,
  -6.67939708e-02f, 7.07007796e-02f, 1.23560810e-02f, 5.99945821e-02f, 4.50033545e-02f, 7.50296041e-02f, 1.20475598e-01f, -2.62133293e-02f, 1.01163641e-01f, 2.18101759e-02f,
  -3.73742022e-02f, 2.68131811e-02f, 1.13635637e-01f, -2.97930893e-02f, 3.88582945e-02f, 1.55631870e-01f, 8.78433522e-04f, 6.61564320e-02f, 3.07558943e-02f, 9.56150424e-03f,
  -5.96713535e-02f, -8.05253163e-02f, -4.03864570e-02f, -3.55320945e-02f, 1.63613111e-01f, -1.27382219e-01f, -1.35910615e-01f, -2.20024679e-02f, 5.47751412e-02f, 1.90846279e-01f,
  1.24591522e-01f, -1.07606076e-01f, -1.72591060e-01f, 1.81443989e-02f, -7.77639672e-02f, -1.60840631e-01f, 9.21970680e-02f, 7.36221448e-02f, 1.78120837e-01f, -1.42607510e-01f,
  -1.25386650e-02f, 1.32460043e-01f, -1.13587417e-01f, -5.90765923e-02f, 1.37250841e-01f, -1.10406131e-01f, 8.11439902e-02f, 8.76524001e-02f, 6.25407621e-02f, 1.12811677e-01f,
  6.11645170e-02f, 6.17812462e-02f, 2.78091263e-02f, 3.34800929e-02f, 1.25688806e-01f, 4.75555323e-02f, 6.54250830e-02f, -1.10877333e-02f, -1.56073079e-01f, 1.64480180e-01f,
  4.97733019e-02f, -7.90571943e-02f, 4.38898727e-02f, 7.17753395e-02f, 6.92209750e-02f, 1.51252300e-01f, 7.84177333e-03f, -9.20286924e-02f, -6.96680546e-02f, 1.26913652e-01f,
  7.79960304e-02f, 1.03134327e-01f, -3.26435119e-02f, 1.28537580e-01f, -5.98939043e-03f, 6.07732795e-02f, 1.49202779e-01f, -8.34826231e-02f, 9.23331454e-02f, -2.69886758e-02f,
  1.36879459e-02f, -1.00213632e-01f, -1.40511960e-01f, 4.97984923e-02f, -1.15471914e-01f, -9.53155532e-02f, 1.07844114e-01f, 5.50709181e-02f, -9.12452415e-02f, -1.63946841e-02f,
  -8.33045170e-02f, -7.58450553e-02f, -1.73580810e-01f, -1.25670701e-01f, 1.19955860e-01f, 9.38581582e-03f, 3.22411023e-02f, 3.38875875e-02f, -8.88002217e-02f, -5.48017770e-02f,
  1.34993464e-01f, -7.25539848e-02f, -1.20968021e-01f, 9.50254351e-02f, -1.14540763e-01f, -6.28841482e-03f, -2.39754301e-02f, -1.79201022e-01f, -9.88464728e-02f, -8.02433714e-02f,
  8.50160494e-02f, 3.44949774e-02f, -1.37861982e-01f, -2.18459703e-02f, 6.96619600e-02f, -4.92487885e-02f, -7.37438304e-03f, -6.40488276e-03f, 6.47712350e-02f, -1.44046381e-01f,
  2.03037888e-01f, 1.10663846e-01f, -2.48304065e-02f, 2.39738021e-02f, -3.21321539e-03f, 1.17262989e-01f, -3.81698608e-02f, 5.86395673e-02f, -2.44926736e-02f, -2.02910416e-02f,
  1.21380672e-01f, -9.22141969e-02f, 2.97832657e-02f, -2.80569810e-02f, 3.63412648e-02f, 2.87345098e-03f, 4.48292382e-02f, 1.49840757e-01f, -4.36095782e-02f, -3.95108312e-02f,
  -1.83322001e-02f, 2.64843330e-02f, 1.61349252e-01f, 9.22824293e-02f, -1.60832088e-02f, 1.48576617e-01f, 2.55892556e-02f, -7.35815167e-02f, 1.08955212e-01f, -1.18485510e-01f,
  8.58382955e-02f, -9.54185054e-02f, -6.74237907e-02f, 3.13106366e-02f, 1.00828052e-01f, 7.89822042e-02f, -7.36182332e-02f, 1.20238446e-01f, 1.31485453e-02f, 3.26814130e-02f,
  -1.44224856e-02f, 1.23102479e-01f, 7.42103904e-02f, -4.77489531e-02f, 9.81211066e-02f, 5.31118712e-04f, -2.37383246e-02f, 2.70629562e-02f, -1.13269053e-01f, 1.36979148e-01f,
  -1.33924037e-01f, 9.47288871e-02f, 2.26463508e-02f, -1.39604053e-02f, 4.47219573e-02f, 3.42952460e-02f, 8.69972035e-02f, 3.62143070e-02f, 1.18044242e-01f, -1.30779475e-01f,
  6.85094595e-02f, 1.06796369e-01f, -3.08276806e-02f, 1.27013355e-01f, -1.05383517e-02f, -7.68959746e-02f, -1.25921100e-01f, -3.70447412e-02f, -1.62159614e-02f, 2.89665498e-02f,
  -1.62567906e-02f, -9.03369933e-02f, 2.16549318e-02f, 5.87611683e-02f, -8.24860260e-02f, -1.10278018e-02f, 9.19003710e-02f, 1.23892225e-01f, 4.03047241e-02f, -7.94718117e-02f,
  1.90305742e-04f, 2.27091387e-02f, -2.88402569e-02f, -1.57248914e-01f, -7.89321437e-02f, -9.09291804e-02f, 7.06844702e-02f, -9.38575938e-02f, 9.11277905e-02f, 9.50747877e-02f,
  -5.93392588e-02f, -6.31486773e-02f, 5.81918703e-03f, -6.94824755e-02f, 3.74852568e-02f, -3.80217880e-02f, -3.40966731e-02f, 1.59597948e-01f, 8.45296532e-02f, -4.67577064e-03f,
  -5.54452427e-02f, 6.30747676e-02f, 1.16712078e-01f, 9.46277604e-02f, 7.64523670e-02f, 1.32338360e-01f, 8.11306909e-02f, 1.12837307e-01f, 1.83532964e-02f, 6.79421425e-02f,
  -1.22450501e-01f, -1.03177696e-01f, -9.98382568e-02f, -1.54356360e-01f, 1.20552756e-01f, -3.65411453e-02f, 6.77651586e-03f, 1.21920496e-01f, -5.89208826e-02f, -1.01157509e-01f,
  -1.45291155e-02f, -1.28306597e-01f, 1.02108650e-01f, -4.71758060e-02f, 1.52785465e-01f, 8.97283331e-02f, 4.39233258e-02f, -1.16411000e-01f, 1.03926682e-03f, 3.81744504e-02f,
  -6.87240437e-02f, 1.15632430e-01f, 1.06371701e-01f, 1.08288571e-01f, -1.21171949e-02f, -9.47499052e-02f, 5.93638569e-02f, -1.01770185e-01f, 1.33581953e-02f, 9.78832096e-02f,
  5.20655327e-02f, -8.04290771e-02f, -1.05248779e-01f, -1.06741160e-01f, 5.12906574e-02f, 8.74244496e-02f, -3.25425155e-02f, -7.92760551e-02f, -7.53698722e-02f, 6.30267113e-02f,
  -6.96769953e-02f, 4.15146984e-02f, 6.17741942e-02f, 3.89871821e-02f, -2.59495154e-02f, 6.57090023e-02f, -1.53357247e-02f, -6.02101572e-02f, 3.91385555e-02f, -7.13297576e-02f,
  -1.11448765e-01f, 5.52108809e-02f, 1.61468908e-01f, -2.70130262e-02f, -7.94780031e-02f, 5.81794381e-02f, 2.60798763e-02f, -4.21473831e-02f, -8.32844451e-02f, -1.22866854e-01f,
  -5.22146076e-02f, -1.27848208e-01f, 1.31341457e-01f, 9.61080119e-02f, 5.74908853e-02f, 1.87799279e-02f, -1.19632483e-01f, 1.08595341e-01f, -5.58466325e-03f, 1.03435237e-02f,
  5.54134212e-02f, 1.13338605e-01f, 6.52026162e-02f, 1.19777627e-01f, 4.13749032e-02f, -6.88798055e-02f, -1.19343154e-01f, -1.04854256e-01f, 9.16774943e-02f, -4.85990904e-02f,
  -1.55108906e-02f, 4.08652686e-02f, -4.93017025e-02f, -1.37737449e-02f, 1.04008920e-01f, 2.38127485e-02f, 7.35125039e-03f, -6.35766312e-02f, -8.08031708e-02f, -9.66199934e-02f,
  1.22283250e-01f, -4.06838953e-02f, -8.10707733e-02f, -1.03029847e-01f, -3.14633511e-02f, 3.99542525e-02f, 1.43413633e-01f, -6.17273450e-02f, -4.56804708e-02f, -2.09881049e-02f,
  -7.97220320e-02f, -1.58870310e-01f, -1.64394788e-02f, -2.19094567e-02f, -1.28857106e-01f, 1.00557067e-01f, -8.27168673e-02f, -9.81867090e-02f, -3.48664895e-02f, 7.09841922e-02f,
  -1.45217538e-01f, 5.21251857e-02f, -1.01741344e-01f, 1.21863872e-01f, -2.20830794e-02f, -4.38306257e-02f, 7.96598941e-02f, 7.16090947e-02f, 7.57119209e-02f, -3.99184972e-02f,
  2.15936801e-03f, -3.54878083e-02f, 9.98286009e-02f, -7.00170770e-02f, -6.54444173e-02f, 6.19853362e-02f, 2.29967088e-02f, 1.26201119e-02f, -3.46154161e-02f, -8.10955837e-02f,
  1.10309467e-01f, -6.07875995e-02f, -4.41660844e-02f, -1.01846218e-01f, 2.42626499e-02f, 9.00608581e-03f, 2.13086784e-01f, -5.96929938e-02f, -6.26115501e-02f, 3.98479141e-02f,
  -1.40012586e-02f, 4.16477397e-02f, 8.34482163e-03f, -4.30969708e-02f, 7.35650659e-02f, 4.72538471e-02f, -1.33851528e-01f, -5.36691956e-02f, 1.08675458e-01f, -4.36212644e-02f,
  1.25640094e-01f, 1.87577810e-02f, 6.25728145e-02f, 9.14575607e-02f, -4.81125042e-02f, -1.22320637e-01f, 1.25730157e-01f, 9.79923382e-02f, -8.27858225e-02f, -1.62229612e-02f,
  -2.51552518e-02f, -6.82611018e-02f, 1.04194015e-01f, 1.37919769e-01f, -1.11976629e-02f, 5.00772260e-02f, -6.34380728e-02f, -5.10281548e-02f, -2.76086535e-02f, 2.31048651e-02f,
  5.75606003e-02f, -5.23367114e-02f, 9.16779116e-02f, 8.93502980e-02f, -1.13297537e-01f, 6.50571808e-02f, 5.05644530e-02f, 1.56046106e-02f, -9.49393511e-02f, -8.31971236e-04f,
  -3.96915339e-02f, 5.50620928e-02f, 4.24897633e-02f, 9.33869258e-02f, 6.07901849e-02f, 1.90392092e-01f, 2.87082940e-02f, -3.20075862e-02f, -1.31709382e-01f, -1.53636172e-01f,
  6.27039820e-02f, -5.76646365e-02f, -9.51856747e-02f, -7.06671849e-02f, 3.98462340e-02f, 1.67718704e-03f, 4.83628288e-02f, -5.63266054e-02f, 2.23120600e-01f, -7.93955103e-02f,
  2.34545410e-01f, 3.22662257e-02f, -7.31774047e-02f, 1.31185623e-02f, -9.65894386e-02f, -4.00928333e-02f, -2.55110916e-02f, 3.41452174e-02f, 5.07397875e-02f, -6.58010319e-02f,
  -1.06994152e-01f, 9.76103470e-02f, -4.34145406e-02f, -1.31271884e-01f, -1.45169348e-02f, 1.77689418e-02f, 5.22270892e-03f, 5.63052781e-02f, 6.53315932e-02f, 3.77383530e-02f,
  -8.96428078e-02f, -5.59759922e-02f, 8.57249424e-02f, -7.61951134e-02f, -6.50810897e-02f, 1.10181093e-01f, -6.29347041e-02f, 8.65207314e-02f, -1.07832983e-01f, 8.62098038e-02f,
  7.14521706e-02f, 9.81512479e-03f, 9.36328098e-02f, -8.52535367e-02f, -5.52263483e-02f, -6.98435232e-02f, -1.15878440e-01f, -1.07964404e-01f, -2.81176344e-02f, -1.04105391e-01f,
  9.04354379e-02f, 9.70565602e-02f, -1.25079542e-01f, 1.33049041e-01f, 1.06228143e-02f, 4.46440391e-02f, 3.23637109e-03f, 4.97965962e-02f, -1.71022322e-02f, 1.37974411e-01f,
  1.25102341e-01f, 2.30335761e-02f, 8.99201930e-02f, 6.17176294e-02f, 8.87770802e-02f, -5.38913421e-02f, 9.55714136e-02f, -5.58626689e-02f, -4.28575017e-02f, 1.07250258e-01f,
  7.26553202e-02f, -1.41832838e-03f, -1.19680427e-01f, -3.45204026e-02f, 5.64995110e-02f, 7.87445009e-02f, 4.20931354e-02f, -1.21296301e-01f, -1.23715669e-01f, -1.76909752e-02f,
  -1.90309361e-02f, -1.04478844e-01f, 2.28000153e-02f, -1.94307733e-02f, 3.74324210e-02f, -5.70295341e-02f, 1.15264030e-02f, -6.21055253e-02f, 3.77837047e-02f, 1.00679263e-01f,
  1.30782800e-03f, 5.86119182e-02f, 1.00186452e-01f, 9.41690207e-02f, -7.77609134e-03f, 1.28136687e-02f, -7.84865469e-02f, 1.27956821e-02f, 9.17890742e-02f, -8.02356005e-02f,
  1.23435974e-01f, 2.52096783e-02f, -5.50460219e-02f, -1.46974161e-01f, -4.32336032e-02f, 5.11820726e-02f, 5.92055246e-02f, 5.81255881e-03f, 1.16599582e-01f, 2.83715315e-02f,
  -2.55179312e-02f, 8.94192904e-02f, 8.26499462e-02f, 1.26140222e-01f, -1.75583169e-01f, -8.95607397e-02f, -4.00091894e-02f, -2.20676754e-02f, 5.40067591e-02f, -9.71955135e-02f,
  -9.27482024e-02f, -2.14421406e-01f, 4.23548818e-02f, 8.25294182e-02f, 1.82506755e-01f, 9.37395915e-02f, 1.53500825e-01f, 1.79009065e-01f, -2.43592888e-01f, -6.90375865e-02f,
  1.02415100e-01f, 1.61972806e-01f, -2.01855954e-02f, 1.14427786e-02f, 1.44002125e-01f, 1.06646150e-01f, 1.69831350e-01f, 2.18338482e-02f, 1.51015744e-01f, 7.97999278e-02f,
  1.28679439e-01f, -3.25995833e-02f, -6.88638389e-02f, -1.57950044e-01f, 1.19450286e-01f, 1.69483081e-01f, -3.77038531e-02f, -8.84901881e-02f, -4.57536131e-02f, 1.05497107e-01f,
  -2.58731190e-02f, 9.17500630e-02f, 2.06955239e-01f, -2.25380715e-02f, 1.70791581e-01f, 7.32500106e-02f, -7.76804686e-02f, 2.41517380e-01f, -1.07303552e-01f, 1.88091341e-02f,
  -2.09170766e-02f, -6.70269951e-02f, -6.42034188e-02f, 4.46284078e-02f, 7.42166340e-02f, 1.01492971e-01f, 1.47293478e-01f, 1.18609242e-01f, 1.25419959e-01f, -3.11051942e-02f,
  2.10678980e-01f, -1.16270790e-02f, 4.96976785e-02f, -5.56533746e-02f, -7.60050192e-02f, -4.28861417e-02f, 1.26164198e-01f, 6.35930896e-02f, -1.59143999e-01f, 1.85250640e-01f,
  4.45809867e-03f, -2.59734653e-02f, -1.83601724e-03f, 7.48659670e-03f, -2.26435423e-01f, -8.89693126e-02f, -1.91621214e-01f, -9.99438344e-04f, 9.36955512e-02f, 2.92255670e-01f,
  8.59770328e-02f, -1.60669778e-02f, 1.28701851e-02f, 6.20144084e-02f, 7.74659365e-02f, 2.71164507e-01f, -1.20036945e-01f, 6.14138581e-02f, -1.78092211e-01f, -1.08953372e-01f,
  5.51188067e-02f, 6.23557866e-02f, 1.75526030e-02f, 4.49119546e-02f, -1.06496744e-01f, -7.73386285e-02f, 1.70305148e-01f, -1.59993619e-02f, 1.12020724e-01f, 6.30212426e-02f,
  -1.75834692e-03f, -1.17958868e-02f, 1.78403661e-01f, 6.02563731e-02f, 6.72209784e-02f, 7.96058252e-02f, -6.47831708e-02f, 9.61379036e-02f, -4.79783863e-02f, 1.13388389e-01f,
  6.13849498e-02f, -5.09148203e-02f, -1.59400348e-02f, 1.18794916e-02f, -5.45705445e-02f, 5.32260649e-02f, 9.92661491e-02f, -8.79332274e-02f, -5.32535091e-02f, -2.79928781e-02f,
  3.44147012e-02f, 1.26079619e-01f, -5.12285009e-02f, -2.48731580e-02f, 1.25225872e-01f, 1.05676323e-01f, 1.00252643e-01f, 6.45709410e-02f, 1.01115413e-01f, 6.54627830e-02f,
  -1.37998372e-01f, 3.52243185e-02f, -8.52311403e-02f, 1.13519125e-01f, -1.20200746e-01f, 7.66900852e-02f, -9.51927155e-02f, -2.85611451e-02f, 1.31725118e-01f, 1.07854702e-01f,
  9.63440388e-02f, 1.58225000e-01f, -6.10348880e-02f, -1.92774281e-01f, 8.20636228e-02f, 5.87232597e-02f, -1.24451600e-01f, 2.62180567e-02f, 9.14482325e-02f, 1.09270923e-02f,
  -1.03244647e-01f, 4.67080902e-03f, 1.96636841e-02f, 1.61560804e-01f, -9.04516801e-02f, -2.57840706e-03f, -5.81809785e-03f, 4.73299921e-02f, 1.03869662e-01f, 4.91878092e-02f,
  -1.29647804e-02f, 1.13727197e-01f, -1.34386450e-01f, 3.14828195e-02f, 9.33674276e-02f, -8.49890411e-02f, -1.15717091e-01f, -1.17625087e-01f, 6.42182082e-02f, -6.47250116e-02f,
  1.40709162e-01f, 9.56589356e-02f, 9.69159380e-02f, 6.69300035e-02f, -1.56510528e-02f, 9.28876400e-02f, 1.81309119e-01f, 4.52481881e-02f, -6.36555403e-02f, -7.70369545e-02f,
  9.06562358e-02f, -7.53296241e-02f, 3.67575325e-02f, -7.08801597e-02f, 8.78272206e-02f, -9.95588154e-02f, -2.50970926e-02f, 1.39605701e-01f, -1.27092421e-01f, 5.12062646e-02f,
  6.52869269e-02f, -7.42017627e-02f, -6.28911182e-02f, 2.51133600e-03f, -1.13203652e-01f, 5.37907258e-02f, 1.06337462e-02f, -1.50774062e-01f, 1.08410619e-01f, 2.76033264e-02f,
  -4.40579914e-02f, -9.56344157e-02f, -2.98517160e-02f, -1.60782635e-01f, 2.52578454e-03f, 2.03990079e-02f, 1.03910901e-01f, -9.95491296e-02f, 7.74709061e-02f, 6.11989796e-02f,
  -3.55428942e-02f, -9.29970741e-02f, -6.41135452e-03f, -1.59228638e-01f, 3.59960087e-02f, -1.74181834e-01f, 1.67775139e-01f, 1.22761004e-01f, 2.56592575e-02f, -5.65814301e-02f,
  1.76620483e-01f, -3.54745537e-02f, -2.38204692e-02f, 7.94418529e-02f, -1.03069745e-01f, 4.51351143e-02f, 8.47703218e-02f, 1.87669992e-01f, -5.61171137e-02f, -2.70647053e-02f,
  -8.97903442e-02f, 3.25088087e-03f, 1.35137424e-01f, 1.66254357e-01f, -4.56786416e-02f, -5.03906347e-02f, 1.77075975e-02f, 1.35424510e-01f, -3.09320875e-02f, 4.02117930e-02f,
  1.00812994e-01f, 1.09412432e-01f, 3.91198741e-03f, 1.06894635e-01f, -3.30485846e-03f, 1.05966404e-01f, 9.69110951e-02f, 1.26672372e-01f, -6.61025420e-02f, -3.10602207e-02f,
  -5.77880852e-02f, 4.41212356e-02f, -4.95015793e-02f, 3.08072474e-02f, 9.87603739e-02f, 2.40123402e-02f, -3.58617567e-02f, -4.53912914e-02f, 1.71099842e-01f, -3.60086896e-02f,
  -6.99413270e-02f, 1.02342315e-01f, 4.13241014e-02f, -1.03534453e-01f, 2.05565661e-01f, -1.18016385e-01f, 1.73434138e-01f, 2.15550531e-02f, 5.45925125e-02f, -1.42664224e-01f,
  1.07142806e-01f, 1.51210530e-02f, -1.06525861e-01f, -1.20541558e-01f, -8.32298994e-02f, -2.17477623e-02f, 7.64158145e-02f, 5.54098375e-02f, -1.63207114e-01f, -1.66932810e-02f,
  4.14354168e-02f, -9.28554907e-02f, 2.22323790e-01f, 5.17491326e-02f, 1.02310486e-01f, -4.36652452e-02f, 1.45642124e-02f, 7.27481544e-02f, 7.18816444e-02f, -6.00673258e-02f,
  2.10470171e-03f, 1.01781346e-01f, -1.26789898e-01f, 6.73227683e-02f, 2.67740469e-02f, 7.45367631e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.18035376e-01f, -8.11341684e-03f, -9.29852799e-02f, -4.88171205e-02f, 2.02085059e-02f, -7.41681978e-02f, -4.82027605e-03f, 1.11108802e-01f, 1.41369337e-02f, 1.34379387e-01f,
  1.68260932e-01f, 1.75600406e-02f, 1.61809132e-01f, 1.77582756e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -7.03125224e-02f, 1.15601309e-02f, 9.87091139e-02f, 1.83081433e-01f, -1.68054178e-02f, -4.05032113e-02f, -1.82357430e-01f, -1.05412737e-01f, -6.93598986e-02f, 1.66516244e-01f,
  1.15683302e-01f, -8.85569900e-02f, 6.47033751e-02f, 4.30548470e-03f, 8.54490995e-02f, 3.75553407e-02f, -1.63610443e-01f, -5.14183529e-02f, 6.89150468e-02f, -3.97393219e-02f,
  -9.78251249e-02f, -8.04866552e-02f, 1.91654339e-02f, -8.28512982e-02f, -5.53739741e-02f, -1.04856275e-01f, -1.53846862e-02f, -9.86031070e-03f, 4.02884074e-02f, 7.88328722e-02f,
  -2.48976916e-01f, 2.36613788e-02f, 3.07070076e-01f, -2.78016537e-01f, -1.69598892e-01f, -1.57774493e-01f, 1.42278075e-01f, -1.29089326e-01f, -2.85214782e-02f, 1.40234366e-01f,
  -1.03514813e-01f, -2.03247741e-01f, 1.36383355e-01f, 1.23502210e-01f, 1.81001797e-01f, -8.51702839e-02f, -2.07278773e-01f, -3.47569026e-02f, -1.01414435e-01f, 1.59901798e-01f,
  -9.05049741e-02f, 1.34566218e-01f, -1.71123639e-01f, -6.15599081e-02f, -1.19620778e-01f, 1.23631306e-01f, -1.10775098e-01f, 5.36551774e-02f, -8.51327553e-02f, 4.17726934e-02f,
  -2.13522673e-01f, 1.02630101e-01f, -9.59837362e-02f, -7.23547265e-02f, 7.75636062e-02f, -1.85977429e-01f, -1.86270531e-02f, 1.95377305e-01f, -5.41742481e-02f, 6.73267990e-02f,
  7.07740337e-02f, 1.99529212e-02f, 3.63030136e-02f, 4.91490364e-02f, -5.16956188e-02f, 1.01236075e-01f, 6.28265515e-02f, -1.60799965e-01f, 2.73627877e-01f, -4.86501157e-02f,
  -2.64055580e-02f, 2.17904478e-01f, 1.21705629e-01f, 5.25605753e-02f, 1.23960124e-02f, 4.82341126e-02f, 5.54155745e-02f, 1.95983678e-01f, 1.62682161e-01f, -4.93377745e-02f,
  -9.21479836e-02f, -1.47662992e-02f, -1.23982169e-01f, -5.20918965e-02f, -1.75821632e-01f, -2.65799761e-02f, -1.66806236e-01f, 6.60912395e-02f, -5.41142933e-02f, 2.39269584e-01f,
  1.16802089e-01f, 3.84135097e-02f, -3.23990643e-01f, -2.28656009e-01f, 2.66394049e-01f, 9.16525051e-02f, 1.43507674e-01f, -6.43775240e-02f, -3.37093025e-01f, 2.54361451e-01f,
  6.41662702e-02f, -1.76039398e-01f, 2.95095384e-01f, 5.45609854e-02f, 2.06896976e-01f, -1.49261042e-01f, 1.42916873e-01f, 2.90569663e-02f, -1.15646543e-02f, 9.65713465e-04f,
  -7.42944106e-02f, -1.63142800e-01f, -7.77653679e-02f, -9.51700844e-03f, 4.93713804e-02f, -3.03649828e-02f, -1.57478154e-01f, -6.98874667e-02f, -7.58191049e-02f, -1.14699163e-01f,
  1.70329034e-01f, 5.73992915e-02f, 8.56582373e-02f, 6.61385655e-02f, -7.46817440e-02f, 5.20578586e-02f, -6.81919232e-02f, -4.64628525e-02f, -1.90527104e-02f, 8.25911984e-02f,
  -1.80873826e-01f, 2.23050877e-01f, -1.76678538e-01f, 6.31823838e-02f, 1.66110516e-01f, -1.32977039e-01f, 8.31270292e-02f, -1.11118048e-01f, 8.60372111e-02f, -9.11403298e-02f,
  -6.18145429e-02f, 1.72750250e-01f, -7.04250624e-03f, -4.67092283e-02f, 1.68947443e-01f, 3.66449058e-02f, -4.99526896e-02f, 1.37154266e-01f, 2.96937793e-01f, -1.28948197e-01f,
  5.92695363e-02f, -1.66153029e-01f, 6.74030334e-02f, -2.75468469e-01f, -1.66545212e-01f, 3.52049410e-01f, 2.61743695e-01f, 3.10159326e-01f, -1.78007141e-01f, -1.63411885e-01f,
  -2.66898662e-01f, 3.28895241e-01f, 9.77036133e-02f, -2.39482298e-01f, 1.18761085e-01f, 9.86019000e-02f, -3.71636987e-01f, -2.35024273e-01f, 6.59964010e-02f, 4.97467481e-02f,
  6.55234009e-02f, 1.33073358e-02f, 2.41929274e-02f, -1.20633639e-01f, -3.84714874e-03f, -8.94496292e-02f, -6.23066127e-02f, 3.56125683e-02f, 1.20316781e-02f, -3.90267931e-02f,
  -5.39387912e-02f, 9.94030312e-02f, -3.59004103e-02f, -2.64858037e-01f, 1.80390492e-01f, -5.58951758e-02f, 1.06095523e-01f, 5.59864044e-02f, 1.30011201e-01f, 1.61837220e-01f,
  9.63181108e-02f, -1.29247472e-01f, 3.69246714e-02f, 6.18946962e-02f, -8.72226804e-02f, 1.16748713e-01f, -1.28122464e-01f, -4.85527292e-02f, -5.35560912e-03f, -1.44917578e-01f,
  -7.36900717e-02f, 1.30996034e-01f, -1.38492450e-01f, -1.71373323e-01f, -5.90002015e-02f, 1.03407197e-01f, -1.93150174e-02f, -2.45510846e-01f, -1.35420054e-01f, 4.52589914e-02f,
  -1.63253397e-02f, 3.95272411e-02f, 3.51200640e-01f, 4.93014865e-02f, -2.06553087e-01f, -1.83003992e-02f, 2.09944844e-01f, 1.08625792e-01f, -9.81539413e-02f, 2.73676574e-01f,
  6.74092323e-02f, 1.58883691e-01f, 7.09720999e-02f, 1.88976880e-02f, -1.87185064e-01f, -2.38172393e-02f, -2.38745749e-01f, 5.87004423e-02f, 1.70251220e-01f, -1.49206787e-01f,
  -7.03323185e-02f, -2.92726725e-01f, 1.86521992e-01f, -5.63762598e-02f, 7.16221184e-02f, -5.58893122e-02f, 3.08373664e-03f, 5.78757748e-03f, 7.27872699e-02f, -2.10363001e-01f,
  9.42063630e-02f, 1.71226248e-01f, 1.09000854e-01f, -1.42036542e-01f, 1.43893048e-01f, -7.62503445e-02f, -1.01105226e-02f, 4.85137990e-03f, -2.19881222e-01f, -6.17287755e-02f,
  1.64503857e-01f, 5.67070507e-02f, 1.02036133e-01f, -1.32414386e-01f, -6.46926612e-02f, -1.05085045e-01f, 5.08167595e-02f, -2.24324688e-01f, 1.87048495e-01f, -1.02328278e-01f,
  5.21883667e-02f, 4.22921255e-02f, -4.98732142e-02f, 4.58903871e-02f, 7.64602721e-02f, -1.60908908e-01f, -1.25216782e-01f, 6.97050169e-02f, 5.95366359e-02f, -1.78878620e-01f,
  9.67709795e-02f, 3.65362018e-02f, -6.89677373e-02f, -2.59566933e-01f, 9.16920975e-02f, 5.50429486e-02f, -1.62351996e-01f, 7.47513818e-03f, 1.16656432e-02f, 8.03538188e-02f,
  4.51093912e-02f, -1.12904556e-01f, 2.09446013e-01f, -2.25728750e-01f, -1.15607940e-01f, -1.17349744e-01f, 3.76745649e-02f, -2.70873401e-03f, 2.26645693e-01f, -1.09178044e-01f,
  -2.80723512e-01f, 8.44186917e-02f, -3.66443813e-01f, -1.70971036e-01f, -3.09656970e-02f, 2.28276327e-01f, 1.92990266e-02f, -3.97968590e-02f, 1.09726064e-01f, 2.32586022e-02f,
  -1.08000375e-01f, 5.55006787e-02f, -1.20079540e-01f, 2.21637990e-02f, -8.20052996e-02f, 1.41135767e-01f, 7.33182132e-02f, 1.69806302e-01f, -1.17768914e-01f, 1.47397399e-01f,
  -1.10919975e-01f, -1.35579020e-01f, -1.04394436e-01f, -2.49999464e-02f, 7.19050914e-02f, 5.53910173e-02f, 1.07192613e-01f, 7.95256570e-02f, 1.35556176e-01f, -1.90667972e-01f,
  -1.62262246e-02f, -2.04798117e-01f, 9.20625404e-02f, -3.61422263e-02f, -7.56240860e-02f, -1.01140320e-01f, 1.63261890e-01f, 1.19863339e-01f, 3.84555236e-02f, -2.03406513e-02f,
  -4.45731767e-02f, -5.19258603e-02f, -1.48201376e-01f, -1.09761782e-01f, -1.53494075e-01f, 1.43434435e-01f, -8.03241134e-02f, -8.00019056e-02f, -1.30863860e-01f, 3.70389479e-03f,
  2.02883467e-01f, 2.23894328e-01f, -1.76110417e-01f, 1.22236446e-01f, 1.99090347e-01f, 1.88012898e-01f, -7.10261241e-02f, 8.31017122e-02f, -1.61830187e-01f, 1.06072746e-01f,
  1.33535311e-01f, 1.29600927e-01f, 1.23226449e-01f, -2.19076034e-02f, -1.83833450e-01f, 3.47745195e-02f, -6.56440407e-02f, 1.49854096e-02f, 7.96274170e-02f, -9.08627957e-02f,
  -2.75424309e-02f, 6.35619555e-03f, -6.96781725e-02f, -1.35080174e-01f, 6.53390884e-02f, -1.57996360e-02f, 3.51207354e-03f, -1.20065778e-01f, -5.14833257e-02f, 1.61157802e-01f,
  2.44518667e-01f, -4.77730930e-02f, 1.12864658e-01f, 2.58488487e-02f, -2.69199908e-02f, 1.35203764e-01f, -1.32521525e-01f, -8.45931321e-02f, 1.48759067e-01f, -8.18258058e-03f,
  -1.66872233e-01f, -3.08146775e-02f, -8.87735412e-02f, -2.50532432e-03f, 4.33605686e-02f, -1.35872215e-01f, 2.79747307e-01f, 3.74225602e-02f, 9.61810425e-02f, -4.77887467e-02f,
  -1.09870911e-01f, -1.91137604e-02f, 7.29081258e-02f, -3.56122269e-03f, 2.84951944e-02f, 1.25204593e-01f, 5.59836999e-02f, -8.99532363e-02f, 9.18275639e-02f, 2.63043553e-01f,
  8.67930800e-02f, -2.44012982e-01f, 9.95811746e-02f, 1.36618868e-01f, -8.11437666e-02f, -1.32048041e-01f, 3.54272500e-02f, -1.32881859e-02f, -2.97399133e-01f, -1.42502442e-01f,
  1.90198928e-01f, -1.46654099e-01f, -9.70675573e-02f, -2.28495061e-01f, -4.04150449e-02f, -9.96033251e-02f, 1.64962143e-01f, -9.14355516e-02f, 1.92561224e-02f, 9.13188159e-02f,
  -3.61704022e-01f, -7.76300998e-03f, -4.92668971e-02f, 1.21113755e-01f, -7.94584956e-03f, 6.27020448e-02f, -2.90012844e-02f, 1.42468616e-01f, -7.19189122e-02f, 3.53879780e-02f,
  -8.90761018e-02f, 9.17628109e-02f, -4.63401340e-02f, -1.46290585e-01f, 1.63651139e-01f, 1.23212831e-02f, -1.92245707e-01f, 1.12994500e-01f, 5.31091690e-02f, 1.56812757e-01f,
  -1.42830163e-01f, -1.14225820e-01f, -1.41561434e-01f, -2.35863756e-02f, 2.91708857e-02f, 7.77610317e-02f, 9.24418867e-02f, -1.43249542e-01f, -6.21483847e-02f, -1.97334155e-01f,
  -5.86175844e-02f, 3.14083174e-02f, 1.62715092e-02f, -8.36495683e-02f, 8.95870328e-02f, -1.63508594e-01f, -1.74919441e-01f, 7.95964599e-02f, -1.66117236e-01f, -1.41079603e-02f,
  -7.01285824e-02f, -1.15729153e-01f, -1.69479270e-02f, 6.18527196e-02f, 1.57604188e-01f, 6.63207769e-02f, -3.52942377e-01f, -6.78142309e-02f, 2.74056587e-02f, 9.59173515e-02f,
  -2.05995828e-01f, 2.48066381e-01f, 7.40507692e-02f, 3.38446379e-01f, -7.57592022e-02f, 1.43766567e-01f, 6.19055182e-02f, -1.15688592e-01f, 1.92658246e-01f, 2.38123983e-01f,
  -1.87154859e-02f, -2.90772170e-01f, 1.28057584e-01f, 1.94345936e-01f, -6.14484996e-02f, 1.17192596e-01f, 1.21261187e-01f, 1.75635964e-02f, -2.11816635e-02f, -1.35614518e-02f,
  -1.66122317e-02f, -2.81526186e-02f, 8.46663117e-02f, 1.31227849e-02f, 3.84247042e-02f, 2.40182541e-02f, -1.29164219e-01f, 6.46808296e-02f, 1.22890405e-01f, -1.48998156e-01f,
  2.70253606e-02f, 1.20390384e-02f, -6.28647730e-02f, -1.22748233e-01f, -1.93182454e-01f, -1.73495170e-02f, 5.77827878e-02f, -1.11393549e-01f, 2.35204369e-01f, 8.87851641e-02f,
  1.32585436e-01f, 1.00713363e-02f, -9.66399536e-03f, -1.19119249e-01f, -5.06297573e-02f, 1.14963008e-02f, -2.23306213e-02f, 1.57230601e-01f, 2.56958678e-02f, 3.53926234e-02f,
  9.44711939e-02f, 6.53582858e-03f, -5.95736168e-02f, -3.80863994e-02f, 1.39210701e-01f, 1.29824057e-01f, 3.00432816e-02f, -9.16674063e-02f, -1.22940568e-02f, 9.83350426e-02f,
  -2.17472285e-01f, 5.00365160e-02f, 1.08736016e-01f, -2.60188468e-02f, -2.00292319e-01f, -1.04451738e-02f, 1.63454756e-01f, 3.01141143e-02f, -1.51889399e-02f, -1.08527966e-01f,
  -1.42931476e-01f, -2.11632684e-01f, -7.22833946e-02f, -3.81339118e-02f, -6.43994883e-02f, 5.03730513e-02f, -2.96938926e-01f, -1.62094027e-01f, 6.14186935e-02f, -4.52006646e-02f,
  2.11144552e-01f, -5.12193777e-02f, 4.55036685e-02f, -1.65332690e-01f, -2.26200055e-02f, 4.74172235e-02f, 1.10559978e-01f, 1.16422370e-01f, 6.96982965e-02f, 4.95401248e-02f,
  -1.62030116e-03f, 1.41772717e-01f, 8.99283886e-02f, -1.69059247e-01f, 1.82858288e-01f, 1.15124486e-01f, -1.07715212e-01f, 2.56953891e-02f, -1.07405923e-01f, 2.72896998e-02f,
  2.25888565e-01f, 4.23786603e-02f, -6.98529650e-03f, -5.73005229e-02f, -1.45266041e-01f, 4.37076464e-02f, 1.37116402e-01f, -1.65441513e-01f, -4.53959145e-02f, 1.41203940e-01f,
  -2.51933724e-01f, 2.20398068e-01f, 2.12055724e-02f, -3.71705852e-02f, 1.15560509e-01f, -1.48600161e-01f, 1.57395333e-01f, -9.33524370e-02f, 5.15228435e-02f, 2.75432356e-02f,
  -1.35985926e-01f, 1.24055542e-01f, -2.32894626e-02f, -1.72973685e-02f, 1.61804035e-01f, 8.44764188e-02f, -2.41960771e-02f, 1.06591210e-02f, 1.89905629e-01f, -2.17195407e-01f,
  -9.61771011e-02f, -3.54404122e-01f, 7.38014132e-02f, 1.11497499e-01f, 1.26108944e-01f, 2.08612122e-02f, -3.83669496e-01f, -2.21643314e-01f, -9.97999460e-02f, 4.22829479e-01f,
  -1.27255663e-01f, -1.79769158e-01f, -1.11721102e-02f, -1.71702001e-02f, 3.18696089e-02f, -8.23860541e-02f, -9.54030976e-02f, 7.34286755e-02f, -6.59784004e-02f, 1.03406973e-01f,
  -4.66163568e-02f, 1.27758965e-01f, 9.75352302e-02f, 6.93902448e-02f, -1.14485621e-01f, 4.73606847e-02f, -1.90088395e-02f, 1.26761552e-02f, 5.94604984e-02f, 2.18774244e-01f,
  4.33096103e-02f, 2.79067457e-02f, -1.25029728e-01f, -1.89035572e-02f, -1.51135176e-02f, 1.14979386e-01f, -7.47652724e-03f, -1.03082120e-01f, 1.10250100e-01f, -7.46343508e-02f,
  -1.95818454e-01f, 5.35173118e-02f, 1.48396626e-01f, -4.06713486e-02f, 1.67918041e-01f, -1.74139038e-01f, -1.44929796e-01f, -1.25282377e-01f, -8.14623386e-02f, 8.57039317e-02f,
  4.52763774e-02f, 1.14669330e-01f, 4.78310212e-02f, 2.38033161e-02f, 1.71100274e-01f, 2.12961718e-01f, 1.29784048e-01f, -1.18191421e-01f, -1.96368128e-01f, -3.69702317e-02f,
  -2.00867549e-01f, 1.33665688e-02f, -1.55872673e-01f, -7.88987800e-03f, 9.78378803e-02f, 3.23785841e-01f, 1.78084031e-01f, -8.14656317e-02f, -3.00913714e-02f, -7.41207972e-02f,
  1.33577317e-01f, 2.77981251e-01f, 1.48693509e-02f, -2.74332434e-01f, -2.61272714e-02f, 2.81084329e-01f, -1.62180215e-01f, 4.33690138e-02f, 1.09391332e-01f, 2.34984264e-01f,
  7.11631477e-02f, 8.38679075e-02f, 1.27426565e-01f, -7.97508135e-02f, 6.66315779e-02f, -4.10119072e-03f, 1.33927196e-01f, 6.05521724e-02f, -1.77562330e-02f, -8.16381276e-02f,
  5.30562140e-02f, 6.54491186e-02f, -1.01993017e-01f, -2.39175800e-02f, -1.38590693e-01f, -5.51494472e-02f, -1.26225099e-01f, -3.32499668e-03f, -1.88273210e-02f, 5.95645979e-02f,
  -5.81017733e-02f, -1.20383240e-01f, 7.62394741e-02f, -5.80414049e-02f, -1.90926492e-02f, -1.04855374e-01f, -9.32825450e-03f, -2.81784330e-02f, 2.22573262e-02f, 8.94010291e-02f,
  1.08524896e-01f, -3.95021029e-02f, 1.22735500e-01f, 1.85624212e-02f, 1.34822920e-01f, 3.11557986e-02f, -1.71485871e-01f, -1.11197397e-01f, -8.30838606e-02f, -7.72900134e-03f,
  -8.75886381e-02f, -2.09445432e-01f, 1.87988028e-01f, 2.03572646e-01f, 1.29590392e-01f, -1.61403328e-01f, 1.78146333e-01f, 2.62931027e-02f, -7.64617547e-02f, -2.37651616e-01f,
  4.63422528e-03f, -3.71803232e-02f, 1.29202500e-01f, -7.93695524e-02f, -9.92485508e-02f, -1.66989252e-01f, 8.28443244e-02f, 1.83173835e-01f, -3.03219408e-02f, -8.74813087e-03f,
  -9.41389576e-02f, 7.43595883e-02f, -9.48584378e-02f, -2.31219828e-02f, 2.95461738e-03f, 1.15310207e-01f, -8.50632712e-02f, 6.76535666e-02f, 1.10477572e-02f, -1.47799379e-04f,
  -2.37955302e-02f, 1.41644618e-02f, -2.04799306e-02f, -1.55576080e-01f, 1.86913118e-01f, -9.51800197e-02f, -4.26005311e-02f, 1.23231299e-01f, -1.15060164e-02f, -4.39207517e-02f,
  -9.43784714e-02f, -4.97637950e-02f, 7.96404853e-03f, -1.43693005e-05f, 2.20381662e-01f, 1.87783949e-02f, -9.62401927e-02f, -8.53555202e-02f, 9.08115804e-02f, 1.68024767e-02f,
  6.29528984e-02f, -6.82926923e-02f, 1.46653846e-01f, 2.35291913e-01f, 1.64034776e-02f, 5.38260601e-02f, 1.69673681e-01f, 4.92534926e-03f, -1.17221430e-01f, -1.82586219e-02f,
  5.85205629e-02f, 2.42315710e-01f, -1.53538957e-01f, -9.98079404e-02f, -1.06304362e-01f, 2.90946990e-01f, -5.23562804e-02f, -4.24129441e-02f, 8.17201734e-02f, 1.12118512e-01f,
  -7.75639489e-02f, -1.83112308e-01f, 2.50467002e-01f, -7.27029459e-04f, -1.86008558e-01f, -1.23538285e-01f, -8.98941085e-02f, -1.10599905e-01f, -1.43964484e-01f, -2.14089364e-01f,
  -4.24184240e-02f, 2.25575089e-01f, -2.73334861e-01f, -3.75422567e-01f, -3.47406119e-02f, 7.48059712e-03f, 3.02568078e-01f, -6.31979555e-02f, 1.27854049e-01f, -5.22309691e-02f,
  -4.85686734e-02f, -9.25112367e-02f, -3.54060791e-02f, 1.06844595e-02f, 1.44939609e-02f, -5.20022139e-02f, 1.13148749e-01f, 2.45877877e-01f, -1.69210374e-01f, 2.30717361e-02f,
  2.15034485e-01f, -8.69485363e-02f, 1.29506961e-01f, 1.03340670e-01f, 1.42532796e-01f, 4.52146567e-02f, -8.21397007e-02f, 6.83813319e-02f, 9.88107249e-02f, 1.86988100e-01f,
  8.12286586e-02f, -3.66809927e-02f, -5.33210561e-02f, 6.50269166e-02f, -2.51578480e-01f, 2.35013768e-01f, -4.05228958e-02f, -2.86308397e-02f, -3.90698202e-03f, -3.22847366e-02f,
  -5.79490587e-02f, -5.62304631e-02f, -1.28815338e-01f, 2.61709616e-02f, 2.32932623e-02f, 2.23327532e-01f, 1.39655769e-01f, 7.98816681e-02f, -5.06827869e-02f, 2.62753159e-01f,
  -8.08423758e-02f, 1.49333365e-02f, 1.98367223e-01f, -2.25054305e-02f, -9.52942222e-02f, 4.31282669e-02f, 8.23963583e-02f, 5.41821010e-02f, -2.17964146e-02f, 2.00875416e-01f,
  4.14633863e-02f, 7.70564154e-02f, -1.15512580e-01f, -8.73244107e-02f, -2.67385006e-01f, 8.89476575e-03f, 2.04097807e-01f, 6.42045215e-02f, 1.70758992e-01f, 1.35161921e-01f,
  -2.05901697e-01f, -1.53443322e-01f, -9.27168056e-02f, -4.87336889e-02f, -1.16741240e-01f, 6.27467260e-02f, -6.92170933e-02f, -6.80083781e-02f, 2.88183931e-02f, 4.86902930e-02f,
  -7.50067681e-02f, -4.45831893e-03f, 4.10575308e-02f, 3.04388180e-02f, 3.33449431e-02f, 9.09288153e-02f, -1.10519892e-02f, 1.82442501e-01f, -1.75593555e-01f, 1.29799426e-01f,
  8.78350809e-02f, -5.40950261e-02f, -1.95993498e-01f, 1.05790667e-01f, -1.04505971e-01f, 1.11509869e-02f, 1.32167056e-01f, 5.83588853e-02f, 1.62892222e-01f, -5.38499281e-03f,
  -5.76220229e-02f, 1.02034792e-01f, -1.35683611e-01f, 1.13352299e-01f, 1.68297067e-01f, -1.08283035e-01f, 1.45363033e-01f, 1.12120621e-02f, -1.25570267e-01f, -9.43951905e-02f,
  1.34295911e-01f, 1.39671192e-01f, 7.14428648e-02f, -1.77464142e-01f, 1.31244063e-01f, 3.02043676e-01f, 5.01464345e-02f, -1.29040301e-01f, 2.69495517e-01f, -1.14483893e-01f,
  -3.34869981e-01f, -3.13443094e-01f, 4.51070666e-02f, -6.36289194e-02f, 8.91730636e-02f, -4.38698605e-02f, -6.05231598e-02f, -9.06246379e-02f, 4.44287136e-02f, 2.88293995e-02f,
  2.72378802e-01f, 9.88445058e-02f, -2.20907480e-01f, 7.62867779e-02f, -3.54545057e-01f, -1.23032540e-01f, -2.12986946e-01f, 7.82737657e-02f, -9.60582495e-02f, -7.42436200e-02f,
  -1.41734987e-01f, 1.48587644e-01f, 3.98632437e-02f, 4.65734154e-02f, 1.14463873e-01f, -7.89298788e-02f, -9.21861157e-02f, 4.76867863e-04f, -7.98375085e-02f, 4.42357659e-02f,
  4.25230935e-02f, 5.17830700e-02f, -6.21247292e-02f, 9.20929983e-02f, -9.06545669e-02f, 6.94278032e-02f, 3.16554867e-02f, -4.20603678e-02f, 8.76192302e-02f, -1.02276750e-01f,
  -1.11774147e-01f, 8.39134529e-02f, 4.48769443e-02f, -7.09058121e-02f, 1.89054638e-01f, -2.06944793e-01f, -3.70079838e-02f, 1.65804118e-01f, -6.01365343e-02f, -6.65540472e-02f,
  2.36775931e-02f, -2.26747384e-03f, -1.03923388e-01f, -9.39562246e-02f, 2.06295066e-02f, 5.83235733e-02f, -1.04094595e-01f, -1.97467327e-01f, -4.48546745e-02f, -7.31757358e-02f,
  -2.41348907e-01f, 1.23480648e-01f, -6.76985905e-02f, 6.01671170e-03f, -1.53272897e-01f, 2.00438082e-01f, 1.65692002e-01f, -3.18150252e-01f, -2.25371867e-01f, -2.67266572e-01f,
  2.93642789e-01f, 1.71040505e-01f, 8.39210227e-02f, -3.24165374e-01f, -2.92104483e-02f, 8.22022781e-02f, -1.70386761e-01f, 7.18748197e-02f, 2.57343471e-01f, 3.01979542e-01f,
  -1.34269074e-01f, -6.67682812e-02f, 1.55696228e-01f, 1.63085431e-01f, 6.41704500e-02f, 4.97806668e-02f, -1.19151808e-01f, 9.31051895e-02f, 1.50462285e-01f, 1.06969811e-02f,
  1.35733321e-01f, 9.95195284e-02f, -1.37257829e-01f, -1.43392593e-01f, 3.47018279e-02f, -2.87673950e-01f, 1.04562700e-01f, -7.40518188e-03f, 3.61967273e-03f, 1.60790309e-01f,
  -1.07759573e-01f, 3.99384238e-02f, -1.32293120e-01f, 1.34606272e-01f, 2.10343137e-01f, 1.16655320e-01f, -8.40357244e-02f, -1.54890403e-01f, 9.65584442e-02f, -7.43370829e-03f,
  1.50053725e-01f, 6.70112250e-03f, 4.26553898e-02f, 1.52679160e-01f, 1.39082268e-01f, 5.13435043e-02f, 1.80671528e-01f, 2.34284952e-01f, -3.78894582e-02f, -2.11974099e-01f,
  -1.37183383e-01f, 1.39483772e-02f, 1.69614881e-01f, -1.21234275e-01f, -8.39356482e-02f, 9.06692222e-02f, 1.00430250e-01f, -1.83872119e-01f, -3.04054245e-02f, -6.44473210e-02f,
  3.56850959e-02f, -3.60543244e-02f, -9.25711691e-02f, -6.21075332e-02f, 7.27578700e-02f, -3.45518179e-02f, 1.35101229e-01f, 1.07616782e-01f, -2.47521758e-01f, -1.21788587e-03f,
  2.69420803e-01f, -9.88150202e-03f, -1.30910546e-01f, -2.13587731e-01f, -1.70677584e-02f, -1.46086827e-01f, -9.86365154e-02f, 1.08481400e-01f, -8.76264051e-02f, -3.12628672e-02f,
  -1.56726778e-01f, -1.05158724e-01f, -2.09657233e-02f, -3.93173508e-02f, 5.16110063e-02f, -3.75789143e-02f, -8.57474506e-02f, -9.43100080e-02f, -4.71673422e-02f, -1.75600320e-01f,
  9.33425277e-02f, 8.47968087e-03f, -7.11930990e-02f, -6.30593766e-03f, 7.26067796e-02f, -9.23182443e-02f, -2.07430154e-01f, -6.95771575e-02f, 1.56100392e-01f, 4.33039367e-02f,
  6.08594390e-03f, 3.43676135e-02f, 1.31100625e-01f, 1.90072626e-01f, -1.55344680e-01f, 1.19437382e-01f, -1.94601286e-02f, -1.55665740e-01f, -1.54238999e-01f, 2.03872975e-02f,
  1.03924334e-01f, 1.34093910e-01f, -3.39396484e-02f, -2.08971668e-02f, -7.30081573e-02f, -1.31347422e-02f, 2.82993857e-02f, -3.40456292e-02f, -2.00679317e-01f, -3.68799828e-02f,
  2.51015395e-01f, -2.16178790e-01f, 2.02440590e-01f, -2.33892143e-01f, -3.24832574e-02f, -2.19590291e-01f, -7.46970326e-02f, 7.38178715e-02f, -1.70625627e-01f, -8.91865790e-02f,
  3.64023596e-02f, 2.72969663e-01f, -3.57688107e-02f, -2.81525731e-01f, -3.92266884e-02f, -1.31924465e-01f, 2.99327731e-01f, 3.47205773e-02f, -7.78034255e-02f, -1.08991988e-01f,
  -1.39504448e-01f, -4.85984497e-02f, -9.18487683e-02f, 9.20577273e-02f, -1.31860645e-02f, 9.56087634e-02f, -1.23314455e-01f, 7.12822378e-02f, -2.68480092e-01f, 1.43906519e-01f,
  5.16190678e-02f, 1.57068186e-02f, 2.09943801e-02f, -2.71538138e-01f, -1.81186348e-01f, 1.16894804e-01f, 1.76745832e-01f, -1.10223271e-01f, 2.37967558e-02f, 1.05462171e-01f,
  3.46555933e-02f, -1.45663783e-01f, 1.14199720e-01f, -1.11073568e-01f, -1.12476304e-01f, -6.52681617e-03f, 1.23107977e-01f, 1.80099934e-01f, -5.54689998e-03f, -3.14821042e-02f,
  1.05526291e-01f, -1.28909782e-01f, -3.88784409e-02f, -7.31889531e-02f, 1.16216622e-01f, 1.78606495e-01f, -1.25505462e-01f, -1.09951459e-01f, -1.15956277e-01f, 1.76310152e-01f,
  -8.89634416e-02f, 5.32376170e-02f, 2.06791952e-01f, -7.63900857e-03f, -9.46030095e-02f, 4.59977575e-02f, 5.15698344e-02f, -2.11039558e-01f, -1.45414904e-01f, -1.01272330e-01f,
  -1.06982939e-01f, 9.36333016e-02f, -2.22816542e-01f, -2.48451829e-01f, -3.97508405e-02f, 3.45032901e-01f, -1.89301133e-01f, -3.12886864e-01f, 1.58085406e-01f, -1.35087539e-02f,
  1.27178028e-01f, -1.96053088e-01f, -4.42926139e-02f, -9.16740969e-02f, -2.14465290e-01f, 1.05791219e-01f, -5.75073245e-05f, 4.95760590e-02f, 1.20956540e-01f, -5.70082925e-02f,
  -4.40229811e-02f, 1.71910614e-01f, 4.93242592e-02f, 8.30205530e-02f, -6.15589209e-02f, 1.24170661e-01f, -3.97662930e-02f, 2.07444474e-01f, 4.71912660e-02f, 9.59937926e-03f,
  -1.63911685e-01f, -1.16144665e-01f, -1.41946018e-01f, -3.70463505e-02f, 2.34242491e-02f, -1.65457457e-01f, 4.58181165e-02f, 1.34628206e-01f, 6.93778545e-02f, 8.61994401e-02f,
  -1.34932980e-01f, -5.17872982e-02f, -2.93039549e-02f, -3.72251496e-02f, -1.71841145e-01f, 1.04176432e-01f, -1.94512494e-02f, -6.69484809e-02f, -2.21861918e-02f, -2.70795263e-02f,
  -3.97668295e-02f, -5.26441671e-02f, 2.92756796e-01f, 2.40444124e-01f, -1.71041355e-01f, -5.22635542e-02f, -1.13320179e-01f, 4.97054979e-02f, -1.86100658e-02f, 7.75396600e-02f,
  1.64929524e-01f, -4.69793417e-02f, -1.83359429e-01f, 1.31209746e-01f, 1.44468307e-01f, 1.93747044e-01f, 2.52410397e-02f, 1.25354037e-01f, -1.73391268e-01f, -2.10696086e-01f,
  3.61995578e-01f, 2.25704517e-02f, 1.38140544e-01f, 9.10929516e-02f, -6.32323921e-02f, -9.11322534e-02f, -1.37615964e-01f, 7.80405849e-02f, 6.10732362e-02f, -9.80778039e-03f,
  8.53994414e-02f, -8.49028006e-02f, 8.53094161e-02f, 1.25751659e-01f, -5.42428344e-03f, 1.28598064e-01f, -1.58847734e-01f, 6.75128177e-02f, 2.01107875e-01f, -1.69001848e-01f,
  1.73446536e-02f, -8.77988338e-02f, 1.27654895e-01f, 5.49713969e-02f, -7.02401623e-02f, -1.69441327e-01f, 1.81579351e-01f, -4.30270284e-02f, 1.13104343e-01f, -1.03438199e-01f,
  1.83423117e-01f, -2.39997637e-02f, 6.97530434e-02f, 8.99837092e-02f, 1.47201553e-01f, 5.83076254e-02f, -4.92189899e-02f, -1.28736839e-01f, -7.84158707e-02f, -1.01119600e-01f,
  -3.52435955e-03f, -1.96015358e-01f, 6.99115917e-02f, 2.68159777e-01f, -5.56281582e-02f, -3.90144102e-02f, 6.14665747e-02f, 2.09667295e-01f, -2.64652044e-01f, -4.09837719e-03f,
  2.41975754e-01f, 1.07635871e-01f, 4.53162976e-02f, -2.20144670e-02f, 2.46876553e-01f, 6.30670637e-02f, -2.80339122e-01f, -1.04436420e-01f, -2.07225606e-01f, -1.64169017e-02f,
  -1.45733923e-01f, -1.23140379e-03f, 6.51737675e-02f, 1.30864382e-01f, -9.21411589e-02f, -2.40016967e-01f, 9.03526768e-02f, 6.58995286e-02f, 4.45263050e-02f, -2.08304495e-01f,
  -3.15027079e-03f, -9.36846733e-02f, -1.63307101e-01f, -8.08137506e-02f, -7.77587369e-02f, -4.02661487e-02f, 1.68749150e-02f, 2.01465134e-02f, 6.73700497e-02f, 2.69114673e-01f,
  -1.09657958e-01f, 5.72414361e-02f, 9.79863852e-02f, 4.40183990e-02f, -2.96834204e-02f, 7.05959946e-02f, -5.75694777e-02f, 8.93172473e-02f, 1.01205990e-01f, -4.04942967e-02f,
  -1.68997467e-01f, 5.25518805e-02f, -1.00589693e-02f, -1.45337299e-01f, 1.52523592e-01f, -1.18285686e-01f, 1.14569932e-01f, 1.85455486e-01f, -1.40590861e-01f, -7.71119669e-02f,
  -1.64187327e-01f, -1.42977789e-01f, -7.79995173e-02f, -6.25678003e-02f, -1.15249641e-01f, 7.42097795e-02f, -9.27023217e-03f, -4.49317135e-02f, -2.38235132e-03f, 2.65035987e-01f,
  2.02367142e-01f, -9.94497165e-02f, 1.38458624e-01f, 2.54211903e-01f, 9.95718688e-02f, -1.61145926e-01f, 2.41237551e-01f, -8.70066509e-02f, -1.82255715e-01f, -1.49537310e-01f,
  6.18064664e-02f, -1.46008506e-01f, 1.72177687e-01f, 9.72534493e-02f, -1.01334020e-01f, 1.05349109e-01f, 1.53793588e-01f, 1.39969990e-01f, 1.44227698e-01f, 1.66789308e-01f,
  -1.69552509e-02f, 1.03914700e-01f, -3.49991351e-01f, 1.30904749e-01f, -2.00560808e-01f, -3.39449644e-02f, -1.53787777e-01f, 2.09000185e-02f, -2.71229316e-02f, -1.77397598e-02f,
  3.91283892e-02f, 5.36035188e-02f, -8.07778388e-02f, 2.47302447e-02f, 6.45605773e-02f, 3.34588438e-02f, -8.27674866e-02f, -4.51318286e-02f, 5.89714572e-03f, -5.91107868e-02f,
  1.79507196e-01f, 7.32073486e-02f, -1.85640201e-01f, 9.06203687e-02f, -2.23249681e-02f, 6.59949407e-02f, -3.89274098e-02f, 2.40476817e-01f, -2.73958165e-02f, 1.82704225e-01f,
  6.16172403e-02f, -1.40440971e-01f, -4.90562171e-02f, 5.75824417e-02f, 6.88798502e-02f, -5.19340001e-02f, -2.18338743e-02f, 6.34875149e-02f, 1.85315415e-01f, 7.04527050e-02f,
  -6.75987976e-04f, -3.48703824e-02f, 1.15525790e-01f, -2.62459159e-01f, -1.91859215e-01f, -9.16559547e-02f, -4.46446203e-02f, -6.10834919e-02f, 1.68762445e-01f, 5.71794473e-02f,
  -1.28938034e-01f, -4.43173684e-02f, -8.02448466e-02f, 1.05196824e-02f, 4.27515395e-02f, 1.63527921e-01f, -1.85528584e-03f, 1.01553783e-01f, -1.18792420e-02f, -1.13753296e-01f,
  4.44836318e-02f, -3.47746462e-02f, -1.10795796e-01f, 6.72136247e-02f, 1.45047426e-01f, -1.81082979e-01f, 1.91086456e-01f, -1.13136530e-01f, 1.70568049e-01f, 6.55882284e-02f,
  -7.31327757e-03f, 8.88148993e-02f, -4.19193320e-02f, -2.57477295e-02f, -4.99863736e-02f, -6.94359913e-02f, 3.13077755e-02f, 2.38224827e-02f, 7.38949478e-02f, -1.05305240e-01f,
  -7.30716363e-02f, 6.92401379e-02f, -2.87960991e-02f, -4.45604585e-02f, 1.13569789e-01f, -1.96215548e-02f, -7.63353407e-02f, 2.24733818e-02f, -6.01634197e-02f, 6.26700837e-03f,
  5.88261522e-02f, 1.87486768e-01f, 2.37594172e-02f, 1.66744560e-01f, -5.19062951e-02f, 1.45542979e-01f, 8.29317421e-03f, -9.72418711e-02f, -7.53702074e-02f, 5.99065237e-02f,
  -3.87901291e-02f, -7.18703195e-02f, -1.17252976e-01f, 1.60080139e-02f, -1.52252335e-02f, 7.02022156e-03f, 8.80648661e-03f, -4.40260582e-02f, 9.60256439e-03f, -1.93481073e-01f,
  2.91962266e-01f, 1.49809182e-01f, 1.08289830e-01f, -1.42422259e-01f, -4.53083217e-02f, -3.99183035e-02f, -2.40836352e-01f, -7.84589723e-02f, 2.33395174e-01f, 1.01250252e-02f,
  5.57572581e-02f, 2.22229864e-02f, -3.87180522e-02f, -7.02800006e-02f, -2.09156647e-02f, 8.22306704e-03f, 1.13996968e-01f, 1.30235314e-01f, -9.93181765e-02f, 1.23314254e-01f,
  -2.41963625e-01f, -1.32695541e-01f, -2.38663387e-02f, 2.39488959e-01f, -6.05256222e-02f, -2.55316962e-02f, -1.01540335e-01f, 9.97282639e-02f, -8.67806599e-02f, -7.41109326e-02f,
  -6.13572821e-02f, 3.13702822e-02f, 1.32517681e-01f, -9.06822905e-02f, -9.64573175e-02f, -2.65268646e-02f, -7.86318332e-02f, 1.23667620e-01f, -2.98162967e-01f, -1.71003789e-02f,
  1.89496309e-01f, 9.31307599e-02f, -1.48042098e-01f, -1.92045681e-02f, -8.73486847e-02f, -3.26558575e-02f, 1.25750288e-01f, 2.31977901e-03f, 2.22686812e-01f, 9.59192365e-02f,
  1.57526769e-02f, -4.67032194e-03f, 9.54313874e-02f, 9.62969195e-03f, -3.25379036e-02f, 6.52355701e-02f, 9.88599937e-03f, 1.55322641e-01f, -1.19336158e-01f, -2.09789410e-01f,
  -4.12463509e-02f, 2.99387664e-01f, 1.48797914e-01f, -2.17318520e-01f, 2.21862316e-01f, 8.02619383e-02f, -1.80118345e-02f, -5.84295020e-02f, 2.08088115e-01f, 1.24492154e-01f,
  -2.27751613e-01f, -1.82966918e-01f, 2.38276437e-01f, -6.43412545e-02f, 1.46456435e-01f, -1.05629571e-01f, -8.62852558e-02f, 2.68122777e-02f, 6.65710643e-02f, -4.16117236e-02f,
  8.13393444e-02f, -2.41387840e-02f, -2.25365072e-01f, 1.94354475e-01f, -1.80928797e-01f, 4.75153374e-03f, -1.77945852e-01f, 1.23520277e-01f, 7.70481378e-02f, 6.62459955e-02f,
  4.34019156e-02f, -8.92612934e-02f, 1.58136133e-02f, 3.00964974e-02f, 5.70643097e-02f, -1.91339720e-02f, 9.67174619e-02f, -7.88830668e-02f, -1.00288920e-01f, 1.52569205e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -4.55485433e-02f, -3.14281844e-02f, 1.20011391e-02f, -1.86138786e-02f, 1.62425950e-01f, 3.03859334e-03f, 1.13269530e-01f, -4.83677089e-02f, -2.28869990e-02f, -6.31337166e-02f,
  3.91343096e-03f, 4.95275706e-02f, 1.32399708e-01f, 2.98535265e-02f, -7.47933313e-02f, -1.45382220e-02f, 2.39240807e-02f, -7.93375075e-02f, 7.95109197e-02f, 2.10227352e-02f,
  9.47620198e-02f, -9.54541713e-02f, 7.94059504e-03f, -6.30257651e-02f, 8.65509585e-02f, -7.90566653e-02f, -1.04501639e-02f, -1.24408402e-01f, 2.33613737e-02f, 9.13759768e-02f,
  -7.70463943e-02f, 4.93296124e-02f, -4.80682291e-02f, -5.89942709e-02f, -1.44582734e-01f, 8.88859928e-02f, -6.37220368e-02f, -4.78320420e-02f, 1.80980638e-02f, -9.06512365e-02f,
  -3.17506380e-02f, 1.34300753e-01f, -2.27289125e-02f, 4.32372466e-02f, -1.24619044e-01f, 6.23716563e-02f, 8.34716707e-02f, -4.26081270e-02f, -1.34428844e-01f, 7.29845837e-02f,
  4.31890339e-02f, -6.50520995e-02f, -2.11445987e-02f, 9.42000449e-02f, -6.37281965e-03f, -1.14352614e-01f, 5.14599346e-02f, 1.01865299e-01f, -2.03689504e-02f, 1.23659924e-01f,
  1.81025937e-01f, 5.24763912e-02f, -9.69925001e-02f, -1.21013306e-01f, 4.54645902e-02f, -7.96783939e-02f, 6.88820109e-02f, -1.02451500e-02f, 9.89028066e-02f, 7.58755505e-02f,
  1.71903819e-01f, -7.57165998e-02f, 5.84948361e-02f, 3.14269289e-02f, 3.60811800e-02f, 1.32898437e-02f, 1.19993649e-02f, -2.05757976e-01f, 8.37557390e-02f, 2.02588942e-02f,
  2.12125137e-01f, 2.01104462e-01f, 1.62884459e-01f, 6.67830706e-02f, 1.47876993e-01f, 5.32711893e-02f, 1.94566295e-01f, 3.42501216e-02f, 6.96704090e-02f, -2.27875397e-01f,
  -3.01935405e-01f, 8.86316895e-02f, -1.27039716e-01f, -3.43264802e-03f, 2.18186691e-01f, -6.37642667e-02f, -2.33502507e-01f, 6.97117718e-03f, 3.61456815e-03f, 1.94967002e-01f,
  6.37758523e-02f, 8.33976343e-02f, -1.93043157e-01f, 1.59663968e-02f, 1.49118319e-01f, -1.15575036e-02f, 1.86505467e-01f, -1.13100477e-01f, -3.73830050e-01f, -7.15730414e-02f,
  2.24544495e-01f, -2.46496513e-01f, 3.19485068e-01f, -9.56326127e-02f, 4.61949408e-02f, -1.62639737e-01f, -8.78910795e-02f, 1.50514796e-01f, -1.04192421e-01f, -1.91951171e-02f,
  3.98525386e-04f, 7.03562424e-02f, -9.22876671e-02f, 2.34066218e-01f, 2.52072006e-01f, 2.92344522e-02f, 1.20973356e-01f, 1.31428272e-01f, -7.54686594e-02f, -4.11945209e-03f,
  2.64162332e-01f, 1.29172206e-01f, 7.76681378e-02f, -1.17582846e-02f, 1.50228426e-01f, 2.33758241e-01f, 5.29227443e-02f, 6.72610551e-02f, 3.56048718e-02f, 1.80430695e-01f,
  -1.55186355e-01f, 1.33796707e-01f, -1.64884508e-01f, 8.14036354e-02f, 1.77445397e-01f, -9.80067998e-02f, -7.16149583e-02f, 3.04697976e-02f, -9.77926031e-02f, -1.85801834e-02f,
  2.22003534e-01f, 6.84799254e-02f, 4.45078090e-02f, -2.87363201e-01f, -2.00063646e-01f, 2.91040335e-02f, 1.93006217e-01f, 8.54898244e-03f, 1.40003756e-01f, -1.43858746e-01f,
  -9.87885147e-02f, -6.55016601e-02f, -4.15500291e-02f, -1.99705750e-01f, -1.46926805e-01f, 2.57445037e-01f, -1.04158342e-01f, 8.01197067e-02f, -5.00337705e-02f, -7.79771283e-02f,
  -2.38558248e-01f, 2.18702316e-01f, -1.41141545e-02f, 8.48494098e-02f, 1.95785820e-01f, 1.02617340e-02f, 2.87921471e-03f, -5.32505251e-02f, 1.40895043e-02f, 1.30231425e-01f,
  -1.30529001e-01f, 1.33792385e-01f, -7.09088966e-02f, -8.75479802e-02f, -1.45892873e-01f, -8.17717463e-02f, -1.44085005e-01f, -1.47453079e-03f, 5.65237030e-02f, -2.25411747e-02f,
  -7.53971422e-03f, 3.11996177e-04f, -1.11476131e-01f, 6.72036558e-02f, -1.83096498e-01f, -4.58237715e-02f, -9.76568907e-02f, -7.10044354e-02f, 1.97857041e-02f, 1.04892209e-01f,
  -4.49083261e-02f, 2.79580094e-02f, 3.33909281e-02f, -7.43330717e-02f, 7.37127289e-02f, -1.38226449e-01f, 1.67961922e-02f, -1.13852225e-01f, 1.31136207e-02f, 8.46051499e-02f,
  -1.08417377e-01f, 9.60205793e-02f, -6.48316368e-02f, 5.73612899e-02f, 1.66966952e-02f, -1.53992012e-01f, 6.89910352e-03f, 1.44661916e-02f, -1.34856135e-01f, -1.69692799e-01f,
  -8.64426270e-02f, -1.07608147e-01f, -1.80127516e-01f, 3.08237802e-02f, 2.29591019e-02f, 5.03684133e-02f, -6.46883026e-02f, 6.75619766e-02f, 3.91678587e-02f, 4.73828577e-02f,
  -4.73834500e-02f, 3.45875807e-02f, -2.26235501e-02f, 6.48438334e-02f, 2.85845231e-02f, -8.57245550e-02f, -6.24675937e-02f, 1.12240538e-01f, -1.56095341e-01f, 7.82065094e-02f,
  1.72003463e-01f, 1.79043084e-01f, -1.91732012e-02f, -7.78854191e-02f, -2.81943306e-02f, -5.11604548e-02f, 7.37714469e-02f, 3.11248321e-02f, -1.04533434e-02f, -9.71429646e-02f,
  -8.26103687e-02f, -1.04166798e-01f, -4.45687491e-03f, 2.92536709e-02f, 5.26430365e-03f, -2.49328241e-02f, -4.89091361e-03f, -1.16710946e-01f, -3.14681903e-02f, -7.07259625e-02f,
  6.77478760e-02f, -9.51058604e-03f, 2.63110753e-02f, -2.31699701e-02f, 1.33250102e-01f, -8.36593360e-02f, -5.54953748e-03f, 4.99505177e-02f, -4.01187092e-02f, -8.82098377e-02f,
  -4.01100256e-02f, -1.35438917e-02f, -5.37412986e-03f, 1.33539051e-01f, 9.27277356e-02f, -6.19418211e-02f, 1.13887958e-01f, -1.04179144e-01f, -3.29573303e-02f, 2.19875760e-02f,
  1.43724501e-01f, -2.48968899e-02f, -8.13315809e-02f, -7.94083998e-02f, -8.29537213e-03f, -8.84143636e-03f, -9.15214941e-02f, 9.13810283e-02f, 2.60090232e-02f, 1.84495933e-02f,
  -1.33606181e-01f, 1.03946686e-01f, -7.66535625e-02f, 6.51179031e-02f, -1.12620175e-01f, -4.61047143e-02f, 8.96179862e-03f, -6.43522218e-02f, 1.16858691e-01f, 4.66526970e-02f,
  3.73302363e-02f, 5.61381169e-02f, -1.46542406e-02f, -7.58756325e-02f, 3.86316776e-02f, -6.34685159e-02f, 1.12221912e-01f, -7.73132369e-02f, -8.06899145e-02f, 3.72838117e-02f,
  -5.17094024e-02f, -9.47124138e-02f, -9.03913304e-02f, 8.98021981e-02f, 2.17415337e-02f, 4.61863577e-02f, -1.03480935e-01f, 9.59883444e-03f, -1.89585499e-02f, -9.24842134e-02f,
  2.65401881e-02f, 4.56513092e-02f, -1.26419142e-01f, 1.88962430e-01f, 8.39521810e-02f, 1.29988194e-01f, 1.91995986e-02f, 7.90079534e-02f, -1.07724786e-01f, 7.25586712e-02f,
  4.16571721e-02f, 1.02821559e-01f, 5.15342206e-02f, -1.54638132e-02f, -2.51577459e-02f, 1.78020656e-01f, -6.26109019e-02f, 1.85580552e-01f, 1.36925772e-01f, 1.14288824e-02f,
  1.40896574e-01f, 3.03470418e-02f, 1.76737443e-01f, 7.97161832e-02f, 1.58458963e-01f, 7.28664398e-02f, -2.92016920e-02f, 1.02121003e-01f, 1.19542249e-01f, 1.15876861e-01f,
  -1.74489766e-01f, -7.06026480e-02f, 5.76881729e-02f, -2.15819716e-01f, 9.85153764e-02f, -1.45732507e-01f, 1.03717722e-01f, -2.10410029e-01f, 3.76534425e-02f, -8.46789628e-02f,
  -1.32689133e-01f, -4.26001251e-02f, 2.21639983e-02f, 2.32007876e-01f, -1.93493605e-01f, -1.73133135e-01f, 5.73585331e-02f, -4.43480536e-02f, 1.90742746e-01f, -4.00670357e-02f,
  -7.46218814e-03f, -6.85240552e-02f, -2.24794410e-02f, 5.17643802e-02f, -1.60198927e-01f, 1.17834918e-01f, 1.87892951e-02f, 3.99856605e-02f, -1.08602278e-01f, -7.57500008e-02f,
  -7.00845849e-03f, -7.82387853e-02f, 9.30738375e-02f, 1.16518751e-01f, 1.89363360e-01f, 1.39905117e-03f, 1.68822035e-02f, 1.28095686e-01f, -1.36287048e-01f, 2.03133166e-01f,
  -5.01449779e-02f, 3.52912396e-02f, -2.99888430e-03f, 1.83721945e-01f, -1.27365366e-01f, 5.05789854e-02f, 1.43759459e-01f, -1.45231280e-02f, 8.78549963e-02f, -1.48826599e-01f,
  4.86622490e-02f, 1.21896371e-01f, 1.12048909e-01f, 1.29979789e-01f, 1.14539392e-01f, 8.88176560e-02f, 1.79206893e-01f, -6.56464044e-03f, 2.00540274e-01f, 1.00347720e-01f,
  -1.67599529e-01f, -8.62166062e-02f, 1.21204099e-02f, -1.16320305e-01f, -2.09874943e-01f, -1.30803511e-01f, -1.27082273e-01f, 1.98209465e-01f, -1.27050906e-01f, 1.91989630e-01f,
  1.93713933e-01f, 8.57339799e-03f, -1.57821968e-01f, -1.18606135e-01f, 2.24884510e-01f, 2.52506882e-01f, 2.02603377e-02f, -2.30823278e-01f, -8.08243155e-02f, 7.67990872e-02f,
  2.10972764e-02f, -4.05379348e-02f, 2.36983329e-01f, 2.10987553e-01f, -4.75935265e-02f, -2.79945955e-02f, 1.96516719e-02f, 1.34653881e-01f, -3.69640961e-02f, -6.34152889e-02f,
  8.89579579e-02f, -1.10267140e-01f, 1.35455608e-01f, 6.00854121e-02f, 2.39885882e-01f, -5.36738001e-02f, 1.73883941e-02f, 5.90520650e-02f, -7.15822587e-03f, 7.31801689e-02f,
  -9.79394689e-02f, -9.01154801e-02f, -4.58203740e-02f, 5.30580580e-02f, -8.78514443e-03f, -9.21699703e-02f, -7.90423304e-02f, 4.98435088e-02f, 1.68887954e-02f, -3.64758410e-02f,
  8.48805606e-02f, -8.73526093e-03f, -1.34291628e-03f, -5.45480028e-02f, -6.99908584e-02f, 6.99602589e-02f, -8.60882476e-02f, 1.03125967e-01f, 3.14263329e-02f, 4.65252958e-02f,
  9.29758996e-02f, -6.26605600e-02f, 1.29129872e-01f, 1.43956035e-01f, 1.55555993e-01f, 2.75450796e-02f, -1.29564643e-01f, -1.27178496e-02f, -1.22676320e-01f, -5.43940552e-02f,
  1.68675095e-01f, 4.72269170e-02f, 1.50012625e-02f, 8.61963853e-02f, -5.55707775e-02f, -3.96847837e-02f, 2.36502904e-02f, -1.69587899e-02f, -7.61366040e-02f, 6.11145720e-02f,
  3.27261835e-02f, 1.91350617e-02f, 1.52301267e-01f, 9.53249633e-02f, -3.34736658e-03f, -4.52621318e-02f, -9.55862328e-02f, 4.17059883e-02f, 6.92777783e-02f, 9.41104442e-02f,
  -1.23006277e-01f, -2.31008623e-02f, -9.03455317e-02f, 9.81267765e-02f, 5.24877235e-02f, 8.93772840e-02f, 7.84328729e-02f, -2.47880183e-02f, 8.50885734e-02f, 1.29094064e-01f,
  4.25697602e-02f, 5.69638126e-02f, -1.10642537e-01f, -9.47178230e-02f, -3.71413119e-02f, -8.06281343e-02f, -7.75887594e-02f, 7.68165886e-02f, 8.06839094e-02f, 5.29870167e-02f,
  8.09651054e-03f, -8.56657475e-02f, -5.08530326e-02f, 1.16381824e-01f, 3.25124487e-02f, 2.49731932e-02f, -6.18722439e-02f, -5.00490656e-03f, -7.85430223e-02f, 7.95932785e-02f,
  7.20614418e-02f, 5.50733274e-03f, 9.80504528e-02f, -9.17623267e-02f, -1.22810364e-01f, 8.71594399e-02f, 1.11644298e-01f, 7.86233991e-02f, 5.53337252e-03f, 2.70810095e-03f,
  -2.89944783e-02f, 1.06957071e-01f, -8.87059607e-03f, 4.94346842e-02f, 3.47409770e-02f, 3.86031531e-02f, 8.59837681e-02f, -9.25272256e-02f, -4.52100411e-02f, -4.84402366e-02f,
  -2.77930293e-02f, 6.59245104e-02f, 4.47769463e-02f, -5.70389666e-02f, -1.04014175e-02f, -6.98488206e-02f, 1.03131786e-01f, 1.17918655e-01f, -1.47830117e-02f, -5.22319041e-02f,
  -1.00402899e-01f, 2.70937979e-02f, -6.55582473e-02f, 1.15726829e-01f, -6.53346777e-02f, 1.31621853e-01f, 8.23501348e-02f, 1.17577389e-01f, -1.03989623e-01f, -2.05833502e-02f,
  -8.54127556e-02f, -7.80805200e-02f, 3.86382118e-02f, 6.31954372e-02f, -4.79860194e-02f, -3.84359923e-03f, 2.74298731e-02f, 1.02345102e-01f, -1.19875759e-01f, -1.15696035e-01f,
  -2.68006455e-02f, 1.14150189e-01f, 1.34669974e-01f, -3.69245298e-02f, -5.00089824e-02f, -8.85727927e-02f, -2.78583094e-02f, -9.35290679e-02f, -6.16777241e-02f, -9.59919915e-02f,
  -7.36989677e-02f, -3.61248255e-02f, -1.06114857e-01f, 6.42587915e-02f, 2.75526978e-02f, -1.23211116e-01f, 9.18140933e-02f, -9.29868687e-03f, -5.25316559e-02f, -7.79287564e-03f,
  8.94131511e-02f, 1.21153899e-01f, -2.97188312e-02f, 7.77076110e-02f, 1.83802266e-02f, -1.11607155e-02f, -1.04724899e-01f, -9.13628638e-02f, -4.15911004e-02f, 5.27999848e-02f,
  3.71267535e-02f, -5.52147143e-02f, 7.04128519e-02f, -9.98162478e-02f, 8.51304680e-02f, 4.66832444e-02f, -1.26148388e-01f, -1.28539830e-01f, 8.81279185e-02f, 1.15558177e-01f,
  -1.05143480e-01f, 2.84032449e-02f, 4.49418798e-02f, 6.55301809e-02f, 7.27001578e-02f, -6.68796450e-02f, -3.31614874e-02f, 3.98330763e-02f, 1.08369425e-01f, -4.76967394e-02f,
  5.19876219e-02f, -4.50671017e-02f, -7.30195548e-03f, 5.43915965e-02f, -9.49155539e-02f, -1.04571201e-01f, 2.71907542e-02f, 8.81569386e-02f, -7.29353502e-02f, -6.84395730e-02f,
  9.45265591e-02f, 1.08569540e-01f, -3.33090052e-02f, -6.30315319e-02f, -9.32495818e-02f, -7.46665522e-02f, 7.03333989e-02f, -1.79511309e-02f, 1.46174282e-02f, 1.24196962e-01f,
  -5.69981821e-02f, -1.55269250e-01f, 7.33995885e-02f, -9.68992263e-02f, -9.65987593e-02f, 7.32233524e-02f, -3.28271464e-02f, -9.38565359e-02f, -1.39207095e-01f, -9.83809903e-02f,
  -4.21380028e-02f, 8.88476521e-02f, 1.31104425e-01f, 1.16559444e-02f, 7.81045780e-02f, 4.19717357e-02f, 1.08901709e-02f, -3.01842988e-02f, 6.91769691e-03f, -1.36385098e-01f,
  -7.83913136e-02f, -5.93964867e-02f, -3.17889713e-02f, -4.32195999e-02f, 3.70832644e-02f, -7.77842551e-02f, 4.78441082e-02f, -1.17364019e-01f, -1.27495691e-01f, 6.66327029e-02f,
  1.10269733e-01f, 2.94923615e-02f, 1.09087504e-01f, -6.91885352e-02f, -1.16302088e-01f, 9.23520401e-02f, -1.28960133e-01f, 3.45314457e-03f, -4.71566468e-02f, 1.60368636e-01f,
  8.13207775e-02f, -5.71543984e-02f, 8.14637914e-02f, -6.11571409e-02f, 7.22378045e-02f, -1.89218614e-02f, -5.87965287e-02f, -1.57556906e-02f, 3.60148959e-02f, 1.35191148e-02f,
  -3.42409760e-02f, -1.06963433e-01f, -1.05776846e-01f, 8.58607143e-02f, -3.09206313e-04f, 1.74822565e-02f, -1.37963220e-01f, -3.68586481e-02f, 1.84934825e-01f, -1.19759880e-01f,
  5.21352552e-02f, -5.88694997e-02f, 1.45412058e-01f, -8.53822380e-02f, 1.54848769e-01f, 2.86228415e-02f, 2.42791288e-02f, 1.45129368e-01f, 1.05745353e-01f, -7.00443015e-02f,
  -3.54586705e-03f, -8.92492011e-02f, 9.99829471e-02f, 1.33500889e-01f, -7.65260160e-02f, 4.49789502e-02f, -2.65955813e-02f, 1.41995385e-01f, 1.25540778e-01f, 1.15661711e-01f,
  5.15868962e-02f, 1.53637350e-01f, -1.14653312e-01f, 6.05975911e-02f, 1.35762602e-01f, -1.18297100e-01f, 1.28754750e-02f, 1.84511580e-02f, 1.11647293e-01f, -1.58120647e-01f,
  3.40751372e-02f, -3.21399495e-02f, -9.54548046e-02f, -3.36243436e-02f, -2.32382536e-01f, -1.02103740e-01f, 7.88242817e-02f, 1.79016441e-01f, -5.02006523e-02f, -1.85846791e-01f,
  -5.68298213e-02f, 9.02268291e-02f, 3.50736012e-03f, 4.87250276e-02f, -4.51839976e-02f, -3.36835496e-02f, 5.45400567e-02f, 5.18001523e-03f, 3.22836749e-02f, 1.02155872e-01f,
  1.72912136e-01f, 1.41271085e-01f, -9.58279967e-02f, 2.55112648e-01f, -1.45136118e-01f, 8.71876702e-02f, 3.60465758e-02f, 2.05130130e-01f, 8.99068639e-02f, -1.61974877e-01f,
  2.03061756e-02f, 4.88083176e-02f, -5.14116092e-03f, 5.03310636e-02f, 1.40173033e-01f, 1.05022959e-01f, 1.99730739e-01f, 1.64382368e-01f, 1.23758808e-01f, 2.90054101e-02f,
  1.43435165e-01f, 6.07665926e-02f, 1.83260858e-01f, 6.19948283e-02f, 1.44378632e-01f, 1.81463286e-01f, 2.05942631e-01f, 1.23193506e-02f, 1.27179980e-01f, 1.64925039e-01f,
  1.59710273e-01f, 1.35799885e-01f, 1.74809359e-02f, 1.88632414e-01f, -3.10821891e-01f, -2.38082960e-01f, 4.17651124e-02f, -9.64441001e-02f, 3.20180207e-02f, -9.38132033e-02f,
  3.80019248e-02f, 1.57149166e-01f, 1.34939119e-01f, 1.50034368e-01f, 2.85831779e-01f, -7.46541470e-02f, -2.37215385e-01f, -2.03836381e-01f, 4.11635563e-02f, -1.62926316e-01f,
  -2.27742139e-02f, 6.98405355e-02f, -2.98484772e-01f, 9.72303655e-03f, -2.26998717e-01f, -2.17714027e-01f, 2.41667911e-01f, -6.85802177e-02f, 1.35346189e-01f, 5.79361012e-03f,
  1.42342746e-01f, 5.71340062e-02f, 1.14105932e-01f, 2.32378319e-02f, -1.11446495e-03f, -5.60620353e-02f, -6.83514476e-02f, 1.47043057e-02f, 1.86584532e-01f, -1.70990720e-01f,
  -1.08580239e-01f, 1.19215846e-01f, -5.69246858e-02f, 9.79510993e-02f, -6.31851628e-02f, -2.06475612e-02f, 9.47025120e-02f, -3.58579122e-02f, 1.28744289e-01f, 1.69080392e-01f,
  -4.53585014e-02f, -3.62254344e-02f, 1.57582648e-02f, 1.71786368e-01f, -1.26130134e-01f, 6.38125613e-02f, -1.03928208e-01f, -2.52886210e-02f, 8.25223252e-02f, -2.38149818e-02f,
  -5.69347031e-02f, -9.54082236e-03f, 1.71046793e-01f, 1.82814613e-01f, -2.90694870e-02f, 5.87547012e-02f, 1.42057687e-01f, -6.49961904e-02f, 4.61862385e-02f, 1.57475304e-02f,
  3.98181491e-02f, 2.97471359e-02f, 1.37269497e-01f, -1.88540086e-01f, -1.08345538e-01f, 1.43110920e-02f, -2.93549635e-02f, -3.68575901e-02f, -5.19879684e-02f, 1.35674000e-01f,
  7.17753097e-02f, 1.99008718e-01f, 1.42366793e-02f, -7.42639005e-02f, -1.46167636e-01f, -9.11687836e-02f, 1.20506555e-01f, 9.61549673e-03f, 1.15619361e-01f, 1.75772920e-01f,
  -1.66332036e-01f, -1.83958128e-01f, 9.50363278e-02f, 5.32448590e-02f, -1.88147724e-02f, -5.50286584e-02f, 8.97392482e-02f, 2.23127138e-02f, -1.14183418e-01f, 3.13537242e-03f,
  -4.60316380e-03f, -2.02545468e-02f, -1.61159039e-02f, -9.06975418e-02f, 4.89022732e-02f, 1.56276643e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.59665626e-02f, 1.92013398e-01f, 3.83660160e-02f, -9.35949534e-02f, -9.92117599e-02f, 1.14801759e-02f, 4.97544445e-02f, -3.39230821e-02f, -1.29633710e-01f, 5.75348996e-02f,
  4.56053913e-02f, -1.85407326e-02f, 4.71348055e-02f, 1.83445841e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -1.39612436e-01f, -1.54740810e-01f, -3.40386212e-01f, 8.51768441e-03f, -3.87175202e-01f, -9.74705368e-02f, -1.56310901e-01f, -8.79479200e-02f, -2.46617151e-03f, -7.33455047e-02f,
  -4.20789599e-01f, -2.07236689e-02f, -2.77327150e-02f, -6.96046203e-02f, -5.28393462e-02f, -3.75847489e-01f, 6.02033548e-02f, -2.03589678e-01f, -1.92942932e-01f, -1.03840075e-01f,
  -2.84980267e-01f, -1.66584477e-01f, 8.15661177e-02f, 2.99988315e-02f, 1.21395022e-01f, -2.56886274e-01f, 8.05935487e-02f, 2.35101990e-02f, -2.23274231e-01f, 4.97772872e-01f,
  2.53557861e-01f, 2.86877990e-01f, 3.26534688e-01f, 1.26761824e-01f, -3.28003764e-01f, 1.00186989e-01f, 3.90446484e-02f, -3.07668615e-02f, -4.43227172e-01f, -3.40012401e-01f,
  -3.20675597e-02f, -2.57404000e-01f, -6.16420396e-02f, -2.71978229e-01f, -4.22720075e-01f, -2.20995679e-01f, -1.51892141e-01f, 7.64897987e-02f, -6.99678436e-02f, 1.23631433e-01f,
  3.48216556e-02f, 4.00021672e-03f, -2.07107738e-01f, 2.77228415e-01f, -7.77502954e-02f, -4.65267152e-02f, 3.87644261e-01f, 4.89633121e-02f, -2.26043798e-02f, 1.17446065e-01f,
  2.61496484e-01f, 3.67190503e-02f, 4.11526293e-01f, -2.31854260e-01f, 8.36699009e-02f, -5.47692627e-02f, 2.05418952e-02f, -7.66691417e-02f, -2.38362670e-01f, 2.03446932e-02f,
  -2.49765456e-01f, -1.11561000e-01f, 2.19184309e-01f, 1.50860352e-02f, 1.77017450e-01f, 1.65882647e-01f, 1.57517627e-01f, -1.19216733e-01f, 1.39358625e-01f, 1.67872056e-01f,
  -5.16504236e-02f, -4.87486161e-02f, 8.56182575e-02f, -3.14342976e-01f, 4.97769518e-03f, 3.55687916e-01f, 2.11569294e-01f, 1.97686642e-01f, 8.25296119e-02f, 4.11772549e-01f,
  8.33569542e-02f, -2.78578162e-01f, -6.08260095e-01f, 2.06038401e-01f, -2.96713918e-01f, 3.70726228e-01f, -1.73958763e-01f, 4.40359950e-01f, 4.65368003e-01f, 3.02330889e-02f,
  2.69755155e-01f, 3.58177602e-01f, -1.99296817e-01f, 5.29655993e-01f, 2.68081844e-01f, -4.21519354e-02f, 5.62210858e-01f, 3.32455009e-01f, 1.08708352e-01f, 1.92399025e-01f,
  1.63959160e-01f, -1.56368554e-01f, 1.16002053e-01f, 4.97881025e-01f, 3.54508273e-02f, 5.40319495e-02f, -3.69972557e-01f, 9.64202657e-02f, 1.41451180e-01f, 3.71471673e-01f,
  -1.08979102e-02f, 1.35113716e-01f, -4.16471995e-02f, 1.58164755e-01f, 1.00079346e-02f, 4.19097602e-01f, 2.87061602e-01f, -3.12355846e-01f, 1.02864496e-01f, -1.66476756e-01f,
  4.31980997e-01f, 2.00035036e-01f, 5.01941377e-03f, 2.02896848e-01f, 2.79575408e-01f, -2.73181975e-01f, 1.94145031e-02f, 3.32690328e-01f, 3.32859099e-01f, 7.66698495e-02f,
  -5.31635545e-02f, 1.97163820e-01f, 2.94001758e-01f, 5.96674323e-01f, -3.55937123e-01f, -9.02810469e-02f, 2.68088222e-01f, 3.81747559e-02f, 3.31186056e-01f, -3.15078765e-01f,
  -2.31132746e-01f, 3.71694155e-02f, 2.36443877e-01f, 1.35345191e-01f, 3.75632972e-01f, -3.99336480e-02f, 1.01362847e-01f, 1.22373417e-01f, -9.92343947e-02f, -1.17100157e-01f,
  -2.27560222e-01f, 5.67046739e-02f, 2.77875978e-02f, -1.79044664e-01f, -1.52529731e-01f, 5.79115331e-01f, -2.89251626e-01f, -3.58755380e-01f, -1.02877785e-02f, 3.02865118e-01f,
  5.10268867e-01f, 2.17969790e-01f, -2.93857932e-01f, 3.23400229e-01f, -4.75536436e-01f, 1.75136641e-01f, -2.13851586e-01f, -4.96243715e-01f, -4.89697754e-02f, 1.50098071e-01f,
  -2.01439276e-01f, -1.08106039e-01f, 1.46705462e-02f, 3.01788390e-01f, 2.81669665e-02f, -4.55248449e-03f, -5.27932458e-02f, 8.40971321e-02f, -4.44232598e-02f, -2.32458591e-01f,
  2.27646932e-01f, -1.78041264e-01f, 2.20936090e-01f, 4.32325788e-02f, 3.99942666e-01f, 1.39966413e-01f, -3.76247987e-02f, 7.15243667e-02f, 1.03130966e-01f, 1.27766386e-01f,
  2.02920645e-01f, -8.34105685e-02f, -2.04121396e-01f, -1.86728358e-01f, 1.06143281e-01f, -2.22406536e-01f, 3.24582517e-01f, 2.02368215e-01f, 1.82258204e-01f, 8.92965943e-02f,
  -2.02883571e-01f, 1.77904084e-01f, 2.36150816e-01f, 2.23530680e-01f, 1.57463923e-01f, -2.51127332e-02f, 9.65088829e-02f, -7.36473352e-02f, 4.98460889e-01f, -2.27356702e-01f,
  -2.78815106e-02f, -3.21464896e-01f, -3.40398997e-01f, -1.69804603e-01f, 4.27314520e-01f, -3.73845428e-01f, -2.91007996e-01f, 4.65479910e-01f, -1.78066641e-01f, -3.48374158e-01f,
  2.30417639e-01f, -3.62916142e-01f, 3.73758942e-01f, -2.57690251e-01f, -1.63564652e-01f, -5.41975677e-01f, 4.48233306e-01f, -1.81869283e-01f, -1.42325997e-01f, -6.51401207e-02f,
  9.87454951e-02f, -2.64911741e-01f, -2.20910713e-01f, -5.29146016e-01f, 8.44421908e-02f, -1.33128511e-02f, -6.65671974e-02f, -1.92665890e-01f, 8.91319215e-02f, 6.25229767e-03f,
  -1.39739672e-02f, -7.29941502e-02f, 8.08904022e-02f, -3.37783247e-02f, -2.92975754e-02f, 3.92182954e-02f, -3.85155737e-01f, -3.31710398e-01f, 1.71593875e-02f, -1.02086477e-01f,
  2.48395085e-01f, 1.20288685e-01f, 1.80610135e-01f, 9.45682675e-02f, -2.17769165e-02f, -4.07629937e-01f, -6.92019239e-02f, -7.10575059e-02f, 2.68954217e-01f, 1.09307088e-01f,
  -1.93663552e-01f, -3.79861295e-02f, -1.52951509e-01f, -1.64090693e-01f, 2.00873047e-01f, 2.27730677e-01f, 1.32831529e-01f, -3.70553225e-01f, -3.38301241e-01f, -5.12810647e-02f,
  -1.92739859e-01f, -2.28520826e-01f, -1.00518718e-01f, -5.66461980e-01f, 1.72908261e-01f, -1.80280432e-01f, 8.13253000e-02f, -1.83419704e-01f, 2.38363445e-01f, 1.06720276e-01f,
  -2.03239188e-01f, 3.17170829e-01f, -2.51496613e-01f, -1.20671362e-01f, 1.96122810e-01f, -2.37277225e-01f, 3.71333539e-01f, 2.83470839e-01f, -3.78758758e-01f, -3.67697358e-01f,
  -1.93055108e-01f, 9.67487507e-03f, -2.29815945e-01f, 1.42478645e-01f, 1.03116356e-01f, -3.60792667e-01f, -1.39419129e-02f, 3.33584309e-01f, -4.08155620e-02f, -8.33300874e-02f,
  2.29994766e-02f, -1.62343055e-01f, 3.59219909e-01f, 4.44500670e-02f, -5.58169819e-02f, 1.14173079e-02f, -1.50829464e-01f, -1.99905690e-02f, 4.20335913e-03f, 7.75192818e-03f,
  9.84247178e-02f, 1.20965682e-01f, 4.55017716e-01f, 4.34015661e-01f, 1.92454368e-01f, 2.70597800e-03f, 3.46166920e-03f, 1.58720464e-01f, 2.45937780e-01f, 4.10971642e-01f,
  1.71264097e-01f, 9.08979177e-02f, 3.01562905e-01f, 2.77158748e-02f, 1.71857849e-01f, 3.93365085e-01f, -1.84231430e-01f, 1.90543868e-02f, 3.57512712e-01f, -2.47343138e-01f,
  -4.88327853e-02f, 2.29009107e-01f, -1.28685921e-01f, -6.16236329e-02f, 5.63875027e-02f, -2.54770041e-01f, 2.42272779e-01f, 3.13662738e-01f, 2.79202312e-01f, 2.98629522e-01f,
  1.69519126e-01f, 4.73968297e-01f, -2.57415086e-01f, -6.31988868e-02f, -2.53811534e-02f, 4.52711135e-02f, 3.12433243e-01f, -3.47968668e-01f, 1.20016590e-01f, 2.74389207e-01f,
  6.68488890e-02f, 3.89857322e-01f, -3.72628182e-01f, -1.13596909e-01f, -5.13835132e-01f, -9.39870253e-02f, 1.03931904e-01f, 7.57645592e-02f, 3.33688885e-01f, 3.76405835e-01f,
  1.37539506e-01f, 1.55892121e-02f, -3.46115977e-02f, -1.70519412e-01f, 5.85388904e-03f, -1.59746051e-01f, 1.54765010e-01f, -1.80066884e-01f, 9.43831205e-02f, -2.10854840e-02f,
  -3.18618156e-02f, -1.31468147e-01f, 4.96929377e-01f, -2.52379430e-03f, 2.32322127e-01f, 4.22182530e-01f, -4.03661042e-01f, -3.18057746e-01f, 1.04970157e-01f, 1.48023382e-01f,
  -1.06221415e-01f, -2.37638384e-01f, -2.33221561e-01f, -2.05202013e-01f, -4.18145180e-01f, 3.71656679e-02f, -4.52428550e-01f, 3.24421935e-02f, 4.86468412e-02f, -4.08887267e-01f,
  -1.51558116e-01f, -2.73256570e-01f, -4.84022260e-01f, 4.39939275e-02f, -3.56776297e-01f, -7.09030032e-02f, 1.00769736e-01f, 8.42120051e-02f, -1.68851241e-01f, 8.43923446e-03f,
  1.16182841e-01f, 3.01553667e-01f, 7.60180727e-02f, -8.68226513e-02f, 2.15456724e-01f, -1.73595428e-01f, -1.98195621e-01f, 2.27792591e-01f, 4.25022811e-01f, -1.91326082e-01f,
  4.74067852e-02f, 1.90655798e-01f, 1.02796867e-01f, -3.69818687e-01f, -2.45958537e-01f, 2.30531767e-01f, 3.98527592e-01f, 6.64833337e-02f, -1.76412687e-01f, 2.33368352e-01f,
  -2.93376714e-01f, 1.43434525e-01f, 4.86509092e-02f, -2.89988250e-01f, -4.55740318e-02f, 1.19856387e-01f, 3.46910268e-01f, -1.58752240e-02f, -9.90696251e-02f, 1.20246068e-01f,
  -3.42260510e-01f, 3.04801445e-02f, 6.00744151e-02f, 2.64163390e-02f, -1.18960135e-01f, 1.74606115e-01f, 6.19456023e-02f, -3.06686573e-02f, -1.52356818e-01f, -9.90968272e-02f,
  -2.59498507e-01f, 6.19567633e-02f, -1.19201690e-01f, 2.75949109e-02f, -7.58403465e-02f, 1.02387525e-01f, -1.31758779e-01f, 6.94605261e-02f, 2.05365717e-01f, 4.46819887e-02f,
  -2.52080476e-03f, -2.44672105e-01f, 1.70691654e-01f, -2.68006951e-01f, 8.79189596e-02f, 1.57852024e-01f, 8.08831677e-03f, -5.06784260e-01f, -1.75988451e-01f, 1.55140743e-01f,
  1.81200117e-01f, -5.15531152e-02f, 2.37347841e-01f, -2.82852411e-01f, -4.87253845e-01f, 3.26934993e-01f, 2.77283907e-01f, -2.38420591e-01f, 2.45658368e-01f, -2.93592513e-01f,
  4.30195659e-01f, 2.84416974e-01f, 9.51294973e-02f, -2.17662647e-01f, -1.80445760e-01f, 3.20848286e-01f, 2.64284909e-01f, -1.26850799e-01f, -3.58720899e-01f, -4.82781649e-01f,
  -1.27865568e-01f, 2.85126686e-01f, 4.51025039e-01f, 2.73684233e-01f, 3.45671214e-02f, -3.78275037e-01f, -3.47973377e-01f, -1.12214200e-01f, 1.93551811e-03f, -1.45799860e-01f,
  -2.23241806e-01f, -1.71106249e-01f, -1.47071019e-01f, 3.83833759e-02f, -2.28072837e-01f, 1.19807780e-01f, -5.87467365e-02f, 1.30367512e-02f, -1.37897417e-01f, 3.23819339e-01f,
  -4.43723589e-01f, 1.99598536e-01f, 1.09246768e-01f, -1.87840611e-01f, -4.10290658e-01f, -1.45076830e-02f, 6.39567897e-02f, -1.46697499e-02f, -1.04976363e-01f, -8.61155614e-02f,
  1.87727902e-02f, -3.62316251e-01f, 1.46376714e-01f, -9.29151177e-02f, 6.56525791e-02f, 1.05984159e-01f, -3.36781442e-01f, 1.23975299e-01f, 1.35487020e-01f, 1.90173134e-01f,
  1.20357402e-01f, 1.44675359e-01f, -2.04684818e-03f, -2.49862634e-02f, 4.71498966e-02f, -1.94595218e-01f, -3.80372971e-01f, 2.80786186e-01f, -6.30914748e-01f, 4.48575526e-01f,
  -2.46696681e-01f, 1.05431071e-02f, -8.30308273e-02f, 2.59711206e-01f, -2.85740376e-01f, -2.95692503e-01f, 2.94690043e-01f, -3.78183156e-01f, 4.29998845e-01f, -4.05795753e-01f,
  1.47377521e-01f, -2.55915970e-02f, -4.65817362e-01f, -1.95165843e-01f, -4.47036587e-02f, -1.30591854e-01f, -4.72454652e-02f, -3.12962174e-01f, 6.05092764e-01f, 3.80500196e-03f,
  3.44200283e-01f, 3.59109491e-01f, -4.61898632e-02f, -2.36870483e-01f, -8.27835649e-02f, -3.17334644e-02f, -3.88712250e-02f, 1.34241700e-01f, -3.00223500e-01f, 6.75732419e-02f,
  9.22946557e-02f, 2.66571380e-02f, -3.33981104e-02f, -2.89528128e-02f, -1.04507603e-01f, 1.26079038e-01f, -2.41916075e-01f, -1.11952282e-01f, 3.44628155e-01f, -3.76857966e-01f,
  -1.24155790e-01f, -1.75271213e-01f, -2.74135709e-01f, 3.14281732e-01f, -3.57048780e-01f, 3.36786687e-01f, 2.85765797e-01f, -1.28724962e-01f, -3.17442983e-01f, -4.88083996e-02f,
  -4.29197907e-01f, 3.51500690e-01f, 1.66107759e-01f, 1.44970790e-01f, -2.33123541e-01f, 7.95807689e-02f, -2.52564043e-01f, -2.53437221e-01f, -5.45676537e-02f, -2.19900161e-02f,
  -3.16585600e-01f, -1.10647745e-01f, 3.72275054e-01f, 1.84851572e-01f, 1.64198443e-01f, -1.12378402e-02f, 4.87817764e-01f, -1.81614876e-01f, 2.48559862e-01f, 2.89624423e-01f,
  -2.68733174e-01f, -3.12227309e-01f, -1.75252616e-01f, 1.60081998e-01f, -1.88155174e-02f, -1.53382674e-01f, -1.68179736e-01f, 2.88243350e-02f, -1.73626170e-02f, 5.08254349e-01f,
  1.42014533e-01f, 2.42798597e-01f, 9.25559085e-03f, 4.76116091e-02f, -3.25492084e-01f, -2.06151605e-01f, 1.22670390e-01f, 5.74129343e-01f, -5.76537251e-02f, -1.25566065e-01f,
  1.52762011e-01f, -1.49835899e-01f, -1.35349020e-01f, -5.60714223e-04f, -1.08331457e-01f, -5.85431047e-02f, 3.05240117e-02f, -1.22804314e-01f, 1.47657946e-01f, -1.33231893e-01f,
  1.58343926e-01f, 3.75203520e-01f, 1.57025665e-01f, -1.36813521e-01f, 4.78351153e-02f, 8.22554380e-02f, -2.54554838e-01f, 3.11009169e-01f, -1.67854071e-01f, 3.23976994e-01f,
  -1.22849479e-01f, 2.15471849e-01f, -2.98029602e-01f, 2.43667275e-01f, -7.46920779e-02f, -7.65443221e-02f, 1.12899385e-01f, -2.81450385e-03f, -3.84498596e-01f, 8.47770795e-02f,
  6.12419425e-03f, -3.74026038e-02f, -7.44032813e-03f, -1.08078577e-01f, -1.98162049e-01f, 2.90081292e-01f, -4.23456691e-02f, -4.89688247e-01f, -3.53267998e-01f, 3.63188267e-01f,
  -1.12653658e-01f, 2.72891194e-01f, -1.06450886e-01f, -5.03629804e-01f, -4.12376106e-01f, 3.44208211e-01f, 1.72926206e-02f, -3.17794144e-01f, -3.22121173e-01f, 4.28991139e-01f,
  4.65055853e-01f, 3.78175974e-02f, -5.58294579e-02f, -4.22112077e-01f, 1.90041736e-01f, -2.57580578e-01f, 6.07978880e-01f, -3.39291036e-01f, 1.43563434e-01f, 2.50946641e-01f,
  1.55158475e-01f, -2.83165514e-01f, -2.12105125e-01f, 1.71394423e-02f, 6.74873516e-02f, -1.62836105e-01f, 1.40350148e-01f, 2.07707018e-01f, -3.38114426e-02f, -8.64203274e-02f,
  2.02408507e-02f, -1.09466255e-01f, -2.73085505e-01f, -8.61829743e-02f, 1.45062223e-01f, 4.86611724e-02f, -4.86764252e-01f, 1.42155722e-01f, -2.66584188e-01f, -1.85438558e-01f,
  2.58758694e-01f, -1.63307816e-01f, 2.12684035e-01f, -2.56641924e-01f, -2.92385519e-01f, 1.99641481e-01f, 3.00458878e-01f, -1.27821282e-01f, 2.01639205e-01f, -3.50491345e-01f,
  -8.19631517e-02f, -4.84619662e-03f, 1.19618505e-01f, 1.37754291e-01f, 3.41353774e-01f, 2.97090024e-01f, -6.03813194e-02f, -2.29670238e-02f, 3.79758567e-01f, 1.21779032e-01f,
  -2.66819060e-01f, 9.70096812e-02f, 3.42301339e-01f, -2.22027317e-01f, -2.86159456e-01f, -2.47182950e-01f, -2.62860805e-01f, 1.04225995e-02f, 3.34701210e-01f, -4.06061411e-01f,
  2.54778832e-01f, 8.35335553e-02f, -2.57529728e-02f, 3.38281989e-01f, -1.83879957e-01f, 2.31250420e-01f, -4.82286736e-02f, 3.82124752e-01f, 5.76942302e-02f, -1.60620525e-01f,
  -6.41670749e-02f, 1.21609040e-01f, 2.07881570e-01f, 8.47932622e-02f, 1.15144417e-01f, -2.96229459e-02f, 4.79528278e-01f, -2.93560885e-02f, 1.07892919e-02f, 7.54317194e-02f,
  -2.46664315e-01f, -1.12939589e-01f, 8.44067112e-02f, 4.43706550e-02f, 6.98070750e-02f, -5.08589335e-02f, -3.30392420e-01f, 1.85509205e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  5.46219982e-02f, -4.51904833e-02f, -1.53416470e-01f, 1.08332634e-01f, -1.23491138e-01f, -9.55386534e-02f, -1.03251517e-01f, 1.51319191e-01f, 4.67241816e-02f, -4.29238006e-02f,
  1.64596532e-02f, 7.98511878e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    