/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.66253513e-02f, -1.17927585e-02f, -3.02149773e-01f, 6.78119808e-02f, -1.81360003e-02f, 3.70880738e-02f, 6.56129271e-02f, 2.26184577e-01f, 2.22093150e-01f, 1.63669929e-01f,
  2.26698339e-01f, 4.17545140e-01f, 2.63619781e-01f, 1.45771787e-01f, 6.87084720e-02f, 8.74971226e-02f, -2.15286657e-01f, -2.59901024e-03f, 2.00501904e-01f, 3.61680865e-01f,
  4.44447488e-01f, 2.73855180e-01f, 2.26876944e-01f, 1.06018409e-01f, 1.66722000e-01f, 3.08424890e-01f, -3.27057838e-02f, 4.54036593e-02f, 2.06998035e-01f, -1.35350898e-01f,
  1.38375480e-02f, -1.19219035e-01f, 2.61505514e-01f, 2.04920933e-01f, 5.82986809e-02f, 2.38574952e-01f, 1.32768452e-01f, 4.02399376e-02f, 1.64737388e-01f, 1.94395527e-01f,
  1.14704870e-01f, 6.02392703e-02f, -8.68920423e-03f, 1.27555430e-01f, 6.95903525e-02f, 1.87851667e-01f, 9.65698287e-02f, 1.51333973e-01f, 8.52414593e-02f, 2.07224771e-01f,
  2.59871840e-01f, 7.34025165e-02f, 9.33370441e-02f, 1.96244642e-01f, 1.55461743e-01f, 7.83210471e-02f, 2.54170056e-02f, 1.02819525e-01f, -1.10421358e-02f, 1.66032687e-01f,
  -4.71493676e-02f, -6.62255436e-02f, -9.02311504e-02f, -1.42943233e-01f, -1.86912213e-02f, -2.12692656e-02f, -1.02897048e-01f, -1.41284885e-02f, -2.21811514e-02f, -1.29894018e-01f,
  -4.92009893e-02f, 1.14855897e-02f, -3.93730178e-02f, -3.71501632e-02f, 5.30233718e-02f, -1.28027439e-01f, -1.10635214e-01f, -1.16968472e-02f, -2.38520112e-02f, -1.62480667e-01f,
  -5.21484949e-02f, -1.43431917e-01f, -1.52174562e-01f, -1.02002062e-01f, -5.79473116e-02f, -1.58350542e-01f, -1.10561766e-01f, -8.30551071e-05f, -4.98345047e-02f, -7.12062791e-02f,
  2.19988734e-01f, 3.81416231e-02f, 1.94243878e-01f, 1.62996396e-01f, 1.17267564e-01f, 2.14563355e-01f, 1.81462020e-01f, 1.82870656e-01f, 9.49808434e-02f, 1.80593163e-01f,
  1.66098341e-01f, 1.91121101e-01f, 1.75582781e-01f, 1.45055816e-01f, 2.03088075e-01f, 1.85400635e-01f, 1.98998064e-01f, 1.40972525e-01f, 1.89772367e-01f, 2.11813763e-01f,
  2.80957609e-01f, 2.08071962e-01f, 2.88662821e-01f, 1.69558525e-01f, 2.04772413e-01f, 2.65479118e-01f, 2.48370156e-01f, 3.21662247e-01f, 1.88552320e-01f, 4.41220671e-01f,
  5.54801822e-01f, -3.75991613e-01f, 9.59170330e-03f, 2.70956069e-01f, -1.49076626e-01f, -2.13634431e-01f, -3.04590970e-01f, -1.04518667e-01f, 1.36491641e-01f, -2.52211541e-01f,
  -4.39760119e-01f, -2.42420435e-01f, -7.72462711e-02f, -1.20941982e-01f, -1.89368092e-02f, 5.14670238e-02f, 3.87539953e-01f, 4.28717703e-01f, 1.20952055e-01f, -3.04108411e-01f,
  -1.42701626e-01f, 1.84275508e-01f, 2.30136633e-01f, 1.46170974e-01f, -6.48350343e-02f, -8.07240009e-02f, 4.84342538e-02f, -5.74842319e-02f, -2.00785697e-01f, 1.92017838e-01f,
  -1.87560126e-01f, -2.10014477e-01f, 4.62548584e-02f, 1.47889912e-01f, -3.43397893e-02f, 1.25945628e-01f, -4.30637822e-02f, 7.71896308e-03f, 6.54776907e-03f, -6.15477674e-02f,
  -4.91140932e-02f, -1.01708479e-01f, 5.53140603e-02f, -6.85300007e-02f, -7.05442159e-03f, -4.58600558e-02f, 2.88043148e-03f, 5.29713407e-02f, -4.92703877e-02f, -6.22885115e-02f,
  -1.74787551e-01f, -1.58739224e-01f, -3.13581079e-02f, -1.41855657e-01f, -7.97734335e-02f, 9.37889740e-02f, -2.13346645e-01f, -1.59072906e-01f, -1.04762323e-01f, 3.61934192e-02f,
  1.42708272e-01f, 1.37767829e-02f, -4.08869274e-02f, 7.24171996e-02f, -8.20107671e-05f, -7.80225098e-02f, 9.72727686e-02f, 2.41169222e-02f, 3.70056443e-02f, -6.01645038e-02f,
  -2.70372126e-02f, 7.42766783e-02f, -4.42121476e-02f, 2.44338382e-02f, -1.85347663e-03f, 2.24445239e-02f, -4.93945414e-03f, -1.99939460e-02f, 3.99124362e-02f, 2.04476304e-02f,
  2.98088528e-02f, 7.11600706e-02f, 1.35319130e-02f, -4.43730503e-02f, -1.76988151e-02f, 1.12928435e-01f, 3.34750232e-03f, -8.37763678e-03f, -1.60364304e-02f, -5.56845637e-03f,
  -5.03365360e-02f, -5.37516102e-02f, 2.81153643e-03f, -1.43531607e-02f, -2.30723806e-02f, -4.65649962e-02f, -5.14483154e-02f, -1.06742822e-01f, -5.68739399e-02f, -4.35730554e-02f,
  -1.26594216e-01f, -4.10447046e-02f, -7.58897290e-02f, -4.50324751e-02f, -3.29757743e-02f, -8.20438564e-02f, -3.49412225e-02f, 5.00359870e-02f, -2.79728044e-02f, -1.29135147e-01f,
  1.81810965e-03f, 1.12906145e-02f, -2.49533299e-02f, -1.02390185e-01f, -6.48851693e-02f, 8.95361528e-02f, -6.18051253e-02f, -9.04171914e-03f, 4.68096435e-02f, 3.11217252e-02f,
  4.48238105e-01f, -3.03566486e-01f, 4.41808626e-02f, 2.72643089e-01f, -1.18242592e-01f, 8.85825679e-02f, -3.04584235e-01f, 1.62439272e-02f, 1.42893195e-01f, -1.07374988e-01f,
  9.13750529e-02f, 4.21460003e-01f, 2.30573565e-01f, 2.78427035e-01f, 2.35010132e-01f, -2.23775744e-01f, -3.00905854e-01f, 2.54548490e-01f, 4.87946689e-01f, 2.78948337e-01f,
  -1.01845652e-01f, -1.27833234e-02f, 2.98085988e-01f, 1.92891806e-01f, -1.14686728e-01f, 1.16849914e-01f, -9.09866691e-02f, -1.23603493e-01f, 4.34687622e-02f, -1.76598728e-01f,
  2.26116464e-01f, 1.14497185e-01f, 3.11022371e-01f, 1.81859419e-01f, 2.25615725e-01f, 2.48583496e-01f, 2.04160064e-01f, 2.27680951e-01f, 2.35926554e-01f, 1.77994430e-01f,
  1.67543009e-01f, 2.07626015e-01f, 2.33060315e-01f, 2.44441107e-01f, 2.35531136e-01f, 2.52140969e-01f, 9.03401971e-02f, 1.69734284e-01f, 2.32501835e-01f, 1.89723611e-01f,
  -3.48363854e-02f, 1.28628716e-01f, 1.69382080e-01f, 7.84709156e-02f, 1.87798232e-01f, 2.44643554e-01f, 2.17303544e-01f, 2.01675221e-01f, 2.91427493e-01f, 2.55272597e-01f,
  -6.56007007e-02f, -1.13443751e-02f, -7.07501397e-02f, -6.77939504e-02f, -3.54741067e-02f, 3.11596710e-02f, -4.51737121e-02f, -8.72904137e-02f, -3.40890810e-02f, -8.52364954e-03f,
  1.54354738e-03f, 4.44775596e-02f, 4.90741320e-02f, 2.79410630e-02f, 3.66718657e-02f, -2.25237682e-02f, 2.42943726e-02f, -9.74802375e-02f, -4.31388356e-02f, 2.71396860e-02f,
  6.81888536e-02f, -3.97271775e-02f, -4.42388095e-02f, -2.01860648e-02f, -7.33721554e-02f, -2.12109904e-03f, 2.26234067e-02f, -1.50907300e-02f, -1.27536403e-02f, 7.95775279e-02f,
  2.07160965e-01f, 3.08911353e-01f, 1.71706736e-01f, 2.17959046e-01f, 7.26461411e-02f, 1.99713141e-01f, 1.26082689e-01f, 1.69829682e-01f, 1.53962091e-01f, 1.04934603e-01f,
  1.81108847e-01f, 2.62419581e-01f, 1.54121578e-01f, 1.38408795e-01f, 1.11166619e-01f, 1.48920983e-01f, 5.72920926e-02f, 9.39002484e-02f, 1.65476680e-01f, 1.09817706e-01f,
  3.85691002e-02f, 1.32835835e-01f, 2.83893168e-01f, 1.50041133e-01f, 1.89866155e-01f, 2.99808383e-01f, 2.05690309e-01f, 2.87044317e-01f, 1.60883248e-01f, 1.21195003e-01f,
  -1.92699119e-01f, 4.64392304e-01f, -1.44183055e-01f, -1.05865508e-01f, 1.13872647e-01f, -2.59580351e-02f, 9.48510170e-02f, -9.09326226e-02f, -1.34751812e-01f, 1.59954354e-01f,
  4.34330970e-01f, 6.18340597e-02f, 8.43097568e-02f, -1.03191748e-01f, -2.08834827e-01f, -1.27353966e-01f, -2.26559356e-01f, -3.72033268e-01f, -4.28245276e-01f, -5.54642677e-02f,
  8.09754580e-02f, -8.66128728e-02f, -1.41269743e-01f, -5.31329475e-02f, 8.29364285e-02f, -7.17971623e-02f, 3.60085419e-03f, 1.45937651e-01f, 1.97516382e-01f, 1.04124747e-01f,
  1.29232362e-01f, 3.41822237e-01f, -1.11239746e-01f, 5.05387783e-02f, 1.99285045e-01f, 4.72326837e-02f, 9.03798547e-03f, 1.34408325e-01f, 9.15106013e-02f, 2.79706903e-02f,
  1.64932057e-01f, 5.57485595e-02f, 1.01912640e-01f, 8.36326927e-02f, 3.00276037e-02f, 1.04679111e-02f, 6.88004792e-02f, -3.47399674e-02f, 4.17499281e-02f, 1.44590780e-01f,
  7.70364553e-02f, 2.50038952e-01f, 1.75843224e-01f, -5.05038677e-03f, 2.04130728e-02f, -4.92360294e-02f, 1.29793450e-01f, 4.38780673e-02f, 1.37478739e-01f, 1.31395329e-02f,
  3.69456830e-04f, 7.11491182e-02f, 3.46822776e-02f, -1.44721353e-02f, 1.62089989e-02f, -2.45430358e-02f, -2.37018149e-02f, -2.21476704e-02f, -5.25258891e-02f, -4.44416404e-02f,
  -3.42394635e-02f, -3.45023051e-02f, -1.11277804e-01f, -1.00087300e-01f, -1.84340198e-02f, -2.25476082e-02f, -4.44770046e-02f, -8.20832327e-03f, -3.07216495e-02f, -1.20339571e-02f,
  -4.22863057e-03f, -6.91250563e-02f, -1.31750582e-02f, -9.86576900e-02f, 2.18723901e-02f, -2.13482883e-02f, -3.25359069e-02f, 2.77623907e-02f, 4.85069118e-02f, 2.25132126e-02f,
  4.47711721e-02f, -2.08981764e-02f, -4.31301706e-02f, 2.06501689e-02f, -2.23699715e-02f, -2.50219628e-02f, -1.08712828e-02f, -3.38130966e-02f, 1.49679020e-01f, 7.03482479e-02f,
  9.09172744e-02f, -7.08857104e-02f, 6.27806112e-02f, -7.22832903e-02f, -3.71848382e-02f, 5.18066026e-02f, -1.34859355e-02f, -2.77760550e-02f, 5.87567650e-02f, 1.06157191e-01f,
  -1.52106229e-02f, -7.80012235e-02f, -7.31720328e-02f, -1.04349345e-01f, -5.80875762e-02f, -6.25674352e-02f, -6.42936304e-03f, -6.75214827e-02f, -1.33699447e-01f, -8.65170881e-02f,
  2.46840924e-01f, 4.52148646e-01f, 3.17782611e-02f, -7.31446669e-02f, -7.17550591e-02f, 1.59103230e-01f, 4.64613289e-01f, 3.01533431e-01f, 4.68962230e-02f, 2.20933259e-01f,
  3.62282768e-02f, -8.20310414e-02f, 5.62910065e-02f, 7.92732537e-02f, 2.32086450e-01f, 3.15199256e-01f, 2.07632482e-01f, 1.93534009e-02f, -4.58655171e-02f, 2.70262100e-02f,
  -2.86746137e-02f, 2.26595253e-03f, 9.06163156e-02f, 1.35256723e-02f, 5.35662100e-02f, -1.10127784e-01f, 8.05096626e-02f, -2.31846310e-02f, -1.10751353e-01f, -2.16590837e-01f,
  -8.35862234e-02f, 2.43170291e-01f, -8.27044100e-02f, 7.88772404e-02f, 6.34233356e-02f, 6.84390813e-02f, -1.59343630e-02f, -2.29619630e-03f, -1.51492758e-02f, 1.41574860e-01f,
  5.63934222e-02f, 7.24286884e-02f, 7.32782111e-02f, -1.66927632e-02f, 3.29825208e-02f, 1.28731921e-01f, 1.03969358e-01f, 1.25933200e-01f, 1.12803243e-01f, 1.58823073e-01f,
  1.83056705e-02f, 7.90163279e-02f, 2.44389325e-01f, 1.88545853e-01f, 2.17061549e-01f, 1.45375878e-02f, 1.07302837e-01f, 1.28333524e-01f, 6.83432668e-02f, 2.38885507e-01f,
  2.93238350e-04f, 1.95420366e-02f, -4.16195504e-02f, -9.69624845e-04f, -9.89244692e-03f, -1.51421025e-01f, -9.97325256e-02f, -6.15614504e-02f, -3.78767475e-02f, -3.91108370e-05f,
  -1.14542827e-01f, -7.58547261e-02f, -1.48750797e-01f, -3.76145132e-02f, -8.83084983e-02f, -4.69066761e-02f, 8.98398645e-03f, 3.16324644e-02f, -1.01756109e-02f, -9.63583887e-02f,
  -2.38488857e-02f, -1.38508722e-01f, -1.34931535e-01f, -6.87040091e-02f, 4.09999676e-03f, -4.40907739e-02f, -4.15007770e-02f, 3.79253663e-02f, -8.13258812e-04f, -2.27906425e-02f,
  1.95723549e-01f, -1.33149087e-01f, 5.27907722e-02f, 1.22175209e-01f, -4.52959351e-02f, 3.57425734e-02f, -6.10105395e-02f, 3.00234277e-02f, -5.67952581e-02f, 1.11093700e-01f,
  5.54180108e-02f, 1.80613399e-02f, 7.57685974e-02f, 3.79571877e-03f, 8.07986781e-02f, 8.00353214e-02f, 2.05305323e-01f, 7.52123222e-02f, 6.88441470e-02f, 9.41627249e-02f,
  1.48224562e-01f, 1.24805607e-01f, 2.31800184e-01f, 2.24315092e-01f, 1.48136005e-01f, 1.02070712e-01f, 1.73985064e-01f, 1.72636241e-01f, 1.65818855e-01f, 2.53525347e-01f,
  -1.61887139e-01f, -6.33395836e-02f, -9.36703756e-03f, -2.59831607e-01f, 1.69287110e-03f, 1.78832844e-01f, 2.03125685e-01f, -1.27845839e-01f, -3.14901114e-01f, 1.27295241e-01f,
  -1.36565134e-01f, -2.23698884e-01f, -1.66226670e-01f, -9.62537378e-02f, -4.14118394e-02f, 1.99962258e-01f, 6.31787106e-02f, -3.94580811e-02f, -2.81759147e-02f, -7.03635141e-02f,
  -1.20100565e-01f, -2.10916921e-02f, -5.44523746e-02f, -1.37632817e-01f, 1.49439454e-01f, -2.18254998e-02f, 1.33156449e-01f, 2.43175998e-01f, 1.47088602e-01f, 2.47478068e-01f,
  5.78090735e-02f, -1.46197483e-01f, -1.47005290e-01f, -1.74148306e-02f, -1.07836043e-02f, -9.34940204e-02f, -1.53258935e-01f, -1.77135140e-01f, -1.75117388e-01f, -4.26751748e-02f,
  -1.36461288e-01f, -1.89505011e-01f, -1.48885220e-01f, -1.10094033e-01f, -1.15893848e-01f, -1.29926369e-01f, -7.65879527e-02f, -1.28214598e-01f, -5.88902794e-02f, -3.06925084e-02f,
  -5.98312430e-02f, -1.57622509e-02f, 8.07583779e-02f, -9.74626690e-02f, -1.23206511e-01f, -2.59299219e-01f, 1.04199005e-02f, 6.78059366e-03f, -3.87050658e-02f, 5.19650616e-02f,
  -5.81428222e-02f, -7.95206651e-02f, -3.85379978e-02f, 9.83950794e-02f, 5.37409782e-02f, 1.99020281e-02f, -8.43988582e-02f, 1.32209938e-02f, -3.42801549e-02f, 2.32468434e-02f,
  -1.16532192e-01f, 1.19569607e-01f, -1.04556698e-02f, 7.79162794e-02f, 7.26564303e-02f, -4.62470278e-02f, 3.23210955e-02f, -2.17750343e-03f, 2.34624790e-03f, 6.01623952e-02f,
  4.05708440e-02f, -2.65685022e-02f, 7.78197199e-02f, 1.35955393e-01f, -4.95049246e-02f, 9.86820459e-03f, -5.49072884e-02f, -5.34201786e-02f, 2.95257792e-02f, -1.45641476e-01f,
  3.54716219e-02f, -1.03121847e-01f, 5.49289398e-02f, 6.88532274e-03f, -3.04076895e-02f, -6.89312536e-03f, 7.66810821e-03f, 7.78477965e-03f, -6.44413829e-02f, -3.61783691e-02f,
  -1.42771350e-02f, -2.03766171e-02f, -3.86554040e-02f, 2.69702598e-02f, 1.09866019e-02f, 3.29312459e-02f, 6.96886554e-02f, 3.50929121e-03f, -3.48801054e-02f, -2.26150360e-02f,
  -3.40323485e-02f, -1.14849759e-02f, -3.51913385e-02f, 4.13191430e-02f, -4.12023067e-02f, 4.87060584e-02f, 3.53230163e-02f, 1.78422965e-02f, 1.21026285e-01f, 2.11517900e-01f,
  -9.37198624e-02f, 7.26693496e-02f, 5.32925010e-01f, -2.43752152e-02f, 1.25114858e-01f, 2.25391448e-01f, 3.38490665e-01f, 6.31816313e-02f, -3.46597806e-02f, 4.48113754e-02f,
  4.15441431e-02f, -1.98037922e-01f, -3.15857469e-03f, 9.58208442e-02f, 1.58965439e-01f, 3.25119793e-01f, 4.00546879e-01f, 2.64140278e-01f, 3.19355726e-01f, 1.75755575e-01f,
  -7.99738895e-03f, 9.52373594e-02f, 1.20053284e-01f, 1.36762276e-01f, 1.24301247e-01f, -3.46265808e-02f, 6.83139265e-02f, 1.11633755e-01f, 1.69990405e-01f, 1.91442043e-01f,
  4.08873498e-01f, 2.17759207e-01f, 1.24327928e-01f, 8.25787559e-02f, 1.26870051e-01f, 1.53128967e-01f, 1.40558198e-01f, 1.86253771e-01f, 1.52567700e-01f, 2.15343133e-01f,
  9.29747522e-02f, 1.95608705e-01f, 2.61191100e-01f, 1.37853950e-01f, 1.14505135e-01f, 1.57901049e-01f, 1.59257397e-01f, 2.51954436e-01f, 1.79363608e-01f, 2.59734154e-01f,
  1.04104973e-01f, 2.42556497e-01f, 3.63594651e-01f, 1.52810022e-01f, 2.60082126e-01f, 2.03624919e-01f, 1.27115220e-01f, 1.61422566e-01f, 1.97214603e-01f, 5.18562235e-02f,
  -1.52327418e-01f, -9.77437347e-02f, 1.41492551e-02f, 4.28743213e-02f, 1.86689794e-02f, 2.93988059e-03f, 4.71069068e-02f, 5.24183884e-02f, -7.13369995e-03f, 9.24085155e-02f,
  3.87647711e-02f, 2.12804805e-02f, 6.91687763e-02f, 2.64803208e-02f, 2.82253195e-02f, 1.64091960e-01f, 1.05715901e-01f, 1.16129376e-01f, 9.08852816e-02f, 5.94596677e-02f,
  7.57089108e-02f, 1.12057902e-01f, 3.37269753e-02f, 4.39414643e-02f, 2.64004841e-02f, 9.36717913e-02f, -3.31875810e-04f, 8.56201276e-02f, 1.57693494e-02f, 3.40282954e-02f,
  -2.32424095e-01f, 9.18466821e-02f, 9.73487720e-02f, 5.42209260e-02f, 1.51488066e-01f, 3.83397788e-02f, 4.70329560e-02f, 1.16751127e-01f, 1.26851544e-01f, 8.09390843e-02f,
  1.95585459e-01f, 1.65210783e-01f, 9.40974727e-02f, 6.88613057e-02f, 7.51301199e-02f, 1.55893341e-01f, 1.01882108e-01f, 8.06960166e-02f, 8.37522298e-02f, 1.50929153e-01f,
  5.14355488e-02f, 1.30712226e-01f, 7.82949477e-02f, 6.34030402e-02f, 1.01949386e-01f, 6.93434104e-02f, 1.28464609e-01f, 6.60744607e-02f, 7.11939260e-02f, 5.68120927e-03f,
  -1.63121790e-01f, 3.46782029e-01f, 8.03526565e-02f, -1.29879698e-01f, 2.92730242e-01f, 3.46400648e-01f, 6.87698960e-01f, 2.42226794e-01f, -1.32810483e-02f, 2.23310411e-01f,
  5.82908727e-02f, -4.45489168e-01f, -2.31433690e-01f, -2.69653231e-01f, -6.86644763e-02f, 3.34837765e-01f, 5.03643304e-02f, -2.32097298e-01f, -1.03318900e-01f, 4.75590117e-02f,
  -1.79194901e-02f, 3.15093584e-02f, -2.38204926e-01f, -9.38703567e-02f, 2.04088390e-02f, -2.22932041e-01f, 8.78855735e-02f, -7.80332163e-02f, -6.46530315e-02f, -1.83521852e-01f,
  -4.38730679e-02f, -1.50556220e-02f, -1.06871299e-01f, -1.16269290e-01f, -4.99823363e-03f, 1.05947303e-02f, -3.99884656e-02f, 2.92250942e-02f, 2.92447843e-02f, 8.30700714e-03f,
  -9.18895155e-02f, 1.87352225e-02f, -7.38327429e-02f, 5.29661728e-03f, 6.52081668e-02f, -1.34931458e-02f, -4.31047678e-02f, -6.29249215e-02f, -3.46955247e-02f, 1.21099032e-01f,
  -7.74510801e-02f, 4.24271412e-02f, 4.75847423e-02f, 6.79024309e-02f, 4.39543575e-02f, -1.93025514e-01f, 9.87474155e-03f, -8.71602371e-02f, -2.01573479e-03f, 7.69229308e-02f,
  -3.76028009e-02f, 7.30521902e-02f, -2.53267046e-02f, 6.87688142e-02f, 2.62588765e-02f, -1.30142942e-02f, -8.39103535e-02f, -2.39131674e-02f, 8.80423281e-03f, -5.73222898e-02f,
  -4.51437384e-02f, 2.00604051e-02f, 1.66558346e-03f, 6.60171360e-02f, -2.51428857e-02f, 7.56682605e-02f, -9.36742593e-03f, -2.05443557e-02f, -1.61575861e-02f, 6.53161108e-02f,
  -5.95871639e-03f, -2.06637550e-02f, 8.25640745e-03f, -2.82996837e-02f, 4.61434908e-02f, -2.67912447e-02f, -4.50011119e-02f, 4.03812435e-03f, 1.23404143e-02f, 5.18089868e-02f,
  -2.56350059e-02f, -2.54940707e-03f, -1.71991400e-02f, -5.83554560e-04f, 2.78124749e-03f, -4.68509123e-02f, -6.17443360e-02f, -4.71759662e-02f, -5.81284575e-02f, -3.84994894e-02f,
  1.15802415e-01f, -9.09480825e-02f, 8.14697295e-02f, 2.14520153e-02f, -7.12029869e-03f, 3.45871225e-02f, -1.15979288e-03f, -8.32187682e-02f, 7.60978460e-02f, 7.76161849e-02f,
  1.81789510e-02f, 1.63133949e-01f, 2.39160620e-02f, 4.52537164e-02f, -1.60845947e-02f, -4.22826931e-02f, 1.38181224e-01f, 1.91488098e-02f, -3.36202569e-02f, 3.17897916e-01f,
  -4.74008381e-01f, 6.29623160e-02f, -2.72457242e-01f, -2.59875834e-01f, 1.80546120e-01f, 2.27775618e-01f, 1.41500518e-01f, 2.24382877e-01f, -5.24473959e-04f, -4.16197814e-03f,
  6.98331445e-02f, 9.33843255e-02f, 8.31881911e-02f, 1.77261844e-01f, 1.14497155e-01f, -1.86337382e-01f, -1.03838772e-01f, -1.12713300e-01f, 3.39366086e-02f, 3.83064806e-01f,
  2.34183505e-01f, -6.01788908e-02f, -1.34102449e-01f, 2.38247197e-02f, -2.20766976e-01f, -4.42990251e-02f, -2.92518556e-01f, -2.50619501e-01f, -4.59538810e-02f, -4.11895037e-01f,
  -2.41621032e-01f, -2.57382959e-01f, 8.13931450e-02f, 6.71438500e-02f, -1.15055799e-01f, -4.38344479e-02f, -1.15509192e-02f, -1.09841272e-01f, 5.37276901e-02f, -6.66783750e-02f,
  -1.13897696e-01f, -2.65470706e-03f, -2.54391693e-02f, 3.41699757e-02f, -4.50733975e-02f, -8.95964652e-02f, -4.93357666e-02f, -2.29664311e-01f, -1.54788002e-01f, 7.78169092e-03f,
  5.69547638e-02f, 7.83796329e-03f, -2.54411668e-01f, -2.83941533e-02f, -2.59196814e-02f, 3.50989103e-02f, -5.08749038e-02f, -1.70785517e-01f, -6.44180924e-02f, -2.91955829e-01f,
  1.27262563e-01f, -3.76619585e-02f, 1.71768088e-02f, -2.18552481e-02f, 3.62929031e-02f, -4.18382064e-02f, -3.27189416e-02f, 1.91747099e-02f, 4.22767363e-02f, -5.49100898e-02f,
  1.82911064e-02f, 9.75463074e-03f, 7.20195053e-03f, -4.54406142e-02f, 1.57993045e-02f, -8.33907723e-02f, -1.73020232e-02f, 1.97760034e-02f, -6.46009594e-02f, 7.04490952e-03f,
  -5.42676775e-03f, -7.34118447e-02f, -3.60420868e-02f, -5.49187027e-02f, -1.22359907e-02f, 9.52994287e-06f, 2.97699459e-02f, -1.32408598e-02f, -2.48924480e-04f, -1.39603391e-02f,
  -1.07471831e-01f, 7.77484626e-02f, -6.97449893e-02f, -3.90240699e-02f, -6.33522794e-02f, 1.21311925e-03f, -3.42130959e-02f, 1.16661796e-03f, -3.33040506e-02f, -2.12253258e-03f,
  4.98277768e-02f, -8.46216902e-02f, -1.56329945e-01f, 2.28536092e-02f, -1.49251465e-02f, 6.49557263e-02f, 8.01228136e-02f, -8.53033960e-02f, 6.93581849e-02f, 1.00425268e-02f,
  9.22894329e-02f, 2.24208869e-02f, -1.43983811e-02f, -2.24526767e-02f, 2.26989724e-02f, 2.86991131e-02f, -1.12243079e-01f, -3.65685709e-02f, 2.81306524e-02f, 7.46483682e-04f,
  -6.54499650e-01f, 3.99663568e-01f, 1.10831775e-01f, -7.38847181e-02f, 3.69255394e-01f, 6.31492808e-02f, 7.12149516e-02f, -4.39522937e-02f, -4.59141023e-02f, 5.10198027e-02f,
  1.80358559e-01f, 6.04258850e-02f, -1.81871885e-03f, -4.00413796e-02f, -1.05249047e-01f, 6.44982904e-02f, 2.09367827e-01f, -9.83583555e-02f, -3.26072782e-01f, -1.86033592e-01f,
  4.59693447e-02f, -9.87633504e-03f, -1.45019680e-01f, -9.33758765e-02f, 1.89464599e-01f, 8.21270887e-03f, 2.64151573e-01f, 1.33994997e-01f, 1.29225001e-01f, 2.44907603e-01f,
  -1.85986627e-02f, -2.17996798e-02f, -3.71947363e-02f, 1.07576422e-01f, 1.47862971e-01f, -1.18016981e-01f, 4.26128739e-03f, -1.45455468e-02f, 6.88390359e-02f, -2.44692061e-02f,
  1.48440331e-01f, 3.95220555e-02f, 9.98572782e-02f, 9.67705473e-02f, -2.94005275e-02f, -3.86783853e-02f, -4.05040905e-02f, 2.11011060e-02f, 9.45255533e-03f, 2.63087656e-02f,
  2.29071438e-01f, 1.51162475e-01f, 1.24493890e-01f, 9.16308090e-02f, 4.92455065e-02f, 4.76998501e-02f, 1.15587473e-01f, 1.20575599e-01f, 4.35416885e-02f, -1.84224267e-02f,
  -6.77562505e-02f, 1.41380131e-02f, 5.70973977e-02f, 8.08502808e-02f, 4.35837470e-02f, -8.13818630e-03f, 4.33823727e-02f, 7.25674108e-02f, -9.02647246e-03f, -1.58363320e-02f,
  2.64443401e-02f, 6.85168663e-03f, 2.85827033e-02f, -1.23273442e-02f, -1.93565770e-03f, 5.38769141e-02f, 6.68916702e-02f, 3.72057594e-02f, 2.04498079e-02f, 1.69482101e-02f,
  4.70324904e-02f, 4.34787013e-02f, -5.33317868e-03f, -3.07056010e-02f, 8.16567056e-03f, 7.79173821e-02f, 5.16543426e-02f, 2.43642516e-02f, -3.12453266e-02f, 4.83732857e-02f,
  -9.68243107e-02f, 1.46697327e-01f, -4.40050960e-02f, -1.68801006e-02f, 2.87760105e-02f, 8.79742652e-02f, 1.18305348e-01f, 6.81447908e-02f, 4.76495214e-02f, -8.29258189e-03f,
  1.16069533e-01f, -7.90155157e-02f, 4.16536964e-02f, -5.37676690e-03f, -1.02843242e-02f, -2.14108061e-02f, 8.38635713e-02f, 5.38007841e-02f, 7.60677233e-02f, 7.67754987e-02f,
  5.88551946e-02f, 3.27214003e-02f, -1.77471384e-01f, 3.22780050e-02f, 3.05793714e-02f, 2.11594179e-02f, 1.17824208e-02f, 4.60503213e-02f, -8.52957077e-04f, -9.04673561e-02f,
  4.26894337e-01f, -1.26693159e-01f, -3.83609951e-01f, 3.97206664e-01f, -4.10716347e-02f, -1.02503344e-01f, -2.04961300e-01f, 4.30301763e-02f, 2.71918297e-01f, 3.52852903e-02f,
  -5.92148975e-02f, 2.94027999e-02f, -5.16278110e-02f, -1.55489892e-01f, -2.74264812e-01f, -3.21293354e-01f, -2.21280798e-01f, -3.76634806e-01f, -1.61677599e-01f, -6.10594414e-02f,
  1.08142033e-01f, 2.19634518e-01f, 1.09078892e-01f, 1.16008028e-01f, 2.55315870e-01f, 9.60492641e-02f, 6.79871216e-02f, 5.49427643e-02f, 6.23194687e-03f, 9.86210331e-02f,
  -1.16311900e-01f, 8.12667310e-02f, -1.00365251e-01f, 5.97597398e-02f, -6.42881147e-04f, 5.93607128e-02f, 7.38270059e-02f, 5.92740141e-02f, 3.30203352e-03f, 4.53840606e-02f,
  2.53404863e-02f, 1.11239597e-01f, -1.61854401e-02f, 5.72323240e-02f, 5.34537435e-02f, 4.99666715e-03f, -3.42300721e-02f, -7.19276816e-02f, -8.88530090e-02f, 6.53756708e-02f,
  8.00040364e-02f, -1.41939074e-01f, -1.75787047e-01f, -5.11555001e-02f, -1.80351306e-02f, -1.06038556e-01f, 7.81894028e-02f, 7.89559036e-02f, 2.47125756e-02f, 2.13172689e-01f,
  5.97803630e-02f, -6.61406480e-03f, -2.47386564e-02f, 8.78776014e-02f, 4.38770205e-02f, 3.31613161e-02f, 7.38200918e-02f, 4.89239432e-02f, 8.07186514e-02f, 9.64213088e-02f,
  2.87867859e-02f, 5.25207818e-02f, 1.66115779e-02f, 2.00025402e-02f, -2.07141368e-03f, 3.95418778e-02f, -4.57578413e-02f, 2.37338357e-02f, -2.24007349e-02f, 7.24027529e-02f,
  -1.65573433e-02f, 4.45862114e-02f, 3.46905440e-02f, 2.82058362e-02f, -2.68654414e-02f, -6.48550317e-02f, 3.20984237e-02f, 9.81900170e-02f, 9.79765505e-02f, 7.15945736e-02f,
  3.47569168e-01f, -2.64885932e-01f, 9.96435136e-02f, -9.23291743e-02f, -7.44179115e-02f, -2.45834012e-02f, -3.29334326e-02f, -8.59526843e-02f, 4.43565361e-02f, 2.36875433e-02f,
  -1.91160280e-03f, -2.71320548e-02f, -2.58370489e-02f, -3.40516726e-03f, -2.17452971e-03f, 7.06221759e-02f, -1.03788283e-02f, -4.30661179e-02f, -3.29822488e-02f, 3.23467888e-02f,
  1.36465486e-02f, 3.67974788e-02f, -9.14286375e-02f, -1.27645195e-01f, 3.09303310e-02f, -6.02432378e-02f, -7.44311586e-02f, 6.06809109e-02f, -1.24382019e-01f, 1.11698262e-01f,
  -2.41601877e-02f, -6.13205075e-01f, 2.98634559e-01f, -2.01036066e-01f, 4.50317115e-02f, 2.21259147e-01f, -4.73597310e-02f, 6.47741258e-02f, 1.95314735e-02f, -2.33964622e-01f,
  -2.16212183e-01f, 2.90725548e-02f, -3.83206829e-02f, 2.17187822e-01f, 1.59118593e-01f, -1.83821991e-01f, -3.81506830e-02f, 3.23662251e-01f, 4.79181677e-01f, 1.74959391e-01f,
  -4.77136225e-02f, -1.56615093e-01f, 1.69878930e-01f, 1.44583061e-01f, -3.85627747e-01f, -3.06385127e-03f, -1.17215641e-01f, -1.50771111e-01f, -7.17761815e-02f, -5.33515394e-01f,
  2.95861047e-02f, -1.90861493e-01f, 1.21266343e-01f, 3.88023518e-02f, 9.77095123e-03f, 8.11155662e-02f, 9.47529376e-02f, 1.92451924e-02f, -1.92331821e-02f, -9.86092724e-03f,
  -1.47364184e-01f, 4.31102403e-02f, 1.94307659e-02f, 1.20791562e-01f, -3.07311695e-02f, 8.74311179e-02f, 4.51660007e-02f, 1.32340416e-01f, 1.24205619e-01f, 6.63664266e-02f,
  -1.59393117e-01f, -1.32957250e-01f, -7.43105076e-03f, 1.58468202e-01f, 2.20877498e-01f, 8.82177055e-02f, -9.29627381e-03f, -2.67712027e-03f, 1.89013869e-01f, -2.03806713e-01f,
  1.34360775e-01f, -4.49563600e-02f, 6.41684653e-03f, -1.98432785e-02f, 9.34380048e-04f, 5.40843494e-02f, -5.18762805e-02f, 9.11285635e-03f, -6.46606013e-02f, -2.75910981e-02f,
  1.54674826e-02f, 1.23609841e-01f, 4.79804613e-02f, 1.05774114e-02f, -5.43376207e-02f, -1.11328224e-02f, 2.10973080e-02f, -4.05958742e-02f, 1.82712879e-02f, -2.73097195e-02f,
  2.67395079e-02f, 8.53309482e-02f, -9.38594565e-02f, 1.08749270e-01f, 2.38293670e-02f, 7.02927914e-03f, 5.09937629e-02f, 4.19939570e-02f, 3.09637673e-02f, -2.84943301e-02f,
  -7.39737600e-03f, 3.99638116e-01f, -4.19569984e-02f, -8.52617156e-03f, 5.04760072e-02f, -5.31794988e-02f, -4.01437096e-02f, -1.54734673e-02f, -8.25303942e-02f, 2.28450652e-02f,
  9.90826562e-02f, 4.90233563e-02f, -4.40233722e-02f, 4.88225324e-03f, 3.12673114e-02f, -5.23266830e-02f, -7.11614117e-02f, 1.00757748e-01f, 6.78166375e-02f, -2.87755784e-02f,
  4.37690578e-02f, 9.49574038e-02f, 1.96546316e-01f, -4.24919781e-05f, 6.32937029e-02f, 1.58579081e-01f, 2.35133208e-02f, 1.62903085e-01f, 2.25356817e-01f, 5.74833415e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.13024008e+00f, 3.18936646e-01f, 1.57265171e-01f, 1.85925037e-01f, -4.85549718e-01f, -3.98262411e-01f, -4.40387279e-01f, -1.32757396e-01f, 9.70250964e-02f, 2.55452901e-01f,
  1.79132536e-01f, 3.63689333e-01f, 1.40016362e-01f, 2.15665147e-01f, 1.94745913e-01f, 2.05032453e-02f, -1.21607251e-01f, 2.13698030e-01f, 9.48529840e-02f, 1.75539955e-01f,
  1.34010494e-01f, 3.85835916e-02f, 2.51024008e-01f, 9.07299593e-02f, 6.05405197e-02f, 4.00313474e-02f, -1.07042752e-01f, -5.43416664e-02f, 1.00496307e-01f, 5.16900420e-01f,
  4.49829966e-01f, 1.25428900e-01f, -2.04993457e-01f, -3.59475277e-02f, -6.13090284e-02f, 1.56709608e-02f, -1.67389978e-02f, 4.01937328e-02f, -7.19874799e-02f, -1.68298379e-01f,
  -6.88803149e-03f, -6.76826835e-02f, -4.07545790e-02f, -6.96264878e-02f, -9.37272012e-02f, -6.86644614e-02f, 5.43778874e-02f, 2.30728865e-01f, -3.00143361e-02f, 7.89477956e-03f,
  -4.54406859e-03f, 1.29060194e-01f, -1.25154883e-01f, -1.71228334e-01f, 3.04542296e-02f, -9.84090045e-02f, 3.28768715e-02f, 6.15550913e-02f, -8.70681480e-02f, 3.69340867e-01f,
  -1.35217085e-02f, 2.02592090e-01f, 6.80415183e-02f, -5.07674739e-02f, 6.99646324e-02f, -1.05334364e-01f, 3.91844334e-03f, -4.25119698e-02f, 1.19203843e-01f, 1.51882945e-02f,
  -1.49101317e-01f, 1.03164896e-01f, 5.49058355e-02f, 3.18902149e-03f, 2.20360845e-01f, 4.06460389e-02f, 4.80411202e-02f, -4.68485290e-03f, -1.48321018e-01f, -5.37602678e-02f,
  3.00894603e-02f, -1.01104580e-01f, -2.83869752e-03f, -1.83536094e-02f, -8.42387527e-02f, 1.08942196e-01f, 7.24374577e-02f, -2.38548275e-02f, -1.59409717e-02f, -6.69070184e-02f,
  -1.47311598e-01f, -2.67834812e-01f, 1.48741871e-01f, 1.08078755e-01f, 4.12304327e-02f, 4.77124937e-02f, 1.43210113e-01f, -7.15117753e-02f, -2.60137230e-01f, 3.70325111e-02f,
  -3.88795920e-02f, -5.56330942e-02f, -1.41769033e-02f, 1.57214291e-02f, -5.91725931e-02f, -1.11026168e-01f, 4.81415763e-02f, 9.46285278e-02f, -1.62006840e-02f, -9.01162401e-02f,
  1.98092125e-02f, -3.68012078e-02f, -1.17011145e-01f, -6.28990456e-02f, 2.94120479e-02f, 4.95703593e-02f, -1.24682836e-01f, -7.72083849e-02f, -4.25383188e-02f, -4.36801016e-02f,
  -6.67061433e-02f, -7.89166838e-02f, -8.29678059e-01f, 4.85859782e-01f, -4.94951338e-01f, -6.41508341e-01f, -3.26205701e-01f, 2.86411077e-01f, 4.89632726e-01f, 5.71563467e-02f,
  9.61686298e-02f, -2.34358653e-01f, 7.70782232e-02f, -3.27850014e-01f, -6.99459791e-01f, -4.37399209e-01f, -5.63453197e-01f, -8.52320135e-01f, -9.97514248e-01f, -4.57926989e-01f,
  -2.80707091e-01f, -1.26376867e-01f, -2.30830029e-01f, -1.42595306e-01f, 2.61617005e-01f, 1.30834237e-01f, 1.34220839e-01f, -1.09985352e-01f, -3.19551528e-01f, -7.32160434e-02f,
  -4.90127683e-01f, -5.26057146e-02f, -1.15712129e-01f, -3.06970230e-03f, 6.35871142e-02f, -1.00350641e-01f, -3.32312465e-01f, -4.24799882e-02f, 1.60363000e-02f, -7.22795203e-02f,
  -3.00316401e-02f, -1.15903117e-01f, -1.15033351e-01f, -2.35045493e-01f, -1.08632497e-01f, -2.51795560e-01f, -7.57998303e-02f, -2.29943722e-01f, -1.65508896e-01f, -1.82527304e-03f,
  -3.29409987e-01f, -4.92711812e-01f, -3.00091445e-01f, -6.36293218e-02f, -1.33117884e-01f, -1.97054595e-01f, 6.65170997e-02f, 6.49928972e-02f, -1.32432789e-01f, 5.83446860e-01f,
  1.41773775e-01f, 1.85342968e-01f, -4.74189632e-02f, 7.23122954e-02f, 3.82184633e-03f, 3.87898684e-02f, -1.40313700e-01f, -2.70666294e-02f, -8.36913809e-02f, -1.56697839e-01f,
  8.09714943e-02f, 1.64282322e-01f, -3.15278918e-02f, 3.78959700e-02f, -4.00033928e-02f, 9.92841423e-02f, -2.31764391e-02f, -8.78639426e-03f, 1.00885659e-01f, -9.41397250e-02f,
  -1.23664446e-01f, -3.62942405e-02f, 8.02033693e-02f, 1.35352626e-01f, -1.04869448e-01f, -4.06648405e-02f, -5.11045232e-02f, -3.08465585e-02f, 3.98920774e-02f, -9.83669609e-02f,
  3.58726859e-01f, -4.95396346e-01f, 2.18023077e-01f, 1.01067327e-01f, -1.48053586e-01f, 9.42327306e-02f, 1.38965786e-01f, 1.31874964e-01f, 3.28359492e-02f, -1.00926802e-01f,
  -2.16195986e-01f, 8.72483924e-02f, 1.61842480e-01f, -9.09857973e-02f, -8.34839642e-02f, -5.15894704e-02f, -6.54148757e-02f, -1.29992336e-01f, -2.56884955e-02f, 1.84413046e-01f,
  1.17556684e-01f, 8.29466209e-02f, -2.06978042e-02f, 5.47228530e-02f, 6.63009658e-02f, -1.79760754e-01f, -6.52569905e-02f, 8.86157248e-03f, -2.86882728e-01f, 5.69665670e-01f,
  -9.02776301e-01f, -1.12124383e-01f, -2.08537653e-03f, -1.12190568e+00f, -2.57237792e-01f, 1.72436461e-01f, 5.75387895e-01f, -3.01337894e-03f, -5.79367936e-01f, 4.31567997e-01f,
  2.60415643e-01f, 1.38837501e-01f, 2.23800000e-02f, 2.91188210e-01f, 2.58399546e-01f, 4.61019129e-01f, -2.73032010e-01f, -5.95513843e-02f, 2.15005979e-01f, 2.61537701e-01f,
  7.41306618e-02f, -2.82096386e-01f, -6.66601121e-01f, -4.99373198e-01f, -3.10394108e-01f, 6.28828909e-03f, -1.62312180e-01f, -4.31428790e-01f, 1.84979066e-01f, -6.37172699e-01f,
  5.48540473e-01f, -4.51717198e-01f, -2.26941854e-02f, -2.97401875e-01f, -8.45331699e-02f, -1.65826648e-01f, -4.35502604e-02f, -8.81806388e-02f, -2.62724813e-02f, -9.78475511e-02f,
  -3.31788629e-01f, 1.37623288e-02f, -2.45709002e-01f, -4.90914471e-03f, -9.96378064e-02f, -6.93238899e-02f, -3.90274567e-04f, -1.75495356e-01f, -1.09681144e-01f, 1.46927238e-01f,
  -1.42792445e-02f, -1.36336908e-01f, 4.53941450e-02f, 6.54071942e-03f, -2.70785764e-02f, 2.07324550e-02f, 1.20705344e-01f, -7.16849864e-02f, 2.50964742e-02f, -2.83472077e-03f,
  4.18031327e-02f, 1.00103579e-01f, 9.08012316e-02f, 1.19571704e-02f, -2.28698142e-02f, 1.10228181e-01f, 7.38742724e-02f, 8.92444178e-02f, 2.66334992e-02f, 5.73282875e-02f,
  -8.30698386e-02f, 3.98881473e-02f, 2.55709956e-03f, -7.25095277e-04f, 8.31041709e-02f, -1.50801361e-01f, -5.42661957e-02f, 1.05150133e-01f, 8.76974501e-03f, -9.71052721e-02f,
  -1.37123391e-01f, -7.89599791e-02f, -9.71665084e-02f, 1.67998932e-02f, -2.13979464e-02f, -1.02154568e-01f, -1.17786497e-01f, -3.87722999e-02f, 9.63018537e-02f, -1.50155008e-01f,
  1.10086240e-01f, -3.01353782e-01f, 6.85572997e-02f, 7.31101213e-03f, -6.87217936e-02f, -1.11311816e-01f, -3.35432440e-02f, -3.36134546e-02f, 3.35898325e-02f, 6.30552545e-02f,
  -9.96381566e-02f, 8.54753852e-02f, -1.52052036e-02f, 5.03839143e-02f, 1.19034581e-01f, -1.30374050e-02f, -9.74544976e-03f, -6.20970652e-02f, -9.99963284e-03f, -9.16659366e-03f,
  -1.33374587e-01f, 1.71897009e-01f, 2.48388365e-01f, 1.66547239e-01f, 4.59056422e-02f, 1.81206092e-01f, 4.13040549e-01f, 2.64395535e-01f, 1.47394553e-01f, 3.63486379e-01f,
  -8.70757282e-01f, -2.55779952e-01f, -1.66682571e-01f, -2.40421757e-01f, 8.99654746e-01f, 2.45286375e-01f, -5.75335063e-02f, -1.48993298e-01f, 1.99797098e-02f, -1.54717609e-01f,
  3.28669041e-01f, 4.48836744e-01f, 2.81109095e-01f, 2.26897195e-01f, -3.19539219e-01f, -3.62774767e-02f, 2.53962815e-01f, -2.18122363e-01f, -2.81291306e-01f, -4.77428921e-02f,
  3.39989305e-01f, -2.21015915e-01f, -7.42025077e-01f, -1.83799088e-01f, 1.40598804e-01f, 4.86101303e-03f, 1.26336902e-01f, 8.60491842e-02f, 1.16836950e-01f, 1.28276765e-01f,
  -3.60679656e-01f, -4.21124965e-01f, 1.84574157e-01f, -5.26412763e-02f, 2.61088848e-01f, -1.50184751e-01f, -2.94408023e-01f, -1.78330898e-01f, 1.86930984e-01f, -2.55535185e-01f,
  1.81785166e-01f, -2.27667004e-01f, 2.97257841e-01f, 2.96428446e-02f, -1.82248250e-01f, -2.80400127e-01f, -9.03787464e-02f, -2.51156896e-01f, -3.08662981e-01f, -1.91525221e-01f,
  5.21299660e-01f, 3.02020133e-01f, -1.89749435e-01f, 1.26443937e-01f, -6.51466101e-03f, 1.30869597e-01f, 7.48025998e-02f, -2.94882029e-01f, -3.40429187e-01f, -6.68438852e-01f,
  -6.16465062e-02f, 2.91504674e-02f, 6.60227165e-02f, -1.43314287e-01f, 1.18453920e-01f, 1.90482929e-01f, 1.55228242e-01f, 2.37427354e-02f, 1.48841962e-01f, -2.28894114e-01f,
  1.70750856e-01f, 1.32555186e-04f, -4.37076800e-02f, -1.49502337e-01f, 7.15711564e-02f, -5.23734763e-02f, -7.75663108e-02f, -1.04365908e-01f, -5.62783629e-02f, -9.95942056e-02f,
  -2.31736768e-02f, 1.59846529e-01f, -1.89402085e-02f, 5.07303067e-02f, 1.17573939e-01f, 3.67496610e-02f, -1.41545177e-01f, 1.11860670e-02f, -1.93556007e-02f, -8.06723461e-02f,
  -3.22386593e-01f, 4.28009272e-01f, -2.63568819e-01f, -2.35643168e-03f, -1.42073616e-01f, 6.20113648e-02f, 7.63591900e-02f, 5.14501072e-02f, 4.48506624e-02f, -1.57738969e-01f,
  -1.67329952e-01f, -4.01920117e-02f, -1.20895244e-01f, 8.85293186e-02f, -1.50032669e-01f, -6.16623014e-02f, 3.13206837e-02f, 8.10067505e-02f, -2.58492112e-01f, -5.93182780e-02f,
  -1.12574674e-01f, -2.76697010e-01f, -4.74493891e-01f, -1.11692198e-01f, -2.22544625e-01f, -1.95051536e-01f, -2.90646404e-01f, -4.08904940e-01f, -5.36663175e-01f, -7.62445807e-01f,
  1.21900761e+00f, 2.85809249e-01f, 3.02086532e-01f, 1.68084592e-01f, 1.47261918e-01f, 2.97073096e-01f, 5.42366624e-01f, 4.21742052e-01f, 3.09154745e-02f, 2.57515013e-01f,
  -8.93084481e-02f, -2.78517812e-01f, -3.07188213e-01f, -3.03542197e-01f, 1.41272888e-01f, 2.21704338e-02f, -1.83396384e-01f, 1.53591499e-01f, 1.51219994e-01f, 9.83866304e-02f,
  -6.98245391e-02f, 2.41616473e-01f, 2.98438609e-01f, 1.14466116e-01f, -1.59983024e-01f, -3.95264804e-01f, -8.96797180e-02f, 1.23620583e-02f, -2.74587333e-01f, -3.50357056e-01f,
  -3.07014972e-01f, 4.15476710e-01f, -2.09277049e-01f, -1.65244207e-01f, 1.74802262e-02f, 1.71357170e-01f, 4.77791280e-02f, 1.00769423e-01f, 8.91243219e-02f, 2.01654024e-02f,
  -1.13888063e-01f, 1.42593924e-02f, -8.89502242e-02f, 3.63946408e-02f, 6.39223233e-02f, 1.35252550e-01f, 9.43424702e-02f, -6.95393793e-03f, -1.19037423e-02f, 7.66067579e-03f,
  -1.89174697e-01f, 5.01962565e-03f, 9.00352225e-02f, 3.19621228e-02f, 9.23279971e-02f, -1.05178490e-01f, -4.40610312e-02f, -9.26175416e-02f, -6.70521185e-02f, 1.28738061e-01f,
  1.37245864e-01f, 1.01890728e-01f, -2.16345981e-01f, -6.55840635e-02f, 1.60209090e-02f, -4.11326252e-02f, -7.29719996e-02f, 4.57697138e-02f, 2.97274329e-02f, 2.45491296e-01f,
  -1.02597050e-01f, -1.08183138e-01f, -3.64349298e-02f, 6.50572851e-02f, -6.54725507e-02f, -8.23056325e-02f, 1.41580135e-01f, -8.79079178e-02f, -9.72511321e-02f, -3.04853767e-02f,
  5.67115843e-02f, 4.72058728e-02f, 4.02742401e-02f, -1.70199856e-01f, -6.70806319e-02f, -3.08136251e-02f, -2.30635889e-02f, 4.86280434e-02f, 1.87261105e-02f, 6.20686188e-02f,
  -5.23742974e-01f, -1.64699689e-01f, -1.89952269e-01f, -1.61205567e-02f, 3.21147293e-02f, 8.08365121e-02f, -6.45123571e-02f, -1.45066485e-01f, -7.31352642e-02f, 7.55718816e-03f,
  -2.96255443e-02f, 1.29373223e-02f, -3.58404331e-02f, 8.52143988e-02f, 1.53049361e-02f, 1.64148379e-02f, 1.43796187e-02f, 8.21838900e-02f, -1.55150026e-01f, -1.46651134e-01f,
  1.86351612e-02f, 2.23659843e-01f, 5.80331534e-02f, 5.56857958e-02f, 5.61732873e-02f, 3.36656049e-02f, 1.00501075e-01f, 1.35220036e-01f, 8.39466304e-02f, 1.75421745e-01f,
  -1.00011599e+00f, -3.06473583e-01f, -2.00670674e-01f, -9.00226831e-01f, -1.19997300e-02f, 6.39133751e-02f, -3.08198720e-01f, 1.24398284e-01f, -5.87680079e-02f, -4.65103120e-01f,
  -7.87949562e-02f, 1.13013573e-02f, -4.16807353e-01f, -6.91300351e-03f, -7.70033151e-02f, -5.53938806e-01f, -3.62738490e-01f, -2.14943979e-02f, 5.86225450e-01f, 5.67409277e-01f,
  2.58747011e-01f, -1.75529882e-01f, 2.12679133e-01f, 2.42114648e-01f, -4.98687118e-01f, -5.62633835e-02f, -4.60474968e-01f, -1.68284729e-01f, 7.07919076e-02f, -8.92852843e-01f,
  -6.58601463e-01f, -9.22252834e-02f, 1.83236629e-01f, -1.47160077e-02f, -1.28772363e-01f, 7.76516367e-03f, -1.22875169e-01f, -1.02194734e-01f, 1.63889006e-01f, 5.23662427e-03f,
  -1.25315368e-01f, 2.16762275e-01f, -3.27928141e-02f, -6.89884722e-02f, -5.41678211e-03f, 4.20751087e-02f, -1.78162102e-02f, 9.03724134e-02f, 1.99653562e-02f, 7.13695437e-02f,
  2.21857559e-02f, 3.02810092e-02f, -6.20757341e-02f, 1.82549328e-01f, 2.46749416e-01f, 1.55862227e-01f, 2.47926220e-01f, 2.76989192e-01f, 3.99323046e-01f, -3.69546860e-01f,
  3.03166267e-02f, 4.33064289e-02f, -1.01304904e-01f, 2.51481310e-02f, 1.66790355e-02f, -1.39827222e-01f, -1.96535319e-01f, -6.03961982e-02f, 7.28480220e-02f, -4.77467291e-02f,
  -7.20021799e-02f, -3.18622813e-02f, -2.56530959e-02f, -6.46708682e-02f, -6.22984357e-02f, 6.97256103e-02f, -8.06137174e-02f, -6.51709959e-02f, -4.15617274e-03f, 1.45640597e-02f,
  1.26823261e-01f, 1.94538042e-01f, -5.33744805e-02f, 9.66636911e-02f, 1.01315053e-02f, -1.45528421e-01f, 1.04628447e-02f, 1.13637090e-01f, -5.76860271e-02f, 1.48223028e-01f,
  -5.19142509e-01f, 2.56293267e-01f, -4.99936223e-01f, 1.44433334e-01f, -1.75144255e-01f, 8.10574740e-02f, -9.81124490e-02f, 2.83447132e-02f, -1.38908938e-01f, -8.27576383e-04f,
  2.38255501e-01f, -7.45791793e-02f, -1.72628492e-01f, 1.76339403e-01f, 2.65066531e-02f, 5.34513639e-03f, -4.96155210e-02f, -1.01258792e-01f, 1.45612463e-01f, 1.49322972e-01f,
  1.08315840e-01f, -8.93276185e-02f, -2.23470300e-01f, -2.06346259e-01f, 1.02659777e-01f, -2.02693850e-01f, -1.66565076e-01f, -7.64660863e-03f, -1.00834846e-01f, -6.22910500e-01f,
  -3.69087666e-01f, -2.83895671e-01f, 2.23615453e-01f, 4.81763273e-01f, 2.58771241e-01f, 2.16023102e-01f, 7.58099928e-02f, 3.35075051e-01f, 2.67353326e-01f, 8.90135467e-02f,
  6.97123632e-02f, 2.83546001e-01f, 3.27742636e-01f, 2.05870032e-01f, 2.11070061e-01f, 2.91499525e-01f, 3.31873834e-01f, 2.26584598e-01f, 2.11867884e-01f, 9.36010182e-02f,
  1.77435502e-01f, -1.88778624e-01f, -2.97746599e-01f, 1.13698296e-01f, 7.19758645e-02f, 2.26985291e-01f, 5.01144007e-02f, -2.98311025e-01f, -6.78527504e-02f, 2.23834544e-01f,
  -7.47676268e-02f, -1.96225837e-01f, 3.11010242e-01f, -5.05449157e-03f, -1.57887205e-01f, -1.06416054e-01f, 3.19025549e-03f, -1.72669161e-02f, -9.13688615e-02f, -4.29100124e-03f,
  5.99911176e-02f, -7.24128336e-02f, -1.39640972e-01f, -5.63359261e-02f, -1.34085119e-01f, -1.09429128e-01f, -1.14256740e-01f, -2.47446187e-02f, 3.25029716e-02f, 2.65075895e-03f,
  1.06757432e-01f, 6.31264225e-02f, 1.21579304e-01f, 3.14754397e-01f, 1.40864462e-01f, 1.21953532e-01f, -1.86790917e-02f, -2.93033142e-02f, 2.43286379e-02f, -5.90301454e-02f,
  3.50302190e-01f, 1.19143270e-01f, 3.78916529e-03f, -3.76758836e-02f, -1.92098543e-02f, -9.18949619e-02f, -4.16269489e-02f, -1.45498002e-02f, 1.10120028e-01f, -1.34620085e-01f,
  4.06610556e-02f, 9.39962193e-02f, -3.70398574e-02f, 2.73424704e-02f, 1.06079228e-01f, -2.29280628e-02f, 2.24209502e-02f, -8.36624503e-02f, -1.28030896e-01f, -4.89859544e-02f,
  -1.15221192e-03f, 4.22362536e-02f, -1.29041821e-01f, -1.23985320e-01f, -1.66552179e-02f, 1.24428906e-01f, -3.48851904e-02f, 2.82367691e-02f, -8.81001353e-02f, 2.25439630e-02f,
  -1.33673683e-01f, 1.73490778e-01f, 1.41337216e-01f, 1.23576842e-01f, -1.64063171e-01f, -2.42891774e-01f, 1.10566616e-01f, -4.98691462e-02f, -4.87323888e-02f, 2.12270871e-01f,
  -1.49048969e-01f, -5.70910685e-02f, -1.45828456e-01f, -8.23850185e-02f, 4.07596165e-03f, 4.21425998e-02f, -7.88751394e-02f, 2.82953884e-02f, 4.86185066e-02f, -2.85662594e-03f,
  -6.54123500e-02f, 1.09343454e-01f, 4.05224502e-01f, 1.91733047e-01f, 7.20451474e-02f, 2.14864790e-01f, -1.96631979e-02f, -2.14607939e-02f, 3.78207602e-02f, -1.21275164e-01f,
  1.27351701e+00f, -4.74879831e-01f, -1.01879954e+00f, 3.16796809e-01f, -2.94830829e-01f, 1.09310411e-01f, -1.64982945e-01f, 3.54739070e-01f, 3.57917249e-01f, -3.95032912e-01f,
  3.57012227e-02f, 6.06315076e-01f, 3.11188370e-01f, 6.70721456e-02f, 3.51750523e-01f, -5.99851668e-01f, -5.97232938e-01f, 9.59692150e-02f, 3.25815380e-01f, 3.92257087e-02f,
  -3.24370340e-03f, 2.06221417e-02f, 3.54551166e-01f, 1.43929720e-01f, -3.14568281e-01f, 1.16021961e-01f, -6.98785305e-01f, -2.72315532e-01f, -4.18719143e-01f, -8.72018576e-01f,
  -3.59164655e-01f, -3.22693199e-01f, -1.18493870e-01f, -7.71917403e-02f, -1.89084828e-01f, 1.56826600e-01f, -4.96041141e-02f, -7.09119663e-02f, 2.26989593e-02f, -1.43926948e-01f,
  -1.46459609e-01f, 2.14477889e-02f, 9.30044241e-03f, -7.59734958e-02f, -6.62252456e-02f, 2.96324119e-02f, -1.01503186e-01f, -1.64106756e-01f, -6.34533912e-02f, -1.66614696e-01f,
  -7.31925815e-02f, -4.73304316e-02f, 1.51692762e-03f, -9.33382213e-02f, 1.07689574e-03f, 3.34476158e-02f, -1.66711360e-01f, -1.85739100e-01f, -2.25754365e-01f, -1.70413405e-01f,
  -1.61633685e-01f, 7.46503472e-02f, 3.94498967e-02f, 4.23567835e-03f, 2.38375172e-01f, 8.72280598e-02f, 2.56652609e-02f, 4.94502857e-02f, 1.01421177e-01f, 3.69056547e-03f,
  -2.27723029e-02f, -2.40897462e-02f, -7.49296620e-02f, 3.03445593e-03f, -3.29273827e-02f, -6.90260679e-02f, -5.20965829e-02f, -4.56826650e-02f, -4.21732571e-03f, 2.57931799e-02f,
  9.08074453e-02f, 2.02145837e-02f, 2.04118919e-02f, 3.12954225e-02f, -8.80918503e-02f, -1.41137158e-02f, -1.27182856e-01f, 2.04329807e-02f, 1.12184538e-02f, -5.47660887e-02f,
  2.82766134e-01f, 8.13683588e-03f, 8.84145051e-02f, 8.64952058e-03f, 3.22802216e-02f, -7.28329420e-02f, -1.05945490e-01f, -4.72665988e-02f, 1.68750212e-01f, 4.93651330e-02f,
  -5.33472300e-02f, 7.83222392e-02f, 9.05984733e-03f, -1.41410470e-01f, 6.49366006e-02f, 1.19331636e-01f, 1.12577742e-02f, 1.08329467e-01f, 7.40063116e-02f, -1.34230763e-01f,
  -2.57713404e-02f, 2.28268936e-01f, 3.61106306e-01f, 1.47473201e-01f, 7.23022521e-02f, 2.55558521e-01f, 1.15906760e-01f, 7.20879957e-02f, 2.37573937e-01f, 1.89024433e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  5.79167664e-01f, 3.58979940e-01f, 5.93163669e-01f, 1.00407434e+00f, 6.19140387e-01f, 4.91726130e-01f, -1.23787820e-01f, 4.42376077e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.25109300e-01f, -1.13143995e-01f, 2.02567447e-02f, 2.18100436e-02f, -1.10129543e-01f, -4.50593196e-02f, -1.00009471e-01f, -3.50900851e-02f, -2.75030695e-02f, 1.10107243e-01f,
  1.51313275e-01f, -1.25654280e-01f, 1.23068660e-01f, 9.00007337e-02f, 9.51365195e-03f, -9.14677531e-02f, 4.45365608e-02f, 1.44855484e-01f, 3.72689553e-02f, 2.08639890e-01f,
  -6.17882311e-02f, 1.03215232e-01f, -1.97693482e-01f, 4.32143211e-01f, -1.24324679e-01f, -4.36741740e-01f, 2.19053313e-01f, -3.74304295e-01f, 1.92754552e-01f, 3.07684153e-01f,
  -1.81619540e-01f, 1.35979712e-01f, 6.98455498e-02f, -6.30611405e-02f, 2.12968186e-01f, -3.38381827e-02f, -1.17118113e-01f, 1.57605514e-01f, 4.91881855e-02f, -1.37329683e-01f,
  8.94563869e-02f, -5.29273227e-03f, 2.11513594e-01f, 3.20974998e-02f, -1.23917505e-01f, 1.91904947e-01f, -8.00875872e-02f, -1.37687832e-01f, -7.59925246e-02f, 2.50237924e-03f,
  1.81125805e-01f, -7.19478428e-02f, -2.21834034e-01f, -1.86824426e-01f, -1.04379401e-01f, 2.39746850e-02f, 3.35504502e-01f, -1.91423088e-01f, -2.74588257e-01f, -1.09315634e-01f,
  1.57005489e-01f, -2.44615152e-02f, -2.24311307e-01f, 2.45646566e-01f, -1.88332759e-02f, 4.49782833e-02f, -9.17416736e-02f, 2.61348132e-02f, 4.40574251e-02f, -6.63905293e-02f,
  -4.74016517e-02f, 1.83088928e-01f, -1.15479857e-01f, 3.04159708e-02f, 6.14577904e-03f, -4.43708859e-02f, -2.86598075e-02f, -5.32532558e-02f, -5.12583815e-02f, -4.25185775e-03f,
  1.16171196e-01f, 9.57971141e-02f, -3.81106101e-02f, 1.95516735e-01f, 4.82465960e-02f, -1.32627189e-02f, 4.79456456e-03f, -2.71791309e-01f, -9.16019082e-02f, 1.64048627e-01f,
  -1.55306548e-01f, -9.00239125e-02f, 3.11741292e-01f, -2.66111702e-01f, 1.79946035e-01f, -2.90439725e-01f, 2.96626762e-02f, -1.31533062e-02f, 1.09724872e-01f, 6.68581203e-02f,
  1.60915218e-02f, 4.21274155e-02f, -7.08914995e-02f, -3.54362689e-02f, 6.35767402e-03f, 7.29753897e-02f, 1.60989404e-01f, -9.55470428e-02f, 8.57668594e-02f, -1.01941898e-02f,
  -4.24057245e-03f, -8.07654336e-02f, -1.14298210e-01f, 6.71116412e-02f, 6.61632493e-02f, 1.77683577e-01f, -2.39746459e-02f, -1.02538234e-02f, -1.22701772e-01f, -2.40765229e-01f,
  2.33279839e-01f, -9.36013609e-02f, -1.83825210e-01f, 3.47888470e-01f, 1.00682877e-01f, -3.38631094e-01f, 1.65586293e-01f, -2.46264130e-01f, 4.17164853e-03f, 4.87688743e-02f,
  1.24398470e-01f, 5.58410659e-02f, 8.58010054e-02f, 9.06318799e-02f, -8.75625014e-02f, 8.91776904e-02f, 8.33742544e-02f, 2.81621516e-02f, -7.19967484e-02f, 2.93249309e-01f,
  -9.97114740e-03f, -7.43962973e-02f, -2.52070040e-01f, -7.92480074e-03f, 1.18618771e-01f, 1.87902063e-01f, 2.02721003e-02f, 2.21508294e-01f, 3.87572199e-02f, -7.72031918e-02f,
  2.83621341e-01f, -5.45292139e-01f, 3.20355892e-01f, 7.18425289e-02f, 1.14067070e-01f, -2.64018863e-01f, 1.16023114e-02f, -4.37247634e-01f, -1.70129910e-01f, 1.92086369e-01f,
  -1.75853431e-01f, 1.06537357e-01f, 2.77378887e-01f, -1.89823136e-02f, -7.51137659e-02f, -2.04424828e-01f, -1.52879775e-01f, -8.38266686e-03f, -2.26821396e-02f, -5.74910268e-02f,
  -3.61505806e-01f, 2.27851048e-01f, 9.01433378e-02f, -4.52230811e-01f, -1.07581042e-01f, 2.39712924e-01f, 6.44939542e-02f, 2.94242967e-02f, -2.12018251e-01f, 2.97729313e-01f,
  3.79155219e-01f, 6.39853105e-02f, 3.79091322e-01f, -3.93366873e-01f, -3.23796511e-01f, 2.39318728e-01f, -2.24503770e-01f, -1.55120239e-01f, 2.28619948e-01f, 1.87800348e-01f,
  -1.11945242e-01f, -1.45819440e-01f, -1.82534624e-02f, -1.36153609e-01f, 2.05418497e-01f, -4.28639399e-03f, -5.70709668e-02f, 5.95780388e-02f, 1.45045951e-01f, -2.43706647e-02f,
  2.94246167e-01f, 2.47757569e-01f, 1.90438017e-01f, 1.60359010e-01f, -5.72735332e-02f, -1.27727568e-01f, 1.07958697e-01f, -1.66472763e-01f, -4.49044779e-02f, -1.40443547e-02f,
  -3.77461091e-02f, 3.60747337e-01f, -1.12911947e-01f, -1.82766020e-02f, -1.39949217e-01f, 4.61425871e-01f, -2.80224711e-01f, -1.91641226e-02f, 4.66642678e-01f, -4.94915321e-02f,
  2.30028197e-01f, 1.52714089e-01f, -4.38889153e-02f, -4.87033904e-01f, -1.53448135e-01f, -2.51587648e-02f, -9.41659808e-02f, -1.09647214e-02f, 7.43744224e-02f, -5.42603955e-02f,
  7.79027045e-02f, 2.97067136e-01f, 1.50241882e-01f, -1.05108917e-01f, -2.07082272e-01f, 1.46752551e-01f, -1.02220871e-01f, -3.12603652e-01f, -7.08793476e-03f, 1.93683684e-01f,
  6.91942200e-02f, 9.64339916e-03f, -9.81138740e-03f, 2.79702187e-01f, -3.03730555e-02f, 2.52672374e-01f, 3.86425480e-02f, -3.26418042e-01f, -1.46294698e-01f, 2.74404228e-01f,
  2.49701291e-01f, 1.14699766e-01f, 2.11228542e-02f, -3.81386429e-01f, -1.85003325e-01f, -5.03953934e-01f, 3.15440558e-02f, -2.84650102e-02f, 9.84600000e-03f, -1.06403502e-02f,
  1.11858390e-01f, 6.61394522e-02f, 3.80064845e-02f, -7.64270723e-02f, -1.09440066e-01f, 2.62268027e-03f, 2.15081368e-02f, 8.27255771e-02f, -1.53283551e-02f, -9.44065303e-03f,
  -1.24936327e-01f, 3.05765681e-02f, -6.11444786e-02f, 1.52429447e-01f, 1.24392934e-01f, 3.78903031e-01f, -5.78594320e-02f, 1.22322701e-01f, -4.76577729e-02f, -4.33893263e-01f,
  -2.92178104e-03f, -4.33151945e-02f, 2.90437371e-01f, 5.87251224e-02f, 5.17054319e-01f, -3.18688065e-01f, 2.20148817e-01f, -4.98474628e-01f, -1.07574230e-02f, 5.40053546e-02f,
  4.36957777e-02f, 1.41566262e-01f, 1.48657024e-01f, 2.25765780e-01f, 1.13850191e-01f, 1.82529911e-01f, 5.06248958e-02f, 1.38491169e-01f, 2.94552445e-01f, -1.40507907e-01f,
  -9.98128131e-02f, 2.14118406e-01f, 3.37600373e-02f, -1.99185580e-01f, 9.20505449e-02f, 1.53466165e-01f, 5.43818772e-02f, 2.25863039e-01f, -5.27868085e-02f, -5.70518412e-02f,
  6.36889786e-02f, -2.43554726e-01f, -3.39272134e-02f, -2.87078202e-01f, -9.35521945e-02f, 1.38937339e-01f, 2.94198215e-01f, -5.69845200e-01f, -2.07132816e-01f, -1.40302917e-02f,
  -1.84153289e-01f, -6.93796575e-03f, 3.52945954e-01f, -5.99742010e-02f, -8.32121223e-02f, 3.64910178e-02f, -3.26705426e-02f, 2.62731224e-01f, -9.06620845e-02f, 3.67817461e-01f,
  -8.47272053e-02f, 3.34452361e-01f, 5.43489717e-02f, 2.38987401e-01f, -7.78846890e-02f, -2.16433823e-01f, -4.85566929e-02f, 3.06109488e-02f, -1.87160954e-01f, 1.60944805e-01f,
  -7.69954100e-02f, -1.75684527e-01f, 2.29365736e-01f, 4.93454218e-01f, -3.45036596e-01f, -7.76747847e-03f, -3.43991593e-02f, -3.06584448e-01f, -6.92283213e-02f, 1.38061062e-01f,
  2.40807623e-01f, 2.04647526e-01f, 9.19199437e-02f, 7.42683932e-02f, -7.96026811e-02f, -9.21511203e-02f, 4.51391861e-02f, 6.70829117e-02f, 1.09215481e-02f, 2.40247585e-02f,
  2.04595312e-01f, -1.82230696e-01f, 2.19581231e-01f, -3.74133080e-01f, -2.44449228e-01f, 3.35872978e-01f, -2.21932912e-03f, 1.87018793e-02f, 5.80087909e-03f, 1.55039519e-01f,
  1.71881869e-01f, 3.15346688e-01f, -1.88818574e-01f, 3.14910442e-01f, -1.12760082e-01f, -1.75014585e-01f, -5.00803471e-01f, 3.88251320e-02f, -2.78020471e-01f, 2.67825752e-01f,
  8.46664235e-02f, -3.51247400e-01f, 1.35758564e-01f, -6.23924024e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.50404269e-01f, 5.04194461e-02f, 3.39953542e-01f, 2.61006147e-01f, -4.53845300e-02f, 1.66945681e-01f, -7.22629949e-02f, 7.15994656e-01f, 6.03091538e-01f, 6.99120939e-01f,
  5.59908628e-01f, 5.03669381e-01f, 1.93247512e-01f, -1.17886804e-01f, 3.85708809e-02f, -2.54258722e-01f, 2.87187189e-01f, 8.20900500e-01f, 5.63596599e-02f, 8.65509689e-01f,
  -8.57397541e-02f, 4.04770263e-02f, -2.53134876e-01f, 3.73338640e-01f, -5.79495370e-01f, 3.03751558e-01f, 9.54896152e-01f, 1.83005348e-01f, 1.92350104e-01f, -9.66533005e-01f,
  -3.07994127e-01f, -1.48281977e-02f, 7.19607770e-02f, 1.53788179e-01f, 5.11605561e-01f, 2.18571723e-01f, 5.89097589e-02f, 1.25305295e-01f, 5.56712113e-02f, 7.75169671e-01f,
  8.63147452e-02f, 4.49217588e-01f, -6.99342787e-01f, 1.21181048e-01f, 1.63902730e-01f, -1.20609269e-01f, -8.30716416e-02f, 1.83920816e-01f, 2.57671118e-01f, 1.48520067e-01f,
  -1.12343729e-01f, -7.48053730e-01f, -2.14979976e-01f, -3.65037233e-01f, 1.20320070e+00f, -1.46378505e+00f, 6.30842388e-01f, 6.56059265e-01f, -2.18994588e-01f, 4.76352125e-02f,
  -2.80971557e-01f, -1.63269296e-01f, -4.27988589e-01f, 2.43120000e-01f, 1.20871015e-01f, -1.77103549e-01f, -1.80259958e-01f, 2.27743924e-01f, -3.40125244e-03f, 2.51634922e-02f,
  2.20276430e-01f, 1.96980715e-01f, -4.11429584e-01f, 9.32509750e-02f, 4.76440191e-01f, 2.42456764e-01f, 2.39172503e-01f, -3.11054349e-01f, 1.71358734e-01f, -1.69298455e-01f,
  1.03052132e-01f, 2.11661994e-01f, 4.32218574e-02f, 5.78675628e-01f, 3.09376448e-01f, -2.41821766e-01f, -1.91533267e-01f, 9.44855392e-01f, 2.02742144e-02f, -1.46499351e-01f,
  1.00702274e+00f, 7.12402284e-01f, -3.70793372e-01f, 8.27328920e-01f, 1.82267830e-01f, 1.90861121e-01f, 1.55000821e-01f, 1.69502974e-01f, 5.56145571e-02f, 3.52771521e-01f,
  3.09543729e-01f, 3.00320804e-01f, 3.46024334e-01f, 3.13868433e-01f, 1.41593637e-02f, 2.21185684e-01f, 3.10329556e-01f, 3.10874172e-02f, 2.27155820e-01f, 4.85028833e-01f,
  7.67918229e-02f, -5.13282895e-01f, 1.34291798e-01f, -1.53859928e-01f, 4.43160124e-02f, 1.36775851e-01f, 2.56677885e-02f, -3.92006516e-01f, 2.01768354e-01f, 7.50856459e-01f,
  4.49079245e-01f, 3.82388800e-01f, -4.52732779e-02f, -7.10732341e-01f, 3.50123584e-01f, -3.27696174e-01f, 1.18921012e-01f, 1.29185104e+00f, -2.63025351e-02f, 3.69560838e-01f,
  1.89434171e-01f, 9.15829688e-02f, -1.93640724e-01f, -1.71030104e-01f, -1.87458307e-01f, 6.08477414e-01f, 4.50387418e-01f, -2.74006397e-01f, -1.62586212e-01f, 5.54452896e-01f,
  1.25608698e-01f, -4.96707916e-01f, 2.41862521e-01f, 1.74879193e-01f, 1.92684755e-01f, -2.60763645e-01f, -2.53002495e-01f, -6.06047869e-01f, -5.18452413e-02f, -1.32177994e-01f,
  3.01665485e-01f, 1.45070016e-01f, 3.35345656e-01f, 7.46575892e-01f, -1.30141020e-01f, -1.64229751e-01f, 9.62596983e-02f, -1.92867234e-01f, 9.20975283e-02f, 8.14444423e-01f,
  -1.22770080e-02f, 6.55125856e-01f, 1.71795145e-01f, 2.82727540e-01f, -8.73910934e-02f, 2.09552720e-01f, -1.44739076e-01f, 4.62254584e-01f, 4.41815138e-01f, 4.69356775e-01f,
  2.95764327e-01f, 5.27321100e-01f, 3.51569265e-01f, 4.22399461e-01f, 1.40276596e-01f, -3.41097057e-01f, 2.92794257e-01f, 1.72519624e-01f, -2.84275174e-01f, -4.43801135e-02f,
  3.59210253e-01f, -4.80228335e-01f, 2.09561020e-01f, 8.51630211e-01f, -2.02926055e-01f, 2.38984808e-01f, 2.19229773e-01f, -8.71097576e-03f, -5.06637469e-02f, -5.92881665e-02f,
  -1.67979762e-01f, 1.58707118e+00f, 3.88660699e-01f, 1.92565247e-01f, 7.78614506e-02f, 1.47666708e-01f, -9.83839557e-02f, 4.88791853e-01f, 2.25289792e-01f, 1.32175833e-01f,
  4.11553979e-01f, 2.07547948e-01f, 1.18713826e-02f, 4.06367034e-01f, -1.91515923e-01f, 2.12347656e-01f, -1.68693885e-01f, 4.71224170e-03f, -2.74939179e-01f, -5.55951819e-02f,
  -2.17700437e-01f, -2.66055882e-01f, 7.98232332e-02f, 3.32467526e-01f, -9.34418440e-02f, -1.39281318e-01f, -1.21823214e-01f, 4.81413126e-01f, -4.97170508e-01f, 1.57411385e+00f,
  -7.54702985e-01f, 8.74700844e-01f, 3.09746027e-01f, -1.10783064e+00f, -6.90805390e-02f, 1.39357641e-01f, 4.58630830e-01f, 4.94573116e-02f, 1.25951702e-02f, 1.58264562e-01f,
  2.06639171e-01f, 2.46151447e-01f, -2.66362101e-01f, 2.83857938e-02f, -6.08889386e-03f, 7.36898363e-01f, 8.40229616e-02f, -7.69957483e-01f, -2.13643536e-01f, 4.04275477e-01f,
  3.26367468e-01f, -4.45737153e-01f, 3.43488939e-02f, 1.36929786e+00f, 6.96878076e-01f, -1.05668709e-01f, 8.49301293e-02f, -4.67762917e-01f, 1.80793494e-01f, 7.38660276e-01f,
  3.12861145e-01f, 1.50025055e-01f, 5.01621008e-01f, 5.74272931e-01f, -7.28790700e-01f, -3.59345049e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  5.43491900e-01f, 5.93776405e-01f, -4.75043952e-02f, 1.79766759e-01f, 8.71344432e-02f, -6.37572259e-02f, 3.23454976e-01f, 3.47421288e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  2.34847993e-01f, 2.62225479e-01f, -6.26442313e-01f, -7.41390884e-01f, -5.85728049e-01f, -3.04338157e-01f, -7.77638778e-02f, -3.16032022e-01f, -5.64579904e-01f, 4.09643322e-01f,
  -4.36163485e-01f, -1.04232311e+00f, -2.18936458e-01f, -3.61300856e-01f, -4.09202218e-01f, 8.41390789e-02f, -2.69132286e-01f, 4.05518532e-01f, 1.30145878e-01f, -4.93646175e-01f,
  -2.32049823e-01f, 6.22333884e-02f, 3.20653141e-01f, 3.33438069e-01f, -1.16888869e+00f, 9.81036425e-02f, 2.90301174e-01f, -9.06483382e-02f, 1.99610040e-01f, 1.80079326e-01f,
  -1.15786001e-01f, 2.14837879e-01f, 1.03601009e-01f, 3.06268752e-01f, -9.70751107e-01f, -1.05446529e+00f, 8.13101828e-01f, -5.66967249e-01f, -1.63239669e-02f, -3.40630531e-01f,
  6.86969832e-02f, -1.70347661e-01f, 6.20832682e-01f, 7.17568099e-02f, -1.82970166e-01f, 7.32572496e-01f, -6.32655263e-01f, -3.37760299e-01f, 1.60013258e-01f, -3.83909553e-01f,
  -4.64111954e-01f, -3.93514633e-01f, -4.22896855e-02f, -4.05156970e-01f, 3.36080611e-01f, -5.65627098e-01f, -6.57370329e-01f, -4.92557436e-01f, -1.78301036e-02f, 5.42394459e-01f,
  3.77161354e-01f, 4.47274625e-01f, -5.82725585e-01f, -1.13171935e+00f, 5.57076752e-01f, -2.34870479e-01f, -5.93852878e-01f, 3.83150458e-01f, -2.87637021e-02f, -1.99272364e-01f,
  2.07605824e-01f, -7.56056070e-01f, -1.77677780e-01f, 5.58419824e-01f, 9.30497721e-02f, 1.99242160e-01f, -1.45567805e-01f, 4.85038340e-01f, -9.87570286e-01f, 5.33820152e-01f,
  -6.97419286e-01f, -1.99765325e-01f, 4.40903127e-01f, -5.76862991e-01f, -1.06008983e+00f, -5.32616615e-01f, 5.84114432e-01f, -4.24417794e-01f, -3.53622615e-01f, -4.68211383e-01f,
  -1.75166979e-01f, -7.23172054e-02f, -3.11441153e-01f, 2.00306609e-01f, 7.35066175e-01f, -8.97590697e-01f, -9.12730768e-02f, -7.81524897e-01f, -3.54140066e-02f, 2.65984654e-01f,
  -7.73859799e-01f, 1.16321221e-01f, -1.22287166e+00f, -3.78282554e-02f, 2.63027072e-01f, -4.17123020e-01f, -1.81659833e-01f, -5.19367270e-02f, 1.61983538e-02f, -1.82254151e-01f,
  -2.21125051e-01f, -8.45078751e-02f, -1.55658096e-01f, 4.72332209e-01f, -2.57037729e-01f, 2.31885985e-01f, 4.14462239e-02f, -5.37373163e-02f, 5.54330237e-02f, -2.47519910e-01f,
  -9.58861485e-02f, -6.54936910e-01f, 6.12548172e-01f, -9.27851200e-01f, -9.49731588e-01f, -5.98892808e-01f, -1.51381372e-02f, 6.08407676e-01f, -4.68558788e-01f, 2.36310475e-02f,
  8.81796300e-01f, 1.19473279e+00f, 5.43352365e-01f, -1.49121076e-01f, 3.63885462e-01f, -1.76171064e-01f, 4.24636364e-01f, -1.57800123e-01f, 1.11193970e-01f, 5.48260212e-01f,
  4.00246322e-01f, -8.88993561e-01f, 5.92855692e-01f, -9.18444335e-01f, -5.33647180e-01f, -4.69039381e-02f, 6.60306096e-01f, 8.50912392e-01f, -5.68473876e-01f, -5.68613172e-01f,
  -4.64469828e-02f, -4.71713915e-02f, -1.34278864e-01f, 3.44473124e-01f, -2.17673436e-01f, -2.06596553e-01f, 4.22642350e-01f, -4.57891792e-01f, 9.77059081e-02f, 2.04287767e-01f,
  9.11486000e-02f, 4.72756028e-01f, 1.22960426e-01f, 6.62954450e-01f, -6.87971532e-01f, 5.50174177e-01f, -3.39957252e-02f, 6.69106781e-01f, 4.51627016e-01f, 3.53754938e-01f,
  -9.77349132e-02f, -3.10547054e-01f, -2.31542289e-01f, -3.24257404e-01f, 8.73500034e-02f, -4.43640769e-01f, 4.87958342e-01f, 7.99579203e-01f, -1.09908946e-01f, -1.30639747e-01f,
  -8.13890874e-01f, 3.77428859e-01f, 6.38661146e-01f, -7.13459998e-02f, 3.24325889e-01f, 3.54956567e-01f, -9.81825948e-01f, 2.32891828e-01f, 1.17129877e-01f, 3.86897177e-01f,
  -8.92434597e-01f, 1.74284533e-01f, 2.79231668e-01f, -6.60499394e-01f, 5.01062691e-01f, -6.29372120e-01f, -2.74972856e-01f, -2.13787213e-01f, 4.81385857e-01f, 4.32005912e-01f,
  -4.13897336e-02f, -4.54052955e-01f, 1.08323321e-01f, 1.71247303e-01f, -8.07166636e-01f, 2.01879784e-01f, 7.32565343e-01f, 2.51864821e-01f, 4.73081440e-01f, -4.46096778e-01f,
  -7.28081107e-01f, -7.45605469e-01f, 1.24692965e+00f, 3.43791544e-01f, -4.50192600e-01f, -6.09336853e-01f, -7.80328393e-01f, 8.42620134e-01f, -6.60655737e-01f, 3.21577072e-01f,
  -3.07198822e-01f, -1.28106701e+00f, -1.38727868e+00f, -1.20864749e-01f, -3.32588047e-01f, -5.52398384e-01f, -3.22695337e-02f, -4.98587698e-01f, 3.42288688e-02f, -2.68699139e-01f,
  2.76386812e-02f, 2.72270858e-01f, -1.99889988e-01f, -2.45564520e-01f, -4.90772158e-01f, -5.60806572e-01f, 1.12156361e-01f, -5.86786091e-01f, 5.41764021e-01f, 1.34105295e-01f,
  -5.64426064e-01f, -1.63824752e-01f, -6.80135012e-01f, -5.09801023e-02f, 4.14135635e-01f, 4.94375855e-01f, -3.99632633e-01f, 6.94969475e-01f, -3.22320402e-01f, -1.13037014e+00f,
  4.60664332e-01f, -1.48386955e-01f, 5.24651855e-02f, -8.18729877e-01f, 7.97913194e-01f, -1.19694054e+00f, -4.71816808e-01f, -3.31481159e-01f, 3.27165872e-01f, 5.28920352e-01f,
  1.68357402e-01f, -1.80736095e-01f, 6.49576932e-02f, 2.11148486e-01f, -9.33885455e-01f, -7.19164193e-01f, -3.63639146e-02f, 4.35568601e-01f, 1.00986564e+00f, 1.78722650e-01f,
  9.50033367e-01f, 5.25113106e-01f, 1.37722686e-01f, -2.60240585e-01f, 6.86404884e-01f, -3.71061623e-01f, 7.80031025e-01f, 4.88212645e-01f, 7.17615068e-01f, 9.71758485e-01f,
  7.04884887e-01f, -1.38274741e+00f, -5.97369373e-02f, 3.96192402e-01f, -3.47071320e-01f, 4.32072729e-01f, -1.43565103e-01f, -1.03640413e+00f, -7.16445267e-01f, 5.11149347e-01f,
  6.86907351e-01f, 1.43326983e-01f, 4.43856329e-01f, 4.18666005e-01f, -2.00129837e-01f, 3.46160680e-01f, 6.31086707e-01f, 8.01947534e-01f, -1.71080381e-01f, 3.13703418e-01f,
  -2.10332558e-01f, 3.58520508e-01f, -6.34736776e-01f, 3.82458866e-01f, 4.82405961e-01f, -1.45812184e-01f, -7.36325562e-01f, -3.35624307e-01f, 2.28884190e-01f, -5.66401303e-01f,
  -1.74108088e-01f, 8.99814349e-03f, -9.17982817e-01f, 7.91445315e-01f, -1.05458760e+00f, -1.00077128e+00f, 7.47098029e-02f, -7.46407688e-01f, 6.14902318e-01f, -7.07247436e-01f,
  5.99143170e-02f, -1.90969318e-01f, -1.16400532e-01f, 3.06030184e-01f, -1.09832346e-01f, -4.01081651e-01f, -8.36232126e-01f, -3.19657505e-01f, -1.37609378e-01f, 2.24423021e-01f,
  1.72194820e-02f, -6.97045207e-01f, 3.22100580e-01f, -5.54654717e-01f, -8.24210644e-01f, -3.97979379e-01f, 8.53154838e-01f, -5.02967358e-01f, -2.42365763e-01f, 7.88956523e-01f,
  5.14997005e-01f, -6.68872297e-01f, -2.82051098e-02f, -7.19772816e-01f, 9.33389664e-01f, -4.79269236e-01f, 3.96348149e-01f, -5.82315803e-01f, -1.36511967e-01f, 2.17007414e-01f,
  -1.32672203e+00f, -4.18753177e-01f, 5.00503659e-01f, 3.95269603e-01f, -4.02104437e-01f, -1.99478462e-01f, 4.72266644e-01f, 6.30016148e-01f, 4.06516999e-01f, 7.55244568e-02f,
  -4.69823778e-01f, -5.74196160e-01f, 4.88652848e-02f, 3.75197858e-01f, 5.60339540e-02f, 9.91383433e-01f, 5.64227104e-01f, 4.12750453e-01f, 7.72305250e-01f, 1.95887804e-01f,
  2.54300863e-01f, 7.80917168e-01f, -3.22863191e-01f, 7.17192054e-01f, -9.94888783e-01f, 6.66646183e-01f, 1.03056587e-01f, -5.51546752e-01f, -6.24614358e-01f, -2.86638588e-01f,
  -2.40579814e-01f, -6.91786528e-01f, -2.67425776e-01f, 1.24676669e+00f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -4.21089441e-01f, -4.57243361e-02f, 2.58308887e-01f, -3.92104805e-01f, 1.47116736e-01f, -1.19157985e-01f, 3.50994140e-01f, -2.79149383e-01f, -1.29749984e-01f, 1.98779583e-01f,
  -5.58582902e-01f, 3.19397390e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    