/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.80067709e-02f, 7.24330619e-02f, -9.32459608e-02f, 2.47032605e-02f, -3.71837243e-02f, -6.09754026e-02f, 4.10073698e-02f, -1.81746681e-03f, -5.61775938e-02f, -1.56475361e-02f,
  6.07955940e-02f, -4.05714586e-02f, -5.33706881e-02f, -5.80547936e-02f, 6.31390736e-02f, 9.85902734e-03f, -1.21510150e-02f, -1.27444640e-01f, 4.64339927e-03f, 4.56576087e-02f,
  -6.46205945e-03f, -7.00541586e-02f, -1.03900813e-01f, -9.63439234e-03f, -7.16272444e-02f, 7.62865618e-02f, -3.85130867e-02f, 4.43354510e-02f, 2.10532248e-02f, -8.79476294e-02f,
  -2.75580250e-02f, 3.01987734e-02f, 6.11335970e-02f, 1.17519505e-01f, 2.91285757e-02f, -2.14047637e-02f, -8.42719227e-02f, -1.39034456e-02f, 7.56562948e-02f, -7.39850774e-02f,
  6.13683276e-02f, 2.26313211e-02f, 6.00900985e-02f, -6.22377582e-02f, -1.79652381e-03f, 2.35739220e-02f, -7.50483200e-02f, 6.94001988e-02f, -2.50163898e-02f, -1.98516473e-02f,
  6.57976568e-02f, -3.53906415e-02f, -3.75723802e-02f, -3.77779193e-02f, 6.80988207e-02f, 8.13125372e-02f, 8.93162638e-02f, 4.78180964e-03f, 9.51824710e-02f, -9.48957205e-02f,
  2.22372226e-02f, -3.93720791e-02f, 1.27327710e-01f, 1.75960679e-02f, 3.94221805e-02f, 4.81655113e-02f, 6.41917810e-02f, -2.86430921e-02f, 9.88321751e-02f, -8.08529463e-03f,
  -6.27409965e-02f, -4.60075662e-02f, 7.84700513e-02f, 9.11935940e-02f, 2.30792947e-02f, 7.94173479e-02f, -2.96879932e-02f, 2.64231730e-02f, 1.24094589e-02f, 5.33721745e-02f,
  1.69881608e-03f, 4.03214134e-02f, 5.43183684e-02f, -4.65631261e-02f, 2.88717747e-02f, 3.78234219e-03f, 1.34007722e-01f, -1.86055265e-02f, 3.92684862e-02f, -1.37642473e-02f,
  -4.91752960e-02f, 7.09622428e-02f, 1.48018980e-02f, -9.72903445e-02f, -7.59827346e-02f, 4.64700498e-02f, 7.48333614e-03f, -8.85201693e-02f, -4.05160785e-02f, -3.27782310e-03f,
  5.71413664e-03f, 2.22407514e-03f, -9.36925188e-02f, 9.80999507e-03f, -7.36461133e-02f, 3.19300182e-02f, 1.17414296e-01f, -6.53390735e-02f, -3.18523869e-02f, -3.97006283e-03f,
  -7.91368484e-02f, -5.24470843e-02f, 4.03815135e-02f, -3.79261710e-02f, 8.90326574e-02f, 1.27657186e-02f, 5.45143150e-02f, -3.66442720e-03f, -6.33125752e-02f, -7.73878768e-02f,
  -2.71857083e-01f, 1.49893254e-01f, -2.12476268e-01f, 2.37857148e-01f, 5.44676594e-02f, -1.68135256e-01f, -1.05094880e-01f, -2.01056805e-03f, 5.20807616e-02f, 1.43568099e-01f,
  1.47398263e-01f, 9.73698720e-02f, 7.29957446e-02f, -4.63635623e-02f, -8.66485238e-02f, -5.34006841e-02f, -1.13217533e-01f, -2.75311351e-01f, -3.49404067e-01f, -9.42896530e-02f,
  9.69046652e-02f, 8.58993158e-02f, -1.01126246e-01f, -1.06443308e-01f, 1.35550216e-01f, -9.45577025e-02f, -6.67488053e-02f, -2.66880961e-04f, -4.22653556e-02f, 1.53569013e-01f,
  3.18691805e-02f, 5.41724488e-02f, -2.73120273e-02f, -1.36684934e-02f, 4.52373959e-02f, -2.65983623e-02f, -2.69036870e-02f, -4.26857024e-02f, -7.88794905e-02f, 8.72103944e-02f,
  3.33874822e-02f, 7.52872378e-02f, -4.51974906e-02f, 2.12876815e-02f, -3.40006524e-03f, -3.48020196e-02f, 1.46667343e-02f, -7.50522241e-02f, -1.86809022e-02f, -4.35242131e-02f,
  1.56118767e-02f, 6.37356639e-02f, -3.65155982e-03f, 1.04332976e-01f, -7.01168776e-02f, -1.88147824e-03f, 7.42245540e-02f, -6.76267780e-03f, 1.81681011e-02f, 5.10249771e-02f,
  4.79288138e-02f, 1.97987128e-02f, -4.31133844e-02f, -2.45947100e-04f, 4.15009260e-02f, 4.40608449e-02f, 1.86000597e-02f, 2.23657675e-03f, 1.27728703e-02f, -1.60910841e-02f,
  2.64048036e-02f, 8.84821191e-02f, -6.27371892e-02f, 5.41327614e-03f, -1.45451901e-02f, 2.68498603e-02f, -1.95050836e-02f, 6.56122789e-02f, -1.68463644e-02f, -4.09894623e-02f,
  4.00561504e-02f, -6.35040412e-03f, -6.81047365e-02f, 1.59927309e-02f, 2.16973876e-03f, -2.39896849e-02f, -9.56394302e-04f, -8.60764273e-03f, -2.37677861e-02f, 4.04550657e-02f,
  -1.59405842e-02f, -1.37621328e-01f, -3.22310429e-04f, 2.04809606e-02f, -8.81109610e-02f, -2.30855085e-02f, 6.43081218e-02f, -6.65571308e-03f, 7.13698193e-02f, 5.53463213e-02f,
  9.46705267e-02f, -3.21876481e-02f, 5.48301972e-02f, 7.61965523e-03f, 1.55995563e-02f, 2.09979992e-02f, 4.26892601e-02f, -6.40176609e-02f, -2.56841928e-02f, 3.36443670e-02f,
  9.79833975e-02f, 3.61166708e-02f, 4.89562796e-03f, 2.73266844e-02f, 2.54779658e-03f, -8.27738643e-02f, -3.46144624e-02f, -5.55277020e-02f, -1.30056590e-01f, 4.82907370e-02f,
  1.48737729e-02f, -9.35274661e-02f, -2.48739570e-01f, -1.26576439e-01f, -8.67962092e-02f, -2.38401033e-02f, -1.70294538e-01f, 3.19461152e-02f, 3.72255258e-02f, -5.93132805e-03f,
  3.91410924e-02f, 5.83198667e-02f, 3.25095393e-02f, 5.11158668e-02f, 8.25285017e-02f, -8.00814629e-02f, -3.18188965e-02f, -4.05664276e-03f, 1.13124080e-01f, 2.16145795e-02f,
  -1.42410127e-02f, 1.21652059e-01f, -4.40264121e-02f, 4.24780734e-02f, 3.03557534e-02f, -1.12533858e-02f, -8.67996216e-02f, -6.41526356e-02f, -1.49361836e-02f, -1.31173939e-01f,
  -2.82459776e-03f, -1.03823856e-01f, 4.04748740e-03f, 1.69593170e-02f, -1.46023273e-01f, -7.45824948e-02f, 5.03745303e-02f, -4.67788763e-02f, -4.36044745e-02f, -6.39310777e-02f,
  5.28860949e-02f, -3.63502055e-02f, -7.15259016e-02f, 7.05826730e-02f, 6.82584792e-02f, -5.78295700e-02f, 5.51422648e-02f, -7.34247938e-02f, 5.92575185e-02f, -1.32874653e-01f,
  3.17481123e-02f, -8.85005221e-02f, -4.87767756e-02f, -1.15359530e-01f, 3.50530967e-02f, -5.15136272e-02f, -2.60021593e-02f, -2.73864865e-02f, 1.77825484e-02f, -2.75969431e-02f,
  -6.65161982e-02f, 3.69392261e-02f, -2.39432994e-02f, -2.03543454e-02f, 7.17968643e-02f, -4.22947016e-03f, -7.54111707e-02f, 6.32309616e-02f, 4.38203523e-03f, 8.50179344e-02f,
  -1.13066219e-01f, -8.40300694e-03f, -3.03387307e-02f, 8.60117469e-03f, 6.83783740e-02f, -5.80067262e-02f, 5.39347418e-02f, -2.06113178e-02f, 2.83298306e-02f, 6.01994656e-02f,
  1.64028071e-02f, 1.22393742e-02f, 4.86088730e-02f, 3.57964933e-02f, -7.91184530e-02f, 3.32050808e-02f, -2.62327529e-02f, 3.31895389e-02f, -2.20478158e-02f, -5.55683002e-02f,
  1.79381594e-01f, -9.34778005e-02f, 7.37242252e-02f, 3.83364037e-02f, -4.56571393e-02f, 6.30701408e-02f, 6.58114254e-02f, -1.57353878e-02f, -1.21912477e-03f, 2.01655999e-02f,
  -8.99070054e-02f, 1.75730849e-03f, 9.10514146e-02f, -6.26485124e-02f, -3.93931083e-02f, -3.96706201e-02f, 1.34457275e-01f, 5.27053513e-03f, 6.16200380e-02f, -4.20419872e-02f,
  8.72436631e-03f, -2.44269893e-02f, -1.69938360e-03f, 3.98792438e-02f, 6.60814345e-02f, 6.70151338e-02f, -2.46961527e-02f, 7.69216865e-02f, 9.29893255e-02f, 1.32116690e-01f,
  2.50154976e-02f, 1.94005016e-02f, 7.56028667e-02f, 3.20964903e-02f, 9.20294374e-02f, 8.50814134e-02f, -4.86013591e-02f, -1.10264413e-01f, -6.44916445e-02f, 8.33647400e-02f,
  -9.01600793e-02f, 5.00149801e-02f, 2.40960661e-02f, -3.17424759e-02f, 3.32325101e-02f, 4.46048379e-02f, 1.09917834e-01f, 1.75998118e-02f, 1.03244651e-03f, -1.27420917e-01f,
  2.60693710e-02f, 5.48623167e-02f, -3.84021774e-02f, -1.96674541e-02f, 9.34865102e-02f, 8.56398698e-03f, 7.68920332e-02f, 1.39739782e-01f, 5.59212305e-02f, 2.59565264e-01f,
  2.13570848e-01f, -5.29679283e-02f, -2.22141594e-02f, 4.74218167e-02f, -8.48101918e-04f, -6.22102469e-02f, -4.99971546e-02f, 1.87180806e-02f, -1.01258777e-01f, 4.75752838e-02f,
  7.96098784e-02f, -1.03584304e-01f, 8.98081362e-02f, -1.67948361e-02f, 6.43070117e-02f, -8.52786079e-02f, -1.19695738e-01f, -1.32150754e-01f, -8.22730288e-02f, -4.46250141e-02f,
  7.51309320e-02f, -8.49576071e-02f, -1.79487150e-02f, -1.02855735e-01f, -2.73208953e-02f, -4.99737114e-02f, -7.48128593e-02f, 1.78343225e-02f, 4.55847867e-02f, -5.82230948e-02f,
  -3.92324179e-02f, 3.82180735e-02f, -3.19973491e-02f, -6.41113669e-02f, 9.86032039e-02f, -5.29383831e-02f, 5.67386448e-02f, 5.78228757e-02f, 1.01070683e-02f, -6.16369322e-02f,
  -6.85590655e-02f, -1.86380204e-02f, -3.85413729e-02f, -8.92614052e-02f, -2.09581871e-02f, -3.87599207e-02f, 4.03092876e-02f, 3.78436083e-03f, -5.09966128e-02f, 1.01891480e-01f,
  5.34979114e-03f, 6.25884086e-02f, 2.17154901e-03f, -2.33659334e-02f, 4.00208123e-02f, -2.52239518e-02f, -5.49034439e-02f, 3.65807116e-02f, -4.75158170e-02f, -5.41211339e-04f,
  -1.39644342e-02f, 4.51088622e-02f, 1.77398119e-02f, -2.04424132e-02f, -5.72640402e-03f, 2.97374334e-02f, 7.11522400e-02f, -1.37407230e-02f, 2.70352252e-02f, 3.77798006e-02f,
  -6.71918392e-02f, -4.37267832e-02f, 1.50003657e-01f, -6.45139813e-02f, -1.21509787e-02f, 4.25849780e-02f, -4.86241765e-02f, 1.24131748e-02f, 3.28932106e-02f, -1.67075992e-02f,
  3.65396999e-02f, 6.94665313e-02f, -2.31049210e-02f, 4.46879334e-04f, -1.83834098e-02f, 8.54436383e-02f, 2.83094794e-02f, -2.15724874e-02f, 4.45245020e-03f, -5.46986535e-02f,
  -3.39525826e-02f, 2.02860937e-01f, -3.35708648e-01f, 6.82145124e-03f, -2.28623316e-01f, -1.91385671e-01f, -2.68216431e-01f, 4.65888940e-02f, 7.05672055e-02f, -9.20892134e-02f,
  7.34033510e-02f, 4.11353931e-02f, 9.14278701e-02f, 1.00798115e-01f, 5.63744791e-02f, -4.66266125e-02f, 2.65960377e-02f, -4.57701087e-02f, -1.65688112e-01f, -7.38392696e-02f,
  -7.96057004e-03f, 1.62010372e-01f, 1.84328049e-01f, 5.23406155e-02f, 1.07408576e-01f, -1.44615337e-01f, 8.97218809e-02f, 8.13736394e-02f, -1.07934058e-01f, 1.83360472e-01f,
  -1.46891207e-01f, 8.45007971e-02f, -5.96406087e-02f, 1.22236677e-01f, 4.04540561e-02f, 1.55457323e-02f, -2.51845270e-02f, 1.35532975e-01f, -7.05708889e-03f, -5.07450029e-02f,
  5.71016893e-02f, 1.07967682e-01f, 6.68754280e-02f, 2.00236216e-02f, 1.71815089e-04f, -1.84079129e-02f, 1.31671205e-01f, 1.15874209e-01f, 3.63606364e-02f, 7.07829371e-02f,
  6.42409176e-02f, -5.82250468e-02f, -1.52221620e-02f, -1.38237420e-02f, 4.32734936e-02f, -2.79965345e-02f, -5.27259186e-02f, 3.00394800e-02f, 1.78910140e-02f, 1.41981378e-01f,
  -4.45039682e-02f, 1.01876659e-02f, -4.78829071e-02f, 2.45155338e-02f, -2.83973925e-02f, -5.71338609e-02f, -1.23912254e-02f, 8.96789357e-02f, 2.73926947e-02f, 4.28388864e-02f,
  -1.33687351e-02f, -3.74941118e-02f, -2.16345638e-02f, 2.79066600e-02f, 1.76655948e-02f, -1.85153410e-02f, -6.25515655e-02f, 3.06698158e-02f, -7.32200686e-03f, -3.61147933e-02f,
  4.03525494e-03f, -3.98550667e-02f, 3.57034244e-03f, -3.69902154e-05f, 4.06517535e-02f, 1.05200941e-02f, 4.60677641e-03f, 6.54221922e-02f, 5.91599271e-02f, -8.45800340e-03f,
  2.00412139e-01f, -4.19309251e-02f, 2.39072889e-02f, -2.81455368e-02f, -7.10287169e-02f, 6.26965836e-02f, -7.51015320e-02f, 9.49421339e-03f, -4.38210405e-02f, -1.21393399e-02f,
  -6.74652867e-03f, 1.95935164e-02f, 2.17495463e-03f, 3.27066658e-03f, -2.78048739e-02f, -7.55714849e-02f, 1.52646620e-02f, -6.09230436e-02f, 1.15896687e-01f, 4.46318928e-03f,
  7.35804439e-02f, -9.88594294e-02f, -1.21462852e-01f, -1.05753243e-01f, 6.66120350e-02f, -2.35053711e-02f, -5.22102900e-02f, -2.12054942e-02f, -1.09165438e-01f, -6.99607655e-02f,
  2.11259469e-01f, -1.26748860e-01f, -1.24325482e-02f, -3.06021841e-03f, -6.57470599e-02f, 8.97178948e-02f, 4.14568521e-02f, 1.36400118e-01f, 2.91295741e-02f, -6.92880750e-02f,
  -4.04894352e-02f, -1.35138169e-01f, -1.05525460e-02f, -2.07395684e-02f, -3.90111022e-02f, -2.96228696e-02f, -1.73149988e-01f, -6.78515658e-02f, 3.90069336e-02f, -7.01408759e-02f,
  -5.29297581e-03f, 6.53404742e-02f, 7.07214046e-03f, -7.60925859e-02f, -4.45233174e-02f, -2.48218179e-02f, -1.50676325e-01f, -1.38855189e-01f, -2.63596047e-02f, -2.03543916e-01f,
  5.14535196e-02f, -4.02792916e-02f, 5.71402088e-02f, 6.84562474e-02f, 4.95413411e-03f, 4.30879220e-02f, -3.01678572e-02f, 4.24148329e-02f, 5.83264790e-02f, 8.42200220e-02f,
  3.05607659e-03f, 1.84151977e-02f, -7.34046847e-02f, -6.88669039e-03f, 3.51592191e-02f, 2.25932021e-02f, 6.15231320e-02f, 1.91562660e-02f, 7.17965588e-02f, 9.54898372e-02f,
  -2.01413613e-02f, -8.53603648e-04f, 8.41618627e-02f, -3.71316299e-02f, -3.33718844e-02f, -2.15207078e-02f, 1.03120347e-02f, -6.25277385e-02f, -1.30570950e-02f, -6.34090528e-02f,
  -2.05439124e-02f, 2.34558545e-02f, 1.61114410e-02f, 2.45253351e-02f, 2.23496766e-03f, 3.75418477e-02f, -2.08630450e-02f, -3.75538208e-02f, -5.56309149e-02f, -3.48531380e-02f,
  1.44939736e-01f, -6.57742471e-02f, -6.53279349e-02f, 3.00966501e-02f, 2.92474125e-02f, 2.41490863e-02f, -5.14796898e-02f, -1.17102787e-02f, 5.39218374e-02f, 5.16858846e-02f,
  -5.92245534e-02f, 3.70929912e-02f, 6.39502853e-02f, 4.24535684e-02f, -1.24552377e-01f, -1.03791960e-01f, 6.41575232e-02f, -9.73851085e-02f, -6.47727028e-02f, -8.11106488e-02f,
  2.32540555e-02f, 7.30970204e-02f, -6.27240688e-02f, -6.52518868e-02f, -4.45146486e-02f, -2.52549723e-02f, -3.98215763e-02f, 2.14321204e-02f, 1.43928267e-02f, 5.12525477e-02f,
  6.89802468e-02f, 2.64883861e-02f, -1.59616675e-02f, 9.80505943e-02f, 1.10527471e-01f, 2.85875034e-02f, -7.91239887e-02f, -5.57605848e-02f, -4.12286483e-02f, 9.44915190e-02f,
  4.07562368e-02f, -1.86783765e-02f, 2.57637464e-02f, 1.20234929e-01f, 5.61648421e-02f, -2.98238738e-04f, -3.14719751e-02f, -1.92384832e-02f, 1.13228895e-01f, 1.26014993e-01f,
  3.80967081e-01f, 7.86043555e-02f, 1.16960809e-01f, 1.25153095e-01f, 1.56404391e-01f, 9.48381200e-02f, 2.44929716e-01f, 2.45446302e-02f, 7.60811940e-02f, 2.03685626e-01f,
  1.30078182e-01f, -4.50586863e-02f, 1.80778533e-01f, -1.15308903e-01f, 1.11863680e-01f, 1.21893950e-01f, 1.39671683e-01f, 1.63331673e-01f, -9.13173985e-03f, -1.09702125e-01f,
  -1.12371165e-02f, 9.18352455e-02f, 1.29723512e-02f, -8.39529112e-02f, 2.21339036e-02f, -8.92442018e-02f, 4.10994701e-03f, 2.10242961e-02f, -3.79747003e-02f, 3.52096036e-02f,
  1.67837797e-03f, 1.14455335e-01f, -1.16197720e-01f, -1.33292507e-02f, 4.50406596e-02f, 1.79883689e-02f, -6.08252641e-03f, -6.28198683e-02f, 2.95374263e-02f, -8.62355083e-02f,
  2.57098693e-02f, -1.36557579e-01f, 1.00751109e-01f, 1.07797293e-03f, 1.20806647e-02f, 3.20270397e-02f, -1.38469273e-02f, 1.93674471e-02f, -1.32565107e-02f, -7.43203610e-02f,
  7.49661922e-02f, 5.36622182e-02f, -7.14246333e-02f, -8.13258812e-02f, -1.62292700e-02f, -8.80889315e-03f, -4.99596335e-02f, -9.25398991e-02f, -6.58953786e-02f, -1.34265453e-01f,
  -3.50787900e-02f, -1.43736536e-02f, 8.88247881e-03f, -6.58584461e-02f, 4.39739926e-03f, 2.76666172e-02f, 6.95760697e-02f, -8.13132226e-02f, 9.92877781e-03f, 3.65392491e-02f,
  -7.25456774e-02f, 3.70457433e-02f, -3.10951974e-02f, 3.90872220e-03f, -1.46350898e-02f, -2.24104822e-02f, 3.07342559e-02f, -2.94946171e-02f, -7.59248249e-03f, -4.62523773e-02f,
  -4.61890884e-02f, 2.69334894e-02f, 4.53372896e-02f, -4.82315049e-02f, -1.25806415e-02f, -9.76117421e-03f, 1.76911969e-02f, -5.40505461e-02f, 4.87535782e-02f, 1.61196925e-02f,
  1.80521421e-02f, 9.92912427e-02f, -5.58200739e-02f, 8.78432952e-03f, 4.93309461e-04f, 1.50672887e-02f, -1.79630350e-02f, -5.89395650e-02f, 6.31812215e-02f, -1.35798315e-02f,
  4.61739302e-03f, 2.38200594e-02f, 9.71632078e-03f, -1.12814963e-01f, 4.46654037e-02f, 5.05076628e-03f, -3.04015893e-02f, 5.22282571e-02f, -1.24288149e-01f, -2.67570317e-02f,
  -6.28802786e-03f, 4.39778902e-03f, -1.18921138e-01f, -1.13465581e-02f, -2.98232064e-02f, 1.37511596e-01f, -4.06504720e-02f, -9.28880367e-03f, 3.32570262e-02f, -7.25557804e-02f,
  4.71991479e-01f, -2.22726122e-01f, -3.73706892e-02f, 7.43362382e-02f, -1.10737376e-01f, -2.45604128e-01f, -1.37673989e-01f, -9.34062246e-03f, 2.48969179e-02f, 5.79649210e-02f,
  -1.62086323e-01f, 1.29358247e-01f, 6.57151267e-02f, 9.94805843e-02f, 1.50259331e-01f, 2.69610230e-02f, -7.30308890e-02f, 1.04134500e-01f, 1.27546728e-01f, -4.69298810e-02f,
  -2.85178311e-02f, 1.18318394e-01f, 2.37623125e-01f, 1.42403200e-01f, -8.79631191e-02f, 1.25857517e-01f, 3.59213799e-02f, -9.62944925e-02f, -5.89730479e-02f, -9.61690620e-02f,
  4.60424349e-02f, 3.24338186e-03f, 3.53599302e-02f, -1.33543387e-02f, -1.19967088e-01f, 5.14535643e-02f, -4.06404249e-02f, 8.10481049e-03f, 4.67150323e-02f, -1.03359474e-02f,
  -3.57447416e-02f, -3.17039080e-02f, -8.13953057e-02f, -3.07800751e-02f, -3.56336758e-02f, 5.24600334e-02f, 3.43450867e-02f, 1.17941899e-02f, 3.20732184e-02f, 4.27650809e-02f,
  -1.35975286e-01f, -1.90089837e-01f, 2.41375007e-02f, -4.82232459e-02f, 1.53739890e-02f, 8.62271525e-03f, -1.42593158e-03f, 1.23805674e-02f, 5.29423691e-02f, 1.49102375e-01f,
  2.03038603e-02f, -2.23654807e-02f, -4.44694795e-02f, -7.31188133e-02f, 7.51206577e-02f, -6.40181899e-02f, -2.51022168e-03f, 3.22560556e-02f, 3.95348668e-02f, -1.19384024e-02f,
  -2.18894575e-02f, -3.04590736e-04f, -6.49106596e-03f, 1.71763748e-02f, 1.74065214e-02f, -4.41792905e-02f, 3.44010699e-03f, 1.12689443e-01f, -1.01585388e-01f, 9.49641690e-02f,
  6.86936360e-03f, -2.45286413e-02f, -1.28721334e-02f, 3.07227336e-02f, -5.83618395e-02f, -2.30404548e-03f, -4.05651815e-02f, 2.29977593e-02f, -3.53643261e-02f, 6.40853867e-02f,
  3.33252698e-01f, -1.98173821e-01f, 9.13933218e-02f, 9.77549553e-02f, 8.01126808e-02f, 1.68949682e-02f, -3.39432545e-02f, -2.04776339e-02f, -8.30796286e-02f, 5.88331893e-02f,
  -6.45534135e-03f, 1.45216985e-02f, 5.30229658e-02f, 7.64533645e-03f, -6.10426292e-02f, 4.66401763e-02f, -5.75709790e-02f, 8.69271681e-02f, -2.68053673e-02f, 3.49965543e-02f,
  1.99115742e-02f, 1.72133520e-01f, 2.45551512e-01f, 4.84994166e-02f, -1.53406002e-02f, 7.22455680e-02f, 1.04604140e-01f, 1.27953202e-01f, 1.11801110e-01f, 4.02093053e-01f,
  -5.98047733e-01f, 3.62112105e-01f, -1.22175239e-01f, -1.39979377e-01f, 2.44688075e-02f, -3.72933112e-02f, 1.93217501e-01f, -1.40955016e-01f, -1.64255142e-01f, -5.24722273e-03f,
  8.62625763e-02f, -2.35496592e-02f, -7.41564408e-02f, -6.86653405e-02f, -2.84176450e-02f, 5.64023256e-02f, -4.01164368e-02f, -1.91758648e-01f, -1.70467407e-01f, 1.36273444e-01f,
  2.10106522e-01f, -6.97604343e-02f, -2.02206969e-01f, 8.00872371e-02f, 1.61178529e-01f, -9.77983400e-02f, 2.72722989e-02f, -1.76322777e-02f, 1.29183382e-01f, -1.27778515e-01f,
  9.53653827e-02f, -8.59440342e-02f, -7.30485693e-02f, -4.45933156e-02f, 4.39598560e-02f, -1.13081165e-01f, 1.78005993e-02f, -9.66325402e-02f, -3.38485057e-04f, 2.87595615e-02f,
  8.58104452e-02f, 6.24210760e-02f, -4.20088501e-04f, 5.83344419e-03f, -1.76662244e-02f, -5.67341000e-02f, -4.61063907e-02f, -4.41703014e-02f, -9.52923819e-02f, 5.87539524e-02f,
  9.40357298e-02f, 9.28566679e-02f, 6.53217733e-02f, 4.12642695e-02f, -4.44926880e-02f, -1.33391153e-02f, 8.30240399e-02f, 3.24504226e-02f, -9.27617922e-02f, 8.93487185e-02f,
  5.85341938e-02f, 6.39911070e-02f, -8.02678708e-03f, 7.45213553e-02f, -1.18816048e-01f, 5.77711724e-02f, 9.35445204e-02f, -6.35452569e-03f, -2.81479843e-02f, 6.32945541e-03f,
  -1.29996352e-02f, -5.36166094e-02f, -2.50506364e-02f, -3.83230112e-02f, 2.48198677e-02f, -6.91504553e-02f, 5.49177602e-02f, -2.79602017e-02f, -2.46512983e-02f, -7.96960481e-03f,
  -4.01063077e-03f, -1.38837248e-02f, 5.85377142e-02f, 6.83095902e-02f, -4.51842835e-03f, -9.10705980e-03f, -5.94110824e-02f, 5.89488298e-02f, -5.59798516e-02f, -4.67755906e-02f,
  1.58120990e-01f, -1.63099840e-01f, 1.62090510e-02f, 5.38305826e-02f, -6.88413973e-04f, -1.89981312e-02f, 3.73992808e-02f, 6.07381426e-02f, -5.91319753e-03f, 4.19126004e-02f,
  2.88081598e-02f, 4.12327610e-02f, 1.44834900e-02f, 5.83880283e-02f, 3.30464765e-02f, -4.85821702e-02f, -2.36170795e-02f, -2.47433353e-02f, -5.27271777e-02f, -7.75960088e-03f,
  -4.15007176e-04f, -7.81215429e-02f, -4.25604992e-02f, 4.23935503e-02f, 1.69510823e-02f, -1.19635858e-01f, 6.90702423e-02f, 1.29548684e-01f, -7.75606856e-02f, 7.14355260e-02f,
  1.20374449e-01f, -1.39138013e-01f, 1.77056953e-01f, 1.20512925e-01f, -1.17290385e-01f, 5.10566048e-02f, 1.91388838e-02f, -1.25007555e-01f, -3.30889896e-02f, 1.77731388e-04f,
  -1.79868385e-01f, -7.42999651e-03f, -7.55385682e-02f, -8.77965242e-02f, -1.32317454e-01f, 8.15747082e-02f, 1.33399367e-01f, 8.88907313e-02f, -8.10471550e-02f, -5.63497990e-02f,
  -8.28456506e-02f, 2.66179591e-02f, 6.33149371e-02f, -1.14610203e-01f, 1.12363763e-01f, -1.19513273e-01f, 1.16477586e-01f, 6.20800853e-02f, -2.29513645e-01f, 3.01670969e-01f,
  1.56899825e-01f, -2.12478396e-02f, -1.23942994e-01f, -1.27161562e-01f, -1.08671542e-02f, 4.01821472e-02f, 5.54935029e-03f, 1.06170200e-01f, -4.98098657e-02f, 1.29542828e-01f,
  8.07192251e-02f, 6.07504770e-02f, 9.91985425e-02f, -2.65390147e-02f, 2.26791799e-02f, 7.94118717e-02f, 1.01294242e-01f, -4.79586199e-02f, 3.96805331e-02f, 1.19906524e-02f,
  -1.34636611e-02f, 2.23312080e-02f, 3.87821645e-02f, -8.23530182e-02f, 8.96820948e-02f, 1.08196355e-01f, 4.05160151e-02f, 1.04691572e-01f, -1.70266386e-02f, -1.46288872e-02f,
  1.12770602e-01f, -2.03081523e-03f, -1.45358425e-02f, -1.77880749e-02f, 1.46803036e-02f, 2.44631954e-02f, 2.94109248e-02f, -9.21009388e-03f, -3.57673094e-02f, 9.13356915e-02f,
  4.89425212e-02f, 5.03825918e-02f, 3.42449546e-02f, 2.11509038e-02f, -2.69880574e-02f, 1.27277344e-01f, -4.78002392e-02f, -7.44079649e-02f, 4.69518155e-02f, 7.44436309e-02f,
  -2.84382817e-03f, 1.58261806e-02f, 2.36957371e-02f, 3.38715455e-03f, 3.11280545e-02f, -6.74391240e-02f, 5.49818985e-02f, 1.57742407e-02f, -4.02504839e-02f, 6.45889342e-02f,
  -8.61550421e-02f, -8.41139182e-02f, 1.70870908e-02f, -9.44626778e-02f, 5.06267175e-02f, -5.17042261e-03f, 6.47093132e-02f, -5.29186726e-02f, -4.96376194e-02f, -8.37772787e-02f,
  2.10350920e-02f, -2.34406013e-02f, -1.73003599e-02f, 5.88339046e-02f, -1.02544706e-02f, -2.31015366e-02f, -4.39052805e-02f, -2.18504686e-02f, -9.29155052e-02f, 1.69440713e-02f,
  -2.86448337e-02f, -5.84578775e-02f, -1.45082921e-02f, 1.91515423e-02f, 2.04868298e-02f, -6.91418946e-02f, 4.25328687e-02f, -4.28861305e-02f, -3.54125388e-02f, -1.12841494e-01f,
  -6.15469217e-02f, -5.57668321e-02f, -2.71969438e-02f, -1.34034097e-01f, -1.42399475e-01f, -4.72088680e-02f, -6.97041005e-02f, -7.34482892e-04f, -5.67267612e-02f, 1.89603642e-02f,
  -9.32253823e-02f, 5.66772111e-02f, 1.55682027e-01f, 2.45453585e-02f, -1.18136955e-02f, -3.63427252e-02f, 7.78075084e-02f, 9.92463343e-03f, 6.59069419e-02f, -7.36203194e-02f,
  1.61763635e-02f, -7.93502107e-02f, 4.15449031e-02f, -1.49498088e-02f, -2.22207978e-02f, -1.06833540e-02f, -5.33592403e-02f, -2.35424228e-02f, -1.28225284e-02f, -2.18290072e-02f,
  4.40194942e-02f, -1.69620484e-01f, -1.01957936e-02f, -8.95331241e-03f, 5.85457124e-02f, 6.75973594e-02f, 7.55427182e-02f, 7.44813457e-02f, -8.19028318e-02f, 6.84638740e-03f,
  -1.17378078e-01f, 1.16079096e-02f, 1.94644444e-02f, 2.75014690e-03f, -8.93361196e-02f, 7.68819684e-03f, 8.51813704e-03f, -6.11302294e-02f, 8.36703647e-03f, 3.85376997e-02f,
  -1.19082391e-01f, -5.50022312e-02f, 1.70600936e-02f, 2.09422670e-02f, -6.30733594e-02f, 4.06450108e-02f, -1.33573338e-01f, 9.04263649e-03f, -2.92202421e-02f, -1.16662487e-01f,
  -1.18490040e-01f, 1.11777158e-02f, 1.87319554e-02f, 3.77192274e-02f, -1.43103413e-02f, 8.12154934e-02f, 4.96333912e-02f, -1.58098452e-02f, 7.85083622e-02f, 7.81606585e-02f,
  4.93256822e-02f, -7.58252740e-02f, -7.51489401e-02f, -2.80379485e-02f, -5.86959496e-02f, 4.89876606e-02f, -3.17542292e-02f, -4.49070446e-02f, -7.13941036e-03f, -2.41736006e-02f,
  5.47681488e-02f, 8.78770297e-05f, -2.39651706e-02f, 8.14198852e-02f, 5.80265410e-02f, -4.84966189e-02f, -5.47073316e-03f, 2.39569936e-02f, -7.35016987e-02f, 6.64876997e-02f,
  1.40366614e-01f, 3.43463793e-02f, 6.17198972e-03f, 2.30275728e-02f, 9.81672928e-02f, -1.14621688e-02f, -2.46737041e-02f, -6.81610927e-02f, -5.05440123e-02f, -6.43915981e-02f,
  4.10959013e-02f, -4.21235189e-02f, -1.94466263e-02f, -2.81620342e-02f, 1.37015404e-02f, -1.42168710e-02f, 1.92828123e-02f, -2.68480042e-03f, -5.16373441e-02f, -5.32921217e-02f,
  4.66088988e-02f, 4.55971844e-02f, -5.77982217e-02f, 4.02228087e-02f, 8.53493437e-03f, 1.72681622e-02f, 9.02475640e-02f, 1.79122537e-02f, 1.03158414e-01f, 9.74962711e-02f,
  -6.52742013e-02f, 6.33034036e-02f, -7.11333230e-02f, 1.42476037e-01f, 1.19203724e-01f, -5.47487885e-02f, -1.33780897e-01f, -6.80467188e-02f, 8.15672651e-02f, -5.49439229e-02f,
  1.99209247e-02f, -6.31699746e-04f, -8.96187723e-02f, -3.73651609e-02f, -1.43273681e-01f, -1.31682619e-01f, 7.73154199e-02f, -1.00713477e-01f, -1.85236841e-01f, 4.26619127e-02f,
  1.10308826e-02f, 4.26500384e-03f, 1.41620681e-01f, 6.95410222e-02f, 1.34460270e-01f, 1.03447298e-02f, 9.70636383e-02f, 1.10692620e-01f, 3.41432467e-02f, 1.54429927e-01f,
  2.76807323e-03f, -4.36990261e-02f, 1.81880146e-02f, 1.98408887e-02f, 2.17668898e-02f, -3.44842300e-02f, -7.19916075e-02f, -1.04415733e-02f, -2.01022392e-03f, -6.50646761e-02f,
  4.13807333e-02f, -8.17530751e-02f, -2.56506912e-02f, -9.56140682e-02f, -5.55697344e-02f, 2.03402154e-02f, -1.58731341e-02f, -2.93904496e-03f, -1.58824041e-01f, 5.61570469e-03f,
  4.61240066e-03f, -4.59644273e-02f, -4.80493978e-02f, -5.85202454e-03f, -1.12153389e-01f, 9.85063333e-03f, 1.03167869e-01f, 6.92213401e-02f, -7.88315572e-03f, 9.71763656e-02f,
  1.53158363e-02f, 8.93526673e-02f, 4.68301140e-02f, 1.92065239e-02f, -2.94304807e-02f, 3.92325334e-02f, -1.88709255e-02f, -2.00815573e-02f, 9.20276046e-02f, 1.80771779e-02f,
  -3.75251472e-02f, -6.60460740e-02f, -3.50316651e-02f, -4.23752982e-03f, 9.55082197e-03f, -3.03135291e-02f, 1.74221806e-02f, 6.06462508e-02f, -5.51291592e-02f, 4.32227552e-02f,
  2.77823186e-04f, 1.08405836e-02f, -5.02892863e-03f, -6.19629510e-02f, 2.17866581e-02f, 4.16947342e-02f, -4.88539487e-02f, 4.03759889e-02f, 8.89104418e-03f, 6.18438190e-03f,
  7.60027692e-02f, 2.28373017e-02f, -7.43319243e-02f, -4.97092865e-02f, 6.07428961e-02f, 7.98496157e-02f, -9.18535441e-02f, 5.74832112e-02f, -5.77123836e-02f, 2.97325477e-02f,
  -8.24676231e-02f, 5.93695901e-02f, 4.83502336e-02f, -1.14339059e-02f, -1.45753687e-02f, 1.10666477e-03f, -5.77748865e-02f, 1.33748660e-02f, 3.71040143e-02f, -2.39902213e-02f,
  -4.34272364e-02f, -9.32268724e-02f, -3.09499037e-02f, -3.61585133e-02f, 2.38616834e-03f, -4.77498956e-02f, 6.88127354e-02f, -6.47448897e-02f, -7.89822191e-02f, -3.25441994e-02f,
  1.15430884e-01f, -2.02079609e-01f, -9.45189223e-02f, 1.83928147e-01f, -1.42592157e-03f, -4.30678464e-02f, -2.62242913e-01f, 8.95902812e-02f, 1.63637191e-01f, 1.48911001e-02f,
  -1.25026643e-01f, 1.73135530e-02f, 5.20019494e-02f, -4.31788750e-02f, -1.42875865e-01f, -1.46153823e-01f, 2.45540440e-02f, -7.29215294e-02f, -6.67943582e-02f, 3.32689695e-02f,
  -3.66072915e-02f, 1.92418583e-02f, 4.06134911e-02f, 8.58577490e-02f, 1.35441139e-01f, 5.08305617e-02f, 2.90432628e-02f, 1.31963730e-01f, -2.05989480e-01f, 1.54716700e-01f,
  -1.16749994e-01f, -1.15602009e-01f, 9.24314931e-02f, 1.26518264e-01f, 1.83549430e-02f, 4.62338850e-02f, 2.27095392e-02f, 1.01757437e-01f, 4.18329835e-02f, 5.86425588e-02f,
  -5.32230660e-02f, -3.06706987e-02f, -6.63305745e-02f, 1.36483996e-03f, 4.78737615e-02f, 1.04326963e-01f, 4.14210409e-02f, -6.56055063e-02f, -6.80444716e-03f, -1.33417517e-01f,
  -8.75697583e-02f, 4.07456085e-02f, 1.01948723e-01f, -3.43475910e-03f, -6.58189356e-02f, -9.96016059e-03f, -1.89644527e-02f, 1.87753551e-02f, 4.48525362e-02f, 1.03820749e-01f,
  5.16273500e-03f, -4.43608547e-03f, -1.54581573e-02f, 2.15965882e-02f, -8.24430957e-03f, -4.11631577e-02f, -1.81912463e-02f, -3.28246653e-02f, -1.10813916e-01f, -1.04963064e-01f,
  1.94148310e-02f, 1.41843455e-02f, -3.94991785e-02f, 4.30479134e-03f, 7.22452207e-03f, 1.91556010e-02f, 2.63958966e-04f, -1.02667667e-01f, 1.57594383e-02f, 7.71386027e-02f,
  4.07533254e-03f, 7.62328133e-02f, 9.17752385e-02f, -1.53600974e-02f, 7.45154396e-02f, -7.15328678e-02f, 1.99739356e-02f, -2.83543728e-02f, 3.78293507e-02f, 4.89552096e-02f,
  1.12671696e-01f, -5.75358570e-02f, 2.23426688e-02f, 3.33401412e-02f, -9.64284223e-03f, 9.06498507e-02f, 3.07061393e-02f, -7.36595839e-02f, -8.91719833e-02f, -1.53924366e-02f,
  -4.90900576e-02f, -1.15566276e-01f, -9.44598392e-02f, 6.28716722e-02f, -5.00488281e-02f, 6.80636689e-02f, -3.88454385e-02f, 2.42499169e-02f, 9.96839534e-03f, 6.43503517e-02f,
  -3.18140648e-02f, 9.94720235e-02f, -9.05699003e-03f, 2.31353752e-02f, 4.90457155e-02f, -6.63156137e-02f, -8.00495148e-02f, -4.70216759e-02f, -7.84503818e-02f, 6.18566684e-02f,
  -2.91693360e-01f, -2.14467108e-01f, -1.85484722e-01f, -3.33024621e-01f, -1.76990867e-01f, -1.40804768e-01f, -6.35828003e-02f, -8.36648718e-02f, -6.77390546e-02f, -1.19823277e-01f,
  -1.22313000e-01f, -5.47791943e-02f, 7.80974403e-02f, 8.41777101e-02f, 5.24667725e-02f, -1.58399660e-02f, -1.22624256e-01f, 3.91474105e-02f, 1.85920313e-01f, -1.68823637e-02f,
  -7.78611600e-02f, -1.82139829e-01f, -5.73854707e-02f, 4.53313664e-02f, 3.16592539e-03f, 4.55483533e-02f, -1.29350349e-01f, -1.43517852e-01f, 1.97518677e-01f, -2.68595159e-01f,
  1.15786836e-01f, -1.52202353e-01f, -1.15678990e-02f, -3.85954343e-02f, -2.70685628e-02f, 7.85206631e-02f, 1.15427159e-01f, 2.76251393e-03f, 6.95701987e-02f, 3.61024067e-02f,
  5.26286364e-02f, 3.94253731e-02f, 7.74314627e-02f, -1.97732076e-02f, -7.98161328e-02f, 5.91678433e-02f, 5.56985550e-02f, 4.08044085e-02f, 4.43166727e-03f, 3.41279320e-02f,
  -2.90774461e-02f, -8.46656188e-02f, 5.71336423e-04f, -2.45807376e-02f, 4.86657172e-02f, -3.61490808e-02f, 5.05078435e-02f, 1.62442867e-02f, -2.13157162e-02f, 8.21601693e-03f,
  1.55609837e-02f, 5.28820343e-02f, 3.91224921e-02f, -5.16645312e-02f, 2.13496517e-02f, 2.96301059e-02f, -2.24233576e-04f, -1.21639958e-02f, -1.44392597e-02f, 8.74543004e-03f,
  3.14651616e-02f, 1.61486138e-02f, 5.24463505e-02f, -4.15046588e-02f, 9.49378219e-03f, -5.36476970e-02f, 1.12323500e-02f, -8.55245814e-03f, -3.59528139e-02f, 1.61218885e-02f,
  -3.43034714e-02f, 3.34538668e-02f, -2.44364999e-02f, -2.78714392e-03f, 2.43450738e-02f, -2.94450130e-02f, 3.97019386e-02f, -5.66799454e-02f, -4.34807204e-02f, -5.08373939e-02f,
  6.63727149e-02f, 2.31288206e-02f, -1.44959077e-01f, 1.95510574e-02f, 2.23850925e-02f, 1.15150176e-02f, -4.01258394e-02f, 6.41180575e-02f, -2.87332968e-03f, 1.95985846e-03f,
  -5.68955402e-05f, -1.31255249e-02f, -2.75290851e-02f, 3.00733093e-02f, 5.71823493e-02f, -3.58213671e-02f, -3.09531111e-02f, -8.37199986e-02f, 7.98688270e-03f, 2.04858892e-02f,
  6.65924400e-02f, 1.70139538e-03f, 3.06805950e-02f, -5.56217413e-03f, 4.15069088e-02f, 2.58538220e-02f, 2.14840025e-02f, -1.11413999e-02f, -1.81215573e-02f, -5.95203191e-02f,
  -1.30904257e-01f, 1.82792589e-01f, 1.14205696e-01f, 8.70688036e-02f, 4.64439839e-02f, 7.62962028e-02f, 1.24533869e-01f, 9.74763334e-02f, -1.14495791e-02f, 7.83457607e-02f,
  1.06419280e-01f, -1.54477730e-02f, -2.79828086e-02f, -7.60702416e-03f, 6.26839548e-02f, 2.97355875e-02f, 6.29218891e-02f, 3.46368290e-02f, 6.84698150e-02f, -4.80362847e-02f,
  2.35869698e-02f, -2.47484148e-02f, -1.07673116e-01f, -1.56659987e-02f, 5.99680375e-03f, 2.96073016e-02f, 8.00104961e-02f, -2.74960650e-03f, 5.97098656e-02f, -2.92154290e-02f,
  -6.80819005e-02f, -2.67243497e-02f, -1.03332542e-01f, -3.84736881e-02f, -5.20829074e-02f, -1.04092896e-01f, -6.09061532e-02f, -6.95832223e-02f, -1.05580270e-01f, -1.04965419e-02f,
  -6.55212104e-02f, -7.31712207e-02f, 9.53320065e-04f, 8.03307146e-02f, 4.47152182e-02f, -7.03852028e-02f, 4.22342680e-02f, -5.82354069e-02f, -1.16778217e-01f, -4.39242534e-02f,
  6.34957924e-02f, 3.79279889e-02f, 5.07182442e-02f, 6.32374436e-02f, 2.65079066e-02f, -3.24370973e-02f, 7.73267969e-02f, 2.74006687e-02f, 2.83706523e-02f, -6.57327054e-03f,
  3.92731465e-02f, 5.76544814e-02f, 9.76366270e-03f, 4.18683738e-02f, -4.87320274e-02f, -7.01362342e-02f, 3.77990380e-02f, -5.56034409e-02f, 7.64154568e-02f, -9.14878547e-02f,
  -1.15674669e-02f, -3.27565707e-02f, 6.34966716e-02f, 6.57581091e-02f, 1.42020974e-02f, 4.30735806e-03f, 6.72764853e-02f, 5.93027622e-02f, -4.88786735e-02f, -2.23737285e-02f,
  7.39614889e-02f, 1.01600541e-02f, 4.84990552e-02f, 4.18920331e-02f, -4.50147130e-02f, 5.37745878e-02f, 1.04571311e-02f, 4.28211093e-02f, 3.17942761e-02f, -2.29494162e-02f,
  -9.97944623e-02f, -7.56523535e-02f, -3.72047834e-02f, 3.93464975e-02f, 8.54328088e-03f, 1.54418545e-02f, -3.31272744e-02f, 2.76212227e-02f, -5.25949150e-02f, -7.27632781e-03f,
  -1.16619868e-02f, -7.09589524e-03f, -5.77228926e-02f, -9.94165689e-02f, -6.19313940e-02f, 7.27696205e-03f, -1.95735265e-02f, 1.17791872e-02f, -4.10436839e-02f, -7.56637529e-02f,
  1.05268829e-01f, 9.22821369e-03f, -3.05247009e-02f, 1.14251869e-02f, -8.55683163e-02f, -1.74233224e-02f, -8.54925513e-02f, -2.84052361e-02f, -9.42799225e-02f, -1.04989477e-01f,
  2.32176170e-01f, -1.45041794e-01f, 9.55249146e-02f, -8.60542953e-02f, -2.69193888e-01f, -8.54550451e-02f, -1.48789346e-01f, -2.43682861e-02f, 6.61142543e-02f, 8.42952877e-02f,
  -1.59257263e-01f, -7.02178702e-02f, 6.20772168e-02f, 5.05315438e-02f, -2.80021448e-02f, -4.17587422e-02f, 3.34953070e-02f, 2.99150459e-02f, -5.39606363e-02f, -2.69338489e-01f,
  -1.41595677e-01f, -1.06080443e-01f, 7.73413405e-02f, -9.97941568e-02f, 6.25897869e-02f, 1.07856780e-01f, 1.91997930e-01f, 8.96516372e-04f, -3.06909699e-02f, 3.65924120e-01f,
  1.26959249e-01f, -8.44841301e-02f, 2.60088556e-02f, -4.44744416e-02f, 3.17717791e-02f, 8.33971798e-02f, -2.70075947e-02f, 3.01918220e-02f, 3.20313731e-03f, -4.08546999e-02f,
  -1.53016046e-01f, -5.02494760e-02f, -5.60405850e-02f, 1.70328226e-02f, -7.38109350e-02f, -3.91840190e-02f, 7.61541426e-02f, 2.66618542e-02f, 8.42179060e-02f, 6.91807121e-02f,
  1.46841714e-02f, -1.25032380e-01f, -2.43296903e-02f, -4.99286801e-02f, 8.55992138e-02f, -4.38956954e-02f, -4.78030555e-02f, -2.25522947e-02f, 1.02851309e-01f, 3.45922977e-01f,
  -3.92418392e-02f, 1.96129326e-02f, 8.14778507e-02f, 3.08743138e-02f, -1.28862383e-02f, -2.98413560e-02f, 7.91944265e-02f, -9.29617602e-03f, -3.50465393e-03f, 5.81153966e-02f,
  4.65706997e-02f, -1.83568578e-02f, 4.54834811e-02f, 4.68497053e-02f, 1.58923585e-02f, -8.70155264e-03f, 5.34151262e-03f, 8.74517113e-02f, -6.63157552e-02f, -4.72690575e-02f,
  3.77023444e-02f, -2.83544566e-02f, 1.58065446e-02f, 1.94545090e-02f, 4.30397410e-03f, 3.07291038e-02f, 2.00831182e-02f, -1.05425276e-01f, -5.56868985e-02f, -1.48106376e-02f,
  6.20401390e-02f, -1.35346875e-01f, -2.21205279e-02f, -7.58733740e-03f, -7.20112002e-05f, -6.71256855e-02f, 1.31999105e-02f, 7.50346929e-02f, -2.66102683e-02f, 9.56021808e-03f,
  1.09075326e-02f, 6.13768846e-02f, 5.84650040e-02f, 1.98304746e-02f, -1.72164086e-02f, -6.89891726e-02f, -3.44536919e-03f, 4.09664959e-02f, -1.08567648e-01f, -6.36418164e-02f,
  7.96932057e-02f, 5.50028831e-02f, 7.99665824e-02f, 1.09328762e-01f, -1.90365408e-02f, -1.00617230e-01f, 1.29621536e-01f, 9.93960872e-02f, 7.34171197e-02f, 2.65372097e-01f,
  -6.78494573e-02f, 1.76172525e-01f, -1.27740532e-01f, 7.39958882e-02f, 3.24886641e-04f, 1.41694797e-02f, 6.17568307e-02f, 7.89397061e-02f, 8.27629399e-03f, 2.63563059e-02f,
  1.64825730e-02f, 3.30574028e-02f, -4.78911549e-02f, 3.80468704e-02f, -4.87769470e-02f, -1.80158652e-02f, -1.58247188e-01f, -1.26037046e-01f, -1.15150183e-01f, 1.23445384e-01f,
  5.49539179e-02f, -8.29954520e-02f, -4.42229249e-02f, 5.28409891e-02f, -1.26247574e-02f, 2.28208899e-02f, -7.95329064e-02f, 6.84101209e-02f, 6.40265495e-02f, -2.75966078e-01f,
  -1.47604868e-01f, 1.38075039e-01f, -3.89515646e-02f, 4.92270179e-02f, 4.66755293e-02f, 7.37792701e-02f, 5.55259474e-02f, 2.44690217e-02f, -8.17427505e-03f, 1.78982560e-02f,
  2.56180931e-02f, 2.37365197e-02f, -1.09365977e-01f, 2.64064260e-02f, 4.22875135e-04f, 2.81545073e-02f, 1.07560083e-01f, -5.46730198e-02f, 1.81189440e-02f, -2.47500762e-02f,
  2.55689840e-03f, -6.82815164e-02f, -6.38914853e-02f, 1.40411660e-01f, -2.42688376e-02f, -2.72707306e-02f, 2.20325086e-02f, 3.50519866e-02f, 3.88003960e-02f, 1.23086600e-02f,
  1.60501003e-02f, -8.82427916e-02f, -2.11559590e-02f, -2.62412205e-02f, 7.80811682e-02f, -2.32632179e-02f, -4.50246297e-02f, 9.76840034e-03f, -5.89692630e-02f, -1.34265088e-02f,
  4.83232290e-02f, 7.44911432e-02f, 8.93742312e-03f, -1.65126864e-02f, -7.55844265e-02f, 4.93097566e-02f, -9.99786332e-03f, -4.15587723e-02f, 5.54542802e-02f, -6.45655766e-02f,
  3.87837514e-02f, -1.29549224e-02f, -2.57539507e-02f, -4.54386324e-02f, -1.11953039e-02f, -7.34743755e-03f, 7.24447425e-03f, 1.25291780e-01f, -3.12805027e-02f, 7.42723420e-02f,
  1.10045858e-01f, 9.06516910e-02f, -5.34671769e-02f, -6.12690039e-02f, 2.22695600e-02f, 7.09334686e-02f, 1.56090886e-03f, 1.05266199e-02f, -2.83662649e-03f, -1.58160448e-03f,
  5.51518984e-03f, -8.61052889e-03f, 6.52460977e-02f, -1.72507809e-03f, -2.69417241e-02f, 3.86680886e-02f, 2.48292796e-02f, 1.96576975e-02f, -5.78670800e-02f, 4.83703800e-02f,
  1.07884165e-02f, 4.71266313e-03f, -4.57863621e-02f, -2.53871419e-02f, 5.15414514e-02f, -2.63345186e-02f, 4.31555659e-02f, -6.16284572e-02f, 7.20341057e-02f, 1.52060196e-01f,
  -3.81861955e-01f, 1.59411281e-01f, 3.87607068e-02f, -2.32013136e-01f, -7.77657032e-02f, 3.36606726e-02f, -7.53453141e-03f, -1.80117767e-02f, -1.38400927e-01f, 6.99522793e-02f,
  1.02577470e-01f, 8.91602561e-02f, 8.05627853e-02f, 3.50765400e-02f, 4.52245288e-02f, 7.57048801e-02f, 9.01741255e-03f, -7.83993155e-02f, 2.36804318e-02f, -8.66429228e-03f,
  7.57190660e-02f, -2.92195659e-02f, -9.46088284e-02f, -6.39173761e-02f, 4.56533022e-02f, -5.80016039e-02f, 3.30378860e-02f, -1.56063391e-02f, 1.69766277e-01f, -8.93945545e-02f,
  1.79837078e-01f, -4.60236184e-02f, -6.45927936e-02f, -1.05852615e-02f, -6.22112378e-02f, -6.79338351e-02f, 7.52406344e-02f, 1.93050802e-02f, -1.58139747e-02f, 8.34673177e-03f,
  -3.11083160e-03f, -1.06530068e-02f, -4.30441787e-03f, -4.18719426e-02f, -2.77618226e-02f, 7.53616989e-02f, -8.17117468e-02f, 3.58800255e-02f, -3.75506319e-02f, 7.54503980e-02f,
  1.10618882e-01f, -1.16411440e-01f, -5.36198281e-02f, 5.36222197e-02f, -6.09022342e-02f, -9.93115827e-02f, 8.86318460e-02f, 1.41236931e-02f, 9.66316741e-03f, 2.38908717e-04f,
  -1.30937370e-02f, 6.08732319e-03f, 7.30339736e-02f, 5.35657741e-02f, 5.14479280e-02f, -5.83425686e-02f, 1.41739557e-02f, 5.17312773e-02f, 3.54785919e-02f, -9.30878147e-02f,
  3.27674188e-02f, 3.72486450e-02f, 2.20206194e-02f, 2.77043469e-02f, 2.43937895e-02f, -7.68812373e-02f, -9.13250446e-02f, 5.91330491e-02f, -5.35849575e-03f, 5.55695128e-03f,
  2.07627118e-02f, -2.65981648e-02f, -2.93161552e-02f, -1.94336695e-03f, 6.03577755e-02f, -4.81613614e-02f, -3.19317728e-03f, -3.60088237e-02f, -6.22889809e-02f, 5.19437194e-02f,
  1.60669193e-01f, -1.36413470e-01f, -6.75398903e-03f, -6.32451102e-03f, 3.87941003e-02f, -6.73281252e-02f, 4.22044620e-02f, 2.89714932e-02f, 2.08058674e-02f, 1.26974275e-02f,
  -8.28373656e-02f, -8.36996660e-02f, -3.99557129e-02f, 5.74679598e-02f, -5.25009185e-02f, -1.86068956e-02f, -3.50165693e-03f, 1.13734044e-02f, 8.26959908e-02f, -2.50694919e-02f,
  -1.17287682e-02f, -6.72699735e-02f, 4.12427261e-03f, -8.17660391e-02f, 3.85265201e-02f, -1.46178557e-02f, -1.46927638e-02f, 5.89974411e-02f, 3.18544195e-03f, 7.99713507e-02f,
  5.52098900e-02f, 1.04712443e-02f, -1.05408095e-02f, 3.70972417e-02f, 1.18115060e-01f, 1.68707341e-01f, 1.33057430e-01f, 4.30512503e-02f, -1.15561336e-01f, 3.23517546e-02f,
  6.46631122e-02f, 1.41370930e-02f, -3.54277492e-02f, 4.62480709e-02f, 6.95213825e-02f, 1.06241710e-01f, -7.33603910e-02f, -3.74721624e-02f, 3.01012490e-02f, 9.51052457e-02f,
  9.29598138e-03f, -7.47051761e-02f, 5.67895137e-02f, 4.56501804e-02f, 1.04092747e-01f, -5.39379120e-02f, 6.29969761e-02f, -3.52341644e-02f, 2.70884018e-02f, -1.08852223e-01f,
  -1.05564296e-01f, 1.26008913e-01f, 9.11995694e-02f, 9.38597694e-02f, 2.41111778e-02f, 1.72733869e-02f, -6.16412684e-02f, -9.46804360e-02f, 4.58157472e-02f, -1.38935558e-02f,
  -6.24701083e-02f, 2.29745582e-02f, -9.85185727e-02f, 3.86104477e-03f, 5.70635162e-02f, -2.44646333e-02f, -7.61497170e-02f, 5.23681529e-02f, -6.24058954e-02f, 6.48928508e-02f,
  -2.27691457e-02f, 4.96270806e-02f, 1.75065175e-02f, -6.72790036e-02f, 3.85625958e-02f, -2.53288820e-02f, -7.96667635e-02f, 3.76697518e-02f, 1.10548221e-01f, -1.12394147e-01f,
  3.68226394e-02f, -1.46001363e-02f, -6.96230903e-02f, -2.39292551e-02f, -9.79949720e-04f, -1.44959344e-02f, 5.00493310e-03f, 3.03145759e-02f, -9.20410603e-02f, -5.53084612e-02f,
  -6.44769669e-02f, 6.24800697e-02f, 5.12875505e-02f, -3.17787752e-02f, -9.94629040e-03f, -7.08874986e-02f, 6.48708418e-02f, 1.53979864e-02f, -2.97593474e-02f, 9.53573957e-02f,
  5.83387315e-02f, 2.05806717e-02f, 4.05172780e-02f, 1.16345070e-01f, 9.69311744e-02f, -2.52826810e-02f, 4.16486897e-03f, -7.66950771e-02f, -8.05348903e-03f, -2.29369812e-02f,
  -9.93028730e-02f, 7.48288184e-02f, -1.68305933e-02f, 5.33608086e-02f, -5.87921254e-02f, 4.41681594e-02f, -5.64314798e-02f, -5.85277341e-02f, -5.09039871e-02f, 4.38727206e-03f,
  2.59157475e-02f, -2.21512411e-02f, -1.37673481e-03f, -6.10530153e-02f, -8.91916826e-02f, -1.99569762e-02f, -1.32878661e-01f, -1.14006167e-02f, 1.19775943e-01f, -2.21382529e-02f,
  -5.89006841e-02f, -3.62184905e-02f, 2.99397744e-02f, -5.10197058e-02f, -2.20607519e-02f, 2.94816289e-02f, -8.67240950e-02f, 3.99011634e-02f, 5.29694036e-02f, -1.26334116e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.63367037e-03f, 1.14355959e-01f, -4.51041125e-02f, 4.30300236e-02f, 6.66246563e-02f, 8.69860947e-02f, 1.33786783e-01f, 6.14215843e-02f, -4.40131612e-02f, 1.18786603e-01f,
  1.67562738e-01f, 1.17923506e-01f, 1.65335000e-01f, 1.06372312e-01f, 1.40883446e-01f, 9.27737206e-02f, -1.39401597e-03f, 3.17441411e-02f, 8.45415145e-02f, -4.32252139e-03f,
  -2.14990750e-02f, 1.85851809e-02f, -4.24599014e-02f, -7.58782253e-02f, 6.13449812e-02f, 6.80362210e-02f, -1.09167630e-02f, 2.77137738e-02f, -2.17366777e-02f, -1.33537933e-01f,
  7.28990510e-02f, 7.05080181e-02f, 1.29105821e-01f, -2.46420316e-02f, -4.07518223e-02f, -7.09436312e-02f, 1.08593749e-02f, -1.99112613e-02f, -5.14420271e-02f, 6.41639577e-04f,
  -1.24281861e-01f, -1.04515962e-01f, 7.55191818e-02f, 6.81592971e-02f, -5.73870204e-02f, 7.29083568e-02f, 6.83043972e-02f, 2.49294192e-02f, 9.53432918e-02f, 2.92722266e-02f,
  1.11613981e-01f, 8.72292817e-02f, 1.32466346e-01f, 4.53714021e-02f, 6.47365823e-02f, 7.03039989e-02f, 9.59578082e-02f, 5.85804507e-02f, 1.12263583e-01f, 7.28760809e-02f,
  -3.28977257e-02f, -5.33920117e-02f, 2.63271555e-02f, 1.34333770e-03f, 2.97845770e-02f, 2.10061189e-04f, -2.16560047e-02f, -9.06777233e-02f, -6.31566942e-02f, -3.29713970e-02f,
  1.24254115e-01f, 2.28530876e-02f, 4.58156429e-02f, 4.32301089e-02f, 6.30376264e-02f, 2.44381726e-02f, 3.98068391e-02f, 2.10678554e-03f, 1.03560992e-01f, -1.42355347e-02f,
  1.25290856e-01f, 7.62158111e-02f, -3.57515328e-02f, 8.70882943e-02f, 3.97615470e-02f, 5.88004068e-02f, 1.04638087e-02f, -8.42262283e-02f, -1.63667556e-02f, -5.87059520e-02f,
  4.05050702e-02f, 9.04870853e-02f, -6.79948181e-02f, -2.80520059e-02f, -5.05284499e-03f, 3.97802442e-02f, 4.40838337e-02f, -5.35279587e-02f, 5.70132304e-03f, 4.53602262e-02f,
  6.91452399e-02f, -6.10868819e-02f, 6.26610070e-02f, -3.94250900e-02f, 1.55085353e-02f, -7.42976442e-02f, -4.80180793e-02f, -4.57380107e-03f, 7.18611404e-02f, -3.43266055e-02f,
  1.97721785e-03f, 4.85571064e-02f, -2.00409237e-02f, 9.43898261e-02f, 2.30850354e-02f, -4.85117175e-02f, -4.04670909e-02f, -8.54329243e-02f, -1.09081250e-02f, -5.87614998e-02f,
  -1.32191390e-01f, -2.91410744e-01f, -2.11995199e-01f, 2.09930446e-02f, 1.31216403e-02f, 5.66152558e-02f, -1.81592871e-02f, -5.06397511e-04f, 8.83422717e-02f, -4.03876901e-02f,
  -1.24322787e-01f, -1.08351223e-01f, -1.25754789e-01f, 4.59729023e-02f, -2.50337739e-02f, -2.65155267e-02f, -9.11213681e-02f, -1.48269638e-01f, 2.00727326e-03f, 1.82772905e-01f,
  1.21581584e-01f, 3.97915877e-02f, -7.48724416e-02f, -1.69708282e-02f, 8.81219283e-02f, -5.14139421e-03f, 7.99244270e-03f, -3.05100984e-04f, 7.37287756e-03f, -2.85683926e-02f,
  -7.73571134e-02f, -8.77906277e-05f, 4.09987271e-02f, 1.24980155e-02f, -3.12554725e-02f, 4.66802418e-02f, 4.69945967e-02f, 7.95622990e-02f, -4.93790470e-02f, -7.04728067e-02f,
  -3.94148864e-02f, -3.13656479e-02f, 6.08327314e-02f, 2.63973866e-02f, 6.99572777e-03f, 5.13655283e-02f, -2.61639934e-02f, -9.68647525e-02f, -1.09527722e-01f, -5.02283052e-02f,
  6.75834194e-02f, 3.61916907e-02f, -9.13596675e-02f, -1.87779330e-02f, -6.64483150e-03f, -2.29121186e-03f, -6.44388124e-02f, 8.89239311e-02f, -3.92071065e-03f, -7.87281489e-04f,
  -3.37937362e-02f, 1.36660002e-02f, -1.08028045e-02f, -4.83479723e-02f, 6.45182580e-02f, 1.81833860e-02f, -2.40005236e-02f, 3.98895741e-02f, 2.68648379e-02f, 2.91696731e-02f,
  -8.48154053e-02f, 4.02180068e-02f, 8.64583626e-02f, 2.33774874e-02f, 3.03894840e-02f, 5.83642758e-02f, -3.89359370e-02f, 6.07821345e-03f, -5.72336465e-02f, -1.25371153e-02f,
  -7.08429739e-02f, 9.56994593e-02f, 1.85182914e-02f, 6.29197136e-02f, 2.62535773e-02f, 9.63165518e-03f, 3.04161478e-03f, -5.49175218e-03f, -4.58017290e-02f, 9.39464271e-02f,
  -1.35997161e-01f, -1.02033339e-01f, 1.26940915e-02f, 3.56098190e-02f, 8.96672383e-02f, -7.06527084e-02f, -6.00166582e-02f, -2.23979764e-02f, -3.69611010e-02f, -2.80327871e-02f,
  -3.52600627e-02f, 3.29149626e-02f, -1.40806502e-02f, -3.93652543e-02f, -1.09434808e-02f, -2.60884538e-02f, -8.75742584e-02f, -4.42630574e-02f, -1.05271108e-01f, 3.20411138e-02f,
  -1.16917633e-01f, 4.77566989e-03f, -1.49002001e-01f, -5.49914688e-02f, -3.35434452e-02f, 1.83045715e-02f, -1.30525097e-01f, 4.96823974e-02f, -5.58337271e-02f, -1.45836234e-01f,
  1.80519581e-01f, -7.22045545e-03f, -8.88167769e-02f, -9.56063941e-02f, -1.23443328e-01f, -1.37916043e-01f, -3.37930247e-02f, 1.32601359e-03f, -5.78382351e-02f, -4.43996899e-02f,
  -3.02820150e-02f, -4.29887958e-02f, 6.13860711e-02f, -5.78691624e-02f, 4.83176522e-02f, 1.30069545e-02f, 7.63171818e-03f, -9.58431065e-02f, -8.99591595e-02f, -1.29574373e-01f,
  -5.69605976e-02f, -5.75267561e-02f, 2.43855156e-02f, 4.76016803e-03f, 1.50415618e-02f, -7.93035775e-02f, -7.13888975e-03f, -1.10541090e-01f, -1.77117325e-02f, -9.76166874e-02f,
  -1.42087445e-01f, -5.05014509e-02f, -4.54026572e-02f, 2.75507253e-02f, -1.12962879e-01f, 5.01970127e-02f, 5.00581376e-02f, 6.21082373e-02f, -4.12951373e-02f, -2.72440799e-02f,
  -7.82446787e-02f, 3.13868597e-02f, -7.79396147e-02f, -9.14632976e-02f, -5.93725545e-03f, -2.27324851e-02f, -3.98430824e-02f, -6.58717602e-02f, -7.60335103e-02f, -8.80022794e-02f,
  -9.09380838e-02f, -2.64951196e-02f, 8.21538344e-02f, 9.05546695e-02f, 1.90537293e-02f, 1.00346401e-01f, -2.76699699e-02f, 4.18111905e-02f, -9.57932994e-02f, 6.93029165e-02f,
  -7.81737491e-02f, 7.83841386e-02f, 6.89617991e-02f, 1.14761852e-02f, -3.67171280e-02f, 2.09789220e-02f, 3.96990515e-02f, 7.63310120e-02f, -4.54694778e-02f, 6.73741326e-02f,
  6.75850734e-02f, 4.31611799e-02f, -8.03926885e-02f, 5.15541434e-02f, 5.18096238e-02f, -1.42157292e-02f, -6.34220019e-02f, -1.98302921e-02f, -5.92039824e-02f, 4.70555760e-02f,
  1.51626789e-03f, -5.60252145e-02f, 1.91255566e-02f, 2.97972616e-02f, -6.27229735e-02f, 6.66056573e-02f, 5.46089597e-02f, -4.37038094e-02f, -5.53046800e-02f, -4.13069241e-02f,
  -2.45878510e-02f, 6.12086020e-02f, 1.20814033e-01f, 5.95006198e-02f, 5.30975759e-02f, -4.97708656e-02f, -7.01544136e-02f, -5.81172891e-02f, -2.58636326e-02f, 5.99207990e-02f,
  7.81118423e-02f, -6.95525706e-02f, 9.03112367e-02f, -1.09289773e-02f, 1.99531168e-02f, -1.80156529e-02f, 3.47448364e-02f, -3.05340369e-03f, 7.20191449e-02f, 7.40498677e-02f,
  -2.04293267e-03f, 1.07655495e-01f, 3.74857448e-02f, 7.12785870e-02f, 8.47934783e-02f, 5.25514744e-02f, -4.08891067e-02f, -4.71137017e-02f, -3.30294110e-02f, 4.13185693e-02f,
  4.46268022e-02f, -6.51032478e-02f, -8.70052632e-03f, 9.72942337e-02f, -2.73714662e-02f, 2.96526612e-03f, 1.37320176e-01f, 5.34494445e-02f, 7.13499859e-02f, 4.96980511e-02f,
  -1.05213597e-01f, 8.21255427e-03f, 6.32626712e-02f, 6.83630183e-02f, 1.60008088e-01f, 8.16373006e-02f, 1.85100645e-01f, 1.39075413e-01f, 6.70802295e-02f, 1.37872919e-01f,
  -1.02353757e-02f, 5.42107224e-02f, -5.59915304e-02f, 8.57833922e-02f, 1.06653564e-01f, 4.70281951e-02f, 4.63024341e-02f, 9.15516689e-02f, -4.57024276e-02f, 1.92357510e-01f,
  -7.19906464e-02f, 1.33090526e-01f, 1.51117123e-03f, -2.41396809e-03f, -8.76536816e-02f, 1.13763042e-01f, 8.07091296e-02f, -5.17933257e-02f, 5.92572335e-03f, 2.54871175e-02f,
  -3.53935361e-02f, -1.54237477e-02f, 9.66003258e-03f, 8.62812810e-03f, 2.96163056e-02f, 1.29243322e-02f, 3.52574103e-02f, 2.58593634e-02f, 6.02044389e-02f, 1.17972689e-02f,
  9.68321934e-02f, 3.11813410e-02f, -7.72314742e-02f, 7.95719251e-02f, 4.05036956e-02f, -2.83100680e-02f, -2.28459518e-02f, 1.88302658e-02f, 2.25702915e-02f, 8.04115906e-02f,
  -3.49010527e-02f, -3.05442549e-02f, 6.94447309e-02f, -2.08754279e-02f, -8.71098321e-03f, 3.70804556e-02f, 1.66138739e-03f, -5.31109981e-02f, 5.98503510e-03f, -1.54339727e-02f,
  -7.66118104e-03f, 4.89705876e-02f, -5.67976721e-02f, -1.11001935e-02f, 1.46868371e-03f, 5.44906594e-02f, -2.95346882e-02f, -2.49651056e-02f, -9.12498757e-02f, -5.79604656e-02f,
  4.75379154e-02f, 7.45925978e-02f, 1.95348859e-02f, -2.67344583e-02f, 1.21205468e-02f, 1.72928218e-02f, 5.81526011e-03f, -4.72287312e-02f, 1.38924886e-02f, 2.19916436e-03f,
  -1.46017631e-03f, -1.72436729e-01f, 2.32258588e-02f, 4.98425700e-02f, -7.34720603e-02f, -2.23056432e-02f, -2.06290884e-03f, -1.06723435e-01f, -9.50428843e-02f, -1.01954583e-02f,
  1.50864176e-03f, 6.94865361e-02f, -5.65377809e-02f, 6.37091324e-02f, 4.47676033e-02f, 6.95874169e-02f, -3.40882950e-02f, 5.46359643e-02f, -4.70760185e-03f, -6.96116090e-02f,
  -7.04348758e-02f, -2.80130729e-02f, -2.22685356e-02f, -8.01003352e-02f, 1.13312922e-01f, -5.90707473e-02f, 7.21421167e-02f, -4.04418521e-02f, -1.05686471e-01f, -1.01542631e-02f,
  1.56858226e-03f, 8.45881701e-02f, -2.77625713e-02f, -1.02022111e-01f, 8.69913027e-02f, 6.19713813e-02f, -1.51737444e-02f, -7.15081543e-02f, -2.79477593e-02f, 4.73716557e-02f,
  -2.08762148e-03f, -3.15217301e-02f, -2.12447289e-02f, -9.42231417e-02f, -8.62135887e-02f, -7.25399256e-02f, -8.29533264e-02f, 2.09508222e-02f, -5.10000102e-02f, 5.58252186e-02f,
  1.86686739e-02f, 8.07421133e-02f, -8.14398006e-02f, -6.14077486e-02f, -7.27248266e-02f, 5.85059375e-02f, -1.53976064e-02f, 5.10057248e-02f, 2.07935534e-02f, 7.45671540e-02f,
  6.44277483e-02f, 8.02642778e-02f, -1.04999840e-02f, -4.96557690e-02f, 1.65444054e-02f, 4.12754379e-02f, 4.18757321e-03f, -3.42856417e-03f, 4.70422320e-02f, 7.25632980e-02f,
  1.97667512e-04f, 6.81051239e-02f, -5.78683838e-02f, -6.15210563e-04f, 2.24184580e-02f, -6.42151833e-02f, -8.04585814e-02f, 8.93658102e-02f, 2.63672434e-02f, -6.31691813e-02f,
  3.62297557e-02f, 5.31321578e-02f, 5.93775623e-02f, -2.71141157e-02f, 3.26043926e-02f, 4.85716611e-02f, 9.08323750e-02f, 5.41171208e-02f, 4.64909822e-02f, 6.01578802e-02f,
  1.35172186e-02f, -8.96681193e-03f, 5.35477102e-02f, 5.54947853e-02f, -2.71936320e-02f, -3.80545110e-02f, 7.58814812e-02f, 3.21151316e-02f, -5.11143245e-02f, 6.30077869e-02f,
  4.38849218e-02f, -1.44199049e-02f, -1.49886152e-02f, 1.21942554e-02f, 2.98287459e-02f, 8.02631080e-02f, 1.08838594e-02f, 7.98898377e-03f, -3.39795761e-02f, 3.55159119e-02f,
  4.04429361e-02f, 4.46669385e-02f, -7.49815628e-02f, 1.58925559e-02f, 3.75539511e-02f, 5.48372529e-02f, -7.78820887e-02f, -9.74660218e-02f, -3.39479484e-02f, 3.58382128e-02f,
  -8.37169588e-02f, 9.87795070e-02f, 8.06375742e-02f, -5.24553992e-02f, -1.05222657e-01f, -3.10501140e-02f, 6.97117522e-02f, -4.59886193e-02f, -3.60365175e-02f, 6.21672384e-02f,
  -3.89974825e-02f, 2.15594433e-02f, 1.92882549e-02f, 4.41738144e-02f, 8.88994634e-02f, -5.66501729e-02f, -1.01384848e-01f, 6.65211305e-02f, 6.91766664e-02f, -6.41259179e-02f,
  1.42439064e-02f, 8.40035453e-02f, -7.87004605e-02f, 1.10722192e-01f, -4.25641006e-03f, -3.66414199e-03f, 6.91478401e-02f, -6.54010698e-02f, -2.51412112e-02f, 8.32353756e-02f,
  -1.06611669e-01f, -2.99134925e-02f, 9.92689133e-02f, 8.64761174e-02f, 1.58670619e-02f, -9.88570452e-02f, -1.30642697e-01f, 6.28041998e-02f, -1.07305115e-02f, -6.37355521e-02f,
  -8.12271759e-02f, -2.70162597e-02f, -4.50873002e-02f, 6.90882728e-02f, 1.82694361e-01f, 8.96234736e-02f, 2.07185000e-01f, 1.38163179e-01f, 1.39706627e-01f, -2.35577095e-02f,
  4.65258099e-02f, 1.11844987e-01f, 1.44328713e-01f, 5.25962338e-02f, 1.66363150e-01f, -5.16887493e-02f, -6.47510365e-02f, 1.33111507e-01f, -3.88438925e-02f, 2.58538604e-01f,
  4.22401018e-02f, 9.61369872e-02f, 1.09710144e-02f, 9.08014700e-02f, -7.16668516e-02f, 2.58706007e-02f, -3.33974212e-02f, 1.96676422e-03f, 5.23659475e-02f, -3.47252525e-02f,
  -5.06120287e-02f, -4.95239943e-02f, 1.50965229e-02f, -1.54208476e-02f, -1.38141979e-02f, -9.92487222e-02f, 6.97449595e-03f, -1.94938586e-03f, 9.21190605e-02f, 3.19168344e-02f,
  7.53639406e-03f, -6.46928698e-02f, 4.27290760e-02f, 4.66061719e-02f, -1.05151556e-01f, -8.44641849e-02f, -6.85779378e-02f, 1.13636635e-01f, -2.53103152e-02f, 6.31272420e-02f,
  3.95208783e-02f, -3.94723117e-02f, -4.86171469e-02f, 2.34715473e-02f, -2.24762876e-02f, -9.98892859e-02f, 6.95056245e-02f, -8.01181979e-03f, -1.67987999e-02f, -3.86517644e-02f,
  2.38110451e-03f, -2.39228900e-03f, 1.27858249e-02f, -6.69326857e-02f, 1.28566355e-01f, 8.04558918e-02f, 4.69241058e-04f, -1.64227858e-02f, -9.65246931e-03f, 2.77851596e-02f,
  -8.03979207e-03f, -7.21936524e-02f, 2.51603182e-02f, 6.40841275e-02f, 1.73553340e-02f, 7.91927725e-02f, 1.12858117e-02f, 4.31799106e-02f, 6.96146563e-02f, 9.34461306e-04f,
  -4.27841358e-02f, 9.79149267e-02f, 2.14209016e-02f, 7.13648424e-02f, 3.00597250e-02f, 5.54852746e-02f, -9.12618116e-02f, -2.97715031e-02f, 9.56713222e-03f, -1.19566489e-02f,
  6.35462254e-02f, 5.55958971e-02f, -6.07137084e-02f, 5.51781133e-02f, 5.26659228e-02f, 7.40322098e-02f, 5.32146059e-02f, -3.50517631e-02f, -1.80662796e-02f, 3.20858583e-02f,
  -5.98345622e-02f, 4.70057596e-03f, -5.90283144e-03f, -9.25727487e-02f, 2.72258315e-02f, -1.03455506e-01f, -2.41381465e-03f, -3.44797932e-02f, -4.55486290e-02f, -2.55507659e-02f,
  -4.42804731e-02f, 7.82279223e-02f, 1.07825950e-01f, -1.91169027e-02f, -5.18493280e-02f, 1.08817481e-02f, 4.05647829e-02f, -8.23596120e-02f, -8.12996626e-02f, 4.47780304e-02f,
  -7.69640431e-02f, 7.94217288e-02f, -5.64026833e-02f, 3.69000770e-02f, -4.99649160e-02f, 5.63688651e-02f, 3.49470787e-03f, 6.52680546e-02f, -6.49859905e-02f, -5.31196930e-02f,
  8.35334435e-02f, -9.05616209e-03f, 6.45696297e-02f, 8.64259824e-02f, -4.22847718e-02f, -7.84219950e-02f, 1.02476224e-01f, 8.95200819e-02f, 6.11150563e-02f, 7.50023052e-02f,
  -8.18039849e-03f, -3.27058770e-02f, 5.76857701e-02f, 5.10442853e-02f, 5.49470633e-02f, 8.14176798e-02f, 2.96369810e-02f, -8.54705200e-02f, -8.41009170e-02f, -3.51216793e-02f,
  8.24425966e-02f, -6.50979877e-02f, -8.85595828e-02f, -6.67135715e-02f, 5.73512092e-02f, -5.72523437e-02f, 3.17206904e-02f, 5.08127622e-02f, 7.88443834e-02f, -9.19862278e-03f,
  5.02210520e-02f, -9.30243433e-02f, 2.56996509e-02f, 5.04855439e-02f, -4.17838804e-02f, 8.24997723e-02f, -9.11331549e-03f, 5.98674081e-02f, 3.41892950e-02f, -5.67800775e-02f,
  -7.94539377e-02f, -6.00946844e-02f, -4.39317450e-02f, -8.50173738e-03f, -3.10521219e-02f, 2.44875439e-02f, -1.04175974e-02f, 1.83025151e-02f, -3.16060409e-02f, 2.07927097e-02f,
  -1.41503662e-02f, 4.09735320e-03f, -3.12193502e-02f, 1.07113773e-03f, -8.15362185e-02f, 8.45495090e-02f, 2.53110249e-02f, -2.91155726e-02f, 8.45011249e-02f, 9.59629640e-02f,
  2.48603337e-02f, 5.12303337e-02f, -8.33169669e-02f, -5.89672150e-03f, 1.02118487e-02f, 4.26667519e-02f, 9.25618596e-03f, 1.04950778e-01f, -6.36438141e-03f, -8.78504366e-02f,
  1.14209019e-01f, 8.45203362e-03f, 7.55526349e-02f, 7.63837844e-02f, 4.05603498e-02f, -1.70624368e-02f, 5.81393316e-02f, 1.56519394e-02f, 1.58457924e-02f, 8.21440294e-02f,
  4.80671041e-02f, 8.99988413e-03f, -2.00456716e-02f, 1.03077374e-01f, -8.85897577e-02f, -3.34442593e-02f, 3.02437916e-02f, 5.07416502e-02f, 8.35802034e-02f, 9.33298394e-02f,
  -2.92073525e-02f, 5.37730902e-02f, -4.06833552e-02f, 2.13949997e-02f, -2.17029005e-02f, 1.80096291e-02f, -7.60249794e-02f, -4.19614911e-02f, -2.34129149e-02f, -1.02864660e-01f,
  1.62180141e-01f, -3.21809873e-02f, -1.18184984e-01f, 5.37409708e-02f, -1.37919500e-01f, 4.97668348e-02f, -1.02964349e-01f, -7.61710107e-02f, -6.13947771e-02f, -4.88669649e-02f,
  -5.65317869e-02f, 7.26561770e-02f, -8.93481914e-03f, 2.85074059e-02f, -4.16316427e-02f, -4.93379720e-02f, 5.92661090e-02f, -2.54392461e-03f, 2.85522975e-02f, -1.11116655e-01f,
  4.88183051e-02f, -8.74442384e-02f, 3.00966613e-02f, 2.06299536e-02f, -1.55324012e-01f, -6.73050731e-02f, -1.20241292e-01f, -7.28412122e-02f, -1.38364136e-01f, -7.35770985e-02f,
  -7.21464306e-02f, 4.74534594e-02f, -5.73650002e-02f, 9.05137435e-02f, -2.04875115e-02f, 7.88103119e-02f, -8.44251961e-02f, -4.52958345e-02f, -5.37717342e-03f, -6.98493347e-02f,
  -5.50019033e-02f, -3.98704819e-02f, 2.21844409e-02f, -8.49644467e-02f, -2.92037278e-02f, -8.32012668e-02f, -1.96918231e-02f, 6.55383691e-02f, -2.94484645e-02f, -1.15280911e-01f,
  3.02267279e-02f, 4.15685065e-02f, -1.26938876e-02f, -3.79385687e-02f, -2.65975092e-02f, 1.71704702e-02f, -9.24497694e-02f, -9.44203585e-02f, 1.38520701e-02f, -4.27665785e-02f,
  1.98609252e-02f, 3.46753821e-02f, -6.02099188e-02f, 7.23621845e-02f, 3.09118982e-02f, 3.67647856e-02f, -2.88987104e-02f, 3.64944711e-02f, -7.76961148e-02f, -8.89730826e-02f,
  -5.51899672e-02f, 3.10613192e-03f, 2.95868851e-02f, -8.06754362e-03f, -6.37628138e-02f, 3.48364674e-02f, 7.35928267e-02f, -5.04621565e-02f, 4.66857105e-02f, -4.98112701e-02f,
  4.79367338e-02f, -3.83224525e-02f, -4.56178412e-02f, 2.77036000e-02f, 1.69069711e-02f, -2.07392890e-02f, 8.99667665e-02f, 9.95640308e-02f, 4.73571382e-02f, -6.44155964e-02f,
  1.33980187e-02f, 7.72393569e-02f, 7.23518431e-02f, 8.77703875e-02f, -3.76452995e-03f, 4.45759557e-02f, 5.51567562e-02f, 2.41877083e-02f, -2.23032515e-02f, 5.30481301e-02f,
  -5.42875715e-02f, 6.62657544e-02f, 3.07121128e-02f, -2.73758862e-02f, 5.91416806e-02f, -3.94678675e-02f, 9.32514016e-03f, -1.02887256e-02f, -7.12559745e-02f, -4.78170738e-02f,
  2.94735115e-02f, 8.42999015e-03f, 1.26687109e-01f, 1.33950531e-01f, -5.06195202e-02f, 4.80303355e-02f, 9.01830047e-02f, -7.02004582e-02f, 7.98933655e-02f, 1.36668772e-01f,
  1.17432900e-01f, 1.39672726e-01f, 2.06224769e-02f, -7.49944570e-03f, -1.02772145e-03f, 1.36992913e-02f, -7.54533559e-02f, -9.08151940e-02f, -5.83340414e-02f, 6.44362718e-02f,
  4.76662070e-03f, -9.70857497e-03f, -2.89053898e-02f, -1.09909117e-01f, -1.19831815e-01f, -4.86074500e-02f, 3.46658926e-05f, 9.54525918e-03f, 2.15176102e-02f, -7.74679407e-02f,
  2.89665312e-02f, -7.25342035e-02f, 1.02678508e-01f, 5.03708683e-02f, -2.83548795e-03f, -1.07599586e-01f, 5.83421513e-02f, 9.33690518e-02f, 4.18837517e-02f, 5.60357198e-02f,
  5.51806204e-02f, 5.95380776e-02f, -1.21827967e-01f, 2.84353271e-02f, 3.83981094e-02f, -8.45294073e-02f, -4.84731980e-02f, -6.82177544e-02f, 3.72035243e-02f, -3.32027557e-03f,
  4.81908023e-02f, 1.62010267e-02f, -8.97317082e-02f, -4.27479148e-02f, 6.93242473e-04f, -3.39131467e-02f, -9.23146233e-02f, -2.42276043e-02f, -8.76681805e-02f, -2.97734950e-05f,
  1.02473265e-02f, 6.30937740e-02f, 2.97557078e-02f, 1.19590759e-02f, -4.74911034e-02f, -3.44823599e-02f, 3.79613638e-02f, 1.37111973e-02f, -2.03742441e-02f, 9.44705773e-03f,
  -1.43050417e-01f, -7.39257922e-03f, -6.91640973e-02f, 5.66836745e-02f, -5.01048043e-02f, -5.77999167e-02f, -9.76172984e-02f, -1.52782993e-02f, -6.68587955e-03f, 1.69854565e-03f,
  -6.73502833e-02f, 3.54035795e-02f, 4.07738145e-03f, -6.47201017e-02f, -5.06030396e-02f, -1.91308837e-02f, -7.83576071e-03f, -5.10873683e-02f, -5.96635044e-02f, 2.91312188e-02f,
  1.76688023e-02f, 4.76404205e-02f, -1.75006520e-02f, 3.09554692e-02f, 5.90847060e-02f, -7.40513206e-03f, -1.67048052e-02f, 1.30178565e-02f, -5.50522469e-02f, -7.69556537e-02f,
  -6.21544272e-02f, -1.45213318e-03f, -2.20742114e-02f, -3.68344103e-04f, 4.28851731e-02f, -7.78337717e-02f, 2.35268828e-02f, 4.81979996e-02f, -7.87759013e-03f, 1.55393463e-02f,
  -6.85410425e-02f, -6.97551966e-02f, -7.49472110e-03f, -5.90573698e-02f, -2.57270243e-02f, -4.09000441e-02f, 7.03829825e-02f, 4.36247960e-02f, 1.20517798e-02f, -1.44090420e-02f,
  1.13495449e-02f, -4.83866781e-02f, -5.00690052e-03f, 4.00211811e-02f, 2.98640244e-02f, 5.85447205e-03f, -2.44959798e-02f, 1.21789023e-01f, -4.69426773e-02f, 1.73279047e-02f,
  -8.93626139e-02f, 1.41449168e-01f, 6.54701218e-02f, -8.81306478e-04f, 1.40850663e-01f, 1.44298479e-01f, 2.28657216e-01f, 8.44381377e-02f, -7.30458722e-02f, 6.61560893e-02f,
  -9.66207031e-03f, 4.90201861e-02f, -6.97563868e-03f, -3.53310779e-02f, 1.13655709e-01f, 7.49806613e-02f, 1.44724905e-01f, -1.28494613e-02f, -8.93656462e-02f, -9.15168747e-02f,
  8.05473626e-02f, -2.46751104e-02f, 2.50955652e-02f, 5.63962795e-02f, -1.52192218e-02f, -3.61408130e-03f, 4.07278817e-03f, 8.90787020e-02f, -2.57343811e-04f, 8.07152763e-02f,
  2.71304734e-02f, 1.88512821e-03f, -4.48234901e-02f, -6.27249479e-02f, -3.55781280e-02f, -1.03597499e-01f, -2.14990880e-02f, 6.91768005e-02f, 6.01558387e-02f, 7.48902485e-02f,
  -6.45746663e-03f, -5.91973774e-02f, 6.67813569e-02f, 2.95885839e-02f, 2.41468251e-02f, -2.55982392e-03f, 3.52985784e-02f, 5.90502620e-02f, -7.27631822e-02f, 7.52634630e-02f,
  1.06651329e-01f, -6.00294955e-02f, -1.47362212e-02f, -6.43835813e-02f, -2.57799425e-03f, 1.47445714e-02f, 6.31807372e-02f, -3.01550645e-02f, 5.12302257e-02f, -6.34848773e-02f,
  -6.88129142e-02f, -6.96809813e-02f, -2.37273071e-02f, 8.02017935e-03f, -6.10925555e-02f, -1.45026166e-02f, -2.55488884e-02f, 6.98824003e-02f, 1.98598974e-03f, -2.41813809e-02f,
  -3.72417122e-02f, 4.36149649e-02f, 4.36387397e-02f, 5.71971759e-02f, -6.19342960e-02f, -7.62106758e-03f, -4.33588447e-03f, 7.74981678e-02f, 2.66379611e-05f, 4.97131869e-02f,
  3.27428281e-02f, 3.09941489e-02f, -7.48830242e-03f, 2.18643323e-02f, 4.03804565e-03f, -8.86036083e-03f, 2.41580494e-02f, -2.03247182e-02f, 1.13889854e-02f, -5.34347966e-02f,
  2.60616150e-02f, -1.19232954e-02f, -7.94705003e-03f, -6.29953146e-02f, 6.10992052e-02f, -1.28320986e-02f, 1.41113466e-02f, 2.01323256e-02f, -5.37162237e-02f, 5.29434755e-02f,
  2.11587586e-02f, 9.03743226e-03f, -3.11595686e-02f, -2.47596186e-02f, -7.56894872e-02f, 2.32832115e-02f, -4.81622145e-02f, 6.06540553e-02f, 2.08496116e-02f, 4.25684378e-02f,
  -5.08259721e-02f, 6.40655980e-02f, -7.26866024e-03f, 6.00899570e-02f, 2.79243812e-02f, -2.38530599e-02f, 4.02728766e-02f, -5.38734049e-02f, -9.90995243e-02f, -1.20708652e-01f,
  -1.97223559e-01f, 6.85932785e-02f, -6.35774732e-02f, 6.54788688e-02f, 1.12946227e-01f, -4.76587340e-02f, -8.76364124e-04f, 6.04483746e-02f, -5.35252728e-02f, -1.02784574e-01f,
  3.87942009e-02f, 9.15292874e-02f, -1.44836670e-02f, 7.05221221e-02f, -1.02509841e-01f, 2.40051132e-02f, 9.81321707e-02f, -5.39720617e-03f, -1.31228566e-01f, -2.54154229e-03f,
  1.14425778e-01f, 2.61014909e-03f, -1.26919776e-01f, -3.79755124e-02f, 7.06522018e-02f, -1.07490435e-01f, -1.29004149e-02f, 8.86163190e-02f, 5.63688353e-02f, 2.16435224e-01f,
  4.41181883e-02f, -2.11936748e-03f, -1.13396823e-01f, -2.37243474e-02f, -2.49683969e-02f, 2.21824204e-03f, 3.22467685e-02f, 2.82038711e-02f, 3.14655900e-02f, -1.52455736e-02f,
  9.48415473e-02f, -2.67813466e-02f, 8.07424784e-02f, -3.94431092e-02f, -5.35371304e-02f, -5.16348705e-02f, -1.20433688e-01f, -6.34352341e-02f, 2.39289850e-02f, -5.18071428e-02f,
  8.79973732e-03f, 1.09128706e-01f, -7.81193823e-02f, -2.86150863e-03f, 2.10994985e-02f, -1.09245576e-01f, 1.25895347e-02f, -5.81041016e-02f, -1.11543499e-01f, -1.42917586e-02f,
  -9.36172307e-02f, -2.69757956e-02f, 1.06835016e-03f, 2.23893765e-02f, 1.24699458e-01f, -1.97300725e-02f, -4.44233678e-02f, -3.26211341e-02f, -3.59364338e-02f, 7.69409630e-03f,
  2.68095005e-02f, -5.29288352e-02f, -7.44389743e-03f, 1.73215475e-03f, -9.32084545e-02f, 3.03365737e-02f, 7.93001335e-03f, 2.02133358e-02f, 3.09696351e-03f, -8.66140649e-02f,
  4.20267656e-02f, -3.17886882e-02f, 1.97864510e-02f, -6.32630661e-02f, 2.03732611e-03f, 4.58440222e-02f, 5.51292785e-02f, -1.23294808e-01f, -6.17713444e-02f, -9.76546202e-03f,
  7.18862116e-02f, 5.19380905e-02f, 4.81818952e-02f, -2.30866820e-02f, -3.15422900e-02f, 6.58200383e-02f, 1.17691569e-02f, -8.17513838e-02f, 1.62794758e-02f, -1.20585330e-01f,
  -6.74100369e-02f, -3.29935029e-02f, 2.95169987e-02f, -1.07492581e-01f, -4.19748351e-02f, 2.21964307e-02f, -1.39137842e-02f, -5.04129119e-02f, -6.99859187e-02f, 2.17567217e-02f,
  -4.62238751e-02f, -6.93185627e-02f, 1.83488224e-02f, -4.27384377e-02f, 3.32712382e-02f, -1.88697334e-02f, -2.82016974e-02f, 5.54885007e-02f, -9.85422581e-02f, -9.38498303e-02f,
  2.39110570e-02f, 2.65864022e-02f, -3.20438221e-02f, 1.05773807e-01f, 2.57132240e-02f, 1.36171103e-01f, 5.82304075e-02f, 1.08485468e-01f, 1.06567917e-02f, 8.57204013e-03f,
  8.26098956e-03f, 6.98037222e-02f, 1.03669316e-01f, 1.17980400e-02f, -5.68192229e-02f, 4.12165299e-02f, 3.90032716e-02f, -2.89282892e-02f, 1.21316453e-02f, 1.91766284e-02f,
  -5.12143262e-02f, -3.14985700e-02f, 8.05202946e-02f, 4.66191731e-02f, -2.77980268e-02f, 4.74136397e-02f, 6.87433034e-02f, 5.89277223e-02f, -1.73361879e-02f, -8.54963437e-02f,
  -1.27407447e-01f, -8.85142162e-02f, -1.51783638e-02f, -5.82572669e-02f, -5.65095171e-02f, -3.32294255e-02f, 6.66094422e-02f, -3.80724370e-02f, -6.61655813e-02f, 7.24869668e-02f,
  3.97094041e-02f, 2.93705408e-02f, 9.57001001e-02f, -3.42893861e-02f, -9.65635553e-02f, -4.07424048e-02f, -9.96654257e-02f, 2.78101675e-02f, -1.73876248e-02f, 9.18535367e-02f,
  -9.04315934e-02f, -6.83143735e-02f, 5.70014305e-03f, 7.22212046e-02f, 6.03367463e-02f, 6.45643331e-06f, 2.61548720e-02f, -4.37410995e-02f, 6.25034720e-02f, -3.09584290e-02f,
  -8.59581158e-02f, 2.38038767e-02f, 9.37087983e-02f, 8.25138241e-02f, 7.40619302e-02f, 9.53056514e-02f, 3.99066927e-03f, 2.23150793e-02f, 1.05684958e-01f, -4.60243821e-02f,
  -3.81859764e-02f, 1.04168877e-02f, -1.80629827e-02f, 6.48937374e-02f, 2.40639038e-02f, 2.92224810e-02f, -5.17260209e-02f, -5.22807464e-02f, 1.32501042e-02f, -5.20420969e-02f,
  -6.22802996e-04f, -1.41017186e-02f, -1.08566629e-02f, -5.78940380e-03f, -2.17379797e-02f, 2.58724596e-02f, -6.58971891e-02f, -2.06750017e-02f, -1.59436371e-04f, 3.27861235e-02f,
  -9.97402817e-02f, 9.96344956e-04f, -6.76540807e-02f, 1.16406485e-01f, -8.20413083e-02f, -5.45885637e-02f, 4.82811332e-02f, 4.10681330e-02f, -1.02189742e-01f, -2.84116976e-02f,
  2.97220461e-02f, -1.60556997e-03f, 1.12211473e-01f, -4.06016558e-02f, 2.85103787e-02f, 9.81089771e-02f, -5.29417321e-02f, 7.17476159e-02f, -6.14382923e-02f, 3.90732214e-02f,
  8.46464280e-03f, 5.71990833e-02f, 6.30778307e-03f, 9.30247381e-02f, -7.61331350e-04f, -5.26901595e-02f, -3.91837433e-02f, -6.09289482e-02f, -4.66031469e-02f, 1.17307842e-01f,
  -3.55221868e-01f, 5.60475104e-02f, 3.23879533e-02f, 6.07914291e-02f, 1.13041304e-01f, 1.65016279e-01f, 3.54428560e-01f, 2.76233107e-01f, 1.14031337e-01f, 1.16217986e-01f,
  3.74128111e-03f, -6.61987290e-02f, 1.62505135e-02f, 6.48880228e-02f, 1.84915494e-02f, 2.77733028e-01f, 1.43677890e-01f, 1.16703488e-01f, 8.29923004e-02f, 3.68491895e-02f,
  1.14929199e-01f, -1.21851258e-01f, -6.45541549e-02f, -8.96969996e-03f, 8.41362327e-02f, -5.58761694e-02f, 4.62668091e-02f, -2.81312317e-02f, 4.60608155e-02f, 9.36766900e-03f,
  -1.90757915e-01f, -4.04467992e-02f, -1.28285494e-03f, -1.16698720e-01f, -1.44125465e-02f, -8.01999718e-02f, -3.93584520e-02f, -9.83849615e-02f, -6.66937754e-02f, 3.87322865e-02f,
  4.84156050e-02f, 2.16491427e-03f, 7.86171481e-02f, 1.70161054e-02f, 1.26228109e-02f, -1.91710482e-03f, 7.99867231e-03f, 9.36980695e-02f, -3.98197733e-02f, -5.20969294e-02f,
  5.57719357e-02f, -3.29704024e-03f, 5.47566675e-02f, 6.63219318e-02f, 5.82272932e-02f, 2.09300537e-02f, -1.75593868e-02f, -3.76667194e-02f, -2.85948962e-02f, 1.39445579e-02f,
  -8.86938069e-03f, -6.11135513e-02f, 6.08143508e-02f, -2.17729993e-02f, 8.10360387e-02f, 6.67482689e-02f, 7.87090510e-02f, 2.12091673e-02f, 3.85146327e-02f, -6.37787068e-03f,
  2.53582411e-02f, -1.85765885e-02f, 5.79247475e-02f, 9.89574566e-03f, 1.29694054e-02f, -3.51452567e-02f, 5.39398566e-02f, 7.18976706e-02f, 6.00996315e-02f, -2.83451322e-02f,
  -1.87707376e-02f, -6.97204918e-02f, 1.87290069e-02f, 6.83537275e-02f, -3.36262994e-02f, 1.84804611e-02f, 1.10898660e-02f, -3.85626890e-02f, -1.87832154e-02f, 2.67080348e-02f,
  -2.11936489e-01f, -7.34613836e-02f, 3.22232060e-02f, 4.29269932e-02f, -3.37605700e-02f, -1.01098709e-01f, -5.30319922e-02f, 3.70152108e-02f, -6.78754672e-02f, -3.64390276e-02f,
  -3.74514721e-02f, 1.02273999e-02f, -9.00321230e-02f, -3.49438079e-02f, -4.92005311e-02f, -1.84381064e-02f, 6.42963452e-03f, 6.42042533e-02f, 2.08581258e-02f, -9.71817735e-06f,
  1.09519057e-01f, 3.09653096e-02f, -2.35022418e-02f, 1.12735413e-01f, -1.00321397e-02f, -8.83095041e-02f, -5.08759618e-02f, 5.17868102e-02f, 7.73771852e-02f, -8.37511569e-02f,
  -1.83937669e-01f, -1.06518313e-01f, -2.40059555e-01f, 1.47771493e-01f, 1.05944782e-01f, -5.02744280e-02f, -1.66536734e-01f, -1.12924539e-01f, 1.54603004e-01f, 3.74171101e-02f,
  5.69357052e-02f, 1.34635150e-01f, 6.64993748e-02f, -6.60281479e-02f, -1.41718939e-01f, -6.05685078e-02f, 6.00524768e-02f, -8.10050443e-02f, -8.12707096e-02f, -3.57108712e-02f,
  8.60051364e-02f, 5.73137514e-02f, -6.04116023e-02f, -1.13652989e-01f, 1.17946953e-01f, -2.80322181e-03f, 2.84870267e-02f, 2.75156777e-02f, -6.64543882e-02f, 1.60051391e-01f,
  8.22575241e-02f, -3.44071127e-02f, 2.85772607e-02f, 2.55751554e-02f, -9.05345194e-03f, 6.79497197e-02f, -9.42005962e-02f, -2.67025596e-03f, 4.84279841e-02f, -7.44718313e-02f,
  9.43123847e-02f, 4.25736494e-02f, 1.01030074e-01f, -1.64666828e-02f, -2.95496508e-02f, -1.00024186e-01f, -2.42428035e-02f, -1.05569042e-01f, -1.30481228e-01f, 2.00775024e-02f,
  7.13680610e-02f, 6.07878640e-02f, -7.47642517e-02f, -1.23243891e-01f, -4.70745750e-02f, 5.59779853e-02f, -2.51590051e-02f, -8.65426511e-02f, -1.25807717e-01f, -3.85980941e-02f,
  1.16949387e-01f, 3.81369479e-02f, 3.86802480e-02f, -1.03761367e-01f, -5.14794067e-02f, 2.35959640e-04f, 1.12340897e-01f, 3.91389169e-02f, 7.59826042e-03f, -7.38858581e-02f,
  5.55567257e-02f, 3.24606448e-02f, -1.88910905e-02f, 5.90118170e-02f, -1.10993553e-02f, 2.15839483e-02f, 5.36132753e-02f, -1.06601827e-01f, -2.59141177e-02f, 2.60575861e-02f,
  -1.08458977e-02f, -1.50327841e-02f, 6.40644431e-02f, 3.45748290e-02f, -8.55129138e-02f, -3.51074785e-02f, 5.58250695e-02f, 1.37425903e-02f, -6.23634122e-02f, -1.03431553e-01f,
  9.48337168e-02f, -4.63008620e-02f, -3.24973799e-02f, 3.18184383e-02f, 2.19290257e-02f, -2.03551911e-02f, 6.66925013e-02f, -5.55991866e-02f, -3.09383329e-02f, -6.98484182e-02f,
  -1.17820725e-02f, -5.57374060e-02f, -4.12261300e-02f, 5.09880818e-02f, 1.24514764e-02f, 1.26100676e-02f, -5.59835769e-02f, -1.10993944e-02f, 1.33627169e-02f, -3.27979610e-03f,
  -3.31391953e-02f, -1.12112910e-01f, -2.85969023e-02f, -7.04858080e-02f, 2.43886895e-02f, -5.23557290e-02f, -1.11269616e-01f, -4.35248613e-02f, -6.81276545e-02f, -7.84309506e-02f,
  -1.08492896e-01f, 3.97079401e-02f, -2.43113879e-02f, -7.03155473e-02f, -2.68162861e-02f, 9.50413048e-02f, 4.91931438e-02f, 8.32671206e-03f, -6.61992803e-02f, -6.27455534e-03f,
  9.87005159e-02f, 9.96474996e-02f, -5.21269487e-03f, 1.13361776e-01f, -2.73524337e-02f, -6.07631430e-02f, -5.35659567e-02f, 5.29598966e-02f, 6.83777183e-02f, 6.56759040e-03f,
  -3.70642245e-02f, -8.02057385e-02f, -1.18514281e-02f, -6.89537358e-03f, 7.17725605e-02f, -2.63940375e-02f, -5.98727055e-02f, 2.88892016e-02f, 1.00644361e-02f, -2.15967139e-03f,
  8.50931704e-02f, -2.40501594e-02f, -1.16219409e-02f, 5.88924251e-02f, -3.14526935e-03f, -2.89393123e-02f, 5.47001436e-02f, 8.59353393e-02f, -8.90628174e-02f, 5.61230406e-02f,
  -1.58048477e-02f, -7.96626061e-02f, -5.33856750e-02f, 5.92571869e-02f, 6.98752701e-02f, -6.40354604e-02f, 3.03182453e-02f, -7.81017244e-02f, 3.13250013e-02f, -1.02492981e-02f,
  3.87755334e-02f, -5.98621853e-02f, -4.53504659e-02f, -4.81074080e-02f, 4.75650467e-02f, 3.64607982e-02f, 9.86184180e-02f, -1.41271874e-02f, -4.70863376e-03f, -8.95105361e-04f,
  -3.48360762e-02f, 4.13371995e-02f, -9.07191783e-02f, -5.80630824e-02f, -5.61148115e-03f, 2.56101228e-03f, 2.65699811e-02f, 4.29705009e-02f, -4.76349369e-02f, 4.45966721e-02f,
  -4.46880721e-02f, -3.79389748e-02f, -7.73823485e-02f, 7.20361620e-02f, -6.74188286e-02f, 1.33101782e-02f, -6.33945614e-02f, 4.25097607e-02f, -1.70877315e-02f, 3.48342732e-02f,
  6.03421107e-02f, -1.70292780e-02f, -2.94341147e-02f, -2.22670939e-03f, 8.18389058e-02f, -1.35210836e-02f, 9.06861108e-03f, -1.98343005e-02f, -1.05715826e-01f, -6.27160519e-02f,
  1.16949439e-01f, -6.53374493e-02f, -2.02918295e-02f, 6.62347488e-03f, 9.68810394e-02f, -1.52484551e-02f, 2.70971339e-02f, 1.23384848e-01f, 7.26515502e-02f, 3.68941464e-02f,
  -3.31448503e-02f, -4.29761223e-02f, -3.23224962e-02f, -5.08049466e-02f, 4.08086702e-02f, -5.03484048e-02f, -2.29800139e-02f, -2.74399593e-02f, -1.71221700e-02f, -5.71640655e-02f,
  4.89309542e-02f, 1.60918571e-02f, -1.50924632e-02f, -5.08203395e-02f, 8.21436103e-03f, 6.46872669e-02f, 1.22348137e-01f, 8.55346546e-02f, 5.23562096e-02f, -4.32998873e-03f,
  -1.27305999e-01f, 1.51485339e-01f, 1.54838681e-01f, -7.49650970e-02f, -1.03506535e-01f, -2.42431685e-01f, -2.54298955e-01f, -5.60063235e-02f, -1.27441630e-01f, 1.34797841e-02f,
  1.80885531e-02f, -2.13983748e-02f, 1.83397327e-02f, 2.69298372e-03f, 4.24014553e-02f, 4.24737185e-02f, 6.89216256e-02f, 5.51102795e-02f, -2.38800123e-02f, -2.75234971e-02f,
  2.49060299e-02f, 2.88185906e-02f, 8.81407112e-02f, -1.30214155e-01f, 1.68627039e-01f, -6.62434706e-03f, -1.24328835e-02f, 7.12918118e-02f, 1.18640149e-02f, 1.90260261e-01f,
  1.16442434e-01f, -1.16390688e-02f, 5.63323963e-03f, 1.48436412e-01f, 1.00598112e-01f, -4.66868058e-02f, 1.64125990e-02f, 3.29499878e-02f, 2.61790548e-02f, 6.84855282e-02f,
  -3.08537856e-02f, -7.02991933e-02f, -6.14527054e-02f, 1.81992315e-02f, 6.22268207e-02f, 6.08543195e-02f, -1.83038935e-02f, 7.91222081e-02f, 3.03268600e-02f, 5.09376638e-02f,
  -5.94451055e-02f, -1.05263278e-01f, -5.16870618e-03f, -6.67300299e-02f, 7.98641518e-02f, -1.32556437e-02f, -6.91976249e-02f, 8.47269148e-02f, -1.84769761e-02f, -2.69135684e-02f,
  -2.17860118e-02f, -1.90409794e-02f, -5.60969412e-02f, 3.75155583e-02f, -2.25487649e-02f, 7.42228478e-02f, -9.67507809e-02f, 4.06338461e-02f, -9.63243023e-02f, 8.45446289e-02f,
  -3.32439831e-03f, -5.74041903e-02f, 6.83320239e-02f, -1.53097389e-02f, 1.44399880e-02f, -3.01878266e-02f, -5.55807315e-02f, 1.98181327e-02f, -4.59910510e-03f, -3.44980285e-02f,
  7.84858987e-02f, -2.81181047e-03f, -4.43992279e-02f, 6.57012239e-02f, 5.71481548e-02f, 9.06708464e-03f, -3.82822901e-02f, 2.49298755e-03f, -5.09070884e-03f, -5.23199188e-03f,
  4.14185822e-02f, 1.41271588e-03f, 5.95784225e-02f, 4.38312739e-02f, -6.90352172e-03f, -4.69517373e-02f, -7.20493868e-03f, -2.94648837e-02f, 7.24542886e-02f, 2.41279248e-02f,
  -6.19488321e-02f, -3.93198431e-02f, -3.54913399e-02f, -5.20942397e-02f, -4.76343818e-02f, -2.28501260e-02f, -5.58164790e-02f, 2.45978069e-02f, -5.12405522e-02f, 6.17483929e-02f,
  -4.63118851e-02f, -1.51281700e-01f, -1.48603082e-01f, -6.65908754e-02f, -7.54913390e-02f, -1.36740834e-01f, -4.39562909e-02f, -7.20665827e-02f, -6.57740161e-02f, -1.05238251e-01f,
  -3.04857105e-01f, 1.30055100e-01f, 1.71873167e-01f, -1.87085554e-01f, 5.60819693e-02f, 1.31682262e-01f, 5.00381105e-02f, -9.89548713e-02f, -1.25129893e-01f, 1.14042923e-01f,
  -3.25020999e-02f, -2.77629215e-02f, 2.84472071e-02f, 7.75541440e-02f, -5.36643639e-02f, 1.68014899e-01f, 6.11580238e-02f, 7.63847306e-02f, -4.25643437e-02f, -1.62420925e-02f,
  7.45188370e-02f, -1.63080826e-01f, -1.58476457e-01f, -1.38253823e-01f, -1.16984405e-01f, -7.77099729e-02f, -4.04885076e-02f, -7.53903314e-02f, 1.87481329e-01f, 6.95363358e-02f,
  2.23736748e-01f, -1.11445941e-01f, -6.55840784e-02f, -7.15224892e-02f, 3.14537399e-02f, 7.88508542e-03f, -3.11750267e-02f, -9.59013682e-03f, -8.01697969e-02f, 2.31581293e-02f,
  2.29091551e-02f, -1.34556275e-02f, -2.36395262e-02f, -4.00393195e-02f, -6.19251058e-02f, 2.52825487e-02f, 4.20679525e-02f, -8.19215365e-03f, 1.84537824e-02f, 6.34224489e-02f,
  1.04036883e-01f, -4.72306609e-02f, -2.94657964e-02f, 1.02858283e-01f, -1.61630064e-02f, -7.46088549e-02f, -3.71409692e-02f, 6.26336709e-02f, 7.66519085e-02f, -2.60531884e-02f,
  7.31939683e-03f, -2.48145359e-03f, -4.02342528e-02f, 5.18682692e-03f, 1.10229179e-02f, -8.27639326e-02f, 7.89479911e-02f, 7.91717544e-02f, -7.16777816e-02f, 4.45918851e-02f,
  -6.53909147e-02f, 1.07870355e-01f, 2.21912339e-02f, 1.42419348e-02f, 7.72739435e-03f, 1.07196542e-02f, -2.96582971e-02f, 1.32176774e-02f, -6.43167868e-02f, 7.14717992e-03f,
  -4.08497266e-02f, -7.05726445e-02f, 2.94666062e-03f, 6.12493046e-03f, 1.90832391e-02f, 2.97533274e-02f, -9.84376855e-03f, 7.25802258e-02f, -1.21032298e-02f, -2.13102791e-02f,
  -7.43591338e-02f, -2.93620303e-02f, 3.76565903e-02f, -8.41510966e-02f, 3.54925171e-02f, -8.32754560e-03f, 7.91283417e-03f, -6.13139942e-03f, -6.11799359e-02f, 2.48373253e-03f,
  -8.82199779e-03f, -2.46870015e-02f, -3.34863551e-02f, 7.74647668e-02f, 4.53527458e-02f, 1.33593464e-02f, -1.35293547e-02f, -5.74787520e-02f, -5.01882620e-02f, -1.47923930e-02f,
  -5.39242066e-02f, -9.08783171e-04f, -2.04045717e-02f, -5.85993789e-02f, 3.28416862e-02f, 8.66508856e-02f, 7.28059858e-02f, 7.19272718e-02f, 2.61571221e-02f, -1.47855738e-02f,
  1.15097784e-01f, -3.06070268e-01f, 2.03067333e-01f, 2.16423515e-02f, 9.05061737e-02f, 1.62333086e-01f, -1.07332570e-02f, -8.90854001e-03f, 8.85526687e-02f, -2.06111167e-02f,
  -1.00925148e-01f, -4.20271233e-02f, -6.33419678e-02f, 6.48438111e-02f, -3.59420031e-02f, -2.76927557e-02f, 2.35802811e-02f, 4.05125841e-02f, 7.86639303e-02f, 1.14590712e-01f,
  -1.09421328e-01f, -3.72490883e-02f, 6.37525916e-02f, -7.15280324e-02f, 8.12328514e-03f, 2.08212472e-02f, 2.94533651e-02f, -1.92481149e-02f, -4.57528308e-02f, -5.88402227e-02f,
  -2.15222687e-02f, -6.24070503e-02f, 1.60333455e-01f, 6.77720979e-02f, 5.85707799e-02f, 3.41754071e-02f, -3.08842491e-02f, 9.24514793e-03f, 5.04705645e-02f, 1.36264740e-02f,
  3.59673202e-02f, -1.86387729e-02f, -2.68070912e-03f, -3.11542060e-02f, 3.48026231e-02f, 5.31806573e-02f, -1.08716257e-01f, -8.90969336e-02f, -6.68597892e-02f, -1.65756345e-02f,
  -1.48043990e-01f, -6.06089681e-02f, 8.19414482e-02f, -7.84923136e-03f, -3.33304927e-02f, -2.24658251e-02f, 7.68961525e-03f, -2.79366951e-02f, 6.61855517e-03f, -8.33247975e-02f,
  -5.90852834e-02f, 1.15510955e-01f, 3.84171605e-02f, 7.86968041e-03f, -1.60622075e-02f, 3.87645885e-02f, -3.10379677e-02f, -4.72825281e-02f, 4.40355055e-02f, -1.46109117e-02f,
  -9.01801586e-02f, 3.99200320e-02f, -7.77804926e-02f, -4.40477952e-02f, -3.17113586e-02f, 1.27039915e-02f, 6.40661642e-02f, -5.04418463e-03f, -1.60056017e-02f, -2.72757583e-03f,
  2.55901478e-02f, 9.19378176e-02f, -4.52909881e-04f, -8.27678591e-02f, -2.07563788e-02f, 7.00129941e-02f, -3.24853435e-02f, 7.43072014e-03f, 4.26808139e-03f, 6.85817003e-02f,
  9.99353379e-02f, 9.60273072e-02f, 1.18370257e-01f, 2.96023791e-03f, 2.81886216e-02f, 7.35204155e-03f, 6.81248233e-02f, 7.68657075e-03f, -1.81923267e-02f, 9.36959237e-02f,
  -5.23001552e-02f, -4.18912992e-02f, -1.05441742e-01f, -5.08034192e-02f, 3.37393470e-02f, 3.07404529e-02f, -3.86202559e-02f, -2.34360136e-02f, 4.81091067e-02f, -1.94232017e-02f,
  -1.60153732e-01f, 1.30477741e-01f, 3.57354172e-02f, 7.84395933e-02f, 8.16029459e-02f, 1.55741349e-01f, 1.12619035e-01f, 8.85452330e-02f, 5.19999377e-02f, 7.80904144e-02f,
  8.26406851e-02f, 5.34981042e-02f, 1.55911623e-02f, -4.07079011e-02f, -7.36098364e-03f, -5.62474914e-02f, -8.01634118e-02f, -7.20754936e-02f, -3.20408009e-02f, -3.08022387e-02f,
  -9.31619573e-03f, 8.07680562e-03f, -9.78833064e-02f, -6.20976230e-03f, -8.28787163e-02f, 2.19624396e-03f, -9.93422791e-02f, -1.63359150e-01f, -1.24003276e-01f, -4.22750823e-02f,
  -2.64415760e-02f, 6.83156326e-02f, 3.05571258e-02f, -1.04617327e-01f, -5.11266962e-02f, 5.11711948e-02f, -3.12810838e-02f, 4.53010947e-03f, -9.55097154e-02f, 8.04702863e-02f,
  2.21738890e-02f, -5.55262603e-02f, -6.24865107e-02f, 4.06344160e-02f, -5.31776510e-02f, 4.11326326e-02f, 1.88666116e-02f, -8.25068653e-02f, 6.48501143e-02f, -1.18562197e-02f,
  -7.64334723e-02f, -2.04770472e-02f, 3.36648636e-02f, -5.23410216e-02f, -4.14168835e-02f, -1.76778212e-02f, -1.30777759e-02f, -7.39790052e-02f, -1.03273191e-01f, 6.05288446e-02f,
  7.33193979e-02f, -4.68795821e-02f, -7.45819882e-02f, -7.20322728e-02f, 8.06464814e-03f, -1.90621335e-02f, -6.70961887e-02f, 7.62886032e-02f, 7.24901110e-02f, 6.36202395e-02f,
  -7.02805221e-02f, -6.07013851e-02f, 1.90449730e-02f, 9.73953828e-02f, -8.95857532e-03f, 9.93772037e-03f, -4.83558401e-02f, -6.22546822e-02f, -4.29691449e-02f, 4.94742841e-02f,
  -3.52219567e-02f, -7.05261528e-02f, 6.19708037e-04f, 1.82525180e-02f, -9.54522286e-03f, -1.23058166e-03f, -6.78701252e-02f, 4.78019044e-02f, -3.25293504e-02f, 3.15782242e-03f,
  -9.90159251e-03f, -1.23978183e-02f, -1.40748397e-02f, -2.31607873e-02f, 5.32048717e-02f, 6.43097013e-02f, -9.01598781e-02f, 6.78997710e-02f, -2.75126658e-03f, 4.96568345e-02f,
  1.72293857e-02f, -2.66931411e-02f, 5.61888702e-02f, -4.99061309e-02f, -7.16658635e-03f, -7.89893195e-02f, 7.38522708e-02f, 7.29261106e-03f, 7.43807033e-02f, 1.03191562e-01f,
  8.44912082e-02f, -4.39248346e-02f, -1.59781575e-02f, -7.36637115e-02f, 3.40847000e-02f, 2.94055808e-02f, 6.98782457e-03f, 3.96135785e-02f, -4.13126945e-02f, 1.09660782e-01f,
  9.78348479e-02f, 4.33857180e-02f, 8.46304819e-02f, 3.80327106e-02f, 1.35575337e-02f, -7.31773973e-02f, -4.91857268e-02f, 6.43114299e-02f, 7.18134036e-03f, -1.51834730e-02f,
  1.38048336e-01f, 1.95273831e-01f, 7.34113902e-02f, -7.21355006e-02f, -1.19800366e-01f, -9.49838459e-02f, -1.16254106e-01f, -6.10234961e-02f, -5.19978814e-02f, 6.06788509e-03f,
  6.90182820e-02f, -6.68770000e-02f, 1.03328988e-01f, -3.72699201e-02f, -4.95962799e-02f, 4.70180437e-02f, 2.28850096e-02f, -9.50091332e-02f, -4.88295145e-02f, -1.20983362e-01f,
  -8.21859613e-02f, -1.23722362e-03f, 4.53898199e-02f, 3.87542620e-02f, 1.54218003e-01f, -2.35988963e-02f, -6.90485686e-02f, 2.03185901e-02f, 1.97555940e-03f, 1.73503533e-01f,
  8.37016106e-02f, 6.54788921e-03f, 4.59078932e-03f, 1.17244817e-01f, 8.06815848e-02f, 9.17798281e-02f, -2.12551206e-02f, -7.32787326e-03f, 1.85508709e-02f, -7.22537637e-02f,
  7.86015242e-02f, -5.61619624e-02f, 5.22263013e-02f, -5.70592377e-03f, 7.94770941e-03f, 1.55987041e-02f, 2.65495032e-02f, -1.27339244e-01f, 5.38473390e-02f, 5.89484349e-02f,
  -1.20695354e-02f, -3.82638536e-02f, -7.68021196e-02f, -6.55287579e-02f, -6.73833936e-02f, -4.34029335e-03f, -6.11375980e-02f, -6.98227342e-03f, 1.21363737e-02f, 7.72623718e-02f,
  -2.70248819e-02f, 3.57997566e-02f, 5.93175702e-02f, 1.17100468e-02f, 2.03769170e-02f, 5.56010976e-02f, 6.30054565e-05f, -3.95074189e-02f, -6.99930564e-02f, -4.96582463e-02f,
  2.26404890e-03f, 2.16490608e-02f, 5.34713781e-03f, -3.58717865e-03f, 2.08003614e-02f, 2.41404790e-02f, 3.29962224e-02f, -9.83462110e-03f, -4.09451164e-02f, 2.22907811e-02f,
  -6.19202070e-02f, -1.65548699e-03f, -4.46991622e-03f, 4.64519002e-02f, 1.80947930e-02f, -9.54078883e-02f, 4.27099355e-02f, 8.37867055e-03f, -7.10289031e-02f, -2.51342356e-02f,
  -6.80327788e-02f, -1.55213043e-01f, 2.43977048e-02f, -4.35417071e-02f, 7.86151215e-02f, -2.82657556e-02f, 9.69718471e-02f, 4.81192581e-02f, -9.44459438e-03f, 4.68213037e-02f,
  5.26533276e-02f, 6.25837818e-02f, 5.53896800e-02f, 7.69538879e-02f, -6.49193907e-03f, 2.87324656e-02f, -9.37404670e-03f, -3.80965732e-02f, -1.58234946e-02f, 1.64937135e-02f,
  -4.29340415e-02f, -9.24159661e-02f, -1.58405870e-01f, -4.30267826e-02f, -2.86553148e-03f, 8.12590495e-03f, 1.50441462e-02f, 4.76745218e-02f, -8.54224414e-02f, -7.29941949e-02f,
  -8.28477293e-02f, 1.38576120e-01f, 5.08326665e-02f, -1.13745071e-01f, -9.30354893e-02f, 1.02116778e-01f, 9.62114334e-02f, -3.66359316e-02f, -1.52964607e-01f, -2.24811509e-02f,
  5.81772029e-02f, 4.64065038e-02f, -1.43724652e-02f, 8.50494429e-02f, 1.08127736e-01f, 1.24423049e-01f, 1.00386944e-02f, 6.13131896e-02f, 9.80900675e-02f, 4.22424525e-02f,
  -5.06241247e-02f, -1.49868041e-01f, -1.68570444e-01f, 2.52384543e-02f, -5.48409298e-02f, -2.30485690e-03f, -8.33373889e-02f, -1.02566198e-01f, 1.42811671e-01f, -9.34983566e-02f,
  2.61150539e-01f, -1.61175326e-01f, 9.76353362e-02f, 1.51502742e-02f, -4.00060527e-02f, 6.69829696e-02f, -8.70921090e-03f, -5.27964532e-02f, -6.21242449e-02f, -3.33224833e-02f,
  -2.02924535e-02f, -6.74558356e-02f, 4.13378812e-02f, -2.02086233e-02f, 2.15508621e-02f, 8.48355610e-03f, -8.80407691e-02f, -8.77996609e-02f, -3.30434740e-02f, -3.21986363e-03f,
  5.09687625e-02f, -7.88245425e-02f, -7.74202645e-02f, -2.99470350e-02f, 4.92076427e-02f, 1.69504415e-02f, 7.48953298e-02f, 3.87669578e-02f, -7.84523711e-02f, 1.08321225e-02f,
  -1.20272068e-02f, -5.00620389e-03f, -2.01335885e-02f, -5.75485118e-02f, -7.55953118e-02f, 1.51401358e-02f, 2.78894342e-02f, -5.01371287e-02f, 1.03951879e-02f, 1.85173508e-02f,
  3.96296829e-02f, 9.43473801e-02f, -1.01100765e-01f, 5.32463007e-03f, -5.71525015e-04f, 4.84247953e-02f, 5.79193495e-02f, -4.58940603e-02f, 4.23337109e-02f, 1.03599280e-02f,
  1.30821895e-02f, -1.00840837e-01f, 2.65235291e-03f, -1.67878028e-02f, 8.60029832e-02f, -5.26338220e-02f, 4.51747281e-03f, 2.01180633e-02f, 5.70421442e-02f, 5.06208949e-02f,
  -1.35485232e-01f, 6.00759983e-02f, 1.03717931e-01f, -1.13758117e-01f, -2.30223313e-03f, -3.65524031e-02f, -3.98284532e-02f, -6.40125275e-02f, -5.07854111e-02f, 1.93355232e-03f,
  6.44208714e-02f, 5.76148294e-02f, -2.69049015e-02f, 4.87191491e-02f, 3.93856056e-02f, -7.43776094e-03f, -4.51698862e-02f, 4.36417870e-02f, -7.61671783e-03f, 9.30042118e-02f,
  2.10844539e-02f, 4.51555215e-02f, -7.38821700e-02f, 7.74163008e-02f, -4.47077351e-03f, -1.01580054e-01f, 7.24619180e-02f, -8.85089561e-02f, 3.59750427e-02f, 5.78479841e-02f,
  1.11722492e-01f, 1.28611267e-01f, 1.09240144e-01f, -2.61580013e-02f, 1.09971471e-01f, -5.29645830e-02f, -1.95918456e-02f, -5.78356273e-02f, -1.15260612e-02f, -1.65555999e-02f,
  2.30405461e-02f, -7.63582587e-02f, 4.76939417e-02f, 1.93575639e-02f, 3.26376781e-02f, 3.04943845e-02f, -6.27363548e-02f, 7.45684728e-02f, 5.25993183e-02f, -7.52919614e-02f,
  4.29008342e-02f, 7.10572451e-02f, -1.94222927e-02f, -4.22317795e-02f, -3.82220894e-02f, -9.05627906e-02f, 2.44326405e-02f, 5.37871644e-02f, -2.55132001e-02f, -3.72324768e-03f,
  -6.01401404e-02f, 9.95990708e-02f, 2.21466459e-03f, -1.91740058e-02f, -5.55570647e-02f, 2.88471114e-02f, -1.48834744e-02f, 2.49349568e-02f, 2.37213448e-02f, 4.18105870e-02f,
  -3.02453097e-02f, -2.75015011e-02f, -3.36829498e-02f, 6.09585792e-02f, -5.50020672e-02f, 2.90298704e-02f, 5.57795092e-02f, -5.57754515e-03f, -6.39551133e-02f, 5.88945709e-02f,
  5.50055597e-03f, 1.25035286e-01f, 1.36141360e-01f, 4.76602912e-02f, 5.22178635e-02f, 5.18780723e-02f, 5.97583354e-02f, -2.28165556e-02f, -1.05169108e-02f, 1.51545592e-02f,
  -1.20342545e-01f, -8.77836496e-02f, -3.65347066e-03f, -7.56176561e-02f, -1.46439262e-02f, 3.11187897e-02f, -5.80063201e-02f, 3.75029780e-02f, -8.05611238e-02f, 4.49578017e-02f,
  8.13546032e-02f, -8.89145136e-02f, 2.81957146e-02f, -5.01900725e-02f, -7.47523597e-03f, 7.34968856e-02f, 2.03224923e-02f, -1.09289074e-02f, 6.27325252e-02f, 6.62248880e-02f,
  -7.12746531e-02f, -7.26792123e-03f, -4.67303842e-02f, -4.70535681e-02f, 2.93968879e-02f, 4.92131338e-02f, 5.73517121e-02f, -6.52779862e-02f, 3.55579332e-03f, -9.79868695e-02f,
  -6.05687238e-02f, -4.57632914e-03f, 4.43915166e-02f, 3.24464543e-03f, 8.31876695e-02f, 1.84814315e-02f, 1.00839138e-01f, -3.76768745e-02f, -4.89758551e-02f, -4.29905988e-02f,
  1.50560793e-02f, -8.63291025e-02f, -8.47142562e-03f, -5.23650423e-02f, 6.89009354e-02f, 7.02141374e-02f, -1.44368233e-02f, 5.26231676e-02f, -3.17264423e-02f, -2.33062208e-02f,
  7.92496931e-03f, -4.37479615e-02f, 7.48708397e-02f, -1.24892192e-02f, 8.88767093e-02f, 8.37573782e-02f, 8.50445181e-02f, 7.37976357e-02f, 9.59966555e-02f, 5.65552153e-02f,
  8.57337788e-02f, 1.97388716e-02f, 1.13405891e-01f, -2.53194384e-02f, 5.38190380e-02f, 1.47162721e-01f, 1.72262743e-01f, 5.53092472e-02f, 3.57371643e-02f, -3.91795440e-03f,
  -7.28899688e-02f, -2.24824296e-03f, -1.07059777e-01f, -3.89636698e-04f, -8.36129412e-02f, -3.46757583e-02f, 1.21034887e-02f, 5.84442243e-02f, 1.31602511e-01f, 9.45711881e-03f,
  -3.27696726e-02f, 6.36104643e-02f, 3.59285958e-02f, 1.04343630e-01f, -2.52788905e-02f, -4.16114256e-02f, 8.88176411e-02f, 9.08741821e-03f, -4.24226485e-02f, -5.00201173e-02f,
  1.95937827e-01f, 9.34259742e-02f, 6.76085576e-02f, -1.16621867e-01f, 7.27893934e-02f, -8.93521160e-02f, 6.15746789e-02f, -1.25661314e-01f, -1.05857320e-01f, 7.79795051e-02f,
  4.29678634e-02f, 1.51262507e-02f, -7.38455951e-02f, -1.25260660e-02f, -6.10741004e-02f, 9.83734727e-02f, 5.11925248e-03f, -1.60523938e-04f, -1.31403254e-02f, 6.00665286e-02f,
  -1.15938991e-01f, -1.96457002e-02f, 8.48650634e-02f, 7.22422600e-02f, -5.80467843e-03f, 3.07677127e-02f, -3.39798233e-03f, -5.26667899e-03f, -5.34397811e-02f, 8.50153938e-02f,
  4.51523252e-02f, -6.29933476e-02f, -4.07406725e-02f, -7.10979253e-02f, 2.98262164e-02f, -9.50962082e-02f, 4.06425297e-02f, 5.27831949e-02f, 1.62322773e-03f, -3.85414213e-02f,
  9.46130604e-05f, 6.01074398e-02f, 6.42516986e-02f, 2.37210691e-02f, -1.15473447e-02f, -6.99435323e-02f, -1.05677801e-03f, -6.99491203e-02f, 2.94523127e-03f, -1.01340935e-01f,
  2.06305310e-02f, 3.23081091e-02f, -6.00705575e-03f, 3.32287252e-02f, 4.76630181e-02f, 3.33806276e-02f, 9.64025967e-03f, 2.60445736e-02f, -7.33200833e-02f, -3.26198153e-02f,
  -5.08841090e-02f, -1.11194879e-01f, -3.86344194e-02f, -7.41244629e-02f, 3.44112180e-02f, -3.60227004e-02f, 6.86274543e-02f, 1.35553293e-02f, 4.01253812e-02f, 8.82756040e-02f,
  1.30675867e-01f, 6.24462403e-02f, -1.22527881e-02f, -1.26114115e-02f, 4.08743322e-02f, -8.33816081e-02f, -1.04341889e-02f, -4.26429976e-03f, 4.62149419e-02f, -5.81202060e-02f,
  -5.12746386e-02f, 1.04218371e-01f, -6.76689669e-02f, 6.47612512e-02f, 9.31461900e-02f, -6.35905489e-02f, 1.74598899e-02f, 5.32958061e-02f, -4.50298116e-02f, 2.93614287e-02f,
  9.65720862e-02f, -4.84688953e-02f, -1.72296047e-01f, 2.13006437e-02f, -3.49608324e-02f, 4.40412521e-04f, -1.72235649e-02f, 1.07139543e-01f, 9.84011889e-02f, -5.34017310e-02f,
  6.37586117e-02f, 1.84519976e-01f, 4.78392281e-02f, -7.45942118e-03f, 1.01189584e-01f, -4.37242985e-02f, -5.12381606e-02f, -6.94992691e-02f, 1.63571373e-01f, 8.99357945e-02f,
  -2.11999156e-02f, 9.99302566e-02f, 1.45372450e-02f, 1.24793492e-01f, 2.65468117e-02f, 1.30648178e-03f, -1.44113451e-01f, -1.77170172e-01f, 1.09658239e-03f, -2.06094205e-01f,
  4.41890918e-02f, -6.93216771e-02f, 5.04251430e-03f, 1.02395475e-01f, 3.78305689e-02f, 7.63044059e-02f, -7.60627761e-02f, -2.17816439e-02f, 3.91456038e-02f, -5.72660230e-02f,
  -1.33915860e-02f, -5.48393540e-02f, -9.11976919e-02f, 2.37107910e-02f, -8.21075961e-02f, 1.87751241e-02f, -7.24972561e-02f, -1.01917483e-01f, -8.18557814e-02f, -7.37933666e-02f,
  -6.19107261e-02f, -1.02564335e-01f, -1.75563455e-01f, -5.99393249e-03f, 4.27342057e-02f, -6.47583455e-02f, -9.51971710e-02f, -1.02244630e-01f, 4.36637813e-04f, -1.63795296e-02f,
  -3.13888602e-02f, 2.77292393e-02f, 6.28899112e-02f, -7.76721612e-02f, 1.08500086e-01f, -3.97483036e-02f, 5.73209859e-03f, -5.67375496e-02f, -7.32407197e-02f, 7.00866431e-02f,
  8.63624141e-02f, -8.98880418e-03f, -4.07515205e-02f, -3.55869606e-02f, -7.94198811e-02f, 1.21199777e-02f, -5.67177162e-02f, -5.51508591e-02f, -8.35974142e-03f, -1.12410383e-02f,
  1.04246855e-01f, 1.51803009e-02f, -7.90448207e-03f, 2.04865225e-02f, 4.25660759e-02f, 2.08219327e-02f, -1.20072458e-02f, 9.48042497e-02f, 4.68657389e-02f, -9.93681047e-03f,
  7.79584572e-02f, -4.37153801e-02f, 4.63937484e-02f, 5.68215251e-02f, -7.04279020e-02f, 3.28419381e-03f, 3.29785682e-02f, -5.25048897e-02f, 1.30254358e-01f, -3.12308930e-02f,
  8.40269029e-02f, -1.35358041e-02f, 1.34544726e-02f, -4.00843024e-02f, 8.50364193e-02f, 3.25968787e-02f, -9.19279829e-03f, -3.81902792e-02f, 6.69618556e-03f, -6.57387301e-02f,
  -7.30675310e-02f, 7.00358450e-02f, -1.35850385e-02f, -1.14349104e-01f, -9.60518140e-03f, 9.61136818e-02f, -4.40073758e-02f, -2.03846507e-02f, 6.64831176e-02f, -4.61137332e-02f,
  -2.48120744e-02f, -1.84994116e-01f, 5.42129856e-03f, 3.00045107e-02f, 1.26664102e-01f, 1.27975434e-01f, 8.10006559e-02f, -4.10796097e-03f, 1.02862410e-01f, 7.19609037e-02f,
  5.96417766e-03f, 4.33820114e-02f, -8.00863877e-02f, 3.63058597e-02f, 7.27638453e-02f, 4.38532494e-02f, -7.57940039e-02f, -3.64539772e-02f, 8.31990242e-02f, 8.29865262e-02f,
  2.60536838e-02f, -1.04205990e-02f, 1.12658869e-02f, -8.96612331e-02f, -6.02217019e-02f, 1.50903268e-02f, -7.81869367e-02f, -5.28575294e-02f, -9.50622186e-02f, 7.36154020e-02f,
  7.99019858e-02f, -6.21672571e-02f, 1.40503660e-01f, -9.27566644e-03f, -1.10643581e-01f, -4.81045581e-02f, 1.79465599e-02f, -1.96089246e-03f, -2.07541808e-02f, 4.92048860e-02f,
  6.14476763e-02f, -1.63329467e-02f, -7.05539435e-02f, 2.14905273e-02f, -6.02570064e-02f, -5.32663893e-03f, -1.55546531e-01f, 1.49217329e-03f, -1.58998289e-03f, -6.46121800e-02f,
  -9.61192325e-03f, 4.24508676e-02f, -4.37051021e-02f, 3.87958363e-02f, -2.53514349e-02f, 5.38167767e-02f, -8.36917013e-02f, 1.71039216e-02f, -1.63036375e-03f, -8.25664997e-02f,
  7.43830353e-02f, 2.87099220e-02f, -1.70851331e-02f, -7.73664936e-02f, -9.35208276e-02f, -5.28334007e-02f, -3.57443653e-02f, 3.85601702e-03f, -4.34957854e-02f, -3.92610766e-02f,
  -7.78735010e-03f, 9.30803865e-02f, 8.00023973e-03f, 6.48533478e-02f, -7.89752603e-02f, -8.82193819e-02f, 6.67656437e-02f, 4.76449132e-02f, -5.39849363e-02f, 8.83964896e-02f,
  -6.95486143e-02f, -5.15873209e-02f, -1.24491183e-02f, -9.26170424e-02f, 4.74644003e-05f, 7.86024258e-02f, 8.25818162e-03f, 4.59542125e-02f, -8.23195558e-03f, 2.14492083e-02f,
  6.88840970e-02f, 8.65009055e-02f, 1.43367201e-01f, 3.85118574e-02f, 6.95274249e-02f, -5.41940220e-02f, -6.09692000e-02f, -1.16051082e-02f, -3.50649133e-02f, 6.21079467e-02f,
  8.40281174e-02f, 4.27862108e-02f, 9.51836929e-02f, 3.61360870e-02f, 4.69230711e-02f, 4.42430191e-02f, -3.43204066e-02f, 9.90027487e-02f, 5.62471338e-02f, 5.61982878e-02f,
  2.24969853e-02f, 7.11846203e-02f, 5.06069735e-02f, 1.17227204e-01f, 4.34455648e-02f, 2.33892966e-02f, 4.64231744e-02f, 7.76188299e-02f, 1.08055674e-01f, -1.17295068e-02f,
  -7.53921866e-02f, 3.28808394e-03f, 3.12960707e-02f, 6.24818355e-02f, -1.69533063e-02f, 4.99070156e-03f, -1.13507016e-02f, -4.99972515e-02f, 4.81243096e-02f, 5.13668545e-02f,
  -4.32074741e-02f, 6.42459616e-02f, 1.08338741e-03f, 1.07790016e-01f, 7.28642046e-02f, 1.36665646e-02f, 1.57969564e-01f, 1.37381688e-01f, -1.86164526e-03f, 6.75860187e-03f,
  -5.70575036e-02f, 8.07581991e-02f, 2.62518860e-02f, 8.09144899e-02f, 1.21497117e-01f, 2.21093483e-02f, 2.20002774e-02f, -8.36682133e-03f, 6.71704579e-03f, 1.82712689e-01f,
  -4.93555591e-02f, 9.31023154e-03f, 7.36561865e-02f, -4.66133580e-02f, -8.76092166e-02f, -2.86030322e-02f, -2.94724964e-02f, 3.54873873e-02f, -1.02422588e-01f, 1.23443820e-01f,
  -1.14963874e-01f, 1.79772098e-02f, -5.82379885e-02f, -5.96476495e-02f, 1.99079290e-02f, -1.77332330e-02f, 7.67166466e-02f, 8.95124376e-02f, -2.86693480e-02f, -6.36247396e-02f,
  8.71477125e-04f, 2.70410832e-02f, -8.90638381e-02f, 2.07504234e-03f, 5.12367152e-02f, 2.97873318e-02f, -4.89988737e-02f, 1.17319733e-01f, -2.88178176e-02f, 1.05515912e-01f,
  -2.39063390e-02f, -9.28662159e-03f, -4.10661586e-02f, 6.62750155e-02f, 6.83154166e-02f, 5.56511097e-02f, -6.19024634e-02f, 2.54774708e-02f, -2.84079015e-02f, -2.99071427e-02f,
  2.68760398e-02f, 6.78870529e-02f, -1.20290145e-01f, 4.38603833e-02f, -2.36704815e-02f, -1.23687856e-01f, 1.85378809e-02f, 5.98620363e-02f, 4.19156663e-02f, -4.95458543e-02f,
  -1.81639083e-02f, -3.23653445e-02f, 7.80802080e-03f, -3.99281196e-02f, -4.22015712e-02f, -1.36838732e-02f, 3.40479687e-02f, 5.44829294e-02f, 1.12836761e-02f, -1.75828692e-02f,
  -4.52703014e-02f, -1.26453862e-01f, -2.97386423e-02f, 5.15427478e-02f, 1.62751414e-02f, -1.64118018e-02f, -9.10040587e-02f, -2.13989411e-02f, -7.96155035e-02f, 2.78426819e-02f,
  -8.52275267e-02f, 2.33444776e-02f, 4.01232988e-02f, -9.46467668e-02f, -1.24035254e-01f, -2.10295599e-02f, 1.11853518e-01f, 4.06221226e-02f, -5.84721714e-02f, -9.22698826e-02f,
  -1.30734947e-02f, -1.32765755e-01f, 4.82662441e-03f, -7.58860260e-02f, -4.56693470e-02f, -2.52773277e-02f, -4.04552557e-02f, 4.40096185e-02f, -8.73752832e-02f, -6.13428690e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.67173368e-02f, -8.80827978e-02f, -1.90086057e-03f, 5.56762628e-02f, 6.13829903e-02f, 9.74866226e-02f, 9.94451120e-02f, 7.32507706e-02f, -5.60171530e-02f, -5.36462516e-02f,
  -1.06301587e-02f, 9.89451259e-02f, 3.99169847e-02f, -2.93653749e-04f, 5.28344139e-02f, 1.38339400e-01f, -4.58988622e-02f, 2.64390372e-02f, 5.57309762e-03f, 3.22744660e-02f,
  -6.19585067e-03f, 8.26954842e-02f, 6.36706278e-02f, 1.30867828e-02f, -6.16698014e-03f, -3.28751318e-02f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.39098734e-01f, -1.66035607e-01f, 1.14671014e-01f, 8.35162625e-02f, -1.32126838e-01f, -1.33371845e-01f, 4.67791557e-02f, -4.54775430e-02f, -1.40046448e-01f, 6.59113377e-02f,
  -7.02919587e-02f, 1.56561416e-02f, -2.84735393e-02f, 8.49860832e-02f, -3.66330780e-02f, -9.17061791e-02f, 1.49205253e-02f, -1.42954051e-01f, 3.72196344e-04f, 8.07496160e-02f,
  -7.08392188e-02f, -1.18686296e-01f, 1.03967533e-01f, -7.19145909e-02f, -1.57656491e-01f, 4.63390164e-02f, 2.38599814e-02f, 3.69718228e-03f, 1.07261986e-01f, -2.08989754e-02f,
  -1.33862540e-01f, -3.52363065e-02f, -1.02564357e-01f, 1.18862838e-01f, 1.11417659e-02f, -1.71360895e-01f, 1.14026524e-01f, 9.01830047e-02f, -3.21119428e-02f, -2.00828388e-01f,
  7.82615840e-02f, 1.38139397e-01f, -8.18985999e-02f, -3.43291685e-02f, 9.09682736e-02f, 3.85430828e-02f, 1.03695616e-01f, 4.41492200e-02f, -6.88528940e-02f, 8.22285786e-02f,
  1.00434691e-01f, 8.22251365e-02f, 5.36947511e-02f, 1.25803351e-01f, -5.13666943e-02f, -3.45582329e-02f, -1.44314975e-03f, -2.77585983e-02f, 5.45478724e-02f, 1.01875663e-01f,
  1.29379839e-01f, -1.64343059e-01f, 6.17746003e-02f, 8.89135599e-02f, -3.43015306e-02f, 8.45977515e-02f, -6.00415282e-02f, 1.77130520e-01f, -8.34349468e-02f, 1.73708901e-01f,
  -3.70447300e-02f, 8.76236856e-02f, -6.50113374e-02f, -3.72615978e-02f, 1.21208215e-02f, 2.23269507e-01f, 8.17773268e-02f, 4.22444530e-02f, 9.79561135e-02f, -4.51445878e-02f,
  4.60916460e-02f, -6.20499998e-02f, -2.22146865e-02f, 1.37054026e-01f, -1.60795093e-01f, 2.74081528e-02f, 9.13096517e-02f, 4.32473384e-02f, 1.34436348e-02f, 1.48714289e-01f,
  1.97321773e-01f, -1.84733436e-01f, -3.31931412e-02f, -7.78353214e-02f, -1.34419098e-01f, -1.95500642e-01f, 8.94452706e-02f, 1.54374599e-01f, 6.40661716e-02f, 4.60184775e-02f,
  5.10886312e-02f, 7.68292844e-02f, -1.81288853e-01f, -1.81084365e-01f, -3.84151516e-03f, -3.65202129e-02f, -1.22511327e-01f, -1.57756843e-02f, -1.58936664e-01f, 2.45371945e-02f,
  -1.37400895e-01f, -9.98803005e-02f, -1.73785880e-01f, -4.67933714e-02f, -1.90890402e-01f, -1.72373325e-01f, 3.91663648e-02f, -1.58336133e-01f, 4.68154401e-02f, 1.42270431e-01f,
  -3.97798494e-02f, 3.60934064e-02f, 1.59754202e-01f, 3.82418223e-02f, 1.55336872e-01f, 9.09157470e-02f, 1.14484176e-01f, 6.88604861e-02f, -1.02989405e-01f, -1.79039553e-01f,
  1.08425304e-01f, 2.58932281e-02f, -1.40652299e-01f, -6.21741228e-02f, 3.34468894e-02f, -3.31382602e-02f, 6.29007667e-02f, -8.04628432e-02f, 1.15202323e-01f, 3.69861536e-02f,
  1.10761233e-01f, -1.49499567e-03f, 1.12596139e-01f, 6.80519873e-03f, 1.50056863e-02f, 6.24666028e-02f, -2.39146631e-02f, -1.25088900e-01f, 3.31426449e-02f, -7.01049566e-02f,
  1.85245067e-01f, 9.52629000e-02f, -3.69266085e-02f, 3.86009961e-02f, -6.87420890e-02f, -1.12475969e-01f, 2.17789710e-01f, 3.83307561e-02f, 1.17487542e-01f, 4.01220769e-02f,
  -7.69878775e-02f, -2.60518175e-02f, 1.17528468e-01f, -2.14654908e-01f, 9.90669355e-02f, -6.79290891e-02f, -1.29435748e-01f, -1.29453331e-01f, -8.03593844e-02f, 1.04510896e-01f,
  -8.84534791e-02f, 2.15251997e-01f, 9.55878175e-04f, -1.06519081e-01f, -6.82634935e-02f, -8.37788433e-02f, 1.20944239e-01f, -1.32965282e-01f, -3.64450142e-02f, 2.03804210e-01f,
  2.73751374e-02f, 1.39719069e-01f, 8.15318301e-02f, 9.06812847e-02f, -1.43263233e-03f, 1.51087761e-01f, -4.51745167e-02f, 1.04313018e-02f, -4.46426682e-02f, -1.07483745e-01f,
  -5.62619977e-02f, 6.52516931e-02f, 5.34566864e-02f, 1.35758400e-01f, -4.87125553e-02f, -3.30255516e-02f, 8.03874657e-02f, 1.18445255e-01f, -5.90464361e-02f, -1.71853662e-01f,
  -8.05889815e-02f, 7.37767145e-02f, 2.13418808e-02f, 7.18203261e-02f, -1.34732155e-02f, 3.44312936e-02f, -2.35920232e-02f, 1.47773623e-01f, 6.04478009e-02f, -1.34304315e-01f,
  5.91387227e-03f, 5.30557893e-02f, -1.67509243e-01f, 6.70410320e-02f, -1.02804251e-01f, -2.21091270e-01f, 3.00523490e-02f, 4.02106978e-02f, 1.01242721e-01f, -7.79833496e-02f,
  -1.43862411e-01f, 1.24194637e-01f, -1.81842670e-01f, -6.39748648e-02f, 1.01242505e-01f, 1.49575248e-01f, 2.58745924e-02f, -4.11546119e-02f, -9.44444835e-02f, -5.21690808e-02f,
  1.03094101e-01f, 7.28858486e-02f, 1.42737553e-01f, 3.28977220e-02f, -7.57583752e-02f, 1.64080691e-02f, -9.39676315e-02f, 1.16343617e-01f, 4.44124043e-02f, 8.03768262e-03f,
  -9.63552296e-02f, 1.18900172e-01f, 3.55190672e-02f, -1.04062550e-01f, 6.21481799e-02f, 3.10923140e-02f, 5.30505739e-02f, 1.43757895e-01f, -1.47738084e-01f, -1.68202817e-01f,
  1.21648058e-01f, -7.54768262e-03f, 1.57116458e-01f, 1.13300430e-02f, 1.14741430e-01f, -9.48918611e-02f, -9.77951884e-02f, -1.55514330e-01f, 7.26726204e-02f, 1.03981487e-01f,
  -1.42171308e-01f, 6.81566447e-02f, -2.33981479e-02f, -1.17077954e-01f, -2.12442521e-02f, 6.66429708e-03f, 1.68395266e-02f, 8.65797028e-02f, -4.78394777e-02f, -1.53195951e-02f,
  1.43119872e-01f, 1.65011540e-01f, -3.12981531e-02f, -1.20986722e-01f, 1.07675470e-01f, 4.13552113e-02f, -1.04848690e-01f, -2.00240403e-01f, 1.44723728e-01f, -1.86234951e-01f,
  -5.46037927e-02f, -9.31574106e-02f, -4.76498529e-02f, -1.37612224e-01f, 6.64641187e-02f, 7.08963163e-03f, 5.59601858e-02f, -3.62209864e-02f, -5.81086725e-02f, -5.16398028e-02f,
  7.82664120e-02f, -5.32677360e-02f, 5.05888462e-02f, -3.33853289e-02f, -1.10509269e-01f, -1.27373040e-01f, -1.35119289e-01f, 1.15018226e-01f, -5.18742688e-02f, 1.43322960e-01f,
  -1.03868008e-01f, -1.08066030e-01f, -6.70928657e-02f, -1.58701658e-01f, 2.39214599e-02f, -1.54264510e-01f, -2.47239098e-02f, -4.86302860e-02f, 1.26795433e-02f, 2.10722476e-01f,
  1.66542411e-01f, -3.92855657e-03f, -8.88821706e-02f, 8.90981853e-02f, 1.05585702e-01f, 2.24603023e-02f, 1.57009199e-01f, -1.68220043e-01f, -1.68873537e-02f, -4.39243242e-02f,
  1.70779750e-02f, -5.99736348e-03f, -4.00039889e-02f, -4.43529263e-02f, -2.57332320e-03f, 6.17115982e-02f, 5.66092245e-02f, 1.07247613e-01f, -5.34257479e-02f, 5.59650920e-02f,
  6.55050650e-02f, -9.91507322e-02f, -2.54102834e-02f, -4.42975424e-02f, 2.39433050e-02f, -4.50227819e-02f, -1.12489432e-01f, 1.00381486e-01f, -9.31548774e-02f, 2.69530471e-02f,
  2.00960651e-01f, -1.33703649e-01f, -6.24018125e-02f, -3.12131345e-02f, -1.07837550e-01f, -1.07240982e-01f, -7.39869401e-02f, 1.71957418e-01f, -1.66961595e-01f, -9.96925384e-02f,
  7.01888800e-02f, -6.59479201e-02f, -4.53246087e-02f, 6.38412014e-02f, -1.88174024e-01f, 1.75865918e-01f, 1.73823491e-01f, -1.08697757e-01f, -2.26143617e-02f, 1.00266181e-01f,
  -8.16906244e-02f, -1.54575467e-01f, 1.43316403e-01f, -1.75725281e-01f, 1.02268592e-01f, -9.47203487e-02f, -2.79277209e-02f, -7.75004625e-02f, 1.27960309e-01f, -1.30284443e-01f,
  -1.23519287e-01f, 7.31276721e-02f, 9.07906294e-02f, 1.00174293e-01f, 1.53778806e-01f, -8.99521932e-02f, 1.07058443e-01f, 1.07139200e-01f, 1.14942662e-01f, -1.68173492e-03f,
  -9.12458822e-02f, -9.69846994e-02f, -6.52736649e-02f, -1.01962164e-01f, -1.00494605e-02f, -6.11722469e-02f, 3.21061537e-03f, 3.84782813e-02f, 7.39518087e-03f, -1.23017035e-01f,
  1.14620812e-01f, 7.95762762e-02f, -1.00962920e-02f, -5.42455576e-02f, 1.19120449e-01f, 2.32854038e-02f, 7.07966611e-02f, 4.75139283e-02f, -2.74813399e-02f, 9.44482014e-02f,
  -7.33018434e-03f, -6.81739748e-02f, -7.87009001e-02f, -9.71884429e-02f, -6.62418306e-02f, 1.60378650e-01f, -7.66642094e-02f, 2.04010010e-01f, 3.78092378e-02f, -8.14930908e-03f,
  1.43594712e-01f, -3.42333555e-01f, 2.07197860e-01f, -7.05182180e-02f, -1.14130884e-01f, 9.66010392e-02f, 1.38093699e-02f, -1.12365283e-01f, 2.85271525e-01f, -1.73851386e-01f,
  -1.52748451e-01f, -2.25951914e-02f, -1.93860188e-01f, -9.02241543e-02f, 1.42898023e-01f, 1.86803401e-01f, -1.15356974e-01f, -2.72139776e-02f, -1.01065829e-01f, 2.21286505e-01f,
  -1.08588330e-01f, 2.34009742e-04f, -1.21585310e-01f, -2.63437983e-02f, -1.54109538e-01f, -6.98348358e-02f, 4.37700190e-02f, 3.37992013e-02f, -1.97663918e-01f, 2.01344743e-01f,
  1.67589575e-01f, 2.16063838e-02f, -5.22439331e-02f, -8.83265957e-02f, -6.53991625e-02f, 4.42805551e-02f, 1.23383090e-01f, 4.59687971e-02f, -8.83459300e-02f, 3.12006939e-02f,
  1.46840617e-01f, 2.32181158e-02f, 1.84551161e-02f, 1.03375234e-01f, 1.73092991e-01f, -8.97834823e-03f, -1.20935269e-01f, -8.00827593e-02f, -2.25424618e-02f, -6.90324306e-02f,
  -1.27877414e-01f, 1.21474832e-01f, 3.89149487e-02f, -1.14933643e-02f, 1.20254703e-01f, 7.37136789e-03f, -4.14946042e-02f, -9.00116488e-02f, -8.40758346e-03f, -2.69503817e-02f,
  4.77772169e-02f, -2.57431678e-02f, 1.17693007e-01f, -9.63327363e-02f, 2.31330350e-01f, -2.43451223e-01f, -3.49813364e-02f, 1.31783739e-01f, -6.09448627e-02f, 7.93848932e-03f,
  1.71100378e-01f, 5.35980947e-02f, 2.30430841e-01f, 4.72921133e-02f, -7.51742944e-02f, -1.04636483e-01f, -2.49750301e-01f, -3.51608694e-02f, 1.38277203e-01f, 2.76481993e-02f,
  -4.06964496e-02f, -1.26444891e-01f, -1.72965880e-02f, 1.37888134e-01f, -5.68682961e-02f, -6.72462061e-02f, 3.40408869e-02f, -7.71294385e-02f, -1.31036803e-01f, -1.04648434e-01f,
  5.88053018e-02f, -3.95083837e-02f, 2.27061789e-02f, 1.51628017e-01f, 6.23065643e-02f, 1.23897225e-01f, -3.49667631e-02f, -4.34845798e-02f, -5.77422008e-02f, -8.10805708e-02f,
  -4.23322096e-02f, 1.30241876e-02f, -5.74085340e-02f, -1.15236178e-01f, -2.08196212e-02f, 4.68356721e-02f, -1.52449206e-01f, 1.83551848e-01f, 1.77407160e-01f, 2.20977627e-02f,
  -1.36353254e-01f, 1.88489296e-02f, -1.04848310e-01f, 1.86116509e-02f, 3.66072655e-02f, 2.80029718e-02f, 1.61478192e-01f, 1.04848057e-01f, 9.27286446e-02f, 1.16263241e-01f,
  -5.70161492e-02f, -1.09326169e-01f, -4.52833399e-02f, -6.10925183e-02f, 1.55742034e-01f, 3.90903428e-02f, -6.32833838e-02f, 2.07535434e-03f, 1.11000560e-01f, -9.59555954e-02f,
  1.43660828e-01f, 1.37130126e-01f, 8.81506503e-02f, 1.44749150e-01f, 1.96856931e-01f, 3.40111293e-02f, 5.71938306e-02f, -7.38006607e-02f, 1.17421232e-01f, -2.67202640e-03f,
  -1.57485127e-01f, -1.17030963e-02f, -1.50605664e-01f, 3.81851345e-02f, -4.17995676e-02f, 1.95819251e-02f, 1.34194046e-01f, -7.27165164e-03f, -5.07614901e-03f, -9.84248742e-02f,
  -5.27042262e-02f, -3.88081037e-02f, -2.36809909e-01f, 7.89103210e-02f, -7.93681741e-02f, 2.03467906e-01f, 1.32517964e-01f, 1.62100390e-01f, -2.98398710e-03f, 3.64155322e-02f,
  9.51200500e-02f, -7.78614953e-02f, -4.66830283e-02f, -1.30679533e-01f, 9.80352834e-02f, 1.01255491e-01f, -5.50215654e-02f, 1.16642706e-01f, -1.55515771e-03f, 7.70114809e-02f,
  4.88546789e-02f, 2.16207653e-01f, -1.31096676e-01f, -8.27252045e-02f, -1.70805976e-01f, 1.06203355e-01f, -1.50579795e-01f, -1.29157733e-02f, -1.57795027e-01f, -6.56193718e-02f,
  2.64255758e-02f, -1.31494582e-01f, -3.55902989e-03f, 3.04006413e-02f, -5.50419427e-02f, 9.12632197e-02f, -1.63004279e-01f, -7.55462446e-04f, -6.01697490e-02f, -2.34395832e-01f,
  6.45758808e-02f, -7.15534389e-02f, 1.57230139e-01f, -1.65019765e-01f, -1.89235240e-01f, -1.49942609e-02f, -1.64669290e-01f, -1.82685051e-02f, 7.93063790e-02f, 3.67580093e-02f,
  -1.50001064e-01f, 1.28514677e-01f, -8.52458999e-02f, 1.15897708e-01f, 9.68885943e-02f, -4.87524495e-02f, 6.24906868e-02f, -4.95999716e-02f, 8.72561783e-02f, -2.54096299e-01f,
  -1.60827935e-01f, -2.81109363e-02f, 2.87844986e-02f, -8.10118616e-02f, -9.72167328e-02f, 1.14314318e-01f, -1.19772159e-01f, -1.54834941e-01f, 8.36512595e-02f, -2.49449968e-01f,
  1.01051234e-01f, -6.02451488e-02f, 4.26466838e-02f, -1.32372990e-01f, 5.51387854e-02f, 5.79449311e-02f, 9.58699808e-02f, -1.11054666e-02f, -3.32379453e-02f, -2.19992772e-01f,
  -6.57039732e-02f, 1.32751167e-01f, 7.89131224e-02f, -6.57419562e-02f, -4.05879281e-02f, -9.11738575e-02f, -1.52146667e-01f, 6.28317073e-02f, 3.97933163e-02f, 1.11128248e-01f,
  -4.89933649e-03f, -2.11176667e-02f, -1.13847619e-03f, -4.16355617e-02f, 7.33910203e-02f, -6.98339865e-02f, 5.72221875e-02f, -4.88910452e-02f, -1.38850110e-02f, -4.01039943e-02f,
  -8.69197026e-02f, 2.35851869e-01f, -1.32109374e-01f, 1.13053292e-01f, -3.28250998e-03f, -1.06643841e-01f, 1.98709637e-01f, 1.37483701e-01f, 3.66924191e-03f, 1.13425612e-01f,
  -8.64905789e-02f, -1.04207613e-01f, 2.46233076e-01f, -3.01939826e-02f, 6.01106063e-02f, -3.92820388e-02f, 1.81379169e-01f, -3.84844989e-02f, -1.49516324e-02f, -5.14033325e-02f,
  1.03898041e-01f, -8.81683975e-02f, -8.46731365e-02f, 2.49875337e-02f, -1.13581017e-01f, -4.61179353e-02f, -1.04797594e-01f, -8.68959129e-02f, -1.61692038e-01f, -7.11422190e-02f,
  -9.46838856e-02f, 1.08711600e-01f, 1.56866774e-01f, -7.61341974e-02f, 1.06039040e-01f, 4.96644638e-02f, 1.31953970e-01f, -3.30658741e-02f, 1.31570801e-01f, -1.81737527e-01f,
  4.68647517e-02f, 6.72413409e-02f, -1.28565878e-02f, -7.97946602e-02f, -8.47427025e-02f, 3.26974094e-02f, 3.41649242e-02f, -1.35866210e-01f, 8.91834274e-02f, 4.00353968e-02f,
  1.31987361e-02f, -9.06890556e-02f, 3.81435230e-02f, 6.60117790e-02f, 2.65007503e-02f, -6.32739589e-02f, -5.02177849e-02f, -9.87210274e-02f, -1.53161347e-01f, 3.91019583e-02f,
  3.88521818e-03f, 5.35954274e-02f, 8.10405165e-02f, 1.72329210e-02f, -8.32343400e-02f, 2.49870196e-02f, 5.82302324e-02f, 7.95915201e-02f, -1.04170233e-01f, -4.30750893e-03f,
  2.99388804e-02f, -5.96935712e-02f, -1.59670010e-01f, -9.45903957e-02f, -1.32529801e-02f, -5.81406057e-02f, -1.87902197e-01f, -1.07949920e-01f, 2.51510832e-02f, 9.46651176e-02f,
  -8.24377090e-02f, -9.93615761e-03f, 1.44943282e-01f, 7.51645267e-02f, 1.42154157e-01f, -6.49313107e-02f, 1.11201800e-01f, 1.13106899e-01f, -1.58637594e-02f, 1.30168051e-01f,
  5.99289052e-02f, 1.09021366e-01f, 1.00528218e-01f, 6.87637851e-02f, 1.25290170e-01f, 1.02877513e-01f, 8.94674659e-03f, -1.07437737e-01f, -6.33039549e-02f, 7.07343370e-02f,
  -5.91607466e-02f, -9.87323970e-02f, 3.19775306e-02f, 8.66987742e-03f, -4.02675569e-02f, -8.29034075e-02f, -9.33460817e-02f, -5.69728157e-03f, 2.60166712e-02f, -3.11053470e-02f,
  -8.73896778e-02f, 8.10051337e-02f, 5.31431241e-03f, -1.36758357e-01f, 1.06323570e-01f, -4.91697602e-02f, 8.28935057e-02f, -6.69893846e-02f, -7.50318691e-02f, 9.20362249e-02f,
  -7.00674281e-02f, -7.02615157e-02f, -1.30043551e-01f, -7.75876045e-02f, 1.05403177e-01f, 9.50603262e-02f, 2.38134433e-03f, -1.03501104e-01f, 7.59058073e-02f, -6.55112267e-02f,
  2.98446752e-02f, -5.82253858e-02f, 1.26895532e-01f, -6.38116598e-02f, -3.93986702e-02f, -1.87214568e-01f, 1.18116349e-01f, 5.12171909e-02f, 6.88509142e-04f, -8.13006889e-03f,
  -1.33035362e-01f, 9.64521393e-02f, 1.38523072e-01f, -3.78166400e-02f, -1.68876611e-02f, 3.81069444e-02f, -3.01591121e-02f, -1.53872997e-01f, 7.23002702e-02f, 1.95327014e-01f,
  2.77115591e-03f, 9.18857157e-02f, -3.82442819e-03f, 2.52147974e-03f, -5.28085493e-02f, -6.61413148e-02f, 2.96773221e-02f, -6.06381632e-02f, -3.58178467e-02f, -3.39026190e-02f,
  1.19619789e-02f, 5.93431592e-02f, 4.72418964e-02f, 1.21939912e-01f, -4.90648225e-02f, 2.21772268e-02f, -1.08750716e-01f, -3.21507230e-02f, 4.18353006e-02f, -3.25394012e-02f,
  1.35321870e-01f, 1.63833529e-01f, 4.74338047e-02f, -1.11635998e-01f, 2.11868808e-02f, -3.24304998e-02f, 1.87051535e-01f, -1.56388655e-01f, -3.24100293e-02f, -1.51465964e-02f,
  -3.22426669e-02f, 1.04690418e-01f, 1.65568851e-02f, -4.95374501e-02f, 1.21691391e-01f, 7.73979351e-02f, 1.17245885e-02f, -1.74587548e-01f, 3.61012705e-02f, 1.22716777e-01f,
  -9.27815512e-02f, 7.96447322e-03f, 2.39235714e-01f, -1.48964137e-01f, -1.19076855e-01f, 7.21315965e-02f, -5.24466522e-02f, -6.96158633e-02f, -2.37575963e-01f, 1.94104254e-01f,
  -2.52765846e-02f, -1.20748863e-01f, 1.83549181e-01f, -9.62392706e-03f, -2.06640795e-01f, -1.10615604e-02f, -8.76327828e-02f, 1.85405433e-01f, -8.56071338e-02f, -3.70885320e-02f,
  -1.26499802e-01f, 1.40125230e-01f, -7.46203437e-02f, -2.51846854e-02f, -1.14254653e-01f, -1.20251765e-02f, -5.03172725e-02f, -4.76233326e-02f, 1.74906582e-01f, 8.33072513e-02f,
  1.78693846e-01f, 3.51245962e-02f, -1.40893250e-03f, 2.03014329e-01f, -1.39647603e-01f, 7.65207708e-02f, -1.36815414e-01f, -1.64395154e-01f, 5.77010550e-02f, 2.47737747e-02f,
  2.09303815e-02f, 8.67874920e-02f, -6.50093779e-02f, -9.50065479e-02f, -1.42590478e-01f, -1.01345785e-01f, -4.30071540e-02f, -3.30249555e-02f, 6.38229996e-02f, 1.93129890e-02f,
  -1.16165191e-01f, -6.07497953e-02f, -3.32865841e-03f, -2.12024212e-01f, -1.81291059e-01f, 1.12229809e-01f, -9.71564204e-02f, -8.27586651e-02f, 2.27031740e-03f, -2.03754026e-02f,
  6.13538828e-03f, -8.37973952e-02f, 1.28135085e-01f, 5.90250567e-02f, -1.16220132e-01f, -1.15675606e-01f, -1.51669458e-01f, -3.44349407e-02f, 2.79762652e-02f, -1.17843635e-01f,
  -1.22723328e-02f, 9.78052467e-02f, -1.15753144e-01f, 3.85306627e-02f, 1.69274788e-02f, 5.35014607e-02f, 7.29165319e-03f, -1.75556898e-01f, 1.94093082e-02f, 1.55328989e-01f,
  -9.02113020e-02f, 1.13638610e-01f, 6.04269579e-02f, -2.38630045e-02f, 5.59418015e-02f, -1.52283564e-01f, -8.74319449e-02f, 4.90676574e-02f, 1.64179206e-02f, -4.36639339e-02f,
  -4.79455926e-02f, -3.99841480e-02f, -3.01197954e-02f, -4.84672636e-02f, 1.04536526e-02f, 1.51568890e-01f, 2.09668919e-01f, -1.72748476e-01f, 1.29116073e-01f, 5.37283421e-02f,
  1.49828583e-01f, 8.95827860e-02f, -9.12362188e-02f, -5.35216443e-02f, 1.09475397e-01f, 5.44201285e-02f, 1.67014658e-01f, -1.44448504e-01f, 4.93271835e-02f, 1.55010372e-01f,
  4.27145734e-02f, -1.03716403e-01f, 1.25621840e-01f, 3.39967906e-02f, -2.57159118e-02f, -2.70356014e-02f, -5.24770096e-02f, -9.09459814e-02f, -2.27589291e-02f, 6.03050552e-02f,
  8.71546045e-02f, 6.57394230e-02f, -7.69828409e-02f, -5.97053021e-02f, 6.27117902e-02f, -8.87900516e-02f, 7.62253255e-02f, -7.36722574e-02f, -2.11851820e-02f, -6.98237047e-02f,
  -7.54949600e-02f, 4.10704426e-02f, 1.46435618e-01f, 6.49530143e-02f, -1.53679281e-01f, -6.69434667e-02f, -1.32247314e-01f, 1.55923128e-01f, 9.89291295e-02f, 7.88018405e-02f,
  -5.04253730e-02f, 1.20550245e-01f, 8.28787461e-02f, -8.59321840e-03f, -3.58942896e-02f, -3.00081652e-02f, 1.61331937e-01f, -1.07258707e-01f, -5.50655015e-02f, 7.25511014e-02f,
  -4.72288914e-02f, 1.50336117e-01f, -8.50176215e-02f, -2.99751982e-02f, 1.85329504e-02f, -1.16164669e-01f, -1.25751317e-01f, -4.07460369e-02f, 1.74139962e-02f, 7.92328939e-02f,
  2.48206586e-01f, 1.44004777e-01f, -9.38291401e-02f, 3.39089073e-02f, 1.11696132e-01f, -1.01284822e-02f, 3.86852883e-02f, -7.48150423e-02f, -9.38111469e-02f, -1.07348785e-01f,
  5.32221422e-02f, -4.62164218e-03f, 2.71376222e-02f, -2.30817236e-02f, 3.81163843e-02f, 1.38292655e-01f, 2.24714261e-02f, -1.51873425e-01f, 1.06880061e-01f, 3.46531719e-02f,
  -1.79526269e-01f, -4.37312499e-02f, -1.43288508e-01f, 8.15793127e-02f, 6.84983209e-02f, 3.72231305e-02f, -2.62254849e-02f, -1.40972152e-01f, 8.94962717e-03f, 7.19175488e-02f,
  3.63390148e-02f, -1.41577169e-01f, 4.27666306e-03f, 8.92733131e-03f, -1.85608361e-02f, -5.02482243e-02f, -1.61327034e-01f, -1.02082737e-01f, 1.39288185e-02f, -5.19300885e-02f,
  1.73294738e-01f, 2.66667698e-02f, -2.53424585e-01f, 4.62107174e-02f, -4.70973477e-02f, -1.86994240e-01f, -7.74057806e-02f, 3.86526138e-02f, -2.31536478e-01f, 3.21859270e-02f,
  2.32830681e-02f, 1.81117684e-01f, 1.24343984e-01f, 6.57440796e-02f, -7.41816536e-02f, -5.97047573e-03f, -8.08100849e-02f, -1.54528961e-01f, -1.01140924e-01f, 1.13814361e-01f,
  -1.40523583e-01f, 1.02939427e-01f, -1.57810319e-02f, 7.71396160e-02f, -2.93556112e-03f, -2.07399040e-01f, 9.20621306e-02f, -2.40432441e-01f, 1.74208269e-01f, -1.11880228e-01f,
  2.87416056e-02f, -3.90399545e-02f, -5.76827070e-03f, 3.32400054e-02f, -5.46128228e-02f, 3.41767594e-02f, -1.03685074e-01f, -5.69791421e-02f, -4.73846644e-02f, 2.14570668e-02f,
  9.94753540e-02f, -1.47990182e-01f, 1.82034239e-01f, -1.06807783e-01f, 5.56437299e-02f, -4.15448025e-02f, 1.87511280e-01f, 1.29926488e-01f, -7.44490549e-02f, 1.28796041e-01f,
  8.18444565e-02f, 1.20506167e-01f, 8.32943842e-02f, 4.83889645e-03f, -2.42005978e-02f, 2.06989661e-01f, -2.55208276e-02f, 1.73798129e-02f, 2.56311953e-01f, -5.75966127e-02f,
  -1.53337866e-01f, 2.11771548e-01f, 3.02576134e-03f, -1.06769703e-01f, -2.00169981e-01f, 1.01078518e-01f, -7.93556049e-02f, -1.20078802e-01f, 1.55544966e-01f, 1.44292682e-01f,
  -1.73331246e-01f, -6.99794963e-02f, -1.91476420e-01f, 1.35884359e-01f, -4.22040559e-02f, -3.63561250e-02f, -7.51428902e-02f, 1.25820607e-01f, 3.52876298e-02f, 5.39529324e-02f,
  -4.34911400e-02f, 5.44495024e-02f, -3.02680060e-02f, -8.82520825e-02f, 1.04779065e-01f, -1.39881864e-01f, 9.04537886e-02f, -4.88380380e-02f, 1.49694711e-01f, 1.15130424e-01f,
  -2.18479987e-02f, -2.53063329e-02f, -1.48604568e-02f, -1.73522845e-01f, 9.26952735e-02f, 1.07779741e-01f, -6.68203784e-03f, 8.36541653e-02f, -2.08807677e-01f, -3.16661261e-02f,
  -1.86073333e-01f, 7.56953955e-02f, -1.05499662e-01f, -1.42531395e-01f, 1.33775145e-01f, -1.72368046e-02f, -1.27638757e-01f, -1.23684950e-01f, 2.05422014e-01f, -1.98946148e-01f,
  -9.20600370e-02f, 4.18710932e-02f, -4.05256217e-03f, 1.90175939e-02f, 2.81563662e-02f, 7.96796679e-02f, -1.80142038e-02f, 2.68080421e-02f, -3.08377072e-02f, -9.59836766e-02f,
  3.38252075e-02f, -1.22901976e-01f, -1.48762600e-03f, -2.30113089e-01f, 2.53288001e-01f, 4.65321019e-02f, -7.82515556e-02f, 1.39813036e-01f, -9.43941325e-02f, 1.53544908e-02f,
  2.38220915e-01f, -8.82245153e-02f, -2.19933391e-02f, -6.44372851e-02f, -3.29640478e-01f, 7.97118321e-02f, 9.73831210e-03f, -1.74171045e-01f, -1.21550269e-01f, 8.82654414e-02f,
  -4.00453359e-02f, -9.53029618e-02f, -1.65591329e-01f, 5.64793721e-02f, 9.71380472e-02f, 1.38612473e-02f, -6.24687783e-02f, -2.10524574e-01f, 5.97013049e-02f, 8.39336067e-02f,
  1.81117833e-01f, 3.38952169e-02f, 2.42978737e-01f, 1.20388739e-01f, 8.13649148e-02f, 2.01990455e-01f, 5.64081557e-02f, 7.12338537e-02f, 4.97944513e-03f, 1.04822934e-01f,
  -7.35410601e-02f, 1.48165375e-01f, 6.54714322e-03f, -2.35471010e-01f, -4.65406626e-02f, 1.57631695e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -7.87760392e-02f, 1.20757163e-01f, 7.07223341e-02f, 2.64049321e-02f, 2.67100390e-02f, -2.80526318e-02f, 6.58480972e-02f, 8.06738660e-02f, 7.60789588e-02f, -1.00962967e-01f,
  -4.62372229e-02f, -5.70014752e-02f, 1.41619906e-01f, -5.17118089e-02f, 1.08946145e-01f, -8.05469230e-02f, -6.13360405e-02f, -1.81541592e-02f, 1.12815112e-01f, 8.33465904e-02f,
  1.16274215e-01f, 9.72870439e-02f, 2.08123028e-02f, 1.45854726e-01f, 1.10540509e-01f, -4.97964919e-02f, 4.02855920e-04f, 1.97442546e-02f, -1.54022112e-01f, 9.43734369e-04f,
  -1.96317490e-03f, 1.03581034e-01f, -1.66887701e-01f, -5.12977391e-02f, -9.15047601e-02f, 1.22081451e-01f, 4.82109338e-02f, 1.17463686e-01f, -4.51329499e-02f, 2.09869206e-01f,
  4.37544957e-02f, 8.95532370e-02f, -4.72287014e-02f, 4.36497815e-02f, -1.30779920e-02f, 8.58936459e-02f, -8.41611698e-02f, -1.24034211e-02f, -3.77361253e-02f, 9.80204493e-02f,
  1.95998579e-01f, 1.74268708e-01f, 7.61701465e-02f, -1.41299903e-01f, -1.54671505e-01f, -9.98314843e-02f, 6.58440068e-02f, -7.67760575e-02f, -1.03082135e-01f, 1.07628129e-01f,
  6.99941814e-02f, 4.40135561e-02f, 7.04042288e-03f, 6.50021806e-02f, 8.34881663e-02f, -9.91005357e-03f, 1.27104849e-01f, 1.76497381e-02f, -1.34181734e-02f, 1.32912740e-01f,
  -1.08471610e-01f, -7.45877698e-02f, -6.30344078e-02f, 4.44751680e-02f, 7.28765950e-02f, -1.19715348e-01f, 1.34392176e-03f, -4.84958179e-02f, -5.20453900e-02f, -7.98544437e-02f,
  4.73711342e-02f, 4.62186895e-02f, 3.62276360e-02f, 1.32009402e-01f, -1.12505583e-02f, -7.67361699e-03f, -5.66139258e-02f, 9.95011628e-02f, -8.28006640e-02f, -1.29417017e-01f,
  -8.80166888e-02f, 1.01785073e-02f, 1.90611444e-02f, 8.08889396e-04f, 5.09979762e-02f, -1.69466157e-02f, -2.89695822e-02f, 1.08640268e-01f, -1.09545000e-01f, 1.29045725e-01f,
  -4.14069258e-02f, 1.36344377e-02f, 2.09971353e-01f, 1.02251150e-01f, -9.97314975e-02f, 1.32238358e-01f, 2.80410163e-02f, -6.40952289e-02f, -3.02900579e-02f, -9.64276120e-02f,
  -5.50547577e-02f, 4.03368697e-02f, -7.34274909e-02f, -6.52047247e-02f, 1.26675099e-01f, -4.64284979e-02f, -4.71523479e-02f, -6.07156828e-02f, 6.41204929e-03f, -1.48073556e-02f,
  4.96081971e-02f, -4.63283099e-02f, -4.94808219e-02f, 1.19645633e-01f, 1.12805158e-01f, 3.15806968e-03f, -5.68997003e-02f, 4.98887375e-02f, 8.78943503e-02f, 6.68136850e-02f,
  -2.69414745e-02f, 9.58655402e-02f, 1.03019349e-01f, 9.59903896e-02f, -1.24453165e-01f, -2.84414552e-02f, 7.26727396e-02f, -1.52016943e-02f, 1.14895687e-01f, 8.23952779e-02f,
  1.19656771e-01f, -1.61986146e-02f, 1.10856138e-01f, -7.98022971e-02f, 6.01602979e-02f, 1.16504386e-01f, -3.22243050e-02f, -1.38761522e-02f, 2.26102993e-02f, 1.77673504e-01f,
  3.69735844e-02f, 1.42722689e-02f, -1.07512288e-01f, -2.05278203e-01f, -1.36362955e-01f, 1.50793359e-01f, -8.02397281e-02f, 4.37776782e-02f, 8.69103819e-02f, 1.77680120e-01f,
  6.39823750e-02f, -8.32128972e-02f, 3.03230081e-02f, 1.39818370e-01f, 1.14526547e-01f, -1.29328981e-01f, 7.40103647e-02f, 1.76490843e-01f, 1.74644012e-02f, 1.96425579e-02f,
  1.55316480e-02f, -8.86842608e-02f, -3.07842270e-02f, 2.77647693e-02f, -6.69006631e-02f, -3.69203910e-02f, 5.65483160e-02f, -1.06100544e-01f, -2.04915434e-01f, 3.07107996e-02f,
  -5.76430000e-02f, 1.48558980e-02f, -7.91759416e-02f, 6.76063523e-02f, 9.28142518e-02f, 6.90372065e-02f, -5.07579260e-02f, 1.41656324e-01f, -1.01330571e-01f, 1.25348330e-01f,
  -4.84008007e-02f, -5.88288531e-02f, 5.71990735e-04f, 1.22673176e-01f, 1.17740199e-01f, -6.76380396e-02f, 1.97154924e-01f, 5.60918115e-02f, 7.51584247e-02f, -4.75079678e-02f,
  1.87527478e-01f, 1.35790303e-01f, 1.35349557e-01f, 1.40421331e-01f, 6.34820685e-02f, -1.11375675e-01f, 1.33935720e-01f, 2.43333466e-02f, 4.27057147e-02f, 7.02621713e-02f,
  1.73666313e-01f, 1.23399794e-01f, 3.30672413e-02f, -9.41397324e-02f, 3.49756819e-03f, 1.72482934e-02f, 8.39981586e-02f, 4.10601199e-02f, -1.86259136e-01f, 1.37149453e-01f,
  3.32189910e-02f, -1.37087047e-01f, -9.87299457e-02f, -7.02143088e-02f, -1.66049644e-01f, 1.81524798e-01f, -1.66603237e-01f, 7.63061345e-02f, 8.82645100e-02f, 1.80867150e-01f,
  9.16282162e-02f, 1.97509468e-01f, -2.73381732e-02f, -3.98996845e-02f, 1.58363488e-02f, -6.61426038e-02f, 3.34945992e-02f, -6.73602298e-02f, 1.01610102e-01f, 1.49847448e-01f,
  1.28447160e-01f, -8.05105194e-02f, 1.35934815e-01f, 1.95632994e-01f, -1.15007171e-02f, -1.70690436e-02f, -3.76491137e-02f, -1.53378695e-01f, 5.25225559e-03f, -1.90429967e-02f,
  -1.57567076e-02f, 5.59771527e-03f, 7.77911618e-02f, -1.20530218e-01f, -2.92237364e-02f, -2.38070656e-02f, 8.62045512e-02f, -7.54131898e-02f, 1.30133584e-01f, 7.43501782e-02f,
  2.02308208e-01f, -1.00725345e-01f, -1.02016941e-01f, -6.32049516e-02f, 1.22072875e-01f, -8.82652998e-02f, 1.90697044e-01f, 1.46437045e-02f, 1.96672365e-01f, 6.50758892e-02f,
  -7.36005157e-02f, -6.51687458e-02f, -1.16175644e-01f, 2.44521022e-01f, 1.84178278e-01f, 9.01200548e-02f, 2.24074461e-02f, -1.59095936e-02f, 5.49302213e-02f, 1.68809235e-01f,
  1.23558976e-02f, -6.93789572e-02f, -2.57526696e-01f, 1.11251347e-01f, -1.10044509e-01f, 7.56604597e-02f, 4.62192111e-02f, 1.67880893e-01f, -9.01710466e-02f, -2.75932532e-02f,
  -2.24802978e-02f, 2.97991578e-02f, 1.00634716e-01f, -9.39958021e-02f, 1.55249655e-01f, 1.93480998e-01f, -5.59783243e-02f, -7.06347823e-02f, -5.72796054e-02f, 6.55397922e-02f,
  6.60052672e-02f, -4.17366400e-02f, 1.01802632e-01f, 7.77412727e-02f, 2.00140566e-01f, -1.31744191e-01f, -1.05868923e-02f, 3.09689790e-01f, 1.22404955e-01f, 1.00591280e-01f,
  -1.75471187e-01f, -1.32655233e-01f, 1.32558286e-01f, 2.68019270e-02f, -2.07280561e-01f, 7.99203590e-02f, 6.15757145e-03f, -3.28445658e-02f, 8.59352201e-02f, -3.87791172e-02f,
  -1.30738631e-01f, 8.98633525e-02f, -3.79822007e-03f, 6.66095167e-02f, 6.01472426e-03f, -1.25711948e-01f, -1.23634957e-01f, -6.43163100e-02f, -8.79582390e-03f, 4.04875576e-02f,
  -1.20008059e-01f, 4.31025848e-02f, -1.23231009e-01f, -1.13188110e-01f, 1.96800493e-02f, -9.35591534e-02f, 1.40491724e-02f, -4.85027507e-02f, 1.21553138e-01f, 2.31460351e-02f,
  -9.87403840e-02f, -9.73450299e-03f, 3.45063880e-02f, -8.81148502e-03f, 4.02126461e-02f, -6.77452534e-02f, 8.81614238e-02f, -9.93109345e-02f, -2.03873906e-02f, -6.63306043e-02f,
  -8.56663510e-02f, -1.22977169e-02f, -5.21520041e-02f, 1.25000596e-01f, 1.30656764e-01f, -9.88224074e-02f, -8.30170291e-04f, 1.16220661e-01f, -8.20362382e-03f, 2.79532783e-02f,
  9.70792249e-02f, -5.55613115e-02f, -7.17435628e-02f, 4.69109230e-02f, 1.20355241e-01f, -6.33800402e-02f, -6.68305978e-02f, 1.22021616e-01f, -3.10208779e-02f, -4.08191644e-02f,
  -2.88085323e-02f, -1.24695815e-01f, 1.75366681e-02f, 4.51945001e-03f, -1.23560000e-02f, -1.09197069e-02f, -7.35149533e-02f, 9.73734073e-03f, -5.03980294e-02f, 5.31491712e-02f,
  -3.41285914e-02f, -1.23181462e-01f, -4.55689803e-02f, 3.34172696e-02f, -6.13455940e-03f, 4.46689054e-02f, -7.39328861e-02f, 5.22094257e-02f, -4.16825823e-02f, -9.96929556e-02f,
  -5.59172370e-02f, -2.99045052e-02f, -1.01872563e-01f, -7.69968480e-02f, 1.08146019e-01f, 1.11982234e-01f, 1.25801697e-01f, -4.38854657e-02f, -2.04117037e-02f, -1.10081360e-01f,
  -1.20475292e-01f, 6.03673533e-02f, -9.54486802e-02f, -4.43044603e-02f, -1.18021123e-01f, 5.97758405e-02f, 6.05434850e-02f, -2.60096043e-02f, 5.91224208e-02f, -1.56447906e-02f,
  3.20319906e-02f, -8.33181888e-02f, 5.67489937e-02f, -3.86825204e-02f, 6.78886473e-02f, 5.19171022e-02f, 1.26604410e-02f, -1.16593782e-02f, 1.30194286e-02f, -7.27979392e-02f,
  -1.21693529e-01f, 1.22638606e-01f, 1.10225342e-02f, -1.01229794e-01f, 5.72143048e-02f, 1.39872178e-01f, 1.03793040e-01f, -9.80988666e-02f, 8.22035819e-02f, -5.31996004e-02f,
  -4.56757993e-02f, 3.30542810e-02f, 8.84793326e-02f, 6.07833080e-02f, -2.49924953e-03f, 2.90023834e-02f, -4.21590470e-02f, -1.49481278e-02f, -6.87817037e-02f, -2.83805188e-02f,
  -2.34438498e-02f, -3.10944580e-02f, -1.16133928e-01f, 8.71903524e-02f, -1.33704133e-02f, 1.04772083e-01f, 1.49600878e-01f, 5.95842563e-02f, -5.35039045e-02f, 8.88425633e-02f,
  7.62627497e-02f, 1.28298610e-01f, 1.20046616e-01f, -1.33373514e-02f, 2.17866138e-01f, 1.33192405e-01f, 2.50749975e-01f, 1.19040951e-01f, 1.64256215e-01f, 8.03348869e-02f,
  2.77024448e-01f, 1.97415188e-01f, 5.82246222e-02f, 1.38434649e-01f, 1.14339860e-02f, 3.02380651e-01f, 2.72728473e-01f, -5.59428483e-02f, 8.19388852e-02f, -4.95422818e-02f,
  1.89659029e-01f, 1.17152616e-01f, -1.13591090e-01f, 1.97059616e-01f, -2.23465487e-01f, -2.14411452e-01f, 2.81910449e-01f, -1.06649697e-01f, 2.59432103e-02f, 9.02161002e-03f,
  -2.54851073e-01f, -6.61363378e-02f, 2.57570416e-01f, -2.00369254e-01f, -6.93902150e-02f, -2.69791819e-02f, -7.54013211e-02f, -1.41156420e-01f, 1.06451631e-01f, 1.65084437e-01f,
  8.50727111e-02f, 2.50263810e-01f, 1.19072601e-01f, 3.30102891e-02f, 5.40729687e-02f, 1.88158154e-01f, 1.30973950e-01f, -1.41864121e-01f, 1.55890331e-01f, 2.54740450e-03f,
  -9.50021967e-02f, 1.09030180e-01f, -2.64654994e-01f, 1.20782971e-01f, 1.44784734e-01f, 1.93005383e-01f, -2.65065134e-01f, 4.60666567e-02f, -1.40016153e-02f, -2.49510393e-01f,
  4.07835469e-02f, 6.46107364e-03f, 9.92348567e-02f, -8.50757137e-02f, 9.81004722e-03f, -4.33809906e-02f, -7.50487379e-04f, 4.72093513e-03f, 1.03575274e-01f, 3.68987136e-02f,
  1.29711712e-02f, -9.25841108e-02f, -8.82777423e-02f, 1.09482538e-02f, 3.20967962e-03f, -3.86608057e-02f, -5.02868779e-02f, -1.42053980e-02f, -8.81015137e-02f, 3.41225043e-02f,
  -1.16948485e-01f, 1.07042484e-01f, -8.97228122e-02f, 5.72391711e-02f, -7.52092525e-03f, -7.24306554e-02f, 4.60151434e-02f, 4.27344181e-02f, 4.19361033e-02f, 7.57896975e-02f,
  -8.36855024e-02f, 7.25266039e-02f, -6.17797002e-02f, -4.64032926e-02f, -1.01727962e-01f, 5.70226908e-02f, 1.19067878e-02f, -1.12763442e-01f, 1.09648630e-01f, -5.36450185e-02f,
  -6.09102100e-02f, 5.75939082e-02f, -4.88882214e-02f, 1.82213429e-02f, 4.81242500e-02f, 1.02883302e-01f, -1.32936854e-02f, 1.01354375e-01f, 6.82569146e-02f, 3.94686274e-02f,
  -1.14170052e-02f, 8.87478963e-02f, -1.22425452e-01f, -8.27944055e-02f, 9.95438993e-02f, 3.81332710e-02f, -3.15363891e-02f, 1.30762890e-01f, 5.26170135e-02f, -8.27820599e-02f,
  1.02274612e-01f, 9.75099429e-02f, 6.66305795e-02f, -1.18770480e-01f, 3.22703235e-02f, -1.10731833e-01f, -5.79545125e-02f, 1.42873868e-01f, 7.51014799e-02f, -1.17993943e-01f,
  1.33782268e-01f, 2.22713798e-02f, -1.18508756e-01f, -8.24169368e-02f, 1.30315542e-01f, 1.79290086e-01f, 1.32289454e-01f, 1.38686255e-01f, 4.43640761e-02f, -1.89346131e-02f,
  7.70743489e-02f, 1.23061843e-01f, 1.23800211e-01f, 2.95244679e-02f, 1.40842766e-01f, 1.30771354e-01f, 8.83427560e-02f, 7.85859972e-02f, -6.40865322e-03f, 6.23616837e-02f,
  -1.84250064e-02f, -1.84173882e-01f, 5.88711612e-02f, 1.94286421e-01f, -1.90444872e-01f, -4.60726954e-02f, 2.29080021e-03f, -7.52829090e-02f, 1.42608897e-03f, 7.08089545e-02f,
  -2.34811157e-01f, 4.89281304e-02f, 2.07265448e-02f, 6.08136244e-02f, 7.84289464e-02f, 1.98967978e-01f, 6.67735040e-02f, 6.48677126e-02f, -9.08324681e-03f, -1.07707284e-01f,
  1.14992574e-01f, 4.57115844e-02f, -6.20928630e-02f, -4.16009836e-02f, 5.92112765e-02f, 2.40487736e-02f, 1.43541604e-01f, -6.66668732e-03f, 1.51090696e-02f, -8.06979761e-02f,
  1.67430937e-01f, -6.95643201e-02f, -1.22279592e-01f, -1.58829495e-01f, -1.86659175e-03f, 7.15554208e-02f, -1.24272376e-01f, 1.14786595e-01f, -2.95453575e-02f, -1.24281593e-01f,
  1.55545354e-01f, 4.36394438e-02f, 2.92830411e-02f, 1.31154368e-02f, 8.56649280e-02f, 6.90566674e-02f, 1.51070863e-01f, 3.09894700e-02f, -4.36131991e-02f, 9.80002880e-02f,
  -5.27693629e-02f, 2.57966816e-02f, 1.28446192e-01f, -7.78752416e-02f, -6.53668866e-02f, 1.48762211e-01f, 1.09127365e-01f, -3.54638807e-02f, 1.30254269e-01f, -4.32590432e-02f,
  1.64896995e-02f, 5.08466735e-03f, 1.17558107e-01f, -2.67443787e-02f, 6.47182092e-02f, 1.22428074e-01f, -1.90945752e-02f, -2.07436219e-01f, 7.18594193e-02f, -5.10754995e-02f,
  -1.18087113e-01f, -6.21671528e-02f, -4.68953662e-02f, 4.64677513e-02f, 1.24485180e-01f, -1.33172721e-01f, 5.15995435e-02f, -7.86642730e-02f, -9.94864106e-02f, -4.01664488e-02f,
  -5.77367432e-02f, 9.35828760e-02f, -5.99695630e-02f, -7.41023850e-03f, 6.34844154e-02f, 1.60926089e-01f, -6.20736443e-02f, 3.11319288e-02f, 1.14898451e-01f, 1.63475554e-02f,
  1.63375735e-01f, -1.67260230e-01f, -6.84619066e-04f, -9.03874040e-02f, -2.69909222e-02f, 1.74272224e-01f, 1.24177389e-01f, 9.79478881e-02f, 2.83312332e-02f, -8.28453992e-03f,
  1.24914989e-01f, -1.01473168e-01f, 1.99171409e-01f, 2.00099703e-02f, 4.78294529e-02f, -1.02109611e-01f, 6.27726018e-02f, 7.58966804e-02f, -5.85958064e-02f, -1.46525651e-01f,
  1.38517283e-02f, 4.73687313e-02f, 1.26843616e-01f, -3.61842699e-02f, 5.57497181e-02f, -2.80561708e-02f, -2.75073815e-02f, 1.66870281e-01f, -8.59363303e-02f, 1.38827577e-01f,
  -5.28574623e-02f, 1.49966598e-01f, 1.54702783e-01f, -7.04034790e-03f, 6.01636469e-02f, 1.05481885e-01f, 1.12122844e-03f, 2.60224678e-02f, 1.42756058e-02f, -4.41251248e-02f,
  6.15344346e-02f, -1.06060743e-01f, -8.65800083e-02f, -4.33335034e-03f, 1.09865062e-01f, 1.60511658e-01f, 6.81831017e-02f, 1.79540105e-02f, 1.65240304e-03f, -8.57999027e-02f,
  -9.05350000e-02f, -1.24170311e-01f, -4.19493131e-02f, -7.65542537e-02f, 1.92679856e-02f, 8.57452527e-02f, -1.52895655e-02f, 7.78375939e-02f, 1.77364573e-02f, 1.41279325e-01f,
  3.30414474e-02f, 7.98622668e-02f, 1.04663350e-01f, -3.91006842e-02f, 1.21960215e-01f, 6.62940219e-02f, -7.75247663e-02f, 1.76556602e-01f, -1.67004660e-01f, 1.41355291e-01f,
  5.11697121e-02f, 1.87054634e-01f, -1.57848492e-01f, 1.88827775e-02f, 1.06491365e-01f, -1.10961400e-01f, 1.44421503e-01f, 1.29635215e-01f, 2.61902902e-02f, 2.77107079e-02f,
  9.53043178e-02f, -3.21786553e-02f, 9.15597677e-02f, -8.19695517e-02f, 1.00279022e-02f, 1.09221570e-01f, 1.33051038e-01f, -1.06021337e-01f, 9.44197644e-03f, -6.97167441e-02f,
  1.27256036e-01f, 7.29875714e-02f, -1.19898105e-02f, 9.47296340e-03f, -4.20076773e-03f, -1.04464129e-01f, 8.05061162e-02f, -2.87722778e-02f, 1.32693335e-01f, -3.34586129e-02f,
  9.66200884e-03f, -6.29451638e-03f, -4.96042520e-02f, -8.61298442e-02f, 9.21229739e-03f, 8.27599466e-02f, 1.09227479e-01f, -1.50891682e-02f, 1.02215543e-01f, 1.36094987e-01f,
  5.16699366e-02f, 5.58519736e-02f, 7.95978159e-02f, 2.44497862e-02f, 7.30354860e-02f, -1.19379908e-01f, 6.40861318e-03f, -2.14338899e-02f, -6.38146624e-02f, 1.68667417e-02f,
  -3.85596491e-02f, -7.83841163e-02f, -7.46907527e-03f, -2.00585090e-02f, 1.43350497e-01f, -4.65993248e-02f, -4.51456616e-03f, 5.94377518e-02f, 1.04341507e-02f, -6.26578033e-02f,
  -4.85508889e-02f, 1.54349253e-01f, 8.27672854e-02f, -4.81697381e-04f, 5.80075458e-02f, 3.10082249e-02f, -8.86322483e-02f, -5.04093128e-04f, -1.27973884e-01f, 2.83902995e-02f,
  5.00239916e-02f, 9.56853926e-02f, -6.70322999e-02f, -5.03333919e-02f, -9.47477072e-02f, 2.19590850e-02f, -1.08768046e-01f, -7.18024522e-02f, 7.71363033e-03f, 1.47192419e-01f,
  1.36682481e-01f, 8.86303931e-02f, 5.15165599e-03f, 5.45798019e-02f, 4.61085811e-02f, -6.98345378e-02f, -9.10282508e-02f, 9.64714587e-02f, 1.35523394e-01f, -4.24543805e-02f,
  1.34801045e-01f, 3.05177458e-02f, -7.97923505e-02f, -6.72190413e-02f, -6.65307418e-03f, 9.09437016e-02f, 1.61551699e-01f, -9.04944018e-02f, 1.30875453e-01f, -2.60469969e-03f,
  -7.52855912e-02f, 7.73039684e-02f, -3.78330350e-02f, 1.05495311e-01f, -2.87047066e-02f, -7.10735694e-02f, -4.46995087e-02f, 3.50460224e-02f, -1.25381500e-01f, -3.02570523e-03f,
  -4.07507792e-02f, 3.82219218e-02f, 3.35203446e-02f, 7.67693520e-02f, 1.59719344e-02f, 6.63120393e-03f, -1.01281308e-01f, -1.34896562e-02f, -4.54189964e-02f, -1.23339273e-01f,
  -7.93801993e-02f, -3.78754362e-02f, 7.87105411e-02f, -8.47354755e-02f, 2.51422543e-02f, -5.98500818e-02f, -5.15510961e-02f, -2.74011232e-02f, 5.37413545e-02f, 2.58804094e-02f,
  1.92626771e-02f, 6.34259209e-02f, -6.93442747e-02f, 1.24051876e-01f, 8.30938816e-02f, -2.70659160e-02f, -6.55124336e-02f, 6.32771477e-02f, 5.32973139e-03f, -4.58685458e-02f,
  1.29553542e-01f, -9.74808559e-02f, -7.90888816e-02f, -1.15126975e-01f, -3.06415197e-04f, 2.72254599e-03f, 4.56403196e-02f, -8.60914215e-02f, 1.49045423e-01f, -6.38758997e-03f,
  -1.12851860e-03f, 4.29360233e-02f, -2.26391386e-02f, 1.48225516e-01f, 8.19861144e-02f, 1.31334499e-01f, -2.90730484e-02f, -7.70260319e-02f, 1.13303952e-01f, 1.09331766e-02f,
  1.15151525e-01f, 6.96688443e-02f, 6.73460141e-02f, 7.30354786e-02f, -7.96407182e-03f, 8.03725943e-02f, -1.61475912e-01f, 4.92907986e-02f, -6.03800407e-03f, -1.02341287e-01f,
  -7.35203251e-02f, -9.92288440e-02f, -1.43119603e-01f, 1.72868878e-01f, 2.18313113e-01f, 6.37930855e-02f, 1.56939447e-01f, 1.80908471e-01f, 1.12158656e-01f, 4.33779471e-02f,
  1.07874297e-01f, 1.13578379e-01f, 5.41820526e-02f, 1.67723492e-01f, 9.57439914e-02f, 9.66899097e-02f, 2.68667638e-01f, -9.46721211e-02f, -6.67659938e-02f, -8.64175260e-02f,
  -1.33153480e-02f, 8.86524767e-02f, 1.24430507e-02f, -9.47590843e-02f, 5.57685904e-02f, 1.07785240e-01f, 7.13286176e-02f, 1.36804298e-01f, -4.74058911e-02f, -1.80899650e-02f,
  4.26732376e-02f, 5.43120652e-02f, 9.62201431e-02f, 5.27020730e-02f, -8.07616115e-02f, 1.76309552e-02f, 7.89192785e-03f, 5.68553694e-02f, -1.05063217e-02f, -4.20626365e-02f,
  5.32344542e-02f, 1.53274551e-01f, -2.19845865e-02f, 1.01099439e-01f, 3.12577374e-02f, 1.12083264e-01f, -2.54338570e-02f, 9.24360752e-02f, 4.72917892e-02f, -7.49376267e-02f,
  -1.36325717e-01f, -6.15562908e-02f, 6.67690039e-02f, -3.23363543e-02f, -1.32609099e-01f, -2.49867775e-02f, -1.41685512e-02f, 1.13615587e-01f, -1.26852587e-01f, -6.28351346e-02f,
  -5.20690950e-03f, -1.19418211e-01f, 4.48872820e-02f, -4.47418690e-02f, -6.32509636e-03f, 1.05220199e-01f, 9.51137692e-02f, -8.75585824e-02f, 1.27366846e-02f, -7.80579168e-04f,
  -1.35343537e-01f, -1.33897319e-01f, -4.60123643e-02f, 1.99577659e-02f, 2.91374326e-02f, 4.14471813e-02f, 2.11557448e-02f, -1.34889841e-01f, -1.24770127e-01f, 1.24592438e-01f,
  -5.74464500e-02f, -1.49589673e-01f, 7.47144371e-02f, -4.69876751e-02f, 8.35782290e-02f, 1.13021936e-02f, 3.61261666e-02f, -3.71572785e-02f, 6.31284267e-02f, -4.27727997e-02f,
  4.44485992e-03f, 1.63101678e-04f, -1.36519326e-02f, -7.21347705e-02f, 1.05287477e-01f, 1.36356018e-02f, 4.94934022e-02f, 1.68184265e-01f, 4.45603952e-02f, 1.23994730e-01f,
  6.05637543e-02f, -1.02100715e-01f, 9.31904390e-02f, 9.07815155e-03f, -3.74920964e-02f, 1.26794904e-01f, -1.99490320e-02f, -7.60796294e-02f, 2.93108542e-02f, 4.47877795e-02f,
  3.65151116e-03f, 1.65839717e-02f, 1.25477195e-01f, -7.10023269e-02f, -1.69174120e-01f, 2.31005959e-02f, 5.29238656e-02f, -2.05519959e-01f, 2.72166748e-02f, -1.07572436e-01f,
  7.39316344e-02f, 7.73678571e-02f, -1.18880250e-01f, -7.35119358e-02f, -1.38410836e-01f, -9.68756378e-02f, 3.50040942e-02f, -2.01882590e-02f, -8.05238038e-02f, -9.25820619e-02f,
  1.50597796e-01f, 1.68532524e-02f, 8.59800130e-02f, -2.85638254e-02f, -7.82995149e-02f, 4.40528207e-02f, 1.05704434e-01f, -8.79779682e-02f, -1.18427031e-01f, -1.35928050e-01f,
  -9.51055884e-02f, -1.51365221e-01f, -1.13431336e-02f, -7.30346888e-02f, 3.73377763e-02f, -9.17125493e-02f, 1.31262138e-01f, -1.19393617e-01f, 2.62360424e-01f, -2.03039609e-02f,
  6.58302829e-02f, -4.10921611e-02f, 2.51270294e-01f, 2.72331964e-02f, 1.61222801e-01f, 9.83062387e-02f, 1.22300558e-01f, 7.11626485e-02f, 4.95986305e-02f, 1.20063543e-01f,
  5.20578539e-03f, 1.45236865e-01f, 8.46025869e-02f, 1.37614682e-01f, 1.26402944e-01f, -6.57670572e-02f, -2.12288433e-04f, 1.23996191e-01f, -7.64342621e-02f, 2.71273335e-03f,
  -2.55803410e-02f, 7.12260231e-02f, 3.20021696e-02f, 6.10991046e-02f, 1.44111097e-01f, 5.21503575e-02f, 1.10553063e-01f, -1.37009658e-02f, 8.30149220e-04f, -1.77421927e-01f,
  4.32161279e-02f, -1.71551034e-01f, 7.10460618e-02f, 1.70385554e-01f, -2.43771881e-01f, 1.66704103e-01f, 1.83904469e-01f, -1.34689352e-02f, 9.38723311e-02f, -1.46284103e-01f,
  -1.73804656e-01f, 8.18053037e-02f, -1.74537912e-01f, -8.38989243e-02f, -1.23720586e-01f, 4.93089333e-02f, 6.46456107e-02f, -9.75426212e-02f, 1.78498711e-04f, -5.28001450e-02f,
  1.44670932e-02f, 6.12728577e-03f, 8.31917301e-02f, 1.50835887e-03f, -5.87666482e-02f, -1.32898698e-02f, 6.99869245e-02f, -2.27088612e-02f, 1.91818982e-01f, -8.64663124e-02f,
  -2.19463650e-02f, 1.03113107e-01f, 6.46942575e-03f, 4.26535010e-02f, 2.75704823e-03f, -7.57777691e-03f, -9.60256979e-02f, 4.57546972e-02f, 1.84945583e-01f, -4.49627489e-02f,
  -1.11869425e-01f, -8.25426355e-02f, -3.89415100e-02f, -9.92851406e-02f, -7.71126971e-02f, 1.09130749e-02f, -6.44658580e-02f, -6.58090636e-02f, 4.36039194e-02f, -1.20565586e-01f,
  1.55591264e-01f, -1.21859054e-03f, 1.44910574e-01f, 1.46070823e-01f, 8.47905725e-02f, -8.08958188e-02f, 6.97671846e-02f, 7.37248734e-02f, 2.10538004e-02f, 5.71775325e-02f,
  -3.31444331e-02f, -4.19615163e-03f, -1.45325083e-02f, -1.17382884e-01f, 7.46759996e-02f, -3.74911800e-02f, -5.67159168e-02f, 1.35171756e-01f, 8.33863765e-02f, 7.55330175e-02f,
  9.35370326e-02f, -9.02691260e-02f, -1.09816603e-01f, -9.65967923e-02f, -1.07554741e-01f, 1.26128018e-01f, 3.10368836e-02f, -3.26383263e-02f, -5.52754998e-02f, 1.31797984e-01f,
  4.16850708e-02f, -3.33386064e-02f, 1.37490174e-03f, 1.11923687e-01f, -5.36596440e-02f, -6.54708296e-02f, -1.73032209e-02f, -4.48199809e-02f, 6.18313476e-02f, -1.41063482e-02f,
  9.63803232e-02f, 9.91886556e-02f, 3.27843353e-02f, -3.25353891e-02f, 4.62917984e-03f, 1.51539510e-02f, -4.63156626e-02f, -9.44305509e-02f, -6.44602580e-03f, 1.20460451e-01f,
  -1.15621246e-01f, -1.16692036e-01f, 8.47171471e-02f, -2.17643492e-02f, 1.13264062e-01f, -3.55092697e-02f, -1.54392486e-02f, 4.15227935e-02f, -7.23993108e-02f, -8.96364730e-03f,
  -5.89755848e-02f, 1.63454995e-01f, 9.95201897e-03f, 8.84526670e-02f, -1.17561571e-01f, 1.01301573e-01f, -8.97341445e-02f, -2.95434911e-02f, 8.21745992e-02f, -4.77052256e-02f,
  8.60664323e-02f, -4.39660437e-02f, 1.84651598e-01f, -8.51071328e-02f, 5.55204041e-03f, 1.37412176e-01f, -9.75589976e-02f, -6.57583028e-02f, -7.54983276e-02f, -1.73572257e-01f,
  -3.63775715e-02f, 2.39737565e-03f, 1.53020740e-01f, 5.53534031e-02f, 1.08515173e-01f, 1.03821293e-01f, 1.05148200e-02f, -1.37325168e-01f, 1.13013186e-01f, -8.87055621e-02f,
  -2.46698186e-02f, -8.62394944e-02f, -1.32197022e-01f, 6.91787302e-02f, 2.11876154e-01f, -9.89932567e-03f, 6.00190200e-02f, 2.26286411e-01f, 6.19204976e-02f, 1.34607151e-01f,
  -6.31013811e-02f, 5.43008037e-02f, -4.52962033e-02f, 1.16498843e-01f, -9.54445973e-02f, 1.01150990e-01f, 2.27731228e-01f, 5.06269895e-02f, 3.69796827e-02f, 2.62620822e-02f,
  -6.76706880e-02f, 1.47544265e-01f, 2.59672571e-02f, -1.03954963e-01f, -3.48436385e-02f, 4.05387394e-02f, 2.28991732e-02f, 1.43823907e-01f, 1.29115567e-01f, -4.79282029e-02f,
  1.65151209e-01f, 1.07077599e-01f, -1.19885996e-01f, 1.70076102e-01f, -2.11674064e-01f, 5.37064150e-02f, 1.59702003e-01f, 1.21312574e-01f, -1.86499566e-01f, 1.01440310e-01f,
  -6.13025017e-02f, 6.49473369e-02f, 1.12863429e-01f, -5.98765239e-02f, 2.01003496e-02f, 2.96325833e-02f, 1.11364521e-01f, -3.03420871e-02f, 6.81121200e-02f, 2.38039419e-02f,
  -2.76336193e-01f, -2.30968874e-02f, -9.57391283e-04f, 7.18801394e-02f, 1.49595901e-01f, 2.17053983e-02f, 3.27637792e-01f, -2.85854697e-01f, 3.31996940e-02f, 7.26038516e-02f,
  -8.38533118e-02f, -9.87034962e-02f, 1.22854702e-01f, -9.89665538e-02f, 1.85136423e-01f, -7.07976446e-02f, 5.62818302e-03f, -1.28612146e-01f, 2.15535909e-02f, -4.30723792e-03f,
  -1.00015476e-02f, 3.38133201e-02f, -4.61172722e-02f, -3.29686748e-03f, -6.87214583e-02f, 2.54537873e-02f, -6.12569675e-02f, -4.22744527e-02f, -1.43151611e-01f, 1.21548966e-01f,
  1.24566637e-01f, -2.19416186e-01f, -1.01568580e-01f, 2.62192022e-02f, -1.24181449e-01f, 4.85442989e-02f, -1.21345483e-01f, 8.74042138e-02f, 3.89392227e-02f, -7.79581442e-02f,
  -4.34316695e-02f, 3.97941321e-02f, 9.94227920e-03f, 1.85160369e-01f, 9.60276797e-02f, -2.96189263e-02f, -2.69140173e-02f, -5.64821921e-02f, -9.38552842e-02f, -4.61268909e-02f,
  1.19557299e-01f, -7.05736578e-02f, -1.01617716e-01f, -1.06129115e-02f, 5.28877899e-02f, 4.61709760e-02f, 1.14305921e-01f, 2.93693691e-02f, -9.44322422e-02f, 4.33957167e-02f,
  5.81324287e-02f, 3.64909992e-02f, -1.00099586e-01f, 8.18338916e-02f, 1.33292362e-01f, 5.54911010e-02f, 9.24127772e-02f, 1.68297812e-01f, -5.99948764e-02f, 1.23985134e-01f,
  5.69958836e-02f, 1.10846423e-01f, 5.52139729e-02f, 5.98691218e-02f, 2.07285788e-02f, -9.18538030e-03f, -6.26591370e-02f, 6.82963282e-02f, 1.34100959e-01f, 7.43871108e-02f,
  1.07394405e-01f, -8.67407694e-02f, 4.57552858e-02f, 1.27287433e-01f, 5.17246425e-02f, 1.43259510e-01f, 2.48021483e-02f, 7.07227215e-02f, 2.39532385e-02f, -1.03875168e-01f,
  1.25953585e-01f, -5.46956398e-02f, 1.25503793e-01f, 2.38524824e-02f, -6.07271492e-02f, 7.17936233e-02f, -8.71406496e-02f, 1.73457824e-02f, 3.29844616e-02f, 8.65588412e-02f,
  -6.88390583e-02f, -1.17115472e-02f, -7.82208983e-03f, 1.94829479e-02f, 6.23873854e-03f, 3.28557231e-02f, -1.13189653e-01f, -8.46182704e-02f, 1.21465527e-01f, -2.73035839e-02f,
  -1.05044104e-01f, 3.53633054e-02f, -1.24059832e-02f, 7.82721564e-02f, 6.84659407e-02f, -1.27876237e-01f, 6.95243999e-02f, -2.60057617e-02f, 9.74580529e-04f, -2.06238665e-02f,
  -3.27484868e-02f, -5.00179566e-02f, -1.29461795e-01f, -5.89642413e-02f, -2.62783654e-03f, -1.56161105e-02f, -9.39000621e-02f, -8.82050861e-03f, -5.02953194e-02f, -1.13851435e-01f,
  1.15667798e-01f, 6.12726174e-02f, -1.03987142e-01f, 7.58178234e-02f, 5.86562008e-02f, 1.06320418e-01f, 6.10832311e-02f, 9.57993269e-02f, 9.34360847e-02f, -4.77780402e-02f,
  -2.52433140e-02f, 8.12359899e-02f, 5.66477887e-02f, -8.64714235e-02f, -1.04722083e-01f, 3.10758259e-02f, -1.03808515e-01f, -7.17293173e-02f, 4.63741012e-02f, -3.18195224e-02f,
  1.04389906e-01f, -3.19885500e-02f, -2.95395683e-02f, -1.03765719e-01f, -1.24459602e-01f, -1.18078589e-02f, 5.94075806e-02f, -2.84241624e-02f, 1.70606554e-01f, 8.21426883e-02f,
  -6.59022182e-02f, 1.17215432e-01f, 2.22987924e-02f, -6.79918975e-02f, 3.10934633e-02f, -6.23862334e-02f, -6.87342808e-02f, -1.02093637e-01f, -9.90934297e-03f, 9.10460129e-02f,
  1.05218843e-01f, 1.17229529e-01f, -9.83774364e-02f, 6.20108135e-02f, 1.67188589e-02f, 8.75049382e-02f, -9.46538299e-02f, -2.64035515e-03f, 2.05596209e-01f, 2.83262208e-02f,
  8.45296010e-02f, -1.07837327e-01f, 2.09760834e-02f, 1.57293882e-02f, 1.69065997e-01f, 1.70209602e-01f, 1.23417586e-01f, 8.87125582e-02f, 1.63973570e-02f, -7.76238889e-02f,
  9.34119970e-02f, 1.16510009e-02f, -4.00344171e-02f, -4.03271839e-02f, 5.77792749e-02f, 1.21030137e-01f, 2.95131020e-02f, -6.40506148e-02f, 3.39736938e-02f, -7.69907050e-03f,
  1.67456105e-01f, 1.35780247e-02f, 1.43617624e-03f, 1.34953842e-01f, -5.08292466e-02f, 4.80049141e-02f, 1.67851239e-01f, -7.83557668e-02f, -3.95697206e-02f, -1.10957086e-01f,
  4.61398698e-02f, 9.87846497e-03f, 1.19951852e-01f, -1.79470852e-02f, -1.18943542e-01f, 1.66938424e-01f, -1.25396252e-03f, -2.19094614e-03f, 1.49478698e-02f, -1.25216916e-01f,
  -4.13915217e-02f, -9.04918686e-02f, -4.50769998e-02f, -4.63713780e-02f, -7.69610107e-02f, -3.22364882e-04f, -4.30645384e-02f, -1.88925210e-02f, 1.34077623e-01f, -8.08364619e-03f,
  -1.14565408e-02f, -4.61920090e-02f, 8.85932967e-02f, -1.79482296e-01f, -7.46629611e-02f, 4.04470935e-02f, 1.29024372e-01f, 1.13540694e-01f, -9.03774500e-02f, 4.76519763e-02f,
  9.49200839e-02f, -8.26336890e-02f, 5.52507564e-02f, 8.33640024e-02f, 6.24871477e-02f, 1.22387633e-01f, 4.50068749e-02f, -9.65243280e-02f, -1.08357690e-01f, -4.51605357e-02f,
  -3.38514335e-02f, 1.42053783e-01f, 2.84377001e-02f, 3.65775749e-02f, 2.38116197e-02f, -8.01970959e-02f, -4.96236272e-02f, 1.51973963e-01f, -4.38451432e-02f, 5.42712659e-02f,
  1.22436993e-01f, 8.96202214e-03f, 8.65738094e-02f, -8.26973990e-02f, -1.04709221e-02f, -4.48176153e-02f, -5.38300574e-02f, 3.09105609e-02f, 8.90109167e-02f, -3.72311585e-02f,
  9.47745368e-02f, 1.07634746e-01f, 6.78354874e-02f, 7.75704160e-02f, 5.93236759e-02f, -9.26365405e-02f, 1.05411284e-01f, 1.13366209e-01f, -1.14516363e-01f, 9.44178775e-02f,
  -1.22135483e-01f, 1.53783534e-03f, 2.65751798e-02f, -1.25217825e-01f, 3.38202976e-02f, -7.14940904e-03f, 1.79676097e-02f, -8.73047262e-02f, -9.22244564e-02f, -1.14957891e-01f,
  1.17917500e-01f, -1.08352698e-01f, 3.58358845e-02f, -6.34370223e-02f, -8.12350959e-02f, 7.81687722e-03f, -1.99993458e-02f, 9.18050781e-02f, 7.49699324e-02f, -8.97344854e-03f,
  -6.98990151e-02f, -3.38215828e-02f, 2.67707109e-02f, 1.32734686e-01f, 8.69337246e-02f, 8.96584913e-02f, 1.56345859e-01f, 1.78919345e-01f, -2.63893642e-02f, -9.33068618e-02f,
  5.25336294e-03f, -1.33127701e-02f, 5.75379655e-02f, 3.70328538e-02f, 1.46092236e-01f, -1.10705169e-02f, -7.17997476e-02f, 1.85613170e-01f, 1.13609329e-01f, 1.03607662e-01f,
  9.55954194e-02f, 3.01872399e-02f, 9.91052315e-02f, 1.12857148e-01f, -5.14447503e-03f, -8.99739936e-02f, 1.05239831e-01f, -1.06388465e-01f, -2.31846664e-02f, -3.21476199e-02f,
  6.39256164e-02f, 3.69380079e-02f, 1.19276688e-01f, -1.54754361e-02f, 7.27365315e-02f, -4.02065143e-02f, -8.53069872e-02f, -3.39673050e-02f, 1.88190918e-02f, -6.35041296e-02f,
  5.72166555e-02f, -3.79156396e-02f, -1.18477717e-01f, 1.22729234e-01f, -4.08670641e-02f, 5.48197515e-02f, 3.02046388e-02f, -6.43696710e-02f, 3.39518115e-02f, -1.19620219e-01f,
  -5.70734553e-02f, -7.34205022e-02f, 4.61628735e-02f, 8.03500116e-02f, 5.87445050e-02f, -9.08030719e-02f, -7.83858635e-03f, 1.63854226e-01f, -1.40365183e-01f, -6.94943294e-02f,
  -1.44364787e-02f, -6.80758357e-02f, -1.18806906e-01f, 9.46890786e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.30807176e-01f, -4.17777197e-03f, 1.38030887e-01f, 1.31785229e-01f, 8.25675204e-02f, 4.12394553e-02f, -4.12448496e-02f, 3.31691951e-02f, -7.75538385e-02f, 7.75562972e-02f,
  1.54091969e-01f, 1.37701318e-01f, -5.91207445e-02f, 1.07295804e-01f, -2.64447499e-02f, 1.53926596e-01f, 8.81701261e-02f, -4.02252823e-02f, 1.54253971e-02f, 1.03651218e-01f,
  8.87035206e-02f, -6.40151575e-02f, 2.38156063e-03f, -2.41679586e-02f, -9.79943126e-02f, 7.13875964e-02f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  9.42969620e-02f, 1.97765953e-03f, 2.62165181e-02f, 7.26453140e-02f, 1.41353048e-02f, 1.36003345e-01f, 4.72263247e-02f, -3.58028710e-02f, 8.78634080e-02f, -2.12131310e-02f,
  -3.33605073e-02f, -1.29461080e-01f, -5.75657412e-02f, -3.21442522e-02f, 2.64506359e-02f, -1.32969722e-01f, 6.54354598e-03f, -1.92794114e-01f, 1.35388985e-01f, -1.10082157e-01f,
  -2.12682590e-01f, -1.21229470e-01f, -4.42683771e-02f, 5.23079112e-02f, 1.30147502e-01f, -2.57434636e-01f, -2.11976781e-01f, -1.50731221e-01f, -3.39235961e-02f, -3.65311615e-02f,
  8.10781866e-02f, -1.18024044e-01f, 1.88416004e-01f, 1.08798239e-02f, -6.89238310e-02f, 1.41017199e-01f, 1.20692268e-01f, 1.06141262e-01f, 1.51181683e-01f, -5.28240167e-02f,
  1.27056940e-02f, 2.19774544e-01f, 2.35416755e-01f, 7.16494173e-02f, 1.62567962e-02f, -1.76408812e-01f, 5.01818135e-02f, 1.88390121e-01f, -1.02605194e-01f, -1.86305463e-01f,
  -8.63392577e-02f, -9.12100449e-02f, 1.66887604e-02f, -6.26203930e-03f, 2.64145788e-02f, 1.07373089e-01f, 2.92990473e-03f, -7.62729719e-02f, -2.98051357e-01f, 6.73636347e-02f,
  6.79647699e-02f, -8.99192318e-02f, -1.32654786e-01f, -1.14038222e-01f, -1.29426986e-01f, 5.38387895e-02f, 1.12049758e-01f, 5.99620454e-02f, 1.10662214e-01f, 8.54233578e-02f,
  6.71212524e-02f, -5.79276010e-02f, -1.13617860e-01f, -2.66357027e-02f, 2.87678298e-02f, -6.68792352e-02f, 3.09021119e-02f, -6.54938594e-02f, -5.77050745e-02f, -5.70106208e-02f,
  -9.74029601e-02f, -1.16970457e-01f, -5.68515025e-02f, 3.18402238e-02f, -1.49340764e-01f, 5.58485202e-02f, -1.63115412e-01f, -1.75517902e-01f, 6.01422824e-02f, -1.83524400e-01f,
  -1.99465841e-01f, -2.08726630e-01f, -1.48502260e-01f, -1.81012332e-01f, 8.53479132e-02f, -6.59114569e-02f, 1.17598221e-01f, -6.93381727e-02f, -8.29039365e-02f, 5.32251783e-02f,
  2.24086672e-01f, 1.16471581e-01f, -1.17055755e-02f, -6.33612797e-02f, 1.97259672e-02f, 1.40408427e-01f, 1.25336781e-01f, -5.86610213e-02f, -9.17652026e-02f, 7.57950079e-03f,
  7.44769201e-02f, 1.33847758e-01f, -2.13126000e-02f, 4.19347994e-02f, -8.90657902e-02f, -9.95993614e-02f, -1.05350493e-02f, -1.38708383e-01f, -4.30330969e-02f, -3.50457412e-04f,
  -5.09518646e-02f, -8.04643258e-02f, -2.31275633e-01f, 5.28903073e-03f, 8.26121494e-02f, -9.82913282e-03f, 5.39793111e-02f, 9.06674266e-02f, -1.33062126e-02f, -2.59100273e-02f,
  1.93015728e-02f, -1.25218213e-01f, 1.88853778e-02f, -7.18693659e-02f, 3.49635519e-02f, -9.18004289e-02f, 1.20057873e-01f, 1.20864108e-01f, -6.67555779e-02f, -4.42234427e-02f,
  6.21087551e-02f, -1.29585803e-01f, 1.91306829e-01f, 1.53044105e-01f, 1.50499851e-01f, 1.39234155e-01f, 2.23967014e-03f, 7.47380555e-02f, 2.47506499e-01f, -1.55458301e-01f,
  1.33514255e-01f, 1.24121252e-02f, -4.00816649e-02f, 8.63307714e-02f, 1.22676224e-01f, -3.62315960e-02f, 5.54758906e-02f, -6.96601868e-02f, -8.83276239e-02f, -1.28079906e-01f,
  -1.12679616e-01f, 1.99145272e-01f, -4.41794693e-02f, 1.42207220e-01f, -1.44490853e-01f, -6.48453087e-02f, -1.65373281e-01f, 8.27649757e-02f, 3.77931334e-02f, -1.09806255e-01f,
  -2.88765043e-01f, -7.62133598e-02f, -5.88693246e-02f, -1.26671851e-01f, 1.21274646e-02f, 7.12110847e-02f, 1.33917078e-01f, -1.74895212e-01f, -6.91186637e-02f, -3.82873937e-02f,
  8.25174078e-02f, 7.94219896e-02f, 1.74932912e-01f, 1.25372380e-01f, 1.14695631e-01f, 1.33013487e-01f, 6.92428425e-02f, -2.44665947e-02f, -8.89277458e-02f, -3.20205018e-02f,
  7.60501027e-02f, -4.32880074e-02f, -1.04662180e-01f, 4.83167209e-02f, -3.41831930e-02f, -1.77574903e-02f, -1.43187586e-02f, -1.79187372e-01f, -7.73353353e-02f, 2.55783368e-02f,
  1.54027930e-02f, -9.42403451e-02f, -6.94483370e-02f, -5.65868095e-02f, -4.25102608e-03f, 5.31471297e-02f, -3.84881683e-02f, -1.52172402e-01f, 7.58419409e-02f, -5.52084856e-02f,
  -2.69960463e-01f, 6.08709157e-02f, 1.43255949e-01f, 8.72981995e-02f, 1.39614418e-01f, -9.19904858e-02f, -2.32419357e-01f, 3.22427345e-03f, 9.56957713e-02f, -2.30870545e-02f,
  -1.68491788e-02f, -1.45859450e-01f, 4.67273220e-02f, 8.22232217e-02f, -1.50405923e-02f, -6.84283599e-02f, -4.94134147e-03f, 2.63179392e-02f, -1.79766208e-01f, 1.13643937e-01f,
  -9.95080639e-03f, -1.20760269e-01f, -6.09105937e-02f, 8.94532166e-03f, -3.04439850e-02f, 7.36564677e-03f, 3.91852446e-02f, 7.58598745e-02f, -3.03338226e-02f, 3.82091068e-02f,
  1.21449642e-01f, -5.27666956e-02f, -3.07794218e-03f, 1.65015474e-01f, 4.02047969e-02f, -8.40300396e-02f, 1.03510238e-01f, -9.98540893e-02f, 4.60095219e-02f, -5.00383452e-02f,
  1.41364068e-01f, -1.54649829e-02f, -7.34759942e-02f, 6.94125444e-02f, 2.42001973e-02f, 9.97510627e-02f, -9.34638977e-02f, -3.84294018e-02f, -3.70752439e-02f, -7.33838156e-02f,
  2.87482757e-02f, 6.39147237e-02f, 1.00751489e-01f, 1.08572930e-01f, 3.42647322e-02f, 2.61123106e-02f, -1.27708703e-01f, 9.91755128e-02f, 8.77226889e-02f, 9.30968076e-02f,
  4.40887660e-02f, -2.10036021e-02f, 8.98923818e-03f, -3.74353491e-02f, -6.13299534e-02f, -7.20896497e-02f, 1.39504904e-02f, -5.78003889e-03f, -2.86901440e-03f, -1.47062436e-01f,
  5.98801821e-02f, 5.96074797e-02f, 1.46140661e-02f, -5.08341081e-02f, -1.21344738e-01f, 6.62140027e-02f, -5.84610216e-02f, -1.26689285e-01f, 8.98461863e-02f, -2.78170612e-02f,
  8.49643201e-02f, -6.62903488e-02f, 1.42379209e-01f, -1.55144364e-01f, 1.60142798e-02f, 4.08192277e-02f, -8.56294762e-03f, -5.56548722e-02f, 4.64733057e-02f, -8.21732059e-02f,
  9.40518901e-02f, -3.05509157e-02f, 9.86796692e-02f, 4.51923199e-02f, 4.02294993e-02f, -8.01239684e-02f, -3.72171178e-02f, 9.34377536e-02f, -6.58123335e-03f, 4.35691513e-02f,
  4.69522700e-02f, -9.16787386e-02f, 1.04269862e-01f, 9.17875245e-02f, 7.50230299e-03f, 2.27128007e-02f, 1.00871108e-01f, 8.40753242e-02f, 2.58782618e-02f, 3.46434526e-02f,
  -7.06275599e-03f, 3.61022446e-03f, -8.35952684e-02f, 3.65338959e-02f, 1.18444510e-01f, 7.83699453e-02f, 8.32493454e-02f, 1.55544311e-01f, -9.63690653e-02f, -4.99685120e-04f,
  2.15495769e-02f, 4.81987447e-02f, 1.14725925e-01f, -1.80687055e-01f, 3.65813933e-02f, -8.87492895e-02f, -2.32299305e-02f, 1.20919436e-01f, -3.58516909e-02f, 8.91322419e-02f,
  1.80662498e-02f, 1.41156942e-01f, 3.20723578e-02f, 2.07588598e-01f, -5.43163307e-02f, -5.86011149e-02f, 5.65748550e-02f, 2.05146968e-01f, 1.05595790e-01f, 1.16509177e-01f,
  -1.59840882e-01f, -6.66400492e-02f, -9.43531394e-02f, 1.25506625e-01f, 2.09376335e-01f, -4.45154980e-02f, -2.78307676e-01f, -5.10318205e-02f, -1.37438402e-01f, -8.12942013e-02f,
  -7.03216493e-02f, -7.59281665e-02f, -2.50742249e-02f, 6.45285025e-02f, 1.69177838e-02f, 6.26512384e-03f, 3.78492437e-02f, -1.24420680e-01f, 1.35603637e-01f, -4.59159836e-02f,
  1.07655406e-01f, -1.04617246e-03f, 5.24535365e-02f, 1.53262585e-01f, 2.39212081e-01f, -1.37260512e-01f, 5.09841554e-03f, 1.71598434e-01f, -3.55433598e-02f, -3.33920158e-02f,
  7.69835487e-02f, 1.03528807e-02f, -5.10641076e-02f, -2.73501035e-02f, 9.43274423e-02f, -9.52392444e-02f, -1.91680770e-02f, 9.51114297e-03f, 1.14046596e-01f, -7.69924074e-02f,
  8.16333815e-02f, 7.05170035e-02f, -4.14251313e-02f, -1.18496463e-01f, 1.73643738e-01f, -7.90581778e-02f, -6.06146529e-02f, 7.61559084e-02f, -8.10571983e-02f, 1.33060114e-02f,
  5.60007319e-02f, -8.49724412e-02f, 1.86894685e-01f, 1.21152677e-01f, -2.11525157e-01f, 2.04054520e-01f, -5.97507916e-02f, 1.72848672e-01f, 8.14512447e-02f, 1.86354376e-03f,
  -2.25768350e-02f, 1.47997797e-01f, -2.56203264e-01f, -2.31700629e-01f, 2.10965350e-02f, 1.59691587e-01f, 2.37514660e-01f, 1.41675295e-02f, -4.89321910e-02f, -2.03605875e-01f,
  2.05509394e-01f, 1.63262084e-01f, 2.42584990e-03f, 1.18909344e-01f, 8.54743347e-02f, 5.75773865e-02f, 9.75156650e-02f, 3.95764783e-02f, -3.36245238e-03f, 3.13715249e-01f,
  6.31024912e-02f, -1.29435658e-01f, -4.88717668e-02f, 2.72194333e-02f, 1.29605994e-01f, -1.88518435e-01f, -5.25609590e-02f, -5.94882704e-02f, -8.83056819e-02f, 3.62084992e-02f,
  -3.39020938e-02f, -1.75212294e-01f, -1.49252400e-01f, -9.49744731e-02f, 1.12971336e-01f, 1.89862251e-01f, -1.45107314e-01f, -4.47214171e-02f, 6.56926408e-02f, -8.66903216e-02f,
  -9.04534161e-02f, -1.16468683e-01f, 1.24864832e-01f, -8.33237842e-02f, 6.19707182e-02f, 2.86995396e-02f, 9.61404592e-02f, -1.14257455e-01f, 8.78608599e-02f, 3.46333273e-02f,
  4.82855551e-02f, -8.14289227e-02f, -1.00062182e-02f, -3.02873030e-02f, -6.47354797e-02f, -6.83766678e-02f, -1.77480765e-02f, 3.00403312e-02f, 1.15910005e-02f, 7.20779374e-02f,
  -1.20733976e-01f, 5.87790757e-02f, 2.91504506e-02f, -8.27468783e-02f, 8.56042653e-02f, -1.18921697e-01f, -1.66759670e-01f, -3.42947543e-02f, -8.03989172e-02f, -2.79556066e-02f,
  5.91889620e-02f, -4.12422232e-02f, 1.20052449e-01f, -3.09914406e-02f, 4.81434204e-02f, 2.02854350e-01f, -5.14935553e-02f, 1.13338307e-01f, -6.07327465e-03f, -7.51550347e-02f,
  1.27779454e-01f, -2.71984544e-02f, 6.02601208e-02f, 2.70908654e-01f, 1.20167471e-01f, -1.37074918e-01f, 6.73260540e-02f, 1.99083552e-01f, -9.77732241e-02f, -2.15396378e-02f,
  1.65486187e-01f, -1.55429572e-01f, -7.08025396e-02f, 1.47525042e-01f, 8.43994170e-02f, 8.80292207e-02f, -1.00638166e-01f, 1.38637081e-01f, -4.57520336e-02f, 3.01760640e-02f,
  -1.54665473e-03f, -1.04578927e-01f, 5.44803366e-02f, 2.54817773e-02f, 7.46282190e-02f, 4.74009588e-02f, 4.58043776e-02f, -1.27448468e-02f, 8.99917781e-02f, -1.04483433e-01f,
  7.91530833e-02f, -1.60443395e-01f, -3.91239598e-02f, -2.49024685e-02f, -3.82106118e-02f, 1.18641920e-01f, -5.70943505e-02f, -8.86219665e-02f, -7.60069266e-02f, 1.27830639e-01f,
  -1.72536984e-01f, 7.91577473e-02f, 2.35434044e-02f, -8.14495906e-02f, -1.17662251e-01f, -7.37261847e-02f, 8.22866783e-02f, 5.57729676e-02f, -9.89381000e-02f, -1.48680300e-01f,
  1.02498196e-01f, -2.04649210e-01f, -4.68616560e-02f, 1.14757381e-01f, 2.43406612e-02f, -1.12039708e-01f, -6.72630891e-02f, 2.25375798e-02f, 2.31701061e-01f, 9.00027081e-02f,
  -6.04569204e-02f, -3.28942649e-02f, -1.43703625e-01f, 5.03592640e-02f, 1.40289664e-01f, 1.14053944e-02f, 8.08966309e-02f, 1.85332641e-01f, -7.46853426e-02f, -2.75882389e-02f,
  6.77166581e-02f, -3.96024473e-02f, -1.06795870e-01f, 1.95265263e-02f, -1.85094047e-02f, 6.24833442e-02f, -1.24921747e-01f, -5.38512543e-02f, -9.11389664e-02f, 1.12326048e-01f,
  -1.30012557e-01f, 5.76827675e-02f, 1.92491356e-02f, 3.26809883e-02f, -8.68979618e-02f, 9.96630192e-02f, -8.91645923e-02f, 1.79417059e-01f, -5.22960164e-02f, -3.78189422e-02f,
  -1.72658730e-02f, 1.13432258e-01f, 8.89671817e-02f, 3.51025909e-02f, 1.51138514e-01f, 1.58520937e-01f, -1.51264844e-02f, 4.41181771e-02f, 7.04421997e-02f, -7.92321749e-03f,
  4.06235904e-02f, 2.17240572e-01f, 1.86963547e-02f, -2.18597278e-02f, 9.53333825e-02f, -2.42650852e-01f, 1.04241967e-01f, -1.11091055e-01f, -7.23450631e-02f, -1.62564248e-01f,
  2.06888378e-01f, 9.02518034e-02f, 1.82109475e-01f, 1.42592236e-01f, 6.93240436e-03f, 1.35802552e-01f, -1.16408259e-01f, -1.26507550e-01f, -2.46100053e-02f, -1.65416956e-01f,
  4.92154285e-02f, 1.46245062e-01f, 7.94784278e-02f, -2.67498821e-01f, -4.70456928e-02f, -2.67694835e-02f, 1.74904719e-01f, -6.27348348e-02f, 3.14730369e-02f, 6.46303892e-02f,
  -5.62907755e-02f, -1.80484399e-01f, -2.05175057e-02f, 1.94069982e-01f, -1.88540682e-01f, -1.44875735e-01f, -5.42625189e-02f, -7.92779550e-02f, -1.25082076e-01f, 3.45350476e-03f,
  -1.44969523e-01f, -1.71863571e-01f, -9.92925614e-02f, -1.65806517e-01f, 1.52516887e-01f, -1.42567649e-01f, 2.39324365e-02f, 4.39589052e-03f, -3.01741660e-02f, 1.39562294e-01f,
  -1.36937410e-01f, -1.14175491e-01f, -9.03790072e-02f, -1.09374605e-01f, -1.56316951e-01f, 7.74057135e-02f, -1.50938258e-02f, 4.13573049e-02f, 1.18275955e-01f, -5.15486533e-03f,
  -8.72347653e-02f, 1.43083325e-02f, -1.34624645e-01f, 6.33356199e-02f, 2.87766736e-02f, -1.24123417e-01f, -1.03971753e-02f, 1.42754182e-01f, -1.78833634e-01f, 1.09615721e-01f,
  1.09017946e-01f, -3.42184491e-02f, -1.26826176e-02f, 5.39141186e-02f, -1.37271360e-01f, 2.80832767e-01f, -3.22479308e-02f, -5.09816781e-03f, 6.20595627e-02f, 8.50493610e-02f,
  4.28025518e-03f, 1.65866718e-01f, -2.05876350e-01f, -6.03505224e-02f, -9.15381014e-02f, -1.57520771e-01f, -2.80563712e-01f, 1.00172952e-01f, -7.22734304e-03f, -2.05891989e-02f,
  -1.84378698e-01f, -2.45299801e-01f, -2.56323367e-01f, 2.73235813e-02f, 9.59938392e-02f, 2.96559156e-04f, 1.06542952e-01f, -9.08031613e-02f, 1.41516387e-01f, 6.44685701e-02f,
  5.09824976e-02f, 8.08071494e-02f, -1.04280576e-01f, -4.82686609e-02f, 1.20108269e-01f, -7.14197531e-02f, 9.50447097e-02f, 1.48312807e-01f, 1.69265941e-01f, -4.73544449e-02f,
  9.61665884e-02f, 1.67047922e-02f, 5.29652387e-02f, 6.41115233e-02f, 1.12106599e-01f, -6.91599324e-02f, -1.10626057e-01f, 1.85148586e-02f, -6.98918402e-02f, 3.63874175e-02f,
  -1.44906044e-01f, -6.38348833e-02f, 2.77665351e-02f, 1.84290595e-02f, 1.03136130e-01f, -5.15677892e-02f, 5.79971494e-03f, -7.08182007e-02f, 9.32680666e-02f, 1.95697993e-02f,
  8.39262269e-03f, -1.51311219e-01f, -4.56955470e-02f, -3.26651661e-03f, -1.02575026e-01f, -1.54371711e-03f, -5.12715504e-02f, 3.17522623e-02f, 1.90925717e-01f, -2.39887908e-01f,
  -1.56048432e-01f, 9.21689440e-03f, 9.80580673e-02f, -1.16284922e-01f, -3.67182121e-02f, -1.57700047e-01f, 4.02446091e-02f, -1.04120404e-01f, 3.86792310e-02f, -3.37610431e-02f,
  4.22472954e-02f, -5.01281284e-02f, 1.22974657e-01f, 1.48774326e-01f, -9.40660685e-02f, 1.70784935e-01f, 9.85780954e-02f, -9.35810581e-02f, 1.16198078e-01f, -2.68759299e-02f,
  4.66247322e-04f, 1.32284969e-01f, 1.58449914e-02f, -5.20206578e-02f, -1.36776552e-01f, 5.28367944e-02f, 3.73649746e-02f, 8.60506967e-02f, 7.26044700e-02f, 4.91203330e-02f,
  -3.39229740e-02f, -6.08232506e-02f, -1.81375802e-01f, 1.24436663e-02f, -8.17162171e-02f, -1.63984671e-01f, -5.06124757e-02f, -1.48351759e-01f, 1.71491459e-01f, 5.89484647e-02f,
  -2.82191429e-02f, 6.09395355e-02f, 7.96973258e-02f, -9.84956250e-02f, -6.90156873e-03f, 7.12978691e-02f, 8.72169361e-02f, 1.66012630e-01f, -1.10571750e-01f, 1.66540265e-01f,
  1.19654536e-01f, -9.40355957e-02f, -1.42211150e-02f, 1.67030439e-01f, 1.26367435e-01f, 5.91104329e-02f, 2.06507802e-01f, -1.09485164e-01f, 1.83176622e-01f, 2.67822500e-02f,
  1.60406485e-01f, 1.84470713e-01f, -8.74674916e-02f, 1.35422379e-01f, 9.01229382e-02f, 1.80284470e-01f, 1.74655691e-01f, 1.41709879e-01f, 2.90054791e-02f, 9.51321572e-02f,
  -2.42783308e-01f, 2.17934921e-02f, -9.04007908e-03f, -4.45215553e-02f, -2.29493082e-01f, -7.29932934e-02f, -2.01162353e-01f, 8.87012035e-02f, 2.22749952e-02f, -8.97393078e-02f,
  -1.11658007e-01f, -6.89927116e-02f, 8.43800546e-04f, -1.05620258e-01f, -8.44860673e-02f, 5.24871703e-03f, 1.58605427e-01f, -1.38139158e-01f, -9.98556316e-02f, -7.79650733e-02f,
  -2.86967997e-02f, 1.18909985e-01f, 1.02740295e-01f, 9.98202264e-02f, -8.24332088e-02f, 1.96606502e-01f, 1.88206568e-01f, 1.05122142e-01f, 4.38750051e-02f, 1.12762094e-01f,
  1.54600576e-01f, 9.30193439e-02f, -1.34458020e-01f, 1.94830205e-02f, -1.28284350e-01f, -5.73083162e-02f, 4.99107800e-02f, -1.16188414e-01f, 2.04319283e-02f, 3.10914237e-02f,
  -9.70855653e-02f, 1.81605283e-03f, 1.76362209e-02f, -3.08752917e-02f, -4.42648828e-02f, -1.17960401e-01f, 8.77888277e-02f, -6.18623607e-02f, -1.16087638e-01f, -3.45446616e-02f,
  -1.74986571e-02f, 1.53351855e-02f, -8.98989812e-02f, 1.17023513e-01f, 3.71966213e-02f, 1.23341471e-01f, -1.70125440e-01f, 2.49468118e-01f, 2.24974304e-01f, 1.64391309e-01f,
  -1.63371563e-01f, 1.28465071e-02f, -3.90795544e-02f, -3.16550694e-02f, -9.21960473e-02f, -1.83559164e-01f, -1.06641486e-01f, -2.45094895e-01f, 1.01722978e-01f, -7.14827031e-02f,
  -1.54993264e-02f, -3.88812609e-02f, -5.13672903e-02f, -2.00891450e-01f, -4.15036716e-02f, -3.83296236e-02f, -1.02362216e-01f, 2.83803761e-01f, -9.53460783e-02f, -1.98852401e-02f,
  7.81165361e-02f, 1.52259290e-01f, 1.00053556e-01f, -4.50187027e-02f, 9.17273853e-03f, -4.74715903e-02f, -1.81077674e-01f, -1.58209592e-01f, -1.57241285e-01f, -1.19554736e-01f,
  1.66768014e-01f, 7.23215267e-02f, 9.20711178e-03f, 7.88469519e-03f, 7.12237507e-02f, 1.76403776e-01f, 7.61431009e-02f, -1.56438891e-02f, 6.86847046e-02f, 1.05000183e-01f,
  8.18796083e-02f, 9.87678021e-02f, 3.56760696e-02f, -1.18028717e-02f, 5.81553089e-04f, 5.58986887e-02f, -6.96050003e-02f, 2.75278222e-02f, 6.07712679e-02f, -1.02218747e-01f,
  1.05184786e-01f, 2.62517948e-02f, -8.75834152e-02f, 1.11772224e-01f, 7.29812905e-02f, -1.17252842e-01f, -7.03007132e-02f, 1.62715808e-01f, -6.17745854e-02f, 1.77459016e-01f,
  -3.82905789e-02f, 1.09254837e-03f, 6.22839108e-02f, 1.17387898e-01f, -8.71269405e-02f, -3.47043824e-04f, -1.80922806e-01f, -1.05822727e-01f, -1.18205063e-01f, 1.54454028e-02f,
  1.52338475e-01f, -1.71142027e-01f, -1.49941808e-02f, -1.13686122e-01f, -1.87070698e-01f, -1.04536057e-01f, -2.82458067e-02f, 3.42812091e-02f, -1.17691047e-01f, -9.60562378e-02f,
  4.87204455e-02f, -7.79230967e-02f, -1.12042259e-02f, -7.62710301e-03f, -2.12059859e-02f, -9.59923118e-02f, -2.60294583e-02f, 4.27282043e-02f, -2.25781187e-01f, 1.03676274e-01f,
  4.88869585e-02f, -7.51019269e-02f, -2.28845212e-03f, -1.43977210e-01f, 6.04922920e-02f, 5.66897579e-02f, -7.00865090e-02f, 8.64589214e-02f, 5.76648973e-02f, 5.95553666e-02f,
  7.63728470e-02f, 8.31541419e-03f, -6.91881850e-02f, -9.47600454e-02f, -7.56114125e-02f, -1.56857055e-02f, 3.54560241e-02f, -1.43654585e-01f, -1.29394293e-01f, -6.06887378e-02f,
  -9.39743370e-02f, 7.67616704e-02f, 9.09150578e-03f, 1.05228528e-01f, -8.34486261e-02f, -5.79524674e-02f, -6.24854341e-02f, -6.88774362e-02f, -2.19173860e-02f, -2.37333793e-02f,
  -1.07341610e-01f, 9.47651789e-02f, 1.54578630e-02f, 6.12840690e-02f, -1.58732891e-01f, 1.24601483e-01f, 7.39361048e-02f, -1.33101523e-01f, -6.19207211e-02f, -1.27252564e-01f,
  1.14102170e-01f, 6.84744790e-02f, 3.49517912e-02f, 1.19355641e-01f, -6.67016730e-02f, 5.14549576e-02f, 8.56294557e-02f, 1.59633502e-01f, -4.95442674e-02f, 7.72949755e-02f,
  -1.83401391e-01f, 2.51255650e-02f, 6.31201938e-02f, 2.42279563e-02f, -6.13995343e-02f, 2.53210217e-01f, -2.22073067e-02f, -1.24516852e-01f, -4.47271019e-03f, 1.72990918e-01f,
  1.05401583e-01f, 9.09034237e-02f, 1.61959261e-01f, -1.50541544e-01f, -8.09861645e-02f, 1.54432282e-01f, 7.68157765e-02f, -8.98474082e-03f, 9.33321044e-02f, -5.88040054e-02f,
  1.20905891e-01f, 8.00197199e-02f, -3.09871491e-02f, 4.18849103e-02f, 5.30814193e-02f, 1.57519490e-01f, 6.35534227e-02f, 8.73354301e-02f, 1.00851081e-01f, -1.17993437e-01f,
  1.91233754e-01f, 1.81131139e-01f, -1.28968924e-01f, -1.25951111e-01f, 3.53200771e-02f, -3.39682102e-02f, -1.04562871e-01f, -1.10778868e-01f, 4.54484038e-02f, 5.81054874e-02f,
  -7.30948150e-02f, -8.05663969e-03f, -4.11237925e-02f, 1.20710924e-01f, 1.14519916e-01f, 2.69069403e-01f, -2.19946191e-01f, 9.61744506e-03f, 9.36972201e-02f, 1.62604243e-01f,
  1.02070056e-01f, 1.29024610e-01f, -2.17874974e-01f, -7.32240081e-02f, -1.40592486e-01f, 1.70926511e-01f, 1.22910654e-02f, -1.26763821e-01f, -1.10053467e-02f, -2.32791245e-01f,
  3.46862040e-02f, 3.14347399e-03f, 5.37521243e-02f, -1.91668086e-02f, 4.77649644e-02f, -1.64589122e-01f, -4.27218415e-02f, -2.23676991e-02f, 9.17670429e-02f, 1.04828998e-01f,
  7.72263929e-02f, -1.63989872e-01f, 1.00217856e-01f, 2.19181180e-02f, -6.26113862e-02f, -8.64031166e-02f, -1.11648187e-01f, 4.75593358e-02f, -5.80377504e-02f, -7.72780254e-02f,
  -1.09680131e-01f, -5.94189055e-02f, -7.65450299e-02f, 5.95916361e-02f, -3.22599411e-02f, 4.20666337e-02f, -1.13218032e-01f, 5.21095544e-02f, 1.75621882e-02f, -2.13096607e-02f,
  1.07837081e-01f, 6.63958341e-02f, -1.02083348e-01f, -7.36613423e-02f, 4.43312228e-02f, -3.93744670e-02f, 9.01076868e-02f, 1.61187164e-02f, 1.01483554e-01f, 7.68519640e-02f,
  8.40157568e-02f, -3.86750959e-02f, 4.88180108e-03f, 9.65420976e-02f, -1.96176413e-02f, -8.00227448e-02f, 2.83975843e-02f, -2.41459813e-02f, -4.06279648e-03f, -2.13583112e-01f,
  -4.12289687e-02f, -2.13578299e-01f, 6.22182079e-02f, -8.74564499e-02f, -4.19667996e-02f, -5.03802635e-02f, 1.42180458e-01f, -4.48123999e-02f, 8.87874588e-02f, -1.34551615e-01f,
  5.61105460e-02f, 5.94195239e-02f, -6.80948347e-02f, 1.00094534e-01f, 6.59637228e-02f, -2.06087261e-01f, 8.19795430e-02f, 6.01497106e-02f, 1.50796801e-01f, 1.04910284e-01f,
  2.93657240e-02f, -4.82693035e-03f, -1.26366215e-02f, -1.11075662e-01f, -1.01832576e-01f, 3.78685445e-02f, -8.98092240e-03f, -2.21181614e-03f, 1.38965905e-01f, 1.43818939e-02f,
  1.54602915e-01f, 1.07959338e-01f, -1.80253144e-02f, -1.12101212e-01f, -1.19601704e-01f, 1.15889043e-01f, -1.09336823e-01f, -8.74184817e-02f, 1.13362841e-01f, -9.25904810e-02f,
  -1.07357157e-02f, -1.37933940e-01f, 5.84587157e-02f, 3.99097949e-02f, 8.84829760e-02f, 8.10922682e-02f, 1.33940548e-01f, -1.06870057e-02f, -8.74231979e-02f, 8.68788511e-02f,
  2.80875880e-02f, 1.27403244e-01f, -1.33461908e-01f, 8.19853619e-02f, 4.94648479e-02f, -5.98310530e-02f, 4.89296503e-02f, 1.04112849e-01f, 8.47755224e-02f, 2.96958769e-03f,
  8.43834132e-03f, -8.17121193e-02f, -6.38809651e-02f, -8.05300623e-02f, 1.46299481e-01f, -1.85887516e-01f, 5.52846827e-02f, -2.19311640e-01f, -5.94822988e-02f, -1.70944378e-01f,
  8.66101012e-02f, 3.71328816e-02f, 1.15812249e-01f, 4.15140614e-02f, 1.16855256e-01f, 1.92794278e-01f, 1.11955829e-01f, 1.47367731e-01f, 1.11960657e-02f, -1.99993566e-01f,
  -9.22468957e-03f, 1.72040507e-01f, -5.84046282e-02f, 1.26116738e-01f, -1.43100649e-01f, 5.16384244e-02f, -8.89368653e-02f, -6.84631988e-02f, 7.15941796e-03f, 5.16026765e-02f,
  4.48623374e-02f, -1.45024583e-01f, -8.88043270e-02f, -8.85411445e-03f, 2.11140931e-01f, 1.75500736e-01f, 7.46201575e-02f, -2.10225042e-02f, 4.47702743e-02f, 1.02700666e-01f,
  1.95665807e-02f, -1.30019829e-01f, -8.74549802e-03f, -1.07801385e-01f, 1.08174853e-01f, -2.13676050e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  2.43099093e-01f, 8.20857361e-02f, 1.47541270e-01f, 1.19897254e-01f, 1.57234937e-01f, 3.62042710e-02f, -8.16110969e-02f, -2.48365328e-02f, 2.02892348e-01f, 1.50413603e-01f,
  -4.17428277e-02f, 1.70222253e-01f, 1.88478902e-01f, -1.63960811e-02f, 1.65661275e-01f, 1.88912705e-01f, 3.71079184e-02f, 2.54029900e-01f, -6.16101436e-02f, 2.13568583e-02f,
  3.17334622e-01f, -1.13424018e-01f, 2.34388039e-01f, 1.86818719e-01f, -5.10860793e-02f, 4.62982021e-02f, 2.63407547e-03f, -2.57638972e-02f, 9.56216305e-02f, -2.15722993e-02f,
  6.16170466e-02f, 5.25530539e-02f, -1.37464851e-01f, -1.01159327e-02f, -8.34759176e-02f, 1.12020895e-01f, -2.27346465e-01f, 1.12529472e-01f, -9.88343358e-02f, -6.59208298e-02f,
  -1.64306715e-01f, 1.81219026e-01f, -2.59015530e-01f, -8.42714906e-02f, -9.11400169e-02f, 1.94693312e-01f, -6.84506912e-03f, -1.22471116e-01f, 2.62426436e-01f, -1.07604504e-01f,
  -1.47627622e-01f, 9.43469107e-02f, 1.18765794e-01f, 1.51850671e-01f, 2.66422890e-02f, 2.84829527e-01f, 1.49300426e-01f, 1.15281262e-01f, 1.87556490e-01f, 4.78766561e-02f,
  -4.10815589e-02f, 1.03159826e-02f, -4.27220762e-02f, 9.28701088e-03f, 1.40123114e-01f, 7.74182454e-02f, -5.73693365e-02f, 8.78519118e-02f, 1.44148078e-02f, 5.94063755e-03f,
  1.68393567e-01f, 8.95014927e-02f, -3.76608856e-02f, 1.19675420e-01f, 1.10533096e-01f, 1.49276003e-01f, -6.40284643e-02f, 1.18948808e-02f, 9.92897227e-02f, 1.05452098e-01f,
  -8.38984328e-04f, 1.11874677e-01f, 7.62112290e-02f, 4.13901582e-02f, 2.42373161e-02f, 7.10125128e-03f, 1.02078266e-01f, 1.17055774e-01f, 1.48548260e-01f, -8.85253549e-02f,
  5.36507703e-02f, 9.76654664e-02f, -2.42349971e-02f, 1.78707182e-01f, 4.44034813e-03f, -1.39159903e-01f, 3.42211314e-02f, 1.33876786e-01f, 2.41252109e-02f, 3.83533016e-02f,
  -3.84893529e-02f, -1.38692752e-01f, -8.33070725e-02f, 4.94133271e-02f, 8.61678869e-02f, 8.53362456e-02f, 3.80423963e-02f, -1.09036192e-01f, -7.11052045e-02f, -1.69491135e-02f,
  -3.51178907e-02f, 1.01562394e-02f, -4.69297804e-02f, 2.80351136e-02f, 1.56733796e-01f, -1.68081045e-01f, -1.77596640e-02f, -5.77930138e-02f, 9.33161750e-02f, -1.10848971e-01f,
  3.03384755e-03f, -5.36833555e-02f, -1.51864225e-02f, -1.37777813e-02f, -1.41233555e-03f, 2.64443010e-02f, 7.33864121e-03f, -1.29420776e-02f, -3.49244848e-02f, -1.09676346e-01f,
  1.14213534e-01f, 1.04645953e-01f, 1.06504366e-01f, 1.00727856e-01f, 5.35444058e-02f, -9.42032188e-02f, 5.49106533e-03f, 7.57434219e-02f, 4.69683111e-02f, 4.84769382e-02f,
  1.49343044e-01f, 1.43377647e-01f, 9.06987637e-02f, 9.63646099e-02f, -7.70159513e-02f, -9.57477540e-02f, -3.63334641e-02f, -6.09381460e-02f, -4.86909412e-02f, 1.51372463e-01f,
  -1.11481085e-01f, -1.29905120e-01f, 1.43689081e-01f, -9.88271534e-02f, -1.85191557e-01f, 2.98118833e-02f, -1.39648557e-01f, 4.07938585e-02f, -8.70692134e-02f, 3.07566486e-02f,
  1.84944883e-01f, -6.00847192e-02f, 1.55854777e-01f, 7.16997460e-02f, 3.69891115e-02f, 2.62520406e-02f, -4.17829119e-02f, -4.53064330e-02f, 4.40395512e-02f, 9.50532630e-02f,
  1.17471382e-01f, 9.38085094e-02f, -1.24944612e-01f, 1.33111298e-01f, 7.87361413e-02f, 2.79637240e-02f, 3.74830589e-02f, 3.08503360e-02f, 5.96514493e-02f, -9.69189778e-02f,
  -9.61310416e-03f, 7.28574619e-02f, 3.52736674e-02f, 1.27518266e-01f, -1.52800856e-02f, 1.01171114e-01f, -1.79248482e-01f, 7.47785270e-02f, 5.54688200e-02f, -9.32243317e-02f,
  -1.60902053e-01f, 8.15352146e-03f, 1.93913933e-02f, 4.14813049e-02f, 7.93787763e-02f, -6.55272603e-02f, 7.91799724e-02f, 3.97663340e-02f, 4.24454920e-02f, -3.21702547e-02f,
  -9.88851115e-02f, -3.65934484e-02f, -6.82129860e-02f, 5.70961449e-04f, 3.34647261e-02f, 4.72247489e-02f, 7.25665269e-03f, -1.01906970e-01f, 5.48426248e-03f, -6.86761141e-02f,
  8.66591260e-02f, -1.22090802e-01f, -2.86736190e-02f, -1.04719093e-02f, 7.54899904e-02f, -2.85449624e-02f, 1.24070980e-01f, 2.30947789e-02f, 5.19493297e-02f, -8.51659924e-02f,
  6.42654672e-02f, -1.06892020e-01f, -7.01564178e-02f, -1.23681314e-01f, 3.78426611e-02f, 4.23702635e-02f, -1.04760826e-01f, 9.32429358e-02f, 4.95301560e-03f, 1.97496521e-03f,
  3.16912681e-02f, 1.17168389e-01f, -9.53878239e-02f, 9.61731523e-02f, -3.72870229e-02f, 3.97075526e-02f, 2.64053717e-02f, -8.40664469e-03f, 2.34168582e-02f, 1.00260928e-01f,
  1.09815150e-01f, -1.68819074e-02f, 4.34795469e-02f, -1.26684368e-01f, -1.13655724e-01f, 1.07165076e-01f, 9.92120281e-02f, -4.70494293e-02f, 6.79739863e-02f, -1.04624085e-01f,
  -1.23968765e-01f, -4.61317636e-02f, -1.23738468e-01f, 6.45417497e-02f, 5.65499626e-02f, 2.29607299e-02f, -8.35561752e-02f, -1.61702763e-02f, 1.31099895e-01f, -4.27428335e-02f,
  -4.13138308e-02f, -8.90043825e-02f, 5.30356243e-02f, -9.36062038e-02f, -2.41686236e-02f, -8.83181840e-02f, -1.13045678e-01f, 2.61892900e-02f, -3.42763253e-02f, 1.44493654e-02f,
  1.16257399e-01f, -8.86744112e-02f, -6.65093586e-02f, -7.20822439e-02f, 2.29570661e-02f, 2.01549716e-02f, -3.65783162e-02f, -3.39264199e-02f, 4.69842963e-02f, 6.27825558e-02f,
  -1.21356376e-01f, -8.25692788e-02f, 9.79874879e-02f, -5.31073250e-02f, 2.66494695e-02f, -4.95473407e-02f, 4.23786975e-02f, 6.69389069e-02f, -4.35797274e-02f, 1.17448248e-01f,
  -3.23264301e-03f, -5.84978051e-02f, -1.16810366e-03f, 1.75464489e-02f, 7.58950710e-02f, -3.96216772e-02f, 3.38015556e-02f, 4.69978899e-02f, 1.15328535e-01f, -3.45190591e-03f,
  -9.28985234e-03f, 1.40916750e-01f, 4.43297587e-02f, 2.36997269e-02f, -5.88552766e-02f, 8.07523802e-02f, 1.86176635e-02f, -1.21512309e-01f, -2.39874385e-02f, 4.87444969e-03f,
  -8.84703770e-02f, -3.21061499e-02f, 8.34691748e-02f, -6.87244982e-02f, -4.46106605e-02f, -8.11555758e-02f, 2.31516417e-02f, 6.91631958e-02f, -7.20343962e-02f, 5.53374290e-02f,
  1.60698760e-02f, 1.11213304e-01f, -9.71871540e-02f, 8.80555436e-02f, -1.06291689e-01f, -2.82882396e-02f, 4.88460176e-02f, -9.05502364e-02f, 2.54201703e-02f, -2.55912784e-02f,
  9.84487161e-02f, 4.54536639e-02f, 1.29418269e-01f, -1.03745237e-01f, 1.22530617e-01f, 2.22143475e-02f, -4.72371690e-02f, -3.61685418e-02f, 1.15075313e-01f, -3.80510241e-02f,
  1.04130283e-02f, -3.67707647e-02f, 7.35256597e-02f, 1.00700334e-01f, 1.28689140e-01f, 6.40532328e-03f, -7.81059358e-03f, 1.22949913e-01f, -6.65819123e-02f, -7.63610080e-02f,
  -8.75133947e-02f, -6.49769306e-02f, 1.18294537e-01f, 8.32687169e-02f, 7.43803456e-02f, 3.29513475e-02f, 5.61932325e-02f, -6.91657364e-02f, -1.37899712e-01f, -6.82392716e-02f,
  -3.08811888e-02f, -9.02173221e-02f, 1.10559978e-01f, -5.36000021e-02f, -4.61288020e-02f, -1.95882320e-02f, -3.99894007e-02f, 1.20055173e-02f, -9.96279866e-02f, -7.58107901e-02f,
  -1.24369681e-01f, 1.37551678e-02f, 7.86373839e-02f, 1.30852804e-01f, 1.20033041e-01f, 1.00980163e-01f, 7.88547322e-02f, 7.70026818e-02f, -7.08475187e-02f, -6.76391821e-04f,
  -1.21243328e-01f, -6.86420053e-02f, 1.67168155e-02f, 1.05737090e-01f, 1.23789124e-02f, -2.91918032e-02f, 3.08761634e-02f, -1.44063095e-02f, -2.34994683e-02f, 6.81269169e-02f,
  -4.15233932e-02f, -1.94012914e-02f, -1.65652670e-02f, 4.11036424e-02f, 4.05049808e-02f, 7.98359662e-02f, -6.89475760e-02f, -6.18303940e-02f, -9.95799154e-02f, -1.05095066e-01f,
  -3.91037427e-02f, 1.12961575e-01f, -4.71081324e-02f, 4.15294915e-02f, -5.87140732e-02f, 9.82420146e-02f, -3.51146795e-02f, -1.40147414e-02f, 2.50313245e-02f, 1.85915753e-02f,
  1.01914391e-01f, 2.59732883e-02f, 5.31438440e-02f, 6.66512251e-02f, 1.15797497e-01f, 1.09944217e-01f, -1.87553391e-02f, -6.16632029e-03f, 1.21905439e-01f, 1.19442843e-01f,
  -5.01681268e-02f, 7.53033832e-02f, 1.14210412e-01f, 9.24481377e-02f, -1.67377442e-02f, -9.70296785e-02f, -6.60339892e-02f, 5.25571406e-02f, 7.83064514e-02f, -9.72424969e-02f,
  -3.79400365e-02f, 8.27511624e-02f, -8.09037760e-02f, 2.58809309e-02f, -9.31356102e-02f, 1.08808935e-01f, -9.82425455e-03f, -9.97938588e-02f, 7.63253272e-02f, 6.57420680e-02f,
  -4.13257889e-02f, 1.10066883e-01f, -8.81118774e-02f, -6.95556449e-03f, 1.00884020e-01f, -6.82291901e-03f, -6.75657392e-03f, -9.38384384e-02f, -7.07520545e-02f, 3.68340127e-02f,
  -5.30913956e-02f, -1.26110300e-01f, -1.64224543e-02f, -7.83271343e-03f, 4.48786188e-03f, 2.97017004e-02f, -1.21423498e-01f, 1.26280740e-01f, -7.59154409e-02f, -1.09044336e-01f,
  -3.22748497e-02f, -8.75984430e-02f, 1.25293359e-01f, -1.06239803e-01f, -1.09908782e-01f, 1.03871562e-01f, 9.89035144e-02f, 8.68219044e-03f, -8.81836489e-02f, 9.50376540e-02f,
  7.64042363e-02f, -6.56507025e-03f, -8.00041854e-02f, 4.60947976e-02f, -2.82120630e-02f, -7.80811384e-02f, 2.62134951e-02f, 7.02640414e-02f, 3.92160639e-02f, 4.99669388e-02f,
  5.02345152e-02f, -8.21657293e-03f, 1.13215700e-01f, 1.42610455e-02f, -1.33199289e-01f, -8.99308547e-02f, 4.75758091e-02f, 6.91790283e-02f, 3.93157750e-02f, -2.69795069e-04f,
  1.04473785e-01f, 7.09647462e-02f, 3.32365222e-02f, 1.10568143e-01f, -5.30049093e-02f, 4.02742364e-02f, -9.33059901e-02f, -2.85467189e-02f, 1.21897563e-01f, 2.74745896e-02f,
  1.29047364e-01f, 1.98007040e-02f, -1.10029176e-01f, 1.14384025e-01f, 1.05065648e-02f, -3.32112871e-02f, 5.99280708e-02f, -9.42574292e-02f, 1.24581538e-01f, -2.27938388e-02f,
  9.06798616e-03f, -4.76390161e-02f, 1.57509118e-01f, 6.26975670e-02f, 1.48471845e-02f, 9.22072083e-02f, -2.14188583e-02f, 1.09390974e-01f, 7.92355314e-02f, -2.54145302e-02f,
  1.80130359e-02f, -1.48922861e-01f, 1.16945781e-01f, -9.55624040e-04f, -4.32145111e-02f, 5.48415370e-02f, 5.04971109e-02f, -3.26543488e-02f, -3.47833522e-02f, -7.72372633e-02f,
  -1.35823041e-01f, 8.57321098e-02f, -1.64455205e-01f, 1.87246725e-01f, 6.20359965e-02f, 1.97201073e-01f, 6.42385781e-02f, 9.68469828e-02f, -6.91235811e-02f, -3.13254446e-03f,
  -2.02670261e-01f, -2.13085879e-02f, -3.30107771e-02f, 2.95058708e-03f, 2.63950147e-04f, 6.67721033e-02f, 1.72752813e-01f, -2.08405867e-01f, 1.46567216e-03f, 1.80422127e-01f,
  -9.51385964e-03f, 5.24595864e-02f, -1.16274692e-01f, 9.53968614e-03f, 2.49217786e-02f, 1.10138975e-01f, 9.46382061e-02f, 1.76203132e-01f, 2.30453927e-02f, -6.35188445e-03f,
  1.24026790e-01f, 1.69983774e-01f, 2.95682289e-02f, -5.78805022e-02f, -9.65732895e-03f, -4.98131216e-02f, 3.45732123e-02f, 2.74306871e-02f, 4.67119515e-02f, -1.03495665e-01f,
  -1.27242193e-01f, 4.14718390e-02f, -1.62941907e-02f, -3.60156223e-02f, 2.74754968e-02f, -1.08109444e-01f, -1.21403582e-01f, 9.28318501e-02f, -2.19849348e-02f, -2.96271741e-02f,
  -6.57265633e-02f, -5.65327853e-02f, 4.20995168e-02f, 5.57628945e-02f, 6.71329722e-02f, 7.91002288e-02f, 1.26834642e-02f, 6.16274364e-02f, -6.76953346e-02f, -1.18515491e-01f,
  -9.53291059e-02f, 1.88775938e-02f, -7.61533331e-04f, -8.90314300e-03f, -7.57511333e-02f, 1.27516925e-01f, -5.26817366e-02f, -8.30149557e-03f, -7.88920596e-02f, 1.04749352e-01f,
  5.03531247e-02f, 6.65801466e-02f, 9.29476321e-02f, -1.10313088e-01f, -1.21393777e-01f, 1.08675592e-01f, 1.19488351e-01f, -5.31556010e-02f, -2.59854328e-02f, -7.88662657e-02f,
  4.59910817e-02f, 1.01407200e-01f, -1.49153825e-02f, -7.48864859e-02f, -2.42825574e-03f, -6.73980564e-02f, -4.81462516e-02f, -5.57367168e-02f, 5.47423661e-02f, -6.98204432e-03f,
  1.20484848e-02f, -2.83307973e-02f, 1.22576229e-01f, -5.50937727e-02f, 9.02504846e-02f, -3.27284746e-02f, 1.45921912e-02f, -9.10546109e-02f, 7.59231374e-02f, -8.20541233e-02f,
  -3.33738588e-02f, 2.66093425e-02f, -1.73424985e-02f, 1.60002947e-01f, -1.13138020e-01f, -6.72952905e-02f, -5.28803170e-02f, -1.18272223e-01f, -4.44281884e-02f, -7.69850686e-02f,
  9.26815793e-02f, -1.75515204e-04f, 9.60078910e-02f, 1.39742838e-02f, -1.18656732e-01f, -7.90717974e-02f, 6.47183657e-02f, -7.60612488e-02f, -8.64508674e-02f, 9.79045555e-02f,
  -2.72136871e-02f, -1.16219312e-01f, -4.87162583e-02f, -3.93275619e-02f, -4.58303690e-02f, -4.43233214e-02f, 9.76537913e-02f, -1.07283212e-01f, 1.17525592e-01f, -1.32979294e-02f,
  5.69701269e-02f, 7.91645721e-02f, -1.18489683e-01f, -7.56035792e-03f, 1.43962353e-02f, -2.30135210e-02f, -8.66043642e-02f, 4.24696170e-02f, -1.03391439e-01f, -5.76862460e-03f,
  -2.74436101e-02f, -2.10131351e-02f, 7.94786140e-02f, -4.03678790e-02f, -4.55293134e-02f, 8.08487162e-02f, 9.18780337e-04f, 1.11260019e-01f, 1.45529015e-02f, -1.77576337e-02f,
  -3.93957272e-02f, -1.83985177e-02f, 6.91512506e-03f, -7.21977502e-02f, 4.98041697e-03f, -1.04460455e-01f, -1.00028500e-01f, 3.65530737e-02f, 3.37833762e-02f, 6.85189739e-02f,
  -1.17263094e-01f, -2.40689591e-02f, -7.73302838e-02f, 9.72695425e-02f, -1.03373230e-01f, 1.05076674e-02f, 3.68528552e-02f, -1.00212164e-01f, -7.88089857e-02f, -1.43101932e-02f,
  -3.85528505e-02f, -9.02638398e-03f, 1.14267483e-01f, 8.70650113e-02f, 1.56412289e-01f, 7.12701529e-02f, 2.28738133e-02f, 3.93206514e-02f, 1.51075289e-01f, 1.70693733e-02f,
  8.82225335e-02f, 3.56735140e-02f, 1.90237388e-01f, 1.40290394e-01f, 1.25846162e-01f, 1.81529760e-01f, 1.51273012e-01f, 7.45115578e-02f, 7.57114068e-02f, 1.35010421e-01f,
  1.21652067e-01f, 7.12569356e-02f, 4.89965044e-02f, -1.78808585e-01f, 6.28555268e-02f, -1.97022200e-01f, -1.81909360e-03f, -5.27212545e-02f, 6.92558810e-02f, 2.12613083e-02f,
  6.46119937e-02f, -2.68176217e-02f, 1.49048522e-01f, 1.13904394e-01f, -3.35803553e-02f, -1.52532652e-01f, 1.09600149e-01f, -4.13049459e-02f, 1.22934498e-01f, 2.13442653e-01f,
  1.59345210e-01f, -2.84780949e-01f, 2.41061281e-02f, 1.21402204e-01f, 2.56255537e-01f, 1.40917763e-01f, -2.65311152e-02f, -6.86760843e-02f, 4.86862063e-02f, -1.04918920e-01f,
  1.08409502e-01f, 3.09643149e-01f, -3.35004367e-02f, 6.59873113e-02f, 1.04449711e-04f, -2.92496774e-02f, -6.12794384e-02f, -3.46556492e-02f, 1.86866477e-01f, -1.32649809e-01f,
  4.74314615e-02f, -1.26279015e-02f, -1.07550345e-01f, 1.33054424e-02f, -1.33302703e-01f, -1.59669921e-01f, 9.83910859e-02f, 6.42502755e-02f, 1.45362839e-02f, -4.34573367e-02f,
  1.40111566e-01f, -1.14587188e-01f, -6.44892454e-02f, 6.98667392e-03f, -1.38835832e-01f, -1.41683873e-02f, -3.61966644e-03f, 2.08594725e-02f, 1.81655735e-02f, 2.51147225e-02f,
  6.91028610e-02f, -8.40246454e-02f, -4.96900566e-02f, -7.29264840e-02f, 8.71950909e-02f, 3.94783355e-02f, -1.68648183e-01f, -6.25895634e-02f, -9.02998000e-02f, -4.92072850e-02f,
  1.43268481e-01f, -1.40258491e-01f, -9.91461277e-02f, 2.76396628e-02f, -8.46938491e-02f, -1.50540233e-01f, 5.66320792e-02f, 6.57619163e-03f, 5.90595677e-02f, 8.21408853e-02f,
  2.30423976e-02f, -2.43582902e-03f, 8.60923752e-02f, 1.50662720e-01f, -1.11659214e-01f, 8.41356367e-02f, 2.01350093e-01f, 3.79101783e-02f, -1.02471128e-01f, 1.34279773e-01f,
  9.52204019e-02f, 4.58490662e-02f, 5.72149977e-02f, 4.84786592e-02f, 1.20248320e-02f, 1.32479548e-01f, 1.37610167e-01f, 1.63243994e-01f, -1.08257696e-01f, 1.18032672e-01f,
  2.63080299e-01f, -1.25625774e-01f, -1.19195748e-02f, -3.66709605e-02f, 5.18145077e-02f, 2.51061231e-01f, 9.18328166e-02f, 3.87265272e-02f, 3.42472047e-02f, -1.17994577e-01f,
  9.89383161e-02f, -9.98156592e-02f, 8.10210332e-02f, 1.09490424e-01f, 3.97567414e-02f, 1.58735916e-01f, 4.48042564e-02f, 8.22920799e-02f, -3.34501974e-02f, 1.22087933e-01f,
  -8.02011788e-02f, 5.30805066e-03f, 1.51043221e-01f, -8.49857777e-02f, 4.80903611e-02f, 1.10076532e-01f, -1.50603112e-02f, -1.61617622e-02f, 1.01717308e-01f, 9.03312489e-02f,
  1.87968299e-01f, -7.97931477e-02f, 6.57734945e-02f, -5.83482608e-02f, -1.55398339e-01f, -3.18663046e-02f, 6.67172149e-02f, -7.70984888e-02f, 1.02094367e-01f, 5.74788265e-02f,
  4.85820472e-02f, -1.04658619e-01f, -2.17659827e-02f, -8.95309076e-02f, 1.60748228e-01f, -1.09041229e-01f, -7.69157056e-03f, -1.11613153e-02f, 9.23159905e-03f, 4.13706861e-02f,
  -1.28895000e-01f, -1.27180338e-01f, 1.15237562e-02f, 3.32994014e-02f, -2.42835209e-02f, -5.98564781e-02f, -4.27781790e-02f, 8.51272792e-02f, -8.56711864e-02f, -1.00681007e-01f,
  7.36594107e-03f, 1.15533238e-02f, 2.14647735e-03f, -8.56099203e-02f, -1.59694776e-02f, -3.48967277e-02f, -1.09290548e-01f, 8.02362934e-02f, 6.42009452e-02f, 3.58951688e-02f,
  -4.71013747e-02f, 5.50127923e-02f, -6.57730252e-02f, 1.02335826e-01f, -9.26324874e-02f, 1.35370508e-01f, -9.89999622e-02f, -7.53996894e-02f, 1.23167023e-01f, -5.72765432e-02f,
  -1.13382563e-01f, -2.45406386e-02f, -1.24562867e-02f, -8.92236978e-02f, -1.17932528e-01f, -9.91635695e-02f, -3.53794061e-02f, 3.67471427e-02f, 7.06302449e-02f, -6.96835294e-02f,
  -1.74052101e-02f, 8.61791819e-02f, -5.96637912e-02f, 8.65832251e-03f, -1.06668390e-01f, -1.13778889e-01f, 3.61296497e-02f, 1.18223494e-02f, -3.06887608e-02f, 1.11554854e-01f,
  1.02674449e-02f, -4.64349277e-02f, -9.47736427e-02f, -5.49422950e-02f, 9.36932676e-03f, 1.46360118e-02f, -1.10889517e-01f, 5.54623408e-03f, 1.09518304e-01f, 5.49399145e-02f,
  4.60747443e-02f, -1.11946076e-01f, -4.88741696e-02f, 4.33846116e-02f, 8.31042454e-02f, -6.43878728e-02f, -1.63758174e-02f, -1.02922752e-01f, -6.25954494e-02f, 7.02064335e-02f,
  -8.15969184e-02f, 1.12737685e-01f, -1.05126403e-01f, -1.12210788e-01f, 6.67233691e-02f, -5.61721921e-02f, -1.06059633e-01f, -1.24154866e-01f, -1.19462550e-01f, 6.03691302e-02f,
  -1.09308571e-01f, 7.67039657e-02f, -1.07952550e-01f, 2.93265469e-02f, 3.53607498e-02f, 9.03799087e-02f, -6.90130368e-02f, 6.82550995e-03f, 4.33285274e-02f, 7.42037594e-02f,
  -4.46115248e-02f, 1.29801571e-01f, -9.47737768e-02f, 3.88430208e-02f, -7.63155520e-02f, 3.97158638e-02f, 1.57291308e-01f, 7.56626353e-02f, 7.03943893e-02f, -2.90125832e-02f,
  5.24660088e-02f, 8.35608467e-02f, -1.53086931e-02f, 4.72790413e-02f, -2.40938570e-02f, 3.74587849e-02f, 8.84344131e-02f, -5.77960163e-02f, -2.13696331e-01f, 9.55711231e-02f,
  -1.74077094e-01f, -2.25682687e-02f, -1.82908699e-01f, 8.24091360e-02f, -2.41121254e-03f, 2.43561372e-01f, -4.14625602e-03f, 8.33379924e-02f, -1.65412337e-01f, -2.92998040e-03f,
  1.09285908e-02f, 1.32370830e-01f, 1.89833883e-02f, -7.97598213e-02f, 9.39377919e-02f, -1.99505657e-01f, -7.41341105e-03f, 1.67980492e-01f, -4.09825034e-02f, -5.60540333e-02f,
  1.24883048e-01f, 1.08769424e-01f, 2.01252460e-01f, -3.84038649e-02f, 1.04495464e-03f, 2.78003305e-01f, -5.89446835e-02f, -1.01235531e-01f, 2.30307374e-02f, 1.46703199e-01f,
  2.15695743e-02f, 1.64048392e-02f, 4.14093360e-02f, 1.61964614e-02f, -6.99502230e-02f, -4.96784709e-02f, 9.47092548e-02f, -1.09999925e-01f, 5.75995967e-02f, 1.47590965e-01f,
  8.48790556e-02f, 6.93053156e-02f, 8.81605372e-02f, -1.40025411e-02f, 1.43727183e-01f, 1.59795836e-01f, 1.03065699e-01f, 1.58264637e-01f, 1.85639113e-01f, -2.31825281e-02f,
  -2.24024802e-02f, 1.42292455e-01f, 1.22564837e-01f, 8.86846408e-02f, 4.63126898e-02f, 6.77972334e-03f, -1.59909260e-02f, 1.25814125e-01f, 1.96403772e-01f, 9.54860598e-02f,
  -5.69036277e-03f, 1.05973892e-01f, 1.74426839e-01f, -9.59664304e-03f, -1.25700638e-01f, -1.60529554e-01f, 7.91041926e-02f, 1.77434478e-02f, 2.46559829e-01f, -2.90645510e-01f,
  -1.55193880e-01f, -3.54609340e-02f, 1.20296210e-01f, 8.08549970e-02f, -1.05957307e-01f, 1.11760702e-02f, 1.25197187e-01f, 1.06927969e-01f, 6.28258362e-02f, 7.49380961e-02f,
  6.69183908e-03f, -1.45584881e-01f, -3.67224626e-02f, 1.64383486e-01f, 6.87955618e-02f, 2.13201821e-01f, 1.07531548e-01f, -4.83689383e-02f, -3.17547470e-03f, -1.07533582e-01f,
  8.14335346e-02f, 1.04840957e-01f, -6.72365129e-02f, -2.02154487e-01f, -5.33019900e-02f, -4.09739986e-02f, -1.32176518e-01f, 1.28222123e-01f, 1.68375447e-01f, 1.73148066e-01f,
  -1.16151735e-01f, -1.08360231e-01f, -4.20750268e-02f, -2.45134812e-02f, -8.85245353e-02f, -6.79766163e-02f, -6.27027601e-02f, 3.34768221e-02f, -1.26805678e-01f, 6.85565919e-02f,
  6.05614902e-03f, -4.06518392e-02f, -1.02286339e-01f, -4.52084169e-02f, 1.64224342e-01f, 8.26068893e-02f, -3.10380682e-02f, 1.39658928e-01f, -2.47091930e-02f, 1.33121595e-01f,
  3.03400550e-02f, 1.29386380e-01f, -6.20466098e-02f, -7.83221796e-03f, 8.25090781e-02f, 2.21600179e-02f, -7.72249922e-02f, -3.93716246e-02f, -1.33380949e-01f, 2.63260156e-02f,
  8.10606554e-02f, -1.85112596e-01f, -1.59482677e-02f, 1.58217490e-01f, 5.78362383e-02f, -1.28739044e-01f, -9.02200863e-02f, 1.32624924e-01f, 7.30549395e-02f, -1.36401132e-01f,
  1.16036668e-01f, -1.31800383e-01f, -5.04333228e-02f, -3.36611532e-02f, 1.83713704e-01f, -1.48586556e-01f, 1.07345842e-01f, 7.48988464e-02f, 2.48890340e-01f, -2.85008121e-02f,
  2.30698794e-01f, 4.11497429e-03f, 5.16579449e-02f, -1.11041116e-02f, -5.14061972e-02f, 7.78383110e-03f, 9.42112133e-02f, 1.23043351e-01f, -4.94898595e-02f, 1.32992893e-01f,
  3.34561318e-02f, 9.01146382e-02f, -3.43537182e-02f, -1.12132564e-01f, -3.45808715e-02f, -1.04109317e-01f, -1.20184995e-01f, 7.63067752e-02f, -4.83934209e-02f, -6.62484616e-02f,
  3.30470875e-02f, 5.70651367e-02f, 6.58387244e-02f, -1.89651456e-02f, 3.00887804e-02f, 1.12377003e-01f, 1.95949469e-02f, -5.46486303e-02f, 7.16745704e-02f, -9.54157189e-02f,
  -1.05768211e-01f, -1.06064463e-02f, 1.19578680e-02f, 1.76799577e-02f, 9.47974157e-03f, -2.02802569e-02f, -5.10268770e-02f, -1.28359914e-01f, -3.32907178e-02f, 1.80985685e-02f,
  7.44002387e-02f, 6.69328049e-02f, -3.53101455e-02f, 6.16932660e-02f, 8.81821588e-02f, -5.41309901e-02f, -5.04770093e-02f, 7.81292394e-02f, 7.05366284e-02f, -1.11215673e-01f,
  8.26058611e-02f, -2.85187066e-02f, 4.47939988e-03f, 6.75766319e-02f, 4.02766280e-02f, -3.48469950e-02f, 1.11446314e-01f, 3.16129401e-02f, 1.06561035e-01f, -5.55944405e-02f,
  1.88918728e-02f, -1.11406274e-01f, 5.63680604e-02f, -7.77310804e-02f, 6.23495728e-02f, 6.94659799e-02f, 1.11899935e-01f, -8.12668167e-03f, -3.97981368e-02f, 4.49200626e-03f,
  -1.03512615e-01f, -8.56283233e-02f, -1.21958256e-01f, 8.23944360e-02f, 6.36780635e-02f, -2.91758459e-02f, 1.05273992e-01f, 2.81910803e-02f, 7.56170377e-02f, -1.72819744e-03f,
  1.06200045e-02f, -6.38162419e-02f, -5.41950502e-02f, -1.26994886e-02f, 7.57763088e-02f, 1.27653377e-02f, -3.42677422e-02f, 4.53434177e-02f, -7.44875073e-02f, 8.51968303e-02f,
  -1.15631735e-02f, -7.97669142e-02f, 7.95061067e-02f, -1.77523643e-02f, -4.55063432e-02f, -1.20013125e-01f, -8.08243528e-02f, -1.14431158e-01f, -1.08973682e-01f, -1.22292534e-01f,
  7.64712244e-02f, 1.04708567e-01f, 3.84022444e-02f, 9.13181826e-02f, 7.00558769e-03f, 7.38102123e-02f, 1.06442951e-01f, 4.78789657e-02f, -6.95656613e-02f, -5.30363582e-02f,
  4.16828729e-02f, 3.28164697e-02f, 5.51769696e-02f, 8.08512717e-02f, -6.47124127e-02f, -1.34440260e-02f, -1.05896227e-01f, -8.97901580e-02f, 1.20306723e-01f, -8.15120712e-02f,
  1.20017335e-01f, 3.84806260e-03f, -2.34021898e-02f, 8.52086693e-02f, -1.83926709e-02f, -8.70806575e-02f, -1.02852568e-01f, 4.62923236e-02f, 6.68617636e-02f, 1.21417105e-01f,
  1.09164983e-01f, -3.70192970e-03f, -2.09782813e-02f, 1.20694861e-02f, 4.93458882e-02f, -1.11743897e-01f, 1.06510527e-01f, -2.28443593e-02f, -1.10151611e-01f, -3.22788693e-02f,
  -9.21963900e-03f, 7.42518380e-02f, -1.16609603e-01f, -1.76091995e-02f, 1.05040222e-01f, 3.98825593e-02f, 7.02705607e-02f, -3.30791227e-04f, -9.18991747e-04f, 6.11695647e-02f,
  4.06779163e-02f, -6.26687706e-02f, -8.67838785e-02f, -2.77881362e-02f, 8.77441913e-02f, 3.80103998e-02f, 2.54543852e-02f, -9.97636747e-03f, 1.44278556e-02f, -3.83234769e-02f,
  6.86543062e-02f, -1.17915876e-01f, -1.04592614e-01f, -1.22638987e-02f, 7.27875754e-02f, -1.04513057e-01f, 2.88638845e-02f, -9.46762487e-02f, -1.47610856e-02f, 1.39008567e-01f,
  -4.52682748e-03f, 9.48612243e-02f, 3.77962850e-02f, 1.11891083e-01f, 9.17784348e-02f, -3.83010432e-02f, -1.18524909e-01f, 3.64855081e-02f, -5.24556264e-02f, -9.20156986e-02f,
  -2.81161014e-02f, 4.54158336e-02f, -1.09278262e-01f, 1.01212393e-02f, 7.55622387e-02f, -1.09161839e-01f, -5.55005558e-02f, 5.21298274e-02f, -6.32933676e-02f, 1.03140660e-01f,
  -1.72106810e-02f, 3.48631591e-02f, 6.55257255e-02f, -9.89076719e-02f, 4.34657186e-02f, 5.80746084e-02f, -1.22872546e-01f, 1.38287693e-01f, -7.18105063e-02f, 7.23115215e-03f,
  -7.92624727e-02f, 4.93341796e-02f, 3.92124131e-02f, -1.26731172e-01f, 6.21935315e-02f, -9.50807035e-02f, 5.78636900e-02f, 8.51772502e-02f, 1.02186523e-01f, 6.42686635e-02f,
  5.90915643e-02f, 1.38743268e-02f, -3.29319201e-02f, -6.59851357e-03f, 9.06914994e-02f, 7.95098543e-02f, 1.96599469e-01f, -8.12722296e-02f, 6.35846406e-02f, -5.32373600e-02f,
  2.28361115e-02f, 1.79191485e-01f, 3.70367579e-02f, 2.28099599e-01f, -1.09984562e-01f, 2.05387577e-01f, 1.81357518e-01f, -6.41364753e-02f, 2.28150189e-01f, 6.06680363e-02f,
  1.77690133e-01f, 1.64722651e-01f, 2.34672979e-01f, 1.07824117e-01f, 1.34255245e-01f, -4.35114279e-03f, 6.90512210e-02f, 2.25956723e-01f, -1.10708289e-02f, -1.20788716e-01f,
  7.31492788e-02f, 8.66734013e-02f, 1.50327638e-01f, -4.31815051e-02f, -1.37265801e-01f, -3.01753804e-02f, -1.40612230e-01f, 8.97961110e-02f, 3.77092957e-02f, -3.68667836e-03f,
  -1.49556383e-01f, 1.04527995e-01f, -1.57474607e-01f, -9.04227495e-02f, -6.11750111e-02f, 3.52340415e-02f, -7.01286495e-02f, 7.27147833e-02f, -2.38283407e-02f, 1.07401073e-01f,
  2.07113046e-02f, 6.77200109e-02f, 3.10060866e-02f, -2.13584602e-02f, -1.04034446e-01f, 1.64800528e-02f, -1.13505729e-01f, 7.64975026e-02f, 1.67806312e-01f, 1.61872059e-01f,
  -9.40863490e-02f, -5.90422042e-02f, 1.89602032e-01f, -1.31824151e-01f, 1.11283902e-02f, -3.02468799e-02f, 4.23853025e-02f, 4.93931444e-03f, 6.62486255e-02f, 1.30987242e-01f,
  3.50300781e-02f, 1.03041656e-01f, -5.48344664e-03f, -5.55030107e-02f, -8.18556026e-02f, 4.11876813e-02f, -6.67918995e-02f, 1.68483749e-01f, 9.46474299e-02f, 1.82312489e-01f,
  -3.45582440e-02f, 4.94115315e-02f, 7.26711452e-02f, 2.53821779e-02f, 8.97963047e-02f, 9.46054682e-02f, -1.06922239e-01f, -3.67003269e-02f, 1.17279805e-01f, 9.46565941e-02f,
  1.40900854e-02f, 5.77391163e-02f, -1.17064290e-01f, -3.88880745e-02f, -9.33046732e-03f, 8.08393359e-02f, 9.67389941e-02f, 4.52705063e-02f, 4.85878959e-02f, -9.44571383e-03f,
  -1.69640437e-01f, 9.18017179e-02f, -6.82365298e-02f, -4.16759066e-02f, -9.04310644e-02f, 4.37364206e-02f, -1.13925479e-01f, -9.54680517e-02f, 5.82032911e-02f, 2.94968486e-02f,
  -9.67449993e-02f, -1.12619832e-01f, 9.06663910e-02f, 1.62101194e-01f, -5.63374497e-02f, -6.99197873e-02f, -8.80924426e-03f, -2.90546212e-02f, 1.28729548e-03f, -3.78883258e-02f,
  -4.91535142e-02f, -2.95684151e-02f, 9.71286818e-02f, 1.41845122e-01f, -5.87973483e-02f, -3.26375216e-02f, 2.32421547e-01f, -8.38871375e-02f, -8.60009640e-02f, 4.81894389e-02f,
  -1.46416239e-02f, -6.17777966e-02f, 1.57628834e-01f, -3.46210599e-02f, -9.30225030e-02f, 1.63026452e-01f, -7.17359930e-02f, -6.01048879e-02f, 1.81465954e-01f, 5.25192805e-02f,
  1.35130063e-01f, -1.16206333e-01f, 1.61740750e-01f, 1.09850891e-01f, -3.17952335e-02f, 1.02487825e-01f, 1.45428821e-01f, 1.47179917e-01f, 1.16761841e-01f, 1.21944435e-01f,
  -4.59106490e-02f, 4.42514494e-02f, -1.06082655e-01f, 2.48256817e-01f, -1.12949744e-01f, 6.38760030e-02f, -2.06419870e-01f, 2.81035960e-01f, -1.70495640e-02f, 1.41564384e-01f,
  -2.47392714e-01f, -2.52790064e-01f, -4.00404856e-02f, 5.01299053e-02f, 7.21285865e-02f, 3.36812660e-02f, 9.29307938e-02f, -2.69712120e-01f, 1.06412575e-01f, 2.25594595e-01f,
  5.69719598e-02f, -1.20742366e-01f, -9.27098021e-02f, 1.43489569e-01f, 9.89032686e-02f, -1.08474836e-01f, 3.17629613e-02f, 5.99786222e-01f, 1.12844907e-01f, -2.62523264e-01f,
  2.49075517e-01f, 2.58338869e-01f, 1.86151043e-02f, -6.72878698e-02f, -1.61632165e-01f, 4.47081625e-02f, -1.76661208e-01f, 1.80627421e-01f, 1.39427155e-01f, -6.28140643e-02f,
  1.72577813e-01f, 1.26927301e-01f, -8.00309852e-02f, 2.73095131e-01f, -5.58004342e-03f, 1.46745026e-01f, 8.99491459e-02f, 7.69024715e-02f, 1.03556551e-02f, 6.84504136e-02f,
  1.33657008e-01f, 1.62259832e-01f, -1.46214413e-02f, 1.12236761e-01f, -9.36094075e-02f, -6.72275797e-02f, 5.19449748e-02f, 1.41650846e-03f, 4.75099348e-02f, 1.48665756e-01f,
  -1.60305798e-02f, 1.16423808e-01f, 1.15079619e-01f, -1.26675814e-01f, -5.90888448e-02f, -1.96390226e-02f, -2.71343529e-01f, 2.05071345e-01f, -2.68412620e-01f, -3.18629593e-02f,
  1.30335763e-01f, -1.67265013e-01f, -1.33745924e-01f, 4.19105440e-02f, -3.14930007e-02f, -1.85293183e-01f, 2.47707348e-02f, -7.40933120e-02f, 2.34827355e-01f, -2.01256022e-01f,
  -1.42086782e-02f, -1.56879410e-01f, 2.06382841e-01f, 1.77755237e-01f, -3.68266329e-02f, -8.73132981e-03f, 1.55504972e-01f, 1.25046328e-01f, 3.28495115e-01f, 3.90343852e-02f,
  -7.97827542e-03f, 3.37638915e-01f, -1.18381061e-01f, 1.12210535e-01f, -1.10435918e-01f, -3.89723592e-02f, 1.91514134e-01f, 8.55225772e-02f, -8.64176899e-02f, 1.33237801e-02f,
  -2.17200533e-01f, -7.33077526e-02f, 6.27285894e-03f, -9.49644390e-03f, -1.46383867e-01f, -1.04244493e-01f, 5.70080709e-03f, 8.65310580e-02f, -4.02396955e-02f, 1.22504987e-01f,
  -3.00389770e-02f, 9.27433968e-02f, -3.98760326e-02f, 1.91524133e-01f, 5.23623191e-02f, 9.68779251e-02f, 1.24043012e-02f, 1.45916278e-02f, 6.84430227e-02f, -3.77869233e-03f,
  -2.13758014e-02f, -2.78970841e-02f, 1.52757525e-01f, 3.34213674e-02f, -5.31673357e-02f, 1.35752121e-02f, 1.93046793e-01f, -4.32337075e-02f, -2.09417641e-01f, 2.25003827e-02f,
  -1.92402557e-01f, -4.51544598e-02f, -2.26989631e-02f, -1.12818748e-01f, -1.08385518e-01f, -6.51206821e-02f, -2.85739452e-01f, -3.20334077e-01f, -1.29634976e-01f, -1.42855689e-01f,
  1.07829399e-01f, -2.03628335e-02f, 2.14264661e-01f, 1.18366577e-01f, 1.35830164e-01f, -7.19130263e-02f, 2.60018289e-01f, 9.62821841e-02f, 1.69305727e-01f, -1.11030238e-02f,
  -3.42000760e-02f, 3.14946681e-01f, 2.19355032e-01f, -2.18954496e-02f, -1.75939247e-01f, 2.52153516e-01f, -6.87700287e-02f, 1.96031004e-01f, 1.70883071e-02f, 1.14429500e-02f,
  -9.03857052e-02f, 1.41082807e-02f, -3.99416909e-02f, -7.08670914e-02f, -3.41848582e-02f, 1.91866815e-01f, 1.90389305e-01f, -2.15093464e-01f, -2.11379841e-01f, -6.96204230e-02f,
  9.42952186e-02f, -1.26492590e-01f, 3.72271389e-02f, -1.10853903e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  -3.59197408e-02f, -5.28727621e-02f, 5.29620163e-02f, -1.76240634e-02f, -5.49156331e-02f, -3.11894529e-02f, -8.51543099e-02f, 3.00412020e-03f, 2.96792388e-02f, -3.55921127e-03f,
  3.27764265e-02f, 9.97193158e-03f, 1.30126774e-01f, -6.05866574e-02f, -3.11030932e-02f, -9.14418995e-02f, 9.18685868e-02f, 1.21107198e-01f, -1.05750717e-01f, -1.13901190e-01f,
  -6.76142424e-02f, 1.04071960e-01f, 1.00528091e-01f, 1.06898218e-01f, 1.07864402e-01f, 7.37854317e-02f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  1.55002554e-03f, 2.70185228e-02f, -1.20196640e-02f, 1.25486702e-01f, 1.26264547e-03f, 1.48852274e-01f, 1.50201201e-01f, 1.04243882e-01f, 5.55327954e-03f, -2.27723196e-02f,
  -6.49357066e-02f, -1.92398801e-02f, 9.74280909e-02f, 7.06797242e-02f, -4.13333066e-02f, -2.34672194e-03f, -5.70846908e-02f, -6.86289975e-03f, 1.30772948e-01f, -1.48030873e-02f,
  -4.22021262e-02f, 1.09389469e-01f, 9.97785851e-02f, 8.91935825e-02f, -1.84852630e-01f, -2.03861788e-01f, -2.94036847e-02f, -7.35921934e-02f, -3.66380438e-02f, -8.88148174e-02f,
  7.00512752e-02f, 1.00763924e-01f, 2.75241546e-02f, -3.65069602e-03f, -1.82802491e-02f, -1.65750146e-01f, 7.07765892e-02f, -7.91334957e-02f, -6.66695163e-02f, -1.15074657e-01f,
  -1.74271747e-01f, -7.71477297e-02f, -7.41240382e-02f, -2.79451292e-02f, 3.49527113e-02f, 1.20067574e-01f, -2.23079816e-01f, -6.05973415e-02f, -3.63711687e-03f, 1.29621208e-01f,
  7.61416480e-02f, 8.96627307e-02f, -9.56507102e-02f, -3.98634858e-02f, -1.49484873e-01f, 7.04710260e-02f, 3.87389958e-02f, -1.54707581e-02f, 7.29487762e-02f, -1.75160080e-01f,
  6.74367920e-02f, -1.05634630e-01f, -5.74972555e-02f, -1.24475956e-01f, 1.55087709e-01f, -5.09663373e-02f, -3.66707817e-02f, 3.93267646e-02f, -4.14845534e-02f, 1.12184733e-01f,
  9.73303020e-02f, 5.11769913e-02f, 3.12250908e-02f, 8.68498683e-02f, 4.39014137e-02f, 5.05375070e-03f, -7.72736818e-02f, -9.84244887e-03f, 6.41521392e-03f, -1.32085130e-01f,
  5.82194477e-02f, -3.36782709e-02f, -1.90568149e-01f, 2.31725663e-01f, 8.80694464e-02f, 1.24512240e-01f, -1.48279235e-01f, 9.48771164e-02f, -1.84688240e-01f, -2.58816242e-01f,
  -7.35156462e-02f, -7.50472397e-02f, 1.83381394e-01f, -1.18829511e-01f, 2.09488392e-01f, 4.50812653e-03f, -2.49816895e-01f, 3.10639236e-02f, -9.22367349e-02f, -1.93270415e-01f,
  2.71217912e-01f, 2.25585401e-01f, 1.41241193e-01f, 1.60495669e-01f, -9.61011369e-03f, 3.82024273e-02f, 6.67055622e-02f, -8.63959827e-03f, 5.34408391e-02f, -2.93192100e-02f,
  -2.13433206e-01f, 1.28575921e-01f, 3.13119255e-02f, 9.79586989e-02f, 1.70460120e-02f, -5.94873726e-02f, 4.79214787e-02f, -2.23874003e-01f, 1.69433251e-01f, 4.23500650e-02f,
  -5.62305786e-02f, 7.04451427e-02f, -4.42685746e-02f, 1.15439445e-01f, -7.68472627e-02f, -3.52852464e-01f, -3.36732008e-02f, 9.21841711e-03f, -1.84982747e-01f, -1.54628128e-01f,
  -1.34819090e-01f, -1.12106100e-01f, -1.06366642e-01f, 6.19305521e-02f, -8.70835632e-02f, -2.28301603e-02f, -1.87262952e-01f, -2.38635585e-01f, -6.31888583e-02f, -1.70855224e-01f,
  5.25882281e-02f, -1.37869179e-01f, 4.37558210e-03f, 3.87288183e-02f, -1.05588488e-01f, -7.71056861e-02f, 3.19016948e-02f, 9.99818905e-04f, 1.46953195e-01f, 6.35786057e-02f,
  2.09225222e-01f, -2.25302652e-01f, -2.30318941e-02f, -3.03551648e-02f, 1.31759152e-01f, 2.20622033e-01f, -3.53807569e-01f, 6.18678443e-02f, -3.14473249e-02f, -3.77853401e-02f,
  1.34502217e-01f, -1.64073914e-01f, 2.75011182e-01f, -8.23515281e-02f, -4.35776711e-02f, -1.91863790e-01f, 1.94922760e-01f, -1.57768175e-01f, -2.32881662e-02f, 6.90506697e-02f,
  1.29080471e-02f, 2.92427111e-02f, 1.13174051e-01f, 8.77774581e-02f, 1.46514475e-01f, 6.32662326e-02f, 9.08579230e-02f, -1.25663012e-01f, -1.51747167e-01f, 1.26175478e-01f,
  1.03257336e-01f, -9.67954025e-02f, -1.73672065e-01f, -1.72185212e-01f, 6.41823784e-02f, -5.55203594e-02f, -4.17085066e-02f, 9.00155604e-02f, 1.04996420e-01f, 1.51919544e-01f,
  -4.43544462e-02f, 9.75964740e-02f, 5.03143221e-02f, 1.22765377e-01f, -1.49216443e-01f, -6.49956390e-02f, 9.42408592e-02f, -4.87665087e-02f, -3.19616906e-02f, -3.46863531e-02f,
  -6.19721338e-02f, 2.78405070e-01f, -1.79537125e-02f, -6.08529560e-02f, -3.24638076e-02f, -1.16272576e-01f, 2.24928483e-02f, 1.04805581e-01f, -9.59938318e-02f, 6.38050884e-02f,
  -2.01002702e-01f, 1.55596763e-01f, -6.41568005e-02f, 1.27611965e-01f, -1.80866808e-01f, 4.88412902e-02f, 9.32721514e-03f, -1.36363283e-01f, -4.59156670e-02f, -1.45382375e-01f,
  1.49159044e-01f, 3.20912190e-02f, 1.22987516e-01f, 5.41949309e-02f, -1.04102284e-01f, 9.97089036e-03f, -2.36050010e-01f, -1.36055708e-01f, -3.51015478e-02f, 3.70346271e-02f,
  1.60305444e-02f, 1.31037384e-01f, 1.29539639e-01f, -1.95420850e-02f, 2.08763853e-02f, -2.01388393e-02f, -8.26000571e-02f, 4.03112918e-02f, 7.91790709e-03f, 9.12873149e-02f,
  -1.37970848e-02f, 1.20506667e-01f, 5.27285933e-02f, 7.69026577e-02f, -1.62559282e-02f, -2.11065203e-01f, 2.49770224e-01f, -6.43941015e-02f, -6.59564361e-02f, -4.43050899e-02f,
  -1.18424602e-01f, 1.49095774e-01f, 9.20100734e-02f, -3.40297639e-01f, 1.52611611e-02f, -4.42480706e-02f, -1.22682109e-01f, 1.90923121e-02f, 1.20879725e-01f, 7.72125050e-02f,
  7.55346660e-03f, -8.53767395e-02f, -6.20451346e-02f, 9.48935896e-02f, 6.70541485e-04f, 1.26314219e-02f, -4.55521010e-02f, -1.49103135e-01f, -1.28333032e-01f, -1.61917269e-01f,
  8.43361914e-02f, 7.50686377e-02f, 3.56996208e-02f, -1.57795772e-02f, 5.50426804e-02f, -1.98500469e-01f, -1.17510349e-01f, 4.60043997e-02f, -7.95419887e-02f, -1.00066677e-01f,
  -1.93733480e-02f, 1.50342479e-01f, 1.08634606e-01f, -7.96776786e-02f, -2.57340282e-01f, 1.60581499e-01f, -1.23670682e-01f, 1.50288120e-01f, 6.69285059e-02f, 7.68169761e-02f,
  -5.42121120e-02f, 1.61894843e-01f, -3.01367015e-01f, -2.66693905e-02f, 2.72692263e-01f, -8.33127126e-02f, 2.38211844e-02f, 5.85152879e-02f, -6.79360181e-02f, 1.26628429e-01f,
  8.70107114e-02f, 8.05762112e-02f, -5.49864136e-02f, -1.00108944e-01f, -4.63044383e-02f, -2.36476853e-01f, -1.01348773e-01f, 6.16972372e-02f, -8.16265121e-02f, 5.01055941e-02f,
  -9.38565060e-02f, -5.43412715e-02f, 3.17746513e-02f, -7.54590854e-02f, -8.97259042e-02f, 2.51796812e-01f, 1.65157139e-01f, 2.45456159e-01f, -8.50755796e-02f, -9.96564403e-02f,
  -5.82794435e-02f, 5.83084300e-02f, -1.76492646e-01f, -8.26591179e-02f, 1.36244800e-02f, -1.84444651e-01f, -1.07712680e-02f, -5.36221676e-02f, -1.12730883e-01f, 3.71357836e-02f,
  2.65269987e-02f, 7.16895387e-02f, 5.89791238e-02f, 1.03182204e-01f, 1.88042715e-04f, -4.65080775e-02f, 2.55558677e-02f, -1.38604060e-01f, 1.80204570e-01f, -7.10811466e-02f,
  7.75967687e-02f, -1.84467688e-01f, 8.89936239e-02f, -6.38963357e-02f, 1.00077465e-01f, 2.27708191e-01f, 2.58001359e-03f, -7.99066722e-02f, -2.51387730e-02f, 1.24749146e-01f,
  -7.43677765e-02f, 2.00440567e-02f, 1.10356115e-01f, 8.14220384e-02f, -3.95491160e-02f, 3.22173387e-01f, -1.35205373e-01f, -2.51888514e-01f, -2.02066720e-01f, -4.03734716e-03f,
  -7.21365288e-02f, 1.13243517e-02f, -4.37649302e-02f, -1.12928964e-01f, 8.36735219e-02f, -1.14354528e-01f, 1.20409042e-01f, 7.68881813e-02f, 9.41417366e-02f, -1.89903587e-01f,
  -8.53857696e-02f, -2.30593719e-02f, 1.23059630e-01f, 1.25889868e-01f, -1.31104037e-01f, 1.37154132e-01f, -7.14832172e-02f, 8.16675350e-02f, -3.34616974e-02f, -8.67982507e-02f,
  7.19107762e-02f, 3.21867794e-01f, 1.93667084e-01f, -1.94781646e-01f, 1.37997186e-02f, -7.03852475e-02f, 8.95744339e-02f, 5.59581183e-02f, -6.16649874e-02f, 7.71140605e-02f,
  -5.02419546e-02f, 1.00080773e-01f, -3.97937708e-02f, 2.39712462e-01f, 1.01616241e-01f, 1.08853623e-01f, -1.64336294e-01f, 1.24384455e-01f, 3.44330110e-02f, -2.37611346e-02f,
  1.40350088e-01f, 2.17393637e-02f, 8.98086503e-02f, -2.85410464e-01f, -1.40601888e-01f, 2.58946806e-01f, 9.84091461e-02f, -1.14460237e-01f, 1.23336334e-02f, -2.13201821e-01f,
  4.57208566e-02f, -2.51222737e-02f, 7.40153762e-03f, 1.77088425e-01f, -1.50894657e-01f, 1.58347681e-01f, 9.98626128e-02f, 1.66977732e-03f, -1.88793436e-01f, 2.46111639e-02f,
  1.03202835e-01f, -3.09760552e-02f, 2.31015861e-01f, -5.24367169e-02f, -1.35142222e-01f, -7.08205700e-02f, -2.74346210e-02f, 3.87915224e-02f, -4.59549725e-02f, 5.23387790e-02f,
  -2.28239689e-02f, 2.25212146e-03f, -7.03830943e-02f, -3.21830399e-02f, 3.31099816e-02f, 6.62860498e-02f, -5.18147312e-02f, 7.13878646e-02f, -1.71384513e-01f, 1.31780475e-01f,
  -8.77564549e-02f, -1.02440298e-01f, 1.30698988e-02f, 4.46598977e-02f, 6.03117160e-02f, -5.86549602e-02f, -2.30504349e-01f, -2.60776192e-01f, -3.26823480e-02f, -1.37110308e-01f,
  -1.17609181e-01f, -1.59603357e-01f, -1.44637182e-01f, -6.51633888e-02f, -4.51855399e-02f, 4.58376743e-02f, -1.71282217e-01f, -1.01838276e-01f, 2.06090752e-02f, -2.41187084e-02f,
  -1.66286863e-02f, 1.51087316e-02f, -9.29414928e-02f, -5.74261621e-02f, 3.57889794e-02f, 2.41340790e-02f, 1.22937880e-01f, -5.69311269e-02f, 7.58408457e-02f, -6.04381002e-02f,
  -3.58404145e-02f, 3.84400226e-02f, -7.85833076e-02f, 2.13194251e-01f, 2.11237431e-01f, 4.20580991e-02f, -3.42490077e-01f, -5.83755709e-02f, -1.67897511e-02f, -2.30707288e-01f,
  1.71652347e-01f, -1.08401515e-01f, 3.34177315e-01f, 1.14325061e-01f, -1.17073752e-01f, -3.91439609e-02f, 5.96585423e-02f, -6.44060895e-02f, 6.79642633e-02f, -8.01427588e-02f,
  6.47775084e-02f, 2.32147425e-02f, 1.96644999e-02f, -1.54283062e-01f, 1.41209647e-01f, -1.06106184e-01f, 2.27949675e-02f, -3.45579058e-01f, -9.41841230e-02f, 1.01137862e-01f,
  5.73735461e-02f, 1.65813431e-01f, -2.16121122e-01f, -1.18562661e-01f, 1.10029176e-01f, -2.16117613e-02f, -1.08340383e-01f, -7.77291134e-02f, -4.22330983e-02f, 3.84105951e-01f,
  1.16507702e-01f, 2.43675858e-01f, 1.39470622e-01f, 6.84274957e-02f, -8.59272555e-02f, -1.69019718e-02f, -5.30050194e-04f, 1.47983208e-01f, -2.88871545e-02f, -1.18998036e-01f,
  6.58494234e-02f, -1.11029975e-01f, 1.88843966e-01f, -5.17969765e-02f, 1.28316119e-01f, -8.19879249e-02f, -5.60822189e-02f, 5.93320616e-02f, 6.25836775e-02f, 8.40545222e-02f,
  -1.59950536e-02f, 1.15577832e-01f, 1.72995210e-01f, -1.79471716e-01f, 3.88913741e-03f, 7.98965767e-02f, -2.00353831e-01f, 1.29055139e-02f, 7.01509714e-02f, 2.30692193e-01f,
  8.80431384e-02f, -1.92882597e-01f, 1.19281240e-01f, -2.44438276e-01f, 1.16994642e-01f, -1.98256761e-01f, 2.74099380e-01f, 5.61903492e-02f, -3.78670394e-02f, -1.21385999e-01f,
  -1.55033052e-01f, -1.01547740e-01f, 1.08613089e-01f, -7.25141913e-02f, -8.88555050e-02f, 3.50293368e-02f, -4.19927016e-02f, -8.83147642e-02f, -6.99581876e-02f, 2.84048226e-02f,
  -2.89128218e-02f, -1.43903747e-01f, 3.13934311e-02f, -1.54314265e-02f, -2.57916432e-02f, 1.87194362e-01f, -1.81235671e-01f, 1.56022936e-01f, -2.39006970e-02f, 1.26312584e-01f,
  -7.48867318e-02f, -2.65979320e-01f, -5.63397110e-02f, 1.08701691e-01f, 2.34492213e-01f, 2.66058058e-01f, 4.45131585e-02f, -7.63462344e-03f, -1.39163509e-01f, -1.69169195e-02f,
  -9.22986716e-02f, -6.02340838e-03f, 1.03792874e-02f, -7.84261078e-02f, -1.07883671e-02f, -2.34206408e-01f, 1.28230870e-01f, -1.46827027e-01f, 3.28371488e-03f, -4.73189214e-03f,
  -4.11356203e-02f, -1.06628634e-01f, -1.71409816e-01f, -1.02816790e-01f, -1.59406319e-01f, 4.69376072e-02f, 5.84779233e-02f, -1.87154278e-01f, -3.11424788e-02f, -1.38886683e-02f,
  -1.54810533e-01f, 3.03859301e-02f, 1.68367922e-01f, 1.92035377e-01f, -1.95024893e-01f, 7.05929995e-02f, 8.53387117e-02f, -2.51100600e-01f, 9.24799219e-03f, -1.76172495e-01f,
  1.09740622e-01f, -1.24467514e-01f, -1.60740510e-01f, -4.27513011e-02f, 5.02495058e-02f, -1.80868477e-01f, -2.29153614e-02f, -5.90054095e-02f, 1.04271896e-01f, 9.74593535e-02f,
  -6.44372031e-02f, -1.15980685e-01f, 9.52854455e-02f, 5.79144396e-02f, 2.30351277e-02f, -1.05717674e-01f, 1.84417695e-01f, 1.87193472e-02f, 7.70704523e-02f, -2.74195559e-02f,
  -9.35637876e-02f, -1.32156119e-01f, -1.10413820e-01f, -1.20480813e-01f, 3.65574844e-02f, -1.50136292e-01f, -1.10889539e-01f, 7.65750706e-02f, 1.67536154e-01f, 1.42221645e-01f,
  9.99247357e-02f, -5.34241609e-02f, -8.09609890e-02f, 1.12575054e-01f, -5.32801375e-02f, 1.44607767e-01f, -5.15550096e-03f, -7.44631588e-02f, 6.97943047e-02f, -6.85459143e-03f,
  1.41347021e-01f, 9.61661935e-02f, -6.10335320e-02f, 1.60181537e-01f, 1.39102787e-01f, 1.67714074e-01f, 4.78985459e-02f, 1.04072221e-01f, 2.55338907e-01f, -3.43280405e-01f,
  -8.87830481e-02f, 1.64781027e-02f, 6.63184002e-02f, -8.88741240e-02f, -2.81793326e-02f, -1.36235103e-01f, -8.87447000e-02f, 6.13069125e-02f, -2.50452191e-01f, 1.66620657e-01f,
  -3.54962014e-02f, 2.63546169e-01f, 1.75169066e-01f, -2.36289599e-03f, 9.90317911e-02f, 1.45562157e-01f, -2.34572232e-01f, -5.78561239e-02f, 3.02723467e-01f, -8.35551880e-03f,
  -2.03752846e-01f, 2.56253127e-02f, -3.73782553e-02f, -1.87846320e-03f, -7.72800222e-02f, 4.33788374e-02f, -8.16902071e-02f, -8.14267099e-02f, 4.86528128e-02f, -9.15225893e-02f,
  6.97914734e-02f, 1.13890439e-01f, 1.08955791e-02f, 1.83139503e-01f, -2.45898694e-01f, -7.59452879e-02f, -8.59623551e-02f, 4.47858945e-02f, -1.25742536e-02f, 1.04761764e-01f,
  2.61327308e-02f, 1.52141228e-01f, -1.42760098e-01f, -1.32428929e-01f, -9.93038341e-02f, 4.65792492e-02f, -5.02742268e-02f, -7.13660866e-02f, 6.89756945e-02f, 4.09287736e-02f,
  5.45146577e-02f, 8.03619400e-02f, 4.00931016e-02f, -8.50260705e-02f, 1.36741295e-01f, -3.94543028e-03f, -2.03575730e-01f, 1.19437002e-01f, -6.09820336e-02f, 9.88814384e-02f,
  2.73058284e-02f, -1.95686519e-02f, 1.16785154e-01f, -2.28844002e-01f, -2.32213661e-01f, 1.20888837e-01f, 1.46218479e-01f, 1.04492530e-01f, 1.05403420e-02f, -1.55678555e-01f,
  -6.77699596e-02f, 3.02994363e-02f, -4.25786618e-03f, 2.15431049e-01f, -2.31418267e-01f, 1.33187398e-01f, 2.46062428e-01f, 1.44697770e-01f, 4.33019958e-02f, 1.91128045e-01f,
  -1.32357866e-01f, 2.46885400e-02f, -4.18118760e-03f, 1.38426900e-01f, -1.78976834e-01f, 3.32162865e-02f, 8.65266621e-02f, 4.74878252e-02f, 9.58450958e-02f, -6.81227818e-02f,
  -8.45024139e-02f, 9.76680964e-02f, 5.92286959e-02f, -1.33454919e-01f, 9.58008841e-02f, 7.02105314e-02f, 4.50549740e-03f, 1.07477643e-01f, -1.84530869e-01f, -6.02328638e-03f,
  -3.46056931e-02f, 5.68357296e-02f, 1.05431989e-01f, 1.10218033e-01f, 2.55568288e-02f, 1.99447721e-01f, -2.36312434e-01f, -1.43988237e-01f, -1.46885544e-01f, -6.34395927e-02f,
  5.37927859e-02f, 6.81079775e-02f, -1.11183792e-01f, 9.20937285e-02f, 1.46054462e-01f, 8.30790251e-02f, 7.97995925e-02f, -1.02728471e-01f, 1.00776292e-01f, -9.50585529e-02f,
  1.28541559e-01f, 1.09062955e-01f, -9.18298885e-02f, 5.91796264e-02f, -2.19931025e-02f, 3.47480178e-02f, 4.39858772e-02f, -2.70434737e-01f, -1.60632074e-01f, 1.95265748e-02f,
  1.77377224e-01f, 4.40324955e-02f, -5.31082321e-03f, -2.06743516e-02f, 1.82785392e-02f, -8.38987976e-02f, -4.95957620e-02f, 2.61806428e-01f, -1.79485366e-01f, 2.12739512e-01f,
  2.24748895e-01f, 5.59485592e-02f, 1.87157720e-01f, 8.63641351e-02f, -2.22094938e-01f, -1.80182919e-01f, 1.51549920e-01f, -1.05853781e-01f, -1.75962985e-01f, 1.47521188e-02f,
  8.51588026e-02f, -8.61479118e-02f, -7.63484761e-02f, -1.06158592e-02f, 1.37082681e-01f, -7.93329775e-02f, -4.03916053e-02f, -7.80077577e-02f, -9.90128145e-02f, 4.56199273e-02f,
  1.17763110e-01f, 1.95799202e-01f, -1.10218689e-01f, -1.98292136e-02f, -1.13678545e-01f, 5.20926006e-02f, 8.19052234e-02f, -6.34714812e-02f, 2.08107866e-02f, 2.60285735e-01f,
  -1.12971209e-01f, -5.37019484e-02f, -7.90626928e-02f, 4.31475528e-02f, -8.21648687e-02f, 5.98039627e-02f, -1.52000291e-02f, 3.58702689e-02f, -1.52943954e-01f, 6.71838894e-02f,
  5.05850874e-02f, 8.87375847e-02f, 1.48252416e-02f, -1.20029468e-02f, -1.73790604e-01f, -7.44676962e-02f, 4.03313302e-02f, 5.21739721e-02f, -1.13263488e-01f, -1.31207094e-01f,
  -2.10183673e-03f, 3.11821047e-03f, -9.14383009e-02f, -1.34396004e-02f, -6.24064989e-02f, -8.06156639e-03f, 1.87423095e-01f, -1.68557540e-01f, -5.87517209e-02f, -1.51286706e-01f,
  -1.62078738e-02f, 9.44600701e-02f, -8.75411108e-02f, 1.25614241e-01f, 6.04744293e-02f, 1.71695650e-01f, -7.59519041e-02f, 3.76599245e-02f, 3.19510652e-03f, -1.45437438e-02f,
  9.97299552e-02f, 1.53366789e-01f, -1.04515053e-01f, -8.97367820e-02f, -9.20113400e-02f, -5.89666106e-02f, -6.87104464e-02f, 1.28533483e-01f, -7.57473782e-02f, 1.15859628e-01f,
  8.20855871e-02f, 8.90619978e-02f, -5.09717837e-02f, -1.41162649e-01f, -2.15716120e-02f, -1.12736933e-01f, -3.23000997e-02f, 5.63042462e-02f, -8.61865357e-02f, -3.75317298e-02f,
  -6.68575615e-02f, 1.29747661e-02f, 7.38024246e-03f, -1.91405043e-01f, -1.06274173e-01f, -2.61459202e-01f, 2.15235520e-02f, 7.86677599e-02f, -6.55743778e-02f, -1.30929887e-01f,
  1.54218534e-02f, -1.12499408e-01f, 1.78172160e-02f, -3.61577468e-03f, -4.67703566e-02f, 7.83027634e-02f, -1.70129851e-01f, 4.29302789e-02f, -4.86161523e-02f, -2.77965814e-02f,
  5.71850352e-02f, -1.38546467e-01f, 4.52948697e-02f, -1.23984650e-01f, -1.83841452e-01f, 3.77246402e-02f, 5.61473742e-02f, -7.00373948e-02f, -1.73234299e-01f, 1.50624365e-01f,
  3.99891101e-02f, -1.48689345e-01f, -1.24308430e-01f, -2.70464160e-02f, 2.26237997e-01f, -1.25325412e-01f, 4.19266112e-02f, -2.57392675e-02f, -2.27553263e-01f, -2.83038914e-02f,
  -1.84425414e-01f, 2.86488477e-02f, 2.27712154e-01f, 5.07801250e-02f, -2.09014773e-01f, 1.54835805e-01f, 1.30227119e-01f, 1.11078225e-01f, -1.19649172e-01f, -3.46790105e-02f,
  9.73678827e-02f, -6.54498860e-02f, -1.85983360e-01f, 4.76715900e-03f, -8.49924386e-02f, 2.07465470e-01f, -1.21684028e-02f, 4.35312577e-02f, 5.45540117e-02f, -9.80555564e-02f,
  1.79976523e-01f, -3.93335633e-02f, 4.37522158e-02f, -3.68524157e-02f, -7.57794976e-02f, 1.78154260e-02f, -1.19639821e-01f, -2.29030058e-01f, -8.64215344e-02f, -1.17166517e-02f,
  -1.56099722e-01f, 9.62924138e-02f, 1.34113893e-01f, -2.65702996e-02f, 5.71688823e-02f, 7.39886835e-02f, 1.22883573e-01f, -1.73794720e-02f, 7.97234755e-03f, -3.47128585e-02f,
  -6.97721094e-02f, -5.36417514e-02f, 5.44430725e-02f, -1.44074261e-02f, -3.73382270e-02f, -8.52992758e-02f, 6.54790252e-02f, -3.11548021e-02f, -1.41938731e-01f, 2.18723863e-01f,
  2.27020606e-01f, -5.81316538e-02f, -3.57088111e-02f, 1.31383752e-02f, -2.33540520e-01f, 1.88337654e-01f, 3.20301694e-03f, 8.04445446e-02f, -1.38458759e-01f, -1.52518108e-01f,
  8.41517448e-02f, -2.06971262e-02f, 2.22483370e-02f, -8.34428668e-02f, -1.68276369e-03f, 6.51850551e-02f, -1.22944057e-01f, -7.03259185e-02f, 5.96756153e-02f, -8.93639848e-02f,
  3.79438698e-02f, 1.12690426e-01f, 5.49402684e-02f, 1.08412495e-02f, -1.28418073e-01f, -9.38894823e-02f, -5.14071295e-03f, -1.17314301e-01f, 9.61129218e-02f, -1.74550876e-01f,
  -1.51764542e-01f, 1.28321737e-01f, 1.23641729e-01f, -5.02292514e-02f, 9.94003937e-02f, -7.89722486e-04f, -9.52205658e-02f, 2.81065404e-02f, 8.63987133e-02f, -1.18515357e-01f,
  -1.31375581e-01f, 1.22771755e-01f, 7.01233149e-02f, 2.71373957e-01f, -2.16774359e-01f, -2.07420550e-02f, -5.06963506e-02f, 7.45359762e-03f, 4.42116596e-02f, -1.29739955e-01f,
  6.69874018e-03f, 4.58861206e-04f, -3.19911055e-02f, -2.77105033e-01f, 1.07229888e-01f, -2.56371405e-02f, -7.37079829e-02f, 8.15526024e-02f, -8.67229253e-02f, -1.18643202e-01f,
  -2.02184357e-02f, -1.33300930e-01f, 6.49090707e-02f, -1.77563787e-01f, 2.81997565e-02f, 6.24540634e-03f, 2.84309894e-01f, -3.20842415e-02f, 8.42699781e-02f, -1.87055320e-01f,
  -2.24245507e-02f, 8.49082768e-02f, -2.10513636e-01f, 1.00356266e-01f, -1.42226547e-01f, -2.02003643e-01f, -4.30960506e-02f, -1.78230599e-01f, 2.52705574e-01f, -8.70443135e-02f,
  -1.12522133e-01f, 3.29484083e-02f, 1.19579867e-01f, -1.95038974e-01f, -1.19556161e-02f, -9.82443169e-02f, 3.39613557e-02f, -1.48874342e-01f, 1.09829411e-01f, 3.66692804e-02f,
  7.04504400e-02f, -1.01028785e-01f, 4.03584428e-02f, -1.37037039e-01f, 2.09088385e-01f, -2.11900711e-01f, 6.92339838e-02f, 6.36715218e-02f, -2.18796328e-01f, 1.56949148e-01f,
  1.30205929e-01f, 4.11032736e-02f, -5.63465431e-02f, -1.59415156e-01f, 1.15505673e-01f, 2.12678954e-01f, -1.02517851e-01f, 5.82419671e-02f, 2.11137403e-02f, 1.50742307e-01f,
  -4.83745523e-02f, 6.86700642e-02f, 2.15808209e-02f, 1.06241807e-01f, 8.03048983e-02f, 1.15577253e-02f, 1.18676938e-01f, 1.94690555e-01f, 1.09790497e-01f, -3.56268547e-02f,
  1.28038406e-01f, -3.85148525e-02f, 1.87295258e-01f, -1.28254024e-02f, 9.89178047e-02f, -4.76490743e-02f, 8.71222243e-02f, 9.86034423e-02f, 2.19867900e-02f, 4.92353626e-02f,
  -1.12628162e-01f, 1.28491595e-01f, -1.68305188e-01f, -1.65183932e-01f, -1.96995050e-01f, -7.27947354e-02f, 2.05131203e-01f, -2.33400866e-01f, 4.47066232e-05f, -7.77954282e-03f,
  -1.75664425e-01f, -7.67936707e-02f, -1.13993920e-01f, -1.11270413e-01f, 1.64051354e-01f, 1.79034039e-01f, 1.13732582e-02f, 5.41213974e-02f, -3.84533331e-02f, -7.11448118e-02f,
  6.19969629e-02f, 4.77956943e-02f, 7.29831681e-02f, -3.57464924e-02f, -1.62792444e-01f, 1.11774176e-01f, -9.74762440e-02f, 2.64400452e-01f, -1.31360054e-01f, -8.70014168e-03f,
  2.80710608e-02f, -1.37470439e-01f, 1.95670068e-01f, 1.53571010e-01f, -4.68401909e-02f, 3.08527183e-02f, -2.02990067e-03f, -1.16215929e-01f, -2.54012533e-02f, -2.97315866e-01f,
  1.69123933e-02f, -2.23216019e-03f, 8.76615271e-02f, 1.04522370e-01f, -1.28021166e-02f, -9.53773707e-02f, 9.27329138e-02f, 9.38715115e-02f, 5.07478416e-02f, 6.12038523e-02f,
  1.50059965e-02f, 6.37977123e-02f, 2.86437403e-02f, -5.29481806e-02f, -1.61488891e-01f, 5.41846966e-03f, 6.33785352e-02f, 9.56618879e-03f, -1.10281125e-01f, 1.37534782e-01f,
  -3.75130102e-02f, -2.79135704e-01f, -1.48648217e-01f, 1.52413324e-01f, -2.75978465e-02f, -1.46693494e-02f, -5.78567423e-02f, 5.12076430e-02f, -7.28275701e-02f, 4.43190821e-02f,
  -9.31698456e-02f, 2.43338898e-01f, -1.11814015e-01f, 7.56584778e-02f, 1.46444574e-01f, 6.88922592e-03f, -2.88526760e-03f, 1.37490541e-01f, -3.08634602e-02f, 8.89448449e-02f,
  1.41931564e-01f, 7.85911679e-02f, -1.03945248e-01f, -1.77778229e-02f, -2.88507417e-02f, 2.42541023e-02f, -9.53607410e-02f, -6.49417639e-02f, -9.08618718e-02f, 5.60923554e-02f,
  1.94622967e-02f, 4.37763631e-02f, -6.32812977e-02f, -6.35539442e-02f, 3.62294284e-03f, -1.41848713e-01f, 5.89495301e-02f, -1.35598958e-01f, -2.28092726e-02f, 8.77460539e-02f,
  1.07642934e-01f, 1.93754852e-01f, 1.72024942e-04f, 2.15430140e-01f, -8.20701122e-02f, -1.32803231e-01f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -4.50740345e-02f, -9.93725285e-02f, 5.51556498e-02f, 1.49762481e-01f, 1.13134883e-01f, 6.08389862e-02f, -1.03686877e-01f, -5.58040291e-02f, 1.14954315e-01f, -2.58281291e-01f,
  1.11254275e-01f, -7.26576895e-02f, -1.76438987e-01f, -5.49855977e-02f, 1.06046788e-01f, 1.85325127e-02f, -1.04851257e-02f, 1.52066574e-01f, 1.11129947e-01f, -3.69237247e-03f,
  1.95399299e-02f, 1.53264627e-01f, 2.62286305e-01f, -6.89227656e-02f, 1.05849087e-01f, -2.07230985e-01f, 1.50125369e-01f, 4.24095355e-02f, -1.93209529e-01f, 3.01699162e-01f,
  9.83155817e-02f, -6.42461106e-02f, 2.82404316e-03f, -1.44555002e-01f, 1.25615031e-01f, -2.84917295e-01f, 7.70360529e-02f, 1.75814733e-01f, 2.98020184e-01f, 7.96498789e-05f,
  4.26189825e-02f, -1.42690944e-04f, 1.01225950e-01f, -4.52810414e-02f, 7.08369091e-02f, 1.49825424e-01f, 1.88554630e-01f, -5.51357046e-02f, -6.06821217e-02f, -1.36111509e-02f,
  3.27983886e-01f, -2.07955018e-01f, -7.19876215e-02f, 3.75092737e-02f, -2.96060964e-02f, -1.42945632e-01f, -1.06613189e-01f, 1.02047011e-01f, 1.99605599e-01f, 1.11651435e-01f,
  1.23570181e-01f, 1.78903695e-02f, -2.20226765e-01f, 2.65906185e-01f, 1.27554223e-01f, 9.26327184e-02f, -2.07310408e-01f, 4.10216413e-02f, 7.47127607e-02f, -1.99725516e-02f,
  -2.45474726e-01f, -5.80044612e-02f, -1.35322660e-01f, 1.27157986e-01f, -1.39988437e-01f, 4.40541506e-02f, 2.08696887e-01f, -1.14073992e-01f, 1.02603346e-01f, -9.13003460e-02f,
  -9.88347828e-02f, 2.10603643e-02f, 1.24097280e-01f, 1.25390932e-01f, 9.20578167e-02f, -1.78597689e-01f, -1.53036350e-02f, -1.39528945e-01f, 2.41350364e-02f, 2.39278704e-01f,
  5.77005334e-02f, 9.88828018e-02f, -1.50676608e-01f, -2.42074747e-02f, 9.14538801e-02f, -4.74109761e-02f, 1.57332376e-01f, 4.98300567e-02f, 1.78978160e-01f, 7.52933770e-02f,
  -1.75803170e-01f, -2.44925022e-02f, -4.36942056e-02f, 1.00480027e-01f, 1.20309308e-01f, 4.82455082e-02f, -1.72657687e-02f, -9.30761918e-02f, 4.76364978e-02f, -2.60550492e-02f,
  1.32076502e-01f, 1.00977026e-01f, -6.12879358e-02f, -1.06473811e-01f, 3.82021512e-03f, 1.66199520e-01f, -4.32998203e-02f, 1.23410501e-01f, 6.78520352e-02f, -1.40555680e-01f,
  -2.26264913e-02f, 5.56032248e-02f, 9.26523581e-02f, 1.71527900e-02f, -4.99795191e-03f, 1.81534931e-01f, 2.91821271e-01f, 9.36569497e-02f, 5.40494472e-02f, 2.54792690e-01f,
  1.68747872e-01f, 1.93646505e-01f, 1.84506163e-01f, 2.55908608e-01f, 2.63011754e-01f, 2.79710710e-01f, 6.27744272e-02f, 2.89980203e-01f, -1.25063539e-01f, 8.55118856e-02f,
  2.66245723e-01f, 1.15954727e-01f, 1.27196014e-01f, 2.12320164e-01f, 1.76181048e-02f, 2.23164141e-04f, -4.78937179e-02f, 2.75051564e-01f, 1.74354807e-01f, -6.12766780e-02f,
  -2.84869432e-01f, -4.52635400e-02f, -2.70502985e-01f, -4.85640615e-02f, -1.29097000e-01f, 8.77335966e-02f, 2.43541300e-01f, -2.90184021e-01f, 8.12750608e-02f, 7.18610138e-02f,
  -5.49347028e-02f, -1.57996625e-01f, -1.85509131e-03f, -1.91135436e-01f, 3.54916930e-01f, 2.19124272e-01f, 6.00572154e-02f, -1.39984842e-02f, 1.17601743e-02f, 2.52166186e-02f,
  7.88020194e-02f, 4.36110497e-02f, -3.11478674e-02f, 6.62291497e-02f, -2.10884109e-01f, 2.23916350e-03f, 1.85440062e-03f, 4.33257192e-01f, 1.09267808e-01f, 8.52470100e-02f,
  3.97302359e-02f, -4.50274348e-02f, 2.38419577e-01f, 2.50334293e-01f, 5.67240901e-02f, -2.82532740e-02f, -1.16463946e-02f, -8.33583623e-02f, -9.95716825e-02f, -6.24718107e-02f,
  1.91782400e-01f, 1.99251309e-01f, -2.26912759e-02f, -2.87971348e-02f, -1.06022283e-01f, -7.11764246e-02f, 9.53035653e-02f, 1.22057192e-01f, 4.09468375e-02f, -8.29294547e-02f,
  1.31174892e-01f, 6.83136582e-02f, -5.40960878e-02f, 7.33423084e-02f, -3.97310406e-02f, 6.60726354e-02f, -1.15407825e-01f, 1.16511673e-01f, 4.78988104e-02f, -1.01065308e-01f,
  3.51370275e-02f, -5.24403490e-02f, -9.76708755e-02f, 7.78562203e-03f, -4.51699942e-02f, 8.63505229e-02f, 8.51137862e-02f, -1.18692309e-01f, 1.09770879e-01f, 3.63752060e-02f,
  -2.91146915e-02f, 1.40013233e-01f, 1.15830816e-01f, 2.70407703e-02f, 3.56703177e-02f, -1.15321964e-01f, 7.85981193e-02f, -1.38516277e-01f, -9.52492002e-04f, -1.97181534e-02f,
  -4.31364588e-02f, -6.96476996e-02f, -2.39502061e-02f, 3.42501402e-02f, -1.91848874e-02f, -1.00695096e-01f, 1.17292061e-01f, 9.30186883e-02f, 2.08315458e-02f, 3.25351134e-02f,
  -9.80604365e-02f, -3.67893763e-02f, 1.53587908e-01f, -2.03865138e-03f, -1.18866712e-02f, 9.00529549e-02f, -1.12046055e-01f, 3.42793837e-02f, -9.49141011e-02f, -5.42618521e-02f,
  6.19906075e-02f, 2.87196273e-03f, 1.08376995e-01f, 2.40416415e-02f, -4.11625430e-02f, -1.10225894e-01f, -1.20022245e-01f, 2.11640954e-01f, 1.74543962e-01f, 1.75622880e-01f,
  2.28555441e-01f, 9.79930609e-02f, 2.28532106e-01f, 1.77131072e-01f, 2.19785362e-01f, 1.09645821e-01f, 1.71390787e-01f, 5.50660044e-02f, -1.15474813e-01f, -5.96276633e-02f,
  2.08859503e-01f, 1.00894943e-01f, 1.02320611e-01f, 2.45094687e-01f, 7.43625984e-02f, -2.24161983e-01f, -2.79740393e-01f, 2.74576992e-01f, 5.86031415e-02f, 2.45042760e-02f,
  1.01275273e-05f, 9.39445104e-03f, -8.34081471e-02f, -6.19295314e-02f, 3.45384367e-02f, 8.24131072e-02f, -1.06175870e-01f, 4.09893036e-01f, 1.45294219e-01f, 1.59980670e-01f,
  -1.03997447e-01f, -9.49948505e-02f, -7.81051442e-02f, 1.70692250e-01f, 2.89672405e-01f, 9.68161784e-03f, -1.30094066e-01f, -3.92343812e-02f, -8.26404765e-02f, 1.27561346e-01f,
  8.41354579e-02f, 1.08403631e-01f, -9.35907364e-02f, -9.84606817e-02f, -1.02497473e-01f, 1.12917624e-01f, 6.12329207e-02f, 1.45574868e-01f, 1.46997403e-02f, -1.02898546e-01f,
  2.12097734e-01f, -1.26162902e-01f, 2.46003494e-02f, 6.21987246e-02f, -1.30441412e-02f, 3.87606055e-01f, 2.22721025e-01f, 2.39022210e-01f, -1.47473201e-01f, -1.77258238e-01f,
  1.55698135e-02f, -9.14700478e-02f, 1.12075858e-01f, -6.62106201e-02f, -5.21321557e-02f, -1.12610511e-01f, 8.89777169e-02f, -1.03309356e-01f, 9.75053757e-02f, -1.16334237e-01f,
  -3.74425128e-02f, -1.07684612e-01f, -1.11015409e-01f, -1.53946597e-02f, 2.47024116e-03f, 3.49618047e-02f, 2.84963455e-02f, 9.69214514e-02f, -8.00894573e-02f, 7.24253729e-02f,
  1.03800148e-01f, -2.86788996e-02f, 7.71739781e-02f, -7.19673857e-02f, -5.54467961e-02f, -3.79546210e-02f, 1.18520699e-01f, 1.22907303e-01f, -3.59019227e-02f, -4.78423387e-03f,
  -1.01407520e-01f, -2.20372882e-02f, -2.31199414e-02f, 2.46995054e-02f, 3.72482575e-02f, 1.27001494e-01f, 1.22866310e-01f, 1.53864371e-02f, 1.14898132e-02f, -4.07345444e-02f,
  -2.78101489e-02f, 9.20367688e-02f, 1.20290697e-01f, -1.11955665e-01f, -2.24308353e-02f, 2.43559573e-02f, -5.38729131e-02f, 7.37577975e-02f, -1.18375748e-01f, 9.90292802e-02f,
  1.10346779e-01f, -1.61622707e-02f, 6.17712177e-02f, -6.09450117e-02f, -3.56682949e-02f, -1.92500204e-02f, -2.32664198e-02f, -4.74390276e-02f, 7.51544461e-02f, -1.88556733e-03f,
  -8.41389745e-02f, -8.16742107e-02f, -8.56211782e-03f, 2.76505388e-02f, 6.22824170e-02f, 5.13268113e-02f, -4.25790772e-02f, 7.81467706e-02f, 2.03803509e-01f, 2.09895894e-02f,
  3.42917964e-02f, 8.09571669e-02f, 1.61068574e-01f, 7.42480308e-02f, 1.22613288e-01f, 3.31214406e-02f, -1.86523855e-01f, 1.72209457e-01f, 1.77050442e-01f, 6.51794672e-02f,
  -4.36015651e-02f, 1.48132652e-01f, -2.56965589e-02f, -1.80564612e-01f, -1.90825850e-01f, 3.65344048e-01f, 2.55942773e-02f, 2.82511041e-02f, 2.53988981e-01f, -1.07705049e-01f,
  6.83517978e-02f, -1.33655921e-01f, -8.78861248e-02f, 1.89663768e-01f, -4.03148234e-02f, 2.61272579e-01f, -1.86753526e-01f, 3.94013301e-02f, -1.66528985e-01f, 9.96259972e-03f,
  -1.62746266e-01f, 1.42205834e-01f, 5.27914762e-01f, 1.10935941e-01f, -1.41078904e-01f, 4.58476394e-02f, 1.05162427e-01f, -1.04301460e-01f, 4.20515202e-02f, 1.59947928e-02f,
  3.29927616e-02f, 4.24067341e-02f, -9.65891406e-02f, 8.61461684e-02f, -6.78403676e-03f, 5.59723563e-02f, -3.55660766e-02f, 1.03105241e-02f, 3.17308418e-02f, 1.11285280e-02f,
  1.13824576e-01f, -8.92522782e-02f, -4.45701778e-02f, 2.32893020e-01f, 2.69201279e-01f, 2.96176337e-02f, -2.10873291e-01f, -1.95647813e-02f, -6.46221712e-02f, 1.02533057e-01f,
  8.46202001e-02f, 4.98289838e-02f, -8.69402140e-02f, -2.06221920e-02f, 8.11208934e-02f, -6.85871094e-02f, -3.69233415e-02f, -9.67186987e-02f, -3.04656066e-02f, 7.70492852e-02f,
  -7.57695660e-02f, -2.29552668e-03f, 1.05799757e-01f, 8.74250084e-02f, -7.69971162e-02f, 4.36079539e-02f, -1.19546197e-01f, 4.72147949e-02f, 1.16767682e-01f, 7.86278099e-02f,
  -7.18587413e-02f, 7.22463354e-02f, -5.76740615e-02f, 7.99357891e-02f, 1.71492286e-02f, 8.21899548e-02f, 4.59479075e-03f, 4.11048867e-02f, 2.92630047e-02f, 8.47506709e-03f,
  1.22685067e-01f, -3.30368653e-02f, -3.95771414e-02f, -1.08493846e-02f, -2.54973187e-03f, -1.11477941e-01f, 2.32722852e-02f, -1.05543807e-01f, -3.48069817e-02f, -5.46741672e-02f,
  1.12463392e-01f, -1.00135561e-02f, -1.18723072e-01f, 1.04528390e-01f, -1.15514256e-01f, 2.65864027e-03f, -6.89646825e-02f, -2.69791801e-02f, -1.18199930e-01f, -1.38138989e-02f,
  -6.16137870e-02f, -5.34096435e-02f, 5.51484898e-02f, 4.11051810e-02f, -8.63892511e-02f, -4.03104350e-03f, 6.31793439e-02f, 2.78658196e-02f, -9.01776850e-02f, -9.34995487e-02f,
  -4.86172102e-02f, 1.72457192e-02f, -1.19212046e-01f, 6.74881935e-02f, -6.00983575e-02f, 7.72807077e-02f, -1.13002606e-01f, -4.28195931e-02f, 9.26701818e-03f, 3.41988169e-02f,
  -7.23780841e-02f, -6.50445893e-02f, 8.83183554e-02f, -1.19831078e-01f, 3.39327119e-02f, -8.80325660e-02f, 3.31398137e-02f, 4.51008901e-02f, 1.27533423e-02f, -4.87425812e-02f,
  -4.58351560e-02f, 3.51078101e-02f, -2.85243634e-02f, 4.69936617e-02f, -2.33609192e-02f, -9.63313282e-02f, 7.17490986e-02f, 7.15398192e-02f, -9.67582688e-02f, 3.40393707e-02f,
  -9.39343199e-02f, 2.97448109e-03f, -8.69128332e-02f, -1.15417866e-02f, 8.76795202e-02f, -6.22833446e-02f, -8.78845230e-02f, -7.89419413e-02f, -1.48628587e-05f, 1.16678663e-01f,
  5.51590789e-03f, 5.62913567e-02f, 1.04680248e-01f, -8.71544480e-02f, -6.95905834e-02f, -1.51778841e-02f, -8.34307298e-02f, -4.17268984e-02f, 3.28307487e-02f, 7.58531839e-02f,
  -2.84772366e-02f, 1.13762692e-01f, -9.72338989e-02f, 9.19088051e-02f, 8.76421258e-02f, -5.30004241e-02f, -4.39577848e-02f, -6.71977326e-02f, 9.94405225e-02f, 7.31967986e-02f,
  7.49168023e-02f, -4.49137278e-02f, -4.05249447e-02f, -2.10196972e-02f, -5.81727810e-02f, -7.91845024e-02f, 3.83396670e-02f, -7.40770772e-02f, 1.07597433e-01f, -4.64489162e-02f,
  9.73378047e-02f, -1.79616604e-02f, 9.05046985e-02f, -2.98938230e-02f, -2.87044849e-02f, -3.98753397e-02f, -6.82429746e-02f, 4.06093150e-02f, -4.31836769e-02f, -3.42766643e-02f,
  1.51463449e-01f, 2.74890736e-02f, 9.29858610e-02f, 9.46749642e-04f, 2.22461447e-02f, -4.48205546e-02f, 1.14923067e-01f, -1.19356714e-01f, -1.28434628e-01f, 1.06708080e-01f,
  1.88154913e-02f, -4.72352430e-02f, -1.16965607e-01f, 6.37750551e-02f, 3.82175669e-02f, -1.39714316e-01f, -3.08593605e-02f, -1.69663027e-01f, -6.43864870e-02f, -3.23082507e-02f,
  -1.19797394e-01f, -1.64681762e-01f, 5.10698222e-02f, -4.25937586e-02f, -1.00139007e-01f, 3.98852341e-02f, 5.82559546e-03f, 1.13210522e-01f, -4.65764850e-03f, 2.50389259e-02f,
  -6.55673742e-02f, -6.22034818e-03f, -6.00697752e-03f, 3.51351500e-02f, 6.51543811e-02f, 3.07533448e-03f, 1.19344927e-01f, 3.36135877e-03f, 3.23611163e-02f, 5.80809116e-02f,
  1.16258897e-01f, -2.71711443e-02f, -5.75989261e-02f, -3.78143159e-04f, 2.80457009e-02f, -1.41149402e-01f, -1.05431661e-01f, -1.57027971e-02f, 1.43695027e-01f, 2.37720475e-01f,
  2.95821819e-02f, 2.16092080e-01f, 1.23475315e-02f, 2.35612988e-02f, 5.45576699e-02f, 1.15437038e-01f, -6.77115694e-02f, -1.02182575e-01f, 8.75197873e-02f, 2.26388663e-01f,
  -1.61284227e-02f, 7.54359588e-02f, 2.05484897e-01f, 6.56900182e-02f, -9.04731080e-02f, 1.62943959e-01f, 9.59025323e-02f, 1.51391670e-01f, 2.05801830e-01f, -1.59402024e-02f,
  1.01320982e-01f, -3.04674149e-01f, -1.30107388e-01f, -4.99376934e-03f, 3.43682095e-02f, 3.82605106e-01f, 1.41144067e-01f, 6.72622845e-02f, -2.97490004e-02f, -1.55552208e-01f,
  -6.62462339e-02f, -1.91954020e-02f, 1.44262761e-01f, 1.37080491e-01f, 7.79952183e-02f, 1.82873994e-01f, -1.59542620e-01f, -2.60998398e-01f, -5.02339788e-02f, 9.24735982e-03f,
  1.14026196e-01f, 4.20788974e-02f, -7.85757303e-02f, 3.72995436e-02f, 3.27055119e-02f, -3.73185761e-02f, 2.38092691e-01f, -2.31406745e-02f, -9.46685597e-02f, -8.64764377e-02f,
  -2.60628402e-01f, 6.11464418e-02f, 1.17340729e-01f, 1.25421554e-01f, 1.90357007e-02f, 3.05447970e-02f, 1.23531349e-01f, -6.90908059e-02f, -1.24996893e-01f, 9.40174907e-02f,
  7.55891055e-02f, 4.56197143e-01f, 4.19784546e-01f, -4.79378738e-02f, 2.11644545e-01f, 5.77580892e-02f, 5.14605381e-02f, 7.28064552e-02f, 4.67759138e-03f, 6.19785525e-02f,
  1.61107004e-01f, -7.64955133e-02f, 2.46627554e-02f, -1.51548591e-02f, 4.32136618e-02f, 1.14455760e-01f, 2.92562187e-01f, 2.46290013e-01f, 1.69001356e-01f, 8.10336024e-02f,
  7.19087422e-02f, 7.58532062e-02f, 1.49479792e-01f, 3.69385630e-02f, 1.76628217e-01f, -3.81665707e-01f, -2.44815834e-02f, 9.13438499e-02f, -2.89190620e-01f, 1.65411755e-01f,
  1.92983642e-01f, 8.90372321e-02f, 9.11738127e-02f, -1.21595651e-01f, -5.08219153e-02f, -2.80734420e-01f, 7.00610355e-02f, -1.12566359e-01f, -1.35200424e-02f, 4.45821732e-02f,
  -1.56615824e-02f, 1.40171632e-01f, -3.11931491e-01f, 5.12568578e-02f, 1.63849160e-01f, 2.22764909e-02f, 3.29584479e-02f, -1.56599149e-01f, -7.83419758e-02f, 6.14214726e-02f,
  5.37439175e-02f, 3.32055874e-02f, 6.22747932e-03f, 7.81501308e-02f, -5.56171685e-02f, 1.47787809e-01f, -4.37429957e-02f, 3.14817876e-01f, -1.04109630e-01f, 2.59523243e-01f,
  1.58217438e-02f, 9.67981890e-02f, 1.00677423e-01f, -1.55598730e-01f, -5.00913933e-02f, 2.41421118e-01f, 3.68961275e-01f, 4.65893149e-01f, -1.01478290e-04f, -2.65759341e-02f,
  -5.71997017e-02f, 1.18312776e-01f, 6.40748516e-02f, -1.14866816e-01f, 1.01941153e-02f, -5.65254837e-02f, -5.48258945e-02f, -8.68706554e-02f, 1.16037950e-01f, 3.65850590e-02f,
  5.63637018e-02f, -3.46824303e-02f, 1.18892267e-01f, 8.55064020e-03f, 9.80113819e-02f, -9.31116790e-02f, -9.64061171e-02f, -5.49483448e-02f, -9.27651376e-02f, -9.95300338e-02f,
  5.15136681e-02f, -6.20801635e-02f, -5.80699816e-02f, -8.44288711e-03f, -2.79503986e-02f, 3.35703269e-02f, 4.95802760e-02f, -8.71231258e-02f, -6.49626330e-02f, -7.00354129e-02f,
  6.39792979e-02f, -7.99452588e-02f, 6.67152926e-02f, 1.37891099e-02f, 1.04029767e-01f, 2.48171426e-02f, 8.94096307e-03f, 4.20777574e-02f, -3.69549766e-02f, -6.54584449e-03f,
  5.96381761e-02f, 5.85149601e-02f, -9.86141786e-02f, 5.74844964e-02f, -1.40139367e-02f, -5.09621613e-02f, 8.40398297e-02f, -1.14225768e-01f, 1.42799124e-01f, -7.92360380e-02f,
  -3.53670269e-02f, 2.05902848e-02f, 8.52322057e-02f, -5.29492460e-02f, 9.63435620e-02f, 5.06258570e-04f, 1.94293279e-02f, -1.01031162e-01f, -2.35785777e-03f, 3.58109027e-02f,
  -1.00083247e-01f, -1.27757885e-04f, 2.95832790e-02f, 5.51802926e-02f, 1.73529297e-01f, 4.02375348e-02f, 1.08520322e-01f, -2.46567708e-02f, -5.72338421e-03f, 1.20239884e-01f,
  -7.28267878e-02f, -4.52424362e-02f, 2.80700363e-02f, 1.26016550e-02f, -9.26077291e-02f, -8.70654061e-02f, -7.41374120e-02f, -8.54489505e-02f, -6.48151562e-02f, 5.83983725e-04f,
  -1.33400306e-01f, -8.34548250e-02f, 4.58717234e-02f, 9.68794748e-02f, 1.08880736e-01f, 2.96484604e-02f, -7.96272382e-02f, 2.60734539e-02f, 4.39620391e-02f, 7.03949481e-02f,
  3.34190130e-02f, 9.87995509e-03f, -8.57275501e-02f, 1.45104164e-02f, -1.33261174e-01f, -3.09807733e-02f, -3.97650637e-02f, -3.56536508e-02f, -7.41198137e-02f, 9.24340934e-02f,
  2.93568313e-01f, -4.68199700e-02f, -6.35288376e-03f, 5.32433204e-02f, -6.05178997e-02f, 1.04480810e-01f, 9.49919373e-02f, 5.50347827e-02f, -1.47781270e-02f, -1.17164940e-01f,
  8.31174403e-02f, -2.20527723e-02f, -5.77643178e-02f, -1.68262757e-02f, 7.12557286e-02f, -9.13209245e-02f, 2.04386905e-01f, -1.29799947e-01f, 3.10056210e-02f, -5.73416017e-02f,
  -3.67970206e-02f, 2.39834949e-01f, 1.19823225e-01f, -7.93683436e-03f, 7.60197490e-02f, 1.42506868e-01f, -2.38065999e-02f, -5.05030863e-02f, -7.25029483e-02f, -4.41161394e-02f,
  1.40003964e-01f, -6.76891953e-02f, 4.86390293e-02f, -4.50081415e-02f, -9.49264765e-02f, -1.49136176e-02f, 1.41041121e-02f, -6.37239888e-02f, -1.11339800e-01f, 4.72467467e-02f,
  3.75210643e-02f, -8.86132419e-02f, 1.05385177e-01f, 6.83786348e-02f, 2.42335014e-02f, -6.11315519e-02f, -1.25705391e-01f, -7.76737258e-02f, 3.00111063e-02f, 3.28308158e-02f,
  2.55955327e-02f, -1.58500839e-02f, 1.26571521e-01f, 9.43693332e-03f, -1.07010968e-01f, -4.16008979e-02f, -1.12240426e-01f, -9.92758647e-02f, -7.28407037e-03f, -1.54122747e-02f,
  9.62081775e-02f, 5.61248139e-02f, 4.52649072e-02f, -7.72121102e-02f, 1.38039291e-01f, 1.07714422e-01f, 2.74113715e-02f, 1.22861005e-01f, -1.19264141e-01f, -4.54010442e-02f,
  -5.63186258e-02f, 1.06603034e-01f, -5.54123148e-02f, -1.18501343e-01f, -8.13924670e-02f, -6.70991018e-02f, -4.13644612e-02f, 1.06673604e-02f, -2.28028814e-03f, -6.82451203e-02f,
  1.33858755e-01f, -1.18704863e-01f, -6.24125898e-02f, -9.53790471e-02f, -5.40153794e-02f, 1.61749199e-01f, 3.09783537e-02f, 1.01308413e-02f, 7.45946020e-02f, -7.28035271e-02f,
  -2.10993960e-02f, -6.69889748e-02f, -1.16077662e-01f, -9.00790095e-02f, 4.52803224e-02f, -4.49216776e-02f, 7.67719175e-04f, -7.33186975e-02f, -7.60550350e-02f, -5.66744953e-02f,
  1.66831147e-02f, 7.81669840e-02f, -3.22630480e-02f, 3.44766416e-02f, -1.24263220e-01f, 1.73993297e-02f, -5.41762859e-02f, -1.41448617e-01f, 8.23002588e-03f, -9.00532156e-02f,
  5.20818345e-02f, 6.16241852e-03f, -9.70844850e-02f, 9.61563811e-02f, -7.27970451e-02f, -1.29761789e-02f, -7.15634823e-02f, -3.64507884e-02f, 1.20999090e-01f, 1.24507183e-02f,
  -9.14943442e-02f, -1.03641786e-01f, 5.72063290e-02f, -7.08047375e-02f, 4.25487831e-02f, -1.06064174e-02f, 7.57876486e-02f, -5.17567359e-02f, 9.45945010e-02f, 3.37304845e-02f,
  -1.16354130e-01f, 1.07711516e-01f, 7.65558006e-03f, 8.29914585e-02f, -1.03732506e-02f, 3.27846110e-02f, 8.33466500e-02f, 4.73885797e-02f, -1.10872343e-01f, 9.35420245e-02f,
  9.31037664e-02f, -6.43065646e-02f, -3.24554406e-02f, 3.07485498e-02f, -1.12227723e-01f, 1.12140458e-03f, 1.17105454e-01f, -1.17994927e-01f, 3.80192250e-02f, 5.15432358e-02f,
  -1.06636345e-01f, -4.46612537e-02f, 4.58934531e-02f, -3.14149843e-03f, -6.36144876e-02f, -2.46965587e-02f, -6.06294572e-02f, 8.71876776e-02f, 9.89438128e-03f, -1.10680103e-01f,
  -2.86129396e-02f, 9.89373699e-02f, -8.28093514e-02f, -8.36740062e-02f, -6.46121278e-02f, 1.23274095e-01f, 1.17536336e-01f, -2.67918780e-02f, -9.47442129e-02f, -1.08058281e-01f,
  -9.01761353e-02f, 1.10302866e-01f, -4.29994836e-02f, 5.09829484e-02f, -9.43550020e-02f, 1.15054147e-02f, 2.16270778e-02f, 6.38555586e-02f, 1.01831965e-01f, -1.90172158e-02f,
  1.30048227e-02f, 7.98061192e-02f, 1.26493409e-01f, 7.90291801e-02f, 2.31561866e-02f, -4.28905375e-02f, 8.98459554e-03f, -5.04301153e-02f, 2.91412286e-02f, -4.11473960e-03f,
  -8.35612416e-02f, -9.64644700e-02f, 9.84319206e-03f, 1.05514497e-01f, -7.94213265e-02f, -4.89090104e-03f, -7.11072534e-02f, 5.48649579e-02f, -3.93217169e-02f, 7.38240927e-02f,
  -7.79686198e-02f, 6.78339675e-02f, -1.61936767e-02f, 1.25642240e-01f, -1.12069063e-01f, 7.06523210e-02f, -9.22209024e-02f, -4.64709214e-04f, -1.00261346e-01f, 6.74384609e-02f,
  8.67681392e-03f, 1.22316107e-01f, -2.77808663e-02f, 1.06680021e-01f, -1.17945664e-01f, 1.02777341e-02f, 7.46640563e-02f, -1.06771141e-02f, -8.95203054e-02f, -4.03159633e-02f,
  -4.30328138e-02f, -4.24209237e-02f, 9.06607360e-02f, -8.14038217e-02f, 1.47538353e-02f, 4.96008322e-02f, 4.88745831e-02f, -5.31744622e-02f, 9.48228538e-02f, -6.55921251e-02f,
  -8.60116482e-02f, -2.55800169e-02f, -1.03976652e-02f, 1.17138691e-01f, -9.21468735e-02f, 1.22982301e-01f, -6.40124157e-02f, -1.67300645e-02f, -1.49140507e-01f, 4.60243337e-02f,
  1.28498703e-01f, -1.05081573e-01f, 1.76121225e-03f, -1.25070110e-01f, 1.14310592e-01f, -1.66804530e-02f, 7.77504547e-03f, 1.04891375e-01f, -5.41650578e-02f, -4.92943972e-02f,
  9.26520303e-02f, -1.03640566e-02f, 8.42736587e-02f, -9.42663401e-02f, -1.16756774e-01f, -1.37099009e-02f, 5.92459366e-02f, -1.01002790e-01f, -3.57177444e-02f, -1.08789168e-02f,
  -6.80296123e-02f, -2.08231411e-03f, -2.45354455e-02f, 1.03416406e-01f, -1.10577032e-01f, 6.23066239e-02f, -9.64489132e-02f, -3.50103453e-02f, -6.83280127e-03f, -2.77821608e-02f,
  5.89519814e-02f, -7.28120059e-02f, -6.72880337e-02f, -1.07773073e-01f, 1.25804897e-02f, -3.32465731e-02f, 6.19495399e-02f, 1.17279187e-01f, 6.78847432e-02f, 9.33356360e-02f,
  4.15001251e-02f, -1.09887727e-01f, -9.33881551e-02f, -1.10702567e-01f, -1.77771952e-02f, -1.11512266e-01f, -9.73937884e-02f, 8.82923305e-02f, -4.22946960e-02f, -1.20926604e-01f,
  -2.04724614e-02f, 5.65994196e-02f, -2.38590501e-02f, -7.43607432e-02f, 2.42066998e-02f, -6.72479998e-03f, 1.99800427e-03f, -6.73599616e-02f, 1.16963178e-01f, 6.01024106e-02f,
  1.81560908e-02f, 8.57746303e-02f, 3.13480832e-02f, 1.28001918e-03f, -5.52309901e-02f, 1.79729946e-02f, 1.13730460e-01f, 6.31014332e-02f, 6.32350221e-02f, 1.10833853e-01f,
  -6.36160895e-02f, -9.50670466e-02f, 6.33913465e-03f, -8.54449049e-02f, -4.52188402e-02f, 9.55445692e-02f, -1.43786427e-02f, 4.59563881e-02f, 6.49794936e-02f, -1.90813635e-02f,
  5.77182211e-02f, 9.50881913e-02f, -1.05810560e-01f, -5.17230481e-03f, -6.83361366e-02f, -1.15253039e-01f, -1.14325076e-01f, -1.10200271e-01f, -4.78688031e-02f, -1.54540325e-02f,
  -7.58699700e-02f, 5.58545142e-02f, -2.19663717e-02f, 3.18417475e-02f, -2.65879091e-02f, -7.95980766e-02f, -2.74798498e-02f, 2.50133332e-02f, -9.86520015e-03f, 3.33239324e-02f,
  8.02462026e-02f, -5.65892234e-02f, -4.04011048e-02f, 2.09344067e-02f, 8.91585201e-02f, -1.02365270e-01f, 6.29508570e-02f, -5.54169826e-02f, -2.47201212e-02f, 5.35800271e-02f,
  -5.75677305e-02f, -2.44800914e-02f, 5.44293225e-02f, 9.35784355e-03f, -3.53834778e-02f, -1.18149921e-01f, -1.37396287e-02f, -1.73819140e-02f, -6.12145402e-02f, 1.15455978e-01f,
  1.13755271e-01f, 1.04696877e-01f, -7.58077577e-02f, 5.28891720e-02f, -1.44670112e-02f, -1.42786771e-01f, -1.03218950e-01f, -1.82536006e-01f, -6.32594749e-02f, 2.30346415e-02f,
  -9.21390206e-02f, 8.00081119e-02f, 8.09882805e-02f, -1.96009089e-04f, 5.99776171e-02f, -9.95024890e-02f, -1.01578407e-01f, 3.89619097e-02f, 1.70846760e-01f, -4.77772169e-02f,
  1.53564706e-01f, 1.35433495e-01f, -1.63600177e-01f, -7.70991370e-02f, 3.70968580e-02f, -9.19918939e-02f, 1.17481470e-01f, -1.19158007e-01f, -1.87979266e-02f, 7.36130625e-02f,
  -4.78711389e-02f, -1.17241099e-01f, 1.22631989e-01f, -6.58035651e-02f, -5.42055145e-02f, -1.06021367e-01f, 1.09946899e-01f, -4.52187434e-02f, 2.61426549e-02f, 2.11716995e-01f,
  -1.23986743e-01f, 1.68323610e-02f, 1.31767569e-02f, -5.91063239e-02f, -5.04626483e-02f, -1.21343121e-01f, -1.01799227e-01f, 2.02140570e-01f, 1.48745310e-02f, -7.39563629e-02f,
  -4.29686010e-02f, -3.49189192e-02f, 1.01619840e-01f, -9.93380323e-02f, -5.04205413e-02f, 7.11616352e-02f, 8.40164945e-02f, -1.23867661e-01f, -3.73221599e-02f, -1.13955565e-01f,
  1.07001498e-01f, 1.27468050e-01f, -3.10362633e-02f, 2.09021941e-02f, -1.31011769e-01f, -3.58354077e-02f, -6.42383993e-02f, 8.27521086e-03f, -4.31634486e-02f, -1.07059784e-01f,
  -1.15481518e-01f, -4.31537740e-02f, 3.04557495e-02f, 1.55621078e-02f, -5.58028976e-03f, 8.18277076e-02f, -8.34115371e-02f, -6.14559799e-02f, -2.22499836e-02f, -5.19939885e-03f,
  1.15275159e-01f, 3.03598829e-02f, -1.05173357e-01f, -8.39205235e-02f, 2.20474564e-02f, -5.70621975e-02f, -4.48285714e-02f, 9.75589082e-02f, -1.22782014e-01f, 5.17002195e-02f,
  1.13803282e-01f, -3.84900272e-02f, 6.76387697e-02f, -6.79312050e-02f, 6.27292469e-02f, 5.10699563e-02f, 1.81709696e-02f, 9.91445780e-02f, -4.55169231e-02f, -4.59561385e-02f,
  1.38531297e-01f, -4.60898690e-02f, 6.90319389e-02f, -5.92402592e-02f, -5.67596629e-02f, -6.40691444e-02f, 5.83853275e-02f, 3.74732539e-02f, 2.37510391e-02f, 8.60112309e-02f,
  4.37657051e-02f, -4.30640914e-02f, -6.23138659e-02f, -1.01203941e-01f, 1.37809083e-01f, -9.64607224e-02f, -8.34619068e-03f, -4.86897081e-02f, -8.57636146e-03f, -3.69079635e-02f,
  -1.20977260e-01f, 2.01778077e-02f, -1.01334125e-01f, -1.39451930e-02f, 3.50369662e-02f, 1.26495108e-01f, 3.86746041e-02f, -1.44214369e-03f, 3.43320109e-02f, 1.34102022e-02f,
  1.54868299e-02f, 6.29456639e-02f, -1.05807241e-02f, -1.35875866e-01f, -1.02828518e-02f, 1.49889693e-01f, 5.45109855e-03f, 3.44542749e-02f, 2.01488778e-01f, -4.39803377e-02f,
  3.76418643e-02f, -7.37987310e-02f, 1.54245272e-01f, -3.87911461e-02f, -1.08904317e-01f, 5.82550056e-02f, -1.28430203e-01f, 1.10537395e-01f, -1.61465213e-01f, -1.12983957e-01f,
  8.14741030e-02f, 1.43166974e-01f, 4.17866325e-03f, -4.28026216e-03f, 1.71189774e-02f, 4.68717329e-02f, -9.58342776e-02f, 9.36983824e-02f, -5.49552664e-02f, -4.29597590e-03f,
  1.05088420e-01f, -1.98308844e-02f, -2.82286406e-02f, 6.56166533e-03f, -9.22293812e-02f, -7.52415657e-02f, -2.87480429e-02f, -2.98942588e-02f, 1.13906883e-01f, -9.47019905e-02f,
  2.04610545e-02f, 1.08077414e-01f, -4.54065427e-02f, -1.68985222e-02f, -8.93900618e-02f, -3.01243737e-02f, 2.95715556e-02f, -1.25017717e-01f, 3.78354378e-02f, 9.67522040e-02f,
  1.73836146e-02f, -6.29312098e-02f, -8.06060508e-02f, -8.93762931e-02f, 8.37547779e-02f, 4.15875614e-02f, -1.53071424e-02f, -2.15000436e-01f, 1.45606436e-02f, -2.44388487e-02f,
  8.12405795e-02f, -1.01368546e-01f, 9.73565271e-04f, -1.39634088e-01f, -1.10858660e-02f, -8.03489089e-02f, -1.09405331e-01f, 8.96722544e-03f, 6.48743436e-02f, -1.12742037e-01f,
  1.55844927e-01f, -6.09682612e-02f, -7.95591176e-02f, -1.46472931e-01f, -5.96271157e-02f, 1.05203845e-01f, -1.97073929e-02f, 6.63304701e-03f, -1.19055927e-01f, 4.78252470e-02f,
  -4.33018804e-02f, -1.17241088e-02f, -5.21903001e-02f, 8.06541890e-02f, -7.98105542e-03f, 5.25268503e-02f, 4.07603681e-02f, -1.51956603e-01f, -1.27983838e-01f, 2.74205916e-02f,
  1.08260065e-01f, -1.59197792e-01f, -4.06022295e-02f, 3.30504887e-02f, -3.16248611e-02f, -3.67155224e-02f, 2.72236168e-02f, 7.33122528e-02f, 1.44136846e-01f, -1.09221019e-01f,
  -1.08742870e-01f, 4.83912863e-02f, -9.49635729e-02f, 3.41103636e-02f, -9.83271003e-03f, 3.40751512e-03f, -8.59930832e-03f, -3.72703932e-02f, 8.56292248e-02f, 1.60750479e-01f,
  1.15906954e-01f, 2.20630422e-01f, -1.08734362e-01f, 8.38847682e-02f, 6.56859055e-02f, 9.13223159e-03f, 9.79307368e-02f, -2.42054164e-02f, -1.24186933e-01f, 2.48424225e-02f,
  -6.05526604e-02f, -5.62122017e-02f, -2.60995817e-03f, 2.14489247e-03f, 1.13599144e-01f, 1.02165379e-02f, -3.59108485e-02f, -7.24405572e-02f, -9.58948731e-02f, -4.24242467e-02f,
  -5.14772758e-02f, -1.19258322e-01f, 1.37481885e-02f, -8.71753506e-03f, -9.15305167e-02f, -1.03846639e-01f, -6.37852959e-03f, -7.74025247e-02f, -1.20789438e-01f, -3.74174081e-02f,
  1.37059120e-02f, -1.47363264e-02f, 8.18027481e-02f, -7.83201773e-03f, 7.44259432e-02f, -1.06882840e-01f, 5.14848828e-02f, -4.15390544e-03f, 5.68233244e-03f, -9.03035551e-02f,
  -9.77056175e-02f, 8.02728906e-02f, -9.01718661e-02f, 3.14671993e-02f, -1.10000134e-01f, -3.06632668e-02f, -4.62905802e-02f, -5.51338261e-03f, -2.95966528e-02f, -1.20390914e-01f,
  1.16273351e-01f, 2.97622825e-03f, 8.25195834e-02f, -1.39259240e-02f, 3.96263674e-02f, 5.43628260e-02f, 9.31523070e-02f, -2.30088830e-02f, 1.54815791e-02f, 1.18413538e-01f,
  -9.76378918e-02f, -4.94270660e-02f, 1.00685872e-01f, -9.68539268e-02f, -8.79389122e-02f, 3.19557041e-02f, 3.25516611e-02f, -9.23112035e-02f, -7.34254643e-02f, -1.68232787e-02f,
  -1.05814869e-02f, 3.91058549e-02f, 2.52809897e-02f, -4.17236201e-02f, 1.12434134e-01f, 3.53286862e-02f, -2.48773992e-02f, 6.33664103e-03f, -1.24249026e-01f, -8.94834399e-02f,
  3.49060223e-02f, -6.45615906e-02f, 7.43575394e-02f, 1.14578649e-01f, -7.62905600e-03f, 1.84485354e-02f, 1.49414122e-01f, 2.61093769e-02f, -1.12023555e-01f, -1.99776459e-02f,
  -6.89436570e-02f, 8.16292986e-02f, 1.18970871e-01f, 6.26247525e-02f, -1.10707715e-01f, 5.17516071e-03f, 1.44452006e-01f, -1.25205621e-01f, 9.26966686e-03f, -1.08378038e-01f,
  6.07186146e-02f, -2.22486611e-02f, 1.01970330e-01f, 1.60114065e-01f, 8.85148495e-02f, -5.68354204e-02f, 4.16008420e-02f, -8.96204449e-03f, 4.22444940e-02f, -1.15729600e-01f,
  7.78253302e-02f, 9.82134119e-02f, -7.89657384e-02f, -8.08124393e-02f, 7.70538747e-02f, -1.48445547e-01f, 3.73598523e-02f, -1.09646522e-01f, 3.61775234e-02f, 6.21642508e-02f,
  -6.49702772e-02f, -1.37965977e-01f, 1.06485799e-01f, 1.09039269e-01f, -1.22840405e-01f, 6.59481809e-02f, 3.06822527e-02f, 3.20396908e-02f, 4.48373146e-02f, 2.07701460e-01f,
  9.28187743e-02f, 2.24593636e-02f, 1.24187097e-01f, -6.39651418e-02f, -6.62095100e-02f, -1.07085980e-01f, -8.32952932e-02f, 2.24245666e-03f, -5.94100803e-02f, 1.02500401e-01f,
  -4.82359864e-02f, -4.34601540e-03f, 9.08591226e-02f, -9.00856927e-02f, -9.40931067e-02f, -7.88257495e-02f, 1.38518196e-02f, 4.15024012e-02f, 8.77882540e-02f, 9.94866192e-02f,
  4.27871943e-03f, 1.21858157e-01f, -4.81930387e-04f, 2.67600454e-02f, 1.18643545e-01f, 3.61185931e-02f, -9.12016779e-02f, 4.21596952e-02f, 6.47214204e-02f, 2.05068476e-02f,
  5.43956161e-02f, -1.71199441e-02f, 7.20848367e-02f, -3.58695425e-02f, 6.82875961e-02f, 6.95949569e-02f, -2.27154531e-02f, -1.15015302e-02f, -1.13913022e-01f, 1.01342425e-01f,
  9.62570310e-02f, -3.80825512e-02f, -5.04338220e-02f, -1.71740595e-02f, 1.73081271e-02f, 1.11294940e-01f, 6.29303902e-02f, -3.26646902e-02f, 4.54704128e-02f, -1.01170808e-01f,
  -8.41266960e-02f, -8.00967813e-02f, 3.57664712e-02f, -3.03049162e-02f, -4.47925963e-02f, 6.74932217e-03f, -1.82362422e-02f, -8.12742338e-02f, -6.53448105e-02f, 5.73182339e-03f,
  -5.81807382e-02f, 3.21194381e-02f, 3.24347913e-02f, -9.68436524e-03f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  8.43938068e-02f, 7.33060390e-02f, 1.99786857e-01f, 4.20643240e-02f, 3.18832546e-02f, 6.37160905e-04f, 2.24544108e-01f, -1.01807527e-01f, 4.06485759e-02f, 1.01608858e-01f,
  1.13004021e-01f, 1.69559807e-01f, -1.14314720e-01f, -2.83665862e-02f, 2.89531369e-02f, -8.50534514e-02f, -1.17218152e-01f, -3.98388058e-02f, 2.79849917e-02f, 4.98838872e-02f,
  8.20514858e-02f, -6.78289160e-02f, 1.07714012e-01f, -1.06349282e-01f, 1.24941114e-03f, -4.08028699e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  1.18763901e-01f, -8.49566385e-02f, -2.90957987e-01f, 1.91249773e-01f, -3.49308014e-01f, 9.96113271e-02f, -7.23569766e-02f, -2.46876553e-01f, -7.38493130e-02f, 1.26980901e-01f,
  4.44155224e-02f, -1.04223691e-01f, -1.11527391e-01f, 8.59326720e-02f, 1.65744692e-01f, 9.19210166e-02f, 2.48480603e-01f, -3.80678475e-01f, -2.07362011e-01f, 3.15945506e-01f,
  4.43211466e-01f, -5.46074957e-02f, 3.11964244e-01f, -2.57630020e-01f, -2.13462502e-01f, -1.58919737e-01f, -5.08687079e-01f, 3.91832203e-01f, -7.23544732e-02f, -1.31580919e-01f,
  -5.78073263e-02f, -4.01611894e-01f, -1.48494929e-01f, 4.08477455e-01f, -1.51735414e-02f, -3.17627072e-01f, 2.00149283e-01f, -2.81903863e-01f, -1.28892183e-01f, -3.22708726e-01f,
  4.78511274e-01f, 1.19005844e-01f, -4.00968254e-01f, -5.12147322e-02f, -2.29272440e-01f, 5.06803133e-02f, 1.06810272e-01f, 2.19656825e-01f, -3.98397088e-01f, 3.07482004e-01f,
  -3.87466177e-02f, -1.67173862e-01f, 4.68143076e-02f, -8.31146818e-03f, 1.94344425e-03f, -4.19579409e-02f, 1.26911299e-02f, -3.14332359e-02f, 3.64989825e-02f, -7.90413190e-03f,
  2.30059922e-01f, -4.66883928e-02f, -8.01112056e-02f, 1.64295619e-04f, -2.42612418e-03f, 4.74358439e-01f, 2.75823236e-01f, 2.58379400e-01f, 2.01391831e-01f, -1.11977153e-01f,
  -8.84255692e-02f, 1.32817710e-02f, 1.35817423e-01f, 1.00883190e-02f, -4.04485971e-01f, -1.11748017e-01f, 1.05163448e-01f, 2.11339563e-01f, 1.11944862e-01f, 1.77737847e-02f,
  8.50085169e-02f, 3.34825009e-01f, 3.40787806e-02f, 3.00403476e-01f, 2.04671383e-01f, -1.31459683e-01f, 1.70616075e-01f, 3.53419363e-01f, -4.12063628e-01f, 2.23983750e-01f,
  -5.06149650e-01f, -4.09557372e-01f, 7.73258060e-02f, 3.08493555e-01f, 4.28349793e-01f, 3.95391464e-01f, 1.34485334e-01f, -4.51607704e-01f, -4.03678447e-01f, 1.53628275e-01f,
  1.01184949e-01f, 2.48179138e-01f, 4.32758033e-01f, -6.52342662e-02f, -2.03278400e-02f, 2.30869472e-01f, 3.46230656e-01f, -7.10925981e-02f, 3.55515629e-01f, -6.41029477e-02f,
  -1.23610035e-01f, -1.38722047e-01f, -4.86251086e-01f, -5.53966939e-01f, 6.05030321e-02f, 1.21528115e-02f, 3.25531885e-02f, 6.25254214e-02f, -1.09551221e-01f, 1.70563888e-02f,
  2.78723035e-02f, -1.57894194e-01f, 1.79315642e-01f, -2.01636896e-01f, -5.22203222e-02f, 7.62405321e-02f, -1.01696616e-02f, 4.74161506e-02f, 3.27968597e-02f, -3.98093313e-01f,
  2.13003621e-01f, 1.56239763e-01f, -3.92141223e-01f, 1.04657628e-01f, 3.67914617e-01f, 1.21703602e-01f, 3.40378135e-01f, 1.82483301e-01f, -1.58728600e-01f, 9.25500691e-02f,
  -1.18592732e-01f, 1.19387053e-01f, -3.53436470e-01f, 1.58157870e-01f, 3.24882895e-01f, 1.56337380e-01f, -3.48545238e-02f, -1.13932133e-01f, -4.38323706e-01f, -1.07628033e-01f,
  -2.70513326e-01f, 2.07087159e-01f, 4.68694359e-01f, -5.50569780e-02f, 5.08957028e-01f, 3.19122434e-01f, -2.90476471e-01f, 1.61912993e-01f, 2.92500436e-01f, 3.67082000e-01f,
  -1.78497747e-01f, -2.42932290e-01f, -6.96603805e-02f, -1.61509559e-01f, -5.52446306e-01f, 1.40160665e-01f, -3.49045724e-01f, -7.55017390e-03f, -7.12093413e-02f, -3.69331911e-02f,
  4.06424135e-01f, 9.69844498e-03f, -1.94154792e-02f, -1.26809608e-02f, 3.71981226e-02f, -1.03564657e-01f, 4.80293393e-01f, -7.45562091e-02f, -4.72519137e-02f, 1.16556836e-02f,
  -3.44897178e-03f, 1.18993834e-01f, 7.96898827e-02f, 1.87316183e-02f, 3.43298353e-02f, 8.14126879e-02f, 9.65003744e-02f, -6.33253083e-02f, -2.75460538e-02f, 1.15502492e-01f,
  -1.61926925e-01f, -2.63005104e-02f, -1.55913467e-02f, -2.43168592e-01f, -1.12450294e-01f, -4.29435253e-01f, 4.09493782e-03f, -3.02154809e-01f, -1.07376195e-01f, -3.09899211e-01f,
  8.79489779e-02f, -9.78827700e-02f, -2.71936446e-01f, -2.20154092e-01f, -1.65656313e-01f, 2.06307337e-01f, -9.93676037e-02f, 1.12184986e-01f, -3.04864973e-01f, -4.86288555e-02f,
  1.62350670e-01f, 3.78658064e-02f, 9.19562280e-02f, -2.49522611e-01f, 1.84087679e-01f, -3.96572232e-01f, 7.84854293e-02f, -1.43835217e-01f, -9.72250700e-02f, -3.52894247e-01f,
  -2.62847722e-01f, -3.28567654e-01f, -2.37277269e-01f, -3.21147621e-01f, -1.00557124e-02f, 3.03968072e-01f, 1.10375784e-01f, -5.80814965e-02f, 1.24072522e-01f, -6.23067170e-02f,
  -1.31994531e-01f, -1.05169438e-01f, 5.74060917e-01f, 5.57265012e-03f, 1.73917025e-01f, -8.10791999e-02f, 2.66383179e-02f, -8.64185765e-02f, 3.21395783e-05f, 1.31694645e-01f,
  -2.41861314e-01f, -3.15520972e-01f, 5.68067245e-02f, 1.16665848e-01f, 7.39340186e-02f, -9.78038013e-02f, -1.01130888e-01f, -3.23178135e-02f, -3.88154052e-02f, -2.14120522e-01f,
  -4.52913856e-03f, -6.59990609e-02f, -1.64655358e-01f, -2.17616167e-02f, -5.06827682e-02f, -4.45610378e-03f, 3.89847904e-02f, 5.45704782e-01f, -2.18454808e-01f, 1.78959265e-01f,
  2.96670824e-01f, 3.54536861e-01f, -1.52716809e-03f, 4.96054113e-01f, 4.25512493e-02f, 4.87138815e-02f, 3.02594692e-01f, -4.50679734e-02f, 1.95814699e-01f, -4.46749255e-02f,
  3.70328039e-01f, 3.44228819e-02f, -2.30985314e-01f, 1.56842425e-01f, 6.00351095e-02f, -1.20212182e-01f, 3.41862813e-02f, -3.36330771e-01f, 2.68209670e-02f, -4.17118967e-01f,
  1.60670355e-01f, -2.09267244e-01f, 3.49372327e-02f, 1.72615901e-01f, -1.56198725e-01f, -4.34246182e-01f, -3.24047923e-01f, -4.36501712e-01f, 1.03269853e-02f, 1.59011215e-01f,
  -7.63525581e-03f, -1.69952095e-01f, 6.23139024e-01f, -1.67116240e-01f, -3.12496990e-01f, 2.23044112e-01f, 1.67100042e-01f, 2.81041283e-02f, -3.14183652e-01f, -1.53755350e-02f,
  -2.93442816e-01f, 5.25484234e-03f, 8.65859985e-02f, 4.27241959e-02f, 3.24163407e-01f, 4.02906716e-01f, 6.04058281e-02f, -1.80608422e-01f, -5.57297617e-02f, 1.28120050e-01f,
  -2.79044621e-02f, 5.26371133e-03f, -3.00772600e-02f, -1.14550054e-01f, -9.57171470e-02f, -2.89443061e-02f, -1.98001564e-01f, 6.50646538e-02f, -1.36209548e-01f, 5.85161597e-02f,
  1.02015436e-01f, 4.60891485e-01f, 5.94478995e-02f, 2.81678796e-01f, 3.45670581e-01f, 1.21683039e-01f, 4.59375769e-01f, 4.83406484e-01f, 3.59579533e-01f, -1.83267407e-02f,
  1.62892535e-01f, 3.07076871e-01f, 1.28941491e-01f, 1.19459569e-01f, 3.54072869e-01f, 3.96305442e-01f, 2.22212151e-01f, 2.04898730e-01f, 2.90905554e-02f, 1.12123221e-01f,
  3.00593171e-02f, -3.80943090e-01f, -1.67672679e-01f, 2.08337888e-01f, -9.28717628e-02f, 4.02998000e-01f, -2.94662356e-01f, -5.20208068e-02f, -2.40578964e-01f, 3.76205325e-01f,
  1.79611027e-01f, 3.05129409e-01f, -2.00314075e-01f, -2.68562257e-01f, -4.73844297e-02f, -2.50429213e-01f, 4.00041282e-01f, 2.23008499e-01f, -3.52276862e-01f, -3.97131413e-01f,
  3.61745685e-01f, -9.21373814e-02f, 2.83554167e-01f, 6.78400472e-02f, 6.08019391e-03f, 7.90130813e-03f, -8.47392455e-02f, -2.24556914e-03f, -2.72943359e-02f, 2.81493247e-01f,
  -1.23667546e-01f, -1.57549623e-02f, -1.57470495e-01f, -3.28155607e-02f, -1.02646492e-01f, -1.71400428e-01f, -8.71584192e-02f, -4.66853045e-02f, -5.10765985e-02f, -1.15466796e-01f,
  4.52979319e-02f, 9.28745493e-02f, 7.68468156e-02f, 1.28914211e-02f, -1.50261387e-01f, -1.81123376e-01f, -2.10127845e-01f, -3.81997705e-01f, -4.53753829e-01f, -1.48016483e-01f,
  1.41228348e-01f, -8.84116162e-03f, -2.16616139e-01f, 4.36028019e-02f, -2.71904677e-01f, -1.04908437e-01f, -4.99070883e-01f, -1.02295071e-01f, -1.50218368e-01f, 4.00156528e-02f,
  -2.96912670e-01f, -5.12236297e-01f, 2.34459247e-02f, -3.50821875e-02f, 1.18806422e-01f, 2.13519484e-01f, 1.32574037e-01f, -1.70410559e-01f, 2.19129920e-01f, -1.67451039e-01f,
  -3.48353721e-02f, 3.66373003e-01f, 4.11425740e-01f, 6.68985620e-02f, 2.41176173e-01f, -6.03321753e-02f, -1.70137808e-01f, 2.62613147e-01f, 5.78874871e-02f, 4.23792273e-01f,
  2.23746859e-02f, 9.23724994e-02f, 5.28581776e-02f, 2.72240132e-01f, -6.23996556e-01f, -9.14971679e-02f, -2.72780415e-02f, -8.58442187e-02f, 1.42220957e-02f, 6.74783215e-02f,
  -5.71179725e-02f, -1.47319824e-01f, 1.98225513e-01f, 2.13045135e-01f, -6.15081787e-02f, 7.59913847e-02f, 7.56136253e-02f, 7.78393894e-02f, -1.50977529e-03f, -4.62298356e-02f,
  1.20356619e-01f, 1.51361734e-01f, -4.10241261e-02f, 8.02752748e-02f, 2.86076158e-01f, 7.30472524e-03f, -9.62430984e-02f, -5.66876791e-02f, -1.29043490e-01f, 1.69987604e-01f,
  6.60935491e-02f, -9.63059962e-02f, 1.26015499e-01f, 1.15837805e-01f, -4.73734558e-01f, -2.85767823e-01f, -2.19793096e-01f, -2.79006332e-01f, 1.78585872e-01f, -1.81647092e-01f,
  1.52320281e-01f, -1.69125631e-01f, -1.64381325e-01f, -1.39911950e-01f, -8.08425471e-02f, -1.12381279e-02f, -4.49530520e-02f, -4.58805971e-02f, -4.37665731e-01f, 3.48247796e-01f,
  -2.26006940e-01f, -1.43201768e-01f, -2.91977257e-01f, -2.29889695e-02f, 1.31782681e-01f, -6.97288513e-02f, 2.29289740e-01f, -3.76114547e-01f, -1.24486983e-01f, -1.03303552e-01f,
  1.40420213e-01f, -9.14495066e-02f, 1.44544408e-01f, 4.55055326e-01f, -3.78921390e-01f, -1.82176679e-01f, 3.98137063e-01f, -1.94321163e-02f, 1.75977126e-02f, 1.47935720e-02f,
  -3.66868466e-01f, -5.66714443e-03f, -3.60025227e-01f, -1.29675232e-02f, -6.44033849e-02f, 2.60730714e-01f, -1.68900073e-01f, 3.52962434e-01f, 1.26065910e-01f, 2.22509131e-02f,
  -3.69741283e-02f, -8.26536790e-02f, -4.71871272e-02f, 6.23524338e-02f, -3.18156858e-03f, -4.34040576e-02f, 1.08823478e-01f, -6.34270236e-02f, 1.91669226e-01f, -1.00423805e-01f,
  2.23291636e-01f, 9.09795612e-02f, 1.99079309e-02f, -1.40578434e-01f, 1.63515493e-01f, -1.11943357e-01f, -5.56156754e-01f, 1.11991189e-01f, 6.10736124e-02f, -3.53675708e-02f,
  -2.07534745e-01f, -3.81399244e-02f, -2.70152658e-01f, -1.80728361e-01f, -3.81385237e-01f, -2.40385104e-02f, -3.98585469e-01f, 7.39320442e-02f, 1.07196039e-02f, -3.84848639e-02f,
  -6.27226308e-02f, -1.63475275e-01f, -3.23379517e-01f, 3.16502690e-01f, -1.68252289e-01f, 4.77811284e-02f, 1.68583006e-01f, 3.67146105e-01f, 2.90120721e-01f, -3.71732235e-01f,
  -2.44186327e-01f, -1.28353268e-01f, 2.67610222e-01f, 1.61027297e-01f, 4.28074077e-02f, -3.84412669e-02f, -7.41546899e-02f, 2.90356219e-01f, -4.48154211e-01f, -1.25478320e-02f,
  3.93123031e-01f, -1.76274598e-01f, -6.26294911e-01f, 5.60107678e-02f, 2.94393748e-01f, -7.55628422e-02f, 5.56618392e-01f, -8.79439265e-02f, -1.00871464e-02f, -1.36323394e-02f,
  -2.06920266e-01f, -4.47594285e-01f, -1.08685002e-01f, 2.28247009e-02f, 1.03314035e-01f, 1.23713702e-01f, -5.30412979e-02f, 1.72791108e-01f, -5.91880307e-02f, 1.64734237e-02f,
  -1.11156881e-01f, -1.10333338e-01f, -4.94947135e-02f, -9.92395729e-03f, 1.45998240e-01f, 8.67893845e-02f, -1.28109455e-01f, -5.69785357e-01f, 9.17048827e-02f, -1.48761302e-01f,
  2.44264498e-01f, -1.52474359e-01f, -1.88611224e-01f, -5.94955385e-02f, -2.95546412e-01f, 1.70683533e-01f, 7.34277591e-02f, 1.19090319e-01f, 3.37395482e-02f, -9.45550203e-02f,
  -3.39982688e-01f, 9.85335279e-03f, 2.00775594e-01f, -1.52336970e-01f, 1.83383495e-01f, 8.43933448e-02f, -4.82644886e-02f, 3.31856847e-01f, -2.24424705e-01f, 3.67244989e-01f,
  3.42434973e-01f, -3.72196853e-01f, 1.13380134e-01f, 4.24660966e-02f, 2.65703291e-01f, 3.00675303e-01f, -1.59170687e-01f, 4.31205928e-01f, 9.82805192e-02f, 2.28624623e-02f,
  1.75173339e-02f, 1.44764826e-01f, -4.52264309e-01f, -2.12943047e-01f, -3.04674864e-01f, 3.93854350e-01f, -1.66856259e-01f, -6.23136386e-02f, -5.80134869e-01f, 5.29366210e-02f,
  -3.08031917e-01f, -6.45980015e-02f, -6.05129972e-02f, 7.49775171e-02f, 4.23394293e-01f, 2.94311613e-01f, 7.21734837e-02f, -2.30776370e-01f, -1.61867552e-02f, 6.34371266e-02f,
  1.02113567e-01f, 7.79999569e-02f, 2.15738062e-02f, 2.15429574e-01f, 5.80622628e-03f, -5.32647260e-02f, -1.19647577e-01f, 6.71573281e-02f, 6.57749027e-02f, -5.18318564e-02f,
  -8.14178661e-02f, -1.67553023e-01f, -3.64618480e-01f, -2.80153096e-01f, 9.15281624e-02f, -1.38083354e-01f, -2.82678870e-03f, -4.71295714e-01f, -4.30701375e-01f, -3.71221155e-01f,
  1.59746230e-01f, 2.83934712e-01f, 1.73930705e-01f, 1.15370959e-01f, 2.91692853e-01f, -2.04365149e-01f, -1.02265105e-01f, -5.52755706e-02f, 3.51944976e-02f, -1.37610361e-01f,
  3.59268665e-01f, -1.41455069e-01f, 4.91826087e-01f, 1.37454569e-01f, -1.98803857e-01f, 4.50986177e-01f, -2.07986891e-01f, -2.43661866e-01f, -1.98238939e-01f, 2.47358352e-01f,
  1.61380574e-01f, -2.17736453e-01f, 3.31917435e-01f, 3.17210525e-01f, -2.83493102e-01f, -3.42538267e-01f, 3.95459682e-01f, 6.29054606e-02f, 1.37489550e-02f, -2.04290031e-03f,
  -2.16437429e-01f, -6.13885336e-02f, 3.13559890e-01f, -5.31301834e-02f, 5.32069385e-01f, 7.84979016e-02f, -7.45093897e-02f, -1.27330035e-01f, -3.36152673e-01f, -5.17576158e-01f,
  -6.14399426e-02f, 1.83268711e-01f, 7.61461928e-02f, -8.07472989e-02f, 8.69666636e-02f, -9.85925179e-03f, 1.08813427e-01f, -1.16526328e-01f, -5.84987737e-02f, 3.09175730e-01f,
  3.34418565e-02f, 8.11390858e-03f, 1.08963318e-01f, 1.10587783e-01f, 2.21394375e-02f, 3.75455111e-01f, 3.34588617e-01f, 3.26945841e-01f, 1.36132479e-01f, 5.43787051e-03f,
  3.06431092e-02f, 1.80036515e-01f, 9.46607143e-02f, 2.71920741e-01f, 3.02852333e-01f, -1.81509793e-01f, 1.72140092e-01f, -3.04208219e-01f, -2.16129981e-02f, -7.59730041e-02f,
  3.57223630e-01f, 5.56552947e-01f, 7.67392442e-02f, -1.22699827e-01f, 3.07923406e-02f, 3.59727234e-01f, 4.70798798e-02f, 3.90146911e-01f, -2.49194890e-01f, -4.46991086e-01f,
  5.51730275e-01f, 2.68647790e-01f, 2.96771854e-01f, 1.64684266e-01f, -3.94248933e-01f, -1.30216151e-01f, -1.36703297e-01f, -4.19116288e-01f, 3.50802928e-01f, -6.40774593e-02f,
  -2.55918596e-02f, 3.60861905e-02f, -7.16700451e-03f, 1.18004322e-01f, 2.43721247e-01f, -1.08413301e-01f, 1.03326574e-01f, -1.01841807e-01f, 8.41015577e-02f, 1.98435672e-02f,
  3.65558043e-02f, -4.77041081e-02f, -3.28177251e-02f, -1.76246222e-02f, 4.55206297e-02f, 3.59356731e-01f, 9.17038321e-02f, 8.36204663e-02f, 7.51431957e-02f, 8.03446844e-02f,
  -9.71931070e-02f, -3.01773787e-01f, 5.61826825e-02f, 1.13006249e-01f, 3.35745551e-02f, -5.81189767e-02f, 2.32719526e-01f, 8.11326802e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -7.83624575e-02f, 8.76763016e-02f, -4.96573448e-02f, -2.24594539e-03f, 3.11476979e-02f, -5.20804711e-03f, 2.43373122e-02f, -1.19772144e-02f, 7.45566264e-02f, 1.20513896e-02f,
  -2.20648758e-02f, -7.34199136e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    