/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.42556286e-01f, -2.34608456e-01f, -3.71910539e-03f, -1.39258653e-01f, 3.41672450e-02f, 2.05712318e-01f, 2.58458674e-01f, 1.35419831e-01f, -1.13143198e-01f, 1.74986031e-02f,
  -9.44813192e-02f, -7.45138004e-02f, -1.13684297e-01f, -4.40443605e-02f, 6.48949370e-02f, -4.48454916e-02f, -4.54441421e-02f, -3.64725180e-02f, 3.16831201e-01f, 3.68513167e-01f,
  2.57159591e-01f, 1.75484866e-02f, 4.45879325e-02f, 1.34716034e-01f, -8.23867768e-02f, -9.66105387e-02f, -7.45264664e-02f, -2.22464278e-01f, -1.16870090e-01f, -3.12452734e-01f,
  -1.26577944e-01f, -2.59043485e-01f, 1.28469810e-01f, -9.81066152e-02f, -4.31155525e-02f, -5.85301667e-02f, 6.24572597e-02f, -1.05526328e-01f, -5.04703224e-02f, -1.56663842e-02f,
  -4.63343598e-02f, 5.33745550e-02f, -3.93000804e-02f, 1.32276654e-01f, 2.92347632e-02f, 8.97614211e-02f, 2.46759336e-02f, 4.18525673e-02f, 6.52341731e-03f, 2.82566389e-03f,
  1.14900872e-01f, -1.65992379e-02f, -3.59250717e-02f, 7.43918214e-03f, 1.31101860e-02f, 7.57859573e-02f, 7.71733001e-02f, 4.65269126e-02f, -8.47141631e-03f, -7.26973042e-02f,
  1.29542172e-01f, -5.20864278e-02f, -3.79402228e-02f, 2.33836770e-02f, 1.33012712e-01f, -3.85369956e-02f, -9.31924284e-02f, -5.35423867e-02f, 1.13373466e-01f, 5.83057571e-03f,
  3.29024345e-02f, 1.45013571e-01f, -2.51411833e-02f, -2.28482913e-02f, 7.45357797e-02f, -6.97030127e-03f, 2.01363582e-02f, 3.83568890e-02f, 2.31926870e-02f, 8.12724605e-02f,
  -2.70337258e-02f, -1.12924285e-01f, -1.89897679e-02f, -3.86193059e-02f, -2.14380734e-02f, -8.92355107e-03f, 4.74562533e-02f, 8.37762728e-02f, 3.57181579e-02f, 1.11242190e-01f,
  -6.03012741e-02f, -1.50800318e-01f, -1.00003421e-01f, 3.84795517e-02f, -1.19928911e-01f, -1.09049737e-01f, 4.64887060e-02f, 6.53561130e-02f, -9.91176963e-02f, 1.06381672e-02f,
  1.20198606e-02f, -5.65922912e-03f, 6.25133142e-03f, 3.43951620e-02f, 5.30658513e-02f, 1.35957468e-02f, 1.85307220e-03f, -2.93460693e-02f, -4.37451303e-02f, 6.26847371e-02f,
  4.83345650e-02f, -2.96789408e-02f, -2.16323197e-01f, -6.42378405e-02f, -1.45549566e-01f, -6.49261177e-02f, 6.20542327e-03f, -2.27985363e-02f, -2.02227775e-02f, -5.94742363e-03f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.35221815e-01f, 4.87948567e-01f, 4.60448235e-01f, -5.25895894e-01f, 1.56858385e-01f, 3.55475724e-01f, 6.20660067e-01f, 1.37526348e-01f, -4.29629833e-01f, 2.17884481e-01f,
  3.83171201e-01f, -4.81905609e-01f, -2.20933169e-01f, -1.04380451e-01f, 1.19726151e-01f, 1.64213702e-01f, -9.47999656e-02f, -4.03924108e-01f, -2.55349606e-01f, -6.06166944e-02f,
  -2.65586287e-01f, -2.61325240e-01f, -4.50766653e-01f, -3.33474725e-01f, -6.00008965e-02f, -3.53088439e-01f, 1.31288379e-01f, 4.09456268e-02f, 3.18034053e-01f, -2.08081782e-01f,
  4.26829129e-01f, 2.48608872e-01f, -2.07856491e-01f, -1.41786173e-01f, 1.08240038e-01f, -4.37697507e-02f, -1.12731932e-02f, -7.18150511e-02f, 8.69741570e-03f, 4.25038114e-03f,
  2.27648504e-02f, 5.39301969e-02f, -5.49215637e-03f, 4.32412140e-02f, 1.01547139e-02f, 1.23416334e-01f, 4.08280604e-02f, -1.21921480e-01f, 2.80783121e-02f, 1.90007165e-01f,
  -1.96679085e-02f, 2.31326118e-01f, 2.06510752e-01f, 1.89181432e-01f, 2.35717714e-01f, -1.07171364e-01f, 4.30052757e-01f, 1.24011897e-01f, 2.61875451e-01f, -1.43861353e-01f,
  -1.09788969e-01f, 4.59659398e-02f, 1.62937596e-01f, -4.71403524e-02f, 2.82301623e-02f, -4.30577174e-02f, -7.01896250e-02f, 1.69127844e-02f, 1.03994086e-02f, -3.09000090e-02f,
  -3.91263934e-03f, 3.68367806e-02f, 1.30905816e-02f, -3.72589938e-02f, -2.07788311e-02f, 3.88831235e-02f, 6.47288039e-02f, -3.54284160e-02f, 1.25123471e-01f, 4.21810858e-02f,
  -3.20550911e-02f, 1.12292551e-01f, -1.73738934e-02f, -1.18471710e-02f, 7.15389326e-02f, -1.44053837e-02f, -2.99032836e-04f, 1.34463578e-01f, 4.57018008e-03f, -6.25380203e-02f,
  -2.77739257e-01f, 2.00428769e-01f, -2.79614449e-01f, 1.49549499e-01f, 4.75593656e-02f, -7.87201375e-02f, -9.52062607e-02f, -6.93748370e-02f, -1.09582908e-01f, -7.05328584e-02f,
  4.96573150e-02f, -1.44753501e-01f, 6.72528818e-02f, -7.04378029e-03f, -2.03066707e-01f, -1.51017150e-02f, 2.26913858e-02f, -1.12169899e-01f, -6.96809124e-03f, -6.82654008e-02f,
  4.73975530e-03f, -1.46774232e-01f, -3.13097715e-01f, -1.41533449e-01f, -1.39169231e-01f, -2.44259849e-01f, 5.47466315e-02f, -4.56618890e-02f, 1.75894722e-01f, 2.93356483e-03f,
  -4.35254931e-01f, -7.91804016e-01f, -2.33202696e-01f, -4.36288297e-01f, -4.17102695e-01f, -2.33485252e-01f, -4.52810228e-01f, -1.35631077e-02f, -1.22909129e-01f, -5.94983637e-01f,
  -2.61852473e-01f, 1.91380933e-01f, 5.41725196e-02f, 1.42393202e-01f, 2.23310918e-01f, -4.79935467e-01f, -4.08011019e-01f, 1.43192798e-01f, 6.77030742e-01f, 2.46615812e-01f,
  -1.92394897e-01f, -6.45293370e-02f, 1.76533490e-01f, 9.80002210e-02f, -6.03740990e-01f, -1.23904951e-01f, -5.21039307e-01f, -3.94634932e-01f, -3.48077834e-01f, -8.49428117e-01f,
  -3.14612746e-01f, 5.52070625e-02f, 1.50501624e-01f, 4.12563793e-03f, -2.23644495e-01f, 2.92979032e-02f, -8.21373090e-02f, 3.84678356e-02f, -4.87262011e-02f, 2.24717171e-03f,
  -8.84843171e-02f, 1.30645096e-01f, 2.05968007e-01f, 3.85337956e-02f, -2.25969285e-01f, -2.20018309e-02f, 1.69609170e-02f, 4.23208065e-02f, -3.78205515e-02f, -7.30423769e-03f,
  -1.56925619e-01f, -1.39228106e-01f, -1.19847548e-03f, -1.23808924e-02f, 2.54329085e-01f, 2.47834459e-01f, -6.33893535e-02f, -1.89255476e-02f, 2.03492939e-02f, -5.91930807e-01f,
  -9.79931131e-02f, 7.52750710e-02f, 5.41646145e-02f, 9.44035798e-02f, 3.09358397e-03f, 1.47578004e-03f, 1.86602455e-02f, 4.69702156e-03f, 5.10068890e-03f, 3.38159613e-02f,
  -7.48963002e-03f, -8.52606352e-03f, 1.03633858e-01f, -6.50555864e-02f, -1.41743883e-01f, -4.49697748e-02f, 4.22407128e-02f, -1.38585623e-02f, 6.93436936e-02f, 2.83161383e-02f,
  2.82108755e-04f, 6.97036786e-03f, -1.08146749e-01f, 1.43719882e-01f, -1.55940354e-01f, 3.85422334e-02f, 9.60734580e-03f, 6.58311993e-02f, 9.23809223e-03f, 6.00214377e-02f,
  -1.04721926e-01f, 2.03443855e-01f, -2.54836321e-01f, 1.06982522e-01f, -2.15675998e-02f, -5.53595275e-02f, -1.12945363e-01f, 1.26974598e-01f, 2.06217244e-02f, -8.68389308e-02f,
  -7.83674419e-02f, -3.99225540e-02f, -8.12664852e-02f, -8.19072723e-02f, 1.03870973e-01f, -5.98451644e-02f, -2.51199037e-01f, -3.14690173e-02f, 2.16902364e-02f, 8.69869720e-03f,
  -1.42414212e-01f, 1.29170433e-01f, -7.18144178e-02f, -2.38476843e-02f, -1.27750397e-01f, 1.01827472e-01f, -7.80199170e-02f, -3.62979472e-02f, 1.28050536e-01f, -5.13332725e-01f,
  1.00787652e+00f, -2.21543312e-01f, -2.23310441e-01f, 2.01582298e-01f, -1.90266848e-01f, -2.69598681e-02f, -1.85282618e-01f, -9.31873918e-03f, 2.69064814e-01f, 3.79643291e-02f,
  3.68201047e-01f, 5.77981353e-01f, 4.62213576e-01f, 3.84088695e-01f, 3.56105804e-01f, -1.07204922e-01f, -1.52278468e-01f, 8.74472931e-02f, 1.74522489e-01f, 4.30441089e-02f,
  -1.57306731e-01f, -1.56233788e-01f, 2.26295330e-02f, -3.84382159e-02f, -4.06557590e-01f, 1.61176592e-01f, 9.08736314e-04f, -7.30059519e-02f, 6.84192113e-04f, -1.97036132e-01f,
  -6.87826648e-02f, 1.21044330e-01f, 2.62674809e-01f, 2.30070099e-01f, -2.30801493e-01f, 1.92052592e-03f, 1.78191453e-01f, 1.86197478e-02f, -5.35284281e-02f, -1.51010931e-01f,
  1.63547233e-01f, -4.55457829e-02f, 1.29000098e-01f, -1.52841195e-01f, -1.26190469e-01f, -9.78635773e-02f, -2.09963739e-01f, 7.15887621e-02f, 5.67766465e-02f, -6.38353676e-02f,
  -2.26288244e-01f, 3.61312069e-02f, 6.85729831e-02f, 5.73911853e-02f, 1.31768748e-01f, 6.63847327e-02f, -3.20750847e-02f, 1.65187698e-02f, 1.17028035e-01f, 7.86968991e-02f,
  -9.94887650e-02f, -1.82854235e-01f, 1.48758637e-02f, 5.82166612e-02f, 6.93143755e-02f, 4.30903882e-02f, -1.93020180e-02f, -5.46558127e-02f, 8.43056962e-02f, -1.06448263e-01f,
  6.14685416e-02f, 5.96877672e-02f, 5.60558261e-03f, 1.03784747e-01f, 7.02908030e-03f, -1.16196200e-01f, -1.20986745e-01f, -4.91602160e-02f, 7.04223141e-02f, 7.88436756e-02f,
  9.50456932e-02f, 1.27692828e-02f, -1.83589645e-02f, -8.39165449e-02f, 6.30374327e-02f, 4.05225381e-02f, 7.00805560e-02f, 6.27340004e-02f, -5.76887317e-02f, -1.12487786e-01f,
  3.38076174e-01f, 5.85728168e-01f, 1.42787799e-01f, 6.54405653e-02f, -3.24382558e-02f, -2.53473409e-02f, 1.47624865e-01f, 5.50054722e-02f, -1.69866458e-01f, -2.72573961e-04f,
  3.95607986e-02f, 1.35390824e-02f, -1.44484481e-02f, -1.22538581e-01f, 1.26898428e-02f, 1.60597518e-01f, -6.69205328e-03f, 1.86754391e-01f, 6.78587705e-02f, -2.12576210e-01f,
  -2.78662890e-01f, 1.56663150e-01f, 4.17423278e-01f, 1.81367263e-01f, 1.22078575e-01f, 3.56430918e-01f, -2.75331493e-02f, -4.60967831e-02f, 2.58516043e-01f, -9.20725167e-02f,
  -3.51051897e-01f, -1.33876517e-01f, -2.13622838e-01f, 2.01644704e-01f, 2.93816835e-01f, 3.55686471e-02f, -6.30116686e-02f, -8.56712535e-02f, 1.33738562e-01f, 1.01270038e-03f,
  1.62074521e-01f, 1.69418797e-01f, 7.30559155e-02f, 1.55801386e-01f, 1.04170993e-01f, 1.87457770e-01f, 2.93186545e-01f, 6.99865865e-03f, -8.61898363e-02f, 5.01469299e-02f,
  1.42934948e-01f, -2.39304498e-01f, -3.48284900e-01f, -9.62312892e-03f, 2.67623842e-01f, 1.31045848e-01f, 8.38837475e-02f, 1.88775316e-01f, 1.34886786e-01f, 4.49424028e-01f,
  7.46209687e-03f, 2.70255562e-02f, 2.80772686e-01f, 2.20055595e-01f, 3.90656404e-02f, -1.27441525e-01f, -1.43443510e-01f, -2.11117893e-01f, -6.89248145e-02f, -1.86604351e-01f,
  2.54316390e-01f, 1.40956715e-02f, -8.56448635e-02f, -1.10232294e-01f, -2.15329118e-02f, 6.88574091e-02f, 7.16917682e-03f, 7.63215348e-02f, 4.70615029e-02f, -1.88877527e-02f,
  1.75278470e-01f, 1.62617624e-01f, 1.06725730e-01f, 3.77011672e-02f, 4.12027761e-02f, 4.39021349e-01f, 2.58714676e-01f, 2.09529117e-01f, 1.49909273e-01f, 7.06590861e-02f,
  2.64217973e-01f, -1.67199552e-01f, 6.03517443e-02f, 5.52737266e-02f, -1.30533474e-02f, -1.87860101e-01f, -1.53323740e-01f, -2.43813153e-02f, 1.53050020e-01f, -2.15664972e-02f,
  6.88279420e-02f, 4.83638868e-02f, -4.34984751e-02f, 7.87694752e-03f, 3.01602092e-02f, -4.47086804e-02f, 2.69492213e-02f, 9.40445065e-02f, 1.96660802e-01f, -7.57984668e-02f,
  1.77923039e-01f, -9.11676958e-02f, 1.35380207e-02f, -1.04441773e-02f, -2.80382927e-03f, 1.12246737e-01f, 1.08251072e-01f, 1.40393734e-01f, 6.21582456e-02f, 4.22423519e-02f,
  -1.34761333e-01f, 1.55326754e-01f, 1.12882167e-01f, 5.91378808e-02f, 1.39687076e-01f, 1.88776366e-02f, 3.99948936e-03f, -1.59715638e-02f, 4.15577926e-02f, -3.47468890e-02f,
  1.53004527e-01f, -1.33035462e-02f, -8.42358246e-02f, -9.64696333e-02f, -1.46581054e-01f, 2.47271694e-02f, 6.20198511e-02f, -7.86783397e-02f, 1.43883720e-01f, 1.82040498e-01f,
  1.10759079e-01f, 1.61711410e-01f, 7.58097693e-02f, -2.69639082e-02f, 1.89825729e-01f, 2.21125826e-01f, 1.44172031e-02f, 2.82116741e-01f, 1.66723520e-01f, -1.81317069e-02f,
  -1.01101875e+00f, -5.31104267e-01f, 7.63479471e-02f, -1.54790357e-01f, 3.29822570e-01f, -1.39141932e-01f, -5.01715839e-01f, -4.47553396e-01f, 1.18968235e-02f, -1.70426637e-01f,
  4.30728532e-02f, 2.64892131e-01f, 2.17556879e-01f, 1.31980404e-01f, -2.55680025e-01f, 3.91125167e-03f, 5.21225095e-01f, 2.34558508e-01f, -6.71200156e-02f, -1.88503340e-01f,
  1.30775869e-01f, -2.54917499e-02f, -2.59911716e-01f, 7.04310462e-02f, 6.25815243e-02f, 7.46318027e-02f, 1.13199405e-01f, 7.34207481e-02f, 2.96284282e-03f, 2.57684380e-01f,
  -1.43296793e-01f, -6.27677679e-01f, 2.85820991e-01f, 5.50549664e-02f, 1.13347538e-01f, -1.88803628e-01f, -2.54753739e-01f, 1.01152815e-01f, 1.18506499e-01f, 3.25474106e-02f,
  4.78115166e-03f, -1.18118584e-01f, 5.20424247e-02f, 6.35649934e-02f, -2.50977892e-02f, -1.33258894e-01f, 9.05178711e-02f, 1.53345224e-02f, 4.46580537e-02f, -1.23442888e-01f,
  3.07837397e-01f, -9.53030493e-03f, -3.09623033e-01f, -2.58623194e-02f, -4.71245721e-02f, 2.02171281e-01f, -2.45146811e-01f, -2.66704500e-01f, -1.67819172e-01f, -3.37627590e-01f,
  1.67290255e-01f, 5.65229394e-02f, -6.03476129e-02f, 3.11731137e-02f, 1.50505397e-02f, 5.08793741e-02f, 1.28339961e-01f, 2.76411455e-02f, 7.06515163e-02f, 5.04262652e-03f,
  6.53921068e-02f, 1.05950490e-01f, -4.78583295e-03f, -1.29468609e-02f, 6.53583556e-02f, 5.26406942e-03f, 2.59982068e-02f, -4.92141284e-02f, 9.73559022e-02f, 2.64386442e-02f,
  1.33032873e-01f, -1.64434221e-02f, 1.52260847e-02f, 3.67351584e-02f, -3.84749696e-02f, -2.17377581e-02f, 1.59952622e-02f, 1.96624864e-02f, -1.31262839e-01f, -1.39994949e-01f,
  -1.35276213e-01f, 3.99845302e-01f, -3.23212259e-02f, -2.64488496e-02f, -1.07078128e-01f, 1.87736273e-01f, 9.50341150e-02f, 3.88866030e-02f, -1.41355366e-01f, -1.83895081e-01f,
  -2.26494849e-01f, -4.84789498e-02f, -1.01179980e-01f, 1.30753785e-01f, -3.87599738e-03f, -1.18501060e-01f, 1.29777016e-02f, 6.07910268e-02f, 1.91660970e-02f, -1.19830139e-01f,
  1.06583335e-01f, -2.12190062e-01f, -3.18706930e-01f, -1.16276011e-01f, -2.22296402e-01f, -2.91435331e-01f, -1.55243114e-01f, -1.96624801e-01f, -3.34868729e-01f, -4.62395668e-01f,
  -2.55471796e-01f, 4.10342574e-01f, 1.41073391e-01f, 1.18995875e-01f, 5.01962841e-01f, -1.99401565e-02f, -3.41711380e-02f, -3.25155854e-01f, -1.52760997e-01f, 2.41973162e-01f,
  4.12894219e-01f, 3.26275416e-02f, 3.74783538e-02f, -1.54651150e-01f, -4.44290280e-01f, -5.66097572e-02f, 8.90013501e-02f, -1.50277317e-01f, -5.83719134e-01f, -2.78717160e-01f,
  1.54716685e-01f, 1.52100651e-02f, -2.81377763e-01f, -3.00351530e-01f, 2.52774626e-01f, -1.28485367e-01f, -7.59079261e-03f, 1.99251369e-01f, 1.50541589e-01f, 5.87322414e-01f,
  2.09118932e-01f, 9.11539942e-02f, -2.18073159e-01f, 1.67852058e-03f, 3.37131590e-01f, -4.38959636e-02f, -8.68070275e-02f, 3.78495604e-02f, -3.36800213e-03f, 6.06951676e-02f,
  3.08936864e-01f, 1.07242979e-01f, 2.18538985e-01f, -1.22042932e-02f, -1.81298647e-02f, -1.87174439e-01f, -1.75612986e-01f, -2.57838398e-01f, -2.60697275e-01f, -1.76756959e-02f,
  2.95204401e-01f, 2.17500478e-01f, 5.39244227e-02f, -2.94503450e-01f, -3.06115329e-01f, 9.07958150e-02f, 3.65666971e-02f, -7.19141737e-02f, -4.16638315e-01f, -9.69644934e-02f,
  -1.13689721e-01f, 6.98247254e-02f, 4.59650867e-02f, 1.34583145e-01f, -1.35242892e-02f, 7.04337582e-02f, 3.91782671e-02f, -5.33328988e-02f, -8.05810988e-02f, -4.32055555e-02f,
  3.71478498e-02f, 9.22181178e-03f, -6.19940180e-03f, -9.36776921e-02f, -5.36954887e-02f, 8.32858458e-02f, -6.38160929e-02f, -7.28707686e-02f, -1.20975621e-01f, 2.28595771e-02f,
  -6.87582493e-02f, 7.18244836e-02f, -2.32150108e-02f, -9.64345690e-03f, -6.66106269e-02f, -2.25754291e-01f, 1.16264760e-01f, 1.29623294e-01f, 3.16827558e-02f, 2.13971257e-01f,
  -2.31708318e-01f, -2.05846786e-01f, 1.53054059e-01f, -1.56486243e-01f, -9.87766087e-02f, -5.84611259e-02f, 1.28127590e-01f, -8.29822049e-02f, 5.02331834e-03f, -1.05103157e-01f,
  -1.06308758e-02f, -2.34528184e-02f, 5.89273795e-02f, -4.95544076e-02f, -3.25209908e-02f, -1.04260147e-02f, 3.22153866e-02f, 4.02185246e-02f, -3.07591558e-01f, -2.47944724e-02f,
  3.75211984e-02f, -2.32593670e-01f, -2.64469951e-01f, -3.55844162e-02f, -7.17328787e-02f, -1.83792517e-01f, -1.27539217e-01f, -2.42052883e-01f, -3.68533939e-01f, -3.07305962e-01f,
  6.54235423e-01f, 3.30708414e-01f, 6.88253939e-02f, 2.39624560e-01f, -1.25143796e-01f, 1.95088889e-02f, 3.40700418e-01f, 3.71854603e-01f, 1.86138928e-01f, 3.38327229e-01f,
  -2.22557858e-01f, -4.37336534e-01f, -2.58672535e-01f, -2.30392978e-01f, 5.82205243e-02f, 3.60852182e-01f, 1.97105438e-01f, 6.35271445e-02f, 9.90574807e-02f, 1.86212987e-01f,
  1.55057330e-02f, 3.09768677e-01f, 5.04988670e-01f, 1.65136397e-01f, -8.07822123e-03f, -2.88147062e-01f, 1.41681239e-01f, 6.21859133e-02f, -7.34867826e-02f, -1.85306147e-01f,
  -3.97663295e-01f, 2.57747144e-01f, -2.68280923e-01f, -1.15528226e-01f, -1.17612116e-01f, 2.66178772e-02f, -4.80410457e-03f, 1.73047110e-01f, 9.16642025e-02f, 1.89430356e-01f,
  -1.25955850e-01f, 2.09023744e-01f, -6.83360845e-02f, 9.87725109e-02f, 1.33029878e-01f, 6.81190693e-04f, 2.64440894e-01f, 2.01642498e-01f, 1.26522824e-01f, -8.32124799e-02f,
  -1.11950785e-01f, 6.70390427e-02f, 1.77839492e-02f, 5.20207360e-03f, -2.17899438e-02f, -2.51425654e-01f, -1.34705782e-01f, -7.22648064e-03f, -7.17220977e-02f, 1.23573087e-01f,
  -3.42047438e-02f, 9.70107764e-02f, -8.45927279e-03f, 6.98759332e-02f, 1.45199060e-01f, 6.81021288e-02f, 6.06158748e-02f, 2.12764926e-02f, 8.81611034e-02f, 1.51610002e-01f,
  -1.31997049e-01f, -9.80457570e-03f, 5.87409586e-02f, 5.77619523e-02f, -3.83464135e-02f, 5.94451688e-02f, 9.06062126e-03f, 2.84586158e-02f, 1.50010008e-02f, 1.56210557e-01f,
  -1.93192791e-02f, -1.18193179e-01f, -4.88222130e-02f, -9.16868523e-02f, -1.81064531e-02f, -9.75580737e-02f, -5.44246510e-02f, 7.45432153e-02f, -4.98336554e-02f, 5.88927567e-02f,
  -3.21314782e-02f, 1.14806229e-02f, 1.46539919e-02f, -5.27008064e-02f, 1.31639175e-03f, -6.25606775e-02f, -2.52883524e-01f, -5.43385036e-02f, -1.93047389e-01f, -4.96190190e-02f,
  -1.26693785e-01f, -1.66183516e-01f, 1.34940118e-01f, -7.63348490e-02f, -4.58182730e-02f, -9.55915451e-02f, -5.15797995e-02f, -5.61078340e-02f, 1.33242635e-02f, -2.08401933e-01f,
  7.39235952e-02f, 1.40284643e-01f, -1.38111087e-02f, -1.68633670e-01f, -1.48971826e-01f, -2.05727428e-01f, -6.37324676e-02f, -2.81140152e-02f, -4.98961136e-02f, 2.22360224e-01f,
  -6.94275081e-01f, 5.55918038e-01f, 2.71555871e-01f, -3.60215962e-01f, 2.63674319e-01f, 3.83930147e-01f, 6.42276943e-01f, 2.19353244e-01f, -2.09573507e-01f, 2.05465127e-03f,
  1.69594705e-01f, -1.47082031e-01f, -3.83734400e-03f, 7.72572458e-02f, 2.24642619e-01f, 3.92537475e-01f, 3.05310547e-01f, -1.53387114e-02f, -1.22352399e-01f, -4.79513668e-02f,
  4.90947850e-02f, -1.33388743e-01f, -4.38849002e-01f, -1.27274767e-01f, -1.29434571e-01f, -2.41589159e-01f, 2.87493505e-02f, 7.98163041e-02f, 1.54762879e-01f, -9.49139893e-02f,
  -3.36337864e-01f, 3.64276231e-03f, 1.27424479e-01f, -2.85551846e-01f, -1.09379567e-01f, -1.73122287e-01f, -6.79383948e-02f, -9.41659734e-02f, -5.74979037e-02f, -1.15058245e-02f,
  -1.35447532e-01f, -1.62775084e-01f, 1.68730766e-01f, -1.06838122e-01f, 2.15237364e-02f, -2.62529906e-02f, -1.67835075e-02f, -9.09773335e-02f, 7.23949284e-04f, 2.62192134e-02f,
  1.03391722e-01f, -7.89416954e-02f, 7.38605410e-02f, 1.69774219e-01f, 6.33877441e-02f, -1.07885644e-01f, -3.42319086e-02f, -2.13168070e-01f, -4.79303710e-02f, -5.09500265e-01f,
  6.84349798e-03f, -2.75296010e-02f, 5.00808060e-02f, -1.29064973e-02f, -3.65864746e-02f, 1.30292132e-01f, 1.16905712e-01f, 9.09160152e-02f, 5.47223315e-02f, -3.19949538e-02f,
  4.74294499e-02f, -4.13332842e-02f, 2.17801519e-02f, -7.90995662e-04f, -4.51422995e-03f, 8.73066299e-03f, 4.95430715e-02f, 1.73589103e-02f, 2.92132720e-02f, -7.53723383e-02f,
  -1.82911120e-02f, 4.27356102e-02f, -3.13861035e-02f, 3.54073010e-02f, 1.71843097e-02f, 7.76661858e-02f, -1.26301110e-01f, -2.43348815e-02f, -6.88693449e-02f, -5.12927175e-02f,
  -3.16523612e-01f, 3.62258494e-01f, -1.61202177e-01f, 5.95947541e-02f, 8.08348805e-02f, -5.18484935e-02f, 6.14652298e-02f, 2.90300529e-02f, 6.90264776e-02f, 3.79884914e-02f,
  -1.47978723e-01f, 2.70442162e-02f, 1.30423427e-01f, 1.27588399e-02f, 8.85316432e-02f, -1.34824693e-01f, -3.16971145e-03f, 2.89344974e-02f, 2.29539815e-02f, -1.54528007e-01f,
  -8.88386518e-02f, 1.04087040e-01f, -9.63299423e-02f, 1.45725936e-01f, 1.37196288e-01f, -1.30320936e-01f, 6.04121806e-03f, -1.01919569e-01f, 3.51456143e-02f, -3.04774135e-01f,
  -5.09475291e-01f, -1.50683699e-02f, 2.16035709e-01f, -4.07051206e-01f, -3.10966056e-02f, -2.36105844e-02f, 1.62305400e-01f, 1.09339226e-03f, -1.01608716e-01f, 8.07636306e-02f,
  1.21034328e-02f, 1.02172166e-01f, 2.28057802e-01f, 2.51760781e-01f, 1.12480335e-01f, -5.68896979e-02f, -2.73102760e-01f, 1.27889514e-02f, 3.76201719e-01f, 1.90394938e-01f,
  -9.89221185e-02f, -9.20302421e-02f, -2.27625996e-01f, -7.77675807e-02f, 9.54729542e-02f, 1.75772041e-01f, -1.95450019e-02f, -1.35830700e-01f, 7.72056803e-02f, 4.38779294e-02f,
  6.33320808e-01f, -2.70673215e-01f, 1.91547692e-01f, -4.16589677e-02f, 3.44894342e-02f, -4.93512787e-02f, 6.46450669e-02f, -7.33779743e-02f, -5.22294864e-02f, -2.99079902e-02f,
  -3.33310924e-02f, -5.02412906e-03f, 2.05173194e-02f, 1.54802464e-02f, -2.80162226e-02f, 1.40665114e-01f, -1.62754342e-01f, 9.27358307e-03f, -1.25117712e-02f, 1.21208504e-01f,
  5.37843555e-02f, -7.06269816e-02f, 4.36157957e-02f, 9.51384529e-02f, -1.74057022e-01f, -8.05909336e-02f, 6.45535439e-02f, -3.76135558e-02f, -1.37781590e-01f, -4.14035544e-02f,
  -5.60980104e-03f, 1.14142494e-02f, -3.59147377e-02f, -1.01444297e-01f, -2.16781959e-01f, 1.00231078e-02f, 1.02457695e-01f, 8.03449526e-02f, -2.06444725e-01f, -1.00228816e-01f,
  -2.39768177e-02f, -3.12164170e-03f, -5.70276454e-02f, 1.03281438e-01f, 1.91702053e-01f, -1.54820248e-03f, 1.43310651e-02f, 6.58177286e-02f, -2.26515662e-02f, -5.59498928e-02f,
  -1.42506316e-01f, 7.20889494e-02f, 9.18666348e-02f, 1.73258349e-01f, -1.67012438e-02f, -2.86977403e-02f, 4.03474309e-02f, -3.74237075e-02f, 2.98291687e-02f, -1.03684470e-01f,
  4.29303110e-01f, -1.55593142e-01f, 1.11608431e-01f, 7.95691609e-02f, 5.96709847e-02f, 8.18586946e-02f, 1.56461328e-01f, 8.81595016e-02f, -4.29843478e-02f, 7.35207126e-02f,
  1.48113668e-01f, 1.98761985e-01f, 8.81817937e-02f, 1.91544294e-02f, 1.53187782e-01f, 6.72831312e-02f, -3.59501280e-02f, 1.51483074e-01f, 2.24431783e-01f, 1.25742570e-01f,
  -1.91759840e-02f, 1.68391064e-01f, 2.34518632e-01f, 2.38865763e-01f, 1.95469931e-01f, 3.27857614e-01f, 3.35478097e-01f, 2.29642615e-01f, 2.71632403e-01f, 1.25995189e-01f,
  -2.91403770e-01f, 4.35235575e-02f, -2.94910103e-01f, -2.87058800e-01f, -4.47976500e-01f, -2.35851794e-01f, 1.51854694e-01f, -8.62343684e-02f, -2.52278119e-01f, 1.08984828e-01f,
  1.66895941e-01f, 1.08141080e-02f, 1.86044887e-01f, -5.14818681e-03f, -2.73052417e-03f, 2.27825731e-01f, -4.37561423e-02f, -1.29438087e-01f, -2.98253030e-01f, -2.02675492e-01f,
  -1.19514756e-01f, -5.94699606e-02f, -4.21502441e-01f, -2.48474672e-01f, -6.12555444e-02f, -3.51845659e-02f, -1.16494372e-02f, -4.21053886e-01f, -2.34807298e-01f, -3.35207134e-01f,
  1.83607742e-01f, -3.85133773e-01f, 7.93705061e-02f, -1.23642467e-01f, 5.70620708e-02f, 1.35064915e-01f, -1.58173010e-01f, -2.19887197e-02f, 1.79224294e-02f, -1.04665220e-01f,
  -1.45147294e-01f, -3.98142263e-02f, -2.48235390e-01f, -2.29056299e-01f, -2.61660993e-01f, -1.70265913e-01f, -7.20248893e-02f, -2.41681978e-01f, -3.90284434e-02f, -1.47547442e-02f,
  -8.72286260e-02f, -1.62503988e-01f, -4.35635522e-02f, 8.05505179e-03f, -2.98860520e-01f, -1.57442391e-01f, -9.02688801e-02f, -2.97487497e-01f, -4.20175910e-01f, -6.39873818e-02f,
  1.22289822e-01f, -1.05528131e-01f, -6.06516516e-03f, 1.36452332e-01f, 1.31655097e-01f, -8.11255872e-02f, -3.11538856e-03f, 1.10406257e-01f, -2.19203215e-02f, 2.05597859e-02f,
  -5.93837835e-02f, 5.63363358e-02f, -8.75051990e-02f, 4.33832258e-02f, 4.55563888e-03f, -7.11227879e-02f, 6.49801493e-02f, 2.74788849e-02f, 3.10913809e-02f, -4.35788184e-02f,
  -1.59489270e-02f, -1.09212831e-01f, -2.96903476e-02f, 1.15671672e-01f, 6.13263436e-03f, 6.63351081e-03f, 4.19819169e-02f, 9.06487405e-02f, 1.40997186e-01f, -5.85584976e-02f,
  4.58372444e-01f, -1.29760787e-01f, 4.39131796e-01f, 2.29323268e-01f, -9.28526446e-02f, 1.81992158e-01f, 5.86656434e-03f, -8.40992108e-03f, 4.21644747e-02f, 6.73045143e-02f,
  -1.26315892e-01f, 2.02485314e-03f, -8.75829160e-02f, -8.75331163e-02f, 5.25737666e-02f, -5.34855090e-02f, -6.42148331e-02f, 5.13301976e-02f, -7.64372125e-02f, 1.07622840e-01f,
  1.25195071e-01f, 2.65337616e-01f, 3.21932584e-01f, 1.92679659e-01f, 9.89504009e-02f, 1.50391176e-01f, 3.47595245e-01f, 2.78583854e-01f, -2.25955006e-02f, 5.73499322e-01f,
  -2.03472838e-01f, 1.74035922e-01f, -8.40207577e-01f, -1.65509269e-01f, -6.87649667e-01f, -1.81075871e-01f, 1.68897018e-01f, 4.45970505e-01f, 3.47943813e-01f, -2.53727268e-02f,
  -1.85128078e-02f, -3.10798675e-01f, -3.58989239e-01f, -2.81317621e-01f, -1.13178045e-01f, -3.40198368e-01f, -5.45608997e-01f, -9.19387579e-01f, -7.50911772e-01f, -2.96552926e-01f,
  -1.90191194e-01f, -2.51399010e-01f, -3.14317822e-01f, -5.24255587e-03f, -1.74090952e-01f, -2.51833528e-01f, -2.56684214e-01f, -4.28259075e-01f, -2.13780805e-01f, -6.74738407e-01f,
  -7.79231191e-01f, -3.75191033e-01f, -1.87285796e-01f, -1.40452400e-01f, -1.58349261e-01f, 4.05707629e-04f, -5.74507676e-02f, -2.50024833e-02f, 1.13704473e-01f, -6.97777048e-02f,
  -3.65792930e-01f, -7.05577284e-02f, -1.42203927e-01f, -1.70022309e-01f, -1.15948796e-01f, -1.46891341e-01f, 1.80011958e-01f, -3.33359092e-01f, -2.01677278e-01f, -1.48213888e-02f,
  -1.36869624e-01f, -4.50926036e-01f, -3.56849849e-01f, 1.70228958e-01f, 9.86361131e-02f, -1.35797843e-01f, -5.30333184e-02f, -7.98830166e-02f, 6.87301904e-02f, 1.24215726e-02f,
  1.24647738e-02f, -1.73823684e-01f, 2.82471366e-02f, 1.99722379e-01f, 1.19286038e-01f, 1.16259120e-01f, 4.54196474e-03f, -1.19681440e-01f, -1.04827690e-03f, 1.00635951e-02f,
  1.07718050e-01f, 3.94865545e-03f, 7.45305344e-02f, 1.11503191e-02f, -1.05541222e-01f, -1.43566012e-01f, 9.53065455e-02f, -9.00286734e-02f, -5.35772070e-02f, 1.96601104e-04f,
  -1.40179276e-01f, -1.31302044e-01f, 4.84255366e-02f, -1.58861838e-02f, -2.89896369e-01f, 1.94635298e-02f, -1.07774295e-01f, 9.77424607e-02f, 1.22153707e-01f, 1.47554114e-01f,
  5.04809320e-01f, -9.75610539e-02f, 1.54950276e-01f, -9.44025517e-02f, -1.20201163e-01f, -6.78292140e-02f, 4.01023999e-02f, 2.01092854e-01f, -5.25673665e-02f, -5.93150333e-02f,
  -9.00039598e-02f, 1.42839132e-02f, 1.66049227e-01f, 6.19070679e-02f, -8.75166282e-02f, 7.15391114e-02f, 2.59728938e-01f, -1.72944158e-01f, 5.09810522e-02f, 1.42364353e-01f,
  2.05150545e-01f, 2.32923746e-01f, 5.13155274e-02f, 1.26203388e-01f, 3.66235040e-02f, -2.92408001e-02f, -4.19451259e-02f, 7.68934190e-02f, 1.55463219e-01f, 4.74043369e-01f,
  -1.99995667e-01f, -5.77187955e-01f, 6.07866645e-01f, -1.60929561e-01f, 1.79429516e-01f, 2.97690302e-01f, 4.02001828e-01f, 6.07939288e-02f, -2.73459285e-01f, 1.64517313e-01f,
  -3.29844922e-01f, -4.47111756e-01f, -3.94781590e-01f, -3.54560196e-01f, -2.44456694e-01f, 2.54786491e-01f, 1.62932649e-01f, 1.86047420e-01f, 3.73612493e-01f, 1.46224573e-01f,
  -8.63744989e-02f, 1.97674949e-02f, -2.13134155e-01f, -1.53075010e-01f, -4.98663336e-02f, -1.73225328e-01f, 1.10728800e-01f, -8.97768885e-02f, -1.26807496e-01f, 3.39692608e-02f,
  3.94482076e-01f, -1.29711419e-01f, 2.75724530e-02f, -3.89826387e-01f, -4.53562327e-02f, -9.40055996e-02f, 7.70387724e-02f, 8.74129240e-04f, -1.03374273e-01f, 9.95750502e-02f,
  -1.04352169e-01f, -5.54521903e-02f, 6.77574193e-03f, 3.62950796e-03f, 5.23387967e-03f, 9.35192630e-02f, -1.21524081e-01f, -2.21543580e-01f, -2.45329708e-01f, -1.45419732e-01f,
  -3.21254730e-01f, -3.01431548e-02f, 2.30615079e-01f, -6.13013245e-02f, -5.98540418e-02f, -9.41751748e-02f, -3.02033685e-02f, -1.14542022e-01f, -2.22484916e-01f, 7.40175024e-02f,
  5.18877022e-02f, 1.11351222e-01f, 1.61400679e-02f, 5.25592677e-02f, -8.62345938e-03f, 1.40791118e-01f, 8.85809015e-04f, -3.79619338e-02f, -1.58731788e-01f, -2.25505307e-02f,
  -8.55344310e-02f, 1.61481991e-01f, 5.97724877e-03f, 1.42709911e-02f, -1.10287722e-02f, -1.74182318e-02f, 2.55887005e-02f, -9.96759310e-02f, -3.44191231e-02f, -5.95628433e-02f,
  -2.77410168e-02f, -3.03481240e-02f, -3.38959470e-02f, -4.30433489e-02f, -1.70233414e-01f, -2.57690754e-02f, -3.73519026e-02f, -3.14249732e-02f, -1.17332943e-01f, -1.06301591e-01f,
  -6.26117289e-02f, -3.66517633e-01f, 1.99055552e-01f, -3.23461965e-02f, 5.02204448e-02f, -3.18630576e-01f, -1.34621710e-01f, 1.63789131e-02f, 6.46421388e-02f, 7.82640278e-02f,
  -1.58018067e-01f, 9.58402529e-02f, -1.51045723e-02f, -9.87036899e-02f, 2.41798684e-01f, 8.85951221e-02f, -1.68584034e-01f, 9.91970524e-02f, -3.04943323e-02f, 6.89715967e-02f,
  -7.63796791e-02f, 1.62671536e-01f, 1.55466989e-01f, 1.46592528e-01f, 8.42986405e-02f, 2.27347374e-01f, 2.43562073e-01f, 5.71588688e-02f, 1.64790481e-01f, 3.38169217e-01f,
  9.56497550e-01f, -7.16743469e-01f, 9.13142115e-02f, 6.28262699e-01f, 5.59398472e-01f, 3.75041574e-01f, 2.84869194e-01f, 2.03227311e-01f, 3.59013557e-01f, 1.68764204e-01f,
  -1.76642478e-01f, -9.06753913e-02f, -1.74396232e-01f, -1.21821567e-01f, 7.12241381e-02f, 5.75909652e-02f, 1.49698511e-01f, 2.67308861e-01f, 3.10012847e-01f, 9.58045274e-02f,
  -6.41586110e-02f, -3.15332785e-02f, 2.54580360e-02f, -1.11263648e-01f, -2.45547995e-01f, -1.32196516e-01f, -7.46591687e-02f, -1.68347031e-01f, -2.41585359e-01f, -1.42511964e-01f,
  -1.77602330e-03f, -1.48995697e-01f, 1.40309066e-01f, -2.22455040e-01f, -1.15922317e-01f, -1.22323096e-01f, 1.15811020e-01f, -1.96414977e-01f, -1.60002276e-01f, -1.38695404e-01f,
  -2.16204152e-01f, -1.75648123e-01f, -1.14059404e-01f, -1.56466097e-01f, -7.83396233e-03f, -1.74701452e-01f, -1.37437120e-01f, -8.25903565e-02f, -7.65019655e-02f, -5.33972494e-02f,
  -1.93490759e-01f, 4.97073913e-03f, 1.52857512e-01f, 1.07796647e-01f, -6.78235888e-02f, 5.00880331e-02f, -1.59214884e-01f, -1.07906954e-02f, -1.04045533e-02f, 1.02298871e-01f,
  2.11853117e-01f, 1.66305572e-01f, 2.84281343e-01f, 9.53144431e-02f, 1.98174268e-01f, 8.36693719e-02f, -3.95032577e-02f, -8.85830522e-02f, 1.44573420e-01f, 5.99815277e-03f,
  3.80444080e-02f, 2.73446292e-01f, 1.51446480e-02f, 1.17717655e-02f, 1.58990547e-01f, 4.80144173e-02f, 6.24947213e-02f, -1.75133437e-01f, 6.13456182e-02f, 7.53039494e-02f,
  9.35620368e-02f, -5.92331169e-03f, -7.26300031e-02f, -7.10759163e-02f, -1.85325116e-01f, 7.15314820e-02f, -5.98026328e-02f, -3.22984010e-02f, -2.82766707e-02f, 6.93918616e-02f,
  9.35008079e-02f, 2.53863633e-01f, 2.99839407e-01f, -2.51505766e-02f, 2.09314339e-02f, -1.13828741e-01f, 1.64885923e-01f, -1.51266158e-02f, -1.70874342e-01f, -5.03442623e-02f,
  -1.53967127e-01f, -6.95311874e-02f, -1.77935392e-01f, 7.99055491e-03f, 1.67575091e-01f, -3.00068352e-02f, -6.56063482e-02f, 1.48937032e-01f, -8.30892771e-02f, -5.70674017e-02f,
  -3.62887159e-02f, 1.79110602e-01f, 3.64583313e-01f, 2.15485826e-01f, 2.16063950e-02f, 2.23968029e-01f, -2.94390358e-02f, -1.16506005e-02f, 6.93199262e-02f, 2.68072903e-01f,
  1.49588734e-01f, 7.89157078e-02f, 2.48056039e-01f, 1.50858939e-01f, -5.44645786e-01f, -7.18869209e-01f, -7.62503386e-01f, -3.97348851e-01f, -1.15452677e-01f, 4.48842831e-02f,
  -1.22877799e-01f, -2.20620960e-01f, -4.51731086e-02f, -5.77776171e-02f, -7.66687170e-02f, 1.21376224e-01f, 2.75841951e-01f, 1.61715612e-01f, -1.85422719e-01f, -4.24369335e-01f,
  -1.58747032e-01f, 7.93068931e-02f, 1.60718501e-01f, 7.21764639e-02f, 2.18043953e-01f, -5.19895554e-02f, 2.65885115e-01f, 2.22232684e-01f, 3.75778861e-02f, 4.98915702e-01f,
  1.44912153e-01f, 1.88381404e-01f, -1.09291367e-01f, 4.76462133e-02f, 8.94697458e-02f, 9.38968882e-02f, -2.38481481e-02f, 1.97234496e-01f, -1.36628021e-02f, 6.45894259e-02f,
  -1.56873882e-01f, -3.52260307e-03f, -4.05002013e-02f, -1.38967382e-02f, -7.88598880e-02f, 5.83675178e-03f, 2.52222389e-01f, 2.58142412e-01f, 3.16182464e-01f, -2.68994495e-02f,
  -2.25485906e-01f, -1.29808053e-01f, -1.92684025e-01f, -1.38955280e-01f, 1.60489619e-01f, 1.75910041e-01f, -7.07125738e-02f, 1.02556244e-01f, -6.40483797e-02f, 2.39718243e-01f,
  -1.41319543e-01f, 1.02506220e-01f, -3.47233079e-02f, 3.44119072e-02f, -7.11201802e-02f, -6.30803630e-02f, 1.83423962e-02f, -3.89228575e-02f, -8.82482901e-03f, 4.01252322e-03f,
  1.17800431e-02f, 8.65498781e-02f, -2.60683391e-02f, 2.42352225e-02f, 7.96069577e-02f, -2.76583806e-03f, 1.36968924e-03f, 5.01614362e-02f, 9.39112306e-02f, 1.19827781e-02f,
  -4.01985087e-02f, -5.95854968e-02f, 8.50273967e-02f, 1.78678110e-02f, 9.63987187e-02f, 2.06359744e-01f, 3.74951437e-02f, 9.87404492e-03f, 1.27026990e-01f, 1.60522144e-02f,
  -1.77064449e-01f, -6.42564595e-02f, 4.56562191e-02f, 8.06631148e-02f, 1.00125104e-01f, 1.15948364e-01f, 2.57455297e-02f, 1.04613490e-01f, 1.62417546e-01f, -6.24374934e-02f,
  -2.20699415e-01f, -7.36373104e-03f, 1.60042062e-01f, 4.18434143e-02f, -1.96140736e-01f, -1.61088809e-01f, -2.59223375e-02f, -2.92306066e-01f, -1.06224038e-01f, 9.03502852e-02f,
  -4.28068675e-02f, -4.18992728e-01f, -3.40825588e-01f, -1.28580377e-01f, -4.41802144e-02f, -3.65552396e-01f, -2.42731109e-01f, -2.70625949e-01f, -4.55515087e-01f, -4.92317259e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.62209630e-01f, 3.25756401e-01f, -2.08571665e-02f, -3.52860302e-01f, 4.63495702e-01f, 2.78230011e-01f, 8.68089139e-01f, 2.34347999e-01f, -7.97717124e-02f, 4.63961661e-01f,
  5.68376660e-01f, 2.44023740e-01f, 8.49947751e-01f, 4.95639086e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.51742324e-02f, -1.75761208e-01f, 3.71051878e-01f, -3.24524075e-01f, -3.29015106e-01f, -5.88670671e-02f, 2.88471997e-01f, 3.50065798e-01f, 3.31476361e-01f, 3.76086622e-01f,
  -3.71620715e-01f, 3.89790237e-02f, -9.41036269e-02f, -1.96512833e-01f, -2.98538297e-01f, -6.04918450e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.22107187e-01f, -1.51471883e-01f, -5.74633062e-01f, 3.11445713e-01f, 3.24295908e-01f, 3.56149189e-02f, -1.32749066e-01f, 1.31998494e-01f, 2.68620610e-01f, -2.77712137e-01f,
  -2.61444271e-01f, 5.25013637e-03f, 3.46753627e-01f, -2.31230766e-01f, 8.12122881e-01f, -3.51489484e-01f, 3.87707084e-01f, 3.37003380e-01f, -6.06677115e-01f, -5.00623286e-01f,
  -4.67272289e-02f, 3.71486088e-03f, -4.15829688e-01f, -5.38699090e-01f, 2.28989720e-01f, -3.20620447e-01f, -2.53117889e-01f, 2.00982019e-01f, 3.07561994e-01f, 3.40128064e-01f,
  5.23286223e-01f, -2.36087805e-03f, -3.05861175e-01f, -1.45747960e-01f, -6.32709801e-01f, 6.69158757e-01f, 2.69687295e-01f, -3.11594129e-01f, -2.77747333e-01f, -4.21881288e-01f,
  -2.77430296e-01f, -5.15991688e-01f, -2.39917003e-02f, -1.45009570e-02f, 1.18153192e-01f, -1.63001820e-01f, 2.66931832e-01f, -3.39466602e-01f, 2.96410263e-01f, 2.06038896e-02f,
  6.74555600e-01f, 4.44048107e-01f, 1.86060041e-01f, -1.62140921e-01f, -2.53821492e-01f, -3.74144197e-01f, 4.86286789e-01f, 7.72602707e-02f, -1.50373161e-01f, 7.20107198e-01f,
  5.97241461e-01f, -3.32219481e-01f, 2.40893364e-01f, 1.94491819e-01f, 6.14511669e-01f, -1.70080625e-02f, -3.57727945e-01f, 2.07489118e-01f, -2.99900949e-01f, 2.54696608e-01f,
  8.10196519e-01f, 3.06340277e-01f, -1.68033883e-01f, 4.64721709e-01f, -2.34405890e-01f, -4.44536895e-01f, -1.56555280e-01f, -3.07670712e-01f, 3.59475836e-02f, 5.95111668e-01f,
  4.05670315e-01f, 1.93708137e-01f, -4.38488901e-01f, 6.38826847e-01f, 3.13075364e-01f, -5.10260999e-01f, -2.18695439e-02f, -4.43627924e-01f, 5.22637844e-01f, -1.89314052e-01f,
  -5.05883247e-02f, 5.55879891e-01f, 8.70329678e-01f, -6.17241681e-01f, 1.85595881e-02f, 5.60590982e-01f, 3.79073620e-02f, 2.40461931e-01f, 8.26388955e-01f, 2.56247997e-01f,
  -5.98021984e-01f, 3.09920788e-01f, 8.20237100e-01f, 6.39729142e-01f, -3.26298624e-01f, 3.77068400e-01f, 8.47898331e-03f, -5.21344543e-01f, 3.56677979e-01f, -3.26935321e-01f,
  -1.56498075e-01f, 2.60101348e-01f, 3.20498019e-01f, 4.57422957e-02f, 1.08068037e+00f, -2.26281211e-01f, -4.87179309e-01f, -2.08114728e-01f, -7.39348456e-02f, 4.34245825e-01f,
  4.75174248e-01f, 6.66065991e-01f, 2.98306733e-01f, 6.48070633e-01f, 9.65347663e-02f, 8.70343924e-01f, 1.59342974e-01f, -9.24510658e-02f, 4.04880017e-01f, -2.45780855e-01f,
  -1.01378523e-01f, -2.73070425e-01f, -3.16044301e-01f, -4.81209636e-01f, -3.23034316e-01f, 1.57314420e-01f, 2.98485070e-01f, -5.57546020e-01f, 4.69979584e-01f, 5.68619251e-01f,
  2.91446950e-02f, 8.06210995e-01f, 1.87691078e-01f, 5.34016848e-01f, 4.58646089e-01f, -2.95358658e-01f, 3.25234741e-01f, 8.65366757e-02f, 4.84294556e-02f, -2.24252865e-02f,
  8.47536504e-01f, 5.11571109e-01f, 1.19161330e-01f, 1.09055567e+00f, -3.72775286e-01f, -8.93615708e-02f, -2.70873547e-01f, 1.04072586e-01f, 2.02387646e-01f, 1.38044227e-02f,
  5.19991875e-01f, -6.26226425e-01f, -3.90795320e-01f, -4.37996924e-01f, -3.51576895e-01f, -1.63274944e-01f, -8.08904171e-02f, -1.60952229e-02f, 7.22080469e-01f, -6.61954045e-01f,
  -2.06307322e-01f, 1.45599991e-01f, 4.03813928e-01f, 1.13271132e-01f, -8.31056461e-02f, 6.87191248e-01f, 1.18892333e-02f, -6.44895375e-01f, 2.95311779e-01f, -4.15334433e-01f,
  2.21541966e-03f, 8.75482559e-02f, 9.13239270e-02f, 8.21155846e-01f, 6.77337646e-01f, 5.39884828e-02f, -4.48245019e-01f, 1.44796953e-01f, 1.45419165e-01f, 3.54378298e-02f,
  4.59397376e-01f, 5.29684484e-01f, 2.34137759e-01f, 2.79811323e-01f, 5.59600592e-01f, 6.87183559e-01f, -9.19784248e-01f, -1.01278313e-01f, 7.58881450e-01f, -2.86832839e-01f,
  -1.45211890e-01f, 4.93112028e-01f, 2.59412497e-01f, 5.25881112e-01f, 7.17860639e-01f, 1.73296243e-01f, -3.35044831e-01f, 1.14864513e-01f, 6.86859906e-01f, -4.15184617e-01f,
  -6.47451162e-01f, -7.58938566e-02f, -2.94303685e-01f, -1.47395758e-02f, 2.94370949e-01f, 4.09616381e-01f, 1.59129068e-01f, -3.77030015e-01f, -2.94502378e-01f, -1.21468231e-01f,
  1.40024692e-01f, 3.81423742e-01f, 5.31504154e-01f, 5.16397238e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  5.52466437e-02f, 4.80217665e-01f, -6.97546676e-02f, 8.13062787e-01f, 5.27746797e-01f, 2.64665067e-01f, 3.42878193e-01f, 2.09910139e-01f, 6.87330842e-01f, 3.69001269e-01f,
  3.03659469e-01f, 7.65352309e-01f, 3.11956644e-01f, 4.95837331e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.62967670e-01f, 1.81678280e-01f, 3.08295220e-01f, -2.35142201e-01f, 2.74300277e-01f, -1.04680538e-01f, 5.54313540e-01f, 1.21261314e-01f, 4.19257045e-01f, -2.08419397e-01f,
  -1.61590308e-01f, -1.24898190e-02f, -4.18256938e-01f, -1.48577005e-01f, -2.64127050e-02f, 6.90890402e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  4.83494140e-02f, 2.76156012e-02f, -3.30550298e-02f, 1.19108759e-01f, -3.06705683e-01f, -8.68882358e-01f, 4.87852931e-01f, -3.95043254e-01f, 4.32138026e-01f, -1.49763256e-01f,
  -2.48514503e-01f, 1.94611579e-01f, 2.66427219e-01f, 5.23448944e-01f, -6.16226554e-01f, 1.52895540e-01f, 7.32089102e-01f, -1.36518061e-01f, -2.99971491e-01f, 3.55289757e-01f,
  -5.89450836e-01f, -8.71595964e-02f, 5.38829684e-01f, -9.64304805e-03f, 2.29499578e-01f, -2.38818303e-02f, 1.05916607e+00f, -4.26891327e-01f, 1.02010131e+00f, 1.75246194e-01f,
  -1.05038337e-01f, 6.23553932e-01f, 5.07685065e-01f, 3.95925045e-01f, -5.69654882e-01f, -7.14230001e-01f, -7.29924440e-01f, 2.22649142e-01f, 1.42700329e-01f, -3.38977277e-01f,
  5.17119527e-01f, 8.15967262e-01f, -1.43348232e-01f, 9.92309690e-01f, -1.29019052e-01f, 2.21292377e-01f, 2.47173160e-01f, 1.58902332e-01f, 4.57164735e-01f, -6.19513571e-01f,
  1.72260702e-01f, 6.58483148e-01f, -2.50685275e-01f, 4.50983971e-01f, 1.88940600e-01f, 3.21152598e-01f, -1.71171844e-01f, -1.30522892e-01f, 7.46867239e-01f, -2.35207632e-01f,
  9.19949174e-01f, 9.18354511e-01f, -5.07245302e-01f, 6.59106493e-01f, 7.72228003e-01f, 7.27123082e-01f, -3.75760756e-02f, -2.55937368e-01f, -8.34781647e-01f, 1.33182123e-01f,
  7.50066102e-01f, 5.01212716e-01f, 1.04318738e+00f, -6.00945115e-01f, -2.42390469e-01f, 1.51390761e-01f, 7.10641384e-01f, 1.12563357e-01f, 7.26251066e-01f, 5.27107179e-01f,
  -1.29566163e-01f, 2.99336940e-01f, -5.59228882e-02f, -1.19991325e-01f, -4.70059544e-01f, -4.59846199e-01f, 6.76711023e-01f, -5.83822131e-01f, 4.03881878e-01f, 7.92510901e-03f,
  2.54185975e-01f, 5.82744658e-01f, 1.59033865e-01f, 5.34286261e-01f, -5.62896729e-01f, 4.76628006e-01f, -1.23033054e-01f, -6.65622413e-01f, 2.72541940e-01f, 7.55774379e-01f,
  4.55889925e-02f, 4.17776227e-01f, -3.32269937e-01f, 3.26874465e-01f, -3.73673052e-01f, -2.18270347e-01f, 4.47422862e-01f, -6.62832320e-01f, -1.20400146e-01f, 2.35033378e-01f,
  2.82095224e-01f, 3.34017426e-01f, -6.30388334e-02f, -1.73752569e-02f, 6.35055542e-01f, 5.07427931e-01f, 1.12937249e-01f, 7.08155334e-02f, 3.96032184e-01f, -1.25089920e+00f,
  4.51442748e-02f, 5.11963546e-01f, -3.52852166e-01f, 8.07657182e-01f, -5.77208042e-01f, 3.40480030e-01f, -5.16228735e-01f, 4.30499166e-01f, 2.63042271e-01f, -1.96027070e-01f,
  1.19157963e-01f, 6.78872824e-01f, 7.34417617e-01f, 4.94438291e-01f, -5.33669412e-01f, 5.63556731e-01f, 2.03475412e-02f, -3.59001011e-01f, -2.45625347e-01f, -3.03537220e-01f,
  4.34525281e-01f, 2.55999267e-01f, 1.69674724e-01f, -4.02758978e-02f, 1.28244951e-01f, 6.62396371e-01f, -5.25679469e-01f, -1.89012438e-01f, 2.32472897e-01f, -8.96233544e-02f,
  -5.82579430e-03f, -5.31091928e-01f, 7.16269612e-02f, 3.98016840e-01f, 6.75989687e-01f, 1.13672510e-01f, 7.83654690e-01f, 7.02534556e-01f, -1.11163354e+00f, 2.03569278e-01f,
  8.98349732e-02f, -1.51356280e-01f, 2.02659424e-02f, 4.27573293e-01f, 5.49194813e-01f, 7.19905913e-01f, -7.07967281e-01f, 2.45431617e-01f, 5.39092243e-01f, 9.80380893e-01f,
  1.63858637e-01f, -4.37803239e-01f, -2.91386396e-01f, 2.00379670e-01f, 6.28713369e-01f, -7.41223395e-01f, -5.00358403e-01f, -1.46636501e-01f, -2.80551072e-02f, -6.13128543e-01f,
  1.06735742e+00f, 6.26472533e-01f, 1.44777656e-01f, 3.22419375e-01f, -8.82944316e-02f, 4.15076107e-01f, 1.49449902e-02f, 4.55073684e-01f, -3.35124791e-01f, 3.16111028e-01f,
  4.29361731e-01f, -5.71718395e-01f, 3.52222472e-02f, -2.31878266e-01f, -4.85432297e-01f, 5.64380229e-01f, -8.05185735e-01f, 2.00496271e-01f, -6.41224802e-01f, 2.53764223e-02f,
  1.25018150e-01f, 1.09272039e+00f, 6.93151295e-01f, -3.84493560e-01f, 7.31997907e-01f, 1.75174162e-01f, 1.91073567e-01f, -2.20418200e-01f, -1.50263980e-01f, -4.01217729e-01f,
  1.96826100e-01f, 4.68887419e-01f, 7.23205924e-01f, 2.88245887e-01f, -1.84245437e-01f, -8.48410800e-02f, -7.31529951e-01f, 1.20671719e-01f, 6.48370683e-01f, -1.09979607e-01f,
  -7.15527475e-01f, -9.12566781e-02f, -4.32722196e-02f, 1.01794586e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -4.14006829e-01f, 2.14863658e-01f, -2.78647363e-01f, 5.27356803e-01f, 6.25426650e-01f, 1.45492882e-01f, 4.66977745e-01f, -7.78498650e-02f, 4.37339067e-01f, 2.62914300e-02f,
  -9.31841731e-02f, -3.47462684e-01f, 1.67274028e-01f, 1.15395663e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  2.76875407e-01f, 1.27263144e-01f, -4.16118771e-01f, -6.88669026e-01f, -5.63342273e-01f, -7.15081573e-01f, 3.35026324e-01f, 2.84074724e-01f, 8.96158367e-02f, -6.01718664e-01f,
  4.77912515e-01f, 1.50440812e-01f, 4.63434517e-01f, 1.90115213e-01f, -6.57247365e-01f, -6.83532953e-01f, 4.62764651e-01f, 5.39062202e-01f, 1.83892921e-01f, -3.09856743e-01f,
  -4.85990286e-01f, 2.44738966e-01f, -4.61085826e-01f, 1.39088675e-01f, 4.21407074e-01f, 8.70387722e-03f, 3.80009055e-01f, -4.13176775e-01f, 2.87348419e-01f, 4.33272868e-01f,
  -1.37855458e+00f, 4.05014187e-01f, -7.20129907e-02f, 4.97366637e-01f, -5.66312611e-01f, 2.23233864e-01f, 3.19314092e-01f, -7.82523081e-02f, 8.01386595e-01f, -1.94030032e-01f,
  -3.81069839e-01f, -2.30227023e-01f, -2.75987715e-01f, -3.91346008e-01f, -1.11986470e+00f, -1.84763029e-01f, -7.94691026e-01f, -2.64547706e-01f, -4.27538306e-01f, -7.36935586e-02f,
  -1.78609207e-01f, -1.40911746e+00f, 5.77635944e-01f, -1.20519769e+00f, 4.84105423e-02f, -6.86186790e-01f, -2.30646759e-01f, -2.63140917e-01f, -1.63116261e-01f, -7.17251062e-01f,
  4.15434450e-01f, 3.51854810e-03f, 3.43874067e-01f, -4.60782856e-01f, -4.45987761e-01f, 8.91931236e-01f, -3.74708354e-01f, 1.50499359e-01f, 2.71884918e-01f, -4.05323431e-02f,
  3.42266053e-01f, -6.82168126e-01f, 1.62274703e-01f, -3.31580197e-03f, -1.17607139e-01f, -3.87751937e-01f, 2.50905603e-01f, -3.43059629e-01f, 9.77794454e-02f, -2.93607622e-01f,
  2.40655199e-01f, -1.08227897e+00f, -2.86593735e-01f, 3.27618033e-01f, -1.11418295e+00f, 3.04634213e-01f, -1.43581450e-01f, -7.03913152e-01f, 3.90125424e-01f, -8.09724808e-01f,
  3.95587683e-01f, -4.85190719e-01f, 1.49198323e-01f, -3.92815948e-01f, 2.54432350e-01f, -1.29792318e-01f, 1.61104381e-01f, -5.52918673e-01f, -2.51936466e-01f, 3.91012877e-01f,
  -5.95150769e-01f, 4.46951747e-01f, -5.69930077e-02f, -9.78385881e-02f, 1.59190729e-01f, -7.42070675e-01f, -1.35603637e-01f, 4.05792564e-01f, -1.02465808e+00f, -4.53694284e-01f,
  3.58089626e-01f, -2.81786352e-01f, 3.63632172e-01f, 7.22380459e-01f, 2.86547780e-01f, -7.22724676e-01f, 4.66373652e-01f, -5.33110976e-01f, -1.45406663e-01f, 3.67065012e-01f,
  1.06429875e-01f, 6.77586257e-01f, -1.03005320e-01f, -1.18633822e-01f, -5.88014603e-01f, 2.41794541e-01f, -1.02796483e+00f, 3.22517663e-01f, -1.08242059e+00f, -6.93296134e-01f,
  6.70934469e-02f, 4.46667701e-01f, -2.15261817e-01f, 1.12522840e-01f, -1.16545975e+00f, -3.36049534e-02f, 1.20158739e-01f, 4.51032817e-01f, -4.68446076e-01f, 1.94099233e-01f,
  2.92553715e-02f, -6.83058262e-01f, 3.73745114e-01f, 5.14193714e-01f, 1.74114645e-01f, 3.29152703e-01f, 7.18116343e-01f, 4.00863051e-01f, 4.87607047e-02f, 4.23182324e-02f,
  9.51485932e-02f, 5.98214686e-01f, -9.63206291e-01f, -1.60887063e-01f, -1.39557183e+00f, 3.17984521e-01f, -6.87008262e-01f, -1.26816595e+00f, -9.13387656e-01f, -5.82067072e-01f,
  -6.39113545e-01f, -3.85667503e-01f, 3.50048631e-01f, 5.41731194e-02f, -4.93212342e-02f, -3.45276028e-01f, -1.05793738e+00f, -8.19821477e-01f, 6.20013326e-02f, -9.70337689e-01f,
  -6.54225945e-01f, -5.98726392e-01f, 4.95342970e-01f, 6.04578972e-01f, 5.65668643e-01f, 3.92097086e-01f, -6.53351307e-01f, -6.58038855e-01f, -3.38397384e-01f, -3.04854035e-01f,
  2.39493772e-01f, -8.66125748e-02f, -8.59063148e-01f, -4.10933346e-02f, -7.09129870e-01f, 3.00408632e-01f, -3.11718106e-01f, 5.81220925e-01f, 9.25692841e-02f, 4.26482350e-01f,
  4.15774137e-01f, -6.52977943e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  4.05768156e-01f, -2.04658106e-01f, 3.35515827e-01f, -9.77234244e-01f, 1.22593969e-01f, 2.50508875e-01f, 1.22506842e-01f, -6.23974651e-02f, -3.17912579e-01f, -1.20018221e-01f,
  -7.75405407e-01f, -6.14925921e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    