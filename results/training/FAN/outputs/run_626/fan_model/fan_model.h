/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.66563207e-01f, -2.79654235e-01f, 2.24244654e-01f, -5.61836958e-02f, -1.40275463e-01f, 2.77184919e-02f, -2.71461934e-01f, -2.62829904e-02f, 9.29280967e-02f, -9.17657986e-02f,
  1.40920416e-01f, 2.68410534e-01f, 2.79931486e-01f, 3.13981295e-01f, 2.71940887e-01f, -2.65692621e-01f, -2.58212686e-01f, 2.24312529e-01f, 3.44509512e-01f, -4.15313840e-02f,
  -1.40078753e-01f, -9.72234160e-02f, 8.20156783e-02f, 3.80702280e-02f, -2.40855142e-01f, -6.08313233e-02f, -3.97886634e-02f, -9.47267413e-02f, -1.92392498e-01f, -4.77041811e-01f,
  1.60703108e-01f, 2.32429340e-01f, 1.17050648e-01f, 1.87251464e-01f, 1.21484131e-01f, 5.97156286e-02f, 9.04417560e-02f, 1.13881335e-01f, 6.52116537e-02f, 1.85138322e-02f,
  8.13071281e-02f, 1.36747926e-01f, 1.37930959e-01f, 3.98038737e-02f, 1.31286427e-01f, 1.40341714e-01f, 1.22870289e-01f, 2.01892972e-01f, 2.12863997e-01f, 1.40020311e-01f,
  1.21792583e-02f, 2.58436371e-02f, 1.49153575e-01f, 1.38090208e-01f, 1.27251729e-01f, 1.39998868e-01f, 4.11612913e-02f, 9.26898643e-02f, 1.71566814e-01f, -1.60523757e-01f,
  -4.16893400e-02f, -4.31788191e-02f, -9.94677618e-02f, -8.17258582e-02f, -1.32721812e-01f, -5.58090284e-02f, -1.32185355e-01f, -1.04116410e-01f, -5.37445359e-02f, -5.57826906e-02f,
  -1.34304157e-02f, -2.97802445e-02f, 1.61970463e-02f, -1.02553472e-01f, -7.18305036e-02f, -2.85181608e-02f, -8.39338750e-02f, -8.46725181e-02f, -3.04433145e-02f, -4.07273434e-02f,
  4.16732356e-02f, -5.06925993e-02f, 4.68875375e-03f, -1.04367197e-01f, -7.68790860e-03f, -2.40097400e-02f, -9.79262963e-02f, 2.82259029e-03f, -8.23921710e-03f, -7.34226182e-02f,
  4.17798311e-02f, 4.26358759e-01f, -5.60971815e-03f, 1.33487463e-01f, -4.83089685e-03f, 1.57585680e-01f, 1.05195150e-01f, 9.08600688e-02f, 1.69501469e-01f, 1.47937253e-01f,
  2.21323639e-01f, 1.01250991e-01f, 1.44312561e-01f, 3.00558694e-02f, 7.50385299e-02f, 9.73351523e-02f, -4.66865450e-02f, 5.68992235e-02f, 4.01509367e-02f, 4.92802002e-02f,
  -1.99580342e-02f, -5.30199148e-02f, -1.50019135e-02f, 3.22985724e-02f, 1.03662089e-01f, 6.61395565e-02f, 3.16309705e-02f, -5.75379096e-02f, 1.23801529e-01f, -2.82815814e-01f,
  7.44736865e-02f, 4.39106822e-01f, 4.36876528e-02f, 3.07494342e-01f, 1.61040664e-01f, -3.47909957e-01f, -2.42503986e-01f, -2.23749474e-01f, 1.84452593e-01f, 2.32524231e-01f,
  1.50849417e-01f, 6.11052802e-03f, 1.21356979e-01f, -1.90668672e-01f, -4.03653502e-01f, -1.96280424e-03f, 3.44725624e-02f, -3.56678039e-01f, -4.78457332e-01f, -3.19781780e-01f,
  6.01265877e-02f, 1.86336730e-02f, -8.97962749e-02f, -1.09775282e-01f, 3.93416762e-01f, 4.92999852e-02f, 1.22333005e-01f, 1.18531853e-01f, -9.40776914e-02f, 3.10466915e-01f,
  5.72721772e-02f, 9.03690048e-03f, -2.30097070e-01f, -7.02719912e-02f, 5.89019656e-02f, -8.17751512e-02f, -3.73242190e-03f, -4.17684466e-02f, -1.68698020e-02f, -3.76883056e-03f,
  6.44217059e-02f, -7.59417489e-02f, 3.42182033e-02f, -4.09472659e-02f, 4.72074412e-02f, -5.22360019e-02f, -8.68397132e-02f, -8.88393372e-02f, -1.06417559e-01f, -9.40325037e-02f,
  1.46482289e-01f, 2.62169870e-05f, -9.29265916e-02f, -1.03173845e-01f, -1.58967048e-01f, -1.29945815e-01f, -7.79368877e-02f, -1.28789812e-01f, -2.49552995e-01f, 1.58125043e-01f,
  -8.86143968e-02f, 6.23440742e-02f, -3.06031145e-02f, 4.60127033e-02f, 3.74256982e-04f, 1.28349587e-01f, 6.42182156e-02f, 3.78372446e-02f, -5.07406741e-02f, 1.58388525e-01f,
  8.12397990e-03f, 4.16743197e-02f, -1.76303759e-02f, 1.34221926e-01f, 6.97605014e-02f, 1.47689015e-01f, 5.37586249e-02f, 9.06514898e-02f, 4.20312956e-02f, 2.77986452e-02f,
  2.75159068e-02f, -1.49598448e-02f, 2.06673473e-01f, 1.39844576e-02f, 2.14625876e-02f, 6.23735487e-02f, 7.80488551e-02f, 3.43074016e-02f, 1.40881166e-01f, 8.73531997e-02f,
  3.13032508e-01f, -3.95385504e-01f, 8.64920020e-02f, -8.33721012e-02f, 8.39093700e-02f, -5.20726182e-02f, -3.27911153e-02f, -1.01867178e-02f, -2.09190398e-02f, -1.01584099e-01f,
  -1.46198422e-01f, -5.38919792e-02f, -2.14341413e-02f, -7.21158832e-02f, -1.45818174e-01f, -6.91854805e-02f, 4.83948588e-02f, -2.97813700e-03f, -9.35987383e-02f, -2.21579056e-02f,
  -2.19934210e-02f, -4.37659137e-02f, 3.84977600e-03f, -2.34197360e-03f, -6.82473332e-02f, -4.59339432e-02f, -6.63253814e-02f, -7.11043775e-02f, -1.73613533e-01f, 8.83396491e-02f,
  -3.16268027e-01f, -6.60459280e-01f, -7.49368519e-02f, 1.21850381e-02f, 9.23384652e-02f, -5.56325680e-03f, -3.71238887e-01f, -2.59226710e-01f, -3.34090106e-02f, -3.00408155e-01f,
  -9.93498266e-02f, 1.81318477e-01f, 1.25141874e-01f, 1.58702269e-01f, -1.47746354e-01f, -1.51768148e-01f, -8.48600343e-02f, 1.68463022e-01f, 1.55466214e-01f, -4.91906442e-02f,
  -5.59279583e-02f, -2.61788428e-01f, -2.61531681e-01f, -7.20817521e-02f, -1.55746847e-01f, 5.69912083e-02f, -2.66475350e-01f, -2.16887370e-01f, -9.07033384e-02f, 1.51764639e-02f,
  -7.68728778e-02f, -3.43184024e-01f, 1.02128059e-01f, -3.09303636e-03f, -1.36305779e-01f, -1.65895239e-01f, -1.32925779e-01f, -1.81447878e-01f, -6.71351776e-02f, -2.00918764e-01f,
  -4.84333225e-02f, -6.97823986e-02f, -1.15082480e-01f, -1.92485034e-01f, -1.28941059e-01f, -1.45797715e-01f, -2.25410700e-01f, -7.25369230e-02f, -3.09448484e-02f, -1.60786107e-01f,
  -6.66941330e-02f, -1.13331057e-01f, -5.51189343e-03f, -1.78600177e-01f, -2.01607943e-01f, 1.00322321e-01f, -1.37302488e-01f, -4.71445359e-02f, -1.26959294e-01f, -2.37786442e-01f,
  -8.81707594e-02f, -4.78866063e-02f, 3.90134677e-02f, -1.53442509e-02f, -4.59168926e-02f, 3.81342359e-02f, -3.15543786e-02f, -5.47607094e-02f, -6.46207994e-03f, 5.85772060e-02f,
  -9.39272810e-03f, 8.20555724e-03f, -6.58602715e-02f, 6.25959132e-03f, -1.53209744e-02f, -8.18451028e-03f, -2.23151259e-02f, -2.89913751e-02f, 1.03968624e-02f, -6.72651902e-02f,
  -8.29289202e-03f, 3.89859527e-02f, -1.25543103e-02f, -4.00375761e-03f, 3.42109520e-03f, 1.20607773e-02f, 2.41932999e-02f, -1.97262391e-02f, -1.68616660e-02f, 1.00290598e-02f,
  -7.48465434e-02f, 6.74467832e-02f, -2.10653921e-03f, -8.74746069e-02f, -9.20664147e-02f, -7.84206688e-02f, -1.01108849e-01f, -1.08644925e-01f, -6.22636862e-02f, -1.78379446e-01f,
  -1.07940979e-01f, -1.24937534e-01f, -1.23813361e-01f, -1.38961181e-01f, -7.59218866e-03f, -9.44403186e-02f, -1.81373894e-01f, 6.32909983e-02f, -1.16523176e-01f, -2.43979558e-01f,
  -1.69991255e-01f, 1.18998485e-02f, -1.38872303e-02f, -5.92114627e-02f, -2.16010772e-02f, 9.50962156e-02f, -1.23452604e-01f, -4.82574441e-02f, 1.05341442e-01f, -2.69515276e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.02866864e+00f, 5.82225800e-01f, 2.34347731e-01f, 4.13420200e-02f, 7.94418275e-01f, 2.18057573e-01f, -1.08794026e-01f, -5.13939440e-01f, -6.44044429e-02f, 2.68179327e-01f,
  6.26154661e-01f, 1.40322044e-01f, 1.42644927e-01f, -2.19568223e-01f, -7.23824024e-01f, 1.66334540e-01f, 3.07904691e-01f, -5.09275079e-01f, -8.34712207e-01f, -5.17830789e-01f,
  1.18009925e-01f, -2.57825524e-01f, -6.40519857e-01f, -3.84955257e-01f, 4.51128632e-01f, 7.63560385e-02f, 3.76000851e-01f, 2.92747736e-01f, 2.73307949e-01f, 5.18600285e-01f,
  7.44852647e-02f, 2.33830567e-02f, -1.98005259e-01f, 1.52372330e-01f, 3.20033699e-01f, -4.14137363e-01f, -1.09339446e-01f, -1.31993130e-01f, 5.58371134e-02f, -1.16372205e-01f,
  3.05630028e-01f, -4.39790152e-02f, 3.52322549e-01f, -1.15439460e-01f, -1.29296049e-01f, -4.21555698e-01f, -3.13590527e-01f, -6.76102459e-01f, -5.42736888e-01f, -2.09938720e-01f,
  5.49476445e-01f, 3.46795261e-01f, -2.68906355e-01f, -3.96828562e-01f, -4.37380135e-01f, -2.94584543e-01f, -3.51199061e-01f, -3.80715370e-01f, -7.94626772e-01f, -5.76029062e-01f,
  -4.89666946e-02f, 1.17836840e-01f, 1.07584279e-02f, -8.33425894e-02f, -6.07489832e-02f, 8.51723850e-02f, 2.61312544e-01f, 1.14725836e-01f, 3.87180224e-02f, -3.45030129e-02f,
  1.66499704e-01f, -1.59153417e-01f, -1.75025314e-01f, 1.14424070e-02f, -3.55433375e-02f, -3.94140892e-02f, -1.44820781e-02f, -1.73482686e-01f, -1.18003320e-02f, -1.49692193e-01f,
  8.23634584e-03f, -7.14578852e-02f, 1.59972802e-01f, -1.33321747e-01f, 1.06385127e-01f, -1.10139325e-01f, -7.87589848e-02f, -1.10305816e-01f, -1.02685787e-01f, -5.13068959e-02f,
  -2.07044363e-01f, -1.60279483e-01f, -1.09901966e-03f, -1.39975756e-01f, 1.93693548e-01f, 1.21246271e-01f, 1.80475309e-01f, -5.53387357e-03f, 2.08513930e-01f, -1.38824061e-01f,
  -1.60190880e-01f, -1.75021067e-01f, 1.64520636e-01f, -6.75059408e-02f, -2.09684208e-01f, -5.71018644e-02f, 1.53997898e-01f, 4.98173162e-02f, -2.38208473e-01f, 1.96334589e-02f,
  8.70531127e-02f, -4.79318857e-01f, -5.96673548e-01f, -2.65137792e-01f, 1.22450024e-03f, -4.13065314e-01f, -3.14955592e-01f, -3.42222691e-01f, -5.97501874e-01f, -7.83242643e-01f,
  1.11888063e+00f, 6.44611359e-01f, 6.92024291e-01f, 4.05534506e-01f, -2.19658427e-02f, 2.70191431e-01f, 5.01900494e-01f, 4.11524355e-01f, 1.58901528e-01f, 3.55836749e-01f,
  -5.69813186e-03f, -1.50836676e-01f, -1.02092952e-01f, -2.27641407e-02f, 3.26329380e-01f, 2.40831658e-01f, 1.79097459e-01f, 2.28884012e-01f, 2.57084280e-01f, 1.11352250e-01f,
  -1.00292072e-01f, -6.83195218e-02f, 1.71125587e-02f, 2.00344563e-01f, -1.10545969e-02f, -5.70261143e-02f, 4.86113355e-02f, 1.09296320e-02f, -3.51616926e-02f, 4.52093892e-02f,
  -1.29317924e-01f, 3.69008005e-01f, -3.44646245e-01f, -3.23218524e-01f, -2.42971212e-01f, -4.85848710e-02f, 5.08616157e-02f, -2.22525224e-01f, -3.61385979e-02f, 1.94178503e-02f,
  -2.70968348e-01f, -1.39389589e-01f, -4.98880222e-02f, 2.46601421e-02f, -8.76078829e-02f, -1.49692094e-03f, -3.04885134e-02f, 8.26638341e-02f, -1.28704878e-02f, -5.71029559e-02f,
  -3.17932457e-01f, -1.02158487e-01f, 8.35423693e-02f, 1.23066232e-01f, 1.17284596e-01f, -1.81732953e-01f, 8.58407915e-02f, 9.39224139e-02f, 8.58059675e-02f, 2.82123238e-01f,
  -4.41209599e-02f, 1.84275106e-01f, 1.80683076e-01f, 1.64350033e-01f, 5.46536744e-02f, 1.55244514e-01f, 2.84302067e-02f, -1.40571624e-01f, -1.61601938e-02f, 2.38519032e-02f,
  -8.12169630e-03f, 9.63289961e-02f, 1.26568556e-01f, 1.43101662e-01f, -1.49049014e-01f, 1.18850835e-01f, -1.54091660e-02f, -1.30409114e-02f, -1.18342433e-02f, -1.08286515e-01f,
  8.60388801e-02f, -3.42914909e-02f, 4.19255458e-02f, 1.17053464e-01f, -6.96967244e-02f, 8.79302546e-02f, 6.72062933e-02f, -1.30141348e-01f, -6.88385591e-02f, -4.28596810e-02f,
  -5.94239473e-01f, -2.15185195e-01f, -8.62386227e-02f, -3.06691546e-02f, -5.08024395e-02f, -9.66296494e-02f, -1.47528220e-02f, -2.02236161e-01f, -1.53597698e-01f, 1.14499712e-02f,
  -2.92706434e-02f, 1.30633950e-01f, -6.63130283e-02f, 4.44265604e-02f, -4.20160927e-02f, -6.73807785e-02f, -1.26225457e-01f, -5.18763298e-03f, -3.78050841e-02f, -8.86807516e-02f,
  -1.42993942e-01f, -2.74595041e-02f, -1.92511342e-02f, -2.34172884e-02f, -2.68340595e-02f, -2.14323387e-01f, -6.11670613e-02f, -1.13301672e-01f, 1.24027366e-02f, 9.38021950e-03f,
  8.32066298e-01f, -2.59980977e-01f, 4.65067923e-01f, 2.57832110e-01f, 4.52942252e-01f, 4.61526662e-01f, 3.32403570e-01f, 1.15036622e-01f, 5.47767133e-02f, -6.80234507e-02f,
  -1.38060749e-01f, -2.05654502e-01f, -1.81034386e-01f, -2.09550068e-01f, -1.31893426e-01f, -1.32309139e-01f, -6.89853914e-03f, 3.28520507e-01f, 3.74184489e-01f, 1.45255104e-01f,
  -2.48202026e-01f, 4.93122414e-02f, 1.90773636e-01f, 5.01663536e-02f, -2.47662082e-01f, -8.80535766e-02f, -2.87780967e-02f, 1.49146263e-02f, -1.90978087e-02f, -3.54843318e-01f,
  -4.04405087e-01f, 1.22960359e-01f, -7.72906584e-04f, -1.96468338e-01f, -4.61593829e-02f, -9.49169472e-02f, -7.20080212e-02f, -1.07723780e-01f, -1.50593862e-01f, -1.14468299e-01f,
  -9.31853950e-02f, 3.18158939e-02f, 5.23942299e-02f, -3.66789773e-02f, 5.86228780e-02f, 7.25812390e-02f, -3.70463356e-02f, -1.80081744e-02f, -1.34124041e-01f, -8.55566487e-02f,
  -9.35306549e-02f, 8.75259340e-02f, 1.59279808e-01f, -5.64058460e-02f, 7.31594041e-02f, 7.35949874e-02f, -9.10810661e-03f, -1.36282742e-01f, 1.29042313e-01f, -3.72477844e-02f,
  3.18279229e-02f, 3.16436850e-02f, -1.73597771e-03f, 7.88499489e-02f, 8.28215554e-02f, 1.24082960e-01f, 7.37646297e-02f, 1.51815694e-02f, 2.38168865e-01f, 7.96100199e-02f,
  -3.94329391e-02f, 1.43836349e-01f, 1.82928488e-01f, -9.66169089e-02f, -5.29680774e-03f, 6.75857216e-02f, 8.52201879e-02f, -6.72552735e-02f, 1.18518539e-01f, -1.37599846e-02f,
  9.30590928e-03f, -2.75368039e-02f, -6.23895675e-02f, -2.10488200e-01f, -3.01102940e-02f, 1.15519157e-02f, -4.83911522e-02f, -4.05138778e-03f, 4.85368893e-02f, -2.26809774e-02f,
  -5.27367055e-01f, 5.42870104e-01f, -1.07773907e-01f, -1.31562918e-01f, 3.54167335e-02f, -3.55828833e-03f, 1.59619059e-02f, -1.49562567e-01f, -2.07774103e-01f, -1.29621059e-01f,
  -2.97412425e-02f, 4.64670323e-02f, 1.23216249e-02f, -6.88122734e-02f, 2.67983854e-01f, 1.11271225e-01f, -4.89852652e-02f, -6.83540553e-02f, -1.88462600e-01f, -1.84910655e-01f,
  -1.16376549e-01f, 2.19918177e-01f, 1.24194562e-01f, 1.13114499e-01f, 1.07992105e-01f, 2.58584738e-01f, 1.97922349e-01f, 1.15947545e-01f, 2.02704519e-01f, 2.20184028e-01f,
  4.54006910e-01f, -4.25681651e-01f, -5.30402720e-01f, 4.32675302e-01f, -4.12704438e-01f, -7.55015135e-01f, -1.03798103e+00f, -3.46732020e-01f, 2.93041766e-01f, -4.19732094e-01f,
  -4.16530371e-01f, 1.67637408e-01f, -5.09437136e-02f, -7.09780678e-02f, -4.10430372e-01f, -6.57127023e-01f, -2.86889911e-01f, 1.13817304e-01f, 2.69908398e-01f, 8.23995993e-02f,
  1.62549511e-01f, 3.49163085e-01f, 5.21386802e-01f, 2.85597324e-01f, 5.24878383e-01f, 3.21514100e-01f, 9.55682322e-02f, 2.82057405e-01f, -1.14938371e-01f, 3.10842723e-01f,
  8.83429945e-02f, 8.40922892e-02f, -1.21972553e-01f, 2.22963810e-01f, -5.56631535e-02f, 5.61011620e-02f, -2.02035844e-01f, 2.44324714e-01f, -2.37734839e-01f, 4.69481200e-02f,
  -1.81797102e-01f, 3.10670827e-02f, 3.42543311e-02f, -5.39014302e-03f, 7.69962221e-02f, -2.02686533e-01f, -3.69350836e-02f, 2.32507847e-02f, -1.69643298e-01f, 5.31515330e-02f,
  -7.38393217e-02f, -1.84585787e-02f, -3.70905221e-01f, -3.38633537e-01f, -6.42694160e-02f, 3.26197334e-02f, -2.08688021e-01f, 2.27838606e-01f, -2.57408291e-01f, 2.30325997e-01f,
  1.81450084e-01f, -2.64533404e-02f, -1.36934638e-01f, -1.29867956e-01f, -5.29723167e-02f, -1.89490411e-02f, 6.53961152e-02f, -3.94991646e-03f, 4.69459109e-02f, -2.61284765e-02f,
  -6.04555644e-02f, -1.44766942e-02f, 1.77082375e-01f, 7.83905853e-03f, 2.80870572e-02f, 6.79036975e-02f, -6.25706688e-02f, 6.75191954e-02f, 1.00304075e-01f, 1.83598623e-01f,
  6.75173998e-02f, -1.32892996e-01f, 1.00779779e-01f, -5.83661497e-02f, -1.99286729e-01f, -6.91423938e-02f, 2.00792238e-01f, -2.47807987e-02f, 1.09003872e-01f, 6.00081012e-02f,
  2.10916951e-01f, -4.81601119e-01f, -8.33654702e-02f, 1.53138071e-01f, -4.62684557e-02f, 1.10663749e-01f, 4.58428301e-02f, -9.25082937e-02f, -1.20018832e-01f, 6.52106805e-03f,
  -2.54155308e-01f, -2.22359493e-01f, -6.09035268e-02f, 7.99847841e-02f, -7.83481542e-03f, -1.43996194e-01f, -2.42886350e-01f, -2.83347189e-01f, -1.82974488e-01f, -6.43284693e-02f,
  -1.88225597e-01f, -2.34459952e-01f, -5.43490648e-01f, -6.01193249e-01f, -1.04417637e-01f, -4.65681016e-01f, -3.19100827e-01f, -2.37160966e-01f, -7.87308156e-01f, -7.29294360e-01f,
  -5.57733238e-01f, -7.36360252e-01f, 3.76168750e-02f, -8.44909430e-01f, -3.30204487e-01f, 1.97497755e-01f, -2.30758488e-02f, -1.65100724e-01f, -3.95273983e-01f, -4.48255301e-01f,
  2.20795661e-01f, 5.47252536e-01f, 3.40390444e-01f, 4.13470358e-01f, 5.04177868e-01f, -4.75646675e-01f, -5.67953885e-01f, 3.07554360e-02f, 4.44758385e-01f, 2.02032000e-01f,
  -2.13753000e-01f, -5.87090373e-01f, -4.42807734e-01f, -3.02611172e-01f, -7.27952480e-01f, -5.81613369e-02f, -6.10482752e-01f, -4.95307535e-01f, 2.94700675e-02f, -6.92685246e-01f,
  2.62005061e-01f, -3.00611164e-02f, 1.48481324e-01f, -9.42657441e-02f, -2.39993244e-01f, 1.22071013e-01f, 1.17426915e-02f, -2.21745923e-01f, 2.35726144e-02f, -7.06808735e-03f,
  -1.08755775e-01f, -2.15407480e-02f, -8.60557985e-03f, -7.02403560e-02f, -3.11469167e-01f, -1.01663703e-02f, -3.60293716e-01f, -2.06275135e-01f, 3.24171148e-02f, 4.55717407e-02f,
  -2.06202939e-01f, 1.10257842e-01f, 2.53106594e-01f, 1.68414906e-01f, 1.81154385e-01f, 2.90040135e-01f, 1.27605677e-01f, 7.82680362e-02f, 1.49406642e-01f, -5.87470114e-01f,
  -8.67785141e-02f, -8.06072429e-02f, -3.22372727e-02f, -1.58668593e-01f, -8.61883610e-02f, -3.00899129e-02f, 6.45138323e-02f, -1.61793712e-03f, -3.97628881e-02f, -1.13157377e-01f,
  2.54388265e-02f, 8.17124173e-02f, 2.75021251e-02f, 5.85190021e-02f, -6.44498765e-02f, -4.61726189e-02f, 6.03406467e-02f, -1.71461627e-01f, 3.69040333e-02f, -2.08115429e-02f,
  7.30739683e-02f, 7.74656236e-02f, -5.02726659e-02f, -1.27378395e-02f, 6.02551959e-02f, -4.28505316e-02f, 2.58187037e-02f, 1.45269915e-01f, 6.57246038e-02f, 3.40772048e-02f,
  1.98035613e-01f, 3.85184139e-01f, -6.41511902e-02f, 6.12838641e-02f, -2.21188530e-01f, -1.39159076e-02f, -3.50551344e-02f, 3.70388385e-03f, 1.01436153e-01f, 5.24303615e-02f,
  6.19454533e-02f, 6.03174530e-02f, -5.02963848e-02f, -1.16316363e-01f, -1.42348809e-02f, 1.93901639e-02f, -2.42084727e-01f, -1.02199979e-01f, 3.65969203e-02f, -2.45705009e-01f,
  -3.57937753e-01f, 6.60729855e-02f, 2.83480495e-01f, 1.88101336e-01f, 9.89862252e-03f, 2.78762758e-01f, 1.04821622e-01f, 1.23959258e-01f, 3.59004259e-01f, -4.21373069e-01f,
  -7.19640732e-01f, 4.45551068e-01f, 1.16832569e-01f, -9.24594581e-01f, -8.48947391e-02f, 3.95692468e-01f, 8.30570042e-01f, 4.35482621e-01f, -2.77295470e-01f, 8.14438164e-02f,
  2.06482112e-01f, -4.02909279e-01f, -5.70171714e-01f, -2.76649386e-01f, -1.53694540e-01f, 1.63124382e-01f, -5.84271729e-01f, -6.66642725e-01f, -2.11487636e-01f, 3.77748013e-01f,
  1.26514314e-02f, -4.53036129e-01f, -5.64372182e-01f, -3.43440831e-01f, -2.73637235e-01f, -6.06696010e-01f, -3.68787467e-01f, -4.96165305e-01f, -3.91253643e-02f, -5.81051230e-01f,
  6.29556119e-01f, -5.60918786e-02f, -1.13884151e-01f, -5.39035320e-01f, -6.78228587e-02f, -8.95757005e-02f, 3.14259566e-02f, -3.40990067e-01f, -4.20482099e-01f, 4.20687022e-03f,
  -4.20295924e-01f, 8.80456045e-02f, -3.04349571e-01f, 9.11541805e-02f, -6.24263100e-02f, 3.74636501e-02f, -1.99958995e-01f, -6.84773624e-02f, 3.14413048e-02f, 7.70145535e-01f,
  3.99923623e-01f, -2.05102816e-01f, -1.93567678e-01f, 1.79964364e-01f, 2.38438770e-01f, -1.53933093e-01f, 4.09652799e-01f, 6.60622790e-02f, -5.16927391e-02f, -9.16471481e-02f,
  1.43440619e-01f, 2.95298286e-02f, 6.59697354e-02f, 1.76591679e-01f, -5.36535792e-02f, 4.36006226e-02f, -2.54355043e-01f, 1.51963318e-02f, 5.60180731e-02f, 4.64023761e-02f,
  4.77316305e-02f, 3.52516741e-01f, 3.50339413e-02f, -2.10343808e-01f, -2.19810382e-01f, -1.87152587e-02f, 8.07569176e-02f, 6.83576167e-02f, -8.99973214e-02f, -2.31549561e-01f,
  -1.17951654e-01f, -1.69698924e-01f, -3.66869234e-02f, 1.28311321e-01f, -5.10562696e-02f, -8.67143497e-02f, 1.28757805e-01f, 1.44430459e-01f, 1.62319973e-01f, 2.38831760e-03f,
  -1.40272126e-01f, -3.07348352e-02f, -1.39959350e-01f, -2.04133779e-01f, 7.01127946e-02f, -6.45801127e-02f, -2.32698008e-01f, -5.13085490e-03f, -2.82626748e-01f, 2.04899460e-02f,
  9.57105830e-02f, 6.60822392e-02f, -5.64789213e-02f, 9.42975283e-02f, 7.86643773e-02f, 6.21181242e-02f, -4.57650982e-02f, -1.92766249e-01f, -6.44584745e-02f, 1.77961364e-01f,
  4.02573831e-02f, -1.01225302e-01f, -2.78390646e-01f, -1.77411631e-01f, 3.59947644e-02f, -4.39267159e-01f, 1.13545477e-01f, 1.84045866e-01f, -1.49826154e-01f, 8.07875693e-02f,
  -2.64911473e-01f, -9.23294649e-02f, -1.32718277e+00f, 4.14744876e-02f, 2.14510667e-03f, 1.32177270e-03f, 4.95453924e-01f, 4.16425049e-01f, 1.78140640e-01f, -3.89051773e-02f,
  7.72054493e-02f, 2.88786590e-01f, -9.16667506e-02f, 1.84084654e-01f, 1.87300041e-01f, -2.95633655e-02f, -1.96712703e-01f, -3.57179761e-01f, 6.36907518e-02f, 6.25431836e-01f,
  6.91390991e-01f, 3.97202969e-01f, 1.19308811e-02f, 9.50635448e-02f, 5.28381858e-03f, 5.79640828e-02f, -3.51074487e-01f, -1.71841264e-01f, -1.40797272e-01f, -5.01737118e-01f,
  -8.90639484e-01f, -3.86664331e-01f, -9.06012282e-02f, -1.46914748e-02f, -3.52264911e-01f, -3.24722201e-01f, -1.05065852e-01f, -4.58341897e-01f, -1.06103614e-01f, -1.43279985e-01f,
  -3.53083462e-01f, -9.35025960e-02f, 9.03944112e-03f, -4.86486591e-02f, 1.94913134e-01f, 5.02471477e-02f, 3.08605228e-02f, -2.52401412e-01f, -4.21793520e-01f, -3.54234099e-01f,
  3.60255092e-01f, -2.39348233e-01f, -8.89348209e-01f, -1.01663582e-01f, -2.74890751e-01f, -3.73772323e-01f, -3.28824937e-01f, -2.38134637e-01f, -5.60537755e-01f, -4.30908382e-01f,
  1.26674503e-01f, -9.12059620e-02f, 8.51264372e-02f, 3.02059334e-02f, 3.34074020e-01f, 4.16213227e-03f, 8.76647532e-02f, 1.62639841e-01f, 5.12511879e-02f, 4.95976908e-03f,
  -1.37891276e-02f, -1.09893396e-01f, 5.59339561e-02f, -1.04592778e-01f, 1.23093911e-01f, -1.28847733e-01f, 4.68374416e-02f, 1.52384073e-01f, -4.62646261e-02f, 1.15114339e-01f,
  6.72590584e-02f, -3.83886136e-02f, -1.83377732e-02f, 2.09336922e-01f, -6.46934733e-02f, -6.59067482e-02f, -5.00417650e-02f, 2.00417399e-01f, 8.62905979e-02f, -2.64295563e-02f,
  3.88723701e-01f, 1.44622818e-01f, -2.19649002e-01f, 7.71420524e-02f, -2.39336208e-01f, -9.12997201e-02f, 5.05109802e-02f, 6.49620593e-02f, -1.83076367e-01f, -1.08257964e-01f,
  -2.50174850e-02f, -9.79812723e-03f, 1.38845384e-01f, 5.27695790e-02f, 1.23918787e-01f, -1.12669475e-01f, 2.58484989e-01f, -8.42533261e-02f, 7.93002993e-02f, -5.42917475e-02f,
  3.00813317e-01f, 2.45298579e-01f, -2.48566791e-01f, -1.79370835e-01f, 1.02402538e-01f, 9.66671780e-02f, -1.90515324e-01f, 2.25198399e-02f, -3.61557037e-01f, 1.44091710e-01f,
  7.25523412e-01f, 6.46857381e-01f, 3.24121565e-01f, 1.46558270e-01f, 2.31917009e-01f, -2.18804479e-02f, 2.06501156e-01f, -1.42196892e-02f, -1.49829417e-01f, 2.38611504e-01f,
  2.84383863e-01f, -1.73944280e-01f, -2.54077762e-01f, -2.36206532e-01f, -1.67328089e-01f, -1.83606386e-01f, -1.92820400e-01f, -6.26535341e-02f, -1.17487632e-01f, 2.74499476e-01f,
  8.25371295e-02f, 5.07873178e-01f, 3.54071856e-01f, 3.75083573e-02f, 4.14174318e-01f, -1.35337502e-01f, 7.16695413e-02f, 4.52032715e-01f, 3.11717898e-01f, 4.87216324e-01f,
  4.26810801e-01f, 4.90919590e-01f, -5.02083957e-01f, -1.22964956e-01f, 1.55320212e-01f, -7.92997330e-02f, -9.15967077e-02f, -1.26597388e-02f, -1.42897949e-01f, -4.79502194e-02f,
  1.26897812e-01f, 9.86280814e-02f, 9.40131769e-02f, -3.81963397e-03f, 3.02151367e-02f, -1.16705604e-01f, 3.08013167e-02f, -1.16942413e-01f, -2.85513818e-01f, 9.76455957e-02f,
  -9.70477909e-02f, 2.47605696e-01f, 4.15776446e-02f, -4.17426437e-01f, -2.80417979e-01f, -3.16221178e-01f, 6.67881966e-02f, -4.68793809e-02f, -1.32726803e-01f, -1.00415431e-01f,
  -4.59625661e-01f, -2.37721056e-02f, 3.38508040e-02f, -1.65316444e-02f, -8.33288506e-02f, -6.57663792e-02f, -1.36988580e-01f, -7.76867568e-03f, -1.47838339e-01f, 7.37390667e-02f,
  -1.94657937e-01f, -1.88117474e-01f, -1.55364126e-01f, -1.47435054e-01f, -2.93628246e-01f, 3.53612117e-02f, 1.07181631e-01f, -1.32319480e-01f, -1.16231382e-01f, -3.76567319e-02f,
  2.40306482e-02f, -5.19247428e-02f, 7.67992064e-03f, -7.12194890e-02f, -9.46120173e-02f, -2.19181702e-01f, -1.80977762e-01f, -9.63786319e-02f, -1.88539535e-01f, 4.31527793e-02f,
  -1.08585782e-01f, -3.21021318e-01f, 1.41584512e-03f, 1.06658205e-01f, 2.77849436e-01f, 1.18567407e-01f, -4.23465185e-02f, 4.63488735e-02f, 1.68367773e-01f, -1.04306549e-01f,
  1.91132307e-01f, 1.58905704e-02f, 1.12477213e-01f, -1.37024187e-02f, 1.20743737e-02f, -3.47274020e-02f, 2.14622036e-01f, 1.53999820e-01f, -1.43754900e-01f, 5.64560294e-02f,
  -4.13747095e-02f, -6.15208261e-02f, -2.85756618e-01f, -5.49543202e-01f, -2.76163280e-01f, -3.97825092e-01f, -1.20727345e-01f, -8.10015295e-03f, -1.24513596e-01f, -1.99064106e-01f,
  2.00583085e-01f, -5.31822979e-01f, -5.04884660e-01f, 1.78612042e-02f, -1.52468115e-01f, -2.21114755e-01f, -8.10803950e-01f, 5.17365374e-02f, 3.31633657e-01f, -8.42909276e-01f,
  -4.06317621e-01f, 3.09349924e-01f, -8.62616822e-02f, -1.23092249e-01f, -3.74654442e-01f, -9.44239616e-01f, -7.43211687e-01f, -3.04747432e-01f, 1.67600811e-01f, 7.73149729e-03f,
  -1.99115679e-01f, -7.71488936e-04f, 7.89759234e-02f, 1.27458706e-01f, 8.73659328e-02f, 2.29560807e-01f, -2.09615573e-01f, -1.93907730e-02f, -3.23277086e-01f, -3.83272737e-01f,
  -5.46257734e-01f, 2.32575804e-01f, 6.69625401e-02f, 9.99455377e-02f, -8.95420760e-02f, -3.63923796e-02f, -1.88472003e-01f, 1.23080730e-01f, 8.76702517e-02f, -1.61246523e-01f,
  -7.85181001e-02f, 1.75250426e-01f, 7.51742721e-02f, 4.44691489e-03f, -3.55498493e-02f, -4.36102692e-03f, 7.29072765e-02f, 1.94533452e-01f, -8.94318670e-02f, -1.28892750e-01f,
  -2.86779463e-01f, -9.90357324e-02f, -7.93984905e-02f, 1.86013371e-01f, 2.42525995e-01f, 1.11505970e-01f, 1.71324685e-01f, 3.84957045e-01f, 1.36625439e-01f, -1.36120349e-01f,
  1.74203496e-02f, -1.35047389e-02f, -2.66732927e-02f, 3.11287105e-01f, 1.17206261e-01f, 4.51801941e-02f, 2.11792476e-02f, -2.80831993e-01f, 8.61460045e-02f, 1.75924852e-01f,
  5.35136387e-02f, -1.60657495e-01f, 4.82395776e-02f, -1.74542665e-01f, -1.76194355e-01f, -1.62438288e-01f, -4.37592976e-02f, -1.01099975e-01f, -1.33124590e-01f, 1.76886395e-02f,
  4.82634306e-02f, 1.32275164e-01f, 8.32370147e-02f, 5.95259331e-02f, 9.75622702e-03f, -1.23996139e-01f, 2.67180684e-03f, 6.40313923e-02f, 1.49642453e-01f, 9.48394537e-02f,
  7.76149035e-02f, -1.73263699e-01f, -3.85541111e-01f, -7.65050352e-02f, -2.41970941e-01f, 3.36205661e-02f, -1.58546835e-01f, 1.36167388e-02f, 7.15895742e-02f, -8.75551626e-02f,
  2.27842527e-03f, -1.17868118e-01f, -1.53372645e-01f, -5.76895811e-02f, -7.42069408e-02f, 1.07515074e-01f, -3.05225998e-01f, -2.05999017e-01f, 6.92095459e-02f, 3.33160050e-02f,
  -1.55127198e-01f, -2.31162816e-01f, -3.62453938e-01f, -1.46289751e-01f, 1.48426294e-01f, 3.36860605e-02f, -1.56449392e-01f, -4.55262102e-02f, -2.98485637e-01f, -6.10599577e-01f,
  6.85108423e-01f, -3.13444855e-03f, -8.39825690e-01f, 1.97211906e-01f, -5.50678790e-01f, -5.80740631e-01f, -5.99868715e-01f, 4.43810560e-02f, 1.23582117e-01f, -3.16687077e-01f,
  -3.05063307e-01f, 1.52939975e-01f, 2.07486778e-01f, 3.92120257e-02f, 3.22851613e-02f, -4.67281163e-01f, -5.68785191e-01f, -2.89665818e-01f, -3.10297936e-01f, -5.12488484e-01f,
  -2.99692303e-01f, -9.26846340e-02f, 3.89395319e-02f, 5.18497750e-02f, -1.28799602e-01f, -1.38276070e-01f, -3.08591753e-01f, -2.71638155e-01f, -4.59355325e-01f, -3.88938189e-01f,
  -3.04734707e-01f, -9.77513045e-02f, -2.85359123e-03f, 4.57610898e-02f, -1.06644809e-01f, -1.78581197e-02f, 5.46967126e-02f, 3.87277044e-02f, 4.75905277e-02f, 6.07943609e-02f,
  -8.55915025e-02f, -4.46904860e-02f, 5.54227680e-02f, -1.33138642e-01f, -1.45282373e-01f, -1.84977159e-01f, -1.06841572e-01f, -1.13325387e-01f, -5.76793551e-02f, -2.51818955e-01f,
  -2.42181987e-01f, -2.73922294e-01f, 3.37982550e-03f, -8.01928863e-02f, -1.51764497e-01f, -1.11851893e-01f, -5.46177961e-02f, -8.98008645e-02f, -4.78893146e-02f, 1.70132995e-01f,
  9.51746181e-02f, 5.83774894e-02f, -1.09231435e-01f, -1.65664703e-02f, 1.91841573e-02f, -9.87924635e-02f, -2.00823369e-03f, 3.94165739e-02f, -8.86757597e-02f, 1.18118346e-01f,
  8.86743963e-02f, -1.20371459e-02f, -2.02219132e-02f, 5.70057556e-02f, -2.47329324e-02f, -2.17835680e-02f, -3.94969247e-02f, 8.03441703e-02f, 6.48584589e-02f, -1.86410807e-02f,
  -5.83296828e-02f, -1.16633549e-01f, 6.49496689e-02f, 8.56901035e-02f, -1.82966501e-01f, -6.78242818e-02f, 3.22748870e-02f, 1.45107349e-02f, 6.46204948e-02f, -2.19442949e-01f,
  7.26178110e-01f, 1.52896523e-01f, 3.28072846e-01f, 9.82307643e-02f, -7.42864832e-02f, -8.02424178e-02f, -3.19723599e-02f, -5.51250158e-03f, 1.34500312e-02f, 1.09697934e-02f,
  -1.25394031e-01f, 1.85334221e-01f, 7.91133270e-02f, -1.35739610e-01f, -8.14743489e-02f, -1.52795821e-01f, 4.80407216e-02f, -7.68452734e-02f, -3.43369991e-02f, -2.32010797e-01f,
  -3.30142975e-02f, 2.12843250e-02f, 3.46480936e-01f, 1.32821709e-01f, 8.31455737e-02f, 1.80839241e-01f, 1.21668935e-01f, 1.83543172e-02f, 1.38650149e-01f, 4.14770305e-01f,
  -6.91152096e-01f, -2.26421446e-01f, 2.65386194e-01f, 1.11060448e-01f, 2.00585276e-01f, 2.75272548e-01f, 8.07535872e-02f, -1.91221088e-02f, 7.03885406e-02f, 4.93977442e-02f,
  1.44764200e-01f, 3.66996467e-01f, 4.59438205e-01f, 3.46256673e-01f, 2.17080370e-01f, 3.26124579e-01f, 3.11997861e-01f, 1.98940501e-01f, 2.77444541e-01f, 9.28078964e-02f,
  2.40325674e-01f, -1.08039714e-01f, -3.16339433e-01f, 4.35382873e-02f, 2.04127625e-01f, 4.31480855e-01f, 3.63974348e-02f, 5.33044711e-03f, 1.92520395e-01f, 2.51640081e-01f,
  5.44037640e-01f, -3.34861845e-01f, 2.52122581e-01f, -4.77136485e-02f, -1.46841124e-01f, -2.63087422e-01f, -3.43972258e-03f, -2.49166444e-01f, -1.24414936e-01f, -7.76064619e-02f,
  -4.95125800e-02f, -1.31515071e-01f, -5.39331092e-03f, -1.56493172e-01f, -2.10381523e-01f, -2.03862637e-01f, -1.66043684e-01f, -6.40840158e-02f, 1.88661683e-02f, 7.65178949e-02f,
  9.56713185e-02f, 7.55405501e-02f, 6.72553778e-02f, 1.04491144e-01f, 1.09988578e-01f, 4.31319885e-02f, -1.04591981e-01f, 1.08502582e-02f, 1.64405387e-02f, -7.38853142e-02f,
  1.08400494e-01f, 1.74914509e-01f, 1.91839203e-01f, 9.31903943e-02f, 3.08638681e-02f, -4.89667393e-02f, -7.02904025e-03f, 1.38314769e-01f, 6.88091218e-02f, -7.26170242e-02f,
  2.02655122e-01f, 2.42804542e-01f, 7.69648328e-02f, -3.07137482e-02f, 1.15781143e-01f, 1.61657929e-02f, 1.32871568e-01f, 1.24820687e-01f, 5.09059541e-02f, 3.85598280e-02f,
  1.00498065e-01f, -6.30173981e-02f, -2.28153676e-01f, -2.72032879e-02f, -7.20273703e-02f, 9.21407491e-02f, -3.80320998e-04f, 1.70019597e-01f, 4.14531268e-02f, -9.53344926e-02f,
  3.07583928e-01f, 1.51973650e-01f, 2.95264781e-01f, -6.91967923e-03f, -1.52161703e-01f, -2.66353279e-01f, 1.79971874e-01f, -1.46739319e-01f, -2.26183146e-01f, 7.89754540e-02f,
  -2.73181684e-03f, -1.39645144e-01f, -3.82437967e-02f, -6.45329580e-02f, 3.37939872e-03f, -8.85479897e-02f, -1.05093576e-01f, -4.62469496e-02f, 7.60888904e-02f, -9.33904573e-02f,
  -1.19680539e-01f, 7.95625336e-03f, 3.90222549e-01f, 2.03594416e-01f, 4.09015156e-02f, 1.66231558e-01f, 1.18629798e-01f, 9.90448967e-02f, 1.65441230e-01f, 7.73783624e-02f,
  6.42770290e-01f, 4.68359292e-01f, -3.18064898e-01f, 4.66438204e-01f, 2.44164959e-01f, 2.38740429e-01f, 4.00013745e-01f, 5.28794527e-01f, 4.94465858e-01f, 3.39230090e-01f,
  1.22808650e-01f, 2.33961090e-01f, 2.48827279e-01f, 8.57066363e-02f, 2.63085991e-01f, 3.97215784e-01f, 2.81110466e-01f, -3.05037852e-02f, -6.44561425e-02f, 2.27484897e-01f,
  3.45080584e-01f, 2.28135645e-01f, -1.63418185e-02f, 1.78004876e-01f, 2.00014368e-01f, 8.59600082e-02f, 1.60480008e-01f, -5.30398861e-02f, -8.11639708e-03f, 1.83773324e-01f,
  -6.52719498e-01f, -2.22126633e-01f, 9.22721103e-02f, -4.31092381e-02f, -2.44768232e-01f, -5.51298670e-02f, -1.06141299e-01f, 2.62373295e-02f, 1.11151338e-01f, 5.35458252e-02f,
  -1.53085619e-01f, -3.59714516e-02f, -1.72503889e-01f, -6.11345842e-02f, -8.46226364e-02f, -1.57729268e-01f, -3.63023416e-03f, 8.71079192e-02f, 4.00671847e-02f, -1.26702964e-01f,
  -8.41229036e-02f, -1.58755153e-01f, -1.33474410e-01f, -9.19159725e-02f, -4.32736687e-02f, 5.55875245e-03f, -5.31697758e-02f, 1.18295671e-02f, -1.62456036e-01f, 9.52805877e-02f,
  3.93641070e-02f, -2.73501724e-02f, -2.69446880e-01f, -1.29861236e-02f, -9.35118347e-02f, -8.62029120e-02f, -2.99424250e-02f, -2.89930496e-02f, 3.77045013e-02f, -4.56309598e-03f,
  4.41272780e-02f, -9.38951075e-02f, -3.30041125e-02f, -4.67927121e-02f, -2.51484998e-02f, -1.69697180e-02f, 3.36245783e-02f, -2.75178581e-01f, -4.06546324e-01f, -2.52169490e-01f,
  -1.13296568e-01f, 1.01959109e-02f, -1.85866490e-01f, -1.88483953e-01f, -3.54203619e-02f, -5.58740757e-02f, 9.28812772e-02f, -7.47034252e-02f, 1.28125980e-01f, 2.02892184e-01f,
  2.65737802e-01f, -4.83514637e-01f, 1.27058234e-02f, 1.80041492e-01f, -1.60608619e-01f, -4.31372039e-02f, -1.21955745e-01f, -9.96628627e-02f, -1.75436839e-01f, -1.38057396e-01f,
  -1.22675635e-01f, -8.17849338e-02f, -1.06765769e-01f, -4.42076214e-02f, -1.25497252e-01f, 1.28222397e-03f, 2.66740918e-02f, 2.18936458e-01f, -5.32168709e-02f, -8.66227448e-02f,
  1.32484794e-01f, 1.63851768e-01f, 2.06109345e-01f, 2.42579728e-02f, 9.66877341e-02f, 5.79219460e-02f, -1.20993480e-01f, -4.48305532e-02f, 3.70921306e-02f, 3.22309673e-01f,
  -3.80223304e-01f, 3.70802402e-01f, 5.85942745e-01f, -5.32992482e-01f, -6.45334780e-01f, -1.51386544e-01f, 3.38621378e-01f, 1.11682795e-01f, -4.79281634e-01f, -2.48535145e-02f,
  -4.26701099e-01f, -7.80570030e-01f, -2.81144410e-01f, 1.40062094e-01f, 5.01748681e-01f, 9.24910069e-01f, 7.44682193e-01f, 6.06629729e-01f, -1.32443696e-01f, -3.45776767e-01f,
  -2.20400035e-01f, -6.16358258e-02f, -5.82097750e-03f, 2.74018705e-01f, -1.76330525e-02f, -2.18637407e-01f, 3.21109653e-01f, 8.29383507e-02f, 3.79747242e-01f, 4.57766622e-01f,
  4.53188270e-02f, -5.91467246e-02f, -1.40274584e-01f, -5.43117166e-01f, -2.19255045e-01f, 8.21578577e-02f, -2.14629639e-02f, 3.45212780e-02f, -1.21314555e-01f, 2.36804292e-01f,
  -2.71858662e-01f, -9.95193049e-02f, -2.59904385e-01f, -7.44820479e-03f, -1.66401640e-01f, -1.20035045e-01f, 2.05278248e-01f, 2.70458698e-01f, 2.80872792e-01f, -8.16051587e-02f,
  -1.24094777e-01f, -4.59901989e-01f, -3.73075128e-01f, 1.05383202e-01f, 2.96112984e-01f, -3.32818598e-01f, 1.98496971e-02f, -1.39142722e-01f, -3.11207511e-02f, 1.83883667e-01f,
  -4.52459045e-02f, -6.70775473e-02f, 3.22358832e-02f, 4.71801944e-02f, 1.00279883e-01f, -6.65115118e-02f, 5.96674383e-02f, 1.12085290e-01f, 7.05403760e-02f, 4.05327417e-03f,
  1.40065169e-02f, -2.24415153e-01f, 1.96649730e-02f, -2.86234240e-03f, -1.74862340e-01f, -9.89021286e-02f, -1.78928021e-02f, 1.67780504e-01f, 8.55348334e-02f, 3.46691012e-02f,
  -1.52511075e-01f, 1.57492444e-01f, -1.66518435e-01f, 2.12424144e-01f, -2.17166822e-02f, 3.89367677e-02f, -9.88794211e-03f, -1.63611084e-01f, -4.90403408e-03f, -4.97468971e-02f,
  -3.30606043e-01f, 1.36747092e-01f, -1.68486815e-02f, 1.95266455e-01f, 1.16492147e-02f, -1.50402680e-01f, -1.40013143e-01f, -1.40787929e-01f, -3.23976427e-01f, -8.50536153e-02f,
  -2.19271392e-01f, -2.61008173e-01f, -5.01423404e-02f, -5.03912978e-02f, -2.45691910e-01f, -2.27830619e-01f, -3.26349437e-02f, -4.44090873e-01f, -1.75049186e-01f, -2.31174216e-01f,
  2.44338308e-02f, -3.21466476e-01f, -7.11165488e-01f, -2.99071848e-01f, -1.79146081e-01f, -7.12454140e-01f, -2.14003846e-01f, -3.37083012e-01f, -4.27954942e-01f, -1.89520583e-01f,
  1.02809560e+00f, -6.99937701e-01f, 3.93940099e-02f, 1.82409346e-01f, 2.53101829e-02f, -1.74235687e-01f, -5.95123172e-01f, -3.65289181e-01f, 9.54829305e-02f, 5.49926050e-02f,
  2.88923442e-01f, 5.48483312e-01f, 3.96663427e-01f, 2.72031307e-01f, -6.82742372e-02f, -2.03170672e-01f, -1.05306454e-01f, 1.76992819e-01f, 2.10212231e-01f, 1.07940093e-01f,
  1.35647908e-01f, -2.37187725e-02f, 1.22581989e-01f, 9.22527984e-02f, 8.06989148e-02f, 2.77766645e-01f, -1.56618014e-01f, -4.60527763e-02f, 9.37517583e-02f, 1.88822061e-01f,
  2.17080966e-01f, 4.82704351e-03f, 1.76405668e-01f, 8.65124390e-02f, -2.08687298e-02f, -1.75428331e-01f, 3.31772584e-03f, -1.00697309e-01f, -9.48589295e-02f, -1.12799384e-01f,
  -3.73666659e-02f, 3.77640799e-02f, 3.75663936e-02f, -6.31084591e-02f, -1.94497313e-02f, 1.46747436e-02f, -1.41414896e-01f, -3.30046494e-03f, -1.83686838e-02f, 2.93569155e-02f,
  1.02411330e-01f, 8.18585604e-02f, 6.13712668e-02f, -1.92911401e-01f, -1.07207000e-01f, 1.66918859e-01f, -1.31591499e-01f, -1.38224615e-02f, -9.14225578e-02f, -1.02008618e-01f,
  3.36428553e-01f, 1.75493255e-01f, 2.61510998e-01f, 3.70596498e-02f, 1.35054633e-01f, 1.59046113e-01f, 4.19193320e-03f, 1.34233832e-01f, 1.13994539e-01f, 1.73158012e-02f,
  -1.92132238e-02f, 1.98114812e-01f, -4.56469916e-02f, -2.59543266e-02f, 1.78455770e-01f, 1.02721691e-01f, 5.64060248e-02f, -3.69972661e-02f, 8.27345401e-02f, -2.27137934e-03f,
  6.59144223e-02f, 5.41021824e-02f, 8.93258229e-02f, 2.08000485e-02f, 1.11418024e-01f, 1.19841725e-01f, 1.52292594e-01f, 2.74589676e-02f, 1.27653569e-01f, 3.37023400e-02f,
  -7.27472365e-01f, 1.40398383e-01f, 3.13875526e-01f, 8.22622776e-02f, -1.19878408e-02f, 8.50988775e-02f, 1.08444177e-01f, -1.49181470e-01f, -1.52400866e-01f, -1.37765795e-01f,
  -1.29749686e-01f, 1.23329777e-02f, -8.24675187e-02f, -5.88163957e-02f, -5.70122525e-02f, 5.81155606e-02f, 8.04139897e-02f, 4.14382927e-02f, 1.73627064e-02f, -8.97962302e-02f,
  -8.75340626e-02f, -3.57121974e-02f, 2.83410642e-02f, -1.19243510e-01f, 4.72056530e-02f, 2.83539593e-01f, -8.76883715e-02f, -5.54780923e-02f, 1.24924202e-02f, -8.96533057e-02f,
  -1.26535416e+00f, -1.69979289e-01f, 5.21378219e-01f, -4.16332483e-01f, -2.13290274e-01f, -3.92750412e-01f, -4.79980558e-01f, -4.19569939e-01f, -2.24177465e-01f, -6.93285018e-02f,
  -2.73185819e-02f, 8.76150727e-02f, 2.03849316e-01f, -7.99457952e-02f, -3.05623651e-01f, -1.82725996e-01f, -2.68802017e-01f, -3.53300303e-01f, -4.22898114e-01f, -4.75247949e-01f,
  -4.26857769e-01f, -4.96946186e-01f, -5.51002502e-01f, -2.06125379e-01f, 1.43770307e-01f, -5.86709008e-02f, 3.22517306e-01f, -7.11398423e-02f, -2.48249471e-01f, -1.84792176e-01f,
  5.61984897e-01f, -3.06407839e-01f, -2.65250839e-02f, -1.56485483e-01f, 7.19013438e-02f, -5.87901659e-02f, -4.89829555e-02f, 6.13480136e-02f, -4.83489037e-02f, 1.46560594e-01f,
  2.37498824e-02f, 2.22379100e-02f, 3.50504257e-02f, 8.62768069e-02f, 5.44269048e-02f, 1.49223998e-01f, 1.81229487e-01f, 3.19197774e-02f, 1.78316280e-01f, 2.71865308e-01f,
  1.44074261e-01f, -1.20324075e-01f, 1.55221894e-01f, 1.20653391e-01f, 2.56968644e-02f, -7.16333240e-02f, 1.67789727e-01f, -4.99962922e-03f, 1.42798826e-01f, 9.54146758e-02f,
  -4.58396748e-02f, 2.50480741e-01f, -5.65276146e-02f, 3.57388742e-02f, 2.26882976e-02f, 3.18543054e-02f, -1.97016429e-02f, 1.65615052e-01f, -8.51103738e-02f, 8.16860870e-02f,
  8.93229321e-02f, 7.14066671e-03f, -2.58255824e-02f, -3.14969867e-02f, 1.10251248e-01f, 3.53338793e-02f, -1.14108697e-01f, 1.64083555e-01f, 1.42622560e-01f, -1.08139895e-01f,
  -1.96717352e-01f, -9.83456802e-03f, 4.07323092e-02f, 1.53289184e-01f, -9.72777754e-02f, -1.22266253e-02f, 1.29315201e-02f, 5.73995933e-02f, 8.80651828e-03f, -1.61494017e-01f,
  3.15103799e-01f, -3.12033415e-01f, -2.21888945e-01f, -9.02441815e-02f, -1.45035788e-01f, 4.31207977e-02f, 1.89213883e-02f, -1.04955576e-01f, -1.07514136e-01f, -1.18750602e-01f,
  -1.16895601e-01f, -2.71533206e-02f, 2.15196177e-01f, 1.55631348e-01f, 2.32593878e-03f, 1.83917154e-02f, -4.49209511e-02f, -1.19770914e-02f, 7.64289796e-02f, 2.70771295e-01f,
  2.06202343e-01f, -1.52048767e-01f, -2.78682541e-02f, 1.94047928e-01f, 4.59235720e-02f, -1.83488831e-01f, 1.91194102e-01f, 1.71099648e-01f, 4.04099412e-02f, -5.08111641e-02f,
  8.93384397e-01f, 6.37829721e-01f, 9.55657288e-02f, 3.40228945e-01f, -2.06004474e-02f, -4.18288648e-01f, -3.46827090e-01f, -1.63045526e-02f, 1.62942812e-01f, 2.93917775e-01f,
  1.37386799e-01f, -3.80901009e-01f, -1.46752119e-01f, -4.57002461e-01f, -5.32315314e-01f, -1.53832406e-01f, -9.23966765e-02f, -4.16939437e-01f, -7.52286077e-01f, -8.09428215e-01f,
  -4.18562233e-01f, 9.18499082e-02f, 1.63374022e-01f, -1.64111592e-02f, 4.97068584e-01f, -1.28046870e-01f, 5.70879817e-01f, 3.74290675e-01f, 3.06347031e-02f, 3.27861100e-01f,
  -1.47211282e-02f, 6.85795903e-01f, -6.11636460e-01f, -1.52023450e-01f, 1.05938047e-01f, 7.01063825e-03f, -2.37442151e-01f, 2.93833643e-01f, 1.76448061e-03f, 1.64624870e-01f,
  -9.63768587e-02f, -1.44908307e-02f, -2.92218197e-02f, -1.81053162e-01f, 2.94968225e-02f, -2.00305060e-01f, 1.30174085e-01f, -1.29411057e-01f, 1.00922965e-01f, 1.95427742e-02f,
  -3.58649611e-01f, 8.45102146e-02f, 2.68729985e-01f, -3.66162509e-02f, 7.00643361e-02f, -1.11895166e-01f, 1.29870564e-01f, 4.27419655e-02f, 6.24203868e-02f, 5.80823958e-01f,
  -8.80617946e-02f, 2.31884364e-02f, 4.15770486e-02f, 1.64482608e-01f, 4.45593558e-02f, 4.37413976e-02f, 1.54000044e-01f, -4.25279848e-02f, -6.36582077e-02f, -4.00150474e-03f,
  6.19052388e-02f, 7.36846626e-02f, 8.30110461e-02f, 8.07320997e-02f, -6.62385151e-02f, 1.85581908e-01f, -1.07722573e-01f, 1.33057339e-02f, 4.10094745e-02f, 3.15255523e-02f,
  -5.97720779e-02f, -1.29945984e-03f, 6.14837483e-02f, -6.68918416e-02f, 3.39979529e-02f, 7.81951770e-02f, -4.50005047e-02f, 2.50866301e-02f, 1.04073487e-01f, 2.18445376e-01f,
  -1.22000247e-01f, -5.88263094e-01f, 2.70579696e-01f, -1.05683133e-01f, 1.38340443e-01f, 7.19426423e-02f, 2.89247464e-02f, -5.46089597e-02f, 2.65869617e-01f, -7.38094077e-02f,
  -1.24660097e-01f, 1.02473013e-01f, 1.34409964e-01f, -3.02426875e-01f, -4.02038038e-01f, -7.88876787e-02f, -1.49819747e-01f, -1.87909454e-01f, -2.78571486e-01f, 9.56851542e-02f,
  3.43138948e-02f, -2.90009648e-01f, -1.73750520e-01f, -8.86815190e-02f, 2.86064502e-02f, -2.89111137e-01f, 3.42675671e-02f, -2.10159197e-01f, -4.29574609e-01f, 2.54101634e-01f,
  4.70889956e-01f, -4.53169733e-01f, -8.48304451e-01f, -2.74327099e-01f, -5.01374900e-01f, -5.50429046e-01f, -6.46861851e-01f, -3.86052966e-01f, -8.61013159e-02f, -3.51121426e-01f,
  -1.81249157e-01f, 2.00459063e-01f, -2.05263808e-01f, -1.20094687e-01f, -3.28879476e-01f, -7.05918312e-01f, -5.62596917e-01f, -3.87998343e-01f, -3.84274982e-02f, 8.94820690e-02f,
  1.00990787e-01f, -3.47338468e-02f, 9.98691395e-02f, -1.97818562e-01f, -3.61953884e-01f, -1.89406216e-01f, -5.62158883e-01f, -2.79421300e-01f, -3.06060910e-01f, -4.04187799e-01f,
  -4.85075325e-01f, -4.11208361e-01f, -9.41835493e-02f, 2.68203676e-01f, -1.52264044e-01f, 1.82709157e-01f, -1.50353312e-01f, -9.02192071e-02f, 2.42972612e-01f, -2.61143655e-01f,
  1.16866291e-01f, 1.91485286e-01f, 1.96341928e-02f, -4.15016338e-03f, -2.54116118e-01f, -7.63067007e-02f, -8.02210942e-02f, -1.17155276e-01f, -9.05513763e-02f, -1.03448592e-01f,
  1.64656207e-01f, -8.66094008e-02f, -3.10262471e-01f, -4.62873764e-02f, -2.32501090e-01f, -1.01748012e-01f, -3.41488451e-01f, -1.40910164e-01f, -1.20764866e-01f, -2.09385887e-01f,
  -1.13940304e-02f, -6.42973930e-02f, -8.85760039e-02f, 5.84933683e-02f, 1.13337971e-01f, 4.27236147e-02f, -1.66558884e-02f, 2.75490135e-02f, 8.06375965e-02f, -5.88005371e-02f,
  -1.72296334e-02f, 9.34163481e-02f, 9.04714167e-02f, -1.06496446e-01f, -1.45541221e-01f, -7.14893490e-02f, -1.54180201e-02f, -1.19747389e-02f, -5.71420081e-02f, 9.08133574e-03f,
  9.11779553e-02f, 3.48033868e-02f, -1.32053792e-01f, 1.54395729e-01f, -9.30837169e-02f, -1.40182078e-01f, -1.57993310e-03f, 3.09550855e-02f, -8.38973597e-02f, -5.24687534e-03f,
  -2.05868557e-01f, 9.75943804e-02f, -3.27957243e-01f, -4.44546826e-02f, -1.87950954e-01f, -3.60068008e-02f, 3.63759696e-02f, 6.33560196e-02f, 6.96162879e-02f, -1.37025014e-01f,
  -1.72599062e-01f, -8.38965625e-02f, -2.99906760e-01f, 6.45974949e-02f, 1.25754014e-01f, -8.34139362e-02f, 1.18574001e-01f, 1.56138316e-02f, 3.00132204e-02f, 1.50759205e-01f,
  3.86116910e-03f, 2.01322511e-02f, 4.70503494e-02f, -1.25885129e-01f, -8.48116204e-02f, 2.08600461e-02f, -3.45415711e-01f, -2.54994184e-01f, -7.27014691e-02f, -6.23446219e-02f,
  4.59667414e-01f, -8.97754505e-02f, 3.48741084e-01f, 3.08772057e-01f, 4.17886376e-01f, 5.60086191e-01f, 7.73629367e-01f, 4.58171099e-01f, 7.09162429e-02f, 8.70503485e-02f,
  -8.53775293e-02f, -4.48437691e-01f, -4.24467355e-01f, -3.98594588e-01f, -6.73703998e-02f, 7.85724148e-02f, 1.29683778e-01f, 4.47567105e-02f, 6.17906004e-02f, 4.57135960e-02f,
  -2.28482082e-01f, 3.63516748e-01f, 2.60131896e-01f, -1.42748147e-01f, -3.05660725e-01f, -2.32963622e-01f, 1.21716432e-01f, 2.24367231e-01f, -9.97294039e-02f, -5.64522862e-01f,
  -1.35036916e-01f, 3.50527942e-01f, -1.39429986e-01f, -4.03892934e-01f, -2.61712402e-01f, -1.01625726e-01f, 6.24759160e-02f, 1.64939966e-02f, 5.29283658e-02f, 1.00422427e-01f,
  -2.36801188e-02f, -9.25413594e-02f, 4.79576625e-02f, -1.07020577e-02f, 2.65539438e-01f, 4.48112451e-02f, -2.53191814e-02f, 2.81505063e-02f, -5.84211126e-02f, -2.11861417e-01f,
  -2.72086203e-01f, 1.95346162e-01f, 2.79327005e-01f, 1.03878677e-01f, 7.41172060e-02f, 2.55155582e-02f, -2.14602109e-02f, -2.06265062e-01f, -6.23761453e-02f, -2.00353533e-01f,
  1.29536957e-01f, -5.19597298e-03f, -1.00401312e-01f, 5.17097078e-02f, -6.25864565e-02f, -8.95680860e-02f, -5.72843924e-02f, 6.38956800e-02f, 6.41735569e-02f, 2.34049827e-01f,
  1.68180525e-01f, 4.36232537e-02f, 2.23366395e-01f, 1.76619202e-01f, 1.75932050e-02f, 9.50938612e-02f, 1.75921530e-01f, -7.38442391e-02f, 4.84037101e-02f, 2.43537277e-01f,
  1.38000742e-01f, 1.76315725e-01f, 7.25453123e-02f, 1.09309115e-01f, 7.55799562e-02f, 2.67437976e-02f, 5.97484261e-02f, 5.90838157e-02f, 1.69994280e-01f, 3.71434927e-01f,
  1.85231715e-01f, 3.78425568e-01f, -1.47548988e-01f, -2.41980061e-01f, 3.04733030e-02f, -3.00190616e-02f, -1.09325424e-02f, -1.33888751e-01f, 1.22287236e-02f, 3.44558596e-03f,
  1.25866666e-01f, -8.95950347e-02f, 1.32742196e-01f, 1.24686502e-01f, 1.93259895e-01f, 3.82555425e-02f, -9.77833122e-02f, -1.61413383e-02f, -1.81223467e-01f, -9.28797051e-02f,
  -1.98133305e-01f, 6.42612018e-03f, 3.10687125e-01f, 1.08725294e-01f, -1.13335028e-02f, -2.97330227e-02f, 3.38991880e-02f, 6.87382072e-02f, 5.84305003e-02f, 1.66379645e-01f,
  -7.62141645e-02f, 1.63578361e-01f, 1.21019827e-02f, 4.90164429e-01f, 4.21976417e-01f, 3.92017990e-01f, 2.32049868e-01f, 7.72294477e-02f, 1.71627328e-01f, 1.60109103e-01f,
  2.55924851e-01f, 2.63481438e-01f, 2.35671476e-01f, 2.27857903e-01f, 9.79928374e-02f, 4.60893754e-03f, 8.07769150e-02f, -2.52411738e-02f, 6.98553864e-03f, 5.86040132e-02f,
  3.23806971e-01f, 1.05279379e-01f, -1.56659668e-03f, 1.31179392e-01f, 1.74141228e-01f, 3.32412660e-01f, 2.34665006e-01f, 2.51173377e-01f, 3.12492698e-01f, 1.68632850e-01f,
  -9.06771943e-02f, -6.44783750e-02f, -1.34256676e-01f, 1.19118415e-01f, 2.55180467e-02f, -3.34214211e-01f, -2.27179095e-01f, -3.07504654e-01f, -2.79554389e-02f, -7.55929574e-02f,
  7.80454427e-02f, -1.21729188e-01f, 1.13670737e-01f, -1.36488184e-01f, -1.35844216e-01f, -2.01728329e-01f, -2.47733533e-01f, -1.62777096e-01f, -7.69476369e-02f, -1.27347544e-01f,
  1.27823293e-01f, 8.32569599e-02f, -1.26440981e-02f, -5.67802601e-02f, 1.57589316e-01f, 1.49060443e-01f, -1.27708837e-02f, -3.52281518e-02f, -1.41782627e-01f, -2.44106054e-01f,
  -8.07147920e-02f, -4.19722274e-02f, 6.72519132e-02f, -4.86079752e-02f, 8.55100974e-02f, -1.32180095e-01f, -2.86119413e-02f, 1.01215035e-01f, 4.22114693e-02f, -1.93197355e-01f,
  -1.79810688e-01f, -7.22294897e-02f, -3.50498296e-02f, -1.32562190e-01f, -1.49088691e-03f, 3.33995074e-02f, -1.32100597e-01f, 3.45220491e-02f, 2.24764775e-02f, -8.69844854e-02f,
  4.87132202e-04f, -1.86990798e-01f, -9.75167081e-02f, -1.89366087e-01f, -1.31249622e-01f, -4.39046398e-02f, 5.44870971e-04f, 2.08976753e-02f, 6.67833015e-02f, -3.75662819e-02f,
  -4.76015881e-02f, 3.01801562e-01f, -8.76358598e-02f, -2.44836882e-01f, -1.63941253e-02f, -7.02575594e-02f, 3.46128196e-02f, -1.98401958e-01f, 7.91218206e-02f, -1.11388251e-01f,
  1.59707312e-02f, -1.27251372e-01f, -2.31803618e-02f, -1.17998838e-01f, -2.55926758e-01f, -1.96235701e-01f, -6.86400384e-02f, -5.62855937e-02f, -9.48919915e-03f, -8.42483938e-02f,
  -1.04975216e-01f, -1.63922861e-01f, -1.35473132e-01f, -8.72527659e-02f, 1.65474545e-02f, 1.30126113e-02f, -1.03352316e-01f, -1.59889758e-01f, -1.30160302e-01f, -1.55367911e-01f,
  -1.07944536e+00f, -3.86850685e-01f, 7.47341394e-01f, -2.65909404e-01f, -5.94642088e-02f, -1.95631474e-01f, -4.37000901e-01f, -1.34548426e-01f, 1.38384029e-02f, -1.55255482e-01f,
  -1.05442822e-01f, -1.01913586e-01f, 1.79533690e-01f, 5.73468255e-03f, -1.82701364e-01f, -8.31880122e-02f, 3.56473625e-01f, 1.68806612e-01f, -1.97412968e-01f, -5.47093570e-01f,
  -4.25730705e-01f, -1.89891517e-01f, -6.70453385e-02f, 1.88579299e-02f, -2.29908973e-01f, -5.67470193e-02f, 4.97229397e-01f, -1.22526988e-01f, -1.69750601e-01f, -2.40575954e-01f,
  -3.71909320e-01f, -8.90769511e-02f, 2.43839920e-01f, 8.24105665e-02f, 2.11443976e-01f, -3.43451351e-01f, -2.67028004e-01f, 1.96754843e-01f, 1.13985036e-02f, -1.18333071e-01f,
  -1.24488935e-01f, -1.89952835e-01f, -1.19180419e-01f, -1.19222768e-01f, -1.95426166e-01f, -2.57656157e-01f, 2.62122244e-01f, 4.32320349e-02f, 1.29979715e-01f, -1.02598526e-01f,
  -4.07517880e-01f, -3.17681402e-01f, -1.22679070e-01f, 1.53757930e-01f, 7.72948861e-02f, 2.74659127e-01f, 6.62048385e-02f, -2.74778306e-01f, -4.37831469e-02f, -4.71173972e-01f,
  -1.97538473e-02f, 1.64966121e-01f, 7.00872019e-02f, 1.53019011e-01f, -2.18636930e-01f, 1.55762389e-01f, -5.44395708e-02f, -1.21396119e-02f, -7.81091303e-02f, -1.66141048e-01f,
  7.86300525e-02f, -1.36869797e-03f, 1.80454940e-01f, -7.63221011e-02f, -1.03910305e-01f, -3.50443386e-02f, -1.56940952e-01f, -1.00532435e-01f, 1.18596973e-02f, 1.59006659e-02f,
  -4.46270593e-02f, 8.44358429e-02f, 3.14040601e-01f, 5.77767054e-03f, 1.17615439e-01f, 2.66938031e-01f, -3.95008624e-02f, -7.88188949e-02f, -1.18533067e-01f, -1.69000715e-01f,
  -1.07465841e-01f, 5.32556713e-01f, -3.88125062e-01f, -3.72157209e-02f, 1.45381549e-02f, 1.45146638e-01f, 5.76455370e-02f, -1.33945339e-03f, 1.49927825e-01f, -9.81271937e-02f,
  -4.68807528e-03f, -3.36624421e-02f, 5.45267947e-02f, 1.57742575e-01f, -2.44324952e-01f, -8.25088024e-02f, -2.62459904e-01f, -1.05249457e-01f, 5.47590069e-02f, -1.58569261e-01f,
  -1.04713559e-01f, -4.99872118e-01f, -6.80346668e-01f, -4.05043423e-01f, -3.59759092e-01f, -1.91970840e-01f, -1.47997350e-01f, -3.14214945e-01f, -2.68047273e-01f, -7.62780666e-01f,
  5.92551649e-01f, 2.59984642e-01f, 3.55122805e-01f, 1.25631094e-01f, -1.92224532e-01f, -5.55571280e-02f, 7.06725940e-02f, 1.20017603e-01f, -2.24666540e-02f, 1.15861632e-01f,
  5.73224537e-02f, -7.32700601e-02f, 1.90836433e-02f, 1.14987247e-01f, 1.98972598e-01f, 4.48850207e-02f, 1.40895143e-01f, 1.03539206e-01f, 1.02345124e-01f, -1.12236865e-01f,
  -1.09610856e-01f, -9.84902084e-02f, 2.07905158e-01f, 1.55164218e-02f, -4.82756905e-02f, -2.11104140e-01f, -5.24100214e-02f, -1.14774786e-01f, -1.46672353e-01f, -1.67313755e-01f,
  1.99404567e-01f, 5.30647516e-01f, 5.60324453e-02f, 4.38631363e-02f, 1.82987213e-01f, 7.72106349e-02f, 1.35067850e-01f, -8.86078104e-02f, -8.90000015e-02f, -7.17700273e-02f,
  -1.20778568e-02f, 4.96353917e-02f, 1.22822590e-01f, 4.92975526e-02f, 1.66090094e-02f, -2.14938670e-02f, 2.32477307e-01f, 1.41720921e-01f, 8.48112777e-02f, 1.64506048e-01f,
  1.14715509e-01f, -1.38224103e-02f, 4.61159386e-02f, -6.83536679e-02f, 1.85194507e-01f, 2.08483301e-02f, 1.56875879e-01f, 8.23375508e-02f, 1.25637218e-01f, -5.24733216e-02f,
  -2.07813270e-02f, 1.42152803e-02f, 8.31831470e-02f, -3.47972065e-02f, -4.94817123e-02f, -8.18101242e-02f, -1.01474188e-01f, -1.66694388e-01f, -3.08877807e-02f, -1.38203427e-01f,
  -2.31456563e-01f, 4.19787364e-03f, 4.61177481e-03f, -2.39721775e-01f, 3.33671942e-02f, -1.06734246e-01f, -1.30575478e-01f, -5.63769341e-02f, 1.28995702e-01f, 8.01881030e-02f,
  -1.00923024e-01f, -1.26278400e-01f, -1.73594818e-01f, -1.10737175e-01f, -1.30176634e-01f, -1.14016503e-01f, -1.15043148e-01f, 3.20389192e-03f, -1.51315913e-01f, -1.74066126e-01f,
  -6.07542433e-02f, 3.49843055e-01f, -4.82275803e-03f, 1.00053340e-01f, 1.06292196e-01f, 6.66781589e-02f, 1.11567721e-01f, -8.11162814e-02f, -9.47855785e-02f, -7.05359653e-02f,
  1.11707859e-02f, 6.03592731e-02f, 8.17700252e-02f, -4.48432490e-02f, -1.51392877e-01f, -6.23893179e-02f, 1.74110204e-01f, -4.37517725e-02f, 1.33443117e-01f, 9.35792699e-02f,
  2.28840299e-02f, -9.79621112e-02f, -8.25437680e-02f, -4.51807529e-02f, 2.86699720e-02f, -7.24693835e-02f, -2.00171590e-01f, -1.56447619e-01f, -7.49504417e-02f, -2.14801297e-01f,
  1.24782896e+00f, -2.78173923e-01f, 2.87538439e-01f, 9.07037035e-02f, -5.64103842e-01f, -4.79687393e-01f, -7.54997551e-01f, -4.22038585e-01f, -1.32781014e-01f, -1.24211103e-01f,
  -5.72192818e-02f, 4.58764941e-01f, 5.90002477e-01f, 5.41387498e-01f, 5.45739770e-01f, -1.91033468e-01f, 1.04118466e-01f, 7.65094399e-01f, 6.77748442e-01f, -2.75855530e-02f,
  -9.69472900e-02f, 2.46484187e-02f, 4.83390301e-01f, 2.25067928e-01f, -2.58037895e-01f, 3.49231660e-02f, -1.86284870e-01f, -9.38123539e-02f, 3.03773452e-02f, 2.60525525e-01f,
  2.25896746e-01f, 6.51550293e-02f, -1.98374595e-02f, 1.13544390e-01f, 3.10284309e-02f, 6.49937093e-02f, -1.45267956e-02f, 7.05898032e-02f, -1.01339752e-02f, -1.47204518e-01f,
  -4.48713079e-02f, 8.82104710e-02f, -2.60345195e-03f, -6.37238100e-02f, -1.48653433e-01f, -9.50142816e-02f, 9.61508751e-02f, 3.67677063e-01f, 9.34090912e-02f, -7.72627518e-02f,
  -1.39880821e-01f, -7.69490153e-02f, -9.74155366e-02f, -2.81928986e-01f, -1.25774622e-01f, 3.05287719e-01f, -7.22512454e-02f, -3.62237804e-02f, 1.92665979e-02f, -7.86166117e-02f,
  -1.66082792e-02f, 2.17272416e-01f, -3.93029042e-02f, 9.93241817e-02f, 7.59372115e-02f, 2.96898428e-02f, 4.67284620e-02f, -9.09574628e-02f, 9.24402773e-02f, -1.45288855e-02f,
  9.96892378e-02f, 1.29743427e-01f, 2.51394846e-02f, -8.44803154e-02f, 1.07754260e-01f, 1.45868763e-01f, 5.76745756e-02f, -6.76561669e-02f, 1.12208329e-01f, 3.54339816e-02f,
  1.52355433e-01f, 4.79747467e-02f, 8.19925144e-02f, 1.04821838e-01f, 5.47495484e-02f, 1.97172031e-01f, 1.22003987e-01f, 7.12680742e-02f, 7.27456203e-03f, -7.28056952e-02f,
  -5.64500928e-01f, 9.17232335e-02f, -5.45950467e-03f, 1.03587367e-01f, -2.63872296e-01f, -1.62073687e-01f, 1.62440967e-02f, 1.12391941e-01f, -9.72288568e-03f, -8.21086466e-02f,
  -1.50075331e-01f, 6.99826926e-02f, 8.32983777e-02f, -6.36392534e-02f, -3.33661363e-02f, -1.92265794e-01f, 5.19725867e-02f, 1.80985346e-01f, 2.80316565e-02f, -1.61642119e-01f,
  -2.40352303e-01f, -1.94124803e-01f, 1.08355787e-02f, -6.85965419e-02f, -2.13512242e-01f, 2.40105256e-01f, -2.25105375e-01f, -2.88052112e-01f, 6.90512136e-02f, -3.97852063e-01f,
  1.03620863e+00f, -3.57411653e-01f, -7.77018368e-01f, 1.15572423e-01f, -1.93825945e-01f, -7.80022144e-02f, 1.92338735e-01f, 1.79827780e-01f, 2.05175474e-01f, -3.29888612e-02f,
  -2.56876200e-01f, -1.36337727e-01f, -2.75454730e-01f, -2.40882128e-01f, 8.90017152e-02f, -1.70725331e-01f, -1.90103501e-01f, -1.44372806e-01f, 7.60208145e-02f, 3.91214669e-01f,
  1.36554718e-01f, 2.55929023e-01f, 2.24876091e-01f, -7.97740519e-02f, -3.11423331e-01f, -8.36826786e-02f, -4.40761030e-01f, -3.61063302e-01f, -5.16362786e-01f, -5.27637601e-01f,
  -4.27314371e-01f, -2.84376949e-01f, 1.54141396e-01f, 1.00830048e-01f, 8.36337358e-03f, 1.15483552e-01f, 1.55192569e-01f, 2.78669614e-02f, 1.42305329e-01f, 1.50529847e-01f,
  -7.22702369e-02f, -2.46635042e-02f, -2.04414979e-01f, -7.20388964e-02f, -6.39576092e-02f, 3.96333411e-02f, -3.92237678e-02f, -5.93600720e-02f, -6.66452646e-02f, -9.84369740e-02f,
  -2.07650974e-01f, -1.36702910e-01f, 2.00821217e-02f, 4.58179601e-02f, -2.52084155e-02f, -3.27698030e-02f, -9.86032188e-02f, -4.91922395e-03f, -1.48788184e-01f, 1.81377709e-01f,
  -6.16741739e-02f, 6.95757121e-02f, -5.63374311e-02f, 8.53810459e-02f, 1.97575524e-01f, 1.56119645e-01f, 7.28604868e-02f, 1.13703661e-01f, 6.83427602e-02f, 6.17143400e-02f,
  3.88967432e-02f, -1.21998310e-01f, -1.09037004e-01f, 2.89521441e-02f, -1.51283130e-01f, -1.11148193e-01f, 1.21606595e-03f, -2.29063444e-02f, -6.00638278e-02f, -5.14643639e-02f,
  -4.71728183e-02f, 2.59157028e-02f, -1.01084612e-01f, -1.15857787e-01f, -2.24642515e-01f, -6.02095723e-02f, -1.61217064e-01f, -5.52696548e-02f, -6.61819875e-02f, -3.60787809e-02f,
  3.26535106e-01f, -3.85092795e-01f, 1.13344774e-01f, 4.45814505e-02f, -5.98269925e-02f, -1.22613959e-01f, -2.20652267e-01f, 1.66054275e-02f, -8.80631357e-02f, 9.57530439e-02f,
  -8.36468562e-02f, 2.44055167e-02f, -1.97449103e-01f, -2.68198196e-02f, 1.86822698e-01f, 1.37590930e-01f, 1.18930489e-01f, -9.77807678e-03f, -1.16614573e-01f, -8.93506333e-02f,
  -5.22668213e-02f, 2.06581563e-01f, 3.19366753e-01f, 2.98663825e-01f, 2.22174630e-01f, 2.51431018e-01f, 1.33296102e-01f, 1.70104697e-01f, 2.12256864e-01f, 6.55608296e-01f,
  -1.37448207e-01f, 6.35488749e-01f, -2.89394706e-01f, -4.26747680e-01f, -2.64065444e-01f, -1.61648914e-01f, 2.28383645e-01f, -2.41564751e-01f, -1.76209301e-01f, 4.25719440e-01f,
  1.92143202e-01f, -6.06764317e-01f, -3.63040268e-01f, -4.97401506e-01f, -2.05664575e-01f, 3.82502019e-01f, 2.31328219e-01f, -4.78731453e-01f, -9.08138037e-01f, -5.45768678e-01f,
  -2.60974556e-01f, -4.30616945e-01f, -3.81428570e-01f, -2.97184646e-01f, -1.91835567e-01f, -5.20720601e-01f, -4.91545759e-02f, -1.63056612e-01f, 1.25196457e-01f, -4.49564718e-02f,
  -5.42128623e-01f, -7.93712810e-02f, -3.65131915e-01f, -4.22810763e-02f, 2.22128090e-02f, 1.68578416e-01f, -1.74192805e-02f, -1.04728766e-01f, 1.73601553e-01f, 1.34193018e-01f,
  -8.38164836e-02f, 3.43029909e-02f, -1.66084677e-01f, -1.71527594e-01f, -2.63873994e-01f, -1.58816442e-01f, -5.58993146e-02f, -1.59767643e-01f, 7.52984434e-02f, 3.62217486e-01f,
  3.90491277e-01f, 2.32856274e-01f, 1.04590997e-01f, 1.76119342e-01f, 9.86433551e-02f, 3.28493379e-02f, 9.74769369e-02f, 1.18443212e-02f, -5.68847805e-02f, 4.90011945e-02f,
  3.26137096e-01f, 2.00670406e-01f, -4.03501056e-02f, 1.01519665e-02f, 1.74097449e-01f, 1.91794530e-01f, -5.74113987e-02f, 5.48391649e-03f, -7.36681670e-02f, -4.47503366e-02f,
  -9.83387418e-03f, 2.83848017e-01f, 1.86013244e-02f, 9.49242432e-03f, -5.50303310e-02f, 3.71287428e-02f, 1.14198804e-01f, 1.77906632e-01f, 1.57152623e-01f, 6.58181384e-02f,
  1.59622766e-02f, 4.31885943e-02f, 8.82210210e-03f, -3.04723531e-02f, 8.58055577e-02f, 1.37867525e-01f, 1.21889628e-01f, 1.83187753e-01f, -3.18748280e-02f, 8.00398663e-02f,
  -6.33023918e-01f, -4.48402390e-02f, -4.46715243e-02f, -2.19524860e-01f, -5.37632629e-02f, 9.59356502e-02f, -8.78227577e-02f, 1.31891549e-01f, -9.35126562e-03f, -3.66011150e-02f,
  1.25277247e-02f, -1.43951491e-01f, 5.25540411e-02f, -6.54741973e-02f, -2.26360157e-01f, -2.03859825e-02f, 3.14577490e-01f, -1.36278998e-02f, 1.92378893e-01f, 1.61516860e-01f,
  2.99729049e-01f, 2.35879123e-01f, 1.17444411e-01f, 6.34244233e-02f, 2.94860210e-02f, -1.02402940e-01f, -7.14975521e-02f, -1.06493142e-02f, -2.72395685e-02f, 1.93103522e-01f,
  4.14464295e-01f, -2.41452649e-01f, -1.76248729e-01f, 2.11882889e-01f, -2.89938450e-01f, -5.29666722e-01f, -4.56421793e-01f, -4.19167966e-01f, 8.65885057e-03f, 2.08663628e-01f,
  1.38176516e-01f, 3.33143413e-01f, 4.76359725e-01f, 1.24958485e-01f, -4.56087962e-02f, 1.07097827e-01f, 1.15732208e-01f, -1.52148185e-02f, -2.47514665e-01f, -4.69596833e-01f,
  -2.24171858e-02f, 1.91705197e-01f, 1.44703254e-01f, -8.35873261e-02f, 4.46742848e-02f, 3.58077213e-02f, 1.85129449e-01f, -1.06298037e-01f, -1.98937193e-01f, -8.39921683e-02f,
  6.63075745e-01f, -6.70502126e-01f, -2.82416224e-01f, -3.79024684e-01f, -1.87256783e-01f, -3.12778577e-02f, -1.44167691e-01f, -2.77775168e-01f, -2.07209751e-01f, -4.84694541e-02f,
  -1.52856693e-01f, -1.86456397e-01f, -1.47552252e-01f, -2.57228836e-02f, -5.93136847e-02f, -5.14515862e-02f, -8.53170976e-02f, -3.16661894e-01f, -5.05296364e-02f, -1.60011694e-01f,
  -7.97610730e-02f, -2.81950384e-01f, -2.73204803e-01f, -1.80725068e-01f, -2.32908443e-01f, -1.93986052e-03f, -2.53845066e-01f, -3.82298917e-01f, -2.43305698e-01f, 3.43064405e-02f,
  -3.11848875e-02f, 1.82324409e-01f, 1.53832743e-02f, 3.34517583e-02f, 1.41479090e-01f, 1.41019762e-01f, 6.24407493e-02f, -4.90036756e-02f, -4.05026004e-02f, 5.85748814e-02f,
  -1.47046000e-01f, 5.08582816e-02f, -1.00510724e-01f, 7.61044025e-02f, 1.00748474e-02f, -1.12070933e-01f, -9.72699001e-02f, 5.45114577e-02f, -2.09992543e-01f, 8.88350978e-02f,
  -6.11245073e-02f, -5.01006320e-02f, 1.89887598e-01f, -1.10148989e-01f, -1.01102017e-01f, -5.82706779e-02f, 2.89268754e-02f, 1.06823798e-02f, 5.20385839e-02f, -7.85835981e-02f,
  9.16589618e-01f, -1.71925426e-01f, 3.89878154e-01f, -2.32799843e-01f, -2.64028370e-01f, -9.97420773e-02f, 1.69787019e-01f, -1.59796774e-01f, -3.35053541e-02f, -2.11016573e-02f,
  -3.27863395e-01f, -1.92734040e-02f, 1.71447784e-01f, 1.28509581e-01f, 1.52450621e-01f, -4.17211168e-02f, 4.39729840e-02f, -6.73976019e-02f, -2.21762434e-02f, -5.32008968e-02f,
  1.03579625e-01f, -5.22089265e-02f, 4.36415672e-01f, 2.09545255e-01f, -5.19434027e-02f, 2.41674155e-01f, 4.93166447e-01f, 5.09122312e-02f, 8.87309164e-02f, 6.82604790e-01f,
  -7.47670293e-01f, -1.02761960e+00f, 3.15052390e-01f, 1.20570600e-01f, 4.09060806e-01f, 2.34034225e-01f, -2.86831051e-01f, -2.56635278e-01f, -1.08638719e-01f, -2.59184629e-01f,
  -5.84890664e-01f, -4.76503819e-01f, -4.88329113e-01f, -3.72450501e-01f, -3.98579985e-01f, -1.80025157e-02f, 5.75453699e-01f, 5.32764912e-01f, 4.68338937e-01f, 2.93405145e-01f,
  6.35080040e-02f, 2.30906099e-01f, 2.77983434e-02f, 3.62071171e-02f, 1.02821514e-01f, 1.00511767e-01f, 1.74885824e-01f, 2.20302284e-01f, 7.38976896e-02f, 3.41634214e-01f,
  8.06065649e-02f, -5.71589947e-01f, 1.71803981e-01f, -1.68651253e-01f, 4.07968126e-02f, -1.56529948e-01f, -5.46044894e-02f, -8.35288092e-02f, -2.55830973e-01f, -6.33279458e-02f,
  -6.26975223e-02f, -9.08734798e-02f, 2.09882911e-02f, -6.04683831e-02f, -2.53516231e-02f, -4.96140905e-02f, -4.68895286e-02f, -4.18723561e-02f, -2.36547310e-02f, -2.25849301e-01f,
  -1.48078844e-01f, 1.95174947e-01f, 1.18902460e-01f, -2.04995558e-01f, -2.15464056e-01f, 1.15673654e-01f, -9.22555551e-02f, -1.36425376e-01f, -9.83425155e-02f, -1.19713552e-01f,
  1.58514157e-01f, -8.48889202e-02f, -1.58331424e-01f, -4.15772432e-03f, -5.65431565e-02f, -7.99652636e-02f, 2.33413056e-02f, -1.75639510e-01f, -9.84327495e-02f, -1.03660688e-01f,
  -4.57489975e-02f, 3.73957828e-02f, -1.04081482e-02f, -1.86878666e-02f, -1.15546443e-01f, -1.04665607e-01f, -9.41169390e-04f, -1.56996220e-01f, 2.06090081e-02f, -1.26635253e-01f,
  -6.72832876e-02f, 1.33826490e-02f, 8.73190835e-02f, 3.17291133e-02f, 2.05641445e-02f, -3.39632630e-02f, 2.92969085e-02f, -9.89359692e-02f, -1.68065041e-01f, -1.06038637e-02f,
  -3.09018455e-02f, 2.01367706e-01f, 8.97236983e-04f, -1.55234843e-01f, 9.30408090e-02f, -7.42079690e-02f, -9.41717923e-02f, 1.83864415e-01f, 1.31049836e-02f, -2.92682853e-02f,
  -1.65712893e-01f, -9.76897962e-03f, -1.40889334e-02f, -2.67347321e-02f, 2.15283811e-01f, 1.17302597e-01f, -4.26554494e-02f, 1.52669758e-01f, 1.59226954e-02f, 7.54213706e-02f,
  3.13073881e-02f, 1.50233448e-01f, 8.65578800e-02f, 3.93573716e-02f, 1.15083512e-02f, 2.38024995e-01f, 7.99644515e-02f, 1.19887426e-01f, 1.05254859e-01f, 8.11818168e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.08328232e-01f, 4.41778332e-01f, 7.46877372e-01f, 4.99139965e-01f, 5.63733995e-01f, 7.75406599e-01f, 5.75562596e-01f, 5.44852138e-01f, -2.32963841e-02f, 4.96189028e-01f,
  5.97152114e-01f, 7.31729627e-01f, 9.36485469e-01f, 5.98192334e-01f, 4.91178960e-01f, 9.35930789e-01f, 5.81237555e-01f, 6.74321890e-01f, 3.50640684e-01f, 4.89373386e-01f,
  3.82453561e-01f, 1.00672436e+00f, 7.49969780e-01f, 8.08664739e-01f, 1.07723927e+00f, 9.98731554e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -4.10197318e-01f, -3.25184524e-01f, -2.00122148e-01f, 9.00862813e-02f, -3.99487168e-01f, -1.77577436e-01f, -6.25491440e-01f, 2.71967668e-02f, -4.55421686e-01f, 4.76234645e-01f,
  1.61694616e-01f, 2.55891502e-01f, 9.97243643e-01f, -9.07273710e-01f, 7.67776787e-01f, 1.21550336e-01f, -4.86548543e-01f, -5.43471158e-01f, -1.23762655e+00f, -1.55594513e-01f,
  -1.03764154e-01f, -9.54177022e-01f, 4.51995373e-01f, -2.40465716e-01f, -1.15210645e-01f, -1.71170667e-01f, 2.94897944e-01f, -5.57379782e-01f, 2.99242865e-02f, -3.13764006e-01f,
  -1.02267623e+00f, -4.69858617e-01f, -2.15995371e-01f, -5.03179617e-02f, -8.10420066e-02f, 4.96525645e-01f, -4.32096332e-01f, 1.64964274e-01f, -7.82981813e-01f, 3.12626153e-01f,
  2.39726484e-01f, -6.50223851e-01f, 7.06797302e-01f, -1.28318119e+00f, -3.22806567e-01f, -3.67121339e-01f, 4.06495899e-01f, 3.84217381e-01f, 4.32241289e-03f, 4.79108617e-02f,
  -1.13342941e+00f, 8.35865498e-01f, -7.22721279e-01f, -1.43245316e+00f, 5.84793389e-01f, -1.47172287e-01f, 3.67986590e-01f, -4.75338817e-01f, 1.44396022e-01f, 3.79721940e-01f,
  3.30968499e-01f, -1.68252975e-01f, 2.39268005e-01f, -9.89270091e-01f, -9.26476941e-02f, -9.74221602e-02f, 9.48871747e-02f, 5.37569344e-01f, -7.69219100e-01f, 3.79297405e-01f,
  -6.31213367e-01f, -7.56879568e-01f, 2.30160773e-01f, 3.63977939e-01f, -4.09427077e-01f, -6.61688507e-01f, -5.24923384e-01f, -4.29009289e-01f, 1.05611108e-01f, -5.32801867e-01f,
  -1.15641588e-02f, -7.06308722e-01f, 5.97549379e-01f, 8.83705840e-02f, -8.00105408e-02f, -4.82664466e-01f, 9.74604040e-02f, -1.51156634e-01f, -1.13713823e-01f, 9.47880864e-01f,
  2.98889101e-01f, 6.56939805e-01f, -4.23075765e-01f, -7.34851658e-01f, -1.63424239e-01f, 6.92430377e-01f, -1.48984745e-01f, -2.84426779e-01f, -1.91401273e-01f, -1.15704186e-01f,
  -6.26073956e-01f, -1.61183193e-01f, 4.21438575e-01f, -2.54408509e-01f, 1.01011284e-01f, -1.31406796e+00f, 6.52948678e-01f, 7.74200201e-01f, 1.75084323e-02f, -3.43078971e-01f,
  -6.59383476e-01f, -8.31047237e-01f, -2.28716731e-01f, -2.52484262e-01f, 8.63924980e-01f, -6.41154826e-01f, 1.64207797e-02f, -1.05949342e+00f, 4.67405096e-02f, -3.52573097e-01f,
  -3.27806890e-01f, 3.02501708e-01f, -7.26716101e-01f, -3.96518528e-01f, -6.51198030e-01f, 7.13212132e-01f, -9.53584731e-01f, 9.46616232e-02f, -5.80017343e-02f, -5.33447154e-02f,
  -2.11747661e-01f, 2.86768258e-01f, 7.03537524e-01f, 1.67093739e-01f, 5.50537169e-01f, 1.61687061e-01f, -2.18830720e-01f, 2.40746140e-01f, -3.63865286e-01f, -1.86550454e-03f,
  -8.04020464e-01f, -1.53078184e-01f, 2.30018318e-01f, 1.04654662e-01f, 5.52722849e-02f, 3.80860388e-01f, -3.13132435e-01f, -1.35394067e-01f, 6.67130888e-01f, 8.35340083e-01f,
  -1.06749676e-01f, -2.35289052e-01f, -6.60109818e-01f, 4.28151757e-01f, 6.37065470e-02f, -9.90360022e-01f, -7.20810831e-01f, 2.09467828e-01f, -6.62841350e-02f, -4.48644012e-01f,
  3.83875966e-01f, 3.04813534e-01f, 3.62173617e-01f, -5.67572534e-01f, 6.49635732e-01f, -2.96599656e-01f, -8.98774981e-01f, -2.08876655e-01f, -3.42123747e-01f, -1.65139213e-02f,
  -1.15388405e+00f, -1.90402225e-01f, 9.20942783e-01f, -3.34355742e-01f, -6.17566049e-01f, 5.90851009e-01f, -5.52325547e-01f, 5.42706192e-01f, -2.38685176e-01f, -7.34041989e-01f,
  -4.23518896e-01f, 3.39559972e-01f, 3.98127377e-01f, 2.38542825e-01f, 4.01711166e-02f, -5.37514985e-01f, -1.72077924e-01f, -8.90625656e-01f, 6.68796539e-01f, 4.65694726e-01f,
  7.25258052e-01f, -7.61184037e-01f, 6.42995536e-02f, -1.76338688e-01f, -1.30089656e-01f, -8.66654068e-02f, 1.88471332e-01f, -3.92397881e-01f, -1.15744138e+00f, 5.49486816e-01f,
  -9.22682047e-01f, 5.74458599e-01f, -3.62780958e-01f, -6.19884610e-01f, -1.32687604e+00f, 4.53666657e-01f, -4.43614632e-01f, -3.96634221e-01f, -6.09629691e-01f, 1.24163114e-01f,
  9.05610919e-01f, 9.98662598e-03f, -7.01048672e-01f, 5.93644202e-01f, -7.78667510e-01f, -5.83153069e-01f, -7.66987443e-01f, -7.83512771e-01f, 5.96199743e-02f, 6.88994586e-01f,
  -3.37086469e-01f, -9.01535034e-01f, -4.05462503e-01f, -3.73925954e-01f, -4.16720897e-01f, -1.18314959e-01f, -8.80951285e-02f, -6.25378862e-02f, 1.51950885e-02f, 3.60034108e-02f,
  9.51888680e-01f, -1.69046313e-01f, -6.71698511e-01f, -9.88613307e-01f, -4.58300292e-01f, -5.31936407e-01f, 7.54929245e-01f, -7.34836996e-01f, -1.29811510e-01f, -1.40715390e-01f,
  4.74568993e-01f, 1.98131248e-01f, 4.50717688e-01f, -6.18805826e-01f, -3.02758843e-01f, -2.70744801e-01f, -3.68920356e-01f, -1.58808067e-01f, 2.81193733e-01f, -1.16593437e-02f,
  3.71974930e-02f, -5.52735806e-01f, -6.18201613e-01f, -6.51563644e-01f, -5.65028548e-01f, 3.25806737e-01f, 6.48947526e-03f, 1.90381646e-01f, 1.56384185e-01f, -2.77325451e-01f,
  -3.99712384e-01f, 2.53385067e-01f, -2.45828014e-02f, 2.25468382e-01f, 5.91941237e-01f, -2.77923197e-01f, -1.84306260e-02f, -3.73582870e-01f, -9.19286788e-01f, -2.50387609e-01f,
  -3.37871671e-01f, -6.46018207e-01f, 8.93336460e-02f, -4.10534553e-02f, -8.01368654e-02f, -3.69492322e-02f, -6.35509670e-01f, -6.00622296e-01f, -3.78543884e-01f, 7.17977822e-01f,
  -2.55836874e-01f, -3.33015829e-01f, -5.28152168e-01f, -5.71275413e-01f, 5.64458370e-01f, -7.32396662e-01f, 2.35061869e-01f, 1.03120649e+00f, 1.80198029e-01f, -2.27473721e-01f,
  2.93489754e-01f, -5.06293476e-01f, 7.22986519e-01f, 7.19639435e-02f, 1.04958856e+00f, -7.59532273e-01f, -7.29510486e-01f, 5.56889355e-01f, -7.90812612e-01f, -5.10886073e-01f,
  -5.03012240e-01f, 3.82446647e-01f, -1.12137035e-01f, -4.85204667e-01f, 1.08148575e-01f, -3.29793364e-01f, -7.00430572e-01f, 7.50937760e-01f, -5.67121983e-01f, 4.52121317e-01f,
  3.13107908e-01f, -7.93487191e-01f, 2.28993267e-01f, -8.39443922e-01f, 6.94824606e-02f, 2.26018786e-01f, -5.42685211e-01f, 2.04427198e-01f, 1.88643839e-02f, 5.83332360e-01f,
  1.14303149e-01f, -1.13879470e-02f, 1.04437247e-01f, -3.51260789e-02f, 1.40781030e-01f, -1.04661293e-01f, -4.44787025e-01f, -3.11893016e-01f, -6.94213688e-01f, -3.94637674e-01f,
  6.42159879e-01f, 5.58036983e-01f, -2.41671950e-01f, -1.29936665e-01f, -8.71649086e-01f, 6.53659552e-02f, 6.44537687e-01f, -2.20624298e-01f, -3.07162285e-01f, -5.89229941e-01f,
  6.83732808e-01f, -3.74602944e-01f, -1.10317779e+00f, -6.63506806e-01f, -3.61531563e-02f, -7.42629111e-01f, -4.73514616e-01f, -4.06639725e-01f, -2.53252834e-02f, -8.84517074e-01f,
  6.98946774e-01f, -3.39527940e-03f, 2.50242859e-01f, -8.37305933e-03f, -1.67749934e-02f, 6.53664917e-02f, -6.92245141e-02f, -2.75807232e-01f, 8.96072462e-02f, 4.13153201e-01f,
  3.84652019e-01f, -7.22356260e-01f, 1.08251877e-01f, 3.64587456e-01f, -6.06645405e-01f, 8.12879503e-01f, -3.00954312e-01f, -3.34407777e-01f, -7.58302867e-01f, -3.18249077e-01f,
  -1.70872971e-01f, -7.10115969e-01f, -1.79501280e-01f, 7.04166293e-01f, -5.22316694e-01f, 8.40142787e-01f, 3.15884203e-01f, 5.75116426e-02f, -9.95645002e-02f, -3.78336877e-01f,
  -9.72701311e-01f, 1.75797090e-01f, -5.27832448e-01f, -1.23148906e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.04773778e-01f, 1.10514238e-01f, 3.01158160e-01f, -1.18758962e-01f, -2.15588868e-01f, 2.27625176e-01f, -1.53227448e-01f, 5.32170571e-02f, 4.72727269e-02f, -2.56246179e-02f,
  -1.89762264e-02f, -2.86625266e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    