/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.90047121e-01f, -6.66695684e-02f, -1.59770325e-01f, -1.08062793e-02f, 9.36224833e-02f, -5.58324419e-02f, 1.53129799e-02f, 1.75436661e-01f, -4.48864046e-03f, -4.03756052e-02f,
  7.82611221e-02f, 1.63225308e-01f, 6.16609380e-02f, 9.98115912e-02f, 1.89294294e-02f, 3.17120291e-02f, 1.17670968e-01f, -5.68077564e-02f, 4.13892604e-02f, 1.31244987e-01f,
  1.01623669e-01f, 3.17751653e-02f, -1.37039684e-02f, 8.29546899e-03f, 3.68731730e-02f, 1.20743088e-01f, -8.65836535e-03f, -9.60733518e-02f, -2.58340761e-02f, -7.92307630e-02f,
  -5.04081734e-02f, -2.41538182e-01f, -3.26833152e-03f, 6.42931014e-02f, 6.15416430e-02f, 3.64946462e-02f, 3.34397592e-02f, -1.74473692e-02f, 4.39756215e-02f, 3.68710048e-02f,
  -1.71999708e-02f, 5.82616264e-03f, 2.43920926e-02f, 1.26343146e-01f, -6.04287870e-02f, -5.66940866e-02f, -5.54700829e-02f, -2.89349904e-04f, 2.39346810e-02f, -8.83238986e-02f,
  -8.00604559e-03f, -5.95531687e-02f, -4.79181223e-02f, -3.24819027e-03f, -8.93653110e-02f, -1.30814612e-01f, 3.01743415e-03f, 3.21119316e-02f, -7.51412585e-02f, 7.05122063e-03f,
  2.26964559e-02f, 1.96219124e-02f, 1.53890867e-02f, 7.58456662e-02f, -5.97457103e-02f, -1.98246818e-02f, 5.42651713e-02f, -2.20392644e-02f, 2.18816902e-02f, -3.33823599e-02f,
  3.62577178e-02f, -4.81214523e-02f, 9.35435481e-03f, -2.56380420e-02f, 1.40133100e-02f, -2.37069353e-02f, 3.30779143e-02f, 5.75765930e-02f, -1.33135915e-01f, -5.97286364e-03f,
  -7.50635341e-02f, 3.30248527e-04f, -4.94115725e-02f, 7.39776194e-02f, -7.45840445e-02f, 1.41842654e-02f, 3.72625701e-02f, 7.49473460e-03f, 1.70259345e-02f, -6.75782636e-02f,
  1.48705423e-01f, -1.47667319e-01f, -3.23527604e-02f, 1.11290598e-02f, -3.60479802e-02f, -3.86788361e-02f, 4.02416363e-02f, 2.62660217e-02f, -9.83145982e-02f, -5.07414117e-02f,
  -9.08814091e-03f, 5.73675483e-02f, -1.23392902e-02f, -7.26283237e-04f, -4.99879941e-02f, 3.93199921e-02f, 1.06991818e-02f, 7.48222694e-02f, -1.05370609e-02f, 5.68394661e-02f,
  9.60816909e-03f, -2.22087242e-02f, -3.77713963e-02f, 7.23380521e-02f, 3.16631086e-02f, -2.07285155e-02f, 9.51008033e-03f, 6.98111281e-02f, 1.15620367e-01f, 1.61431700e-01f,
  4.84363496e-01f, 5.08677401e-02f, -1.12049334e-01f, 4.11084890e-02f, -7.41849933e-03f, -2.39861861e-01f, -2.19904780e-01f, -4.75029834e-02f, 8.87101367e-02f, -5.43946140e-02f,
  -9.76931751e-02f, -5.19196279e-02f, 8.57508406e-02f, 2.85658874e-02f, -4.93189879e-02f, -1.57040842e-02f, 1.49407744e-01f, 2.06438884e-01f, -2.28336938e-02f, -1.43748596e-01f,
  2.45054276e-03f, 1.36414424e-01f, 1.53019592e-01f, 5.87426089e-02f, 1.35108810e-02f, -1.58777967e-01f, -4.73310836e-02f, -1.80368405e-02f, -3.77426036e-02f, 3.81838620e-01f,
  -4.50127497e-02f, 5.87632731e-02f, -1.04151480e-01f, 7.45610148e-02f, -6.75613284e-02f, 1.87894683e-02f, -2.13300996e-02f, 8.90795812e-02f, 4.49005626e-02f, 6.03509583e-02f,
  7.76402056e-02f, 6.69899806e-02f, 1.25355959e-01f, -4.82550776e-03f, -1.48918414e-02f, 2.33897287e-02f, -3.23947370e-02f, 9.22438130e-02f, -6.21123891e-03f, -1.22674210e-02f,
  1.10233687e-01f, 9.41797644e-02f, -6.26965985e-02f, -2.56777331e-02f, 5.30694500e-02f, -2.35799439e-02f, -5.23222163e-02f, 6.94926679e-02f, -2.40287129e-02f, 1.11469828e-01f,
  2.85881590e-02f, 6.74555078e-02f, 1.76562164e-02f, 9.56756528e-03f, 3.18573900e-02f, -5.86963817e-02f, 1.87086931e-03f, -5.82762398e-02f, -1.50488876e-02f, 2.23870892e-02f,
  1.35214580e-03f, -2.22366378e-02f, -1.49913598e-03f, 3.95942852e-02f, -7.69501328e-02f, 4.70703468e-03f, -1.62575599e-02f, 3.28242294e-02f, 1.97928417e-02f, 5.93678036e-04f,
  1.16032863e-03f, 2.44179256e-02f, -2.12192237e-02f, 2.39405725e-02f, -5.49831502e-02f, 4.98524420e-02f, 8.15267041e-02f, 3.64330108e-03f, 6.38593659e-02f, 2.93948613e-02f,
  -2.45176479e-01f, -9.59727615e-02f, 3.04692164e-02f, 2.21087486e-02f, -4.49044928e-02f, -4.37157080e-02f, 1.16366958e-02f, 9.04010758e-02f, -1.39901526e-02f, 1.34450579e-02f,
  -6.38390407e-02f, 9.26959515e-03f, -4.80716713e-02f, -3.71336862e-02f, -4.59983386e-02f, 5.21718487e-02f, 3.57094407e-02f, -7.98459351e-02f, -1.15086190e-01f, -2.32428126e-02f,
  3.02996002e-02f, -5.81865273e-02f, -1.05480410e-01f, -1.04853787e-01f, -2.11918410e-02f, -2.63082702e-03f, -1.64797321e-01f, -7.05871433e-02f, -1.68323785e-01f, -2.23100573e-01f,
  1.24069210e-02f, -3.88929248e-02f, 6.81047589e-02f, 3.47111225e-02f, 5.53730391e-02f, -2.07785234e-01f, -2.44504839e-01f, -1.16743766e-01f, -7.22189471e-02f, -8.51149336e-02f,
  -7.22348830e-03f, 5.60328588e-02f, 1.54334426e-01f, 1.70274705e-01f, 9.63774219e-04f, -8.57777968e-02f, 1.61027372e-01f, 1.36915535e-01f, -5.49571179e-02f, -7.69074634e-02f,
  1.26020253e-01f, 1.15717866e-01f, 1.90225929e-01f, 6.91808239e-02f, 6.64801970e-02f, -1.00533990e-02f, 6.90093264e-02f, 1.14611521e-01f, -6.72893077e-02f, 1.98156163e-01f,
  9.25403684e-02f, -9.67482280e-04f, 8.35495070e-02f, 9.36820805e-02f, 8.45884308e-02f, 3.36585529e-02f, -3.78541909e-02f, 1.19845262e-02f, 1.54461497e-02f, -3.70351560e-02f,
  6.13658242e-02f, -4.47407737e-02f, 8.62430483e-02f, 5.12634180e-02f, -7.22947856e-03f, -4.97199297e-02f, 1.14501432e-01f, 9.86730531e-02f, -3.62357199e-02f, -2.96806227e-02f,
  1.39315650e-01f, -3.39195356e-02f, -8.43562707e-02f, -9.43631530e-02f, -1.65786259e-02f, 5.81886917e-02f, -9.52394009e-02f, 1.60869549e-03f, -7.45889079e-03f, -5.21776490e-02f,
  2.01828661e-03f, -6.53790087e-02f, 4.94961552e-02f, 1.70533713e-02f, -5.03032058e-02f, -3.86462398e-02f, 4.39005764e-03f, 4.38808724e-02f, -5.16100153e-02f, -2.81345099e-02f,
  2.16057505e-02f, -8.13666955e-02f, 4.02701907e-02f, -4.56809290e-02f, -2.55425852e-02f, 5.55429459e-02f, -5.31919599e-02f, 3.94886769e-02f, 3.04836892e-02f, -2.03988701e-03f,
  2.56650466e-02f, -4.47876602e-02f, 2.76099630e-02f, 3.19815334e-03f, -4.92349081e-02f, 1.60041153e-02f, -4.29201387e-02f, -4.87667173e-02f, 4.56805751e-02f, -4.35935631e-02f,
  -1.98182110e-02f, 8.44916776e-02f, -5.44363968e-02f, -4.05886536e-03f, 5.62287420e-02f, 7.27252290e-02f, 7.13090003e-02f, 5.09869568e-02f, -1.89028289e-02f, 4.57334667e-02f,
  -3.55878323e-02f, -1.75628960e-02f, -4.99882028e-02f, -5.49688586e-04f, -3.85777876e-02f, -5.45190945e-02f, 3.69231440e-02f, 9.98069197e-02f, 2.14369576e-02f, -5.27190976e-02f,
  -4.42664251e-02f, -1.87663481e-01f, -3.39940377e-02f, -4.36740965e-02f, -9.80704129e-02f, 1.88207766e-03f, -2.66732667e-02f, -8.00774992e-02f, -1.19712586e-02f, -7.23140985e-02f,
  9.62062255e-02f, -1.13136753e-01f, -1.53116971e-01f, 1.36874467e-01f, -7.13811219e-02f, 1.87544413e-02f, 1.54776290e-01f, 9.34780166e-02f, 1.21758342e-01f, 1.64437830e-01f,
  -3.82675566e-02f, 5.05377986e-02f, 6.51939809e-02f, 5.02356477e-02f, 1.03744455e-01f, 1.24379456e-01f, 2.85402108e-02f, -1.17385782e-01f, 1.80702031e-01f, 3.35806012e-02f,
  9.98844728e-02f, -1.39139313e-02f, -7.91716650e-02f, -7.87624195e-02f, 6.25271499e-02f, 5.27258292e-02f, -1.00955509e-01f, -1.31118864e-01f, -1.68072551e-01f, -7.94439614e-02f,
  1.05943007e-03f, -3.08982193e-01f, 1.27950549e-01f, 7.18697757e-02f, -4.23479602e-02f, 4.18158099e-02f, 9.77932941e-03f, -7.61005059e-02f, -1.55063458e-02f, 4.29583117e-02f,
  -2.38757581e-02f, 4.24381047e-02f, 1.92421246e-02f, 3.44193913e-02f, -1.30367950e-02f, 5.55265509e-02f, -1.16122521e-01f, -1.90894343e-02f, 2.11873502e-02f, -6.90589622e-02f,
  1.23542023e-03f, -1.29527360e-01f, -1.73100129e-01f, -9.84710548e-03f, -1.38048932e-01f, 4.44565639e-02f, -6.89639002e-02f, 2.89121214e-02f, -9.47027355e-02f, 8.84973258e-02f,
  3.32058314e-03f, -2.03227978e-02f, -7.15394411e-03f, 5.96515350e-02f, 5.15055060e-02f, 3.12665105e-02f, -1.86747964e-02f, 6.72479719e-03f, -5.38011780e-04f, 9.35454518e-02f,
  -2.62558647e-02f, 7.64906257e-02f, 3.02458629e-02f, -3.93235162e-02f, 2.01926939e-02f, 5.75382486e-02f, 3.92642505e-02f, -6.51355758e-02f, -1.02944426e-01f, -1.23909665e-02f,
  -3.32760066e-02f, -8.37808996e-02f, 5.41031314e-03f, -7.05422908e-02f, -4.39671874e-02f, -5.30186556e-02f, 6.32217200e-03f, -8.14360008e-03f, 7.49430880e-02f, 4.36935909e-02f,
  4.19833452e-01f, -1.87077314e-01f, 1.80922776e-01f, 4.61629741e-02f, 3.35344970e-02f, 2.36370899e-02f, 8.28313641e-04f, -9.41931158e-02f, 2.67088171e-02f, -7.72502869e-02f,
  -4.19181474e-02f, 4.57273386e-02f, -9.79552343e-02f, -3.81135903e-02f, 3.22632976e-02f, 3.17406021e-02f, 9.70041677e-02f, 1.39578789e-01f, -6.06468432e-02f, -1.63669547e-03f,
  3.78248096e-02f, 1.02439173e-01f, 2.60618716e-01f, 9.64677557e-02f, 2.31357720e-02f, 8.59410241e-02f, 1.05120391e-01f, 2.10048243e-01f, 2.18262762e-01f, 4.34743196e-01f,
  3.38574648e-01f, -7.66677335e-02f, 5.14164306e-02f, 7.31724352e-02f, -7.18944520e-02f, -2.32116450e-02f, 1.73981041e-02f, -6.05428480e-02f, -1.39691934e-01f, -1.28727853e-01f,
  -2.41496507e-02f, 4.47135009e-02f, 4.52309055e-03f, -1.32610872e-01f, -2.64014229e-02f, 1.42457550e-02f, 2.95145642e-02f, 4.36823852e-02f, 5.02568707e-02f, 1.45717591e-01f,
  -1.85404569e-02f, 1.52855981e-02f, 7.75345638e-02f, -1.47372643e-02f, 1.77509487e-02f, 2.13161130e-02f, 1.31516829e-02f, 9.62914601e-02f, -9.90198180e-02f, 4.71228361e-02f,
  3.52705866e-01f, 9.29035153e-03f, 1.54516678e-02f, -7.02330843e-02f, 6.40660301e-02f, -4.93351296e-02f, -4.10449058e-02f, -2.42392905e-02f, -1.00860439e-01f, -2.54828315e-02f,
  -7.71439523e-02f, -9.61573496e-02f, -7.14897141e-02f, 2.28303168e-02f, 1.52034402e-01f, 2.89323218e-02f, 8.77301171e-02f, -7.69648403e-02f, -1.32485762e-01f, 9.17070452e-03f,
  -8.28003436e-02f, -5.67825735e-02f, -5.26008010e-02f, -9.84649733e-02f, 4.62571979e-02f, -7.05865845e-02f, 8.17893222e-02f, -3.90083827e-02f, 2.15363950e-02f, 8.21553022e-02f,
  -4.74221185e-02f, -1.31816827e-02f, -9.53149889e-03f, -2.44989600e-02f, -7.07893148e-02f, -5.37952483e-02f, 4.15216796e-02f, -7.07385987e-02f, 3.76970544e-02f, 3.88751589e-02f,
  3.80852968e-02f, 4.38297074e-03f, 6.06147898e-03f, -5.18301576e-02f, 1.44085204e-02f, -4.21952680e-02f, 4.83779460e-02f, -6.41086474e-02f, -1.81178972e-02f, 3.62579487e-02f,
  -7.26051396e-04f, -1.70788709e-02f, 9.34451297e-02f, 1.20315276e-01f, -9.36271846e-02f, 3.35517302e-02f, -6.82352334e-02f, 2.89748572e-02f, -4.63015661e-02f, 2.28571966e-02f,
  3.50447893e-02f, -1.92433849e-01f, 1.38914004e-01f, 2.44688224e-02f, -3.04852612e-02f, -7.16512427e-02f, -2.65512802e-02f, 1.29850395e-03f, 9.16739553e-03f, -8.45712237e-03f,
  3.18646356e-02f, 3.11769247e-02f, -4.77713309e-02f, 3.33124660e-02f, -1.83869973e-02f, 6.50794012e-03f, -5.89971766e-02f, -6.49769208e-04f, -1.17699746e-02f, 3.54290404e-03f,
  -1.13922194e-01f, 8.30495954e-02f, 1.30307958e-01f, 2.80281659e-02f, 2.45752633e-02f, -2.21016202e-02f, -1.61707997e-02f, 6.69170124e-03f, -4.03812155e-02f, 2.75126286e-02f,
  -7.53935635e-01f, -8.36124569e-02f, 1.39159843e-01f, -1.57854065e-01f, 1.33317292e-01f, 2.66065784e-02f, 3.39507721e-02f, -5.99890389e-02f, -8.15943703e-02f, 7.14714229e-02f,
  1.04516625e-01f, 6.44416735e-02f, 4.62198853e-02f, 1.36201978e-01f, -1.43061161e-01f, 9.91414785e-02f, 9.13045183e-02f, 1.16449289e-01f, -3.58131598e-03f, -7.48770731e-03f,
  1.06070913e-01f, -1.96894277e-02f, -1.59660578e-01f, -1.07763350e-01f, 3.87139642e-03f, 8.55581556e-03f, 1.37165949e-01f, -3.52859609e-02f, -9.80953779e-03f, 1.78431734e-01f,
  2.18967304e-01f, -6.26228526e-02f, 4.12411019e-02f, -5.80130741e-02f, 5.87389059e-02f, -3.31648551e-02f, -5.34362011e-02f, 3.41706462e-02f, -6.85366662e-03f, -1.64755601e-02f,
  1.20027788e-01f, 1.58083327e-02f, 2.82973610e-03f, 7.09399432e-02f, 1.25463549e-02f, 1.08185876e-02f, -3.23521458e-02f, -3.58740389e-02f, 3.33469845e-02f, 3.12492047e-02f,
  6.04908243e-02f, 6.85129166e-02f, 2.40864903e-02f, 1.72374565e-02f, -3.10091656e-02f, 1.61749363e-01f, 6.84142038e-02f, -4.05895486e-02f, -9.91152506e-03f, -4.55478653e-02f,
  -3.58496085e-02f, 6.71669515e-03f, 2.24890038e-02f, -1.35010108e-02f, -5.29929101e-02f, -2.35186759e-02f, -2.47264709e-02f, 2.88331583e-02f, -3.57480790e-03f, 1.52309686e-02f,
  8.28936249e-02f, 2.30226025e-04f, 4.73949984e-02f, -2.54018847e-02f, 8.59730095e-02f, 8.78052227e-03f, -3.14398594e-02f, 1.57703031e-02f, 1.25636756e-02f, 3.74988504e-02f,
  -6.03136420e-02f, -2.70075388e-02f, 3.12646255e-02f, 9.58242118e-02f, 2.49217637e-02f, -1.14781819e-02f, 3.04279998e-02f, -2.69201375e-03f, -4.79084961e-02f, 2.43109278e-02f,
  -6.16818154e-03f, 1.23647735e-01f, 7.94996247e-02f, 1.43300584e-02f, -2.59124227e-02f, 5.22371568e-03f, 2.48084664e-02f, -6.00754432e-02f, -3.31374304e-03f, -7.27292225e-02f,
  -1.09508457e-02f, -2.06072498e-02f, 4.32175249e-02f, 1.87485721e-02f, -7.36643001e-02f, -1.34092882e-01f, 5.08567803e-02f, -3.09954640e-02f, 3.04289367e-02f, -4.38563488e-02f,
  3.15881036e-02f, -1.61260739e-01f, -9.14168581e-02f, 6.65908903e-02f, 1.15317563e-02f, -1.87430909e-04f, 1.76610220e-02f, 4.08296054e-03f, -2.71612480e-02f, -1.04157180e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.91384479e-01f, -4.65109870e-02f, 8.24413151e-02f, -2.10806295e-01f, -5.51507846e-02f, 5.04975989e-02f, -1.21074850e-02f, 9.04969871e-02f, -6.15234263e-02f, 1.79312397e-02f,
  -1.78303961e-02f, -1.54629406e-02f, 7.08355457e-02f, -1.47184515e-02f, 9.32052732e-02f, 2.17915103e-02f, -6.20646328e-02f, -6.05931319e-02f, 1.30130410e-01f, -1.48439477e-03f,
  -7.42931664e-02f, -7.03087375e-02f, -1.65298164e-01f, -1.26049956e-02f, -1.48330539e-01f, -1.27125993e-01f, -4.96527851e-02f, -1.21216118e-01f, -2.90463548e-02f, -2.18770236e-01f,
  -2.94522829e-02f, 3.39164697e-02f, 4.35472690e-02f, -6.73018619e-02f, 6.52765781e-02f, 3.32939066e-02f, 5.83473258e-02f, -1.07780369e-02f, -7.05854669e-02f, 2.78896131e-02f,
  -5.64948246e-02f, 9.67639685e-03f, -5.57677671e-02f, 4.80583608e-02f, 3.34324464e-02f, 7.89107159e-02f, 1.09885782e-02f, 1.75415035e-02f, -2.23190617e-02f, 8.83061886e-02f,
  3.07608638e-02f, -1.88541159e-01f, -7.15418532e-02f, 8.33152328e-03f, 9.55654308e-03f, -4.91054207e-02f, -1.26360700e-01f, -6.69485033e-02f, -2.29795948e-02f, -1.26066938e-01f,
  -5.70904464e-02f, 6.43202886e-02f, 6.49028271e-02f, -6.84099644e-02f, 4.65004332e-02f, 5.06853200e-02f, 2.48362012e-02f, -9.10146013e-02f, -1.77924316e-02f, -8.89738351e-02f,
  2.30593979e-02f, 1.29393026e-01f, 6.66678026e-02f, -5.46639077e-02f, -8.28098729e-02f, -5.13016768e-02f, -7.82890469e-02f, -9.06664208e-02f, 4.19861935e-02f, 6.12454452e-02f,
  -1.11154109e-01f, 2.94319075e-02f, 4.30045724e-02f, -6.65110052e-02f, -7.46219978e-02f, -6.67624697e-02f, 1.32601662e-02f, -1.43615194e-02f, 2.47653536e-02f, -1.87683962e-02f,
  -1.16688900e-01f, 1.76115438e-01f, -2.00393284e-03f, -2.27078199e-02f, -3.96262556e-02f, 3.18178646e-02f, -6.40902743e-02f, -3.82391997e-02f, -1.22166937e-02f, 1.48873627e-02f,
  1.15826949e-02f, 4.56860326e-02f, -4.52494659e-02f, 6.97714612e-02f, 3.47939245e-02f, 6.04626350e-02f, -1.34895667e-02f, -4.07255292e-02f, -5.18462509e-02f, -5.34440093e-02f,
  -5.94701152e-03f, -5.75400479e-02f, -2.31235385e-01f, -5.65955304e-02f, -8.25563520e-02f, -1.09216295e-01f, -1.15227595e-01f, -8.05766061e-02f, 6.55962601e-02f, -1.96591690e-01f,
  4.42879554e-03f, -1.67956296e-02f, -2.84145754e-02f, 5.36697879e-02f, -4.48806435e-02f, -2.17435826e-02f, 8.96475464e-02f, -5.16835041e-03f, 1.52655616e-02f, 1.51814222e-01f,
  4.48831208e-02f, 9.63279046e-03f, -8.04631934e-02f, 8.78632143e-02f, 1.47642521e-02f, 9.66074467e-02f, -6.90435991e-02f, -1.05813414e-01f, -9.71415192e-02f, 9.17645246e-02f,
  -4.79040369e-02f, 3.02940421e-02f, 1.55952349e-02f, -1.04057863e-02f, -4.90043461e-02f, 1.30452201e-01f, -2.64049266e-02f, 9.88772884e-03f, 7.59288222e-02f, -7.36083314e-02f,
  -3.28036249e-02f, -1.05940118e-01f, -8.00462663e-02f, -4.24611755e-02f, -1.19503578e-02f, -3.26891094e-02f, -6.83784783e-02f, -6.90160915e-02f, -8.81916657e-02f, -2.80710086e-02f,
  -6.37570173e-02f, -8.88643563e-02f, -8.75755250e-02f, 1.07424371e-02f, -6.24936558e-02f, 7.47335851e-02f, -7.19297007e-02f, 4.23493199e-02f, -1.07340313e-01f, -8.87258872e-02f,
  -5.64492606e-02f, -3.22907567e-02f, -1.08880244e-01f, 7.84852654e-02f, -2.63484921e-02f, -1.56223495e-02f, -1.00136455e-02f, -4.02511470e-02f, -1.46673182e-02f, 1.12282999e-01f,
  -8.20668135e-03f, 6.83093630e-03f, 6.21997900e-02f, 3.18785049e-02f, 7.35136122e-02f, 1.12219471e-02f, -4.97185625e-02f, 7.55285546e-02f, -6.89002173e-03f, -1.53585188e-02f,
  -3.35555263e-02f, -1.11685500e-01f, -1.12312124e-03f, 6.70991465e-02f, 8.74532238e-02f, 6.81417063e-02f, -3.32667045e-02f, -1.02678705e-02f, -5.87770529e-02f, 1.07421540e-01f,
  5.67576557e-04f, 7.75531307e-02f, 9.82678384e-02f, -6.62221387e-02f, -1.54755851e-02f, 5.47346845e-02f, 3.88085842e-02f, 2.87755150e-02f, -2.98950654e-02f, 6.96397647e-02f,
  5.62358983e-02f, -2.98921298e-02f, 3.53778899e-02f, -3.77245992e-02f, 5.66010661e-02f, 6.30388856e-02f, -6.52890536e-04f, 7.44040757e-02f, -7.77736232e-02f, 8.32922831e-02f,
  -1.09091803e-01f, -5.69343492e-02f, 5.35593107e-02f, 7.87183866e-02f, 5.63173778e-02f, 2.61222832e-02f, -2.04106439e-02f, -5.65006435e-02f, -7.52157271e-02f, 2.28618998e-02f,
  5.32115586e-02f, 1.49253920e-01f, 5.61500080e-02f, 1.21038213e-01f, -6.09957837e-02f, 2.85930298e-02f, 3.57444776e-04f, 1.05958328e-01f, -1.07550696e-02f, 2.42895126e-01f,
  3.50630254e-01f, -4.92582172e-01f, -3.76940638e-01f, 2.81421661e-01f, -2.53100932e-01f, -5.74468933e-02f, -4.04340714e-01f, 2.76692398e-02f, 1.85287192e-01f, -1.21570550e-01f,
  -6.93120435e-03f, 2.47465342e-01f, 1.63086683e-01f, 6.92286640e-02f, 1.44522563e-01f, -3.25538456e-01f, -2.94320136e-01f, 1.24406070e-02f, 2.02515408e-01f, 3.32198292e-02f,
  -6.54363781e-02f, 2.58506369e-02f, 1.44559249e-01f, 2.12951168e-01f, -5.06175980e-02f, -6.85217083e-02f, -2.44583637e-01f, -1.07560173e-01f, -8.34136978e-02f, -4.21058118e-01f,
  -1.28250316e-01f, -3.81249227e-02f, 1.17418291e-02f, 4.36699316e-02f, -5.03830723e-02f, 1.23080596e-01f, 2.44108657e-03f, -2.52487268e-02f, 7.61588663e-02f, -2.35187449e-02f,
  7.42988959e-02f, 5.57836965e-02f, -1.82024448e-03f, -4.09777202e-02f, -9.26393829e-03f, 1.25860246e-02f, -1.86177604e-02f, 8.46193582e-02f, -5.73872626e-02f, -4.62933965e-02f,
  -1.16562836e-01f, -1.16061904e-02f, -8.36499035e-03f, -4.83309105e-02f, 1.16004452e-01f, 7.60989934e-02f, -1.30307645e-01f, 5.25399521e-02f, -3.08612660e-02f, -2.81207889e-01f,
  -3.94623354e-02f, 4.82508028e-03f, 6.76184073e-02f, -4.71109003e-02f, 2.54365299e-02f, 1.79049391e-02f, -1.25894062e-02f, -4.59554642e-02f, 1.38776116e-02f, -5.52097112e-02f,
  -2.34776009e-02f, -1.12603046e-02f, 2.81030275e-02f, 2.00106744e-02f, -2.04713363e-02f, -3.52593921e-02f, 1.81446467e-02f, -2.47018225e-02f, 5.21266349e-02f, 1.96170676e-02f,
  -3.64038497e-02f, 1.38595747e-02f, -1.08688008e-02f, 4.13711295e-02f, -3.29334778e-03f, 1.06618991e-02f, 4.16844934e-02f, -3.59513424e-02f, 1.32457260e-02f, -6.33740798e-02f,
  1.28864989e-01f, 7.08834305e-02f, -2.47037243e-02f, 3.23915598e-03f, 4.30497117e-02f, -5.66037744e-03f, 1.76388212e-02f, 3.03335977e-03f, -8.48947559e-03f, 9.10935458e-03f,
  1.57051906e-02f, 5.53062856e-02f, -2.76516508e-02f, 1.30740749e-02f, -1.59947537e-02f, 4.11993191e-02f, -4.42048348e-02f, -2.81453915e-02f, 5.10934927e-02f, -3.54013708e-03f,
  5.78475334e-02f, -4.87361662e-02f, -6.97007626e-02f, 4.00540493e-02f, 1.69814173e-02f, 3.59227555e-03f, -7.62169734e-02f, 5.39800562e-02f, 5.58047257e-02f, -1.80428818e-01f,
  -4.52684015e-01f, -2.54718699e-02f, -8.50730166e-02f, 1.45034701e-01f, 1.83584109e-01f, 5.62052615e-02f, 1.12308837e-01f, 1.30553439e-01f, 1.61276042e-01f, 1.12655856e-01f,
  8.06650333e-03f, 1.19577289e-01f, 1.82999343e-01f, 1.58252582e-01f, 6.99079707e-02f, 7.78401867e-02f, 2.88994879e-01f, 1.31628439e-01f, 6.36751717e-03f, 2.34213658e-02f,
  1.07984051e-01f, -1.89040340e-02f, -8.44980329e-02f, 7.87395313e-02f, 1.00541405e-01f, 7.26916417e-02f, -3.04059554e-02f, -3.70206721e-02f, -1.65403690e-02f, 2.32391700e-01f,
  -2.43687227e-01f, -2.43476093e-01f, 1.66450534e-02f, 7.74979666e-02f, -6.52367482e-03f, -9.79038998e-02f, -1.12315506e-01f, -3.01695298e-02f, -3.71292420e-02f, -7.95046166e-02f,
  -1.11968361e-01f, -7.98604786e-02f, 5.16568422e-02f, -6.30494729e-02f, -8.06697756e-02f, -8.16637725e-02f, -1.69999264e-02f, -1.30060270e-01f, 7.45630544e-03f, -1.19650029e-01f,
  8.72413740e-02f, -6.24056645e-02f, -1.65168807e-01f, -5.80383576e-02f, 5.44878356e-02f, 2.14190800e-02f, -2.42688842e-02f, -1.09286241e-01f, -1.07364483e-01f, 3.16560902e-02f,
  8.71408358e-02f, -5.97349368e-02f, 2.08348334e-02f, -2.66448595e-02f, 1.55379465e-02f, 4.15832102e-02f, 8.55229124e-02f, 9.11341235e-02f, 2.66842972e-02f, 4.04667258e-02f,
  2.89700143e-02f, 2.51087882e-02f, -4.16208245e-02f, 2.21562088e-02f, 7.81723410e-02f, -2.21524015e-02f, -2.43138205e-02f, -8.85604881e-03f, -2.59845890e-02f, -1.63206067e-02f,
  -4.50485619e-03f, -5.17649464e-02f, -1.30554944e-01f, 2.37554200e-02f, 5.90979122e-02f, -3.03078052e-02f, 2.65559517e-02f, 5.62404655e-02f, -8.22889507e-02f, -1.54128941e-02f,
  9.87806842e-02f, -6.48744544e-03f, 6.14679269e-02f, -6.44308627e-02f, -5.93675710e-02f, -6.44983584e-03f, -8.67451727e-02f, -8.34456906e-02f, -8.21820721e-02f, -9.84593481e-02f,
  -6.65116236e-02f, -2.61768363e-02f, -2.74946149e-02f, -6.62596226e-02f, 5.36275841e-03f, 3.09664328e-02f, 4.76635955e-02f, 6.80725137e-03f, 7.32701048e-02f, -9.58316848e-02f,
  -7.61267310e-03f, 7.49325054e-03f, -1.43296599e-01f, -4.94082607e-02f, -6.77320585e-02f, 2.78498530e-02f, -1.14398282e-02f, -8.07873160e-02f, -4.31993231e-02f, -1.43514782e-01f,
  -4.55758348e-02f, 6.42229319e-02f, -3.49559784e-02f, 2.66106743e-02f, 5.48299178e-02f, 5.35318553e-02f, 1.06413998e-01f, -2.42744982e-02f, -3.71307880e-02f, 5.86957717e-03f,
  -8.31960514e-03f, 3.64068486e-02f, 5.07213026e-02f, -7.87179992e-02f, 3.39557603e-02f, 1.52660972e-02f, 5.03508700e-03f, -5.18592820e-03f, -4.29146737e-02f, -6.27689436e-02f,
  7.59799331e-02f, 6.41293777e-03f, -3.38130482e-02f, -6.41153902e-02f, 1.02366256e-02f, -8.97202268e-02f, 4.81362157e-02f, 1.00397013e-01f, -3.45070288e-02f, 9.76485386e-02f,
  6.02020882e-02f, 1.58829689e-01f, 5.99550828e-02f, -6.24260120e-02f, 1.78813078e-02f, 5.44564053e-02f, 1.45185301e-02f, 1.52933681e-02f, -2.09132228e-02f, 4.44395170e-02f,
  -3.89457196e-02f, 8.05991143e-02f, -2.76244432e-02f, -5.80961108e-02f, -7.60188252e-02f, -1.88815575e-02f, 4.12679836e-02f, 5.55864945e-02f, -8.47813338e-02f, -3.95541228e-02f,
  6.30732849e-02f, 3.00104953e-02f, 3.28464769e-02f, -9.25378278e-02f, -6.00898266e-02f, -8.39738771e-02f, 3.93202109e-03f, -2.23367680e-02f, -4.42973152e-03f, 4.10592370e-02f,
  -8.00639167e-02f, 6.68774620e-02f, 1.18700571e-01f, -6.32105917e-02f, 5.17060347e-02f, -4.21989411e-02f, 5.18184789e-02f, 2.62799859e-02f, -1.10910702e-02f, 7.19954148e-02f,
  -7.91938826e-02f, -1.17207117e-01f, 5.48455603e-02f, -8.21527392e-02f, -4.07350846e-02f, -2.01651007e-02f, 9.92584005e-02f, -8.43295231e-02f, -8.79587233e-02f, 2.46615354e-02f,
  1.68876965e-02f, -5.90355732e-02f, -3.99979278e-02f, 1.17686205e-02f, 7.71600977e-02f, 6.65842295e-02f, -3.59897688e-02f, -8.42504650e-02f, 1.21235223e-02f, 7.83192888e-02f,
  -6.50886521e-02f, 4.29860614e-02f, 2.92176306e-02f, 5.06757982e-02f, 4.66616713e-02f, 2.96175852e-02f, -6.04097769e-02f, 3.05756591e-02f, 8.20745826e-02f, -2.78526153e-02f,
  8.13518539e-02f, 9.34402049e-02f, 3.22213657e-02f, -7.06221089e-02f, 2.91874893e-02f, -6.88099265e-02f, -6.80888668e-02f, -1.28457576e-01f, 6.82988390e-02f, -6.96945712e-02f,
  -2.32963059e-02f, -3.62887122e-02f, -3.60662602e-02f, -6.04006611e-02f, 4.85636443e-02f, -1.18308499e-01f, -3.65541875e-02f, 3.38352546e-02f, 3.77454869e-02f, -6.11361191e-02f,
  6.18504127e-03f, -6.47443160e-02f, -3.22734453e-02f, 1.73059534e-02f, 6.98313490e-02f, 5.47619425e-02f, -1.25080705e-01f, 1.52708292e-01f, 1.75892636e-01f, -9.11270231e-02f,
  -3.91169488e-02f, 7.61622638e-02f, 6.52206093e-02f, 3.74237113e-02f, -4.23553400e-02f, -9.59542170e-02f, -1.24267794e-01f, -5.52153215e-02f, 1.42334536e-01f, 5.34108169e-02f,
  -3.68776955e-02f, -1.80834271e-02f, 1.07557185e-01f, 1.30046874e-01f, -7.01339096e-02f, -1.04660392e-01f, -9.59362462e-02f, -5.41838668e-02f, -1.13088541e-01f, -3.87615740e-01f,
  -1.99518830e-01f, 8.37262496e-02f, -1.67592540e-02f, 6.46056160e-02f, -8.14917833e-02f, 3.45206261e-03f, -4.97987717e-02f, -4.47242483e-02f, -2.79919687e-03f, -5.78094982e-02f,
  5.60145937e-02f, 3.32308076e-02f, 4.62787338e-02f, -3.34675051e-02f, -2.03229394e-03f, 1.62732489e-02f, 4.59030317e-03f, -8.66870955e-02f, -1.93526538e-03f, -2.30727177e-02f,
  -6.18855245e-02f, -8.88258740e-02f, -1.04154192e-01f, 3.85080576e-02f, 4.09107767e-02f, -4.53429408e-02f, -5.53718954e-02f, -1.24930657e-01f, -7.31474757e-02f, -8.55971724e-02f,
  1.04000075e-02f, -6.00751899e-02f, -3.84462029e-02f, 2.38779038e-02f, -6.50892854e-02f, -1.32194022e-02f, -2.92187557e-02f, -3.11631709e-02f, 5.41012622e-02f, 2.06270739e-02f,
  8.34928453e-02f, 2.69530322e-02f, 3.79422121e-02f, 2.75634173e-02f, -1.01924554e-01f, 4.21487689e-02f, 9.78052467e-02f, -5.16780466e-02f, -8.88740644e-03f, -3.40455249e-02f,
  6.28952235e-02f, -4.33824509e-02f, 5.92698827e-02f, 4.82253358e-02f, -7.68647641e-02f, 4.34656404e-02f, 6.53170049e-02f, -8.17780942e-03f, 8.61269161e-02f, 1.49919927e-01f,
  3.90381776e-02f, 1.05422862e-01f, -8.27244148e-02f, 9.58844926e-03f, -1.18137486e-02f, -6.68600127e-02f, -3.53064798e-02f, 6.58980384e-02f, 1.00483976e-01f, 6.38866276e-02f,
  3.00338725e-03f, 4.09813458e-03f, -4.46242876e-02f, -5.02444580e-02f, 3.61945555e-02f, -3.60966958e-02f, -2.63521969e-02f, -3.09977233e-02f, -4.57302071e-02f, -4.25231606e-02f,
  -1.14786282e-01f, -1.21664479e-01f, 1.12960776e-02f, -6.29575476e-02f, -9.67520773e-02f, -7.32837692e-02f, -8.51044208e-02f, -1.40389174e-01f, -1.18944012e-01f, -6.06240444e-02f,
  6.70248419e-02f, -1.45690635e-01f, -3.94164585e-02f, 5.45364209e-02f, -9.43896696e-02f, 7.05968589e-02f, -1.38530612e-01f, -3.67299393e-02f, -4.01023291e-02f, -5.71386255e-02f,
  -7.07901195e-02f, 7.69164413e-02f, 7.17017725e-02f, 3.28968056e-02f, -5.14781587e-02f, -7.59225041e-02f, -8.56067762e-02f, 2.10382584e-02f, 5.22728488e-02f, -6.17294088e-02f,
  -8.40715840e-02f, -4.21112664e-02f, -5.28363027e-02f, 7.94328973e-02f, -4.21674140e-02f, -8.88303071e-02f, -1.21502392e-02f, -1.82865802e-02f, -1.42794728e-01f, -2.72776447e-02f,
  -1.27967119e-01f, -4.80974615e-02f, 4.00506072e-02f, 4.10802960e-02f, -6.37649372e-02f, -8.96969065e-03f, -5.21180639e-03f, 4.31575105e-02f, -5.79912737e-02f, 3.85362916e-02f,
  -1.00917168e-01f, -3.31630707e-02f, 5.17932437e-02f, 2.44473629e-02f, 6.40803799e-02f, 3.00072823e-02f, 5.57136722e-02f, -8.96863174e-03f, -4.99398746e-02f, 3.10801230e-02f,
  2.57040728e-02f, 3.20204441e-03f, 1.00962698e-01f, 9.34281647e-02f, -2.54974067e-02f, 7.46408775e-02f, -1.79438516e-02f, -5.90492152e-02f, -3.94998975e-02f, 9.02674422e-02f,
  5.33491373e-02f, 1.28496094e-02f, -4.68636826e-02f, -3.05589270e-02f, 5.61038889e-02f, 8.53477791e-02f, -2.37154803e-04f, -2.36721486e-02f, 3.27180699e-02f, 1.98457707e-02f,
  2.88854446e-02f, 4.07565609e-02f, -4.95784022e-02f, 4.63942550e-02f, -5.26898764e-02f, -4.67896685e-02f, 9.76020191e-03f, -8.20369571e-02f, 4.58568931e-02f, 4.44196425e-02f,
  7.28504136e-02f, -1.96001399e-02f, -4.48114239e-02f, 4.90862057e-02f, 5.39131574e-02f, -3.32389623e-02f, 4.83618267e-02f, 3.23622525e-02f, -6.73315376e-02f, 9.83581021e-02f,
  5.57035506e-02f, 8.89216587e-02f, -6.21149503e-02f, 5.45046329e-02f, -3.99208330e-02f, -8.96356534e-03f, 3.44451964e-02f, -7.52013102e-02f, 8.85036401e-03f, 8.22035130e-03f,
  -8.01329017e-02f, -4.92011122e-02f, 7.59659754e-03f, -1.35960756e-02f, 6.54388070e-02f, -5.04235066e-02f, -4.52224817e-03f, -7.21742166e-03f, -1.04660705e-01f, -5.66265583e-02f,
  2.40369644e-02f, 7.81183317e-02f, 1.26032025e-01f, 1.06678754e-01f, 1.06779993e-01f, 8.23333338e-02f, 1.13063917e-01f, 8.15619901e-02f, 1.54026851e-01f, 9.82419401e-02f,
  2.22665109e-02f, 1.28956670e-02f, -1.17951445e-01f, -3.23697887e-02f, -1.00556850e-01f, -9.32474528e-03f, 4.21817275e-03f, 1.00206239e-02f, 2.02563088e-02f, -1.99940093e-02f,
  2.91536506e-02f, -2.11073756e-02f, 1.10096626e-01f, 1.25558570e-01f, 1.48380846e-02f, 7.16117099e-02f, 6.12715222e-02f, -5.96065857e-02f, 4.28186655e-02f, -8.02505687e-02f,
  -5.66824786e-02f, -5.65970130e-02f, 1.72592681e-02f, -3.70037742e-02f, -9.16749090e-02f, -7.36362189e-02f, 6.65792525e-02f, -9.85065624e-02f, -3.55492234e-02f, -7.15970546e-02f,
  -5.69291189e-02f, -3.28867771e-02f, -6.80462644e-02f, -5.90250734e-03f, -9.49580744e-02f, 5.41573949e-02f, 5.94477216e-03f, 8.20571149e-05f, 5.96840531e-02f, -6.70977384e-02f,
  -3.26957628e-02f, 9.16675385e-03f, -2.14957558e-02f, -4.49805724e-04f, -5.16615175e-02f, 6.88031036e-03f, 7.92012662e-02f, -1.74058061e-02f, -4.15291674e-02f, -9.43979174e-02f,
  -7.09303021e-02f, -3.50954011e-02f, 7.33683212e-03f, -8.30575153e-02f, 4.16776910e-02f, -1.22727165e-02f, -7.35491812e-02f, -6.96214139e-02f, -9.25389454e-02f, -2.88917013e-02f,
  -2.81416662e-02f, -9.02062953e-02f, -2.85867583e-02f, 8.21977779e-02f, -4.07505035e-02f, -6.79407865e-02f, -2.47630272e-02f, -5.52138537e-02f, 6.51372448e-02f, 2.84011457e-02f,
  1.85151789e-02f, -1.56183606e-02f, 8.07475895e-02f, -5.87094612e-02f, -6.78087473e-02f, -3.46695296e-02f, 6.51515722e-02f, -5.82560785e-02f, 2.14124881e-02f, 8.73264074e-02f,
  -2.91691208e-03f, 3.02662682e-02f, -5.64035540e-03f, -5.91123253e-02f, -1.88963581e-02f, -8.58051796e-03f, -1.07144795e-01f, 6.83417395e-02f, -3.45147215e-02f, -2.56302133e-02f,
  4.53107199e-03f, 1.30549029e-01f, 9.03096050e-02f, 7.44980723e-02f, 3.39987576e-02f, 5.71445301e-02f, -3.40265073e-02f, -6.96416646e-02f, 5.57648316e-02f, -1.71028320e-02f,
  -7.63488039e-02f, -5.47813736e-02f, -2.36988030e-02f, 6.35664240e-02f, 3.26147419e-03f, 7.45970458e-02f, 1.66545622e-02f, -6.97678104e-02f, -7.82535821e-02f, -4.09298427e-02f,
  -2.78006308e-02f, 8.65565985e-02f, 2.98766280e-03f, 8.66714567e-02f, -9.72959679e-03f, 1.01968609e-01f, 1.74281579e-02f, -3.89441289e-02f, 3.60253151e-04f, -6.39130175e-02f,
  -1.51340842e-01f, -7.45949671e-02f, 4.87227552e-02f, 5.13274558e-02f, 8.13247785e-02f, 9.41325650e-02f, -5.39139286e-02f, 1.20046265e-01f, -2.48729959e-02f, 1.10263028e-03f,
  7.31799379e-02f, 1.36825010e-01f, 3.43666272e-03f, 1.36623174e-01f, 1.38238773e-01f, 1.15834862e-01f, 8.96139368e-02f, 1.15494095e-01f, 1.00783944e-01f, 3.07884533e-02f,
  4.42587361e-02f, 8.24280754e-02f, 3.74937542e-02f, 8.12539384e-02f, -5.01002595e-02f, 2.75869332e-02f, -3.19401058e-03f, 2.50443015e-02f, 5.45462109e-02f, 1.08132541e-01f,
  6.47413358e-02f, -3.32102808e-03f, 1.73512161e-01f, 1.37521140e-02f, 3.99676263e-02f, 3.58406976e-02f, 8.67976397e-02f, 8.72286856e-02f, -6.02051727e-02f, 8.45244452e-02f,
  4.24918830e-02f, 6.07080348e-02f, -5.62471226e-02f, -5.12157194e-02f, 8.00005123e-02f, -6.57412335e-02f, -4.45170254e-02f, 1.41497403e-02f, 8.12514201e-02f, 8.21368694e-02f,
  1.24449976e-01f, -7.02408403e-02f, -4.67075333e-02f, 4.07119840e-02f, -3.94928409e-03f, 3.59997340e-02f, 7.85715058e-02f, 5.80800176e-02f, -6.82490468e-02f, 8.56149271e-02f,
  7.52039850e-02f, 1.76980272e-02f, -9.34810936e-02f, -1.30241066e-02f, -2.07311171e-03f, -2.14986801e-02f, -1.02131903e-01f, 3.45111936e-02f, 2.07935609e-02f, -3.41990665e-02f,
  -3.80875450e-03f, 8.36164039e-03f, -1.64395701e-02f, 8.02775025e-02f, 1.75718646e-02f, 2.70983446e-02f, -3.52281518e-02f, -9.70989689e-02f, 4.97615971e-02f, -8.43587071e-02f,
  -6.01544976e-02f, -1.12600327e-01f, 1.20939286e-02f, -5.10212742e-02f, -1.33006265e-02f, 4.62521389e-02f, -5.30848838e-02f, -9.83536094e-02f, -7.23221898e-02f, -6.64405003e-02f,
  2.00143699e-02f, 8.74693245e-02f, 1.10826276e-01f, 6.53810203e-02f, -9.40085426e-02f, -8.13129395e-02f, -6.56471997e-02f, -8.17537401e-03f, -4.34906781e-03f, 2.85760406e-02f,
  -3.68908383e-02f, -8.87207240e-02f, -3.14398073e-02f, 2.71904841e-02f, -1.16262557e-02f, -2.76706424e-02f, -5.15272515e-03f, 6.68934286e-02f, 4.84825037e-02f, 6.57212958e-02f,
  2.56972015e-02f, 5.05580567e-02f, 1.80962011e-02f, -5.23229241e-02f, 6.02092519e-02f, -2.79829521e-02f, -3.35507989e-02f, 2.24359799e-02f, -9.54285860e-02f, -4.71300520e-02f,
  4.31531549e-01f, -1.93375781e-01f, -1.53428540e-01f, 9.61327851e-02f, 1.66893471e-02f, 2.70733759e-02f, -2.26701573e-02f, 4.38070968e-02f, 3.74746993e-02f, 8.23473856e-02f,
  4.25396450e-02f, 1.80035681e-01f, 1.78533509e-01f, 5.60942478e-02f, 6.63511902e-02f, -1.27819404e-01f, -1.91056758e-01f, 6.50958046e-02f, 2.54748940e-01f, 1.16053611e-01f,
  5.36233746e-02f, -1.93307176e-02f, 1.70601860e-01f, -1.02943610e-02f, -2.26998046e-01f, 6.47493219e-03f, -1.64804146e-01f, 4.90875728e-03f, -8.27091709e-02f, -2.37244695e-01f,
  1.09286927e-01f, 4.60669883e-02f, 1.37129113e-01f, 5.89705445e-02f, -5.41649312e-02f, 2.85704527e-02f, 5.52562065e-03f, -1.01231724e-01f, -8.22108239e-02f, 3.82110514e-02f,
  -2.27362961e-02f, 4.61957825e-04f, 2.11014319e-02f, 5.33926561e-02f, -1.82280801e-02f, 3.87005880e-02f, -8.16830620e-02f, -2.38446128e-02f, 1.68785423e-01f, -3.73475999e-02f,
  -1.65504124e-02f, 6.58442527e-02f, -1.68279232e-03f, 7.81156123e-02f, 1.69625003e-02f, 6.89049512e-02f, -4.30654809e-02f, 1.97625943e-02f, 4.29869406e-02f, -1.17570736e-01f,
  2.32730117e-02f, 8.62900615e-02f, 4.65599336e-02f, 7.59998485e-02f, -4.91303531e-03f, -3.60512249e-02f, -2.18010377e-02f, 7.49008656e-02f, 1.00138842e-03f, -1.02202050e-01f,
  -2.14347970e-02f, 4.73236367e-02f, 3.90078016e-02f, -3.05338614e-02f, 8.43193531e-02f, -5.66170271e-03f, -6.14874326e-02f, 4.60052676e-02f, -6.32942691e-02f, 4.10467423e-02f,
  3.50800678e-02f, 2.02349182e-02f, -6.89550266e-02f, -1.14779640e-02f, 2.48407703e-02f, 1.26361344e-02f, -1.87423732e-02f, 3.23514417e-02f, -2.93712057e-02f, -2.57271361e-02f,
  -9.32788104e-02f, 2.92414397e-01f, 8.18742290e-02f, -1.28801195e-02f, -9.68359336e-02f, -6.93543106e-02f, -2.46278048e-02f, -2.18097530e-02f, -2.50602141e-02f, -8.28568041e-02f,
  1.18628079e-02f, 4.88348417e-02f, -3.46682556e-02f, -5.56180924e-02f, -1.36765661e-02f, 3.78979556e-02f, -1.08351715e-01f, 8.15593600e-02f, 4.11687270e-02f, -3.90306488e-02f,
  -9.56827551e-02f, -3.54247615e-02f, 1.14886232e-01f, -2.54352279e-02f, 6.18170686e-02f, 2.00028747e-01f, -1.29391849e-02f, -1.60312410e-02f, 1.73662007e-01f, -5.03998548e-02f,
  -1.55213952e-01f, 6.65638223e-02f, 4.91555892e-02f, -1.31067276e-01f, -9.89587605e-02f, 2.01061144e-02f, 5.00089936e-02f, -8.10909793e-02f, 2.83006392e-02f, 4.04011607e-02f,
  1.02016293e-01f, -3.73571962e-02f, -7.66698048e-02f, 1.13303289e-02f, 4.52183932e-02f, 4.92545636e-03f, 1.02851130e-01f, -8.41097161e-02f, -6.65744543e-02f, 4.52205949e-02f,
  8.98397565e-02f, 1.65720955e-02f, -7.11764917e-02f, 1.10372873e-02f, 1.18059970e-01f, 2.24773642e-02f, -3.89707566e-04f, 2.58487253e-03f, -1.08315684e-02f, 3.09929866e-02f,
  1.39716774e-01f, -5.98655604e-02f, 1.02721505e-01f, -1.45578049e-02f, 3.89279798e-02f, 3.30116437e-03f, -3.77228409e-02f, -5.17255813e-02f, 6.40964508e-02f, -5.56187220e-02f,
  2.11853208e-03f, -6.43063523e-03f, -1.11592258e-03f, 1.33708075e-01f, 9.17913318e-02f, -5.66587923e-03f, 3.85992341e-02f, -7.18964115e-02f, 3.33592035e-02f, 5.20986766e-02f,
  -2.43679266e-02f, 8.22843984e-02f, 7.56978318e-02f, 2.45960783e-02f, 1.72170624e-02f, 6.98017376e-03f, -1.10720098e-03f, 3.48475017e-02f, 7.57453293e-02f, -6.80851191e-02f,
  3.61284167e-02f, 6.34206459e-02f, 1.86668951e-02f, 3.16612273e-02f, 1.57195739e-02f, -7.09557608e-02f, 5.56849129e-02f, -3.06896865e-02f, -4.85446751e-02f, -8.42553973e-02f,
  -2.83118477e-03f, 4.91541997e-02f, 8.11389014e-02f, 5.00657642e-03f, 4.33631241e-02f, 4.54604812e-02f, 2.65297685e-02f, 4.18208614e-02f, -3.01022362e-02f, -6.82025105e-02f,
  2.50101611e-02f, -1.60395354e-02f, -8.13698247e-02f, -3.05877849e-02f, -7.18634874e-02f, 1.03748003e-02f, -5.48572950e-02f, 4.13016565e-02f, 8.38085935e-02f, 9.09261405e-02f,
  1.19165473e-01f, -1.30995223e-02f, 6.05637692e-02f, -5.11246175e-03f, -3.17469835e-02f, -5.72366752e-02f, -9.26258042e-03f, 5.35639338e-02f, -3.50780450e-02f, 5.85961081e-02f,
  -2.72536632e-02f, 1.10408794e-02f, 4.42336984e-02f, 5.75619899e-02f, 3.34624536e-02f, 9.82385352e-02f, 5.07003441e-02f, -1.54422233e-02f, -3.66784148e-02f, -2.72299722e-02f,
  -2.36764811e-02f, -4.44562472e-02f, 9.23552662e-02f, -6.68785870e-02f, 4.57768664e-02f, 1.68726388e-02f, 8.27560946e-02f, 7.75445253e-02f, -1.48583455e-02f, 1.16093539e-01f,
  9.63009149e-02f, 4.76569146e-01f, 3.16464484e-01f, 1.88568607e-01f, 7.92798959e-03f, 3.05584278e-02f, 4.67385650e-01f, 2.07395494e-01f, -7.38130212e-02f, 1.75916910e-01f,
  5.64615540e-02f, -1.90699384e-01f, -6.54024407e-02f, -7.36888796e-02f, 1.86655015e-01f, 1.46088421e-01f, 1.54568642e-01f, 3.19776721e-02f, -1.19463295e-01f, 2.35933068e-04f,
  -1.10813417e-01f, 3.39251794e-02f, -3.00040524e-02f, 5.19954935e-02f, 1.57077089e-01f, -1.40688151e-01f, 1.69089630e-01f, 1.30768031e-01f, -2.96669733e-02f, 1.54750288e-01f,
  6.22496121e-02f, 4.50687885e-01f, -2.41414517e-01f, -3.51157365e-03f, -3.00194845e-02f, 2.48437542e-02f, -5.25323935e-02f, 4.99528274e-02f, -1.04128271e-01f, -1.55682229e-02f,
  9.57703870e-03f, -6.03261441e-02f, 1.07160501e-01f, -1.95828360e-02f, 2.43058689e-02f, -1.95344095e-03f, 8.34150836e-02f, 1.53600588e-01f, 2.73555778e-02f, -2.32074857e-02f,
  9.91518050e-02f, 3.75818200e-02f, 6.49712980e-02f, 6.98378980e-02f, 1.62913084e-01f, -8.46205056e-02f, 1.02788366e-01f, 7.39266425e-02f, 7.36134052e-02f, -7.13063590e-03f,
  -5.28213903e-02f, -6.65673800e-03f, -5.04241809e-02f, 3.51576768e-02f, -3.16822790e-02f, -4.46303822e-02f, 2.01515504e-03f, -1.69235806e-03f, -2.82510240e-02f, 2.31768265e-02f,
  -9.92816221e-03f, 3.13515663e-02f, -9.98856407e-03f, 5.80802895e-02f, 3.69991525e-03f, 2.01480445e-02f, -1.85003765e-02f, 8.21883827e-02f, 5.41485380e-03f, 9.36665852e-03f,
  -8.03626031e-02f, -2.49716565e-02f, -1.10071327e-03f, 3.85347791e-02f, -1.02539808e-02f, 8.05084407e-03f, 1.72496233e-02f, 2.03086678e-02f, 3.66572887e-02f, -8.41011554e-02f,
  -1.73019081e-01f, -9.07668471e-02f, -1.94351189e-02f, -4.22975346e-02f, 6.73226416e-02f, -6.20880984e-02f, -3.75727341e-02f, 4.04470833e-03f, -3.34831141e-02f, -2.32992247e-02f,
  4.88453284e-02f, -6.76134089e-03f, 6.55315444e-02f, 1.45956846e-02f, -3.76393870e-02f, -9.66498777e-02f, 1.98181812e-03f, 5.58463857e-02f, -9.24553350e-03f, 5.03759552e-03f,
  1.49573004e-02f, -1.11294858e-01f, -1.32353365e-01f, -5.88415097e-03f, -3.83534804e-02f, -1.26886308e-01f, -1.58721894e-01f, -7.47704655e-02f, -9.85658765e-02f, -1.86034977e-01f,
  3.63504626e-02f, -8.95050727e-03f, 1.85335297e-02f, 2.87993904e-02f, 7.08632842e-02f, -3.91847901e-02f, -4.47048545e-02f, -2.98130792e-02f, -3.49777490e-02f, -8.37172046e-02f,
  9.73161403e-03f, -1.24035232e-01f, 2.46192882e-04f, -8.93922821e-02f, -7.72077218e-02f, -9.14114490e-02f, -2.08575539e-02f, -1.48612887e-01f, 4.26866561e-02f, -2.81463657e-03f,
  -2.72568297e-02f, -1.41866850e-02f, 3.09896357e-02f, -2.64149290e-02f, -6.21358454e-02f, -9.51565877e-02f, -1.43893123e-01f, 2.50022057e-02f, -5.67992367e-02f, -1.12579159e-01f,
  -2.69258991e-02f, 1.18899345e-01f, 3.43786925e-02f, -8.95760730e-02f, 6.98131025e-02f, -2.94719655e-02f, -5.80660999e-02f, 1.69903580e-02f, 3.35950665e-02f, -7.28624687e-02f,
  -8.13136324e-02f, -4.06169370e-02f, -6.40141666e-02f, -1.32764811e-02f, 6.54780567e-02f, 4.57901433e-02f, -3.96274813e-02f, 8.17652866e-02f, -6.95579648e-02f, -2.82591991e-02f,
  -4.64109294e-02f, -5.20953648e-02f, -1.02594733e-01f, -3.06353662e-02f, 8.08097646e-02f, -2.07496732e-02f, 1.70769729e-02f, 3.50431465e-02f, -7.63173103e-02f, -8.37562606e-02f,
  -6.83510154e-02f, -2.88279317e-02f, 9.07605141e-02f, 1.52818142e-02f, 4.87252958e-02f, -1.09856697e-02f, -6.28197789e-02f, -3.29290926e-02f, 4.37759236e-02f, 4.37263809e-02f,
  -1.08149769e-02f, 4.24381234e-02f, -3.79910618e-02f, -1.57419313e-02f, 5.62276170e-02f, -1.04432777e-01f, 5.18156700e-02f, -3.51393819e-02f, -3.21429819e-02f, 2.79755499e-02f,
  -9.48175266e-02f, -2.73285285e-02f, -1.61579028e-02f, 4.92667146e-02f, 8.00567120e-02f, -2.99351104e-02f, -3.76825370e-02f, 1.49445292e-02f, 8.39423239e-02f, 4.79563028e-02f,
  -1.55198842e-01f, 1.36295468e-01f, 1.51474364e-02f, 2.65263785e-02f, 3.75056360e-03f, -8.30519050e-02f, 6.81609139e-02f, 1.66491531e-02f, -1.35781681e-02f, 3.00392397e-02f,
  7.33469576e-02f, 3.83000933e-02f, -7.24053243e-03f, -5.35703301e-02f, -6.14007264e-02f, -4.73774895e-02f, -2.92198043e-02f, -8.42289552e-02f, -4.79681566e-02f, 6.48027211e-02f,
  -8.24183673e-02f, -1.53424099e-01f, -1.23025373e-01f, -7.68564194e-02f, -8.01565275e-02f, -9.93238389e-02f, -8.26262031e-03f, -1.02766179e-01f, -4.44476083e-02f, -2.05014691e-01f,
  8.57575461e-02f, -7.62224719e-02f, -2.92027066e-03f, -2.73552164e-02f, -2.31116246e-02f, -1.72183290e-02f, 8.12721327e-02f, -3.37778181e-02f, 9.55569446e-02f, 1.94059517e-02f,
  -5.52927665e-02f, 3.21705407e-03f, 1.79893561e-02f, -4.72720414e-02f, 8.41266140e-02f, 4.05415818e-02f, 5.38202561e-02f, -8.87178481e-02f, 2.62510777e-02f, -4.55277301e-02f,
  3.20541449e-02f, -5.64606041e-02f, -4.64431616e-03f, 7.56188184e-02f, 2.69647501e-02f, -4.67182063e-02f, 8.09767656e-03f, -9.40702558e-02f, 5.52792512e-02f, -3.96406911e-02f,
  -1.27086267e-01f, -1.58531219e-02f, 7.80874640e-02f, 5.12361601e-02f, -3.13752815e-02f, -5.08480556e-02f, 6.07853644e-02f, 6.49000332e-02f, 4.23218273e-02f, 1.08189948e-01f,
  -5.17714061e-02f, 4.20760661e-02f, 6.94251582e-02f, 7.69448746e-03f, -2.15509105e-02f, 5.48306778e-02f, 5.65122701e-02f, -2.89874207e-02f, 3.08427028e-02f, -9.03979223e-03f,
  6.49559423e-02f, 7.80202216e-04f, -7.10171610e-02f, -5.38057759e-02f, 3.52626033e-02f, -2.16243211e-02f, 7.97882602e-02f, 8.28648210e-02f, -2.66317315e-02f, -9.18931589e-02f,
  6.95148902e-03f, -8.69028568e-02f, -4.47532907e-02f, 7.69095421e-02f, 5.58929332e-02f, -2.51697712e-02f, -3.27566192e-02f, 1.25651108e-02f, 3.32362577e-03f, 9.10466351e-03f,
  2.26441883e-02f, 2.30039340e-02f, 7.66224563e-02f, -4.63993140e-02f, -3.70692760e-02f, -5.17931208e-02f, -9.69009027e-02f, -1.08886480e-01f, -4.92313802e-02f, 6.37144223e-02f,
  -5.98391816e-02f, 4.78911959e-03f, -2.29094848e-02f, -9.84554887e-02f, -1.10467151e-01f, -6.88237920e-02f, -2.10295543e-02f, -1.67375300e-02f, 2.63441429e-02f, -3.66643444e-02f,
  2.52033956e-02f, 7.28510767e-02f, 4.16470580e-02f, 9.45303440e-02f, -8.24210867e-02f, -5.28654158e-02f, 6.01868443e-02f, 6.93103746e-02f, -8.83126538e-03f, -7.14015495e-03f,
  -4.46854718e-03f, -2.38557160e-02f, -3.93093154e-02f, -8.86889771e-02f, -1.19351581e-01f, -1.13210686e-01f, -2.49670297e-02f, 4.79531027e-02f, -6.85440823e-02f, -7.02702999e-02f,
  -7.47395903e-02f, 3.00145186e-02f, -7.93597102e-02f, -6.19622841e-02f, 3.79021689e-02f, -1.78540535e-02f, 4.44475263e-02f, -6.62105531e-02f, -1.23617105e-01f, -8.23124424e-02f,
  -5.84901869e-03f, -1.60041898e-01f, 1.57691270e-01f, 4.00458723e-02f, 6.34052306e-02f, 1.48328915e-01f, 7.48943910e-02f, 3.78166810e-02f, -2.74030417e-02f, -9.75406840e-02f,
  -7.26581272e-03f, -1.12239189e-01f, -1.12548508e-01f, -1.11063294e-01f, 6.77827224e-02f, 6.96477145e-02f, 6.44397959e-02f, 1.24723591e-01f, 2.09571764e-01f, 1.79854840e-01f,
  9.34166238e-02f, 7.32320324e-02f, -2.12915465e-02f, 6.59221038e-02f, 3.18021402e-02f, 9.19541344e-02f, 3.22980434e-03f, -3.71570736e-02f, -2.24519279e-02f, 9.86194313e-02f,
  1.81278393e-01f, -6.08011000e-02f, 8.72434527e-02f, -2.20543500e-02f, -2.14672443e-02f, -2.34854855e-02f, 3.58567294e-03f, 6.07179292e-02f, -9.40016136e-02f, 4.49206643e-02f,
  2.91383415e-02f, -4.80782166e-02f, -1.15650602e-01f, 3.95292602e-02f, 3.75975594e-02f, 3.79851018e-03f, -1.37721628e-01f, -1.26158684e-01f, -2.35406011e-02f, -8.47869217e-02f,
  -5.75285889e-02f, 1.64702367e-02f, -3.90426554e-02f, -7.73987547e-02f, -4.04858366e-02f, -7.12561831e-02f, 6.26983866e-02f, -3.21600214e-02f, -5.66600971e-02f, -1.02417834e-01f,
  6.57599121e-02f, -1.32667953e-02f, 4.74247150e-02f, 2.67132632e-02f, -3.72358561e-02f, 5.84668331e-02f, -1.85923465e-02f, 5.63097447e-02f, -4.82632369e-02f, 1.65002812e-02f,
  -4.94311526e-02f, 6.12678099e-03f, -8.09287578e-02f, 1.10332467e-01f, -1.01096712e-01f, -7.97118694e-02f, -7.07565099e-02f, -5.00271730e-02f, 2.55890638e-02f, 2.61570304e-03f,
  -1.93631146e-02f, 7.13403523e-02f, 4.67345454e-02f, 3.69540462e-03f, -5.40462323e-02f, -6.31412193e-02f, 1.36914924e-02f, -1.28624337e-02f, -5.15211932e-02f, 4.08655889e-02f,
  7.41878748e-02f, -1.56250104e-01f, 1.28868341e-01f, -5.45476889e-03f, -9.26346108e-02f, -2.65564700e-03f, 7.35286325e-02f, 1.96137503e-02f, -1.73442699e-02f, 5.12635000e-02f,
  8.58581737e-02f, -2.45889965e-02f, 7.65177533e-02f, -4.70606945e-02f, 1.30196422e-01f, 3.26826647e-02f, -8.78727213e-02f, 3.77866551e-02f, 4.97389212e-02f, 6.25324622e-02f,
  3.12588401e-02f, 1.23562485e-01f, 1.14081549e-02f, -1.28172534e-02f, 5.23904301e-02f, 1.31735131e-01f, 1.27842844e-01f, 7.22295195e-02f, 8.04850683e-02f, 1.31836742e-01f,
  -7.82746002e-02f, 9.25021097e-02f, -4.65278290e-02f, -2.19599158e-02f, -6.01588003e-02f, 6.40689954e-02f, 2.69598458e-02f, -7.90852308e-02f, -8.50429460e-02f, -6.15784787e-02f,
  -7.82016441e-02f, -3.27176563e-02f, 2.99313180e-02f, -4.76939119e-02f, 2.24777013e-02f, 8.42659622e-02f, -9.54015460e-03f, -5.21118753e-02f, -4.84986156e-02f, -5.80319129e-02f,
  -4.85071763e-02f, 4.33909073e-02f, -2.71534510e-02f, 2.19759252e-02f, 7.18272552e-02f, -7.75897205e-02f, 6.97057620e-02f, 4.01540585e-02f, -7.08280280e-02f, -3.05288807e-02f,
  9.60445404e-02f, -4.34516184e-02f, -2.84546800e-02f, -6.85061738e-02f, 2.71907784e-02f, 9.11026914e-03f, -5.58831878e-02f, -1.46595864e-02f, -8.17429274e-02f, -7.58666545e-02f,
  3.42123047e-03f, -9.62344632e-02f, -5.43403700e-02f, -4.96956706e-02f, -5.17493533e-03f, 1.37204556e-02f, -2.61510648e-02f, 3.50363851e-02f, -6.40019551e-02f, -7.80185536e-02f,
  -1.99050624e-02f, 8.22847188e-02f, -7.16336146e-02f, 5.25116827e-03f, -2.58578062e-02f, -6.24945275e-02f, 1.41267180e-02f, 7.16127977e-02f, -7.72652254e-02f, -7.23533705e-02f,
  -3.35825942e-02f, 8.64194110e-02f, 5.39523549e-03f, 3.57105173e-02f, 6.66859820e-02f, -2.89180595e-02f, -5.26158027e-02f, 2.72376295e-02f, 8.24062377e-02f, 5.54139055e-02f,
  -9.85403508e-02f, 3.49922404e-02f, -9.15808901e-02f, -4.53473553e-02f, 1.14218909e-02f, -6.11925777e-03f, -4.06076498e-02f, 8.16959813e-02f, 3.26288864e-02f, 6.92229941e-02f,
  3.43454257e-02f, 3.84317897e-02f, -1.50316395e-02f, -5.51980622e-02f, -4.92852926e-02f, -9.40057933e-02f, -1.71286818e-02f, -8.81784335e-02f, -1.00203171e-01f, 3.60056907e-02f,
  -1.86249744e-02f, -9.07184333e-02f, -4.46744338e-02f, 9.14308578e-02f, -6.37958199e-02f, 1.44818390e-04f, -6.04950264e-02f, -2.41127256e-02f, -4.05015945e-02f, 6.75842911e-02f,
  -1.24692395e-02f, -3.75574082e-02f, 3.71981524e-02f, 8.07356611e-02f, -7.00850447e-04f, -1.78825967e-02f, 7.54870335e-03f, -1.36718936e-02f, -7.05566350e-03f, -5.66714583e-03f,
  7.98798203e-02f, 9.18225646e-02f, 9.10021588e-02f, 1.01634502e-01f, 1.36583904e-03f, -4.21928726e-02f, 5.06529026e-02f, -1.12354674e-03f, 5.87231144e-02f, 1.36166289e-01f,
  1.81747705e-01f, -4.07785326e-02f, -6.38442487e-02f, 7.94185102e-02f, 8.64592344e-02f, -2.15534374e-01f, -3.02527934e-01f, -2.21382156e-01f, 3.39347892e-03f, -1.49079353e-01f,
  -1.12404987e-01f, 1.00056283e-01f, -2.87858564e-02f, -2.53161564e-02f, -1.34367362e-01f, -7.36149102e-02f, 1.31329224e-01f, 2.36100927e-01f, 1.20269567e-01f, -4.39782888e-02f,
  1.37854487e-01f, 1.96620703e-01f, 1.39523163e-01f, 6.68969378e-02f, 1.00838661e-01f, 9.49018300e-02f, -3.13403271e-02f, 1.10838600e-01f, 8.59622508e-02f, 2.43177459e-01f,
  1.14825420e-01f, 1.63717046e-02f, -5.83160594e-02f, -1.02366684e-02f, 7.74204582e-02f, 1.23891523e-02f, -1.83271933e-02f, -5.35772704e-02f, -3.88253704e-02f, -1.99776422e-02f,
  -4.73028049e-03f, -4.40867268e-04f, -6.78700879e-02f, 2.57079508e-02f, 2.95934007e-02f, -1.69084594e-02f, 3.06578446e-02f, 2.26588454e-03f, -6.11114390e-02f, -5.35863973e-02f,
  -5.29302694e-02f, 1.56704649e-01f, 5.39579280e-02f, -1.15986980e-01f, -1.70089513e-01f, 4.00945134e-02f, -4.14091982e-02f, -4.63016517e-02f, -3.89169455e-02f, 5.37317470e-02f,
  -3.81817762e-03f, -7.35468580e-04f, -4.25379239e-02f, 2.84569338e-02f, 6.85323635e-03f, 8.74545649e-02f, 1.67198349e-02f, -1.49911446e-02f, 5.23237027e-02f, -3.43895629e-02f,
  -2.49840003e-02f, -3.21488604e-02f, -3.13917338e-03f, -3.28527056e-02f, 6.03717789e-02f, 1.61397830e-02f, -3.55037637e-02f, 1.67312231e-02f, -3.48080061e-02f, 3.91921774e-02f,
  2.45962702e-02f, -1.91324092e-02f, 4.61448990e-02f, -1.22551903e-01f, -9.87457484e-03f, 3.43400030e-03f, 1.23238256e-02f, -6.41754419e-02f, -3.58738080e-02f, 5.45397587e-02f,
  7.42398761e-03f, -3.96740530e-03f, 9.57506448e-02f, 2.92275604e-02f, 3.51810642e-02f, -5.91467805e-02f, -3.20861228e-02f, -8.89057219e-02f, 9.17303283e-03f, -1.32492427e-02f,
  -8.18168074e-02f, 4.82572503e-02f, 3.39868246e-03f, -3.78942974e-02f, -1.11019090e-01f, 2.22674124e-02f, -7.33780190e-02f, 6.48643961e-03f, 1.67021286e-02f, -9.36938375e-02f,
  -4.09111157e-02f, -4.36558016e-02f, -9.34953988e-02f, -1.25870541e-01f, -6.54061735e-02f, -6.20476529e-02f, -1.24347284e-01f, -7.18538612e-02f, -1.42939299e-01f, -1.03109658e-01f,
  -2.75307477e-01f, 1.09246351e-01f, -2.47695625e-01f, -1.30828291e-01f, -2.95646358e-02f, 6.01632185e-02f, -5.63856540e-03f, 2.18254834e-01f, 5.79819158e-02f, 5.62505238e-02f,
  -6.62689134e-02f, -1.81939438e-01f, -1.61547959e-01f, -1.15370616e-01f, -4.53203619e-02f, -1.20972037e-01f, -1.94689751e-01f, -2.70205557e-01f, -2.08217368e-01f, 5.57213649e-03f,
  -1.03847094e-01f, -1.61462426e-01f, -1.89980254e-01f, 1.14477903e-03f, 5.97853102e-02f, -1.09912418e-02f, -9.47564021e-02f, 1.91307161e-02f, 1.52462423e-01f, -8.56631547e-02f,
  -1.74151719e-01f, 6.36833385e-02f, 8.99855494e-02f, -3.32573429e-03f, -6.29440472e-02f, -1.27097606e-04f, -4.43118736e-02f, -1.68108679e-02f, -4.41641212e-02f, -5.24096098e-03f,
  -8.10842663e-02f, 2.88444906e-02f, -1.18459024e-01f, -8.28629732e-02f, 1.45701692e-02f, 5.60927438e-03f, 6.52613416e-02f, -8.13406408e-02f, 1.04243077e-01f, 6.00031652e-02f,
  4.55446057e-02f, 2.68287752e-02f, -2.15179455e-02f, 6.58237338e-02f, 1.39991537e-01f, -5.33250608e-02f, 1.12459920e-01f, 2.28119969e-01f, 1.39185995e-01f, 1.13651678e-01f,
  6.44206554e-02f, 2.70376913e-03f, -2.91677658e-02f, 3.07357367e-02f, 1.89274456e-02f, 3.58702205e-02f, -1.90129988e-02f, 1.76945291e-02f, -3.98541503e-02f, 3.10264789e-02f,
  4.48187813e-02f, -7.35137612e-02f, -6.91849291e-02f, -3.40916496e-03f, -8.01149979e-02f, 8.00357088e-02f, -9.31553096e-02f, 5.67777921e-03f, 2.74769329e-02f, -1.02166990e-02f,
  9.88002568e-02f, 5.75981755e-03f, 2.23286226e-02f, -2.01925468e-02f, 9.81357768e-02f, -1.67226288e-02f, -4.84415106e-02f, 3.30394320e-03f, -3.04635018e-02f, -6.89481348e-02f,
  -4.80659865e-02f, -9.52254981e-02f, -4.25163135e-02f, 8.13089460e-02f, 1.65165011e-02f, 8.74200277e-03f, -5.45406714e-03f, -4.93621081e-02f, -1.60179734e-02f, 5.58082685e-02f,
  8.56223553e-02f, 4.53695841e-03f, -1.02360964e-01f, 2.39365287e-02f, -4.19792952e-03f, 1.19141743e-01f, -9.51305404e-03f, -8.71305168e-02f, 1.03474639e-01f, 1.92824826e-02f,
  3.87426130e-02f, 1.22626722e-01f, 7.69074708e-02f, 4.26120833e-02f, 9.71199051e-02f, -1.15326203e-01f, -7.74750113e-02f, -3.42045613e-02f, -9.62699503e-02f, 6.21158667e-02f,
  -1.60489336e-01f, -1.63150534e-01f, -1.60244182e-01f, -3.06521058e-02f, -5.94308553e-03f, -1.32744476e-01f, -6.89872727e-02f, 2.76321056e-03f, -2.97942497e-02f, -1.92177057e-01f,
  -5.96752800e-02f, -3.64565998e-02f, -6.80297315e-02f, -4.85868528e-02f, -4.43824008e-02f, -1.72944382e-01f, -1.82961270e-01f, -1.39725115e-03f, 1.88585341e-01f, 1.76805511e-01f,
  -1.31574767e-02f, 9.01916847e-02f, 1.15430817e-01f, 1.40991375e-01f, -1.28567129e-01f, -5.84595501e-02f, -1.17883332e-01f, -8.21304768e-02f, -9.99412984e-02f, -2.30993301e-01f,
  -2.60858446e-01f, 4.08415589e-03f, 3.84593755e-02f, -4.86237220e-02f, -2.59584561e-02f, -4.23349813e-02f, 4.46166247e-02f, -6.21826649e-02f, 9.77743790e-02f, -3.76544967e-02f,
  -3.71847674e-02f, 7.68555179e-02f, 2.69740354e-02f, 4.06750478e-02f, 3.07275238e-03f, 8.73484686e-02f, 8.95517394e-02f, -6.03685826e-02f, 3.79409306e-02f, 3.19703482e-02f,
  4.93831176e-04f, -6.85919076e-03f, -9.41148698e-02f, 2.61890106e-02f, 7.92559311e-02f, -2.88683958e-02f, 1.12538207e-02f, 2.71346290e-02f, 6.29461482e-02f, -2.14717731e-01f,
  -7.25845248e-03f, -4.95703109e-02f, -8.10864717e-02f, -1.63449650e-03f, -3.83446887e-02f, -1.90992113e-02f, -5.79029135e-02f, 7.76499659e-02f, -6.18689060e-02f, 5.21047600e-03f,
  -4.84212674e-02f, -4.10051458e-02f, -1.54778380e-02f, -1.16441231e-02f, 9.90885049e-02f, -1.65510420e-02f, 1.39251305e-03f, 2.57690344e-03f, 1.28233731e-01f, -9.60490201e-04f,
  -4.86228727e-02f, 5.44996466e-03f, -6.69987872e-04f, -6.86909929e-02f, -8.15107971e-02f, -6.06150813e-02f, 1.16541574e-04f, -1.74542088e-02f, 4.55617309e-02f, 2.36082599e-02f,
  1.23118041e-02f, -1.44590428e-02f, -4.92880568e-02f, 1.14548184e-01f, -7.86017552e-02f, 1.52972611e-02f, -1.01492561e-01f, 1.40706599e-02f, -2.52595805e-02f, 7.85030704e-03f,
  3.83630618e-02f, 4.84291427e-02f, -8.65053479e-03f, 2.56532133e-02f, -7.26579316e-03f, -3.76665890e-02f, 7.57116750e-02f, 1.60103291e-02f, -1.33170225e-02f, 6.40751645e-02f,
  5.40490299e-02f, -2.22253762e-02f, -5.76937683e-02f, -1.32065728e-01f, -2.31333077e-02f, 2.41088521e-04f, -8.21265876e-02f, -5.63057624e-02f, -4.45473045e-02f, -2.24072784e-01f,
  8.22876096e-02f, -3.12027514e-01f, 2.87095517e-01f, 2.76973099e-01f, 3.91428083e-01f, 5.12713432e-01f, 4.58422810e-01f, 2.47749522e-01f, 1.18500777e-02f, 3.31443809e-02f,
  -2.22016010e-03f, -1.73850417e-01f, -7.14139715e-02f, -1.25092417e-01f, -9.75496694e-02f, 1.77706510e-01f, 1.07252643e-01f, 1.82834342e-02f, 1.44999921e-01f, 1.34885803e-01f,
  1.43360335e-03f, 2.36137267e-02f, -1.86395496e-01f, -4.61619943e-02f, -2.41549108e-02f, 4.91804294e-02f, 1.09780066e-01f, 1.08719140e-01f, -1.10724457e-01f, -1.74530715e-01f,
  -1.59929886e-01f, -3.94554585e-02f, 1.73523873e-01f, -1.24322265e-01f, 7.45947734e-02f, -1.15580276e-01f, -5.43280505e-02f, -9.93947387e-02f, -3.85952578e-03f, -5.63287660e-02f,
  -2.40960922e-02f, -4.16680351e-02f, -9.29939933e-03f, -4.67964821e-03f, -3.65897128e-03f, -7.73663586e-03f, -1.16546839e-01f, -2.63965130e-02f, 7.34525826e-03f, -1.79504380e-01f,
  -3.14323902e-02f, 2.51115784e-02f, 8.78296047e-02f, 1.29916549e-01f, -2.46863030e-02f, -5.62061667e-02f, -9.29569304e-02f, -5.50823100e-02f, 3.59709933e-02f, -1.91850945e-01f,
  8.16943124e-02f, 3.69158611e-02f, 7.64505565e-02f, -3.63470651e-02f, -2.19224896e-02f, 2.48738006e-02f, 7.65740778e-03f, -2.16647275e-02f, 5.73505508e-03f, 5.14765875e-03f,
  -9.71645699e-04f, -7.15763271e-02f, -3.07543259e-02f, 7.27495030e-02f, -8.66863430e-02f, -2.35634018e-02f, -3.43598947e-02f, 8.83011706e-03f, -2.68006995e-02f, 1.92522835e-02f,
  -1.62049774e-02f, 2.14486406e-03f, -4.94145975e-03f, -1.13799259e-01f, 4.56016846e-02f, 3.40843317e-03f, -2.82490402e-02f, 3.67987528e-03f, 5.36631569e-02f, -3.31470743e-02f,
  -1.77734405e-01f, 9.69440341e-02f, -7.59987906e-02f, -9.20858458e-02f, 4.33710462e-04f, -2.42793057e-02f, 1.30185494e-02f, -5.41885719e-02f, -5.74981719e-02f, -3.77484635e-02f,
  -4.00732830e-02f, -2.26325765e-02f, 1.49156330e-02f, 2.61940882e-02f, 4.01389785e-02f, 1.26609743e-01f, -4.56975214e-02f, 6.48833662e-02f, 3.72903422e-02f, 2.87438906e-03f,
  -1.88894328e-02f, 3.03163677e-02f, 3.71321887e-02f, -7.41484296e-03f, 1.93524417e-02f, 8.89769197e-02f, -1.14776818e-02f, 1.39642701e-01f, 2.09720135e-01f, 1.03079244e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  -4.86640781e-02f, -2.63445266e-02f, 8.53177682e-02f, 2.80807056e-02f, -2.56171264e-02f, 1.56759381e-01f, 1.22156247e-01f, 2.28839740e-02f, 8.95292684e-03f, 5.50016016e-02f,
  2.16436666e-03f, 1.26974076e-01f, 4.29267026e-02f, 1.33761503e-02f, 5.88606149e-02f, -8.02738219e-02f, -8.02714452e-02f, 8.44814032e-02f, 5.62246777e-02f, -1.33700490e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -5.87611049e-02f, -1.00033551e-01f, 2.41194107e-03f, -2.41885278e-02f, 1.32854760e-01f, 7.43165538e-02f, -2.16689184e-01f, 2.61456966e-01f, 2.01875135e-01f, -9.17319804e-02f,
  2.24036396e-01f, -1.05763115e-01f, -1.36898667e-01f, -4.74035814e-02f, 6.49008006e-02f, 2.15796575e-01f, -5.43580428e-02f, -2.00638294e-01f, 9.16723013e-02f, 8.73011798e-02f,
  1.20406635e-01f, 2.35692099e-01f, 2.52399687e-02f, 7.57434964e-02f, -6.17026426e-02f, -1.10459495e-02f, 1.54547542e-01f, 3.69166695e-02f, 2.31422067e-01f, -3.52096856e-01f,
  -3.79460454e-02f, 2.50783801e-01f, -2.05649927e-01f, 1.38232306e-01f, 9.39144567e-03f, -1.91377904e-02f, -1.68876886e-01f, -1.36918664e-01f, -1.18370041e-01f, -2.36066535e-01f,
  -1.18702032e-01f, 9.35079623e-03f, 2.64422745e-01f, -1.03175007e-01f, -1.98565975e-01f, 1.34148315e-01f, 7.53164589e-02f, -2.69525021e-01f, 8.44698995e-02f, -1.53667659e-01f,
  -1.13148186e-02f, -1.51572213e-01f, 4.13095355e-02f, 2.02453345e-01f, -1.31878018e-01f, 1.00666098e-01f, 1.89621206e-02f, 5.84436534e-03f, 3.18244472e-02f, -7.29968399e-02f,
  -4.09541093e-02f, -2.22632233e-02f, 1.75086245e-01f, -5.24684079e-02f, -2.50429153e-01f, -2.22321618e-02f, -1.47726923e-01f, 2.72523880e-01f, 7.96846449e-02f, 1.01727873e-01f,
  -3.11402291e-01f, 3.67142111e-01f, 2.36875311e-01f, -3.06256413e-01f, 2.57175602e-02f, -4.23072763e-02f, -1.68434262e-01f, -3.72688442e-01f, 2.71404654e-01f, 2.35036179e-01f,
  -6.73640845e-03f, -1.60079986e-01f, 3.03661060e-02f, -1.43280691e-02f, 3.14186245e-01f, 1.09210886e-01f, -1.65743470e-01f, 2.98354208e-01f, -1.17079087e-01f, -3.48644294e-02f,
  -2.06226632e-01f, -1.06159776e-01f, 1.57085598e-01f, -3.44834328e-01f, 3.09658125e-02f, -2.35199183e-01f, 8.37048814e-02f, -6.70282170e-02f, -3.63769978e-02f, 1.83848161e-02f,
  -1.26540750e-01f, -1.06568351e-01f, 1.83938760e-02f, 1.13425218e-01f, 7.46395513e-02f, 1.49760380e-01f, 1.61114141e-01f, -4.77900058e-02f, -1.41293779e-01f, -1.21661305e-01f,
  1.28769800e-01f, 4.62017842e-02f, 1.28920689e-01f, 6.24608854e-03f, -1.41984314e-01f, -1.20561831e-01f, 7.33624771e-02f, -5.42370752e-02f, -1.27327114e-01f, -4.17986745e-03f,
  7.59387538e-02f, -1.60764992e-01f, 2.09370896e-01f, -1.44965231e-01f, -1.84009552e-01f, -2.16294169e-01f, 5.05238678e-03f, 3.05026263e-01f, -3.98200415e-02f, -2.18563870e-01f,
  -1.26793742e-01f, 7.83527549e-03f, 1.12558655e-01f, 1.07020140e-01f, 2.77631283e-02f, 1.07602321e-01f, 1.81166962e-01f, 1.56835735e-01f, 2.20164627e-01f, 1.00189999e-01f,
  -6.74183369e-02f, -1.32787839e-01f, -8.01391155e-03f, 2.70657063e-01f, -1.22281194e-01f, -2.84691472e-02f, 1.53336078e-01f, -1.94837093e-01f, 6.95718005e-02f, -7.13243708e-02f,
  -6.37969747e-02f, 4.75329608e-02f, -5.98885342e-02f, -6.74634501e-02f, 2.73009002e-01f, 4.53218259e-02f, -3.61738056e-02f, -2.40739599e-01f, -6.13740310e-02f, -4.29375172e-02f,
  -4.86717224e-02f, 1.48264751e-01f, 1.89844623e-01f, -1.68327600e-01f, -1.29418492e-01f, 7.23148212e-02f, -1.14712380e-02f, -1.89876214e-01f, -3.01770754e-02f, 4.41279709e-01f,
  4.24323864e-02f, -2.79249042e-01f, -1.50194168e-01f, 1.90250978e-01f, -1.70983858e-02f, -1.19118161e-01f, -3.41138169e-02f, -1.37190819e-02f, 1.45440549e-01f, -1.14367329e-01f,
  1.37977824e-01f, 6.88835606e-02f, -1.28147617e-01f, -5.23280278e-02f, -6.01861775e-02f, -1.95660919e-01f, 2.94072270e-01f, 6.29379302e-02f, -6.70284182e-02f, 1.59126535e-01f,
  1.43970639e-01f, 1.46722332e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.79618770e-01f, 5.66932321e-01f, 1.99298188e-01f, 3.24808881e-02f, 7.77338073e-02f, 1.46615118e-01f, 1.68535024e-01f, -7.55143464e-02f, 2.76114017e-01f, -1.16734184e-01f,
  -5.07110097e-02f, -3.02543826e-02f, 1.17440045e-01f, 7.55270347e-02f, 7.40040720e-01f, 9.93763655e-02f, -1.70863435e-01f, 3.20590973e-01f, 1.99153721e-01f, 2.20597178e-01f,
  1.85670098e-03f, 4.26056504e-01f, -7.35216588e-02f, 4.27562632e-02f, 2.22553328e-01f, 1.55872330e-01f, -2.62180299e-01f, -1.61560811e-02f, -1.85293779e-01f, 4.22695816e-01f,
  4.96316284e-01f, -2.59838820e-01f, 2.29316846e-01f, -6.41937777e-02f, 1.62773713e-01f, 2.62700915e-01f, 1.40149951e-01f, 1.36374310e-01f, 1.84276830e-02f, 1.31851614e-01f,
  -2.15032906e-03f, -1.01809636e-01f, -2.89255351e-01f, 2.81820893e-01f, 1.36255085e-01f, -3.29425111e-02f, -4.02483009e-02f, 3.06386292e-01f, 8.88634175e-02f, -2.15435233e-02f,
  3.05051878e-02f, 1.35836437e-01f, -7.96630681e-02f, -2.41652846e-01f, -9.52814594e-02f, 2.89021060e-02f, 1.70121685e-01f, 2.05403343e-01f, -8.74492005e-02f, -3.76967825e-02f,
  2.28880286e-01f, 2.35004704e-02f, 2.61425190e-02f, 1.27263695e-01f, 9.82270017e-02f, -1.34291323e-02f, 4.63950559e-02f, 1.14924178e-01f, 2.28520036e-01f, -1.78580284e-02f,
  -2.68654395e-02f, -1.10384244e-02f, 1.61530554e-01f, -1.61871865e-01f, 2.31537148e-02f, 2.01799855e-01f, -5.15566729e-02f, -2.02339679e-01f, 5.89719415e-02f, 2.27679357e-01f,
  1.66640997e-01f, -1.09931722e-01f, -1.73350453e-01f, 1.46527424e-01f, 1.90437168e-01f, 1.94280326e-01f, 3.01100630e-02f, -2.15034354e-02f, -5.19848727e-02f, -1.01779521e-01f,
  -1.04268603e-01f, -1.25696376e-01f, -1.28166527e-01f, -1.27914444e-01f, -9.37015563e-02f, 2.06542406e-02f, 8.61771703e-02f, 3.66216809e-01f, 1.37225375e-01f, 1.78228572e-01f,
  3.01017109e-02f, -1.76747199e-02f, -8.94179419e-02f, -9.45669264e-02f, 2.27802545e-01f, 5.17060347e-02f, -1.54263869e-01f, -2.15866432e-01f, -5.42583987e-02f, 1.81289595e-02f,
  3.97597283e-01f, 1.61505327e-01f, -1.81743190e-01f, 1.42936587e-01f, 1.77807257e-01f, 5.35419025e-02f, 2.25958541e-01f, 2.94807136e-01f, 7.92991817e-02f, 8.08115974e-02f,
  1.16934881e-01f, 4.74577919e-02f, -3.35350819e-02f, 1.11248352e-01f, -1.83654130e-01f, -1.28126174e-01f, -1.57850198e-02f, 3.06125075e-01f, 1.01166651e-01f, -5.81566803e-03f,
  -1.90469891e-01f, -9.96352956e-02f, -9.54245999e-02f, -2.87420005e-02f, 1.35690913e-01f, -1.35324791e-01f, 1.29657969e-01f, -6.92114606e-02f, 6.74230456e-02f, 1.84996463e-02f,
  2.90491074e-01f, 1.78055838e-01f, 9.86157805e-02f, 5.32867201e-02f, 1.46032587e-01f, 2.15580255e-01f, -3.32692564e-02f, 1.46881849e-01f, 1.12691499e-01f, 2.73247838e-01f,
  4.43142243e-02f, 1.34689599e-01f, 1.24780536e-01f, -1.87030062e-01f, 1.71787068e-01f, -7.07902983e-02f, 1.95785612e-01f, 1.89138427e-01f, -2.64023170e-02f, -1.63700610e-01f,
  1.14431642e-01f, 1.01859525e-01f, -1.86582893e-01f, -2.38780100e-02f, 1.96202826e-02f, 7.25906640e-02f, 9.40555558e-02f, 1.56565756e-01f, -7.55288750e-02f, -5.35638221e-02f,
  -8.09781402e-02f, 5.03846270e-04f, 1.00882389e-01f, -1.33607939e-01f, -8.72406065e-02f, 1.76843554e-01f, 8.69999230e-02f, 6.80690333e-02f, -9.54305455e-02f, -1.43513852e-03f,
  1.72623575e-01f, 1.41635850e-01f, -1.42317032e-02f, 1.72468796e-01f, -1.18317865e-01f, -1.79475769e-01f, 6.12403639e-02f, 2.25271452e-02f, 5.77361844e-02f, -1.30850390e-01f,
  -1.06127888e-01f, -1.49342552e-01f, 7.72504210e-02f, 4.25860286e-01f, 2.68772900e-01f, 1.26117542e-01f, 2.76569098e-01f, 1.21102422e-01f, 1.23501368e-01f, 7.88873807e-03f,
  -9.07139406e-02f, 1.85795084e-01f, -2.58062214e-01f, 1.88906845e-02f, 1.64400503e-01f, -1.04705267e-01f, 4.51624095e-01f, 4.34077919e-01f, -1.84155200e-02f, 2.65311569e-01f,
  -5.49315140e-02f, 1.51756510e-01f, -7.43798763e-02f, 2.74989545e-01f, -1.90969288e-01f, 2.02282652e-01f, -5.36789522e-02f, 2.36592576e-01f, -1.74074903e-01f, -1.57644063e-01f,
  -2.83401996e-01f, 1.27199009e-01f, 1.74520820e-01f, 3.33544225e-01f, 1.59839645e-01f, 1.16430633e-01f, -2.21932237e-03f, 4.79539260e-02f, 3.59422415e-02f, -2.15055477e-02f,
  -1.11400977e-01f, 1.37459248e-01f, -7.22700208e-02f, 2.15438791e-02f, -1.75438538e-01f, -3.21300253e-02f, -1.04846135e-01f, 1.69526845e-01f, 6.33140188e-03f, 2.69856364e-01f,
  -1.68142039e-02f, -1.48681313e-01f, 1.91088468e-01f, -1.40257284e-01f, 1.61792517e-01f, -8.37307498e-02f, 7.40380660e-02f, -1.15071826e-01f, -1.33360103e-01f, -1.84147000e-01f,
  4.89159934e-02f, -6.16780110e-02f, -1.28978537e-03f, 1.12135656e-01f, 4.16235114e-03f, 8.42258409e-02f, -9.05139446e-02f, 9.16152522e-02f, 2.20895559e-01f, 6.06006831e-02f,
  1.83755979e-01f, 3.02034110e-01f, -2.83986002e-01f, 2.49022827e-01f, -2.10765019e-01f, -1.18287988e-01f, 7.90217444e-02f, -3.06569219e-01f, -1.47296339e-01f, -1.63866654e-01f,
  2.65963137e-01f, -3.09710830e-01f, 1.80096790e-01f, 4.40545976e-02f, 2.64897972e-01f, 8.94249380e-02f, -2.54686832e-01f, 1.68669909e-01f, -2.36660689e-01f, 5.99388361e-01f,
  2.33346298e-01f, 2.58589946e-02f, -1.20843060e-01f, 3.46570425e-02f, 8.97756070e-02f, -4.50912230e-02f, 7.60202259e-02f, 3.08561355e-01f, -5.77304736e-02f, 4.52165931e-01f,
  2.35398188e-01f, 4.16216142e-02f, 1.55543536e-01f, 2.05438927e-01f, -2.14311853e-01f, -1.68172762e-01f, -2.64516234e-01f, 3.35794985e-01f, 2.15988010e-01f, -4.11315531e-01f,
  -3.18406001e-02f, -7.25897476e-02f, 5.85321367e-01f, -1.27982244e-01f, -1.35888994e-01f, 2.49635845e-01f, 6.80148825e-02f, -1.29971117e-01f, -2.82634646e-01f, 2.76115656e-01f,
  -1.96015418e-01f, 2.68877625e-01f, -8.06619227e-02f, -7.89809823e-02f, 4.84014414e-02f, -8.80870074e-02f, -3.54997784e-01f, -6.42385632e-02f, 6.15432896e-02f, 4.43204492e-01f,
  3.76453400e-01f, 2.38005966e-01f, 9.17363763e-02f, 8.63814130e-02f, 9.97960716e-02f, 2.83499330e-01f, -2.39667613e-02f, 6.26374930e-02f, 5.10015115e-02f, -5.02133191e-01f,
  -1.91437796e-01f, 3.98310125e-01f, 1.64589018e-01f, -6.56063035e-02f, -1.28253400e-01f, -3.34291272e-02f, -8.23787302e-02f, 1.14530645e-01f, -1.41129456e-02f, -1.08348452e-01f,
  -2.69872397e-02f, -1.19757228e-01f, -6.63639903e-02f, -3.11754614e-01f, 8.79560784e-02f, 1.67962480e-02f, -3.69150154e-02f, -5.43047488e-02f, 2.51975089e-01f, 8.84131640e-02f,
  4.49684486e-02f, -2.69259155e-01f, -4.01992500e-02f, 1.39109313e-01f, -9.42383334e-03f, 5.67393787e-02f, -5.19949757e-02f, -1.10501433e-02f, 2.20137477e-01f, -1.10887952e-01f,
  -1.23875469e-01f, -2.40483239e-01f, -1.11532018e-01f, 4.28211801e-02f, 8.11352953e-02f, -1.34000197e-01f, 3.37630898e-01f, -7.20702931e-02f, -1.12995142e-02f, 2.89077282e-01f,
  1.63565323e-01f, -6.65253997e-02f, 3.64059396e-03f, -9.29313973e-02f, 1.16124064e-01f, 7.32099041e-02f, 1.65119737e-01f, 1.07299551e-01f, -1.54405847e-01f, -1.36103824e-01f,
  -1.08359151e-01f, 1.18340261e-01f, 3.78772557e-01f, -1.51290804e-01f, 5.70455603e-02f, 1.08610369e-01f, 1.25807792e-01f, -8.68952461e-03f, 3.20044965e-01f, 1.06752492e-01f,
  6.99982001e-03f, 2.18993485e-01f, 1.10354088e-01f, -2.22515970e-01f, 1.66066483e-01f, -1.70178473e-01f, -1.32954732e-01f, -2.39050910e-02f, -8.69895145e-02f, -1.32943809e-01f,
  1.86695561e-01f, -1.24857269e-01f, -2.16129601e-01f, -1.69896245e-01f, 2.15786733e-02f, -2.42400050e-01f, 1.55100122e-01f, 4.64395970e-01f, 2.58505374e-01f, 8.14986750e-02f,
  4.42108661e-02f, -7.55445883e-02f, 2.50099041e-02f, -5.52360900e-02f, -1.16227187e-01f, 7.92238191e-02f, 1.07587129e-01f, -8.01573098e-02f, -1.00225978e-01f, -1.36673227e-01f,
  -1.06764078e-01f, -1.01587273e-01f, -1.45284951e-01f, 3.59060243e-02f, 1.57246605e-01f, -1.87987506e-01f, -1.11182250e-01f, 4.42445613e-02f, 7.32345581e-02f, -3.27689312e-02f,
  8.65444425e-04f, 3.52336615e-02f, 4.32153605e-02f, -3.11555229e-02f, 7.46560693e-02f, -8.45845491e-02f, -1.23332784e-01f, -3.23412977e-02f, -4.77399975e-02f, 4.35315035e-02f,
  -2.95456704e-02f, -1.61793619e-01f, 2.64212321e-02f, -1.71565473e-01f, 3.71647142e-02f, -1.74817547e-01f, -1.09860664e-02f, -1.51717499e-01f, 4.50841822e-02f, -1.32318005e-01f,
  1.92846507e-01f, 2.00735539e-01f, 1.89446136e-01f, 2.11553052e-01f, -1.60823002e-01f, 1.38417641e-02f, 8.28008056e-02f, -3.40058096e-02f, -6.08063340e-02f, 1.34666488e-01f,
  1.27627123e-02f, -1.81956738e-02f, -1.58579201e-01f, 1.62766010e-01f, 8.86714980e-02f, 1.75706763e-02f, 1.52602673e-01f, -1.44881383e-01f, -1.15428589e-01f, -2.11616587e-02f,
  2.23883279e-02f, 1.38849497e-01f, 5.36318570e-02f, -4.04312238e-02f, -7.54927099e-02f, -1.37502640e-01f, 2.72086561e-01f, -1.01917731e-02f, 3.34128998e-02f, -6.80278987e-02f,
  5.95086589e-02f, -1.54026859e-02f, 7.81296939e-02f, 4.04469185e-02f, -1.12063829e-02f, -1.56799436e-01f, 4.73916121e-02f, -5.00161164e-02f, -6.55132011e-02f, -9.13659669e-03f,
  -1.64770987e-02f, 1.31356493e-01f, -8.09646919e-02f, -1.12168677e-01f, -8.34207982e-02f, 2.96761513e-01f, -2.72732752e-04f, -5.72727807e-02f, 4.69924025e-02f, 1.38490349e-01f,
  -1.46415472e-01f, 6.14121296e-02f, -1.64551884e-01f, 6.04667477e-02f, -1.24284178e-01f, -5.78284934e-02f, -1.17928691e-01f, -8.69613215e-02f, 3.86901721e-02f, -5.79613224e-02f,
  1.40267178e-01f, -9.60086007e-03f, -3.22956741e-02f, 4.19936366e-02f, 9.00560096e-02f, -1.34536922e-01f, 8.08277074e-03f, -2.13089790e-02f, -1.46265939e-01f, -9.39697400e-02f,
  -3.62292267e-02f, -7.02923676e-03f, -5.30453362e-02f, -1.10906713e-01f, 2.09320392e-02f, -1.65930837e-01f, -1.31473839e-01f, 4.57963422e-02f, 3.69809084e-02f, 8.18475410e-02f,
  -1.41148865e-01f, -1.16726771e-01f, 1.06335938e-01f, -1.82164222e-01f, -1.51353806e-01f, 1.30300716e-01f, 2.67485250e-02f, -1.72848463e-01f, -1.69389233e-01f, 1.37728408e-01f,
  -6.06667921e-02f, -7.41713122e-02f, 7.18899146e-02f, 7.36266235e-03f, 4.35174167e-01f, 3.79761189e-01f, -1.08462997e-01f, -4.25914042e-02f, 2.53949702e-01f, 2.93268949e-01f,
  6.14399388e-02f, 1.35905072e-01f, -2.31240895e-02f, -4.90318269e-01f, -2.94779688e-01f, 4.13137972e-01f, 3.72763872e-01f, -1.15959123e-01f, -1.37112573e-01f, -1.36916831e-01f,
  1.05613530e-01f, 3.94930720e-01f, -2.93239988e-02f, -1.01307526e-01f, -1.42510742e-01f, -1.19116217e-01f, -1.28446400e-01f, -2.86413789e-01f, 2.15075463e-01f, -1.11013308e-01f,
  -8.30637291e-03f, -8.80958289e-02f, -2.38799918e-02f, 2.80577213e-01f, 3.25073302e-01f, -2.63768613e-01f, 2.02999450e-02f, 1.26789913e-01f, 8.67020637e-02f, 2.21559525e-01f,
  -8.11632816e-03f, 3.67614180e-02f, 2.41484225e-01f, 1.02226194e-02f, -1.75545990e-01f, 1.66377023e-01f, -2.07425535e-01f, -1.49537385e-01f, 1.13066874e-01f, 8.09514616e-03f,
  -7.70115852e-02f, 2.98036903e-01f, -1.38908416e-01f, 1.50657957e-02f, 4.59888130e-02f, 1.10689305e-01f, 1.49818346e-01f, -7.30392784e-02f, 5.46278059e-02f, -3.33270468e-02f,
  1.03543334e-01f, -1.05705559e-01f, 4.25874107e-02f, 2.04134941e-01f, -1.51862174e-01f, 8.94121081e-02f, -1.69041322e-03f, 2.58473814e-01f, -1.24885052e-01f, 1.27104819e-01f,
  2.43009493e-01f, 5.70769571e-02f, 1.86642166e-02f, 6.13500811e-02f, 6.87999874e-02f, -7.53230080e-02f, 2.90876161e-02f, -5.45803532e-02f, 1.13582484e-01f, -1.74807653e-01f,
  -1.06485225e-01f, -1.05722763e-01f, 3.93616468e-01f, 1.15119971e-01f, -5.14441468e-02f, 1.05313554e-01f, 1.14863664e-01f, -1.49491981e-01f, -5.74091077e-03f, 1.68327197e-01f,
  7.16654211e-02f, 2.85314322e-01f, 8.15957859e-02f, 7.68645480e-02f, 3.78757194e-02f, -6.00969531e-02f, 4.00757305e-02f, 6.41668811e-02f, 2.79968202e-01f, 7.30916411e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  3.66865844e-01f, 5.75297512e-02f, 1.59257818e-02f, -6.10352159e-02f, 9.15112570e-02f, -5.67064155e-03f, -7.65568996e-03f, -2.70779971e-02f, 9.18394998e-02f, 2.58701086e-01f,
  3.47579479e-01f, -3.14842016e-02f, 1.31585345e-01f, 2.32216511e-02f, -2.37371475e-02f, -1.10628076e-01f, 1.59516148e-02f, 3.66084456e-01f, 9.77604017e-02f, 6.02637744e-03f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  2.17657760e-01f, -2.21406460e-01f, 1.21380150e-01f, 5.20460941e-02f, 1.64276406e-01f, -1.63151070e-01f, 2.35252995e-02f, 1.09282630e-02f, -9.93555188e-02f, 8.02107155e-02f,
  1.80097073e-01f, -6.92650229e-02f, 9.03834179e-02f, -1.91228732e-01f, -3.31695527e-02f, 2.45584577e-01f, -1.78885162e-01f, -3.68194655e-02f, 1.48167342e-01f, 1.33514136e-01f,
  2.60513090e-02f, 2.55259067e-01f, -1.82937995e-01f, -1.56301409e-01f, -2.18749478e-01f, 7.69448727e-02f, -1.40726939e-01f, 3.19566205e-02f, -1.73642501e-01f, -1.78945720e-01f,
  4.93288087e-03f, 1.87523410e-01f, -1.40681028e-01f, 1.17803417e-01f, -1.40336454e-01f, 8.12545791e-02f, -1.49866566e-01f, 7.33608902e-02f, -1.65788665e-01f, -2.15809390e-01f,
  -3.42245400e-01f, -1.86918870e-01f, 8.30709115e-02f, -1.13066584e-01f, -1.90035909e-01f, 1.03876024e-01f, 7.95567259e-02f, -2.00581819e-01f, -1.55158147e-01f, 2.44669579e-02f,
  -2.79324432e-03f, -1.73127428e-02f, -2.57383883e-01f, -1.87303051e-01f, 1.23378560e-01f, -3.65955234e-02f, -1.59445614e-01f, -1.79899246e-01f, 1.80531532e-01f, -3.10801510e-02f,
  6.10532314e-02f, 5.61096072e-02f, 1.56395435e-01f, -6.17895164e-02f, -5.85811883e-02f, -2.60092854e-01f, -6.52777925e-02f, -1.59730390e-01f, -3.21693063e-01f, -1.60904997e-03f,
  1.23810805e-01f, 2.34998152e-01f, 1.47516236e-01f, 1.67867288e-01f, 2.00191259e-01f, 1.26064733e-01f, -1.52987674e-01f, 1.00977980e-01f, 9.85015035e-02f, 1.60206676e-01f,
  2.23180011e-01f, 2.12475345e-01f, 2.61598855e-01f, 7.78856501e-02f, 2.21628174e-01f, 2.06809118e-01f, -3.21184844e-01f, 5.18804640e-02f, 1.84241161e-01f, -8.98265168e-02f,
  -1.01181149e-01f, 5.02986498e-02f, -9.27774459e-02f, -4.35616642e-01f, 2.20609814e-01f, 2.76372552e-01f, 6.23977818e-02f, 2.11139396e-01f, 1.68769374e-01f, 1.79722570e-02f,
  1.95112661e-01f, 1.65385261e-01f, 2.08641246e-01f, -1.21718004e-01f, 1.37142196e-01f, 1.02645881e-01f, 9.19515565e-02f, 2.39344630e-02f, -1.41805798e-01f, -8.76420513e-02f,
  -3.93962003e-02f, 1.02395579e-01f, -1.37087688e-01f, 1.50950328e-01f, 1.03221811e-01f, -2.96704657e-02f, 2.95583338e-01f, 2.89844215e-01f, -1.96762145e-01f, -1.51584730e-01f,
  1.80807382e-01f, -1.20111644e-01f, -6.77958205e-02f, 6.29783124e-02f, -1.32651955e-01f, -2.52700895e-01f, -4.11208756e-02f, 6.66583106e-02f, 4.52109501e-02f, -1.45566449e-01f,
  7.69656077e-02f, -7.96545818e-02f, -3.49321440e-02f, 1.04962841e-01f, 3.43491100e-02f, -1.67561516e-01f, -1.70071661e-01f, -7.12389126e-02f, -7.17467666e-02f, -7.81519413e-02f,
  -1.35365486e-01f, 2.34856769e-01f, 3.26265991e-02f, -2.18456939e-01f, -1.12362213e-01f, 1.34622425e-01f, 1.05062544e-01f, 1.86150342e-01f, -2.58762062e-01f, -1.71235755e-01f,
  1.77947897e-03f, -1.51220366e-01f, -1.01523310e-01f, -4.53083180e-02f, -5.58162071e-02f, 8.24926347e-02f, 8.71713981e-02f, 3.82648259e-02f, 1.81251675e-01f, -2.56916732e-01f,
  -1.50623187e-01f, 9.89159755e-03f, 6.34979606e-02f, -3.89683098e-02f, 1.17487289e-01f, 5.05611263e-02f, 4.73781154e-02f, 1.62953407e-01f, -1.19949086e-02f, -3.86710130e-02f,
  1.11573271e-01f, 4.56740260e-02f, 1.76840857e-01f, -1.78782120e-01f, -8.50979462e-02f, -9.18279514e-02f, 1.69435292e-02f, -9.02627558e-02f, -1.66706905e-01f, -8.14438835e-02f,
  3.16485554e-01f, 3.54110330e-01f, -1.93538427e-01f, 2.03731358e-01f, -8.56744125e-02f, 1.31193502e-02f, 1.79287061e-01f, 1.06117770e-01f, 1.30554527e-01f, -2.19833955e-01f,
  -2.23278672e-01f, 7.50988647e-02f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.28079930e-01f, -1.88072119e-02f, 2.91340314e-02f, 2.12669045e-01f, 1.10490069e-01f, 2.60780901e-01f, 2.15245277e-01f, -1.41342267e-01f, 3.48757982e-01f, 4.04579230e-02f,
  1.96556330e-01f, -3.51016998e-01f, -8.87982026e-02f, 3.71578813e-01f, -4.22779508e-02f, 8.91698748e-02f, 3.58559042e-02f, -3.41298506e-02f, 2.89435685e-01f, -6.55830204e-02f,
  -9.96088982e-02f, -1.21484168e-01f, 5.69614470e-02f, -9.00949910e-02f, -7.86054805e-02f, -3.59885842e-02f, 1.62998453e-01f, 1.21209435e-01f, 1.04182303e-01f, 3.91596183e-02f,
  -9.00194868e-02f, 1.07490711e-01f, 3.89810130e-02f, 1.82209268e-01f, 2.67990291e-01f, 4.58796918e-02f, 2.62762666e-01f, -1.58978030e-02f, -2.36564428e-01f, 5.44138346e-03f,
  2.51037717e-01f, -1.77025378e-01f, -2.57339984e-01f, -1.28873333e-01f, 4.16433513e-01f, 1.79820042e-02f, -7.39927143e-02f, 1.43555596e-01f, -6.58538938e-02f, -8.21259525e-03f,
  8.10808018e-02f, -2.26686418e-01f, 1.40276715e-01f, 9.41179767e-02f, 1.70083284e-01f, 1.63852781e-01f, 1.79184299e-05f, -1.63847804e-01f, 2.54945885e-02f, -1.84475049e-01f,
  1.83906853e-01f, 3.90123397e-01f, -2.48261020e-01f, 1.86296493e-01f, 4.28058393e-02f, -2.42790487e-02f, -6.35618065e-03f, -7.97173530e-02f, 1.93858445e-01f, 1.77674770e-01f,
  1.77666277e-01f, -1.47474095e-01f, 6.41164854e-02f, -7.37022758e-02f, -7.97934160e-02f, -1.28779948e-01f, 9.80345979e-02f, 6.99482039e-02f, -2.24886066e-03f, 2.36864820e-01f,
  2.01572165e-01f, 1.20485313e-01f, 1.57535598e-01f, 2.25882661e-02f, -1.91794097e-01f, -4.90540378e-02f, 2.76216328e-01f, -7.40054324e-02f, 5.08438013e-02f, 1.32687390e-01f,
  1.11419998e-01f, -1.08130582e-01f, -5.97286485e-02f, 1.31536022e-01f, -1.83324754e-01f, -8.40797275e-02f, -2.62299776e-01f, 1.85017005e-01f, 1.26463160e-01f, -5.25216386e-02f,
  3.25104147e-02f, 1.52166277e-01f, -3.34336549e-01f, 1.11001525e-02f, 1.14886768e-01f, -2.28514940e-01f, -1.45200759e-01f, 1.53268218e-01f, 6.43965602e-01f, 1.35717809e-01f,
  -4.19834219e-02f, -7.81391114e-02f, 2.58277863e-01f, -2.54363380e-02f, 4.04084355e-01f, 1.37613982e-01f, -8.46906379e-02f, -4.46547493e-02f, 3.08393300e-01f, 3.78027171e-01f,
  -2.26084143e-01f, -1.01546042e-01f, -1.98610678e-01f, -4.69149798e-02f, 8.28972608e-02f, 2.73635358e-01f, -6.84681907e-02f, 1.23456009e-01f, -4.45631184e-02f, 1.31742835e-01f,
  2.16660768e-01f, 2.40648165e-01f, 2.38215104e-01f, 3.22888702e-01f, -1.30032748e-01f, -5.42239994e-02f, -3.84772092e-01f, -1.45749509e-01f, -1.41683817e-01f, -1.30569115e-01f,
  6.08655214e-01f, 7.61649385e-02f, 1.05071098e-01f, -8.22916552e-02f, 2.30092883e-01f, -1.10042959e-01f, 7.35327229e-03f, 1.34162769e-01f, -2.84654468e-01f, -7.86374286e-02f,
  4.19225186e-01f, 2.28389099e-01f, -1.19496979e-01f, 8.49191621e-02f, -1.44382134e-01f, 8.04852135e-03f, 9.43936631e-02f, 6.20041847e-01f, 3.53666432e-02f, -5.69269806e-02f,
  3.22114602e-02f, 2.58717686e-01f, 1.59757510e-01f, 9.13773328e-02f, 1.88025385e-01f, 1.99117318e-01f, -1.51784942e-01f, 2.38938909e-02f, -2.29652122e-01f, 1.56630576e-02f,
  -1.94366932e-01f, 3.19641829e-01f, 4.68647450e-01f, -7.14494567e-03f, -2.52523571e-01f, 1.92152202e-01f, -2.06726089e-01f, -1.95955962e-01f, 4.82932746e-01f, -7.42517114e-02f,
  2.93895483e-01f, 7.59779513e-01f, -1.89581886e-01f, 1.02422707e-01f, 8.31521377e-02f, -1.00295968e-01f, -1.20800570e-01f, -7.96517432e-02f, -8.27993155e-02f, 5.37601067e-03f,
  1.30168751e-01f, 1.56631529e-01f, -2.69632339e-02f, 1.94982752e-01f, 2.15287924e-01f, -1.07248798e-01f, -1.62120517e-02f, -4.31338996e-02f, -8.86446387e-02f, 8.75975937e-02f,
  1.84761640e-02f, 1.62572175e-01f, -1.33837223e-01f, -3.57800759e-02f, 3.67345512e-01f, -1.83865577e-01f, -1.02523537e-02f, 2.19284557e-02f, -8.49072635e-02f, -1.30973622e-01f,
  5.80722354e-02f, -1.82915747e-01f, 6.23652339e-02f, 1.32366702e-01f, -1.29993841e-01f, 2.37729818e-01f, 2.75589917e-02f, -1.26553075e-02f, -5.97074768e-03f, 1.18061684e-01f,
  -1.05038717e-01f, 4.30102682e-06f, -1.47990184e-03f, 2.28892043e-01f, -1.24766663e-01f, -3.84331122e-02f, -6.12192489e-02f, 7.54233301e-02f, -1.06994942e-01f, 1.35474980e-01f,
  -8.57556611e-02f, -1.93360433e-01f, -1.61972046e-01f, 3.19949277e-02f, -6.77664764e-03f, -2.05071513e-02f, 4.40712363e-01f, 1.46595329e-01f, -4.72752750e-02f, -1.82423607e-01f,
  2.29010239e-01f, -4.17719707e-02f, 2.93497026e-01f, 7.35599846e-02f, -1.83787346e-01f, 4.94700968e-02f, 2.27310732e-02f, 2.25027785e-01f, -1.88859686e-01f, -2.36928053e-02f,
  9.14626122e-02f, -7.60830790e-02f, -1.03100866e-01f, 4.17502940e-01f, 1.44931860e-03f, 1.75731257e-01f, -5.65012954e-02f, -1.03173897e-01f, -2.30357684e-02f, -2.63811965e-02f,
  8.94403011e-02f, 9.25736502e-02f, -9.05375034e-02f, -1.30446628e-01f, 3.06495339e-01f, 9.08860192e-02f, 9.42416191e-02f, -1.43385246e-01f, 6.81907386e-02f, -1.65865757e-02f,
  2.30631143e-01f, 1.50961205e-01f, -1.05477646e-02f, 6.01128377e-02f, 3.15755218e-01f, -1.34142950e-01f, -2.78622955e-02f, 1.02469191e-01f, 3.37998010e-02f, 5.37295155e-02f,
  -3.26053761e-02f, -1.81346480e-02f, -2.76729502e-02f, 6.64400607e-02f, -1.36501104e-01f, -5.80900274e-02f, -3.49558778e-02f, 8.33638310e-02f, -1.82124116e-02f, -1.71850666e-01f,
  8.81113485e-02f, -1.14073895e-01f, 9.69949439e-02f, -1.12177096e-01f, -1.36466131e-01f, 2.51491088e-02f, -8.84922296e-02f, -2.16542762e-02f, -5.23284636e-03f, 6.43129833e-03f,
  4.70922112e-01f, 2.75938474e-02f, 4.24046256e-02f, 2.14881167e-01f, -9.35361832e-02f, -4.34415974e-03f, 3.81696880e-01f, 7.38482028e-02f, -7.95500353e-03f, 1.90879896e-01f,
  9.61801782e-02f, 1.96790114e-01f, -2.53405690e-01f, -1.24641329e-01f, 7.65651539e-02f, -8.84261355e-02f, -4.12498638e-02f, 1.64409012e-01f, 1.55582368e-01f, -3.67210731e-02f,
  -5.02464622e-02f, -1.22012347e-02f, 8.58945400e-02f, 1.50381729e-01f, -3.41678485e-02f, -4.84087840e-02f, -7.58003667e-02f, -3.85540375e-03f, -4.39772047e-02f, 1.31319344e-01f,
  -1.78272724e-01f, 9.62915793e-02f, 9.93532464e-02f, 8.60936195e-02f, -7.41336308e-03f, 2.27170244e-01f, -7.60812759e-02f, -1.68779299e-01f, 1.98891804e-01f, -1.35278225e-01f,
  1.47714287e-01f, 3.65859047e-02f, -1.56916529e-01f, 5.32754511e-02f, 1.47079900e-01f, 9.72306430e-02f, -1.48106039e-01f, 8.25832486e-02f, 7.66672716e-02f, -1.29025549e-01f,
  2.36747507e-02f, -1.21882424e-01f, 1.72094896e-01f, 9.94933248e-02f, -9.01574343e-02f, 2.97135770e-01f, 2.60392010e-01f, 3.97861570e-01f, 4.94317025e-01f, -3.67188811e-01f,
  7.50755191e-01f, -1.37063175e-01f, 9.08960402e-02f, -5.52142203e-01f, -8.14672410e-02f, 4.20368493e-01f, 1.43835276e-01f, -1.13432810e-01f, -7.12637678e-02f, 1.30715802e-01f,
  -7.89547805e-03f, -1.79500692e-02f, 2.91702092e-01f, -2.27054939e-01f, 5.14966071e-01f, 2.62426939e-02f, 4.42694277e-01f, 7.24657327e-02f, 2.43946016e-01f, 7.91635737e-02f,
  7.35226944e-02f, 1.14680327e-01f, -8.49226862e-02f, -3.14316265e-02f, 1.77196503e-01f, -9.43839625e-02f, 1.34962201e-01f, -1.58944190e-01f, -7.80475736e-02f, -3.85513343e-02f,
  1.03704683e-01f, -8.24660882e-02f, -1.84726089e-01f, -1.79110497e-01f, 3.12867798e-02f, -5.81735652e-03f, 2.04831660e-02f, -8.18537176e-02f, 1.73980758e-01f, 1.23516209e-01f,
  1.26115784e-01f, 1.25389338e-01f, -1.82096034e-01f, -7.99993053e-03f, -1.06999218e-01f, -2.86518373e-02f, 1.15162283e-01f, 1.32308275e-01f, 1.24126688e-01f, -1.08319521e-02f,
  -1.26397505e-01f, 7.36576319e-02f, 2.32739467e-02f, -1.45833969e-01f, 1.21543027e-01f, -7.74301812e-02f, 2.69646525e-01f, 1.27371568e-02f, -9.74395406e-03f, 1.81674182e-01f,
  1.16065614e-01f, 2.98140109e-01f, 3.62051666e-01f, 4.58312556e-02f, 5.36307335e-01f, 1.26364112e-01f, -7.24649206e-02f, -2.60014892e-01f, 2.70549834e-01f, -1.78546514e-02f,
  2.08880469e-01f, -7.59104341e-02f, -1.96344391e-01f, -1.03350133e-01f, 2.03666717e-01f, -1.20115228e-01f, 4.39601630e-01f, 4.11097985e-03f, 1.00268103e-01f, -4.96804342e-02f,
  3.43111336e-01f, 1.59232065e-01f, 2.36917466e-01f, -1.50010153e-03f, 5.15227281e-02f, 9.50378999e-02f, -2.11102828e-01f, 2.35354334e-01f, -1.70074090e-01f, -8.57152883e-03f,
  1.17552221e-01f, -1.44852147e-01f, -4.66280133e-02f, -2.15668604e-01f, -6.67887181e-02f, -6.53593838e-02f, 1.45770594e-01f, 8.14677253e-02f, 9.70655680e-02f, -1.27826124e-01f,
  3.11267972e-01f, -1.53354704e-01f, 1.73879460e-01f, 1.54645413e-01f, 1.51034594e-01f, 1.92466572e-01f, 1.84777036e-01f, -9.20569971e-02f, -7.52264410e-02f, 1.96724571e-02f,
  -3.20143402e-02f, -3.58726010e-02f, 1.02737181e-01f, -1.31766111e-01f, -1.37843981e-01f, 1.41298786e-01f, -1.58296600e-01f, 1.54213712e-01f, -9.01627913e-03f, -1.82365552e-02f,
  5.34737715e-03f, -4.60074050e-03f, 1.52563140e-01f, 2.59837836e-01f, 1.10564180e-01f, 2.42656261e-01f, -2.35292107e-01f, -3.04638356e-01f, -2.73126751e-01f, -1.97281092e-01f,
  -2.27204904e-01f, 8.41430947e-02f, 1.97996423e-01f, 9.94232073e-02f, -1.48624882e-01f, -2.22934052e-01f, 1.36961296e-01f, 1.46987801e-02f, 1.51045144e-01f, 5.09857908e-02f,
  -2.07158551e-01f, -2.71908015e-01f, 2.22627938e-01f, 2.10341662e-01f, 3.09067033e-02f, -1.99002773e-01f, 1.31367594e-01f, 1.59661829e-01f, 1.38721359e-03f, 5.65771461e-01f,
  1.57489434e-01f, -4.23262231e-02f, -1.72284499e-01f, -4.29965835e-03f, -9.75649729e-02f, -1.56459630e-01f, 1.45964786e-01f, -1.56313762e-01f, -1.84936091e-01f, -1.58555880e-01f,
  7.52880871e-02f, 3.61740775e-02f, -7.63474181e-02f, -1.69409111e-01f, -1.36596719e-02f, -6.37089461e-02f, 1.68821424e-01f, 2.31164997e-03f, -8.62156004e-02f, 1.06954694e-01f,
  2.13929415e-01f, 1.72001645e-01f, 7.34151155e-02f, -3.98259200e-02f, -1.80094108e-01f, 1.40670657e-01f, 8.26119855e-02f, 1.23238586e-01f, -8.59946667e-05f, 1.37948200e-01f,
  -1.60145596e-01f, -1.53987601e-01f, -8.73932615e-02f, 6.01867065e-02f, 2.02518478e-01f, 1.53690413e-01f, 1.51336789e-01f, 2.10524127e-01f, 8.69152471e-02f, 1.73488379e-01f,
  1.98533237e-01f, 4.20240015e-02f, 1.44643068e-01f, -5.83272949e-02f, -1.62336186e-01f, 1.25963211e-01f, 3.39916855e-01f, -9.57360044e-02f, -1.18622929e-02f, 2.34772205e-01f,
  -1.96715966e-01f, -2.54118681e-01f, 3.97423029e-01f, 9.38405469e-03f, 5.49460411e-01f, 7.36822724e-01f, -3.28264385e-01f, 1.06193922e-01f, 2.57557511e-01f, -5.94427846e-02f,
  -9.65757370e-02f, -1.53976873e-01f, 9.45648700e-02f, -4.06758934e-01f, 1.01251505e-01f, 2.01847628e-01f, 1.69669405e-01f, -1.27672404e-01f, 2.14941166e-02f, 3.48882712e-02f,
  -1.17887154e-01f, -1.28149629e-01f, 2.70051640e-02f, -1.59686774e-01f, 1.77339509e-01f, 4.15978357e-02f, 3.06143872e-02f, 6.72177821e-02f, 1.74629688e-01f, 2.15816274e-02f,
  1.73099950e-01f, 2.41918117e-01f, -8.08126330e-02f, 1.74620729e-02f, 9.08633098e-02f, 4.95974272e-02f, 3.23316604e-02f, -9.07085463e-02f, -4.90477197e-02f, -1.00905471e-01f,
  -1.40262857e-01f, -5.59072904e-02f, 1.13920517e-01f, 1.01576872e-01f, -1.17376447e-01f, 9.45616513e-03f, 1.10962056e-01f, -2.09427997e-02f, -1.52842537e-01f, 5.25039658e-02f,
  9.92992148e-02f, -9.57807899e-02f, -4.88887280e-02f, -8.85504335e-02f, 6.95820376e-02f, 6.82374788e-03f, 1.54426977e-01f, 1.08296610e-01f, 2.33897179e-01f, 1.37819245e-01f,
  1.07002877e-01f, 9.72379968e-02f, 2.46611744e-01f, 3.86526704e-01f, -6.77579567e-02f, -9.68307480e-02f, 3.53384584e-01f, 1.40874892e-01f, -1.19027205e-01f, 3.17603089e-02f,
  6.89686984e-02f, -7.94905350e-02f, -1.17767937e-01f, -1.57591999e-01f, -1.85680818e-02f, 2.12182820e-01f, 9.18940082e-03f, -1.74324647e-01f, 2.52877116e-01f, 2.06834763e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  -5.34508005e-03f, 1.97565109e-01f, -6.33343160e-02f, 2.10182682e-01f, 2.54709035e-01f, 2.94925034e-01f, -4.39475998e-02f, 6.51217550e-02f, -1.15204640e-01f, 7.31137320e-02f,
  -4.35721241e-02f, 3.73163909e-01f, 9.92700681e-02f, 1.46604627e-02f, 2.49724835e-02f, 1.90511033e-01f, -1.50323644e-01f, 1.51656374e-01f, 2.08380356e-01f, -6.78948388e-02f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  9.76911113e-02f, -1.05278067e-01f, -4.29018633e-03f, 2.08837301e-01f, -8.83096457e-02f, 2.77982265e-01f, 8.87585804e-02f, -4.24533002e-02f, -2.28968576e-01f, 1.38901055e-01f,
  -3.02697480e-01f, 1.46990493e-02f, -2.32085377e-01f, -1.12486556e-01f, 1.10599190e-01f, 1.22482859e-01f, 5.92698902e-02f, 9.00416523e-02f, 1.36291355e-01f, -1.75223649e-01f,
  -1.44838840e-01f, -1.28344119e-01f, -1.08809359e-01f, -1.51901066e-01f, -5.63955233e-02f, -2.51348853e-01f, 2.47695241e-02f, -8.38762522e-02f, -9.56136361e-03f, 1.46826282e-01f,
  9.12085474e-02f, -9.32548493e-02f, 1.17355511e-01f, -2.30885103e-01f, -1.14646420e-01f, -2.69684583e-01f, -6.06762432e-02f, 8.20772275e-02f, 1.36411369e-01f, -7.59812891e-02f,
  3.67924422e-01f, 3.59797686e-01f, -1.54891536e-01f, -1.02996454e-01f, 2.24236295e-01f, -1.09885611e-01f, -8.90190750e-02f, -6.69216514e-02f, -2.48743743e-01f, 1.72853366e-01f,
  1.12785742e-01f, -2.28572056e-01f, 2.17486262e-01f, -1.47527754e-01f, -3.11051570e-02f, 2.37004817e-01f, -6.99766725e-02f, 1.90780386e-02f, 6.98032901e-02f, -2.33854383e-01f,
  2.40961630e-02f, 9.03273821e-02f, 1.25513822e-01f, 1.94703549e-01f, -1.12362549e-01f, 2.21707657e-01f, -2.11629882e-01f, 1.57490581e-01f, 2.00213581e-01f, -5.46565652e-02f,
  1.72782838e-01f, 4.08595800e-02f, -2.83261836e-01f, -1.54905140e-01f, 2.24034145e-01f, -4.27825786e-02f, 1.84498057e-01f, -4.73627150e-02f, 1.28739655e-01f, -1.16665222e-01f,
  2.14815125e-01f, -3.21491778e-01f, -8.95602927e-02f, -7.85879046e-02f, 9.88982841e-02f, 9.21308473e-02f, 7.07449913e-02f, 1.41844869e-01f, -8.02902970e-03f, 3.58737633e-02f,
  -1.40697464e-01f, 3.22735347e-02f, 1.95876226e-01f, -2.76543051e-01f, 6.41523227e-02f, 1.53768152e-01f, 4.48075868e-02f, -2.53985554e-01f, -1.80322677e-01f, -7.13625401e-02f,
  -1.26072183e-01f, -5.25827426e-03f, -3.20762508e-02f, 1.58668384e-01f, -1.07689761e-01f, -1.08992882e-01f, 1.99254736e-01f, 1.45872727e-01f, -2.64801592e-01f, 2.01286972e-02f,
  -5.34283966e-02f, 2.08900899e-01f, 5.53745218e-02f, 1.61505520e-01f, 1.71009768e-02f, 5.07734381e-02f, -1.10025123e-01f, 9.92347207e-03f, -9.60699022e-02f, -4.40758616e-01f,
  1.58470869e-01f, -4.53269705e-02f, 6.57481849e-02f, 1.31592676e-01f, 1.02317236e-01f, 7.18952417e-02f, 9.33187827e-02f, 1.32446617e-01f, 5.20292334e-02f, -1.22837000e-01f,
  -1.76511705e-01f, 1.37662336e-01f, -1.95297316e-01f, -4.27077413e-02f, 1.98198497e-01f, -1.89186767e-01f, 2.11211234e-01f, 2.05362499e-01f, -1.36153698e-01f, -3.97170186e-02f,
  1.72094479e-01f, 5.01231514e-02f, 1.39362782e-01f, -2.77188599e-01f, -2.39662472e-02f, 2.07483117e-02f, -3.45528312e-02f, -2.65885502e-01f, 5.35122044e-02f, -5.87230735e-02f,
  4.66873646e-02f, 1.73526719e-01f, 1.09512046e-01f, 1.28918454e-01f, 5.59715666e-02f, -2.33307466e-01f, 6.81575909e-02f, 3.44487518e-01f, 1.59790337e-01f, 2.26328999e-01f,
  -3.48234981e-01f, -4.52047378e-01f, -3.82196784e-01f, -2.15519682e-01f, -3.86890084e-01f, -1.39469355e-01f, 2.31361151e-01f, -1.69338994e-02f, 4.55122560e-01f, 8.07130709e-02f,
  5.99330179e-02f, -1.33767590e-01f, 2.18101397e-01f, 6.26335712e-03f, -7.62720704e-02f, 5.06635336e-03f, -3.02655667e-01f, -1.79433122e-01f, -1.06769264e-01f, -7.85804018e-02f,
  1.12440132e-01f, 1.27915621e-01f, 2.20046937e-02f, 6.09126687e-02f, -1.25650436e-01f, 2.04135537e-01f, -7.12411776e-02f, -7.45781437e-02f, 1.48000658e-01f, 1.60587445e-01f,
  1.07560657e-01f, 1.56360477e-01f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -6.01580925e-02f, -2.77530640e-01f, 1.29495263e-01f, -2.55392820e-01f, -1.64306372e-01f, -8.97243097e-02f, 3.75872925e-02f, -1.32222936e-01f, 1.30756542e-01f, 7.67415809e-03f,
  -1.77317020e-02f, 1.66057974e-01f, 7.31850564e-02f, 1.28459886e-01f, 4.98152412e-02f, 1.44176289e-01f, 3.83518077e-02f, 1.56454202e-02f, 2.29300022e-01f, -7.20273256e-02f,
  7.91443214e-02f, 8.17020983e-02f, -1.18301339e-01f, -1.67739764e-01f, -1.65322497e-01f, -3.53050195e-02f, 1.72982454e-01f, -1.43189192e-01f, -1.58189744e-01f, 3.03733975e-01f,
  -1.53200001e-01f, 7.46474788e-02f, 2.91484762e-02f, 8.72897878e-02f, -3.71966101e-02f, -9.84707847e-02f, 1.83596596e-01f, 2.27404326e-01f, 1.56200737e-01f, -2.50940889e-01f,
  3.14682692e-01f, 4.34242226e-02f, 1.59673132e-02f, 8.25187564e-02f, 1.61306977e-01f, -1.77040651e-01f, 8.42253417e-02f, -2.28578359e-01f, -2.45277271e-01f, 3.90608519e-01f,
  -9.96019505e-03f, -1.21273696e-01f, -7.18422513e-03f, 1.57863289e-01f, 1.78935528e-01f, -6.49168491e-02f, 6.85131773e-02f, -1.04011960e-01f, -1.03558861e-01f, -9.84983519e-02f,
  -4.36862372e-02f, 3.80836248e-01f, 1.48661688e-01f, 2.51268208e-01f, -1.08042285e-01f, 1.54681265e-01f, 4.66234684e-02f, -3.86775732e-02f, -9.47373547e-03f, 2.46259034e-01f,
  -2.62438804e-01f, 1.64271548e-01f, -4.94575426e-02f, -6.89674243e-02f, 1.71218574e-01f, -2.16604427e-01f, -5.31937666e-02f, 2.38213301e-01f, 1.30718499e-01f, 2.82204002e-01f,
  1.85648710e-01f, -7.55582750e-02f, 1.19863592e-01f, 1.14300892e-01f, 7.30256215e-02f, 1.06987104e-01f, 3.83082293e-02f, 2.62566715e-01f, -1.53878137e-01f, -1.88452348e-01f,
  1.48439780e-01f, 4.25815791e-01f, 1.19983464e-01f, -2.73351967e-01f, 9.68405828e-02f, -1.72240332e-01f, 4.14479375e-02f, -2.74513900e-01f, 4.65752259e-02f, 2.39212718e-02f,
  -2.84093946e-01f, 4.72226813e-02f, 1.95978642e-01f, -3.80918235e-01f, 9.62010622e-02f, -1.14107713e-01f, -1.82871953e-01f, 1.60671890e-01f, -1.83442697e-01f, 2.96370804e-01f,
  -2.17751712e-02f, 2.17923105e-01f, -7.35491440e-02f, 4.23906654e-01f, 1.09163441e-01f, 8.36585388e-02f, 1.35087624e-01f, 1.28472626e-01f, 1.75279751e-01f, -2.98900545e-01f,
  -1.77282870e-01f, 2.80767500e-01f, -4.00559828e-02f, -2.86706895e-01f, 1.79519415e-01f, 3.48732561e-01f, 8.92120078e-02f, -4.95617762e-02f, 1.89047992e-01f, 1.87072113e-01f,
  8.03722162e-03f, 1.92786559e-01f, 2.67541111e-01f, 1.06665224e-01f, -2.27024034e-01f, -6.64597526e-02f, -1.84117183e-01f, 2.08558246e-01f, 8.28991979e-02f, -2.05601066e-01f,
  3.25225919e-01f, 5.31920092e-03f, 2.02494696e-01f, 1.29857874e-02f, 7.21373111e-02f, -7.83739090e-02f, -6.17730543e-02f, 8.30288157e-02f, 2.76717395e-01f, -4.06679511e-02f,
  5.49847074e-02f, 7.56005883e-01f, -1.09042853e-01f, 4.33683783e-01f, 7.86036551e-02f, -1.88679192e-02f, 1.10327549e-01f, -1.19093945e-02f, 1.38713121e-01f, 1.66136697e-01f,
  -1.66435450e-01f, -2.01416612e-01f, 8.35830066e-03f, -1.61999166e-01f, -9.06167850e-02f, -1.27216622e-01f, -1.48346918e-02f, 1.13986239e-01f, 3.20495181e-02f, -1.00451343e-01f,
  -2.11186651e-02f, 1.20273024e-01f, 1.66667834e-01f, -6.35500103e-02f, 8.27583447e-02f, 1.96340319e-04f, -1.34675009e-02f, 7.35707507e-02f, -9.61384028e-02f, -1.08721778e-01f,
  -1.30029365e-01f, 8.83269217e-03f, 1.79183245e-01f, 8.53734016e-02f, -6.15678355e-02f, 1.78467913e-03f, 4.90235165e-02f, -3.24730165e-02f, 1.62055165e-01f, 1.98129669e-01f,
  1.58358082e-01f, -1.82329246e-03f, -4.87728268e-02f, 2.07036823e-01f, -2.64950186e-01f, -4.89159897e-02f, 2.37283841e-01f, -7.49244094e-02f, 2.08751380e-01f, 9.69694033e-02f,
  2.32347148e-03f, 5.66318035e-02f, 2.93955594e-01f, -3.04340988e-01f, 3.84779042e-03f, -8.64803866e-02f, 9.56325680e-02f, 4.29976732e-01f, 1.74700513e-01f, 1.75936937e-01f,
  -6.47887066e-02f, 2.60035306e-01f, 5.32041602e-02f, 4.41813797e-01f, 1.01630598e-01f, -1.27707347e-01f, -1.10839285e-01f, -1.48526266e-01f, 1.82295814e-01f, 2.95141697e-01f,
  -6.35241270e-02f, 9.05850455e-02f, 1.64230466e-01f, 3.49372298e-01f, -2.27861837e-01f, -1.86497495e-01f, -1.74955919e-01f, -2.20052674e-02f, -1.27709329e-01f, 2.70177629e-02f,
  7.92388916e-02f, 6.81870878e-02f, -2.68986207e-02f, 1.81673765e-02f, 2.84182820e-02f, 1.42842636e-01f, 7.35401511e-02f, 2.11189315e-01f, -1.35760412e-01f, 3.20241123e-01f,
  1.61591582e-02f, 1.69861782e-02f, 1.91333219e-01f, 3.27534527e-01f, 1.12226114e-01f, 3.19932066e-02f, -3.70904952e-02f, -2.85329763e-02f, 1.41203627e-02f, -1.56858703e-03f,
  2.23059431e-01f, -5.60686663e-02f, 6.30170181e-02f, -1.50853228e-02f, -6.71286955e-02f, 1.11438259e-01f, 3.76697369e-02f, -8.49406198e-02f, -1.56561255e-01f, -7.39175081e-03f,
  -1.71154380e-01f, -4.85569425e-02f, 7.26902336e-02f, -6.74443021e-02f, 5.97068891e-02f, -1.91922233e-01f, -2.33612359e-01f, 2.38535270e-01f, -1.89341083e-01f, 2.80863732e-01f,
  1.61965549e-01f, 2.31573462e-01f, 2.29330257e-01f, 2.68789798e-01f, 2.19495177e-01f, 1.39543071e-01f, 1.25818089e-01f, 3.37276369e-01f, 2.28867278e-01f, -1.56136349e-01f,
  1.36318520e-01f, 1.43065661e-01f, 8.23801756e-02f, -6.75517246e-02f, 1.51662212e-02f, 2.17772707e-01f, 1.96577892e-01f, -2.59273853e-02f, -2.52758805e-02f, 2.96107322e-01f,
  -7.20120966e-02f, 1.70709807e-02f, 3.78187507e-01f, 3.75330627e-01f, -5.16253784e-02f, -6.38183281e-02f, -2.44090736e-01f, 1.56542733e-01f, 3.57342102e-02f, -2.85110980e-01f,
  -1.29056036e-01f, 3.27743173e-01f, 1.11826286e-01f, 1.98088676e-01f, 3.94785821e-01f, -2.69062519e-02f, -1.76752120e-01f, -1.22536793e-02f, -2.34422088e-01f, -1.04887672e-01f,
  4.98633645e-02f, 3.44533175e-01f, -6.76934272e-02f, -6.15700223e-02f, -1.94492087e-01f, 1.40856624e-01f, -1.29195824e-01f, -1.94745019e-01f, -7.72517547e-02f, -2.69229531e-01f,
  -4.48212102e-02f, 1.57980457e-01f, 2.44023297e-02f, -1.84257507e-01f, 5.24165034e-02f, -8.63049626e-02f, 4.61473018e-02f, -1.47272423e-01f, 2.39079952e-01f, 1.97275788e-01f,
  -1.74145520e-01f, 1.27571836e-01f, 3.53718002e-04f, 9.91402101e-03f, -1.58761859e-01f, -2.46958166e-01f, -2.10321490e-02f, -2.63501890e-02f, -2.34287698e-02f, -2.05364272e-01f,
  -7.34675210e-03f, -2.07889482e-01f, -2.54331660e-02f, 4.10700470e-01f, -1.31056532e-01f, 2.95934618e-01f, -1.94985628e-01f, -1.91401377e-01f, -1.81416973e-01f, 3.14180225e-01f,
  -7.58181810e-02f, -2.49640748e-01f, 3.63570988e-01f, 5.01352906e-01f, -3.15121897e-02f, 3.11198860e-01f, 2.29463473e-01f, 4.12720084e-01f, -1.52726390e-03f, 2.57657111e-01f,
  -6.57652020e-01f, -2.74975806e-01f, -9.87593830e-02f, -1.55093327e-01f, 9.42129642e-02f, 4.06581700e-01f, 2.97484472e-02f, 3.80896091e-01f, 7.40051031e-01f, 6.77046627e-02f,
  -8.99692774e-02f, 2.86830664e-01f, 2.12335382e-02f, 1.20308824e-01f, -1.46276310e-01f, -1.96412325e-01f, -6.14615381e-02f, 8.25714543e-02f, 3.35001480e-03f, 6.61631942e-01f,
  -7.84749910e-02f, -2.85720557e-01f, 9.86657739e-02f, -2.49118075e-01f, 3.42058688e-01f, 1.70942411e-01f, 3.97867084e-01f, 8.81088227e-02f, 4.13592905e-01f, 3.60802919e-01f,
  2.43421882e-01f, -5.87745547e-01f, 4.34904605e-01f, 5.15656769e-01f, -3.30836564e-01f, 3.77739996e-01f, -7.18663707e-02f, 2.09354594e-01f, -2.53601402e-01f, -2.00626001e-01f,
  -1.27093688e-01f, 9.96055186e-01f, 9.85607877e-02f, -1.40016854e-01f, -2.20602393e-01f, 7.50105530e-02f, 7.33756721e-02f, -1.33791849e-01f, -1.83166549e-01f, 2.01348841e-01f,
  -3.46185327e-01f, -1.16260514e-01f, -4.65993844e-02f, 9.04723585e-01f, -1.57903701e-01f, 9.35365632e-02f, 1.59871116e-01f, -2.04726562e-01f, 2.77138978e-01f, -7.02658743e-02f,
  -2.64523894e-01f, 1.45154327e-01f, -1.83517903e-01f, 7.33679393e-03f, 1.73824728e-01f, -1.06074139e-01f, -5.65826893e-02f, 2.12392882e-01f, -9.81182680e-02f, 1.08481713e-01f,
  -3.72425355e-02f, 3.49903740e-02f, -1.83816269e-01f, 4.37834412e-02f, 2.48784170e-01f, -7.67089725e-02f, 1.11087710e-01f, 2.22034231e-02f, -3.93262021e-02f, 4.26664688e-02f,
  -1.68376446e-01f, 3.38996559e-01f, 3.46681103e-02f, -1.44341350e-01f, -8.59327018e-02f, 2.83951432e-01f, -2.31034830e-01f, -1.41183227e-01f, -4.65006493e-02f, -2.68834233e-02f,
  -8.09404068e-03f, -1.62404642e-01f, 4.28298078e-02f, 8.78038034e-02f, -2.98685059e-02f, -2.69301105e-02f, -8.23906958e-02f, -4.05526787e-01f, -1.65436089e-01f, 5.99846914e-02f,
  -2.95654476e-01f, 4.58272666e-01f, 1.79132000e-02f, 4.66149211e-01f, 4.94752586e-01f, 4.65860873e-01f, 2.60655522e-01f, 3.55094671e-01f, -1.53696373e-01f, 3.01464587e-01f,
  1.31435141e-01f, -3.61511827e-01f, -5.03624007e-02f, 1.14065833e-01f, -3.02651674e-02f, 2.97683418e-01f, -7.86057040e-02f, 9.45463777e-02f, -1.33847922e-01f, 1.04266718e-01f,
  -1.24586150e-01f, -1.87070370e-01f, -2.34339923e-01f, 2.17206523e-01f, -1.21451408e-01f, 1.11120641e-01f, -5.71918115e-02f, -1.99591994e-01f, -2.70255446e-01f, 8.71256664e-02f,
  -7.74456337e-02f, 3.52771208e-02f, 1.27180874e-01f, 3.37427586e-01f, 1.06269620e-01f, 3.02307129e-01f, 2.21893653e-01f, -9.01907608e-02f, 2.37567276e-01f, -9.07379463e-02f,
  1.06189042e-01f, 6.92465007e-02f, 3.20144705e-02f, 2.27757022e-01f, 2.01385058e-02f, 3.52301180e-01f, 1.39831215e-01f, 1.13108559e-02f, -9.59718302e-02f, 1.01668052e-01f,
  4.02909815e-02f, 1.57719821e-01f, 4.28323224e-02f, 6.85832426e-02f, -1.66369766e-01f, -1.54881775e-01f, 3.96607183e-02f, 8.02616403e-03f, -1.92534342e-01f, 1.49565399e-01f,
  9.19645801e-02f, 1.52914554e-01f, -1.44693926e-01f, -2.12165445e-01f, 2.82140583e-01f, 1.56975448e-01f, -1.91864688e-02f, 1.42970324e-01f, 1.24647722e-01f, 1.25324935e-01f,
  -8.55230615e-02f, -2.38370989e-03f, -3.99020733e-03f, -2.47611795e-02f, 1.49989724e-01f, 2.29850650e-01f, 4.46260273e-02f, 1.58764735e-01f, -5.07766493e-02f, 1.02377698e-01f,
  3.13469507e-02f, -1.41127408e-01f, 2.34667361e-02f, -1.43795386e-01f, 2.94891864e-01f, 2.03799367e-01f, 3.78595084e-01f, 5.50510734e-02f, -8.64368007e-02f, 2.96184570e-01f,
  -3.46070498e-01f, -3.07466209e-01f, 5.32302670e-02f, 1.74554542e-01f, -1.08616576e-01f, 7.03578368e-02f, 3.22020859e-01f, 2.88553178e-01f, 1.45550251e-01f, -2.93653339e-01f,
  -3.56620461e-01f, -2.27888092e-01f, -2.25696445e-01f, -1.52975649e-01f, 5.83539121e-02f, -2.24031687e-01f, -7.88359642e-02f, 1.01851869e+00f, 2.75317505e-02f, 6.87171936e-01f,
  -4.88142930e-02f, -4.37134504e-02f, -1.32906005e-01f, -2.79278494e-02f, -9.41701308e-02f, -1.36052191e-01f, -6.78055882e-02f, -4.08165244e-04f, 3.13038118e-02f, -4.81027626e-02f,
  1.33637920e-01f, -5.36275283e-02f, -1.06613807e-01f, 1.04871832e-01f, 1.55273806e-02f, -8.05634186e-02f, 1.44097852e-02f, 2.08042607e-01f, -1.25327438e-01f, -8.92606974e-02f,
  -4.11206782e-02f, -6.34144917e-02f, -1.32301793e-01f, -1.59209184e-02f, -7.27157295e-02f, 4.81981784e-02f, 8.85899470e-04f, -1.79445013e-01f, 2.92435451e-03f, 2.23572515e-02f,
  -8.53981674e-02f, 5.40402345e-02f, 9.03304741e-02f, -1.34073958e-01f, 1.61506131e-01f, 3.17413509e-01f, 1.68487113e-02f, -1.06903337e-01f, 5.05863205e-02f, -8.94620568e-02f,
  -1.41125605e-01f, -5.83028831e-02f, -1.45154446e-01f, 4.91528679e-03f, -7.49721304e-02f, 1.67169094e-01f, 7.76093379e-02f, -6.91488981e-02f, 1.73644304e-01f, -5.13001531e-02f,
  2.24399343e-02f, 6.41857088e-02f, -1.51492223e-01f, -1.59955621e-01f, -1.46194920e-01f, 1.57030284e-01f, 9.44139436e-02f, 2.43757199e-02f, -7.21274987e-02f, -8.96458924e-02f,
  -1.01810887e-01f, -1.09401509e-01f, 3.41646597e-02f, 1.34848328e-02f, 1.05033867e-01f, -1.42641947e-01f, -6.68377429e-02f, 2.01885104e-01f, -1.05957396e-01f, 7.11819530e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  -5.35360947e-02f, 4.88588773e-02f, 4.72270604e-03f, -1.00110486e-01f, 1.84735842e-02f, -1.78531779e-03f, -1.15641244e-01f, -2.02286288e-01f, -1.95988879e-01f, 3.42507213e-01f,
  4.07781266e-02f, 4.96159017e-01f, 3.26335013e-01f, 2.89884135e-02f, 8.68098512e-02f, 8.41753334e-02f, -1.49812669e-01f, 1.66458189e-01f, 9.14471671e-02f, 2.16630492e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -9.74351913e-03f, -4.10876013e-02f, -4.73150402e-01f, 1.06677972e-01f, -1.40159100e-01f, -1.30032957e-01f, -1.51911661e-01f, -7.04417676e-02f, 2.26896361e-01f, -2.91655481e-01f,
  2.78717801e-02f, 1.67457119e-01f, 3.19229186e-01f, -1.76042184e-01f, 6.61378503e-02f, 3.00739408e-01f, -3.42897147e-01f, 2.15500630e-02f, 6.85334653e-02f, 3.67624104e-01f,
  3.54584754e-01f, -5.01295626e-01f, 3.10790334e-02f, 1.66895047e-01f, -3.45774025e-01f, 1.78303480e-01f, 5.59476316e-01f, 6.03163801e-02f, 4.37877998e-02f, -1.89018056e-01f,
  -6.36287257e-02f, 7.40264505e-02f, -5.66638038e-02f, 2.03971833e-01f, 4.70452942e-02f, -4.11657035e-01f, -3.17809254e-01f, 2.93235719e-01f, 1.05911687e-01f, 1.69175103e-01f,
  8.93268660e-02f, 1.46523386e-01f, 1.48885906e-01f, 2.72549748e-01f, 3.11355948e-01f, 2.73187757e-02f, -3.60961378e-01f, 5.68224013e-01f, -2.33559161e-01f, 1.74709260e-01f,
  1.50523677e-01f, 3.13444316e-01f, 4.81130481e-01f, -4.13447320e-01f, -2.68186063e-01f, -5.46860754e-01f, 1.58913970e-01f, 1.83467820e-01f, 2.07373753e-01f, 2.58759052e-01f,
  -1.75835580e-01f, -2.52197653e-01f, -1.96895763e-01f, 8.06240141e-02f, 2.77726091e-02f, 2.70739317e-01f, -3.68321761e-02f, 4.01959121e-01f, 9.49096084e-02f, 6.84977919e-02f,
  -2.25327298e-01f, -4.62758511e-01f, 2.35624403e-01f, -2.89446890e-01f, -1.21336933e-02f, -4.08904344e-01f, -4.59942631e-02f, -2.08768159e-01f, 1.58784360e-01f, 5.92389591e-02f,
  3.04293424e-01f, -1.75358355e-01f, 1.35189265e-01f, -8.96151066e-02f, 1.14464745e-01f, 3.43604833e-01f, -1.80926070e-01f, 5.06694138e-01f, -6.71069741e-01f, -2.90699989e-01f,
  -6.39049634e-02f, 3.86905968e-01f, 1.31167039e-01f, 1.71864718e-01f, -9.86869913e-03f, 9.88090336e-02f, -6.61517829e-02f, -2.21496016e-01f, 6.32845089e-02f, -5.21300659e-02f,
  -3.08426470e-01f, -1.00234307e-01f, -2.74175078e-01f, -1.24038257e-01f, 2.11195964e-02f, 2.77195573e-01f, 4.13808711e-02f, -2.06697822e-01f, -2.86808968e-01f, -1.30235285e-01f,
  6.38917029e-01f, -4.61887538e-01f, -1.12595305e-01f, 1.89551786e-02f, 3.86008203e-01f, 1.16559289e-01f, -1.58316463e-01f, 4.09937710e-01f, -2.45144144e-01f, 5.03173292e-01f,
  -1.19264877e+00f, -2.72793710e-01f, 3.62366408e-01f, -2.75770098e-01f, 2.20915943e-01f, -4.04299527e-01f, -1.68408781e-01f, 7.94443041e-02f, 9.44432989e-02f, -6.19983196e-01f,
  -2.62747500e-02f, -2.93772131e-01f, -8.42882320e-02f, -2.06268534e-01f, 1.22017547e-01f, -5.74654564e-02f, -3.72808158e-01f, 3.98691684e-01f, -7.14956462e-01f, 5.23332693e-02f,
  -2.05613241e-01f, -5.63255921e-02f, 1.77634165e-01f, -8.08286667e-02f, 9.41418186e-02f, 1.16841473e-01f, 9.66623146e-03f, -9.69268605e-02f, 2.79939443e-01f, 2.79166192e-01f,
  -1.42840773e-01f, 3.98745090e-01f, -2.31466889e-01f, -1.72223091e-01f, 3.99743080e-01f, 1.19311444e-01f, 5.99842332e-02f, -4.70492572e-01f, -9.09944698e-02f, -1.49119003e-02f,
  3.61332931e-02f, 3.41003001e-01f, -7.65471980e-02f, 3.00174896e-02f, 4.73888218e-01f, -1.68044403e-01f, 3.74830604e-01f, -3.71748328e-01f, -4.48264807e-01f, 7.91616216e-02f,
  -9.50827450e-02f, -4.14729476e-01f, -1.52821526e-01f, 3.33268791e-01f, -5.97355813e-02f, 2.90736079e-01f, -3.34432989e-01f, -2.09399641e-01f, 2.01804310e-01f, -1.89785495e-01f,
  2.38230959e-01f, -7.25417435e-02f, -1.68321297e-01f, -5.22318780e-02f, 5.93489647e-01f, -1.82227448e-01f, 2.49778241e-01f, -5.54318167e-02f, -1.05908439e-01f, -1.45184323e-01f,
  -2.29997590e-01f, -2.18768612e-01f, 2.37410858e-01f, -1.08770013e-03f, 1.30397707e-01f, -8.67390819e-03f, -6.53361157e-02f, 5.56117237e-01f, -2.40654245e-01f, 6.79743648e-01f,
  -2.06644237e-01f, -1.81608632e-01f, 2.45533898e-01f, -8.04946795e-02f, -1.56553015e-01f, -4.59320098e-02f, -1.17077753e-01f, -3.11635792e-01f, 3.21776122e-01f, 1.34552702e-01f,
  -2.95682579e-01f, -4.24633212e-02f, -3.31580549e-01f, 1.36895329e-01f, 4.73603934e-01f, -6.60660863e-01f, 2.27968842e-01f, 2.82798827e-01f, -6.82356894e-01f, -2.02412158e-01f,
  1.11313060e-01f, 9.44054008e-01f, -3.11584640e-02f, -7.88384974e-02f, -4.85721499e-01f, -4.59501684e-01f, 7.46687278e-02f, -1.12652436e-01f, -2.60126978e-01f, -1.99426010e-01f,
  -1.06120847e-01f, 1.84778824e-01f, 4.14742649e-01f, -3.02496791e-01f, 8.58440250e-02f, 4.05619085e-01f, -3.76937538e-02f, 3.58371168e-01f, -1.03584083e-03f, -5.48222512e-02f,
  5.56804359e-01f, 6.89368397e-02f, 4.78321016e-01f, 1.64720923e-01f, -1.81011513e-01f, -2.26374522e-01f, 6.74415156e-02f, -1.66016072e-01f, 1.52197957e-01f, -2.32697755e-01f,
  -3.69053304e-01f, 1.80177718e-01f, 2.46396407e-01f, 1.75383896e-01f, -8.20102617e-02f, -1.77161247e-02f, 2.49532307e-03f, -1.18825600e-01f, -3.02767366e-01f, 1.64257392e-01f,
  -1.03879519e-01f, 2.81580418e-01f, 1.10551633e-01f, 6.69010103e-01f, -2.39282846e-01f, -1.82269805e-03f, 2.34260544e-01f, 2.80134469e-01f, 1.06412284e-01f, 5.74031115e-01f,
  -2.61135727e-01f, 1.47852480e-01f, -4.22811627e-01f, 8.81570652e-02f, -1.53699443e-01f, -8.46856609e-02f, -9.45824310e-02f, -2.07678992e-02f, 1.53240949e-01f, -7.35584676e-01f,
  1.02921700e+00f, -8.23028982e-02f, -3.13041985e-01f, -4.13522214e-01f, -1.03260763e-01f, -4.83252764e-01f, 1.18993111e-01f, -2.96278168e-02f, 2.16144845e-01f, 3.78857255e-01f,
  -3.60903665e-02f, -1.08766332e-01f, 2.89187729e-01f, 2.62108557e-02f, -4.87656035e-02f, -5.38580269e-02f, 2.13098571e-01f, -5.23500480e-02f, 1.42624602e-01f, -2.99505025e-01f,
  3.89216691e-02f, -3.06386322e-01f, 2.24636599e-01f, -6.50250241e-02f, 5.34767568e-01f, -8.89541954e-02f, -3.89660865e-01f, -2.42422178e-01f, -3.14761788e-01f, 2.96803325e-01f,
  -3.73735838e-02f, 2.15521321e-01f, -2.77249753e-01f, -1.80695221e-01f, -6.03195548e-01f, 2.90094763e-01f, 1.57056108e-01f, 8.41519952e-01f, -1.39257625e-01f, 1.18327491e-01f,
  5.57298601e-01f, 4.26681578e-01f, 6.54084623e-01f, 5.85806608e-01f, 5.66831052e-01f, -6.02693677e-01f, 3.67440253e-01f, -7.05826879e-01f, -2.69395828e-01f, 2.71515220e-01f,
  -2.65370429e-01f, -5.51613748e-01f, -2.36822948e-01f, -8.62128288e-02f, -6.60728216e-02f, -4.37632263e-01f, -8.97574872e-02f, -3.10629839e-03f, -7.31906518e-02f, -2.39113614e-01f,
  -2.93849379e-01f, 3.09265822e-01f, -3.51517111e-01f, 9.01641548e-01f, 1.98289990e-01f, -1.27512023e-01f, 3.39756880e-05f, -1.92747816e-01f, -1.02366596e-01f, -3.46490353e-01f,
  -7.03643188e-02f, -1.08930655e-01f, 1.47494478e-02f, -2.55090475e-01f, -3.57202470e-01f, 1.87419669e-03f, -3.04104269e-01f, 1.99962091e-02f, -2.56549358e-01f, 1.02846347e-01f,
  -2.92143792e-01f, -1.82649672e-01f, -1.00818589e-01f, 1.55600920e-01f, 1.18899070e-01f, 2.75858231e-02f, 4.29184660e-02f, 3.76280546e-01f, -1.47705331e-01f, 1.66807190e-01f,
  -5.39773047e-01f, 6.27283603e-02f, 5.83719974e-03f, -1.12512380e-01f, 4.40210730e-01f, -2.64658183e-01f, 4.81099635e-01f, 4.61269110e-01f, -8.63370597e-02f, 6.67959359e-03f,
  1.44778043e-01f, 2.98883945e-01f, 1.90037012e-01f, 1.58609897e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.03465445e-01f, -1.18065946e-01f, 4.00930345e-02f, 7.44891167e-02f, -8.38842392e-02f, 3.83713916e-02f, 9.81602892e-02f, -1.79689199e-01f, 1.42411858e-01f, 1.59299269e-01f,
  2.74055481e-01f, -1.93638861e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    