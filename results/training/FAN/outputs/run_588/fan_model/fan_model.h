/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.43407884e-02f, -3.10895145e-01f, -4.41183627e-01f, -1.34689242e-01f, -2.80995548e-01f, -2.58309126e-01f, -3.38783354e-01f, 6.15498889e-03f, -3.76685187e-02f, -2.79949367e-01f,
  -1.27171978e-01f, 1.66654080e-01f, -2.30713282e-02f, -3.80905122e-02f, -2.02227190e-01f, -4.42562521e-01f, -4.81453508e-01f, -2.11358532e-01f, -3.19149122e-02f, -2.30884794e-02f,
  -8.68055224e-02f, -1.47367626e-01f, 5.28171957e-02f, -2.71692150e-03f, -7.72310719e-02f, 1.55998081e-01f, -2.39167005e-01f, -1.09517150e-01f, 9.31153540e-03f, -3.70701313e-01f,
  -3.19022924e-01f, -2.08322480e-01f, 7.39514083e-02f, -2.81765088e-02f, -5.31870164e-02f, -6.67283908e-02f, -4.40591425e-02f, 9.50248074e-03f, 1.33004457e-01f, -8.82678181e-02f,
  -1.39580861e-01f, -5.69043960e-03f, 4.57802862e-02f, -3.54322083e-02f, -9.73772407e-02f, -6.94766566e-02f, -2.89437938e-02f, -9.47437733e-02f, -1.55716285e-01f, -8.82272571e-02f,
  1.31667191e-02f, -8.43545720e-02f, -1.34472214e-02f, 1.43662631e-03f, -9.25106257e-02f, -2.50453390e-02f, -1.23744830e-01f, 3.52598242e-02f, -7.71857575e-02f, -9.12446305e-02f,
  -8.98998305e-02f, 1.59230366e-01f, 1.28952116e-01f, 2.05458552e-01f, 1.66995421e-01f, 1.70188546e-01f, 4.57787141e-02f, 7.17599317e-02f, 1.12798989e-01f, 1.67003930e-01f,
  7.30700493e-02f, -2.03486457e-02f, -7.15906825e-03f, 1.19353250e-01f, 6.59309104e-02f, 6.00919649e-02f, 3.36037129e-02f, 6.79397434e-02f, 2.21524954e-01f, 1.51939690e-01f,
  1.87158927e-01f, 1.26423761e-01f, 1.15149759e-01f, 5.83428852e-02f, -5.06022014e-02f, -2.04218812e-02f, 7.43418112e-02f, 1.12215616e-01f, 1.52930379e-01f, 5.47013395e-02f,
  7.45251030e-02f, -5.93725853e-02f, -1.05918854e-01f, -6.19136468e-02f, -8.87387991e-02f, 5.27874343e-02f, -6.87031299e-02f, 1.44301346e-02f, 1.76195763e-02f, -6.09480515e-02f,
  -1.06435068e-01f, -7.02296123e-02f, -1.14103407e-01f, 2.81266030e-03f, -8.64327326e-03f, 7.60145998e-03f, -6.97349235e-02f, -1.52522415e-01f, -2.09868830e-02f, -6.18566386e-02f,
  -8.98954421e-02f, 1.09375538e-02f, 1.23701781e-01f, 8.82574394e-02f, -1.81827415e-02f, 9.24768597e-02f, 5.47211878e-02f, 3.70105393e-02f, 3.09680160e-02f, -6.95483834e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.60202432e-01f, 2.19110936e-01f, 1.83847755e-01f, -2.32072800e-01f, 1.82758510e-01f, 6.10141866e-02f, 2.50229955e-01f, -1.14154546e-02f, 2.67356068e-01f, 4.59540099e-01f,
  5.20569310e-02f, -3.33430707e-01f, -1.59419794e-02f, 9.05557647e-02f, -2.98881948e-01f, 5.95078349e-01f, 6.75535500e-01f, -1.36742592e-01f, -6.16518736e-01f, -4.31971729e-01f,
  1.74938560e-01f, -3.12554359e-01f, -4.44454342e-01f, -1.79945618e-01f, -1.86714891e-03f, -3.08271766e-01f, 2.47951776e-01f, -7.04331398e-02f, 5.78718679e-03f, 2.49003142e-01f,
  -2.45366156e-01f, -3.84714365e-01f, -2.97864825e-01f, -1.73035070e-01f, -8.86354893e-02f, 1.10092163e-02f, -1.11105949e-01f, -8.31281692e-02f, -1.24467231e-01f, 6.25095814e-02f,
  1.37371689e-01f, -1.49528235e-01f, -1.63000062e-01f, -4.68329452e-02f, -2.03557745e-01f, -1.89220041e-01f, 2.56035537e-01f, -1.92737594e-01f, -6.13778783e-03f, -6.34492263e-02f,
  2.97161043e-01f, -3.31253186e-02f, -2.75936753e-01f, 7.96070844e-02f, 4.91323881e-03f, 5.01915999e-02f, -1.72163039e-01f, -1.73386693e-01f, -2.30744764e-01f, -1.32851511e-01f,
  5.77623323e-02f, 6.52369037e-02f, -1.12044644e-02f, 1.70343131e-01f, 5.46121933e-02f, 1.31469935e-01f, 9.64921489e-02f, 3.51438345e-03f, -3.54195572e-02f, 2.47018207e-02f,
  1.64128527e-01f, 3.07454895e-02f, 6.94786906e-02f, -9.95961800e-02f, 6.48175180e-02f, -9.46621597e-02f, -3.36586460e-02f, -3.83623913e-02f, 5.40106446e-02f, -3.09089036e-03f,
  -2.60386560e-02f, -3.88109051e-02f, 4.69894037e-02f, -1.06706887e-01f, 3.19106728e-01f, -7.34533668e-02f, 7.08883405e-02f, 5.81825487e-02f, 1.48414508e-01f, 1.05672767e-02f,
  -3.06160599e-01f, 2.25322545e-01f, -1.83723211e-01f, 3.23312916e-02f, -1.40534312e-01f, 1.34463653e-01f, -7.29945824e-02f, 2.59031244e-02f, -4.97829765e-02f, -1.83251008e-01f,
  -1.47935659e-01f, -6.69030175e-02f, 2.30143368e-01f, -2.53946893e-03f, -2.87703037e-01f, 8.81465152e-02f, 2.84501642e-01f, -1.55293895e-02f, 2.72916019e-01f, -1.76436063e-02f,
  2.93183237e-01f, 1.40265435e-01f, -1.31750137e-01f, 3.66362953e-03f, 9.54504013e-02f, -6.56508729e-02f, -1.68300360e-01f, -1.44945890e-01f, -1.11709706e-01f, -1.44433714e-02f,
  -6.61598384e-01f, -1.26534030e-01f, -9.11363065e-01f, 2.43609697e-01f, 5.46902061e-01f, -2.31498644e-01f, -7.18638182e-01f, -5.06489575e-01f, 7.59534463e-02f, -2.63688207e-01f,
  1.19991831e-01f, 5.07134020e-01f, 1.69519767e-01f, -3.11405007e-02f, -4.88462508e-01f, -1.16174355e-01f, 1.73425540e-01f, -1.93873748e-01f, -2.92907149e-01f, 1.05139889e-01f,
  5.09458005e-01f, 1.91750214e-01f, -2.73383081e-01f, -3.91729809e-02f, 4.76120085e-01f, 1.65269628e-01f, 3.39159034e-02f, 3.73048186e-01f, -2.23656837e-02f, 5.12407064e-01f,
  -2.56692320e-01f, -2.41051301e-01f, -1.45018667e-01f, 3.00026864e-01f, 2.81398267e-01f, -3.24647158e-01f, -1.56002820e-01f, -6.11650087e-02f, -5.21202106e-04f, -2.15978235e-01f,
  2.60146052e-01f, -2.26927958e-02f, 2.63294667e-01f, -4.41623218e-02f, -1.68759033e-01f, -2.81737328e-01f, -2.97613174e-01f, -3.33646357e-01f, -3.13650966e-01f, -1.65944606e-01f,
  5.97308338e-01f, 3.82023305e-01f, -3.29773784e-01f, -2.01823965e-01f, -4.34315950e-01f, 1.19090125e-01f, -2.62299389e-01f, -1.50970533e-01f, -6.92093968e-01f, -4.29988801e-01f,
  -9.03172716e-02f, 5.88152977e-03f, 7.66070187e-02f, -6.19738027e-02f, -2.60793287e-02f, 4.32244428e-02f, 1.18688174e-01f, 3.49472165e-02f, 6.16183446e-04f, -7.90835321e-02f,
  4.25494947e-02f, -2.47153845e-02f, -6.02861680e-02f, -1.79821268e-01f, 5.57126477e-02f, 2.43338645e-02f, 4.71780822e-02f, -5.17394319e-02f, 2.64833197e-02f, -1.34965762e-01f,
  -7.78588131e-02f, -1.33981705e-01f, 2.07919374e-01f, 1.67826712e-02f, -1.48598745e-01f, -1.10475019e-01f, 5.14757968e-02f, -7.58311003e-02f, -1.53169721e-01f, 3.95233966e-02f,
  6.71103224e-02f, -1.32821381e-01f, -5.52900694e-02f, -1.87906981e-01f, -1.31621230e-02f, -2.46637668e-02f, 1.27399623e-01f, -1.52111784e-01f, -2.10010558e-02f, -1.52230531e-01f,
  -1.35530904e-01f, -3.01832706e-01f, 6.97385892e-02f, -2.80361535e-04f, -1.25080749e-01f, 4.94705476e-02f, 7.04409480e-02f, -3.02862674e-02f, -1.56832337e-01f, 1.42037868e-01f,
  -1.18464462e-01f, -3.48892570e-01f, -4.41011220e-01f, -3.47147316e-01f, 4.58501205e-02f, -1.93561286e-01f, -2.94567287e-01f, -3.33626717e-01f, -6.15537226e-01f, -4.95789528e-01f,
  6.56187236e-01f, -1.16124630e-01f, 5.76004624e-01f, 3.88754040e-01f, 4.05097723e-01f, 1.56955242e-01f, -1.28090918e-01f, -2.22773507e-01f, -1.58499822e-01f, 7.12317601e-02f,
  -2.33535379e-01f, -3.39110017e-01f, -5.24392843e-01f, -4.60225910e-01f, -3.42994958e-01f, -1.35284234e-02f, 2.04158723e-01f, 2.07395151e-01f, 3.13738406e-01f, 3.02243531e-01f,
  3.80106196e-02f, 3.53913903e-01f, 2.58130789e-01f, 2.32124422e-02f, 8.57272893e-02f, -1.14573494e-01f, 5.81121333e-02f, 2.47266456e-01f, -1.12309996e-02f, 4.27907079e-01f,
  3.22859079e-01f, 2.65279651e-01f, -2.22743332e-01f, -2.13110328e-01f, 1.70960277e-01f, -2.26296559e-01f, 4.83662747e-02f, 6.29393160e-02f, -1.11312479e-01f, 4.04531844e-02f,
  7.10292161e-02f, 1.25468701e-01f, -1.09458484e-01f, -6.48636222e-02f, 1.19796798e-01f, -9.48017347e-04f, -1.44274622e-01f, -1.15103506e-01f, -2.18563601e-01f, -9.29766372e-02f,
  -2.60821104e-01f, 2.45454267e-01f, 9.34177190e-02f, -3.19311798e-01f, -1.19698361e-01f, 8.23528841e-02f, -4.82210750e-03f, 4.20704708e-02f, -2.51236916e-01f, 1.02204077e-01f,
  8.30246061e-02f, 2.58866251e-01f, 2.02123776e-01f, 1.73594892e-01f, 2.07644567e-01f, 1.15355551e-01f, 5.63196763e-02f, 1.11646093e-01f, 3.73596549e-02f, 2.06632987e-01f,
  -3.99266444e-02f, 8.98717493e-02f, 8.88132229e-02f, 1.41323358e-02f, -3.12912907e-03f, 6.45911768e-02f, 1.76156074e-01f, -1.43292351e-02f, -1.41905814e-01f, 1.54524028e-01f,
  1.58244118e-01f, -3.92552167e-02f, 4.89554815e-02f, -1.13974102e-01f, 3.94248329e-02f, 9.09331515e-02f, 1.21142231e-01f, 1.96593683e-02f, 1.11159794e-01f, 1.44736752e-01f,
  -2.25237235e-01f, -2.18691409e-01f, 7.99673051e-03f, -2.49234870e-01f, 1.48151234e-01f, -5.28086014e-02f, -4.07326557e-02f, -4.63606827e-02f, 2.47324537e-02f, -2.30644532e-02f,
  -1.33885294e-02f, -1.78873688e-02f, -1.92391291e-01f, -5.83216511e-02f, 1.84931397e-01f, 3.93434353e-02f, 5.29952580e-03f, 7.44671300e-02f, -9.20678675e-02f, 1.78358201e-02f,
  -1.45115972e-01f, 3.38354670e-02f, 1.93911150e-01f, -8.79292116e-02f, -2.86910199e-02f, 1.90591682e-02f, 1.37437940e-01f, 5.61839268e-02f, -7.09523112e-02f, 8.79472427e-05f,
  8.91423702e-01f, 2.21869007e-01f, -6.91120982e-01f, 3.97901207e-01f, -8.96427706e-02f, -6.52547553e-02f, 3.40511948e-01f, 2.33549416e-01f, 3.69869709e-01f, 5.25008082e-01f,
  -5.67866638e-02f, -4.72254634e-01f, -2.76649654e-01f, -3.54726642e-01f, -2.83608198e-01f, 3.12005669e-01f, 2.42206305e-01f, -2.80881971e-01f, -4.66784596e-01f, -2.16997936e-01f,
  1.89980671e-01f, 3.18259567e-01f, 3.60279202e-01f, -6.25584945e-02f, -1.62820011e-01f, -2.40673870e-01f, 7.02733770e-02f, -1.56057149e-01f, -2.82741100e-01f, -3.03658038e-01f,
  -5.44194043e-01f, -8.87058303e-02f, -6.57059401e-02f, 5.04334494e-02f, -4.41985756e-01f, 1.14657149e-01f, -8.63596126e-02f, -1.84488237e-01f, -1.38634101e-01f, 1.33988842e-01f,
  -2.54185677e-01f, 3.89701128e-03f, -1.64967850e-01f, -5.12769818e-02f, 1.90211292e-02f, -5.96116222e-02f, 1.56103093e-02f, -1.24113165e-01f, -1.20126449e-01f, -1.36886075e-01f,
  -5.28344363e-02f, -3.29037935e-01f, -5.12397170e-01f, -9.24751833e-02f, -3.24887782e-01f, -3.39100838e-01f, -3.98490131e-01f, -5.00389457e-01f, -3.22414726e-01f, 2.37095878e-01f,
  4.79674712e-02f, 4.97137755e-02f, 4.73261438e-02f, 1.48375645e-01f, 1.46505699e-01f, -1.31685942e-01f, -6.15586387e-03f, -2.89074201e-02f, 1.34903982e-01f, 6.86651170e-02f,
  -1.45063445e-01f, 1.21853806e-01f, 7.24694058e-02f, 1.96224570e-01f, 5.16125858e-02f, -1.41362518e-01f, 1.01302326e-01f, 3.24242413e-01f, -1.69733047e-01f, 1.27707183e-01f,
  -1.53380647e-01f, -9.02118906e-03f, 1.18788660e-01f, -5.11022061e-02f, 6.35109395e-02f, -1.69815451e-01f, 7.33003318e-02f, -7.34955668e-02f, -1.23881675e-01f, 2.19656661e-01f,
  3.40004265e-01f, 1.21792421e-01f, 2.12560818e-01f, -4.04215418e-02f, -5.36071137e-02f, -2.41309747e-01f, -2.95594893e-02f, 2.63496040e-04f, -2.29277089e-01f, -1.06309116e-01f,
  -1.26578927e-01f, 7.60282129e-02f, 3.36879790e-02f, 7.82933906e-02f, 1.03841521e-01f, -6.14624424e-03f, 2.53077447e-01f, 5.63624129e-02f, 4.89454418e-02f, 4.84029092e-02f,
  3.96191955e-01f, 4.23308372e-01f, 2.98064083e-01f, 1.89807162e-01f, -5.44674881e-03f, 2.16213554e-01f, 2.72141420e-03f, 5.41508980e-02f, 1.11476891e-01f, 8.78327787e-01f,
  -5.98865330e-01f, 4.26377326e-01f, 2.44280159e-01f, -2.37600401e-01f, -2.40438521e-01f, -1.58385903e-01f, -2.34553829e-01f, -1.40530452e-01f, 2.24279985e-02f, 2.66852319e-01f,
  1.77487701e-01f, -2.14842558e-01f, 1.01792738e-01f, -2.41544485e-01f, -6.91569924e-01f, -1.32912412e-01f, -2.23806947e-01f, -5.51306725e-01f, -7.62626946e-01f, -8.61254215e-01f,
  -4.57421303e-01f, -4.34899420e-01f, -4.73284453e-01f, -3.87348771e-01f, 4.09477144e-01f, 1.07432254e-01f, 3.88430476e-01f, -1.17541008e-01f, -6.21418208e-02f, 4.13809955e-01f,
  7.33383298e-01f, 2.01920554e-01f, -1.92711204e-01f, -4.88054335e-01f, 2.82736450e-01f, -1.37853727e-01f, 2.78139003e-02f, 1.47097662e-01f, -1.46411523e-01f, 1.56321958e-01f,
  -1.33554369e-01f, 3.25502194e-02f, -1.03458971e-01f, 2.66901683e-02f, 1.06165692e-01f, -3.16919833e-02f, -1.95411459e-01f, -4.32432860e-01f, -1.30120650e-01f, 9.40242410e-02f,
  -1.03896827e-01f, -2.84441352e-01f, 1.01668887e-01f, 9.55725759e-02f, 7.25786239e-02f, -1.01213664e-01f, 2.37863183e-01f, 3.91840898e-02f, -1.18974354e-02f, 5.30357838e-01f,
  -3.75743099e-02f, 3.32436323e-01f, -2.95861177e-02f, 1.37635604e-01f, -4.99366447e-02f, -4.04478759e-02f, 1.33373812e-01f, 8.92663002e-02f, -1.80841893e-01f, 2.56287232e-02f,
  3.65073644e-02f, 1.11871839e-01f, 1.35926649e-01f, 1.04590692e-01f, 1.85665470e-02f, -3.94137390e-02f, 4.25234213e-02f, 1.81297928e-01f, 1.37474895e-01f, 6.33233488e-02f,
  -8.43469277e-02f, 8.05712491e-02f, 1.23398207e-01f, 3.00549273e-03f, -6.92393333e-02f, 1.35787010e-01f, 3.43795610e-03f, -4.14088331e-02f, -1.47557408e-01f, -1.04464851e-01f,
  4.90596324e-01f, -3.82522047e-01f, 2.88028568e-01f, -2.27755532e-01f, 7.84008577e-02f, -1.57540739e-01f, 2.32494235e-01f, -1.15552470e-01f, 3.17084491e-01f, 1.32103801e-01f,
  -1.24496497e-01f, 2.18808547e-01f, 2.58609876e-02f, 2.20469721e-02f, -1.15139693e-01f, -4.93650660e-02f, -3.05859506e-01f, 1.12311505e-02f, -2.42747739e-01f, 1.64968058e-01f,
  -1.50072575e-01f, -3.04135531e-01f, -1.32730231e-03f, 1.59213871e-01f, 1.13156037e-02f, -1.81213364e-01f, 3.88789147e-01f, 1.17337786e-01f, -1.80405244e-01f, 2.42078409e-01f,
  4.82210845e-01f, -7.16275454e-01f, -3.01386297e-01f, -2.83190846e-01f, -2.01925203e-01f, 9.94024277e-02f, -1.75000489e-01f, 7.70994870e-04f, -8.88152421e-02f, -3.31243634e-01f,
  2.13413432e-01f, 3.24656248e-01f, 1.47283539e-01f, 1.53438032e-01f, 3.03946823e-01f, -6.43731952e-01f, -4.44545448e-01f, 1.60405710e-01f, 5.35948217e-01f, 2.63099402e-01f,
  -1.40751392e-01f, -1.40399054e-01f, 1.20737232e-01f, 6.73530670e-03f, -4.84735847e-01f, -2.02464506e-01f, -5.17001271e-01f, -2.26141781e-01f, -2.14012891e-01f, -7.35771239e-01f,
  -2.88371611e-02f, 1.87034592e-01f, 2.10001856e-01f, 1.72093630e-01f, -2.06419930e-01f, -4.99231145e-02f, 1.28630502e-02f, -1.51024163e-01f, -1.06900625e-01f, -1.53602108e-01f,
  -2.07402017e-02f, 1.92875788e-02f, -2.47869380e-02f, -1.03736997e-01f, 2.95730326e-02f, -2.01435070e-02f, -3.96168381e-02f, 5.40894121e-02f, -2.57975813e-02f, -1.32044151e-01f,
  -1.03695452e-01f, 1.48750007e-01f, 1.19005911e-01f, 1.54468328e-01f, 2.23253816e-01f, 3.80135804e-01f, 2.08978325e-01f, 2.45491296e-01f, 2.81155348e-01f, -4.26565498e-01f,
  1.41769096e-01f, 1.81703065e-02f, 1.37586072e-01f, 7.34060481e-02f, 3.03459857e-02f, -3.73573266e-02f, -3.65636963e-03f, -4.86575952e-03f, -3.66989113e-02f, -6.97754696e-02f,
  -1.43755049e-01f, 5.05691804e-02f, 2.50626981e-01f, -4.53621075e-02f, -1.53791979e-02f, 1.19984308e-02f, -1.03783831e-02f, 7.42925704e-02f, 1.33111864e-01f, -7.97912180e-02f,
  5.95036000e-02f, 8.29373673e-02f, -1.21485256e-02f, 1.00727081e-01f, 2.31436431e-01f, 9.18475688e-02f, 5.32656945e-02f, 1.40566126e-01f, -7.09360614e-02f, -8.36147964e-02f,
  -9.85321850e-02f, 4.97627050e-01f, -2.61278749e-01f, -6.11616648e-04f, -1.41710460e-01f, -1.18657745e-01f, 4.24041599e-02f, -1.14718378e-01f, -1.35515317e-01f, -3.14068571e-02f,
  7.94423744e-02f, 8.31933618e-02f, 8.17948356e-02f, -2.94981580e-02f, -1.22729219e-01f, 1.15386881e-01f, 1.09563939e-01f, 6.52234480e-02f, 1.43430933e-01f, -2.13321254e-01f,
  -1.20060034e-01f, -4.79288884e-02f, 5.24448184e-03f, -9.31444541e-02f, 4.11763880e-03f, 1.74191818e-01f, -6.33355305e-02f, -2.80410703e-02f, 1.64872646e-01f, -4.29902196e-01f,
  3.13746691e-01f, -3.27507883e-01f, 5.80483794e-01f, -1.05754696e-01f, -7.67479002e-01f, -5.78038692e-01f, -7.51771390e-01f, -1.02573752e-01f, 7.44148483e-03f, -3.15754443e-01f,
  -6.61942780e-01f, -4.05938625e-01f, -1.68696102e-02f, 7.76154920e-02f, 1.95862934e-01f, 5.64690456e-02f, 3.33076328e-01f, 5.86521208e-01f, 2.19522238e-01f, -3.49580318e-01f,
  -4.27600265e-01f, 9.58679803e-03f, 4.22616124e-01f, 3.29629391e-01f, -3.35827768e-02f, -1.19015940e-01f, 3.35045636e-01f, 1.33997321e-01f, 1.49034802e-02f, 6.72860205e-01f,
  4.06697333e-01f, 2.95356125e-01f, -1.30526111e-01f, -2.36620069e-01f, -9.36478302e-02f, -9.87744406e-02f, -1.59286097e-01f, 3.86370659e-01f, -1.20506212e-01f, 1.79014295e-01f,
  -2.21074015e-01f, 6.53232336e-02f, -5.44081293e-02f, -5.45993708e-02f, -1.73470184e-01f, -7.62328086e-03f, 2.07009047e-01f, 4.20761377e-01f, 2.49423817e-01f, -4.66812290e-02f,
  -3.98338348e-01f, -2.54101038e-01f, -1.30336881e-01f, -1.46246210e-01f, 1.40117735e-01f, -1.56863362e-01f, -1.06897123e-01f, 1.64553538e-01f, 1.77261129e-01f, 3.89007896e-01f,
  -1.58210427e-01f, 1.15567660e-02f, 6.68850839e-02f, 1.52407408e-01f, -8.26700851e-02f, -1.49765268e-01f, 2.73248088e-02f, -1.72911525e-01f, 1.13749348e-01f, -4.22350019e-02f,
  -2.31762009e-04f, -9.73892137e-02f, 5.70400544e-02f, -1.08060382e-01f, -1.07007518e-01f, 9.55156982e-02f, 1.90482009e-02f, 1.90820426e-01f, 5.75427897e-02f, -9.05828476e-02f,
  -7.11571053e-02f, -2.32554674e-02f, 8.36574733e-02f, 1.69665173e-01f, -1.38936982e-01f, 2.20727310e-01f, -6.55450970e-02f, -8.49689096e-02f, -7.43852928e-02f, -2.73456220e-02f,
  -2.61507392e-01f, -7.97693953e-02f, 1.10856086e-01f, 1.51210338e-01f, -7.62913451e-02f, -9.70517620e-02f, -1.26422703e-01f, -2.88825184e-02f, -1.20285898e-01f, -1.01377085e-01f,
  -1.55081823e-01f, -1.21405348e-01f, -7.34649301e-02f, 8.79553184e-02f, -1.57273397e-01f, -1.11707844e-01f, -1.41839713e-01f, -2.68230200e-01f, -2.10570678e-01f, -2.17133000e-01f,
  -1.33304030e-01f, -2.31834128e-01f, -3.97312671e-01f, -3.16338271e-01f, -2.74936616e-01f, -5.32631159e-01f, -1.73781201e-01f, -2.61282355e-01f, -3.99302691e-01f, -4.06376988e-01f,
  4.76762176e-01f, -4.44623381e-01f, -8.57200861e-01f, 2.39109516e-01f, -3.93546671e-01f, -3.82571131e-01f, -5.10655105e-01f, 2.49108568e-01f, 3.32835078e-01f, -5.49971640e-01f,
  -2.80483276e-01f, 2.43733432e-02f, -2.31324926e-01f, -1.94364890e-01f, -2.50324398e-01f, -8.07791889e-01f, -6.90507889e-01f, -5.07915854e-01f, -9.62972566e-02f, 1.92612320e-01f,
  -1.49793446e-01f, -1.87569410e-01f, -3.89945731e-02f, 1.70911942e-02f, -1.28695175e-01f, -6.08947948e-02f, -5.71349919e-01f, -3.76052916e-01f, -5.54344594e-01f, -6.76242471e-01f,
  -3.73362422e-01f, 8.32403079e-02f, -1.17319897e-01f, -1.34480566e-01f, -1.87063530e-01f, 1.14908844e-01f, 6.40678182e-02f, -1.33885413e-01f, 1.90649237e-02f, 6.82368577e-02f,
  -2.45144978e-01f, 6.69873729e-02f, -1.14838816e-01f, -1.12765700e-01f, 1.60373583e-01f, 3.63821611e-02f, -9.26932320e-02f, -1.05351083e-01f, -1.73401266e-01f, -1.98741272e-01f,
  -1.59043074e-01f, -3.00578266e-01f, -6.79504424e-02f, 3.38442177e-02f, 3.30214091e-02f, -2.58282218e-02f, -7.00965673e-02f, 7.20953569e-02f, -1.61971256e-01f, -1.80994481e-01f,
  -7.37806186e-02f, 6.92473128e-02f, -3.11483592e-02f, 1.34667709e-01f, 2.00661004e-01f, 1.84595305e-02f, 1.94048528e-02f, -1.04421161e-01f, 1.17821313e-01f, 3.01184170e-02f,
  7.61168078e-02f, -2.20382512e-01f, -1.38094546e-02f, 8.85787159e-02f, -1.57429099e-01f, -8.82245377e-02f, 4.53733318e-02f, -7.88019970e-02f, -1.31914183e-01f, -7.02225044e-02f,
  4.76911701e-02f, 1.65942144e-02f, 9.21160579e-02f, -9.56850573e-02f, -1.40529394e-01f, -8.04157555e-02f, 2.14874018e-02f, 2.50327617e-01f, 2.16690063e-01f, -7.94678088e-03f,
  5.36428154e-01f, -4.14905518e-01f, 1.00235127e-01f, -7.31083676e-02f, -1.21914387e-01f, -1.03534952e-01f, -1.21167183e-01f, 1.01612374e-01f, 9.68381588e-04f, 2.11302176e-01f,
  -2.00510651e-01f, -1.77419968e-02f, -1.45595297e-01f, -5.07575423e-02f, 1.78701833e-01f, 1.59929648e-01f, -1.76743761e-01f, -2.62992412e-01f, -1.20783202e-01f, 6.24235272e-02f,
  -2.99156606e-02f, -1.66784421e-01f, 1.98438570e-01f, -8.15728083e-02f, 9.32766646e-02f, -3.98614369e-02f, -2.39782482e-02f, -1.04649201e-01f, 1.12708412e-01f, 6.05375618e-02f,
  -1.01337230e+00f, -5.09607136e-01f, 6.58860564e-01f, -7.74751484e-01f, -1.12816989e-01f, 7.82912225e-02f, -2.90928423e-01f, -1.73559964e-01f, -1.33072570e-01f, -2.35779777e-01f,
  6.27192296e-03f, -2.83547550e-01f, -2.80946642e-01f, -9.09338295e-02f, 9.00028460e-03f, 7.58182956e-03f, 2.57434249e-01f, 1.81087002e-01f, 1.39742911e-01f, 5.53851165e-02f,
  -2.46630400e-01f, -1.58077106e-01f, 1.52157038e-01f, 2.10829675e-01f, -4.95354652e-01f, -2.08469152e-01f, 2.34265223e-01f, -2.14585885e-01f, 1.94838509e-01f, -6.71725690e-01f,
  -2.00681075e-01f, -1.08395807e-01f, 1.65068805e-01f, -1.31447405e-01f, 6.91805482e-02f, -8.65194649e-02f, -7.14167878e-02f, -3.85974534e-02f, 1.36296690e-01f, 3.09005976e-02f,
  2.00809669e-02f, 1.12622142e-01f, -1.62362680e-01f, -6.45101443e-02f, -5.52409664e-02f, -1.98489651e-01f, 2.05205500e-01f, 2.12215796e-01f, 1.69307798e-01f, 2.13184834e-01f,
  -2.17847437e-01f, -2.40037441e-01f, -1.33284954e-02f, 1.73407570e-01f, 8.20619911e-02f, 2.03331560e-01f, 1.30924717e-01f, -1.43443078e-01f, 2.85593748e-01f, -6.00171924e-01f,
  -4.40345593e-02f, 5.76802939e-02f, 9.85316113e-02f, 4.24580947e-02f, -1.77964672e-01f, 4.55135107e-03f, 1.01560697e-01f, -2.79473085e-02f, 6.11283630e-02f, -1.17008731e-01f,
  8.85305852e-02f, 7.01110139e-02f, -3.80910039e-02f, -2.07334742e-01f, 1.47126392e-01f, -7.17992261e-02f, 1.03465980e-02f, 1.03886992e-01f, -3.48369703e-02f, -7.80821517e-02f,
  -4.93902862e-02f, -7.25907534e-02f, 1.12501062e-01f, -2.78348010e-02f, -4.33191657e-02f, 1.03928819e-01f, -5.93126826e-02f, -1.12218633e-01f, -8.79027694e-02f, 1.60851836e-01f,
  -4.46342081e-01f, 5.56961715e-01f, -4.50967908e-01f, 1.07013278e-01f, -9.66094062e-02f, 1.26829343e-02f, 6.96241409e-02f, 1.22545630e-01f, -1.62568763e-01f, -1.90893169e-02f,
  -1.71349216e-02f, -3.01162511e-01f, -1.16124734e-01f, -1.33823901e-02f, 3.76026742e-02f, -7.74184912e-02f, -1.87145412e-01f, -1.41643882e-01f, 2.59430856e-02f, -1.26525238e-01f,
  -6.94777295e-02f, -3.71537149e-01f, -5.59187293e-01f, -4.79518324e-01f, -2.01571077e-01f, -2.36625955e-01f, -1.73670009e-01f, -2.44756743e-01f, -1.83277115e-01f, -6.93368852e-01f,
  -6.08837664e-01f, -6.25105381e-01f, 8.76502320e-02f, -8.46260726e-01f, 1.23398684e-01f, 5.32909274e-01f, 6.24376714e-01f, 1.28365815e-01f, -4.11662310e-01f, -2.18611777e-01f,
  -3.23969573e-01f, -2.89594501e-01f, -5.15085399e-01f, -1.80556267e-01f, 1.09821610e-01f, 2.51602471e-01f, -7.45630041e-02f, 5.28467968e-02f, 6.39325738e-01f, 7.25892782e-01f,
  1.50014490e-01f, -3.50716621e-01f, -4.65395182e-01f, -3.13704997e-01f, -3.68430167e-01f, -9.57574546e-02f, -5.33668816e-01f, -4.78374988e-01f, -2.83076726e-02f, -6.37274981e-01f,
  4.53115970e-01f, -6.46112740e-01f, 1.92384124e-01f, -3.48468542e-01f, -2.78211176e-01f, -1.50186494e-01f, 5.69436289e-02f, -2.58176714e-01f, -1.33740604e-01f, -3.30781192e-02f,
  -3.39549780e-01f, -1.29957765e-01f, -1.89023703e-01f, 3.92379686e-02f, -1.62397139e-02f, -3.11749503e-02f, -2.03774288e-01f, -3.15998554e-01f, -2.30052933e-01f, -1.65228173e-02f,
  -2.09410414e-01f, 2.46067178e-02f, 2.19531566e-01f, 9.01914388e-02f, -2.24653371e-02f, -1.06236473e-01f, -6.94742575e-02f, -7.77233765e-02f, -6.06811047e-02f, -9.11629423e-02f,
  3.10997455e-03f, 5.69660850e-02f, 1.16438232e-01f, 1.99911650e-03f, 8.76004472e-02f, 1.66234374e-02f, 7.62675405e-02f, 4.20805141e-02f, 3.73446532e-02f, 1.00419624e-02f,
  7.78107494e-02f, 2.14502700e-02f, 1.39922313e-02f, -2.50687897e-02f, -8.64531994e-02f, -4.61252332e-02f, 1.41054884e-01f, 1.02386083e-02f, -7.44695216e-02f, -1.42263398e-01f,
  -2.71094553e-02f, 6.24462403e-02f, -1.06416933e-01f, -6.56153401e-03f, -2.39768475e-02f, 2.62050936e-03f, -1.99067742e-02f, -3.32717746e-02f, -9.79483244e-04f, -2.11387835e-02f,
  1.75013393e-01f, -9.90807861e-02f, 1.26863703e-01f, -6.63535744e-02f, -1.13732137e-01f, -8.57653245e-02f, -1.33235127e-01f, -9.33715329e-02f, -1.59743667e-01f, 1.43694535e-01f,
  -8.68646652e-02f, 1.65169535e-03f, -5.14362082e-02f, -1.58648230e-02f, 2.43905097e-01f, 2.74675284e-02f, -2.40191087e-01f, -1.82396993e-02f, -4.95486967e-02f, 8.70587453e-02f,
  -7.68318921e-02f, 1.49943516e-01f, 2.49416664e-01f, 2.31341794e-01f, 1.06524214e-01f, 2.94060141e-01f, 1.69466898e-01f, 1.99824557e-01f, 3.34118873e-01f, 3.86170447e-01f,
  2.81206310e-01f, -1.20181382e-01f, -2.45565683e-01f, -4.77280289e-01f, -6.43823802e-01f, -6.02012634e-01f, -4.51136917e-01f, -4.93464023e-01f, -4.26488549e-01f, -5.78735583e-03f,
  4.36200835e-02f, 1.74247399e-01f, 4.94838566e-01f, 1.76045984e-01f, 3.35145563e-01f, 2.58642316e-01f, 9.80286226e-02f, 2.12092653e-01f, -1.41947076e-01f, -4.79978621e-01f,
  -1.52471587e-01f, -1.08626172e-01f, -1.10852592e-01f, -1.22677371e-01f, -3.63921851e-01f, -2.69198287e-02f, -9.16374549e-02f, -2.25057140e-01f, -1.18016899e-01f, -5.29850945e-02f,
  5.10583162e-01f, -2.52585322e-01f, -4.32591960e-02f, -4.76948842e-02f, -1.62464663e-01f, -1.37415901e-02f, -1.26588926e-01f, -1.56338438e-01f, 3.41154672e-02f, -7.07379654e-02f,
  -2.03892484e-01f, -8.33991915e-02f, -3.60243954e-02f, 1.81075614e-02f, -2.67427653e-01f, -1.63339972e-01f, -2.09528916e-02f, -1.13569405e-02f, 1.41001015e-03f, -8.67731590e-03f,
  1.51040517e-02f, -1.99088812e-01f, -1.66120809e-02f, -1.70441329e-01f, -2.32956275e-01f, 3.60383615e-02f, -1.37636662e-01f, -3.98538321e-01f, -3.22184376e-02f, -8.95755216e-02f,
  -9.38065648e-02f, 8.40466693e-02f, -8.67117494e-02f, -4.00976166e-02f, 5.43010496e-02f, 1.36146918e-01f, 1.94756940e-01f, 1.59476310e-01f, -1.11438846e-02f, 8.71730372e-02f,
  -5.45314886e-02f, 1.12449080e-02f, -4.42273319e-02f, 2.86334660e-02f, -1.66699141e-02f, -5.12538850e-02f, 3.32238413e-02f, -9.46761966e-02f, 4.41742949e-02f, -1.42867759e-01f,
  -9.59734768e-02f, -1.57898530e-01f, 5.73237352e-02f, 6.52573779e-02f, -1.01849042e-01f, -2.28346628e-03f, -3.98931205e-02f, 9.10692383e-03f, 1.26627386e-01f, -6.90498343e-03f,
  5.58648527e-01f, 2.96803057e-01f, 1.42212257e-01f, -5.23825772e-02f, 4.01912257e-02f, -1.68206424e-01f, -5.97952530e-02f, -5.85029684e-02f, 8.54605138e-02f, -1.43907458e-01f,
  -1.71959266e-01f, -5.00124432e-02f, 5.17314076e-02f, -3.02432943e-03f, -1.46520749e-01f, -1.25864604e-02f, 5.30992448e-02f, 2.74964660e-01f, 5.19943424e-02f, -2.25184023e-01f,
  -2.15933211e-02f, 1.93111584e-01f, 4.10011441e-01f, 2.22026616e-01f, -7.39488974e-02f, 1.16735153e-01f, 1.71740726e-01f, -1.58519782e-02f, 2.49643594e-01f, 3.74922872e-01f,
  1.24437129e+00f, 6.14062250e-01f, 2.56438971e-01f, 3.36457007e-02f, -4.81511913e-02f, 8.91200155e-02f, 3.75989437e-01f, 2.19656572e-01f, 3.88112292e-02f, 1.75530136e-01f,
  1.63265437e-01f, 2.38905605e-02f, 1.89812839e-01f, 1.65495768e-01f, 2.17450038e-01f, 9.12415832e-02f, -1.01121806e-01f, 6.53215721e-02f, -4.57315743e-02f, -6.79464266e-03f,
  -2.86716133e-01f, -2.19609663e-02f, 1.01546817e-01f, -3.68550010e-02f, -8.22139755e-02f, -1.14197180e-01f, 7.13724941e-02f, 6.45916909e-02f, 1.47374958e-01f, 1.81081006e-03f,
  2.77657225e-03f, 4.48537499e-01f, -2.48034850e-01f, -7.85339102e-02f, 6.50526807e-02f, -1.82151217e-02f, 2.52863532e-03f, -1.29148632e-01f, -1.29814163e-01f, -1.01884700e-01f,
  -1.11189522e-01f, -2.55401828e-04f, -1.16755869e-02f, -8.65195468e-02f, 3.65394242e-02f, -1.03940234e-01f, 6.08354509e-02f, 3.75125743e-02f, 7.05841277e-03f, -5.23170340e-04f,
  -9.25972611e-02f, -1.10147059e-01f, -7.59826526e-02f, 1.89115051e-02f, 1.76290572e-01f, -1.38200104e-01f, 1.11219481e-01f, 1.01085514e-01f, 1.49843991e-01f, 1.91733316e-01f,
  2.14043632e-03f, 1.31136969e-01f, 2.41732135e-01f, 1.44775689e-01f, 2.08346114e-01f, 1.31757498e-01f, 8.22203234e-02f, 2.40475070e-02f, 8.61770213e-02f, 5.48727810e-02f,
  5.87261915e-02f, 3.96486335e-02f, 9.58779305e-02f, 1.26203746e-01f, -1.57888364e-02f, 6.98765442e-02f, -7.72365406e-02f, -1.05621874e-01f, 9.87379104e-02f, -2.62781214e-02f,
  5.31665944e-02f, -7.29177222e-02f, -1.21846929e-01f, -1.19499117e-02f, -1.54559374e-01f, -5.59737091e-04f, -3.16318683e-02f, 4.78155985e-02f, 4.80360202e-02f, -1.16784826e-01f,
  -4.94295359e-01f, 3.18154246e-02f, -4.23981473e-02f, -6.63620681e-02f, -3.17560770e-02f, 6.29022047e-02f, 1.10616952e-01f, -7.19550550e-02f, -6.26114160e-02f, -7.43038654e-02f,
  -2.52220016e-02f, 9.00165960e-02f, 1.02725908e-01f, -2.50147395e-02f, -2.33422861e-01f, -1.72967747e-01f, 5.03774472e-02f, -1.28008023e-01f, -1.10956199e-01f, -1.47053465e-01f,
  -8.29194859e-02f, -1.28460541e-01f, -2.20030800e-01f, -2.93389298e-02f, -1.00244902e-01f, -1.36600792e-01f, -4.86619212e-02f, -1.37752712e-01f, 7.91289320e-04f, 1.78730432e-02f,
  1.04060322e-01f, -7.07333088e-01f, 1.37819543e-01f, 4.44948286e-01f, 2.33844250e-01f, 2.09996715e-01f, -1.82274610e-01f, 1.45285830e-01f, 3.11385244e-01f, 2.83246357e-02f,
  -1.96516231e-01f, 1.37136817e-01f, 3.29891652e-01f, 1.54556111e-01f, 2.12234482e-01f, 2.89215624e-01f, 3.88862550e-01f, 4.74093258e-01f, 2.95146197e-01f, 1.04760751e-01f,
  1.81103736e-01f, 4.55482155e-02f, -3.59677197e-03f, 7.89055154e-02f, -1.79807335e-01f, 2.55754977e-01f, -1.99460704e-02f, -1.01915941e-01f, -8.20719674e-02f, -3.21673863e-02f,
  -1.87930033e-01f, -2.56636322e-01f, 3.51925969e-01f, -3.84584218e-02f, -2.30327994e-01f, -2.06131995e-01f, -2.00548768e-02f, -7.19817877e-02f, -2.55743772e-01f, -2.39714235e-02f,
  -1.42839044e-01f, -1.10230461e-01f, 4.31553088e-02f, -1.57029480e-01f, -1.22743689e-01f, -1.53968528e-01f, -1.78476751e-01f, 6.96505681e-02f, 2.40394011e-01f, -8.39039087e-02f,
  -1.26316145e-01f, -6.46977648e-02f, 7.34330192e-02f, 1.52295977e-01f, 1.20152578e-01f, 2.30218381e-01f, -1.24143183e-01f, -9.00452584e-02f, 4.07411158e-02f, -1.69235006e-01f,
  1.73528805e-01f, 1.27144679e-01f, 2.07750559e-01f, 7.58445710e-02f, -1.99613050e-02f, -1.88960414e-02f, 8.71584266e-02f, 9.33969691e-02f, 2.15205312e-01f, -1.64758578e-01f,
  1.40582070e-01f, 1.97966635e-01f, 1.23197816e-01f, 8.61641914e-02f, 4.74178977e-03f, -5.16912714e-03f, -8.31756443e-02f, -1.13237128e-02f, -1.82004366e-02f, -6.88172057e-02f,
  8.19470659e-02f, 9.93353203e-02f, -1.84266299e-01f, -1.09807039e-02f, -1.04200669e-01f, 6.47952631e-02f, 1.15935266e-01f, -8.84621963e-02f, -4.13534380e-02f, -6.33687675e-02f,
  1.31834954e-01f, 5.17645240e-01f, 2.07501963e-01f, -1.67024937e-02f, -6.88224062e-02f, -2.20128015e-01f, -2.62990370e-02f, -5.45238405e-02f, -1.34656176e-01f, -5.37635274e-02f,
  -2.08852828e-01f, -1.08079977e-01f, -1.61396518e-01f, -1.03996471e-01f, -3.57473530e-02f, -1.52514637e-01f, -1.44027308e-01f, 1.35931000e-01f, 1.38049588e-01f, -7.78203607e-02f,
  -1.99797928e-01f, 9.00990143e-02f, 2.98755288e-01f, 1.93916529e-01f, 1.17947988e-01f, 2.94809282e-01f, -1.22268371e-01f, -5.77433333e-02f, 1.73914775e-01f, -1.27726216e-02f,
  -7.71896482e-01f, 6.36682630e-01f, 4.36589122e-01f, -1.71340883e-01f, 5.08411109e-01f, 6.62030518e-01f, 9.78203714e-01f, 2.75586575e-01f, -4.43888098e-01f, 8.16711411e-02f,
  2.37445563e-01f, -5.15019000e-01f, -2.21780092e-01f, -2.84618884e-01f, 6.84751794e-02f, 3.85150760e-01f, 3.20541143e-01f, -2.65331209e-01f, -3.03815633e-01f, -3.29713039e-02f,
  8.89159516e-02f, -3.09476644e-01f, -5.73123217e-01f, -3.51442575e-01f, -1.14234902e-01f, -3.73718292e-01f, 1.73758529e-02f, 1.05640508e-01f, 3.77035648e-01f, -2.02425241e-01f,
  -2.02815861e-01f, 3.92243266e-01f, -2.42028251e-01f, -4.10890281e-01f, 1.81391276e-02f, -4.17557746e-01f, -1.71277523e-01f, -3.38144749e-01f, -2.79197320e-02f, -1.10874131e-01f,
  4.40996215e-02f, -7.03937858e-02f, 7.65036270e-02f, 4.88408469e-02f, 7.84537345e-02f, 9.83211622e-02f, -1.45401597e-01f, -4.58301269e-02f, -1.64910048e-01f, 3.07925232e-02f,
  1.79689124e-01f, 2.47546524e-01f, 3.42498273e-01f, 3.46906751e-01f, 1.28552601e-01f, -2.21995160e-01f, 2.52434134e-01f, 3.58196534e-02f, 4.66570556e-02f, -3.72157574e-01f,
  -2.01210752e-01f, 1.52274752e-02f, 2.48895913e-01f, -1.60783187e-01f, -1.17186122e-02f, 3.35637294e-03f, -5.85722513e-02f, 1.80803418e-01f, 9.17325094e-02f, 9.94910719e-04f,
  5.60292341e-02f, -6.90979464e-03f, -2.53318716e-02f, 7.72255585e-02f, -1.61785752e-01f, 6.19610436e-02f, 1.60431013e-01f, -7.71488762e-04f, 5.32020181e-02f, 8.93192589e-02f,
  3.51426490e-02f, 1.29377842e-01f, -3.46061736e-02f, 1.39489964e-01f, 3.77845056e-02f, -6.74603432e-02f, -1.57553807e-01f, -3.10076941e-02f, -1.53527886e-01f, -8.25202465e-02f,
  -3.96628439e-01f, 5.40512323e-01f, -3.34950984e-01f, -7.50425011e-02f, 1.32551804e-01f, -1.05382465e-01f, 5.39954156e-02f, -4.59669568e-02f, 4.23076674e-02f, -7.09144473e-02f,
  1.01680279e-01f, -2.03989029e-01f, 1.12083703e-01f, 4.04269882e-02f, -2.00327158e-01f, -1.20089784e-01f, 1.08965971e-01f, 3.91220078e-02f, -3.68775837e-02f, -4.59345393e-02f,
  -1.62941273e-02f, -1.59237925e-02f, -3.46145242e-01f, -1.69359058e-01f, -1.87363386e-01f, -4.25089628e-01f, 6.50530076e-03f, -8.90291855e-02f, -8.11094865e-02f, -3.59534115e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.15629089e+00f, 3.99955630e-01f, 1.01491892e+00f, 8.21881950e-01f, 4.86786246e-01f, 4.80835378e-01f, 3.70736390e-01f, 6.82599843e-02f, 4.18022960e-01f, 8.55972707e-01f,
  9.01717007e-01f, 4.84836370e-01f, 1.06272876e+00f, 5.53073049e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.49061099e-01f, -9.48579311e-02f, 5.33971846e-01f, 2.02238992e-01f, 3.66435230e-01f, 6.41620979e-02f, -5.13700880e-02f, -3.29048693e-01f, 8.55270624e-02f, -3.52949113e-01f,
  -1.68537378e-01f, 4.52059180e-01f, -2.20831241e-02f, -4.61457044e-01f, 3.97408642e-02f, -1.54953599e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -1.61899820e-01f, 4.48693521e-02f, 1.16550469e+00f, 3.64378035e-01f, -7.22605646e-01f, -4.77483571e-01f, -1.75431937e-01f, 6.33772075e-01f, -2.04798996e-01f, 2.49434769e-01f,
  9.62814867e-01f, 1.22396991e-01f, -1.82451352e-01f, -2.04881936e-01f, 4.54479665e-01f, 5.16336977e-01f, 3.92821521e-01f, 3.82908314e-01f, -1.27234101e-01f, 2.80364096e-01f,
  6.07396007e-01f, 9.61850166e-01f, 4.27954674e-01f, -5.70446074e-01f, -3.81616235e-01f, -7.11335242e-02f, -2.34902382e-01f, 2.37284169e-01f, 5.93185008e-01f, -2.07480788e-01f,
  -4.20198068e-02f, -4.97576892e-02f, 2.26831660e-01f, -1.54983893e-01f, 8.18416119e-01f, 6.51225984e-01f, 5.63970685e-01f, -6.47227705e-01f, 5.03988445e-01f, 1.73981354e-01f,
  1.44315124e+00f, -2.60028958e-01f, 5.39637923e-01f, -8.79044533e-01f, -4.22989279e-02f, 8.20652675e-03f, 3.79173666e-01f, -3.61063331e-01f, 4.70286101e-01f, 5.41510694e-02f,
  4.19861346e-01f, 4.86022353e-01f, 4.52478565e-02f, -5.51679194e-01f, 6.01385713e-01f, 4.36581701e-01f, -3.83109376e-02f, 4.23942059e-02f, 9.98216122e-02f, 8.27031136e-01f,
  4.56394911e-01f, -1.73218355e-01f, -8.11161399e-01f, -3.35405707e-01f, -5.51565364e-02f, -2.15505242e-01f, 1.36465400e-01f, 7.00604618e-01f, 5.86012244e-01f, -1.95337087e-01f,
  7.92277604e-03f, 4.49353069e-01f, -2.26634324e-01f, 3.46837193e-01f, 2.09952086e-01f, 2.66906589e-01f, -6.87931240e-01f, 4.80926245e-01f, -8.14697325e-01f, 9.11050260e-01f,
  1.67820215e-01f, -6.49880543e-02f, -2.25247234e-01f, -1.60599217e-01f, 1.83290362e-01f, 1.06156743e+00f, -6.16734147e-01f, 4.19182181e-01f, -1.86337069e-01f, 4.51607972e-01f,
  -1.28655031e-01f, 1.79509558e-02f, 5.72633684e-01f, -1.47090316e-01f, 4.76077050e-01f, -5.56459069e-01f, 2.25744739e-01f, 2.73542758e-02f, 6.81702495e-02f, -4.23465908e-01f,
  3.99762154e-01f, -3.40081118e-02f, -4.42879617e-01f, 7.52941728e-01f, 1.65562347e-01f, -7.44501293e-01f, 7.50805676e-01f, 1.02087569e+00f, 4.42197233e-01f, -1.54671684e-01f,
  1.15733951e-01f, 1.27102292e+00f, 6.69602305e-02f, -1.19237207e-01f, -2.46956125e-01f, 9.39688385e-01f, 4.42483783e-01f, 2.03022942e-01f, -2.37271950e-01f, 3.81898314e-01f,
  -1.92887440e-01f, 5.62927246e-01f, -6.72501802e-01f, -4.42037642e-01f, 3.44694018e-01f, 3.86055410e-01f, 2.98671246e-01f, 5.48074186e-01f, -5.06928451e-02f, 6.16106205e-02f,
  8.40446651e-01f, -4.98636917e-04f, 5.85007668e-02f, 9.88196790e-01f, 1.14566773e-01f, -2.61258513e-01f, -6.75112247e-01f, -2.24546000e-01f, -5.28549636e-03f, 6.09220862e-01f,
  4.36970145e-01f, -2.92099386e-01f, 5.12093842e-01f, 1.03208232e+00f, -2.89695740e-01f, 1.72252595e-01f, -1.44310191e-01f, 1.22319683e-01f, -7.60287762e-01f, -6.02873079e-02f,
  9.40460682e-01f, 6.15525842e-01f, -5.50568581e-01f, 6.78877234e-01f, 2.28397697e-01f, -9.01903287e-02f, 6.02587461e-01f, 5.38356960e-01f, 6.04468048e-01f, -8.33613947e-02f,
  -4.66637723e-02f, -1.57735646e-01f, -9.02719021e-01f, -7.80319571e-01f, 7.07066834e-01f, -3.36964093e-02f, -2.97027469e-01f, 2.65516460e-01f, 8.06740820e-01f, 2.69662421e-02f,
  -7.62280107e-01f, 4.10000026e-01f, 2.81011254e-01f, 6.98914349e-01f, 1.58173412e-01f, 4.23656285e-01f, 4.84302789e-01f, 3.90670657e-01f, 8.36493611e-01f, 3.14447373e-01f,
  4.52673852e-01f, 8.40447307e-01f, 1.11568689e+00f, -7.61162102e-01f, -2.97452092e-01f, -3.31666507e-02f, 1.73180014e-01f, -4.68898676e-02f, 1.73733264e-01f, -1.81166828e-01f,
  -3.24945599e-01f, 1.54530749e-01f, -2.35565230e-02f, -1.17954351e-01f, -2.51644284e-01f, 7.26608038e-01f, 7.11120665e-01f, 3.80292833e-01f, -6.62263513e-01f, 2.99332559e-01f,
  -5.47675908e-01f, 3.88824075e-01f, 3.60110030e-02f, 7.35991895e-01f, -6.12256587e-01f, -4.59167808e-01f, 6.06006831e-02f, -6.74824640e-02f, 3.02532941e-01f, -3.04402947e-01f,
  2.62120277e-01f, 1.00018108e+00f, 3.59785765e-01f, -2.99470216e-01f, 2.04109445e-01f, -6.96819603e-01f, -3.15993011e-01f, -6.73264086e-01f, -8.05758834e-01f, 9.11749005e-01f,
  1.58895269e-01f, -6.80796146e-01f, 5.41030407e-01f, 3.45149755e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -1.03191495e-01f, 6.49109840e-01f, 7.27149546e-01f, 6.71678632e-02f, 8.52254927e-02f, 8.24761927e-01f, -5.59908189e-02f, 2.99983352e-01f, 3.65133956e-02f, 2.23722383e-01f,
  4.02551740e-01f, 2.78379917e-01f, 2.69042291e-02f, 4.98786084e-02f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -7.70954967e-01f, -1.87351763e-01f, 1.60197303e-01f, -5.69614649e-01f, -5.79752922e-01f, 3.24648112e-01f, 4.58004922e-01f, 1.59294307e-01f, -3.89177769e-01f, -1.77716911e-01f,
  -7.75606215e-01f, 3.89443249e-01f, -4.57477033e-01f, -5.37676811e-01f, 8.93364847e-01f, -3.24271232e-01f, -1.02578111e-01f, -6.66583538e-01f, -1.25216782e-01f, -7.35233054e-02f,
  -4.67824012e-01f, -2.09120110e-01f, -8.23475122e-01f, 5.87771714e-01f, -7.50113577e-02f, 3.95441085e-01f, -1.30518168e-01f, 4.60632592e-01f, 4.93502170e-01f, -1.17416084e+00f,
  -2.27553889e-01f, -5.05885839e-01f, 4.10799533e-01f, -1.57806829e-01f, 3.06617141e-01f, -7.86328256e-01f, 7.33070016e-01f, -1.34230569e-01f, -4.72379237e-01f, 3.22198987e-01f,
  8.29143226e-01f, -6.24246895e-01f, -1.25097454e+00f, -2.69793183e-01f, -5.23002446e-01f, -5.54776967e-01f, -3.50066900e-01f, -7.99401164e-01f, -3.76235962e-01f, 1.48934856e-01f,
  5.35418868e-01f, -3.65888923e-01f, -7.92613328e-01f, 2.70801723e-01f, -1.94425751e-02f, -5.33673942e-01f, 7.81907022e-01f, -1.68472433e+00f, 3.89106750e-01f, -2.37565085e-01f,
  -3.96512419e-01f, 1.11396007e-01f, -1.62905037e-01f, -5.45822859e-01f, 2.14275643e-01f, -1.36606753e-01f, 2.52564639e-01f, -3.24362040e-01f, 3.72614264e-01f, -1.79909207e-02f,
  -1.83179632e-01f, -3.32234919e-01f, -1.27892447e+00f, -5.17942071e-01f, -2.09783390e-01f, 5.79629838e-01f, -6.21160194e-02f, 5.32866120e-01f, -7.70247877e-01f, -5.19406796e-02f,
  7.72213995e-01f, 5.79636395e-01f, -6.38772249e-01f, 7.69911647e-01f, -6.94035828e-01f, -2.68697172e-01f, -6.25168383e-01f, 6.64488733e-01f, -1.36400425e+00f, -1.63139567e-01f,
  3.38682771e-01f, -1.65168568e-01f, -6.73479617e-01f, 5.45600951e-01f, -6.16914444e-02f, -2.43290886e-01f, 6.39002979e-01f, 4.27972972e-01f, -9.43375111e-01f, -3.11315775e-01f,
  7.08099902e-01f, -7.68189967e-01f, -7.46648246e-03f, -3.51998776e-01f, -9.12750542e-01f, -2.15612397e-01f, -9.02507544e-01f, -8.41854930e-01f, 8.41187418e-01f, -3.73923928e-01f,
  -8.95937860e-01f, -1.02811575e+00f, -4.33341771e-01f, 5.40517569e-01f, 5.37075162e-01f, -8.38041008e-01f, -3.42761308e-01f, -1.12875760e+00f, 9.16624293e-02f, -1.46484032e-01f,
  -1.88370138e-01f, 2.93288082e-01f, 5.15674531e-01f, -6.07726276e-02f, -7.63206899e-01f, -3.14682096e-01f, 2.03697849e-02f, 6.20729685e-01f, -8.28202367e-01f, 4.74558771e-01f,
  -8.48591566e-01f, 1.73436508e-01f, -6.54681861e-01f, -4.87342387e-01f, -5.92436254e-01f, 2.23379225e-01f, 4.54313457e-01f, -3.88241380e-01f, 2.40581155e-01f, -8.72479796e-01f,
  2.74135768e-01f, -8.96271616e-02f, 7.91514218e-01f, 5.61897993e-01f, -2.10049286e-01f, 4.62438166e-01f, -9.30325508e-01f, 3.32496107e-01f, 3.44018430e-01f, 3.20851833e-01f,
  2.57463276e-01f, -6.32539451e-01f, -1.26517737e+00f, 3.82733047e-01f, -1.27209389e+00f, -9.30197537e-01f, -4.58349049e-01f, 3.59669745e-01f, 5.18020570e-01f, 8.73934090e-01f,
  -7.02468514e-01f, 5.11917591e-01f, -7.18951762e-01f, 3.04470748e-01f, -1.23173380e+00f, 7.30696142e-01f, -1.10340810e+00f, -4.16485846e-01f, 2.09795535e-01f, -9.62702274e-01f,
  4.47676815e-02f, 2.19506055e-01f, 9.82008874e-02f, 1.78909630e-01f, -1.24788237e+00f, 7.68067837e-01f, -3.41747522e-01f, -3.93980712e-01f, -5.79654992e-01f, -2.14999944e-01f,
  -7.04021335e-01f, -6.40382946e-01f, 8.65845978e-01f, -1.04758179e+00f, 9.22809184e-01f, 2.36974955e-01f, -5.83902746e-02f, -4.27596360e-01f, 4.18447435e-01f, -4.80544269e-01f,
  -1.00275755e-01f, -7.79520094e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  5.48060648e-02f, 5.10979034e-02f, 2.30959550e-01f, -8.83988917e-01f, 2.47046262e-01f, 2.61904776e-01f, 4.83068556e-01f, -6.09856784e-01f, -4.10470843e-01f, -7.18270382e-03f,
  -7.04726517e-01f, -3.47429901e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    