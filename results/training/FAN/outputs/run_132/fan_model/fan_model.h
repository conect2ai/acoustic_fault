/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.92503095e-01f, 1.67420983e-01f, -1.09280862e-01f, 1.33133680e-01f, 2.32658964e-02f, 1.42173111e-01f, 6.65703043e-02f, 1.65842205e-01f, 1.12511426e-01f, -6.62149535e-03f,
  2.28371043e-02f, 7.99331889e-02f, -2.82874797e-02f, 8.15836564e-02f, 3.25892806e-01f, 4.31036241e-02f, 1.38823897e-01f, 5.58269136e-02f, -4.33611907e-02f, 1.53028250e-01f,
  -1.25207924e-04f, 1.41570672e-01f, -7.45451497e-03f, -1.61350712e-01f, 2.17940211e-02f, -1.80688098e-01f, -1.27607495e-01f, -1.17215477e-01f, -1.21545023e-03f, -4.66879718e-02f,
  1.23722851e-01f, 1.30456582e-01f, 5.37279770e-02f, -4.65024710e-02f, 4.22790535e-02f, -8.68135169e-02f, -4.99740290e-03f, -3.59913372e-02f, 2.63189226e-02f, 1.06581319e-02f,
  -7.50782788e-02f, 5.42515442e-02f, 3.15712020e-02f, -2.62281150e-02f, -3.04538254e-02f, 3.04869600e-02f, -3.69404033e-02f, -1.20356828e-01f, 2.31416225e-02f, 5.96880317e-02f,
  1.92288868e-02f, 3.48068215e-02f, -5.67832850e-02f, -5.96963502e-02f, -1.40009388e-01f, -5.33252954e-02f, -1.50927052e-01f, -1.32977009e-01f, 8.50428566e-02f, -2.11181045e-02f,
  6.48406371e-02f, 1.64496582e-02f, -3.88842970e-02f, 1.93120595e-02f, 6.71105087e-02f, 4.57777493e-02f, -5.36862612e-02f, -9.34631098e-03f, -3.15319858e-02f, 8.86500552e-02f,
  2.78421286e-02f, 8.08856916e-03f, -5.09478673e-02f, 2.68222876e-02f, -5.01642562e-02f, 4.10865173e-02f, -2.32472084e-02f, -8.72551929e-03f, -8.88667032e-02f, -2.80559920e-02f,
  3.38669233e-02f, 1.62966400e-02f, -5.38189821e-02f, -9.48430747e-02f, 1.28760198e-02f, 1.79417524e-02f, -4.49508466e-02f, -7.01352581e-03f, 5.54500408e-02f, -8.09691381e-03f,
  2.09132135e-01f, 6.70575723e-02f, 7.04267547e-02f, 3.19048390e-02f, -2.36129705e-02f, -1.01692304e-01f, -6.27598464e-02f, -2.66307257e-02f, -3.48567106e-02f, -1.17335822e-02f,
  -3.09808226e-03f, -1.01140782e-01f, 9.99936089e-03f, -7.63244880e-03f, 2.09555104e-02f, -9.74754803e-03f, 7.69848004e-02f, 5.86052351e-02f, -4.39854078e-02f, 8.37910846e-02f,
  -5.41704558e-02f, -2.79365778e-02f, -3.11403293e-02f, -5.87034896e-02f, -1.08294092e-01f, 2.50391825e-03f, -3.60357389e-02f, -1.01574495e-01f, -1.56732984e-02f, -2.24674447e-03f,
  -4.10637766e-01f, 1.24907441e-01f, 1.75945625e-01f, -6.06562011e-02f, 4.38418239e-02f, 1.31840155e-01f, 4.59776260e-02f, 3.27385478e-02f, -5.97216822e-02f, 2.21182272e-01f,
  -6.18194379e-02f, 6.01705573e-02f, -6.40823394e-02f, 8.94423425e-02f, -2.98008680e-01f, -6.13359995e-02f, 9.95412990e-02f, 6.84797466e-02f, -7.41596445e-02f, -1.24702200e-01f,
  -2.29694948e-01f, 7.79883005e-03f, -7.94302300e-02f, 6.67071491e-02f, 8.42502639e-02f, 2.13805959e-03f, -1.05945215e-01f, 7.34473346e-04f, -1.42062893e-02f, -4.33339775e-02f,
  1.68900262e-03f, -6.63457718e-03f, -4.20856150e-03f, 3.41127906e-03f, -3.00241876e-02f, -8.89475923e-03f, 5.90455811e-03f, -2.95412578e-02f, -4.65708673e-02f, -3.20122689e-02f,
  3.96633558e-02f, -1.65906269e-02f, 1.27403438e-01f, -5.29581457e-02f, 1.22496501e-01f, 3.96470279e-02f, 9.67595577e-02f, 6.84927851e-02f, -6.01479970e-02f, 1.98641066e-02f,
  -4.74205986e-02f, 1.10137597e-01f, 1.79466940e-02f, 2.35644132e-02f, 5.28849140e-02f, -2.42503593e-03f, -5.76224551e-02f, 2.79719830e-02f, 7.25593641e-02f, -8.54625851e-02f,
  -3.57150286e-02f, 7.32044801e-02f, -5.26909046e-02f, 2.61923168e-02f, -5.60691766e-02f, 3.14230882e-02f, -4.92901448e-03f, -1.49805984e-02f, -7.46780708e-02f, -2.81135347e-02f,
  -7.35308183e-03f, -1.14227884e-01f, 6.33809017e-03f, -3.62160280e-02f, -3.01819034e-02f, -5.57559952e-02f, 2.03991942e-02f, -4.57968153e-02f, 1.43048754e-02f, 9.65650566e-03f,
  5.00697196e-02f, 1.27926264e-02f, -5.09836562e-02f, 1.30576223e-01f, 4.21352647e-02f, -4.88258675e-02f, 4.05523069e-02f, -1.77571867e-02f, -7.57157849e-03f, 5.23694139e-03f,
  -2.95381760e-03f, -6.70574456e-02f, 3.93490531e-02f, 4.13556360e-02f, 1.48148136e-02f, -1.40990512e-02f, 7.21289143e-02f, 8.73334184e-02f, 3.57706263e-03f, -6.75654188e-02f,
  -7.92399142e-03f, 7.15422034e-02f, 9.13320929e-02f, 7.87352864e-03f, 1.26186088e-02f, 9.70090646e-03f, -6.44086823e-02f, -5.54804057e-02f, 5.29316105e-02f, 6.26996830e-02f,
  1.09577037e-01f, 1.36237100e-01f, -5.21752201e-02f, 1.04222558e-02f, 4.20412906e-02f, 1.62609145e-02f, -5.53383259e-03f, -3.25666741e-02f, 2.11539902e-02f, -5.15452633e-03f,
  -1.25418559e-01f, -8.29622746e-02f, 1.32105842e-01f, -1.53152779e-01f, -9.61948335e-02f, 3.48081440e-02f, 4.36773598e-02f, -2.20482796e-01f, -8.94399434e-02f, -1.46140382e-01f,
  1.08406022e-01f, 4.97967005e-02f, 1.93506554e-01f, 2.26840787e-02f, 8.92788544e-02f, 3.73993874e-01f, -1.51314750e-01f, -2.64910683e-02f, 1.09286956e-01f, -1.83256015e-01f,
  -4.20057178e-02f, -2.17394784e-01f, 4.84189652e-02f, -1.73431173e-01f, -1.37914836e-01f, 4.07638215e-02f, -1.30921721e-01f, 2.03595623e-01f, -1.10143974e-01f, -1.83913298e-02f,
  -1.38856277e-01f, 2.86364369e-03f, 1.26320161e-02f, 9.41085629e-03f, -3.35153118e-02f, -2.80889366e-02f, 5.35649881e-02f, 8.17470849e-02f, 8.06566700e-02f, 2.33714506e-02f,
  -1.82526559e-02f, 5.71913719e-02f, -9.82934684e-02f, 2.51813773e-02f, -3.96239050e-02f, 5.91862351e-02f, 3.36724110e-02f, -1.75002236e-02f, -6.53676242e-02f, 5.64059727e-02f,
  7.40883574e-02f, 1.80279557e-03f, -4.50835377e-03f, 4.43536751e-02f, 9.32049453e-02f, 2.45115403e-02f, -2.39740182e-02f, 5.03173359e-02f, 1.37908431e-02f, -5.75474426e-02f,
  3.93261574e-02f, -6.61554933e-02f, -1.41492928e-03f, -2.99638622e-02f, -2.41059363e-02f, -2.59408094e-02f, 7.22112134e-02f, 3.95477898e-02f, -5.52449524e-02f, -5.83180785e-02f,
  -1.15184225e-01f, 1.06868371e-02f, 6.02130145e-02f, 3.62148806e-02f, 1.55211613e-02f, -1.07618541e-01f, 5.13583012e-02f, 3.12864110e-02f, -3.05875912e-02f, -3.20435464e-02f,
  -3.35325077e-02f, 2.69661687e-04f, -8.20967660e-04f, -2.25034151e-02f, 8.29990581e-02f, -1.79269891e-02f, 4.50910479e-02f, -2.96496488e-02f, 3.38063873e-02f, 3.60245593e-02f,
  -2.01890036e-01f, -2.22017705e-01f, 4.62099258e-03f, 1.78225785e-02f, 1.59995314e-02f, 3.14444639e-02f, 1.16522824e-02f, 1.50670642e-02f, 1.03516936e-01f, 3.23279984e-02f,
  5.52909262e-02f, -7.17090443e-02f, 2.16042679e-02f, -2.14200951e-02f, 3.85571048e-02f, 9.31853428e-02f, -1.01413630e-01f, -3.20984274e-02f, 7.65438983e-03f, -2.99310200e-02f,
  -8.74512196e-02f, 1.66683476e-02f, 6.40060902e-02f, -3.24901417e-02f, -4.92282547e-02f, -1.99796353e-03f, -8.20324942e-02f, 1.33291304e-01f, 3.86316585e-03f, 8.99329409e-03f,
  -1.18258268e-01f, 3.69916074e-02f, -1.15791574e-01f, 2.83368379e-02f, 3.69779021e-02f, 4.46220845e-01f, 3.72036517e-01f, 5.45649678e-02f, 1.76866964e-01f, 1.48524538e-01f,
  8.51128846e-02f, -2.21490022e-02f, -8.80417898e-02f, 1.94324195e-01f, 1.01812132e-01f, 1.62498772e-01f, 2.34276116e-01f, 3.04245614e-02f, 8.63055065e-02f, -1.40562188e-02f,
  -7.44768977e-02f, 1.35509312e-01f, -4.62975651e-02f, -1.98874362e-02f, -5.76847382e-02f, -1.49274185e-01f, -8.30292180e-02f, -1.31677836e-01f, -3.93760763e-02f, 2.84611154e-02f,
  1.96241498e-01f, -5.48386155e-03f, -3.36866826e-03f, 1.95331033e-02f, -4.92185690e-02f, -2.73326281e-02f, 4.16619144e-02f, 1.82591267e-02f, -1.08058609e-01f, 3.40855308e-02f,
  1.31277507e-02f, -1.07536558e-02f, 7.22682551e-02f, 3.29019353e-02f, 2.07359530e-02f, -4.79502603e-02f, -1.74972713e-02f, 6.88783228e-02f, -8.82262923e-03f, -4.38010730e-02f,
  3.47204171e-02f, 6.68978170e-02f, 3.09402738e-02f, 7.68027008e-02f, -8.66046771e-02f, -9.37197171e-03f, 4.77549946e-03f, 7.16538057e-02f, 2.00146139e-02f, 5.87741286e-02f,
  1.89756658e-02f, -4.80879052e-03f, 9.11322683e-02f, -5.93744591e-02f, 1.56594086e-02f, 3.00656520e-02f, 3.80414934e-03f, 1.23090867e-03f, -2.02230029e-02f, -1.44059416e-02f,
  3.04764099e-02f, -3.68941179e-03f, 3.09276637e-02f, -5.35226380e-03f, 3.65529247e-02f, 3.08991447e-02f, -9.25910026e-02f, -3.06938868e-02f, 1.65951177e-02f, 6.30575418e-02f,
  -3.34966779e-02f, -2.98686847e-02f, 3.56500521e-02f, -3.99099588e-02f, -9.49615762e-02f, -1.13677504e-02f, -2.85641272e-02f, 2.01711282e-02f, -8.75759944e-02f, 1.09672286e-02f,
  3.14808153e-02f, -4.87607382e-02f, 6.28094450e-02f, 5.00124879e-02f, -6.38881996e-02f, 7.24832639e-02f, -8.70794896e-03f, 8.79587233e-03f, -6.33144155e-02f, 2.80365590e-02f,
  -4.11320776e-02f, 9.17576626e-02f, -3.89696024e-02f, 7.17567950e-02f, -8.33993256e-02f, 1.48638293e-01f, -5.36265820e-02f, -1.23881111e-02f, -2.29657069e-02f, -2.66090427e-02f,
  -5.59139177e-02f, 4.79299687e-02f, -6.01166347e-03f, -2.74558775e-02f, 3.07873217e-03f, -9.00559053e-02f, 8.21391307e-03f, -6.96366280e-02f, -3.18952091e-02f, -1.36178751e-02f,
  1.02249652e-01f, 1.04004338e-01f, -3.33437249e-02f, 2.64868438e-01f, -8.45968276e-02f, 2.08433941e-01f, 1.31975025e-01f, -1.68025363e-02f, -1.07434496e-01f, 5.71667915e-03f,
  1.12329260e-01f, -3.72062624e-02f, -8.59491974e-02f, 2.94170856e-01f, 1.14944048e-01f, 4.08727415e-02f, 3.63244712e-01f, 1.11000419e-01f, -2.42076106e-02f, 1.08698579e-02f,
  1.04194097e-02f, 1.13531120e-01f, 4.48353142e-02f, -8.27930346e-02f, 1.41029313e-01f, -2.53233127e-02f, 3.23085450e-02f, -1.26893267e-01f, 1.33104652e-01f, -1.44494757e-01f,
  6.46888912e-02f, -1.08436972e-01f, -4.24051024e-02f, 2.22252580e-04f, 6.58688769e-02f, 7.16943145e-02f, 7.64854029e-02f, 2.19559576e-02f, -7.34778568e-02f, 2.18888349e-03f,
  -1.38707524e-02f, -3.86667922e-02f, -2.46215891e-02f, 1.27625298e-02f, -3.96935120e-02f, -1.64346080e-02f, -3.83629389e-02f, -4.85298373e-02f, -7.09537864e-02f, -1.33354580e-02f,
  1.47506967e-02f, -1.20119983e-02f, 9.95111987e-02f, -9.04544070e-03f, 1.93698481e-02f, -6.61671236e-02f, -6.95291534e-02f, 3.74192744e-02f, 1.24503030e-02f, -7.94982910e-02f,
  -2.18819920e-02f, 2.38497518e-02f, 1.34083882e-01f, 2.15459540e-02f, 7.64689757e-04f, 5.69718005e-03f, 5.77749275e-02f, -6.98930547e-02f, -5.87390177e-02f, -6.02253526e-02f,
  4.70358785e-03f, 3.54987290e-03f, 6.43321052e-02f, 3.15321349e-02f, 8.08695108e-02f, -3.27215865e-02f, -3.24986652e-02f, -1.04695912e-02f, 5.23057692e-02f, -4.02484322e-03f,
  -1.50581188e-02f, -5.54720685e-02f, -7.13261738e-02f, 8.91470760e-02f, -4.97194799e-03f, 5.63108660e-02f, 4.30078693e-02f, 2.23974455e-02f, 7.38687664e-02f, -4.82950285e-02f,
  -6.49210019e-03f, 4.68061902e-02f, -3.91048379e-02f, -4.23687277e-03f, -5.96353039e-02f, 3.40211880e-03f, 1.22137810e-03f, -4.86919619e-02f, -5.14412206e-03f, -5.03853559e-02f,
  6.62422851e-02f, 1.50454964e-03f, 4.55086939e-02f, -3.84021201e-03f, -8.87130573e-03f, 1.79440826e-02f, 2.05019563e-02f, -1.93629321e-02f, 6.62047938e-02f, 1.50341950e-02f,
  -5.38188256e-02f, 3.32115665e-02f, -1.01116821e-01f, -7.51621127e-02f, -5.59754111e-02f, -2.19803564e-02f, -1.79225039e-02f, -2.01341342e-02f, -3.99492718e-02f, 6.32837880e-03f,
  -1.90238446e-01f, 6.75649419e-02f, -1.57184154e-01f, 1.57902360e-01f, -1.05806455e-01f, 1.81652591e-01f, 2.19984189e-01f, -1.30130386e-03f, 6.89959601e-02f, 1.10823169e-01f,
  5.34391729e-03f, -3.23979221e-02f, -8.04179683e-02f, 2.20249295e-01f, 1.54121235e-01f, 1.74278244e-01f, 2.54546821e-01f, 9.68967900e-02f, 1.02924682e-01f, -2.15857439e-02f,
  -3.84343565e-02f, 1.74324945e-01f, -2.71926750e-03f, 3.85495573e-02f, -6.42038435e-02f, 5.21524693e-04f, -7.40563264e-03f, 1.00130942e-02f, 3.51807922e-02f, -4.22824733e-02f,
  -1.38150156e-01f, -2.09050149e-01f, -1.05080239e-01f, 5.17298328e-03f, -7.83258751e-02f, -2.34819539e-02f, -6.25546649e-02f, -5.09177260e-02f, -9.31257308e-02f, -1.04507133e-02f,
  -7.47602433e-02f, 1.74646489e-02f, 1.87647995e-02f, 1.91731453e-02f, -8.30043014e-03f, 1.42092835e-02f, 1.79170109e-02f, 4.71372157e-02f, 5.68571873e-02f, 1.22156385e-02f,
  8.39643255e-02f, 3.53938118e-02f, 9.03171152e-02f, 9.88605022e-02f, 4.27669100e-02f, 5.09230718e-02f, 2.22933572e-02f, 1.83131061e-02f, 8.31123069e-02f, 2.80874111e-02f,
  -1.18357660e-02f, -1.96646247e-02f, -1.25898020e-02f, -1.15163093e-02f, 7.17038810e-02f, 1.60762351e-02f, -4.61149141e-02f, 1.03949262e-02f, 7.95957148e-02f, 5.88523448e-02f,
  6.34348318e-02f, -8.01037103e-02f, 2.23583393e-02f, 2.07107831e-02f, 3.19251195e-02f, -1.09035941e-02f, 1.02684256e-02f, 1.52478758e-02f, 1.25603423e-01f, 8.08839453e-04f,
  -9.49319638e-03f, -1.42621426e-02f, 2.82545900e-03f, 2.73881163e-02f, 1.37874056e-02f, 3.79547738e-02f, 1.36759534e-01f, 6.87379465e-02f, 8.01471621e-03f, -1.66777223e-02f,
  3.40707190e-02f, -1.36465937e-01f, -8.96281097e-03f, -6.86717639e-03f, -4.91066836e-02f, 3.37486342e-02f, -1.30733773e-01f, -4.80084168e-03f, 1.66857969e-02f, 5.25780628e-03f,
  -3.89086418e-02f, 3.10282651e-02f, -1.91204704e-03f, 4.45039803e-03f, -1.76348649e-02f, -3.67520787e-02f, 5.22302464e-02f, 4.30894159e-02f, -5.98320737e-03f, -3.59393563e-03f,
  -3.02016418e-02f, -1.96598154e-02f, 3.09505668e-02f, -2.04907991e-02f, -6.53122226e-03f, 1.25288405e-02f, -6.19959570e-02f, 6.40977919e-02f, 4.36805338e-02f, 2.77592950e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.42693564e-01f, 7.07897469e-02f, -1.23308845e-01f, -1.55785561e-01f, 5.66343926e-02f, -4.00932014e-01f, -1.94939196e-01f, 2.89124735e-02f, -1.17033884e-01f, 1.03864893e-01f,
  -5.93346879e-02f, -1.45535439e-01f, 3.20624188e-02f, -3.42987567e-01f, -2.55349666e-01f, -9.46020707e-02f, -2.92422682e-01f, -2.24965721e-01f, -7.41590783e-02f, -9.66523811e-02f,
  -1.92733854e-01f, -3.79432887e-02f, -2.08849505e-01f, 7.67991170e-02f, -1.53271019e-01f, -2.15013027e-02f, 2.36492261e-01f, 6.31038845e-03f, -5.85296117e-02f, -4.29503433e-03f,
  -1.65202290e-01f, -4.71768752e-02f, -1.19486563e-02f, -8.39143544e-02f, -7.37084895e-02f, -3.81384753e-02f, -5.22990637e-02f, -3.60348821e-02f, -6.37116730e-02f, -5.64464405e-02f,
  -6.13709353e-02f, -8.04550648e-02f, -3.40074785e-02f, 5.99010289e-02f, -4.77304533e-02f, 3.19597125e-02f, -7.14922547e-02f, 3.66983726e-03f, -1.19973689e-01f, -1.38279423e-01f,
  -1.00709759e-01f, -8.08455795e-02f, -6.67337403e-02f, 3.91028486e-02f, -5.73905334e-02f, 4.19891402e-02f, -6.17691241e-02f, 7.38046616e-02f, 1.45577835e-02f, -2.51985099e-02f,
  4.15869318e-02f, -3.74436714e-02f, -2.97537409e-02f, -2.65646167e-02f, -1.09877372e-02f, 1.77368224e-02f, 3.42041776e-02f, -5.44277318e-02f, 9.03567895e-02f, 7.54401907e-02f,
  6.41876692e-03f, -3.03560533e-02f, 5.17639630e-02f, 1.80132333e-02f, -4.70397845e-02f, 2.69001406e-02f, -4.34737988e-02f, 2.36587804e-02f, -9.27956328e-02f, 1.20638376e-02f,
  2.06806650e-03f, -2.21370850e-02f, -2.97268014e-03f, 5.33323660e-02f, 4.32398953e-02f, 5.97863868e-02f, 1.41470237e-02f, 4.05487493e-02f, -1.75465122e-02f, 1.56860594e-02f,
  7.23345950e-02f, 1.58826992e-01f, -4.93103154e-02f, 2.86122616e-02f, -2.94592269e-02f, -5.57886958e-02f, -3.63467373e-02f, 4.29358296e-02f, -3.45532782e-02f, 1.17648775e-02f,
  -3.13007012e-02f, 3.25418375e-02f, 4.37126383e-02f, 1.00845275e-02f, -2.91155782e-02f, 3.08674183e-02f, 4.82897572e-02f, 4.95308861e-02f, 6.46825358e-02f, -8.77603143e-02f,
  7.52595961e-02f, 4.36769947e-02f, 2.63790153e-02f, -5.25543243e-02f, 1.07106902e-02f, 9.81145799e-02f, 5.62147498e-02f, 5.87833638e-04f, -3.65755521e-02f, 1.09694619e-02f,
  2.09477261e-01f, -2.19347373e-01f, 9.35193151e-03f, 3.21425237e-02f, 6.31108973e-03f, -7.43061975e-02f, 9.50689390e-02f, -1.88570291e-01f, 1.11470595e-01f, -2.13414267e-01f,
  -1.57190599e-02f, 1.68762729e-01f, 1.16876312e-01f, -1.90569296e-01f, 2.92915821e-01f, 7.88208097e-02f, -1.61532342e-01f, -2.04827040e-02f, 8.53606015e-02f, 2.69928649e-02f,
  4.73060310e-02f, -7.52796233e-02f, -7.68194860e-03f, -2.74407804e-01f, -8.98110718e-02f, -1.73891068e-01f, -9.52562988e-02f, -3.38821821e-02f, -2.10089922e-01f, 4.44815643e-02f,
  6.39935136e-02f, -8.32187291e-03f, -2.98068710e-02f, -4.44163606e-02f, -4.61266749e-02f, -7.56446421e-02f, 4.49462496e-02f, 4.99526970e-03f, 8.67477357e-02f, -5.50574437e-03f,
  -1.87568739e-02f, 1.76522247e-02f, -1.38891399e-01f, -4.87005003e-02f, -6.16359413e-02f, -8.52703750e-02f, -2.28574630e-04f, 1.09944027e-02f, -7.29632154e-02f, -2.13192054e-03f,
  -1.49787813e-02f, -1.48894992e-02f, 5.12642488e-02f, 1.34791182e-02f, 2.47387309e-02f, -2.24364921e-02f, 9.69364773e-03f, 1.07008919e-01f, -1.58108976e-02f, -8.34642947e-02f,
  -1.11307159e-01f, 6.38079569e-02f, -2.78082062e-02f, -3.08951419e-02f, 6.96945330e-03f, -3.73086776e-04f, -6.51276903e-03f, 1.36390366e-02f, 2.54727360e-02f, 4.95816171e-02f,
  -1.81479920e-02f, 1.00853607e-01f, 9.71882418e-02f, 1.73183918e-01f, 1.37937553e-02f, 8.99754986e-02f, 7.21015036e-03f, 1.99170522e-02f, -6.82103708e-02f, -4.78272252e-02f,
  -8.98028091e-02f, 2.92047262e-02f, -2.35889032e-02f, -2.89599430e-02f, -3.82949859e-02f, 7.33529553e-02f, -4.92237210e-02f, 4.49578138e-03f, -7.54852295e-02f, 1.34281842e-02f,
  -3.80407684e-02f, -7.35369921e-02f, -9.55431238e-02f, -2.77651567e-02f, 1.53350588e-02f, -4.39386256e-03f, 6.01323228e-03f, -4.18736562e-02f, -7.92013481e-02f, 6.16983511e-02f,
  2.29400694e-02f, 7.36582801e-02f, -1.93156488e-02f, 2.62849499e-02f, 6.44380972e-02f, -1.66935161e-01f, 4.87102978e-02f, -6.54793754e-02f, -1.14651859e-01f, -8.62445310e-02f,
  1.79380532e-02f, 2.71075182e-02f, 1.39017463e-01f, -7.53964558e-02f, -2.65877191e-02f, 3.42176706e-02f, 7.50454143e-02f, -2.60724071e-02f, 5.76729365e-02f, 4.99075241e-02f,
  -2.95093060e-01f, 2.50092685e-01f, 1.91417083e-01f, 5.69846993e-03f, 2.18558535e-01f, 3.32237221e-02f, -2.04886533e-02f, 5.83784208e-02f, 2.28857264e-01f, 1.05278380e-02f,
  -1.72827005e-01f, -3.52917612e-02f, -5.09249941e-02f, -1.61135532e-02f, -5.95261455e-02f, 3.81662627e-03f, 1.81680992e-01f, 1.41036781e-02f, 1.78119868e-01f, 7.56565332e-02f,
  1.37812361e-01f, -8.53532851e-02f, 3.00631616e-02f, 8.37898925e-02f, -1.43232662e-02f, -3.87784690e-02f, -1.07651673e-01f, 8.69995207e-02f, -1.22240826e-01f, 6.67155311e-02f,
  6.08704844e-03f, -2.96238512e-02f, -9.58177000e-02f, 5.38638942e-02f, 1.44860903e-02f, 2.11733859e-02f, -3.05622490e-03f, -7.71713331e-02f, 4.19451259e-02f, -5.81401475e-02f,
  -1.01558886e-01f, -8.65855291e-02f, 3.86229940e-02f, -7.12434109e-03f, 6.58440217e-02f, 7.37221092e-02f, -5.94010577e-02f, -3.47859189e-02f, 1.08125217e-01f, 1.21062160e-01f,
  -2.36279834e-02f, -3.37377079e-02f, 6.27623424e-02f, 9.45005789e-02f, 8.41497630e-03f, -1.09692067e-02f, 5.79169206e-03f, -9.35856700e-02f, -6.79726675e-02f, 1.24652721e-01f,
  1.57646928e-02f, 1.86253130e-01f, 4.91119027e-02f, -4.15901728e-02f, 1.66888982e-02f, 5.19479290e-02f, 3.82496300e-03f, 4.96648252e-02f, -7.53596872e-02f, 6.80288626e-03f,
  5.77961933e-03f, -1.72432736e-02f, -2.43326463e-03f, 2.25919876e-02f, 5.93514480e-02f, 1.06971012e-02f, -7.13265985e-02f, -4.67884131e-02f, -1.97891183e-02f, 1.45363901e-02f,
  7.73598328e-02f, 4.24778014e-02f, -2.73025241e-02f, -2.33611614e-02f, 1.97267588e-02f, 1.92997176e-02f, -1.39368147e-01f, 5.70693500e-02f, 3.64109166e-02f, -1.02538280e-02f,
  -5.78146726e-02f, 2.15380844e-02f, -1.43548161e-01f, -8.01756829e-02f, 1.77430175e-02f, -3.87172848e-02f, -7.77655393e-02f, -1.00903042e-01f, -6.00765795e-02f, -3.60841565e-02f,
  -3.81260067e-02f, -5.37975170e-02f, -8.09028372e-02f, -1.47881377e-02f, -6.48280606e-02f, -6.18898086e-02f, -5.05050793e-02f, -2.38609519e-02f, -1.02982618e-01f, -6.15813397e-02f,
  -1.46055013e-01f, 3.44409719e-02f, -3.73306125e-02f, 8.98405239e-02f, 2.27394290e-02f, -2.07250975e-02f, 4.43807431e-02f, 6.99511692e-02f, -4.95107546e-02f, 1.12474620e-01f,
  -1.11341681e-02f, 1.49059027e-01f, -2.24219039e-01f, 4.36027534e-02f, -2.01476201e-01f, 2.23088101e-01f, 1.76201537e-01f, 1.69249228e-03f, -5.00239581e-02f, 3.32772434e-01f,
  1.85104251e-01f, -1.34243384e-01f, 1.58854812e-01f, 3.08371246e-01f, -3.63576300e-02f, 2.75587261e-01f, 2.79230744e-01f, 2.41703525e-01f, -5.26587740e-02f, -5.75924758e-03f,
  -8.29790831e-02f, 2.91895360e-01f, -2.81378869e-02f, -9.76940617e-03f, -3.31998505e-02f, -1.55966893e-01f, 5.58708273e-02f, -1.95688769e-01f, 6.61560893e-02f, 3.86845157e-03f,
  3.75823453e-02f, -8.85666907e-02f, -2.61914544e-02f, -4.02944162e-02f, 6.17941841e-02f, 3.17187384e-02f, -9.18255597e-02f, -6.80053085e-02f, -8.02927017e-02f, 1.80423278e-02f,
  -3.45490202e-02f, -1.62231235e-03f, 2.70721968e-03f, -5.12340963e-02f, -3.71317007e-02f, -9.85121056e-02f, -7.67954215e-02f, -4.12648208e-02f, -6.65732622e-02f, -1.65734123e-02f,
  -8.65726322e-02f, -8.68651345e-02f, -4.16834243e-02f, 8.61814246e-02f, -1.27920285e-01f, 6.17864989e-02f, 3.34201218e-03f, 1.85513049e-02f, -4.55997102e-02f, -8.48690346e-02f,
  -2.19279658e-02f, 7.41817579e-02f, -1.91297778e-03f, 3.83397192e-02f, -1.81648023e-02f, -4.89210337e-02f, 9.02858898e-02f, 6.74144849e-02f, -6.34540319e-02f, 4.36109044e-02f,
  5.12982346e-03f, -6.24592081e-02f, -1.11043258e-02f, -6.46413043e-02f, 5.79679273e-02f, -1.10499132e-02f, -3.31458524e-02f, 2.46419925e-02f, 8.10847618e-03f, -9.74727273e-02f,
  5.01723513e-02f, -4.55770418e-02f, 5.68632595e-02f, 5.43638691e-02f, 4.19442654e-02f, -5.05825654e-02f, 6.54473752e-02f, -4.14608307e-02f, 1.82181690e-02f, -5.84665090e-02f,
  7.97417015e-02f, 9.75005999e-02f, -4.17484380e-02f, -1.52580300e-02f, -8.44293311e-02f, 3.35434973e-02f, -5.65487240e-03f, 2.36456227e-02f, 3.82059067e-02f, 4.58481349e-02f,
  2.19786279e-02f, -2.14165039e-02f, -1.79482496e-03f, 2.17818469e-03f, -3.10957469e-02f, 2.47603469e-02f, 4.03379686e-02f, -4.83215898e-02f, -2.27567218e-02f, -5.84889278e-02f,
  -1.11398377e-01f, -4.14902046e-02f, -4.38989215e-02f, -1.45836277e-02f, 2.59771347e-02f, -3.95751186e-02f, 4.77078371e-02f, -1.08717039e-01f, -5.29107675e-02f, 1.44873355e-02f,
  2.40654185e-01f, -2.57996351e-01f, -3.70199196e-02f, 1.72311455e-01f, 2.69787252e-01f, 3.20303701e-02f, 2.27442220e-01f, 1.67609453e-01f, 3.33445817e-01f, -2.73555845e-01f,
  -5.49372062e-02f, -2.21474782e-01f, -2.73914158e-01f, -6.29379079e-02f, 1.23377584e-01f, -2.68207223e-04f, 8.71641710e-02f, -5.22411130e-02f, 1.16645686e-01f, 4.73922752e-02f,
  1.80799842e-01f, 7.92608410e-02f, 6.94869412e-03f, -1.16423681e-01f, 1.62593201e-01f, -4.31644469e-02f, -1.81701183e-02f, -3.72630991e-02f, -1.07326150e-01f, -7.35828141e-03f,
  1.29734457e-01f, -2.20681299e-02f, 6.87064603e-02f, -7.72506464e-03f, -1.85506064e-02f, -7.63965584e-03f, -6.51430339e-02f, -2.43799761e-02f, 1.16225243e-01f, 1.11440085e-02f,
  -7.63709694e-02f, -8.73909444e-02f, 2.64209397e-02f, 1.02235995e-01f, 1.13126427e-01f, 1.75187048e-02f, -6.47314712e-02f, 2.73491070e-02f, 1.52213033e-02f, -5.65461181e-02f,
  -5.46911359e-02f, -5.13254553e-02f, 1.46202341e-01f, -1.20154291e-01f, -1.53086996e-02f, 1.32232890e-01f, -2.03616843e-02f, -6.05370142e-02f, -1.38665102e-02f, 1.11137092e-01f,
  1.62816476e-02f, -4.93936799e-02f, 5.93921021e-02f, 5.24098799e-02f, 5.75172193e-02f, -3.69798653e-02f, -2.93189511e-02f, -2.04310808e-02f, -2.85614971e-02f, -4.19715159e-02f,
  8.90587792e-02f, -2.55645998e-02f, -4.11558412e-02f, 2.61630677e-02f, -6.54890314e-02f, 2.59549497e-03f, 1.33629655e-02f, -4.43721339e-02f, 5.65293878e-02f, 6.42117783e-02f,
  -4.68673883e-03f, 2.54643261e-02f, -1.60306897e-02f, 5.93238696e-02f, 6.72176182e-02f, -1.21910973e-02f, -4.07637097e-02f, -1.15761226e-02f, 9.52441543e-02f, -4.87253033e-02f,
  1.59462281e-02f, -1.91112667e-01f, -8.50998014e-02f, -1.21082008e-01f, 2.27530710e-02f, 5.85535243e-02f, 2.83479374e-02f, -1.68816317e-02f, 7.99521580e-02f, -7.02681243e-02f,
  -1.54383242e-01f, -5.22877537e-02f, -2.67766435e-02f, 5.29601723e-02f, -2.66821533e-02f, 3.53500969e-03f, 1.21514834e-02f, -7.10494593e-02f, -2.95539782e-03f, -1.54451549e-01f,
  1.44174164e-02f, -1.06324777e-01f, 6.39883475e-03f, 2.82375999e-02f, -3.01898550e-02f, 6.36106342e-05f, -8.35131258e-02f, -4.23597060e-02f, -3.03923134e-02f, 3.56057007e-03f,
  1.59221932e-01f, 1.04351707e-01f, -5.17223887e-02f, 1.16323724e-01f, -3.81719843e-02f, -2.70423800e-01f, -3.24951947e-01f, 1.00585975e-01f, -1.33428499e-01f, -2.80724857e-02f,
  -2.42671538e-02f, 1.46723762e-01f, -1.34748742e-01f, 1.71775088e-01f, 1.66560322e-01f, -2.02742100e-01f, 1.84499159e-01f, -2.41497997e-02f, -4.65305187e-02f, 1.98489264e-01f,
  7.07209408e-02f, 2.31606349e-01f, 7.78082833e-02f, 1.39854550e-01f, 3.08166035e-02f, -3.74713377e-03f, 1.36786148e-01f, -1.42065555e-01f, 2.28414267e-01f, 1.07909843e-01f,
  -3.80367488e-02f, 1.09785199e-01f, 2.44600996e-02f, -2.42684763e-02f, 1.01279698e-01f, 3.09804548e-02f, -4.45901453e-02f, 8.36182386e-02f, -2.54008584e-02f, 5.87149188e-02f,
  1.94795504e-02f, -2.33336594e-02f, 2.81734709e-02f, 4.17962484e-02f, 6.31047785e-02f, 6.14204153e-04f, -9.50595178e-03f, 5.98784685e-02f, -6.19564131e-02f, 1.09917343e-01f,
  -1.08719781e-01f, 5.82691990e-02f, 3.88090238e-02f, 5.69421090e-02f, 9.93880443e-03f, 2.58097127e-02f, -2.13965345e-02f, -3.43417563e-02f, 4.71782759e-02f, 8.38334113e-02f,
  2.31792256e-02f, -3.80453914e-02f, 1.63254216e-02f, 1.40901580e-02f, -9.80567113e-02f, 2.24906346e-03f, 9.79004949e-02f, -6.12857714e-02f, 8.89129564e-03f, -3.00412774e-02f,
  -2.48953197e-02f, -1.45501615e-02f, -2.30462942e-02f, -1.22562917e-02f, 6.41061291e-02f, -5.61045334e-02f, -1.04825988e-01f, 8.87350924e-03f, 1.29082520e-02f, -3.81573401e-02f,
  5.93477907e-03f, -8.21287632e-02f, 3.53193693e-02f, -1.61003768e-02f, -9.29900780e-02f, -3.19823436e-02f, 5.83060905e-02f, 6.96662962e-02f, -3.26514430e-02f, -8.88409689e-02f,
  7.25971609e-02f, 7.80478790e-02f, -4.24667448e-02f, -3.74863036e-02f, -5.49096093e-02f, 1.14274025e-02f, 1.77865233e-02f, 7.36815408e-02f, -1.28854811e-02f, -7.26460591e-02f,
  7.91949555e-02f, -4.22070809e-02f, 4.44074385e-02f, -1.32831605e-02f, 5.63585646e-02f, 6.80311322e-02f, -2.16051005e-02f, -1.20276920e-01f, -5.12479804e-02f, 3.81188206e-02f,
  3.98686491e-02f, -7.51075074e-02f, 4.57641371e-02f, -8.22207779e-02f, 5.03655076e-02f, 2.81882901e-02f, 1.80147439e-02f, 1.00763887e-02f, 5.78477979e-03f, 2.77388170e-02f,
  1.78805113e-01f, -1.80104271e-01f, -9.86713022e-02f, -7.43527785e-02f, -1.06327377e-01f, -1.04947232e-01f, 9.39447656e-02f, -2.69030660e-01f, -5.17254807e-02f, -1.25823960e-01f,
  -1.73884928e-02f, 1.41896248e-01f, 3.42579111e-02f, -9.74061862e-02f, 1.89657494e-01f, 6.38648793e-02f, -1.25569329e-01f, -1.67647544e-02f, 2.97856610e-02f, -5.70243560e-02f,
  -5.25412112e-02f, -1.30935490e-01f, 1.27933938e-02f, -1.77204281e-01f, -1.30073115e-01f, -9.00955647e-02f, -1.61345750e-02f, 4.32852246e-02f, -1.33831963e-01f, 2.17460226e-02f,
  1.82643700e-02f, 7.84815326e-02f, 8.91542342e-03f, -1.73097886e-02f, -7.06750229e-02f, -6.13153465e-02f, -8.73898417e-02f, 4.04018089e-02f, 1.24772796e-02f, 3.05362698e-02f,
  3.81967910e-02f, 5.14955260e-03f, 2.04287600e-02f, 5.30965105e-02f, 1.96124963e-03f, -6.62525520e-02f, 1.57372355e-02f, -3.91391590e-02f, 3.70413661e-02f, 2.82522030e-02f,
  -2.59522605e-03f, 3.98465097e-02f, 3.58574130e-02f, 3.61389667e-02f, -1.07274652e-02f, 5.49006574e-02f, 7.84408525e-02f, 4.40353490e-02f, -1.35041466e-02f, -3.60358767e-02f,
  -8.82994831e-02f, -5.36147319e-02f, 3.93261388e-02f, -1.12528250e-01f, -6.15530610e-02f, 2.40418203e-02f, -1.87053271e-02f, -1.03089631e-01f, 7.44753405e-02f, 8.65724124e-03f,
  6.85271025e-02f, 2.92935725e-02f, 4.24877927e-02f, 1.09683909e-01f, -1.34810703e-02f, 7.75181577e-02f, 2.42654309e-02f, 3.16200815e-02f, -1.05246030e-01f, -6.84392750e-02f,
  3.69654410e-02f, 5.35508841e-02f, 5.50557710e-02f, -1.16696894e-01f, 2.02211831e-02f, -1.97076164e-02f, -5.09199835e-02f, -2.90018022e-02f, -3.00116073e-02f, -4.74850368e-03f,
  -2.86197830e-02f, 4.55021895e-02f, -7.93196708e-02f, 2.11412758e-02f, -9.27397311e-02f, -4.24113385e-02f, -8.32085237e-02f, -1.15339495e-01f, -4.42878008e-02f, 6.89154789e-02f,
  5.48390485e-02f, -1.93809476e-02f, 9.27355420e-03f, -3.54237407e-02f, -5.12133017e-02f, -3.53970565e-02f, 1.64863333e-01f, -6.20365795e-03f, -1.13236792e-01f, -1.10661402e-01f,
  2.06710473e-02f, 4.22514193e-02f, 8.74810964e-02f, 2.06175689e-02f, 3.09815761e-02f, 8.22770447e-02f, 4.55735950e-03f, 5.55657335e-02f, -4.52932492e-02f, -7.79894143e-02f,
  -4.08739835e-01f, 1.55938700e-01f, -1.77011877e-01f, 2.45267600e-02f, -8.57435688e-02f, -1.24279603e-01f, -1.65206380e-02f, 1.28974281e-02f, -1.10964283e-01f, 2.08622351e-01f,
  1.44868612e-01f, -1.06726371e-01f, 9.94287431e-02f, 8.10288340e-02f, -2.40747035e-01f, 6.74398765e-02f, -3.38906571e-02f, -6.18151277e-02f, -6.56994507e-02f, 1.40574425e-01f,
  -1.75258778e-02f, 2.69937813e-01f, 7.81141073e-02f, 8.34665969e-02f, 8.60255584e-03f, 3.17016467e-02f, 1.08284228e-01f, 1.46597981e-01f, 6.37368485e-02f, -2.50927601e-02f,
  2.08871383e-02f, 1.08685479e-01f, -1.99381774e-03f, -4.64689136e-02f, -5.64514957e-02f, -6.16321526e-02f, 1.40147367e-02f, -1.49880186e-01f, -6.76174788e-03f, -6.45888075e-02f,
  3.89188807e-03f, 1.42352954e-02f, -3.74544114e-02f, -2.76286975e-02f, -1.84960123e-02f, -5.49126640e-02f, -3.42586040e-02f, -1.81747377e-02f, 5.45728952e-03f, 1.93323120e-02f,
  1.76228285e-02f, 3.41317989e-02f, 4.73169088e-02f, 3.22515368e-02f, 3.03005259e-02f, 1.08662188e-01f, -7.52231181e-02f, -4.71910201e-02f, -5.62489256e-02f, -8.09213668e-02f,
  -9.27455202e-02f, -4.32045870e-02f, 3.82150486e-02f, 3.53928991e-02f, -3.58407316e-03f, 4.22018394e-02f, -4.53501865e-02f, -5.75695001e-02f, -1.08192354e-01f, -4.19018418e-02f,
  -4.34759296e-02f, -4.58351895e-02f, 5.36605902e-02f, 5.90924397e-02f, -4.31647934e-02f, -1.12447387e-03f, 3.02097686e-02f, 1.46040367e-02f, -9.54683647e-02f, -1.05123863e-01f,
  1.82118975e-02f, -1.21349059e-01f, 1.10250060e-02f, 1.10245280e-01f, 4.23092805e-02f, -4.79605831e-02f, -2.25706156e-02f, 8.98427293e-02f, 6.54940754e-02f, 5.31048374e-03f,
  7.16695040e-02f, -1.36643052e-02f, 1.12774810e-02f, 7.19489008e-02f, 4.48088124e-02f, -9.70834941e-02f, 4.78935950e-02f, -1.00698844e-01f, -1.52187105e-02f, 1.37908272e-02f,
  -9.62002724e-02f, 4.70860712e-02f, -5.35542108e-02f, -1.28753418e-02f, 1.08692525e-02f, -3.07340566e-02f, -2.68754642e-02f, 3.14373076e-02f, 8.82115867e-03f, 1.70730539e-02f,
  2.10370105e-02f, -3.63316573e-03f, -2.17953622e-02f, -1.23811997e-02f, 7.86543563e-02f, -1.96806770e-02f, -6.52228147e-02f, 1.09668253e-02f, -3.47654661e-03f, -4.70343139e-03f,
  -1.04075968e-01f, 2.25679725e-01f, -1.62976086e-02f, 1.07505526e-02f, 1.27086416e-01f, -1.66020691e-01f, -2.87683718e-02f, 2.57483423e-02f, -1.31840277e-02f, 1.03303172e-01f,
  -3.38642709e-02f, 1.32542878e-01f, 8.03253148e-03f, -8.03315341e-02f, -2.55516410e-01f, -2.09583148e-01f, -1.21538848e-01f, -5.43947294e-02f, -4.59967181e-02f, -3.58052775e-02f,
  -1.22195967e-01f, -1.71872750e-01f, -1.32011399e-01f, 7.55398814e-03f, -2.48457901e-02f, 5.45251854e-02f, -7.97089562e-02f, 1.19174207e-02f, 5.35574369e-02f, -7.17071965e-02f,
  4.67183796e-04f, 7.86246583e-02f, 8.60342979e-02f, -2.04528868e-02f, -8.60642865e-02f, -2.28428710e-02f, -2.03388333e-02f, -5.60475094e-03f, -2.34619956e-02f, -2.03411258e-03f,
  5.49214296e-02f, -9.52094644e-02f, -3.60808074e-02f, -3.53001500e-03f, -1.00384373e-02f, -6.66794479e-02f, 5.07467724e-02f, 8.84558912e-03f, 7.09839091e-02f, -8.43508169e-02f,
  -5.07915802e-02f, 1.47094289e-02f, -2.29401921e-04f, -1.65936444e-02f, -2.80521400e-02f, -9.40485895e-02f, 6.76626042e-02f, -8.78485963e-02f, 2.07885336e-02f, -9.97236446e-02f,
  -1.40574843e-01f, -7.16269314e-02f, 3.93980853e-02f, 2.45595220e-02f, 1.34608567e-01f, -2.94368435e-02f, -1.79140251e-02f, -2.96123233e-02f, -6.86263666e-02f, -1.26125738e-01f,
  5.78175783e-02f, 4.62584272e-02f, 6.22384511e-02f, -1.12268172e-01f, -1.25962365e-02f, -4.03050566e-03f, -9.66428034e-03f, 9.02746096e-02f, 1.08492143e-01f, 1.04685212e-02f,
  2.83812527e-02f, 1.02052856e-02f, -7.36110881e-02f, 6.26425222e-02f, -4.29214798e-02f, -2.49221940e-02f, -8.42817053e-02f, -6.07871730e-03f, -2.17887554e-02f, 2.31215451e-02f,
  3.01275868e-02f, -1.05381936e-01f, 8.21371675e-02f, 2.92805731e-02f, -3.04917246e-02f, 1.57729834e-02f, 3.40338275e-02f, 8.55743513e-02f, 1.06499987e-02f, 8.76239408e-03f,
  -4.42398526e-02f, 4.68154065e-02f, -7.27253333e-02f, -7.47212619e-02f, 1.24025106e-01f, -4.69389446e-02f, -2.87316535e-02f, 5.88748278e-03f, 2.25602202e-02f, -4.60253097e-02f,
  -5.45175746e-03f, 7.45441765e-03f, -1.30580664e-01f, -2.29167379e-02f, -8.15777406e-02f, 4.61321659e-02f, 3.00954431e-02f, 6.27714917e-02f, -4.92616445e-02f, -9.85520333e-02f,
  -1.64048031e-01f, 9.67125222e-02f, 1.97034389e-01f, 9.12089497e-02f, 2.99376041e-01f, 9.59295481e-02f, 1.73460376e-02f, 2.02140823e-01f, 2.13787019e-01f, -7.38826990e-02f,
  -2.76465148e-01f, -1.15469299e-01f, -1.19378820e-01f, -1.66847464e-02f, 2.61449739e-02f, 1.04225226e-01f, 7.68790841e-02f, -2.11461075e-02f, 1.76611155e-01f, 7.75130242e-02f,
  9.83598828e-02f, -1.32992744e-01f, 7.55098388e-02f, 6.14344738e-02f, 6.98112845e-02f, -7.04854280e-02f, -1.24357142e-01f, 1.24467410e-01f, -8.81413743e-02f, 5.44818603e-02f,
  -5.50121963e-02f, -3.31154317e-02f, -8.01649243e-02f, -7.79426172e-02f, 2.80571543e-02f, -1.66705161e-01f, -2.28890907e-02f, -7.28576928e-02f, -4.99168374e-02f, 1.90450195e-02f,
  -6.56849593e-02f, -8.36106688e-02f, -7.67336637e-02f, -3.99169065e-02f, -7.35342577e-02f, -2.49402151e-02f, 1.32470116e-01f, -5.47358282e-02f, -1.14491978e-03f, 8.82107168e-02f,
  5.87866791e-02f, 5.18069081e-02f, 8.80733505e-02f, -6.20695241e-02f, -5.60211092e-02f, 8.68174285e-02f, 4.65828143e-02f, 7.48617761e-03f, 1.26820505e-01f, 1.17030546e-01f,
  -3.28281149e-02f, 6.33018017e-02f, 1.06929410e-02f, -4.85873735e-03f, -2.06828620e-02f, 9.18377042e-02f, -9.80260447e-02f, -1.17089301e-01f, 9.19543505e-02f, 5.53599671e-02f,
  -6.67682961e-02f, -6.68552592e-02f, 5.61689958e-02f, 3.83857600e-02f, -4.67173336e-03f, -4.09043357e-02f, 2.21510045e-02f, 1.63882487e-02f, -1.83968935e-02f, -9.45467055e-02f,
  -3.28116305e-02f, -2.40001772e-02f, -1.64941084e-02f, 7.63679370e-02f, -5.46027794e-02f, 5.31339236e-02f, -4.27323580e-02f, 7.08252937e-02f, -8.57292563e-02f, -6.72075152e-02f,
  -4.08810563e-02f, -8.83995518e-02f, -1.32032767e-01f, -1.56952292e-01f, -6.01249188e-02f, -8.91763270e-02f, -8.26188996e-02f, 3.20912339e-02f, -5.82666956e-02f, -9.00081396e-02f,
  -5.16503304e-02f, -4.25493196e-02f, -4.70748134e-02f, 4.06700224e-02f, -2.50866916e-02f, -5.08727357e-02f, -1.51261883e-02f, -3.80845331e-02f, -7.44629204e-02f, -8.37801099e-02f,
  -1.53895672e-02f, -5.51923066e-02f, 2.30936166e-02f, -1.51283992e-02f, -1.68956369e-02f, -6.76781684e-02f, 4.08611633e-02f, 3.01504578e-03f, -4.58723307e-03f, 7.91033916e-03f,
  8.42212141e-02f, -6.90115467e-02f, -1.70907602e-01f, 2.80072968e-02f, -7.62587264e-02f, -2.83721894e-01f, -2.68812686e-01f, 8.94158408e-02f, -1.69049323e-01f, 3.68119068e-02f,
  5.79000227e-02f, -1.14718743e-01f, 2.05616467e-03f, 1.74660403e-02f, -9.77179874e-03f, -1.28716901e-01f, 1.13324143e-01f, -2.82961912e-02f, 3.15200761e-02f, 2.46898741e-01f,
  7.39679411e-02f, 1.79224774e-01f, 9.70050469e-02f, 1.27406776e-01f, 4.56123240e-02f, 3.59430127e-02f, 2.47953162e-01f, 3.80917341e-02f, 7.67467320e-02f, -2.79106689e-03f,
  -3.20161581e-02f, -1.07282016e-03f, -3.84324603e-02f, -2.36874372e-02f, 8.08925852e-02f, 4.26170751e-02f, 8.79131723e-03f, -2.98975278e-02f, -5.88898808e-02f, 8.70827362e-02f,
  -1.71046723e-02f, 3.98817752e-03f, -3.09323240e-03f, 3.84089462e-02f, 3.76083161e-04f, 3.17010209e-02f, 1.08485064e-02f, -6.57823011e-02f, -6.57952065e-03f, 2.09952649e-02f,
  -9.99999698e-03f, 2.85831522e-02f, 3.35350707e-02f, -2.61549447e-02f, -4.21474203e-02f, 5.82072213e-02f, 1.10112578e-01f, 3.49773243e-02f, 1.46523351e-02f, 1.03648186e-01f,
  4.99723665e-02f, 5.89182675e-02f, -1.07837126e-01f, -1.96495429e-01f, -3.45828347e-02f, -3.40700932e-02f, -4.73698787e-02f, -8.62668231e-02f, 9.21799708e-03f, 6.50369674e-02f,
  5.70953228e-02f, 3.20220506e-03f, 3.91673483e-02f, -1.57434121e-02f, 9.46734548e-02f, 1.11614816e-01f, 1.46142080e-01f, 6.45527914e-02f, -3.20352986e-02f, -8.06453303e-02f,
  -4.66631837e-02f, 1.07887022e-01f, 1.97328143e-02f, 2.84281764e-02f, 1.02857567e-01f, 9.67375338e-02f, 4.58789431e-03f, -5.47647439e-02f, -6.17540330e-02f, 3.36220302e-02f,
  1.04833655e-01f, 1.69648781e-01f, -8.67756307e-02f, -8.86040628e-02f, -2.24703867e-02f, 3.02397627e-02f, 2.76862886e-02f, -6.97948560e-02f, 9.14240479e-02f, 6.05318844e-02f,
  1.03768364e-01f, -9.52467993e-02f, 6.23385943e-02f, 3.57453339e-03f, 5.32136075e-02f, 3.15478705e-02f, 4.32040170e-02f, -6.91579953e-02f, 4.84236293e-02f, -2.61698049e-02f,
  1.27908930e-01f, -9.26661305e-03f, -4.57415059e-02f, -1.48002371e-01f, -6.06434839e-03f, 8.49598125e-02f, 3.64422016e-02f, 3.78458127e-02f, 1.17594469e-02f, -5.82599789e-02f,
  4.87459265e-02f, -2.33863771e-01f, 1.09333787e-02f, -1.08890735e-01f, 7.02870339e-02f, 4.06005904e-02f, 5.53396083e-02f, -1.41312003e-01f, -1.49075791e-01f, -1.94814712e-01f,
  -2.28337217e-02f, 4.80618887e-02f, -4.41385806e-02f, -1.34123310e-01f, 3.40004444e-01f, -1.05254106e-01f, -1.32576928e-01f, 9.13808420e-02f, -1.40549503e-02f, -8.10193568e-02f,
  1.58592351e-02f, -9.53673050e-02f, 6.76992238e-02f, -8.30676854e-02f, -1.27302766e-01f, -2.15136427e-02f, -2.65084039e-02f, 1.05990686e-01f, 3.48556004e-02f, 9.00990590e-02f,
  -5.97516522e-02f, -2.06607863e-01f, -7.79087469e-02f, -1.10279523e-01f, -6.29139915e-02f, 1.32330367e-02f, -7.19649671e-03f, 5.08936271e-02f, 7.90478140e-02f, -2.67340168e-02f,
  5.63450195e-02f, -2.97057014e-02f, 1.59599930e-02f, -3.64550687e-02f, -4.42283675e-02f, 1.54714296e-02f, 4.89920042e-02f, -6.70744514e-04f, -7.31891245e-02f, 7.15561062e-02f,
  2.77008247e-02f, -6.93423152e-02f, 2.17962097e-02f, -1.72599051e-02f, 4.02923934e-02f, -6.09818511e-02f, -1.08503373e-02f, 1.74804404e-02f, -7.02335611e-02f, -1.98981650e-02f,
  7.64848664e-02f, 2.47488506e-02f, -3.40902396e-02f, -4.31025699e-02f, 1.67031325e-02f, -1.91794187e-02f, 5.30023389e-02f, 1.05049655e-01f, -8.01413357e-02f, -3.22190346e-03f,
  7.21841725e-03f, -4.00928929e-02f, 1.27028786e-02f, -6.90841228e-02f, 4.44576032e-02f, -7.72808716e-02f, -5.05410321e-02f, -4.84300926e-02f, 1.82737615e-02f, -1.02485083e-01f,
  1.52121171e-01f, 2.86444481e-02f, -6.27528504e-02f, 5.42746522e-02f, -5.71043715e-02f, -4.23615333e-03f, -1.00114599e-01f, -9.51681063e-02f, 2.84069334e-03f, -2.64500417e-02f,
  -1.94488317e-01f, -1.79024592e-01f, -1.62444506e-02f, -7.27118365e-03f, -8.71502161e-02f, -1.40086114e-01f, -9.11925163e-04f, -8.89753848e-02f, -7.88914971e-03f, 3.49370278e-02f,
  1.69520627e-03f, -2.59189401e-02f, 6.85145035e-02f, 4.25733030e-02f, 8.20348039e-02f, 3.22652981e-02f, -5.39535061e-02f, -7.78180659e-02f, 2.05875305e-03f, -7.49428868e-02f,
  -1.10768177e-01f, 7.81420171e-02f, 4.86906990e-02f, -6.20500511e-03f, 2.10825913e-02f, -7.99296889e-03f, -3.47732939e-02f, 2.92961579e-03f, 7.24701732e-02f, 2.35672873e-02f,
  -1.01839282e-01f, -2.01341845e-02f, -6.09445982e-02f, 6.26009628e-02f, 3.02549521e-03f, -2.35206798e-01f, -1.86759457e-01f, 9.52359214e-02f, -9.43496078e-02f, 9.23985764e-02f,
  1.01716034e-01f, 5.78299202e-02f, 7.90134817e-02f, 1.20681502e-01f, -1.41512111e-01f, 1.73435152e-01f, -8.32921267e-03f, -4.58402373e-02f, 1.53905496e-01f, 1.45831987e-01f,
  1.37022197e-01f, 1.27672061e-01f, 1.12777025e-01f, 1.49843350e-01f, -4.45344718e-03f, 3.47845419e-03f, 1.30966634e-01f, 1.11999445e-01f, 4.81930561e-02f, -1.62855983e-02f,
  -3.20711322e-02f, 4.23765667e-02f, 9.46541224e-03f, -1.64429143e-01f, -9.79089644e-03f, 1.60233565e-02f, -1.51298316e-02f, -1.08114943e-01f, -1.91788301e-02f, 8.21669027e-03f,
  6.77099675e-02f, -4.73132879e-02f, -3.40310298e-03f, -4.63198572e-02f, -2.25841608e-02f, -1.26453741e-02f, 3.82063836e-02f, -8.20463058e-03f, 2.62119975e-02f, -9.77283693e-04f,
  7.17709288e-02f, -4.39960836e-03f, -4.57503051e-02f, -6.74792081e-02f, -1.57413315e-02f, 9.88191739e-03f, -7.88964629e-02f, -4.09273468e-02f, 1.16194010e-01f, 1.64682176e-02f,
  7.80130224e-03f, -4.48606759e-02f, 1.03065008e-02f, -2.32484248e-02f, -1.38638746e-02f, -5.92813306e-02f, -9.90055650e-02f, -8.77976045e-02f, 2.66339220e-02f, 3.23121473e-02f,
  1.63932145e-02f, 5.57068475e-02f, -5.27506992e-02f, -3.24514918e-02f, 9.55865136e-04f, -3.79126668e-02f, 7.56855607e-02f, 1.88641082e-02f, -1.28946736e-01f, 2.17165258e-02f,
  -5.18198349e-02f, -2.82673817e-02f, 1.96166877e-02f, 7.63350399e-04f, 2.81881485e-02f, -3.52785811e-02f, -4.27812897e-02f, -3.69827449e-02f, 1.53226079e-02f, 2.05645133e-02f,
  -5.20804562e-02f, 1.75727203e-01f, 6.89501688e-02f, -7.72863328e-02f, -1.15470923e-02f, -1.38612734e-02f, 3.23675722e-02f, 6.68246746e-02f, 3.79240140e-02f, 6.35523275e-02f,
  8.48215222e-02f, -1.46300241e-01f, 4.91971597e-02f, -4.19695266e-02f, -7.27361217e-02f, 5.54972515e-02f, -2.29682699e-02f, -8.61748233e-02f, 2.29111686e-02f, 2.87951753e-02f,
  1.49752095e-01f, 1.36288762e-01f, 5.64712659e-02f, -4.83940765e-02f, 3.63212987e-03f, -3.94284464e-02f, 3.47968452e-02f, 5.44502996e-02f, 1.10059761e-01f, 7.97474086e-02f,
  2.12189227e-01f, 2.25856900e-02f, -1.88094944e-01f, -1.42910868e-01f, -1.57003343e-01f, -2.36518368e-01f, -2.14084402e-01f, -5.83683439e-02f, 4.89424169e-02f, 1.07031398e-01f,
  -1.59358695e-01f, 2.57595390e-01f, 6.88833073e-02f, -1.21509843e-01f, -2.24176601e-01f, 2.12117150e-01f, -2.77183324e-01f, -1.11520980e-02f, -4.28154133e-02f, -6.98042214e-02f,
  -1.58323683e-02f, -8.72174501e-02f, -2.16504484e-01f, -8.26740712e-02f, -1.56966716e-01f, -1.15058888e-02f, 3.12713273e-02f, -3.19520384e-02f, -1.19193509e-01f, -1.67539239e-01f,
  -5.88685609e-02f, -6.08874522e-02f, 7.23678544e-02f, 2.30874363e-02f, -5.22143021e-02f, -8.64863470e-02f, -1.31584749e-01f, 1.93729363e-02f, 5.11969300e-03f, -5.05922921e-02f,
  9.31159183e-02f, 1.06385149e-01f, 7.35403001e-02f, 5.03131673e-02f, 3.73045653e-02f, -3.76010425e-02f, -4.22879085e-02f, 2.99046598e-02f, -8.32288787e-02f, -3.11387479e-02f,
  -1.02728056e-02f, -4.96038385e-02f, 2.27454747e-03f, 7.57463276e-02f, -4.58957665e-02f, -5.85292019e-02f, -3.95831168e-02f, -8.92377198e-02f, 3.34636644e-02f, -5.59179019e-03f,
  4.77684923e-02f, -1.46238448e-03f, -1.27058371e-03f, -1.89021118e-02f, 4.91686203e-02f, -6.65919781e-02f, 3.17418799e-02f, -1.71329523e-03f, 1.72119215e-02f, 6.29198849e-02f,
  -3.73509228e-02f, -4.24231356e-03f, -1.11928880e-01f, 5.90816373e-03f, -1.84199270e-02f, 6.45700842e-02f, 9.03789476e-02f, -2.12224312e-02f, -2.89411712e-02f, -8.67733806e-02f,
  6.94034696e-02f, -6.28312677e-02f, 6.77469280e-03f, 8.57162056e-04f, -1.05658956e-01f, -2.91250111e-03f, 1.74818151e-02f, 5.84108708e-03f, -7.40473047e-02f, -5.74482977e-02f,
  -1.75019443e-01f, -1.53207973e-01f, 2.92416848e-02f, -2.18094140e-02f, 3.61621454e-02f, 4.71003354e-03f, -3.76722030e-03f, -5.10707730e-03f, -5.13989665e-02f, -4.05494235e-02f,
  8.40233415e-02f, 2.89143529e-02f, 7.29259569e-03f, 1.09474458e-01f, 1.54021299e-02f, -1.65772885e-01f, 1.75089817e-02f, -1.93051305e-02f, -1.01200096e-01f, -1.02593288e-01f,
  -3.17141116e-02f, -1.33458851e-02f, -3.19298990e-02f, 5.44269495e-02f, 8.84981640e-03f, -7.79186515e-03f, -5.88751025e-02f, -8.19467939e-03f, -1.73305161e-02f, 6.47118464e-02f,
  -4.72858667e-01f, 2.77265787e-01f, -1.15464434e-01f, 2.09685788e-01f, -1.98719442e-01f, -5.25543317e-02f, 1.43503606e-01f, -1.39362752e-01f, -8.74159671e-03f, 2.45088100e-01f,
  1.27002269e-01f, -5.14735607e-03f, 6.69386331e-03f, 1.99421510e-01f, -3.05236846e-01f, 9.29478332e-02f, 6.43569306e-02f, 1.42908901e-01f, -7.16170371e-02f, -7.90120512e-02f,
  -1.90285873e-02f, 4.62570004e-02f, -4.96442951e-02f, -6.37353212e-02f, -1.77714422e-01f, -5.82315959e-02f, 3.91774774e-02f, -4.65944409e-02f, 2.84293741e-02f, 2.21518166e-02f,
  5.31674512e-02f, 4.44172770e-02f, -2.61061788e-02f, -8.32354948e-02f, -1.00608774e-01f, 9.04058851e-03f, -1.23517830e-02f, -1.14032030e-02f, 1.16993627e-02f, -1.01448566e-01f,
  -6.11406304e-02f, -6.56079724e-02f, 6.38790131e-02f, -9.04924609e-03f, -6.31394610e-02f, 6.23792373e-02f, -4.89733368e-02f, 1.95028521e-02f, 2.96398904e-02f, -1.02582380e-01f,
  5.32404296e-02f, -9.56689417e-02f, 1.84818767e-02f, -1.91857442e-02f, -8.60331133e-02f, 5.83159104e-02f, 1.10834718e-01f, 6.25058487e-02f, -3.89921106e-02f, -1.13369357e-02f,
  1.81612112e-02f, 2.06221249e-02f, -7.09740445e-02f, 6.20074086e-02f, 6.12393692e-02f, -8.98470264e-03f, 3.78975570e-02f, 6.05431125e-02f, 5.99616393e-02f, -5.41951992e-02f,
  -2.41725333e-02f, -1.58343799e-02f, 9.66721587e-03f, 4.90714386e-02f, -1.88484527e-02f, 3.96034755e-02f, 1.96698327e-02f, -5.65842129e-02f, -2.95507442e-03f, 2.79433765e-02f,
  -2.73464657e-02f, 2.33209468e-02f, 8.88008997e-03f, 2.54273731e-02f, -1.13271940e-02f, 7.24665225e-02f, -7.99656063e-02f, 5.38455369e-03f, 5.77457547e-02f, -2.49629002e-02f,
  1.65983643e-02f, -4.73891348e-02f, 8.45149253e-03f, -1.76542569e-02f, 3.76032405e-02f, 1.06179737e-03f, 7.32370373e-03f, -5.55116534e-02f, 6.01141565e-02f, -3.26939784e-02f,
  -4.30042185e-02f, -5.25532812e-02f, 6.15285151e-02f, 1.87240932e-02f, -5.52048795e-02f, 7.02326819e-02f, 3.36164609e-02f, 2.43661646e-02f, 3.46874893e-02f, -1.20355569e-01f,
  9.60942134e-02f, 1.62307546e-02f, -6.05149195e-02f, -1.82593260e-02f, -1.11317627e-01f, 6.67666271e-02f, 2.02601440e-02f, -9.52759665e-03f, -1.34518975e-02f, 8.67946446e-02f,
  3.32486704e-02f, 3.31507951e-01f, 4.60330434e-02f, 1.63799018e-01f, -7.87747875e-02f, 4.33381386e-02f, -1.85988024e-02f, -1.56524196e-01f, -6.81001320e-02f, 1.17654964e-01f,
  -2.81543732e-02f, 2.95228124e-01f, -7.25231990e-02f, 1.36795282e-01f, -1.56440869e-01f, -7.94090480e-02f, 8.56189951e-02f, 1.96999088e-01f, -1.35452403e-02f, 8.10886770e-02f,
  -6.95491806e-02f, -1.72914509e-02f, 7.78861195e-02f, 4.73370478e-02f, 8.84786844e-02f, 9.58594978e-02f, -1.32162452e-01f, -1.16720274e-01f, 2.00294212e-01f, -6.85147047e-02f,
  -9.07087773e-02f, 2.01358963e-02f, 1.09509826e-01f, -3.02144103e-02f, -6.76621646e-02f, -2.27763653e-02f, 6.89233840e-02f, -5.81138022e-02f, -1.72191694e-01f, -2.82644518e-02f,
  1.81930199e-01f, 8.16814974e-02f, 5.34916148e-02f, -4.41683978e-02f, -3.30497473e-02f, 1.21971928e-02f, -1.05723493e-01f, 1.56536222e-01f, 5.52811772e-02f, -4.67678867e-02f,
  -3.52147482e-02f, 2.23027673e-05f, -3.70173231e-02f, -1.93153713e-02f, 2.55467854e-02f, 9.84722301e-02f, -3.48186791e-02f, 2.41574440e-02f, 6.46735802e-02f, 3.06718089e-02f,
  1.84362363e-02f, -2.30813008e-02f, -4.33511660e-02f, -7.30478317e-02f, 1.95317660e-02f, 9.36404467e-02f, 5.82761131e-02f, -8.13375190e-02f, 6.53682128e-02f, 8.67419317e-02f,
  -2.62614191e-02f, 2.60291249e-02f, -7.11240843e-02f, -1.31942732e-02f, 5.10304458e-02f, 2.97569092e-02f, 1.32756718e-02f, 7.89433643e-02f, -4.08292226e-02f, -6.75106570e-02f,
  -4.92364056e-02f, 1.27008379e-01f, 5.25231054e-03f, -3.69892046e-02f, 9.84455645e-03f, -6.17278628e-02f, -7.08752498e-02f, -7.90232942e-02f, 4.34669331e-02f, -6.48460388e-02f,
  -5.08643351e-02f, -7.25957677e-02f, 1.05596587e-01f, -1.37447745e-01f, -2.35779714e-02f, -1.22629248e-01f, -8.04266408e-02f, -2.00691223e-02f, -1.32743761e-01f, -5.58785833e-02f,
  7.55125061e-02f, 9.06370506e-02f, -3.20521034e-02f, -4.03107442e-02f, -7.36941642e-04f, -4.54827882e-02f, -9.68189836e-02f, -1.67557131e-02f, -1.02322705e-01f, -7.63022974e-02f,
  -3.86230014e-02f, -4.88100275e-02f, -8.31434280e-02f, 5.28662391e-02f, 6.45479560e-02f, 7.11259767e-02f, 9.67750698e-02f, -5.53987511e-02f, -4.67162021e-02f, -3.00301220e-02f,
  1.78597391e-01f, -3.14682782e-01f, -3.14401463e-02f, 5.14687486e-02f, 1.65261198e-02f, -4.13246006e-02f, -8.58558435e-03f, -8.39464143e-02f, -1.50793448e-01f, -1.32755578e-01f,
  9.28234980e-02f, -6.20334968e-03f, -6.85411841e-02f, 5.17847501e-02f, 2.07575083e-01f, -1.24637425e-01f, -3.30483355e-02f, 3.94728407e-02f, -3.41836289e-02f, -1.37795046e-01f,
  7.90718794e-02f, 1.50030077e-01f, 1.56984642e-01f, 1.36900499e-01f, 7.29062110e-02f, 1.57140806e-01f, 5.13334982e-02f, 1.27293721e-01f, 1.25127211e-01f, 2.17419282e-01f,
  -4.61503677e-02f, -3.39823179e-02f, 2.37832274e-02f, 5.52935933e-04f, -1.05619729e-01f, -6.34902865e-02f, -1.58912328e-03f, 9.81504172e-02f, 9.25620645e-02f, 5.55728115e-02f,
  -7.46060535e-02f, 8.32747086e-04f, 1.22756325e-02f, -2.11096611e-02f, 1.71345640e-02f, 3.05982307e-02f, -4.13183048e-02f, -7.28158653e-02f, -8.11672136e-02f, 3.34060267e-02f,
  -7.25684613e-02f, -3.88988219e-02f, -1.02315478e-01f, 4.87000421e-02f, -2.32980382e-02f, -2.79756617e-02f, 1.11283913e-01f, -1.77363902e-02f, -5.27381198e-03f, 4.12400328e-02f,
  4.90899347e-02f, 8.47922452e-03f, 4.62098094e-03f, 7.69713242e-03f, 1.99505184e-02f, -7.13013336e-02f, -3.94445807e-02f, 2.84005888e-02f, 7.72966817e-03f, -3.60317454e-02f,
  1.00706816e-02f, 4.26261127e-02f, 1.01462632e-01f, 2.17716843e-02f, 3.24220769e-02f, -8.84274840e-02f, 7.19904602e-02f, -1.20111490e-02f, 3.53466794e-02f, 5.34945726e-03f,
  1.91073250e-02f, -5.79800382e-02f, 4.67275316e-03f, 1.26817390e-01f, 1.25543073e-01f, -1.64644774e-02f, 1.52000217e-02f, -4.35591601e-02f, -1.44812362e-02f, -4.01029317e-03f,
  -1.23206057e-01f, -6.20138310e-02f, 2.40998901e-02f, 2.48028841e-02f, 8.04571509e-02f, 2.39122603e-02f, 5.39239049e-02f, -8.90661925e-02f, -3.78286429e-02f, -2.11796258e-02f,
  4.47424352e-02f, 7.35404855e-03f, 1.48034180e-02f, 5.96118309e-02f, 4.47488539e-02f, -9.10273641e-02f, 2.65893340e-02f, 1.14709255e-03f, 3.42346653e-02f, -8.08166414e-02f,
  -2.19369177e-02f, -4.77209017e-02f, 1.10904366e-01f, -2.21271552e-02f, 5.64906709e-02f, 3.42163593e-02f, -1.12114577e-02f, -4.16232273e-02f, -2.42989254e-03f, 1.52968634e-02f,
  1.92551408e-02f, -1.49097160e-01f, -3.70287411e-02f, 1.93477437e-01f, 3.53511870e-02f, -1.98672026e-01f, -1.50068656e-01f, 3.51654887e-02f, 2.89574061e-02f, -1.08008578e-01f,
  -5.44754751e-02f, 8.07159990e-02f, -1.41129466e-02f, 1.07500665e-01f, 2.25273281e-01f, -1.33713201e-01f, 4.83177118e-02f, -2.82659084e-02f, -9.73413959e-02f, -1.52707240e-03f,
  2.44887084e-01f, 1.17651746e-01f, 2.56269395e-01f, 9.30225626e-02f, 1.41373125e-03f, 2.08906353e-01f, 3.13080810e-02f, 3.84852029e-02f, 1.59130171e-01f, 1.09921172e-01f,
  -1.49928778e-02f, -1.98965962e-03f, 7.72750080e-02f, -8.51375237e-02f, -6.39819121e-03f, -9.02616885e-03f, -1.76519334e-01f, 4.73726429e-02f, 2.16287803e-02f, 7.51518980e-02f,
  -3.28450426e-02f, 4.54410613e-02f, 9.92565677e-02f, 9.90593955e-02f, 2.94612944e-02f, 1.55794220e-02f, 3.21309939e-02f, 8.42117816e-02f, 4.03433181e-02f, 4.39002775e-02f,
  -9.54918936e-02f, -2.06453633e-02f, -5.46229407e-02f, 2.51899548e-02f, -2.07870752e-02f, -6.60505816e-02f, 3.98126692e-02f, 3.40997390e-02f, -5.57856075e-02f, 6.13474753e-03f,
  -1.28199860e-01f, 1.08730737e-02f, -6.35369718e-02f, 1.19614065e-01f, 9.89951491e-02f, -7.23543465e-02f, -4.81786169e-02f, -9.46986023e-03f, -6.60983697e-02f, -3.05396505e-02f,
  -1.03346154e-01f, 5.04468046e-02f, -4.35914956e-02f, -7.39589855e-02f, 1.69250332e-02f, 2.19060332e-02f, -3.99832949e-02f, 3.28946626e-03f, 2.98989490e-02f, -8.07367847e-04f,
  -8.48374441e-02f, -4.49622981e-03f, 4.86951359e-02f, -6.54237494e-02f, 2.00145617e-02f, 5.71689010e-02f, -3.88874486e-02f, 8.62214621e-03f, -1.26751096e-04f, -6.90948591e-02f,
  -6.83715492e-02f, -1.19121820e-01f, 4.32483964e-02f, 3.79071049e-02f, -5.68815209e-02f, -8.12129229e-02f, -8.97644982e-02f, -8.23788121e-02f, -4.42131720e-02f, 1.87863540e-02f,
  -2.89382022e-02f, 7.21416250e-02f, -7.75753632e-02f, 5.99231049e-02f, -2.43068133e-02f, -2.23420821e-02f, 3.03648524e-02f, 8.71286020e-02f, 1.12061083e-01f, -2.90291384e-03f,
  -1.19772768e-02f, -8.25515985e-02f, 6.52396232e-02f, 8.92707612e-04f, 2.66095940e-02f, -1.31343007e-01f, 3.04176733e-02f, -6.22086748e-02f, -7.86371063e-03f, -3.18577886e-02f,
  1.87052190e-01f, -1.15500957e-01f, -1.41774833e-01f, -4.62890677e-02f, 2.51857266e-02f, -1.14462435e-01f, -1.40887216e-01f, -1.68795899e-01f, -1.40071049e-01f, -5.12533970e-02f,
  -1.60694301e-01f, -1.41879439e-01f, -1.10871419e-02f, -2.74593323e-01f, 4.56231795e-02f, -1.99692417e-02f, -5.83684631e-02f, -3.42542194e-02f, -1.98410675e-02f, 2.95036975e-02f,
  1.00085922e-01f, -1.04646407e-01f, -1.20940544e-01f, -1.28040552e-01f, -1.32749379e-01f, 1.08453073e-01f, 1.06900670e-01f, 1.51716210e-02f, -6.51366264e-02f, -1.80939853e-01f,
  -4.30000573e-02f, -1.62473306e-01f, -6.03645444e-02f, -1.55195177e-01f, 7.57721066e-02f, 7.52124488e-02f, 2.23627733e-03f, -3.67571712e-02f, -6.44832477e-03f, -2.77395844e-02f,
  2.08221544e-02f, -5.25617115e-02f, -1.12480246e-01f, 4.95929085e-02f, 4.44800071e-02f, 7.70635437e-03f, -8.45580474e-02f, -1.75917804e-01f, 5.85400574e-02f, 1.41866831e-02f,
  -1.61281191e-02f, 1.85188558e-02f, 4.57724258e-02f, -1.02866469e-02f, 1.14253208e-01f, 4.02524918e-02f, 8.66879374e-02f, 1.27672806e-01f, -1.02739558e-02f, 1.62870094e-01f,
  5.02610281e-02f, 7.55385160e-02f, 4.05516326e-02f, -5.84485680e-02f, -4.74725210e-04f, 1.33129908e-03f, -8.12887028e-02f, -3.61737162e-02f, -1.05845723e-02f, 8.60141125e-03f,
  -2.81420872e-02f, -1.02549503e-02f, -2.12991703e-02f, -2.80887131e-02f, 8.78798887e-02f, -8.38850718e-03f, 3.40383090e-02f, 1.26709593e-02f, -3.33240703e-02f, -7.68887624e-02f,
  -8.31945390e-02f, 9.75806266e-03f, 2.68799569e-02f, -2.35524913e-03f, -4.04947996e-02f, -1.55531345e-02f, 8.34862329e-03f, 5.36037013e-02f, -4.66724783e-02f, -4.03984673e-02f,
  -1.29174963e-02f, 6.79622144e-02f, -9.96822268e-02f, -4.43407893e-02f, 9.19727888e-03f, -8.40646587e-03f, -8.42840597e-02f, -4.70324419e-02f, 4.20176871e-02f, 6.28211396e-03f,
  1.04314961e-01f, 1.33705856e-02f, 2.75077429e-02f, -2.20520459e-02f, -1.10022627e-01f, -2.88575552e-02f, 9.33484286e-02f, -9.09688100e-02f, -2.22605001e-02f, 4.59835976e-02f,
  6.11602180e-02f, -1.87386088e-02f, -7.58314803e-02f, 6.60551200e-03f, 6.38599461e-03f, 9.17115137e-02f, -2.57839207e-02f, 4.57761958e-02f, 1.92396902e-02f, 8.20449144e-02f,
  1.98420256e-01f, 2.93289244e-01f, 9.68054608e-02f, 2.69371301e-01f, -1.02664083e-01f, 3.83466110e-02f, -3.95847484e-02f, 5.40894978e-02f, 3.88621300e-01f, -1.93110202e-02f,
  -1.11024328e-01f, 3.48692864e-01f, -3.69518027e-02f, 4.14874665e-02f, 1.12208463e-01f, 1.48107842e-01f, 1.97418958e-01f, 5.67299649e-02f, 1.78220525e-01f, 7.34558478e-02f,
  1.69007406e-01f, -7.42350100e-03f, -9.92257968e-02f, -1.26400962e-01f, -9.93841588e-02f, 9.90217999e-02f, -1.97409645e-01f, -1.54960677e-01f, -1.11723036e-01f, -1.09790795e-01f,
  3.22228931e-02f, 1.52294397e-01f, -4.90374416e-02f, -8.03922489e-02f, -3.54147740e-02f, -5.70931099e-02f, -3.72460149e-02f, -1.04383327e-01f, -8.00191909e-02f, 6.05740398e-02f,
  2.17731558e-02f, -5.56768142e-02f, 6.07964359e-02f, 2.52873320e-02f, 2.57342327e-02f, -3.66582610e-02f, 1.18315546e-02f, -4.00318429e-02f, -5.63522615e-02f, -2.53821369e-02f,
  -4.09337319e-03f, 3.00858635e-02f, -1.96312810e-03f, -7.34961452e-03f, -8.04668199e-03f, 8.32286328e-02f, 2.89012101e-02f, 1.01674004e-02f, -7.09310547e-02f, 1.74169302e-01f,
  1.26228303e-01f, -4.30429652e-02f, 1.38559546e-02f, -4.41580042e-02f, -5.40771075e-02f, 6.61287308e-02f, 2.57324539e-02f, 1.07183596e-02f, 8.53420869e-02f, 4.36636806e-02f,
  1.07461132e-01f, -4.52590175e-02f, -5.53864986e-02f, 4.04598564e-02f, 1.60972297e-01f, 2.57048421e-02f, 4.07687724e-02f, -6.85430914e-02f, 1.97715089e-02f, 3.71911824e-02f,
  3.47664766e-02f, 3.91624821e-03f, -6.67717680e-02f, -1.28294215e-01f, 1.22309569e-02f, 1.08710080e-02f, 9.79915634e-03f, 1.55000773e-03f, 3.54548777e-03f, 1.14046820e-02f,
  1.23493277e-01f, 3.47630739e-01f, -5.57892844e-02f, -9.00809988e-02f, 1.13063455e-01f, 6.70353249e-02f, 4.05086726e-02f, -5.62280230e-03f, 1.66281074e-01f, -2.87495349e-02f,
  8.24763253e-02f, 1.73957106e-02f, 2.51781121e-02f, -2.59176362e-02f, -6.84822723e-02f, 5.92158139e-02f, 4.59136181e-02f, 1.60657205e-02f, 3.74492258e-02f, -3.38795106e-03f,
  -4.51366864e-02f, 2.53632348e-02f, 6.70029521e-02f, -4.51249187e-04f, -5.39624924e-03f, -3.67437452e-02f, 1.06830690e-02f, -7.70314485e-02f, -8.73282901e-04f, 1.62643433e-01f,
  2.56509148e-02f, -6.24752678e-02f, 1.92876995e-01f, 3.06327403e-01f, -6.78623021e-02f, -3.04810554e-01f, -2.36728832e-01f, 1.60071589e-02f, 3.62754688e-02f, -1.71239793e-01f,
  5.41118905e-02f, 1.47696391e-01f, -8.44909921e-02f, 1.19091287e-01f, 9.55187604e-02f, -1.23722844e-01f, 1.19189665e-01f, 8.71346518e-02f, 2.65486240e-02f, 1.42003089e-01f,
  1.41240209e-01f, 4.47791778e-02f, 2.59998351e-01f, 1.38469756e-01f, 1.71022099e-02f, 2.01260284e-01f, -5.78276254e-03f, -9.57311541e-02f, 1.17233180e-01f, 9.36698727e-03f,
  -8.64932388e-02f, -6.41755983e-02f, 7.13379905e-02f, 8.33210200e-02f, -7.31582493e-02f, -8.65660701e-03f, -2.39746980e-02f, -1.19214959e-03f, 8.10053051e-02f, -6.50711134e-02f,
  -8.23340658e-03f, 7.24047422e-02f, -5.23125455e-02f, 4.51890379e-02f, 3.93790789e-02f, 1.29269123e-01f, -3.42666358e-03f, -2.90323910e-03f, 7.84829110e-02f, 7.46477172e-02f,
  2.14234535e-02f, -4.42439807e-04f, 4.50953208e-02f, -3.79856639e-02f, 1.68391168e-02f, -1.10543668e-01f, -1.41142234e-01f, 4.71543260e-02f, 9.47077479e-03f, 6.85653761e-02f,
  -1.34928390e-01f, 2.58962624e-02f, -1.27062388e-02f, 4.72831205e-02f, 4.67064455e-02f, 2.88553461e-02f, -8.82167835e-03f, -5.06904535e-02f, 1.11536928e-01f, -6.79974109e-02f,
  3.75253372e-02f, -3.79574150e-02f, -1.95066724e-02f, 7.85815939e-02f, -6.22675642e-02f, -2.67658476e-02f, 3.35143767e-02f, -2.91651804e-02f, -2.88232304e-02f, 6.40458101e-03f,
  2.70526726e-02f, 1.10709621e-02f, -2.76903119e-02f, -4.91143242e-02f, -2.92830002e-02f, -1.88512895e-02f, 3.56061943e-03f, -6.77702054e-02f, -5.69303939e-03f, 8.85639153e-03f,
  5.39766178e-02f, 4.11566086e-02f, -1.09666837e-02f, -4.60710004e-02f, -1.76399983e-02f, -9.03810114e-02f, -3.55922058e-02f, -1.54100051e-02f, 1.88008733e-02f, 8.13904405e-02f,
  -3.90513018e-02f, -5.88261522e-03f, -3.55444173e-03f, 7.00413212e-02f, 4.13739309e-02f, -1.39634823e-02f, 3.48478854e-02f, 7.48813152e-02f, 3.83744799e-02f, 8.01236257e-02f,
  -4.71642241e-02f, -9.20422375e-02f, 5.80006577e-02f, -2.47353707e-02f, -6.77041709e-02f, -7.55839497e-02f, -6.70386106e-02f, -1.79418200e-03f, -2.31842473e-02f, -3.56691852e-02f,
  -6.19242311e-01f, 2.59722859e-01f, 1.28635675e-01f, -3.95375252e-01f, 1.23932876e-01f, -1.69088408e-01f, -1.58058152e-01f, 1.05306715e-01f, -9.09130555e-03f, -8.36566370e-03f,
  5.34025431e-02f, -9.41221714e-02f, 1.58700898e-01f, -4.83159274e-02f, -6.23147711e-02f, 6.97842166e-02f, -7.39335492e-02f, -2.39944026e-01f, 5.26864044e-02f, -6.01019822e-02f,
  -1.05664611e-01f, 5.95080703e-02f, -1.61620174e-02f, 2.16154844e-01f, -7.14548901e-02f, -5.22487611e-02f, -1.57115310e-01f, 1.26600668e-01f, -5.54677323e-02f, 7.59545043e-02f,
  -2.15034440e-01f, -2.75807768e-01f, -9.74886566e-02f, -1.64532959e-01f, -1.41318783e-01f, -1.09489627e-01f, -1.57783225e-01f, -7.56294001e-04f, -2.34387517e-02f, -1.83133241e-02f,
  -1.41212657e-01f, -9.21438169e-03f, -3.47887725e-02f, 6.97528794e-02f, -8.96125436e-02f, -3.48507240e-02f, 1.20647095e-01f, 2.65238862e-02f, -1.19784242e-02f, 1.15877524e-01f,
  9.20726061e-02f, 1.77429625e-04f, -1.09912284e-01f, -8.32803547e-02f, -2.61420384e-02f, -1.01196775e-02f, -6.74800798e-02f, -3.06360554e-02f, -8.76606405e-02f, 2.33679190e-02f,
  -1.82463136e-02f, -1.92883480e-02f, 7.27556366e-03f, 5.92132136e-02f, 4.05348875e-02f, 6.20053969e-02f, 3.87957916e-02f, -6.79394603e-02f, -1.24599477e-02f, 1.92539170e-02f,
  -6.38545677e-02f, -5.06505035e-02f, -5.21047898e-02f, -2.00490225e-02f, 5.64449690e-02f, -2.73427442e-02f, -4.48770449e-02f, 2.42183227e-02f, 4.37654965e-02f, -6.92797452e-03f,
  -6.30565593e-03f, -3.18049304e-02f, -3.06505952e-02f, -1.85049698e-02f, -9.99497343e-03f, -2.64137182e-02f, -1.09096123e-02f, 1.84988193e-02f, -9.98140275e-02f, -2.36377050e-03f,
  -4.55063313e-01f, -3.70535344e-01f, -7.48427436e-02f, -1.35152310e-01f, -5.50445542e-02f, -8.89124498e-02f, 7.17950892e-03f, -5.27507104e-02f, -5.02501242e-02f, 3.44390534e-02f,
  7.62490649e-03f, 6.42889598e-03f, -3.51651162e-02f, 4.03876863e-02f, 8.34835172e-02f, -1.51270174e-03f, -3.86961587e-02f, -9.70037356e-02f, -5.17157465e-02f, 4.53555211e-02f,
  4.95030824e-03f, -2.17675548e-02f, 3.30946669e-02f, -1.17287748e-02f, -8.08294490e-02f, -1.32067412e-01f, -5.43888733e-02f, 5.62588684e-02f, -8.34698044e-03f, 1.95172150e-02f,
  -2.39416793e-01f, -1.50449201e-01f, 1.03256973e-02f, -7.87475109e-02f, 3.51831727e-02f, 5.06731197e-02f, -2.89992597e-02f, 2.77198143e-02f, -2.72388607e-01f, 7.48389736e-02f,
  7.91608393e-02f, -8.75152946e-02f, -5.19898534e-02f, 6.63534105e-02f, -2.69638635e-02f, -1.11790188e-01f, 1.13910526e-01f, 1.25027493e-01f, 1.98480617e-02f, 1.08956262e-01f,
  1.58152103e-01f, 1.17557056e-01f, 1.94542259e-01f, 1.28455594e-01f, 3.60200182e-02f, 1.18338771e-01f, 1.59692690e-01f, 1.35584220e-01f, 1.96051300e-01f, -1.39537817e-02f,
  -1.18303578e-02f, -4.51145060e-02f, -2.50208434e-02f, -5.85226109e-03f, 5.01719974e-02f, 4.16904949e-02f, 8.29315037e-02f, 1.00836523e-01f, 7.37179071e-02f, 8.15678760e-02f,
  -8.47273041e-03f, 3.45126688e-02f, -3.15126255e-02f, -1.91553365e-02f, 5.23544848e-02f, -3.79991196e-02f, 6.63670376e-02f, -6.34862110e-02f, 5.71484379e-02f, -3.20788547e-02f,
  1.05185416e-02f, 4.43318188e-02f, -8.53705853e-02f, -1.28225937e-01f, -7.04391897e-02f, -2.55530402e-02f, -5.12210652e-02f, -7.20456988e-02f, -5.07528968e-02f, 2.96352264e-02f,
  -4.16658893e-02f, 3.84660379e-04f, -4.09814231e-02f, -1.35962963e-01f, -6.96630850e-02f, 1.10701565e-02f, -4.50925715e-02f, 4.98259403e-02f, 9.08508338e-03f, 9.83842462e-02f,
  6.00237120e-03f, 1.51149118e-02f, -5.23829483e-04f, 6.13933988e-02f, 1.51377879e-02f, -3.30201276e-02f, 1.77109957e-01f, 8.39697942e-02f, -1.04286380e-01f, -9.19948891e-03f,
  6.90639615e-02f, 2.04142611e-02f, -3.42251807e-02f, 3.67691889e-02f, 5.83267622e-02f, -2.48817950e-02f, 3.24730091e-02f, 3.28920991e-03f, -1.95854772e-02f, -4.08899896e-02f,
  7.31547177e-03f, -3.52027491e-02f, 3.75580639e-02f, -2.47005653e-03f, 1.70520600e-02f, 2.97782905e-02f, 9.76755545e-02f, 2.35225260e-02f, 5.48254848e-02f, 3.89323570e-02f,
  1.46360174e-01f, -7.81267732e-02f, 1.53311621e-02f, -3.12886052e-02f, 3.35855968e-02f, -5.15998527e-02f, -5.25357462e-02f, -9.37081873e-03f, 4.00916710e-02f, 7.85625055e-02f,
  3.01219262e-02f, 3.96040529e-02f, -3.43441777e-02f, -8.44149739e-02f, 9.36379191e-03f, -8.51588994e-02f, -6.33158162e-02f, 2.88950671e-02f, -4.13585305e-02f, 3.11183017e-02f,
  -1.60459235e-01f, -7.16340169e-02f, -1.77988991e-01f, -1.23373911e-01f, 8.23494568e-02f, -1.10497572e-01f, -1.65709168e-01f, 7.32011124e-02f, -2.18462944e-01f, -4.34120446e-02f,
  -2.94639263e-02f, -1.42791152e-01f, -1.29101217e-01f, -2.25800306e-01f, -1.26174659e-01f, -2.52700776e-01f, -9.30414870e-02f, -1.60229847e-01f, -1.23902028e-02f, 1.16201483e-01f,
  4.26827036e-02f, 8.38006437e-02f, -1.09440990e-01f, 1.01035841e-01f, -1.04266210e-02f, 1.61303520e-01f, 3.95019412e-01f, 7.67953396e-02f, 2.38871247e-01f, 1.81579974e-03f,
  -4.92071547e-02f, -4.84048687e-02f, -1.59963816e-01f, -7.19104856e-02f, 1.29038781e-01f, 1.65235139e-02f, 3.25740344e-04f, -3.36844772e-02f, -1.76156238e-02f, 6.20971620e-02f,
  -5.15858643e-02f, -1.79905724e-02f, 1.17340013e-01f, -7.45793656e-02f, 3.12333982e-02f, -1.57783162e-02f, 1.89385395e-02f, -4.04478163e-02f, 4.18898687e-02f, -9.61991027e-02f,
  3.80591787e-02f, 1.10915415e-02f, -4.39098552e-02f, 3.50467116e-02f, -7.97197595e-02f, 7.49788731e-02f, 9.39564854e-02f, 2.47275736e-02f, -2.54727397e-02f, 1.10334344e-01f,
  8.12777877e-02f, 1.02156535e-01f, 6.14625076e-03f, -1.22245692e-01f, -6.61950652e-03f, -1.00740433e-01f, -9.69916731e-02f, 2.58158445e-02f, -7.17348903e-02f, 4.59773876e-02f,
  2.91037615e-02f, -1.16627216e-02f, -2.02527270e-02f, -5.90496045e-03f, 9.23952982e-02f, -9.50483829e-02f, 5.59703670e-02f, 1.19220577e-01f, 6.54856637e-02f, -8.22573528e-02f,
  -3.42832841e-02f, -7.01939221e-03f, -2.43727751e-02f, -1.94535963e-02f, -6.42994717e-02f, 7.26582333e-02f, -1.47489281e-02f, 1.27024025e-01f, -4.63341884e-02f, 6.88364357e-02f,
  6.86804354e-02f, 1.25746280e-01f, -5.62478267e-02f, -1.39990086e-02f, -8.00518245e-02f, -4.13393639e-02f, -1.02266312e-01f, -7.32019171e-02f, -7.26888552e-02f, 6.13825284e-02f,
  6.12329878e-02f, 8.67393762e-02f, 1.53000066e-02f, -1.74592845e-02f, 7.98332170e-02f, 3.85672264e-02f, 2.90795974e-02f, -4.34960388e-02f, -5.30925170e-02f, 8.29264745e-02f,
  1.96252652e-02f, 6.21965528e-02f, -2.63323914e-03f, -1.44870020e-02f, -4.45140339e-02f, 1.09572709e-01f, 1.51893467e-01f, 5.82686178e-02f, -3.45468782e-02f, -1.60943512e-02f,
  2.02114865e-01f, 1.76455289e-01f, 8.79070982e-02f, 1.09044790e-01f, -4.69641313e-02f, -9.74221230e-02f, -7.85066411e-02f, 4.39619226e-03f, -8.20636153e-02f, -4.53975238e-02f,
  -7.38109276e-02f, 2.02062115e-01f, -1.34049878e-01f, 7.14858621e-02f, 8.57979711e-03f, -1.98788047e-01f, 1.45323083e-01f, 1.27965629e-01f, -9.17626172e-02f, 1.13212526e-01f,
  -1.93520173e-04f, 4.51810956e-02f, -4.29491140e-02f, 4.23706509e-02f, 1.50618255e-01f, 6.91249967e-02f, 5.03324531e-02f, -1.80137008e-02f, 1.62676767e-01f, 6.68718815e-02f,
  -6.67719543e-02f, 2.81046536e-02f, 7.06319213e-02f, 3.47600766e-02f, -9.53264236e-02f, 9.74164065e-03f, -3.33228000e-02f, 1.02090970e-01f, 5.49501255e-02f, -5.33988029e-02f,
  5.34769669e-02f, -9.42033380e-02f, -8.51818547e-02f, 2.69086044e-02f, 1.12298839e-01f, -7.15791211e-02f, 9.93594714e-03f, -3.57516902e-03f, -1.77155323e-02f, 6.64670616e-02f,
  -1.12079754e-02f, 2.28529572e-02f, 9.87763479e-02f, -1.77392140e-02f, -5.88463843e-02f, -3.05625033e-02f, 2.84498669e-02f, 1.19863197e-01f, 1.39186561e-01f, 1.94665859e-03f,
  -6.77366834e-03f, 1.12897016e-01f, 7.69511387e-02f, -3.78653407e-02f, -4.11366001e-02f, -7.95969218e-02f, -2.86348630e-02f, -5.12911864e-02f, -9.79644898e-03f, 7.21288286e-03f,
  5.14449850e-02f, -2.12987028e-02f, -2.95161828e-02f, -4.15649312e-03f, 3.72729897e-02f, 4.89834920e-02f, -1.17122028e-02f, 1.91776990e-03f, 8.27722624e-03f, -1.94982700e-02f,
  -6.86860308e-02f, 8.43257178e-03f, 6.26040995e-02f, 1.34466439e-02f, -5.62101454e-02f, -8.29444006e-02f, -2.53938176e-02f, -2.43104110e-03f, -2.74725109e-02f, 6.76419586e-02f,
  8.86410549e-02f, 7.12175146e-02f, -7.06199035e-02f, 1.39232480e-03f, -1.63387582e-01f, 4.60735746e-02f, -5.25002256e-02f, 5.89041635e-02f, 4.71077338e-02f, -7.23749101e-02f,
  -3.04604564e-02f, 6.89163245e-03f, -2.13929862e-02f, 5.42469732e-02f, 4.02296335e-02f, 2.93198675e-02f, -4.90719453e-02f, -2.31093951e-02f, 2.35394873e-02f, -5.96371153e-03f,
  9.78483483e-02f, 2.49985158e-02f, -3.01092491e-02f, -2.41088979e-02f, -8.16706046e-02f, 1.82981081e-02f, -3.66756357e-02f, 1.51842341e-01f, 1.66139612e-03f, 1.28541002e-02f,
  -4.38710265e-02f, -9.30846483e-02f, 1.05719589e-01f, -1.48488194e-01f, -1.12461507e-01f, 1.02139972e-01f, 2.65123457e-01f, -2.24335298e-01f, -2.98453510e-01f, -2.07359627e-01f,
  -1.32527873e-01f, 1.25830278e-01f, 2.48571575e-01f, -2.73265392e-02f, 2.91199327e-01f, 2.20636666e-01f, -4.95937653e-02f, 5.45961037e-02f, 3.95679772e-02f, 2.08929759e-02f,
  1.35654770e-02f, -9.72547680e-02f, 2.87495524e-01f, -1.18052445e-01f, -1.33363288e-02f, -1.08349249e-01f, 2.90410239e-02f, 6.52184114e-02f, -1.72139287e-01f, 6.38287216e-02f,
  1.11118950e-01f, 9.13566630e-03f, 5.88088594e-02f, 2.47582737e-02f, 6.50371388e-02f, 5.61884642e-02f, 9.87057611e-02f, 1.82147428e-01f, 2.26825681e-02f, -1.83558967e-02f,
  8.03624764e-02f, -9.60838608e-03f, -1.30121484e-01f, -4.18356061e-02f, -9.96407494e-02f, -4.32356820e-02f, 3.05042230e-02f, -3.09826843e-02f, -2.76543368e-02f, 1.07283443e-01f,
  8.19033235e-02f, -7.28042498e-02f, -9.94493067e-02f, 3.15575823e-02f, -8.16534683e-02f, -1.70133263e-01f, 3.19943239e-04f, 1.04994945e-01f, -2.62767859e-02f, 5.46459369e-02f,
  9.34373662e-02f, -9.35644028e-04f, 1.01570696e-01f, -9.81419235e-02f, 5.61704747e-02f, -1.03158347e-01f, -2.13004611e-02f, 5.72963059e-02f, -1.30959600e-01f, -2.84050442e-02f,
  -1.03289768e-01f, -7.86874667e-02f, -1.49459764e-02f, -3.28361653e-02f, -1.98199432e-02f, -9.61144716e-02f, 1.43563785e-02f, -5.27389236e-02f, -9.09061357e-02f, -3.38611901e-02f,
  2.87815612e-02f, 8.00032690e-02f, 3.80677693e-02f, -1.85458735e-02f, 2.06855778e-02f, 6.06134944e-02f, -3.76422815e-02f, -1.56454295e-01f, 2.64060739e-02f, 1.42725453e-01f,
  -8.51637498e-02f, -1.51767552e-01f, 8.02583247e-03f, -4.79093194e-02f, 5.06836511e-02f, 5.56644350e-02f, 1.93915870e-02f, -9.18788910e-02f, -5.05483039e-02f, 1.13981143e-01f,
  -9.62284021e-03f, 5.83360307e-02f, 2.84072850e-02f, 8.90364754e-04f, -7.98897594e-02f, 5.39487228e-02f, 1.07363679e-01f, 3.06771751e-02f, -4.28449735e-02f, -6.91951662e-02f,
  -7.27316588e-02f, -2.65255775e-02f, 6.43191636e-02f, -8.18783119e-02f, -7.72594661e-02f, -1.14227742e-01f, 6.07336359e-03f, -2.95540057e-02f, 3.25862058e-02f, -2.16621533e-02f,
  -7.42471367e-02f, 1.97409261e-02f, -9.52573344e-02f, -2.15460166e-01f, 5.24535775e-02f, -2.27837250e-01f, -2.96062797e-01f, -1.93976853e-02f, 1.06895985e-02f, -1.41805932e-01f,
  -2.08987147e-01f, 1.14416495e-01f, 8.44113603e-02f, -2.47967914e-01f, 1.30414039e-01f, 1.02402709e-01f, -1.87514827e-01f, -1.06946692e-01f, 1.09448500e-01f, -1.88283905e-01f,
  1.78584270e-02f, -1.64921299e-01f, 1.29075557e-01f, 2.22197957e-02f, -1.23770773e-01f, -6.79446310e-02f, -2.82128491e-02f, -1.56220958e-01f, -8.31882432e-02f, 1.50099704e-02f,
  -1.53763052e-02f, 1.68708414e-02f, 8.60168636e-02f, 6.38080686e-02f, 1.14577310e-02f, -4.56983931e-02f, -1.22506745e-01f, 2.19405014e-02f, -5.46937957e-02f, -1.25960382e-02f,
  -5.82215972e-02f, 9.63478908e-03f, -3.13632190e-02f, -4.80355136e-02f, -6.25274554e-02f, -8.68269429e-02f, 1.31759010e-02f, -1.72029343e-02f, 1.24834679e-01f, 4.22776565e-02f,
  4.58259648e-03f, -4.65918565e-03f, -4.62232381e-02f, 4.43960391e-02f, 7.95389190e-02f, -4.98652086e-02f, 7.05025494e-02f, 4.13882248e-02f, 4.99178916e-02f, 4.10878100e-03f,
  -3.53171974e-02f, -8.54939669e-02f, -1.64736491e-02f, -2.60007065e-02f, -3.13283950e-02f, -9.11326930e-02f, 4.28665010e-03f, -3.00477054e-02f, -6.83739781e-02f, 1.44766383e-02f,
  4.56103459e-02f, 1.00524977e-01f, 1.87647063e-02f, -4.91685979e-02f, -7.52608255e-02f, 1.89169794e-02f, -5.61107211e-02f, 7.74751697e-03f, -7.45343193e-02f, 4.22625877e-02f,
  1.58243831e-02f, -2.53564026e-02f, 1.91264655e-02f, -4.74906638e-02f, -7.22058639e-02f, 4.71336581e-02f, 7.52801672e-02f, 9.10006580e-04f, -8.94722342e-03f, -4.73876996e-03f,
  3.71029116e-02f, -4.34499122e-02f, 7.09480569e-02f, 8.53816718e-02f, 6.77633435e-02f, -5.90756349e-02f, 6.89988285e-02f, 4.18701544e-02f, -8.13500360e-02f, -8.84098038e-02f,
  -1.32696718e-01f, -1.99040864e-02f, -2.18962040e-02f, -9.99288727e-03f, 4.34676372e-02f, -1.18270375e-01f, -9.25941989e-02f, -2.42156591e-02f, 2.45395973e-02f, 2.71520559e-02f,
  2.37649716e-02f, 4.60830256e-02f, -3.00796498e-02f, -6.84165359e-02f, 3.86484228e-02f, -5.37033379e-02f, 1.02185272e-01f, 4.15102169e-02f, -8.26884732e-02f, -6.68335333e-02f,
  -3.86445940e-01f, 2.14561343e-01f, -1.17641516e-01f, 8.28118026e-02f, 2.83093713e-02f, 2.53878981e-01f, 3.34695637e-01f, 8.35787412e-03f, 7.49256015e-02f, 1.16212323e-01f,
  1.34458452e-01f, 7.45130405e-02f, 9.07396525e-02f, 2.95333892e-01f, 2.23065540e-01f, 1.96469501e-01f, 2.00590089e-01f, 7.06352219e-02f, -6.16023988e-02f, -1.17899455e-01f,
  -3.62169072e-02f, 1.05310209e-01f, 5.43219931e-02f, -8.22129548e-02f, -2.01725923e-02f, -2.37981901e-01f, -6.53851554e-02f, 2.73048282e-02f, 3.72100100e-02f, 1.59475863e-01f,
  -1.01522349e-01f, -1.86030924e-01f, -1.11557260e-01f, -1.17423691e-01f, 2.96199825e-02f, -9.22474731e-03f, 6.15182109e-02f, 3.95705029e-02f, 1.65313464e-02f, -1.70262214e-02f,
  3.05761416e-02f, -1.86717079e-03f, -4.85304929e-02f, 3.49236503e-02f, 2.40105242e-02f, -3.51682901e-02f, -1.20723061e-02f, -2.61720028e-02f, -2.80031413e-02f, 7.18799978e-02f,
  -3.68198790e-02f, 7.42920563e-02f, 5.36731705e-02f, 2.02133097e-02f, 6.77535236e-02f, -8.57848115e-03f, -2.60218163e-03f, 2.11761035e-02f, 7.17935190e-02f, 5.13463747e-03f,
  -6.84032962e-02f, 3.04210894e-02f, 4.33575958e-02f, -8.96054506e-02f, -1.86416842e-02f, -3.08946632e-02f, 2.31503081e-02f, -4.62014824e-02f, 5.10157719e-02f, 3.61958183e-02f,
  1.31372028e-04f, 7.50072673e-02f, -6.52034655e-02f, -5.17903604e-02f, -1.91079658e-02f, -1.17941052e-02f, -2.85559557e-02f, -6.85513988e-02f, -3.40929776e-02f, 1.51919704e-02f,
  -8.34003687e-02f, -1.55764017e-02f, 8.88522789e-02f, -2.32296530e-02f, 8.47584847e-03f, 1.40998140e-03f, 3.90898809e-02f, 3.03541441e-02f, 1.21410796e-02f, 9.09767114e-03f,
  1.47431865e-01f, -1.57943796e-02f, 1.76618267e-02f, -9.23304074e-03f, 4.92433757e-02f, -1.43826410e-01f, 2.34757494e-02f, -2.30591968e-02f, 1.00410111e-01f, 3.25532220e-02f,
  -1.46287279e-02f, -9.13512334e-03f, 1.73555091e-02f, 3.42800794e-03f, 5.26109561e-02f, 1.03671029e-01f, -4.49485853e-02f, -1.33666191e-02f, 1.54018924e-02f, -1.95103753e-02f,
  -2.74959076e-02f, -3.48561779e-02f, -3.91541123e-02f, -3.90956812e-02f, 2.19930615e-02f, -3.84849263e-03f, 8.29640590e-03f, -2.75319279e-03f, 2.45700683e-02f, 5.75875603e-02f,
  4.42992896e-01f, -2.47135222e-01f, 1.19549535e-01f, 3.84214997e-01f, 2.62328893e-01f, -9.65547040e-02f, 9.72700790e-02f, 1.39736459e-01f, 2.28674456e-01f, -2.71706581e-01f,
  5.55451028e-02f, -1.47123665e-01f, -1.70151725e-01f, 1.47397295e-01f, 1.26970977e-01f, -9.78949144e-02f, 1.54760122e-01f, -1.38929198e-02f, 6.26288578e-02f, 9.48484167e-02f,
  2.15924606e-01f, 7.45735019e-02f, 2.09675375e-02f, 5.72680309e-02f, 1.02203012e-01f, 1.23822816e-01f, 6.32336661e-02f, -1.17951632e-01f, 1.34920537e-01f, -1.53372437e-01f,
  -5.05383536e-02f, 7.06832781e-02f, -1.31267626e-02f, -3.48713808e-02f, -4.20468301e-02f, -5.29779866e-02f, -1.69592470e-01f, 1.50566110e-02f, 7.88754821e-02f, 2.11355854e-02f,
  6.75614038e-03f, 1.72978379e-02f, 3.44760902e-02f, 1.25203520e-01f, -9.78237391e-03f, 1.52385727e-01f, 2.98524536e-02f, -1.88681856e-02f, -2.87278323e-03f, 8.29944909e-02f,
  1.92041770e-02f, 1.34024490e-02f, 8.80380794e-02f, -4.17304561e-02f, 1.05284199e-01f, 7.33306333e-02f, 2.85980087e-02f, -9.29877441e-03f, 4.47435938e-02f, 5.85877672e-02f,
  -4.31737043e-02f, -3.61582078e-02f, 4.37823823e-03f, 5.12595065e-02f, -6.75285086e-02f, 9.97509807e-02f, -7.90139008e-03f, 4.09825407e-02f, -5.02548665e-02f, -7.53795281e-02f,
  4.39284705e-02f, 3.10515892e-02f, -3.57384495e-02f, -4.41934802e-02f, -1.12676974e-02f, 5.37043549e-02f, -2.62687430e-02f, 7.16009662e-02f, -1.08821116e-01f, 5.09501547e-02f,
  5.61558455e-02f, -3.27565707e-02f, 2.80131269e-02f, 1.19424537e-02f, 4.00159508e-02f, -3.29847750e-03f, 4.32301164e-02f, -4.39575948e-02f, -1.08400378e-02f, -3.60297300e-02f,
  -3.14632207e-01f, -2.34107986e-01f, -8.19755346e-02f, -6.63897395e-02f, -2.56544799e-02f, 2.59946492e-02f, -5.12993410e-02f, -2.65350528e-02f, -2.80640293e-02f, -3.38908546e-02f,
  -8.45765918e-02f, 3.57966982e-02f, -6.06846511e-02f, -2.02375371e-03f, -1.83542311e-01f, 3.79243232e-02f, 1.46018423e-03f, -1.68174103e-01f, -6.96717799e-02f, -2.63815224e-02f,
  -7.02824965e-02f, 1.33949863e-02f, 8.07064995e-02f, 1.41945379e-02f, 5.39462194e-02f, -1.54132834e-02f, 4.52877209e-02f, 9.28517897e-03f, 5.53258732e-02f, -7.52129331e-02f,
  -3.62222791e-02f, -2.85188735e-01f, -2.66404506e-02f, 2.39687301e-02f, 1.66387498e-01f, 1.60289690e-01f, 8.11455697e-02f, -2.46635213e-01f, -2.88334072e-01f, -9.15073529e-02f,
  6.03233129e-02f, 1.34859473e-01f, 3.38491499e-02f, -1.05130002e-02f, 1.91965118e-01f, -9.06149223e-02f, -7.89968148e-02f, 1.18952595e-01f, -1.31798565e-01f, 1.61184743e-02f,
  -4.15550265e-03f, -6.76297173e-02f, 4.04577367e-02f, -5.21597080e-02f, 7.69432308e-03f, 7.41369203e-02f, 1.37681216e-01f, 1.58970267e-01f, 5.19802645e-02f, 2.52474159e-01f,
  -1.06293559e-01f, -9.12117660e-02f, -7.40079209e-02f, -2.57691070e-02f, -6.52750731e-02f, -4.85029817e-02f, 8.12288895e-02f, 1.65508285e-01f, 5.17101996e-02f, -1.64210960e-01f,
  4.05689627e-02f, -4.70108725e-03f, -7.40294829e-02f, -5.16448915e-02f, -9.79665443e-02f, 3.95580903e-02f, -7.43986573e-03f, -3.41220424e-02f, 2.45456770e-02f, 3.57048213e-02f,
  -6.27254844e-02f, 3.34704220e-02f, -2.55452357e-02f, 3.35986726e-02f, -1.98326074e-02f, -5.88639006e-02f, 5.05061783e-02f, 5.50278723e-02f, -5.34413084e-02f, 5.20534068e-03f,
  -1.85790695e-02f, -3.21323983e-02f, -4.77494411e-02f, -1.30298823e-01f, 2.47729234e-02f, -6.00993969e-02f, -2.36839000e-02f, 1.06829233e-01f, 7.52254203e-02f, 6.14531105e-03f,
  -6.03794344e-02f, -1.05646662e-01f, -2.87485532e-02f, -9.67707485e-03f, -2.82129776e-02f, -9.33863968e-03f, 3.26904282e-02f, 7.43906349e-02f, -9.48450863e-02f, -1.10794064e-02f,
  -1.40137877e-02f, -9.53675583e-02f, -3.76064181e-02f, -3.86637449e-02f, -4.17304784e-03f, -9.29782819e-03f, 5.64668290e-02f, -4.53976318e-02f, -2.97731701e-02f, 6.75850809e-02f,
  -1.46101534e-01f, -1.84037045e-01f, -3.24077792e-02f, -7.32838595e-03f, -3.37951332e-02f, 1.69584937e-02f, 2.42030993e-02f, -1.85919125e-02f, -3.77649292e-02f, -4.15358730e-02f,
  -1.07612852e-02f, 4.78043482e-02f, 4.25147489e-02f, -6.89401999e-02f, 9.67173353e-02f, -1.23107329e-01f, -1.51856625e-02f, 4.93402556e-02f, 1.00301303e-01f, 2.24935841e-02f,
  -7.48097375e-02f, 4.13870886e-02f, 8.31120089e-02f, -1.91721283e-02f, 2.16733254e-02f, 7.89868906e-02f, -2.54878812e-02f, 5.93829714e-02f, -2.87074503e-02f, 2.70574726e-02f,
  9.91604924e-02f, -1.60587400e-01f, -2.71360755e-01f, -6.26999140e-02f, 2.19408944e-01f, 2.11897582e-01f, -9.07733291e-02f, 5.94350584e-02f, -1.29974276e-01f, 4.65161167e-02f,
  8.99594128e-02f, -1.72383547e-01f, -2.80300140e-01f, -1.33765710e-03f, -5.28252460e-02f, -4.24027026e-01f, 2.11794272e-01f, -1.56704523e-02f, -1.09039724e-01f, 4.69978489e-02f,
  -9.74745862e-03f, 2.49581665e-01f, -1.48851588e-01f, 2.62332886e-01f, 1.68998078e-01f, -2.42802501e-02f, 3.07053834e-01f, -6.18492179e-02f, 2.16130883e-01f, 8.72908607e-02f,
  1.63927842e-02f, -1.02819271e-01f, -2.23139711e-02f, -3.27926241e-02f, 8.88386890e-02f, 1.63231969e-01f, 4.48834710e-02f, -1.58039127e-02f, 8.46671872e-04f, -1.01916209e-01f,
  -3.30355368e-03f, 2.58448757e-02f, 6.06468283e-02f, -9.09318328e-02f, 4.52630110e-02f, -7.93940648e-02f, -9.45004150e-02f, 1.41894370e-02f, -1.60253048e-01f, -1.42601490e-01f,
  -5.82469665e-02f, -2.44662724e-02f, -4.05967422e-02f, 8.82555824e-03f, -2.08565351e-02f, 1.71378478e-02f, 1.26765557e-02f, 6.18518293e-02f, 9.94083732e-02f, -1.09019065e-02f,
  9.52619612e-02f, -7.98801612e-03f, -5.07885851e-02f, 7.93685392e-03f, -5.70364259e-02f, -2.28349604e-02f, 7.97162130e-02f, -1.01363823e-01f, -6.59652799e-02f, 3.30671594e-02f,
  4.89006750e-02f, -6.10279758e-03f, 6.97212145e-02f, 8.67097303e-02f, 1.03629231e-01f, 2.61118449e-02f, 7.77541995e-02f, 4.10768799e-02f, -5.15947118e-03f, 9.86858737e-04f,
  -4.39874046e-02f, 1.24813206e-01f, -4.11148407e-02f, 5.13319485e-02f, 4.58495542e-02f, -2.95768417e-02f, 6.81313919e-03f, -7.98355136e-03f, -6.17239811e-02f, 3.45616490e-02f,
  8.21111947e-02f, 1.43447965e-01f, -5.76007850e-02f, -3.80865633e-02f, -3.44142020e-02f, 8.96168724e-02f, -7.78986067e-02f, 6.52115643e-02f, 5.35121150e-02f, 1.53128139e-03f,
  1.34818226e-01f, -5.71017750e-02f, 1.47923768e-01f, -2.37890016e-02f, 6.23789392e-02f, 7.55193532e-02f, 5.43458201e-02f, -3.11633963e-02f, 1.58261910e-01f, 8.45147856e-03f,
  3.57441008e-02f, 1.78109556e-02f, 3.86661701e-02f, 8.79176892e-03f, 5.56223281e-02f, 3.93102765e-02f, 1.35128528e-01f, 7.11840913e-02f, 3.58634666e-02f, -6.89803883e-02f,
  9.79404598e-02f, -3.83241624e-02f, 7.53456876e-02f, -1.06583469e-01f, -1.19848728e-01f, 1.06773302e-01f, 1.02171712e-01f, 1.71492249e-02f, -6.14860021e-02f, 4.31398898e-02f,
  -6.25963211e-02f, 2.17114523e-01f, 1.98062688e-01f, -3.26075107e-02f, 2.65255958e-01f, 9.04359445e-02f, -2.50511523e-02f, -1.32191852e-01f, 3.81830323e-04f, 6.33057430e-02f,
  -3.32974270e-02f, -2.44959533e-01f, 1.83604807e-01f, -1.43540978e-01f, -8.12490750e-03f, -3.38349380e-02f, -8.04898739e-02f, -5.93636557e-03f, -1.16380490e-01f, 7.05722254e-03f,
  -1.19557537e-01f, -5.18617593e-02f, -5.20414710e-02f, 5.26783876e-02f, -1.02983080e-01f, -3.46583053e-02f, 5.64428419e-03f, 5.60949892e-02f, -2.07273513e-01f, 7.83751756e-02f,
  4.33800928e-02f, 3.89322685e-03f, -9.48010534e-02f, -2.36566905e-02f, 3.61907319e-03f, -7.10437670e-02f, -5.56129664e-02f, -8.19870383e-02f, 4.44211848e-02f, 9.74177048e-02f,
  5.01961559e-02f, 4.79262993e-02f, -3.85749415e-02f, 8.15031976e-02f, 1.19003765e-01f, -1.63296163e-01f, 1.25245675e-01f, 1.03978634e-01f, 1.90230943e-02f, -6.38785139e-02f,
  9.63341817e-02f, 9.26642045e-02f, 5.94375096e-02f, -3.10042053e-02f, -1.20938011e-01f, -1.76681176e-01f, -3.07264598e-03f, -6.30851388e-02f, -1.46679357e-02f, 3.06340982e-03f,
  3.39212338e-03f, 1.51131777e-02f, 1.24675259e-01f, 6.74729049e-02f, 1.00816842e-02f, 1.91443563e-02f, -5.64638600e-02f, -4.98011359e-04f, 2.07847673e-02f, -2.82177161e-02f,
  2.93577220e-02f, 3.40211540e-02f, -6.90083206e-02f, -2.92505398e-02f, 1.00536242e-01f, 8.84612650e-02f, 2.65534166e-02f, 1.63328707e-01f, 1.96343288e-02f, 9.24918801e-02f,
  -1.33685961e-01f, -7.08909035e-02f, -9.51106697e-02f, -1.88967250e-02f, 3.67874764e-02f, 4.47786786e-03f, 4.08725115e-03f, -4.81747352e-02f, -1.29113257e-01f, 6.67649359e-02f,
  4.91099693e-02f, -3.45908701e-02f, 4.60973158e-02f, -2.55333148e-02f, 1.96785163e-02f, -1.21310756e-01f, 4.83519509e-02f, -1.70427524e-02f, -8.74381959e-02f, 8.65147859e-02f,
  -6.07292615e-02f, 4.53147991e-03f, -1.91149693e-02f, 2.28028372e-02f, 8.21763836e-03f, -7.80432001e-02f, 3.53337228e-02f, 1.02498885e-02f, 2.92911958e-02f, -5.48802391e-02f,
  1.98033080e-01f, -9.89651158e-02f, -1.72647938e-01f, 3.41052674e-02f, -1.43293086e-02f, -1.10825740e-01f, -1.17985800e-01f, 5.09695113e-02f, 4.71911393e-02f, -5.77924177e-02f,
  1.17874265e-01f, 1.73021138e-01f, -1.11383952e-01f, 1.59454599e-01f, 2.18603253e-01f, -1.00742787e-01f, 1.51321590e-01f, 2.41201576e-02f, 1.15842624e-02f, 5.80889024e-02f,
  3.55814472e-02f, 1.65854886e-01f, 7.74557739e-02f, 2.06187338e-01f, 1.07140109e-01f, -9.29655209e-02f, 6.95235357e-02f, -7.93533772e-02f, 1.18175551e-01f, 1.11989208e-01f,
  -3.78760174e-02f, -2.27731597e-02f, 5.84034016e-03f, 5.15525937e-02f, -7.91651234e-02f, -1.24759778e-01f, -1.00433335e-01f, -7.52473697e-02f, 1.03776902e-01f, -3.89197022e-02f,
  -2.83984877e-02f, 1.06995381e-01f, -5.08546904e-02f, 7.72002116e-02f, 8.11151192e-02f, -2.57164128e-02f, 1.96041930e-02f, 1.37800714e-02f, -8.19321349e-02f, 5.45325093e-02f,
  -7.11477250e-02f, -3.16928141e-02f, -2.24122051e-02f, 1.48623837e-02f, -3.76755260e-02f, -4.16981988e-02f, -3.92090529e-02f, 3.17577533e-02f, -6.06670454e-02f, -4.72334065e-02f,
  5.17801605e-02f, 6.75884336e-02f, -8.22298303e-02f, 4.46817745e-03f, -4.97965589e-02f, -1.31927356e-01f, 7.89625570e-02f, -1.98254790e-02f, -4.02213596e-02f, 1.47068901e-02f,
  -5.80907241e-02f, 3.22027914e-02f, 1.27171263e-01f, 4.41833287e-02f, -4.83305678e-02f, 2.88912412e-02f, -3.34793776e-02f, -4.02857959e-02f, -6.31847605e-02f, -2.50605922e-02f,
  1.45479636e-02f, -5.04239928e-03f, -6.79904036e-03f, -3.59634049e-02f, -7.86256138e-03f, 4.04852144e-02f, -4.98151109e-02f, -8.17453780e-04f, -1.02043776e-02f, -2.93535739e-02f,
  8.33012238e-02f, 5.34291640e-02f, 5.48687577e-02f, -3.62845184e-03f, -1.31331503e-01f, -1.27431229e-01f, 8.47338792e-03f, -3.94365601e-02f, 6.86675981e-02f, -5.00183254e-02f,
  -2.26527266e-02f, 4.68388759e-02f, 2.84061506e-02f, 3.52249369e-02f, 2.89992038e-02f, 2.77681984e-02f, 9.34891552e-02f, 9.06071160e-03f, -2.83699781e-02f, 6.10406995e-02f,
  1.64278783e-02f, -2.30999012e-02f, 3.91534343e-02f, -1.02067173e-01f, -4.82363366e-02f, 9.57384147e-03f, 6.89733252e-02f, 4.14090045e-02f, -1.86398719e-02f, 1.70669407e-02f,
  -1.85867861e-01f, -1.31462663e-02f, 3.83029580e-02f, 7.02645704e-02f, 3.91785279e-02f, -1.26282638e-02f, 1.39983550e-01f, 5.65119670e-04f, -2.87716240e-01f, 2.36179698e-02f,
  1.84697747e-01f, -7.12475702e-02f, 1.09555557e-01f, 2.64477849e-01f, 2.36390665e-01f, -5.07061891e-02f, 1.41558498e-01f, 1.13994457e-01f, -1.47916242e-01f, -9.01872218e-02f,
  1.77361891e-02f, 1.76295027e-01f, 1.37050003e-01f, -2.48229746e-02f, -1.08783217e-02f, -9.62840244e-02f, 3.58418189e-02f, -1.73828361e-04f, 1.16246477e-01f, 7.63023868e-02f,
  6.81225443e-04f, -1.54446542e-01f, -1.61328223e-02f, -1.17229871e-01f, -2.60651167e-02f, 1.69377457e-02f, -6.94729537e-02f, 4.08159383e-02f, -7.00774416e-02f, 7.02084647e-03f,
  -1.06132329e-01f, -4.84802984e-02f, -1.43900082e-01f, -1.84800830e-02f, -4.18260284e-02f, -6.27846569e-02f, -7.61603564e-03f, -1.91695262e-02f, -8.00070837e-02f, 7.35946745e-02f,
  -4.48648520e-02f, 1.61920171e-02f, 1.87060107e-02f, -5.63172176e-02f, 8.63184556e-02f, 6.66075870e-02f, -9.35016125e-02f, -1.41597660e-02f, -6.32351711e-02f, 6.62748069e-02f,
  -1.38959661e-01f, -1.29176259e-01f, 3.82353528e-03f, 9.38032791e-02f, 4.65987213e-02f, 5.87910861e-02f, 4.42334004e-02f, 1.46955550e-01f, 1.44249722e-02f, 9.07163098e-02f,
  3.22344750e-02f, -2.18521658e-04f, -2.89085433e-02f, -1.78520512e-02f, -3.45369503e-02f, -9.54645276e-02f, -1.03143789e-01f, 1.01138912e-02f, 7.82408714e-02f, 2.59186625e-02f,
  -5.90267330e-02f, 2.19504554e-02f, -9.35394317e-02f, 2.72229388e-02f, -2.51705833e-02f, -7.83531740e-02f, 4.55132015e-02f, 1.64180528e-02f, -3.72540019e-02f, -1.56259183e-02f,
  -3.44899260e-02f, -3.14217731e-02f, 4.24797572e-02f, 1.34039912e-02f, 3.92890759e-02f, 4.03421223e-02f, 5.04522808e-02f, -3.35214622e-02f, -3.97033580e-02f, 2.90117282e-02f,
  6.92796474e-03f, 6.57529235e-02f, 3.58228795e-02f, 2.31526829e-02f, -6.43130615e-02f, -4.87063006e-02f, -7.54412562e-02f, -5.82297915e-04f, 9.03389305e-02f, 1.39117315e-01f,
  5.25386855e-02f, -2.81337667e-02f, -6.81647211e-02f, 1.00635864e-01f, 5.40403612e-02f, 1.47651300e-01f, -1.58093467e-01f, -1.39097229e-01f, 7.01132119e-02f, 6.87940861e-04f,
  -9.05353948e-03f, 6.99361488e-02f, 2.46500865e-01f, -4.57840562e-02f, 7.43399635e-02f, 2.87465788e-02f, -1.31145597e-01f, 8.48372132e-02f, 1.20100029e-01f, 1.07978530e-01f,
  -1.56095788e-01f, 1.76924273e-01f, 2.90663503e-02f, -4.59224805e-02f, -2.36997962e-01f, -2.22736627e-01f, -2.40884334e-01f, 4.84362654e-02f, -4.65888046e-02f, 3.51771191e-02f,
  -1.21400394e-01f, -2.55463749e-01f, -7.29177743e-02f, 7.01976344e-02f, 1.22524329e-01f, 6.23019300e-02f, -1.57464355e-01f, 6.18446730e-02f, 2.02525891e-02f, 4.51557711e-02f,
  -6.58017322e-02f, 4.74672802e-02f, 1.27537772e-01f, 1.31804302e-01f, 1.76392291e-02f, 4.24378999e-02f, -1.18325941e-01f, 1.62936691e-02f, 8.24497864e-02f, 3.90357561e-02f,
  5.26274331e-02f, -1.40174432e-02f, 5.77947870e-02f, 4.03210521e-02f, 1.06982291e-01f, 9.99116898e-03f, -7.13117048e-02f, 5.78573644e-02f, 8.94581005e-02f, 4.78690527e-02f,
  4.88401391e-02f, 1.22824050e-01f, -1.02179870e-02f, -4.34959307e-02f, -5.51526807e-02f, 9.87369493e-02f, -7.44070560e-02f, -2.20107194e-02f, 3.58654149e-02f, -1.48114776e-02f,
  -2.95778997e-02f, -6.45168722e-02f, 6.00735284e-02f, 7.44912541e-03f, -3.49360406e-02f, 3.53449993e-02f, 8.83322060e-02f, 2.58507747e-02f, 9.46923066e-03f, -1.49867795e-02f,
  -6.73299208e-02f, 6.41896427e-02f, -1.73296705e-02f, -2.00717710e-02f, -1.25198718e-03f, -2.79443115e-02f, -8.71886313e-02f, 6.32072985e-02f, 2.14375034e-02f, -5.26438206e-02f,
  -8.01119506e-02f, 3.94799747e-02f, -3.47589813e-02f, 6.33554235e-02f, 3.42144109e-02f, 5.07281907e-02f, 2.88087167e-02f, 8.55785832e-02f, -1.03899930e-02f, -6.80653378e-02f,
  -9.87381414e-02f, -1.34301618e-01f, -8.63366351e-02f, -2.32839324e-02f, -1.43511512e-03f, -6.37637377e-02f, -7.68624544e-02f, 1.21489912e-01f, -2.13224236e-02f, -4.64198962e-02f,
  1.10847298e-02f, -4.49915826e-02f, -1.75093897e-02f, 8.02333016e-05f, -5.00177741e-02f, -6.68127015e-02f, -5.12326695e-02f, -8.68366957e-02f, -6.44459054e-02f, -5.71092479e-02f,
  5.35309277e-02f, -7.43062422e-03f, -3.98956425e-02f, 5.65273203e-02f, -1.03525929e-01f, -4.39676791e-02f, -6.92604408e-02f, -1.77675614e-03f, -6.63258657e-02f, -6.87571615e-02f,
  1.55803212e-03f, -1.79840371e-01f, 2.34469578e-01f, -1.10041447e-01f, 6.58961907e-02f, 1.05377309e-01f, 5.20675890e-02f, -1.46884501e-01f, -2.08193809e-01f, -1.18788935e-01f,
  -5.96894622e-02f, 3.84527189e-03f, 1.38848364e-01f, -1.88086152e-01f, 2.44617492e-01f, -2.94243009e-03f, -6.77247345e-02f, -1.61965355e-01f, -1.17605560e-01f, -1.91052631e-01f,
  -1.10252097e-01f, -1.29259452e-01f, 5.88433966e-02f, -9.37513337e-02f, -1.78688169e-01f, -4.52126898e-02f, -4.75139208e-02f, 1.09013692e-01f, -5.67944720e-02f, 8.79408047e-02f,
  8.35282207e-02f, -1.12539575e-01f, -3.86258326e-02f, -1.26255797e-02f, -8.88159499e-02f, -3.45483348e-02f, -4.30323854e-02f, 7.40843713e-02f, 1.09885260e-01f, 4.84276712e-02f,
  -5.51727079e-02f, -6.06069639e-02f, -9.35840309e-02f, 5.11208130e-03f, -2.86467150e-02f, -7.96749373e-04f, -4.93706111e-03f, 7.79100358e-02f, 1.66797377e-02f, 7.83796012e-02f,
  6.73957169e-03f, -6.42085299e-02f, -1.77804078e-03f, -1.12016439e-01f, -1.67380422e-02f, -5.67254014e-02f, 4.80071865e-02f, -1.12619167e-02f, -3.80573161e-02f, 7.31824711e-02f,
  -6.91910386e-02f, 1.27181448e-02f, -6.14828840e-02f, -3.34873274e-02f, 3.47293764e-02f, 7.75781646e-02f, 6.76476657e-02f, -6.05576485e-02f, -1.16783239e-01f, -1.35031296e-02f,
  -1.02625266e-02f, -1.69863133e-03f, -5.48256971e-02f, -1.02936979e-02f, -1.08756445e-01f, 9.01719034e-02f, -3.12084686e-02f, 4.42340551e-03f, -8.03577378e-02f, 1.92805827e-02f,
  1.24856597e-02f, 1.11062340e-01f, -7.87632093e-02f, 3.19516584e-02f, 1.08569860e-01f, -5.42688407e-02f, 6.51590154e-03f, 1.91763714e-02f, 5.54669369e-03f, -7.28262216e-02f,
  1.00469917e-01f, -1.21228367e-01f, 2.16360278e-02f, 2.71009579e-02f, 2.44926731e-03f, 1.08273476e-02f, -6.05541542e-02f, -8.05467740e-02f, 4.84552793e-02f, -2.24194713e-02f,
  6.09288178e-02f, -8.30263421e-02f, 4.32906859e-03f, 7.05297198e-03f, -1.90400649e-02f, -8.44504163e-02f, -2.65769288e-02f, 1.25048563e-01f, -3.27830799e-02f, -7.17472809e-04f,
  -5.18074669e-02f, -9.46932957e-02f, -7.82343075e-02f, -7.91725442e-02f, -2.77699549e-02f, -3.73582207e-02f, 1.95705947e-02f, -2.45909635e-02f, -4.67863865e-03f, -7.26075098e-02f,
  1.95085511e-01f, 3.67270142e-01f, 2.31095165e-01f, 2.89666623e-01f, -1.15497775e-01f, -2.77018845e-01f, -1.85288131e-01f, -7.18108937e-02f, -9.01364312e-02f, -2.56484840e-02f,
  -1.54492229e-01f, 3.50363404e-01f, -1.23034008e-01f, 1.32395774e-01f, -1.39143318e-01f, -1.61138922e-01f, 2.92528756e-02f, 9.55277830e-02f, -5.89728951e-02f, 1.08622581e-01f,
  1.98317468e-02f, -7.68841654e-02f, 1.66185424e-01f, -1.25642672e-01f, 1.69785470e-01f, 2.41888985e-01f, -2.65112855e-02f, -7.67402053e-02f, 2.31454343e-01f, -9.44045782e-02f,
  -6.33422146e-03f, 7.63659775e-02f, 1.65946350e-01f, -1.55363437e-02f, 2.53576487e-02f, 8.73882324e-02f, 8.25373828e-02f, -2.37670597e-02f, -2.25099679e-02f, -7.34985992e-02f,
  -7.66515732e-04f, 1.03840418e-02f, -3.31505425e-02f, -4.21377644e-02f, 6.77565858e-03f, 5.43818399e-02f, 1.36078317e-02f, 2.03443661e-01f, 4.55235131e-02f, 1.13997474e-01f,
  6.26432821e-02f, 6.83420151e-02f, 1.19555471e-02f, 1.10833563e-01f, 1.03735968e-01f, -2.92156041e-02f, -1.06233079e-02f, 5.38444705e-02f, 3.69284004e-02f, 5.71384691e-02f,
  1.03684507e-01f, -4.88148928e-02f, -3.16995345e-02f, -7.17092976e-02f, 2.07957420e-02f, 1.02265321e-01f, 3.89796123e-03f, -2.73285829e-03f, -2.97110770e-02f, -1.23931980e-02f,
  -1.90055277e-02f, 6.18232340e-02f, -2.62351055e-02f, 9.98143330e-02f, 1.28203183e-01f, 1.31515330e-02f, -9.38076079e-02f, -4.94265109e-02f, 1.27603650e-01f, -2.01314688e-02f,
  5.81986122e-02f, 7.75969960e-03f, -3.96853797e-02f, -3.23087838e-03f, -5.80273829e-02f, 2.85654180e-02f, -5.62941208e-02f, 5.31238429e-02f, -3.95097882e-02f, -6.73556775e-02f,
  -2.48376001e-02f, -4.05873284e-02f, -2.13195309e-02f, 8.32962338e-03f, -2.40268763e-02f, -1.01003645e-03f, -1.63397373e-04f, 2.76866034e-02f, -3.46750952e-02f, -7.46673867e-02f,
  5.94048090e-02f, -2.81864312e-02f, -3.04630473e-02f, -2.27230601e-03f, 4.37984355e-02f, -1.03597477e-01f, -9.86912698e-02f, 7.67820328e-02f, 3.65456939e-02f, 1.83165949e-02f,
  7.89187104e-02f, -7.96055868e-02f, -7.12335035e-02f, 8.11545998e-02f, 1.19978460e-04f, 7.23004118e-02f, 6.25744313e-02f, 1.37730792e-01f, 2.27854736e-02f, -8.71130545e-03f,
  2.79218793e-01f, 5.74057810e-02f, 1.80567667e-01f, 2.57708281e-01f, 1.98522140e-03f, 1.97894543e-01f, 3.69201787e-03f, 2.32579455e-01f, 4.09272254e-01f, -3.27600390e-02f,
  -2.42559627e-01f, 2.17040062e-01f, -1.61764827e-02f, -9.29918587e-02f, -8.45988095e-02f, 6.59269914e-02f, 4.75297235e-02f, -4.44509424e-02f, 1.98154345e-01f, 7.03955367e-02f,
  8.22394118e-02f, -2.67616898e-01f, -1.56144187e-01f, -2.10905507e-01f, -1.38826638e-01f, -4.95690219e-02f, -2.97877848e-01f, -7.21763819e-02f, -7.93473870e-02f, -5.26284352e-02f,
  -9.56043452e-02f, 3.18741356e-03f, -6.42258674e-03f, 6.33850694e-02f, 2.29717586e-02f, 3.23668830e-02f, 8.16065595e-02f, -8.45745206e-02f, 2.18980107e-02f, 8.07583109e-02f,
  6.00830168e-02f, 1.13181271e-01f, 6.24353345e-03f, -9.75366980e-02f, 6.41489998e-02f, -4.43799682e-02f, 4.89935987e-02f, 1.99463386e-02f, 2.11750995e-02f, 1.13716453e-01f,
  -6.34894446e-02f, 7.32069509e-03f, -2.51517110e-02f, 5.76755404e-02f, 6.24789968e-02f, -1.62207820e-02f, 1.95271347e-03f, -5.00280783e-02f, 8.24079439e-02f, 9.91951525e-02f,
  -8.13408569e-03f, 1.30815282e-01f, -3.59805934e-02f, -6.96358755e-02f, 1.08274315e-02f, -1.17009312e-01f, -9.54071432e-02f, -7.12265223e-02f, -4.69364896e-02f, -1.11287318e-01f,
  9.06641260e-02f, 8.15653279e-02f, -3.21737006e-02f, 7.96568245e-02f, -1.24312956e-02f, 8.12730864e-02f, 2.42870059e-02f, 1.02703266e-01f, -1.49570741e-02f, -5.08428514e-02f,
  -2.55273227e-02f, 3.80671062e-02f, -7.98646510e-02f, -6.89868778e-02f, -7.45637417e-02f, -7.36167654e-03f, -4.96450029e-02f, 8.96995142e-02f, 4.55056392e-02f, -1.23976141e-01f,
  1.88068170e-02f, 5.78077696e-02f, 2.23693103e-02f, 5.73610067e-02f, -4.73578237e-02f, -9.59733278e-02f, 1.07728191e-01f, -1.72182545e-02f, 5.17252199e-02f, -2.13198364e-02f,
  -1.01416837e-02f, 1.10617645e-01f, 1.64246913e-02f, -3.28413136e-02f, 6.93301810e-03f, -8.95316973e-02f, 3.01392712e-02f, 3.16635668e-02f, -4.48612794e-02f, 2.48873625e-02f,
  -1.30078390e-01f, -1.64501723e-02f, -6.89135417e-02f, -6.78942725e-02f, 1.22829191e-02f, -2.80865319e-02f, 2.97527704e-02f, 6.40926138e-02f, -6.04522042e-02f, -3.37657034e-02f,
  8.64897743e-02f, 2.19009057e-01f, 7.01088235e-02f, 4.88181859e-02f, -1.15468755e-01f, 7.28516057e-02f, 1.47299170e-01f, 1.32494485e-02f, 4.22959775e-02f, 1.27087042e-01f,
  -4.90089804e-02f, 2.11266056e-01f, 9.17911250e-03f, 1.65765390e-01f, -6.19403608e-02f, 5.39668649e-02f, 1.99553698e-01f, 2.04861179e-01f, -5.60793355e-02f, 1.52168730e-02f,
  -6.98082447e-02f, -7.39641488e-02f, -5.76090775e-02f, -9.73477960e-02f, 5.34408614e-02f, 3.02842110e-02f, -1.39164135e-01f, 4.24934179e-02f, 5.48292287e-02f, 1.56380702e-02f,
  2.42324397e-02f, 9.49232429e-02f, 3.82499024e-02f, 3.78881805e-02f, 7.65294060e-02f, -6.47825450e-02f, 2.05226988e-02f, 1.47912934e-01f, 6.15114681e-02f, -4.60605649e-03f,
  9.59002823e-02f, -3.66377905e-02f, 2.10835282e-02f, -1.60336383e-02f, 1.80644542e-02f, 2.25243922e-02f, -3.05854548e-02f, 8.51412863e-02f, 5.53402975e-02f, -1.76971368e-02f,
  8.31696168e-02f, -3.01701836e-02f, 1.27251416e-01f, 6.01863600e-02f, 3.29537429e-02f, 1.14969961e-01f, 8.72739628e-02f, 1.11179687e-01f, 3.30161601e-02f, 6.32516593e-02f,
  -7.71138445e-02f, 8.26350302e-02f, 1.27456650e-01f, -4.97286394e-02f, -5.72002307e-02f, 7.02878535e-02f, 1.28777213e-02f, 8.66166279e-02f, -2.27183591e-06f, -7.01519148e-03f,
  8.52975249e-03f, -2.78280880e-02f, 1.04422336e-02f, 8.47683325e-02f, -3.74326250e-03f, 6.03133552e-02f, 3.15192752e-02f, -3.83054055e-02f, 7.80175999e-02f, -3.45147662e-02f,
  -1.54203340e-01f, 1.05589563e-02f, 2.13567354e-02f, -1.02966554e-01f, 8.02833661e-02f, -3.79898623e-02f, -1.51624292e-01f, -1.57989822e-02f, 6.59057405e-03f, -4.58259545e-02f,
  5.01430500e-03f, 3.68126407e-02f, 2.84508858e-02f, -6.28905520e-02f, 7.35289752e-02f, -4.60792221e-02f, 9.49298516e-02f, 7.66197592e-02f, 8.91850665e-02f, -4.70122918e-02f,
  -3.92366312e-02f, 3.13861519e-02f, 1.78963002e-02f, -1.18553817e-01f, 6.87092021e-02f, 1.07148796e-01f, 5.36731370e-02f, 3.24397124e-02f, -3.95039469e-03f, -1.07985735e-02f,
  -8.49635750e-02f, 1.81386005e-02f, 5.60831465e-02f, 6.39449358e-02f, 8.60351995e-02f, 2.62491964e-02f, 2.67295502e-02f, 2.64789094e-03f, -9.31067616e-02f, 5.87540120e-02f,
  -4.86904383e-01f, 1.42409638e-01f, -1.13372535e-01f, -4.78920564e-02f, -1.50175869e-01f, -3.03177118e-01f, -6.19573183e-02f, -2.82520354e-02f, -1.50410354e-01f, 2.44254336e-01f,
  9.54675023e-03f, -2.79244572e-01f, 1.75455272e-01f, 6.37194142e-02f, -2.48028755e-01f, 1.26093432e-01f, -1.15637876e-01f, -5.94266877e-02f, 4.44057398e-02f, 1.53118325e-02f,
  6.93659335e-02f, 1.19149975e-01f, 4.80974950e-02f, 1.32312134e-01f, 9.08395834e-03f, -5.06603681e-02f, 1.94131926e-01f, 2.59259231e-02f, 1.66488886e-02f, 1.36878360e-02f,
  -1.89300865e-01f, -5.75742498e-02f, -8.21088850e-02f, -6.30347058e-02f, -1.77543372e-01f, 2.83072721e-02f, -5.29850163e-02f, -4.80013303e-02f, 1.45279542e-02f, -7.22573921e-02f,
  -3.60725187e-02f, -6.40980303e-02f, -7.75451213e-02f, -8.68525729e-02f, -1.06359176e-01f, 3.55786122e-02f, 1.42121753e-02f, -1.61775082e-01f, -4.57787849e-02f, 4.36371937e-02f,
  -3.40507925e-02f, 7.94755854e-03f, 7.40268379e-02f, -1.97724588e-02f, 4.39252099e-03f, -1.33046424e-02f, -3.36222798e-02f, -4.19317558e-02f, -1.59565359e-01f, -1.26416892e-01f,
  1.35775103e-04f, -9.99192446e-02f, 3.16540077e-02f, -4.15679142e-02f, -2.80202813e-02f, 2.82559767e-02f, -1.56880897e-02f, 4.39366512e-03f, 2.82802638e-02f, 2.24152263e-02f,
  2.68019736e-03f, -1.96751561e-02f, 5.88428676e-02f, 4.00760844e-02f, -3.60640883e-02f, 3.81792448e-02f, -4.54772683e-03f, 8.09267759e-02f, -7.90049806e-02f, -8.14017579e-02f,
  1.96247548e-02f, 9.85509809e-03f, 7.56795332e-02f, 8.29276629e-03f, -3.48805375e-02f, 1.19788926e-02f, -4.12626565e-02f, -4.15203795e-02f, 7.07726181e-02f, -5.07165082e-02f,
  -2.20094144e-01f, -3.05103324e-02f, 2.51093805e-02f, -8.13503005e-03f, 1.04505126e-03f, -2.59348582e-02f, -5.26350399e-04f, -7.46887848e-02f, -2.33542845e-02f, -1.01641484e-01f,
  8.99695326e-03f, 1.23997822e-01f, 1.45209916e-02f, -8.97126459e-03f, 2.40112133e-02f, -1.11215904e-01f, 1.03925563e-01f, -1.34794980e-01f, -4.51022014e-02f, 1.68056097e-02f,
  -5.97934499e-02f, -4.43592072e-02f, 4.20505367e-02f, 2.10673232e-02f, 1.17565453e-01f, 3.27950977e-02f, -1.54657111e-01f, 4.50843014e-03f, -2.15810835e-02f, -9.51248184e-02f,
  -1.66380063e-01f, 1.81799158e-01f, -6.91068321e-02f, 1.72607109e-01f, -1.10647261e-01f, 4.19163480e-02f, 2.01293081e-03f, 2.42059492e-02f, -8.14126134e-02f, 9.30915177e-02f,
  1.52226642e-01f, -7.98631236e-02f, 8.68015885e-02f, 3.06431890e-01f, 7.10933656e-02f, 1.33754089e-01f, 1.74076661e-01f, 1.69766307e-01f, 7.44697377e-02f, 4.61407676e-02f,
  4.99841683e-02f, 2.54342109e-01f, 2.26623073e-01f, 6.04985990e-02f, -8.50609783e-03f, -2.84535345e-02f, 1.10232383e-01f, 4.03191447e-02f, 8.12268481e-02f, 4.23028646e-03f,
  8.75939801e-02f, -3.43181416e-02f, 3.59067693e-02f, -1.25669509e-01f, 4.00940850e-02f, -4.86966968e-02f, -3.70097086e-02f, -6.88563660e-02f, -4.72434089e-02f, 4.26912196e-02f,
  -8.99448991e-02f, -4.05835621e-02f, -8.51185154e-03f, -4.60236035e-02f, 3.29989530e-02f, 5.51283695e-02f, 3.53155509e-02f, -8.05763900e-02f, 3.25021446e-02f, -3.96776535e-02f,
  -1.85816009e-02f, 4.46374528e-02f, 3.91514860e-02f, 8.92112330e-02f, 8.89344364e-02f, -3.63044180e-02f, 1.86937749e-02f, 2.89651733e-02f, 1.16649203e-01f, 8.03038254e-02f,
  -2.54058018e-02f, -5.30587323e-02f, 8.73506442e-02f, -6.25751074e-03f, 3.39776427e-02f, 8.46847892e-02f, -3.08100693e-02f, -3.14783007e-02f, 6.58828989e-02f, 9.50083137e-02f,
  -4.64157946e-02f, -1.19635239e-02f, 2.29291338e-03f, -3.77815850e-02f, 2.03758143e-02f, -4.88599315e-02f, -7.45750451e-03f, -1.60470791e-02f, 4.36734222e-02f, -5.81817813e-02f,
  2.93623805e-02f, 6.30277917e-02f, 2.73689888e-02f, 7.02084675e-02f, 2.97009144e-02f, 4.41010036e-02f, 5.81550933e-02f, -8.12974572e-02f, 3.28426138e-02f, -5.89484535e-02f,
  8.44365805e-02f, 1.50921509e-01f, -4.52112220e-02f, -7.39216879e-02f, -4.21312526e-02f, -7.39281997e-02f, -5.14326990e-02f, -3.34635675e-02f, 1.24832831e-01f, 5.75201176e-02f,
  -9.56649333e-03f, 1.32907499e-02f, 1.66685805e-02f, 1.24899400e-02f, 5.84491715e-02f, -1.94705259e-02f, -3.89481261e-02f, -9.01135057e-02f, 2.49588024e-02f, 8.05733055e-02f,
  -1.83318797e-02f, -1.96425375e-02f, -2.72979569e-02f, -9.86597780e-03f, 8.44001696e-02f, -2.79673189e-02f, 2.55370252e-02f, 4.14459407e-02f, 4.69302610e-02f, 3.00656818e-02f,
  2.25525260e-01f, -3.75145674e-02f, -2.96039820e-01f, -4.68141697e-02f, -5.02101779e-02f, 9.74521115e-02f, 4.79726195e-02f, 4.98765409e-02f, -2.40176488e-02f, 2.30947614e-01f,
  1.03400268e-01f, 1.71104386e-01f, 1.58813652e-02f, 9.71739963e-02f, 2.37942245e-02f, 1.74145564e-01f, 5.04995473e-02f, 8.14156607e-02f, 5.15089594e-02f, 9.15790796e-02f,
  -1.75237060e-02f, 2.00053588e-01f, -2.58557908e-02f, 2.87667997e-02f, 1.88874066e-01f, -1.05297923e-01f, 8.54925588e-02f, -1.08463662e-02f, 3.73674817e-02f, 1.50690023e-02f,
  5.24204634e-02f, -1.31003624e-02f, -5.83948754e-02f, 1.13880560e-02f, -7.63112083e-02f, -1.67499501e-02f, -7.54907504e-02f, 2.96986979e-02f, 6.21696375e-02f, 3.42324860e-02f,
  4.06938642e-02f, -1.46868099e-02f, 4.89836298e-02f, 4.59224395e-02f, -4.93600070e-02f, -7.25880340e-02f, -4.63107601e-02f, -5.72707467e-02f, -6.51654229e-02f, -3.90520282e-02f,
  -1.51751921e-01f, -4.19719741e-02f, 3.72667611e-02f, -8.75752419e-02f, -5.65066002e-02f, 9.80437640e-03f, -1.28373921e-01f, 2.51768902e-02f, -7.26414919e-02f, 6.36605173e-02f,
  -3.61755514e-03f, 7.34181181e-02f, 4.88434620e-02f, 2.39236653e-02f, -9.37191471e-02f, -4.28946950e-02f, -3.10789440e-02f, -3.45332287e-02f, -5.34139946e-02f, 7.96732828e-02f,
  2.81850435e-02f, -1.10489808e-01f, 4.07102108e-02f, 3.58793102e-02f, 2.15096492e-02f, 5.81542030e-02f, 6.83705211e-02f, 3.39879468e-02f, 4.10098676e-03f, -1.29997715e-01f,
  5.38599640e-02f, 8.81486461e-02f, 5.37219048e-02f, -4.55896445e-02f, -7.91680440e-03f, 3.08608785e-02f, 8.99753422e-02f, 2.11106930e-02f, -4.57468629e-02f, -2.66675968e-02f,
  -4.34262585e-03f, -1.03314612e-02f, -7.02733770e-02f, -4.96333763e-02f, -3.87946106e-02f, 1.53264906e-02f, -3.41217332e-02f, 2.88434308e-02f, -1.42281438e-04f, 4.79528420e-02f,
  1.35451602e-02f, -6.57945797e-02f, 8.81761089e-02f, 2.48870105e-02f, -2.06547901e-01f, 1.92642640e-02f, 7.78865591e-02f, -5.60695566e-02f, -1.06809914e-01f, -1.11859687e-01f,
  -3.78000736e-03f, -9.17303562e-03f, -5.63637652e-02f, 3.28147318e-03f, -9.24381986e-02f, 3.37690674e-02f, -2.42106318e-02f, 7.80405924e-02f, -4.50852253e-02f, -4.48471792e-02f,
  -2.75718849e-02f, -1.94324046e-01f, -1.87692256e-03f, -9.39768776e-02f, -4.35455777e-02f, -1.66603118e-01f, 4.22938401e-03f, -2.18613014e-01f, 1.29077751e-02f, -1.76140323e-01f,
  -8.29815045e-02f, 8.16864371e-02f, 7.15063289e-02f, -1.81845650e-01f, 3.27539295e-01f, 8.79058763e-02f, -2.00779840e-01f, 3.51136690e-03f, 1.00922231e-02f, -1.85959756e-01f,
  7.33187795e-02f, -1.94782004e-01f, 8.31038132e-02f, -1.82273000e-01f, -1.79375157e-01f, -5.88286035e-02f, 1.77924022e-01f, -1.21502116e-01f, -1.58445179e-01f, 2.35358607e-02f,
  -6.36351258e-02f, -2.40670279e-01f, -7.39812404e-02f, -6.92549124e-02f, -8.97661895e-02f, -7.90414885e-02f, 3.63603756e-02f, 1.11061573e-01f, 4.71249297e-02f, -1.00884244e-01f,
  5.35738692e-02f, -1.42182000e-02f, -5.96887022e-02f, 2.74817422e-02f, -8.68728086e-02f, -1.89220123e-02f, -2.99996380e-02f, -5.34329861e-02f, -7.77847245e-02f, 7.72562623e-02f,
  4.74994145e-02f, -8.61784071e-02f, -4.19992171e-02f, 3.64283957e-02f, 2.69427858e-02f, -7.81512856e-02f, 5.88137768e-02f, 3.95570882e-02f, -7.85180703e-02f, 5.39157260e-03f,
  3.99572067e-02f, 5.25576174e-02f, 4.84055430e-02f, 7.88376853e-03f, -2.78772675e-02f, 7.84860104e-02f, -5.82327992e-02f, -1.09758331e-02f, 3.53255346e-02f, -9.53379348e-02f,
  5.88154458e-02f, -5.89134246e-02f, 5.30584110e-03f, -3.23410146e-02f, -2.15719622e-02f, 4.06645648e-02f, 2.98421327e-02f, 3.90405171e-02f, 5.90439886e-02f, -5.96566722e-02f,
  1.99855976e-02f, 3.20282057e-02f, -2.75083520e-02f, 2.30957195e-03f, 4.60630357e-02f, 2.80331597e-02f, 3.89190391e-02f, -1.11103013e-01f, 6.03831224e-02f, 3.53164636e-02f,
  -1.34702832e-01f, -2.70010442e-01f, 1.70887485e-02f, -7.00957924e-02f, 2.20161397e-02f, 2.97357198e-02f, -1.36019224e-02f, -1.40003935e-01f, -2.28327774e-02f, -7.45221376e-02f,
  5.63414507e-02f, -5.10469684e-03f, 2.30390579e-02f, 4.52216156e-02f, -4.29156087e-02f, -1.01785304e-03f, -6.91292749e-04f, -1.02929756e-01f, 8.29344466e-02f, -2.06590127e-02f,
  -5.78897558e-02f, 1.23308292e-02f, 8.24279413e-02f, -1.08689833e-02f, -7.50651360e-02f, 1.23249646e-02f, -2.82940045e-02f, 8.00610259e-02f, -1.22182891e-01f, 6.25141785e-02f,
  -6.03332892e-02f, 1.36658058e-01f, -1.12372391e-01f, 1.16923168e-01f, -1.66277923e-02f, 2.99529061e-02f, -1.15254261e-01f, 1.52191594e-01f, -5.70455566e-02f, -9.16360170e-02f,
  7.80105442e-02f, -1.08879603e-01f, -9.60175842e-02f, 1.19365990e-01f, 1.11151926e-01f, -6.02179319e-02f, 1.85307547e-01f, 1.16639736e-03f, -4.52148393e-02f, -1.80048565e-03f,
  1.03262059e-01f, 9.53137800e-02f, 2.89680641e-02f, 6.92637116e-02f, -6.73709959e-02f, 7.19226673e-02f, 1.41080916e-01f, -8.12178776e-02f, 2.25286290e-01f, 9.62934271e-02f,
  -8.21460187e-02f, 4.35018279e-02f, 1.09654767e-02f, -2.34810319e-02f, 2.48737577e-02f, -6.59264401e-02f, -5.68109490e-02f, 2.21734941e-02f, 4.78654765e-02f, 6.30553113e-03f,
  6.88289031e-02f, -8.32585394e-02f, 3.64726745e-02f, 4.89182211e-03f, 5.46168759e-02f, -6.71774298e-02f, 1.05407080e-02f, -2.31205765e-02f, 4.48928797e-04f, -5.53601533e-02f,
  -4.57001813e-02f, 2.88264081e-02f, 7.61613548e-02f, 7.01637939e-02f, 8.66934657e-02f, 8.65362734e-02f, -4.76013683e-02f, 4.94861677e-02f, 1.33241564e-01f, 4.45299409e-02f,
  8.59057829e-02f, -4.44195420e-02f, 2.90310457e-02f, -6.16860166e-02f, -2.27782801e-02f, 6.90276250e-02f, 9.14383531e-02f, 5.87563170e-03f, -1.73929967e-02f, -3.99971418e-02f,
  -5.47303483e-02f, 1.16729327e-01f, 1.32283457e-02f, -3.94728594e-02f, -3.59972082e-02f, -3.51769403e-02f, 8.28371570e-03f, -1.67973731e-02f, 2.82409880e-02f, 7.20745474e-02f,
  -4.32951450e-02f, 1.51845068e-02f, -1.01077013e-01f, 1.81412045e-02f, 4.19042818e-02f, -2.19967924e-02f, 3.88584509e-02f, -8.28106329e-02f, -1.03865741e-02f, -1.22363912e-02f,
  8.72954875e-02f, 1.65948972e-01f, 6.87591657e-02f, 1.60287637e-02f, 7.56939501e-03f, -1.04183331e-01f, 5.01561984e-02f, 2.47705709e-02f, 2.16957871e-02f, -7.42456615e-02f,
  2.19538547e-02f, -1.55242130e-01f, 1.19056255e-01f, -6.42023981e-02f, 9.14556682e-02f, 2.04679510e-03f, 1.40662054e-02f, -2.23980956e-02f, 4.58892770e-02f, 5.26173413e-02f,
  5.94199747e-02f, -1.68982074e-02f, 5.83753772e-02f, 2.66598426e-02f, 5.31101003e-02f, 2.91347373e-02f, 2.77774315e-02f, -9.22639370e-02f, 5.58390357e-02f, 6.19972199e-02f,
  3.03227883e-02f, 1.70405045e-01f, 2.50898987e-01f, 3.76061767e-01f, -1.80626422e-01f, -6.39793351e-02f, -1.05250895e-01f, 5.00545315e-02f, 1.67535424e-01f, -2.30264049e-02f,
  -8.54772478e-02f, 1.71045795e-01f, -2.16990765e-02f, 1.98094517e-01f, -1.33163735e-01f, 6.32950813e-02f, -8.55458342e-03f, 7.73082301e-02f, 6.85716644e-02f, 7.95502961e-02f,
  4.20549931e-03f, -8.07514861e-02f, -6.08251281e-02f, -8.38324949e-02f, 1.50928751e-01f, 9.90773961e-02f, 1.46865416e-02f, -1.57503374e-02f, 6.80569708e-02f, 1.06271533e-02f,
  -1.22518152e-01f, 8.97880420e-02f, 6.61278889e-02f, 2.95567606e-02f, 1.61059741e-02f, -1.34506747e-01f, 2.69656125e-02f, -2.36517861e-02f, 8.65076780e-02f, 5.74484952e-02f,
  3.37437093e-02f, -8.53421986e-02f, 4.91111688e-02f, 7.87503421e-02f, -1.32140471e-02f, 4.06532474e-02f, 1.44848693e-02f, 3.06427125e-02f, 1.60915881e-01f, 2.46209428e-02f,
  3.40189785e-02f, 2.51328256e-02f, -6.96724374e-03f, 6.02526292e-02f, -1.72182862e-02f, -1.84863228e-02f, -1.11106835e-01f, -6.30808715e-03f, -4.00921144e-02f, 6.38049748e-03f,
  -4.91112284e-02f, 2.81324219e-02f, 4.68954928e-02f, 7.13589117e-02f, -7.74886608e-02f, 9.19551104e-02f, -3.81323062e-02f, -1.48582645e-02f, -3.76744382e-02f, 6.49570748e-02f,
  -4.36664224e-02f, 3.29776742e-02f, 4.14126292e-02f, 3.26770730e-02f, -8.53124727e-03f, -4.45932560e-02f, -7.14030191e-02f, 1.02069966e-01f, -5.52695245e-02f, -9.56619009e-02f,
  -1.68274865e-02f, -2.75766216e-02f, -6.63063908e-03f, -4.75143716e-02f, -1.67037155e-02f, 3.90561819e-02f, 1.20674945e-01f, 8.44040290e-02f, 6.43530637e-02f, -1.78634077e-02f,
  3.00757959e-02f, 1.17545351e-01f, -1.46145942e-02f, -6.73619658e-02f, -3.17694992e-02f, 6.79427758e-02f, -5.01334071e-02f, 6.42406270e-02f, 1.20026395e-02f, -3.48362140e-02f,
  -1.37368562e-02f, -1.64249986e-01f, -4.70722839e-02f, -6.30335137e-02f, -2.74461284e-02f, -1.45647838e-03f, 7.43940100e-02f, -4.72114831e-02f, -5.69982752e-02f, 5.35106994e-02f,
  1.79990996e-02f, -6.94477111e-02f, -6.04563802e-02f, 4.16869782e-02f, -1.20828718e-01f, 8.44843918e-04f, 6.93499669e-02f, 4.84745502e-02f, -1.02584129e-02f, -3.12012043e-02f,
  -3.20856050e-02f, 1.13079712e-01f, 1.59041230e-02f, 1.90151826e-01f, -6.08124658e-02f, -2.09136873e-01f, -3.19861740e-01f, 8.00741240e-02f, -1.00266322e-01f, -8.41662213e-02f,
  3.73797305e-02f, -6.63945898e-02f, 8.07041749e-02f, 6.83828071e-02f, 2.56127752e-02f, -1.31875910e-02f, 3.25895613e-03f, 2.30339654e-02f, -2.07778299e-03f, -4.77246493e-02f,
  -3.11801140e-03f, 3.79511714e-02f, 6.30519865e-03f, 1.09219350e-01f, -9.60260034e-02f, 1.16010174e-01f, 1.05678089e-01f, -9.40402448e-02f, 5.61958589e-02f, -4.58243713e-02f,
  -6.37831017e-02f, -8.92067179e-02f, -6.20137751e-02f, 4.95572342e-03f, -9.13492814e-02f, 6.12560008e-03f, -2.68762070e-03f, -1.62639156e-01f, 2.20956467e-02f, -1.06948450e-01f,
  -7.00042248e-02f, 2.08177455e-02f, -4.60033938e-02f, -1.00889027e-01f, 1.23566287e-02f, 3.59145403e-02f, 4.41531017e-02f, 4.39676307e-02f, -9.02588144e-02f, 6.42415788e-03f,
  8.50272248e-04f, -2.80920453e-02f, 3.66847180e-02f, 1.22248709e-01f, 1.86605565e-02f, 2.56139599e-02f, -1.09264582e-01f, -1.15205564e-01f, 3.85107920e-02f, -1.02244586e-01f,
  -3.16960849e-02f, -7.34490156e-02f, 1.37400152e-02f, 2.52413489e-02f, 1.11163163e-03f, 2.58556455e-02f, 1.30051851e-01f, 1.00785814e-01f, -7.44431280e-03f, -4.05824445e-02f,
  -3.50964926e-02f, -1.06534854e-01f, 6.29289374e-02f, -8.47202688e-02f, -5.90187721e-02f, 6.69450387e-02f, -5.14877439e-02f, -5.88543294e-03f, 5.09635955e-02f, 3.47658023e-02f,
  -8.18782896e-02f, 3.10674142e-02f, -1.59182116e-01f, -6.56024292e-02f, -3.28008793e-02f, -1.44935064e-02f, 4.77161743e-02f, -1.32717922e-01f, 1.49072096e-01f, 9.83911306e-02f,
  1.75806694e-02f, 2.21255366e-02f, -3.65560986e-02f, -8.18977579e-02f, -9.02666748e-02f, 1.42984455e-02f, 6.51376471e-02f, -1.87019985e-02f, 4.18399274e-02f, -9.23722759e-02f,
  -6.47360757e-02f, 1.97306629e-02f, -1.56288166e-02f, 1.63110951e-03f, -7.63937607e-02f, -8.51621181e-02f, 1.19219877e-01f, -7.33390590e-03f, -8.49551260e-02f, 1.33557588e-01f,
  5.25512993e-02f, -1.60466850e-01f, -1.59379631e-01f, 1.45978615e-01f, -1.03934128e-02f, 2.65253847e-03f, 6.38860911e-02f, -2.02270329e-01f, 9.68013778e-02f, -5.58448695e-02f,
  1.55042350e-01f, 1.88986361e-01f, -8.23273957e-02f, 5.08411154e-02f, 1.81110632e-02f, 1.54562339e-01f, 9.69199184e-03f, -1.67806284e-04f, -1.95066035e-01f, 9.25781354e-02f,
  -7.02364817e-02f, 1.56117544e-01f, -1.27434626e-01f, 8.73804558e-03f, -2.70128518e-01f, -1.12400264e-01f, 5.70308492e-02f, 1.50801837e-01f, -1.33427739e-01f, 9.78527516e-02f,
  -4.45331037e-02f, -3.23878974e-02f, -1.39560148e-01f, 1.73237249e-01f, 1.69133589e-01f, 1.69455245e-01f, -7.61681749e-03f, -1.12744421e-02f, 1.60804570e-01f, -3.22834961e-02f,
  4.60903607e-02f, -8.18395391e-02f, 3.97421308e-02f, -3.39282975e-02f, -2.69490238e-02f, 1.12810083e-01f, 5.50150946e-02f, -8.18783864e-02f, -8.68661981e-03f, -2.23923326e-02f,
  8.82965177e-02f, -9.17874202e-02f, -3.78178433e-02f, -7.09630102e-02f, -8.67939368e-02f, 3.20481919e-02f, 5.67701273e-02f, -6.34809770e-03f, 1.15908487e-02f, 6.49070591e-02f,
  5.37741594e-02f, -7.18532503e-02f, 3.18521075e-02f, -7.53006712e-03f, -8.80776998e-03f, 1.08598150e-01f, 5.57674654e-02f, -9.64341965e-03f, 1.33482069e-01f, -7.52562881e-02f,
  -3.42639349e-02f, 3.16650094e-03f, 1.11054197e-01f, 2.02258900e-02f, -2.54914612e-02f, -7.54818767e-02f, -1.63658895e-03f, -3.71628553e-02f, -2.55262450e-04f, 2.79408321e-02f,
  -3.26726306e-03f, 2.20511239e-02f, -4.77840379e-02f, -2.50785891e-02f, 8.27759877e-02f, -3.00487201e-03f, 4.48724255e-02f, 1.52352815e-02f, 3.48705659e-03f, -1.35782376e-01f,
  1.60449762e-02f, 6.59656972e-02f, 7.74289947e-03f, 4.65772394e-03f, 1.22467004e-01f, -1.08286506e-02f, 2.20606532e-02f, -3.60704511e-02f, -2.22538877e-02f, 1.42114377e-02f,
  1.20433355e-02f, -8.90610144e-02f, -8.56078230e-03f, -4.20245007e-02f, 4.16595722e-03f, 6.82921708e-02f, 3.89148332e-02f, 2.65800264e-02f, 1.05009694e-02f, -4.25426625e-02f,
  3.63821760e-02f, -3.05892155e-02f, 2.28728689e-02f, 7.33617286e-04f, 9.92686953e-03f, -4.01828438e-02f, 4.21997951e-03f, -5.64524420e-02f, 5.31717110e-03f, 1.05676301e-01f,
  -3.44334543e-02f, 9.04203430e-02f, -1.87891573e-02f, -4.17872891e-02f, -5.38977906e-02f, 9.42735821e-02f, 8.99602622e-02f, 1.09145567e-01f, -8.99091549e-03f, -2.26691160e-02f,
  4.78665605e-02f, 1.44519776e-01f, -2.68620923e-02f, 6.85387552e-02f, -1.52490631e-01f, -7.25072026e-02f, 8.49615112e-02f, -7.02991635e-02f, 9.46571752e-02f, 1.97875842e-01f,
  -2.95844376e-02f, 2.02989623e-01f, -5.11878915e-02f, 5.92592061e-02f, -3.31645817e-01f, 5.69569785e-03f, -1.66534171e-01f, 1.88924652e-02f, 5.79426661e-02f, -4.12953738e-03f,
  -1.89903125e-01f, -1.24593042e-01f, -1.94065079e-01f, -8.78525451e-02f, 2.98922285e-02f, 1.08702391e-01f, -3.63710597e-02f, 4.90942411e-02f, 7.25360066e-02f, -6.14645518e-02f,
  6.82583973e-02f, 1.59314826e-01f, 6.83300644e-02f, 7.21848533e-02f, -1.11077495e-01f, -7.93208033e-02f, 8.56329873e-03f, 5.02769649e-02f, 5.32771386e-02f, -7.34649692e-03f,
  -9.91966650e-02f, 3.61636579e-02f, 1.55617613e-02f, 8.31893310e-02f, 5.79370707e-02f, 2.10469738e-02f, -5.26200533e-02f, -6.32366464e-02f, 3.19805145e-02f, -7.72297457e-02f,
  -2.48607937e-02f, 6.05351664e-02f, -4.23957855e-02f, -3.50178964e-02f, -7.91833997e-02f, 5.27638867e-02f, 9.41474512e-02f, 8.65071733e-03f, 8.41544643e-02f, -5.48133738e-02f,
  -2.72137467e-02f, 5.84815070e-02f, -2.38065445e-03f, 1.41733447e-02f, 6.87287524e-02f, -3.34314182e-02f, 9.22348350e-02f, 7.92000517e-02f, 3.05429269e-02f, 4.47584540e-02f,
  -1.57680397e-03f, 2.03921255e-02f, 4.64940071e-02f, -5.58040179e-02f, -8.16140398e-02f, -2.69772150e-02f, -2.22092066e-02f, 5.07963672e-02f, 9.80293378e-02f, 1.41537394e-02f,
  -1.13874637e-02f, -8.14583600e-02f, -1.55341867e-02f, -2.74630804e-02f, -1.72598809e-02f, -3.05017009e-02f, 3.64989811e-03f, -5.81320487e-02f, -5.25711440e-02f, 5.33827394e-03f,
  7.57948682e-03f, 7.21238274e-03f, -4.01482657e-02f, -6.72994256e-02f, -7.77612180e-02f, 4.44983989e-02f, -9.32514817e-02f, -1.89540610e-02f, 4.38073166e-02f, 4.56176735e-02f,
  -1.12009957e-01f, -1.99698620e-02f, 3.73490341e-02f, 9.00328234e-02f, 1.40046835e-01f, 2.24884748e-02f, -6.41275048e-02f, -1.29035562e-01f, 2.32630763e-02f, -7.18221292e-02f,
  -1.06809989e-01f, 2.87329536e-02f, -1.11118563e-01f, 2.28973161e-02f, -8.14130530e-02f, -3.25357206e-02f, -2.42562778e-03f, 8.67187902e-02f, -4.33596820e-02f, 5.47779612e-02f,
  2.81179935e-01f, 1.58632219e-01f, 1.50621250e-01f, 2.17835203e-01f, 7.64001533e-02f, -7.75966495e-02f, -5.50577790e-02f, -5.95437773e-02f, 2.64045656e-01f, 4.30767275e-02f,
  -1.68691054e-01f, 3.36922258e-01f, -2.07351208e-01f, -3.49375233e-02f, -1.60452142e-01f, -1.19383380e-01f, -1.69545084e-01f, -2.48057954e-03f, -1.18583785e-02f, 5.63525595e-02f,
  -5.52234538e-02f, -1.32776365e-01f, -7.51526132e-02f, 3.23356129e-02f, 1.37921154e-01f, 1.51962101e-01f, -6.22704737e-02f, -6.23977147e-02f, 2.59200912e-02f, -6.18277490e-02f,
  -1.02871798e-01f, -9.69968457e-03f, 1.52791649e-01f, -1.67603381e-02f, 7.82810152e-03f, 9.55835134e-02f, -7.23451227e-02f, -5.43006472e-02f, -1.04359582e-01f, 5.12734838e-02f,
  1.06279552e-02f, -2.92106848e-02f, 4.93958481e-02f, -1.87016483e-02f, -2.11826572e-03f, 7.01968372e-02f, 8.09584707e-02f, 3.27801481e-02f, 1.19409852e-01f, 4.01855633e-02f,
  2.05213234e-01f, 3.56253348e-02f, -4.52958196e-02f, -4.02740911e-02f, 9.88350902e-03f, 9.42838937e-03f, 4.89432830e-03f, 1.45532272e-03f, 8.94152150e-02f, 3.95303480e-02f,
  1.45383291e-02f, -2.30823979e-02f, 1.00750819e-01f, -1.51272370e-02f, 6.05624393e-02f, 3.04944105e-02f, 3.78425084e-02f, -5.97046129e-02f, 2.75360444e-03f, 7.03865848e-03f,
  -5.23875169e-02f, -4.96720485e-02f, -1.25172148e-02f, 5.61622364e-05f, 4.15088274e-02f, 5.92578389e-02f, -1.40749943e-02f, -1.16981581e-01f, 4.84262146e-02f, -4.62000770e-03f,
  -1.99535508e-02f, -1.20999971e-02f, -7.59427436e-03f, 1.48996450e-02f, 5.77669451e-03f, 2.78808828e-02f, -1.76429953e-02f, 1.01329736e-01f, -2.19151354e-03f, -7.19836578e-02f,
  -2.30701938e-01f, -3.01056415e-01f, -6.57131597e-02f, -1.10783994e-01f, 7.14028627e-02f, -2.21964493e-02f, -8.78711492e-02f, 2.43758317e-03f, -7.75592327e-02f, -2.78136581e-02f,
  -6.92198751e-03f, -2.11026650e-02f, -3.42535088e-03f, -7.27638928e-03f, -6.24819286e-02f, -6.85413405e-02f, -6.85194209e-02f, -4.73268777e-02f, -7.64654353e-02f, -8.43903944e-02f,
  1.34584270e-02f, -2.79180333e-02f, 7.40386546e-02f, -3.12006343e-02f, -5.14582060e-02f, -2.84406003e-02f, -2.27276590e-02f, 8.17693828e-04f, -2.29983311e-02f, -5.15485555e-02f,
  1.03273705e-01f, -3.53801727e-01f, 1.46398306e-01f, 3.59227844e-02f, 2.09640130e-01f, 1.14187948e-01f, 1.95146054e-01f, -1.45406291e-01f, -1.44555688e-01f, -2.21239015e-01f,
  -2.10065059e-02f, 1.07383262e-02f, -1.07565388e-01f, -3.77314053e-02f, 2.56339818e-01f, -4.92508151e-02f, 9.83554125e-02f, 3.47904116e-02f, -3.04313935e-02f, -1.55702353e-01f,
  4.30165827e-02f, 1.06096687e-02f, 1.87257960e-01f, 8.27193633e-02f, 4.61969860e-02f, 7.97934458e-03f, 4.42184582e-02f, 2.15620980e-01f, 2.22403966e-02f, 1.79482609e-01f,
  7.60169839e-03f, -1.64746970e-01f, -1.30944014e-01f, -1.52563043e-02f, -2.67304778e-02f, -8.85548012e-04f, 8.46353397e-02f, 1.50047034e-01f, -6.20256513e-02f, -8.86834785e-02f,
  -2.66708229e-02f, -1.18770236e-02f, 1.55786872e-02f, 7.34842420e-02f, 4.12583798e-02f, -2.68031023e-02f, 2.35952437e-04f, -4.52568978e-02f, -2.57399864e-02f, -7.00602029e-03f,
  -7.72514567e-02f, 9.40498337e-02f, -4.91264742e-03f, 5.30120954e-02f, -6.61781873e-04f, -1.37712911e-03f, -1.40888682e-02f, 8.68282765e-02f, -6.02196641e-02f, -5.10548428e-02f,
  1.53270483e-01f, -1.35282883e-02f, -2.96140164e-02f, -1.99223999e-02f, 3.48416902e-02f, -7.34557211e-02f, 3.59471478e-02f, -5.82140759e-02f, 2.86917072e-02f, 1.79068185e-02f,
  -7.68802091e-02f, 1.26363840e-02f, -1.40317276e-01f, -4.58585881e-02f, 2.71311719e-02f, -7.20102265e-02f, 7.07402676e-02f, -6.42878190e-02f, 8.02311394e-03f, -6.91308081e-02f,
  -8.55075493e-02f, -3.80828306e-02f, 1.14361167e-01f, -3.11695766e-02f, 7.86334351e-02f, -5.70083596e-03f, -1.09188952e-01f, 4.86045890e-02f, 5.27900681e-02f, -2.14408319e-02f,
  -3.21140915e-01f, -2.71519005e-01f, -2.78357733e-02f, -3.22459340e-02f, -3.90972421e-02f, 2.56110094e-02f, -5.79973683e-02f, -4.16680574e-02f, -9.54878777e-02f, 5.56787364e-02f,
  4.23821695e-02f, 9.00207385e-02f, -5.70836850e-03f, -8.04437697e-03f, 2.24410836e-02f, -8.99550691e-02f, -5.41080236e-02f, -8.30553621e-02f, -3.89028564e-02f, 5.07062078e-02f,
  -4.96155582e-02f, 5.42112142e-02f, 1.68299361e-03f, 3.75161530e-03f, -5.74466735e-02f, 4.49563265e-02f, -1.34447530e-01f, 3.10161877e-02f, 3.07650790e-02f, 1.82330646e-02f,
  1.45488605e-01f, 9.48728919e-02f, 1.73726544e-01f, 2.54712671e-01f, -8.55211467e-02f, -9.87431034e-02f, -1.41713798e-01f, 1.07294001e-01f, -1.08781032e-01f, -1.37709558e-01f,
  9.67947841e-02f, 5.91421202e-02f, -4.51060161e-02f, 9.50710699e-02f, 2.03216508e-01f, -6.52590618e-02f, 1.80748198e-02f, -2.30045766e-02f, -3.47182117e-02f, -1.00617558e-02f,
  1.08194046e-01f, 5.20573370e-03f, 1.76308811e-01f, 1.86236709e-01f, 8.80714506e-02f, 1.60981119e-01f, 3.09278034e-02f, -6.68275952e-02f, 1.04925580e-01f, -1.99509304e-04f,
  -1.22521974e-01f, 5.24990112e-02f, -2.39898860e-02f, -6.69081509e-02f, 3.78401093e-02f, 3.42649855e-02f, -9.53920186e-02f, 8.23960230e-02f, 8.10026154e-02f, -7.90304765e-02f,
  -7.19855055e-02f, 7.90262967e-02f, -1.98562257e-02f, -6.21699262e-03f, -4.59305197e-02f, 8.55020434e-02f, -4.59394269e-02f, 4.76760082e-02f, -6.07536314e-03f, 4.75742519e-02f,
  -2.67646424e-02f, 5.60128726e-02f, -4.92901541e-02f, -2.48218551e-02f, 6.65026605e-02f, -1.19393736e-01f, -8.54652449e-02f, 2.35040877e-02f, 8.74007270e-02f, -2.30519902e-02f,
  -4.32071323e-03f, -4.41492610e-02f, 9.98940170e-02f, 1.07059637e-02f, 7.19892234e-02f, 3.12468465e-02f, -3.08223590e-02f, -4.81376871e-02f, -6.90422654e-02f, -3.69958319e-02f,
  1.37767056e-02f, 2.04509590e-02f, -3.27718966e-02f, 3.40574048e-02f, 3.32030538e-03f, -7.14403838e-02f, 3.24036926e-02f, -9.14683491e-02f, -4.78311777e-02f, 5.00043593e-02f,
  7.50684515e-02f, -5.89794433e-03f, 8.03299993e-02f, -5.55553548e-02f, -7.59645402e-02f, 5.00955507e-02f, -5.61491549e-02f, -4.01667766e-02f, -5.95445260e-02f, -2.77189948e-02f,
  -9.21542123e-02f, 9.70316529e-02f, -3.02370507e-02f, -1.15766041e-01f, 2.77903368e-04f, 3.10119614e-02f, -4.16534990e-02f, -5.35753891e-02f, 8.57790858e-02f, 5.37850671e-02f,
  3.93005200e-02f, -2.17239242e-02f, -4.92496416e-02f, 4.40148488e-02f, -2.88925823e-02f, -5.39458299e-04f, 2.47200914e-02f, 2.62988731e-02f, 1.67708304e-02f, 6.91393837e-02f,
  -1.28477057e-02f, -4.38499749e-02f, -8.26030374e-02f, 4.36584465e-02f, -5.23972400e-02f, -1.22505203e-02f, -1.79656576e-02f, 4.94597480e-02f, 3.12687047e-02f, -6.97356649e-03f,
  1.21981256e-01f, -7.42635429e-02f, 2.19662786e-01f, -3.25120352e-02f, 4.58383895e-02f, 1.11243919e-01f, 2.03874782e-01f, -5.01779653e-02f, 2.45899826e-01f, -9.96885300e-02f,
  -5.11067659e-02f, -2.28926633e-02f, 1.22215385e-02f, -1.94791779e-01f, 2.27276057e-01f, 7.77163580e-02f, -9.51554701e-02f, -1.56828806e-01f, -3.15177962e-02f, 1.27005046e-02f,
  -3.60954949e-03f, -1.52602062e-01f, 1.37943206e-02f, -1.55418247e-01f, -9.35643017e-02f, -7.75761530e-02f, -1.02206983e-01f, 1.60252564e-02f, -1.17872648e-01f, 1.84656885e-02f,
  4.47636880e-02f, 1.10461451e-01f, 1.70749426e-02f, 3.96736003e-02f, -1.75665691e-02f, -1.31580174e-01f, -9.97996032e-02f, 2.74935141e-02f, 1.08012557e-01f, -1.73250097e-03f,
  -7.22933710e-02f, -9.69348103e-02f, 5.42856120e-02f, 1.42317703e-02f, 1.17874287e-01f, -3.15263160e-02f, -7.30444342e-02f, -4.56787646e-02f, 1.52734220e-01f, 8.29968527e-02f,
  1.02950506e-01f, 2.42226049e-02f, 1.20695509e-01f, -2.05475204e-02f, -1.81587171e-02f, 6.68142885e-02f, 1.17520265e-01f, 5.30907549e-02f, -7.20506832e-02f, 7.32472241e-02f,
  -4.71707024e-02f, 1.35933347e-02f, -2.93601528e-02f, 4.63991016e-02f, -2.49380805e-02f, 8.10155421e-02f, -1.00871287e-01f, -2.47870181e-02f, 5.43704294e-02f, 9.08559635e-02f,
  6.58467114e-02f, 1.47584938e-02f, -3.62646184e-03f, 1.05683524e-02f, -2.22618897e-02f, 2.78996751e-02f, -4.77649942e-02f, -5.11696823e-02f, -8.12132135e-02f, 5.40199280e-02f,
  -1.52172968e-02f, 7.49156624e-02f, -1.14561521e-01f, -3.08204386e-02f, 5.49522005e-02f, 8.75812098e-02f, 3.52073088e-02f, -6.39428496e-02f, 1.91444010e-02f, -3.04998420e-02f,
  -1.06678657e-01f, -6.99740881e-03f, 3.00088674e-02f, -8.47124979e-02f, -1.41314983e-01f, -1.41262084e-01f, -1.75868925e-02f, -2.49604005e-02f, 1.14903502e-01f, -2.18786169e-02f,
  -1.24002865e-03f, -8.96742418e-02f, -1.99778955e-02f, -9.64796767e-02f, 6.42439276e-02f, -9.78171006e-02f, 3.65370065e-02f, 6.55547082e-02f, 7.68378377e-02f, -5.36661036e-02f,
  -1.65137704e-02f, -7.94889033e-03f, -2.24207179e-03f, -2.67444588e-02f, -4.00918610e-02f, 9.60820168e-02f, -1.98982917e-02f, -2.93715540e-02f, -8.63689482e-02f, -5.07223494e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.36701912e-01f, 6.57579899e-02f, 5.82093559e-02f, 1.56880394e-01f, 1.21148169e-01f, 7.87437111e-02f, 5.39977849e-02f, 1.65801197e-01f, 5.30810915e-02f, 4.08843383e-02f,
  8.57655890e-03f, 2.55609900e-02f, -3.18835974e-02f, 9.24412757e-02f, 1.91850979e-02f, 9.85785872e-02f, -1.04933986e-02f, 7.44831115e-02f, -2.39001401e-02f, 1.41483024e-01f,
  2.79989094e-02f, 7.04549327e-02f, 1.24956705e-01f, 6.24759216e-03f, 1.34476945e-01f, 1.94527730e-01f, 5.51799685e-02f, 2.43130565e-01f, 1.26091346e-01f, 1.48734644e-01f,
  1.72293305e-01f, 1.15586117e-01f, -7.88770523e-03f, 1.95981888e-03f, 1.62823230e-01f, 7.61287659e-02f, 2.78944448e-02f, 1.71166807e-01f, -3.91083909e-03f, 2.23367780e-01f,
  1.32690907e-01f, 4.57220860e-02f, 3.24101970e-02f, 7.31068328e-02f, 8.30705166e-02f, 7.76088005e-03f, 1.60234362e-01f, 5.72580025e-02f, 1.49516478e-01f, 1.91016555e-01f,
  5.15404120e-02f, 1.61449105e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  6.70052469e-02f, 3.43346782e-02f, 8.49523023e-02f, 8.50557163e-02f, 2.10772529e-01f, -1.46263346e-01f, 5.42046390e-02f, 8.83243755e-02f, 5.76705225e-02f, 2.11713776e-01f,
  1.64938420e-01f, 5.80451675e-02f, -2.69202232e-01f, 9.51137170e-02f, 8.16994980e-02f, 5.28340936e-02f, 1.29561469e-01f, -2.03821927e-01f, 8.59498158e-02f, -2.11121608e-02f,
  -9.16862190e-02f, 1.83423921e-01f, -1.17109425e-01f, -1.93572920e-02f, -1.62871871e-02f, -9.63252783e-02f, 5.10171652e-02f, 8.36668313e-02f, -5.33069856e-02f, -1.70422748e-01f,
  3.78850207e-04f, -4.03679982e-02f, -1.41500443e-01f, 5.18696345e-02f, 7.17628375e-02f, -1.02594867e-01f, -5.45319729e-02f, 1.81248948e-01f, -1.00459054e-01f, 1.62764862e-01f,
  -4.68511060e-02f, 1.02441153e-02f, -5.82810305e-02f, 9.42000970e-02f, -1.15708061e-01f, 1.04821377e-01f, -1.59011390e-02f, 1.57315005e-02f, -1.51921719e-01f, 4.90105664e-03f,
  1.48068786e-01f, -1.14131477e-02f, 1.11705869e-01f, 1.07351653e-01f, -1.07842758e-01f, -5.93444845e-03f, -3.84999067e-02f, -1.25873774e-01f, -4.72751446e-02f, -1.41553953e-02f,
  -2.15867069e-02f, 4.32778038e-02f, -5.41498512e-02f, 1.14617750e-01f, -2.70436332e-02f, -1.26584500e-01f, -4.30934019e-02f, -6.43932074e-02f, 5.38251139e-02f, 8.11410323e-02f,
  1.61290094e-01f, -6.97369650e-02f, -1.95315361e-01f, 7.50622526e-02f, 1.90252885e-01f, 9.82361585e-02f, -2.62982637e-01f, -3.44989970e-02f, 6.32847324e-02f, -1.03006504e-01f,
  1.24146596e-01f, 2.24836543e-01f, -7.39611015e-02f, -1.71938524e-01f, -1.48229664e-02f, 4.33903076e-02f, -1.18782260e-02f, -7.72228390e-02f, -2.03266926e-02f, 7.42947385e-02f,
  -9.26124752e-02f, 1.16154635e-02f, 1.03274928e-02f, 1.62305117e-01f, 6.27845526e-02f, 3.03863466e-01f, 1.52535617e-01f, -2.63457894e-01f, -8.96415040e-02f, -7.59425759e-02f,
  1.05676524e-01f, -2.13011995e-01f, -2.47662701e-02f, -4.16560136e-02f, 2.50376791e-01f, -1.66038066e-01f, 6.69949949e-02f, -7.58884028e-02f, 1.89557269e-01f, -1.32161528e-02f,
  -2.87659597e-02f, -1.27735212e-01f, 3.16948652e-01f, 2.58801669e-01f, 1.69936448e-01f, -2.16657311e-01f, -4.63691466e-02f, 1.31901324e-01f, -7.71701038e-02f, 1.06626168e-01f,
  1.25424221e-01f, 6.43727481e-02f, 1.06194921e-01f, 6.91707879e-02f, 1.20210424e-01f, -3.05279028e-02f, 1.08481586e-01f, 4.37122285e-02f, 2.44206861e-02f, 5.76982312e-02f,
  -9.54797119e-02f, 6.37375331e-03f, -5.30300662e-02f, -3.92531801e-04f, 3.99015322e-02f, -1.27154961e-01f, -1.90286003e-02f, 2.44474158e-01f, -2.27169767e-02f, 1.42900661e-01f,
  -1.42837256e-01f, 3.46158780e-02f, 1.47572517e-01f, -7.37721398e-02f, 1.22757919e-01f, -8.07910785e-02f, -1.95456132e-01f, -1.31218478e-01f, -5.73908091e-02f, 9.04594734e-02f,
  -2.41346881e-01f, -1.47590235e-01f, -2.57822782e-01f, -2.28880286e-01f, -9.60770622e-02f, -1.68938249e-01f, 2.18023807e-02f, 1.14321448e-01f, -1.58200055e-01f, 1.03422202e-01f,
  -7.14678392e-02f, 3.52806523e-02f, -1.15286775e-01f, -1.39427751e-01f, -1.18906654e-01f, -2.02160776e-01f, -4.43770103e-02f, -3.84476930e-02f, 5.81495315e-02f, 1.31958146e-02f,
  -9.85300168e-03f, -2.16257349e-02f, 1.92600358e-02f, -1.70818910e-01f, -4.58476041e-03f, -7.53526613e-02f, -2.06417605e-01f, 1.79001704e-01f, -1.06831551e-01f, -2.29039356e-01f,
  -1.76954612e-01f, -8.76748189e-02f, -8.87106284e-02f, 5.54691106e-02f, -8.33219290e-03f, -1.58620760e-01f, -7.88918436e-02f, -7.65939578e-02f, -3.68859246e-02f, 8.83976519e-02f,
  5.15780002e-02f, 4.05614674e-02f, -7.34861568e-02f, 7.33117312e-02f, 5.42267971e-02f, -7.33489497e-03f, 1.55478626e-01f, 2.20151067e-01f, 3.93769741e-02f, -9.32400823e-02f,
  -2.17178576e-02f, -9.15125534e-02f, 2.63440125e-02f, -6.63822740e-02f, -1.19009934e-01f, 2.55976230e-01f, -1.05831638e-01f, -7.74557590e-02f, 8.33641067e-02f, 9.28487033e-02f,
  1.37468502e-01f, -1.42824546e-01f, -4.06097397e-02f, -3.98463383e-02f, 9.67498049e-02f, 6.16034903e-02f, -8.23435858e-02f, 1.25283435e-01f, -4.10979874e-02f, 4.75949459e-02f,
  1.20593626e-02f, 9.92145613e-02f, 1.13954663e-01f, 1.99508429e-01f, 1.48524746e-01f, -2.31007010e-01f, -6.43210411e-02f, -3.55332866e-02f, 1.55642405e-01f, 5.79847805e-02f,
  -2.39991490e-02f, 5.89379407e-02f, 2.65320301e-01f, 1.27937168e-01f, 1.10034198e-02f, 6.15656003e-02f, 6.81057647e-02f, 1.97493900e-02f, -8.35579559e-02f, 2.40621436e-02f,
  2.28354365e-01f, 1.49635032e-01f, 4.78832759e-02f, -1.73545033e-01f, 7.37602413e-02f, 1.07937649e-01f, 1.79710999e-01f, 5.56398593e-02f, 8.30411762e-02f, 1.83269113e-01f,
  -1.16891023e-02f, 5.31601859e-03f, 8.38062912e-02f, -4.86820564e-03f, 1.62117690e-01f, -2.04950217e-02f, -3.53666618e-02f, -3.90536338e-02f, -1.18178003e-01f, 4.60013300e-02f,
  3.80642638e-02f, -9.86385196e-02f, 8.32760781e-02f, 1.42883454e-02f, 5.25177084e-02f, 1.77481622e-02f, 2.20846254e-02f, 4.06821072e-02f, -1.07254402e-03f, 2.07107753e-01f,
  -2.44164150e-02f, -5.37667163e-02f, 5.48309609e-02f, -1.26436561e-01f, 2.19398648e-01f, -1.71166196e-01f, -1.02916665e-01f, 4.25492302e-02f, 8.65815878e-02f, 1.54247910e-01f,
  2.11130194e-02f, -1.14342719e-01f, -2.41033286e-01f, -4.58336361e-02f, 1.54410034e-01f, 5.74826859e-02f, 5.56732379e-02f, -1.52089223e-01f, 6.88210279e-02f, 6.49802238e-02f,
  1.11560278e-01f, 5.29935732e-02f, -8.89395028e-02f, 6.44288361e-02f, 8.56947154e-02f, -6.70826808e-02f, 1.86125457e-01f, 5.20591922e-02f, 4.94932057e-03f, 7.45791420e-02f,
  7.44398832e-02f, -2.44336389e-03f, -8.82834643e-02f, 1.50437459e-01f, -1.06898472e-01f, 2.25002673e-02f, -9.53224003e-02f, -1.38455912e-01f, 2.32548770e-02f, -2.70412751e-02f,
  1.48230374e-01f, -1.04773929e-02f, -1.16833545e-01f, -1.16304588e-02f, 5.13091162e-02f, -9.85107720e-02f, -8.41803476e-02f, 1.56230628e-01f, 5.66627681e-02f, 2.64721997e-02f,
  -1.08214796e-01f, 4.14880970e-03f, 3.74229103e-02f, 6.60403296e-02f, 1.11465707e-01f, 8.85993764e-02f, 1.79443538e-01f, 7.55861728e-03f, -5.91393597e-02f, -6.51544258e-02f,
  1.37740180e-01f, 8.77908021e-02f, -2.35029951e-01f, -3.37800682e-02f, 3.66616733e-02f, 7.42259948e-03f, 1.67368844e-01f, 5.79545014e-02f, -7.02165663e-02f, -1.03592344e-01f,
  6.92917705e-02f, 1.01413347e-01f, -6.56059086e-02f, -1.15301115e-02f, 1.51166813e-02f, -6.52591288e-02f, -8.41518119e-02f, 6.73860088e-02f, -4.02810574e-02f, 1.26845920e-02f,
  -3.81254740e-02f, 5.52790649e-02f, 7.79356882e-02f, -1.94875762e-01f, -3.51625532e-02f, -1.29277140e-01f, 6.19277321e-02f, -7.71488175e-02f, -1.00747705e-01f, 2.68304776e-02f,
  1.12586252e-01f, 2.86636334e-02f, 9.46428180e-02f, -8.50011110e-02f, 1.63205620e-02f, -3.81953269e-02f, 1.13516010e-01f, -2.52710329e-03f, 2.34557420e-01f, 1.46519572e-01f,
  5.83253428e-02f, -2.49673456e-01f, -5.19704707e-02f, 4.49260995e-02f, -1.64752945e-01f, -4.82774427e-04f, 2.31146254e-02f, 2.98401527e-02f, 4.43218835e-02f, -2.32419278e-02f,
  1.43909171e-01f, 1.31145760e-03f, 9.04780701e-02f, -5.03166802e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.01027586e-01f, -3.06760762e-02f, 7.97886029e-03f, 4.41375840e-03f, -1.85294319e-02f, 9.62699354e-02f, 1.24260336e-02f, -3.36916931e-02f, 6.78282091e-03f, -1.38134271e-01f,
  8.67269095e-03f, -1.34708807e-01f, 4.45030704e-02f, 1.62936077e-02f, -4.80929092e-02f, -1.09050743e-01f, -1.84102193e-01f, 1.16215795e-01f, 1.43777132e-01f, 4.15330417e-02f,
  2.34822780e-02f, -5.61566502e-02f, 1.39231235e-01f, 3.97523455e-02f, 2.47543678e-02f, 1.86196625e-01f, -9.02864560e-02f, 9.24792290e-02f, -5.06986529e-02f, 6.01498410e-03f,
  1.43590793e-01f, 7.01279342e-02f, 1.54010162e-01f, -2.87963897e-02f, -3.98896970e-02f, -2.13240925e-02f, 7.88973570e-02f, -4.52178949e-03f, 1.03722073e-01f, 8.83230567e-03f,
  -4.71507385e-02f, -4.75335692e-05f, -1.73783466e-01f, 3.32469828e-02f, 5.17927408e-02f, -4.17102017e-02f, 1.03516065e-01f, -8.29638541e-03f, 1.98527977e-01f, 1.44068971e-01f,
  -5.17952554e-02f, 4.23602611e-02f, 1.95573345e-02f, -1.71470772e-02f, 1.28244340e-01f, -8.85323957e-02f, 1.65544480e-01f, 5.45736402e-02f, -3.84871550e-02f, 4.40267660e-02f,
  5.49372248e-02f, -7.70544931e-02f, 1.47383228e-01f, 3.04576680e-02f, 1.71659201e-01f, 9.09116566e-02f, 1.08388983e-01f, 1.68616161e-01f, 2.21892431e-01f, 5.47646731e-02f,
  2.30234140e-03f, -1.11012325e-01f, 8.03795457e-02f, 4.38885354e-02f, -1.42167024e-02f, -3.73599306e-02f, -1.95322800e-02f, 1.75362438e-01f, 1.08931154e-01f, -7.69133046e-02f,
  2.62897730e-01f, -1.37293667e-01f, 3.17043141e-02f, -1.26787782e-01f, -2.70850826e-02f, 1.57499686e-01f, -4.86760288e-02f, 5.72816934e-03f, -1.38489204e-02f, 7.08071189e-03f,
  -9.25910994e-02f, -1.06049798e-01f, -9.74491611e-02f, -3.62806208e-02f, 4.61896732e-02f, 2.18075290e-01f, -5.90075739e-02f, 8.01511258e-02f, -1.77000850e-01f, -3.96198705e-02f,
  -7.39092007e-02f, 5.90355098e-02f, 2.00851053e-01f, 6.40073791e-02f, 1.51270196e-01f, -7.54740834e-02f, -1.74437016e-01f, 2.16893390e-01f, 2.36278251e-02f, -1.49030060e-01f,
  -1.90137438e-02f, 9.65923071e-02f, -1.58706412e-01f, 1.86503693e-01f, 1.50705710e-01f, -1.83339491e-01f, -6.50783479e-02f, -1.54057881e-02f, 9.21753496e-02f, 1.34118963e-02f,
  3.77871729e-02f, -4.77335416e-02f, -1.14202589e-01f, -1.47888185e-02f, 6.52356213e-03f, 5.86201251e-03f, -5.16243763e-02f, 2.17901841e-01f, 1.27236158e-01f, 9.97590125e-02f,
  3.28660086e-02f, 7.72301480e-02f, 5.26355654e-02f, -1.38021380e-01f, -1.03449963e-01f, 6.74976334e-02f, 1.97743163e-01f, 4.42134142e-02f, -1.54939249e-01f, -1.90135986e-02f,
  6.86143935e-02f, -3.05210724e-02f, 1.81181684e-01f, 1.34857804e-01f, -1.36404663e-01f, -1.01101108e-01f, -5.22505753e-02f, 1.42369464e-01f, 7.67557099e-02f, 7.88942054e-02f,
  -9.81046930e-02f, 3.47928405e-02f, 1.34380490e-01f, 1.39005890e-03f, 2.11972147e-01f, 8.79660901e-03f, 4.15069610e-03f, -8.85706991e-02f, -8.91921520e-02f, -3.77932214e-03f,
  -3.23403329e-02f, 3.69053364e-01f, 4.46967781e-02f, -7.48555660e-02f, 2.08138227e-02f, 8.62343609e-02f, 9.68238786e-02f, -4.11175936e-02f, -1.50651559e-01f, -1.32908732e-01f,
  -1.00651927e-01f, -2.08709147e-02f, -1.23951815e-01f, -8.57231840e-02f, 1.06012877e-02f, 7.51695409e-02f, -2.83776899e-03f, -3.83535735e-02f, 2.16699298e-02f, 2.21376479e-01f,
  2.53424235e-02f, 9.37497593e-04f, 2.45588087e-02f, 8.13127384e-02f, 8.12605396e-02f, -9.29467753e-02f, 5.11863455e-02f, 6.64909035e-02f, 9.52023715e-02f, 8.31227656e-03f,
  -3.90124880e-02f, 7.64959157e-02f, 7.30724111e-02f, 1.50709413e-02f, 9.33753327e-02f, -1.11156804e-02f, 9.43518728e-02f, 1.24495856e-01f, -2.99419705e-02f, 4.35183309e-02f,
  -2.05562681e-01f, -7.06689879e-02f, -1.96257327e-02f, 5.87972105e-02f, -3.26343067e-02f, -1.75154746e-01f, -6.73314556e-02f, -3.19768898e-02f, -3.65535244e-02f, 1.48621157e-01f,
  -1.31358713e-01f, 3.44889350e-02f, 3.04531958e-02f, -8.15380663e-02f, 8.86492208e-02f, -1.42027270e-02f, 3.24086845e-02f, -1.77053418e-02f, 8.62753298e-03f, 1.70332894e-01f,
  -2.70830430e-02f, 1.10613383e-01f, 2.93679759e-02f, -9.73332748e-02f, 9.17228460e-02f, -2.19893381e-01f, 1.02554873e-01f, 1.52885243e-01f, 1.30840078e-01f, -2.00119436e-01f,
  -1.11242399e-01f, -1.13823516e-02f, 1.13752507e-01f, 8.44965205e-02f, 2.92217225e-01f, -2.17991233e-01f, 4.66068871e-02f, -3.04853972e-02f, 6.94474727e-02f, -5.78055568e-02f,
  7.86487460e-02f, -5.83604053e-02f, -5.65069765e-02f, -6.78143352e-02f, 3.31864529e-03f, -8.85268152e-02f, -4.00662571e-02f, 6.48637116e-02f, 1.81957502e-02f, 1.23441741e-01f,
  1.54598966e-01f, 8.14479291e-02f, 8.20398033e-02f, -2.58137640e-02f, 9.80696008e-02f, -1.47947833e-01f, 1.99979395e-01f, 1.25494033e-01f, 1.03632703e-01f, 2.12835312e-01f,
  1.85108379e-01f, -4.59457114e-02f, -6.72432259e-02f, 1.76284552e-01f, 2.48749033e-01f, 1.39979674e-02f, 7.56488889e-02f, -9.72025990e-02f, -4.28474247e-02f, -7.19838589e-02f,
  5.00258133e-02f, -7.19888955e-02f, -1.06706172e-01f, -1.38513297e-01f, 5.89291081e-02f, 1.73429593e-01f, 1.12028293e-01f, 9.34804082e-02f, -4.28250320e-02f, 1.26336673e-02f,
  1.08202226e-01f, -8.84373300e-03f, 3.61443944e-02f, 8.29443038e-02f, -7.71345273e-02f, -9.99746099e-02f, 2.34758500e-02f, -1.25563368e-01f, -1.20357692e-01f, 2.54126996e-01f,
  -1.14029963e-02f, -1.44669279e-01f, -2.72086337e-02f, 2.27454945e-01f, 7.15035200e-02f, 7.31710941e-02f, -7.05236197e-02f, 1.38065845e-01f, -1.66873589e-01f, 1.35702461e-01f,
  -6.61936700e-02f, 2.95042899e-02f, 1.70486569e-01f, 1.18121900e-01f, 3.02294679e-02f, -1.35452181e-01f, 9.55671147e-02f, 1.95381373e-01f, 1.12184100e-01f, 5.39839007e-02f,
  -1.04966583e-02f, -1.75146032e-02f, -4.01360989e-02f, -1.12811059e-01f, 1.07139073e-01f, 4.22662795e-02f, -3.05510563e-04f, 6.83705434e-02f, -2.67246533e-02f, 6.90765232e-02f,
  7.72307441e-02f, 1.61964849e-01f, 1.12439327e-01f, 1.46497294e-01f, -2.01759879e-02f, -1.27834693e-01f, -2.98606232e-02f, 2.29153037e-01f, 2.24130750e-01f, 1.22206412e-01f,
  2.36347807e-03f, 1.31176278e-01f, -1.73820797e-02f, -1.94759876e-01f, 1.87781125e-01f, 9.91841182e-02f, -1.53497264e-01f, 3.81348655e-02f, -6.70847893e-02f, 1.22945011e-01f,
  4.50933278e-02f, 1.77522585e-01f, -8.50914270e-02f, -7.64587596e-02f, -1.56618152e-02f, 8.72655362e-02f, 2.69460201e-01f, 2.16897484e-02f, -4.55401577e-02f, -6.48857579e-02f,
  -1.59078121e-01f, -1.90068390e-02f, 3.18822600e-02f, 3.15103233e-01f, 6.24247491e-02f, -1.30419046e-01f, -5.33801578e-02f, 1.64270282e-01f, 1.62242532e-01f, 1.45640671e-01f,
  -1.23384200e-01f, -1.30674303e-01f, -1.86379775e-01f, 1.31630898e-01f, -1.24022312e-01f, -1.34837460e-02f, 3.35286781e-02f, 5.76685779e-02f, 2.37807538e-02f, 1.30950212e-02f,
  8.88871774e-02f, 2.34884933e-01f, 1.32454634e-01f, 4.75447699e-02f, 1.09750666e-02f, 5.04889786e-02f, 9.74551290e-02f, -3.92760150e-02f, 1.59271628e-01f, 1.03923112e-01f,
  9.82910916e-02f, -9.21873376e-02f, 6.87829778e-02f, 3.39138582e-02f, 1.49109095e-01f, 1.37754545e-01f, 1.30640388e-01f, 1.92066193e-01f, 1.52261943e-01f, 1.19911864e-01f,
  -1.21168166e-01f, -3.91999446e-02f, -7.27531537e-02f, 3.54805328e-02f, 7.33237043e-02f, 5.67105524e-02f, -2.53917426e-02f, 2.77303401e-02f, 9.07334462e-02f, -1.48700684e-01f,
  2.70179570e-01f, 1.27001226e-01f, -1.23904891e-01f, -3.26731838e-02f, -7.95411915e-02f, -1.54312830e-02f, -5.75899296e-02f, 1.47767842e-01f, 6.16479777e-02f, -2.18172252e-01f,
  -1.93214282e-01f, 1.37091791e-02f, 1.44352570e-01f, 2.52950221e-01f, 1.14932209e-02f, -3.92510518e-02f, 2.18058616e-01f, -1.12625370e-02f, 5.63525632e-02f, 2.29708508e-01f,
  7.79534429e-02f, 4.52595204e-02f, -9.39433128e-02f, 5.73548768e-03f, 3.45044166e-01f, 1.98816314e-01f, 2.12043390e-01f, -6.83672577e-02f, 5.87684708e-03f, 3.92876752e-02f,
  1.20373815e-01f, 6.36804774e-02f, 1.50924072e-01f, 8.28031451e-03f, -1.15062810e-01f, -2.01645866e-02f, 4.76794578e-02f, -1.43428430e-01f, -2.18453463e-02f, 5.33506796e-02f,
  -9.04562417e-03f, 1.36669859e-01f, 2.88753007e-02f, -6.84799328e-02f, 4.91950586e-02f, 2.60229707e-01f, 5.65732904e-02f, -5.04284725e-03f, -1.54914930e-01f, -4.04575653e-02f,
  1.09736966e-02f, -1.22245513e-01f, -6.39303699e-02f, -4.50228602e-02f, 1.64544672e-01f, -1.12874851e-01f, -1.71085641e-01f, -1.47694543e-01f, 8.50122273e-02f, 1.33281559e-01f,
  -5.42226061e-02f, -1.16782365e-02f, -2.66877078e-02f, 1.21417202e-01f, 2.67393086e-02f, 1.86938450e-01f, 1.81479976e-02f, -4.32338864e-02f, -5.70477173e-02f, -3.08682751e-02f,
  5.83992042e-02f, -3.23124863e-02f, -1.38077633e-02f, -3.82745229e-02f, -2.51710285e-02f, -9.10743698e-02f, 1.42630696e-01f, 1.64324611e-01f, 1.08690865e-01f, 6.51844442e-02f,
  6.74839839e-02f, -1.25421658e-01f, 1.02459937e-01f, 9.34300274e-02f, -4.51587234e-03f, 1.61950234e-02f, -1.57295614e-02f, 1.12782992e-01f, 1.00047924e-01f, -5.92932617e-03f,
  1.81708872e-01f, -1.30242035e-01f, 1.87563136e-01f, -3.10487114e-02f, -4.40112501e-02f, -1.90431438e-02f, 4.11683097e-02f, -5.06428927e-02f, -1.08460143e-01f, -7.17720669e-03f,
  -6.41302438e-03f, 7.48980418e-02f, -8.64268690e-02f, 4.69722645e-03f, 1.01636425e-01f, 9.97376144e-02f, -1.63415615e-02f, 6.63998351e-03f, -1.43045202e-01f, -4.04430740e-02f,
  4.01719287e-02f, -6.19093664e-02f, 1.65797900e-02f, 2.94215269e-02f, 5.09513281e-02f, 1.25769377e-01f, 9.63343903e-02f, 7.30527118e-02f, -5.29799573e-02f, 3.75584848e-02f,
  -9.13751200e-02f, -8.82144943e-02f, -6.35326728e-02f, 1.42082265e-02f, 1.60857141e-01f, -2.17594042e-01f, 5.50371781e-02f, -4.81827594e-02f, -1.93835765e-01f, -9.02657025e-03f,
  -1.16485842e-01f, 8.99103433e-02f, 1.10018849e-02f, -8.20382982e-02f, 9.16945413e-02f, 4.12114989e-03f, 1.11541711e-01f, -1.46405771e-01f, -1.89431675e-03f, 1.22872721e-02f,
  3.90742309e-02f, 6.53960705e-02f, 3.98644283e-02f, -6.35951757e-02f, 1.26705229e-01f, 1.03496723e-01f, 1.29062295e-01f, 2.35155225e-01f, -6.98715299e-02f, -1.05260096e-01f,
  -9.85172018e-02f, 4.88723144e-02f, 5.50784916e-02f, 8.01720545e-02f, 1.82338998e-01f, -1.12358049e-01f, -5.45407385e-02f, 1.31261244e-01f, 5.69881359e-03f, -1.15597630e-02f,
  -6.15430437e-02f, -2.10221291e-01f, -4.96684983e-02f, 1.41139090e-01f, 7.20917881e-02f, -1.89700648e-01f, -9.07883495e-02f, 1.35601610e-01f, -4.43262123e-02f, 1.58703700e-01f,
  6.07872717e-02f, -9.64826122e-02f, -1.02705501e-01f, 8.87215510e-02f, 8.79377797e-02f, -1.08073384e-01f, 1.08185098e-01f, 1.59548849e-01f, 3.26908566e-02f, 1.67893082e-01f,
  -1.34699121e-02f, 1.06123798e-01f, -2.07402334e-02f, -8.43732059e-02f, 1.46483764e-01f, -1.34825651e-02f, 7.75171220e-02f, -2.93926764e-02f, -2.57452503e-02f, 1.36461660e-01f,
  -6.88008443e-02f, -9.69455689e-02f, 1.59752458e-01f, -4.67132926e-02f, -2.08966900e-02f, -9.78848264e-02f, -6.96985647e-02f, -1.74381845e-02f, -2.33048461e-02f, 1.75223246e-01f,
  4.57536541e-02f, -1.03123814e-01f, -1.85217783e-01f, -5.43832220e-02f, 1.08353160e-01f, 1.56260863e-01f, -3.39860655e-02f, -1.36914015e-01f, 1.05094872e-01f, 7.15258643e-02f,
  1.01056628e-01f, 9.78475362e-02f, -6.18432984e-02f, 1.91911861e-01f, 1.03445791e-01f, -3.70803842e-04f, 1.82684898e-01f, 1.26630202e-01f, 2.51698513e-02f, -3.37450206e-03f,
  5.87839223e-02f, -6.83624810e-03f, -5.72582055e-03f, 9.72732976e-02f, -7.16491640e-02f, -1.22406989e-01f, -3.84505233e-03f, -2.51982994e-02f, 2.37676427e-02f, -1.22689977e-01f,
  1.02865838e-01f, -4.23421897e-02f, -9.92124602e-02f, -2.18641032e-02f, 1.53640239e-02f, -1.16310515e-01f, 4.09387089e-02f, 2.54934460e-01f, 2.07743775e-02f, -1.03868274e-02f,
  4.68287477e-03f, 1.58723313e-02f, -2.23165378e-02f, -9.09287890e-04f, -3.54140364e-02f, 9.50536057e-02f, 9.82370079e-02f, -2.67041214e-02f, 8.56525525e-02f, 1.10428722e-03f,
  1.29312471e-01f, -2.46183341e-03f, -3.96415070e-02f, 8.03562477e-02f, -1.17047384e-01f, -3.07885576e-02f, 7.81057552e-02f, 1.11833304e-01f, 1.94972344e-02f, -8.08389299e-03f,
  -8.17479640e-02f, -2.13406175e-01f, 4.69495133e-02f, 1.87312365e-01f, -5.18487184e-04f, -1.80232376e-02f, -1.56793401e-01f, -2.34036688e-02f, 3.26932780e-02f, 1.20614804e-01f,
  1.93985812e-02f, -1.17276646e-01f, 8.99930820e-02f, -2.00889241e-02f, 5.55156954e-02f, -2.92192083e-02f, 2.00745221e-02f, 9.02659222e-02f, 4.90194522e-02f, 2.83484627e-02f,
  3.37712327e-03f, 2.03724265e-01f, -5.23640960e-02f, 6.30920753e-02f, 4.57695648e-02f, 1.60039485e-01f, -1.35935277e-01f, 3.47995088e-02f, 9.65833962e-02f, -1.70741290e-01f,
  -1.84015967e-02f, -4.23969999e-02f, 8.65544081e-02f, 5.61710149e-02f, 1.97555810e-01f, -2.07096133e-02f, -6.42773658e-02f, 6.03526384e-02f, -9.73088294e-03f, -1.25298202e-01f,
  -2.22405754e-02f, 1.65923834e-01f, 1.42306805e-01f, 2.49379855e-02f, 8.62067193e-03f, 1.15353331e-01f, 1.93616245e-02f, 9.57103595e-02f, -1.54035911e-01f, 3.03458772e-03f,
  -2.30837941e-01f, 6.12302544e-03f, -8.73745307e-02f, -8.29353184e-02f, -2.55626559e-01f, -2.31852829e-01f, 2.47467294e-01f, 6.62063062e-02f, -9.24114808e-02f, -1.90655127e-01f,
  -1.23396821e-01f, -4.09942772e-03f, 3.64613570e-02f, 5.58441766e-02f, 1.45804405e-01f, -4.72584665e-02f, 6.00184463e-02f, 7.02107549e-02f, 4.20054533e-02f, 1.36380687e-01f,
  4.26817238e-02f, -1.34543866e-01f, -2.00693816e-01f, -1.53777733e-01f, 1.45201191e-01f, -5.01845069e-02f, -1.00874342e-01f, 1.35846719e-01f, -7.96875060e-02f, 2.34559640e-01f,
  7.27989571e-03f, -8.68816525e-02f, 1.48221850e-01f, -1.83820531e-01f, -9.66674909e-02f, -1.02312624e-01f, 1.70662269e-01f, -7.31632710e-02f, 3.55772935e-02f, -1.24598064e-01f,
  1.34803683e-01f, 8.93383548e-02f, -6.71030805e-02f, 6.81929737e-02f, -8.03835839e-02f, 1.45060912e-01f, -2.22111166e-01f, 1.00005604e-01f, 1.65888295e-01f, -6.68878108e-02f,
  -3.45082171e-02f, 1.17702596e-01f, 2.30690315e-02f, 8.95553753e-02f, 1.05445631e-01f, -2.44353712e-01f, -1.62895873e-01f, 8.01043585e-02f, 7.99254104e-02f, 6.55562729e-02f,
  9.17985439e-02f, 1.66852653e-01f, 3.05923223e-02f, 7.70480633e-02f, -3.33913058e-01f, 1.19508833e-01f, -1.36646360e-01f, -5.15487492e-02f, -1.13171734e-01f, -1.18553720e-01f,
  1.28753752e-01f, -1.11224167e-01f, 1.04132578e-01f, -6.79573640e-02f, 5.19707613e-02f, -1.85770273e-01f, -1.19668514e-01f, 3.20840664e-02f, 1.94641188e-01f, 9.99918729e-02f,
  -2.99930107e-03f, 3.08901146e-02f, -2.04513874e-02f, -1.83122139e-02f, 1.75767310e-03f, 5.08636720e-02f, -4.89634201e-02f, -3.72823812e-02f, -2.84772180e-03f, -2.10326865e-01f,
  2.21316852e-02f, 1.92467630e-01f, 1.20398141e-01f, 2.16954961e-01f, 8.83701351e-03f, -4.76639345e-02f, -3.84068191e-02f, -1.44687206e-01f, 2.44855862e-02f, 2.94075385e-02f,
  2.84500599e-01f, -1.17973693e-01f, -9.68401283e-02f, -7.13722631e-02f, 1.24755047e-01f, 6.58746660e-02f, -7.56369680e-02f, -1.74173303e-02f, 4.73521836e-02f, 1.67678539e-02f,
  -6.08270243e-02f, -8.18940178e-02f, -1.46911681e-01f, 2.53766030e-03f, -7.29587674e-02f, 2.51523387e-02f, 1.37488350e-01f, 1.40861258e-01f, 6.93237707e-02f, 4.53531593e-02f,
  -1.17940828e-01f, 1.26856957e-02f, -7.55363703e-02f, 1.16724446e-01f, 7.68181533e-02f, 8.95843878e-02f, 1.90992266e-01f, 1.55017897e-01f, 1.61956444e-01f, -1.97256988e-04f,
  -1.01100072e-01f, 9.22925621e-02f, 8.49146172e-02f, 5.55755720e-02f, -8.26221853e-02f, 1.51458234e-01f, 5.96990716e-03f, 2.39482112e-02f, 2.68865883e-01f, 1.72482897e-02f,
  1.56660713e-02f, -8.96091014e-02f, -5.12719229e-02f, 3.06872763e-02f, 2.20963880e-02f, 7.72823319e-02f, -6.93900976e-04f, 7.17143193e-02f, -1.31888390e-01f, 5.85269136e-03f,
  3.50137129e-02f, 5.04726470e-02f, 1.11421943e-01f, 5.63753247e-02f, 2.81254146e-02f, -1.30132452e-01f, -3.79737616e-02f, 4.25894894e-02f, 8.42314512e-02f, 8.06652158e-02f,
  -9.12958980e-02f, 2.05631484e-03f, 2.12637261e-01f, 1.41781688e-01f, 3.28241847e-02f, 8.41277093e-02f, 1.26552045e-01f, 5.41604199e-02f, 3.09011489e-02f, 2.94906157e-03f,
  6.90364763e-02f, 8.42967555e-02f, 1.02690551e-02f, -2.06626713e-01f, 9.88431368e-03f, 1.61253065e-01f, 6.23327419e-02f, 7.35526299e-03f, -5.34852520e-02f, -1.79108307e-02f,
  2.48656562e-03f, -1.61260075e-04f, 7.64127597e-02f, 2.00279459e-01f, -1.25852339e-02f, 1.91611480e-02f, 1.67243004e-01f, 9.50488150e-02f, -1.22956121e-02f, 2.48186350e-01f,
  1.58561304e-01f, 1.48711875e-01f, -1.53741583e-01f, -1.71388313e-02f, 1.01002872e-01f, -3.72519456e-02f, 1.24709997e-02f, -1.97033569e-01f, 1.18732035e-01f, 3.81112583e-02f,
  -7.06496462e-02f, -6.56351224e-02f, 1.18997939e-01f, -3.46043929e-02f, 1.06708884e-01f, -1.04968026e-01f, -9.90878604e-03f, -8.33190046e-03f, -5.03115132e-02f, 1.82298139e-01f,
  -8.26041549e-02f, 1.59307923e-02f, -2.07675323e-01f, -7.71083608e-02f, 1.11642197e-01f, 6.13371059e-02f, 1.44857273e-01f, -1.84354365e-01f, -6.91782981e-02f, 1.43805757e-01f,
  1.56308904e-01f, 1.55025676e-01f, -2.94860341e-02f, 9.11222026e-02f, 6.70319190e-03f, -8.14510509e-02f, 6.62199929e-02f, 2.02182949e-01f, 6.90451637e-02f, -1.29183717e-02f,
  2.29166504e-02f, 8.10747594e-02f, 3.89956906e-02f, 2.08862990e-01f, -9.08814371e-02f, 2.56599695e-03f, -2.23807823e-02f, -9.84922871e-02f, -7.04729259e-02f, 3.98758538e-02f,
  1.49678215e-01f, 1.72597915e-02f, -1.51455000e-01f, 8.30501616e-02f, 1.06990628e-01f, -4.58390936e-02f, 5.75739443e-02f, 2.79042453e-01f, 3.02343387e-02f, 1.13202393e-01f,
  1.92035064e-01f, 1.39580891e-01f, 1.76209986e-01f, 5.21641001e-02f, 2.15307355e-01f, 7.60837495e-02f, -8.13372806e-03f, 1.73180372e-01f, 1.53913081e-01f, 5.38629889e-02f,
  7.55865052e-02f, 1.56338230e-01f, -1.87150776e-01f, -1.21436320e-01f, 1.15566611e-01f, -2.87300367e-02f, 2.20719222e-02f, 1.02980822e-01f, -1.58086531e-02f, -5.29028177e-02f,
  4.30030860e-02f, 1.13331541e-01f, -1.09347194e-01f, 8.29430670e-03f, -2.12651879e-01f, -4.98629399e-02f, 5.65383695e-02f, 1.37884170e-01f, -3.39260176e-02f, -3.04970350e-02f,
  -9.78644565e-02f, 8.79824385e-02f, -1.92262717e-02f, 8.82915258e-02f, 6.99531287e-02f, -1.72437057e-02f, 4.99663800e-02f, -1.77387558e-02f, 5.78443557e-02f, 1.19707145e-01f,
  -6.15481399e-02f, 9.88993049e-02f, -3.90112144e-03f, 1.95304915e-01f, -9.63516235e-02f, -1.32563412e-01f, 5.45521937e-02f, -3.17372568e-02f, 9.30523574e-02f, 2.24906981e-01f,
  1.09917462e-01f, -9.89170298e-02f, 6.49262592e-02f, -1.03089653e-01f, -1.01183318e-02f, 6.03482826e-03f, 2.32818592e-02f, -1.02461740e-01f, 1.36551410e-01f, 7.05387667e-02f,
  1.69923425e-01f, 2.45034080e-02f, 3.36606167e-02f, 1.19462609e-01f, 8.71116072e-02f, -3.33982892e-02f, -2.59485338e-02f, 3.99106778e-02f, 2.57242639e-02f, 9.03487056e-02f,
  -1.18292337e-02f, -2.48113126e-02f, 2.28195608e-01f, -4.17146087e-03f, -2.99813729e-02f, -2.17939541e-01f, 1.49192987e-02f, 7.34779015e-02f, -6.05665110e-02f, -1.07630908e-01f,
  2.61710696e-02f, -2.60852668e-02f, 6.06894307e-02f, -2.75375340e-02f, -5.50326407e-02f, -1.15142629e-01f, -5.46873584e-02f, 1.24735564e-01f, -2.50232848e-03f, 2.20279954e-02f,
  -4.67474312e-02f, -1.15541622e-01f, -6.07395098e-02f, -6.33889362e-02f, 3.35798487e-02f, 2.65373960e-02f, -2.71880925e-02f, -3.43954377e-02f, -1.66455694e-02f, -5.68517298e-02f,
  -7.37492740e-02f, 2.44600147e-01f, 6.46412075e-02f, 8.70735124e-02f, -6.09839670e-02f, 1.12318367e-01f, -1.66111216e-01f, 1.68770730e-01f, -1.80759083e-03f, 8.81600007e-02f,
  -7.07642958e-02f, 1.41369909e-01f, -3.81178521e-02f, 2.05003694e-02f, -8.43819305e-02f, -4.99503277e-02f, -7.57099688e-02f, 1.40010687e-02f, 2.36135647e-01f, -1.33920282e-01f,
  -5.06890044e-02f, -5.93055747e-02f, -7.18548745e-02f, -6.03844710e-02f, 4.34524305e-02f, 1.03100389e-01f, 2.95369495e-02f, 1.24860838e-01f, 1.07665144e-01f, 8.69565606e-02f,
  1.83070242e-01f, 9.39919800e-02f, 1.86051890e-01f, 7.72585422e-02f, 1.73630163e-01f, -2.07712203e-02f, 6.55625463e-02f, 7.04906359e-02f, -4.16706840e-04f, 6.48301989e-02f,
  -1.56932026e-01f, 7.94983432e-02f, 4.31045629e-02f, -8.48830044e-02f, 2.25317866e-01f, -1.68608531e-01f, 1.37467802e-01f, -2.46839654e-02f, 5.94959408e-02f, 2.08462924e-01f,
  -8.53317231e-02f, 4.03076895e-02f, -3.77446860e-02f, 1.39004111e-01f, -1.36963837e-02f, 7.80903026e-02f, -6.03169762e-02f, -9.67908651e-02f, 3.06092612e-02f, 1.24451391e-01f,
  -3.51246893e-02f, 5.81285469e-02f, -8.55619684e-02f, -7.59032369e-02f, 8.36130381e-02f, 1.45227551e-01f, 8.24716389e-02f, 4.86081950e-02f, 9.91727039e-02f, -1.98447402e-03f,
  -1.99329332e-01f, 1.55194849e-01f, 8.53390526e-03f, -9.70284864e-02f, 1.15730064e-02f, 5.47657721e-02f, -2.04407070e-02f, 2.82918364e-01f, 2.21411847e-02f, -1.06429242e-01f,
  4.19570506e-03f, -3.82145471e-03f, -1.50530702e-02f, -2.07892079e-02f, 2.49485970e-02f, -9.57890600e-02f, 5.31094223e-02f, 6.24140874e-02f, 1.28180444e-01f, 2.87684221e-02f,
  9.59085226e-02f, 7.73573220e-02f, -2.75853984e-02f, -1.39948269e-02f, -7.29501620e-02f, -3.34866792e-02f, -7.20599443e-02f, -3.25361490e-02f, -5.43118492e-02f, -1.54618278e-01f,
  9.26264524e-02f, -7.33778179e-02f, -4.47112434e-02f, -2.04739019e-01f, 1.15888357e-01f, 1.97410509e-01f, -6.69250190e-02f, -1.14281848e-01f, -6.11411827e-03f, 1.32855490e-01f,
  1.80083603e-01f, -4.50185128e-02f, -5.33033162e-02f, -7.74975866e-02f, 4.23399620e-02f, 9.00297910e-02f, -1.53099224e-02f, 9.71340090e-02f, -1.50195971e-01f, -7.68218637e-02f,
  -1.14131132e-02f, 2.73504350e-02f, 1.64396867e-01f, 7.57475123e-02f, 4.37789075e-02f, 2.21616682e-02f, -4.68861908e-02f, 1.72714249e-03f, 5.30223828e-04f, 1.36442065e-01f,
  3.35010588e-02f, 1.66754741e-02f, 2.01935414e-03f, -1.65109965e-03f, -1.09345704e-01f, 1.46358147e-01f, 1.18904561e-01f, 2.45040413e-02f, -1.47196651e-01f, -1.88194914e-03f,
  1.03955586e-02f, 9.67958570e-03f, -1.06479973e-01f, -1.10552749e-02f, -1.35781913e-04f, 4.85341921e-02f, 2.03478292e-01f, -6.38124421e-02f, 7.86524266e-02f, 2.49026194e-02f,
  6.01120526e-03f, -2.52280384e-02f, 3.21504031e-03f, -1.14567317e-02f, 1.14232171e-02f, 8.84853452e-02f, 2.10843250e-01f, 8.96137804e-02f, 8.93574357e-02f, 7.67909586e-02f,
  2.52562743e-02f, -4.40106019e-02f, -1.96013153e-01f, 1.49506718e-01f, 5.84925264e-02f, 2.45720334e-02f, -2.02690368e-03f, 6.27160743e-02f, 1.44706547e-01f, -8.90419334e-02f,
  1.39952838e-01f, 6.64249361e-02f, -1.31149068e-01f, -6.07845485e-02f, -6.92968443e-02f, 1.83815077e-01f, 1.87905893e-01f, 7.32921064e-02f, 3.70648652e-02f, 3.09998505e-02f,
  -5.35075404e-02f, -4.74022701e-02f, 1.20280243e-01f, 1.28083408e-01f, -5.51088676e-02f, -6.51537403e-02f, -8.62451568e-02f, -2.00435832e-01f, -4.00938690e-02f, 3.01802903e-01f,
  1.53511167e-01f, 4.61124405e-02f, 1.32924896e-02f, 5.99307641e-02f, 4.80621271e-02f, 3.43663432e-02f, -1.30201340e-01f, -8.40527657e-03f, -1.10000903e-02f, -7.69351721e-02f,
  -1.21269532e-01f, -2.54654121e-02f, 2.08270162e-01f, 2.26537772e-02f, 7.00412840e-02f, -3.31630856e-02f, 6.15958907e-02f, 2.50073880e-01f, 1.33366987e-01f, -1.53554112e-01f,
  -4.44543473e-02f, 4.20302385e-03f, 4.11076024e-02f, -5.33849280e-03f, 1.45859569e-01f, 1.46788001e-01f, 6.79859743e-02f, -8.43079314e-02f, -1.01409145e-01f, 5.53044118e-03f,
  -6.08930923e-03f, -9.38298739e-03f, -2.06517633e-02f, -7.21620917e-02f, -1.42530009e-01f, -8.59471597e-03f, -3.76811586e-02f, -1.73675776e-01f, 1.13206454e-01f, -1.78408413e-03f,
  -1.03218108e-01f, -1.92347139e-01f, 1.34856060e-01f, 1.52931109e-01f, -3.74837928e-02f, -1.55895099e-01f, -4.10648100e-02f, 1.27503380e-01f, 1.05497040e-01f, 4.78983968e-02f,
  -4.14869934e-02f, -1.17228813e-01f, 8.14799499e-03f, 5.82495667e-02f, -4.78256308e-02f, 2.38859698e-01f, -7.11284056e-02f, -1.30984724e-01f, 7.09066913e-02f, 1.27851386e-02f,
  1.09742046e-03f, 5.53237982e-02f, -5.39233163e-02f, 1.34409517e-01f, -8.36636201e-02f, 2.84540169e-02f, -1.24020822e-01f, 1.12270460e-01f, 1.93853885e-01f, -4.18735035e-02f,
  -7.37945810e-02f, -2.74089798e-02f, -1.00228243e-01f, -2.59578209e-02f, 1.19778164e-01f, -4.72890399e-02f, -5.31763844e-02f, 2.56631039e-02f, -7.08075017e-02f, 5.60639389e-02f,
  -1.26922473e-01f, 3.35223377e-02f, -1.04343347e-01f, 1.12950414e-01f, 2.28486642e-01f, -1.10626012e-01f, -6.79276437e-02f, 4.94209267e-02f, -6.19045645e-02f, 6.08352758e-02f,
  2.92456914e-02f, -2.28743348e-02f, -8.71802941e-02f, 8.98110308e-03f, 1.54115269e-02f, -4.13114671e-03f, 1.55116081e-01f, -9.59854797e-02f, 1.59106210e-01f, -7.33108819e-02f,
  9.37726125e-02f, 1.10444531e-01f, -1.41657010e-01f, 1.20542511e-01f, 1.20547444e-01f, 3.11390549e-01f, -4.64015454e-02f, -1.38220545e-02f, 7.14407414e-02f, 2.96729296e-01f,
  -4.51100990e-02f, 6.66891709e-02f, 7.61087164e-02f, 2.74421852e-02f, -1.09450668e-01f, -1.81380846e-02f, 1.32731572e-01f, -6.88922256e-02f, -1.82431154e-02f, 2.46081203e-02f,
  1.30535349e-01f, 1.01260096e-01f, 2.00927630e-01f, -6.67228252e-02f, 1.14156164e-01f, -1.72666520e-01f, -1.70349702e-01f, -4.34727035e-02f, 1.45086870e-01f, 1.47586033e-01f,
  2.46389173e-02f, 2.01970771e-01f, -9.63377282e-02f, 2.54588604e-01f, -1.20881021e-01f, 2.57448703e-02f, 3.32880080e-01f, 1.06009357e-02f, 5.56500219e-02f, 1.61093086e-01f,
  -1.89301297e-01f, 4.26525958e-02f, -8.01079571e-02f, -1.14955179e-01f, 1.19727619e-01f, 1.12045988e-01f, 6.38653263e-02f, 1.41456187e-01f, -1.01872139e-01f, 1.41449207e-02f,
  -1.12674713e-01f, -2.56909747e-02f, 1.79676145e-01f, -1.30316960e-02f, -1.67657793e-01f, -3.58790299e-03f, -6.20635487e-02f, -6.57823682e-02f, 1.80972800e-01f, 1.13089971e-01f,
  1.80348337e-01f, 1.26149729e-01f, 1.17371179e-01f, 7.58540779e-02f, -2.08420325e-02f, 4.86302823e-02f, 1.63642719e-01f, -7.89085478e-02f, -1.26072899e-01f, -1.18118003e-01f,
  5.82847707e-02f, 8.28254502e-03f, 6.25363141e-02f, 1.12237474e-02f, 9.18864682e-02f, 4.88341302e-02f, -3.85568887e-02f, 1.14543915e-01f, 1.37676239e-01f, 2.03377232e-01f,
  -1.35846809e-01f, 5.31246476e-02f, 7.19076535e-03f, 7.83888903e-03f, 1.88941043e-02f, 9.01134871e-03f, -1.27107322e-01f, 2.13351957e-02f, 9.39920023e-02f, 1.30980507e-01f,
  4.18735594e-02f, 2.77003258e-01f, -1.70917250e-02f, -9.46775898e-02f, -5.85182048e-02f, -2.38414332e-02f, 6.99784830e-02f, -9.33107212e-02f, 7.38433152e-02f, -5.97682260e-02f,
  -1.35208249e-01f, 1.26389742e-01f, 4.39810567e-03f, -1.39440462e-01f, 2.32692510e-01f, 5.20213395e-02f, 7.58843869e-02f, 2.26397529e-01f, 1.07701030e-02f, 1.25129029e-01f,
  -6.58222586e-02f, -1.52879499e-03f, 7.76993558e-02f, -3.82953025e-02f, 2.05584630e-01f, 4.20319699e-02f, 4.86369282e-02f, 1.23633936e-01f, 2.21491158e-01f, 2.04485804e-02f,
  7.01875687e-02f, -7.71787111e-03f, 1.63965359e-01f, 9.47666615e-02f, -1.45314552e-03f, 9.56401154e-02f, 5.43441577e-03f, -3.03571038e-02f, -3.80585641e-02f, 1.11271627e-01f,
  2.19350561e-01f, 1.60616532e-01f, 4.52076793e-02f, 1.48817495e-01f, -1.56604841e-01f, -1.39295198e-02f, 1.44571155e-01f, -9.23540890e-02f, 7.79376999e-02f, -1.28753521e-02f,
  -1.38062149e-01f, -1.50138006e-01f, -5.92209660e-02f, 8.50090235e-02f, -1.30900577e-01f, 2.24010974e-01f, -1.37330696e-01f, -1.42840236e-01f, -4.99390103e-02f, -2.45777681e-03f,
  2.28369161e-01f, 1.11248441e-01f, -1.30418524e-01f, -2.91067868e-01f, 1.07897885e-01f, 1.01449862e-01f, 9.71828476e-02f, 3.20322998e-02f, -1.22383922e-01f, 6.16761521e-02f,
  9.33568329e-02f, 1.21430203e-01f, 2.29317293e-01f, 1.94198340e-01f, 1.69935403e-03f, 9.61087942e-02f, 7.64562264e-02f, 1.42201453e-01f, 4.28558625e-02f, 1.94456592e-01f,
  -1.53334603e-01f, -2.76525337e-02f, -1.95420489e-01f, 2.16163490e-02f, 9.74211842e-03f, -8.28742012e-02f, 1.15762211e-01f, 5.97676747e-02f, -2.09301770e-01f, 1.37985162e-02f,
  -1.50232941e-01f, -1.67213693e-01f, -4.44394238e-02f, 3.16527128e-01f, -4.77536954e-02f, 3.53475064e-02f, 2.12323871e-02f, -5.64937806e-03f, 6.15659244e-02f, 9.40297395e-02f,
  1.23910435e-01f, 1.43704265e-01f, 1.05504006e-01f, -4.17172834e-02f, 2.32082993e-01f, 6.51777461e-02f, 5.31769805e-02f, -1.17585324e-01f, 3.34824584e-02f, 6.44006282e-02f,
  -7.26670772e-02f, -1.88667595e-01f, -5.06350398e-02f, -7.40310624e-02f, 5.20581454e-02f, -3.20738591e-02f, -1.80247799e-02f, -4.91007641e-02f, -5.05873375e-02f, 7.10022524e-02f,
  5.72091900e-02f, 5.33584319e-02f, -1.46469548e-01f, -1.28313854e-01f, -2.90395245e-02f, -3.33500318e-02f, 7.18307421e-02f, -9.62460935e-02f, -2.05194317e-02f, 1.58689246e-01f,
  5.80849173e-03f, -6.77113608e-02f, -1.01736844e-01f, 2.74076283e-01f, 1.63400263e-01f, 1.08430468e-01f, -8.23860243e-02f, 1.55601859e-01f, -1.46491751e-01f, 1.16862148e-01f,
  2.01688223e-02f, 8.13510716e-02f, -2.27474570e-02f, 1.96460754e-01f, -7.96520486e-02f, -1.60339884e-02f, -4.38523619e-03f, -9.04180184e-02f, -1.15361534e-01f, 8.70625526e-02f,
  2.12087497e-01f, -1.58552662e-01f, -8.30767676e-02f, -5.50783100e-03f, 7.90788308e-02f, -6.04828075e-02f, -9.18288454e-02f, 2.26066977e-01f, 1.01752579e-01f, 9.14797559e-02f,
  3.93743366e-02f, 7.68112168e-02f, 3.73270772e-02f, 2.83897147e-02f, 3.24437506e-02f, 3.65935639e-02f, 2.33839639e-02f, 1.05876379e-01f, 1.44319832e-01f, 5.87505959e-02f,
  -6.56590462e-02f, -8.29437864e-04f, 6.00454062e-02f, -2.62114964e-02f, 1.29934311e-01f, -3.56604122e-02f, -1.33047193e-01f, 1.24288186e-01f, -6.85537467e-03f, 9.44474041e-02f,
  1.48383200e-01f, 1.00678630e-01f, -1.56678513e-01f, -2.80863661e-02f, -8.12508389e-02f, 1.11114927e-01f, 7.40595162e-02f, 1.82272971e-01f, 1.83794424e-02f, -2.82299034e-02f,
  -1.28242046e-01f, 3.18508968e-02f, 8.47033113e-02f, 2.41423607e-01f, -1.94761176e-02f, -1.44044161e-01f, 5.77147603e-02f, 4.20913808e-02f, 9.65991393e-02f, 3.74423563e-02f,
  -1.50897473e-01f, -8.33489597e-02f, -1.52550742e-01f, 1.02696136e-01f, 2.83121206e-02f, -8.08857530e-02f, 9.82764065e-02f, -9.18254629e-02f, 9.29649174e-02f, 1.78916499e-01f,
  -2.05841307e-02f, 2.07101345e-01f, -3.87651138e-02f, -3.06902099e-02f, -3.30956988e-02f, 3.88424061e-02f, 1.39099509e-01f, -3.03186458e-02f, 6.64512366e-02f, 1.82588294e-01f,
  1.76701114e-01f, -7.29418024e-02f, 6.69363234e-03f, -1.35549689e-02f, 9.71389115e-02f, 4.16095071e-02f, 7.48341009e-02f, 1.54727489e-01f, 9.11568627e-02f, -9.21813324e-02f,
  -1.62982166e-01f, 1.53774559e-01f, 1.61743671e-01f, 5.26634939e-02f, -8.94885212e-02f, 1.02168761e-01f, -1.30780518e-01f, -1.47642821e-01f, 1.00484326e-01f, 5.95535189e-02f,
  -2.61124689e-02f, -2.33781245e-02f, -9.66394097e-02f, 2.32458767e-03f, 9.58329886e-02f, 8.23833942e-02f, -1.15581520e-03f, -7.48399198e-02f, -5.00249006e-02f, 2.91143451e-02f,
  1.68819815e-01f, 1.97038457e-01f, -8.44827071e-02f, -8.60276297e-02f, -1.12839170e-01f, 1.53667625e-05f, 3.20783444e-02f, 2.03900158e-01f, 3.15427333e-02f, -1.16338827e-01f,
  -3.02884188e-02f, 6.96203932e-02f, 2.43754406e-02f, -2.48561576e-02f, -4.34945524e-02f, -5.33278286e-02f, -1.45456269e-01f, -8.36596545e-03f, -1.53670505e-01f, -3.16615850e-02f,
  1.67771697e-01f, -2.28330698e-02f, 5.91331832e-02f, -7.73013290e-03f, -1.93594191e-02f, 2.07561687e-01f, -8.75816113e-05f, 4.47572581e-02f, -9.80779231e-02f, 8.22769552e-02f,
  2.98157264e-03f, -7.02873245e-02f, 1.14267543e-01f, 1.22758634e-01f, 1.63472727e-01f, 4.46492285e-02f, 3.72231826e-02f, 6.86013252e-02f, -9.65675041e-02f, 1.24494862e-02f,
  -1.21774837e-01f, 6.63303658e-02f, 3.29025201e-02f, 3.86037491e-02f, -8.06833878e-02f, -1.47586048e-01f, -1.00952327e-01f, 1.18371859e-01f, 2.23393482e-03f, -3.99008282e-02f,
  -1.01690643e-01f, 6.50650635e-02f, -1.73981078e-02f, -3.67020182e-02f, 3.23421299e-01f, -8.51508137e-03f, 7.25263134e-02f, -1.43788308e-01f, -7.23124519e-02f, 8.85222182e-02f,
  -5.97491637e-02f, -4.11124900e-02f, -1.69825137e-01f, -2.08370276e-02f, -3.24357748e-02f, 2.89332308e-02f, 7.21920356e-02f, 1.38289481e-01f, -7.99940974e-02f, 8.08789581e-02f,
  9.57807228e-02f, -1.95224851e-01f, -9.20270011e-03f, 6.19072579e-02f, -3.28030773e-02f, -1.01808794e-01f, -1.32743381e-02f, -1.59642577e-01f, 3.76834184e-01f, -7.15272948e-02f,
  3.42526287e-02f, -1.52967289e-01f, 3.51393037e-02f, -8.87366571e-03f, -5.17553501e-02f, -7.91978166e-02f, -1.54762743e-02f, 3.41155306e-02f, 1.26707673e-01f, -1.29265472e-01f,
  -1.02198750e-01f, -9.90316495e-02f, -6.80275261e-03f, -4.67364937e-02f, -4.30038944e-03f, 2.80319024e-02f, -6.51175082e-02f, -1.39945569e-02f, 1.16325080e-01f, 1.53277814e-01f,
  1.96680985e-02f, 1.35338083e-01f, 1.49936959e-01f, 8.95739943e-02f, 1.10682800e-01f, -8.97603482e-03f, 4.05138656e-02f, -3.72537449e-02f, -3.36057656e-02f, 2.99924091e-02f,
  7.55174160e-02f, -2.57683615e-03f, -8.40890110e-02f, 4.51915972e-02f, 1.68153495e-01f, -1.69084087e-01f, -3.42781767e-02f, 1.48496836e-01f, -1.00539237e-01f, -6.52293339e-02f,
  -7.70120844e-02f, 1.85038924e-01f, 4.20858450e-02f, 7.92739019e-02f, 9.17892978e-02f, 7.35812932e-02f, 1.41086444e-01f, -8.11091810e-02f, 5.79481050e-02f, -7.76533112e-02f,
  -9.10513755e-03f, -2.56639943e-02f, -4.07367870e-02f, -1.52238414e-01f, 6.72117323e-02f, 2.56972790e-01f, 1.05197512e-01f, 1.14665076e-01f, -1.39298156e-01f, 9.58310291e-02f,
  -7.29267672e-03f, 1.34392247e-01f, -8.42280462e-02f, 7.19353259e-02f, 1.24466561e-01f, -1.53335184e-03f, -3.09603270e-02f, 1.12017401e-01f, 9.14603621e-02f, 1.02363080e-01f,
  -1.10438727e-01f, -1.53652608e-01f, -9.25941989e-02f, 1.39198050e-01f, 8.44820738e-02f, -8.22109208e-02f, -4.35945615e-02f, 1.43370122e-01f, -7.22170472e-02f, 3.05155683e-02f,
  5.45208827e-02f, -3.30383219e-02f, -1.53280094e-01f, -9.64849722e-03f, -5.88090606e-02f, -2.08710935e-02f, 5.79055920e-02f, -1.07134851e-02f, 5.80442548e-02f, 8.35177079e-02f,
  1.15641929e-01f, 1.89794406e-01f, 2.00731516e-01f, -8.69212747e-02f, -1.72389716e-01f, -9.07533243e-02f, 2.92233005e-02f, 6.79237396e-03f, -6.03797734e-02f, -3.32394801e-02f,
  4.37480025e-03f, 1.36046082e-01f, 2.38080308e-01f, 9.04553086e-02f, -6.90553337e-02f, -2.72191092e-02f, -9.31644812e-03f, 4.58159745e-02f, 1.20677143e-01f, -1.94151308e-02f,
  -1.84493549e-02f, -7.53735974e-02f, -9.02558044e-02f, 1.21109128e-01f, 3.65509018e-02f, 1.05276711e-01f, -1.39661571e-02f, 4.14980501e-02f, 6.32147342e-02f, -1.99013114e-01f,
  -2.70149969e-02f, 5.70156612e-02f, 5.34660295e-02f, -6.37013093e-02f, -1.13345295e-01f, -2.08662134e-02f, 2.24284500e-01f, -7.39604561e-03f, 1.20204978e-01f, -1.55507540e-02f,
  1.87058643e-01f, 5.44831455e-02f, 2.25262623e-02f, 3.66897173e-02f, 1.02013521e-01f, 9.24919695e-02f, -2.92780320e-03f, -1.21401772e-01f, 1.32587224e-01f, 1.03456348e-01f,
  -9.12796631e-02f, 1.39197081e-01f, 9.19961557e-02f, 8.87088925e-02f, 1.28099903e-01f, -1.37441931e-02f, -2.24204734e-02f, -2.56303940e-02f, 1.57231435e-01f, 1.73383486e-03f,
  3.96895036e-02f, 2.31356435e-02f, 3.18667628e-02f, 1.43290162e-01f, 1.22001462e-01f, 2.11575121e-01f, -2.39697993e-01f, 1.20639972e-01f, -6.86294660e-02f, -5.77878542e-02f,
  -1.12139635e-01f, -1.77991733e-01f, 1.27787873e-01f, -7.43115619e-02f, -6.13001250e-02f, -1.27796888e-01f, -7.49039054e-02f, -1.18149407e-01f, 7.14752078e-03f, -6.61213920e-02f,
  4.15400378e-02f, -1.32617667e-01f, -1.03199035e-01f, 4.89254557e-02f, -1.66338637e-01f, -4.87356447e-03f, -5.81077486e-02f, 3.34122963e-02f, -1.06624169e-02f, -2.39753798e-02f,
  1.32895797e-01f, -1.55876458e-01f, 1.72666237e-02f, -8.32279027e-02f, 3.91916186e-02f, 2.71109700e-01f, -1.48767801e-02f, -5.14576286e-02f, -4.61269319e-02f, -5.03202938e-02f,
  -1.12181336e-01f, 1.65062696e-01f, 2.56168336e-01f, -1.26192182e-01f, -8.76603276e-02f, -1.90079314e-04f, 1.61470607e-01f, 1.19170032e-01f, 1.17063865e-01f, -1.09248757e-02f,
  -2.18924489e-02f, -1.77532826e-02f, -7.35298451e-03f, -7.73487240e-02f, 6.48946781e-03f, 3.56782861e-02f, -1.08289555e-01f, 4.09507789e-02f, 2.16522962e-01f, -3.67993489e-03f,
  2.14363690e-02f, 7.77000040e-02f, -6.69375509e-02f, -4.02988940e-02f, 5.68657853e-02f, -2.15217154e-02f, -1.00476341e-02f, -2.10900605e-02f, -3.97848859e-02f, 5.72341159e-02f,
  -1.37447506e-01f, -1.69852406e-01f, -1.05033806e-02f, -2.20940068e-01f, 1.53073873e-02f, -6.43888712e-02f, 9.67111140e-02f, -6.62264228e-02f, -9.07798558e-02f, -1.40973613e-01f,
  -2.49074608e-01f, 1.47930533e-01f, -8.29009041e-02f, -3.81861813e-03f, 1.86446980e-02f, -1.53079093e-01f, 1.47626117e-01f, 7.29148388e-02f, 7.58466050e-02f, 7.45423958e-02f,
  -7.49366358e-02f, -7.19937533e-02f, 2.90259905e-02f, 5.72666191e-02f, 9.32992995e-02f, 1.43543214e-01f, 2.16648072e-01f, -7.71176443e-02f, 4.22320031e-02f, 1.46294475e-01f,
  3.73857878e-02f, -1.41838625e-01f, 1.17708117e-01f, -9.81846154e-02f, 3.52805406e-02f, 1.29105081e-03f, 3.11597381e-02f, -2.53737275e-03f, 4.58461680e-02f, -3.92646249e-03f,
  -7.55156726e-02f, 3.92030068e-02f, 6.70163557e-02f, -4.46095644e-03f, -4.48855571e-02f, 2.88613215e-02f, 9.08022374e-02f, -7.90807977e-02f, 6.24410734e-02f, 1.02423586e-01f,
  -4.43856465e-03f, 9.45464298e-02f, -1.17647849e-01f, -1.82330102e-01f, -1.26100868e-01f, -1.82962753e-02f, 7.25229308e-02f, -1.09493211e-02f, 1.17913000e-01f, 2.01478988e-01f,
  -1.72054283e-02f, 8.03870335e-02f, -1.89928822e-02f, 3.65729001e-03f, -6.28026947e-02f, 1.51109636e-01f, 3.70542258e-02f, 1.00101680e-01f, -1.54138863e-01f, 1.03748277e-01f,
  -8.54587182e-02f, -1.24699205e-01f, 1.78378090e-01f, 2.72741355e-02f, 4.79541607e-02f, -6.45533809e-03f, -7.49762803e-02f, 1.01083331e-01f, 7.98424929e-02f, 1.64236113e-01f,
  -1.20695598e-01f, -3.76453139e-02f, 2.94518080e-02f, -9.78173837e-02f, 1.37212947e-01f, 3.77731025e-02f, -5.45920059e-02f, -5.03934398e-02f, -1.83226138e-01f, 7.88346119e-03f,
  -4.86043803e-02f, 2.55449474e-01f, -6.00281134e-02f, -1.17591619e-01f, -6.70423582e-02f, -3.19950618e-02f, 5.18907756e-02f, 2.13049073e-03f, 7.91546106e-02f, -1.62194684e-01f,
  -1.06278293e-01f, 1.48567215e-01f, -3.92033868e-02f, -1.33005055e-02f, 1.90666363e-01f, 4.56640264e-03f, -5.64276800e-02f, 1.30110115e-01f, 2.70787776e-02f, 1.78760946e-01f,
  1.44839033e-01f, -2.39583105e-02f, -1.14192165e-01f, -1.49433799e-02f, 5.55529334e-02f, 1.84823312e-02f, 4.08425665e-04f, 1.57231331e-01f, 9.45885181e-02f, -6.00106046e-02f,
  -7.49110058e-02f, 1.41882792e-01f, -9.72943604e-02f, -1.45711988e-01f, -2.06036270e-02f, -1.14996299e-01f, -8.61587301e-02f, -2.57130526e-02f, 3.52785923e-02f, -1.30261108e-01f,
  -7.44536817e-02f, -1.30306780e-01f, -3.90227661e-02f, 3.66149172e-02f, 6.11063465e-02f, 1.36092559e-01f, -4.90901396e-02f, -1.08120196e-01f, -8.93466920e-02f, 6.85183629e-02f,
  4.29886766e-02f, 6.12177290e-02f, -4.63216081e-02f, -2.44480725e-02f, 1.81258455e-01f, -4.48009595e-02f, 4.51914743e-02f, 1.05994247e-01f, -4.85318489e-02f, -1.00673817e-01f,
  9.20494199e-02f, 1.10325374e-01f, 1.77669704e-01f, 8.24122056e-02f, 6.16456680e-02f, 6.12112228e-04f, 5.02822921e-02f, 2.63305288e-02f, 7.67403170e-02f, 5.29890880e-02f,
  9.91281867e-02f, -5.07076755e-02f, -5.92134520e-03f, -1.22915857e-01f, -4.19824123e-02f, 4.12964374e-02f, 9.62178130e-03f, -5.16091213e-02f, -1.41021475e-01f, 5.52348513e-03f,
  -2.29101675e-03f, 1.45171927e-02f, -5.21076992e-02f, 2.25621276e-02f, 2.64785043e-03f, 5.23281470e-02f, 8.02989006e-02f, 5.25619835e-02f, 8.30841959e-02f, 8.83884951e-02f,
  -5.36994934e-02f, -1.95969548e-02f, -7.50899017e-02f, -9.19947997e-02f, 9.51384380e-02f, 1.21252954e-01f, -3.46121332e-03f, 1.37813359e-01f, 1.84888780e-01f, -2.14112513e-02f,
  1.24113247e-01f, 5.27496822e-02f, 2.75448442e-01f, 3.23940255e-02f, -2.55161412e-02f, 1.93596527e-01f, 2.25905716e-01f, 2.60037690e-01f, -1.37454703e-01f, -3.65049504e-02f,
  5.83831780e-02f, 3.11312050e-01f, 2.84485286e-03f, 4.97455522e-02f, 4.57873270e-02f, 1.00588113e-01f, 6.48146123e-02f, 5.03544174e-02f, 1.51512157e-02f, -1.68674484e-01f,
  -5.92689253e-02f, 1.89786837e-01f, 1.03702724e-01f, 2.26187021e-01f, -1.05763569e-01f, -6.46990612e-02f, -6.88095391e-02f, 2.42866546e-01f, -5.94729511e-03f, -2.11465374e-01f,
  1.47052091e-02f, -1.64308012e-01f, 1.18764967e-01f, 5.92421442e-02f, -4.80324104e-02f, 1.63433701e-01f, -8.80363137e-02f, -1.81160465e-01f, -3.05007175e-02f, 5.76965846e-02f,
  6.49200231e-02f, -7.03970343e-02f, 5.42181637e-03f, -1.87097073e-01f, 1.70381829e-01f, 2.31429368e-01f, 1.83226123e-01f, -1.28168851e-01f, 1.22417718e-01f, 1.41992077e-01f,
  -1.07782230e-01f, 8.32495838e-02f, 6.63498566e-02f, -1.45702418e-02f, 1.69922486e-01f, -3.28314416e-02f, -6.09542243e-02f, -1.53043389e-01f, -6.61331639e-02f, 1.76946409e-02f,
  1.44372478e-01f, 2.07268745e-02f, 1.17266819e-01f, 7.04751909e-02f, 7.33478963e-02f, 1.27013728e-01f, 8.86355620e-03f, 4.00090776e-02f, -1.84128881e-01f, 4.29697558e-02f,
  9.93516520e-02f, 5.93061522e-02f, 6.89584240e-02f, -1.44501016e-01f, 1.63134467e-02f, 1.65933862e-01f, -8.87810364e-02f, 7.58558288e-02f, -6.57872185e-02f, 1.48571745e-01f,
  7.62050450e-02f, -9.75394100e-02f, 1.76975764e-02f, -1.87114760e-01f, -2.61743236e-02f, 1.16014183e-01f, 1.67560965e-01f, 2.75142372e-01f, -5.19183427e-02f, -2.82987114e-02f,
  3.04344203e-02f, 1.33297443e-01f, 2.76486054e-02f, -6.52548149e-02f, -4.31558955e-03f, 2.91399583e-02f, 1.50147036e-01f, 1.90548748e-02f, -1.26703918e-01f, 1.31286338e-01f,
  -1.56373203e-01f, -6.79626912e-02f, -7.48778088e-03f, -9.68953148e-02f, 3.52728367e-03f, 1.44220188e-01f, -2.22300570e-02f, -1.47710159e-01f, 1.76755950e-01f, 2.01709904e-02f,
  1.54018089e-01f, 1.65746272e-01f, 1.21803656e-01f, 1.23721167e-01f, -1.15945846e-01f, -1.42071350e-02f, -3.21082287e-02f, 3.23621370e-03f, 3.30505744e-02f, 9.53111053e-02f,
  -1.04025006e-03f, -2.36013800e-01f, 7.51972124e-02f, -7.75919408e-02f, -5.28161786e-02f, -9.76286712e-04f, 1.24018304e-01f, -5.76329716e-02f, 5.99949211e-02f, 1.02626398e-01f,
  3.35148335e-01f, 2.89398860e-02f, -1.40099093e-01f, 1.46628544e-01f, 1.68665990e-01f, 2.67379463e-01f, 6.02104608e-03f, 1.13294058e-01f, 7.17440760e-03f, 2.36611098e-01f,
  -7.44613260e-02f, 8.10705349e-02f, 4.19239067e-02f, 9.19414908e-02f, -1.17010787e-01f, 6.73522949e-02f, 1.92406191e-03f, -1.76356211e-02f, 7.89270625e-02f, 8.02412778e-02f,
  1.47901639e-01f, 4.47224639e-02f, 5.12165502e-02f, -7.26919174e-02f, 1.16421245e-01f, 2.93466467e-02f, -8.74919742e-02f, -1.85851008e-01f, 9.76794437e-02f, 4.81047668e-03f,
  1.34608403e-01f, 1.41034603e-01f, -1.29371807e-01f, 2.80248672e-01f, -1.08206317e-01f, 7.41637722e-02f, 1.66407183e-01f, 3.44062224e-02f, 7.33788908e-02f, 5.20384386e-02f,
  -1.53375968e-01f, 1.39114270e-02f, 1.43801817e-03f, 5.73583208e-02f, -1.68673415e-02f, -2.89947819e-02f, 3.19740810e-02f, 6.93351403e-02f, -6.84317946e-02f, 3.49470489e-02f,
  -6.71440363e-02f, 5.37727624e-02f, 1.51248828e-01f, 2.90882830e-02f, -2.03956544e-01f, -9.14601386e-02f, 6.13525398e-02f, -4.97185178e-02f, 2.50615124e-02f, -2.75218114e-02f,
  -1.01916455e-01f, 3.79534923e-02f, -4.04255167e-02f, 6.82802722e-02f, -5.54770865e-02f, -1.85982794e-01f, 1.26464859e-01f, -1.40518054e-01f, -6.75977999e-03f, -2.06185162e-01f,
  6.60584718e-02f, 5.21072559e-02f, -2.18006819e-02f, -1.64507791e-01f, -1.22230642e-01f, 1.59142300e-01f, -6.39291853e-02f, 2.21323371e-02f, -3.01985610e-02f, -5.55583127e-02f,
  1.02688849e-01f, -1.94749795e-02f, 2.13554263e-01f, 2.31770240e-02f, -1.77959844e-01f, -1.10092789e-01f, -2.94128675e-02f, 1.51169538e-01f, -1.41080217e-02f, 1.36291847e-01f,
  1.76606655e-01f, 4.08435352e-02f, 3.07531711e-02f, -6.82909936e-02f, -3.92346866e-02f, -3.76554057e-02f, 9.47893336e-02f, -4.22313064e-02f, 1.28949225e-01f, -2.88184173e-02f,
  -1.69839129e-01f, 8.71818587e-02f, 8.03945065e-02f, 8.73212591e-02f, -8.76225904e-02f, 4.44442444e-02f, 1.03603475e-01f, -1.22294232e-01f, -1.03337973e-01f, 1.42293066e-01f,
  1.43809080e-01f, -1.88902780e-01f, 9.23245400e-02f, -1.10680761e-03f, 1.97335884e-01f, 1.37961373e-01f, -1.97292179e-01f, -1.92946553e-01f, -5.03127947e-02f, -9.32902992e-02f,
  1.83956012e-01f, 3.75689492e-02f, -7.67596960e-02f, -5.72860874e-02f, 7.98075125e-02f, -1.37519285e-01f, -8.74728933e-02f, 1.02328081e-02f, 1.20775566e-01f, -6.18194137e-03f,
  -1.67356327e-01f, -1.55601986e-02f, 1.51957661e-01f, 1.05321161e-01f, 8.01267326e-02f, -1.70946851e-01f, -1.06962752e-02f, 1.06301561e-01f, -4.65449058e-02f, 1.52031541e-01f,
  -8.97664726e-02f, 3.94650027e-02f, -3.98721825e-03f, -5.84635548e-02f, 1.69624642e-01f, 2.08509974e-02f, 7.40944520e-02f, -1.12964146e-01f, 1.61254667e-02f, -3.81997675e-02f,
  1.66154783e-02f, 1.61284238e-01f, -4.83834855e-02f, 4.29655500e-02f, 4.20044325e-02f, -2.04137981e-01f, 1.19938023e-01f, 1.48472607e-01f, 4.34097126e-02f, -5.96550256e-02f,
  -4.73391674e-02f, 8.76435861e-02f, 9.51527506e-02f, 3.04182228e-02f, 1.12110727e-01f, -1.09663181e-01f, 3.82689275e-02f, 1.70674726e-01f, -1.17120065e-01f, -5.07589467e-02f,
  2.92836390e-02f, -2.19847515e-01f, 3.67319509e-02f, 6.83733821e-02f, 1.15754105e-01f, -2.45370269e-02f, -9.99411494e-02f, 2.02314287e-01f, 1.38955088e-02f, 2.00670362e-01f,
  -1.38696786e-02f, -9.09654275e-02f, -1.71648100e-01f, 3.55452448e-02f, 1.36535510e-01f, -1.30227759e-01f, 4.50659469e-02f, 1.62054747e-02f, -4.22678888e-02f, -4.91028428e-02f,
  -1.38048589e-01f, 2.00249832e-02f, 3.10002416e-02f, -1.03700489e-01f, -6.77241758e-02f, -1.12319879e-01f, 1.18760705e-01f, 3.90535593e-02f, 3.17301489e-02f, 4.91536632e-02f,
  -5.24535170e-03f, 1.37781620e-01f, -6.72736987e-02f, 1.97553590e-01f, -2.90040094e-02f, 4.44653183e-02f, -7.75197968e-02f, -1.00964762e-01f, 9.94661152e-02f, 5.10181449e-02f,
  1.58140033e-01f, -7.04288185e-02f, -4.03796555e-03f, 4.92651053e-02f, 8.76784101e-02f, 5.60915694e-02f, -2.56870943e-03f, 1.67559888e-02f, 1.62835389e-01f, -3.84506807e-02f,
  6.94778338e-02f, -5.52293137e-02f, -3.61609384e-02f, 1.90012068e-01f, -1.39106177e-02f, 1.73975721e-01f, -9.73646250e-03f, 6.61142990e-02f, 2.23203506e-02f, 4.82940264e-02f,
  1.04150943e-01f, 1.77403644e-01f, -1.66390583e-01f, 2.54650544e-02f, 8.39364249e-03f, -1.63660735e-01f, 2.48828847e-02f, 8.89830217e-02f, 1.03376888e-01f, 3.25051248e-02f,
  1.68762445e-01f, 1.18400000e-01f, -3.48994955e-02f, 1.02433525e-01f, -1.45040751e-01f, -2.21236169e-01f, -1.14101812e-01f, 1.00856870e-01f, 1.28023952e-01f, 6.86934143e-02f,
  8.67373049e-02f, 9.63890329e-02f, 1.19098410e-01f, 1.28386058e-02f, 9.44920555e-02f, 8.92679989e-02f, -9.82914865e-02f, 1.06682152e-01f, 2.57973522e-01f, -4.89858910e-02f,
  -8.68681353e-03f, -4.72400757e-03f, -3.66663747e-02f, -5.06999418e-02f, 8.60219598e-02f, 1.90011915e-02f, 3.48962983e-03f, -4.14636359e-02f, 8.25212672e-02f, 2.90432442e-02f,
  5.93776330e-02f, 1.11787409e-01f, -3.25983949e-02f, -2.31806915e-02f, -4.19302769e-02f, 1.37014031e-01f, 8.63749757e-02f, 1.26528695e-01f, -5.44193909e-02f, -6.99119270e-02f,
  -8.77694935e-02f, 1.41860187e-01f, 4.14746404e-02f, 2.57956624e-01f, -3.87705639e-02f, -1.05478399e-01f, 2.97341309e-02f, -3.03032878e-03f, 1.57458097e-01f, 1.06896900e-01f,
  -1.81664214e-01f, -2.04266179e-02f, -1.08797796e-01f, 9.43047404e-02f, -7.31611624e-02f, -1.97825879e-02f, 1.65156662e-01f, -8.40827823e-03f, -1.77204479e-02f, 2.09996507e-01f,
  9.80856270e-02f, 1.14651933e-01f, -4.89372350e-02f, 2.71651521e-02f, 8.74819830e-02f, -1.92578435e-02f, 1.33729592e-01f, -9.00463462e-02f, -6.86019138e-02f, 1.25521407e-01f,
  4.54126708e-02f, -1.62274495e-03f, 2.56363750e-02f, 7.87256006e-03f, 8.59945714e-02f, 9.36495438e-02f, 1.94057852e-01f, -9.05899704e-02f, 1.34858906e-01f, -4.49500866e-02f,
  4.76966649e-02f, -3.34594361e-02f, -9.98160169e-02f, 3.57331224e-02f, 9.85273346e-02f, 2.52623558e-01f, 9.41205770e-02f, -1.30229726e-01f, -3.13476026e-02f, 2.74723291e-01f,
  -1.29228666e-01f, 1.33481473e-01f, -9.21231955e-02f, 1.40637890e-01f, -1.54159935e-02f, -1.75115606e-03f, 1.79508060e-01f, -7.42201284e-02f, 1.55124977e-01f, -4.34210943e-03f,
  1.57096475e-01f, 1.90964080e-02f, 1.62110791e-01f, 3.36393602e-02f, 1.12024896e-01f, 9.31343511e-02f, -6.59782439e-02f, -1.90326646e-01f, 9.54608992e-02f, 7.31879622e-02f,
  4.70092520e-02f, 8.46354142e-02f, -3.65826860e-02f, 2.22614303e-01f, -2.48948187e-02f, -4.41598333e-02f, 2.84283668e-01f, -5.46650738e-02f, 1.41867936e-01f, 9.50787291e-02f,
  -1.35136455e-01f, 4.03477065e-02f, -8.20223466e-02f, -1.01067185e-01f, -4.68045063e-02f, 1.94405336e-02f, 1.95051670e-01f, 1.84005558e-01f, -1.45699084e-01f, 1.40305892e-01f,
  -4.29490320e-02f, 5.96653484e-02f, 1.32457361e-01f, 4.23407368e-02f, -2.24199995e-01f, -1.30261794e-01f, 1.30551672e-02f, -6.74023777e-02f, 1.91453353e-01f, 1.18149497e-01f,
  4.74636331e-02f, 2.37341002e-02f, 1.34493694e-01f, -9.03906152e-02f, -1.26392812e-01f, 1.60462871e-01f, 7.41553158e-02f, 7.74514377e-02f, 4.23945393e-03f, -2.78588608e-02f,
  5.51863993e-03f, -1.59785628e-01f, 8.81702155e-02f, -4.35272045e-02f, -1.83053408e-03f, 4.16728668e-02f, -5.98619580e-02f, 1.08165435e-01f, 1.12099990e-01f, 8.37511569e-02f,
  -8.86538252e-02f, 1.76599633e-03f, 4.26675975e-02f, 4.90797088e-02f, 1.29400283e-01f, 1.15667410e-01f, -5.98763786e-02f, -2.99318042e-03f, -1.63541794e-01f, 1.77630428e-02f,
  2.00826991e-02f, 2.63040245e-01f, 3.96158397e-02f, -1.70622930e-01f, 4.17888425e-02f, 2.54508667e-02f, 4.15077396e-02f, -5.22562116e-02f, 5.11720194e-04f, -1.18037179e-01f,
  -1.69942960e-01f, -1.20510608e-02f, -5.09058423e-02f, -5.36721200e-02f, 1.39718547e-01f, 2.77796499e-02f, 8.62027928e-02f, 1.32458508e-01f, 6.26384094e-02f, 8.49081799e-02f,
  4.31146249e-02f, -1.09418325e-01f, -8.31468031e-02f, -1.89551748e-02f, 1.15687912e-02f, -1.00071616e-02f, -2.47388221e-02f, 8.78871456e-02f, 1.66646466e-01f, 3.62249427e-02f,
  -2.82846913e-02f, 1.04963228e-01f, 1.32173941e-01f, 4.37189192e-02f, 1.04348168e-01f, 1.67910308e-01f, 1.75183490e-01f, 1.94510724e-02f, -1.75378993e-02f, 4.19451632e-02f,
  -9.20898933e-03f, -7.33042462e-03f, -1.60484426e-02f, -1.18532017e-01f, -1.20199129e-01f, 5.83014153e-02f, 1.20385185e-01f, -5.73990531e-02f, 2.16358826e-01f, 4.80725942e-03f,
  7.16410875e-02f, 6.22595428e-03f, 4.69454564e-02f, 8.55200067e-02f, -1.94144400e-03f, -7.91671425e-02f, 4.49968874e-03f, 1.65001694e-02f, -9.22880098e-02f, 1.89983085e-01f,
  -8.03258121e-02f, 6.95862854e-03f, 4.97329682e-02f, 2.52892494e-01f, -6.59101689e-03f, -5.26882373e-02f, -1.71134129e-01f, -1.11286424e-01f, 3.58806364e-02f, 3.92274745e-03f,
  1.80246700e-02f, -7.41568208e-02f, 1.78429201e-01f, -7.86797032e-02f, -1.21036261e-01f, 1.24262743e-01f, -6.81823418e-02f, -1.50863230e-01f, 1.45244092e-01f, -1.36462420e-01f,
  1.52822658e-01f, 2.87227690e-01f, 3.89752649e-02f, -1.64780065e-01f, 2.31637377e-02f, -4.19960916e-02f, -3.77384163e-02f, -8.59681144e-02f, 1.46129489e-01f, -9.14824475e-03f,
  1.48118928e-01f, 1.85310483e-01f, 2.34469503e-01f, -8.47330689e-02f, 3.42725627e-02f, 1.31149456e-01f, 1.86751023e-01f, 1.18880108e-01f, -1.96212325e-02f, 1.45752758e-01f,
  1.16006449e-01f, 1.93665892e-01f, 4.16164100e-02f, -8.27849731e-02f, 1.71389922e-01f, 1.04085490e-01f, 3.71564031e-02f, -9.17129777e-03f, -1.67081729e-02f, 2.47048326e-02f,
  1.98861789e-02f, -1.87816232e-01f, 1.07170828e-01f, 1.10894144e-01f, -2.00254265e-02f, -9.38239247e-02f, -5.31855859e-02f, 6.37181625e-02f, -1.29162639e-01f, 1.59528211e-01f,
  -1.28991410e-01f, -4.22027335e-02f, -1.73965335e-01f, -1.28129004e-02f, 5.71971200e-02f, 4.83186655e-02f, -5.22373803e-03f, -1.21489242e-01f, 4.08336222e-02f, 1.25065506e-01f,
  3.79725806e-02f, -2.23577488e-02f, -3.51177379e-02f, 1.68861151e-01f, 1.61104836e-02f, 7.01566562e-02f, 1.99279949e-01f, 2.22713247e-01f, -5.33346012e-02f, 1.50695235e-01f,
  1.27052367e-01f, 9.96361598e-02f, 5.50195910e-02f, 1.28930435e-01f, -3.36178765e-02f, 4.42379229e-02f, -6.49118572e-02f, -1.37535200e-01f, -7.32096955e-02f, -6.86572446e-03f,
  9.06796828e-02f, -2.13447381e-02f, -2.61310395e-02f, -5.08425459e-02f, -3.44264992e-02f, -1.19325705e-01f, 1.08335607e-01f, 1.90279961e-01f, 8.60308204e-03f, 1.23828426e-01f,
  1.02337889e-01f, -1.22226626e-02f, 1.38944797e-02f, 7.78148044e-03f, -6.70647323e-02f, 1.85326219e-01f, -2.77637869e-01f, -3.65165174e-02f, -1.38903648e-01f, -2.58460194e-01f,
  -6.99593946e-02f, -2.75271386e-01f, 2.08284467e-01f, -1.19573856e-02f, -5.25065809e-02f, -2.70657510e-01f, -2.14020327e-01f, 1.43833533e-01f, -6.45264983e-02f, 1.14480881e-02f,
  1.10412456e-01f, -5.37586883e-02f, 1.75010208e-02f, 3.68795870e-03f, 4.11711000e-02f, 2.32885048e-01f, -7.35445693e-02f, 8.49740356e-02f, -1.58869803e-01f, 8.29726532e-02f,
  8.54399279e-02f, 5.96291013e-03f, 1.79606035e-01f, 4.87369718e-03f, 2.84733903e-02f, 1.30763724e-01f, 1.00808591e-01f, -2.16129005e-01f, 1.18054815e-01f, -3.12427044e-01f,
  5.02531528e-02f, -6.04809225e-02f, 7.58240093e-03f, -6.56361729e-02f, 9.78093781e-03f, -1.31154969e-01f, 1.30414709e-01f, -8.02612826e-02f, 1.89019755e-01f, 1.17766395e-01f,
  2.12324578e-02f, 7.11839795e-02f, -4.65076827e-02f, -6.14952147e-02f, 1.31812021e-01f, 9.63983499e-03f, 1.93513349e-01f, 1.75371632e-01f, 6.11179508e-02f, 8.07810947e-02f,
  2.75503367e-01f, -2.07406864e-01f, 4.70942445e-02f, -7.60433972e-02f, 1.17156260e-01f, -2.28627599e-04f, -5.48909269e-02f, -1.79653130e-02f, -1.87905744e-01f, 1.63612841e-03f,
  -1.94664776e-01f, -1.47686273e-01f, 1.98650993e-02f, -6.49545193e-02f, -1.71152696e-01f, -2.04922780e-01f, 1.71222046e-01f, 7.73641393e-02f, 2.44101975e-02f, -1.88733578e-01f,
  -3.14952657e-02f, 1.55420437e-01f, 3.24658677e-02f, 1.75224952e-02f, 5.24602048e-02f, -7.59563670e-02f, 9.74685401e-02f, 9.39360559e-02f, 7.39804879e-02f, 1.41509175e-01f,
  -9.87776890e-02f, -8.95999819e-02f, -7.90027827e-02f, 6.58164397e-02f, 1.09193794e-01f, 8.52578878e-02f, 2.09235158e-02f, 1.81995630e-01f, -1.00622298e-02f, 8.81890580e-02f,
  -8.52890536e-02f, -5.63798696e-02f, 1.38366953e-01f, -1.14363141e-01f, -3.58097516e-02f, -1.18012771e-01f, 6.23240285e-02f, 4.06639576e-02f, 2.83384603e-02f, -5.84140085e-02f,
  -4.90974784e-02f, 8.02382827e-03f, -9.56010148e-02f, 2.42531579e-03f, -1.28710293e-03f, 1.27828777e-01f, 8.65111593e-03f, 1.08158924e-02f, 1.64509445e-01f, -3.33521143e-02f,
  -8.42998549e-03f, 1.25389844e-01f, -1.30500332e-01f, 9.01788995e-02f, -1.78802423e-02f, -6.47291243e-02f, -4.72011082e-02f, -2.41815839e-02f, 5.55800498e-02f, 1.55380871e-02f,
  7.26481229e-02f, 7.71552697e-03f, 1.11216404e-01f, 1.33830577e-01f, 3.79077382e-02f, -9.33221728e-02f, -1.53957427e-01f, -1.06952697e-01f, 1.16454720e-01f, 1.03999518e-01f,
  -5.81123084e-02f, -3.11045628e-02f, -2.92111672e-02f, 1.10197244e-02f, 1.39388815e-01f, 1.22207321e-01f, -3.58620360e-02f, -1.22702613e-01f, 2.23261192e-02f, 7.27898534e-03f,
  1.66026559e-02f, -4.71614711e-02f, -5.21637946e-02f, 5.38980439e-02f, -1.28951490e-01f, 1.44816428e-01f, 3.26754078e-02f, 1.25203609e-01f, 1.16598764e-02f, 1.03182219e-01f,
  1.85571924e-01f, -1.90333411e-01f, 5.26956432e-02f, 3.72529142e-02f, 1.61617056e-01f, -1.53130382e-01f, -9.49677005e-02f, -5.14776297e-02f, 3.20839316e-01f, 3.67537290e-02f,
  1.00655861e-01f, -6.31187335e-02f, 1.00310229e-01f, -4.60180528e-02f, 1.02851354e-01f, -6.19458593e-03f, 2.58674622e-01f, 1.81070089e-01f, -2.96526612e-03f, -1.34769335e-01f,
  6.75501972e-02f, -6.97226450e-02f, -1.19027615e-01f, 1.04269892e-01f, 1.46484822e-01f, 1.48511976e-01f, 3.59187671e-03f, 2.71123070e-02f, 2.21533105e-01f, 1.11534439e-01f,
  1.73027456e-01f, -4.18449901e-02f, 6.33849204e-02f, -5.46825537e-03f, 6.42407406e-03f, -3.97863574e-02f, -8.00839346e-03f, -5.49408793e-02f, 6.30939156e-02f, -4.86689880e-02f,
  4.48951088e-02f, -7.47046620e-02f, -4.37441990e-02f, -1.40320569e-01f, 8.61991048e-02f, 7.68343657e-02f, -7.44528696e-02f, -3.04015838e-02f, -5.21693043e-02f, 2.30937880e-02f,
  1.58981249e-01f, 2.06264276e-02f, -9.71187130e-02f, -7.28741363e-02f, 2.34872848e-02f, 7.47975484e-02f, 6.10957816e-02f, 1.38927609e-01f, -5.86923994e-02f, -9.60676596e-02f,
  8.59933272e-02f, -4.34572175e-02f, 7.17807114e-02f, 1.91279955e-03f, -8.56180266e-02f, -2.81744115e-02f, -3.71599160e-02f, -7.70635083e-02f, -4.37562577e-02f, 9.37114060e-02f,
  3.99454311e-02f, 2.61687934e-02f, -1.17753536e-01f, 6.71579763e-02f, -1.01557143e-01f, 8.66627321e-02f, 6.10720403e-02f, -3.39989997e-02f, -1.39724597e-01f, 3.94699015e-02f,
  -5.83970360e-02f, 4.75239232e-02f, -1.87577549e-02f, 4.86245332e-03f, -9.97840092e-02f, 2.37183422e-01f, 2.02828929e-01f, -1.42503649e-01f, -3.51341031e-02f, -7.79184001e-03f,
  -7.66097158e-02f, -6.76252916e-02f, -8.37555341e-03f, 1.13975722e-02f, 2.03910604e-04f, 8.62663612e-02f, 1.75025448e-01f, 6.92024529e-02f, 4.48891111e-02f, -2.49760710e-02f,
  -9.35459957e-02f, -4.40418273e-02f, -1.52374402e-01f, 4.84613664e-02f, 1.42070159e-01f, -1.41429573e-01f, -1.00638019e-02f, -1.58291847e-01f, 1.77556157e-01f, 7.55387405e-03f,
  2.60488652e-02f, 2.22255830e-02f, -1.50000751e-01f, 2.16482148e-01f, 5.43161854e-02f, 1.41194925e-01f, 3.76570933e-02f, -2.25641932e-02f, 7.08903149e-02f, -1.22057488e-02f,
  1.10222429e-01f, 4.08959836e-02f, 2.06499100e-01f, 3.76288518e-02f, -4.02065441e-02f, 5.08869551e-02f, -2.55370606e-02f, 8.29655826e-02f, 1.36775136e-01f, 1.28297344e-01f,
  3.38637680e-02f, -7.50164539e-02f, -2.42178198e-02f, 5.80741949e-02f, 1.33534446e-01f, 1.33345455e-01f, -6.84820712e-02f, -9.76826102e-02f, -1.55984953e-01f, 9.67949331e-02f,
  -2.01796032e-02f, 4.56550233e-02f, 7.26237297e-02f, -3.60363647e-02f, 9.50525850e-02f, -1.09024189e-01f, -6.48181960e-02f, 3.48906964e-01f, 2.06079438e-01f, -1.72714710e-01f,
  1.05179697e-01f, 1.03193142e-01f, 1.52394891e-01f, 9.69244093e-02f, -1.82580635e-01f, 8.90911296e-02f, 7.29473680e-02f, -1.37864575e-01f, 6.68243617e-02f, 4.96166945e-02f,
  6.83892369e-02f, 9.85249057e-02f, 4.53620143e-02f, -3.70592647e-03f, -3.84498648e-02f, 1.34372354e-01f, -1.83357760e-01f, 3.15088853e-02f, -9.95807126e-02f, -1.37316808e-01f,
  -1.33699447e-01f, -1.74361676e-01f, 7.84390047e-02f, -6.78676441e-02f, -1.01040393e-01f, -1.56428546e-01f, -1.85178950e-01f, -8.89033917e-03f, 5.15237488e-02f, 7.64226075e-03f,
  8.89842138e-02f, -9.40895826e-02f, -3.89329642e-02f, 3.16258185e-02f, 6.77365065e-03f, 1.41833648e-01f, 3.25347185e-02f, 4.65779006e-02f, -1.11600786e-01f, -1.09988883e-01f,
  1.30729973e-01f, -6.27869293e-02f, -4.61370088e-02f, -8.48894101e-03f, 1.39766783e-02f, 4.27511297e-02f, 6.03690110e-02f, -1.28868073e-01f, 8.66642222e-03f, -2.50874907e-01f,
  -3.88656333e-02f, 2.07655840e-02f, 1.49186095e-02f, -9.96095315e-02f, -7.74858892e-02f, -1.29405886e-01f, 1.95308059e-01f, 1.43414065e-02f, 1.99938178e-01f, 9.05498564e-02f,
  -7.03501254e-02f, 1.23003878e-01f, -1.15899026e-01f, -2.64616832e-02f, 4.15025018e-02f, -9.93089452e-02f, -1.34493234e-02f, 7.47499838e-02f, 1.33978024e-01f, 1.37631923e-01f,
  1.47641540e-01f, -1.53312892e-01f, 1.62224900e-02f, 4.64225225e-02f, 6.77338392e-02f, 2.44193450e-02f, 4.23768871e-02f, 2.17237160e-01f, 1.16233319e-01f, 2.21704185e-01f,
  1.16465412e-01f, -4.26992215e-02f, 1.66768923e-01f, 1.59324899e-01f, 4.59097363e-02f, -2.27783415e-02f, -1.69441372e-01f, 2.42731303e-01f, 1.29970893e-01f, -7.11247418e-03f,
  1.10211380e-01f, -2.03704998e-01f, 6.76394552e-02f, -3.96603122e-02f, -4.25593145e-02f, 4.24355455e-02f, -1.73509717e-01f, 1.42381089e-02f, -1.14070497e-01f, -1.53787583e-01f,
  2.04457100e-02f, -1.56604424e-01f, 2.14152951e-02f, -4.34469990e-02f, 3.43170427e-02f, 1.51686713e-01f, -2.93647218e-02f, 4.06296328e-02f, -1.33038968e-01f, -5.74170239e-02f,
  6.31088838e-02f, 1.18559957e-01f, -6.54737875e-02f, 1.03388049e-01f, 1.31996185e-01f, 2.79459190e-02f, -1.36122376e-01f, 1.76278651e-01f, -3.49180959e-02f, -7.89492950e-02f,
  7.47995228e-02f, 1.48322321e-02f, -1.03148632e-01f, 1.96716815e-01f, 1.85743477e-02f, -1.46084413e-01f, -3.24446633e-02f, -1.47507682e-01f, -2.21137423e-02f, 5.59540242e-02f,
  1.85673963e-02f, -8.37237909e-02f, -6.80115148e-02f, -7.55622014e-02f, -9.30830240e-02f, 1.42412603e-01f, -1.70697700e-02f, 2.06247717e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  4.12364528e-02f, 1.33165270e-01f, 1.37310013e-01f, 9.98272449e-02f, 4.59812731e-02f, 1.25475749e-01f, 2.08697259e-01f, -9.22326744e-03f, 1.63062885e-01f, 7.96458742e-04f,
  -2.65027564e-02f, 8.53138138e-03f, 7.40888119e-02f, 1.62460461e-01f, 9.61946175e-02f, 1.18480153e-01f, 1.76368374e-02f, 4.63908277e-02f, -6.54784888e-02f, 5.62244765e-02f,
  -3.16910595e-02f, 1.54086888e-01f, 1.44573301e-01f, 1.07686639e-01f, -2.94012250e-03f, 1.16910383e-01f, 8.28606337e-02f, 3.33847404e-02f, 1.43797860e-01f, 2.15440635e-02f,
  6.45835996e-02f, -2.95139812e-02f, 6.14430383e-02f, -1.02912284e-01f, 3.77418883e-02f, 1.48509398e-01f, 7.69997165e-02f, 3.66410054e-02f, 6.42619804e-02f, -1.61244869e-02f,
  1.45434350e-01f, 7.53438845e-02f, 7.59483874e-02f, 1.28470778e-01f, 1.83035344e-01f, 1.17219478e-01f, 8.45071301e-02f, 3.95896249e-02f, -2.53192818e-04f, 4.62175123e-02f,
  4.41268981e-02f, 1.69650927e-01f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -2.26504337e-02f, 6.60436694e-03f, 9.07420516e-02f, 2.81472541e-02f, 1.32966086e-01f, -2.31394498e-03f, -6.90220520e-02f, 1.45759851e-01f, 4.58357334e-02f, -3.73834595e-02f,
  -1.23969298e-02f, -1.01040006e-02f, -7.65982419e-02f, 9.38712731e-02f, 1.12177931e-01f, 6.62361905e-02f, -5.80026768e-02f, -8.22927151e-03f, 1.54250979e-01f, -1.17364684e-02f,
  1.27090424e-01f, 9.78134014e-03f, -7.16941580e-02f, 9.84568447e-02f, 1.34335145e-01f, -2.85173729e-02f, 4.89628538e-02f, -2.79254653e-02f, -7.14517161e-02f, -7.74354953e-03f,
  -1.83109753e-03f, -8.33427068e-03f, 1.99726690e-02f, -2.09716037e-01f, 1.11720912e-01f, -7.33941570e-02f, -4.81448881e-02f, 8.45688954e-02f, 1.59553960e-02f, 1.33140936e-01f,
  8.50051455e-03f, -1.76165439e-02f, -9.03979223e-03f, 5.44290245e-02f, -1.05078937e-02f, 5.35878772e-03f, -1.13312975e-01f, -6.40875250e-02f, -2.27525711e-01f, 7.72127882e-02f,
  -4.21193354e-02f, -1.50161043e-01f, 5.92099056e-02f, 2.27587409e-02f, -7.17867687e-02f, 2.10306346e-01f, -4.81568575e-02f, 1.92796364e-01f, 1.85676023e-01f, 4.98726182e-02f,
  9.40381829e-03f, 7.26294750e-03f, 1.47606255e-02f, -1.13221750e-01f, 3.95826213e-02f, 5.17642032e-03f, 3.12420689e-02f, 2.13511392e-01f, 9.98922139e-02f, 3.06470804e-02f,
  6.22212216e-02f, -5.26111387e-02f, -8.49881917e-02f, 2.89166924e-02f, 4.25770693e-02f, 2.04792097e-02f, -1.87291428e-01f, -1.70640111e-01f, -3.17102298e-02f, 1.10900834e-01f,
  -4.00283337e-02f, 1.57435108e-02f, 4.15297002e-02f, -6.32778108e-02f, 1.00262173e-01f, -2.21630335e-02f, 6.99646771e-02f, -1.09242000e-01f, 3.27216946e-02f, -8.69001895e-02f,
  -1.74377803e-02f, 4.20919172e-02f, -6.27798960e-02f, -2.30064183e-01f, -1.15584187e-01f, 4.82858755e-02f, -1.20971307e-01f, 2.09187895e-01f, -1.97598949e-01f, 1.19341955e-01f,
  -7.22083747e-02f, -7.13783130e-02f, -2.39552725e-02f, -8.39806199e-02f, 3.78595963e-02f, 3.87635194e-02f, 2.08379049e-02f, -6.65254593e-02f, -5.94984628e-02f, -1.89193219e-01f,
  5.88353612e-02f, 7.03250319e-02f, -2.52527706e-02f, -9.97461975e-02f, 1.12236500e-01f, 5.80431223e-02f, -9.48338211e-02f, 8.26376304e-02f, -7.39163607e-02f, -2.20584765e-01f,
  2.43240241e-02f, 2.81026959e-02f, -1.65929407e-01f, -8.79267231e-02f, -1.04330435e-01f, -2.42914911e-02f, -6.13373145e-02f, -6.47307858e-02f, 3.29382382e-02f, 6.07881770e-02f,
  -4.72970605e-02f, 7.06963912e-02f, 6.79596588e-02f, 1.88631285e-02f, 2.18409076e-02f, -2.52433151e-01f, -1.30944505e-01f, -1.22703286e-02f, -3.77362594e-02f, -1.53705075e-01f,
  -6.22215085e-02f, -1.37284502e-01f, 9.23769102e-02f, -4.50410545e-02f, 1.66657194e-01f, 1.36287361e-01f, -6.08789325e-02f, -9.33365151e-02f, 4.53269444e-02f, -8.92346427e-02f,
  -3.28772143e-02f, -1.27469748e-02f, 1.21566048e-02f, -5.68076074e-02f, 6.59495965e-02f, 8.39255229e-02f, 4.01682220e-02f, -2.62523070e-03f, -5.49471565e-02f, 1.03310592e-01f,
  -4.47371118e-02f, 8.95981267e-02f, -1.24366377e-02f, 6.58022612e-02f, 1.08322173e-01f, -4.95100720e-03f, 7.73034431e-03f, -1.32646739e-01f, 8.11117291e-02f, -1.29742131e-01f,
  -1.99113437e-03f, -8.89723450e-02f, -3.42519656e-02f, -9.86419916e-02f, -3.54436077e-02f, 3.63369659e-02f, 7.04698935e-02f, -8.12496990e-02f, -9.35462043e-02f, -5.14376834e-02f,
  1.30353877e-02f, 9.07204300e-02f, 1.20812347e-02f, -7.19451159e-02f, -1.10644422e-01f, 4.51166183e-03f, -8.81938934e-02f, -7.69812539e-02f, 4.75624837e-02f, 1.38962762e-02f,
  4.78975140e-02f, 6.62472323e-02f, -1.04506485e-01f, -1.95680290e-01f, -6.00199029e-02f, -4.89027575e-02f, -4.96365242e-02f, -7.33817220e-02f, -1.43177837e-01f, 3.40565741e-02f,
  -1.81214243e-01f, -1.30644161e-02f, -5.63212782e-02f, -6.54069036e-02f, 1.08069174e-01f, -9.23904106e-02f, 5.82548194e-02f, 9.37176198e-02f, -1.16203889e-01f, 9.20286924e-02f,
  -5.87635003e-02f, -8.49134475e-03f, 8.58660340e-02f, -1.46948650e-01f, 1.93499848e-02f, 1.41278654e-01f, 1.24555202e-02f, -4.43178415e-02f, -6.61679655e-02f, 7.27533223e-03f,
  -4.98897322e-02f, -6.95894531e-04f, 4.09399234e-02f, 6.12604916e-02f, 8.91849026e-02f, -1.13048695e-01f, 7.52030686e-02f, -1.23331688e-01f, -1.18489705e-01f, -1.75344513e-03f,
  1.14467464e-01f, -7.78354844e-03f, -1.67058781e-02f, -1.16812043e-01f, -3.65346558e-02f, 1.36061773e-01f, 7.64514133e-02f, 7.89364651e-02f, -7.13770166e-02f, 7.20616505e-02f,
  -1.85105667e-01f, 1.03802107e-01f, 3.50967050e-02f, 1.71518624e-02f, -9.47685447e-03f, 1.10850194e-02f, -1.36007089e-02f, 8.16621408e-02f, -1.94369510e-01f, 2.13305131e-01f,
  1.23977631e-01f, 7.02452511e-02f, -3.11530632e-04f, 1.60107389e-01f, 1.27059683e-01f, -1.87080860e-01f, -1.59714632e-02f, 3.48281637e-02f, -5.02443723e-02f, -6.33750036e-02f,
  4.88135181e-02f, 7.53185228e-02f, 3.94793637e-02f, -7.25485682e-02f, -1.04614981e-01f, 1.06466964e-01f, 7.86781982e-02f, -8.27553496e-02f, 4.02637795e-02f, 4.18327004e-02f,
  -1.52177528e-01f, 5.32149523e-02f, 2.23059254e-03f, -3.93567607e-02f, 1.20921349e-02f, 9.06974450e-02f, 9.96686816e-02f, 4.59151454e-02f, 1.85503900e-01f, 2.14002505e-02f,
  -4.65276986e-02f, 4.35478203e-02f, 8.46961811e-02f, -1.41676143e-01f, 1.10678049e-02f, -4.48606499e-02f, 1.35856271e-01f, -5.60522154e-02f, 8.01218823e-02f, 4.63820174e-02f,
  -8.15830454e-02f, -9.22040083e-03f, 1.68590248e-01f, -7.48150498e-02f, -1.16727710e-01f, -9.25761685e-02f, 1.35673145e-02f, 3.47723104e-02f, 1.56474449e-02f, 7.38290027e-02f,
  -8.75693187e-02f, 7.85426721e-02f, -4.31827307e-02f, 1.48445722e-02f, 1.09258033e-01f, -2.28569023e-02f, 1.29137874e-01f, 1.80753753e-01f, -8.65629613e-02f, 1.50058582e-01f,
  -1.59531608e-01f, -4.12525088e-02f, -6.25915593e-04f, 8.23820289e-03f, 3.26259546e-02f, -3.16647626e-02f, 1.09052278e-01f, -4.81078448e-03f, -8.24626759e-02f, 9.55344923e-03f,
  1.14986459e-02f, -7.55077899e-02f, -4.90662083e-03f, -2.60665901e-02f, -1.05170114e-02f, 1.03232317e-01f, -6.32466935e-03f, -4.85885926e-02f, 6.04453171e-03f, -1.27298757e-01f,
  9.79278516e-03f, -1.53315142e-01f, -1.85629018e-02f, -7.29852468e-02f, 1.72561128e-02f, -2.85194181e-02f, -1.12179756e-01f, 7.27234483e-02f, -4.96262498e-02f, 1.14033222e-01f,
  5.56809083e-02f, -5.64062595e-02f, 8.23820233e-02f, 2.00504307e-02f, 1.37749678e-02f, -8.13197345e-02f, -1.38683230e-01f, -1.32875264e-01f, -1.25130445e-01f, -9.27555859e-02f,
  -4.37592492e-02f, 7.13405991e-03f, -4.71543148e-02f, 8.24583843e-02f, -2.74488702e-02f, -7.75260269e-04f, -1.30183011e-01f, -7.07002431e-02f, -2.83255591e-03f, 1.13425071e-04f,
  1.60069019e-01f, 5.51625155e-02f, -1.04324207e-01f, 5.36136217e-02f, 6.43816143e-02f, 2.49436703e-02f, 4.29723226e-02f, -1.56303216e-02f, 5.27623557e-02f, 1.11488208e-01f,
  8.86707902e-02f, 1.49194404e-01f, -9.94569436e-02f, 1.63659781e-01f, 7.48192295e-02f, -1.43471688e-01f, -1.21176362e-01f, -6.83991015e-02f, 1.58923157e-02f, -2.85309087e-02f,
  8.90526548e-03f, 1.56643495e-01f, -9.46981832e-02f, -1.37313321e-01f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -2.24030968e-02f, 8.99124891e-02f, 1.04228191e-01f, 5.75826652e-02f, 5.35028242e-02f, 2.71940026e-02f, 2.27846187e-02f, -1.28845796e-01f, 6.30765632e-02f, -9.45423767e-02f,
  1.28432080e-01f, -1.10866867e-01f, 7.31534213e-02f, 9.06257257e-02f, 1.21347308e-01f, -1.52143419e-01f, 3.19748707e-02f, 1.23019315e-01f, 5.47216609e-02f, -8.66660774e-02f,
  -5.62008237e-04f, 3.44627760e-02f, 9.52712297e-02f, 5.70816770e-02f, -6.48029000e-02f, -6.76561072e-02f, 1.51380897e-01f, 6.08008206e-02f, 7.69090056e-02f, 1.05491839e-01f,
  1.67378590e-01f, 4.58374135e-02f, 1.83188006e-01f, -9.04656202e-02f, 1.51624888e-01f, 9.60901007e-02f, 1.88805521e-01f, 4.33627144e-02f, -5.60276844e-02f, -1.12677969e-01f,
  1.29222959e-01f, -1.36635318e-01f, -7.70482060e-04f, 7.71019757e-02f, -3.78318951e-02f, 5.89942671e-02f, -2.10765094e-01f, -1.40249312e-01f, -1.17700189e-01f, 7.88614526e-02f,
  -8.45104605e-02f, 3.47380340e-02f, 8.71204466e-05f, 8.52435362e-03f, 4.14524693e-03f, -6.17392883e-02f, 1.38348728e-01f, -1.33237764e-02f, 6.18568137e-02f, -2.11678118e-01f,
  1.46117002e-01f, 8.02130625e-02f, -8.32106546e-02f, 4.32236306e-02f, 4.14436758e-02f, 1.08940415e-01f, 3.90683226e-02f, 5.28298132e-02f, 9.30147618e-02f, 6.60824105e-02f,
  1.16181508e-01f, -1.28548637e-01f, -3.36469896e-02f, -2.83416938e-02f, 6.96686357e-02f, -7.24337623e-02f, 5.33396304e-02f, 1.13356588e-02f, 8.60493630e-02f, -1.16673507e-01f,
  2.00072482e-01f, 1.62280917e-01f, -4.14450057e-02f, 2.08879225e-02f, -9.39621553e-02f, 8.65838379e-02f, 1.68115020e-01f, -5.54483905e-02f, -1.85898736e-01f, 9.49412435e-02f,
  2.40591206e-02f, 6.61468804e-02f, 1.73900843e-01f, 1.01830093e-02f, 6.84805363e-02f, -5.50894514e-02f, 1.16693288e-01f, 2.96168000e-01f, 6.66457554e-03f, 5.57480119e-02f,
  2.50750661e-01f, -5.94482534e-02f, -3.84912975e-02f, -2.35347420e-01f, 1.89003333e-01f, -1.69144776e-02f, -8.77440199e-02f, 1.39590129e-02f, -4.36245129e-02f, 2.03595534e-02f,
  1.54013336e-01f, -3.16240080e-02f, 2.36722305e-01f, -1.16628548e-02f, -1.09451637e-02f, 1.60357967e-01f, 6.30820990e-02f, 1.42407462e-01f, -4.29045819e-02f, -1.40793473e-01f,
  1.40435457e-01f, -2.44285777e-01f, -3.46628986e-02f, -1.17012948e-01f, 1.68073073e-01f, -4.19991976e-03f, -4.71993983e-02f, 6.68975264e-02f, -4.55433577e-02f, 4.35461551e-02f,
  1.25108436e-01f, 1.32291794e-01f, -3.97002660e-02f, 7.40860254e-02f, -8.00728947e-02f, 9.02440585e-03f, -8.99965018e-02f, -3.14360927e-03f, 2.98147798e-02f, 3.22024524e-02f,
  -2.41426043e-02f, -2.08274350e-01f, -9.60230604e-02f, 1.89697817e-01f, -7.61759281e-02f, -6.25860393e-02f, 1.55167446e-01f, 2.73956377e-02f, 2.10209340e-01f, 1.39859980e-02f,
  1.02110863e-01f, 7.01169670e-02f, 5.73946238e-02f, -2.38888655e-02f, 5.09283133e-02f, 5.67431673e-02f, -7.85396621e-02f, -7.47188851e-02f, -4.25033271e-02f, -3.52357551e-02f,
  -1.15850121e-01f, 8.72151181e-02f, -1.53174907e-01f, 1.84242666e-01f, -8.13372806e-02f, -1.71990633e-01f, -3.62196937e-02f, -2.06307042e-02f, 5.29541485e-02f, -2.92354096e-02f,
  1.62483335e-01f, 1.52315691e-01f, -8.81093591e-02f, -5.62164783e-02f, -7.09686354e-02f, 2.19170866e-03f, 9.15454328e-02f, 1.16369501e-01f, 1.67556837e-01f, 6.75811768e-02f,
  -5.67286499e-02f, 1.22717455e-01f, -1.26501888e-01f, -1.48339391e-01f, 5.50779440e-02f, 5.38886636e-02f, -2.05541477e-02f, 7.01661631e-02f, -9.77465734e-02f, 6.20732643e-02f,
  -6.37999102e-02f, -9.60748047e-02f, 1.37795582e-01f, -6.43282989e-03f, 1.46175817e-01f, 1.81101598e-02f, 8.27993006e-02f, 7.16219321e-02f, 8.09673890e-02f, 1.47588670e-01f,
  1.30364120e-01f, 1.49380684e-01f, 2.54264269e-02f, 2.19208434e-01f, -2.22242195e-02f, 2.25867271e-01f, -1.60148460e-02f, -8.74151960e-02f, 7.88338259e-02f, 1.62509486e-01f,
  1.69488728e-01f, -1.41751215e-01f, -1.11068256e-01f, 2.77217198e-03f, -1.00115621e-02f, -2.82616466e-01f, -3.17475609e-02f, 1.22345313e-01f, 9.90658551e-02f, 2.22442597e-01f,
  -9.57162119e-03f, 2.00482234e-01f, -1.12790108e-01f, 1.29535664e-02f, -2.10479081e-01f, -6.25495687e-02f, 1.36552036e-01f, 9.48584303e-02f, 9.68950912e-02f, 1.23173259e-01f,
  1.39474437e-01f, 5.20770364e-02f, -4.71031070e-02f, 8.06536674e-02f, -6.24759262e-03f, -1.01441696e-01f, 1.24756463e-01f, -1.16499521e-01f, 1.03140973e-01f, -9.04906914e-02f,
  -1.18009754e-01f, -1.97898317e-02f, -2.07285851e-01f, -6.54127374e-02f, 1.80449367e-01f, -9.59262848e-02f, 1.87537536e-01f, 1.94075599e-01f, 1.45913765e-01f, -1.90436006e-01f,
  -1.33978978e-01f, 1.70479909e-01f, -2.42008008e-02f, -1.26956344e-01f, -1.09094694e-01f, 2.62630194e-01f, 8.91447738e-02f, -2.79569230e-03f, 7.43303820e-02f, 8.80555287e-02f,
  6.11359701e-02f, 1.27786905e-01f, 1.42886236e-01f, 2.07527861e-01f, 1.32052317e-01f, 1.38410941e-01f, -7.10549206e-02f, 7.67897740e-02f, -8.80757812e-03f, 1.72448024e-01f,
  6.89188838e-02f, -8.30310769e-03f, 2.85807531e-02f, 7.06912205e-02f, 6.64949715e-02f, -6.68174028e-02f, -1.48562446e-01f, 6.78929985e-02f, -1.35922864e-01f, -2.39324808e-01f,
  -2.64577530e-02f, 6.28781095e-02f, 5.07136900e-03f, 1.61802500e-01f, -5.79755120e-02f, 1.08997382e-01f, -1.19287111e-01f, -9.79707614e-02f, -1.50165841e-01f, -1.71857253e-01f,
  1.62805095e-01f, 2.57443730e-02f, -2.42623501e-03f, 7.57825747e-02f, 1.29622012e-01f, 1.25820309e-01f, -2.07086541e-02f, 7.74621516e-02f, 9.07674432e-03f, -1.45615861e-01f,
  1.11403957e-01f, -1.15421772e-01f, 7.04384670e-02f, -8.37894455e-02f, 4.47093062e-02f, 1.74409710e-02f, -2.21818104e-01f, -1.27134442e-01f, 6.53311685e-02f, -1.29291698e-01f,
  1.10415421e-01f, 9.14991722e-02f, 1.16650239e-01f, -7.76120946e-02f, -1.82541341e-01f, 3.92085686e-02f, -6.68529645e-02f, -1.03460610e-01f, -5.14161773e-02f, 1.82587996e-01f,
  2.49754451e-02f, -5.94637543e-02f, 8.43930021e-02f, -3.88835706e-02f, -2.07348205e-02f, -9.82061923e-02f, -4.19103578e-02f, -1.32424384e-01f, -1.33236349e-01f, -8.41834582e-03f,
  -8.03394094e-02f, -9.91838574e-02f, 1.39317438e-01f, 3.33256088e-02f, 1.97264627e-01f, -5.47191352e-02f, 4.06081304e-02f, 1.61991686e-01f, -5.13730943e-02f, -3.64639461e-02f,
  -7.30285421e-02f, -1.50258206e-02f, 1.06756531e-01f, 1.28324732e-01f, -5.50483353e-02f, -3.89922969e-02f, 9.56527703e-03f, 9.19720531e-02f, 1.68485984e-01f, 5.40330298e-02f,
  3.15431617e-02f, 1.95713565e-01f, 1.70237139e-01f, -4.72390950e-02f, 1.53224438e-01f, 7.92323798e-02f, 1.30185977e-01f, 2.41552949e-01f, 6.63163587e-02f, -1.12584911e-01f,
  8.60602111e-02f, -5.32316603e-02f, -6.42868057e-02f, 1.26680741e-02f, 1.04731530e-01f, -3.68703716e-02f, -4.47904505e-02f, 8.81429538e-02f, -6.43251911e-02f, 1.16187468e-01f,
  -3.15483809e-02f, 7.01802447e-02f, 2.15886906e-01f, -1.26661867e-01f, 1.45400971e-01f, 9.83380452e-02f, 2.53676493e-02f, 1.50470972e-01f, 1.19404905e-01f, -8.27803016e-02f,
  1.35884717e-01f, 1.72665775e-01f, 1.21374443e-01f, -8.83598328e-02f, -6.55026454e-03f, -3.34009491e-02f, -6.88465778e-03f, -2.54682209e-02f, -1.55148795e-02f, 4.21450324e-02f,
  -9.91833881e-02f, -2.05721959e-01f, -1.68159947e-01f, -1.23053633e-01f, -1.64393246e-01f, -8.96655023e-02f, 8.40469450e-02f, -9.48558599e-02f, 1.77003771e-01f, 1.26111791e-01f,
  8.15993473e-02f, 1.00857258e-01f, 9.21453610e-02f, -3.72452624e-02f, 1.43382773e-01f, -3.84315848e-02f, -5.25145717e-02f, 1.47554204e-01f, 1.72262758e-01f, -1.41030997e-01f,
  -4.11583111e-02f, -7.96392485e-02f, -1.07560195e-01f, -6.98458925e-02f, -5.25115132e-02f, 1.97893247e-01f, 5.84335532e-03f, -5.84723763e-02f, 1.35420606e-01f, -1.43550456e-01f,
  -9.34579447e-02f, 1.41214296e-01f, 1.02251083e-01f, -9.24164280e-02f, 1.31060138e-01f, -5.10241427e-02f, 5.46930730e-02f, 1.12671487e-01f, 4.69398499e-02f, -3.27061452e-02f,
  3.90597284e-02f, 1.57499805e-01f, -1.11735739e-01f, 1.18775405e-01f, -4.47199913e-03f, 3.94871309e-02f, 3.59470658e-02f, -6.73662573e-02f, 1.66092128e-01f, -3.38011310e-02f,
  -8.62750635e-02f, 2.51249343e-01f, 1.21437393e-01f, 1.01578228e-01f, -1.19774073e-01f, 2.07346916e-01f, 2.11845756e-01f, -2.13730186e-01f, -3.88696953e-03f, 1.03712268e-01f,
  2.59642154e-02f, 6.40102103e-03f, 1.27300888e-01f, 4.56853816e-03f, -5.89748472e-02f, -1.12471946e-01f, -1.24798842e-01f, 2.52525434e-02f, 2.24278979e-02f, -4.84416671e-02f,
  9.78722051e-02f, 1.25565097e-01f, 8.61968026e-02f, 3.45201045e-02f, 1.64017528e-01f, -7.45361149e-02f, 1.05805203e-01f, -4.46577929e-02f, 2.31605899e-02f, 9.39127728e-02f,
  9.45109427e-02f, 1.34234115e-01f, 1.36398105e-02f, 5.26768863e-02f, 1.85428575e-01f, 4.30666767e-02f, 4.47452441e-02f, 7.16131628e-02f, 1.44619152e-01f, 1.22189485e-02f,
  7.80915618e-02f, -1.56640559e-01f, 1.41805291e-01f, -1.83961205e-02f, 2.11012289e-01f, 3.38108502e-02f, -3.69505398e-02f, -1.56926028e-02f, 2.66186595e-02f, -3.57452258e-02f,
  9.08216685e-02f, 1.20836437e-01f, -6.38235211e-02f, 2.90144812e-02f, -1.55125856e-01f, -8.34597275e-02f, -9.51522067e-02f, 1.64295316e-01f, -3.31566259e-02f, 5.85111715e-02f,
  9.57671031e-02f, -8.13751295e-02f, 1.39779132e-02f, 1.13003209e-01f, 1.62056416e-01f, 1.49354085e-01f, 1.02065615e-01f, -4.36398834e-02f, 2.42312439e-02f, 9.32952240e-02f,
  1.22346081e-01f, -1.32321781e-02f, 1.36824176e-02f, -2.21937764e-02f, 3.25137749e-02f, 3.69363725e-02f, -4.18205094e-03f, -1.44115351e-02f, -7.01518208e-02f, -1.04301885e-01f,
  -7.43733570e-02f, -1.38536826e-01f, -1.11097701e-01f, -1.69159234e-01f, 7.93081149e-02f, 2.69977357e-02f, 9.66373309e-02f, -8.08324963e-02f, -3.19797397e-02f, 8.38512331e-02f,
  -1.67121023e-01f, 3.45027214e-03f, 8.09408072e-03f, -2.11782586e-02f, -6.95478022e-02f, 1.52103111e-01f, 5.71658425e-02f, -1.24026291e-01f, -4.91423048e-02f, -7.34453052e-02f,
  3.50305997e-02f, -5.74157294e-03f, 8.57833922e-02f, 5.62063716e-02f, 1.77136317e-01f, -4.65275608e-02f, 1.23276584e-01f, 9.20844637e-03f, 1.10656945e-02f, 1.97976932e-01f,
  1.75854880e-02f, -2.15093847e-02f, 1.45055041e-01f, -1.19409584e-01f, -1.21597730e-01f, 6.67414395e-03f, 1.87491894e-01f, 2.22600549e-02f, -5.20659648e-02f, 5.53830341e-02f,
  9.26346797e-03f, 4.92655672e-02f, 1.42937549e-03f, 4.82987938e-03f, 1.80130675e-01f, 7.85182416e-02f, 1.45117760e-01f, 4.64408146e-03f, -2.09171213e-02f, 8.79591852e-02f,
  1.83865920e-01f, -8.20908323e-02f, 7.67790601e-02f, 1.63094714e-01f, 1.17830364e-02f, -1.78259555e-02f, -1.33541329e-02f, -2.29781456e-02f, 9.03551057e-02f, 1.25492647e-01f,
  9.93768796e-02f, 7.60552064e-02f, 5.27665913e-02f, 9.85633880e-02f, 1.09873768e-02f, -1.44799892e-02f, 4.81481999e-02f, 9.65030417e-02f, -9.45836976e-02f, -3.92384874e-03f,
  1.85990799e-02f, 9.12771225e-02f, -6.52281865e-02f, -3.37086543e-02f, 1.90633923e-01f, -2.47084256e-02f, 1.65004015e-01f, 2.95675751e-02f, -1.59219485e-02f, -3.55386958e-02f,
  1.67475492e-01f, -3.61563824e-02f, -2.95852795e-02f, 4.25972156e-02f, -1.24046646e-01f, -2.97242440e-02f, -9.83359516e-02f, 7.56619647e-02f, -1.10758290e-01f, -2.26880163e-02f,
  1.14205807e-01f, -2.87599699e-03f, -7.54346624e-02f, 5.55057777e-03f, 1.69806443e-02f, 4.69238497e-02f, 6.28468394e-02f, 8.92095715e-02f, -1.66212600e-02f, 1.61184892e-02f,
  7.71546215e-02f, -3.52291800e-02f, -1.01425610e-01f, -1.30847665e-02f, -1.25243261e-01f, 2.90952735e-02f, 5.07622920e-02f, 3.92981917e-02f, -5.89092150e-02f, 3.50883529e-02f,
  3.38676013e-02f, 7.83432201e-02f, 9.73779485e-02f, 3.96032557e-02f, -3.58687453e-02f, 9.35488194e-02f, -1.31593421e-01f, -5.35969390e-03f, 1.02560939e-02f, -9.30329636e-02f,
  1.02883875e-01f, -1.82509013e-02f, 2.88622249e-02f, 1.01293981e-01f, 1.03647041e-03f, 4.72205169e-02f, 2.19594892e-02f, 2.58354414e-02f, 1.09558500e-01f, 4.04786281e-02f,
  4.16744575e-02f, -2.52252836e-02f, -2.82397904e-02f, 2.28771627e-01f, 2.10841790e-01f, -1.73693046e-01f, 1.31396502e-01f, 2.42546424e-01f, 2.85523068e-02f, -1.13813527e-01f,
  -7.17101246e-02f, -3.44988815e-02f, -6.00331686e-02f, -9.55694094e-02f, -1.20931938e-01f, -1.37274526e-02f, -1.54697429e-02f, 1.67437896e-01f, 1.02060527e-01f, 1.17509305e-01f,
  2.80376058e-02f, 3.88809629e-02f, 5.65527342e-02f, -6.66115731e-02f, 2.27046877e-01f, 1.67063355e-01f, 1.83973834e-02f, 2.05077723e-01f, 1.38618782e-01f, 7.08681867e-02f,
  -3.47790085e-02f, -7.35675395e-02f, -6.40708655e-02f, -2.88428422e-02f, 1.55118927e-01f, -1.34573886e-02f, 1.13022991e-01f, -7.30076209e-02f, -2.80731190e-02f, 2.88906842e-02f,
  -1.81843773e-01f, -3.49316970e-02f, 2.18001604e-01f, -6.94848970e-02f, 2.13531330e-01f, 1.41031351e-02f, 1.47604659e-01f, -1.04765631e-01f, 5.49734905e-02f, 6.93827285e-04f,
  5.92110381e-02f, 7.59807825e-02f, -9.66653377e-02f, 1.36929587e-01f, 9.13436636e-02f, 7.62729719e-02f, -3.90125997e-02f, 6.98729381e-02f, 5.29800579e-02f, 7.14078471e-02f,
  5.41442670e-02f, -6.79725334e-02f, -3.92843969e-02f, -1.25368908e-02f, 2.60169450e-02f, -4.46783602e-02f, -8.28650966e-02f, -1.02509707e-01f, 4.43179160e-02f, -4.84288484e-02f,
  3.92761976e-02f, 3.76460962e-02f, -9.51534584e-02f, 7.88265616e-02f, 3.36242444e-03f, 2.51757894e-02f, 4.49650642e-03f, 6.43342510e-02f, 1.97212342e-02f, 9.96035933e-02f,
  8.66779592e-03f, 2.70218961e-02f, 3.53508703e-02f, 8.53307843e-02f, 2.46084128e-02f, 8.53729919e-02f, 9.03709978e-02f, 3.30420226e-01f, -1.12615839e-01f, 1.39925659e-01f,
  9.66484323e-02f, -5.92984408e-02f, 6.66605821e-03f, -4.73557860e-02f, 1.02804780e-01f, 5.43714985e-02f, 2.47453768e-02f, -7.79630244e-02f, 8.27913880e-02f, 2.39485223e-02f,
  1.06680524e-02f, 1.37031436e-01f, 1.88637286e-01f, -1.60320312e-01f, 3.30788596e-03f, 6.08986616e-02f, -5.17864004e-02f, 2.16530740e-01f, -1.39116189e-02f, -9.89723057e-02f,
  1.30627595e-03f, -1.17943883e-01f, 5.88471256e-02f, -1.20639309e-01f, 1.19644925e-01f, -6.12691939e-02f, 2.14819666e-02f, -3.24116386e-02f, 1.65765271e-01f, 8.25257525e-02f,
  -7.74852782e-02f, 1.36650935e-01f, 3.93605269e-02f, 9.71873626e-02f, 1.26144528e-01f, 7.56550655e-02f, 5.92863709e-02f, 1.12643525e-01f, 1.08444905e-02f, 1.27022028e-01f,
  -7.26899281e-02f, 1.45952791e-01f, 4.08265553e-03f, 1.00374594e-02f, 1.46717981e-01f, 1.42634571e-01f, 9.37867388e-02f, -4.78312932e-02f, -4.05685827e-02f, -8.28918070e-03f,
  9.11011174e-02f, -1.78314880e-01f, -7.48975798e-02f, 1.79562286e-01f, 5.81172332e-02f, 2.03653321e-01f, 6.84206933e-02f, 1.81370974e-01f, -4.85987924e-02f, -3.45343188e-03f,
  -1.15134515e-01f, 2.26669610e-01f, 7.39151705e-03f, 1.19853549e-01f, 1.46720871e-01f, -4.92769144e-02f, 3.71474810e-02f, 3.76582183e-02f, 2.46817283e-02f, -4.29903576e-03f,
  -5.44420145e-02f, -1.01725131e-01f, 9.55592766e-02f, 1.09310122e-02f, 2.31321245e-01f, -1.46222105e-02f, 1.77987963e-01f, -6.87949508e-02f, -5.04529551e-02f, 2.48707123e-02f,
  1.21250778e-01f, 8.36383726e-04f, 3.05049587e-02f, 5.97160421e-02f, 7.31269196e-02f, -2.24684909e-01f, -1.62310511e-01f, -1.63558610e-02f, 4.35643643e-02f, -5.23626469e-02f,
  -9.06015635e-02f, 1.51019469e-01f, 7.03637376e-02f, 3.90748233e-02f, 5.53712733e-02f, 2.04845089e-02f, 1.27809821e-02f, 4.52350713e-02f, -1.25060812e-01f, 2.72856131e-02f,
  -1.18778907e-01f, 6.45178631e-02f, -1.88044682e-01f, 4.73979395e-03f, 1.33608297e-01f, -1.89564586e-01f, -3.81200947e-02f, 1.63400233e-01f, 7.54764630e-03f, -1.01279564e-01f,
  -2.90830731e-02f, 7.78497979e-02f, 6.64298236e-02f, -1.10534549e-01f, -6.38731197e-02f, 6.04637712e-02f, 1.16703557e-02f, -2.96874549e-02f, -1.40568659e-01f, 7.45207965e-02f,
  -1.13685563e-01f, 2.02001892e-02f, -9.84254554e-02f, 1.08474895e-01f, -7.59738311e-02f, 3.83754484e-02f, 7.94236809e-02f, -1.62168235e-01f, -1.78816199e-01f, 5.05316667e-02f,
  -2.51788609e-02f, -1.45668149e-01f, 3.64109799e-02f, 1.79204106e-01f, 1.90497804e-02f, 1.14500679e-01f, -6.25787750e-02f, -5.10571641e-04f, 9.05162320e-02f, 1.41863897e-01f,
  1.42264515e-01f, 1.60246775e-01f, 1.53619930e-01f, 7.38736019e-02f, -6.10347241e-02f, 1.59730434e-01f, 3.39605063e-02f, 5.30834012e-02f, -1.22406952e-01f, 1.54362991e-01f,
  -2.32564677e-02f, 1.80435106e-01f, -4.81756926e-02f, 5.45992292e-02f, 1.54458433e-01f, -7.66743198e-02f, 1.72830708e-02f, 9.59942564e-02f, 6.32366240e-02f, -9.61741358e-02f,
  2.03258498e-03f, 2.01523136e-02f, -1.36376888e-01f, -1.77068800e-01f, -5.36310673e-02f, 5.71198314e-02f, -1.64984155e-03f, -8.86147618e-02f, 1.38525546e-01f, -4.34089079e-03f,
  5.33339893e-03f, 3.93784456e-02f, -3.69758755e-02f, -1.32685518e-02f, -2.24231537e-02f, -5.82345412e-04f, 1.29456997e-01f, 1.17512114e-01f, 1.47882864e-01f, 1.68335110e-01f,
  1.37059605e-02f, 7.82074258e-02f, 7.40274042e-02f, -5.34073189e-02f, 1.02094822e-01f, -1.44866686e-02f, 8.66993740e-02f, 1.19438693e-01f, 1.12608150e-01f, -1.87489346e-01f,
  1.12586178e-01f, -1.21226907e-02f, 8.69801193e-02f, 1.56813279e-01f, -8.38159490e-03f, -1.04509063e-01f, 8.65644068e-02f, -3.04184332e-02f, 7.78845623e-02f, 1.74219877e-01f,
  -1.05811968e-01f, 3.91513333e-02f, -1.46300986e-01f, 7.62778521e-02f, -7.28453919e-02f, 2.02635258e-01f, 9.55685228e-02f, 1.24312550e-01f, 1.27944887e-01f, -8.91992673e-02f,
  9.48763192e-02f, -9.02290940e-02f, 9.82781798e-02f, 2.87016302e-01f, 7.72048905e-02f, -5.51900011e-04f, 1.70032717e-02f, 1.26933202e-01f, 1.41142309e-01f, -9.14851353e-02f,
  -3.78534682e-02f, 2.16215733e-03f, -4.39498276e-02f, -6.14641681e-02f, -3.22748125e-02f, -1.78582761e-02f, -1.09753095e-01f, 3.32794935e-01f, -7.71889556e-03f, 1.00158632e-01f,
  -6.67640269e-02f, 1.56093463e-01f, 3.37521248e-02f, 1.83583703e-02f, -1.23472519e-01f, 3.31163257e-02f, -1.49137825e-01f, 9.42341611e-02f, 1.25681370e-01f, 1.21579431e-01f,
  -2.74711344e-02f, -1.10172495e-01f, 7.19788764e-03f, -2.10187823e-01f, -1.24642372e-01f, -1.71013493e-02f, -1.42110392e-01f, 1.29701003e-01f, -1.27416745e-01f, 1.19451217e-01f,
  -3.30676623e-02f, -6.03414662e-02f, -1.00849710e-01f, 1.74756367e-02f, 5.19660078e-02f, -1.05066493e-01f, -1.50956780e-01f, 2.23676562e-02f, 5.59715729e-04f, 7.02768862e-02f,
  -9.95828118e-03f, 9.35259908e-02f, -8.81456882e-02f, 1.06831148e-01f, -1.00206360e-02f, 4.87414263e-02f, 2.59403527e-01f, 1.17053322e-01f, 4.86908220e-02f, 1.72799036e-01f,
  8.70499685e-02f, 1.08033098e-01f, -2.73058005e-02f, 2.79806145e-02f, 1.29091635e-01f, 1.26349241e-01f, -6.78781420e-02f, 9.60679054e-02f, -6.90443069e-02f, 1.82057276e-01f,
  -8.33543241e-02f, 3.16238105e-02f, -3.04955039e-02f, 6.33811429e-02f, -3.76634263e-02f, 5.52901812e-02f, 1.49746075e-01f, 2.70390343e-02f, 1.28608979e-02f, 1.33268192e-01f,
  9.08351431e-05f, -2.40687385e-01f, -2.44487319e-02f, -2.70890575e-02f, 1.69346333e-01f, -4.60627787e-02f, 5.35148047e-02f, 5.73987663e-02f, -3.07645295e-02f, -5.26937582e-02f,
  2.09010556e-01f, 4.60383929e-02f, 1.89674363e-01f, -3.19183916e-02f, 7.48489797e-02f, 2.47816548e-01f, 2.01764733e-01f, 6.32079169e-02f, 1.26481047e-02f, 1.05381116e-01f,
  1.18480757e-01f, 7.65137449e-02f, 1.17146157e-01f, -4.54020016e-02f, 7.72085339e-02f, -9.16753244e-03f, 4.23268862e-02f, -2.08962858e-02f, 6.64303005e-02f, 3.07871670e-01f,
  2.18613267e-01f, -1.33913025e-01f, -1.55017190e-02f, 8.97345506e-03f, 5.90008907e-02f, -5.62503524e-02f, 6.93820119e-02f, 1.05461970e-01f, -5.52840494e-02f, -5.13107367e-02f,
  -1.94133610e-01f, -1.59999520e-01f, 9.27641056e-04f, 3.84604931e-02f, 7.74178328e-03f, 7.06759915e-02f, 4.82803918e-02f, -1.02280512e-01f, -8.46584737e-02f, -8.70187804e-02f,
  2.59505808e-01f, 2.20173411e-02f, 7.00719878e-02f, 1.86552927e-02f, -2.82880967e-03f, -2.02450026e-02f, -2.49301568e-02f, 9.54447389e-02f, 2.22868901e-02f, -1.27010182e-01f,
  4.95727845e-02f, -8.83846264e-03f, 1.95442345e-02f, -8.51798505e-02f, -6.32837042e-02f, 2.16388941e-01f, 7.59138316e-02f, 9.93771628e-02f, -9.80816707e-02f, 7.04360232e-02f,
  1.71081871e-01f, 1.37004942e-01f, 6.98088408e-02f, 4.98620979e-02f, 2.75382958e-02f, 1.52286306e-01f, -3.75062935e-02f, -5.73614463e-02f, -1.02499060e-01f, -1.00542575e-01f,
  -2.40680948e-02f, 1.16269914e-02f, -2.13481449e-02f, 8.03266168e-02f, -5.08733727e-02f, 1.78021371e-01f, -5.27261794e-02f, 2.79988050e-02f, 4.17152010e-02f, 9.32271183e-02f,
  6.92552552e-02f, -1.39110446e-01f, 2.38787830e-01f, -1.53048858e-01f, -7.33975768e-02f, 1.84701696e-01f, 6.32645935e-02f, 6.86885938e-02f, -1.95163056e-01f, -2.65224408e-02f,
  -8.18081647e-02f, -7.53526986e-02f, 1.30082592e-01f, -1.13270739e-02f, 1.75636083e-01f, 1.42997026e-01f, -1.26386613e-01f, 2.31633522e-03f, -1.34798780e-01f, -8.29195306e-02f,
  1.36438906e-01f, -3.12744044e-02f, 1.11059584e-01f, 1.40582770e-01f, 7.40237087e-02f, 1.43678948e-01f, -3.71781327e-02f, 1.78177387e-01f, 1.86346751e-02f, 6.85104132e-02f,
  1.13913178e-01f, -2.50619673e-03f, 5.70572689e-02f, 8.07593614e-02f, 3.63009945e-02f, 2.30712965e-01f, 1.59459442e-01f, 1.51038975e-01f, 1.39770195e-01f, -1.05389275e-01f,
  2.21030321e-02f, 5.75633114e-03f, 6.24728166e-02f, 4.22847420e-02f, 4.59244698e-02f, 1.93143889e-01f, -3.27054551e-03f, 1.03746653e-02f, 2.38682646e-02f, -6.02593198e-02f,
  1.15807533e-01f, -4.81662489e-02f, 5.80595322e-02f, 7.02755749e-02f, -6.34698123e-02f, 4.47649658e-02f, 6.37509748e-02f, 8.33656713e-02f, 1.13417685e-01f, -7.11983116e-03f,
  7.08561912e-02f, 7.00628087e-02f, 2.02651136e-02f, -2.13550422e-02f, -4.18905914e-02f, -5.31855086e-03f, 1.91926509e-02f, 7.32215121e-02f, 1.18314289e-01f, -8.55805650e-02f,
  -6.08460233e-02f, -2.62238998e-02f, 1.28088623e-01f, -7.84900598e-03f, 9.96394828e-02f, 7.11511075e-02f, -3.50884236e-02f, 5.11315698e-03f, -9.45330337e-02f, -9.74088162e-02f,
  -5.73132411e-02f, -7.35920807e-03f, -3.76262739e-02f, -1.13261156e-01f, 1.65848434e-02f, 2.63678990e-02f, -4.71464135e-02f, 3.55564654e-02f, 7.36953020e-02f, -1.84550080e-02f,
  2.99063679e-02f, -7.47337192e-02f, 2.50901980e-03f, -4.24590409e-02f, -1.40091302e-02f, 1.12768941e-01f, -1.29743606e-01f, -6.48251474e-02f, -1.00557813e-02f, -1.27605721e-01f,
  -1.20168649e-01f, -7.67118335e-02f, -1.43840820e-01f, 2.57729851e-02f, -6.51814938e-02f, -2.11290587e-02f, 7.47131789e-03f, -1.41119526e-03f, 1.00245744e-01f, -8.84911045e-02f,
  -4.80501205e-02f, 1.20882234e-02f, -1.44676834e-01f, -3.22251320e-02f, -3.29928519e-03f, 1.24193262e-03f, 9.90091115e-02f, -5.07403724e-02f, -2.38068774e-02f, -4.43742685e-02f,
  -1.27155215e-01f, 6.93345256e-03f, -1.61845595e-01f, -1.73851550e-01f, -4.14986797e-02f, -8.29208195e-02f, 6.33082464e-02f, -1.25016093e-01f, -1.54142641e-02f, -9.79585201e-02f,
  1.76076367e-02f, -7.47977570e-02f, -2.16383934e-02f, -6.59244647e-03f, -8.81675407e-02f, -9.77318287e-02f, -9.22986958e-03f, 1.50996894e-01f, -1.24133140e-01f, 8.56674612e-02f,
  -5.70912063e-02f, 1.39995247e-01f, 1.83138140e-02f, -2.79110521e-02f, -3.84090059e-02f, 3.04595888e-01f, 9.96700674e-02f, 1.03963971e-01f, -2.69826353e-02f, 4.15984280e-02f,
  3.66754048e-02f, -5.95753640e-02f, -1.23409361e-01f, 7.14329556e-02f, 2.32238080e-02f, 5.60509004e-02f, -5.64530380e-02f, 2.00546727e-01f, -8.91328976e-02f, -1.32606849e-01f,
  1.91774145e-02f, -9.82970446e-02f, 1.29547119e-01f, 5.52674234e-02f, 6.97144344e-02f, -1.19293429e-01f, -8.60017985e-02f, 1.89794868e-01f, 1.90969389e-02f, 8.16735625e-02f,
  -8.27512443e-02f, 1.23565190e-01f, 1.52720541e-01f, 1.25017300e-01f, 1.06460772e-01f, 1.08297065e-01f, 1.01737618e-01f, 9.95006487e-02f, -2.36599240e-02f, -4.12241071e-02f,
  -2.28979234e-02f, 1.37971509e-02f, -8.94798711e-02f, 1.34421408e-01f, 7.01010451e-02f, 9.58392676e-03f, -3.86790792e-03f, 1.15499549e-01f, -7.86046088e-02f, 1.36043787e-01f,
  5.79349361e-02f, 1.31818801e-01f, 8.77659842e-02f, -2.54790664e-01f, 1.12117708e-01f, -1.12754762e-01f, -2.64262687e-02f, 2.15675324e-01f, 1.95591658e-01f, 9.34013203e-02f,
  -1.13722235e-01f, 5.73270433e-02f, -5.15193865e-02f, -1.69550795e-02f, 1.71581745e-01f, -1.00784479e-02f, 3.17315571e-02f, 3.29618319e-03f, -1.73726872e-01f, 3.29633355e-02f,
  -5.27401939e-02f, -1.68744624e-01f, 1.95273757e-01f, -1.52904868e-01f, 1.51414827e-01f, 2.79057473e-01f, 7.22256228e-02f, 2.03413352e-01f, 1.41918227e-01f, 1.36414602e-01f,
  1.30156102e-02f, 3.27200592e-02f, 2.08388299e-01f, -8.41293558e-02f, 4.95620146e-02f, 4.41419072e-02f, 2.40401365e-02f, 1.17621645e-01f, -5.54903448e-02f, -6.05076700e-02f,
  1.48167845e-03f, 1.80414096e-01f, 1.05526850e-01f, 1.81471482e-02f, 6.46296814e-02f, 1.60469145e-01f, -1.75667942e-01f, -7.98394009e-02f, -1.29190996e-01f, 2.57248543e-02f,
  -2.06454650e-01f, -1.50436521e-01f, 2.03416571e-01f, 1.10722795e-01f, 6.25619814e-02f, 7.35869855e-02f, 9.01767910e-02f, -1.03386687e-02f, 3.80578488e-02f, 1.07944123e-01f,
  5.84860751e-03f, 2.17002369e-02f, -1.11031845e-01f, -2.40466967e-02f, -7.78683349e-02f, -1.15798905e-01f, -5.79348132e-02f, 3.53245288e-02f, -1.10929340e-01f, 1.69421881e-01f,
  -7.93951452e-02f, -1.18762963e-01f, -8.29792991e-02f, 1.42961219e-01f, -4.70226072e-02f, 5.01616336e-02f, -2.21037976e-02f, -6.32669926e-02f, -5.79111651e-02f, -4.10863459e-02f,
  3.54755186e-02f, -6.69821575e-02f, 4.44038175e-02f, -1.32164732e-01f, 1.41249150e-01f, -1.97379366e-02f, -1.07067764e-01f, 1.52131274e-01f, -8.76113325e-02f, -7.70205036e-02f,
  1.12730913e-01f, -7.48999566e-02f, -3.75046507e-02f, 1.41813442e-01f, -1.02246024e-01f, -2.95378834e-01f, -4.37052101e-02f, -9.55252945e-02f, 1.03411891e-01f, 1.92777827e-01f,
  2.31851920e-01f, 1.02672793e-01f, 4.26999666e-02f, 7.62995258e-02f, 2.28889268e-02f, -2.21060187e-01f, -5.80573902e-02f, -2.23766603e-02f, 1.32903636e-01f, -1.52414897e-03f,
  -1.42772254e-02f, -7.23624304e-02f, 3.85642797e-02f, 1.32967994e-01f, 1.03691287e-01f, -5.95782734e-02f, 3.00955057e-01f, -3.94506268e-02f, 2.61269063e-01f, 1.59180179e-01f,
  -8.80599860e-03f, 1.10511273e-01f, 3.33533764e-01f, 7.46383294e-02f, 2.82662898e-01f, 1.94371954e-01f, -6.59349412e-02f, 3.11526167e-03f, -1.20888680e-01f, 1.56264246e-01f,
  -1.33674145e-01f, 1.20816126e-01f, 5.85498922e-02f, 2.06006184e-01f, 8.38445425e-02f, 3.82115245e-02f, 8.41745287e-02f, -5.69485277e-02f, 1.63908795e-01f, 4.80730180e-03f,
  3.47517252e-01f, -4.87600919e-03f, -7.00823739e-02f, -1.85788423e-01f, -2.40633428e-01f, -4.08138372e-02f, -9.46734175e-02f, -1.78411543e-01f, -6.28835559e-02f, -1.15401044e-01f,
  -7.66146695e-03f, -7.61926398e-02f, 6.66138381e-02f, -8.55179597e-03f, 1.29973099e-01f, 6.74942508e-02f, -1.07303625e-02f, 5.99390157e-02f, -8.88894349e-02f, -2.28580385e-01f,
  1.68999866e-01f, -8.09255466e-02f, 1.07109547e-01f, 5.16827926e-02f, 5.38038602e-03f, 4.12840098e-02f, 7.15369731e-02f, -6.75068200e-02f, 8.64232630e-02f, 1.66298360e-01f,
  -5.43678068e-02f, 2.42121860e-01f, -1.61012262e-01f, 3.93299945e-02f, -2.05407124e-02f, -7.42804408e-02f, 1.45852864e-02f, 9.57253948e-02f, -2.33831648e-02f, 1.45034432e-01f,
  -1.87389240e-01f, -4.40104194e-02f, -1.23925902e-01f, -1.49908066e-01f, 5.03247343e-02f, -1.63361534e-01f, -1.80315420e-01f, 5.45727387e-02f, -1.86690003e-01f, 1.22576274e-01f,
  1.67398751e-02f, 1.12085119e-02f, 6.38554711e-03f, 1.43577717e-03f, 2.19412353e-02f, 7.54211023e-02f, -6.84415027e-02f, -1.44638076e-01f, -6.42954260e-02f, 1.68569773e-01f,
  1.09935619e-01f, -1.29800692e-01f, -9.13127214e-02f, 4.32388857e-02f, -1.25360623e-01f, -1.83611229e-01f, -1.69767644e-02f, -7.61577114e-02f, 2.49846235e-01f, 2.36218333e-01f,
  2.32041270e-01f, -1.59154132e-01f, -4.72380854e-02f, -2.68812552e-02f, 7.94267952e-02f, 1.00554667e-01f, 2.00721202e-03f, 1.32800087e-01f, -1.85179021e-02f, -6.44863248e-02f,
  -1.47897229e-01f, 2.13491581e-02f, 8.08266923e-02f, 1.03499264e-01f, -8.63269344e-03f, 2.13672221e-02f, 1.14817649e-01f, 3.32073085e-02f, -6.34457469e-02f, 1.47532344e-01f,
  1.66829214e-01f, -2.17189081e-02f, 1.81915611e-01f, 1.61936402e-01f, 1.38551697e-01f, -7.45889544e-02f, -1.17391488e-03f, 4.31906953e-02f, -2.27318611e-02f, 1.83005318e-01f,
  1.19486831e-01f, -8.98655280e-02f, -2.73035988e-02f, 6.61099926e-02f, -8.55392218e-02f, 5.08064777e-02f, -6.95419312e-02f, -9.09198970e-02f, -1.37540087e-01f, -4.39926982e-02f,
  -7.59728625e-02f, 2.02992894e-02f, -1.04599074e-01f, 6.34619892e-02f, -1.23163082e-01f, 1.59665972e-01f, -7.47401416e-02f, -5.27513176e-02f, -3.25264111e-02f, 7.10168704e-02f,
  5.28459400e-02f, 2.93474179e-03f, -8.09500217e-02f, 5.36666811e-03f, 9.43925697e-03f, 1.96392834e-03f, 9.04484913e-02f, 6.48623053e-03f, -1.26463920e-01f, -1.37574300e-01f,
  1.75244942e-01f, 7.57034030e-03f, 2.01430947e-01f, 9.02329981e-02f, 1.50935143e-01f, -1.39143154e-01f, -1.39179915e-01f, -1.42236066e-03f, 3.32498737e-02f, 1.32404223e-01f,
  9.73118003e-03f, 2.43404089e-03f, -1.58972234e-01f, -2.93844491e-01f, -5.34729026e-02f, -2.49533840e-02f, -2.50099320e-02f, -1.51697487e-01f, -1.66596502e-01f, 1.03977203e-01f,
  -1.23236299e-01f, 5.50796129e-02f, -1.88276172e-02f, 2.44567823e-02f, 2.91135460e-02f, 3.36530060e-02f, -1.09342657e-01f, -6.54046014e-02f, -1.44457206e-01f, 8.24130327e-02f,
  -1.13129597e-02f, -1.41127314e-03f, 1.46261632e-01f, 1.01475909e-01f, -6.86042532e-02f, 3.39707695e-02f, -8.11025947e-02f, -9.35470909e-02f, -4.97589894e-02f, 9.90522280e-03f,
  -1.17492117e-02f, -1.50086749e-02f, 4.54970561e-02f, 1.06691837e-01f, -1.73025131e-01f, 3.00108213e-02f, 1.34854943e-01f, -3.15944552e-02f, 1.80205956e-01f, -2.39555072e-03f,
  1.52472675e-01f, -1.87405974e-01f, 1.47202611e-01f, -4.47917730e-02f, 5.32476790e-03f, 1.49095319e-02f, 1.26191705e-01f, -1.48813412e-01f, -2.00028017e-01f, -5.10654859e-02f,
  6.13509938e-02f, -2.77760793e-02f, -8.14196188e-03f, 1.76221415e-01f, -1.69349521e-01f, 1.27164721e-01f, -5.39900586e-02f, 2.36949231e-02f, 7.57066980e-02f, 1.60401076e-01f,
  8.75291750e-02f, 7.87055939e-02f, -6.02996983e-02f, 2.81727687e-02f, -1.34331480e-01f, -6.42539337e-02f, 6.69066757e-02f, 1.75903484e-01f, 1.29380509e-01f, -4.32971306e-02f,
  1.42623842e-01f, 8.38160962e-02f, 7.60045871e-02f, -5.77302687e-02f, -1.73396841e-02f, 3.75870168e-02f, 5.45123480e-02f, 4.28597331e-02f, 5.55889495e-02f, 9.74724367e-02f,
  -2.51515396e-02f, 5.08213565e-02f, -1.07086912e-01f, -1.25147998e-02f, 3.51079851e-02f, 4.87232059e-02f, -8.47288892e-02f, -2.09264144e-01f, -1.42618030e-01f, 1.86392099e-01f,
  -1.08281434e-01f, -1.68485016e-01f, 9.47661176e-02f, 9.19068009e-02f, 1.84478074e-01f, 5.68971820e-02f, 5.58651537e-02f, 1.76517982e-02f, 9.13928971e-02f, 2.00366881e-02f,
  -7.40917996e-02f, 2.91448012e-02f, -1.48922399e-01f, -1.29793748e-01f, -5.88274077e-02f, 5.78754069e-03f, -1.10741049e-01f, 1.44925550e-01f, -1.97973222e-01f, 1.04595169e-01f,
  -8.08165744e-02f, -1.20827429e-01f, -8.63122046e-02f, -6.33078665e-02f, 1.09436266e-01f, 1.91527046e-02f, 3.07921357e-02f, 1.03621453e-01f, -7.94207305e-02f, -2.26372797e-02f,
  3.68422456e-02f, 1.27206489e-01f, 2.67801322e-02f, 7.71425441e-02f, 1.78528219e-01f, 1.92556996e-02f, -1.61644787e-01f, 1.99542716e-01f, -1.13215238e-01f, -1.87945440e-01f,
  -6.57709762e-02f, -1.03797195e-02f, 2.65751332e-02f, 1.35579109e-01f, -1.17445968e-01f, -5.83258877e-03f, 3.29065397e-02f, -1.84639394e-01f, 7.04316050e-02f, 5.31109609e-02f,
  7.87760839e-02f, 1.08195670e-01f, 8.20506066e-02f, 6.21939413e-02f, 1.47569448e-01f, 4.43864539e-02f, 1.67833328e-01f, -4.68626097e-02f, 1.05441421e-01f, 1.23573206e-01f,
  -9.36107635e-02f, 1.30081713e-01f, -1.08704604e-02f, -2.24726535e-02f, 6.59453496e-02f, 6.13637678e-02f, 1.88443482e-01f, -7.32786581e-02f, -1.05833532e-02f, 1.48265302e-01f,
  -4.75697555e-02f, -1.71939343e-01f, 4.84401360e-02f, 1.07163675e-01f, 5.48431948e-02f, 2.93182395e-02f, 6.10404648e-03f, 1.44567326e-01f, -7.15925097e-02f, 1.12541663e-02f,
  -1.35043278e-01f, -1.67464837e-01f, 1.45168096e-01f, -2.67909025e-03f, 3.35306786e-02f, 2.86030639e-02f, 8.42103884e-02f, 1.62090048e-01f, 2.06594374e-02f, 5.67561723e-02f,
  -2.06895806e-02f, -7.27204457e-02f, 9.54678655e-02f, -5.84327504e-02f, 7.62931863e-03f, -1.58247516e-01f, 1.53736537e-02f, 3.48472185e-02f, -1.21714734e-01f, -7.11075291e-02f,
  8.54260325e-02f, -9.45584029e-02f, 1.00562468e-01f, 1.28467232e-01f, 1.75544202e-01f, -1.71485871e-01f, -1.24012463e-01f, 1.11887697e-02f, -5.77973798e-02f, -8.79808515e-02f,
  -7.00121298e-02f, 1.45101622e-01f, -6.83361804e-03f, 6.10526502e-02f, -1.15090581e-02f, 4.96222489e-02f, -1.99188273e-02f, -4.13311496e-02f, -1.47418797e-01f, -1.58743613e-04f,
  -5.17258197e-02f, -6.87427595e-02f, -3.21031027e-02f, -4.46117483e-02f, -4.92651276e-02f, -1.37385443e-01f, -1.00928724e-01f, 5.32806478e-02f, -1.28887981e-01f, -1.53804943e-01f,
  1.51645929e-01f, 1.02697670e-01f, 1.86199635e-01f, 5.17988801e-02f, 3.15614045e-02f, 8.41844678e-02f, 3.34851444e-02f, -2.83597112e-02f, 2.47799214e-02f, -1.41853854e-01f,
  -7.94853792e-02f, -1.57085940e-01f, 8.85198731e-03f, -1.14240265e-02f, -3.54278795e-02f, -3.16585638e-02f, -8.49625617e-02f, 8.80791619e-02f, -8.21063966e-02f, -1.45873666e-01f,
  -1.31274849e-01f, -1.74652711e-02f, 7.05151707e-02f, 8.57683718e-02f, 6.59411028e-02f, 1.28287956e-01f, -1.43366218e-01f, 6.41906857e-02f, 6.57815039e-02f, 2.62008496e-02f,
  2.59417966e-02f, 1.65312409e-01f, 1.90080851e-01f, 1.20585874e-01f, -6.26757890e-02f, 1.12431735e-01f, -7.78404921e-02f, -1.16127320e-01f, -4.96967845e-02f, 1.21881180e-01f,
  4.91209067e-02f, 1.00971207e-01f, -6.87764511e-02f, -7.67837410e-05f, 3.43561284e-02f, -9.48211923e-02f, -5.54690734e-02f, 5.62407449e-02f, -5.85359000e-02f, -4.32923213e-02f,
  1.40612973e-02f, -2.97090393e-02f, -4.84491065e-02f, 1.88302249e-01f, -7.08668604e-02f, 2.60512084e-01f, -3.73202227e-02f, 6.83460832e-02f, 2.17382118e-01f, 1.08421683e-01f,
  -7.66557977e-02f, 1.77414827e-02f, -6.60437997e-03f, -3.61613147e-02f, -6.88761249e-02f, 9.14996583e-03f, -1.13514066e-01f, -7.75811225e-02f, 6.68831542e-02f, -1.49152488e-01f,
  -1.80870205e-01f, 1.19625159e-01f, 5.13578532e-03f, 1.14154108e-01f, 1.23680860e-01f, 1.66247025e-01f, 1.03511170e-01f, -1.97165553e-02f, 9.77933928e-02f, -3.78967896e-02f,
  -9.20333061e-03f, -1.86657682e-01f, 1.17885150e-01f, 2.73411088e-02f, -7.63013680e-03f, -1.05069354e-01f, -1.57279074e-01f, 1.64678041e-02f, 1.22855083e-04f, 3.34406532e-02f,
  -5.68859950e-02f, 3.61266583e-02f, 2.26662666e-01f, 4.13084365e-02f, 1.47489101e-01f, 5.71648329e-02f, -9.67584476e-02f, 2.44427770e-02f, 9.35489833e-02f, -3.31911556e-02f,
  8.50817095e-03f, 1.93217069e-01f, 7.79380053e-02f, 6.78799599e-02f, 2.36763321e-02f, 1.39847875e-01f, 1.31194457e-01f, 3.14428210e-02f, 1.18925512e-01f, 1.29454687e-01f,
  -7.62376636e-02f, 1.49890492e-02f, 7.97630548e-02f, 5.34529686e-02f, 9.48090702e-02f, 8.48031044e-03f, -2.32572835e-02f, 1.04178041e-01f, 1.13746464e-01f, 7.39686415e-02f,
  1.72609240e-01f, 1.21667318e-01f, -2.30190344e-02f, 2.03032106e-01f, -2.19243672e-02f, 1.24467313e-02f, 3.03568579e-02f, 4.34543676e-04f, 1.81145698e-01f, 5.76574653e-02f,
  -1.92490928e-02f, 1.40446678e-01f, 3.02354582e-02f, -7.53066093e-02f, -3.93009298e-02f, 4.75427397e-02f, 1.27217546e-01f, 9.26783681e-02f, 5.01315109e-02f, 7.85398334e-02f,
  3.44543122e-02f, -5.41311093e-02f, 1.77367758e-02f, -1.71877027e-01f, 1.37602091e-01f, 2.15173706e-01f, 9.47525129e-02f, -1.90155748e-02f, -5.09891137e-02f, 1.87720031e-01f,
  4.45749424e-03f, 7.53821060e-02f, -1.19043484e-01f, 1.16270401e-01f, -4.14875522e-02f, -2.86153927e-02f, -1.30114883e-01f, -1.55702636e-01f, -7.51519576e-02f, 1.66027635e-01f,
  -7.55015481e-03f, 9.96459052e-02f, 2.63395384e-02f, -1.24713629e-01f, 7.23967105e-02f, 6.87960759e-02f, 2.25357383e-01f, 2.45361663e-02f, 7.15807453e-02f, 2.00196847e-01f,
  -3.62095167e-03f, 9.58596691e-02f, -6.89208508e-02f, 1.50282770e-01f, 3.74619476e-02f, 1.61296591e-01f, 8.22153389e-02f, 2.03687176e-01f, 1.54980617e-02f, 8.70839506e-02f,
  8.19296390e-02f, -6.76352158e-02f, -1.76633626e-01f, -7.20707104e-02f, -4.29205634e-02f, -6.61025792e-02f, -5.99927753e-02f, 2.00719759e-03f, 2.48269085e-02f, 1.20726526e-01f,
  -3.72207686e-02f, 1.69456169e-01f, -1.63674764e-02f, 3.64630558e-02f, 7.41475672e-02f, -1.77472532e-02f, 2.63934024e-02f, 1.46921977e-01f, 6.81392699e-02f, 7.65299657e-04f,
  1.44520164e-01f, -8.93579144e-03f, 2.14961525e-02f, -2.95530669e-02f, 9.03281048e-02f, 1.18355751e-01f, 8.49934444e-02f, 3.34341437e-01f, -1.26276523e-01f, 1.83948696e-01f,
  1.59233483e-03f, -2.93041039e-02f, 6.44673407e-03f, -1.19804040e-01f, 1.29294708e-01f, 4.95818667e-02f, 1.01544783e-01f, -2.35605687e-02f, -3.01342271e-02f, -4.70665768e-02f,
  1.85253397e-01f, 1.14292592e-01f, 2.68341273e-01f, -1.11749247e-01f, 6.14170618e-02f, 1.74001709e-01f, 5.18817790e-02f, 2.85568893e-01f, 5.50107770e-02f, -1.10097066e-01f,
  -6.02167882e-02f, -7.15104118e-02f, 1.22046292e-01f, -1.11966990e-01f, 1.09261744e-01f, 2.21368317e-02f, 7.53597915e-02f, -9.76115763e-02f, 4.13134396e-02f, 1.42345876e-01f,
  9.88353044e-02f, 1.08130433e-01f, 2.51653586e-02f, 1.31905124e-01f, 1.61192015e-01f, -3.41353297e-01f, 6.36880621e-02f, -2.63417453e-01f, 8.27742517e-02f, -2.19286188e-01f,
  -5.86628430e-02f, -3.87201272e-03f, 2.52035230e-01f, -2.25370944e-01f, 2.41371900e-01f, 1.88795313e-01f, -1.18018724e-01f, -1.30096972e-01f, 1.07720628e-01f, 1.37058645e-01f,
  6.03429675e-02f, 2.02619396e-02f, -2.53369976e-02f, -1.32754877e-01f, 2.40101349e-02f, -3.76201570e-02f, 1.18240736e-01f, 6.01793043e-02f, -4.90079820e-03f, 1.99072897e-01f,
  -6.65222993e-03f, -3.75802070e-02f, 9.57726613e-02f, 2.94952452e-01f, 1.77257761e-01f, 8.95781070e-02f, 1.32701904e-01f, -9.50452387e-02f, 2.57154197e-01f, -1.18887447e-01f,
  -8.53185132e-02f, -9.41023007e-02f, 1.14345990e-01f, -1.01393454e-01f, -5.39285615e-02f, -8.95213410e-02f, -9.24818218e-02f, 8.22443143e-02f, -1.23865195e-01f, 1.27001405e-01f,
  -1.30938832e-02f, 1.94931665e-04f, 1.47830069e-01f, -9.29852948e-02f, 3.32923606e-02f, -1.79668158e-01f, 6.05221326e-03f, -2.45757088e-01f, -2.75135655e-02f, 1.76602006e-01f,
  -6.14621257e-03f, -7.16193300e-03f, 1.26171753e-01f, -2.14613192e-02f, 6.68065473e-02f, 1.22091413e-01f, 5.78329191e-02f, 1.16868824e-01f, 1.22425750e-01f, -2.09644943e-01f,
  -2.28523105e-01f, -5.05107865e-02f, -1.96752533e-01f, -9.36115384e-02f, 7.88164735e-02f, -1.12745196e-01f, 1.45841107e-01f, 1.49606690e-01f, 2.08416209e-01f, 2.93690175e-01f,
  -9.48285758e-02f, -9.99080613e-02f, 1.67466387e-01f, -1.07053719e-01f, -9.65293422e-02f, -1.08584501e-02f, 1.14604473e-01f, -1.56740174e-01f, -2.31172945e-02f, 1.68466449e-01f,
  -9.91899893e-02f, 2.47275177e-02f, -1.67269513e-01f, 2.72553384e-01f, -6.01160936e-02f, 8.62372890e-02f, 1.75171584e-01f, -9.88799632e-02f, -9.95759442e-02f, 1.80094764e-01f,
  2.54057884e-01f, -1.67945012e-01f, 1.65804639e-01f, -1.75061766e-02f, 2.71314420e-02f, -2.94242501e-02f, 1.64368048e-01f, -1.81982562e-01f, 1.58204392e-01f, 2.44823381e-01f,
  7.95027092e-02f, -9.78897810e-02f, -3.50085087e-02f, -6.31817654e-02f, 2.23017678e-01f, 1.76658034e-01f, 2.39458978e-01f, 6.39875308e-02f, -7.46799260e-03f, 1.54864773e-01f,
  -1.05373695e-01f, -6.87223598e-02f, -1.01141088e-01f, 1.63721621e-01f, 8.58427659e-02f, -8.22109208e-02f, 9.58439037e-02f, 3.83299682e-03f, 1.19856104e-01f, 1.50598153e-01f,
  4.67891358e-02f, -3.82146910e-02f, 5.96301705e-02f, 2.13130340e-01f, 1.61787033e-01f, 5.32832444e-02f, -9.13849249e-02f, 1.86384723e-01f, 9.22185648e-03f, 9.16818455e-02f,
  1.11418091e-01f, -7.20811961e-03f, -5.33802435e-02f, 2.65908577e-02f, 2.44534723e-02f, -5.61926328e-02f, -1.45555198e-01f, -7.04363585e-02f, -9.63044092e-02f, -2.14363024e-01f,
  -5.00367098e-02f, 2.63111517e-02f, 1.78333689e-02f, 1.93473577e-01f, -6.44362494e-02f, 1.52056172e-01f, -1.44942895e-01f, -2.09036358e-02f, -8.60744715e-02f, -3.87519747e-02f,
  8.11902806e-02f, -4.30026650e-02f, -1.16215907e-02f, 1.34447008e-01f, -5.31842783e-02f, -9.70762130e-03f, -7.48827010e-02f, 1.41387329e-01f, -8.46255869e-02f, -2.35626474e-02f,
  4.43943925e-02f, -8.79933164e-02f, 2.51130104e-01f, 5.48291905e-03f, 1.06465258e-01f, -6.59119859e-02f, 3.55605502e-03f, -1.46794945e-01f, 1.77058756e-01f, 5.49872927e-02f,
  6.55427799e-02f, 6.09187484e-02f, 8.85159224e-02f, -1.74798593e-01f, -1.05711207e-01f, 7.27637634e-02f, -3.92240360e-02f, -4.51728478e-02f, -2.49784011e-02f, 1.89277738e-01f,
  9.63914916e-02f, 7.50949085e-02f, -9.70686437e-04f, -2.73651127e-02f, 4.71483283e-02f, 5.89865670e-02f, 4.99846153e-02f, 7.97648504e-02f, -1.51830360e-01f, 8.62052292e-02f,
  -1.80807546e-01f, 5.42410500e-02f, 4.73231450e-02f, -3.16123143e-02f, -4.21181321e-02f, 7.16629550e-02f, 2.68121343e-02f, 3.43855470e-02f, -3.89328375e-02f, 8.48354921e-02f,
  -1.17771327e-02f, -9.48988423e-02f, -6.87381700e-02f, 1.71517134e-02f, -3.36605795e-02f, -5.28567396e-02f, -1.06650501e-01f, 3.29265594e-02f, -4.25936095e-02f, 9.41061601e-03f,
  -4.42558527e-03f, -6.01494685e-03f, -6.71450980e-03f, 1.32708713e-01f, 8.03476572e-02f, -1.85936838e-01f, -1.35816513e-02f, 1.05121069e-01f, -1.23241153e-02f, -1.17190167e-01f,
  4.27891314e-03f, 1.18409224e-01f, 9.67672747e-03f, -1.89970527e-02f, 2.96205785e-02f, -2.44485792e-02f, 1.75386772e-01f, 1.62992030e-01f, 1.61391079e-01f, -1.09220639e-01f,
  6.35774657e-02f, -3.88487540e-02f, 9.11448151e-02f, 1.14369676e-01f, -2.15135105e-02f, -3.17920707e-02f, -8.69455561e-02f, 2.53517111e-03f, -3.97505462e-02f, 7.16136470e-02f,
  6.54283836e-02f, -1.67126860e-02f, 9.84006226e-02f, -6.17969260e-02f, 5.22528179e-02f, -1.78741738e-02f, 4.70276475e-02f, -1.77063663e-02f, 1.18020596e-02f, 6.41906038e-02f,
  -1.27668619e-01f, 8.68311524e-02f, -6.42078966e-02f, 1.16980076e-01f, 1.08175159e-01f, 2.11628992e-02f, 5.40587716e-02f, -3.19711491e-02f, -1.42845437e-01f, 5.93535639e-02f,
  -2.76223719e-02f, -8.12372193e-02f, 1.44796059e-01f, 1.82511657e-01f, -2.14915574e-02f, 2.93666050e-02f, 7.32792392e-02f, -2.47499887e-02f, -1.16371952e-01f, 1.53069958e-01f,
  8.13966468e-02f, -1.04482807e-01f, -3.08413175e-03f, -2.17308514e-02f, 7.81602412e-02f, -2.05036119e-01f, 3.94953154e-02f, 5.75048327e-02f, -5.83241433e-02f, -1.72864832e-02f,
  1.12167463e-01f, -1.29989326e-01f, -1.73017547e-01f, 3.24969068e-02f, 9.29844528e-02f, 1.71143621e-01f, -1.16521157e-01f, 9.02565718e-02f, -1.58993810e-01f, -8.01769271e-03f,
  -3.22459452e-02f, -4.91172634e-02f, 1.00590199e-01f, 1.05907105e-01f, 7.46543109e-02f, 1.59007236e-01f, -1.45478994e-01f, 7.89009556e-02f, -1.24575563e-01f, 1.47908730e-02f,
  4.35095131e-02f, -2.15584934e-02f, 9.97905508e-02f, 1.26775548e-01f, 9.91818607e-02f, -5.83424419e-02f, -1.02162004e-01f, -8.24878961e-02f, -6.72741607e-02f, 6.36162795e-03f,
  6.66509988e-03f, -3.94102149e-02f, -1.14115793e-02f, 2.57521477e-02f, -1.06796965e-01f, -9.10066813e-02f, 4.86050770e-02f, 1.41459987e-01f, 1.75783575e-01f, 5.54933865e-03f,
  -6.95956722e-02f, 2.97327545e-02f, -4.59172539e-02f, 2.77073309e-02f, -6.05707690e-02f, -1.85066164e-01f, 2.15402752e-01f, -2.18601674e-02f, 2.04873011e-02f, 1.18688643e-01f,
  1.96505517e-01f, -5.51251397e-02f, -8.71036425e-02f, 1.77828580e-01f, 1.65050238e-01f, -7.74712786e-02f, 1.84630647e-01f, 1.79901235e-02f, 2.30127852e-02f, -1.78804025e-01f,
  -5.84830111e-03f, -1.12470150e-01f, -7.30538815e-02f, 2.22809643e-01f, 1.17765330e-01f, -1.55312464e-01f, -1.05513707e-01f, 2.01260105e-01f, -7.79491886e-02f, 7.84465447e-02f,
  4.21440601e-02f, 4.78327721e-02f, -1.80078849e-01f, -1.20751858e-01f, -1.66432381e-01f, -1.74300149e-01f, -8.26737508e-02f, -2.33418196e-02f, 1.90810412e-02f, 1.11487128e-01f,
  -3.71986218e-02f, -1.65253520e-01f, -5.72015457e-02f, -2.52670459e-02f, 2.43374124e-01f, 3.67742144e-02f, 1.08167185e-02f, 7.62277320e-02f, 6.40778709e-03f, -5.27864546e-02f,
  -3.62629332e-02f, 1.77328750e-01f, 6.10251501e-02f, -4.72344831e-02f, 4.98270765e-02f, -1.13583105e-02f, -8.07531085e-03f, -8.81687924e-03f, -1.49059534e-01f, 5.54175153e-02f,
  -1.26836762e-01f, -2.49661338e-02f, -2.30292063e-02f, -7.85942897e-02f, 2.44671386e-02f, -1.76751494e-01f, -4.86309752e-02f, 1.71269402e-01f, -1.06766067e-01f, -1.81366682e-01f,
  1.75378114e-01f, 1.07219398e-01f, 2.64578551e-01f, 5.68595082e-02f, -3.72340009e-02f, 1.94617435e-01f, 1.46653295e-01f, 4.72506462e-03f, 4.27846685e-02f, -6.59360215e-02f,
  -1.38490513e-01f, -2.22542673e-01f, -6.55577108e-02f, 6.24733865e-02f, -8.46822783e-02f, -1.60924584e-01f, 1.04350612e-01f, 4.65081297e-02f, -1.24474213e-01f, -3.02375052e-02f,
  -1.08880751e-01f, 1.72896888e-02f, 1.02639325e-01f, 1.38285831e-01f, 1.62294969e-01f, 9.81078744e-02f, -1.91687103e-02f, -5.70842624e-02f, -9.11184177e-02f, 1.31268620e-01f,
  -4.45051352e-03f, 1.58374846e-01f, 1.62558526e-01f, -3.98158357e-02f, -1.15861103e-01f, 8.35951641e-02f, 1.89249739e-02f, -1.04959637e-01f, 4.56803888e-02f, 1.30901605e-01f,
  2.61318870e-02f, 8.12971517e-02f, -1.56520337e-01f, -9.51865595e-03f, 7.69276172e-02f, -1.69227675e-01f, -3.09496503e-02f, 8.61962587e-02f, -1.40694138e-02f, -3.63086276e-02f,
  -1.31301936e-02f, 1.08228028e-01f, 3.38003710e-02f, -8.11145734e-03f, 1.13421921e-02f, 1.42205864e-01f, 4.92364690e-02f, 8.06369409e-02f, 1.44441247e-01f, -7.93691073e-03f,
  -3.59398387e-02f, -8.06286093e-03f, 1.43123344e-01f, -2.58309450e-02f, 9.05240923e-02f, 7.37882182e-02f, 4.99898940e-03f, 1.05872862e-01f, 1.16742410e-01f, -1.64982602e-01f,
  -1.54991001e-01f, 4.72343825e-02f, 3.48974653e-02f, 1.30409533e-02f, 1.28036052e-01f, 1.26529768e-01f, -6.07695058e-02f, -4.60614525e-02f, -6.15565032e-02f, 7.59950653e-02f,
  -7.61783570e-02f, -6.16062395e-02f, 1.59787744e-01f, -4.74860929e-02f, -2.82370243e-02f, -1.42831177e-01f, 3.89089808e-02f, 1.07853495e-01f, -3.39173600e-02f, 6.45495802e-02f,
  -8.14722478e-02f, -3.18246451e-03f, 1.06301934e-01f, 6.56196699e-02f, 1.16074368e-01f, 1.30057082e-01f, 4.94101830e-02f, 1.49594575e-01f, 3.77069674e-02f, 9.79326665e-02f,
  -3.00489627e-02f, 1.18967413e-03f, 2.88340840e-02f, -1.80737853e-01f, -1.33738339e-01f, 4.81554568e-02f, 8.06178749e-02f, -2.81876675e-03f, -8.80981237e-02f, 1.50923222e-01f,
  8.88748243e-02f, -3.96979600e-02f, 9.25979018e-02f, -2.83325352e-02f, 4.49388288e-02f, -4.37409543e-02f, 4.69346084e-02f, 1.33310050e-01f, 1.75047427e-01f, 1.24109432e-01f,
  7.09820315e-02f, 1.29481658e-01f, -1.17782034e-01f, 1.60848930e-01f, -7.77387200e-03f, 1.15431309e-01f, -8.99939984e-03f, -3.16491984e-02f, 1.14169732e-01f, 1.06657194e-02f,
  -9.32627469e-02f, 1.40578717e-01f, 7.39811882e-02f, -9.03904811e-02f, 8.66787881e-02f, 1.61518931e-01f, 5.57625107e-02f, 2.96697728e-02f, -7.53326267e-02f, 1.82533309e-01f,
  -6.06149025e-02f, -8.24935436e-02f, -5.09461761e-02f, 5.45519926e-02f, 4.60646302e-02f, 4.63458188e-02f, 4.40653588e-04f, -8.65871012e-02f, 1.13442484e-02f, 2.10676268e-01f,
  -3.48633192e-02f, 1.49042666e-01f, 5.42795239e-03f, -1.27120033e-01f, 1.05073102e-01f, -8.05169344e-02f, 1.49808452e-01f, -7.46310502e-02f, -2.29432568e-04f, -1.16709411e-01f,
  -7.71592036e-02f, -8.76593217e-02f, -4.96846177e-02f, -6.80073947e-02f, 3.87806706e-02f, 1.84681937e-01f, 8.78135711e-02f, -1.04799949e-01f, -6.89870715e-02f, 1.43961474e-01f,
  -8.15612599e-02f, -1.60809383e-01f, -4.69557494e-02f, 1.83405548e-01f, 4.19554599e-02f, -1.58786140e-02f, 9.62660536e-02f, 1.19742766e-01f, 4.25995626e-02f, -1.84471216e-02f,
  1.74800064e-02f, -1.54533491e-01f, -8.90669525e-02f, -8.30020830e-02f, -6.50732890e-02f, -9.38122720e-02f, -8.43407586e-03f, 5.68877421e-02f, 4.84192185e-02f, 3.37745175e-02f,
  5.25123551e-02f, 1.08315699e-01f, -8.69082585e-02f, -8.93887952e-02f, 4.77055274e-02f, -1.32779032e-01f, -6.17051385e-02f, 1.50578216e-01f, 1.07077502e-01f, -1.43584803e-01f,
  5.99028990e-02f, 8.25186893e-02f, -2.07234807e-02f, 1.91716589e-02f, -1.44210644e-02f, 1.04494683e-01f, 1.44046443e-02f, 8.81436560e-03f, 1.32828608e-01f, -5.06541394e-02f,
  2.18760073e-02f, 1.07866131e-01f, 1.15171097e-01f, -1.30573258e-01f, 1.18176304e-01f, -5.60551584e-02f, 8.51365998e-02f, -6.38372898e-02f, 1.08834162e-01f, -1.16756856e-01f,
  1.09381065e-01f, 7.33191743e-02f, 2.92121526e-03f, -9.28668827e-02f, -3.76859792e-02f, -5.60376383e-02f, 1.25742793e-01f, 7.09694400e-02f, 9.16845500e-02f, 5.80343530e-02f,
  -1.00139054e-02f, 2.68835425e-02f, 5.91131561e-02f, -1.04132637e-01f, -3.27779651e-02f, 1.92809999e-02f, 3.97433452e-02f, -8.65294859e-02f, 1.25538846e-02f, -2.92975605e-02f,
  5.34649491e-02f, 5.75276613e-02f, 8.47903788e-02f, -4.50588576e-02f, -4.25168350e-02f, -1.05482087e-01f, -1.97088882e-01f, -4.01484072e-02f, -1.15971491e-01f, -1.06500454e-01f,
  4.32795845e-03f, -6.45471439e-02f, 8.40699822e-02f, 1.16503298e-01f, 1.33746535e-01f, 6.99659064e-02f, 1.02231055e-01f, -7.42043480e-02f, 8.54968354e-02f, -7.31923282e-02f,
  -1.14880793e-01f, 1.20527238e-01f, 1.95278510e-01f, -1.41450107e-01f, 7.81681761e-02f, 7.59982830e-03f, -1.31267384e-01f, -4.53011058e-02f, -6.88943490e-02f, 1.29267201e-01f,
  -4.96122949e-02f, -4.39625978e-02f, 1.34995684e-01f, -8.59337226e-02f, -1.17054172e-01f, 7.99075067e-02f, 1.31931141e-01f, -3.47106420e-02f, 2.13096384e-02f, 1.51159586e-02f,
  1.39601916e-01f, 1.15031544e-02f, 4.92260680e-02f, -3.29108834e-02f, -6.21064659e-03f, 1.28006577e-01f, -9.02296677e-02f, -2.01717671e-02f, -5.93613125e-02f, -1.05877787e-01f,
  7.80291185e-02f, 1.43472869e-02f, 1.62049100e-01f, 1.03013091e-01f, -2.50554215e-02f, 1.95037663e-01f, 1.14264011e-01f, 5.32390811e-02f, -2.41313521e-02f, 8.76897499e-02f,
  2.20694527e-01f, -1.53206781e-01f, 3.42935845e-02f, 3.25756557e-02f, -1.98867880e-02f, 1.11676902e-01f, 1.29791558e-01f, -1.48786558e-02f, 1.68984592e-01f, 1.26879811e-01f,
  -4.38384935e-02f, 1.28459007e-01f, -1.55849010e-01f, -2.88595702e-03f, -1.20914849e-02f, 7.17866048e-02f, 8.79561305e-02f, 7.51889497e-02f, -5.67343719e-02f, 1.09159015e-01f,
  -1.83508694e-01f, 3.22521850e-02f, -1.60645723e-01f, -2.17601612e-01f, -7.40607381e-02f, -7.51725435e-02f, -2.09563598e-01f, 4.71109413e-02f, -2.47685030e-01f, 1.84198648e-01f,
  1.77274048e-02f, 1.09485656e-01f, -6.21778369e-02f, -1.15087785e-01f, 2.13552453e-02f, 1.54281586e-01f, -7.06632137e-02f, -1.08137116e-01f, -4.02806066e-02f, -6.67876680e-04f,
  -3.00802849e-02f, -1.17234245e-01f, -5.32937385e-02f, -2.22149491e-02f, -1.71926454e-01f, -6.82023987e-02f, 2.63128383e-03f, -5.64486757e-02f, 3.03124726e-01f, 2.57533640e-01f,
  1.62960947e-01f, -7.17404857e-02f, 5.35571277e-02f, -6.86193705e-02f, 3.74118835e-02f, 1.65045351e-01f, -5.32401912e-02f, 5.70768751e-02f, -7.74910450e-02f, -2.37499580e-01f,
  -1.24396309e-01f, -1.32935286e-01f, 2.64644101e-02f, -1.16695408e-02f, -1.69254005e-01f, 1.25623986e-01f, 1.35629296e-01f, 7.43765607e-02f, 9.20339227e-02f, 1.53106034e-01f,
  9.10482779e-02f, -5.18534444e-02f, -9.18023884e-02f, 1.92530811e-01f, -8.38729069e-02f, 1.77683845e-01f, 3.14721279e-02f, 1.43822551e-01f, -1.43768955e-02f, -2.26671044e-02f,
  -7.61139840e-02f, 2.43144572e-01f, -8.20057094e-02f, -3.06455456e-02f, 1.90465391e-01f, 4.11847159e-02f, 6.63573965e-02f, 1.13173509e-02f, -1.71012580e-02f, -7.90273994e-02f,
  1.43561333e-01f, 1.58848971e-01f, 1.82925344e-01f, 1.71220571e-01f, -1.41705006e-01f, -1.15938922e-02f, -1.38031110e-01f, 9.03989747e-03f, -1.44562349e-01f, 2.03375071e-01f,
  -1.51091088e-02f, 6.74986234e-03f, -1.34644493e-01f, -5.24664782e-02f, 1.05737045e-01f, 1.21819146e-01f, -7.88296387e-03f, 1.61469519e-01f, 2.32631072e-01f, -4.04992737e-02f,
  -7.15401620e-02f, -4.03832421e-02f, 6.86955824e-02f, 6.54261559e-02f, 1.02433346e-01f, -1.50330067e-01f, 1.88935141e-03f, 1.65790394e-02f, -1.15786366e-01f, 1.20125279e-01f,
  7.16127232e-02f, 7.75311589e-02f, 2.57814918e-02f, 1.09616809e-01f, -9.06260088e-02f, 2.37318292e-01f, -9.63452682e-02f, -1.91659912e-01f, 1.14525564e-01f, -1.14468403e-01f,
  -1.25381099e-02f, 7.46344179e-02f, 1.50567204e-01f, 2.25518998e-02f, 1.51744563e-04f, 1.34550020e-01f, -3.04412190e-02f, -1.69906154e-01f, -9.75596383e-02f, -1.03302253e-02f,
  6.61262199e-02f, 4.43797000e-03f, 1.83634143e-02f, -3.21569294e-02f, 2.31426954e-02f, 6.69438988e-02f, 1.03189997e-01f, -8.21902975e-02f, 1.79933801e-01f, 1.17479172e-02f,
  9.38699022e-02f, 1.43548816e-01f, 1.02447361e-01f, 9.67835933e-02f, 5.81661016e-02f, 4.36583459e-02f, 1.88230932e-01f, 2.03661807e-02f, 4.45471779e-02f, 2.71037444e-02f,
  4.16969582e-02f, 1.04565956e-01f, -2.42742673e-02f, -1.60203740e-01f, 1.12035736e-01f, 5.72485477e-02f, 2.55233198e-02f, -5.04909381e-02f, -5.32240458e-02f, 2.68220771e-02f,
  2.17523389e-02f, 3.96606028e-02f, 1.47798926e-01f, 1.11424275e-01f, -1.06786229e-01f, -6.10145181e-02f, -1.53325602e-01f, -6.56818002e-02f, -7.89082199e-02f, 1.31939888e-01f,
  9.18740481e-02f, 1.25678256e-01f, -3.22589725e-02f, -2.80354153e-02f, -6.07134812e-02f, 5.99844009e-02f, 4.71895412e-02f, 9.56303701e-02f, 6.40797913e-02f, 4.63747140e-03f,
  -4.90757450e-03f, 1.02874257e-01f, -3.41081843e-02f, 1.11347064e-01f, 6.03822432e-02f, 3.56404372e-02f, -5.58441654e-02f, 1.17895775e-01f, 2.95627583e-02f, 1.74684748e-01f,
  1.38368532e-01f, -2.25823388e-01f, 9.15905908e-02f, -1.70359418e-01f, -2.40921788e-02f, -3.32090221e-02f, -3.99950445e-02f, 6.39780164e-02f, 1.99965194e-01f, -1.72046259e-01f,
  2.09101960e-01f, 2.76747167e-01f, -4.92266417e-02f, -1.06326155e-01f, -7.40015060e-02f, 6.79579601e-02f, 1.61608104e-02f, -1.10708453e-01f, -2.71120016e-02f, -4.60787565e-02f,
  -4.33736853e-02f, 1.73873469e-01f, 2.29008831e-02f, 1.46109983e-01f, -9.87139121e-02f, 1.77708998e-01f, -8.17249939e-02f, -5.09821847e-02f, 1.36370629e-01f, 1.46683261e-01f,
  3.55422795e-02f, 1.02734216e-01f, 1.69689596e-01f, -6.77528307e-02f, -2.35793530e-03f, -3.64600122e-02f, -1.43634379e-01f, -1.52720943e-01f, 2.07148477e-01f, -3.70594813e-03f,
  1.26033984e-02f, 4.02402058e-02f, 6.22107051e-02f, 1.45822577e-02f, -9.73523334e-02f, -1.07338345e-02f, 1.32865027e-01f, -9.18213725e-02f, 1.33545712e-01f, 5.28593361e-02f,
  9.76816118e-02f, -1.92773074e-01f, -7.95607492e-02f, -1.31560519e-01f, -4.90823388e-02f, 1.32335350e-01f, -1.17129095e-01f, 5.57958186e-02f, 7.76772648e-02f, 2.20342185e-02f,
  -1.68338809e-02f, -1.15965508e-01f, 4.38023694e-02f, -2.86542196e-02f, 5.87700047e-02f, 2.16361940e-01f, 7.45527744e-02f, 1.58199757e-01f, -2.85651553e-02f, 2.18207449e-01f,
  9.10174549e-02f, 1.76627003e-02f, -8.62074643e-02f, 5.70481308e-02f, 6.75511286e-02f, -1.23451255e-01f, 2.13865682e-01f, 2.08305735e-02f, -1.04789421e-01f, 3.79221812e-02f,
  6.56078607e-02f, -2.54794449e-01f, -5.81411608e-02f, 1.38351038e-01f, -3.09407897e-02f, 8.44576210e-02f, 1.52337365e-02f, 2.10783437e-01f, -2.66106930e-02f, -1.14443034e-01f,
  -1.64611518e-01f, -2.62392610e-01f, 1.08212464e-01f, -1.11871868e-01f, -1.28504774e-02f, 3.74074169e-02f, -1.77726205e-02f, 2.60970592e-01f, -1.33323908e-01f, 2.15936512e-01f,
  -1.88372489e-02f, -3.78487520e-02f, 6.03424944e-02f, -1.53373489e-02f, 1.31583318e-01f, 5.05809337e-02f, -3.94628160e-02f, 1.62407160e-01f, -3.93771939e-02f, 3.54884043e-02f,
  3.96821834e-03f, -1.04440294e-01f, 3.92950848e-02f, 1.93043455e-01f, 6.43944219e-02f, 1.60182014e-01f, -1.16800524e-01f, 2.36108080e-01f, -9.32522416e-02f, 7.80806765e-02f,
  3.48010771e-02f, 8.09621438e-02f, -1.23543650e-01f, 3.16903964e-02f, 3.85994799e-02f, -2.30994225e-02f, -1.11821719e-01f, 1.05073862e-02f, -8.22375640e-02f, 8.81890878e-02f,
  -3.54872062e-03f, 1.90310646e-02f, 7.69176260e-02f, 6.37593269e-02f, 1.50804259e-02f, -1.82857364e-01f, -1.80245936e-02f, 1.04766205e-01f, -1.05404548e-01f, -3.52947339e-02f,
  1.03510112e-01f, 1.19344778e-01f, 1.23437002e-01f, -4.16285853e-04f, 1.10717468e-01f, -4.22275532e-03f, -3.82194631e-02f, -4.94835824e-02f, -9.81754810e-02f, 4.00946429e-03f,
  -8.79490376e-02f, -1.68979585e-01f, -2.86030788e-02f, -2.61074807e-02f, -7.07074478e-02f, 1.48291826e-01f, -1.07343331e-01f, 1.28223330e-01f, -8.94718394e-02f, -7.54754841e-02f,
  -1.06070638e-01f, -7.53917871e-03f, 9.62366015e-02f, 1.59945816e-01f, -8.46934319e-02f, 6.86160177e-02f, -4.87201400e-02f, 2.82165781e-02f, 4.39254567e-02f, 5.23428284e-02f,
  4.45690006e-02f, 1.58622295e-01f, 1.06367335e-01f, 1.24819443e-01f, -6.89402148e-02f, 1.51070178e-01f, -6.56824484e-02f, -8.49951804e-02f, -7.73927420e-02f, 1.72303505e-02f,
  -9.45666526e-03f, 2.35007592e-02f, -6.71749040e-02f, 9.29750204e-02f, -1.23902589e-01f, -1.17988117e-01f, 9.93543640e-02f, 1.25333101e-01f, 8.08077753e-02f, -5.74947111e-02f,
  7.72733688e-02f, 7.63858408e-02f, -7.59161636e-02f, 1.12478018e-01f, 1.32477179e-01f, 1.18378192e-01f, 1.56823456e-01f, 1.38109624e-01f, 9.39424708e-02f, 9.72072035e-02f,
  -1.12521574e-01f, 2.02424247e-02f, -6.35211123e-03f, -1.49704203e-01f, 1.87934041e-01f, 1.31160334e-01f, 5.51989451e-02f, 2.02168688e-01f, 1.94348693e-01f, -3.32396030e-02f,
  -4.89402451e-02f, 1.82676107e-01f, 2.31454372e-01f, -1.35264937e-02f, 4.49195616e-02f, 1.74488083e-01f, 9.02128816e-02f, -1.73074290e-01f, 1.08464643e-01f, 2.66687777e-02f,
  6.48871809e-02f, 1.83851153e-01f, 1.44015133e-01f, -7.42617249e-02f, -1.34929195e-01f, -7.19674118e-03f, 1.01242535e-01f, 1.60936803e-01f, -2.23152172e-02f, 8.24392540e-04f,
  -1.12358175e-01f, 1.51364794e-02f, 3.74301150e-02f, -4.65795770e-02f, 1.10063635e-01f, 2.32836902e-02f, 3.74808572e-02f, 7.15913698e-02f, -5.32737225e-02f, 1.49641305e-01f,
  -1.81461759e-02f, 4.06032540e-02f, 2.41626456e-01f, -1.41370118e-01f, 1.40560091e-01f, 7.51590580e-02f, 3.86492312e-02f, -1.16753846e-01f, -3.86648141e-02f, 1.60167679e-01f,
  -6.64098635e-02f, 6.99344352e-02f, -1.11817539e-01f, -4.54514883e-02f, -2.84887776e-02f, -1.46918511e-02f, 1.69132475e-03f, -4.65224385e-02f, -1.57732427e-01f, 6.50450811e-02f,
  9.51461308e-03f, -1.71067361e-02f, 1.12853900e-01f, -2.08639596e-02f, -3.15678157e-02f, -3.73160429e-02f, -3.23355608e-02f, 7.61831105e-02f, -9.76367965e-02f, 1.17528588e-01f,
  -3.71318683e-02f, 3.17481533e-03f, 1.22209668e-01f, 2.52403151e-02f, -2.17296124e-01f, -3.20858858e-03f, -6.48866817e-02f, -6.61803707e-02f, 8.65224153e-02f, 5.30389659e-02f,
  1.45330906e-01f, -9.17895138e-02f, 1.25427350e-01f, 1.06750824e-01f, -4.61066961e-02f, -2.79674144e-03f, 1.13073960e-01f, 7.39196176e-03f, -6.98439628e-02f, -5.52809648e-02f,
  -2.16992609e-02f, 8.62146616e-02f, -1.24236584e-01f, 2.88566910e-02f, 1.60207879e-02f, 5.08966073e-02f, 8.71046409e-02f, 7.69254267e-02f, 2.62820683e-02f, 1.87915757e-01f,
  1.07696973e-01f, 1.77725896e-01f, -1.86751857e-02f, 1.43370017e-01f, 2.41769217e-02f, -1.45755652e-02f, -2.65259035e-02f, 2.87848841e-02f, 5.57472855e-02f, 6.54995441e-02f,
  1.47980586e-01f, 1.12708546e-01f, -7.63612539e-02f, -6.00859411e-02f, -2.65836380e-02f, -1.18920933e-02f, 1.04953414e-02f, 1.77776784e-01f, 7.98506588e-02f, 1.88194230e-01f,
  2.14553639e-01f, -3.18110049e-01f, 7.73956478e-02f, -2.85196543e-01f, 5.23589253e-02f, -1.51032016e-01f, -1.42264396e-01f, 2.38560531e-02f, 1.84772819e-01f, -1.26319945e-01f,
  2.03450039e-01f, 2.76431859e-01f, -5.83630390e-02f, -6.42159134e-02f, 2.47933362e-02f, 1.06756166e-02f, -1.31911819e-03f, -3.93580422e-02f, 2.08844543e-02f, -1.10050783e-01f,
  -3.87946889e-02f, 1.34225562e-01f, 7.44794682e-02f, -1.36399791e-02f, -9.12458152e-02f, 1.94567472e-01f, -2.23211050e-02f, -3.05333617e-03f, 3.21511775e-02f, 1.57272160e-01f,
  7.46163502e-02f, 5.09830043e-02f, 1.39166057e-01f, -7.52621219e-02f, 2.01790228e-01f, -1.55950740e-01f, -1.85583472e-01f, -7.16722980e-02f, 2.33928233e-01f, -3.26683186e-02f,
  -1.47410464e-02f, 2.78480947e-02f, -7.78174922e-02f, 3.89549360e-02f, -8.80946219e-02f, 7.28472602e-03f, 9.48444083e-02f, 6.78716600e-02f, 1.25271812e-01f, -3.57499556e-03f,
  1.73357818e-02f, -2.58955240e-01f, 1.75494533e-02f, -2.28839502e-01f, -9.68602374e-02f, 1.50098056e-01f, -1.24270082e-01f, 1.48968786e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  -2.01508142e-02f, 1.18258022e-01f, 1.18932715e-02f, 9.57921427e-03f, -3.21721844e-03f, 6.84931874e-02f, -4.97325324e-02f, 3.03579699e-02f, 3.19165960e-02f, 4.76603061e-02f,
  9.71247330e-02f, 1.06390201e-01f, 1.23575628e-01f, 1.02208694e-02f, 7.36893043e-02f, -3.37416716e-02f, 1.07431807e-01f, 1.82913300e-02f, 1.21800438e-01f, -2.63044853e-02f,
  -3.35408300e-02f, 1.55119819e-03f, 1.03846475e-01f, -4.49653046e-04f, 2.29312833e-02f, -2.20734999e-02f, 6.63785189e-02f, 6.70640096e-02f, -3.43133025e-02f, -5.59781156e-02f,
  1.95583589e-02f, 8.64255726e-02f, 8.14417452e-02f, 1.32692486e-01f, 6.40531853e-02f, 7.91154429e-02f, 1.18711055e-03f, -5.59575409e-02f, 2.85518952e-02f, 2.64503062e-02f,
  8.21953565e-02f, 5.99105768e-02f, 9.65572894e-02f, 8.41430109e-03f, 8.99386406e-02f, 3.31824236e-02f, 1.38910502e-01f, -1.53296813e-02f, -2.66930256e-02f, 1.34428456e-01f,
  5.32093979e-02f, 4.07384299e-02f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -4.17288616e-02f, -9.20057017e-03f, -3.65238339e-02f, 3.17736082e-02f, -1.76452138e-02f, -1.83334257e-02f, 9.67881233e-02f, -5.81644662e-02f, 8.23035911e-02f, 1.26655679e-02f,
  -7.71290734e-02f, 2.22792476e-02f, -2.89778747e-02f, -1.07187577e-01f, -4.02361900e-02f, -6.32415805e-03f, -6.29223362e-02f, 8.22776854e-02f, 2.30051368e-01f, 8.95705074e-02f,
  1.31437525e-01f, 9.81859565e-02f, 9.34511423e-02f, 3.93900601e-03f, 3.54443826e-02f, -3.34071852e-02f, 1.07384376e-01f, 6.82386830e-02f, -8.37725848e-02f, 5.95283955e-02f,
  -7.49269128e-02f, 4.41054143e-02f, 5.63426223e-03f, -9.83411446e-02f, -4.43590479e-03f, -3.26795168e-02f, -2.64547747e-02f, -1.00466661e-01f, -1.12217471e-01f, 2.55560968e-02f,
  1.40499708e-03f, -1.03570379e-01f, 6.21898379e-03f, -6.29514679e-02f, 8.77589881e-02f, 1.21707112e-01f, -3.61665413e-02f, 5.17918319e-02f, -1.27788916e-01f, -1.35398701e-01f,
  7.59217665e-02f, -4.39856872e-02f, -8.41172040e-02f, 7.78208673e-02f, 1.54045761e-01f, -4.66223732e-02f, -1.64088514e-02f, 4.32354696e-02f, 6.27408773e-02f, -2.48979926e-02f,
  8.60871281e-03f, -8.27414244e-02f, 5.89269698e-02f, 1.18504792e-01f, -7.56982714e-02f, 1.09763106e-03f, 9.42076277e-03f, -1.91861793e-01f, -1.25815049e-01f, 4.03762981e-02f,
  1.90481581e-02f, 7.39338920e-02f, -4.18120213e-02f, 1.23502769e-01f, 1.38915345e-01f, 4.55464609e-03f, -9.22587141e-02f, -1.31827012e-01f, 9.74324793e-02f, -1.53201565e-01f,
  -1.40957423e-02f, -1.31574333e-01f, 1.65157914e-02f, -9.16737020e-02f, -5.13685271e-02f, 9.51001868e-02f, -2.00641930e-01f, -4.52912897e-02f, -1.62268788e-01f, 5.29067107e-02f,
  6.18796311e-02f, -4.89188544e-02f, 1.91759337e-02f, 5.07331602e-02f, -2.63304692e-02f, 1.25438124e-01f, 6.51116818e-02f, 7.09282383e-02f, 7.63001442e-02f, -6.90839961e-02f,
  -6.46824390e-02f, 9.27363057e-03f, 6.51899204e-02f, -1.38372838e-01f, 1.09015390e-01f, -4.95365188e-02f, 9.15814657e-03f, -5.93060963e-02f, -2.23281428e-01f, 4.91946042e-02f,
  -1.54229864e-01f, 1.16836596e-02f, -4.02480848e-02f, 4.59611416e-02f, 1.42848745e-01f, -8.29839930e-02f, 3.06680892e-02f, -2.56992821e-02f, 2.05394011e-02f, -4.17247675e-02f,
  1.23312203e-02f, -7.46819302e-02f, -1.38570398e-01f, -3.22149806e-02f, 1.35602146e-01f, -3.86054162e-03f, 5.75667731e-02f, -9.87043902e-02f, 7.22592324e-02f, 6.19550571e-02f,
  -7.78943524e-02f, 5.45555390e-02f, -8.59825686e-03f, 9.71678644e-02f, 6.52683452e-02f, -7.20534101e-02f, 1.32560236e-02f, 3.87521200e-02f, -5.32690361e-02f, -1.18577152e-01f,
  3.28058116e-02f, -3.35646607e-02f, -1.13083154e-01f, 2.36979779e-02f, 2.04141140e-02f, 1.18316330e-01f, 7.86736906e-02f, 3.26886624e-02f, 7.11529106e-02f, 8.28894135e-03f,
  9.44142863e-02f, -4.15375419e-02f, -5.73952263e-03f, -4.05718945e-02f, 7.11501017e-02f, -1.74126886e-02f, -8.87572914e-02f, 1.24362268e-01f, 3.78448814e-02f, -1.78479478e-02f,
  1.88504979e-01f, -1.47535605e-02f, 3.25039774e-02f, 2.22285520e-02f, 5.18830679e-02f, 2.03642566e-02f, -6.86572418e-02f, -7.89129734e-03f, 4.47923597e-03f, -3.48003507e-02f,
  4.06902656e-02f, -4.67448235e-02f, -5.12377359e-03f, 8.67655203e-02f, 4.36593294e-02f, 9.66877341e-02f, -6.44921064e-02f, -1.05039857e-01f, -5.37847839e-02f, -1.22889251e-01f,
  7.62773827e-02f, 1.21413387e-01f, 1.50189519e-01f, 5.38933165e-02f, -4.56116423e-02f, -6.76296651e-02f, -6.19117469e-02f, 7.95432031e-02f, 2.95857247e-03f, -4.10088897e-02f,
  -3.71459723e-02f, -1.79592241e-02f, -1.13581665e-01f, -1.01748355e-01f, 4.18283157e-02f, -7.85279647e-03f, 4.38680947e-02f, -6.78558052e-02f, 1.01171672e-01f, 1.49623945e-01f,
  -1.08737588e-01f, -1.39307231e-01f, 3.72217074e-02f, -1.29144788e-02f, 1.83407962e-03f, -9.45729539e-02f, 6.03724457e-02f, -1.43079951e-01f, -7.34647177e-03f, 5.73884919e-02f,
  -9.17910039e-02f, 9.30539332e-03f, 7.61057138e-02f, 3.12003307e-03f, -9.81205106e-02f, 3.41779217e-02f, -7.90357888e-02f, -7.41746202e-02f, -6.36035725e-02f, 1.72422715e-02f,
  7.20131490e-03f, -8.71221051e-02f, 1.72810052e-02f, -5.39186299e-02f, -7.91637823e-02f, 1.49928704e-01f, -2.95468178e-02f, -8.02577734e-02f, 6.49425685e-02f, 6.39807880e-02f,
  8.48549455e-02f, 4.70679179e-02f, 7.49565512e-02f, -1.08876556e-01f, -1.67110730e-02f, 1.10539943e-01f, -5.88944256e-02f, -3.22141871e-02f, -1.00356899e-01f, 5.50233424e-02f,
  4.84407991e-02f, 3.42069417e-02f, 9.92758349e-02f, -1.20688155e-01f, 8.13667998e-02f, 7.90893734e-02f, -1.74658634e-02f, 5.98442294e-02f, 1.19687505e-01f, 3.69690321e-02f,
  -1.00265518e-01f, -4.47723828e-02f, 7.79994484e-03f, 8.26112088e-03f, -3.94459479e-02f, 8.52730032e-03f, 1.89172029e-02f, 1.90389141e-01f, 4.39200662e-02f, -2.07288675e-02f,
  8.30789655e-02f, -1.76653359e-02f, -7.81537965e-02f, 2.65296996e-02f, -5.85078681e-03f, 1.08902557e-02f, -9.85474512e-02f, 3.14951129e-02f, 1.77629620e-01f, 1.23846285e-01f,
  2.10231140e-01f, 1.22657210e-01f, -9.43697989e-03f, 8.22026730e-02f, 7.49745220e-02f, 1.83937903e-02f, -1.06180310e-02f, 1.53605476e-01f, 1.63062349e-01f, 1.18434779e-01f,
  1.64090586e-03f, 1.23087861e-01f, 4.70856577e-02f, 1.16276734e-01f, 1.89477116e-01f, 9.59131029e-03f, 6.28889501e-02f, 2.65829694e-02f, 6.67192563e-02f, 1.44297406e-01f,
  1.50923759e-01f, 1.12091325e-01f, 1.71214119e-02f, 1.17694614e-02f, 9.98266861e-02f, 4.09488007e-02f, 1.58067748e-01f, -1.22765481e-01f, 2.80096531e-02f, 7.54115656e-02f,
  1.55304417e-01f, 2.54245222e-01f, 3.48615125e-02f, 1.67115733e-01f, 3.79096949e-04f, 2.52620745e-02f, 9.92637947e-02f, 1.39125571e-01f, 8.34595039e-02f, 9.50592682e-02f,
  5.10567501e-02f, 7.33877942e-02f, 1.86529264e-01f, 9.70574766e-02f, 1.30807966e-01f, 4.57281880e-02f, 7.66970962e-02f, 1.90139115e-01f, 6.59376755e-02f, 1.12421885e-01f,
  -4.53520641e-02f, 1.31156649e-02f, 3.82015035e-02f, -1.84481710e-01f, -3.30137624e-03f, -4.61094044e-02f, -4.16913927e-02f, -4.03102189e-02f, -1.28485113e-01f, -2.17642915e-02f,
  -6.75405860e-02f, 6.33930936e-02f, -3.36343311e-02f, 2.30398159e-02f, 4.08061258e-02f, -9.78583023e-02f, -6.92480057e-02f, 9.31133851e-02f, 1.22768842e-01f, -7.00996444e-02f,
  1.03354536e-01f, -2.63879076e-02f, 7.23331645e-02f, 2.50797998e-02f, -1.14645481e-01f, 5.97530901e-02f, 1.10290334e-01f, 6.03609085e-02f, -6.08990639e-02f, 1.57268494e-01f,
  -8.51524696e-02f, 4.34749350e-02f, 1.48496166e-01f, 1.17739439e-01f, -1.50869340e-01f, -1.59894291e-03f, 1.47260278e-02f, -5.08704521e-02f, 3.36014107e-02f, 7.99705684e-02f,
  8.92744064e-02f, 1.04956008e-01f, 1.08944885e-01f, -1.45785213e-01f, -1.50165811e-01f, -5.93335442e-02f, 8.83785188e-02f, 2.30505373e-02f, 1.23314947e-01f, 3.41204628e-02f,
  6.88573569e-02f, -8.39442238e-02f, -1.90686504e-03f, 6.80983737e-02f, -6.95565939e-02f, -4.38962206e-02f, -1.02566622e-01f, -9.29004326e-02f, -6.05638623e-02f, 3.41039263e-02f,
  3.76718268e-02f, 1.03687361e-01f, -8.96626990e-03f, -1.34061649e-01f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  7.32040629e-02f, -5.73250614e-02f, -1.14317071e-02f, 7.17139617e-02f, 8.92416760e-02f, 3.24415453e-02f, -1.29919067e-01f, 8.55492726e-02f, 4.84650908e-03f, -1.54024601e-01f,
  2.65932120e-02f, -1.73238181e-02f, 1.29409268e-01f, 1.64566994e-01f, 3.54530364e-02f, 9.07767490e-02f, 5.57502583e-02f, -7.08542019e-02f, -1.28648937e-01f, -6.17748685e-03f,
  -1.87785309e-02f, -7.85301439e-03f, 1.75921395e-01f, 2.13133365e-01f, 2.38134101e-01f, -1.47766158e-01f, -9.45167895e-03f, -5.76159954e-02f, 1.88660160e-01f, -9.08729136e-02f,
  1.13340989e-01f, -1.17634475e-01f, -2.03982033e-02f, 1.17511250e-01f, 8.24085772e-02f, 4.29144129e-02f, 1.79297611e-01f, -6.47081435e-02f, -2.92723347e-02f, 6.88133389e-02f,
  -9.89005342e-02f, -4.86989282e-02f, 1.94233432e-01f, 1.58675879e-01f, 3.64542417e-02f, -1.52906448e-01f, 7.13156536e-02f, -1.12061929e-02f, -6.89932331e-03f, 1.60209820e-01f,
  -5.24148531e-02f, 3.50483358e-02f, 2.08871886e-01f, 3.17489654e-02f, -1.02929354e-01f, 5.77108562e-02f, 1.75809428e-01f, 3.07840761e-02f, 1.79558516e-01f, 6.08906634e-02f,
  5.35384156e-02f, 1.38919026e-01f, -5.45577100e-03f, 8.93569514e-02f, -3.96393798e-03f, 9.18461308e-02f, 1.68986898e-02f, -7.20121106e-03f, 1.14098191e-01f, 5.04660234e-02f,
  2.00078618e-02f, -4.07225862e-02f, 3.60493436e-02f, 7.56265149e-02f, -1.21121921e-01f, 5.94370067e-03f, -4.38226238e-02f, -9.19913352e-02f, -1.65776964e-02f, -8.97576511e-02f,
  -1.64501086e-01f, -1.09725958e-02f, 1.49698541e-01f, -6.72408119e-02f, 1.22518741e-01f, 8.60365108e-02f, -6.03672229e-02f, 6.42445460e-02f, -1.99441224e-01f, 1.07557271e-02f,
  9.17053893e-02f, -1.25451148e-01f, -1.24812178e-01f, -3.85364667e-02f, -3.04436870e-02f, -1.22087002e-01f, -4.90129553e-02f, 3.12842987e-02f, 7.83438534e-02f, 3.63769457e-02f,
  -6.08917512e-02f, -5.34027554e-02f, 2.35074162e-02f, -1.93944216e-01f, 4.62325551e-02f, -1.04479037e-01f, -1.66707993e-01f, 7.82400593e-02f, 2.35261396e-02f, 1.20073818e-01f,
  -1.40039980e-01f, 1.25359133e-01f, -8.69770721e-02f, 3.65360565e-02f, 1.67977303e-01f, -1.02540478e-01f, -7.76416659e-02f, 1.27491876e-01f, 1.65214181e-01f, 8.98206681e-02f,
  6.87169880e-02f, 2.05092821e-02f, -7.70941153e-02f, -1.20217182e-01f, -5.41516915e-02f, -1.23471081e-01f, -1.25094190e-01f, 6.30531758e-02f, 4.54348736e-02f, 2.66739707e-02f,
  -7.42676482e-02f, 7.42135942e-02f, 9.05829072e-02f, 1.17319815e-01f, 1.40955254e-01f, 4.52104248e-02f, -8.56779963e-02f, -1.04622496e-02f, 3.33554391e-03f, 6.72529079e-03f,
  -6.23172708e-02f, -1.38200924e-01f, 2.10940883e-01f, -1.14247158e-01f, -4.89536189e-02f, -1.50697246e-01f, 8.05056542e-02f, 7.00339675e-02f, -1.11078702e-01f, 4.06902023e-02f,
  -6.84264526e-02f, -6.47829771e-02f, -1.02054164e-01f, 1.50191709e-01f, 4.09201384e-02f, 4.60844971e-02f, 3.41240205e-02f, -7.30946362e-02f, 6.30003884e-02f, 2.32588570e-03f,
  -8.67230743e-02f, 1.60669774e-01f, 2.34982371e-01f, -2.32437834e-01f, -1.58763915e-01f, 4.29120585e-02f, 1.33474499e-01f, 1.39189400e-02f, 2.03085631e-01f, -2.09613696e-01f,
  1.34913892e-01f, 1.13522753e-01f, -9.47366431e-02f, -3.84348594e-02f, -5.09860888e-02f, -1.21973127e-01f, -3.40056117e-03f, 4.25524078e-02f, 2.68702269e-01f, -2.95430720e-02f,
  -2.30981708e-02f, -2.64879297e-02f, 9.79826041e-03f, -2.03961611e-01f, 1.37464389e-01f, 8.96825045e-02f, -2.53033191e-01f, -4.42946479e-02f, 1.13302700e-01f, -5.47583622e-04f,
  -6.53965846e-02f, -1.62200272e-01f, 3.95843051e-02f, -1.81898028e-02f, 9.01666731e-02f, 8.97883475e-02f, 1.39623523e-01f, 9.78541821e-02f, 7.57634044e-02f, 1.47757724e-01f,
  7.07329214e-02f, 4.63327542e-02f, 7.91939721e-02f, -6.70418069e-02f, 5.79523994e-03f, 3.12762568e-03f, 6.38660491e-02f, -2.36373357e-02f, -4.14251238e-02f, -1.53982997e-01f,
  9.20629653e-04f, -6.06600021e-04f, -1.26455933e-01f, 3.51023003e-02f, -2.19570369e-01f, 2.48074662e-02f, -1.28116468e-02f, -2.36658789e-02f, 5.43103963e-02f, -1.10143952e-01f,
  3.37453447e-02f, -6.83122277e-02f, 1.12851702e-01f, -1.76967129e-01f, -6.00038357e-02f, 9.60922316e-02f, 1.81629911e-01f, 1.78974718e-02f, -2.27971505e-02f, 1.04583606e-01f,
  2.98191905e-02f, -9.46640410e-03f, -1.41882999e-02f, -8.91415700e-02f, -6.90586790e-02f, 9.20078382e-02f, -1.72628075e-01f, 5.99687770e-02f, 1.32796597e-02f, 6.02719150e-02f,
  2.89960336e-02f, 8.56558606e-03f, 8.44624192e-02f, -1.13767266e-01f, 5.04407473e-02f, 3.78755741e-02f, 1.39958560e-01f, -9.95877199e-03f, 1.33220375e-01f, 7.49873295e-02f,
  -1.75367385e-01f, -4.29317951e-02f, -5.60723133e-02f, 6.10116385e-02f, -4.44626324e-02f, -2.14407042e-01f, -1.68554932e-01f, -2.61533931e-02f, -1.24465980e-01f, -7.78948516e-02f,
  -4.14574258e-02f, -2.33661719e-02f, 3.60763632e-02f, 3.96387950e-02f, 1.25948573e-02f, 1.53721541e-01f, -7.12615997e-02f, 2.33756498e-01f, -1.10789701e-01f, 4.79150638e-02f,
  2.68274043e-02f, -2.36523256e-01f, -1.10295735e-01f, 1.28482226e-02f, 2.38461211e-01f, -5.72768524e-02f, 4.79020216e-02f, -4.79062134e-03f, -5.93861900e-02f, -3.11387721e-02f,
  -1.64080143e-01f, 1.74375027e-01f, 1.31801635e-01f, 2.54448634e-02f, -1.25266105e-01f, 9.36397463e-02f, -1.67445794e-01f, 9.21929404e-02f, 6.13658279e-02f, -7.30509907e-02f,
  -1.50685027e-01f, 1.07732974e-01f, -1.24461494e-01f, -2.80331429e-02f, 5.83892949e-02f, -2.88918018e-01f, 4.55008149e-02f, -1.08452685e-01f, -1.44991368e-01f, 8.57633427e-02f,
  3.50272544e-02f, 2.08045736e-01f, -1.41752154e-01f, 1.32869855e-01f, -8.87511745e-02f, -1.39310332e-02f, 1.47336543e-01f, 4.93438682e-04f, -2.22207278e-01f, 1.46495923e-01f,
  1.29059196e-01f, -9.09646600e-03f, -1.25126198e-01f, -2.62710005e-02f, 1.39931992e-01f, -1.88499615e-02f, -1.81608479e-02f, -2.02870071e-01f, 1.12602105e-02f, 1.11243753e-02f,
  1.26206353e-01f, -6.77620620e-02f, 1.09833486e-01f, 2.19597757e-01f, 6.91966191e-02f, 4.75157276e-02f, -1.05508208e-01f, 1.11564584e-01f, 1.80035576e-01f, -8.11017752e-02f,
  8.88094679e-02f, 5.48308827e-02f, 2.42164657e-02f, 1.43494084e-01f, -3.11958790e-02f, 1.11508645e-01f, 3.16952020e-02f, -1.24378260e-02f, 2.26754695e-02f, -1.12407506e-01f,
  1.40783980e-01f, 1.89554662e-01f, -5.72555047e-03f, 2.10247368e-01f, 8.47848430e-02f, 9.80508551e-02f, -5.41712716e-02f, 5.03009968e-02f, -4.74867150e-02f, 1.79885477e-02f,
  -3.17997597e-02f, -8.55699480e-02f, 1.32398792e-02f, -1.16181679e-01f, 7.40614012e-02f, 1.71499550e-01f, 1.67330563e-01f, -7.26114884e-02f, 1.07471570e-01f, -4.75945137e-02f,
  -1.12500109e-01f, -5.53554371e-02f, -1.18304849e-01f, 2.44221911e-01f, 1.40147209e-01f, 3.45903963e-01f, 1.63143873e-01f, 9.01662186e-02f, -1.21440277e-01f, -1.99153647e-01f,
  -1.12610050e-01f, 1.28010428e-02f, -9.53693166e-02f, 2.12893218e-01f, 1.34918615e-01f, 2.63876945e-01f, 8.84389356e-02f, -4.56698835e-02f, 2.29826987e-01f, -2.04176247e-01f,
  -1.55671481e-02f, -1.14455044e-01f, -2.65399180e-03f, 2.33336583e-01f, 6.90023750e-02f, 5.01601435e-02f, -3.54037844e-02f, 1.40697017e-01f, 6.24283217e-02f, 1.00543872e-01f,
  -4.08669263e-02f, 1.73461989e-01f, 4.88356240e-02f, 1.94250199e-03f, -2.71816961e-02f, 5.31550050e-02f, 1.65519100e-02f, 1.14719801e-01f, 1.71081558e-01f, -1.44269437e-01f,
  -1.59744158e-01f, -9.86309499e-02f, 1.31852940e-01f, 2.78853644e-02f, -1.18442103e-02f, 2.06115037e-01f, -1.10890441e-01f, 8.44231993e-02f, 8.83863792e-02f, 6.77601919e-02f,
  -1.00244442e-02f, -1.24296792e-01f, 3.56470495e-02f, -1.82220042e-01f, 9.23879370e-02f, -1.31537274e-01f, -1.51729986e-01f, 8.66188854e-02f, 2.24905625e-01f, -4.20417488e-02f,
  1.15929525e-02f, -7.28003457e-02f, 2.06407949e-01f, -7.23747984e-02f, 1.14069097e-01f, -1.68419793e-01f, -1.08978130e-01f, 2.27634519e-01f, 1.58692479e-01f, 1.01796374e-01f,
  -1.05964422e-01f, 3.61085385e-02f, -4.69305590e-02f, 3.02319955e-02f, 1.14215426e-01f, 1.67031121e-02f, -1.02033518e-01f, 1.05158255e-01f, 1.98281277e-02f, 3.18661295e-02f,
  2.08112046e-01f, 1.23333804e-01f, 1.35649100e-01f, -2.02673256e-01f, -6.94924074e-06f, -1.23954949e-03f, -8.01950246e-02f, 8.37932229e-02f, 4.29365933e-02f, -3.91303301e-02f,
  3.28685567e-02f, 5.97865395e-02f, 2.12457925e-02f, 5.21596521e-02f, -9.38185155e-02f, -2.74379048e-02f, 1.22249285e-02f, 1.17167886e-02f, 9.93655473e-02f, 1.52555361e-01f,
  1.59013532e-02f, 3.38035598e-02f, 4.53022569e-02f, -2.17388824e-01f, -1.75015047e-01f, -5.74889109e-02f, 3.82916667e-02f, 6.00782223e-02f, -1.90968774e-02f, 1.15569800e-01f,
  -2.19932154e-01f, 9.40738395e-02f, -9.24320891e-02f, 3.12530398e-02f, 6.35415763e-02f, 5.42231910e-02f, -8.03561434e-02f, -1.31043449e-01f, 1.01577796e-01f, 1.22191153e-01f,
  -1.21805161e-01f, 7.64691308e-02f, -4.85753641e-02f, -9.43496972e-02f, 6.16531372e-02f, 1.01374626e-01f, 4.11332808e-02f, -1.09502748e-01f, 1.09399989e-01f, 3.72152776e-02f,
  2.12215018e-02f, 1.05411097e-01f, -6.51654676e-02f, -7.81291351e-02f, -7.18645519e-03f, 3.43779363e-02f, 1.58951774e-01f, -8.29712898e-02f, 1.45757347e-01f, 8.09986293e-02f,
  -1.04560694e-02f, -1.60177681e-03f, 3.52730080e-02f, -2.50340831e-02f, -2.26309779e-03f, -2.35382793e-03f, -1.28028423e-01f, 6.20602816e-02f, 1.54890388e-01f, 8.60883072e-02f,
  1.53570354e-01f, -1.41062617e-01f, 3.19620259e-02f, 3.71254906e-02f, 6.40079528e-02f, 5.28284274e-02f, 2.90432200e-02f, 5.27704358e-02f, -3.07055801e-04f, 8.99767950e-02f,
  3.61502245e-02f, 1.03052799e-02f, 6.15751334e-02f, 5.84088936e-02f, -9.74187404e-02f, -8.29530507e-02f, 1.50751755e-01f, -5.77943325e-02f, -1.06896646e-01f, -1.52226642e-01f,
  8.02727416e-02f, -9.55564156e-03f, -8.16362575e-02f, 6.72890842e-02f, -2.07379088e-01f, 5.65783214e-03f, 2.68578995e-02f, 1.43807888e-01f, -8.76744464e-03f, 4.94696200e-02f,
  3.81527692e-02f, -1.74157456e-01f, 1.25915200e-01f, 3.47707644e-02f, -8.85663182e-02f, 3.65769826e-02f, 1.94984123e-01f, -7.70488009e-02f, -3.34203430e-02f, 7.11443648e-02f,
  1.37759358e-01f, -1.05264246e-01f, 1.76475301e-01f, -5.08839916e-03f, -7.83924609e-02f, 9.33169797e-02f, -1.51230944e-02f, 5.96006773e-03f, -8.99384171e-02f, 9.78576392e-02f,
  9.05315280e-02f, -6.29524514e-02f, 1.08918607e-01f, 5.96110076e-02f, -8.74792710e-02f, 3.30594629e-02f, 6.03296869e-02f, -4.17670310e-02f, 1.22557096e-01f, 8.27172697e-02f,
  -8.28927755e-02f, -6.85389340e-02f, 3.79348323e-02f, 1.15971662e-01f, 3.98755483e-02f, -1.64521366e-01f, 5.95963793e-03f, -7.84323364e-02f, -2.19880324e-03f, 7.58253112e-02f,
  -4.98597808e-02f, 1.31267011e-01f, 9.62844193e-02f, -7.27428272e-02f, 1.59817655e-02f, -1.59385145e-01f, -1.33463264e-01f, -2.49875849e-03f, 6.21547475e-02f, -1.48102880e-01f,
  -7.60771185e-02f, 5.77642545e-02f, 4.91555706e-02f, -8.15619603e-02f, 5.34811839e-02f, 3.42924800e-03f, 3.71196941e-02f, 1.66148826e-01f, 1.00766495e-01f, -6.05345070e-02f,
  4.58569117e-02f, -1.42153293e-01f, -2.20039412e-02f, -9.33308527e-02f, 1.01810053e-01f, 5.12164533e-02f, -5.87094501e-02f, -2.92528328e-02f, 1.17628142e-01f, 2.23262273e-02f,
  1.30649671e-01f, -6.35886788e-02f, 4.59872894e-02f, -1.80189893e-01f, -5.07621616e-02f, 1.46285981e-01f, -7.72825107e-02f, -1.74897313e-01f, 9.51784775e-02f, -1.05917782e-01f,
  1.29221097e-01f, -3.44386511e-03f, -8.09932798e-02f, -7.83314109e-02f, -6.99599758e-02f, -7.16807395e-02f, -1.10100649e-01f, -9.54333320e-02f, 2.79177260e-02f, 2.26020776e-02f,
  6.58411672e-03f, -1.93575054e-01f, -2.66155861e-02f, 1.39766196e-02f, 7.75759891e-02f, -6.49618357e-02f, -1.51786059e-02f, -6.08066581e-02f, -1.19877718e-01f, 1.40178040e-01f,
  -2.16652756e-04f, 5.61274216e-02f, -6.20188750e-02f, -7.95228407e-02f, 4.38590832e-02f, 1.65715329e-02f, 1.34231113e-02f, 7.88209513e-02f, -1.49232030e-01f, -3.11975479e-02f,
  1.42984334e-02f, 2.28813831e-02f, 5.88563420e-02f, -1.03661142e-01f, 1.13082916e-01f, 1.16832472e-01f, -5.48933335e-02f, -4.77524623e-02f, 5.12347259e-02f, 7.77141526e-02f,
  1.99209992e-02f, 1.15903147e-01f, 1.30918086e-01f, -1.91378102e-01f, 2.49577183e-02f, -3.13475057e-02f, 9.03449655e-02f, 5.80366142e-02f, 1.16747163e-01f, -7.96115026e-02f,
  -1.05808675e-02f, 1.53752208e-01f, 4.38237190e-02f, 1.69650659e-01f, 1.35172755e-01f, -2.63018042e-01f, -1.60545155e-01f, 8.13327953e-02f, 8.84449780e-02f, 1.01581030e-01f,
  1.50464907e-01f, -7.20476210e-02f, 2.60069996e-01f, -1.42454714e-01f, 6.37913793e-02f, -2.31403202e-01f, 5.74993016e-03f, -1.62685394e-01f, 1.68575361e-01f, 2.78335899e-01f,
  1.51276156e-01f, 1.06518604e-01f, 1.28520310e-01f, -1.68151617e-01f, -8.55692104e-02f, -2.70102054e-01f, 8.49979594e-02f, 2.18721986e-01f, -8.52375180e-02f, 5.63787073e-02f,
  1.40385166e-01f, 1.07976913e-01f, 2.08858233e-02f, -7.44760185e-02f, -2.29696487e-03f, 8.59806761e-02f, 1.64048709e-02f, 9.52320397e-02f, 2.63005495e-02f, 4.27580513e-02f,
  6.10375181e-02f, -3.63036394e-02f, -1.62901659e-03f, -1.15612529e-01f, -1.14714921e-01f, -7.24882036e-02f, -1.40142024e-01f, -1.32475346e-01f, -1.18503653e-01f, 2.59666979e-01f,
  2.41144672e-01f, 5.96455373e-02f, -1.35605689e-02f, -6.08245097e-02f, -6.37628883e-02f, 1.27843648e-01f, 1.30941823e-01f, -1.07477605e-01f, 7.74168894e-02f, 3.62207033e-02f,
  -1.52164072e-01f, 1.52036538e-02f, -1.44748807e-01f, 1.72016785e-01f, 1.28930762e-01f, -3.56375985e-02f, 1.21890210e-01f, -1.34083018e-01f, -1.58737544e-02f, 1.35783553e-01f,
  4.05902229e-02f, -7.16820508e-02f, -2.67099813e-02f, 1.46293387e-01f, -1.07490838e-01f, 1.45758614e-01f, 5.31654768e-02f, -1.35152653e-01f, -1.04978502e-01f, 8.00110996e-02f,
  1.65193692e-01f, -3.67043121e-03f, -3.13514061e-02f, -1.04881331e-01f, -6.47976473e-02f, 1.64438989e-02f, 1.17390767e-01f, 2.69418340e-02f, 1.18783034e-01f, 5.22188358e-02f,
  1.92412078e-01f, -3.76084307e-03f, 5.43967374e-02f, 2.40190372e-01f, -1.46074519e-01f, -5.65178767e-02f, -1.13104746e-01f, -2.68507041e-02f, -8.28469098e-02f, 2.40560416e-02f,
  3.44263725e-02f, 1.72388062e-01f, -8.57843906e-02f, 3.98588590e-02f, 2.14323506e-01f, -4.76957718e-03f, 1.20943546e-01f, 6.42232373e-02f, -2.70603672e-02f, -1.00391902e-01f,
  -1.54669136e-01f, -1.38201877e-01f, 1.06812036e-02f, 1.46277472e-01f, 9.78353992e-03f, 1.62602484e-01f, 2.25661173e-01f, 2.54627727e-02f, -4.13156748e-02f, 1.59261733e-01f,
  3.94189842e-02f, -2.66954582e-02f, 3.58620360e-02f, 1.01245068e-01f, 5.81268482e-02f, 3.79335582e-02f, -7.75505677e-02f, 1.15425043e-01f, -7.32613504e-02f, -7.50197992e-02f,
  2.26640880e-01f, -7.95088410e-02f, 3.14514428e-01f, -1.02085397e-01f, 9.45031526e-04f, -1.19339451e-01f, -3.15018557e-02f, 8.69684294e-02f, -1.03193477e-01f, -5.83988875e-02f,
  -5.36632016e-02f, 8.52891710e-03f, 7.03523979e-02f, 2.61976570e-01f, 7.25132823e-02f, 9.15854499e-02f, -7.95675591e-02f, -1.77600145e-01f, 7.94064626e-02f, -1.93992719e-01f,
  -9.66529399e-02f, 1.30589306e-01f, 2.21220136e-01f, -1.91070795e-01f, 1.10422842e-01f, -9.16048139e-03f, 1.65617511e-01f, 6.81454614e-02f, -1.35322630e-01f, -1.84864983e-01f,
  -1.26631096e-01f, 1.03116795e-01f, -6.38383105e-02f, -1.19436542e-02f, 5.52135967e-02f, 7.58176669e-02f, -2.11774483e-02f, 1.22966729e-01f, -3.63360643e-02f, -1.85840745e-02f,
  -3.34195830e-02f, -8.93546119e-02f, -2.41513606e-02f, 2.62882095e-02f, -2.01977089e-01f, 3.84172634e-03f, -9.35506448e-02f, 4.40911837e-02f, 1.38032511e-01f, -7.00642616e-02f,
  -1.81357525e-02f, -1.10854544e-01f, -9.05291736e-03f, 5.15420958e-02f, 7.18196481e-02f, 5.68274185e-02f, 1.29306987e-01f, 1.55284271e-01f, -9.70743522e-02f, 1.73773810e-01f,
  -2.23248437e-01f, 9.25757885e-02f, -2.92482879e-02f, 1.00762220e-02f, 1.48090944e-01f, 3.06304526e-02f, -1.56620756e-01f, 2.03883782e-01f, 1.24811769e-01f, -1.35221422e-01f,
  8.66035521e-02f, -2.90820990e-02f, -5.48082478e-02f, 6.83127567e-02f, -1.91593811e-01f, 5.14242686e-02f, -1.72772959e-01f, 1.83226734e-01f, 1.68530017e-01f, 1.45507053e-01f,
  -4.54860367e-03f, -2.26489589e-01f, -6.23244047e-02f, -3.57769392e-02f, 5.40684834e-02f, -4.35950756e-02f, 1.49733452e-02f, 2.09479436e-01f, 1.31958812e-01f, -1.94444284e-01f,
  4.74445857e-02f, -1.65935382e-02f, -6.09732643e-02f, 4.59182635e-02f, -3.64731848e-02f, -4.19973135e-02f, 2.17528977e-02f, -4.38475749e-03f, -7.90744945e-02f, -5.64083308e-02f,
  -6.85422421e-02f, -7.51392543e-03f, 2.31792331e-01f, 2.02353485e-03f, -1.58497114e-02f, 1.54552385e-01f, -3.50467861e-02f, 6.95135966e-02f, 4.88290414e-02f, 6.50904253e-02f,
  -5.37905376e-04f, -1.54793084e-01f, -1.20354638e-01f, 1.81475207e-01f, 1.55957878e-01f, 3.63680273e-02f, 9.23215300e-02f, 9.38848108e-02f, 8.67572874e-02f, -2.03377772e-02f,
  -1.70324787e-01f, 1.26379043e-01f, 2.08058223e-01f, 1.12584360e-01f, 5.48161715e-02f, 1.21161796e-01f, 5.39278165e-02f, 7.74868652e-02f, 2.78095186e-01f, -4.96879704e-02f,
  8.83908495e-02f, 9.05050803e-03f, -1.58172920e-01f, 8.17572847e-02f, -9.46043991e-03f, -1.20254576e-01f, -2.89439061e-03f, 1.22187480e-01f, -1.65270828e-02f, 1.30061835e-01f,
  5.19535504e-02f, 2.46785685e-01f, -1.16001301e-01f, 1.01008765e-01f, -6.95919544e-02f, 3.47009785e-02f, 1.68126047e-01f, -1.13110848e-01f, -1.40733868e-01f, 3.86667177e-02f,
  2.20177293e-01f, -3.53707783e-02f, -1.55340903e-03f, 8.66664201e-02f, -4.19876613e-02f, -3.02375983e-02f, 1.67987513e-04f, -1.29421934e-01f, -2.33488735e-02f, -1.04627214e-01f,
  1.31089360e-01f, -2.25216057e-02f, 1.12977117e-01f, 1.51133075e-01f, 4.87279519e-02f, 1.32505849e-01f, -6.10600896e-02f, -4.46782000e-02f, 4.43015015e-04f, -1.78124383e-01f,
  -4.00298089e-02f, -9.47295055e-02f, 2.67820992e-02f, 1.50407493e-01f, -4.77493033e-02f, 1.80151612e-01f, 1.97485089e-01f, -5.05898707e-02f, -9.89255831e-02f, -3.42567787e-02f,
  -6.62939698e-02f, 4.50501144e-02f, -2.34550070e-02f, 9.30188671e-02f, 2.22258776e-01f, -4.33107950e-02f, -9.05797109e-02f, 1.59290776e-01f, -7.89225325e-02f, 8.17320496e-02f,
  9.09099728e-02f, -7.01324791e-02f, -4.07349989e-02f, 1.94021225e-01f, 6.83022514e-02f, 1.73369661e-01f, 2.70428210e-01f, -9.81192067e-02f, 1.13628907e-02f, 7.58369341e-02f,
  -3.97189632e-02f, 1.04636878e-01f, 1.26172444e-02f, 1.07943647e-01f, -4.77774553e-02f, -4.72529307e-02f, 1.87095791e-01f, 1.68396890e-01f, 1.48602217e-01f, 1.17986407e-02f,
  -2.42749844e-02f, 1.18803248e-01f, 2.45723873e-01f, 7.91777372e-02f, 7.00062290e-02f, 2.29162365e-01f, 2.35387295e-01f, -1.87855773e-02f, 9.12512839e-02f, 7.01126009e-02f,
  1.28494382e-01f, 1.76778525e-01f, 5.24564274e-02f, -4.32127342e-02f, -5.41582406e-02f, -1.29629254e-01f, 4.31219712e-02f, 2.69073416e-02f, -6.02206290e-02f, 1.09411217e-01f,
  8.29648040e-03f, -8.62754416e-03f, -8.34887102e-02f, -1.06755465e-01f, 4.12945263e-02f, 1.61072776e-01f, -9.09195170e-02f, 5.83441965e-02f, 1.45690367e-01f, -1.88406911e-02f,
  -7.72148818e-02f, -1.91093400e-01f, -3.48899290e-02f, -6.69610649e-02f, -8.83389190e-02f, 1.87508166e-01f, -1.26201808e-01f, 6.67048693e-02f, -7.39003345e-02f, 1.20370366e-01f,
  2.19257306e-02f, 1.44854009e-01f, -7.67745301e-02f, -5.40833687e-03f, -3.75568867e-02f, 2.07397953e-01f, -5.76380901e-02f, 2.66281664e-01f, 1.61362849e-02f, -1.09451069e-02f,
  -1.45686558e-02f, -1.20272273e-02f, 2.56894469e-01f, -2.73717996e-02f, 1.16342850e-01f, -9.92166102e-02f, -1.62167903e-02f, 8.45668763e-02f, -1.44449845e-01f, -1.54825971e-01f,
  5.12807071e-02f, -3.70073020e-02f, 2.33621299e-01f, 6.32437989e-02f, 1.69793159e-01f, 3.07609867e-02f, 2.06510480e-02f, -1.17956489e-01f, -9.41078365e-03f, 3.21246795e-02f,
  2.00149223e-01f, -1.05160987e-03f, -5.13432287e-02f, 1.33899271e-01f, 2.24819303e-01f, 1.72273815e-01f, 5.45197502e-02f, -1.61318108e-01f, 1.12585396e-01f, 4.00315113e-02f,
  1.01979688e-01f, -3.15520056e-02f, 1.46032169e-01f, 1.60527483e-01f, -7.90790003e-03f, -7.43899401e-03f, 3.78501713e-02f, -2.63159037e-01f, -5.26755862e-02f, -2.54842460e-01f,
  3.03534288e-02f, 9.45899710e-02f, -5.44067807e-02f, 2.75866091e-01f, 2.32231542e-01f, -1.22532673e-01f, -1.46837130e-01f, 5.33082671e-02f, -9.98739302e-02f, 1.15912482e-01f,
  1.29000351e-01f, -8.48808289e-02f, 7.08260462e-02f, -1.97936192e-01f, 2.50377227e-03f, -4.18094173e-03f, 1.61522761e-01f, -5.73829822e-02f, 1.95376784e-01f, -8.30268264e-02f,
  -6.00385554e-02f, 1.25837654e-01f, 2.40410537e-01f, -1.59559563e-01f, 2.24996004e-02f, -8.08594599e-02f, -1.12634726e-01f, 1.77811801e-01f, 7.17590610e-03f, 8.61989055e-03f,
  7.99089223e-02f, -1.80069208e-02f, 3.94738950e-02f, -4.96056154e-02f, 2.22461894e-01f, -1.08674720e-01f, 9.03899148e-02f, 7.30703026e-02f, -3.10437363e-02f, 9.33309570e-02f,
  2.61112273e-01f, 4.23052460e-02f, -1.81914017e-01f, -1.29678436e-02f, 1.35606810e-01f, 5.50598539e-02f, 2.38538131e-01f, 1.42867178e-01f, -4.29501086e-02f, 2.20166326e-01f,
  -1.87645704e-01f, 1.39917240e-01f, -9.79110077e-02f, 7.90956151e-03f, -7.81403333e-02f, 3.01956385e-02f, -2.34235637e-02f, -8.27500746e-02f, -4.30194177e-02f, 1.50981927e-02f,
  -3.25625464e-02f, 3.26406024e-02f, -2.49309023e-03f, 2.22058937e-01f, -4.30897512e-02f, 1.09363869e-01f, 1.04074523e-01f, -1.42580092e-01f, -8.99226516e-02f, -2.47933026e-02f,
  1.92999318e-02f, -8.56959820e-02f, -2.05006227e-02f, 2.90837791e-02f, 3.84310409e-02f, -1.59952976e-02f, 3.26581503e-04f, 8.15653205e-02f, 1.02675306e-02f, 1.57154694e-01f,
  -5.83922528e-02f, -2.42451802e-02f, -1.08233720e-01f, 1.56954780e-01f, -7.53572881e-02f, -3.86432186e-02f, -2.45920300e-01f, 3.66397835e-02f, -2.49345764e-03f, 2.80915424e-02f,
  1.80401630e-03f, -1.39682129e-01f, 1.17584325e-01f, -2.10051835e-02f, -6.67264499e-03f, 3.47585492e-02f, 5.31056672e-02f, 1.30324379e-01f, 1.02827158e-02f, 3.96705568e-02f,
  2.16241330e-02f, -3.50127593e-02f, 1.37362361e-03f, 9.36418623e-02f, -7.88812712e-02f, 6.62784232e-03f, -7.27983192e-02f, 3.63186784e-02f, -2.13245377e-02f, -6.36389032e-02f,
  1.86634790e-02f, 2.40425132e-02f, 1.53026789e-01f, -6.68651462e-02f, 8.94393474e-02f, 1.18665941e-01f, -1.55111691e-02f, -5.80705404e-02f, 1.08423224e-02f, 7.61531442e-02f,
  9.18499604e-02f, -3.37859392e-02f, 3.37643884e-02f, 1.59460127e-01f, 1.01654166e-02f, -3.60387638e-02f, 1.00963742e-01f, -7.32839555e-02f, 8.39055851e-02f, 4.34643626e-02f,
  1.41443953e-01f, 1.00731052e-01f, -6.56533579e-04f, 5.66314608e-02f, -5.33178039e-02f, 1.43138826e-01f, -2.80286539e-02f, -5.82445897e-02f, 9.42643732e-02f, 1.23057899e-03f,
  1.13593020e-01f, -1.81092352e-01f, 8.25674459e-02f, -1.30902737e-01f, 2.72995591e-01f, -9.37064514e-02f, 1.16145961e-01f, -8.52969140e-02f, 9.81182009e-02f, 1.55990764e-01f,
  2.08739951e-01f, -2.14733824e-01f, -1.40619025e-01f, -2.00108532e-02f, 1.39872789e-01f, 1.38994053e-01f, 4.29553650e-02f, -3.21117230e-02f, 2.58190542e-01f, -3.47843801e-04f,
  6.16403818e-02f, -1.91240624e-01f, 1.42219858e-02f, -1.92634776e-01f, -2.22056918e-02f, 2.44756967e-01f, 1.00590801e-02f, -3.29650715e-02f, 1.52031243e-01f, 2.22626831e-02f,
  2.23030504e-02f, -1.99792817e-01f, 1.18369430e-01f, 8.01675767e-02f, -5.32044694e-02f, 4.71554734e-02f, 7.24709453e-03f, 1.26381800e-01f, -9.52825397e-02f, -2.80477498e-02f,
  7.59510696e-02f, 5.15760332e-02f, 2.71096434e-02f, 1.94714461e-02f, 8.44096765e-03f, 4.49914783e-02f, 9.61517841e-02f, -2.99449675e-02f, 3.66317555e-02f, -1.69730000e-02f,
  -6.05483279e-02f, 5.03878519e-02f, 1.73583388e-01f, 1.59366965e-01f, -8.73075128e-02f, 1.87402815e-01f, -2.08401610e-03f, 2.30810106e-01f, -5.28812855e-02f, 1.20641477e-02f,
  1.78897411e-01f, 3.35470252e-02f, 2.37409189e-01f, -1.36987763e-02f, -2.27463059e-02f, -1.37250766e-01f, 1.64248139e-01f, -1.02583639e-01f, -3.06491158e-03f, 1.21704385e-01f,
  2.03987840e-03f, -2.64151152e-02f, 1.85080022e-02f, -1.03568472e-01f, -6.54020235e-02f, -3.09243817e-02f, 6.01897128e-02f, 7.35253319e-02f, -1.00245290e-01f, 3.73079255e-02f,
  -1.60610065e-01f, -8.40090588e-02f, 1.10463709e-01f, 1.14025034e-01f, 3.12043637e-01f, 1.22212201e-01f, 9.14771333e-02f, -1.00817949e-01f, -4.45642136e-02f, -1.64099466e-02f,
  -1.84500188e-01f, 1.95624791e-02f, -1.11753277e-01f, 4.77894880e-02f, 1.91277955e-02f, -6.41029775e-02f, -2.27290452e-01f, -2.90573516e-04f, 2.82662004e-01f, -1.75103232e-01f,
  -5.66252768e-02f, -5.41855171e-02f, -1.25637837e-03f, 3.27696234e-01f, -4.84787207e-03f, -5.44626005e-02f, 1.22601420e-01f, -6.54969141e-02f, -3.62868533e-02f, -2.43009534e-02f,
  -5.45653291e-02f, 1.08414575e-01f, -2.24771146e-02f, 1.32455871e-01f, 1.86967149e-01f, 2.32309923e-02f, 1.17304713e-01f, 1.64264977e-01f, 7.72743821e-02f, -7.01790676e-02f,
  -1.03726253e-01f, -1.43751884e-02f, -1.36553906e-02f, 1.68191016e-01f, 6.56091049e-02f, -1.46865966e-02f, -1.15666583e-01f, 6.99657574e-03f, 3.45010534e-02f, 1.00751989e-01f,
  1.07348643e-01f, 1.32046282e-01f, 1.92022901e-02f, -6.07700460e-02f, 4.61192764e-02f, 1.12241469e-01f, 6.23583570e-02f, 1.03331663e-01f, -1.43057153e-01f, 2.55158208e-02f,
  -8.13390240e-02f, 1.65319443e-01f, 8.21701214e-02f, -5.99144213e-02f, 7.92841464e-02f, 2.09542185e-01f, 1.36685502e-02f, 1.01718090e-01f, -1.35016024e-01f, -8.13280493e-02f,
  1.73952077e-02f, 1.26422703e-01f, 1.32225469e-01f, -1.16217406e-02f, 5.36539480e-02f, 8.15057084e-02f, -3.72232236e-02f, -5.52284392e-03f, -1.07729293e-01f, 5.33381924e-02f,
  1.34434164e-01f, -1.94033701e-02f, -2.06671119e-01f, 1.39005166e-02f, 3.04893218e-02f, 1.72397405e-01f, 1.13676883e-01f, -2.37144813e-01f, -3.65304872e-02f, -5.63299507e-02f,
  3.48810330e-02f, -2.45116595e-02f, -1.13355651e-01f, -6.52828440e-02f, 1.66238651e-01f, -5.26174679e-02f, -8.19234774e-02f, 1.45817369e-01f, 8.77228156e-02f, 4.40795943e-02f,
  1.38203934e-01f, -5.58298193e-02f, -8.38989392e-02f, -8.20629597e-02f, -1.06578574e-01f, 2.06533581e-01f, 1.19098745e-01f, 2.27281004e-01f, 7.85583183e-02f, 7.73725659e-02f,
  1.13300852e-01f, -1.42981812e-01f, -2.04544500e-01f, 6.41600862e-02f, 2.18857571e-01f, 5.65524362e-02f, 4.02452722e-02f, 1.68954164e-01f, -2.51714736e-02f, 1.63374543e-01f,
  2.77138770e-01f, -5.90502955e-02f, 4.25097570e-02f, -1.94890834e-02f, -1.69349611e-01f, 9.73389000e-02f, 6.44849613e-02f, -4.63654548e-02f, 4.82144058e-02f, 4.50599827e-02f,
  3.74474078e-02f, -1.96487810e-02f, 6.42160773e-02f, 9.22341868e-02f, -1.41892835e-01f, -3.08555737e-02f, 6.14546658e-03f, -5.80831766e-02f, 7.41475299e-02f, -1.12904973e-01f,
  -1.02334239e-01f, 1.29705146e-01f, 1.25899687e-01f, -1.76862925e-01f, -1.54168695e-01f, 1.17155157e-01f, -8.25627297e-02f, 7.59005472e-02f, 8.13499615e-02f, 1.22533133e-02f,
  1.08600006e-01f, 3.80910411e-02f, 4.62478735e-02f, -5.59565127e-02f, 1.51484743e-01f, -3.17410007e-02f, 5.54084368e-02f, -3.53198089e-02f, -3.37860212e-02f, 2.52440143e-02f,
  -5.19688241e-02f, 1.12404399e-01f, 6.86049908e-02f, -2.95950249e-02f, -7.51022249e-02f, 7.79961199e-02f, 1.22890426e-02f, 5.88156991e-02f, -9.13358703e-02f, 5.76648861e-02f,
  2.24276679e-03f, 1.06761850e-01f, 1.20265797e-01f, 1.13177076e-02f, 6.26570731e-02f, 1.22582791e-02f, 7.85928667e-02f, 2.21867204e-01f, 8.31639171e-02f, 1.44265965e-01f,
  -9.63171944e-02f, 9.77792889e-02f, -2.16985829e-02f, -3.12699028e-03f, -1.07885376e-02f, -7.07404176e-03f, 4.05978337e-02f, 2.76937366e-01f, 1.15545489e-01f, 1.06103443e-01f,
  8.94189104e-02f, -2.96694115e-02f, 5.30688427e-02f, 2.15703294e-01f, -1.21041290e-01f, 1.83319509e-01f, -1.32058457e-01f, 1.14161447e-01f, 1.19426094e-01f, 2.03638285e-01f,
  7.74075277e-03f, -1.45108774e-01f, 5.63872606e-02f, 9.21643618e-03f, -1.74746402e-02f, 1.52290687e-01f, 3.96601446e-02f, 2.81203449e-01f, 2.04218626e-01f, -8.58368054e-02f,
  -1.49117976e-01f, -3.65966409e-02f, 8.56111795e-02f, -3.75898667e-02f, 6.51227683e-02f, -2.10943684e-01f, -5.23375943e-02f, 2.47255098e-02f, -2.26530656e-02f, -1.92568943e-01f,
  9.57586318e-02f, -1.59447733e-02f, -8.44151676e-02f, -3.81709859e-02f, -5.94683588e-02f, -1.38007119e-01f, -3.88905592e-02f, 2.60525919e-03f, -9.74696875e-02f, -1.42728925e-01f,
  -1.21129453e-01f, 1.17871739e-01f, 7.52225891e-02f, -3.75943817e-03f, -1.26022547e-01f, -6.02936819e-02f, -4.67246287e-02f, -8.46878439e-02f, -4.07850109e-02f, -4.93781231e-02f,
  1.03665724e-01f, 1.24142701e-02f, -6.33980101e-03f, 7.91356862e-02f, -1.39836743e-01f, 1.57968402e-01f, -1.37204751e-01f, 7.13676065e-02f, 5.49979210e-02f, 4.46732491e-02f,
  -7.20681399e-02f, 1.30729064e-01f, 2.69661359e-02f, -2.79448386e-02f, 4.36237045e-02f, 7.86544159e-02f, 3.06457523e-02f, 8.16476271e-02f, -4.93209511e-02f, -1.45254686e-01f,
  -1.62748992e-01f, 3.04845773e-04f, 5.19752465e-02f, 1.11986160e-01f, 1.10502712e-01f, -2.85709985e-02f, 2.53907982e-02f, 8.95811394e-02f, 1.67598695e-01f, 4.93177352e-03f,
  -5.65337623e-03f, 4.26151976e-02f, 9.46405828e-02f, -1.17207214e-01f, 5.41788563e-02f, 1.94125876e-01f, -2.14181039e-02f, 5.01779541e-02f, 1.65818701e-03f, -1.02580868e-01f,
  6.00466803e-02f, -3.57621606e-03f, 5.33233173e-02f, 3.55753824e-02f, 3.14422250e-02f, -4.49232906e-02f, 5.47326095e-02f, 2.11067069e-02f, 4.07993682e-02f, -4.24788073e-02f,
  8.31516162e-02f, -7.28428587e-02f, 8.28271210e-02f, 1.56774595e-02f, 2.23265309e-02f, 1.35938123e-01f, 2.10696012e-01f, 2.95468159e-02f, -3.78311947e-02f, 1.67483240e-01f,
  -2.85120849e-02f, 7.18938112e-02f, 1.70007318e-01f, -3.35800610e-02f, 1.34731382e-01f, -2.26280820e-02f, 1.01989701e-01f, 3.98523510e-02f, 1.43718421e-01f, 1.71395943e-01f,
  7.51578063e-02f, -1.00801513e-01f, 2.40422532e-01f, 1.04978003e-01f, 2.97957659e-01f, -8.54414608e-03f, -1.78056583e-02f, 2.32608225e-02f, 1.75874401e-02f, 1.36655137e-01f,
  -7.76557904e-03f, 4.82662320e-02f, 2.02367604e-01f, -1.19311430e-01f, -8.96637961e-02f, 8.16508606e-02f, 1.96514488e-03f, -2.83649145e-03f, -2.08944548e-02f, 1.41057879e-01f,
  5.34181530e-03f, 6.48015551e-03f, 9.81825292e-02f, -4.75049801e-02f, 2.41805632e-02f, -2.14601800e-01f, 1.76405177e-01f, 1.50764599e-01f, 7.50267580e-02f, 2.02508479e-01f,
  -5.99359870e-02f, 2.00675782e-02f, -1.02397777e-01f, -1.58149168e-01f, -6.62026405e-02f, -1.93008203e-02f, -7.17254728e-02f, -4.45852848e-03f, 1.18402801e-01f, -1.19847283e-01f,
  1.02550954e-01f, -2.44998722e-03f, -4.53638919e-02f, 6.23870157e-02f, -6.10802621e-02f, -5.82215656e-03f, -5.44762984e-02f, -2.35573307e-01f, -6.93199337e-02f, 4.24338281e-02f,
  5.64509444e-02f, -2.36359779e-02f, 4.16829810e-02f, 5.96856810e-02f, -7.72592351e-02f, -1.53052500e-02f, -2.73240749e-02f, -1.33946538e-01f, 2.90524550e-02f, -4.51450311e-02f,
  -3.48212980e-02f, -6.00485429e-02f, 3.70587967e-02f, 9.10375938e-02f, -1.15037858e-02f, -6.86756000e-02f, 1.34801850e-01f, 1.55948726e-02f, 9.11962911e-02f, -9.69188139e-02f,
  -1.97281018e-02f, -7.61564001e-02f, -1.17751129e-01f, 1.72357693e-01f, -7.47177079e-02f, -3.67081948e-02f, 1.05681285e-01f, -1.92752734e-01f, -9.35749039e-02f, -7.72520676e-02f,
  2.95461137e-02f, -1.15025118e-01f, -1.39877135e-02f, 8.76676291e-02f, -2.23405417e-02f, -1.09194487e-01f, 2.05937073e-01f, -5.42569049e-02f, 6.40280247e-02f, -1.28049627e-01f,
  8.80486891e-02f, -1.01848068e-02f, 2.51748078e-02f, 1.18268892e-01f, -1.35342672e-01f, 6.08041622e-02f, -1.21314101e-01f, -1.32471472e-01f, 3.46651860e-02f, -3.01909503e-02f,
  1.24631070e-01f, -6.62379619e-03f, 6.44809799e-03f, 1.01382673e-01f, -7.77887553e-02f, 1.27469808e-01f, 1.07055223e-02f, 2.67291851e-02f, 6.23995066e-02f, 1.02160022e-01f,
  -4.09815870e-02f, 1.34849221e-01f, 2.03138247e-01f, -1.05149068e-01f, -1.17108740e-01f, -1.77362904e-01f, -3.39299031e-02f, -1.07440367e-01f, -1.14484370e-01f, 1.27624691e-01f,
  -1.14158854e-01f, 7.38690570e-02f, 4.85420339e-02f, 1.74109474e-01f, 9.72452238e-02f, 9.51085389e-02f, 1.14019448e-02f, -1.32415503e-01f, 1.95075478e-02f, 1.03188641e-01f,
  -1.71069577e-01f, 6.16323836e-02f, 1.27699330e-01f, 6.80939900e-03f, 2.92460080e-02f, 1.05892457e-01f, 2.52666026e-01f, -1.24040633e-01f, 1.50501356e-01f, -9.30756480e-02f,
  2.94693410e-02f, 4.44637015e-02f, -1.58490345e-01f, 3.39556113e-02f, 3.48057802e-04f, 1.42941296e-01f, 1.76385522e-01f, -9.90623385e-02f, 8.05200487e-02f, 1.67056307e-01f,
  -1.18610471e-01f, 1.17311552e-02f, 8.40865169e-03f, 1.82489827e-02f, 4.48449366e-02f, 1.31701725e-02f, -1.30717129e-01f, -5.36730513e-02f, 1.35037005e-01f, 1.23989895e-01f,
  9.97229517e-02f, -1.53645575e-01f, 7.05882460e-02f, -3.25968526e-02f, 7.04184696e-02f, 2.28828758e-01f, -7.94604197e-02f, 1.30881757e-01f, -8.33361968e-03f, 1.06426977e-01f,
  1.21521905e-01f, 3.34248953e-02f, 1.67562570e-02f, -1.17231973e-01f, 1.00707248e-01f, 9.96656120e-02f, 1.87981017e-02f, 8.64557773e-02f, 8.39008167e-02f, 9.01916027e-02f,
  -1.25317514e-01f, -3.81981134e-02f, 1.23256154e-01f, 2.06666403e-02f, 9.58973169e-02f, 1.09197319e-01f, 2.05965880e-02f, 7.26411045e-02f, 4.38026106e-03f, -2.94304211e-02f,
  1.16288383e-02f, 2.85170227e-02f, 1.00037500e-01f, -1.71717070e-02f, 7.01374561e-02f, -4.46227454e-02f, 1.69897135e-02f, 1.12546384e-01f, 1.38788745e-01f, -5.90454005e-02f,
  6.76159514e-03f, 7.88090192e-03f, -6.35238318e-03f, 1.64305139e-02f, -5.19803017e-02f, 7.53282830e-02f, 8.46282244e-02f, 1.54963687e-01f, 1.77963346e-01f, 8.94466117e-02f,
  -7.36551881e-02f, -2.08539054e-01f, -7.05235079e-03f, 1.14122713e-02f, -9.07350481e-02f, 1.66575134e-01f, -4.01201732e-02f, 1.03855751e-01f, 1.22824207e-01f, -7.97677133e-03f,
  5.09497859e-02f, -1.96890011e-01f, -1.15156304e-02f, -4.59136888e-02f, 1.57952048e-02f, 1.55878797e-01f, -2.79339757e-02f, -8.44129696e-02f, 1.03417739e-01f, -3.33463016e-04f,
  2.81414520e-02f, -1.47223845e-01f, -1.70743316e-01f, 1.03745431e-01f, -3.96021977e-02f, 9.66023803e-02f, 1.39724508e-01f, 1.04666494e-01f, 9.39906910e-02f, 2.66948134e-01f,
  2.42538154e-02f, -9.55071114e-03f, -9.56394598e-02f, 1.06003143e-01f, -5.06747328e-02f, 7.74746714e-03f, -1.00102603e-01f, -7.65488744e-02f, -1.19472528e-03f, 1.22825749e-01f,
  1.21958710e-01f, 9.65425596e-02f, 1.00817524e-01f, 9.58173200e-02f, 7.18571469e-02f, -7.83815160e-02f, -2.45358478e-02f, 3.79166454e-02f, -1.97139919e-01f, -9.49415118e-02f,
  -1.29264399e-01f, 1.70506716e-01f, -4.68502864e-02f, 1.99748755e-01f, 2.86972448e-02f, -7.83169344e-02f, 4.74572070e-02f, 1.84849665e-01f, 4.86398637e-02f, 1.03613146e-01f,
  8.16540867e-02f, 1.00035489e-01f, -8.34786240e-03f, -2.38685794e-02f, 7.47095719e-02f, -2.89366860e-02f, -6.02002516e-02f, 1.47125363e-01f, -4.31484357e-02f, 3.85302817e-03f,
  -6.92985803e-02f, 1.48340300e-01f, 3.43676172e-02f, 1.16413971e-02f, 1.10917158e-01f, 1.83926169e-02f, 1.00230902e-01f, 8.06492418e-02f, 2.11277559e-01f, 1.04855262e-01f,
  2.89781410e-02f, 7.82441869e-02f, -6.81013241e-02f, 1.84809603e-02f, 3.79529744e-02f, 4.01713878e-05f, -3.26291360e-02f, -1.12381421e-01f, 1.45299137e-01f, -6.59551322e-02f,
  -1.20062418e-01f, -1.57446843e-02f, 4.72712964e-02f, 1.25857294e-01f, -1.49236947e-01f, 4.68858704e-02f, 7.28327259e-02f, 5.94716668e-02f, 7.98675120e-02f, 3.24068740e-02f,
  -2.14330037e-03f, -9.14673805e-02f, 6.49756864e-02f, -4.76484839e-03f, 1.49444968e-01f, -1.32958472e-01f, -4.61767204e-02f, -1.27823964e-01f, -5.96739575e-02f, 3.30338143e-02f,
  -4.84809689e-02f, -5.53183779e-02f, -1.95687339e-02f, -5.96515574e-02f, -1.66930676e-01f, 6.57691360e-02f, 1.32879376e-01f, -9.52640846e-02f, -2.07154423e-01f, 1.39881438e-02f,
  -1.16558462e-01f, -7.66090974e-02f, -6.21995889e-02f, 7.10069537e-02f, 1.24817409e-01f, 1.67542964e-01f, -2.61549931e-02f, 6.38071299e-02f, 2.50982679e-02f, 5.54431975e-02f,
  -2.11481303e-01f, 6.56008646e-02f, 4.47033085e-02f, -2.67944392e-02f, -3.01926881e-02f, 5.56460582e-02f, -7.72178322e-02f, -8.46766829e-02f, 1.35739088e-01f, 9.91669856e-03f,
  -8.23299512e-02f, 3.49475481e-02f, 6.99760159e-03f, 1.63345829e-01f, 1.18855704e-02f, -3.60128917e-02f, 1.80461735e-01f, -1.45313367e-01f, -3.23608471e-03f, -1.28204841e-03f,
  -1.85298070e-01f, 1.51899248e-01f, 2.11174116e-02f, 4.65369411e-02f, 1.68017268e-01f, 3.78706083e-02f, 1.92652404e-01f, 2.99430285e-02f, 5.95810972e-02f, -1.53131500e-01f,
  -8.52985606e-02f, 2.03668866e-02f, -5.40251732e-02f, 1.83753595e-01f, -8.17253590e-02f, -5.19799106e-02f, -1.25749946e-01f, 1.64778113e-01f, 1.31415144e-01f, 1.76236242e-01f,
  1.73849463e-01f, -5.69887348e-02f, 1.88061133e-01f, -1.72488973e-01f, 3.57894436e-03f, 7.25355446e-02f, -8.63029286e-02f, 2.96556894e-02f, 8.22426230e-02f, 5.66247068e-02f,
  -4.65508811e-02f, 2.71446735e-01f, 1.74254835e-01f, -9.64326039e-02f, 1.34206042e-01f, 1.18602358e-01f, -1.44340461e-02f, 2.11465567e-01f, -7.36827403e-02f, -1.92202210e-01f,
  3.66462208e-02f, 4.75444533e-02f, 2.20471203e-01f, 9.70299095e-02f, 4.24208753e-02f, 7.76428282e-02f, -9.81438756e-02f, -8.80963579e-02f, -7.59260505e-02f, 1.39246890e-02f,
  -4.00576368e-02f, 9.24868360e-02f, -7.47306645e-02f, -7.13289231e-02f, 2.60929558e-02f, 2.25775421e-01f, 1.58270672e-01f, -2.24235252e-01f, 5.32373674e-02f, 4.69321534e-02f,
  -4.86204997e-02f, 1.57450721e-01f, -2.81496532e-03f, 1.64943784e-01f, 1.61452204e-01f, 2.81721931e-02f, -6.16675094e-02f, -5.57907745e-02f, 3.44871655e-02f, -6.83064684e-02f,
  1.90674275e-01f, 1.07891813e-01f, -3.57528552e-02f, 1.44524381e-01f, -3.44912261e-02f, 4.06946503e-02f, -1.89509079e-01f, 7.44387880e-02f, -5.41131198e-03f, -2.82634161e-02f,
  1.29220277e-01f, -5.63031770e-02f, 1.23248190e-01f, -7.43161812e-02f, 2.07337011e-02f, -3.08925752e-02f, 2.96962149e-02f, -2.89365668e-02f, 1.63837537e-01f, -5.55309951e-02f,
  9.98771191e-02f, -2.81076487e-02f, -1.30529776e-02f, -1.20933056e-01f, 1.59470111e-01f, 1.51154608e-01f, -9.81588215e-02f, 1.10540487e-01f, 1.12143159e-02f, -9.60792005e-02f,
  1.40861392e-01f, 8.93487856e-02f, 1.79379404e-01f, -1.58522218e-01f, 4.73501198e-02f, -1.25344887e-01f, 7.68667236e-02f, -1.81157496e-02f, -6.77309707e-02f, -6.25809804e-02f,
  2.88634095e-02f, 9.82425921e-03f, -7.62711465e-02f, 2.10448354e-02f, -1.04325339e-01f, 5.85430264e-02f, 2.97791306e-02f, -4.96048443e-02f, -7.76332617e-02f, 8.05880129e-02f,
  7.12573947e-03f, 1.78637236e-01f, -1.05424505e-02f, 6.58553317e-02f, -1.41483406e-02f, 3.40767279e-02f, 1.23626411e-01f, -2.57829595e-02f, 1.49560764e-01f, 1.01500817e-01f,
  -4.29067910e-02f, 2.50126034e-01f, 7.40508437e-02f, -3.29108089e-02f, -8.15280452e-02f, -1.31078839e-01f, 5.66474609e-02f, 2.36393474e-02f, 1.27530023e-01f, 3.60606238e-02f,
  1.45765617e-01f, 2.18783438e-01f, -8.75744224e-02f, 4.78019589e-04f, -3.30306888e-02f, -1.53028056e-01f, -2.64326874e-02f, 1.43104017e-01f, 1.24478079e-01f, -8.66560042e-02f,
  8.53139162e-02f, -9.48083214e-03f, 7.93873593e-02f, -3.74404490e-02f, 1.79412425e-01f, -9.05894637e-02f, 1.88749477e-01f, -1.01200819e-01f, -1.35767907e-01f, 2.67722830e-02f,
  5.41824363e-02f, 8.04704502e-02f, 1.19758733e-02f, 9.21614282e-03f, 7.54327402e-02f, -9.32770669e-02f, 2.08976632e-03f, 4.00505401e-02f, -5.61991222e-02f, -1.89432297e-02f,
  8.47159773e-02f, 1.67660460e-01f, 1.81683436e-01f, -6.04685396e-02f, 2.33060680e-02f, 9.75310430e-02f, 2.41503626e-01f, -2.11929858e-01f, 1.82545722e-01f, 1.74767226e-01f,
  -5.18064201e-02f, 1.85335681e-01f, -6.12759264e-03f, 2.89516877e-02f, -5.95348626e-02f, -1.71218380e-01f, 1.21674933e-01f, 1.06129341e-01f, 8.63713920e-02f, 1.55396685e-01f,
  -1.89590491e-02f, -4.82296757e-02f, -1.85474604e-01f, 6.52685314e-02f, 1.03959672e-01f, -9.84741002e-02f, 5.39846122e-02f, -3.11676189e-02f, 1.03039525e-01f, 2.93351799e-01f,
  -9.74452272e-02f, 1.86451003e-01f, 2.16352791e-01f, 7.80892224e-05f, -1.47223160e-01f, 6.72661290e-02f, -3.76949385e-02f, -1.00865252e-01f, 1.23030022e-01f, 9.97597873e-02f,
  2.82333434e-01f, -1.25284672e-01f, -1.22324461e-02f, 3.58628109e-02f, 1.15438335e-01f, -3.95714827e-02f, 1.07533760e-01f, -4.95189652e-02f, -8.50516409e-02f, -2.02018097e-01f,
  -9.53446850e-02f, 1.64161757e-01f, 2.09245488e-01f, 1.65020581e-02f, -3.86030748e-02f, 1.41394481e-01f, -8.41891393e-02f, 2.25571319e-01f, 3.94562036e-02f, 2.94492971e-02f,
  1.89982370e-01f, 3.24180759e-02f, 1.42820477e-01f, -1.33426078e-02f, -8.41229632e-02f, -2.83806920e-02f, -2.27486596e-01f, 2.37949431e-01f, -4.46199253e-03f, 8.08781385e-02f,
  -1.09464861e-01f, 1.35189161e-01f, -2.92686988e-02f, 2.90631619e-03f, 9.37278271e-02f, -3.39958584e-04f, -1.01399943e-01f, 1.21165112e-01f, 6.32810816e-02f, 1.99569419e-01f,
  4.28643823e-02f, 7.82002732e-02f, -6.53053001e-02f, -1.35847665e-02f, -5.79258986e-02f, -2.35149711e-02f, 1.12279110e-01f, -5.80100901e-02f, -1.93587765e-01f, 8.84258524e-02f,
  1.04427502e-01f, 9.59481448e-02f, 4.05106321e-02f, -4.69073951e-02f, 2.88860835e-02f, 9.87200812e-02f, 4.44457754e-02f, 1.37534261e-01f, 1.01346098e-01f, 9.87700894e-02f,
  1.11014530e-01f, 3.20742745e-03f, 6.91345260e-02f, -1.88278690e-01f, -4.21343632e-02f, 4.89822403e-02f, 1.18120737e-01f, 1.68994963e-01f, 3.79149802e-02f, 1.49299324e-01f,
  5.94767109e-02f, 2.34551132e-01f, 1.30467981e-01f, -7.92017505e-02f, -3.17044109e-01f, -1.36759713e-01f, -5.03085926e-02f, 7.84954354e-02f, 1.13108389e-01f, 8.48990306e-02f,
  1.02929860e-01f, 6.86199814e-02f, 2.69952178e-01f, -1.15632325e-01f, -8.95524472e-02f, -2.04649076e-01f, -9.86973196e-03f, -6.87094703e-02f, 1.54757380e-01f, 1.06737688e-01f,
  -1.72344800e-02f, 8.38933699e-03f, 2.21224073e-02f, -2.58763018e-03f, -8.77400041e-02f, -8.42212215e-02f, -8.32353011e-02f, 5.77160269e-02f, 3.56369168e-02f, 2.26493284e-01f,
  1.52829975e-01f, 1.27887398e-01f, 1.18531905e-01f, -1.01585962e-01f, 3.64443511e-02f, 2.46512704e-04f, 6.75936863e-02f, -6.24083057e-02f, 4.12562164e-03f, -3.30356625e-03f,
  6.92997426e-02f, 2.58123185e-02f, 6.57812133e-02f, 3.28848362e-02f, 7.30304122e-02f, -2.34444179e-02f, 2.03896984e-01f, 1.33589447e-01f, -3.69482040e-02f, -3.39849815e-02f,
  1.14789810e-02f, 2.25799412e-01f, 1.71438813e-01f, 1.09503254e-01f, 1.18369348e-01f, -3.16261314e-03f, 4.91736829e-02f, -9.43473633e-03f, -7.97983184e-02f, -2.93391454e-03f,
  1.26255244e-01f, -1.23524934e-01f, 5.12532368e-02f, 9.83673334e-02f, -5.16338497e-02f, -2.98257563e-02f, 1.21206127e-01f, 7.34743942e-03f, 1.03317618e-01f, 2.05054227e-02f,
  -1.97168440e-02f, 6.22921716e-03f, -1.20918140e-01f, 1.90786198e-02f, -9.29384083e-02f, -6.26923367e-02f, -3.12659666e-02f, -3.30446437e-02f, 1.99597299e-01f, 1.35727271e-01f,
  -9.56138894e-02f, -2.14880612e-02f, 2.06489000e-03f, 4.20609824e-02f, -1.24322370e-01f, -5.62278144e-02f, -3.83818932e-02f, 1.13354713e-01f, 1.22422650e-01f, -8.28511044e-02f,
  -8.15480649e-02f, 1.15999179e-02f, 1.47367567e-01f, -1.19515449e-01f, -6.84583187e-02f, 8.12372491e-02f, -1.42260613e-02f, 1.30027354e-01f, -1.25612170e-01f, -6.60185749e-03f,
  7.88893476e-02f, 1.25971353e-02f, -1.10840209e-01f, 3.31515335e-02f, 6.04351535e-02f, 6.10334352e-02f, 1.46969669e-02f, 7.15774372e-02f, 8.67964923e-02f, 1.43316492e-01f,
  7.73565248e-02f, 3.42086842e-03f, -3.39244157e-02f, -2.07922339e-01f, -2.31507957e-01f, 2.12799236e-01f, 1.74519032e-01f, 1.91797227e-01f, 2.56462485e-01f, 1.20760374e-01f,
  -5.01506254e-02f, 2.03427225e-01f, -1.31893083e-01f, 3.36487330e-02f, 7.10775852e-02f, -6.72757700e-02f, 4.57198471e-02f, -5.57678146e-03f, -8.10271222e-03f, 5.80923818e-02f,
  1.17844269e-01f, 4.51261327e-02f, 3.24978456e-02f, 3.09729371e-02f, 6.59315214e-02f, 2.01387882e-01f, 5.67594096e-02f, -1.95120856e-01f, 7.94508085e-02f, -6.37332490e-03f,
  -4.87618074e-02f, 1.76362321e-01f, 1.02954403e-01f, 1.45876274e-01f, -1.14312664e-01f, 1.39966642e-03f, 7.52560496e-02f, -8.22233930e-02f, 1.05279952e-01f, -1.13578714e-01f,
  -1.20261416e-01f, 1.49869248e-01f, 1.79455414e-01f, 2.66153589e-02f, -1.59479026e-02f, 8.30774605e-02f, 4.75287624e-02f, -2.22007379e-01f, 6.60725832e-02f, -3.73218954e-02f,
  1.88299954e-01f, 1.03357613e-01f, 4.78131324e-02f, 1.00647070e-01f, 1.26113102e-01f, -1.90764833e-02f, -8.10693279e-02f, -6.88032284e-02f, -9.71162990e-02f, -6.54012263e-02f,
  8.02802593e-02f, -7.87013303e-03f, -1.96712706e-02f, -9.11005065e-02f, 1.31071154e-02f, 1.03693202e-01f, -8.66226107e-02f, 1.95829794e-01f, 1.24246992e-01f, 5.47340512e-02f,
  1.66853089e-02f, -4.09236597e-03f, 3.56340967e-02f, 7.22791180e-02f, 1.00620836e-01f, -2.67541185e-02f, 4.56186123e-02f, 4.86342125e-02f, -7.39000291e-02f, 6.29652590e-02f,
  -7.91170299e-02f, 1.91055253e-01f, -6.17779829e-02f, -3.47298644e-02f, 1.37385488e-01f, -1.12681128e-01f, -6.38387203e-02f, 2.37382293e-01f, -2.15017684e-02f, 1.08068148e-02f,
  -3.72218192e-02f, -2.30193511e-02f, -1.15579307e-01f, 2.32093826e-01f, -4.91293892e-02f, 6.40085116e-02f, 4.59066294e-02f, 1.16896659e-01f, 1.82604894e-01f, 4.82955277e-02f,
  -8.15397575e-02f, -7.77608305e-02f, -1.27524883e-01f, 2.48189345e-02f, 9.68841184e-03f, 2.36363299e-02f, 5.61164916e-02f, 1.72661573e-01f, 3.49333063e-02f, -4.92733307e-02f,
  6.41475767e-02f, 1.48171902e-01f, -1.05222128e-01f, 5.01821972e-02f, 5.40646352e-02f, -2.69900169e-02f, 1.14815846e-01f, 3.85812037e-02f, 1.38897240e-01f, -9.74596068e-02f,
  1.57842785e-02f, 1.05527453e-01f, 1.62986852e-03f, -6.43770546e-02f, 1.10239334e-01f, -1.96490139e-02f, 7.83127993e-02f, -4.27356735e-02f, 1.99395925e-01f, 9.38755870e-02f,
  -4.07192297e-02f, -1.21619485e-01f, -1.05392292e-01f, 1.26188442e-01f, 1.19127333e-01f, 1.84773415e-01f, 1.54321596e-01f, -1.50225192e-01f, -2.03167778e-02f, 1.02019094e-01f,
  -5.44026271e-02f, -1.47018790e-01f, 1.96310744e-01f, -2.55110741e-01f, 1.48430631e-01f, -6.65969253e-02f, 1.04599901e-01f, -7.39517212e-02f, 6.07296266e-02f, -1.49748363e-02f,
  1.34975210e-01f, -1.46092653e-01f, -5.54320067e-02f, 1.10112093e-01f, -1.57647714e-01f, -6.49851840e-03f, -3.32998186e-02f, 3.18548307e-02f, 3.20943482e-02f, -4.32949699e-02f,
  1.98956639e-01f, 2.61707474e-02f, -4.02038768e-02f, -1.17827706e-01f, 3.13294269e-02f, 1.56827807e-01f, -7.97155350e-02f, 9.06289816e-02f, -7.37628862e-02f, 3.35516632e-02f,
  5.25464118e-02f, -1.91588581e-01f, -8.92179087e-02f, 5.52069098e-02f, 6.04241341e-02f, -1.91161364e-01f, -1.54722601e-01f, 1.60837457e-01f, -6.20323047e-02f, 4.99568880e-02f,
  1.29817620e-01f, 9.01238173e-02f, 6.11583441e-02f, 1.04509041e-01f, 6.71302527e-02f, 1.66132495e-01f, 1.39468879e-01f, -1.72167540e-01f, 2.31788997e-02f, -3.01303595e-01f,
  -1.81944773e-01f, -1.46387175e-01f, 3.77127081e-02f, 1.84018146e-02f, -6.09987676e-02f, 2.57768910e-02f, 1.90178320e-01f, -1.08127922e-01f, -8.76726285e-02f, 7.54899532e-02f,
  -1.63184042e-04f, 1.22406363e-01f, 1.29746243e-01f, -5.75544462e-02f, -3.29536721e-02f, -1.70572832e-01f, -1.42740726e-01f, -9.33154151e-02f, -9.09006372e-02f, 5.42676412e-02f,
  1.62466839e-01f, -4.91619743e-02f, 3.49073447e-02f, -2.15676799e-02f, -1.09743755e-02f, -7.65534937e-02f, 1.53925061e-01f, -1.23112515e-01f, -6.76096231e-02f, 2.02262834e-01f,
  -7.51623362e-02f, -7.97093287e-02f, 9.65034887e-02f, -1.41606390e-01f, 7.33993649e-02f, 4.80208434e-02f, 1.12623706e-01f, -7.57789612e-02f, -1.13292947e-01f, 7.30502559e-03f,
  -8.76894742e-02f, 5.77325374e-03f, 7.12601170e-02f, 4.61890176e-02f, 5.09438813e-02f, 4.65967432e-02f, -1.08534120e-01f, 6.79280784e-04f, 1.83769330e-01f, 4.49329875e-02f,
  -1.78920090e-01f, 7.80907646e-02f, -1.98836744e-01f, 1.81154922e-01f, 6.59542680e-02f, 1.07989609e-01f, 6.21718541e-02f, 8.60342905e-02f, 4.92260307e-02f, 7.10166176e-04f,
  1.38530999e-01f, -7.62392506e-02f, 4.81074937e-02f, 1.54179797e-01f, 2.09676921e-02f, 1.45041738e-02f, 7.16959639e-03f, -1.10016420e-01f, 4.96505946e-02f, 5.64191714e-02f,
  5.80179580e-02f, 8.16633329e-02f, 1.50958776e-01f, 1.57964930e-01f, 1.91384461e-02f, 6.15498833e-02f, 4.17954661e-02f, -1.58004209e-01f, -1.71352550e-01f, 1.85721055e-01f,
  1.40886039e-01f, 5.53973764e-02f, 3.21115479e-02f, 1.61691055e-01f, 9.40843597e-02f, 2.15284601e-01f, 2.27798596e-01f, -1.28780916e-01f, 2.74124090e-02f, -1.31543204e-01f,
  -8.08238909e-02f, 7.46251121e-02f, 1.23685591e-01f, 6.99673593e-02f, 1.24985516e-01f, 3.07638589e-02f, -4.43288423e-02f, -5.97831756e-02f, -3.06417271e-02f, 1.16121143e-01f,
  -5.72258122e-02f, 9.85119492e-02f, -1.86209641e-02f, -1.43902346e-01f, 1.66268498e-01f, 5.42068109e-02f, -1.83199048e-01f, 8.27764943e-02f, 2.22864151e-01f, -2.40098491e-01f,
  2.99588847e-03f, 1.77701399e-01f, -2.90308483e-02f, 8.46810490e-02f, 1.26231745e-01f, -5.38486391e-02f, 2.50616074e-02f, 8.31923739e-04f, -8.41254219e-02f, -3.68251652e-02f,
  3.39359380e-02f, -5.89521900e-02f, 1.08068161e-01f, -5.47264107e-02f, -1.39124990e-01f, -1.17503172e-02f, -8.90000015e-02f, -1.00029074e-02f, 5.18949404e-02f, 1.69935469e-02f,
  -5.45234643e-02f, -5.59461210e-03f, 1.67312190e-01f, 3.63755897e-02f, 4.19936329e-03f, -8.00151080e-02f, -1.51651278e-01f, 6.57513738e-03f, -2.23963544e-01f, -1.48402024e-02f,
  4.78267018e-03f, -2.26881076e-02f, 9.67068747e-02f, -2.37965882e-02f, 6.59596398e-02f, 4.96721901e-02f, 1.72070622e-01f, -1.28203988e-01f, 1.00751244e-03f, 2.52116583e-02f,
  -2.15429857e-01f, 8.53826180e-02f, 4.91695888e-02f, -9.61940736e-02f, -5.43382727e-02f, -2.93388702e-02f, 1.35085778e-03f, 4.98505384e-02f, 5.04412018e-02f, -5.24427332e-02f,
  5.80327362e-02f, -3.24563980e-02f, -1.05247669e-01f, -2.55172312e-01f, -6.60575703e-02f, -6.69177026e-02f, 2.19381049e-01f, 1.40240923e-01f, 4.65859920e-02f, 1.45087555e-01f,
  6.41073510e-02f, -2.36172602e-01f, -1.37264758e-01f, -8.99705514e-02f, 2.19538882e-02f, 1.64471000e-01f, 7.13548809e-02f, 9.17185694e-02f, 1.36033714e-01f, 2.18609825e-01f,
  7.06683397e-02f, -6.42808154e-02f, -4.25583869e-02f, -2.58356221e-02f, -1.02084406e-01f, -3.01834429e-03f, 8.18405580e-03f, -1.20409213e-01f, 5.11487760e-02f, 6.69802958e-03f,
  -8.68118703e-02f, 7.66253546e-02f, -7.23979026e-02f, -5.96682504e-02f, -1.75108880e-01f, -5.30140325e-02f, 1.20470356e-02f, 1.00327782e-01f, 1.81090564e-01f, -4.64752540e-02f,
  7.51091167e-02f, -6.20020879e-03f, -4.22734022e-02f, 1.11630574e-01f, 6.11776374e-02f, -1.51077509e-01f, -3.81729342e-02f, -3.28061334e-03f, -1.36626408e-01f, 3.01234990e-01f,
  -2.11285114e-01f, 1.99293762e-01f, -1.11051232e-01f, 7.54669011e-02f, 8.30743983e-02f, -1.42865712e-02f, -7.92460814e-02f, 1.49553388e-01f, -9.07742325e-03f, -1.11218482e-01f,
  -5.77994622e-02f, 1.51326852e-02f, -2.45201457e-02f, 2.16418356e-01f, 9.61984843e-02f, -1.50457257e-02f, -2.21161962e-01f, 7.74762258e-02f, 1.04976080e-01f, -1.90286320e-02f,
  -5.29555529e-02f, -3.48248668e-02f, 8.93159062e-02f, 1.45733869e-02f, 1.08782865e-01f, -7.72036985e-02f, 6.62438273e-02f, 1.87240131e-02f, 1.73973694e-01f, -3.14810611e-02f,
  5.50568216e-02f, 2.71593422e-01f, -6.29777263e-04f, -9.64017957e-02f, 5.41442968e-02f, -1.29539981e-01f, -9.21147540e-02f, -7.55758137e-02f, -1.16643392e-01f, -1.41901597e-01f,
  -5.73170781e-02f, -1.19899325e-01f, 2.50519011e-02f, -2.28723586e-02f, -4.95546609e-02f, 1.23937309e-01f, -3.30675952e-02f, 4.26326022e-02f, -1.38195559e-01f, -1.00026511e-01f,
  -7.10328296e-02f, -1.29221737e-01f, -4.26598080e-02f, 1.67782873e-01f, 1.94622681e-01f, 3.56032662e-02f, 1.41117245e-01f, 5.99585213e-02f, 3.89912538e-02f, 1.19233482e-01f,
  -6.81338906e-02f, 6.31386116e-02f, 1.02318853e-01f, -6.56754896e-02f, -1.98267952e-01f, 1.80226624e-01f, -1.24823548e-01f, -6.70276135e-02f, 9.43969563e-02f, -5.33781014e-02f,
  -5.25305495e-02f, 2.66200453e-02f, 3.18210535e-02f, -9.61758196e-02f, -1.23122036e-01f, -1.42726168e-01f, -1.12008758e-01f, -7.14073330e-03f, -1.24750406e-01f, 1.22154489e-01f,
  6.94606900e-02f, 2.68684149e-01f, -1.89869814e-02f, 6.45886958e-02f, -1.75590247e-01f, 8.19568262e-02f, -3.54826041e-02f, -1.12513110e-01f, -5.55751510e-02f, 5.00917397e-02f,
  9.16379914e-02f, -1.05695594e-02f, 2.21462268e-02f, -7.90156201e-02f, 4.42169905e-02f, -6.06762469e-02f, -2.91780476e-02f, -2.24706456e-01f, 6.19648956e-02f, 7.94466734e-02f,
  4.31046938e-05f, -8.05131253e-03f, -3.75118367e-02f, -4.33366839e-03f, 9.96944085e-02f, 1.11404419e-01f, -2.05185777e-03f, 1.90669581e-01f, -2.54940465e-02f, 2.67777796e-04f,
  -6.71487451e-02f, 1.80109307e-01f, -8.67440086e-03f, 1.76112071e-01f, 1.61268413e-01f, -2.00114012e-01f, -5.17915636e-02f, 6.88700527e-02f, 1.14529029e-01f, -2.27184240e-02f,
  1.20969720e-01f, 2.75420002e-03f, 6.51210099e-02f, 2.16953054e-01f, 2.73943245e-02f, 7.45415539e-02f, -1.27564427e-02f, -8.09931457e-02f, 1.39036030e-01f, -8.77488554e-02f,
  -2.05073953e-02f, -5.06512597e-02f, -9.29770470e-02f, 1.20017432e-01f, 1.43675447e-01f, -1.72661655e-02f, 7.23173320e-02f, 3.99598591e-02f, 1.91943586e-01f, -9.99797806e-02f,
  2.68752910e-02f, -1.87312558e-01f, -3.96656245e-02f, 2.43073821e-01f, 1.93046540e-01f, 1.70402646e-01f, -1.19164273e-01f, 5.79983369e-02f, 7.52676353e-02f, 1.15982614e-01f,
  4.09664176e-02f, -7.92262552e-04f, -2.81471964e-02f, 1.07170813e-01f, 7.15456903e-02f, -3.90330539e-03f, 3.40085737e-02f, -1.80759898e-03f, -3.18565741e-02f, -2.81938761e-01f,
  7.08012655e-02f, -6.00782782e-02f, -2.33495492e-03f, 2.01250777e-01f, 2.73042321e-02f, 1.15884878e-01f, -1.42855262e-02f, 1.42317042e-01f, -5.49951149e-03f, 8.35964233e-02f,
  2.93272398e-02f, -1.05168581e-01f, -2.79457271e-02f, -1.35538191e-01f, -5.83218448e-02f, -2.43891925e-02f, -1.93140972e-02f, 5.10218814e-02f, -1.72045499e-01f, 1.82690978e-01f,
  1.52198255e-01f, -5.07542118e-02f, 5.99150546e-02f, -1.25878915e-01f, -7.56358076e-03f, 1.71555012e-01f, 2.05192015e-01f, -8.07018392e-03f, 2.12965220e-01f, 1.41621783e-01f,
  -1.95282876e-01f, 1.76272213e-01f, -2.20651045e-01f, 2.27087095e-01f, -5.47301807e-02f, -7.42899999e-02f, 5.20586260e-02f, 3.22352871e-02f, -2.42086545e-01f, 2.24020481e-01f,
  2.49166355e-01f, -1.14198178e-01f, -7.06096590e-02f, 4.69554309e-03f, -6.17390573e-02f, 1.98759496e-01f, -8.79815873e-03f, 1.45510780e-02f, -6.11455776e-02f, 1.91409290e-01f,
  2.72297800e-01f, 1.34928346e-01f, -7.07144588e-02f, -1.95578605e-01f, -1.19463913e-01f, 7.05250204e-02f, 6.77114278e-02f, 1.45145744e-01f, 7.60961547e-02f, 3.15494746e-01f,
  7.80306458e-02f, -2.15188622e-01f, 1.44491404e-01f, 4.60585542e-02f, -6.52098432e-02f, -3.19112949e-02f, -2.49445830e-02f, 2.57519204e-02f, -1.73564767e-03f, -7.79098272e-02f,
  -3.15285660e-02f, 1.92874834e-01f, -1.04466472e-02f, 2.79211011e-02f, -4.98529673e-02f, 2.50327345e-02f, 1.46110862e-01f, -8.84956047e-02f, -8.18921924e-02f, 5.90322353e-03f,
  2.26229168e-02f, 1.24462269e-01f, 2.44248984e-03f, 4.04269956e-02f, 1.31946668e-01f, 3.01957056e-02f, -6.09482266e-02f, -1.03069261e-01f, 9.06687928e-04f, -1.60571057e-02f,
  -2.00008396e-02f, 9.08889323e-02f, 7.92520717e-02f, -1.41467839e-01f, -4.52580191e-02f, -4.32677567e-02f, 2.98072621e-02f, -7.70606175e-02f, 2.73609944e-02f, -2.29541268e-02f,
  4.59116092e-03f, -7.87784159e-02f, -7.10774586e-02f, 6.86158389e-02f, 1.09081000e-01f, -1.66213602e-01f, -1.07819475e-01f, 9.02099758e-02f, -9.49596167e-02f, -1.01921335e-01f,
  1.99031662e-02f, 9.58823189e-02f, 2.17667863e-01f, 1.91812143e-01f, 6.23744801e-02f, 4.41778600e-02f, -6.28211126e-02f, -7.35232383e-02f, -1.66559115e-01f, 2.90001296e-02f,
  -1.00793941e-02f, -7.98682570e-02f, -7.02035129e-02f, 5.41961417e-02f, -4.34854552e-02f, -1.21973015e-01f, 2.41804749e-01f, -1.70519024e-01f, 2.21218541e-03f, -2.19074283e-02f,
  3.68684307e-02f, 2.81094939e-01f, 6.64507747e-02f, 9.01371613e-02f, 1.09640852e-01f, -1.25561073e-01f, -4.43678349e-02f, -4.43296246e-02f, -1.24764219e-01f, 1.77841634e-02f,
  2.51801834e-02f, 5.38374484e-03f, 1.05925649e-01f, -7.11237118e-02f, 1.57347739e-01f, 2.05542222e-01f, -3.87025028e-02f, 3.55357639e-02f, -2.13805307e-02f, 1.98370099e-01f,
  7.64553249e-02f, 1.71360880e-01f, 1.05594628e-01f, -1.58594429e-01f, 2.60658469e-02f, -8.99964012e-03f, -8.20629299e-03f, 1.38121322e-02f, 1.77283138e-01f, -2.61996180e-01f,
  1.72241122e-01f, -1.35510355e-01f, 1.66363999e-01f, -4.87940237e-02f, -9.27304178e-02f, -1.11779265e-01f, 1.41480595e-01f, -1.26061931e-01f, -1.35647744e-01f, 9.62916464e-02f,
  -1.13463499e-01f, 2.95278076e-02f, -2.81640273e-02f, -3.77940722e-02f, 1.48743810e-02f, 1.53677352e-02f, 1.60992876e-01f, -6.28336594e-02f, -1.33942306e-01f, 2.73061506e-02f,
  4.23313044e-02f, 1.84614867e-01f, -3.29363123e-02f, 8.43842924e-02f, -7.84248039e-02f, 9.55762118e-02f, -7.11011738e-02f, -1.24999046e-01f, -1.74194843e-01f, 1.21059343e-01f,
  2.86013279e-02f, -1.76999748e-01f, -8.23859200e-02f, 5.04849851e-03f, -3.72037366e-02f, 5.11646755e-02f, 8.33400488e-02f, 1.03353277e-01f, 4.87000309e-02f, 1.19142167e-01f,
  6.61783814e-02f, -1.08530737e-01f, 2.33930014e-02f, 9.38884616e-02f, 3.90656851e-02f, 7.54110813e-02f, 8.18995908e-02f, -8.74806121e-02f, 3.75667913e-03f, 1.18788563e-01f,
  8.24750066e-02f, 1.14040673e-01f, 1.51546985e-01f, -6.90868571e-02f, 5.28403372e-02f, 2.22146109e-01f, -1.45217896e-01f, 5.06833494e-02f, -5.36930412e-02f, 7.37691997e-04f,
  -6.60144910e-03f, -2.69384719e-02f, 2.59838570e-02f, -4.74674366e-02f, 2.04899818e-01f, -1.05817020e-01f, 1.67914689e-01f, -1.56417629e-03f, 7.99902901e-02f, -1.57820042e-02f,
  1.06391132e-01f, -1.03297584e-01f, -6.87808394e-02f, 9.50507000e-02f, -3.79342102e-02f, 1.10353775e-01f, -3.13997716e-02f, 9.73172411e-02f, 4.10414226e-02f, -1.43176073e-03f,
  -3.85078974e-02f, 8.15890636e-03f, -6.40380681e-02f, -8.80680978e-02f, 5.49330451e-02f, 1.02117449e-01f, 6.14257008e-02f, 1.08035251e-01f, 3.03151160e-02f, 5.79738319e-02f,
  9.47024580e-03f, -1.46080881e-01f, 8.00719708e-02f, 1.14224814e-01f, -2.21790699e-03f, 1.59284204e-01f, -8.41078907e-02f, 1.51535779e-01f, 2.04297714e-02f, -3.76506113e-02f,
  -2.07061225e-04f, 5.61395139e-02f, 6.46627173e-02f, 6.97606355e-02f, 5.65273389e-02f, -8.41408297e-02f, 2.47190353e-02f, 1.20329030e-01f, -6.74527790e-03f, 1.10736638e-01f,
  1.18210748e-01f, -1.46281607e-02f, -6.92557469e-02f, -2.76177563e-02f, 1.55365855e-01f, 4.43459451e-02f, -3.70986201e-02f, 2.94034723e-02f, 8.32225606e-02f, 6.97293803e-02f,
  -1.61553964e-01f, 2.10685916e-02f, -1.21881425e-01f, -6.73484206e-02f, -3.34505513e-02f, 1.10731274e-01f, 1.03197537e-01f, 1.18399702e-01f, 2.22668424e-03f, 8.31009969e-02f,
  8.64229277e-02f, 6.52292296e-02f, -6.86510131e-02f, -4.18777131e-02f, 1.49282083e-01f, -4.21141945e-02f, -1.55501902e-01f, -7.76210576e-02f, 1.03516169e-01f, -1.36670386e-02f,
  5.05319461e-02f, 1.51638631e-02f, 1.32049099e-01f, 1.63246356e-02f, -1.37033612e-01f, 6.30833432e-02f, 4.72226292e-02f, 4.19133268e-02f, 1.76443513e-02f, 1.05623595e-01f,
  6.77802414e-02f, 1.23408027e-01f, 2.10455246e-02f, 8.12824722e-03f, -7.11016962e-03f, -1.38649508e-01f, 1.93689227e-01f, 1.11345902e-01f, -3.63519378e-02f, 9.66218263e-02f,
  9.42839682e-02f, -9.77938622e-03f, -7.27856308e-02f, -1.80646494e-01f, 1.06092155e-01f, 6.15608282e-02f, 6.50529712e-02f, 7.60123283e-02f, 8.31654891e-02f, 8.82805437e-02f,
  1.75018087e-01f, 4.31875922e-02f, 1.46239325e-01f, 9.92217753e-03f, 3.50295268e-02f, -9.70338508e-02f, 1.87141955e-01f, 8.46038163e-02f, 7.56117180e-02f, -3.27513665e-02f,
  -3.11053544e-02f, 1.18773974e-01f, 1.78735390e-01f, 8.79292488e-02f, 2.40041651e-02f, 3.61103490e-02f, 1.59404397e-01f, 3.98354828e-02f, -8.47144350e-02f, -4.89972606e-02f,
  1.01394244e-01f, -2.37227023e-01f, 2.41015941e-01f, 2.03942955e-02f, 1.29615977e-01f, -1.07588336e-01f, 5.41682877e-02f, -4.20175008e-02f, 3.11886340e-01f, -1.00712985e-01f,
  -1.25892177e-01f, 1.65098496e-02f, 6.18004650e-02f, 2.10889764e-02f, -7.14719668e-02f, -1.30044878e-01f, 1.16520077e-02f, 1.32217556e-01f, 2.41008297e-01f, 2.18522102e-01f,
  -3.03995237e-03f, 1.28209665e-02f, -4.71073240e-02f, -1.80527158e-02f, 2.52141673e-02f, -1.12892143e-01f, -1.57470226e-01f, 9.36743021e-02f, 1.66084409e-01f, -2.20865056e-01f,
  9.50444564e-02f, 1.31250829e-01f, 1.04018815e-01f, -2.46310487e-01f, -5.76920211e-02f, -1.12210773e-01f, -9.75926518e-02f, 1.56813264e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  7.13893771e-02f, 3.34851556e-02f, 2.21901592e-02f, 3.74384262e-02f, 4.84366976e-02f, 6.28714487e-02f, 8.26761872e-02f, -3.10696252e-02f, 3.44306193e-02f, 5.13894111e-03f,
  4.56989631e-02f, 4.49187569e-02f, 4.08520773e-02f, 7.39369690e-02f, 8.76150727e-02f, 3.65748219e-02f, 8.65168497e-02f, 1.08942114e-01f, 5.13090640e-02f, 5.17363250e-02f,
  1.12933684e-02f, 3.52565125e-02f, 5.01652099e-02f, 4.28411877e-04f, -4.68855985e-02f, -4.07311358e-02f, -4.75265421e-02f, 1.36226148e-03f, 6.02693260e-02f, 5.01615293e-02f,
  3.31803970e-02f, 4.88733277e-02f, 1.88411120e-02f, -3.18660438e-02f, -1.70837957e-02f, 1.49352914e-02f, -2.70499429e-03f, 1.24499341e-02f, 2.95626726e-02f, -3.09147947e-02f,
  1.18765980e-01f, -4.39467244e-02f, -7.56600648e-02f, -8.08719322e-02f, 3.83390971e-02f, 9.53749418e-02f, 6.80423006e-02f, 2.90535241e-02f, 6.44009337e-02f, -1.38971107e-02f,
  -3.52242365e-02f, 7.25747943e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  1.01027757e-01f, -7.66208097e-02f, 1.29260480e-01f, 1.41593710e-01f, -1.26060709e-01f, -1.37809083e-01f, 6.64352477e-02f, 3.73917334e-02f, -1.68275759e-02f, 2.97621582e-02f,
  1.96237162e-01f, -1.20988399e-01f, 7.32182115e-02f, 4.66662385e-02f, 3.06732059e-02f, -5.63395843e-02f, 2.21112087e-01f, 2.43517071e-01f, 1.43308908e-01f, -1.33226424e-01f,
  -1.24172799e-01f, -8.92989188e-02f, -8.72077718e-02f, 2.17078682e-02f, -4.10045423e-02f, 3.27151343e-02f, 3.08193117e-02f, -6.03617914e-02f, -2.63477057e-01f, -2.08670139e-01f,
  1.87878668e-01f, -1.67011604e-01f, 9.89093110e-02f, -2.03750104e-01f, -2.00954705e-01f, 1.72010697e-02f, -1.54504463e-01f, -4.75839913e-01f, 2.04844903e-02f, -6.36631697e-02f,
  9.35575441e-02f, 1.82676405e-01f, 1.37499034e-01f, -2.22469643e-01f, 2.57235765e-02f, -3.40696633e-01f, 8.98861066e-02f, -3.05196047e-01f, -4.10181470e-02f, 1.04047418e-01f,
  2.56004054e-02f, -2.60369122e-01f, -1.49241418e-01f, -2.38170892e-01f, -1.18108056e-01f, 6.13633581e-02f, 1.78308234e-01f, 1.86606795e-01f, 9.41989943e-02f, 1.81593895e-01f,
  -1.59237325e-01f, -3.33509326e-01f, -1.42927065e-01f, -4.59169671e-02f, -1.38233332e-02f, 1.15482792e-01f, 8.14516023e-02f, 1.48123130e-01f, 8.49020258e-02f, 1.11165047e-01f,
  -2.94155180e-01f, -2.22282007e-01f, -1.62216291e-01f, 2.10467651e-01f, 8.85993764e-02f, 6.46975823e-03f, 1.13899499e-01f, -2.71804839e-01f, -2.03949526e-01f, 6.56906515e-02f,
  -4.80729006e-02f, 1.51995942e-01f, 4.33573276e-02f, 1.46593660e-01f, 5.46179861e-02f, -2.63642166e-02f, -2.11850256e-01f, -7.31557980e-02f, -3.03446025e-01f, 1.76514283e-01f,
  -2.38264054e-01f, 2.18917429e-01f, 7.03365877e-02f, -4.32665162e-02f, 1.12804614e-01f, -1.74832463e-01f, -3.07299644e-01f, 1.68269083e-01f, 9.71318129e-03f, 1.62264198e-01f,
  1.04119927e-01f, -2.48542398e-01f, -6.12546727e-02f, 1.49933249e-01f, 1.27788391e-02f, 1.34486124e-01f, -1.78112425e-02f, 2.30958119e-01f, -2.12235805e-02f, -2.78965175e-01f,
  3.13373692e-02f, -1.61005735e-01f, -1.39596701e-01f, 1.15540780e-01f, -3.88527177e-02f, 1.23343572e-01f, -2.56529301e-01f, -1.06974959e-01f, 3.36574428e-02f, -7.62237748e-03f,
  -1.85234010e-01f, 8.19659904e-02f, 9.02662948e-02f, 2.65961532e-02f, 9.88138095e-02f, 1.45470295e-02f, -1.76735651e-02f, -1.87897086e-01f, -8.49839002e-02f, -3.17596905e-02f,
  -1.07279681e-01f, -1.69260129e-01f, 1.55827448e-01f, -9.58859473e-02f, -2.49073654e-02f, 1.39001444e-01f, -6.50108159e-02f, 7.41458237e-02f, 1.82395801e-01f, 6.58888817e-02f,
  1.72585994e-01f, -1.99370161e-02f, 2.04775602e-01f, 5.45603260e-02f, -2.30331734e-01f, -3.00237089e-01f, 8.00941512e-02f, -5.14074899e-02f, 2.31787171e-02f, -1.05719022e-01f,
  2.14912996e-01f, -3.06590497e-01f, -2.11936951e-01f, -1.07741587e-01f, -2.08144143e-01f, 1.28703952e-01f, 1.90437630e-01f, 1.47799119e-01f, 7.45441811e-03f, 2.14989454e-01f,
  -2.79586673e-01f, -1.90711934e-02f, -1.21375501e-01f, -2.73894630e-02f, 3.92437056e-02f, 3.05078514e-02f, -1.28753126e-01f, 1.40464023e-01f, -8.98812711e-02f, -7.44199380e-02f,
  -2.20797554e-01f, 5.86639903e-02f, -3.98964323e-02f, -6.69456869e-02f, -1.66072175e-01f, -3.76848765e-02f, -2.14286283e-01f, -1.17240526e-01f, -3.44172388e-01f, -7.44873807e-02f,
  -2.51656651e-01f, -1.31222710e-01f, 1.77378923e-01f, -1.01807505e-01f, 1.34902403e-01f, 9.54537094e-02f, -3.46064985e-01f, -2.37197757e-01f, -7.16919526e-02f, -1.46334441e-02f,
  1.20598190e-01f, -1.50391862e-01f, 8.24061260e-02f, 4.77842912e-02f, -4.62576523e-02f, 1.14295997e-01f, -3.00783478e-02f, 8.23318511e-02f, 1.93856597e-01f, 1.20833345e-01f,
  -8.05526823e-02f, -1.78002939e-01f, 2.25607604e-01f, 1.96902752e-01f, -4.67251152e-01f, 1.32336557e-01f, -3.79050940e-01f, -3.01337957e-01f, 2.41784334e-01f, 5.47272339e-02f,
  -2.65118722e-02f, -2.07176581e-01f, -1.90505952e-01f, 1.30661979e-01f, -2.50797331e-01f, -1.07091248e-01f, 1.06367730e-01f, -1.79203078e-02f, 1.33721486e-01f, -3.79471242e-01f,
  7.68508436e-03f, -3.21963847e-01f, -5.89216091e-02f, -3.43854576e-01f, 1.69592336e-01f, -2.52161771e-01f, 1.41059533e-01f, -9.89202186e-02f, -6.33980241e-03f, -1.36203736e-01f,
  -1.06738940e-01f, -2.97376007e-01f, -1.16857260e-01f, -2.08895817e-01f, 1.02727339e-01f, -2.18601614e-01f, -1.71922579e-01f, 4.75039613e-03f, -3.87141317e-01f, -2.01259062e-01f,
  2.14834526e-01f, 2.22051173e-01f, -4.33529280e-02f, 1.51060984e-01f, 2.28817221e-02f, 7.52773881e-02f, 3.46932709e-02f, -2.17570901e-01f, 2.04793826e-01f, 4.54146303e-02f,
  -6.78386912e-02f, 6.34913519e-02f, 4.36900072e-02f, -2.25370035e-01f, -2.20042020e-01f, 9.88921374e-02f, -1.27939209e-01f, -7.29747266e-02f, 4.86006076e-03f, 5.87807670e-02f,
  1.42417744e-01f, -1.31162181e-01f, 1.35238752e-01f, -2.99510002e-01f, 4.76639010e-02f, -8.18667486e-02f, -6.29735216e-02f, -8.49380121e-02f, -1.01761147e-02f, -3.66867542e-01f,
  -4.76406887e-03f, 3.08467411e-02f, -2.56257355e-01f, 1.16029806e-01f, 3.33138071e-02f, 8.53151083e-02f, 6.71782866e-02f, 2.56400347e-01f, -2.12255679e-02f, 3.90779562e-02f,
  1.65754586e-01f, -2.82712672e-02f, -1.06816389e-01f, -7.56430551e-02f, -8.48946497e-02f, 1.11665793e-01f, -1.84623040e-02f, 2.83688214e-02f, 1.74642116e-01f, -1.61190197e-01f,
  -2.43566334e-02f, -2.27647871e-01f, -1.47971630e-01f, -2.04525720e-02f, -2.83807400e-03f, 5.24797179e-02f, 1.19863845e-01f, -7.83021376e-02f, 5.96525446e-02f, -5.68410493e-02f,
  1.47988021e-01f, -1.13214202e-01f, 9.27867442e-02f, -1.32788122e-01f, 5.76701462e-02f, -5.45501001e-02f, -5.83210550e-02f, 8.32310021e-02f, 1.80852696e-01f, 1.21431485e-01f,
  -1.59224749e-01f, -1.18331492e-01f, -1.85575694e-01f, -5.67000872e-03f, -1.00339449e-03f, 1.84569791e-01f, 3.52909155e-02f, 3.08659356e-02f, -4.35023271e-02f, 2.49123678e-01f,
  9.26433876e-02f, -7.68884793e-02f, 1.19717391e-02f, -1.12809911e-01f, 9.82174128e-02f, 1.25941828e-01f, -7.05587119e-02f, -1.26218110e-01f, 2.60070086e-01f, -2.24748358e-01f,
  -2.79678732e-01f, 9.01825950e-02f, -4.71107522e-03f, 4.53092158e-02f, 1.37710953e-02f, -1.28435865e-01f, -1.92736164e-01f, 5.32436743e-02f, -2.74967223e-01f, -1.13219261e-01f,
  -1.32736266e-01f, -1.33867323e-01f, -3.09443712e-01f, 2.17324734e-01f, -5.19556105e-02f, 1.66504622e-01f, -1.78647995e-01f, 1.33881927e-01f, -1.84547305e-01f, 1.66997835e-01f,
  -7.83089399e-02f, -3.17393720e-01f, 6.41729832e-02f, -9.47825834e-02f, -3.85279238e-01f, 1.32047743e-01f, 1.59636647e-01f, -8.40601772e-02f, -1.67666793e-01f, -2.16423199e-02f,
  1.76143348e-01f, -4.06253599e-02f, 1.39183715e-01f, -1.33205593e-01f, 6.59081712e-02f, -3.13516229e-01f, 1.61695763e-01f, -4.72316407e-02f, -8.58226791e-02f, -3.99866551e-01f,
  1.66801527e-01f, -5.98987453e-02f, 1.87129989e-01f, -1.03450388e-01f, -1.78735629e-01f, 1.01707488e-01f, -1.83894962e-01f, -1.83932871e-01f, 2.87970304e-01f, 6.61243498e-02f,
  -1.10931240e-01f, -1.37849241e-01f, -1.15125477e-01f, -2.01959014e-01f, 6.47899434e-02f, 5.01317270e-02f, 8.81786644e-02f, 4.70947623e-02f, -2.76427492e-02f, 3.91286090e-02f,
  -1.73516363e-01f, -2.09382959e-02f, 4.10013683e-02f, 4.08915803e-03f, 6.47490937e-03f, 1.15534231e-01f, 1.70469135e-01f, -4.74651270e-02f, -1.19380718e-02f, 7.28243822e-03f,
  -3.78144495e-02f, -3.96107495e-01f, -2.26728439e-01f, -1.39425516e-01f, -1.63266242e-01f, 9.70231593e-02f, 1.27933711e-01f, 2.11408541e-01f, -3.09280604e-02f, -1.92200057e-02f,
  -7.26986676e-02f, 1.08154081e-01f, -1.03591099e-01f, 2.01414049e-01f, -3.51840258e-02f, 8.17901567e-02f, -1.42664090e-01f, -1.30383179e-01f, -2.21846864e-01f, -1.97532773e-01f,
  5.29606976e-02f, 6.08519502e-02f, 2.68144637e-01f, -1.65985048e-01f, -2.26872340e-01f, -2.67239004e-01f, 6.40155226e-02f, -1.69232666e-01f, 9.30640548e-02f, 8.79255682e-02f,
  -2.82675009e-02f, 6.58716857e-02f, -3.09642553e-01f, 1.92048075e-03f, -6.20973222e-02f, -2.26751074e-01f, 1.97717577e-01f, -1.17212281e-01f, 6.09747879e-02f, 1.34168118e-01f,
  -1.58823699e-01f, -3.40355128e-01f, 7.23818317e-02f, 3.45010273e-02f, -3.01196247e-01f, 1.66932791e-01f, -3.76426824e-03f, -3.67449224e-01f, -5.18348478e-02f, 1.02438219e-01f,
  -1.17556164e-02f, -5.47788106e-02f, 3.59451212e-02f, 2.81657628e-03f, 1.06121739e-02f, -4.60034329e-03f, 3.39684412e-02f, 1.42258167e-01f, -7.73292854e-02f, 3.05916965e-01f,
  -4.52122912e-02f, -2.16072276e-01f, -6.68312907e-02f, -8.50780979e-02f, -6.71026781e-02f, -2.10484520e-01f, -3.57091576e-01f, -7.80230835e-02f, -2.06916168e-01f, -1.19020797e-01f,
  7.86511004e-02f, -1.91401988e-01f, -2.13718265e-01f, -8.74366090e-02f, 1.82510927e-01f, -2.63202578e-01f, -1.50163010e-01f, -3.23476076e-01f, -3.86956669e-02f, 1.43148199e-01f,
  1.51843607e-01f, 1.31908551e-01f, 2.17047378e-01f, 3.63768116e-02f, -1.22522913e-01f, 4.25240062e-02f, -6.46842271e-02f, -9.57788303e-02f, -3.66619714e-02f, 4.95530069e-02f,
  -1.11349426e-01f, 1.26693577e-01f, 1.92840442e-01f, 5.54583222e-02f, -8.64415541e-02f, 2.26012647e-01f, 5.42688295e-02f, 1.86660796e-01f, -6.58647269e-02f, 9.83226821e-02f,
  -2.42475793e-01f, 5.80393039e-02f, -1.36502847e-01f, -6.33187816e-02f, -4.09839824e-02f, -5.58751412e-02f, -1.88764721e-01f, -2.71043718e-01f, 6.59032241e-02f, 3.68465409e-02f,
  -2.33121589e-02f, 4.70473059e-02f, 4.53427620e-02f, -2.33372733e-01f, -8.45021904e-02f, -2.30052844e-02f, -6.87376708e-02f, -2.00259954e-01f, 7.46630356e-02f, -2.74543408e-02f,
  -7.31814653e-02f, 4.41225804e-02f, -7.60053331e-03f, 1.24388091e-01f, -2.34907374e-01f, -9.45133641e-02f, 8.94897208e-02f, -1.48104191e-01f, 1.93385467e-01f, -1.45517245e-01f,
  -2.82873902e-02f, 1.79297179e-01f, 9.46962610e-02f, 5.57785816e-02f, 1.34282336e-01f, -8.58188942e-02f, -1.55471042e-01f, -5.92233464e-02f, 1.23621762e-01f, -1.46613166e-01f,
  1.62775531e-01f, -2.69777030e-01f, 2.16205910e-01f, -2.90764600e-01f, -1.49125800e-01f, 6.21334352e-02f, 1.39895320e-01f, 3.41711156e-02f, 1.28771327e-02f, -2.27427617e-01f,
  -1.02930129e-01f, 1.59851715e-01f, -2.84893036e-01f, 1.29414096e-01f, -5.50539270e-02f, 9.13220495e-02f, -2.32153952e-01f, 6.66415244e-02f, -1.14835881e-01f, 2.56904542e-01f,
  -2.22757488e-01f, 5.93019612e-02f, -1.73595563e-01f, -2.37373278e-01f, 6.95552602e-02f, 2.58124918e-01f, 9.55268294e-02f, 1.16785511e-01f, -1.05177194e-01f, -2.45369808e-03f,
  -1.53183669e-01f, -8.39346722e-02f, -5.44479638e-02f, 6.23693317e-02f, 1.49261907e-01f, -2.91174918e-01f, -4.09193002e-02f, -1.22139528e-01f, 5.97258992e-02f, -1.54943407e-01f,
  -1.09126434e-01f, 5.47644123e-02f, -1.38144001e-01f, -2.92389113e-02f, -1.51578680e-01f, -1.70323730e-01f, -4.93302643e-02f, -1.71146274e-01f, 9.53492150e-02f, 7.75731131e-02f,
  -2.63469577e-01f, -1.48895502e-01f, 7.34777227e-02f, -2.32328311e-01f, -2.10215390e-01f, -2.58659005e-01f, -1.67030394e-01f, -7.30523318e-02f, 1.46407902e-01f, -1.21556222e-01f,
  -3.66158903e-01f, -3.23594600e-01f, -3.22625786e-01f, -1.20324686e-01f, -3.30866933e-01f, 1.87669322e-01f, -3.61755267e-02f, 1.49645686e-01f, 6.93927109e-02f, -7.26310536e-02f,
  -1.50856435e-01f, -2.51549482e-01f, -1.75414495e-02f, 6.77894130e-02f, 7.34969303e-02f, -8.05045143e-02f, -1.57000512e-01f, 1.68094933e-01f, 6.92839846e-02f, 1.62263647e-01f,
  2.63882913e-02f, 9.32384729e-02f, 1.47449076e-01f, -1.93210803e-02f, 2.47353874e-02f, -3.64496380e-01f, -3.66660990e-02f, 1.89035103e-01f, -2.56988481e-02f, -1.54268607e-01f,
  1.68133497e-01f, -2.98311859e-01f, 4.49511819e-02f, -1.11549929e-01f, -2.37126946e-01f, 1.14974128e-02f, 2.30971083e-01f, 2.08907157e-01f, 4.49140854e-02f, -3.84462103e-02f,
  -1.08576469e-01f, -2.75779106e-02f, -4.19932865e-02f, 3.04011106e-02f, 2.08320320e-02f, 1.82149671e-02f, 1.38593212e-01f, 2.76494384e-01f, 2.11605504e-01f, 1.76478714e-01f,
  1.04153290e-01f, -1.96847096e-01f, -1.76916450e-01f, 2.49421820e-01f, 2.98449934e-01f, 2.95271009e-01f, 9.83211696e-02f, 1.19999237e-01f, 2.63701618e-01f, -4.26453091e-02f,
  1.43017456e-01f, -2.17587754e-01f, -1.56700805e-01f, -3.00183855e-02f, 4.38832305e-02f, -3.18680257e-02f, 1.94940612e-01f, -1.97356924e-01f, -1.01313204e-01f, -5.50864041e-02f,
  -2.32614383e-01f, -3.44465487e-02f, -2.23302051e-01f, -4.84770574e-02f, -6.91882223e-02f, 1.64751604e-01f, -1.27492309e-01f, -8.48883614e-02f, 3.31977122e-02f, 7.91455507e-02f,
  1.17092533e-02f, -1.40331641e-01f, -1.72712654e-01f, 2.19643768e-02f, -2.14201763e-01f, 2.44416818e-01f, -3.54457766e-01f, -3.55181009e-01f, -1.04768850e-01f, 1.11730434e-01f,
  -1.35905117e-01f, -2.98401136e-02f, -2.12096423e-01f, 1.03118770e-01f, -2.07816005e-01f, -1.14857025e-01f, -2.33029537e-02f, 1.19106747e-01f, -1.98490322e-01f, -2.77501494e-01f,
  -8.92542675e-03f, 1.01143241e-01f, 1.72497287e-01f, 1.01568021e-01f, 6.60505295e-02f, 6.71196431e-02f, 4.08556946e-02f, -9.02977735e-02f, 1.20603673e-01f, -1.63711935e-01f,
  1.07056312e-01f, 2.12496966e-01f, -3.15478034e-02f, 1.14618674e-01f, 5.37419319e-02f, 8.36240053e-02f, -2.14457482e-01f, -1.23157248e-01f, -4.77691106e-02f, 1.44480504e-02f,
  9.02069211e-02f, 2.57454757e-02f, -1.16885744e-01f, -2.06120715e-01f, -6.26409799e-02f, 1.48430802e-02f, -1.44252792e-01f, 2.04913110e-01f, 2.11841926e-01f, 9.31256488e-02f,
  1.38380498e-01f, -4.87494506e-02f, -1.88843310e-01f, -1.57811895e-01f, -8.01138356e-02f, -1.24695212e-01f, -6.77836835e-02f, -9.73434746e-02f, 8.37058574e-02f, 1.22601420e-01f,
  1.23723269e-01f, 1.94131121e-01f, 1.32555425e-01f, -1.84610382e-01f, -1.75208109e-03f, -7.39163160e-02f, 4.49193977e-02f, -2.46764243e-01f, -2.81298280e-01f, 1.20288581e-01f,
  -1.17271356e-01f, -4.70887721e-02f, 1.06802611e-02f, -6.05693609e-02f, 1.32189259e-01f, -2.41549850e-01f, -1.18114680e-01f, 1.49143711e-01f, -1.44520059e-01f, 2.21126929e-01f,
  1.04672372e-01f, -1.99060977e-01f, 1.26096874e-01f, 3.01594958e-02f, -2.98650980e-01f, 4.15265411e-02f, 1.47252738e-01f, -2.87357904e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -5.90984663e-03f, -4.82826792e-02f, -6.93211779e-02f, -1.22466050e-01f, 2.16511283e-02f, 7.46909976e-02f, 2.59917956e-02f, -1.22926533e-02f, 2.95761903e-03f, -2.51105241e-02f,
  4.19086255e-02f, -1.07767671e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    