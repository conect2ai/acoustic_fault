/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.70602965e-01f, 1.14983633e-01f, -3.63115519e-02f, -1.97627112e-01f, -2.58599799e-02f, -2.61761583e-02f, -1.20556347e-01f, -6.06676415e-02f, -1.17178567e-01f, 1.64902255e-01f,
  -6.04877919e-02f, -1.77030526e-02f, 3.70125249e-02f, -7.12382048e-02f, -1.95549682e-01f, -6.54342119e-04f, -7.20223263e-02f, -1.28480578e-02f, -3.42640989e-02f, -2.97695771e-02f,
  -6.84443936e-02f, -4.74450067e-02f, -4.11102585e-02f, 1.25298172e-01f, -3.40581662e-03f, 9.41322371e-02f, 1.20797679e-01f, 1.26490414e-01f, -8.50763023e-02f, 4.78066988e-02f,
  -1.09295152e-01f, -3.23489681e-02f, -5.00495769e-02f, -3.64084728e-02f, -4.60673459e-02f, 1.60313603e-02f, 8.41443837e-02f, 1.21123053e-01f, -4.43278514e-02f, -7.75823146e-02f,
  5.26746325e-02f, 3.34844515e-02f, -5.86586669e-02f, -3.08575742e-02f, -5.33896312e-02f, -1.06779166e-01f, -7.01366812e-02f, -5.95688410e-02f, 2.40876004e-02f, -3.68296802e-02f,
  -1.25681043e-01f, -4.87425365e-02f, 3.06827631e-02f, 1.49814226e-02f, -4.46491875e-03f, -3.05736121e-02f, 2.27000136e-02f, 3.64918448e-02f, 3.80854644e-02f, 2.14638542e-02f,
  -4.13359925e-02f, -8.03004019e-03f, 6.27908623e-04f, -7.01963902e-02f, -8.88793264e-03f, -5.57070300e-02f, -4.15971801e-02f, 3.00003756e-02f, 2.24093013e-02f, -3.79170217e-02f,
  -5.53188585e-02f, -3.10085528e-02f, -2.40309425e-02f, -5.54524325e-02f, -3.85064818e-02f, 5.84793161e-04f, 2.33860705e-02f, -2.41495688e-02f, 1.75509099e-02f, -3.92618179e-02f,
  6.04592124e-03f, -1.33248623e-02f, -1.58325583e-02f, 2.82089133e-02f, 9.38146841e-03f, -2.53840536e-02f, -2.58640442e-02f, -2.18840875e-02f, -5.03429386e-04f, 3.43428962e-02f,
  4.58890647e-02f, 2.45257482e-01f, 9.36147794e-02f, 6.45822659e-02f, 6.87704310e-02f, 6.56760931e-02f, 5.10665104e-02f, -4.16624211e-02f, 3.29199657e-02f, 5.65156676e-02f,
  -5.30290529e-02f, -1.98176187e-02f, 5.85410595e-02f, -2.88625769e-02f, 5.39082550e-02f, -1.16171045e-02f, 7.05774873e-03f, 6.41301274e-02f, 7.49275237e-02f, -3.18081826e-02f,
  2.43780501e-02f, -1.43779926e-02f, 3.12327519e-02f, -2.97796652e-02f, -1.09753176e-03f, -2.93880235e-03f, 4.36974391e-02f, -1.56968571e-02f, 3.99710573e-02f, -2.03361362e-02f,
  -2.83034444e-01f, -1.03173517e-01f, 2.28720019e-03f, -5.18416613e-02f, -2.49519162e-02f, 1.16687313e-01f, 2.40227148e-01f, -1.35475382e-01f, 1.75852448e-01f, 1.67751506e-01f,
  -1.55471014e-02f, 1.13561437e-01f, 1.75320916e-02f, 1.49020195e-01f, -2.56156083e-02f, 9.09748152e-02f, 4.97048628e-03f, 8.59019831e-02f, -6.33861721e-02f, -1.37548745e-01f,
  -5.97777069e-02f, -6.21566325e-02f, -8.88616964e-02f, -1.55046403e-01f, -3.68321128e-02f, -1.30646273e-01f, -5.88485673e-02f, -3.00188493e-02f, -8.62586498e-03f, 4.98964302e-02f,
  -6.74395561e-02f, -1.67569876e-01f, -2.15561483e-02f, -4.75135958e-03f, -4.88926470e-02f, -9.39101800e-02f, 3.47371697e-02f, 2.95624509e-02f, 4.69652824e-02f, 4.48080786e-02f,
  3.90262417e-02f, -1.57669839e-02f, 2.38714311e-02f, 2.50667930e-02f, -1.43186962e-02f, -4.88961535e-03f, 2.67040525e-02f, 1.69296563e-02f, 1.43152950e-02f, -4.77641076e-02f,
  1.26621099e-02f, 2.41723880e-02f, 8.05831887e-03f, -5.45460768e-02f, -4.10711281e-02f, 1.72849353e-02f, 8.95215794e-02f, 4.29250002e-02f, -6.59249797e-02f, 6.62493557e-02f,
  -7.25152493e-02f, 5.74009791e-02f, -4.60702777e-02f, 3.50546986e-02f, -8.17465931e-02f, -6.91301301e-02f, 5.84718436e-02f, -5.28828390e-02f, 5.03651239e-02f, -1.66762918e-02f,
  9.39327758e-03f, 1.41413976e-03f, -7.48172998e-02f, 2.16578003e-02f, 7.86715187e-03f, 4.32333760e-02f, -2.01568250e-02f, 8.19257053e-04f, -2.25615278e-02f, 6.24645874e-03f,
  3.12009733e-02f, -3.33550163e-02f, 3.28234024e-02f, -1.33736795e-02f, 3.28424238e-02f, 3.54000963e-02f, -1.69760622e-02f, 5.33133140e-03f, 4.34912518e-02f, -1.43317191e-03f,
  -1.87316816e-02f, -2.66345084e-01f, 1.98413860e-02f, -1.56778619e-02f, 5.53813297e-03f, -2.07628962e-02f, -6.08805846e-03f, -1.86055303e-02f, -4.76952717e-02f, -3.74084823e-02f,
  -5.49038779e-03f, 1.08022429e-02f, -2.62538698e-02f, -4.92233876e-03f, 5.20565696e-02f, -2.14975625e-02f, -3.07878125e-02f, 5.07967994e-02f, 2.70125512e-02f, -3.04362876e-03f,
  -3.05183847e-02f, -9.47465673e-02f, 8.45329762e-02f, -5.70658334e-02f, -5.97574422e-03f, -3.51093970e-02f, -1.09891742e-01f, 9.80231725e-03f, -7.59043396e-02f, -4.76161838e-02f,
  2.18943402e-01f, -1.47783875e-01f, -3.61133553e-02f, -1.02955215e-01f, 8.30133706e-02f, -9.01788920e-02f, -1.29104987e-01f, 6.56721764e-04f, 6.75186664e-02f, -2.17226431e-01f,
  -2.07246929e-01f, -4.30109464e-02f, -2.59903818e-01f, -2.46754274e-01f, -1.16888046e-01f, -2.25664616e-01f, -1.53987840e-01f, -1.27041280e-01f, -4.85574268e-02f, -7.38200918e-02f,
  4.11399417e-02f, -1.68681905e-01f, -9.77529958e-02f, -4.66585308e-02f, -4.87001799e-02f, 2.92438231e-02f, -1.16396286e-01f, -2.62215976e-02f, -8.37236866e-02f, -9.51116011e-02f,
  3.12253498e-02f, -5.62230311e-02f, 8.03435072e-02f, -3.67191397e-02f, -3.53132002e-02f, 9.32269469e-02f, 7.60202855e-02f, -9.46260169e-02f, 6.86360747e-02f, 4.23372164e-02f,
  -5.61168566e-02f, 7.86791323e-04f, 4.63389941e-02f, 2.56848577e-02f, -1.17675718e-02f, -1.60298031e-02f, 2.83613149e-02f, 2.99596265e-02f, -5.42964004e-02f, -1.11290952e-02f,
  2.44617965e-02f, 6.34581689e-03f, -2.77014673e-02f, -3.12922150e-02f, -3.69050838e-02f, -4.82962001e-03f, -6.10759333e-02f, 3.15742157e-02f, -2.73466948e-02f, 4.72864918e-02f,
  -5.13175800e-02f, 2.13909168e-02f, 5.37359342e-02f, 2.91566327e-02f, 1.16345473e-02f, -2.23461334e-02f, -1.37782350e-01f, -4.66681384e-02f, 1.03831522e-01f, -4.05857749e-02f,
  8.19311105e-03f, 1.37843546e-02f, 2.41594482e-02f, -7.74751930e-03f, 3.08842137e-02f, 2.43949704e-02f, 4.31009196e-02f, -5.28967083e-02f, -4.70638694e-03f, -2.32594442e-02f,
  -6.66677430e-02f, 3.64645123e-02f, -3.80535088e-02f, 6.02857620e-02f, -4.67948131e-02f, -4.71961722e-02f, -1.51880002e-02f, -1.21204171e-03f, -3.59078571e-02f, -5.03934659e-02f,
  -1.40843555e-01f, -2.19041720e-01f, 9.36605502e-03f, 3.20282243e-02f, 1.53335808e-02f, 1.23020023e-01f, 1.20394565e-02f, 3.64606790e-02f, -1.01119988e-01f, -5.66350110e-02f,
  4.23705019e-02f, 7.32084662e-02f, -9.80407652e-03f, 2.44459845e-02f, 5.63560463e-02f, -3.34706455e-02f, -1.19340643e-01f, 1.78306773e-02f, -4.90395539e-03f, -5.17791696e-02f,
  -6.58925399e-02f, -7.20031857e-02f, 2.04112679e-02f, -5.82579449e-02f, -5.20197907e-03f, 1.49448812e-02f, 4.86372598e-02f, -1.51270600e-02f, -1.72051531e-03f, -6.32447451e-02f,
  -2.82129645e-01f, 2.31933773e-01f, 1.04806125e-01f, -1.11420877e-01f, -2.00254947e-01f, -2.25102492e-02f, -2.00918123e-01f, 7.82263577e-02f, 7.63596445e-02f, 5.83128110e-02f,
  -1.18058592e-01f, 1.20081253e-01f, 5.59246168e-02f, -2.48792749e-02f, -2.26579696e-01f, 1.46803185e-01f, -1.69272125e-01f, -1.01865806e-01f, 7.88764562e-03f, 8.00698921e-02f,
  -3.40721793e-02f, -7.60304406e-02f, -9.54276249e-02f, -3.92665602e-02f, -9.46652964e-02f, -1.52794998e-02f, -6.53515384e-02f, 9.47506875e-02f, -1.36464700e-01f, -4.09736158e-03f,
  -5.38515821e-02f, -4.55977730e-02f, -2.80542672e-02f, 4.16798815e-02f, -5.99031523e-02f, -5.57386652e-02f, -2.14252528e-02f, -1.39590085e-01f, 2.98401341e-03f, -3.16428649e-03f,
  -1.04459422e-02f, -9.20695513e-02f, -2.59672292e-02f, -1.36156389e-02f, 5.30465916e-02f, 2.07040384e-02f, -2.21211873e-02f, -8.11573304e-03f, 1.87511109e-02f, -3.92363109e-02f,
  4.13315743e-02f, -3.29653616e-03f, -4.32465374e-02f, -2.99157817e-02f, -4.43463726e-03f, -4.15379554e-02f, -1.36065930e-02f, -4.96894047e-02f, -3.73394564e-02f, -2.12792233e-02f,
  1.78130937e-03f, 9.28707123e-02f, -5.69037423e-02f, 2.05932986e-02f, -4.00416466e-05f, -3.20047066e-02f, 3.19920518e-02f, -5.07689975e-02f, 4.66128699e-02f, 1.65498834e-02f,
  2.88029052e-02f, -1.05900727e-02f, 3.23121473e-02f, 5.09493472e-03f, -2.87771551e-03f, -8.22723005e-03f, 1.00509217e-02f, -5.03993966e-02f, 3.94472890e-02f, -5.09005636e-02f,
  1.53414626e-02f, -3.03758886e-02f, 6.17494471e-02f, 1.08789233e-02f, 5.80095388e-02f, -2.89189927e-02f, 2.58205011e-02f, 4.77356231e-03f, 3.19187902e-02f, -3.66724804e-02f,
  1.58760160e-01f, 2.75315940e-01f, 2.34094709e-02f, 4.57900278e-02f, 3.69863473e-02f, 6.88782334e-03f, 1.27069466e-02f, 1.20882150e-02f, 1.21764615e-01f, -5.06476201e-02f,
  -1.00551648e-02f, -5.56897260e-02f, 3.23477574e-02f, -4.14680578e-02f, -3.98291126e-02f, 4.59833816e-03f, 5.06473854e-02f, -9.20137670e-03f, 4.37367074e-02f, -2.46415995e-02f,
  -2.90030949e-02f, -2.17272807e-02f, 7.21631991e-03f, -5.75440675e-02f, -6.94042817e-02f, -4.30460945e-02f, 3.11293174e-02f, 8.33203346e-02f, -4.47040349e-02f, 6.89779148e-02f,
  -1.56924784e-01f, 2.36512125e-01f, -4.01873067e-02f, -1.84026718e-01f, -1.04047008e-01f, 2.33673360e-02f, -1.16876706e-01f, 7.58133084e-02f, 1.18206739e-02f, 2.13912621e-01f,
  -1.29281253e-01f, 1.22452870e-01f, 9.64548141e-02f, -1.91181988e-01f, -4.15032357e-01f, -1.15475409e-01f, -2.47218877e-01f, -2.86372397e-02f, -1.13094868e-02f, 2.62768697e-02f,
  -2.67957807e-01f, -2.85431147e-01f, -2.05799460e-01f, -6.92981780e-02f, -5.48576117e-02f, 1.84625372e-01f, -5.06821424e-02f, -6.21892884e-02f, -3.59764434e-02f, -1.55936509e-01f,
  -4.42911722e-02f, 2.00207513e-02f, 4.58616531e-03f, 8.84579588e-03f, -1.77642368e-02f, 1.48967011e-02f, 2.04794351e-02f, -1.36837829e-03f, 6.78164046e-03f, 6.44106269e-02f,
  6.78574741e-02f, 6.52343556e-02f, -1.31433913e-02f, -2.30491105e-02f, -2.11310387e-02f, 2.78193271e-03f, 8.67106467e-02f, 7.55883902e-02f, 1.77849527e-03f, 3.13276015e-02f,
  -1.51088694e-02f, 5.43834902e-02f, -3.21703516e-02f, 1.85387675e-02f, -5.57463476e-03f, 2.79340195e-03f, -3.73296887e-02f, 6.91741332e-02f, 1.08547710e-01f, -1.41292745e-02f,
  2.96087712e-02f, 5.03124259e-02f, -2.34003328e-02f, 4.12989520e-02f, -2.87557989e-02f, -4.07796428e-02f, 1.54758859e-02f, 7.94410822e-04f, -1.21851331e-02f, -3.32213528e-02f,
  4.89463955e-02f, 6.05593547e-02f, -6.63875937e-02f, 5.98684512e-02f, -7.97903240e-02f, 2.00973637e-02f, 4.31327242e-03f, -4.02789414e-02f, -5.81273288e-02f, -1.42898848e-02f,
  -3.20866914e-03f, -2.35043969e-02f, 7.25918710e-02f, -2.76439656e-02f, 9.79056302e-03f, 6.16485998e-03f, 4.54281904e-02f, 4.82579507e-02f, 2.93312743e-02f, -9.15939361e-02f,
  2.02500727e-02f, 1.02455094e-01f, -1.63717114e-03f, -3.62378731e-02f, -5.15443599e-03f, 3.40189636e-02f, -2.74642110e-02f, 4.90858033e-02f, -4.79892567e-02f, 3.10683958e-02f,
  -2.40475982e-02f, -2.40985937e-02f, 5.98674901e-02f, -1.74332466e-02f, 3.88480048e-03f, 3.65909971e-02f, -7.53438547e-02f, 3.91626395e-02f, 6.27604723e-02f, 3.52482572e-02f,
  1.02950498e-01f, 2.39204410e-02f, -2.07605958e-02f, -1.05727278e-02f, -1.91881582e-02f, 3.89581174e-02f, 3.60915214e-02f, -3.25743109e-02f, -2.47353110e-02f, -2.71867588e-02f,
  -1.37067372e-02f, 1.61845133e-01f, 1.00032397e-01f, 3.00426874e-02f, -9.15704668e-02f, -3.22608232e-01f, -3.37164581e-01f, -4.80323210e-02f, -2.92404711e-01f, 8.72570090e-03f,
  -1.73550785e-01f, 1.03246689e-01f, -2.02915847e-01f, -1.54171803e-03f, -2.23001704e-01f, -3.14210176e-01f, -3.79498564e-02f, -2.09684614e-02f, -6.36530370e-02f, 1.16677552e-01f,
  3.22377719e-02f, 1.92934908e-02f, 1.19837604e-01f, 1.51699737e-01f, 6.36985973e-02f, 2.13799134e-01f, 2.48118564e-01f, 7.80023355e-03f, 1.34592831e-01f, 9.82898101e-03f,
  -6.47748262e-02f, 3.75774093e-02f, 4.78277542e-02f, -6.09330693e-03f, 5.74530736e-02f, 2.33498160e-02f, 4.36673835e-02f, -2.96344180e-02f, 1.16315521e-02f, -3.09576001e-02f,
  5.26569113e-02f, 4.65969332e-02f, 1.82725843e-02f, -1.21856574e-02f, -2.16992795e-02f, 5.96743636e-02f, 6.39326721e-02f, 3.92053574e-02f, 6.25618622e-02f, -2.59304862e-03f,
  6.74519166e-02f, 3.39560993e-02f, 8.89996663e-02f, -3.53236683e-02f, 3.46446931e-02f, -1.45929316e-02f, -2.99620144e-02f, 5.45399114e-02f, 4.27558273e-02f, -7.67558143e-02f,
  -1.77525561e-02f, -4.24549356e-02f, 5.10067195e-02f, 4.97690235e-05f, 3.20816375e-02f, 2.66199205e-02f, 2.04874966e-02f, -5.91576509e-02f, 2.94690728e-02f, -6.56201988e-02f,
  -5.72859310e-02f, 8.68965499e-03f, -3.83768901e-02f, -3.40558700e-02f, -4.83760163e-02f, 4.45253439e-02f, -3.58391018e-03f, -1.84524190e-02f, -5.04685193e-02f, 2.43865084e-02f,
  -1.32248759e-01f, 1.28242197e-02f, -3.22177447e-02f, 1.18908711e-01f, -2.19803844e-02f, -1.42362099e-02f, 2.22495962e-02f, -1.10911136e-03f, 1.37818279e-02f, -1.17517670e-03f,
  -2.94821872e-03f, 1.23661421e-01f, -3.69847193e-02f, -3.61650512e-02f, -5.04661165e-02f, -1.59677863e-02f, -1.98869519e-02f, -1.24106575e-02f, 5.39698228e-02f, -3.70590165e-02f,
  2.42582932e-02f, 2.84315813e-02f, 1.60348397e-02f, 2.67252307e-02f, 2.98073646e-02f, -3.70480418e-02f, -2.31295358e-02f, 2.93531623e-02f, 1.03494093e-01f, 2.17139106e-02f,
  3.49173434e-02f, -1.15948662e-01f, -9.61627066e-03f, 3.59367654e-02f, 3.71070057e-02f, 1.62940621e-02f, -8.27175844e-03f, -1.15704946e-02f, -6.54424308e-03f, 6.88438676e-03f,
  1.83122531e-01f, 1.78303942e-01f, -1.64658818e-02f, -1.12330541e-01f, -3.13346624e-01f, -1.85619950e-01f, 4.20304909e-02f, -2.15430632e-01f, -2.62660116e-01f, 7.43023083e-02f,
  1.84670314e-01f, 1.35591492e-01f, 1.81538805e-01f, 1.24816962e-01f, 3.93276475e-02f, 1.58608943e-01f, -8.81983340e-03f, -7.00079054e-02f, -1.69477493e-01f, -8.66668001e-02f,
  -1.22284181e-01f, 7.85596371e-02f, 2.41518408e-01f, -1.18114740e-01f, 6.75060377e-02f, -1.07689649e-01f, -4.41872664e-02f, 2.04617158e-02f, 2.19093319e-02f, 5.47994189e-02f,
  8.18124563e-02f, -8.16557482e-02f, 1.16413068e-02f, 2.00360604e-02f, -1.76873170e-02f, -2.50447467e-02f, 1.78149510e-02f, 2.27350909e-02f, 3.40062566e-02f, -2.96554826e-02f,
  5.54240942e-02f, -2.32832413e-02f, 1.06583741e-02f, -2.18191035e-02f, -9.82796177e-02f, 3.30409184e-02f, -1.62024256e-02f, 2.77172029e-02f, 7.48428795e-03f, 1.91378556e-02f,
  4.45318483e-02f, 1.29288144e-03f, 3.07943821e-02f, -7.70741850e-02f, -3.91666554e-02f, 1.26167368e-02f, 9.21700802e-03f, -8.88272282e-03f, 4.46082279e-02f, -7.34485015e-02f,
  -5.87250367e-02f, -1.18000567e-01f, 4.88528460e-02f, -4.92726900e-02f, -3.25662293e-03f, -2.65519805e-02f, 2.44451016e-02f, 2.12083552e-02f, -7.15214014e-02f, -9.34641622e-03f,
  -3.14447694e-02f, 1.50078451e-02f, -9.48515609e-02f, -6.46090508e-02f, -6.35306910e-02f, -3.77334207e-02f, 7.29340613e-02f, 1.98209864e-06f, -5.68220839e-02f, -4.04855497e-02f,
  2.86158789e-02f, -6.09441474e-02f, 7.64306337e-02f, -1.30889448e-03f, 1.50573840e-02f, 3.35356197e-03f, -9.98289287e-02f, -1.24717448e-02f, 8.68282318e-02f, -1.55530497e-03f,
  -3.51958238e-02f, -2.52288252e-01f, -4.96877183e-04f, 1.46467136e-02f, 2.18043346e-02f, 4.64716293e-02f, 3.34131494e-02f, -5.16160950e-03f, -1.52523443e-01f, 1.49267660e-02f,
  -1.49934003e-02f, -5.24379984e-02f, 8.26281123e-03f, 1.28182070e-02f, 1.08042983e-02f, -1.02571561e-03f, -2.28578821e-02f, -1.31254971e-01f, -7.75474533e-02f, -1.69433244e-02f,
  4.97294031e-02f, -1.58542003e-02f, -7.03374222e-02f, -7.06917569e-02f, -1.18106883e-02f, 6.84272218e-03f, -8.25542957e-02f, -3.58869471e-02f, -6.35855868e-02f, -2.11891886e-02f,
  -1.45514786e-01f, 1.92912519e-02f, -3.06570828e-01f, -9.31235217e-03f, 1.03037782e-01f, -2.76682861e-02f, -1.21675280e-03f, 5.61955497e-02f, -2.79601991e-01f, 1.61014289e-01f,
  9.91242751e-02f, -2.79543310e-01f, -6.37509003e-02f, 1.53616751e-02f, 3.94022800e-02f, -1.52818486e-01f, 1.31833091e-01f, -5.07266782e-02f, -1.76031232e-01f, 2.01233272e-02f,
  2.11246405e-03f, 3.29059511e-01f, 2.78993826e-02f, 1.81325838e-01f, 1.45720333e-01f, -8.64847153e-02f, 3.30727071e-01f, 1.83667745e-02f, 1.69244707e-01f, 3.32797728e-02f,
  -2.94279475e-02f, -1.67452961e-01f, -7.36417696e-02f, -3.23217213e-02f, 2.94389129e-02f, 5.96258901e-02f, 2.91985646e-02f, -2.31782184e-03f, -3.83616495e-03f, -7.92561471e-02f,
  -1.92520134e-02f, -6.78309426e-03f, 3.30672227e-02f, 4.40830812e-02f, -1.47507982e-02f, 9.38340090e-03f, -7.63950944e-02f, 5.54140396e-02f, -9.96891111e-02f, -4.90778200e-02f,
  -5.36786672e-03f, 3.65099614e-03f, 1.97366886e-02f, 1.23032192e-02f, -1.92244537e-02f, 5.55732928e-04f, 4.14741971e-02f, -2.39827037e-02f, 1.71450805e-02f, -2.71591619e-02f,
  2.18292717e-02f, 5.69965467e-02f, -1.26000377e-03f, 6.31504059e-02f, -1.88465603e-02f, 1.69463009e-02f, -1.59573313e-02f, 8.74925703e-02f, -2.58572157e-02f, 6.97860196e-02f,
  9.51091871e-02f, -4.97319456e-03f, -5.62515929e-02f, -6.17519952e-03f, 5.97124808e-02f, 5.54789603e-03f, 1.60961933e-02f, -1.07021059e-03f, 5.65948850e-03f, 1.91630404e-02f,
  -1.46844741e-02f, -3.23761068e-02f, -1.12067619e-02f, 4.51225042e-02f, -5.63879274e-02f, -1.05113955e-02f, 4.06574458e-02f, 2.00626571e-02f, 1.02926958e-02f, 3.03873010e-02f,
  8.66107121e-02f, 1.30989790e-01f, 2.07479391e-02f, -6.76850881e-03f, -5.06714284e-02f, 4.56082858e-02f, -9.32860840e-03f, -1.49430437e-02f, -6.90649375e-02f, -2.30480805e-02f,
  1.11428052e-01f, 4.94074300e-02f, -4.97556874e-04f, 1.88520085e-02f, -3.71365063e-02f, -3.40409635e-04f, 4.22933213e-02f, 1.45487925e-02f, 1.09211735e-01f, 6.66951016e-02f,
  7.58633837e-02f, -3.15919169e-03f, 1.60833839e-02f, 9.76165682e-02f, 2.95853205e-02f, -1.16745811e-02f, 5.91449300e-03f, -8.27121083e-03f, 3.50519419e-02f, 2.08531022e-02f,
  -3.01582413e-03f, -1.09523706e-01f, -1.32960767e-01f, 8.47788230e-02f, 1.77787200e-01f, 3.03960711e-01f, 2.78111428e-01f, 4.73275669e-02f, 3.08018029e-02f, 8.35524499e-02f,
  4.23749909e-02f, -4.11037095e-02f, 5.80627769e-02f, 2.92905480e-01f, 2.83575594e-01f, 1.17524572e-01f, 1.74742922e-01f, 1.39040232e-01f, -2.66843941e-02f, -1.55758904e-02f,
  3.93003598e-02f, 2.90891200e-01f, 1.39730468e-01f, 3.32077779e-02f, -1.48845077e-01f, -2.03396082e-01f, -7.97077045e-02f, -1.12982966e-01f, 4.57864180e-02f, 1.69451982e-01f,
  9.95764602e-03f, 1.69542190e-02f, 3.05334460e-02f, 2.95853149e-02f, -8.57692771e-03f, -5.94764836e-02f, 5.58322892e-02f, 8.45889971e-02f, 3.87901403e-02f, -5.79896048e-02f,
  -3.04758456e-03f, 7.60132745e-02f, 1.08292717e-02f, -8.36642832e-03f, 3.67343053e-02f, 2.65344642e-02f, -1.06881365e-01f, 5.36382347e-02f, 1.02869220e-01f, 5.23717701e-02f,
  -4.59575513e-03f, -1.07602542e-02f, -8.65831524e-02f, -4.08026837e-02f, -8.84310082e-02f, -1.27071273e-02f, 1.20897330e-02f, -3.81456390e-02f, 1.00348787e-02f, -3.86737660e-02f,
  -3.98404673e-02f, 1.83146074e-03f, 3.24907452e-02f, -2.51207477e-03f, 6.48968145e-02f, 6.60931831e-03f, 8.30941722e-02f, -1.19815888e-02f, 2.18251478e-02f, 6.92541972e-02f,
  1.03951031e-02f, 2.76048332e-02f, 4.15457971e-02f, -7.43681267e-02f, -8.97104144e-02f, 3.22425067e-02f, -9.04069394e-02f, -2.90709678e-02f, -2.13899277e-03f, 2.48141284e-03f,
  1.27474777e-02f, 1.21824302e-01f, -1.14039391e-01f, -2.61296462e-02f, 8.29671025e-02f, -5.44990636e-02f, -3.18588205e-02f, 1.87338062e-03f, -1.12022310e-01f, -4.80130911e-02f,
  6.51249960e-02f, -1.05246596e-01f, -6.70571923e-02f, 1.04126632e-01f, -9.91066769e-02f, -8.56972486e-03f, 4.35408689e-02f, 2.95508653e-02f, 3.81433801e-03f, 5.55177182e-02f,
  -6.70318156e-02f, -2.69879717e-02f, -1.74634829e-02f, -5.58436103e-02f, -3.65056610e-03f, 3.17981504e-02f, -3.12818885e-02f, -4.66360338e-02f, 3.79667245e-02f, -4.78928275e-02f,
  -1.23650350e-01f, -1.65800989e-01f, 7.98478276e-02f, 3.66777293e-02f, -2.82156449e-02f, -5.15873805e-02f, -9.89280045e-02f, 1.31689273e-02f, -8.83045644e-02f, -5.07187359e-02f,
  -9.76713840e-03f, 2.16919512e-01f, 6.40494153e-02f, 9.03607458e-02f, -2.48361751e-01f, -1.80725262e-01f, 1.62134260e-01f, -2.10330468e-02f, 3.22342254e-02f, 1.01922870e-01f,
  8.49396512e-02f, -1.46999568e-01f, 2.17231482e-01f, 3.64173949e-02f, 2.21370205e-01f, 2.24062055e-01f, -8.90319794e-02f, -4.68963571e-02f, 5.34766279e-02f, 8.43092501e-02f,
  4.29925211e-02f, 8.78429934e-02f, 2.08158404e-01f, -5.58626913e-02f, -9.27146301e-02f, 7.32769212e-03f, 1.22458652e-01f, -4.75175641e-02f, -9.62974429e-02f, -5.65716289e-02f,
  1.07064079e-02f, 4.40459996e-02f, -2.77600009e-02f, -6.40629977e-02f, 4.62328196e-02f, -1.79767739e-02f, -6.58461004e-02f, 4.21252623e-02f, -4.15633991e-03f, 2.26303656e-03f,
  1.62280686e-02f, 2.52091624e-02f, 1.59323625e-02f, 1.76250245e-02f, -4.73669320e-02f, -1.01717114e-02f, 9.61428043e-03f, -4.67343405e-02f, -1.48535604e-02f, 7.63894916e-02f,
  5.14999256e-02f, 7.21502230e-02f, -2.53075957e-02f, -4.58686706e-03f, 2.85181962e-02f, -5.73160173e-03f, -9.66704218e-04f, -8.66488181e-03f, -3.57166193e-02f, -3.46345790e-02f,
  7.44933635e-02f, -8.20179761e-04f, 5.20409318e-03f, 2.42959410e-02f, 3.40089016e-02f, -1.29261427e-02f, 5.32794511e-03f, 4.82679671e-03f, 2.16783937e-02f, -2.85201496e-03f,
  -4.67560105e-02f, -3.96090485e-02f, 1.84504967e-02f, -1.87787283e-02f, 2.90517192e-02f, 3.61350030e-02f, -4.34060581e-02f, 4.39495081e-03f, -6.92374259e-02f, -4.58517000e-02f,
  -2.41937991e-02f, -3.11108120e-02f, -4.99993972e-02f, 2.21147016e-02f, -4.75456417e-02f, -1.80624034e-02f, 4.87577665e-04f, 5.26136905e-03f, 1.75915677e-02f, -2.05022208e-02f,
  3.00545953e-02f, 2.87433714e-01f, 4.16559242e-02f, -2.00295690e-02f, -4.54308391e-02f, -3.83110642e-02f, -4.20424789e-02f, -3.20599861e-02f, 4.81891334e-02f, 2.49641947e-02f,
  1.86909698e-02f, 1.75570361e-02f, -4.71801199e-02f, -2.51819268e-02f, 7.85734877e-03f, 1.10215358e-01f, -1.06603652e-02f, 3.12506221e-02f, -6.78453478e-04f, -1.90468808e-03f,
  -2.05861442e-02f, -6.29355572e-03f, -1.60478428e-02f, -1.09019525e-01f, 3.70884761e-02f, -8.15054402e-03f, 3.36354114e-02f, -3.16415988e-02f, 8.19668174e-02f, 3.38648236e-03f,
  -4.56762880e-01f, -3.76018360e-02f, -1.42961726e-01f, -3.31514031e-01f, 2.28146650e-02f, 3.31562646e-02f, -1.79123789e-01f, 1.14351600e-01f, -2.96955526e-01f, 7.68998116e-02f,
  1.55857161e-01f, -2.82423586e-01f, 2.39601836e-01f, -2.69619346e-01f, -2.13376254e-01f, 3.36356685e-02f, -3.26858848e-01f, -1.62843809e-01f, -4.47300822e-03f, -1.86306238e-02f,
  -1.88317299e-02f, -3.16808261e-02f, -6.78744018e-02f, 2.68152148e-01f, -1.62701994e-01f, 1.15311861e-01f, 3.50639448e-02f, 1.39254019e-01f, -3.02708745e-02f, -2.70101093e-02f,
  -2.20775674e-03f, 2.36468529e-03f, -2.02161334e-02f, 6.28753845e-03f, -2.11128760e-02f, 4.93330928e-03f, 1.28417583e-02f, -1.04119675e-02f, -2.60631591e-02f, 1.35047548e-02f,
  -3.95924076e-02f, -2.39773504e-02f, -6.14806376e-02f, 4.34774868e-02f, -1.29385339e-02f, -1.81940366e-02f, -5.57357222e-02f, -3.38106193e-02f, -4.33879569e-02f, -2.91870255e-02f,
  -9.73063987e-03f, -9.37445741e-03f, -5.28727360e-02f, -3.95300165e-02f, -2.18186416e-02f, -1.32803926e-02f, -9.18597803e-02f, 1.87172852e-02f, -5.41983955e-02f, -3.16010080e-02f,
  3.80990212e-03f, -1.65809393e-02f, 2.07975012e-04f, -9.62110609e-03f, -2.22147834e-02f, 4.08126861e-02f, 1.05677759e-02f, 1.13669718e-02f, -3.76377143e-02f, 5.09659760e-03f,
  -1.51408222e-02f, -3.78103703e-02f, -3.26427221e-02f, -1.45508209e-03f, -2.06381548e-02f, 7.57924654e-03f, 3.03577457e-04f, 2.85238698e-02f, -3.85206863e-02f, 1.15207247e-02f,
  -4.19601594e-04f, -3.39598618e-02f, 5.51603325e-02f, 2.46480443e-02f, 5.98814851e-03f, 9.72186308e-03f, 2.63564344e-02f, -2.20350157e-02f, 5.68535365e-02f, 3.78233045e-02f,
  6.61622081e-03f, 3.09793861e-03f, 6.39596907e-03f, -1.56797785e-02f, -8.85108113e-03f, 2.03054957e-02f, -5.95410950e-02f, -2.81282775e-02f, -1.27365235e-02f, -5.07423803e-02f,
  3.08566764e-02f, 1.16850566e-02f, -2.90047601e-02f, -3.02399322e-03f, 1.37252463e-02f, 2.31785849e-02f, -4.04697750e-03f, -3.59001048e-02f, -4.70521599e-02f, 2.91159768e-02f,
  6.07335083e-02f, 1.83151737e-02f, -3.40901129e-03f, 1.42358812e-02f, -6.27037836e-03f, 1.93636920e-02f, 1.99047625e-02f, 3.57383327e-03f, 2.72667874e-02f, -2.12119054e-02f,
  4.52908650e-02f, -1.93630785e-01f, 4.51780036e-02f, 7.79023692e-02f, 7.93435499e-02f, 2.41294205e-01f, 2.35888377e-01f, 5.77830262e-02f, -2.46193446e-02f, -8.82900506e-02f,
  1.68281540e-01f, -1.78464651e-01f, 2.67520770e-02f, 1.14959449e-01f, 1.59686059e-01f, 5.62007865e-03f, 9.97186452e-02f, 1.59708913e-02f, -1.92995202e-02f, 1.37938574e-01f,
  8.20638984e-02f, 7.49898925e-02f, 8.22308436e-02f, -9.20125842e-02f, 4.35605310e-02f, -1.28303722e-01f, 1.21880583e-01f, -1.77397542e-02f, -8.79129395e-03f, -1.28309876e-02f,
  1.48436278e-01f, 2.74338052e-02f, -6.15960248e-02f, -6.73125759e-02f, 1.84944794e-01f, -8.50078743e-03f, 5.99402264e-02f, -5.08392137e-03f, 5.85524254e-02f, -4.93726283e-02f,
  -2.27174703e-02f, -6.58512935e-02f, -2.79397927e-02f, -5.22632524e-02f, -4.32280563e-02f, -8.09560120e-02f, -1.70226917e-02f, 9.32740271e-02f, 2.49625314e-02f, -7.32206553e-02f,
  -4.50607203e-03f, -4.46681418e-02f, 3.22242044e-02f, -2.67489627e-02f, 6.33384362e-02f, -3.13854031e-02f, -4.93340380e-02f, 1.81231101e-03f, -3.97115983e-02f, -6.13443777e-02f,
  5.34026586e-02f, 7.87006393e-02f, -4.24840823e-02f, -3.63052413e-02f, -8.80800188e-03f, 2.24910099e-02f, 5.15414448e-03f, 7.26971775e-02f, -4.38802131e-02f, 5.62962517e-02f,
  -2.61929375e-03f, -4.35766540e-02f, -1.35623449e-02f, 2.47064289e-02f, 7.01250359e-02f, -1.25398776e-02f, -1.88990578e-03f, -9.47555974e-02f, -1.72887444e-02f, -1.45349279e-03f,
  -3.83403450e-02f, -1.88049879e-02f, 3.57299671e-02f, 2.93074474e-02f, 1.66613739e-02f, -8.89866203e-02f, -1.26533331e-02f, -6.46763891e-02f, 4.70021255e-02f, 4.62483466e-02f,
  1.49900541e-02f, 1.06597118e-01f, 3.35830376e-02f, -3.54732275e-02f, -1.26764327e-02f, 3.64928842e-02f, -1.36779295e-02f, -8.07825476e-02f, 2.25911830e-02f, 3.70661612e-03f,
  3.92495804e-02f, 8.07429105e-02f, 7.97354430e-02f, -5.41970403e-05f, -3.35374288e-02f, -3.64290513e-02f, 1.55417109e-02f, -3.67454290e-02f, 9.37633663e-02f, 2.51979493e-02f,
  7.48731121e-02f, 3.06479204e-02f, -3.25265266e-02f, -6.28043041e-02f, -3.20584700e-02f, -2.54336298e-02f, 6.52555302e-02f, 1.51657471e-02f, 3.74630317e-02f, 1.00971498e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.30902159e-01f, 4.46058065e-03f, 3.80784333e-01f, -2.50810474e-01f, -7.74444565e-02f, 3.70558292e-01f, 2.20683873e-01f, -4.71373089e-02f, -1.40161917e-01f, -1.20331757e-01f,
  -1.27059549e-01f, 2.35242806e-02f, 2.20204130e-01f, -1.72650993e-01f, 3.89052451e-01f, 1.43476158e-01f, -7.79739171e-02f, 1.03231318e-01f, 4.26703878e-02f, -1.68073833e-01f,
  -8.08982551e-02f, -2.13982835e-01f, 1.54591247e-01f, -1.63320556e-01f, -1.36627838e-01f, -1.57187134e-01f, -3.35661769e-02f, 1.65714115e-01f, -1.78390592e-01f, 1.12381868e-01f,
  -1.13181971e-01f, 1.74195915e-02f, -1.25803858e-01f, -3.68746743e-02f, 4.63144742e-02f, 1.65463071e-02f, 1.55092224e-01f, 1.79126695e-01f, -9.31637958e-02f, -7.39340633e-02f,
  -3.54857147e-02f, 7.85500184e-02f, -1.29510030e-01f, -1.43770389e-02f, -2.34588832e-02f, 6.63786009e-03f, -5.52714430e-02f, -1.14344925e-01f, -7.33824745e-02f, 7.55785778e-02f,
  1.96934231e-02f, -4.33606375e-03f, -3.83675545e-02f, 5.36092371e-02f, 1.00288726e-01f, 6.00365289e-02f, 4.99804458e-03f, 3.33690718e-02f, -2.55141035e-02f, -6.48086295e-02f,
  7.19800591e-02f, 7.47496262e-02f, -2.35433299e-02f, -3.08934040e-02f, -1.04043055e-02f, -8.59137997e-02f, -5.60087711e-02f, 8.57498404e-03f, -1.39316488e-02f, -2.47010831e-02f,
  -5.27356043e-02f, 1.32585904e-02f, 7.46002048e-02f, 9.01763588e-02f, -5.41052260e-02f, -1.05757058e-01f, 9.86657385e-03f, -6.79152645e-03f, -2.93866545e-02f, 5.06880619e-02f,
  4.46010232e-02f, 8.80064741e-02f, 5.46437837e-02f, -2.35831402e-02f, 1.00145735e-01f, 1.27942219e-01f, -7.73928966e-03f, 4.29776758e-02f, -1.52216740e-02f, 1.63988788e-02f,
  1.32301385e-02f, 5.74174747e-02f, -1.50823977e-03f, 7.61734173e-02f, -2.57423297e-02f, 9.43844542e-02f, 3.67721803e-02f, -4.98628579e-02f, 2.02251859e-02f, -3.22847627e-02f,
  -7.14765862e-02f, 1.37778427e-02f, 4.30596527e-03f, 5.82042821e-02f, 2.38872264e-02f, -3.74589413e-02f, 5.95849529e-02f, -5.33491969e-02f, 3.27220671e-02f, -1.16207954e-02f,
  -7.79413432e-02f, 1.96930626e-03f, 6.68067485e-02f, 3.65212224e-02f, -2.40962952e-02f, 2.62860721e-03f, -5.15015945e-02f, 2.41441075e-02f, 6.72854558e-02f, -4.64662872e-02f,
  -6.45718932e-01f, 2.25731716e-01f, 2.85381764e-01f, -3.57773483e-01f, 2.20009908e-01f, 1.77645870e-02f, -1.82228580e-01f, 1.05680838e-01f, -7.24190706e-03f, -1.24611333e-01f,
  1.24316990e-01f, -8.41382593e-02f, 4.59217653e-02f, 1.13233358e-01f, -1.11717552e-01f, -6.71958551e-02f, -2.24031687e-01f, -9.06354710e-02f, 8.36757496e-02f, 9.39293671e-03f,
  -9.18166991e-03f, 9.34972540e-02f, 3.04318517e-02f, 2.46086836e-01f, 5.00455946e-02f, -4.14949991e-02f, -1.26355603e-01f, 1.87351182e-01f, -2.29098797e-02f, 1.27177641e-01f,
  -2.48796880e-01f, -8.35273489e-02f, -8.20477977e-02f, -3.90023435e-03f, -1.61466617e-02f, -1.67504642e-02f, -1.26834705e-01f, 6.85237572e-02f, 4.94463332e-02f, 1.97231676e-02f,
  -4.43686508e-02f, 5.36179617e-02f, -4.72170301e-02f, 9.76078212e-02f, -2.14133468e-02f, 4.57265340e-02f, 7.19409883e-02f, 3.54853868e-02f, 6.08266070e-02f, 1.25915065e-01f,
  4.53257449e-02f, -9.28818807e-03f, 2.74108928e-02f, -5.69443852e-02f, 4.14854325e-02f, 6.02234993e-03f, -9.64020938e-02f, -5.64115085e-02f, -4.25630249e-02f, -5.97618259e-02f,
  6.12968728e-02f, -9.69733950e-03f, 4.81356718e-02f, 2.67070625e-02f, 5.21679334e-02f, 4.90562581e-02f, 8.05117190e-03f, -2.79003046e-02f, -5.63590676e-02f, -2.67078746e-02f,
  -6.62485324e-03f, -1.14260130e-01f, -3.07649709e-02f, -1.34215141e-02f, -7.03572482e-02f, -5.52445203e-02f, -5.70577681e-02f, -2.89447163e-03f, -3.07285432e-02f, -3.02488860e-02f,
  -3.94743346e-02f, 2.09188554e-02f, 3.09741031e-02f, -7.79795041e-03f, 4.36154902e-02f, -4.73495126e-02f, 7.77340531e-02f, 2.74050012e-02f, -7.55021069e-03f, -3.65629457e-02f,
  -3.02479893e-01f, -2.64133275e-01f, 2.81440448e-02f, -3.15367021e-02f, -2.04930473e-02f, -1.15540056e-02f, -2.13633385e-02f, -4.06846171e-03f, -5.31488061e-02f, 3.95495109e-02f,
  5.81312291e-02f, -6.12478890e-02f, 2.63012853e-02f, -1.84860558e-03f, 1.81945774e-03f, -4.30353582e-02f, -7.34167621e-02f, -8.91042054e-02f, -8.58690590e-02f, 3.22887488e-02f,
  -5.07595800e-02f, -3.72968987e-02f, -4.03043851e-02f, -1.40772751e-02f, -1.43461693e-02f, -7.57860690e-02f, -2.59297490e-02f, 3.44651900e-02f, 1.84420459e-02f, 2.23520882e-02f,
  1.74133733e-01f, 3.66751514e-02f, 3.73636067e-01f, 3.88667643e-01f, -1.74428880e-01f, -2.61174887e-01f, -1.23698644e-01f, 4.20218594e-02f, -1.93560999e-02f, -2.86871314e-01f,
  -1.50080919e-01f, 2.27016568e-01f, -1.38769582e-01f, 1.12514347e-01f, 2.16308162e-01f, -1.43894270e-01f, -1.59487762e-02f, 5.97995631e-02f, 3.37732136e-02f, 1.30311459e-01f,
  5.30997403e-02f, -1.15284845e-01f, 3.26325208e-01f, 6.26382902e-02f, 1.63380489e-01f, 2.81108141e-01f, 1.31252617e-01f, 1.14597529e-01f, 2.65631050e-01f, 2.37177044e-01f,
  -1.57743737e-01f, 3.11403647e-02f, -7.55822461e-04f, 1.01763248e-01f, -4.99991402e-02f, -5.66899218e-02f, -6.41937330e-02f, 1.30331486e-01f, 7.95642957e-02f, 7.68893287e-02f,
  -4.67452370e-02f, 2.16330327e-02f, 5.83534278e-02f, 1.14116771e-02f, -1.05864316e-01f, 3.86414193e-02f, 5.27579011e-03f, 3.50829363e-02f, 1.67873167e-02f, 4.97718230e-02f,
  -5.52824885e-03f, 6.06999500e-03f, 5.18224016e-02f, 3.73792765e-03f, 7.30321333e-02f, 2.41802074e-02f, 3.49155487e-03f, 3.84816229e-02f, 4.37726453e-02f, -3.98350619e-02f,
  7.17168078e-02f, -4.62386906e-02f, 5.91794169e-03f, 6.19578436e-02f, 7.93866068e-02f, -8.05885345e-02f, -2.25120839e-02f, -5.13823740e-02f, -5.19027300e-02f, -2.79957689e-02f,
  -6.08982611e-03f, 8.59693997e-03f, -2.37718783e-02f, -5.64186387e-02f, -7.91030824e-02f, 2.94073299e-02f, -6.18140271e-04f, 2.77441423e-02f, -8.91084448e-02f, -1.38103422e-02f,
  -1.15628101e-01f, 2.92712692e-02f, 2.91154683e-02f, -1.17986640e-02f, 3.33284922e-02f, -1.07964072e-02f, 3.08494139e-02f, 7.02007189e-02f, -2.47315951e-02f, -6.16045259e-02f,
  -3.49968910e-01f, 8.87656510e-02f, -4.02532928e-02f, -5.35724871e-02f, -3.45928743e-02f, -6.24038577e-02f, 5.73132560e-02f, 1.51406983e-02f, 9.27390829e-02f, -8.95780604e-03f,
  -9.24243182e-02f, -3.70403491e-02f, -5.98624945e-02f, 2.15782151e-02f, 6.48094118e-02f, 3.41623351e-02f, -2.09415937e-03f, -2.34404635e-02f, -3.00669875e-02f, 3.61423343e-02f,
  4.89383191e-03f, -6.79168850e-02f, -6.38730871e-03f, -2.17319522e-02f, -5.56002446e-02f, -9.89966616e-02f, -3.69361192e-02f, 9.23243761e-02f, -4.58431356e-02f, 1.37872770e-02f,
  -4.68561172e-01f, 3.76277864e-01f, -1.51598796e-01f, 1.63943306e-01f, -2.21070796e-01f, 3.61123234e-01f, 3.37673753e-01f, -5.38119040e-02f, 3.40895690e-02f, 3.92248660e-01f,
  5.29981367e-02f, -5.97254150e-02f, 7.56281093e-02f, 3.51099908e-01f, -1.36748552e-01f, 3.50236893e-01f, 3.59934956e-01f, 2.44955212e-01f, 1.65867098e-02f, 1.72896578e-03f,
  -1.08830534e-01f, 1.69397160e-01f, 2.11480409e-02f, 1.06807956e-02f, -6.22748397e-02f, -1.98766083e-01f, -5.18136732e-02f, -1.45400092e-01f, 2.29526870e-02f, -3.52500565e-02f,
  5.07509746e-02f, -3.68782505e-02f, -1.20728031e-01f, 2.36417502e-02f, 2.96496414e-02f, 4.90693115e-02f, 2.87390146e-02f, -8.98157731e-02f, -1.02774642e-01f, 8.84056762e-02f,
  -9.24896523e-02f, -8.91094431e-02f, 1.15211636e-01f, -5.42841777e-02f, -5.99314049e-02f, -3.40816043e-02f, -7.07332939e-02f, 5.14674634e-02f, 1.61979329e-02f, -8.02128762e-02f,
  -3.56688648e-02f, -2.94856001e-02f, -4.27164584e-02f, 1.42199397e-01f, -7.77967051e-02f, -1.17764873e-02f, 9.52632651e-02f, -5.72277941e-02f, 3.37957554e-02f, -6.78493874e-03f,
  -5.74975647e-03f, -1.16119431e-02f, 5.72452471e-02f, 3.33801806e-02f, 2.24303044e-02f, 2.44073663e-02f, -4.01780047e-02f, -2.65736431e-02f, -3.00732534e-02f, 4.82104160e-02f,
  -3.18078808e-02f, -5.35273850e-02f, 4.27602567e-02f, 3.47609892e-02f, 4.35327813e-02f, 4.84093279e-02f, -3.64128985e-02f, -5.91486581e-02f, 6.16242066e-02f, -5.17830253e-02f,
  1.96065959e-02f, 1.52639104e-02f, 2.11254172e-02f, 7.51417875e-02f, -1.40475063e-02f, -3.05883195e-02f, 6.70862347e-02f, -1.10119190e-02f, -8.65706652e-02f, -3.46456096e-02f,
  1.54799655e-01f, 1.37581572e-01f, 1.35735245e-02f, 2.17341464e-02f, 3.76638025e-02f, -2.56760325e-02f, 2.89561693e-02f, 3.01734582e-02f, 1.05072603e-01f, -9.19642765e-03f,
  4.38570864e-02f, 6.02758909e-03f, -4.89180163e-02f, -2.37675142e-02f, 2.60728952e-02f, 2.83415932e-02f, 4.88095805e-02f, 1.60089619e-02f, -1.12747075e-02f, 3.82596999e-02f,
  -4.61969748e-02f, 1.42851463e-02f, -2.46563200e-02f, 1.66119933e-02f, -4.11530249e-02f, 3.62593159e-02f, -5.84612936e-02f, 1.87311936e-02f, -7.95969460e-03f, 3.64746600e-02f,
  5.46371453e-02f, -1.85603738e-01f, -3.92561644e-01f, -1.70111373e-01f, -2.63374448e-01f, -3.47920358e-01f, -3.02793294e-01f, -2.63305426e-01f, 2.96179540e-02f, 7.93555900e-02f,
  -9.72741619e-02f, 5.50425872e-02f, 3.25300276e-01f, -9.36356857e-02f, 1.61974400e-01f, 2.92212248e-01f, -1.59951538e-01f, -4.45475467e-02f, -1.89644750e-02f, -2.83396155e-01f,
  -1.42292529e-02f, -1.03564724e-01f, 4.88854125e-02f, -2.40421444e-01f, -3.10110867e-01f, -1.47267789e-01f, 1.05031252e-01f, -1.70419246e-01f, -1.21096902e-01f, -7.02512637e-02f,
  -6.88394085e-02f, -1.89167466e-02f, -6.04605637e-02f, 5.32245869e-03f, -8.18360448e-02f, -2.67611295e-02f, -1.69688314e-01f, 3.31997164e-02f, 4.13079485e-02f, -2.23891493e-02f,
  -1.22441780e-02f, 6.13885224e-02f, -6.86868653e-02f, 4.25985530e-02f, -1.50116593e-01f, -8.28182325e-02f, -2.91808862e-02f, -3.89584117e-02f, -4.64116931e-02f, 8.77910387e-03f,
  -4.35531512e-02f, -9.86375362e-02f, -9.54886749e-02f, 1.10940307e-01f, -5.98635711e-02f, -1.33333549e-01f, 3.55982482e-02f, 1.63747706e-02f, -5.51427640e-02f, -1.02988847e-01f,
  1.99654456e-02f, 2.81890612e-02f, 1.98639780e-02f, -1.90681126e-02f, -7.51099437e-02f, 5.25144786e-02f, -4.26607616e-02f, 4.75655347e-02f, 3.71771455e-02f, 5.32827899e-02f,
  6.58200309e-02f, 3.98471579e-02f, -6.92851422e-03f, -3.41821983e-02f, -1.32144988e-02f, -1.75431445e-02f, -8.57455749e-03f, -4.99134883e-03f, -6.19974583e-02f, -5.16677685e-02f,
  6.60699084e-02f, -3.02353967e-02f, 1.29436273e-02f, 2.94722226e-02f, -3.74587774e-02f, 5.90630248e-03f, 4.24855761e-02f, 6.35813102e-02f, -1.38823345e-01f, -5.35524972e-02f,
  -1.50922596e-01f, -1.78463385e-01f, -2.40713079e-02f, 5.62286377e-02f, 3.43004912e-02f, -3.60720791e-02f, -2.81834882e-02f, -8.18216950e-02f, -1.47920027e-01f, -5.24484701e-02f,
  -1.41231894e-01f, 1.05352178e-01f, -4.39390764e-02f, 2.38907188e-02f, 8.01089555e-02f, -8.41770917e-02f, -1.34180505e-02f, -4.31263633e-02f, -6.22698292e-02f, -2.35237386e-02f,
  1.15362732e-02f, 6.44323900e-02f, 1.71624631e-01f, 6.17887750e-02f, 1.09522305e-02f, -1.33875955e-03f, -3.13601829e-02f, 5.59261180e-02f, -9.85514969e-02f, 5.21371514e-02f,
  -1.69442460e-01f, -9.38551407e-03f, -2.03365564e-01f, -2.42212683e-01f, -2.28405707e-02f, 1.43506855e-01f, -5.82115576e-02f, 2.45855544e-02f, -2.03962833e-01f, 1.82798415e-01f,
  2.01641634e-01f, -2.41524935e-01f, 5.61514646e-02f, -6.61936179e-02f, -3.12699527e-01f, -9.41460505e-02f, -7.94607624e-02f, 1.06262229e-02f, -1.09201938e-01f, 1.22142643e-01f,
  -1.54078558e-01f, 1.70079723e-01f, -4.61723246e-02f, 2.98871338e-01f, 3.22243869e-02f, 1.98817383e-02f, 9.10980403e-02f, 9.67042744e-02f, 1.08689228e-02f, -1.87897943e-02f,
  -3.35029978e-03f, 6.52826875e-02f, 9.16567817e-03f, 8.79046768e-02f, 7.62680620e-02f, 5.40012680e-02f, 2.51744203e-02f, -9.99015849e-03f, -5.82409538e-02f, -4.24865000e-02f,
  -3.83456275e-02f, -4.22360189e-02f, -5.77757880e-02f, -1.25179961e-01f, -8.35223347e-02f, -9.38302800e-02f, 2.51994822e-02f, -5.09251170e-02f, 1.88307855e-02f, -5.09779006e-02f,
  9.10337456e-03f, -9.61833596e-02f, -8.46209824e-02f, -5.03708757e-02f, -2.69034635e-02f, 4.13333848e-02f, -2.02024765e-02f, 1.90984663e-02f, -3.83125059e-02f, -1.15128674e-01f,
  -4.96314876e-02f, -8.39092024e-03f, 8.23891461e-02f, -3.87296304e-02f, 2.27166340e-02f, 5.25710033e-03f, 3.05244997e-02f, 4.04936485e-02f, -5.05187586e-02f, 3.66240703e-02f,
  1.89340301e-02f, 3.25799324e-02f, -6.66997535e-03f, 7.47584030e-02f, -1.89917739e-02f, 1.34978639e-02f, 4.60996069e-02f, -2.31638290e-02f, -8.80452096e-02f, 3.17231677e-02f,
  5.88266971e-03f, -4.14569937e-02f, 2.24649552e-02f, -3.11211348e-02f, 3.79798934e-02f, -6.65425956e-02f, -7.36408383e-02f, -3.41953859e-02f, 1.45073729e-02f, -1.22471385e-01f,
  4.18137014e-02f, 2.50599552e-02f, 5.53172342e-02f, -4.13541123e-02f, 1.55249750e-02f, 2.20832843e-02f, 4.20166273e-03f, -5.56670353e-02f, -3.14229392e-02f, -1.07277965e-03f,
  1.70579627e-02f, 7.56040066e-02f, 4.15508561e-02f, -4.46878374e-02f, -7.07175806e-02f, -6.77952766e-02f, 3.40285071e-04f, 1.19630508e-01f, -7.33304322e-02f, -4.63214256e-02f,
  9.91989002e-02f, 6.29526004e-02f, 2.73926975e-03f, 6.49164617e-02f, 7.75993541e-02f, 7.77088664e-03f, -1.46782070e-01f, 4.92055481e-03f, -6.57116026e-02f, 2.75153257e-02f,
  2.85399575e-02f, -8.19314048e-02f, -3.46524775e-01f, -5.51887900e-02f, 5.42596355e-02f, 3.19867948e-04f, -2.77856857e-01f, 7.00131953e-02f, -3.19952905e-01f, 1.72929823e-01f,
  2.13645443e-01f, -6.90566227e-02f, -2.14240566e-01f, 2.44212851e-01f, 2.09622785e-01f, -2.11760744e-01f, 1.92997053e-01f, 6.03500307e-02f, -1.15104489e-01f, 2.39560828e-01f,
  5.71093298e-02f, 4.53085989e-01f, 1.82105619e-02f, 3.10856193e-01f, 9.24171228e-03f, -7.09037706e-02f, 3.91101897e-01f, -2.33788062e-02f, 4.51000929e-01f, 1.83923751e-01f,
  -1.10693146e-02f, -3.88753377e-02f, -4.95922863e-02f, -1.20226845e-01f, 5.66395819e-02f, 2.47898642e-02f, -1.05101978e-02f, -3.44630182e-02f, -1.27201034e-02f, 1.41946534e-02f,
  -1.10359274e-01f, 1.78205222e-02f, 4.91501240e-04f, -4.68485616e-02f, -5.65134138e-02f, -4.97674532e-02f, -6.15106374e-02f, -1.33004501e-01f, -1.00408278e-01f, 4.36575972e-02f,
  -9.61825252e-02f, 1.38730463e-02f, -4.60897237e-02f, 2.90277833e-03f, -5.94981574e-03f, 4.84433658e-02f, -5.76126575e-02f, -7.65469968e-02f, -2.60635838e-02f, 6.11460134e-02f,
  1.20273918e-01f, -4.05853689e-02f, -2.63680294e-02f, 1.91844516e-02f, -1.76684349e-03f, 4.38961275e-02f, 5.44175878e-02f, 1.37953106e-02f, -5.71681745e-02f, 4.19444814e-02f,
  7.35617727e-02f, -2.64345948e-02f, 2.81702746e-02f, 3.30300704e-02f, 2.43040342e-02f, -3.86780761e-02f, -4.52060737e-02f, -1.10459561e-02f, 1.71354022e-02f, -4.69546728e-02f,
  -4.18098792e-02f, 1.31735995e-01f, 3.24004591e-02f, -5.79508133e-02f, 6.53615370e-02f, 2.73883697e-02f, 1.29839778e-01f, 2.46939659e-02f, -8.26071575e-02f, -2.84003746e-02f,
  7.05975741e-02f, 1.30967796e-01f, -3.14824954e-02f, 6.77184686e-02f, -9.97004565e-03f, 1.39545470e-01f, -5.32691926e-02f, 7.97602311e-02f, 3.52930687e-02f, -7.37843802e-03f,
  1.01346649e-01f, -3.51677798e-02f, 7.99781531e-02f, 1.59695763e-02f, 1.41354010e-01f, 5.30348644e-02f, 6.51824474e-02f, 6.03374615e-02f, 8.71681944e-02f, 9.71372351e-02f,
  -3.49165942e-03f, -6.45256564e-02f, 6.00288063e-02f, -9.30305868e-02f, 1.07669771e-01f, -6.87365085e-02f, -3.76712829e-02f, 3.43464762e-02f, 7.26142302e-02f, -5.29781394e-02f,
  -3.45983833e-01f, -3.35458443e-02f, 1.70973465e-01f, -2.24851429e-01f, 2.49865741e-01f, 2.47080296e-01f, 1.23572066e-01f, -1.15925178e-01f, -3.10026228e-01f, -2.93492407e-01f,
  -1.13785841e-01f, 4.35207039e-03f, 1.42368451e-01f, -1.78973585e-01f, 2.79749066e-01f, 2.05759600e-01f, -5.59339225e-02f, -1.85646996e-01f, 6.58535510e-02f, -1.12703018e-01f,
  -1.04645919e-03f, -1.55801371e-01f, 1.84359536e-01f, 2.99636769e-04f, 6.96835443e-02f, -1.21598691e-01f, -7.12056533e-02f, 1.08031824e-01f, -2.21984833e-02f, -1.07463459e-02f,
  4.11173180e-02f, -1.90351456e-01f, 1.17250308e-01f, 4.10635211e-02f, -5.59700131e-02f, 7.20525384e-02f, -6.43382454e-03f, 1.31075472e-01f, 5.47991134e-02f, 4.30934876e-02f,
  -1.62474588e-02f, 7.82993995e-03f, -7.08750486e-02f, -6.48750886e-02f, -3.52316871e-02f, -1.15442790e-01f, -3.03310696e-02f, 1.12489007e-01f, 3.74771096e-02f, 3.38921919e-02f,
  1.37506714e-02f, 4.46489304e-02f, -4.76436391e-02f, -5.85822947e-02f, 2.03222465e-02f, -2.92440746e-02f, 3.15225720e-02f, 1.52825102e-01f, 1.99957211e-02f, -4.29403819e-02f,
  -5.87295927e-02f, 1.91006362e-02f, -1.24654500e-02f, -5.31383939e-02f, -8.08546843e-04f, -1.19278263e-02f, -6.14272505e-02f, -1.29237967e-02f, -4.27114256e-02f, -6.49084570e-03f,
  5.31087071e-02f, -5.20408675e-02f, -4.70249616e-02f, -5.85218221e-02f, -1.21465571e-01f, -6.06220365e-02f, -1.94663331e-02f, -6.75706342e-02f, -2.94177476e-02f, -3.88994478e-02f,
  -1.22481763e-01f, 6.86186925e-03f, 2.01636553e-02f, -5.72979599e-02f, 3.28045115e-02f, 1.17126368e-02f, -4.55812439e-02f, 2.90724728e-03f, -5.10238297e-02f, 5.45625314e-02f,
  -6.62282109e-02f, -3.12268496e-01f, -4.91044372e-02f, -4.87179756e-02f, -6.28364086e-02f, -1.83695219e-02f, -3.49683389e-02f, -1.05307642e-02f, -1.54983914e-02f, -1.74389151e-03f,
  -6.31502047e-02f, -4.34918478e-02f, 1.40434489e-01f, 4.31998307e-03f, 9.68754385e-03f, 5.31348176e-02f, 7.40256533e-03f, 1.47879254e-02f, -4.69573913e-03f, -2.42687799e-02f,
  6.95705181e-03f, -7.45503083e-02f, -2.34069284e-02f, -4.02745530e-02f, -3.81994098e-02f, -6.96528628e-02f, 3.50440629e-02f, -9.06048790e-02f, 7.34558329e-02f, 1.49207506e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.20977193e-01f, 7.98802525e-02f, 1.60878643e-01f, 1.39209449e-01f, -1.54043622e-02f, 7.32001960e-02f, 1.15888163e-01f, 1.25915572e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.55422920e-01f, -7.34735355e-02f, -7.03597590e-02f, 1.03164874e-01f, -1.43353999e-01f, -4.51538920e-01f, 1.69528633e-01f, -1.98791459e-01f, -1.85051501e-01f, -1.91430330e-01f,
  1.34972617e-01f, -2.34604135e-01f, -8.36059004e-02f, -9.30873901e-02f, 1.09655306e-01f, 1.08365983e-01f, -3.45444344e-02f, 2.73115247e-01f, 2.57234246e-01f, -3.71373117e-01f,
  -1.70752838e-01f, 2.36711919e-01f, -4.04217809e-01f, -4.79925759e-02f, -3.05251759e-02f, -4.14901793e-01f, 2.57109940e-01f, 1.06562085e-01f, 2.05102935e-01f, -1.51193812e-01f,
  -4.91716973e-02f, -3.48361656e-02f, 5.84539808e-02f, -2.79133409e-01f, -1.45085379e-01f, 9.19848830e-02f, 2.36296162e-01f, 1.09169781e-01f, -3.22539210e-01f, 1.21836849e-01f,
  7.51759112e-02f, 1.50077507e-01f, 3.63536716e-01f, -3.80050042e-03f, -1.80329546e-01f, 1.07254267e-01f, -8.97268020e-03f, -2.56550342e-01f, -2.40307078e-01f, -1.91969737e-01f,
  7.69303963e-02f, 1.05021931e-01f, 1.62843734e-01f, 1.58785358e-01f, 5.16733043e-02f, 1.91856235e-01f, 2.77495116e-01f, 1.00743905e-01f, -1.23579964e-01f, 1.54804513e-01f,
  -1.98818713e-01f, 1.67139575e-01f, -1.96700454e-01f, 3.18044126e-01f, 2.18157142e-01f, -1.62307784e-01f, -8.43027383e-02f, -1.52955025e-01f, 1.53674588e-01f, -1.19737811e-01f,
  5.29082790e-02f, 1.51330024e-01f, 2.09448695e-01f, -1.28273711e-01f, -9.63794887e-02f, 1.81647036e-02f, 2.17887297e-01f, 2.72276074e-01f, -3.18576157e-01f, 2.03073025e-01f,
  -1.81595013e-02f, 1.38324341e-02f, 1.88567623e-01f, -1.94654644e-01f, 8.03049207e-02f, 3.63238305e-01f, 1.04184113e-01f, -1.06415726e-01f, 4.01183307e-01f, 2.16315091e-01f,
  -4.64192213e-04f, 1.83517799e-01f, 3.02864462e-01f, 6.53887028e-03f, -1.99117288e-01f, 3.79956573e-01f, 2.78210759e-01f, 2.99115449e-01f, 9.70790461e-02f, 3.68601456e-02f,
  -5.64938560e-02f, 5.25495037e-02f, -1.32386819e-01f, 3.53734903e-02f, -7.00333789e-02f, -7.25728124e-02f, -3.12455535e-01f, -1.31509945e-01f, 9.12853032e-02f, -1.11939693e-02f,
  -8.95032883e-02f, 4.64708984e-01f, 2.24458084e-01f, -1.87664125e-02f, -1.00803405e-01f, -4.17420059e-01f, -1.76068276e-01f, 7.91499317e-02f, -9.63862240e-02f, -3.20369393e-01f,
  8.08188543e-02f, 1.97705343e-01f, -7.00521916e-02f, 1.51505724e-01f, 3.13722074e-01f, 7.26061612e-02f, -2.07233757e-01f, 6.08041883e-03f, 6.07595267e-03f, 1.85506821e-01f,
  9.85191241e-02f, 2.65323818e-01f, -2.01929882e-02f, -4.65527736e-02f, 5.93895353e-02f, 6.72717690e-02f, 7.18593374e-02f, 2.91167468e-01f, -1.78600088e-01f, 1.59473583e-01f,
  1.40973449e-01f, 9.73535609e-03f, 1.29591022e-02f, 2.39471272e-01f, 3.48248422e-01f, 2.05079000e-02f, -2.51262099e-01f, -1.02890633e-01f, -4.65646647e-02f, 4.39876094e-02f,
  1.84649616e-01f, -1.94730014e-01f, -2.04741374e-01f, 3.00362378e-01f, -1.73109502e-01f, -5.86481765e-02f, -2.71920353e-01f, 2.84368545e-01f, -2.35842690e-01f, -2.29037963e-02f,
  1.51920691e-01f, -7.23456964e-02f, -4.92545180e-02f, -1.11468829e-01f, 4.25498150e-02f, 1.09606601e-01f, -1.17740497e-01f, 6.70714676e-02f, 1.40793398e-01f, 2.22008064e-01f,
  2.87296951e-01f, 2.74243355e-01f, -6.47973716e-02f, 1.67432442e-01f, 7.32390806e-02f, -2.92544544e-01f, -4.36676107e-03f, -2.28564799e-01f, 8.16786587e-02f, 2.59527892e-01f,
  2.31028154e-01f, -2.62613297e-01f, -2.49167144e-01f, 2.56511658e-01f, 1.78390145e-02f, -8.55223369e-03f, -3.02833468e-01f, 5.00444509e-02f, -4.89475965e-01f, -9.15022753e-03f,
  2.62742162e-01f, 1.19558282e-01f, -1.04558408e-01f, 3.88648957e-01f, -7.98009743e-04f, -2.11099610e-02f, -1.50985554e-01f, 3.63288224e-02f, 6.89803883e-02f, 1.30441487e-01f,
  1.60139017e-02f, 1.06108531e-01f, -1.31845638e-01f, -2.57375300e-01f, -1.19680330e-01f, 7.98829645e-02f, 2.49978513e-01f, 1.90377951e-01f, 1.77444965e-01f, 1.65059969e-01f,
  3.63219976e-02f, -1.92847639e-01f, -1.03521518e-01f, -1.81990996e-01f, 7.50646740e-02f, -1.70350522e-01f, 2.15033844e-01f, 3.09637994e-01f, -1.52511880e-01f, -2.34361261e-01f,
  1.00085042e-01f, -5.32526597e-02f, -3.33654344e-01f, 2.26540968e-01f, -2.56325603e-01f, 3.38156193e-01f, -2.81168371e-02f, -1.49684414e-01f, -1.58332199e-01f, -9.85223576e-02f,
  -1.09321699e-01f, -9.56166610e-02f, -1.66548491e-01f, -1.39694855e-01f, -3.39834660e-01f, -3.40776369e-02f, -9.96844750e-03f, -5.39092645e-02f, 3.13216120e-01f, -2.76431348e-02f,
  -1.26055917e-02f, 4.40953188e-02f, -3.82435709e-01f, 5.47556803e-02f, -2.67877221e-01f, -2.27090329e-01f, 2.72193067e-02f, 1.16192400e-01f, -2.47645646e-01f, 1.58439338e-01f,
  -7.02357665e-02f, -2.59487629e-01f, -5.16094901e-02f, 4.11056392e-02f, 1.48992136e-01f, -1.85555592e-01f, 1.71592057e-01f, -2.15228096e-01f, 4.92733642e-02f, -1.06999694e-04f,
  2.06602857e-01f, 1.69517860e-01f, -1.35218529e-02f, -3.29131931e-02f, 7.97172189e-02f, 1.75943419e-01f, -1.42281607e-01f, -1.31149173e-01f, 1.20568871e-01f, 1.12199351e-01f,
  -1.61555707e-01f, 6.88556954e-02f, -3.91371660e-02f, 7.82072246e-02f, 7.71707371e-02f, 1.88985781e-03f, 1.72367826e-01f, 1.55110970e-01f, 3.53178769e-01f, -1.06380880e-01f,
  9.21210498e-02f, 7.30919912e-02f, -4.51112121e-01f, 3.78016531e-01f, 1.90693185e-01f, -1.09354714e-02f, 3.17495354e-02f, 4.56645712e-02f, -2.05595046e-01f, 1.64483488e-01f,
  2.44509906e-01f, -6.37075827e-02f, -2.17392325e-01f, 2.91961543e-02f, -1.42386630e-01f, 6.54159337e-02f, 1.11907639e-01f, 5.14686182e-02f, -2.88498223e-01f, 1.39847681e-01f,
  1.43855035e-01f, -1.49686545e-01f, -1.03439562e-01f, 3.25702965e-01f, 1.54591024e-01f, 2.49572217e-01f, -3.48310024e-01f, 1.54720694e-02f, -2.67899185e-02f, -2.27169320e-01f,
  2.16647089e-01f, -9.69736800e-02f, -3.20663042e-02f, 2.98109591e-01f, -1.88166231e-01f, -7.93343708e-02f, -3.58888924e-01f, 1.80034295e-01f, -1.36603788e-01f, 7.79260695e-02f,
  2.70410217e-02f, 3.35991383e-04f, 8.75174552e-02f, -2.31715113e-01f, -2.22478375e-01f, 1.32280346e-02f, 1.04505196e-01f, -1.29586428e-01f, -2.63075791e-02f, -1.16459943e-01f,
  2.38787621e-01f, 1.50338292e-01f, -3.02729696e-01f, -3.59971151e-02f, 2.79469907e-01f, -2.27680698e-01f, -1.70582324e-01f, -8.83359239e-02f, 1.66539088e-01f, -2.08268628e-01f,
  8.65269080e-02f, -2.92353421e-01f, -4.76766735e-01f, 9.87997130e-02f, 1.52622163e-01f, -2.02915430e-01f, 3.01534355e-01f, -5.10616004e-01f, -1.70466796e-01f, -2.28140742e-01f,
  -1.50174037e-01f, 1.67333275e-01f, 9.17363018e-02f, 1.02691568e-01f, 1.25656381e-01f, 7.21911713e-02f, 4.49717492e-02f, -1.90358490e-01f, 2.46236429e-01f, -1.21271022e-01f,
  -1.87284052e-01f, -9.41200033e-02f, 5.10987267e-02f, -1.97789930e-02f, 4.41889018e-02f, -3.19581330e-01f, -1.01436228e-01f, 1.81411758e-01f, 2.84596801e-01f, 6.89910129e-02f,
  -3.36683035e-01f, 1.07544750e-01f, -1.36057884e-01f, -2.21750706e-01f, -2.66072214e-01f, 1.93634748e-01f, -9.70653221e-02f, -2.07715899e-01f, 2.29863197e-01f, 4.05714773e-02f,
  -5.91717839e-01f, -1.23186871e-01f, 2.76602983e-01f, -2.45986030e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.21546162e-02f, 4.45681036e-01f, 3.14837754e-01f, -2.33937487e-01f, -3.18225205e-01f, 1.73389278e-02f, 3.47480565e-01f, -1.87581390e-01f, -2.72473171e-02f, 2.27471650e-01f,
  2.25075349e-01f, -1.27179818e-02f, -4.24918920e-01f, -1.40632108e-01f, 2.55751073e-01f, -1.01216868e-01f, 2.26786435e-02f, -9.41087157e-02f, 3.42412293e-01f, -2.63171941e-01f,
  1.07723214e-01f, -3.08890402e-01f, -3.79404664e-01f, 1.80998906e-01f, 2.61417180e-01f, -1.72342613e-01f, 1.18635267e-01f, -6.02136672e-01f, -1.00220228e-02f, -2.38888487e-01f,
  -3.18112820e-02f, 1.85390785e-01f, 2.52742559e-01f, 5.00706196e-01f, 1.65469304e-01f, 2.98995614e-01f, -6.30562529e-02f, 1.11396551e-01f, 2.83363640e-01f, 2.84884721e-01f,
  6.39877841e-02f, 3.72055739e-01f, 9.55054611e-02f, -2.50430465e-01f, -1.19478673e-01f, 1.01823139e-03f, 3.26468378e-01f, -1.02398522e-01f, 7.59090930e-02f, -1.04312655e-02f,
  3.33551794e-01f, -3.19325954e-01f, 3.41117196e-02f, -2.47031748e-01f, -2.11341202e-01f, -1.03523090e-01f, 2.51966357e-01f, 4.02449012e-01f, 8.93275216e-02f, -3.79866481e-01f,
  1.23432204e-01f, -3.73341292e-01f, -5.64586282e-01f, 4.92102236e-01f, 1.70363616e-02f, 2.35242009e-01f, 1.35703787e-01f, 7.87403360e-02f, 4.05719467e-02f, -6.52963817e-02f,
  5.79879619e-02f, 2.03127950e-01f, -7.35256076e-02f, 1.36488751e-01f, 7.48979971e-02f, 3.89570631e-02f, -2.90997207e-01f, -1.12769030e-01f, 3.79447848e-01f, -4.03774530e-01f,
  -9.32322666e-02f, 1.13040376e-04f, 1.80056036e-01f, -3.26536089e-01f, -2.62290865e-01f, -1.90697402e-01f, -2.69080281e-01f, 3.08497977e-02f, 2.79521737e-02f, -2.29027629e-01f,
  2.51294464e-01f, -4.81160223e-01f, 2.94257365e-02f, -3.22850883e-01f, -5.50739884e-01f, 5.00331679e-03f, 2.23673865e-01f, -2.26238206e-01f, 4.70318422e-02f, 2.87067384e-01f,
  2.19596744e-01f, -6.24348372e-02f, 1.44617841e-01f, 9.03791636e-02f, 1.22048222e-01f, 1.01586416e-01f, 3.92615616e-01f, 2.03375801e-01f, -1.33197471e-01f, 1.54353827e-01f,
  -2.64333189e-01f, -6.38938695e-02f, -1.86102360e-01f, -8.45274106e-02f, 9.76668149e-02f, 3.64553705e-02f, 9.39031243e-02f, 3.17228556e-01f, -1.07431352e-01f, 2.56114662e-01f,
  4.00387526e-01f, 9.45614651e-02f, -1.18638493e-01f, 2.16302067e-01f, 1.05184518e-01f, -2.06973657e-01f, -1.88718829e-02f, 7.32978359e-02f, 5.21129854e-02f, 1.21214107e-01f,
  -3.39966714e-02f, 1.08040139e-01f, 8.78504589e-02f, 2.89809883e-01f, -7.59516582e-02f, 3.76656860e-01f, 1.62334889e-01f, 2.42196977e-01f, -2.04464421e-02f, 9.03629661e-02f,
  2.15091724e-02f, 2.87886143e-01f, 1.57011319e-02f, 1.98593438e-01f, -2.97864586e-01f, -2.74214476e-01f, -9.28966030e-02f, -2.47323588e-01f, 3.40160839e-02f, 1.05471477e-01f,
  1.28925219e-01f, -1.45662710e-01f, 3.26296717e-01f, 4.19635594e-01f, -1.42130619e-02f, 1.01098001e-01f, 3.52225527e-02f, -6.33586291e-03f, -3.40787143e-01f, 3.75949651e-01f,
  5.15886061e-02f, -7.95589983e-02f, -3.16038817e-01f, -1.66492481e-02f, 5.97423464e-02f, -1.26211643e-01f, 7.65767917e-02f, -1.75514407e-02f, 1.89086609e-02f, -4.78433119e-03f,
  3.37515444e-01f, 1.18018147e-02f, -1.32921308e-01f, 3.28530550e-01f, -3.62138927e-01f, -1.66180223e-01f, 5.62090799e-03f, -2.46626157e-02f, 4.90912646e-01f, 2.96760470e-01f,
  2.13665426e-01f, 1.02980927e-01f, 1.30011290e-01f, 1.66201413e-01f, -2.11683527e-01f, -8.25474262e-02f, -4.99999285e-01f, 2.45828241e-01f, 2.89590567e-01f, 1.56319052e-01f,
  2.13401988e-01f, -4.21300381e-01f, 3.93174171e-01f, 2.06418917e-01f, 1.82828948e-01f, 2.04726517e-01f, 4.82162870e-02f, -1.54676870e-01f, 2.95751542e-01f, 2.74911337e-02f,
  4.58334722e-02f, 1.09790899e-01f, 2.88624167e-01f, 2.85721987e-01f, 1.38746291e-01f, -2.45457783e-01f, 1.85457349e-01f, 3.34161401e-01f, 3.01650107e-01f, 2.49386713e-01f,
  -2.95639843e-01f, -1.49330139e-01f, -9.19947997e-02f, -3.82508114e-02f, -2.34726414e-01f, 2.09574099e-03f, 2.92161107e-01f, 1.65318936e-01f, 4.48635519e-01f, -1.49576172e-01f,
  -2.07907194e-03f, 3.33813205e-02f, 2.35799193e-01f, -2.84527447e-02f, 3.78981143e-01f, -1.99435532e-01f, 1.53823912e-01f, 1.71492934e-01f, 2.58186460e-01f, 1.04901813e-01f,
  -1.20052576e-01f, 1.12867147e-01f, 2.19255269e-01f, 1.38283104e-01f, 2.26223946e-01f, 3.11943859e-01f, -5.78961521e-02f, 2.18889475e-01f, -3.34345311e-01f, 1.59928679e-01f,
  -1.49883196e-01f, -2.84149885e-01f, -1.84381604e-01f, -1.42755315e-01f, 2.34706685e-01f, 2.63008207e-01f, -3.19325835e-01f, 2.40698069e-01f, 2.26845607e-01f, -1.67723268e-01f,
  2.40486562e-01f, 5.11629224e-01f, -5.62310815e-02f, -1.02529094e-01f, 5.05391993e-02f, 1.62346840e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  4.02265787e-02f, 2.13902608e-01f, 1.15905762e-01f, -3.50782312e-02f, 2.29517326e-01f, -1.28392011e-01f, 1.66360438e-01f, -1.85311586e-02f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.09068155e-01f, -1.68474346e-01f, -1.20187990e-01f, 1.67100474e-01f, 1.73821952e-02f, 1.77945733e-01f, -1.29234940e-01f, 1.88437372e-01f, 1.93858724e-02f, 2.45482363e-02f,
  7.53855631e-02f, 1.62870884e-02f, -3.51811826e-01f, 7.08718505e-03f, -1.24908783e-01f, 5.78804947e-02f, 1.39743283e-01f, 4.90117930e-02f, 2.18543217e-01f, -2.31102761e-02f,
  5.49286343e-02f, 3.90541524e-01f, -1.45014167e-01f, -2.36542206e-02f, -2.97539890e-01f, 2.58541200e-02f, -3.74952048e-01f, -2.33201727e-01f, 1.51853591e-01f, -3.49703580e-01f,
  1.21533461e-01f, -1.07252523e-01f, -1.70686230e-01f, -2.34741736e-02f, -2.60936702e-03f, -2.69868016e-01f, -3.51830833e-02f, -2.67457664e-01f, -1.94065571e-01f, -5.23944013e-02f,
  -3.21838439e-01f, 2.88419425e-02f, 2.17809409e-01f, -1.53787345e-01f, -3.67453545e-01f, 5.34289591e-02f, -4.04486321e-02f, 5.15296683e-02f, -9.89815779e-03f, -1.26799777e-01f,
  -1.15619235e-01f, -5.95137589e-02f, 2.89607853e-01f, 1.24283575e-01f, -3.43740046e-01f, -2.99404263e-01f, -3.25387746e-01f, -9.53491628e-02f, 2.06119418e-01f, -6.32757470e-02f,
  2.31141821e-01f, 3.31558794e-01f, -1.14542484e-01f, -7.82843828e-02f, -1.09824613e-01f, 7.16462284e-02f, -6.69078603e-02f, -2.19001234e-01f, 1.29289687e-01f, -1.29426464e-01f,
  -2.23940372e-01f, 9.35021415e-02f, 2.22362146e-01f, -8.33778363e-03f, -2.03944996e-01f, -2.53017664e-01f, 3.59706998e-01f, -2.43731081e-01f, 8.70232878e-04f, -3.04386728e-02f,
  -7.75447562e-02f, -2.84182400e-01f, 1.25364721e-01f, 1.66818127e-02f, -3.26256275e-01f, -7.26965442e-02f, 9.12812054e-02f, 2.19425663e-01f, -8.98136124e-02f, 1.30637690e-01f,
  2.71330804e-01f, 6.91075474e-02f, -1.89398542e-01f, 2.35082768e-02f, -2.13696714e-02f, -2.47913584e-01f, -2.01041903e-02f, 1.91065103e-01f, 2.41398383e-02f, -2.45801881e-01f,
  -1.78919494e-01f, -2.39766061e-01f, -1.44411266e-01f, 3.79845619e-01f, 6.11880273e-02f, 1.19547248e-01f, -5.42035401e-02f, -7.57522602e-03f, 3.49482238e-01f, -3.78883958e-01f,
  -6.16842471e-02f, 2.47650251e-01f, -3.79380509e-02f, -1.70180034e-02f, 1.72876894e-01f, -8.58394578e-02f, -3.97442803e-02f, -1.32361919e-01f, 4.25873883e-02f, 1.61991358e-01f,
  1.55537635e-01f, 1.73254520e-01f, -2.24117756e-01f, -2.58231133e-01f, -1.11544818e-01f, -3.72673780e-01f, 2.66620696e-01f, -3.44361693e-01f, 1.34668313e-02f, -1.35254487e-01f,
  -1.32664233e-01f, 2.34987766e-01f, -4.59340252e-02f, -1.60048027e-02f, 1.54107392e-01f, -3.82475644e-01f, -2.74231642e-01f, 1.10018767e-01f, -6.82299435e-02f, -2.04981595e-01f,
  -3.26020449e-01f, 4.30939585e-01f, 1.04838520e-01f, -1.02960289e-01f, -8.59689638e-02f, 8.27804357e-02f, -8.11687112e-02f, 1.67894781e-01f, -9.66468379e-02f, 1.28107280e-01f,
  1.59572139e-01f, -2.09679276e-01f, 1.09961465e-01f, 2.98432168e-02f, -1.39151230e-01f, 1.29956648e-01f, 1.76772848e-01f, 1.19807072e-01f, -1.31701708e-01f, 1.95932969e-01f,
  1.73375234e-01f, -1.61151767e-01f, 1.97530270e-01f, 1.35786504e-01f, -2.89578941e-02f, -1.33306995e-01f, -6.32695258e-02f, 2.02884339e-02f, 9.05472264e-02f, 2.44316384e-02f,
  -4.47699100e-01f, -2.16547295e-01f, -8.96828845e-02f, 6.86180815e-02f, -2.18847692e-01f, -4.82289195e-01f, -2.43703425e-01f, 1.04908086e-01f, -3.26066524e-01f, 1.57135472e-01f,
  -1.61988452e-01f, -3.99615943e-01f, 1.58539295e-01f, -1.78155690e-01f, 1.63083777e-01f, -3.08647845e-02f, 2.86295235e-01f, 1.40073374e-01f, 1.78843755e-02f, 2.08783895e-01f,
  -1.47430420e-01f, -4.16175835e-02f, -1.95171103e-01f, -6.20303713e-02f, 4.60289344e-02f, -7.42662605e-03f, -1.84839163e-02f, -5.75580522e-02f, 1.94112975e-02f, -1.55840740e-01f,
  -1.85469568e-01f, -7.89207518e-02f, 5.05439639e-02f, -3.86308618e-02f, -4.51592177e-01f, 8.98332074e-02f, 1.45684004e-01f, -4.12522070e-02f, 3.53869110e-01f, -2.09155738e-01f,
  -9.95487049e-02f, 7.91221187e-02f, 2.39583999e-01f, 3.10800284e-01f, -3.60817760e-01f, -2.06046954e-01f, -2.49934793e-01f, -7.55009577e-02f, -6.99157640e-02f, 6.90272450e-02f,
  2.39714473e-01f, 2.03097984e-01f, -2.16421679e-01f, 1.55758798e-01f, -3.50084044e-02f, 9.78789032e-02f, 1.78703263e-01f, 3.81078012e-02f, 1.50388390e-01f, 2.41267204e-01f,
  -8.86763632e-02f, -1.03739887e-01f, 4.91612777e-02f, -1.10256724e-01f, -1.15641810e-01f, 1.23292051e-01f, -1.88568592e-01f, 3.72017115e-01f, -1.09782271e-01f, -3.46967995e-01f,
  -1.69055864e-01f, 1.75471663e-01f, -3.47691447e-01f, 9.38885063e-02f, -1.65170044e-01f, -1.69654086e-01f, 3.04666847e-01f, 1.70642182e-01f, -6.54986501e-02f, -2.96259105e-01f,
  -7.94302970e-02f, 2.36753628e-01f, -9.11750868e-02f, 1.45562232e-01f, -1.37889281e-01f, 3.46692383e-01f, 2.20791221e-01f, 1.71464786e-01f, -1.13796756e-01f, 6.28924295e-02f,
  -5.73272370e-02f, -4.18744273e-02f, 1.95723906e-01f, 9.08876359e-02f, 7.17332140e-02f, 6.51630536e-02f, 1.92725718e-01f, 8.58441815e-02f, -3.46419156e-01f, -6.70270175e-02f,
  -3.29180092e-01f, -1.43269628e-01f, -6.02272153e-03f, 2.82149971e-01f, -4.38698828e-01f, 1.14688225e-01f, -1.17607296e-01f, 8.15801695e-02f, 1.21699914e-01f, 4.00245726e-01f,
  -6.06482439e-02f, -2.66759664e-01f, -1.64115980e-01f, 4.95797098e-02f, -2.84290045e-01f, 1.33008398e-02f, -9.10140201e-02f, 2.19948679e-01f, 3.68332975e-02f, -1.33220389e-01f,
  -1.84919611e-01f, -1.39072657e-01f, 2.50292979e-02f, 2.09988266e-01f, -6.33306876e-02f, -4.25711185e-01f, -1.36755422e-01f, 2.22921539e-02f, -1.59724727e-01f, 1.57608524e-01f,
  1.38756202e-03f, -1.49087653e-01f, 5.17832398e-01f, 3.02353919e-01f, 1.77550286e-01f, -1.98106557e-01f, 2.10539550e-01f, -5.47324717e-02f, 1.09663084e-01f, 3.20508331e-01f,
  -9.09398124e-02f, -2.31897891e-01f, 2.75297952e-03f, 1.47479847e-01f, 2.10142374e-01f, 1.74256101e-01f, 2.06638291e-01f, -1.15428835e-01f, -1.11704111e-01f, 1.58305094e-01f,
  1.32116348e-01f, 3.37147154e-02f, 1.40343413e-01f, -1.22029737e-01f, -1.14015147e-01f, -7.16694370e-02f, 8.03181827e-02f, 1.02358654e-01f, -7.84949511e-02f, 1.02320261e-01f,
  -1.95878655e-01f, -1.72193497e-02f, -2.99732119e-01f, 3.98587257e-01f, -1.41650423e-01f, -3.29243332e-01f, -2.15313941e-01f, 3.12799752e-01f, -1.85590580e-01f, 2.44611442e-01f,
  2.28103120e-02f, -2.79331505e-01f, 2.88967341e-01f, -4.19822007e-01f, 2.85253733e-01f, -4.59546261e-02f, 1.98657736e-01f, 1.21491954e-01f, 1.21598974e-01f, 1.86360493e-01f,
  -2.22023174e-01f, -8.76005888e-02f, 1.97954383e-02f, -4.52675521e-02f, 1.22211948e-01f, -1.60274759e-01f, 1.64723918e-01f, -3.47211033e-01f, 5.66276237e-02f, 1.90442860e-01f,
  2.20243961e-01f, -1.06355563e-01f, 3.21840912e-01f, -2.58054435e-01f, 2.81401753e-01f, -4.21345308e-02f, -4.32862818e-01f, -1.16503552e-01f, -1.62885845e-01f, 1.85297534e-01f,
  9.87118855e-02f, -1.96514815e-01f, 1.47123024e-01f, -1.67676315e-01f, -4.93298545e-02f, 2.24899694e-01f, 1.57580059e-02f, -1.19499765e-01f, -5.85820526e-02f, -1.61845963e-02f,
  -3.00372750e-01f, 1.02135390e-01f, 2.50748605e-01f, -6.58025295e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.62983918e-01f, 4.69696037e-02f, -2.05982924e-01f, -1.07744277e-01f, -1.31963983e-01f, -1.83211014e-01f, 3.05621088e-01f, 1.88232243e-01f, 2.56268978e-01f, 3.45074028e-01f,
  -2.17978984e-01f, 2.57561922e-01f, -4.69469011e-01f, -4.94695038e-01f, -3.21763307e-01f, -2.08600238e-01f, -3.36467624e-01f, 4.47435349e-01f, -4.53806639e-01f, 4.09744740e-01f,
  -2.63855010e-01f, 2.40676358e-01f, 2.40874961e-01f, 2.51148969e-01f, 4.93690819e-01f, -1.76894277e-01f, -8.03404570e-01f, -4.70283538e-01f, -1.29625782e-01f, -2.37896349e-02f,
  1.43833727e-01f, -3.00970022e-02f, -1.03934236e-01f, 5.08043885e-01f, 2.25303397e-01f, -3.83602045e-02f, -3.92028362e-01f, 2.62793571e-01f, 1.56641513e-01f, 5.95786512e-01f,
  2.48499140e-01f, -3.42885703e-01f, -2.54463971e-01f, 9.85213220e-02f, -5.74767411e-01f, -7.15790391e-01f, -2.56634653e-01f, 1.96649596e-01f, 5.01153469e-01f, -2.54158616e-01f,
  1.94777064e-02f, 5.51662445e-01f, 4.83395457e-01f, 5.84930778e-01f, -8.34854901e-01f, 1.65810555e-01f, -6.66655064e-01f, -1.42240644e-01f, -6.95828319e-01f, -7.46989548e-01f,
  5.38483858e-02f, -2.60767639e-01f, 4.23051305e-02f, -4.84470963e-01f, 2.34156430e-01f, 4.18382972e-01f, 3.61611962e-01f, 2.17469800e-02f, 2.33185813e-02f, 2.52224147e-01f,
  -4.63864319e-02f, 1.89448461e-01f, 1.88288093e-01f, 3.42454459e-03f, 4.20922011e-01f, -2.92106271e-02f, 3.44913155e-01f, -9.31546614e-02f, -2.39777155e-02f, 3.66515443e-02f,
  -2.04483226e-01f, 1.75613284e-01f, -5.22514343e-01f, -3.86012763e-01f, 4.16148975e-02f, -4.60595906e-01f, 9.85252932e-02f, 6.48720086e-01f, -4.36404586e-01f, -4.74050373e-01f,
  -4.38887209e-01f, 1.45616531e-01f, -1.60875954e-02f, 1.56006098e-01f, 4.38350022e-01f, 4.84079659e-01f, 2.13871561e-02f, 1.78822130e-01f, 3.93466443e-01f, 2.39330500e-01f,
  1.04472145e-01f, 4.72830772e-01f, 3.43250483e-01f, 3.07507247e-01f, 1.16417728e-01f, 4.31637138e-01f, 1.16177239e-01f, 3.13847750e-01f, 9.48745534e-02f, -3.92300427e-01f,
  -8.45183492e-01f, -2.07789004e-01f, 1.20016798e-01f, 1.44215569e-01f, -7.37972707e-02f, 2.06411630e-01f, -6.06012702e-01f, -1.99959315e-02f, 3.74851197e-01f, 5.91327369e-01f,
  3.11328322e-01f, -1.33821061e-02f, 6.73738346e-02f, -4.42249686e-01f, -2.99243957e-01f, -5.29782712e-01f, 4.11052734e-01f, -1.53608322e-01f, 1.01081349e-01f, 3.31871867e-01f,
  1.69355154e-01f, 2.28100047e-01f, 2.01302648e-01f, 5.49433470e-01f, 5.30558348e-01f, 5.84736407e-01f, 5.82233071e-01f, 4.55583066e-01f, 2.47996613e-01f, 3.76986921e-01f,
  -1.29507616e-01f, 5.66455163e-02f, 1.74004316e-01f, 6.07356608e-01f, 6.51847422e-01f, 4.37803306e-02f, 6.16940022e-01f, -2.62880266e-01f, 2.13919699e-01f, 5.93232214e-01f,
  -1.74409747e-01f, -3.10328096e-01f, -2.64501609e-02f, 7.42914498e-01f, 1.41250238e-01f, -8.85156915e-02f, 5.27214348e-01f, -4.07245040e-01f, 3.35270703e-01f, -7.02862516e-02f,
  2.52374560e-01f, 3.47299576e-01f, 1.83977783e-01f, 1.29118368e-01f, 9.69271436e-02f, 1.35739133e-01f, 4.59756821e-01f, 3.73397112e-01f, 2.13212311e-01f, 2.08520606e-01f,
  4.09357948e-03f, 2.47091472e-01f, -2.59496868e-01f, -4.18467611e-01f, -6.29892409e-01f, -2.89125949e-01f, 3.16654950e-01f, 1.19235151e-01f, 1.68609858e-01f, 2.94130504e-01f,
  -2.34518707e-01f, 2.71089584e-01f, 3.23939562e-01f, 4.32800144e-01f, 2.82469362e-01f, 1.67477891e-01f, -9.89140496e-02f, -5.15234530e-01f, -2.54016429e-01f, -4.08833563e-01f,
  2.04173654e-01f, -1.21494435e-01f, -1.58643007e-01f, -1.11057118e-01f, -7.73328841e-02f, 1.98193103e-01f, 1.24936281e-02f, 1.94560960e-02f, 1.57983806e-02f, -7.04029063e-03f,
  -1.58010632e-01f, -7.81914219e-02f, 1.11713178e-01f, -1.35663629e-01f, -2.79975007e-03f, -2.94191632e-02f, -1.15578033e-01f, 1.07864790e-01f, 5.40437922e-02f, -5.98153993e-02f,
  1.57040372e-01f, 5.43475933e-02f, -8.74198005e-02f, 1.33075807e-02f, -1.87232330e-01f, 4.27482538e-02f, -1.92817912e-01f, -5.26126027e-02f, 6.68002144e-02f, -3.76743153e-02f,
  -1.22096598e-01f, -1.35943428e-01f, -1.11525118e-01f, -1.55248627e-01f, 3.86446387e-01f, -2.94749602e-03f, 1.22928239e-01f, 3.55933398e-01f, 3.33204478e-01f, 2.51421720e-01f,
  3.24627936e-01f, 6.70014322e-02f, 1.57940015e-01f, 8.96651000e-02f, 1.14944542e-03f, 4.89510084e-03f, -9.96826440e-02f, 5.06405056e-01f, 2.53603756e-01f, -1.11544065e-01f,
  -4.87612821e-02f, 3.33340913e-01f, 1.73657894e-01f, -1.53723598e-01f, -2.68064514e-02f, -8.42221454e-02f, 3.48726094e-01f, -2.86334604e-01f, 3.74905765e-01f, 5.07654250e-01f,
  4.53324586e-01f, 4.78148848e-01f, 5.35665512e-01f, -1.53490051e-04f, 2.73297191e-01f, 3.45821112e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  1.44874752e-01f, 1.50123924e-01f, 9.43424851e-02f, 3.75278741e-01f, 4.62991893e-01f, 1.75133750e-01f, -1.85363263e-01f, 9.82994139e-02f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  1.92998007e-01f, 9.64690298e-02f, 1.58520967e-01f, -1.84654221e-02f, 1.67700276e-01f, -7.55132437e-02f, 3.74522060e-01f, 4.00839001e-02f, -7.81907961e-02f, 1.64522335e-01f,
  1.13511145e-01f, 1.73623115e-01f, -3.52991670e-01f, -2.39115566e-01f, -6.06559291e-02f, -3.74447733e-01f, 1.11540020e-01f, 3.15396369e-01f, -5.78005426e-02f, 2.29195356e-01f,
  -3.31537351e-02f, -8.40814859e-02f, -1.10373627e-02f, 2.57853419e-01f, -3.13808024e-01f, -2.01216072e-01f, 1.31904334e-01f, -2.32656673e-01f, -6.42974079e-02f, -1.87380716e-01f,
  -1.88271105e-01f, 2.54515827e-01f, 6.72157481e-02f, -8.60630423e-02f, 1.88429415e-01f, 1.63563699e-01f, 2.08219364e-02f, 2.09040031e-01f, -1.00716487e-01f, -2.75313139e-01f,
  -5.76845882e-03f, 2.82912344e-01f, 1.65417671e-01f, 1.75816506e-01f, -5.19994318e-01f, 1.98152572e-01f, 1.87483490e-01f, 4.17707473e-01f, -3.16526115e-01f, 2.34912232e-01f,
  -2.95278072e-01f, 1.31404474e-01f, 1.94618806e-01f, -2.60989428e-01f, 2.58993745e-01f, 1.58902019e-01f, -2.18482018e-01f, 3.56510058e-02f, 2.16793090e-01f, 1.05284661e-01f,
  -1.53786182e-01f, -1.24344826e-01f, -2.81185284e-02f, -8.72069225e-03f, -1.08770644e-02f, 2.49816775e-01f, -1.15683690e-01f, 5.18860668e-02f, 7.97009394e-02f, -3.24527211e-02f,
  1.09376818e-01f, 1.39492035e-01f, 5.55522516e-02f, 1.29941121e-01f, 1.67983890e-01f, 2.75605246e-02f, 1.82273358e-01f, 1.51194364e-01f, 5.19163534e-02f, -2.22361803e-01f,
  3.10535431e-01f, 1.03821881e-01f, 1.68360993e-01f, 1.72250316e-01f, -8.27788338e-02f, 3.58852595e-01f, 1.83240175e-01f, -2.63853908e-01f, 2.72266902e-02f, -7.69725768e-03f,
  -1.73348457e-01f, -2.33969837e-01f, 1.00533240e-01f, -1.69578865e-01f, -1.51719391e-01f, 2.93292046e-01f, 1.47987932e-01f, 3.34857553e-01f, -1.68007702e-01f, 2.64051527e-01f,
  3.17802489e-01f, -5.49573675e-02f, 7.81660452e-02f, 3.68984342e-01f, 6.04304206e-03f, 1.16328821e-01f, 8.07598904e-02f, -4.25823480e-02f, 3.21029961e-01f, 2.22116057e-02f,
  -3.44446778e-01f, -3.81667048e-01f, 3.49111974e-01f, 8.93120766e-02f, 1.51652068e-01f, 2.24518348e-02f, 1.99655235e-01f, -4.51005012e-01f, 2.83142984e-01f, -7.78634325e-02f,
  2.01365259e-02f, -1.25766043e-02f, -2.41895542e-01f, 1.42799234e-02f, 5.76310381e-02f, 2.39144221e-01f, 1.20980740e-01f, 8.26137215e-02f, 4.07114020e-03f, 1.08688988e-01f,
  1.36246383e-01f, -1.95887648e-02f, -1.27591625e-01f, 7.99472108e-02f, 3.55463699e-02f, -1.94364533e-01f, -2.33838826e-01f, 2.00089201e-01f, -8.18410888e-02f, 1.19134203e-01f,
  2.31665745e-01f, 1.76329598e-01f, 3.85999560e-01f, -4.80976515e-02f, -3.12282443e-01f, 3.87953036e-02f, -1.26620596e-02f, -3.64192963e-01f, -1.69414014e-01f, -2.47253999e-01f,
  -2.34196916e-01f, 5.08934081e-01f, -2.73501843e-01f, 2.29148537e-01f, -1.35591358e-01f, 3.26277055e-02f, 9.88530964e-02f, 3.50443758e-02f, -2.56203562e-01f, -1.76984996e-01f,
  4.73804586e-02f, 1.26600191e-01f, -1.88993052e-01f, -2.27237493e-01f, -9.34036598e-02f, -1.58852801e-01f, 1.71389058e-01f, 3.99211720e-02f, -2.43110493e-01f, -3.54594998e-02f,
  2.04435542e-01f, 1.65755868e-01f, 9.40872356e-02f, 7.70185003e-03f, 3.01924706e-01f, -8.49012509e-02f, -9.56463963e-02f, -4.55727309e-01f, 2.14524996e-02f, -3.60218227e-01f,
  -3.52629989e-01f, 3.86071742e-01f, -3.19295824e-01f, 2.48917714e-01f, 1.80342913e-01f, -3.83278966e-01f, -1.93021238e-01f, -2.51889676e-01f, 1.70146421e-01f, -7.56096095e-02f,
  -1.12271801e-01f, 7.88263753e-02f, 1.16850518e-01f, 1.76288560e-01f, -1.65127188e-01f, 1.13517113e-01f, 8.38925764e-02f, 2.06595853e-01f, 4.31645755e-03f, -1.47755072e-02f,
  -6.80021122e-02f, 1.64771333e-01f, 8.22028592e-02f, 5.93121536e-02f, 3.10996771e-01f, -1.52038664e-01f, -1.32644162e-01f, 3.48595791e-02f, -2.83473283e-01f, -3.20347518e-01f,
  8.46607238e-02f, -2.81193078e-01f, -1.69003829e-01f, -2.05187574e-01f, -1.91865131e-01f, -2.28962362e-01f, 9.65010747e-02f, 6.93561211e-02f, -2.94622838e-01f, 2.75574893e-01f,
  2.29737118e-01f, 2.61679649e-01f, -1.97258711e-01f, -1.71832979e-01f, 1.33174002e-01f, -3.29764187e-01f, -3.07247844e-02f, -5.17418375e-03f, -1.44143686e-01f, 4.23763841e-02f,
  -2.55422056e-01f, 8.54537636e-02f, 9.07335952e-02f, -3.35887790e-01f, -4.87378798e-02f, -1.28436655e-01f, 3.91261071e-01f, -2.36469805e-01f, 6.07340634e-02f, 8.59015584e-02f,
  -1.10845737e-01f, -4.36457545e-01f, 2.56181419e-01f, -1.21212959e-01f, 1.78194102e-02f, 1.07975453e-01f, -2.78305501e-01f, -2.43606523e-01f, 2.73272127e-01f, 2.60117322e-01f,
  8.58659819e-02f, 2.48434976e-01f, 7.92495906e-02f, 7.56815076e-02f, -2.72135865e-02f, -2.90715307e-01f, 4.02018651e-02f, -3.24865937e-01f, 2.72869438e-01f, 9.09906551e-02f,
  4.40321816e-03f, -3.04395705e-01f, 1.56445101e-01f, 1.24209307e-01f, -1.17116883e-01f, -1.99042931e-01f, -1.36287823e-01f, -4.02440168e-02f, -1.49626940e-01f, -3.39032799e-01f,
  -8.72081965e-02f, -2.02760011e-01f, 8.54648426e-02f, 3.56468976e-01f, -2.70811945e-01f, 2.60487944e-01f, 2.62913823e-01f, -4.25673902e-01f, 2.79960513e-01f, 2.08768189e-01f,
  1.56944111e-01f, 3.12382996e-01f, 1.40673235e-01f, 1.63063183e-01f, -7.45932385e-02f, 2.36740768e-01f, 2.25055188e-01f, -3.57850157e-02f, 6.34563938e-02f, 3.19746792e-01f,
  -2.65961051e-01f, -5.54791614e-02f, 1.56061023e-01f, 3.86211835e-02f, 2.54176617e-01f, -1.03731759e-01f, 1.05330899e-01f, 1.46797523e-01f, 1.53916493e-01f, 1.18307613e-01f,
  -3.37707520e-01f, 3.05953771e-01f, -1.90378949e-01f, -6.27683476e-02f, 1.27139777e-01f, -3.44449691e-02f, 1.31877884e-01f, 1.92589223e-01f, -2.41834670e-02f, 1.15590408e-01f,
  1.22738838e-01f, 2.13512808e-01f, -2.19627529e-01f, -2.96223283e-01f, 2.91778028e-01f, -1.67743206e-01f, -3.92523408e-03f, -3.32227856e-01f, -5.73001010e-03f, 1.17120020e-01f,
  -1.82372332e-01f, -3.33413750e-01f, -3.66700813e-02f, -1.64912015e-01f, -1.69085816e-01f, 5.85711822e-02f, -1.72357231e-01f, -3.57650876e-01f, 2.86253154e-01f, 1.52684760e-03f,
  4.62690406e-02f, 5.38286082e-02f, 1.14127263e-01f, 1.67768821e-01f, -2.73763895e-01f, 2.14304045e-01f, -2.66352594e-01f, 1.89898297e-01f, -1.36606647e-02f, 2.42170528e-01f,
  3.76456350e-01f, -2.77054399e-01f, 1.69661164e-01f, 6.20957557e-03f, -1.74586013e-01f, 4.26006317e-01f, 3.39412183e-01f, 1.33935630e-01f, -5.79410344e-02f, 3.09772879e-01f,
  -1.17232233e-01f, -2.04613134e-01f, -5.32698967e-02f, 2.12854028e-01f, 1.52206987e-01f, 2.64019817e-01f, -6.43131807e-02f, 1.21906037e-02f, -2.46537551e-02f, -1.31378740e-01f,
  -4.29220498e-02f, 1.76380411e-01f, 4.11097184e-02f, -1.57331750e-01f, 3.45717967e-02f, 3.95760417e-01f, 1.49375826e-01f, 1.71866342e-01f, 1.18138991e-01f, 3.17553848e-01f,
  1.01806015e-01f, -2.54701883e-01f, -2.97554106e-01f, -2.58720946e-02f, 3.44609231e-01f, -6.70910254e-02f, 5.52860759e-02f, 1.34895593e-01f, -3.19012791e-01f, -2.52233356e-01f,
  6.52886629e-02f, -2.52297074e-01f, -1.64196193e-01f, 1.57234177e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -6.26604185e-02f, -5.68216562e-01f, 4.68814969e-01f, 2.91135877e-01f, 1.61267947e-02f, -2.70447582e-01f, -9.05246381e-03f, 5.74416041e-01f, 2.36523584e-01f, 2.09970757e-01f,
  -6.12907350e-01f, 3.63340408e-01f, -9.38150212e-02f, -6.22312605e-01f, -3.55381429e-01f, -4.04010683e-01f, 3.51353258e-01f, 7.48797238e-01f, -6.65245414e-01f, 9.40863639e-02f,
  -4.05221641e-01f, -1.31164640e-01f, 6.40960574e-01f, -5.46950579e-01f, 2.66997606e-01f, -5.45613229e-01f, -6.42374575e-01f, 8.82398367e-01f, 5.29876351e-01f, 4.95461792e-01f,
  -3.67309675e-02f, 5.90981424e-01f, 4.90319550e-01f, 3.77155274e-01f, 1.98449194e-01f, -1.56120528e-02f, 2.27539152e-01f, 5.25766671e-01f, 4.47495356e-02f, -2.70705551e-01f,
  -2.87294090e-02f, 3.75401527e-01f, 6.67625070e-01f, 3.59447926e-01f, 5.96664786e-01f, 4.97604758e-01f, 2.58445948e-01f, 6.82631671e-01f, -7.71699965e-01f, -7.21600056e-01f,
  3.09373111e-01f, -5.60680747e-01f, -5.25228798e-01f, 2.94871479e-01f, -5.66222906e-01f, 2.58495450e-01f, -2.55102456e-01f, 1.02734923e+00f, -6.06476724e-01f, 2.55935162e-01f,
  6.80624247e-01f, 3.03904861e-01f, -7.01246560e-01f, 6.83651417e-02f, 8.88205320e-02f, 3.26362491e-01f, 2.05930062e-02f, -3.42803419e-01f, 4.86646146e-01f, 7.22411573e-02f,
  6.65640891e-01f, -3.10340375e-01f, -2.42751032e-01f, 1.22935146e-01f, 7.20904022e-02f, 1.74578369e-01f, -4.55833405e-01f, 1.70526683e-01f, -4.24036711e-01f, -5.99520624e-01f,
  2.36179754e-01f, 6.66552544e-01f, 2.79048920e-01f, 1.08472355e-01f, 5.23168623e-01f, -8.65123093e-01f, 5.50401986e-01f, 7.00919092e-01f, 1.09084370e-03f, -8.91423747e-02f,
  2.65030682e-01f, -6.20858014e-01f, -3.64271522e-01f, -1.69609129e-01f, -2.37359032e-01f, -1.75537512e-01f, -7.00902864e-02f, 1.81315780e-01f, 2.96757221e-01f, 3.10545564e-01f,
  3.18027735e-01f, 1.37341484e-01f, 3.95289570e-01f, 2.93019116e-01f, 1.16561972e-01f, 2.72377461e-01f, -2.28376508e-01f, 1.83302373e-01f, 1.77292913e-01f, -2.64405042e-01f,
  -4.02116090e-01f, -2.97383547e-01f, -7.38976076e-02f, 7.33576298e-01f, -1.51607424e-01f, 4.77584541e-01f, 5.29706001e-01f, -8.26105535e-01f, 3.64229083e-01f, 4.12764192e-01f,
  7.32707620e-01f, 6.08772695e-01f, 1.90505221e-01f, 5.61931968e-01f, -4.81091291e-02f, 4.16554391e-01f, -4.73131686e-02f, 7.17146695e-03f, 1.48840621e-01f, -3.06390285e-01f,
  -1.25483662e-01f, -3.45344365e-01f, -7.79510364e-02f, -3.46157670e-01f, -4.94777322e-01f, 9.69133750e-02f, -6.41795099e-01f, -7.42120504e-01f, -1.74924865e-01f, 7.41202757e-02f,
  -5.53007647e-02f, 1.28458798e-01f, -3.27984303e-01f, 4.92900997e-01f, 2.11823985e-01f, 1.47210896e-01f, 2.14663684e-01f, 4.03127849e-01f, 5.33316672e-01f, -1.65228143e-01f,
  5.14462054e-01f, 2.41279691e-01f, 1.30566883e+00f, -3.53423387e-01f, 8.98828581e-02f, 4.10692602e-01f, -3.18155438e-01f, 4.17776465e-01f, 4.93296027e-01f, -3.50339413e-01f,
  3.94188017e-01f, -3.18635553e-02f, 8.00340027e-02f, 2.54142165e-01f, 2.94757247e-01f, 3.53360444e-01f, -8.93594548e-02f, 2.59385645e-01f, 3.67102116e-01f, 2.26684898e-01f,
  1.03259973e-01f, 2.17378497e-01f, 2.85483718e-01f, -5.76966941e-01f, 1.48766249e-01f, 2.29506403e-01f, -6.31745756e-01f, -7.06171930e-01f, -1.39029190e-01f, -3.90272848e-02f,
  3.92226934e-01f, -3.27580571e-01f, -7.12587357e-01f, -6.27475381e-02f, 1.76675543e-01f, 5.03892243e-01f, 5.77001750e-01f, 9.96776640e-01f, 2.98077285e-01f, 8.05317521e-01f,
  -8.24912116e-02f, -2.88720187e-02f, 2.18366563e-01f, 4.54911172e-01f, -1.62043810e-01f, 4.12435681e-02f, 4.51405406e-01f, 1.04950458e-01f, 4.03508037e-01f, 3.47824991e-01f,
  3.53029013e-01f, -1.37338907e-01f, 4.43411440e-01f, 9.77420621e-03f, 4.17262942e-01f, 1.81432113e-01f, -7.13646352e-01f, -7.40434527e-01f, 6.82940781e-01f, -5.50536931e-01f,
  6.04716361e-01f, 1.41319364e-01f, 2.48338938e-01f, 1.40046626e-01f, 1.11960927e-02f, -4.65594172e-01f, -2.01644272e-01f, 5.97687721e-01f, 2.09258154e-01f, -3.47722620e-01f,
  7.18687892e-01f, -1.28383577e-01f, -9.66476500e-02f, 4.30046260e-01f, 5.15856683e-01f, 1.87972650e-01f, 3.65188062e-01f, -2.83645511e-01f, 6.22951865e-01f, 4.50041533e-01f,
  2.91389853e-01f, -2.50448644e-01f, 4.05675858e-01f, 3.10047746e-01f, 5.05818903e-01f, 3.03945571e-01f, -7.26991236e-01f, -5.23137629e-01f, 4.49156553e-01f, 2.80132517e-02f,
  -6.29199386e-01f, -2.00743489e-02f, -4.69222784e-01f, 9.49608237e-02f, 3.03849392e-02f, -4.26152676e-01f, -6.19994760e-01f, 1.00320232e+00f, -7.58568823e-01f, -7.80842423e-01f,
  7.30696142e-01f, 2.38240823e-01f, 3.11105996e-01f, -1.80279151e-01f, -3.59027773e-01f, 6.55873641e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  4.23584506e-02f, 3.31300229e-01f, 1.17307812e-01f, 8.77803639e-02f, -2.38898933e-01f, 2.85465211e-01f, 2.33248606e-01f, 1.81503013e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  6.07128203e-01f, 3.00119668e-01f, -2.14006633e-01f, 4.79496151e-01f, -5.88778079e-01f, 3.89902294e-01f, -6.04291379e-01f, -1.01249702e-01f, 6.42667651e-01f, -5.00951111e-01f,
  2.90851861e-01f, 4.25485790e-01f, 7.24741220e-01f, 7.82260895e-01f, 8.51348341e-01f, -6.74032509e-01f, -6.09926760e-01f, -9.27323461e-01f, -5.15905559e-01f, -8.10030818e-01f,
  -7.30304718e-01f, 7.18848109e-01f, 7.76344538e-01f, 8.90270233e-01f, 2.63869204e-02f, -6.77235603e-01f, -3.54700744e-01f, -3.53760123e-01f, -6.31408393e-01f, -7.99283564e-01f,
  2.02428252e-01f, -4.49652046e-01f, -4.04762715e-01f, -8.13671574e-02f, 4.26674157e-01f, 1.87864192e-02f, 2.50989139e-01f, -2.60702595e-02f, -1.07436711e-02f, -4.38787907e-01f,
  -2.19376925e-02f, -1.90886796e-01f, -2.25575060e-01f, 2.04360560e-01f, -7.87065551e-02f, 4.27698404e-01f, -5.02795205e-02f, 1.64374501e-01f, -2.94319987e-01f, -3.17079008e-01f,
  -6.36497661e-02f, -1.28715634e-01f, 4.63686287e-01f, -1.75761849e-01f, 3.80352348e-01f, -3.50237817e-01f, -3.18892032e-01f, -4.31978077e-01f, 1.02492535e+00f, 3.53599012e-01f,
  -1.31813750e-01f, -4.07520473e-01f, 5.34399552e-03f, 3.50913912e-01f, 1.67107567e-01f, -6.09219782e-02f, -2.69305885e-01f, 1.12672411e-01f, -1.04687996e-01f, -2.05064699e-01f,
  3.12121004e-01f, 1.53765930e-02f, 3.41377147e-02f, 8.63796547e-02f, -2.29780987e-01f, -2.27409780e-01f, -4.09738719e-01f, 4.51789886e-01f, -4.21018541e-01f, 1.36995092e-01f,
  -2.84986287e-01f, -1.79917857e-01f, 2.48131782e-01f, 2.47282505e-01f, -1.31155998e-02f, -3.64188075e-01f, 1.49488881e-01f, -2.71525323e-01f, 8.89314786e-02f, -6.43552363e-01f,
  -1.30413711e-01f, 1.49812862e-01f, 7.95300722e-01f, 1.56312078e-01f, -5.46622574e-01f, -1.64942771e-01f, -2.13561341e-01f, -2.13082954e-01f, 9.78735983e-02f, 1.96096852e-01f,
  1.48433074e-01f, 2.41371647e-01f, -4.98338342e-01f, -3.74446958e-01f, 1.18860647e-01f, 1.64661780e-01f, 3.82521152e-01f, -2.63073862e-01f, -5.50669134e-01f, -5.51891327e-01f,
  5.71667314e-01f, 3.06211654e-02f, 4.96107370e-01f, 5.26744843e-01f, 1.68063864e-01f, 6.53133571e-01f, -4.98485535e-01f, -5.65950692e-01f, 3.88107628e-01f, 5.07315874e-01f,
  -1.12407362e+00f, 4.96661633e-01f, -2.18902696e-02f, -2.47558385e-01f, 4.63541262e-02f, 8.03099424e-02f, 2.47181222e-01f, -7.13946998e-01f, 4.79808241e-01f, -4.10959661e-01f,
  -1.94423884e-01f, -5.65990567e-01f, 4.87628937e-01f, -4.17251348e-01f, -7.45494142e-02f, 5.36849439e-01f, -3.61440271e-01f, 2.68252075e-01f, -3.76612931e-01f, -1.59196690e-01f,
  2.48517379e-01f, -1.26352713e-01f, -1.23714007e-01f, 2.62437165e-01f, -4.44156468e-01f, 2.21793786e-01f, 4.74008948e-01f, -1.04850354e-02f, -3.49559814e-01f, 4.26732898e-01f,
  -2.33336732e-01f, 3.46273631e-01f, -1.82283204e-02f, 1.72864825e-01f, 3.97549495e-02f, -2.03689247e-01f, 1.91718683e-01f, -2.30532274e-01f, 4.54396129e-01f, -9.59845126e-01f,
  -5.67794025e-01f, 3.12621027e-01f, -2.55328804e-01f, 1.15874194e-01f, -3.94919276e-01f, 3.18664253e-01f, 4.54624832e-01f, 1.40166596e-01f, 1.49675369e-01f, -5.68387330e-01f,
  2.05725476e-01f, 9.87324789e-02f, 2.34632134e-01f, -6.78783596e-01f, 1.28334463e-01f, 2.72674590e-01f, -2.81308025e-01f, 6.16066277e-01f, -2.48614207e-01f, -7.77588114e-02f,
  -1.18916862e-01f, -2.46651787e-02f, -4.32042599e-01f, -5.70183158e-01f, -3.82646561e-01f, -4.56826717e-01f, -6.31744742e-01f, -2.90665686e-01f, -1.70238152e-01f, 1.67986199e-01f,
  4.89068419e-01f, 3.22509825e-01f, 1.01739280e-02f, 3.02390307e-01f, 7.47775882e-02f, -5.98081350e-01f, 6.38223514e-02f, 8.80577508e-03f, 1.03978235e-02f, 3.75194550e-02f,
  -4.10176039e-01f, 2.77808756e-01f, 4.35350299e-01f, 2.89815009e-01f, 2.21099719e-01f, -1.25761870e-02f, 5.19773066e-01f, 3.71722318e-02f, -1.98897943e-01f, -6.07631445e-01f,
  5.33203185e-01f, -3.13443631e-01f, 5.44335127e-01f, -1.81329876e-01f, -3.62746507e-01f, -1.58145934e-01f, 4.97399926e-01f, -3.60933453e-01f, -3.31887305e-01f, 4.11207676e-01f,
  -5.12804449e-01f, 2.51385663e-02f, -2.54846305e-01f, -1.52758241e-01f, 1.08815983e-01f, 1.06559746e-01f, 3.61725301e-01f, 5.95409460e-02f, 6.00998253e-02f, -3.68013322e-01f,
  1.11410469e-01f, 5.21153361e-02f, -1.50998965e-01f, 1.66738033e-01f, -2.81244218e-01f, 2.31379360e-01f, 2.14943305e-01f, 5.39593279e-01f, 2.20012546e-01f, -3.84168386e-01f,
  6.07933521e-01f, 4.61181134e-01f, 4.27452266e-01f, -4.29718405e-01f, -3.97578895e-01f, 4.20033097e-01f, -5.19253254e-01f, 5.38073361e-01f, -7.52360940e-01f, 5.84547877e-01f,
  -2.84678042e-01f, -5.41874230e-01f, 1.57644246e-02f, -8.87625962e-02f, -5.24500132e-01f, 6.62160456e-01f, -1.70586221e-02f, -3.59027356e-01f, 1.00466954e-02f, 4.56822775e-02f,
  2.85962760e-01f, -3.41561526e-01f, 2.56006956e-01f, 3.77717793e-01f, -3.39160502e-01f, 2.46586695e-01f, -3.08993310e-01f, -4.19272006e-01f, 3.08983326e-01f, -6.15503043e-02f,
  -4.89484757e-01f, -5.69276154e-01f, -2.29416683e-01f, -8.79763719e-03f, -3.20457369e-01f, -2.90491041e-02f, 3.67810607e-01f, 3.38968188e-01f, 1.80150822e-01f, -3.65891725e-01f,
  -3.13798934e-01f, -7.81330585e-01f, -4.94722605e-01f, 1.00027949e-01f, -5.55949092e-01f, 3.82017553e-01f, -5.73315918e-01f, 6.75093651e-01f, -4.14224923e-01f, -7.46723562e-02f,
  -2.74383783e-01f, -1.39695540e-01f, 6.42401874e-02f, 1.62614241e-01f, 1.44856185e-01f, -3.57156962e-01f, 3.54331195e-01f, 2.23156944e-01f, -5.93985498e-01f, -1.51318744e-01f,
  -3.83361578e-02f, -5.99915445e-01f, -1.67967647e-01f, 3.04165214e-01f, -1.62495703e-01f, 4.95704710e-01f, -5.62778234e-01f, 1.99104492e-02f, 5.76028109e-01f, 6.61795363e-02f,
  -2.26128444e-01f, 4.65234488e-01f, 7.22787261e-01f, -7.17048526e-01f, -9.66545790e-02f, -1.28232971e-01f, 2.09778979e-01f, -8.62786472e-01f, 1.17226869e-01f, -5.61732531e-01f,
  -1.77428454e-01f, 1.99889153e-01f, 2.68810064e-01f, -2.99610347e-01f, 1.68451704e-02f, -1.25988677e-01f, -1.52623862e-01f, 2.58463826e-02f, -1.79320753e-01f, -4.86582778e-02f,
  -4.06282991e-01f, -1.38773963e-01f, -2.99518466e-01f, -3.79111528e-01f, -4.01917666e-01f, 1.96264476e-01f, 3.79785210e-01f, -4.79339123e-01f, -2.70359784e-01f, 1.66726559e-01f,
  5.05067766e-01f, -2.53616452e-01f, -1.73281670e-01f, -6.26075029e-01f, -3.87951612e-01f, 1.13358513e-01f, -8.59613121e-02f, 5.85087657e-01f, -2.97226548e-01f, 3.44353616e-01f,
  -5.30298660e-03f, -8.18215966e-01f, 5.84330782e-02f, 1.20066665e-01f, 1.63537458e-01f, 7.47824088e-02f, 1.03750721e-01f, 1.35631233e-01f, -3.86298895e-01f, 6.96482286e-02f,
  3.24083000e-01f, -1.52353540e-01f, 7.11356774e-02f, -8.44652206e-03f, -6.07901990e-01f, -2.40924984e-01f, -4.76085186e-01f, -2.99141318e-01f, 4.03738171e-01f, 4.14024979e-01f,
  -2.26187527e-01f, 5.93986750e-01f, 1.94461688e-01f, -4.62874055e-01f, 1.76935539e-01f, -4.51368809e-01f, 3.02138865e-01f, 2.13012323e-01f, 7.99289346e-02f, -5.70939839e-01f,
  -2.48905361e-01f, 2.83787906e-01f, -6.55972540e-01f, 1.61046714e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  5.61497808e-01f, -1.61788538e-01f, 2.58596856e-02f, -2.94408035e-02f, -9.14003178e-02f, -1.43073812e-01f, -1.50245056e-01f, 1.43537074e-02f, 1.52331740e-01f, -8.87595192e-02f,
  -1.76084220e-01f, -7.20260944e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    