/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.26018658e-01f, 1.61136881e-01f, 8.40049163e-02f, 1.65252298e-01f, 9.58922058e-02f, -1.54468238e-01f, -1.43129855e-01f, -6.25643507e-02f, -1.04719490e-01f, 1.07576385e-01f,
  6.38468787e-02f, -1.03670679e-01f, -6.84771985e-02f, -1.78188086e-02f, -2.25230725e-03f, -6.79209009e-02f, 1.90589130e-02f, -4.16431129e-02f, -2.29766876e-01f, -1.83752686e-01f,
  -5.51956482e-02f, 1.78513881e-02f, 1.06423333e-01f, -8.67637321e-02f, 4.33301628e-02f, -1.19492695e-01f, 1.15108319e-01f, 1.71801195e-01f, 1.21960320e-01f, 2.87823707e-01f,
  1.83682576e-01f, 3.09397280e-01f, -6.14363514e-02f, 4.19487096e-02f, 4.89113927e-02f, -4.99398739e-04f, -1.21872174e-02f, 1.15197256e-01f, 7.50288367e-02f, 1.62393134e-02f,
  1.64078876e-01f, -1.13884788e-02f, 3.22727188e-02f, -7.16282427e-02f, 5.05159386e-02f, 5.67018874e-02f, 3.36848795e-02f, 1.48987416e-02f, 1.12209521e-01f, 5.21618575e-02f,
  2.55132150e-02f, 2.42834259e-02f, 1.28810495e-01f, 4.79262955e-02f, -3.21305096e-02f, 1.34564773e-03f, 5.16778417e-02f, 7.86338970e-02f, 5.63960820e-02f, 1.04953870e-01f,
  -7.80666396e-02f, -1.01502351e-02f, 1.20618995e-02f, 3.04313526e-02f, -6.61523864e-02f, -8.58948603e-02f, 7.56319836e-02f, -3.76237296e-02f, -2.59195250e-02f, 3.01714446e-02f,
  -4.73327227e-02f, -4.07905653e-02f, 4.22272384e-02f, 4.73203184e-03f, -5.50526660e-03f, -1.85415859e-03f, 2.38071606e-02f, -2.77084783e-02f, 4.44504246e-02f, -7.09226876e-02f,
  -2.48256028e-02f, 7.70211034e-03f, 5.79897389e-02f, -6.86579850e-03f, 7.54386559e-02f, 5.47322864e-03f, 5.27119078e-02f, 1.07375290e-02f, 3.80860083e-02f, 1.62215736e-02f,
  -1.56963974e-01f, 7.92560056e-02f, -5.58841191e-02f, -3.76578718e-02f, 3.84734687e-03f, 1.16790608e-02f, 1.44292368e-02f, -2.98749637e-02f, -2.91253645e-02f, -7.66132846e-02f,
  -4.65165116e-02f, -6.53844699e-02f, 2.62790434e-02f, -2.30352432e-02f, -6.92744330e-02f, -1.56296082e-02f, 1.22007225e-02f, -7.49743432e-02f, -1.93679184e-02f, 7.57131949e-02f,
  -6.63215891e-02f, -1.00236282e-01f, -8.21537450e-02f, -1.43418029e-01f, 3.82434353e-02f, -1.85260579e-01f, -1.01061173e-01f, -1.06471412e-01f, -8.84058326e-02f, -1.76669270e-01f,
  -4.16209430e-01f, -9.36062038e-02f, -5.36042862e-02f, -7.39890859e-02f, 8.59720632e-02f, 2.38338545e-01f, 1.99198857e-01f, 1.42977638e-02f, -1.43812135e-01f, -5.71938641e-02f,
  -5.07034995e-02f, -1.66283536e-03f, -7.00355181e-03f, -1.49208046e-02f, 9.95713174e-02f, 9.19630304e-02f, 8.17020088e-02f, 1.72227051e-03f, 1.67203352e-01f, 6.59940317e-02f,
  1.78440288e-02f, 1.06829079e-02f, -2.60021370e-02f, 1.45745724e-02f, -4.19962183e-02f, 1.39955908e-01f, -6.86544226e-03f, -2.03314558e-01f, -4.72013392e-02f, -2.04183429e-01f,
  -1.20960355e-01f, -2.96428531e-01f, 1.52260005e-01f, -2.71373186e-02f, -2.50726733e-02f, -1.47896215e-01f, 2.99026370e-02f, -6.38071075e-02f, -9.88889486e-02f, -1.04901344e-01f,
  -6.37241974e-02f, -4.69933599e-02f, -1.04595795e-01f, -4.43511829e-02f, -1.03946514e-01f, -9.71256495e-02f, -3.38852666e-02f, -4.92130145e-02f, 3.71523649e-02f, -6.21167794e-02f,
  1.18541503e-02f, -9.67437327e-02f, -4.70939726e-02f, 8.34692717e-02f, 4.55869809e-02f, 4.72293310e-02f, 3.44850589e-03f, -9.87586230e-02f, 4.60403562e-02f, -7.07305968e-02f,
  6.12359792e-02f, -7.77812675e-02f, -1.81599159e-03f, -1.07808830e-02f, 4.19964120e-02f, -6.47463128e-02f, -4.41939533e-02f, 2.56989840e-02f, 6.53074458e-02f, -1.00560356e-02f,
  1.72976609e-02f, -8.25531024e-04f, -5.27489670e-02f, -3.27746905e-02f, 8.27194825e-02f, -9.63639691e-02f, 9.51017141e-02f, -3.32248397e-02f, 2.10965313e-02f, -1.31969508e-02f,
  5.07083759e-02f, -5.41611612e-02f, -3.68176177e-02f, 5.83923310e-02f, -1.25242937e-02f, 3.44298370e-02f, -2.74307840e-02f, 3.84599045e-02f, -3.26304287e-02f, -4.02521566e-02f,
  -1.53281474e-02f, 1.52124599e-01f, -9.07985047e-02f, -2.69961115e-02f, 5.27398400e-02f, 1.68318618e-02f, 6.32246491e-03f, -3.75912897e-02f, 9.02718492e-03f, -4.20598574e-02f,
  1.20777544e-02f, -4.47826311e-02f, -1.13130085e-01f, 3.81625816e-02f, 1.30249187e-02f, 3.76931839e-02f, 2.76320018e-02f, 2.87288576e-02f, 9.34909359e-02f, 1.22748110e-02f,
  6.31593168e-02f, 1.18017502e-01f, 8.95826425e-03f, -5.74359624e-03f, 2.09152345e-02f, 3.16688120e-02f, 3.59022096e-02f, -3.73108014e-02f, 1.27637774e-01f, 7.80942366e-02f,
  1.15124404e-01f, 2.24583875e-02f, -8.96534696e-02f, 2.07657721e-02f, 3.14015970e-02f, -1.94236472e-01f, -2.54122376e-01f, -7.17609823e-02f, 1.72066033e-01f, 1.15735091e-01f,
  2.04383671e-01f, 2.05187842e-01f, 1.83848292e-01f, 6.52203411e-02f, -6.01263791e-02f, -1.23197861e-01f, -4.34934720e-02f, -1.26316845e-01f, -1.25931188e-01f, 2.42369678e-02f,
  -3.63822468e-02f, -3.82476784e-02f, -5.97030781e-02f, -3.06487698e-02f, 6.39697239e-02f, 8.16245191e-03f, -8.03592280e-02f, 2.89524738e-02f, 3.06021087e-02f, 1.09689102e-01f,
  1.83108866e-01f, 4.42904234e-02f, -1.55515894e-01f, 1.19564477e-02f, 4.90434915e-02f, 1.24764936e-02f, -2.35731378e-02f, 4.42226641e-02f, -8.08869898e-02f, -2.46351343e-02f,
  2.41971333e-02f, 3.74709889e-02f, 4.05730344e-02f, 2.65217777e-02f, -9.58587751e-02f, 1.07509745e-02f, 3.28131355e-02f, 3.48972119e-02f, -9.35195014e-02f, 8.15792605e-02f,
  1.18567571e-01f, 6.53147101e-02f, -9.47251990e-02f, -1.26329064e-02f, -2.66505796e-02f, 7.13141337e-02f, -5.93718179e-02f, 5.79010397e-02f, 7.72136450e-03f, 1.57497838e-01f,
  6.24820590e-02f, -8.41770135e-03f, -1.82944089e-02f, 4.39884029e-02f, 6.92204833e-02f, 2.64183208e-02f, -2.03917250e-02f, 2.12070346e-03f, -7.37050250e-02f, -3.59851979e-02f,
  -2.34193727e-02f, 4.89472076e-02f, -2.06161868e-02f, 8.36180821e-02f, -3.01951300e-02f, 3.30634415e-02f, -9.18923039e-03f, -3.96536738e-02f, 1.81100722e-02f, 1.06306840e-02f,
  -5.33682555e-02f, -9.38263759e-02f, 3.02310009e-02f, -3.10721416e-02f, -5.33866212e-02f, -3.08243670e-02f, 6.24719262e-02f, 8.44246671e-02f, 3.61650134e-04f, 7.82673061e-03f,
  1.58378869e-01f, -7.88201541e-02f, 1.33299664e-01f, 2.92273648e-02f, 3.68056297e-02f, 1.68288499e-02f, 3.46133150e-02f, -2.46112403e-02f, 5.83373941e-02f, -1.09207155e-02f,
  -2.04975661e-02f, -2.24442352e-02f, -9.25864428e-02f, -1.60501916e-02f, -4.72424366e-02f, 1.63419619e-02f, -7.74690695e-03f, 5.39025515e-02f, -9.83625650e-02f, 1.45801099e-03f,
  4.08248184e-03f, -1.48739755e-01f, 4.27143537e-02f, 1.28566390e-02f, 3.20040956e-02f, -2.15277523e-02f, 8.35603662e-03f, -2.88177319e-02f, -1.52495757e-01f, -4.90094759e-02f,
  7.27236047e-02f, -6.68202564e-02f, 8.17770287e-02f, 9.77596194e-02f, 3.50331143e-02f, 6.11484274e-02f, -2.63181441e-02f, 2.59215664e-02f, 4.52043191e-02f, -9.72894654e-02f,
  -7.29679391e-02f, -1.61236644e-01f, -1.06941387e-01f, 1.79980248e-02f, -1.12589158e-01f, -7.14308023e-02f, 9.02685802e-03f, 2.14802492e-02f, 1.03550870e-02f, -4.37830724e-02f,
  1.01051293e-02f, -4.03519608e-02f, 2.33324915e-02f, 2.44983821e-03f, 1.50189951e-01f, 2.50688307e-02f, 1.29762813e-01f, 1.45976335e-01f, 9.55561772e-02f, 1.91221595e-01f,
  -7.30200708e-02f, 1.08341187e-01f, 4.00290973e-02f, -5.55691421e-02f, 3.46757919e-02f, -5.60986437e-02f, 2.52716988e-03f, -2.80597862e-02f, -2.22878400e-02f, -6.65196553e-02f,
  4.37254198e-02f, -8.44095126e-02f, -1.01957776e-01f, -2.09595542e-02f, -3.99776734e-02f, -5.77904135e-02f, 4.27892506e-02f, 4.24378105e-02f, 4.71000783e-02f, 4.92687002e-02f,
  -7.33536035e-02f, 1.14129081e-01f, 3.10506672e-02f, 3.10173212e-03f, 1.27307111e-02f, 4.07534353e-02f, 2.07330752e-02f, 1.01907305e-01f, -3.03560104e-02f, 1.12251900e-01f,
  -1.88093614e-02f, -1.05218040e-02f, -6.75116628e-02f, 9.54450890e-02f, 2.66847610e-02f, 5.44302166e-02f, -2.04235092e-02f, -5.67074493e-02f, 2.61166394e-02f, 5.95872663e-02f,
  1.31986355e-02f, -5.22901081e-02f, 4.87317145e-02f, 7.55529031e-02f, 3.50445397e-02f, 4.86868806e-02f, 5.82204275e-02f, 5.76304011e-02f, -2.66871415e-03f, 2.42171735e-02f,
  -5.46409488e-02f, 1.09826494e-02f, 9.40738767e-02f, -5.85054904e-02f, 2.75316108e-02f, -4.05203328e-02f, -1.10431395e-01f, -2.90932227e-02f, -2.18772274e-02f, -1.12077922e-01f,
  -5.79813309e-02f, -1.13057680e-02f, 3.02911345e-02f, 5.91291673e-02f, -5.54863811e-02f, 3.06581613e-02f, 6.05453849e-02f, 2.59150453e-02f, -4.94437665e-02f, -3.55770960e-02f,
  -5.07285148e-02f, 1.25180848e-03f, -2.27377210e-02f, 1.68948751e-02f, -6.87616095e-02f, -7.33449906e-02f, 6.11337908e-02f, -6.78677857e-03f, 5.82317822e-02f, 7.72771016e-02f,
  3.34985331e-02f, -8.24054179e-04f, -4.73991595e-02f, 3.01183891e-02f, 5.46915121e-02f, 5.49415797e-02f, -7.83013031e-02f, 1.10327199e-01f, 1.37267134e-03f, 5.55185974e-02f,
  2.98007339e-01f, -1.74252212e-01f, -5.82853742e-02f, 1.00999728e-01f, -1.18621767e-01f, -6.08844645e-02f, -1.51921481e-01f, 1.15638591e-01f, 1.42216042e-01f, -1.29139364e-01f,
  -2.90375631e-02f, 4.09542732e-02f, 6.10501431e-02f, 9.37401801e-02f, 9.20336023e-02f, -1.11489452e-01f, -8.27600248e-03f, 9.52750146e-02f, 1.56144664e-01f, -3.86087112e-02f,
  2.89017335e-02f, 3.96495126e-02f, 1.40848503e-01f, 4.23310995e-02f, 1.20376758e-02f, 1.83602154e-01f, -5.57287000e-02f, 7.18583353e-03f, -1.43659547e-01f, -1.72262207e-01f,
  -1.81276992e-01f, -5.80140240e-02f, 4.05045487e-02f, 1.49364183e-02f, -1.03047758e-01f, 7.92128220e-02f, -1.26571320e-02f, 5.21432012e-02f, -8.77337754e-02f, 6.57343119e-02f,
  -3.07775810e-02f, 6.10090457e-02f, 8.35821107e-02f, -2.81612040e-03f, -7.61277750e-02f, -1.13957552e-02f, -3.26803401e-02f, -4.04695794e-02f, -8.70682523e-02f, -9.14776325e-02f,
  -4.19287235e-02f, -4.72831987e-02f, -4.11360972e-02f, 3.81847546e-02f, 7.92196393e-02f, -1.22247227e-02f, -3.79420184e-02f, -8.31650868e-02f, 4.90877405e-02f, 4.78870943e-02f,
  1.77726317e-02f, 5.67521825e-02f, -8.80472064e-02f, -2.29288731e-02f, -1.32788783e-02f, -2.66720392e-02f, -3.22170891e-02f, 5.88388667e-02f, 7.91976303e-02f, 1.78394672e-02f,
  3.30703333e-02f, 1.55068059e-02f, -4.46870402e-02f, 9.27906781e-02f, 2.21390706e-02f, 1.73676629e-02f, 1.09571908e-02f, -5.78686595e-02f, -1.83218569e-02f, -4.04700264e-02f,
  4.50430065e-02f, 4.47579287e-03f, 7.38438498e-03f, 4.17335406e-02f, -4.87590535e-03f, -8.13894719e-02f, 5.86713329e-02f, 1.02492953e-02f, -1.44086648e-02f, -8.88031647e-02f,
  6.05219230e-02f, 1.19567169e-02f, -4.09563594e-02f, 4.83123660e-02f, -5.45128770e-02f, -7.17286021e-02f, -4.68964241e-02f, -3.30289714e-02f, 1.33222463e-02f, -2.80451663e-02f,
  -6.86981156e-02f, 3.65140028e-02f, 4.13832106e-02f, -7.35437274e-02f, 5.41750863e-02f, -3.36201936e-02f, 3.96799222e-02f, 5.04664630e-02f, 4.68334518e-02f, -1.25018731e-01f,
  3.56317610e-02f, 1.01635987e-02f, -7.13038296e-02f, 6.32065684e-02f, 5.08443974e-02f, -4.37411033e-02f, -4.89211567e-02f, 2.03948691e-02f, 5.40610589e-02f, 8.94651264e-02f,
  -2.77808815e-01f, -1.82470396e-01f, -1.97005525e-01f, -4.89401855e-02f, 5.63867390e-02f, 1.33319318e-01f, -3.69051807e-02f, -3.61853428e-02f, 5.37479809e-03f, 6.83682933e-02f,
  6.25709146e-02f, 1.14147320e-01f, 9.28705484e-02f, -5.43871894e-02f, -1.06751598e-01f, 2.04883907e-02f, 7.97630772e-02f, -1.18661143e-01f, 8.29412695e-03f, 6.83367997e-02f,
  5.18148765e-02f, 9.42224357e-03f, -5.77790290e-03f, -3.66318785e-02f, 1.08992554e-01f, 6.26379848e-02f, -5.53972721e-02f, 8.42295811e-02f, 8.75186026e-02f, 1.04518406e-01f,
  -1.42585874e-01f, -3.08781266e-02f, 1.01145439e-01f, 1.20735615e-02f, 2.57552080e-02f, -2.41586678e-02f, -8.94794986e-02f, -2.64305361e-02f, 5.49272746e-02f, -3.73190343e-02f,
  1.08615756e-01f, -2.48302910e-02f, 1.00503162e-01f, -4.88443263e-02f, -4.31317687e-02f, -7.82512277e-02f, -1.21721439e-01f, -1.43447369e-01f, -6.49153814e-02f, -1.55048683e-01f,
  4.53200862e-02f, -7.45555237e-02f, -1.59213245e-01f, 1.26366019e-02f, -9.25498083e-02f, 1.60294101e-02f, -7.91872665e-02f, -1.03972435e-01f, -3.16356272e-02f, -5.22292890e-02f,
  -2.50248183e-02f, 4.75331508e-02f, 3.48845795e-02f, -1.63122341e-02f, 6.01389892e-02f, 4.77982275e-02f, 4.00473252e-02f, 1.29518092e-01f, 2.40507536e-02f, -5.61215430e-02f,
  -2.71749385e-02f, 4.13412042e-02f, 6.10102490e-02f, 6.08065948e-02f, 4.94114012e-02f, -1.49264038e-02f, -2.97375433e-02f, 6.01930404e-03f, 8.58343765e-03f, -1.13653541e-02f,
  1.06505537e-02f, -1.82719212e-02f, 8.84812232e-03f, 9.12619382e-02f, -3.05796824e-02f, 6.71760458e-03f, -2.79492252e-02f, -1.17124677e-01f, -9.18349475e-02f, 5.06021874e-03f,
  -1.18736863e-01f, 3.95115726e-02f, 4.30488512e-02f, 6.55556917e-02f, 4.63359542e-02f, -5.54983281e-02f, 2.25477163e-02f, 5.80816977e-02f, 1.12996347e-01f, -1.20494641e-01f,
  -6.87373728e-02f, -6.67799562e-02f, -1.21516837e-02f, -1.12309888e-01f, -3.13439080e-03f, -2.82751787e-02f, -1.17802538e-01f, 8.60963091e-02f, 1.71666928e-02f, -1.07464768e-01f,
  -9.79636461e-02f, -1.27342358e-01f, -1.24765009e-01f, -7.68303797e-02f, -1.72543749e-02f, -4.07856293e-02f, 6.10834807e-02f, -2.82172766e-03f, -3.62435803e-02f, -1.72644138e-01f,
  -2.41696835e-02f, 7.79379606e-02f, -9.52587426e-02f, -1.69006605e-02f, -4.29800600e-02f, 9.32900980e-02f, 1.82110757e-01f, 6.92766607e-02f, -2.07293294e-02f, 1.07141800e-01f,
  -4.65206914e-02f, -1.07766792e-01f, 7.41088390e-02f, -8.54572058e-02f, 6.00982681e-02f, 1.34651423e-01f, 5.93163669e-02f, -2.61235833e-02f, 7.62027968e-03f, 7.86939263e-02f,
  1.60664006e-03f, -5.49646653e-02f, 2.70465203e-02f, 4.71027531e-02f, -5.52395098e-02f, -6.17636740e-03f, -7.58220926e-02f, -5.48483916e-02f, -1.21497534e-01f, -1.11406870e-01f,
  -6.79165423e-02f, 4.12998348e-02f, -1.04574777e-01f, 2.41090031e-03f, 7.65498728e-03f, 4.91932817e-02f, 6.31608963e-02f, -4.73688543e-02f, -3.51258367e-02f, 8.55554789e-02f,
  6.70988951e-03f, -4.23612073e-02f, 5.51534295e-02f, 3.20641627e-03f, 9.63183492e-02f, 1.28319254e-02f, -8.54259655e-02f, 3.82198095e-02f, 7.39983544e-02f, -7.36549273e-02f,
  -3.75405699e-03f, -5.35948835e-02f, -7.66052976e-02f, 4.30492237e-02f, 4.66592461e-02f, -6.95520490e-02f, 4.28624637e-02f, -1.22907147e-01f, -3.97130065e-02f, -1.41091412e-02f,
  -4.66970578e-02f, -2.20755022e-03f, -8.09369422e-03f, 7.67749101e-02f, 8.82662833e-02f, 7.26950541e-02f, 3.75692584e-02f, 6.26904331e-03f, -7.06028566e-02f, 1.21268267e-02f,
  -3.76793034e-02f, -2.71808580e-02f, 6.81963712e-02f, 9.07887742e-02f, -9.38544050e-02f, -7.87949562e-02f, -9.39809233e-02f, -1.98719539e-02f, -2.80977543e-02f, 5.24151511e-02f,
  -5.15962951e-02f, -1.93041600e-02f, 3.26552428e-02f, 3.98019291e-02f, -9.68014002e-02f, -2.40383055e-02f, -2.76998337e-02f, -4.92670499e-02f, 8.68337527e-02f, -7.29866996e-02f,
  1.56117931e-01f, -2.93599013e-02f, -9.98757109e-02f, 1.39339473e-02f, -8.83529782e-02f, 5.38827404e-02f, -3.09770592e-02f, 4.60265465e-02f, -4.49664891e-02f, -5.72089218e-02f,
  2.71680299e-02f, -5.27584665e-02f, -4.63537984e-02f, 8.11930373e-02f, -6.08541444e-02f, 6.71433732e-02f, 6.63759932e-02f, -4.71135527e-02f, -8.15043300e-02f, 3.84275522e-03f,
  6.45817816e-02f, 7.44259283e-02f, 8.79377648e-02f, 2.72059590e-02f, -1.97602552e-03f, -9.24108177e-02f, 9.38376784e-03f, -2.50081308e-02f, 9.23140123e-02f, 7.13122115e-02f,
  -1.56097367e-01f, -1.12420050e-02f, -1.15669429e-01f, -4.72845398e-02f, 5.96066862e-02f, 1.18060410e-01f, -7.97483549e-02f, -8.59801248e-02f, -6.85267448e-02f, -3.02556697e-02f,
  9.94587913e-02f, 1.12914182e-01f, 2.76650675e-03f, -9.65707153e-02f, -1.70403078e-01f, -2.24986583e-01f, -3.02770585e-01f, -2.91424692e-01f, -9.12290066e-02f, 1.23804219e-01f,
  1.51809320e-01f, -1.16136730e-01f, -1.64537370e-01f, -1.35999084e-01f, 1.63948769e-03f, 1.37068406e-01f, 7.56584108e-02f, 4.09457907e-02f, 1.75478727e-01f, -2.23537628e-03f,
  8.03636461e-02f, 1.38426535e-02f, -3.41136977e-02f, 6.64715394e-02f, 8.41171443e-02f, -3.36337239e-02f, -5.87208197e-02f, -1.40504822e-01f, -2.51825824e-02f, -1.13709405e-01f,
  -4.36040609e-05f, 3.32809426e-02f, -7.16181621e-02f, 4.78288010e-02f, -4.27859724e-02f, -1.08203657e-01f, -1.31582409e-01f, -1.38766423e-01f, -6.31973147e-02f, -6.90148249e-02f,
  1.27792746e-01f, 1.03676639e-01f, -3.55731361e-02f, 2.43635513e-02f, 3.88455950e-02f, 9.12431479e-02f, 4.36581075e-02f, 3.49387154e-02f, 4.18871753e-02f, -2.56773084e-02f,
  -5.49520403e-02f, -5.02188317e-02f, 6.33286908e-02f, -4.59091701e-02f, 3.12292930e-02f, 8.39160383e-02f, -9.15570185e-03f, -1.33494195e-02f, 3.78528982e-02f, -7.36187100e-02f,
  -2.05271225e-02f, -2.98087373e-02f, -3.04440577e-02f, -8.10323134e-02f, 5.77085093e-02f, -3.96173149e-02f, 3.18427198e-02f, -1.21174613e-02f, -8.72131288e-02f, 5.06222621e-02f,
  5.32719716e-02f, 5.10794967e-02f, 1.85937912e-03f, 1.15014397e-01f, 3.92636918e-02f, -1.14341319e-01f, -4.04788069e-02f, 9.67847779e-02f, -3.46154184e-03f, 8.81454162e-03f,
  -4.65933196e-02f, -1.18696541e-02f, -1.17855527e-01f, -8.82215798e-02f, -5.94011657e-02f, 4.87791793e-03f, 1.62813421e-02f, -1.02565577e-02f, -2.54108664e-03f, 3.09346020e-02f,
  -5.06789722e-02f, -3.21302339e-02f, -3.82165425e-03f, 3.15744318e-02f, 3.89427803e-02f, 1.55824963e-02f, -2.74901018e-02f, -3.69650126e-02f, -3.62243392e-02f, -4.56888834e-03f,
  -1.04071401e-01f, -3.36106606e-02f, -7.42201358e-02f, 1.63773634e-02f, 1.36079285e-02f, -1.29311634e-02f, 6.83571994e-02f, 6.08029701e-02f, -7.31572136e-02f, -1.22524217e-01f,
  2.72746831e-01f, -1.96116120e-01f, -2.01022312e-01f, 1.90051213e-01f, -7.22598732e-02f, -1.90895483e-01f, -3.20176095e-01f, -3.26726623e-02f, 1.99682310e-01f, -5.72155379e-02f,
  -1.59419067e-02f, 1.56801194e-01f, 1.65666774e-01f, 1.04395598e-01f, 3.46208252e-02f, -1.80844039e-01f, -2.77710408e-02f, -8.70313775e-03f, 1.71171069e-01f, 2.08679363e-02f,
  9.45488364e-02f, 7.99039230e-02f, 2.26844802e-01f, 1.27126932e-01f, -7.89771974e-02f, 6.06775004e-03f, -1.89989135e-01f, -6.37750328e-02f, -1.63682595e-01f, -8.65966678e-02f,
  4.82752100e-02f, 6.28117397e-02f, 4.03116271e-02f, 6.74096271e-02f, -8.33588243e-02f, 4.13456894e-02f, 4.32582200e-02f, -4.01933491e-02f, 9.24670196e-04f, -2.38933209e-02f,
  8.97299573e-02f, 1.09934978e-01f, 5.94458207e-02f, -3.45264859e-02f, 1.79807637e-02f, 7.60681629e-02f, 6.89849779e-02f, 1.35709539e-01f, -6.60339743e-02f, -5.60021177e-02f,
  -7.09033087e-02f, -7.31535554e-02f, -1.23532481e-01f, -4.85137738e-02f, -4.32208888e-02f, 2.19121743e-02f, -6.87467009e-02f, -4.82201353e-02f, -4.40314822e-02f, -9.43191275e-02f,
  1.92732941e-02f, 4.88958508e-02f, -3.71608697e-02f, 2.00659614e-02f, 3.82668935e-02f, -4.60864939e-02f, 1.72954816e-02f, 3.36278826e-02f, 5.61615899e-02f, -2.06738636e-02f,
  -1.96076389e-02f, -5.89679703e-02f, 6.87121749e-02f, 1.60003977e-03f, -4.64419127e-02f, -1.41115738e-02f, -4.21302356e-02f, 3.61058898e-02f, -7.31202774e-03f, 5.73038198e-02f,
  5.77502698e-02f, 3.93405668e-02f, -5.53495549e-02f, 8.05313364e-02f, -3.78686152e-02f, -4.36535105e-02f, -1.00158211e-02f, 1.80854998e-03f, -1.19528724e-02f, -2.91735306e-03f,
  -1.20540932e-02f, 5.79788424e-02f, -3.58809792e-02f, 1.37044210e-02f, 6.71455264e-02f, -4.89180908e-02f, 1.64990164e-02f, 3.32138082e-03f, 1.05038792e-01f, 9.59396362e-03f,
  6.55252784e-02f, 4.75435378e-03f, 2.41644643e-02f, -1.60799343e-02f, 2.85080671e-02f, -1.15787415e-02f, -9.18072835e-02f, -1.65836811e-02f, 8.35333690e-02f, 2.22323183e-02f,
  4.58767265e-02f, 5.53085469e-02f, 2.30394620e-02f, -6.70298636e-02f, 8.91004577e-02f, -2.48578824e-02f, -8.51194039e-02f, -9.14337710e-02f, -1.13372199e-01f, -2.39159673e-01f,
  -1.02424204e-01f, 2.54185647e-01f, 1.37941822e-01f, -4.33082618e-02f, 7.90044814e-02f, -7.58942124e-03f, 4.04009312e-01f, 7.79042318e-02f, -5.30176908e-02f, 4.31611277e-02f,
  1.06409872e-02f, -3.88171412e-02f, -1.14495354e-02f, -1.34146124e-01f, 3.84039916e-02f, 1.27606109e-01f, 5.70471883e-02f, -1.10113241e-01f, 3.61003466e-02f, -3.12444009e-03f,
  -6.42352328e-02f, 1.00263685e-01f, -7.05248863e-03f, -1.00665558e-02f, 1.02203727e-01f, -9.28246006e-02f, -1.60088036e-02f, 5.17429188e-02f, -7.11366981e-02f, -2.51017860e-03f,
  7.56839886e-02f, -1.51209403e-02f, -5.51949479e-02f, -7.16513768e-02f, 1.72515493e-02f, -1.01501895e-02f, -6.94975704e-02f, 3.24107669e-02f, -1.87075175e-02f, 6.01648130e-02f,
  -5.21682650e-02f, 3.45901735e-02f, 8.82291060e-04f, -4.50790673e-02f, 8.06606486e-02f, 5.59828468e-02f, 2.42362879e-02f, 1.68579891e-02f, -6.98406324e-02f, -3.28561291e-02f,
  -1.33149214e-02f, -1.09127618e-01f, -3.00025400e-02f, 7.87839852e-03f, -4.07074355e-02f, -6.74086437e-02f, 1.33530080e-01f, 2.27790941e-02f, 3.53594720e-02f, 1.78075820e-01f,
  -4.77278307e-02f, -2.42964383e-02f, 6.21238239e-02f, 1.26403347e-02f, 7.72714391e-02f, 1.25895182e-04f, -2.67915633e-02f, 6.13067783e-02f, -4.82406281e-02f, -1.35077641e-03f,
  -3.52384895e-02f, -1.22228200e-02f, 4.30758595e-02f, 8.41292590e-02f, 6.40623793e-02f, 7.45858178e-02f, -9.00985375e-02f, 3.58023457e-02f, -1.12628751e-01f, -6.84021339e-02f,
  2.29212921e-02f, 3.84764262e-02f, -4.70396318e-03f, 7.86321238e-02f, -4.83998582e-02f, -3.90390269e-02f, 8.86118859e-02f, 8.59657973e-02f, -2.33077095e-03f, 1.21700084e-02f,
  1.67671576e-01f, -1.42932832e-01f, 1.63510870e-02f, 1.68496192e-01f, 1.30903702e-02f, -7.59242997e-02f, 3.46486159e-02f, -2.04950143e-02f, 6.15191609e-02f, 5.50533161e-02f,
  6.15111515e-02f, -5.09655615e-03f, 7.10640475e-02f, -1.10237934e-02f, 2.12636255e-02f, 2.39058100e-02f, -1.87624749e-02f, 1.41795278e-02f, -1.00004315e-01f, 5.49003147e-02f,
  4.79972623e-02f, 4.25609276e-02f, -1.47711085e-02f, 1.08313300e-01f, 1.64734386e-02f, -7.50562685e-05f, 1.05847746e-01f, 6.60561621e-02f, 9.99075621e-02f, 3.51417273e-01f,
  1.04475468e-01f, -1.93123385e-01f, -6.73450753e-02f, -8.25553536e-02f, -1.26870619e-02f, 8.98660496e-02f, -1.25048891e-01f, 1.32074729e-01f, 7.71506503e-02f, 6.25206381e-02f,
  7.39503372e-03f, 1.38816833e-01f, 1.63671672e-01f, -2.40472984e-02f, -4.54710983e-02f, -2.19266027e-01f, -1.57312453e-01f, -5.21826185e-02f, 1.02507003e-01f, 6.24486618e-02f,
  -7.03591574e-03f, -6.36620261e-03f, 4.49416637e-02f, 1.58365611e-02f, -2.96567623e-02f, 1.45503923e-01f, 3.90815400e-02f, -1.41607076e-02f, 1.93381608e-02f, -1.64714783e-01f,
  5.80470487e-02f, -1.40307918e-01f, -1.47227831e-02f, -2.15509301e-03f, 2.63102129e-02f, 3.10534723e-02f, 2.78980527e-02f, 3.55855338e-02f, 5.88365085e-02f, -1.50223235e-02f,
  3.63431983e-02f, 1.43747292e-02f, 3.58292051e-02f, 5.57630286e-02f, 3.12461760e-02f, 4.92555611e-02f, 4.59595509e-02f, -7.83544183e-02f, -2.08306164e-02f, 9.48625728e-02f,
  -3.48907374e-02f, -8.57488886e-02f, -1.04053676e-01f, 5.96213751e-02f, -4.09640633e-02f, -2.80439816e-02f, -1.71682443e-02f, -3.45099606e-02f, 5.72309867e-02f, 4.52514999e-02f,
  3.27794291e-02f, -3.70763317e-02f, -2.59266701e-02f, -2.25539482e-03f, -1.22404499e-02f, 5.72495870e-02f, 3.64905670e-02f, -2.14268398e-02f, -1.07653234e-02f, 3.64076253e-03f,
  9.51721445e-02f, 5.97183034e-02f, 7.79665187e-02f, 2.79751141e-02f, -3.78060341e-02f, -6.51545152e-02f, 1.06702067e-01f, -6.41746372e-02f, -2.50481647e-02f, -5.46641760e-02f,
  -8.63340423e-02f, 2.07585823e-02f, 3.09767667e-02f, 7.14038149e-04f, -5.16805388e-02f, -4.39596213e-02f, 6.41731471e-02f, 7.63146728e-02f, -6.15845621e-03f, -4.62519452e-02f,
  3.19055319e-01f, -1.21315010e-01f, 6.69307774e-03f, -7.54760727e-02f, -9.82236564e-02f, 5.30390069e-03f, -3.95756587e-02f, 1.43432217e-02f, -2.88378876e-02f, 4.07180712e-02f,
  6.15099743e-02f, -3.15209702e-02f, 5.76018170e-02f, -2.54449726e-04f, 5.19649014e-02f, -5.54161845e-03f, 2.51146313e-02f, 2.05150968e-03f, 1.55750811e-02f, -7.37239327e-03f,
  2.82220617e-02f, -9.37682868e-04f, 8.77424777e-02f, 1.60587225e-02f, 1.81226935e-02f, 1.22490421e-01f, 6.44356236e-02f, 4.49071415e-02f, 8.92017931e-02f, 2.15982422e-01f,
  9.80692580e-02f, -2.32241705e-01f, 5.63882887e-02f, 1.96787357e-01f, -1.07397594e-01f, -1.76281095e-01f, -1.90265223e-01f, -6.71104193e-02f, -3.01554576e-02f, -1.08607046e-01f,
  6.53729914e-03f, 1.46278664e-01f, 9.71571654e-02f, 4.55191098e-02f, -6.21977672e-02f, -1.39148384e-01f, -4.11347449e-02f, 2.09131256e-01f, 1.23124659e-01f, -4.75758761e-02f,
  1.05366357e-01f, 1.74653471e-01f, 1.40286237e-01f, 1.28035739e-01f, 3.37511487e-02f, 2.02161539e-02f, -7.07915872e-02f, 4.46920656e-02f, -4.58691791e-02f, -9.23852250e-03f,
  7.35114515e-02f, -5.02359457e-02f, 1.01788202e-02f, 5.79912513e-02f, -6.57080710e-02f, -1.99282691e-02f, -7.11237714e-02f, 1.56544950e-02f, -6.92151068e-03f, 1.47174960e-02f,
  4.33695167e-02f, 8.09404403e-02f, -1.37254512e-02f, 6.75958991e-02f, -2.17248108e-02f, -6.72079436e-03f, 2.49852221e-02f, 1.38335243e-01f, -2.78492458e-02f, -1.18303224e-01f,
  -4.71369699e-02f, -6.18822500e-02f, -9.93539914e-02f, -1.41628891e-01f, 5.31886145e-02f, 1.26166821e-01f, -3.46038640e-02f, -2.99988929e-02f, -8.03151131e-02f, -1.08493008e-01f,
  -4.52306755e-02f, 4.34961133e-02f, 3.31937671e-02f, -2.88044531e-02f, -1.02569468e-01f, 4.44328114e-02f, 5.72415181e-02f, 3.94493081e-02f, 2.89826002e-02f, 1.30367524e-03f,
  -7.39179179e-02f, -3.59903499e-02f, 6.57951906e-02f, -7.93463811e-02f, 7.06609488e-02f, -4.33771685e-02f, -4.55324613e-02f, 3.62872332e-02f, 2.95813661e-02f, 5.08537218e-02f,
  -1.32456999e-02f, 7.89541304e-02f, -5.67200081e-03f, 2.52720946e-03f, -7.43080750e-02f, 3.41153480e-02f, -3.15683521e-02f, -9.29076076e-02f, -1.76343136e-02f, 3.91143858e-02f,
  7.81445727e-02f, -4.91053946e-02f, 8.12663361e-02f, 2.43323110e-02f, 2.39461455e-02f, 7.82286841e-03f, -3.80036086e-02f, 1.32146552e-02f, 8.53851903e-03f, 3.67890075e-02f,
  -3.51705104e-02f, 3.52907780e-04f, -3.22699584e-02f, 6.86418265e-02f, -4.89914902e-02f, 3.57426405e-02f, -6.81105331e-02f, 5.57122491e-02f, 6.53172284e-02f, 1.39635429e-02f,
  4.84365784e-02f, -7.67251253e-02f, -3.22153680e-02f, -9.85700712e-02f, -6.69805035e-02f, 8.69128555e-02f, -1.21813916e-01f, -1.01090223e-02f, 7.30245421e-03f, -1.95078954e-01f,
  9.89853889e-02f, -3.07131782e-02f, 1.91251189e-01f, -1.88916236e-01f, -5.48247099e-02f, 1.73025101e-01f, 3.29020619e-01f, 1.32457376e-01f, -1.42131150e-01f, -1.93055961e-02f,
  -1.44885937e-02f, -8.69725049e-02f, -1.67662534e-03f, -2.03844579e-03f, 1.77441910e-01f, 7.70879909e-02f, -5.98456375e-02f, 1.00808471e-01f, 4.48295102e-02f, 8.36127624e-02f,
  2.22685151e-02f, -2.97673922e-02f, -1.08035833e-01f, -7.94306491e-03f, -8.21396410e-02f, -1.27536684e-01f, -1.33216336e-01f, -1.15281083e-01f, 2.03722361e-02f, -2.51461655e-01f,
  2.13720843e-01f, 1.53380349e-01f, 1.34697063e-02f, 2.80304011e-02f, -4.61860597e-02f, 6.01853058e-03f, 6.31961739e-03f, -4.36722077e-02f, -4.16747704e-02f, -8.45892504e-02f,
  2.15187259e-02f, -5.28735220e-02f, -9.77286953e-04f, -8.42383876e-02f, 2.82887630e-02f, -1.08567728e-02f, -5.37498631e-02f, 3.86043191e-02f, 2.31200196e-02f, 8.86791050e-02f,
  2.60095745e-02f, 5.90053871e-02f, 1.29046202e-01f, -5.01674190e-02f, -3.12089976e-02f, 4.96887565e-02f, -8.77096783e-03f, -1.74851343e-02f, -6.07393831e-02f, -6.34467676e-02f,
  -2.82170251e-02f, -1.87345687e-02f, -1.05079319e-02f, -3.28640118e-02f, 7.87681118e-02f, 6.76691383e-02f, 4.19485616e-03f, -8.48122239e-02f, 3.73318568e-02f, 2.69811824e-02f,
  -2.36384850e-02f, 5.84061071e-02f, 3.67309749e-02f, -2.61298809e-02f, -1.33341610e-01f, 1.64850000e-02f, -5.84645383e-02f, -4.06346954e-02f, 6.33851364e-02f, -1.18570784e-02f,
  -4.98388298e-02f, 6.56525120e-02f, 2.88485307e-02f, -8.16147849e-02f, 1.83610786e-02f, -1.02998309e-01f, 6.47639623e-03f, -1.26331626e-02f, 1.40895331e-02f, 4.12824377e-03f,
  -2.53723618e-02f, -1.78659186e-02f, 6.47089258e-02f, -2.97189020e-02f, -5.37761971e-02f, 1.16502708e-02f, 1.63796265e-02f, -1.50030479e-02f, -3.93837430e-02f, 5.36948442e-02f,
  8.84158015e-02f, 1.42428547e-01f, -6.55777827e-02f, -1.06697371e-02f, -3.77907194e-02f, -7.08125439e-03f, 3.76588441e-02f, 5.08082770e-02f, 3.89198549e-02f, 6.83419779e-02f,
  3.88238905e-03f, 2.04407461e-02f, 1.76744342e-01f, 1.61993802e-01f, 1.05862534e-02f, 1.49212226e-01f, 8.38093534e-02f, 6.63828701e-02f, 9.16848257e-02f, 1.49989381e-01f,
  -5.47484040e-01f, 1.00769605e-04f, -2.89065372e-02f, -1.53537929e-01f, 1.39116675e-01f, 8.79187658e-02f, 2.24437773e-01f, 3.36777791e-02f, -2.71944348e-02f, 1.82272680e-02f,
  3.45304161e-02f, -2.97460835e-02f, -1.12176254e-01f, 8.27289969e-02f, 1.51534555e-02f, 1.62729576e-01f, 1.07243977e-01f, -1.30685344e-01f, -3.19591723e-02f, 7.49859437e-02f,
  1.71711832e-01f, -5.21475226e-02f, -1.75437450e-01f, -3.78231406e-02f, 8.73297304e-02f, 8.54700506e-02f, 9.14019346e-02f, -3.96289378e-02f, 1.20329298e-01f, -8.50326568e-02f,
  -1.43006638e-01f, -1.69050142e-01f, 5.90719022e-02f, 7.13950321e-02f, -4.03307080e-02f, -1.10133283e-03f, -5.84437065e-02f, 1.15964292e-02f, -4.43504602e-02f, -2.49334555e-02f,
  6.06226064e-02f, 2.20505558e-02f, -5.62963858e-02f, -2.13959850e-02f, -4.53144535e-02f, -3.22308205e-02f, -1.46980246e-03f, -3.09865847e-02f, 2.96877008e-02f, -1.41507937e-02f,
  1.19077325e-01f, 5.09303994e-02f, -7.80626312e-02f, -2.09472794e-02f, -1.21688256e-02f, -5.57775982e-03f, -6.73155934e-02f, -1.14298642e-01f, -4.75695319e-02f, -1.69923782e-01f,
  9.52177681e-03f, -9.01534036e-03f, -4.10494432e-02f, 6.67350739e-03f, 9.34102014e-03f, -2.98517048e-02f, 6.16073329e-03f, 7.67616555e-02f, -6.59810333e-03f, 2.72150561e-02f,
  -2.39431225e-02f, -3.20721343e-02f, -1.77974459e-02f, 1.03313504e-02f, -5.87076973e-03f, -7.76531966e-03f, 3.87813374e-02f, -8.36351421e-03f, 5.53110242e-02f, -6.77444637e-02f,
  -2.16722060e-02f, -3.42888162e-02f, -6.86958134e-02f, -3.01076192e-02f, 5.76092163e-03f, -3.52068208e-02f, 5.26465029e-02f, -3.52889188e-02f, 4.12272755e-03f, 2.82824673e-02f,
  -5.17391227e-02f, 2.34796293e-02f, 3.00283153e-02f, 2.36285478e-02f, 2.45546345e-02f, -5.09414487e-02f, -4.49149609e-02f, -8.44657142e-03f, 2.50766817e-02f, -5.51121645e-02f,
  1.35523137e-02f, -1.00623354e-01f, -3.07021122e-02f, 1.03590079e-01f, 7.20952079e-02f, 4.50829864e-02f, 3.78338993e-02f, -6.50545433e-02f, 3.81133668e-02f, 5.29794618e-02f,
  6.69088736e-02f, -4.45438363e-02f, -5.55492789e-02f, 2.98300404e-02f, 3.10342200e-02f, 8.95293988e-03f, 2.34233420e-02f, 3.97355966e-02f, 8.22639279e-03f, 3.48077640e-02f,
  2.02684700e-01f, -9.83917713e-02f, 2.35083312e-01f, 3.24019969e-01f, 1.75986469e-01f, 5.17523251e-02f, 2.53018178e-02f, -2.54573161e-03f, 1.07890382e-01f, 5.61365932e-02f,
  -7.04287812e-02f, -4.68913950e-02f, 1.35228327e-02f, 4.85179573e-02f, -7.40844682e-02f, 8.02489966e-02f, 9.30702239e-02f, 9.71666351e-02f, 2.75023848e-01f, 1.27363399e-01f,
  1.92549676e-01f, 2.68095165e-01f, 2.68142581e-01f, 1.79911494e-01f, 2.83580646e-02f, 1.08866572e-01f, 1.84231788e-01f, 9.78748277e-02f, 9.17352065e-02f, 2.37395465e-01f,
  1.23030871e-01f, -4.89015318e-03f, -2.22016796e-02f, 1.19250141e-01f, -4.69070822e-02f, -1.07325897e-01f, -5.76143265e-02f, -1.17883451e-01f, -1.58229157e-01f, -6.44300804e-02f,
  3.37088779e-02f, -9.84750781e-03f, -5.83729483e-02f, -9.14345160e-02f, -2.78268103e-02f, -3.59803624e-02f, 1.02939121e-02f, 3.18654557e-03f, -9.31370780e-02f, -2.74287239e-02f,
  -6.62696362e-02f, 2.50887610e-02f, -1.98956244e-02f, -1.26267746e-01f, -5.70016168e-03f, 5.05336858e-02f, -8.29429179e-02f, -4.86736223e-02f, -1.98544934e-03f, -8.59437063e-02f,
  -5.85401691e-02f, -3.39019485e-03f, 1.79277752e-02f, 4.63754982e-02f, 4.30309474e-02f, -5.45638092e-02f, 1.42895905e-02f, 6.34931447e-03f, 7.56669641e-02f, 5.31761395e-03f,
  -7.73718506e-02f, -2.33335700e-02f, -3.15042362e-02f, 6.95662573e-02f, -2.03594733e-02f, 3.16944495e-02f, -7.75376558e-02f, -8.84388015e-03f, -3.99990007e-03f, 1.64354150e-03f,
  -1.80683825e-02f, 7.14024110e-03f, 1.53758051e-02f, -4.74778675e-02f, 1.98399127e-02f, 4.46365867e-03f, -2.89996658e-02f, 2.53469627e-02f, 3.38020474e-02f, 6.43182173e-02f,
  -9.13743973e-02f, -1.30642936e-01f, 1.31163904e-02f, -4.83363941e-02f, -6.24160059e-02f, -2.91294400e-02f, -3.63204181e-02f, -4.80124056e-02f, 2.89183687e-02f, -6.70865476e-02f,
  -7.05029145e-02f, 3.99563881e-03f, -6.83265477e-02f, -6.95795473e-03f, 8.30869228e-02f, 1.03964664e-01f, -4.19100933e-02f, 6.89357296e-02f, 1.74485669e-02f, -1.15754463e-01f,
  -7.80339018e-02f, 3.88490851e-03f, 4.33860254e-03f, -2.31287852e-02f, -4.79088277e-02f, -3.82391028e-02f, -7.01580569e-02f, -4.88316268e-02f, -1.10465333e-01f, -1.45663321e-01f,
  -4.30744410e-01f, 5.42943999e-02f, -5.57753518e-02f, -9.48251709e-02f, 1.80036932e-01f, -6.40389174e-02f, 5.10218851e-02f, -5.85737936e-02f, 7.21420795e-02f, 1.57877337e-02f,
  1.41905725e-01f, 1.30511135e-01f, -3.20759751e-02f, 5.77225164e-02f, -9.78845134e-02f, -1.91104859e-02f, -3.94076519e-02f, -7.20898882e-02f, -1.88311443e-01f, -5.98486997e-02f,
  9.13711414e-02f, 1.95771586e-02f, -1.48669034e-01f, 6.50957634e-04f, 1.65506318e-01f, 4.82833106e-03f, 3.68100032e-02f, 3.16878222e-02f, 8.86304155e-02f, 7.86836073e-02f,
  8.94454941e-02f, -6.81849867e-02f, -3.49495783e-02f, -2.80120410e-02f, 9.28004086e-02f, -8.05345774e-02f, 4.88147959e-02f, 3.91316116e-02f, -9.36554559e-03f, -8.59478314e-04f,
  -2.09216010e-02f, -7.15056583e-02f, -4.20928858e-02f, -4.81923446e-02f, 7.58875832e-02f, -6.82508796e-02f, -4.60611247e-02f, -9.63874459e-02f, -1.52413726e-01f, 6.62790239e-02f,
  9.09038484e-02f, 2.69755088e-02f, -5.35627455e-02f, -6.88170344e-02f, 3.83214243e-02f, 1.51879517e-02f, 7.80638084e-02f, 1.15637025e-02f, -9.23092291e-02f, 4.88283299e-02f,
  3.26440148e-02f, 5.00443056e-02f, -3.53750288e-02f, 2.07821978e-03f, 3.35793495e-02f, 5.18636294e-02f, 1.70560218e-02f, -7.75055774e-03f, 7.20380545e-02f, -8.02007541e-02f,
  6.98966384e-02f, -1.66292209e-03f, -3.39496247e-02f, 2.76402035e-03f, 9.44734290e-02f, 3.75715457e-02f, -4.26604934e-02f, 6.58761263e-02f, 4.01719399e-02f, -2.20083203e-02f,
  -7.10675418e-02f, 5.75364009e-02f, 5.08265160e-02f, 1.51258020e-03f, 5.86011559e-02f, -3.74988355e-02f, -2.92750448e-02f, -5.32730622e-03f, 4.60974835e-02f, -6.63680807e-02f,
  1.13059655e-01f, -4.17602658e-02f, 4.81207073e-02f, -2.65065543e-02f, -3.14630307e-02f, -2.12287419e-02f, -2.72220522e-02f, -4.11285423e-02f, -8.73246714e-02f, -1.08465357e-02f,
  9.07503590e-02f, -1.05865933e-02f, -5.37605397e-03f, -2.96445601e-02f, -8.18637908e-02f, -5.51734939e-02f, 1.24216981e-01f, -2.35598385e-02f, -5.19692451e-02f, 4.49762642e-02f,
  1.58162806e-02f, -2.70121489e-02f, 5.26751839e-02f, -1.67317521e-02f, -4.18270007e-02f, 2.87746433e-02f, -2.77240910e-02f, -5.95594496e-02f, -3.84683162e-03f, -4.24786806e-02f,
  2.02027753e-01f, 4.08240557e-02f, -2.68602986e-02f, -2.52043060e-03f, -1.31263183e-02f, -1.03048734e-01f, -1.13827042e-01f, 7.85752386e-03f, -6.03110343e-02f, -6.49617240e-02f,
  -3.20310928e-02f, -6.67036921e-02f, 6.94662854e-02f, -6.91946894e-02f, -5.24808979e-03f, -3.79336849e-02f, 3.98866460e-02f, 1.20099165e-01f, -7.67576396e-02f, 3.84951606e-02f,
  -6.00979999e-02f, 9.20622889e-03f, 4.36060354e-02f, 8.99902880e-02f, -3.27529460e-02f, 5.80873564e-02f, 3.02950833e-02f, -3.60142067e-03f, 3.53790633e-02f, 1.22035675e-01f,
  9.14858431e-02f, -4.88649458e-02f, 4.89916913e-02f, -1.89006031e-02f, 2.71919910e-02f, 7.78053794e-03f, 2.56735776e-02f, 4.93446253e-02f, -8.12432840e-02f, 8.79581347e-02f,
  -2.45256554e-02f, 1.22984033e-03f, -2.14582235e-02f, -4.40816730e-02f, -6.30467683e-02f, 7.50524625e-02f, 6.84936717e-02f, 5.52988313e-02f, -2.89318804e-02f, 5.81769496e-02f,
  -3.35756387e-03f, -7.50402957e-02f, 7.10962936e-02f, -4.10177037e-02f, 5.94074326e-03f, 1.19223185e-02f, -6.26366138e-02f, -1.68025342e-03f, 6.18813112e-02f, 3.17782955e-03f,
  5.00288866e-02f, 7.63548836e-02f, -6.95356727e-02f, 2.10632849e-02f, -8.99885874e-03f, -3.52421366e-02f, 5.66600487e-02f, 3.29594612e-02f, -3.05709317e-02f, 5.03102317e-02f,
  -2.21902188e-02f, -9.21591669e-02f, 5.42923100e-02f, -6.85847318e-03f, 3.32437828e-02f, 5.11989631e-02f, 4.53710556e-02f, 4.14091758e-02f, -8.14007223e-03f, -8.82348642e-02f,
  4.63059498e-03f, -5.55017181e-02f, 3.94744426e-02f, -2.97378097e-02f, -7.75609091e-02f, -8.45272560e-03f, 2.09765714e-02f, -4.50048856e-02f, -2.43622027e-02f, -1.67325921e-02f,
  8.54759514e-02f, -1.30516952e-02f, 7.10947253e-03f, 1.92719735e-02f, 2.82700080e-02f, -3.72099243e-02f, 1.77668761e-02f, 3.99628170e-02f, -5.46616055e-02f, -5.72449975e-02f,
  -5.18796630e-02f, -8.39092955e-03f, -3.26306000e-02f, 6.84449300e-02f, 1.08570391e-02f, -6.29554391e-02f, 1.17497435e-02f, -4.66034822e-02f, -1.22795060e-01f, -9.89409015e-02f,
  4.27905619e-02f, -8.80659572e-05f, -3.41690406e-02f, -1.73252448e-02f, -6.65998980e-02f, 2.71363240e-02f, -5.82673140e-02f, 1.31331589e-02f, -2.37449016e-02f, 8.46351981e-02f,
  3.39727253e-02f, 6.95916116e-02f, 1.34852827e-01f, -2.16884837e-02f, 1.62576243e-01f, 5.46739176e-02f, 4.35738862e-02f, -1.45401344e-01f, -7.08781630e-02f, 5.99514181e-03f,
  6.75689876e-02f, -4.86238897e-02f, -1.17774136e-01f, -4.74518910e-02f, -6.70910180e-02f, -8.97191372e-03f, 5.25280461e-02f, 1.96524318e-02f, -3.03585324e-02f, 5.03842793e-02f,
  1.70233231e-02f, -9.31118503e-02f, -7.84375891e-02f, 2.39343680e-02f, -9.27985981e-02f, -1.23299196e-01f, 5.54549396e-02f, -2.30181478e-02f, 1.16362665e-02f, 3.27037345e-03f,
  -4.70484272e-02f, 1.58642009e-01f, -3.38205658e-02f, -8.26989021e-03f, 9.62494407e-03f, -8.16720575e-02f, 6.57824501e-02f, -3.09775770e-03f, 8.08378011e-02f, -8.41062423e-03f,
  1.26968801e-01f, 7.88109303e-02f, -2.01882310e-02f, -2.83583179e-02f, 5.26174903e-02f, -8.94353166e-02f, 4.61972058e-02f, -3.05907391e-02f, 9.11070257e-02f, 3.88417393e-02f,
  1.13950081e-01f, 1.61001429e-01f, -1.05952388e-02f, 6.71321154e-02f, -2.30659191e-02f, -6.60550371e-02f, -9.24165547e-02f, -9.23417509e-02f, 5.67284748e-02f, -1.47855282e-01f,
  2.00558454e-02f, 8.81623924e-02f, -4.38615270e-02f, -4.48071696e-02f, 2.24048700e-02f, 7.54050091e-02f, -3.90984416e-02f, -5.67175485e-02f, 4.97589484e-02f, -4.06031460e-02f,
  3.97037342e-02f, 8.60329270e-02f, 2.91700773e-02f, 5.39094582e-02f, -1.01283401e-01f, 8.93720090e-02f, 5.14351726e-02f, -1.94171797e-02f, -1.25903345e-03f, 5.83270378e-02f,
  -5.97960465e-02f, 9.89985280e-03f, 8.00229833e-02f, -7.17802048e-02f, 6.48706453e-03f, -1.20040644e-02f, 9.37320874e-04f, 4.76537347e-02f, 1.08418390e-02f, -1.39975538e-02f,
  -3.61179888e-01f, 2.46010780e-01f, -2.34327372e-02f, -9.48239863e-02f, 1.95330121e-02f, -2.55181883e-02f, -5.03793992e-02f, 9.00155455e-02f, 3.96897830e-02f, 6.50497805e-03f,
  8.35319534e-02f, -3.38656679e-02f, 6.18350916e-02f, 5.87405777e-03f, -1.20796338e-01f, -2.28442959e-02f, -4.65955213e-02f, -7.91467577e-02f, -5.75662404e-02f, 4.23562936e-02f,
  -1.15687959e-01f, -9.73655283e-02f, -2.25420177e-01f, -6.52970672e-02f, -6.97058588e-02f, -1.29433379e-01f, -1.28827184e-01f, -1.62683338e-01f, -1.35641977e-01f, -3.01394284e-01f,
  -6.39074817e-02f, 3.49722862e-01f, 1.19220605e-02f, 7.40825459e-02f, 1.26390178e-02f, -2.37943400e-02f, -1.21952454e-02f, -7.31978118e-02f, 4.66472358e-02f, 1.82178766e-01f,
  4.98545691e-02f, -7.59607786e-03f, -8.41479823e-02f, -9.48230401e-02f, -1.66392371e-01f, 6.65885359e-02f, 1.37330055e-01f, -3.58835720e-02f, -2.62632102e-01f, -1.01501569e-01f,
  -1.76438037e-03f, -4.64533940e-02f, -1.12763397e-01f, 1.55924242e-02f, 1.66706830e-01f, -2.39194427e-02f, 1.59644127e-01f, 1.58943981e-01f, 8.61999393e-02f, 4.52780783e-01f,
  7.12557659e-02f, 4.53984477e-02f, -2.22749010e-01f, 6.96133301e-02f, -3.07905730e-02f, 3.98761639e-03f, 5.87265305e-02f, 4.24494110e-02f, -1.93006266e-02f, 4.29339595e-02f,
  4.46965434e-02f, 4.98225726e-02f, 2.29971614e-02f, 4.67797630e-02f, -2.18262840e-02f, 1.81354471e-02f, -1.94621272e-02f, -1.52795929e-02f, -1.00609347e-01f, -3.23853344e-02f,
  8.00501928e-02f, 6.07527830e-02f, 5.71925975e-02f, 4.91979346e-03f, -1.42514110e-01f, -2.84323469e-02f, 9.42376480e-02f, -2.23064478e-02f, -6.74069151e-02f, 3.20922047e-01f,
  1.34005630e-02f, -3.26062702e-02f, -2.60433368e-02f, 1.76257472e-02f, 6.09110631e-02f, 2.89446414e-02f, 7.61416554e-03f, 2.30350457e-02f, -5.81050962e-02f, -8.80094338e-03f,
  -3.37170102e-02f, 2.50634849e-02f, -1.86912399e-02f, -6.06623664e-02f, 8.90006498e-03f, -7.90498126e-03f, 2.22836453e-02f, -3.67947407e-02f, -7.45903924e-02f, -2.36051157e-02f,
  6.27756864e-02f, -4.39164042e-02f, 1.03095435e-01f, -1.92312170e-02f, -3.74814607e-02f, -3.13447695e-03f, -5.12693226e-02f, -4.38921712e-02f, -6.65471926e-02f, -6.44105524e-02f,
  5.80339171e-02f, -3.78403515e-01f, 6.62705228e-02f, -1.27266068e-02f, -4.22403477e-02f, 1.89727824e-02f, 4.31382097e-02f, -6.33207783e-02f, -7.94725046e-02f, 1.50801484e-02f,
  -1.60115510e-02f, 9.31602065e-03f, -4.86660749e-02f, -4.94553708e-02f, 2.42482666e-02f, -3.95335555e-02f, 1.60209574e-02f, 2.10831352e-02f, -5.40280715e-02f, -2.71176305e-02f,
  4.53481935e-02f, 6.18106872e-02f, -9.34610665e-02f, 8.26959386e-02f, -1.41611211e-02f, -1.15051687e-01f, -1.49082467e-01f, 7.81421214e-02f, -1.30891860e-01f, 7.89875090e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.53291279e-01f, -1.50966570e-01f, -6.84600398e-02f, -5.65820634e-02f, -3.08463853e-02f, 1.39294751e-02f, 2.54894029e-02f, 1.33882865e-01f, -4.23976891e-02f, -1.26614109e-01f,
  1.27153583e-02f, -4.80954535e-02f, -1.01348482e-01f, 2.82888208e-02f, -1.78110585e-01f, -8.64757970e-02f, -1.20257981e-01f, -2.00974733e-01f, -1.02064591e-02f, 1.17536917e-01f,
  -3.42979208e-02f, -1.86234057e-01f, -1.04700327e-01f, -8.88343006e-02f, 1.72886811e-02f, 9.44071636e-03f, -1.74646795e-01f, -1.02266327e-01f, -2.26304326e-02f, -3.01737916e-02f,
  -1.57198772e-01f, 9.87975448e-02f, 1.02147818e-01f, 6.68085227e-03f, -3.58515270e-02f, 7.78997391e-02f, 7.59724379e-02f, 5.00579216e-02f, 2.93284617e-02f, 6.02861755e-02f,
  -5.91968633e-02f, 1.33819520e-01f, -5.66358231e-02f, 9.32478830e-02f, 8.63722898e-03f, 7.07886070e-02f, -3.42106149e-02f, 6.82131723e-02f, -7.02127665e-02f, 1.70314655e-01f,
  -1.64656378e-02f, -1.99853983e-02f, 1.50030758e-02f, 5.96772023e-02f, -2.30320357e-02f, -4.29081870e-03f, 5.54153509e-02f, 5.40230796e-02f, -5.01163267e-02f, -7.99681097e-02f,
  2.76528522e-02f, -3.87911126e-02f, 9.69457701e-02f, 5.34411473e-03f, 3.57234627e-02f, -5.56268618e-02f, 7.00200051e-02f, -3.60630155e-02f, -8.96947682e-02f, -9.23416689e-02f,
  2.04412695e-02f, 1.06226550e-02f, 1.19087256e-01f, -9.37707573e-02f, -8.87566581e-02f, -4.51189764e-02f, 2.33711619e-02f, -7.65941059e-03f, 3.10324896e-02f, -6.69572204e-02f,
  -2.30354443e-02f, 1.15153957e-02f, -3.34780961e-02f, 4.67081740e-02f, 2.07418557e-02f, 2.41702553e-02f, 8.12420398e-02f, -2.71069016e-02f, 1.33910537e-01f, 8.78355801e-02f,
  -2.04065695e-01f, -5.40924333e-02f, -3.28551382e-02f, 9.15853456e-02f, -1.57823339e-02f, -1.19654546e-02f, -1.70111435e-03f, 6.15234002e-02f, -7.87511840e-03f, 7.22122490e-02f,
  1.02395870e-01f, 5.92518114e-02f, 5.19623235e-02f, 7.29837790e-02f, 1.85780432e-02f, 5.73669188e-02f, 5.67749515e-02f, 4.50401232e-02f, -6.65192455e-02f, 1.99861191e-02f,
  -7.42532611e-02f, -1.04173318e-01f, -8.75888243e-02f, -6.02264516e-02f, -5.57903871e-02f, -5.44923879e-02f, -1.74586717e-02f, 8.07824358e-02f, 1.78054720e-02f, -1.74494371e-01f,
  -1.97780162e-01f, 3.53419408e-02f, -4.20138389e-02f, -7.80032873e-02f, 1.34264678e-02f, 9.40990001e-02f, 4.49512806e-03f, 7.85575435e-02f, 8.80932882e-02f, 5.84517568e-02f,
  4.63497639e-03f, 2.03555152e-02f, 1.99075118e-02f, -5.64126186e-02f, -9.06807557e-02f, -1.11561552e-01f, -5.48617207e-02f, -2.12728977e-01f, -1.15597926e-01f, 6.25974238e-02f,
  6.97030872e-02f, -2.75639333e-02f, -1.37421638e-01f, -5.44567779e-02f, -7.18465745e-02f, -1.02186330e-01f, -1.77433208e-01f, -9.93924066e-02f, -5.62138930e-02f, -1.41806200e-01f,
  7.21604936e-03f, 1.59242764e-01f, 5.09741679e-02f, -2.42874566e-02f, 1.79215707e-02f, -5.04860282e-02f, -2.91130878e-02f, -5.65091595e-02f, 9.02944431e-02f, -2.24037021e-02f,
  -1.55817391e-02f, -3.12195159e-03f, -6.79342356e-03f, 4.08219313e-03f, 1.54143954e-02f, -5.02615795e-02f, -4.80994321e-02f, -5.36876172e-03f, -3.13216783e-02f, -2.64834631e-02f,
  2.52542663e-02f, -5.40827066e-02f, 1.47557072e-02f, -8.15528482e-02f, 1.48726963e-02f, -1.03158690e-02f, -4.45597805e-02f, -1.35174757e-02f, -7.49661773e-02f, -6.05211221e-03f,
  -1.22676052e-01f, -1.13281822e-02f, -3.38767357e-02f, 4.54422198e-02f, -3.44350338e-02f, -1.25148343e-02f, -7.03909770e-02f, -6.06011450e-02f, -8.60351175e-02f, 5.89427873e-02f,
  -5.05645387e-02f, -6.11245483e-02f, -5.49493395e-02f, -1.41390264e-01f, -1.03037655e-01f, -2.34748926e-02f, -1.23866148e-01f, -1.15668818e-01f, -1.47689983e-01f, -8.19706693e-02f,
  1.91910956e-02f, 2.20914558e-02f, -8.40142556e-03f, 2.43083015e-02f, -2.65708715e-02f, -1.68690253e-02f, 1.12135299e-02f, 1.03436641e-01f, -2.11978462e-02f, 8.12114179e-02f,
  -1.47279784e-01f, -3.40234526e-02f, 3.14813890e-02f, 4.73612882e-02f, -8.51684436e-02f, 5.38779013e-02f, -5.04995137e-02f, 2.56124921e-02f, 2.74039004e-02f, 1.75640024e-02f,
  5.01232482e-02f, -1.17663085e-01f, -7.31266066e-02f, -7.64679769e-03f, 5.66604547e-02f, 1.99215878e-02f, -8.66563022e-02f, -1.17805757e-01f, -3.16410661e-02f, -2.73123030e-02f,
  -6.99640019e-03f, -7.23717511e-02f, -1.10606983e-01f, 1.94126386e-02f, 1.05792116e-02f, -1.09151848e-01f, -9.78065208e-02f, 1.16266692e-02f, -1.13588080e-01f, -2.07073033e-01f,
  -2.71995775e-02f, -2.64944173e-02f, 5.71871325e-02f, 1.70333628e-02f, 2.58276202e-02f, 7.37482533e-02f, 9.17585343e-02f, 8.61887913e-03f, 4.49317944e-04f, 3.61849703e-02f,
  2.44289432e-02f, 5.95498905e-02f, 3.50488424e-02f, 4.23369855e-02f, 1.50432095e-01f, 1.56705663e-01f, 1.92069888e-01f, 5.99663518e-03f, -5.76688386e-02f, -1.40152583e-02f,
  7.77473599e-02f, 8.68631080e-02f, -6.39904514e-02f, -1.43557694e-02f, 1.15450487e-01f, 4.82138097e-02f, -6.39250800e-02f, 2.65130214e-02f, 8.51438120e-02f, 2.23066375e-01f,
  -1.08304434e-01f, -4.71603535e-02f, 1.04527483e-02f, -7.69027472e-02f, -5.64967021e-02f, -7.43927658e-02f, -3.98014858e-02f, 1.63089503e-02f, 2.37417277e-02f, 2.65850853e-02f,
  1.73903797e-02f, 2.78610997e-02f, -6.32265732e-02f, 8.41048285e-02f, 4.82704677e-02f, -7.70651028e-02f, -2.75468901e-02f, 2.33729333e-02f, 9.48242769e-02f, 6.28084410e-03f,
  4.39133085e-02f, -4.56419177e-02f, 2.44073402e-02f, 2.64154132e-02f, 2.09093112e-02f, -1.14081308e-01f, -4.99450378e-02f, 5.79660758e-02f, 6.71463683e-02f, -4.15310189e-02f,
  -2.06692778e-02f, -3.11011057e-02f, 3.04054078e-02f, -3.44879180e-02f, 9.46348067e-03f, -5.73356226e-02f, 8.61197934e-02f, -1.33139668e-02f, 7.40209296e-02f, 8.55977833e-03f,
  -8.99662450e-02f, -7.20655695e-02f, 4.26600054e-02f, 7.70484209e-02f, -6.97111562e-02f, 5.78959249e-02f, -1.67586666e-03f, -5.68269379e-02f, -1.14965759e-01f, -6.25913367e-02f,
  4.27322760e-02f, -7.31307343e-02f, -7.30595365e-02f, -5.23362383e-02f, -2.29727570e-02f, -2.14190651e-02f, -3.12345568e-03f, -6.50026202e-02f, 5.64896911e-02f, -2.24182196e-02f,
  -1.46402642e-01f, -1.91705167e-01f, 5.43969776e-03f, -2.47916691e-02f, -1.41848698e-02f, -5.99664450e-02f, -9.09873694e-02f, -4.68287580e-02f, 4.94296327e-02f, -3.59488167e-02f,
  5.76572157e-02f, -6.78009391e-02f, -2.97789965e-02f, -2.41378397e-02f, -4.13960777e-02f, 2.21885946e-02f, -1.05652653e-01f, 6.33992553e-02f, -6.02220092e-03f, 1.24783872e-03f,
  6.60975575e-02f, -6.78993091e-02f, -3.38482372e-02f, -1.04816459e-01f, 1.36602754e-02f, -1.31938174e-01f, -4.15080637e-02f, -9.99589041e-02f, -1.36942506e-01f, -1.03350595e-01f,
  -3.33415382e-02f, 3.22758127e-03f, -1.10744335e-01f, -5.37307151e-02f, 8.69577006e-02f, 4.85699624e-02f, 3.65736187e-02f, 6.96490631e-02f, 6.18647337e-02f, -6.02280907e-02f,
  -8.60709101e-02f, 1.60851907e-02f, 2.78892443e-02f, 4.71676029e-02f, 4.50820774e-02f, -3.07514090e-02f, 7.31976777e-02f, -4.07691412e-02f, -1.06066642e-02f, 1.09461108e-02f,
  8.99749547e-02f, 5.24321832e-02f, -9.23478603e-02f, 6.02366030e-02f, -2.70452872e-02f, -7.04241022e-02f, -6.21740110e-02f, 5.57016097e-02f, -2.61478312e-02f, 7.42497966e-02f,
  -4.13806178e-02f, -5.24310060e-02f, 4.70879814e-03f, 1.91803591e-03f, 2.64790375e-02f, -6.90298900e-02f, 5.64041361e-03f, -7.34478310e-02f, -8.74744356e-02f, -9.37597305e-02f,
  1.75933260e-03f, -6.48136437e-02f, -3.95071208e-02f, -4.01148982e-02f, -6.05457127e-02f, 3.82764079e-02f, -5.84725700e-02f, -6.12725317e-03f, -1.64342951e-02f, -9.13951769e-02f,
  9.75367203e-02f, -1.28724743e-02f, -6.72865426e-03f, -5.55108897e-02f, 7.17441067e-02f, -1.83298066e-02f, -5.44160381e-02f, 2.05770414e-02f, -7.32738897e-02f, -7.99515545e-02f,
  6.66562244e-02f, -3.32332179e-02f, 2.73956154e-02f, 1.27751669e-02f, 6.90221041e-02f, -1.72829092e-03f, -2.52029370e-03f, 5.76425046e-02f, -6.68627210e-03f, 4.60114777e-02f,
  6.55837655e-02f, -4.69452292e-02f, 1.72191821e-02f, -3.66039909e-02f, -1.26271113e-03f, -5.58015238e-03f, -4.49364968e-02f, 6.68235570e-02f, -5.68358786e-02f, -5.36946468e-02f,
  -4.69734967e-02f, -2.76810471e-02f, -8.90012905e-02f, -2.32051741e-02f, 6.04015104e-02f, -7.38787353e-02f, -6.39114827e-02f, -3.92704941e-02f, -3.47699523e-02f, 4.66019139e-02f,
  -7.40973353e-02f, -1.31217957e-01f, 3.89463305e-02f, 4.31664661e-02f, -7.25769391e-03f, -8.12635571e-02f, -2.15388369e-02f, -4.39513661e-02f, 1.52008713e-03f, -1.66958962e-02f,
  -2.89964080e-02f, -7.26086795e-02f, -4.13583927e-02f, -4.28430177e-02f, -1.02875367e-01f, -1.85523257e-02f, -1.63911507e-02f, -3.00624464e-02f, 2.25822069e-02f, -5.05392142e-02f,
  3.04177534e-02f, 3.81007157e-02f, -9.40416008e-02f, -7.48384595e-02f, 7.24692550e-03f, 3.98165248e-02f, -5.76124825e-02f, -4.05155644e-02f, -3.05245933e-03f, 1.70631073e-02f,
  -5.51639311e-02f, 2.80676153e-03f, -9.59376059e-03f, -1.60108544e-02f, 5.13571315e-02f, -2.38767508e-02f, -2.21889213e-01f, -7.87226707e-02f, 4.08003777e-02f, -1.13322012e-01f,
  -1.72290672e-02f, 4.91686314e-02f, 4.49868999e-02f, -1.26652002e-01f, -9.97991636e-02f, -1.37470827e-01f, -6.35740235e-02f, 2.15374082e-02f, -6.27752841e-02f, 7.38731166e-03f,
  -3.32137896e-03f, 5.76764308e-02f, -4.07353751e-02f, 2.07303613e-02f, -5.14571816e-02f, -5.57399653e-02f, 6.35303631e-02f, -5.32442518e-02f, -7.60699585e-02f, -8.23180098e-03f,
  -1.36256844e-01f, 1.64122991e-02f, 4.82766628e-02f, -5.09724347e-03f, -7.97957182e-02f, -2.16215961e-02f, -6.40204698e-02f, 4.03196886e-02f, -5.70047041e-03f, -7.15215430e-02f,
  -1.51562272e-02f, -3.98608483e-02f, 8.09523240e-02f, 8.65147077e-03f, -6.05655313e-02f, -5.96051104e-02f, -6.12906255e-02f, 5.87836877e-02f, 9.44011286e-02f, 9.77814645e-02f,
  -1.92492269e-02f, -3.12053170e-02f, 2.61918865e-02f, 6.75686896e-02f, -5.08985519e-02f, -2.74958853e-02f, 5.27588390e-02f, 2.67975568e-03f, -3.07114348e-02f, 4.43553142e-02f,
  -5.39660491e-02f, -9.12546888e-02f, 1.33082429e-02f, 2.63005346e-02f, -6.59421086e-03f, -1.08516701e-02f, 3.47889550e-02f, -4.66647893e-02f, -1.01545919e-03f, -2.62699276e-02f,
  7.03777894e-02f, 4.08943333e-02f, -6.64917603e-02f, -6.42433316e-02f, 7.03432411e-02f, 5.05263992e-02f, -7.11873397e-02f, -6.51156483e-03f, 5.58675043e-02f, -1.25218350e-02f,
  -5.65034114e-02f, 8.01370516e-02f, -6.45895824e-02f, -7.85822235e-03f, 7.97929913e-02f, 4.43542972e-02f, -2.19463594e-02f, -1.21960148e-01f, -6.87910318e-02f, -9.95868146e-02f,
  9.18036606e-03f, -3.65667976e-02f, 2.74852868e-02f, -3.98607478e-02f, 1.10020630e-01f, -1.65266939e-03f, 1.01979569e-01f, 8.49654824e-02f, -9.29939933e-03f, -1.24757634e-02f,
  -1.10130049e-02f, 1.93258692e-02f, 6.06530681e-02f, -4.53842022e-02f, 7.36756995e-02f, -3.97968479e-02f, 5.11453450e-02f, 5.18842638e-02f, 2.72612646e-02f, 9.43710506e-02f,
  -4.84223850e-02f, -6.52323216e-02f, -4.91726585e-02f, -3.15894047e-03f, 7.98557922e-02f, -5.39411940e-02f, -2.24690624e-02f, -4.54146266e-02f, -7.30188861e-02f, -6.26215637e-02f,
  1.18710503e-01f, -1.25457197e-01f, 1.57810748e-02f, -3.33437584e-02f, 1.75623372e-02f, -4.97983843e-02f, -8.12115744e-02f, 7.77772442e-02f, 1.83317270e-02f, -9.12698582e-02f,
  -4.94514480e-02f, 1.13154598e-01f, 3.74193341e-02f, -6.37326613e-02f, 9.64827463e-03f, 4.06171344e-02f, 8.20112228e-02f, 6.37407154e-02f, 1.00227512e-01f, 5.77634722e-02f,
  4.47221138e-02f, -2.08365433e-02f, -2.69788373e-02f, -2.23428477e-02f, -6.04918227e-02f, 4.58364412e-02f, 2.24446598e-02f, 1.22069744e-02f, -1.58441979e-02f, -6.79143593e-02f,
  -5.50996922e-02f, -9.34637431e-03f, 4.07134891e-02f, 2.02110335e-02f, -1.11768663e-01f, 2.67316382e-02f, 3.90592441e-02f, -3.08330320e-02f, -2.37553976e-02f, -6.13566488e-02f,
  -5.40677942e-02f, -4.58206497e-02f, 8.53363276e-02f, -1.43110426e-02f, 8.49683583e-02f, -8.10339674e-02f, -6.99519664e-02f, 8.77199974e-03f, -4.92087491e-02f, -3.77149954e-02f,
  -5.24889603e-02f, -1.01693965e-01f, 2.12302362e-03f, -6.90880567e-02f, -5.98847009e-02f, 1.02311060e-01f, 3.75752780e-03f, 6.78682849e-02f, -3.69504578e-02f, -4.37486991e-02f,
  3.00300829e-02f, 4.60840538e-02f, -5.06836958e-02f, -8.84269848e-02f, 1.70503650e-02f, 9.12060514e-02f, -4.84255292e-02f, -6.70741126e-02f, -2.36965045e-02f, -3.56552266e-02f,
  7.95010570e-03f, 2.12061331e-02f, -1.85533315e-02f, -6.15984835e-02f, 1.11232027e-01f, -2.33004596e-02f, -1.40614640e-02f, 3.94055247e-02f, 4.37526144e-02f, 1.32816331e-02f,
  8.35279971e-02f, 1.12940678e-02f, -9.63125080e-02f, 2.63151433e-02f, 2.09929459e-02f, 2.78085750e-02f, 3.81628312e-02f, 6.95267692e-02f, -3.98901366e-02f, 3.70453745e-02f,
  -8.87197107e-02f, -1.00885250e-01f, -9.32833627e-02f, -4.45068441e-02f, 3.06592807e-02f, -9.37950388e-02f, -8.23280215e-02f, -2.30076793e-03f, -4.09181602e-02f, -1.75808836e-02f,
  -2.75835562e-02f, -7.49533698e-02f, -1.93712432e-02f, 5.25076129e-02f, -4.61083762e-02f, 6.90289261e-03f, -6.84663579e-02f, -6.77238852e-02f, 8.09792653e-02f, 4.31405641e-02f,
  -4.81972061e-02f, 5.66522293e-02f, -5.10870926e-02f, 4.61222939e-02f, -7.69782811e-02f, 4.57188971e-02f, 4.63591963e-02f, -2.30567865e-02f, -6.74645454e-02f, -3.96736860e-02f,
  4.15369123e-01f, -2.00104430e-01f, 1.70085266e-01f, 1.21024333e-01f, 1.79145515e-01f, 1.57560423e-01f, 9.81624331e-03f, 1.02986895e-01f, 1.01476364e-01f, 4.73054349e-02f,
  -8.22418854e-02f, -2.05899682e-03f, -5.89778274e-02f, -2.62984075e-02f, 3.14764380e-02f, 3.34219486e-02f, 2.40387861e-02f, 8.49079788e-02f, 9.68775377e-02f, 6.50227889e-02f,
  -1.38115048e-01f, -4.18747924e-02f, -1.37957036e-02f, 4.60334383e-02f, -6.95442362e-03f, 1.28490955e-01f, 1.61839407e-02f, -1.04660213e-01f, -1.37603551e-01f, 1.57696865e-02f,
  5.40987775e-02f, 7.64222741e-02f, 7.84949884e-02f, -1.19010955e-01f, 3.01385927e-03f, 1.35763409e-02f, 6.63125068e-02f, -4.84429002e-02f, -1.60634238e-02f, -4.27004471e-02f,
  -3.90571542e-02f, 2.63298932e-03f, -3.30025032e-02f, -1.40240163e-01f, 5.83281070e-02f, 1.08291935e-02f, -1.65445879e-02f, 2.87570264e-02f, 6.43873885e-02f, 8.03604163e-03f,
  -3.50777656e-02f, 1.68768931e-02f, 1.25838608e-01f, 4.84708790e-03f, 1.05837189e-01f, -2.71948194e-03f, 3.15609351e-02f, -6.74075186e-02f, 1.28647983e-02f, -1.18099913e-01f,
  1.96259692e-02f, 7.88483396e-02f, -4.27265055e-02f, 2.35501919e-02f, 4.56928797e-02f, -2.26248745e-02f, 4.12291475e-02f, -9.76224989e-02f, -4.70012240e-02f, -3.83674391e-02f,
  1.04518386e-03f, -1.30145308e-02f, 3.18559520e-02f, 8.31161365e-02f, -8.23175255e-03f, -3.04650608e-02f, 1.31445695e-02f, 8.17949325e-03f, -3.89882401e-02f, 4.16959897e-02f,
  -2.60470286e-02f, 2.22599171e-02f, 3.43583822e-02f, 2.69930363e-02f, -4.94964905e-02f, -8.36831238e-03f, 5.47356270e-02f, 3.05101853e-02f, -6.81481510e-02f, -5.62677486e-03f,
  3.22536081e-02f, 1.00731730e-01f, 1.13936946e-01f, -2.90975496e-02f, 1.18221410e-01f, -9.88437533e-02f, 7.25206807e-02f, -3.93904299e-02f, 4.97660376e-02f, 6.61082119e-02f,
  7.67850727e-02f, -3.80350575e-02f, 2.44205929e-02f, 2.98274104e-02f, 5.97606860e-02f, -2.97837295e-02f, -1.38905421e-01f, 1.00281253e-01f, -1.20536961e-01f, -1.11646093e-01f,
  -1.29993245e-01f, 1.50429800e-01f, 1.24583058e-01f, 3.40168737e-02f, 2.67468803e-02f, 1.64525419e-01f, -3.00514288e-02f, 5.50664477e-02f, 1.05971247e-01f, 7.99126178e-02f,
  6.32439256e-02f, 6.33191466e-02f, 6.62545934e-02f, -6.79272264e-02f, -3.04228738e-02f, -8.43672380e-02f, 6.39756843e-02f, 5.96909598e-02f, 1.79997422e-02f, 6.77013993e-02f,
  -1.34400859e-01f, -7.77545869e-02f, 2.01650225e-02f, 1.66199747e-02f, 1.01130344e-01f, 8.62596463e-03f, 1.30796373e-01f, 1.94411911e-02f, -1.62021518e-02f, 8.50315318e-02f,
  -4.74019684e-02f, 6.79829121e-02f, 2.72625331e-02f, 1.11917026e-01f, 8.25313330e-02f, 4.42840420e-02f, -5.44661190e-03f, 6.78600278e-03f, -3.40538137e-02f, 2.92703379e-02f,
  1.25219561e-02f, 1.07580870e-01f, -3.21326144e-02f, 1.36431986e-02f, -3.78207043e-02f, 8.05061087e-02f, 9.37591866e-02f, -8.28488842e-02f, -6.21148897e-03f, -7.33369663e-02f,
  -1.04824215e-01f, 1.99276451e-02f, 5.38685434e-02f, -3.47663090e-02f, -9.05413777e-02f, -9.57434326e-02f, -5.73913974e-04f, 2.53109951e-02f, 1.01770088e-02f, -6.61822110e-02f,
  1.76911913e-02f, -3.66347581e-02f, 1.20393634e-02f, -4.44187112e-02f, 7.40226060e-02f, -3.69380191e-02f, 3.17058824e-02f, 4.74605672e-02f, -2.69639753e-02f, -7.21001774e-02f,
  -7.44948313e-02f, -3.63471941e-03f, -5.69234528e-02f, 1.91211719e-02f, -5.95761724e-02f, -1.04666874e-01f, 3.11891641e-02f, -6.93388432e-02f, 4.69254740e-02f, 4.37576622e-02f,
  -9.58967954e-03f, -2.43503228e-02f, -1.22822337e-01f, -1.09607629e-01f, -5.76017983e-02f, -5.01412377e-02f, 5.38972355e-02f, 6.17019087e-02f, -3.18662226e-02f, -1.48542514e-02f,
  -2.50948733e-03f, -2.14828849e-02f, 3.71329971e-02f, 9.66179371e-02f, -8.69799033e-02f, 2.92914025e-02f, -1.00502871e-01f, -1.09454215e-01f, -1.67192370e-02f, 7.64780566e-02f,
  -1.16396256e-01f, -9.37668905e-02f, -8.50246400e-02f, -2.33167186e-02f, 1.18139520e-01f, 6.79574907e-02f, 1.38988402e-02f, -5.32281809e-02f, -4.70944680e-02f, -4.43455763e-02f,
  -8.08429793e-02f, 1.16896611e-02f, 7.33411461e-02f, -4.17069942e-02f, 8.55446160e-02f, -4.88826213e-03f, 5.14804684e-02f, 1.17747381e-01f, 4.76091802e-02f, 2.73516681e-02f,
  3.72122228e-02f, -8.40721056e-02f, -7.54488213e-03f, -1.01757757e-02f, 3.27725173e-03f, -3.92402932e-02f, -4.66521718e-02f, -6.48770705e-02f, -1.06194943e-01f, -2.07253974e-02f,
  2.14298904e-01f, -2.06155762e-01f, -1.75858200e-01f, -4.97188158e-02f, 4.18551937e-02f, 4.40775417e-02f, -8.73340387e-03f, 1.72284152e-02f, 8.75110477e-02f, -6.04716986e-02f,
  -2.77140574e-03f, 2.00727377e-02f, 2.24460941e-03f, -6.11645766e-02f, 9.65315178e-02f, -1.12825938e-01f, -1.91121530e-02f, -7.79377818e-02f, 1.21860527e-01f, 7.51857311e-02f,
  -3.78676914e-02f, 2.90101618e-02f, -1.85707305e-02f, 7.68735781e-02f, -1.49882764e-01f, -3.67883258e-02f, -1.08638473e-01f, -8.54694750e-03f, -7.02548176e-02f, -8.05760249e-02f,
  -2.99094580e-02f, 6.04556687e-02f, 7.24536628e-02f, 6.96813464e-02f, -2.70862281e-02f, -7.54272286e-03f, -4.94085290e-02f, -3.01284883e-02f, -1.81672536e-02f, 8.02849978e-03f,
  -7.95686767e-02f, 4.44843397e-02f, -5.87063469e-02f, 5.44359349e-02f, 7.24351108e-02f, 8.48826114e-03f, 5.68925925e-02f, 4.83634807e-02f, 1.17845228e-02f, -6.83511123e-02f,
  -1.06038280e-01f, -7.32611418e-02f, -1.11051332e-02f, -7.50636831e-02f, 1.90272629e-02f, -3.23024839e-02f, -7.35226572e-02f, 8.87855235e-03f, -5.57037853e-02f, -7.02070743e-02f,
  2.57204119e-02f, -9.09159333e-02f, -6.15836047e-02f, -9.59599018e-03f, 6.15758495e-03f, -2.90685035e-02f, -5.04777655e-02f, -9.12629887e-02f, 1.72227267e-02f, -7.98723698e-02f,
  6.65516630e-02f, 1.13310546e-01f, 5.29905148e-02f, 1.80956889e-02f, -5.49071655e-02f, 6.77710250e-02f, -4.12150249e-02f, 4.05791849e-02f, -9.01083723e-02f, -7.26897866e-02f,
  5.15169203e-02f, -1.08544312e-01f, -9.62326005e-02f, 4.72546406e-02f, 4.54570819e-03f, 3.46435942e-02f, 8.15346912e-02f, -6.54325858e-02f, 1.66625027e-02f, 1.15744285e-02f,
  5.71282245e-02f, 5.81672229e-02f, -7.79368654e-02f, -6.98705669e-04f, -7.94245303e-02f, 8.40291604e-02f, -3.81877571e-02f, -3.32415923e-02f, 1.91831011e-02f, 5.83412834e-02f,
  1.30955987e-02f, 3.00973114e-02f, -9.39927101e-02f, -4.62512225e-02f, -4.89043370e-02f, -5.02195358e-02f, -3.96149904e-02f, 2.61814352e-02f, -9.09136608e-02f, 7.79989883e-02f,
  -7.30478317e-02f, 1.09762840e-01f, 3.67789622e-03f, -9.75767034e-04f, -7.57608935e-02f, 5.13681630e-03f, -1.23720691e-02f, -8.52574781e-02f, 9.32351202e-02f, 8.66497159e-02f,
  -1.33614063e-01f, 4.36172541e-03f, 4.33472358e-02f, 1.05410606e-01f, 1.52276158e-01f, 1.86618175e-02f, 1.19704627e-01f, 4.64855321e-02f, 1.06141552e-01f, -2.14298293e-02f,
  -1.36766750e-02f, -5.22934608e-02f, 8.43012780e-02f, 7.26663396e-02f, 5.76507784e-02f, 7.87124857e-02f, 1.48762375e-01f, -3.84228234e-03f, -1.07574929e-02f, 1.20807014e-01f,
  1.44381791e-01f, -7.00259060e-02f, 4.23770696e-02f, 4.83009703e-02f, 2.90709012e-03f, 1.04300998e-01f, 8.75605121e-02f, -7.32814074e-02f, 8.47491771e-02f, 1.31685808e-01f,
  -9.54867378e-02f, -7.63785094e-02f, -4.71979268e-02f, 1.19244074e-02f, -5.06877042e-02f, -7.13970885e-02f, -2.49145199e-02f, -3.84958722e-02f, 7.08363131e-02f, 3.70983519e-02f,
  6.40471326e-03f, 1.61407702e-02f, -3.10373995e-02f, 4.39309925e-02f, 1.07891941e-02f, -8.00439343e-03f, -1.20232487e-02f, -1.25033529e-02f, 6.55044913e-02f, 7.90323690e-02f,
  -9.62246303e-03f, 7.71404356e-02f, -3.70540395e-02f, 9.17974114e-02f, -5.98587655e-02f, -4.53817844e-02f, -8.80730823e-02f, -8.09322670e-02f, 4.84036468e-02f, -2.26130299e-02f,
  -8.30645189e-02f, -1.96687095e-02f, 8.56340602e-02f, 6.98040426e-02f, 6.31711036e-02f, 1.87799882e-03f, -4.41813208e-02f, 4.77702469e-02f, 7.66189694e-02f, 4.60070670e-02f,
  7.14349374e-02f, -6.37190267e-02f, 2.93519329e-02f, 5.04698865e-02f, 8.58023763e-03f, 4.00416814e-02f, 1.67922545e-02f, -1.73336398e-02f, -6.78697377e-02f, 9.12414212e-03f,
  -7.89540187e-02f, 2.52226479e-02f, -1.82523336e-02f, -2.46501286e-02f, 9.77642089e-02f, 1.49123755e-03f, -3.64710353e-02f, -5.25761172e-02f, 4.31122407e-02f, -9.07849222e-02f,
  -4.52255197e-02f, -7.67890289e-02f, 9.05471295e-02f, -3.38877887e-02f, 5.31453565e-02f, 2.09556483e-02f, 2.11987854e-03f, 4.07024212e-02f, -3.30225006e-02f, 2.57226992e-02f,
  -1.06400371e-01f, -8.52497667e-02f, -3.36764976e-02f, -9.20375288e-02f, -3.90887298e-02f, -9.10817832e-02f, -7.19414232e-03f, -8.14152583e-02f, -9.13235620e-02f, -1.04802594e-01f,
  4.17794734e-02f, -5.06098941e-02f, -3.52247991e-02f, -8.62994604e-03f, -6.76739812e-02f, -6.61042929e-02f, 3.22435461e-02f, 5.48743531e-02f, -8.88865963e-02f, -8.41655359e-02f,
  4.27260786e-01f, -2.92422026e-01f, 6.09349161e-02f, 1.34355009e-01f, -1.61221270e-02f, 7.36653358e-02f, -1.30110979e-01f, 5.31631336e-02f, 9.73102152e-02f, -2.90847998e-02f,
  -2.73734629e-02f, 4.68122698e-02f, -1.85093526e-02f, -5.68412729e-02f, 6.57912567e-02f, -8.35355893e-02f, -9.84499753e-02f, 1.68602645e-01f, 2.96032995e-01f, 1.06773265e-01f,
  -1.89777054e-02f, -1.76799260e-02f, -3.10729612e-02f, 3.20114829e-02f, -1.47287309e-01f, 6.19377680e-02f, -1.91613510e-01f, -5.85329160e-02f, -1.45376101e-01f, -1.66533321e-01f,
  -3.53153348e-02f, 2.80513912e-02f, 1.25234455e-01f, 1.21777598e-02f, -8.92182589e-02f, 5.87852895e-02f, 1.97837725e-02f, -1.02844462e-02f, 1.30693028e-02f, 2.67675593e-02f,
  1.14912078e-01f, -5.45949563e-02f, 9.20194760e-02f, -4.05596159e-02f, -2.26770081e-02f, 6.21441901e-02f, -1.35295779e-01f, -5.67309186e-02f, 6.65720105e-02f, -4.45493832e-02f,
  -1.35670274e-01f, -7.91714489e-02f, -1.57511849e-02f, -1.50841218e-03f, 1.01339177e-03f, 7.10946843e-02f, -9.63458568e-02f, 2.30125170e-02f, 6.78825825e-02f, -1.97131112e-01f,
  -9.07721147e-02f, -1.22376289e-02f, 5.88130020e-03f, -4.84540723e-02f, 6.46456927e-02f, -3.03413030e-02f, 5.59256002e-02f, 6.49663107e-03f, 2.17984300e-02f, -3.53006385e-02f,
  -3.02052349e-02f, 2.67327385e-04f, -5.61132953e-02f, -5.17085306e-02f, -1.01418258e-03f, 5.70113771e-02f, 6.31556809e-02f, 1.84879340e-02f, -6.63000271e-02f, -8.63404050e-02f,
  3.79488617e-03f, 4.93962839e-02f, 2.32682917e-02f, -5.88640978e-04f, -2.92248162e-03f, 1.05096987e-02f, 4.54072170e-02f, -2.87762787e-02f, 5.52418865e-02f, 2.02957187e-02f,
  -9.93191972e-02f, 5.74940704e-02f, 4.54486981e-02f, 3.82612906e-02f, 8.11662376e-02f, 1.42938681e-02f, 5.84090361e-03f, -4.32838202e-02f, -1.13055296e-01f, -7.23068565e-02f,
  -3.93737629e-02f, 4.56614755e-02f, -6.12971187e-02f, -7.50061050e-02f, 1.25205452e-02f, 1.02287136e-01f, -9.64961648e-02f, 2.37784106e-02f, -3.18758413e-02f, -2.04594973e-02f,
  -5.61072528e-02f, 1.43883824e-01f, 1.25195786e-01f, 1.34518296e-01f, 9.10897627e-02f, 2.09064379e-01f, -4.34532203e-02f, -3.23187443e-03f, 1.84108481e-01f, -3.37455310e-02f,
  1.93443432e-01f, -4.37388308e-02f, -1.93918571e-01f, 1.17139228e-01f, -8.00170228e-02f, -1.22361191e-01f, -1.32728755e-01f, 1.65637601e-02f, 5.27568124e-02f, -1.67244941e-01f,
  -8.44400451e-02f, -4.47555706e-02f, 7.97371119e-02f, 7.13252276e-02f, 6.09458759e-02f, -1.81454048e-01f, -1.24656700e-01f, -9.66547132e-02f, -2.47008214e-03f, -8.18382725e-02f,
  -7.63022853e-03f, 3.86914946e-02f, 1.29605249e-01f, 4.88008233e-03f, -3.79333347e-02f, 5.72677776e-02f, 9.29699466e-03f, -9.53099057e-02f, -6.59029707e-02f, 2.41592843e-02f,
  -1.32175118e-01f, -4.80862819e-02f, -1.89829972e-02f, 2.83214040e-02f, -1.00130640e-01f, -1.03502274e-01f, 2.75724195e-02f, -3.97849753e-02f, -6.75941780e-02f, -8.38506371e-02f,
  -2.78951842e-02f, -3.09103518e-03f, 2.80919150e-02f, -5.18126078e-02f, -1.84081849e-02f, -6.23706020e-02f, -8.16269293e-02f, 1.22866966e-02f, 4.90954854e-02f, 6.15427643e-03f,
  6.24177605e-02f, -4.50070240e-02f, -7.64547363e-02f, 4.14891429e-02f, 7.97999576e-02f, 7.98222795e-02f, 6.17096461e-02f, -6.47242321e-03f, -5.20357117e-02f, 5.98934619e-03f,
  -9.74295288e-02f, -2.53972039e-02f, 2.34209299e-02f, -4.70047928e-02f, 6.99300840e-02f, -4.99178618e-02f, 4.63412404e-02f, -5.42922914e-02f, -6.45381073e-03f, 2.64485069e-02f,
  2.22597066e-02f, -1.10006696e-02f, 6.25311509e-02f, 3.74790058e-02f, -4.25821990e-02f, 3.38234156e-02f, 8.53947550e-02f, -2.70323157e-02f, 6.96942732e-02f, -1.46274334e-02f,
  -4.34789667e-03f, -6.98604584e-02f, -1.06588975e-01f, 7.70504549e-02f, -2.61553191e-02f, -4.00749408e-03f, 7.60474652e-02f, -7.17611909e-02f, 1.09780068e-02f, 6.76124692e-02f,
  6.39075637e-02f, -9.92462039e-02f, 3.11670043e-02f, -5.60474358e-02f, 7.12747797e-02f, -7.52134621e-02f, 7.40376115e-02f, -2.69055944e-02f, 2.33046636e-02f, 2.66643334e-02f,
  9.92790982e-03f, -6.50150254e-02f, -2.67622974e-02f, -5.77368168e-03f, -5.65107912e-02f, 1.79254450e-02f, -8.44310820e-02f, 4.83448058e-03f, -3.87581214e-02f, -5.91928586e-02f,
  -6.00533821e-02f, -1.10329371e-02f, 1.09107442e-01f, -7.51832426e-02f, -7.33631700e-02f, 1.68808026e-03f, -2.72872485e-02f, 1.76137034e-02f, 5.38076721e-02f, -7.05593973e-02f,
  -6.47616535e-02f, -2.05935519e-02f, 2.66242120e-02f, 2.48863950e-01f, 1.27520725e-01f, 1.30447105e-01f, 8.16151872e-02f, 1.67818919e-01f, 2.32623756e-01f, 4.61932570e-02f,
  7.03445971e-02f, 5.14827594e-02f, 1.49736211e-01f, 1.17109060e-01f, 9.18107331e-02f, 7.81785250e-02f, 1.47601977e-01f, 1.22302935e-01f, -5.14271632e-02f, 1.16743699e-01f,
  8.32413658e-02f, 9.42711309e-02f, -1.94961801e-02f, 1.67809613e-02f, 1.20631732e-01f, 1.20969541e-01f, 4.27618697e-02f, -1.01527572e-01f, -6.79588392e-02f, 1.09374128e-01f,
  -1.03684261e-01f, -1.81633025e-01f, 1.45803303e-01f, -9.25518200e-02f, -2.11180281e-02f, -5.86517453e-02f, 2.02655327e-03f, -3.15488339e-03f, -4.94359434e-02f, -4.60151583e-02f,
  6.69930223e-03f, -1.01834582e-02f, 7.71611836e-03f, -3.27106342e-02f, -3.83966900e-02f, -4.66433325e-04f, -1.14156511e-02f, 4.20579016e-02f, 8.88502076e-02f, 7.10250437e-02f,
  7.51706287e-02f, 1.92240358e-03f, -2.09818006e-01f, -2.07992233e-02f, -7.94691667e-02f, 3.11711873e-03f, -4.70860526e-02f, 4.77649737e-03f, -5.22303022e-02f, -2.05671526e-02f,
  9.44937021e-03f, 1.88129023e-02f, 2.01689191e-02f, 4.30013575e-02f, 1.09227739e-01f, 8.25312585e-02f, 7.70814046e-02f, -1.58331208e-02f, -1.50668051e-03f, -7.52454102e-02f,
  2.65115853e-02f, 2.98451781e-02f, -3.09883673e-02f, -3.61781497e-03f, 1.02078160e-02f, -5.20964246e-03f, -2.83823628e-02f, 5.66183776e-02f, 3.91363390e-02f, -8.86123180e-02f,
  -4.81566694e-03f, -5.92440963e-02f, 4.81009372e-02f, -7.47967735e-02f, 3.41144204e-02f, 4.17701080e-02f, -3.37044155e-04f, 5.24344780e-02f, 2.75601540e-02f, -3.70216444e-02f,
  6.61721826e-02f, -4.24226113e-02f, 1.33186921e-01f, -5.20950332e-02f, -6.42797872e-02f, -7.91817605e-02f, 5.42050935e-02f, -8.78830776e-02f, -1.42798796e-01f, 5.53015620e-02f,
  -1.21540040e-01f, -5.74895702e-02f, 9.53138433e-03f, -2.28646956e-02f, -9.64304358e-02f, -6.38370514e-02f, 1.12992851e-02f, -4.28717844e-02f, 3.45076509e-02f, -4.04027989e-03f,
  3.48530263e-02f, -8.61608833e-02f, -5.81490658e-02f, 2.06998233e-02f, 7.95366392e-02f, -1.02859540e-02f, -5.27281873e-03f, -6.41292110e-02f, -3.66745554e-02f, -9.10041388e-03f,
  3.39704365e-01f, 1.51192015e-02f, -3.79695684e-01f, -5.26998118e-02f, -2.34420478e-01f, -1.60202786e-01f, -4.36993465e-02f, 7.02873841e-02f, 1.25524685e-01f, -1.97776362e-01f,
  -6.21848740e-02f, 8.61321241e-02f, -4.40183170e-02f, -4.88675013e-02f, 5.62327318e-02f, -2.31297627e-01f, -3.01737368e-01f, -1.22568883e-01f, -4.75976281e-02f, -3.51215131e-03f,
  -2.28913873e-02f, 3.39355394e-02f, 5.72923310e-02f, 4.20426466e-02f, 5.36396541e-02f, 3.03626545e-02f, -1.52003169e-01f, -4.27729748e-02f, -1.25016183e-01f, -2.02294126e-01f,
  -3.76851618e-01f, 3.64020541e-02f, -6.60455525e-02f, 2.13248562e-02f, -8.84788558e-02f, 7.55547658e-02f, -4.13809493e-02f, -1.27838328e-02f, 1.07540689e-01f, 3.53573225e-02f,
  -7.73636475e-02f, -5.50691187e-02f, 6.59440309e-02f, -2.40065027e-02f, 1.48222421e-03f, 2.24887189e-02f, 7.90053084e-02f, -4.64433022e-02f, -5.56713939e-02f, -4.74803597e-02f,
  -5.97637221e-02f, -9.04939920e-02f, 1.99463728e-04f, 5.49391881e-02f, -6.74753040e-02f, -9.38247666e-02f, 2.53363959e-02f, 1.26649544e-01f, 4.00594510e-02f, 1.16810985e-01f,
  -5.45410886e-02f, -5.16344868e-02f, 2.83259824e-02f, 6.55770972e-02f, 3.03084087e-02f, 6.03314862e-02f, -3.53564583e-02f, -2.20659263e-02f, 8.74008983e-02f, 1.81630347e-02f,
  -5.85631430e-02f, -1.64776891e-01f, -9.55760106e-02f, -3.75513136e-02f, 8.97513703e-03f, -5.37607074e-02f, 2.04114597e-02f, 4.41432819e-02f, 5.85295334e-02f, 7.20150545e-02f,
  2.97582224e-02f, 7.12290257e-02f, 2.14809533e-02f, 3.27780060e-02f, -1.56064615e-01f, -3.26736346e-02f, -1.26646757e-01f, 7.49187544e-02f, 8.70198309e-02f, 1.86838477e-03f,
  2.34462917e-01f, -7.08091259e-02f, -9.89635661e-02f, 1.01858072e-01f, -2.16751955e-02f, -5.05440775e-03f, -1.19052036e-02f, 3.37488353e-02f, -3.73149253e-02f, -8.73682722e-02f,
  4.43414710e-02f, -8.08616728e-03f, -4.45453636e-02f, 2.97169797e-02f, 7.90741146e-02f, -2.93229688e-02f, 4.87214327e-02f, 1.09687215e-02f, -7.80621469e-02f, 1.77485030e-02f,
  4.13202383e-02f, 8.98289979e-02f, 8.23286362e-03f, 8.29388127e-02f, 4.87447344e-02f, -3.99702825e-02f, 2.60116104e-02f, -5.47626838e-02f, 8.32629725e-02f, 1.01244867e-01f,
  -8.32750946e-02f, -9.99130011e-02f, 1.04068950e-01f, -1.09579146e-01f, -2.37659849e-02f, 7.18940645e-02f, 2.72343196e-02f, 8.65458045e-04f, -2.11043470e-02f, -4.00325954e-02f,
  -1.32575892e-02f, -3.99639830e-02f, 3.42379808e-02f, -6.53397739e-02f, -9.12205949e-02f, -5.08347340e-02f, -2.42691860e-03f, -6.04837164e-02f, 8.31359848e-02f, 1.04772151e-01f,
  3.71301770e-02f, 9.88022797e-03f, 5.18053994e-02f, -1.38551826e-02f, 1.84821170e-02f, -6.00284971e-02f, -5.75180016e-02f, 7.67327249e-02f, 1.96668357e-02f, -1.29904300e-01f,
  3.06591094e-01f, -1.03282757e-01f, -7.87305832e-02f, -8.96107405e-02f, 4.49971901e-03f, -8.13095346e-02f, 4.52905074e-02f, -2.52606478e-02f, -5.51258922e-02f, 6.79429853e-03f,
  -3.61512788e-02f, -9.37676243e-03f, -2.38638045e-03f, 4.28172424e-02f, -1.55890491e-02f, -5.96558489e-03f, -9.17800330e-03f, -6.83457032e-02f, -4.53859866e-02f, -6.20570034e-02f,
  3.32205789e-03f, -7.90539160e-02f, 4.41169776e-02f, -2.55012102e-02f, -8.27817097e-02f, 7.74007365e-02f, 4.65478636e-02f, 5.58464117e-02f, 5.86858578e-02f, -3.78553569e-02f,
  -6.27472773e-02f, -5.24795689e-02f, 8.67922083e-02f, -3.79278548e-02f, -3.89254205e-02f, 7.84341544e-02f, 6.08788058e-02f, 7.50735402e-02f, 1.12697974e-01f, -2.70027090e-02f,
  6.33411556e-02f, -6.57037692e-03f, 3.83129604e-02f, -5.27594276e-02f, -8.88693035e-02f, -6.91304496e-03f, 3.06737665e-02f, 5.35899848e-02f, -5.05612185e-03f, -8.65217596e-02f,
  -3.96214090e-02f, 1.20997941e-02f, 8.96484405e-03f, -7.80665874e-02f, -4.48817350e-02f, -1.05775278e-02f, -7.27856085e-02f, 3.08851041e-02f, -1.45279511e-03f, 3.76805216e-02f,
  2.53567398e-01f, 3.91052924e-02f, 6.39505461e-02f, -3.80557477e-02f, 1.13904499e-01f, -8.20302442e-02f, 3.10554891e-03f, -5.48015721e-03f, 1.85512360e-02f, 7.84807652e-02f,
  1.08239101e-02f, -4.24914621e-02f, 8.38821232e-02f, 2.42452398e-02f, 6.08143397e-02f, 7.41281882e-02f, -7.95767531e-02f, 2.79556755e-02f, -2.26240437e-02f, 3.19436938e-02f,
  -7.83631131e-02f, -6.26133978e-02f, 4.43242602e-02f, -2.29111370e-02f, 3.09454817e-02f, 1.23631284e-01f, 1.53519452e-01f, 8.95085931e-02f, 1.02813423e-01f, -1.37806628e-02f,
  -3.07729930e-01f, 8.17157179e-02f, 1.05280885e-02f, -8.02692845e-02f, 6.37655333e-02f, -2.53927596e-02f, -1.02043608e-02f, -6.46331534e-02f, -1.06421597e-02f, 5.85388169e-02f,
  8.93845260e-02f, 1.02152042e-01f, 9.72837210e-02f, -4.61171530e-02f, -2.07340613e-01f, -1.75457590e-05f, -9.71115083e-02f, -1.28030077e-01f, -7.47162774e-02f, -7.93811455e-02f,
  3.41227949e-02f, -1.12998731e-01f, -1.32476732e-01f, -1.12947635e-02f, 4.75289412e-02f, 1.39642164e-01f, 7.86353424e-02f, 2.76078237e-04f, 9.35168862e-02f, -2.28903890e-02f,
  2.19777897e-01f, 2.26693042e-02f, -3.17204967e-02f, -5.76932356e-03f, 3.91256474e-02f, -5.91054708e-02f, -6.39507696e-02f, -1.16005309e-01f, 5.63101470e-03f, 5.15155233e-02f,
  2.08531171e-02f, 5.27149215e-02f, -6.83506429e-02f, -5.91989011e-02f, -1.00121029e-01f, -1.20109238e-01f, -9.97443721e-02f, -1.25788108e-01f, -1.05001479e-01f, 3.47647034e-02f,
  -2.34745014e-02f, 1.21812806e-01f, -6.87799007e-02f, -4.91853394e-02f, -4.83270688e-03f, -6.81277364e-02f, -1.30775226e-02f, 4.96435678e-03f, 1.73657164e-02f, -3.95410135e-02f,
  -7.57542849e-02f, 1.17109725e-02f, 3.63859050e-02f, -7.16430172e-02f, -7.93508515e-02f, -3.82447094e-02f, -2.77581774e-02f, -3.48148048e-02f, 1.56793911e-02f, 5.85525781e-02f,
  -2.17766613e-02f, 6.54351190e-02f, 4.23326567e-02f, -1.58197265e-02f, 1.76895633e-02f, 4.37229611e-02f, -1.69747900e-02f, -4.63890173e-02f, -8.95279553e-03f, -7.95860589e-03f,
  -6.09633736e-02f, -4.68085110e-02f, 1.62287448e-02f, -5.02102338e-02f, -2.29457356e-02f, -8.20720568e-02f, -9.58910063e-02f, -6.31765053e-02f, 1.04845837e-01f, -8.88372138e-02f,
  1.29548371e-01f, -1.22807711e-01f, 2.12725112e-03f, -9.41181779e-02f, 4.26911488e-02f, -1.66643821e-02f, 1.05205067e-01f, -1.21436648e-01f, 6.53292285e-03f, -4.84689958e-02f,
  -7.43815154e-02f, -4.60733101e-02f, 1.03452487e-03f, 3.30560207e-02f, -9.29250568e-02f, -2.05484685e-02f, -1.40578002e-01f, -8.45016390e-02f, 9.62100103e-02f, -1.18835818e-03f,
  -9.23913494e-02f, -7.31727332e-02f, -7.72287026e-02f, 4.53421101e-03f, 2.82442700e-02f, 3.62859108e-02f, 1.57599859e-02f, 1.08149610e-01f, -7.53893983e-03f, -8.45571607e-02f,
  1.29112527e-01f, 3.90871204e-02f, -7.82299973e-03f, -1.68068465e-02f, -8.10178220e-02f, -3.52708660e-02f, -1.28933787e-01f, -9.24438164e-02f, 1.85430869e-02f, -3.93467210e-02f,
  -1.13242455e-02f, -3.54258977e-02f, 2.77956575e-02f, 8.64155889e-02f, 1.24347746e-01f, 7.38733336e-02f, 1.24511622e-01f, 1.07768260e-01f, 7.21703917e-02f, 7.57771581e-02f,
  6.12714812e-02f, 6.46950081e-02f, 1.86555848e-01f, 6.52045608e-02f, 1.00864932e-01f, 6.43416494e-02f, 1.04624428e-01f, 2.08179895e-02f, 1.68661829e-02f, 1.21263660e-01f,
  9.51421782e-02f, 6.96538314e-02f, 7.57451802e-02f, 3.10253538e-02f, -6.91025853e-02f, 9.49063897e-02f, 1.77535638e-02f, 7.56059736e-02f, -8.77793953e-02f, -1.03150932e-02f,
  7.45751010e-03f, -4.29629069e-03f, -1.26243848e-02f, 6.92057237e-02f, 7.87965581e-02f, -7.43066519e-02f, 7.42319226e-02f, 9.85773727e-02f, 9.04474407e-02f, -6.43504262e-02f,
  -1.83964279e-02f, -2.51739584e-02f, -8.08309913e-02f, -8.03274214e-02f, 7.75115266e-02f, 6.15083762e-02f, -5.12643494e-02f, 3.15431692e-02f, -3.73995304e-02f, 3.20489854e-02f,
  7.36677125e-02f, -2.78682616e-02f, -4.94685471e-02f, 7.47696459e-02f, 9.17999670e-02f, -9.53306109e-02f, 4.64527719e-02f, 1.26572117e-01f, 8.59404653e-02f, 6.50016442e-02f,
  4.42109257e-02f, 2.69265380e-02f, -7.32088313e-02f, 9.45108980e-02f, -2.96701840e-03f, 4.83137742e-02f, -4.43863980e-02f, 8.39980766e-02f, -9.19510517e-03f, 1.38146430e-02f,
  8.70136023e-02f, -2.95757633e-02f, 4.42557745e-02f, 7.40612447e-02f, 6.41684681e-02f, 7.05005750e-02f, 6.14737496e-02f, 4.67760451e-02f, -6.63689300e-02f, 1.80103106e-03f,
  -7.64869479e-03f, -3.45289521e-02f, 1.05717368e-01f, -6.14718199e-02f, -3.44804302e-02f, 6.59152567e-02f, -1.10799946e-01f, -8.98493174e-03f, 3.67533006e-02f, -4.28457512e-03f,
  -7.60915279e-02f, -3.40359658e-02f, 7.96901900e-03f, 9.78536904e-03f, -3.82939614e-02f, -4.51848246e-02f, -4.52544540e-02f, -6.30712733e-02f, -8.29811767e-02f, -8.85621831e-02f,
  -6.88317865e-02f, -1.37688205e-01f, -1.72651708e-02f, -6.44606650e-02f, -4.53575216e-02f, -6.57956749e-02f, -7.40746334e-02f, -4.49516289e-02f, 3.23016942e-02f, -8.94687548e-02f,
  5.27107306e-02f, 1.09144725e-01f, -1.77888796e-02f, 9.05105323e-02f, -6.91341385e-02f, -1.74087752e-02f, -1.21297665e-01f, -7.41656721e-02f, 5.22240065e-02f, -1.44520588e-02f,
  -2.78812703e-02f, -4.72179353e-02f, 4.79939245e-02f, -7.05499053e-02f, -2.64987331e-02f, -1.22332700e-01f, -3.64605486e-02f, -1.18994907e-01f, -1.97302386e-01f, -1.46854922e-01f,
  -1.21544614e-01f, -4.63125780e-02f, -3.92951518e-02f, 4.19933945e-02f, 1.86639894e-02f, 3.98120992e-02f, -4.36739996e-02f, 4.99329567e-02f, -1.45742282e-01f, 4.15289886e-02f,
  -1.03914313e-01f, -5.84864281e-02f, 3.62104550e-02f, -5.78604043e-02f, 7.18754530e-02f, -5.00576869e-02f, 6.60241395e-02f, 6.20869687e-03f, 1.12907328e-01f, 9.91384834e-02f,
  1.42859565e-02f, -6.56235963e-02f, 3.56615633e-02f, -2.35121977e-02f, -2.10287496e-02f, 1.10591836e-01f, 5.34167737e-02f, -6.09257966e-02f, -7.53593966e-02f, 3.97475734e-02f,
  4.88418266e-02f, -1.04743131e-02f, 2.98309582e-03f, -3.33312005e-02f, 2.61559375e-02f, 2.50272788e-02f, 8.07769075e-02f, 8.12751353e-02f, 3.17512229e-02f, 5.02435379e-02f,
  -7.22604319e-02f, -6.07793704e-02f, 1.97964348e-02f, -7.36102462e-02f, 3.80374640e-02f, 9.79095399e-02f, 3.99831422e-02f, 7.15487003e-02f, 2.51191277e-02f, 8.30167681e-02f,
  1.19479954e-01f, 5.71483113e-02f, -8.15658271e-02f, 1.01621859e-01f, 6.08039759e-02f, -5.68266260e-03f, -1.84335895e-02f, -1.48375127e-02f, -2.29815370e-03f, 1.29677905e-02f,
  6.64798990e-02f, 4.92861159e-02f, 5.34318062e-03f, 9.77012049e-03f, -2.59006824e-02f, 5.44197261e-02f, -8.11500400e-02f, 4.17486355e-02f, -8.20724666e-02f, -3.08576450e-02f,
  1.54307351e-01f, -1.20462328e-01f, 1.18692126e-02f, 1.64606590e-02f, 5.00402376e-02f, 8.20715949e-02f, 4.66544703e-02f, 4.15706523e-02f, -3.88477594e-02f, 8.98598731e-02f,
  -6.39176145e-02f, 2.94865333e-02f, 1.61903873e-02f, 8.96601006e-03f, 4.29275930e-02f, -2.18805075e-02f, 6.80420846e-02f, -4.35842983e-02f, -5.48334643e-02f, 6.41775504e-02f,
  -5.28242905e-04f, 2.37029418e-02f, 1.21164300e-01f, 4.11696471e-02f, 6.59471937e-03f, -9.71842483e-02f, -7.44985640e-02f, 9.21521103e-04f, -4.43855934e-02f, 1.51728868e-01f,
  1.26742171e-02f, -2.53663566e-02f, 1.62386093e-02f, 1.06377505e-01f, -5.21425307e-02f, -1.28590390e-01f, -6.69995621e-02f, 2.82159075e-03f, 5.33985868e-02f, 1.98701080e-02f,
  3.31079843e-03f, 4.29479741e-02f, 2.64802426e-02f, -3.65584828e-02f, 6.45683110e-02f, -7.37714320e-02f, -4.56475001e-03f, -3.76532343e-03f, 4.59958427e-02f, -4.51990589e-02f,
  -3.25682312e-02f, 1.53471939e-02f, -2.08059140e-02f, 9.93724391e-02f, -3.99328619e-02f, -6.59804940e-02f, 1.08363926e-02f, 2.64018960e-02f, -8.48315889e-04f, 2.66470406e-02f,
  -1.48173004e-01f, -9.04393047e-02f, 1.49120055e-02f, -6.42522797e-02f, -4.84358482e-02f, -6.71368763e-02f, -3.51362340e-02f, -5.57561219e-02f, -5.18028177e-02f, 2.26761661e-02f,
  -5.36801666e-02f, 3.89394201e-02f, -5.60162440e-02f, 6.00658990e-02f, -2.21749861e-02f, -3.26894820e-02f, 4.16840725e-02f, -1.23213017e-02f, -1.68805216e-02f, -2.67875195e-02f,
  -2.12241821e-02f, -5.96094467e-02f, -1.07131869e-01f, -9.34501737e-02f, -6.79311603e-02f, -7.86313117e-02f, -6.61056936e-02f, 8.07139054e-02f, 8.59729424e-02f, 8.31550453e-04f,
  1.73364431e-02f, 1.06956949e-03f, -1.10675186e-01f, 2.41883844e-02f, 1.09162042e-02f, -3.60946245e-02f, -8.91278088e-02f, -5.01799304e-03f, -8.91353935e-02f, 2.82814428e-02f,
  -5.74661186e-03f, -4.12334464e-02f, -2.95810383e-02f, 7.22335577e-02f, 5.42672351e-02f, -5.60635701e-02f, 4.91467938e-02f, 5.49564213e-02f, 1.99518166e-02f, 6.21706285e-02f,
  -7.52964765e-02f, -2.15333197e-02f, 1.44228265e-02f, 1.99797228e-02f, 1.48823233e-02f, -5.33067584e-02f, 1.22734858e-02f, 4.24171723e-02f, -9.47521180e-02f, 6.35043457e-02f,
  4.93140295e-02f, -1.33755254e-02f, 6.75651506e-02f, -5.87375350e-02f, 7.45148584e-02f, 5.94157949e-02f, 2.98689175e-02f, -6.27475530e-02f, -1.00791939e-02f, 4.05079909e-02f,
  -5.98120652e-02f, -2.62958910e-02f, -7.64773190e-02f, 3.15738320e-02f, -3.08262147e-02f, 8.38647634e-02f, 4.45343144e-02f, -4.78413627e-02f, 5.82595505e-02f, -2.50042044e-02f,
  5.26500773e-03f, -1.76341254e-02f, 3.61387394e-02f, -3.60217527e-03f, 8.42829794e-02f, -4.56791669e-02f, 6.02176897e-02f, -7.50252903e-02f, -4.91292812e-02f, 3.71213257e-02f,
  9.22832489e-02f, 1.01310484e-01f, 1.47516713e-01f, -4.80328798e-02f, 1.90012813e-01f, 2.08644405e-01f, 3.04490328e-01f, -1.80850213e-03f, -1.18687071e-01f, 9.29125026e-02f,
  2.92134490e-02f, -1.40844375e-01f, -1.32703632e-01f, -1.77147284e-01f, 3.31881531e-02f, 8.86326581e-02f, 7.28311017e-02f, 7.88525864e-03f, 6.23492636e-02f, 6.19447380e-02f,
  -2.67880969e-03f, -1.70033816e-02f, 3.19477692e-02f, -3.39387506e-02f, -2.42992025e-03f, -9.39365700e-02f, 7.05183744e-02f, 1.40030101e-01f, -2.13176459e-02f, -9.83899925e-03f,
  -9.25484300e-02f, 2.47004464e-01f, -6.43352047e-02f, -1.97189167e-01f, 5.52921109e-02f, -3.26930769e-02f, 5.31137630e-04f, 7.49672651e-02f, 5.96828200e-02f, -6.35563880e-02f,
  -1.62368547e-02f, -3.89932059e-02f, 3.81756164e-02f, -3.88996899e-02f, 2.66249143e-02f, 1.09105855e-01f, 3.82244624e-02f, -1.94884352e-02f, -1.04947291e-01f, 1.24298017e-02f,
  -6.76095709e-02f, 5.27059771e-02f, 1.77104473e-01f, 6.26231879e-02f, 8.93404260e-02f, -1.23702183e-01f, 4.54511978e-02f, -8.71927813e-02f, -1.75779741e-02f, -1.53735772e-01f,
  -7.73544684e-02f, -5.79165434e-03f, 1.00828558e-01f, -2.78071407e-02f, -2.94501949e-02f, 8.80508777e-03f, -4.15754365e-03f, 4.09168713e-02f, -2.42601186e-02f, 2.67985314e-02f,
  -3.97362746e-02f, 7.74551481e-02f, -5.97309954e-02f, -5.99036515e-02f, -6.31561056e-02f, 6.08201362e-02f, 1.90327931e-02f, 2.86203367e-03f, 7.00826570e-02f, 2.36450825e-02f,
  -3.81294973e-02f, 9.02983844e-02f, -5.26192002e-02f, 3.74066122e-02f, 1.21552879e-02f, -3.60784568e-02f, -9.42528397e-02f, 2.33798218e-03f, -3.48509499e-03f, -2.52191611e-02f,
  -1.73448101e-01f, 2.21486855e-02f, -1.05674483e-01f, -9.72658843e-02f, 1.77120548e-02f, -8.43268111e-02f, -1.10839829e-01f, -1.19211003e-02f, -6.04859330e-02f, 6.24520220e-02f,
  5.59398264e-04f, -2.99438294e-02f, -1.11613423e-02f, -1.20507879e-02f, 6.68689096e-03f, 1.68307554e-02f, -6.61084056e-02f, 7.55053072e-04f, -6.75087795e-02f, -7.71775544e-02f,
  -5.40683791e-02f, -3.18959057e-02f, 1.27292750e-02f, -7.89992884e-02f, -3.95755358e-02f, -1.10250555e-01f, 8.43268037e-02f, 8.48689862e-03f, -3.15268105e-03f, -5.27693238e-03f,
  -2.20441505e-01f, -3.02016810e-02f, -2.76324078e-02f, -8.67726728e-02f, 1.14254206e-01f, 8.43885317e-02f, 1.10445738e-01f, 2.51264963e-02f, -7.07324520e-02f, -2.49324441e-02f,
  -7.80714080e-02f, 5.08544259e-02f, 4.03573215e-02f, 9.86334458e-02f, 8.63645673e-02f, 6.24267198e-02f, 1.03281125e-01f, -8.40934590e-02f, -3.36428992e-02f, -5.27344039e-03f,
  -2.68613314e-03f, 7.07321763e-02f, -1.40035108e-01f, -6.68470515e-03f, 4.04880717e-02f, -7.12217763e-02f, 7.64583126e-02f, -2.78095063e-02f, 8.72073099e-02f, 8.78327787e-02f,
  3.07899201e-04f, 3.26656587e-02f, 2.04225928e-02f, 1.41421668e-02f, 1.96590144e-02f, -1.09358035e-01f, -4.63780090e-02f, 1.79349259e-02f, -8.33729804e-02f, 3.66276689e-02f,
  3.77659760e-02f, -9.07333288e-03f, -1.51324887e-02f, 8.56186002e-02f, -7.76656717e-02f, -2.69994028e-02f, -9.10930634e-02f, 1.42489942e-02f, 8.35583061e-02f, -3.49045843e-02f,
  1.36135621e-02f, -5.39537035e-02f, -2.89815925e-02f, 2.50063911e-02f, 8.16733018e-03f, -8.04404691e-02f, 3.63150216e-03f, 4.79716733e-02f, -5.42335026e-02f, 6.30247518e-02f,
  -4.63431366e-02f, -8.40014592e-02f, 1.61618087e-02f, -4.29369323e-02f, 2.16700379e-02f, 4.60753404e-02f, 1.99886132e-02f, -3.82967219e-02f, -4.07385291e-04f, -1.06732562e-01f,
  7.31934533e-02f, -1.81239359e-02f, -2.76900046e-02f, 9.49634910e-02f, 6.64955080e-02f, -9.55454819e-03f, 7.55897835e-02f, -7.66386651e-03f, -7.62548018e-03f, 6.20266572e-02f,
  2.36276463e-02f, 8.94280598e-02f, 8.05977657e-02f, 8.08779448e-02f, 1.20483125e-02f, 3.22935358e-02f, 6.51902035e-02f, 3.85386054e-03f, -9.43556279e-02f, 5.38929477e-02f,
  1.49641156e-01f, -9.59056709e-03f, -2.83737816e-02f, 1.53745329e-02f, -6.56944737e-02f, 3.54975127e-02f, 8.22131634e-02f, 3.79881524e-02f, 4.94416468e-02f, 7.10628480e-02f,
  6.43528402e-02f, 8.94948989e-02f, -8.56846850e-03f, -1.93144288e-02f, 1.91181188e-03f, 6.38476983e-02f, -3.60636301e-02f, -3.96572463e-02f, 5.33550919e-04f, 1.14784006e-03f,
  6.36928156e-02f, -7.33100623e-02f, -4.33532372e-02f, -7.72340521e-02f, 7.59165660e-02f, 1.26134884e-02f, 3.40478905e-02f, 7.65827745e-02f, -5.30148074e-02f, 4.18619812e-02f,
  8.44519064e-02f, 1.42936334e-01f, -2.17541531e-02f, -2.16971450e-02f, -1.72637671e-01f, -1.14079796e-01f, 8.00624397e-03f, 2.95291636e-02f, 3.76407169e-02f, 6.19768202e-02f,
  -2.25590821e-02f, 2.01307330e-02f, -8.69837925e-02f, -3.55121344e-02f, 4.35016491e-02f, 1.59057915e-01f, 1.65964440e-01f, 1.68300852e-01f, 3.55752334e-02f, 1.09095201e-01f,
  2.29180586e-02f, 6.57628104e-02f, -3.02198809e-02f, -4.61497307e-02f, 7.23128915e-02f, -1.32302921e-02f, 5.18970797e-03f, 9.25003290e-02f, -2.59323940e-02f, 2.70491123e-01f,
  5.47335446e-02f, 7.99561292e-02f, -7.58218318e-02f, -2.84761358e-02f, 6.65947497e-02f, -2.71894857e-02f, -2.39726789e-02f, -2.35745050e-02f, -7.11822510e-02f, 6.00458384e-02f,
  -2.81240828e-02f, 1.21171549e-01f, -1.54344980e-02f, -2.80720033e-02f, 7.06612617e-02f, 3.97708826e-02f, 6.47007972e-02f, -1.87402987e-03f, 1.42394723e-02f, -6.04648478e-02f,
  3.03098466e-02f, -4.65403199e-02f, -5.75187504e-02f, -6.31648526e-02f, 7.46602267e-02f, -5.74175231e-02f, -8.88147131e-02f, 5.90696372e-02f, -4.59431633e-02f, 9.90813375e-02f,
  2.99270730e-02f, 4.88143489e-02f, 2.86660343e-02f, 3.15421857e-02f, 1.89152285e-02f, 3.09163183e-02f, -5.09570651e-02f, -1.96688883e-02f, -4.85485159e-02f, -4.01786007e-02f,
  5.38333692e-03f, -8.13027546e-02f, -3.02746613e-02f, -7.43661374e-02f, -1.06050670e-01f, 1.00921476e-02f, -1.02810971e-02f, 6.33689314e-02f, 1.69025511e-02f, -9.51449201e-03f,
  -6.44778609e-02f, 3.03448401e-02f, -1.17421970e-02f, -1.90007798e-02f, 1.31306062e-02f, 2.85694283e-02f, 2.17092019e-02f, -8.76531005e-02f, -2.39437986e-02f, 3.32714543e-02f,
  -1.64914802e-01f, -2.39768296e-01f, 5.09843268e-02f, 1.47739276e-01f, 1.46029834e-02f, 1.20590590e-02f, 3.19771282e-02f, -5.23178913e-02f, 4.53617424e-03f, 6.49002045e-02f,
  1.05728395e-02f, 1.42498147e-02f, -4.48623151e-02f, 4.40509357e-02f, -6.93649724e-02f, 3.40108685e-02f, 3.08050904e-02f, -2.04386748e-02f, -5.81425726e-02f, 5.35037778e-02f,
  -1.18017541e-02f, -4.96023260e-02f, -8.67420882e-02f, -1.04521597e-02f, -5.90265496e-03f, -1.05645210e-01f, -4.64903228e-02f, -7.26158544e-03f, -7.51976594e-02f, -1.32306099e-01f,
  1.60197750e-01f, -5.76412268e-02f, -8.85227770e-02f, 2.35082172e-02f, -8.13361481e-02f, -1.20599620e-01f, -6.80242404e-02f, 2.65923459e-02f, 4.63154577e-02f, -2.78993547e-02f,
  -3.62421609e-02f, 1.59149170e-01f, 6.85058534e-02f, 1.36783510e-01f, 4.41899374e-02f, -8.28614160e-02f, -8.55268687e-02f, 2.63192188e-02f, 5.72516359e-02f, 5.66345267e-02f,
  -8.06844085e-02f, 7.29700271e-03f, -1.74922962e-02f, -1.69679001e-02f, -5.81605993e-02f, 6.51383623e-02f, -1.45448789e-01f, -2.78199390e-02f, -1.23122183e-03f, -9.87495035e-02f,
  9.50054377e-02f, 1.30376607e-01f, -1.26117393e-02f, 8.37877169e-02f, -1.12966418e-01f, 3.74586657e-02f, 4.85844910e-02f, -1.02117851e-01f, 3.34892496e-02f, -4.10385616e-02f,
  -2.35889573e-02f, 4.75966297e-02f, -7.53726810e-02f, -9.64726731e-02f, 2.14439929e-02f, -5.66471554e-02f, -1.05021745e-01f, -1.64571614e-03f, 3.25993858e-02f, -8.05288106e-02f,
  -4.84946705e-02f, -6.72149360e-02f, 5.81616163e-02f, 2.53683105e-02f, 1.06271364e-01f, 5.30237239e-03f, 5.17796353e-02f, 6.44533783e-02f, 1.47983264e-02f, -2.68248394e-02f,
  -4.64755446e-02f, -1.16320616e-02f, 1.06415160e-01f, -6.19833358e-02f, -6.10372610e-02f, 2.21903361e-02f, 5.34390174e-02f, 3.04556219e-03f, -4.18153070e-02f, -1.05531536e-01f,
  4.16878574e-02f, 6.77321181e-02f, -2.05779616e-02f, -4.16994020e-02f, 3.24903093e-02f, -2.11483408e-02f, -2.52515841e-02f, -5.31715527e-02f, -7.76415616e-02f, -5.83594339e-03f,
  -8.83544981e-02f, 1.49381515e-02f, -2.89941090e-03f, 6.73386678e-02f, -1.69672016e-02f, 8.37265924e-02f, 7.99073800e-02f, -4.75594215e-03f, -8.11756998e-02f, -4.35961112e-02f,
  -2.73785042e-03f, 1.40308365e-01f, 1.04178287e-01f, 8.63726437e-02f, -3.00191417e-02f, 2.48348825e-02f, 1.50423959e-01f, -6.33988995e-03f, -4.11513746e-02f, 1.52218889e-03f,
  1.67747028e-02f, 8.01541191e-03f, -2.60817576e-02f, 9.62279551e-03f, -3.78251113e-02f, 4.59650718e-02f, -1.46752661e-02f, 1.00175060e-01f, -3.14181596e-02f, 3.54962684e-02f,
  -8.18461254e-02f, -9.80140716e-02f, 1.20983630e-01f, 8.17965425e-04f, -1.53662404e-02f, 7.43526891e-02f, 5.99686988e-02f, 7.92246312e-02f, 3.58501598e-02f, -2.93194633e-02f,
  1.80711761e-01f, -8.14007223e-02f, 3.21882367e-02f, 3.27069536e-02f, -7.59966448e-02f, -1.69967562e-02f, -1.15756452e-01f, -4.91653681e-02f, -5.84005006e-02f, -1.86335314e-02f,
  1.00034498e-01f, 1.34731963e-01f, 3.43770459e-02f, 5.06347306e-02f, 6.71321526e-02f, 2.87385192e-02f, 2.75881719e-02f, 1.44692427e-02f, 1.05064929e-01f, -7.32347369e-03f,
  -9.27622691e-02f, -5.21154441e-02f, 3.55946124e-02f, -7.33590424e-02f, -1.04938611e-01f, 4.06566784e-02f, -3.05223446e-02f, -6.53951988e-02f, -4.86986935e-02f, -1.25709176e-01f,
  1.55076925e-02f, -2.92330980e-02f, 6.50836155e-02f, 1.19116604e-01f, 3.20227817e-02f, -6.71636537e-02f, 9.90728512e-02f, 9.35355350e-02f, 2.90139597e-02f, 4.21671830e-02f,
  -5.97903505e-02f, 9.10048410e-02f, -2.52394974e-02f, 4.66740923e-03f, 1.03279218e-01f, -1.02744717e-02f, -4.39504487e-03f, -2.48154830e-02f, 4.18766290e-02f, 6.75666630e-02f,
  -1.75602660e-02f, 3.57186347e-02f, 4.24615946e-03f, 5.85005209e-02f, 4.41614613e-02f, -4.75851260e-02f, -1.89230754e-03f, 7.96109810e-02f, -4.17065248e-03f, -6.44148663e-02f,
  -1.16553389e-01f, 5.00136008e-03f, 7.89136160e-03f, 5.82882622e-03f, 6.02918677e-02f, -6.28184602e-02f, -2.89543122e-02f, 1.63978676e-03f, 1.14783151e-02f, -3.64650749e-02f,
  -5.11286221e-02f, -4.68307594e-03f, -4.04546820e-02f, 7.43450597e-02f, -4.72673923e-02f, -7.29826018e-02f, -2.27288008e-02f, -5.35368882e-02f, 3.67373563e-02f, 1.78321861e-02f,
  -5.00535481e-02f, -9.82017741e-02f, 3.57528403e-02f, -3.71192284e-02f, 1.86106823e-02f, 2.43751071e-02f, -6.40901029e-02f, 6.21533133e-02f, -8.43173172e-03f, -1.36531387e-02f,
  5.96418045e-02f, -3.62673998e-02f, -5.62038384e-02f, 6.04670197e-02f, -6.99577704e-02f, -4.87486869e-02f, 1.04864225e-01f, 1.00752048e-01f, -6.12689219e-02f, 3.69111821e-02f,
  1.31068397e-02f, -2.71307398e-02f, -4.30070795e-02f, -1.27223495e-03f, 1.36631019e-02f, 7.28350133e-02f, 5.86358160e-02f, -8.06200132e-02f, -7.45043159e-02f, 3.15987468e-02f,
  1.92052070e-02f, 1.29794981e-02f, 1.01176435e-02f, -1.60365123e-02f, 1.67862456e-02f, 9.87905934e-02f, 3.35143507e-02f, 4.81266417e-02f, -5.88180050e-02f, -8.12720582e-02f,
  3.35250907e-02f, 6.81102723e-02f, -1.59780174e-01f, -1.32650912e-01f, -1.46244064e-01f, 1.04976855e-02f, 6.75218701e-02f, 7.97651038e-02f, -9.07317474e-02f, -9.73593518e-02f,
  5.64346313e-02f, -6.26845136e-02f, 1.32317338e-02f, -5.50944209e-02f, 3.45643498e-02f, -5.13935313e-02f, -1.37154520e-01f, 4.88135219e-02f, -3.48000377e-02f, -1.02233604e-01f,
  5.69316894e-02f, -1.02536276e-01f, -2.81709228e-02f, -4.02221717e-02f, -8.48675817e-02f, 5.66620268e-02f, 3.63123529e-02f, 2.35006455e-02f, -6.14027977e-02f, -1.51053116e-01f,
  -9.39512327e-02f, -1.37352899e-01f, 5.35413250e-02f, 6.82159811e-02f, 1.73274036e-02f, 2.83350889e-02f, -7.91626945e-02f, 3.55272926e-02f, 7.22438395e-02f, 1.02760661e-02f,
  -7.41176009e-02f, -8.26439708e-02f, -5.19301780e-02f, -5.76213188e-02f, -4.44980226e-02f, 7.22868815e-02f, 5.96205629e-02f, 3.00479792e-02f, 4.06553335e-02f, -5.13912216e-02f,
  -5.94675019e-02f, 5.87529689e-02f, -7.58272130e-03f, -7.15279132e-02f, -5.61100170e-02f, -1.55633036e-02f, 1.89609993e-02f, -1.07891910e-01f, -8.74574259e-02f, 1.56646837e-02f,
  -7.66768977e-02f, -1.35785807e-02f, 5.60675934e-02f, -3.80598456e-02f, 5.84960766e-02f, 7.37325698e-02f, -3.41716334e-02f, 4.40555140e-02f, 6.76446930e-02f, -3.54647897e-02f,
  -8.09672251e-02f, -8.60057846e-02f, 8.48294720e-02f, -1.65218394e-02f, -5.65955825e-02f, -3.69916335e-02f, 5.50020263e-02f, -1.57946199e-02f, -5.62482588e-02f, 5.37277497e-02f,
  -3.81645374e-02f, 7.40107447e-02f, 4.22548037e-03f, 8.98979455e-02f, -5.36878258e-02f, 5.98544963e-02f, 3.39329690e-02f, -2.74749491e-02f, 7.31834322e-02f, -1.12965666e-02f,
  -6.59808293e-02f, -1.16012422e-02f, -7.48111457e-02f, -3.77737768e-02f, 3.68854478e-02f, 7.62760639e-02f, 4.73721680e-04f, -7.93865649e-04f, 5.52799255e-02f, 3.98669653e-02f,
  -1.68971177e-02f, 6.99257404e-02f, -5.59515581e-02f, -1.38011407e-02f, -3.34298052e-02f, -8.08567256e-02f, -1.72702111e-02f, 1.22158602e-02f, -1.88467838e-03f, 4.97723259e-02f,
  1.27574190e-01f, 8.16441402e-02f, 2.56477967e-02f, -2.04849970e-02f, 3.72388028e-02f, -1.99024025e-02f, -7.09992722e-02f, -4.17411253e-02f, -1.12455115e-02f, 1.00392103e-01f,
  -5.54132015e-02f, 3.44744250e-02f, 5.45627140e-02f, 8.81009102e-02f, 9.30645540e-02f, 9.66794789e-02f, 1.37465987e-02f, 1.21621907e-01f, 7.32518882e-02f, 5.53112812e-02f,
  -5.38449362e-02f, -7.52851786e-03f, 9.94881317e-02f, 1.53085530e-01f, 2.94595174e-02f, -7.48855527e-05f, 1.04316719e-01f, 9.90170315e-02f, 4.97173471e-03f, -1.29091376e-02f,
  6.42852932e-02f, -9.78004560e-03f, 2.88663395e-02f, 3.16359699e-02f, 1.12840161e-01f, 2.86104437e-02f, -1.04566440e-02f, -3.34628671e-02f, 5.86659573e-02f, 2.56860461e-02f,
  -6.83170259e-02f, -1.32676102e-02f, 1.64278317e-02f, 5.44863455e-02f, 1.11909152e-03f, 1.78777706e-02f, -7.69641101e-02f, 4.97493446e-02f, -1.02653600e-01f, -1.50501747e-02f,
  -8.52469206e-02f, -2.89284103e-02f, -4.48414348e-02f, -7.98118487e-02f, -8.34289417e-02f, 1.12026129e-02f, -8.21619853e-02f, 8.61067101e-02f, 2.22986545e-02f, 8.82044509e-02f,
  1.06836021e-01f, 4.08435911e-02f, -9.71516594e-02f, -3.26980799e-02f, 7.06136376e-02f, -5.80235831e-02f, -7.38642141e-02f, -6.99495822e-02f, 8.24806020e-02f, 2.98076943e-02f,
  1.09267402e-02f, 4.23195865e-03f, 3.63678522e-02f, -8.59955996e-02f, 3.35035808e-02f, 9.06995535e-02f, 4.83428985e-02f, -9.58161131e-02f, 7.60941729e-02f, -1.09998040e-01f,
  -6.37724325e-02f, 7.58572593e-02f, -2.89378855e-02f, 8.23922083e-02f, 1.00041099e-03f, 1.42243495e-02f, -2.75815949e-02f, 6.05564192e-02f, -4.63018231e-02f, 6.58819526e-02f,
  -3.69198546e-02f, 6.77925497e-02f, -2.18796674e-02f, -2.31056679e-02f, 2.96663195e-02f, -5.79544380e-02f, -2.74982341e-02f, -1.04990251e-01f, -1.40711933e-01f, 2.58401372e-02f,
  9.30745155e-02f, 7.29988813e-02f, 1.14461638e-01f, -1.53084155e-02f, 5.81777096e-02f, 1.54433167e-03f, 6.03895672e-02f, 8.25478807e-02f, -3.21113467e-02f, 3.98270786e-02f,
  3.88761126e-02f, 4.24230434e-02f, -5.41204624e-02f, 3.35215665e-02f, 1.69033352e-02f, -7.14746490e-02f, 5.95079549e-02f, -1.34883868e-02f, 9.26236659e-02f, 9.92002860e-02f,
  4.14132886e-02f, -3.81521396e-02f, -6.62144572e-02f, -2.40844232e-03f, 8.62663761e-02f, 1.67129617e-02f, 7.76217207e-02f, 4.51644659e-02f, 8.44201222e-02f, -2.22069006e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.06192566e-01f, 8.01707059e-03f, 4.28271107e-02f, -2.56423391e-02f, -3.83612663e-02f, -3.95436548e-02f, 4.68897633e-02f, -3.13251885e-03f, 1.68182209e-01f, -2.87298970e-02f,
  2.23469615e-01f, 1.45425543e-01f, 1.16523653e-01f, 1.70310333e-01f, -2.10013706e-02f, 2.14331910e-01f, 5.14348485e-02f, 2.11869483e-03f, 2.87785530e-02f, 1.46013007e-01f,
  1.04702577e-01f, 2.02914663e-02f, -1.24932611e-02f, 4.31765690e-02f, 1.16109587e-01f, -6.87284321e-02f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  6.66344985e-02f, 9.04273894e-03f, -7.23113492e-02f, -1.48927066e-02f, -1.14782341e-01f, -3.45598906e-02f, -8.98266435e-02f, -5.12236170e-02f, 5.32712340e-02f, 8.27330500e-02f,
  5.95393851e-02f, -1.23561054e-01f, -7.28871301e-02f, -7.91663304e-02f, -1.29852310e-01f, -4.40256819e-02f, -1.02516003e-01f, 1.47803590e-01f, -1.69762596e-01f, -2.14074198e-02f,
  -2.50936866e-01f, 2.12000862e-01f, -6.00202801e-03f, 9.37235951e-02f, -3.89219224e-02f, 3.92969586e-02f, -6.92396536e-02f, 2.51851112e-01f, -7.73510039e-02f, 2.08875835e-01f,
  1.15635976e-01f, -9.04586464e-02f, -1.56153113e-01f, -1.26242667e-01f, 1.20245673e-01f, 7.76864514e-02f, -1.46429881e-01f, -4.59193066e-02f, -6.55164570e-02f, 1.29453763e-01f,
  -3.33092758e-03f, -5.84201775e-02f, 3.62445191e-02f, -4.85274680e-02f, -9.53885913e-02f, -1.84169896e-02f, 3.13917361e-02f, -1.38261333e-01f, 4.51779738e-03f, 2.21752644e-01f,
  9.59612057e-02f, 2.40978822e-01f, -1.07868932e-01f, 1.01836570e-01f, 5.77307567e-02f, 9.81537998e-02f, -9.79290679e-02f, -2.77361214e-01f, 8.49364847e-02f, 1.30947933e-01f,
  1.44181252e-01f, 4.34509069e-02f, -9.35031921e-02f, 8.75435397e-02f, -5.67400493e-02f, -1.68734014e-01f, -6.96661472e-02f, 6.57087471e-03f, 3.63545083e-02f, -5.25697619e-02f,
  -2.54441760e-02f, -1.09749325e-02f, -3.51231433e-02f, 5.43566085e-02f, -5.32390513e-02f, -7.83285052e-02f, 4.92729247e-03f, 3.34835239e-02f, 1.52717650e-01f, 1.92541331e-02f,
  7.59082139e-02f, 5.13992049e-02f, -1.39086530e-01f, 2.11245194e-01f, -2.62452245e-01f, -1.17397131e-02f, 8.40636343e-02f, 6.06316701e-02f, -3.73888202e-02f, -1.24564551e-01f,
  1.35055944e-01f, 1.63709581e-01f, -1.87534586e-01f, -1.80292919e-01f, 1.76566597e-02f, -2.40661576e-01f, -7.16197416e-02f, 6.57900795e-02f, 1.70486882e-01f, 1.28162116e-01f,
  9.61612836e-02f, 1.81917623e-01f, 1.22186229e-01f, 5.85409589e-02f, 2.36667879e-02f, 4.32952717e-02f, 7.79596791e-02f, -1.46074239e-02f, -2.20327720e-01f, 7.09905326e-02f,
  -6.09184764e-02f, 5.99783063e-02f, -2.06934005e-01f, -1.76478233e-02f, -1.15594141e-01f, 5.21432124e-02f, -1.02610346e-02f, 4.32094820e-02f, 1.63935617e-01f, 7.89373964e-02f,
  1.17622145e-01f, -1.95821375e-01f, 9.01128501e-02f, 2.87195947e-02f, -1.85026020e-01f, -2.01366078e-02f, -1.51357397e-01f, -1.66166902e-01f, -1.07314341e-01f, -1.56959906e-01f,
  -4.46898043e-02f, -9.20638815e-02f, -2.63749212e-02f, 9.51760113e-02f, 7.88018480e-02f, 1.47879263e-02f, 6.51998296e-02f, -1.64593626e-02f, -3.74194346e-02f, 1.60097644e-01f,
  5.24665117e-02f, -3.25739849e-03f, -4.45008203e-02f, -4.78981547e-02f, 6.10772334e-02f, -2.64301263e-02f, -8.77836421e-02f, -6.08022809e-02f, 1.38477981e-01f, -1.36913031e-01f,
  1.02371804e-01f, -1.40413180e-01f, 5.04006706e-02f, 1.16092928e-01f, -3.30800451e-02f, -9.41932946e-02f, 1.90471068e-01f, -1.50061086e-01f, -1.54790059e-01f, 5.06091565e-02f,
  1.69371769e-01f, 4.84181382e-02f, -7.25003630e-02f, -1.41007319e-01f, 1.46365300e-01f, 1.15996256e-01f, -1.14433885e-01f, -8.70112106e-02f, 1.23065017e-01f, 9.28844064e-02f,
  -5.11967912e-02f, -1.01066895e-01f, 5.05425259e-02f, 8.87257904e-02f, -1.44174516e-01f, 3.43761370e-02f, 1.55226765e-02f, 4.35802341e-02f, 7.44038224e-02f, -1.47850439e-01f,
  1.71842426e-01f, 5.94589598e-02f, 9.70959887e-02f, 6.42374009e-02f, -4.41327430e-02f, 7.33890757e-02f, -4.23178785e-02f, 8.38244408e-02f, -5.24301864e-02f, -1.23876184e-01f,
  -1.60570756e-01f, -2.73353569e-02f, -1.72130838e-01f, 5.68771213e-02f, -1.68040246e-01f, -3.33761121e-03f, -7.33163953e-02f, 3.63853201e-02f, 3.11342832e-02f, 1.16854748e-02f,
  -8.99561793e-02f, -9.64883566e-02f, -7.96097443e-02f, 5.31927273e-02f, -1.10222086e-01f, -1.45888338e-02f, -2.05690861e-02f, -1.43787876e-01f, -6.02065474e-02f, -3.21509433e-03f,
  1.15008047e-02f, -4.64049093e-02f, -1.59716327e-02f, -1.68367743e-01f, 9.25385207e-02f, -1.60820648e-01f, 4.36239615e-02f, -3.92061286e-02f, -8.72582421e-02f, -9.29711908e-02f,
  2.39931703e-01f, -2.47354037e-03f, -1.62354097e-01f, 2.07874730e-01f, 1.78515054e-02f, 3.99847440e-02f, 5.04045375e-02f, -3.05442419e-02f, 6.71651736e-02f, 1.25248209e-01f,
  -1.31698802e-01f, -2.51018517e-02f, 7.40897581e-02f, -8.53962451e-02f, -1.65144533e-01f, 7.42319822e-02f, 1.17007159e-01f, 6.21950701e-02f, 5.15945144e-02f, -6.12586588e-02f,
  8.13715234e-02f, -1.75370663e-01f, -9.68465135e-02f, -1.61150724e-01f, 2.11087719e-01f, 1.85807556e-01f, -5.65759242e-02f, 4.17609364e-02f, -1.39924556e-01f, 1.92351118e-01f,
  9.00190622e-02f, -3.77237052e-02f, -1.22480139e-01f, -4.03260179e-02f, -1.28214151e-01f, -1.10314131e-01f, 7.77259190e-03f, 6.64563924e-02f, -3.37011255e-02f, 1.83863677e-02f,
  -1.20956331e-01f, -1.27612883e-02f, -1.14752531e-01f, 7.07058311e-02f, -4.61603003e-03f, 1.10192327e-02f, 1.15692846e-01f, -5.71033359e-02f, -5.63069433e-02f, 7.66270310e-02f,
  -5.51307835e-02f, -4.63683531e-02f, -3.75205539e-02f, 1.82568312e-01f, -8.94728303e-02f, 2.11598963e-01f, -1.34048671e-01f, 1.79421797e-01f, 7.66291842e-02f, 2.49226950e-02f,
  1.10086150e-01f, -6.04169965e-02f, -5.95229678e-02f, 3.21727723e-01f, -2.46200770e-01f, 1.14663631e-01f, 2.36307308e-01f, -2.70784765e-01f, -8.46808404e-02f, -1.16177715e-01f,
  -8.66054818e-02f, 3.02127618e-02f, 5.55744246e-02f, -7.47214258e-03f, -4.34253700e-02f, -1.70965437e-02f, -9.68097821e-02f, 8.72193873e-02f, 1.09146699e-01f, -5.29243276e-02f,
  9.86106172e-02f, -1.15998209e-01f, 3.35357990e-03f, -1.22100882e-01f, -9.32700858e-02f, 2.04195261e-01f, 6.35060444e-02f, 1.27539992e-01f, -1.54629841e-01f, -1.39863595e-01f,
  1.19790323e-01f, 1.54405043e-01f, 1.44914970e-01f, -2.77844489e-01f, 4.86884639e-02f, 7.73605704e-02f, 1.07365720e-01f, 2.86673792e-02f, 8.57581794e-02f, 8.34211931e-02f,
  -9.92998574e-03f, 7.54259303e-02f, 4.70997021e-02f, -9.16643292e-02f, 2.93753929e-02f, -8.88623390e-03f, 7.77046159e-02f, -4.01542708e-02f, 2.95009017e-02f, -5.16045168e-02f,
  -1.89976290e-01f, -1.89828891e-02f, 1.60000846e-02f, 2.25911159e-02f, -8.85346346e-03f, -1.28781915e-01f, -6.64917901e-02f, -2.17968121e-01f, 1.02387950e-01f, -8.15150142e-02f,
  2.54427016e-01f, -3.65997315e-03f, -6.46944996e-03f, -1.99556336e-01f, -4.43200767e-02f, 1.63464174e-01f, -6.54667690e-02f, -3.20315897e-01f, 2.78326124e-01f, -7.59321302e-02f,
  -2.18525216e-01f, 8.27813968e-02f, 1.99925408e-01f, -5.72119802e-02f, 1.98136941e-01f, 7.77000852e-04f, -1.10363215e-01f, -4.39067744e-03f, 5.93481921e-02f, 1.08464375e-01f,
  1.50069371e-01f, 9.32361186e-02f, -7.97454938e-02f, -1.38718322e-01f, -5.77995554e-02f, 4.72245961e-02f, -1.48839712e-01f, 1.22003332e-01f, -8.43775645e-02f, -2.10112363e-01f,
  5.94103821e-02f, -1.76813036e-01f, 2.69081909e-02f, 1.13915913e-01f, -1.91760004e-01f, 3.58156040e-02f, 9.23790876e-03f, 2.05095604e-01f, 1.53246596e-01f, 2.39759926e-02f,
  -1.52127966e-01f, -7.51676410e-02f, -5.22670485e-02f, 4.56079468e-02f, 1.59594551e-01f, 9.51353740e-03f, 9.98192802e-02f, -1.27559960e-01f, -8.77857357e-02f, -1.90669641e-01f,
  -9.96507853e-02f, -3.87035869e-02f, -6.15670010e-02f, 6.14762828e-02f, 1.82931438e-01f, -1.39706349e-02f, 2.05470268e-02f, -1.03308603e-01f, 2.27812119e-02f, -2.34635151e-03f,
  3.10100237e-04f, 1.45654649e-01f, -1.42976671e-01f, -8.22544843e-02f, 1.00081444e-01f, 1.47796273e-01f, 5.86358793e-02f, 7.11107627e-02f, 1.19528085e-01f, 8.99813622e-02f,
  1.90413088e-01f, 2.33855143e-01f, -2.02307329e-01f, 1.35619268e-01f, -3.14058433e-03f, -6.56980947e-02f, -2.23802663e-02f, -2.86049601e-02f, 1.30263818e-02f, -1.47779271e-01f,
  -4.00926992e-02f, 6.91554174e-02f, 1.82091773e-01f, 1.12638295e-01f, 1.33609265e-01f, 5.64465486e-02f, 4.29847464e-02f, 8.19161683e-02f, -1.00767456e-01f, -4.13917527e-02f,
  4.47820574e-02f, 4.67230305e-02f, -9.35515482e-03f, 1.30395263e-01f, 2.05860555e-01f, 1.82385221e-01f, -6.91487566e-02f, 4.65421677e-02f, 7.19325393e-02f, 1.44984588e-01f,
  -1.01803534e-01f, -2.28876844e-01f, -1.24497421e-01f, 7.20381737e-02f, 8.77146721e-02f, 3.47761177e-02f, 6.57160580e-02f, 2.76552960e-02f, 6.23917859e-03f, -2.31254343e-02f,
  -1.24776423e-01f, -7.74995163e-02f, -1.61327329e-02f, -4.28846478e-03f, -2.30867919e-02f, -3.18399929e-02f, -1.36519447e-01f, -7.66899586e-02f, 8.66509005e-02f, -1.42125338e-01f,
  -1.28037184e-01f, 1.87398437e-02f, 1.40784234e-01f, -6.71285018e-02f, -3.15849371e-02f, 1.47265211e-01f, 7.15482756e-02f, -1.95296109e-02f, -6.65940046e-02f, 5.89345656e-02f,
  2.76380498e-02f, 1.62423477e-01f, 7.47827739e-02f, -5.14406860e-02f, 6.52564615e-02f, 1.38616443e-01f, -1.94360480e-01f, -6.91283643e-02f, 7.28480071e-02f, -9.39066085e-05f,
  -1.26807436e-01f, 9.60698053e-02f, -6.04793504e-02f, -3.77915204e-02f, -4.60611954e-02f, -7.73024559e-02f, 1.01471379e-01f, 3.80517095e-02f, -5.55315800e-02f, -5.51270843e-02f,
  1.23645715e-01f, 8.71375501e-02f, -9.24258679e-02f, -4.28590812e-02f, 2.59133074e-02f, -1.31352887e-01f, 1.32704243e-01f, 1.46174565e-01f, -9.69853476e-02f, 1.50140241e-01f,
  -1.00984529e-01f, -1.19192339e-01f, -4.78065573e-02f, -1.03217112e-02f, -8.35593045e-02f, -4.03644927e-02f, -2.80542187e-02f, 7.58401826e-02f, -3.70213799e-02f, 3.23776416e-02f,
  -5.85846677e-02f, 1.65062863e-02f, -8.95817354e-02f, -1.31096900e-01f, 1.07295699e-01f, -6.90613538e-02f, -1.43400803e-01f, 1.48173466e-01f, 3.89563069e-02f, 1.84597932e-02f,
  9.69464108e-02f, 8.33119303e-02f, -5.35133891e-02f, 1.31402183e-02f, 6.87354207e-02f, 6.54430613e-02f, -1.14616072e-02f, -7.79752880e-02f, -9.97609869e-02f, -1.67188086e-02f,
  5.88459186e-02f, 2.21768677e-01f, -1.45454407e-01f, -6.24735914e-02f, 1.65315896e-01f, -8.80028531e-02f, -8.54338184e-02f, -9.97222308e-03f, -5.19081503e-02f, 1.07873827e-01f,
  -4.69906852e-02f, -4.47468385e-02f, -1.42706633e-01f, -1.11102700e-01f, -1.11846961e-01f, 1.02645777e-01f, -6.56725094e-02f, -3.12731750e-02f, 1.23711117e-01f, 1.09172584e-02f,
  -1.55039012e-01f, -7.39086717e-02f, -9.50836837e-02f, -1.42272683e-02f, -1.44974114e-02f, 3.04152984e-02f, -2.48685908e-02f, -7.42890164e-02f, -6.93874480e-03f, 3.30537334e-02f,
  -1.31246392e-02f, -6.57492727e-02f, -1.08418509e-01f, -2.08574086e-01f, -9.91705656e-02f, -1.84091091e-01f, -4.05085422e-02f, -3.71938497e-02f, -7.42685869e-02f, 1.70445561e-01f,
  -2.92367470e-02f, 8.65962058e-02f, 2.98527163e-02f, -3.28918882e-02f, -9.21985209e-02f, 6.49537193e-03f, -1.01649828e-01f, 5.21421321e-02f, -1.50333002e-01f, -1.00673169e-01f,
  -1.34203866e-01f, -3.70050147e-02f, -1.30733386e-01f, -1.87289983e-01f, -1.89574078e-01f, 5.76822497e-02f, 1.09126583e-01f, -1.16596401e-01f, -1.64943293e-01f, 5.67537360e-02f,
  1.57609567e-01f, 3.62484716e-02f, 2.53765434e-02f, 7.73526961e-03f, -1.92670017e-01f, 2.02459693e-01f, -1.05528481e-01f, 1.35279730e-01f, 7.05045015e-02f, -1.53655961e-01f,
  1.87647581e-01f, -1.09060146e-01f, 2.50841916e-01f, 8.44220296e-02f, -2.78426081e-01f, -2.60505117e-02f, 1.15347132e-01f, -2.31802970e-01f, 2.67500360e-03f, -8.00099894e-02f,
  1.03820130e-01f, -3.25205848e-02f, 2.10190147e-01f, -3.90581489e-02f, 9.08461511e-02f, 7.55037218e-02f, -1.31838217e-01f, 2.00588647e-02f, 1.22323826e-01f, -7.47188106e-02f,
  -6.37275875e-02f, -4.18626368e-02f, -9.38088226e-04f, -1.97365824e-02f, -3.44536826e-02f, -7.74917379e-02f, -1.04711272e-01f, -2.04888716e-01f, -1.83431171e-02f, 9.42522734e-02f,
  -6.12780675e-02f, -1.26432003e-02f, -1.34431988e-01f, -1.51783973e-01f, -5.67866676e-03f, -1.60009623e-01f, -6.02162210e-03f, -1.08207045e-02f, -1.44809127e-01f, 6.65652677e-02f,
  -1.26718711e-02f, 4.58035953e-02f, 3.89136858e-02f, 8.28077719e-02f, 8.61336589e-02f, -1.66857675e-01f, 4.51498888e-02f, 1.02660775e-01f, -8.98554102e-02f, 9.31474492e-02f,
  1.62906554e-02f, -2.58833990e-02f, 3.02360468e-02f, -1.06376916e-01f, 9.55969840e-02f, 1.49408095e-02f, 5.76632880e-02f, -4.38909337e-04f, -1.31150514e-01f, -5.56509495e-02f,
  2.36440971e-01f, -2.59793736e-02f, -1.41678616e-01f, 1.99529573e-01f, 1.39907554e-01f, -2.55053733e-02f, -5.28592663e-03f, 1.13121107e-01f, -6.97011426e-02f, 7.10033625e-02f,
  2.78747473e-02f, -5.28561883e-02f, 1.72675997e-01f, -8.99756849e-02f, 7.65488595e-02f, -1.23444498e-01f, -1.15542486e-01f, -1.20103598e-01f, 1.00890733e-01f, -3.17049623e-02f,
  -3.75624634e-02f, 1.12681031e-01f, 2.99603562e-03f, 8.32710415e-02f, 3.42994072e-02f, -1.64875850e-01f, -3.55127081e-02f, 1.53437808e-01f, 1.50551900e-01f, 1.53526261e-01f,
  2.12462857e-01f, 2.45307982e-01f, -5.08963615e-02f, -5.70834167e-02f, -9.29696634e-02f, -2.38330979e-02f, 1.31439418e-02f, -1.09300666e-01f, 1.48750171e-01f, -1.34178996e-01f,
  6.58073137e-03f, 1.12099566e-01f, 1.09695755e-01f, 1.18162848e-01f, 3.66371088e-02f, 9.23002213e-02f, 1.34580154e-02f, -9.68763530e-02f, 1.08491182e-01f, 1.49879128e-01f,
  1.14054859e-01f, -6.64799288e-03f, -4.23819646e-02f, -8.26217085e-02f, 1.36605710e-01f, -8.76521468e-02f, 8.13418552e-02f, -1.66544586e-01f, 4.01373319e-02f, 9.17549282e-02f,
  5.11871949e-02f, -7.54756331e-02f, -1.48822486e-01f, -1.82803348e-01f, 1.93324700e-01f, -2.09186658e-01f, 4.43941914e-03f, 1.79626018e-01f, 2.91407318e-03f, -9.83383209e-02f,
  -1.59945920e-01f, 1.01638444e-01f, -1.32651016e-01f, 1.26164213e-01f, 2.00811714e-01f, 1.63820773e-01f, -1.29384547e-01f, 1.84290692e-01f, -5.18860519e-02f, -3.04131247e-02f,
  -1.56172827e-01f, -3.52678090e-01f, 1.31121846e-02f, -6.18948638e-02f, 5.41530475e-02f, 1.11727484e-01f, -1.10332415e-01f, 1.24896564e-01f, 2.50070453e-01f, -1.43722072e-01f,
  1.49721175e-01f, -4.79243416e-03f, 2.64144480e-01f, -4.44492325e-02f, 1.28971711e-01f, 9.35877040e-02f, -2.83329133e-02f, -2.67452393e-02f, -4.64316607e-02f, -2.14296132e-01f,
  8.16270988e-03f, -1.46659464e-02f, -1.37912318e-01f, -1.63038727e-02f, 9.71801132e-02f, 2.75654532e-03f, -3.70612703e-02f, 8.21764097e-02f, 1.99801233e-02f, -1.36297166e-01f,
  3.89720164e-02f, -2.49943901e-02f, -3.13407071e-02f, 9.51479897e-02f, -1.16390496e-01f, 1.11213431e-01f, 3.13715525e-02f, -2.80845836e-02f, -1.02500565e-01f, 1.41821541e-02f,
  -1.01419853e-03f, -4.93770353e-02f, -1.01593375e-01f, -1.26243860e-01f, -1.16072938e-01f, 6.94367439e-02f, 1.12687767e-01f, -1.44767627e-01f, 1.59037352e-01f, -5.10989130e-02f,
  5.05764745e-02f, 1.47403881e-01f, -7.39643397e-03f, 4.26091999e-03f, -9.26717892e-02f, -1.44403771e-01f, 2.18443707e-01f, 1.10345602e-01f, 3.51223797e-02f, 9.40559283e-02f,
  7.48545155e-02f, 6.63117841e-02f, -1.82234883e-01f, 1.31381124e-01f, -2.57782564e-02f, 5.83066717e-02f, -2.36257881e-01f, -2.39920244e-01f, 8.92128870e-02f, 1.11918762e-01f,
  -1.54579252e-01f, -7.39144683e-02f, 7.90965110e-02f, -4.13710773e-02f, 7.77391344e-02f, 9.39636305e-02f, 2.51411814e-02f, 7.01884702e-02f, 5.14844134e-02f, 5.83290821e-03f,
  -7.97090158e-02f, -1.20369591e-01f, 8.43489394e-02f, -1.22036142e-02f, -6.69655353e-02f, 3.82815115e-02f, 4.77418415e-02f, -1.06634140e-01f, -7.18501955e-03f, -5.86515432e-03f,
  -8.76876861e-02f, -1.17397338e-01f, 8.71664565e-03f, -2.18460876e-02f, 4.20968561e-03f, 1.09685913e-01f, -3.32539603e-02f, 2.25019120e-02f, -6.83411732e-02f, 8.32998902e-02f,
  1.66157439e-01f, -7.62609839e-02f, 1.38718244e-02f, -8.96803886e-02f, 2.45363675e-02f, -4.66901809e-02f, 1.47274002e-01f, -3.16669829e-02f, 9.70764235e-02f, 2.07795441e-01f,
  7.79010449e-03f, 2.24171489e-01f, -9.49608460e-02f, -7.96736255e-02f, -2.55851112e-02f, 3.88246626e-02f, -2.73219068e-02f, 2.73460038e-02f, -2.28421181e-01f, 4.58951946e-03f,
  -2.24923100e-02f, -2.91336536e-01f, 6.20487742e-02f, -1.77271590e-01f, -6.68778121e-02f, 2.81748891e-01f, 4.93282303e-02f, 1.49297401e-01f, 3.37511487e-02f, 3.21149826e-01f,
  -3.24683376e-02f, -1.54717028e-01f, 7.83528313e-02f, 1.25689536e-01f, -3.43336277e-02f, 9.87225249e-02f, -2.40666538e-01f, 1.55177534e-01f, -3.23681310e-02f, -1.06318548e-01f,
  -2.13826656e-01f, 4.52249087e-02f, 4.70242538e-02f, -5.17871529e-02f, -1.03050031e-01f, -1.35052741e-01f, 2.95383204e-02f, 1.83833972e-01f, 7.70633742e-02f, 1.10853784e-01f,
  -2.05810405e-02f, 1.30533144e-01f, -1.38249531e-01f, -2.82740444e-02f, -1.46100353e-02f, -1.21505648e-01f, -1.36274368e-01f, -6.39725477e-02f, -8.93740505e-02f, 5.90015426e-02f,
  5.75483637e-03f, 6.56671599e-02f, -5.81538416e-02f, 2.09694002e-02f, -7.69648626e-02f, -8.91581550e-02f, 9.52692851e-02f, 4.03209031e-02f, 1.03620104e-01f, -3.50874588e-02f,
  1.25339866e-01f, 3.16780917e-02f, 2.40524355e-02f, 8.73561725e-02f, 1.48436040e-01f, -1.30560026e-01f, -1.45256296e-01f, -1.18868379e-02f, -9.37038809e-02f, 8.87308493e-02f,
  -2.35264704e-01f, 1.43901661e-01f, 6.96166828e-02f, -1.41210649e-02f, 1.14288375e-01f, 2.05995739e-01f, -5.33414707e-02f, 2.03819469e-01f, -1.61749616e-01f, -2.76133865e-01f,
  -3.42164971e-02f, 1.95062682e-02f, -6.09612204e-02f, 4.97417673e-02f, -7.09922835e-02f, -2.83344369e-02f, -5.57278208e-02f, -1.00148879e-01f, 3.24978344e-02f, -9.16929990e-02f,
  1.11318320e-01f, -1.25689879e-01f, -7.58685619e-02f, -9.58005488e-02f, -5.81230558e-02f, 3.18966284e-02f, -1.77732989e-01f, 2.44544148e-01f, 9.59522277e-02f, -3.55568267e-02f,
  -1.51747614e-01f, -1.88958533e-02f, -4.89429235e-02f, 9.33855921e-02f, -1.37458518e-01f, -1.74771473e-02f, -1.00376055e-01f, 1.18959099e-01f, -3.03196684e-02f, -1.17046438e-01f,
  -4.90756035e-02f, -3.23101543e-02f, -1.11765109e-01f, 9.09549370e-02f, 4.40621451e-02f, -1.41777441e-01f, 9.35143828e-02f, 1.11530654e-01f, 1.72467113e-01f, -5.97299496e-03f,
  -3.72072384e-02f, -1.46783486e-01f, 8.29915404e-02f, 1.17725953e-02f, -4.34566177e-02f, 1.42918393e-01f, -6.18581660e-02f, 5.99781536e-02f, 1.50530934e-01f, 1.96339697e-01f,
  -2.54962653e-01f, 7.70949200e-02f, 7.97666833e-02f, -1.03572637e-01f, 1.98877417e-02f, -1.76657904e-02f, -4.33203503e-02f, -7.69838020e-02f, 3.19839604e-02f, -2.73704678e-01f,
  -1.84159845e-01f, -2.15932995e-01f, 2.60974374e-02f, 7.59848803e-02f, 9.26582515e-02f, -9.51854661e-02f, 2.05437206e-02f, 3.83291751e-01f, 5.01302667e-02f, -2.79838238e-02f,
  4.83746678e-02f, 1.22811027e-01f, -9.22502130e-02f, -3.24562117e-02f, -2.45659471e-01f, -2.05734540e-02f, -1.55958921e-01f, 8.81580636e-02f, -2.12467238e-01f, -4.00790349e-02f,
  -7.05467910e-02f, -2.73980480e-02f, -2.32217073e-01f, 1.35673374e-01f, 9.80679095e-02f, 8.75808205e-03f, 1.23612709e-01f, 1.81303907e-03f, -4.36686948e-02f, 1.78743944e-01f,
  -2.33388647e-01f, -1.35543317e-01f, 3.99043001e-02f, -7.17476830e-02f, -1.45270288e-01f, -1.11468039e-01f, 8.96988250e-03f, -1.65871275e-03f, -1.06658518e-01f, -8.92012939e-03f,
  1.02135837e-01f, -1.80873442e-02f, 6.86772838e-02f, -1.15265004e-01f, -7.02631921e-02f, 2.08826400e-02f, -6.07088767e-02f, -1.43175572e-01f, 2.02267300e-02f, -4.73602191e-02f,
  -9.72784460e-02f, 1.37201890e-01f, 5.63507155e-02f, -1.22546703e-01f, 2.29644999e-02f, -1.66902944e-01f, 1.96812060e-02f, 1.14121139e-01f, 1.85803473e-02f, 3.93285155e-02f,
  -2.24257205e-02f, -6.52021030e-03f, 6.30667582e-02f, -1.36968240e-01f, 1.07940145e-01f, 1.49672180e-01f, -1.04807392e-01f, 2.04016685e-01f, -1.78037897e-01f, -9.44585651e-02f,
  8.68440345e-02f, 4.88194190e-02f, -1.86048359e-01f, -1.84417158e-01f, -4.98636737e-02f, 9.11141559e-02f, -2.08009481e-02f, 7.16648921e-02f, 6.14002869e-02f, 1.21099530e-02f,
  8.83646077e-04f, -8.63330141e-02f, 1.27267003e-01f, 7.38377646e-02f, -2.87788361e-02f, -6.84077665e-02f, 4.88929898e-02f, -1.25426412e-01f, -9.07706767e-02f, -2.95010339e-02f,
  -9.07621998e-03f, 8.81632492e-02f, 7.45051401e-03f, 7.83982351e-02f, -4.86272722e-02f, 1.42016783e-01f, 2.58929208e-02f, 1.76575825e-01f, -1.39068052e-01f, 1.03531703e-01f,
  -7.84816295e-02f, -5.50207347e-02f, -7.30946586e-02f, 8.81916732e-02f, -9.27235633e-02f, -8.52022171e-02f, -6.70269877e-02f, -2.50832215e-02f, -1.42549261e-01f, 1.54148252e-03f,
  1.59992231e-03f, -3.72417383e-02f, 6.84428774e-03f, -1.38134301e-01f, -5.38028553e-02f, -1.57887965e-01f, 7.49582499e-02f, 8.15671869e-04f, -5.06508797e-02f, 1.88005436e-02f,
  -3.54898721e-02f, -6.71827495e-02f, -1.98603533e-02f, 8.32726015e-04f, 4.04277593e-02f, -3.70051973e-02f, 1.95223004e-01f, 9.51717421e-02f, -1.95321366e-02f, 6.06413139e-03f,
  -6.68193251e-02f, -4.31028083e-02f, -3.81665155e-02f, 6.23944625e-02f, -1.65774718e-01f, 1.25785574e-01f, -6.83683306e-02f, -1.54954672e-01f, 6.25484437e-02f, -6.90133721e-02f,
  -1.14741832e-01f, -9.06217173e-02f, 1.47550032e-01f, -6.80984184e-03f, 6.90919440e-03f, -8.81673619e-02f, -1.22906484e-01f, -9.71372724e-02f, -2.25382987e-02f, 1.73720270e-02f,
  1.83021184e-02f, 1.41548678e-01f, -1.87581684e-02f, 1.26536325e-01f, -1.29971653e-01f, -6.45033829e-03f, 9.12394524e-02f, -3.18268500e-02f, 3.59315090e-02f, 1.18378885e-01f,
  6.48507150e-03f, 1.24088852e-02f, 4.15130891e-02f, -5.20202331e-02f, -6.64749518e-02f, 7.10534528e-02f, 9.76721123e-02f, -3.11214011e-02f, -3.50492895e-02f, 6.06430471e-02f,
  1.29148796e-01f, 4.68484238e-02f, 9.01870709e-03f, 6.72052130e-02f, 5.94076850e-02f, 1.42289609e-01f, 9.92189720e-02f, 2.20069923e-02f, 2.78287139e-02f, -3.02887596e-02f,
  -2.52787489e-02f, 9.51152071e-02f, -5.22807539e-02f, 1.39460325e-01f, 9.67597589e-03f, -5.26077971e-02f, -1.49030402e-01f, -2.98229679e-02f, -8.76588514e-04f, -1.84304506e-01f,
  2.10384429e-01f, -1.50842786e-01f, -1.10049963e-01f, 8.31424072e-02f, -9.87334996e-02f, 7.35009089e-02f, -8.99659842e-02f, 1.20202012e-01f, -1.03745960e-01f, 1.53021142e-01f,
  -8.57968070e-03f, 1.96685623e-02f, -2.55831070e-02f, 7.05480948e-02f, 6.49677888e-02f, 1.92104578e-02f, -4.55337390e-02f, 9.85886753e-02f, -8.79837051e-02f, -9.97207034e-03f,
  -1.75543696e-01f, -4.76858690e-02f, -1.80512872e-02f, -5.52922972e-02f, -3.98817584e-02f, -6.53041080e-02f, 7.80773014e-02f, -6.70150965e-02f, -1.26729235e-01f, 1.34540707e-01f,
  8.69271457e-02f, 1.61689967e-01f, -9.27190110e-02f, 1.27486601e-01f, 4.52461950e-02f, -5.44767603e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -7.29324073e-02f, 7.95028806e-02f, 7.08550140e-02f, -2.00855383e-03f, -7.69838542e-02f, 1.11490570e-01f, 1.19222008e-01f, 4.80032042e-02f, 2.36715395e-02f, 2.77432464e-02f,
  -9.88273695e-02f, 2.60648318e-03f, 2.93009337e-02f, -5.64319789e-02f, -8.47791601e-03f, -1.14232518e-01f, -8.69712606e-02f, 1.91950239e-02f, 5.67075498e-02f, 3.49137485e-02f,
  9.74368956e-03f, -6.97939307e-04f, 1.08085684e-01f, 1.75776035e-02f, -1.08717643e-01f, -3.42759229e-02f, -3.68626527e-02f, 1.86916534e-02f, 9.66200083e-02f, -4.00482491e-02f,
  1.09290868e-01f, -9.51461494e-02f, -3.43708731e-02f, 1.04442023e-01f, 5.93674332e-02f, -9.88256261e-02f, 5.95960170e-02f, -5.31893373e-02f, 2.15113852e-02f, 1.26141191e-01f,
  -1.21060153e-02f, -9.28951353e-02f, 1.19347982e-02f, 9.81951058e-02f, 5.36628962e-02f, -6.38688728e-02f, -1.19693533e-01f, -2.70110611e-02f, -6.98059201e-02f, -6.79502124e-03f,
  7.90046677e-02f, 9.94975343e-02f, -1.10886075e-01f, 9.49791912e-03f, 5.11741005e-02f, 1.34827584e-01f, -8.13368037e-02f, -1.91185437e-02f, 1.14559524e-01f, 1.24478247e-02f,
  8.03705677e-02f, 1.38895422e-01f, -5.07041737e-02f, -9.17874277e-02f, 2.69766878e-02f, 5.44989556e-02f, -3.29746008e-02f, 9.33725610e-02f, -6.36122674e-02f, -1.78844798e-02f,
  -1.02215029e-01f, 9.73488316e-02f, -4.70524766e-02f, 1.37269452e-01f, 1.38837043e-02f, -1.00083485e-01f, -9.10451859e-02f, 4.25470956e-02f, -7.54527003e-02f, -9.75942388e-02f,
  3.64791206e-03f, 5.63363954e-02f, 2.83677336e-02f, 8.03103149e-02f, 1.47612944e-01f, -2.68670581e-02f, -5.09643629e-02f, -2.48098895e-02f, 4.09574583e-02f, -1.01738341e-01f,
  4.21147123e-02f, -6.13407418e-02f, -6.33337768e-03f, -9.40551460e-02f, -5.87104671e-02f, -3.70429568e-02f, 1.47585217e-02f, -9.00970921e-02f, 8.77515599e-02f, 6.29329905e-02f,
  7.29649588e-02f, -6.50697276e-02f, -3.08988653e-02f, 4.59448528e-03f, 8.58423933e-02f, 9.58769992e-02f, 9.15007070e-02f, 2.96206027e-02f, -1.26497686e-01f, -4.56993617e-02f,
  5.19772097e-02f, 1.52401239e-01f, 6.84871078e-02f, -8.97132307e-02f, 1.44063950e-01f, 6.56136647e-02f, 7.58087784e-02f, 3.49511467e-02f, 1.05207944e-02f, -1.14044473e-01f,
  -9.70562175e-02f, -2.76074316e-02f, 1.21737346e-01f, 1.31992459e-01f, 1.50323510e-02f, -1.24288395e-01f, 8.09303150e-02f, 1.52617246e-02f, 7.83632249e-02f, 9.35574770e-02f,
  9.09302831e-02f, -5.81023730e-02f, 9.01735276e-02f, 1.12108059e-01f, -1.62156429e-02f, 4.27902152e-04f, 2.92707831e-02f, 1.40392646e-01f, 1.41766652e-01f, 1.86699748e-01f,
  1.40318066e-01f, -5.24381064e-02f, 3.84709351e-02f, 1.17882855e-01f, 1.62324712e-01f, 3.69924642e-02f, 9.39785540e-02f, -2.05432191e-01f, 3.14511865e-01f, -2.52330780e-01f,
  -2.70387419e-02f, 3.62747796e-02f, 9.03389044e-03f, -5.90700209e-02f, 2.87296046e-02f, -1.89911872e-01f, -1.10355891e-01f, 5.53837828e-02f, -1.21855810e-02f, 1.26294896e-01f,
  2.49253049e-01f, 1.48106918e-01f, -6.34130538e-02f, -1.49353519e-01f, 1.01641767e-01f, -1.87144369e-01f, 1.28981978e-01f, 6.48745373e-02f, -6.47502765e-02f, 3.80779877e-02f,
  -4.05455120e-02f, -4.78284061e-02f, 1.87884897e-01f, -6.12908825e-02f, 1.75922245e-01f, -4.43746559e-02f, 1.70802236e-01f, 2.99270321e-02f, 7.31276423e-02f, 1.21794552e-01f,
  -6.76216707e-02f, 2.08722074e-02f, 1.03322044e-01f, -7.12880939e-02f, 1.19270585e-01f, -3.64026427e-02f, 5.10577299e-02f, -2.57590711e-02f, -7.18720183e-02f, 1.08642586e-01f,
  2.50242744e-02f, -3.94334570e-02f, 1.35553107e-01f, 6.68643862e-02f, 1.59597367e-01f, -2.92713363e-02f, 9.70519781e-02f, 1.97992951e-01f, 3.91178243e-02f, 5.18045463e-02f,
  1.10779554e-01f, 6.05533458e-02f, -5.49502298e-02f, 6.60828780e-03f, -1.18663218e-02f, -2.11824067e-02f, 6.60765618e-02f, 1.58518866e-01f, 9.31945220e-02f, -3.85808125e-02f,
  1.79052860e-01f, -1.58500031e-01f, -5.88174090e-02f, 1.70071915e-01f, -2.93707456e-02f, 1.07764542e-01f, -1.15998924e-01f, 1.44693986e-01f, -7.79903606e-02f, 1.56008214e-01f,
  1.86674654e-01f, 2.97242016e-01f, 9.31852236e-02f, -1.04519308e-01f, 3.42499614e-02f, -2.99229324e-01f, -3.83934416e-02f, 8.52933154e-02f, -1.69741258e-01f, 1.18633538e-01f,
  7.33058974e-02f, 8.54774751e-03f, -1.42078549e-01f, 9.32214707e-02f, 3.29808295e-02f, 2.03899015e-03f, -8.55726153e-02f, -1.56373959e-02f, 1.88899919e-01f, 4.91055958e-02f,
  2.95845419e-02f, -2.68988102e-03f, -1.74567010e-02f, 3.85896206e-01f, 8.95747021e-02f, -3.34939657e-04f, -1.55341372e-01f, 1.89632624e-01f, 1.62625983e-01f, -1.51260599e-01f,
  -7.06873536e-02f, -1.39590859e-01f, 8.48102346e-02f, -4.63747606e-02f, 3.44686978e-03f, -4.21020947e-02f, 6.91693127e-02f, -7.55663142e-02f, 1.68814391e-01f, 1.92420825e-01f,
  2.10265249e-01f, 3.81169915e-02f, 7.46396706e-02f, 5.31531349e-02f, 2.19868585e-01f, 1.18916839e-01f, 9.55772921e-02f, 7.70028979e-02f, 1.20413706e-01f, -1.78970899e-02f,
  1.24070413e-01f, 1.03219785e-01f, 1.36798859e-01f, 3.81780937e-02f, -6.90964311e-02f, 2.66344070e-01f, -2.25001261e-01f, 7.04859346e-02f, 1.10504091e-01f, -1.80065542e-01f,
  1.39919668e-02f, -1.74358651e-01f, -2.01523691e-01f, 1.26410136e-02f, 2.31570899e-01f, -1.41565755e-01f, 1.47335187e-01f, 6.18400797e-02f, -9.93476510e-02f, 2.39636064e-01f,
  2.15432663e-02f, -1.28809782e-02f, -2.21814625e-02f, 8.03238377e-02f, -3.90053019e-02f, -1.66875377e-01f, 1.75507039e-01f, -7.77581036e-02f, 2.79203895e-02f, 2.64065992e-02f,
  -1.48422405e-01f, 1.86264530e-01f, -1.25842467e-01f, -5.40662408e-02f, -4.65927795e-02f, 5.99611625e-02f, -1.78481951e-01f, -2.76951492e-01f, 8.42927247e-02f, -1.11101732e-01f,
  1.87707588e-01f, -1.17782205e-01f, -1.16651885e-01f, 1.49588257e-01f, 1.09120496e-01f, 2.41711527e-01f, 1.19793303e-01f, -6.90421835e-03f, -1.16760612e-01f, 9.65380371e-02f,
  1.51189929e-02f, -8.56064633e-02f, 7.44556040e-02f, 1.06652014e-01f, 4.99503389e-02f, -7.51810297e-02f, -7.43203685e-02f, -6.60165846e-02f, 5.61605804e-02f, -9.44943577e-02f,
  1.42118946e-01f, -1.03688471e-01f, -4.78251055e-02f, 3.27301174e-02f, -2.88387984e-02f, 8.66549686e-02f, -5.59856668e-02f, 6.79032654e-02f, -4.98557873e-02f, 3.76764461e-02f,
  -1.07611962e-01f, 3.93257290e-02f, -2.91772913e-02f, -6.46355376e-02f, 9.71593633e-02f, -1.13974005e-01f, -1.02251291e-01f, 7.26741701e-02f, -5.23102209e-02f, 4.16065976e-02f,
  8.20023641e-02f, -5.75666036e-03f, 6.37892038e-02f, -8.20124522e-02f, 2.45851763e-02f, -8.83116201e-02f, 1.02349646e-01f, 1.32497311e-01f, 3.78135294e-02f, -8.61092359e-02f,
  -8.08782876e-02f, -2.61646546e-02f, 1.05271071e-01f, -8.05044174e-02f, 2.95046829e-02f, -5.68917720e-03f, 2.87352898e-03f, -7.95701742e-02f, 7.81564042e-02f, 1.01745784e-01f,
  7.31675029e-02f, -4.67528515e-02f, -3.53568122e-02f, 1.16417073e-01f, 4.71703261e-02f, -1.03697330e-01f, -1.22209921e-01f, 5.56738824e-02f, -8.67945999e-02f, -6.93352148e-02f,
  -1.80941506e-03f, -8.87864456e-02f, 1.71877258e-02f, 2.81495266e-02f, -3.69587503e-02f, -3.42992321e-02f, -4.77624200e-02f, 8.74051154e-02f, 9.83509943e-02f, -7.94540718e-02f,
  -2.96229832e-02f, 3.00724432e-02f, -1.00521326e-01f, 1.20805353e-01f, 9.26491097e-02f, 1.10316761e-01f, -8.27736855e-02f, 9.28815827e-03f, 2.48255916e-02f, 8.94994363e-02f,
  1.03720322e-01f, -5.95660172e-02f, 7.25819096e-02f, -6.26248494e-02f, 1.96792752e-01f, -6.94025904e-02f, -1.00377589e-01f, 2.28838995e-02f, 7.98523873e-02f, 7.44642541e-02f,
  4.16771844e-02f, -4.95419502e-02f, -7.37600625e-02f, 7.53125474e-02f, -9.15895551e-02f, 6.35296926e-02f, 1.15559377e-01f, -5.00050522e-02f, 2.58445293e-02f, -3.62154245e-02f,
  2.21478380e-02f, 4.69723493e-02f, 7.66022280e-02f, 6.86075091e-02f, 8.87435898e-02f, 1.18104331e-01f, -5.65112382e-02f, 9.45046395e-02f, -2.91611850e-02f, 4.64845411e-02f,
  -2.68101618e-02f, 1.35049507e-01f, 5.34675382e-02f, -1.29849046e-01f, 1.05645761e-01f, -7.12596029e-02f, 3.66145708e-02f, -7.81219453e-02f, -1.95863266e-02f, -1.27508879e-01f,
  1.25869185e-01f, 9.53056887e-02f, 1.74887329e-02f, -8.44428036e-03f, 6.59076795e-02f, -6.90039843e-02f, 1.05776340e-01f, -1.18138179e-01f, 2.33055487e-01f, 1.96789905e-01f,
  5.09964824e-02f, 1.77413851e-01f, 7.52489939e-02f, 7.17023090e-02f, 2.08217502e-01f, 9.45967659e-02f, 5.79945445e-02f, 3.90157774e-02f, 2.50844598e-01f, -3.16651240e-02f,
  2.33403482e-02f, 2.94521898e-01f, 4.83862273e-02f, 2.21299976e-01f, 8.96356404e-02f, 4.06437404e-02f, 1.50377765e-01f, -1.02915771e-01f, 3.96548510e-02f, -5.61944675e-03f,
  4.50628214e-02f, -4.49469276e-02f, 2.13344097e-01f, -8.98343101e-02f, 8.84338766e-02f, 7.47562945e-02f, 1.63999852e-02f, -1.00157306e-01f, -1.62800521e-01f, -7.24015161e-02f,
  2.93434799e-01f, -1.29155248e-01f, 2.36028299e-01f, -1.61399618e-01f, 2.31594250e-01f, -1.49916634e-01f, 2.93335736e-01f, 1.21704742e-01f, 2.97933519e-02f, 4.00694236e-02f,
  1.07854307e-01f, -1.40099540e-01f, -2.04655066e-01f, 5.42053208e-02f, 1.10854834e-01f, 9.21119452e-02f, -2.12939635e-01f, -5.96742965e-02f, -5.41681759e-02f, 5.95413074e-02f,
  -5.16348667e-02f, 2.20139116e-01f, -1.18117392e-01f, -5.40104173e-02f, -9.09294710e-02f, 6.78483844e-02f, 9.90241319e-02f, -1.40359998e-01f, -1.52699590e-01f, -5.58444411e-02f,
  1.59620091e-01f, -5.69030084e-02f, 1.31890953e-01f, 7.33097792e-02f, -1.09232077e-02f, 6.04944304e-02f, 5.37658632e-02f, 4.46706042e-02f, 5.23739569e-02f, 1.49759099e-01f,
  -6.44929558e-02f, 1.69081897e-01f, 7.89981335e-02f, 1.01089701e-01f, 2.30840333e-02f, -4.59295437e-02f, -1.47461174e-02f, 6.57069162e-02f, 2.35448424e-02f, 1.12845637e-01f,
  -9.59953293e-03f, -1.74634323e-01f, 7.97887668e-02f, -1.04303896e-01f, -7.31889997e-03f, 9.73780900e-02f, -7.74168149e-02f, 9.94950682e-02f, -5.98019287e-02f, -8.14727172e-02f,
  -4.10154611e-02f, 1.87439620e-01f, -4.94068041e-02f, 1.21267833e-01f, -1.16053447e-01f, -7.67802000e-02f, -7.82182962e-02f, 5.70589267e-02f, -6.41283914e-02f, -2.71957349e-02f,
  7.06234500e-02f, -1.06245980e-01f, -8.05376843e-02f, 7.85334855e-02f, -9.25665796e-02f, 1.53880715e-01f, 2.27573767e-01f, -1.05136074e-02f, 2.22327486e-01f, 1.14733465e-01f,
  3.00331831e-01f, 8.20198581e-02f, 1.14709988e-01f, 2.86864996e-01f, 4.03025821e-02f, -1.53920218e-01f, -9.80728567e-02f, -2.69605946e-02f, -2.71449760e-02f, -1.53015424e-02f,
  -1.14074744e-01f, -5.33212461e-02f, 7.16904178e-02f, -9.88112688e-02f, 1.34900734e-01f, 4.65269387e-02f, 1.13772027e-01f, 9.77295637e-02f, 5.62809110e-02f, 8.48188028e-02f,
  1.11248076e-01f, 2.23181009e-01f, 7.67655596e-02f, -4.34482470e-02f, 1.19752347e-01f, 1.77695021e-01f, 1.00691959e-01f, 1.23814479e-01f, -1.10433511e-01f, 2.23761469e-01f,
  6.95989579e-02f, -1.36182113e-02f, 2.22259566e-01f, 3.68803367e-02f, 7.75817856e-02f, 2.48086855e-01f, -3.55412453e-01f, 2.74110854e-01f, -4.95036505e-02f, 7.70845413e-02f,
  -5.81910759e-02f, -9.28227231e-02f, 2.11493552e-01f, -6.09241426e-02f, 1.03330314e-02f, 1.67170599e-01f, 6.31701723e-02f, 4.07895893e-02f, -2.25677282e-01f, -2.32696384e-01f,
  1.05990842e-01f, -2.84528360e-02f, -1.54290691e-01f, 1.68477625e-01f, 1.81314666e-02f, 1.11399919e-01f, 3.75118963e-02f, -8.25597346e-03f, 5.79444654e-02f, 3.47578377e-02f,
  3.50695960e-02f, -1.28976643e-01f, 1.42986160e-02f, 9.21180192e-03f, -6.86037615e-02f, 7.70699084e-02f, 5.50945215e-02f, 4.03424464e-02f, 4.03525680e-02f, 2.49003798e-01f,
  4.44902591e-02f, 2.15189591e-01f, 7.11426437e-02f, -8.90880898e-02f, -4.64549847e-02f, -9.35038775e-02f, 1.24438792e-01f, 1.55557647e-01f, -6.71444759e-02f, -1.42160216e-02f,
  7.65049383e-02f, -1.74716488e-02f, -7.11184666e-02f, -6.22922257e-02f, 1.12847034e-02f, -4.31861095e-02f, 8.39809363e-04f, -6.81339353e-02f, 1.02695345e-03f, 2.09787376e-02f,
  -3.51796225e-02f, 7.90452026e-03f, 3.14850844e-02f, 9.71108973e-02f, -1.08439494e-02f, 1.05447101e-03f, 6.83001280e-02f, 1.39730135e-02f, -1.01602916e-02f, 1.15120441e-01f,
  5.94052188e-02f, 5.01331314e-02f, 8.91329721e-02f, 4.51098010e-03f, -6.76522106e-02f, -2.52493024e-02f, 2.16289654e-01f, 1.23480342e-01f, -1.54327482e-01f, 1.02587417e-01f,
  1.26059711e-01f, -1.03372648e-01f, -8.33499879e-02f, -1.13018095e-01f, 1.92248612e-03f, -1.05437174e-01f, 1.16353370e-01f, -7.34781325e-02f, 1.64023921e-01f, 1.95639536e-01f,
  -4.93541360e-02f, 1.18649654e-01f, 9.58464593e-02f, 3.02605480e-02f, 1.07727215e-01f, -7.40562603e-02f, 4.85893823e-02f, -5.92689142e-02f, -4.67618741e-02f, 1.20174207e-01f,
  2.94907950e-02f, 1.91498518e-01f, 7.12931603e-02f, 1.23149030e-01f, 2.78127976e-02f, 1.05034634e-01f, -5.74952550e-02f, -8.76755789e-02f, 2.93454695e-02f, -5.93089163e-02f,
  -8.80527794e-02f, -9.46102068e-02f, 6.90436810e-02f, -4.11157124e-02f, 7.74904294e-03f, 6.59585819e-02f, 6.50322735e-02f, 1.69754982e-01f, 2.15513974e-01f, 3.07076514e-01f,
  8.90267864e-02f, 1.82838991e-01f, 2.18209282e-01f, 1.53275251e-01f, 9.85674262e-02f, 9.59911868e-02f, 2.48872280e-01f, 2.71858513e-01f, -3.23732421e-02f, 1.00779012e-01f,
  2.13293672e-01f, 2.91399479e-01f, 5.28171510e-02f, 1.06277652e-01f, -1.84981421e-01f, -6.68467358e-02f, 2.41012812e-01f, 1.43785506e-01f, -3.14943552e-01f, 1.29533961e-01f,
  -3.65835398e-01f, 4.57212105e-02f, 1.52438059e-01f, -2.01769769e-01f, 4.09378819e-02f, -1.10061970e-02f, -3.49668890e-01f, 1.70806125e-01f, -4.41057861e-01f, 1.67669788e-01f,
  2.93742009e-02f, 1.55420944e-01f, -3.00599724e-01f, -2.74426043e-01f, 1.02207273e-01f, 1.93881355e-02f, 5.02102636e-02f, 4.34479240e-04f, 2.61885077e-01f, 2.14854717e-01f,
  1.38018131e-01f, -5.22352802e-03f, 2.50807106e-01f, 9.79290307e-02f, -1.14035875e-01f, 1.10199660e-01f, 9.57034063e-03f, -2.03225404e-01f, 2.30765030e-01f, 9.30587575e-02f,
  3.69283892e-02f, 2.01880530e-01f, -7.83964619e-02f, 8.11163634e-02f, -7.43231401e-02f, -2.45309565e-02f, -1.83387734e-02f, -1.46605251e-02f, -7.55819827e-02f, 7.15076774e-02f,
  -3.86612937e-02f, 8.85582194e-02f, 3.94798778e-02f, 1.59064770e-01f, 3.54330093e-02f, 7.76556805e-02f, 5.68724051e-03f, -7.59104937e-02f, 4.94393185e-02f, 7.25266263e-02f,
  -1.24028018e-02f, 8.00571889e-02f, 4.13942374e-02f, -6.07595928e-02f, 4.08537760e-02f, -2.34325193e-02f, 1.03416272e-01f, -1.81167573e-01f, 2.05884110e-02f, 1.63949206e-01f,
  -1.77927718e-01f, 3.20297703e-02f, -6.85362378e-03f, 1.42091036e-01f, 2.78412849e-02f, -7.78825060e-02f, 1.67177200e-01f, 2.09917918e-01f, -8.25989619e-02f, -8.27082843e-02f,
  3.95579524e-02f, -1.84949830e-01f, -4.13997211e-02f, 8.18661749e-02f, -8.47666711e-02f, 1.00123845e-01f, 6.87905923e-02f, 3.89661305e-02f, -3.28470357e-02f, 1.05304129e-01f,
  6.75547570e-02f, -1.06604099e-01f, -1.06905885e-01f, 6.46007955e-02f, 7.88063854e-02f, -1.09815985e-01f, -1.67481765e-01f, 1.46222413e-01f, 1.32101104e-01f, 7.51214921e-02f,
  1.27932020e-02f, 1.70090780e-01f, 5.36975563e-02f, 1.62348915e-02f, 1.00106344e-01f, 3.18335257e-02f, 3.40636298e-02f, 6.83042780e-02f, -5.84378503e-02f, -4.36015278e-02f,
  8.85901377e-02f, -7.28568807e-02f, 7.68420845e-02f, -8.70364625e-03f, -8.04135278e-02f, 7.74823874e-02f, 7.07435980e-02f, 8.89677480e-02f, 5.69041371e-02f, 9.05165635e-03f,
  -1.41948126e-02f, -5.22886328e-02f, -7.64671266e-02f, 1.18799180e-01f, -4.53671589e-02f, -1.03344120e-01f, 1.01897821e-01f, -7.51290247e-02f, -3.54839750e-02f, -7.25694597e-02f,
  1.73020922e-02f, 1.24411033e-02f, 8.53367746e-02f, -6.57463297e-02f, 1.40617877e-01f, 8.20811838e-03f, 2.76069343e-02f, -3.10917664e-03f, -4.53989357e-02f, 5.06477132e-02f,
  1.31062821e-01f, -1.25084728e-01f, -3.08987871e-02f, -9.77403522e-02f, 6.49215654e-02f, 1.41269401e-01f, -6.09857999e-02f, 9.50777456e-02f, 9.64485332e-02f, -7.50573128e-02f,
  -9.01347026e-02f, -5.57799451e-02f, -1.62818860e-02f, -2.27449462e-02f, -1.32971853e-02f, -9.24957823e-03f, 1.16040863e-01f, 3.67669985e-02f, 1.73894484e-02f, -7.94655904e-02f,
  -3.56254615e-02f, 8.74304771e-02f, -3.56160966e-03f, -1.47803307e-01f, 1.72777660e-02f, 3.85258980e-02f, 1.20307185e-01f, 6.36039451e-02f, -1.06070355e-01f, 1.50880039e-01f,
  -2.15836391e-02f, 8.96695331e-02f, -4.31748020e-04f, -5.35845645e-02f, -2.11082604e-02f, 1.18291549e-01f, 6.74851686e-02f, 1.64770093e-02f, -5.74310645e-02f, 6.90725967e-02f,
  6.71307743e-03f, -1.07042231e-01f, -9.85618830e-02f, -1.16683461e-01f, 7.22776875e-02f, 9.57520828e-02f, -3.05021182e-02f, -5.67271747e-02f, 6.89502954e-02f, 7.26653412e-02f,
  1.25026718e-01f, -1.11050062e-01f, 1.27702415e-01f, -1.19095005e-01f, -2.24784687e-02f, 6.02677986e-02f, -1.27181977e-01f, 1.30778864e-01f, -2.71138698e-02f, -4.46552187e-02f,
  -1.06308728e-01f, 3.52850370e-02f, 1.37040894e-02f, -1.11474775e-01f, 1.67990047e-02f, 5.22151925e-02f, 3.48667838e-02f, 5.23633249e-02f, -4.48411331e-02f, 9.87293571e-03f,
  1.33354157e-01f, 7.80849084e-02f, -7.05995187e-02f, -4.89820577e-02f, -1.66900810e-02f, -1.04812561e-02f, -6.91465363e-02f, -1.11274064e-01f, 6.85213804e-02f, 1.73472371e-02f,
  8.46253037e-02f, -2.65859324e-03f, -1.83729585e-02f, -1.10528126e-01f, -8.14198554e-02f, 3.03563476e-02f, -1.16710842e-01f, 1.81691823e-04f, -1.52056189e-02f, -2.76873540e-02f,
  -2.72798557e-02f, -7.27335364e-02f, 5.85203134e-02f, 9.25382748e-02f, 1.35655820e-01f, 5.93642890e-03f, -2.82507925e-03f, -3.72351408e-02f, 6.66442141e-02f, 2.63506118e-02f,
  1.02444589e-01f, -1.03510126e-01f, 1.23875231e-01f, -6.47820458e-02f, 2.54238490e-02f, 9.62085053e-02f, 1.66700587e-01f, 1.18230477e-01f, -1.59471836e-02f, -5.80240712e-02f,
  -8.37280676e-02f, -3.69173102e-03f, 1.36976019e-01f, -1.22173607e-01f, -1.38598859e-01f, 6.73219338e-02f, -5.34632467e-02f, -4.12359927e-03f, -4.21294346e-02f, 7.30226338e-02f,
  7.42923096e-02f, -1.47877913e-02f, -2.18209624e-02f, -8.36097747e-02f, 1.12716835e-02f, 1.16234310e-01f, -3.48680206e-02f, 1.34093747e-01f, 4.40340638e-02f, -1.54115006e-01f,
  7.49087483e-02f, -8.11601356e-02f, 1.47778004e-01f, 1.38257593e-01f, -1.59437452e-02f, -1.37142599e-01f, 6.67770877e-02f, 4.84082336e-03f, 1.99606523e-01f, 2.52904333e-02f,
  4.63811122e-02f, 7.47946799e-02f, -5.95619529e-02f, 5.73878037e-03f, 8.32826272e-02f, 8.91194642e-02f, 1.23945154e-01f, -7.95423388e-02f, -1.40340954e-01f, -5.27949296e-02f,
  1.65194348e-01f, 8.57538953e-02f, 5.09620383e-02f, 1.63937584e-01f, -4.63958755e-02f, -1.39723554e-01f, 2.86122616e-02f, 2.59010457e-02f, -6.06728066e-03f, 1.70814633e-01f,
  1.12668350e-02f, 7.94240683e-02f, -6.15895912e-02f, 1.51719958e-01f, 4.06833142e-02f, 8.46179351e-02f, 1.44186646e-01f, -1.44216400e-02f, 1.89579912e-02f, -1.01186916e-01f,
  5.56475110e-02f, 2.74086446e-02f, 7.00576752e-02f, -6.21215366e-02f, -1.09966233e-01f, 3.91142219e-02f, 1.09780366e-02f, -1.36949182e-01f, -9.04708728e-02f, 1.16141252e-01f,
  5.41641936e-02f, -6.65346012e-02f, 1.41213715e-01f, -7.38469958e-02f, 1.61331177e-01f, -1.55412778e-01f, -1.35787670e-02f, -1.76884413e-01f, 1.83182895e-01f, 1.34019837e-01f,
  -1.60123780e-02f, -1.91414967e-01f, 6.27194792e-02f, -1.51536644e-01f, -1.76967844e-01f, -1.28330439e-01f, 1.56138092e-01f, 9.59166288e-02f, -2.64592678e-03f, 9.68961790e-03f,
  2.58701909e-02f, 1.86382905e-02f, 1.34131059e-01f, 2.10765243e-01f, 1.90877333e-01f, 4.75689210e-02f, -1.22582145e-01f, 9.44044366e-02f, -1.13009606e-02f, 2.71517299e-02f,
  -1.18152812e-01f, 1.85135245e-01f, 8.97871703e-03f, 4.16118801e-02f, 1.46332785e-01f, -2.07543653e-02f, -6.48144484e-02f, 2.83894148e-02f, -4.99440543e-02f, -1.61305934e-01f,
  -1.08287834e-01f, 1.04038671e-01f, 2.22795248e-01f, 1.65804282e-01f, 1.22031085e-01f, 7.41398335e-02f, -3.92464027e-02f, 2.13659644e-01f, 4.38417159e-02f, 2.86910683e-02f,
  -3.07345092e-02f, -7.33920038e-02f, 8.98548663e-02f, -2.20053140e-02f, -7.49076232e-02f, 9.42597613e-02f, -7.22358376e-02f, -8.60760920e-04f, 1.19752355e-01f, 1.30903125e-01f,
  -3.66767496e-02f, 5.93273453e-02f, -9.27824080e-02f, 1.36479884e-01f, -1.28902066e-02f, 4.04638760e-02f, -1.02253407e-01f, 1.53840020e-01f, -6.26461953e-02f, 1.60672858e-01f,
  -9.88840126e-03f, 5.95757924e-02f, -5.66946268e-02f, -1.26521096e-01f, 5.49953082e-04f, -2.42478251e-02f, 1.86794009e-02f, -1.26943400e-03f, -1.01138644e-01f, 4.98979390e-02f,
  -7.92600736e-02f, 1.14011712e-01f, -1.41162006e-02f, -1.02457874e-01f, 3.59703191e-02f, 4.47235070e-02f, -2.27550194e-02f, -1.15896039e-01f, 2.15311442e-02f, -8.10914580e-03f,
  3.82971354e-02f, -2.70612296e-02f, 1.83754414e-01f, -8.57754052e-02f, -2.26041880e-02f, 1.87791288e-02f, 9.20644104e-02f, -9.13065225e-02f, 7.88163021e-02f, 4.02676947e-02f,
  -2.81634871e-02f, 8.74157846e-02f, 1.38970375e-01f, -1.17993010e-02f, 1.09399267e-01f, 1.10953040e-01f, -1.12245776e-01f, 8.75486434e-02f, -2.60061398e-03f, -6.57684729e-02f,
  -1.08953297e-01f, 7.94854313e-02f, 1.42974421e-01f, 2.65694633e-02f, 1.36676803e-01f, 2.00099498e-02f, 1.01996906e-01f, 1.27484296e-02f, 2.75404286e-02f, -5.50386906e-02f,
  9.32371244e-02f, 3.94382067e-02f, 1.70911968e-01f, -3.67683209e-02f, 1.37759671e-01f, -2.49073133e-02f, -8.42539519e-02f, 3.99133116e-02f, 6.91057965e-02f, -1.22451313e-01f,
  -1.54210776e-02f, 1.37571007e-01f, 1.50699755e-02f, 6.40983060e-02f, 1.77438557e-02f, -1.29135683e-01f, -6.14274666e-02f, -1.14804022e-01f, 1.45202056e-01f, 4.40094583e-02f,
  -5.39571010e-02f, 4.67612147e-02f, -1.93102628e-01f, 6.77857101e-02f, 1.74512371e-01f, -1.92373142e-01f, 1.22755863e-01f, -4.13165614e-02f, 1.26670226e-01f, 1.58770859e-01f,
  2.95061041e-02f, 1.12816609e-01f, -9.20686573e-02f, 1.08661689e-01f, 3.70257907e-02f, 7.87269324e-02f, -1.12468284e-02f, -1.17604963e-01f, -3.75729762e-02f, -8.72188359e-02f,
  -1.11359589e-01f, 4.05954663e-03f, 3.58650945e-02f, -3.40330154e-02f, -8.78883898e-02f, 1.75842658e-01f, 7.70790353e-02f, 1.39490843e-01f, -1.77846402e-02f, -1.04178295e-01f,
  4.29553241e-02f, 6.64564297e-02f, -7.20193461e-02f, 8.39213468e-03f, 1.59002349e-01f, -1.01108238e-01f, -5.53171784e-02f, -9.74586010e-02f, -6.37404323e-02f, 2.46648658e-02f,
  1.41915698e-02f, 3.24313575e-03f, 6.34940565e-02f, 1.01527162e-02f, 1.27799094e-01f, 1.16158798e-01f, 1.27473772e-01f, 1.22347042e-01f, 4.91995178e-02f, -1.02403693e-01f,
  -1.03091761e-01f, -6.51102280e-03f, -6.25889897e-02f, 9.73136052e-02f, 9.64119285e-02f, 1.02299124e-01f, 4.71208952e-02f, -9.30123404e-02f, 3.90706360e-02f, -9.49733630e-02f,
  6.60279170e-02f, 7.23504499e-02f, 7.54296258e-02f, -3.24541405e-02f, -7.94295520e-02f, 3.16684321e-02f, 1.17358439e-01f, -1.62574187e-01f, 1.39249340e-01f, 9.01915208e-02f,
  2.25718245e-02f, 7.87246451e-02f, 3.47785428e-02f, 6.55300617e-02f, 1.23995118e-01f, 6.41492829e-02f, 1.49652913e-01f, 3.53227779e-02f, 7.10231140e-02f, 1.11735761e-01f,
  -1.11039720e-01f, -4.37645316e-02f, 6.66292086e-02f, -1.80627555e-02f, -2.38548517e-02f, 1.99596919e-02f, 1.46937162e-01f, 2.35607568e-02f, 7.42810732e-03f, 1.18482329e-01f,
  7.12570325e-02f, -9.97724943e-03f, -4.60101366e-02f, -1.51991442e-01f, 1.38489231e-01f, 1.16465472e-01f, -8.77490863e-02f, -2.06918921e-02f, 6.00723829e-03f, -5.98866418e-02f,
  -4.05465923e-02f, 1.15021124e-01f, 5.85600920e-02f, 3.29908431e-02f, -1.08381048e-01f, 1.41753200e-02f, 7.69378468e-02f, 6.31218851e-02f, 7.66612217e-02f, -6.94872588e-02f,
  -8.34550634e-02f, -3.73704801e-03f, 5.08509064e-03f, -7.50441477e-02f, -1.54663146e-01f, 8.79408047e-02f, -7.87564442e-02f, -4.15500663e-02f, 4.85252626e-02f, -1.04601234e-01f,
  -9.27842706e-02f, 1.19285256e-01f, -1.10855103e-01f, -7.59105524e-03f, 6.18768483e-02f, 1.83853880e-02f, 9.97322705e-03f, -5.84814660e-02f, 1.36346249e-02f, 5.15768193e-02f,
  -2.96072923e-02f, 1.45106316e-01f, 6.77326024e-02f, -9.74082872e-02f, -6.93007782e-02f, -5.62113151e-03f, -6.03833944e-02f, -5.73210046e-02f, 1.07121572e-01f, 1.29971623e-01f,
  -6.87333271e-02f, 1.17083810e-01f, -1.18583634e-01f, -8.70292336e-02f, 5.73205277e-02f, -1.26210317e-01f, -7.96263572e-03f, -6.98996037e-02f, 4.20017019e-02f, 5.54475412e-02f,
  -1.05386093e-01f, 5.73263690e-02f, 4.38897386e-02f, -7.14163035e-02f, 3.76852602e-02f, 5.81644922e-02f, -8.90197381e-02f, -1.29314303e-01f, -1.75966080e-02f, -1.02116786e-01f,
  1.21311784e-01f, -1.08443528e-01f, -9.15229321e-02f, -3.03544756e-03f, 1.23655327e-01f, 9.43006948e-02f, 7.39402696e-02f, 9.16859955e-02f, 9.66144949e-02f, 1.16974354e-01f,
  1.74397022e-01f, 7.99562782e-03f, -1.36710107e-01f, -9.34712663e-02f, 6.38207868e-02f, 1.80274323e-01f, 5.33616208e-02f, 2.20972821e-02f, -2.60581493e-01f, -3.82569060e-02f,
  9.35294405e-02f, 2.41390646e-01f, -2.28556603e-01f, -3.60417478e-02f, -1.14741594e-01f, 1.96685106e-01f, -1.15709051e-01f, 2.20713004e-01f, -1.14934996e-01f, -1.53531432e-01f,
  -2.45139394e-02f, 2.86316544e-01f, -1.79138511e-01f, 9.54534039e-02f, 1.33929059e-01f, 8.88407379e-02f, -1.25287011e-01f, 4.92219515e-02f, -2.17093587e-01f, 1.09303631e-01f,
  -1.11685768e-01f, -3.65469269e-02f, 1.00758165e-01f, -6.68432638e-02f, 2.07970247e-01f, 3.25678997e-02f, 2.36633662e-02f, 1.32473052e-01f, 1.09155238e-01f, 1.32876977e-01f,
  9.93975550e-02f, 2.04705834e-01f, 3.27923864e-01f, 1.04962930e-01f, 3.03964972e-01f, 1.54065698e-01f, -2.66962908e-02f, -1.23001218e-01f, 2.42625117e-01f, -1.45609185e-01f,
  -1.11924767e-01f, -1.12062320e-01f, 3.55647597e-03f, 1.00168027e-01f, 1.82351589e-01f, 1.29499882e-01f, -5.13230413e-02f, 8.87378305e-03f, -6.68502972e-02f, -9.05348659e-02f,
  -4.91600186e-02f, 2.39922851e-01f, 2.15153158e-01f, 1.35440320e-01f, -4.15740982e-02f, 9.67192575e-02f, 5.23818657e-02f, 1.33135542e-01f, 8.33018422e-02f, 1.85711179e-02f,
  1.26656041e-01f, 7.07612410e-02f, 7.15905651e-02f, 5.59637174e-02f, 3.41031980e-03f, 2.09011167e-01f, 4.15089130e-02f, 3.37442666e-01f, -1.73996031e-01f, 1.56581238e-01f,
  5.21246865e-02f, -8.09328556e-02f, 1.01983137e-01f, -1.09305747e-01f, -1.76601075e-02f, 1.08494170e-01f, -8.14530998e-02f, -8.58328268e-02f, 1.48918256e-01f, 8.32244009e-03f,
  -1.33597493e-01f, 1.00836672e-01f, 4.31837291e-02f, 1.37490690e-01f, 1.73399597e-01f, 2.76906908e-01f, 6.92585334e-02f, 8.65185708e-02f, 9.94009897e-02f, 3.92510630e-02f,
  -5.97162656e-02f, -4.36895974e-02f, -8.05689320e-02f, -1.68944951e-02f, 1.61439478e-02f, 9.25881937e-02f, -1.18744351e-01f, -3.78605984e-02f, -8.36013183e-02f, -1.80190772e-01f,
  -1.13016285e-01f, 9.23047587e-02f, 1.56194016e-01f, 4.45403792e-02f, -1.11583516e-01f, 6.59872293e-02f, 3.15764509e-02f, 1.66155830e-01f, -1.24425068e-01f, -6.34841323e-02f,
  4.18455061e-03f, -1.02649324e-01f, 3.92515510e-02f, 8.71895030e-02f, -4.31798249e-02f, 9.21922997e-02f, 1.89435035e-01f, -2.95628868e-02f, -3.98296528e-02f, 1.94936097e-01f,
  1.66720599e-01f, 8.75317380e-02f, -7.07768053e-02f, 1.52055295e-02f, 1.92418352e-01f, 1.89849809e-02f, 3.83152589e-02f, 3.57439592e-02f, -4.73942123e-02f, -2.13267561e-02f,
  5.15481457e-02f, -3.86968851e-02f, 1.60963193e-01f, -1.29884750e-01f, -4.07212786e-02f, 1.07955225e-01f, 2.80123018e-03f, 8.31451192e-02f, -5.73847704e-02f, -9.72089991e-02f,
  1.56941563e-01f, -9.04990807e-02f, -5.81111684e-02f, 4.85675083e-03f, -4.33311425e-02f, 1.02817275e-01f, 9.78422537e-02f, -1.29881024e-01f, -1.58348516e-01f, 1.27838984e-01f,
  -1.48832813e-01f, -1.01312906e-01f, 1.31793678e-01f, 1.53873846e-01f, -2.49393135e-02f, 2.61819437e-02f, -2.67860899e-03f, 1.19165136e-02f, 3.52883851e-03f, 1.70689613e-01f,
  -2.83379760e-02f, 1.84577610e-02f, 8.89617279e-02f, 1.18772008e-01f, 1.25998035e-01f, 3.48223560e-02f, -9.63531584e-02f, 6.55404851e-02f, 9.27433744e-02f, -1.34642636e-02f,
  1.37151361e-01f, -8.14937502e-02f, -4.89651114e-02f, -4.27440107e-02f, 5.12961335e-02f, 8.77429470e-02f, 1.17489435e-01f, 7.20640421e-02f, 1.04205303e-01f, 1.12386853e-01f,
  8.56973007e-02f, 2.42248520e-01f, 1.68661833e-01f, 2.68152028e-01f, 2.42538676e-01f, 1.14351794e-01f, 4.86609004e-02f, -9.30365454e-03f, -5.61218942e-03f, 1.18530296e-01f,
  2.89735973e-01f, 8.98292512e-02f, 6.90272748e-02f, 4.54387441e-02f, 2.98010439e-01f, -1.18429363e-02f, 7.54903331e-02f, -2.06828043e-01f, 1.95947830e-02f, 2.60579982e-03f,
  -1.28787428e-01f, 1.50636971e-01f, -1.02799557e-01f, -2.63783008e-01f, 4.57115062e-02f, 6.53807074e-02f, -7.53474385e-02f, 4.60748449e-02f, 6.94958493e-02f, 7.42096975e-02f,
  5.94107956e-02f, 6.73329160e-02f, -1.23134712e-02f, -1.30538508e-01f, -3.27092633e-02f, -1.65932685e-01f, -9.38427076e-02f, -4.26101126e-03f, 5.94984218e-02f, -5.45637384e-02f,
  7.62493089e-02f, -6.57745078e-02f, 1.09840833e-01f, -7.76079893e-02f, 3.85154895e-02f, -7.77305961e-02f, -1.35056928e-01f, 3.15730348e-02f, 2.21215725e-01f, 4.97403890e-02f,
  7.26510212e-02f, 1.20560795e-01f, -5.97108640e-02f, 1.76273033e-01f, 1.04117870e-01f, -1.49345234e-01f, -1.44974172e-01f, -7.46179791e-03f, 1.16358273e-01f, -5.80641702e-02f,
  3.50944959e-02f, 9.95899290e-02f, 1.61340520e-01f, 1.37978151e-01f, 1.21599853e-01f, 1.18429856e-02f, 1.83332097e-02f, -2.94940658e-02f, -6.89415308e-03f, 1.66738957e-01f,
  4.63109910e-02f, 6.60925657e-02f, 9.41709727e-02f, -7.29036564e-03f, 9.58333984e-02f, 1.34573743e-01f, 4.38112020e-02f, 2.24983901e-01f, -5.58769517e-02f, -1.77172512e-01f,
  -1.73959555e-03f, -1.49591371e-01f, 4.32049073e-02f, 2.89764374e-01f, -4.98790108e-02f, -3.40824574e-03f, -1.86837316e-01f, 2.18705192e-01f, -2.15429589e-01f, 1.82245985e-01f,
  1.85727477e-01f, -1.00117020e-01f, -5.06006181e-02f, -7.51264766e-03f, -1.25955954e-01f, 2.71794479e-02f, 7.99260382e-03f, -2.13462859e-01f, -5.68290651e-02f, -5.94014712e-02f,
  2.52703503e-02f, -1.10132612e-01f, 1.02797188e-01f, 1.37936935e-01f, -2.32635159e-02f, -5.99045195e-02f, 2.32694238e-01f, -9.29386448e-03f, 2.66069770e-01f, 2.23300129e-01f,
  1.29318103e-01f, 3.33057523e-01f, -1.21417984e-01f, -1.56281173e-01f, -2.20490936e-02f, 1.31170437e-01f, 1.51143000e-01f, -1.33157328e-01f, -1.55002624e-01f, -9.34407786e-02f,
  1.16555700e-02f, 1.89567924e-01f, 1.28962249e-01f, 1.34755149e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -4.65789661e-02f, 3.35028465e-03f, 8.35574046e-02f, 1.59229577e-01f, 9.17320848e-02f, -6.28331229e-02f, 2.03668401e-02f, 1.35555074e-01f, 1.53288636e-02f, 2.12725639e-01f,
  1.28153667e-01f, 7.08981678e-02f, 1.44380510e-01f, 5.94861023e-02f, 9.00298078e-03f, 9.02027190e-02f, 1.10611603e-01f, 2.45535504e-02f, 1.43183887e-01f, -8.33054930e-02f,
  -2.43103020e-02f, -3.27804275e-02f, 1.61647230e-01f, 1.86559409e-02f, 1.69793114e-01f, 1.28364801e-01f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.18562937e-01f, 6.12641312e-02f, -9.72441733e-02f, 1.10039331e-01f, -2.32475586e-02f, -4.16273475e-02f, -7.48073608e-02f, -1.84866697e-01f, 2.76930854e-02f, -1.78355426e-01f,
  -6.21171035e-02f, 1.54170454e-01f, -3.67439091e-02f, -2.47483611e-01f, 4.33002636e-02f, -1.65738285e-01f, 1.28462523e-01f, 9.66925919e-02f, -5.84495813e-02f, 7.79878572e-02f,
  -6.07503876e-02f, 1.79858893e-01f, 9.63970944e-02f, -7.73316026e-02f, 2.53496021e-01f, -2.82684535e-01f, -1.39609784e-01f, 5.73158637e-02f, -1.84062019e-01f, -9.69708934e-02f,
  -2.52690949e-02f, 1.57390788e-01f, 2.60938723e-02f, -8.96812826e-02f, 4.22329642e-02f, 9.17446464e-02f, 2.30214342e-01f, 2.05085814e-01f, -6.18938394e-02f, -4.19551134e-02f,
  -8.30960497e-02f, -1.19959205e-01f, 3.05288017e-01f, -5.11907190e-02f, -8.90767202e-02f, -1.58933952e-01f, -3.12719531e-02f, -1.46737754e-01f, -7.00209811e-02f, 2.25874007e-01f,
  1.90561086e-01f, 1.68960795e-01f, -2.94203479e-02f, 4.79386337e-02f, 1.55481532e-01f, -2.74105947e-02f, -1.38704538e-01f, 1.35666028e-01f, 3.90848555e-02f, 3.16836387e-02f,
  6.56356737e-02f, 1.32073745e-01f, -1.11143798e-01f, -1.16358697e-01f, -4.91791107e-02f, 4.50805016e-02f, 2.19817571e-02f, -1.28267378e-01f, -8.33763033e-02f, 1.18804350e-01f,
  1.76858038e-01f, 6.50955662e-02f, -8.30182508e-02f, 1.14838287e-01f, 1.14234656e-01f, -3.34375463e-02f, 9.10642464e-03f, -2.02726964e-02f, 1.13654479e-01f, -4.91263643e-02f,
  -1.43586043e-02f, -4.88758422e-02f, -6.54102489e-02f, 2.06500247e-01f, 1.65167093e-01f, -1.53072283e-01f, -1.83891222e-01f, 9.76645425e-02f, -2.41592079e-01f, 1.40571758e-01f,
  4.94158566e-02f, -8.61066952e-03f, 2.36542270e-01f, 1.64995119e-02f, -1.73905566e-01f, -1.37343630e-01f, 9.45131406e-02f, 7.78383762e-02f, 1.25027597e-01f, -7.17682019e-02f,
  1.19980782e-01f, -1.19295128e-01f, 1.06216252e-01f, -4.92427088e-02f, -1.54931456e-01f, 6.86455220e-02f, 7.26509690e-02f, 1.29078001e-01f, -1.81546763e-01f, 1.15299292e-01f,
  -2.56035388e-01f, 2.40051731e-01f, 2.81867646e-02f, -1.10582910e-01f, 1.05663344e-01f, -1.46257371e-01f, 7.15123340e-02f, -4.48588990e-02f, -2.35651597e-01f, -4.62515168e-02f,
  -7.86878094e-02f, 3.43129821e-02f, -5.39559536e-02f, -1.04306139e-01f, 8.74361247e-02f, -1.39054388e-01f, -1.49187101e-02f, 3.49249169e-02f, -2.06491023e-01f, 1.38174117e-01f,
  -9.58739072e-02f, 6.32355213e-02f, -6.63124770e-02f, -1.49020314e-01f, -1.53408244e-01f, -1.00521632e-01f, -2.03527004e-01f, -4.27511111e-02f, 3.67351808e-02f, -2.03755330e-02f,
  -1.00188620e-01f, -1.98651060e-01f, -7.78310969e-02f, 7.75508285e-02f, 8.31894428e-02f, 5.00320755e-02f, 6.70480505e-02f, -6.05788864e-02f, -3.86059284e-02f, 8.10570270e-02f,
  1.38029650e-01f, -3.00292492e-01f, 2.09694594e-01f, -9.22609493e-02f, -8.45129788e-02f, -2.06732880e-02f, 8.87877271e-02f, -5.90811484e-02f, -5.36803827e-02f, 6.10025739e-03f,
  -2.22053111e-01f, -3.35939564e-02f, -1.05071098e-01f, -2.87991222e-02f, 1.25712395e-01f, 4.03838493e-02f, 4.29912619e-02f, 1.52021244e-01f, -8.97257254e-02f, -1.96269453e-02f,
  6.73723966e-02f, -9.84236822e-02f, 1.43798999e-03f, 2.14363888e-01f, -1.19728610e-01f, -3.42421606e-02f, 1.47523293e-02f, -3.35826218e-01f, 1.32019892e-01f, 1.35372519e-01f,
  5.14887609e-02f, -3.20192091e-02f, 1.74186513e-01f, -2.18957122e-02f, -4.78063971e-02f, 3.15346308e-02f, 1.24085866e-01f, 4.54868015e-04f, 5.42162731e-02f, 1.31771669e-01f,
  -3.86129171e-02f, -2.31820866e-01f, 1.21277437e-01f, 1.40496790e-01f, 1.27401233e-01f, -3.63710970e-02f, -8.88071433e-02f, 1.36262834e-01f, -6.00977987e-02f, 5.62356375e-02f,
  1.40784398e-01f, 1.21300884e-01f, -4.31832895e-02f, 1.12068415e-01f, -1.52451396e-01f, 2.33553678e-01f, 1.12603709e-01f, 3.29341531e-01f, -1.61179379e-01f, -9.56188515e-02f,
  1.13564715e-01f, -1.44345507e-01f, 1.30485818e-01f, -1.39169857e-01f, -5.82616813e-02f, 1.07202325e-02f, -9.98388454e-02f, -2.05802396e-02f, 1.51402429e-02f, -1.03173867e-01f,
  1.90803617e-01f, 1.30873367e-01f, -1.45847023e-01f, -1.74915846e-02f, 1.24796532e-01f, 1.62490472e-01f, 1.40742898e-01f, -6.10450143e-03f, 5.13960533e-02f, 4.09533158e-02f,
  2.83999275e-02f, -5.39513454e-02f, 1.31825924e-01f, 1.11208566e-01f, -2.22165465e-01f, 1.19628400e-01f, 8.22101980e-02f, 2.81020045e-01f, 5.04789576e-02f, -1.11783028e-01f,
  5.22106737e-02f, -2.34232485e-01f, -6.51989877e-02f, 4.36512381e-02f, -7.93864485e-03f, 4.93659377e-02f, 1.20481431e-01f, -4.64090481e-02f, 1.75388262e-01f, 9.48005691e-02f,
  -1.61531754e-02f, -2.47905508e-01f, -1.47435293e-01f, -2.36731470e-02f, 1.06907286e-01f, -2.22253576e-02f, -4.91914758e-03f, -4.84763272e-02f, 9.89998206e-02f, -9.43131596e-02f,
  -8.01720947e-04f, -4.57854643e-02f, -1.36580747e-02f, 8.48935265e-03f, -5.38622960e-02f, -5.24661988e-02f, 1.14255428e-01f, -1.45396814e-02f, -7.65950158e-02f, -3.19736600e-02f,
  4.85049374e-02f, -1.29835188e-01f, -2.94707119e-02f, -6.78070858e-02f, 3.91090214e-02f, 2.06596836e-01f, 2.20099315e-01f, 9.16425698e-03f, -1.99372217e-01f, 3.05011958e-01f,
  -1.16436765e-01f, 8.65094587e-02f, -8.21928456e-02f, 1.54037148e-01f, 1.30591867e-02f, -8.85791406e-02f, -1.46923050e-01f, -1.46568809e-02f, 2.43037194e-01f, 8.19965545e-03f,
  1.92355230e-01f, 9.99232978e-02f, -8.90649110e-02f, -4.92572831e-03f, 1.26905486e-01f, 4.92344871e-02f, -2.91743517e-01f, -1.04609141e-02f, 2.22817495e-01f, 6.65167421e-02f,
  -1.40331045e-01f, -1.37925923e-01f, -1.84990183e-01f, 1.85996577e-01f, -1.24272630e-01f, 1.03272714e-01f, -1.11079939e-01f, -9.96796340e-02f, -9.77692828e-02f, 6.16966262e-02f,
  -3.19923162e-02f, 1.57137036e-01f, 1.20443970e-01f, -3.52558680e-02f, 6.54695556e-02f, 1.84654966e-01f, 1.59594819e-01f, 7.51478747e-02f, -1.53400213e-01f, -7.93330297e-02f,
  -4.73484509e-02f, -7.16567263e-02f, 5.30642718e-02f, 1.12240147e-02f, 4.23285179e-02f, -9.99860652e-03f, 2.99008153e-02f, -2.57100333e-02f, -8.70405361e-02f, -1.71077758e-01f,
  -1.23597950e-01f, 4.51399907e-02f, 9.90874022e-02f, 9.19058248e-02f, 6.39510751e-02f, -9.44036841e-02f, 2.68429946e-02f, 7.52160847e-02f, -3.79213095e-02f, 2.73859352e-01f,
  4.90453057e-02f, -3.43775600e-02f, -7.25832805e-02f, 1.54424980e-01f, -2.49587208e-01f, 5.97139411e-02f, 1.30162001e-01f, -1.25184998e-01f, -1.98595095e-02f, 1.03125513e-01f,
  1.17795505e-01f, 2.33025942e-02f, -7.27237463e-02f, 2.08832279e-01f, -1.49802372e-01f, -9.98302624e-02f, -4.01250608e-02f, -1.04221568e-01f, -1.16100609e-02f, -5.68266064e-02f,
  -2.09612795e-03f, 1.64454311e-01f, -1.78460240e-01f, -1.88622568e-02f, 7.60061517e-02f, -1.97760403e-01f, 2.73239240e-03f, -6.62157545e-03f, -3.75115424e-02f, 1.98156163e-01f,
  9.45779588e-03f, -4.70315479e-02f, -1.09178990e-01f, 7.20255263e-03f, -1.85952514e-01f, 1.40259191e-01f, 2.97460728e-03f, -1.44550771e-01f, 8.52754340e-02f, 2.60472119e-01f,
  -7.64418691e-02f, -5.01187444e-02f, 3.18673905e-03f, 2.89009750e-01f, -3.67029905e-02f, -4.75434847e-02f, -7.56586567e-02f, 2.06677187e-02f, -1.09648947e-02f, -1.68927889e-02f,
  1.06485799e-01f, -2.04380155e-02f, -3.97678986e-02f, -1.38956279e-01f, -7.74056539e-02f, -1.62581354e-02f, 1.19172901e-01f, -3.27901766e-02f, -2.03928556e-02f, 4.36528251e-02f,
  8.26535374e-02f, -9.37941857e-03f, 2.96956450e-02f, -1.79569975e-01f, -1.57810971e-01f, 2.09120750e-01f, 1.69602364e-01f, -9.33581442e-02f, 2.47834139e-02f, -2.45312214e-01f,
  -1.16256818e-01f, -8.68023485e-02f, -2.51744300e-01f, -1.21801250e-01f, 1.14162058e-01f, 4.47490737e-02f, -1.07616540e-02f, 6.04330888e-03f, 1.07629731e-01f, 9.29277614e-02f,
  5.48585728e-02f, 2.37090327e-02f, 4.47792634e-02f, -5.03014103e-02f, 1.26864105e-01f, -1.00420505e-01f, 2.13036641e-01f, -5.48334010e-02f, 3.23331133e-02f, -1.48339525e-01f,
  -5.89663275e-02f, -1.21560268e-01f, -1.21193171e-01f, 1.20135352e-01f, -2.00685728e-02f, 1.34902596e-01f, 1.00165039e-01f, 7.21787959e-02f, 7.96443298e-02f, -6.85993284e-02f,
  1.79903291e-03f, -1.05295204e-01f, -7.37410411e-02f, -7.62914419e-02f, 1.64092675e-01f, 1.50766343e-01f, 7.17714205e-02f, -1.88446343e-01f, 1.43080607e-01f, 6.09028004e-02f,
  1.86263144e-01f, 1.08885773e-01f, 1.70478612e-01f, -3.18003185e-02f, 1.78234473e-01f, -3.86978127e-02f, 1.46809295e-01f, 1.18613124e-01f, -6.02811985e-02f, 1.19456165e-01f,
  -6.29597250e-03f, -1.70306548e-01f, -3.46641615e-02f, 1.05256543e-01f, -2.77232695e-02f, -1.83560587e-02f, -9.06414613e-02f, 3.24362181e-02f, 3.37185264e-01f, -1.36783630e-01f,
  -2.64498532e-01f, 5.85518777e-02f, -1.02460019e-01f, 8.97590518e-02f, 7.72489980e-02f, 1.09829985e-01f, 1.71183959e-01f, 1.79196689e-02f, -2.18027279e-01f, -1.05567709e-01f,
  2.17356741e-01f, -2.73189306e-01f, 1.63069755e-01f, 5.57929203e-02f, -1.19369142e-01f, 1.29608229e-01f, -7.23559633e-02f, -5.16924448e-02f, -1.60960227e-01f, -1.09109506e-01f,
  1.64627954e-01f, 9.34519172e-02f, -4.28256467e-02f, -1.73217505e-02f, -2.42666081e-01f, 5.42345569e-02f, 2.75175646e-03f, -9.29407924e-02f, -7.50094503e-02f, -1.09600551e-01f,
  -5.49771599e-02f, 1.07250944e-01f, 2.68803872e-02f, -6.30336031e-02f, -3.03002447e-02f, 1.52770296e-01f, 1.02623500e-01f, -8.67462978e-02f, 2.65909940e-01f, 5.48060797e-02f,
  -6.02153465e-02f, 1.45215556e-01f, 5.57987541e-02f, -8.43490213e-02f, -5.30671068e-02f, 5.89166675e-03f, -2.17284206e-02f, 9.70755965e-02f, 4.61258441e-02f, -3.31042428e-03f,
  1.00869976e-01f, 1.68216661e-01f, -4.02329192e-02f, 5.25387190e-02f, -1.88736498e-01f, -7.88706765e-02f, -7.26386718e-03f, -9.48370174e-02f, -6.66130558e-02f, 7.80243799e-02f,
  -4.58002910e-02f, 2.26067498e-01f, 2.05824703e-01f, -6.01835586e-02f, -2.86921654e-02f, 2.58741200e-01f, -2.37127781e-01f, 1.80177391e-01f, 1.17565840e-02f, 1.06295258e-01f,
  2.84105271e-01f, -1.79460004e-01f, -2.82785505e-01f, -6.10503778e-02f, 1.72892790e-02f, 4.40291949e-02f, 2.23355919e-01f, -9.40147415e-02f, -5.19597903e-02f, -1.25139251e-01f,
  8.89967531e-02f, 8.80631730e-02f, -9.46439579e-02f, -6.69986904e-02f, 8.81405622e-02f, -6.96043372e-02f, -1.34648411e-02f, -1.03715822e-01f, -1.11093126e-01f, 2.52256602e-01f,
  7.09177777e-02f, -2.19691083e-01f, 3.35195707e-03f, -5.09559177e-02f, -1.45778190e-02f, 3.72594316e-03f, -1.43631443e-01f, 3.46872099e-02f, 1.24662198e-01f, -2.11142991e-02f,
  -8.97891298e-02f, 4.98397797e-02f, 1.88884303e-01f, -1.64474681e-01f, -1.03146367e-01f, -6.94242194e-02f, -9.41427946e-02f, 4.98451181e-02f, -1.66057318e-01f, -4.35211398e-02f,
  4.68505584e-02f, -5.75333089e-02f, -1.31647319e-01f, 4.66079377e-02f, -2.61082314e-02f, 4.51714210e-02f, -7.18798339e-02f, 4.20346111e-02f, -7.73855597e-02f, -1.26546115e-01f,
  -1.54501423e-02f, 1.22805953e-03f, -6.85771629e-02f, -1.69791505e-01f, -1.11538641e-01f, 1.72288299e-01f, 1.26151592e-01f, 9.87255499e-02f, -5.88996634e-02f, 1.69687375e-01f,
  -3.52193676e-02f, 2.13674307e-01f, -3.33899744e-02f, -1.60938039e-01f, -9.85032171e-02f, 2.28729844e-01f, 1.77894101e-01f, 1.93946697e-02f, 9.36999843e-02f, -1.92063302e-01f,
  7.08154030e-03f, -5.95048144e-02f, -1.46384761e-02f, -7.50570297e-02f, -1.03264436e-01f, 6.16036206e-02f, 6.99506775e-02f, 6.52373657e-02f, 1.13463826e-01f, -7.23382831e-02f,
  3.83569524e-02f, -6.29346967e-02f, 6.49930090e-02f, -2.07807705e-01f, 1.08073279e-01f, -3.71445045e-02f, -8.55832547e-02f, 6.23257048e-02f, -1.47123843e-01f, 6.28863350e-02f,
  1.28558621e-01f, -8.49800557e-02f, -8.12301114e-02f, 1.40080944e-01f, 6.19141571e-02f, 1.93327636e-01f, -1.32170245e-01f, 3.39414254e-02f, -1.79667667e-01f, 2.66238302e-01f,
  -1.36124417e-01f, 1.28021345e-01f, 8.31734985e-02f, 8.65918696e-02f, -1.23208957e-02f, 8.41036141e-02f, 1.69585198e-02f, -1.38301358e-01f, -9.20322984e-02f, -1.65470824e-01f,
  -7.22232135e-03f, 8.87913480e-02f, 9.87448171e-02f, 1.84823960e-01f, 2.16109883e-02f, 1.43015593e-01f, -7.77999833e-02f, 1.31080657e-01f, 3.18501964e-02f, -1.38940975e-01f,
  -1.80382997e-01f, 8.49535018e-02f, 1.76977888e-01f, -1.33900166e-01f, 2.05340415e-01f, -1.81840986e-01f, -1.47572219e-01f, -9.16325450e-02f, -4.34235521e-02f, -5.37604131e-02f,
  -1.10790938e-01f, 1.53929248e-01f, 1.72702268e-01f, 5.84143437e-02f, -6.36289865e-02f, -9.62640438e-03f, -2.79188436e-02f, 6.34965003e-02f, -4.73192222e-02f, 6.36943504e-02f,
  -9.55164805e-02f, 1.45167798e-01f, -1.90479398e-01f, 1.52772991e-02f, -5.65981567e-02f, 2.94060390e-02f, -1.05832309e-01f, 1.36669993e-01f, -1.61762804e-01f, 1.01275807e-02f,
  1.65671617e-01f, -3.61070335e-02f, 1.06068678e-01f, -1.57116786e-01f, -1.45960629e-01f, -8.96502957e-02f, -1.03268541e-01f, 8.48183632e-02f, -7.17562810e-02f, -3.03022593e-01f,
  -1.25811487e-01f, 1.52502641e-01f, 1.90538540e-01f, -4.32606190e-02f, 6.11516610e-02f, -9.39972997e-02f, 1.24104664e-01f, 2.35888315e-03f, 5.14268018e-02f, 5.57351857e-02f,
  -1.67988576e-02f, 5.68265542e-02f, 1.47341937e-01f, 5.56875505e-02f, 1.70966506e-01f, 1.46383747e-01f, 1.99036524e-02f, 1.50692025e-02f, -1.27153754e-01f, -1.28105938e-01f,
  1.02988884e-01f, 4.48990874e-02f, 7.56382570e-02f, -9.37415585e-02f, 1.17283188e-01f, 1.14841655e-01f, -5.62157435e-03f, 1.04434520e-01f, 1.04179777e-01f, 5.95885795e-05f,
  -6.61208257e-02f, 1.84737630e-02f, -3.16831432e-02f, -9.84309241e-02f, -1.39901072e-01f, 3.58027928e-02f, 1.96111679e-01f, -3.04795206e-01f, 1.72724277e-01f, -2.45650783e-02f,
  -6.67346492e-02f, -1.55508891e-03f, 1.20149046e-01f, 8.13879073e-02f, -1.90783098e-01f, -2.77859122e-01f, 6.80955574e-02f, 1.02134876e-01f, 4.72416030e-03f, 1.34183720e-01f,
  -2.60586768e-01f, -1.89950094e-01f, 3.45066451e-02f, -2.37835962e-02f, -5.98286651e-02f, 7.25205541e-02f, 3.89564149e-02f, 1.52660668e-01f, 1.96662933e-01f, 2.38107685e-02f,
  1.70647711e-01f, 6.10320531e-02f, -1.48009928e-02f, -3.77964936e-02f, 2.60940760e-01f, 3.38038020e-02f, -1.23901144e-01f, -2.21923620e-01f, -1.31316900e-01f, -1.65899441e-01f,
  1.05394851e-02f, 9.79655758e-02f, -3.69132310e-02f, -4.39911038e-02f, 1.36656407e-02f, -3.38234864e-02f, -4.39226702e-02f, 1.84352428e-01f, 7.45562911e-02f, 3.41172926e-02f,
  2.18187645e-02f, -5.72623461e-02f, 1.75461471e-01f, -1.32428423e-01f, 4.07033227e-02f, -7.71085033e-03f, -5.16078696e-02f, -1.88295335e-01f, 6.57076091e-02f, 1.00613266e-01f,
  1.76428780e-01f, 2.59372294e-02f, 1.14935510e-01f, -1.97437748e-01f, -6.77533820e-02f, 1.62045449e-01f, 1.56552225e-01f, -3.17157835e-01f, -7.15578869e-02f, -4.94245365e-02f,
  4.53894883e-02f, 3.59551683e-02f, 9.05378088e-02f, 6.45669773e-02f, -9.87607464e-02f, 1.20891988e-01f, -4.68425825e-02f, 5.92824407e-02f, -2.55735628e-02f, -2.99612403e-01f,
  1.57689735e-01f, 6.88422397e-02f, 2.08183052e-03f, -9.22156349e-02f, -1.96382120e-01f, 8.49392824e-03f, 1.07961390e-02f, 2.48941377e-01f, -1.24257699e-01f, 1.57782242e-01f,
  -1.15212714e-02f, -1.33346483e-01f, -1.19847782e-01f, 1.11772455e-01f, -3.06899985e-03f, -8.45518112e-02f, 9.08895805e-02f, -3.02352719e-02f, 1.49608120e-01f, -1.36956930e-01f,
  1.40832022e-01f, -8.71832743e-02f, 6.81133643e-02f, -1.11667449e-02f, -9.46301594e-02f, -8.12118649e-02f, -5.52820005e-02f, 1.21921055e-01f, 8.48923326e-02f, 1.41352430e-01f,
  -4.25598957e-03f, 7.10781477e-03f, -3.96652520e-02f, -3.87737043e-02f, -2.07687259e-01f, 4.61302549e-02f, 9.13911834e-02f, -4.93399054e-02f, 2.16041785e-02f, -1.09993033e-01f,
  1.50501087e-01f, 5.86572103e-03f, 2.01663926e-01f, -5.60634173e-02f, -2.55841792e-01f, 1.29450962e-01f, -6.77138045e-02f, 3.30187917e-01f, -3.92712690e-02f, -2.28236452e-01f,
  2.82029122e-01f, 1.75942779e-01f, -1.60411507e-01f, -9.72410068e-02f, -1.35653049e-01f, -1.64911702e-01f, 1.02741964e-01f, -1.97707504e-01f, 3.73292193e-02f, -1.87653095e-01f,
  -6.57952204e-02f, 1.97863225e-02f, 1.05286418e-02f, -4.59931931e-03f, -2.66968399e-01f, 1.50138840e-01f, 2.88052727e-02f, 1.57853201e-01f, 1.48554333e-02f, 6.61225393e-02f,
  3.40522230e-02f, -2.90531784e-01f, 8.19109008e-02f, -5.47525361e-02f, -1.60913505e-02f, -5.92106059e-02f, -5.66527992e-02f, 8.72606561e-02f, 2.08154041e-02f, 8.62602592e-02f,
  4.61185127e-02f, 2.26306453e-01f, -1.90125536e-02f, -1.78731784e-01f, -1.98227182e-01f, 9.96293351e-02f, 1.14291564e-01f, 2.08204370e-02f, -5.19791320e-02f, 6.92215934e-03f,
  2.11566277e-02f, -3.33254337e-02f, -5.56475557e-02f, 1.74605921e-02f, 5.96858859e-02f, 4.91921268e-02f, 6.40389621e-02f, 4.73536476e-02f, -1.48052471e-02f, 1.22408010e-01f,
  -3.99987549e-02f, -2.23048381e-03f, -1.11551732e-01f, -4.74507883e-02f, 8.04022402e-02f, 1.05945505e-01f, 2.59098262e-01f, 1.38353594e-02f, -6.78778961e-02f, -1.01268962e-02f,
  7.75875598e-02f, 1.60865888e-01f, 1.55492529e-01f, 6.89563826e-02f, 2.55776703e-01f, 8.21256712e-02f, -2.88485646e-01f, -1.64275333e-01f, -2.06736941e-02f, -6.96812272e-02f,
  1.89815611e-01f, -1.76287174e-01f, -7.15420619e-02f, 9.50554684e-02f, 1.21313445e-01f, 3.38681117e-02f, -1.21921837e-01f, 4.64889146e-02f, 3.93926688e-02f, -1.59774795e-02f,
  -4.27954197e-02f, 2.42257699e-01f, -1.90445244e-01f, 1.26951948e-01f, 1.09595828e-01f, -2.51207113e-01f, -6.56680167e-02f, 1.55522057e-03f, 1.16071150e-01f, 5.03551327e-02f,
  2.43109185e-02f, -1.50951788e-01f, 1.70308486e-01f, 1.14431202e-01f, -6.85219690e-02f, -1.47001594e-01f, 1.76699832e-01f, 6.82432652e-02f, -9.57405865e-02f, -3.61833051e-02f,
  1.95317492e-02f, -1.87155262e-01f, 4.76244465e-02f, 1.48939444e-02f, -6.45501763e-02f, 3.99535615e-03f, -1.46491021e-01f, -5.10922819e-02f, -1.76904634e-01f, 1.94534883e-02f,
  -1.66362584e-01f, -1.97855458e-01f, -1.11619890e-01f, 2.95706932e-02f, -1.25705630e-01f, -1.22733146e-01f, 3.66604924e-02f, -7.58177713e-02f, -1.03674591e-01f, 8.10334757e-02f,
  -2.29337558e-01f, 6.58660457e-02f, 1.22793838e-01f, -1.22517698e-01f, -3.43784355e-02f, 7.24703595e-02f, -4.70746569e-02f, -9.18330774e-02f, -8.27676952e-02f, 1.03294462e-01f,
  2.47912869e-01f, 1.45545110e-01f, -3.10943723e-01f, 1.50135040e-01f, -3.58025461e-01f, -1.48733072e-02f, 5.73777929e-02f, -6.71490282e-02f, 6.27022460e-02f, 6.08240478e-02f,
  9.85550955e-02f, 1.38169289e-01f, -3.21463756e-02f, 1.13644302e-01f, 5.74835241e-02f, -1.42870143e-01f, 1.28152922e-01f, 1.51491672e-01f, 1.88042447e-01f, -1.82093307e-01f,
  3.40263685e-03f, -1.35710075e-01f, -1.04249246e-01f, 3.38810943e-02f, -3.84001732e-02f, 2.42867544e-02f, 1.67053416e-02f, 7.26386830e-02f, 7.94606656e-02f, 2.10494742e-01f,
  -1.33937746e-01f, -3.59867178e-02f, -1.35530680e-01f, 5.83238490e-02f, 3.18669230e-02f, 4.54885103e-02f, -9.43630785e-02f, -7.71471858e-02f, -3.30304429e-02f, -2.39983555e-02f,
  -4.40518633e-02f, 3.34703624e-02f, 3.55153345e-02f, -1.03496924e-01f, 1.74966827e-03f, 2.13063970e-01f, 1.22754917e-01f, 1.34464785e-01f, 6.67201206e-02f, 8.14401060e-02f,
  -3.30861658e-02f, -5.57802655e-02f, -1.01748556e-01f, -1.31023079e-01f, -2.04074711e-01f, 5.42773940e-02f, 1.85529068e-01f, -9.39872041e-02f, 1.33296162e-01f, -1.56675786e-01f,
  -7.20834732e-02f, 6.78649321e-02f, -1.71059430e-01f, -1.35499433e-01f, -5.04234768e-02f, 9.87456664e-02f, 1.09870270e-01f, 8.82638767e-02f, -4.13191281e-02f, 6.72489554e-02f,
  5.15789874e-02f, 1.91872895e-01f, 1.03611402e-01f, 1.03155971e-01f, 1.38439521e-01f, 1.09016038e-01f, 1.45648852e-01f, -3.79417352e-02f, -5.59388362e-02f, -5.62296696e-02f,
  -8.17880332e-02f, -1.33926094e-01f, -5.76051958e-02f, 2.41526723e-01f, -8.09049904e-02f, 4.14315350e-02f, -1.06841646e-01f, -9.60471928e-02f, -1.49701267e-01f, -1.04143202e-01f,
  6.52322471e-02f, -8.98162350e-02f, 5.12271300e-02f, -1.62135959e-01f, -1.08317591e-01f, 1.37873754e-01f, 2.46433944e-01f, 1.29747568e-02f, -3.40200476e-02f, -1.81948375e-02f,
  -5.98464869e-02f, 2.46902201e-02f, 7.36887287e-03f, -3.90561819e-02f, 4.74623963e-02f, 1.56691328e-01f, -2.27115657e-02f, 2.16342956e-01f, 1.58427894e-01f, -8.71795565e-02f,
  -7.53629804e-02f, -1.11635402e-03f, 2.12145314e-01f, 8.13688114e-02f, 7.34756002e-04f, 4.38337177e-02f, 7.22015947e-02f, 9.87212956e-02f, 3.10955286e-01f, -2.71987766e-02f,
  7.24461628e-03f, 1.91386849e-01f, -1.65902808e-01f, -5.32773808e-02f, 5.95152117e-02f, 1.25018612e-01f, 4.31356058e-02f, -2.17159223e-02f, -2.99658865e-01f, -1.84019431e-01f,
  1.74667194e-01f, 1.52816968e-02f, 8.12702477e-02f, -1.48719788e-01f, 9.44566913e-03f, 1.22327894e-01f, 9.48955119e-02f, -5.11546209e-02f, -1.27530575e-01f, -1.09205991e-01f,
  1.81195095e-01f, 1.24003328e-01f, -1.79520756e-01f, 3.49049680e-02f, -1.33629382e-01f, 2.39561394e-01f, 1.00248493e-01f, 2.26061847e-02f, -1.23017326e-01f, -1.14237152e-01f,
  5.41841425e-02f, -5.22816442e-02f, -1.01892009e-01f, 1.66050568e-02f, -5.94906211e-02f, -7.54148886e-02f, 7.78209344e-02f, 4.07676436e-02f, 1.47655621e-01f, -9.38670114e-02f,
  -1.58382490e-01f, -5.31320274e-03f, -6.68614209e-02f, 7.64893889e-02f, 5.48571274e-02f, 4.46235090e-02f, 3.26110981e-02f, 6.71441182e-02f, 2.19316613e-02f, 4.39733490e-02f,
  -3.74342874e-02f, 1.31374672e-01f, 9.43252295e-02f, 1.03794888e-01f, 1.15694150e-01f, -2.37195529e-02f, 1.78437710e-01f, 2.79197730e-02f, 1.37518123e-01f, 1.45578206e-01f,
  -4.92733764e-03f, -4.72887680e-02f, 2.50723988e-01f, 1.30221769e-01f, -2.44726520e-02f, 6.05167709e-02f, -9.02119279e-02f, -1.89249426e-01f, 6.00999892e-02f, 8.05343166e-02f,
  1.02324247e-01f, -2.92909056e-01f, -1.07137658e-01f, -4.62191179e-02f, 2.17143908e-01f, -9.15878490e-02f, 1.49733841e-01f, -1.07457876e-01f, 7.57139400e-02f, 1.63995046e-02f,
  2.70351414e-02f, -6.18465319e-02f, -2.18735225e-02f, -1.52635142e-01f, 8.85497332e-02f, 1.17190853e-01f, -2.28710566e-02f, -2.18628377e-01f, 2.05356367e-02f, 1.47742918e-02f,
  -1.11981951e-01f, 3.58257562e-01f, 1.02763452e-01f, 3.30698378e-02f, 1.06898271e-01f, -8.68272483e-02f, -8.02163258e-02f, -7.90074840e-02f, -1.64097473e-02f, 1.32029310e-01f,
  -1.65238768e-01f, -1.53693229e-01f, 2.98247814e-01f, -4.65786941e-02f, -4.92231129e-03f, -1.82802081e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -8.98525491e-02f, -3.84524427e-02f, -1.11599565e-02f, -5.41506223e-02f, -3.88084166e-02f, 6.31968975e-02f, -8.76844898e-02f, -5.78737855e-02f, -1.07610323e-01f, -6.57737032e-02f,
  -6.05803402e-03f, 5.37236892e-02f, 7.71820247e-02f, -3.87027934e-02f, -6.60229996e-02f, 2.55498346e-02f, 1.35417320e-02f, -4.72629406e-02f, -8.82916451e-02f, -3.03559005e-02f,
  1.09984204e-01f, 9.17585343e-02f, 9.53340754e-02f, -1.38323039e-01f, 4.37815301e-02f, 3.93688157e-02f, -1.23154856e-01f, 1.86773278e-02f, -1.29430190e-01f, -1.30349835e-02f,
  -1.57999694e-02f, -7.33224228e-02f, -7.40794316e-02f, 5.11983708e-02f, -4.16583009e-02f, 1.32378995e-01f, 5.73601387e-02f, -6.56440929e-02f, -6.75273836e-02f, -7.57431388e-02f,
  -1.97122782e-03f, -5.59215620e-03f, 6.96056662e-03f, 6.38332516e-02f, 7.22988695e-02f, -1.41844973e-01f, 6.38743266e-02f, -9.48124751e-02f, 7.67408609e-02f, 1.89825609e-01f,
  -1.01288430e-01f, -4.06131893e-02f, 1.07614852e-01f, 8.83744061e-02f, -3.84833477e-02f, 1.27796233e-01f, 1.59681235e-02f, 1.15071133e-01f, 6.58959746e-02f, -3.40694524e-02f,
  -5.93877807e-02f, 1.35792822e-01f, 7.05385432e-02f, 8.88386071e-02f, 1.26462951e-01f, 2.32006937e-01f, 4.05873396e-02f, 9.97110642e-03f, 1.60980269e-01f, 1.79722775e-02f,
  3.88942845e-02f, -1.43587925e-02f, -1.42366877e-02f, -6.64836541e-02f, -3.05924732e-02f, 2.02159986e-01f, 1.55420929e-01f, 8.33517686e-02f, 8.30672309e-02f, 1.88894644e-01f,
  4.67268042e-02f, -3.66065791e-03f, 6.54533505e-02f, -8.32610279e-02f, -1.15298107e-01f, 9.51914638e-02f, -2.29422495e-01f, -1.56080514e-01f, 9.10294950e-02f, 2.32940629e-01f,
  -9.59934201e-03f, -4.36913222e-02f, -1.41298383e-01f, 1.72304884e-01f, 1.26296327e-01f, -5.28789796e-02f, -2.29661226e-01f, -4.73968312e-02f, -6.04982786e-02f, -8.88168961e-02f,
  -3.23213190e-02f, -8.83317366e-02f, 1.21132080e-02f, -5.35874115e-03f, 3.12756747e-01f, -8.91805887e-02f, -8.34129751e-02f, -1.12581767e-01f, 1.47548750e-01f, 2.43236586e-01f,
  6.44794479e-02f, -2.47139931e-01f, 3.65432128e-02f, -2.10508540e-01f, -9.23463330e-02f, -4.56688330e-02f, 7.33603612e-02f, 1.29415676e-01f, 1.83575362e-01f, -9.60604027e-02f,
  -6.23536110e-02f, 1.00004993e-01f, -1.69357602e-02f, 1.80138573e-01f, -1.05274439e-01f, -6.03271872e-02f, -1.35830924e-01f, 1.58962607e-01f, 1.07888468e-01f, -1.63603872e-01f,
  7.66212540e-03f, -5.29080257e-02f, 1.38878435e-01f, -1.42188802e-01f, 3.78288813e-02f, -2.28596781e-03f, -1.13534145e-01f, -5.47893792e-02f, -1.11269541e-01f, 4.86125275e-02f,
  -9.10867229e-02f, 5.14488369e-02f, 1.17444351e-01f, -1.67369060e-02f, 1.16104305e-01f, 1.20868519e-01f, -3.44067886e-02f, 1.55261616e-04f, -4.77379141e-03f, 2.40281243e-02f,
  5.29757142e-02f, 1.95322130e-02f, 7.39657357e-02f, -6.91205915e-03f, 8.94161761e-02f, -1.56640317e-02f, -9.83579680e-02f, 1.52016088e-01f, 1.27477020e-01f, -7.02980235e-02f,
  -2.56301314e-01f, 1.63341835e-01f, -2.45589986e-01f, -1.11371122e-01f, -3.37713957e-02f, -1.15304254e-01f, -1.05813161e-01f, 4.64202091e-02f, -3.73423249e-02f, 6.53610379e-03f,
  5.47037981e-02f, 8.38959143e-02f, -1.70559622e-02f, -1.15360826e-01f, 9.85206142e-02f, 2.62136787e-01f, 1.44347176e-01f, -3.73165905e-02f, 3.03329471e-02f, 1.27991918e-03f,
  8.11931938e-02f, 8.56015831e-02f, 1.57014579e-02f, 9.97206718e-02f, -6.85576871e-02f, -1.05273323e-02f, 3.06496955e-02f, 3.26405108e-01f, -1.41854182e-01f, -1.19496353e-01f,
  -1.41335815e-01f, 9.51595679e-02f, -4.52575572e-02f, 1.16457507e-01f, 1.34140894e-01f, 3.04419256e-04f, 1.62499025e-02f, -2.45341975e-02f, 7.42894113e-02f, 3.72676440e-02f,
  1.71256661e-01f, -8.01638514e-02f, 9.75539163e-03f, -9.48558152e-02f, -1.15764616e-02f, 9.57549363e-02f, 1.17655359e-01f, -3.20077352e-02f, 3.10551655e-02f, -3.54673788e-02f,
  -1.20020602e-02f, -1.96683735e-01f, -1.37570173e-01f, 1.27336875e-01f, -4.02623117e-02f, -9.06048045e-02f, -8.42720345e-02f, -2.03435495e-01f, -7.58763328e-02f, 1.63040981e-01f,
  -1.52675122e-01f, -5.94141036e-02f, 2.08150178e-01f, 1.17467999e-01f, 6.94765449e-02f, -3.68030407e-02f, -1.28368691e-01f, 1.26890853e-01f, 3.79700251e-02f, -3.94644551e-02f,
  1.20704427e-01f, -1.10462800e-01f, 1.10838950e-01f, -8.29746947e-02f, 9.54401270e-02f, -1.20739555e-02f, -6.51739165e-02f, 2.61552166e-02f, 2.14016914e-01f, -2.82649435e-02f,
  -7.94775411e-02f, 4.14774120e-01f, -9.48170125e-02f, -4.01668511e-02f, -4.78901304e-02f, -2.33094431e-02f, -1.18779326e-02f, 6.57758266e-02f, -1.33033574e-01f, -1.79345816e-01f,
  -1.34976313e-01f, -6.08498156e-02f, -7.07602128e-02f, 8.49582627e-03f, 2.77303040e-01f, 3.06051243e-02f, -1.93983763e-02f, 1.20776817e-01f, 3.72950993e-02f, 6.73026070e-02f,
  5.18705882e-02f, 6.61193579e-02f, -3.45182344e-02f, 9.49813277e-02f, -3.13040055e-02f, 1.32476941e-01f, 5.09924479e-02f, 8.76066834e-02f, -1.01047978e-01f, -1.11920297e-01f,
  4.11844850e-02f, 5.69941886e-02f, -6.78985268e-02f, 7.85651654e-02f, 1.21931873e-01f, -2.18081195e-02f, 7.94123113e-02f, 4.77003343e-02f, 2.73085032e-02f, -6.18805550e-02f,
  9.91873443e-02f, -1.10358514e-01f, -4.03213389e-02f, -1.52707532e-01f, 3.12246848e-03f, 3.39511037e-02f, -1.33702993e-01f, -1.32091388e-01f, -5.02497181e-02f, 3.21200378e-02f,
  -8.35711882e-02f, 6.49883524e-02f, -6.91274479e-02f, 1.77160483e-02f, 6.56070635e-02f, 1.08288676e-01f, 6.78581446e-02f, 3.22928503e-02f, -5.36654852e-02f, -1.18462788e-03f,
  -7.71341205e-04f, 1.48213938e-01f, -7.80093968e-02f, 8.64647776e-02f, 9.64048058e-02f, -2.67817657e-02f, 4.27061617e-02f, 2.35408675e-02f, 7.77888596e-02f, 7.47633725e-02f,
  -2.24082284e-02f, -5.12520373e-02f, 1.57095283e-01f, 5.49616143e-02f, 1.14070602e-01f, 7.98917711e-02f, -1.57224849e-01f, -1.32780537e-01f, 8.55914205e-02f, -1.33619323e-01f,
  -5.60883693e-02f, -7.13614281e-03f, 1.14482023e-01f, -5.05099222e-02f, 1.32060662e-01f, -4.40915562e-02f, 8.83238390e-02f, 8.00088346e-02f, -7.27636507e-03f, -1.32714346e-01f,
  1.05521776e-01f, -9.86550599e-02f, 1.31095767e-01f, 1.07002534e-01f, 4.47694622e-02f, 1.61525652e-01f, 1.48590654e-02f, 1.46646976e-01f, 1.56392515e-01f, -1.38914004e-01f,
  -1.06560238e-01f, -3.28791626e-02f, 8.86840746e-02f, -9.19405520e-02f, 5.42032719e-02f, -1.13429606e-01f, 2.35183872e-02f, -1.09570660e-01f, -9.81667042e-02f, 1.15605697e-01f,
  -1.78239439e-02f, 4.77136374e-02f, 1.21774480e-01f, 9.38958526e-02f, 4.49359640e-02f, 1.23696223e-01f, 1.61602590e-02f, 1.00290060e-01f, -1.19621448e-01f, -4.59241606e-02f,
  9.02172551e-02f, -3.92654585e-03f, -1.18255533e-01f, -8.51013213e-02f, 1.88938510e-02f, 8.30131695e-02f, 4.45872806e-02f, -1.64871267e-03f, 5.65736629e-02f, 3.01992625e-01f,
  -2.82665379e-02f, -8.63550529e-02f, -7.20845759e-02f, -1.14633404e-01f, -7.46386126e-02f, -4.87037674e-02f, -2.11161282e-03f, -7.96013698e-02f, -2.59279218e-02f, -1.58278912e-01f,
  7.39346445e-02f, 6.56918287e-02f, 1.71929270e-01f, 1.31720334e-01f, 1.24020353e-01f, 1.06119951e-02f, 4.05559726e-02f, 6.06280938e-02f, 6.03196584e-02f, -5.80019355e-02f,
  7.54476860e-02f, -6.72758445e-02f, 9.69968215e-02f, -7.33612552e-02f, -5.68672344e-02f, -2.66740620e-02f, 2.46313512e-02f, 8.96691680e-02f, 5.09119704e-02f, 9.52831842e-03f,
  -1.73755940e-02f, 1.17580004e-01f, -5.39561966e-03f, -4.67294976e-02f, -1.17138391e-02f, -9.63345096e-02f, -2.00547174e-01f, 3.94541286e-02f, -1.04582526e-01f, 4.89035212e-02f,
  -1.01452239e-01f, -2.07171626e-02f, -7.41104782e-02f, 3.76823507e-02f, 1.33737251e-01f, -5.21989129e-02f, -9.33542252e-02f, -7.05952058e-04f, -3.94335017e-02f, -1.28880680e-01f,
  -3.68109569e-02f, 6.34119567e-03f, 6.45823553e-02f, 1.11771531e-01f, 1.51705474e-01f, -7.79147446e-02f, -1.04414582e-01f, -2.48240754e-02f, 8.59664977e-02f, 2.09437892e-01f,
  -8.97311941e-02f, -6.92120641e-02f, -9.18696895e-02f, 1.45373242e-02f, -2.36642975e-02f, 1.15568703e-02f, -8.30230340e-02f, -7.06681833e-02f, 1.29455393e-02f, 2.14133449e-02f,
  9.39341187e-02f, -3.62694822e-02f, 1.23683624e-02f, 6.16996028e-02f, -7.00931577e-03f, -1.30234778e-01f, 6.92974553e-02f, 1.63406208e-02f, 1.76127464e-01f, 3.38531509e-02f,
  -6.67362064e-02f, -9.49319601e-02f, 1.54506326e-01f, -4.30599339e-02f, -5.81207462e-02f, 1.76601574e-01f, 1.16242692e-01f, -3.41214761e-02f, -2.10844763e-02f, -1.07238688e-01f,
  9.20914933e-02f, -6.48886785e-02f, 8.27887058e-02f, -1.12820946e-01f, 1.35737449e-01f, 8.60953107e-02f, 8.30707327e-02f, 3.31148833e-01f, 6.07173219e-02f, -2.11992979e-01f,
  -9.52467397e-02f, 2.95347661e-01f, -2.99908757e-01f, 2.36641169e-01f, -3.07849199e-02f, 1.89090092e-02f, -8.84158537e-02f, 7.34714717e-02f, 8.14531222e-02f, -1.20464498e-02f,
  -4.32602540e-02f, 1.75909683e-01f, -1.37451512e-03f, 1.72340181e-02f, -4.63481247e-02f, 6.19634427e-02f, 8.84907544e-02f, 4.57529072e-03f, -1.32400349e-01f, 2.71809876e-01f,
  -9.86148417e-02f, 1.02521494e-01f, -1.46357343e-01f, 4.91031893e-02f, 1.76715493e-01f, 2.41371006e-01f, 1.14636712e-01f, 2.69119501e-01f, -2.30303966e-02f, -1.66995041e-02f,
  7.79349431e-02f, 1.33681647e-03f, 4.84451279e-02f, 1.42100483e-01f, -5.99643122e-03f, 9.12211314e-02f, 3.71165201e-02f, 3.88029575e-01f, 1.72431618e-02f, -1.12335198e-02f,
  -2.04035148e-01f, 2.34850302e-01f, -3.93545441e-02f, -1.03463612e-01f, -1.45903202e-02f, -3.89823467e-02f, 1.12105921e-01f, 3.50121036e-02f, 1.44740015e-01f, 2.87034195e-02f,
  6.69772699e-02f, -9.97540951e-02f, -3.30452286e-02f, 5.87383732e-02f, 5.56721352e-02f, 2.33553350e-02f, 7.34824687e-02f, -2.02222213e-01f, 2.07918674e-01f, 4.08430584e-02f,
  1.35942012e-01f, -6.80129454e-02f, -1.75073043e-01f, -9.51068550e-02f, -1.20421894e-01f, 1.08909376e-01f, -1.44929543e-01f, 1.16986051e-01f, 6.89744651e-02f, 1.04165599e-01f,
  -1.38289481e-01f, 8.02517310e-02f, 1.04740582e-01f, 5.20590134e-02f, 9.59461778e-02f, -3.18981595e-02f, 1.71000473e-02f, -2.15278622e-02f, 5.98329566e-02f, 6.84812218e-02f,
  -2.22049151e-02f, 5.48925847e-02f, -9.07674059e-02f, 7.54945427e-02f, 2.37773225e-01f, 1.74784344e-02f, -1.17354631e-01f, -2.69598216e-01f, 1.34047091e-01f, 4.19726297e-02f,
  1.87822580e-02f, 3.96673262e-01f, -1.65602386e-01f, 4.75031249e-02f, -2.80882269e-02f, 7.26424996e-03f, -1.00801393e-01f, 2.89618759e-03f, -1.17446057e-01f, -2.62018405e-02f,
  8.72120634e-02f, 3.67789477e-01f, 1.27219677e-01f, 4.69248891e-02f, -1.03771254e-01f, 1.71165973e-01f, 2.42829546e-02f, 1.11918584e-01f, -6.72810078e-02f, -1.25159854e-02f,
  -7.11333677e-02f, 1.23903692e-01f, -8.70537758e-02f, -4.14219610e-02f, -3.97088192e-02f, 1.66105688e-01f, 1.17183946e-01f, 9.32549164e-02f, -5.25526702e-03f, -4.83363681e-02f,
  1.54754281e-01f, 3.02980412e-02f, 1.01230055e-01f, -1.11776188e-01f, 1.70070052e-01f, 1.15154862e-01f, 1.46257907e-01f, 4.49850783e-02f, -1.28562763e-01f, 1.12062469e-01f,
  -1.00765936e-01f, 4.52974671e-03f, 1.05014302e-01f, -2.85070669e-02f, 1.15809172e-01f, 1.72100425e-01f, 2.21695062e-02f, -1.16705604e-01f, 1.78955868e-01f, -1.65804103e-01f,
  -1.06311835e-01f, 3.41585241e-02f, -8.34517705e-04f, -1.18135370e-01f, 1.27027586e-01f, 9.55280066e-02f, 3.30020301e-02f, 5.87004907e-02f, 1.31632566e-01f, -1.03281975e-01f,
  7.86373541e-02f, 2.13112682e-01f, -3.42126414e-02f, -6.11784235e-02f, 1.96378931e-01f, 7.44099680e-07f, 1.72489043e-02f, 2.32530646e-02f, 5.59273325e-02f, 2.23180763e-02f,
  -8.92113373e-02f, -1.65102243e-01f, 2.14803079e-03f, 3.94142233e-02f, -4.67818379e-02f, 1.69997998e-02f, 6.05748184e-02f, 2.01433450e-02f, 1.09277621e-01f, 2.34358296e-01f,
  -8.45308900e-02f, -4.04397026e-02f, -9.13765356e-02f, 3.22860703e-02f, 9.26104840e-03f, -2.51466446e-02f, -8.99821147e-02f, -1.83354449e-02f, -3.92459482e-02f, 8.97028521e-02f,
  7.63744116e-02f, 3.31154913e-02f, -1.35026187e-01f, -3.35201025e-02f, 1.59456849e-01f, 1.19880788e-01f, -1.18228771e-01f, -7.59382220e-03f, 9.01891813e-02f, 1.11321054e-01f,
  1.91027343e-01f, 3.24526825e-03f, -3.29170413e-02f, 1.68473080e-01f, -9.38050151e-02f, 4.73968126e-02f, 1.35643914e-01f, -1.07596852e-01f, 8.68223235e-02f, 8.39967728e-02f,
  5.53199975e-03f, 9.42422077e-03f, 4.33911458e-02f, -1.19786836e-01f, 4.80325855e-02f, -1.10144153e-01f, -1.26508936e-01f, 8.29103813e-02f, 1.21820271e-01f, -5.50167309e-03f,
  8.76154974e-02f, 6.89456686e-02f, 8.56279209e-02f, -4.84531038e-02f, -1.21910155e-01f, 1.24715351e-01f, 7.41566950e-03f, 1.94500282e-01f, 1.04190230e-01f, -8.58339295e-02f,
  1.18391789e-01f, 1.25858799e-01f, -2.91932914e-02f, 1.14752091e-01f, -4.35936451e-02f, -6.90136030e-02f, 7.29104131e-02f, 7.99265578e-02f, -1.16816975e-01f, -3.13182659e-02f,
  5.89706302e-02f, -9.99966040e-02f, 1.03955166e-02f, -1.88905410e-02f, -4.75819148e-02f, 1.17939867e-01f, 2.88152415e-02f, 1.13153040e-01f, 8.29265043e-02f, 2.68813074e-01f,
  1.75263777e-01f, 6.20950572e-02f, -1.02656679e-02f, -1.86780281e-02f, -2.21125297e-02f, 3.06968540e-01f, 9.58924294e-02f, 1.99667558e-01f, 1.08478844e-01f, 2.99340278e-01f,
  3.88064347e-02f, 1.25139445e-01f, -4.89558801e-02f, -1.08909927e-01f, 3.79307456e-02f, 7.70215839e-02f, 1.86082174e-03f, -1.95953548e-01f, 2.35044569e-01f, -9.15613249e-02f,
  -8.62582177e-02f, 1.02210864e-02f, -7.62574822e-02f, -1.46724703e-02f, -1.82615325e-01f, -1.48958907e-01f, 1.69792116e-01f, 1.05783872e-01f, 2.69479483e-01f, -3.44281178e-03f,
  -4.99909781e-02f, 1.51821017e-01f, -4.69449759e-02f, 3.26927379e-02f, 7.86589310e-02f, 5.29971533e-02f, 9.70333144e-02f, -1.80409849e-02f, -7.72176012e-02f, 1.38269439e-01f,
  -1.00829464e-03f, 9.93923470e-02f, -6.89181760e-02f, 2.03916624e-01f, 1.86997414e-01f, -5.91353253e-02f, -8.84692818e-02f, 1.55064613e-01f, 1.63749322e-01f, 2.80986670e-02f,
  1.13757558e-01f, 5.27316034e-02f, -8.37926567e-02f, -2.60708749e-01f, -6.19526254e-03f, -5.51680028e-02f, 2.23943666e-01f, -9.13054422e-02f, 1.20671831e-01f, -2.82173255e-03f,
  6.14792146e-02f, 1.28832385e-02f, -7.44043291e-02f, 9.88968741e-03f, 7.22872987e-02f, -2.07467005e-02f, 7.54425153e-02f, 4.93833721e-02f, 6.31203279e-02f, 5.47503307e-02f,
  2.47271489e-02f, -8.17704499e-02f, -2.96041425e-02f, 4.16591577e-02f, 1.24343738e-01f, -6.70655966e-02f, 1.13185704e-01f, -1.31574437e-01f, 1.09997384e-01f, 7.72463679e-02f,
  -7.94860944e-02f, 3.97873074e-02f, 1.93291083e-01f, 3.04733869e-02f, -1.83338404e-01f, -9.89013165e-02f, -1.50128543e-01f, 4.07183766e-02f, -1.94709077e-02f, 2.24387180e-02f,
  -8.41115564e-02f, 5.40451817e-02f, 8.60732049e-02f, 6.12585880e-02f, -7.12992996e-03f, -4.82939146e-02f, -6.55261129e-02f, 6.43131733e-02f, 7.31843784e-02f, 1.23794734e-01f,
  -4.78255861e-02f, -1.11743157e-06f, 3.91545035e-02f, 8.25122595e-02f, -1.30241394e-01f, -5.43174967e-02f, -1.13983989e-01f, -1.32296443e-01f, 7.25926012e-02f, -1.21590130e-01f,
  -2.60611307e-02f, 6.34271130e-02f, 2.04361990e-01f, 6.77853674e-02f, 5.71680330e-02f, 8.03536624e-02f, 1.29166752e-01f, -8.06473643e-02f, 3.86334909e-03f, 8.94622207e-02f,
  1.61006898e-01f, -5.27714752e-02f, 2.79494729e-02f, -4.54845950e-02f, 3.32112193e-01f, 1.09149233e-01f, 2.15835143e-02f, 2.60945648e-01f, 1.88571692e-01f, 2.29858428e-01f,
  2.45274007e-01f, 3.05328071e-01f, 3.29329133e-01f, 2.10680082e-01f, 6.32684166e-03f, 2.17503846e-01f, 1.71770528e-01f, 9.32809189e-02f, -8.82100314e-03f, 1.75559103e-01f,
  7.84579366e-02f, -7.55598992e-02f, 3.82710770e-02f, 1.74939763e-02f, -1.44872358e-02f, -1.39352113e-01f, 1.79221690e-01f, 5.74337058e-02f, -1.49001047e-01f, -6.31506555e-03f,
  1.14150293e-01f, -3.71335261e-02f, -3.04215103e-01f, -2.89827228e-01f, -2.01382741e-01f, 2.19990220e-02f, 2.28176832e-01f, -1.71422914e-01f, 7.73560116e-03f, 2.72311294e-03f,
  4.92952876e-02f, 7.11844563e-02f, -3.46521847e-03f, -9.74820703e-02f, -4.90634926e-02f, -3.85919921e-02f, -9.04538929e-02f, 4.01033401e-01f, -1.42513812e-01f, 1.99609235e-01f,
  5.46519905e-02f, -2.63261139e-01f, -6.96474165e-02f, -1.34160131e-01f, 5.38640879e-02f, 5.30618727e-02f, 2.90224385e-02f, 1.01274960e-01f, 2.98262089e-01f, -7.90860504e-02f,
  1.19025614e-02f, -2.27634430e-01f, 1.48736402e-01f, -1.95150375e-01f, 6.74402192e-02f, -3.32033128e-01f, 2.17999607e-01f, 1.51451275e-01f, 1.55783087e-01f, -3.37691344e-02f,
  -1.79735813e-02f, 1.95663571e-02f, 9.27972421e-02f, -9.74621251e-02f, -5.83502874e-02f, -1.25734601e-02f, 4.12738100e-02f, 1.76586077e-01f, 9.16442424e-02f, 1.27116635e-01f,
  -4.24631842e-04f, 1.96291864e-01f, -1.17090099e-01f, -6.80338871e-03f, 5.85932620e-02f, 1.67927012e-01f, -5.81549518e-02f, -1.76443741e-01f, -1.11174084e-01f, -9.70319435e-02f,
  1.80891454e-01f, 5.68360500e-02f, -1.51156723e-01f, -1.25578478e-01f, -1.29391342e-01f, 3.89523767e-02f, -1.08627461e-01f, -2.35021636e-02f, -2.35616416e-01f, 2.08616197e-01f,
  -1.22069024e-01f, -2.30885834e-01f, 1.36428699e-01f, 1.72004588e-02f, 1.19226798e-01f, -9.03525576e-03f, -9.94973481e-02f, 4.12889332e-01f, -8.89412463e-02f, -5.87900281e-02f,
  -5.91762438e-02f, 1.57319203e-01f, 6.78411648e-02f, 2.73934036e-01f, 6.34361729e-02f, -2.55384296e-01f, 2.58389205e-01f, -1.49012893e-01f, 3.96890640e-02f, -4.55866940e-02f,
  -1.81807488e-01f, -7.68793225e-02f, 4.69621420e-02f, -3.72562334e-02f, 1.33308932e-01f, -1.41679034e-01f, -9.32495520e-02f, 1.58221796e-01f, 9.26088169e-02f, 1.01536103e-01f,
  4.54687811e-02f, -5.19395545e-02f, 6.12586644e-03f, -6.77349269e-02f, 1.59386069e-01f, -6.41367808e-02f, 1.14190124e-01f, 8.87832195e-02f, 1.55913249e-01f, 4.13575396e-02f,
  6.56957850e-02f, -2.08198830e-01f, 1.13787457e-01f, 1.66402563e-01f, 1.47888526e-01f, 9.38244537e-02f, 6.05305508e-02f, 9.15526226e-02f, 1.80449799e-01f, -9.26384702e-02f,
  -1.07649088e-01f, -3.10912225e-02f, -4.30587158e-02f, 8.13339353e-02f, -1.76869333e-01f, -1.89906031e-01f, 3.36056724e-02f, 1.47316262e-01f, -1.85049519e-01f, -2.15720553e-02f,
  2.28458032e-01f, 5.69945201e-02f, -1.68064795e-02f, -6.43181950e-02f, -2.01084197e-01f, 1.10971630e-01f, 3.41870151e-02f, 1.89516470e-02f, -6.84233150e-03f, -4.44858521e-02f,
  -5.16071124e-03f, -1.11039300e-02f, 1.76052719e-01f, -3.90695669e-02f, -1.18525878e-01f, -1.33246288e-01f, 1.18083499e-01f, 2.03788951e-02f, -1.01164095e-01f, 3.70255262e-01f,
  -1.68397427e-01f, 9.12534352e-03f, -1.10944286e-01f, -1.51160389e-01f, -1.68866068e-01f, 4.38388996e-02f, -2.13964343e-01f, -1.11720257e-01f, -1.08548917e-01f, 2.13629022e-01f,
  2.27460451e-02f, 2.18886118e-02f, 2.55709678e-01f, 2.76599079e-01f, 1.47923812e-01f, 9.01893079e-02f, 9.76821780e-02f, 1.08809471e-01f, -8.03054869e-03f, -3.06182988e-02f,
  -1.96090471e-02f, 1.24757968e-01f, -9.64520350e-02f, -1.26831666e-01f, -2.11632513e-02f, 4.65482473e-02f, 1.01272091e-01f, 1.21816441e-01f, -1.36460448e-02f, 1.82644919e-01f,
  -7.11702257e-02f, 5.50769866e-02f, 2.92035546e-02f, 9.43837389e-02f, 9.23735276e-02f, 3.28561328e-02f, -1.55467764e-01f, 9.46531147e-02f, -2.02928893e-02f, 1.36518002e-01f,
  -6.85212165e-02f, -3.75513546e-02f, 7.82013088e-02f, -1.00256227e-01f, -5.80265078e-05f, 2.97720358e-02f, 5.10313250e-02f, 1.79058433e-01f, 1.32378295e-01f, -1.17882065e-01f,
  1.04967073e-01f, -6.83394969e-02f, -3.56586464e-02f, 3.34127806e-02f, -1.69108108e-01f, 2.77380228e-01f, -8.88725221e-02f, -9.15050060e-02f, -9.20205712e-02f, 1.24851521e-02f,
  -5.19236252e-02f, 2.73375422e-01f, -1.91682130e-02f, 4.70307544e-02f, 1.47440583e-01f, -9.36202854e-02f, 3.22249755e-02f, -5.66909611e-02f, 2.04730295e-02f, 2.97158957e-02f,
  2.37718560e-02f, -2.32853312e-02f, -1.28060624e-01f, 2.88247503e-02f, -6.49914071e-02f, 3.31512168e-02f, 8.97509679e-02f, 8.60125571e-02f, 1.39505386e-01f, 3.69006097e-02f,
  -7.44363070e-02f, 1.38366044e-01f, 3.87975089e-02f, -5.07710017e-02f, -3.46594900e-02f, -6.10354133e-02f, 7.68184438e-02f, -2.76088249e-02f, 7.00464025e-02f, 1.61021322e-01f,
  2.81134583e-02f, -1.60004869e-01f, 1.41503319e-01f, -5.66690750e-02f, -4.44648303e-02f, 7.79473633e-02f, -7.01591745e-02f, 6.81861416e-02f, -3.92914452e-02f, 1.41071454e-01f,
  1.44971490e-01f, -1.93632022e-01f, 1.04276277e-01f, -8.36863518e-02f, 1.99604034e-02f, 1.20528758e-01f, -1.58095405e-01f, -2.05671191e-01f, -8.14291909e-02f, 2.73150578e-02f,
  -4.86431317e-03f, -5.82672330e-03f, -1.06719382e-01f, 3.13357487e-02f, 3.44781205e-02f, 1.47657469e-01f, -5.41289821e-02f, -6.68246970e-02f, -6.94883242e-02f, 8.43017921e-02f,
  4.69624884e-02f, 5.85790463e-02f, -8.70834850e-03f, -1.29067823e-01f, -1.09042391e-01f, 1.52754292e-01f, 4.13762257e-02f, 1.44057661e-01f, 1.05598457e-02f, -4.93867099e-02f,
  3.14454325e-02f, -2.25738324e-02f, -1.28190115e-01f, 7.30169266e-02f, 1.05391294e-01f, 3.88225056e-02f, 3.07914466e-02f, 1.03954375e-01f, 2.22104955e-02f, 6.04308210e-03f,
  1.92310363e-01f, -2.28764340e-02f, 8.19426700e-02f, -8.71326309e-03f, 7.97847956e-02f, 1.42804727e-01f, 4.90787551e-02f, 8.39300379e-02f, -9.35881436e-02f, -2.98406426e-02f,
  3.23117115e-02f, -4.79450040e-02f, -1.07861154e-01f, 1.89477429e-01f, -1.73999704e-02f, 9.61830467e-02f, -1.22218981e-01f, 2.62588318e-02f, 4.83495556e-02f, 1.42075062e-01f,
  1.50121361e-01f, -4.07119617e-02f, 1.55360714e-01f, 8.15996826e-02f, -1.60960153e-01f, 8.28136057e-02f, 1.02889255e-01f, 1.97709084e-01f, -2.41844896e-02f, -1.11441530e-01f,
  1.06684446e-01f, 1.70166060e-01f, 5.13730273e-02f, 7.44519457e-02f, 2.37283781e-02f, 5.18189818e-02f, 1.59988046e-01f, -4.30705100e-02f, 1.80676337e-02f, 1.17508069e-01f,
  4.03079502e-02f, 1.19091749e-01f, 1.40073895e-02f, 3.47540081e-02f, -8.73387307e-02f, -2.23869346e-02f, 8.03941935e-02f, 4.31114022e-04f, 3.64283174e-02f, 1.37226596e-01f,
  8.83737877e-02f, 2.12637763e-02f, 1.38387486e-01f, 7.59850740e-02f, 5.44182546e-02f, 3.52565921e-03f, 1.09730199e-01f, 1.74152981e-02f, -5.04507683e-02f, -2.99369022e-02f,
  -5.85831329e-02f, 5.40108383e-02f, 4.00362052e-02f, 1.95953697e-01f, 1.61792580e-02f, -9.70753506e-02f, 3.22814882e-02f, -1.30037323e-01f, -4.36931364e-02f, 1.86034981e-02f,
  -1.10837199e-01f, -5.68840578e-02f, 2.37105954e-02f, -6.17746674e-02f, -3.18875760e-02f, 8.06755647e-02f, -1.16053730e-01f, 1.11206248e-01f, 1.83535162e-02f, -1.43469989e-01f,
  -2.20096763e-02f, 3.45876031e-02f, 3.70804854e-02f, 7.48798028e-02f, 4.61131334e-04f, -5.94772622e-02f, -8.78111497e-02f, 1.48704723e-01f, 3.55666429e-02f, -1.08174652e-01f,
  -5.78782521e-02f, -4.10786942e-02f, -1.33647963e-01f, -1.52010426e-01f, -1.32422149e-01f, 9.96196195e-02f, -6.32426739e-02f, 3.95088531e-02f, 2.50237305e-02f, 4.11867276e-02f,
  5.51478341e-02f, -2.62263343e-02f, 1.23629473e-01f, -6.31794333e-02f, 9.68510360e-02f, -9.06554908e-02f, 1.48708716e-01f, -3.72317806e-02f, -1.00324340e-01f, 5.51516488e-02f,
  -6.43734634e-02f, 4.22996506e-02f, 1.62439011e-02f, -9.34337527e-02f, -7.29652941e-02f, 7.06946999e-02f, -8.16244334e-02f, 1.06396228e-01f, 6.34556264e-02f, 2.36855783e-02f,
  1.31061107e-01f, -3.87685113e-02f, -6.97876215e-02f, -7.06818253e-02f, -1.27317971e-02f, -5.84227673e-04f, 1.27890361e-02f, 9.30833146e-02f, 1.02426738e-01f, -2.61898916e-02f,
  6.35071844e-02f, 1.52178198e-01f, 6.58890083e-02f, 7.87784755e-02f, 9.32633951e-02f, 3.11921127e-02f, 1.50854260e-01f, 1.16063148e-01f, 4.86733839e-02f, 1.83701545e-01f,
  1.92612216e-01f, 2.46470273e-01f, 9.15877670e-02f, -2.09454626e-01f, 6.82296306e-02f, -1.88942328e-01f, 1.48238376e-01f, 1.47544906e-01f, -8.68200958e-02f, -1.45062193e-01f,
  8.76086205e-02f, 7.18047246e-02f, -1.52736902e-01f, -4.23396081e-02f, -1.13900760e-02f, -9.71848425e-03f, -1.86989918e-01f, 2.82930166e-01f, -1.26702264e-01f, -1.89488679e-01f,
  -2.07027212e-01f, -5.95865063e-02f, 3.26707631e-01f, -2.84904331e-01f, 3.55011702e-01f, 1.11583881e-01f, -6.50205612e-02f, 1.83879539e-01f, 1.24120072e-01f, -5.74033260e-02f,
  -2.96680123e-01f, -1.45195797e-01f, 5.17695963e-01f, -3.03545520e-02f, -1.50156999e-02f, -7.58318976e-02f, -2.62670487e-01f, 8.87357220e-02f, -1.49745971e-01f, 3.86627048e-01f,
  -1.31077528e-01f, 3.11024766e-02f, 9.72215348e-05f, 1.08989157e-01f, 1.28348038e-01f, 7.73730204e-02f, -1.09920613e-01f, 1.16010547e-01f, -2.75126286e-02f, 8.55931714e-02f,
  3.06143045e-01f, -2.67121978e-02f, -1.40914589e-01f, -2.42217511e-01f, 4.49393876e-02f, -3.09783965e-02f, 9.04380679e-02f, 1.76706269e-01f, 1.32180840e-01f, 1.31428212e-01f,
  -1.01796851e-01f, 1.09531474e-03f, 7.63141513e-02f, -1.13040609e-02f, 8.07524025e-02f, 7.65048787e-02f, -3.04766260e-02f, 6.44651949e-02f, 9.45762619e-02f, -6.45222887e-03f,
  7.06021413e-02f, 8.22365806e-02f, -3.03529459e-03f, -8.56891423e-02f, -7.70591050e-02f, 2.22651772e-02f, 8.28449503e-02f, -2.29950203e-03f, 8.97144824e-02f, -2.64175422e-02f,
  -1.34392858e-01f, 2.74294848e-03f, -5.74955251e-03f, 7.13201538e-02f, -8.93194973e-02f, -7.13445395e-02f, -5.31446040e-02f, 5.04624378e-03f, -2.55463924e-02f, 5.23906499e-02f,
  1.02708049e-01f, 1.17345192e-01f, 7.17934370e-02f, -8.38050991e-02f, -1.41932964e-01f, 5.35706654e-02f, -3.51383770e-03f, -1.02127425e-01f, -1.28289506e-01f, 3.29145938e-02f,
  7.51625821e-02f, 2.38149822e-01f, 1.41793162e-01f, 1.12183191e-01f, -2.48591974e-02f, -1.80688128e-02f, 6.50316849e-02f, -1.29981218e-02f, -5.22091649e-02f, -9.52120945e-02f,
  1.38796985e-01f, -1.52560890e-01f, -6.72558099e-02f, -8.33740011e-02f, 1.23681709e-01f, 1.71395689e-02f, 1.17930613e-01f, -1.23807602e-01f, 6.11805022e-02f, -7.48928040e-02f,
  4.07402739e-02f, 1.13220558e-01f, -1.01280682e-01f, 7.66147226e-02f, 3.60399149e-02f, -4.37777601e-02f, 9.54863895e-03f, 1.33266419e-01f, 1.51153773e-01f, 2.00011488e-02f,
  -3.81928571e-02f, -1.20007768e-02f, 1.18251406e-01f, 2.64773071e-02f, -4.80761826e-02f, -4.50194068e-02f, 1.66693274e-02f, -5.73692471e-02f, 1.72257707e-01f, -6.89904094e-02f,
  4.44984026e-02f, 1.09767966e-01f, -7.66983777e-02f, 5.18145785e-03f, -7.32972920e-02f, -6.05712719e-02f, 2.87815537e-02f, 8.38510916e-02f, -5.68742529e-02f, 1.83288809e-02f,
  6.36685267e-02f, -8.03411976e-02f, -8.06378201e-02f, -9.08099953e-03f, 1.08784392e-01f, 2.14953534e-02f, -4.65051718e-02f, -4.20115478e-02f, -3.17184664e-02f, 1.04452163e-01f,
  3.93550657e-02f, -6.59639994e-03f, -1.18553108e-02f, 1.60579786e-01f, -1.14476494e-01f, 2.33385950e-01f, 1.69884831e-01f, -1.08985826e-01f, 1.79657284e-02f, 7.92317241e-02f,
  5.76672668e-04f, -5.25243059e-02f, -1.45734012e-01f, 8.11908841e-02f, -1.39645012e-02f, -9.91319343e-02f, -4.01587076e-02f, 6.63759112e-02f, 1.64691254e-01f, -1.07036904e-02f,
  1.51098266e-01f, -8.95601586e-02f, -1.50539160e-01f, 1.05779320e-01f, 6.36652559e-02f, 7.62437955e-02f, -9.36583430e-02f, 1.10385574e-01f, 1.14078239e-01f, 7.99290761e-02f,
  -7.69130662e-02f, -1.49698511e-01f, 1.06668219e-01f, 1.11187220e-01f, -9.78652481e-03f, 7.95074627e-02f, -9.09726173e-02f, 1.63897797e-02f, 1.24932237e-01f, 1.56050935e-01f,
  9.39067155e-02f, -1.99269593e-01f, -2.59052575e-01f, 2.51744181e-01f, 2.99006671e-01f, -3.09268624e-01f, 3.48375827e-01f, -8.81271288e-02f, -1.15359604e-01f, -5.27948095e-03f,
  -3.10734361e-02f, 3.37270685e-02f, 1.18848555e-01f, 8.88689384e-02f, 4.74260077e-02f, -1.61195267e-02f, 5.97317740e-02f, 6.36648992e-03f, 1.87235698e-02f, 1.16682088e-03f,
  5.13257645e-02f, 1.06221870e-01f, 1.51218534e-01f, -2.52037831e-02f, 1.56420261e-01f, -1.26748487e-01f, 1.70882627e-01f, -2.50366535e-02f, 3.86362746e-02f, 4.91132066e-02f,
  -1.33446744e-02f, -7.09297135e-03f, -8.21202174e-02f, -2.13566460e-02f, 1.12382472e-01f, 9.31501091e-02f, 3.14338744e-01f, 2.21413244e-02f, -1.03807531e-01f, -4.04094532e-02f,
  -7.14479610e-02f, -1.71783298e-01f, 4.57105003e-02f, 2.21298635e-01f, 2.40542933e-01f, -2.66033411e-01f, -7.69780502e-02f, 1.41541883e-01f, -3.02692689e-02f, 1.10035650e-01f,
  4.33463864e-02f, -3.69383879e-02f, 3.06982491e-02f, -5.10647446e-02f, -5.16577475e-02f, 2.09258329e-02f, -1.16245843e-01f, 1.16304837e-01f, -1.68069322e-02f, 1.19621847e-02f,
  -1.31237060e-01f, -1.70654655e-02f, 1.29023567e-01f, -8.14331230e-03f, 1.39237419e-02f, 3.84502709e-02f, -1.21557586e-01f, -6.70282394e-02f, 6.88427174e-03f, 6.52064905e-02f,
  9.85657871e-02f, -8.12467933e-03f, -1.46605432e-01f, -5.12458105e-03f, 8.04720223e-02f, 8.81734267e-02f, 1.38168531e-02f, 9.02899355e-02f, 6.25139521e-03f, -8.90818834e-02f,
  7.99537525e-02f, 2.79657338e-02f, -5.74548431e-02f, -6.43966347e-02f, -7.59780332e-02f, 1.57236382e-01f, 4.88273241e-02f, -7.48614147e-02f, -6.05515353e-02f, 6.25598729e-02f,
  -1.09960008e-02f, 6.30005077e-03f, -8.19268525e-02f, -1.26383007e-02f, -3.66709605e-02f, -2.56631020e-02f, -9.03113186e-02f, -8.43541101e-02f, 9.10678059e-02f, 4.29037027e-02f,
  1.23181351e-01f, -9.55223590e-02f, -8.99557918e-02f, 1.28388196e-01f, 7.20209181e-02f, 4.42995341e-04f, 4.62230621e-03f, 1.49237365e-01f, 5.26423231e-02f, 9.17388797e-02f,
  1.20519623e-01f, 3.19593847e-02f, -5.80206290e-02f, -1.04185417e-01f, -4.50139940e-02f, -2.35938579e-02f, -2.37048250e-02f, 6.73510730e-02f, -7.94542879e-02f, 5.51567934e-02f,
  1.29137309e-02f, -8.78420919e-02f, 2.08300389e-02f, -1.33177996e-01f, -5.14546037e-03f, -7.33060464e-02f, -6.55785426e-02f, 8.11405703e-02f, 9.85638648e-02f, -1.25370830e-01f,
  1.33517561e-02f, 1.42787844e-01f, 2.92853396e-02f, -3.01626744e-03f, 7.88254440e-02f, -8.26131478e-02f, -3.09349503e-02f, 7.18180016e-02f, 7.09963962e-02f, 5.24434671e-02f,
  -4.66024727e-02f, 3.23681347e-02f, 1.41602308e-01f, 6.68791449e-03f, -4.24151719e-02f, 1.69701520e-02f, 1.49635933e-02f, 1.66148953e-02f, 7.18669519e-02f, -6.07440360e-02f,
  -6.19980022e-02f, -2.07629129e-02f, 1.43162504e-01f, -1.23996466e-01f, 8.11183229e-02f, -5.03332503e-02f, 1.74937565e-02f, -3.86791751e-02f, 1.06893897e-01f, 1.88048154e-01f,
  1.10991567e-01f, 5.27159050e-02f, -1.03330888e-01f, 4.82285284e-02f, 4.57556956e-02f, 5.63235544e-02f, -9.63154137e-02f, 1.34430423e-01f, -4.71724533e-02f, -5.69103174e-02f,
  -7.14591444e-02f, 3.72232869e-02f, -1.13983408e-01f, -1.04740039e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  8.69994909e-02f, 2.60639619e-02f, 3.22956517e-02f, 1.62933737e-01f, -7.73057342e-02f, -6.62024096e-02f, -5.24518602e-02f, -2.52136588e-02f, 1.25855789e-01f, 1.02582850e-01f,
  1.04258396e-01f, 1.53428406e-01f, -4.43105064e-02f, 7.88912997e-02f, 8.28102529e-02f, 4.35430603e-03f, -6.57462776e-02f, 6.89397976e-02f, 3.97806242e-02f, -1.17589934e-02f,
  1.35488331e-01f, -6.83392137e-02f, 1.57719910e-01f, 8.60939994e-02f, -2.33259890e-02f, -4.85651903e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -3.27699155e-01f, 1.41293928e-01f, 1.57576770e-01f, -1.10838540e-01f, -1.21109940e-01f, -1.83744892e-01f, -2.46725768e-01f, 2.31802747e-01f, 1.71081126e-01f, -1.75183058e-01f,
  -2.16893703e-01f, -1.34290248e-01f, -1.50539368e-01f, -2.61180550e-01f, 2.22292125e-01f, -1.48796335e-01f, 4.18027043e-02f, 1.18642911e-01f, -2.63424963e-01f, -2.74829119e-01f,
  2.35133424e-01f, 9.11407173e-02f, 1.04485862e-01f, -1.10972002e-01f, 3.41856331e-01f, -1.54685542e-01f, -4.10985909e-02f, 5.01404107e-02f, 2.88849682e-01f, -1.92993656e-01f,
  -3.39684278e-01f, 3.67097999e-03f, 2.64917761e-01f, 2.23187506e-01f, 4.33947504e-01f, -3.91188830e-01f, 1.00701317e-01f, -2.69694269e-01f, -7.20233694e-02f, 3.19545746e-01f,
  2.56062508e-01f, -1.46815956e-01f, 1.88568756e-01f, -1.63880348e-01f, 1.06603839e-01f, 3.74380350e-01f, -2.16454312e-01f, 2.52570450e-01f, 2.12255850e-01f, -4.24937159e-01f,
  -1.22859962e-02f, -1.82682022e-01f, 2.28470117e-01f, -2.62688905e-01f, 3.80633958e-02f, -3.02191507e-02f, -5.25126513e-03f, 8.48612115e-02f, -3.22670788e-01f, -1.90063074e-01f,
  7.36868083e-02f, -7.24795088e-02f, -3.75009105e-02f, -2.75038853e-02f, -1.09414093e-01f, -6.50912225e-02f, -1.50134712e-01f, -1.31635308e-01f, 1.19982168e-01f, -3.73030573e-01f,
  9.17853266e-02f, 2.85430923e-02f, -6.28813803e-02f, 4.59514186e-02f, 3.65848318e-02f, -1.34105071e-01f, 1.60091650e-02f, 1.80632621e-01f, -3.96820158e-01f, -1.37035489e-01f,
  1.49993107e-01f, 1.01385459e-01f, -1.66021794e-01f, -1.38689801e-01f, -2.16240376e-01f, 8.05656239e-02f, -4.79732037e-01f, 7.75932288e-03f, -4.97473888e-02f, -5.36647700e-02f,
  -3.93135965e-01f, -3.83723527e-01f, 2.61582255e-01f, -3.07961047e-01f, 7.93878213e-02f, -9.34754163e-02f, 1.62303805e-01f, -3.75142187e-01f, 3.67845058e-01f, -1.12928726e-01f,
  -2.10161299e-01f, -2.65708447e-01f, -8.55150670e-02f, 8.17210302e-02f, 3.83136630e-01f, 8.95315260e-02f, -8.86662677e-02f, 9.47559066e-03f, 1.36446908e-01f, 5.00836194e-01f,
  4.67652410e-01f, -2.54417270e-01f, -1.20410547e-01f, -5.57705939e-01f, -1.65400103e-01f, -3.66295367e-01f, -5.29602692e-02f, 4.08071488e-01f, -1.55770287e-01f, -1.36735812e-01f,
  -4.46184427e-02f, -3.68457250e-02f, -2.10869476e-01f, 6.28811028e-03f, -1.03241272e-01f, -2.60255486e-01f, 5.92699163e-02f, 9.18204263e-02f, 3.43710065e-01f, 3.49697918e-01f,
  -3.70389462e-01f, 3.32642674e-01f, 3.46073598e-01f, 1.27126828e-01f, 1.91451266e-01f, -1.03317425e-01f, 3.58253181e-01f, 6.19472936e-02f, 8.07471052e-02f, 3.63503367e-01f,
  2.19379038e-01f, 3.90893131e-01f, 3.00762475e-01f, -2.46703014e-01f, 2.87058175e-01f, 1.34146795e-01f, 9.56711546e-02f, -4.56586987e-01f, 2.74834096e-01f, -7.98843205e-02f,
  2.27850184e-01f, 2.36945227e-01f, 1.79702207e-01f, -8.30659196e-02f, 5.24011910e-01f, -1.10147782e-01f, 7.86540434e-02f, -3.50606069e-02f, -5.53139374e-02f, -2.95554511e-02f,
  2.36197356e-02f, 6.73605576e-02f, -4.59964842e-01f, 1.68037131e-01f, 2.81128764e-01f, 4.14919317e-01f, -1.03161275e-01f, -1.71986893e-02f, -2.78540641e-01f, 2.27312148e-01f,
  -2.54400671e-02f, 1.47669002e-01f, 2.07386717e-01f, -6.34771213e-02f, 9.80791673e-02f, 3.02140415e-01f, 5.74246794e-02f, 1.24333827e-02f, 2.31475718e-02f, -8.13479498e-02f,
  -2.25834280e-01f, 4.93760079e-01f, -1.58369690e-01f, -8.90016407e-02f, -1.17090248e-01f, -8.57928172e-02f, -1.17905969e-02f, -1.66520074e-01f, 7.27602169e-02f, -3.24292898e-01f,
  5.41673368e-03f, -1.21615000e-01f, -6.84631988e-02f, 1.77531376e-01f, 2.79365182e-01f, -3.05090547e-01f, -1.64626345e-01f, 1.13075882e-01f, 3.24219912e-02f, 1.49010271e-01f,
  1.42987609e-01f, 1.14888646e-01f, 2.43168548e-01f, 2.85783082e-01f, 1.38493732e-01f, -1.11273833e-01f, 5.47227226e-02f, 1.96128548e-03f, 2.04579145e-01f, 2.65459925e-01f,
  1.50624886e-02f, -5.26029408e-01f, -1.65069595e-01f, 9.79008973e-02f, 1.72187880e-01f, -3.12924832e-01f, -3.44676316e-01f, -7.46816620e-02f, -3.91330719e-02f, -2.04664201e-01f,
  -9.42422152e-02f, -6.05411641e-02f, 2.67970800e-01f, -3.10201310e-02f, 3.87660116e-01f, 2.80368358e-01f, -1.21273570e-01f, -7.54751787e-02f, -1.41441643e-01f, -1.38303429e-01f,
  3.01463604e-02f, 4.75647360e-01f, -1.79074332e-01f, -5.06503209e-02f, 2.21230000e-01f, -1.20255062e-02f, 2.47142449e-01f, -3.98585707e-01f, -2.04997599e-01f, -1.88990206e-01f,
  -8.78596082e-02f, 2.57077843e-01f, 1.81261048e-01f, 6.86472118e-01f, -3.12599055e-02f, -2.64758915e-01f, -2.78504848e-01f, -1.03246227e-01f, -3.61465290e-02f, -2.35016085e-02f,
  -3.32703680e-01f, 1.35123916e-02f, -1.37453750e-01f, -5.10550477e-02f, -1.57053228e-02f, -1.51131257e-01f, -9.28266793e-02f, -2.94896096e-01f, 9.09929127e-02f, -2.46478721e-01f,
  2.37989604e-01f, 2.65478671e-01f, -1.57191887e-01f, 2.14188639e-02f, -1.13557369e-01f, 2.03432724e-01f, 1.24674641e-01f, 3.44136059e-01f, 1.40168875e-01f, -2.59574175e-01f,
  -9.34094563e-02f, 2.22129062e-01f, -1.48204580e-01f, -1.20446518e-01f, 2.91776478e-01f, -2.61455715e-01f, 3.75121623e-01f, -2.62973100e-01f, 1.61103293e-01f, 3.35910439e-01f,
  1.30909190e-01f, -2.29791597e-01f, 2.07296357e-01f, 5.23569167e-01f, -1.71626493e-01f, 4.98304237e-03f, -1.44323349e-01f, -2.60660261e-01f, 2.86114156e-01f, 1.10386990e-01f,
  -2.45201007e-01f, -2.79397070e-01f, 4.03494686e-01f, 3.36885899e-02f, 7.50719979e-02f, -3.25426042e-01f, -9.14587826e-03f, -1.44436806e-01f, 1.64607435e-01f, 5.05663119e-02f,
  -8.90362542e-03f, 2.47279793e-01f, -2.26717710e-01f, -5.55288941e-02f, 2.75960445e-01f, 7.16991201e-02f, 3.19379121e-02f, 5.49312890e-01f, 2.07183465e-01f, -1.88798949e-01f,
  1.51811376e-01f, -9.70235318e-02f, 1.41729102e-01f, 4.93172593e-02f, -3.31491411e-01f, 1.92808956e-01f, 2.34334603e-01f, -1.83854148e-01f, -7.69059509e-02f, 4.31809239e-02f,
  1.50345847e-01f, 1.80044577e-01f, -3.44905257e-01f, -4.48415615e-02f, 6.06250726e-02f, -3.80891204e-01f, 1.22602843e-01f, 3.79797041e-01f, -5.22326380e-02f, 7.97028393e-02f,
  9.38399434e-02f, -4.21616770e-02f, -3.00710410e-01f, 3.31892408e-02f, 1.46715090e-01f, 3.84537011e-01f, -1.13750830e-01f, 1.17730228e-02f, 2.97463685e-01f, -1.67064443e-01f,
  -2.30616704e-01f, -2.42251530e-01f, 3.60264629e-01f, 2.43187742e-03f, 3.66362005e-01f, -9.90336463e-02f, -2.71748245e-01f, -1.88749954e-01f, 2.43241340e-03f, 3.17979753e-01f,
  -4.10764903e-01f, -3.64983827e-01f, -3.83165702e-02f, -1.55595228e-01f, -1.61273852e-01f, 3.09147149e-01f, -1.69783488e-01f, -5.79611212e-02f, -4.95257862e-02f, 7.35546574e-02f,
  -2.05402315e-01f, -3.31044532e-02f, -9.44947526e-02f, 2.80710638e-01f, 4.44007516e-02f, 3.47803116e-01f, 1.18785508e-01f, -8.06488469e-02f, -8.03589299e-02f, 3.39656860e-01f,
  -6.45693615e-02f, -3.37286472e-01f, 4.16604936e-01f, -8.67173448e-03f, 3.23106319e-01f, -1.21348985e-01f, 2.26637498e-01f, -1.10187702e-01f, -3.70594382e-01f, 9.95715633e-02f,
  -1.96707428e-01f, -2.45004818e-01f, -9.96231362e-02f, -1.13059923e-01f, -4.13350761e-01f, 2.67993629e-01f, -2.95615494e-01f, -3.66584688e-01f, -3.85080427e-01f, 9.38110426e-02f,
  -6.39393926e-02f, -3.26746792e-01f, 1.79584488e-01f, 2.41965149e-02f, -2.35292450e-01f, -1.78767502e-01f, -1.13507330e-01f, -1.50570780e-01f, 6.02512211e-02f, -1.88442722e-01f,
  -4.11817953e-02f, -2.57661697e-02f, -2.75061578e-01f, 5.33555865e-01f, -4.92223613e-02f, -2.10763328e-02f, -2.75208801e-01f, 1.12758182e-01f, 5.10205552e-02f, 3.57159853e-01f,
  7.17591643e-02f, 1.69321060e-01f, 3.99223417e-02f, -2.47010738e-01f, 7.67385960e-02f, 2.38117978e-01f, -2.22105742e-01f, -7.17786923e-02f, -1.09301083e-01f, 3.64549868e-02f,
  2.53694743e-01f, -1.47898346e-01f, 9.18249413e-02f, -3.40981722e-01f, -1.09151915e-01f, 5.52462135e-03f, -1.88140403e-02f, -2.06468433e-01f, 1.17849289e-02f, 1.58714861e-01f,
  3.11602294e-01f, -1.81131408e-01f, -1.15272306e-01f, 1.09522799e-02f, 3.10706198e-02f, -3.67594630e-01f, -9.08621624e-02f, 1.78383619e-01f, 1.83403511e-02f, 2.54662931e-01f,
  -1.63331583e-01f, -1.07085094e-01f, 6.65019512e-01f, -1.74968727e-02f, -1.71392038e-01f, -2.86653936e-01f, -1.17161117e-01f, 1.09275803e-01f, -1.84791729e-01f, -2.48904750e-01f,
  2.49336883e-01f, 1.00033849e-01f, 1.94721907e-01f, -4.69632633e-02f, -9.42658409e-02f, 1.38922840e-01f, -9.62895080e-02f, 8.15170109e-02f, -1.48788262e-02f, -3.65512252e-01f,
  -2.20161732e-02f, 1.41553193e-01f, -6.29528891e-03f, 2.52404418e-02f, 6.01517819e-02f, 8.39179158e-02f, 1.90356076e-01f, 5.19253790e-01f, -2.25444362e-01f, 2.37197772e-01f,
  -1.93037644e-01f, 1.40127093e-01f, -2.71403968e-01f, 3.48343134e-01f, 3.13500971e-01f, -2.66918808e-01f, 5.46237171e-01f, 4.24862187e-03f, 4.09562409e-01f, -2.29291797e-01f,
  -1.10746250e-01f, -4.91785705e-02f, -1.31381512e-01f, -8.80026966e-02f, -3.73542309e-01f, -1.58731163e-01f, 9.50262770e-02f, 2.98419654e-01f, -1.40915468e-01f, -1.54614046e-01f,
  7.75347231e-03f, -3.26129720e-02f, 6.75458089e-02f, -6.09558336e-02f, -9.53080785e-03f, -8.37956183e-03f, -3.15250145e-05f, 1.07911028e-01f, 2.95090973e-01f, -2.28760138e-01f,
  -5.71921207e-02f, -3.05618256e-01f, -1.09221958e-01f, -2.29207858e-01f, 2.55673587e-01f, 1.55044943e-01f, 2.76044816e-01f, -1.41580671e-01f, -1.65466383e-01f, 3.97285670e-01f,
  2.28708178e-01f, 6.25287667e-02f, 1.17806844e-01f, -5.54103851e-01f, -3.84099297e-02f, 1.40629560e-01f, -1.71119139e-01f, -1.76703986e-02f, -1.75677463e-01f, -3.03838015e-01f,
  -2.90476710e-01f, -4.92954403e-02f, 1.11160989e-04f, -6.86134547e-02f, 2.49511406e-01f, -2.91514575e-01f, -3.31214249e-01f, 1.23018086e-01f, -1.58306971e-01f, -4.44406830e-02f,
  1.97159387e-02f, 1.83599904e-01f, -1.29720375e-01f, -2.38438398e-02f, -1.18198887e-01f, -2.32428700e-01f, 5.64509071e-02f, 3.58248681e-01f, -3.36472154e-01f, -6.79272488e-02f,
  -1.61481559e-01f, 2.51421720e-01f, -2.88477540e-01f, 2.08861962e-01f, -2.90826887e-01f, -1.43903434e-01f, 2.58848041e-01f, 2.19719276e-01f, -2.45131627e-01f, 1.05679929e-01f,
  1.70920223e-01f, -2.24366665e-01f, -5.23018949e-02f, 4.76875901e-01f, -4.02862318e-02f, 3.61276299e-01f, -9.03863981e-02f, -1.34887666e-01f, 1.19006254e-01f, -2.33846679e-02f,
  -6.24054410e-02f, -8.40971768e-02f, -7.93875903e-02f, -2.08786100e-01f, -4.07272339e-01f, 3.38624835e-01f, -1.76991329e-01f, -1.21171651e-02f, -9.50164944e-02f, 1.19526856e-01f,
  -2.49559164e-01f, 2.02874988e-02f, -2.80224299e-03f, 3.86179298e-01f, 8.49739015e-02f, -6.98407413e-03f, 4.82754767e-01f, 3.42816822e-02f, -9.17092487e-02f, 3.54838759e-01f,
  -2.58840650e-01f, 4.22385484e-02f, 1.32615864e-01f, -4.08639759e-01f, -8.75587165e-02f, -1.09198382e-02f, -1.32169008e-01f, -2.63666660e-01f, 1.25821427e-01f, 3.64543587e-01f,
  -1.60168365e-01f, 6.97984034e-03f, 1.91206679e-01f, -2.75405467e-01f, -2.12454647e-01f, 7.30498880e-02f, 3.05979192e-01f, 1.53013514e-02f, -2.43444845e-01f, 2.01592967e-01f,
  -1.02763347e-01f, -1.29508317e-01f, 1.14424877e-01f, 5.88524818e-01f, -1.36214092e-01f, -2.13525057e-01f, 1.63163751e-01f, 2.65000492e-01f, 3.89827222e-01f, 5.34296751e-01f,
  -1.60599262e-01f, -3.18850338e-01f, -3.46462126e-03f, 3.83386523e-01f, -5.09204669e-03f, -2.31001735e-01f, -1.70157943e-02f, -3.93929720e-01f, -6.40417486e-02f, -1.41443059e-01f,
  1.50051583e-02f, 2.26881012e-01f, 1.38399467e-01f, 8.86866301e-02f, 1.13107741e-01f, -3.53768282e-02f, -2.35333517e-02f, 3.84090990e-01f, -2.36763880e-01f, -1.78351283e-01f,
  1.35427922e-01f, -5.30481301e-02f, 9.92506817e-02f, -5.97910509e-02f, 5.84846377e-01f, -3.41887474e-02f, 1.91813096e-01f, -1.37055531e-01f, 2.58037150e-02f, -3.95068387e-03f,
  3.04030240e-01f, 1.52212828e-01f, 3.01878780e-01f, 1.21260554e-01f, -2.58955508e-01f, 2.58580804e-01f, 7.44339973e-02f, 8.61131400e-02f, -1.51611120e-01f, -1.42096311e-01f,
  -2.93968111e-01f, 9.18091834e-02f, 2.47710082e-03f, 1.07285336e-01f, 1.55869454e-01f, 1.79282546e-01f, -1.34036075e-02f, -2.23298743e-02f, -1.75917186e-02f, 3.60917710e-02f,
  -1.04620405e-01f, 3.47654879e-01f, 1.88457400e-01f, -1.34072140e-01f, 4.48233671e-02f, 1.37554556e-01f, -4.93811101e-01f, -2.78187186e-01f, -3.44560534e-01f, 3.71739805e-01f,
  -4.59190398e-01f, -1.48293748e-01f, -3.52135777e-01f, -1.96042687e-01f, 1.81501642e-01f, 1.61828712e-01f, -1.30431712e-01f, -5.07085845e-02f, -5.69331683e-02f, -1.01208709e-01f,
  8.05280358e-02f, -1.56409964e-01f, 1.73470244e-01f, 2.30723582e-02f, 2.32046470e-03f, -3.05783242e-01f, -3.77669394e-01f, -1.68124437e-01f, -1.67588815e-01f, 1.29751340e-01f,
  2.11747676e-01f, 2.60323048e-01f, 6.04994595e-01f, -1.27417132e-01f, 2.94689517e-02f, 2.10889980e-01f, 4.31718007e-02f, 7.66281337e-02f, -3.23620230e-01f, 1.76063851e-01f,
  1.63515359e-01f, 2.02664331e-01f, -3.13364305e-02f, -6.24734201e-02f, -1.22769728e-01f, -6.84350170e-03f, 1.75416067e-01f, -3.89423743e-02f, 2.57560611e-01f, 3.85680050e-02f,
  -2.22337529e-01f, 1.25353679e-01f, 5.70781380e-02f, -1.38942465e-01f, 7.54144043e-02f, 4.18541655e-02f, -3.23409140e-01f, -3.21498603e-01f, 6.40458763e-02f, -1.98675126e-01f,
  -2.36528218e-01f, 7.52454624e-02f, -3.86254877e-01f, 3.01901400e-01f, -1.20442271e-01f, 2.00242475e-01f, -1.26262411e-01f, 2.32209653e-01f, -2.94774950e-01f, 2.36830667e-01f,
  1.04495898e-01f, -1.32539973e-01f, -3.05489153e-01f, 3.43446076e-01f, 2.30344906e-01f, 4.41703767e-01f, 3.42897624e-02f, -1.90106124e-01f, -9.37222242e-02f, 1.73215032e-01f,
  1.24516435e-01f, 2.32974067e-01f, 1.02735519e-01f, -2.23078698e-01f, -6.19013906e-02f, 2.93551594e-01f, 9.18032452e-02f, 1.63318336e-01f, -1.41989648e-01f, -2.42959559e-01f,
  -1.28740370e-01f, -1.89142108e-01f, -4.63111363e-02f, 3.93486023e-01f, -1.04515553e-01f, 6.31324500e-02f, -2.47438580e-01f, -6.85904697e-02f, 3.88983488e-02f, 1.41905010e-01f,
  -5.77673726e-02f, -9.32348240e-03f, 3.97874057e-01f, 2.42070585e-01f, 1.16374204e-02f, 3.41584682e-01f, -2.72693392e-02f, 4.65311147e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  5.27232178e-02f, 4.97357659e-02f, 4.52994406e-02f, 1.02050249e-02f, -7.07184225e-02f, 1.22145586e-01f, -8.23050812e-02f, 2.45276373e-03f, 6.51125386e-02f, -2.90112123e-02f,
  -8.49044695e-02f, 3.90560366e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    