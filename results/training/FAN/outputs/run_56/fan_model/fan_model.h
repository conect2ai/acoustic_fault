/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.24628347e-01f, 6.41137883e-02f, -9.83262658e-02f, -1.02357574e-01f, 3.24114680e-01f, 5.93149304e-01f, -8.97333622e-02f, 3.45376521e-01f, 2.05004841e-01f, -2.34951213e-01f,
  1.24291070e-01f, -3.10893327e-01f, -1.05737977e-01f, 8.47439393e-02f, 2.78734744e-01f, -1.52657822e-01f, 2.23677129e-01f, -5.53140119e-02f, 2.13999614e-01f, 2.22262055e-01f,
  6.62292093e-02f, 1.51363000e-01f, -1.82305411e-01f, 2.87688285e-01f, 1.27161801e-01f, 7.23158717e-02f, -1.41788006e-01f, -1.94027051e-01f, 3.52178738e-02f, -4.55396697e-02f,
  2.45195135e-01f, 1.57975275e-02f, -1.20423637e-01f, 1.52813960e-02f, 1.02096841e-01f, -2.91080754e-02f, -1.14295438e-01f, -1.13376699e-01f, -4.51314375e-02f, 6.63045496e-02f,
  -8.36117938e-02f, 1.64123058e-01f, -1.13213826e-02f, -8.41491148e-02f, -4.39183451e-02f, -3.30605432e-02f, 3.52448486e-02f, 3.19851227e-02f, -2.37344410e-02f, -4.18584310e-02f,
  -2.54616374e-03f, -5.08436300e-02f, -2.02777795e-02f, -2.59512989e-03f, 4.24639583e-02f, -9.34764859e-04f, -6.33169413e-02f, -6.68894276e-02f, 5.24253882e-02f, 7.64336735e-02f,
  6.23032004e-02f, -5.41046150e-02f, -7.43122846e-02f, -4.98587713e-02f, 2.77097039e-02f, 8.67897719e-02f, -1.13451228e-01f, -5.03866114e-02f, -1.38705537e-01f, -3.95657159e-02f,
  8.12076703e-02f, -7.65596330e-02f, 5.57726026e-02f, -2.61325315e-02f, -1.41682317e-02f, -2.75069624e-02f, -1.46691669e-02f, 3.88057679e-02f, 1.54598385e-01f, -4.27124165e-02f,
  -1.03665655e-02f, 9.74599719e-02f, -3.50835100e-02f, -4.66387011e-02f, 6.07038327e-02f, -5.68990149e-02f, 3.87912467e-02f, 6.40610531e-02f, -5.07899374e-02f, 4.51271087e-02f,
  1.48688272e-01f, 3.20181437e-02f, -2.87622381e-02f, 2.64980830e-02f, -1.09845102e-01f, -3.84196676e-02f, -2.20432356e-02f, 6.51024207e-02f, 5.48548512e-02f, 1.13885075e-01f,
  4.87606078e-02f, -7.42130205e-02f, 1.44560888e-01f, 5.27633429e-02f, -5.01760095e-02f, 1.10870926e-02f, -9.32201073e-02f, -1.79838203e-02f, 2.26324238e-02f, -4.21574339e-02f,
  -6.17880200e-04f, 5.08580320e-02f, -2.56116930e-02f, 1.35049537e-01f, -2.37843543e-02f, 2.69662123e-03f, -6.92911725e-03f, -6.64484426e-02f, -8.97151083e-02f, -5.71508743e-02f,
  9.54644531e-02f, 1.40151069e-01f, -2.10008845e-01f, -5.76952659e-03f, -6.16881363e-02f, 4.78782296e-01f, 1.86945274e-01f, 9.16636437e-02f, -2.34679997e-01f, 2.44270548e-01f,
  2.62877196e-01f, -2.80214101e-01f, 2.35575035e-01f, 3.08674186e-01f, 1.66187778e-01f, 1.65243506e-01f, 2.52603292e-01f, 1.06270105e-01f, -1.72052518e-01f, 4.49132062e-02f,
  4.84573618e-02f, 2.73732662e-01f, 1.99030176e-01f, -5.12074232e-02f, 1.79853290e-01f, -8.63023326e-02f, 2.35565811e-01f, -9.29228738e-02f, 1.11509994e-01f, -2.16158088e-02f,
  1.38144925e-01f, -1.09847955e-01f, -8.70367698e-03f, -7.28998939e-03f, 8.38628113e-02f, 3.83814313e-02f, 2.85630245e-02f, -3.07806879e-02f, -3.10512111e-02f, -1.11434922e-01f,
  -1.15604671e-02f, -9.06600058e-02f, 1.92441437e-02f, -1.21220812e-01f, 4.21570003e-04f, -2.51899194e-02f, -9.50237513e-02f, -2.37423498e-02f, -1.16846912e-01f, 2.22871229e-02f,
  -7.14985430e-02f, -2.35437434e-02f, 1.12921946e-01f, 5.79644972e-03f, -4.47695814e-02f, -1.05818003e-01f, -6.04377985e-02f, -1.66406110e-02f, 7.90760070e-02f, -7.69688934e-02f,
  -8.53120070e-03f, 2.83810701e-02f, 3.98203842e-02f, -9.92862415e-03f, -2.13899650e-02f, -2.57252995e-02f, -9.17767175e-04f, 2.11693048e-02f, -5.57308160e-02f, 7.35769123e-02f,
  -1.83515158e-02f, 2.19538901e-02f, -4.57989275e-02f, -8.86983052e-03f, 6.02965429e-02f, 5.55350147e-02f, -1.20433234e-02f, -6.17234968e-02f, 8.13118815e-02f, -9.28878561e-02f,
  -7.06771836e-02f, 4.73249517e-02f, 7.05156848e-02f, 1.16427593e-01f, 3.23105939e-02f, -2.22497042e-02f, 5.01347855e-02f, -3.14513431e-03f, 3.63586918e-02f, 6.32675961e-02f,
  3.82164717e-01f, 2.82516778e-01f, 2.08491795e-02f, -2.51158457e-02f, 5.66354999e-03f, 5.30931726e-02f, -2.74727102e-02f, -1.44715300e-02f, 8.65899548e-02f, 5.70443757e-02f,
  4.21367586e-02f, 2.70464774e-02f, 1.60344895e-02f, 5.30352630e-02f, -5.35002118e-03f, 2.62462869e-02f, 7.13663325e-02f, 6.14596978e-02f, 1.62270203e-01f, 6.45957664e-02f,
  8.10562745e-02f, -2.97280640e-04f, -8.87982622e-02f, 5.50871938e-02f, 2.42592115e-02f, 5.44703528e-02f, -3.29506882e-02f, -1.34852245e-01f, -2.26276908e-02f, 7.20613077e-02f,
  4.96104509e-01f, 7.18936883e-03f, 2.89442003e-01f, 3.09028029e-01f, 3.57176736e-02f, 9.65516865e-02f, 4.75104377e-02f, -9.29489583e-02f, 1.79389305e-02f, -3.43492985e-01f,
  -5.04949465e-02f, -1.09451367e-02f, -4.37226504e-01f, 2.97935069e-01f, 4.48410213e-01f, -3.56755525e-01f, 2.96894193e-01f, -2.26012222e-03f, -6.88648224e-02f, -4.14447151e-02f,
  1.73436850e-01f, -7.92366173e-03f, 3.94885205e-02f, -9.87898931e-02f, 1.40785173e-01f, 1.92636907e-01f, 1.88290715e-01f, 2.56798565e-02f, 4.23261762e-01f, 1.77239746e-01f,
  -8.04955885e-02f, -1.68963164e-01f, 8.66295472e-02f, 3.49455066e-02f, 2.85989419e-02f, -1.74368415e-02f, 1.20414577e-01f, -8.28567520e-03f, 6.86564520e-02f, -8.72408673e-02f,
  -3.13024782e-02f, 3.88334952e-02f, 3.49114230e-03f, -1.25572653e-02f, 9.64649022e-02f, 5.34942485e-02f, 4.73314263e-02f, 1.52744714e-03f, 7.59900594e-03f, 2.71335319e-02f,
  1.52123468e-02f, 1.33162569e-02f, 9.25830826e-02f, -1.02730496e-02f, 1.87374994e-01f, 5.18966801e-02f, 1.32124461e-02f, 3.88502255e-02f, 6.17723353e-03f, 3.77158374e-02f,
  3.45645510e-02f, -1.36868292e-02f, -4.95398603e-02f, -8.02826211e-02f, -2.36017108e-02f, 8.66074208e-03f, 4.11252752e-02f, -4.99898344e-02f, 9.42901000e-02f, -8.27821568e-02f,
  1.68957952e-02f, 3.43227037e-03f, -8.96508247e-03f, -2.00814405e-03f, 1.10761207e-02f, -5.83644621e-02f, -4.26133573e-02f, -2.70203128e-02f, -1.76465623e-02f, 1.84684452e-02f,
  -4.32174690e-02f, 6.40661940e-02f, -4.44535464e-02f, 5.42486645e-02f, -4.51341830e-02f, 4.14690338e-02f, 6.27368614e-02f, 7.88295344e-02f, -6.72222376e-02f, 2.64762305e-02f,
  8.38223547e-02f, 1.32157102e-01f, -5.18113263e-02f, -2.59387009e-02f, -5.93207031e-03f, 7.84220360e-03f, -7.33130146e-03f, 1.09889798e-01f, 7.65081570e-02f, -2.54563503e-02f,
  -3.31574827e-02f, -3.35865393e-02f, 1.66929495e-02f, 3.29165310e-02f, -3.04096583e-02f, 1.70384534e-02f, -1.70628224e-02f, 5.16928558e-04f, 5.64149804e-02f, -8.01649503e-03f,
  1.20844468e-02f, -1.36072144e-01f, -4.51489910e-02f, -1.88369993e-02f, -1.38690677e-02f, -5.74022233e-02f, 5.80081977e-02f, 3.38245295e-02f, 3.02829556e-02f, -1.49792284e-02f,
  -3.28787237e-01f, 1.34784818e-01f, -3.40024799e-01f, -1.68018848e-01f, -1.68638289e-01f, -2.08021209e-01f, -9.21348855e-02f, -1.94941044e-01f, 5.95395379e-02f, 2.17263192e-01f,
  5.84227964e-02f, 1.39481947e-02f, 8.76065344e-02f, 3.93416375e-01f, -1.59539819e-01f, 3.84291649e-01f, -4.46629860e-02f, 1.11963421e-01f, 1.55818045e-01f, -2.20656633e-01f,
  -1.46788269e-01f, 1.77031115e-01f, -2.63461858e-01f, 1.14139400e-01f, -2.43020669e-01f, -2.34099120e-01f, -1.34998947e-01f, -6.02850094e-02f, -2.84598898e-02f, 1.19376257e-01f,
  1.65669948e-01f, 1.55146196e-01f, -1.02467008e-01f, 5.28506190e-02f, -2.83454716e-01f, 1.52829895e-02f, -5.47480360e-02f, 5.87452166e-02f, -1.44542241e-02f, 3.34545858e-02f,
  4.13662046e-02f, -9.91259422e-03f, 4.14771251e-02f, 4.12256038e-03f, 1.88334528e-02f, 3.67949419e-02f, 1.57446135e-02f, -3.93192237e-03f, 6.77306205e-02f, -8.60356316e-02f,
  1.78746786e-02f, 3.48899513e-02f, -7.65164569e-02f, 1.00878756e-02f, -1.27732784e-01f, -2.81710289e-02f, -5.56208827e-02f, -2.08057627e-01f, 9.32442769e-02f, -9.29649025e-02f,
  -4.37498689e-02f, -5.30228764e-02f, 7.57063478e-02f, 1.09512255e-01f, 4.77037132e-02f, 4.87011261e-02f, 7.32192993e-02f, 6.40533119e-02f, -3.71650904e-02f, -9.08905920e-03f,
  -9.77023877e-03f, 1.01218903e-02f, 8.04837719e-02f, -9.65270326e-02f, -6.76060319e-02f, 2.20928583e-02f, 5.14058135e-02f, 1.42292362e-02f, -1.74657330e-01f, 3.25846151e-02f,
  1.80700272e-01f, -2.68674418e-02f, -1.09847128e-01f, 3.27059254e-03f, 1.15043610e-01f, -1.68272167e-01f, 2.00591628e-02f, 1.75813176e-02f, -6.76302821e-04f, -6.02942407e-02f,
  7.42505537e-03f, -1.98667303e-01f, -1.33761819e-02f, 9.11273584e-02f, 2.30091244e-01f, 9.01498199e-02f, 1.02088377e-01f, 3.90982348e-03f, -4.96937719e-04f, 6.97446987e-02f,
  -1.22669607e-01f, 6.73119584e-03f, -6.23435900e-02f, 4.46708314e-02f, 3.42075713e-02f, -8.40603858e-02f, -2.06237771e-02f, 2.95541883e-02f, -6.88237175e-02f, -5.03890142e-02f,
  -1.08334318e-01f, -7.71389082e-02f, 2.82527264e-02f, 2.39975546e-02f, -8.09704326e-03f, -7.38505879e-03f, -4.78745326e-02f, 6.36344915e-03f, 1.71894114e-02f, 9.08729807e-02f,
  -4.48827028e-01f, -2.09976509e-01f, -3.74408692e-01f, 1.10692620e-01f, 5.89445187e-03f, 4.87749219e-01f, 3.21164310e-01f, -3.23339663e-02f, -1.26381591e-01f, 2.85410374e-01f,
  2.49778762e-01f, -5.46661392e-02f, -6.90426603e-02f, 3.62558424e-01f, 7.36416206e-02f, 7.58717215e-05f, 8.27163607e-02f, 3.09353955e-02f, -1.30650520e-01f, -1.85219884e-01f,
  -1.32938743e-01f, 2.87294090e-01f, 6.19711280e-02f, -3.62195298e-02f, 5.60116172e-02f, -4.86638658e-02f, 6.35998249e-02f, -7.66370371e-02f, 1.48069382e-01f, 2.20763803e-01f,
  -7.29879290e-02f, -2.65050173e-01f, -5.27144819e-02f, -2.20269407e-03f, 5.24113290e-02f, -9.55373421e-03f, -1.76586043e-02f, 1.29719386e-02f, -4.95634675e-02f, 1.78863257e-02f,
  8.73652771e-02f, -1.85857490e-02f, 1.22702926e-01f, 2.80053541e-02f, -9.33272615e-02f, -1.91647876e-02f, -6.88586682e-02f, 2.79203267e-03f, -8.17267522e-02f, -7.31260108e-04f,
  -1.19980387e-02f, -1.19217029e-02f, -8.29986669e-03f, 1.89954378e-02f, -3.94499190e-02f, 8.18036497e-02f, -5.28931729e-02f, -4.46620025e-02f, -9.19562858e-03f, -1.94220003e-02f,
  6.17916435e-02f, -4.22157682e-02f, -2.98181828e-03f, 5.69762848e-02f, -7.56896287e-02f, 2.55214460e-02f, -5.91235906e-02f, -3.82759087e-02f, -1.59937833e-02f, -4.46858630e-02f,
  -4.05474054e-03f, -7.62833580e-02f, 2.75101289e-02f, 2.59623155e-02f, -3.56546929e-03f, -4.04388458e-02f, -5.21247834e-02f, 1.03955075e-01f, -9.49953124e-02f, 4.65446599e-02f,
  -9.88078304e-03f, -5.26419133e-02f, 4.38108249e-03f, 1.27058346e-02f, 5.98252751e-02f, 7.10785910e-02f, 3.55913229e-02f, -8.60419124e-02f, 4.56100106e-02f, 6.15703464e-02f,
  -1.57721147e-01f, -9.33621824e-02f, 1.29750356e-01f, 6.42709550e-04f, 3.53757776e-02f, 3.99585776e-02f, 1.40267201e-02f, 4.44477014e-02f, -9.06359521e-04f, -2.35218965e-02f,
  6.86203763e-02f, 1.56780891e-02f, -3.69523391e-02f, 1.12074148e-02f, -3.10729332e-02f, 7.25022331e-02f, 2.89967339e-02f, 3.26113999e-02f, 2.31178440e-02f, -3.33829387e-03f,
  -1.79316476e-02f, -6.87538832e-02f, 4.10296349e-03f, 3.80202495e-02f, 2.98241284e-02f, 5.50188757e-02f, -3.35598178e-02f, 8.84013157e-03f, -2.93765888e-02f, -3.72074428e-03f,
  3.03208262e-01f, 3.48179549e-01f, -3.52332115e-01f, 1.31343320e-01f, 2.05732994e-02f, -2.25997925e-01f, -2.65233934e-01f, 1.20771624e-01f, 5.34983017e-02f, 3.19922864e-01f,
  1.65428758e-01f, 1.64958596e-01f, 6.08206727e-02f, -9.15314779e-02f, -1.11687906e-01f, -2.57711321e-01f, 5.63461073e-02f, 1.12919964e-01f, -1.64002061e-01f, 2.10376173e-01f,
  -1.06655784e-01f, 3.45811397e-02f, -1.62871659e-01f, -1.74057469e-01f, 9.21500623e-02f, 3.88950892e-02f, 1.34145275e-01f, -2.84818143e-01f, 1.00740373e-01f, -9.83798504e-02f,
  -7.61183500e-02f, -4.46937466e-03f, 2.44308170e-02f, 2.02651089e-03f, -2.03413162e-02f, 1.52155980e-02f, 3.59622315e-02f, -8.63207355e-02f, -7.55453929e-02f, 2.33648065e-02f,
  2.61088014e-02f, 4.50079627e-02f, -1.12847164e-01f, -6.53500333e-02f, 7.24515319e-02f, 2.12772060e-02f, -1.41474151e-03f, 1.20230451e-01f, 1.04747498e-02f, -7.17588291e-02f,
  -8.15134123e-02f, 2.43115686e-02f, -1.88400745e-02f, 8.56538564e-02f, -9.55660269e-02f, -9.01638493e-02f, -1.23092905e-01f, 3.95464078e-02f, 7.76001438e-02f, -2.07126997e-02f,
  -6.46559671e-02f, 6.48970157e-03f, -3.85116600e-03f, -7.24988282e-02f, 1.01790866e-02f, 2.20538732e-02f, -1.81002170e-02f, 2.93534398e-02f, 3.67261879e-02f, 4.75622490e-02f,
  3.00586633e-02f, 9.64300781e-02f, 2.90772598e-02f, 5.29390834e-02f, 1.99580099e-02f, 1.65577307e-02f, -4.19395044e-02f, 7.00980052e-02f, 2.03184839e-02f, 5.03283590e-02f,
  -2.68259570e-02f, -4.98413518e-02f, 1.18404970e-01f, 8.27084705e-02f, -2.04363074e-02f, 7.63627365e-02f, 5.53628430e-02f, 1.21432602e-01f, -4.76988815e-02f, -6.31895065e-02f,
  2.81766087e-01f, 3.45466405e-01f, -8.84872153e-02f, 7.96453133e-02f, -1.36742536e-02f, 6.67549297e-02f, -1.30454168e-01f, 2.39111874e-02f, -4.82720397e-02f, -3.71978320e-02f,
  1.26661211e-02f, 4.45591472e-02f, 1.42856911e-01f, 4.54550125e-02f, -1.03452377e-01f, 4.97309193e-02f, 4.86393273e-02f, 2.87159197e-02f, 3.80803831e-02f, 9.31860805e-02f,
  1.41264409e-01f, 8.84896517e-03f, -2.98579242e-02f, 2.58307345e-02f, -5.00880145e-02f, 7.71741271e-02f, 1.59881786e-01f, -1.20888248e-01f, 1.31133124e-02f, -1.02656437e-02f,
  -3.74292403e-01f, -3.79543036e-01f, -3.00710917e-01f, -1.45731494e-01f, 1.11407116e-01f, 3.35861981e-01f, 3.49559076e-02f, 1.90653965e-01f, 2.95640200e-01f, 2.96129026e-02f,
  -2.55582072e-02f, -4.40508813e-01f, -1.69775039e-01f, -2.07856577e-03f, 4.99323457e-02f, 7.99168199e-02f, 1.27478674e-01f, -1.54485732e-01f, -9.86214802e-02f, -1.43998310e-01f,
  7.55102262e-02f, 2.18452707e-01f, -5.99422567e-02f, 7.27115497e-02f, -2.13154927e-01f, -2.80846804e-01f, -2.03613177e-01f, -1.80891126e-01f, -5.25253713e-02f, -1.10608656e-02f,
  8.11368152e-02f, 2.15801381e-04f, 7.89632276e-02f, 6.89037843e-03f, -7.59550631e-02f, 9.52959880e-02f, -1.02349713e-01f, -6.22892976e-02f, 1.36517212e-02f, -1.06808528e-01f,
  2.71608029e-02f, 9.12157223e-02f, 6.24619089e-02f, 9.73092467e-02f, 4.94389236e-02f, 5.96299060e-02f, 1.14222392e-01f, -5.37272729e-03f, -6.38082027e-02f, -5.08328602e-02f,
  2.64586210e-02f, -4.77621303e-04f, 2.52124970e-03f, -1.44352969e-02f, -8.00714940e-02f, 6.05396032e-02f, -2.96545271e-02f, -7.00063705e-02f, 3.62215750e-02f, 9.99920629e-03f,
  1.07788153e-01f, -1.22612687e-02f, 4.65540849e-02f, -3.10656540e-02f, -1.81416497e-02f, -3.48464143e-03f, 4.88997847e-02f, -3.57674360e-02f, -2.75956234e-03f, -8.37768838e-02f,
  -2.04123650e-02f, -3.00586130e-02f, 6.84488639e-02f, -3.07631809e-02f, -3.04674674e-02f, 1.87800359e-02f, 1.77570749e-02f, -1.38457194e-01f, -2.35162266e-02f, 7.57761896e-02f,
  1.07018452e-03f, 3.06467041e-02f, -5.04187718e-02f, 2.24639364e-02f, -9.81122628e-03f, 3.09221167e-02f, 9.61435944e-05f, -8.23116750e-02f, 5.19102663e-02f, -1.98618975e-03f,
  -2.34958708e-01f, -2.84299046e-01f, -2.66109090e-02f, 3.38553153e-02f, 9.36258398e-03f, -1.20186672e-01f, 8.44339952e-02f, 1.09646752e-01f, -1.27987921e-01f, 6.84724096e-03f,
  -8.02384932e-07f, -3.67810577e-02f, -4.24412894e-04f, 7.65995085e-02f, 5.68784811e-02f, -3.04597057e-02f, 2.91343220e-02f, -1.05492197e-01f, 7.59454519e-02f, -5.58277555e-02f,
  -9.01419446e-02f, -7.79620856e-02f, 6.98132515e-02f, 8.11690018e-02f, 9.34752375e-02f, -1.47504359e-01f, -5.06313704e-02f, 6.26620501e-02f, 2.73692869e-02f, 3.45338918e-02f,
  -2.83787340e-01f, 3.24478149e-01f, 4.08409894e-01f, -7.14021772e-02f, -9.49706323e-03f, -1.63432211e-02f, -3.30646098e-01f, 2.02908516e-01f, -2.82529533e-01f, -2.90323477e-02f,
  -3.51886719e-01f, 3.78070921e-02f, -3.38230252e-01f, -1.73445627e-01f, -3.89680833e-01f, -3.42790723e-01f, -4.92768995e-02f, -3.97296436e-02f, -4.68903556e-02f, 2.73917951e-02f,
  8.95637611e-04f, -1.43448561e-01f, 5.14223762e-02f, 2.93476194e-01f, 1.70495398e-02f, 2.78389275e-01f, -1.54077411e-01f, 1.79083541e-01f, 1.39589056e-01f, 1.00465082e-02f,
  -3.91184092e-02f, -6.99194372e-02f, 1.41585857e-01f, 8.30972940e-02f, -4.80529442e-02f, 1.80379115e-02f, 4.82063703e-02f, 6.21921122e-02f, 2.57486422e-02f, 5.44131063e-02f,
  -7.60286003e-02f, 2.76680267e-03f, 5.08913770e-02f, -1.05439033e-02f, -1.64236091e-02f, 1.02405578e-01f, -2.90138032e-02f, -2.39862204e-02f, 6.05636239e-02f, -1.44210160e-01f,
  -9.62437317e-02f, 1.18158143e-02f, -1.62172019e-01f, -6.29513487e-02f, -1.70195121e-02f, -8.18871632e-02f, 4.23783883e-02f, 1.48854312e-02f, -8.65884274e-02f, -2.16731057e-03f,
  -6.79706335e-02f, 4.71140584e-03f, 3.16771045e-02f, 2.90220361e-02f, 5.14957085e-02f, 1.42168356e-02f, -4.72188517e-02f, -2.21367478e-02f, 2.37160898e-03f, -6.30467758e-02f,
  3.56877297e-02f, 2.43056584e-02f, 1.98017946e-03f, -2.04294501e-03f, -3.98857407e-02f, 2.04294138e-02f, 1.34641333e-02f, -5.13533242e-02f, -9.65944529e-02f, 2.04000771e-02f,
  -4.78770360e-02f, -5.81712201e-02f, 5.67192473e-02f, -6.34003952e-02f, -1.57226715e-02f, -1.07443921e-01f, -1.54185742e-02f, 8.17646608e-02f, 4.57246117e-02f, -4.05077748e-02f,
  -7.68405199e-02f, -4.31957319e-02f, -2.77437586e-02f, 5.85188754e-02f, 3.52556296e-02f, 5.37186228e-02f, 1.62583403e-02f, 1.72001291e-02f, 7.95134902e-02f, -3.29960547e-02f,
  7.82187358e-02f, 6.41391724e-02f, 6.95123971e-02f, -2.87260432e-02f, 6.12947866e-02f, -5.18222861e-02f, 5.16014546e-03f, 5.11535928e-02f, 3.48019823e-02f, 3.32874730e-02f,
  7.09905177e-02f, -1.11501597e-01f, 1.01137020e-01f, 8.24205279e-02f, 6.61737518e-03f, -2.64685340e-02f, 2.15792768e-02f, -2.84609515e-02f, -3.57086472e-02f, -6.71842918e-02f,
  -8.64622965e-02f, 3.68995070e-02f, 1.05675288e-01f, -2.07247958e-01f, 2.41975188e-01f, -9.94347855e-02f, -1.57872885e-01f, 6.80716783e-02f, 3.15704226e-01f, -2.50201762e-01f,
  -7.36480057e-02f, -2.81089038e-01f, -4.01544645e-02f, -1.77848667e-01f, -3.18652421e-01f, 1.53081447e-01f, -1.02104828e-01f, -1.63346857e-01f, 3.64070922e-01f, -7.07944855e-02f,
  9.24776196e-02f, -3.50879490e-01f, -1.43318683e-01f, -9.03681479e-03f, -2.38889948e-01f, 6.06639162e-02f, -3.15175295e-01f, 1.25310361e-01f, -3.27611953e-01f, 3.85787189e-02f,
  -5.06013520e-02f, 1.16591908e-01f, 1.31893694e-01f, -4.47073206e-02f, -9.15773883e-02f, -7.07812957e-04f, -8.94737989e-02f, -3.17379693e-03f, 5.85388811e-03f, 1.06509663e-02f,
  -5.66961505e-02f, -1.40779495e-01f, -5.97746484e-02f, 9.63800400e-03f, 1.93468034e-01f, 4.62703593e-02f, 1.83510669e-02f, 1.21391237e-01f, 3.14605832e-02f, 5.39821945e-02f,
  1.42217889e-01f, 1.28189892e-01f, 8.62748474e-02f, -5.62649779e-02f, 7.77486945e-03f, 5.90999238e-02f, 9.13875476e-02f, -3.88879701e-02f, -5.02158292e-02f, 5.27401827e-02f,
  2.85096634e-02f, 2.96712890e-02f, 2.53192112e-02f, -4.06057276e-02f, 2.20562164e-02f, 1.87548678e-02f, -8.16402063e-02f, -1.16166659e-01f, -6.70618960e-04f, -1.83800999e-02f,
  -2.87538464e-03f, 4.51840367e-03f, 8.76427144e-02f, 1.50117144e-01f, -4.30383300e-03f, 4.16753814e-03f, -8.45113546e-02f, 1.71747506e-02f, 1.03650622e-01f, -3.61511149e-02f,
  -4.61909324e-02f, 2.18035504e-02f, -9.76548940e-02f, 2.73539964e-02f, 7.26459846e-02f, 4.79589887e-02f, 2.87401062e-02f, 1.35333121e-01f, -2.26541664e-02f, -4.94096130e-02f,
  -2.67317533e-01f, -3.31977576e-01f, -1.44526362e-02f, -5.23790643e-02f, -4.50204723e-02f, -9.31332111e-02f, 4.25187126e-02f, 7.80924112e-02f, -1.01180270e-01f, -3.72394100e-02f,
  1.02520175e-01f, 2.43337508e-02f, -2.02393860e-01f, 1.34843905e-02f, -5.68221286e-02f, -2.61385106e-02f, -5.44097759e-02f, -8.67541973e-03f, -1.74360722e-01f, -4.08084095e-02f,
  -1.21703811e-01f, -1.48908004e-01f, 2.01015212e-02f, -3.13328989e-02f, 1.03924973e-02f, -1.20704561e-01f, -3.10654249e-02f, 1.16312928e-01f, -7.63101801e-02f, -5.19466493e-03f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.20591223e+00f, -9.56301987e-01f, -2.55678952e-01f, 5.76794147e-01f, 7.67338276e-01f, 7.11809576e-01f, 9.62893605e-01f, -1.84003282e-02f, 4.67505723e-01f, -7.09653676e-01f,
  -4.52609137e-02f, -3.62850130e-01f, -5.01854002e-01f, 9.80071798e-02f, 1.11405861e+00f, -2.40361646e-01f, 4.27265286e-01f, 1.10262729e-01f, 3.81630100e-02f, 1.37285024e-01f,
  4.93997604e-01f, 5.65022767e-01f, -7.13178292e-02f, -4.25342143e-01f, 2.28953004e-01f, -3.22498977e-01f, -1.77438349e-01f, -3.03378433e-01f, -3.10518861e-01f, 3.10293287e-01f,
  1.77153781e-01f, 1.53293191e-02f, 1.17847905e-01f, -9.92652774e-02f, -3.98943126e-02f, 1.06591200e-02f, -8.76702443e-02f, 1.58873782e-01f, 1.58669323e-01f, -1.38811953e-02f,
  -7.42322281e-02f, 6.97883442e-02f, 4.28693965e-02f, 9.50818732e-02f, 2.02107936e-01f, -1.55916782e-02f, -1.76506117e-02f, -1.08953431e-01f, -1.85171202e-01f, 2.31927726e-02f,
  6.45820424e-02f, -8.75712857e-02f, 2.28105281e-02f, -1.09479293e-01f, -9.52441618e-03f, 4.58748229e-02f, -6.33991808e-02f, -1.32567763e-01f, -4.33323421e-02f, 1.30335629e-01f,
  -3.92380171e-02f, -3.04722991e-02f, -1.43982274e-02f, -8.99562333e-03f, 1.25105247e-01f, 4.63128127e-02f, 6.95573241e-02f, -1.34551659e-01f, 4.81063500e-02f, 1.86011624e-02f,
  1.34149551e-01f, 6.27826452e-02f, 2.33159102e-02f, 5.14040217e-02f, 8.31152499e-02f, 6.52289167e-02f, 1.77174229e-02f, -8.21261480e-02f, -7.40647838e-02f, 2.66019125e-02f,
  -1.58478133e-02f, 4.90168668e-02f, -1.51442349e-01f, -1.05337590e-01f, -1.55954578e-04f, -1.22543285e-02f, -1.86576650e-01f, 3.75997722e-02f, -8.98209400e-03f, 1.03448503e-01f,
  -1.53725967e-01f, -7.74969995e-01f, -1.64159030e-01f, -6.86991438e-02f, -1.32266894e-01f, -8.25891085e-03f, 2.39540376e-02f, 8.55237320e-02f, -1.96647361e-01f, 1.02551185e-01f,
  -5.92251755e-02f, 4.00636904e-02f, -6.41703829e-02f, 7.10972622e-02f, -2.35403907e-02f, -2.52127163e-02f, -1.61763042e-01f, 3.93462069e-02f, 1.23930899e-02f, -1.60204336e-01f,
  -7.45955333e-02f, 1.02478094e-01f, 1.39822990e-01f, 1.76188663e-01f, -1.68230105e-02f, -2.17926297e-02f, -5.37527492e-03f, -1.39638588e-01f, -9.67120007e-02f, -3.85881737e-02f,
  2.84333974e-01f, 6.81085110e-01f, 6.83230519e-01f, 3.89886320e-01f, 1.59552142e-01f, -6.55197442e-01f, -3.09939116e-01f, 5.49441755e-01f, 4.34732854e-01f, -1.93123687e-02f,
  -1.24976382e-01f, 8.33738521e-02f, 1.82398036e-01f, 2.17145130e-01f, -5.87903440e-01f, -1.94622234e-01f, -3.39725941e-01f, -2.13298410e-01f, 2.43446305e-01f, 1.13590665e-01f,
  1.78625852e-01f, -3.49127680e-01f, 3.20639968e-01f, 1.98595420e-01f, 6.29221737e-01f, 4.11832988e-01f, -2.64681160e-01f, 1.30694821e-01f, -2.59892404e-01f, -1.90326244e-01f,
  2.28228586e-04f, 5.51323891e-01f, 3.45058590e-01f, 4.78909463e-02f, 1.95968244e-02f, -2.09341988e-01f, -1.38957620e-01f, -6.21071421e-02f, 8.89448896e-02f, 4.53522839e-02f,
  -3.61506008e-02f, 1.30412921e-01f, 3.37842293e-02f, 1.23693772e-01f, 1.22556254e-01f, 2.76088923e-01f, 2.11045906e-01f, 1.53710440e-01f, 2.99324989e-01f, 1.61502540e-01f,
  2.60038346e-01f, 1.55794129e-01f, -5.45118116e-02f, -2.11095244e-01f, 1.59302965e-01f, 1.25147432e-01f, -2.87678003e-01f, -1.32426307e-01f, -2.00470816e-02f, 4.00343351e-03f,
  5.78591712e-02f, -2.52237797e-01f, -1.69411842e-02f, 1.41094759e-01f, -1.21320434e-01f, 8.11321363e-02f, -1.15680313e-02f, -1.04913563e-02f, -5.07051833e-02f, -6.57442436e-02f,
  -1.27670616e-01f, 2.46844161e-02f, 3.42751965e-02f, -7.95041248e-02f, -6.86352281e-03f, 1.57939091e-01f, -8.01472515e-02f, 2.13793702e-02f, -5.56298569e-02f, 3.91393602e-02f,
  4.71975766e-02f, -3.06134135e-01f, 6.52884394e-02f, -4.31426894e-03f, -2.28586253e-02f, 8.25856403e-02f, 7.55312517e-02f, 1.63433313e-01f, 2.41381135e-02f, -1.25987560e-01f,
  -7.23167717e-01f, -3.63262832e-01f, 1.03471644e-01f, 1.74835734e-02f, -4.30703014e-02f, -3.94777358e-02f, -9.04014707e-02f, 1.00621067e-01f, -7.79874921e-02f, -9.65285972e-02f,
  -4.04558964e-02f, -4.20826264e-02f, -2.87568986e-01f, -6.95928857e-02f, -1.32599548e-01f, -1.20320156e-01f, -9.61676687e-02f, -1.55580804e-01f, -1.61350027e-01f, -1.05887316e-02f,
  4.51657549e-02f, -8.50830972e-02f, -9.90359858e-02f, -1.03511875e-02f, -1.13609985e-01f, -8.43193084e-02f, -3.07563599e-02f, 1.27880648e-01f, -7.75096416e-02f, -8.76715258e-02f,
  -1.16188072e-01f, -4.37516540e-01f, 3.30135465e-01f, -3.18889856e-01f, 8.04391652e-02f, -1.85747016e-02f, -2.61908472e-01f, -2.83659220e-01f, -3.73977333e-01f, -4.86749023e-01f,
  -3.73092800e-01f, 4.02779222e-01f, 5.00760861e-02f, -4.35983181e-01f, 9.58438873e-01f, 1.78558558e-01f, -2.67040789e-01f, -2.30172902e-01f, -1.36624768e-01f, -4.77198154e-01f,
  -1.15906566e-01f, -6.03337824e-01f, 2.16990769e-01f, -6.63292766e-01f, -3.36127073e-01f, -1.65186569e-01f, 1.25413150e-01f, 1.07155651e-01f, -1.87547043e-01f, 2.78549254e-01f,
  -1.01031706e-01f, -3.95918906e-01f, -5.51730022e-02f, 3.13799419e-02f, -1.05749734e-01f, 3.32694799e-02f, 1.61961764e-01f, 2.26630658e-01f, 5.04334942e-02f, 1.18277557e-01f,
  1.19255476e-01f, 1.23796761e-01f, -2.09418342e-01f, 1.51170045e-01f, -1.44164205e-01f, -1.48051269e-02f, 6.40943870e-02f, 7.37416297e-02f, -1.67611092e-02f, 1.95378646e-01f,
  2.53060069e-02f, 2.03630462e-01f, -2.41924934e-02f, 9.04956535e-02f, 8.27589557e-02f, -5.54287136e-02f, 9.23841000e-02f, 2.21364170e-01f, 8.61209929e-02f, -9.69716068e-03f,
  -1.50978193e-01f, -3.86340246e-02f, -3.45212780e-02f, -3.17060426e-02f, -1.38869911e-01f, -6.00006171e-02f, 4.92662564e-02f, -2.36240309e-02f, -9.96336620e-03f, 1.91670563e-02f,
  -4.31453697e-02f, 1.15877718e-01f, -7.73985609e-02f, -1.64730232e-02f, -8.96710828e-02f, -5.97862378e-02f, 1.13289066e-01f, 5.33726886e-02f, -1.01673104e-01f, 4.72334027e-03f,
  -7.01101273e-02f, -9.85351279e-02f, 3.99747193e-02f, 1.32010877e-03f, -6.04496710e-02f, 1.52721867e-01f, -1.94477255e-03f, 7.96501487e-02f, -3.12225465e-02f, -2.96046189e-03f,
  -1.99935779e-01f, -6.36193752e-01f, -1.46045521e-01f, 5.62271755e-03f, -4.52008508e-02f, 4.50933985e-02f, -9.86779183e-02f, 6.14688359e-03f, -5.11634387e-02f, -9.01555419e-02f,
  3.91393639e-02f, 3.96161117e-02f, -1.62338838e-02f, -1.65406410e-02f, -5.81129342e-02f, 1.53987920e-02f, -9.12936926e-02f, 8.29439703e-03f, 2.63543706e-02f, -7.36837909e-02f,
  -1.02829382e-01f, -6.26003742e-02f, 5.08725755e-02f, -1.73150778e-01f, -1.39393255e-01f, 1.60207435e-01f, -3.02453991e-02f, 3.73509973e-02f, 1.05773315e-01f, -4.75332625e-02f,
  -6.61384940e-01f, 8.90734643e-02f, -5.22690296e-01f, -1.92681789e-01f, 3.91088039e-01f, -5.62808633e-01f, -3.42383236e-01f, 4.85940464e-02f, -3.38591874e-01f, 2.97023088e-01f,
  -1.38865765e-02f, -2.12685585e-01f, -1.70193180e-01f, -3.36029470e-01f, -9.93558347e-01f, -7.47278392e-01f, -4.68304664e-01f, -3.86896133e-01f, -2.62430698e-01f, -7.37293512e-02f,
  -3.03806454e-01f, 2.31216922e-01f, -2.59062916e-01f, 5.58135808e-01f, 2.01765761e-01f, 3.68052602e-01f, 5.82402527e-01f, 3.49541843e-01f, 1.73497394e-01f, 1.79564923e-01f,
  -3.11716557e-01f, 2.81532924e-03f, 4.82043289e-02f, -2.33859345e-02f, -4.11861949e-02f, 9.38380212e-02f, -6.57660961e-02f, 6.60088519e-03f, -6.34191483e-02f, -3.72841172e-02f,
  8.23373199e-02f, 3.09251379e-02f, 8.38020071e-02f, 4.48185019e-02f, -6.43475279e-02f, 3.30773406e-02f, -1.18128486e-01f, -1.18009284e-01f, -7.50248646e-03f, -2.00663865e-01f,
  -1.70794785e-01f, -1.43081158e-01f, -2.57267170e-02f, 9.45962071e-02f, 1.52161792e-02f, -1.10144764e-01f, -6.31192550e-02f, 8.51889700e-02f, -4.05944372e-03f, -6.61431288e-04f,
  7.09406957e-02f, -1.76895577e-02f, -2.91805472e-02f, -1.39750540e-01f, -1.21494189e-01f, 9.65255871e-02f, -4.33483869e-02f, 7.68541247e-02f, 4.60542440e-02f, 2.99327634e-02f,
  2.31408719e-02f, -6.07814454e-02f, 4.46555465e-02f, -2.46132798e-02f, -6.00154549e-02f, -7.36398473e-02f, -3.54611762e-02f, 1.36462480e-01f, -1.61525998e-02f, -1.16958804e-01f,
  1.28023639e-01f, -7.61447102e-02f, 8.51655304e-02f, 3.44071575e-02f, -1.71071336e-01f, 6.57762140e-02f, 1.20201170e-01f, -6.98174313e-02f, -4.89596371e-03f, 1.62793901e-02f,
  8.91157538e-02f, 3.02723944e-01f, 1.12698697e-01f, 1.44388467e-01f, -1.95593515e-04f, -4.65536602e-02f, -9.30958167e-02f, 1.10352030e-02f, -9.30487663e-02f, 5.74750863e-02f,
  3.76387686e-02f, 1.38633668e-01f, 5.88596277e-02f, 4.72514257e-02f, 5.85554205e-02f, -9.13758427e-02f, 1.16837136e-01f, 1.31759942e-01f, 3.03760260e-01f, 8.80141631e-02f,
  2.17525378e-01f, 8.74818414e-02f, 9.56893116e-02f, 8.44728425e-02f, 2.06953883e-01f, 1.47646576e-01f, 9.12049562e-02f, -6.11803010e-02f, 6.01982810e-02f, 1.77074485e-02f,
  -2.15905696e-01f, 2.91793495e-01f, -1.22150809e-01f, -8.88374329e-01f, 1.13350026e-01f, 6.05173111e-01f, -3.54349732e-01f, 3.33300143e-01f, -1.16850369e-01f, -2.84132399e-02f,
  -4.23104763e-01f, -3.52464110e-01f, 1.75975323e-01f, -4.81502056e-01f, 3.65144700e-01f, 3.43452692e-01f, -2.90442616e-01f, -4.91560400e-01f, 2.13013157e-01f, -1.69412315e-01f,
  -9.22156349e-02f, -4.19807196e-01f, -3.26244235e-01f, 2.35651195e-01f, -4.45377082e-01f, -2.00704321e-01f, -2.95687437e-01f, 1.22164898e-01f, -3.80143613e-01f, 1.10528059e-01f,
  -1.95340246e-01f, -1.13247056e-02f, 3.67139429e-02f, 1.00230187e-01f, 6.66226074e-03f, 1.07847434e-02f, -1.78012878e-01f, 1.40424713e-01f, -5.80327325e-02f, 1.01924948e-02f,
  -1.67051435e-01f, 4.63108569e-02f, 6.45795465e-02f, 7.46628195e-02f, -5.31850494e-02f, -4.30070981e-02f, -5.26644140e-02f, -1.98993459e-01f, -5.30149927e-03f, 7.31807277e-02f,
  -1.21724650e-01f, -6.43870831e-02f, -9.69467908e-02f, -1.26702473e-01f, -2.13676676e-01f, -1.15760550e-01f, -1.78807944e-01f, -4.75568473e-02f, -8.35936517e-02f, 2.76306644e-03f,
  7.27152303e-02f, 1.37258887e-01f, -5.52138407e-03f, -1.05781801e-01f, 7.53945857e-02f, -3.25514898e-02f, -1.02479957e-01f, -4.25731987e-02f, 3.50131951e-02f, -1.09011717e-01f,
  -8.92679542e-02f, -1.63127929e-01f, -6.12758808e-02f, -1.00119062e-01f, -2.46332809e-02f, -1.07637078e-01f, 3.81711312e-02f, -9.44127962e-02f, -1.19384713e-01f, -8.34306031e-02f,
  -3.32604814e-03f, 1.42086118e-01f, -3.48962873e-04f, -5.35851009e-02f, -1.48639712e-03f, -9.01487693e-02f, 5.13634868e-02f, -1.59777477e-01f, 2.16715783e-02f, 3.22445072e-02f,
  7.76933357e-02f, 4.30260450e-01f, 3.24133784e-02f, -7.85484090e-02f, 1.24046970e-02f, 1.54077977e-01f, 1.96922794e-01f, 9.33202580e-02f, 4.07602601e-02f, 2.25899488e-01f,
  -1.20725855e-02f, -1.34075105e-01f, -9.34152678e-02f, -5.19839227e-02f, 2.31834464e-02f, 1.62346497e-01f, -2.47687623e-01f, 1.27581479e-02f, -6.61705136e-02f, 1.26019999e-01f,
  -3.46249118e-02f, 2.29140352e-02f, 2.38434561e-02f, -1.14705361e-01f, 4.73873690e-02f, -1.68995172e-01f, 9.42602307e-02f, -1.68484375e-01f, -3.53834145e-02f, 7.82558881e-03f,
  -3.59776735e-01f, -5.11078358e-01f, -1.83502048e-01f, -3.20651680e-02f, -4.46593128e-02f, -5.65360010e-01f, -9.69862461e-01f, -4.10882905e-02f, -3.32405448e-01f, -7.77761638e-01f,
  -4.59624916e-01f, -6.05508350e-02f, -5.94013989e-01f, 9.12576243e-02f, 6.80935204e-01f, 6.22416325e-02f, 1.72401458e-01f, -2.15446576e-02f, 4.52835083e-01f, -1.31776124e-01f,
  4.14576292e-01f, 2.36324102e-01f, 6.95558906e-01f, 5.42563915e-01f, -1.47278652e-01f, 3.44591916e-01f, 5.00394106e-01f, 1.00626446e-01f, 3.80011499e-01f, 3.14482421e-01f,
  3.50517929e-02f, 2.70584528e-03f, -8.30026194e-02f, -3.06268614e-02f, -6.00665435e-02f, -1.97970778e-01f, -8.69706497e-02f, -1.69877224e-02f, 1.42023638e-01f, 1.58256978e-01f,
  -1.01020724e-01f, 2.29587004e-01f, 1.66326221e-02f, 8.13158154e-02f, -8.89421552e-02f, -1.24033755e-02f, 1.74070507e-01f, 1.16009507e-02f, -1.83378235e-02f, -1.32545978e-01f,
  -1.17097944e-01f, 3.74353789e-02f, -7.16496538e-03f, 1.45383582e-01f, 6.41206428e-02f, -1.30945235e-01f, -7.54188895e-02f, -7.42409676e-02f, -6.11446351e-02f, 5.26299179e-02f,
  -1.52049223e-02f, -1.31387413e-01f, -4.38072123e-02f, -1.12434044e-01f, -2.16911547e-02f, 4.44880500e-02f, 1.20399976e-02f, 8.88094131e-04f, 1.31256700e-01f, -1.40284121e-01f,
  -2.27780864e-02f, 8.80132988e-02f, -1.35396831e-02f, -2.51432389e-01f, 1.11031497e-03f, 1.25547618e-01f, 6.92414343e-02f, -1.23372667e-01f, -1.08577281e-01f, -7.73526542e-03f,
  -1.07228737e-02f, 1.72892231e-02f, 5.28609008e-02f, 2.52504684e-02f, -1.01489276e-01f, -1.05900258e-01f, -1.08591132e-01f, -5.95607571e-02f, 1.17544875e-01f, 4.03935909e-02f,
  9.38054472e-02f, 1.37456581e-01f, -1.08060703e-01f, 7.13795773e-04f, 6.07676022e-02f, 4.97791432e-02f, 6.30317703e-02f, 2.41930839e-02f, 1.00891642e-01f, -8.49954691e-03f,
  -7.63693750e-02f, 7.91733563e-02f, 2.68403813e-02f, -1.80670824e-02f, 3.40330571e-01f, -1.70769244e-01f, -4.14077491e-02f, 2.71708034e-02f, 4.10725595e-03f, 1.71284720e-01f,
  -2.22706385e-02f, -1.12192981e-01f, 1.21516794e-01f, 2.86138523e-02f, -5.96137978e-02f, -2.92667970e-02f, 4.40193824e-02f, -9.03363153e-02f, 2.35444486e-01f, 5.56465499e-02f,
  -6.25785947e-01f, -2.30625570e-01f, -2.29289562e-01f, -2.51826555e-01f, -6.42395139e-01f, -3.47508341e-01f, 1.26996204e-01f, -3.39514941e-01f, -1.35716140e-01f, 2.55038112e-01f,
  2.80806627e-02f, -8.98696855e-02f, 6.22947276e-01f, -1.90449417e-01f, 2.90893823e-01f, 6.45049632e-01f, -1.57768622e-01f, 1.94898501e-01f, -2.04138041e-01f, -3.83149683e-01f,
  -1.83488399e-01f, -1.91483036e-01f, 2.07729682e-01f, -5.54808915e-01f, -6.66815162e-01f, -4.64369595e-01f, 9.13830474e-02f, -2.38544822e-01f, -5.34450114e-01f, -3.45631868e-01f,
  -5.00646055e-01f, -3.33010793e-01f, 4.74882014e-02f, -5.57017401e-02f, -1.86020434e-01f, 8.03813189e-02f, -3.95744480e-02f, 1.42854571e-01f, 2.72575091e-03f, 1.03233159e-02f,
  1.19712643e-01f, -1.23068951e-01f, -1.99235439e-01f, 5.86954579e-02f, -1.30370438e-01f, -2.61582583e-01f, -2.30939060e-01f, -1.25537142e-01f, -2.34510805e-02f, -1.73683196e-01f,
  4.61710850e-03f, -1.93521097e-01f, -1.30295306e-01f, 3.60928625e-02f, -3.50382701e-02f, -2.29495913e-01f, 8.60298239e-03f, 2.04536524e-02f, -1.88109502e-01f, -3.23537111e-01f,
  7.40236342e-02f, 1.78334624e-01f, 3.40422220e-03f, 1.03207327e-01f, 2.50507495e-03f, -1.41712241e-02f, 3.71106938e-02f, 5.63746803e-02f, -6.60850061e-03f, -5.02668433e-02f,
  -1.09288514e-01f, -6.23350926e-02f, -1.27082989e-01f, 5.55565022e-02f, -3.72295007e-02f, 8.64890292e-02f, 1.75037727e-01f, -1.74258173e-01f, -3.81281413e-02f, -4.20430228e-02f,
  7.69865215e-02f, -4.63117287e-02f, 6.19467646e-02f, 9.39609110e-02f, -4.20490615e-02f, 1.15467615e-01f, -6.92458674e-02f, -1.81013811e-02f, -4.11781892e-02f, 1.42756542e-02f,
  -5.42546093e-01f, -5.20863652e-01f, 1.46679476e-01f, -3.06549948e-02f, 5.71254492e-02f, -1.78181142e-01f, 7.42787868e-02f, -5.71143553e-02f, -1.66686609e-01f, -6.20812438e-02f,
  -1.06735520e-01f, 1.05786063e-01f, -1.50426850e-01f, 1.34444563e-02f, 8.78372267e-02f, -1.12893833e-02f, 2.00632602e-01f, -4.53128517e-02f, -1.25669211e-03f, -5.13853803e-02f,
  1.61479503e-01f, 1.49950102e-01f, 1.32328287e-01f, -9.34430957e-02f, 5.35233580e-02f, 2.23583896e-02f, -8.13985392e-02f, 1.03810914e-02f, -1.65778354e-01f, -2.10249168e-03f,
  -8.02735984e-02f, -2.42796853e-01f, -8.40411723e-01f, -6.64743364e-01f, 2.49456361e-01f, 3.95575821e-01f, 4.67406027e-02f, 1.06758267e-01f, -4.99085397e-01f, 4.40697998e-01f,
  1.99141279e-02f, -5.14562249e-01f, -1.61171034e-01f, -5.84943295e-01f, -6.00157142e-01f, -3.85358423e-01f, -4.02637452e-01f, -1.75498456e-01f, -1.20578974e-01f, 2.19338085e-03f,
  -1.90646932e-01f, 9.28064901e-03f, -4.69141513e-01f, 5.07222235e-01f, 2.44837701e-01f, 3.00745755e-01f, 5.40827453e-01f, 2.68402249e-01f, 2.40581274e-01f, -2.12378219e-01f,
  -4.44367751e-02f, -4.43755835e-02f, -1.53792530e-01f, -1.70682788e-01f, 1.74887121e-01f, 2.96092778e-01f, 1.65167391e-01f, -1.31404534e-01f, 2.07509808e-02f, -1.69289842e-01f,
  1.44956946e-01f, -1.08534381e-01f, -1.51445076e-01f, -2.13447660e-02f, 1.35705903e-01f, 8.04555640e-02f, -6.11851178e-02f, 1.08574042e-02f, -2.74680965e-02f, -2.35466108e-01f,
  -9.27584320e-02f, 3.82784009e-02f, 1.13620520e-01f, -1.95779622e-01f, -8.51255134e-02f, -4.91012307e-03f, 1.16766177e-01f, 3.98416519e-02f, 1.35669991e-01f, -3.23826037e-02f,
  1.71236902e-01f, 2.39896864e-01f, 4.20383401e-02f, 8.86003301e-02f, -2.62233429e-03f, 3.10933068e-02f, 1.41865999e-01f, -1.51091330e-02f, 1.52070960e-02f, 1.38396947e-02f,
  -9.53233019e-02f, -2.20802203e-02f, 2.70566903e-02f, 4.19030674e-02f, -2.07648403e-03f, -6.84182122e-02f, 3.49103399e-02f, -6.40032589e-02f, -1.35303020e-01f, 2.17927896e-04f,
  -6.44802153e-02f, 2.54263971e-02f, -2.18848474e-02f, 1.52106658e-01f, 6.00015037e-02f, -1.17427334e-01f, 4.53207875e-03f, 3.87668237e-02f, 8.90674628e-03f, 7.15551749e-02f,
  1.29215777e-01f, 3.85027267e-02f, -1.51659727e-01f, -4.36024517e-02f, -4.35113832e-02f, 1.56659603e-01f, -4.50291932e-02f, -1.57757610e-01f, 6.25756979e-02f, 3.54418866e-02f,
  1.23837613e-01f, 1.14332780e-01f, 3.15308094e-01f, -1.04595236e-01f, -4.38620057e-03f, 3.45697142e-02f, 1.02696288e-02f, -3.29802036e-02f, 3.17738205e-02f, 1.07840106e-01f,
  1.73200220e-01f, 2.03255728e-01f, 4.68747094e-02f, 1.01243913e-01f, 7.94302225e-02f, 1.25551373e-01f, 2.53428429e-01f, 5.38199842e-02f, -1.16856163e-03f, 2.60125846e-03f,
  5.03220893e-02f, 6.75526738e-01f, -3.22542638e-01f, 2.21547723e-01f, -4.16644841e-01f, 3.38134497e-01f, 7.83082247e-01f, 1.13567837e-01f, 4.57828850e-01f, 6.02851093e-01f,
  -2.75130600e-01f, 6.03924990e-01f, 3.73526335e-01f, 1.66448087e-01f, -9.81072895e-03f, 4.39136654e-01f, 2.57972658e-01f, 2.41705701e-01f, 2.32269734e-01f, 1.72091126e-01f,
  -1.06919125e-01f, 3.27183664e-01f, -3.81947726e-01f, 9.49825048e-02f, -2.31154770e-01f, -1.26996651e-01f, -1.82215929e-01f, -8.44416618e-02f, -1.26085117e-01f, 1.26065165e-01f,
  -6.71312632e-03f, 4.60033000e-01f, -1.78495184e-01f, 2.07824577e-02f, -1.39218450e-01f, -1.62182242e-01f, -9.83960703e-02f, -5.51021062e-02f, -6.58675879e-02f, 1.04349732e-01f,
  1.70115769e-01f, 3.47397402e-02f, 2.21846402e-01f, 1.86551616e-01f, 2.73973159e-02f, -4.34075668e-02f, -9.44550112e-02f, -3.32922637e-01f, 3.60850692e-02f, -7.78135881e-02f,
  -1.50127977e-01f, -1.35981947e-01f, -2.39624038e-01f, 2.04370365e-01f, -1.49033636e-01f, 1.41568080e-01f, 6.90954700e-02f, -1.07270591e-01f, 1.15471907e-01f, 2.32102349e-01f,
  8.34864601e-02f, 1.18786223e-01f, 6.38329517e-03f, -1.26130596e-01f, 4.87921201e-02f, -1.72480911e-01f, 1.89770207e-01f, -1.38113320e-01f, 4.24992852e-02f, 3.97299789e-02f,
  -8.41233954e-02f, -1.46556441e-02f, 9.33333412e-02f, 4.68058735e-02f, 9.31693614e-02f, 1.17186122e-01f, -1.85926408e-01f, 1.01155803e-01f, -7.37898275e-02f, -1.81106478e-01f,
  1.34574652e-01f, -1.51854428e-02f, 1.70905530e-01f, -9.49331969e-02f, 4.30346094e-02f, -7.23454356e-02f, 9.64166597e-02f, 2.43528094e-02f, -9.67587680e-02f, -1.85141843e-02f,
  2.28368506e-01f, 8.83201778e-01f, 7.43778720e-02f, 3.68813202e-02f, 5.40139005e-02f, -5.42080440e-02f, 5.67091592e-02f, -6.99326769e-02f, 2.97187448e-01f, 1.43478140e-01f,
  -4.44470122e-02f, 6.81221336e-02f, -2.05923289e-01f, -1.49744406e-01f, 1.92507915e-02f, 5.91632025e-03f, 1.38218254e-01f, 1.57350078e-01f, 5.04886433e-02f, -6.36701882e-02f,
  -3.19009274e-02f, 2.48477980e-01f, 6.20014742e-02f, -7.49647692e-02f, -1.26179624e-02f, 6.42662495e-02f, -2.11609416e-02f, -2.44284030e-02f, 1.94332637e-02f, 7.06301704e-02f,
  8.06281686e-01f, 7.60296345e-01f, 5.67456067e-01f, 5.81667662e-01f, -4.84198391e-01f, 4.81360406e-02f, 2.27927208e-01f, -3.33081819e-02f, 8.72895122e-01f, 1.34339079e-01f,
  -7.10560083e-01f, 8.22632372e-01f, -5.58067024e-01f, 1.78293422e-01f, -1.89507738e-01f, -1.63942188e-01f, 2.35108197e-01f, 3.62729996e-01f, 1.18559822e-01f, 8.07716772e-02f,
  1.28249243e-01f, -6.42526686e-01f, -3.84475559e-01f, -4.88641500e-01f, -1.82097763e-01f, 3.69107991e-01f, -7.27369249e-01f, -1.75214872e-01f, -2.05672607e-02f, -1.34410799e-01f,
  -9.73995626e-02f, -1.24907894e-02f, 1.48356345e-03f, 1.29287243e-01f, -1.52393430e-01f, 4.61535119e-02f, -2.51819734e-02f, -1.67302832e-01f, -1.31245852e-01f, 1.86375380e-01f,
  1.93897843e-01f, -6.07554652e-02f, 1.32299140e-01f, -6.05726205e-02f, 7.54896924e-02f, 1.28192902e-01f, 5.69848865e-02f, 1.28871128e-02f, 5.46823144e-02f, 5.59748895e-03f,
  1.99217480e-02f, 8.89710784e-02f, 6.93283677e-02f, 8.26453716e-02f, 1.00036971e-01f, 1.60291076e-01f, 1.97169960e-01f, 3.19645815e-02f, 1.27882496e-01f, 8.92168656e-02f,
  -8.68160427e-02f, 2.91884057e-02f, -1.01990759e-01f, -8.68422091e-02f, -6.94187731e-02f, -2.81066801e-02f, 4.81513441e-02f, -1.18569948e-01f, 1.41093165e-01f, -7.74432942e-02f,
  5.21749780e-02f, 6.46666437e-02f, -4.60405685e-02f, 4.69501428e-02f, -4.21838872e-02f, 1.12257965e-01f, 2.40507675e-03f, 1.63867287e-02f, 1.68608814e-01f, -8.53876397e-03f,
  -1.64817959e-01f, 2.05132794e-02f, -5.38601950e-02f, -1.06829576e-01f, -4.59917895e-02f, -6.98451325e-02f, 5.74552082e-02f, 3.24349403e-02f, -6.02005161e-02f, -1.91906691e-01f,
  -1.41693116e-03f, 1.01715989e-01f, 8.66658911e-02f, -1.24527945e-03f, 7.12270215e-02f, -6.04847483e-02f, 7.06640556e-02f, 1.80220097e-01f, 1.30597338e-01f, -3.66357854e-03f,
  -3.66058424e-02f, 8.73608738e-02f, 1.09524094e-01f, -2.46243421e-02f, 2.28521004e-02f, -6.30152449e-02f, 9.51223075e-02f, 1.44283101e-01f, -1.35601843e-02f, -1.27182156e-01f,
  -4.57854532e-02f, -4.04259562e-02f, 1.16964065e-01f, 4.11438644e-02f, -6.63659209e-03f, -7.90711194e-02f, 6.03458807e-02f, 6.83733672e-02f, -1.71821266e-01f, 1.16280399e-01f,
  -1.09712565e+00f, 4.39990163e-01f, -2.57973224e-01f, -4.38029110e-01f, -2.66848594e-01f, -4.79326338e-01f, -1.00893073e-01f, -1.76826820e-01f, -1.02624819e-01f, 3.87453854e-01f,
  1.98082656e-01f, -2.60394096e-01f, 4.51241165e-01f, 6.55416772e-02f, -6.19009733e-01f, 4.22687262e-01f, -3.58706295e-01f, -1.76958263e-01f, 8.45159963e-02f, -4.62539703e-01f,
  -2.75891751e-01f, 2.49417648e-02f, -1.42475292e-01f, 1.75355941e-01f, -4.11254048e-01f, -2.15999514e-01f, 6.23694621e-02f, 1.76355883e-01f, 4.00893427e-02f, 1.16531305e-01f,
  -3.70468974e-01f, -2.28016108e-01f, -2.31196448e-01f, -1.56639889e-01f, -2.56318420e-01f, -1.10024534e-01f, -1.71351925e-01f, 4.60847393e-02f, -9.03076231e-02f, -1.86053514e-02f,
  -8.17063451e-02f, -5.61701320e-03f, 2.82604154e-02f, 3.95219773e-02f, -1.28406703e-01f, -4.27319184e-02f, -8.83236751e-02f, 1.26195988e-02f, 5.63350692e-02f, -2.08515953e-02f,
  8.14802945e-02f, 1.38836369e-01f, 1.35801565e-02f, 7.53847584e-02f, -7.99374655e-02f, -6.37336168e-03f, 7.84100906e-04f, -5.37925065e-02f, -1.20895348e-01f, -8.42748210e-02f,
  -3.70500572e-02f, -9.10949111e-02f, -9.14445966e-02f, -3.25577892e-02f, 4.68876809e-02f, 1.36532813e-01f, 2.60294857e-03f, 6.40608445e-02f, -4.22431268e-02f, 7.04077259e-03f,
  -1.81866139e-02f, 6.38810173e-02f, 1.12789376e-02f, -6.41096905e-02f, -1.01764239e-01f, -6.82546720e-02f, -5.13908044e-02f, -7.84636810e-02f, 4.84399833e-02f, -7.15741441e-02f,
  -1.10334679e-01f, 5.49827442e-02f, 1.76609725e-01f, 2.77687479e-02f, -3.25324722e-02f, -3.40021923e-02f, 1.34020343e-01f, 6.20041862e-02f, -1.06476611e-02f, -1.14739902e-01f,
  -8.38596404e-01f, -5.10165393e-01f, -2.03695893e-01f, -3.63821574e-02f, -1.23342410e-01f, -1.65694207e-01f, -2.45309640e-02f, -9.19911116e-02f, -1.36804014e-01f, -1.06311530e-01f,
  -1.49207488e-01f, -9.98692820e-04f, -2.83198245e-02f, -2.95272451e-02f, -5.98061681e-02f, -7.78699294e-03f, -1.50778025e-01f, -1.85497031e-02f, -3.10383201e-01f, -7.79910088e-02f,
  -8.41151774e-02f, -3.93174477e-02f, -4.75518405e-02f, -5.38612157e-03f, -4.78694513e-02f, 4.63285074e-02f, -1.49299815e-01f, 5.58541976e-02f, -4.40329947e-02f, 6.40859529e-02f,
  -1.19376712e-01f, 1.14774995e-01f, 6.34936571e-01f, -6.16724372e-01f, 1.02260120e-01f, 1.80231676e-01f, 4.26644564e-01f, -3.51687282e-01f, -6.33518398e-01f, -3.34151715e-01f,
  -2.77649432e-01f, 6.01319671e-01f, 5.63849092e-01f, -3.43061477e-01f, 1.32562071e-01f, -7.98118263e-02f, -6.17942929e-01f, -1.16557151e-01f, 9.89871100e-02f, -7.05164075e-02f,
  -2.52231002e-01f, -3.83301467e-01f, 7.32966438e-02f, -2.13916093e-01f, 1.32881492e-01f, 1.70207508e-02f, -2.82399535e-01f, 6.13436043e-01f, -1.44547015e-01f, 3.17576200e-01f,
  -1.49584696e-01f, -2.65288502e-01f, 6.19784556e-02f, -6.85690939e-02f, -2.13998958e-01f, 1.03096060e-01f, 1.65744036e-01f, 3.38358641e-01f, -8.57156422e-03f, 6.10970594e-02f,
  1.10035494e-01f, -2.04792991e-02f, -8.59506801e-02f, 2.31847301e-01f, -9.31423753e-02f, -1.30740821e-01f, -8.71064067e-02f, -3.52037698e-02f, 1.69527475e-02f, 6.31278828e-02f,
  1.20408453e-01f, -3.66409495e-02f, -9.78387818e-02f, -6.53745309e-02f, 9.89019126e-02f, -1.37068078e-01f, -5.07784151e-02f, 2.86871403e-01f, 6.92654252e-02f, -1.66232333e-01f,
  4.47421297e-02f, 3.95365932e-04f, -5.95306158e-02f, -6.64680824e-02f, -6.11191662e-03f, 2.98264511e-02f, 1.11354003e-02f, -2.47647278e-02f, -5.25090704e-03f, -6.54431134e-02f,
  -1.57845497e-01f, 4.42155674e-02f, -1.52885363e-01f, -2.00349763e-01f, -1.01698004e-01f, -2.64638722e-01f, 1.19808972e-01f, 3.07964366e-02f, -7.09695071e-02f, 6.21087626e-02f,
  6.44267052e-02f, 5.54611385e-02f, 1.06807314e-01f, 1.41212484e-02f, -4.35464010e-02f, 3.46793719e-02f, -3.89787718e-03f, 4.39222828e-02f, -1.71697825e-01f, 1.27796903e-01f,
  -2.04650894e-01f, -5.43922424e-01f, -9.77070164e-03f, -4.39009583e-03f, 6.95499405e-02f, -7.55142048e-02f, -3.01719736e-02f, -1.00316077e-01f, -6.61845952e-02f, -7.61077777e-02f,
  -1.05789065e-01f, -5.03989533e-02f, -5.43573536e-02f, -1.35517446e-02f, 1.64880410e-01f, -6.88140914e-02f, 4.86435853e-02f, -7.38225952e-02f, -7.59097263e-02f, -9.13240239e-02f,
  3.00713740e-02f, -1.16559803e-01f, 1.52523696e-01f, -7.24285915e-02f, -1.89383864e-01f, -4.67975549e-02f, -6.30248114e-02f, 5.75389899e-03f, 4.44505848e-02f, 1.44120697e-02f,
  1.98841363e-01f, -4.85567227e-02f, -5.84128857e-01f, 1.95232630e-01f, -1.70797020e-01f, -1.27208102e-02f, -2.86787212e-01f, 3.52931805e-02f, -5.23959517e-01f, 4.75038648e-01f,
  3.73802960e-01f, -1.14810713e-01f, -3.28344464e-01f, 9.14050102e-01f, 4.63522106e-01f, -2.13449672e-01f, 7.95410573e-01f, 3.24148566e-01f, -6.39009997e-02f, 4.93718505e-01f,
  3.10244292e-01f, 9.25549328e-01f, 1.99897960e-01f, 5.66495717e-01f, 3.66572678e-01f, -1.13552548e-02f, 5.22556186e-01f, -2.94576466e-01f, 6.67682171e-01f, 1.51936680e-01f,
  1.21403329e-01f, 2.61520725e-02f, -5.97177409e-02f, -2.19906688e-01f, 1.29149517e-03f, -5.01281768e-02f, -6.33089319e-02f, -4.53766361e-02f, -2.24694282e-01f, -5.52619509e-02f,
  -7.43457377e-02f, 3.47947553e-02f, 1.16176136e-01f, -6.64388537e-02f, 6.38978854e-02f, -9.49444249e-02f, -1.98006347e-01f, -2.29354367e-01f, -1.44681454e-01f, 9.04339775e-02f,
  -2.35234648e-01f, -7.03239366e-02f, -5.52128665e-02f, -1.15782239e-01f, -8.14536810e-02f, -7.42485374e-02f, -9.51164290e-02f, -7.68271685e-02f, -1.45552754e-01f, -4.55104411e-02f,
  1.17161341e-01f, -9.59360898e-02f, -4.08572555e-02f, -3.73678207e-02f, -9.85179469e-03f, 7.60401785e-02f, 6.68890625e-02f, 7.46456981e-02f, -1.02918692e-01f, 8.41827169e-02f,
  4.35076021e-02f, -3.28602418e-02f, -3.82509106e-03f, -5.65096810e-02f, 1.45281523e-01f, -1.43644974e-01f, -8.00017715e-02f, 1.13877490e-01f, -8.08829963e-02f, 2.01515108e-02f,
  -5.99492416e-02f, 2.02269107e-03f, -1.27764896e-01f, -6.44671246e-02f, 1.05810277e-01f, 1.74989700e-02f, 1.80214331e-01f, 1.20384045e-01f, -1.97887585e-01f, -3.59074399e-02f,
  1.04775190e-01f, 2.80594200e-01f, -1.29387170e-01f, -2.81317756e-02f, -3.56954560e-02f, 1.74480468e-01f, 8.99733752e-02f, 1.64921001e-01f, 4.36709076e-02f, 5.86104468e-02f,
  1.89116970e-01f, -2.38830909e-01f, 3.62452976e-02f, 4.72752471e-03f, 5.83441891e-02f, 1.56396762e-01f, 4.10591997e-02f, -2.03432113e-01f, 1.11392941e-02f, 2.29744285e-01f,
  3.35399732e-02f, -9.73135605e-03f, 4.77291159e-02f, -1.81368142e-01f, 1.18174650e-01f, -2.51533519e-02f, 3.88456369e-03f, 1.29430257e-02f, 1.55827448e-01f, -1.51534071e-02f,
  -1.11316788e+00f, 7.71241188e-01f, 4.50468421e-01f, -4.54434425e-01f, -7.08712041e-02f, 1.04603565e+00f, 6.05306983e-01f, 1.24029383e-01f, -1.87944353e-01f, 3.84953916e-01f,
  1.73116863e-01f, -1.76882088e-01f, 5.01819909e-01f, 3.74657899e-01f, 2.48630628e-01f, 6.45632029e-01f, 3.72269362e-01f, 2.08937764e-01f, -7.81244785e-02f, -1.07606500e-01f,
  -1.39074549e-01f, 1.26391798e-01f, 4.53813851e-01f, -4.68508564e-02f, 1.00552008e-01f, -4.35539782e-01f, -1.90359354e-01f, 2.27495423e-03f, 1.75997123e-01f, 1.11495070e-01f,
  -1.36140451e-01f, -5.32578588e-01f, -2.77756471e-02f, 5.25683761e-02f, -2.37733573e-02f, -1.69136047e-01f, 4.88584451e-02f, -8.94048717e-03f, -2.15882927e-01f, 5.90477847e-02f,
  -2.59236861e-02f, -3.39315012e-02f, -1.77350491e-01f, -4.51689549e-02f, -1.17265955e-01f, -6.41521662e-02f, 2.43613973e-01f, 1.96850061e-01f, 2.23069042e-01f, 1.37152478e-01f,
  1.93659186e-01f, 1.81381881e-01f, 1.17643990e-01f, 1.76568493e-01f, 5.01351282e-02f, -8.78068432e-02f, 1.31786302e-01f, 2.76685543e-02f, 1.18655376e-01f, -2.33318135e-02f,
  -9.47768986e-03f, 6.41058723e-04f, 1.22719072e-01f, -1.29971812e-02f, -5.98507188e-02f, -1.63560897e-01f, 2.73412894e-02f, -1.68262180e-02f, -4.72077057e-02f, 1.38939291e-01f,
  -1.62062675e-01f, -4.15516924e-03f, -1.13711931e-01f, 1.25718996e-01f, -1.14748329e-01f, -6.60163388e-02f, -2.34895516e-02f, -5.29180281e-02f, -3.53928804e-02f, -7.67942593e-02f,
  -3.14418413e-02f, -1.18184105e-01f, 8.96025673e-02f, -1.73228867e-02f, 8.23204741e-02f, 3.92425880e-02f, -3.61575186e-02f, 1.56442955e-01f, -1.00680459e-02f, -2.80637015e-02f,
  2.25669190e-01f, -2.91525483e-01f, -7.69696310e-02f, 2.30032671e-02f, -2.18015034e-02f, 1.06590353e-01f, -7.20477477e-02f, -3.28597575e-02f, 8.83593559e-02f, -2.90718079e-02f,
  -1.07473589e-01f, -5.25508299e-02f, -7.50529245e-02f, -6.09923899e-03f, 4.28592078e-02f, 1.23824820e-01f, -5.74998595e-02f, -1.36506438e-01f, 3.13116014e-02f, -5.53456210e-02f,
  -3.54264528e-02f, -2.09648326e-01f, -6.12340160e-02f, -7.17273131e-02f, -1.38176590e-01f, 9.24599264e-03f, -1.27320051e-01f, -1.19693235e-01f, -2.03775372e-02f, 3.63518707e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  9.55792785e-01f, 1.08413768e+00f, 8.55657816e-01f, 5.38517535e-01f, 9.62758243e-01f, 4.31724459e-01f, 3.79407436e-01f, 8.48131478e-01f, 7.15481520e-01f, 8.27832282e-01f,
  3.46960247e-01f, 7.28759229e-01f, 5.45617461e-01f, 8.92326713e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -1.81227401e-01f, -2.86512285e-01f, -1.75385877e-01f, -7.24133730e-01f, -7.70071089e-01f, 1.01213939e-01f, -3.86487842e-01f, -1.79224014e-01f, 4.97100949e-01f, -9.36092556e-01f,
  5.34906507e-01f, -6.12849891e-01f, 1.03287868e-01f, 3.74673158e-01f, -5.45288622e-01f, 5.35735369e-01f, -3.98053229e-01f, -4.08233881e-01f, -9.43769455e-01f, -4.53632295e-01f,
  -5.95600843e-01f, -4.88763571e-01f, -9.83364582e-01f, -2.66653597e-01f, 6.65956199e-01f, -2.81689107e-01f, 3.15401524e-01f, -4.71377343e-01f, 6.27569139e-01f, -9.02915537e-01f,
  1.82250410e-01f, 6.78980529e-01f, -4.94140834e-01f, -8.80717337e-01f, 9.20521677e-01f, 3.22975487e-01f, -6.94714904e-01f, -1.56385407e-01f, -3.49471793e-02f, -4.77722079e-01f,
  -5.41219771e-01f, 7.10757256e-01f, 2.24296808e-01f, 8.23223412e-01f, 7.20723748e-01f, 6.43862411e-02f, 1.19494247e+00f, -2.66665578e-01f, -6.10120475e-01f, -6.73003376e-01f,
  2.80510545e-01f, -6.43514335e-01f, -8.92304659e-01f, -6.73360586e-01f, 8.13065022e-02f, -3.34391207e-01f, -9.33622062e-01f, 1.36875600e-01f, 2.46667758e-01f, -9.16638672e-01f,
  -7.88786411e-01f, -3.77243042e-01f, 6.55202091e-01f, 5.53323507e-01f, -9.29516926e-02f, 5.39849043e-01f, -6.83500230e-01f, -3.10414344e-01f, -4.71727133e-01f, 2.35701695e-01f,
  3.88114035e-01f, -1.56809658e-01f, -1.22599639e-01f, 3.51248711e-01f, 9.74938157e-04f, -3.25604856e-01f, 1.41968161e-01f, 7.54409969e-01f, -7.12330818e-01f, 6.78096890e-01f,
  3.75459105e-01f, -1.99583381e-01f, 5.17449558e-01f, -6.41237795e-01f, 3.15085612e-02f, 4.80394065e-01f, -8.39477241e-01f, 6.39445305e-01f, -4.78784472e-01f, -3.36853683e-01f,
  -8.99793386e-01f, -5.37541032e-01f, -1.82507426e-01f, -4.25457120e-01f, 3.82413536e-01f, -7.72928476e-01f, -3.68432611e-01f, -4.60354805e-01f, -5.71687400e-01f, -3.17199260e-01f,
  -2.67764628e-01f, 1.04103751e-01f, 2.59987354e-01f, -5.56983687e-02f, -3.68741781e-01f, -4.81475502e-01f, -4.65824455e-01f, -6.92653609e-03f, 1.01500690e+00f, -2.43179068e-01f,
  -1.92500010e-01f, 1.25548407e-01f, 2.85072833e-01f, 4.93274063e-01f, -4.35205132e-01f, 6.86463177e-01f, -7.85586238e-01f, 5.88360906e-01f, 4.34224233e-02f, -6.53210044e-01f,
  1.06833488e-01f, -8.56359005e-02f, 3.76284301e-01f, -5.78856885e-01f, 8.60442758e-01f, 3.94535154e-01f, -6.02374434e-01f, -6.89196289e-01f, 3.06636304e-01f, 4.99105513e-01f,
  4.77254748e-01f, 1.87102631e-01f, 5.74052036e-01f, -5.22075593e-01f, 2.64966577e-01f, 3.34467798e-01f, -2.54923970e-01f, 2.67271131e-01f, -3.89377773e-01f, -8.01284909e-01f,
  -9.17179734e-02f, 1.16118498e-01f, -5.94001710e-01f, 6.44029796e-01f, 8.16851318e-01f, 6.22782469e-01f, -9.58245754e-01f, 3.12412828e-01f, 2.84118921e-01f, -1.25245607e+00f,
  7.38282800e-01f, 4.03898150e-01f, -4.29617018e-01f, -2.94259071e-01f, -6.23569906e-01f, -2.92647779e-01f, 4.06473279e-01f, 3.72624338e-01f, -2.14475572e-01f, 7.26353884e-01f,
  2.03443602e-01f, 5.91721594e-01f, -3.41667324e-01f, 4.87366021e-01f, 7.19581366e-01f, 5.88073313e-01f, 1.32869184e-01f, 6.12802982e-01f, 4.67176616e-01f, 6.17135167e-01f,
  3.52121294e-01f, -1.23689570e-01f, 2.72320598e-01f, 2.03054160e-01f, -1.67390466e-01f, -3.46249521e-01f, -7.13583708e-01f, 2.71935761e-01f, -2.50905216e-01f, -9.46027756e-01f,
  -5.83325863e-01f, -5.08136094e-01f, 4.83814925e-01f, -4.59198296e-01f, 2.39703625e-01f, -1.06497335e+00f, 1.01618803e+00f, 9.15450752e-01f, -8.71267855e-01f, -4.45711583e-01f,
  -6.32251799e-01f, -4.75066677e-02f, -2.28631780e-01f, 1.05767176e-01f, 9.36757699e-02f, -1.52557626e-01f, 5.64801574e-01f, 1.49371341e-01f, 2.87564158e-01f, -1.86776504e-01f,
  -3.50009277e-02f, 5.75342655e-01f, -6.01258457e-01f, 6.01886153e-01f, -2.11349070e-01f, -3.43838185e-01f, -5.16612530e-01f, 7.10246861e-01f, -1.81721672e-01f, 8.39676380e-01f,
  1.18472171e+00f, 6.03993356e-01f, -1.93255037e-01f, -3.92570168e-01f, -4.37701106e-01f, -5.69479108e-01f, -8.89517844e-01f, -6.80692866e-02f, -6.48737013e-01f, 2.02301323e-01f,
  -2.13654682e-01f, -9.94395673e-01f, -8.86059523e-01f, -1.03383172e+00f, -3.12594622e-01f, -5.62249184e-01f, -3.54545027e-01f, -3.04856390e-01f, -4.14357364e-01f, 7.57396594e-02f,
  -4.28611070e-01f, -3.43469977e-01f, -1.17104523e-01f, -2.98111051e-01f, -3.26867551e-01f, -1.33970484e-01f, 3.52988034e-01f, -4.77374911e-01f, 2.81769067e-01f, -7.07121342e-02f,
  -3.44596207e-01f, -1.08957477e-01f, -6.22070849e-01f, -3.60669702e-01f, 7.65397370e-01f, -3.74122202e-01f, 4.65899557e-01f, 8.02973628e-01f, 6.23935521e-01f, -1.83859527e-01f,
  9.99055058e-02f, -1.11682802e-01f, 2.81029671e-01f, -2.91487612e-02f, -5.68323135e-01f, -1.15750897e+00f, 4.15237516e-01f, -1.31856531e-01f, -4.31791842e-01f, 5.40729798e-02f,
  8.90869796e-02f, -2.30777711e-01f, -7.24290788e-01f, 2.44102314e-01f, -3.97264898e-01f, -1.45582780e-01f, 5.11853874e-01f, 4.43707883e-01f, -7.07559824e-01f, -7.02625275e-01f,
  2.14764461e-01f, -4.43422467e-01f, 5.35766780e-01f, -2.97234625e-01f, -1.22005427e+00f, 5.51873803e-01f, -5.47446132e-01f, 2.93715894e-01f, -4.00628150e-01f, 8.56477737e-01f,
  -2.80781090e-01f, -1.03698289e+00f, -3.80404368e-02f, -1.83454543e-01f, -3.99240464e-01f, -3.84123832e-01f, 6.31183028e-01f, -5.61100304e-01f, 2.83716321e-01f, 1.16975561e-01f,
  1.63778573e-01f, -5.28668053e-02f, -8.88737943e-03f, -1.17874645e-01f, 1.08849689e-01f, -1.20258808e-01f, 3.25726151e-01f, -6.46623254e-01f, -7.26666003e-02f, 1.96750924e-01f,
  -4.44750816e-01f, 2.15569898e-01f, -2.78403372e-01f, -4.89526421e-01f, -5.82001686e-01f, -6.01643503e-01f, 5.92519224e-01f, -8.88035357e-01f, 8.24421048e-01f, -4.57181662e-01f,
  -5.93959987e-01f, -2.42977381e-01f, 4.68523562e-01f, -4.48418289e-01f, -4.74335581e-01f, -8.41231406e-01f, -7.87085652e-01f, 1.02419019e+00f, -8.58730435e-01f, -1.54478252e-01f,
  4.67937261e-01f, 2.50286460e-01f, 4.42007214e-01f, 9.04524848e-02f, 4.07358438e-01f, -2.47094035e-01f, 9.86789390e-02f, 2.14039251e-01f, 4.37561721e-01f, -4.66873385e-02f,
  5.44596136e-01f, -5.66414773e-01f, -8.05881500e-01f, -2.41365060e-01f, 4.92532015e-01f, -3.82200778e-01f, 3.47387671e-01f, -4.12627608e-01f, -7.21469104e-01f, -6.96130395e-01f,
  -2.74234325e-01f, 8.30915511e-01f, 7.50670908e-03f, -5.07233500e-01f, -7.00580537e-01f, 8.22404087e-01f, -7.67729342e-01f, -5.74394047e-01f, -3.77173334e-01f, -1.96902916e-01f,
  -2.88914829e-01f, -6.54863060e-01f, 5.59682138e-02f, 3.29270144e-03f, 3.11568588e-01f, -7.93370157e-02f, -1.43379837e-01f, 7.03746825e-02f, -3.45858425e-01f, -3.00151765e-01f,
  3.89893860e-01f, -4.64231193e-01f, -5.28254271e-01f, 4.58554894e-01f, -3.86580706e-01f, -2.60143578e-01f, 6.10830784e-01f, -6.69693768e-01f, 6.77455008e-01f, 2.28487849e-01f,
  -1.02306938e+00f, 8.85312259e-01f, 5.27507029e-02f, -2.22385228e-01f, -6.30076826e-01f, -7.97731876e-01f, -4.68887210e-01f, -2.79795319e-01f, -3.28444839e-01f, 1.08954656e+00f,
  -4.95560348e-01f, 3.46881092e-01f, -5.66134930e-01f, -3.68310869e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.63686767e-01f, 1.77498177e-01f, -2.88536429e-01f, -3.50016207e-01f, -4.68884595e-02f, 1.47459656e-01f, 2.02835634e-01f, -2.82707453e-01f, -8.94871727e-02f, 3.54897231e-02f,
  5.40679023e-02f, 1.72753438e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    