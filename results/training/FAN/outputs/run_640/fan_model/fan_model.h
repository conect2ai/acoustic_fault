/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.63232362e-01f, -1.87287256e-01f, -8.43950212e-02f, -3.21219951e-01f, -1.59636945e-01f, 7.34922513e-02f, 1.11210663e-02f, 1.60457715e-01f, 2.76487041e-03f, -1.09074861e-01f,
  -1.13991983e-01f, 1.29746884e-01f, 1.94405124e-01f, 1.12368308e-01f, 2.05988601e-01f, -7.11080879e-02f, -1.47069231e-01f, 2.56707370e-02f, 3.31711382e-01f, 2.35422194e-01f,
  -2.89137121e-02f, -3.31119299e-02f, -2.99002286e-02f, -5.08935936e-02f, -2.23983541e-01f, -2.99996324e-02f, -5.78594543e-02f, -1.81697667e-01f, -1.09106414e-01f, -4.19563651e-01f,
  -8.49682167e-02f, -2.52000153e-01f, 7.50761405e-02f, -1.40406936e-01f, -8.05571899e-02f, 3.09745409e-02f, 1.00404518e-02f, -2.54629049e-02f, -1.10399790e-01f, -5.55359274e-02f,
  -1.79520920e-01f, -4.45802882e-02f, -1.34584993e-01f, 7.52764940e-03f, 2.60512419e-02f, -1.08516798e-03f, -5.75069338e-02f, 1.32612474e-02f, 9.14105996e-02f, -3.02670896e-02f,
  -8.01223218e-02f, -2.50749111e-01f, -2.00590059e-01f, 4.54749465e-02f, 9.20142457e-02f, 4.11797548e-03f, -5.86874336e-02f, -6.66208789e-02f, 1.03221051e-02f, -1.36166915e-01f,
  -2.14215163e-02f, -3.74498498e-03f, 1.08705558e-01f, 4.90083732e-02f, 1.35203555e-01f, 5.10608964e-02f, 2.90695839e-02f, 2.70241518e-02f, 1.56601548e-01f, -4.27634902e-02f,
  5.44765368e-02f, -6.06068410e-02f, 5.73958308e-02f, -6.66904896e-02f, -6.35399669e-02f, -2.07255855e-02f, -1.52504044e-02f, -7.67104793e-03f, -2.11855099e-02f, -5.31757902e-03f,
  -1.28413104e-02f, -1.15782516e-02f, -1.23276068e-02f, 1.68439758e-03f, -8.53556022e-03f, -3.06614526e-02f, -2.72638444e-02f, 7.72213116e-02f, 7.16645941e-02f, 4.28778157e-02f,
  1.58322811e-01f, -4.04146500e-02f, -3.63023095e-02f, 1.31987119e-02f, -1.38916582e-01f, -3.39830294e-02f, -5.31574376e-02f, -8.75007361e-02f, -6.18898645e-02f, 2.55106688e-02f,
  1.40090734e-02f, 9.21944827e-02f, -2.81132255e-02f, 6.29040375e-02f, 8.79609212e-03f, 5.51609509e-02f, -2.77780294e-02f, -2.95777973e-02f, 6.68043569e-02f, -7.93741196e-02f,
  -7.09139556e-02f, 1.25166237e-01f, 9.18653384e-02f, 1.07827961e-01f, 3.81867699e-02f, 1.12370558e-01f, 1.56249553e-01f, 9.78112817e-02f, 2.28802100e-01f, 8.05560872e-02f,
  -6.65220380e-01f, -1.07124358e-01f, -3.13082226e-02f, -1.58469439e-01f, 1.71761677e-01f, 9.78231356e-02f, -3.96261737e-03f, 9.76668950e-03f, -1.01645999e-01f, -1.08388044e-01f,
  1.72514185e-01f, 2.35016868e-01f, 1.54225603e-01f, 2.04614639e-01f, -4.28073257e-02f, -1.47567987e-01f, -2.37010643e-01f, -1.42477885e-01f, -1.72963999e-02f, 1.48665652e-01f,
  1.45753026e-01f, -2.56831553e-02f, -3.61509025e-02f, 4.43875045e-03f, -6.34866804e-02f, 8.43458995e-02f, 3.97210494e-02f, 1.12967111e-01f, 5.42803742e-02f, -2.06277654e-01f,
  -3.87243740e-02f, -1.04141980e-01f, 6.11116067e-02f, -4.33497652e-02f, 6.69619367e-02f, -1.35098472e-01f, -8.79220143e-02f, -1.02954425e-01f, -1.23105600e-01f, -4.84681651e-02f,
  3.00159352e-03f, 2.19694860e-02f, 2.06009839e-02f, 9.61421877e-02f, -7.10150152e-02f, -3.50017920e-02f, -1.85115207e-02f, -3.62138413e-02f, -6.65108040e-02f, 8.48714635e-03f,
  -6.80952938e-03f, 1.04951002e-01f, -5.72907813e-02f, 1.78444702e-02f, -2.80319229e-02f, -4.69074994e-02f, 7.06120282e-02f, -5.18400408e-02f, 1.16637405e-02f, -1.03260189e-01f,
  7.05765411e-02f, 2.14474890e-02f, 2.51916647e-02f, -9.11766943e-03f, -5.04379235e-02f, -3.77244800e-02f, -6.07066043e-02f, 1.80552304e-02f, 7.32909739e-02f, 7.07697310e-03f,
  5.75384647e-02f, -6.55478165e-02f, 4.71603544e-03f, -1.19260266e-01f, 3.95833924e-02f, -4.22351845e-02f, 1.39534269e-02f, -5.09373434e-02f, 1.63354632e-02f, -1.10836886e-01f,
  -1.14291674e-02f, -4.78994921e-02f, -5.51844165e-02f, 6.33835867e-02f, -9.15292352e-02f, 8.78020655e-03f, -6.72761351e-02f, 1.93838477e-02f, 1.76730677e-02f, -6.73155263e-02f,
  -1.59873396e-01f, 8.99918750e-02f, -1.21167004e-01f, 7.35513717e-02f, -3.90262045e-02f, 6.05906881e-02f, 3.52680422e-02f, -3.70744355e-02f, 5.72785437e-02f, -6.32677525e-02f,
  1.30364403e-01f, -8.35241750e-02f, -8.10862333e-02f, 2.65844837e-02f, 9.05046910e-02f, 2.17584725e-02f, 3.67679149e-02f, -2.96656825e-02f, -1.51345301e-02f, -2.87534911e-02f,
  -3.59823108e-02f, -4.68907170e-02f, -1.57459993e-02f, 1.55391172e-02f, 7.84498453e-02f, 1.82550959e-02f, 5.08176237e-02f, 4.86911163e-02f, 5.05626909e-02f, -1.42015263e-01f,
  -2.04473510e-01f, 3.73803467e-01f, 2.86205977e-01f, 1.14737861e-01f, 2.66357005e-01f, 1.48765087e-01f, 3.50686222e-01f, -3.05284038e-02f, -1.99991092e-01f, 3.17549288e-01f,
  8.25561136e-02f, -1.30771488e-01f, -1.73593611e-01f, -2.53160149e-01f, -1.26920879e-01f, 3.85895073e-01f, 3.33636910e-01f, 3.71763785e-03f, -1.99880108e-01f, -2.05220073e-01f,
  8.86968058e-03f, 9.44994837e-02f, -1.89625114e-01f, -1.74930200e-01f, 1.23862445e-01f, 6.97743893e-02f, 1.85064957e-01f, 1.43538386e-01f, 2.44668826e-01f, 4.41770494e-01f,
  2.07268134e-01f, -3.19279730e-02f, -8.18580091e-02f, -1.40258431e-01f, 1.08179580e-02f, -6.54935613e-02f, 7.17165135e-03f, 3.74551374e-03f, -3.23767215e-02f, 7.15366900e-02f,
  3.02108321e-02f, -1.20160535e-01f, -2.13888250e-02f, -5.14639467e-02f, 5.30595938e-03f, -1.32052246e-02f, 1.05647268e-02f, -1.48314148e-01f, -7.17669874e-02f, 5.05954809e-02f,
  8.67429599e-02f, 1.46930054e-01f, 4.47879732e-02f, 5.75286336e-03f, -1.23194762e-01f, -9.01630223e-02f, 7.81890452e-02f, -6.51136711e-02f, 3.58176604e-02f, 9.11699161e-02f,
  4.35384084e-03f, -1.70326866e-02f, -1.98213104e-02f, 6.72813319e-03f, -5.26069570e-03f, -1.41875085e-03f, 8.12149420e-03f, 3.50492410e-02f, -1.05917573e-01f, 3.74655379e-03f,
  -6.76106364e-02f, 4.84355316e-02f, -1.80920176e-02f, 9.07933433e-03f, 1.08470609e-02f, 5.94933610e-03f, 1.66086515e-03f, -5.40112052e-03f, -4.10376862e-02f, -3.66306342e-02f,
  -7.27955922e-02f, -1.02763083e-02f, -4.46463861e-02f, -9.52681378e-02f, -5.00797257e-02f, -2.46942248e-02f, -1.99299008e-02f, -4.40592282e-02f, -4.83382419e-02f, 5.06012961e-02f,
  -5.30324876e-02f, -1.47155613e-01f, 1.29640818e-01f, -7.87686780e-02f, 1.12601966e-01f, 4.04484347e-02f, 1.24479756e-01f, 1.65432449e-02f, 8.66225883e-02f, -8.75297096e-03f,
  -3.15437876e-02f, 1.29477354e-02f, 5.04132509e-02f, -2.54352000e-02f, 1.85195114e-02f, -4.92649004e-02f, 8.74312147e-02f, 1.11788660e-01f, -3.49248573e-03f, 6.15578666e-02f,
  9.19127986e-02f, 9.76210013e-02f, 1.45662427e-01f, 1.09831944e-01f, 3.69026177e-02f, -4.47827362e-04f, 1.69041976e-01f, 9.63415727e-02f, 9.23644155e-02f, 3.22381049e-01f,
  5.85408390e-01f, -4.32563215e-01f, -5.68218865e-02f, 6.43071756e-02f, -3.07279110e-01f, -1.93671077e-01f, -4.71751243e-01f, -6.82893023e-02f, -3.60051617e-02f, -2.01571986e-01f,
  -2.01829702e-01f, 9.76256579e-02f, -4.02805582e-02f, 6.27789348e-02f, 2.38965489e-02f, -2.70129085e-01f, 5.65484725e-03f, 2.34553307e-01f, 2.72189587e-01f, -2.82583795e-02f,
  -1.44813225e-01f, 1.11354860e-02f, 1.23022281e-01f, 8.66259933e-02f, -6.01732656e-02f, -1.90484654e-02f, -1.43138632e-01f, -1.47057101e-01f, -1.91607073e-01f, 6.09054007e-02f,
  -1.09162703e-01f, -6.06905594e-02f, 2.61185430e-02f, -3.46585922e-02f, -1.10733435e-01f, 1.60338338e-02f, -3.69813815e-02f, 6.04746230e-02f, -1.10184550e-01f, -9.34705976e-03f,
  -3.88944782e-02f, -3.44200619e-02f, 9.42611545e-02f, -2.45221201e-02f, -3.17734443e-02f, -9.39089358e-02f, 3.14606950e-02f, 2.06340533e-02f, 2.54004225e-02f, -1.37959540e-01f,
  -1.47498876e-01f, -1.38506785e-01f, -1.71640620e-01f, -1.41314253e-01f, 1.40233673e-02f, 1.04486480e-01f, -7.42097124e-02f, -3.83116640e-02f, 4.18535210e-02f, -8.77868086e-02f,
  1.23871885e-01f, 7.59196430e-02f, 3.32522020e-02f, 1.48176821e-02f, -8.07584599e-02f, 2.80636121e-02f, 5.79813123e-02f, 3.12418560e-03f, 7.83355087e-02f, 5.20873591e-02f,
  4.89506200e-02f, 2.05992647e-02f, 2.92776469e-02f, 1.83313210e-02f, 1.51954927e-02f, 8.15458223e-03f, 1.13904029e-01f, 6.22295588e-02f, 1.66214500e-02f, 1.98615342e-02f,
  5.78080676e-02f, 7.10046440e-02f, -5.76588698e-03f, 1.15040146e-01f, -1.92377158e-02f, 7.91014656e-02f, 5.65623231e-02f, 4.87503298e-02f, 6.67745844e-02f, -1.18623814e-02f,
  -7.49465376e-02f, -1.20178886e-01f, 8.54090229e-03f, 4.53033410e-02f, 4.62211529e-03f, -6.26404136e-02f, -7.90418163e-02f, -5.00424989e-02f, 1.37671297e-02f, -4.32910100e-02f,
  2.81697558e-03f, 1.41967712e-02f, -1.49165705e-01f, -8.40786695e-02f, -7.40749016e-02f, -6.16080537e-02f, -1.90328315e-01f, -2.32768748e-02f, -7.54102990e-02f, -1.15542496e-02f,
  -7.03581199e-02f, -6.00512214e-02f, -6.45415857e-02f, -8.59676078e-02f, -5.56093529e-02f, -1.47547023e-02f, -5.65730669e-02f, -2.61079445e-02f, -7.21495822e-02f, -1.55152500e-01f,
  -4.17055666e-01f, -5.70295453e-02f, -2.15017363e-01f, -3.04926902e-01f, 5.82698695e-02f, 2.90069431e-01f, 4.63045299e-01f, 9.57978070e-02f, -1.36024341e-01f, 4.04961072e-02f,
  -4.38335352e-02f, -6.97743800e-03f, -1.05260342e-01f, -1.02012912e-02f, 1.05232462e-01f, 9.65562686e-02f, -1.00814298e-01f, -1.28124729e-01f, 1.84951648e-01f, 2.54926324e-01f,
  7.52045438e-02f, -1.19370006e-01f, -6.34162128e-02f, 4.56362311e-03f, -9.44152996e-02f, -3.48548815e-02f, -2.29375422e-01f, -2.02728644e-01f, -9.96267200e-02f, -3.68525684e-01f,
  -7.70499110e-02f, -3.72586191e-01f, 1.04447812e-01f, -1.09518476e-01f, -1.33471161e-01f, -6.97674304e-02f, -7.55962962e-03f, -1.95774570e-01f, -7.64321610e-02f, -7.84637630e-02f,
  -1.27503753e-01f, -1.29820621e-02f, -1.02169789e-01f, -1.29418686e-01f, -1.50861666e-01f, -6.69871792e-02f, -1.03204481e-01f, -2.46825159e-01f, -1.37988433e-01f, -5.71743213e-02f,
  -5.01077324e-02f, -1.61794245e-01f, -1.28971055e-01f, 1.89833753e-02f, -1.19094945e-01f, -1.32079348e-01f, -2.41862312e-02f, -5.78453839e-02f, -8.67186040e-02f, -8.70065913e-02f,
  7.59507418e-02f, -2.31219064e-02f, -4.12514061e-03f, 1.07308179e-01f, 9.57209244e-02f, 8.01662263e-03f, -5.39430864e-02f, 1.39342751e-02f, 8.53549689e-02f, 1.15683973e-01f,
  2.95875072e-02f, 1.15120225e-01f, -2.85717491e-02f, 3.76899503e-02f, 6.22917451e-02f, 6.60411641e-02f, 7.72536844e-02f, 4.83577698e-02f, 1.05844878e-01f, 9.87323821e-02f,
  2.15953719e-02f, 1.23055652e-04f, 8.35659634e-03f, -2.04237439e-02f, -1.34005316e-03f, -2.44072545e-02f, -3.93686257e-03f, 6.61334544e-02f, 3.69429812e-02f, 1.19508039e-02f,
  1.31880060e-01f, -5.90913817e-02f, 2.82983365e-03f, 1.92824733e-02f, -8.64300281e-02f, -1.16195992e-01f, -4.85316515e-02f, -2.59330794e-02f, -6.96439445e-02f, -3.22904019e-03f,
  -7.46927783e-02f, -5.72077818e-02f, -1.46955013e-01f, -2.96534617e-02f, 4.98936959e-02f, -5.18546663e-02f, 5.65750003e-02f, 5.97502925e-02f, -1.71734598e-02f, -3.21251713e-02f,
  7.99807087e-02f, 7.61014363e-03f, 1.62783623e-01f, 1.01812392e-01f, -1.01225652e-01f, 1.41209541e-02f, 1.34524703e-01f, -3.68591957e-02f, 1.20333306e-01f, 1.75013870e-01f,
  6.58364713e-01f, 2.84186155e-01f, 5.40174209e-02f, 3.40008318e-01f, -1.69648170e-01f, -3.50992195e-02f, 1.17565066e-01f, 1.44313022e-01f, 1.84299931e-01f, 8.55332017e-02f,
  -1.71687648e-01f, -2.69350797e-01f, -1.13928303e-01f, -2.83053875e-01f, 8.29025358e-02f, 1.63752601e-01f, 9.50400904e-02f, -7.75967585e-03f, -6.91701025e-02f, -2.15838462e-01f,
  -1.55003190e-01f, 2.25301817e-01f, 2.71674663e-01f, 4.64365669e-02f, 2.60228897e-03f, -6.82985112e-02f, 1.20395891e-01f, 8.38598758e-02f, -2.11682662e-01f, -7.81011581e-02f,
  -1.69225812e-01f, 2.20977977e-01f, -1.36144474e-01f, -9.97440219e-02f, -1.42066693e-02f, 8.75894576e-02f, -3.01895459e-04f, 1.59517616e-01f, 1.57834415e-03f, 6.44788668e-02f,
  -4.49622944e-02f, -5.68532832e-02f, -5.58893383e-02f, -4.16289382e-02f, 1.12217613e-01f, -3.58322263e-03f, 1.32135600e-01f, 8.54386166e-02f, -2.95220148e-02f, -1.07308447e-01f,
  -1.60243258e-01f, -2.47992743e-02f, 3.45843397e-02f, -4.54894342e-02f, -7.87517652e-02f, -1.73831105e-01f, -3.62694338e-02f, -6.76601976e-02f, 7.88839981e-02f, 1.42146170e-01f,
  3.41900475e-02f, -6.99504241e-02f, -8.53894353e-02f, 1.25575950e-02f, -1.21208839e-02f, 5.36686974e-03f, -2.58835312e-02f, -1.54349040e-02f, -5.35608754e-02f, 3.79531905e-02f,
  2.45938799e-03f, -5.74276298e-02f, -4.85279225e-02f, 1.15261033e-01f, -5.04541621e-02f, -1.00335144e-01f, -3.25439684e-02f, 1.18294945e-02f, -8.29292461e-04f, 8.78534392e-02f,
  -3.30788121e-02f, 1.49103273e-02f, 6.14367872e-02f, -7.81108811e-02f, -1.40063502e-02f, -5.04539115e-03f, -3.07053663e-02f, -1.15266643e-01f, -1.63181461e-02f, -2.87845414e-02f,
  2.67392635e-01f, -1.52600899e-01f, 7.27833062e-02f, -9.56865773e-03f, 5.48660159e-02f, 2.30481066e-02f, 4.76008467e-02f, -3.68912145e-02f, -9.45576951e-02f, 6.63503483e-02f,
  -3.10302805e-02f, 5.11386134e-02f, 8.79605487e-03f, -8.18534475e-03f, -4.32931371e-02f, 7.11888075e-02f, -1.63223501e-02f, -6.74060434e-02f, -5.35893813e-02f, 6.40913919e-02f,
  7.00419024e-02f, 2.33502891e-02f, 4.85397018e-02f, 5.65881506e-02f, -4.74866144e-02f, 3.94874923e-02f, 8.42797477e-03f, -1.29425796e-02f, 6.31292015e-02f, 2.82001704e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.14753646e-01f, 6.05188012e-01f, 1.95565566e-01f, 1.66700836e-02f, 1.92056060e-01f, 1.21767566e-01f, 4.23228562e-01f, -4.42847498e-02f, -2.67810732e-01f, 1.09866291e-01f,
  1.25026926e-01f, -2.41020262e-01f, -1.52581140e-01f, -1.59978032e-01f, -1.33142143e-01f, 5.57506606e-02f, 7.39521980e-02f, -1.66604429e-01f, -3.14006031e-01f, -1.66541770e-01f,
  -6.75116926e-02f, -4.91734557e-02f, -8.95381793e-02f, -8.14321935e-02f, 1.65040240e-01f, -1.73332274e-01f, 1.10922664e-01f, 1.99041694e-01f, 1.88684613e-01f, 4.13143337e-01f,
  1.21625699e-01f, 3.84852916e-01f, -5.21186173e-01f, -1.20358162e-01f, -6.61773514e-03f, -1.21579934e-02f, -8.71178210e-02f, -1.25832427e-02f, 6.24753209e-03f, 1.56057244e-02f,
  7.17291683e-02f, 2.42074966e-01f, 1.56956077e-01f, 8.39258656e-02f, -3.73219587e-02f, -3.45017854e-03f, 4.35194708e-02f, -7.80253485e-02f, -1.13653883e-01f, 1.13712074e-02f,
  1.52534246e-01f, 1.94548815e-01f, 5.56711704e-02f, -1.51604474e-01f, -4.92490940e-02f, -2.20412329e-01f, 1.85299873e-01f, 7.87815675e-02f, -2.08273545e-01f, 2.14276269e-01f,
  -2.14135647e-01f, 1.58593252e-01f, 2.54098624e-01f, 1.40710086e-01f, 8.18232074e-02f, -1.68876573e-02f, 5.51844612e-02f, 5.00221476e-02f, 1.70927774e-02f, 4.43832874e-02f,
  -4.90811281e-02f, -7.00585619e-02f, -6.55294582e-02f, 3.11253760e-02f, -9.36033055e-02f, 1.00508370e-01f, 1.84200739e-03f, -2.39404868e-02f, -1.01352289e-01f, 5.23550957e-02f,
  -4.20348197e-02f, -9.40102860e-02f, 3.46171670e-02f, 1.80153325e-02f, -5.83236180e-02f, -3.28462496e-02f, -1.70029759e-01f, -8.83183852e-02f, -6.46189451e-02f, 6.02694117e-02f,
  -3.27208519e-01f, -2.20855296e-01f, -1.69779956e-01f, 1.40476033e-01f, 6.34041876e-02f, 1.69093031e-02f, -3.91244441e-02f, -2.12199707e-02f, 1.96286634e-01f, -1.80015609e-01f,
  1.26569092e-01f, -1.34681717e-01f, 4.87485193e-02f, -5.39293736e-02f, -1.67161465e-01f, -1.04367295e-02f, 1.62070151e-02f, 8.70496184e-02f, -9.75447819e-02f, 1.24701627e-01f,
  -2.11367458e-02f, -2.50111580e-01f, -2.97922879e-01f, -2.74811476e-01f, -2.80293286e-01f, -5.45440912e-01f, -1.59323201e-01f, -8.05484354e-02f, -2.41457388e-01f, -1.91805884e-01f,
  -1.10129893e-01f, 1.60671007e-02f, 1.74808621e-01f, -1.57049686e-01f, -3.11349303e-01f, -5.63184261e-01f, -5.76981723e-01f, -4.83775377e-01f, -3.64642560e-01f, -1.11008883e-01f,
  2.21519083e-01f, 5.28910697e-01f, 5.55278540e-01f, 1.81861192e-01f, -1.20028436e-01f, -1.31743774e-01f, -1.79312453e-01f, -2.21849345e-02f, -1.74509525e-01f, -3.52878898e-01f,
  -5.74164614e-02f, -8.26210715e-03f, -8.97724554e-02f, -2.48385057e-01f, 3.91629674e-02f, 2.55788118e-01f, 2.39693634e-02f, -1.12050228e-01f, -9.20215845e-02f, 1.01674929e-01f,
  5.89776635e-01f, -3.55165035e-01f, -1.84101179e-01f, -1.77084073e-01f, 1.12113841e-01f, -1.10762581e-01f, 3.21611501e-02f, -8.80465135e-02f, -4.77246977e-02f, -2.78452840e-02f,
  -1.38395466e-02f, -8.12432915e-02f, -6.14264561e-03f, -6.95840176e-03f, -1.37855038e-01f, -4.36179563e-02f, -1.69042796e-01f, -1.13954782e-01f, -7.66774267e-02f, 3.55140232e-02f,
  -2.13207025e-02f, -3.96573208e-02f, 4.56184149e-02f, -1.34354144e-01f, -2.68415034e-01f, 9.57425609e-02f, -9.58352014e-02f, -1.42034516e-01f, -2.44619086e-01f, 5.57847172e-02f,
  -7.51734152e-02f, 2.37786621e-01f, -1.25570208e-01f, 3.64609323e-02f, 1.45759702e-01f, 6.55855164e-02f, 9.62206945e-02f, -8.95959139e-03f, -6.66173361e-03f, 7.21456930e-02f,
  -1.72543600e-02f, 8.70558061e-03f, -3.59203443e-02f, -1.44382901e-02f, -5.12596220e-03f, -1.22884654e-01f, 4.93902620e-03f, 3.44035849e-02f, -1.55440062e-01f, 1.46177709e-02f,
  -4.73576151e-02f, 2.23434102e-02f, 5.35443090e-02f, -4.00851592e-02f, -1.43885463e-01f, -5.46475779e-03f, -1.31855831e-01f, -7.74880573e-02f, 7.75192082e-02f, -5.49772866e-02f,
  4.27939504e-01f, -2.03282610e-01f, 3.35159808e-01f, 1.44987823e-02f, -7.94436932e-02f, -9.45981368e-02f, 7.99593404e-02f, -1.19268499e-01f, 1.97941214e-02f, 1.32872807e-02f,
  -1.47005364e-01f, -1.23140834e-01f, 7.77146071e-02f, 2.94320006e-02f, -1.44884601e-01f, -9.57400650e-02f, -1.31252587e-01f, 9.96241048e-02f, -1.55068383e-01f, -7.10045621e-02f,
  -1.98621929e-01f, -1.48982227e-01f, 2.99232900e-01f, 1.29595980e-01f, -5.03833704e-02f, 1.76485613e-01f, 3.01313639e-01f, 5.86182810e-02f, 1.35076523e-01f, 1.01652078e-01f,
  -2.17323959e-01f, -2.00719848e-01f, 1.98728070e-01f, 1.85576811e-01f, -1.35014519e-01f, -3.25721532e-01f, -4.05041724e-01f, -1.01800606e-01f, 1.31465301e-01f, 1.11283350e-03f,
  -2.53227234e-01f, 6.66108727e-02f, 2.73752928e-01f, 2.77582377e-01f, 2.64726222e-01f, 2.39741996e-01f, 4.08250928e-01f, 5.38791955e-01f, 2.47597307e-01f, 7.48979449e-02f,
  1.20086774e-01f, 2.83447117e-01f, 1.92289412e-01f, 3.86870712e-01f, 1.77427068e-01f, 3.15718383e-01f, 2.08270580e-01f, 1.70447662e-01f, 1.84070632e-01f, 5.21311700e-01f,
  -8.14228493e-04f, -9.16448832e-02f, 2.64869779e-01f, 5.74005172e-02f, -4.31432538e-02f, -8.37504491e-02f, -1.03415318e-01f, 7.18635172e-02f, -1.81684032e-01f, 7.36844465e-02f,
  -7.31166527e-02f, -1.33213893e-01f, 8.25093985e-02f, 3.30702253e-02f, -1.34791642e-01f, -1.11322187e-01f, 2.52582937e-01f, 2.04067186e-01f, 2.42698893e-01f, -1.84867289e-02f,
  7.62994960e-02f, -4.77409810e-02f, -2.23448381e-01f, 4.16405685e-02f, 9.39808711e-02f, 1.41717389e-01f, -9.23019350e-02f, 1.25531554e-01f, 1.18854053e-01f, 2.42011994e-03f,
  1.57479644e-01f, 1.14292622e-01f, 5.26029207e-02f, 2.07047239e-01f, 8.60044137e-02f, 2.19359361e-02f, 1.09399267e-01f, -4.65715490e-02f, 1.32020876e-01f, -2.66490169e-02f,
  4.45159115e-02f, 9.72917769e-03f, 4.11148965e-02f, -1.66728199e-02f, 1.61267426e-02f, 2.69368794e-02f, -1.67747349e-01f, 6.72650384e-03f, -2.77418420e-02f, -6.40853867e-02f,
  4.94687492e-03f, 5.29384315e-02f, -9.41880941e-02f, 4.68423739e-02f, -7.90222436e-02f, 1.26818717e-01f, -2.88357027e-02f, -9.22625065e-02f, -2.28240844e-02f, -2.37355591e-03f,
  -1.60064310e-01f, 2.68059134e-01f, 1.06749631e-01f, 3.61655280e-02f, -1.22538127e-01f, -1.77885070e-01f, 9.81545746e-02f, -3.39283943e-02f, -1.36158153e-01f, -1.26108691e-01f,
  -1.81760132e-01f, -1.41326278e-01f, -4.56395112e-02f, 2.72466857e-02f, -1.20645933e-01f, -1.22342549e-01f, -6.76397607e-02f, 1.86533947e-02f, 8.00009668e-02f, -1.99584290e-01f,
  3.12952772e-02f, -2.38385066e-01f, -3.52428943e-01f, -1.06072634e-01f, -6.54409528e-02f, -9.48584378e-02f, -1.69923320e-01f, -2.08138287e-01f, -2.14337572e-01f, -2.08870813e-01f,
  -6.86548725e-02f, 1.43534154e-01f, -4.22949791e-01f, 4.23742473e-01f, 1.44011781e-01f, -4.53874677e-01f, -5.95097542e-01f, -3.80970180e-01f, 3.04931074e-01f, 1.24673709e-01f,
  6.62508309e-02f, 3.58889967e-01f, 1.79499134e-01f, 8.35823938e-02f, -3.51846606e-01f, 3.04911658e-02f, 4.66592401e-01f, -1.06085595e-02f, -3.77377629e-01f, -1.20392404e-01f,
  2.34900802e-01f, 9.78904814e-02f, -2.00823262e-01f, 3.21409404e-02f, 3.63223284e-01f, 9.22627077e-02f, 5.14496192e-02f, 2.06118077e-01f, 2.39828750e-02f, 6.71214581e-01f,
  -1.28405988e-01f, -2.89500803e-01f, -2.82690287e-01f, 2.21876204e-01f, 9.91005152e-02f, 2.51828339e-02f, -9.30948406e-02f, -2.53618080e-02f, 4.70848940e-02f, 5.60284853e-02f,
  1.85263127e-01f, -8.73642936e-02f, 4.07948583e-01f, -4.45497185e-02f, -2.31271051e-02f, -3.28325987e-01f, -1.73646435e-01f, -3.12471211e-01f, -2.80709058e-01f, -1.64815366e-01f,
  4.73442942e-01f, 8.39906633e-02f, -4.64432389e-01f, -4.32717323e-01f, -3.26900929e-01f, 6.36665672e-02f, -3.54117692e-01f, -2.20635504e-01f, -6.67381942e-01f, 3.68508734e-02f,
  -6.51172996e-02f, -1.34365961e-01f, -5.23615964e-02f, 1.28740996e-01f, 1.65123656e-01f, 1.54068500e-01f, 1.53316826e-01f, -3.36750932e-02f, 1.60248503e-01f, -6.01113066e-02f,
  1.22652799e-02f, 5.89187853e-02f, 6.93866685e-02f, -2.90320888e-02f, 1.43469915e-01f, -7.63051733e-02f, -5.69861010e-02f, -7.94095919e-02f, -1.95314750e-01f, -6.40748069e-02f,
  1.70925915e-01f, 2.37637535e-02f, 9.65004712e-02f, -1.07393991e-02f, -3.57364044e-02f, -2.08667386e-03f, 9.34098437e-02f, 8.91918167e-02f, 6.61398545e-02f, 5.93181066e-02f,
  3.51445749e-02f, -2.92139560e-01f, 1.23949915e-01f, -1.35708392e-01f, -1.74485426e-02f, 1.43455282e-01f, 8.97198394e-02f, -4.64101247e-02f, 1.05800495e-01f, -1.85568944e-01f,
  -1.15009040e-01f, -1.57848448e-01f, 6.17870092e-02f, -9.16830227e-02f, 1.04427133e-02f, 6.17391476e-03f, 1.36538446e-01f, 1.90383241e-01f, -5.25534861e-02f, 4.98348176e-02f,
  -8.74878243e-02f, -3.24620366e-01f, -3.47017765e-01f, -3.89750510e-01f, 3.50772217e-02f, -2.43532658e-02f, -3.70817393e-01f, -1.50840655e-01f, -7.39986777e-01f, -3.21913064e-01f,
  8.41136932e-01f, 3.55144590e-01f, 1.42582133e-01f, 4.59432453e-01f, 3.77868861e-01f, 6.11883067e-02f, -2.10689707e-03f, -1.31580576e-01f, 7.09808245e-02f, 2.88101077e-01f,
  3.31411272e-01f, 3.45852256e-01f, 1.83974937e-01f, -4.22717538e-03f, -9.01485234e-02f, -4.79058139e-02f, -1.24591127e-01f, -5.28035834e-02f, 7.38761202e-03f, 1.29142493e-01f,
  1.07776664e-01f, 1.06856212e-01f, 2.94172823e-01f, 8.08904693e-02f, 3.01657945e-01f, 1.87129185e-01f, 5.29642142e-02f, 3.12255830e-01f, 3.15135926e-01f, 3.98757368e-01f,
  3.33438486e-01f, 3.45166832e-01f, -1.08798079e-01f, 1.06327645e-01f, 1.05314642e-01f, -7.40248486e-02f, 9.70822349e-02f, -7.79204443e-02f, -4.95271645e-02f, -9.64993760e-02f,
  1.30118370e-01f, 3.75386178e-02f, 1.77876446e-02f, -3.20976004e-02f, -6.92422464e-02f, -1.03455805e-03f, -2.35145509e-01f, -1.97577566e-01f, -8.33954513e-02f, 5.06787784e-02f,
  -2.34257579e-02f, 8.36643651e-02f, -7.19160512e-02f, -2.33523250e-01f, -1.24316528e-01f, 8.50274414e-02f, -7.69800916e-02f, -2.42676735e-02f, -1.20003037e-01f, -8.55208114e-02f,
  2.03131199e-01f, 1.47025093e-01f, 1.80545896e-01f, -3.78437042e-02f, -9.03127193e-02f, -5.22659905e-02f, -7.05146790e-02f, -4.04613465e-02f, -7.20866546e-02f, 1.08113373e-02f,
  -7.11684301e-02f, 1.21353038e-01f, -8.27440172e-02f, 3.16981860e-02f, 4.72484827e-02f, 1.23723611e-01f, 1.09833099e-01f, -2.10372172e-02f, -2.15601083e-02f, -1.44767738e-03f,
  -2.61954102e-03f, -2.02023596e-01f, 7.39701849e-04f, -1.20663591e-01f, -9.33802724e-02f, 3.83638926e-02f, -1.02022670e-01f, -2.66765035e-03f, 1.47879273e-02f, -4.73523475e-02f,
  -2.54588485e-01f, 8.00551102e-02f, 1.37621328e-01f, -1.90600771e-02f, 1.55761391e-01f, 7.20091537e-02f, 2.06725210e-01f, 1.16379254e-01f, 1.76854461e-01f, 3.21359523e-02f,
  3.52283716e-02f, 7.00910538e-02f, 1.28883803e-02f, -2.10294396e-01f, -1.71991155e-01f, -1.53653443e-01f, -3.59954871e-02f, 5.06562740e-02f, -1.21494427e-01f, -8.49855505e-03f,
  -1.58667237e-01f, -2.18114868e-01f, -1.43203318e-01f, -1.68032110e-01f, -1.83770657e-01f, 5.49244955e-02f, -5.23189977e-02f, -1.48654789e-01f, -8.86577070e-02f, -2.53953785e-01f,
  5.67427695e-01f, 1.71848778e-02f, -1.51509583e-01f, 1.70612663e-01f, -1.64811701e-01f, -8.12957138e-02f, -2.87604898e-01f, -2.48512756e-02f, 1.29973680e-01f, 7.08857402e-02f,
  3.51097733e-01f, 3.66759062e-01f, 3.43770176e-01f, 3.35031122e-01f, 2.75643259e-01f, -7.09238872e-02f, -1.71132222e-01f, 4.18696404e-02f, -8.40356760e-03f, 2.60625463e-02f,
  -4.26674820e-02f, -5.27732745e-02f, 4.49892841e-02f, 1.42178545e-03f, -9.80033427e-02f, 2.02665124e-02f, -6.97811618e-02f, -5.01569882e-02f, -1.48455892e-02f, -4.76827323e-02f,
  -1.53623998e-01f, 2.85544574e-01f, 2.77032167e-01f, 2.77710944e-01f, 7.92637281e-03f, 1.39200732e-01f, 3.80721428e-02f, -7.13257864e-02f, 2.12327447e-02f, -8.13716128e-02f,
  3.30638736e-02f, -4.39801738e-02f, -1.77100133e-02f, -1.20395429e-01f, -1.19195767e-01f, 1.75861157e-02f, -2.71633696e-02f, -7.43471012e-02f, 4.56348993e-02f, 7.99251646e-02f,
  5.98167628e-02f, 1.59221664e-02f, -1.14016913e-01f, 1.18570421e-02f, 1.40870791e-02f, 2.51357526e-01f, 1.92058422e-02f, -3.60515118e-02f, 1.00157320e-01f, -1.18579427e-02f,
  1.73542395e-01f, 1.52222309e-02f, 1.69037990e-02f, 6.52089044e-02f, 2.87321657e-02f, 7.25042671e-02f, -3.28373816e-03f, -1.10361360e-01f, 1.31998083e-03f, -1.35864288e-01f,
  -1.21289961e-01f, 1.63366683e-02f, 9.03804153e-02f, -6.57412857e-02f, 1.23385474e-01f, -1.21507049e-01f, -1.35299057e-01f, -3.67359333e-02f, 6.27961233e-02f, -7.25462586e-02f,
  -6.19936921e-02f, -8.75870734e-02f, -7.93160722e-02f, -2.10516736e-01f, 1.00325784e-02f, -1.02371030e-01f, -6.90768808e-02f, 1.30246691e-02f, -1.49400845e-01f, -7.39582404e-02f,
  -1.41175911e-01f, 2.89030343e-01f, 9.16612372e-02f, -4.15956452e-02f, -5.18763065e-03f, -1.13862604e-02f, 1.53604418e-01f, 1.09366417e-01f, -4.53639068e-02f, 2.55528577e-02f,
  6.25844374e-02f, 4.65998473e-03f, -1.43190026e-01f, -5.59836589e-02f, 1.57567265e-03f, 5.75954653e-03f, 1.96808234e-01f, -9.07166768e-03f, 7.25515261e-02f, 7.89680481e-02f,
  -4.41798270e-02f, 1.53697163e-01f, 2.92097241e-01f, 2.55219519e-01f, 1.63499787e-01f, 2.47149661e-01f, 1.63897783e-01f, -3.84321087e-03f, 1.46560013e-01f, 6.59476742e-02f,
  6.79804742e-01f, -4.78751451e-01f, -6.74248934e-01f, -2.91096810e-02f, -1.04217395e-01f, 2.05521688e-01f, 6.24050051e-02f, 1.27817169e-01f, 9.47413817e-02f, -2.18143925e-01f,
  -3.09972852e-01f, -1.36152923e-01f, -3.34858865e-01f, -9.93931442e-02f, 2.70333976e-01f, -1.84048831e-01f, -1.76146910e-01f, 8.68113115e-02f, 3.31945181e-01f, 2.11561516e-01f,
  6.53735250e-02f, 7.61723444e-02f, 1.80426657e-01f, -4.64198552e-02f, -5.01022816e-01f, -1.66362450e-01f, -5.95324218e-01f, -2.56081045e-01f, -1.42947823e-01f, -5.33398569e-01f,
  -3.75934899e-01f, -1.86458915e-01f, -4.88280319e-02f, 2.56002545e-01f, -1.43565685e-01f, 1.37685463e-01f, 9.76835378e-03f, -1.21419087e-01f, -2.13408470e-03f, -2.10531622e-01f,
  -1.08028419e-01f, 6.74075633e-02f, -1.05015673e-01f, -1.21055983e-01f, -5.73578924e-02f, 1.65913075e-01f, -4.47963141e-02f, -2.07299776e-02f, -3.04655731e-02f, -1.36749178e-01f,
  -8.40893164e-02f, 5.00622615e-02f, -1.97324991e-01f, -5.19818738e-02f, -1.33843511e-01f, 4.34842631e-02f, -1.76419467e-01f, -1.73292994e-01f, -6.01317100e-02f, -1.98579833e-01f,
  -2.87565272e-02f, -2.25478020e-02f, 3.44944075e-02f, -7.84961320e-03f, 1.18106753e-01f, -2.41564978e-02f, -1.47568183e-02f, 1.51711166e-01f, 1.29953086e-01f, 4.58352901e-02f,
  -7.54601657e-02f, -1.31322116e-01f, -4.18407768e-02f, -2.30154563e-02f, 1.17013790e-02f, 1.32102380e-02f, 1.66827980e-02f, 1.25294570e-02f, -1.03703506e-01f, 1.01927876e-01f,
  4.75259311e-02f, 2.36643590e-02f, -1.43440872e-01f, 4.49346006e-02f, -5.67860007e-02f, -5.77977523e-02f, -6.46977052e-02f, -4.95861061e-02f, 4.29075398e-02f, 1.34496406e-01f,
  -1.34100104e-02f, 1.72190115e-01f, -1.26344725e-01f, -1.01066707e-02f, -3.25077176e-02f, -2.83822976e-02f, -3.98764051e-02f, -4.92770132e-03f, -1.55450087e-02f, 5.95692024e-02f,
  -3.58066075e-02f, 4.47662920e-02f, -2.79945344e-01f, -9.82220322e-02f, 1.73352420e-01f, 3.09581328e-02f, 1.29239887e-01f, 1.59838527e-01f, -2.49757841e-02f, 6.88703880e-02f,
  8.56978968e-02f, 3.63848269e-01f, 2.68874288e-01f, 7.86652416e-02f, -2.41980813e-02f, 2.01765791e-01f, -7.20018744e-02f, -7.06031993e-02f, 1.76763862e-01f, 2.32162163e-01f,
  5.45643330e-01f, 6.87948108e-01f, 4.15861219e-01f, -1.53264299e-01f, -5.86321235e-01f, -3.35903168e-01f, -1.88005760e-01f, 1.72891899e-03f, -1.03945233e-01f, -8.29672217e-02f,
  -2.60024428e-01f, -2.73531199e-01f, -2.06312612e-02f, 4.92222160e-02f, 2.11456463e-01f, 2.34939262e-01f, 2.46959001e-01f, 3.07840616e-01f, -3.11650038e-02f, -2.14512348e-01f,
  -3.74719873e-02f, 1.66211843e-01f, 3.39353234e-01f, 2.30060607e-01f, 1.32679716e-01f, -1.54706419e-01f, 3.52446642e-03f, 4.22038473e-02f, -4.23692651e-02f, 4.05301243e-01f,
  -1.90408342e-02f, 1.70189992e-01f, -3.26604933e-01f, -3.71136628e-02f, 1.33176565e-01f, 1.75495088e-01f, 9.72687006e-02f, 1.22232422e-01f, -5.72627597e-02f, 1.99662521e-02f,
  -6.43799901e-02f, -9.56839323e-02f, -2.49114372e-02f, -9.71267652e-03f, -1.09244093e-01f, -3.31583014e-03f, 1.95290059e-01f, 2.96282649e-01f, 1.71758384e-01f, 8.58438984e-02f,
  -5.35188466e-02f, -1.81955621e-01f, -1.08254887e-01f, -2.02485591e-01f, 5.19014485e-02f, -2.46806815e-01f, -7.61144310e-02f, -7.87364691e-03f, -6.19739220e-02f, 5.55923171e-02f,
  -2.06552044e-01f, -7.81330243e-02f, 1.22641744e-02f, -5.40882461e-02f, -9.03256088e-02f, -3.82908396e-02f, -4.01782878e-02f, -1.86370295e-02f, 3.85184176e-02f, 9.44080427e-02f,
  -5.21477237e-02f, -7.31043294e-02f, 6.16232445e-03f, 3.11930664e-02f, 7.88861439e-02f, 1.55305499e-02f, 5.81309907e-02f, -1.05507784e-01f, -1.53841749e-01f, -1.01503082e-01f,
  -7.02569261e-02f, 1.19335894e-02f, 2.00740760e-03f, 2.03281179e-01f, -6.92069605e-02f, -7.75263011e-02f, -1.27426580e-01f, -4.99419942e-02f, 5.55287004e-02f, 3.08618322e-02f,
  -6.20128885e-02f, -3.28598320e-01f, -1.22200996e-01f, 2.21918151e-01f, 1.41586095e-01f, 1.91424355e-01f, 1.49166644e-01f, -7.86572769e-02f, 4.96791899e-02f, 9.82907787e-02f,
  1.41580582e-01f, 1.43811807e-01f, 1.17181681e-01f, 1.14461742e-01f, -3.64336930e-02f, -1.62782654e-01f, -7.93156847e-02f, 1.29627571e-01f, 5.31321131e-02f, 1.01404287e-01f,
  -5.54723479e-02f, -2.43722677e-01f, -3.38783711e-01f, -2.81083286e-01f, -1.89866349e-01f, -4.20971811e-01f, -1.59713075e-01f, -8.06805342e-02f, -1.79500535e-01f, -1.96251776e-02f,
  -5.45034051e-01f, -3.41559649e-02f, 5.96679449e-01f, -3.35411340e-01f, 2.69198030e-01f, 6.03491627e-02f, -2.09347785e-01f, -2.89356977e-01f, -1.22888669e-01f, -1.46089107e-01f,
  6.99250028e-02f, -1.56483695e-01f, 5.40654582e-04f, -7.09002241e-02f, -2.54695326e-01f, -9.64486003e-02f, -1.26378179e-01f, 1.18520921e-02f, -1.49654865e-01f, -3.02898496e-01f,
  -3.59380454e-01f, -3.42614084e-01f, -2.59052336e-01f, -1.20269723e-01f, -2.40800187e-01f, -1.95734799e-01f, 1.95960149e-01f, -1.68824583e-01f, 8.50632265e-02f, -1.99307635e-01f,
  -4.61043231e-02f, -1.81615829e-01f, 1.90520898e-01f, -7.14965537e-02f, 8.61749947e-02f, -3.38828675e-02f, -2.26046741e-02f, -2.63662711e-02f, 1.37420550e-01f, 8.01101699e-02f,
  -5.56145944e-02f, 9.03186128e-02f, -3.63755673e-02f, -7.88339674e-02f, -2.36197829e-01f, -3.58288825e-01f, -2.92362303e-01f, -9.85604972e-02f, 2.97743711e-04f, 2.64233276e-02f,
  -2.60928363e-01f, -2.35525504e-01f, -4.61404286e-02f, -5.22794537e-02f, -7.26744439e-03f, 7.90564902e-03f, -5.61542213e-02f, -2.29090631e-01f, -7.15874285e-02f, -3.92149508e-01f,
  -5.87966992e-03f, 1.71554267e-01f, 1.46935850e-01f, 1.01497941e-01f, -9.14442241e-02f, -1.03958314e-02f, 1.40733153e-01f, -9.27969441e-02f, -2.95798145e-02f, 5.22541776e-02f,
  3.02514851e-01f, 8.04963335e-02f, 1.30588010e-01f, -1.20610707e-02f, -3.41971405e-02f, -1.45308241e-01f, 6.35046363e-02f, -1.45151585e-01f, -8.97327736e-02f, 1.75006464e-02f,
  -2.40180209e-01f, -2.51614805e-02f, -7.72420764e-02f, -1.63506955e-01f, -2.67628599e-02f, -2.29396775e-01f, -1.77576214e-01f, -1.69405907e-01f, -9.23407078e-02f, -1.25584796e-01f,
  -2.18309596e-01f, 3.98479313e-01f, -2.00966567e-01f, -1.63390130e-01f, -1.52317896e-01f, 6.57012835e-02f, -1.94751297e-03f, 1.69938862e-01f, -2.83340719e-02f, -1.69815093e-01f,
  3.11967004e-02f, -2.12377384e-01f, 7.80677646e-02f, -1.07857049e-01f, -3.10838111e-02f, -2.44576260e-01f, -3.98168325e-01f, -1.81587875e-01f, -1.78286526e-02f, -3.01062226e-01f,
  -2.35141620e-01f, -4.06302273e-01f, -4.86068755e-01f, -3.26107144e-01f, -3.42587322e-01f, -4.35485184e-01f, -4.90802586e-01f, -2.49152467e-01f, -2.72130460e-01f, -7.63308764e-01f,
  6.89252734e-01f, -1.89172417e-01f, 2.10958496e-02f, 3.06291312e-01f, 2.37894103e-01f, 1.98493958e-01f, 2.37621441e-02f, 1.13818437e-01f, 3.14498752e-01f, 3.62082452e-01f,
  3.77895951e-01f, 4.19150710e-01f, 3.07495236e-01f, 2.61207163e-01f, 2.70651519e-01f, 1.09146774e-01f, -1.66512191e-01f, 1.11524493e-01f, 2.06648782e-01f, 1.84330091e-01f,
  1.40439615e-01f, -8.66252929e-02f, 2.26088036e-02f, 8.64983872e-02f, -2.33381279e-02f, 8.67352560e-02f, -1.03525996e-01f, -8.69385302e-02f, -7.78909400e-02f, -2.52156585e-01f,
  1.07338600e-01f, -2.05788165e-01f, 7.71050667e-03f, -4.39788885e-02f, -1.98113531e-01f, -6.91920891e-02f, -7.31491148e-02f, -1.51033282e-01f, -3.72758768e-02f, -4.95962650e-02f,
  -1.51095003e-01f, -1.34599619e-02f, 2.98701436e-03f, -1.33176476e-01f, -1.76309701e-02f, 1.18768126e-01f, 1.48142991e-03f, 8.90722498e-04f, -6.79821670e-02f, -2.33571101e-02f,
  4.31215949e-03f, 8.43896270e-02f, -7.44559765e-02f, -1.76682621e-02f, -2.96319406e-02f, 1.98368095e-02f, -2.82217190e-02f, -8.78958106e-02f, -1.24046624e-01f, -1.91294298e-01f,
  4.57938425e-02f, -8.53678733e-02f, 5.37835397e-02f, -6.41849935e-02f, 1.74495026e-01f, 1.63679391e-01f, -1.00932540e-02f, 4.96345479e-03f, 7.50775710e-02f, -1.82061717e-02f,
  1.76115364e-01f, 1.71653211e-01f, 7.36586377e-03f, -4.65904549e-02f, 1.82869837e-01f, -1.90960661e-01f, -1.75889671e-01f, -1.33144230e-01f, -7.02770576e-02f, 9.81037244e-02f,
  1.87137067e-01f, 7.61453286e-02f, -1.45891309e-02f, -7.54247233e-02f, 1.10854711e-02f, 7.11472183e-02f, 6.38537947e-03f, 4.24115881e-02f, -2.01356541e-02f, 5.33328801e-02f,
  -1.07913144e-01f, 9.06486623e-03f, 4.44855355e-02f, -3.72552499e-02f, -2.10986346e-01f, -3.20951082e-02f, 1.05982344e-03f, -1.28280520e-01f, -1.59506708e-01f, -1.71491072e-01f,
  2.81541944e-02f, -4.65826206e-02f, -4.31764983e-02f, -4.22921740e-02f, 5.17295375e-02f, 6.28969073e-02f, 4.88073789e-02f, -3.65222767e-02f, -1.32043973e-01f, -1.21494167e-01f,
  4.23817299e-02f, 1.56177394e-02f, 1.20266609e-01f, 1.06877498e-01f, 4.66610752e-02f, 1.07936941e-01f, -3.25093642e-02f, -1.07335307e-01f, 1.64951254e-02f, -2.15178709e-02f,
  5.77383995e-01f, -7.83426702e-01f, 2.84608960e-01f, 5.27062491e-02f, 7.76640102e-02f, 3.44558984e-01f, -2.14524344e-01f, -5.47694117e-02f, 1.03959002e-01f, -2.81120479e-01f,
  -2.33983919e-01f, 1.65272743e-01f, 1.66515842e-01f, 5.33527508e-02f, 1.55350536e-01f, -8.70441794e-02f, 1.65005326e-02f, 4.91493940e-01f, 4.65623677e-01f, -3.65826599e-02f,
  -3.29022914e-01f, -1.55088514e-01f, -6.05732016e-02f, -3.72061245e-02f, -2.94370890e-01f, 5.18669784e-02f, -7.56385401e-02f, -2.24082217e-01f, -1.51923239e-01f, -3.05351675e-01f,
  -5.55068851e-02f, -2.55986065e-01f, 1.13532193e-01f, -1.40154297e-02f, -4.14330512e-02f, 5.46062998e-02f, -9.21100099e-03f, -6.46612570e-02f, -1.35006040e-01f, -5.95929287e-02f,
  -7.18801245e-02f, -1.07903659e-01f, 1.02477774e-01f, -5.85816354e-02f, -1.26877859e-01f, -5.72734028e-02f, -2.98231076e-02f, -4.11955602e-02f, -3.56132351e-02f, -4.99231182e-02f,
  -1.06195003e-01f, 1.09871417e-01f, 1.29952788e-01f, -7.66750006e-03f, 3.96956839e-02f, 1.05300076e-01f, -1.98197499e-01f, -6.07962385e-02f, 6.13825284e-02f, -8.21443871e-02f,
  -7.67268166e-02f, 1.09449320e-01f, -6.17330484e-02f, -1.23694770e-01f, -3.97719489e-03f, 5.97536704e-03f, 1.43712601e-02f, 2.65078433e-02f, 7.17421249e-03f, -3.92677225e-02f,
  2.58284453e-02f, 6.25067949e-02f, 2.84544975e-02f, -3.72708775e-02f, 5.10182641e-02f, 5.87767735e-02f, 4.96148020e-02f, -9.57972705e-02f, -1.45508545e-02f, -3.70289348e-02f,
  -2.11180449e-02f, 4.65013534e-02f, 2.96171568e-02f, -1.17535003e-01f, -2.96361744e-02f, 3.83276939e-02f, 1.09614000e-01f, 3.20546106e-02f, -1.67850573e-02f, -1.05470675e-03f,
  -2.33654618e-01f, 3.21818948e-01f, -3.48602980e-02f, -1.07808538e-01f, -2.52162628e-02f, -1.45583466e-01f, 2.96732201e-03f, -9.13122222e-02f, 1.82133522e-02f, 3.19815278e-02f,
  -6.21946268e-02f, 9.27786082e-02f, -9.64008719e-02f, -9.33808386e-02f, 7.48199522e-02f, -9.86845978e-03f, -1.67004004e-01f, 1.53605908e-01f, -5.03745526e-02f, -8.45476016e-02f,
  7.56175397e-03f, 1.51869148e-01f, 2.42486000e-01f, 2.11174682e-01f, 6.30971417e-02f, 3.20438802e-01f, -3.44645269e-02f, 3.22097391e-02f, 1.49946377e-01f, -1.34598017e-01f,
  1.05173624e+00f, 9.03904662e-02f, -1.04189527e+00f, 3.20811927e-01f, -1.98080897e-01f, -3.16570491e-01f, 4.48318720e-02f, 3.53308290e-01f, 2.48218521e-01f, -2.41011865e-02f,
  7.90540576e-02f, 7.51340063e-03f, -1.49616823e-01f, -7.99807534e-02f, 1.03178238e-02f, -4.15601939e-01f, -4.22690898e-01f, -3.94002736e-01f, -9.20066312e-02f, 3.10284913e-01f,
  1.79433137e-01f, 2.59472549e-01f, 2.76108891e-01f, 2.93893851e-02f, -1.52310073e-01f, -1.20298341e-01f, -3.93211424e-01f, -2.99241513e-01f, -3.30946088e-01f, -4.89914209e-01f,
  -8.12399387e-01f, -2.23756745e-01f, 5.39004244e-02f, 1.41815379e-01f, 2.68068463e-02f, 1.79676548e-01f, 8.06529820e-02f, 1.13584280e-01f, 2.34780163e-01f, -7.71027803e-03f,
  -4.84887920e-02f, -2.95856651e-02f, 7.71924928e-02f, -1.21952007e-02f, 7.34950677e-02f, 9.15577486e-02f, 2.77231056e-02f, 1.08752534e-01f, -1.19625270e-01f, 1.35095511e-02f,
  -2.02602521e-02f, -8.11693445e-02f, -1.25464544e-01f, 7.56058022e-02f, -1.20215155e-01f, -1.87270045e-01f, -5.98793551e-02f, -1.39630884e-01f, -2.16133535e-01f, 1.13566674e-01f,
  2.63399468e-03f, -7.83913881e-02f, -8.86268690e-02f, 7.71543682e-02f, 1.39735878e-01f, 2.34312229e-02f, -1.15126677e-01f, 1.45561108e-02f, -6.32887930e-02f, 1.85748726e-01f,
  7.75975063e-02f, -1.07840903e-01f, -4.20604423e-02f, 2.17200238e-02f, -1.37045562e-01f, -9.14132670e-02f, -1.36095583e-01f, -2.69785170e-02f, -9.31219384e-02f, 3.51610780e-02f,
  4.32286263e-02f, -8.50258917e-02f, -7.62797743e-02f, 4.64893430e-02f, -1.69854522e-01f, -4.84050699e-02f, -1.22846395e-01f, 2.09320504e-02f, 1.63118452e-01f, -1.08378157e-02f,
  2.60421097e-01f, -2.91639090e-01f, -8.48790407e-02f, -2.36426946e-02f, -2.31621101e-01f, 1.93504686e-03f, -2.48002663e-01f, -5.04798479e-02f, -5.54070733e-02f, -1.46318600e-01f,
  -1.36938810e-01f, -8.32228139e-02f, -1.06325217e-01f, -1.44343805e-02f, 1.53798223e-01f, -3.58968899e-02f, 8.88886452e-02f, -9.20573995e-02f, -2.53145937e-02f, -9.10536051e-02f,
  -6.76043937e-03f, 7.61078149e-02f, 2.02986836e-01f, 1.23488186e-02f, 1.05248392e-01f, -4.34634313e-02f, -7.49565586e-02f, -1.18247131e-02f, -1.26739755e-01f, 4.15377349e-01f,
  4.49448645e-01f, 3.88111889e-01f, 4.33697075e-01f, 4.77507859e-02f, 2.06802621e-01f, 4.63029206e-01f, 7.12309062e-01f, 4.20408398e-01f, 9.13067162e-03f, 1.74602225e-01f,
  2.64474213e-01f, 2.74388934e-04f, 1.12653017e-01f, 1.53253868e-01f, 2.32598618e-01f, 2.19328508e-01f, 1.06439620e-01f, -3.80833820e-02f, 4.09972183e-02f, 9.01291072e-02f,
  -1.00582860e-01f, 3.34020332e-02f, 1.52002648e-01f, -1.01013914e-01f, -1.99361086e-01f, -2.63140798e-01f, 7.13290870e-02f, 1.25917464e-01f, 1.58753291e-01f, -4.27239865e-01f,
  1.62450805e-01f, 4.45410520e-01f, -1.90603063e-01f, -1.52324870e-01f, -4.68009822e-02f, -3.63464616e-02f, -7.20578283e-02f, 3.80477682e-03f, 1.24146998e-01f, -1.77522860e-02f,
  1.88692063e-01f, -3.07619534e-02f, 1.56018049e-01f, 9.66146588e-02f, 9.87596065e-02f, 1.34350628e-01f, 5.01418039e-02f, 1.33377686e-01f, 1.78474575e-01f, 4.52521816e-03f,
  6.95181265e-02f, 9.84736159e-02f, 2.42898777e-01f, 1.18956454e-01f, 3.25741738e-01f, 1.31824743e-02f, 1.28680676e-01f, 6.73633963e-02f, 6.00249730e-02f, 3.58124562e-02f,
  2.50579659e-02f, 5.85600398e-02f, 7.14512318e-02f, -1.74339399e-01f, 1.57471020e-02f, 5.32985590e-02f, -3.20213847e-02f, 1.02675065e-01f, 5.36358692e-02f, -9.49676707e-02f,
  3.60144675e-03f, 2.56017279e-02f, 9.93165001e-02f, -4.62652259e-02f, -4.31077220e-02f, 8.05066153e-03f, 1.04144119e-01f, 4.42054421e-02f, 1.44361496e-01f, 3.79338041e-02f,
  1.81392834e-01f, 1.03240974e-01f, 1.49584701e-02f, 4.42416966e-02f, 2.71319319e-02f, -2.46065538e-02f, -2.31088847e-02f, 4.85453904e-02f, -5.21718077e-02f, 6.66607693e-02f,
  -7.21313879e-02f, 3.07587057e-01f, -3.10118586e-01f, -1.46784008e-01f, -4.84181717e-02f, -6.23230031e-03f, 2.05202978e-02f, -1.43596843e-01f, -1.11152068e-01f, -2.81131808e-02f,
  1.76631093e-01f, -8.60603005e-02f, 1.28168762e-01f, 7.05903918e-02f, -2.07420457e-02f, -8.34312662e-02f, -1.68417245e-01f, 2.27357596e-02f, 2.39549894e-02f, -9.14292410e-02f,
  -6.94557056e-02f, -6.60968423e-02f, 3.21378075e-02f, -7.23688453e-02f, -1.38182789e-01f, -2.65490621e-01f, -1.02702826e-01f, -3.66927907e-02f, 2.45302748e-02f, -1.70242995e-01f,
  -7.27558434e-01f, 5.95400512e-01f, -9.74684209e-02f, -4.32711035e-01f, 1.85712025e-01f, 3.56741935e-01f, 8.04852843e-01f, 1.60158187e-01f, -3.45999807e-01f, 4.01656657e-01f,
  2.27245301e-01f, -3.39209646e-01f, -2.39821389e-01f, -2.72310283e-02f, 3.62717271e-01f, 6.57522440e-01f, 4.06593561e-01f, -2.67997265e-01f, -4.35811162e-01f, -1.75144970e-01f,
  2.06830636e-01f, -3.01954478e-01f, -5.54737270e-01f, -2.18969837e-01f, -1.19383752e-01f, -3.46656322e-01f, -1.76090263e-02f, -2.07148224e-01f, 3.53041649e-01f, -1.11802649e-02f,
  -1.65284947e-01f, -1.16903475e-02f, -8.46575722e-02f, -2.67313659e-01f, -5.23525514e-02f, -1.80547282e-01f, -6.48351386e-02f, -3.07641357e-01f, -6.28118813e-02f, -1.05657764e-01f,
  -2.15345979e-01f, -1.06782736e-02f, -8.41193050e-02f, -1.66947618e-01f, -5.39527088e-02f, -8.95797387e-02f, -1.85964331e-01f, -5.81526570e-02f, -9.72418189e-02f, 3.28331292e-02f,
  3.45034987e-01f, 1.01334997e-01f, -4.05242778e-02f, 1.95534945e-01f, 1.59136847e-01f, 5.21937683e-02f, 5.77931711e-03f, -2.69163549e-01f, 1.34685030e-02f, -2.42315277e-01f,
  8.33582059e-02f, -5.13112471e-02f, 1.78253595e-02f, -1.77669935e-02f, 8.23521689e-02f, 3.79014313e-02f, -2.43982021e-03f, 3.52433063e-02f, -6.74647465e-03f, -7.21388236e-02f,
  -8.26983675e-02f, 4.30984572e-02f, 9.51793417e-03f, -4.81109023e-02f, -1.46746412e-01f, 9.26470943e-03f, -3.03095654e-02f, 1.48395617e-02f, 8.40032473e-03f, -4.71920446e-02f,
  -9.58603323e-02f, 7.09562004e-02f, -3.26017439e-02f, 1.05194645e-02f, 9.62891728e-02f, -6.24604970e-02f, -1.13572702e-01f, 5.06884530e-02f, -8.75290334e-02f, 1.29864797e-01f,
  -3.75346065e-01f, 2.47031242e-01f, -7.73595124e-02f, 8.86341110e-02f, 8.95618275e-02f, -4.21514064e-02f, 8.40660855e-02f, 2.46560723e-02f, 4.35318723e-02f, -5.25093265e-02f,
  -3.80224618e-03f, -4.64266166e-02f, 1.37567773e-01f, -5.98745719e-02f, -9.65026990e-02f, -8.14930908e-03f, 1.74175829e-01f, -1.36368901e-01f, 1.12106740e-01f, 1.85652787e-03f,
  8.12127739e-02f, 2.79488694e-02f, 5.99014433e-03f, -7.66647980e-04f, 2.29831748e-02f, -1.11933565e-02f, -7.51251727e-02f, -1.57567620e-01f, 2.10753959e-02f, 5.48119247e-02f,
  1.22879401e-01f, -2.02472419e-01f, -6.85981572e-01f, -7.09360763e-02f, -4.14451271e-01f, -3.45671475e-01f, -4.24129158e-01f, 3.20290169e-03f, 1.36660829e-01f, -3.89876544e-01f,
  -7.09117427e-02f, 3.48818421e-01f, 7.71389157e-02f, 1.74995929e-01f, 7.12362453e-02f, -5.41338980e-01f, -5.33959806e-01f, -2.39388824e-01f, 1.96330026e-01f, 1.09518051e-01f,
  -1.00736851e-02f, -1.17915563e-01f, 6.17865846e-02f, -1.44748855e-02f, -2.49121383e-01f, -5.26690297e-02f, -6.29688680e-01f, -3.61240625e-01f, -3.41409653e-01f, -5.16933799e-01f,
  -1.01850212e-01f, -2.68827856e-01f, -6.67728484e-02f, 5.46548180e-02f, -2.31407449e-01f, 5.67034781e-02f, 1.04611777e-01f, -7.08799958e-02f, 1.07288644e-01f, -1.38215646e-01f,
  2.34301779e-02f, 3.30236591e-02f, 1.69033930e-01f, 1.48728630e-02f, -1.27091318e-01f, 5.91104850e-02f, -2.62421012e-01f, -3.32304537e-02f, -1.14947163e-01f, -7.51604065e-02f,
  -6.02698438e-02f, -2.11493790e-01f, -6.27880841e-02f, -8.53713378e-02f, -5.20405248e-02f, -4.73179407e-02f, -8.71762186e-02f, -1.06048509e-01f, -2.28883624e-01f, -3.31775695e-01f,
  -1.26479968e-01f, 8.81769881e-02f, -6.43487722e-02f, -1.40581718e-02f, -6.65624812e-03f, -3.38044614e-02f, -1.69807486e-02f, 6.80174008e-02f, 4.26166765e-02f, 2.21604668e-03f,
  -1.41995043e-01f, -1.71982467e-01f, 1.06481098e-01f, -3.38779353e-02f, -7.82570317e-02f, -7.31205791e-02f, -4.45206091e-02f, 3.99481393e-02f, 1.59928650e-02f, -1.08024485e-01f,
  7.62564018e-02f, 7.75031969e-02f, -1.41608328e-01f, 7.90783167e-02f, -1.74779147e-01f, -3.16633247e-02f, 2.89780740e-02f, 9.86461863e-02f, 1.07632153e-01f, -6.45336136e-02f,
  4.73379374e-01f, -2.92080253e-01f, -3.43251079e-02f, 2.81426013e-01f, -6.08413592e-02f, -1.22276418e-01f, -1.05570041e-01f, 2.04753298e-02f, 1.48098841e-01f, 2.38804400e-01f,
  1.70537848e-02f, 1.29918754e-01f, -1.72818583e-02f, -1.42137602e-01f, -1.37467727e-01f, -1.02026753e-01f, -2.41502464e-01f, 4.99727987e-02f, 8.34643543e-02f, -1.52628114e-02f,
  -1.02517985e-01f, 3.92213576e-02f, 2.54702657e-01f, 1.57384783e-01f, 1.30669281e-01f, 1.22907802e-01f, 1.38509110e-01f, -2.53617372e-02f, 1.11586370e-01f, 1.38120472e-01f,
  -8.65625501e-01f, -4.50731665e-01f, 2.56386250e-01f, 1.21399172e-01f, 4.65572625e-01f, 4.52454299e-01f, 3.53732437e-01f, 1.61791578e-01f, 1.40504107e-01f, -3.42994370e-02f,
  -3.38097453e-01f, -2.15197325e-01f, -1.32858828e-02f, -3.72459739e-02f, 1.92578007e-02f, 3.16394538e-01f, 4.37904179e-01f, 1.99459225e-01f, 2.38843784e-01f, 2.92027295e-01f,
  3.24531645e-01f, 5.87208793e-02f, -1.48971081e-01f, 5.48439249e-02f, 1.75850913e-01f, 1.52144969e-01f, 6.22934215e-02f, 1.87493861e-01f, 4.90462035e-02f, 2.76788265e-01f,
  4.55980241e-01f, -4.62629497e-01f, 5.93342185e-02f, -2.38460526e-01f, -2.21871838e-01f, -2.40082413e-01f, 2.28920132e-02f, -1.50170818e-01f, -7.58067295e-02f, 5.88052273e-02f,
  -1.06690921e-01f, -9.63999182e-02f, -7.87476376e-02f, 8.25032243e-04f, 9.99068618e-02f, -6.16337918e-02f, -2.34860659e-01f, -4.31908444e-02f, -4.93081175e-02f, -3.05191819e-02f,
  -1.62722059e-02f, 5.31321652e-02f, 6.63552135e-02f, 5.96774556e-02f, -1.17912300e-01f, 1.25350013e-01f, -1.66389301e-01f, -2.73717567e-02f, -9.12121236e-02f, 7.67303444e-03f,
  8.57172608e-02f, -8.96808133e-03f, -2.67202109e-02f, -4.09181006e-02f, -6.61629811e-02f, 1.25654534e-01f, 1.46492615e-01f, 3.47972475e-02f, 9.74700078e-02f, -1.30078830e-02f,
  3.12364791e-02f, 9.96313915e-02f, 1.24696819e-02f, 2.42354367e-02f, -8.47924054e-02f, -1.15212807e-02f, 1.64473187e-02f, -1.00424707e-01f, -2.21063644e-01f, -1.79273695e-01f,
  -1.46115482e-01f, 1.14762634e-01f, -7.87456334e-02f, -2.76141409e-02f, -2.15331282e-04f, -4.95038740e-02f, 8.61518085e-02f, -1.69254735e-01f, 2.16574110e-02f, 2.52001602e-02f,
  3.43461126e-01f, -3.10822815e-01f, 7.09844157e-02f, -8.02062824e-02f, 5.99598400e-02f, -2.53254831e-01f, -1.18808068e-01f, 2.80940235e-02f, -5.40902242e-02f, 4.45261449e-02f,
  -4.39904220e-02f, -1.33995622e-01f, -4.07647491e-02f, 4.18079831e-02f, 9.40836594e-02f, 5.21739684e-02f, -1.88906804e-01f, 7.62223154e-02f, 1.00118615e-01f, 7.91998878e-02f,
  -1.06876984e-01f, 1.72819883e-01f, 2.20968142e-01f, 2.21439600e-01f, 9.59762856e-02f, 2.70437837e-01f, 2.02827349e-01f, 1.32834718e-01f, 1.48973361e-01f, 1.75088584e-01f,
  9.56887722e-01f, -5.96207857e-01f, 6.11357510e-01f, 1.66599765e-01f, 2.24945489e-02f, 1.38758153e-01f, -9.67471898e-02f, 1.09436423e-01f, -3.72391529e-02f, -9.71414670e-02f,
  -2.24000886e-01f, -8.76366794e-02f, -3.82192321e-02f, -7.47993309e-03f, 5.19028753e-02f, -4.96716015e-02f, 3.61989662e-02f, 4.39033180e-01f, 5.45281529e-01f, -6.00905754e-02f,
  -3.15624028e-01f, -2.34001666e-01f, 1.42296150e-01f, 9.47554111e-02f, -2.34420374e-01f, -1.02148661e-02f, -8.61811489e-02f, -1.12109659e-02f, -1.70111790e-01f, -1.60485998e-01f,
  -3.05367149e-02f, 8.13337415e-02f, 3.88461910e-02f, -1.44968629e-01f, -1.26205519e-01f, 6.81044608e-02f, 7.57215992e-02f, -1.05081826e-01f, -1.84533834e-01f, -7.39628822e-02f,
  -1.42868534e-01f, -1.53716560e-03f, 1.20935872e-01f, -8.96788947e-03f, -3.83520164e-02f, -1.63769946e-02f, -1.04178444e-01f, 1.28222378e-02f, 5.00510260e-02f, -2.68318076e-02f,
  -2.74105251e-01f, -6.59226179e-02f, 4.40480560e-02f, -6.31028712e-02f, 5.53002246e-02f, 6.06404729e-02f, 9.20585077e-03f, 1.25071198e-01f, 2.40614682e-01f, 9.01341438e-02f,
  1.35261849e-01f, 6.17513806e-02f, 5.68721369e-02f, 4.19272892e-02f, 1.78725481e-01f, 8.81400183e-02f, -2.06532665e-02f, -1.07943624e-01f, 9.29908529e-02f, 1.14261679e-01f,
  -1.19968198e-01f, 5.53337112e-02f, 8.64696652e-02f, -9.83977392e-02f, -8.80178437e-02f, -1.24322753e-02f, -6.23443015e-02f, -5.33762015e-02f, 6.68567652e-03f, -8.63160118e-02f,
  1.96190830e-02f, -1.09473616e-01f, -1.20387711e-01f, -3.70342471e-02f, -1.29365250e-01f, 9.30925906e-02f, 3.12758721e-02f, -1.85514152e-01f, 4.83938828e-02f, -1.23518445e-01f,
  -5.95073223e-01f, 2.76599824e-01f, 2.36050040e-03f, 6.58138543e-02f, -4.03594561e-02f, -1.08731799e-01f, -4.17736406e-03f, -7.52763599e-02f, -9.64115560e-02f, -5.55716045e-02f,
  5.79070076e-02f, 1.00416213e-01f, -1.75669119e-02f, -5.08774295e-02f, 1.31862879e-01f, 1.06978439e-01f, -8.04277137e-02f, -6.43806383e-02f, -1.18989453e-01f, -2.26300240e-01f,
  -2.23638341e-01f, 8.38897154e-02f, 3.66513468e-02f, 6.54267073e-02f, 1.17218360e-01f, 2.85936892e-01f, -5.50368987e-02f, -1.16994940e-02f, 2.26132423e-01f, -1.12226598e-01f,
  -4.23714668e-01f, 1.00205943e-01f, -2.10429549e-01f, 1.76799625e-01f, 2.62156159e-01f, 1.49036631e-01f, 3.23308051e-01f, 1.84230030e-01f, 1.43310785e-01f, 2.61418726e-02f,
  -4.43078876e-01f, -2.87112892e-01f, -2.02047437e-01f, -1.74659163e-01f, -6.34578289e-03f, 3.11575949e-01f, 3.56279612e-01f, -1.10594757e-01f, -2.01135278e-01f, -3.94953415e-03f,
  1.89911887e-01f, 5.10288440e-02f, -1.55723885e-01f, 3.34437974e-02f, 4.05020751e-02f, -4.64540459e-02f, -1.03264727e-01f, -1.61344275e-01f, 1.86591707e-02f, 1.36555582e-01f,
  -8.29030693e-01f, -3.75150204e-01f, 8.07505473e-03f, -1.00908108e-01f, -2.13537380e-01f, -1.68579314e-02f, 7.82565773e-03f, -8.35344419e-02f, -8.73635933e-02f, 4.69136052e-02f,
  4.32422198e-02f, -5.35989143e-02f, 5.84321022e-02f, 7.64656588e-02f, 2.96332054e-02f, -7.66415671e-02f, -2.90941261e-02f, -1.56610310e-02f, -1.77601222e-02f, -1.13140509e-01f,
  -9.98256579e-02f, -2.27442235e-01f, -1.00881867e-01f, 4.21509407e-02f, -3.97733487e-02f, -2.42126137e-01f, -2.20256552e-01f, -7.99749047e-02f, -1.84010759e-01f, 6.85988069e-02f,
  3.10301315e-02f, 8.70492458e-02f, 4.78033870e-02f, -1.68096591e-02f, 1.52719706e-01f, 1.36390880e-01f, 9.36343595e-02f, -4.44415882e-02f, 6.94477186e-02f, 3.94560061e-02f,
  2.75769327e-02f, 5.59882931e-02f, -2.24531647e-02f, 3.13973725e-02f, 3.50287184e-02f, -2.11863033e-03f, 9.73338187e-02f, 8.93752575e-02f, -5.59806079e-02f, 3.24937254e-02f,
  -3.90465781e-02f, -5.03302738e-02f, -6.82965666e-02f, -5.60064055e-02f, -1.22559540e-01f, -1.08065516e-01f, -2.69738268e-02f, 7.87727684e-02f, 4.28683907e-02f, -1.72157306e-02f,
  -1.01537593e-01f, -1.05253600e-01f, 3.91764045e-02f, -3.63634415e-02f, -1.01464286e-01f, -1.08147234e-01f, -1.27996609e-01f, -1.49822384e-02f, 1.20090097e-01f, 6.06975704e-03f,
  2.80422065e-02f, 1.17314331e-01f, 9.03122276e-02f, 5.49465381e-02f, 1.63710535e-01f, 7.34588057e-02f, -2.50039343e-02f, -6.20057508e-02f, 3.31570432e-02f, -6.40116185e-02f,
  1.17266387e-01f, 1.48483306e-01f, 2.56399699e-02f, 9.59180146e-02f, 1.98369883e-02f, -9.23555344e-02f, -4.17477116e-02f, 1.39614597e-01f, -3.26831900e-02f, 2.31513932e-01f,
  -4.62993413e-01f, 2.58091897e-01f, -1.51791215e-01f, -4.36354317e-02f, -5.22807650e-02f, -3.18618447e-01f, -4.03913915e-01f, -1.61240734e-02f, 3.91194336e-02f, 9.50889811e-02f,
  -7.41778985e-02f, -2.82315761e-01f, -3.07026148e-01f, -5.60411036e-01f, -7.63664603e-01f, -3.98468524e-01f, -3.14824849e-01f, -7.59798527e-01f, -9.68364537e-01f, -4.43116248e-01f,
  -4.13085073e-01f, -3.51666689e-01f, -5.43406487e-01f, -2.23383158e-02f, 3.05052161e-01f, -1.26366928e-01f, 1.01471335e-01f, -1.25547424e-01f, -1.29503518e-01f, 1.00368254e-01f,
  -1.09326892e-01f, -1.37155414e-01f, -2.09881037e-01f, -2.13580787e-01f, -8.82935419e-05f, 1.34848475e-01f, -1.38962805e-01f, -6.04902245e-02f, -1.35622784e-01f, -5.07260626e-03f,
  -1.20760769e-01f, 5.74015528e-02f, -1.70612782e-01f, 2.18433589e-02f, -1.03364944e-01f, -1.53886870e-01f, 6.82665557e-02f, -2.55451530e-01f, -7.13305026e-02f, 2.30949745e-01f,
  5.03973775e-02f, -9.88383815e-02f, -7.25362003e-02f, 9.68508422e-02f, 1.21583216e-01f, -1.84701890e-01f, 2.79675871e-01f, 2.04347834e-01f, 1.19760446e-01f, 4.19063330e-01f,
  2.58245975e-01f, 2.36192048e-01f, -4.16160747e-02f, 5.90829737e-02f, 3.95519398e-02f, -4.68270555e-02f, -1.92515366e-02f, 1.32428616e-01f, -2.77647786e-02f, -7.16244727e-02f,
  1.05342932e-01f, -5.45605011e-02f, 6.64513335e-02f, -3.56802493e-02f, 5.65451058e-03f, 1.25596384e-02f, -3.38876322e-02f, 2.77305543e-02f, -9.06274021e-02f, -5.60128167e-02f,
  -1.23153150e-01f, -3.12141553e-02f, -1.87492482e-02f, 6.58059195e-02f, -8.17508250e-03f, -2.37594228e-02f, 1.16181575e-01f, -1.57437790e-02f, -1.27252236e-01f, -6.31698743e-02f,
  -1.28950834e-01f, -4.04801965e-01f, -1.20868281e-01f, 3.57740447e-02f, 9.35792364e-03f, 1.05710894e-01f, 1.81721300e-01f, 9.33433101e-02f, -4.38590050e-02f, 9.32889357e-02f,
  -3.12259775e-02f, 8.80194902e-02f, -6.12341948e-02f, 2.03924745e-01f, -1.27173573e-01f, 2.22018380e-02f, -2.32311944e-03f, -1.05492830e-01f, -4.18858677e-02f, 3.11599255e-01f,
  1.70255333e-01f, -4.44369391e-02f, -1.52265951e-01f, 9.45777912e-03f, 1.81127459e-01f, -1.54466286e-01f, 9.46174487e-02f, 2.99942017e-01f, 6.56738225e-03f, 2.90590763e-01f,
  -4.64766473e-01f, -4.49560434e-01f, 1.81094650e-02f, -2.07749635e-01f, 6.79513738e-02f, -1.55875742e-01f, -7.44646788e-01f, -1.70484185e-01f, 1.43567428e-01f, -4.91935402e-01f,
  -1.54287592e-01f, 2.70231426e-01f, 4.07118499e-02f, 1.28843272e-02f, -5.17264664e-01f, -7.36746669e-01f, -3.53965938e-01f, -1.23553343e-01f, 6.57035410e-02f, 8.88202265e-02f,
  -6.18759654e-02f, 4.76769954e-02f, 6.12060279e-02f, 7.58835599e-02f, -7.11007714e-02f, 1.51316654e-02f, 8.49513337e-02f, -1.24184936e-01f, -1.49972379e-01f, -2.20412284e-01f,
  -5.05794644e-01f, 3.54695208e-02f, 1.70892715e-01f, 2.66817063e-01f, 1.77813128e-01f, -8.41235295e-02f, -2.54648225e-03f, 1.07065432e-01f, 8.63801241e-02f, -1.05002224e-01f,
  8.48659724e-02f, 3.87197621e-02f, 1.31953850e-01f, 1.18896633e-01f, 1.27297640e-01f, -5.37548624e-02f, 1.16770051e-01f, 1.03408070e-02f, -2.86806673e-01f, -2.21875474e-01f,
  -1.17501974e-01f, -1.22279860e-01f, -1.35428011e-01f, -8.81179050e-02f, -2.62759440e-02f, 2.01639354e-01f, 2.01298781e-02f, 9.62605402e-02f, -1.38812646e-01f, -3.19365680e-01f,
  -1.22805789e-01f, -1.09471753e-01f, -1.26540409e-02f, 7.12596402e-02f, 2.12376397e-02f, 5.87246716e-02f, 5.94569109e-02f, -7.48648914e-03f, 4.05140128e-03f, -2.17330512e-02f,
  -4.80960906e-02f, -9.30072740e-02f, -2.71075219e-02f, -1.88807577e-01f, 3.23257446e-02f, -7.18449354e-02f, -1.06090516e-01f, -1.74305931e-01f, -1.34350806e-01f, -7.48651102e-02f,
  -3.20870131e-02f, 2.17067942e-01f, 1.62265822e-01f, -6.43341169e-02f, -1.46408929e-02f, -1.69095784e-01f, -1.47869037e-02f, -7.64728803e-03f, 1.94891796e-01f, 1.64361909e-01f,
  -2.94739902e-01f, 1.29900649e-01f, -2.86406040e-01f, 7.42533728e-02f, 8.35338905e-02f, -1.16089031e-01f, -7.35662207e-02f, 7.35777617e-02f, 9.06855911e-02f, -3.35814580e-02f,
  -2.42932159e-02f, -2.37970930e-02f, 6.75384924e-02f, 2.35271994e-02f, -2.39452347e-03f, 1.12475388e-01f, -6.07892461e-02f, 4.87237377e-03f, -1.18181005e-01f, -4.65366952e-02f,
  -1.32468730e-01f, -3.35436881e-01f, -3.57371002e-01f, -3.43075812e-01f, -1.48262948e-01f, -1.38806775e-01f, -1.59573123e-01f, -2.09598303e-01f, -5.52013218e-01f, -6.49465621e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  4.26170915e-01f, 5.98974109e-01f, 4.67508554e-01f, 5.45502126e-01f, 3.96917224e-01f, -1.57430127e-01f, 1.13017254e-01f, 3.44255418e-01f, 3.97993386e-01f, 2.82519400e-01f,
  5.36989868e-01f, 4.91818219e-01f, 2.14225240e-02f, 7.74365425e-01f, 3.50435168e-01f, 3.65626425e-01f, 7.34836936e-01f, 5.88600576e-01f, 4.57650334e-01f, 3.38795483e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.51053742e-01f, 2.91263536e-02f, -1.94622502e-01f, -1.12589039e-01f, 1.34427339e-01f, 1.29191391e-02f, 1.07243001e-01f, -6.52734861e-02f, -2.55212821e-02f, 2.41723448e-01f,
  -4.61385585e-03f, 1.86425984e-01f, -1.26126066e-01f, -1.14801846e-01f, 1.77275151e-01f, -3.82995963e-01f, 1.25102311e-01f, -5.33378199e-02f, 2.32135817e-01f, 3.77245545e-01f,
  -9.79947522e-02f, 1.40688702e-01f, 2.43507653e-01f, 1.01030357e-01f, 5.56275733e-02f, -3.55561644e-01f, 2.32953146e-01f, -3.12718362e-01f, 4.42943275e-01f, -2.70489752e-01f,
  -2.60756493e-01f, -1.72600970e-02f, 7.18594790e-02f, 2.10312709e-01f, 3.92095335e-02f, 4.28793244e-02f, -1.33498341e-01f, 1.39910683e-01f, 5.50523885e-02f, 2.30592936e-01f,
  -8.52927938e-02f, -8.39290768e-02f, -2.18277708e-01f, -2.00518027e-01f, -1.32553399e-01f, 1.61692753e-01f, -5.75549118e-02f, 6.91629723e-02f, -2.80492246e-01f, 2.89255548e-02f,
  -4.90646631e-01f, -2.60738701e-01f, 2.41015017e-01f, 1.59468174e-01f, 1.56360969e-01f, -4.54648197e-01f, 3.37528554e-03f, -3.89711261e-01f, -4.45676595e-02f, -2.06454739e-01f,
  1.08952768e-01f, -1.84869021e-01f, 2.01169252e-01f, 3.21757840e-03f, 2.83202212e-02f, -8.04211497e-02f, 2.73944288e-01f, 2.77562104e-02f, -6.17110245e-02f, -1.62149042e-01f,
  -1.11052476e-01f, -2.91823506e-01f, 1.56551406e-01f, 4.26192433e-02f, 1.67975947e-01f, 1.50201514e-01f, 7.16689751e-02f, 1.11081172e-02f, -2.15633988e-01f, 3.27328742e-01f,
  1.84283987e-01f, 9.48698744e-02f, -1.66707590e-01f, 1.19506121e-02f, 1.98282555e-01f, -7.78070651e-03f, 3.43726985e-02f, -1.07311770e-01f, 7.95496181e-02f, 4.69799548e-01f,
  -1.60497919e-01f, 1.36564896e-01f, -1.19996578e-01f, 3.51662673e-02f, 3.05819474e-02f, -1.79708540e-01f, 7.51651078e-02f, -3.01593007e-03f, -8.24725404e-02f, 1.05119228e-01f,
  1.47039369e-01f, 9.42079946e-02f, 5.11299483e-02f, -1.49820700e-01f, -2.48666629e-01f, 2.45096087e-01f, -7.04775676e-02f, 2.09460780e-01f, -4.47976440e-02f, -1.77452192e-01f,
  -7.37927258e-02f, 7.65099563e-03f, 8.62429291e-02f, 1.45449087e-01f, 3.46532077e-01f, -2.56658405e-01f, 1.64757058e-01f, 1.70575798e-01f, 2.48294279e-01f, 4.61082831e-02f,
  8.74726102e-03f, -1.14473686e-01f, 2.49054268e-01f, 1.86679810e-01f, 4.58255187e-02f, -3.00754547e-01f, -2.01271877e-01f, 9.94711146e-02f, 2.00848967e-01f, -9.83029678e-02f,
  1.57222643e-01f, 4.22840863e-02f, -4.67100181e-02f, 1.87071756e-01f, -3.17716412e-02f, -2.08697557e-01f, 8.70336127e-03f, 1.90804467e-01f, -2.67119855e-02f, 1.58615470e-01f,
  5.29376790e-02f, 2.73587495e-01f, 4.29854929e-01f, 2.83306003e-01f, -1.86105534e-01f, 2.12133843e-02f, -1.25976756e-01f, 1.53009236e-01f, -2.03642651e-01f, -2.41436914e-01f,
  1.82876021e-01f, -9.30171385e-02f, -2.47487351e-01f, -1.92324340e-01f, -1.46564782e-01f, 3.45313609e-01f, 2.43190825e-01f, 1.62944362e-01f, -4.31441031e-02f, 3.28886956e-02f,
  -3.56641971e-02f, -5.61943986e-02f, 2.48691086e-02f, -6.29295111e-02f, -1.07914537e-01f, 5.84761286e-03f, -2.75951512e-02f, 9.44710299e-02f, -2.29724258e-01f, -1.04614474e-01f,
  -1.46048129e-01f, -1.40395269e-01f, -1.10665374e-01f, -4.61914726e-02f, 1.07860573e-01f, 7.85916820e-02f, 3.22102398e-01f, 1.61619902e-01f, -7.04100579e-02f, -3.62843752e-01f,
  1.77230120e-01f, 7.80804008e-02f, 6.81125894e-02f, -1.65634468e-01f, 1.12798356e-01f, -4.06655632e-02f, -3.59084755e-02f, -2.16412589e-01f, -4.21994597e-01f, -3.65631998e-01f,
  3.18882465e-01f, 3.70886862e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  7.51691982e-02f, -1.17859796e-01f, 6.07257374e-02f, 5.12633547e-02f, 1.86542124e-01f, 5.55529557e-02f, -1.64242648e-02f, 8.23984481e-03f, -1.08910456e-01f, -4.17439900e-02f,
  4.71730232e-02f, 1.34435311e-01f, 1.10398000e-02f, 5.44491827e-01f, 3.66458088e-01f, 7.23130763e-01f, -3.22270719e-03f, 7.63249770e-02f, 3.65566581e-01f, -1.84707329e-01f,
  -3.88794690e-01f, 4.14973974e-01f, 2.05319956e-01f, 7.37941146e-01f, -4.19236869e-02f, -6.44811273e-01f, 6.12673342e-01f, 2.11812943e-01f, 3.64632279e-01f, 2.45814309e-01f,
  6.64960742e-02f, 6.49438500e-02f, -6.14367910e-02f, 8.43537003e-02f, 3.56674254e-01f, 2.70964175e-01f, -2.67666817e-01f, 5.77397346e-02f, -2.85540614e-02f, -1.52767554e-01f,
  3.19243938e-01f, -1.18176140e-01f, 1.35239035e-01f, -1.40645057e-01f, 2.46358082e-01f, 6.67276144e-01f, 2.73460031e-01f, 9.79258001e-01f, 1.43461570e-01f, 2.54149884e-02f,
  -1.65750831e-01f, 3.29668909e-01f, -5.14442325e-01f, -1.96112081e-01f, -5.13014436e-01f, 5.36242425e-01f, -1.40481979e-01f, 3.61012727e-01f, 4.40188766e-01f, 4.22950208e-01f,
  -8.13600898e-01f, 3.70974571e-01f, -2.17253380e-02f, -7.23443866e-01f, 6.79382756e-02f, 1.60505295e-01f, 2.38791317e-01f, 2.28243753e-01f, -9.81361605e-04f, -9.12274048e-02f,
  2.04390064e-01f, -1.41244113e-01f, 1.70039781e-03f, 2.38554657e-01f, 3.47734131e-02f, 4.62437719e-02f, 3.25618714e-01f, -1.55175090e-01f, 2.40162745e-01f, -1.24941744e-01f,
  -1.38156772e-01f, -1.22700922e-01f, 1.00937031e-01f, 7.84876227e-01f, 4.20375407e-01f, -2.10848629e-01f, 3.39918554e-01f, -7.69313931e-01f, 1.79779172e-01f, 6.13228381e-01f,
  -2.65849322e-01f, -2.17347518e-01f, 2.33653024e-01f, 2.80006886e-01f, -1.99484304e-01f, 6.83704689e-02f, -1.60485655e-01f, 2.38827154e-01f, 5.37742674e-02f, -5.37169464e-02f,
  1.12330534e-01f, -3.67330723e-02f, 6.29498512e-02f, 1.43907011e-01f, 9.23526734e-02f, -4.00846869e-01f, 1.48360536e-01f, -3.00510049e-01f, 3.87983501e-01f, 6.89426064e-02f,
  2.76962072e-01f, -1.36576936e-01f, 1.92236811e-01f, -2.44769201e-01f, -2.84205288e-01f, -8.23782384e-02f, 2.25311279e-01f, -4.48660627e-02f, 2.30894350e-02f, -3.54628772e-01f,
  2.03777716e-01f, 9.67236519e-01f, 2.09442601e-02f, 3.95163119e-01f, -7.65096396e-02f, 5.89264445e-02f, 1.23685203e-01f, -8.13339576e-02f, 3.24145481e-02f, -5.39540797e-02f,
  -1.32871702e-01f, -1.03816479e-01f, -3.50311324e-02f, 3.23728800e-01f, 7.38909319e-02f, 2.78289467e-01f, -4.36246485e-01f, 3.09916466e-01f, -3.78500044e-01f, -5.94595551e-01f,
  -2.08956808e-01f, 4.90354270e-01f, 5.58463156e-01f, 5.24145439e-02f, 1.20239593e-01f, -3.22387479e-02f, 4.17854749e-02f, 2.28171386e-02f, 4.47150588e-01f, 2.73225516e-01f,
  4.73201960e-01f, -2.39816681e-01f, -1.44190177e-01f, -4.80816603e-01f, 3.47064734e-01f, -2.93380767e-01f, 4.20490384e-01f, -5.04470944e-01f, 2.35087737e-01f, 7.13658214e-01f,
  3.98642182e-01f, 2.33806267e-01f, 4.20512408e-01f, 3.71476620e-01f, 6.24724478e-02f, 9.10337120e-02f, 2.54375011e-01f, -3.23720537e-02f, -2.80887842e-01f, -3.93073738e-01f,
  -1.11250244e-01f, -1.45456195e-01f, -8.51821154e-03f, -3.83501947e-01f, 3.89057249e-01f, 6.70061111e-01f, -2.64323771e-01f, 9.76041630e-02f, -1.07755840e-01f, -2.96572208e-01f,
  5.40822744e-01f, 7.94831365e-02f, -3.61051232e-01f, 2.27835774e-01f, -4.48693752e-01f, 7.30164826e-01f, -1.15662493e-01f, 4.72038500e-02f, -5.30770600e-01f, 6.03253782e-01f,
  6.13007367e-01f, 5.05778134e-01f, -1.29930004e-01f, 2.42600963e-01f, -1.29099250e-01f, 4.64509040e-01f, 1.13813259e-01f, 1.29151158e-03f, 5.84685385e-01f, 4.28506970e-01f,
  -1.19460806e-01f, -7.16098845e-02f, 4.58874673e-01f, -1.34171993e-01f, -3.24057192e-01f, 2.02181026e-01f, -4.69441146e-01f, -3.40416044e-01f, -4.99418117e-02f, -1.28476277e-01f,
  6.01412773e-01f, -5.93884826e-01f, 2.24073038e-01f, 2.61746913e-01f, 3.64427008e-02f, 6.75752819e-01f, -1.48118988e-01f, 4.49579954e-01f, 5.96214890e-01f, -2.84946263e-01f,
  -4.60486352e-01f, 2.10265666e-01f, 2.58107841e-01f, 1.03334978e-01f, 4.75214161e-02f, 1.89475074e-01f, 5.40465355e-01f, 1.03767976e-01f, 1.42550692e-01f, 7.08840638e-02f,
  1.06510215e-01f, 2.55674958e-01f, 2.40344435e-01f, -3.44390363e-01f, 3.68902497e-02f, -3.00224513e-01f, 4.39319134e-01f, 3.87503028e-01f, -2.87314415e-01f, -4.47621703e-01f,
  -3.53697032e-01f, -2.43615463e-01f, -2.69179285e-01f, 3.54365438e-01f, 2.54924715e-01f, 2.29528368e-01f, 4.02165025e-01f, -6.25802696e-01f, -2.87303422e-02f, 7.28174567e-01f,
  9.04571190e-02f, 1.44187212e-01f, 4.21964884e-01f, 1.55923247e-01f, 4.08372998e-01f, 1.01566315e-02f, -1.26961023e-01f, 4.74584937e-01f, 3.05898376e-02f, 3.82878482e-01f,
  -2.12735593e-01f, 3.30570161e-01f, -9.76905897e-02f, 5.56326628e-01f, -1.59336366e-02f, 2.77226239e-01f, -1.79866299e-01f, -5.99106729e-01f, -1.49135202e-01f, 7.78095961e-01f,
  -1.67506654e-02f, 4.32478637e-01f, 2.12931737e-01f, -2.48716533e-01f, -4.44625258e-01f, -2.99493760e-01f, 7.77080357e-02f, 2.08389938e-01f, -3.95839006e-01f, -9.19836909e-02f,
  -3.41705322e-01f, -4.49881226e-01f, 1.35680094e-01f, 3.25265199e-01f, -6.61612809e-01f, -3.22660774e-01f, 5.03469765e-01f, 3.81111979e-01f, 1.95578530e-01f, 1.63828999e-01f,
  -5.03170751e-02f, 1.88548177e-01f, 2.90902257e-01f, 6.22665346e-01f, 1.14577194e-03f, -2.63785332e-01f, -4.31868196e-01f, 4.09553617e-01f, -2.77044892e-01f, 1.52259842e-01f,
  -2.51508147e-01f, 4.14963305e-01f, 3.99642169e-01f, 6.38801277e-01f, 2.17519343e-01f, 2.59743482e-01f, 2.45167255e-01f, 2.59850800e-01f, 3.66448313e-02f, 1.41468853e-01f,
  2.73114592e-01f, 2.26311952e-01f, -1.77994192e-01f, -6.61459625e-01f, 3.83445084e-01f, -2.83631474e-01f, 2.58674324e-01f, -4.38909978e-01f, -3.55189405e-02f, 2.57568687e-01f,
  2.37707309e-02f, 2.21476763e-01f, -2.60150861e-02f, 2.48390529e-02f, 8.09997320e-03f, -2.69418150e-01f, 3.67783904e-01f, 2.15073049e-01f, -1.81101218e-01f, 1.75281122e-01f,
  5.33647180e-01f, -1.75058633e-01f, -1.57393113e-01f, 3.51660140e-02f, 3.15446585e-01f, 5.62869072e-01f, -1.49341794e-02f, -1.14837147e-01f, 5.23663282e-01f, -4.52128887e-01f,
  -9.54504833e-02f, 2.22115695e-01f, 4.58906889e-01f, 1.92917436e-01f, -2.12984025e-01f, 6.17002368e-01f, 3.20450425e-01f, 5.62808633e-01f, -6.03968017e-02f, 5.17923951e-01f,
  -2.08079871e-02f, 2.59062909e-02f, 2.08557278e-01f, 2.90360115e-02f, -2.24813327e-01f, 5.36848068e-01f, 2.19580159e-01f, 6.51967386e-03f, -2.02021375e-01f, 1.91025361e-01f,
  -7.51310913e-03f, -3.66875142e-01f, -1.90251336e-01f, -1.63086697e-01f, 7.39524901e-01f, -3.87901336e-01f, -6.84963405e-01f, 1.09381571e-01f, 2.17943683e-01f, -4.23641831e-01f,
  -2.54136086e-01f, 9.98375416e-02f, 4.64394271e-01f, -4.58162744e-03f, -5.72683811e-01f, 5.49556494e-01f, 2.95329243e-01f, 5.45318723e-01f, 2.93087661e-02f, -4.03598189e-01f,
  -1.88639492e-01f, 3.15052420e-02f, 8.59732509e-01f, 4.41482693e-01f, 4.36914980e-01f, 1.70585603e-01f, 2.86374539e-01f, 5.03146946e-01f, 1.58430815e-01f, -2.04286367e-01f,
  -3.61245614e-03f, -3.52117538e-01f, 4.15193647e-01f, 1.18456244e-01f, 1.35827765e-01f, 6.50849223e-01f, 6.48900494e-02f, 8.72389451e-02f, 5.50194204e-01f, 2.71776259e-01f,
  -4.83980596e-01f, -3.13261449e-01f, 3.24378669e-01f, 4.23486382e-01f, 5.90735115e-02f, -3.50672543e-01f, -9.15521458e-02f, 1.18189295e-04f, -7.17229918e-02f, 3.22472423e-01f,
  -3.73003483e-01f, 5.13700366e-01f, 1.01134710e-01f, 6.62494063e-01f, 1.94725972e-02f, -1.33894473e-01f, 5.16715229e-01f, 3.06560427e-01f, 4.94423419e-01f, 2.51258135e-01f,
  1.90205231e-01f, 3.94682467e-01f, -4.44287866e-01f, -2.35245943e-01f, 7.36162215e-02f, -2.23390803e-01f, -4.94725049e-01f, -3.23437423e-01f, 4.98360157e-01f, 6.30966797e-02f,
  2.32710347e-01f, 4.00814235e-01f, -2.22892120e-01f, -1.35880351e-01f, -4.90059018e-01f, 5.97247601e-01f, 5.05699754e-01f, -3.09175819e-01f, 2.90503323e-01f, -4.26874995e-01f,
  1.06365629e-01f, 3.89737189e-02f, -2.32877553e-01f, -2.27935866e-01f, -9.14760828e-02f, 1.81198809e-02f, 1.33072928e-01f, 1.10951751e-01f, 3.03375740e-02f, 2.81447947e-01f,
  3.02713215e-01f, 1.31848633e-01f, 8.25360417e-02f, 1.59417450e-01f, -2.16456398e-01f, -1.21255614e-01f, 7.56832883e-02f, -5.28797656e-02f, -1.60510540e-01f, -3.87938768e-01f,
  4.57548559e-01f, 6.79277554e-02f, 1.82628259e-01f, 2.84592539e-01f, 7.33388841e-01f, -7.54764527e-02f, -2.65774399e-01f, 1.79765716e-01f, 3.18438888e-01f, -1.95467740e-01f,
  -9.75097865e-02f, -3.36398095e-01f, 7.95044005e-02f, 4.45597410e-01f, -2.13030800e-01f, -1.46271899e-01f, 8.36119726e-02f, -2.42328301e-01f, 2.11337343e-01f, 1.09904744e-01f,
  -1.71983063e-01f, -5.19940816e-02f, 2.66746640e-01f, 1.10157467e-01f, -2.18401983e-01f, -9.21889842e-02f, -5.97076118e-01f, -1.82779834e-01f, 4.18633342e-01f, -2.92679183e-02f,
  -2.01071769e-01f, 5.33475995e-01f, 7.11742818e-01f, -3.06383401e-01f, 2.85586476e-01f, 7.80953467e-02f, 2.17567340e-01f, -2.89366513e-01f, -9.35609713e-02f, 6.51925981e-01f,
  8.38011876e-03f, 3.31431359e-01f, 2.29607254e-01f, -2.64992297e-01f, 1.19460031e-01f, 3.71184498e-02f, -4.65601265e-01f, 2.15294614e-01f, 5.78936934e-01f, 1.39386654e-01f,
  -6.60783127e-02f, -4.46527660e-01f, 5.35331845e-01f, 4.52543274e-02f, -3.21143508e-01f, 5.67076467e-02f, 3.27189714e-01f, 4.54956442e-02f, 7.79452473e-02f, -1.78313002e-01f,
  -6.34144172e-02f, 1.99092090e-01f, -2.45491624e-01f, 2.23343402e-01f, 2.97025815e-02f, -3.30488443e-01f, 3.27569515e-01f, 9.99668539e-02f, -3.98850888e-01f, 8.58045146e-02f,
  3.58247966e-01f, 7.63381943e-02f, 1.60646774e-02f, 5.49099326e-01f, 4.60106611e-01f, 6.55297339e-01f, 6.01389766e-01f, -2.62697011e-01f, 3.45332921e-01f, 4.84254435e-02f,
  7.02624500e-01f, 3.66294056e-01f, 4.93672937e-02f, 3.17330807e-01f, 3.74878347e-01f, 2.59691983e-01f, 4.16476786e-01f, 1.64556429e-01f, 2.41918430e-01f, 2.94270009e-01f,
  2.38775969e-01f, 2.10196614e-01f, 2.70741671e-01f, -2.65886426e-01f, 6.93654492e-02f, 1.16803743e-01f, -2.57115215e-01f, 3.46268803e-01f, 2.04857066e-01f, -1.79930866e-01f,
  2.35827975e-02f, -1.36723906e-01f, -2.74524748e-01f, -2.97877006e-02f, 1.99914023e-01f, 3.43343914e-01f, 3.02915841e-01f, -7.27753639e-02f, 1.67245507e-01f, 3.65350395e-01f,
  -3.52477990e-02f, 5.18473208e-01f, 1.95315614e-01f, 2.57227600e-01f, 4.89078134e-01f, -1.42785728e-01f, 5.31840146e-01f, 5.00113606e-01f, 6.76349998e-01f, 2.78857708e-01f,
  1.76340669e-01f, 2.56542742e-01f, -1.00405462e-01f, -6.78170085e-01f, 3.77124220e-01f, -1.64259002e-01f, 5.53299189e-02f, 8.60051692e-01f, 4.71734792e-01f, 6.81648076e-01f,
  -7.33963475e-02f, 1.62337303e-01f, 5.40996909e-01f, -2.04971015e-01f, 4.08923745e-01f, 4.84275103e-01f, -3.94922733e-01f, 5.57757974e-01f, -1.22063056e-01f, 4.21521097e-01f,
  -1.38578936e-01f, -2.40131259e-01f, 2.57673740e-01f, -1.39626101e-01f, 2.15625316e-01f, -1.06736168e-01f, 1.84762552e-01f, -3.17226917e-01f, -5.28901517e-01f, -1.64175052e-02f,
  4.91403714e-02f, 2.49053687e-01f, -4.99002278e-01f, 4.12197679e-01f, -4.43177193e-01f, -3.89234692e-01f, 9.05065686e-02f, 4.98683006e-01f, 2.56095659e-02f, -2.05210581e-01f,
  1.93344101e-01f, 1.17921479e-01f, -1.55054301e-01f, 4.66103047e-01f, 2.09480360e-01f, -2.26143450e-02f, 4.46100682e-01f, 1.00772321e-01f, -4.24477875e-01f, -3.41181532e-02f,
  4.93073821e-01f, -1.35680735e-01f, -6.43000007e-01f, -2.89639384e-01f, -8.07122514e-02f, 4.16185737e-01f, 7.09478080e-01f, 1.97688952e-01f, -2.05183789e-01f, 2.46636242e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  -9.34516788e-02f, 2.43595496e-01f, 2.63956070e-01f, 2.39697382e-01f, 2.70223320e-01f, 1.78337336e-01f, 1.77981645e-01f, 4.02532786e-01f, 3.83424491e-01f, 1.49037272e-01f,
  2.80166745e-01f, 4.00442600e-01f, 2.89488971e-01f, 1.85515836e-01f, 1.25766814e-01f, 1.25092983e-01f, -1.28031582e-01f, 1.62643209e-01f, 4.08368319e-01f, 2.89600402e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  2.84324378e-01f, 2.33553827e-01f, -5.57045341e-01f, 5.92924953e-02f, -7.48653114e-01f, -3.63876641e-01f, -2.36068010e-01f, 3.85574073e-01f, -7.77208507e-01f, -2.74463743e-01f,
  -3.00978661e-01f, 8.24088082e-02f, -1.06473463e-02f, -6.03526413e-01f, -2.72053391e-01f, -9.31661189e-01f, 1.15021549e-01f, 1.07909806e-01f, 3.98220837e-01f, -2.74370611e-01f,
  1.43900082e-01f, 3.06141395e-02f, 1.58667907e-01f, 2.49547958e-01f, -4.54497874e-01f, -8.41199517e-01f, -9.47697103e-01f, -2.34323025e-01f, 3.66596907e-01f, -4.82542813e-01f,
  -6.99189663e-01f, -6.29416287e-01f, -6.16529524e-01f, 2.01902553e-01f, -5.90707302e-01f, -6.58582926e-01f, 9.64969158e-01f, 3.75241667e-01f, 6.99262738e-01f, -2.15491593e-01f,
  -3.27975869e-01f, -1.64573967e-01f, 8.43977183e-02f, -4.95915189e-02f, 3.44258755e-01f, -4.21063125e-01f, -3.39180410e-01f, -1.31658077e-01f, 5.85487247e-01f, -7.34805942e-01f,
  1.53806895e-01f, -1.27551511e-01f, -5.01939356e-01f, 2.81736344e-01f, -2.07562428e-02f, -1.02714360e+00f, -1.13320076e+00f, -4.36968237e-01f, -1.34803250e-01f, 1.58080846e-01f,
  1.12919301e-01f, -9.79904756e-02f, 1.75400048e-01f, -2.93197781e-01f, 1.96071699e-01f, 3.23983252e-01f, -3.40010285e-01f, -8.00530687e-02f, -5.53922713e-01f, 2.70012796e-01f,
  6.01436436e-01f, 3.58532906e-01f, -5.80703139e-01f, 1.56818330e-02f, 4.27171707e-01f, 3.09102535e-01f, -2.67536223e-01f, -8.86773169e-01f, 4.52062935e-01f, -7.32107878e-01f,
  4.38715577e-01f, 2.89901763e-01f, -6.61684513e-01f, -1.38900997e-02f, -1.32478643e-02f, 4.44146425e-01f, -4.53965999e-02f, -9.00203228e-01f, 6.49427712e-01f, 4.19078857e-01f,
  5.68873435e-02f, -4.63290751e-01f, 8.28743540e-03f, -1.68153927e-01f, -4.90343422e-01f, -1.27248377e-01f, -2.85710454e-01f, 1.96668819e-01f, -7.56961927e-02f, 1.89349294e-01f,
  -3.93966705e-01f, -1.37762710e-01f, 1.38155743e-01f, 1.23975813e-01f, 2.93436587e-01f, 1.14250958e-01f, -1.94190562e-01f, 1.69986367e-01f, -9.73466933e-01f, -5.75456083e-01f,
  3.40377361e-01f, 4.63580102e-01f, -5.52771091e-02f, 3.71398836e-01f, 3.00949961e-01f, 5.75826168e-01f, -3.70742619e-01f, -1.05414593e+00f, 3.16305995e-01f, 7.82909989e-02f,
  -2.76125491e-01f, -1.59374386e-01f, 2.65766084e-01f, -3.97008449e-01f, -7.77979493e-01f, 1.73010647e-01f, -1.07101047e+00f, -3.35425824e-01f, -2.55106211e-01f, -5.89372158e-01f,
  4.72013295e-01f, 6.01742744e-01f, 5.01213908e-01f, -2.53322840e-01f, -3.90275866e-01f, 7.37774849e-01f, 7.25611672e-02f, 4.95707780e-01f, -1.10867985e-01f, 2.64863782e-02f,
  -7.84181282e-02f, -2.31238991e-01f, -1.06269431e+00f, -2.09143266e-01f, 1.95570841e-01f, 3.72084618e-01f, -2.48684570e-01f, 2.22835913e-01f, 1.66369513e-01f, -1.71095461e-01f,
  -6.87803388e-01f, 2.30612755e-01f, -2.70209551e-01f, 4.15318549e-01f, 2.02691868e-01f, -1.80258408e-01f, 1.42148025e-02f, 2.62764454e-01f, -1.36402681e-01f, -1.07243049e+00f,
  3.21603209e-01f, -4.36884731e-01f, 6.26142442e-01f, 6.27476210e-03f, 3.77072513e-01f, 1.69763252e-01f, 3.01313311e-01f, -3.58534008e-01f, 2.19107494e-01f, 6.41045868e-01f,
  1.39761016e-01f, 5.61395884e-02f, 1.53104678e-01f, 2.92009920e-01f, -8.27692032e-01f, -5.14824390e-01f, -7.65231848e-01f, 1.63562685e-01f, 3.21896791e-01f, -4.73247677e-01f,
  -4.51829396e-02f, -5.61273806e-02f, 4.75613885e-02f, -1.35124996e-01f, 3.83703887e-01f, -6.99788392e-01f, -2.14467928e-01f, -4.23354298e-01f, -7.59204011e-03f, -1.74005087e-02f,
  5.25047660e-01f, -7.88951933e-01f, -2.13805009e-02f, -4.68484908e-01f, 4.21647578e-01f, 5.15899479e-01f, -4.88549531e-01f, 1.26681924e-01f, 3.99218708e-01f, -4.52075183e-01f,
  1.69166937e-01f, -4.48632509e-01f, 1.70638561e-01f, -5.20984113e-01f, -1.65070936e-01f, 1.08167581e-01f, 4.00583923e-01f, -6.16352856e-01f, -6.31751046e-02f, -6.79259658e-01f,
  -3.75851661e-01f, -3.69272083e-01f, -1.15228319e+00f, 3.26046079e-01f, -9.32829618e-01f, -8.65711212e-01f, 3.62800211e-01f, 2.39986137e-01f, 2.01086402e-01f, 3.52449954e-01f,
  -1.67162627e-01f, -9.58758712e-01f, 3.50081354e-01f, 8.66688117e-02f, -1.58503875e-02f, -1.55695558e-01f, -2.27111325e-01f, -2.92489260e-01f, -3.05749834e-01f, -3.78192440e-02f,
  -2.77964503e-01f, -3.13800812e-01f, -5.02430141e-01f, -5.81982672e-01f, 8.84511918e-02f, -1.27720311e-01f, -2.00266972e-01f, 3.88366938e-01f, -8.01077858e-02f, 3.19155931e-01f,
  -5.81252813e-01f, 3.46521676e-01f, -9.13792431e-01f, -2.22643852e-01f, -6.57096207e-01f, -4.65732992e-01f, 4.77609396e-01f, -4.13502336e-01f, 3.97339582e-01f, 1.39895082e-01f,
  1.29457816e-01f, -5.29476106e-02f, 3.03378738e-02f, -1.86971456e-01f, -6.56363189e-01f, -2.16332376e-01f, 1.19164899e-01f, 9.24791098e-02f, 1.59429207e-01f, -3.18162471e-01f,
  -4.48925585e-01f, -3.62336546e-01f, 1.28686756e-01f, -2.03478470e-01f, 3.79087925e-01f, 2.13574544e-01f, 3.56326312e-01f, -3.95384640e-01f, 6.08018748e-02f, -8.05810988e-01f,
  -3.25374573e-01f, -1.43795252e-01f, -5.04216552e-01f, -3.49304140e-01f, -5.91110587e-01f, 2.71289498e-01f, -6.67762280e-01f, -5.77094555e-01f, 1.47554129e-01f, -8.04934919e-01f,
  5.79411387e-01f, -2.79410362e-01f, -6.14999712e-01f, 3.93463165e-01f, 1.62767127e-01f, 1.42452419e-01f, -1.69542283e-01f, 1.00126195e+00f, 3.45069587e-01f, 5.59406996e-01f,
  -1.33718789e-01f, 1.15221813e-01f, 2.70798970e-02f, 5.38357347e-02f, -8.10702682e-01f, -5.65561533e-01f, 7.40852535e-01f, 2.82166004e-01f, 2.12383673e-01f, 7.07926333e-01f,
  -3.73739712e-02f, 1.04945473e-01f, -3.62250626e-01f, -6.50638118e-02f, 1.40782326e-01f, 9.87377614e-02f, -6.89307570e-01f, -8.22550178e-01f, 6.14935935e-01f, 2.15991929e-01f,
  -1.39598012e-01f, -1.06034324e-01f, -4.04156804e-01f, 1.51784420e-01f, 3.72496754e-01f, 1.04835043e-02f, -8.12571526e-01f, -7.78639197e-01f, -1.17859468e-01f, 5.17988086e-01f,
  -2.49716207e-01f, 2.19822824e-01f, 1.74455494e-01f, 5.16548276e-01f, 1.13325611e-01f, -3.41392457e-02f, -5.47541857e-01f, 5.83988786e-01f, -1.67566672e-01f, -2.87967235e-01f,
  4.61316526e-01f, -2.88364857e-01f, -2.34416015e-02f, 4.99841303e-01f, -1.08024508e-01f, -2.26418525e-02f, 7.33141229e-02f, -4.32082027e-01f, 1.25950739e-01f, 6.07563138e-01f,
  6.20355725e-01f, -5.51518083e-01f, -2.93700937e-02f, -6.96925640e-01f, 5.62972203e-02f, -5.08707941e-01f, -5.00447690e-01f, -6.98906064e-01f, -1.27208507e+00f, 1.80027962e-01f,
  1.66673914e-01f, -7.16067776e-02f, -1.13418855e-01f, 7.30919838e-02f, -1.74078792e-01f, 2.90422052e-01f, 3.38541538e-01f, 1.91709310e-01f, 3.50294888e-01f, 2.41047353e-03f,
  4.52409893e-01f, 2.13523358e-01f, -1.35011390e-01f, -2.70185441e-01f, -6.08593464e-01f, -5.07051408e-01f, 2.24354222e-01f, 4.31549877e-01f, -6.42968237e-01f, -6.39256179e-01f,
  -3.04846466e-01f, 2.44720325e-01f, -7.26844132e-01f, -6.95925772e-01f, -5.45425355e-01f, 7.09079623e-01f, -4.33396101e-01f, 2.20259637e-01f, 2.33127266e-01f, 4.08228666e-01f,
  -1.07831009e-01f, -4.14570123e-01f, 2.61740386e-01f, -6.01164281e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.09586357e-02f, 9.47541557e-03f, 1.01439297e-01f, -1.66257158e-01f, 4.56904992e-02f, 2.72803068e-01f, 2.36760154e-01f, -2.10884050e-01f, 1.13603503e-01f, 1.16152018e-01f,
  2.29504723e-02f, 6.26029298e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    