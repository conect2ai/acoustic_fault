/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.38213843e-01f, 2.10424125e-01f, 3.18880588e-01f, 1.75741732e-01f, 2.31182382e-01f, 1.87989563e-01f, 2.44358197e-01f, 2.88413204e-02f, -1.40734287e-02f, 1.60096541e-01f,
  -4.30049859e-02f, -2.88498580e-01f, -1.91022366e-01f, -1.89442694e-01f, -1.82157815e-01f, 3.13204527e-01f, 3.30526292e-01f, 5.65055124e-02f, -2.13274956e-01f, -1.80149049e-01f,
  -1.93379477e-01f, -5.38259931e-02f, -1.44436419e-01f, -9.23376307e-02f, 9.78093222e-02f, -3.54794338e-02f, 2.64111698e-01f, 5.55362515e-02f, 5.47151715e-02f, 3.03369999e-01f,
  1.09312378e-01f, 1.01900734e-01f, -1.09129958e-01f, -1.51820570e-01f, 6.26978977e-03f, 2.20443439e-02f, -1.85288787e-02f, 4.53137606e-02f, -1.13757476e-02f, -6.69109672e-02f,
  8.00718740e-02f, -1.28130063e-01f, 1.84703190e-02f, 2.38762535e-02f, 5.07418662e-02f, 2.58617289e-03f, 2.81355008e-02f, -7.02476874e-02f, 1.33657921e-02f, -3.46461907e-02f,
  5.46801239e-02f, 1.68410003e-01f, 6.49065822e-02f, 1.04411496e-02f, -2.29375325e-02f, 1.82637316e-03f, 5.90324849e-02f, 1.50475036e-02f, -4.80124354e-02f, -2.06038426e-03f,
  -1.38064306e-02f, 5.68330325e-02f, 1.03834771e-01f, 1.36674689e-02f, 2.82457061e-02f, 1.28666803e-01f, -2.80598439e-02f, -6.18662797e-02f, 3.51538472e-02f, -1.47547293e-02f,
  -5.85959926e-02f, 7.10736215e-02f, -3.80207673e-02f, 6.07525818e-02f, 8.20714533e-02f, 7.62730092e-02f, 4.75561023e-02f, -2.88337208e-02f, -1.00337928e-02f, 2.48782616e-02f,
  -7.80719295e-02f, 5.97363636e-02f, 5.73471226e-02f, -3.79807763e-02f, 1.52740888e-02f, 2.83824746e-02f, 2.61945669e-02f, -3.40408348e-02f, 4.40237187e-02f, 1.32435216e-02f,
  -1.99501231e-01f, -5.34173287e-02f, 7.19937496e-03f, -1.49842396e-01f, 7.33013377e-02f, -3.68630812e-02f, -5.79579882e-02f, -4.99320626e-02f, -3.92285623e-02f, 3.74661759e-02f,
  -9.63993296e-02f, -7.32483640e-02f, 2.12273840e-02f, 2.69302092e-02f, -2.27231327e-02f, 1.78488754e-02f, -1.22747719e-01f, 2.26255413e-02f, -1.11935467e-01f, -5.44086006e-03f,
  -6.62512407e-02f, -4.56365831e-02f, -1.01292647e-01f, -2.87993606e-02f, -4.93136048e-02f, -1.05337352e-01f, -8.21179245e-03f, -2.50327270e-02f, -4.18392979e-02f, 3.02933082e-02f,
  -3.53554100e-01f, 1.87453896e-01f, -3.15437615e-02f, -2.89797634e-01f, 8.48045126e-02f, 1.70491442e-01f, 3.41390252e-01f, 3.13084602e-01f, -2.55205967e-02f, 3.07905637e-02f,
  6.72537740e-03f, -2.12782070e-01f, -8.58061314e-02f, 1.00163119e-02f, -1.08150234e-02f, -1.97369810e-02f, -1.43458068e-01f, -3.39800864e-02f, -4.40312959e-02f, -4.13179211e-02f,
  -3.48071791e-02f, -7.78612196e-02f, -4.00789417e-02f, 3.23450901e-02f, -8.09538588e-02f, -1.13821454e-01f, 1.30386233e-01f, 4.18872908e-02f, -2.39129607e-02f, -3.39667916e-01f,
  -3.50908279e-01f, -1.14235073e-01f, 4.31548692e-02f, 1.71873290e-02f, 9.07962248e-02f, -4.67518829e-02f, 2.58556325e-02f, -1.04028005e-02f, 3.34452353e-02f, 6.88405633e-02f,
  -8.64468142e-02f, -4.89235222e-02f, -4.79843132e-02f, -2.04480328e-02f, -5.46825491e-02f, 8.89916867e-02f, -4.25716639e-02f, 1.01958103e-02f, 1.49569493e-02f, 9.30870697e-03f,
  -5.96158542e-02f, 1.04167592e-02f, 1.04797594e-01f, 8.72481391e-02f, 4.75275926e-02f, -1.28115283e-03f, 4.82103303e-02f, 7.91442394e-02f, 1.80655822e-01f, -3.49402316e-02f,
  -4.18416969e-02f, 9.82251242e-02f, 3.68743502e-02f, -1.38925798e-02f, -1.99993979e-02f, 1.39597468e-02f, -7.27062374e-02f, -7.00896233e-02f, 1.69967525e-02f, -4.09625955e-02f,
  1.80082005e-02f, -1.42830953e-01f, 3.00120395e-02f, 3.56855690e-02f, 9.27129388e-03f, -7.38598853e-02f, 3.40650119e-02f, 3.96202058e-02f, 4.30202559e-02f, 5.29081635e-02f,
  -1.20276779e-01f, 8.02308246e-02f, -7.70647377e-02f, -3.04966364e-02f, 7.06944987e-02f, 8.80218204e-03f, -9.42973047e-02f, -3.95013765e-02f, -3.39064710e-02f, -1.54869584e-02f,
  -1.04396723e-01f, 1.89132079e-01f, -1.75004199e-01f, -1.06677398e-01f, 1.54745057e-02f, -1.34204384e-02f, -1.30533352e-01f, -3.02188843e-02f, -6.35422692e-02f, -9.12527367e-02f,
  -4.33109887e-02f, -6.69159507e-03f, -2.16607954e-02f, 4.71219309e-02f, -2.40188688e-02f, -6.64798096e-02f, 4.26143371e-02f, -1.57821536e-01f, 4.77204025e-02f, 7.38827512e-02f,
  6.52084127e-02f, -2.35848948e-02f, -7.05084801e-02f, 2.70413868e-02f, 3.38052586e-02f, -5.76876514e-02f, -3.83545719e-02f, 2.45653875e-02f, -1.40331332e-02f, 9.61247310e-02f,
  1.43472508e-01f, 3.02781999e-01f, 1.68751061e-01f, -3.93606350e-02f, 4.88889255e-02f, 9.36129875e-03f, 1.39299139e-01f, -6.43908679e-02f, -2.39872679e-01f, 1.19610697e-01f,
  -3.89765725e-02f, -4.07379717e-01f, -2.00505465e-01f, -1.45455673e-01f, -1.33718163e-01f, 3.16912353e-01f, 2.31546208e-01f, 1.19655151e-02f, -2.25883886e-01f, -6.08140044e-02f,
  5.54379821e-02f, 8.81960541e-02f, 3.02643720e-02f, -1.28576979e-01f, 1.01084048e-02f, -2.19513729e-01f, 1.44697160e-01f, 1.18315570e-01f, 1.29263297e-01f, 2.62184948e-01f,
  -4.54285331e-02f, 5.98464720e-02f, -8.24132785e-02f, -1.07090604e-02f, -2.28617210e-02f, -5.35643660e-02f, 3.77351493e-02f, 6.30426221e-03f, 2.49201823e-02f, 1.02126315e-01f,
  -4.34553716e-03f, 1.16606504e-02f, -4.44031991e-02f, 6.38810592e-03f, 6.05691522e-02f, 7.15971068e-02f, 5.06616421e-02f, 9.54316780e-02f, 8.75006523e-03f, 1.10042375e-02f,
  2.02956311e-02f, 2.04172865e-01f, 4.38483395e-02f, -7.03413785e-02f, 1.41315097e-02f, 5.24006523e-02f, 2.01487597e-02f, 3.30105983e-02f, 3.18383910e-02f, 1.92519873e-01f,
  -3.74878608e-02f, -2.32727062e-02f, 6.06338717e-02f, 5.83512336e-03f, 6.33009300e-02f, -1.33363158e-01f, -1.90215167e-02f, -1.01559060e-02f, -1.90479401e-02f, 3.33264694e-02f,
  -4.41262983e-02f, -4.24438715e-02f, 3.00326142e-02f, -1.79979727e-02f, -2.49900259e-02f, 3.49627882e-02f, 3.05300299e-02f, -1.36876460e-02f, -4.74834517e-02f, -4.27924283e-02f,
  -4.30299118e-02f, -7.90033862e-02f, -3.40962857e-02f, -4.88390028e-02f, 6.14918955e-02f, -1.84161321e-03f, 7.71635026e-02f, -6.62226602e-02f, -1.89526360e-02f, 4.31337841e-02f,
  -1.78738236e-01f, -5.52452132e-02f, -6.04222193e-02f, -7.72936642e-02f, 9.65782031e-02f, -1.54266013e-02f, 3.84013318e-02f, -2.69169100e-02f, -2.18146201e-02f, -4.23921831e-02f,
  3.46142203e-02f, -1.24518283e-01f, 1.35914879e-02f, 2.97489036e-02f, -4.05545495e-02f, -5.57537153e-02f, 8.57366025e-02f, -6.32862421e-03f, 3.09008174e-02f, 9.73916426e-02f,
  -3.34758824e-03f, -7.22967554e-03f, -6.98680878e-02f, -3.35819758e-02f, -9.19495076e-02f, -6.55270666e-02f, -1.16909362e-01f, -3.02896667e-02f, -9.07407328e-02f, 9.00499895e-02f,
  5.66403270e-01f, 3.07026863e-01f, 3.42230529e-01f, -1.36005461e-01f, -1.78254426e-01f, -3.59067530e-03f, 2.79608399e-01f, 3.08086001e-03f, -1.25601619e-01f, 5.56543423e-03f,
  -3.58942337e-02f, -2.68286288e-01f, -2.82441569e-03f, -8.32258016e-02f, 1.15774505e-01f, 1.99936703e-01f, 4.67764698e-02f, 1.05186716e-01f, 2.40536444e-02f, -1.69074416e-01f,
  -1.45546928e-01f, -9.85955447e-02f, 2.99748164e-02f, -7.41880611e-02f, -2.88032610e-02f, -1.66541427e-01f, 2.33972762e-02f, 2.90735867e-02f, 2.97834761e-02f, 6.19200952e-02f,
  2.07807750e-01f, 2.82155365e-01f, -8.78762230e-02f, -4.28801551e-02f, 6.67731911e-02f, 7.17910305e-02f, 1.07469693e-01f, 3.78780030e-02f, -8.93025473e-03f, 3.93215455e-02f,
  1.29740359e-02f, 9.82026085e-02f, -1.79310031e-02f, -1.20448426e-03f, 4.06805426e-02f, 9.97761339e-02f, -4.25789952e-02f, 1.74913421e-01f, 1.41562089e-01f, 6.42389134e-02f,
  4.11580550e-03f, 3.67848799e-02f, 2.05153331e-01f, 3.44423279e-02f, 1.85562164e-01f, 1.61550939e-02f, 6.27666786e-02f, 3.22064161e-02f, 1.66987568e-01f, 1.31855801e-01f,
  -8.90377536e-02f, 5.97340465e-02f, -5.99082187e-02f, 8.37161951e-03f, -6.13922700e-02f, -1.07317649e-01f, 1.74951609e-02f, -1.18232099e-02f, -4.75528836e-02f, 2.16933619e-02f,
  3.62595581e-02f, -6.06814735e-02f, -5.33351339e-02f, 6.38284460e-02f, -8.30101073e-02f, 3.59748229e-02f, 4.27955687e-02f, 4.20500226e-02f, 1.10187044e-03f, -2.12529041e-02f,
  7.47386962e-02f, -3.39729413e-02f, 8.14569555e-03f, 5.08695506e-02f, -2.07143724e-02f, 3.97309214e-02f, -1.92582086e-02f, 3.19555849e-02f, -4.44701761e-02f, 2.31370330e-02f,
  -3.87491360e-02f, -1.08506801e-02f, 8.63108858e-02f, 2.82183569e-02f, 1.66636351e-02f, 3.21103744e-02f, -6.06806912e-02f, -3.32024768e-02f, 2.67964005e-02f, 5.13688028e-02f,
  -6.37742644e-03f, 9.63223651e-02f, -2.57814750e-02f, -2.23572161e-02f, -4.97265905e-02f, 6.47554696e-02f, -1.12886000e-02f, -3.79396267e-02f, -5.49664907e-03f, -8.30912590e-02f,
  -3.20024230e-02f, 4.57444973e-02f, 1.64133444e-01f, 1.05411634e-01f, 5.15037514e-02f, -7.21006002e-03f, 1.23361491e-01f, 6.70576394e-02f, 1.83440283e-01f, 1.25893965e-01f,
  1.09293267e-01f, -1.79069027e-01f, -1.47903115e-01f, -1.56485319e-01f, 2.41797313e-01f, 3.21449339e-01f, 4.63329226e-01f, 1.47574246e-01f, 1.19123952e-02f, -7.31324032e-02f,
  3.83444652e-02f, -1.24615110e-01f, -2.09020093e-01f, -1.16365686e-01f, 1.38517335e-01f, 7.72000477e-03f, -5.92938960e-02f, -4.28859070e-02f, 1.35129273e-01f, 1.83790818e-01f,
  6.88908920e-02f, -4.17877547e-02f, -1.31132677e-01f, 3.81958820e-02f, -1.30476564e-01f, -1.36126146e-01f, -1.25175402e-01f, -1.06114581e-01f, -6.25920435e-03f, -4.54269379e-01f,
  -3.33278447e-01f, 6.68781251e-02f, -5.07939570e-02f, -1.50600849e-02f, -5.86992018e-02f, -8.90699476e-02f, -2.41139587e-02f, -7.08867908e-02f, -1.79945137e-02f, -5.52802123e-02f,
  -2.24168822e-02f, -3.06333583e-02f, 1.15142927e-01f, 1.07693411e-02f, 2.95128226e-02f, 3.55236717e-02f, 3.79380025e-02f, -1.14036873e-02f, -4.35065031e-02f, -1.35517329e-01f,
  -1.39581729e-02f, 1.69041548e-02f, 1.42428979e-01f, 8.46358836e-02f, 4.00039088e-03f, 1.05746582e-01f, 1.28345452e-02f, -3.16906348e-02f, 7.78932348e-02f, -2.18601406e-01f,
  3.80895175e-02f, -6.81946054e-02f, 5.87820746e-02f, -1.87610853e-02f, 5.86022176e-02f, 5.16419858e-02f, -3.24958041e-02f, 6.45493995e-03f, -8.02849531e-02f, -1.02288621e-02f,
  1.49928275e-02f, -2.21659336e-02f, 2.19252948e-02f, -1.30518069e-02f, 7.39777926e-03f, -2.73267943e-02f, 7.58270770e-02f, -1.02114461e-01f, -4.61784052e-03f, -2.98710447e-03f,
  -1.04253888e-02f, -1.40850227e-02f, -1.89509168e-02f, -1.81568842e-02f, -3.45008932e-02f, -3.23586538e-02f, -1.06824990e-02f, -6.69969022e-02f, 2.61916649e-02f, -9.26412269e-02f,
  -7.54622445e-02f, 3.07302743e-01f, -1.72521681e-01f, -1.31211709e-02f, 4.95949108e-03f, -6.81820810e-02f, -2.62462310e-02f, 8.17877240e-03f, -2.34133080e-02f, -5.11375070e-02f,
  1.54822750e-03f, -1.34907272e-02f, -1.00045159e-01f, 2.22768169e-02f, 1.90980397e-02f, 6.29132912e-02f, 8.53548478e-03f, -2.17125881e-02f, 2.21024156e-02f, -1.29657432e-01f,
  -3.46370116e-02f, 1.06256798e-01f, -4.28243016e-04f, -3.20617817e-02f, -1.97029561e-02f, 5.67280762e-02f, 5.90187404e-03f, 3.83644141e-02f, 1.22369260e-01f, -1.68955757e-03f,
  3.16923797e-01f, 3.02798182e-01f, -1.04981326e-01f, 1.16445147e-01f, 2.23604515e-01f, 4.53302450e-02f, 9.39377546e-02f, 1.87243432e-01f, 4.90820967e-03f, -8.90461206e-02f,
  4.55763154e-02f, -1.29336700e-01f, -1.33553132e-01f, -2.28871331e-01f, -8.09112191e-02f, -2.51291662e-01f, -2.78951377e-01f, -2.51798570e-01f, -2.94667304e-01f, -1.12769514e-01f,
  -1.13701746e-01f, 8.90243948e-02f, 4.40263525e-02f, -2.17717811e-02f, -6.15980336e-03f, -2.14725822e-01f, -1.03025287e-01f, 5.22191115e-02f, -1.95342213e-01f, -2.42095560e-01f,
  -3.45518529e-01f, 1.24528468e-01f, -8.56576413e-02f, 1.72252338e-02f, 9.94867459e-02f, 4.36413176e-02f, 3.85678820e-02f, -4.96630520e-02f, 1.44483954e-01f, -1.25301719e-01f,
  7.61434482e-03f, 1.08004399e-01f, -5.91930561e-02f, -1.08899241e-02f, -2.76315748e-03f, -7.30315745e-02f, 1.38697131e-02f, 1.77195668e-02f, -9.03391652e-03f, -3.96017879e-02f,
  9.53173786e-02f, -9.55462456e-03f, 8.55889767e-02f, 8.09784159e-02f, 8.90748203e-03f, 9.57694501e-02f, 9.63734463e-02f, -8.09845626e-02f, -6.65900260e-02f, -1.54075056e-01f,
  -2.31338665e-02f, 1.18284948e-01f, 5.92386872e-02f, 1.20465472e-01f, 1.66612342e-02f, 1.24145381e-01f, -5.86215034e-02f, -4.30622771e-02f, 8.08824599e-02f, 4.08627465e-02f,
  2.77839601e-02f, 9.66493273e-04f, 5.70636317e-02f, -2.52692793e-02f, -7.42033496e-02f, 3.63609307e-02f, 3.95867303e-02f, 2.52901372e-02f, 2.16746628e-02f, 2.89647207e-02f,
  7.58163780e-02f, 5.27215935e-02f, 7.04196766e-02f, 9.83566162e-04f, 6.86068907e-02f, -2.45025232e-02f, -2.35257912e-02f, 4.45911884e-02f, 1.18565653e-02f, 2.97822617e-02f,
  9.83965117e-03f, 1.90864399e-01f, -4.83116508e-02f, -5.18747792e-02f, 2.41479967e-02f, 1.96986292e-02f, -6.37329593e-02f, 5.95181659e-02f, 1.06551915e-01f, -8.07993114e-02f,
  -1.82472579e-02f, -5.98577932e-02f, -3.49652246e-02f, -6.74649999e-02f, 2.65607554e-02f, -1.12823814e-01f, 8.99510086e-02f, -1.45290950e-02f, 1.33909378e-02f, 4.22077179e-02f,
  6.21550120e-02f, 2.68694684e-02f, -3.99807729e-02f, -1.76302586e-02f, 2.24790052e-02f, -4.53033075e-02f, -1.78221196e-01f, -1.09457955e-01f, -1.76469274e-02f, -1.03189908e-01f,
  6.75107762e-02f, -1.44547582e-01f, -1.16044290e-01f, -3.68685909e-02f, 2.57881377e-02f, 1.12681136e-01f, 6.09364919e-02f, 8.81504044e-02f, -9.74878594e-02f, -6.12759329e-02f,
  -4.25782017e-02f, 1.61406949e-01f, 4.59386781e-02f, -8.53232853e-03f, 2.22749457e-01f, -2.35283338e-02f, -7.92809054e-02f, 1.57281518e-01f, 2.52982974e-01f, 2.35745549e-01f,
  1.53219536e-01f, -5.22859022e-02f, 1.19163826e-01f, 1.67822972e-01f, -4.23272178e-02f, 1.01407552e-02f, -1.28061205e-01f, -9.42706615e-02f, -6.89479709e-02f, -1.31147683e-01f,
  -3.17297429e-02f, 1.23148359e-01f, 1.46561727e-01f, 1.98789418e-01f, 5.31299599e-02f, 1.23503730e-01f, 5.50727509e-02f, 1.12232780e-02f, 1.34360999e-01f, 3.20435129e-02f,
  1.50974885e-01f, 1.34737507e-01f, 1.64257467e-01f, 5.84962815e-02f, 5.33629954e-02f, 1.17229514e-01f, 5.38150519e-02f, 2.58392878e-02f, 1.40594244e-01f, 9.83661115e-02f,
  1.34202331e-01f, 1.35707676e-01f, 1.05218768e-01f, 6.49306690e-04f, 1.55996591e-01f, 1.40585229e-01f, 8.44798051e-03f, 7.35362321e-02f, 9.63883400e-02f, -1.18215457e-01f,
  9.10825562e-03f, -7.31078088e-02f, -3.50537486e-02f, -3.65344919e-02f, -1.06081858e-01f, -7.09062070e-02f, 3.23776789e-02f, -1.12089999e-01f, -1.09559111e-02f, -6.05491474e-02f,
  1.91516113e-02f, -1.33907437e-01f, -4.75869142e-02f, 3.86503190e-02f, 6.07556757e-03f, -7.79293524e-03f, 9.35660675e-03f, -1.24190718e-01f, -7.61283711e-02f, -1.71102688e-01f,
  -9.41039845e-02f, -4.57098475e-03f, -4.01031859e-02f, -1.06867485e-01f, 1.94150526e-02f, -1.57735180e-02f, -9.08275545e-02f, -6.15555793e-03f, -6.68959320e-02f, 1.74843799e-02f,
  -1.63777366e-01f, 1.03715891e-02f, -1.03888258e-01f, 6.00000583e-02f, 1.04494408e-01f, 5.75800017e-02f, -8.68592113e-02f, 3.67466584e-02f, 4.13709655e-02f, 1.58792123e-01f,
  1.60948575e-01f, 1.43911034e-01f, 2.01907884e-02f, -7.78383994e-03f, 1.87025189e-01f, 1.36605039e-01f, 5.84492907e-02f, 5.55192605e-02f, 1.90805718e-02f, 4.60466035e-02f,
  -4.27180119e-02f, -3.81350294e-02f, -5.67022860e-02f, -1.58246726e-01f, 2.06297636e-02f, -1.56359226e-02f, -1.16688423e-02f, -1.04353294e-01f, 6.59411028e-02f, -2.53771216e-01f,
  -2.03828499e-01f, -2.21712142e-01f, -2.03219280e-01f, -1.08727440e-02f, 7.69532695e-02f, -1.59595907e-01f, -3.29654306e-01f, -2.26638839e-01f, 1.58571586e-01f, -4.84984629e-02f,
  1.15203355e-02f, 2.38194503e-02f, 4.22140583e-02f, 3.50751057e-02f, -1.72923878e-01f, -1.53401464e-01f, -1.03173204e-01f, -5.53950444e-02f, -1.14535175e-01f, 6.82242736e-02f,
  1.10234104e-01f, 4.63347360e-02f, -2.67806631e-02f, 4.33421284e-02f, 4.61828969e-02f, 8.56316388e-02f, -1.11142090e-02f, 3.68964882e-03f, -9.51033682e-02f, -5.09852618e-02f,
  -5.31067625e-02f, -1.46106735e-01f, 4.38303165e-02f, 1.15386374e-01f, -3.74975381e-03f, -7.83063471e-02f, -5.76948747e-02f, -7.04337135e-02f, -3.68161388e-02f, -5.65382726e-02f,
  4.56827134e-02f, 5.51440343e-02f, 2.43116859e-02f, 3.33137102e-02f, -1.08638428e-01f, -1.40659660e-01f, -1.39429286e-01f, -1.59509197e-01f, -8.83533657e-02f, -8.83872434e-02f,
  4.70019877e-02f, -1.66561101e-02f, -1.93470880e-01f, -8.26126784e-02f, -1.62720196e-02f, 1.02923587e-01f, -1.09687410e-01f, 3.60553265e-02f, -3.36919948e-02f, -1.16079174e-01f,
  1.50797263e-01f, 5.96428243e-03f, -3.28205302e-02f, -8.57082978e-02f, 2.60229465e-02f, 3.63885313e-02f, 9.33433399e-02f, 3.86635438e-02f, -2.83859726e-02f, -8.13940261e-03f,
  8.28613117e-02f, 3.06766331e-02f, 9.59970206e-02f, 8.66931975e-02f, 5.56531660e-02f, -3.28751653e-02f, 5.59979789e-02f, -2.45166458e-02f, -1.35721220e-02f, -6.34576380e-02f,
  9.36181098e-02f, -3.60609479e-02f, 4.73100953e-02f, 6.90156594e-02f, -4.52468432e-02f, 6.33976087e-02f, 3.86951268e-02f, 2.81311274e-02f, -5.79731390e-02f, 6.00405522e-02f,
  -1.45363271e-01f, 1.42774180e-01f, -5.41553423e-02f, -2.04452619e-01f, -6.23813681e-02f, -9.03665945e-02f, -4.25142571e-02f, -1.00554368e-02f, -4.09601554e-02f, -5.83470017e-02f,
  -1.27360478e-01f, -3.98165770e-02f, -8.43036920e-02f, -6.94313571e-02f, -3.85631248e-02f, -7.11131692e-02f, -1.89584926e-01f, -1.17358617e-01f, -7.81512111e-02f, -1.58582658e-01f,
  -6.03121705e-02f, -1.72645792e-01f, -1.26382664e-01f, -1.43697217e-01f, -6.64450973e-02f, -8.23537856e-02f, -1.20442562e-01f, -5.52395061e-02f, -9.31304619e-02f, -2.07476512e-01f,
  6.64069355e-01f, -3.29869509e-01f, 6.62500188e-02f, 1.19068012e-01f, -2.99668223e-01f, -2.24550039e-01f, -2.75397539e-01f, 5.77777475e-02f, 7.34898821e-02f, -1.79346114e-01f,
  -2.25919738e-01f, -1.98891401e-01f, -3.99089158e-02f, -7.43541792e-02f, 2.24212021e-01f, -1.03449732e-01f, 3.11739910e-02f, 3.32515806e-01f, 3.06394130e-01f, 3.93482372e-02f,
  -1.06161512e-01f, 9.88174677e-02f, 3.34861398e-01f, 1.45606413e-01f, -1.79442585e-01f, -4.04186025e-02f, -1.25873029e-01f, -1.66065283e-02f, -2.51070708e-01f, -1.62285745e-01f,
  -1.13356121e-01f, 2.43517314e-03f, 2.36376207e-02f, 2.97717955e-02f, -8.56209770e-02f, 5.82553670e-02f, -1.08059878e-02f, 1.39425043e-04f, -2.53127422e-02f, 2.49706209e-02f,
  -1.81977510e-01f, -8.11112598e-02f, 1.53586129e-02f, -8.13883469e-02f, -2.29895785e-02f, 4.06926731e-04f, 8.94633159e-02f, 1.42035529e-01f, 1.08494639e-01f, -5.83172850e-02f,
  -2.22207278e-01f, -8.46446604e-02f, 6.59613013e-02f, -7.20389932e-02f, 7.39760771e-02f, 8.73937234e-02f, -9.00055692e-02f, 1.18853403e-02f, 6.63012713e-02f, 6.95561292e-03f,
  -4.08846550e-02f, -3.76404971e-02f, -3.38950008e-02f, 1.17110778e-02f, 1.64564811e-02f, -3.81013216e-03f, 2.82060746e-02f, -2.54972428e-02f, 3.86006385e-02f, -7.69135877e-02f,
  2.55253748e-03f, 4.12364118e-02f, 2.40385868e-02f, 6.32680545e-04f, -1.16953127e-01f, -9.16426629e-03f, -4.31870632e-02f, -8.29188805e-03f, -6.24325387e-02f, 3.05567775e-02f,
  7.97607005e-02f, 9.04998742e-04f, 3.40185389e-02f, -3.80044896e-03f, -2.32719388e-02f, 7.67573118e-02f, -3.95871252e-02f, -8.99572596e-02f, 1.95906614e-03f, -2.17736373e-03f,
  -1.07039660e-02f, -3.83770391e-02f, -3.01570706e-02f, 4.53577861e-02f, -5.50743267e-02f, 4.72296914e-03f, -9.22191050e-03f, -2.15265667e-03f, -4.14603204e-02f, -1.34196291e-02f,
  4.55089001e-04f, 8.55656564e-02f, 2.93952273e-03f, 2.36620512e-02f, 9.56841260e-02f, -5.56980669e-02f, -8.69008452e-02f, -3.19921747e-02f, -5.98545372e-02f, -3.95212658e-02f,
  4.21975926e-03f, 1.08631112e-01f, 1.47614703e-01f, 1.35406498e-02f, -8.47102925e-02f, 5.94922714e-02f, -1.00124724e-01f, 6.83368072e-02f, 1.77871391e-01f, 4.72368896e-02f,
  1.88325062e-01f, 4.52727303e-02f, 1.05257310e-01f, 5.08253612e-02f, -2.59133637e-01f, -3.98967266e-01f, -4.55219030e-01f, -2.22550541e-01f, -3.49854827e-02f, -1.67042896e-01f,
  1.96675658e-02f, 2.00469755e-02f, -3.83234322e-02f, -8.83448198e-02f, -2.01983258e-01f, -1.61147743e-01f, -1.92608804e-01f, 4.18375246e-02f, -1.47190303e-01f, -3.29896212e-01f,
  -1.64049491e-01f, 5.85704446e-02f, 1.53536677e-01f, 1.92586444e-02f, -5.86046241e-02f, -4.93979156e-02f, -5.36327204e-03f, 4.83040772e-02f, -1.16747417e-01f, 2.04848930e-01f,
  8.61574635e-02f, 8.02414492e-02f, -1.60372704e-01f, -3.53082344e-02f, -4.70317490e-02f, -1.20770026e-04f, -1.36219546e-01f, 8.93761963e-02f, -6.14593178e-03f, -9.83048156e-02f,
  1.98727287e-02f, -3.97016673e-04f, 3.25940140e-02f, -1.32675581e-02f, 4.74516526e-02f, -1.23645328e-01f, -9.59095638e-03f, 3.07804737e-02f, 4.08888608e-02f, -1.32273734e-01f,
  -6.49110377e-02f, 1.12898685e-01f, 3.29922959e-02f, -3.84739228e-02f, -9.14350823e-02f, 9.36245080e-03f, -4.45580930e-02f, -8.75180066e-02f, -3.21928822e-02f, -5.47787212e-02f,
  -9.57844481e-02f, 1.47734582e-01f, 1.35091260e-01f, 2.21245274e-01f, 1.31223857e-01f, 2.12066337e-01f, 8.43907595e-02f, 6.07916191e-02f, 1.07681021e-01f, 1.49577141e-01f,
  2.06433281e-01f, 1.32923946e-01f, 1.66131213e-01f, 1.88844234e-01f, 1.78833917e-01f, 1.66018575e-01f, 8.78602564e-02f, 2.34813511e-01f, 1.49882361e-01f, 1.56856716e-01f,
  1.77250296e-01f, 1.65528163e-01f, 2.08171517e-01f, 1.69959471e-01f, 2.26680592e-01f, 2.18598977e-01f, 9.85066593e-02f, 1.55313447e-01f, 2.06350118e-01f, 1.14605114e-01f,
  -1.17728956e-01f, -1.13337494e-01f, -1.04082316e-01f, -1.38957441e-01f, -8.94024298e-02f, -1.02869146e-01f, -9.93276536e-02f, -7.29912221e-02f, -7.60432053e-03f, -1.37861744e-01f,
  -9.20986757e-02f, 1.98962237e-03f, -7.22528845e-02f, -4.00798880e-02f, -1.92741320e-01f, -1.47275686e-01f, -6.20077625e-02f, -7.41659030e-02f, -1.72824219e-01f, -1.17502950e-01f,
  -1.17992006e-01f, -1.99923292e-01f, -2.18578070e-01f, -2.34996602e-01f, -1.47465199e-01f, -2.33135879e-01f, -1.56232193e-01f, -2.43839011e-01f, -2.65306979e-01f, -2.15048119e-01f,
  4.38381612e-01f, -2.24540457e-01f, -7.93777481e-02f, 1.92136541e-01f, 2.52326250e-01f, 1.52317271e-01f, -1.05850719e-01f, -2.73187365e-02f, 1.81543335e-01f, -1.28017887e-01f,
  -1.81270525e-01f, 8.76628906e-02f, 2.61628907e-02f, -5.97681887e-02f, -8.34104717e-02f, 1.96196698e-02f, 1.48147285e-01f, 1.23116195e-01f, 2.48576209e-01f, 2.29059696e-01f,
  2.22102210e-01f, 3.51273745e-01f, 3.50011408e-01f, 1.26986712e-01f, 1.17422469e-01f, 9.79896039e-02f, 1.55828623e-02f, 9.70605016e-02f, 9.24320053e-03f, 1.39482081e-01f,
  -2.24153578e-01f, -2.47468874e-02f, 2.39700321e-02f, -4.78516379e-03f, -1.09546985e-02f, -1.00815088e-01f, -1.10459238e-01f, -6.13248385e-02f, -4.56817895e-02f, -2.58302577e-02f,
  -3.46254520e-02f, 1.47987588e-03f, -3.39760026e-03f, -2.14152094e-02f, 4.10638005e-03f, -7.07732067e-02f, -4.90614772e-02f, -1.18416920e-01f, -8.58032610e-03f, -1.70822948e-01f,
  -6.45588711e-02f, 1.64814189e-01f, 1.69382114e-02f, -7.17944428e-02f, -1.08704276e-01f, 3.36867124e-02f, -1.89135447e-01f, 1.14260940e-02f, -2.98221186e-02f, -1.08482495e-01f,
  2.35556602e-03f, -6.97086230e-02f, 5.99900037e-02f, -1.66266970e-02f, 8.07505324e-02f, -7.90225938e-02f, 4.89744283e-02f, 7.27463290e-02f, 3.47716473e-02f, 4.79753539e-02f,
  -1.36604691e-02f, -6.01502359e-02f, 2.60162633e-02f, -6.66728383e-03f, 1.87201016e-02f, 9.69761238e-02f, 7.58400485e-02f, 3.99709446e-03f, 1.80439800e-02f, -1.29358596e-04f,
  7.28686973e-02f, 9.62432176e-02f, 7.13507133e-03f, 2.98057776e-03f, 2.02629436e-02f, 4.58264761e-02f, 1.55231981e-02f, 2.39990074e-02f, 3.01671997e-02f, 5.59771247e-02f,
  -2.08030120e-02f, -9.99693647e-02f, -6.48724735e-02f, -3.98118608e-02f, 3.76793928e-03f, -1.74238026e-01f, -1.19414866e-01f, -4.71678823e-02f, -1.07138775e-01f, -1.22542128e-01f,
  -2.50646640e-02f, -4.55397293e-02f, -1.05616018e-01f, -7.83116966e-02f, 7.80955628e-02f, -2.08883323e-02f, -9.43376198e-02f, 4.78322431e-02f, -9.43033770e-02f, -9.80938673e-02f,
  -1.10201478e-01f, -1.39893563e-02f, 1.38005286e-01f, -6.66239709e-02f, -3.87682728e-02f, 1.22163162e-01f, -1.11454420e-01f, -8.17123652e-02f, -1.07744694e-01f, -1.31913573e-01f,
  1.35019526e-01f, -3.04085702e-01f, -4.35495406e-01f, 2.12354049e-01f, -6.28417879e-02f, -2.25616634e-01f, -4.81211394e-01f, -1.35927379e-01f, 2.37002611e-01f, -1.40151322e-01f,
  8.29942971e-02f, 3.31711531e-01f, 2.14957431e-01f, 1.16029181e-01f, -3.30359340e-02f, -2.64013290e-01f, -9.76971462e-02f, -7.33153298e-02f, 1.46060556e-01f, 6.42323196e-02f,
  1.71043232e-01f, 7.68114105e-02f, 1.82673708e-01f, 7.45266825e-02f, -2.18679849e-02f, 6.32990003e-02f, -2.08443791e-01f, 1.55051192e-02f, -1.96823299e-01f, -1.51023164e-01f,
  -3.02007999e-02f, -8.77174735e-03f, 1.29003987e-01f, 1.94357425e-01f, 8.86453614e-02f, 8.80042985e-02f, 1.10481000e-02f, 3.73769552e-02f, 3.34881768e-02f, 8.86556357e-02f,
  6.14615232e-02f, 1.85271755e-01f, 1.07184656e-01f, 3.76063660e-02f, -1.55807026e-02f, 1.02536134e-01f, 1.58979986e-02f, 5.34719341e-02f, 2.72389245e-03f, 3.20417248e-02f,
  8.10388774e-02f, 7.55690634e-02f, -1.32888556e-01f, 1.29305441e-02f, -1.06317267e-01f, 1.31628707e-01f, -1.24978319e-01f, -5.53817488e-02f, -1.05162926e-01f, 1.30923446e-02f,
  5.17343618e-02f, -6.84935972e-02f, -8.20862427e-02f, -4.84350733e-02f, -1.30111547e-02f, 1.58061832e-02f, 1.93188321e-02f, -3.11446749e-02f, 9.08026993e-02f, -7.23965019e-02f,
  1.12559628e-02f, -2.80812737e-02f, 1.19896233e-02f, 9.33355279e-03f, 8.07701983e-03f, -3.35788503e-02f, -1.97069589e-02f, 1.15076480e-02f, 8.67063180e-02f, 6.46901429e-02f,
  2.02014577e-02f, 1.90615803e-02f, 5.88362999e-02f, -1.53321978e-02f, 6.31253794e-02f, -1.86221092e-03f, 1.73243433e-02f, 2.96420474e-02f, -1.00178430e-02f, 9.13381800e-02f,
  2.01128542e-01f, -7.73478001e-02f, 1.06872074e-01f, 7.69992471e-02f, 4.07374609e-05f, 8.17062184e-02f, 4.87137958e-02f, 3.96201164e-02f, 1.09279498e-01f, -5.26391994e-03f,
  1.91546436e-02f, -5.44745289e-03f, -1.72173101e-02f, 3.00754681e-02f, 5.18196300e-02f, 2.72719711e-02f, 9.70949456e-02f, 4.62120213e-02f, 4.32536118e-02f, 9.13866609e-02f,
  -1.82020513e-03f, 9.33168679e-02f, 4.11174670e-02f, -5.40709086e-02f, 7.27706477e-02f, 1.32343965e-02f, 2.30168290e-02f, 2.77082971e-03f, -1.01190247e-01f, -4.77497047e-03f,
  5.77554815e-02f, -9.29473713e-02f, 2.12030143e-01f, -3.91233638e-02f, -8.53881836e-02f, 1.05008595e-01f, -5.04017286e-02f, 8.33346620e-02f, 7.87544921e-02f, 6.64740577e-02f,
  8.87117088e-02f, -4.93764244e-02f, 7.36527890e-02f, 9.79776680e-02f, 6.16069026e-02f, 1.97188362e-01f, 5.28756343e-02f, 2.40053132e-01f, 2.32002482e-01f, -1.81120390e-03f,
  -1.09501906e-01f, -2.43201219e-02f, 4.35032882e-02f, 1.48473144e-01f, 2.61077136e-02f, 6.28252849e-02f, 1.26508206e-01f, -2.64366698e-02f, 7.40899071e-02f, 2.89411545e-02f,
  2.27848440e-01f, 3.04319337e-02f, 1.46225840e-01f, 8.44664648e-02f, 7.72865023e-03f, 2.97777746e-02f, 7.44230896e-02f, 9.73144025e-02f, 1.03284493e-01f, 5.60085028e-02f,
  1.76478624e-02f, -5.11087663e-02f, 2.51837075e-02f, 3.60360295e-02f, 4.40672413e-02f, 1.12284012e-01f, 1.09386235e-01f, 9.64308083e-02f, 7.02809989e-02f, 1.67261064e-01f,
  -1.49614494e-02f, 1.44175673e-03f, 6.01853356e-02f, 7.79533759e-02f, 2.90203895e-02f, 1.48635447e-01f, 2.01935172e-01f, 5.39140441e-02f, 2.35370085e-01f, 1.81711331e-01f,
  -2.01666402e-03f, -9.28901285e-02f, -7.81792849e-02f, -6.85546398e-02f, -1.29361719e-01f, -5.57091609e-02f, -6.36380538e-02f, -1.42649174e-01f, -1.09047130e-01f, -4.48989868e-03f,
  1.78683102e-02f, -1.48405891e-03f, -2.96501629e-02f, -8.39637667e-02f, -8.35876092e-02f, -9.63275582e-02f, -7.19272569e-02f, -7.96498358e-02f, -7.29261190e-02f, -1.03728995e-01f,
  -9.12832469e-02f, -8.50202069e-02f, -4.09309268e-02f, -6.37942106e-02f, -9.20718238e-02f, -1.07665360e-01f, -2.38408595e-02f, -1.11769855e-01f, 2.98233870e-02f, -3.12225986e-02f,
  2.14865655e-01f, -4.33687419e-02f, 1.96637005e-01f, 5.31689562e-02f, 1.67846158e-01f, 1.63936004e-01f, 3.83804068e-02f, 4.98569310e-02f, 8.83827209e-02f, 9.33028162e-02f,
  7.74634629e-02f, 1.40226185e-01f, 1.35808200e-01f, 1.00020207e-01f, 1.74994588e-01f, 1.69680759e-01f, 3.51792797e-02f, 1.81929410e-01f, 1.53791025e-01f, 1.74710363e-01f,
  1.54626310e-01f, 1.63139999e-01f, 2.72162884e-01f, 1.97336495e-01f, 1.89579666e-01f, 2.57220834e-01f, 3.19250971e-01f, 2.46354416e-01f, 2.09412903e-01f, 3.51567566e-01f,
  4.29486305e-01f, 1.70360759e-01f, 1.13376930e-01f, 3.99450988e-01f, 2.46625006e-01f, 1.28244907e-01f, 2.43569940e-01f, 1.02517314e-01f, 1.41431659e-01f, 2.10265607e-01f,
  -2.02155299e-02f, -7.44042099e-02f, -1.12741068e-01f, -3.70870046e-02f, 8.21975395e-02f, 2.82933742e-01f, 2.04818159e-01f, 2.19518945e-01f, 1.20502472e-01f, 6.54657139e-03f,
  -1.06156636e-02f, 8.08047801e-02f, 1.19827218e-01f, 1.03643425e-01f, 1.37004048e-01f, 7.13757575e-02f, 6.18255846e-02f, 7.55588338e-02f, -1.20537259e-01f, 2.34068841e-01f,
  9.86358970e-02f, 1.11228451e-01f, -5.06522320e-02f, 2.75517330e-02f, 6.53864071e-02f, 5.78378700e-02f, 3.29465903e-02f, 5.52284867e-02f, 9.43530500e-02f, 1.18960209e-01f,
  6.18016198e-02f, -4.04663384e-02f, 6.65129200e-02f, 2.69647017e-02f, 1.86825365e-01f, 3.45000550e-02f, 7.12424442e-02f, 1.42873526e-01f, 4.44573499e-02f, 4.38571498e-02f,
  -1.39815928e-02f, 6.36339262e-02f, 1.86784547e-02f, -7.26590008e-02f, 9.07080527e-03f, -4.97742929e-02f, 4.76219654e-02f, -3.41324732e-02f, -5.53302020e-02f, 1.24772385e-01f,
  1.78762022e-02f, 8.89818091e-03f, 5.78859821e-03f, 1.69135049e-01f, 1.42538190e-01f, 1.74903885e-01f, 2.17763558e-01f, 6.68199137e-02f, 1.07656218e-01f, 5.03621772e-02f,
  8.65016505e-02f, 1.45322345e-02f, 1.59360364e-01f, 7.11625069e-02f, 8.47343057e-02f, 4.96169105e-02f, 3.00897099e-02f, 8.94618183e-02f, 3.23658735e-02f, 2.83236802e-02f,
  3.96117615e-03f, 7.28065372e-02f, 8.87072235e-02f, 8.85584764e-03f, 5.75608201e-02f, 6.17036298e-02f, -5.00708148e-02f, -4.24170494e-02f, -5.24192452e-02f, -2.08331402e-02f,
  4.71180305e-02f, -2.35631630e-01f, 7.32171312e-02f, -2.49230415e-02f, 2.25201026e-02f, 1.22943474e-02f, 7.67523199e-02f, 8.71144459e-02f, 1.11695543e-01f, 9.82668027e-02f,
  -2.78844200e-02f, 1.04681738e-01f, 9.51892659e-02f, 3.30207162e-02f, 1.52988479e-01f, 1.22533232e-01f, 1.09747738e-01f, 1.15401454e-01f, -2.11054226e-03f, -6.78228810e-02f,
  5.49756959e-02f, 1.20193258e-01f, 7.97594190e-02f, 5.52496985e-02f, 2.52687093e-02f, -4.21964154e-02f, 1.15943672e-02f, -6.21225089e-02f, -4.24160548e-02f, 1.28730491e-01f,
  8.81665125e-02f, -3.60215604e-02f, 1.51043355e-01f, -3.89450863e-02f, -1.52311549e-01f, -1.42860621e-01f, -9.58712399e-02f, 9.79158208e-02f, 4.07695398e-02f, -9.26782489e-02f,
  -1.52982503e-01f, -8.18600580e-02f, 9.48273912e-02f, 1.63787052e-01f, 3.05997133e-01f, 1.94946423e-01f, 2.59184629e-01f, 2.76909322e-01f, 1.96832776e-01f, -1.40183628e-01f,
  -1.48320794e-01f, -1.09344525e-02f, 1.99008092e-01f, 1.28082246e-01f, -1.24486648e-01f, 9.54830572e-02f, 1.20711759e-01f, -1.80131942e-02f, -1.24080338e-01f, 1.36469886e-01f,
  -1.31955758e-01f, -5.47034629e-02f, 2.41478920e-01f, 4.87319306e-02f, -8.25218391e-03f, 1.41536281e-01f, 3.23742777e-02f, 9.71256644e-02f, 5.16744740e-02f, 4.64083590e-02f,
  3.74282338e-02f, 6.21733554e-02f, 1.25633344e-01f, 5.60577549e-02f, -5.34406193e-02f, 6.68935478e-02f, 1.58036157e-01f, 1.55691147e-01f, 1.91593021e-01f, 8.37070048e-02f,
  -6.63328776e-03f, -1.12400979e-01f, -9.53409597e-02f, 8.06216747e-02f, 1.15780666e-01f, 1.07329294e-01f, 8.82374868e-03f, 6.43557683e-02f, 5.19954599e-02f, 3.63247246e-02f,
  1.35577455e-01f, -2.29888707e-02f, -3.22459601e-02f, -5.79114594e-02f, -8.02620947e-02f, -6.47757500e-02f, -5.74195152e-03f, -1.23233974e-01f, -3.12442631e-02f, -6.09054267e-02f,
  1.22492965e-02f, -2.76993606e-02f, -2.82298829e-02f, -2.46283691e-02f, -3.13933715e-02f, 1.56458244e-02f, -9.40884724e-02f, 3.57388780e-02f, 5.55609539e-02f, -2.89860480e-02f,
  -1.06395066e-01f, -9.77896992e-03f, -1.13151677e-01f, -5.01011983e-02f, -2.29982305e-02f, 3.83798918e-03f, -1.24929743e-02f, -3.92535068e-02f, 7.15706544e-03f, -6.35258257e-02f,
  1.21703140e-01f, 1.95670009e-01f, 6.37347177e-02f, 1.14701815e-01f, 7.02416301e-02f, 1.85476184e-01f, 8.16694200e-02f, 1.65467262e-01f, 7.11896643e-02f, 1.52899906e-01f,
  -4.81742509e-02f, 7.90961534e-02f, -3.06462087e-02f, 1.37405753e-01f, 1.07419297e-01f, 6.12980202e-02f, 3.69827300e-02f, 6.53071329e-02f, 1.82168812e-01f, 1.15014808e-02f,
  1.30126312e-01f, 2.28847545e-02f, 1.74516976e-01f, 1.46776408e-01f, 4.64062497e-04f, 9.41903293e-02f, 1.18080541e-01f, 8.26391429e-02f, 1.92673743e-01f, 2.64307141e-01f,
  -3.06631356e-01f, 2.49216720e-01f, -1.37333393e-01f, -6.57200441e-02f, 1.16276957e-01f, 5.37528023e-02f, 8.46152473e-03f, -5.14402911e-02f, 7.04862997e-02f, 1.35940671e-01f,
  3.40376168e-01f, 1.58695027e-01f, -5.31253591e-03f, 8.14580172e-02f, 7.36334652e-04f, 1.56451747e-01f, -1.46993631e-02f, -2.06199512e-01f, -2.48194844e-01f, 4.48902659e-02f,
  1.03031710e-01f, -5.48878387e-02f, -1.26294911e-01f, -1.24153711e-01f, 1.74232334e-01f, 1.00544758e-01f, 8.11259151e-02f, 1.81246549e-01f, 1.07151501e-01f, 1.23301938e-01f,
  1.56058058e-01f, 1.46448120e-01f, -2.72607729e-02f, 1.29440293e-01f, 1.36188507e-01f, 6.27267361e-02f, 1.46797329e-01f, 5.76663809e-03f, 6.76672757e-02f, 6.99868873e-02f,
  1.98400393e-01f, 8.86665434e-02f, 2.06863865e-01f, 3.76401246e-02f, 1.04006082e-01f, 1.26792058e-01f, 1.53760403e-01f, 3.14317606e-02f, -1.75471306e-02f, 2.53427982e-01f,
  2.84814954e-01f, 1.05466850e-01f, 1.03187852e-01f, 9.46787447e-02f, 5.93156507e-03f, 4.68576476e-02f, 1.73302606e-01f, 3.03613860e-02f, -2.85833087e-02f, 1.68108150e-01f,
  -3.72890104e-03f, 3.69396433e-02f, 3.18728499e-02f, -3.18939574e-02f, -5.65309376e-02f, -2.37663724e-02f, 4.71642986e-02f, 8.08043964e-03f, -2.87712347e-02f, -1.01146474e-01f,
  -1.15960598e-01f, -8.29450563e-02f, -3.05187721e-02f, -5.60608655e-02f, 2.44907662e-02f, 4.26080376e-02f, 9.93570313e-03f, -4.80147637e-03f, 2.05484442e-02f, -6.15106560e-02f,
  -2.86325105e-02f, -9.39157456e-02f, 1.59028675e-02f, -4.54955883e-02f, -9.65954512e-02f, -3.00397314e-02f, -4.40483391e-02f, -5.19307479e-02f, 1.39669573e-04f, -8.25783461e-02f,
  -4.16245461e-02f, -1.58672035e-01f, 1.06107391e-01f, 1.59516484e-01f, -1.67717831e-03f, 7.68210068e-02f, 2.24834923e-02f, 1.12498790e-01f, 8.11774284e-02f, 3.46627124e-02f,
  1.08638309e-01f, 5.97371981e-02f, 1.06358580e-01f, 1.01935402e-01f, 1.15582749e-01f, 8.20164159e-02f, 1.41598523e-01f, 2.12541856e-02f, 6.84339777e-02f, 1.55000791e-01f,
  1.33949414e-01f, 6.56248480e-02f, -5.47150485e-02f, -2.77335756e-02f, 9.54345167e-02f, -6.31546602e-02f, 5.05800582e-02f, 1.30158260e-01f, -1.07702471e-01f, -4.13022637e-02f,
  2.13888865e-02f, 3.83113235e-01f, -1.73119381e-02f, 4.21736538e-02f, 6.41456842e-02f, -1.00461096e-01f, 3.72209698e-02f, -1.19926408e-01f, -9.08804163e-02f, 1.10293612e-01f,
  2.71040238e-02f, -1.95243284e-01f, -1.01667590e-01f, -1.09527044e-01f, -1.95295542e-01f, 7.98700750e-02f, 1.02800407e-01f, -1.06350996e-01f, -3.03550363e-01f, -3.13888416e-02f,
  1.06808171e-01f, 1.29963368e-01f, -1.78509150e-02f, -2.74328142e-02f, 9.36464891e-02f, -1.27881125e-01f, 1.16661236e-01f, 2.04879507e-01f, -6.43109679e-02f, 3.49739730e-01f,
  -4.33457494e-02f, 1.47850126e-01f, -2.17772797e-01f, 6.96131587e-02f, 4.26575392e-02f, -1.14351310e-01f, -5.85059896e-02f, -4.61281464e-02f, -1.00992452e-02f, -2.14318000e-02f,
  1.53241027e-02f, 7.03675896e-02f, 1.09280482e-01f, 2.20300537e-02f, 4.36760578e-03f, -2.77761128e-02f, 3.62069085e-02f, 6.57165051e-02f, -1.26035333e-01f, -7.81350955e-02f,
  1.01779234e-02f, 1.18802994e-01f, -1.59032885e-02f, -6.97264969e-02f, -5.67216799e-02f, -2.23032515e-02f, 1.66609995e-02f, -3.23205367e-02f, -1.03039004e-01f, -4.59160097e-02f,
  -5.53866243e-03f, -1.09027028e-02f, -3.17635871e-02f, 1.70567557e-02f, -3.72042544e-02f, -8.34140703e-02f, 1.75956469e-02f, -3.46144885e-02f, -4.85087521e-02f, 6.45092353e-02f,
  -2.85598207e-02f, -5.73300086e-02f, -3.39350216e-02f, -2.91176029e-02f, -2.54881345e-02f, -2.69411802e-02f, -2.59186178e-02f, -5.54721616e-02f, -5.39670475e-02f, -1.54027992e-04f,
  -6.90770522e-02f, -3.94857209e-03f, 2.13607010e-02f, -1.00709929e-03f, 4.47938964e-02f, 2.26286035e-02f, -3.22185680e-02f, 4.71915267e-02f, -9.53845959e-03f, -4.05664556e-02f,
  -7.69366622e-02f, -7.95924813e-02f, -5.59736565e-02f, -4.17938419e-02f, -1.05172723e-04f, -6.30611703e-02f, 2.56231185e-02f, -6.74166009e-02f, 2.70039942e-02f, -5.15965894e-02f,
  -1.99500024e-02f, -7.13837519e-02f, -8.68773088e-02f, -3.04028578e-02f, -3.70482840e-02f, -2.64290217e-02f, -6.06875010e-02f, -1.08336993e-01f, -1.00219950e-01f, -1.03042098e-02f,
  7.75110349e-03f, -1.55700296e-01f, -1.31471634e-01f, -1.09148495e-01f, -4.50531021e-02f, -1.44284040e-01f, -1.16915479e-01f, -1.21959470e-01f, -1.60936296e-01f, -2.23657325e-01f,
  4.90605608e-02f, -9.37702879e-02f, -2.83350527e-01f, -6.25667647e-02f, -4.64082845e-02f, -3.10800433e-01f, -2.98676938e-01f, -8.48317519e-02f, -3.90883684e-02f, -3.26595567e-02f,
  1.52560592e-01f, 1.45743206e-01f, 3.19590122e-02f, -1.86275563e-03f, -2.40091801e-01f, -4.10215229e-01f, -3.53544146e-01f, -2.98244387e-01f, -2.28002910e-02f, 1.43755451e-01f,
  1.58090696e-01f, 1.08770051e-04f, 1.27009191e-02f, -5.98300397e-02f, -6.75250664e-02f, 4.63510379e-02f, -1.10182554e-01f, 4.26438823e-02f, -9.11069885e-02f, -1.54658854e-01f,
  6.81725517e-02f, -3.89447175e-02f, -6.23258799e-02f, 1.06537975e-01f, 3.81777547e-02f, -1.01007760e-01f, -1.02277428e-01f, 3.05690547e-03f, 1.00701731e-02f, -8.36204663e-02f,
  6.95810169e-02f, 1.05300210e-02f, -3.30138095e-02f, 4.01784889e-02f, -8.71436521e-02f, -3.27852964e-02f, -2.66237780e-02f, -1.06254645e-01f, -1.51118711e-01f, -6.53177723e-02f,
  -2.06411257e-03f, -5.31834923e-02f, -1.23919271e-01f, -1.17986284e-01f, -1.22979999e-01f, 3.14026028e-02f, -8.40406865e-02f, 2.82485373e-02f, -3.00617274e-02f, -1.14624090e-01f,
  1.45083014e-02f, 7.60250539e-02f, -2.92785838e-02f, 4.02721949e-02f, 7.78771341e-02f, 3.46740782e-02f, 1.59659963e-02f, 1.72590259e-02f, 1.02293976e-02f, 2.13838197e-04f,
  2.27397699e-02f, -1.38299903e-02f, -6.74620718e-02f, 5.95497247e-03f, 3.32414880e-02f, 5.24385162e-02f, 8.89410302e-02f, 4.00305614e-02f, 4.24862839e-02f, 8.99980124e-03f,
  1.12802505e-01f, 3.94920036e-02f, 3.29735987e-02f, 4.63857986e-02f, 7.87452012e-02f, -3.93614247e-02f, 7.75001347e-02f, 1.21670656e-01f, 7.05376342e-02f, 3.97024155e-02f,
  1.72544703e-01f, -6.15435205e-02f, 3.01159713e-02f, -1.05981924e-01f, -1.57616213e-02f, -3.21635716e-02f, -4.87840250e-02f, 1.05337575e-02f, 3.71687859e-02f, -4.27109711e-02f,
  -4.01442647e-02f, -6.22452097e-03f, -8.98879319e-02f, 4.92204875e-02f, -4.95074205e-02f, -2.32895445e-02f, -1.09376401e-01f, -5.01157418e-02f, 4.15850691e-02f, -6.38921484e-02f,
  -2.64210571e-02f, -8.59960690e-02f, 4.02846672e-02f, -1.12666205e-01f, -2.68340739e-03f, -1.62105355e-02f, -3.27573046e-02f, -1.68360602e-02f, -8.37639868e-02f, -1.59398988e-01f,
  1.91476390e-01f, 1.35506406e-01f, -4.48633909e-01f, 1.00126468e-01f, 4.20438417e-04f, 1.94759294e-01f, 4.42724407e-01f, 3.19497287e-01f, 1.47378728e-01f, 4.70774174e-02f,
  8.82998407e-02f, -4.64450344e-02f, -1.19949877e-01f, -9.07637551e-02f, 9.39824656e-02f, 1.31818682e-01f, -1.63792272e-03f, -1.91934764e-01f, 3.34443413e-02f, 6.61402196e-02f,
  1.25416964e-01f, -8.36973041e-02f, 1.85737871e-02f, -6.16614819e-02f, -6.97974041e-02f, 4.10932600e-02f, -1.70370296e-01f, -1.85816377e-01f, -1.34968638e-01f, -3.50449622e-01f,
  -3.58292967e-01f, -1.25630111e-01f, 1.22209229e-01f, -3.91340256e-02f, -1.52334481e-01f, 5.95967993e-02f, -1.59674436e-02f, -1.55388281e-01f, -2.30504908e-02f, -3.59669216e-02f,
  -5.83017543e-02f, -4.81925309e-02f, -3.38281617e-02f, 4.93518729e-03f, 4.00163196e-02f, 1.56537220e-02f, -9.40906443e-03f, -5.62600568e-02f, -1.30997092e-01f, -1.32857502e-01f,
  4.13954407e-02f, -5.89888841e-02f, -9.99825671e-02f, 1.09836660e-01f, 1.34767722e-02f, -5.06163351e-02f, -2.12411042e-02f, -4.16619256e-02f, -9.92572829e-02f, 6.94144219e-02f,
  1.07551843e-01f, -1.86964702e-02f, -1.45524532e-01f, 3.25401612e-02f, 8.66687074e-02f, -2.33116131e-02f, -6.38898164e-02f, 4.55537662e-02f, 2.86845658e-02f, 4.12834845e-02f,
  -7.38260373e-02f, 4.51610088e-02f, -2.92304642e-02f, 3.07772029e-02f, 2.45696120e-02f, -7.77105615e-02f, 1.58485249e-02f, 4.16281261e-03f, 3.29182595e-02f, 3.28584351e-02f,
  6.89121801e-03f, 4.60206578e-03f, -9.85706076e-02f, 1.16248671e-02f, 3.65987159e-02f, -3.34220156e-02f, 4.01550159e-02f, 2.26231739e-02f, 1.72937252e-02f, 3.37826610e-02f,
  1.73716426e-01f, -6.70710299e-03f, -2.16132775e-02f, 4.50217836e-02f, -5.36401160e-02f, -7.51306564e-02f, -8.75097513e-02f, 1.75323449e-02f, -3.05227302e-02f, 3.82779650e-02f,
  3.04303337e-02f, 5.69860041e-02f, 1.91600360e-02f, -2.33152620e-02f, 1.22054577e-01f, 7.60488957e-02f, 6.11467808e-02f, -2.07713190e-02f, -3.53215411e-02f, -3.48934419e-02f,
  9.98084694e-02f, 1.29022345e-01f, 1.75329626e-01f, 1.05254650e-01f, 6.42360076e-02f, 5.85118011e-02f, 5.61630540e-02f, 6.41168654e-02f, 1.80579618e-01f, 4.58683610e-01f,
  -2.47216135e-01f, 5.54491766e-02f, 3.99660796e-01f, -3.58845860e-01f, -1.54025620e-02f, 2.37461984e-01f, 3.07378560e-01f, 2.80696154e-02f, -1.99666932e-01f, -6.78809211e-02f,
  -1.28614709e-01f, -1.40947551e-01f, -6.58313408e-02f, -9.36841071e-02f, 1.29738227e-01f, 2.40814850e-01f, 1.36465132e-01f, 2.10746795e-01f, 6.35832399e-02f, 1.06045514e-01f,
  -1.68322861e-01f, -1.24199219e-01f, -1.30153492e-01f, 3.07870703e-03f, -8.78368840e-02f, -1.55763375e-02f, 7.47042745e-02f, -3.62942331e-02f, 1.66017190e-01f, 7.19009712e-02f,
  2.29384556e-01f, 1.10622108e-01f, 1.26743495e-01f, -7.59977615e-03f, 6.04053102e-02f, 4.95120697e-02f, 3.97818983e-02f, 4.28272635e-02f, -5.99131659e-02f, 4.93186526e-02f,
  8.60014651e-03f, 6.99791266e-03f, -9.82242674e-02f, 2.35018432e-02f, 1.65208187e-02f, 7.60201644e-03f, -3.04468460e-02f, 1.11108802e-01f, 9.63359997e-02f, 8.81664902e-02f,
  -1.17969505e-01f, 8.39855447e-02f, 1.04575440e-01f, 3.73111553e-02f, 1.06061503e-01f, -1.80537403e-02f, 1.12732284e-01f, 3.46973687e-02f, 1.86620891e-01f, -1.07126972e-02f,
  -1.35229185e-01f, 6.40400201e-02f, 2.66920449e-03f, 7.64091383e-04f, -5.47738001e-02f, -4.13795263e-02f, 3.07620317e-02f, 2.02026311e-02f, 1.76323429e-02f, -4.07353081e-02f,
  -7.50715882e-02f, 2.73530800e-02f, 2.50021908e-02f, 7.46944845e-02f, -2.41851918e-02f, -8.87932628e-03f, 1.05841234e-01f, 6.08440489e-02f, -6.82564406e-03f, 2.93138847e-02f,
  -3.44770625e-02f, 8.74981284e-02f, 3.37067172e-02f, 5.51274866e-02f, 6.84578940e-02f, 4.83925901e-02f, -4.54104785e-03f, -5.82697205e-02f, -1.34791389e-01f, 7.79462093e-03f,
  -2.01542199e-01f, 1.66100696e-01f, 5.79060689e-02f, 6.60817623e-02f, 1.24244727e-01f, 4.36503328e-02f, 1.53812259e-01f, 3.83902788e-02f, 6.52753785e-02f, 1.40919343e-01f,
  1.25705048e-01f, 6.12492599e-02f, 3.86696905e-02f, -1.01174079e-02f, 4.38762903e-02f, 3.90896462e-02f, 1.30963162e-01f, 8.70897919e-02f, 1.63980201e-01f, 6.01864606e-02f,
  5.76572940e-02f, 1.27345100e-01f, 1.07607163e-01f, 1.73266694e-01f, 1.14900537e-01f, 7.07062408e-02f, 1.64739832e-01f, 9.26594734e-02f, 2.06684813e-01f, 4.18846086e-02f,
  1.72917143e-01f, 9.85741094e-02f, 3.22566517e-02f, 5.83456084e-02f, -2.56927282e-01f, -2.38344878e-01f, -2.27899194e-01f, -1.14874393e-01f, -4.57623638e-02f, 1.43079702e-02f,
  -1.67910174e-01f, -1.56535611e-01f, -2.44593006e-02f, -1.13755934e-01f, -1.88796759e-01f, -1.37017384e-01f, 3.34576145e-02f, 1.05484806e-01f, -1.98700652e-01f, -2.27718696e-01f,
  -8.64025131e-02f, 1.30665004e-01f, 1.80217177e-01f, -4.67288494e-02f, 1.86790407e-01f, -9.14008394e-02f, 2.37310037e-01f, 2.76815087e-01f, -6.39391616e-02f, 2.81296670e-01f,
  6.26762733e-02f, 1.33634433e-01f, -1.39886141e-01f, -1.11331530e-01f, -3.92288417e-02f, -4.90330160e-03f, -1.53339759e-01f, 1.08715698e-01f, -6.51031733e-02f, 3.58416373e-03f,
  -4.19932082e-02f, -8.30420703e-02f, 2.10990245e-03f, 2.99467036e-04f, -3.22635807e-02f, -2.35703345e-02f, 8.78880844e-02f, 8.37944448e-02f, -3.01598664e-02f, 9.68208630e-03f,
  -1.03319459e-01f, -1.44085273e-01f, -7.70989284e-02f, -2.19059005e-01f, 9.59559064e-03f, -1.91891715e-01f, -3.76105309e-02f, -4.46709841e-02f, -8.73885453e-02f, 9.02131796e-02f,
  -4.38109925e-03f, 2.63236891e-02f, 1.60121527e-02f, 1.45708211e-02f, 7.23147839e-02f, 4.62105311e-02f, 2.12660246e-02f, -1.01413745e-04f, -2.89649460e-02f, 2.80891173e-02f,
  -1.10319993e-02f, -4.79944609e-02f, 2.73146443e-02f, 1.77609380e-02f, -6.24920279e-02f, 2.40313332e-03f, -5.85099831e-02f, 2.88501456e-02f, 5.34847416e-02f, 1.30688637e-01f,
  1.70481130e-02f, 1.07955143e-01f, 7.24186972e-02f, 6.90594316e-02f, 6.94615184e-04f, 6.15929104e-02f, 1.15170861e-02f, 1.35558117e-02f, -3.64537202e-02f, 5.35801686e-02f,
  -4.81570512e-02f, -9.68458429e-02f, -6.99427947e-02f, -4.57768254e-02f, -2.86646355e-02f, -2.40533315e-02f, -1.39736002e-02f, -4.66564931e-02f, -3.53696421e-02f, -6.82120845e-02f,
  -1.02943160e-01f, -3.17870714e-02f, -5.85795827e-02f, -5.22927977e-02f, -1.37168795e-01f, -1.22862607e-01f, -4.80828024e-02f, -9.02891830e-02f, -8.17442089e-02f, -9.11760777e-02f,
  -6.84758127e-02f, -1.73009694e-01f, -2.72495270e-01f, -2.04546854e-01f, -1.10354766e-01f, -2.47424185e-01f, -9.80766863e-02f, -1.90565571e-01f, -2.42165267e-01f, -2.34261483e-01f,
  -1.77370794e-02f, -1.29136473e-01f, 9.16188061e-02f, 1.61466748e-03f, -1.29880250e-01f, -1.29055893e-02f, -9.15459618e-02f, 9.69786942e-02f, -8.38813409e-02f, -1.10806957e-01f,
  -1.93339512e-01f, -4.06172080e-03f, 1.39870226e-01f, 2.08651617e-01f, 3.49522591e-01f, 1.31816179e-01f, 2.91671395e-01f, 3.67924720e-01f, 4.05903846e-01f, 2.35404193e-01f,
  1.10872433e-01f, 4.31386493e-02f, 7.99789727e-02f, 2.39601150e-01f, 1.51680976e-01f, 1.15404546e-01f, -1.71936397e-02f, -1.76339261e-02f, -2.24171439e-03f, 1.74088493e-01f,
  4.47748154e-02f, 1.14167772e-01f, 1.37423515e-01f, 5.72352149e-02f, 6.52789399e-02f, 1.31625935e-01f, 8.47773403e-02f, 1.56062409e-01f, 4.14789729e-02f, 1.61718160e-01f,
  9.70909446e-02f, 3.88377719e-02f, 1.24125324e-01f, 7.48372525e-02f, 1.48362786e-01f, 1.67099550e-01f, 1.73416182e-01f, 2.56987870e-01f, 1.48623124e-01f, 7.45919272e-02f,
  8.62712711e-02f, 8.35231692e-03f, 1.41792700e-01f, 6.59149289e-02f, 1.82525873e-01f, 1.99069157e-01f, 1.44790292e-01f, 2.35760927e-01f, 1.23306863e-01f, 1.02696136e-01f,
  2.27847951e-03f, -3.86857055e-02f, -1.85479149e-01f, -1.32534131e-01f, -8.67083892e-02f, -1.41910225e-01f, -6.43534511e-02f, -8.81195366e-02f, -5.56261316e-02f, -8.01567957e-02f,
  -9.11125615e-02f, -1.25614107e-01f, -7.72525892e-02f, -1.38838843e-01f, -9.37568545e-02f, -6.09096177e-02f, -1.07184630e-02f, -1.35479152e-01f, -3.29576358e-02f, -1.13549627e-01f,
  -1.70748100e-01f, -4.83259410e-02f, -2.23056093e-01f, -1.56294450e-01f, -1.20134272e-01f, -7.18819797e-02f, -4.35750596e-02f, -1.12721369e-01f, -1.68417603e-01f, -1.85188696e-01f,
  -2.09602430e-01f, 1.16226659e-03f, 7.79381022e-02f, 1.86422452e-01f, 1.02089077e-01f, 1.20088011e-02f, -1.62330810e-02f, 8.99964496e-02f, 1.48492068e-01f, 6.04268201e-02f,
  5.48481643e-02f, 1.75017178e-01f, 9.66613144e-02f, 8.41871426e-02f, 6.80542439e-02f, -7.17822649e-03f, 7.87561610e-02f, 1.61789894e-01f, 9.50108618e-02f, 1.30086824e-01f,
  6.05841503e-02f, 3.22455429e-02f, 5.99485077e-02f, 7.78084323e-02f, 2.96592172e-02f, 1.61989957e-01f, 9.85608697e-02f, -5.88485925e-03f, 1.28388416e-03f, -2.38773115e-02f,
  -4.79776055e-01f, 1.53313071e-01f, -1.47749022e-01f, -1.15583591e-01f, 1.09647244e-01f, 5.24096526e-02f, 8.23207647e-02f, -1.29478604e-01f, 8.69471673e-03f, 1.32276461e-01f,
  3.30939651e-01f, 1.26547217e-01f, 4.68436368e-02f, -6.14869930e-02f, -2.55458534e-01f, -7.66770821e-03f, -2.48352319e-01f, -3.41868371e-01f, -2.53493607e-01f, 5.00277653e-02f,
  3.36558670e-02f, -6.12354837e-02f, -2.86286592e-01f, -1.43442005e-01f, 1.08614661e-01f, 9.86047462e-03f, -5.84054701e-02f, -3.50750573e-02f, 1.17312156e-01f, -4.65638712e-02f,
  1.80612668e-01f, 1.11496979e-02f, -6.22398639e-03f, -1.34286070e-02f, 1.63512394e-01f, -1.44618079e-01f, -3.66484076e-02f, -5.72991744e-02f, 2.01472789e-02f, 1.35136221e-03f,
  7.50069693e-02f, -2.71808170e-02f, -7.31382743e-02f, -1.66928116e-02f, -3.96987721e-02f, -1.67733561e-02f, -4.73981388e-02f, -1.93417504e-01f, -1.36937574e-01f, 9.36004370e-02f,
  9.44225639e-02f, 1.09992877e-01f, 2.98588313e-02f, 3.55007611e-02f, -7.17568621e-02f, -8.85347277e-02f, 7.02921152e-02f, 4.57794173e-04f, -6.06191419e-02f, 7.21527170e-03f,
  -7.16079846e-02f, 3.78105417e-02f, 1.98891126e-02f, 1.76596711e-03f, 1.93859003e-02f, 1.06867202e-01f, -3.43349129e-02f, 4.52455543e-02f, -3.94537784e-02f, -1.05056574e-03f,
  -1.64944958e-02f, -7.96122570e-03f, -8.08773097e-03f, -2.88245715e-02f, 5.37555153e-03f, -3.18340734e-02f, -1.18785061e-01f, 1.18747456e-02f, -4.35939357e-02f, 9.03973076e-03f,
  1.44509180e-02f, 4.42687906e-02f, -5.27840517e-02f, -1.16274610e-01f, -1.93582978e-02f, -6.37961775e-02f, -1.66246649e-02f, 4.68079047e-03f, 8.32780171e-03f, -1.11972482e-03f,
  4.59774248e-02f, -1.18274419e-02f, 4.02193330e-03f, -1.47120878e-01f, 2.96533927e-02f, -4.06767093e-02f, 7.18546510e-02f, -1.25673950e-01f, 1.00537380e-02f, 6.69377530e-03f,
  1.82027407e-02f, -3.57307643e-02f, 7.74394721e-02f, -2.60737538e-02f, -7.49521554e-02f, -4.08106707e-02f, -4.69391197e-02f, 1.27549078e-02f, -3.43552381e-02f, 9.34286267e-02f,
  -8.30454826e-02f, -9.86062661e-02f, -7.87588283e-02f, 1.41312871e-02f, 8.43889080e-03f, -3.85405980e-02f, -1.47573296e-02f, -2.26165671e-02f, -6.97176903e-02f, -9.91734639e-02f,
  -8.45252275e-02f, -1.99370310e-01f, -2.07376927e-01f, -2.33977079e-01f, -1.36379585e-01f, -1.76083073e-01f, -2.22234458e-01f, -1.24677815e-01f, -6.14226982e-03f, -1.64317116e-01f,
  7.57811740e-02f, 2.31668264e-01f, 2.10451931e-02f, 7.34155327e-02f, -1.17448412e-01f, -3.62791836e-01f, -3.26587766e-01f, -1.16567820e-01f, 1.50495216e-01f, 5.28849103e-02f,
  9.19326544e-02f, 1.22634038e-01f, 6.74882457e-02f, 4.16190876e-03f, -1.42639488e-01f, 7.27780536e-02f, -1.67902350e-01f, -5.43660298e-02f, 8.82186741e-02f, -1.44116372e-01f,
  -2.71205485e-01f, -1.76703572e-01f, 1.08061535e-02f, 1.28763929e-01f, -3.58377658e-02f, 6.50572777e-02f, -3.82071338e-03f, -3.32409404e-02f, -4.65787807e-03f, -1.55277625e-02f,
  3.16934586e-02f, 6.59270817e-03f, 1.51778189e-02f, 6.42566150e-03f, -3.38268764e-02f, -3.55094932e-02f, -5.50522842e-03f, 1.74155254e-02f, -5.76848537e-02f, -3.33777294e-02f,
  5.46715781e-02f, 1.24751449e-01f, -4.16161641e-02f, -8.26693326e-02f, -9.03563108e-03f, 2.37570051e-02f, 1.94402579e-02f, -6.02936186e-02f, 6.76310807e-02f, 1.03629744e-02f,
  -5.47697134e-02f, 5.45787206e-03f, 9.90602523e-02f, 5.98479509e-02f, 1.56978771e-01f, 1.19405642e-01f, -1.57066267e-02f, 2.47000512e-02f, 6.98695257e-02f, 3.95377092e-02f,
  3.22497333e-03f, -8.33596811e-02f, 8.70907456e-02f, -3.31937633e-02f, -6.60977280e-03f, 6.17158115e-02f, -1.17868129e-02f, -2.88194744e-03f, 7.78951645e-02f, 9.87873375e-02f,
  7.74760097e-02f, 1.59461591e-02f, -2.22760364e-02f, -8.32676701e-03f, -4.18814383e-02f, -1.27463639e-01f, 5.50108626e-02f, 1.47558982e-02f, -2.83549167e-02f, -2.35533603e-02f,
  9.87407565e-02f, 6.03861064e-02f, -6.77048713e-02f, 7.40847588e-02f, -3.79136065e-03f, 3.09245028e-02f, -6.14437573e-02f, -5.82583540e-04f, -1.15681924e-02f, -1.05374880e-01f,
  -7.23531768e-02f, -1.59850214e-02f, -5.42223826e-02f, 8.97083059e-03f, -4.36664298e-02f, -2.42080763e-02f, 4.83479211e-03f, 1.85332391e-02f, 7.09602684e-02f, 2.91991476e-02f,
  2.13210005e-02f, 1.11601735e-02f, 7.14935586e-02f, -3.72769386e-02f, -5.21185361e-02f, 1.31832898e-01f, 4.13369350e-02f, 6.42273501e-02f, -4.12442572e-02f, -8.87475386e-02f,
  4.21387345e-01f, 4.56182241e-01f, -2.15070382e-01f, -1.67175643e-02f, 9.49632004e-02f, -4.74607572e-02f, 1.52017340e-01f, 2.25568879e-02f, 4.77438606e-02f, 1.54404223e-01f,
  1.18448332e-01f, -4.49127741e-02f, -1.80548131e-01f, -1.34167627e-01f, -8.28639194e-02f, 1.10022224e-01f, 6.98270798e-02f, -3.23994398e-01f, -3.02443594e-01f, -3.22662294e-02f,
  1.75966576e-01f, 1.38653114e-01f, 4.51150574e-02f, -9.34464484e-02f, 2.05959961e-01f, 3.60244289e-02f, 7.06373155e-02f, 7.11957663e-02f, 7.32390061e-02f, 2.06089973e-01f,
  -8.10397193e-02f, 1.89882159e-01f, -1.73115775e-01f, 1.72867309e-02f, 5.79892024e-02f, -1.09069645e-02f, 1.59736481e-02f, 3.04516368e-02f, 9.68977958e-02f, 1.67854386e-03f,
  6.48515746e-02f, 1.26775196e-02f, 5.52353524e-02f, -5.32981940e-02f, -1.42644243e-02f, -2.57357880e-02f, -3.60499807e-02f, -2.99927350e-02f, -7.85010234e-02f, 2.39865971e-03f,
  1.28460526e-02f, 9.86160040e-02f, -1.36030823e-01f, 3.33367003e-04f, -1.61509544e-01f, -2.38002881e-01f, -2.03147233e-02f, -6.27814680e-02f, -1.06559128e-01f, 1.41425744e-01f,
  -7.66954198e-02f, 3.91146690e-02f, 1.71873495e-02f, -5.67173846e-02f, 2.96093095e-02f, 1.16145350e-02f, 3.35098729e-02f, 2.85803732e-02f, -6.12263866e-02f, -1.11494130e-02f,
  -1.92467533e-02f, 8.95747729e-03f, -7.77610764e-02f, 4.42850366e-02f, -9.29438770e-02f, -2.83127669e-02f, -2.52732448e-02f, 5.64906523e-02f, -1.02966480e-01f, -3.65826115e-02f,
  -2.88621094e-02f, -3.01275551e-02f, 2.71824673e-02f, -6.60653412e-02f, -1.74106341e-02f, -1.46738496e-02f, -4.46442105e-02f, 2.01393925e-02f, -4.30598408e-02f, 6.40932620e-02f,
  3.74379717e-02f, -2.14076370e-01f, 6.39069676e-02f, 9.14301872e-02f, 1.58107486e-02f, 9.37341377e-02f, 2.15793848e-02f, 8.98430198e-02f, -4.30592448e-02f, 5.15256487e-02f,
  -6.43452257e-02f, -9.96334478e-03f, 2.12889034e-02f, -1.42379082e-03f, 3.12423427e-02f, -7.43965432e-03f, 1.54277757e-01f, -4.34813090e-02f, -5.46974987e-02f, 1.49661317e-01f,
  8.37826729e-03f, 4.56443056e-02f, 2.63974760e-02f, -8.32962468e-02f, -2.58987937e-02f, -1.43842343e-02f, 5.13988510e-02f, -4.43283543e-02f, -7.24422634e-02f, 1.99915677e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.52741253e-01f, -3.61298285e-02f, 8.82345587e-02f, 2.15178803e-01f, -1.50388747e-01f, -1.24584235e-01f, -1.38382271e-01f, -7.84850642e-02f, 2.49201998e-01f, 1.49341375e-01f,
  6.05340786e-02f, 1.89368278e-01f, 2.34938994e-01f, 1.17845379e-01f, 4.56630588e-02f, -1.42361999e-01f, -8.58574063e-02f, 4.74275686e-02f, 1.96202323e-01f, -4.83513325e-02f,
  -5.13221584e-02f, -1.24350131e-01f, -7.69720748e-02f, 2.48515494e-02f, -1.81339785e-01f, 9.79680791e-02f, -6.49314225e-02f, -3.46659958e-01f, -3.21312517e-01f, -9.97707173e-02f,
  2.86966145e-01f, 2.00613201e-01f, 2.09670573e-01f, 1.95246875e-01f, 1.19457081e-01f, 6.59981295e-02f, 1.92290246e-01f, 4.38025175e-03f, -4.57486324e-02f, -5.38191125e-02f,
  7.35818446e-02f, -4.85598706e-02f, -4.75426801e-02f, -2.77616046e-02f, -8.46774131e-02f, -5.66358753e-02f, 3.50425467e-02f, 7.92541429e-02f, -6.29723221e-02f, 1.50644392e-01f,
  -1.71909109e-02f, 3.43904132e-04f, 8.44810456e-02f, -2.61992458e-02f, 1.19139917e-01f, 3.12265065e-02f, 8.62167031e-02f, 8.77010524e-02f, 1.37618974e-01f, 1.24151520e-01f,
  -3.33268158e-02f, 5.88568747e-02f, 1.60437539e-01f, 2.48974472e-01f, 9.37234908e-02f, 6.55224919e-02f, -4.67060879e-02f, -2.06322204e-02f, 1.10581152e-01f, -1.49089754e-01f,
  -1.02592893e-01f, 1.31802216e-01f, 8.96170661e-02f, 2.86868419e-02f, 1.83653399e-01f, -4.05840799e-02f, -1.11176968e-01f, -3.43254283e-02f, -1.55378049e-02f, -2.61251442e-02f,
  5.74225709e-02f, -8.61740634e-02f, -2.05884185e-02f, -1.16339222e-01f, -5.15156202e-02f, 7.47944415e-02f, 2.36804709e-02f, -6.54840991e-02f, -7.10844547e-02f, -1.18797302e-01f,
  1.20443627e-01f, 2.19335124e-01f, 2.56072372e-01f, -3.58093344e-02f, -4.99528833e-02f, -2.18502153e-02f, 7.47437105e-02f, -6.34957850e-02f, -6.95162937e-02f, -1.94312856e-02f,
  5.98138608e-02f, 1.24806993e-01f, -7.76199624e-02f, -1.20228797e-01f, 1.24869402e-02f, 5.19584864e-02f, 4.54988815e-02f, 2.51090415e-02f, 1.83738451e-02f, 3.90849961e-03f,
  5.63150365e-03f, 8.81913230e-02f, 1.25585571e-01f, 8.37157518e-02f, 9.32247192e-02f, 1.85976341e-01f, -5.52320555e-02f, 8.25110078e-02f, -4.83063497e-02f, 6.51281625e-02f,
  1.12555645e-01f, 1.69481203e-01f, -2.92256981e-01f, 3.26247752e-01f, 1.86438877e-02f, -4.01676416e-01f, -4.70354557e-01f, -1.35665745e-01f, 4.07862961e-01f, 2.24112228e-01f,
  5.67665743e-03f, -2.11409703e-02f, 1.26731977e-01f, -2.64894158e-01f, -5.04917562e-01f, -3.04793656e-01f, -2.51719058e-01f, -4.60288107e-01f, -6.59303844e-01f, -4.54457462e-01f,
  -1.53628066e-01f, -4.12697084e-02f, -7.25347996e-02f, -1.08331256e-01f, 4.15626854e-01f, 1.79939762e-01f, 2.38562465e-01f, 8.25919360e-02f, -2.08736226e-01f, 1.82900369e-01f,
  1.08916730e-01f, 7.42700463e-03f, -2.34503359e-01f, -1.34786502e-01f, 2.91655540e-01f, -2.51585096e-02f, -2.52147853e-01f, 1.55549096e-02f, 1.51164364e-02f, -4.92840074e-02f,
  2.87180766e-02f, -7.93714821e-02f, 2.42939331e-02f, 1.97827723e-02f, -1.30120084e-01f, -1.68523043e-01f, -1.01405876e-02f, -1.69236928e-01f, -6.06422313e-02f, -5.09434678e-02f,
  -2.01318383e-01f, -2.70121634e-01f, -2.14549273e-01f, -4.94352728e-02f, -7.37815350e-02f, -1.63301855e-01f, 8.06809738e-02f, 3.26245688e-02f, -1.83247760e-01f, 4.58475113e-01f,
  3.23713981e-02f, 5.74510545e-03f, -6.04958786e-03f, 1.08404756e-01f, -4.19094898e-02f, 6.98092654e-02f, 5.06158099e-02f, 1.41623178e-02f, -9.93523076e-02f, 4.43659723e-03f,
  5.73001765e-02f, -2.80056782e-02f, -8.70547593e-02f, 8.71661529e-02f, -4.02871929e-02f, -5.18021919e-02f, -9.00314972e-02f, -7.70067498e-02f, -1.34280547e-01f, -4.21115011e-02f,
  -1.38489664e-01f, -4.87131253e-02f, 1.41185507e-01f, 3.92000601e-02f, -3.94258276e-02f, -3.54718901e-02f, 2.34229420e-03f, -8.64816085e-02f, -7.02407286e-02f, -1.41871423e-01f,
  5.58614850e-01f, -2.56392688e-01f, 1.92201167e-01f, -8.45204592e-02f, -2.06574192e-03f, 7.61755332e-02f, 2.34780267e-01f, -2.13808636e-03f, 7.15351850e-02f, -1.15115024e-01f,
  -2.49446556e-01f, 3.83856371e-02f, 1.55020475e-01f, -2.20551081e-02f, -1.32156596e-01f, 1.01868827e-02f, -5.04498894e-04f, -3.53015773e-02f, -2.64243245e-01f, 6.84897006e-02f,
  1.60876900e-01f, -2.02515051e-01f, 7.62698660e-03f, -1.76820648e-03f, 1.36801034e-01f, -2.09690835e-02f, 1.13860339e-01f, 8.99935588e-02f, -1.67486787e-01f, 3.52552921e-01f,
  -8.72053981e-01f, -3.30623150e-01f, 3.66870105e-01f, -6.29421920e-02f, 2.62078285e-01f, 2.10472912e-01f, 1.77908570e-01f, -1.01869814e-02f, -1.09579548e-01f, -4.13123472e-03f,
  -7.13132992e-02f, -1.70303881e-02f, -1.10762700e-01f, 1.22933341e-02f, 3.27800214e-02f, 2.04010054e-01f, 1.63614333e-01f, 9.85404700e-02f, 1.48376867e-01f, 4.99417707e-02f,
  9.33002774e-03f, -1.73161253e-01f, -3.26110750e-01f, -5.50960973e-02f, 3.29392254e-02f, 3.84182180e-03f, 2.93489713e-02f, 3.05114649e-02f, -1.91187463e-03f, 1.61837637e-02f,
  6.41351581e-01f, -9.38405767e-02f, -4.69971821e-02f, -2.07267612e-01f, 5.41252550e-03f, -1.18423849e-01f, 5.93353845e-02f, -1.22774825e-01f, -2.39624418e-02f, 6.93258867e-02f,
  -7.21171424e-02f, -2.35162806e-02f, 1.21911587e-02f, -8.19984302e-02f, 8.75780955e-02f, -9.27352682e-02f, -1.46998182e-01f, -2.02846490e-02f, 2.61681452e-02f, 7.54464716e-02f,
  -9.48090181e-02f, 7.24821612e-02f, 1.80942222e-01f, 4.43664417e-02f, 9.24685597e-03f, -8.71906348e-04f, 8.62265602e-02f, -1.30988464e-01f, -6.92307353e-02f, -1.65554658e-02f,
  1.59810662e-01f, 1.01009525e-01f, 5.40411398e-02f, -1.30877513e-02f, 2.18929108e-02f, 4.74410765e-02f, 1.53772226e-02f, 1.21387966e-01f, -2.87158936e-02f, -5.61968191e-03f,
  7.08101764e-02f, 5.55297546e-03f, 2.06769966e-02f, 7.21369982e-02f, -4.54853736e-02f, -1.03464350e-01f, -1.10138483e-01f, 1.05484292e-01f, -4.91848364e-02f, -8.17763805e-02f,
  -9.13689286e-02f, 1.60129711e-01f, -1.91820282e-02f, 4.22908776e-02f, -7.10009933e-02f, 9.17314924e-03f, 9.07686502e-02f, -5.69150634e-02f, 3.32452990e-02f, 1.13970144e-02f,
  3.88315082e-01f, -5.31240366e-02f, 3.90046686e-02f, -1.48615763e-01f, -1.07036307e-01f, -1.26329616e-01f, -3.83681655e-02f, 3.28341648e-02f, 8.82722512e-02f, 2.45894909e-01f,
  1.14401661e-01f, 1.17193358e-02f, -7.68908635e-02f, 8.72595757e-02f, 8.76816064e-02f, 1.29401516e-02f, -1.53485239e-01f, -4.97249812e-02f, 7.08657280e-02f, 3.18093508e-01f,
  1.27593596e-02f, 3.38382572e-02f, 2.12556466e-01f, 1.16752081e-01f, 1.20559810e-02f, 1.31618828e-01f, 2.71018714e-01f, 1.69794500e-01f, 2.37867177e-01f, 1.36800930e-01f,
  -4.11238045e-01f, -2.70391941e-01f, -1.70737710e-02f, -1.82417175e-03f, 8.42005238e-02f, 2.17378274e-01f, -1.22108087e-01f, 1.96911484e-01f, 1.22345999e-01f, -3.48783284e-01f,
  1.09230421e-01f, 1.20072544e-01f, -8.04691911e-02f, -1.11027199e-04f, -1.22588530e-01f, -3.55830371e-01f, -3.16426694e-01f, -1.95363522e-01f, 3.16218764e-01f, 3.94941598e-01f,
  6.02813959e-02f, -7.58021399e-02f, 5.25882095e-03f, 5.86539693e-02f, -2.25323319e-01f, -5.75305484e-02f, -3.17197353e-01f, -2.11497128e-01f, -1.00499846e-01f, -5.80121875e-01f,
  -1.81397676e-01f, 2.95553803e-02f, 1.48316383e-01f, -9.97910947e-02f, -5.81273867e-04f, 1.37509620e-02f, 4.68625836e-02f, -1.19212642e-01f, 1.07597366e-01f, -1.59232825e-01f,
  -4.61568832e-02f, 1.25545412e-01f, 8.29795226e-02f, 2.32631974e-02f, 6.61079362e-02f, 4.81782816e-02f, 2.71794610e-02f, 5.87915350e-03f, -1.31004199e-01f, 6.89117536e-02f,
  -2.70417660e-01f, -1.16392866e-01f, -9.02415812e-02f, -5.38798757e-02f, 7.08629861e-02f, 8.61460343e-03f, 3.07371505e-02f, -6.18551113e-02f, -4.02834527e-02f, -6.08778238e-01f,
  -6.69565424e-02f, 6.01342283e-02f, 1.50710344e-01f, 9.05285776e-02f, -4.51452322e-02f, 9.86579508e-02f, -9.66231376e-02f, -2.05578003e-02f, 1.48068830e-01f, -8.16360191e-02f,
  9.63065028e-02f, 4.71723489e-02f, -1.91722773e-02f, -9.62308645e-02f, -9.86740459e-03f, -9.10454914e-02f, -5.93440421e-02f, -8.84674340e-02f, -1.40309371e-02f, -1.39935583e-01f,
  2.73575447e-02f, -2.75016259e-02f, -7.07583278e-02f, 8.22833627e-02f, -4.46367003e-02f, 1.06022106e-02f, -2.25346256e-02f, 1.19208910e-01f, 2.99265366e-02f, 5.78020327e-02f,
  7.86130689e-03f, 1.02255143e-01f, -2.04343617e-01f, 3.26330513e-02f, 2.89749335e-02f, -1.19744152e-01f, -1.71799392e-01f, 1.87308099e-02f, -2.95011494e-02f, 7.74032921e-02f,
  1.83203965e-01f, -1.40976399e-01f, -1.20218985e-01f, -1.74849667e-02f, -1.21619124e-02f, -7.88944438e-02f, -1.57004774e-01f, -1.84011366e-02f, 2.26334706e-02f, 8.06444138e-02f,
  -1.60659373e-01f, -1.89460561e-01f, -2.18640223e-01f, -2.32350960e-01f, -1.12133257e-01f, -1.99861720e-01f, -1.15582839e-01f, -2.55134016e-01f, -9.82589051e-02f, -5.38419306e-01f,
  -3.98493052e-01f, -6.67201936e-01f, 2.12965593e-01f, -5.17186560e-02f, 5.95075905e-01f, 2.65910625e-01f, 1.81267923e-03f, -3.12526971e-01f, -1.33870512e-01f, -4.89208251e-02f,
  -2.73739636e-01f, -4.00203109e-01f, -3.47972989e-01f, -3.00105602e-01f, -4.69829738e-01f, -7.22671524e-02f, 1.42456844e-01f, 1.08670644e-01f, 1.26325771e-01f, 3.06462586e-01f,
  1.95526928e-01f, 4.33782823e-02f, -1.16004437e-01f, -1.52170449e-01f, 2.49696583e-01f, 2.54794329e-01f, 1.22667313e-01f, 1.72479942e-01f, 2.57879734e-01f, 3.72310251e-01f,
  8.13535601e-02f, -3.89628917e-01f, 2.14082882e-01f, -1.26683474e-01f, -1.19342906e-02f, -1.85132995e-01f, -1.35079946e-03f, -1.63210943e-01f, -2.08779365e-01f, -1.37895733e-01f,
  -7.54770041e-02f, -1.33153826e-01f, -5.75485174e-03f, 2.46628132e-02f, -1.84832681e-02f, -1.55057520e-01f, -1.40716881e-01f, -2.86946535e-01f, -3.28774363e-01f, -1.66847318e-01f,
  -1.81937277e-01f, 1.83014184e-01f, 1.15242630e-01f, -1.37340337e-01f, -1.52699262e-01f, 6.79678842e-02f, 4.77470681e-02f, 1.62414178e-01f, 3.75446421e-03f, 2.52723724e-01f,
  6.50132000e-02f, 7.79577941e-02f, -8.22160020e-02f, 1.03320397e-01f, 4.29365784e-02f, 1.25867963e-01f, 1.17095746e-02f, -6.76659867e-02f, -2.58273282e-03f, 2.16627382e-02f,
  -2.68052034e-02f, 3.71539071e-02f, -3.21369991e-02f, -1.36474520e-01f, -1.48951099e-03f, -7.56453201e-02f, 3.00376415e-02f, -9.39712003e-02f, -7.71935331e-03f, -1.85167491e-02f,
  1.77686848e-02f, 8.90167505e-02f, 9.60246008e-03f, 2.89101712e-02f, 1.22057118e-01f, -7.08512813e-02f, 3.49605419e-02f, -3.04169897e-02f, -7.70725831e-02f, -7.87523531e-05f,
  -2.54148960e-01f, -1.77952126e-01f, 8.01744089e-02f, -1.64231881e-01f, -4.02984023e-02f, -2.71291230e-02f, -4.29092832e-02f, 1.03128478e-02f, -3.62870693e-02f, -1.67981547e-03f,
  -7.71758109e-02f, -8.91642794e-02f, -1.13095641e-01f, -1.43520320e-02f, 1.25147596e-01f, 1.36287278e-02f, -1.01397164e-01f, 6.68683425e-02f, -6.11794442e-02f, -5.70222773e-02f,
  -3.25709693e-02f, 1.23932503e-01f, 1.47401959e-01f, 2.88699549e-02f, 1.47473648e-01f, 1.83887884e-01f, 1.43963173e-01f, 2.41129935e-01f, 5.21918163e-02f, 1.44535691e-01f,
  -8.70197356e-01f, 6.81897774e-02f, -4.54987466e-01f, 1.75808281e-01f, 1.46821231e-01f, -7.07201958e-02f, 1.71466723e-01f, -2.32707243e-02f, 1.39173061e-01f, 2.24041920e-02f,
  -8.74520838e-02f, 9.21387300e-02f, 1.80918500e-01f, 1.25102520e-01f, 1.03929840e-01f, 1.90720797e-01f, 2.67517716e-01f, 6.91393437e-03f, -3.88659872e-02f, -7.07930326e-02f,
  3.16135734e-01f, 1.28561422e-01f, -2.57716507e-01f, -6.25287741e-02f, 6.60647824e-02f, 1.34711668e-01f, 1.83684945e-01f, 1.02579892e-01f, 1.51281327e-01f, 3.29474598e-01f,
  -4.69763160e-01f, -3.88497502e-01f, 3.64681357e-03f, 1.95111148e-02f, -2.91378766e-01f, -1.24182582e-01f, -2.53411740e-01f, -2.39742950e-01f, -1.25436068e-01f, -8.86180717e-03f,
  -6.28510164e-03f, -1.09139420e-01f, 2.22023323e-01f, 1.00988097e-01f, -5.19219376e-02f, -1.21584006e-01f, -6.99307993e-02f, -2.76747435e-01f, -2.46700987e-01f, -3.50542456e-01f,
  2.58967876e-01f, -1.62226036e-01f, -3.29139590e-01f, 4.61138450e-02f, -8.90837088e-02f, 4.61937897e-02f, -8.89498293e-02f, -3.46036673e-01f, -3.37113291e-01f, -1.02285251e-01f,
  -4.06819843e-02f, -5.67791089e-02f, 4.45941612e-02f, 3.16227637e-02f, -3.88613306e-02f, 2.49727238e-02f, 8.54130648e-03f, 9.75668728e-02f, 1.67570964e-01f, -5.46476394e-02f,
  -4.27090190e-02f, -1.25925581e-03f, 4.94024111e-03f, 4.86240797e-02f, 1.51530743e-01f, -9.81904343e-02f, 1.63380224e-02f, 8.66200253e-02f, -8.53223577e-02f, -7.44946301e-02f,
  5.13642058e-02f, -1.12302326e-01f, 1.07194223e-01f, 4.02372889e-02f, 7.52954036e-02f, -8.94432813e-02f, -6.95502385e-02f, 1.34137779e-01f, 5.91704529e-03f, -1.16852723e-01f,
  4.20225799e-01f, -7.24809095e-02f, -1.72834452e-02f, 9.36061740e-02f, -6.25868812e-02f, -3.92395966e-02f, 1.28791770e-02f, -1.37751475e-01f, 1.32311611e-02f, -1.07323788e-01f,
  -3.23332548e-02f, -4.99909557e-02f, 1.65315509e-01f, 1.42017141e-01f, 8.53957832e-02f, 1.07029289e-01f, 1.36275396e-01f, 6.82428628e-02f, 1.60210013e-01f, -1.06603757e-01f,
  2.22855732e-01f, 1.42526507e-01f, 4.88913544e-02f, 5.72548173e-02f, 8.61371458e-02f, 1.01012602e-01f, 1.26949390e-02f, -9.00531486e-02f, -1.28488988e-01f, -6.86410815e-02f,
  1.46776229e-01f, 4.27027911e-01f, -8.06892812e-01f, 2.91387327e-02f, -3.05270851e-01f, -2.66764581e-01f, 1.94820285e-01f, 3.59771997e-01f, 1.62474513e-01f, 7.67507404e-02f,
  5.18075116e-02f, -3.52980375e-01f, -3.29559296e-01f, -4.33294356e-01f, -2.39032581e-01f, -2.11916625e-01f, -4.10622686e-01f, -7.00677216e-01f, -7.36256719e-01f, -1.99925587e-01f,
  -1.94356725e-01f, -2.49256596e-01f, -2.51262933e-01f, -2.56439865e-01f, 3.57992463e-02f, -2.99882919e-01f, -1.30351335e-01f, -2.07256675e-01f, -3.88287365e-01f, -3.28371227e-01f,
  -6.26492321e-01f, -2.60589439e-02f, -1.22493386e-01f, -2.13518497e-02f, 3.00150383e-02f, 9.37060639e-02f, 1.09922230e-01f, 7.07680956e-02f, 2.65437216e-01f, 7.35323280e-02f,
  -7.67981187e-02f, 8.74518882e-03f, -1.04557432e-01f, -1.11493848e-01f, -1.50386291e-02f, -5.55393137e-02f, 1.16730705e-01f, 1.02863699e-01f, 2.02952084e-04f, 1.48932338e-01f,
  2.40198940e-01f, -7.84553885e-02f, 9.99922529e-02f, 1.75588354e-01f, 1.30228028e-01f, -3.53427939e-02f, 1.77022949e-01f, 6.49202093e-02f, 2.11642589e-02f, 2.81529248e-01f,
  8.93930942e-02f, 2.56527681e-02f, -1.41592935e-01f, 8.21756199e-02f, 1.43912509e-01f, 1.10307574e-01f, -5.45449853e-02f, 1.13253251e-01f, 1.10861734e-01f, 1.24188259e-01f,
  2.08715200e-01f, -2.32711285e-02f, 7.37706274e-02f, 1.04750641e-01f, -6.47565499e-02f, -1.88147854e-02f, -5.60769476e-02f, 5.29398173e-02f, 1.10219559e-03f, 1.19153351e-01f,
  8.12273659e-03f, 9.48342457e-02f, -1.04521975e-01f, 3.07462066e-02f, -7.34074265e-02f, -5.82273453e-02f, -8.72341990e-02f, 6.86721280e-02f, 6.99758679e-02f, 8.64938870e-02f,
  -2.22294688e-01f, -3.79967600e-01f, -7.38300607e-02f, 8.60353261e-02f, 5.57456166e-03f, 1.72338426e-01f, -4.45564501e-02f, 2.52020061e-02f, 4.80930023e-02f, 8.95977616e-02f,
  9.06841457e-02f, 4.67000250e-03f, -3.69419903e-02f, 9.93331671e-02f, 3.57863009e-02f, -1.43733416e-02f, 1.99594826e-01f, -8.68208483e-02f, 9.11689084e-03f, 1.81261957e-01f,
  2.84108967e-01f, 2.52504677e-01f, 1.42343771e-02f, 1.38426587e-01f, 1.77486435e-01f, -1.78354666e-01f, -8.68857428e-02f, 1.19307619e-02f, -1.81984790e-02f, 3.06042075e-01f,
  4.67407674e-01f, -2.95065105e-01f, 4.65009408e-03f, 2.10967690e-01f, 2.19691638e-02f, 1.26102060e-01f, -7.01840818e-02f, 1.11704580e-02f, 1.34088263e-01f, 1.37553141e-01f,
  5.59541620e-02f, 3.58921438e-01f, 3.29723686e-01f, 2.96502084e-01f, 1.61904648e-01f, 1.08041227e-01f, 1.57330871e-01f, 2.13972732e-01f, 3.04984093e-01f, 2.07860932e-01f,
  4.76037599e-02f, 9.16019380e-02f, 1.02685288e-01f, 1.17129706e-01f, 3.04883551e-02f, 2.01212898e-01f, 2.43406948e-02f, -3.16246878e-04f, 3.80452313e-02f, -4.86353319e-03f,
  -1.07415214e-01f, 1.00693712e-02f, 1.69626862e-01f, -6.81241527e-02f, -9.47535411e-02f, -1.51046589e-01f, -1.10937297e-01f, -6.84010237e-02f, -1.85785636e-01f, -2.26914153e-01f,
  -5.38326055e-03f, -1.26839206e-01f, -2.38725841e-02f, -4.60384004e-02f, -6.98857307e-02f, -7.99016804e-02f, -4.19527516e-02f, -2.80728191e-03f, 5.36814108e-02f, -9.26862955e-02f,
  6.82811514e-02f, -7.09714964e-02f, -1.30831167e-01f, -3.82266263e-03f, 1.26761764e-01f, 1.64730266e-01f, 7.83565044e-02f, -3.30772139e-02f, 9.84276161e-02f, 2.55973544e-02f,
  6.20642044e-02f, 7.17082396e-02f, 2.01955080e-01f, 4.94691590e-03f, 1.58997282e-01f, 9.25811753e-02f, 1.45098746e-01f, 2.85131373e-02f, 1.05091803e-01f, -1.65882930e-02f,
  -2.97420379e-02f, 7.46841282e-02f, -4.82123680e-02f, 2.41669510e-02f, 6.11065328e-02f, 2.32686847e-02f, -1.77801773e-01f, -8.15036707e-03f, 1.67421456e-02f, -4.90999147e-02f,
  5.94839044e-02f, 6.20767102e-02f, 1.40029803e-01f, 8.86236206e-02f, -1.59136280e-02f, 7.99541324e-02f, 8.21962133e-02f, -2.99697518e-02f, 5.55556156e-02f, -3.43740843e-02f,
  -5.63648045e-01f, 3.39852154e-01f, 2.23496914e-01f, -3.61372195e-02f, -1.04569919e-01f, -9.11745206e-02f, 8.57805386e-02f, -5.14053404e-02f, -1.48158625e-01f, -1.42737493e-01f,
  -1.24616742e-01f, 1.30779892e-01f, -2.68090740e-02f, 1.36290696e-02f, -5.10850698e-02f, -1.26252249e-01f, 3.40257622e-02f, 6.22160882e-02f, -3.18698138e-02f, -1.23152301e-01f,
  -2.22713780e-02f, -1.72097217e-02f, -1.55473843e-01f, 4.07944620e-02f, -4.11402546e-02f, -1.12467967e-02f, -6.52401894e-02f, -1.22183971e-01f, 2.95239054e-02f, -1.24997094e-01f,
  -9.46421802e-01f, 8.88327602e-03f, 1.10561766e-01f, -6.00797534e-01f, -1.97612345e-02f, 2.56233364e-01f, 1.28266513e-01f, 2.12810691e-02f, -2.79107988e-01f, -9.15561095e-02f,
  1.59599900e-01f, -2.22160563e-01f, -1.16477951e-01f, 4.14491110e-02f, -5.10829538e-02f, 9.60511155e-03f, -2.24663064e-01f, -2.30226189e-01f, 1.17343314e-01f, 3.42888236e-01f,
  8.12156051e-02f, -3.20323586e-01f, -3.82447660e-01f, -1.10033035e-01f, -2.46727183e-01f, -2.56594926e-01f, -2.26224273e-01f, -2.23617613e-01f, 1.05603881e-01f, -4.38366503e-01f,
  7.84901753e-02f, -2.32647955e-01f, 6.83958977e-02f, -1.01032041e-01f, -8.58881027e-02f, 3.94992493e-02f, -1.81235708e-02f, -1.24625631e-01f, 4.40880917e-02f, -1.63787510e-02f,
  -8.40163231e-02f, 1.22057155e-01f, -1.70999810e-01f, 1.23836510e-01f, -9.86689180e-02f, 1.26616403e-01f, 1.06515408e-01f, 7.98160359e-02f, 1.25462934e-02f, 3.93551916e-01f,
  1.14215225e-01f, 4.22301143e-02f, -9.80701223e-02f, 2.22386345e-01f, 1.78785473e-01f, 6.33245707e-02f, 1.88465223e-01f, 1.19630605e-01f, 2.37091303e-01f, -2.95688540e-01f,
  -1.06190722e-02f, -3.81254330e-02f, 4.61255088e-02f, -5.18771783e-02f, 1.58510054e-03f, -1.10859603e-01f, -9.09863338e-02f, -5.33869602e-02f, 5.68678752e-02f, -1.64121449e-01f,
  3.57302688e-02f, 7.55061880e-02f, 2.10829750e-02f, -5.74778616e-02f, 7.19811115e-03f, 4.87525016e-02f, -7.79001713e-02f, 6.49723113e-02f, 4.68309149e-02f, -1.74544722e-01f,
  -2.93247253e-02f, 2.84004603e-02f, -2.72954442e-02f, -7.45364511e-03f, 1.49602324e-01f, -8.20909292e-02f, 9.23527405e-02f, 1.57193303e-01f, 2.93644816e-02f, 7.18028694e-02f,
  -2.78106779e-01f, 1.09365515e-01f, -3.04717660e-01f, 7.94260129e-02f, -7.04481900e-02f, 4.56823930e-02f, -5.51646650e-02f, 6.48649633e-02f, -1.07876338e-01f, -2.07994487e-02f,
  2.32242614e-01f, -6.02422617e-02f, -1.57175377e-01f, 9.30965170e-02f, -1.31893801e-02f, -3.07719149e-02f, 8.68966207e-02f, -1.19752891e-01f, 1.67135060e-01f, 2.14030400e-01f,
  7.00016990e-02f, -1.28015146e-01f, -2.13096008e-01f, -1.89624485e-02f, 5.93245812e-02f, -1.67208597e-01f, 3.55335250e-02f, 5.06695509e-02f, -9.44310874e-02f, -2.99961060e-01f,
  -5.37929982e-02f, -4.28451002e-01f, -1.23290904e-01f, 1.05626389e-01f, -1.28096849e-01f, -1.26324758e-01f, -6.32775187e-01f, -4.67412546e-02f, 1.83463395e-01f, -5.60928047e-01f,
  -2.25820407e-01f, 2.12625146e-01f, -3.07824109e-02f, -3.16516608e-02f, -8.23163763e-02f, -6.30110025e-01f, -3.91097337e-01f, -2.72070430e-02f, 2.98675895e-01f, 9.98785272e-02f,
  -1.41254932e-01f, -1.13552935e-01f, 2.22766384e-01f, 1.92002311e-01f, -2.76473731e-01f, 3.76887806e-02f, -2.07671940e-01f, -2.11169496e-02f, -1.64004877e-01f, -6.17380679e-01f,
  -3.83850068e-01f, 1.12604052e-01f, 1.02256320e-01f, -5.20600416e-02f, -1.11413091e-01f, 1.18586738e-02f, -1.47009483e-02f, -2.22696587e-02f, 4.91186455e-02f, -2.61500087e-02f,
  4.86926734e-02f, 4.45763767e-02f, 1.22837834e-01f, 4.01271991e-02f, -4.16190960e-02f, -6.59871921e-02f, -4.20549996e-02f, 8.18823129e-02f, -5.83042651e-02f, -1.84533969e-01f,
  -1.96109593e-01f, -8.48903880e-02f, 6.24312647e-02f, -1.58332363e-02f, 2.38535523e-01f, 2.74674773e-01f, 8.84969682e-02f, 2.58874387e-01f, 9.93662924e-02f, -3.53767246e-01f,
  -1.06982432e-01f, 3.11870966e-02f, 2.36906596e-02f, -8.49454850e-02f, -6.09480450e-03f, -2.37883505e-04f, -2.32591964e-02f, -1.65053546e-01f, 3.59955640e-03f, -6.30981997e-02f,
  6.20863810e-02f, 5.12085371e-02f, 1.56693943e-02f, -1.56833027e-02f, -3.85561474e-02f, 4.14955057e-02f, -1.14558667e-01f, -7.40938559e-02f, -7.58993477e-02f, -1.00302897e-01f,
  1.93329025e-02f, 7.34113902e-02f, -2.40254495e-03f, 6.50246963e-02f, -4.60386183e-03f, -4.95061837e-02f, 1.74471904e-02f, 9.28908885e-02f, -7.18798786e-02f, -7.55794048e-02f,
  1.43474783e-03f, 1.46195278e-01f, -2.01966524e-01f, 2.69709732e-02f, -2.56372001e-02f, -8.48171487e-03f, -3.05040013e-02f, 2.57138051e-02f, 7.39864819e-03f, -2.60408726e-02f,
  4.27762978e-02f, -1.14776500e-01f, -1.42977443e-02f, -1.36021161e-02f, -1.10350810e-02f, -8.98762196e-02f, -1.96533844e-01f, -1.64236233e-01f, 1.31404698e-01f, -2.59809792e-02f,
  -1.07389979e-01f, -1.67160094e-01f, 1.45761361e-02f, -1.15366071e-01f, -3.56932990e-02f, 1.80827990e-01f, 2.49270862e-03f, 5.26021468e-03f, 9.20539442e-03f, -4.23085690e-01f,
  3.55740041e-01f, 3.15163970e-01f, 2.05712333e-01f, 3.47591132e-01f, 4.59395915e-01f, 4.61606592e-01f, 6.37553155e-01f, 3.45610231e-01f, 4.52698395e-02f, 2.26890072e-01f,
  2.77518660e-01f, -3.64910401e-02f, -1.69554129e-01f, -5.25640398e-02f, 5.67128696e-02f, 6.26088008e-02f, 7.27174133e-02f, -2.16306895e-02f, -3.75232548e-02f, 1.13337465e-01f,
  2.57210759e-03f, 2.92138696e-01f, 1.62108883e-01f, -6.48352355e-02f, 5.78498244e-02f, -6.27955794e-02f, 2.47916058e-01f, 4.15659785e-01f, 2.87456602e-01f, -2.11637557e-01f,
  1.69326402e-02f, 2.95736313e-01f, -2.96604276e-01f, -6.18901774e-02f, -9.52271298e-02f, -2.33863384e-01f, -7.28808269e-02f, -3.07840556e-02f, -7.30270520e-02f, -5.87539598e-02f,
  -9.15575475e-02f, -2.33999062e-02f, 8.59994590e-02f, 2.69908947e-03f, 6.91504180e-02f, 4.84735053e-03f, -8.78153890e-02f, 4.23426479e-02f, 3.15034986e-02f, -6.90460652e-02f,
  4.48825471e-02f, 2.03551784e-01f, 3.77387762e-01f, 7.78196678e-02f, 1.10480323e-01f, -4.07014266e-02f, -9.24000237e-03f, 3.12281190e-04f, -1.38512617e-02f, 9.68421064e-03f,
  1.21254399e-01f, -3.30074467e-02f, 2.88518071e-02f, 9.79192331e-02f, -2.44484227e-02f, -9.98298600e-02f, -2.57845614e-02f, 5.74215427e-02f, 1.59105048e-01f, 2.11984217e-02f,
  -3.85192148e-02f, 1.60869211e-02f, 6.84284642e-02f, 6.72275499e-02f, -3.53042185e-02f, 1.72170460e-01f, 5.30161755e-03f, 1.81966243e-04f, 9.50897634e-02f, 8.93391147e-02f,
  7.98489898e-02f, 2.15782821e-02f, -7.44786933e-02f, 2.02501509e-02f, 8.30301922e-03f, -3.86545397e-02f, -6.16590900e-04f, 4.52746525e-02f, 1.46328002e-01f, 1.25913182e-02f,
  2.82642066e-01f, 2.30951950e-01f, -2.01877192e-01f, -1.23698361e-01f, -9.80613455e-02f, -7.88957477e-02f, 2.13973038e-03f, -5.53079136e-02f, -4.29873243e-02f, -1.03276528e-01f,
  -1.45354941e-02f, -1.20180942e-01f, -2.72551924e-02f, 4.33935598e-02f, -5.35571650e-02f, -1.05282992e-01f, -3.01392912e-03f, 1.04438335e-01f, -3.39910947e-02f, -9.23377723e-02f,
  -1.29172117e-01f, -4.08034027e-03f, 1.55351579e-01f, -3.61378933e-03f, -5.62292859e-02f, -5.15276343e-02f, -3.39459479e-02f, -5.71680292e-02f, 1.48542644e-02f, -1.01211809e-01f,
  -2.27979228e-01f, -2.11904228e-01f, -3.68975431e-01f, -5.94606340e-01f, -4.92292345e-01f, -1.29139230e-01f, -1.86217010e-01f, -1.36903733e-01f, -3.19177747e-01f, -3.10824752e-01f,
  7.03469142e-02f, 3.78471673e-01f, 4.10345525e-01f, 5.00786901e-01f, 5.59300780e-01f, -1.95832446e-01f, -4.68140572e-01f, 1.06357627e-01f, 4.38889474e-01f, -2.80886497e-02f,
  -6.23468198e-02f, -1.95506483e-01f, -1.95602141e-02f, -7.31118172e-02f, -3.76070946e-01f, 5.48073687e-02f, -3.86494488e-01f, -3.46210837e-01f, -1.23385482e-01f, -4.79942471e-01f,
  2.85825789e-01f, -4.37077463e-01f, -1.32008165e-01f, -1.35079343e-02f, -9.72720310e-02f, 7.39404839e-03f, 8.05886537e-02f, -4.72634435e-02f, -3.63143906e-03f, -1.17745027e-01f,
  -1.65019885e-01f, 3.81195219e-03f, 1.15207337e-01f, 7.93927163e-02f, -4.97423336e-02f, 5.30949757e-02f, -7.10100681e-02f, -1.60583422e-01f, -2.70262472e-02f, -3.63154970e-02f,
  2.99750385e-03f, -1.82601824e-01f, 1.01663530e-01f, 4.45051901e-02f, -3.45566124e-02f, 1.02179125e-01f, 3.96765620e-02f, -1.07649148e-01f, 8.43614489e-02f, -1.12247393e-01f,
  1.04056902e-01f, 8.75156596e-02f, -1.45221537e-03f, 1.70045458e-02f, -1.87704265e-02f, 2.94678062e-02f, 1.45230338e-01f, 1.78434458e-02f, 2.10928414e-02f, 2.23577350e-01f,
  -2.72790585e-02f, -1.04744285e-01f, 1.12873418e-02f, -6.36525303e-02f, 5.35352044e-02f, -1.38904497e-01f, 1.00017088e-02f, 4.68821563e-02f, -1.09386824e-01f, -8.04340616e-02f,
  4.36782651e-03f, -1.75751328e-01f, 1.26971235e-03f, 9.00931805e-02f, -1.48893237e-01f, -8.20647329e-02f, 2.40612775e-02f, 5.29820770e-02f, -4.09885682e-02f, -1.43770531e-01f,
  3.94974977e-01f, -1.82453524e-02f, -1.05214799e-02f, -1.58255436e-02f, -3.59782688e-02f, -8.07108581e-02f, -7.84745365e-02f, -1.03797436e-01f, 2.66466420e-02f, -1.39318053e-02f,
  -1.61257371e-01f, 1.23177081e-01f, 9.70947593e-02f, 4.25356999e-02f, 6.62589222e-02f, -1.97836105e-02f, 2.40857247e-02f, -9.74738784e-03f, -4.54790704e-02f, -1.10753745e-01f,
  -2.23625451e-02f, 1.13426425e-01f, 2.54833877e-01f, 1.22217268e-01f, -1.96342133e-02f, 2.76015520e-01f, 1.07556708e-01f, 7.16189481e-03f, 2.08048046e-01f, 2.20945224e-01f,
  -8.61372530e-01f, 4.69185561e-01f, 2.44021982e-01f, -3.66753042e-01f, 3.19737494e-01f, 1.80033818e-01f, 3.88164341e-01f, 6.77256659e-02f, -2.29820907e-01f, 2.80746698e-01f,
  1.92726821e-01f, -9.37182084e-02f, 7.36650825e-02f, 1.40369251e-01f, -7.37302452e-02f, 3.94652992e-01f, 3.43178272e-01f, -8.57986137e-02f, -5.00543535e-01f, -3.28668714e-01f,
  -3.38298231e-02f, -3.64085734e-01f, -6.60230875e-01f, -2.30322689e-01f, 4.48620729e-02f, -8.93348455e-02f, 2.57223964e-01f, -9.63951796e-02f, 1.41289011e-01f, 3.79577100e-01f,
  -5.13339564e-02f, 9.22407359e-02f, 2.79886927e-02f, -1.10800840e-01f, -4.78447648e-03f, -1.29671872e-01f, -5.98423816e-02f, -5.81487902e-02f, 5.54770492e-02f, 4.37245853e-02f,
  4.02738750e-02f, 2.62731146e-02f, 4.37127352e-02f, 5.59035726e-02f, -2.25405321e-01f, -2.47311115e-01f, -2.29009464e-02f, -1.13548271e-01f, -1.31312143e-02f, -5.14225382e-03f,
  4.34935689e-01f, -5.93295209e-02f, -1.27588794e-01f, 1.98744550e-01f, 6.59543201e-02f, -2.13745117e-01f, -7.52347410e-02f, -1.96630403e-01f, -1.25194684e-01f, -1.25965774e-01f,
  4.21696156e-02f, 1.05651738e-02f, 1.32468536e-01f, 2.86142472e-02f, -3.67389619e-02f, 5.33534326e-02f, 1.38843939e-01f, 5.06799631e-02f, 3.49456556e-02f, -1.21610075e-01f,
  1.05020799e-01f, -1.42662798e-03f, -7.40002990e-02f, 8.74866247e-02f, -1.02658913e-01f, -9.56259482e-03f, 1.00897960e-02f, -2.54302938e-02f, -4.11825292e-02f, -3.39142233e-02f,
  -1.04473092e-01f, 3.42625752e-02f, -3.52239124e-02f, 8.72923899e-03f, 1.50418788e-01f, 8.48601665e-03f, 8.84973351e-03f, -3.78615856e-02f, -9.71032605e-02f, 1.96780134e-02f,
  -2.41431117e-01f, 2.33132958e-01f, -1.19983740e-01f, 1.05783753e-02f, 1.02499627e-01f, -7.19088912e-02f, 4.75796014e-02f, 6.01301575e-03f, 2.28089280e-02f, -1.73398271e-01f,
  -4.14543338e-02f, 5.05386181e-02f, 7.56041706e-02f, 6.78423345e-02f, -1.58849463e-01f, -2.01424323e-02f, 3.57719585e-02f, -7.90451933e-03f, -9.67976917e-03f, -1.54844122e-02f,
  1.12169601e-01f, -2.18509480e-01f, -4.17384565e-01f, -2.99382713e-02f, -1.05855748e-01f, -3.11741859e-01f, -2.22275332e-01f, -2.62190223e-01f, -2.73243278e-01f, -2.67000228e-01f,
  2.11766303e-01f, 1.25859484e-01f, -1.22028284e-01f, 2.13681698e-01f, 1.09641619e-01f, 6.56344965e-02f, 2.02897087e-01f, 2.85748035e-01f, 2.12411210e-01f, 2.37674713e-01f,
  2.11077053e-02f, 8.88000354e-02f, 1.88147426e-01f, 2.12556273e-02f, 8.09291974e-02f, 1.31197110e-01f, 4.82191592e-02f, -7.95196593e-02f, 7.38265589e-02f, 1.58856452e-01f,
  1.15914911e-01f, 1.29713252e-01f, 1.21077336e-02f, 1.16943732e-01f, 7.22773150e-02f, 1.47644253e-02f, -1.05831092e-02f, -1.22160420e-01f, -1.29793197e-01f, 1.14594556e-01f,
  -1.74334660e-01f, -1.58389032e-01f, 1.38008401e-01f, -4.29855213e-02f, -1.66354299e-01f, -1.73380710e-02f, 9.38471183e-02f, 1.02169737e-01f, -1.14572225e-02f, 3.49373259e-02f,
  -1.40014738e-01f, -1.62039295e-01f, -1.73700079e-01f, -9.10851806e-02f, -6.78090975e-02f, -1.57071725e-01f, -7.08904266e-02f, 4.80266809e-02f, 3.63533162e-02f, -2.70854756e-02f,
  6.02931380e-02f, -7.74268955e-02f, 7.13958815e-02f, 6.46908507e-02f, 2.18354221e-02f, 4.02547000e-03f, -7.74980849e-03f, -7.35337734e-02f, -1.19093165e-01f, 2.61427686e-02f,
  2.13663474e-01f, 9.70033035e-02f, 1.60823576e-02f, 1.87270250e-02f, 3.28086130e-02f, 2.21696347e-02f, 6.28609285e-02f, 2.84087323e-02f, -1.19969733e-01f, -4.14224751e-02f,
  6.07989207e-02f, -8.43269657e-03f, -7.96583481e-04f, 1.33005187e-01f, 4.31732349e-02f, 2.71160267e-02f, -2.06749886e-02f, -1.10505447e-01f, -2.60333389e-01f, -1.49242952e-01f,
  -2.93780547e-02f, -3.55464630e-02f, -7.40186870e-02f, -1.10872976e-01f, 1.78595539e-02f, -4.11331952e-02f, -4.56973873e-02f, -1.07250117e-01f, -1.55992284e-02f, 7.41914958e-02f,
  4.57294375e-01f, -2.79841661e-01f, 6.44370243e-02f, -2.33302135e-02f, -2.53850043e-01f, -6.95076361e-02f, 9.01251752e-03f, -1.47930328e-02f, -8.39783475e-02f, 4.10876274e-02f,
  -1.92409351e-01f, -4.34198640e-02f, -8.39604065e-02f, 4.14940752e-02f, -1.12151302e-01f, -1.34656280e-01f, 7.45492801e-03f, 1.58777267e-01f, 1.15232654e-01f, 1.60449371e-02f,
  2.93503553e-02f, 1.55182272e-01f, 2.80969530e-01f, 1.26035899e-01f, 7.76874721e-02f, 1.84386954e-01f, 1.52270421e-01f, 4.02119150e-03f, -5.03422990e-02f, 1.50940135e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.25539124e-02f, 2.24873468e-01f, 5.71922921e-02f, 3.29243481e-01f, 5.56274772e-01f, 1.85402989e-01f, 5.46691298e-01f, 4.98067260e-01f, 1.85540035e-01f, 3.04104179e-01f,
  5.67365170e-01f, 4.59188521e-01f, 3.32818300e-01f, 1.41176105e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.75474510e-01f, 5.01809875e-03f, 3.73592712e-02f, -3.50643806e-02f, 1.02607548e-01f, 8.41655955e-02f, 5.40228002e-02f, 1.09696649e-01f, -1.34178922e-01f, 1.52839929e-01f,
  1.30022854e-01f, -1.95250541e-01f, 5.76767139e-02f, 4.97895554e-02f, -7.96380118e-02f, -3.97703163e-02f, 5.54339550e-02f, 2.05858111e-01f, 9.60710719e-02f, 8.52170214e-02f,
  1.04366526e-01f, 3.25229168e-02f, 1.08585753e-01f, -1.48619473e-01f, 4.72956747e-02f, 1.75225586e-02f, 1.45326674e-01f, -1.49372742e-01f, -6.79511875e-02f, 3.65295380e-01f,
  1.28013179e-01f, 2.03288555e-01f, 8.77480805e-02f, 1.93450809e-01f, 1.17624309e-02f, 1.48525789e-01f, -1.52425244e-01f, -5.87879494e-02f, -1.31820694e-01f, -3.53303105e-02f,
  -2.92959269e-02f, -2.10679527e-02f, 2.79770810e-02f, 2.12524980e-01f, 5.46875298e-02f, -1.48056835e-01f, 6.58654124e-02f, -1.72833666e-01f, 5.95068261e-02f, -2.58087873e-01f,
  1.24076508e-01f, -3.26759815e-01f, -1.29184630e-02f, 1.69861540e-01f, 1.53804272e-01f, -1.24609187e-01f, -6.84175715e-02f, 1.39088362e-01f, -4.93178964e-02f, 3.00381035e-01f,
  1.86298162e-01f, 5.43054603e-02f, 2.25270346e-01f, -3.47240828e-02f, 1.55984238e-01f, 1.98486820e-03f, -1.12744883e-01f, 1.68127090e-01f, 1.67493578e-02f, 8.73050168e-02f,
  1.36127740e-01f, 4.84434403e-02f, 1.28218932e-02f, -3.69946584e-02f, 5.17333262e-02f, 8.86169076e-02f, 6.77967519e-02f, -5.11633679e-02f, 4.87666279e-02f, -9.55940112e-02f,
  -9.39294025e-02f, -2.25512590e-02f, 1.14053279e-01f, 3.64825279e-02f, -1.52522638e-01f, -1.27610229e-02f, 1.95334274e-02f, -5.59969582e-02f, 4.03496958e-02f, -7.15918979e-03f,
  -1.16679385e-01f, 1.50288373e-01f, 2.69185066e-01f, -1.73976332e-01f, 3.95309255e-02f, 3.46314535e-02f, 9.63627473e-02f, 1.41195610e-01f, 6.35303333e-02f, -6.03434704e-02f,
  -1.79115251e-01f, -1.14941578e-02f, 7.45982081e-02f, 1.31374970e-01f, -1.03385039e-01f, 6.28466755e-02f, 2.48201378e-03f, -3.94114971e-01f, -2.87328437e-02f, 5.28395697e-02f,
  -1.87930409e-02f, -4.85813133e-02f, -2.76788138e-02f, -5.06641045e-02f, 2.01563179e-01f, -1.46198079e-01f, -2.44963437e-01f, -1.77816879e-02f, -3.83761734e-01f, -4.78219926e-01f,
  -1.71757340e-01f, 1.83176115e-01f, 1.47331521e-01f, 2.49964640e-01f, -7.80568570e-02f, -1.09728158e-01f, 2.69439757e-01f, -3.85210626e-02f, -1.28672972e-01f, 3.26362774e-02f,
  -1.10927764e-02f, 3.13789956e-02f, 1.48481363e-02f, 1.48151532e-01f, 2.24567354e-01f, 1.93350390e-01f, -8.73889551e-02f, -1.22692417e-02f, 3.54729369e-02f, 3.07618659e-02f,
  -1.06921747e-01f, -1.30247712e-01f, 2.26848107e-02f, -5.63539304e-02f, -1.96235999e-02f, 3.84457991e-03f, 1.31614462e-01f, 2.03649417e-01f, -6.12346753e-02f, 1.88525822e-02f,
  6.63055256e-02f, -2.64129877e-01f, 8.72570425e-02f, -3.13593149e-02f, 1.23444714e-01f, 1.39758199e-01f, 1.51909664e-01f, 2.70977616e-01f, 9.54718739e-02f, -6.32460117e-02f,
  -1.22642525e-01f, 2.86012203e-01f, 2.24710274e-02f, 7.10195899e-02f, -1.95946068e-01f, 1.13567123e-02f, -6.02600053e-02f, 8.96233693e-03f, -4.77413945e-02f, -1.00365482e-01f,
  -3.59378085e-02f, 3.13988566e-01f, 1.21855348e-01f, -1.56470597e-01f, 7.60363564e-02f, -7.65840858e-02f, -2.47814283e-02f, -2.13777162e-02f, -7.88498372e-02f, -2.23297745e-01f,
  6.25142921e-03f, 1.05525568e-01f, 3.10302284e-02f, 1.39621466e-01f, -1.29320025e-01f, 5.56652099e-02f, 6.91360310e-02f, -3.35381031e-02f, 2.46981874e-01f, 3.09647888e-01f,
  7.57992119e-02f, 2.93536246e-01f, -2.31187362e-02f, -1.07738495e-01f, -5.13181686e-02f, -2.29359508e-01f, 2.04543415e-02f, -1.34462863e-01f, -4.54406962e-02f, -1.34281129e-01f,
  2.55902916e-01f, 1.79563388e-02f, 1.54684380e-01f, -2.51356483e-01f, 1.17948279e-01f, 4.86711748e-02f, 4.18862775e-02f, 4.07337956e-02f, 7.16658086e-02f, 3.88890840e-02f,
  1.02298930e-01f, -1.39397368e-01f, -3.32686538e-03f, 1.71334054e-02f, 1.29215941e-01f, 8.33541155e-02f, -1.56710260e-02f, -1.95881635e-01f, 1.54701993e-01f, -9.46066827e-02f,
  -2.02052891e-01f, 1.85206067e-02f, 1.88253850e-01f, 1.80049285e-01f, 2.24080950e-01f, -1.41337886e-01f, -2.71091126e-02f, 2.03109402e-02f, 2.70606488e-01f, -1.09693870e-01f,
  -1.24668315e-01f, -1.68473527e-01f, 1.61829695e-01f, 5.22911325e-02f, 1.30793363e-01f, -3.33893597e-02f, -1.30571976e-01f, 1.13026090e-01f, -1.99009273e-02f, 2.64233142e-01f,
  1.76748514e-01f, -7.31497398e-03f, -1.46425024e-01f, 1.99793845e-01f, -1.88568011e-01f, 3.59714031e-02f, -1.77742824e-01f, -1.05232202e-01f, 2.45470285e-01f, 9.55040380e-02f,
  1.13920942e-01f, 6.10028245e-02f, 4.41410765e-02f, -2.77850956e-01f, -2.41464764e-01f, -4.09199037e-02f, -5.35946079e-02f, 7.55952969e-02f, -1.64482355e-01f, -1.04594842e-01f,
  1.28769241e-02f, -1.84669625e-03f, -3.19655091e-02f, -7.51996189e-02f, 1.23179555e-02f, -3.25874537e-02f, 1.58129826e-01f, -3.73999774e-02f, 1.09702989e-01f, 3.12651768e-02f,
  3.84664536e-02f, -6.27859216e-03f, 5.08421250e-02f, 1.14195254e-02f, 2.50255436e-01f, 7.37304911e-02f, -1.41091868e-01f, -4.11143266e-02f, 1.62602872e-01f, -6.12059236e-02f,
  -5.21072149e-02f, -1.20455800e-02f, -1.94116518e-01f, 3.67548689e-02f, 1.49959564e-01f, -1.64910898e-01f, 1.90087512e-01f, 7.67008886e-02f, 1.36613846e-01f, 1.65022388e-01f,
  -2.62871124e-02f, 7.79442638e-02f, 6.05604760e-02f, -8.55401158e-02f, 3.69573534e-02f, -2.58776974e-02f, -8.06680471e-02f, 1.33460030e-01f, 1.87991951e-02f, -6.47453591e-02f,
  -1.47645235e-01f, 1.58060923e-01f, 1.30364085e-02f, -1.62878677e-01f, -1.15915984e-01f, 5.51108718e-02f, 1.24322377e-01f, 1.01401009e-01f, -1.88178360e-01f, -5.52395098e-02f,
  -2.54072428e-01f, -4.96338934e-01f, 9.97723490e-02f, 2.03617364e-01f, -3.12971264e-01f, 3.54898334e-01f, 1.89325348e-01f, -7.13387802e-02f, -3.04783285e-01f, 1.39948055e-01f,
  1.57865390e-01f, 3.75294592e-03f, 1.50565177e-01f, 2.61660349e-02f, 2.69663557e-02f, 1.55553564e-01f, 8.15974772e-02f, 2.37546060e-02f, -9.50414687e-02f, -1.05789639e-01f,
  9.20950770e-02f, 9.13207680e-02f, 3.95470997e-03f, 8.19000378e-02f, 2.35267747e-02f, -1.18287161e-01f, 1.18313752e-01f, -9.30008963e-02f, -2.05679119e-01f, -5.44858091e-02f,
  -1.24885507e-01f, -4.70249392e-02f, -1.24487855e-01f, 1.37525007e-01f, -6.92135543e-02f, -2.68793125e-02f, 8.00697953e-02f, 3.20271432e-01f, 2.74932534e-02f, -5.17435707e-02f,
  -1.04728043e-01f, -1.64375111e-01f, 1.21304207e-01f, 3.42980295e-01f, 5.42825274e-03f, 2.56308138e-01f, -1.18090615e-01f, 3.34861293e-03f, 9.92562994e-03f, 2.93240696e-01f,
  -1.06974125e-01f, 7.29164332e-02f, -1.69620499e-01f, -1.98420763e-01f, 7.33141601e-02f, 3.26591700e-01f, 1.17006354e-01f, -3.33889246e-01f, 4.86791357e-02f, -8.93272907e-02f,
  -1.13229275e-01f, -1.13584712e-01f, -1.68818966e-01f, -1.95142463e-01f, 1.89387605e-01f, 2.51502007e-01f, 9.79217291e-02f, -2.12175818e-03f, -6.20617792e-02f, -1.19690515e-01f,
  6.99073598e-02f, -1.51901171e-01f, 3.32572311e-01f, -2.77020056e-02f, 7.93104544e-02f, -2.93026894e-01f, 4.18119170e-02f, -4.43219803e-02f, -3.99313271e-02f, 9.31380987e-02f,
  -5.56249991e-02f, 6.98417723e-02f, -1.68413281e-01f, 4.12776545e-02f, -5.10575809e-02f, 1.30848736e-01f, -4.37822528e-02f, -1.46152051e-02f, -1.09160133e-02f, -3.06137856e-02f,
  -2.40908898e-02f, 4.91295196e-02f, -2.20987722e-01f, 8.88259932e-02f, -1.18799590e-01f, 2.44373543e-04f, -7.98612982e-02f, 1.15153544e-01f, -8.73344019e-02f, -3.71716097e-02f,
  -2.56510168e-01f, 1.56398103e-01f, 3.79169248e-02f, -8.72171000e-02f, -5.88684604e-02f, 2.16533057e-02f, -5.62271364e-02f, 2.66867485e-02f, -1.03703007e-01f, 1.65151969e-01f,
  -2.48395517e-01f, 2.29399633e-02f, 1.48651198e-01f, 1.08762801e-01f, 3.78887728e-02f, 3.06254309e-02f, 3.53420638e-02f, -6.41047210e-02f, -5.31319454e-02f, -1.08316526e-01f,
  8.99828449e-02f, -1.77605912e-01f, -7.57218227e-02f, -2.01857332e-02f, 8.42005238e-02f, -5.00756614e-02f, -1.67895809e-01f, -7.62407631e-02f, -1.15771301e-01f, 6.80163354e-02f,
  -6.48480952e-02f, 9.19567496e-02f, -2.22758204e-02f, -2.28152648e-01f, -1.80796459e-02f, -2.68393993e-01f, 2.65818447e-01f, 2.41475835e-01f, -1.63274109e-02f, -6.45224527e-02f,
  -1.26800224e-01f, -1.15079559e-01f, -1.09509557e-01f, 1.17929481e-01f, -1.14995472e-01f, -8.57934207e-02f, -2.20868468e-01f, -3.58849354e-02f, 4.05259319e-02f, -1.32016137e-01f,
  -1.15178183e-01f, -1.65431082e-01f, -1.27379581e-01f, -4.08522738e-03f, -7.70693868e-02f, 9.14905518e-02f, 5.83539605e-02f, -1.81927487e-01f, 5.81706874e-02f, 8.87303129e-02f,
  -1.72384791e-02f, 4.93816361e-02f, -1.08913518e-01f, 2.92716585e-02f, 2.59403110e-01f, 5.74096888e-02f, -1.76605493e-01f, 2.50929058e-01f, 2.28654712e-01f, -1.61496401e-01f,
  -8.49179402e-02f, -1.47556290e-01f, 2.08379067e-02f, -1.69700421e-02f, 7.37755075e-02f, 4.05337997e-02f, -1.14485301e-01f, -8.99981856e-02f, 1.85063761e-02f, -1.13812722e-01f,
  7.50734955e-02f, -1.77764595e-01f, 1.86775342e-01f, 1.48107335e-01f, -2.20695183e-01f, 1.06732912e-01f, 2.59990364e-01f, 4.37912717e-02f, -1.42137259e-01f, -7.10413009e-02f,
  1.08337149e-01f, -1.32023439e-01f, 1.84520528e-01f, -2.44237423e-01f, 1.04572669e-01f, -3.35943013e-01f, 1.38331875e-01f, 2.53578275e-01f, -1.36210695e-01f, -1.26307562e-01f,
  1.58091202e-01f, -1.39596447e-01f, 3.41829695e-02f, 6.74109766e-03f, -2.91282739e-02f, 5.31333499e-02f, -1.19301528e-01f, 1.65043715e-02f, 4.82826531e-02f, 3.08157550e-03f,
  -1.29217476e-01f, 1.45350518e-02f, -7.83684030e-02f, 1.14234924e-01f, -9.58127156e-02f, 2.67337002e-02f, 4.18819264e-02f, 5.32300249e-02f, -1.65450603e-01f, -3.15463468e-02f,
  -7.79297948e-02f, -1.64531823e-02f, 9.88992304e-02f, 8.41334462e-02f, -7.17648864e-02f, -1.37196794e-01f, 2.38697588e-01f, 6.11320278e-03f, -1.90419525e-01f, -5.34065366e-02f,
  -7.11988145e-03f, 3.89320105e-02f, -5.19071706e-02f, -8.31257924e-02f, -1.07483648e-01f, 1.22923665e-01f, -9.00971889e-02f, 1.23885602e-01f, 1.03629775e-01f, 3.96431014e-02f,
  1.32919446e-01f, 2.71110572e-02f, 1.91900302e-02f, 8.87766033e-02f, 2.88818069e-02f, 2.95769542e-01f, -4.63338010e-02f, -1.31421626e-01f, -6.85445368e-02f, -2.59153489e-02f,
  -9.44935158e-02f, 2.07349002e-01f, 1.47747546e-01f, -1.62206858e-01f, 1.42579898e-01f, -2.49992386e-01f, 1.62684415e-02f, 3.89894903e-01f, 1.18383139e-01f, -1.68153197e-02f,
  1.13234147e-02f, -9.90675837e-02f, -1.26443267e-01f, 2.26547405e-01f, -3.78441587e-02f, 1.92183644e-01f, 5.42629063e-02f, 9.67608392e-02f, 1.98263764e-01f, 1.37566149e-01f,
  -5.32536209e-02f, 6.97761402e-02f, -1.76087007e-04f, 1.38179079e-01f, 3.48681323e-02f, -3.09441984e-03f, -4.51278090e-02f, 8.97838548e-02f, -3.67503241e-02f, 1.27993345e-01f,
  9.40552428e-02f, -1.13364123e-01f, 1.17892563e-01f, 1.05346352e-01f, -1.28246039e-01f, 2.53299810e-02f, -1.05959073e-01f, -7.63042718e-02f, -6.11052439e-02f, 4.53864783e-02f,
  4.11106013e-02f, -4.88219187e-02f, -1.50504634e-01f, 8.58568773e-02f, 9.32377279e-02f, -9.18880850e-02f, -6.54687658e-02f, -2.01285198e-01f, -2.20492676e-01f, 2.68334802e-02f,
  -1.13209836e-01f, 6.93028867e-02f, 1.06051192e-01f, 9.99045298e-02f, -2.75105257e-02f, 7.72444382e-02f, -1.63976476e-01f, -1.55317392e-02f, -9.13185626e-02f, 8.07985365e-02f,
  -1.08969539e-01f, 6.43201219e-03f, 2.54142173e-02f, -2.04626128e-01f, -1.14544053e-02f, -4.27242415e-03f, 5.22397496e-02f, 1.87036231e-01f, 4.20251414e-02f, -2.58018792e-01f,
  -1.77399337e-01f, 4.52028483e-01f, 3.56147178e-02f, 1.74736623e-02f, -2.08416834e-01f, -2.50051260e-01f, -1.77797407e-01f, 1.42021805e-01f, 6.87800422e-02f, 2.02647641e-01f,
  -1.26296610e-01f, 4.19985168e-02f, -2.54365355e-02f, -1.13856964e-01f, 2.30835155e-02f, -6.70731887e-02f, -2.40428299e-02f, -8.99320692e-02f, -4.16626595e-02f, -1.19602531e-02f,
  1.34908721e-01f, -4.24085818e-02f, 5.12275435e-02f, -4.71707806e-02f, -5.72353462e-03f, -1.05380006e-02f, -7.13728890e-02f, -1.38937503e-01f, 7.58104995e-02f, -7.45518580e-02f,
  -6.15210235e-02f, -7.39549622e-02f, 4.63338569e-02f, 1.18029326e-01f, 1.80608798e-02f, 1.66698396e-01f, -1.65639356e-01f, -5.32877333e-02f, 9.81058851e-02f, -1.21160574e-01f,
  -1.66216150e-01f, 1.27637804e-01f, 1.26736030e-01f, 1.08925447e-01f, -7.10215885e-03f, -3.23621631e-02f, 1.28626555e-01f, -4.28023785e-02f, 1.32037684e-01f, 1.42854452e-01f,
  6.24334291e-02f, 5.26579991e-02f, -1.48240454e-03f, -2.66534895e-01f, 1.84732564e-02f, 1.83210716e-01f, 2.96319518e-02f, -8.87665525e-02f, -7.35546574e-02f, -5.20177223e-02f,
  1.32875964e-01f, 2.64905673e-02f, -9.34028327e-02f, 1.16464429e-01f, 3.16059850e-02f, -1.93695739e-01f, -3.86461914e-02f, 3.49699199e-01f, 5.63594587e-02f, 3.75373662e-01f,
  -7.74471089e-02f, -2.68660486e-01f, -3.00530225e-01f, -1.38994947e-01f, 1.70647591e-01f, 1.60428196e-01f, 3.20589878e-02f, 6.67938218e-02f, -1.35532161e-02f, 1.05762877e-01f,
  -1.16467923e-01f, -9.05331001e-02f, -1.45889148e-01f, 6.04127161e-02f, -2.03123176e-03f, 1.11681461e-01f, -3.09349392e-02f, -3.79723050e-02f, 5.56569248e-02f, -6.43433109e-02f,
  -1.14274153e-03f, -6.42848536e-02f, -3.80964056e-02f, 6.12055883e-02f, -1.61744043e-01f, -1.16655968e-01f, -1.48068920e-01f, -2.62306705e-02f, -2.21058190e-01f, 2.58921683e-02f,
  -2.31676489e-01f, 1.74480990e-01f, 5.71302278e-03f, -1.30381957e-01f, -2.44492650e-01f, -1.26881897e-01f, 1.37517571e-01f, -8.86661932e-02f, 8.41438323e-02f, 1.89041182e-01f,
  -2.39340425e-01f, 1.26364484e-01f, -3.90206426e-02f, 1.05064400e-01f, 9.03807953e-02f, 1.92765206e-01f, -3.29127908e-02f, -2.10987538e-01f, -6.38586050e-03f, 1.03958905e-01f,
  4.34277691e-02f, -2.05749035e-01f, -2.35507339e-02f, -9.66571197e-02f, -7.01058432e-02f, 4.73218895e-02f, -1.54598802e-01f, -3.02019984e-01f, -2.47828104e-02f, 1.33507967e-01f,
  -1.76080033e-01f, 2.41474167e-01f, -1.83852375e-01f, -1.13778748e-02f, -1.85542420e-01f, -2.67257318e-02f, 3.37668598e-01f, -1.95333079e-01f, -9.77586582e-03f, 2.80718729e-02f,
  8.03252980e-02f, 8.37587342e-02f, -1.16815791e-01f, -8.58189762e-02f, -3.60175855e-02f, 7.90608972e-02f, 3.13737035e-01f, -1.20049194e-01f, -1.63011514e-02f, 1.00336201e-01f,
  5.45937903e-02f, 3.90719026e-02f, 6.73083216e-02f, -9.42656696e-02f, 5.35409674e-02f, 6.93583935e-02f, -6.85364455e-02f, -1.44758016e-01f, 8.83317515e-02f, -2.59728520e-03f,
  1.50219992e-01f, 1.69493303e-01f, -6.53331876e-02f, 2.22150669e-01f, 4.85890098e-02f, 2.37458840e-01f, 1.29257366e-01f, 9.03108250e-03f, 1.69235334e-01f, -1.29268318e-01f,
  -2.40869442e-04f, -7.59158358e-02f, 2.74449238e-04f, -4.01689112e-02f, -1.12926565e-01f, -5.41252233e-02f, 6.12922423e-02f, -1.36306286e-01f, 6.54374808e-03f, 1.13126390e-01f,
  -2.72032209e-02f, -7.45356381e-02f, 1.01577520e-01f, 1.36786193e-01f, -3.42439264e-02f, 1.19196717e-02f, -1.63248479e-01f, 3.72905433e-01f, 1.36716604e-01f, 2.57729620e-01f,
  8.82409438e-02f, -1.01166181e-01f, 3.61764312e-01f, 1.82075039e-01f, 1.13325343e-01f, -2.77784318e-01f, -3.54123712e-01f, -3.76873910e-01f, 9.90791805e-03f, -1.52897596e-01f,
  -1.96383223e-01f, -1.39519140e-01f, 2.79557765e-01f, -2.70167962e-02f, 1.28501579e-01f, -3.92008573e-02f, -1.27871633e-01f, 1.71865553e-01f, 1.92100883e-01f, 9.27850511e-03f,
  -2.33283699e-01f, -4.07171585e-02f, -1.85136288e-01f, 3.22344869e-01f, 5.05490676e-02f, -2.30024103e-02f, 9.52596143e-02f, -1.12986088e-01f, 4.82270531e-02f, 5.16876243e-02f,
  7.17851520e-02f, 5.00421897e-02f, -1.98139265e-01f, 1.05065331e-02f, -3.07574153e-01f, -5.81877902e-02f, 7.11470023e-02f, 4.13365848e-02f, -1.43965691e-01f, 2.30374381e-01f,
  5.20266518e-02f, 5.83602637e-02f, -2.86212891e-01f, -4.06800136e-02f, -1.17904488e-02f, 1.74744055e-01f, 3.12881023e-02f, 2.61481732e-01f, -3.09412718e-01f, -1.24606982e-01f,
  -1.76858548e-02f, 7.87293836e-02f, -1.56324774e-01f, 4.41942923e-02f, -1.41705364e-01f, -2.14463890e-01f, 2.20553547e-01f, 1.11450598e-01f, 8.18010792e-02f, -2.74329424e-01f,
  -1.69217870e-01f, -1.89844757e-01f, -3.21845175e-04f, -2.90962517e-01f, -7.70861357e-02f, -1.16073824e-01f, 1.78390861e-01f, -1.07777476e-01f, -1.54894620e-01f, -3.30870077e-02f,
  7.97497183e-02f, 2.19733994e-02f, -6.00939170e-02f, -1.43345729e-01f, 5.16020119e-01f, -4.33050692e-02f, -1.87178627e-01f, 9.26268995e-02f, -8.36754292e-02f, 7.75347790e-03f,
  1.05398677e-01f, 3.70644853e-02f, 4.66580465e-02f, 7.42980093e-02f, 6.41991794e-02f, -7.66610429e-02f, -3.23325843e-02f, -8.79005622e-03f, -4.26514298e-02f, 8.10989738e-02f,
  -1.16840308e-03f, 3.84734683e-02f, 5.99387698e-02f, -6.55782446e-02f, 1.43877774e-01f, 1.00947484e-01f, 1.42223269e-01f, -6.98734149e-02f, 7.67157972e-02f, -1.48434415e-01f,
  -3.17718089e-02f, -1.08743161e-02f, -3.60717475e-02f, -6.73477724e-02f, 1.08716495e-01f, 1.29218385e-01f, 1.56104276e-02f, -1.24098755e-01f, -7.83565268e-02f, 1.65944055e-01f,
  2.68554240e-02f, -1.19639322e-01f, -3.65263075e-02f, 1.11789526e-02f, 3.80348861e-02f, 1.62538156e-01f, -1.48586631e-01f, -9.08979177e-02f, -7.92950392e-02f, 1.91818833e-01f,
  -7.13208914e-02f, -4.69756834e-02f, -4.35575582e-02f, -1.03594340e-01f, -1.20816037e-01f, 4.73594181e-02f, 1.55621385e-02f, -1.58107907e-01f, -1.01959884e-01f, 3.05031747e-01f,
  -3.53773713e-01f, 7.56702051e-02f, 8.82556736e-02f, -7.79928192e-02f, 2.07892582e-01f, 2.20306024e-01f, -1.38988838e-01f, 2.59425581e-01f, -1.02794081e-01f, -1.69702739e-01f,
  3.17789949e-02f, 1.01576438e-02f, 1.09055400e-01f, -3.96537594e-02f, -4.78645787e-02f, -5.84211349e-02f, -2.76359711e-02f, -1.92420319e-01f, 1.04506142e-01f, -2.50271503e-02f,
  1.35349110e-02f, 1.85130090e-02f, 3.65418196e-02f, 6.23795912e-02f, 1.30725084e-02f, 4.97223623e-02f, 1.19371831e-01f, 3.43851596e-02f, -2.48251900e-01f, -5.09743914e-02f,
  -9.30813402e-02f, -1.57534964e-02f, 1.12061903e-01f, 2.81134278e-01f, -7.60711059e-02f, 4.79100198e-02f, 1.24440201e-01f, 2.27491632e-02f, -1.62378430e-01f, -2.14790732e-01f,
  9.96496975e-02f, 1.82230137e-02f, 1.20241158e-01f, -1.84021786e-01f, -1.27523050e-01f, -9.30207595e-02f, 2.01964408e-01f, -9.22892243e-04f, 1.91781216e-03f, -4.46356796e-02f,
  7.31967948e-03f, 1.38625696e-01f, 1.54999122e-01f, -3.15498024e-01f, -8.47198367e-02f, 1.57812163e-01f, -3.28334272e-02f, 1.24636702e-01f, 1.04339682e-01f, -2.45905705e-02f,
  -1.71112537e-01f, 2.66513824e-01f, -2.85137177e-01f, 8.99646357e-02f, 3.24802577e-01f, -1.43041283e-01f, 1.73634320e-01f, 1.17761359e-01f, 1.86919734e-01f, -1.02184922e-01f,
  1.90329216e-02f, -3.90503615e-01f, 5.80945760e-02f, -3.10540646e-02f, 2.67657507e-02f, -1.03360862e-01f, 5.74145466e-03f, 1.83264136e-01f, 8.12714454e-03f, 1.03285104e-01f,
  2.32512467e-02f, 3.21478136e-02f, 1.19017372e-02f, 9.65286046e-03f, -5.58746494e-02f, -9.04774442e-02f, 1.09224074e-01f, -1.26452908e-01f, 7.34113678e-02f, -1.14729583e-01f,
  2.69738515e-03f, -5.93794435e-02f, -1.35953993e-01f, 1.57869339e-01f, -1.56452209e-01f, 5.87927736e-02f, -1.33895785e-01f, -1.14590153e-01f, -1.27419634e-02f, 1.42023927e-02f,
  1.75443515e-01f, -1.58453524e-01f, 5.05867042e-02f, -6.33969530e-02f, -2.48133600e-01f, -3.48413736e-02f, 1.87408198e-02f, -1.69456378e-02f, -2.66447254e-02f, -2.13091820e-01f,
  -8.15119520e-02f, 5.81749389e-03f, -4.48260866e-02f, 2.00496927e-01f, -5.85008301e-02f, -1.40721485e-01f, -1.99298207e-02f, -1.30421534e-01f, -1.95035543e-02f, 4.14797012e-03f,
  5.10075353e-02f, -4.37117293e-02f, -1.37727171e-01f, -1.63521484e-01f, 5.30852005e-02f, 2.11949885e-01f, 3.19677638e-03f, -3.89731303e-02f, -1.47224432e-02f, -1.46664560e-01f,
  2.69084685e-02f, 1.36522561e-01f, 2.59025395e-01f, 1.38188541e-01f, -3.33294004e-01f, 2.00207055e-01f, -1.19420744e-01f, -1.85737938e-01f, -7.31536672e-02f, -1.23460867e-01f,
  2.97743268e-02f, -1.52451530e-01f, -7.90606290e-02f, -6.32105768e-02f, -3.30767520e-02f, -1.71933666e-01f, -8.18241984e-02f, -8.59120563e-02f, -5.02581783e-02f, 6.09296514e-03f,
  -8.17213655e-02f, 1.04383260e-01f, 1.77115668e-02f, -6.87101111e-02f, -3.73620316e-02f, -7.28479326e-02f, -2.40764946e-01f, -7.37351254e-02f, 2.23989367e-01f, 1.41073288e-02f,
  3.46155912e-02f, 1.79264367e-01f, 9.29421932e-02f, 9.68605932e-03f, 2.39938367e-02f, -1.51353002e-01f, -2.43286714e-01f, 9.68090594e-02f, -6.38302565e-02f, 7.21520633e-02f,
  -7.14078173e-03f, -1.92328766e-01f, -7.59790763e-02f, 1.18047342e-01f, 4.82026301e-02f, -2.26869024e-02f, -1.26913980e-01f, -1.55757293e-01f, 2.79749483e-01f, -8.72694328e-02f,
  4.01680171e-02f, -9.48078483e-02f, 1.02239333e-01f, -1.75794408e-01f, 2.09998749e-02f, 1.51998028e-01f, 7.29331598e-02f, -6.56813085e-02f, -1.70418188e-01f, -7.76278451e-02f,
  8.88904482e-02f, 2.85441458e-01f, 4.46759552e-01f, 4.62549239e-01f, -4.40983400e-02f, 2.05648988e-02f, 3.04311991e-01f, -1.45787776e-01f, -1.90070257e-01f, 3.86441350e-02f,
  6.87076524e-02f, 9.39787701e-02f, 2.57238578e-02f, -1.03509322e-01f, 1.86378900e-02f, 1.00624338e-01f, -4.65844162e-02f, -1.90753788e-01f, -1.54948056e-01f, -2.34405641e-02f,
  4.15104330e-02f, 1.66864932e-01f, -1.07619770e-01f, -6.31972309e-03f, 1.04745114e-02f, -8.64731446e-02f, 1.32219076e-01f, 8.99813101e-02f, -2.16435045e-01f, -2.54917014e-02f,
  1.12195969e-01f, -4.36391532e-02f, 5.89503013e-02f, -1.71495631e-01f, 3.13951001e-02f, 1.03015266e-02f, 3.45484689e-02f, -2.20217602e-03f, -2.69366354e-01f, 3.70361730e-02f,
  -3.97603363e-02f, -3.16066682e-01f, 5.83384233e-03f, -1.41314968e-01f, -1.09324902e-01f, -2.86788464e-01f, 2.56123729e-02f, -3.00765097e-01f, 1.80639535e-01f, 1.23679370e-01f,
  9.11325142e-02f, -1.89791650e-01f, 1.42811045e-01f, 7.64054582e-02f, 2.24489406e-01f, 2.93724220e-02f, -3.51313710e-01f, -1.25494704e-01f, -7.26137012e-02f, 2.36091003e-01f,
  -3.90559323e-02f, 3.06426316e-01f, 1.05194695e-01f, 4.23405528e-01f, 2.44411692e-01f, -2.53404956e-02f, -2.11485907e-01f, -9.48555842e-02f, -6.87792078e-02f, -1.07328355e-01f,
  -1.71129987e-01f, -1.12502396e-01f, -1.04132295e-01f, 5.02242111e-02f, -2.45764256e-01f, -9.54057202e-02f, -2.31584623e-01f, 5.26568741e-02f, -2.72106588e-01f, 3.02901585e-02f,
  8.65903124e-02f, -4.25217524e-02f, 1.28352478e-01f, 1.34196999e-02f, -2.23910943e-01f, 3.88225261e-03f, -1.51875215e-02f, 2.41493098e-02f, 3.75506356e-02f, -1.93009213e-01f,
  -3.28370705e-02f, 1.57754660e-01f, -1.19600400e-01f, -2.11221576e-01f, 2.52826095e-01f, -3.38488780e-02f, -1.33177666e-02f, -1.33333942e-02f, -1.22863553e-01f, -2.96562999e-01f,
  1.08681363e-03f, 2.85414215e-02f, 1.61305860e-01f, -1.81346819e-01f, 2.13821173e-01f, 4.27419037e-01f, -5.44700474e-02f, 1.83838546e-01f, -9.02279690e-02f, 1.25498742e-01f,
  -5.49464673e-02f, 5.78857996e-02f, -2.35862195e-01f, 8.97966400e-02f, -4.42489088e-02f, 4.45396751e-02f, 1.46109322e-02f, -1.41491756e-01f, 4.54331934e-02f, 3.33407730e-01f,
  1.89501926e-01f, -1.59203649e-01f, 3.32336873e-02f, -8.07805657e-02f, -3.10126930e-01f, -1.79564387e-01f, -9.55161229e-02f, -2.86147952e-01f, 4.20234688e-02f, 1.76267937e-01f,
  3.56893897e-01f, -4.45854515e-01f, -2.49722704e-01f, -9.52320620e-02f, 2.23296344e-01f, 2.19931558e-01f, 4.39911382e-03f, 1.79848239e-01f, 1.81610480e-01f, -3.48040536e-02f,
  1.11533776e-01f, 4.66227159e-02f, 1.63875893e-02f, -1.14952073e-01f, -1.67453326e-02f, -1.45354331e-01f, -1.42838836e-01f, -4.60683480e-02f, 9.19842646e-02f, 2.53112260e-02f,
  -7.40527958e-02f, -7.65181556e-02f, -1.16035193e-01f, 6.71103969e-02f, -3.43749709e-02f, 5.14115021e-02f, 3.35770939e-03f, -1.27186105e-01f, -1.77378342e-01f, 7.73084611e-02f,
  1.44658640e-01f, 6.07549027e-02f, 5.51086944e-03f, 1.60748079e-01f, 1.52383909e-01f, -2.00615078e-01f, 1.38782293e-01f, 5.47429472e-02f, -2.34485492e-01f, 1.31669298e-01f,
  2.12198243e-01f, -1.07343264e-01f, -4.83131409e-02f, -2.82236040e-01f, -1.47523612e-01f, 7.14974850e-03f, 6.35412857e-02f, -1.18588291e-01f, -1.43520176e-01f, -6.12182431e-02f,
  1.94550067e-01f, 8.83605182e-02f, 1.51722938e-01f, -5.84451891e-02f, -5.99960200e-02f, 2.75383722e-02f, -1.33841252e-02f, 2.12048054e-01f, 1.91091180e-01f, 1.28973559e-01f,
  -1.20496161e-01f, 4.99085784e-01f, -2.11964011e-01f, 2.21722964e-02f, 9.08692703e-02f, 3.90531957e-01f, 8.94006416e-02f, -2.22270396e-02f, 6.52039796e-03f, 1.11442711e-03f,
  1.37436748e-01f, -2.97478884e-01f, 2.88104564e-01f, -9.55388919e-02f, 2.25656152e-01f, -9.16402414e-02f, 2.44475648e-01f, 4.99251708e-02f, 8.21449086e-02f, 2.56501645e-01f,
  2.09936919e-03f, 4.22724560e-02f, 1.95363805e-01f, 8.32425430e-02f, 3.82763147e-02f, 1.90946624e-01f, -2.49134172e-02f, 8.22555721e-02f, 2.71762554e-02f, 9.06587578e-03f,
  8.57263282e-02f, 1.68377519e-01f, 6.36385605e-02f, -6.31340891e-02f, 8.35988522e-02f, 6.23224154e-02f, 4.32611480e-02f, 1.67210832e-01f, -2.58293049e-03f, 1.95811927e-01f,
  -2.43895501e-02f, 3.07845801e-01f, 9.18190852e-02f, 1.73517942e-01f, 2.68082112e-01f, 4.97759581e-02f, 7.63628408e-02f, -1.38787225e-01f, -8.74832645e-02f, 3.04024350e-02f,
  -4.22379449e-02f, -1.30446896e-01f, 6.43409416e-02f, -2.14874819e-01f, 1.00260369e-01f, 1.51780933e-01f, 7.28268474e-02f, 3.22687402e-02f, 1.12347834e-01f, 2.28396822e-02f,
  -1.01888053e-01f, 1.49132162e-01f, 2.92012319e-02f, 4.32618827e-01f, -8.28497559e-02f, 1.64431185e-01f, -6.96603507e-02f, -1.05520085e-01f, 2.54192710e-01f, -3.88784707e-01f,
  2.83886999e-01f, -1.70798376e-01f, -5.25009558e-02f, -2.02083826e-01f, 2.68866271e-01f, -2.38107786e-01f, 2.29919195e-01f, -1.72161400e-01f, -2.79832900e-01f, -1.86287183e-02f,
  -1.07086934e-02f, -1.51073620e-01f, -2.30569635e-02f, 1.11856852e-02f, 6.03491664e-02f, -1.93076789e-01f, 6.80585429e-02f, -4.00546119e-02f, 9.84668508e-02f, -7.55059943e-02f,
  2.17524953e-02f, 2.75731999e-02f, 1.85947248e-03f, 7.19553307e-02f, 5.11468425e-02f, -5.46098538e-02f, -4.46721613e-02f, 4.62374575e-02f, 6.02813438e-02f, -6.84245750e-02f,
  3.73092107e-03f, -6.31817579e-02f, -4.35991436e-02f, -2.18836203e-01f, -2.21381262e-02f, -1.19016595e-01f, -9.80278626e-02f, 1.57779828e-01f, -1.18886502e-02f, 1.53196147e-02f,
  -1.49580926e-01f, -1.66815706e-02f, -1.24262437e-01f, -6.85029551e-02f, 9.69330892e-02f, -8.15549791e-02f, 8.36536735e-02f, 1.15134016e-01f, -5.21905944e-02f, 2.27980316e-02f,
  -7.35594928e-02f, 3.27643543e-01f, -2.52581924e-01f, -1.75898410e-02f, 1.40955806e-01f, 4.08652797e-02f, 9.30588469e-02f, 5.63628366e-03f, 1.14735700e-01f, 7.62274489e-02f,
  -1.06482685e-01f, 2.89014578e-01f, -3.75544280e-01f, 3.86757612e-01f, 7.16349781e-02f, -5.16499095e-02f, -6.19405806e-02f, 2.35296473e-01f, -1.58844247e-01f, -2.13670507e-01f,
  -1.93962783e-01f, 1.98109433e-01f, 3.87438685e-02f, -1.22179724e-01f, -1.08384283e-03f, -6.26588836e-02f, -9.55731198e-02f, -8.49938616e-02f, -1.02215193e-01f, -1.56605914e-01f,
  -4.61662225e-02f, 3.13863307e-02f, -1.72979891e-01f, -7.41154253e-02f, 5.96005470e-02f, -1.33355454e-01f, -2.91373152e-02f, 2.06119493e-02f, -9.54708904e-02f, -1.29209742e-01f,
  -1.08990856e-01f, -1.54913947e-01f, -7.61404634e-02f, -4.47799005e-02f, -1.61020947e-03f, 2.84978617e-02f, -6.51460513e-03f, 1.07793748e-01f, -1.24606751e-01f, 1.92148425e-02f,
  -1.71963975e-01f, -3.40640098e-01f, -3.89254726e-02f, 1.83955222e-01f, 1.84621990e-01f, -3.79114330e-01f, -3.73879895e-02f, -5.56253195e-02f, 2.39500910e-01f, -3.59441787e-02f,
  -9.45358425e-02f, -1.14836685e-01f, 3.74877691e-01f, 2.27436379e-01f, 9.92040709e-02f, -2.93089926e-01f, -1.93016246e-01f, -2.53076069e-02f, 7.06325024e-02f, 1.71738118e-01f,
  8.98517594e-02f, 8.84728655e-02f, 2.21137062e-01f, 1.84271649e-01f, -2.25911085e-02f, 1.12557709e-02f, 1.25484467e-01f, 2.40800753e-01f, 1.28100559e-01f, 8.12416673e-02f,
  1.17983771e-02f, 1.20652199e-01f, -1.34833634e-01f, -3.67289245e-01f, 6.27332702e-02f, -1.21367900e-02f, -8.95437896e-02f, 4.43105325e-02f, -1.52013630e-01f, -1.41901851e-01f,
  5.05534150e-02f, -7.52362087e-02f, 4.03198637e-02f, 5.71881793e-03f, -5.20648435e-02f, 3.72278877e-02f, -3.80778834e-02f, -1.51313275e-01f, 1.68026146e-02f, -7.02078119e-02f,
  2.23999601e-02f, 6.71684444e-02f, -1.39266718e-02f, -4.33487557e-02f, 1.51911989e-01f, -3.48836482e-02f, 3.69842313e-02f, 5.94066940e-02f, 7.33098164e-02f, -1.47597864e-01f,
  1.10555172e-01f, 6.84308335e-02f, -2.37747300e-02f, -6.65033609e-02f, 1.44956186e-01f, 1.77108556e-01f, -6.18345439e-02f, 1.01950191e-01f, -1.90077633e-01f, 3.19567733e-02f,
  4.08001728e-02f, -7.23112300e-02f, -5.58334775e-02f, -4.95316740e-03f, -8.03825632e-03f, -1.68760180e-01f, -1.08761050e-01f, -5.26688881e-02f, 5.80424592e-02f, 2.26983517e-01f,
  8.26728195e-02f, -2.60769695e-01f, -7.80445188e-02f, 4.66961823e-02f, -8.31481740e-02f, 1.54732630e-01f, 2.83721108e-02f, -4.30441767e-01f, 1.10237263e-01f, 4.22159918e-02f,
  1.32537305e-01f, -5.02669096e-01f, -6.05633706e-02f, -2.76800059e-02f, 1.36521533e-01f, 8.05250332e-02f, 2.54319638e-01f, 2.90408522e-01f, -2.75533766e-01f, -1.63263351e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -2.04114672e-02f, 3.08400333e-01f, 5.28633334e-02f, 1.02643304e-01f, 6.52010590e-02f, 1.83671609e-01f, 2.12965399e-01f, 2.03525886e-01f, -7.05096647e-02f, 8.37661698e-02f,
  2.47182518e-01f, 1.86019734e-01f, 1.13670444e-02f, -1.32881775e-01f, 5.52807450e-02f, 3.69244695e-01f, -6.37250692e-02f, 9.19162668e-03f, 3.25861424e-01f, 1.25001803e-01f,
  -1.59935385e-01f, 7.82091841e-02f, 2.09302098e-01f, -1.14661381e-01f, 2.13914499e-01f, 3.79305959e-01f, -2.38721162e-01f, 2.84253955e-01f, 5.56686223e-01f, 1.10862613e-01f,
  -1.71201695e-02f, 1.15611233e-01f, -2.70122349e-01f, 4.63363498e-01f, 2.23161533e-01f, 1.41226605e-01f, -2.69262433e-01f, -1.72150448e-01f, 3.42707843e-01f, -1.63574323e-01f,
  1.29806608e-01f, 2.39458680e-01f, -2.42110461e-01f, 6.79141134e-02f, 2.79291689e-01f, 3.92207690e-02f, -6.36027828e-02f, -2.94477880e-01f, -3.82502347e-01f, 3.49229664e-01f,
  -1.66792914e-01f, -2.23650739e-01f, 1.74538746e-01f, -2.22585201e-01f, 1.82854816e-01f, -1.66239187e-01f, 2.59195417e-01f, 2.70730495e-01f, -7.32206926e-02f, 2.12887451e-01f,
  6.52426362e-01f, -3.03936899e-01f, 3.75203431e-01f, -9.76729114e-03f, -2.44863138e-01f, -2.01648280e-01f, 4.08391468e-02f, 2.90221870e-02f, 1.88839212e-01f, 1.15684167e-01f,
  3.48739535e-01f, 7.90294409e-02f, -2.54171103e-01f, 4.93630581e-03f, 3.13815139e-02f, -2.21522935e-02f, -4.21128375e-03f, -2.29511335e-01f, -1.72678032e-03f, 1.03317000e-01f,
  1.96682978e-02f, 1.26902327e-01f, 1.70628339e-01f, 1.19530261e-01f, 2.73593813e-01f, 1.95475727e-01f, 7.71595240e-02f, -1.50813147e-01f, 4.02026296e-01f, -2.03939900e-01f,
  8.66323411e-02f, -4.44081165e-02f, -1.27546210e-03f, 5.21421671e-01f, 2.46796444e-01f, 5.41016385e-02f, 3.89191881e-02f, 1.76696122e-01f, -1.47051528e-01f, 9.60063636e-02f,
  -2.26080678e-02f, -1.70326997e-02f, 2.56996583e-02f, -1.24474771e-01f, -2.15174351e-02f, -2.97706813e-01f, -4.35420126e-02f, 6.00020230e-01f, 7.06466287e-02f, -4.34971482e-01f,
  2.66328473e-02f, 4.22676839e-03f, -6.08784035e-02f, 1.92361578e-01f, -7.70820305e-02f, -2.19513640e-01f, -2.39046082e-01f, 2.66113639e-01f, 2.22678959e-01f, 2.49440013e-03f,
  2.82430172e-01f, 3.86050075e-01f, 2.23602593e-01f, 2.74560690e-01f, 2.60808557e-01f, 1.28410086e-01f, -3.95804532e-02f, -3.03934570e-02f, -1.01173244e-01f, 2.33723924e-01f,
  -1.22400664e-01f, -4.26969528e-02f, 1.14793696e-01f, -1.40162826e-01f, 9.52904224e-02f, 3.84741873e-02f, -3.60858180e-02f, 1.52212054e-01f, 2.49836907e-01f, -5.10004796e-02f,
  -1.48155158e-02f, -1.88440233e-01f, 9.61680114e-02f, 4.61771823e-02f, -4.66586314e-02f, -1.41466573e-01f, 3.59400272e-01f, -3.55154872e-02f, 1.37121409e-01f, 8.31123963e-02f,
  1.68426871e-01f, -1.37202352e-01f, 3.29024419e-02f, 4.89412807e-02f, -2.05211043e-01f, -3.14793199e-01f, 2.44130552e-01f, -1.86336309e-01f, -3.45022208e-03f, 3.92465480e-02f,
  1.05727166e-02f, 1.75762195e-02f, 1.84120893e-01f, -2.33762711e-01f, 2.05896422e-01f, 1.14822999e-01f, 1.20068826e-02f, -3.54952477e-02f, -2.11347044e-02f, -1.63398653e-01f,
  2.26893574e-01f, -1.42963648e-01f, -1.88434884e-01f, 1.44443780e-01f, -9.06859711e-02f, 9.75817814e-02f, 1.00399502e-01f, -1.00556061e-01f, 2.70977437e-01f, 3.70064825e-01f,
  -1.57322749e-01f, 3.07931215e-01f, -5.37730753e-01f, -3.44195724e-01f, 1.57145247e-01f, 3.23570281e-01f, -1.12189233e-01f, 5.48169792e-01f, 2.42248386e-01f, 2.50206202e-01f,
  -4.48333740e-01f, 1.04938760e-01f, 2.43972674e-01f, 1.74645707e-01f, 1.58741817e-01f, 2.91393876e-01f, 3.96636933e-01f, 1.93560153e-01f, 6.25766814e-02f, 2.98240989e-01f,
  1.15872294e-01f, 1.14980854e-01f, 7.13896155e-02f, 1.66581944e-01f, 1.10719398e-01f, 8.63580853e-02f, 2.18163759e-01f, 8.03655162e-02f, 3.00616473e-01f, 2.89395064e-01f,
  3.00876439e-01f, 4.43676323e-01f, 1.86019033e-01f, 6.93030283e-02f, 2.61944592e-01f, 1.98242798e-01f, 2.49524072e-01f, -1.07983939e-01f, 3.60928148e-01f, -3.35565597e-01f,
  -1.18023947e-01f, -2.16225177e-01f, -2.58991987e-01f, -3.79453637e-02f, 1.93684533e-01f, -3.35877776e-01f, -8.42188448e-02f, -1.92381844e-01f, -4.71463390e-02f, 7.96086714e-02f,
  -2.57920891e-01f, 2.34734580e-01f, -1.02005653e-01f, -3.03693026e-01f, 7.18853250e-02f, -3.58080506e-01f, 2.75356144e-01f, -2.63158530e-02f, -1.51466414e-01f, 1.43126026e-01f,
  2.68672228e-01f, -6.31002486e-01f, -2.40045622e-01f, -8.61864462e-02f, 2.21324041e-01f, 6.82948768e-01f, 1.50885120e-01f, 4.04297747e-02f, 9.59072188e-02f, 3.65498602e-01f,
  8.64152372e-01f, 4.97052312e-01f, -5.10384738e-01f, 7.10197389e-01f, 4.14219916e-01f, -2.82028288e-01f, 2.22466126e-01f, 3.59218925e-01f, 9.38137770e-02f, 1.17900506e-01f,
  2.00607359e-01f, 1.34442747e-01f, 3.19518954e-01f, 2.85409689e-01f, 8.30359980e-02f, -8.38351343e-03f, 2.82873631e-01f, 3.25815380e-01f, 1.27028659e-01f, 1.96233958e-01f,
  8.53549987e-02f, 1.75452337e-01f, 2.22724617e-01f, 2.11379260e-01f, -1.40525326e-02f, 2.98262507e-01f, 1.19467191e-01f, 9.53877419e-02f, 8.56524259e-02f, 1.70951232e-01f,
  1.58908561e-01f, -1.71564400e-01f, 9.34042186e-02f, -1.03308246e-01f, 2.82046705e-01f, 1.75224021e-01f, 1.20901264e-01f, -2.97858834e-01f, -8.47242475e-02f, 4.85989064e-01f,
  1.07227542e-01f, 1.22437380e-01f, 8.44033882e-02f, 3.89926024e-02f, 1.06496684e-01f, 3.05050701e-01f, -4.25698996e-01f, -2.39094943e-02f, -2.03151554e-01f, 4.84408408e-01f,
  -2.99226455e-02f, -9.63639170e-02f, 4.52020653e-02f, -3.69634420e-01f, 8.99210349e-02f, 1.07265346e-01f, 1.05284132e-01f, 2.62885243e-01f, -5.11161909e-02f, 2.66525686e-01f,
  -1.36801139e-01f, -8.83388072e-02f, 1.80391327e-01f, 3.65504563e-01f, -4.50008661e-01f, 3.82439107e-01f, -1.97865851e-02f, 2.38537639e-01f, -5.21929622e-01f, 3.64219509e-02f,
  1.00843966e-01f, 2.63212323e-01f, 3.17807287e-01f, -2.23988652e-01f, 2.27524191e-01f, -1.50781870e-01f, 1.89603627e-01f, -8.87378976e-02f, 1.84982508e-01f, 2.90957719e-01f,
  2.38506570e-01f, 7.51989931e-02f, 6.63570464e-02f, 1.50507495e-01f, 1.16801254e-01f, 2.75050730e-01f, -1.78869162e-02f, -1.25446729e-03f, 1.85367912e-01f, 4.92170528e-02f,
  3.88469368e-01f, -2.89573465e-02f, 1.91735983e-01f, 9.32105035e-02f, 3.83843146e-02f, 2.12681800e-01f, -2.61637300e-01f, 1.53809562e-01f, -2.27801412e-01f, -1.63839087e-01f,
  -3.62786986e-02f, 4.00297582e-01f, 4.05184388e-01f, -6.56332314e-01f, 1.11072674e-01f, 2.04639554e-01f, 2.98618048e-01f, -2.39879683e-01f, -1.09897554e-01f, -2.81592429e-01f,
  3.89619291e-01f, 5.31122506e-01f, 2.07579106e-01f, -7.06167698e-01f, -3.28738034e-01f, 3.29012483e-01f, 4.84790280e-02f, 2.64958680e-01f, -2.49825660e-02f, 2.41920426e-01f,
  -2.91342527e-01f, 2.76061237e-01f, -2.34798849e-01f, 1.93492174e-01f, 3.85737956e-01f, 6.45469964e-01f, 7.82651156e-02f, 2.35597000e-01f, -9.41566750e-02f, 4.82681096e-01f,
  8.28140378e-02f, -4.61816102e-01f, 5.23842871e-01f, -4.33580786e-01f, 6.81710720e-01f, -1.76027138e-02f, 4.60577577e-01f, 3.12161177e-01f, -7.79267307e-03f, 3.61745767e-02f,
  -2.05813665e-02f, 5.59234619e-03f, 1.87925115e-01f, 1.06830239e-01f, -5.28946593e-02f, 5.15162468e-01f, 2.23595157e-01f, 1.12641498e-01f, 1.44926265e-01f, 1.18705414e-01f,
  1.46129891e-01f, 2.90874541e-01f, -1.75797328e-01f, 9.32192355e-02f, -1.02811076e-01f, 7.27517605e-02f, 1.46522656e-01f, 4.38675940e-01f, 4.37810943e-02f, -1.91261116e-02f,
  -4.81538177e-01f, 2.41726413e-01f, -3.48244399e-01f, -7.65632212e-01f, 5.09380735e-02f, -3.56489986e-01f, 3.27725679e-01f, -9.81752425e-02f, 2.69926369e-01f, -2.22503722e-01f,
  4.03562963e-01f, 1.89243462e-02f, -2.12074779e-02f, -1.43864369e-02f, 1.53970510e-01f, 1.11909859e-01f, 2.30243921e-01f, -8.93877447e-01f, -2.70205468e-01f, 3.32103729e-01f,
  -1.18849225e-01f, -9.97703988e-03f, 5.09931482e-02f, 5.88992238e-02f, -4.04400602e-02f, 6.27047777e-01f, -7.47142732e-02f, -3.53944115e-02f, 2.66835719e-01f, -1.65820867e-01f,
  -4.19892557e-03f, 1.10394001e-01f, -1.92994788e-01f, -4.60100882e-02f, -1.22773968e-01f, -6.86096996e-02f, -4.82121203e-03f, -1.55254334e-01f, -1.00935042e-01f, -7.38784522e-02f,
  3.72961089e-02f, -1.11716986e-01f, 3.35279107e-01f, -4.80192192e-02f, -1.17536699e-02f, 4.72258069e-02f, 3.69647630e-02f, 1.46266669e-01f, 9.62812230e-02f, -1.76067129e-01f,
  4.47401404e-02f, -8.77775848e-02f, 1.85022131e-01f, 1.68801844e-01f, 1.18991680e-01f, 2.08014652e-01f, 1.18410647e-01f, 8.05409923e-02f, 2.37777829e-01f, -2.91609555e-03f,
  2.94372559e-01f, -1.74191609e-01f, 2.08604008e-01f, -2.86097139e-01f, -1.19939327e-01f, -4.22788441e-01f, -1.94520712e-01f, 1.04823865e-01f, 1.15656026e-01f, 9.61884856e-02f,
  1.60309300e-02f, 1.28908068e-01f, 4.21252381e-03f, -6.44256771e-02f, 3.07588518e-01f, 2.49119643e-02f, 1.43176820e-02f, 1.06140733e-01f, -4.79346141e-02f, -3.95610631e-02f,
  1.13533646e-01f, 4.35297400e-01f, -4.40057248e-01f, -6.49949983e-02f, 1.81344345e-01f, -2.14386195e-01f, 6.42103478e-02f, 2.09044471e-01f, 9.37596485e-02f, 1.92484125e-01f,
  -4.32906002e-01f, 2.09667236e-01f, -5.43577492e-01f, 2.63608456e-01f, 4.56697553e-01f, 3.63574982e-01f, -2.32315704e-01f, 3.75734389e-01f, 1.17724635e-01f, 1.55926317e-01f,
  -7.81099260e-01f, -9.58721042e-02f, 3.83066237e-01f, -2.42775112e-01f, 2.81836003e-01f, 1.03190675e-01f, -5.55577502e-03f, -5.84328100e-02f, -1.69068635e-01f, -8.48153159e-02f,
  1.84051007e-01f, 2.05817237e-01f, -1.09565914e-01f, 1.04797132e-01f, 1.53017923e-01f, 5.09118289e-02f, 9.54536870e-02f, 2.70665586e-01f, 1.43868029e-01f, 2.23335758e-01f,
  7.31144398e-02f, 7.90473521e-02f, 4.86764759e-02f, 1.23897530e-01f, 1.67000696e-01f, 2.76827753e-01f, 1.11434966e-01f, -1.33340105e-01f, -2.61195912e-03f, 5.74855059e-02f,
  -1.86273426e-01f, -5.33615351e-02f, 2.47476086e-01f, -1.15715168e-01f, 1.46552458e-01f, -3.40181261e-01f, -1.40550166e-01f, -1.69831648e-01f, 1.80713594e-01f, -2.82201711e-02f,
  -1.87068626e-01f, -2.03906268e-01f, 1.71153337e-01f, 2.02066630e-01f, 2.24549085e-01f, -9.46608856e-02f, -1.08404711e-01f, 9.17029157e-02f, -2.10200980e-01f, 1.92809805e-01f,
  2.67331213e-01f, 2.34797925e-01f, 1.39392156e-03f, 3.88576746e-01f, 6.96675032e-02f, 8.71945769e-02f, -1.57575011e-02f, 3.29545319e-01f, 4.68197763e-01f, -3.11675340e-01f,
  2.43015155e-01f, -2.41470322e-01f, 5.73215894e-02f, -2.16531649e-01f, 6.88057899e-01f, 2.19948739e-01f, 5.77611849e-02f, 3.53892833e-01f, 6.46603201e-03f, -9.95755866e-02f,
  2.89978683e-01f, 1.32229283e-01f, -1.20618321e-01f, 5.72808869e-02f, 5.26690543e-01f, 2.05066115e-01f, -8.65052938e-02f, -1.02420062e-01f, 1.45623386e-01f, 7.48572797e-02f,
  2.28884414e-01f, -5.42271510e-02f, 4.30565894e-01f, 8.59092250e-02f, 3.10217589e-01f, 8.94368067e-02f, 3.28185052e-01f, 1.37110099e-01f, 2.32904390e-01f, 2.85270270e-02f,
  -4.36410569e-02f, -6.65669236e-03f, 6.30035996e-01f, 9.63455215e-02f, -8.79941434e-02f, 4.05831039e-01f, 5.99149525e-01f, -2.17900798e-02f, -6.61670417e-02f, -3.27118903e-01f,
  -1.79044202e-01f, -1.96232960e-01f, -1.34080067e-01f, -7.17173368e-02f, 1.80486023e-01f, -1.26834437e-01f, 9.73036513e-02f, 9.97596830e-02f, -2.64138654e-02f, 5.12553155e-01f,
  -1.41463652e-01f, 4.73807380e-02f, -1.30710036e-01f, 2.52091259e-01f, 5.39743481e-03f, 5.36065936e-01f, -1.93991780e-01f, 8.14130545e-01f, -4.22999322e-01f, 2.85907865e-01f,
  -3.71994555e-01f, -1.29647270e-01f, 7.58440912e-01f, -4.21981215e-01f, 3.85251313e-01f, -3.09396768e-03f, 5.12797952e-01f, -1.91698104e-01f, 2.74782002e-01f, -7.82989636e-02f,
  -1.40344828e-01f, 1.06019959e-01f, 2.43746359e-02f, 1.29423156e-01f, 2.86149532e-01f, 6.80295750e-02f, 2.96019018e-01f, 1.72041640e-01f, -1.18159264e-01f, 1.62400514e-01f,
  6.03762306e-02f, -4.06356668e-03f, 1.54596465e-02f, -9.43111628e-03f, 2.70096511e-01f, 9.40898899e-03f, 9.33841243e-02f, 2.28411574e-02f, 2.32645005e-01f, 1.26684561e-01f,
  1.25524178e-01f, 1.57159626e-01f, 2.05351323e-01f, -6.68039098e-02f, -7.90576190e-02f, -3.22054587e-02f, 2.31451929e-01f, -1.92677125e-01f, -1.41548082e-01f, 3.50472271e-01f,
  -4.39798599e-03f, 3.18958879e-01f, 2.21447244e-01f, 9.66048092e-02f, 1.28340885e-01f, 2.61944272e-02f, -2.85902973e-02f, -1.41205132e-01f, -8.29241648e-02f, 1.55668527e-01f,
  -1.49351716e-01f, -1.13025889e-01f, -1.84738889e-01f, 7.56997103e-03f, 1.21074893e-01f, -2.49825746e-01f, 2.94318050e-01f, -3.70554328e-02f, -2.30886005e-02f, -4.64895368e-01f,
  1.13690607e-01f, -3.81618619e-01f, 1.60804868e-01f, 6.24672413e-01f, -1.52574614e-01f, 1.72975481e-01f, 1.79291040e-01f, 4.03004140e-01f, 3.08652669e-01f, 7.59621441e-01f,
  1.32925555e-01f, 2.23248340e-02f, 4.98945147e-01f, -1.26590148e-01f, -6.97449669e-02f, 2.45251223e-01f, -2.75732880e-03f, -1.44811943e-01f, 2.55966950e-02f, -1.29823416e-01f,
  -1.97074249e-01f, -4.97645624e-02f, 4.58932012e-01f, 1.19649328e-01f, 9.11568031e-02f, -2.14780077e-01f, 1.22420684e-01f, 2.28928681e-02f, 1.26831681e-01f, 1.04853339e-01f,
  1.36833087e-01f, 8.47984105e-02f, 1.62913218e-01f, 1.10986449e-01f, -4.78545204e-03f, 1.19206913e-01f, 5.97366020e-02f, -7.62942508e-02f, 1.16704464e-01f, 1.62934270e-02f,
  3.58586550e-01f, -3.48616600e-01f, -3.82980257e-02f, -2.99956501e-01f, -2.48163745e-01f, -9.92537942e-03f, -1.61985353e-01f, -3.60414952e-01f, -2.14045897e-01f, -3.86475235e-01f,
  8.10648724e-02f, 1.01496033e-01f, -1.81949914e-01f, -1.27258927e-01f, 6.23953715e-02f, -2.24911869e-01f, 1.10305985e-02f, 1.62741482e-01f, -1.78539157e-01f, -2.29422808e-01f,
  8.92351381e-03f, 4.25583720e-01f, 1.49754748e-01f, 4.95832488e-02f, -7.88555071e-02f, 5.94629228e-01f, 1.78155243e-01f, 2.63625234e-01f, 8.62994418e-03f, 5.83218873e-01f,
  2.72315860e-01f, -2.56574988e-01f, 3.19861323e-01f, -4.46646474e-02f, -2.34104231e-01f, 3.52221817e-01f, -3.83738220e-01f, 1.06328256e-01f, 3.60451341e-01f, 2.57821560e-01f,
  3.38121235e-01f, 1.87100649e-01f, 1.57762721e-01f, 1.05064414e-01f, -5.11735864e-03f, 1.43209562e-01f, -1.36488741e-02f, 1.40328929e-01f, -7.87226781e-02f, 3.24799776e-01f,
  1.88848451e-02f, 7.18146712e-02f, 1.30612209e-01f, 1.73027501e-01f, 5.20560779e-02f, -1.30905872e-02f, -1.01965971e-01f, 2.26956263e-01f, 3.10073607e-02f, 1.10863350e-01f,
  8.87677888e-04f, 2.84731925e-01f, 3.11936349e-01f, -4.12384383e-02f, 1.08559981e-01f, -2.09580511e-01f, 1.15036286e-01f, 1.14312612e-01f, -3.92307639e-02f, -3.38411361e-01f,
  -9.89454165e-02f, 1.03255846e-01f, -6.62339702e-02f, -1.77136496e-01f, -1.32558405e-01f, 2.58124173e-01f, -6.08962663e-02f, 1.05906650e-01f, 5.35131991e-02f, -3.43255788e-01f,
  3.75804561e-03f, 3.63779038e-01f, 2.81323582e-01f, -2.55564988e-01f, -1.48837298e-01f, 1.32421916e-02f, 2.41447106e-01f, 1.21672511e-01f, -3.50605557e-03f, 2.29551405e-01f,
  1.70894563e-01f, -1.93752572e-01f, 5.18473327e-01f, 3.85634363e-01f, 1.77972168e-01f, 2.36840211e-02f, -3.16638529e-04f, -2.39690393e-01f, 1.74056441e-02f, 4.40047592e-01f,
  1.30470321e-02f, 2.65076011e-01f, 1.45560652e-01f, 3.95234413e-02f, 3.64045948e-01f, 3.01739305e-01f, 2.46983930e-01f, 5.95312603e-02f, 1.90714255e-01f, 3.40597719e-01f,
  3.78177017e-01f, -1.05393581e-01f, 1.73077345e-01f, 1.40413210e-01f, 8.12876374e-02f, 2.41367593e-01f, 2.23730907e-01f, 1.07637256e-01f, 2.18951136e-01f, 1.67757615e-01f,
  -7.56882206e-02f, 2.88138837e-01f, 1.16462082e-01f, 1.71174064e-01f, 2.82541186e-01f, 1.83429927e-01f, 1.90899014e-01f, -2.82500178e-01f, -4.83434886e-01f, -6.35968819e-02f,
  -1.99450240e-01f, -4.56867218e-01f, -9.44496132e-03f, -2.13010252e-01f, 1.33445993e-01f, 3.97474140e-01f, 8.11904147e-02f, 8.42919946e-02f, 5.82720280e-01f, -1.19409658e-01f,
  -1.86100379e-01f, 1.90861933e-02f, -2.94280738e-01f, -1.34020140e-02f, 2.30292335e-01f, 7.19791502e-02f, -3.28671694e-01f, 1.71048328e-01f, -8.31020437e-03f, -2.55036861e-01f,
  1.01659849e-01f, 6.56558052e-02f, 3.04640885e-02f, 1.45841375e-01f, -4.43852454e-01f, -3.48804265e-01f, -3.55787545e-01f, 2.49392584e-01f, 1.11605145e-01f, 4.25567955e-01f,
  -4.65726435e-01f, 4.20450605e-02f, 1.07228540e-01f, 5.61374128e-01f, -8.15969288e-01f, 5.88953830e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  3.90903026e-01f, 1.44582987e-01f, 1.67471364e-01f, 5.00321127e-02f, 3.10294390e-01f, 3.16890419e-01f, 2.88681328e-01f, 1.65821478e-01f, 2.07177535e-01f, 3.74231130e-01f,
  1.51248559e-01f, 4.40621562e-03f, 1.22244760e-01f, 4.06270176e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -1.12729959e-01f, -1.86106190e-01f, -2.76537240e-02f, -4.42372233e-01f, 1.71021670e-01f, -1.65256381e-01f, -4.90924083e-02f, 2.27696658e-03f, 1.92019075e-01f, -4.73400593e-01f,
  -1.84022561e-01f, -1.83245823e-01f, -2.17399403e-01f, -2.31166720e-01f, 1.54130101e-01f, 2.39950031e-01f, -1.76405758e-02f, -2.32913360e-01f, 2.38083974e-01f, 8.26329831e-03f,
  1.75874829e-01f, 9.49293151e-02f, -5.64355910e-01f, 2.00056151e-01f, 8.31861570e-02f, 1.38189167e-01f, -1.58416927e-01f, -1.10680029e-01f, 2.11295471e-01f, -8.29320699e-02f,
  7.54279271e-02f, 2.07610279e-01f, 4.25145999e-02f, -2.43177906e-01f, -9.55780521e-02f, 4.20218706e-01f, 4.73263919e-01f, -2.24136516e-01f, -1.41846731e-01f, -4.34302002e-01f,
  2.15768069e-01f, 3.11412543e-01f, 3.12851429e-01f, -1.88601196e-01f, 5.19712090e-01f, 4.62171167e-01f, -5.24665236e-01f, -2.81333476e-02f, 1.83603704e-01f, 2.26537600e-01f,
  -7.26624191e-01f, 1.62134901e-01f, 1.26996204e-01f, 1.46172985e-01f, 3.16315703e-02f, -2.22110860e-02f, -6.79433167e-01f, 2.85698235e-01f, -2.32461452e-01f, 6.57425523e-02f,
  3.13869685e-01f, 2.72852391e-01f, -2.65295178e-01f, -2.18281478e-01f, -3.45833451e-01f, 1.76464871e-01f, -4.10555452e-01f, 2.35151350e-01f, -5.78733683e-01f, 6.48296997e-02f,
  -3.92420679e-01f, -1.95700258e-01f, -1.83676511e-01f, 2.23247819e-02f, 1.75422281e-01f, -1.21560931e-01f, -2.72145718e-01f, -1.29519252e-03f, -5.52426696e-01f, -3.57282043e-01f,
  -1.93248734e-01f, -1.87046453e-01f, 4.28088486e-01f, 4.96856719e-02f, 1.93484619e-01f, 1.58574447e-01f, 4.00624052e-02f, -5.42323291e-02f, -4.02386561e-02f, 2.62091935e-01f,
  1.82019725e-01f, 2.37086818e-01f, -2.13279948e-01f, 9.90829915e-02f, -5.74633002e-01f, 1.77712843e-01f, 3.36916178e-01f, 3.25180978e-01f, 8.92573670e-02f, 8.54058862e-02f,
  -1.76005095e-01f, -5.48901498e-01f, -2.65626639e-01f, 2.29136929e-01f, -6.15306735e-01f, 6.24837428e-02f, -4.06692743e-01f, -3.21526192e-02f, 3.43474410e-02f, -5.74366152e-01f,
  -2.16381907e-01f, 2.13613942e-01f, -2.23084077e-01f, 4.27020818e-01f, -9.79831070e-02f, 2.65080184e-01f, 3.56965035e-01f, 2.83001717e-02f, 2.28018552e-01f, -7.35434175e-01f,
  -4.56995219e-01f, 4.83453184e-01f, -3.16635460e-01f, -4.09257680e-01f, 1.91932246e-01f, -3.06573093e-01f, -1.41815161e-02f, 3.61333311e-01f, -1.53206915e-01f, -1.02041557e-01f,
  1.86450526e-01f, -3.50510515e-03f, 3.53617698e-01f, -4.24561739e-01f, 3.16203862e-01f, -7.29708821e-02f, -2.96715885e-01f, 2.22446024e-01f, -1.43233150e-01f, -1.61595613e-01f,
  -1.33857042e-01f, 1.40288696e-02f, 1.82989195e-01f, -1.10998906e-01f, 2.39475414e-01f, -6.57511130e-02f, -5.62590420e-01f, 1.09223709e-01f, -1.25849694e-01f, 3.33810002e-01f,
  2.18911469e-01f, 5.39326817e-02f, -1.92610189e-01f, 3.05293381e-01f, 3.80046755e-01f, -4.00297850e-01f, 1.22011520e-01f, 1.43412724e-01f, 1.82171449e-01f, -8.35861638e-02f,
  -3.01556021e-01f, -5.67176104e-01f, 3.46235693e-01f, 3.83254617e-01f, 2.84455925e-01f, -3.74238461e-01f, 1.96522251e-01f, 2.67771840e-01f, 3.53309631e-01f, 5.20719647e-01f,
  -4.00565602e-02f, -3.08654696e-01f, -2.54309475e-01f, 1.03480339e-01f, -3.61159384e-01f, 2.77342238e-02f, -2.32111692e-01f, -1.51794389e-01f, -5.87075591e-01f, -5.00104189e-01f,
  -2.32052393e-02f, 6.14340246e-01f, 2.18203679e-01f, -4.05575745e-02f, 2.65434772e-01f, -6.94501251e-02f, -3.58632416e-01f, -8.25393200e-01f, 3.37840289e-01f, -6.33839905e-01f,
  -1.47032216e-01f, 2.79097617e-01f, -1.48227841e-01f, -6.82576895e-02f, 1.45900577e-01f, 3.37565511e-01f, -6.78079665e-01f, 2.56926626e-01f, 2.18967274e-01f, -1.91988647e-01f,
  1.17478266e-01f, 2.09255237e-02f, -2.95910865e-01f, -3.73242013e-02f, -3.56300890e-01f, 1.28269151e-01f, -1.22968018e-01f, -1.40488759e-01f, 3.02888844e-02f, -4.21525687e-01f,
  -1.99479610e-01f, -7.33976066e-02f, -1.24193870e-01f, -3.24463367e-01f, 9.21224430e-02f, 2.36617699e-01f, 2.30338685e-02f, 2.24146515e-01f, 1.26755029e-01f, 5.76960802e-01f,
  2.28837922e-01f, -1.43583447e-01f, 1.31734669e-01f, -2.65548438e-01f, 3.86841297e-01f, -2.82588154e-01f, -4.44270194e-01f, -4.87848550e-01f, -2.43046954e-01f, -2.30717093e-01f,
  5.35345376e-01f, 2.10135311e-01f, 3.49580914e-01f, 3.26103151e-01f, 3.60585809e-01f, -3.50828409e-01f, 3.93092841e-01f, 7.33730420e-02f, 3.52234095e-01f, -4.23434414e-02f,
  6.15931265e-02f, -2.57301815e-02f, -4.36844468e-01f, 2.71678656e-01f, -9.88109171e-01f, 4.02939409e-01f, -8.40046346e-01f, -2.97355652e-01f, -3.62437874e-01f, -1.79944247e-01f,
  3.45846534e-01f, 2.10410461e-01f, 2.64276177e-01f, -4.02831882e-02f, 4.85652611e-02f, -3.69199514e-01f, 1.95157766e-01f, 2.70097911e-01f, -1.83011264e-01f, -4.93239090e-02f,
  4.42653984e-01f, 1.30122034e-02f, -3.42454135e-01f, 1.46747977e-01f, -1.54473200e-01f, 2.32466847e-01f, 3.26055765e-01f, 2.61339009e-01f, 1.65780082e-01f, 6.19150326e-03f,
  -1.12245604e-01f, -1.06937163e-01f, -2.02172488e-01f, 2.41984934e-01f, 2.08766818e-01f, 1.57455564e-01f, -1.72373652e-01f, -1.14479465e-02f, 9.95388329e-02f, -2.98776865e-01f,
  -2.92457581e-01f, -6.10144258e-01f, -6.75371289e-02f, -6.90705419e-01f, 3.76354039e-01f, -4.55405176e-01f, -2.41933256e-01f, -2.96621144e-01f, 3.94537777e-01f, -4.25978839e-01f,
  -2.51252085e-01f, 1.67777464e-01f, -3.30625802e-01f, -2.15366945e-01f, -4.33856577e-01f, 5.52981853e-01f, 1.22506395e-01f, 2.35555336e-01f, 2.93869555e-01f, 5.84623933e-01f,
  -3.24869961e-01f, -1.75870821e-01f, -7.81664699e-02f, 3.55579913e-01f, 3.40168804e-01f, -2.07920164e-01f, -9.80465207e-03f, -2.14285925e-01f, 9.87357646e-02f, 1.32861212e-01f,
  -2.39669785e-01f, -1.30716907e-02f, 3.38306367e-01f, -6.61813468e-02f, 1.90314174e-01f, 2.39964858e-01f, -3.85452621e-02f, 1.96312353e-01f, -3.10120173e-02f, -8.28570604e-01f,
  1.06341712e-01f, -1.40973881e-01f, 1.12404488e-02f, 7.04747736e-02f, 2.05880180e-02f, 7.70696476e-02f, -3.55080403e-02f, -1.40610009e-01f, 9.45907906e-02f, -3.31759691e-01f,
  -8.67133439e-02f, -4.85223569e-02f, 3.07951540e-01f, -9.02479813e-02f, -1.48525476e-01f, 3.73305559e-01f, 4.69773933e-02f, 2.49861345e-01f, 8.87854397e-02f, -4.10066366e-01f,
  1.45385593e-01f, -1.13621399e-01f, -1.79319575e-01f, 2.42705066e-02f, 2.53544062e-01f, -1.37379259e-01f, -4.25038457e-01f, 1.70115337e-01f, 3.14841658e-01f, -3.98083478e-02f,
  1.77109316e-01f, 1.97087899e-01f, -1.60703823e-01f, 3.66738409e-01f, 4.99417707e-02f, -4.26973522e-01f, -1.38619155e-01f, 4.91198629e-01f, -2.25362644e-01f, 3.05110782e-01f,
  3.82051505e-02f, -2.48752728e-01f, -2.72917151e-01f, 5.18738180e-02f, -4.39066947e-01f, 5.48357785e-01f, 4.32101816e-01f, 4.42068696e-01f, -2.76700735e-01f, -3.90501499e-01f,
  -4.10488814e-01f, 3.52338552e-02f, -1.39236540e-01f, -3.84759605e-01f, 2.96180189e-01f, -4.91543055e-01f, -4.27424833e-02f, 2.85241783e-01f, 1.75291017e-01f, 3.98450464e-01f,
  -3.37658674e-01f, 1.48373559e-01f, 2.37835720e-01f, 3.82544309e-01f, 2.13674158e-01f, -4.76693213e-01f, 4.43998337e-01f, 5.83816692e-02f, -4.01359648e-01f, -1.93820909e-01f,
  -2.98548758e-01f, -3.76483619e-01f, 5.04236996e-01f, -1.44123193e-03f, 1.41514927e-01f, -1.40417233e-01f, 1.87676281e-01f, -2.96573371e-01f, 3.87409568e-01f, 6.89489126e-01f,
  5.12071609e-01f, -2.51839221e-01f, 1.47115633e-01f, 2.02965394e-01f, 3.56402338e-01f, 4.31827605e-02f, -1.02217339e-01f, 1.81971237e-01f, 3.94158304e-01f, -1.25372544e-01f,
  6.84964836e-01f, 1.07911371e-01f, -4.37502265e-01f, 2.62021005e-01f, 1.85719341e-01f, 4.91536051e-01f, -3.15896422e-01f, -7.26575777e-02f, 3.35582495e-01f, 6.37994468e-01f,
  4.39217031e-01f, 3.67598027e-01f, 1.46223530e-01f, -3.95768821e-01f, 1.71905085e-01f, -1.53212950e-01f, -6.41707122e-01f, 1.18757710e-02f, -5.18274903e-01f, -6.61806762e-01f,
  2.65618384e-01f, -2.37817854e-01f, -1.26741752e-01f, -2.01664910e-01f, 1.82704464e-01f, -3.92329037e-01f, -9.77370236e-03f, -9.36917841e-01f, 1.52207240e-01f, -9.86654758e-02f,
  2.42534444e-01f, -4.24143225e-01f, -2.23233208e-01f, -7.73761988e-01f, -3.97006750e-01f, -2.89769113e-01f, -1.61769435e-01f, 2.21715033e-01f, -2.13721976e-01f, -2.21020967e-01f,
  -3.52114469e-01f, -1.95114091e-01f, 1.54130742e-01f, -3.24935734e-01f, -1.19672455e-01f, -1.52796194e-01f, -2.30306253e-01f, -2.95119464e-01f, -1.24853164e-01f, -3.38909626e-01f,
  1.96068987e-01f, -1.76313788e-01f, -8.32717586e-03f, -1.89272836e-01f, -3.58843833e-01f, 7.58200362e-02f, -3.39745462e-01f, 1.67913496e-01f, -3.96137327e-01f, 2.99484491e-01f,
  3.08305621e-01f, 1.38743520e-01f, -4.73234355e-01f, -5.46636470e-02f, -7.22550690e-01f, 2.05734029e-01f, -2.45772913e-01f, -4.94981324e-03f, 1.04467422e-01f, 2.56024212e-01f,
  -1.30339369e-01f, 2.49204978e-01f, 3.67885500e-01f, -7.33282626e-01f, 2.97391593e-01f, -1.92283615e-01f, 1.31704226e-01f, -2.21904621e-01f, -1.11552127e-01f, -1.99106306e-01f,
  9.62260887e-02f, -7.48492405e-03f, -4.70495783e-02f, 1.18949354e-01f, -1.30220756e-01f, 4.13894832e-01f, 6.41072810e-01f, -3.91666532e-01f, 2.22900152e-01f, -8.32724273e-02f,
  -4.89271022e-02f, -6.94724917e-02f, -2.44804323e-01f, 5.10354459e-01f, -4.59909618e-01f, -4.17997628e-01f, 1.44160137e-01f, -2.33588845e-01f, 2.48774201e-01f, -2.68162843e-02f,
  9.00136773e-03f, -5.22147298e-01f, 7.19717741e-02f, -1.41441852e-01f, -1.15061313e-01f, -5.15150964e-01f, 6.92223132e-01f, 1.05086863e-01f, 4.22524124e-01f, 1.02929085e-01f,
  -5.64530306e-02f, 4.69269633e-01f, 1.14141874e-01f, 1.15887307e-01f, -8.70667771e-02f, 3.52467550e-03f, 2.54558101e-02f, 1.47771373e-01f, 2.93120146e-01f, 5.39162159e-01f,
  -2.86351204e-01f, 3.76479737e-02f, 1.34822605e-02f, -1.00578047e-01f, -6.52590320e-02f, -7.97411054e-02f, 1.25026315e-01f, 3.95969659e-01f, -6.90754056e-01f, 1.36420175e-01f,
  -3.33658844e-01f, -3.97354484e-01f, 3.26811492e-01f, -1.40548721e-01f, -9.90762636e-02f, 3.26424062e-01f, 2.43486747e-01f, -4.63202298e-02f, -3.75616461e-01f, 4.36994940e-01f,
  3.64487827e-01f, -7.26950228e-01f, -2.11967707e-01f, -3.89460117e-01f, 4.90963697e-01f, -1.39928564e-01f, 5.27060091e-01f, -4.40559357e-01f, 1.83244035e-01f, -5.53978562e-01f,
  -2.21321508e-01f, 4.56831723e-01f, 2.52815187e-01f, 2.67483950e-01f, -2.39984035e-01f, -2.16511518e-01f, 2.46787503e-01f, -4.41819578e-01f, -2.04766572e-01f, -5.00783384e-01f,
  -5.31722486e-01f, -8.36405337e-01f, 2.59491839e-02f, -2.15675235e-01f, 3.36859852e-01f, -3.90166938e-01f, 2.24524751e-01f, 4.62519497e-01f, 7.01926723e-02f, -4.83217090e-03f,
  2.35178292e-01f, 2.65642732e-01f, 2.23359689e-01f, 4.71039116e-01f, 1.06246136e-01f, 1.66212097e-01f, 7.05653206e-02f, 1.60511047e-01f, 3.65653895e-02f, 5.19099057e-01f,
  9.70098600e-02f, -7.47439981e-01f, 1.83209345e-01f, 4.07872558e-01f, 2.29718044e-01f, -2.50435978e-01f, -4.86202598e-01f, -1.92342132e-01f, 2.75272846e-01f, -4.75744307e-01f,
  -9.19839591e-02f, -5.43856844e-02f, 1.67334005e-01f, -6.00128174e-01f, 3.10373962e-01f, 3.04057747e-01f, 3.16397697e-02f, -2.35990938e-02f, -9.18223113e-02f, -1.83132142e-02f,
  -1.43152371e-01f, 5.45487106e-01f, 4.57491130e-02f, 3.85364920e-01f, -1.13181416e-02f, -3.15298319e-01f, 1.77910104e-01f, -3.30726862e-01f, 5.38387969e-02f, 4.44288164e-01f,
  1.48362011e-01f, 4.71101344e-01f, 3.91307808e-02f, -1.26842976e-01f, 7.55655050e-01f, -1.50276229e-01f, -1.97348997e-01f, -2.81593800e-01f, -6.92795217e-02f, -5.64471543e-01f,
  -6.12426460e-01f, 5.91225505e-01f, 5.37216842e-01f, 1.62767410e-01f, 3.70169431e-01f, -4.15148854e-01f, -3.66718948e-01f, -3.75892431e-01f, -2.85388082e-01f, 2.33125582e-01f,
  5.23453653e-02f, -3.08297724e-01f, 7.15071559e-02f, -2.30867296e-01f, -4.85593796e-01f, -1.51422307e-01f, -3.00713956e-01f, 2.28847880e-02f, 1.02644794e-01f, -3.41760591e-02f,
  -3.55458587e-01f, 4.86539602e-02f, 2.38678262e-01f, 2.56553460e-02f, 2.64283240e-01f, -1.17919721e-01f, -4.21256535e-02f, -4.76635359e-02f, 3.02048717e-02f, 1.14970088e-01f,
  1.90857947e-02f, 5.16678914e-02f, -2.51360714e-01f, -6.47337660e-02f, -2.23809421e-01f, -3.42133641e-01f, -3.56478423e-01f, 1.07630141e-01f, -3.78518403e-01f, -2.64661670e-01f,
  -3.31862599e-01f, -2.67922997e-01f, -2.28780463e-01f, 2.38821670e-01f, 4.03632045e-01f, -3.56273741e-01f, -1.04432322e-01f, -1.44294441e-01f, -1.51574552e-01f, 2.51769513e-01f,
  -3.18440497e-01f, 3.61835837e-01f, 4.78496671e-01f, 4.03679788e-01f, 1.60944015e-01f, -2.51773924e-01f, -3.25415879e-01f, -4.77503568e-01f, -4.95251536e-01f, 2.54711926e-01f,
  -7.39763498e-01f, -4.21494126e-01f, -2.36779422e-01f, 5.80226779e-01f, -1.51391029e-01f, -4.11554307e-01f, 1.85366385e-02f, -4.48251843e-01f, -2.22494587e-01f, -4.93716300e-01f,
  -4.89528269e-01f, 5.59742689e-01f, 3.15823287e-01f, 3.10400501e-02f, -1.80417225e-01f, 2.55542994e-01f, -9.69036222e-02f, 3.80383998e-01f, -2.21510142e-01f, 2.86782563e-01f,
  3.14792246e-01f, 3.64240944e-01f, 1.79745227e-01f, 1.49696961e-01f, 1.39036924e-01f, 2.29617313e-01f, -2.23551635e-02f, 2.49922737e-01f, 3.25047553e-01f, 2.14225546e-01f,
  -3.69796544e-01f, -2.73875117e-01f, 3.59121971e-02f, 2.64017105e-01f, 7.73634315e-02f, -3.54568809e-01f, 1.16618805e-01f, 1.28413245e-01f, 4.02477868e-02f, 2.91878432e-01f,
  2.79199153e-01f, 1.90509915e-01f, 1.33351147e-01f, 4.03407067e-01f, -4.91921119e-02f, -4.17753786e-01f, -2.30137080e-01f, -3.88110220e-01f, -7.75004745e-01f, -3.51893216e-01f,
  -2.24494562e-01f, 1.64111093e-01f, 9.42869484e-02f, -1.89483613e-01f, -2.88019896e-01f, -1.62562594e-01f, -3.72089267e-01f, -9.12106633e-02f, 2.35963106e-01f, 2.84064859e-01f,
  -3.76393758e-02f, -4.53374475e-01f, -5.27078092e-01f, 3.75836343e-01f, 2.67820865e-01f, 6.47159517e-02f, -1.22763462e-01f, -4.84368026e-01f, -1.45377040e-01f, 1.49832204e-01f,
  -4.52844441e-01f, -9.90458056e-02f, -1.89975023e-01f, 8.06125343e-01f, -5.81999645e-02f, -3.68355423e-01f, -6.01655245e-01f, -4.42664146e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.68438179e-02f, -7.74895847e-02f, -4.97436225e-02f, -1.11385323e-01f, -2.35620379e-01f, 3.26593332e-02f, 1.44355401e-01f, 9.71725583e-02f, 1.33453801e-01f, 1.42743871e-01f,
  -1.79018285e-02f, 3.73968184e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    