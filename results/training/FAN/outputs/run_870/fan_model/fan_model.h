/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.95597345e-01f, -1.42637298e-01f, -1.96341246e-01f, 1.58968464e-01f, -1.91192497e-02f, -1.34178594e-01f, -2.58465201e-01f, 2.49351058e-02f, 1.54848740e-01f, -7.44882599e-02f,
  -3.97778302e-02f, -3.01664583e-02f, 4.60492820e-02f, 5.24776168e-02f, -7.28165135e-02f, -1.10707119e-01f, -1.29848793e-02f, -5.21419235e-02f, 8.64338428e-02f, -6.51810132e-03f,
  7.89800510e-02f, 1.30394578e-01f, -7.34012127e-02f, 4.71775569e-02f, 2.00006187e-01f, 9.82696749e-03f, -2.93603148e-02f, 8.97061154e-02f, 7.27865240e-03f, 8.73273537e-02f,
  -2.54745454e-01f, -5.88921905e-02f, -6.49968311e-02f, -7.28776902e-02f, 1.24913314e-02f, 6.47220621e-03f, -1.09728962e-01f, 2.61257458e-02f, -2.35909391e-02f, -3.38913724e-02f,
  -4.48928736e-02f, -1.58858411e-02f, -9.21601523e-03f, 9.98644680e-02f, 5.01705185e-02f, 4.28495929e-02f, 1.20521642e-01f, 5.38953990e-02f, -4.56710234e-02f, -3.81777924e-03f,
  6.31537959e-02f, -3.21554951e-02f, -8.16760734e-02f, -8.78028199e-02f, 1.29614566e-02f, -6.72609285e-02f, -1.13255188e-01f, -6.33523390e-02f, -5.53820021e-02f, -1.50702804e-01f,
  -6.20387085e-02f, 2.14550877e-03f, 1.01363771e-01f, -1.32350326e-02f, 4.20061946e-02f, 7.07190633e-02f, 1.52900340e-02f, 3.45025584e-02f, 8.08938369e-02f, -1.36694368e-02f,
  1.41960429e-03f, -1.19562997e-02f, -6.76355585e-02f, -9.03435517e-03f, -1.56335831e-02f, -5.95458001e-02f, -2.61986423e-02f, -3.76446918e-02f, -9.83901974e-03f, 4.70485426e-02f,
  1.81289036e-02f, 6.61152601e-02f, -5.26600555e-02f, 7.48002529e-02f, 4.26287465e-02f, -2.78447233e-02f, 2.37387009e-02f, 2.06598509e-02f, 5.41601982e-03f, -5.23663545e-03f,
  -1.38352245e-01f, -2.35245731e-02f, -4.90463413e-02f, -1.76416412e-02f, -1.28303422e-02f, 1.09147364e-02f, -4.10947464e-02f, 1.02012437e-02f, 1.56777687e-02f, 1.11527098e-02f,
  7.66086057e-02f, 3.18796672e-02f, -7.48568997e-02f, 1.18090659e-01f, 6.92326389e-03f, 2.31283624e-02f, -5.47005869e-02f, 1.10981017e-02f, 5.57293110e-02f, 4.12641186e-03f,
  -1.63250044e-02f, -3.14583331e-02f, -1.63706556e-01f, -6.17647506e-02f, 3.99078615e-03f, -1.86056897e-01f, -2.18462989e-01f, -1.40348971e-01f, -2.84406275e-01f, -2.78924823e-01f,
  -8.50738660e-02f, -4.97339100e-01f, 1.66329101e-01f, -3.68543416e-02f, -6.97682202e-02f, -4.68050502e-03f, -3.62937450e-01f, -4.22555581e-02f, -1.12931482e-01f, -2.52078503e-01f,
  -1.17881276e-01f, 1.17434271e-01f, 2.95832574e-01f, 2.33093381e-01f, 6.96288347e-02f, -6.58595487e-02f, -1.04237199e-01f, 3.37866217e-01f, 3.29244107e-01f, 1.27403410e-02f,
  -1.70705050e-01f, -9.59023610e-02f, 1.19173512e-01f, 6.20906278e-02f, -1.55348405e-01f, 1.09450035e-01f, -2.73034014e-02f, -9.36692208e-02f, -1.30848318e-01f, -2.17436671e-01f,
  1.05931610e-01f, -1.26913324e-01f, 2.51693189e-01f, -4.83299829e-02f, 2.65390202e-02f, 5.76266311e-02f, -6.77099898e-02f, 7.61703029e-02f, -3.82886305e-02f, -5.40867273e-04f,
  -1.83298290e-02f, -4.75389510e-02f, -1.90802366e-02f, -2.40559131e-02f, -7.56046847e-02f, 2.86136959e-02f, -9.44590494e-02f, 1.62996024e-01f, 1.99862987e-01f, 1.89059265e-02f,
  -9.23403576e-02f, -1.50865853e-01f, 4.30317372e-02f, -2.42079943e-02f, 9.02272537e-02f, 8.63870829e-02f, -2.23566946e-02f, 6.80003166e-02f, 1.16738848e-01f, -1.28378332e-01f,
  -1.37871485e-02f, 8.22586101e-03f, -5.88694066e-02f, 3.40567827e-02f, -4.85984012e-02f, 2.73400247e-02f, -1.44006349e-02f, 1.55180199e-02f, 1.97175574e-02f, -2.80366577e-02f,
  3.49134654e-02f, 2.67480947e-02f, 3.74371037e-02f, -1.84783936e-02f, -4.40477543e-02f, 9.66300815e-03f, 1.06083956e-02f, -9.53714699e-02f, 9.74848568e-02f, -2.98148096e-02f,
  7.60409459e-02f, 8.84467363e-02f, -1.06168073e-02f, -2.51927078e-02f, 2.84214616e-02f, -1.26137557e-02f, -5.62785193e-02f, 3.31186876e-02f, -8.88211131e-02f, -1.25261083e-01f,
  3.61246094e-02f, 2.01951370e-01f, 4.93236221e-02f, 1.13307647e-01f, -3.88735533e-02f, 2.18721535e-02f, 4.13725674e-02f, 4.41304445e-02f, -7.92572554e-03f, -2.30953861e-02f,
  5.99166267e-02f, -3.08991242e-02f, 4.66766618e-02f, 4.14702147e-02f, 1.87666379e-02f, 1.10764178e-02f, -1.04727924e-01f, 7.88439065e-02f, -2.27901153e-03f, -5.99866621e-02f,
  -4.51353304e-02f, -2.51372959e-02f, 1.10685475e-01f, 5.55361472e-02f, 2.82146279e-02f, 1.77611947e-01f, 6.24684691e-02f, 1.09042402e-03f, 7.31567964e-02f, -1.93322897e-01f,
  1.37988105e-01f, -1.06869824e-01f, -4.07221705e-01f, -6.87327376e-03f, -1.77010417e-01f, -9.97313261e-02f, -1.46683842e-01f, 1.68816462e-01f, 1.51456267e-01f, -8.38774070e-02f,
  -2.33444516e-02f, 5.69734834e-02f, 8.68294537e-02f, 1.51977777e-01f, 2.45151415e-01f, -8.41774195e-02f, 3.19334455e-02f, 1.09637743e-02f, 1.49554521e-01f, 2.51080785e-02f,
  2.81417836e-02f, 9.94850602e-03f, 1.87332273e-01f, 1.46948144e-01f, -4.52862196e-02f, -4.98152785e-02f, -1.66877493e-01f, -3.28412615e-02f, -9.80017260e-02f, -1.93317533e-01f,
  -4.28815752e-01f, -1.22982554e-01f, -4.69221640e-03f, 9.96492337e-03f, -1.60435781e-01f, -2.44329460e-02f, -1.13158613e-01f, 2.99704671e-02f, -1.17752571e-02f, -9.77124423e-02f,
  2.45701410e-02f, -2.41105147e-02f, -1.47508867e-02f, 7.38705695e-02f, -3.04837693e-02f, -1.00916894e-02f, 9.68915001e-02f, 1.45159140e-01f, 2.36143116e-02f, -5.75477183e-02f,
  7.37514812e-03f, -1.48323134e-01f, -1.31709471e-01f, 2.16335896e-02f, 7.87961558e-02f, -5.51243545e-03f, -1.22607566e-01f, -4.93797921e-02f, -7.20191672e-02f, -8.30289051e-02f,
  3.81473079e-02f, -8.72107372e-02f, 7.49875675e-04f, 5.94168939e-02f, -2.87458766e-02f, -5.70953116e-02f, 2.09445935e-02f, -1.41061228e-02f, 3.19866203e-02f, -2.60170866e-02f,
  6.53943792e-02f, -5.49939722e-02f, 1.71245616e-02f, 2.90520489e-02f, -5.33545092e-02f, 2.21636915e-03f, -1.87340323e-02f, -5.54874949e-02f, -6.14263378e-02f, -9.06908419e-03f,
  -2.35791523e-02f, 2.42302455e-02f, -2.90055927e-02f, 7.15543628e-02f, 5.26331216e-02f, -4.21099178e-03f, 7.40051875e-03f, -1.77986547e-03f, 7.29399621e-02f, -5.97991683e-02f,
  -1.52475629e-02f, 1.68814868e-01f, -6.49998337e-02f, 1.15069009e-01f, -3.42116207e-02f, 1.08450510e-01f, -3.22523639e-02f, 2.63934229e-02f, -7.69906417e-02f, 5.01471125e-02f,
  -2.87177116e-02f, 7.16688111e-02f, -8.35663676e-02f, -5.27623948e-03f, -9.80068929e-03f, -2.03999393e-02f, -5.18335961e-02f, -3.41672413e-02f, 1.06175750e-01f, -4.29907031e-02f,
  -3.25454436e-02f, -8.49289745e-02f, -6.96217874e-03f, -6.11504875e-02f, 2.18238253e-02f, 5.19369282e-02f, -5.56464009e-02f, -2.28000507e-02f, 7.74928108e-02f, 2.48535699e-03f,
  1.84863098e-02f, 1.43671095e-01f, -1.51565075e-01f, 3.36986512e-01f, 2.28344008e-01f, -6.73422515e-02f, 7.73157924e-02f, 3.95654254e-02f, 1.15632512e-01f, 2.36290187e-01f,
  2.32216403e-01f, 1.36725217e-01f, 1.40066832e-01f, -4.44596969e-02f, -1.57033533e-01f, -1.09001316e-01f, -8.78490135e-02f, -1.91561773e-01f, -8.59412998e-02f, 1.35810450e-01f,
  1.26373366e-01f, 1.30460501e-01f, -7.83780739e-02f, -8.16675350e-02f, 2.90672988e-01f, 6.84084743e-02f, 2.45623942e-02f, 3.40939686e-02f, 2.43647285e-02f, 1.63815781e-01f,
  2.28924066e-01f, -1.52210072e-01f, 2.64972891e-03f, -3.75253484e-02f, 1.12675667e-01f, -3.84586230e-02f, 4.12799679e-02f, -1.20596267e-01f, -6.89625321e-03f, 2.92593315e-02f,
  5.92355132e-02f, -4.04499136e-02f, -1.98324528e-02f, -5.22280205e-03f, 4.97731045e-02f, -4.27776919e-04f, -1.25255629e-01f, -1.03117295e-01f, -1.57900795e-01f, 1.24642141e-02f,
  4.10839990e-02f, 1.17673501e-01f, -8.96672979e-02f, -1.25511393e-01f, -1.44740224e-01f, -9.86934230e-02f, -1.27957836e-01f, 4.51482181e-03f, -2.00673565e-01f, 2.69459467e-02f,
  4.94749025e-02f, 2.58597918e-02f, -1.00518847e-02f, 7.87402615e-02f, -7.14437664e-03f, -2.03325674e-02f, 1.94856972e-02f, 6.23924658e-02f, -2.38212924e-02f, -2.30385340e-03f,
  2.86885351e-03f, 2.62078419e-02f, 5.21774665e-02f, 3.59759107e-02f, 3.25843878e-02f, -4.62216176e-02f, 3.06056831e-02f, 2.57313921e-04f, 1.93029568e-02f, -4.53884713e-02f,
  -3.37099284e-02f, -3.38277705e-02f, -2.88987393e-03f, -2.48249974e-02f, -1.38377789e-02f, -1.50995366e-02f, -6.12501875e-02f, -2.62140837e-02f, 9.86472517e-03f, -2.89258584e-02f,
  3.00173968e-01f, -3.53494316e-01f, 1.60947189e-01f, -4.77091931e-02f, -3.45256529e-03f, -2.26775985e-02f, 5.40335551e-02f, 1.86877102e-02f, -9.02689714e-03f, 8.32610205e-02f,
  -3.24148796e-02f, -6.75468240e-03f, 9.05292779e-02f, 2.29643770e-02f, 5.18169552e-02f, -2.34238822e-02f, 7.97742046e-03f, 1.37485772e-01f, -1.08514607e-01f, 8.82251859e-02f,
  7.26920273e-03f, -8.17792267e-02f, 9.93703157e-02f, -1.39257126e-02f, 6.58378517e-03f, 7.42260441e-02f, 2.71742907e-03f, -1.27028553e-02f, -8.41270853e-03f, 1.28508240e-01f,
  2.30339974e-01f, 1.91336274e-01f, 4.22040880e-01f, 5.14083244e-02f, -1.55471951e-01f, 3.16477343e-02f, 1.39616758e-01f, -1.56407780e-03f, 2.82771960e-02f, -3.94279435e-02f,
  -2.19909728e-01f, -3.47516358e-01f, -9.35184583e-02f, -1.62893653e-01f, -3.67627502e-03f, 2.27180019e-01f, 3.05815816e-01f, 2.05292404e-01f, 4.91915494e-02f, -1.39019579e-01f,
  -1.60660788e-01f, 7.97498133e-03f, 1.09927803e-01f, 7.02057853e-02f, 1.50335774e-01f, -1.20686777e-02f, 1.46609634e-01f, 1.54874176e-01f, 1.46135874e-02f, 3.44487399e-01f,
  1.88309684e-01f, 5.30542135e-02f, -9.07729119e-02f, -8.95542130e-02f, -4.65093218e-02f, 1.15073048e-01f, -1.08500849e-02f, 1.05747961e-01f, 1.04129743e-02f, 1.00133047e-01f,
  -4.60520536e-02f, -1.28561676e-01f, -1.34570509e-01f, 4.31570262e-02f, 2.32693609e-02f, 1.87426042e-02f, 4.07310426e-02f, 1.48611024e-01f, 1.40666753e-01f, 4.09144908e-02f,
  -2.48949602e-01f, -1.54097974e-01f, 2.12940741e-02f, 6.34166896e-02f, 6.47636205e-02f, -1.23010697e-02f, 8.22879896e-02f, 7.91249275e-02f, 7.66031668e-02f, 3.59985709e-01f,
  2.66428571e-03f, -5.36248833e-03f, -9.49270576e-02f, -1.24659482e-02f, -2.95945369e-02f, 4.24621664e-02f, -1.08927106e-02f, -1.21542495e-02f, 3.21516395e-02f, 3.48046012e-02f,
  -2.38471143e-02f, 2.36641672e-02f, -8.60893130e-02f, 8.32528323e-02f, -1.01774804e-01f, 2.89275534e-02f, 1.53869353e-02f, 2.39501154e-04f, -4.85463999e-02f, -3.49485152e-03f,
  -3.11727077e-02f, 1.58212020e-03f, -3.05916909e-02f, -2.53127683e-02f, 1.84098836e-02f, 8.67222622e-02f, -1.27979880e-02f, -2.15366129e-02f, -2.52005234e-02f, -5.88618666e-02f,
  9.70439464e-02f, -1.92860007e-01f, 8.82095844e-02f, 1.12651654e-01f, 5.64503632e-02f, 7.20494390e-02f, -3.33748274e-02f, 7.50174234e-03f, -8.13179538e-02f, 5.21380976e-02f,
  -1.86109226e-02f, 8.72258991e-02f, -6.44562021e-02f, 4.25029844e-02f, -7.03185871e-02f, -4.56598140e-02f, -4.30033542e-02f, 5.53206401e-03f, -1.72794785e-03f, -2.98024639e-02f,
  9.35401767e-02f, 4.84682620e-02f, 8.18208903e-02f, 8.97378325e-02f, -1.50690544e-02f, -8.30075592e-02f, 1.39334366e-01f, 7.21448362e-02f, 1.02625452e-01f, 2.50253588e-01f,
  8.08454156e-02f, 2.92318076e-01f, 3.41350794e-01f, 4.31377627e-02f, 2.24258304e-01f, 1.71656683e-01f, 2.93839782e-01f, 1.53878346e-01f, 8.34260583e-02f, 1.74265265e-01f,
  8.42840001e-02f, -1.29788578e-01f, -9.90137160e-02f, -1.27016138e-02f, 5.33199199e-02f, 1.85939074e-01f, 2.17563033e-01f, 7.98244178e-02f, -7.33310431e-02f, -5.46304286e-02f,
  1.87831558e-02f, 8.55624899e-02f, 7.94391483e-02f, -2.94370693e-03f, 9.68296453e-03f, -1.18635885e-01f, 9.19436216e-02f, 2.53950208e-02f, -5.25772162e-02f, 2.11524472e-01f,
  4.53770086e-02f, 1.61632806e-01f, -1.62312761e-02f, -1.27830908e-01f, 4.54452224e-02f, -9.66875255e-03f, 2.11041253e-02f, -4.44122851e-02f, 1.26292817e-02f, 5.61476462e-02f,
  2.09887326e-02f, 1.00395093e-02f, -3.66790183e-02f, -1.87358726e-02f, 3.69568840e-02f, 7.53657892e-02f, -1.16711610e-03f, 4.44138385e-02f, -3.71929482e-02f, 7.08918199e-02f,
  4.78125401e-02f, 1.25372455e-01f, 9.62167755e-02f, 4.06259485e-02f, -4.18295301e-02f, -1.99868251e-02f, -9.51230340e-03f, -6.23452030e-02f, 5.08380942e-02f, 1.27939597e-01f,
  8.72578397e-02f, -7.08265901e-02f, -2.00974233e-02f, -3.12641216e-03f, 6.84665143e-02f, -1.16527108e-02f, 1.61992889e-02f, 4.23527397e-02f, -5.03969640e-02f, 3.28985006e-02f,
  -3.89769003e-02f, 3.51544768e-02f, -1.05722826e-02f, 2.23588198e-02f, 2.37173960e-02f, -3.72393914e-02f, 2.38951370e-02f, -1.07929409e-02f, 4.42124382e-02f, -5.30993985e-03f,
  6.77004382e-02f, -1.73709709e-02f, 3.45360264e-02f, 6.46829009e-02f, 7.47191831e-02f, -1.81646086e-02f, 8.58821254e-03f, -4.45698537e-02f, -5.69850840e-02f, 6.60655349e-02f,
  -1.71913058e-01f, -1.17950834e-01f, 6.61820471e-02f, 3.63655165e-02f, -3.04044113e-02f, -1.34273050e-02f, -9.94933955e-03f, 1.75038557e-02f, -1.20162107e-02f, 1.92999616e-02f,
  -7.56425187e-02f, -2.86685005e-02f, 4.91357930e-02f, -8.58069584e-03f, -4.53309901e-02f, 2.87169162e-02f, 8.51767287e-02f, 7.01401308e-02f, -3.20034213e-02f, -1.17173746e-01f,
  -2.90070418e-02f, 9.93187726e-02f, 3.14685069e-02f, -1.49384160e-02f, -7.49659305e-03f, -8.04963484e-02f, -8.50395858e-03f, 2.07387451e-02f, 3.13091949e-02f, 1.28552437e-01f,
  -3.59175771e-01f, -6.80935383e-03f, -3.00637931e-01f, 9.86319501e-03f, 1.20641023e-01f, 1.79272313e-02f, 9.16118920e-02f, 1.32752225e-01f, 9.45962779e-03f, 2.65485402e-02f,
  1.08057067e-01f, 1.27699241e-01f, 5.08644320e-02f, 1.14946060e-01f, -7.95891322e-03f, -1.22382410e-01f, -1.84642330e-01f, -2.82071471e-01f, -2.78567597e-02f, 1.21354401e-01f,
  -1.42650753e-02f, -2.22608954e-01f, -2.51235187e-01f, -2.01597035e-01f, -1.38293877e-01f, -1.34898990e-01f, -2.92324662e-01f, -2.48386070e-01f, -1.86935261e-01f, -3.12923998e-01f,
  -1.24953941e-01f, -5.86943664e-02f, 7.52104893e-02f, 4.47891057e-02f, 4.32764851e-02f, -1.01909891e-01f, -2.30695191e-03f, -6.31064996e-02f, 1.92244584e-03f, -1.46484869e-02f,
  3.17904614e-02f, 1.90071091e-02f, 2.18319632e-02f, -9.28478166e-02f, 2.74719317e-02f, -2.45124120e-02f, -3.92202735e-02f, -7.50958174e-02f, -1.52026967e-03f, 5.78037873e-02f,
  -3.60120460e-03f, -5.61553054e-02f, -1.07641727e-01f, -6.88690469e-02f, -4.75129820e-02f, -3.18222828e-02f, -1.51901366e-02f, -1.19313754e-01f, -1.25281066e-01f, -3.15146178e-01f,
  -1.93690117e-02f, -1.74457096e-02f, -1.17200278e-02f, -1.96482986e-02f, 6.53115138e-02f, -5.77481836e-02f, -8.05073138e-03f, -3.48556936e-02f, 3.28901298e-02f, -6.00766800e-02f,
  4.10627201e-02f, -1.23641500e-02f, 1.46058863e-02f, -4.60417867e-02f, -6.77543180e-03f, -4.49674129e-02f, -3.31522245e-03f, -2.55314750e-04f, 1.96873434e-02f, 1.63901486e-02f,
  -8.38453230e-03f, 3.04594375e-02f, 1.27039207e-02f, 1.61886346e-02f, 6.13156781e-02f, -4.37767506e-02f, 2.12760363e-02f, 2.72063836e-02f, 7.24191964e-02f, 2.88325455e-02f,
  2.01490909e-01f, 1.82686895e-02f, -6.15980029e-02f, 5.87860383e-02f, -1.47020267e-02f, 7.77288973e-02f, -2.74889953e-02f, 1.14728808e-01f, 6.33284599e-02f, 7.24575892e-02f,
  9.95932519e-02f, 5.59490547e-02f, 6.40093163e-02f, -1.69293340e-02f, 5.31237051e-02f, 7.51480386e-02f, 1.41577363e-01f, 3.37090753e-02f, 1.25336600e-02f, 6.45483211e-02f,
  1.06328867e-01f, -5.96140027e-02f, 3.07113715e-02f, 3.51310745e-02f, 7.47309253e-02f, -6.35225102e-02f, -2.87449025e-02f, -2.28205007e-02f, 1.56731741e-03f, -3.47517291e-03f,
  -3.72929454e-01f, 8.97047073e-02f, 2.65451342e-01f, -9.33252722e-02f, 6.46892935e-02f, 2.23829761e-01f, 3.22756767e-01f, 2.06157401e-01f, -6.54673129e-02f, 1.32433884e-02f,
  8.71946439e-02f, -2.10445121e-01f, -9.39160734e-02f, 7.10455375e-03f, -3.12771089e-03f, 1.00238040e-01f, -7.35639185e-02f, -1.30481303e-01f, -1.35700852e-01f, -8.62000138e-02f,
  -1.81368634e-01f, -1.90993458e-01f, -1.40216947e-01f, -1.38747960e-01f, -6.58849329e-02f, -1.28047258e-01f, 7.05861151e-02f, 2.94981971e-02f, -1.64143164e-02f, -1.67551905e-01f,
  1.24463208e-01f, -1.35244930e-03f, -2.57957093e-02f, -2.34397992e-01f, 3.98235731e-02f, -8.00990015e-02f, 1.44710802e-02f, -2.68600397e-02f, 1.48542784e-02f, 5.11632636e-02f,
  -7.07704723e-02f, 9.00320068e-04f, -1.49884522e-02f, 5.66063784e-02f, 1.01814801e-02f, 1.39386496e-02f, 3.40952761e-02f, -7.09323538e-03f, 2.95121875e-02f, 1.48935514e-02f,
  -1.35863423e-01f, -1.12958975e-01f, -1.65466759e-02f, 1.79374516e-01f, 1.20603628e-01f, -8.48215744e-02f, 3.78935821e-02f, -3.22185010e-02f, 6.86605498e-02f, 1.02059968e-01f,
  2.49514263e-03f, -1.12363519e-02f, 2.77743973e-02f, 5.75629994e-04f, -6.07805178e-02f, 2.98210606e-02f, -3.44776437e-02f, -1.34262340e-02f, 5.26462980e-02f, -3.73640619e-02f,
  3.91890556e-02f, 4.57663648e-02f, 2.36963201e-02f, 2.05762535e-02f, 4.38252017e-02f, -5.16027659e-02f, -8.05216730e-02f, 5.19528352e-02f, -1.92039143e-02f, 3.21559198e-02f,
  -2.74518300e-02f, -6.18630089e-03f, 5.08875065e-02f, 4.44959700e-02f, -1.93900242e-02f, -8.69219378e-03f, 1.94998886e-02f, -4.99490015e-02f, -5.29331565e-02f, -1.61789190e-02f,
  1.96296394e-01f, 6.26853481e-02f, -1.12903103e-01f, -3.01160514e-02f, -2.13111900e-02f, 7.54406229e-02f, -5.33096418e-02f, 6.01972230e-02f, -1.00515962e-01f, 3.03880740e-02f,
  2.10799556e-02f, -8.65977705e-02f, -4.18858007e-02f, 1.47633301e-02f, 3.51006314e-02f, 1.63919553e-02f, -4.40666638e-02f, -1.98771674e-02f, 2.45844256e-02f, 7.80306160e-02f,
  4.69553508e-02f, 1.11042865e-01f, 5.87209389e-02f, 8.52481201e-02f, -2.62489263e-02f, -6.40455708e-02f, 1.06177717e-01f, 1.57564506e-02f, 6.16637208e-02f, 1.99964941e-01f,
  4.55582529e-01f, -2.59570301e-01f, -1.93010330e-01f, 1.12459444e-01f, 1.31544769e-01f, 1.39152646e-01f, 9.87545550e-02f, -6.10101083e-03f, 2.01090332e-02f, 4.50392999e-03f,
  1.52861148e-01f, 6.55707270e-02f, 5.31058609e-02f, 5.81714436e-02f, -1.28612630e-02f, -1.93299651e-01f, -1.88110873e-01f, -4.52449396e-02f, 9.78299677e-02f, 2.09581122e-01f,
  6.62792474e-02f, -1.03657819e-01f, 3.89802679e-02f, -5.00559732e-02f, -7.80930221e-02f, -2.68439371e-02f, -2.38094643e-01f, 1.38324173e-02f, -1.16856910e-01f, -2.54768670e-01f,
  7.36866519e-02f, -1.17834704e-03f, 6.84400871e-02f, 5.00393175e-02f, -3.80306691e-03f, -4.18743789e-02f, -5.32113668e-03f, -1.40167162e-01f, 4.65691537e-02f, -7.82595798e-02f,
  9.85055864e-02f, 6.27272576e-02f, 1.20436714e-03f, 6.99788192e-03f, -2.15457585e-02f, 3.03851850e-02f, -1.20166495e-01f, -1.07070506e-01f, 1.96823776e-02f, -3.08094434e-02f,
  -7.65787959e-02f, 1.24025628e-01f, 1.63953274e-01f, -4.05670032e-02f, 2.89905928e-02f, 1.20415434e-01f, -3.15313973e-02f, 5.55390641e-02f, 3.49601954e-02f, -1.86632082e-01f,
  -4.67964076e-02f, 3.66162919e-02f, 1.38069270e-02f, -4.35762815e-02f, -1.29197910e-02f, 3.39794978e-02f, -3.13267522e-02f, 6.95875613e-04f, 7.61377513e-02f, -2.88773468e-03f,
  -7.58497091e-03f, 3.54641154e-02f, -2.52391137e-02f, -1.55256120e-02f, 1.57232787e-02f, -5.42262420e-02f, -1.29855219e-02f, -3.38021782e-03f, 1.52490167e-02f, 3.33583471e-03f,
  2.50436030e-02f, 8.58546719e-02f, -5.37170805e-02f, -1.56775285e-02f, 9.94395930e-03f, -6.99059069e-02f, 4.53595519e-02f, -1.39688756e-02f, 2.44141165e-02f, -3.16085219e-02f,
  4.31213016e-03f, 8.24492276e-02f, -1.73331890e-03f, 4.02919874e-02f, 2.76292786e-02f, -1.61463656e-02f, 2.88749821e-02f, 7.49537139e-04f, -2.95059942e-02f, 4.12965566e-02f,
  3.56179923e-02f, -6.95020854e-02f, -7.83384293e-02f, -7.55424649e-02f, 5.81327733e-03f, 6.68254718e-02f, -1.00990459e-01f, 7.29289502e-02f, 4.84490953e-02f, -2.10881904e-02f,
  -1.16855621e-01f, 1.84066653e-01f, 2.74757534e-01f, 9.62986052e-02f, 1.34437224e-02f, 1.66330338e-01f, 6.44803345e-02f, -1.15546421e-03f, 8.02188143e-02f, -2.04264466e-02f,
  -4.40496355e-02f, 3.13222468e-01f, -3.01589340e-01f, 2.01917738e-01f, -3.70990974e-03f, -1.70817092e-01f, 7.97521472e-02f, -1.26395598e-02f, 1.51389703e-01f, 2.09823430e-01f,
  8.53398517e-02f, -8.52951631e-02f, -7.99694657e-03f, -1.29969120e-01f, -9.94118527e-02f, 7.20129833e-02f, 7.84177929e-02f, -1.75403893e-01f, -3.65606427e-01f, -9.97751355e-02f,
  1.75385177e-01f, 1.37257120e-02f, -7.01382831e-02f, -1.13935564e-02f, 1.54138342e-01f, -4.15142253e-02f, -4.69194762e-02f, 7.64032453e-02f, 1.27184719e-01f, 3.71345699e-01f,
  -1.85396746e-01f, -2.21901573e-02f, -1.71553776e-01f, -1.24433695e-03f, -7.84796700e-02f, 2.40637399e-02f, -4.97188121e-02f, -9.03569907e-02f, -6.07212679e-03f, -1.25723556e-02f,
  1.49648404e-02f, 6.24027401e-02f, -8.79675150e-02f, 4.00950275e-02f, 1.60200689e-02f, -9.50833187e-02f, -2.52557993e-02f, -1.39400288e-01f, -6.83048666e-02f, 4.36600372e-02f,
  1.40160650e-01f, -8.98155123e-02f, -2.37760186e-01f, -6.86259121e-02f, -1.60455763e-01f, -8.43951255e-02f, -1.43238038e-01f, -6.31535724e-02f, -1.01757489e-01f, 2.01580644e-01f,
  4.09978218e-02f, -1.17151476e-02f, -9.04433355e-02f, 1.51457069e-02f, 8.39852320e-04f, -1.71791557e-02f, 2.69662822e-03f, -2.34072413e-02f, 4.23472337e-02f, 2.83309165e-02f,
  -2.33487412e-02f, 1.23356720e-02f, -7.09382398e-03f, 5.65816611e-02f, 2.61712801e-02f, 1.78839341e-02f, -7.21465284e-03f, 6.87387679e-03f, -8.89720395e-02f, 2.15561371e-02f,
  -3.18099074e-02f, -7.19924718e-02f, -3.09623107e-02f, -1.38818463e-02f, -4.69815060e-02f, -4.39078994e-02f, 7.71058500e-02f, 3.38610262e-02f, -5.66471070e-02f, 7.27727339e-02f,
  1.02781668e-01f, -2.26291046e-01f, 9.95776281e-02f, 4.03034166e-02f, -3.65425460e-02f, -3.41664515e-02f, 5.31482659e-02f, -7.42750894e-03f, 8.48675612e-03f, 1.20005971e-02f,
  -8.71891826e-02f, -5.78952990e-02f, -4.78341691e-02f, 8.10480118e-02f, -6.77682459e-02f, 4.03032340e-02f, 1.30786672e-01f, -4.04676013e-02f, -6.22373112e-02f, -2.80726738e-02f,
  9.66946706e-02f, 1.86712351e-02f, -3.74504961e-02f, -5.51999807e-02f, -7.21758902e-02f, -9.95329022e-02f, -8.21816176e-02f, -1.94473118e-02f, -2.67777801e-01f, 2.46115997e-01f,
  -3.91003013e-01f, 3.25301625e-02f, 4.48340207e-01f, -2.76805647e-02f, 8.10808465e-02f, -3.78395198e-03f, 7.43049905e-02f, -4.62676473e-02f, -6.54435903e-02f, 8.49040151e-02f,
  -2.09299233e-02f, -1.22412682e-01f, 1.09747685e-01f, 1.52432561e-01f, 8.13321248e-02f, 3.29091609e-01f, 3.15386325e-01f, 2.22227722e-01f, 8.58853832e-02f, -5.93410432e-02f,
  5.13846870e-04f, -8.49258378e-02f, -1.81046531e-01f, 5.29440753e-02f, 9.04174820e-02f, -1.46089597e-02f, 1.53508201e-01f, 1.88345555e-02f, 1.22428566e-01f, 2.31661931e-01f,
  3.48535597e-01f, -1.87321857e-01f, 1.64257959e-02f, -4.38725241e-02f, 4.86393925e-03f, -8.61056224e-02f, 2.75355577e-03f, 2.70373151e-02f, -1.88659713e-01f, 5.97116165e-02f,
  -3.24140228e-02f, -6.49576783e-02f, -3.19167823e-02f, 6.56590145e-03f, -8.21024477e-02f, 2.10776422e-02f, -2.60369517e-02f, 1.50866935e-03f, 6.11133650e-02f, 2.27407962e-02f,
  -2.82005332e-02f, -9.05905291e-02f, -2.88320519e-02f, -8.97172466e-02f, -6.03773184e-02f, -3.82573493e-02f, -2.41921190e-03f, -8.09150040e-02f, 2.18754802e-02f, 1.17683984e-01f,
  7.51582235e-02f, 6.22460917e-02f, 5.14291003e-02f, -7.79270902e-02f, -1.28776347e-02f, -3.35791484e-02f, 3.88516262e-02f, -2.38213614e-02f, 7.45425420e-03f, 2.18757968e-02f,
  -5.31302653e-02f, 4.53525744e-02f, 5.46750240e-02f, -4.38718796e-02f, 8.38763639e-02f, -1.33910188e-02f, 3.67542473e-03f, 3.95768434e-02f, 6.22762647e-03f, -4.68507111e-02f,
  -6.66596517e-02f, 7.24885054e-03f, -3.51986382e-03f, -6.73615485e-02f, -3.03548202e-03f, 3.47963050e-02f, -2.12462768e-02f, -2.30079703e-02f, -6.68599783e-03f, -2.86652055e-03f,
  -1.24479160e-01f, -6.54894859e-03f, 3.37528088e-03f, -4.51784730e-02f, 4.31594066e-02f, 2.21221186e-02f, -2.88197827e-02f, 7.82499611e-02f, -6.02848679e-02f, -6.34766296e-02f,
  -5.36912829e-02f, -1.62808541e-02f, 3.88320014e-02f, -2.27317773e-02f, 2.40495317e-02f, -6.27524778e-02f, 3.18091782e-03f, 4.30682711e-02f, 7.73186283e-03f, 3.08789369e-02f,
  3.04838605e-02f, 3.81393707e-03f, -1.10579655e-01f, 8.92901123e-02f, 3.82553451e-02f, -6.92443252e-02f, 1.01963446e-01f, 6.93710148e-02f, -3.79400589e-02f, 1.75314873e-01f,
  -2.91708320e-01f, 2.86065459e-01f, -2.50905812e-01f, -7.44824037e-02f, -8.24768171e-02f, 3.05258874e-02f, 1.01340406e-01f, 1.16036370e-01f, 1.00038521e-01f, 1.80587977e-01f,
  1.71650231e-01f, 1.93608537e-01f, 1.66206077e-01f, 1.02175452e-01f, 1.16000146e-01f, 2.53690481e-01f, 1.74434304e-01f, -2.14781210e-01f, -2.27560833e-01f, -2.21848384e-01f,
  -2.42504124e-02f, -5.07543348e-02f, -1.85927942e-01f, -3.35338563e-02f, 2.07500309e-02f, -8.63795131e-02f, 4.33170497e-02f, -7.08662644e-02f, -1.39855063e-02f, -8.55513513e-02f,
  -1.50278091e-01f, -2.65248686e-01f, -4.57339846e-02f, 1.01146358e-03f, -6.85059428e-02f, 5.83529808e-02f, -3.96531560e-02f, 1.96147710e-02f, 4.80086394e-02f, 3.08885314e-02f,
  -2.70828214e-02f, -1.60313062e-02f, 1.88711695e-02f, 4.34879959e-02f, -3.30129638e-02f, -8.77597928e-03f, 2.61668378e-04f, 1.43379280e-02f, 1.64943524e-02f, 1.05565069e-02f,
  2.22415701e-01f, -1.15303800e-01f, -1.64314851e-01f, 7.12822452e-02f, 4.54102382e-02f, -9.28831473e-03f, -3.15699540e-02f, -1.21880457e-01f, -1.26942188e-01f, -3.55771668e-02f,
  -1.82148889e-02f, 1.31258881e-02f, -4.35439795e-02f, -2.66305264e-02f, 3.33977453e-02f, 5.73528651e-03f, 2.05417313e-02f, -3.37652899e-02f, -4.52724062e-02f, 3.32212932e-02f,
  -1.04882186e-02f, 1.87127478e-02f, 3.89672406e-02f, -3.15579996e-02f, 3.47476378e-02f, -6.88111186e-02f, 1.12411985e-02f, 1.29349962e-01f, 4.12491709e-02f, 2.34300736e-02f,
  -4.83970605e-02f, 4.43627639e-03f, -4.55441810e-02f, -2.19359342e-02f, 1.04656152e-01f, 1.65304337e-02f, -4.55098860e-02f, 5.28076254e-02f, 4.63275798e-02f, -2.97676288e-02f,
  2.88489342e-01f, -7.70856719e-03f, 5.75972795e-02f, 2.33517606e-02f, -1.22135226e-02f, 2.38353647e-02f, 1.13621660e-01f, -5.20430319e-02f, -5.14087975e-02f, -1.59055367e-02f,
  -1.52368881e-02f, -1.23058800e-02f, 8.68002474e-02f, 1.38403475e-02f, -1.14886217e-01f, -3.81907541e-03f, 5.46458550e-02f, 8.70114192e-03f, 6.25181869e-02f, -4.24002111e-03f,
  1.39135301e-01f, 6.94771037e-02f, 3.78940371e-03f, 1.08982854e-01f, 3.06587163e-02f, 5.84661067e-02f, -2.48856144e-04f, -6.79130033e-02f, 1.94123369e-02f, 1.49097934e-01f,
  -7.25293338e-01f, -1.90605670e-01f, 2.16109350e-01f, -3.35846514e-01f, 1.08943693e-02f, 3.81121963e-01f, 3.40509653e-01f, 3.16828042e-02f, -1.39668614e-01f, -5.51596563e-03f,
  -9.93450284e-02f, -1.86119467e-01f, -1.58376217e-01f, 2.69678864e-03f, 1.33244351e-01f, 1.56606942e-01f, 6.69782534e-02f, 1.44615844e-01f, 1.96634784e-01f, 1.85984865e-01f,
  3.48376557e-02f, -1.91899583e-01f, -2.69859552e-01f, 5.58853224e-02f, -1.23211913e-01f, 8.46291706e-02f, 2.34561414e-02f, -1.24669097e-01f, 1.80201530e-02f, -1.55430928e-01f,
  4.31966633e-02f, -2.92544782e-01f, 1.98154896e-01f, -1.66956514e-01f, -8.43653455e-02f, 2.18759365e-02f, 3.32932710e-03f, -8.69848281e-02f, -6.50009885e-03f, -5.70607893e-02f,
  -9.30200592e-02f, -1.08720154e-01f, -5.08477911e-02f, 2.08581164e-02f, -2.84138136e-02f, 3.23094614e-02f, -1.22749945e-03f, -3.57613247e-03f, 6.17380720e-03f, 8.78484827e-03f,
  -5.60283363e-02f, -4.32746410e-02f, -9.78099927e-02f, 4.47484739e-02f, 3.53449658e-02f, -5.16913161e-02f, 7.27353990e-02f, -3.08188666e-02f, 3.08514945e-03f, -6.60136640e-02f,
  5.47592901e-02f, 1.43043622e-02f, 3.96093242e-02f, 1.03549436e-02f, 2.11377721e-02f, -4.04613353e-02f, 1.93989817e-02f, 1.48928277e-02f, 1.73254739e-02f, 2.25609504e-02f,
  1.30005591e-02f, 8.04828480e-03f, -4.50183841e-04f, 5.42624807e-03f, -6.01340309e-02f, -1.48238717e-02f, -5.45676146e-03f, -2.39328835e-02f, 5.45618962e-03f, -4.26743813e-02f,
  -6.94000274e-02f, 3.36390249e-02f, -9.46764797e-02f, 1.75283439e-02f, -6.98262081e-03f, -1.61453653e-02f, 2.79361606e-02f, 3.50416563e-02f, -1.24033866e-02f, -5.72664179e-02f,
  -1.37379393e-01f, 3.65343504e-02f, -3.32690626e-02f, -3.52181382e-02f, 2.01008972e-02f, -7.44114146e-02f, -5.23190619e-03f, -3.50273703e-03f, -9.81826708e-02f, 5.59897684e-02f,
  3.99974585e-02f, -3.58053413e-03f, -2.50417888e-02f, -2.68439073e-02f, 9.49536264e-02f, 2.90576480e-02f, -3.51971462e-02f, -4.06741537e-02f, 4.09358516e-02f, -1.62101891e-02f,
  -2.37320624e-02f, 4.70981784e-02f, -5.99401724e-03f, 1.41661018e-01f, -5.61367646e-02f, 8.73714909e-02f, 1.16897479e-01f, 2.99560055e-02f, 1.70439452e-01f, 1.25081450e-01f,
  -1.47793651e-01f, -9.56646055e-02f, -2.25952074e-01f, -2.83916295e-01f, -1.17763385e-01f, -1.20197493e-03f, -1.63798518e-02f, -7.06894994e-02f, -1.02411762e-01f, -5.54530434e-02f,
  -1.46550655e-01f, -4.57666852e-02f, -1.22616939e-01f, -2.09827438e-01f, -1.86261222e-01f, -1.26828060e-01f, -6.11092672e-02f, -9.60494727e-02f, -1.33856282e-01f, -1.27691463e-01f,
  -1.14933819e-01f, -1.77754000e-01f, -1.64621353e-01f, -1.00800134e-01f, -5.41452579e-02f, -1.84807181e-01f, -2.03399926e-01f, -1.29940704e-01f, -1.05362989e-01f, -1.59173608e-01f,
  -5.29096834e-02f, -1.17024243e-01f, 6.86372817e-02f, -7.78385326e-02f, 3.04725487e-02f, 9.38831121e-02f, 3.41106043e-03f, 1.30285129e-01f, 6.98970184e-02f, 1.11909248e-02f,
  2.30719708e-02f, 7.14041814e-02f, 4.45288755e-02f, -3.53008769e-02f, -4.78410348e-02f, 4.37415317e-02f, -1.90624930e-02f, 7.06719095e-03f, 6.06285371e-02f, -4.01136875e-02f,
  4.63925861e-02f, 2.00256407e-02f, 2.62373909e-02f, 1.32166175e-03f, 2.94503551e-02f, 3.87711674e-02f, 7.19661415e-02f, 6.16395511e-02f, 5.50052300e-02f, -1.10671893e-02f,
  -2.13502217e-02f, 5.81836142e-02f, 1.45111317e-02f, 4.51693386e-02f, 2.34211497e-02f, -3.36853042e-02f, 3.58663872e-02f, -3.75789143e-02f, -2.08988972e-02f, 4.07428369e-02f,
  -5.38940132e-02f, 2.75356956e-02f, -6.28783926e-03f, 5.86599968e-02f, -5.70661761e-02f, 3.57304029e-02f, 6.79198280e-02f, 7.46926889e-02f, 2.54898909e-02f, 5.87077104e-02f,
  -4.35884707e-02f, 8.89224932e-02f, 1.16628492e-02f, 2.05779821e-02f, -4.46052663e-02f, 1.00317392e-02f, -9.65908077e-03f, 1.37164677e-02f, 2.56748889e-02f, 6.29734173e-02f,
  -7.17082843e-02f, 3.75201069e-02f, -6.26872256e-02f, -1.59955639e-02f, 6.67101964e-02f, -2.47355527e-03f, -6.52217194e-02f, 2.21283338e-03f, 8.93105567e-02f, -2.65194126e-03f,
  -2.73499638e-02f, -2.59162933e-02f, 2.43881531e-02f, 1.36525016e-02f, 2.34356709e-02f, 4.64938208e-02f, 3.75533514e-02f, -4.27833339e-03f, 5.27234301e-02f, 7.34280124e-02f,
  -9.37734358e-03f, 9.70525816e-02f, 1.51616544e-01f, 9.93047506e-02f, 1.23913828e-02f, 9.78063121e-02f, 7.23932758e-02f, 8.48104805e-02f, 1.35133967e-01f, 1.03543997e-01f,
  -4.32602257e-01f, 2.59393811e-01f, 1.27230629e-01f, -2.32819431e-02f, 2.10965853e-02f, -2.72004068e-01f, -1.34451896e-01f, -1.96418613e-01f, -6.16855137e-02f, 6.81458861e-02f,
  1.36651218e-01f, -1.46404747e-02f, 1.48259372e-01f, 2.91683916e-02f, -5.60952015e-02f, -8.28466937e-03f, 1.40416950e-01f, -7.57968351e-02f, -2.46770367e-01f, -1.42052025e-01f,
  -4.60638776e-02f, -2.68783439e-02f, -8.52703750e-02f, -2.84442343e-02f, 1.89122513e-01f, 1.12239249e-01f, 1.70215741e-01f, 1.12759091e-01f, 1.36504456e-01f, 4.35440302e-01f,
  3.37518513e-01f, 5.66412415e-03f, -1.02063641e-01f, -3.00960690e-02f, 1.16841204e-01f, -3.19593437e-02f, -6.76914155e-02f, 7.02042803e-02f, 7.19843153e-03f, -2.10614260e-02f,
  8.70817453e-02f, 1.09443292e-02f, 6.81867301e-02f, 1.10742692e-02f, -1.91113558e-02f, -8.82233232e-02f, 4.46463563e-02f, -1.70428380e-02f, 6.46055024e-03f, 7.41094798e-02f,
  1.49633750e-01f, 1.37911990e-01f, -2.83642765e-02f, -7.73083838e-03f, 3.56728509e-02f, -1.03089340e-01f, -2.14836951e-02f, 5.75181954e-02f, -1.31760105e-01f, -2.55367141e-02f,
  -6.60804659e-02f, 5.56284115e-02f, 3.90007184e-03f, 1.77239196e-03f, -7.99430311e-02f, 6.43177778e-02f, 3.49306166e-02f, 7.61117507e-03f, -4.88847122e-03f, -2.36794110e-02f,
  8.71249940e-03f, -3.02310418e-02f, -3.01245134e-02f, -2.81720925e-02f, 6.50056228e-02f, 6.34125844e-02f, 4.66390327e-02f, 2.05504335e-02f, 2.25598905e-02f, 3.32176406e-03f,
  -1.13796508e-02f, -2.92094219e-02f, 8.89000446e-02f, 2.71252189e-02f, 7.81952739e-02f, -1.55938845e-02f, 1.48180276e-02f, -1.80488713e-02f, 4.78764661e-02f, -1.77414883e-02f,
  -5.79475053e-02f, -2.13306561e-01f, 7.32338205e-02f, -8.69506150e-02f, 7.35754743e-02f, 5.40124588e-02f, 7.13338852e-02f, -5.49732661e-03f, 3.67998183e-02f, 2.89257281e-02f,
  -3.75634395e-02f, -7.44307637e-02f, 6.56672940e-02f, -8.49136524e-03f, -1.20626628e-01f, -1.79740917e-02f, -2.92819180e-03f, -3.10688429e-02f, -3.66593921e-03f, 5.78838438e-02f,
  -1.23429829e-02f, -1.82839677e-01f, -1.26334891e-01f, -6.15388937e-02f, -7.05381632e-02f, -9.12289321e-02f, -1.02351103e-02f, -8.09419602e-02f, -2.68971831e-01f, -2.82156557e-01f,
  4.77080196e-01f, 7.92708341e-03f, 3.75756264e-01f, 1.88140720e-01f, 9.51656997e-02f, 7.24457437e-03f, -1.79069906e-01f, -1.47039860e-01f, -8.04323629e-02f, -7.54399365e-03f,
  -4.43108454e-02f, -1.91679686e-01f, -1.96766004e-01f, -2.12817207e-01f, -6.51930869e-02f, 1.42484263e-01f, 2.68001318e-01f, 1.06801078e-01f, -2.69699730e-02f, -7.51626194e-02f,
  -7.84901157e-02f, 1.06087932e-02f, 2.16087207e-01f, 2.64524855e-03f, 1.04428776e-01f, -8.85091200e-02f, 2.00390890e-01f, 1.54802248e-01f, -3.78275029e-02f, 2.04545319e-01f,
  -8.80507752e-02f, 1.82706103e-01f, -1.20197773e-01f, 3.07729356e-02f, 1.09489925e-01f, -1.48318475e-02f, -2.43225247e-02f, 4.54554223e-02f, 1.13251647e-02f, 7.29095237e-03f,
  1.74923278e-02f, -6.02671020e-02f, -1.80466659e-02f, -5.20433784e-02f, -1.27807278e-02f, 6.32335395e-02f, 5.08318022e-02f, 1.40516549e-01f, -4.49755937e-02f, -4.42032851e-02f,
  -8.33286792e-02f, 1.97254434e-01f, 9.89799574e-02f, 4.22853790e-02f, 2.21753512e-02f, 5.47835007e-02f, -6.88080257e-03f, 1.21416431e-02f, 6.89536184e-02f, 1.58831477e-01f,
  -8.35388154e-03f, 8.03584456e-02f, 1.43427616e-02f, -2.83795558e-02f, -8.06448162e-02f, -2.89450586e-02f, 9.36015621e-02f, -6.13450743e-02f, -7.10691065e-02f, 8.95813406e-02f,
  -5.11252284e-02f, -7.75536820e-02f, -2.03631143e-03f, 5.23237325e-02f, -2.87999064e-02f, 1.76402982e-02f, 4.66914847e-02f, -9.54004079e-02f, 3.04891896e-02f, 3.04512400e-02f,
  -3.31356637e-02f, -9.12527926e-03f, -2.49830391e-02f, 4.56137396e-02f, -2.10927855e-02f, 2.65890751e-02f, 4.13729586e-02f, -7.02123269e-02f, -3.64617421e-03f, 6.48616999e-02f,
  -2.93045133e-01f, -2.28319969e-02f, -2.90809292e-02f, -5.20915948e-02f, 1.40292734e-01f, -7.07263574e-02f, 3.62819657e-02f, 8.55355263e-02f, 6.79623634e-02f, 5.50922155e-02f,
  -3.58339176e-02f, 1.45445438e-02f, 3.83026674e-02f, -8.06022212e-02f, -2.88528819e-02f, -2.28148997e-02f, -1.59374867e-02f, -5.88399963e-03f, 9.18443489e-04f, -6.53313249e-02f,
  -2.61181295e-02f, -5.35985045e-02f, -2.65890900e-02f, -1.14609420e-01f, -1.01631373e-01f, 2.22513769e-02f, -9.10444632e-02f, -9.25569758e-02f, -4.10661697e-02f, -9.70933437e-02f,
  -1.94781870e-01f, -1.36951178e-01f, -2.16788352e-01f, -1.61553979e-01f, 1.95709273e-01f, 2.31595054e-01f, 2.87596494e-01f, 1.62847325e-01f, 6.34337887e-02f, -3.05742621e-02f,
  8.96944031e-02f, 5.00102527e-02f, -7.43549317e-02f, -3.20256129e-02f, 1.13760851e-01f, 3.74040790e-02f, -1.37323916e-01f, -2.46683910e-01f, -1.41853675e-01f, -2.26456393e-02f,
  -4.47946452e-02f, -1.34417236e-01f, -1.42363593e-01f, -5.68031445e-02f, -1.09465599e-01f, -2.07280777e-02f, -4.59490307e-02f, -8.06844532e-02f, -4.31030430e-03f, -3.21206033e-01f,
  -4.52944010e-01f, -1.99769154e-01f, 1.33219630e-01f, 8.15344974e-02f, -1.69913061e-02f, -5.42151071e-02f, 1.90181155e-02f, -8.60251412e-02f, 8.34123325e-03f, -1.13030016e-01f,
  1.81580777e-03f, -9.21333507e-02f, -6.62952960e-02f, -5.44147976e-02f, -3.19186933e-02f, 1.26960380e-02f, -5.07338606e-02f, -1.13141432e-01f, -8.75036269e-02f, 2.58914586e-02f,
  7.12540299e-02f, 1.72894262e-03f, -6.04265369e-02f, 8.44730362e-02f, -2.71230098e-02f, 5.68525754e-02f, -1.11413397e-01f, -4.68790457e-02f, 1.54930428e-02f, -1.56918809e-01f,
  6.62238225e-02f, -1.24554420e-02f, 7.02750161e-02f, -3.50787938e-02f, -6.19826606e-03f, 6.94900006e-02f, -5.70346564e-02f, -4.76377271e-02f, 6.95236446e-03f, 4.56895214e-03f,
  -1.48543380e-02f, -5.28510474e-03f, 2.93880142e-03f, 1.10408626e-02f, -4.39540222e-02f, -7.39692897e-02f, 3.59997898e-02f, -3.80482227e-02f, -2.72963266e-03f, 5.95245361e-02f,
  9.62685701e-03f, 2.42195856e-02f, -3.92651856e-02f, -1.73648689e-02f, 6.42547384e-02f, -7.34166726e-02f, -4.05632742e-02f, 2.85689756e-02f, 1.34936264e-02f, 3.92977148e-02f,
  -2.86154505e-02f, 2.98453748e-01f, -1.11813337e-01f, -1.84843820e-02f, 4.01121303e-02f, 8.92326459e-02f, -8.71130675e-02f, 3.73102985e-02f, 9.21995437e-04f, -2.48387009e-02f,
  -3.29923034e-02f, 8.59586708e-03f, -6.38689250e-02f, 3.95054407e-02f, -9.03635249e-02f, 2.32351013e-02f, 1.15792982e-01f, -6.55317008e-02f, 9.17700827e-02f, 2.55702976e-02f,
  8.03826973e-02f, 8.24050978e-02f, 7.66910166e-02f, 8.38689134e-02f, 6.53032139e-02f, 4.42829840e-02f, -9.36709868e-04f, 4.85655442e-02f, 9.13634375e-02f, 9.52228755e-02f,
  3.65172416e-01f, 3.73997152e-01f, 1.00866146e-01f, -3.89337679e-03f, -5.40496670e-02f, 2.35071927e-02f, 5.30314399e-03f, -3.93562764e-02f, -3.05535626e-02f, 1.20715618e-01f,
  7.97072351e-02f, -3.64238061e-02f, -3.58632416e-03f, -7.66079202e-02f, 4.56789285e-02f, -4.92074825e-02f, -1.15450155e-02f, -5.76984696e-02f, -1.43108681e-01f, -1.60825565e-01f,
  -1.95236325e-01f, -7.59029612e-02f, 1.03594489e-01f, 4.62183021e-02f, -3.38861682e-02f, 2.86896829e-03f, 1.65977478e-02f, 1.90975834e-02f, 8.67455006e-02f, -4.07086574e-02f,
  3.30230258e-02f, 3.13886583e-01f, -1.83785811e-01f, -4.94616479e-02f, -2.37196479e-02f, -3.46898325e-02f, -8.66204947e-02f, 6.75847158e-02f, 7.06269145e-02f, 1.70055479e-02f,
  9.98115912e-02f, 9.04077888e-02f, 9.71579850e-02f, 6.10560812e-02f, -2.48836111e-02f, 2.36222837e-02f, 8.71699974e-02f, 2.52232999e-02f, 1.08298488e-01f, 3.77100334e-02f,
  -5.95032834e-02f, 7.64079243e-02f, 7.50054866e-02f, 1.04227372e-01f, 2.13702749e-02f, -3.13367993e-02f, 1.29372448e-01f, 8.82156193e-03f, 7.58242309e-02f, 6.15235558e-03f,
  -4.15425487e-02f, -2.64487993e-02f, -3.06395646e-02f, -5.28692380e-02f, -7.75773032e-03f, 2.04208195e-02f, -3.61534621e-04f, -8.77245292e-02f, -6.01057988e-03f, -5.87232783e-03f,
  1.64791644e-02f, -7.03012478e-03f, 3.82502079e-02f, 1.56829669e-03f, -1.22761389e-03f, 6.13310263e-02f, -6.14343137e-02f, 5.98319881e-02f, -2.39443406e-02f, 3.89231294e-02f,
  -3.08939125e-02f, 8.02473500e-02f, -7.44316168e-03f, -6.02129810e-02f, 6.89372700e-03f, 4.65108231e-02f, 4.92182747e-02f, -6.87352046e-02f, 5.82259223e-02f, 1.78225599e-02f,
  -1.71927392e-01f, 5.93409874e-02f, -1.03129689e-02f, 7.15167448e-02f, 1.04234315e-01f, -2.01136395e-02f, 1.50639238e-02f, -2.92770751e-02f, 4.97182191e-04f, -2.57623270e-02f,
  2.62376554e-02f, -5.27498350e-02f, -5.07257245e-02f, -2.72849873e-02f, -1.15157381e-01f, -1.14644177e-01f, -2.62048412e-02f, 2.17877906e-02f, 2.52176672e-02f, 8.74814019e-02f,
  -4.05674893e-03f, 6.97566243e-03f, -2.38084346e-02f, -1.28647730e-01f, 1.72887245e-04f, -1.64787531e-01f, -1.71486914e-01f, -2.36457437e-02f, -1.38614714e-01f, -2.05591053e-01f,
  9.63577405e-02f, -1.02224663e-01f, -2.21930355e-01f, -2.24540845e-01f, -3.83590996e-01f, -3.27248454e-01f, -4.18900490e-01f, -1.17605990e-02f, -5.40923048e-03f, -1.06649242e-01f,
  -1.18165500e-01f, 5.09041660e-02f, 1.32462755e-01f, 1.03299424e-01f, 2.21475307e-02f, -2.02431157e-01f, -1.06505677e-01f, -1.41954869e-02f, -9.07344185e-03f, -7.80490786e-02f,
  -4.22012061e-02f, 5.77721670e-02f, 9.23582613e-02f, 1.58349991e-01f, -5.41390777e-02f, -2.65177265e-02f, -1.04174316e-02f, 6.10467717e-02f, -1.04124852e-01f, -9.54684690e-02f,
  7.11621717e-03f, -1.08252898e-01f, -6.86990470e-02f, 1.09886885e-01f, -7.07600042e-02f, 8.82037506e-02f, -6.83925748e-02f, 4.67195511e-02f, 6.09456655e-03f, -6.68455809e-02f,
  -8.27165842e-02f, 1.09301776e-01f, -7.51596242e-02f, -3.47672254e-02f, -1.80391148e-02f, 4.03514244e-02f, 1.39444768e-01f, 5.11388890e-02f, 5.38952239e-02f, 6.29990324e-02f,
  -4.88575287e-02f, -1.99500948e-01f, -5.12724109e-02f, 4.32823151e-02f, 1.82743538e-02f, -2.62950081e-02f, -5.77536132e-03f, 1.23743512e-01f, -3.00002918e-02f, 1.04606152e-01f,
  2.11190712e-02f, 2.19407352e-03f, -1.01149669e-02f, 4.77560088e-02f, -7.49499828e-04f, -1.74967851e-02f, -4.57341522e-02f, 1.77493598e-02f, -1.65465046e-02f, 9.98201221e-03f,
  5.81908487e-02f, -4.99846078e-02f, 6.85292855e-02f, -6.71470910e-02f, 3.41379866e-02f, -8.51953551e-02f, -5.91151416e-02f, 9.70305689e-03f, 1.38987352e-05f, 2.34854538e-02f,
  3.08043398e-02f, -4.50559035e-02f, 2.48264913e-02f, 8.55837017e-02f, -4.30886969e-02f, -5.30332653e-03f, -5.78266457e-02f, 2.76156683e-02f, -2.78312638e-02f, -3.84175144e-02f,
  2.12643445e-01f, -1.98614329e-01f, 5.25028184e-02f, 1.09702721e-01f, -5.60898446e-02f, 1.21142112e-01f, -2.65127653e-03f, 7.71925375e-02f, -3.97671536e-02f, 3.04647833e-02f,
  -4.99753207e-02f, 2.58884039e-02f, -5.21483906e-02f, 5.59471287e-02f, -2.89603826e-02f, 1.39189474e-02f, -2.70017907e-02f, -5.76526262e-02f, 1.21561931e-02f, -4.15973179e-02f,
  -4.26300988e-02f, -1.89765524e-02f, -6.67815208e-02f, -4.65513265e-04f, 2.25968417e-02f, -9.72865373e-02f, -1.01108290e-02f, -6.75569614e-03f, -6.63259476e-02f, 4.02920879e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.78818067e-02f, 5.84450811e-02f, 1.27710298e-01f, 1.03474692e-01f, 1.01656772e-01f, -1.28339201e-01f, -2.29005590e-01f, -2.46180683e-01f, -4.81549129e-02f, -4.10413519e-02f,
  1.57298625e-01f, 4.76148091e-02f, 5.61558269e-03f, -1.85817793e-01f, -3.77294332e-01f, -2.87097633e-01f, -3.75196673e-02f, -2.60072380e-01f, -1.74151883e-01f, -2.53872663e-01f,
  -1.34165855e-02f, -5.47532402e-02f, 8.54261313e-03f, 7.09216343e-03f, 2.07297176e-01f, 2.58913673e-02f, 6.71971515e-02f, 5.78960218e-02f, 6.07450530e-02f, 1.11130551e-01f,
  7.24061802e-02f, 1.28727823e-01f, -6.37917742e-02f, -6.45169467e-02f, 7.78939351e-02f, -3.73333879e-02f, -4.64366116e-02f, 4.83694253e-03f, 1.01896226e-01f, -7.33430907e-02f,
  8.44898298e-02f, 4.54289876e-02f, -1.78967547e-02f, -9.60750878e-02f, -1.21329963e-01f, -6.96695000e-02f, -6.50746673e-02f, -1.22294053e-01f, -2.10447852e-02f, -1.13970660e-01f,
  9.56508890e-02f, -2.06193663e-02f, 4.71246280e-02f, -5.72499596e-02f, -1.02216244e-01f, 5.22372052e-02f, 8.37695077e-02f, 9.67454985e-02f, -7.79812559e-02f, -4.73370962e-02f,
  5.53148985e-02f, -2.31601782e-02f, -5.29479757e-02f, 7.02512963e-03f, -6.41375082e-03f, 8.67539942e-02f, -4.18038331e-02f, 5.07947849e-03f, -4.06844262e-03f, 6.03586845e-02f,
  4.62089963e-02f, 9.42821205e-02f, 6.78952364e-03f, -3.67529765e-02f, 3.93118896e-02f, 6.56164885e-02f, -9.63326544e-02f, -1.24715827e-01f, -9.01939645e-02f, 8.85130465e-02f,
  1.75891668e-02f, 3.46683115e-02f, 1.14227429e-01f, -1.59241818e-02f, -5.19997440e-02f, 1.50040798e-02f, -7.22523630e-02f, 1.36726592e-02f, -6.20258376e-02f, -4.37800214e-03f,
  1.28670156e-01f, -6.32729828e-02f, -8.25160965e-02f, -4.11213860e-02f, 5.84041700e-02f, 9.65231210e-02f, 4.18478213e-02f, -5.12303691e-03f, 1.06171213e-01f, -4.13337387e-02f,
  -1.70600116e-02f, -5.02173528e-02f, 4.55910852e-03f, -5.11301830e-02f, -1.04941182e-01f, -6.81016892e-02f, -1.12368688e-01f, -6.00561872e-03f, -6.44837618e-02f, 1.58957634e-02f,
  -4.98182997e-02f, -1.68623611e-01f, -2.22260296e-01f, -9.84793976e-02f, 3.08305658e-02f, -1.53140470e-01f, -1.43885508e-01f, -1.43094555e-01f, -1.39196187e-01f, -2.92544305e-01f,
  -4.15412784e-01f, -1.85538381e-01f, -3.24329138e-01f, -8.99089314e-03f, 1.31730378e-01f, 1.26218826e-01f, 8.77021030e-02f, 5.59358560e-02f, 6.66437745e-02f, -8.78097713e-02f,
  -4.65581492e-02f, 7.05043077e-02f, 1.00299306e-02f, -1.23375971e-02f, 9.67831686e-02f, -1.04698747e-01f, -4.05490771e-02f, -6.17140681e-02f, 1.33420333e-01f, 1.96567118e-01f,
  1.94189176e-01f, 8.40416402e-02f, -1.12110421e-01f, 4.30180617e-02f, -4.78594154e-02f, -4.87622842e-02f, -5.70112020e-02f, -8.60729665e-02f, -4.86362986e-02f, -1.30858541e-01f,
  -2.68933475e-01f, -1.40524060e-01f, 9.45028663e-02f, 2.49485131e-02f, -1.10551894e-01f, -4.13745157e-02f, 6.14462327e-03f, -1.31333545e-01f, -8.57181177e-02f, 4.75829514e-03f,
  2.21519656e-02f, 9.28196218e-03f, -7.41451606e-02f, -3.29986284e-03f, -6.54018298e-02f, 5.43730371e-02f, -9.84315723e-02f, -1.72896534e-01f, -8.62487555e-02f, 1.89268752e-03f,
  1.12324923e-01f, -6.82191104e-02f, -1.62489951e-01f, -3.65842916e-02f, -5.52007668e-02f, -3.92435230e-02f, -1.23483472e-01f, -5.13213454e-03f, -1.22244291e-01f, -8.77449363e-02f,
  7.92378411e-02f, -4.01788652e-02f, -2.45683137e-02f, -3.87491100e-02f, -1.31140593e-02f, -4.86900061e-02f, -5.03160805e-02f, 1.29799312e-02f, 5.28717712e-02f, -4.80072433e-03f,
  2.03522723e-02f, -5.27260713e-02f, 1.14897639e-02f, 3.53913940e-02f, -5.59175760e-02f, -1.80034135e-02f, 6.18051030e-02f, 3.84679772e-02f, -3.36091891e-02f, 1.36441961e-02f,
  5.08356839e-02f, -6.11602589e-02f, -2.49943845e-02f, 6.13785423e-02f, -2.54986845e-02f, 1.18330009e-02f, 2.54733153e-02f, -4.81362175e-03f, -4.61331420e-02f, -9.41682607e-02f,
  -2.98285857e-02f, -9.87471789e-02f, -1.77692294e-01f, 5.19278981e-02f, 2.90738605e-02f, -1.35442525e-01f, -1.12821892e-01f, -4.39445162e-03f, -1.75547488e-02f, 4.41362262e-02f,
  9.98977479e-03f, 3.21196159e-03f, -1.10039212e-01f, -2.27421913e-02f, 6.15327395e-02f, -8.69753286e-02f, -1.26142859e-01f, -9.34718642e-03f, -7.50423670e-02f, -4.80386764e-02f,
  -1.12322450e-01f, -2.40560248e-02f, -2.13123679e-01f, -5.05453125e-02f, 4.26823273e-02f, -1.52583018e-01f, -1.24008104e-01f, -5.27353212e-02f, -5.65313660e-02f, -1.68048516e-01f,
  -3.87070209e-01f, 1.86525971e-01f, 2.33373389e-01f, -2.22846448e-01f, 1.83903784e-01f, 2.77957350e-01f, 3.16337854e-01f, 6.40974566e-03f, -1.03187174e-01f, 8.42526257e-02f,
  1.87755361e-01f, -2.11452648e-01f, -7.48552755e-02f, -2.34746328e-03f, -1.66458234e-01f, 1.56547457e-01f, 3.63841541e-02f, -1.28065765e-01f, -3.02790493e-01f, -7.14999139e-02f,
  -1.10551290e-01f, -3.39908838e-01f, -3.49178284e-01f, -1.05387762e-01f, -7.89358169e-02f, -2.10063726e-01f, -2.33046301e-02f, -6.88719004e-02f, 7.32424036e-02f, 7.09775239e-02f,
  9.66075584e-02f, 1.78292289e-01f, -1.95962742e-01f, -8.02902952e-02f, 6.80052117e-02f, -3.58262062e-02f, 2.26365421e-02f, -8.91993046e-02f, -6.64394647e-02f, -2.82110497e-02f,
  7.46171027e-02f, -8.11637416e-02f, -1.02867559e-01f, -2.00936906e-02f, -1.84903190e-01f, -1.49687573e-01f, -2.70725172e-02f, -1.31013647e-01f, -2.15778872e-02f, 4.89178626e-03f,
  9.22434628e-02f, -6.73875958e-02f, -1.38359278e-01f, 3.19580622e-02f, 1.11441202e-02f, -1.09080188e-01f, -5.21600246e-02f, 1.66895930e-02f, -1.01324268e-01f, -1.77156404e-01f,
  -3.84827107e-02f, 2.60373503e-02f, -3.03107463e-02f, 5.55603625e-03f, -7.74524212e-02f, 5.77069214e-03f, 3.65009531e-02f, -2.22154930e-02f, -1.24294110e-01f, -4.08632196e-02f,
  -1.51767600e-02f, 5.71287721e-02f, -5.21809049e-02f, 2.52407938e-02f, -6.20063469e-02f, 2.61595100e-02f, 6.93817735e-02f, -4.73360978e-02f, -3.59584913e-02f, -5.56532340e-03f,
  -7.33117312e-02f, -2.88254470e-02f, -3.33993300e-03f, -7.14935660e-02f, 5.15943170e-02f, 3.83256301e-02f, -5.01646921e-02f, 2.66502984e-03f, -1.02202289e-01f, 4.91077155e-02f,
  -3.37886661e-01f, 8.93858820e-02f, -1.01379067e-01f, -1.58416867e-01f, -3.09206191e-02f, -4.39348966e-02f, 3.03906817e-02f, 1.77637637e-02f, -2.60460433e-02f, -3.08236722e-02f,
  8.24050605e-02f, -9.93677303e-02f, -7.06390589e-02f, -4.85427231e-02f, -1.04039833e-01f, 2.63706082e-03f, -9.85610411e-02f, -1.37545601e-01f, -1.14799291e-01f, -7.74952099e-02f,
  -5.84568121e-02f, -1.64512753e-01f, -3.17843795e-01f, -1.69448331e-01f, -6.85636178e-02f, -2.59792358e-01f, -1.73338756e-01f, -1.15516700e-01f, -2.50347674e-01f, -3.71237546e-01f,
  3.92868072e-01f, -2.12093219e-01f, 2.86783073e-02f, 2.32767031e-01f, 4.16338630e-02f, 5.80455773e-02f, -2.11080924e-01f, -1.10325711e-02f, 3.05027720e-02f, 8.78977850e-02f,
  4.33012471e-02f, 1.92031428e-01f, 9.47932005e-02f, -3.23665068e-02f, -3.52737047e-02f, -6.97005307e-03f, -7.99748152e-02f, 1.00757115e-01f, 1.40201896e-01f, 1.31501228e-01f,
  5.26226647e-02f, -2.60620788e-02f, 4.77744713e-02f, 6.36263564e-02f, -2.14459840e-02f, 1.12338983e-01f, -2.32769381e-02f, -1.15797795e-01f, -5.51050641e-02f, 7.30905607e-02f,
  2.43848097e-02f, 1.44498181e-02f, 4.41854447e-02f, 1.09088726e-01f, -2.32121181e-02f, -1.76535193e-02f, 5.76841012e-02f, 4.18919586e-02f, -7.78587908e-02f, -7.18685240e-02f,
  -4.96069901e-02f, 4.98624556e-02f, -9.53471195e-03f, -4.06200290e-02f, -4.59543765e-02f, -8.83922949e-02f, 2.22317260e-02f, -1.30645916e-01f, -9.73777398e-02f, -9.04405341e-02f,
  -1.00108191e-01f, 1.92150176e-02f, 8.64627957e-02f, -1.32259548e-01f, -1.20510414e-01f, 1.04076147e-01f, -7.51382783e-02f, 3.71301211e-02f, 7.14062154e-02f, -1.37683898e-02f,
  3.24871875e-02f, 1.40531480e-01f, 1.90159380e-02f, -1.77993514e-02f, 2.95484290e-02f, -1.03478916e-02f, -5.37126809e-02f, -4.01557535e-02f, -3.93655561e-02f, -4.07246500e-02f,
  -6.28096312e-02f, 6.77046403e-02f, -3.62150520e-02f, 8.77539888e-02f, 6.32869778e-03f, 5.36446385e-02f, -2.15621106e-02f, 4.19530598e-03f, -5.81722930e-02f, 1.23283518e-02f,
  6.13098871e-03f, 2.47315411e-02f, 4.45030965e-02f, 2.13774554e-02f, -6.48929402e-02f, 1.03329144e-01f, 1.19046576e-01f, 7.41611347e-02f, 1.25885218e-01f, -4.07776535e-02f,
  -5.13210595e-02f, 4.03889380e-02f, 1.49559543e-01f, 4.46642749e-03f, 5.08561619e-02f, 4.69266325e-02f, 4.11428548e-02f, -8.47086534e-02f, -1.39012203e-01f, -9.12877470e-02f,
  -5.42573780e-02f, 5.85756004e-02f, -1.16602682e-01f, -1.07170288e-02f, -2.80833547e-03f, -6.01125024e-02f, -7.64558613e-02f, 1.20374829e-01f, -2.89486125e-02f, -9.77456048e-02f,
  -1.39981797e-02f, 6.07985966e-02f, 9.61788744e-02f, 8.19666684e-02f, 6.23026863e-02f, 1.75280482e-01f, 4.56230417e-02f, 8.53709877e-02f, 5.74318133e-02f, 3.34643759e-02f,
  9.44587309e-03f, -6.11943938e-02f, 7.02957213e-02f, 6.32037148e-02f, 7.36478120e-02f, -9.46716294e-02f, -3.94296944e-02f, 7.06063583e-03f, 3.06621734e-02f, -8.51671025e-03f,
  -3.64593454e-02f, -3.92236076e-02f, 3.90519314e-02f, 6.56905919e-02f, -1.14520274e-01f, 6.69307783e-02f, -5.87219633e-02f, -6.67562336e-02f, 2.84594353e-02f, 6.01545125e-02f,
  -4.40502800e-02f, -4.48539071e-02f, 4.03694175e-02f, -4.80905548e-02f, 1.18006013e-01f, 1.02743052e-01f, -1.37972329e-02f, -7.22687473e-05f, 7.74054378e-02f, 5.77225685e-02f,
  1.36700258e-01f, 4.32565883e-02f, -7.87988603e-02f, -4.26294096e-02f, 7.45908394e-02f, -6.87087178e-02f, -7.32116327e-02f, 5.92247173e-02f, 6.63405005e-03f, -7.41892355e-03f,
  7.70889446e-02f, 7.11571798e-02f, 2.53640581e-02f, 3.25824432e-02f, 2.44161580e-02f, 3.04100811e-02f, -1.03820696e-01f, -5.07581234e-02f, -6.84021488e-02f, 9.91163682e-03f,
  8.54047313e-02f, 9.11902040e-02f, 9.19052437e-02f, -9.86329280e-03f, -3.06850486e-02f, 4.43518497e-02f, -2.56976075e-02f, -6.24828972e-02f, 4.26846333e-02f, -4.75007296e-02f,
  7.36658946e-02f, 8.29913691e-02f, 5.93599416e-02f, 2.83572618e-02f, 1.05012223e-01f, 2.45213415e-02f, 8.87526125e-02f, 1.03426062e-01f, 4.62825559e-02f, 7.86757171e-02f,
  5.90891540e-02f, 7.54646510e-02f, -9.60950851e-02f, -3.12485695e-02f, -5.64002097e-02f, 1.01237945e-01f, 1.33049279e-01f, 2.28889217e-03f, 2.51123104e-02f, 2.30303314e-03f,
  4.02724110e-02f, 9.51965749e-02f, -7.56122218e-03f, -8.69464055e-02f, 3.57515961e-02f, -3.45283411e-02f, 5.71745113e-02f, 4.92501929e-02f, 3.71588320e-02f, 1.07153371e-01f,
  -4.71683443e-02f, -1.51951149e-01f, 4.21892852e-02f, -2.39215139e-02f, 4.95110452e-03f, -1.54829109e-02f, 6.63840249e-02f, -1.11282174e-03f, -8.56109634e-02f, -1.13626895e-02f,
  8.02955851e-02f, -1.89191243e-03f, -6.75758347e-02f, -1.16787134e-02f, -1.19352445e-03f, 9.75836515e-02f, 6.30035549e-02f, -5.31209335e-02f, -8.85609724e-03f, 4.38318774e-02f,
  5.95962740e-02f, -1.62934121e-02f, -5.86164482e-02f, 5.07552251e-02f, 6.52491078e-02f, 8.57397467e-02f, -5.20518757e-02f, -3.24708223e-02f, 3.78715806e-02f, -2.34340467e-02f,
  -1.98956609e-01f, 1.12960331e-01f, -2.78804712e-02f, -2.91148216e-01f, -5.53043708e-02f, -4.05824594e-02f, 3.74697372e-02f, -1.97360516e-02f, -2.14134842e-01f, -7.31304064e-02f,
  2.32500210e-02f, -2.13354491e-02f, 5.26312098e-04f, 1.33838858e-02f, 1.60717443e-01f, 5.43835871e-02f, 1.37943868e-02f, 5.22736609e-02f, 5.30783311e-02f, -6.43809810e-02f,
  -1.35459378e-02f, -1.56395480e-01f, -1.07191786e-01f, -9.08135436e-03f, -1.63563594e-01f, 1.23872440e-02f, -1.41025066e-01f, -1.20850438e-02f, -2.07889881e-02f, -1.54433861e-01f,
  3.31650198e-01f, -3.66905928e-02f, -4.32091206e-02f, -2.03958657e-02f, -7.85088390e-02f, 1.18311094e-02f, -1.05708085e-01f, -1.34066204e-02f, -4.64110598e-02f, -9.56066698e-02f,
  2.90982351e-02f, -4.97911349e-02f, -7.32053071e-02f, -3.93506438e-02f, -3.43098491e-02f, -9.32707787e-02f, -5.04402444e-02f, -6.32394431e-03f, -1.37912221e-02f, 4.19359170e-02f,
  7.14214295e-02f, 5.06895073e-02f, -4.86037284e-02f, -5.51667474e-02f, -4.66013812e-02f, -1.06742695e-01f, 9.06751752e-02f, -1.17051313e-02f, -6.10179715e-02f, 2.92807650e-02f,
  2.37343200e-02f, 2.90795472e-02f, -3.24306414e-02f, 4.11653370e-02f, 2.11483128e-02f, -4.53902483e-02f, -1.71801895e-02f, 4.22316194e-02f, 5.30036911e-02f, -4.66605462e-02f,
  6.70604259e-02f, -4.31601442e-02f, 4.07218039e-02f, 1.64848939e-03f, 3.79563589e-03f, -1.01966202e-01f, -3.77526367e-03f, -4.56530228e-02f, 1.68539782e-03f, -1.95550304e-02f,
  3.50880660e-02f, 2.86271013e-02f, -1.10524602e-03f, -2.73081604e-02f, -5.42203709e-02f, 1.54601997e-02f, 2.39559803e-02f, 7.73993582e-02f, -9.56204440e-03f, 3.07667833e-02f,
  2.06081063e-01f, 6.53122887e-02f, 8.78774300e-02f, -2.63644326e-02f, -1.01182915e-01f, 2.27800384e-02f, 5.95317744e-02f, -1.05346262e-01f, 1.67094450e-02f, 6.50029629e-02f,
  -3.88873704e-02f, -2.51109190e-02f, -2.57390048e-02f, 4.84916149e-03f, -3.38260196e-02f, 9.47839115e-03f, 6.20218925e-02f, -8.73697922e-02f, -1.44936228e-02f, 5.98605350e-02f,
  -4.57056351e-02f, 3.64350826e-02f, 1.84331670e-01f, 4.76692477e-03f, -8.18974688e-04f, 1.09718360e-01f, 1.85703948e-01f, 1.39462933e-01f, 1.57361552e-01f, 6.23009279e-02f,
  2.79825330e-01f, -1.40288249e-01f, -8.48885402e-02f, 6.73295511e-03f, -1.14487171e-01f, -6.70234039e-02f, -1.39302820e-01f, 3.09121865e-03f, 2.45014187e-02f, -7.32248798e-02f,
  -5.11377715e-02f, -7.32168704e-02f, 4.67773341e-02f, -1.07478835e-01f, -6.94320071e-03f, -9.47631821e-02f, -6.37275055e-02f, 6.92581898e-03f, 2.15483509e-04f, -1.47006586e-02f,
  -4.17460427e-02f, -1.01705872e-01f, 9.99656320e-03f, -2.50518434e-02f, 2.87318416e-02f, 1.19508822e-02f, -7.82554299e-02f, -1.13258570e-01f, -1.50854856e-01f, -2.04535797e-02f,
  2.02831514e-02f, 1.27616018e-01f, -9.00220871e-02f, 1.80723686e-02f, 3.06517556e-02f, 7.33132139e-02f, 4.46759211e-03f, -1.78969968e-02f, -6.48018345e-02f, 9.75776836e-02f,
  -2.09730305e-02f, -8.21122155e-02f, 6.88319802e-02f, 2.86564976e-02f, 1.58542600e-02f, 1.30985389e-02f, -5.53546436e-02f, 6.89725280e-02f, -6.95086047e-02f, -1.39162131e-02f,
  -1.66104153e-01f, -4.21035737e-02f, 3.81085984e-02f, 1.55530898e-02f, -5.69434986e-02f, -1.77146439e-02f, -8.61376338e-03f, 9.44826156e-02f, -7.80201405e-02f, -6.64547011e-02f,
  -1.38063312e-01f, 2.17541065e-02f, -2.40390357e-02f, 2.54569738e-03f, 1.87867861e-02f, -6.31393269e-02f, 7.91053474e-02f, 5.51796332e-02f, -7.38862008e-02f, -3.95336524e-02f,
  -5.58727719e-02f, -2.02303007e-02f, -7.16737732e-02f, 5.05777411e-02f, 1.03010293e-02f, 1.11837890e-02f, 4.57461923e-02f, -8.95801112e-02f, -7.48785585e-02f, -4.33001667e-02f,
  1.61375292e-02f, 1.14578372e-02f, 3.22330333e-02f, -7.30478019e-02f, -5.85684851e-02f, -9.24378168e-03f, 8.23207349e-02f, 5.18021872e-03f, -8.06495547e-02f, 4.55858335e-02f,
  1.49938986e-01f, -2.79633906e-02f, 2.50845160e-02f, -2.23180633e-02f, 6.33314550e-02f, -5.57440557e-02f, -5.09742722e-02f, -1.10591715e-03f, -1.53232459e-02f, 5.90419024e-03f,
  -1.07198693e-01f, 6.21063150e-02f, -4.21425439e-02f, -5.17894560e-03f, 1.60324648e-02f, 7.18847811e-02f, -3.91133390e-02f, 3.01028974e-02f, -7.73366094e-02f, -4.52188812e-02f,
  -1.29271716e-01f, 2.89836135e-02f, 2.00456068e-01f, 8.76336619e-02f, 2.05228962e-02f, 3.51133160e-02f, -7.61818606e-03f, 8.42686445e-02f, 8.46136361e-02f, 1.05490729e-01f,
  3.49295408e-01f, -1.02485582e-01f, -1.17655113e-01f, 5.76328859e-02f, 1.44738480e-01f, 4.11837408e-03f, -6.97949156e-02f, -2.02557892e-02f, 9.24754236e-03f, 1.77697111e-02f,
  1.16258888e-02f, 4.43307497e-02f, -7.00409189e-02f, -1.50662944e-01f, -1.62301827e-02f, -1.12680942e-01f, 8.92438740e-02f, 1.78157128e-02f, -1.44588016e-02f, 8.59008133e-02f,
  1.61473408e-01f, 1.37327358e-01f, 5.45200706e-02f, 1.06851578e-01f, 1.08995773e-01f, 1.07714478e-02f, 3.57267633e-02f, 3.68832722e-02f, -3.29335593e-02f, 7.96783790e-02f,
  6.36731014e-02f, -8.57695937e-02f, -1.04432143e-01f, 9.92314443e-02f, -9.46333036e-02f, -6.25209808e-02f, 7.57680163e-02f, 2.30482910e-02f, -1.39865819e-02f, -5.69457114e-02f,
  -1.67892724e-02f, 6.47290573e-02f, 3.04367095e-02f, 2.85318717e-02f, -4.28578518e-02f, 2.07351297e-02f, 3.11063398e-02f, -1.06384955e-01f, -7.34117627e-02f, 1.25296982e-02f,
  1.82256158e-02f, 2.22187378e-02f, -3.41125503e-02f, -1.49940208e-01f, -8.60606581e-02f, -1.04859568e-01f, -1.65483072e-01f, -3.94922215e-03f, -2.89620105e-02f, 1.18855588e-01f,
  5.97123057e-02f, -7.17176795e-02f, -9.40280408e-02f, 1.28801828e-02f, -9.86641198e-02f, -1.08820274e-02f, 3.01786717e-02f, -6.47348389e-02f, -2.75784475e-03f, 1.17368519e-03f,
  -9.29086730e-02f, -1.10466771e-01f, 6.94346949e-02f, -4.41654101e-02f, 5.51086888e-02f, 4.32509296e-02f, -1.31884515e-02f, 5.60232997e-02f, -5.16765378e-02f, 5.30375168e-02f,
  -2.56915409e-02f, -2.42684893e-02f, 9.19454470e-02f, 3.00907232e-02f, -3.54437251e-03f, 1.87366717e-02f, 7.79738128e-02f, -1.93677731e-02f, -7.64299557e-02f, 1.02685399e-01f,
  3.96242663e-02f, -1.88076943e-01f, 4.93408926e-02f, -5.25040366e-02f, -3.93505907e-03f, -8.92636478e-02f, -6.32236823e-02f, 1.24900825e-02f, -1.00961126e-01f, -1.22055912e-03f,
  -1.12243682e-01f, -1.36074340e-02f, -3.09913959e-02f, -4.94830422e-02f, 1.31184801e-01f, 4.25781682e-02f, -2.43267864e-02f, 5.17465621e-02f, 3.05221900e-02f, 6.11643158e-02f,
  -7.60311186e-02f, 2.65170895e-02f, 2.73767095e-02f, 1.66805107e-02f, 6.80713207e-02f, 1.34166390e-01f, -1.99203622e-02f, 3.25218402e-02f, -8.45151991e-02f, 5.88181987e-02f,
  3.11290622e-01f, 2.52469629e-01f, -3.44706446e-01f, 9.86595452e-02f, -1.51815981e-01f, -1.52676985e-01f, 1.57581363e-02f, -3.38847116e-02f, 4.19306708e-03f, 1.09466091e-01f,
  -1.76739022e-02f, -6.41108975e-02f, -1.86636567e-01f, -1.72762707e-01f, -3.58705074e-02f, 2.92071439e-02f, -1.19680325e-02f, -2.45866746e-01f, -1.23162761e-01f, -5.56027815e-02f,
  -2.63459105e-02f, 9.20205787e-02f, -5.50601706e-02f, -7.29287090e-03f, 4.15644906e-02f, -7.67144561e-02f, -2.44017504e-03f, -7.96810687e-02f, -1.22970924e-01f, 4.47148457e-03f,
  -2.22090200e-01f, -7.33888000e-02f, -1.05403643e-02f, 7.96287507e-02f, -2.13986970e-02f, 1.31071666e-02f, -2.61322893e-02f, -2.41350662e-02f, 1.27487734e-03f, 9.60772112e-02f,
  -7.87896737e-02f, 4.11281642e-03f, 2.55899783e-02f, -1.02954350e-01f, -8.54842439e-02f, -5.55468388e-02f, 8.51013437e-02f, -3.52522619e-02f, -2.09784415e-02f, -4.86014076e-02f,
  -7.59135000e-03f, -4.01016548e-02f, -7.52615277e-03f, 7.27978721e-02f, -1.10829063e-01f, -1.71310276e-01f, -1.22324526e-02f, -2.72820517e-02f, -4.56600152e-02f, 2.15787262e-01f,
  3.70187014e-02f, -8.29791352e-02f, 4.77257520e-02f, -3.45499404e-02f, 1.07086517e-01f, -2.31376942e-02f, -6.55912831e-02f, 8.16621855e-02f, 3.14772092e-02f, 4.34966683e-02f,
  8.66119191e-02f, -4.10428569e-02f, -6.26405329e-03f, 1.22331813e-01f, -5.76282255e-02f, 1.58690475e-02f, -2.51846034e-02f, 1.12995356e-01f, 6.41846880e-02f, 8.30666646e-02f,
  3.14691290e-02f, -7.50271138e-03f, -1.51517466e-02f, 6.51949570e-02f, -3.90795991e-02f, 1.29734119e-02f, -7.67745376e-02f, -9.08564255e-02f, -3.14108506e-02f, -1.01683952e-01f,
  1.75304875e-01f, -2.16557756e-01f, 1.00485615e-01f, 1.64500028e-02f, -1.90440752e-03f, 1.56459771e-02f, 2.03842521e-02f, 8.23020041e-02f, -3.50036547e-02f, 7.20951753e-03f,
  -3.35231088e-02f, -4.71735112e-02f, 2.26604185e-04f, -2.75165029e-02f, 5.78495897e-02f, 1.06644060e-03f, 1.45356208e-01f, -1.48172723e-02f, -9.44151580e-02f, 5.78201972e-02f,
  1.01842001e-01f, 1.24750875e-01f, 1.46465778e-01f, 2.23590527e-02f, -1.10039189e-02f, -1.30511016e-01f, -4.59887311e-02f, 9.41994637e-02f, -1.05725855e-01f, 4.01137799e-01f,
  -1.51536301e-01f, -1.08638465e-01f, 2.39945352e-01f, -1.13689691e-01f, 2.08959535e-01f, 2.27562934e-01f, 3.27932805e-01f, 1.06164016e-01f, -4.55741026e-02f, -6.90510646e-02f,
  -6.93902522e-02f, -2.21341327e-01f, -1.80101931e-01f, -5.48492037e-02f, -8.81273150e-02f, 1.38058409e-01f, 5.45799769e-02f, -6.73748925e-02f, 1.05715029e-01f, 1.34388520e-03f,
  -1.00952409e-01f, -2.24729273e-02f, -8.06785375e-03f, -1.21352091e-01f, -1.14315264e-01f, -1.51035935e-01f, -1.99281946e-02f, -4.44229208e-02f, -2.14139055e-02f, -4.12024994e-04f,
  1.66629872e-03f, 1.14867434e-01f, -6.80700466e-02f, -8.72415975e-02f, -2.25605927e-02f, 1.19787119e-02f, -4.08385694e-02f, -5.53735085e-02f, -5.48467934e-02f, -1.05337173e-01f,
  2.32299082e-02f, -2.91900383e-03f, -7.70644192e-03f, 1.88624524e-02f, 1.36002526e-02f, 2.26122979e-02f, 1.27523094e-02f, -1.03091355e-03f, 6.09098263e-02f, -5.21201305e-02f,
  6.33893833e-02f, 1.58028245e-01f, 1.36986032e-01f, 2.56543178e-02f, -1.13227842e-02f, 6.26389217e-03f, 9.00315121e-03f, 5.40416427e-02f, 5.93360923e-02f, -8.30843225e-02f,
  -5.27331382e-02f, -7.83456936e-02f, -3.89091335e-02f, -8.67101271e-03f, 4.82266620e-02f, -6.70082197e-02f, 1.38458014e-02f, 3.12649459e-02f, -9.98271536e-03f, 2.24320870e-02f,
  6.96113706e-02f, 8.63791928e-02f, 8.71867780e-03f, 3.27122933e-03f, -8.59955773e-02f, 4.91573289e-03f, 7.88970590e-02f, 6.38034940e-02f, 4.61006351e-03f, 7.27937222e-02f,
  -1.39264343e-02f, -1.57790014e-03f, 9.54522844e-03f, -5.92437796e-02f, 3.87912728e-02f, 1.14819914e-01f, 8.57239217e-02f, 2.45117061e-02f, -7.38218334e-03f, -2.34209616e-02f,
  -7.42653012e-02f, 1.41123369e-01f, -5.05476743e-02f, -3.13323736e-02f, 6.98465556e-02f, 2.52471995e-02f, -5.95088042e-02f, -7.94349164e-02f, 5.82333468e-02f, 7.14725628e-02f,
  -4.75455541e-03f, -5.04330508e-02f, -6.86100125e-02f, -2.48982459e-02f, 1.05149120e-01f, 7.08818287e-02f, -1.02816321e-01f, -2.67640576e-02f, 9.62982029e-02f, 5.08728288e-02f,
  3.49540934e-02f, 1.09919615e-01f, 5.62334098e-02f, 8.51080865e-02f, 2.05133553e-03f, 3.74382511e-02f, -1.93595532e-02f, 2.80385204e-02f, 1.20629266e-01f, -1.05890661e-01f,
  -6.13791533e-02f, -5.84857985e-02f, 9.27523058e-03f, 7.54967555e-02f, -9.33642313e-02f, 8.06735083e-03f, -1.19918935e-01f, 2.98924185e-02f, -1.44282887e-02f, -4.18047346e-02f,
  7.43673965e-02f, 3.69529240e-02f, 7.59006068e-02f, 2.69728694e-02f, -1.65205389e-01f, -3.03984284e-02f, -4.84970026e-02f, -2.24526227e-02f, -9.99283046e-02f, -4.51808758e-02f,
  -1.05224419e-02f, -7.62195587e-02f, -8.64398554e-02f, -3.24983262e-02f, 1.38223858e-03f, 3.17904875e-02f, 5.00884242e-02f, 2.53194887e-02f, 4.43283729e-02f, 3.70626673e-02f,
  2.11322308e-01f, -7.15310499e-02f, -6.00012578e-02f, 2.91268621e-02f, 3.72838043e-02f, 3.89634185e-02f, 6.03945479e-02f, -2.37180144e-02f, -4.67373319e-02f, -1.55225093e-03f,
  8.01047031e-03f, -4.67510484e-02f, 7.73789287e-02f, -5.32467812e-02f, -1.05201185e-01f, 4.64765094e-02f, -5.56619205e-02f, 1.14253722e-02f, -4.03985381e-02f, -2.37706974e-02f,
  1.79998798e-03f, 4.02075090e-02f, -9.88414735e-02f, 9.17121302e-03f, 4.28378209e-02f, 2.64591761e-02f, 3.02332640e-02f, 7.47488663e-02f, -8.85312166e-03f, -6.25619963e-02f,
  -8.03624392e-02f, 2.09180340e-02f, -9.05213878e-03f, -8.30928087e-02f, -4.92862575e-02f, 2.23829672e-02f, -6.29471987e-02f, 5.41694881e-03f, -1.76061019e-02f, 2.55316235e-02f,
  3.77602264e-04f, -2.03343406e-02f, 7.40723759e-02f, 3.14110816e-02f, 3.07865292e-02f, -7.40907574e-03f, 5.97534217e-02f, -7.15112463e-02f, -8.82864520e-02f, -1.10069392e-02f,
  4.85780537e-02f, 5.49872816e-02f, 2.45170072e-02f, -4.48430926e-02f, -6.50588498e-02f, -4.95775715e-02f, -9.20214802e-02f, -4.96011525e-02f, -7.66925141e-02f, -6.98049441e-02f,
  1.81651026e-01f, -1.59887061e-01f, 4.64844964e-02f, 5.08387350e-02f, 6.18824437e-02f, -8.30557123e-02f, 8.21149796e-02f, -3.02002765e-02f, -5.69234453e-02f, 5.43216094e-02f,
  4.13473994e-02f, -2.47167740e-02f, -6.65400550e-02f, -4.96361963e-02f, -6.00296073e-02f, 2.90001016e-02f, -3.52269188e-02f, -4.66872789e-02f, 1.70920733e-02f, -7.29132295e-02f,
  3.77913564e-02f, 3.40383127e-02f, 1.17720049e-02f, 1.37462532e-02f, 5.07637346e-03f, -6.09765984e-02f, 1.15239900e-02f, -8.71193968e-03f, 7.17419609e-02f, -6.10464029e-02f,
  2.47137547e-01f, -1.12104021e-01f, -1.15978211e-01f, 5.54119684e-02f, -1.43848835e-02f, -7.87271112e-02f, 3.21113244e-02f, -3.52966376e-02f, 1.24663869e-02f, -1.04302846e-01f,
  -5.40588610e-02f, 9.56757143e-02f, 1.28500357e-01f, 3.29068638e-02f, 5.08192144e-02f, -7.78541639e-02f, -8.36655125e-02f, 5.03333732e-02f, 1.01729147e-01f, 2.88352207e-03f,
  7.11931139e-02f, -3.60463373e-02f, -3.38459536e-02f, -1.05199531e-01f, -1.66181058e-01f, 3.00016813e-02f, -1.34403676e-01f, -1.48278952e-01f, -1.67770565e-01f, -2.03695670e-01f,
  1.36513352e-01f, -1.18982822e-01f, 5.52230142e-02f, 2.26518307e-02f, -1.49186105e-01f, -8.64458978e-02f, 1.05788587e-02f, -1.28963470e-01f, -8.88746306e-02f, -7.91149959e-02f,
  -9.32129249e-02f, 7.24264188e-03f, -4.22765724e-02f, -1.43009260e-01f, 6.47711083e-02f, 4.10854071e-02f, -8.55907202e-02f, -1.50852203e-01f, -2.94982381e-02f, -6.48715943e-02f,
  -7.93569461e-02f, -1.35549039e-01f, 1.91183649e-02f, -2.42512450e-02f, -5.79234846e-02f, -7.31581524e-02f, -9.83701572e-02f, -1.25911027e-01f, -1.30885080e-01f, -2.02402882e-02f,
  -3.30675058e-02f, 5.56581914e-02f, -6.58092275e-02f, -4.15444337e-02f, -3.12373284e-02f, 4.57426906e-02f, 9.52374116e-02f, 1.24082305e-02f, -3.72053906e-02f, -3.76909077e-02f,
  6.66700187e-04f, -4.38447334e-02f, -8.34776536e-02f, 3.38785499e-02f, 5.44408709e-02f, -8.43742490e-02f, -4.65756468e-02f, 7.64656216e-02f, -2.35598702e-02f, 4.55795154e-02f,
  -6.11209078e-03f, -4.93389741e-02f, -9.54811946e-02f, -6.23647124e-02f, -1.34036377e-01f, -5.26458882e-02f, -2.26787999e-02f, -7.92499706e-02f, 2.06022663e-03f, 4.07619365e-02f,
  3.79956841e-01f, -1.51268199e-01f, 1.02599122e-01f, 8.76468047e-02f, 1.62944663e-02f, -6.63350374e-02f, -2.64641214e-02f, -6.78137168e-02f, -3.22899558e-02f, 3.94356363e-02f,
  -1.19162865e-01f, 3.90119366e-02f, 4.17446345e-02f, -3.31633165e-02f, -2.86183339e-02f, -5.84568046e-02f, 4.77677360e-02f, 9.29567292e-02f, 9.71583184e-03f, -1.49071470e-01f,
  -3.00631784e-02f, 6.65697455e-02f, 3.07840317e-01f, 1.14344142e-01f, -1.05564907e-01f, 2.29195744e-01f, 2.07567930e-01f, 1.49786219e-01f, 1.60379797e-01f, 2.78293878e-01f,
  1.08771846e-01f, -1.86401337e-01f, -1.93643153e-01f, 2.33463451e-01f, -2.46904586e-02f, -3.35949033e-01f, -2.66275823e-01f, -1.10007390e-01f, 1.73040017e-01f, -7.94181079e-02f,
  -4.49111871e-03f, 2.69879233e-02f, -7.40440190e-02f, -1.93611071e-01f, -3.02108198e-01f, -3.48755032e-01f, -2.26359189e-01f, -3.09998155e-01f, -2.37023160e-01f, -1.02150433e-01f,
  1.06974870e-01f, 2.00988844e-01f, 8.32217559e-02f, 7.00697452e-02f, 1.91389978e-01f, 1.97226569e-01f, 8.63529369e-02f, 8.63477141e-02f, -9.83558074e-02f, 2.53208969e-02f,
  3.25705186e-02f, 3.61712985e-02f, -1.02754645e-01f, 8.96302685e-02f, 2.23688949e-02f, -5.21252584e-03f, -7.75789246e-02f, 9.54448432e-02f, -3.67179629e-03f, 1.52464472e-02f,
  2.94570699e-02f, -6.59601688e-02f, 6.68357536e-02f, 2.94616586e-03f, -5.15804924e-02f, 1.47134457e-02f, -1.04632922e-01f, -1.74525663e-01f, -6.76623499e-03f, 1.11352256e-03f,
  -2.15930224e-04f, -8.67408440e-02f, -2.12081745e-01f, -1.59333840e-01f, -4.50482927e-02f, -6.53532743e-02f, 2.26651393e-02f, -3.96038666e-02f, -1.08108938e-01f, 1.27713233e-01f,
  -4.48787352e-03f, -8.66826773e-02f, 1.45734418e-02f, 5.41021898e-02f, 2.60454137e-03f, -2.08271872e-02f, 2.64121816e-02f, -1.02496140e-01f, 2.27610879e-02f, -1.26510607e-02f,
  -8.69951099e-02f, -2.03856677e-02f, 3.64854559e-02f, 2.53709573e-02f, -7.38290548e-02f, -6.92839250e-02f, -2.95683127e-02f, 4.43012118e-02f, -8.16571638e-02f, 7.45055303e-02f,
  -3.47972661e-02f, 6.88571557e-02f, 2.44204588e-02f, 5.66368131e-03f, -7.19770566e-02f, -2.47054710e-03f, 1.43981185e-02f, 9.48802754e-02f, 2.93982271e-02f, 1.03664093e-01f,
  3.72121483e-01f, -1.88709721e-01f, 7.29038520e-03f, -4.00963873e-02f, -4.87456238e-03f, -2.11340208e-02f, 4.25111577e-02f, -7.30544254e-02f, -2.23782808e-02f, -5.13959490e-02f,
  -6.51224032e-02f, -4.10869904e-02f, -5.66274412e-02f, -4.72689569e-02f, -6.02876879e-02f, -2.37058848e-02f, -1.10780731e-01f, -1.73322875e-02f, -1.14941739e-01f, 6.76398501e-02f,
  -4.43048254e-02f, -1.15502149e-01f, -8.82018059e-02f, -1.60051316e-01f, 6.63014501e-02f, -9.25167426e-02f, -1.03727259e-01f, -8.33828598e-02f, -1.42112836e-01f, 4.30746190e-02f,
  3.08177271e-03f, 3.13400738e-02f, -1.64454460e-01f, 1.36550013e-02f, -6.14880957e-02f, -2.40971800e-02f, -7.73214698e-02f, 6.83639646e-02f, 1.62662659e-02f, 2.69464832e-02f,
  -5.76588027e-02f, 8.58216640e-03f, -2.53311824e-02f, -1.05486244e-01f, -3.04263718e-02f, 9.26057342e-03f, 1.06392400e-02f, -9.77028757e-02f, -1.33788511e-01f, -3.14549208e-02f,
  4.27322835e-02f, -6.35997504e-02f, 3.69743370e-02f, 3.91359907e-03f, 7.08511248e-02f, -5.22071905e-02f, -2.73084044e-02f, -3.29581089e-02f, -4.14423719e-02f, -1.06354788e-01f,
  -5.01689650e-02f, -7.80235603e-02f, -9.08611640e-02f, 1.15294522e-02f, 4.78012040e-02f, 8.26415548e-04f, 7.26136789e-02f, -3.56909931e-02f, 7.33436197e-02f, -2.85399687e-02f,
  -6.67915791e-02f, -1.07946292e-01f, 1.49447620e-02f, 4.66009323e-03f, 3.90575901e-02f, -1.76077348e-03f, 7.77906105e-02f, 5.81592657e-02f, -4.15086672e-02f, -6.60287291e-02f,
  4.91232052e-02f, -1.32436991e-01f, -1.27449576e-02f, 6.99024135e-03f, 4.47757430e-02f, -1.60146445e-01f, 4.55671325e-02f, 3.11650913e-02f, 2.59888428e-03f, 1.41042396e-01f,
  4.92295809e-02f, 1.24395646e-01f, -2.22841389e-02f, 1.09816693e-01f, 7.95261264e-02f, 5.16081229e-02f, 8.47974196e-02f, 2.44880887e-03f, 3.55126038e-02f, 6.35050088e-02f,
  1.59454457e-02f, -4.33878712e-02f, -6.08507283e-02f, 7.25662988e-03f, -7.65496790e-02f, 1.21468846e-02f, -2.88230274e-02f, -1.57902539e-02f, -7.09361862e-03f, -8.03603679e-02f,
  -4.38810363e-02f, -1.08763784e-01f, -4.92112897e-02f, -4.92435358e-02f, -8.04879144e-02f, 4.37271707e-02f, -2.26164032e-02f, 4.32738252e-02f, -5.01164272e-02f, -4.38236929e-02f,
  1.66531324e-01f, -2.50966549e-01f, 3.44281048e-02f, -4.73437645e-02f, -8.40577111e-02f, -4.23683831e-03f, 3.88619266e-02f, -4.85275388e-02f, -6.73500001e-02f, 4.99577448e-02f,
  -1.85744744e-02f, -1.84514690e-02f, 4.78242412e-02f, 6.57731369e-02f, 8.17262009e-02f, 9.23090149e-03f, 3.09218392e-02f, 8.22778046e-02f, -4.35309373e-02f, 3.97574827e-02f,
  1.01154402e-01f, 1.11532182e-01f, 1.02412812e-01f, 1.15400106e-01f, 1.10097567e-03f, -9.75918993e-02f, 1.14356980e-01f, 4.00116146e-02f, 7.17205703e-02f, 2.62379199e-01f,
  1.37072593e-01f, -5.92903011e-02f, -1.15224324e-01f, 2.16803253e-02f, 1.72412336e-01f, 8.10078904e-02f, 1.48913950e-01f, 1.00624032e-01f, 5.96505962e-02f, 6.68373629e-02f,
  2.88213976e-02f, 1.09810077e-01f, 1.49734840e-01f, 1.38397753e-01f, -9.30798333e-03f, 1.25121802e-01f, -1.10345595e-02f, -2.93464400e-02f, 1.00989215e-01f, -2.44619958e-02f,
  9.74911377e-02f, -2.37371167e-03f, -9.06811375e-03f, -1.77947506e-02f, -7.81264678e-02f, 1.40424103e-01f, -5.37661426e-02f, -1.08098304e-02f, -9.70099121e-02f, 1.57755092e-02f,
  -2.81516854e-02f, -6.17338642e-02f, 1.66225642e-01f, 6.49709553e-02f, -3.54743227e-02f, -7.33424947e-02f, -2.60439515e-02f, -1.11940555e-01f, 3.68995108e-02f, -1.19780995e-01f,
  2.65532248e-02f, -1.16141289e-01f, 5.36250658e-02f, -7.12305009e-02f, -9.20133889e-02f, -5.22302873e-02f, -3.65781523e-02f, 2.81194095e-02f, 7.18704015e-02f, -7.71969259e-02f,
  1.24098817e-02f, 3.80868018e-02f, -5.02220206e-02f, 9.38356444e-02f, 8.03563967e-02f, -3.98790911e-02f, -1.21016018e-01f, 2.20120493e-02f, 5.26130274e-02f, -7.89956748e-02f,
  2.95012724e-02f, -5.80028296e-02f, 7.03912154e-02f, 7.46724680e-02f, 1.15519829e-01f, 8.27818736e-02f, 5.02956025e-02f, 8.05711672e-02f, 5.48405312e-02f, 8.14696960e-03f,
  -5.76452166e-02f, -1.33174341e-02f, 9.73724648e-02f, 1.10796787e-01f, 1.23879872e-02f, 4.14870866e-02f, -4.97078430e-03f, -5.43712713e-02f, 3.80903371e-02f, -3.51825170e-02f,
  -4.01702058e-03f, -9.80038941e-02f, -9.86418501e-02f, -9.36734825e-02f, -9.34612006e-03f, -7.21643791e-02f, -3.83736156e-02f, -6.05443958e-03f, 6.59952080e-03f, -3.82132307e-02f,
  -5.60122915e-02f, -5.59544517e-03f, -5.48421964e-03f, 6.06500171e-02f, -1.30274951e-01f, -1.15274638e-01f, 1.05236527e-02f, -6.39178753e-02f, -2.63923351e-02f, 1.41409952e-02f,
  1.18299322e-02f, -3.43966149e-02f, -9.58725065e-02f, -2.66924035e-04f, 8.34004134e-02f, 8.83364826e-02f, -7.25281164e-02f, 1.08392030e-01f, -5.25934957e-02f, -7.43906051e-02f,
  -2.35750433e-02f, 7.59957954e-02f, 1.53191835e-01f, 1.81545749e-01f, 2.54225358e-02f, 1.66049570e-01f, 4.44298498e-02f, -5.16211279e-02f, 1.34140119e-01f, 8.79443437e-02f,
  -5.37140548e-01f, 2.40392964e-02f, -5.80276810e-02f, -8.36671442e-02f, 1.56123474e-01f, 1.97631851e-01f, 1.72167763e-01f, 1.13301478e-01f, 6.77449182e-02f, -7.44485408e-02f,
  -1.14187561e-02f, 1.08276412e-01f, 1.44321769e-01f, 2.04928681e-01f, 1.08504817e-01f, 2.56446362e-01f, 1.90739647e-01f, 2.69617401e-02f, 9.24424529e-02f, 3.75584289e-02f,
  6.46726340e-02f, -8.91928375e-02f, -9.07541141e-02f, 1.00089155e-01f, 1.27426088e-01f, 4.01904285e-02f, 2.84784622e-02f, 4.91943769e-02f, 2.90547237e-02f, 8.04850981e-02f,
  -1.36008859e-01f, -2.36733198e-01f, 6.23860210e-02f, -5.63881919e-02f, -5.46706282e-02f, -4.26464863e-02f, -9.56248716e-02f, -1.30941868e-01f, -1.19189113e-01f, -8.21950957e-02f,
  -7.15973899e-02f, -4.40853275e-02f, 2.70354506e-02f, -1.17652483e-01f, -1.34694546e-01f, -4.96849604e-02f, -5.92398122e-02f, -7.58956671e-02f, 3.49952728e-02f, -3.02695413e-03f,
  1.13058217e-01f, -1.10318072e-01f, 1.60913495e-03f, 8.39765668e-02f, -3.41348350e-02f, 8.38796768e-05f, 3.14146355e-02f, -6.60073087e-02f, 9.37534310e-03f, -1.07949652e-01f,
  2.06461549e-02f, -4.59602252e-02f, -4.10054848e-02f, 3.82487895e-03f, -8.40631574e-02f, 6.30978197e-02f, -1.18216351e-02f, 7.26313740e-02f, -6.82861730e-02f, 4.38703485e-02f,
  -8.54780618e-03f, -1.16618488e-04f, -7.80749097e-02f, -2.56079361e-02f, 7.46180490e-02f, 5.71933351e-02f, -8.29686299e-02f, 5.09827472e-02f, -7.60868415e-02f, 2.83485800e-02f,
  -8.16511083e-03f, -5.40565513e-02f, -1.02446424e-02f, 3.59489620e-02f, 2.31472543e-03f, 1.26719857e-02f, -6.95779100e-02f, -5.43966442e-02f, -8.34969729e-02f, -4.90949191e-02f,
  1.55011192e-01f, 1.42979220e-01f, -4.76523861e-02f, -7.82219134e-03f, -4.57731672e-02f, -1.50268478e-02f, -3.50345373e-02f, -7.09968656e-02f, 7.54471868e-02f, -9.13574174e-02f,
  1.19310236e-02f, -4.61959653e-02f, 6.85134232e-02f, -1.00670774e-02f, 4.52409573e-02f, -2.54143346e-02f, -2.89492775e-02f, 4.34398949e-02f, 1.20700523e-01f, -9.16559249e-02f,
  8.65303725e-02f, -2.85029504e-02f, -7.05988333e-03f, 1.49956763e-01f, -2.74892952e-02f, -2.41719726e-02f, 2.72406708e-03f, -3.87054123e-02f, 6.46281764e-02f, -9.39718410e-02f,
  1.45062804e-01f, -6.07449561e-03f, 1.32461032e-02f, 1.44716904e-01f, 6.21934142e-03f, -4.53944411e-03f, -7.75044709e-02f, -1.24444790e-01f, 5.60194142e-02f, 5.87388910e-02f,
  1.36269659e-01f, 2.44384378e-01f, 2.00253636e-01f, 1.43910080e-01f, 6.48266524e-02f, -5.80649376e-02f, 8.41594860e-03f, -3.57985273e-02f, 7.15432987e-02f, 1.49562299e-01f,
  1.73123956e-01f, 1.87884629e-01f, 5.45026883e-02f, 1.19734429e-01f, 1.58012182e-01f, 1.53943837e-01f, -1.29552828e-02f, 7.25772157e-02f, 4.36282456e-02f, 1.83282048e-01f,
  7.85521492e-02f, -1.87631026e-02f, -2.51322296e-02f, 1.53768500e-02f, -2.35155672e-02f, 3.83754517e-03f, -2.29663122e-03f, -9.79950503e-02f, -7.50539778e-03f, -7.87699521e-02f,
  6.44668788e-02f, 5.26584722e-02f, 2.35587843e-02f, -9.09003839e-02f, -5.42682633e-02f, 2.03596074e-02f, 2.92887874e-02f, -5.67422099e-02f, -1.19401485e-01f, -4.42487225e-02f,
  3.23431827e-02f, 2.23400239e-02f, -1.27862003e-02f, -6.73910379e-02f, -9.33659151e-02f, 4.04900722e-02f, -1.89283285e-02f, -2.32683569e-02f, -1.25072330e-01f, 9.05746594e-03f,
  -2.18534619e-02f, 3.66347395e-02f, -1.29020540e-02f, 7.48635903e-02f, 5.60555831e-02f, 1.78130642e-02f, -4.38763276e-02f, 9.41898003e-02f, -5.86354733e-02f, 4.45297211e-02f,
  3.97792570e-02f, -1.61860394e-03f, -2.12687603e-03f, 5.09724729e-02f, 2.91614793e-02f, 1.00796961e-03f, -2.55468278e-03f, 4.95524481e-02f, -2.34407671e-02f, -4.39060889e-02f,
  8.43751281e-02f, -6.32886887e-02f, 1.19421808e-02f, -1.34051975e-03f, 1.02160256e-02f, 4.32689078e-02f, 2.53622252e-02f, 7.92982653e-02f, -5.41357733e-02f, -2.80651897e-02f,
  -5.50157763e-02f, -5.58067597e-02f, 1.10986978e-01f, 5.60926162e-02f, -2.01185476e-02f, -5.09668961e-02f, -3.32435519e-02f, -3.65765044e-03f, -1.95906442e-02f, -4.71555740e-02f,
  4.87142010e-03f, 2.09352039e-02f, -1.07225396e-01f, 3.93958092e-02f, -9.84180160e-03f, -6.85127378e-02f, -5.16653061e-02f, -8.81747007e-02f, -5.13007818e-03f, 2.19532810e-02f,
  -3.93321328e-02f, -1.90568212e-02f, -1.42160356e-01f, -1.13776192e-01f, -8.03895965e-02f, 3.84996310e-02f, 1.00917099e-02f, -1.15872033e-01f, -9.21141580e-02f, -5.88028654e-02f,
  -1.58194661e-01f, -2.05618478e-02f, -4.87872213e-02f, 6.01262376e-02f, -9.97752994e-02f, -9.31165665e-02f, -1.82770193e-01f, -4.90824245e-02f, 4.54153642e-02f, -5.32971919e-02f,
  1.30269319e-01f, 2.69484110e-02f, -1.93057756e-03f, 8.61885920e-02f, 1.14408685e-02f, -1.34064034e-01f, -6.75313699e-04f, -3.37773040e-02f, 1.48332380e-02f, 7.20188394e-02f,
  -6.19423203e-03f, 3.83092724e-02f, 1.03869110e-01f, 7.21831620e-02f, 4.10827547e-02f, -6.47817086e-03f, 7.28314519e-02f, 6.49453402e-02f, 6.44789264e-02f, 1.12482026e-01f,
  1.44369140e-01f, 6.93773031e-02f, -2.85475701e-03f, 1.24142155e-01f, 5.60727045e-02f, 3.75571623e-02f, 1.05523221e-01f, -1.79653778e-03f, 8.67793113e-02f, 6.34993007e-03f,
  9.24986303e-02f, 1.29518146e-03f, 2.24974602e-02f, 1.03094883e-01f, 6.26439899e-02f, -1.36671746e-02f, -1.27672153e-02f, -2.42944937e-02f, 6.56989366e-02f, -5.72646223e-02f,
  5.94982505e-02f, 7.47705251e-02f, -5.19466326e-02f, 6.70348778e-02f, 7.11865956e-03f, 1.16958484e-01f, -8.09395313e-03f, 6.11538030e-02f, -5.45825548e-02f, 5.47850989e-02f,
  -6.48477376e-02f, -5.37045449e-02f, -6.67136684e-02f, 1.06948297e-02f, -7.84087274e-03f, -7.59225190e-02f, 5.61152659e-02f, -7.96945244e-02f, -1.46351624e-04f, -5.15830554e-02f,
  -4.77169603e-02f, 2.47644577e-02f, -1.72151849e-02f, -2.03839019e-02f, 3.19141103e-03f, 5.86431585e-02f, 4.56177024e-03f, -5.48719242e-03f, 1.17072828e-01f, -3.11614457e-03f,
  -3.27374525e-02f, 3.09861526e-02f, -9.37007740e-03f, 2.32352261e-02f, -3.36781926e-02f, 5.56965023e-02f, 1.59584694e-02f, -8.16130713e-02f, 6.70787767e-02f, 7.67472684e-02f,
  7.66225457e-02f, -2.19057743e-02f, 1.61698069e-02f, 6.99127689e-02f, -6.01506382e-02f, 2.51912810e-02f, 9.80166197e-02f, 4.57570665e-02f, 7.47214034e-02f, 8.01802576e-02f,
  1.31715670e-01f, 5.49250320e-02f, 1.08700991e-01f, 9.12346616e-02f, -5.90179302e-02f, 9.71082672e-02f, 1.37483375e-02f, 7.02369064e-02f, 3.18198241e-02f, 5.24265133e-02f,
  -1.66715812e-02f, -4.86666784e-02f, -7.03930184e-02f, 2.12575868e-02f, 3.06109712e-02f, 2.67880131e-02f, 1.55702448e-02f, 3.96659411e-02f, -6.20698044e-03f, -3.75135504e-02f,
  3.52217942e-01f, 1.86641663e-01f, 2.15656281e-01f, 1.27940550e-01f, 1.32632762e-01f, 1.82433397e-01f, 2.26923853e-01f, 2.13055700e-01f, -1.24340802e-02f, 1.56940937e-01f,
  1.23827457e-01f, -1.39462978e-01f, -9.55307260e-02f, -4.20805402e-02f, -6.15639053e-02f, -2.67389156e-02f, -1.65895913e-02f, -1.84497889e-02f, -5.52107319e-02f, -6.50418038e-03f,
  -4.61407788e-02f, 4.95020524e-02f, -2.94198897e-02f, -1.38922641e-02f, 1.11388788e-03f, -1.79252803e-01f, 5.06394207e-02f, -3.96684278e-03f, 1.79822929e-02f, -6.28503114e-02f,
  -1.03461072e-01f, 2.64134467e-01f, -9.16982666e-02f, -1.55333430e-01f, -4.32243310e-02f, -8.19128081e-02f, 6.15260601e-02f, 7.46120289e-02f, 4.28455137e-02f, 5.19795269e-02f,
  4.55956794e-02f, -9.41995159e-02f, 7.08706826e-02f, -9.06623602e-02f, 7.89986849e-02f, -6.41569644e-02f, 5.49833775e-02f, -6.49440512e-02f, -9.66342762e-02f, -3.27919163e-02f,
  -7.94717893e-02f, 3.86374295e-02f, 6.02577850e-02f, -9.47914086e-03f, 3.62546816e-02f, -1.59444921e-02f, 1.29427582e-01f, 5.18471673e-02f, -2.59256195e-02f, -1.40192118e-02f,
  -1.58947736e-01f, 5.54910488e-02f, -5.61774615e-03f, 7.51196519e-02f, 3.76207307e-02f, 1.51400724e-02f, 5.78278936e-02f, -6.61666393e-02f, 9.04104486e-03f, 3.12562771e-02f,
  3.55759263e-02f, -2.11960040e-02f, 2.11885087e-02f, -2.51992084e-02f, -1.07684731e-01f, -3.21169682e-02f, 4.85491641e-02f, -3.12069207e-02f, 3.27436402e-02f, -2.77052261e-02f,
  3.12890741e-03f, -7.55125657e-02f, 1.39674544e-02f, -6.44210279e-02f, -9.89830494e-02f, -4.57099499e-03f, -1.01262793e-01f, 2.63463496e-03f, 4.66271527e-02f, -2.29819529e-02f,
  -8.37448537e-02f, 2.99089253e-02f, -7.71016255e-02f, -1.50379449e-01f, 1.17354160e-02f, 2.48102359e-02f, -1.80752389e-03f, -1.08498052e-01f, -6.40657768e-02f, 6.40724525e-02f,
  2.56899390e-02f, -2.07331851e-02f, 9.57117975e-02f, 3.48680802e-02f, -1.76674984e-02f, 5.44886105e-02f, 2.74073966e-02f, -4.28883210e-02f, -5.25699668e-02f, 7.38848299e-02f,
  -9.81098562e-02f, 4.20911610e-02f, -3.51849869e-02f, -4.90477756e-02f, -8.82371441e-02f, -6.70358120e-03f, 6.79653957e-02f, -9.80982780e-02f, 1.00760072e-01f, -7.60855945e-03f,
  -1.50748178e-01f, -3.72321308e-02f, 2.85983589e-02f, -8.87673907e-03f, 1.56681277e-02f, -5.77885993e-02f, -7.01712593e-02f, -9.79546010e-02f, 2.75933743e-02f, -1.89245008e-02f,
  -4.59687747e-02f, 1.10595757e-02f, 5.37792221e-02f, -1.44153252e-01f, -2.49771267e-01f, -1.29925102e-01f, -1.78026572e-01f, -1.75560415e-01f, -1.33919448e-01f, -2.01327831e-01f,
  -1.77634135e-01f, -1.53684691e-01f, -1.43063590e-01f, 1.19883651e-02f, 6.74121678e-02f, 9.60212387e-03f, 1.37826547e-01f, 1.07328622e-02f, -6.72543719e-02f, 5.68165444e-02f,
  3.81770045e-01f, 8.37297663e-02f, -4.90526948e-03f, -1.24438800e-01f, 1.06652500e-02f, -2.04147529e-02f, 5.89988753e-02f, 3.33535634e-02f, 1.12747978e-02f, 1.08531155e-02f,
  1.43651583e-03f, -6.15109652e-02f, -4.39435132e-02f, 4.60920818e-02f, -1.34895863e-02f, -6.93541616e-02f, -1.34363636e-01f, -1.11583225e-01f, -1.50585081e-02f, 2.59154700e-02f,
  1.47161549e-02f, -1.55025229e-01f, -4.92454879e-02f, 1.13912281e-02f, 2.32418925e-02f, -3.93241681e-02f, 8.94627720e-02f, 6.31550374e-03f, 1.34949118e-01f, 1.17143542e-01f,
  -1.41469771e-02f, 7.41014257e-02f, -6.83840960e-02f, -4.65830825e-02f, -2.65945052e-03f, 4.78710867e-02f, -7.67312273e-02f, 3.57506052e-02f, -4.51344065e-02f, 3.86259891e-03f,
  5.45546934e-02f, -1.45504829e-02f, 3.11626550e-02f, 1.01259999e-01f, 1.19035421e-02f, 2.92595220e-03f, 5.50832367e-04f, -3.23829725e-02f, 2.12525744e-02f, -7.18178377e-02f,
  4.19316962e-02f, 1.29008498e-02f, 4.08508368e-02f, 1.06116340e-01f, -7.05600381e-02f, 3.53922881e-02f, -2.85636075e-02f, 5.47096357e-02f, 6.57420009e-02f, -7.52097294e-02f,
  2.81133145e-01f, -2.09052041e-01f, 1.19740702e-02f, 9.02897492e-03f, 1.18708499e-01f, 4.90915105e-02f, 7.08426684e-02f, -6.37732223e-02f, 9.33865681e-02f, 5.34588061e-02f,
  3.99195291e-02f, 6.72653839e-02f, 4.16348986e-02f, 5.53363822e-02f, -8.64231363e-02f, -3.11318338e-02f, -1.52449414e-01f, -2.61113755e-02f, 4.18485962e-02f, 6.96361586e-02f,
  5.53046307e-03f, -4.79697138e-02f, -9.00656357e-02f, 5.11018448e-02f, 7.44652003e-02f, -2.81703807e-02f, 4.63383645e-02f, 1.74485534e-01f, -2.01108828e-02f, 1.30986407e-01f,
  4.87701565e-01f, 4.23070043e-01f, 2.45490372e-01f, 7.76401013e-02f, -2.14259718e-02f, 8.38027224e-02f, 2.87647069e-01f, 1.81586713e-01f, -1.30177690e-02f, 4.76678982e-02f,
  -5.32234907e-02f, -5.96208349e-02f, -1.11750498e-01f, -2.81052291e-02f, 1.04487665e-01f, 1.17583707e-01f, 8.24199766e-02f, 7.94708580e-02f, 5.18413298e-02f, -7.13757351e-02f,
  -4.03934624e-03f, 1.15491211e-01f, 8.78253952e-02f, 1.23078793e-01f, -6.79713413e-02f, -1.67221338e-01f, 5.91921993e-02f, 1.32008076e-01f, 3.54939476e-02f, 5.57208173e-02f,
  -7.38807442e-03f, 4.59008753e-01f, -2.45849773e-01f, -1.91678613e-01f, -4.93259504e-02f, 1.03144959e-01f, -1.78071707e-02f, -4.50192429e-02f, -8.22524354e-02f, 5.15780412e-02f,
  -6.97263256e-02f, -4.95602600e-02f, 8.53873938e-02f, 2.80197244e-02f, -1.82112902e-02f, 2.32679117e-03f, 5.75384535e-02f, 1.32478699e-01f, 8.52138773e-02f, 2.22419295e-02f,
  -4.83274981e-02f, -5.97035512e-02f, 5.15858317e-03f, 3.88325751e-02f, 1.02635078e-01f, -5.95964119e-02f, 7.44491965e-02f, 1.02485895e-01f, 7.96246603e-02f, 1.18165210e-01f,
  -2.39418522e-02f, 4.69602533e-02f, -7.34237162e-03f, 1.34058818e-01f, 1.30590154e-02f, -6.76783100e-02f, -4.25769715e-03f, 5.97302131e-02f, -4.11007591e-02f, 3.02410349e-02f,
  5.78396171e-02f, 1.45713810e-03f, 4.94330786e-02f, 6.97094873e-02f, -1.26055241e-01f, 3.31701636e-02f, 5.15585504e-02f, 5.63964322e-02f, 3.38569097e-02f, -4.28926200e-02f,
  6.38501719e-02f, 6.33857958e-03f, -9.05776862e-03f, 1.03560686e-01f, -4.56801243e-02f, 6.58706278e-02f, -6.69380426e-02f, 5.18933274e-02f, 4.78246361e-02f, -8.10538768e-04f,
  -1.01088956e-01f, -1.43349946e-01f, -1.38569534e-01f, 1.54801887e-02f, -4.49688770e-02f, -7.92187080e-02f, -8.93950835e-02f, -5.91123775e-02f, -7.96881840e-02f, 5.04714958e-02f,
  -7.36858025e-02f, 7.10443854e-02f, 3.72705199e-02f, 1.00775696e-02f, -5.28202839e-02f, 3.33090164e-02f, -1.01216026e-01f, -1.25880213e-02f, 2.36398354e-02f, 1.13993641e-02f,
  -1.07231371e-01f, -1.17777281e-01f, -1.55249894e-01f, -1.03556737e-01f, -8.82307217e-02f, -2.53459752e-01f, -1.31783962e-01f, -1.68640450e-01f, -3.40969898e-02f, -1.19941898e-01f,
  2.86532193e-01f, -3.91383879e-02f, 1.08104497e-01f, -6.99412078e-02f, -1.66098639e-01f, -7.81026110e-02f, -1.40067056e-01f, 5.60223646e-02f, -2.53159227e-03f, 8.13372657e-02f,
  2.49268785e-02f, 1.73736483e-01f, 1.43836901e-01f, 2.16878116e-01f, 1.42785400e-01f, -9.01313201e-02f, -1.12857316e-02f, 3.58686559e-02f, 1.71831861e-01f, -2.16150712e-02f,
  -1.16238594e-01f, 7.79571310e-02f, 1.80625394e-01f, 9.33255851e-02f, -3.70443687e-02f, -7.78358057e-02f, 5.48325032e-02f, -1.04463473e-01f, -1.45193711e-01f, -1.25709549e-01f,
  9.02414843e-02f, 4.93065752e-02f, 4.99725118e-02f, -9.06796567e-03f, -1.23204634e-01f, -2.20130887e-02f, -6.53185125e-04f, -2.88729910e-02f, 1.53032104e-02f, 2.55089346e-02f,
  -5.43938503e-02f, -8.35569575e-03f, -6.41171634e-02f, -1.17839053e-01f, -6.25931621e-02f, -3.65045331e-02f, -8.22624713e-02f, -2.78822407e-02f, 1.09222673e-01f, -1.22517377e-01f,
  -1.01720847e-01f, -1.19694360e-01f, -7.48442253e-03f, 1.19318254e-02f, 3.72529924e-02f, -3.58927026e-02f, -1.03140555e-01f, -3.93354930e-02f, -8.31833556e-02f, 2.75108349e-02f,
  -5.70609421e-02f, 2.73454785e-02f, -3.50187756e-02f, 9.39436182e-02f, 1.15063399e-01f, 3.28039899e-02f, -1.05366066e-01f, -7.97667876e-02f, 5.76240793e-02f, -4.54576015e-02f,
  7.36590251e-02f, -2.10571359e-03f, 6.20143376e-02f, -1.51550332e-02f, 4.33637835e-02f, -5.69902733e-02f, -1.01286443e-02f, 4.51066159e-02f, -5.64333797e-02f, 5.72103001e-02f,
  8.27914923e-02f, 2.42860951e-02f, 5.10925390e-02f, -4.70463447e-02f, -7.00840205e-02f, 8.78130794e-02f, 7.87478387e-02f, 2.00063568e-02f, 3.11067495e-02f, 3.95952165e-02f,
  7.23312572e-02f, 1.28118604e-01f, 3.73318195e-02f, -9.20413136e-02f, -9.40959081e-02f, -5.26455678e-02f, -8.24197382e-02f, 5.74055500e-02f, 5.37408283e-03f, -2.13853307e-02f,
  -3.74587551e-02f, 5.43290079e-02f, 3.64114121e-02f, -1.11323660e-02f, 7.94179365e-02f, 1.26044704e-02f, 4.56574373e-02f, -1.10556949e-02f, 7.69594014e-02f, -1.54478604e-03f,
  -8.19884241e-03f, 5.25703095e-02f, 9.05678868e-02f, 5.66204684e-03f, -8.25036392e-02f, 9.44483355e-02f, 1.12294674e-01f, -8.41322448e-03f, 9.09951553e-02f, 3.68812568e-02f,
  3.54087651e-01f, -1.33535471e-02f, -3.45972367e-02f, -5.09339906e-02f, -2.20131978e-01f, -2.70680815e-01f, -3.02200794e-01f, -1.52112462e-03f, -6.90770149e-02f, 3.62540446e-02f,
  -2.19652173e-03f, 2.05850616e-01f, 1.92277551e-01f, 1.36229604e-01f, 6.12078458e-02f, 2.01301859e-03f, 7.57545158e-02f, 2.56885707e-01f, 1.06300384e-01f, 4.56861369e-02f,
  -1.14015646e-01f, -1.61163062e-02f, 1.96446642e-01f, 1.17857262e-01f, 4.28909361e-02f, -5.57058677e-03f, -6.40428290e-02f, 4.18516733e-02f, 5.98585606e-02f, 7.21641034e-02f,
  1.59252793e-01f, 8.23956132e-02f, 7.34178573e-02f, 6.32598400e-02f, -6.05284199e-02f, 4.18518186e-02f, -3.00746933e-02f, 1.03185222e-01f, -4.98176254e-02f, -8.53134394e-02f,
  -7.32085481e-02f, 5.37300818e-02f, 4.72251475e-02f, -2.94130854e-02f, 5.41175425e-04f, -5.05027473e-02f, 1.02112561e-01f, 1.19621783e-01f, 6.51772320e-02f, 8.85662809e-02f,
  -8.21179599e-02f, -1.41279072e-01f, 4.49594902e-03f, -1.98645312e-02f, 1.07331835e-01f, 1.29062042e-01f, -3.85274068e-02f, 5.42713441e-02f, 1.10910706e-01f, 9.96474549e-02f,
  2.11673584e-02f, -2.50133239e-02f, 4.31853794e-02f, 6.76883906e-02f, -1.62576158e-02f, 2.29553375e-02f, -7.86947459e-02f, -5.04037514e-02f, 6.92266226e-02f, -5.54031543e-02f,
  -2.85161585e-02f, -2.17110515e-02f, -4.30059321e-02f, 4.90380079e-03f, 4.10565408e-03f, -1.21660516e-01f, 3.55480537e-02f, -5.27393892e-02f, 1.92450341e-02f, 1.69047248e-02f,
  6.29459769e-02f, -5.40569611e-02f, -1.07495867e-01f, 4.35340963e-02f, -3.52283902e-02f, -4.61445488e-02f, 2.95736268e-02f, -5.30310683e-02f, -1.10157184e-01f, 5.56925219e-03f,
  -1.87550530e-01f, 3.37775871e-02f, 1.08604468e-01f, 5.03045507e-02f, 1.15998276e-02f, 1.13895498e-01f, -1.83078239e-03f, -4.19655740e-02f, -3.83446701e-02f, 2.51937881e-02f,
  2.13685557e-02f, 1.08474277e-01f, 5.32518923e-02f, -8.14117640e-02f, -9.05191153e-02f, 4.68717851e-02f, -6.73804656e-02f, 6.94030821e-02f, -6.40143976e-02f, -9.28472504e-02f,
  -2.62221377e-02f, -6.29741177e-02f, -1.60054881e-02f, -8.24920088e-02f, 1.35986423e-02f, -1.43291308e-02f, -3.16695832e-02f, -9.45042223e-02f, -3.51350382e-02f, -2.74328142e-02f,
  1.81977585e-01f, 1.58492655e-01f, 6.12083683e-03f, 2.29444355e-02f, 7.46157533e-03f, -1.11052781e-01f, -1.53502554e-01f, -1.45737633e-01f, -4.21141200e-02f, 9.72143188e-02f,
  9.75700542e-02f, 7.50670508e-02f, -7.28206411e-02f, -3.85867916e-02f, -2.66013622e-01f, -8.68066251e-02f, -8.54444355e-02f, -2.27219209e-01f, -3.15600157e-01f, -2.25251421e-01f,
  5.63512221e-02f, -6.40919209e-02f, -8.62680674e-02f, -6.62936419e-02f, 8.33321214e-02f, 3.43990177e-02f, 1.33123323e-01f, 6.16791174e-02f, -1.26871839e-02f, 2.40875676e-01f,
  -5.39534912e-02f, 4.45145182e-02f, -1.56204671e-01f, 5.38197309e-02f, -2.78133079e-02f, 7.01007470e-02f, -9.42559689e-02f, -4.41138521e-02f, -6.83417469e-02f, 3.83689217e-02f,
  6.71728253e-02f, 2.54105348e-02f, 7.77708506e-03f, -2.86310147e-02f, -2.32498106e-02f, -2.94968840e-02f, 3.40479277e-02f, -9.02890936e-02f, -2.71632951e-02f, 1.43993031e-02f,
  1.08985871e-01f, -2.72163860e-02f, 2.45309677e-02f, -5.93533702e-02f, -6.73735067e-02f, -8.50680470e-02f, -7.14782476e-02f, 7.19839036e-02f, 4.71238121e-02f, 4.03685905e-02f,
  2.85786111e-02f, -5.73140942e-02f, 1.83922481e-02f, 2.02380642e-02f, -2.16238741e-02f, 2.15160847e-02f, -5.86257018e-02f, -7.86935240e-02f, -4.38790992e-02f, 2.91481428e-02f,
  5.02080731e-02f, -4.53378633e-02f, -2.52755024e-02f, -2.25272179e-02f, -1.87994838e-02f, -6.70266077e-02f, -2.63753571e-02f, -5.30415624e-02f, -4.85754199e-02f, -6.38077632e-02f,
  -5.90873733e-02f, -6.08177818e-02f, 7.68036321e-02f, -6.17097467e-02f, 7.93036073e-02f, 1.02458266e-03f, -9.57678035e-02f, 9.05959401e-03f, -2.66228672e-02f, -3.58034484e-02f,
  1.44536737e-02f, -9.48338136e-02f, -2.73799673e-02f, -6.90441653e-02f, 1.37652442e-01f, -2.20240932e-02f, 3.87241803e-02f, 7.38471299e-02f, 2.88285408e-02f, -2.20794789e-02f,
  2.63349395e-02f, -7.32182488e-02f, 1.08557776e-01f, -2.85518970e-02f, -5.76932691e-02f, -6.40388280e-02f, 9.91053209e-02f, 5.23683950e-02f, -1.36652544e-01f, -1.94514766e-02f,
  -1.66395679e-02f, -1.35847583e-01f, 1.49643635e-02f, -4.39603403e-02f, 3.99926156e-02f, 2.24300604e-02f, 2.86023580e-02f, -5.45074977e-02f, -1.37550265e-01f, 9.61069539e-02f,
  3.13896328e-01f, 2.00453803e-01f, 1.37066007e-01f, 1.71040162e-01f, 1.50333434e-01f, 1.29338130e-01f, 2.83072948e-01f, 2.13725224e-01f, 9.85017493e-02f, 5.04143760e-02f,
  -6.13441616e-02f, -1.24669328e-01f, -9.84202474e-02f, -7.50758499e-02f, 3.38234454e-02f, 8.94687474e-02f, -3.44880158e-03f, 3.99937332e-02f, -1.91977769e-02f, 7.26221071e-04f,
  -4.55161929e-02f, 6.99627176e-02f, 1.03234485e-01f, 3.83142903e-02f, -8.06732997e-02f, -1.77503994e-03f, 3.07832155e-02f, 7.41417345e-04f, 2.97019500e-02f, 2.89411452e-02f,
  -1.82736471e-01f, 2.72017181e-01f, -1.91319272e-01f, -1.40328750e-01f, -3.58363502e-02f, -2.27489900e-02f, -2.27771103e-02f, -9.25875232e-02f, -1.83912478e-02f, 6.17719479e-02f,
  2.54347902e-02f, -1.05505526e-01f, -4.23533022e-02f, -4.81197797e-02f, 1.14002131e-01f, 7.40171745e-02f, -7.01761097e-02f, 2.11183708e-02f, -5.21049462e-02f, -2.45608836e-02f,
  -1.38862908e-01f, 8.88087600e-02f, 1.43446431e-01f, -4.98433458e-03f, -8.99275392e-02f, 1.40663777e-02f, -3.04153506e-02f, -9.07089114e-02f, -7.58773461e-02f, 5.05503081e-02f,
  -1.41007513e-01f, -7.97663257e-02f, -7.12757707e-02f, -2.74066571e-02f, 4.44945134e-02f, -8.91131461e-02f, 1.92820728e-02f, -3.37871723e-02f, 7.12983161e-02f, -6.40370846e-02f,
  3.93051654e-02f, -8.71741772e-02f, -9.28990822e-03f, 5.90595268e-02f, -7.61635602e-02f, 3.01814694e-02f, -4.40932959e-02f, -4.34897467e-02f, -8.45290795e-02f, 1.05411157e-01f,
  3.00937500e-02f, -1.13786664e-02f, 3.83626744e-02f, -2.11921204e-02f, 4.28195633e-02f, -1.08688429e-01f, 2.04821080e-02f, -7.21676275e-02f, -1.21756718e-02f, 8.80217832e-03f,
  1.76117737e-02f, -2.85335928e-02f, 1.26699675e-02f, 1.59893781e-02f, 5.09616127e-03f, 2.40248488e-03f, -9.36916564e-04f, -2.12619640e-03f, 6.63845614e-02f, -4.33030277e-02f,
  9.08873603e-02f, 1.01519115e-01f, 4.40561958e-02f, -1.48730986e-02f, 9.09017678e-03f, -5.30046597e-02f, 5.40169254e-02f, 7.38579333e-02f, -5.90520166e-02f, -5.96214272e-02f,
  2.04031486e-02f, 1.17652239e-02f, 1.46162078e-01f, 2.55172141e-03f, -3.88626591e-03f, -2.93987244e-02f, 1.90285183e-02f, -7.44320825e-02f, 1.16569951e-01f, 9.20415670e-02f,
  -4.33458760e-03f, -3.01698923e-01f, 1.34396777e-01f, 1.51338086e-01f, 2.26136073e-01f, 3.56562495e-01f, 1.33693695e-01f, 1.55343011e-01f, 2.50052691e-01f, 1.15109188e-02f,
  -1.53047413e-01f, -4.19862233e-02f, -6.60963953e-02f, 7.01326132e-02f, 5.48195988e-02f, 7.10393339e-02f, 3.04655910e-01f, 8.84600580e-02f, 2.13029131e-01f, 1.93606094e-02f,
  1.73483789e-01f, 1.12713292e-01f, -1.57783449e-01f, 1.11601055e-01f, 1.21175595e-01f, 1.37820721e-01f, 3.68847023e-03f, -2.82435492e-02f, -2.13804338e-02f, 1.44594520e-01f,
  -2.00796440e-01f, -1.88988686e-01f, 1.98919803e-01f, -1.38654009e-01f, -4.19482812e-02f, -6.28218725e-02f, -3.18732411e-02f, -1.16426170e-01f, -5.02807237e-02f, 3.60637642e-02f,
  -8.19542706e-02f, 2.44413912e-02f, -1.15060844e-02f, -9.01272520e-02f, -8.09815596e-04f, -7.85706416e-02f, -5.59593104e-02f, -4.60981950e-02f, -1.64725557e-02f, -1.68029532e-01f,
  7.62665924e-03f, 5.24049364e-02f, 3.91160026e-02f, -5.59407733e-02f, -7.60624409e-02f, -3.17386389e-02f, -1.22967482e-01f, -2.68515106e-02f, -4.04910408e-02f, -9.74985361e-02f,
  -5.25546167e-03f, -5.71389534e-02f, 3.38846371e-02f, 4.58155125e-02f, 6.10155202e-02f, 9.28880945e-02f, 7.61450902e-02f, 2.45990474e-02f, 7.05615431e-02f, 2.36348342e-02f,
  6.47714734e-02f, 7.69167617e-02f, 1.03869177e-02f, -5.10335267e-02f, 3.87357250e-02f, -3.36010680e-02f, -4.95496765e-02f, 1.37849823e-02f, -6.25663549e-02f, -5.30688874e-02f,
  -5.88946678e-02f, -6.80724112e-03f, 1.15530100e-02f, 7.90835824e-03f, -4.30038497e-02f, -1.04913702e-02f, 1.44383954e-02f, -1.24152049e-01f, -4.14087102e-02f, 3.88169959e-02f,
  6.93355221e-03f, -3.49393636e-02f, 1.11934245e-01f, -4.57299091e-02f, 2.22759647e-03f, -4.67148274e-02f, -4.20249626e-02f, 4.19001188e-03f, -8.87555853e-02f, 3.76284570e-02f,
  -4.93382253e-02f, -1.07953019e-01f, -5.54797007e-03f, 3.96455936e-02f, 1.32977098e-01f, 1.02297299e-01f, -1.80345736e-02f, 1.37603596e-01f, 6.90786242e-02f, -8.75817705e-03f,
  -7.08115473e-02f, 1.14643291e-01f, 1.50016576e-01f, 7.49184415e-02f, 5.74160442e-02f, 1.08940877e-01f, 7.62825971e-03f, 8.64797160e-02f, 1.41394258e-01f, 4.01557125e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.85895309e-01f, 9.71427113e-02f, 2.31248453e-01f, 2.02598959e-01f, -6.22383542e-02f, 9.59387198e-02f, 1.20437294e-01f, 2.35975698e-01f, 1.83535561e-01f, 2.63651758e-01f,
  -2.08831066e-03f, 3.09278280e-01f, 2.77529657e-01f, 1.94631472e-01f, 6.79347068e-02f, 2.44227141e-01f, 6.39879331e-02f, -4.28442890e-03f, 1.32727191e-01f, 9.79667529e-02f,
  1.79551408e-01f, 2.93584347e-01f, 2.88686156e-01f, 9.61925536e-02f, 2.56593198e-01f, 8.08546394e-02f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -2.16026649e-01f, 1.01068623e-01f, -2.02375680e-01f, 2.36227047e-02f, -6.48446977e-01f, -5.64473271e-01f, -4.16198999e-01f, 1.07413672e-01f, 1.15887776e-01f, 1.07945681e-01f,
  -6.99846864e-01f, 1.88350469e-01f, 2.11133644e-01f, -1.49110541e-01f, 1.47299901e-01f, -4.04870391e-01f, -2.26268753e-01f, -1.65209677e-02f, -4.50192243e-01f, 4.62626278e-01f,
  2.48468593e-01f, 4.59883869e-01f, -2.92744726e-01f, -1.88362952e-02f, -1.48999076e-02f, -1.14948176e-01f, 3.11880447e-02f, 3.79702538e-01f, -1.18287556e-01f, -3.39191109e-01f,
  -2.46403649e-01f, 9.14512053e-02f, 1.62302747e-01f, -4.58218455e-01f, -1.77514300e-01f, 1.02054745e-01f, -1.97132483e-01f, 3.84621322e-01f, 6.70443624e-02f, 5.64130664e-01f,
  -7.37176463e-02f, -1.94015399e-01f, -5.39819337e-02f, -1.44084081e-01f, 1.21079005e-01f, 4.84483317e-03f, 1.19040377e-01f, 2.17507259e-04f, 1.88930817e-02f, 7.25148572e-03f,
  5.39954066e-01f, 9.57298204e-02f, -1.34049892e-01f, -1.74537510e-01f, -4.52194698e-02f, 1.92510322e-01f, -1.25797540e-02f, 4.38982621e-02f, -1.18740156e-01f, -8.47214758e-02f,
  2.41312217e-02f, -1.94676489e-01f, -9.85761583e-02f, -8.27844590e-02f, 2.27155387e-01f, -5.05577959e-02f, -1.14325602e-02f, -3.41576666e-01f, 2.59551108e-01f, -1.44312799e-01f,
  1.23033836e-01f, 1.23582713e-01f, -3.24899912e-01f, 7.92874470e-02f, -3.06792796e-01f, 3.25163841e-01f, 1.10237882e-01f, -3.73347580e-01f, -1.82381466e-01f, 3.29610348e-01f,
  5.33874799e-03f, 2.41048977e-01f, -6.33711219e-02f, -4.37881172e-01f, 6.86130106e-01f, 4.45304900e-01f, -1.23490833e-01f, -4.69609708e-01f, -3.79712075e-01f, 3.55495572e-01f,
  -2.14787796e-01f, 6.90890789e-01f, -3.89056265e-01f, -2.36493483e-01f, 1.60265058e-01f, -3.07567835e-01f, 2.93661468e-02f, -4.97593880e-01f, -1.72838554e-01f, 1.78737924e-01f,
  4.03773692e-03f, 1.71329871e-01f, -3.16935450e-01f, -1.96410656e-01f, -3.31942409e-01f, 5.11453748e-01f, 6.55983808e-03f, 1.12730190e-01f, 3.09442878e-01f, -5.04420958e-02f,
  -1.03080884e-01f, -2.02380642e-01f, -2.51159519e-02f, 4.47731704e-01f, -3.25770169e-01f, -6.62817061e-02f, 4.12438422e-01f, -2.93351207e-02f, 2.76221961e-01f, -1.22584067e-02f,
  2.24214159e-02f, -2.69756943e-01f, 1.53442889e-01f, 4.99900848e-01f, 4.24343646e-01f, -1.40102416e-01f, 3.54357734e-02f, 8.69430527e-02f, 4.17294651e-02f, -9.68705341e-02f,
  -2.83465683e-02f, 1.06011042e-02f, 3.66659403e-01f, 3.68889004e-01f, 4.27031964e-01f, 2.27240950e-01f, -1.95369218e-02f, 1.61956728e-01f, 3.06686819e-01f, 1.80349886e-01f,
  2.55034685e-01f, 3.94357771e-01f, 2.61195570e-01f, 2.01009303e-01f, 3.22869658e-01f, 1.80778429e-01f, 1.34737745e-01f, 3.22167099e-01f, 6.00419581e-01f, 3.07034165e-01f,
  -7.27257967e-01f, -1.32175788e-01f, -5.29026985e-01f, -4.22933042e-01f, -2.92753279e-01f, -4.00150031e-01f, -4.55987602e-01f, 2.53160924e-01f, -2.74074346e-01f, -6.07941709e-02f,
  -2.80525327e-01f, 1.50255442e-01f, 2.95154154e-01f, -2.25305393e-01f, -5.36450371e-02f, 3.08563858e-01f, 1.20100930e-01f, -5.05530573e-02f, -1.63998306e-01f, -5.78830317e-02f,
  -1.39341891e-01f, -1.63979813e-01f, -1.41659141e-01f, -2.62737960e-01f, -3.67518038e-01f, -2.94272192e-02f, -1.61645219e-01f, -2.44095922e-01f, 8.33614636e-03f, -2.31939569e-01f,
  -2.04734221e-01f, 1.19568773e-01f, -3.14514711e-02f, 2.36156866e-01f, -2.51662910e-01f, -3.18796933e-01f, -2.35109255e-01f, 2.05008060e-01f, 2.68293768e-01f, -2.21204668e-01f,
  -2.45749444e-01f, -1.57108113e-01f, 1.21957861e-01f, 1.92130767e-02f, 1.65069878e-01f, -1.85183406e-01f, -2.75126338e-01f, 1.55423969e-01f, -7.64630437e-02f, -2.42189974e-01f,
  6.69611851e-04f, 2.27987138e-03f, 4.36481297e-01f, -5.27519062e-02f, -3.59214425e-01f, -1.39116466e-01f, 1.22694686e-01f, -3.29987146e-02f, -3.04708153e-01f, 2.59615660e-01f,
  2.90073246e-01f, 5.60137779e-02f, -2.24710286e-01f, -2.36145690e-01f, -4.29128528e-01f, -3.75164598e-01f, -3.80041420e-01f, 1.76223740e-01f, 4.40315694e-01f, -1.58010781e-01f,
  8.25982019e-02f, 6.83912709e-02f, 2.54426152e-01f, 8.98767650e-01f, 1.71016246e-01f, 1.08287461e-01f, -3.63816708e-01f, 4.32843775e-01f, -8.99773613e-02f, 1.29049560e-02f,
  -1.04256555e-01f, 6.80375546e-02f, 1.00753236e+00f, -4.94110845e-02f, 6.62100166e-02f, 2.77528852e-01f, -3.51333767e-01f, -1.79993033e-01f, -9.84090716e-02f, 3.33890289e-01f,
  -8.50964934e-02f, -3.73291343e-01f, -5.06593168e-01f, -3.37433419e-03f, 3.42023112e-02f, 1.12565219e-01f, -1.75571695e-01f, -8.35161135e-02f, -1.36078119e-01f, -3.36485617e-02f,
  -1.60558432e-01f, -2.82657146e-01f, -1.06669039e-01f, -6.67110980e-02f, -3.36001478e-02f, -2.43456811e-01f, -7.54092410e-02f, -2.08487958e-01f, 7.80742541e-02f, 3.63666900e-02f,
  -1.14259832e-01f, -1.85384557e-01f, -3.38195711e-01f, 5.68024488e-03f, -4.51787710e-02f, -2.70002596e-02f, 1.31090939e-01f, -1.51278794e-01f, 2.18148023e-01f, -1.99487526e-02f,
  -2.15718031e-01f, 1.98974341e-01f, 4.13155407e-01f, -3.17246504e-02f, -1.23852111e-01f, 2.05466047e-01f, -1.26593977e-01f, -3.63460988e-01f, 8.51619930e-04f, -3.87680858e-01f,
  -2.35609755e-01f, 5.51234126e-01f, 4.25089955e-01f, -3.16072822e-01f, 1.78038940e-01f, -2.19192728e-01f, 9.04730409e-02f, -2.89995223e-01f, 3.00286412e-01f, 4.56036806e-01f,
  -1.50325429e-02f, 1.41354665e-01f, 2.45586306e-01f, 3.36528957e-01f, 6.36864066e-01f, -3.47107023e-01f, 3.82789820e-01f, -2.85876985e-03f, 1.89658135e-01f, -2.22970828e-01f,
  7.85437748e-02f, -1.84694007e-01f, 7.47982785e-02f, -1.59353331e-01f, 2.03725353e-01f, -3.31147432e-01f, 5.39228857e-01f, 3.41241546e-02f, -8.16475414e-03f, -2.23817289e-01f,
  -2.48815551e-01f, 1.72998369e-01f, 1.40405089e-01f, 5.61380565e-01f, -1.58618450e-01f, -1.88813329e-01f, -2.06928682e-02f, 3.62471402e-01f, -4.28252332e-02f, 4.04557697e-02f,
  1.83202833e-01f, 3.78465921e-01f, 1.36561707e-01f, 1.18685767e-01f, 3.18437934e-01f, 3.11827511e-01f, 4.59316559e-02f, 2.39920139e-01f, 2.54851162e-01f, 1.24887779e-01f,
  1.65080354e-01f, -1.00993864e-01f, 1.20059170e-01f, -9.79070589e-02f, -6.05292665e-03f, 1.65970534e-01f, 1.23755589e-01f, 6.86250106e-02f, 9.74101946e-03f, -2.35720068e-01f,
  -6.09661758e-01f, 2.81353772e-01f, 1.99507311e-01f, 4.76716533e-02f, -7.30879754e-02f, 1.89123064e-01f, 1.53763875e-01f, 2.83164252e-03f, 7.93863177e-01f, -3.93655717e-01f,
  5.02552032e-01f, -4.06296521e-01f, 3.03535499e-02f, -4.87241417e-01f, -2.60801077e-01f, 4.20451641e-01f, -6.63362518e-02f, 1.37005970e-01f, -2.83132136e-01f, -1.78483382e-01f,
  -5.41059852e-01f, -3.45451199e-02f, -5.48957251e-02f, -2.09218077e-02f, 3.87832262e-02f, 2.07442686e-01f, 8.79466772e-01f, -2.86345154e-01f, -8.54350254e-02f, 2.62129784e-01f,
  2.83680856e-01f, 3.96302372e-01f, 4.62914035e-02f, 6.27978286e-03f, 6.50580898e-02f, -4.99846088e-03f, 1.55945033e-01f, -8.96676406e-02f, -6.66569695e-02f, 1.40991583e-01f,
  -1.72370479e-01f, 1.58881202e-01f, 3.11065435e-01f, -6.56408146e-02f, 1.43479690e-01f, 2.67724823e-02f, 1.49148494e-01f, 2.99099952e-01f, -3.72988850e-01f, 7.29430243e-02f,
  -4.45179701e-01f, -6.48526996e-02f, -1.59793764e-01f, 2.70313136e-02f, 1.42254800e-01f, -1.17518380e-01f, -1.82595924e-01f, -1.14983968e-01f, 4.00986224e-02f, -2.43836671e-01f,
  -6.21451318e-01f, -1.23493530e-01f, 5.08877039e-01f, 1.54079214e-01f, -1.54299945e-01f, 3.38624455e-02f, 1.89767946e-02f, 7.12620914e-01f, 2.54549503e-01f, -2.32909620e-01f,
  -4.72505003e-01f, -3.89506221e-01f, 2.55190223e-01f, 3.20695549e-01f, -1.28663063e-01f, -3.35462868e-01f, -4.10957605e-01f, 3.56004566e-01f, 3.51032168e-01f, -4.37963486e-01f,
  3.26434880e-01f, 2.09533304e-01f, -2.54254460e-01f, -2.82966882e-01f, -1.61857933e-01f, -9.26008970e-02f, 9.31246951e-03f, -6.38514161e-02f, 1.32688165e-01f, 1.13091625e-01f,
  1.15028553e-01f, -2.53283679e-01f, -9.49080661e-02f, 4.44659740e-02f, -1.40142620e-01f, -9.47364196e-02f, -2.89781898e-01f, -4.19247925e-01f, 7.46648759e-02f, -4.67421375e-02f,
  -7.69387782e-02f, -2.23881945e-01f, 6.79912388e-01f, 8.11426789e-02f, 4.93963093e-01f, -4.12614085e-02f, 1.19142786e-01f, -2.81018972e-01f, -1.87708527e-01f, -2.15808868e-01f,
  -1.15820728e-01f, -6.98016211e-02f, -6.80110753e-02f, -8.23603570e-02f, 1.75148517e-01f, -5.33042811e-02f, -2.63794661e-01f, -3.02949250e-01f, -1.80337608e-01f, -2.89424270e-01f,
  1.57801919e-02f, -1.23181567e-01f, -2.26186693e-01f, 4.30485643e-02f, 1.68609113e-01f, 9.16362554e-03f, -3.09494615e-01f, 3.20430338e-01f, -1.41396523e-01f, 2.19556540e-01f,
  3.50306690e-01f, -8.71701539e-02f, 3.05896342e-01f, 2.21935883e-02f, -2.80523479e-01f, -3.12505484e-01f, 3.42254758e-01f, 2.93576866e-01f, 4.83515233e-01f, 1.26768097e-01f,
  -3.53050351e-01f, 3.12380552e-01f, -6.88905939e-02f, 1.68661967e-01f, -1.07336223e-01f, -3.30560863e-01f, -2.01025426e-01f, 5.05091906e-01f, 2.70086855e-01f, -2.67594814e-01f,
  -4.64012660e-02f, 3.97893526e-02f, -1.66836843e-01f, -1.59631550e-01f, -1.37317449e-01f, 8.85476694e-02f, 1.54939648e-02f, -7.01425772e-04f, -2.53088415e-01f, -1.57638207e-01f,
  1.77012399e-01f, 7.39782512e-01f, 3.77688184e-02f, 9.65289921e-02f, -2.23696217e-01f, -2.20486224e-02f, -2.44461875e-02f, -2.67168075e-01f, -1.89305454e-01f, -5.73756956e-02f,
  1.48030519e-02f, 4.90605116e-01f, -3.36707644e-02f, 3.21326889e-02f, 6.35740533e-02f, 1.14727415e-01f, -1.30940571e-01f, 1.10985473e-01f, 1.51861133e-02f, 8.49356502e-02f,
  -1.31489635e-01f, 9.44333822e-02f, 8.22596252e-02f, 1.01981223e-01f, -9.67048854e-02f, 1.87703431e-01f, -3.60670686e-01f, 4.46247011e-02f, 1.71724960e-01f, -8.68286714e-02f,
  -3.82332504e-02f, -2.01493084e-01f, 4.69879806e-02f, -2.85366356e-01f, 5.41956723e-02f, 5.66582263e-01f, 4.51972395e-01f, -2.23611504e-01f, 2.32487470e-01f, 3.52161646e-01f,
  -2.70401537e-01f, 2.45820999e-01f, -4.53511029e-01f, 4.93933141e-01f, 1.12526581e-01f, -4.75020409e-01f, 4.08624947e-01f, 1.31440908e-01f, -2.94102371e-01f, -6.14361346e-01f,
  -2.67066360e-01f, -1.72962651e-01f, -2.50184864e-01f, 2.77587980e-01f, 1.19814515e-01f, -1.31936148e-01f, 2.02444449e-01f, 2.87409425e-01f, -4.62926105e-02f, 3.18232924e-01f,
  1.14500951e-02f, 3.15846413e-01f, -2.57568687e-01f, 9.29499604e-03f, 1.45556122e-01f, -8.87615830e-02f, -1.93510965e-01f, -2.97043800e-01f, 1.17999054e-01f, -8.91924202e-02f,
  -2.72422105e-01f, 5.29189780e-03f, -3.05642009e-01f, -2.07859337e-01f, 2.66439885e-01f, 5.88895380e-01f, 1.26662469e-02f, 9.29469913e-02f, -4.47488427e-02f, -2.40404084e-01f,
  3.90893489e-01f, 3.66222352e-01f, 2.57187307e-01f, -4.24547434e-01f, 4.50381637e-02f, -3.44510861e-02f, -5.44847734e-02f, 1.85861841e-01f, -3.41025740e-01f, 9.10544544e-02f,
  -4.39042747e-01f, 9.68195722e-02f, -1.34249449e-01f, 1.64567426e-01f, 7.75276497e-02f, 3.15159976e-01f, -3.06278735e-01f, -2.96523392e-01f, 6.58348203e-01f, -3.50605786e-01f,
  -1.40880555e-01f, -3.94755095e-01f, -4.43371743e-01f, -1.44260982e-02f, 4.96753067e-01f, -1.16177201e-01f, -2.35610530e-01f, -5.39942622e-01f, -1.27647474e-01f, 5.09826183e-01f,
  3.32234532e-01f, -4.75217789e-01f, 7.21035004e-02f, -1.49275243e-01f, 4.85373408e-01f, -5.20431325e-02f, 3.46577503e-02f, 2.59493470e-01f, 2.66946197e-01f, -1.68768346e-01f,
  -8.41931477e-02f, 2.54831821e-01f, -6.45472631e-02f, -1.95093989e-01f, 1.01565450e-01f, -1.39670804e-01f, 4.69094127e-01f, -2.71117955e-01f, -6.61187544e-02f, -1.25642568e-01f,
  4.57375437e-01f, 2.00788707e-01f, -2.89625466e-01f, -1.82452146e-02f, -3.16266358e-01f, -1.85817033e-01f, 8.76581818e-02f, 3.80713373e-01f, -2.07702249e-01f, -6.66949302e-02f,
  -1.15704603e-01f, 5.50262369e-02f, -2.16370791e-01f, 6.66780695e-02f, 2.42481336e-01f, 1.86635435e-01f, 1.35757104e-01f, -2.23135695e-01f, 5.40597066e-02f, -9.63852033e-02f,
  1.22751489e-01f, 7.86993578e-02f, -3.54410380e-01f, 1.44431204e-01f, 2.46723115e-01f, -3.73812079e-01f, 1.50565103e-01f, -1.79613218e-01f, 6.68782666e-02f, -4.54424471e-01f,
  2.46791154e-01f, -2.99799204e-01f, 5.20211399e-01f, 2.41836339e-01f, -2.13322088e-01f, 3.16365629e-01f, 3.76476973e-01f, -7.16186613e-02f, -1.78677276e-01f, 5.30291021e-01f,
  2.61415273e-01f, 6.21069551e-01f, 1.36995822e-01f, 2.62740791e-01f, -3.57270062e-01f, -1.80313230e-01f, -3.22613895e-01f, 2.78397739e-01f, -7.98537731e-02f, -6.02586102e-03f,
  -3.55299145e-01f, -1.88391998e-01f, 8.77946522e-03f, 4.80093747e-01f, 6.85387477e-02f, -1.59303457e-01f, -6.62207380e-02f, -7.34818503e-02f, 2.36568704e-01f, 4.70303059e-01f,
  1.01476666e-02f, 9.94305834e-02f, 5.27096316e-02f, 2.43639573e-01f, -4.50914800e-02f, 1.12257963e-02f, -1.32084191e-01f, 4.10592973e-01f, -2.42955402e-01f, 1.71776265e-01f,
  -4.82744258e-03f, -1.42229900e-01f, -3.00778776e-01f, -1.69998348e-01f, 1.85665607e-01f, -1.48888722e-01f, 8.67435858e-02f, 9.52313244e-02f, 7.60177225e-02f, -2.12777570e-01f,
  1.56698868e-01f, 1.34284556e-01f, 8.51122942e-03f, 1.20912321e-01f, -8.01435392e-03f, -1.11527897e-01f, -6.41631559e-02f, 1.83686391e-01f, 3.58572334e-01f, -2.33379677e-01f,
  2.23692805e-01f, -3.52101773e-01f, -3.20408702e-01f, -3.40217888e-01f, -3.75145495e-01f, -3.02659065e-01f, -7.88167417e-02f, -1.49008948e-02f, 3.52943867e-01f, -1.90760508e-01f,
  1.33032322e-01f, 1.45409942e-01f, -2.67986864e-01f, -2.10171565e-01f, -1.49192497e-01f, -3.22718769e-01f, -1.27899796e-01f, -1.69897422e-01f, 2.57945240e-01f, -1.14865126e-02f,
  4.90307808e-01f, -6.48810744e-01f, 4.24143411e-02f, -1.32538244e-01f, 3.31363678e-01f, -2.25548267e-01f, 4.73196764e-04f, 5.85950352e-02f, 2.93342816e-03f, -2.01175421e-01f,
  -9.74140316e-02f, 3.33446831e-01f, -1.20358691e-01f, -2.69548893e-01f, -2.10673451e-01f, -2.36428693e-01f, -1.53937206e-01f, -1.34822279e-01f, -1.70352340e-01f, -1.20371528e-01f,
  5.69246054e-01f, -9.82255936e-02f, 6.72105014e-01f, 4.11385447e-02f, -2.52406269e-01f, 3.54636312e-02f, 5.35700679e-01f, -3.30569506e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.55635010e-02f, 1.62192658e-02f, -5.37920594e-02f, 7.72877410e-02f, -1.71343029e-01f, 4.97789085e-02f, -1.17578976e-01f, -5.84916770e-02f, 7.89735988e-02f, 6.79503828e-02f,
  -1.33300945e-01f, -5.50348721e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    