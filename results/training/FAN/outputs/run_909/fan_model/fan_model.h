/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.13122351e-02f, 1.83805674e-01f, 1.36109099e-01f, -7.58205950e-02f, 1.44552765e-02f, 5.00169620e-02f, 4.98201065e-02f, 4.92696539e-02f, -2.73038689e-02f, -1.24403425e-01f,
  -1.41816154e-01f, -1.16435617e-01f, -8.08776468e-02f, -1.17607631e-01f, -4.66490649e-02f, 3.20666879e-02f, -7.16737099e-03f, -7.59865120e-02f, -9.97874439e-02f, -1.61301792e-01f,
  -1.47729307e-01f, -1.50365410e-02f, -1.11539438e-01f, -9.21794251e-02f, 1.48072064e-01f, -4.56946045e-02f, 5.46824303e-04f, 1.29565254e-01f, 9.71018523e-02f, 1.20042272e-01f,
  -2.16917135e-02f, 1.21112846e-01f, 3.54547016e-02f, 4.65205833e-02f, -4.24005091e-03f, 8.03227350e-02f, 1.83707979e-02f, 5.54496124e-02f, 8.58660613e-04f, 6.75184093e-03f,
  -5.51891439e-02f, 1.96507908e-02f, 9.51666757e-02f, 5.68577684e-02f, -5.71022602e-03f, -1.22563869e-01f, 1.18875645e-01f, 1.48776015e-02f, 2.53653899e-03f, 1.14558928e-01f,
  4.65602279e-02f, 1.01748645e-01f, 3.25119160e-02f, 1.88796613e-02f, -2.89977882e-02f, -3.87606025e-02f, 8.41287225e-02f, 1.22364886e-01f, 1.07424386e-01f, 3.29924226e-02f,
  2.25550421e-02f, 4.71156556e-03f, -1.73160993e-02f, -1.51655376e-02f, 4.74286824e-03f, -8.21159258e-02f, 9.24380124e-02f, 1.58985797e-02f, -6.82379454e-02f, -2.07616277e-02f,
  -2.57684756e-02f, 1.07224053e-02f, -3.92395109e-02f, -2.81543750e-02f, 2.92101186e-02f, -3.80919017e-02f, 7.10570812e-02f, 2.67322995e-02f, -1.05042979e-01f, 5.06218933e-02f,
  1.68790706e-02f, -6.01289086e-02f, -7.61127919e-02f, 4.65338156e-02f, 6.34799153e-02f, 1.16730183e-02f, 4.53710482e-02f, -6.85845390e-02f, -1.22149438e-02f, -4.66908142e-02f,
  -8.18399638e-02f, -1.00714499e-02f, -2.08403193e-03f, -2.03397609e-02f, 9.07435566e-02f, -4.34222221e-02f, -1.84584465e-02f, 5.27748130e-02f, 4.72220453e-03f, 4.84113283e-02f,
  -3.73763181e-02f, -8.10902193e-03f, -8.99898484e-02f, 2.04003118e-02f, -8.65525231e-02f, -3.74144502e-02f, -7.35893473e-02f, -4.97596562e-02f, 2.98461993e-03f, 5.05138636e-02f,
  -1.02260813e-01f, -9.35002267e-02f, -8.14341828e-02f, -9.06058252e-02f, -3.53623293e-02f, -8.01800191e-02f, -3.91025096e-02f, 1.78200193e-02f, -2.50008516e-02f, -1.55723974e-01f,
  1.52177200e-01f, 7.76905334e-04f, -3.94864678e-02f, 6.34031743e-02f, -3.45380343e-02f, 6.37190118e-02f, -5.59670776e-02f, -5.72446212e-02f, 7.25715458e-02f, 1.10184792e-02f,
  2.79969652e-03f, 7.78959170e-02f, 1.26561066e-02f, 9.12738442e-02f, 8.93960595e-02f, -6.53130412e-02f, -8.33715126e-02f, 7.46879727e-02f, -1.41592668e-02f, 1.18443653e-01f,
  -9.55427997e-03f, 6.00929782e-02f, -3.28349173e-02f, 7.54847080e-02f, 5.92947043e-02f, 1.40345305e-01f, -5.47769777e-02f, -3.42295095e-02f, 3.37760523e-02f, -5.10282777e-02f,
  -6.40940815e-02f, -8.60600322e-02f, 1.92867406e-02f, 2.99398927e-03f, 1.18164495e-02f, 2.95105781e-02f, -1.87686924e-02f, 5.11632301e-02f, 6.50825445e-03f, -7.31809735e-02f,
  -2.75101718e-02f, 7.32343793e-02f, -2.17904858e-02f, -5.65060563e-02f, -4.44227271e-02f, 1.66819040e-02f, 1.75029356e-02f, 2.26614717e-03f, 6.37571588e-02f, -4.59842980e-02f,
  -7.83253238e-02f, 7.38222199e-03f, -1.13453671e-01f, -1.43150073e-02f, -7.09934160e-03f, -5.63412383e-02f, -4.40677721e-03f, -3.62766832e-02f, -4.47423197e-02f, -8.16976130e-02f,
  8.17598552e-02f, 1.74463203e-03f, -4.59484495e-02f, -3.25883254e-02f, -2.01643221e-02f, 4.50362153e-02f, -5.76981232e-02f, 7.44040832e-02f, -3.55102941e-02f, 1.27857402e-02f,
  1.81944072e-02f, -6.28623441e-02f, -5.97775802e-02f, 3.01879346e-02f, -2.99447067e-02f, -3.54887806e-02f, -7.07656741e-02f, 8.22251514e-02f, 6.53724894e-02f, -3.76825109e-02f,
  4.27763388e-02f, 6.74512610e-02f, 8.11650883e-03f, 1.06608775e-02f, -6.60290346e-02f, -9.19463672e-03f, -4.48076203e-02f, 4.40572388e-02f, 9.38465446e-03f, -4.54845056e-02f,
  -5.90707362e-02f, 6.36820048e-02f, -5.52223530e-03f, 7.38365529e-03f, -5.32459542e-02f, -5.75483032e-02f, -4.23709191e-02f, 4.70452979e-02f, 6.68706670e-02f, -5.29802702e-02f,
  -6.41848445e-02f, 8.18886384e-02f, -3.67246307e-02f, 4.57226634e-02f, -5.18776588e-02f, 1.77838691e-02f, 1.11823492e-02f, -4.84161004e-02f, 2.15899246e-03f, -3.73202264e-02f,
  -7.86868259e-02f, 3.65924463e-02f, -2.35284977e-02f, 3.77724767e-02f, 5.37663028e-02f, -6.76748678e-02f, 1.46691846e-02f, -1.03172392e-01f, -1.08813405e-01f, -7.45600984e-02f,
  3.01197380e-01f, -2.25065257e-02f, 1.78202361e-01f, -2.75941137e-02f, 7.67059699e-02f, 1.83010668e-01f, 2.17357352e-01f, 1.11220568e-01f, -3.50620896e-02f, -5.27352281e-02f,
  -5.83642200e-02f, -1.43571034e-01f, -5.47869466e-02f, -3.46335210e-02f, 1.20103210e-01f, 3.89503613e-02f, 1.34159014e-01f, 1.71041057e-01f, 5.02931885e-02f, 1.43071041e-01f,
  -5.14247417e-02f, 6.53094873e-02f, 5.39877750e-02f, 4.26164605e-02f, -2.75697764e-02f, 1.36699071e-02f, -6.01738729e-02f, 3.15631591e-02f, -3.82915772e-02f, 2.38202699e-02f,
  -4.04793583e-02f, 1.90418497e-01f, -9.36374720e-03f, -5.46744652e-02f, -7.42944106e-02f, -4.57862578e-02f, 7.37006292e-02f, -2.99836206e-03f, -2.67165601e-02f, -5.99396452e-02f,
  3.54167558e-02f, -4.33552302e-02f, -1.04544401e-01f, -8.57199878e-02f, -3.59990411e-02f, 2.09527920e-04f, -1.46456007e-02f, -5.79422712e-02f, -2.64138337e-02f, 4.45187762e-02f,
  -7.50648752e-02f, 4.96399552e-02f, -3.38843167e-02f, -1.02796322e-02f, -6.83848858e-02f, -6.72395946e-03f, -7.07430765e-02f, 4.02855091e-02f, 1.30184684e-02f, 3.80904879e-03f,
  -1.33193622e-03f, -5.46040013e-03f, 6.29882589e-02f, -8.72089043e-02f, -2.43980214e-02f, -2.32680496e-02f, -5.48843183e-02f, 2.14669034e-02f, -2.54183318e-02f, 2.91805808e-02f,
  -1.60667151e-02f, -3.19548100e-02f, -2.55000349e-02f, -5.75995930e-02f, -5.70667316e-06f, 4.49669827e-03f, 6.58561438e-02f, 6.79501668e-02f, -4.72985320e-02f, 9.93232895e-03f,
  -4.15489078e-02f, 2.19557248e-02f, 2.64500529e-02f, 8.91372282e-03f, 2.74899080e-02f, -6.50183856e-02f, -1.95368230e-02f, 5.18184416e-02f, 6.09776750e-02f, -2.68447027e-02f,
  1.02450782e-02f, 1.09967589e-01f, -3.62886488e-02f, -3.65190059e-02f, 1.54772494e-02f, -2.98274141e-02f, -2.97659598e-02f, 3.19828792e-03f, -6.14393316e-02f, 6.36430979e-02f,
  7.39660710e-02f, 2.17517596e-02f, -1.10576876e-01f, -4.68737036e-02f, 7.96774924e-02f, 5.17701581e-02f, 7.77950452e-04f, -4.25669970e-03f, -4.79529575e-02f, 5.61938472e-02f,
  -2.23220047e-02f, 8.46415907e-02f, 2.83557978e-02f, 3.57116829e-03f, 4.54207510e-02f, -3.58778983e-02f, -3.51971239e-02f, 5.80225959e-02f, 8.92153662e-03f, 5.65733295e-04f,
  -1.14960313e-01f, -2.09308621e-02f, -3.20464815e-03f, 1.62265509e-01f, 1.66042224e-01f, 1.62648156e-01f, 9.00846496e-02f, 7.32087567e-02f, 1.21136583e-01f, 2.64024679e-02f,
  -1.11239105e-01f, -5.77845164e-02f, -2.50925049e-02f, -2.05791593e-02f, 7.92920142e-02f, 1.67237133e-01f, 6.05879612e-02f, 2.02227328e-02f, -5.73393074e-04f, 7.08904862e-02f,
  -1.36842756e-02f, 1.20851785e-01f, 7.44938627e-02f, 3.35285552e-02f, 1.31593242e-01f, -2.25147214e-02f, 5.71967214e-02f, -2.14227047e-02f, 3.60349454e-02f, 1.66983351e-01f,
  6.68747211e-03f, -6.14451282e-02f, -6.43195733e-02f, -2.97992723e-03f, 1.08859427e-01f, 4.95017208e-02f, 7.10832551e-02f, 1.02192782e-01f, 9.01863053e-02f, -5.86235374e-02f,
  -2.50143874e-02f, 5.66010065e-02f, 4.25635874e-02f, -9.32081137e-03f, -5.91319054e-02f, -7.68190399e-02f, 4.83277999e-02f, -1.09343985e-02f, 8.58281404e-02f, 2.89137326e-02f,
  8.15843344e-02f, -1.12760186e-01f, 1.01283854e-02f, 3.20710018e-02f, 4.55525927e-02f, -1.01810902e-01f, 3.70556046e-03f, 4.31798287e-02f, 1.63648296e-02f, 2.40545645e-02f,
  2.43915711e-02f, 8.45157951e-02f, -3.56392413e-02f, 1.47063946e-02f, -6.85942397e-02f, 3.02754715e-03f, 2.21505817e-02f, 5.86425234e-03f, -2.03222577e-02f, -7.18657393e-03f,
  -1.25536593e-02f, -2.13227924e-02f, -2.45132539e-02f, 3.11236107e-03f, -1.24180103e-02f, -4.84453002e-03f, 3.66495736e-03f, 7.07942247e-03f, -2.01557521e-02f, -3.70065495e-02f,
  3.91901620e-02f, 1.36391772e-02f, -1.30270468e-02f, 1.19471088e-01f, -5.24751209e-02f, -5.50533161e-02f, 2.68835779e-02f, -4.49524969e-02f, 1.66093297e-02f, -5.06597497e-02f,
  1.83690503e-01f, -1.63084909e-01f, 1.16402902e-01f, 6.38704598e-02f, 4.00754996e-02f, -3.30769941e-02f, 1.14033408e-02f, -2.36362685e-02f, -7.04018548e-02f, -1.26355793e-02f,
  -3.03817801e-02f, 6.98390603e-02f, 2.99014151e-02f, 5.73007762e-02f, 3.30069587e-02f, -5.92192486e-02f, -6.82766065e-02f, 4.58909869e-02f, -7.10074008e-02f, -2.86134779e-02f,
  -4.95821610e-02f, 1.84541214e-02f, -7.56442621e-02f, 4.73996177e-02f, -4.15734276e-02f, -1.25286384e-02f, 6.47944734e-02f, 3.53089347e-02f, -7.87912086e-02f, 3.39082889e-02f,
  3.82920913e-02f, 1.45939171e-01f, 1.52062029e-02f, -9.45598632e-02f, -9.73944142e-02f, -1.18944466e-01f, -2.68316045e-02f, 1.06998449e-02f, -2.05362812e-02f, 7.70781040e-02f,
  4.43597846e-02f, 7.35467970e-02f, -1.64928120e-02f, -4.14706729e-02f, 4.25825827e-03f, 8.79452154e-02f, 2.01122295e-02f, -4.85917926e-02f, -1.44400448e-01f, -4.60675955e-02f,
  -4.32367856e-03f, -2.15623174e-02f, 6.27544522e-03f, -5.83125651e-02f, -2.18301602e-02f, -4.44403104e-02f, 6.64943606e-02f, -1.83498673e-03f, -6.83051627e-03f, 1.13393195e-01f,
  -1.51037738e-01f, -2.91712955e-02f, 2.26871539e-02f, 7.42636994e-02f, 3.73239676e-03f, 4.74786907e-02f, 6.83396310e-02f, -6.69025406e-02f, 8.99191946e-02f, 4.07061912e-02f,
  -3.91324684e-02f, -3.05896159e-02f, -2.56455354e-02f, -2.40364261e-02f, 2.17173025e-02f, -8.34915489e-02f, 9.60324258e-02f, 6.46531805e-02f, 1.05383523e-01f, 6.76823631e-02f,
  -6.59353137e-02f, -4.34963927e-02f, 4.71037626e-02f, -2.93573029e-02f, -5.04233502e-02f, -5.74138053e-02f, -2.47325487e-02f, -6.58209175e-02f, -1.43157027e-03f, 5.07700406e-02f,
  -8.05010647e-02f, -6.10048063e-02f, -6.67173937e-02f, 1.16249397e-01f, 5.26026487e-02f, 3.46820243e-02f, 6.37056120e-03f, -9.03599188e-02f, -4.18469198e-02f, 2.77416166e-02f,
  -5.71360476e-02f, -3.28081660e-02f, -7.79066682e-02f, -2.10893322e-02f, -6.04465604e-02f, -8.61430988e-02f, 3.23172621e-02f, 2.50584679e-03f, -1.66689157e-02f, 8.16878751e-02f,
  -1.78967498e-03f, 6.08041026e-02f, 7.68098012e-02f, -1.15199722e-02f, -4.95680720e-02f, -1.10183926e-02f, -5.76025918e-02f, 6.64519146e-03f, -3.06797400e-03f, -6.96127489e-03f,
  7.09032118e-02f, -5.36438124e-03f, -5.75484820e-02f, 2.55901366e-02f, 2.53120400e-02f, -7.10877627e-02f, -5.66473231e-02f, 4.24842238e-02f, -8.51328373e-02f, -4.80756387e-02f,
  -1.04561761e-01f, 5.58216684e-02f, 6.16896199e-03f, -8.27903301e-02f, -8.71766265e-03f, -6.63399398e-02f, -1.46855169e-03f, 4.80650775e-02f, -6.69577047e-02f, -8.30439478e-02f,
  -9.29229707e-02f, -1.01014480e-01f, -3.28989811e-02f, 5.07963374e-02f, -7.47434571e-02f, -4.61867489e-02f, -8.28592181e-02f, -1.33289188e-01f, -8.31187367e-02f, -5.39066419e-02f,
  -4.12005885e-03f, -2.40389049e-01f, 1.63250819e-01f, -1.35655478e-02f, 3.73322197e-04f, 2.10448708e-02f, -1.24666050e-01f, -1.42459720e-01f, 7.69810751e-02f, -1.46259427e-01f,
  -6.75869957e-02f, 9.27915871e-02f, -6.93176454e-03f, -4.06485461e-02f, -8.29204470e-02f, -4.08505872e-02f, -4.78829630e-02f, 1.39751241e-01f, 2.64286071e-01f, 1.77283406e-01f,
  1.20620072e-01f, -3.17031816e-02f, -5.55845276e-02f, -2.18067635e-02f, -3.97889577e-02f, 2.12365136e-01f, -8.87688026e-02f, -7.41959065e-02f, 1.34743467e-01f, -2.46152431e-02f,
  5.57605959e-02f, -1.00396156e-01f, 1.95125416e-01f, 6.47059530e-02f, 7.56298155e-02f, -1.75844170e-02f, -9.27641019e-02f, -2.82689743e-02f, 2.92488858e-02f, -8.68434608e-02f,
  -1.97917055e-02f, -9.43335146e-02f, -1.42886773e-01f, -5.41856466e-03f, 6.03713207e-02f, 7.11693466e-02f, -4.85530607e-02f, 4.41906042e-02f, -9.27838460e-02f, -7.63898939e-02f,
  -3.37445997e-02f, 5.09205535e-02f, 2.22831871e-02f, -5.24063446e-02f, -1.05753966e-01f, 8.52898955e-02f, 6.89955056e-02f, 8.83338749e-02f, 6.43271580e-02f, -3.94233726e-02f,
  -6.54390082e-03f, 6.48963153e-02f, 2.84605846e-02f, -1.00446716e-02f, -5.28008230e-02f, 2.68037822e-02f, 8.57624859e-02f, -1.05908252e-02f, 8.29391927e-02f, -9.81463417e-02f,
  -1.58388000e-02f, -1.26254819e-02f, -5.41768558e-02f, -3.17543349e-03f, -1.44442515e-02f, -4.03728597e-02f, -8.08247328e-02f, -1.20647907e-01f, 1.67930536e-02f, -9.04578269e-02f,
  1.29257083e-01f, 4.41037351e-03f, 6.66917413e-02f, -1.01939306e-01f, 1.06804268e-02f, 4.86590900e-03f, -5.89370094e-02f, 7.68133104e-02f, -7.92529285e-02f, 4.37296256e-02f,
  1.56801403e-01f, 1.10686935e-01f, -1.31504327e-01f, -8.42800513e-02f, 1.49436042e-01f, 4.24893796e-02f, -4.65191389e-03f, -4.09538224e-02f, 8.54872465e-02f, -7.00804740e-02f,
  -1.92484278e-02f, -4.12318520e-02f, -1.34168984e-02f, 2.20997329e-03f, 4.60834149e-03f, 7.37978965e-02f, -4.89151068e-02f, 7.17574731e-03f, 1.16772033e-01f, 6.81449920e-02f,
  -1.00103326e-01f, 3.51384133e-02f, 1.14441916e-01f, -7.15762153e-02f, -9.16873217e-02f, 7.46995434e-02f, 1.11824647e-01f, 1.24273323e-01f, 7.11834654e-02f, 1.35937305e-02f,
  -6.90441653e-02f, -1.43677354e-01f, -5.43927774e-03f, 1.11832730e-01f, -4.86492328e-02f, -6.43031374e-02f, -2.80119300e-01f, -1.39822327e-02f, 1.19554766e-01f, 3.88432406e-02f,
  -1.40549643e-02f, 3.21331248e-02f, 1.01641946e-01f, -1.76482107e-02f, 2.52393130e-02f, -5.14548123e-02f, 4.00293320e-02f, 1.13238238e-01f, 8.58492628e-02f, -8.03818256e-02f,
  6.75146841e-03f, 2.71451417e-02f, 8.36247653e-02f, 1.54929861e-01f, -3.49199325e-02f, 3.45099494e-02f, 1.10883199e-01f, 8.87788236e-02f, -1.98033396e-02f, 2.08343025e-02f,
  8.65301043e-02f, 9.73613262e-02f, 3.86827402e-02f, -8.41491446e-02f, 5.79905398e-02f, 1.17434394e-02f, -6.50794432e-02f, -2.38702334e-02f, 5.73901981e-02f, 4.36301120e-02f,
  3.76225710e-02f, 1.70901176e-02f, 6.31899089e-02f, 9.69544202e-02f, -4.47602756e-03f, 6.38483763e-02f, -1.26541853e-02f, 7.19941631e-02f, 5.26915640e-02f, 1.19099706e-01f,
  -6.12022588e-03f, 2.15838503e-04f, -1.09503984e-01f, -3.10162324e-02f, 1.03765436e-01f, 4.93737906e-02f, 2.27270350e-02f, -7.28611052e-02f, -8.21710080e-02f, -1.28574327e-01f,
  9.03900247e-03f, 4.29130625e-03f, 9.40423086e-02f, -3.98620777e-02f, 1.25270961e-02f, 3.24320458e-02f, 5.50457016e-02f, 1.80700608e-02f, 2.58397944e-02f, -8.15193802e-02f,
  -1.97203048e-02f, -5.62285744e-02f, 9.31774899e-02f, 5.05456589e-02f, -1.26198336e-01f, 1.02050267e-02f, 5.17082810e-02f, -1.33618340e-01f, -1.68670285e-02f, 7.11364076e-02f,
  5.85897826e-02f, -4.37795818e-02f, 8.50374699e-02f, 4.66375612e-02f, -6.23418055e-02f, 1.77340358e-02f, 7.59671330e-02f, 9.92970262e-03f, -1.98515337e-02f, 1.08133525e-01f,
  -1.36601865e-01f, 4.60820347e-02f, -5.81942350e-02f, -2.98141912e-02f, -3.90691273e-02f, -7.49624744e-02f, 5.25307395e-02f, 4.12254827e-03f, 5.69541454e-02f, 4.07712050e-02f,
  1.93039849e-02f, 5.73927611e-02f, -1.38786640e-02f, -5.74719124e-02f, 9.13682394e-03f, -1.10731358e-02f, -2.76012905e-02f, -3.54957692e-02f, -2.23992746e-02f, -3.24067064e-02f,
  -4.93966676e-02f, -1.92164049e-01f, -1.67373314e-01f, -1.27940491e-01f, -1.11981474e-01f, -9.77634713e-02f, -1.59770265e-01f, -1.04114123e-01f, -2.18940601e-01f, -3.43537658e-01f,
  6.84407711e-01f, -7.54096806e-02f, 1.30345643e-01f, 1.19998209e-01f, 2.78840642e-02f, 1.95347313e-02f, -6.07204549e-02f, 4.22929712e-02f, 7.39836469e-02f, -3.16305757e-02f,
  7.78355077e-02f, -8.76307189e-02f, -6.55754050e-03f, -1.12178229e-01f, -4.26222533e-02f, -9.56578180e-02f, -6.19171485e-02f, 3.90985385e-02f, 6.00053146e-02f, 5.26056662e-02f,
  -1.67809427e-01f, 4.05490808e-02f, 1.31439209e-01f, 1.25133380e-01f, -8.42344388e-02f, -3.46235558e-02f, 4.42693941e-02f, -6.03144392e-02f, -9.56707671e-02f, -2.40389168e-01f,
  1.50466964e-01f, 1.71039209e-01f, -2.81698070e-02f, 1.91830136e-02f, -5.78809753e-02f, 7.53540322e-02f, 6.39141276e-02f, -2.14652028e-02f, -9.14862566e-03f, 4.89558689e-02f,
  -8.63993466e-02f, -6.51751980e-02f, 9.25822183e-02f, 5.24233691e-02f, 3.77979204e-02f, -1.08197838e-01f, -4.81349826e-02f, 4.03365344e-02f, 9.52689797e-02f, -1.09581441e-01f,
  -1.92357287e-01f, -1.04122190e-02f, 1.81530848e-01f, 7.43949562e-02f, 9.02411118e-02f, -5.45217469e-02f, 3.91099565e-02f, -9.16971415e-02f, 8.58962685e-02f, -7.34584704e-02f,
  -7.14877099e-02f, 2.76349597e-02f, -1.16349468e-02f, -1.76050961e-02f, 6.60128668e-02f, -6.23619631e-02f, -1.23044448e-02f, -7.65082091e-02f, 1.64864995e-02f, 6.54043779e-02f,
  -6.31296411e-02f, 1.33030489e-02f, -2.60811560e-02f, 4.59507294e-02f, 1.76602732e-02f, -4.46143746e-02f, 4.23536040e-02f, 3.29104774e-02f, 7.33376900e-03f, 5.27788745e-03f,
  -5.19067906e-02f, -3.65859903e-02f, 2.18973532e-02f, 2.95751952e-02f, -6.94926679e-02f, 6.63719252e-02f, -9.26060230e-03f, -3.48927360e-03f, 1.64786875e-02f, 1.90790147e-02f,
  1.51972085e-01f, 1.56398434e-02f, 4.75940816e-02f, -6.60920739e-02f, 6.90617561e-02f, -6.28333017e-02f, -5.08956565e-03f, -2.45478339e-02f, 3.36504206e-02f, -6.33390620e-02f,
  9.51589495e-02f, 1.12657389e-02f, 6.57418221e-02f, 6.24304079e-03f, -5.46021573e-02f, -1.28239989e-02f, -4.25939783e-02f, 6.87467754e-02f, -5.73188588e-02f, 2.25049444e-02f,
  -1.09451964e-01f, 8.59614909e-02f, 1.49535313e-01f, -1.14954896e-02f, -5.41252270e-02f, 5.80407269e-02f, -8.01509395e-02f, -3.45271304e-02f, 6.43125400e-02f, -1.46787595e-02f,
  2.68203229e-01f, -1.15542769e-01f, 6.04844745e-03f, 1.51537403e-01f, -3.96453142e-02f, 7.53170848e-02f, 7.83390738e-03f, -2.05295607e-02f, -1.14195421e-02f, 2.06246953e-02f,
  3.43259163e-02f, 3.04801725e-02f, 7.53870681e-02f, 5.69561496e-02f, 1.01629324e-01f, 8.97433087e-02f, 1.69293895e-01f, 5.14728427e-02f, 3.64366397e-02f, -3.18803377e-02f,
  -2.65950933e-02f, 6.43433258e-02f, 2.84254341e-03f, -4.22689831e-03f, -2.54000314e-02f, 4.55945991e-02f, -1.76889431e-02f, -1.01897307e-01f, 1.48390168e-02f, 1.28877625e-01f,
  -1.33260801e-01f, -8.73777643e-02f, 9.68954563e-02f, 1.35543138e-01f, -6.55552968e-02f, -1.06389569e-02f, 3.81861776e-02f, -3.24311405e-02f, -2.81871911e-02f, -6.27651587e-02f,
  7.90295936e-03f, 4.54888158e-02f, 9.12354067e-02f, -5.40546589e-02f, -2.15748083e-02f, 7.52907433e-03f, -1.25115082e-01f, -6.20070174e-02f, -3.92292533e-03f, -1.38901277e-02f,
  6.88687861e-02f, 4.98658828e-02f, -4.53474037e-02f, -1.90794282e-02f, 3.45922187e-02f, 1.36168137e-01f, -8.03344250e-02f, -6.34469241e-02f, -7.98920095e-02f, -9.68284756e-02f,
  -1.54396025e-02f, 1.56950187e-02f, -6.05915720e-03f, -1.03509128e-01f, -1.47239014e-04f, -1.47116631e-02f, -4.31347871e-03f, -3.57583202e-02f, 8.52677133e-03f, -2.94259917e-02f,
  6.77196905e-02f, -1.94949831e-03f, 6.83005080e-02f, 5.29903173e-02f, 7.06537440e-02f, 5.55849448e-02f, -4.06342335e-02f, 8.57395753e-02f, 4.02531065e-02f, -3.20172608e-02f,
  1.08106676e-02f, 4.48858067e-02f, -3.84602658e-02f, -1.77735544e-03f, 1.13741502e-01f, 1.00109670e-02f, -3.96549376e-03f, -6.55562431e-02f, -5.92155084e-02f, -1.69746447e-02f,
  -1.41245782e-01f, 1.24739110e-01f, -7.76257180e-03f, -2.16359440e-02f, 5.25700673e-02f, -6.61700964e-02f, 6.66580945e-02f, -8.68812129e-02f, -7.26168007e-02f, 2.87278723e-02f,
  2.66264975e-02f, 7.84950238e-03f, -1.92930307e-02f, 2.98093595e-02f, -1.16879627e-01f, -1.37412245e-03f, -1.17902197e-02f, 2.75051296e-02f, 6.46796823e-02f, 6.43343627e-02f,
  3.45764570e-02f, -3.88600193e-02f, -4.62152343e-03f, -3.29414234e-02f, -3.06129269e-02f, 1.27723068e-01f, -6.95177317e-02f, 1.77201219e-02f, -3.08640264e-02f, -8.88599157e-02f,
  1.72936678e-01f, -2.37198234e-01f, 2.48454615e-01f, 1.55370653e-01f, 2.08586752e-01f, 2.88074575e-02f, 3.58908959e-02f, -4.43357453e-02f, -7.99633041e-02f, 8.91642421e-02f,
  -1.05631590e-01f, -1.00666232e-01f, -7.29668513e-02f, -1.82874039e-01f, -1.11989304e-01f, -9.02055651e-02f, 1.26739889e-01f, 1.20312184e-01f, 1.38741791e-01f, 7.47302696e-02f,
  -4.63141799e-02f, 1.98834345e-01f, -1.46480314e-02f, -1.08024620e-01f, 1.38553098e-01f, -9.09638777e-02f, 7.84329697e-02f, 1.61113814e-01f, -6.34131767e-03f, 3.38444591e-01f,
  1.11668140e-01f, 4.17219959e-02f, 2.85458788e-02f, -9.35077146e-02f, 9.13208872e-02f, -3.63472886e-02f, -1.02128647e-01f, 1.20414644e-02f, -5.69714792e-02f, -2.86450963e-02f,
  -1.43273436e-02f, -9.33445841e-02f, 5.74491620e-02f, -1.88952852e-02f, 3.71102057e-02f, 8.45736787e-02f, -2.94942185e-02f, 4.68242317e-02f, 6.22520074e-02f, -4.76093916e-03f,
  4.82419680e-04f, 3.60872969e-02f, 6.54058605e-02f, -5.17336503e-02f, -5.30837215e-02f, 6.81000724e-02f, -1.88799724e-02f, 7.14543909e-02f, -5.32956831e-02f, -3.52130197e-02f,
  -3.48581374e-03f, -1.66251007e-02f, 1.30768642e-02f, 3.82222328e-03f, 3.43195386e-02f, 7.16914842e-03f, -4.85361665e-02f, 7.72008393e-03f, 3.02842576e-02f, -2.01517940e-02f,
  -1.84612218e-02f, 1.07893832e-02f, -1.66339912e-02f, -6.06185906e-02f, -6.84788451e-03f, 5.88096529e-02f, 1.51447374e-02f, -3.65119465e-02f, 1.81189701e-02f, -3.88695672e-02f,
  9.77831427e-03f, -2.17424706e-03f, 1.15872882e-01f, -2.03130860e-02f, 1.11571923e-02f, -1.05817523e-02f, -1.87067650e-02f, -7.04533607e-02f, 8.64157826e-02f, 6.74084155e-03f,
  -2.85124362e-01f, 1.12197392e-01f, 7.07849441e-03f, 3.09289317e-03f, 1.04481585e-01f, -4.60981838e-02f, 5.94605505e-02f, 5.97918630e-02f, 3.18485089e-02f, 2.83051236e-03f,
  -1.71826768e-03f, -3.54418494e-02f, 5.67310639e-02f, -5.19142933e-02f, 9.11963880e-02f, 4.07599360e-02f, -7.37363696e-02f, 3.63044217e-02f, 5.65367639e-02f, -2.77119763e-02f,
  4.77130665e-03f, 3.95429023e-02f, -1.30980149e-01f, -4.21480276e-02f, -2.65255105e-02f, 1.02814808e-02f, -9.62848216e-02f, -3.77574861e-02f, -4.79663052e-02f, -2.62545764e-01f,
  1.36249319e-01f, -7.86341950e-02f, 5.81728593e-02f, 1.07704110e-01f, 1.11311585e-01f, 1.34671047e-01f, 5.47078885e-02f, 7.53473490e-02f, 1.30636141e-01f, -6.07818402e-02f,
  1.05703875e-01f, 1.44932270e-02f, -6.53929040e-02f, -1.23709843e-01f, 4.51784693e-02f, -1.46936893e-01f, -1.72562599e-01f, -1.47355646e-02f, 3.30105238e-02f, 7.89094418e-02f,
  -4.84030433e-02f, -7.23152459e-02f, 6.89074164e-03f, 5.61295226e-02f, -5.28539643e-02f, 5.25526218e-02f, 6.90541044e-02f, -6.93153590e-02f, 6.55747205e-02f, -2.74045020e-01f,
  -1.44464001e-01f, 5.78598641e-02f, -1.02608927e-01f, 3.66260596e-02f, -1.04968823e-01f, -9.50004309e-02f, 4.93614636e-02f, -2.08339393e-02f, 3.38023640e-02f, -3.76759060e-02f,
  -1.51591785e-02f, -1.10059744e-02f, 6.81277290e-02f, -6.55195266e-02f, 1.03604533e-02f, 4.52785417e-02f, 1.01068810e-01f, -1.07849024e-01f, -8.14138073e-03f, -7.23179281e-02f,
  9.01581734e-06f, 5.13317063e-03f, -3.77402664e-03f, 2.27176305e-02f, 1.33504141e-02f, -7.43981004e-02f, 1.15692616e-01f, 7.85388201e-02f, 6.79286048e-02f, -1.48147987e-02f,
  -2.94922963e-02f, -6.11104332e-02f, -3.47634815e-02f, 2.28425600e-02f, 9.91246998e-02f, 3.06974929e-02f, -1.05867907e-01f, -2.88025313e-03f, 9.39514413e-02f, 3.25588770e-02f,
  -1.33294165e-02f, 6.03158772e-02f, -1.91520657e-02f, 2.18844842e-02f, 6.19229451e-02f, -8.47778865e-04f, 5.45817092e-02f, -6.36394508e-03f, 3.61068994e-02f, -6.88618496e-02f,
  6.09219298e-02f, -2.49191490e-03f, -1.73770841e-02f, -3.07533331e-02f, 4.45721783e-02f, -2.63305753e-02f, -5.07370860e-04f, 4.90921065e-02f, -1.20521914e-02f, -5.13170240e-03f,
  -1.47117957e-01f, 1.79650128e-01f, -1.04585387e-01f, -1.61375124e-02f, 1.05229090e-04f, -2.16352660e-02f, 3.00623327e-02f, 5.43608293e-02f, -1.43995965e-02f, -6.67648390e-02f,
  5.22239730e-02f, 9.60822776e-03f, -3.15461531e-02f, 4.84483503e-02f, -5.87757193e-02f, -9.49141532e-02f, 3.05856820e-02f, 3.01857125e-02f, 1.06740529e-02f, -1.01946630e-01f,
  1.31629454e-02f, 3.60093371e-04f, 5.36438897e-02f, 1.19286127e-01f, 2.38642413e-02f, -4.59192507e-02f, -3.80109507e-03f, 8.14935006e-03f, 1.00949034e-01f, -2.84704734e-02f,
  2.95601398e-01f, 2.02122211e-01f, -9.55898613e-02f, 5.44230081e-02f, -4.41632420e-02f, 5.20779230e-02f, 2.58788824e-01f, 2.31516715e-02f, 6.33922145e-02f, 9.64978486e-02f,
  1.48923630e-02f, -1.57147273e-01f, -1.37405127e-01f, -4.76570651e-02f, -3.06002959e-03f, 2.08815694e-01f, 9.57067758e-02f, 4.16475954e-03f, 2.11265907e-02f, 8.46742466e-02f,
  -1.45387528e-02f, 7.38096163e-02f, 7.20703676e-02f, -5.53307831e-02f, 4.03869152e-02f, -1.75016508e-01f, -5.14636189e-02f, -1.57339647e-02f, -6.96371123e-02f, 2.61611193e-02f,
  -1.39475897e-01f, -4.88318242e-02f, -1.10814571e-01f, -5.87503314e-02f, -4.03552456e-03f, 8.89304187e-03f, 8.49780887e-02f, -4.07038815e-02f, -7.45804906e-02f, 2.07305923e-02f,
  -2.13227496e-02f, -3.08232429e-03f, 2.73910444e-02f, -7.32146669e-03f, 2.54606977e-02f, 1.00913554e-01f, 8.04337040e-02f, -1.54401986e-02f, 2.65102088e-02f, 2.10323017e-02f,
  -3.44923697e-02f, -1.29899578e-02f, 1.28206527e-02f, 5.16695715e-02f, 4.15368564e-02f, -1.28847167e-01f, 3.15696299e-02f, -4.99129780e-02f, -4.61093001e-02f, 5.47767170e-02f,
  6.70722201e-02f, -3.37287635e-02f, -2.45823581e-02f, -5.01931943e-02f, 3.99691127e-02f, 4.22224887e-02f, -1.06658386e-02f, 3.29469182e-02f, 4.33919393e-03f, -1.15882289e-02f,
  -8.69945511e-02f, -1.78431217e-02f, 3.11208293e-02f, 4.93360944e-02f, -2.09617727e-02f, 5.27122132e-02f, 5.82946232e-03f, 4.99638394e-02f, -2.21775174e-02f, -3.21721323e-02f,
  -5.40126711e-02f, -8.78839288e-03f, 6.85638636e-02f, 5.46359122e-02f, -4.11387999e-03f, 1.12687668e-03f, 4.12469059e-02f, 6.20962679e-02f, -5.93362525e-02f, 5.52175045e-02f,
  -1.49015477e-02f, -2.06022426e-01f, 1.05061578e-02f, 6.79765567e-02f, -5.05210683e-02f, -3.58174779e-02f, -7.65087381e-02f, -4.95141558e-02f, -3.62836607e-02f, 6.93097487e-02f,
  1.07256519e-02f, 1.07179523e-01f, 2.99468078e-03f, 4.35877442e-02f, 1.11837210e-02f, -1.47210564e-02f, 4.57906984e-02f, 2.66463049e-02f, 3.62869278e-02f, 9.46514402e-03f,
  1.01300642e-01f, 9.91610512e-02f, 1.12027571e-01f, 9.60985497e-02f, 1.85518935e-02f, 7.97213018e-02f, -5.02587222e-02f, -7.50961015e-03f, 4.77993377e-02f, 1.96502298e-01f,
  -5.17913222e-01f, 1.03409909e-01f, -1.83581710e-02f, 4.36824076e-02f, -3.18411961e-02f, -1.98532403e-01f, -1.55951649e-01f, -1.10552952e-01f, -4.24550623e-02f, -1.86843134e-03f,
  -1.15308957e-02f, 8.97200555e-02f, 1.10252192e-02f, 1.27934605e-01f, -1.32614970e-01f, -1.24934882e-01f, 1.47484625e-02f, -7.91189373e-02f, -8.34527332e-03f, -3.97233889e-02f,
  8.06844085e-02f, 9.61995721e-02f, 9.25503522e-02f, 8.06222036e-02f, 2.07387298e-01f, 1.45048201e-02f, 1.09255537e-01f, 6.26653284e-02f, 5.86409681e-02f, 1.23549037e-01f,
  1.97430521e-01f, -8.74057114e-02f, 9.67457052e-03f, 4.65263203e-02f, 8.39074180e-02f, -3.88006540e-03f, -2.90667936e-02f, 1.79493241e-02f, -6.42153667e-03f, 6.33258671e-02f,
  3.08321360e-02f, -6.39903769e-02f, -5.67114502e-02f, 7.23687485e-02f, -7.70873576e-02f, -5.25098518e-02f, -3.51467840e-02f, -1.21537916e-01f, -3.62706371e-02f, 7.79142231e-03f,
  9.79392827e-02f, -6.37014136e-02f, -3.46881188e-02f, -5.83126023e-02f, 1.39623759e-02f, -9.34616029e-02f, 7.06329718e-02f, 3.44635993e-02f, -5.17719351e-02f, 2.70251241e-02f,
  9.03763846e-02f, 9.48028057e-04f, -3.35995182e-02f, -7.05664903e-02f, 6.48487732e-02f, 2.93891151e-02f, -6.07142597e-02f, 5.42823896e-02f, -5.04576713e-02f, 1.12257876e-01f,
  -1.86199807e-02f, -3.37483212e-02f, -5.25233150e-02f, -3.74457389e-02f, 8.36972743e-02f, -5.81135079e-02f, 3.27223986e-02f, 2.07316801e-02f, -2.49040741e-02f, -1.57317128e-02f,
  -7.86200389e-02f, 1.56939235e-02f, 4.86616790e-02f, -3.97574576e-03f, -4.75525633e-02f, -8.41866364e-04f, 5.48883080e-02f, -1.52453482e-02f, 1.40380310e-02f, -4.27596644e-02f,
  1.84062168e-01f, -9.07358080e-02f, 1.35445178e-01f, 4.29786034e-02f, 7.07682222e-02f, 8.57580395e-04f, 7.55496621e-02f, 3.22360406e-03f, 3.54311848e-03f, 1.49597405e-02f,
  4.80595157e-02f, -6.80962726e-02f, -1.00421440e-02f, 5.70830517e-02f, -1.04277246e-02f, 2.02741306e-02f, 2.69262195e-02f, 6.54333234e-02f, -1.65554490e-02f, 3.36985886e-02f,
  5.95958577e-03f, -1.14975370e-01f, 1.75810419e-02f, 3.24840322e-02f, 4.22024913e-02f, 9.70763154e-03f, 1.31664369e-02f, 1.48946177e-02f, -1.90506488e-01f, 4.08770889e-02f,
  -2.40394890e-01f, 8.93007591e-03f, 1.48096099e-01f, 9.21856426e-03f, 8.56171623e-02f, 1.55267432e-01f, 9.58135948e-02f, -3.97756062e-02f, -4.22869138e-02f, -3.36659104e-02f,
  1.01516940e-01f, 1.28727164e-02f, -8.37467797e-03f, -4.39670868e-02f, -4.99729905e-03f, -4.54869159e-02f, -6.70543090e-02f, -1.72364384e-01f, -1.61274634e-02f, 6.22983053e-02f,
  -1.80127062e-02f, -6.29108101e-02f, -1.57253325e-01f, -6.12844117e-02f, -1.03762470e-01f, -1.94633026e-02f, 8.34714845e-02f, -1.24364786e-01f, 4.46619913e-02f, -2.83089340e-01f,
  1.04343882e-02f, 3.26105207e-02f, 2.27686688e-02f, -9.19653401e-02f, 1.02481626e-01f, 4.53423485e-02f, 2.08130386e-02f, -4.67151031e-02f, -2.04715598e-02f, 9.62865725e-03f,
  6.40144125e-02f, -4.10464853e-02f, 3.59201292e-03f, 5.90434670e-02f, -7.95706138e-02f, -2.42884979e-02f, -1.03466064e-01f, -4.24818620e-02f, 2.48134769e-02f, 2.26456132e-02f,
  -6.41657645e-03f, -1.52158579e-02f, -8.92292187e-02f, 5.36872819e-02f, -1.13174967e-01f, 1.08816326e-02f, -2.07072287e-03f, -1.37447834e-01f, -1.11681931e-01f, -2.31975585e-01f,
  4.55278121e-02f, -6.01572543e-02f, -6.20238576e-03f, -4.13802452e-02f, 9.90043059e-02f, -1.17115234e-03f, -4.11632545e-02f, -4.83458638e-02f, 3.00233588e-02f, -9.35942978e-02f,
  5.11146486e-02f, -7.75068440e-03f, -6.15855120e-02f, -2.48479173e-02f, 2.30092332e-02f, -5.84607609e-02f, 1.57721061e-02f, 1.37820631e-01f, -4.44487035e-02f, -6.77022859e-02f,
  -4.54599820e-02f, 3.07209678e-02f, 7.65834888e-03f, -3.17897857e-03f, -5.68261631e-02f, -5.82994632e-02f, 7.83264115e-02f, 5.36757931e-02f, 2.49890033e-02f, 1.04646489e-01f,
  -3.24555077e-02f, 2.80691981e-02f, -1.52095174e-03f, -4.53234203e-02f, -3.08923833e-02f, 1.08483071e-02f, 9.15357247e-02f, -3.92388459e-03f, 3.70673090e-02f, 7.09930435e-02f,
  4.89780940e-02f, -1.63349379e-02f, 6.93159997e-02f, -4.06287536e-02f, 7.37521276e-02f, 3.84351350e-02f, 6.19309433e-02f, 1.03902409e-03f, 1.51881743e-02f, 5.55864275e-02f,
  -3.04625090e-03f, -6.25566170e-02f, -6.89008161e-02f, -8.60588998e-02f, -4.35485542e-02f, -2.68465057e-02f, 1.37480777e-02f, 5.72646298e-02f, -2.53519490e-02f, 1.43586695e-01f,
  -2.26560056e-01f, -8.50376487e-03f, -1.98682234e-01f, -2.89050758e-01f, -1.64176941e-01f, 7.53786564e-02f, -3.71515602e-02f, 5.58209084e-02f, -6.06295466e-03f, -1.18264273e-01f,
  -5.96152619e-02f, -2.70083435e-02f, -1.02630422e-01f, 2.33169291e-02f, -7.16945454e-02f, -7.07985684e-02f, -7.75166601e-02f, -9.65097398e-02f, -1.19805112e-02f, -1.53449494e-02f,
  1.00538403e-01f, -2.37681139e-02f, -6.45195097e-02f, 1.04955241e-01f, 3.31994370e-02f, 2.57385342e-04f, -8.26508030e-02f, 6.26473352e-02f, 1.03296928e-01f, -6.86251819e-02f,
  4.68557235e-03f, -1.36561096e-01f, -1.84143353e-02f, -7.97325224e-02f, 1.50963683e-02f, -1.67401247e-02f, -7.85041302e-02f, -5.31318374e-02f, 4.14979309e-02f, 3.68843228e-02f,
  -6.34752810e-02f, 4.85063158e-02f, 4.37225290e-02f, -5.45805171e-02f, 1.99422613e-02f, 4.25313190e-02f, -2.30329391e-02f, -6.70184568e-02f, 5.64067252e-02f, -1.21753421e-02f,
  -9.84658077e-02f, -6.00090735e-02f, 1.07985020e-01f, -3.22495177e-02f, 2.28628255e-02f, -1.48046136e-01f, 5.78606427e-02f, 5.99304512e-02f, 2.59572584e-02f, -4.35312204e-02f,
  -6.34054616e-02f, -4.38075745e-03f, -4.50964943e-02f, 5.05063944e-02f, -1.39885917e-02f, -3.39058265e-02f, 1.91488806e-02f, 1.74568295e-02f, -1.91707909e-02f, 7.62343872e-03f,
  -3.41471732e-02f, -8.71858969e-02f, -5.94209023e-02f, 1.39345713e-02f, 4.37845401e-02f, 1.34302760e-02f, 6.88561723e-02f, 1.60161536e-02f, -3.49889807e-02f, 6.87573552e-02f,
  1.76662784e-02f, 7.57334530e-02f, 1.30292717e-02f, 1.20606363e-01f, -7.17336088e-02f, -2.84979939e-02f, 2.39411835e-02f, -5.10240905e-02f, 1.21336477e-02f, 6.14903122e-02f,
  2.94603850e-03f, -1.39849871e-01f, -2.49164142e-02f, 9.04271677e-02f, 4.45974208e-02f, -4.18905802e-02f, -7.11176693e-02f, 2.86526997e-02f, -9.29412469e-02f, 5.48992045e-02f,
  5.20631764e-03f, 4.44187745e-02f, -5.67843579e-02f, 1.19480751e-01f, 6.78228438e-02f, 4.04422954e-02f, 8.24823007e-02f, 3.86627130e-02f, 4.32780646e-02f, 4.28063124e-02f,
  8.87095183e-03f, 5.14693595e-02f, 2.23619770e-02f, 9.60356295e-02f, 2.19412334e-02f, -5.40648326e-02f, 4.17300919e-03f, 1.06817953e-01f, 8.20501000e-02f, 7.81403705e-02f,
  -1.54434621e-01f, 2.58698046e-01f, 1.21298306e-01f, 1.64033413e-01f, -5.13249123e-03f, -1.44127488e-01f, -1.01798147e-01f, -4.49316166e-02f, -7.03684334e-03f, 5.80240339e-02f,
  4.20982353e-02f, 8.03891644e-02f, -4.65944856e-02f, -9.93623659e-02f, -1.13388551e-02f, -1.11310914e-01f, 3.67835499e-02f, -1.34660840e-01f, -9.69312117e-02f, -7.85868838e-02f,
  -1.02666952e-01f, 6.56978115e-02f, 1.69326276e-01f, 5.73515929e-02f, 5.11954129e-02f, -8.62117931e-02f, 1.50383368e-01f, 2.08562955e-01f, 8.97121578e-02f, 1.42485788e-02f,
  -1.54486880e-01f, 1.56877205e-01f, -3.83573063e-02f, 5.45986518e-02f, 8.05668682e-02f, -4.62281853e-02f, -2.70400960e-02f, 8.01316127e-02f, 2.59090122e-02f, -1.49700642e-02f,
  1.08460449e-01f, 4.09145616e-02f, -3.56465168e-02f, 5.15259057e-02f, 1.05911314e-01f, -2.54060812e-02f, 1.30645320e-01f, -2.06682812e-02f, -7.17289373e-02f, -8.60834792e-02f,
  1.01525309e-02f, 8.47956017e-02f, -7.67039880e-02f, 1.68035703e-03f, -3.87938842e-02f, 4.46027480e-02f, 3.41508836e-02f, -5.81926592e-02f, 6.45089075e-02f, 2.63691694e-02f,
  -5.19530699e-02f, -1.44931125e-02f, -5.32891937e-02f, 1.54253719e-02f, -3.98377031e-02f, -7.71996826e-02f, 3.46868113e-02f, 1.56046590e-02f, -3.67683452e-03f, -5.98091371e-02f,
  7.90005103e-02f, 4.07755794e-03f, 5.18831089e-02f, -3.35712656e-02f, 1.51839536e-02f, 8.69527906e-02f, -2.87761576e-02f, -1.33710476e-02f, 2.36172564e-02f, 5.12751378e-02f,
  -4.26889807e-02f, -4.94342670e-02f, -1.37364585e-02f, 6.34644628e-02f, 5.87862208e-02f, 2.25216914e-02f, -6.30103424e-02f, -3.88097437e-03f, -3.69443814e-03f, 1.08764902e-01f,
  9.30591077e-02f, 4.58746441e-02f, -8.29571858e-02f, 5.46011236e-03f, -4.80296277e-02f, 6.17828108e-02f, -2.95520620e-03f, 5.47317415e-02f, 2.75338516e-02f, 3.85996625e-02f,
  -4.49757166e-02f, -6.81907078e-03f, 1.29603863e-01f, -2.47957911e-02f, -6.46571815e-03f, -3.92519981e-02f, 1.07070550e-01f, -7.94624612e-02f, 6.81445934e-03f, 2.11803485e-02f,
  5.21489158e-02f, -7.97554255e-02f, -1.98975012e-01f, -9.41121504e-02f, -4.55993153e-02f, -1.72307685e-01f, -9.33935791e-02f, -1.98679119e-02f, -1.06531613e-01f, -1.88056435e-02f,
  -9.42939594e-02f, 1.04059346e-01f, 2.28742845e-02f, 1.14215367e-01f, 9.50417668e-02f, 4.95964140e-02f, 7.37848282e-02f, 1.98630780e-01f, 8.10316131e-02f, 2.14367788e-02f,
  -1.67637076e-02f, -9.97609794e-02f, -1.09570451e-01f, -5.56191616e-02f, -1.16041571e-01f, -3.76913287e-02f, -1.89867780e-01f, -2.13653758e-01f, -1.33769035e-01f, 5.98584190e-02f,
  -1.34137765e-01f, -6.80152252e-02f, -1.75248906e-01f, -8.04537088e-02f, -7.60821567e-04f, -8.70280862e-02f, -7.69496113e-02f, -2.79804561e-02f, 4.17683693e-03f, -1.33554190e-01f,
  -1.56181619e-01f, 7.58451521e-02f, -3.48270242e-03f, 1.36812944e-02f, -6.31045699e-02f, 2.48781517e-02f, 4.59408462e-02f, 3.14034820e-02f, -1.16615891e-02f, 5.48894145e-02f,
  -5.06504998e-03f, -6.24047220e-02f, -7.81136826e-02f, -9.69446823e-03f, -5.19407205e-02f, 1.39522552e-02f, 2.11618422e-03f, 4.44460697e-02f, -5.34728020e-02f, 6.84379712e-02f,
  7.70017281e-02f, 4.05698419e-02f, 1.60686672e-02f, -2.96791792e-02f, 1.04392707e-01f, 6.98379520e-03f, 5.43098599e-02f, -1.27526699e-02f, -1.88928470e-02f, 6.75499141e-02f,
  1.51099637e-02f, 2.27488913e-02f, 7.41087720e-02f, -4.28296514e-02f, -1.95482862e-03f, 6.43742178e-03f, -8.47293250e-03f, -3.65119018e-02f, 2.94489227e-02f, 3.30099873e-02f,
  5.12685962e-02f, 8.91427323e-03f, -3.33918482e-02f, 9.58568826e-02f, -8.21791291e-02f, -1.35952299e-02f, -5.30704148e-02f, -6.21263012e-02f, -5.09985164e-02f, 2.91082431e-02f,
  -4.41969149e-02f, -1.42005645e-02f, 1.91986598e-02f, -6.51867986e-02f, 3.24361987e-04f, -4.00626697e-02f, -1.48856388e-02f, 8.66300706e-03f, 7.26908632e-03f, 8.11912213e-03f,
  1.40171558e-01f, -1.98482238e-02f, 4.79856227e-03f, -4.14546654e-02f, -5.93536496e-02f, -7.13951793e-03f, -1.66122690e-02f, -1.87604390e-02f, 2.50784848e-02f, -5.05296364e-02f,
  -9.91917588e-03f, -2.28721946e-02f, -4.34150454e-03f, 6.73202723e-02f, -1.47579787e-02f, 4.27407101e-02f, 5.54524474e-02f, 1.23013398e-02f, 7.14260116e-02f, 8.22954252e-02f,
  9.88920704e-02f, 9.81732011e-02f, -2.35243998e-02f, 4.82012928e-02f, 9.63971838e-02f, 2.71128281e-03f, 2.54839845e-02f, 8.27103332e-02f, -1.32915312e-02f, 5.93077764e-02f,
  -2.27135777e-01f, -3.54198292e-02f, -1.81451023e-01f, -2.68677925e-03f, -5.74564673e-02f, 3.36522260e-03f, -1.36250556e-01f, -8.98215268e-03f, 1.42297044e-01f, -1.34724975e-01f,
  3.23514082e-02f, 1.22606410e-02f, 6.68610409e-02f, 1.27398372e-01f, 6.22421689e-02f, -5.80475926e-02f, -7.33862221e-02f, -3.13498452e-02f, -2.63727102e-02f, 3.93071547e-02f,
  -5.82715832e-02f, -1.14621393e-01f, 6.58982694e-02f, 2.20116079e-01f, -9.09648165e-02f, 1.34380877e-01f, -8.86263996e-02f, -5.52183948e-02f, 7.36516044e-02f, -2.08262563e-01f,
  -2.21010804e-01f, -3.68056111e-02f, 9.40669850e-02f, 5.96993975e-02f, 3.73475179e-02f, 4.09633890e-02f, 3.29260225e-03f, -1.48058981e-02f, 2.86432840e-02f, 3.93799357e-02f,
  2.07665972e-02f, 4.85226698e-02f, 7.21845496e-03f, 7.15226755e-02f, -7.58146569e-02f, -5.95125146e-02f, 8.60670879e-02f, 2.73862705e-02f, 6.46288414e-03f, 8.54587406e-02f,
  8.15545470e-02f, 9.15285423e-02f, 3.23579460e-02f, 1.51773021e-01f, 6.76814243e-02f, -1.30568361e-02f, 5.23004271e-02f, 1.45157263e-01f, 1.27157658e-01f, 1.39646098e-01f,
  -1.45248100e-02f, 2.55999416e-02f, -3.70375291e-02f, 9.84765738e-02f, 6.07942231e-03f, 3.79799865e-02f, -7.99976364e-02f, 2.63271499e-02f, -1.82176232e-02f, -1.86857376e-02f,
  -4.37016040e-02f, -3.56809013e-02f, 1.68348737e-02f, -1.80178173e-02f, 2.25611404e-02f, -5.40561676e-02f, -9.73175913e-02f, 2.12541893e-02f, 7.60787204e-02f, -2.93136612e-02f,
  -1.03288941e-01f, 2.84325965e-02f, -5.19618904e-03f, -5.96235432e-02f, -3.04867662e-02f, 7.57275894e-02f, -6.79922774e-02f, -4.39660996e-02f, 2.93688085e-02f, -8.24945234e-03f,
  -2.59903669e-02f, -8.94761703e-04f, 3.97259742e-03f, 7.16949720e-03f, 8.18115845e-02f, 4.83923368e-02f, 2.47864593e-02f, -3.67828533e-02f, -4.52357568e-02f, -4.34681699e-02f,
  3.45558450e-02f, -9.72225443e-02f, 8.56568012e-03f, -6.69005811e-02f, -4.56942134e-02f, 8.20185915e-02f, -2.11073086e-02f, 2.27677971e-02f, 9.96492729e-02f, 8.08509998e-03f,
  -3.38701122e-02f, 9.67129320e-02f, 1.90832885e-03f, -3.91713269e-02f, 7.19427969e-03f, -4.34446186e-02f, -1.61717050e-02f, -5.05389236e-02f, 4.48137149e-02f, 1.89354271e-03f,
  2.61591643e-01f, 1.61410689e-01f, 1.18447289e-01f, 4.51257706e-01f, 3.34417731e-01f, -1.56685803e-03f, -4.20253724e-02f, -4.19460330e-03f, 3.17900814e-02f, 1.14965245e-01f,
  1.30472556e-01f, -1.32917976e-02f, -1.37199610e-02f, -7.54790008e-02f, -7.76643455e-02f, 1.07566025e-02f, -6.08027577e-02f, -9.56271738e-02f, -1.59263052e-02f, 1.36840895e-01f,
  1.96438357e-01f, 1.68958157e-01f, 7.73949996e-02f, 9.25829560e-02f, 3.02820474e-01f, -9.90149081e-02f, -5.83889559e-02f, 2.33200714e-01f, 5.80787882e-02f, 3.64537716e-01f,
  1.33906379e-01f, 3.12021375e-01f, -7.47196302e-02f, 3.25041749e-02f, 2.86742691e-02f, -1.14016183e-01f, -7.24155456e-02f, -2.89842095e-02f, -1.24250539e-01f, 6.45940900e-02f,
  3.49608548e-02f, -1.31293297e-01f, 6.60370365e-02f, -7.11587295e-02f, 7.64971972e-02f, 6.25819191e-02f, -1.09887511e-01f, -4.89295386e-02f, -7.88101554e-02f, 7.88877979e-02f,
  2.00075626e-01f, 1.00888625e-01f, 5.93583472e-02f, 2.29707006e-02f, -6.96187615e-02f, -1.16684251e-01f, 1.10536568e-01f, 7.42053688e-02f, -9.91916433e-02f, 2.06673350e-02f,
  -3.64240594e-02f, -4.65256236e-02f, 4.36526351e-03f, -4.89448495e-02f, 7.95047358e-03f, -1.63337286e-03f, 2.88459640e-02f, 2.20108274e-02f, 3.42605710e-02f, 3.17522213e-02f,
  -8.29068199e-02f, 4.69683297e-02f, 7.74823129e-02f, 1.17855277e-02f, -5.65251522e-02f, 6.83882982e-02f, -2.64421757e-02f, 2.33964920e-02f, 2.14983616e-03f, -9.14390758e-02f,
  1.34857595e-02f, -3.61005813e-02f, -9.28027439e-04f, -5.13810711e-03f, 7.84162357e-02f, 5.07444665e-02f, 5.17463200e-02f, 6.26818463e-02f, -3.63021903e-02f, -3.69588584e-02f,
  -1.29939824e-01f, -1.96420684e-01f, 3.38543355e-02f, -1.44833237e-01f, -4.47277632e-03f, -6.11621402e-02f, 1.15660504e-02f, -8.15222487e-02f, 2.23877956e-03f, -4.91504297e-02f,
  7.07174912e-02f, -3.33296321e-02f, -5.16857021e-02f, -5.40872775e-02f, -1.54254973e-04f, -4.67875488e-02f, -3.85755561e-02f, 4.08445671e-02f, -1.95611224e-01f, -7.17360824e-02f,
  -4.70967591e-02f, -1.60031900e-01f, -1.02383099e-01f, -1.69508636e-01f, 1.54945534e-02f, -1.17115825e-01f, -1.96641535e-01f, -1.51561126e-01f, -2.33390555e-01f, -2.46856362e-01f,
  -1.11549571e-01f, 7.81119615e-02f, 5.51147535e-02f, 5.82431182e-02f, 7.64933676e-02f, -5.61830737e-02f, -1.16204716e-01f, -3.76040814e-03f, 3.69340330e-02f, -9.44258273e-02f,
  8.38125572e-02f, -1.48889208e-02f, -1.06635332e-01f, -8.62479508e-02f, -1.21376380e-01f, -1.64291307e-01f, -8.71405378e-02f, -1.53730497e-01f, -8.02238807e-02f, -4.88748215e-02f,
  5.39380461e-02f, -7.75527395e-03f, 4.60535698e-02f, 7.24590197e-02f, 4.10004780e-02f, -9.41735208e-02f, -1.21400328e-02f, 2.24341694e-02f, -3.77356112e-02f, -6.23194538e-02f,
  -1.13496661e-01f, 5.62329255e-02f, 1.88579615e-02f, -3.25897448e-02f, 1.01673648e-01f, 1.78695414e-02f, 6.69261366e-02f, 8.16902593e-02f, -1.46327456e-02f, 5.48486486e-02f,
  6.04435727e-02f, 4.28682566e-02f, -5.42494133e-02f, -4.38721403e-02f, -5.53134084e-02f, -5.36556095e-02f, 4.29056399e-02f, 7.58218318e-02f, -4.57448848e-02f, 2.43012533e-02f,
  5.57644032e-02f, -3.67108881e-02f, 4.33903784e-02f, 1.09501623e-01f, 6.79990426e-02f, -3.33267860e-02f, 5.86397834e-02f, 3.30744535e-02f, 7.27466717e-02f, -5.25507443e-02f,
  6.12539463e-02f, -1.22066224e-02f, -2.78119948e-02f, -3.45346890e-03f, -5.02511971e-02f, 3.90677117e-02f, -2.52414346e-02f, -2.15426032e-02f, 7.50553384e-02f, -1.54894739e-02f,
  -2.15208028e-02f, -6.14462718e-02f, -4.81619872e-02f, -4.33637314e-02f, 6.16127672e-03f, 4.59997840e-02f, 3.25136958e-03f, 5.58476038e-02f, 8.46835151e-02f, 5.34920543e-02f,
  -2.65860464e-02f, -4.67262417e-02f, 6.83230460e-02f, 7.13126138e-02f, 9.28728748e-03f, 3.42134722e-02f, 5.88518828e-02f, -1.27975745e-02f, 9.35567264e-03f, -6.60463944e-02f,
  -7.79644549e-02f, 6.09917380e-02f, 2.64022965e-02f, 4.45586350e-03f, 7.01167285e-02f, 7.86555856e-02f, -4.17359956e-02f, 2.22380701e-02f, 2.46177204e-02f, -9.55448300e-03f,
  -3.44537310e-02f, 7.18818754e-02f, 1.60524510e-02f, 6.46578074e-02f, 2.19258703e-02f, -6.63584769e-02f, -4.83414494e-02f, -1.39465891e-02f, -2.95877121e-02f, 6.46507144e-02f,
  5.07380106e-02f, -1.98372044e-02f, 1.39625100e-02f, -5.44837154e-02f, -7.36509915e-03f, -1.05089590e-01f, -8.79138112e-02f, -7.22308531e-02f, -1.41846657e-01f, -9.11354944e-02f,
  -1.21461727e-01f, -1.63461361e-02f, -2.90032625e-02f, -3.10945716e-02f, -1.43774301e-02f, 6.98618293e-02f, -1.23527125e-01f, 8.92196521e-02f, -2.41905916e-02f, -1.30981222e-01f,
  -3.64978276e-02f, 1.43376425e-01f, -3.20393546e-03f, 1.38055012e-01f, 8.40683468e-03f, 4.12777774e-02f, 7.26559833e-02f, -1.41875651e-02f, 4.85599972e-02f, 1.21124804e-01f,
  9.06646401e-02f, -6.92000538e-02f, 6.13423921e-02f, 7.33471140e-02f, -9.67941582e-02f, -1.20364092e-01f, -1.95451751e-01f, -7.43720159e-02f, -4.00483496e-02f, -2.42397070e-01f,
  -1.38610721e-01f, 6.60785753e-03f, -6.88765645e-02f, 3.81218567e-02f, -4.79957536e-02f, 8.48529935e-02f, -6.49628881e-03f, 3.89705040e-02f, 1.87220750e-03f, 6.26139576e-03f,
  -1.54980915e-02f, 5.90500347e-02f, -3.65023427e-02f, -4.58955169e-02f, -3.70764127e-03f, -8.09759498e-02f, -4.98259850e-02f, 7.96494186e-02f, 1.24555854e-02f, 8.01656395e-02f,
  -2.23609041e-02f, 2.27652602e-02f, 6.75857067e-02f, 1.00390799e-01f, 2.28261575e-02f, 6.07303903e-02f, -7.67319426e-02f, -8.08196515e-02f, 5.66468239e-02f, -2.69682676e-01f,
  8.55628699e-02f, 9.52033885e-03f, -4.33509424e-02f, -5.41768745e-02f, -1.29721155e-02f, -6.79573566e-02f, 2.09368169e-02f, -7.14274794e-02f, -1.63665470e-02f, -6.20721243e-02f,
  -2.00117230e-02f, 5.88993868e-03f, 4.76239920e-02f, -3.33413132e-03f, -4.26607840e-02f, 3.16729350e-03f, 7.83505365e-02f, 5.17991073e-02f, -5.00238054e-02f, -6.06767833e-03f,
  1.25231436e-02f, -2.98409685e-02f, -4.07232307e-02f, 7.26172999e-02f, 5.07455319e-02f, 5.06532453e-02f, 8.25293064e-02f, -6.85406849e-02f, -6.47923872e-02f, -2.62328871e-02f,
  -6.98316842e-02f, 1.09234214e-01f, -1.01514600e-01f, -1.99563224e-02f, 1.77069176e-02f, 4.52830046e-02f, -9.86449420e-03f, 5.93045875e-02f, 6.60727173e-02f, 2.67057382e-02f,
  -2.65831798e-02f, 1.75554268e-02f, 2.09859037e-03f, -6.16469793e-02f, 1.30021404e-02f, 1.21041862e-02f, -2.62624715e-02f, -7.48825911e-03f, 2.75766477e-03f, 1.21627882e-01f,
  1.08520776e-01f, -1.15321219e-01f, -1.96164474e-03f, -1.25553161e-01f, -8.27857703e-02f, 3.90864313e-02f, -4.19156477e-02f, -1.35466531e-01f, -8.35561901e-02f, -1.25891820e-01f,
  -3.77878875e-01f, 4.60716449e-02f, 1.02345891e-01f, -9.90528837e-02f, 8.99925828e-03f, -5.26896827e-02f, -1.24556065e-01f, -2.06840187e-02f, -1.30408272e-01f, -3.86723951e-02f,
  8.63948464e-02f, 7.57475942e-02f, 1.31413087e-01f, 1.31688388e-02f, -9.26825851e-02f, -6.57149851e-02f, -6.41237497e-02f, 8.31925571e-02f, -3.82374898e-02f, -4.93618362e-02f,
  2.88543515e-02f, 8.29454064e-02f, 2.45573856e-02f, 5.07046580e-02f, 4.13380563e-03f, 1.24350656e-02f, 7.87076948e-04f, -2.17776466e-02f, 8.54213908e-02f, 5.01414724e-02f,
  4.93351519e-02f, -7.67862946e-02f, -6.94622397e-02f, -9.12229121e-02f, -3.22103128e-02f, -2.56112777e-02f, 3.13708596e-02f, 4.40474935e-02f, -8.08250979e-02f, -6.75925836e-02f,
  8.40940513e-03f, 1.58445872e-02f, -4.12755348e-02f, 3.95401977e-02f, 3.46587859e-02f, 7.12249242e-03f, -6.09509423e-02f, 9.27573908e-03f, -3.23886871e-02f, 9.00572259e-03f,
  4.02253531e-02f, -5.49210841e-03f, -1.70652624e-02f, -4.45299260e-02f, -6.13610670e-02f, -2.58241408e-03f, 1.23919975e-02f, -1.44847389e-02f, 1.63139962e-02f, -1.24786295e-01f,
  8.68446939e-03f, 7.74780288e-02f, -4.42124810e-03f, -3.11027151e-02f, -9.78646353e-02f, 5.42663857e-02f, -3.24140936e-02f, 3.81130464e-02f, -5.89078031e-02f, -5.84631115e-02f,
  2.12631635e-02f, -1.01615049e-01f, 3.92671525e-02f, -2.91039106e-02f, -1.05666714e-02f, 4.84774709e-02f, -1.45064788e-02f, -3.28913778e-02f, -4.96520698e-02f, -8.58889706e-03f,
  -7.12606460e-02f, -3.55403684e-02f, 9.36054159e-03f, 7.40791112e-02f, 5.63273728e-02f, -6.87589049e-02f, -1.26317561e-01f, 1.67092681e-02f, 7.95126259e-02f, -4.85879891e-02f,
  -7.13121369e-02f, 9.60350875e-03f, -1.24179237e-02f, 2.10223962e-02f, -1.15223927e-02f, 1.03247799e-01f, -5.40552894e-03f, -1.00194858e-02f, -2.62140390e-02f, -5.26280254e-02f,
  -3.13260369e-02f, -8.57883468e-02f, -2.82819569e-02f, 9.72931832e-02f, -5.37228584e-02f, -8.43864679e-02f, -4.92004901e-02f, -7.52796070e-04f, 6.23864345e-02f, 6.36663139e-02f,
  3.55905220e-02f, 2.27579363e-02f, -1.23529047e-01f, -8.99945199e-03f, -2.37929057e-02f, -1.42782122e-01f, -1.91902723e-02f, -6.91539645e-02f, -1.16945319e-01f, -1.87557802e-01f,
  3.97190116e-02f, -1.38714835e-01f, 6.95427433e-02f, 7.32507110e-02f, 6.66929558e-02f, 1.67494416e-02f, -4.26815301e-02f, -1.41937494e-01f, 1.87187586e-02f, 1.49172902e-01f,
  1.22010656e-01f, 2.00005602e-02f, 1.55962437e-01f, 1.52979031e-01f, 8.07281234e-04f, 1.27834797e-01f, 1.02201859e-02f, 1.39389038e-01f, -1.03416465e-01f, -9.15101320e-02f,
  -7.52477273e-02f, 5.94698414e-02f, 8.16063657e-02f, -2.60540359e-02f, 7.65203498e-03f, 2.11073294e-01f, 2.49364555e-01f, 1.06480204e-01f, 2.23706234e-02f, 2.56265521e-01f,
  3.18042397e-01f, -2.56320208e-01f, 9.60876271e-02f, 9.72165465e-02f, -3.39947455e-02f, 3.36158536e-02f, -2.16431115e-02f, 5.65075176e-03f, -1.47443861e-02f, -6.47274405e-02f,
  -4.60373797e-02f, -9.09584388e-03f, -4.56179827e-02f, -2.70264260e-02f, -4.32853587e-02f, -4.35648598e-02f, -1.22786596e-01f, -2.81589082e-03f, 8.37504267e-05f, 7.39669288e-03f,
  7.04872981e-02f, -4.97449301e-02f, -7.28645399e-02f, 5.54296300e-02f, -1.04856618e-01f, 3.10986433e-02f, -2.27937642e-02f, -1.32097155e-01f, 3.72748524e-02f, 9.42621902e-02f,
  1.17247052e-01f, -5.94732026e-03f, -1.89258568e-02f, 2.49734074e-02f, 3.98808233e-02f, 3.30215283e-02f, 4.68209200e-02f, 7.98431337e-02f, -3.60445455e-02f, 3.17787305e-02f,
  -9.32585523e-02f, 3.21545601e-02f, 5.98794110e-02f, 4.68680710e-02f, 1.81559920e-02f, -4.83238064e-02f, 3.98015417e-02f, 5.75191043e-02f, -6.08074665e-03f, 3.44886631e-02f,
  -3.12108658e-02f, -2.49734297e-02f, 3.19472328e-03f, 2.69908085e-02f, -7.22050853e-03f, 3.97477560e-02f, -2.10409728e-03f, -1.08883783e-01f, -7.09630623e-02f, -8.21842924e-02f,
  -1.07556600e-02f, -1.01243034e-02f, 8.17692727e-02f, -1.09354123e-01f, 3.14565711e-02f, -8.97114053e-02f, -1.41572086e-02f, -1.20921787e-02f, 5.40247466e-03f, 1.83150843e-02f,
  2.34334096e-02f, 4.64919098e-02f, -4.85347089e-04f, -1.56984515e-02f, 8.25135261e-02f, -2.06199326e-02f, -6.62023248e-03f, 5.41941859e-02f, -2.95727104e-02f, -1.03799671e-01f,
  3.08849253e-02f, 9.30713937e-02f, 1.05116293e-01f, 7.82626867e-02f, 1.30759664e-02f, 7.16132075e-02f, 7.99521506e-02f, 8.25525224e-02f, 1.15003567e-02f, 1.19182818e-01f,
  2.16471866e-01f, 1.05259098e-01f, -3.59035991e-02f, 3.00898049e-02f, -3.36502008e-02f, -1.78999677e-02f, -3.69378366e-02f, -8.72924849e-02f, 1.09296322e-01f, 1.63375542e-01f,
  9.98040941e-03f, -1.74026806e-02f, -7.62962475e-02f, -8.70397538e-02f, -2.90193241e-02f, -5.16284183e-02f, 1.42603785e-01f, -2.25692280e-02f, -9.50556621e-02f, -1.88574061e-01f,
  4.70933206e-02f, 5.84036559e-02f, 8.84400457e-02f, -1.84955820e-02f, 1.23593688e-01f, -8.42246190e-02f, 5.84188327e-02f, 6.12586327e-02f, 1.33692985e-02f, 1.00605384e-01f,
  -3.72845307e-02f, 6.11986406e-02f, -8.10370818e-02f, -2.51205824e-02f, 7.80370310e-02f, 1.05488651e-01f, -1.66798662e-02f, -5.81591278e-02f, -5.70870787e-02f, 4.85748574e-02f,
  6.63106069e-02f, 9.73562002e-02f, 3.37873399e-02f, -1.93900708e-02f, -1.06000891e-02f, -1.03973383e-02f, 3.48003507e-02f, -8.28413479e-03f, 1.78598391e-03f, -6.85557351e-02f,
  -1.06933057e-01f, 3.62167284e-02f, -1.97877605e-02f, -6.06935769e-02f, -1.85125023e-02f, -7.64634833e-02f, -2.97315363e-02f, -1.17876410e-01f, -2.39856225e-02f, 7.67660663e-02f,
  -4.09947373e-02f, 9.40439105e-03f, -8.83051157e-02f, 1.28250010e-02f, -1.44509934e-02f, 7.54229873e-02f, -5.97322620e-02f, -1.02945447e-01f, -2.88913921e-02f, 5.35174683e-02f,
  -1.27227619e-01f, -1.27610080e-02f, -7.05848113e-02f, -2.45774724e-02f, -1.70008652e-02f, -6.37055188e-02f, -9.24497284e-03f, 1.50229614e-02f, -6.76612854e-02f, -5.76547459e-02f,
  2.11404320e-02f, -9.61050298e-03f, 6.68670908e-02f, -8.11978281e-02f, -6.75911829e-02f, -1.27910236e-02f, -4.89509776e-02f, -6.25898968e-03f, 4.65977192e-02f, 2.16958299e-02f,
  5.60218841e-03f, -7.82849118e-02f, 1.55132236e-02f, 6.25913590e-02f, 8.72052237e-02f, 8.00779313e-02f, 2.90893577e-02f, -3.00065782e-02f, 6.97492734e-02f, -2.96311844e-02f,
  -5.31352349e-02f, -2.21496280e-02f, -2.17756927e-02f, 3.28754336e-02f, -8.61503109e-02f, 1.08028604e-02f, 1.07582957e-01f, -4.32983227e-02f, -2.82824263e-02f, -3.34819704e-02f,
  2.89576268e-03f, -4.00908431e-03f, -1.43338516e-01f, -2.37378646e-02f, -3.76763381e-03f, -3.47071663e-02f, -1.38254836e-02f, 1.08598582e-02f, -8.92738029e-02f, 1.07379965e-02f,
  4.06247437e-01f, 2.80171726e-02f, 7.51775950e-02f, 1.89243257e-02f, -1.36283347e-02f, -1.08364053e-01f, -5.40183298e-03f, -5.40398471e-02f, 2.62362305e-02f, 1.01970799e-01f,
  6.04835972e-02f, -2.43669838e-01f, -4.09075730e-02f, -1.46753594e-01f, -1.81524962e-01f, 9.68785360e-02f, 2.67642140e-02f, -1.51455194e-01f, -2.37159774e-01f, -6.48667216e-02f,
  -1.08136252e-01f, 6.69993237e-02f, 1.08026564e-01f, 5.84566332e-02f, 1.62438601e-01f, -1.27124041e-01f, 9.06242728e-02f, 3.94133776e-02f, -1.30870312e-01f, 9.96725038e-02f,
  1.73273738e-02f, 1.02713495e-01f, -1.65598840e-01f, -1.83055237e-01f, -4.13793325e-03f, -8.11120088e-04f, -6.17362708e-02f, 2.88779475e-02f, -8.34632963e-02f, 1.02000505e-01f,
  -9.53648388e-02f, -1.25542432e-01f, -8.27042311e-02f, -3.90176103e-02f, -1.05837090e-02f, -8.53306353e-02f, 6.81939125e-02f, 2.21392158e-02f, -6.06963821e-02f, 2.53874473e-02f,
  -1.45539850e-01f, -9.98323262e-02f, 6.24593794e-02f, -6.39169291e-02f, 5.40854670e-02f, -1.19519599e-01f, 6.37588799e-02f, 1.93800032e-02f, 1.01617101e-04f, 1.17792584e-01f,
  2.05668192e-02f, 1.51563222e-02f, -4.37579192e-02f, 3.75673324e-02f, -1.35455839e-03f, -4.75417897e-02f, -4.51573692e-02f, 1.63575402e-03f, 2.54914537e-02f, 2.92728078e-02f,
  -1.28330477e-02f, 9.98343807e-03f, -1.43434689e-03f, 5.11354171e-02f, 9.44079831e-04f, 9.41797066e-03f, -4.89846803e-02f, 6.25171959e-02f, 4.66157459e-02f, -1.63457878e-02f,
  -7.24546239e-02f, 1.13091812e-01f, 9.40820351e-02f, -4.52117696e-02f, -4.73101018e-03f, -3.29438299e-02f, -1.29959155e-02f, -1.92517415e-02f, -1.14215082e-02f, 2.23369300e-02f,
  3.18121538e-02f, -2.95512080e-01f, 9.79412645e-02f, -8.85112286e-02f, -7.40617365e-02f, 6.86584860e-02f, 6.24185987e-02f, 2.14586426e-02f, 6.84677884e-02f, 4.64334562e-02f,
  -1.12739459e-01f, 6.26057312e-02f, -8.03430229e-02f, -6.22285232e-02f, 1.14963874e-02f, 5.40692098e-02f, 3.66221294e-02f, -8.98951199e-03f, -2.27728914e-02f, 1.75563648e-01f,
  1.33466452e-01f, 1.60983694e-03f, -8.53779819e-03f, -9.66307893e-03f, -2.04183580e-03f, -8.05880055e-02f, 2.26928852e-02f, 1.49796344e-02f, -9.29826126e-02f, 9.91263092e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.60535597e-03f, 4.36740480e-02f, -1.17609665e-01f, 4.57805321e-02f, -5.72803244e-02f, 9.94843990e-02f, -2.62748934e-02f, 2.91412584e-02f, -9.25413966e-02f, -8.54383558e-02f,
  -1.13880227e-03f, 9.53238308e-02f, 6.26307130e-02f, 2.58558802e-03f, -5.21519966e-02f, -4.82951179e-02f, 4.07353267e-02f, -5.10344794e-03f, 7.40440115e-02f, 1.71251819e-02f,
  -7.06884712e-02f, -1.96020566e-02f, 3.07927057e-02f, -3.95092629e-02f, -1.06419465e-02f, -9.11439806e-02f, -1.42279931e-03f, -7.72763044e-02f, -3.25715616e-02f, -1.56365037e-01f,
  1.11183142e-02f, -8.85571539e-02f, -2.91055255e-02f, 4.62880582e-02f, -6.18639216e-02f, 2.91747097e-02f, -7.97279701e-02f, -1.20146787e-02f, -1.47510339e-02f, 2.27716137e-02f,
  3.22375111e-02f, -9.52833239e-03f, -9.81203988e-02f, 5.03893457e-02f, -3.61305214e-02f, 7.92932212e-02f, 2.94160377e-02f, -3.23168412e-02f, -4.81705554e-02f, 8.61847475e-02f,
  4.32134680e-02f, 8.84551629e-02f, 8.11957866e-02f, 1.20228633e-01f, 1.18236616e-01f, 1.19274586e-01f, 9.68211964e-02f, 3.47295329e-02f, 4.89887297e-02f, -2.45781709e-02f,
  7.15024844e-02f, 3.48801799e-02f, 3.65073085e-02f, -3.42137963e-02f, -2.50094640e-03f, 4.36107069e-02f, 7.73399994e-02f, -2.16681268e-02f, 2.80763377e-02f, -3.18115763e-02f,
  7.09864199e-02f, 2.98711210e-02f, -2.35457141e-02f, 3.79083976e-02f, -9.28922370e-03f, -7.06489906e-02f, 1.65254939e-02f, -4.01441120e-02f, -5.37632406e-03f, -9.15787369e-03f,
  4.64838333e-02f, -5.22410497e-02f, -2.97193229e-02f, -7.20418692e-02f, 3.73118222e-02f, -1.06060796e-03f, -7.29325637e-02f, -3.41057070e-02f, -1.09329531e-02f, -3.65446433e-02f,
  -7.95788169e-02f, 2.55697258e-02f, 6.63312152e-02f, 1.19037041e-02f, -8.35740492e-02f, 5.31463847e-02f, 3.34223211e-02f, -5.25339134e-03f, 3.97442915e-02f, 4.52272706e-02f,
  2.91250516e-02f, -9.42056719e-03f, -1.02188192e-01f, 9.74286869e-02f, 8.73949677e-02f, 8.95865783e-02f, -1.00704283e-02f, 4.03141156e-02f, -1.58979297e-02f, 3.65115069e-02f,
  6.00474104e-02f, 4.19540145e-03f, 5.66455834e-02f, 1.05875423e-02f, 3.20428647e-02f, -4.95022871e-02f, 5.76738007e-02f, 8.98608491e-02f, -8.22108164e-02f, 4.51912060e-02f,
  -2.33937390e-02f, -6.94416761e-02f, -4.91439290e-02f, -5.94416931e-02f, 1.00593537e-01f, 3.92206833e-02f, -8.22185446e-03f, 7.66051039e-02f, 8.66827890e-02f, -3.36722843e-02f,
  3.73971154e-04f, 5.36180893e-03f, 5.39356917e-02f, 1.95489097e-02f, 7.15574697e-02f, 5.15317591e-03f, -5.88549748e-02f, 9.08147544e-02f, 5.56203648e-02f, 3.49178091e-02f,
  6.57930896e-02f, 1.83424877e-03f, -1.38188139e-01f, 8.29541832e-02f, 4.11225557e-02f, 6.75694942e-02f, -1.41579986e-01f, 1.60746593e-02f, -8.83777253e-03f, -1.15221724e-01f,
  -1.30401149e-01f, -2.95357686e-02f, 1.25314325e-01f, 1.28919706e-02f, -1.18408330e-01f, 3.53845172e-02f, 4.24089804e-02f, -7.57607147e-02f, -1.86026134e-02f, 5.51673165e-03f,
  -7.32752904e-02f, 2.71225045e-03f, 5.91005236e-02f, 4.64016125e-02f, 4.73162800e-04f, -5.72976992e-02f, -5.59352664e-03f, 1.50372842e-02f, -2.78136376e-02f, -5.26889414e-02f,
  3.70440856e-02f, 3.54121737e-02f, -4.39794101e-02f, 3.46649848e-02f, 1.53634787e-01f, 9.87904742e-02f, -2.87079159e-02f, -1.40779205e-02f, -9.63026751e-03f, -1.13470994e-01f,
  -1.93036497e-02f, -4.89847735e-02f, -4.95453179e-02f, 1.18748032e-01f, 1.34734521e-02f, -3.36331315e-02f, -4.61228117e-02f, 1.83018930e-02f, 2.15632934e-02f, -7.56393671e-02f,
  -7.76613280e-02f, -1.74138304e-02f, 4.88456115e-02f, -3.16811539e-02f, 2.03189235e-02f, 4.77390587e-02f, -1.10455612e-02f, -4.10816930e-02f, 3.79533842e-02f, 8.19768105e-03f,
  -8.89374837e-02f, -6.55823126e-02f, 2.85519250e-02f, 3.31506096e-02f, -8.41395278e-03f, -6.60932437e-02f, 2.08737347e-02f, 7.94572476e-03f, -3.69956456e-02f, 2.51572728e-02f,
  -5.36711104e-02f, 1.38279982e-02f, 5.94074577e-02f, 7.67975524e-02f, 4.22985805e-03f, -5.67802228e-02f, -5.48675917e-02f, 3.89397237e-03f, -1.73892211e-02f, -3.75723988e-02f,
  -4.14869264e-02f, -4.23632339e-02f, 1.55060766e-02f, -7.49335289e-02f, -4.74583544e-02f, 9.87559035e-02f, -1.19039081e-02f, 1.22446842e-01f, 2.46899631e-02f, -5.83720207e-02f,
  -6.99281543e-02f, -3.17426311e-05f, 4.87861186e-02f, -4.22144658e-04f, -2.32123444e-03f, 1.10658117e-01f, 2.99205189e-03f, 6.17112778e-02f, 2.79759374e-02f, -3.67687680e-02f,
  -2.36096350e-03f, -2.22889945e-01f, -6.36492744e-02f, 5.13574332e-02f, 9.12826359e-02f, 1.15485415e-01f, -1.89898964e-02f, 8.48958269e-02f, 1.06853984e-01f, 4.74684909e-02f,
  4.89892773e-02f, 8.71486515e-02f, 1.89303663e-02f, -6.47192970e-02f, -3.94089110e-02f, -5.53810410e-02f, 3.67501080e-02f, 1.40517587e-02f, 1.60802215e-01f, 1.31579638e-01f,
  1.28658906e-01f, 9.86274630e-02f, 3.60481218e-02f, -4.93539963e-03f, -9.19283107e-02f, -1.84548050e-02f, -1.37575254e-01f, -4.93234582e-03f, -1.42708821e-02f, -2.78627276e-01f,
  -7.77504444e-02f, -2.94096395e-02f, 7.94059858e-02f, -6.96039423e-02f, -8.59915167e-02f, -3.24352793e-02f, -6.65347204e-02f, -1.39957249e-01f, -3.73188891e-02f, 1.95064712e-02f,
  -4.65142168e-02f, 1.79089177e-02f, 3.92129533e-02f, 8.44804049e-02f, 3.78067978e-02f, 1.94611829e-02f, 1.46844825e-02f, -2.46987790e-02f, -3.32397409e-02f, -2.75091752e-02f,
  -2.63240114e-02f, -2.76775695e-02f, -1.23001188e-01f, -1.51357263e-01f, -1.10734545e-01f, -9.18920338e-03f, -1.78625077e-01f, -1.59417719e-01f, -1.55180782e-01f, -1.72601685e-01f,
  -7.97206685e-02f, -3.59632634e-02f, -9.03573446e-03f, 3.03930305e-02f, -1.21770091e-02f, -4.48205620e-02f, 3.69157195e-02f, -1.53385801e-02f, 5.40330708e-02f, -1.13982139e-02f,
  4.58504260e-02f, 7.60225728e-02f, 3.31021920e-02f, -3.66737358e-02f, -2.16865912e-03f, 3.51916589e-02f, 5.65642864e-02f, -7.12706298e-02f, -3.04627027e-02f, 1.90963373e-02f,
  -8.38697553e-02f, -2.44016275e-02f, 2.26162709e-02f, 1.20900646e-02f, -8.02616030e-03f, -7.85753280e-02f, 4.12449315e-02f, 6.93389666e-05f, 7.23351538e-02f, -3.02705616e-02f,
  -7.81869516e-02f, 3.08246128e-02f, 3.72309200e-02f, 4.89761569e-02f, -3.93395722e-02f, 3.87939508e-03f, 2.70199263e-03f, -1.05132489e-02f, -1.22011360e-02f, 2.91689727e-02f,
  -2.08121389e-02f, -3.46999541e-02f, -9.01014656e-02f, -8.89077410e-02f, -8.87346361e-03f, -1.21805251e-01f, -3.49338241e-02f, -1.25753824e-02f, -8.20187181e-02f, -2.67294832e-02f,
  -6.32572994e-02f, -7.36487582e-02f, -2.20476791e-01f, -1.36030689e-01f, 6.32212264e-03f, 1.81140862e-02f, -1.78049520e-01f, -4.05189618e-02f, -1.29039273e-01f, -2.52896547e-01f,
  -5.27157299e-02f, 1.33030089e-02f, 7.80684873e-02f, -1.82803180e-02f, -5.74186221e-02f, -9.06395391e-02f, 7.59595037e-02f, -9.36462879e-02f, 2.84161065e-02f, 8.22550207e-02f,
  -2.28747893e-02f, 1.38825327e-01f, 8.33198652e-02f, 1.15279123e-01f, 1.27975821e-01f, -1.21059455e-02f, -5.57352453e-02f, -2.03759763e-02f, 1.02030627e-01f, -7.91328901e-04f,
  6.35756105e-02f, -9.82949287e-02f, -4.78647761e-02f, 2.67946348e-02f, 2.79789288e-02f, 1.12987183e-01f, 8.74226764e-02f, 2.24503968e-02f, 7.99551457e-02f, -5.36195701e-03f,
  2.13938445e-01f, -1.12146668e-01f, 9.68746245e-02f, -3.06414776e-02f, -5.04684411e-02f, 3.32429186e-02f, 5.98745886e-03f, -3.06046754e-02f, -1.23895548e-01f, 7.18847588e-02f,
  -6.31806776e-02f, 6.42760098e-02f, -2.69172117e-02f, -5.57375960e-02f, -9.79119167e-02f, -4.51425239e-02f, -1.49196237e-01f, -9.60589424e-02f, 3.59780751e-02f, 9.42753404e-02f,
  -7.05902502e-02f, 4.28561829e-02f, 1.15789110e-02f, -7.90329054e-02f, 2.38558706e-02f, 4.37305234e-02f, -3.62279639e-02f, 3.69268693e-02f, 7.89846703e-02f, -7.11461809e-03f,
  6.09939061e-02f, 7.22182402e-03f, -1.21511817e-02f, -9.67620965e-03f, -1.08489752e-01f, 1.82458423e-02f, -7.63735473e-02f, 5.62282838e-02f, -7.49220746e-03f, -7.80734718e-02f,
  2.37319376e-02f, -9.39490553e-03f, 4.24375348e-02f, -5.73373884e-02f, 4.38334309e-02f, -5.75097129e-02f, 3.25287133e-03f, -4.65732291e-02f, 5.50634600e-02f, 1.87078342e-02f,
  -2.81694308e-02f, -1.63814425e-02f, 3.13417576e-02f, -5.60477898e-02f, 3.31768580e-02f, -8.50618407e-02f, -5.28715812e-02f, 8.54565576e-03f, -5.66330478e-02f, 4.18635644e-02f,
  1.23238251e-01f, 7.53679276e-02f, 4.11435850e-02f, 9.44440067e-02f, 6.89790025e-02f, -2.45540161e-02f, 1.49214836e-02f, 3.47795673e-02f, -3.53020728e-02f, 8.49633962e-02f,
  2.11172625e-02f, 7.60669708e-02f, 5.56194372e-02f, -1.56495851e-02f, 6.85134754e-02f, -3.55085246e-02f, -8.54636654e-02f, 3.73188802e-03f, -1.57062151e-03f, 8.03368837e-02f,
  -8.12420473e-02f, -4.17590402e-02f, 1.33369312e-01f, 2.21500937e-02f, 1.10616393e-01f, 4.06780988e-02f, 3.14149521e-02f, 9.04072225e-02f, 1.29321560e-01f, -6.86559975e-02f,
  -9.26936567e-02f, 5.08445688e-03f, 1.51769165e-02f, -1.28872711e-02f, -5.42584509e-02f, -1.10955410e-01f, -6.71027675e-02f, -3.48887257e-02f, -5.27551994e-02f, 5.31362183e-02f,
  8.13726261e-02f, -3.93822044e-02f, 5.54550923e-02f, 1.21519412e-03f, -6.77625835e-02f, 7.31113255e-02f, 5.45355715e-02f, -5.27330674e-02f, 7.77016133e-02f, 7.75625408e-02f,
  -7.17751384e-02f, 9.54424590e-02f, 2.01821253e-02f, 5.56322150e-02f, 5.96829727e-02f, 1.09741297e-02f, 5.75411832e-03f, -2.03516055e-03f, 6.43779561e-02f, 1.24428198e-01f,
  1.12542897e-01f, -3.02431807e-02f, -2.68582869e-02f, 5.69551624e-02f, -1.03440650e-01f, -4.06628102e-02f, -2.57607363e-02f, 1.64202079e-02f, -2.17501651e-02f, 1.83257516e-02f,
  2.10278742e-02f, 2.35265978e-02f, 7.36210793e-02f, -2.01813108e-03f, 4.86361235e-02f, -3.86691689e-02f, 5.75314537e-02f, 3.90708596e-02f, 7.26337172e-03f, 5.27685396e-02f,
  -7.59785771e-02f, -8.96757469e-02f, -5.54549918e-02f, -3.92217711e-02f, -8.44241306e-03f, -8.58216807e-02f, 5.38810566e-02f, 8.99328440e-02f, -4.08378653e-02f, 3.07823587e-02f,
  1.99589226e-03f, -6.72437847e-02f, -1.32702629e-03f, -7.31023178e-02f, 6.23252429e-02f, -3.25960107e-02f, -7.18020722e-02f, -2.86149438e-02f, 8.23808089e-02f, 7.88466819e-03f,
  7.68728647e-03f, -7.94333592e-02f, 7.11300671e-02f, -9.50386226e-02f, 5.76381152e-03f, -5.30217551e-02f, 4.72844578e-02f, 2.72458699e-02f, 2.51372457e-02f, -3.21826711e-02f,
  -3.91215906e-02f, 6.09739050e-02f, -4.47728001e-02f, -6.27459958e-02f, -4.10513319e-02f, -5.23318984e-02f, 7.20859542e-02f, 4.88155223e-02f, 8.51016939e-02f, 4.60778773e-02f,
  7.79441148e-02f, -1.65302940e-02f, 3.97669850e-03f, -6.72502741e-02f, -9.93349254e-02f, 2.36874074e-02f, 1.58434547e-02f, -1.06604345e-01f, -2.63787359e-02f, 5.49571179e-02f,
  6.97631538e-02f, -5.26150204e-02f, 4.87319455e-02f, 3.47120427e-02f, -3.21814008e-02f, 5.22166491e-02f, -6.02874719e-02f, -3.90344411e-02f, -8.71147960e-03f, 1.71483345e-02f,
  1.12540396e-02f, 3.19027230e-02f, 2.23754765e-03f, 3.28201614e-02f, -7.55298808e-02f, 4.96117994e-02f, -6.17761947e-02f, 4.06274796e-02f, -1.14534326e-01f, 5.21568879e-02f,
  -1.27561942e-01f, -1.19721577e-01f, 2.10508797e-02f, 3.35295834e-02f, -5.16153537e-02f, 6.34557828e-02f, 3.42974216e-02f, 3.18860710e-02f, 4.49208394e-02f, 8.22320860e-03f,
  7.89553917e-04f, -1.04130302e-02f, 1.02348737e-02f, -8.09059069e-02f, -9.57308412e-02f, -4.69612563e-03f, 7.35790133e-02f, -4.53353412e-02f, 3.73728797e-02f, 5.02957627e-02f,
  -6.12622239e-02f, -4.50904295e-02f, -1.73514765e-02f, 2.84531377e-02f, 4.31377776e-02f, 9.56415236e-02f, 7.05573931e-02f, -5.07219285e-02f, 7.43192360e-02f, -9.76128429e-02f,
  4.60245088e-02f, -1.34619474e-01f, 1.24016190e-02f, -1.20273635e-01f, 4.25386131e-02f, -4.97954478e-03f, -7.17986897e-02f, 8.09652954e-02f, 2.37794477e-03f, 1.60904564e-02f,
  -5.61005138e-02f, 8.01258311e-02f, 7.15201944e-02f, -3.12846601e-02f, 2.82392092e-02f, 1.02094412e-01f, -1.98389590e-02f, -4.27893177e-02f, 7.55448341e-02f, -5.09580262e-02f,
  -6.16198964e-02f, -3.12344655e-02f, 7.75119057e-03f, -6.23373687e-02f, -7.53975436e-02f, 9.03003365e-02f, 1.01185241e-03f, 7.17955083e-02f, 1.31315542e-02f, 8.46985206e-02f,
  -3.58650163e-02f, -3.20907198e-02f, -1.08215772e-01f, 5.87914623e-02f, -3.04508721e-04f, 6.55983761e-03f, 2.90719718e-02f, -4.34634872e-02f, 6.03952184e-02f, 5.86771630e-02f,
  8.28676820e-02f, 3.15482467e-02f, 4.50158753e-02f, -8.30563158e-02f, 3.64966132e-02f, 1.47623019e-02f, 8.18776153e-03f, -2.19846070e-02f, 4.16361615e-02f, 3.09661552e-02f,
  3.59715857e-02f, 6.32188171e-02f, -6.18970357e-02f, 7.98532274e-03f, 2.42656376e-02f, -6.45121932e-02f, -1.09275334e-01f, 1.40123945e-02f, 2.16473062e-02f, -6.55432642e-02f,
  7.09479377e-02f, -3.85310091e-02f, -7.93316215e-02f, 9.19135101e-03f, 2.04738812e-03f, -8.43662918e-02f, 3.54660153e-02f, 5.11989696e-03f, 2.72508599e-02f, 8.03849548e-02f,
  3.01389210e-02f, 9.40231383e-02f, 7.54340440e-02f, -5.41420914e-02f, 9.48602930e-02f, 1.01233236e-01f, 3.48367058e-02f, -3.67023051e-02f, -6.14432357e-02f, 1.80129427e-02f,
  -7.25179315e-02f, 3.07696778e-02f, 2.37669162e-02f, 1.31743088e-01f, -7.50189368e-03f, 1.44189343e-01f, 7.25801066e-02f, 7.01819360e-02f, 6.03319332e-02f, 1.01658627e-01f,
  9.90679786e-02f, -5.12415208e-02f, -8.48579705e-02f, -1.15876332e-01f, 7.23262783e-03f, -7.41830468e-02f, -4.67302129e-02f, -6.77148718e-03f, -1.24499924e-01f, -9.53539088e-02f,
  2.31097434e-02f, 1.19640172e-01f, 1.19879641e-01f, 1.49887308e-01f, 8.97746831e-02f, -1.00145273e-01f, -4.38907184e-02f, -2.43675895e-02f, 1.58650950e-01f, 4.94306870e-02f,
  4.79776077e-02f, -8.26853886e-02f, -6.77230433e-02f, -1.06086191e-02f, 3.22087035e-02f, 2.77090706e-02f, -9.04413536e-02f, -1.76249128e-02f, 1.68661550e-02f, -6.66755140e-02f,
  -4.17346396e-02f, 1.26778055e-02f, 1.15700789e-01f, 8.87070745e-02f, -4.65181880e-02f, 8.22517872e-02f, 1.18319718e-02f, -8.06007907e-02f, -1.31184664e-02f, -6.49541151e-03f,
  8.05114433e-02f, -3.51182856e-02f, 6.99967295e-02f, -3.43731232e-02f, -1.05648451e-01f, -9.91111919e-02f, -1.32326916e-01f, 9.20280963e-02f, 1.25862798e-03f, -8.76750723e-02f,
  -7.60568231e-02f, 2.37700567e-02f, -3.56914997e-02f, 1.83777548e-02f, 1.15308575e-01f, 4.18359488e-02f, -1.32458219e-02f, -1.22822798e-03f, -1.53006017e-02f, -1.22927621e-01f,
  4.84692007e-02f, -6.93265051e-02f, 5.12481965e-02f, -7.24380836e-02f, -5.89634441e-02f, 3.84075865e-02f, 3.16213965e-02f, -4.97989580e-02f, 1.68277882e-02f, 1.19264657e-02f,
  -2.22178865e-02f, -6.78768232e-02f, -1.34380674e-02f, 1.82893034e-02f, -3.61418054e-02f, 8.15948565e-03f, -1.01261530e-02f, -4.49471362e-02f, 4.55851434e-03f, 3.87932104e-03f,
  2.17153952e-02f, 2.38671508e-02f, 2.61078036e-04f, 4.95269075e-02f, 4.10320982e-02f, -2.80093998e-02f, -2.89779641e-02f, 5.11129200e-02f, 3.11282501e-02f, 5.87992519e-02f,
  2.90812552e-02f, 1.20474368e-01f, 5.89121971e-03f, 3.67165804e-02f, -4.98337336e-02f, 3.59616466e-02f, 4.68358733e-02f, 1.68882273e-02f, 1.14525147e-01f, 7.28428736e-02f,
  -6.14958033e-02f, 1.04967184e-01f, -7.82475621e-02f, -8.68021846e-02f, -8.74056295e-02f, 8.47746991e-03f, 1.08908638e-02f, 9.91086364e-02f, -1.89651717e-02f, -4.26721759e-02f,
  -1.57134850e-02f, 1.51930172e-02f, 6.56588301e-02f, 6.89896792e-02f, 1.10228285e-01f, 9.43009853e-02f, 7.89097995e-02f, 5.48648871e-02f, 1.38329491e-01f, -7.26895630e-02f,
  -1.87175691e-01f, -8.34536180e-02f, 3.38276736e-02f, -7.89927766e-02f, -2.28673350e-02f, -1.38349067e-02f, -1.03056595e-01f, -8.04002061e-02f, 6.27683592e-04f, -1.34329926e-02f,
  -6.07911237e-02f, -1.53204650e-02f, 5.83620220e-02f, 4.10912782e-02f, -3.44805196e-02f, 5.32066226e-02f, -1.61845945e-02f, 4.85502407e-02f, 2.42167134e-02f, -4.28237244e-02f,
  -1.24796592e-02f, 1.27981126e-01f, -5.34829050e-02f, 9.66288894e-02f, 8.65378305e-02f, 7.84315988e-02f, 1.21562727e-01f, 5.72945410e-03f, -1.17523391e-02f, 4.38915975e-02f,
  1.80089772e-01f, -1.09496914e-01f, 3.02024614e-02f, 1.70632973e-02f, 4.82195318e-02f, -9.87404883e-02f, -6.07772581e-02f, 5.35951331e-02f, -6.29630238e-02f, -7.95483291e-02f,
  5.13728559e-02f, -1.05568394e-01f, 4.87163253e-02f, 8.38550739e-03f, -9.20988992e-02f, -2.06515435e-02f, -3.33765522e-02f, -8.32607523e-02f, 2.06326302e-02f, -5.68936467e-02f,
  -2.71477047e-02f, 5.53162023e-02f, 4.67540580e-04f, 3.76831926e-02f, -5.53883500e-02f, -3.87904719e-02f, -3.17104347e-03f, -1.18941185e-03f, 7.94025585e-02f, 1.27098903e-01f,
  2.17492972e-02f, -6.41535148e-02f, -4.12647799e-02f, -8.99777189e-03f, -7.46805072e-02f, 2.21040696e-02f, 1.08813472e-01f, -8.83678254e-03f, -3.56265418e-02f, -7.17856437e-02f,
  2.97992416e-02f, 8.91269594e-02f, 3.92904989e-02f, 1.58430673e-02f, -3.56864072e-02f, 3.51176113e-02f, 3.62783000e-02f, 7.41384830e-03f, -1.48300675e-03f, -1.18046775e-01f,
  -2.78664585e-02f, 5.08737303e-02f, 1.01136923e-01f, -2.23984942e-02f, -1.50645068e-02f, 9.59252268e-02f, -1.10106338e-02f, -7.34445825e-02f, 6.46730885e-02f, 4.14436385e-02f,
  2.43708920e-02f, 4.08083200e-02f, -4.49411124e-02f, -7.19509646e-02f, 7.29125440e-02f, -9.58174095e-02f, 4.61481996e-02f, -7.46054351e-02f, -6.28568530e-02f, -4.92035486e-02f,
  -1.39287319e-02f, -9.54671204e-02f, -5.73100001e-02f, -3.46139036e-02f, -1.04598366e-01f, 1.41823841e-02f, -1.37487920e-02f, -8.17597359e-02f, -6.54795766e-02f, 2.84781549e-02f,
  -7.98309892e-02f, 5.50373178e-03f, 3.88244577e-02f, -1.00971125e-01f, -5.89014776e-02f, 4.35590968e-02f, 5.34982979e-02f, 9.16344970e-02f, -2.54168343e-02f, 5.78733571e-02f,
  2.77833998e-01f, -1.72692075e-01f, 5.48589267e-02f, 9.12420228e-02f, 1.06090479e-01f, 1.03761189e-01f, 1.14305548e-01f, 6.70306161e-02f, 7.27530345e-02f, -8.96382257e-02f,
  -5.22792488e-02f, 8.62592980e-02f, -6.20599762e-02f, 4.12760954e-03f, -1.40103102e-02f, -5.89697920e-02f, 1.69925038e-02f, -5.28155826e-03f, 1.80627301e-01f, 1.33791029e-01f,
  1.00857895e-02f, -4.70963903e-02f, 3.96485478e-02f, -6.88276589e-02f, 4.53550834e-03f, -3.37256715e-02f, -7.48128071e-03f, -3.88670415e-02f, -3.47898304e-02f, -8.50266218e-02f,
  -1.12241127e-01f, -2.70198323e-02f, 1.96250856e-01f, 3.26938815e-02f, 3.04909013e-02f, 6.05147369e-02f, -7.52112269e-02f, 9.03439801e-03f, 4.25354317e-02f, -4.19300795e-02f,
  -4.35415022e-02f, -1.13234363e-01f, 6.45578280e-02f, -1.97351561e-03f, 3.13387252e-02f, 1.42935570e-02f, 1.97217278e-02f, -9.94579196e-02f, -4.16308381e-02f, -1.43110454e-01f,
  -9.81051028e-02f, 3.25500853e-02f, 6.57367408e-02f, -7.11786598e-02f, -6.37476593e-02f, 5.65851182e-02f, -7.29565695e-02f, -1.24693535e-01f, 8.59380290e-02f, 2.44489387e-02f,
  5.12772687e-02f, 1.54450424e-02f, -4.20542471e-02f, 8.84869546e-02f, -2.05123387e-02f, -2.03814600e-02f, 1.63404923e-02f, 5.93618937e-02f, 5.13227284e-02f, -2.18734052e-03f,
  -3.56024466e-02f, 3.39423530e-02f, -5.32848388e-02f, -6.54542297e-02f, -1.18133046e-01f, -9.34705511e-02f, -7.25662429e-03f, -5.47228009e-02f, 6.10045604e-02f, 7.17471689e-02f,
  -3.38192545e-02f, -7.21100569e-02f, -2.46487614e-02f, -5.02879471e-02f, -8.34636241e-02f, -1.10928513e-01f, 6.20922931e-02f, -8.66614431e-02f, 6.72374964e-02f, 7.47855082e-02f,
  1.24168610e-02f, -6.11848384e-02f, 9.46214125e-02f, 1.39798997e-02f, 2.17940416e-02f, -2.76107900e-02f, -4.88869250e-02f, 1.88437570e-02f, -4.89967242e-02f, -2.78698299e-02f,
  -1.01636566e-01f, 3.82551663e-02f, -1.08089395e-01f, -5.24616688e-02f, 1.48436338e-01f, 6.57914951e-02f, -4.47487533e-02f, 5.40390462e-02f, -8.79710168e-02f, -1.67019635e-01f,
  -8.07976574e-02f, 8.11008811e-02f, 1.23536237e-01f, 6.48131818e-02f, 1.05779096e-01f, 1.53717399e-01f, 5.79090193e-02f, 7.43769761e-03f, 1.39411435e-01f, 2.32332125e-02f,
  1.04290163e-02f, -4.02747951e-02f, -8.09262544e-02f, 6.21188842e-02f, -5.14231138e-02f, 3.01346183e-02f, -2.10306440e-02f, 1.21761218e-01f, -1.51831061e-02f, 2.11533699e-02f,
  6.26338553e-03f, -4.40057460e-03f, -4.49359864e-02f, 2.28837710e-02f, -8.80405530e-02f, -3.12300529e-02f, -1.12635136e-01f, -6.58739358e-02f, 7.50823542e-02f, 2.29439810e-02f,
  5.06589375e-02f, -7.30948821e-02f, -7.60269836e-02f, -2.00369209e-02f, -8.11372921e-02f, -5.04132248e-02f, 4.05105315e-02f, -5.02212951e-03f, -5.10250367e-02f, -1.16300613e-01f,
  7.77432844e-02f, -1.43655101e-02f, 4.15886343e-02f, 1.38786621e-02f, -2.38709003e-02f, 5.58668636e-02f, 5.51540554e-02f, -6.57661930e-02f, -6.04321398e-02f, 6.83499277e-02f,
  -6.59268200e-02f, -6.33686185e-02f, 6.98248595e-02f, 8.42384994e-03f, -1.97971854e-02f, 8.42564157e-04f, -2.17434727e-02f, -8.75921845e-02f, 3.59981470e-02f, 5.77669265e-03f,
  -7.31318966e-02f, -1.13648482e-01f, -6.15029968e-02f, 1.34120882e-02f, 6.77519850e-03f, -6.44653365e-02f, -4.54621948e-02f, 8.95953458e-03f, -2.55908035e-02f, -5.67785874e-02f,
  6.60761520e-02f, -4.19453271e-02f, -6.65532872e-02f, -8.07445571e-02f, 8.92120451e-02f, -1.10721374e-02f, -1.38029279e-02f, -6.85427338e-02f, -7.47050866e-02f, 3.45195271e-02f,
  -4.21459526e-02f, 8.89432505e-02f, 4.19580117e-02f, 4.10407670e-02f, -7.62776053e-03f, -2.69805826e-03f, 5.67235909e-02f, 4.40878496e-02f, -7.12062046e-02f, 7.21729919e-02f,
  4.94931228e-02f, 5.24268597e-02f, 8.09120312e-02f, -5.50465882e-02f, 3.35141718e-02f, -1.96167007e-02f, -6.20265380e-02f, -4.43951460e-03f, 2.34504193e-02f, -7.90852308e-02f,
  4.97591794e-02f, -1.29534125e-01f, 3.75706889e-02f, -4.03159484e-02f, 1.49240419e-02f, 8.22046325e-02f, 3.98345888e-02f, 2.40228185e-03f, -1.00181282e-01f, 2.84315627e-02f,
  -8.93293992e-02f, 1.12454899e-01f, 2.38273144e-02f, 1.15909369e-03f, 3.31292078e-02f, 3.85177620e-02f, 3.88832875e-02f, -1.05223455e-01f, -7.15617388e-02f, -3.49524617e-02f,
  -3.85208018e-02f, 3.88297252e-02f, -7.83520415e-02f, -4.65841778e-02f, -5.72248362e-02f, 6.54599071e-02f, -6.70395792e-02f, 6.26544878e-02f, -3.17765865e-03f, -7.98854157e-02f,
  2.73039192e-02f, 2.28549503e-02f, 1.66531026e-01f, 1.40331939e-01f, 1.25839800e-01f, 1.66398406e-01f, 1.64875165e-01f, 1.45907462e-01f, 1.05752960e-01f, 1.63323179e-01f,
  1.85240514e-03f, 7.49877840e-02f, 1.54536545e-01f, 6.12326637e-02f, 1.86780274e-01f, 9.31590125e-02f, 1.59188479e-01f, 2.66003399e-03f, -3.20861861e-02f, 8.06215331e-02f,
  1.10945843e-01f, -8.23695287e-02f, -4.24178113e-04f, 7.71511197e-02f, 1.77244231e-01f, 1.11543491e-01f, -4.59169690e-03f, 2.99744532e-02f, 8.69369060e-02f, 1.00081727e-01f,
  4.58407514e-02f, -6.15978241e-02f, -1.50909703e-02f, -4.52782214e-02f, 3.73624004e-02f, 5.89538068e-02f, 1.88853908e-02f, -7.83046708e-02f, 4.23983298e-02f, -5.23196459e-02f,
  -1.01742648e-01f, 2.50651781e-03f, 2.45329738e-02f, 6.10523112e-02f, -1.05926439e-01f, 1.90232098e-02f, -9.35278386e-02f, 6.08019065e-03f, 5.68845049e-02f, 2.76029129e-02f,
  6.66612685e-02f, -3.05938013e-02f, -8.10644682e-03f, -1.31586995e-02f, 9.38047171e-02f, 1.11488802e-02f, 6.14337716e-03f, -4.67618629e-02f, 5.66096902e-02f, -1.05020575e-01f,
  -2.92762443e-02f, 1.50513006e-02f, -1.22010196e-02f, -6.10569902e-02f, 5.75476587e-02f, 4.39911857e-02f, 8.34018737e-02f, -1.29544269e-02f, -3.48791257e-02f, -5.42274974e-02f,
  7.13352337e-02f, 7.07158595e-02f, 3.82213853e-02f, 5.98321930e-02f, 6.20053262e-02f, -6.32291511e-02f, 3.31021585e-02f, 1.77281108e-02f, -3.95562090e-02f, -5.72192855e-02f,
  -7.31508732e-02f, 3.01524103e-02f, 4.09558304e-02f, 2.46741083e-02f, 7.77586773e-02f, 7.27896169e-02f, -2.86379997e-02f, 4.82012480e-02f, -1.54664612e-03f, 4.78087254e-02f,
  5.08028083e-02f, 2.48537529e-02f, 7.21387714e-02f, 8.97240788e-02f, -8.39865208e-03f, -1.16967171e-01f, 5.03406413e-02f, -4.55781631e-02f, -2.38476526e-02f, 6.42331392e-02f,
  -7.57360905e-02f, -3.10218669e-02f, -2.27681734e-02f, -4.18114327e-02f, -3.08775455e-02f, -8.88608098e-02f, 3.28734219e-02f, 6.51118904e-02f, 4.47975509e-02f, -4.14419770e-02f,
  5.38635440e-02f, 4.89869565e-02f, -1.24776810e-01f, -3.92142273e-02f, 5.72273023e-02f, -6.64839670e-02f, -6.64126873e-02f, -1.94375459e-02f, -7.29126483e-02f, 3.06724999e-02f,
  -6.75817072e-01f, 1.27845451e-01f, -1.78937837e-02f, -1.42726243e-01f, 6.50217459e-02f, 1.73040301e-01f, 4.20003593e-01f, 1.48111865e-01f, -3.21318209e-02f, -3.46636921e-02f,
  6.50052738e-04f, -1.09184995e-01f, -9.44017395e-02f, 6.21864051e-02f, 1.01688117e-01f, 1.19202018e-01f, 2.38473460e-01f, 1.41732777e-02f, -5.35459258e-02f, 1.86196528e-02f,
  1.10541031e-01f, -1.86611444e-01f, -3.35517317e-01f, -1.93271448e-03f, -1.94951557e-02f, -2.17480771e-02f, -1.61140505e-02f, -1.60481725e-02f, 8.35019164e-03f, 1.76139176e-01f,
  -4.91563901e-02f, -1.14032082e-01f, -4.04151417e-02f, -8.87212381e-02f, -5.85910603e-02f, -4.48161513e-02f, -1.45704683e-03f, -1.17467903e-01f, -9.67527702e-02f, 1.68046262e-02f,
  6.44652057e-04f, -1.18841656e-01f, -1.77715707e-03f, 1.06394604e-01f, -2.38552783e-02f, -3.22576500e-02f, -3.55895987e-04f, -7.53872693e-02f, -1.77433640e-02f, 5.20939715e-02f,
  1.68758899e-01f, 9.89294890e-03f, -4.67973016e-02f, 1.50997089e-02f, -8.68012384e-03f, -1.38312593e-01f, -5.99660650e-02f, 7.77501017e-02f, 2.95196567e-02f, -1.25897780e-01f,
  -1.14216208e-02f, 2.60572211e-04f, -4.08331156e-02f, 2.47551128e-02f, 3.68952341e-02f, -6.74705878e-02f, 6.01498820e-02f, -2.53178887e-02f, 3.55045982e-02f, 1.63043216e-02f,
  -1.86741054e-02f, -2.95377057e-02f, 3.00945435e-02f, -4.66220602e-02f, 1.91244483e-02f, -2.21395940e-02f, 9.92514789e-02f, -9.66404565e-03f, 1.51863554e-03f, -1.53985023e-02f,
  -1.02125863e-02f, -4.90548275e-02f, 1.09235691e-02f, 3.70382406e-02f, -2.13912129e-02f, -5.82649298e-02f, -3.04316934e-02f, 8.53944756e-03f, -1.64864548e-02f, 4.40485887e-02f,
  -1.45028234e-01f, 3.05827912e-02f, -1.07589021e-01f, -9.78070199e-02f, -1.86019056e-02f, -1.03054196e-01f, -6.13160692e-02f, -6.95021376e-02f, -1.63121149e-02f, -6.80433959e-02f,
  5.59554137e-02f, 2.60121860e-02f, -3.90912928e-02f, 6.71941228e-03f, 1.74845606e-02f, -7.92836249e-02f, 5.17351329e-02f, 5.47999050e-03f, 1.95098594e-02f, -3.92226987e-02f,
  4.24207486e-02f, 6.65593194e-04f, -1.47868335e-01f, -2.86989082e-02f, 1.41973263e-02f, -1.31820560e-01f, -7.81110227e-02f, -9.56003144e-02f, -6.60766065e-02f, -1.26767054e-01f,
  -2.24519894e-01f, 7.83354267e-02f, -4.17716466e-02f, -8.06595385e-02f, -1.89668629e-02f, -3.99201587e-02f, 1.09799229e-01f, 2.59583443e-02f, 3.11933067e-02f, -1.10636409e-02f,
  2.66959332e-02f, -2.60919277e-02f, 9.41238105e-02f, 2.63444092e-02f, 1.74730252e-02f, 9.75551903e-02f, 1.48427591e-01f, 2.05124654e-02f, -2.88297497e-02f, 3.25057991e-02f,
  2.48755817e-03f, -2.13186555e-02f, -3.67071815e-02f, 6.11114912e-02f, -3.49006616e-02f, -8.75478163e-02f, -1.35121541e-02f, -2.42048744e-02f, 1.06487080e-01f, 8.41166899e-02f,
  -1.24313071e-01f, -3.46962512e-02f, -4.83001210e-02f, -2.84429286e-02f, -4.85296324e-02f, 2.95191593e-02f, -4.80088927e-02f, -2.10846588e-03f, 7.25205019e-02f, -3.07723153e-02f,
  4.49781530e-02f, -4.86186594e-02f, -2.02246271e-02f, 3.98565084e-02f, -1.77132264e-02f, -4.98774424e-02f, -7.71440491e-02f, 8.13014656e-02f, -7.32134879e-02f, 2.04099249e-02f,
  5.64900637e-02f, -1.07264265e-01f, -1.36581138e-01f, -4.15938273e-02f, 1.05512984e-01f, -1.11362375e-01f, 1.14880651e-02f, -6.75315410e-02f, -8.66825879e-02f, -4.06594016e-02f,
  8.11965540e-02f, -1.27910599e-02f, -6.69633895e-02f, -6.70613796e-02f, -8.06087330e-02f, -4.80244085e-02f, 7.09741488e-02f, 3.77797782e-02f, 2.83896998e-02f, -6.46514520e-02f,
  9.51815397e-02f, 1.23321660e-01f, -5.21544032e-02f, 1.68148857e-02f, 7.09819049e-03f, -7.15467930e-02f, 2.53807604e-02f, -1.03608165e-02f, 8.14933330e-02f, 5.15005440e-02f,
  -5.97432777e-02f, 6.63774833e-02f, -8.32009837e-02f, -5.45642944e-03f, -1.06561091e-02f, 5.22871353e-02f, 8.91981497e-02f, -1.71157848e-02f, -3.28266583e-02f, -6.63907006e-02f,
  -1.40467867e-01f, 4.61234562e-02f, -9.27836169e-04f, -1.00607120e-01f, -1.13585088e-02f, 7.44104683e-02f, 4.92887273e-02f, 5.04864678e-02f, 3.84403616e-02f, -3.95274721e-02f,
  -1.42620010e-02f, -1.92803610e-02f, -4.96175848e-02f, 4.36892025e-02f, -6.70434013e-02f, 1.15193531e-03f, -2.73858570e-03f, -7.00797960e-02f, -6.62063882e-02f, -8.55386630e-02f,
  5.79649210e-02f, -1.27322972e-01f, -2.38805655e-02f, 7.27717876e-02f, -9.10800770e-02f, -7.20198378e-02f, -1.04044266e-01f, -2.13224087e-02f, -5.25417738e-02f, -2.08460782e-02f,
  -4.20780517e-02f, 1.24616407e-01f, 7.14749992e-02f, -4.01696526e-02f, -6.28074110e-02f, -5.40679581e-02f, 4.12301980e-02f, 3.05031519e-02f, -4.13020737e-02f, -8.14064220e-02f,
  -1.29174471e-01f, -5.70052862e-03f, 8.91538616e-03f, 1.75589204e-01f, 1.10069230e-01f, -5.38961738e-02f, 2.42593866e-02f, 1.16553210e-01f, 1.09650120e-01f, -5.20367846e-02f,
  4.72011641e-02f, -1.86911151e-02f, 1.59238130e-01f, -4.34239618e-02f, 3.43935117e-02f, -9.53418911e-02f, 6.22812212e-02f, 1.37415916e-01f, 3.07052843e-02f, 1.09812029e-01f,
  1.30595202e-02f, -9.47770197e-03f, -4.42663440e-04f, 3.66990417e-02f, -6.87161312e-02f, 9.23664793e-02f, 6.68124184e-02f, 8.71548504e-02f, -6.65784925e-02f, 2.24200021e-02f,
  -1.06464922e-02f, -3.83566841e-02f, -2.61385925e-02f, -1.85663421e-02f, 7.64482170e-02f, -4.11361605e-02f, 6.05129227e-02f, 1.32188618e-01f, 5.17431498e-02f, -7.57459626e-02f,
  -5.98090589e-02f, 2.16681063e-02f, -7.42009133e-02f, -4.85403985e-02f, -7.00009521e-03f, -8.97711068e-02f, -1.15825497e-01f, -7.68300220e-02f, 1.67770702e-02f, 5.49526475e-02f,
  -1.84247419e-02f, -7.26944655e-02f, 3.67658609e-03f, 7.52038136e-02f, 9.33875442e-02f, -2.97959372e-02f, 7.83867901e-04f, -6.90367669e-02f, 7.34809116e-02f, -8.88859760e-03f,
  6.49134219e-02f, -2.88614482e-02f, -3.10473554e-02f, 4.15292121e-02f, 5.66338487e-02f, 1.10088751e-01f, -2.76615191e-02f, 6.77768737e-02f, -8.98293965e-03f, 2.08920110e-02f,
  -2.71140169e-02f, -2.41586939e-02f, -2.15763617e-02f, 1.27607495e-01f, -2.32186317e-02f, 2.33473144e-02f, -3.81432474e-02f, 1.50833771e-01f, -3.21267433e-02f, -1.32832564e-02f,
  -8.04254711e-02f, 6.81621805e-02f, -9.47203371e-05f, 7.16290623e-02f, -1.36892321e-02f, 1.54918758e-02f, 5.84626757e-02f, -6.96700951e-03f, 3.47419903e-02f, -3.06876060e-02f,
  8.39886442e-03f, -1.23721836e-02f, 6.52889609e-02f, -8.21726173e-02f, -1.06540158e-01f, -6.99134693e-02f, -4.77209277e-02f, -7.45285824e-02f, 6.37583360e-02f, -7.08851814e-02f,
  -1.13407791e-01f, -1.34812705e-02f, -1.09570451e-01f, -1.15728863e-01f, -4.82468754e-02f, -5.02883047e-02f, -3.61832418e-02f, 3.39556485e-02f, -9.00791883e-02f, -6.90897405e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -3.11902650e-02f, 8.73369053e-02f, 4.59350906e-02f, 8.76499265e-02f, 7.38959610e-02f, -3.75865810e-02f, 2.70248316e-02f, 1.11177556e-01f, 1.83324635e-01f, 5.76668531e-02f,
  1.47479335e-02f, -1.40238062e-01f, -3.51967923e-02f, 9.35194939e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.88354682e-02f, 1.78743545e-02f, -2.93362391e-05f, 1.50280481e-03f, -1.25702769e-01f, 7.75985345e-02f, -8.87362361e-02f, 1.52656734e-01f, -1.62522376e-01f, 2.95893326e-02f,
  4.90330858e-03f, 6.09960640e-03f, 4.17024782e-03f, -6.61209598e-02f, 1.84181668e-02f, -8.13767500e-03f, 3.53070982e-02f, 5.43334670e-02f, -1.35076174e-03f, -9.39421207e-02f,
  5.28031699e-02f, -9.66763422e-02f, -5.46342172e-02f, -5.36142029e-02f, -1.10077314e-01f, -8.59253034e-02f, -1.37829140e-01f, -1.04000725e-01f, 1.01395041e-01f, -1.44276898e-02f,
  4.76254635e-02f, -1.00062275e-02f, -7.27628241e-04f, -1.76087525e-02f, 1.58696193e-02f, -8.35055932e-02f, -4.55478691e-02f, 2.18891442e-01f, 9.11030620e-02f, 6.12326711e-02f,
  6.27605151e-03f, -6.67832717e-02f, -3.62787731e-02f, 4.89441119e-02f, -2.29221322e-02f, -6.89496174e-02f, -1.67614163e-03f, 1.70124128e-01f, 6.67096302e-02f, -9.14939791e-02f,
  1.56306446e-01f, -4.71635759e-02f, -1.15832753e-01f, 1.57674834e-01f, -1.87115707e-02f, -6.00578114e-02f, -1.02684401e-01f, 1.10067107e-01f, -5.73309101e-02f, -9.59401857e-03f,
  -1.56779930e-01f, -7.36790746e-02f, 9.07288268e-02f, -1.15431122e-01f, -1.26785100e-01f, -5.00680134e-02f, 1.66402776e-02f, 1.21274821e-01f, -7.80632496e-02f, 1.55199930e-01f,
  4.48912680e-02f, -1.08589545e-01f, 3.00153960e-02f, 8.80823955e-02f, 1.51541159e-01f, -5.53658567e-02f, 4.93376851e-02f, 1.22854792e-01f, -6.76234113e-03f, 2.01819539e-02f,
  -8.45193416e-02f, -1.50608048e-01f, 1.31058037e-01f, 1.22552151e-02f, -3.00388895e-02f, 6.23557791e-02f, -8.40638764e-03f, -2.43656598e-02f, 8.05799961e-02f, 2.92906933e-03f,
  1.50497854e-01f, 1.58324003e-01f, -1.39452174e-01f, 8.24184567e-02f, -9.97523367e-02f, -6.01442344e-02f, 8.64915326e-02f, 5.56025002e-03f, -1.45223841e-01f, 1.83836520e-01f,
  -1.02787860e-01f, -2.10357875e-01f, -5.01869284e-02f, 8.92190412e-02f, 3.50922421e-02f, 5.45362346e-02f, 1.30763263e-01f, 6.20057695e-02f, 1.34971231e-01f, 1.64319888e-01f,
  1.99043509e-02f, -1.78929836e-01f, -5.03143407e-02f, -9.92224645e-03f, 1.29665941e-01f, 3.83890793e-02f, 2.89425943e-02f, -7.97141418e-02f, -1.37781009e-01f, -8.79456848e-02f,
  -1.51148401e-02f, -3.07439286e-02f, 2.65756138e-02f, 5.42187765e-02f, 7.65960366e-02f, 2.22443923e-01f, 1.16124347e-01f, -3.99426036e-02f, 1.28681451e-01f, 1.17338099e-01f,
  4.21391726e-02f, 1.08133852e-01f, 3.66318785e-02f, 6.79374784e-02f, -9.04635787e-02f, 1.33595422e-01f, 1.50395811e-01f, -9.27075595e-02f, -7.32908696e-02f, -9.15189832e-02f,
  -1.04729496e-02f, -1.55522011e-03f, 9.63902324e-02f, -1.54387737e-02f, 3.56865972e-02f, -1.73691940e-02f, -8.20388123e-02f, -2.83072200e-02f, 1.45752981e-01f, 1.21896215e-01f,
  1.23820595e-01f, 1.20660268e-01f, -1.56918630e-01f, 1.04908831e-02f, -5.55487014e-02f, 1.55273259e-01f, 6.86073154e-02f, 5.97002879e-02f, -1.30350843e-01f, -1.54945642e-01f,
  2.30595186e-01f, -1.65462554e-01f, 4.27758284e-02f, -1.85187787e-01f, 2.32566461e-01f, 1.08871944e-01f, 2.95316391e-02f, -1.36710614e-01f, 1.18820049e-01f, 1.27643377e-01f,
  -1.23824641e-01f, -6.03974201e-02f, -7.82931373e-02f, -2.08788469e-01f, -1.13951437e-01f, 1.28459389e-04f, 4.60925512e-02f, 1.97818115e-01f, -1.59175470e-02f, -9.99647602e-02f,
  -1.73484072e-01f, 8.07096884e-02f, 1.38844803e-01f, -3.98390815e-02f, -3.51160876e-02f, -6.01025559e-02f, 1.08395822e-01f, -4.41417694e-02f, 1.39103740e-01f, -1.85711488e-01f,
  -2.69163027e-02f, -1.07842043e-01f, 1.93729494e-02f, -2.59913858e-02f, 9.40343812e-02f, 4.36741300e-02f, -8.79975185e-02f, -1.06845774e-01f, -8.51295069e-02f, -1.66852087e-01f,
  2.28302702e-02f, -1.27039535e-03f, 2.09883582e-02f, 6.35883445e-03f, 2.09824592e-01f, -1.24752738e-01f, 6.93897903e-02f, 9.54777673e-02f, -8.89569148e-02f, 5.66096045e-02f,
  -1.04266644e-01f, -8.29683244e-02f, 6.77032098e-02f, 7.97444880e-02f, 7.66502544e-02f, -1.05716735e-01f, -8.53620246e-02f, 9.05002058e-02f, -3.69160646e-03f, -1.17219068e-01f,
  -8.32469091e-02f, 1.80914685e-01f, -1.15728647e-01f, 1.65771961e-01f, -2.31679022e-01f, 1.30020991e-01f, 2.15251803e-01f, -3.56600732e-02f, 9.36798304e-02f, -4.74122074e-03f,
  -5.24833612e-02f, -1.80987105e-01f, 1.60101444e-01f, -9.41259190e-02f, -3.70871983e-02f, 1.67293057e-01f, 1.19668342e-01f, 2.43241936e-02f, 2.17024177e-01f, -1.60589725e-01f,
  7.45735243e-02f, -5.23825511e-02f, 1.68164019e-02f, -1.00746892e-01f, 2.88167745e-02f, -1.97093040e-01f, 4.50445414e-02f, -1.40071809e-01f, -6.56380057e-02f, 1.74302347e-02f,
  -2.55069137e-01f, -6.99948967e-02f, 2.15255450e-02f, 2.67513037e-01f, 8.42243880e-02f, 1.23433776e-01f, 5.05506508e-02f, -1.44709677e-01f, 5.30423597e-02f, 1.34776548e-01f,
  -1.26310974e-01f, -9.69590247e-02f, -1.33077085e-01f, 1.48895577e-01f, 2.58518290e-02f, 5.85661037e-03f, 1.13507308e-01f, -1.04540594e-01f, 1.21067740e-01f, -8.61762166e-02f,
  7.14598149e-02f, 1.00966573e-01f, -1.42245531e-01f, 2.45471261e-02f, 1.27737999e-01f, 6.26788735e-02f, 4.59812321e-02f, -4.94800881e-03f, -1.65269952e-02f, 1.06154773e-02f,
  -7.23072365e-02f, 1.20779380e-01f, -1.94058660e-02f, -1.75059274e-01f, 3.20108309e-02f, -7.24538267e-02f, 7.11484030e-02f, 2.21322596e-01f, -1.44785777e-01f, -1.36962337e-02f,
  -2.05959696e-02f, -2.03168571e-01f, -1.25273451e-01f, 2.53141224e-01f, 5.02423989e-03f, -1.12070754e-01f, 1.58608109e-01f, -6.32379055e-02f, 1.03690609e-01f, 3.45346034e-02f,
  1.92667052e-01f, 2.29963544e-03f, 1.90595523e-01f, 1.61774561e-01f, 2.95417570e-02f, -7.66258687e-02f, -1.15335897e-01f, -1.28827110e-01f, 1.96847003e-02f, 1.28429025e-01f,
  1.56785294e-01f, -9.05079395e-02f, 6.89298883e-02f, 2.00480551e-01f, -2.24990189e-01f, 4.31286134e-02f, -1.59834642e-02f, -1.83473527e-01f, -6.10333085e-02f, 1.35749996e-01f,
  -5.84382489e-02f, 1.41022354e-01f, -5.96417747e-02f, 1.06948130e-01f, 1.88908204e-02f, 7.59844333e-02f, 1.11827157e-01f, 1.04954600e-01f, 4.03673165e-02f, 6.22983687e-02f,
  1.39133871e-01f, 8.92663747e-02f, -2.84637194e-02f, 1.51314721e-01f, -1.04144178e-01f, -7.18007833e-02f, 1.52911648e-01f, -1.73188746e-01f, 1.58533230e-02f, -7.34406784e-02f,
  -1.21419959e-01f, -3.72900814e-02f, -7.29372352e-02f, 4.40240391e-02f, 9.62450579e-02f, -1.85142398e-01f, 5.80132902e-02f, -2.14182157e-02f, 6.66772798e-02f, -1.95322394e-01f,
  -6.24468923e-02f, -2.12168336e-01f, 1.41317889e-01f, 3.60934138e-02f, -1.92756519e-01f, 3.14422064e-02f, 2.93531328e-01f, -2.13395625e-01f, 2.75316387e-01f, 2.15283394e-01f,
  -9.47511792e-02f, 1.99455902e-01f, -5.11136912e-02f, -1.73224118e-02f, -1.05065748e-01f, 7.92270005e-02f, -8.42893496e-02f, -6.38566613e-02f, -1.23215709e-02f, 3.78120244e-02f,
  8.23052227e-02f, -6.49789795e-02f, 6.62825480e-02f, -2.08492219e-01f, 3.54595110e-02f, 7.15789348e-02f, -6.65432587e-02f, -4.04397920e-02f, 2.01084822e-01f, 1.07422717e-01f,
  9.05770734e-02f, -2.44382933e-01f, -1.46821395e-01f, -1.97336420e-01f, 5.12977783e-03f, 1.10666901e-01f, -6.55529276e-02f, 1.39487624e-01f, 4.03171107e-02f, -7.69343972e-02f,
  -1.54336348e-01f, 3.62947807e-02f, 6.01268373e-02f, -3.45814903e-03f, 1.02568612e-01f, -1.32890642e-02f, 7.70650879e-02f, -4.93554175e-02f, -2.26776488e-02f, 8.20729509e-02f,
  -2.17597298e-02f, 1.04744293e-01f, 1.52166903e-01f, 2.02240869e-02f, -5.70555665e-02f, -7.20495954e-02f, 1.53836617e-02f, -2.48620957e-02f, -6.97855353e-02f, 6.81892708e-02f,
  7.65567645e-02f, -8.57565273e-03f, 5.94280474e-03f, -1.04617201e-01f, -3.84557433e-02f, -2.92019211e-02f, 1.51220649e-01f, -5.67473769e-02f, -3.39104608e-02f, 5.88314645e-02f,
  1.75412029e-01f, 3.52833755e-02f, 1.02245631e-02f, -4.82048560e-03f, 2.11294405e-02f, 6.39954582e-02f, 3.32859624e-03f, -6.10151561e-03f, 7.56839067e-02f, 9.61004850e-03f,
  -3.14239934e-02f, 3.23522799e-02f, 2.04160839e-01f, 1.67900503e-01f, -1.55455880e-02f, 2.42392700e-02f, 1.17818497e-01f, -1.51894018e-02f, -5.19495793e-02f, 6.55472502e-02f,
  -1.38251305e-01f, -3.59180868e-02f, 1.51103079e-01f, 6.72024414e-02f, -1.14639938e-01f, -2.70748645e-01f, -5.92306517e-02f, -1.89121552e-02f, 1.16167940e-01f, -1.25978813e-01f,
  1.69610128e-01f, -1.27321467e-01f, 8.39784667e-02f, -4.74327877e-02f, -5.13598695e-02f, -8.26637447e-02f, -1.98734730e-01f, 1.41195819e-01f, -1.91508755e-02f, 6.93496391e-02f,
  1.19649835e-01f, 4.81518954e-02f, -9.39279888e-03f, -1.74918454e-02f, -9.61432606e-02f, -4.16222773e-02f, -1.17275737e-01f, 1.26171559e-02f, 1.07748076e-01f, -3.78767662e-02f,
  -1.12890571e-01f, -8.21129084e-02f, 1.29246488e-01f, -8.68145749e-02f, 6.27566054e-02f, -1.35687500e-01f, -4.46356684e-02f, 1.79242081e-04f, 6.35071248e-02f, -3.37051973e-02f,
  -2.48371199e-01f, 5.49683757e-02f, 4.24388126e-02f, 1.87149774e-02f, -2.08458483e-01f, 2.21268818e-01f, 1.11876667e-01f, -5.04440069e-02f, -2.38669924e-02f, -4.73722108e-02f,
  1.06220677e-01f, 1.55528799e-01f, 2.21097395e-02f, 1.46923196e-02f, 1.81407556e-01f, 8.30941871e-02f, -7.77677819e-02f, -2.32394472e-01f, -5.81792593e-02f, -5.53135797e-02f,
  7.45203272e-02f, 1.46796972e-01f, -6.49537668e-02f, 6.74850568e-02f, 1.89109892e-02f, 1.25349879e-01f, -1.27055556e-01f, -1.14149764e-01f, 1.67213038e-01f, 1.40877068e-01f,
  4.19861302e-02f, 2.07284000e-02f, 7.23145083e-02f, -1.28597692e-01f, 3.99694033e-02f, -9.61667523e-02f, -7.97418877e-02f, -6.09534793e-02f, -1.58536732e-01f, -6.56643650e-03f,
  1.13149256e-01f, 9.16345511e-04f, -5.68912178e-02f, -5.34842722e-03f, 1.30055949e-01f, -5.91268837e-02f, 1.35505304e-01f, -6.89656511e-02f, -9.49761271e-02f, 5.21711707e-02f,
  7.64400279e-03f, 1.14640631e-01f, -1.02711774e-01f, 2.06735786e-02f, -1.88072026e-02f, -1.11072868e-01f, -8.04380029e-02f, 5.30777872e-02f, -5.57464585e-02f, 7.97765255e-02f,
  -5.22510447e-02f, 1.01653315e-01f, -1.48370653e-01f, 9.17309821e-02f, -5.66844195e-02f, -3.21053788e-02f, 6.17453419e-02f, -1.31578952e-01f, 2.19719969e-02f, 2.04708092e-02f,
  -1.54323623e-01f, 6.80253655e-02f, 4.69283480e-03f, -5.22183366e-02f, -1.31519854e-01f, -6.02659285e-02f, 5.64830676e-02f, -1.20338619e-01f, 7.66167492e-02f, 3.24332267e-02f,
  4.84256037e-02f, 1.05740234e-01f, 9.25840884e-02f, -5.16685471e-02f, 8.64415094e-02f, -4.85671833e-02f, 6.81261495e-02f, 1.17212132e-01f, 5.88716567e-02f, 1.33393541e-01f,
  -1.05422482e-01f, 7.16090351e-02f, -1.00868426e-01f, 6.82160482e-02f, 7.38596320e-02f, 8.07961524e-02f, -6.06618188e-02f, 9.87461507e-02f, 1.14948004e-01f, 1.14396706e-01f,
  -7.20890164e-02f, 6.94422051e-02f, -9.55060571e-02f, 2.67066926e-01f, -1.29866138e-01f, -1.38124451e-01f, 5.78954816e-02f, -8.67645666e-02f, 1.10373400e-01f, 9.54014137e-02f,
  -6.65552616e-02f, -5.62990159e-02f, -3.38150300e-02f, 5.03308214e-02f, 1.78415254e-01f, -6.01575710e-02f, 9.17548372e-04f, -1.06971011e-01f, -1.05849005e-01f, 1.05118237e-01f,
  7.80692473e-02f, -1.33583918e-01f, 5.34572266e-02f, 2.21104752e-02f, 1.88262127e-02f, 1.61877349e-02f, 9.32354182e-02f, 3.19852084e-02f, 3.47423740e-02f, -1.80889741e-01f,
  -1.53856218e-01f, 1.34790987e-02f, 1.05830468e-01f, 2.39715502e-01f, 9.56249237e-02f, -1.45405922e-02f, 2.02499494e-01f, 5.73448949e-02f, 4.76508886e-02f, -8.06454662e-03f,
  8.99454765e-03f, 2.44731363e-02f, 2.04665005e-01f, 2.18343988e-01f, 1.26115099e-01f, 1.39121655e-02f, 7.60024041e-02f, -5.35545461e-02f, 2.43105456e-01f, 1.76914092e-02f,
  -3.20076197e-02f, 8.78363252e-02f, -8.52711648e-02f, 1.83231384e-01f, 6.53948169e-03f, -1.30632231e-02f, -1.23877339e-01f, -2.15136245e-01f, -1.52744487e-01f, -1.81729309e-02f,
  8.43560547e-02f, 5.15134865e-03f, 1.09885789e-01f, 3.08701172e-02f, -3.42336893e-02f, 1.55955944e-02f, 2.41218895e-01f, -1.50770769e-01f, -4.50124964e-02f, -9.04781818e-02f,
  3.80759351e-02f, 3.83755788e-02f, 2.88474350e-03f, 1.14597217e-03f, -6.50307983e-02f, 1.86794147e-01f, 2.13956863e-01f, 2.00766429e-01f, -1.54664233e-01f, 1.31258760e-02f,
  1.66351259e-01f, 1.73772976e-01f, 1.96792409e-01f, 2.19406802e-02f, 8.95469636e-02f, -1.21309392e-01f, -8.73203203e-02f, 1.75810441e-01f, -1.05403721e-01f, 1.02935741e-02f,
  -3.32239941e-02f, -2.15501413e-01f, 2.44881317e-01f, -1.03414757e-02f, -1.86751813e-01f, -9.85653326e-02f, 2.22217321e-01f, -5.30456901e-02f, -9.99809057e-02f, 5.24182208e-02f,
  -2.24270150e-01f, -1.21903710e-01f, -1.68881029e-01f, 1.57027751e-01f, -1.37111455e-01f, -1.38208359e-01f, -2.22625121e-01f, 1.91712694e-03f, 5.10754809e-02f, -4.99474108e-02f,
  -5.64981252e-02f, 1.58384591e-01f, -1.03598848e-01f, 6.65743789e-03f, -2.56095883e-02f, 3.94636393e-02f, 1.06306694e-01f, -8.68148431e-02f, 2.45127693e-01f, -9.09267589e-02f,
  1.07717901e-01f, 1.49043977e-01f, 1.18266396e-01f, 3.82082388e-02f, 8.41523930e-02f, 1.19243838e-01f, -8.89209360e-02f, 5.27032055e-02f, 2.74714492e-02f, 1.27710685e-01f,
  9.90679581e-03f, 1.42143101e-01f, -1.51326925e-01f, -5.47011867e-02f, 9.75163952e-02f, 1.02056183e-01f, -1.43272812e-02f, 1.42337918e-01f, -8.24866723e-03f, 6.55481145e-02f,
  5.73103735e-03f, 2.46657114e-02f, 1.32071421e-01f, -8.86888709e-03f, -1.10718012e-01f, 9.99119952e-02f, -5.47364913e-02f, 1.32535979e-01f, 1.41541660e-01f, -1.95827574e-01f,
  1.51584208e-01f, -1.32523626e-01f, -8.96536261e-02f, 7.97270909e-02f, -1.10467322e-01f, 5.06537594e-02f, -6.41468316e-02f, -1.42439142e-01f, -2.06989616e-01f, 1.05535209e-01f,
  -5.82518429e-02f, 2.10716218e-01f, 9.40372124e-02f, 1.07951052e-01f, -3.89232337e-02f, 1.25682503e-01f, 8.38025287e-02f, -6.93762824e-02f, -9.93952826e-02f, 5.45814037e-02f,
  -5.64089194e-02f, -1.40252635e-02f, -3.04829981e-02f, 4.75344174e-02f, 5.93238324e-02f, -4.91859689e-02f, -5.91161137e-04f, -3.76618803e-02f, -4.20542806e-02f, -8.12605321e-02f,
  7.77788907e-02f, 2.87165847e-02f, -1.19727023e-01f, -1.20481374e-02f, -3.25564258e-02f, -1.79731533e-01f, -8.79531130e-02f, -4.93414812e-02f, 7.76842162e-02f, -4.29517925e-02f,
  -8.13300535e-02f, -1.53147742e-01f, 6.10161908e-02f, 3.93153019e-02f, -6.51365519e-02f, -1.24978498e-01f, -6.25571907e-02f, -8.69779438e-02f, -3.30553092e-02f, -4.36560363e-02f,
  -1.15386017e-01f, -7.72453770e-02f, 6.24390095e-02f, 5.64641804e-02f, 8.88535082e-02f, 6.07711859e-02f, -1.67585924e-01f, 6.08396120e-02f, 1.30707815e-01f, -1.24811724e-01f,
  6.57904297e-02f, 5.28830104e-02f, 1.13849919e-02f, -6.72410801e-02f, -6.28265040e-03f, -1.54720411e-01f, 6.03802092e-02f, -4.80540358e-02f, 1.36241272e-01f, 2.68514268e-02f,
  -1.34047702e-01f, -6.35272078e-03f, 8.71726945e-02f, -7.54043236e-02f, -4.05927971e-02f, 6.52647316e-02f, 3.17076705e-02f, 1.32886199e-02f, -2.28267655e-01f, -3.71917710e-02f,
  -5.41262627e-02f, -8.37154761e-02f, -1.71044588e-01f, 8.50218907e-02f, 5.50159365e-02f, -1.58599019e-02f, -7.64093325e-02f, -2.27196559e-01f, 9.34023261e-02f, 1.49118081e-01f,
  -9.65762660e-02f, 6.99539408e-02f, -1.03982016e-01f, 8.68365765e-02f, 1.95939600e-01f, -6.44427240e-02f, 1.25825346e-01f, -2.93823034e-02f, -7.79526401e-03f, 2.04291180e-01f,
  4.48158156e-04f, -1.13258898e-01f, 1.92813464e-02f, 7.02110007e-02f, 1.10878341e-01f, 7.25672394e-02f, 5.43734012e-03f, 1.68080389e-01f, 1.42795697e-01f, -1.00452729e-01f,
  -8.16279724e-02f, -4.49436642e-02f, 1.56956315e-01f, -7.67966872e-03f, 6.07539639e-02f, -1.08198501e-01f, -9.96038020e-02f, -1.27670243e-02f, -6.66127354e-02f, 2.28366461e-02f,
  -8.46782774e-02f, 1.17040381e-01f, -3.12129203e-02f, 1.49748623e-02f, -6.93845302e-02f, -5.22503778e-02f, 1.51976869e-01f, -1.41065419e-01f, -1.25016207e-02f, -1.33541629e-01f,
  -1.39495060e-01f, -8.72660056e-02f, 9.35001895e-02f, -2.28111260e-02f, 1.67827774e-02f, -4.23049852e-02f, -8.07124749e-02f, 6.10152073e-02f, -1.23158693e-01f, -5.59671260e-02f,
  1.32374585e-01f, 1.87146571e-02f, 2.55526043e-02f, -9.59005877e-02f, 1.38512015e-01f, -6.71477392e-02f, 6.33272827e-02f, -2.49147341e-02f, 1.43051684e-01f, -1.35665312e-01f,
  -4.75290939e-02f, -1.44428387e-01f, 1.28273100e-01f, 4.04843129e-02f, 1.12197220e-01f, -2.87572164e-02f, 3.03330389e-03f, -6.40233681e-02f, 1.05966076e-01f, 1.22465417e-01f,
  6.18744344e-02f, -8.59372597e-03f, 7.69834593e-02f, 9.75421369e-02f, -6.30872026e-02f, -7.89803267e-02f, 1.62511855e-01f, -1.00773685e-01f, -5.13963215e-02f, -1.49796143e-01f,
  -6.45581558e-02f, 6.70802370e-02f, 1.39076576e-01f, -3.96643281e-02f, 1.97548017e-01f, 1.10141292e-01f, -2.25500632e-02f, 9.33001116e-02f, -3.67826186e-02f, -5.54375015e-02f,
  1.50288194e-01f, 1.25773907e-01f, 8.55819730e-04f, -4.21301760e-02f, -1.64336681e-01f, 3.04442067e-02f, -5.65173849e-02f, -2.66955905e-02f, 1.76779047e-01f, -7.66081065e-02f,
  1.02981133e-02f, 1.62017420e-01f, -1.41264852e-02f, 6.80467114e-02f, -6.34018257e-02f, 1.93879858e-01f, -1.43108785e-01f, 5.70717528e-02f, 1.62593846e-03f, -8.15204903e-02f,
  1.71235099e-01f, -1.33212611e-01f, 1.29692525e-01f, -1.67674214e-01f, -1.15682706e-01f, -1.74938530e-01f, 1.13693878e-01f, 1.38928056e-01f, 6.59002215e-02f, 3.85060310e-02f,
  -4.48108651e-03f, -7.84118176e-02f, -1.33704469e-01f, -1.44101098e-01f, 9.32197794e-02f, -2.99627446e-02f, 2.11067405e-02f, -4.79097739e-02f, 1.29633509e-02f, -1.31152257e-01f,
  -9.64735076e-02f, -6.45604581e-02f, 1.19796535e-02f, 1.83549095e-02f, -1.92005768e-01f, -1.41133949e-01f, -5.32397591e-02f, 1.54711947e-01f, 1.53222755e-01f, 1.57074317e-01f,
  9.03404355e-02f, 6.48571923e-02f, 1.11720175e-01f, -2.44934484e-03f, 1.91738177e-02f, -1.34535342e-01f, 4.08807844e-02f, -6.62815990e-03f, 3.98029573e-03f, 9.52267200e-02f,
  -1.30754709e-01f, 4.66737710e-02f, -1.07651830e-01f, -1.24495715e-01f, 7.00906366e-02f, 1.53291568e-01f, 9.48304832e-02f, 4.45409603e-02f, -9.55587700e-02f, 8.71585906e-02f,
  1.61650419e-01f, -2.52722930e-02f, 7.99753368e-02f, 4.70912829e-02f, -1.56228403e-02f, 5.61355539e-02f, 4.07129861e-02f, -3.97657491e-02f, 3.62434834e-02f, 3.22420150e-02f,
  1.32996617e-02f, -1.01346567e-01f, -6.33276403e-02f, -5.43401949e-03f, 1.27491638e-01f, -1.62967578e-01f, -2.75472589e-02f, 1.71926260e-01f, -1.51424393e-01f, 2.95666233e-03f,
  7.10095614e-02f, -2.90035028e-02f, -1.43765166e-01f, 2.02298742e-02f, 2.51611210e-02f, 6.20565750e-02f, 8.63918141e-02f, 1.43219382e-02f, 4.52679321e-02f, -5.35343178e-02f,
  -6.39532208e-02f, -7.98361599e-02f, -8.30643624e-03f, -1.25671010e-02f, -9.92217362e-02f, -5.47719933e-02f, 7.77140111e-02f, -3.70338745e-02f, 1.84178241e-02f, -2.49657203e-02f,
  -3.80431907e-03f, 8.13512579e-02f, -3.30215995e-03f, 1.55964419e-01f, -7.63432756e-02f, 1.52547702e-01f, -1.13364652e-01f, -1.53265148e-01f, 6.24149665e-02f, -1.68046534e-01f,
  -8.92068073e-02f, 4.66687270e-02f, 1.07886987e-02f, 1.14240728e-01f, -5.27842790e-02f, -1.35220215e-01f, 1.26036450e-01f, 5.56960590e-02f, 1.14074901e-01f, -1.20324060e-01f,
  9.36248153e-02f, 1.61453158e-01f, -9.22071864e-04f, 2.26633642e-02f, 1.34759650e-01f, 1.07899353e-01f, 1.64017856e-01f, -4.97120358e-02f, -2.06123278e-01f, 1.41472727e-01f,
  -8.26707929e-02f, 5.36669120e-02f, -6.59931824e-02f, 2.36253902e-01f, -1.65100023e-01f, 8.84389654e-02f, 1.67740107e-01f, -6.85990825e-02f, 1.00715458e-02f, 2.41513718e-02f,
  8.03555921e-02f, -1.19288675e-01f, 1.36992084e-02f, -2.05350876e-01f, 2.40692735e-01f, 1.25597760e-01f, -1.71838701e-01f, -5.72139211e-02f, 1.27647728e-01f, -7.81863481e-02f,
  -1.20702712e-02f, -1.59052387e-01f, 2.55778134e-01f, 2.49051988e-01f, -6.35736436e-02f, -8.76563266e-02f, -2.33180344e-01f, -1.93294734e-01f, 4.70568873e-02f, -1.13323621e-01f,
  -2.33441517e-01f, -1.61744744e-01f, -1.41706213e-01f, -1.39829010e-01f, -8.26128945e-02f, 1.97327808e-02f, 6.43749163e-02f, 1.06203914e-01f, -1.31455123e-01f, -3.94469276e-02f,
  1.06121615e-01f, 1.00272767e-01f, 3.25029045e-02f, -1.94684528e-02f, -2.09621906e-01f, 1.26865000e-01f, -1.33342579e-01f, 5.02243154e-02f, 2.10343990e-02f, -1.58333838e-01f,
  5.97175471e-02f, 2.06698896e-03f, -1.01506032e-01f, -9.80055518e-03f, 3.14621031e-02f, 8.99372175e-02f, 1.89293250e-01f, 2.35782489e-02f, -1.32041320e-01f, -8.49631652e-02f,
  -1.76461622e-01f, -1.31965235e-01f, 4.91308458e-02f, -1.01150118e-01f, -1.72265507e-02f, -1.73371822e-01f, -1.29250899e-01f, -6.23521805e-02f, -8.68513510e-02f, 1.27651811e-01f,
  -2.04332754e-01f, -4.64930907e-02f, -1.63244650e-01f, -9.49884802e-02f, -1.68380395e-01f, 2.42172375e-01f, 8.22909996e-02f, 4.26783785e-02f, 8.62097293e-02f, 8.16139206e-02f,
  6.00456558e-02f, -6.90218285e-02f, 8.34366679e-02f, 3.76688503e-02f, 1.94759950e-01f, 1.05139415e-03f, -7.19928220e-02f, -1.27910627e-02f, 6.46122098e-02f, 1.66646894e-02f,
  1.70802251e-01f, -3.92521545e-02f, 1.34244263e-01f, 1.07140809e-01f, -9.93130803e-02f, 1.52273700e-01f, -2.14738488e-01f, 5.71757519e-05f, -2.12261632e-01f, 1.51851147e-01f,
  -5.12095820e-03f, -8.46997127e-02f, 1.09396547e-01f, 1.00105435e-01f, -5.55744991e-02f, -8.25677905e-03f, -1.34099528e-01f, -1.15943722e-01f, 2.29950979e-01f, -1.18417755e-01f,
  -8.69117677e-02f, -4.35116962e-02f, 8.99995416e-02f, 1.71371698e-01f, 7.65058845e-02f, -7.14903623e-02f, -9.03874859e-02f, 1.69354882e-02f, 7.35691339e-02f, 6.39448455e-03f,
  -3.01748693e-01f, 7.12906048e-02f, 9.32136849e-02f, 1.12037454e-02f, 5.32974787e-02f, -8.11663792e-02f, 1.23561047e-01f, -1.33953646e-01f, 9.46703926e-02f, 8.16311389e-02f,
  -3.00626513e-02f, -2.12790687e-02f, 1.95747718e-01f, 3.17935534e-02f, 1.45445853e-01f, 1.98343068e-01f, 1.90549865e-01f, -6.88133016e-02f, -5.90461157e-02f, -1.55853018e-01f,
  -1.13740144e-02f, -9.64990482e-02f, -1.51328921e-01f, -4.78983261e-02f, -1.23584881e-01f, 2.78948009e-01f, -1.46600261e-01f, -1.08313993e-01f, -1.37136266e-01f, -8.84420872e-02f,
  1.16544880e-01f, -1.91449448e-01f, -1.23529516e-01f, 7.61794895e-02f, -9.14905667e-02f, 1.49470363e-02f, 1.01808887e-02f, -6.34068623e-02f, 4.73822802e-02f, -1.37379244e-01f,
  9.70540792e-02f, -2.89446395e-02f, 2.38256067e-01f, 7.85663798e-02f, -7.51767233e-02f, 1.91720109e-02f, -1.37487441e-01f, -1.35272384e-01f, 5.27674146e-02f, -1.14168949e-01f,
  -1.12513006e-01f, 5.65978065e-02f, -1.15762623e-02f, -1.09478787e-01f, 9.98214539e-03f, -6.01882711e-02f, 2.85097957e-03f, 1.15637094e-01f, 3.61655019e-02f, -6.50626868e-02f,
  -1.01879627e-01f, 8.54927227e-02f, -7.38550797e-02f, -1.46899223e-01f, -6.24018861e-03f, -8.13793465e-02f, -1.01293221e-01f, 4.22351547e-02f, -1.38935596e-01f, 2.43503619e-02f,
  1.29711449e-01f, 2.23041568e-02f, 1.97444707e-01f, -9.15606413e-03f, 1.21836998e-01f, 3.28296749e-03f, 1.54321805e-01f, 1.26831919e-01f, -3.70249748e-02f, 3.26133445e-02f,
  -1.79530397e-01f, 4.38907854e-02f, -5.93500622e-02f, -6.71421736e-02f, 1.69118330e-01f, 1.08140931e-01f, -9.03984755e-02f, 5.80680035e-02f, 5.47903515e-02f, 9.22663584e-02f,
  1.89086422e-02f, 1.62910849e-01f, 5.12276255e-02f, -1.66705504e-01f, -1.95336401e-01f, -2.06596628e-01f, 9.73360762e-02f, 1.15177311e-01f, 2.12390482e-01f, 8.59215409e-02f,
  -4.07974906e-02f, -2.69210972e-02f, 1.31267920e-01f, -1.54560342e-01f, -2.27687787e-02f, -3.01242005e-02f, 1.50804043e-01f, 1.57468840e-01f, -3.32144313e-02f, 5.39926291e-02f,
  1.50381818e-01f, -5.04806936e-02f, 8.16454515e-02f, -1.48052141e-01f, 9.60428920e-03f, 7.98091013e-03f, 5.19544818e-02f, -2.45071217e-01f, -7.79315457e-02f, 8.95063654e-02f,
  -1.45871088e-01f, 5.08052260e-02f, 1.13108091e-01f, -9.90741923e-02f, 9.59618688e-02f, -9.03035998e-02f, 1.26807347e-01f, 1.17428757e-01f, -4.37894277e-02f, 1.35991111e-01f,
  4.08376716e-02f, 9.23280418e-03f, 4.40561865e-03f, 1.07243359e-01f, 1.01211712e-01f, 5.55417165e-02f, -7.41784722e-02f, -4.21086745e-03f, -1.14992864e-01f, -8.38062614e-02f,
  1.44798666e-01f, -8.54184255e-02f, 3.19248103e-02f, 1.09072244e-02f, 1.08510844e-01f, -1.35503173e-01f, -4.99134026e-02f, 7.95721710e-02f, -1.14449235e-02f, -3.89464054e-04f,
  -1.45030096e-01f, 6.29622256e-03f, -1.63386147e-02f, -3.14273797e-02f, -1.15432963e-01f, 8.77892673e-02f, 1.11085661e-01f, 2.95184343e-03f, -1.71567768e-01f, -1.44022688e-01f,
  1.44563809e-01f, 8.12567323e-02f, -1.09614097e-01f, 2.51215231e-02f, -1.35349095e-01f, 6.77372292e-02f, 2.00953856e-01f, -1.67250894e-02f, 3.53965759e-02f, -1.38709754e-01f,
  -3.54698934e-02f, 3.23723257e-01f, 1.47534356e-01f, -7.57346228e-02f, 1.57725021e-01f, -1.25067025e-01f, 6.79845316e-03f, -1.46142125e-01f, 9.49862646e-04f, -9.57175251e-03f,
  -2.41237553e-03f, -8.74758884e-02f, 1.30695879e-01f, -6.44656792e-02f, -3.89848612e-02f, -7.83440173e-02f, 4.76130052e-03f, -1.95137803e-02f, 3.85049209e-02f, -4.91912700e-02f,
  -2.11541820e-02f, 1.39710948e-01f, -1.66843966e-01f, 1.01059489e-01f, -2.59709693e-02f, -1.65892318e-02f, 6.87933117e-02f, -1.70783758e-01f, -1.26053289e-01f, 3.62235010e-02f,
  -1.07055008e-02f, -7.81592950e-02f, 1.27445564e-01f, -9.74959582e-02f, -1.55697718e-01f, 5.46733290e-02f, 2.29091514e-02f, -9.96755064e-03f, 1.14675827e-01f, -2.03884467e-01f,
  9.36415195e-02f, 2.06723481e-01f, -5.33473343e-02f, 2.62091625e-02f, 5.73902577e-02f, -4.81224991e-03f, -1.65620476e-01f, 7.08327144e-02f, 7.85863772e-02f, -2.03741446e-01f,
  5.37973642e-02f, 4.91915569e-02f, 1.94942653e-01f, 1.19109608e-01f, -5.67018241e-02f, -1.13422401e-01f, -6.38456494e-02f, 1.09687619e-01f, -4.68001813e-02f, 1.02796823e-01f,
  -1.33440584e-01f, 8.14464390e-02f, -4.02463675e-02f, -4.76558581e-02f, 9.28551480e-02f, -8.62007961e-02f, -3.68942022e-02f, 1.25742853e-01f, 9.68365073e-02f, 4.73637283e-02f,
  -9.00178403e-02f, 1.79075018e-01f, -6.81492165e-02f, 5.82189113e-02f, -2.24628691e-02f, 2.18821913e-01f, -5.68606444e-02f, 2.02337168e-02f, -4.74244654e-02f, 2.52347402e-02f,
  -1.06028849e-02f, -2.09515058e-02f, 8.59678537e-02f, -5.34507334e-02f, -8.75830054e-02f, -6.48302734e-02f, 1.05075195e-01f, -9.50109214e-02f, 4.86213947e-03f, 3.14782672e-02f,
  2.81077530e-02f, -8.96435156e-02f, -5.77082261e-02f, -1.13850348e-01f, -9.12127718e-02f, -6.26374111e-02f, 4.22404967e-02f, -6.35995790e-02f, 1.44952908e-01f, 1.32472776e-02f,
  -1.06351422e-02f, -6.12235293e-02f, 9.56450477e-02f, -9.52772722e-02f, -9.36385766e-02f, 2.87392080e-01f, -1.16160829e-02f, 1.26682714e-01f, -5.91172390e-02f, 3.97753827e-02f,
  -1.12513090e-02f, -1.15697682e-01f, 6.38155565e-02f, -2.25711256e-01f, 1.22390278e-01f, 6.31346926e-02f, 8.64023864e-02f, 1.88746646e-01f, -3.03919259e-02f, 2.25261226e-02f,
  4.24309075e-02f, -1.06662609e-01f, -2.25688051e-03f, 1.30480424e-01f, -7.95712322e-02f, 9.85487998e-02f, -9.72385630e-02f, 7.69672263e-03f, 3.90241966e-02f, -2.51814604e-01f,
  -1.39904797e-01f, -1.51681872e-02f, -2.92196758e-02f, -1.86016951e-02f, -1.21290823e-02f, 1.20084517e-01f, -9.66976881e-02f, -8.08398649e-02f, -6.12212047e-02f, -9.19441786e-03f,
  -1.10521428e-01f, 6.81593716e-02f, 6.31983876e-02f, 9.94250253e-02f, 1.10999737e-02f, 5.13384230e-02f, 1.45105347e-01f, 6.21489175e-02f, -4.98383380e-02f, 1.29373491e-01f,
  1.09180268e-02f, -7.13514686e-02f, -2.37736944e-02f, 1.30698502e-01f, 6.17278218e-02f, -1.89594049e-02f, 8.47945288e-02f, 5.68802655e-02f, -3.69342789e-02f, -1.01107545e-01f,
  9.79073122e-02f, -5.20902360e-03f, 7.60881454e-02f, -1.42807765e-02f, 6.49645403e-02f, -9.30740088e-02f, -3.62197147e-03f, -1.06877878e-01f, 1.69413999e-01f, -3.52110900e-02f,
  9.28063467e-02f, 1.19534275e-02f, -9.57676843e-02f, 4.43082713e-02f, -1.75837949e-01f, 6.38534576e-02f, -1.58617288e-01f, -2.15758145e-01f, 4.64092270e-02f, 1.47115543e-01f,
  -7.39779137e-03f, 9.43788514e-02f, -1.19904345e-02f, -2.63920636e-03f, -1.02965884e-01f, 7.64140859e-02f, 8.04226547e-02f, 6.32409230e-02f, 7.83978961e-03f, 9.81576666e-02f,
  1.51721716e-01f, 4.65398841e-02f, -7.14067742e-02f, -7.39707947e-02f, -4.40727845e-02f, -8.40175375e-02f, -1.61814854e-01f, 3.12037971e-02f, -1.31021604e-01f, 6.88748881e-02f,
  -4.09434699e-02f, 1.37372360e-01f, -6.14496581e-02f, -4.08595754e-03f, -2.01779362e-02f, 3.59859467e-02f, -5.81942610e-02f, 9.38949883e-02f, 9.92411077e-02f, 9.44895297e-02f,
  -9.77005959e-02f, -1.12360813e-01f, 4.36740443e-02f, -1.87961176e-01f, 5.51607050e-02f, 2.14531855e-03f, -1.64155066e-01f, 4.93576005e-02f, -3.17997895e-02f, 1.16937131e-01f,
  7.54731297e-02f, -3.74068916e-02f, 8.63646939e-02f, 4.36866619e-02f, -9.77114737e-02f, 1.02490850e-01f, 1.48501322e-01f, -3.63666676e-02f, 1.14124462e-01f, 5.59733585e-02f,
  -1.29664764e-01f, 1.99549526e-01f, 1.77348983e-02f, -2.52494365e-01f, -7.85613880e-02f, 1.31141692e-01f, -4.04860005e-02f, 1.45217419e-01f, 1.58520684e-01f, -7.10418597e-02f,
  1.26742914e-01f, 1.00981995e-01f, -1.55111447e-01f, -1.79344580e-01f, -1.99796259e-02f, -3.97174656e-02f, -5.55622987e-02f, 1.94946174e-02f, 8.64041150e-02f, -8.30461159e-02f,
  -1.10533640e-01f, -8.71258304e-02f, -7.20943585e-02f, -5.61084822e-02f, 4.75244299e-02f, -4.30201972e-03f, 3.87429669e-02f, -3.91783044e-02f, -4.60687540e-02f, -8.69621783e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.93688303e-01f, 5.59238307e-02f, 9.52250790e-03f, -4.39766422e-02f, 7.85823241e-02f, -7.45504797e-02f, 6.64674267e-02f, 6.84177876e-02f, 2.25047246e-01f, 6.88616186e-02f,
  1.02912113e-01f, -1.46251312e-02f, 1.08298428e-01f, -1.39545336e-01f, 8.93201679e-03f, 1.93249717e-01f, -8.36771503e-02f, 8.23823810e-02f, 1.23295605e-01f, 1.73453912e-01f,
  1.96303368e-01f, 3.79413888e-02f, 1.59724907e-03f, 7.24835023e-02f, -4.90050055e-02f, 8.63231644e-02f, 9.37377196e-03f, -1.31062567e-01f, -1.78661466e-01f, 1.08771622e-02f,
  -1.50996909e-01f, 1.62448853e-01f, -1.65437967e-01f, -1.41617171e-02f, 2.19867855e-01f, -1.07358769e-01f, -1.74341886e-03f, 1.85498729e-01f, -1.47158891e-01f, -1.37998268e-01f,
  1.39619604e-01f, -7.52767548e-02f, -1.81452546e-03f, 6.49093464e-02f, -7.77049735e-02f, -2.86064819e-02f, 5.06900400e-02f, 4.60255984e-03f, -5.26591728e-04f, 1.17696434e-01f,
  -6.98654428e-02f, 5.28093055e-03f, -6.86389878e-02f, 9.38835815e-02f, 1.08153865e-01f, -5.71924150e-02f, -6.99254870e-02f, -5.28078154e-02f, -1.78007394e-01f, -9.85933989e-02f,
  -7.09506078e-03f, -5.78274578e-02f, 1.41724184e-01f, 1.19931661e-01f, -4.59345952e-02f, 9.51518640e-02f, 2.71004528e-01f, 7.14330524e-02f, 2.16672212e-01f, 2.99158603e-01f,
  1.56278446e-01f, 1.37614250e-01f, -1.30842164e-01f, 1.27244771e-01f, 1.53228387e-01f, 9.99350250e-02f, 8.84279236e-02f, 4.28600162e-02f, -9.72738788e-02f, 1.29811168e-01f,
  -1.89566948e-02f, 1.85585059e-02f, 3.65001187e-02f, 1.84735462e-01f, 1.10385068e-01f, 2.09094346e-01f, 1.60209984e-02f, 9.64605585e-02f, 3.10441017e-01f, -3.44830342e-02f,
  2.83795241e-02f, -2.24122375e-01f, -3.79801132e-02f, 1.26548544e-01f, 1.89964995e-02f, 1.10315524e-01f, -7.31760040e-02f, -1.96689308e-01f, -3.24422270e-01f, 2.00655237e-02f,
  -1.60584971e-01f, 1.56107619e-01f, 1.74927637e-01f, 4.46111485e-02f, 1.70272067e-01f, 8.88056830e-02f, 2.21394137e-01f, -1.16765969e-01f, 1.60959557e-01f, 9.52009633e-02f,
  9.72762629e-02f, -6.66355416e-02f, -2.30076164e-01f, -1.85876682e-01f, 9.64567822e-04f, -1.06854752e-01f, 3.48034501e-01f, 1.52948136e-02f, 9.48481821e-03f, 3.11352815e-02f,
  6.26713932e-02f, -2.40639690e-02f, -5.22447452e-02f, 9.51031893e-02f, -1.87670186e-01f, -3.50099094e-02f, 1.17449360e-02f, -9.27702859e-02f, 6.63615242e-02f, 5.93492948e-02f,
  2.20045615e-02f, 5.20317350e-03f, -9.37833413e-02f, 1.01983681e-01f, 1.03024773e-01f, -1.62344351e-01f, -1.13254130e-01f, -6.73400145e-03f, 6.40255492e-03f, 1.19270153e-01f,
  6.77831471e-02f, -8.09343234e-02f, 1.25824094e-01f, -4.93434072e-02f, 8.88120979e-02f, 1.07932970e-01f, -5.52483760e-02f, 1.15287052e-02f, -7.41345882e-02f, -1.98525190e-02f,
  -1.11914434e-01f, -9.22820717e-02f, -8.89958814e-02f, -6.65500835e-02f, -2.83297785e-02f, -4.58938666e-02f, 1.53227057e-02f, 8.06864630e-03f, -1.59533262e-01f, -4.01338823e-02f,
  1.04765333e-02f, -1.13339676e-03f, -5.00965444e-03f, -4.40564752e-02f, 8.82343724e-02f, 6.31451234e-02f, 6.10527322e-02f, -8.32651183e-02f, -4.90182079e-02f, -5.35291678e-04f,
  3.36515089e-03f, 6.99576512e-02f, 9.95780155e-02f, 1.34682208e-01f, 1.15768455e-01f, 3.78375351e-02f, -6.23704633e-03f, -1.09633571e-02f, -2.32073888e-02f, 5.00018485e-02f,
  1.11942261e-01f, 1.63056940e-01f, 9.08698067e-02f, -6.23602420e-02f, -4.41190936e-02f, 3.63701060e-02f, -2.30089538e-02f, -2.90199444e-02f, 2.23517537e-01f, 3.68269533e-01f,
  2.24636719e-01f, 9.46499687e-03f, 7.17184916e-02f, 1.93582661e-02f, 9.71135050e-02f, 2.92143431e-02f, -1.37804421e-02f, 6.00103177e-02f, 2.43380852e-03f, 7.38290623e-02f,
  2.23638058e-01f, 1.08220316e-01f, 2.29986794e-02f, -7.89292157e-02f, 1.82167843e-01f, -6.49021789e-02f, 3.69036607e-02f, -2.55439356e-02f, -9.47874710e-02f, 2.09497392e-01f,
  1.01094265e-02f, 1.72166795e-01f, 4.91439626e-02f, 1.26044906e-03f, 1.39669240e-01f, 4.78692092e-02f, 1.28019780e-01f, 7.83201605e-02f, -1.18776625e-02f, -6.48854449e-02f,
  -5.00116870e-02f, 1.81853101e-02f, -1.92180410e-01f, 6.88441694e-02f, -1.13222606e-01f, 7.94436559e-02f, 7.25284815e-02f, 5.07526845e-02f, 9.21194255e-02f, -2.62454413e-02f,
  -8.81659612e-02f, -1.03265196e-01f, 1.18019722e-01f, 4.59415317e-02f, -3.20402458e-02f, -3.47305946e-02f, -2.69613899e-02f, 8.94094780e-02f, 4.93998080e-02f, -9.57552493e-02f,
  1.69313326e-01f, 4.87680361e-02f, 6.74329028e-02f, -5.73938712e-02f, -7.69750550e-02f, -1.32598683e-01f, 8.15338567e-02f, -1.46441922e-01f, -1.41940847e-01f, 7.48483166e-02f,
  4.45186347e-02f, 1.64322164e-02f, -1.01825051e-01f, -1.22079469e-01f, 1.30172685e-01f, 1.56291410e-01f, -2.71621197e-02f, 2.95352209e-02f, 1.58030882e-01f, 1.18601285e-01f,
  1.05009638e-01f, 3.83506864e-02f, -5.79080880e-02f, 4.86946292e-02f, -7.70094395e-02f, -6.89559653e-02f, 9.55348015e-02f, 3.06767169e-02f, -3.87787372e-02f, 3.03603727e-02f,
  5.52017242e-02f, 5.03936149e-02f, -8.07668492e-02f, -6.70066699e-02f, -1.74316065e-03f, -7.68666342e-02f, 5.79819568e-02f, 9.35963616e-02f, -2.73357555e-02f, 2.78889835e-02f,
  1.23956040e-01f, -1.32469952e-01f, 6.23604432e-02f, -1.19370550e-01f, -2.64971200e-02f, 8.51758122e-02f, 8.94775987e-02f, -3.21541354e-02f, -6.49625808e-02f, 7.55940080e-02f,
  2.11825389e-02f, 9.49773565e-02f, -6.88905939e-02f, -4.94231768e-02f, -1.30996844e-02f, 1.74650609e-01f, -8.11986104e-02f, -3.89270894e-02f, 1.33297220e-01f, 1.06643915e-01f,
  8.46666694e-02f, 8.37780312e-02f, 1.21372119e-02f, -3.01039573e-02f, -2.51997132e-02f, -3.78877148e-02f, 1.72225177e-01f, 1.65668890e-01f, 1.28317222e-01f, 5.08175790e-02f,
  -4.65506911e-02f, -6.14530779e-02f, 1.70332775e-01f, 4.34964597e-02f, -1.87838394e-02f, 6.30417094e-02f, -1.40222898e-02f, 1.45960763e-01f, 1.03482567e-01f, -1.28667681e-02f,
  -1.89663824e-02f, 2.50547715e-02f, 9.17754695e-02f, 7.91223198e-02f, 3.39574777e-02f, 4.99147736e-02f, 2.48061288e-02f, 7.86605477e-02f, -7.26878047e-02f, -2.47658249e-02f,
  1.64147958e-01f, -9.86956339e-03f, 8.88194814e-02f, 1.78584173e-01f, 5.67244180e-02f, 1.32795367e-02f, 6.55742958e-02f, 9.12975334e-03f, 8.15010257e-03f, 8.29483122e-02f,
  -7.66984299e-02f, 8.93055741e-03f, 2.17760112e-02f, 1.61695108e-01f, -2.27271449e-02f, -4.40329723e-02f, 3.04142442e-02f, -5.22293895e-02f, 5.40384613e-02f, 2.95940135e-02f,
  -3.27410474e-02f, 1.63189229e-02f, -2.41945647e-02f, 1.30178602e-02f, 5.82299121e-02f, 5.74355274e-02f, -8.33843872e-02f, 1.53717371e-02f, 4.63017039e-02f, 3.10350582e-02f,
  4.92411852e-02f, -2.13256851e-02f, 6.05996884e-02f, -4.60001267e-02f, 3.46318819e-02f, -9.73499864e-02f, 1.14296496e-01f, -2.42277794e-02f, 1.18453443e-01f, 1.74784996e-02f,
  1.69825390e-01f, 5.34723252e-02f, 1.68345749e-01f, 1.03478745e-01f, -1.15735106e-01f, 1.48698077e-01f, -1.11812964e-01f, -4.38165143e-02f, 1.29354179e-01f, 1.38526261e-01f,
  -3.95555459e-02f, -1.96501002e-01f, -1.61399785e-02f, -9.97620001e-02f, -9.87384766e-02f, -1.17510394e-03f, -7.03280047e-02f, -1.02836989e-01f, 1.17178336e-01f, -9.85579267e-02f,
  5.12609072e-02f, 1.13505505e-01f, -4.08208370e-02f, -1.23462699e-01f, -1.22763768e-01f, -2.95996834e-02f, -9.27349031e-02f, 7.45817572e-02f, 8.26635063e-02f, 1.14277624e-01f,
  8.21201503e-02f, -3.57581303e-02f, 1.81223527e-02f, 2.01924983e-02f, -7.31356815e-02f, -1.59582440e-02f, -1.19777851e-01f, -5.98597266e-02f, -4.67031822e-02f, 8.81539751e-03f,
  1.11614950e-01f, 1.19121738e-01f, -4.87313345e-02f, 6.49819970e-02f, -4.05661352e-02f, 1.26769794e-02f, 1.32411635e-02f, -9.45051759e-02f, 5.67853637e-02f, 8.78183842e-02f,
  7.13482872e-02f, -8.10958669e-02f, 9.86298174e-02f, -6.62829950e-02f, -4.71496992e-02f, -7.23420605e-02f, 1.00009456e-01f, 8.19558352e-02f, 6.17451072e-02f, 8.46303999e-02f,
  -1.12059027e-01f, -8.63218904e-02f, 9.35179368e-03f, 1.17563747e-01f, -6.71229959e-02f, 5.66248931e-02f, 2.99722236e-02f, -4.33175191e-02f, -5.76824509e-02f, -7.52845220e-03f,
  2.54727546e-02f, -4.62622754e-02f, 9.72154066e-02f, -7.24489763e-02f, -4.77458946e-02f, 1.74006331e-03f, 5.24602830e-02f, 6.03955686e-02f, 1.02577284e-02f, 1.27612337e-01f,
  -2.55145580e-02f, 9.83666405e-02f, 5.15303388e-03f, -1.30745351e-01f, -9.94013920e-02f, -1.26087368e-02f, -4.40112278e-02f, 8.18373263e-02f, 1.32081538e-01f, -4.20973226e-02f,
  -3.47884484e-02f, -2.38875132e-02f, 1.22360408e-01f, 6.28309548e-02f, -3.29386890e-02f, -7.35231191e-02f, -5.67080788e-02f, 1.04481444e-01f, -8.88946801e-02f, 1.03932016e-01f,
  1.27275258e-01f, -8.45633894e-02f, -1.27231944e-02f, 1.19181648e-01f, 4.28935438e-02f, 1.55087411e-01f, -1.05662011e-01f, -2.13761069e-02f, 8.05376843e-02f, 2.55929884e-02f,
  2.82693058e-02f, 5.18128229e-03f, 1.48069754e-01f, 5.64456023e-02f, 1.22550555e-01f, -1.51946455e-01f, 1.28476908e-02f, 8.76209065e-02f, 3.31923761e-03f, -7.07759410e-02f,
  -6.50091423e-03f, 7.24672154e-02f, -9.55854058e-02f, -5.99451028e-02f, -6.46814927e-02f, -1.12763010e-02f, 7.75401592e-02f, 1.15548991e-01f, 2.96003036e-02f, 1.09102465e-01f,
  -9.04759243e-02f, -3.42674442e-02f, 6.26505762e-02f, -1.15764573e-01f, 7.14928135e-02f, -3.82327996e-02f, 1.03253812e-01f, 1.90839265e-02f, -1.42172456e-01f, -6.25222772e-02f,
  -6.99198097e-02f, 2.28731539e-02f, -3.84260621e-03f, 1.75430942e-02f, 1.43076837e-01f, 8.42655525e-02f, 1.44431278e-01f, 4.60627303e-02f, -6.79058433e-02f, 9.07290801e-02f,
  -1.28816321e-01f, -6.05179593e-02f, 1.16317697e-01f, 1.56026393e-01f, 4.74695489e-02f, 1.47274166e-01f, 1.00638932e-02f, 1.47927701e-01f, 9.88880545e-03f, -1.19405486e-01f,
  2.50169751e-03f, 7.24406466e-02f, 9.50362235e-02f, 7.46332332e-02f, 3.21977884e-02f, -2.20452975e-02f, -5.23422845e-02f, -2.19673254e-02f, -2.12521218e-02f, -1.76942095e-01f,
  -3.24971043e-02f, 6.55878559e-02f, -6.75748810e-02f, -2.46738698e-02f, 8.81325547e-03f, -1.12036251e-01f, -2.40945444e-01f, -1.49353053e-02f, -7.94880688e-02f, -2.13986877e-02f,
  1.80115283e-01f, 5.68378530e-02f, 1.21811017e-01f, 1.53719336e-01f, -7.99282566e-02f, -7.75938332e-02f, -6.88545406e-02f, -1.22137507e-02f, 2.24897955e-02f, -8.38575810e-02f,
  -9.41860527e-02f, 2.62145568e-02f, 8.17523599e-02f, 7.32109919e-02f, 4.64924127e-02f, 7.41720274e-02f, -5.82089983e-02f, 6.59355670e-02f, 4.24475744e-02f, 2.38579605e-02f,
  7.81599954e-02f, 7.40370452e-02f, 4.99367453e-02f, -1.11678749e-01f, 4.48419638e-02f, -1.08666010e-01f, 4.32394594e-02f, 5.17763272e-02f, 8.75705387e-03f, 5.53311594e-02f,
  1.54110178e-01f, 1.09083265e-01f, -2.42645629e-02f, -1.03132278e-01f, 4.70789112e-02f, 2.43941452e-02f, -4.08220589e-02f, 4.88604903e-02f, 8.72240663e-02f, 5.00646327e-03f,
  1.70823187e-02f, 9.54828039e-02f, 3.68869118e-02f, 1.69892296e-01f, -8.43302906e-02f, 6.27485067e-02f, 2.64358483e-02f, 1.10122330e-01f, 9.84813720e-02f, 3.86077561e-03f,
  -5.35471961e-02f, -5.36308810e-02f, -1.40824364e-02f, -6.34238869e-02f, 7.08753914e-02f, -1.04614496e-01f, -2.20865868e-02f, -4.78612296e-02f, -1.14249429e-02f, 1.30139496e-02f,
  1.72072574e-01f, -8.59430656e-02f, 3.05535290e-02f, 1.14925809e-01f, -1.51453810e-02f, 2.29908545e-02f, -1.35801867e-01f, 5.08698113e-02f, -1.00797191e-01f, 2.73399130e-02f,
  -1.30675480e-01f, -9.91516709e-02f, -3.05370265e-03f, 9.01294723e-02f, -1.60304382e-01f, -6.58209343e-03f, 5.08766286e-02f, 1.56271815e-01f, -1.07994713e-01f, 2.18020985e-03f,
  5.62333874e-02f, -4.37253602e-02f, -3.63355875e-02f, -4.65466455e-02f, 6.96401969e-02f, 2.86458991e-02f, 1.41549138e-02f, 6.43173307e-02f, 4.41820398e-02f, -1.18829869e-02f,
  -2.84569208e-02f, 1.14046268e-01f, -4.52503785e-02f, 1.98127273e-02f, 7.35134333e-02f, -2.12282054e-02f, -7.29746819e-02f, 1.16185673e-01f, 2.40533296e-02f, -5.10881618e-02f,
  -4.44752835e-02f, 9.70441177e-02f, 1.10315077e-01f, 7.22550601e-02f, -1.23308981e-02f, 3.28575559e-02f, 1.31734654e-01f, 1.79342061e-01f, -3.27241533e-02f, 2.74950620e-02f,
  7.80415311e-02f, -3.87396920e-03f, 3.12794298e-02f, -1.27638765e-02f, 1.20495722e-01f, -1.35248363e-01f, 4.97635119e-02f, 2.76822634e-02f, 1.01876862e-01f, 3.12829204e-02f,
  3.85478549e-02f, -3.95422131e-02f, -2.53933258e-02f, -6.87480494e-02f, -3.21234763e-02f, 7.20116049e-02f, 1.18274599e-01f, 2.26389449e-02f, 1.10753164e-01f, 2.37182006e-02f,
  -6.33379072e-02f, 5.49478494e-02f, -1.18222058e-01f, 5.42445667e-03f, -4.04768735e-02f, -1.75866753e-01f, 9.49867629e-03f, 1.60902649e-01f, 9.40572396e-02f, 1.64923549e-01f,
  -9.96516570e-02f, -1.28793165e-01f, -1.46981433e-01f, -2.99016498e-02f, 7.15630427e-02f, -6.71642944e-02f, -1.19253814e-01f, 8.86713043e-02f, -2.97818077e-03f, 1.08725969e-02f,
  -1.77091155e-02f, -3.81156243e-02f, 2.73480993e-02f, 8.82232115e-02f, -1.09343328e-01f, -5.37581146e-02f, -1.68285146e-02f, -9.88404527e-02f, -1.24630399e-01f, 2.95189042e-02f,
  -6.42555207e-02f, 7.79392570e-02f, 7.31673241e-02f, 1.51894791e-02f, 6.62377179e-02f, -2.52323318e-02f, 5.10021225e-02f, -4.77382028e-03f, -1.20152287e-01f, 4.73590009e-02f,
  -3.90275382e-02f, -1.31954387e-01f, -5.73993176e-02f, 2.18729340e-02f, 1.03730328e-01f, 9.36964974e-02f, 2.67708395e-02f, -5.84324449e-02f, -8.63804743e-02f, 1.04675360e-01f,
  7.32871741e-02f, -1.88155808e-02f, -1.10973991e-01f, -9.21257436e-02f, -3.52391377e-02f, -5.59533993e-03f, -1.11805856e-01f, 9.90461558e-02f, -2.16613486e-02f, -5.06006293e-02f,
  2.08367612e-02f, -3.65834832e-02f, 1.28193334e-01f, 7.89970756e-02f, -8.84588063e-02f, -4.01340835e-02f, 8.76447707e-02f, -1.65206920e-02f, -6.38028309e-02f, -4.74213324e-02f,
  3.04551106e-02f, 1.17715091e-01f, 1.82591081e-02f, 6.98571876e-02f, -2.63543911e-02f, 5.80376796e-02f, -1.00859836e-01f, -6.77064210e-02f, 7.35871792e-02f, 2.80632507e-02f,
  1.09532379e-01f, 9.10135582e-02f, -7.76575878e-02f, 7.88544118e-02f, -4.26281616e-02f, -1.09351709e-01f, 5.19493176e-03f, 1.07477702e-01f, -2.35947818e-02f, -8.44973624e-02f,
  1.10152997e-01f, -7.78979808e-02f, -6.67627975e-02f, -9.75418612e-02f, 1.17866285e-01f, -1.06015904e-02f, -2.14882568e-02f, 6.23502769e-02f, 3.50201465e-02f, -9.90303308e-02f,
  -1.11822210e-01f, 4.43606228e-02f, -1.09102368e-01f, 3.87406759e-02f, 6.53486252e-02f, 1.29663646e-01f, 2.92149605e-03f, -6.89520538e-02f, 1.72302872e-02f, -9.60169639e-03f,
  -3.97296026e-02f, -1.66437495e-02f, -2.27750521e-02f, -4.12503183e-02f, 4.24859636e-02f, -1.04525082e-01f, -7.16624558e-02f, 6.26062751e-02f, 1.40918329e-01f, -1.19954892e-01f,
  -2.44977809e-02f, -1.40262797e-01f, -8.55102856e-03f, -5.53531423e-02f, -1.38635039e-02f, 1.20416239e-01f, 8.50227177e-02f, 2.15945058e-02f, -1.19733149e-02f, 1.16120003e-01f,
  -1.11171588e-01f, 9.87308174e-02f, 1.01912081e-01f, -9.45233088e-03f, 9.26360954e-03f, 1.14453606e-01f, -1.21662207e-01f, -6.72825053e-02f, -2.87640039e-02f, 1.37746893e-02f,
  9.17044282e-02f, -7.02689812e-02f, 1.29681572e-01f, -8.43043029e-02f, -7.75713623e-02f, -8.54347795e-02f, 1.34230956e-01f, 2.47346871e-02f, -6.99737817e-02f, -2.15445962e-02f,
  -8.56619254e-02f, -4.12131520e-03f, 1.15270816e-01f, -7.75986016e-02f, 1.18066497e-01f, -9.21093822e-02f, 1.47040173e-01f, -3.12866904e-02f, 5.47672361e-02f, 2.81227920e-02f,
  4.21658577e-03f, 5.12172431e-02f, 3.65419835e-02f, 5.50563894e-02f, 2.40471903e-02f, -1.38227686e-01f, 1.09780058e-01f, -1.20052285e-02f, 7.50710145e-02f, -2.05892380e-02f,
  -5.97421303e-02f, 1.80491097e-02f, 1.84351690e-02f, 1.57164872e-01f, 1.50964409e-01f, -8.51486176e-02f, 1.19259261e-01f, 6.90716952e-02f, 2.54304372e-02f, 1.09994542e-02f,
  9.53892022e-02f, 1.28881797e-01f, 7.39757344e-03f, 2.25914437e-02f, -7.06048235e-02f, -8.37988034e-03f, 1.48555204e-01f, -9.15214792e-02f, 2.71418765e-02f, 1.14709347e-01f,
  -1.68895945e-01f, -5.45779839e-02f, 1.06519386e-01f, -7.75728300e-02f, 2.60485541e-02f, 1.03739925e-01f, -1.48092844e-02f, 9.33148414e-02f, -7.56799653e-02f, -7.45267868e-02f,
  1.51607379e-01f, 9.02807340e-02f, 4.00228938e-03f, -4.00404818e-02f, -1.18618533e-01f, 3.49375606e-02f, 7.87899345e-02f, 7.65885273e-03f, 9.69799682e-02f, -9.31255370e-02f,
  -8.37507918e-02f, -5.47964461e-02f, 5.07104807e-02f, 1.43277347e-01f, 3.28291208e-02f, 1.23535194e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -1.58630740e-02f, 9.76568833e-02f, 7.54790157e-02f, 1.00904234e-01f, 1.53145358e-01f, 5.19344397e-02f, -3.43693495e-02f, -7.93750864e-03f, 1.47068258e-02f, 7.58211985e-02f,
  6.79785013e-02f, -1.26948863e-01f, 5.62543981e-03f, 5.72571345e-02f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -2.83482019e-02f, -6.66626319e-02f, 4.15634140e-02f, 1.99530229e-01f, -1.05249554e-01f, 5.51876538e-02f, 5.45644946e-02f, 1.11506186e-01f, -7.73883611e-02f, -1.32192031e-01f,
  -9.67736095e-02f, -1.32712662e-01f, -1.29977375e-01f, 1.57689415e-02f, -1.03630703e-02f, -2.90551540e-02f, -1.25365257e-01f, -7.98558220e-02f, -1.82896823e-01f, 2.46988721e-02f,
  3.61166224e-02f, -1.16364673e-01f, -1.09372690e-01f, 1.15603253e-01f, -7.74264783e-02f, -9.69975516e-02f, 2.79266655e-01f, -5.94193749e-02f, 2.15017553e-02f, -6.94615096e-02f,
  8.93468782e-03f, -3.22432481e-02f, -2.47880220e-02f, 3.42120454e-02f, 6.56484142e-02f, -2.12878644e-01f, 1.20446876e-01f, -2.15320792e-02f, 1.11574747e-01f, -8.67369324e-02f,
  -1.88465908e-01f, 1.20724432e-01f, 2.09397860e-02f, -2.26159215e-01f, 2.32219756e-01f, -7.95914084e-02f, -9.28377807e-02f, -1.56794012e-01f, -1.78040758e-01f, 1.40712306e-01f,
  -1.30675107e-01f, 2.78189570e-01f, 6.15850091e-02f, -1.53738121e-02f, 1.17970608e-01f, -6.89359456e-02f, -1.49927596e-02f, -1.20436765e-01f, 8.91267806e-02f, -1.76230371e-01f,
  -1.19485706e-01f, 3.89152318e-02f, -1.52130332e-02f, -8.72271210e-02f, 1.01346269e-01f, -3.70751098e-02f, -7.38847703e-02f, 5.02947196e-02f, -7.73721859e-02f, -2.00064871e-02f,
  -3.53710018e-02f, -1.74360555e-02f, 4.55129631e-02f, 4.77950126e-02f, 2.02494934e-01f, 2.13132948e-02f, 1.24861851e-01f, 1.37057140e-01f, 1.22301348e-01f, -3.65885124e-02f,
  -2.04802454e-02f, -7.41934627e-02f, 1.95442304e-01f, 3.77789810e-02f, 9.97178555e-02f, 1.32020220e-01f, 1.28500953e-01f, 4.33790125e-03f, 1.94864884e-01f, -3.77210453e-02f,
  -7.05659166e-02f, 1.91926017e-01f, -1.32897511e-01f, 8.30053445e-03f, -1.30033955e-01f, 2.07472116e-01f, -2.49766335e-01f, 3.09196450e-02f, 1.31307989e-01f, -6.03539310e-02f,
  -3.32086720e-02f, -1.39872640e-01f, -1.52696773e-01f, -5.65750599e-02f, -9.44325030e-02f, 2.69100666e-01f, -1.05763478e-02f, -1.66673675e-01f, -3.12777370e-01f, -1.05078153e-01f,
  8.78938138e-02f, 2.90966988e-01f, 1.60815030e-01f, -1.52608126e-01f, 1.35641113e-01f, -1.18607953e-01f, -1.43721163e-01f, 2.05435187e-01f, -2.43814185e-01f, 4.92560156e-02f,
  8.84996504e-02f, 7.79655427e-02f, -7.43522719e-02f, -1.71964541e-02f, 1.95037857e-01f, -1.15199089e-01f, -2.99164373e-02f, -2.66106445e-02f, 9.40636825e-03f, 8.58266503e-02f,
  1.21062890e-01f, -8.69460478e-02f, -5.36014400e-02f, -7.88379312e-02f, 3.36539862e-03f, 7.62331784e-02f, -2.13944502e-02f, -4.39309375e-03f, -1.21916458e-01f, 1.12560831e-01f,
  5.39021827e-02f, -7.67803118e-02f, -5.51012252e-03f, 5.39139248e-02f, 5.13985641e-02f, 8.44347849e-02f, 1.73129410e-01f, 1.44235805e-01f, -2.07269637e-04f, 1.24739073e-01f,
  1.53151173e-02f, 8.68677795e-02f, -1.03800535e-01f, -1.25623094e-02f, -1.28126889e-01f, 1.70616210e-01f, -9.17438567e-02f, -1.37360036e-01f, 6.39408315e-03f, -1.64390936e-01f,
  9.61211175e-02f, -1.41739860e-01f, -1.24933533e-01f, 3.02038699e-01f, -7.78220445e-02f, 1.62293762e-01f, -8.65200311e-02f, -4.49058041e-02f, 7.43634701e-02f, -4.19881940e-02f,
  -1.86546713e-01f, 1.75970182e-01f, -1.82046130e-01f, 1.55011684e-01f, 1.85071677e-01f, 1.14551872e-01f, 1.25807509e-01f, -1.85765028e-01f, -1.10958211e-01f, -7.93705955e-02f,
  5.89812957e-02f, -1.42331392e-01f, 4.78054620e-02f, -3.08817346e-03f, -6.27304465e-02f, 1.11501060e-01f, -1.42488047e-01f, 9.24371034e-02f, -2.24547386e-02f, -1.10616304e-01f,
  1.26798898e-01f, -3.28489542e-02f, 9.96156409e-02f, 9.47070308e-03f, 8.40051174e-02f, 1.93635821e-02f, 4.26967219e-02f, 8.79202783e-02f, -4.04755361e-02f, -5.53613044e-02f,
  -8.22949335e-02f, -3.57119851e-02f, -7.02299699e-02f, 3.87097001e-02f, 5.48407137e-02f, -2.15382874e-02f, 3.62719111e-02f, -4.42309119e-02f, -3.43351774e-02f, -9.27016065e-02f,
  -1.03090920e-01f, -5.90915158e-02f, -7.12685511e-02f, -5.83686531e-02f, 1.22625753e-01f, 2.08281931e-02f, -1.78431924e-02f, -2.01552749e-01f, 1.42779380e-01f, -5.28912246e-02f,
  8.92690793e-02f, -1.35232106e-01f, 1.11613095e-01f, 7.48763159e-02f, -1.72374606e-01f, 6.15610667e-02f, -2.33654380e-01f, -2.65623499e-02f, -7.13599622e-02f, -1.99459866e-02f,
  -9.07469448e-03f, 7.40299225e-02f, -3.02881561e-02f, -3.56956646e-02f, -1.53319404e-01f, 2.26432249e-01f, 1.55185461e-02f, 1.73215374e-01f, -2.21154429e-02f, -2.07369372e-01f,
  -3.81851606e-02f, 2.57891938e-02f, 3.60308252e-02f, -1.29582345e-01f, 1.43998668e-01f, -2.67779513e-04f, -3.82073894e-02f, -1.40387505e-01f, -1.89204309e-02f, 1.15178041e-02f,
  -6.72378540e-02f, -4.76903617e-02f, -1.27398074e-01f, 1.27622448e-02f, -1.13094762e-01f, 7.77865425e-02f, 8.17754865e-02f, 7.88222849e-02f, 1.33335501e-01f, 1.47186533e-01f,
  -6.77971914e-03f, 8.68688896e-02f, -3.93064134e-03f, -6.94930255e-02f, 7.55339712e-02f, -1.13371864e-01f, -2.79746279e-02f, 7.99564943e-02f, 1.02073565e-01f, -7.11803138e-02f,
  1.43464059e-02f, 6.62712678e-02f, -3.10008023e-02f, -5.19290790e-02f, -1.83309674e-01f, -1.57542359e-02f, 1.40377447e-01f, 1.05712786e-02f, 1.06168218e-01f, 4.80436645e-02f,
  6.52122647e-02f, 8.87978896e-02f, 3.96577716e-02f, -1.94329291e-03f, -1.21085413e-01f, 1.30213246e-01f, 1.29816666e-01f, 1.37863224e-02f, 1.40688345e-01f, -7.40077570e-02f,
  1.94002882e-01f, -2.16846287e-01f, 1.44807696e-01f, 3.91417481e-02f, 6.37459382e-03f, -7.39576370e-02f, -4.86416817e-02f, -1.24544904e-01f, 2.39167407e-01f, -1.93603635e-01f,
  4.73387614e-02f, 6.75700530e-02f, -1.10330448e-01f, 1.28664270e-01f, -1.20215490e-01f, 1.01035617e-01f, -1.79483928e-02f, 1.68571889e-01f, -5.82914650e-02f, 1.00656427e-01f,
  7.92944208e-02f, 6.85880706e-02f, 2.85031321e-03f, -1.97396055e-03f, -4.27245162e-02f, -1.29188091e-01f, -2.39446969e-03f, 5.72534241e-02f, -4.35538404e-02f, -1.24667957e-01f,
  5.40666096e-02f, 2.87622381e-02f, -9.96551197e-03f, 6.84577972e-02f, -1.24792889e-01f, -1.47518991e-02f, -3.99622954e-02f, -6.75446242e-02f, -9.83075723e-02f, 3.74961086e-02f,
  9.29066017e-02f, 9.25991014e-02f, -5.29009476e-03f, 3.54332067e-02f, -2.24276762e-02f, 4.39766757e-02f, -9.16483030e-02f, 9.29547995e-02f, 6.76659867e-02f, -3.51741873e-02f,
  1.26089547e-02f, 7.37537071e-02f, -9.33896676e-02f, -1.19929887e-01f, 2.95424387e-02f, -9.77034047e-02f, 4.46787663e-02f, -3.11927957e-04f, 1.12171501e-01f, -1.22026505e-03f,
  -1.12878144e-01f, 1.54050678e-01f, -8.28268155e-02f, 1.01516895e-01f, -6.33524731e-02f, -1.20963894e-01f, -1.06871761e-02f, -3.94272283e-02f, -7.21348301e-02f, 1.70897067e-01f,
  4.92103696e-02f, 2.72057295e-01f, -6.40125424e-02f, -4.22268063e-02f, -1.24292456e-01f, -1.89168394e-01f, 9.92602482e-02f, -7.25587681e-02f, 8.18696320e-02f, -3.50899026e-02f,
  1.98929414e-01f, -1.74224690e-01f, -1.87821388e-01f, 6.55435622e-02f, -2.66886428e-02f, -1.12704575e-01f, 6.50150180e-02f, -9.02535617e-02f, -1.25089481e-01f, 8.63156095e-03f,
  1.95085648e-02f, -9.31926221e-02f, -4.82723601e-02f, 1.24206133e-01f, 6.05798736e-02f, -4.57702056e-02f, -3.14832591e-02f, -5.99059723e-02f, 6.87918216e-02f, -1.07090920e-01f,
  8.43410119e-02f, -2.85183508e-02f, -4.80622053e-02f, -7.26113096e-02f, -1.54567897e-01f, 9.50156525e-02f, 1.07793771e-01f, -6.08630851e-02f, 1.12409340e-02f, 3.64970155e-02f,
  -1.31801650e-01f, -1.65691171e-02f, -1.45932183e-01f, -2.49505658e-02f, 8.23389590e-02f, 1.80223845e-02f, 4.96710613e-02f, -7.72684291e-02f, -1.04247898e-01f, -8.35605562e-02f,
  4.14063744e-02f, -5.19659556e-02f, 4.78317514e-02f, -2.90558506e-02f, -6.78496510e-02f, -1.61888450e-01f, 1.55831441e-01f, -1.97332092e-02f, -1.62038296e-01f, 8.75037163e-03f,
  1.06396023e-02f, -2.51875329e-03f, -2.02111062e-02f, -1.07489698e-01f, -2.74250340e-02f, -2.43541688e-01f, 5.61771356e-02f, 6.06118217e-02f, 1.72878623e-01f, 1.65156096e-01f,
  9.19625908e-03f, -1.93421066e-01f, -3.94628197e-02f, 1.58928856e-01f, -1.34465694e-01f, 2.16223031e-01f, 1.82918176e-01f, -1.49215013e-01f, -9.83561575e-03f, -8.32759291e-02f,
  -1.85493659e-02f, -1.97759382e-02f, 1.66165698e-02f, 7.62871504e-02f, -1.56981975e-01f, -1.88136213e-02f, 2.17739753e-02f, 4.03537527e-02f, -2.84078307e-02f, -1.29167428e-02f,
  1.95378400e-02f, 2.35551205e-02f, -1.57836959e-01f, 5.94086833e-02f, -1.81235150e-02f, -5.06901853e-02f, 9.09335539e-02f, 7.41530955e-02f, 2.34448433e-01f, 1.28821924e-01f,
  -1.01677790e-01f, -1.03228264e-01f, 1.23368748e-01f, -1.83875486e-02f, 1.25433475e-01f, 1.38066933e-01f, 6.03009425e-02f, 1.99261419e-02f, -2.39028484e-02f, -3.40699591e-02f,
  -7.01825619e-02f, -4.53020334e-02f, 1.02948193e-02f, -1.43625308e-02f, -4.41095605e-02f, -1.94332853e-01f, 2.22535789e-01f, 1.99115187e-01f, -6.13666959e-02f, 1.80907045e-02f,
  2.40035541e-02f, 1.20821252e-01f, 1.56490952e-01f, -9.13357586e-02f, 4.99073975e-02f, -1.21146411e-01f, 1.11028381e-01f, 8.08326900e-02f, -1.47977285e-03f, 1.67577863e-01f,
  1.72242895e-01f, -2.36275613e-01f, 1.34884402e-01f, -1.81704815e-02f, -1.42998219e-01f, 6.24266081e-02f, -5.13100661e-02f, -5.19585721e-02f, 1.19352572e-01f, 8.39489847e-02f,
  -7.99797252e-02f, 3.19343172e-02f, 1.10921897e-01f, 1.64572403e-01f, 7.22799376e-02f, 6.26890734e-02f, -9.67301503e-02f, -1.21323258e-01f, -8.09628814e-02f, 2.27784310e-02f,
  1.82288606e-02f, -1.49803301e-02f, 7.49368668e-02f, 6.61941916e-02f, 8.82941633e-02f, -4.65511344e-02f, -1.08824335e-01f, -6.82585239e-02f, -8.44207034e-03f, -2.52252165e-02f,
  2.13506054e-02f, 4.48275246e-02f, -2.62249447e-02f, 5.74058294e-02f, -2.20255274e-02f, -4.83569577e-02f, -7.60898516e-02f, -3.62007581e-02f, 1.51972502e-01f, 2.89050825e-02f,
  7.22183138e-02f, -3.33337039e-02f, -4.09121104e-02f, -9.39062908e-02f, 4.30603586e-02f, 9.68365297e-02f, 7.91411698e-02f, -1.68686718e-01f, 1.91747993e-01f, -9.11625996e-02f,
  2.41911728e-02f, 2.42817160e-02f, -7.13786110e-02f, 5.95620610e-02f, 3.02157812e-02f, 1.68395285e-02f, -9.79465172e-02f, -5.23219816e-02f, -2.04764660e-02f, 4.10890952e-02f,
  -6.85891733e-02f, 1.36327818e-01f, -6.04258245e-03f, 1.71548381e-01f, -1.41434863e-01f, 7.68970549e-02f, 8.77824873e-02f, -5.76405379e-04f, 5.47511550e-03f, -8.84400755e-02f,
  1.76942851e-02f, 1.92405820e-01f, 9.03728902e-02f, -1.31542757e-01f, 7.56087974e-02f, 1.51301041e-01f, 3.91888097e-02f, 9.80978012e-02f, -1.59613546e-02f, -1.20647317e-02f,
  -7.21589848e-02f, -6.01877533e-02f, -1.12102695e-01f, -5.39164394e-02f, -7.80080929e-02f, 1.51368707e-01f, -2.96407975e-02f, 1.32356092e-01f, -5.83975092e-02f, 3.83187570e-02f,
  -7.15909228e-02f, 4.00165357e-02f, 8.45937878e-02f, -3.22276019e-02f, -9.91897583e-02f, -9.11107287e-02f, -7.65717179e-02f, 3.18260454e-02f, 8.19359720e-02f, -4.96884696e-02f,
  7.44063780e-02f, 8.64748135e-02f, -1.56922996e-01f, -5.11411019e-02f, -8.48945156e-02f, 1.09316921e-02f, -5.72426654e-02f, 7.16987252e-02f, 3.73257138e-02f, 5.42168282e-02f,
  7.39409551e-02f, 8.08390900e-02f, 6.43888339e-02f, 8.58367980e-03f, -1.69057250e-01f, -1.64167687e-01f, 9.53366682e-02f, 1.25240326e-01f, -1.21669464e-01f, -1.69650048e-01f,
  -1.38740996e-02f, -9.34679881e-02f, 3.02540325e-02f, -2.79075112e-02f, 5.82905672e-02f, -1.23562545e-01f, -1.43140703e-01f, 5.05096763e-02f, 1.67812202e-02f, 8.41027424e-02f,
  1.67074278e-01f, 8.67837295e-02f, 4.55948152e-03f, -7.65526071e-02f, -9.19006392e-02f, 2.39212811e-02f, -7.23139718e-02f, 1.71776369e-01f, 1.25041708e-01f, -1.56754255e-01f,
  5.51589951e-02f, 6.11580089e-02f, -5.57271503e-02f, -1.06355362e-01f, 5.05109690e-02f, -3.12417783e-02f, -5.40428832e-02f, -2.87514832e-02f, 5.38758114e-02f, -5.53984707e-03f,
  -3.27173434e-02f, -7.50946179e-02f, -3.60712558e-02f, 2.72618122e-02f, 1.02132864e-01f, -6.77805841e-02f, 1.16839655e-01f, -9.60272327e-02f, -5.51110283e-02f, -2.10223664e-02f,
  7.27260038e-02f, -4.33031693e-02f, 1.31985784e-01f, 7.64225423e-03f, 1.18141063e-02f, 1.68464586e-01f, 1.23632029e-01f, -1.65918902e-01f, 1.34976702e-02f, -8.63726661e-02f,
  -3.55136879e-02f, -1.05490789e-01f, -1.21462010e-02f, 1.11722909e-01f, 1.51094988e-01f, -1.45946741e-01f, 1.22223996e-01f, -1.39073595e-01f, -4.32441048e-02f, -7.08786994e-02f,
  2.59276330e-01f, 4.40128706e-02f, -9.35704932e-02f, 6.24385253e-02f, 7.07543865e-02f, -1.41533658e-01f, 1.40823394e-01f, -2.13014275e-01f, 1.56277478e-01f, 8.74571353e-02f,
  -9.41952765e-02f, -4.30368111e-02f, 7.20812008e-02f, -7.44350776e-02f, 1.28099725e-01f, -1.64124146e-01f, -2.06802562e-01f, -5.14223985e-02f, -9.35755000e-02f, 2.52680659e-01f,
  6.33211248e-03f, 6.11426793e-02f, -1.21215992e-01f, 1.06883004e-01f, -8.79062936e-02f, 1.23227136e-02f, -5.80475368e-02f, -5.54748299e-03f, -4.79259938e-02f, -1.02950819e-01f,
  -1.32284343e-01f, -2.84613296e-02f, 3.63913327e-02f, -4.43285890e-03f, 5.39011732e-02f, 1.37111545e-01f, -1.26646712e-01f, 8.80809501e-02f, -8.98052976e-02f, -1.29755542e-01f,
  9.15425792e-02f, 9.84059796e-02f, 1.04447208e-01f, -9.08218622e-02f, 1.37302786e-01f, 4.93544750e-02f, 9.53613408e-03f, 8.28898791e-03f, 7.16370121e-02f, 1.60441756e-01f,
  -6.54151067e-02f, 1.90524701e-02f, 6.04157597e-02f, -1.23053066e-01f, 1.13582565e-02f, -4.36279029e-02f, -8.62944499e-02f, -2.47516297e-02f, 7.21250847e-02f, -1.06896803e-01f,
  -1.67130485e-01f, 1.03650525e-01f, -1.08234987e-01f, 1.67385474e-01f, 8.66982937e-02f, 2.59696394e-02f, -1.98111147e-01f, 3.71469557e-02f, 2.25756206e-02f, 7.78353587e-02f,
  -4.24211398e-02f, -1.69486135e-01f, -5.29304557e-02f, 7.25634843e-02f, 2.79917456e-02f, 6.23745732e-02f, 7.84058869e-03f, -6.24386594e-02f, -1.41754970e-01f, -1.65981203e-01f,
  1.71671003e-01f, 1.76074877e-01f, -3.15245874e-02f, 1.39376484e-02f, 1.46438137e-01f, -1.02899343e-01f, -1.71042949e-01f, 8.12528357e-02f, 3.73471342e-02f, 3.57167535e-02f,
  -1.99506860e-02f, 2.10778266e-02f, 1.23230726e-01f, -7.08041117e-02f, 1.34549495e-02f, -6.03332520e-02f, 4.70327064e-02f, 8.89605954e-02f, 9.22349319e-02f, -1.01831652e-01f,
  -1.18056253e-01f, 5.38976267e-02f, -5.69502525e-02f, -2.25135423e-02f, -8.87641311e-02f, 9.41495374e-02f, 9.71019864e-02f, -6.92127496e-02f, -9.61595699e-02f, 8.24482441e-02f,
  -1.25612512e-01f, 4.40213829e-02f, -2.39972118e-02f, -1.65520772e-01f, 9.06341746e-02f, 2.28424259e-02f, 3.21244225e-02f, -1.21987447e-01f, 7.76669681e-02f, -9.73922983e-02f,
  -3.63820828e-02f, -5.21632433e-02f, -7.83158932e-03f, -5.10256104e-02f, -5.77609986e-02f, 7.52912387e-02f, 3.31603624e-02f, 5.64384125e-02f, -2.76314080e-01f, -7.95424730e-02f,
  1.48776621e-01f, 1.47649571e-01f, -1.54013485e-01f, -7.67643899e-02f, -1.63843393e-01f, -6.33911788e-02f, -1.41862005e-01f, 1.21023074e-01f, 1.00340649e-01f, 2.05916673e-01f,
  -2.55541243e-02f, -8.32405388e-02f, -3.05215921e-02f, -2.50759460e-02f, 1.76653683e-01f, 1.45022599e-02f, 7.97945336e-02f, -2.19350010e-01f, 1.12541139e-01f, -6.88068271e-02f,
  1.47726938e-01f, 3.42722461e-02f, 3.45855765e-02f, -1.27535984e-01f, -3.62605341e-02f, -3.24673988e-02f, 4.28955257e-02f, -1.11972414e-01f, 9.01162326e-02f, 1.25207556e-02f,
  1.18217044e-01f, 1.00565791e-01f, 7.85480079e-04f, 9.92214382e-02f, 5.69217056e-02f, -4.83607203e-02f, 4.03205166e-03f, -8.85784477e-02f, -2.27102675e-02f, -9.97387767e-02f,
  8.29292238e-02f, 2.93605104e-02f, -4.53914739e-02f, 1.53874055e-01f, -3.75051945e-02f, 1.62014753e-01f, -7.07449988e-02f, -3.43407653e-02f, 1.39910176e-01f, 8.14719126e-02f,
  1.07970290e-01f, 1.37457073e-01f, -8.11830685e-02f, -7.97529891e-02f, 8.78224075e-02f, 7.53720254e-02f, 1.10893831e-01f, 3.00335996e-02f, -6.75399825e-02f, 2.03199372e-01f,
  1.26645431e-01f, 5.30821607e-02f, -1.32105455e-01f, 4.42680009e-02f, -9.02091060e-03f, 8.21990371e-02f, -3.11024692e-02f, 1.56653523e-01f, 3.12851593e-02f, 5.54874428e-02f,
  4.85831592e-03f, 1.38352737e-01f, 1.47376701e-01f, 2.58303493e-01f, -1.21065930e-01f, 2.02661101e-02f, -1.78145215e-01f, 1.04860790e-01f, 1.57775193e-01f, -3.72334532e-02f,
  -6.93288967e-02f, 4.82691266e-02f, -2.09284872e-02f, -2.37133801e-01f, -8.35324526e-02f, 1.54941991e-01f, -1.18675008e-01f, 9.13580433e-02f, -1.27163380e-01f, -4.03656028e-02f,
  2.13220809e-02f, 4.56855074e-03f, 1.57183439e-01f, 8.14604834e-02f, 9.60176587e-02f, -3.91171016e-02f, 3.15341502e-02f, 1.25728101e-01f, -5.68798482e-02f, -3.15756164e-02f,
  -5.70916422e-02f, 9.26965475e-03f, -7.96879604e-02f, -2.81918794e-03f, 6.00458644e-02f, 2.27573421e-02f, -8.29668064e-03f, 1.24079622e-01f, -3.09482589e-02f, -2.51999646e-02f,
  2.30145035e-03f, 9.90348235e-02f, 4.84776497e-02f, 1.37191579e-01f, 1.23183884e-01f, 1.33993793e-02f, 3.00209560e-02f, -1.08559534e-01f, 4.75472212e-02f, 9.66784824e-03f,
  9.61784124e-02f, 1.08212568e-01f, -1.07643910e-01f, 1.28741801e-01f, 4.78098616e-02f, 1.56486303e-01f, -1.89823881e-01f, -2.96771876e-04f, -9.71229821e-02f, 8.83315280e-02f,
  -5.63594848e-02f, 4.28412110e-02f, -2.16946751e-02f, 8.14469010e-02f, -1.41941592e-01f, 1.06960192e-01f, 1.23862751e-01f, 1.68054342e-01f, -1.05961852e-01f, 1.25711977e-01f,
  -1.91284940e-01f, 1.34931207e-01f, 1.65143967e-01f, -8.84221718e-02f, -5.91789894e-02f, 2.44277474e-02f, 1.98773935e-01f, -6.03551492e-02f, 9.34339687e-03f, 1.23053968e-01f,
  -9.22744423e-02f, 8.78046677e-02f, 1.05802886e-01f, -2.54770983e-02f, -1.47156149e-01f, 7.50981718e-02f, -8.60990807e-02f, 5.57860807e-02f, -1.12572715e-01f, 3.39675248e-02f,
  -3.04136537e-02f, 1.37819454e-01f, 8.12552273e-02f, -9.49062929e-02f, 1.26029968e-01f, -2.19680443e-02f, -4.75119948e-02f, 5.58025725e-02f, -7.80596435e-02f, 1.03838585e-01f,
  -2.68392614e-03f, 1.16808712e-02f, 1.55935530e-02f, -6.51639253e-02f, -5.88804185e-02f, -3.08249379e-03f, -1.89836174e-02f, -6.44515380e-02f, 1.07264824e-01f, 7.71586448e-02f,
  -1.39100283e-01f, 7.67502189e-02f, -9.03670266e-02f, -5.39780669e-02f, -2.87773144e-02f, 5.45831434e-02f, 1.23725280e-01f, 5.47253862e-02f, 4.69951592e-02f, -1.39639512e-01f,
  -1.78530201e-01f, -1.49453714e-01f, -6.92158416e-02f, -1.20888889e-01f, -2.34100267e-01f, 5.54676875e-02f, -1.66000426e-01f, 1.88763723e-01f, -8.62295404e-02f, 1.39772609e-01f,
  4.70121764e-02f, 5.66256195e-02f, -1.57726794e-01f, 8.24709758e-02f, -1.80742636e-01f, 1.04096070e-01f, 8.70197546e-03f, -4.29807790e-02f, -3.52719687e-02f, -8.85056704e-02f,
  3.64156552e-02f, -7.96144679e-02f, 7.95905590e-02f, -4.94867712e-02f, -4.21333462e-02f, -7.50886053e-02f, -8.68487284e-02f, 1.04136452e-01f, 7.09717348e-02f, 1.56611279e-01f,
  1.36370480e-01f, -1.20475598e-01f, 7.63085186e-02f, 1.14384145e-01f, 1.18871868e-01f, -1.40183404e-01f, 1.07146524e-01f, -7.89715424e-02f, -9.21136066e-02f, 4.55848463e-02f,
  -3.41648869e-02f, -7.85387605e-02f, 8.48424733e-02f, -1.58457041e-01f, -2.91455872e-02f, -9.05861184e-02f, 4.18052636e-02f, -5.22962995e-02f, 8.96243751e-02f, 7.77795836e-02f,
  -3.54107171e-02f, -2.66788285e-02f, 7.72352843e-03f, -1.01398192e-01f, 3.88326831e-02f, -8.03483278e-02f, -7.00918287e-02f, -1.21510178e-01f, -9.47323069e-02f, 7.08035380e-02f,
  -6.23424910e-02f, -1.47498786e-01f, 1.69201326e-02f, 1.84076563e-01f, -1.01317085e-01f, 8.41743574e-02f, 1.64227441e-01f, -6.02358393e-02f, 1.15556866e-01f, -1.75102875e-01f,
  1.46131158e-01f, -6.22660555e-02f, 3.94748449e-02f, -1.15244910e-01f, -6.72409236e-02f, -1.56921804e-01f, 2.14070350e-01f, -1.59563959e-01f, 1.20260917e-01f, -2.14001797e-02f,
  8.04074109e-02f, 6.95940554e-02f, -5.93151711e-02f, -6.94338158e-02f, 1.08245440e-01f, 9.45680887e-02f, 2.25160252e-02f, -7.38387555e-02f, -4.74938452e-02f, -6.75573871e-02f,
  1.01516612e-01f, -1.19986176e-01f, 3.72671559e-02f, 3.33190374e-02f, 3.18697728e-02f, 3.15118022e-02f, 1.15614906e-01f, -1.05423324e-01f, -1.33208307e-02f, 2.80125625e-02f,
  8.69498923e-02f, 1.22777361e-04f, -1.05115339e-01f, 7.12779388e-02f, -1.35791004e-02f, -1.07448278e-02f, -1.51021928e-01f, 1.22565791e-01f, -2.58385856e-02f, 7.94695765e-02f,
  -4.70152684e-02f, -1.07343562e-01f, -1.42230466e-01f, -7.58419856e-02f, 2.33765841e-02f, -4.47249301e-02f, 6.72341213e-02f, 9.47261378e-02f, 5.46583049e-02f, 4.68124412e-02f,
  4.64471616e-02f, 7.38528296e-02f, -1.38384253e-01f, -8.49083718e-03f, -3.23752575e-02f, -1.60951197e-01f, -1.30467257e-02f, -5.27168177e-02f, -2.21768498e-01f, -1.18547283e-01f,
  5.75323366e-02f, -9.17675942e-02f, -1.82158291e-01f, 1.07417591e-01f, -1.48349911e-01f, 2.31702045e-01f, 1.76170617e-01f, 1.03209205e-01f, 1.65755883e-01f, -1.63187623e-01f,
  -9.76970717e-02f, 1.93673015e-01f, 1.30661232e-02f, 1.50429919e-01f, 7.01507495e-04f, -2.15634882e-01f, -1.24995507e-01f, -4.31167558e-02f, 1.31932631e-01f, 1.30703039e-02f,
  9.26466808e-02f, 3.26795131e-02f, 1.03643052e-01f, -8.50155652e-02f, 3.23173329e-02f, 1.01460688e-01f, 7.86666479e-03f, 5.31045049e-02f, -2.82776151e-02f, -1.17007025e-01f,
  9.96044651e-03f, -2.31118798e-02f, -3.64756361e-02f, -2.67264061e-02f, 5.45606464e-02f, 1.45500690e-01f, 5.98178916e-02f, -9.63071212e-02f, 1.73657797e-02f, 7.23169446e-02f,
  -1.27988905e-01f, 1.22819759e-01f, 4.80705611e-02f, -6.04832433e-02f, 2.77245920e-02f, 9.94975790e-02f, 1.43393442e-01f, -1.59282458e-03f, 1.06396146e-01f, -4.33655977e-02f,
  -2.69619562e-02f, 6.64572939e-02f, 6.67416975e-02f, 4.43699099e-02f, -8.59201327e-02f, -1.79573540e-02f, 6.14658035e-02f, -1.67448428e-02f, 1.43699825e-01f, -1.18508331e-01f,
  -1.39235780e-01f, -1.35471433e-01f, 8.74551013e-02f, -8.25936049e-02f, -1.01792015e-01f, -7.40417689e-02f, 9.01066735e-02f, 6.88105300e-02f, -8.56690779e-02f, 9.90924910e-02f,
  -7.29166493e-02f, 1.43684313e-01f, 7.63066933e-02f, 5.59497438e-03f, -5.25245368e-02f, -5.55179454e-02f, 9.84615907e-02f, -3.00876610e-03f, -2.15521306e-01f, -2.04057544e-02f,
  -2.95672957e-02f, 2.33926222e-01f, -1.38402879e-01f, 1.43841311e-01f, 1.07981905e-01f, 1.14720576e-01f, -1.84693970e-02f, -3.07349693e-02f, 3.76222096e-02f, 1.45787299e-02f,
  9.22157764e-02f, -1.58285275e-01f, -4.21321020e-02f, -5.58442138e-02f, 3.67685370e-02f, -1.23418048e-01f, 8.51822123e-02f, -6.96267486e-02f, 1.96816903e-02f, -4.45103236e-02f,
  -1.26977637e-01f, -5.24672084e-02f, -3.82777937e-02f, -5.79456724e-02f, -3.62394229e-02f, -3.25082056e-02f, 4.45362367e-03f, -6.58910871e-02f, -8.63663927e-02f, 2.09055152e-02f,
  -1.15410481e-02f, -1.20152213e-01f, 1.59175172e-01f, 1.24839477e-01f, 6.31818920e-02f, 1.44928517e-02f, -8.85336176e-02f, 4.55292268e-03f, 4.86285761e-02f, 4.96695489e-02f,
  2.75436845e-02f, 4.88013551e-02f, 7.49335214e-02f, -2.46212091e-02f, 3.35601509e-01f, 2.46322423e-01f, -3.41204286e-01f, -4.68769930e-02f, 1.91454381e-01f, -2.31394321e-02f,
  -1.73214570e-01f, -2.46992540e-02f, 3.78878266e-02f, -9.21898559e-02f, -1.31115779e-01f, 2.24895701e-01f, 1.46513015e-01f, 2.37151816e-01f, 1.03881776e-01f, -5.07727340e-02f,
  -1.61996022e-01f, 4.64381389e-02f, 2.54856497e-01f, -1.22081317e-01f, -3.69481668e-02f, -2.15066612e-01f, 2.22199872e-01f, -1.15344398e-01f, 1.58194914e-01f, 6.65300414e-02f,
  -1.35679722e-01f, -1.03943579e-01f, 6.96120504e-03f, 8.09532553e-02f, -1.72846597e-02f, -1.21120103e-01f, -7.80323967e-02f, 1.64901055e-02f, -6.59177676e-02f, 1.50996745e-01f,
  -1.06049590e-02f, 1.17839769e-01f, -1.03582665e-01f, 7.08795805e-03f, -8.23266059e-02f, 1.56534836e-01f, 8.52303877e-02f, -1.46133860e-03f, -7.49308318e-02f, 7.15954825e-02f,
  -7.40892217e-02f, -1.69350117e-01f, 2.99124848e-02f, -4.24642749e-02f, -9.32469964e-03f, 1.60894588e-01f, -1.38396308e-01f, -1.80002227e-01f, -1.33077428e-01f, 6.77718595e-02f,
  1.01992726e-01f, 9.54335108e-02f, -6.08413145e-02f, -5.47691993e-02f, 1.62550420e-01f, -1.05252720e-01f, 6.71304464e-02f, 4.50388454e-02f, -2.06666097e-01f, -1.85361981e-01f,
  3.04597408e-01f, 2.00527176e-01f, -1.39410123e-01f, -1.65966302e-01f, -6.97169751e-02f, -1.37989417e-01f, 1.19747231e-02f, -1.62130371e-01f, 9.61388345e-04f, 2.71586105e-02f,
  -2.47122459e-02f, -5.39337993e-02f, -2.00380743e-01f, -4.57952730e-02f, 7.13648135e-03f, -2.42254630e-01f, -1.51425734e-01f, -8.87577012e-02f, -4.13369155e-03f, 1.71330199e-01f,
  -1.79622352e-01f, 1.66984275e-02f, -3.21332365e-02f, -9.84558165e-02f, 7.72491796e-03f, 1.65180847e-01f, 1.49157912e-01f, -3.10178772e-02f, 5.39047085e-02f, -1.08502105e-01f,
  3.58715206e-02f, 3.65033448e-02f, -1.30731687e-01f, -7.19326660e-02f, -1.47889599e-01f, -6.67575896e-02f, 1.67996492e-02f, 4.07159552e-02f, 1.86787788e-02f, 4.90492582e-02f,
  -1.12529166e-01f, -7.21788481e-02f, -5.72926104e-02f, -3.92923243e-02f, 6.50147647e-02f, -1.52019531e-01f, -1.55629432e-02f, 4.91692722e-02f, 1.01866648e-02f, -4.40091826e-02f,
  -9.30555835e-02f, -9.96560231e-02f, -9.08456147e-02f, 1.80415437e-02f, -1.12213232e-02f, 5.63116409e-02f, -6.93980381e-02f, -1.47257090e-01f, -9.31502804e-02f, -3.28488532e-03f,
  1.80499479e-01f, -7.50869438e-02f, -9.20326486e-02f, 1.32005513e-02f, 8.44905153e-02f, 1.84007838e-01f, -1.50119886e-01f, -5.89059554e-02f, 1.67210147e-01f, -1.67604804e-01f,
  9.77196842e-02f, -2.36848205e-01f, -7.79428333e-02f, 5.05189374e-02f, -1.85565591e-01f, 5.29498123e-02f, 1.36636540e-01f, -7.38966241e-02f, 1.69395119e-01f, -2.49080732e-01f,
  -1.05027139e-01f, 1.13269523e-01f, -1.18600436e-01f, 1.40092522e-01f, -1.21776368e-02f, -3.02892498e-04f, -1.28023386e-01f, -7.40680844e-02f, 8.05107430e-02f, -1.24040479e-02f,
  2.04480141e-02f, 9.96027812e-02f, 1.15740284e-01f, -1.26278266e-01f, -5.07992767e-02f, 4.43033688e-02f, 1.18687540e-01f, 4.16001529e-02f, 7.25035090e-03f, -1.02775604e-01f,
  -5.22177331e-02f, 2.84590889e-02f, 5.26370145e-02f, -4.16716151e-02f, 7.57984668e-02f, 9.21954140e-02f, -1.07993372e-01f, 1.85829140e-02f, -6.31607920e-02f, -1.11269049e-01f,
  8.02042112e-02f, 2.18490511e-02f, -1.07092351e-01f, 9.63490680e-02f, 1.06724314e-01f, 5.73631264e-02f, -1.33530479e-02f, -1.05895206e-01f, -1.04065992e-01f, 9.63175297e-03f,
  -4.60087955e-02f, -8.15093368e-02f, 1.35529190e-01f, -1.69357117e-02f, 1.16019718e-01f, -8.87537748e-02f, 2.76650768e-02f, -2.91354558e-03f, -4.52449918e-02f, -2.47465316e-02f,
  6.95517212e-02f, 3.96416634e-02f, 8.45995769e-02f, -4.50752825e-02f, 2.57534161e-02f, -6.61249757e-02f, 7.69733340e-02f, -8.18259642e-02f, -2.87159476e-02f, -1.72802694e-02f,
  -4.23953170e-03f, 1.12294815e-01f, 1.18307158e-01f, 1.60258085e-01f, -1.78737521e-01f, -7.24462271e-02f, -1.73349436e-02f, -3.21793072e-02f, -3.57765518e-02f, -7.87955010e-04f,
  1.49276346e-01f, 1.86406088e-03f, -3.34090577e-03f, 2.30158214e-02f, 3.45501420e-03f, 5.72434403e-02f, 1.98688898e-02f, 9.55489725e-02f, -1.23487338e-01f, -8.94990712e-02f,
  -4.60775744e-04f, 2.33638678e-02f, -1.08720258e-01f, -1.44896805e-02f, 9.54109803e-03f, -1.51108846e-01f, -1.00491233e-02f, -1.22295842e-01f, -3.44632491e-02f, 7.77382478e-02f,
  -4.52471003e-02f, -2.97933538e-02f, -1.49372220e-01f, 5.46189435e-02f, 3.79902832e-02f, 5.45773171e-02f, -9.81826149e-03f, -2.41477005e-02f, 3.61146703e-02f, -1.63035635e-02f,
  -2.44410615e-02f, -9.92189422e-02f, -8.56085643e-02f, -6.94278702e-02f, -1.05979871e-02f, -6.34347796e-02f, 9.47330147e-02f, -6.51012361e-02f, 1.10392116e-01f, -7.02225640e-02f,
  3.02983145e-03f, -2.19159156e-01f, 1.66140348e-01f, -3.55209000e-02f, 7.88439810e-02f, -5.82462437e-02f, -1.54679239e-01f, -3.48123461e-02f, 4.73429486e-02f, 6.89206272e-02f,
  -5.65118343e-02f, -3.14706191e-02f, -3.34731452e-02f, -7.40158781e-02f, 4.04596590e-02f, -1.33682718e-03f, 1.74252957e-01f, 1.52645275e-01f, -1.65854514e-01f, -1.35532707e-01f,
  -5.41633330e-02f, 1.20743431e-01f, -1.10520035e-01f, -2.87372954e-02f, 9.66667086e-02f, -1.57844950e-03f, 3.82197909e-02f, -3.84791195e-02f, -2.05982123e-02f, -9.53841209e-02f,
  -1.25281051e-01f, -1.08612508e-01f, -5.51394671e-02f, -8.43990222e-02f, -2.22540256e-02f, -9.77592636e-03f, 1.35912187e-02f, 9.36793834e-02f, -7.94914812e-02f, -5.63303567e-02f,
  -4.45007626e-03f, 1.35852218e-01f, -4.67844419e-02f, 6.04966916e-02f, -1.12546265e-01f, 7.01875091e-02f, -1.52860850e-01f, 4.48356010e-02f, 1.69604085e-02f, -1.56194538e-01f,
  8.94152224e-02f, 6.45354092e-02f, -1.69657946e-01f, -7.73911327e-02f, -2.42364615e-01f, -8.40740874e-02f, -1.52546152e-01f, -1.53307125e-01f, -1.53733030e-01f, 1.15058735e-01f,
  -4.69751544e-02f, -1.32912800e-01f, 2.28175655e-01f, -1.94074795e-01f, -7.08113611e-02f, -1.05423793e-01f, 1.31285727e-01f, -1.01228021e-01f, 1.27536833e-01f, -9.75759178e-02f,
  -1.91593736e-01f, -1.49358332e-01f, -6.50561601e-02f, -5.48824370e-02f, 1.66989312e-01f, -5.88856079e-02f, -1.35780886e-01f, 2.51918528e-02f, 1.62312109e-02f, 1.37706354e-01f,
  2.64804512e-01f, 2.31529269e-02f, -1.53958261e-01f, -1.37962535e-01f, -9.53559726e-02f, 1.41699314e-01f, -1.79219142e-01f, 1.46522656e-01f, 1.23595551e-01f, -1.45300701e-01f,
  1.18422821e-01f, 1.04226902e-01f, -9.31248814e-02f, -1.22806028e-01f, 5.90391681e-02f, -4.96150181e-02f, -5.70790321e-02f, -3.07171065e-02f, -1.24941014e-01f, 1.09362498e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -4.95913206e-03f, 7.15333894e-02f, -9.83237699e-02f, 2.45123699e-01f, 2.34526373e-03f, -1.25814406e-02f, 1.78970248e-01f, 1.60257399e-01f, -5.38421571e-02f, 5.84886968e-02f,
  1.82566091e-01f, 5.73795140e-02f, -3.70498635e-02f, 1.42636523e-01f, 1.14826120e-01f, 1.16538376e-01f, -3.54726822e-03f, 7.17845261e-02f, -4.70721275e-02f, 1.14377894e-01f,
  1.38223514e-01f, 1.74841210e-01f, -1.27157988e-02f, 5.67300506e-02f, 2.56082416e-03f, 5.97715238e-03f, 3.17025892e-02f, 1.65384948e-01f, 1.05048090e-01f, 1.85635164e-01f,
  -4.75828238e-02f, 1.91149533e-01f, -1.21023320e-01f, 1.17474727e-01f, 2.15682849e-01f, -1.57821223e-01f, 1.53355017e-01f, -1.86242446e-01f, 9.25769750e-03f, 1.03103466e-01f,
  7.44901896e-02f, 2.67495066e-01f, 1.39655769e-02f, -2.32473180e-01f, -1.90159649e-01f, -1.95211560e-01f, 2.00180486e-01f, -1.06674433e-02f, -8.16778615e-02f, 3.71651389e-02f,
  1.16348259e-01f, 7.48087391e-02f, -1.10412901e-02f, 1.97018951e-01f, -1.39020920e-01f, 1.54727221e-01f, -6.49856329e-02f, -3.29472572e-02f, -3.94047312e-02f, -2.25456972e-02f,
  -8.11988395e-03f, -2.07133647e-02f, -1.16545253e-01f, 5.79220429e-02f, 6.27411678e-02f, -2.45943610e-02f, 1.54931964e-02f, -1.26249954e-01f, -8.08919873e-03f, 7.17332810e-02f,
  7.24202991e-02f, 1.10901520e-01f, 7.28445426e-02f, 1.25385642e-01f, -1.10673845e-01f, -4.40924540e-02f, 1.30717173e-01f, -1.51421688e-02f, 3.89840938e-02f, 1.57706246e-01f,
  4.30428162e-02f, -3.12774740e-02f, -7.59997740e-02f, 3.56689468e-02f, 8.88993219e-02f, 7.44497553e-02f, 1.29101425e-01f, -1.20374903e-01f, 1.06479898e-01f, -8.83354321e-02f,
  -1.59837529e-01f, 3.62499664e-03f, -2.67490804e-01f, 5.82436398e-02f, 1.36051655e-01f, 1.64699540e-01f, -6.63497392e-03f, -1.68434754e-01f, 1.95616633e-01f, 5.51211387e-02f,
  1.23640932e-01f, 1.29764184e-01f, 3.14297117e-02f, -1.36274740e-01f, -9.65232328e-02f, -2.65247107e-01f, -1.04962878e-01f, 3.30540650e-02f, 5.11825942e-02f, 7.63524696e-02f,
  1.03358310e-02f, 1.87170357e-01f, 1.58470005e-01f, 5.02273776e-02f, -7.13251680e-02f, 2.09154114e-01f, -1.11432321e-01f, -7.59982467e-02f, 7.33612701e-02f, 1.17186502e-01f,
  -3.87689471e-02f, -8.54709521e-02f, 2.04780474e-01f, 1.33435056e-01f, 8.97293165e-02f, -4.55563106e-02f, 3.96003909e-02f, -1.16746239e-01f, 1.63915068e-01f, 1.09417237e-01f,
  2.17888445e-01f, -8.93266872e-03f, -2.28072144e-02f, 9.84065011e-02f, 7.98426419e-02f, 4.87771183e-02f, 1.26773879e-01f, 1.15817152e-01f, 2.28088558e-01f, 5.55002466e-02f,
  1.81426078e-01f, 7.86884651e-02f, 1.77172363e-01f, 3.49709578e-02f, -6.93383738e-02f, 2.35132456e-01f, -2.40396359e-03f, 4.53581959e-02f, 1.73521832e-01f, 1.20570295e-01f,
  5.92631325e-02f, 1.10222153e-01f, 4.44612093e-02f, 1.15150906e-01f, -3.88521068e-02f, -1.55427143e-01f, -8.55398178e-02f, 7.66918138e-02f, 3.76788676e-02f, -4.22984734e-02f,
  2.67644495e-01f, 1.12971338e-02f, 3.47625911e-01f, -2.55862653e-01f, 2.09773064e-01f, -2.99444646e-02f, 3.26972425e-01f, -1.79754212e-01f, 9.62175950e-02f, -3.22510451e-01f,
  2.84191757e-01f, -1.48524135e-01f, 1.59822986e-01f, 1.60369985e-02f, -1.82458416e-01f, 3.09532546e-02f, -3.43390042e-04f, -1.28635302e-01f, 4.01963443e-02f, 5.99617362e-01f,
  -5.04419953e-02f, -1.10948205e-01f, 1.92399547e-01f, 1.13529958e-01f, 9.75976214e-02f, -1.97170347e-01f, 2.51274377e-01f, 9.77820717e-04f, 1.20749709e-03f, -5.95612451e-02f,
  1.22558810e-01f, -1.35358926e-02f, 3.08760367e-02f, -7.49703199e-02f, -4.89216950e-03f, 8.93598422e-02f, -8.39473531e-02f, -3.30373272e-02f, 8.62200453e-04f, 4.10117656e-02f,
  -7.16853961e-02f, -1.34846419e-02f, 5.87977022e-02f, 3.97124738e-02f, 1.13264725e-01f, -9.02012736e-02f, 1.37676045e-01f, 3.98449264e-02f, -7.24277049e-02f, -9.35194492e-02f,
  1.25768915e-01f, -4.92624789e-02f, 2.37813555e-02f, -3.07074133e-02f, 6.15977831e-02f, 7.00463578e-02f, 7.21093193e-02f, 6.78290427e-02f, 1.25222743e-01f, -1.21206909e-01f,
  1.17198735e-01f, 1.27808094e-01f, -5.20925969e-02f, 1.83015130e-02f, 4.17797342e-02f, -8.87767971e-02f, -1.03069311e-02f, -9.73517299e-02f, -1.19838968e-03f, -1.11077413e-01f,
  -3.53740640e-02f, 1.31779090e-01f, 4.26449027e-04f, 6.27836511e-02f, -2.30420125e-03f, 5.42027168e-02f, -6.35315105e-02f, 1.00735232e-01f, -6.00042567e-02f, 7.98649937e-02f,
  -2.55660433e-02f, -2.07758546e-02f, 2.63155233e-02f, -6.25578389e-02f, 3.05554806e-03f, 1.69111323e-02f, -5.63218407e-02f, 6.21161275e-02f, -7.99757149e-03f, -2.89060641e-02f,
  8.64213929e-02f, -9.09351092e-03f, -3.49003375e-02f, -1.18400194e-01f, -1.15321830e-01f, 9.21496004e-02f, 1.14009619e-01f, -1.74899809e-02f, -1.22487545e-02f, -9.54852626e-02f,
  -1.18305415e-01f, 1.06480643e-01f, -8.78628436e-03f, -1.18606336e-01f, -3.66229601e-02f, -3.77588160e-02f, 6.64221123e-03f, -6.03374653e-03f, 9.54492241e-02f, 9.75027010e-02f,
  -8.31785500e-02f, -7.55932480e-02f, 2.40632817e-02f, -1.01220116e-01f, 2.18987912e-02f, -4.28676344e-02f, 2.29581501e-02f, -5.53591736e-02f, -6.17439188e-02f, 4.49221805e-02f,
  -1.20644204e-01f, -1.25461221e-01f, 6.91246465e-02f, 1.05234288e-01f, -1.54657466e-02f, 1.38737829e-02f, -9.93310213e-02f, -6.17760047e-02f, 9.65693966e-02f, 2.18609571e-02f,
  7.28871152e-02f, -2.38306783e-02f, 2.39927205e-03f, -9.28553715e-02f, 1.00251185e-02f, 5.96795343e-02f, -7.86259025e-02f, -3.65488827e-02f, -1.32893234e-01f, -6.70354515e-02f,
  -3.89353707e-02f, -6.29098117e-02f, 4.52570580e-02f, -1.29307434e-01f, -1.25883073e-01f, -9.22752917e-02f, -5.53624704e-02f, 4.34809886e-02f, -3.90252918e-02f, 6.91554137e-03f,
  1.00956656e-01f, 8.47495645e-02f, -1.10296838e-01f, -2.31435690e-02f, -4.87442724e-02f, 6.62979409e-02f, 3.62926982e-02f, -7.69910216e-03f, 9.02302414e-02f, -4.66900058e-02f,
  1.97013080e-01f, 1.27374930e-02f, 2.34038144e-01f, 6.73144534e-02f, 4.73442823e-02f, 1.06344566e-01f, 1.74399093e-01f, 7.66848549e-02f, 1.01015240e-01f, 2.44306698e-01f,
  -1.18592149e-02f, 2.35226408e-01f, 1.66078843e-02f, 9.00323763e-02f, 1.23337448e-01f, 7.50999972e-02f, 2.48289213e-01f, 1.61997721e-01f, 1.07337318e-01f, 1.00592919e-01f,
  -9.86978486e-02f, 9.35636535e-02f, 1.69418633e-01f, 1.90564021e-01f, -3.09628434e-02f, -1.36159122e-01f, 6.98085278e-02f, -1.00896940e-01f, 3.50303590e-01f, -8.89180303e-02f,
  -4.51239347e-01f, -1.27420560e-01f, 4.98687699e-02f, 1.49212167e-01f, -2.16668919e-01f, 1.98225185e-01f, -2.67075211e-01f, 1.42448723e-01f, -3.97319272e-02f, 3.28679442e-01f,
  1.06011413e-01f, 4.34074439e-02f, -1.13633960e-01f, 2.57729173e-01f, -1.50026362e-02f, 2.77389497e-01f, 4.26918864e-02f, -2.24722773e-01f, -4.45940383e-02f, -1.19083203e-01f,
  3.44921738e-01f, -1.37228936e-01f, 8.96841846e-03f, 1.85515031e-01f, 8.24539587e-02f, -1.55172482e-01f, -5.89143448e-02f, 1.07930861e-01f, -1.52756482e-01f, 1.67472109e-01f,
  -7.10248277e-02f, -1.32895857e-01f, -7.39457831e-02f, 2.81923980e-01f, -7.48473108e-02f, 1.30980656e-01f, -4.57688533e-02f, -1.19940735e-01f, 6.31258562e-02f, -1.43932914e-02f,
  3.07524987e-02f, -1.11402616e-01f, 1.25591061e-03f, -2.06394736e-02f, -7.15127736e-02f, -7.14999530e-03f, 1.48804542e-02f, 6.30748346e-02f, -6.41768277e-02f, 6.88970834e-02f,
  -8.77863988e-02f, -1.18193857e-01f, 1.24551319e-01f, -9.55933779e-02f, -1.09025471e-01f, 7.36483112e-02f, 7.81995952e-02f, -9.36538577e-02f, -1.38615211e-02f, 9.29228291e-02f,
  9.34820175e-02f, 1.04201682e-01f, 4.70733410e-03f, -4.65942547e-02f, 1.73621941e-02f, -8.25034901e-02f, -6.94229230e-02f, -1.30378529e-01f, 6.39119223e-02f, 3.06940284e-02f,
  -2.39130165e-02f, -3.98602746e-02f, -2.93459967e-02f, 1.02138691e-01f, 2.09990679e-03f, 7.13303015e-02f, -5.35610281e-02f, 1.11643560e-01f, 1.84001355e-03f, 2.29719542e-02f,
  -1.32902652e-01f, 4.01700288e-02f, 1.08449131e-01f, 8.16816390e-02f, -3.79495719e-03f, 9.56870019e-02f, 3.20680737e-02f, 1.14316465e-02f, 1.35531306e-01f, 1.45604044e-01f,
  3.30929607e-02f, -3.36003229e-02f, 1.28331974e-01f, -2.69249268e-02f, 8.84068087e-02f, 6.17925171e-03f, -3.01552806e-02f, -5.06099425e-02f, 1.01092115e-01f, -3.99087854e-02f,
  1.15850754e-02f, 2.00091992e-02f, 1.31971508e-01f, -3.34094986e-02f, -7.17931390e-02f, 2.02577002e-02f, -9.37631652e-02f, 2.67364904e-02f, -6.84487894e-02f, 1.60926394e-02f,
  -1.03611937e-02f, -3.25862058e-02f, -4.33532260e-02f, 1.34538621e-01f, -9.62035134e-02f, 1.10170115e-02f, 7.95411319e-02f, 1.02804653e-01f, -5.44413039e-03f, 9.84282717e-02f,
  -5.47151938e-02f, 1.53096005e-01f, 2.21404172e-02f, -9.13124681e-02f, 1.33874223e-01f, 4.72099781e-02f, -1.22277021e-01f, -1.32883519e-01f, -3.19798701e-02f, -9.80651304e-02f,
  9.64628980e-02f, -1.09395847e-01f, -1.00985594e-01f, 1.40559763e-01f, -1.11773387e-01f, 2.97165290e-02f, 1.26305133e-01f, 6.12394400e-02f, -7.07786232e-02f, -5.24327382e-02f,
  -9.13632214e-02f, 1.51596116e-02f, -6.08470365e-02f, 1.15766846e-01f, -2.02069408e-04f, 5.84708638e-02f, 2.81780828e-02f, -2.41331942e-02f, 1.31919552e-02f, -9.11776423e-02f,
  5.31010032e-02f, 1.14317253e-01f, -3.29499952e-02f, 6.35249391e-02f, -1.15702666e-01f, 3.54130119e-02f, -6.91876113e-02f, -7.84061328e-02f, -1.05389483e-01f, -2.74676681e-02f,
  4.65727933e-02f, -2.88812220e-02f, 4.53144722e-02f, -6.87709078e-03f, -1.23161748e-01f, -1.67476591e-02f, -9.47985798e-02f, 6.93527162e-02f, 1.65727008e-02f, 4.57095802e-02f,
  9.99659002e-02f, 7.87518173e-02f, 7.19771907e-03f, -8.99037123e-02f, -9.23735425e-02f, -7.67318010e-02f, 2.18943916e-02f, 1.40405476e-01f, 7.08362088e-02f, 7.56478012e-02f,
  1.07136499e-02f, 3.12090572e-02f, 1.23795703e-01f, -1.06699336e-02f, -7.35718086e-02f, 1.06536604e-01f, -1.19175846e-02f, 7.27402121e-02f, -8.86536017e-02f, -7.24889487e-02f,
  2.15672273e-02f, 4.20189463e-02f, -2.64701881e-02f, 7.20790178e-02f, -1.32214218e-01f, 3.33288573e-02f, 5.72695173e-02f, 1.47200124e-02f, -7.43156001e-02f, -1.88002735e-02f,
  -8.05854797e-02f, 1.33973688e-01f, -1.08232252e-01f, 1.00680783e-01f, 3.87511998e-02f, -5.94003871e-02f, -1.17278799e-01f, 8.39414373e-02f, -8.60128738e-03f, -8.74120891e-02f,
  -1.11736253e-01f, 1.06228165e-01f, 1.54702133e-02f, 3.13796513e-02f, 7.61152431e-02f, 1.57521054e-01f, 5.12019470e-02f, 5.95570058e-02f, -1.20695300e-01f, 5.83456308e-02f,
  5.96766509e-02f, -6.87049627e-02f, 1.36621088e-01f, -1.13627492e-02f, -8.16000849e-02f, 1.27278611e-01f, 1.82375968e-01f, -4.15943302e-02f, 1.99089527e-01f, 5.83086684e-02f,
  -6.17323220e-02f, 7.38315731e-02f, 1.14008456e-01f, 7.40420222e-02f, -5.10931388e-02f, -8.30200166e-02f, 1.69326916e-01f, 9.09617767e-02f, 1.43871875e-02f, 3.63999680e-02f,
  4.45987247e-02f, 1.47242129e-01f, 1.05953358e-01f, 1.88801274e-01f, -3.79836895e-02f, 2.13042311e-02f, 2.81612705e-02f, -6.20361902e-02f, -2.45855711e-02f, 2.03236684e-01f,
  7.94205070e-03f, -3.06679513e-02f, 6.31630868e-02f, -1.92162991e-01f, 2.05191091e-01f, 2.26529881e-01f, 3.33213620e-03f, -8.10594007e-04f, 1.79600120e-01f, -6.04761504e-02f,
  1.72157019e-01f, -2.93211788e-01f, 1.36759445e-01f, -1.32088453e-01f, -3.67720611e-02f, -2.16126628e-02f, -2.37249769e-02f, -7.28695318e-02f, 3.53619196e-02f, -2.20539868e-01f,
  -7.74568617e-02f, -5.90883270e-02f, -1.44572228e-01f, 1.25627264e-01f, -1.04371227e-01f, 3.79569605e-02f, 7.72987725e-03f, 1.54533342e-01f, -1.20899864e-01f, 1.84853345e-01f,
  -5.74550033e-02f, 1.11435369e-01f, -1.14753976e-01f, -1.10416688e-01f, -1.07675508e-01f, -6.85651675e-02f, -1.63006693e-01f, -1.25242367e-01f, 8.20024312e-02f, -3.46086104e-03f,
  -5.67880422e-02f, 1.25427827e-01f, -1.09087788e-01f, -1.29534295e-02f, 1.63490549e-01f, -8.87279660e-02f, 1.52586013e-01f, -5.75531013e-02f, 1.82461873e-01f, 1.39687493e-01f,
  -1.48259357e-01f, -3.28623429e-02f, 1.04302563e-01f, 1.15502216e-01f, 1.99091118e-02f, 4.25049476e-02f, 8.48557502e-02f, -4.62393947e-02f, 2.86078284e-04f, -8.97329003e-02f,
  1.85471505e-01f, 1.55496299e-01f, 1.37832120e-01f, 1.05062157e-01f, 1.85763776e-01f, 6.48425613e-03f, 1.13964759e-01f, 2.76048183e-01f, -2.15976477e-01f, -2.92902321e-01f,
  3.29252899e-01f, 6.91491589e-02f, -2.66233712e-01f, -2.41849329e-02f, -6.07827567e-02f, 2.64961571e-01f, -1.28562097e-02f, -1.44856855e-01f, -1.92623474e-02f, 1.13215946e-01f,
  3.94660309e-02f, 9.28799063e-02f, -2.98169076e-01f, 3.49655971e-02f, -1.88344680e-02f, -7.02468455e-02f, -2.94857360e-02f, -9.60895494e-02f, 8.00063685e-02f, 1.40128329e-01f,
  -4.74192239e-02f, -2.24372476e-01f, 4.47244793e-02f, 1.08489320e-02f, -5.51061854e-02f, 6.01933785e-02f, 1.05291925e-01f, 1.78991005e-01f, 1.66305467e-01f, -7.29194582e-02f,
  -6.04011258e-03f, 1.06780417e-01f, 4.19187509e-02f, -1.01374276e-01f, -1.18226580e-01f, 8.00379217e-02f, 3.33881266e-02f, -1.82073396e-02f, 2.08161138e-02f, -9.46932808e-02f,
  1.20819457e-01f, 9.68906656e-02f, -5.91569506e-02f, -1.15450881e-01f, 1.38072511e-02f, 8.50838423e-02f, 6.67590350e-02f, -8.60835090e-02f, -3.32687721e-02f, -3.40280496e-02f,
  -4.91905622e-02f, -1.17536172e-01f, -9.83810648e-02f, -1.08452104e-01f, -6.56236261e-02f, -3.05649992e-02f, 2.62863673e-02f, 1.03202999e-01f, 1.18694060e-01f, -5.90177141e-02f,
  1.16159506e-01f, 7.83029422e-02f, 1.14479348e-01f, 1.37542309e-02f, -1.09837372e-02f, 2.04566140e-02f, -4.84821387e-02f, 3.08210608e-02f, 2.74914894e-02f, -9.80413035e-02f,
  -5.88133112e-02f, 1.24480650e-02f, -8.96618178e-04f, -1.03887990e-01f, 9.30506140e-02f, -4.04286794e-02f, -2.48240884e-02f, -9.36024711e-02f, -5.56838363e-02f, 1.15832679e-01f,
  -2.30099112e-02f, 5.40319122e-02f, -1.13471106e-01f, 4.77209315e-02f, 8.37365389e-02f, 3.63722513e-03f, 1.35425001e-01f, 7.42963180e-02f, -9.03638303e-02f, -8.61790851e-02f,
  -1.23169586e-01f, -6.83983341e-02f, 3.95664908e-02f, 7.99307376e-02f, 1.78349651e-02f, 4.72843908e-02f, 6.59518316e-02f, 2.14353148e-02f, -6.97413832e-02f, -2.54436694e-02f,
  -2.35554334e-02f, 2.00577244e-01f, 1.58890128e-01f, 2.71830633e-02f, 6.99319690e-02f, -3.81062776e-02f, -1.02997506e-02f, 8.82411897e-02f, -6.94297487e-03f, 5.68155386e-02f,
  1.88753251e-02f, 1.17845722e-01f, 1.03226863e-01f, 1.39946267e-01f, 2.59287432e-02f, -1.13339694e-02f, -1.16505668e-01f, 1.54180065e-01f, 3.12552974e-02f, -6.86224774e-02f,
  4.93035652e-02f, 1.61294892e-01f, 1.15137637e-01f, -2.03365311e-01f, 2.60396630e-01f, -2.25717470e-01f, 9.92552340e-02f, -2.58683208e-02f, -1.13271398e-03f, 5.64308092e-02f,
  -8.55854452e-02f, -3.71216424e-02f, -1.38640478e-02f, 2.31694691e-02f, 1.39971981e-02f, -8.50142259e-03f, 2.02612892e-01f, 6.98517933e-02f, 7.62832835e-02f, -5.50596341e-02f,
  7.58136362e-02f, -7.84663931e-02f, 1.30490080e-01f, 2.71126460e-02f, -1.15149245e-01f, -2.15444580e-01f, 1.98252825e-03f, 7.46463239e-02f, -6.80143237e-02f, 2.73295075e-01f,
  1.42985329e-01f, 9.52246115e-02f, 1.68171197e-01f, -1.58135640e-03f, 1.14768468e-01f, 1.69757660e-02f, -6.18180148e-02f, -2.98729558e-02f, -3.24756950e-02f, 6.45526722e-02f,
  -4.29407023e-02f, -1.14797816e-01f, 1.31684765e-01f, 6.86124116e-02f, 7.92778581e-02f, -3.74889895e-02f, -5.09478860e-02f, -9.57936198e-02f, -1.24780675e-02f, 6.18547015e-02f,
  1.39916778e-01f, 1.21580712e-01f, -7.10398108e-02f, 6.95848651e-03f, 6.66465387e-02f, 1.57087401e-01f, 3.10837198e-02f, -5.87455593e-02f, 1.58994719e-01f, -1.83496196e-02f,
  9.87614412e-03f, -5.41053116e-02f, 1.18105806e-01f, 5.58433793e-02f, 1.36881724e-01f, -2.94685401e-02f, 9.02800262e-02f, 1.34474754e-01f, -4.30567153e-02f, 1.39701322e-01f,
  -9.53622386e-02f, 4.13947701e-02f, 3.01836454e-03f, 1.82190582e-01f, -1.01567827e-01f, 8.70706514e-02f, 1.09249614e-01f, 5.73104806e-02f, -2.34992318e-02f, -7.10551962e-02f,
  3.80008183e-02f, 4.41735797e-02f, 6.30814433e-02f, 6.97383359e-02f, 6.33067042e-02f, -1.46683082e-01f, 1.66721772e-02f, -1.29948240e-02f, -7.22840894e-03f, 1.69202313e-01f,
  8.30555633e-02f, -1.14285856e-01f, -6.72004521e-02f, -4.20738161e-02f, 5.73679954e-02f, -3.58934812e-02f, -4.02259044e-02f, -1.15802679e-02f, -2.36301590e-02f, 2.20367536e-02f,
  -5.30145243e-02f, 6.66088015e-02f, 9.16402191e-02f, -9.34986174e-02f, -5.28328121e-02f, 1.09780058e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.10914737e-01f, -6.22447245e-02f, 2.24747792e-01f, 1.68065727e-02f, 1.09386898e-03f, 1.26378715e-01f, -5.01896590e-02f, -2.86483974e-03f, -5.23507483e-02f, 1.38571203e-01f,
  6.64890036e-02f, 7.46702328e-02f, 1.41013801e-01f, 1.38578966e-01f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -2.60425359e-01f, -8.13745707e-02f, -1.44105226e-01f, -1.36801511e-01f, -1.02507584e-01f, 2.88855266e-02f, 2.78390478e-02f, -7.42453262e-02f, -3.91918905e-02f, 7.06622899e-02f,
  -1.55669674e-01f, 2.15447936e-02f, 4.99620624e-02f, -1.19267166e-01f, -1.65776268e-01f, -1.06580295e-01f, 1.40921613e-02f, -9.31839421e-02f, 1.34823665e-01f, 6.08354360e-02f,
  -6.19676299e-02f, -1.74375623e-01f, 6.52632713e-02f, -1.33430436e-01f, -2.05029786e-01f, -1.42180681e-01f, 1.25945717e-01f, 1.30435042e-02f, -4.62179305e-03f, -2.44153082e-01f,
  6.84914812e-02f, -3.54118906e-02f, -8.03345144e-02f, 6.04653060e-02f, -1.70416906e-01f, -1.96881086e-01f, 1.62158191e-01f, 2.31713966e-01f, 1.00488774e-01f, 1.81334168e-01f,
  1.12740904e-01f, 6.71520755e-02f, 5.26397116e-02f, -8.57747868e-02f, 2.57756293e-01f, -2.54536867e-01f, -1.33563682e-01f, -1.21858180e-01f, -6.64362609e-02f, -2.20817164e-01f,
  -4.23291326e-03f, -1.62730649e-01f, -7.99605399e-02f, -6.19180873e-02f, 3.70716415e-02f, 2.78832138e-01f, 5.30315097e-03f, -5.62257431e-02f, 9.00109336e-02f, 5.48666902e-02f,
  -1.73994690e-01f, 5.51485084e-03f, -9.76361483e-02f, 7.25050122e-02f, 1.76297233e-01f, -8.53108019e-02f, 4.09670323e-02f, -2.82548387e-02f, 2.30556488e-01f, 1.45907491e-01f,
  -7.79007748e-02f, 1.73967019e-01f, 7.82410894e-03f, 1.66918814e-01f, -2.63878871e-02f, 1.12698652e-01f, 1.70608208e-01f, 6.42581051e-03f, 1.58174112e-01f, 2.23299503e-01f,
  -1.39892280e-01f, 1.15147740e-01f, 1.17082186e-01f, 1.25162918e-02f, -8.63852277e-02f, 8.79269000e-03f, -5.19580826e-05f, 1.61244765e-01f, 9.40671265e-02f, -2.91095883e-01f,
  -1.15750298e-01f, 2.34211460e-01f, 8.94965529e-02f, 3.23302578e-03f, -2.27434207e-02f, -1.44301638e-01f, -1.32958859e-01f, 5.29277660e-02f, 6.88837543e-02f, -9.17200670e-02f,
  -1.23025410e-01f, 7.78218964e-03f, 2.36658633e-01f, 1.42949775e-01f, 1.58193514e-01f, -4.83670123e-02f, 1.99290290e-01f, 1.22314185e-01f, 4.10159267e-02f, 1.86538324e-02f,
  -2.72486895e-01f, -1.09101303e-01f, 2.58182045e-02f, -2.23267153e-01f, -6.40342236e-02f, -1.41655758e-01f, -1.37284324e-01f, -1.27744213e-01f, -4.67000576e-03f, 2.45948985e-01f,
  9.45862308e-02f, 1.48375139e-01f, 5.45249097e-02f, -1.62436217e-01f, 1.06752396e-01f, 3.96492779e-02f, -1.02637680e-02f, -6.95295706e-02f, 3.71963307e-02f, 6.17519654e-02f,
  5.60773946e-02f, 4.46776971e-02f, -8.46459717e-02f, -1.44224241e-01f, -2.09952667e-02f, 3.49743888e-02f, -5.86766982e-03f, -9.25118551e-02f, -2.24080890e-01f, 3.83515358e-02f,
  -6.93220422e-02f, -1.32072151e-01f, -1.14529066e-01f, -6.13559000e-02f, 1.03303403e-01f, -1.73217803e-01f, -7.74090439e-02f, 1.25691947e-02f, -1.47888184e-01f, -1.62264094e-01f,
  -5.34735657e-02f, -1.01810239e-01f, -5.47926463e-02f, -5.80418967e-02f, -2.19882935e-01f, 9.98315737e-02f, 5.09074889e-04f, 7.75515363e-02f, 1.40763670e-01f, 1.27636492e-01f,
  1.79245383e-01f, 1.47862047e-01f, -7.84910247e-02f, -1.51437193e-01f, -1.36187941e-01f, 1.58933744e-01f, -3.90891358e-02f, 1.61298275e-01f, 9.25292447e-02f, 2.94254348e-02f,
  2.62363851e-01f, 9.54117551e-02f, 2.07271099e-01f, -2.52300650e-01f, -1.54819071e-01f, 6.61131814e-02f, 1.09671019e-01f, -7.71679878e-02f, 6.79978123e-03f, -3.66613045e-02f,
  -7.64571279e-02f, -9.79898218e-03f, -1.05446659e-01f, 3.14717233e-01f, -9.25611779e-02f, 5.46501623e-03f, -4.69351448e-02f, -1.58217978e-02f, -2.88985997e-01f, -1.97455715e-02f,
  2.95205880e-02f, -3.34497765e-02f, 2.07756995e-03f, 1.00410357e-01f, 3.80389914e-02f, -6.58485368e-02f, -3.75828929e-02f, 6.15108199e-02f, -6.63934350e-02f, -1.05291396e-01f,
  -2.83108465e-02f, 5.33875488e-02f, 1.28462836e-01f, -2.72562448e-02f, 7.89823979e-02f, 3.13181023e-04f, -9.91898328e-02f, -1.05835451e-02f, 1.17716797e-01f, 1.19307712e-01f,
  -2.00677104e-02f, -9.84675623e-03f, 9.30566341e-02f, 5.87542169e-02f, 1.04844727e-01f, -1.02424823e-01f, 5.33444472e-02f, 1.08247176e-02f, 1.65789932e-01f, -2.09795207e-01f,
  -4.20553796e-02f, 2.28049248e-01f, 4.41197380e-02f, -2.55257580e-02f, 1.37640670e-01f, -2.64220405e-03f, 8.43673050e-02f, 1.75256968e-01f, 5.90616167e-02f, -1.76981837e-01f,
  -2.20538452e-01f, -3.98411527e-02f, -2.11774036e-01f, 1.88290000e-01f, -7.85721093e-02f, -2.58526579e-02f, -3.50274779e-02f, 7.03563765e-02f, 6.50688559e-02f, -1.34679720e-01f,
  -1.57662600e-01f, -7.75896385e-02f, 1.14229605e-01f, 1.59057572e-01f, 2.64673263e-01f, 7.74290115e-02f, -8.79018456e-02f, -3.11339617e-01f, -6.75863922e-02f, -8.99381936e-03f,
  3.71360481e-02f, 5.15386686e-02f, -1.22400984e-01f, -4.31791358e-02f, -6.18984737e-02f, 1.65319368e-02f, -1.03952609e-01f, 4.00316417e-02f, -6.09411187e-02f, -2.30436027e-03f,
  1.68601602e-01f, -1.23160549e-01f, -6.63781464e-02f, 1.03665709e-01f, 6.89794645e-02f, 4.90460731e-03f, -8.19573700e-02f, 7.35732242e-02f, 6.39043376e-02f, 2.73699965e-02f,
  -1.34324795e-02f, 4.08448577e-02f, -1.09570980e-01f, 3.51612456e-02f, -2.67883316e-02f, 3.90555989e-03f, 5.06098419e-02f, -1.15364783e-01f, 6.20694458e-03f, 1.08194359e-01f,
  -1.57280579e-01f, -1.00636162e-01f, -2.11844265e-01f, 3.01997215e-01f, 1.69632688e-01f, -1.50339022e-01f, -4.19128910e-02f, 7.78823346e-03f, -8.04352909e-02f, 5.34432493e-02f,
  4.72855307e-02f, -2.42755279e-01f, -7.15226680e-02f, 9.72493142e-02f, 1.11641712e-01f, 1.54235750e-01f, 2.06995666e-01f, -5.29590100e-02f, 2.38691688e-01f, -9.39008743e-02f,
  1.89682484e-01f, -1.90263435e-01f, -9.97104943e-02f, 1.39021173e-01f, -1.20519385e-01f, -6.75687715e-02f, -1.71346456e-01f, 1.23919964e-01f, -1.88207254e-01f, -1.14806063e-01f,
  7.76599124e-02f, 3.20261329e-01f, 8.18060413e-02f, -1.37623074e-02f, 4.97544296e-02f, -2.57762730e-01f, 2.65136547e-02f, -1.10112123e-01f, -1.20992482e-01f, -3.35977711e-02f,
  2.33492166e-01f, -1.18769154e-01f, 3.22751217e-02f, 8.83857980e-02f, -8.94745290e-02f, 9.69772935e-02f, -5.06086200e-02f, -5.09965718e-02f, 3.48898917e-02f, -8.01103115e-02f,
  6.14356771e-02f, -9.25156474e-02f, -1.36856511e-01f, -4.24981713e-02f, 2.34674364e-02f, -1.52477324e-01f, -1.47916511e-01f, -1.61271274e-01f, -1.99105218e-01f, 9.76784304e-02f,
  -4.45684679e-02f, 8.22919980e-02f, 8.13539028e-02f, 5.47126308e-02f, 1.91935942e-01f, 2.05737025e-01f, 1.95983164e-02f, -1.07632592e-01f, 1.21286839e-01f, 2.09269440e-03f,
  -1.06148683e-01f, -2.44780183e-02f, 4.63403501e-02f, 1.10922843e-01f, 4.50299084e-02f, 1.68010294e-01f, 1.20544158e-01f, -1.97302610e-01f, 1.22217638e-02f, -1.44704178e-01f,
  1.73574444e-02f, 1.24010764e-01f, -1.60760567e-01f, 2.34427899e-01f, -1.89979851e-01f, 3.05778056e-01f, 2.90875047e-01f, -3.06337164e-03f, -1.83703974e-02f, 6.28880411e-02f,
  1.67557806e-01f, 7.54283071e-02f, 5.99006675e-02f, 2.73649730e-02f, -8.42247903e-02f, -2.06009984e-01f, 1.40511962e-02f, -6.66962117e-02f, 6.54838309e-02f, 8.86316299e-02f,
  1.99222013e-01f, -5.62706217e-02f, 1.57786176e-01f, -9.28810835e-02f, 2.32872646e-02f, -1.00286059e-01f, 6.28665462e-02f, -9.29211453e-02f, -2.77904775e-02f, -4.19883765e-02f,
  1.34855524e-01f, -9.59839076e-02f, -1.08546847e-02f, 2.21653581e-02f, 1.52122468e-01f, 8.83701146e-02f, 1.94307894e-01f, -7.59589821e-02f, -7.54073635e-02f, 8.86105821e-02f,
  -2.82961968e-02f, 1.06377840e-01f, 1.61650047e-01f, 1.39870763e-01f, 1.01261087e-01f, 5.00478558e-02f, -8.35230052e-02f, -6.77948520e-02f, -1.36233896e-01f, -1.66095272e-01f,
  1.54207066e-01f, -1.28597826e-01f, -2.23553568e-01f, -1.29507743e-02f, 9.24833640e-02f, -1.67891726e-01f, 2.16556385e-01f, -9.68961641e-02f, 5.30911982e-02f, -1.03536166e-01f,
  2.12766692e-01f, 9.57007259e-02f, 8.45146626e-02f, -7.80900195e-03f, -1.87766045e-01f, 1.10058941e-01f, -2.08250344e-01f, -1.22284815e-01f, 1.54760674e-01f, 7.57240281e-02f,
  -1.16198614e-01f, 8.29676315e-02f, -1.01841412e-01f, -9.47799683e-02f, 2.31179908e-01f, -1.23415269e-01f, 1.66398302e-01f, 4.90176678e-02f, -9.33130756e-02f, -9.79850218e-02f,
  -3.47581506e-02f, -8.23991895e-02f, 2.78268382e-02f, 6.91645686e-03f, -1.29454777e-01f, -8.14301223e-02f, -1.28038451e-01f, -2.82615852e-02f, -2.39800379e-01f, -1.62556797e-01f,
  -4.71929740e-03f, 1.20622970e-01f, 6.50094301e-02f, 3.57498117e-02f, 5.80936782e-02f, 1.20261274e-01f, 6.02275543e-02f, -5.28026372e-02f, 1.89556777e-01f, 5.10601737e-02f,
  -3.68423760e-02f, -5.84806642e-03f, 5.52298203e-02f, 9.02945995e-02f, -1.15311635e-03f, -4.65762988e-02f, 1.23318154e-02f, 9.79904681e-02f, 1.04018435e-01f, -2.72574164e-02f,
  -4.86650057e-02f, 1.85288861e-02f, 2.33484991e-02f, -4.84658703e-02f, 2.60241270e-01f, -3.71357873e-02f, 8.62694383e-02f, 7.89733976e-03f, 2.24270597e-01f, -9.86027196e-02f,
  2.59307977e-02f, 1.48048371e-01f, -1.49098486e-02f, -6.65625557e-02f, 8.07033926e-02f, 8.54154117e-03f, 1.60705104e-01f, 1.60482734e-01f, 6.96427077e-02f, -1.36501461e-01f,
  4.94913831e-02f, -5.26921414e-02f, -1.34765795e-02f, 6.75468743e-02f, -1.53397858e-01f, 6.14491925e-02f, -1.11398436e-01f, -1.26491874e-01f, 1.11111134e-01f, -1.46681994e-01f,
  -2.78599083e-01f, 1.35364071e-01f, -4.15513963e-02f, 5.92530295e-02f, -8.80871862e-02f, -1.09084368e-01f, 1.57165099e-02f, -7.88676068e-02f, 1.96070120e-01f, 7.36685768e-02f,
  -1.41143143e-01f, 1.15200788e-01f, -6.68605566e-02f, 4.57531549e-02f, -1.78546041e-01f, 1.12110168e-01f, -7.99238309e-02f, -7.53001776e-03f, -2.42397860e-02f, 3.09179798e-02f,
  3.29952873e-03f, -1.07230052e-01f, -1.67047083e-01f, 9.79809090e-02f, -2.83391904e-02f, -2.73674447e-02f, 2.01627109e-02f, -1.94292098e-01f, -8.91122371e-02f, -1.21223301e-01f,
  1.00227103e-01f, -1.91372260e-01f, -8.45876187e-02f, -1.77481100e-01f, -4.96101230e-02f, 1.19143710e-01f, 1.10677935e-01f, -2.01185457e-02f, -1.60198525e-01f, 2.67132595e-02f,
  1.14610665e-01f, 4.69680019e-02f, -1.37064531e-01f, 1.88998535e-01f, -4.71094996e-02f, -4.86442260e-02f, 1.39634222e-01f, 7.63983876e-02f, -1.30797774e-01f, -4.68803421e-02f,
  -2.26768002e-01f, -7.94871300e-02f, 1.49591967e-01f, 1.65932104e-01f, 2.87761986e-02f, 1.01818107e-01f, -1.54408321e-01f, 5.33796698e-02f, -4.86447252e-02f, 1.42776236e-01f,
  1.22242294e-01f, 1.12110503e-01f, -2.02752158e-01f, 3.71458456e-02f, 2.15198115e-01f, -5.29125072e-02f, -8.55585188e-02f, -1.65383682e-01f, 3.08347326e-02f, 4.57408801e-02f,
  -1.46911785e-01f, 5.31543754e-02f, -1.36613354e-01f, 1.13496957e-02f, -3.91864823e-03f, -1.64577246e-01f, 1.53498784e-01f, 8.92919302e-02f, -3.18197161e-02f, -2.22845063e-01f,
  9.58883315e-02f, -3.09040267e-02f, -7.49137551e-02f, -7.00654183e-03f, -1.29193962e-01f, 5.00079021e-02f, 1.29098922e-01f, 4.38888036e-02f, 2.82282177e-02f, -2.40973104e-03f,
  -6.44306140e-03f, 1.02138728e-01f, 2.41657048e-02f, 5.90560399e-02f, 1.24528922e-01f, 9.24289525e-02f, 6.31981939e-02f, -2.11441447e-03f, 8.38828553e-03f, -1.45568177e-01f,
  1.00531951e-01f, -1.14623949e-01f, 1.80167064e-01f, -6.31390586e-02f, -1.03458673e-01f, 6.35655746e-02f, 4.81272936e-02f, -7.74927288e-02f, 1.36481375e-01f, -7.12368861e-02f,
  -8.63090307e-02f, -2.30908528e-01f, 7.45948628e-02f, -1.49129890e-02f, 7.13827983e-02f, -4.67266589e-02f, -6.80443645e-03f, 1.30928099e-01f, 3.26795503e-02f, 2.56594364e-02f,
  1.24917708e-01f, -6.70222938e-02f, 2.14414019e-02f, 8.79333988e-02f, 4.35624197e-02f, -1.82131752e-01f, 1.55368179e-01f, 1.70792814e-03f, 2.13806957e-01f, -5.53677045e-02f,
  -7.60541484e-02f, -2.22509220e-01f, -8.81263167e-02f, -1.41161919e-01f, -1.22060522e-01f, 5.51520884e-02f, -2.12094709e-01f, -5.79649918e-02f, -1.27346590e-01f, 1.23226559e-02f,
  9.56245512e-02f, -5.04273735e-02f, 6.53705820e-02f, 5.11001199e-02f, 1.59426183e-02f, 2.55705360e-02f, -6.08444549e-02f, 1.02192964e-02f, 1.31431669e-01f, 1.09356336e-01f,
  4.71728183e-02f, -3.99095155e-02f, 2.16156617e-02f, -4.11310233e-02f, 1.80549711e-01f, -3.43537666e-02f, 5.19114826e-03f, 1.43001378e-01f, 6.71727955e-02f, 1.97882056e-02f,
  -4.46269810e-02f, -4.05686758e-02f, -9.15153604e-03f, 1.48413539e-01f, -5.27254269e-02f, -3.86054367e-02f, 7.47608170e-02f, 1.60286240e-02f, -1.96495920e-01f, 2.72983700e-01f,
  -4.54568453e-02f, 1.40671886e-03f, 1.41856581e-01f, 8.21602345e-03f, 1.28022075e-01f, 1.47263734e-02f, 1.76806543e-02f, -1.64963678e-01f, -1.36219218e-01f, -1.30550474e-01f,
  -7.17979670e-02f, -8.23107958e-02f, -1.96099892e-01f, 1.37998372e-01f, -2.06406549e-01f, 5.83088063e-02f, 1.55174613e-01f, 3.31985019e-02f, -5.32405637e-03f, 4.58416715e-02f,
  1.21917836e-01f, 4.16089892e-02f, 3.57537657e-01f, 1.01312853e-01f, 1.21839354e-02f, -2.72847772e-01f, -1.08621128e-01f, -7.43116066e-02f, 3.94499972e-02f, 9.84229222e-02f,
  -5.07122502e-02f, 2.34734919e-02f, 1.11862674e-01f, 1.27978325e-01f, -1.30778983e-01f, -6.10465482e-02f, -1.49319649e-01f, 9.14934371e-03f, 3.68653238e-02f, -3.84689681e-02f,
  -7.17736781e-02f, 9.84543785e-02f, -1.94648251e-01f, 1.76606383e-02f, -2.27570888e-02f, 6.24409970e-03f, -1.61040276e-02f, 7.39557296e-02f, 3.67654264e-02f, -3.88847813e-02f,
  -9.66179520e-02f, -2.54693106e-02f, -3.89325097e-02f, 2.10765880e-02f, 1.51619375e-01f, -1.39597461e-01f, 3.23245116e-02f, -9.76960137e-02f, -1.08337097e-01f, -2.61011273e-01f,
  3.89200300e-02f, 2.74782330e-01f, 3.75849032e-03f, -2.03176349e-01f, 4.67242375e-02f, -3.88831832e-02f, 4.01177723e-03f, -2.76361722e-02f, -1.26555011e-01f, -2.72208571e-01f,
  1.28974691e-01f, 2.08617032e-01f, 8.42570737e-02f, 9.07363147e-02f, 9.52455923e-02f, 1.95137542e-02f, 1.60068318e-01f, -2.16018468e-01f, -1.97921209e-02f, -2.30956241e-01f,
  -1.94175288e-01f, -2.06763372e-02f, 1.09106880e-02f, -2.83320874e-01f, -1.03702769e-01f, 9.47115794e-02f, -1.47600979e-01f, -1.20324947e-01f, 4.52576987e-02f, 1.11998163e-01f,
  4.43280227e-02f, 1.06563978e-01f, 4.82448451e-02f, -1.62500605e-01f, 6.89707696e-02f, -3.46335247e-02f, -1.95237190e-01f, 1.09647438e-01f, -4.29707840e-02f, 1.28064305e-01f,
  7.45393410e-02f, -1.04731977e-01f, -9.59920436e-02f, -1.79115473e-03f, -5.53176031e-02f, -1.59725070e-01f, -1.14882179e-01f, -3.00870351e-02f, -5.59481494e-02f, -6.37561008e-02f,
  1.90929230e-02f, 1.10242963e-01f, 5.86599521e-02f, 4.59735515e-03f, 5.96788153e-02f, -1.63404923e-02f, 9.37344972e-03f, 1.38352379e-01f, 9.60714892e-02f, 1.81847848e-02f,
  9.49060246e-02f, -1.24813393e-01f, 6.54611215e-02f, 1.13924347e-01f, 1.67417198e-01f, -1.02676906e-01f, -2.11217836e-01f, 2.60520190e-01f, 4.88480628e-02f, 1.32790972e-02f,
  2.60593712e-01f, -4.71396260e-02f, -1.13439210e-01f, 7.17591075e-03f, 2.71501094e-02f, -8.44815373e-02f, -8.43129009e-02f, -4.23561260e-02f, -1.71726629e-01f, 9.11050513e-02f,
  2.34835614e-02f, 2.47296076e-02f, 9.70486179e-02f, -1.71782613e-01f, 3.43002230e-02f, -1.02808453e-01f, -1.08269858e-03f, 6.92671956e-03f, 2.33691171e-01f, 1.11583315e-01f,
  3.14872026e-01f, -3.96508463e-02f, 4.80989106e-02f, -2.46460542e-01f, -1.42548934e-01f, -5.07039428e-02f, 2.64933202e-02f, 1.69674933e-01f, -2.38002077e-01f, 1.06799163e-01f,
  -1.12303652e-01f, -8.78415927e-02f, 5.93420528e-02f, -1.81172609e-01f, 2.07949042e-01f, -6.32607341e-02f, -6.17590249e-02f, 1.78995088e-01f, -8.04836601e-02f, -1.48032140e-03f,
  1.56648189e-01f, 1.00798078e-03f, 1.56968106e-02f, -9.78955030e-02f, -5.73222432e-03f, -6.90109236e-03f, -3.62772355e-03f, 6.26532510e-02f, 6.61194399e-02f, -1.72122419e-02f,
  -8.60174075e-02f, 8.72856900e-02f, 5.89827029e-03f, 1.87212199e-01f, 1.43374456e-02f, -5.83201796e-02f, 3.81506910e-03f, 3.87926735e-02f, 2.25061774e-01f, -2.05282584e-01f,
  -1.57578662e-01f, 1.88816741e-01f, 5.47152869e-02f, -1.07045807e-01f, 2.75500834e-01f, 6.45370781e-02f, 4.70129140e-02f, 3.10111910e-01f, 1.61649540e-01f, -1.14234433e-01f,
  1.19635034e-02f, 9.57861021e-02f, -1.18554272e-01f, -1.58311855e-02f, -2.49789804e-01f, 1.30370259e-01f, 8.14501941e-03f, 1.60390079e-01f, 2.82979488e-01f, -1.21932838e-03f,
  -1.55487061e-01f, -1.46197090e-02f, 1.78644106e-01f, -6.64896369e-02f, -6.47216812e-02f, 9.83300805e-02f, 3.70065570e-02f, -6.71969578e-02f, -1.55957546e-02f, -2.25835759e-02f,
  9.97909978e-02f, 2.32728466e-01f, -2.38459241e-02f, -1.13365173e-01f, 1.11168429e-01f, 1.10156640e-01f, -8.87527838e-02f, -4.57494607e-04f, 1.07077345e-01f, 8.81495103e-02f,
  1.82253122e-01f, -4.90964279e-02f, 7.33965337e-02f, 3.11911926e-02f, 9.84634608e-02f, 9.49054286e-02f, 7.74366260e-02f, 7.89329335e-02f, 1.28230095e-01f, -2.29791831e-02f,
  -3.07280738e-02f, 1.54464245e-01f, -1.66113719e-01f, 1.35054082e-01f, -4.47689891e-02f, 9.93357450e-02f, 1.35407954e-01f, 1.20628558e-01f, 3.31740528e-02f, -1.23453267e-01f,
  -9.46108103e-02f, -4.10376750e-02f, 2.18131110e-01f, 6.33375272e-02f, 8.63659829e-02f, -1.04092233e-01f, 3.69421393e-03f, -2.35682711e-01f, 2.77073868e-02f, -4.60389107e-02f,
  -9.78220105e-02f, -1.16123073e-01f, 1.71746299e-01f, 3.64236981e-02f, 2.66773760e-01f, 6.03000894e-02f, -7.20012262e-02f, -1.86557308e-01f, -8.70392174e-02f, 1.33075356e-01f,
  -5.46572469e-02f, -9.94574428e-02f, -1.42161712e-01f, 6.34811893e-02f, 5.12670353e-02f, -3.27050328e-01f, 6.44458607e-02f, 7.97085017e-02f, -2.97680587e-01f, -1.19866148e-01f,
  8.24754611e-02f, 2.14941740e-01f, 6.86829817e-03f, 1.04534030e-01f, 1.21824630e-01f, -1.38475627e-01f, 1.31400481e-01f, 1.39007475e-02f, -1.48242548e-01f, -3.18484157e-02f,
  -1.08672597e-01f, -1.63179785e-01f, -1.20628655e-01f, -1.78207681e-02f, 1.64235637e-01f, 1.56202480e-01f, 3.30231152e-03f, 7.50723854e-02f, -2.75769439e-02f, -3.41592059e-02f,
  9.92027894e-02f, -4.62132804e-02f, -1.18518427e-01f, -1.39239505e-01f, -1.59072444e-01f, 1.77221566e-01f, 3.11809517e-02f, -9.82438922e-02f, -1.02605201e-01f, -1.32172078e-01f,
  5.54843768e-02f, -7.51945749e-02f, 8.26552585e-02f, 4.27986719e-02f, -1.85357094e-01f, -2.37149000e-01f, 7.03176335e-02f, 1.75597012e-01f, 2.93245297e-02f, -1.50747761e-01f,
  1.03784941e-01f, -1.07835449e-01f, -6.56749383e-02f, 1.69927329e-01f, -2.34100640e-01f, -1.58315316e-01f, 5.46520613e-02f, 4.11909781e-02f, 2.61868864e-01f, 2.34408453e-01f,
  -1.94841288e-02f, -3.95905040e-02f, -4.91291918e-02f, -1.10217132e-01f, 1.71373665e-01f, -1.06233671e-01f, -1.66814640e-01f, -1.27622038e-01f, 2.57200729e-02f, -3.11458975e-01f,
  -6.81665493e-03f, -1.37965143e-01f, -2.37225085e-01f, -8.56555179e-02f, -5.17134927e-02f, 3.05497795e-01f, 4.11751159e-02f, -8.98802131e-02f, 7.96474293e-02f, -1.32241666e-01f,
  -8.66201594e-02f, 3.31133008e-02f, -2.45231874e-02f, 6.04947507e-02f, -4.68617715e-02f, 5.35794906e-02f, -6.50385469e-02f, 7.18600303e-02f, 7.44621456e-02f, 4.82319184e-02f,
  1.20840333e-01f, 1.94590181e-01f, 6.20625094e-02f, 5.21283336e-02f, 1.25982419e-01f, 9.82137918e-02f, 1.07304923e-01f, 5.86927123e-02f, -6.85295016e-02f, -2.19831783e-02f,
  2.41859350e-02f, 4.38790880e-02f, 7.90177062e-02f, -1.31197765e-01f, -1.21095099e-01f, 8.65413621e-02f, 1.03045627e-01f, 1.88181564e-01f, 1.03412375e-01f, -1.49935499e-01f,
  -5.09900413e-02f, 4.24688570e-02f, 1.79862127e-01f, -1.00257322e-01f, 6.34434074e-02f, 1.35482475e-01f, -1.45606756e-01f, 1.50532797e-01f, 4.80350703e-02f, 4.92583625e-02f,
  -1.61046609e-01f, -9.38992351e-02f, 2.94741951e-02f, -2.06250232e-02f, 1.84726357e-01f, 1.22362692e-02f, 1.52288333e-01f, 1.62943482e-01f, -6.42497241e-02f, 1.64106742e-01f,
  -1.21681854e-01f, 7.26170540e-02f, -1.11403940e-02f, 2.55908277e-02f, -2.54642427e-01f, 1.04773462e-01f, -1.90272599e-01f, 6.13755034e-03f, -2.52660215e-02f, 6.67690486e-02f,
  -6.13167994e-02f, 1.54796541e-01f, -1.06088802e-01f, -1.95189670e-01f, 2.76166171e-01f, 1.89387631e-02f, 5.93082942e-02f, -9.51674432e-02f, -1.40154615e-01f, -4.68086936e-02f,
  -1.65338069e-02f, -2.77997609e-02f, 9.87709761e-02f, -4.38847281e-02f, 8.56395364e-02f, -4.32846919e-02f, -2.41680797e-02f, 7.62635171e-02f, 1.34518787e-01f, 3.53160314e-02f,
  5.90648688e-02f, -2.02115029e-02f, -5.94733879e-02f, -2.81968452e-02f, -6.63933158e-02f, 1.21167853e-01f, 9.22454670e-02f, -2.08699450e-01f, 6.07091971e-02f, 4.57665808e-02f,
  4.88871969e-02f, 4.24852856e-02f, 1.04888141e-01f, -8.50466192e-02f, 3.21271122e-02f, 1.53207734e-01f, -1.80099402e-02f, 5.72702065e-02f, -7.35991746e-02f, 1.00987397e-01f,
  -2.29808882e-01f, -1.29151195e-01f, -3.79344374e-02f, 9.83788744e-02f, -4.39212173e-02f, -2.76107103e-01f, -1.75342470e-01f, -9.97489225e-03f, 3.97002650e-03f, -5.56369126e-02f,
  -1.11187525e-01f, 1.48654521e-01f, -1.26893952e-01f, 3.53555009e-02f, 6.25835210e-02f, 5.11515923e-02f, 4.07018438e-02f, 7.33057084e-03f, -1.61638901e-01f, 2.41647720e-01f,
  1.33249193e-01f, -1.11146837e-01f, -6.80168495e-02f, -3.27645838e-01f, 6.50510937e-02f, -5.74416034e-02f, -1.61544934e-01f, -1.78285688e-01f, 1.51696697e-01f, 2.18205601e-02f,
  -1.56236559e-01f, 9.58209634e-02f, 7.67366141e-02f, 1.42035902e-01f, 1.39047816e-01f, 7.01887161e-02f, -7.98133910e-02f, 1.84781589e-02f, -1.09673195e-01f, -1.70710564e-01f,
  -8.07303563e-02f, -1.27037326e-02f, 1.66249108e-02f, 8.62347186e-02f, 1.32013604e-01f, 1.17967442e-01f, 5.65210171e-02f, -1.74356848e-01f, 1.80214256e-01f, -4.86596003e-02f,
  -2.22064480e-02f, 1.26210541e-01f, 1.19003884e-01f, 1.60335913e-01f, 1.09758392e-01f, 6.23606704e-02f, -4.16760743e-02f, 1.41577318e-01f, 8.49688500e-02f, -2.62933195e-01f,
  -1.42507434e-01f, 2.57448614e-01f, 2.00074203e-02f, -1.28651321e-01f, 9.36191082e-02f, -4.49245162e-02f, -3.19758430e-02f, 1.41472861e-01f, -4.33951467e-02f, -2.04483151e-01f,
  -1.95571467e-01f, 2.89857318e-03f, -1.95460513e-01f, 1.37860164e-01f, -2.06031233e-01f, -6.54398054e-02f, -4.29845490e-02f, 1.66313708e-01f, 3.02019715e-02f, 6.75122291e-02f,
  -1.28657177e-01f, -4.95935418e-02f, 2.48672366e-01f, -2.22469084e-02f, 1.99717328e-01f, -7.11003393e-02f, 1.03759147e-01f, -2.84669369e-01f, 3.61966789e-02f, -5.34851998e-02f,
  -5.48750386e-02f, 1.39613718e-01f, -1.62689582e-01f, 1.27083763e-01f, 1.42261177e-01f, 2.49555092e-02f, -1.30266845e-01f, -5.33631667e-02f, -4.48005833e-02f, -1.31931305e-01f,
  7.08110770e-03f, 9.52524543e-02f, -3.85835469e-02f, 8.26255530e-02f, -1.82560459e-02f, 1.98031440e-02f, -3.24725471e-02f, -3.02473698e-02f, 9.73036736e-02f, 1.04203597e-01f,
  -8.60069916e-02f, 1.34276703e-01f, -8.90731290e-02f, 7.42078200e-02f, 1.00369367e-03f, 1.53674409e-01f, 4.37014289e-02f, -1.67728425e-03f, 4.67304587e-02f, -1.65480062e-01f,
  -4.48379181e-02f, -1.46192625e-01f, 2.10185856e-01f, 2.36170664e-01f, 3.27792019e-02f, -1.66394085e-01f, 2.12632731e-01f, -7.90749565e-02f, 5.95973879e-02f, -6.16956912e-02f,
  -4.28422652e-02f, -3.21064264e-01f, 3.73253264e-02f, 1.56427562e-01f, 2.91644990e-01f, 2.52783507e-01f, 6.39540851e-02f, -8.03393275e-02f, -8.54822025e-02f, -7.51616359e-02f,
  2.05598906e-01f, -1.39259756e-01f, -1.06830977e-01f, -1.51158944e-01f, -1.52231798e-01f, -2.83248514e-01f, 1.84034124e-01f, -1.18113577e-01f, -1.06526040e-01f, 1.95988286e-02f,
  -7.33971745e-02f, 1.63780630e-01f, -9.58489552e-02f, -1.13132961e-01f, 7.10148886e-02f, 5.11738621e-02f, -7.51400441e-02f, -3.84796113e-02f, -1.38421804e-01f, 5.85075058e-02f,
  1.00244284e-01f, 1.94757320e-02f, 9.18556526e-02f, -5.32080643e-02f, 1.09130079e-02f, 1.44229650e-01f, 8.39644819e-02f, 3.61618996e-02f, 7.14210644e-02f, -5.04953116e-02f,
  1.27963200e-01f, -1.46116242e-01f, 7.25307688e-02f, 4.71272543e-02f, -7.66857266e-02f, 5.96055761e-03f, -1.48694918e-01f, -2.31056269e-02f, 1.04889423e-01f, 6.33192807e-02f,
  1.29491948e-02f, 1.05918914e-01f, -1.05772458e-01f, -9.14135203e-02f, -9.84511673e-02f, -1.16313249e-01f, 1.71402782e-01f, -7.01714233e-02f, 1.27431765e-01f, -1.43483132e-01f,
  3.02493945e-02f, -1.73713729e-01f, 1.35250390e-01f, 1.02444775e-01f, -1.22138053e-01f, 1.05180115e-01f, -5.53282611e-02f, 1.39526770e-01f, 1.80753991e-01f, 2.09520370e-01f,
  1.20811470e-01f, -7.72097260e-02f, -1.97753906e-02f, -2.59871390e-02f, 3.03817466e-02f, -1.32638320e-01f, -2.64547486e-02f, -5.13292737e-02f, -3.05292662e-02f, -6.54528365e-02f,
  6.21644706e-02f, -3.81421149e-02f, -2.52399504e-01f, 6.48763850e-02f, -6.13126233e-02f, 1.85873047e-01f, -9.36047360e-02f, -1.27943590e-01f, 9.92829576e-02f, 9.38296169e-02f,
  1.12239663e-02f, -9.57214460e-02f, 1.38129583e-02f, -4.30106521e-02f, -4.39712917e-03f, 3.32309194e-02f, 9.46159139e-02f, -1.20240659e-01f, -5.93458414e-02f, 1.25521600e-01f,
  5.24213351e-02f, 9.43179578e-02f, -1.46311879e-01f, -6.30250424e-02f, 1.76523104e-02f, 8.74350443e-02f, -1.02240071e-02f, 4.35828790e-02f, 6.57681227e-02f, 3.92054655e-02f,
  8.81195664e-02f, 6.05334416e-02f, 1.75947949e-01f, 4.14080992e-02f, 5.43230399e-02f, -2.26861686e-02f, 6.82769269e-02f, -1.64245456e-01f, -8.63054693e-02f, -8.00582543e-02f,
  2.72603154e-01f, 1.04604535e-01f, -9.04386025e-03f, -6.30146191e-02f, 1.06219776e-01f, -2.65883263e-02f, -1.29333779e-01f, -1.44626677e-01f, 2.33291294e-02f, -1.22351363e-01f,
  1.58671439e-01f, 1.24245873e-02f, 3.62706818e-02f, 2.49994658e-02f, -1.21198393e-01f, 3.71625461e-02f, -1.43456712e-01f, -9.76243522e-03f, -2.92537622e-02f, -1.35235284e-02f,
  4.54851054e-02f, -7.63712898e-02f, -3.56186703e-02f, -1.74560100e-01f, 6.30488694e-02f, 1.10234223e-01f, 3.65752615e-02f, -1.12036198e-01f, -6.88917413e-02f, -1.59432232e-01f,
  3.11824139e-02f, -3.96257304e-02f, -1.19152389e-01f, -1.24294825e-01f, 7.10249245e-02f, -5.55267967e-02f, -2.28454784e-01f, 4.43041930e-03f, 9.22506675e-02f, 8.60474706e-02f,
  6.70217127e-02f, 8.52297470e-02f, -6.85526282e-02f, -1.17030978e-01f, -7.65302554e-02f, 8.32901523e-02f, -4.18162346e-02f, -2.06075944e-02f, -8.90343040e-02f, 1.92379337e-02f,
  -4.52704504e-02f, -3.03410888e-02f, 2.09421515e-01f, -1.39498770e-01f, -1.44913541e-02f, -2.64602099e-02f, -9.16664377e-02f, -5.10532297e-02f, 1.10408757e-02f, -2.00132262e-02f,
  7.04146102e-02f, -2.24565081e-02f, 2.30043039e-01f, 1.05983734e-01f, -6.47246316e-02f, 5.86535521e-02f, 3.88471447e-02f, 1.40068159e-01f, -2.38381654e-01f, 1.78570360e-01f,
  -8.59182402e-02f, -1.84732527e-01f, 1.87749028e-01f, 9.54711810e-02f, -1.51900247e-01f, -1.58099756e-01f, -7.93581754e-02f, 2.23732162e-02f, -7.59863108e-02f, -1.61542464e-02f,
  -6.05603680e-02f, -6.03445768e-02f, -2.37232134e-01f, 9.43212435e-02f, -4.59331311e-02f, 1.24190889e-01f, 2.08846312e-02f, 2.03188345e-01f, -1.32064432e-01f, 6.11076467e-02f,
  2.45621279e-01f, -1.41374618e-01f, 9.03732777e-02f, -1.44693568e-01f, 1.15433976e-01f, -2.89396867e-02f, -1.39307417e-02f, -1.02766141e-01f, -2.87173986e-02f, 7.31707376e-04f,
  1.75021395e-01f, -1.49141386e-01f, -1.31980568e-01f, -1.22368038e-01f, -1.25696883e-01f, -9.27539989e-02f, 1.15116052e-01f, -4.27452214e-02f, -2.08079554e-02f, 3.64598148e-02f,
  5.30316979e-02f, -5.26534170e-02f, 1.19165629e-01f, -1.14375807e-01f, -4.02921252e-02f, 7.09071904e-02f, -8.97982344e-02f, 5.16515747e-02f, -1.64408311e-01f, 1.51318327e-01f,
  1.03931926e-01f, -4.14151400e-02f, -3.71612944e-02f, 3.76395620e-02f, 9.92440358e-02f, -4.80046123e-03f, -4.71821986e-02f, -5.30886240e-02f, 1.81680948e-01f, 1.41796902e-01f,
  8.19811001e-02f, 1.03622772e-01f, 3.26212607e-02f, -8.34641829e-02f, -2.46591419e-01f, 2.78430805e-02f, -9.53949019e-02f, -2.68672574e-02f, 4.39688787e-02f, -4.74614277e-02f,
  7.63723850e-02f, -4.56718449e-03f, -1.08577814e-02f, -3.60639393e-02f, -7.53107108e-03f, 6.82525709e-02f, -2.18563110e-01f, 1.69335529e-01f, -1.76687166e-01f, -9.26887766e-02f,
  7.84669220e-02f, -4.41443138e-02f, -2.49560382e-02f, 1.92103624e-01f, -1.62770584e-01f, -8.81582275e-02f, -1.19240489e-02f, -1.93586618e-01f, -8.65254477e-02f, -6.37017041e-02f,
  -5.14561683e-02f, -2.36282885e-01f, 1.24431625e-01f, 6.95575252e-02f, -8.06847587e-02f, 1.65480897e-01f, 3.76828089e-02f, 2.41591893e-02f, 8.45781043e-02f, 2.82721072e-02f,
  -4.00177464e-02f, 1.86445005e-02f, 1.09247975e-01f, -1.31018490e-01f, -4.91050556e-02f, -8.34265277e-02f, -1.35934815e-01f, -1.06296673e-01f, 1.14150859e-01f, 1.26829013e-01f,
  1.03084994e-02f, 7.50744417e-02f, 1.57945231e-01f, -1.15294717e-01f, -6.50092587e-02f, -6.48133382e-02f, -8.83007944e-02f, -1.72583520e-01f, -1.25455901e-01f, 6.45861179e-02f,
  6.35909289e-02f, 2.89472640e-02f, -1.52951717e-01f, -2.69723423e-02f, 1.06835559e-01f, 4.90869731e-02f, 4.14694324e-02f, 9.24742222e-02f, 1.25850305e-01f, 1.38788506e-01f,
  -1.38046205e-01f, -3.59313115e-02f, -1.76641434e-01f, 4.48079519e-02f, -9.46958270e-03f, 3.58714126e-02f, 4.51866761e-02f, -1.42330766e-01f, 1.86163291e-01f, 3.40489671e-02f,
  1.31060928e-01f, -2.12705255e-01f, -7.81792551e-02f, 4.75659370e-02f, -6.76820204e-02f, 5.65574765e-02f, -1.18747704e-01f, -1.98397025e-01f, -2.01258063e-02f, -6.66273683e-02f,
  9.94779468e-02f, 2.43519247e-01f, -4.50081937e-02f, -3.37138958e-02f, -7.92143270e-02f, -7.51701966e-02f, -1.18754193e-01f, 8.60411525e-02f, 1.12436861e-01f, -3.41773895e-03f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -1.44248560e-01f, -9.56953168e-02f, -7.57684037e-02f, 8.89846608e-02f, 2.93043279e-03f, 1.25449419e-01f, 8.68575498e-02f, 6.60594180e-02f, -1.61094021e-03f, 1.71192169e-01f,
  1.95082147e-02f, 6.33238703e-02f, 1.01673052e-01f, -4.69766930e-02f, -9.08562622e-04f, 6.35739276e-03f, 4.13897708e-02f, 3.87868332e-03f, 9.39078182e-02f, -4.72065248e-02f,
  3.79184373e-02f, 1.57872558e-01f, 6.73416927e-02f, 1.18790925e-01f, 3.16955335e-03f, 3.12117301e-02f, 1.16519108e-01f, 1.03783887e-02f, -5.87325692e-02f, -5.45949712e-02f,
  8.62511098e-02f, -1.06356978e-01f, -6.81599528e-02f, -7.00536072e-02f, 1.55033454e-01f, 3.85185555e-02f, 1.88596055e-01f, -5.55466413e-02f, 8.19974840e-02f, 8.42805058e-02f,
  -5.53987641e-03f, -1.36523619e-01f, -1.93335250e-01f, 1.19267598e-01f, -1.85681343e-01f, 1.52347311e-01f, -6.58537969e-02f, 9.77334902e-02f, 5.64055555e-02f, -1.66567340e-01f,
  1.46652371e-01f, 1.86698392e-01f, 2.94292010e-02f, 6.75271153e-02f, 3.69061753e-02f, -1.12635687e-01f, -4.56980392e-02f, 7.16906860e-02f, 1.23900190e-01f, -1.19714096e-01f,
  3.55441600e-01f, -4.60547432e-02f, 1.24193482e-01f, 8.24669749e-02f, 7.02048689e-02f, 5.10426424e-02f, -5.62941059e-02f, 1.12580936e-02f, 2.92865727e-02f, -2.58556996e-02f,
  -2.57702209e-02f, -6.50835335e-02f, 7.77271762e-02f, 1.96903143e-02f, -8.17314610e-02f, 5.14249466e-02f, 3.46743092e-02f, -9.12362263e-02f, -1.79257151e-02f, -6.89374655e-02f,
  -3.31755392e-02f, -6.18775487e-02f, 2.02697739e-02f, 6.02690987e-02f, -8.54782909e-02f, -1.17491610e-01f, 1.00135304e-01f, 8.22593570e-02f, -1.02735301e-02f, 4.34919074e-02f,
  -1.26723453e-01f, -3.92958289e-03f, -1.05281897e-01f, -9.49528962e-02f, -1.39063418e-01f, 1.61037371e-01f, 7.21761882e-02f, -3.89542058e-02f, 8.63931924e-02f, -1.10582151e-01f,
  -6.42759129e-02f, -8.42425227e-02f, 6.13867603e-02f, 2.83316728e-02f, -7.64876977e-02f, -1.18125431e-01f, 1.54826075e-01f, 9.62554384e-03f, 1.57642215e-01f, -1.74832717e-02f,
  -1.25369569e-02f, 9.78803355e-03f, -6.95243478e-02f, -8.31036940e-02f, -7.56493285e-02f, -1.39660006e-02f, 5.46048805e-02f, -1.10367388e-01f, 5.33178225e-02f, 6.75683394e-02f,
  -3.63010727e-02f, 1.05034992e-01f, 9.46040675e-02f, 1.37010552e-02f, 6.07840763e-03f, 4.68117818e-02f, 4.20952030e-02f, -1.30068526e-01f, -6.56154379e-02f, -1.15489759e-01f,
  8.52638260e-02f, -1.13246784e-01f, -1.09591633e-01f, 1.92677956e-02f, -1.30222393e-02f, -9.77283716e-02f, -3.12622450e-02f, 5.59558533e-02f, -7.87710845e-02f, 9.76621583e-02f,
  1.04606170e-02f, -1.00457616e-01f, -1.29234225e-01f, 1.16384774e-01f, -7.67361373e-02f, -7.26085529e-02f, -3.02870478e-02f, -9.12874117e-02f, 8.05337727e-02f, 6.51585609e-02f,
  -4.23151776e-02f, 7.23819584e-02f, -4.40512560e-02f, -7.13791773e-02f, 9.02905688e-02f, 1.01810388e-01f, 4.92790453e-02f, -7.18077347e-02f, 5.15283123e-02f, -8.02996978e-02f,
  -4.30310071e-02f, -8.33799839e-02f, -7.69432932e-02f, -8.23410898e-02f, -1.01320175e-02f, 1.35548308e-01f, 1.07083052e-01f, -7.65467659e-02f, 1.12513497e-01f, 2.79141665e-02f,
  1.04175314e-01f, -1.31012976e-01f, -3.59341167e-02f, 4.73960415e-02f, 1.13431349e-01f, -5.41791553e-03f, -4.16166112e-02f, 7.14874640e-03f, 1.08187474e-01f, -1.02584921e-01f,
  -2.14907881e-02f, 3.21800373e-02f, 6.08112626e-02f, -1.65646207e-02f, 7.86971673e-02f, -4.04584818e-02f, 1.04286008e-01f, -2.69771181e-02f, -4.98924665e-02f, 1.05218761e-01f,
  -8.27043429e-02f, 1.13496155e-01f, 9.44798905e-03f, -1.11063756e-01f, 7.33731687e-02f, -4.91406322e-02f, -2.12313663e-02f, -1.35730430e-02f, -4.25655693e-02f, 1.08539484e-01f,
  -1.40705511e-01f, -6.93339184e-02f, 2.23307703e-02f, 7.91952312e-02f, 6.09663464e-02f, -5.38574494e-02f, -1.27143726e-01f, 1.04243718e-01f, 1.69991683e-02f, 1.14657469e-02f,
  9.24766138e-02f, -8.92498530e-03f, -6.70788065e-02f, -8.34267661e-02f, 9.36265588e-02f, -1.27745047e-01f, 1.03954971e-02f, -9.49353799e-02f, -8.86198133e-02f, 1.07934609e-01f,
  -7.16346875e-02f, 1.09284315e-02f, -8.43974650e-02f, -1.07213959e-01f, -9.32660978e-03f, -1.34960502e-01f, -7.93781206e-02f, 6.81188405e-02f, 1.80356521e-02f, 7.72041902e-02f,
  -1.01570107e-01f, 8.66234899e-02f, 2.90045259e-03f, -6.85235485e-02f, -4.35291901e-02f, 3.58787626e-02f, -8.67152885e-02f, -4.59589735e-02f, 5.19739054e-02f, -1.27374962e-01f,
  2.71126553e-02f, -1.00373425e-01f, 1.04029432e-01f, -2.82372907e-02f, 8.06790143e-02f, -7.98674896e-02f, -9.37462598e-02f, -2.75662336e-02f, -1.00932486e-01f, -6.59361249e-03f,
  -1.11539781e-01f, -2.51203589e-03f, -2.65831128e-03f, -6.45702854e-02f, 8.20589717e-03f, -2.55362578e-02f, -1.94537610e-01f, -9.49288979e-02f, 4.58833389e-02f, 1.09871879e-01f,
  1.07133783e-01f, -4.09747809e-02f, 1.45670176e-01f, 4.22234088e-02f, 1.12521075e-01f, 2.01044064e-02f, 1.34190381e-01f, -8.18734989e-02f, -9.31634679e-02f, -1.61698423e-02f,
  7.35620409e-02f, -2.05689576e-02f, 1.56039679e-02f, 6.91126138e-02f, 8.03748518e-02f, -4.48945612e-02f, 1.14177093e-01f, -1.04462869e-01f, -9.71720144e-02f, -8.29395726e-02f,
  -4.11352254e-02f, -2.87357010e-02f, -5.38439443e-03f, 1.40512967e-02f, 2.57637203e-02f, 5.50885797e-02f, 6.84431195e-02f, -9.48136449e-02f, -3.89753319e-02f, -1.37065917e-01f,
  -8.28633234e-02f, 3.43118459e-02f, 5.67636490e-02f, -8.37154388e-02f, 1.51189670e-01f, 7.93714300e-02f, 6.81858882e-02f, -1.10978872e-01f, -7.36163184e-02f, -1.06536135e-01f,
  -1.30785212e-01f, -1.27835378e-01f, -1.03643835e-01f, 5.17973565e-02f, -3.41873206e-02f, -1.47198692e-01f, 2.89374273e-02f, 4.17975895e-02f, 1.19395899e-02f, 3.86132747e-02f,
  -7.30593689e-03f, 7.06890365e-03f, 3.08959167e-02f, -9.25463736e-02f, 6.13557771e-02f, -1.29197076e-01f, 1.61901161e-01f, -9.47322510e-03f, -1.99256390e-02f, 1.07732326e-01f,
  1.48307651e-01f, 6.53840378e-02f, 1.21939749e-01f, 1.32255569e-01f, 9.65351462e-02f, 9.40535888e-02f, 6.78720400e-02f, 7.31047010e-03f, 2.14964613e-01f, 3.49129662e-02f,
  -9.49605182e-02f, 2.42012227e-03f, 1.17545195e-01f, 1.29818752e-01f, 5.24165817e-02f, -1.01200536e-01f, -5.94570450e-02f, 3.25167067e-02f, -5.28559163e-02f, 4.76658642e-02f,
  4.87181097e-02f, 1.15219980e-01f, 1.76884100e-01f, 7.13996068e-02f, 1.27398809e-02f, 1.80975094e-01f, -1.29565045e-01f, -3.68196070e-02f, -4.78217676e-02f, -4.21009585e-03f,
  9.48812962e-02f, 1.18202277e-01f, 7.34826773e-02f, 7.96758235e-02f, -6.58706725e-02f, 2.57535577e-01f, 9.70549658e-02f, 5.87442257e-02f, 9.11937431e-02f, -7.27244169e-02f,
  -7.42120221e-02f, 1.11883339e-02f, 3.97416297e-03f, 1.97883353e-01f, -1.28210559e-01f, 1.93197817e-01f, -2.14474928e-02f, -9.13488418e-02f, 1.60137434e-02f, 1.51733056e-01f,
  2.22236782e-01f, 2.59369239e-02f, 3.90963852e-02f, -7.79573098e-02f, -6.88497052e-02f, -1.17611943e-03f, 1.23692609e-01f, 7.23447874e-02f, 9.30728838e-02f, 4.64781299e-02f,
  9.32997242e-02f, -4.98838797e-02f, 1.59094408e-01f, 7.71065801e-02f, -8.15125257e-02f, -5.44535294e-02f, -7.73107931e-02f, -1.00643918e-01f, 6.05793484e-02f, -7.23997876e-02f,
  -9.90043953e-02f, 1.13705724e-01f, 1.32179201e-01f, -2.40976978e-02f, -1.26431175e-02f, 1.08241260e-01f, 3.70510295e-02f, -7.93058276e-02f, -1.04560867e-01f, -6.64038435e-02f,
  6.70180097e-03f, -8.12329203e-02f, -1.58018246e-02f, -5.32209128e-02f, 3.06952279e-02f, -9.77887213e-02f, 9.07483324e-02f, 2.60666106e-03f, 1.19102351e-01f, -1.18611611e-01f,
  8.84405673e-02f, 9.70035046e-02f, -4.32083271e-02f, 9.82846916e-02f, -3.32635567e-02f, -7.41247684e-02f, 8.98557603e-02f, -2.17368491e-02f, 3.72775161e-04f, 8.03734288e-02f,
  6.91856369e-02f, 9.28485543e-02f, 1.35350451e-01f, -7.37723708e-02f, 5.65564856e-02f, -7.21983686e-02f, 9.95081365e-02f, -1.16931565e-01f, -8.48296005e-03f, 4.44277981e-03f,
  5.40012829e-02f, -5.05109038e-03f, -2.57492401e-02f, -1.34355545e-01f, -5.19396563e-04f, -5.71874604e-02f, 1.08162656e-01f, -4.08055559e-02f, 9.85058490e-03f, -4.71658520e-02f,
  -6.03104383e-02f, -2.15943959e-02f, 1.11058168e-01f, 1.04480192e-01f, -6.40364289e-02f, 1.25460355e-02f, 4.45252545e-02f, -4.73682545e-02f, -5.19085228e-02f, -9.85551402e-02f,
  1.45018827e-02f, 1.60875600e-02f, -5.43103144e-02f, 2.21210755e-02f, 8.24094489e-02f, -1.03711605e-01f, -2.62601227e-02f, -6.61569536e-02f, 1.53120735e-03f, -7.68466890e-02f,
  -1.14840996e-02f, -6.32079318e-02f, -1.20763108e-01f, 7.99473673e-02f, -7.41655231e-02f, -4.07726429e-02f, -6.71390817e-02f, -7.70405754e-02f, -1.00205980e-01f, -2.21608356e-02f,
  9.01992396e-02f, -1.01278881e-02f, -1.00787930e-01f, -3.11692860e-02f, 1.35299891e-01f, 1.35159921e-02f, 6.47987649e-02f, -2.59402557e-03f, 7.62674212e-02f, -4.65403572e-02f,
  1.45018548e-01f, 4.50475886e-02f, 3.39953937e-02f, 1.59705859e-02f, 9.28684026e-02f, 3.43073793e-02f, -7.40340799e-02f, -1.17427586e-02f, -1.41514346e-01f, -7.77320713e-02f,
  1.49334492e-02f, -5.22942543e-02f, 8.65038410e-02f, -2.82589369e-03f, -2.35715341e-02f, -4.22661528e-02f, 7.78080821e-02f, -1.37059139e-02f, 1.79860368e-01f, 1.02909021e-01f,
  2.35080063e-01f, -7.13107437e-02f, 9.30242520e-03f, -1.03669263e-01f, -1.27481623e-03f, -7.90089369e-02f, -5.65308928e-02f, 1.87149361e-01f, 1.14459351e-01f, -2.23707631e-02f,
  4.92567457e-02f, -9.49653015e-02f, 1.97166890e-01f, 7.31230676e-02f, 2.75615305e-01f, 1.54222220e-01f, 1.30327359e-01f, 1.23991720e-01f, 1.28718149e-02f, -1.34272948e-01f,
  6.07779250e-02f, 1.62928835e-01f, 1.42403319e-01f, 6.37050346e-02f, 5.79567589e-02f, 1.35231763e-01f, -7.31990784e-02f, 1.19311772e-01f, 1.61038816e-01f, -6.41870052e-02f,
  -6.86191441e-03f, 2.60890573e-01f, -5.47044165e-03f, 1.06173098e-01f, 1.52961686e-01f, 3.66093740e-02f, -1.06919758e-01f, -1.86496973e-01f, 1.68935239e-01f, -1.01605162e-01f,
  -3.15192863e-02f, 3.21874246e-02f, 1.05021678e-01f, 4.06813249e-02f, 2.22086146e-01f, 2.49572732e-02f, -2.40805775e-01f, 2.31488980e-02f, 6.17619753e-02f, 1.74373403e-01f,
  1.72064632e-01f, 2.72478074e-01f, 6.70685023e-02f, -4.25671898e-02f, 1.41433910e-01f, -3.73016968e-02f, 3.22991878e-01f, -3.38070244e-01f, -2.22020611e-01f, 3.69934365e-02f,
  -1.39755756e-01f, -2.55714774e-01f, 2.05574632e-01f, -2.53048033e-01f, 1.97262287e-01f, 1.53128326e-01f, 6.37404099e-02f, 5.23078382e-01f, -8.96427780e-02f, -1.35007486e-01f,
  -5.40973954e-02f, 1.55568331e-01f, -3.06412429e-01f, 1.07074529e-01f, -4.96187760e-03f, 9.00525153e-02f, -1.46684110e-01f, 2.04917546e-02f, -1.03012376e-01f, 8.43766779e-02f,
  3.63198556e-02f, -7.81579763e-02f, -8.89086947e-02f, 2.57021980e-04f, 5.26020154e-02f, -6.94126217e-03f, -1.02138348e-01f, 4.13175486e-02f, 4.89410758e-02f, 3.33368741e-02f,
  -7.79691190e-02f, 8.26433823e-02f, 1.58525571e-01f, 1.28540590e-01f, 1.13715433e-01f, 5.04886247e-02f, 2.11485978e-02f, -2.99778841e-02f, 7.63139352e-02f, 2.14290675e-02f,
  1.17957164e-02f, -2.17646211e-01f, 8.90050679e-02f, 1.23074912e-01f, -3.35193463e-02f, 9.88114774e-02f, -7.91922510e-02f, -6.24140911e-02f, 1.08054899e-01f, 1.03819203e-02f,
  -6.41464442e-02f, -1.28297180e-01f, -7.92258084e-02f, 1.59548558e-02f, 1.12441838e-01f, 1.05994160e-03f, -5.17857783e-02f, 7.00480267e-02f, 1.24880010e-02f, -1.28422212e-02f,
  6.76786825e-02f, -1.47973180e-01f, 5.29782139e-02f, -6.89880997e-02f, -6.59363270e-02f, -1.11356877e-01f, -6.60056546e-02f, 1.46342725e-01f, 1.72739133e-01f, -1.08352326e-01f,
  -5.67099266e-02f, -5.69798648e-02f, 8.94524604e-02f, 9.60832909e-02f, -7.16115758e-02f, -7.83013105e-02f, -2.82512959e-02f, 7.30297109e-03f, -5.75277507e-02f, 1.23479769e-01f,
  -1.02812439e-01f, -4.04656306e-02f, -4.37267162e-02f, 9.57771838e-02f, -3.11451964e-02f, 5.79420924e-02f, -9.23499614e-02f, 8.92366320e-02f, 7.79249668e-02f, 7.29657337e-02f,
  4.40001637e-02f, -2.73985080e-02f, -8.75827894e-02f, -1.31372437e-01f, -1.24673553e-01f, 1.25598386e-02f, -1.52783329e-02f, -2.35534646e-02f, 1.10441506e-01f, -1.79994619e-03f,
  1.16308078e-01f, -6.55523390e-02f, -7.83452168e-02f, -5.32390662e-02f, -5.88024966e-02f, 9.39364508e-02f, -3.94620448e-02f, 1.95433870e-02f, -3.47746871e-02f, -5.56668639e-02f,
  1.18580200e-01f, -5.24224751e-02f, 3.17624724e-03f, -1.88208167e-02f, -3.09981611e-02f, 2.39859316e-02f, -4.50096391e-02f, -7.56980106e-02f, 1.04638897e-01f, 2.68891677e-02f,
  3.88039425e-02f, -2.25345585e-02f, -6.58059418e-02f, 6.99548721e-02f, 8.30150545e-02f, -3.82998250e-02f, -4.00340036e-02f, 5.04146283e-03f, -1.06369533e-01f, -9.71256346e-02f,
  1.59843266e-01f, -1.11418426e-01f, -1.91334590e-01f, -1.51806995e-02f, 1.14815123e-01f, 9.62093025e-02f, -6.82546273e-02f, 2.28432361e-02f, -9.93499756e-02f, -1.10885739e-01f,
  9.56960618e-02f, -2.26429701e-02f, 7.69032836e-02f, -1.10824093e-01f, -9.74714458e-02f, 9.01254863e-02f, -1.19484358e-01f, 3.65135223e-02f, 5.54070398e-02f, -7.69908205e-02f,
  -6.99471012e-02f, 1.35826126e-01f, -7.03311898e-03f, -1.25874104e-02f, 4.23579253e-02f, -7.00031891e-02f, 1.36092594e-02f, -6.60967305e-02f, -1.22326612e-01f, 7.99225494e-02f,
  1.36656731e-01f, -3.70167233e-02f, -4.13271636e-02f, -1.10702105e-01f, -1.04275621e-01f, -8.44940022e-02f, 9.66002047e-02f, 1.93719044e-02f, -9.99650806e-02f, 4.99111414e-02f,
  -2.76016723e-02f, 5.47269247e-02f, -7.63298869e-02f, 6.35103434e-02f, 1.19501218e-01f, 8.93875062e-02f, -9.38505456e-02f, 2.19803005e-02f, -1.49431482e-01f, -1.27868980e-01f,
  7.65933841e-02f, 3.41140898e-04f, 4.35150713e-02f, 9.21757892e-02f, -3.51693593e-02f, -3.85694131e-02f, -5.01243025e-02f, -2.68855929e-05f, 1.04984052e-01f, -3.24642844e-02f,
  -1.34931535e-01f, 7.55397929e-03f, 7.26854727e-02f, -1.52367786e-01f, 1.03922382e-01f, 1.24367356e-01f, 1.26539797e-01f, -9.27329734e-02f, -3.70820537e-02f, 4.71894667e-02f,
  7.58666825e-03f, 4.36815582e-02f, 1.12835161e-01f, 7.03721419e-02f, -3.49653959e-02f, -1.02267720e-01f, -1.35448202e-01f, 5.64659834e-02f, 1.72919817e-02f, -1.45640336e-02f,
  1.10683832e-02f, 2.61463821e-02f, -6.01422265e-02f, 1.09707145e-02f, 1.66787490e-01f, 6.28367579e-03f, -5.08349612e-02f, 7.52984807e-02f, 1.99999943e-01f, 1.73642918e-01f,
  9.28530395e-02f, 2.16373250e-01f, 2.15470463e-01f, 4.80669253e-02f, 2.34073952e-01f, -1.48215552e-03f, 1.70797125e-01f, 1.10528462e-01f, 1.31996810e-01f, 1.71058431e-01f,
  1.64944127e-01f, -5.33199050e-02f, 6.67627379e-02f, -1.79955930e-01f, 1.77235618e-01f, 1.36850506e-01f, -2.06764162e-01f, 2.35436752e-01f, -2.66304731e-01f, 2.09358893e-02f,
  1.42467320e-02f, -2.20021516e-01f, 4.90845330e-02f, 7.05148503e-02f, -4.02975921e-03f, -1.64621308e-01f, 5.99850863e-02f, 2.03837734e-02f, -4.15016785e-02f, 9.91344228e-02f,
  -2.47899637e-01f, 4.09270599e-02f, -3.12031955e-01f, 7.02198129e-03f, 7.30796233e-02f, -1.23099305e-01f, -7.07649291e-02f, -2.08493620e-01f, -1.90891102e-02f, 3.43980789e-01f,
  4.34508562e-01f, -1.05824269e-01f, -9.71285403e-02f, -2.61657298e-01f, -6.72236681e-02f, -8.71244669e-02f, -5.58714336e-03f, 1.95143804e-01f, -7.37133920e-02f, -1.19195394e-01f,
  3.28372121e-02f, 2.37339720e-01f, -4.86093834e-02f, 2.20566079e-01f, 1.34189725e-01f, -1.88395232e-02f, -1.92724802e-02f, 4.06328291e-02f, 8.45033675e-02f, 1.26538158e-03f,
  -3.88671868e-02f, 1.16313428e-01f, 1.65983359e-03f, 1.65726453e-01f, -1.06698550e-01f, -9.63384882e-02f, 7.61457253e-04f, -3.56234238e-02f, 4.23187315e-02f, 7.30544403e-02f,
  5.89265749e-02f, -1.90875337e-01f, 1.06241658e-01f, -7.68721849e-02f, 4.93265539e-02f, 6.69696089e-03f, 1.46619484e-01f, -6.43122522e-03f, -3.62277538e-01f, 9.54103097e-02f,
  6.54511526e-02f, 1.33931503e-01f, -1.66970357e-01f, 3.19311380e-01f, 1.72941163e-01f, -7.42126554e-02f, 1.01096392e-01f, -6.86937151e-03f, -1.98529661e-01f, -7.85894096e-02f,
  -2.31902838e-01f, -1.53955758e-01f, 1.93110276e-02f, -9.49215423e-03f, 2.71643460e-01f, 2.51131468e-02f, -7.15295896e-02f, -1.35352507e-01f, 7.36968219e-02f, 1.76217645e-01f,
  9.72626284e-02f, 2.89230078e-01f, -2.49197185e-01f, 1.01771906e-01f, 4.59875554e-01f, 5.56935109e-02f, -3.16327251e-02f, 2.54044682e-01f, -4.96574789e-02f, 5.82854263e-02f,
  -4.90571447e-02f, 2.20043898e-01f, -2.32661411e-01f, 4.23949435e-02f, 2.95767099e-01f, -4.82573099e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  -3.08636352e-02f, 1.36266634e-01f, 2.81886552e-02f, 2.38869730e-02f, 1.32373944e-02f, 3.60354893e-02f, -9.07867625e-02f, 8.71506147e-03f, 5.98881468e-02f, -9.48806480e-02f,
  1.23759449e-01f, 3.89856026e-02f, 1.37893379e-01f, -7.73647148e-03f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -7.86701962e-02f, -3.84215772e-01f, -9.24419612e-02f, -1.81850657e-01f, -2.76805341e-01f, -1.66371033e-01f, -4.47419398e-02f, -3.53970826e-01f, -1.05608530e-01f, 8.11334774e-02f,
  7.78550580e-02f, -3.04777503e-01f, -1.43206060e-01f, -4.42395397e-02f, -2.60081232e-01f, -1.89718634e-01f, 3.76265235e-02f, -5.39441667e-02f, -1.23681098e-01f, -4.56668794e-01f,
  -3.61718416e-01f, 3.44033279e-02f, -2.15353742e-01f, -1.63628623e-01f, -1.03486165e-01f, -1.37156203e-01f, -3.77931654e-01f, -8.85248780e-02f, -9.26947221e-02f, -5.16321324e-02f,
  -1.37231378e-02f, 7.30756728e-04f, -7.36072734e-02f, 3.82713884e-01f, -1.54731438e-01f, -1.04713306e-01f, 1.23719968e-01f, 2.04223201e-01f, 1.44038618e-01f, -1.71020865e-01f,
  1.32914543e-01f, -8.27848464e-02f, 1.98712826e-01f, -3.37893665e-02f, -1.61935017e-02f, -1.03597622e-02f, -1.33086979e-01f, -2.10254174e-02f, -2.50920832e-01f, -1.30286798e-01f,
  1.01965033e-01f, 1.23778604e-01f, -6.58382252e-02f, -3.48946899e-02f, -5.32576814e-02f, 1.94463685e-01f, -1.01377495e-01f, 1.54080883e-01f, -6.67897761e-01f, -3.62485722e-02f,
  6.38930351e-02f, 1.65602509e-02f, 1.37128785e-01f, 4.78543192e-01f, -3.89710516e-01f, -5.56460135e-02f, 1.00846186e-01f, 3.03128004e-01f, 1.98622584e-01f, -2.22998243e-02f,
  -9.44814458e-02f, 1.86378643e-01f, 2.28132099e-01f, 1.69763938e-01f, 9.51443538e-02f, 6.91476930e-03f, 3.18404347e-01f, 2.37253889e-01f, 3.45328033e-01f, 4.89124954e-02f,
  -3.25439185e-01f, 6.15672283e-02f, 2.36353830e-01f, -7.08272159e-02f, 2.72463504e-02f, 1.58962563e-01f, -7.13436902e-02f, 2.95521617e-01f, 2.48473823e-01f, -5.52713349e-02f,
  3.17819148e-01f, -1.78569883e-01f, -3.10910642e-02f, 3.07343137e-02f, 2.25882292e-01f, -3.83960456e-01f, -2.36662552e-01f, 1.30476356e-01f, -2.36411497e-01f, 8.28212053e-02f,
  -3.73076290e-01f, -3.26093435e-01f, -2.16365337e-01f, 8.74102041e-02f, -4.71213639e-01f, 3.89185220e-01f, 2.91377753e-01f, 1.01170100e-01f, -3.65275621e-01f, -2.87865907e-01f,
  -2.91351765e-01f, 3.71913612e-01f, 1.79168761e-01f, 1.07648611e-01f, -7.71486759e-02f, 1.34418622e-01f, 6.57390356e-02f, -1.05697386e-01f, -1.18968308e-01f, 1.67100146e-01f,
  -6.15862794e-02f, 4.05472741e-02f, -3.67759943e-01f, -1.81050420e-01f, -8.95282906e-03f, -1.48477003e-01f, 7.28531405e-02f, 3.11323643e-01f, 4.87030655e-01f, 5.50524965e-02f,
  3.55032772e-01f, 2.74741817e-02f, 2.51264095e-01f, 9.06252861e-02f, -2.42524356e-01f, 1.73480526e-01f, -4.85429578e-02f, -1.30718037e-01f, -1.57238573e-01f, 1.25359774e-01f,
  -2.14749798e-01f, -1.60256386e-01f, 2.99697351e-02f, 5.24392605e-01f, -3.72138508e-02f, 1.90179814e-02f, -7.40370154e-02f, 1.43204629e-01f, -6.06804993e-03f, -5.41274846e-02f,
  3.74626160e-01f, -2.42425993e-01f, 1.08019419e-01f, 2.45393902e-01f, 2.12912738e-01f, 6.34855181e-02f, 3.81566346e-01f, -3.70396256e-01f, 1.02482559e-02f, 1.03367917e-01f,
  -2.44660117e-02f, -2.45480359e-01f, 8.16667080e-02f, 2.10413307e-01f, -4.57240820e-01f, 3.46196562e-01f, 1.98178321e-01f, 1.48318037e-01f, -7.21319765e-02f, -3.31331104e-01f,
  -1.05655201e-01f, 2.80136913e-01f, 4.45768684e-01f, 1.20845310e-01f, -6.96344972e-02f, -3.17753702e-01f, -2.30774879e-01f, 1.72732383e-01f, -9.15461183e-02f, 9.30439830e-02f,
  -8.65246207e-02f, -1.39559349e-02f, -1.64373353e-01f, -7.43629858e-02f, 1.22693479e-02f, 1.35516435e-01f, 4.15230691e-01f, 3.12258862e-02f, -1.69632062e-02f, -1.19988210e-01f,
  6.72110319e-02f, 1.80801779e-01f, -7.33546987e-02f, 4.06083733e-01f, 1.57065526e-01f, -9.26256031e-02f, -1.82735443e-01f, 2.48359352e-01f, 2.26925850e-01f, -1.56415522e-01f,
  1.98051125e-01f, 1.68342888e-01f, -1.62584797e-01f, -4.64217871e-01f, 5.41443238e-03f, 7.15384558e-02f, 6.32270426e-02f, -3.98822874e-01f, 1.19525038e-01f, 1.82853982e-01f,
  -2.87871093e-01f, -1.15115553e-01f, 8.01872984e-02f, -1.46578908e-01f, -4.60142419e-02f, -2.74004400e-01f, -4.47002947e-02f, -2.46828601e-01f, -1.89142913e-01f, 8.86669755e-02f,
  2.38166451e-01f, -4.66895938e-01f, 1.59530804e-01f, -2.37816930e-01f, -1.66679278e-01f, 8.39432776e-02f, -9.49864313e-02f, 6.73413053e-02f, -2.29334295e-01f, 3.93867731e-01f,
  3.19460064e-01f, -2.18037918e-01f, -2.97241867e-01f, 5.31437285e-02f, -1.97289318e-01f, 2.66095310e-01f, -4.16627705e-01f, -1.70929074e-01f, -2.73038924e-01f, 1.13933451e-01f,
  -9.17523876e-02f, 3.28112245e-01f, -2.02746361e-01f, 8.34038928e-02f, 1.11153193e-01f, -2.42371354e-02f, -8.70702192e-02f, 1.04740493e-01f, -3.58084477e-02f, -1.46057099e-01f,
  2.05480218e-01f, -1.03302315e-01f, -8.64278451e-02f, -6.32577389e-02f, -1.25977382e-01f, 4.29654062e-01f, 6.15751930e-02f, 9.68337152e-03f, -2.24963635e-01f, -2.86416531e-01f,
  -4.62330848e-01f, -1.15306698e-01f, -2.48035952e-01f, -1.18594768e-03f, 2.42019534e-01f, -2.90146135e-02f, -1.48421200e-02f, -4.52763200e-01f, -9.93263349e-02f, -3.34892571e-01f,
  2.50369608e-01f, -3.75956327e-01f, -2.53615499e-01f, 2.05321610e-01f, -1.07771508e-01f, 2.73491770e-01f, 1.77072018e-01f, 2.37154573e-01f, 1.75082877e-01f, -7.92908669e-02f,
  8.41800272e-02f, -3.81202281e-01f, -6.30793214e-01f, -2.87041008e-01f, -1.07269295e-01f, 4.96660024e-02f, 8.74923915e-02f, 9.38640833e-02f, -1.66776761e-01f, -6.40023425e-02f,
  1.27247453e-01f, 5.98234423e-02f, -3.49491686e-02f, -1.35864303e-01f, -8.69896635e-02f, -3.22673261e-01f, -1.85736910e-01f, -1.88708916e-01f, -1.17306761e-01f, -2.52408117e-01f,
  -3.44771117e-01f, -1.05434872e-01f, 2.36220416e-02f, 2.30271712e-01f, -3.01286012e-01f, -1.04030296e-01f, 4.50453497e-02f, -1.33835435e-01f, 6.68715388e-02f, -7.87577853e-02f,
  -1.43893018e-01f, 1.07530169e-01f, 1.42498570e-03f, 3.47744338e-02f, 9.78736877e-02f, -1.06651239e-01f, 8.43125209e-02f, -1.06524274e-01f, 4.54480469e-01f, -2.05189973e-01f,
  -2.03279957e-01f, 8.64064693e-03f, -2.60075182e-01f, 7.78935030e-02f, 5.17314076e-02f, -1.79503441e-01f, 1.00739889e-01f, 3.03115696e-01f, -1.58342242e-01f, 2.60277569e-01f,
  -1.26227453e-01f, 9.14872289e-02f, 2.52668917e-01f, -2.50753880e-01f, 3.54375280e-02f, 3.16806048e-01f, 7.87165388e-02f, 2.08490700e-01f, 1.85131237e-01f, 3.24593246e-01f,
  2.79100478e-01f, 1.71305120e-01f, 2.25018337e-01f, 2.77431220e-01f, -6.57585487e-02f, -2.95696408e-01f, 2.17970535e-01f, -1.02417760e-01f, 3.56315136e-01f, -3.63412231e-01f,
  3.07514906e-01f, 1.69209182e-01f, 1.85267285e-01f, -3.75854015e-01f, -8.92323442e-03f, 1.91977958e-03f, -2.38651648e-01f, -3.20245065e-02f, 3.58874828e-01f, 4.38492328e-01f,
  -3.15997690e-01f, 1.76900461e-01f, 2.93020457e-01f, 3.42601657e-01f, -7.04474524e-02f, -5.00367880e-02f, 1.38623312e-01f, 1.85293213e-01f, 5.15152775e-02f, -8.45205318e-03f,
  2.69515634e-01f, -1.52601069e-03f, -6.91890270e-02f, 8.85697603e-02f, 9.98009294e-02f, 2.23540768e-01f, -2.01033615e-03f, 1.09795168e-01f, -3.78541313e-02f, -2.44494025e-02f,
  -7.95510188e-02f, 5.44107370e-02f, 2.65172899e-01f, -3.66626054e-01f, -3.42949271e-01f, -1.50345415e-01f, 1.39916494e-01f, -6.35792920e-03f, -2.67447561e-01f, -2.12802052e-01f,
  9.70953330e-02f, -3.42829347e-01f, -2.62013465e-01f, 1.69393599e-01f, -1.72974896e-02f, -1.64565891e-01f, 3.35548706e-02f, 1.62581876e-01f, -2.31112376e-01f, -1.13026172e-01f,
  2.83516109e-01f, -9.07521099e-02f, -3.05131167e-01f, -2.20579162e-01f, -1.22148126e-01f, 8.12558979e-02f, -4.22055155e-01f, 7.37971291e-02f, 9.86118913e-02f, 1.02775566e-01f,
  2.27984682e-01f, 4.24788326e-01f, -3.55299979e-01f, 3.07736158e-01f, -2.77712613e-01f, 2.45979518e-01f, -3.71542163e-02f, 1.72732919e-01f, -1.76480308e-01f, -3.26995075e-01f,
  2.32663929e-01f, -2.47379556e-01f, -1.67902350e-01f, -2.41913050e-02f, -9.88747329e-02f, 8.61189980e-03f, -1.93410680e-01f, -3.71261209e-01f, -4.25327085e-02f, 1.23051494e-01f,
  4.87701595e-02f, 1.18839569e-01f, 1.70892607e-02f, 1.39357150e-01f, -9.82636660e-02f, 5.53727001e-02f, 1.27165288e-01f, 1.14565477e-01f, 1.22363426e-01f, -5.83933890e-02f,
  -5.46955019e-02f, -8.88423324e-02f, 3.32168937e-01f, -8.16396698e-02f, 1.87631339e-01f, 1.38203740e-01f, -4.97994512e-01f, -2.62242287e-01f, -2.58323610e-01f, -2.81615764e-01f,
  -3.78943801e-01f, -3.44632655e-01f, -3.70472640e-01f, -1.20459974e-01f, 2.60005351e-02f, 2.17767060e-01f, 3.38788182e-01f, 5.61666898e-02f, 1.87248811e-02f, 7.19661191e-02f,
  -2.23683342e-01f, -1.76270217e-01f, 1.43987805e-01f, -2.06682876e-01f, -2.07864091e-01f, -1.30405858e-01f, -3.56047660e-01f, -1.80852376e-02f, -9.44795366e-03f, -1.69545457e-01f,
  4.66949008e-02f, -9.62568521e-02f, -2.59173900e-01f, 1.52446404e-01f, -7.79667124e-02f, 4.34823871e-01f, -2.33325914e-01f, 6.21801987e-02f, -1.19177744e-01f, -4.35084164e-01f,
  5.52566759e-02f, -2.88593993e-02f, -2.35955819e-01f, -2.28693113e-01f, 9.51422453e-02f, -2.88825959e-01f, -3.80703002e-01f, 2.05056280e-01f, 1.19316302e-01f, 7.14687482e-02f,
  -2.32185319e-01f, -2.33797997e-01f, 1.72451854e-01f, 2.90072672e-02f, -2.02155828e-01f, -1.07251100e-01f, -2.11777568e-01f, 2.81734675e-01f, -2.42522404e-01f, 3.01594734e-01f,
  -9.57374722e-02f, -7.72373974e-02f, -1.53979808e-01f, -1.29082575e-01f, 2.85899453e-02f, -2.61542927e-02f, 2.63088286e-01f, 1.07138060e-01f, -4.14458700e-02f, 1.97001081e-02f,
  -3.50238442e-01f, 3.14079016e-01f, 2.64494479e-01f, -1.59382358e-01f, -2.16848075e-01f, 3.69435936e-01f, 2.80704051e-01f, 2.13533774e-01f, 2.74966378e-02f, -1.09063938e-01f,
  1.58808455e-01f, -2.93391161e-02f, 2.52134681e-01f, 2.92341471e-01f, -1.08505405e-01f, 2.48083979e-01f, -3.00303012e-01f, 4.38346118e-01f, -3.00295115e-01f, -2.64377981e-01f,
  2.47976348e-01f, 2.25667372e-01f, 2.87165791e-02f, -2.89995130e-02f, 3.30395907e-01f, -1.86551288e-01f, 4.46706861e-02f, -1.49085954e-01f, 1.05382524e-01f, -2.52461374e-01f,
  -6.34622481e-03f, 4.96533543e-01f, 3.65453819e-03f, -1.65388644e-01f, 2.95948774e-01f, -1.12250470e-01f, -1.70259953e-01f, 1.62773684e-01f, 3.42631757e-01f, -3.15744728e-01f,
  -1.03743739e-01f, 2.85381317e-01f, 3.89467776e-01f, 1.94608644e-02f, 3.56668353e-01f, -2.96898067e-01f, 1.77782848e-01f, -2.97358576e-02f, 1.05326436e-01f, -8.10438991e-02f,
  3.17392588e-01f, -2.40109921e-01f, 3.46229672e-01f, -5.76673374e-02f, -2.91925371e-02f, -9.52801332e-02f, 2.06066683e-01f, -1.40925899e-01f, -1.21291436e-01f, -9.95301530e-02f,
  -4.80688602e-01f, 1.61639482e-01f, -1.08977415e-01f, 2.36205235e-02f, 1.81964859e-01f, -3.44123691e-01f, -1.71980590e-01f, -1.22009911e-01f, 1.80164903e-01f, 3.31945300e-01f,
  3.81904870e-01f, -2.67078280e-01f, -2.01679513e-01f, 3.96309830e-02f, -1.61636412e-01f, 2.17244355e-03f, 1.74717590e-01f, 2.93070823e-01f, 2.86554337e-01f, 6.67764321e-02f,
  -1.27390057e-01f, -1.41153052e-01f, 1.59141928e-01f, -6.79356456e-02f, 4.48197991e-01f, -3.26162428e-01f, 1.07481167e-01f, -8.52998644e-02f, -9.80550051e-02f, -6.45113066e-02f,
  -1.01718297e-02f, 4.52424884e-01f, 2.80385345e-01f, 3.43553036e-01f, -4.21024952e-03f, 3.03807288e-01f, -3.41069490e-01f, 2.90260434e-01f, 1.25161782e-01f, 1.21691581e-02f,
  3.52467090e-01f, 2.10854650e-01f, 2.68379062e-01f, 4.82501179e-01f, 1.90412208e-01f, 2.88355798e-01f, 2.94198334e-01f, -2.27520809e-01f, -1.58126414e-01f, 5.75119182e-02f,
  2.49336865e-02f, 2.45220691e-01f, 7.37010539e-02f, -3.51748675e-01f, -2.33560383e-01f, 1.31704956e-01f, -2.54571378e-01f, 9.24660563e-02f, -5.26564717e-02f, 1.35304809e-01f,
  5.51473126e-02f, -5.32828346e-02f, 1.38501465e-01f, 1.93630412e-01f, 4.46057022e-01f, 2.33008131e-01f, -1.08569726e-01f, 1.29155740e-01f, -2.39824206e-01f, -1.33236691e-01f,
  4.57229167e-02f, 3.34444314e-01f, -8.03493038e-02f, -3.00353169e-01f, 2.37210810e-01f, 2.39168078e-01f, 2.51541529e-02f, -5.34864776e-02f, 1.62682548e-01f, -4.22500789e-01f,
  -3.33930925e-02f, 3.71524125e-01f, -1.45122439e-01f, 2.08531216e-01f, 2.46694267e-01f, -9.26077887e-02f, -3.61859016e-02f, -3.40204686e-01f, -6.32647425e-02f, 3.18027020e-01f,
  -2.43851632e-01f, -2.23249719e-01f, -5.57748899e-02f, -6.76603336e-03f, -9.29644480e-02f, -1.73884839e-01f, 6.91157281e-02f, -2.52815858e-02f, 1.34756148e-01f, -3.72038275e-01f,
  -2.07416937e-01f, 2.83024043e-01f, -2.93372959e-01f, 8.47834796e-02f, 2.13051006e-01f, 7.84663185e-02f, -6.49772808e-02f, 8.58320668e-02f, -2.92100340e-01f, -5.45697697e-02f,
  -3.03020269e-01f, -7.70837860e-03f, 2.00750664e-01f, 4.09426153e-01f, -3.25280614e-02f, -2.07699165e-01f, 3.49594563e-01f, 2.91220099e-01f, 1.44306079e-01f, -9.87637192e-02f,
  -6.28644824e-02f, 9.48923379e-02f, 1.60224419e-02f, 1.64416581e-01f, -2.78908201e-02f, -4.18189913e-01f, -4.22178470e-02f, -1.60934646e-02f, -2.57592231e-01f, 1.88649833e-01f,
  4.52928543e-02f, 1.26043901e-01f, 4.65902686e-01f, 8.39311406e-02f, 4.98905420e-01f, -2.68567502e-01f, 3.06909263e-01f, 1.25027940e-01f, 6.48491532e-02f, 3.05228740e-01f,
  1.38742551e-01f, -3.71598154e-01f, -3.43976647e-01f, 1.62413865e-01f, 2.92158782e-01f, 1.02241263e-01f, -1.32629693e-01f, 1.03972599e-01f, -1.88452870e-01f, 6.89859241e-02f,
  -1.91123247e-01f, 2.13914886e-01f, 1.26025870e-01f, -3.33939046e-01f, -1.23562634e-01f, 1.82376131e-01f, 8.76140743e-02f, 2.04983249e-01f, 2.85813719e-01f, 4.28508788e-01f,
  -1.47959277e-01f, -3.53259355e-01f, -2.10794687e-01f, 4.68832552e-01f, -1.34033067e-02f, 2.09931180e-01f, 2.18001276e-01f, -1.84181362e-01f, -2.40841508e-02f, -2.10218087e-01f,
  1.80935144e-01f, -3.21424127e-01f, 5.86692393e-02f, 2.48095617e-02f, 3.91989231e-01f, 2.69176871e-01f, -1.44256026e-01f, -2.35503837e-01f, 4.38019961e-01f, 2.72694021e-01f,
  1.35792047e-03f, -5.72611690e-01f, 2.74506032e-01f, -1.19866513e-01f, 2.54637063e-01f, 3.21423672e-02f, 5.87144941e-02f, -1.20639823e-01f, -3.48012522e-02f, 1.50693461e-01f,
  6.89499006e-02f, -1.13679670e-01f, 9.34143886e-02f, -6.71828464e-02f, 1.82473734e-01f, -1.98092043e-01f, -5.14219820e-01f, -3.14141035e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.27255425e-01f, 1.49308130e-01f, -2.52244659e-02f, 2.02365164e-02f, 7.07545376e-04f, 1.17730722e-01f, -5.78114539e-02f, 1.13169298e-01f, -1.15189999e-01f, 8.69985372e-02f,
  -1.53495923e-01f, 1.70158374e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    