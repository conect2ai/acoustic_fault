/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.93633323e-02f, -4.80727367e-02f, 1.07425496e-01f, 2.74880767e-01f, -3.41212451e-02f, -1.71160668e-01f, -3.02759674e-03f, -6.83368789e-03f, -3.40058990e-02f, 3.46742682e-02f,
  -2.41018176e-01f, -2.98485875e-01f, -2.55937696e-01f, -1.57394439e-01f, -9.14812386e-02f, 1.34321108e-01f, 3.25190514e-01f, -7.74998292e-02f, -2.23138526e-01f, -1.97628662e-01f,
  -4.77998070e-02f, 1.38441578e-01f, 1.75521359e-01f, -9.91882980e-02f, 9.98718664e-02f, -2.60414958e-01f, 2.38839075e-01f, -4.20647068e-03f, -1.37094468e-01f, 2.18603879e-01f,
  -2.42580384e-01f, 3.01057138e-02f, -4.74785529e-02f, -1.08679570e-01f, -5.42062260e-02f, -4.73166257e-02f, -3.26237865e-02f, 1.15005471e-01f, -1.15461070e-02f, 8.18672869e-03f,
  2.66120136e-02f, -1.57928560e-02f, 1.60883944e-02f, 2.77072992e-02f, 9.91671905e-02f, -5.07043824e-02f, 1.43313736e-01f, 7.85675570e-02f, 2.53277440e-02f, -1.90353803e-02f,
  -8.27176794e-02f, 1.98615342e-02f, 4.50682268e-02f, -7.64057785e-02f, 1.89171149e-03f, -1.87933110e-02f, -3.69159831e-03f, -9.65557098e-02f, -8.24531391e-02f, -1.91462832e-03f,
  -5.73792309e-02f, -1.93428695e-02f, -7.31987730e-02f, 4.51731607e-02f, 6.09234758e-02f, 2.53110770e-02f, 1.20855376e-01f, 3.73560786e-02f, 5.09616137e-02f, 7.19642267e-02f,
  -7.45051354e-02f, 6.53561801e-02f, 6.91735074e-02f, 9.97410640e-02f, 9.04389173e-02f, 1.24810927e-01f, -5.28035425e-02f, 4.16057706e-02f, 3.59834405e-04f, 8.32347423e-02f,
  -1.53430207e-02f, -1.05080381e-02f, 1.06484711e-01f, 6.35056347e-02f, -3.55471335e-02f, 2.79480070e-02f, 1.78522244e-02f, -1.00712925e-01f, 4.60150056e-02f, 2.65603159e-02f,
  -9.76543687e-03f, -2.87964586e-02f, -2.78718919e-02f, 1.53685613e-02f, -1.11939909e-03f, 9.69308335e-03f, -1.91227663e-02f, -9.01990607e-02f, -7.18065500e-02f, -6.59609661e-02f,
  -1.33900389e-01f, -2.79667731e-02f, 8.72489586e-02f, -4.68199514e-03f, 3.26281376e-02f, -2.32735164e-02f, 3.42921875e-02f, 1.84335429e-02f, 2.48888438e-03f, 2.00954778e-03f,
  6.77418336e-02f, 4.62974012e-02f, -1.32520169e-01f, -7.68504143e-02f, -1.23074315e-02f, -1.90076694e-01f, -4.35759686e-02f, -9.37346965e-02f, -1.76721677e-01f, 7.70385889e-03f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.52504045e-01f, 2.86287576e-01f, -9.24058259e-01f, -8.40420306e-01f, -7.98103034e-01f, -2.74551630e-01f, 2.42844939e-01f, 5.12489565e-02f, -3.78701724e-02f, 4.60801013e-02f,
  -1.01344913e-01f, 3.29919718e-02f, 1.68428585e-01f, 1.51170328e-01f, 3.46246988e-01f, -6.18445948e-02f, -6.35710955e-01f, -3.46773624e-01f, -8.18189681e-02f, -1.10699376e-02f,
  -1.47517443e-01f, -3.29085648e-01f, -2.34326422e-01f, -1.24519512e-01f, -1.19482033e-01f, 1.44489542e-01f, -3.71571451e-01f, -4.06711459e-01f, -1.26703560e-01f, -4.31229711e-01f,
  3.11830223e-01f, -4.26051021e-01f, -2.51967192e-01f, -2.73526430e-01f, -9.19013247e-02f, 1.05922312e-01f, 1.06539272e-01f, -8.37586597e-02f, 5.46807423e-02f, -6.79322332e-02f,
  -3.57439965e-01f, -7.37385005e-02f, -2.97177434e-01f, -2.13002056e-01f, -2.70429552e-01f, -1.22473992e-01f, -3.06465626e-01f, -3.38516980e-01f, -2.95128286e-01f, -2.09240958e-01f,
  -4.00135934e-01f, -4.39853072e-01f, 9.49640200e-02f, -6.39331713e-02f, -1.23655401e-01f, -4.32190001e-01f, -4.90171718e-04f, -1.40494674e-01f, -1.14979260e-01f, 2.65004665e-01f,
  -6.67735115e-02f, 1.90383479e-01f, 4.08503562e-02f, -7.86655396e-02f, -8.80015045e-02f, -2.81374231e-02f, -4.03256789e-02f, 2.76740283e-01f, -1.47648752e-01f, 2.45560288e-01f,
  -1.14355296e-01f, -9.25589129e-02f, 1.44461721e-01f, 8.89888182e-02f, -1.03789560e-01f, -4.62528728e-02f, 1.66067109e-01f, 1.44544482e-01f, -2.16499567e-01f, 4.69196439e-02f,
  -9.80438665e-02f, -9.84054133e-02f, 1.57657452e-03f, 1.62188500e-01f, -2.97183961e-01f, -1.56300455e-01f, -3.24157774e-02f, 1.72975808e-01f, 1.19358197e-01f, -1.60383418e-01f,
  5.35637677e-01f, -5.25718451e-01f, 1.52390286e-01f, 2.61405185e-02f, 6.33811131e-02f, 4.09457833e-02f, -1.25007749e-01f, 1.46460593e-01f, 7.31003582e-02f, 3.37538123e-01f,
  -2.67000515e-02f, 2.10521832e-01f, -1.76755395e-02f, 1.17861316e-01f, -6.74208030e-02f, -1.24834567e-01f, 1.07910827e-01f, 4.64404635e-02f, -8.02996680e-02f, 8.09798241e-02f,
  -5.86776920e-02f, 2.10959256e-01f, 6.60334051e-01f, 3.26398343e-01f, 2.26407036e-01f, 1.85766414e-01f, 4.14596289e-01f, 2.53556728e-01f, 3.79275531e-01f, 6.24263525e-01f,
  -3.93644601e-01f, 8.35814714e-01f, 5.41155159e-01f, -4.27036762e-01f, 1.29379168e-01f, 4.42003787e-01f, 8.47584188e-01f, 1.61912948e-01f, -3.80997807e-01f, 2.26735055e-01f,
  1.62961394e-01f, -5.13984025e-01f, -1.73450112e-01f, -2.01878294e-01f, -6.19004034e-02f, 3.46719623e-01f, 3.41732204e-01f, -1.50557205e-01f, -4.35301036e-01f, -3.39612484e-01f,
  -1.66400790e-01f, -1.62605733e-01f, -1.87801033e-01f, -5.78285232e-02f, 2.60170382e-02f, -4.23321009e-01f, 2.38451675e-01f, 3.19430470e-01f, 3.44341546e-01f, 4.55238968e-02f,
  -3.11918437e-01f, 3.58041793e-01f, -4.89964485e-01f, -4.71683472e-01f, -3.56368050e-02f, -1.35788456e-01f, -7.59813339e-02f, -1.00590564e-01f, 3.99687290e-02f, -2.50600907e-03f,
  -2.42685810e-01f, -2.01777384e-01f, 2.89440285e-02f, 5.31152599e-02f, -2.34859318e-01f, -1.31734028e-01f, -2.05517020e-02f, -1.31084189e-01f, -1.25986218e-01f, -9.97576788e-02f,
  9.78256240e-02f, 1.44482002e-01f, 4.52146977e-01f, 2.59278506e-01f, 1.11902915e-01f, -4.16109204e-01f, 2.72656947e-01f, -6.34111390e-02f, 1.66367650e-01f, -1.24100246e-01f,
  -6.50192723e-02f, 6.49419278e-02f, 1.32755697e-01f, 4.02812399e-02f, 1.33185655e-01f, -4.43049967e-02f, -1.19200446e-01f, -3.47919278e-02f, 2.59095803e-04f, 4.15502712e-02f,
  9.63995084e-02f, -1.10262260e-01f, -3.85298841e-02f, 8.62965733e-02f, -1.50720462e-01f, 1.53711124e-03f, 2.65847463e-02f, -2.28999741e-03f, 4.53400724e-02f, -4.71449569e-02f,
  -1.60038054e-01f, 1.20892704e-01f, -1.89241976e-01f, -1.09672379e-02f, 7.12314546e-02f, 3.75464037e-02f, -1.75479040e-01f, -1.47654682e-01f, 8.42031911e-02f, 3.74277890e-01f,
  -5.05510747e-01f, 5.23087382e-01f, -4.37691003e-01f, 1.49211138e-02f, -1.76708680e-02f, -5.20356407e-04f, 1.15036123e-01f, -3.78184556e-03f, 7.85339847e-02f, -1.22960052e-02f,
  -2.65515093e-02f, 7.81636834e-02f, 1.00436047e-01f, 4.43587899e-02f, -3.02214652e-01f, -1.51730269e-01f, -1.51053900e-02f, -1.99436933e-01f, -1.29877418e-01f, -9.08873752e-02f,
  3.80662717e-02f, -1.84728816e-01f, -4.60981280e-01f, 9.93493013e-03f, -5.08613288e-02f, -5.11655390e-01f, -2.73133546e-01f, -3.34179550e-01f, -2.53702104e-01f, -2.80395180e-01f,
  -8.33007216e-01f, -2.34609425e-01f, -2.87298232e-01f, -6.93065226e-02f, 2.31342003e-01f, -4.32116389e-01f, -7.31769800e-01f, -6.98378205e-01f, -2.24458367e-01f, -2.71286108e-02f,
  5.82669914e-01f, 6.30490005e-01f, 2.36422092e-01f, 1.27030034e-02f, -7.08409071e-01f, -5.00742435e-01f, -7.56560802e-01f, -6.22246683e-01f, -4.19187784e-01f, 1.03159934e-01f,
  3.82105142e-01f, 4.01136540e-02f, -1.68124124e-01f, 1.03039630e-01f, 5.50266027e-01f, 4.19908762e-01f, 3.19577724e-01f, 2.26228237e-01f, 1.85706645e-01f, 3.03439528e-01f,
  5.71015954e-01f, -4.29721683e-01f, -1.60416931e-01f, 6.82694986e-02f, 1.85709596e-01f, -2.29545116e-01f, -1.16008900e-01f, -5.12961149e-02f, -1.38945341e-01f, -1.11812994e-01f,
  2.67005771e-01f, 3.78434593e-03f, -3.49991173e-02f, 3.72202218e-01f, -3.91265936e-03f, -5.25763780e-02f, 3.86363245e-03f, -3.29289526e-01f, -1.65383980e-01f, 2.31848836e-01f,
  3.86276633e-01f, 1.42737448e-01f, -2.39750281e-01f, -2.43989408e-01f, -1.16544187e-01f, -9.82416142e-03f, 1.35416090e-01f, 7.11506084e-02f, -2.56661773e-01f, -6.05405681e-02f,
  -5.54667227e-02f, 1.34806586e-02f, -7.33076129e-03f, -1.48438830e-02f, -6.90921023e-02f, 7.94346705e-02f, 8.04434717e-02f, 1.88202500e-01f, 8.04287381e-03f, 6.93307221e-02f,
  -4.80435118e-02f, -1.35443151e-01f, -7.62992278e-02f, -9.21176374e-02f, 1.39031649e-01f, 2.72334144e-02f, 2.17759460e-02f, 1.16131175e-02f, -3.35217780e-03f, -6.68912753e-02f,
  -1.42008260e-01f, 2.05393713e-02f, 7.48213232e-02f, 4.86639552e-02f, -7.93772712e-02f, -9.39951912e-02f, 5.64750545e-02f, 1.11380599e-01f, 1.18899249e-01f, -1.40929585e-02f,
  3.57569367e-01f, -2.51903206e-01f, 7.85228387e-02f, -1.76396742e-01f, -4.04293835e-02f, 8.31644833e-02f, 2.61317581e-01f, 2.89568231e-02f, -4.53132130e-02f, -1.05713502e-01f,
  -8.96536112e-02f, 2.05115303e-02f, 1.27480716e-01f, 2.66704291e-01f, 3.10174003e-02f, 7.23663270e-02f, -8.19203854e-02f, 6.03193566e-02f, -1.73114240e-01f, 3.38119924e-01f,
  -2.07399324e-01f, -2.97507375e-01f, -2.47262433e-01f, -8.76600146e-02f, -1.77076787e-01f, -1.95145264e-01f, 1.86082527e-01f, 1.14451535e-01f, -2.58953452e-01f, -1.40984967e-01f,
  -1.00804317e+00f, -3.45426202e-01f, -3.39223802e-01f, -2.85870910e-01f, -1.58174321e-01f, 1.05806805e-01f, 7.43364021e-02f, 3.90022039e-01f, 5.37544787e-02f, -4.85902160e-01f,
  -5.95116258e-01f, 4.47509810e-02f, -2.28380218e-01f, 4.09897193e-02f, 2.11155564e-01f, -2.47369811e-01f, 1.25787601e-01f, 2.84012914e-01f, 4.78192955e-01f, 3.81758928e-01f,
  1.51488438e-01f, -1.48613360e-02f, 1.29550636e-01f, 3.40054750e-01f, -2.64449954e-01f, 9.43470225e-02f, -1.76355854e-01f, -1.71207473e-01f, -8.74925256e-02f, -3.96068186e-01f,
  -7.96520889e-01f, -4.07349199e-01f, 2.02535037e-02f, -8.27896148e-02f, -1.02314539e-01f, -2.02971533e-01f, 7.02757807e-03f, -8.03944096e-02f, -1.70130089e-01f, -9.87499878e-02f,
  -1.85644001e-01f, -2.99064331e-02f, -8.80206302e-02f, 7.37025449e-03f, 7.32900426e-02f, 5.35534509e-02f, 1.77806973e-01f, 1.52195171e-01f, 3.02627571e-02f, -9.22028273e-02f,
  4.24850471e-02f, -1.73444778e-01f, -4.28254485e-01f, 2.39953116e-01f, 2.95681087e-03f, 5.07814884e-02f, 1.01122027e-03f, 1.05935745e-01f, 6.37371838e-02f, -6.12506866e-01f,
  1.24636777e-01f, 8.08221474e-02f, 8.00766274e-02f, 7.58666396e-02f, 1.03861958e-01f, -1.70166530e-02f, 1.30234584e-01f, -2.48512477e-02f, 2.34187365e-01f, 2.37612873e-02f,
  1.40514910e-01f, -7.02517033e-02f, 1.05025992e-01f, -5.85512742e-02f, -1.09680966e-01f, -4.70793918e-02f, 6.58887327e-02f, 6.92976192e-02f, -5.12579158e-02f, -1.14087977e-01f,
  -4.43173274e-02f, -1.86124034e-02f, -4.30927537e-02f, 1.78200170e-01f, -1.03820294e-01f, 1.83972165e-01f, -1.28284320e-01f, 4.77195121e-02f, -3.83673646e-02f, -8.71580914e-02f,
  -5.98575175e-02f, 4.07525450e-01f, -3.03224117e-01f, 1.19844778e-03f, 1.90247372e-02f, -8.65897834e-02f, -6.03314955e-03f, 9.66455936e-02f, -3.79076377e-02f, -6.35277247e-03f,
  -1.75396036e-02f, -1.96407557e-01f, -1.66018996e-02f, 1.77199766e-01f, 8.86995159e-03f, -7.49926642e-02f, -1.21283740e-01f, -2.12591872e-01f, 1.39898330e-01f, -1.66082084e-01f,
  1.24310836e-01f, -1.19977444e-01f, -3.71748418e-01f, -1.36605471e-01f, -7.71301612e-02f, -3.73070568e-01f, -1.62805021e-01f, -5.87805733e-02f, -2.28592440e-01f, -5.19109309e-01f,
  -2.68932874e-03f, -1.10897675e-01f, -1.50306180e-01f, 3.45921874e-01f, 3.03977668e-01f, 1.11997403e-01f, 3.95995826e-02f, 2.38377020e-01f, 3.87175620e-01f, 2.70773739e-01f,
  1.22732855e-01f, 2.76415884e-01f, 4.37216580e-01f, 2.48145074e-01f, 1.72228128e-01f, 2.13805705e-01f, 2.78281063e-01f, 8.65211189e-02f, 1.37283981e-01f, 2.15238914e-01f,
  3.69290501e-01f, 1.43866614e-02f, -1.32143557e-01f, 1.53779924e-01f, 3.71090174e-01f, 4.74673957e-01f, 1.49113253e-01f, -5.27763972e-03f, 8.19089487e-02f, 3.83656591e-01f,
  -2.16388911e-01f, -2.75583237e-01f, 3.57551485e-01f, 1.65877447e-01f, -7.65295625e-02f, -1.21352740e-01f, 3.12667415e-02f, -1.43221647e-01f, -6.45844415e-02f, 7.75825381e-02f,
  -9.47191045e-02f, -1.32729813e-01f, 9.16791800e-03f, -5.78015707e-02f, -6.44548461e-02f, -7.32623488e-02f, -1.81400236e-02f, -1.08059170e-02f, 1.18669560e-02f, 2.86525767e-02f,
  4.40944694e-02f, -1.71046034e-01f, -3.52180958e-01f, 3.83410603e-02f, 4.70555387e-02f, 6.51852861e-02f, 1.82607472e-02f, -4.59700972e-02f, 8.42606556e-03f, 9.79250222e-02f,
  9.41168442e-02f, -3.66748124e-03f, 3.60409394e-02f, 7.12974668e-02f, 1.45026609e-01f, 1.52000025e-01f, 7.09527880e-02f, -8.69147107e-02f, 1.81833446e-01f, -9.22543034e-02f,
  5.71569689e-02f, 1.57643422e-01f, 2.49561071e-02f, 5.42217307e-02f, 3.58480722e-01f, -1.79710045e-01f, -4.83346879e-02f, -6.88830018e-02f, -1.29883643e-02f, -1.08205648e-02f,
  3.16138230e-02f, 7.98039362e-02f, -1.44950626e-02f, 1.86463177e-01f, 9.45722088e-02f, 1.16460234e-01f, 3.88906822e-02f, 9.64605361e-02f, 1.33990753e-03f, -1.10114448e-01f,
  -4.74629641e-01f, -2.46534526e-01f, 2.22819343e-01f, -1.31218387e-02f, -1.14414692e-01f, -6.04431890e-02f, -1.90996826e-02f, -8.62620100e-02f, -1.36393636e-01f, 6.75107492e-03f,
  -2.19250843e-01f, -1.47012934e-01f, -1.37647122e-01f, -1.19740747e-01f, -6.45875931e-02f, -1.64320573e-01f, -3.81491184e-02f, -4.49176580e-02f, -1.03644699e-01f, -1.99723586e-01f,
  -1.03749394e-01f, -1.50369465e-01f, -3.16069126e-01f, -4.04251851e-02f, 1.05423667e-02f, 1.93162747e-02f, -1.87146664e-01f, -2.38881797e-01f, -1.77260682e-01f, -2.32397765e-01f,
  -4.49963510e-01f, -7.41827846e-01f, -6.25340104e-01f, -7.95982897e-01f, -4.47001338e-01f, -1.13430485e-01f, -5.40325820e-01f, -1.62493765e-01f, -3.17236096e-01f, -7.80450523e-01f,
  -4.49328661e-01f, 1.84259042e-01f, -2.24194586e-01f, 2.15721935e-01f, 2.05346286e-01f, -6.26513600e-01f, -5.15046418e-01f, 9.74752530e-02f, 6.51698112e-01f, 3.28994453e-01f,
  -1.31055236e-01f, -1.79874286e-01f, 2.65244156e-01f, 1.14901759e-01f, -6.58131778e-01f, -2.11482778e-01f, -6.99300408e-01f, -2.86448419e-01f, -1.93448052e-01f, -8.34858656e-01f,
  -3.92005444e-01f, -4.28201556e-02f, 1.36427537e-01f, 2.79097229e-01f, -1.83020651e-01f, 9.24519226e-02f, -1.70966834e-01f, -4.60287184e-02f, 1.12939656e-01f, -2.63209820e-01f,
  -5.87968007e-02f, 1.36967883e-01f, 1.70906670e-02f, 3.49337421e-02f, 1.27372320e-03f, 1.25581875e-01f, 6.05088957e-02f, -3.88174132e-02f, -9.14403424e-02f, -2.65312637e-03f,
  -5.81419049e-03f, 9.95236263e-02f, 6.19133227e-02f, -2.31283028e-02f, 2.85075694e-01f, 2.25561634e-01f, -2.30234280e-01f, 3.75658542e-01f, 3.33897263e-01f, -4.34047997e-01f,
  -5.12360297e-02f, -8.72736573e-02f, 4.10632007e-02f, 1.20711699e-01f, 5.12461960e-02f, -4.06383574e-02f, -3.98623385e-02f, -1.71645820e-01f, -2.08464563e-02f, -3.26831974e-02f,
  -6.07322119e-02f, -1.38452977e-01f, -5.12487479e-02f, -1.92427740e-01f, -1.07526399e-01f, -9.15527530e-03f, -7.22120181e-02f, 2.91124228e-02f, -8.62135887e-02f, 4.45197150e-02f,
  1.02287389e-01f, 1.49016097e-01f, 3.22396569e-02f, 1.08820841e-01f, -3.64292040e-02f, -1.27908858e-02f, 7.60376360e-03f, 1.60660401e-01f, 4.63879555e-02f, 8.85796547e-02f,
  -2.79534250e-01f, 4.20320749e-01f, -4.77567106e-01f, 1.16053693e-01f, -1.75580248e-01f, 3.03730685e-02f, -7.79652596e-02f, 2.09665611e-01f, 4.90690721e-03f, -1.65779114e-01f,
  1.78513676e-01f, -1.98649541e-01f, -2.19049692e-01f, -1.87323317e-02f, 2.27455478e-02f, -4.73636836e-02f, -1.29833609e-01f, -1.79911792e-01f, 4.30669822e-02f, 1.77822441e-01f,
  -2.31204778e-02f, 6.96943104e-02f, 3.49459089e-02f, -1.64151415e-01f, -8.35130140e-02f, 6.39577722e-03f, -3.26892614e-01f, -1.80754006e-01f, -7.20285997e-02f, -6.11433625e-01f,
  -1.41670287e+00f, 2.04320103e-01f, -5.36638945e-02f, -8.98904860e-01f, -3.92142087e-01f, 3.48738283e-02f, 4.05003160e-01f, 2.01948155e-02f, -1.55430883e-01f, 3.55913520e-01f,
  3.51995200e-01f, -4.12306309e-01f, -2.64081180e-01f, -1.48947060e-01f, -2.13417843e-01f, 1.37945652e-01f, -4.30547863e-01f, -6.21690810e-01f, -6.97790623e-01f, -7.87378028e-02f,
  -2.01782718e-01f, -8.50359499e-01f, -8.62703085e-01f, -4.87024218e-01f, -1.19648613e-01f, -2.73617774e-01f, -9.99455303e-02f, -2.78153747e-01f, 3.07157546e-01f, -2.00635508e-01f,
  4.64920819e-01f, -2.07752272e-01f, -5.02687730e-02f, -3.53179455e-01f, -1.28708065e-01f, 6.04681335e-02f, -2.51361467e-02f, -1.70197561e-01f, 4.53354865e-02f, 1.52665202e-03f,
  -1.94322050e-01f, -7.91883394e-02f, -3.58530819e-01f, -3.48688513e-02f, -2.19558194e-01f, 6.12731762e-02f, 4.77754790e-03f, -9.07795727e-02f, 1.22293308e-02f, 4.28449512e-01f,
  1.62532270e-01f, -1.43985795e-02f, 9.87599790e-02f, 2.81969368e-01f, 2.40234718e-01f, -1.53682590e-01f, 3.09692621e-01f, 2.06311285e-01f, 2.16734201e-01f, 1.49055183e-01f,
  -4.95751249e-03f, 2.12142207e-02f, -1.51543031e-02f, -4.72845212e-02f, -2.12323219e-02f, -6.66561648e-02f, -1.51501402e-01f, 4.10214625e-02f, -1.92058519e-01f, 1.57665014e-01f,
  1.11581236e-01f, 3.58483265e-03f, 7.82697350e-02f, -2.67147813e-02f, 8.75895545e-02f, -3.11246049e-02f, 7.16335922e-02f, 1.31225688e-02f, 1.12318702e-01f, -2.09402908e-02f,
  -9.12499875e-02f, -9.50778183e-03f, 1.96108241e-02f, 5.77591993e-02f, 1.56462416e-01f, -3.06591615e-02f, 1.40659690e-01f, 1.03920974e-01f, -9.16473195e-02f, -6.69790655e-02f,
  -3.32335263e-01f, -1.19926259e-01f, -6.34558722e-02f, -2.84458753e-02f, -7.75393620e-02f, 1.35298640e-01f, -9.96600911e-02f, 1.62952557e-01f, -1.38538286e-01f, 4.47023958e-02f,
  2.33909152e-02f, -3.17954957e-01f, -2.04271436e-01f, 9.83569399e-02f, -8.73446763e-02f, 1.70450229e-02f, -7.26227313e-02f, -1.78303376e-01f, 6.70157447e-02f, 2.30063125e-01f,
  1.88055098e-01f, 1.20897464e-01f, -3.02037857e-02f, 1.44606754e-01f, 1.13467768e-01f, -2.92552918e-01f, 1.40592754e-01f, 8.58866721e-02f, 5.92204742e-02f, 2.12273635e-02f,
  7.23892152e-01f, 2.98259053e-02f, 4.85861480e-01f, 2.55760670e-01f, -6.64053202e-01f, -6.32918596e-01f, -7.12527752e-01f, -3.59795779e-01f, -7.97335580e-02f, -1.33353919e-01f,
  -2.93333471e-01f, 1.52131906e-02f, 1.28569990e-01f, 1.76825359e-01f, 3.91081780e-01f, -3.81574593e-02f, 4.11187440e-01f, 8.28500926e-01f, 5.23794889e-01f, -2.28462294e-02f,
  2.30569020e-02f, 5.35827339e-01f, 6.59174442e-01f, 2.27147773e-01f, -3.74810696e-02f, -7.29716243e-03f, 1.83878794e-01f, 2.39799142e-01f, 4.67720553e-02f, 4.02739614e-01f,
  1.38169587e-01f, -9.01017115e-02f, -1.70318365e-01f, -4.25633378e-02f, -6.30977675e-02f, 1.40319392e-01f, -8.26165155e-02f, 2.87027091e-01f, -2.54333407e-01f, 5.48073873e-02f,
  -9.49107558e-02f, 2.69046687e-02f, -1.07937209e-01f, 3.95260602e-02f, -1.19892377e-02f, -6.79239035e-02f, 3.02602828e-01f, 4.81622487e-01f, 1.64270997e-01f, -1.66440964e-01f,
  -1.50200188e-01f, -2.29514882e-01f, -2.63795197e-01f, -2.05083698e-01f, -1.39861166e-01f, 4.87874486e-02f, -1.03722826e-01f, -3.93589176e-02f, 2.75021084e-02f, 1.27760649e-01f,
  -4.71459255e-02f, 2.93471143e-02f, 2.42847726e-02f, 1.27761200e-01f, 1.88828055e-02f, -1.26791760e-01f, 4.96650413e-02f, -2.33550835e-02f, 8.70281160e-02f, -1.08229958e-01f,
  1.86698176e-02f, -6.02037385e-02f, -5.40148318e-02f, -1.03669532e-03f, 3.69025841e-02f, 3.47466655e-02f, -6.28938004e-02f, 1.18789755e-01f, 1.33013204e-02f, 1.70301646e-02f,
  1.04048863e-01f, -1.35970488e-02f, 1.30078480e-01f, 9.28160250e-02f, -6.70374632e-02f, 1.49054736e-01f, 1.45810932e-01f, -2.83708125e-02f, -1.09510031e-02f, 3.10536548e-02f,
  -9.94701162e-02f, -2.35906094e-01f, -8.37388039e-02f, -8.70732516e-02f, 8.62531438e-02f, -9.16048512e-03f, -9.98959094e-02f, 1.20795794e-01f, -1.54428542e-01f, 3.14827561e-02f,
  -3.33856076e-01f, -6.75356239e-02f, -1.08721061e-02f, 2.15674080e-02f, -1.07367709e-03f, -8.25837329e-02f, -1.80965826e-01f, -7.20565021e-02f, 8.32018778e-02f, -2.14674756e-01f,
  -2.42822655e-02f, -4.98202652e-01f, -4.90025699e-01f, -2.52249002e-01f, -3.67073774e-01f, -2.37408161e-01f, -2.18410939e-01f, -3.84100795e-01f, -3.75688970e-01f, -4.87121522e-01f,
  -1.07518649e+00f, -8.84942934e-02f, 3.79862189e-01f, -1.28161579e-01f, 6.00490987e-01f, 4.20209020e-02f, -5.26100218e-01f, -8.00145388e-01f, -1.64868325e-01f, 7.07177743e-02f,
  6.12355232e-01f, 1.12350613e-01f, 2.86828876e-01f, 3.92077491e-02f, -3.74010980e-01f, 1.22579850e-01f, 2.42029995e-01f, -1.31017610e-01f, -4.84767437e-01f, -4.09650326e-01f,
  1.39176119e-02f, -1.68256134e-01f, -3.22062522e-01f, -2.83430398e-01f, -8.91547501e-02f, -2.39016153e-02f, 1.96780533e-01f, 1.42296448e-01f, 2.42536709e-01f, 9.30334534e-03f,
  -1.08045384e-01f, -5.08220732e-01f, -1.08011425e-01f, 3.07266623e-01f, 3.53270918e-01f, -2.08226144e-01f, -1.72327563e-01f, -8.07330459e-02f, 6.78669885e-02f, -4.15666997e-02f,
  2.76951820e-01f, 1.72994599e-01f, 2.39482582e-01f, -8.32993463e-02f, -1.49808571e-01f, -4.15415823e-01f, -1.52330264e-01f, -5.20059288e-01f, -2.76952118e-01f, -3.96977901e-01f,
  3.81896645e-01f, 2.08969101e-01f, -2.95451045e-01f, -2.98791289e-01f, -4.58666533e-01f, 2.43006274e-02f, -4.28461760e-01f, -6.90859258e-01f, -6.79683566e-01f, -9.87781942e-01f,
  6.68745264e-02f, 1.54430076e-01f, 1.12095721e-01f, -4.90212291e-02f, -1.01143554e-01f, 3.48742157e-02f, 1.68902576e-01f, 5.87121099e-02f, -1.24559253e-01f, -1.64255843e-01f,
  5.43125048e-02f, 6.37919158e-02f, -8.69838297e-02f, 1.29308254e-02f, 1.39091946e-02f, -1.18182942e-01f, 1.55778369e-02f, -1.31112784e-01f, -5.79288555e-03f, -7.27530643e-02f,
  -1.40682922e-03f, 1.13658816e-01f, 2.10806072e-01f, -2.73503453e-01f, 4.91629243e-02f, 1.87650453e-02f, 6.57141954e-02f, -4.87473756e-02f, -1.16101466e-01f, 7.39427656e-02f,
  -3.37080330e-01f, 5.26879311e-01f, -2.65327960e-01f, -1.28276022e-02f, -6.37561008e-02f, 1.78719208e-01f, 4.93307859e-02f, 6.78332672e-02f, 1.71992257e-01f, -2.38175452e-01f,
  -1.89742491e-01f, -2.51542270e-01f, 2.07841530e-01f, -6.45504147e-02f, -7.81238601e-02f, -1.19024254e-01f, 1.69441402e-01f, -8.46167430e-02f, 9.75011736e-02f, -9.76005122e-02f,
  -4.02027778e-02f, -3.46722722e-01f, -6.02595389e-01f, -4.64326710e-01f, -2.97947228e-01f, -2.17345402e-01f, -3.82346749e-01f, -5.06578267e-01f, -4.66995895e-01f, -1.05509794e+00f,
  9.70663667e-01f, -5.80317795e-01f, -1.06893023e-02f, 1.57691557e-02f, -9.78461131e-02f, -9.19685140e-02f, -3.06176722e-01f, -1.31612852e-01f, -5.61651178e-02f, -2.99134161e-02f,
  9.05261487e-02f, 4.80823696e-01f, 2.44158015e-01f, 2.86001563e-01f, 2.21075535e-01f, -2.78567076e-01f, -2.90469259e-01f, 2.11434126e-01f, 4.33715582e-01f, 2.46156484e-01f,
  -1.11422993e-01f, -1.86457664e-01f, -9.05634612e-02f, 1.40977639e-03f, -3.64862800e-01f, 1.52389750e-01f, -2.40397364e-01f, -2.02787682e-01f, -2.11225882e-01f, -2.63852835e-01f,
  1.69994846e-01f, 1.14652943e-02f, 1.59477711e-01f, -6.10115379e-02f, -5.60369678e-02f, 4.68833447e-02f, 1.08293667e-01f, 9.86807887e-03f, -1.61639191e-02f, -1.63032129e-01f,
  -1.05997078e-01f, -6.14228733e-02f, 1.22523576e-03f, -4.62548360e-02f, -1.56033039e-01f, -3.87279391e-02f, -6.67274073e-02f, 8.21441114e-02f, -1.38240661e-02f, -2.51584575e-02f,
  -1.73301578e-01f, -6.56964257e-03f, -2.12598834e-02f, 1.98719874e-02f, 9.90266353e-02f, 1.10305227e-01f, -6.38941601e-02f, -7.26124570e-02f, 2.40554035e-01f, 4.43704193e-03f,
  6.74488693e-02f, 1.37549207e-01f, 1.60800532e-01f, 7.13463202e-02f, 1.98772326e-01f, -8.99093575e-04f, -1.85769761e-03f, 5.44791184e-02f, 1.89096853e-01f, 3.46068069e-02f,
  -6.47125989e-02f, 1.37611985e-01f, 1.09088041e-01f, -1.40173323e-02f, 6.85085952e-02f, -1.02030642e-01f, 1.24497777e-02f, -5.79491369e-02f, 7.29288012e-02f, -1.43918410e-01f,
  4.21126373e-02f, -6.09853957e-03f, -1.47067979e-01f, -1.91422313e-01f, -2.11720556e-01f, -6.17154911e-02f, 1.60346292e-02f, 1.04497053e-01f, -8.51962343e-02f, -3.86121981e-02f,
  -2.80860275e-01f, 3.07315558e-01f, 1.03741258e-01f, 6.23647347e-02f, 5.90068623e-02f, -1.08119540e-01f, 1.65142491e-01f, -2.71779820e-02f, -2.81314731e-01f, -1.36150509e-01f,
  -1.24984019e-01f, -2.38138027e-02f, -7.64471516e-02f, -1.27147228e-01f, 8.28397349e-02f, -5.65875284e-02f, -2.18003709e-02f, 1.96526155e-01f, -1.02216832e-01f, -2.48875335e-01f,
  -2.49230459e-01f, 7.63598904e-02f, 2.35306188e-01f, 1.60920203e-01f, 1.78954661e-01f, 3.02587479e-01f, 4.65636142e-02f, 2.55053882e-02f, 1.23715639e-01f, 1.00971401e-01f,
  -2.88238347e-01f, -3.73325706e-01f, 5.41266561e-01f, 3.67203742e-01f, 6.11243546e-01f, 6.99846745e-01f, 5.42705476e-01f, 1.51340023e-01f, -1.54645815e-01f, -4.02607508e-02f,
  -2.08106175e-01f, -4.74870563e-01f, -4.63997453e-01f, -5.14373720e-01f, -3.01777631e-01f, 2.72547603e-01f, 4.38243955e-01f, 6.86024651e-02f, 2.58259267e-01f, 3.04705977e-01f,
  8.24639052e-02f, 1.93981618e-01f, -1.35672927e-01f, -1.26217261e-01f, 1.22237228e-01f, 4.33012247e-02f, 9.65131521e-02f, 2.74044126e-01f, -5.27686104e-02f, -3.90153900e-02f,
  1.34981126e-01f, -2.22299561e-01f, 1.03560416e-02f, -4.35726494e-01f, -7.36746639e-02f, -2.40545526e-01f, -8.41914341e-02f, -1.37351558e-01f, -1.05139457e-01f, -9.38567892e-02f,
  -3.70486453e-02f, -4.43957895e-02f, -6.38101250e-02f, -4.07530777e-02f, 1.94501281e-01f, 2.39022751e-03f, -8.63605738e-02f, -2.41613194e-01f, -2.98032075e-01f, -2.84171313e-01f,
  -1.35602161e-01f, 2.33714625e-01f, 2.25338921e-01f, 4.64348271e-02f, -1.77531436e-01f, -1.12131722e-01f, -5.30344248e-02f, -2.81775035e-02f, -3.28706726e-02f, -2.76444227e-01f,
  -6.69583604e-02f, 1.52050212e-01f, 8.96527171e-02f, 9.31896195e-02f, 1.41908824e-01f, 1.29571363e-01f, 1.67960986e-01f, 2.38326997e-01f, 4.73779477e-02f, 1.82479501e-01f,
  7.44588971e-02f, -5.95635623e-02f, -6.36397768e-03f, -3.33564356e-03f, -5.93318306e-02f, 9.03563648e-02f, 1.30627796e-01f, -1.35212213e-01f, -8.59647840e-02f, 7.83239603e-02f,
  2.22882088e-02f, 9.22037885e-02f, 4.47554365e-02f, -3.92555706e-02f, 4.19801921e-02f, 3.47793512e-02f, 2.22818665e-02f, -7.73622170e-02f, -3.21475863e-02f, -2.41213408e-03f,
  -2.79064178e-01f, -3.02014351e-01f, -1.34662449e-01f, -2.46553555e-01f, 1.79999292e-01f, -1.77614138e-01f, -1.68352962e-01f, -9.68923047e-02f, 3.47620621e-02f, -6.69962391e-02f,
  4.69732694e-02f, -3.64128500e-02f, -7.16895536e-02f, -2.28896588e-02f, 2.59096533e-01f, 1.36580423e-01f, -2.22200006e-01f, 1.85492232e-01f, -1.15767367e-01f, -2.74914671e-02f,
  -1.29615590e-01f, 2.22913265e-01f, 2.05612287e-01f, 2.14061975e-01f, 1.63687468e-02f, 1.02864370e-01f, 1.51347667e-01f, 1.62149459e-01f, 1.55102521e-01f, 9.24512520e-02f,
  8.29859197e-01f, 3.56630474e-01f, 4.54151124e-01f, 4.09000635e-01f, -1.14963287e-02f, -2.94620633e-01f, -3.29846710e-01f, -3.55556428e-01f, -1.37547597e-01f, 1.94754511e-01f,
  3.70767802e-01f, -1.24074630e-01f, 6.84648473e-03f, -2.65557438e-01f, -3.34120899e-01f, -1.42950639e-01f, -1.08192950e-01f, -2.63511389e-02f, -4.21931505e-01f, -3.80987912e-01f,
  -2.35304415e-01f, 9.67494026e-02f, 2.04590082e-01f, -1.40528157e-01f, 4.24065232e-01f, -1.50125682e-01f, 3.15031111e-01f, 5.56896269e-01f, 2.67607749e-01f, 5.44195056e-01f,
  5.57557404e-01f, 7.07318068e-01f, -3.71502012e-01f, -1.00146994e-01f, 2.20128760e-01f, 1.29154511e-02f, 5.52878529e-02f, 1.11811377e-01f, -7.24909082e-02f, 2.82186666e-03f,
  1.21176794e-01f, 5.51103987e-02f, -6.38477206e-02f, 8.14274885e-03f, 4.00349088e-02f, -1.97122261e-01f, -8.59397054e-02f, -9.72590446e-02f, -8.00223053e-02f, 1.08613074e-01f,
  -1.41258419e-01f, 2.03647926e-01f, 2.27056026e-01f, -3.74544799e-01f, -1.89998046e-01f, -2.41102070e-01f, 2.76540127e-02f, 3.60989645e-02f, -1.48083687e-01f, 7.25859329e-02f,
  -9.99994278e-02f, 1.25982255e-01f, 1.23543806e-01f, 1.73639774e-01f, 5.11626452e-02f, 3.23130302e-02f, 8.17575380e-02f, -4.68350947e-02f, -9.01442543e-02f, 1.04585595e-01f,
  -1.11735843e-01f, 1.66129246e-02f, 5.93268983e-02f, 9.99320820e-02f, -7.55388215e-02f, 1.41606748e-01f, -2.88923793e-02f, -4.57391664e-02f, 4.72441278e-02f, 6.47172779e-02f,
  -8.12955350e-02f, -3.51272523e-02f, 1.32694095e-01f, -9.28837359e-02f, -5.02112620e-02f, 1.05944075e-01f, 7.31135830e-02f, -7.91259576e-03f, 5.57462126e-02f, 2.54345179e-01f,
  -3.35820943e-01f, -1.80586293e-01f, 1.36106133e-01f, -4.58687805e-02f, 2.04599902e-01f, 1.14651978e-01f, 2.39592314e-01f, -4.44753580e-02f, 3.87077570e-01f, -5.02573662e-02f,
  -2.85435631e-03f, 7.71976262e-03f, 1.10902905e-01f, -1.17745109e-01f, -1.33951366e-01f, -3.54864672e-02f, 2.77415738e-02f, -9.17937234e-02f, -1.96544006e-01f, 2.29317158e-01f,
  -1.85289487e-01f, -4.56494719e-01f, -2.17195481e-01f, -2.60066807e-01f, -1.51279762e-01f, -3.74934584e-01f, -1.43129945e-01f, -2.24257872e-01f, -3.61299723e-01f, -5.16608357e-01f,
  8.07764113e-01f, -3.59971434e-01f, -3.27054918e-01f, 4.71617848e-01f, 2.66558174e-02f, -5.83227612e-02f, 2.35875502e-01f, 1.37628227e-01f, 3.32621723e-01f, 3.07126224e-01f,
  -4.38034147e-01f, -5.25831819e-01f, -4.06787515e-01f, -4.24098372e-01f, -1.82741180e-01f, 2.71759778e-01f, 3.18839908e-01f, -8.11495185e-02f, -1.54038325e-01f, -8.48679990e-02f,
  7.48552158e-02f, 3.25864315e-01f, 3.13952118e-01f, -1.57328382e-01f, -7.68674985e-02f, -4.22790088e-02f, 1.06741101e-01f, -5.98855726e-02f, -3.17475319e-01f, -2.74474084e-01f,
  -2.18397304e-01f, -2.39506900e-01f, 4.01877388e-02f, -3.06413192e-02f, 2.44136769e-02f, 1.64933383e-01f, 1.18504971e-01f, 4.70258594e-02f, -1.12276465e-01f, -3.74115482e-02f,
  -2.44949073e-01f, -3.30522299e-01f, -3.73551458e-01f, -1.13142267e-01f, -7.18230158e-02f, -2.27081287e-03f, 1.04829326e-01f, -2.18456239e-01f, -8.95133242e-02f, -3.26365292e-01f,
  -2.94949979e-01f, -2.98175216e-01f, -2.60542691e-01f, -5.23241311e-02f, -2.95942187e-01f, -1.48650438e-01f, -3.50393623e-01f, -3.80542994e-01f, -3.28600913e-01f, 8.31087213e-03f,
  4.02229540e-02f, 4.80076559e-02f, -7.02877641e-02f, 1.44115865e-01f, 2.95166373e-01f, -6.90387189e-02f, -4.78258356e-02f, 8.22150633e-02f, 2.60274746e-02f, 1.19014800e-01f,
  -1.80611685e-01f, -4.56275195e-02f, -1.87932491e-01f, 8.98092911e-02f, -3.32186483e-02f, -5.01024611e-02f, 1.01778403e-01f, 8.85031149e-02f, -1.68130010e-01f, 1.41146347e-01f,
  -1.59559306e-02f, -5.80927320e-02f, -2.73811314e-02f, -1.67643297e-02f, -7.28505552e-02f, -2.02777222e-01f, 1.23633184e-01f, -1.12422235e-01f, 6.77264035e-02f, -2.77139936e-02f,
  4.56889927e-01f, -1.90891936e-01f, 2.06426889e-01f, -5.39193936e-02f, 8.97508562e-02f, -1.34740517e-01f, 1.15877703e-01f, -8.43243152e-02f, -1.29075572e-01f, -4.14030217e-02f,
  -1.78332642e-01f, -2.63123065e-01f, -2.28254125e-01f, -3.91115574e-03f, 9.54407156e-02f, 1.32507160e-01f, 6.57687485e-02f, -1.31536787e-02f, 3.80271189e-02f, 1.78087369e-01f,
  2.39290148e-01f, 3.87527406e-01f, 4.97874767e-01f, 2.19662532e-01f, 5.41812815e-02f, 2.56642342e-01f, 2.90856808e-01f, 9.21142176e-02f, 6.35698587e-02f, 7.65296459e-01f,
  8.65360439e-01f, 1.35703698e-01f, -7.81081796e-01f, 6.42590284e-01f, -5.13486922e-01f, -7.74245918e-01f, -4.86461788e-01f, -6.48092851e-02f, 5.01349628e-01f, 1.78636238e-01f,
  -3.24027508e-01f, -1.33254498e-01f, 4.09014486e-02f, -1.45390302e-01f, -4.21719342e-01f, -4.17521149e-01f, -3.38654846e-01f, -5.27447879e-01f, -6.60364032e-01f, -5.67365646e-01f,
  -1.26360804e-01f, 8.70988965e-02f, 1.79081246e-01f, -1.02858052e-01f, 2.49597743e-01f, -1.88340934e-03f, 4.77440432e-02f, 4.43252027e-02f, -3.95896822e-01f, 2.36909658e-01f,
  -4.66896206e-01f, 1.19156398e-01f, -3.40009063e-01f, -4.52787690e-02f, -1.38671726e-01f, -2.67531965e-02f, -7.62789845e-02f, 1.84913844e-01f, 8.98570865e-02f, -1.61898565e-02f,
  -1.59046412e-01f, -4.33009118e-02f, -8.32357332e-02f, -1.15218297e-01f, -1.90777302e-01f, -1.88652053e-01f, 1.25412703e-01f, -1.25762150e-01f, 2.24701874e-02f, -1.96054712e-01f,
  -1.54313937e-01f, -2.18826011e-01f, -2.08221778e-01f, -5.32250199e-03f, 7.81346411e-02f, -1.70871824e-01f, -1.32013232e-01f, -7.32431784e-02f, -2.31980145e-01f, 4.88142908e-01f,
  5.71635030e-02f, 4.59190942e-02f, -6.56920820e-02f, 1.15417190e-01f, 1.94196507e-01f, -4.59525734e-02f, 4.38139215e-02f, 3.85109633e-02f, 7.12310337e-03f, 7.26795271e-02f,
  1.60682779e-02f, 1.75487213e-02f, 1.70774572e-02f, -7.65318125e-02f, -1.93269134e-01f, -1.48447320e-01f, -5.86607195e-02f, 1.09320700e-01f, -1.27124004e-02f, -1.02941625e-01f,
  -2.60560755e-02f, -5.65239377e-02f, -9.74462554e-02f, 5.41352667e-03f, -1.08649962e-01f, -3.17310616e-02f, 5.47393830e-03f, 2.38451846e-02f, 2.86490694e-02f, 1.27215341e-01f,
  1.42439529e-01f, -2.81810701e-01f, 1.17211431e-01f, -1.38567016e-01f, -7.29579329e-02f, -6.31543400e-04f, 1.02354519e-01f, 9.55207199e-02f, 9.74848270e-02f, 5.10000624e-03f,
  -2.18381882e-01f, -3.26786302e-02f, 2.43600026e-01f, 1.27134407e-02f, -1.37154892e-01f, -6.27681762e-02f, -3.64066660e-02f, -2.19020396e-01f, -1.59060568e-01f, 1.27847195e-01f,
  1.62984625e-01f, -1.23603232e-01f, -6.18120283e-02f, -2.08335812e-04f, 1.71201244e-01f, -1.86093882e-01f, -1.88477576e-01f, -1.12687901e-01f, -3.81292760e-01f, 3.02514911e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.10551417e+00f, 8.52939785e-01f, 5.03500700e-01f, 5.40418029e-01f, 1.87474802e-01f, 4.21448469e-01f, 6.63213611e-01f, 4.06179905e-01f, 6.83448732e-01f, 5.80286622e-01f,
  4.83584315e-01f, 7.70796418e-01f, 5.22009611e-01f, 7.93948054e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -6.53552115e-02f, 3.31278853e-02f, -3.43214244e-01f, -5.23435175e-01f, 1.47924304e-01f, 2.76998341e-01f, -2.40733370e-01f, -1.64652634e-02f, 1.80229336e-01f, 4.39121872e-01f,
  -1.07635580e-01f, -2.98990101e-01f, -4.97671925e-02f, 2.63620496e-01f, -2.49147981e-01f, 4.35202837e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.17558756e-01f, -7.64397085e-02f, 6.06483072e-02f, -7.29982555e-01f, 1.16449073e-01f, 3.53437476e-02f, 4.74657029e-01f, 8.96273673e-01f, -7.90212214e-01f, 1.12394512e+00f,
  -7.36951157e-02f, 6.06474638e-01f, -4.58001196e-01f, 5.79088926e-01f, 2.15391308e-01f, 1.23350763e+00f, 4.28191990e-01f, 2.24008024e-01f, 1.47842377e-01f, 2.22075969e-01f,
  8.77971724e-02f, -3.15489292e-01f, -1.18805900e-01f, -5.78814566e-01f, 3.90988827e-01f, 5.92610657e-01f, 2.06652805e-01f, -1.07246232e+00f, -5.26928842e-01f, 7.35200763e-01f,
  6.48449659e-01f, 1.02603030e+00f, 4.21060115e-01f, 2.65983731e-01f, 7.70060644e-02f, 2.11252451e-01f, 2.21497983e-01f, 5.09230494e-01f, 3.40208672e-02f, 1.15523212e-01f,
  -6.14346802e-01f, 3.98611218e-01f, -4.03799355e-01f, -7.77849257e-01f, 3.67517531e-01f, -1.16808340e-01f, 8.18130195e-01f, 7.50971019e-01f, 4.51877832e-01f, 5.01681045e-02f,
  -5.80301508e-03f, -5.37766479e-02f, -8.83921236e-02f, 9.54485357e-01f, 3.24400276e-01f, 1.25838065e+00f, -3.26963365e-01f, 3.32902491e-01f, 6.40864253e-01f, 5.75550556e-01f,
  -2.94440895e-01f, -5.24207771e-01f, -3.10081333e-01f, 1.25564858e-01f, 3.73196900e-01f, -8.45227316e-02f, -4.21282381e-01f, 8.50170553e-01f, 9.76549760e-02f, 1.13821661e+00f,
  1.03453487e-01f, 4.40034389e-01f, 4.87635821e-01f, 2.63316005e-01f, 8.04733634e-01f, -7.44274259e-01f, -2.47188479e-01f, 3.22207481e-01f, -1.04293728e+00f, 3.85220587e-01f,
  5.16456485e-01f, 2.67145514e-01f, -2.83672780e-01f, 1.21393311e+00f, 3.90843391e-01f, -5.22972584e-01f, -5.01930535e-01f, -4.90971208e-01f, 6.70415640e-01f, 2.53476858e-01f,
  7.17924297e-01f, -4.41649824e-01f, 4.24144775e-01f, 1.16758227e+00f, -9.61778164e-01f, 1.89860210e-01f, -4.13485736e-01f, -2.06909373e-01f, 5.89297831e-01f, 4.58184421e-01f,
  3.80011559e-01f, 8.65532458e-01f, 5.12095571e-01f, 7.75380135e-01f, 5.99828660e-01f, -5.36653101e-01f, 4.98563170e-01f, 1.29821047e-01f, -4.11362126e-02f, -7.24038661e-01f,
  -4.10311669e-01f, -3.18972021e-01f, 2.85526842e-01f, -1.38619706e-01f, 3.87437433e-01f, -6.18589044e-01f, 8.21394145e-01f, -2.69390255e-01f, 1.02985430e+00f, -2.82934308e-01f,
  -3.63906771e-01f, -2.09481254e-01f, 3.59320432e-01f, 2.26811305e-01f, 6.45690739e-01f, -3.72785956e-01f, 1.10975933e+00f, 6.78802073e-01f, 3.57747912e-01f, 2.65949160e-01f,
  -1.15984030e-01f, 4.38457847e-01f, -9.95448884e-03f, -4.80959088e-01f, 5.85158706e-01f, -5.30804634e-01f, 3.81510764e-01f, -5.53396046e-01f, 4.88419980e-01f, -3.30788553e-01f,
  7.87181616e-01f, 3.88903022e-01f, 2.03858331e-01f, 2.78960139e-01f, 2.40993097e-01f, -2.92097211e-01f, 8.77828896e-01f, 4.57463384e-01f, 2.97128350e-01f, 1.30562901e-01f,
  -1.73866212e-01f, 7.03131676e-01f, 2.38512099e-01f, -2.55877664e-03f, -8.21260288e-02f, 1.07394367e-01f, 1.31922528e-01f, -7.76891112e-01f, 2.63659120e-01f, -7.77866185e-01f,
  4.13196117e-01f, -1.19043872e-01f, 5.48654377e-01f, -5.95259070e-02f, 7.52781987e-01f, -5.90188384e-01f, -2.99615681e-01f, -3.58300328e-01f, 3.92882645e-01f, -4.16783273e-01f,
  4.00265247e-01f, 2.07003221e-01f, 6.21057928e-01f, 5.55846930e-01f, 8.72591376e-01f, 1.75833732e-01f, 6.29075393e-02f, -7.25645274e-02f, 3.70831251e-01f, 6.58745408e-01f,
  -1.32163990e+00f, -7.66939223e-01f, 5.46389461e-01f, 7.30549991e-01f, -5.13094664e-01f, 4.36188459e-01f, -9.72443521e-01f, 3.11676413e-01f, 6.02994621e-01f, 6.80717647e-01f,
  1.84146196e-01f, 4.15999889e-01f, 3.73390853e-01f, -1.80433303e-01f, 7.23463535e-01f, -2.31472135e-01f, 4.43002254e-01f, 5.23054838e-01f, 4.33149278e-01f, 3.95573914e-01f,
  1.08512521e+00f, -1.10204804e+00f, 9.27406698e-02f, -4.65227485e-01f, -7.25414813e-01f, -5.22626638e-01f, 4.00140405e-01f, 8.75808954e-01f, -2.19277471e-01f, 6.85811741e-03f,
  3.47800702e-01f, -9.13750708e-01f, 1.02023947e+00f, -8.06493536e-02f, 3.74028355e-01f, 2.02548891e-01f, -2.23739177e-01f, -3.54602374e-02f, 6.79318383e-02f, 3.92117262e-01f,
  1.95435677e-02f, 6.33846402e-01f, -4.18100536e-01f, 7.16827095e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  6.43938959e-01f, 1.19543724e-01f, 7.36572862e-01f, 3.51654649e-01f, 8.00907254e-01f, 1.44136071e-01f, -1.12228379e-01f, 2.76697427e-01f, 3.17781091e-01f, -5.23619771e-01f,
  2.64534295e-01f, 6.71127975e-01f, 4.07552809e-01f, -1.12771735e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -1.19806774e-01f, 3.78017724e-01f, 9.64942276e-02f, -4.73596334e-01f, 1.56026781e-01f, 4.14046526e-01f, 7.16334879e-02f, -1.15971243e+00f, 1.59880549e-01f, -4.01043713e-01f,
  -4.15848792e-01f, 3.06237899e-02f, -1.69213817e-01f, -3.32582325e-01f, 1.97986752e-01f, 3.78846973e-01f, -5.17652929e-01f, -4.42088008e-01f, 5.88509142e-01f, -1.03272855e+00f,
  -5.08133292e-01f, 5.79103410e-01f, -1.30155170e+00f, -1.81237012e-01f, -7.33121410e-02f, 8.19511339e-02f, -3.95052775e-04f, 4.05490786e-01f, -1.49774298e-01f, 5.00281215e-01f,
  -1.48531720e-01f, 2.88589597e-01f, -1.18858311e-02f, 2.86455691e-01f, 4.38241333e-01f, -2.02036902e-01f, 3.87142539e-01f, 8.51372838e-01f, 4.90287274e-01f, -3.21520865e-01f,
  -1.15251906e-01f, -5.80753148e-01f, -1.25583267e+00f, -1.39818057e-01f, -6.67246163e-01f, -3.79959792e-01f, -1.21314669e+00f, -3.05932164e-01f, -6.75494909e-01f, -7.55227268e-01f,
  -1.53350961e+00f, -1.77624926e-01f, -1.05733860e+00f, 2.36519739e-01f, -2.53002997e-03f, 1.06551439e-01f, 5.52906036e-01f, -1.01155615e+00f, -7.29420632e-02f, 6.42477393e-01f,
  -4.17242385e-02f, -1.19395995e+00f, 1.35132134e-01f, -5.51648736e-01f, 4.89436612e-02f, 5.27099311e-01f, -2.96212826e-02f, 1.81497723e-01f, -4.80033249e-01f, -1.74967766e-01f,
  1.47485092e-01f, 2.83524990e-02f, -6.02048375e-02f, -2.13605896e-01f, 2.78749168e-01f, -6.21380329e-01f, 2.86811709e-01f, -3.28202844e-01f, 3.22911799e-01f, 3.21942061e-01f,
  5.03393471e-01f, -3.55069071e-01f, 1.50776446e-01f, 6.92814529e-01f, 6.52596653e-01f, -2.30373427e-01f, -6.72914386e-01f, -1.35677922e+00f, -3.99329662e-01f, 4.83914584e-01f,
  4.29069763e-03f, -4.00359333e-01f, -1.33913949e-01f, -3.39567959e-01f, 5.70762455e-01f, 4.11125049e-02f, -2.49423236e-01f, 4.50906187e-01f, 6.18686080e-01f, 5.72131395e-01f,
  4.83368814e-01f, -9.80570555e-01f, 1.24995351e-01f, 6.95773736e-02f, -8.33305240e-01f, -7.64424920e-01f, -5.95407307e-01f, 1.25263169e-01f, -9.96013939e-01f, 5.41661739e-01f,
  -4.03835028e-02f, -1.77928135e-01f, 2.82563180e-01f, -6.58955753e-01f, -2.14302197e-01f, -6.75989211e-01f, 2.36512229e-01f, 1.82067215e-01f, 3.89445871e-01f, -4.37440015e-02f,
  5.57392359e-01f, 8.83902535e-02f, 3.56029421e-01f, -9.54526007e-01f, -6.61722064e-01f, 2.09848583e-01f, -2.87718624e-01f, -4.31707263e-01f, -1.18508689e-01f, -4.17143524e-01f,
  -3.74794930e-01f, -1.38739288e+00f, 5.39491057e-01f, -7.88067341e-01f, -9.08764601e-01f, -5.79331696e-01f, -7.83412158e-01f, 5.36917150e-01f, 5.17515540e-01f, 2.15194285e-01f,
  8.79338920e-01f, 3.07070464e-01f, -1.28947282e+00f, -6.37418270e-01f, -2.19697446e-01f, 9.50467408e-01f, 1.55795500e-01f, 2.89613098e-01f, -3.39874476e-01f, -6.61447123e-02f,
  9.69026610e-02f, 3.89831156e-01f, -1.11791015e+00f, 8.18599537e-02f, 5.11138998e-02f, -4.41378623e-01f, 3.25639337e-01f, -4.92920935e-01f, -9.89385784e-01f, 7.99918056e-01f,
  -5.82004547e-01f, -5.64716399e-01f, -1.53711128e+00f, -6.28141463e-01f, -1.04941165e+00f, -8.17195952e-01f, -9.68121111e-01f, -3.36009741e-01f, 2.54785597e-01f, 4.50840592e-01f,
  -4.18598950e-01f, 9.42257941e-01f, 6.04766130e-01f, -1.36004770e+00f, 9.79179814e-02f, 7.06617534e-01f, 4.67029847e-02f, -4.44360077e-01f, -1.00427794e+00f, 1.66838601e-01f,
  1.16232567e-01f, -8.97264898e-01f, 1.25369146e-01f, 9.95859146e-01f, -1.05886126e+00f, -5.84564924e-01f, 4.94867504e-01f, -1.36535034e-01f, 1.69002697e-01f, 2.06800804e-01f,
  -4.49184239e-01f, -1.12832141e+00f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.31259102e-01f, -1.91570744e-02f, 2.46750623e-01f, -5.50492167e-01f, -1.71422914e-01f, 5.85586056e-02f, 2.62382150e-01f, 1.12151816e-01f, -1.37783200e-01f, -3.69107068e-01f,
  -5.26560009e-01f, 1.42332718e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    