/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.05347967e-01f, -3.73478681e-01f, 1.18346959e-01f, -1.18643120e-01f, 1.78560883e-01f, -1.55285686e-01f, -4.01894748e-02f, -1.89121459e-02f, -7.32671842e-02f, -1.66475177e-01f,
  4.29547541e-02f, 1.21284515e-01f, -1.08329430e-01f, -1.92337528e-01f, 3.78214210e-01f, -3.81279022e-01f, 1.23937257e-01f, 4.65989957e-04f, -9.57039669e-02f, 1.37690768e-01f,
  3.75218093e-02f, -6.30478263e-02f, 7.11681321e-02f, -6.96836561e-02f, 1.16037890e-01f, 8.10035989e-02f, 2.22128540e-01f, -9.21214931e-03f, 4.76424098e-02f, 2.51989868e-02f,
  -1.67980179e-01f, -1.56650871e-01f, 4.41166386e-02f, 4.45286259e-02f, 1.31979585e-01f, 6.39124066e-02f, 4.89070155e-02f, 2.27014478e-02f, 8.82420465e-02f, -3.96393724e-02f,
  7.22162239e-03f, 9.02540162e-02f, -7.54669458e-02f, 3.48230824e-02f, 9.56930295e-02f, 5.01272865e-02f, 2.13100351e-02f, 1.82584487e-02f, -4.59745154e-02f, -2.58056372e-02f,
  -3.82532291e-02f, 7.53156245e-02f, 3.88249196e-02f, 9.83812730e-04f, 2.08147839e-02f, 2.70440858e-02f, 1.29287355e-02f, 4.36782837e-02f, -1.90381450e-03f, -8.15784000e-03f,
  2.30545718e-02f, 4.30621393e-03f, -1.06156403e-02f, 1.27117441e-03f, -2.53965743e-02f, 1.37894880e-02f, -1.15753838e-03f, -4.39486206e-02f, 3.00977193e-02f, -1.87486243e-02f,
  2.96733566e-02f, 1.77890826e-02f, -1.70875136e-02f, 3.31304371e-02f, 3.09591591e-02f, -2.88537685e-02f, 2.38483716e-02f, -2.68464200e-02f, 2.60893498e-02f, 2.74732262e-02f,
  -5.32830767e-02f, -2.30848771e-02f, -5.41546829e-02f, -1.49270764e-03f, 1.06887484e-03f, 3.08123622e-02f, -2.62573920e-02f, 1.44058196e-02f, 1.31618688e-02f, 2.55783368e-02f,
  -1.44554134e-02f, -9.55382213e-02f, -7.41471052e-02f, -1.88519119e-03f, -9.07030627e-02f, -1.48623642e-02f, -5.74318096e-02f, -4.15041894e-02f, 1.09314546e-02f, -1.80807989e-02f,
  1.18420847e-01f, 6.26306608e-02f, 7.11057410e-02f, 5.17250746e-02f, 1.23906685e-02f, -2.17391960e-02f, -2.73636337e-02f, 5.28497323e-02f, 8.66723359e-02f, 4.84928712e-02f,
  7.47938305e-02f, 4.63196263e-02f, -9.69986059e-03f, -1.66145246e-02f, 4.52510528e-02f, 7.84676746e-02f, -2.18857173e-02f, 2.34550815e-02f, 3.46374549e-02f, 5.48135526e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.47426176e-01f, 7.08669186e-01f, 6.50035620e-01f, -3.86254132e-01f, 9.52427909e-02f, -7.99093768e-02f, -2.01462463e-01f, 1.75400928e-01f, -6.03641868e-02f, -2.36161649e-02f,
  -9.67485607e-02f, 2.71537006e-01f, 1.61430821e-01f, -1.32003371e-02f, -4.44897413e-01f, -7.48382881e-02f, -2.92256445e-01f, -1.51123539e-01f, 1.22246906e-01f, -5.76266162e-02f,
  -2.37322494e-01f, -2.26670578e-01f, 7.07309321e-02f, 2.46171489e-01f, 7.93501511e-02f, 1.59083419e-02f, -3.69537026e-01f, 2.17389151e-01f, 2.26637702e-02f, 1.04519486e-01f,
  -7.68899918e-02f, -1.78192526e-01f, 1.22540683e-01f, 1.63804054e-01f, -7.09421784e-02f, -6.96409643e-02f, -9.13977027e-02f, 4.93517742e-02f, 4.65267859e-02f, 4.62666713e-02f,
  1.50719564e-02f, 6.34358078e-02f, -5.77001609e-02f, 5.57757951e-02f, 3.55390199e-02f, 1.80809036e-01f, 1.89294517e-01f, 8.81540030e-02f, 1.88344389e-01f, 2.06112623e-01f,
  1.01031102e-01f, 4.36224677e-02f, -3.71320881e-02f, -9.67769884e-03f, 9.73698962e-03f, -9.29981843e-03f, -7.04317093e-02f, 2.65811272e-02f, -5.19135110e-02f, -7.67338136e-03f,
  -1.68531120e-01f, -1.05214249e-02f, 9.25801024e-02f, -3.31021026e-02f, 4.03356887e-02f, 7.07357749e-02f, -3.75206284e-02f, -1.14544975e-02f, 5.78879677e-02f, -3.88088040e-02f,
  -7.59587623e-03f, 2.24243514e-02f, -4.51703416e-03f, -1.00589246e-01f, -5.70678934e-02f, -9.71990451e-02f, -1.41560854e-02f, -6.35167351e-03f, -3.57113853e-02f, -5.39117008e-02f,
  5.29084653e-02f, -6.79745972e-02f, 3.45563963e-02f, -3.03222835e-02f, 2.02327059e-03f, 3.77556426e-03f, 4.90015335e-02f, 5.93508519e-02f, -1.96841937e-02f, -1.45511925e-01f,
  -4.09139007e-01f, -4.07266855e-01f, -3.31433341e-02f, -9.09651257e-03f, -9.21547879e-03f, -1.28590059e-03f, -3.91648896e-02f, 2.54593007e-02f, -1.11530103e-01f, -4.64369580e-02f,
  -7.56377131e-02f, -7.88566694e-02f, -6.85590059e-02f, -3.07379197e-02f, -6.71070889e-02f, -2.17841770e-02f, -1.01912424e-01f, 8.42542667e-03f, -1.74720064e-01f, -8.92282091e-03f,
  -4.95898686e-02f, -5.46817593e-02f, -4.02980106e-04f, -2.40292512e-02f, -1.02731340e-01f, -1.16913028e-01f, -6.66104928e-02f, 5.95981590e-02f, -3.36317606e-02f, -2.42656376e-02f,
  -9.73792747e-03f, -2.77023256e-01f, -1.62386492e-01f, -9.59689766e-02f, -8.76084417e-02f, -2.98740208e-01f, -2.79133618e-01f, -2.49101028e-01f, 1.40229851e-01f, -8.48619714e-02f,
  -1.68968439e-02f, 1.52368262e-01f, 1.30979642e-01f, -2.11069569e-01f, 1.41668826e-01f, 1.73836038e-01f, -2.62704074e-01f, -6.73207417e-02f, 1.53403077e-02f, -2.03863084e-01f,
  2.65702810e-02f, -9.81800035e-02f, -3.14420462e-02f, -2.15451360e-01f, -1.83512673e-01f, -1.93335950e-01f, -1.27460819e-03f, -1.63992681e-02f, -1.20479532e-01f, 2.90715434e-02f,
  -7.98199326e-02f, 7.12965578e-02f, -1.18484259e-01f, 2.80711502e-02f, -1.42277971e-01f, -1.02473550e-01f, -2.20472217e-02f, 1.28615186e-01f, 9.59240943e-02f, 7.79475942e-02f,
  5.44580705e-02f, -3.91007736e-02f, -8.56766552e-02f, 3.34158540e-03f, -5.33871427e-02f, -9.65603217e-02f, -3.79803660e-03f, 1.51234632e-02f, -2.82714516e-02f, -9.09531415e-02f,
  -7.00767264e-02f, -3.52513604e-02f, -3.33157331e-02f, -1.66133475e-02f, -1.35811593e-03f, -1.15517974e-02f, 2.04464048e-02f, 3.64990793e-02f, 4.26206663e-02f, 3.18448395e-02f,
  -9.42764431e-03f, 6.34204671e-02f, 4.58890339e-03f, 3.28553049e-03f, -7.10838512e-02f, 8.90616551e-02f, 4.88033369e-02f, 5.77121601e-03f, -3.62767167e-02f, -6.42637610e-02f,
  -3.82784288e-03f, -2.07903329e-02f, -4.04753946e-02f, 2.37087882e-03f, -4.73841764e-02f, 1.03685215e-01f, -4.75034863e-02f, -3.66260633e-02f, -8.91328678e-02f, -5.27748168e-02f,
  -8.89647286e-03f, 4.53037433e-02f, -4.36377414e-02f, -1.24839516e-02f, -1.11810319e-01f, 8.79866537e-03f, -2.66322792e-02f, -6.65858090e-02f, 5.34129478e-02f, 7.37890974e-02f,
  -8.58404860e-02f, -7.39482418e-02f, 1.89478584e-02f, 1.01836368e-01f, -1.14574388e-01f, -1.17138095e-01f, -5.12482971e-02f, -3.41017954e-02f, -4.30615954e-02f, -5.32776341e-02f,
  -8.30418337e-03f, 6.21474870e-02f, -5.86868450e-02f, 1.66070182e-02f, -7.06377476e-02f, 5.93611374e-02f, -1.58249233e-02f, 3.75049636e-02f, -3.09152175e-02f, -1.09542824e-01f,
  -2.22688378e-03f, 9.08738002e-02f, 5.95617518e-02f, -5.59586845e-02f, 3.53339426e-02f, -4.47841920e-02f, 7.23509714e-02f, -7.43735358e-02f, -3.83603200e-02f, -4.11737636e-02f,
  2.37530664e-01f, -4.55121323e-02f, 1.02874227e-01f, 3.49176675e-01f, 1.42856345e-01f, -1.60081729e-01f, 9.46993157e-02f, -1.50275659e-02f, 1.11802593e-01f, -1.01376370e-01f,
  6.55377284e-02f, 1.00029297e-01f, 1.80036249e-03f, 6.42636791e-03f, -1.32840857e-01f, -1.02172725e-01f, -9.71283764e-02f, -8.45144391e-02f, 6.67942986e-02f, 1.87854152e-02f,
  -1.67943537e-02f, 9.49502066e-02f, 9.72657949e-02f, -1.36664748e-01f, 1.64867699e-01f, 1.25326544e-01f, -6.23239838e-02f, 2.10701153e-02f, -1.24751605e-01f, -8.11384469e-02f,
  -3.82807814e-02f, 1.02092192e-01f, 1.91790357e-01f, -6.33772314e-02f, 1.78745482e-02f, 6.70208922e-03f, -6.03862889e-02f, -4.23583761e-02f, 3.25620584e-02f, 4.95436341e-02f,
  2.23421562e-03f, -3.97686735e-02f, 6.26855791e-02f, 8.68287459e-02f, 4.71051447e-02f, -5.01467697e-02f, 4.05245759e-02f, 1.15365915e-01f, 4.68485057e-02f, -7.57412314e-02f,
  6.75557479e-02f, 6.26007840e-02f, -8.21238756e-02f, -6.42778948e-02f, 7.02509210e-02f, 1.04807325e-01f, -9.40294266e-02f, 3.63153294e-02f, -7.41904676e-02f, -1.08997421e-02f,
  -2.69649439e-02f, 1.32438811e-02f, -2.02607568e-02f, -4.11438495e-02f, 2.23759152e-02f, 5.25252447e-02f, -7.46537000e-03f, 1.66492071e-02f, -5.96867055e-02f, 5.16140088e-02f,
  -9.01949853e-02f, 8.78472701e-02f, -5.43277059e-03f, -3.40015590e-02f, 8.61796662e-02f, 1.63850542e-02f, -3.79124098e-02f, -1.42700998e-02f, -1.56647246e-02f, 5.61525933e-02f,
  -5.00282049e-02f, -4.83165905e-02f, 4.86496650e-02f, -1.08727038e-01f, 2.32481118e-02f, -5.11349365e-02f, 1.12474756e-02f, -6.34424537e-02f, 7.29656816e-02f, 1.41307842e-02f,
  -1.88855171e-01f, -1.75551414e-01f, -2.07108520e-02f, -6.53092861e-02f, -4.14442830e-02f, -9.06653181e-02f, -4.81436364e-02f, 2.56565511e-02f, -3.95670347e-02f, 7.56603433e-03f,
  1.53182754e-02f, -2.77622249e-02f, -2.42717583e-02f, -7.12905452e-02f, 4.12335880e-02f, -6.24702126e-02f, -6.71592131e-02f, -8.88028592e-02f, -2.18441840e-02f, -6.12021647e-02f,
  5.02442867e-02f, -3.40123922e-02f, -3.72816324e-02f, 6.48934394e-02f, -1.66318361e-02f, 2.75348499e-02f, -9.78866741e-02f, 3.83554138e-02f, -2.00970843e-02f, -5.30589297e-02f,
  -4.02150720e-01f, 4.64268029e-02f, 1.59259401e-02f, -4.31166619e-01f, -1.92940980e-01f, 7.88297281e-02f, -1.48805261e-01f, -1.30494282e-01f, 1.75074175e-01f, -2.54259050e-01f,
  -3.96230370e-01f, 9.40861106e-02f, 2.05278382e-01f, -4.53520209e-01f, 6.25562906e-01f, 4.41247880e-01f, -1.28550604e-01f, -1.27023235e-01f, 1.30327106e-01f, -2.77491361e-01f,
  -5.52996807e-02f, -4.67586845e-01f, -2.59282980e-02f, -2.66529620e-01f, -4.59933788e-01f, -1.65470898e-01f, -1.11833528e-01f, 1.14075683e-01f, -4.50200379e-01f, 9.42509696e-02f,
  -7.70099983e-02f, -4.27226126e-02f, -1.61367670e-01f, 8.86104405e-02f, -2.60692462e-03f, -7.72121400e-02f, -1.57210752e-02f, 2.01143697e-02f, -5.30088209e-02f, -2.86461003e-02f,
  -5.74959554e-02f, 2.56466176e-02f, -7.05798417e-02f, -1.54715087e-02f, -9.68300030e-02f, -3.62973139e-02f, -3.99166048e-02f, -1.53154256e-02f, -1.79286916e-02f, 9.71049964e-02f,
  -5.98257519e-02f, -3.24895815e-03f, -9.42862853e-02f, 4.98607419e-02f, -2.74029039e-02f, 1.32275792e-02f, -4.25624661e-02f, 3.55129056e-02f, 3.67873795e-02f, 1.16653323e-01f,
  -9.31902509e-03f, 5.99540882e-02f, 2.57393923e-02f, -9.24958363e-02f, -7.98844099e-02f, -5.96536510e-02f, -8.13398436e-02f, -2.80898232e-02f, -5.12665231e-03f, -1.27876718e-02f,
  -8.70282650e-02f, 8.92137084e-03f, -5.23209646e-02f, -1.34077352e-02f, -8.11076164e-02f, -3.58489864e-02f, 8.00577253e-02f, 7.74524659e-02f, -7.12089334e-03f, 8.33359584e-02f,
  -4.87357527e-02f, 3.76795530e-02f, -4.66032140e-02f, -1.26988459e-02f, 5.26406020e-02f, -8.87403823e-03f, -3.81256454e-02f, -6.06131405e-02f, 6.20273650e-02f, 1.99974868e-02f,
  8.26144516e-02f, 1.90641075e-01f, 1.78215150e-02f, -7.57937729e-02f, 6.95068166e-02f, 3.32598388e-02f, 6.97764233e-02f, -7.01264516e-02f, 6.91308156e-02f, 9.42648798e-02f,
  -5.40640168e-02f, -3.67882177e-02f, 4.21919823e-02f, -3.72652225e-02f, 6.33735582e-02f, 1.43896583e-02f, 8.07811841e-02f, 9.94580216e-04f, 4.20928784e-02f, 1.46734284e-03f,
  -7.13048354e-02f, -7.87978470e-02f, 5.01214601e-02f, -6.75381273e-02f, -1.39288008e-02f, -4.90237437e-02f, 1.33299353e-02f, 6.57520965e-02f, 3.46723497e-02f, 3.31611559e-02f,
  -2.61806965e-01f, 3.12707514e-01f, 1.25566885e-01f, 5.07864773e-01f, -1.92762256e-01f, -1.63800016e-01f, 8.67066756e-02f, 8.12792853e-02f, 1.20750219e-01f, 1.37755319e-01f,
  1.75588861e-01f, -8.58537257e-02f, 1.58926532e-01f, 4.83898371e-01f, 4.72791120e-02f, 2.20757380e-01f, 4.53786343e-01f, 1.52859271e-01f, 4.59358171e-02f, 1.08000390e-01f,
  1.98851421e-01f, 2.15768829e-01f, 4.04549003e-01f, 1.38848526e-02f, -2.42472086e-02f, -6.37485534e-02f, 1.89110786e-01f, -9.85574126e-02f, 5.93127534e-02f, -9.61155146e-02f,
  -8.70374888e-02f, 7.23286048e-02f, -3.11569422e-02f, -1.12883568e-01f, -9.18994565e-03f, -8.04681331e-02f, -5.00787161e-02f, -1.01551615e-01f, -8.63661990e-03f, 5.91608547e-02f,
  -1.08544283e-01f, -6.85515031e-02f, -7.72888735e-02f, -3.30175385e-02f, 3.29307717e-04f, 2.79757790e-02f, -1.88944377e-02f, 1.74312424e-02f, 4.66069654e-02f, -5.72649725e-02f,
  6.50562719e-02f, 6.64244145e-02f, 3.62343453e-02f, 2.62346268e-02f, 4.15871069e-02f, 7.31968433e-02f, 4.65006419e-02f, -3.12325694e-02f, 5.41525483e-02f, 1.03059232e-01f,
  -1.63163409e-01f, -2.42200885e-02f, 5.05146682e-02f, -5.12183830e-03f, -3.45674977e-02f, 2.19686255e-02f, -1.65120047e-02f, -1.38743389e-02f, 1.44848870e-02f, 8.44835341e-02f,
  6.44258633e-02f, -2.65214387e-02f, -7.87858851e-03f, 6.82801986e-03f, 3.65599059e-02f, 2.28907354e-02f, -6.34389967e-02f, 2.72160526e-02f, 1.63311753e-02f, -5.28982207e-02f,
  -1.16390386e-03f, -1.79868692e-03f, 6.95285127e-02f, 2.11499296e-02f, 3.80672254e-02f, -2.61668977e-03f, -4.83612157e-02f, 4.29698825e-02f, 4.04364355e-02f, -2.86474768e-02f,
  1.14532955e-01f, 3.10407609e-01f, -2.40350869e-02f, -1.30416393e-01f, 2.02474352e-02f, -8.33127201e-02f, 4.43169475e-02f, -1.29070450e-02f, 9.86264274e-02f, 1.25160022e-02f,
  -1.39952883e-01f, -1.59532726e-02f, -4.57822718e-02f, 4.84086340e-03f, -8.58662929e-03f, 2.53301412e-02f, 1.14765629e-01f, 5.98182157e-02f, -1.36854099e-02f, -2.33414937e-02f,
  -2.94624493e-02f, -1.07673757e-01f, 4.27747406e-02f, 1.45067964e-02f, -2.64882762e-02f, -6.56026304e-02f, -8.59751031e-02f, -7.32272072e-03f, -9.38602611e-02f, -1.91103071e-02f,
  -2.28346184e-01f, -3.02660167e-01f, -4.65366811e-01f, 1.27641216e-01f, 2.90093452e-01f, 2.44550601e-01f, 2.96060741e-02f, 1.28703132e-01f, -2.17132077e-01f, 3.03267799e-02f,
  1.58670887e-01f, -5.59455864e-02f, -4.34824765e-01f, 4.79768693e-01f, 2.37438083e-01f, -1.33461222e-01f, 3.17242503e-01f, 2.26537198e-01f, -1.30787224e-01f, -8.23786631e-02f,
  1.10330187e-01f, 4.71333444e-01f, 4.36304472e-02f, 3.49428475e-01f, 2.39586413e-01f, -4.26001549e-02f, 9.23166499e-02f, -2.22504646e-01f, 5.10946214e-01f, 3.22973490e-01f,
  3.82947400e-02f, -1.56615168e-01f, -9.79087278e-02f, 2.45015547e-02f, -9.75608230e-02f, -5.32063805e-02f, -8.24269652e-02f, 6.46326020e-02f, -5.61387464e-02f, -5.67114390e-02f,
  -6.93167299e-02f, 6.96723908e-02f, 1.71754777e-01f, -2.19132081e-02f, 1.02796247e-02f, 5.03616035e-02f, -8.52663219e-02f, 4.60778624e-02f, -4.99203317e-02f, -3.69821303e-02f,
  -1.61962390e-01f, 6.27563745e-02f, 1.84016619e-02f, 1.44881783e-02f, -4.00033034e-02f, -5.20536602e-02f, 3.53555717e-02f, -1.22750595e-01f, 5.50575592e-02f, 6.19917139e-02f,
  4.02975492e-02f, 1.46067226e-02f, -5.61240390e-02f, 5.22737205e-02f, -5.53210080e-02f, 2.84414701e-02f, 4.40121721e-03f, 7.96180144e-02f, -6.66482970e-02f, 4.70971316e-02f,
  -3.40314023e-02f, -1.33146159e-02f, 4.30851020e-02f, -2.53413003e-02f, 2.97802594e-02f, -5.64217847e-03f, -1.03171039e-02f, -6.14475412e-03f, -7.95835257e-02f, -6.57749027e-02f,
  -2.88194249e-04f, -6.11444153e-02f, -3.26353498e-02f, -1.84781000e-03f, 7.29200244e-02f, -4.75296751e-02f, 1.67569295e-02f, -6.04468659e-02f, -6.72773570e-02f, 8.93984979e-04f,
  4.99852598e-02f, -2.72823036e-01f, -7.63104632e-02f, 1.07636221e-01f, -1.07303023e-01f, 9.93088186e-02f, -3.33399102e-02f, 5.69752418e-03f, -6.29793480e-03f, -8.68360251e-02f,
  6.14511268e-03f, 2.76857819e-02f, 5.59490989e-04f, 7.60018229e-02f, 9.14949477e-02f, 3.48544377e-03f, -2.37267595e-02f, 6.35870472e-02f, 6.02055416e-02f, 5.22388546e-05f,
  9.33709648e-03f, -6.39304593e-02f, -2.51888181e-03f, -3.10359709e-02f, 7.93580487e-02f, 3.57478708e-02f, -3.94818094e-03f, -1.01652090e-02f, 3.77327800e-02f, -2.12126896e-02f,
  7.31599778e-02f, -6.30971849e-01f, 5.74770033e-01f, -1.02433376e-01f, 3.90809417e-01f, 3.81434739e-01f, 4.58807558e-01f, -2.18256354e-01f, -2.84994304e-01f, -6.49408519e-01f,
  -1.59068957e-01f, 3.79174389e-02f, 1.76905915e-02f, -1.52258143e-01f, 5.46367109e-01f, 9.25097167e-02f, -9.70455483e-02f, -8.44131336e-02f, 8.46515074e-02f, 6.07354678e-02f,
  1.00652583e-01f, -1.49070442e-01f, 3.63581359e-01f, -1.85236752e-01f, 2.78884768e-02f, -1.62483286e-02f, -8.36300403e-02f, 3.21937650e-01f, -7.34368265e-02f, 2.32558236e-01f,
  -5.72831221e-02f, -1.54238448e-01f, 6.45546913e-02f, -9.97068211e-02f, -8.17693919e-02f, -1.26694720e-02f, 7.96433091e-02f, 1.94110975e-01f, 7.52458125e-02f, -3.20345014e-02f,
  -1.07046077e-02f, -2.66049560e-02f, 5.73660545e-02f, -1.96404848e-03f, -2.97806747e-02f, 3.68757639e-03f, 7.60794953e-02f, -2.55250018e-02f, 6.53682649e-02f, 1.38255060e-01f,
  6.78147450e-02f, -5.41062392e-02f, 3.42651270e-02f, -7.15119019e-02f, 1.16370656e-01f, 9.22240503e-03f, 1.11384399e-01f, 1.41730174e-01f, -3.48991230e-02f, -3.19630117e-03f,
  4.13929075e-02f, -1.17532338e-03f, -1.15056448e-02f, -5.46782911e-02f, -3.77684645e-03f, -6.02057278e-02f, 3.23530496e-03f, 4.59557679e-03f, 1.28589442e-03f, -1.91810243e-02f,
  -2.45174244e-02f, -2.19155494e-02f, 7.13988766e-02f, -1.27405953e-02f, -4.24211621e-02f, -5.90665936e-02f, 2.69785076e-02f, -1.41119515e-03f, -6.20952435e-02f, 8.66582897e-03f,
  -4.34547011e-03f, 1.85952298e-02f, 1.72105599e-02f, 1.74832828e-02f, -6.08517490e-02f, 1.83186550e-02f, -6.60360977e-02f, 8.82458463e-02f, 2.22017914e-02f, 8.81539881e-02f,
  -4.01901424e-01f, -4.02719200e-01f, -1.36453152e-01f, -1.06140345e-01f, -8.41126516e-02f, -6.77427649e-02f, 3.14782490e-03f, -6.28142729e-02f, -1.02603532e-01f, -6.74154684e-02f,
  -1.34047255e-01f, -5.16884495e-03f, -7.63589889e-02f, 4.87207323e-02f, 5.01077548e-02f, -4.27532233e-02f, -3.41442227e-02f, -1.65523842e-01f, -9.13763046e-02f, -9.26553831e-02f,
  -5.27700633e-02f, -3.51107158e-02f, 7.75637776e-02f, -9.97212622e-03f, -1.20187432e-01f, -7.98522905e-02f, -5.42985275e-02f, -9.19770449e-02f, 2.00818535e-02f, 1.19037591e-02f,
  -3.29074323e-01f, -7.86358044e-02f, -3.80293578e-01f, -3.76782030e-01f, 2.39948243e-01f, -4.87374626e-02f, -2.13252932e-01f, 9.57156271e-02f, -1.18953452e-01f, 2.44282812e-01f,
  8.43770429e-02f, -2.67657012e-01f, 2.02722978e-02f, -4.64115441e-01f, -6.26421273e-01f, -3.84457171e-01f, -3.13601702e-01f, -2.47434303e-01f, -7.39101768e-02f, 7.52952555e-03f,
  -3.00926000e-01f, -4.08836752e-02f, -3.55503947e-01f, 3.28236490e-01f, -4.20509055e-02f, 1.17845803e-01f, 3.40782523e-01f, 2.42127523e-01f, 8.81777331e-03f, 9.04010609e-03f,
  -2.39446506e-01f, -1.27496496e-01f, -6.77933395e-02f, -3.50700058e-02f, 2.77292244e-02f, -1.99100319e-02f, 2.93010194e-02f, 1.34183066e-02f, -1.13019440e-02f, -6.73886240e-02f,
  -3.68806832e-02f, -6.86215609e-03f, -2.29905881e-02f, 2.71197315e-02f, 9.66762006e-02f, -7.76143298e-02f, -7.83099011e-02f, -8.57326016e-03f, -8.60908851e-02f, -1.43072188e-01f,
  -1.88672706e-01f, -1.40606249e-02f, 1.22580929e-02f, -5.59581444e-02f, -3.38854939e-02f, -8.44867248e-03f, -1.83617398e-02f, -1.51706894e-03f, -6.37408793e-02f, -1.28145870e-02f,
  3.03555746e-02f, 9.18549597e-02f, -7.62014510e-03f, -9.05975699e-02f, -4.72045783e-03f, 5.50798625e-02f, 1.02493912e-02f, 4.14120778e-02f, 7.10874349e-02f, 7.07674921e-02f,
  6.60624653e-02f, -4.81656753e-02f, 8.87949392e-03f, 2.39913240e-02f, 1.34754358e-02f, 2.20882948e-02f, -1.54262045e-02f, -4.57553193e-02f, -8.25705379e-02f, -2.16655917e-02f,
  5.93780912e-02f, -3.61890206e-03f, -4.08159122e-02f, 7.82490969e-02f, -6.21538572e-02f, 3.02456859e-02f, 4.44664806e-02f, -2.69698119e-03f, 1.29878810e-02f, 9.46035329e-03f,
  8.64078775e-02f, 2.08777174e-01f, -5.99092953e-02f, 5.46728447e-02f, -4.80300821e-02f, -5.97556215e-03f, -6.13589287e-02f, 1.13630807e-02f, -5.31633124e-02f, 7.69488141e-02f,
  9.66784880e-02f, 6.46824995e-03f, 8.44942778e-02f, -5.14626428e-02f, -8.10532249e-04f, 5.64062409e-02f, 3.43445428e-02f, 8.89509693e-02f, 5.09816073e-02f, 5.49885444e-02f,
  9.52346399e-02f, 8.96316841e-02f, -3.23798545e-02f, 6.11378439e-02f, 1.80643122e-03f, 2.42732633e-02f, 8.28769431e-03f, -8.64008963e-02f, 6.52895570e-02f, -5.06517757e-03f,
  -6.63702786e-02f, 4.88694519e-01f, 2.52974331e-01f, 2.57777363e-01f, -9.08334553e-02f, -5.53444684e-01f, -2.51837641e-01f, 2.68184543e-01f, -9.74282175e-02f, 1.31751284e-01f,
  -1.27368420e-01f, 2.30337590e-01f, -7.44846314e-02f, -1.73036262e-01f, -6.16846740e-01f, -3.72513056e-01f, -2.10995868e-01f, -1.77946150e-01f, -1.18787244e-01f, 2.35778347e-01f,
  1.46305095e-02f, -1.12979330e-01f, 1.93646811e-02f, 2.46401235e-01f, 1.05694272e-01f, 4.78223592e-01f, 3.23399544e-01f, 2.51685888e-01f, 1.66278034e-01f, -7.18305334e-02f,
  -2.83554405e-01f, 5.92403933e-02f, 1.24149978e-01f, -3.14748351e-04f, -2.04429012e-02f, 5.38270287e-02f, -5.56241954e-03f, -6.18447773e-02f, -1.34629952e-02f, 2.32208874e-02f,
  3.46327759e-02f, -2.18355451e-02f, -1.86140146e-02f, -1.19073763e-02f, -3.52776684e-02f, 1.00089297e-01f, 1.79187022e-02f, 8.49313438e-02f, 4.86405157e-02f, 6.10961430e-02f,
  8.01357031e-02f, -5.92463650e-02f, 6.25939444e-02f, 3.20798978e-02f, 9.63309873e-03f, 7.68524222e-03f, -8.96465927e-02f, 1.01515293e-01f, 9.21353251e-02f, 5.03174553e-04f,
  1.06093183e-01f, -3.68157923e-02f, -5.89016713e-02f, -2.71810200e-02f, -2.13126261e-02f, -3.00448779e-02f, -8.86720121e-02f, 6.50181323e-02f, -3.73849533e-02f, -3.79585065e-02f,
  -5.66763431e-02f, 5.12566268e-02f, -4.17106003e-02f, 6.34988025e-02f, -5.76906539e-02f, 2.97575723e-02f, -4.97087874e-02f, 3.76457674e-03f, 4.48186845e-02f, 8.83859918e-02f,
  -2.35445648e-02f, -1.73294209e-02f, 1.55605366e-02f, -1.18098063e-02f, -5.35660535e-02f, -2.28149313e-02f, 7.30799958e-02f, 2.81504132e-02f, -1.66759528e-02f, 1.44900391e-02f,
  1.15661122e-01f, 3.91615748e-01f, 3.57845761e-02f, 1.34113748e-02f, 2.93633342e-02f, -3.73671502e-02f, 1.52870957e-02f, 3.03375423e-02f, 4.43739165e-03f, -8.19941983e-02f,
  1.41765475e-01f, 6.10552020e-02f, 4.40434590e-02f, -3.22692394e-02f, 9.31609720e-02f, -1.88646186e-02f, 7.16940835e-02f, -7.10358769e-02f, 1.37410030e-01f, 1.26659304e-01f,
  7.11237267e-02f, -2.24498082e-02f, -2.15851050e-03f, -4.52066287e-02f, 9.29599851e-02f, -2.39730030e-02f, 9.36934501e-02f, 5.41096963e-02f, 1.44481147e-02f, 5.18258847e-02f,
  -4.76834357e-01f, 2.57008463e-01f, -8.03762972e-02f, -8.55956227e-02f, -3.59287076e-02f, -1.27770916e-01f, 3.27629335e-02f, -8.64564106e-02f, -9.14758071e-02f, 2.42192045e-01f,
  9.59279016e-02f, -8.76452476e-02f, 2.07759634e-01f, 2.44639650e-01f, -2.77605265e-01f, 1.18561238e-01f, 4.40441556e-02f, 5.62869534e-02f, -2.74877828e-02f, 4.02756669e-02f,
  -5.57641312e-02f, 5.77851646e-02f, 8.81177709e-02f, 9.89479721e-02f, -5.85111715e-02f, 1.50040537e-02f, 1.29670864e-02f, 2.18195468e-02f, -2.32824571e-02f, -8.67036730e-02f,
  -1.74017131e-01f, -8.07568207e-02f, -1.16992123e-01f, -8.61273110e-02f, -3.49053517e-02f, -9.29699168e-02f, -6.70198677e-03f, -1.01574391e-01f, -5.19429334e-04f, -1.35286907e-02f,
  -6.15756176e-02f, -1.69468038e-02f, -5.49760163e-02f, 1.75114144e-02f, -2.66068485e-02f, 5.11576347e-02f, 3.30235399e-02f, -1.59959942e-02f, -6.05390035e-02f, -8.64132680e-03f,
  -1.48684550e-02f, -4.19157296e-02f, 7.79869109e-02f, -2.10180022e-02f, -3.27105150e-02f, 1.12392381e-01f, 2.23166067e-02f, 9.73504130e-03f, -8.81472901e-02f, 2.99783796e-02f,
  3.98595817e-02f, -2.42565218e-02f, -1.27102230e-02f, 6.16674237e-02f, -3.21810097e-02f, -3.82403508e-02f, -2.30761934e-02f, -7.42242634e-02f, 1.63043905e-02f, 8.79122093e-02f,
  -8.68061930e-02f, -3.00763119e-02f, 6.94168964e-03f, 2.42832098e-02f, 8.26481916e-03f, 2.53032497e-03f, 1.14820953e-02f, -2.90012248e-02f, -2.68674176e-02f, -5.50871529e-02f,
  7.83222020e-02f, -6.45529106e-02f, -4.43135090e-02f, 3.66573688e-03f, -2.05944609e-02f, 5.09712026e-02f, 1.86654273e-02f, 1.98049992e-02f, -1.81610715e-02f, -3.14154662e-02f,
  -1.17760763e-01f, -2.23139197e-01f, -1.17100663e-01f, -1.27711654e-01f, -1.76364034e-02f, 2.40404941e-02f, 2.02510115e-02f, -7.35757872e-02f, 4.16339375e-02f, -2.29361169e-02f,
  2.64370013e-02f, 6.42567081e-03f, -7.85541162e-03f, -4.26258110e-02f, -4.03310470e-02f, -2.80395783e-02f, -1.60462484e-02f, -1.18139699e-01f, -9.53965634e-02f, 2.49866731e-02f,
  1.77881941e-02f, 7.05196476e-03f, -6.56275600e-02f, -3.10625378e-02f, 4.13358258e-03f, -3.20475027e-02f, -8.07136744e-02f, -1.07103735e-01f, -3.54073234e-02f, -7.29687372e-03f,
  -1.74675077e-01f, 4.81012136e-01f, 3.45894635e-01f, 1.07099317e-01f, -2.72563487e-01f, 2.85392225e-01f, 1.61402225e-01f, 6.26763254e-02f, 4.24587607e-01f, 4.49440807e-01f,
  -6.21155426e-02f, 4.65238094e-01f, -6.01221398e-02f, 2.70845503e-01f, -2.49693960e-01f, 6.26041228e-03f, 2.25305796e-01f, 2.28951916e-01f, -8.20305347e-02f, 5.33326268e-02f,
  -9.92171690e-02f, -1.65659353e-01f, -1.65697992e-01f, -1.56493932e-01f, 1.23193571e-02f, 9.12413225e-02f, -3.46188754e-01f, -1.92236006e-01f, 2.82709468e-02f, 3.36082093e-02f,
  -7.80265704e-02f, 2.32853085e-01f, 8.77177790e-02f, 2.46834695e-01f, -5.10469712e-02f, -6.32869452e-02f, 7.51113743e-02f, -3.50034386e-02f, -6.98762685e-02f, 6.80091307e-02f,
  1.28859714e-01f, 1.33983595e-02f, 1.10762164e-01f, 1.16081350e-02f, 1.56126350e-01f, 8.05393383e-02f, -5.28661609e-02f, -5.81600480e-02f, 5.94188608e-02f, -3.93907875e-02f,
  9.02660415e-02f, 8.23170468e-02f, 7.46328011e-02f, 1.36391267e-01f, 3.09994668e-02f, -5.91456844e-03f, 9.60560068e-02f, -2.29430031e-02f, 1.10041916e-01f, 1.47177264e-01f,
  8.60091075e-02f, -2.62810104e-02f, -8.01090971e-02f, -1.73018612e-02f, -3.25898360e-03f, -3.11945993e-02f, 2.31344141e-02f, -6.90550208e-02f, -3.51714939e-02f, -3.43923718e-02f,
  -3.79774794e-02f, -2.23984439e-02f, 1.14880893e-02f, 3.48358080e-02f, -1.19722737e-02f, 9.51701179e-02f, -7.56870806e-02f, -5.14551997e-02f, -4.37049232e-02f, -3.49461064e-02f,
  1.62312724e-02f, 5.10502309e-02f, -6.74991534e-05f, -1.36288449e-01f, 6.10572584e-02f, -2.94284299e-02f, -2.80396082e-02f, 1.03521653e-01f, -3.24071944e-02f, -1.23895727e-01f,
  1.81361113e-03f, 1.91618070e-01f, 8.51498917e-02f, 8.02442655e-02f, 9.93723236e-03f, -6.25620559e-02f, -4.92588915e-02f, 1.04229763e-01f, 1.17138796e-01f, 1.76398404e-04f,
  1.70037826e-03f, 2.82819457e-02f, 5.09400256e-02f, 1.10075260e-02f, 3.49416584e-02f, 4.72965054e-02f, -3.53727899e-02f, 4.67847139e-02f, -1.99114252e-02f, -8.26808363e-02f,
  -1.38085755e-02f, 5.06690368e-02f, -2.12600920e-02f, -3.44803445e-02f, -1.29354177e-02f, 2.58878879e-02f, 1.29875429e-02f, 7.13164806e-02f, -4.62001674e-02f, 1.15747742e-01f,
  3.36851090e-01f, 1.61231086e-02f, 3.40642810e-01f, 5.62054098e-01f, 3.62458050e-01f, 1.35430172e-01f, 2.56293416e-01f, 3.51546794e-01f, 7.90986538e-01f, -2.70941943e-01f,
  -2.09799305e-01f, -2.73709837e-02f, -2.14138135e-01f, -4.54171095e-03f, -7.74159431e-02f, -1.54399902e-01f, 2.15192676e-01f, -1.60340723e-02f, 3.12626034e-01f, 1.67250454e-01f,
  2.48400837e-01f, -1.65186405e-01f, -1.70447186e-01f, -1.63096547e-01f, 1.28829271e-01f, 4.35572490e-02f, -5.21878004e-01f, -8.75072256e-02f, -2.30307311e-01f, -1.16614603e-01f,
  1.11085407e-01f, 5.72906397e-02f, -5.45020737e-02f, 2.21480289e-03f, 2.53353976e-02f, -4.61175404e-02f, -1.23460107e-01f, -1.15178078e-01f, 5.67327514e-02f, -5.13105653e-03f,
  -5.76344803e-02f, -1.68160684e-02f, -2.08013579e-02f, -1.11419670e-02f, 1.10543460e-01f, 5.33393817e-03f, 4.37506028e-02f, 9.58067179e-02f, 5.23823611e-02f, 8.38697925e-02f,
  7.46541545e-02f, -2.28163190e-02f, 1.40611827e-01f, -4.33620550e-02f, -5.64001203e-02f, -1.79600902e-02f, 7.32532442e-02f, -1.19972654e-01f, 4.31427918e-02f, 8.33334252e-02f,
  -2.63473559e-02f, 8.92263427e-02f, -5.69756888e-02f, 4.21192311e-02f, -1.58403430e-03f, 1.74788758e-02f, 1.83659047e-02f, -1.74553785e-02f, 2.52466649e-02f, -5.18677421e-02f,
  3.64622734e-02f, 3.24795488e-03f, 6.77199587e-02f, -3.37146670e-02f, 1.24115404e-02f, 6.59878179e-02f, -1.52632978e-03f, 1.55616216e-02f, -3.08557097e-02f, 5.16170263e-02f,
  -1.03299329e-02f, -6.94701727e-03f, -4.96663749e-02f, 2.19055656e-02f, -6.25924068e-03f, 5.96088963e-03f, -9.84318368e-03f, -1.43980458e-02f, -6.05923263e-03f, -1.08897379e-02f,
  2.29644887e-02f, 3.57267782e-02f, -1.22071736e-01f, -5.91174625e-02f, -9.71197709e-02f, -2.40516532e-02f, 1.52271437e-02f, -7.63853360e-03f, 7.45927542e-02f, -1.64616425e-02f,
  -6.23311289e-02f, -8.02533552e-02f, 2.18338277e-02f, -6.15210980e-02f, -6.12618923e-02f, 3.21350284e-02f, -4.46452051e-02f, -1.98091529e-02f, -3.77096198e-02f, -7.79614523e-02f,
  -1.55339405e-01f, 1.14349090e-03f, 5.62026426e-02f, 2.87495442e-02f, -3.41739617e-02f, -1.09365232e-01f, 4.60462831e-02f, -3.41157755e-03f, -2.92507987e-02f, -7.30040297e-02f,
  5.13893127e-01f, 1.02582335e-01f, -1.60903946e-01f, 5.26454970e-02f, 5.25771417e-02f, -3.94618930e-03f, -4.22604345e-02f, 8.74087960e-02f, -1.17122576e-01f, -5.04660308e-02f,
  2.09258094e-01f, 1.24074547e-02f, -1.22705311e-01f, 3.20461452e-01f, 2.92049289e-01f, -6.11353964e-02f, 2.79411942e-01f, 1.41038209e-01f, -7.79614896e-02f, 3.14267814e-01f,
  1.57476291e-01f, 3.21837783e-01f, -2.69384049e-02f, 1.53056726e-01f, 1.26422182e-01f, -5.25998417e-03f, 1.76474929e-01f, -7.44715631e-02f, 2.41495624e-01f, 1.62270114e-01f,
  -1.43093750e-01f, 9.83579010e-02f, -2.56318208e-02f, -1.74219847e-01f, 1.59117445e-01f, 2.58633792e-02f, -1.21008176e-02f, -5.17732166e-02f, -4.42097820e-02f, 1.08872289e-02f,
  6.12885281e-02f, 7.47427940e-02f, -1.46130957e-02f, 2.35629752e-02f, 7.82979056e-02f, 6.63987994e-02f, 3.15805040e-02f, -1.68850124e-01f, -6.49998933e-02f, 4.87980805e-02f,
  -5.51448315e-02f, 1.56316999e-02f, 3.67012881e-02f, -1.43978328e-01f, 1.08721368e-02f, 5.45904273e-03f, -1.00677207e-01f, 9.37081575e-02f, -3.06164771e-02f, 1.29833892e-01f,
  1.71109617e-01f, 4.63111289e-02f, 1.15373164e-01f, -9.10271928e-02f, 1.06823392e-01f, -1.19404264e-01f, 9.14647281e-02f, -2.79484615e-02f, 3.04242726e-02f, 9.05359257e-03f,
  1.73894744e-02f, -4.53118421e-02f, 6.12364570e-03f, 3.16568576e-02f, 7.87857324e-02f, -5.64848259e-02f, -2.07531620e-02f, -8.80414341e-03f, 3.46813095e-03f, -4.21388708e-02f,
  -5.55241480e-02f, 5.41746169e-02f, 7.12567344e-02f, -1.34739622e-01f, -7.45265335e-02f, -7.53827244e-02f, 1.83808804e-01f, 1.95375439e-02f, -1.32709801e-01f, 3.05776224e-02f,
  5.60748242e-02f, 3.50877672e-01f, -8.07016343e-02f, -3.97307090e-02f, -4.97602560e-02f, 9.49871391e-02f, 1.60847101e-02f, 1.41158745e-01f, 3.63586545e-02f, 8.54896083e-02f,
  2.85584852e-02f, -1.33921847e-01f, 8.09007138e-02f, -2.50040926e-02f, -6.90961778e-02f, 6.39588758e-02f, 9.39338133e-02f, -5.58262020e-02f, 1.86993573e-02f, 5.19427247e-02f,
  3.41882482e-02f, -2.34136898e-02f, -1.74682532e-02f, -4.89592068e-02f, -7.45609999e-02f, -7.79534504e-02f, 1.73060186e-02f, -6.72914609e-02f, 1.10979430e-01f, -3.41774747e-02f,
  -2.93589592e-01f, 3.06059062e-01f, -1.34276673e-01f, -1.45627707e-01f, -1.45379528e-01f, 2.34641448e-01f, 3.45593132e-02f, 9.71095413e-02f, -2.16772661e-01f, 8.89637321e-02f,
  5.45158759e-02f, -1.10675387e-01f, 8.42837095e-02f, 1.32863879e-01f, 6.60066530e-02f, 3.06730151e-01f, 1.49585828e-01f, 3.64095382e-02f, 2.54604667e-02f, 2.67986972e-02f,
  3.49531067e-03f, 6.62017539e-02f, 1.97992206e-01f, 1.64707035e-01f, 3.25772204e-02f, -9.61120054e-02f, -2.38401759e-02f, 1.19001502e-02f, -6.94789886e-02f, -2.75327992e-02f,
  -1.14613101e-01f, -2.34861001e-01f, -1.35427332e-02f, -1.39527410e-01f, -7.32980520e-02f, -5.52167222e-02f, -7.97823444e-03f, -1.43012851e-01f, 2.82638753e-03f, -5.83580956e-02f,
  -2.57138144e-02f, -5.51583106e-03f, -5.95597066e-02f, 1.97273754e-02f, 3.18369493e-02f, -7.51329139e-02f, 1.69465307e-03f, 6.54327348e-02f, -6.79849386e-02f, 3.09919082e-02f,
  4.17450778e-02f, 4.46158387e-02f, 5.85853634e-03f, -1.62566435e-02f, -5.96822053e-02f, 3.78396772e-02f, 3.09643727e-02f, 1.26136057e-02f, 1.12074520e-03f, -7.36093670e-02f,
  6.99761957e-02f, -5.89137897e-02f, -2.41092667e-02f, -1.16144828e-01f, -9.07078199e-03f, 1.01457462e-02f, 5.91293313e-02f, 3.44204716e-02f, -8.74967128e-02f, -2.80221850e-02f,
  1.32472180e-02f, -1.06763028e-01f, 5.65932989e-02f, 5.32551967e-02f, -1.34893907e-02f, -2.78922506e-02f, 6.21797144e-02f, -3.67338471e-02f, 5.06579503e-02f, 6.78541735e-02f,
  -6.65144175e-02f, 7.36846998e-02f, 3.10896002e-02f, -1.48591138e-02f, 2.63580065e-02f, -2.92545985e-02f, -5.88826425e-02f, 8.65995809e-02f, -5.94137758e-02f, 4.28480245e-02f,
  -2.65482124e-02f, -2.26785347e-01f, -1.01394109e-01f, -1.28175646e-01f, -3.87624502e-02f, 5.56587540e-02f, -1.36027345e-02f, 5.13612926e-02f, -4.95206518e-03f, -3.37894559e-02f,
  1.89375300e-02f, -7.00653568e-02f, -4.23191078e-02f, 1.18221194e-02f, 3.84121644e-03f, 2.51200888e-02f, -7.62417242e-02f, -7.43410215e-02f, -4.56071757e-02f, 4.09055352e-02f,
  -4.11414728e-02f, -1.73455812e-02f, 2.44873781e-02f, -3.57856490e-02f, 4.05212343e-02f, 9.06765554e-03f, -1.40985295e-01f, 4.74723615e-02f, 3.18970680e-02f, 5.32284044e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.80357271e-01f, 1.54562384e-01f, 1.35008812e-01f, 6.36200309e-01f, 4.51184422e-01f, 1.07674912e-01f, 6.39907360e-01f, 2.64507800e-01f, 4.01979864e-01f, 2.61049598e-01f,
  6.68910682e-01f, 3.35815519e-01f, 2.84783483e-01f, 2.02708751e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -5.39655164e-02f, -1.33283451e-01f, -4.15322363e-01f, 1.33947404e-02f, -2.67594159e-01f, 4.06288266e-01f, -2.00448304e-01f, 2.59295702e-01f, -3.91470283e-01f, 4.89219800e-02f,
  -5.06415248e-01f, 2.54573375e-02f, 3.63369263e-03f, 6.46312386e-02f, -1.88263521e-01f, 1.57568499e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  6.11639023e-01f, 4.06065911e-01f, 5.07720113e-01f, -5.06850258e-02f, 4.18875664e-01f, -2.14637786e-01f, 4.79912087e-05f, -2.60661930e-01f, 4.27408427e-01f, -5.49611568e-01f,
  3.31918150e-01f, -1.82312354e-01f, 6.81538224e-01f, 9.29386199e-01f, 1.15120132e-02f, -2.42885239e-02f, -9.92814302e-02f, -1.17023848e-01f, -1.69955432e-01f, 4.43109274e-01f,
  -2.98325092e-01f, 1.01079273e+00f, -1.32212922e-01f, -1.22628532e-01f, 1.92665443e-01f, 1.39439195e-01f, 7.46759400e-03f, -5.58382235e-02f, 2.67315328e-01f, -9.66751948e-02f,
  6.76522870e-03f, 2.47650355e-01f, 4.74769086e-01f, 1.24993637e-01f, -3.89276952e-01f, 2.78094381e-01f, 2.00458795e-01f, 1.53024241e-01f, -1.04132637e-01f, 6.59129396e-02f,
  -6.93846494e-02f, 8.61183941e-01f, -6.08894117e-02f, -2.43738387e-03f, 1.09911263e-01f, 7.75016665e-01f, -6.90294579e-02f, -1.91016823e-01f, 8.59657377e-02f, 7.50856698e-02f,
  -1.39735907e-01f, -1.39446005e-01f, -2.47166574e-01f, 7.98844844e-02f, 3.00644845e-01f, -4.84943278e-02f, -6.97931051e-02f, -7.83058535e-03f, -1.69851109e-01f, -1.41161293e-01f,
  1.94660217e-01f, -2.26817913e-02f, 6.47621810e-01f, 6.85188128e-03f, 3.94125991e-02f, -4.62330252e-01f, 2.57632792e-01f, -1.27841592e-01f, 2.00862680e-02f, -1.94467157e-02f,
  4.83970940e-01f, -1.39863461e-01f, -2.74833649e-01f, -2.10950494e-01f, 5.26612103e-01f, 3.68751943e-01f, 9.64049220e-01f, 6.07249662e-02f, 1.43830895e-01f, 1.74218491e-01f,
  2.14402452e-01f, 5.92020214e-01f, -4.38952804e-01f, -2.61597484e-01f, -1.17225781e-01f, -3.24286133e-01f, 6.37290299e-01f, -8.62569213e-02f, -1.82234496e-01f, 5.21659434e-01f,
  7.95191050e-01f, 5.52247912e-02f, -2.64981031e-01f, 2.96316236e-01f, 5.36313355e-01f, 1.00282826e-01f, -1.16783634e-01f, -2.01317996e-01f, -2.19396502e-02f, 3.15702111e-01f,
  -3.79754156e-02f, 2.87544459e-01f, 4.38258052e-01f, -1.11371111e-02f, -2.21998617e-01f, 1.53036445e-01f, 3.14416230e-01f, -8.90331194e-02f, -1.14987947e-01f, -3.46982777e-02f,
  9.98367555e-03f, -1.58645920e-02f, -6.56660497e-02f, 8.61622021e-03f, -4.70041066e-01f, 1.10660143e-01f, 4.34930414e-01f, 1.07952654e-01f, 6.97840393e-01f, -2.63714433e-01f,
  1.12592570e-01f, -3.35288227e-01f, 3.20839584e-01f, 1.58870727e-01f, 3.81957352e-01f, 4.32106584e-01f, -1.28083944e-01f, -1.96939468e-01f, 1.46990374e-01f, 3.02174658e-01f,
  8.04348350e-01f, -1.57728896e-01f, 2.08898380e-01f, 1.29053816e-01f, -2.72624046e-01f, 1.47633642e-01f, 6.38417780e-01f, 9.47043121e-01f, 9.64969158e-01f, 1.29449040e-01f,
  8.46527740e-02f, -2.82249659e-01f, -1.44897759e-01f, -2.85049826e-01f, 6.00893259e-01f, 1.29706398e-01f, 3.06706399e-01f, -2.74197280e-01f, -1.03855036e-01f, 6.75072372e-01f,
  1.31573435e-03f, -5.57377040e-01f, 8.18767309e-01f, -3.28489006e-01f, -3.84796619e-01f, -1.58887982e-01f, 4.65942144e-01f, 8.07841182e-01f, 9.46668610e-02f, 7.38264620e-02f,
  1.89562917e-01f, 5.52227795e-01f, 1.96564808e-01f, 5.40146410e-01f, -5.38068973e-02f, 8.70221078e-01f, -4.55838740e-02f, 1.58810422e-01f, 1.30587518e+00f, -1.14894044e-02f,
  -3.52768451e-01f, -7.63771981e-02f, -3.59920323e-01f, -3.18257183e-01f, -1.76722854e-01f, 5.02993427e-02f, 2.49322399e-01f, 1.94967806e-01f, -1.40017390e-01f, 4.06473279e-01f,
  -1.68735400e-01f, 6.28354013e-01f, -4.69937176e-02f, 3.03145468e-01f, -4.36688095e-01f, 6.79413453e-02f, -2.34041616e-01f, -3.64484154e-02f, 3.89443398e-01f, -2.20648888e-02f,
  7.02746451e-01f, 5.44315204e-02f, -1.97702467e-01f, 6.60345674e-01f, -8.53332281e-02f, -1.35690123e-01f, 1.21016271e-01f, -1.23660013e-01f, 4.92204875e-01f, 1.29452908e+00f,
  5.12559533e-01f, 7.57583454e-02f, 2.36193627e-01f, -2.80272275e-01f, -1.58108458e-01f, 1.64206535e-01f, 6.28674150e-01f, -1.64815113e-01f, -6.00283071e-02f, -1.30226135e+00f,
  1.02855551e+00f, -5.57977073e-02f, -1.10469520e-01f, 2.66558975e-01f, 5.44288456e-01f, 3.07058752e-01f, -6.60401136e-02f, 2.19094634e-01f, -1.46852084e-03f, 7.90801704e-01f,
  6.73209906e-01f, -2.93167025e-01f, -1.83917701e-01f, 7.71373689e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.30984217e-01f, 2.47625753e-01f, 4.55772609e-01f, -1.63451936e-02f, 4.76674050e-01f, 4.25495833e-01f, -2.09518090e-01f, 2.43356720e-01f, 1.74046472e-01f, 2.23851085e-01f,
  1.66388437e-01f, 9.25174505e-02f, 3.54392171e-01f, 3.05369616e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  6.40156507e-01f, 3.72544557e-01f, -5.82867682e-01f, -2.00968757e-02f, -4.24855471e-01f, -1.74386129e-01f, 5.13253391e-01f, -1.45435974e-01f, 5.38203232e-02f, 4.00945753e-01f,
  -6.84054971e-01f, -5.39557517e-01f, -3.04723293e-01f, -3.01976651e-01f, -2.17575252e-01f, 1.22707939e+00f, 9.39437449e-01f, 5.38150184e-02f, -4.97874543e-02f, -6.32531270e-02f,
  1.08408712e-01f, 6.00896537e-01f, -6.63628627e-04f, 3.01368117e-01f, -1.85517967e-01f, -3.58675867e-01f, -7.35225439e-01f, -2.92581379e-01f, -5.04362822e-01f, 8.41887951e-01f,
  6.67833388e-01f, 2.19284683e-01f, 4.43471730e-01f, 3.09814036e-01f, -4.47705895e-01f, -2.00886905e-01f, -1.23168342e-01f, 8.94689038e-02f, -7.61316955e-01f, -7.74579793e-02f,
  -2.78718203e-01f, -2.80121118e-01f, 2.70283312e-01f, -5.03887832e-01f, 3.14442515e-01f, 3.48264463e-02f, 1.34917033e+00f, -5.13684750e-01f, -3.10570687e-01f, -3.34452897e-01f,
  -4.44760352e-01f, 8.25058110e-03f, 1.46876007e-01f, 1.01239095e-03f, 1.21736273e-01f, -4.52519387e-01f, 7.87945613e-02f, -9.84809399e-02f, 8.33420217e-01f, -6.05019152e-01f,
  -3.03197056e-01f, -2.11684987e-01f, -7.05210328e-01f, 8.51643562e-01f, 2.91026592e-01f, -2.45614871e-01f, 4.50814441e-02f, 1.94574594e-01f, -5.69451928e-01f, -2.02266619e-01f,
  -1.03378311e-01f, -3.85870844e-01f, -2.19816998e-01f, -6.32301629e-01f, 1.81414008e-01f, 8.49617362e-01f, 3.50471437e-01f, -2.15031534e-01f, -2.12421164e-01f, 9.09680903e-01f,
  5.39404452e-02f, 3.64065826e-01f, 1.18117467e-01f, 3.96154225e-01f, 3.66747409e-01f, 3.19241554e-01f, 4.48710531e-01f, -1.59088314e-01f, -1.06644325e-01f, 5.15521228e-01f,
  -5.71536481e-01f, 8.38145494e-01f, -4.02198702e-01f, 3.38518471e-01f, -2.21552059e-01f, 3.95811871e-02f, -1.06933368e-02f, -2.07427353e-01f, 7.96284854e-01f, -3.36432874e-01f,
  7.25296617e-01f, -2.70515941e-02f, -5.46877444e-01f, 1.40517876e-01f, -9.24890637e-02f, 4.96459693e-01f, -2.49885648e-01f, 6.82895362e-01f, 5.58578363e-03f, -2.65342683e-01f,
  1.26058191e-01f, -8.50342572e-01f, -3.63460302e-01f, 6.17636383e-01f, -5.33703923e-01f, 8.63313913e-01f, 1.47714898e-01f, 5.45598306e-02f, -4.73318011e-01f, -1.27255082e-01f,
  2.20626906e-01f, -5.77775985e-02f, -2.78766662e-01f, 1.24991037e-01f, 7.34286070e-01f, 6.77946270e-01f, -1.13773651e-01f, -3.38307738e-01f, -5.46805263e-01f, 1.08402282e-01f,
  1.53720938e-02f, -1.75700217e-01f, -5.84690809e-01f, 2.73453355e-01f, 2.08938211e-01f, 9.86818910e-01f, 2.03049675e-01f, 4.98034418e-01f, -6.90186918e-02f, -1.90647095e-01f,
  -4.94805992e-01f, -4.32944857e-02f, 4.71511424e-01f, -3.29267412e-01f, -3.43941092e-01f, -1.48073524e-01f, 1.66328275e-03f, 1.02459013e-01f, -2.19636068e-01f, -2.45783582e-01f,
  -5.23145795e-01f, -3.30642015e-01f, -1.15156285e-01f, -1.05996586e-01f, 3.52267861e-01f, 5.27055621e-01f, 1.20121253e+00f, -2.70699590e-01f, 7.93564543e-02f, -7.98835158e-01f,
  1.58757359e-01f, 1.10919334e-01f, -5.02409518e-01f, -7.75195435e-02f, 7.19198346e-01f, -3.12386334e-01f, -2.08056942e-01f, 8.65424931e-01f, -2.35299274e-01f, -2.40190446e-01f,
  8.41708481e-01f, -1.27607659e-01f, -5.15971422e-01f, -5.11570135e-03f, -1.75257131e-01f, -3.49394828e-01f, -5.97790658e-01f, -2.16528714e-01f, 9.92330670e-01f, -5.20639241e-01f,
  -3.87358010e-01f, -1.91304654e-01f, 6.03684902e-01f, -2.26054952e-01f, -3.26728791e-01f, 1.18192509e-02f, 4.96252567e-01f, 1.77183211e-01f, -4.98966366e-01f, -2.86234140e-01f,
  -3.33577245e-01f, 8.26531649e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  2.53271461e-01f, 7.78662980e-01f, -1.43248543e-01f, 1.08666264e-01f, -1.24989092e-01f, -9.53089446e-02f, -1.16597779e-01f, -3.23471755e-01f, -1.89043969e-01f, -2.20468253e-01f,
  1.54178515e-01f, -1.11577734e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    