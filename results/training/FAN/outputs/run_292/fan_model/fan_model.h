/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.17866084e-01f, -2.32920423e-01f, -1.96577415e-01f, -2.12520450e-01f, -4.20198515e-02f, -1.42365351e-01f, -3.13476831e-01f, -9.49759930e-02f, -1.28550872e-01f, 3.31935100e-02f,
  1.42377359e-03f, -3.06709737e-01f, -4.66910377e-02f, -2.99179740e-02f, -1.26532003e-01f, -2.49456838e-02f, -1.51453316e-01f, -5.78728132e-02f, -5.19669093e-02f, -2.49578178e-01f,
  -4.85070311e-02f, -7.69840479e-02f, 6.99737072e-02f, 1.49907172e-01f, -1.41937379e-02f, -3.32959332e-02f, -4.16140491e-03f, -4.33736704e-02f, -2.65826733e-04f, -6.25184402e-02f,
  8.84849280e-02f, -1.28642336e-01f, 5.30643649e-02f, 5.63364699e-02f, 9.51654837e-03f, -2.50680209e-03f, -6.56143278e-02f, 3.58334603e-03f, 3.21533978e-02f, -1.34457285e-02f,
  -7.00844228e-02f, 7.55081326e-02f, 8.08757767e-02f, -4.45542391e-03f, -6.05236292e-02f, -3.81463137e-03f, 7.96399042e-02f, -1.93461124e-02f, -5.13210036e-02f, -3.85794900e-02f,
  2.59845890e-02f, 1.49641390e-04f, 3.42633091e-02f, -6.20441437e-02f, 1.50393918e-02f, -2.05678511e-02f, 4.21028631e-03f, -9.57943872e-02f, -3.83064039e-02f, 2.15456132e-02f,
  -9.74614844e-02f, -1.63565855e-02f, 1.93454791e-02f, 6.41869679e-02f, -3.45563740e-02f, 1.01068042e-01f, -1.93856750e-02f, 2.46916078e-02f, 1.04521308e-02f, -6.96108416e-02f,
  -1.19510144e-02f, -6.78308681e-02f, 7.10605681e-02f, 9.54059884e-03f, -2.89528463e-02f, -5.69998436e-02f, -1.32116303e-02f, -2.34511048e-02f, 3.34563851e-02f, 2.79503819e-02f,
  4.66308780e-02f, -3.77229936e-02f, 6.52444884e-02f, 2.27697822e-03f, 3.89772579e-02f, 1.50139490e-02f, -3.29751857e-02f, -1.83331557e-02f, -5.00543863e-02f, -4.31849100e-02f,
  -1.48138791e-01f, -3.36068690e-01f, 2.71171480e-02f, 8.34679455e-02f, -4.04360704e-02f, 1.33842658e-02f, 2.72237398e-02f, 1.69702210e-02f, -2.77078338e-02f, 2.55475808e-02f,
  7.48071959e-03f, -1.29175037e-02f, -4.62735556e-02f, -3.60267311e-02f, -4.19228673e-02f, -7.33323954e-03f, -8.67884085e-02f, -4.76679243e-02f, -3.16852890e-02f, -4.29634377e-03f,
  2.97503714e-02f, 2.68679615e-02f, -2.53941920e-02f, 2.80245803e-02f, 5.85962087e-02f, -4.58740033e-02f, -1.49250835e-01f, 7.20134228e-02f, -3.65969841e-03f, -2.77157072e-02f,
  -1.88226312e-01f, 3.11137706e-01f, 2.15154797e-01f, -9.89883840e-02f, 9.81442481e-02f, -1.60762891e-01f, -1.34699509e-01f, 9.81590599e-02f, 5.44494651e-02f, 4.06044424e-02f,
  -1.19047873e-01f, 7.83481598e-02f, -2.07101442e-02f, -1.26633137e-01f, -5.44250071e-01f, -2.25673229e-01f, -2.44458675e-01f, -1.22931175e-01f, -6.05077576e-03f, 5.04899248e-02f,
  -7.55639002e-02f, -1.39700815e-01f, 5.15855886e-02f, 2.69863009e-01f, 7.77582750e-02f, 2.80797273e-01f, -1.30972356e-01f, 2.58551091e-01f, -4.95496951e-03f, -3.20547931e-02f,
  -5.87980486e-02f, 1.30671993e-01f, 3.45019288e-02f, 5.63530065e-02f, -1.57883149e-02f, 9.33873374e-03f, -5.37935495e-02f, 1.41012436e-02f, 1.89144611e-02f, -4.37618867e-02f,
  2.46683825e-02f, -5.10390028e-02f, -7.34507479e-03f, 3.04067340e-02f, 3.81830111e-02f, 2.45327875e-02f, 4.49368060e-02f, 2.39534546e-02f, 9.28683728e-02f, 2.50856392e-02f,
  4.80270982e-02f, -2.88535077e-02f, 4.52914275e-03f, -9.89336744e-02f, -1.12373922e-02f, -7.03307975e-04f, -1.21396342e-02f, -2.20457651e-02f, 1.18774055e-02f, -4.89928834e-02f,
  -6.66973069e-02f, -2.68608052e-02f, 5.84621774e-03f, 3.48993950e-02f, -4.32445575e-03f, 4.31185998e-02f, -2.94091012e-02f, 7.85073265e-03f, 1.41084213e-02f, -6.49646996e-03f,
  -2.01276373e-02f, 1.66286640e-02f, -8.30056425e-03f, -2.47262865e-02f, -3.26834843e-02f, -1.24808066e-02f, 1.61866974e-02f, -4.16263752e-02f, -2.98389290e-02f, 4.07389142e-02f,
  1.25940260e-03f, -2.88402569e-02f, 2.65964679e-02f, -2.27405820e-02f, 2.65486632e-02f, 1.81519575e-02f, -2.21518818e-02f, 2.39563268e-02f, 1.34135699e-02f, -2.25614421e-02f,
  -6.45468831e-02f, -3.12493257e-02f, 1.26894966e-01f, 1.24388197e-02f, -1.69586781e-02f, -2.59631313e-02f, 3.75429564e-03f, -1.81196537e-03f, -1.27427941e-02f, 1.15432898e-02f,
  -4.39954251e-02f, 4.55459915e-02f, -4.48625498e-02f, -1.44413877e-02f, 3.12570818e-02f, -3.42726260e-02f, -3.99203598e-02f, -2.09058542e-02f, -4.78800535e-02f, -2.34213993e-02f,
  1.30027747e-02f, 2.57508713e-03f, -2.60750856e-02f, 6.31808564e-02f, -2.50670146e-02f, -3.29839401e-02f, 1.26117524e-02f, 2.87572592e-02f, -1.64047368e-02f, -1.61568001e-02f,
  -3.39263082e-01f, 6.79082349e-02f, -3.41637194e-01f, -4.88493033e-02f, -1.86715107e-02f, 3.34578574e-01f, 1.27426043e-01f, -7.34809507e-03f, -6.07311837e-02f, 1.41064510e-01f,
  2.27639005e-01f, -4.43471409e-02f, 1.85256433e-02f, 1.98602915e-01f, 3.68661463e-01f, 1.77808449e-01f, 2.78653115e-01f, 1.21161051e-01f, -7.65492097e-02f, -3.92597020e-02f,
  -1.18477233e-02f, 3.25546890e-01f, 2.25197989e-02f, 1.99781567e-01f, 3.92777622e-02f, -1.19577400e-01f, 9.30093080e-02f, -1.62365264e-03f, 1.21202745e-01f, 1.70734957e-01f,
  -1.32225543e-01f, -2.24861398e-01f, -1.54710695e-01f, -8.40902925e-02f, -1.65437590e-02f, -1.04885623e-01f, -1.08901918e-01f, -3.45356539e-02f, -1.88389290e-02f, 5.04336022e-02f,
  -3.41423564e-02f, -9.28381737e-03f, -2.09069308e-02f, 1.15493964e-02f, -7.19561568e-03f, -5.53349480e-02f, 2.07786728e-03f, -3.50673683e-02f, -4.17563319e-02f, -4.89919819e-02f,
  -6.52277470e-03f, 9.15192720e-03f, -3.54585908e-02f, 7.75476219e-04f, 8.45783670e-03f, -2.67034620e-02f, 7.31189176e-03f, -5.19498158e-03f, -2.08371363e-04f, 3.32172401e-02f,
  6.54249173e-03f, -7.04637915e-03f, 2.97445222e-03f, -2.24753208e-02f, 3.63151133e-02f, -3.09816524e-02f, 8.00183117e-02f, -2.92929523e-02f, -5.68975415e-03f, 3.50397192e-02f,
  -1.73979569e-02f, -3.84599268e-02f, -2.86947866e-03f, 1.41792018e-02f, -1.53374905e-02f, -4.50282097e-02f, -1.60861090e-02f, -1.04991614e-03f, 1.47227114e-02f, -2.88893352e-03f,
  -6.98781619e-03f, 2.52176374e-02f, 1.72008593e-02f, -4.96870615e-02f, 5.97624071e-02f, 2.53278557e-02f, -1.94121916e-02f, -6.11166190e-03f, -1.83005375e-03f, 9.62703582e-03f,
  4.51949686e-02f, 8.67019817e-02f, 4.33830544e-02f, 5.10358512e-02f, -2.87750959e-02f, 8.68722424e-02f, 5.81353940e-02f, -1.92998052e-02f, 3.23903225e-02f, -1.35630239e-02f,
  -4.27008756e-02f, -2.47002598e-02f, 7.35759959e-02f, 4.57583033e-02f, 3.30646858e-02f, 5.68026258e-03f, 6.26728982e-02f, 9.85288154e-03f, 1.08803086e-01f, 4.70012985e-02f,
  -4.17211605e-03f, 3.80555131e-02f, -1.80642698e-02f, 6.01134263e-02f, -8.85012839e-03f, 4.79282103e-02f, -5.02366126e-02f, 1.01655629e-02f, 6.04540445e-02f, -2.21835952e-02f,
  -1.23754844e-01f, -5.36844246e-02f, -1.29901990e-01f, 1.36973575e-01f, 1.27378345e-01f, 2.03965202e-01f, 2.15692103e-01f, 7.01871812e-02f, 9.37499404e-02f, 1.51748195e-01f,
  2.08334327e-01f, -5.10557070e-02f, -1.44828171e-01f, 3.81859452e-01f, 4.78189513e-02f, 6.64230064e-02f, 2.75532037e-01f, 1.89937741e-01f, -6.11739382e-02f, -7.16708973e-02f,
  6.95693772e-03f, 1.56644508e-01f, 4.47635427e-02f, -1.85881555e-02f, 1.28097907e-01f, -1.33514911e-01f, -9.42298844e-02f, -1.70892194e-01f, 1.96169108e-01f, 1.38111740e-01f,
  -4.78094332e-02f, -2.27843188e-02f, -2.69550141e-02f, -9.64803994e-02f, 1.34819373e-02f, -2.69122794e-02f, -4.41486090e-02f, 1.61265628e-03f, -3.06181470e-03f, 4.67066877e-02f,
  -7.67319603e-03f, -1.51656587e-02f, 9.54792425e-02f, -9.83954780e-03f, -2.64508557e-02f, 1.76266767e-02f, 5.34622706e-02f, -6.12830557e-03f, 7.63367256e-03f, 1.68678463e-02f,
  8.39929953e-02f, 1.22600487e-02f, 2.61237249e-02f, 8.58591776e-03f, -4.26061153e-02f, 4.42960262e-02f, -3.97772454e-02f, 2.51636561e-03f, 6.84819445e-02f, 6.84119239e-02f,
  -1.16853705e-02f, -8.85528922e-02f, 1.10321213e-02f, -2.38064618e-04f, -5.07460460e-02f, 1.74783897e-02f, -3.25675309e-02f, 3.21361981e-02f, -9.90053788e-02f, 2.11591530e-03f,
  3.99645381e-02f, 2.28436608e-02f, -5.16484380e-02f, -5.77043602e-03f, 3.83125730e-02f, -7.18416786e-03f, 1.77353546e-02f, -2.94765774e-02f, 3.50470468e-02f, 5.20529337e-02f,
  -4.58512232e-02f, -8.44137091e-03f, -7.99849164e-03f, 2.75302771e-02f, 1.86361577e-02f, -4.47208174e-02f, -4.22693826e-02f, 2.01088213e-03f, -8.85233399e-04f, -7.33104646e-02f,
  -2.27406830e-01f, -2.25145504e-01f, 6.71290532e-02f, 6.37160689e-02f, -2.48141736e-02f, 3.97008099e-02f, -4.19971347e-02f, 4.38654721e-02f, -5.18324971e-02f, -1.59871802e-02f,
  -1.47162108e-02f, 1.77062489e-03f, -4.26870994e-02f, -2.90344600e-02f, -6.91266591e-03f, 2.40820795e-02f, -4.82492708e-02f, -2.39458168e-03f, -5.89899579e-03f, -1.21373106e-02f,
  -8.58976564e-04f, -8.95234942e-03f, -1.32069481e-03f, -1.91694479e-02f, 4.41015773e-02f, 2.92196609e-02f, -6.15011249e-03f, -8.69216677e-03f, -2.90548615e-02f, -4.19246666e-02f,
  1.52889028e-01f, 1.67247534e-01f, -1.09232530e-01f, 8.36381987e-02f, 1.60759047e-01f, -1.65139839e-01f, -1.29098043e-01f, 1.55989125e-01f, -8.73877257e-02f, 1.73215240e-01f,
  3.72223146e-02f, 8.08429532e-03f, -1.06070600e-01f, -2.54862066e-02f, -2.64396369e-01f, -3.81558150e-01f, 5.08931801e-02f, -8.90331566e-02f, -6.45528436e-02f, 2.78333753e-01f,
  -2.31637880e-02f, 2.18530864e-01f, -1.58151671e-01f, 2.45674416e-01f, 1.35671914e-01f, 6.06033504e-02f, 2.72521228e-01f, -2.21612919e-02f, 2.36482918e-01f, -2.39791758e-02f,
  -3.77211347e-02f, 4.69309390e-02f, 4.36801836e-03f, -1.02677763e-01f, 3.37213390e-02f, 4.96915095e-02f, 3.83625086e-03f, -7.44857192e-02f, -2.52202488e-02f, -4.72363941e-02f,
  1.56835541e-02f, 1.76667087e-02f, -8.70138966e-03f, -7.42865074e-03f, -1.63524337e-02f, -5.49153164e-02f, -3.12852077e-02f, -4.44612578e-02f, 1.66299362e-02f, -1.09322496e-01f,
  -5.14403097e-02f, -3.89458872e-02f, -7.10416883e-02f, 4.15069088e-02f, -4.45705093e-02f, -7.31219500e-02f, -3.47933806e-02f, -5.10614878e-03f, 1.18686236e-03f, 1.17573747e-02f,
  -2.79637184e-02f, 3.57714519e-02f, -6.84264395e-03f, 2.35676765e-02f, 3.62534299e-02f, 3.10763009e-02f, 1.37814861e-02f, -1.70001518e-02f, -3.86910141e-02f, 1.76591929e-02f,
  1.78291984e-02f, 3.20958905e-02f, -2.38124393e-02f, -2.67450809e-02f, 2.07339171e-02f, 3.39271240e-02f, -2.80633885e-02f, 3.47212236e-03f, 5.66811487e-03f, -4.68215123e-02f,
  -8.66389275e-03f, -5.12537546e-03f, 8.65338966e-02f, 6.55117398e-03f, -5.59643144e-03f, 9.15582571e-03f, 4.30691093e-02f, -2.09351387e-02f, -2.77778860e-02f, 1.37520721e-02f,
  2.54097819e-01f, 2.82008976e-01f, 2.79491544e-02f, 5.85447364e-02f, 2.89018899e-02f, -4.26034704e-02f, -1.90445688e-02f, -2.63508316e-02f, 2.11862735e-02f, 3.04842424e-02f,
  -1.24563547e-02f, -2.85836291e-02f, 5.70714958e-02f, -7.34429657e-02f, 9.24228132e-03f, 6.27477020e-02f, 3.86747047e-02f, 4.79733981e-02f, 7.98149332e-02f, 6.92900270e-02f,
  8.12767223e-02f, 4.86146659e-02f, -5.17279934e-03f, 2.13636123e-02f, -1.61309075e-02f, 4.34879214e-02f, 5.54838069e-02f, -1.10374525e-01f, -2.28396300e-02f, -2.33050138e-02f,
  -8.13361928e-02f, -1.27825886e-01f, -9.92738158e-02f, -1.40059054e-01f, -3.29531431e-01f, -2.72592425e-01f, -1.71295293e-02f, -3.10269952e-01f, -3.00502986e-01f, 2.27932692e-01f,
  3.42536792e-02f, 5.42789549e-02f, 2.18034521e-01f, -9.38368440e-02f, 1.11777231e-01f, 8.02175701e-02f, -1.30742386e-01f, -2.40809890e-03f, -2.10324928e-01f, -3.87415737e-02f,
  -1.32090434e-01f, -2.85317050e-03f, -9.34578478e-03f, -4.80432436e-02f, -1.56809434e-01f, -1.56413782e-02f, 2.81406939e-01f, 6.98713735e-02f, 1.00215711e-01f, -5.35834469e-02f,
  -9.04410053e-03f, -1.60414919e-01f, -8.22781250e-02f, -4.13387902e-02f, 3.35881710e-02f, -7.04744970e-03f, 4.95641939e-02f, 8.13051015e-02f, -1.07749060e-01f, -8.53815004e-02f,
  4.96797822e-02f, -7.07456470e-02f, -4.31415364e-02f, -4.60307673e-02f, -1.39677435e-01f, 3.88694461e-03f, -9.64278821e-03f, -1.04428858e-01f, -7.98098817e-02f, -3.45688574e-02f,
  -3.77774052e-02f, -6.22815453e-02f, -3.00365593e-02f, -4.73202057e-02f, -7.26439944e-03f, -1.05807491e-01f, -1.50329666e-02f, -2.09075119e-03f, 3.10590933e-03f, -3.14006470e-02f,
  -7.81597644e-02f, -2.73971707e-02f, 1.04086660e-01f, 2.48215185e-03f, -1.55776320e-03f, 3.85378934e-02f, -1.19095873e-02f, 8.37785825e-02f, 8.65215808e-03f, -2.44683065e-02f,
  -5.15705496e-02f, -6.55640587e-02f, -2.64053605e-02f, -1.29403975e-02f, 2.14454178e-02f, -6.05604239e-02f, 3.37469541e-02f, -2.34044082e-02f, -1.43701406e-02f, 1.90243963e-02f,
  2.26290114e-02f, 1.11812195e-02f, 3.84194218e-02f, 3.76822464e-02f, -1.91492997e-02f, 2.93524060e-02f, 1.76025310e-03f, -3.95062231e-02f, 1.72482822e-02f, 6.14484735e-02f,
  1.16545809e-02f, 1.39063030e-01f, -2.33021267e-02f, -2.09288914e-02f, 1.08359180e-01f, -4.10237946e-02f, -1.45464614e-02f, -8.09281915e-02f, 4.40774672e-02f, 2.49717408e-03f,
  2.17745956e-02f, 1.52990790e-02f, 5.77449538e-02f, 3.26599069e-02f, 1.11282445e-01f, 3.68705243e-02f, 7.41912872e-02f, -3.44077721e-02f, 5.32571152e-02f, -2.64535882e-02f,
  3.00162397e-02f, 4.17780541e-02f, 4.79212664e-02f, -1.35953361e-02f, -2.86833458e-02f, 1.33791849e-01f, -5.78339491e-03f, -5.23264222e-02f, 1.32571189e-02f, 4.14650515e-03f,
  -1.27634615e-01f, -2.25263849e-01f, 8.71548206e-02f, -6.20294660e-02f, 8.21813568e-02f, 2.11411104e-01f, 3.65983307e-01f, -6.16334304e-02f, -4.97415736e-02f, -1.43650146e-02f,
  -2.67374348e-02f, -2.01488703e-01f, 3.46652687e-01f, -2.56266773e-01f, 5.62930070e-02f, 1.98853374e-01f, -3.81135941e-02f, -1.73767600e-02f, -3.12317088e-02f, -2.29061432e-02f,
  -2.74606571e-02f, -2.18507066e-01f, 1.06875740e-01f, -2.19977409e-01f, -3.35794277e-02f, -1.07046776e-01f, -6.87495843e-02f, 9.57466662e-02f, -2.72787333e-01f, -3.07264347e-02f,
  6.77386150e-02f, -8.28562975e-02f, 2.36527566e-02f, -5.95947057e-02f, 6.84063286e-02f, -2.09900383e-02f, 3.39641981e-02f, 4.58647404e-03f, -1.00772204e-02f, 6.09139819e-03f,
  -4.10644561e-02f, -6.14096336e-02f, -6.24883436e-02f, -1.12560885e-02f, -2.14227499e-03f, -8.69293809e-02f, 9.76269506e-03f, 4.71454039e-02f, 2.26217769e-02f, -6.51695952e-02f,
  4.14679050e-02f, -6.25116751e-02f, -9.93477181e-03f, -9.19891074e-02f, 1.01563232e-02f, 2.71221101e-02f, 1.69754773e-02f, 4.91438396e-02f, -3.62312160e-02f, -6.27431795e-02f,
  -4.22906056e-02f, -4.93096001e-03f, 2.28687935e-02f, -2.18262915e-02f, -6.09974563e-03f, 2.67892368e-02f, -4.23600003e-02f, 3.96736003e-02f, -1.20988339e-02f, 6.82090074e-02f,
  -4.00446840e-02f, 1.11790944e-03f, -5.09434342e-02f, 2.70081088e-02f, 2.40507200e-02f, -4.70352173e-03f, 5.17286435e-02f, -8.65656361e-02f, 7.11683976e-03f, -8.63029854e-04f,
  -1.72334036e-03f, 2.54333783e-02f, -5.43100871e-02f, 6.33404478e-02f, 6.15018457e-02f, 5.99691123e-02f, -9.00739878e-02f, 2.59335879e-02f, 9.72839668e-02f, 4.05328944e-02f,
  4.04223576e-02f, -1.85696647e-01f, -1.24824159e-02f, 4.27274294e-02f, -4.45381626e-02f, -8.22561383e-02f, -8.12818389e-03f, -5.43546490e-02f, -4.19856384e-02f, -4.08702306e-02f,
  -1.40052673e-03f, 2.82390900e-02f, 2.08379682e-02f, -5.19454181e-02f, 5.01956902e-02f, 5.75332530e-02f, 2.61134878e-02f, -3.62548344e-02f, -4.90163006e-02f, -4.42406125e-02f,
  -2.93665938e-02f, 7.03074411e-02f, 4.31403294e-02f, 1.64492857e-02f, -2.62898039e-02f, -3.78722399e-02f, -5.41012548e-02f, -5.40365800e-02f, 1.23706488e-02f, -3.33885141e-02f,
  5.81962541e-02f, -4.17949021e-01f, -4.45927203e-01f, 3.99691276e-02f, 7.70200230e-03f, 3.94419581e-02f, 1.49537981e-01f, -1.28160834e-01f, 1.36293963e-01f, 7.62329996e-02f,
  7.71867558e-02f, -1.52673051e-01f, -6.46437258e-02f, 3.05404440e-02f, 1.38587639e-01f, 1.14806242e-01f, 1.87527090e-01f, 1.71681955e-01f, -5.77088706e-02f, -1.80514958e-02f,
  3.21085602e-02f, 1.84033573e-01f, -1.25833109e-01f, -1.86419353e-01f, -8.07248987e-03f, -1.99469507e-01f, 1.07150756e-01f, -1.25073373e-01f, -3.76917087e-02f, -1.79269630e-02f,
  -1.99879315e-02f, -8.30326453e-02f, -5.46219274e-02f, 1.09960223e-02f, 2.02354863e-02f, 7.32843876e-02f, 4.45788577e-02f, 1.78825185e-02f, 1.01167625e-02f, 8.84050783e-03f,
  8.09324719e-03f, -5.61484359e-02f, -9.38892178e-03f, 6.08715378e-02f, -4.48027179e-02f, -1.15210004e-01f, -6.00046813e-02f, -3.20986286e-03f, 8.57931096e-03f, -3.18122320e-02f,
  -9.09343883e-02f, 2.25372408e-02f, 5.78725077e-02f, 3.34320627e-02f, -1.31949885e-02f, -7.37856561e-03f, -3.11811664e-03f, 2.49261595e-02f, 5.74507415e-02f, -4.07961495e-02f,
  4.39223573e-02f, 9.88558456e-02f, 1.61161851e-02f, 9.68438201e-03f, 3.10024526e-02f, -6.88839853e-02f, 4.35558446e-02f, 8.96059908e-03f, -1.36959478e-02f, -5.18200584e-02f,
  4.93314676e-02f, 1.54494205e-02f, 8.81535839e-03f, 5.64195029e-02f, 7.93097392e-02f, 5.29524535e-02f, 7.17259524e-03f, -2.31515188e-02f, -2.82004429e-03f, -3.38647403e-02f,
  -5.53908572e-02f, 6.61834851e-02f, -2.47992184e-02f, 1.06084898e-01f, -1.17816729e-03f, 2.64342912e-02f, 2.04956848e-02f, -4.38668989e-02f, 4.07004282e-02f, 5.48159443e-02f,
  -1.25402352e-02f, -1.59176923e-02f, -6.61295950e-02f, 2.20803581e-02f, -4.58819494e-02f, -4.54646274e-02f, -1.61376093e-02f, -3.98879424e-02f, -1.76426005e-02f, 7.64630213e-02f,
  -7.80558260e-03f, 1.10310083e-02f, -3.88703719e-02f, -6.31382614e-02f, 8.91042128e-03f, 6.11685626e-02f, 3.68669070e-02f, 5.57323582e-02f, 4.06343564e-02f, -7.61323571e-02f,
  -5.10485005e-03f, 5.36418296e-02f, -3.05516589e-02f, -1.27559295e-02f, 3.56676988e-02f, -3.70631577e-03f, 3.41390562e-03f, -9.10704508e-02f, -1.80620458e-02f, 3.52780893e-02f,
  -1.20352516e-02f, -1.64146975e-01f, -2.27855258e-02f, -3.24385822e-01f, 1.22325793e-01f, 3.05000991e-01f, 5.12619279e-02f, -8.15860629e-02f, -2.74438620e-01f, -7.51284882e-02f,
  8.95491019e-02f, -4.71499525e-02f, -1.62030421e-02f, -2.07627311e-01f, 3.08824271e-01f, -7.27703348e-02f, -8.90557468e-02f, -5.87447546e-02f, -1.48973808e-01f, 5.24446659e-04f,
  -9.10437480e-03f, 1.05755422e-02f, -5.82792871e-02f, 2.21587997e-02f, -3.00193187e-02f, -8.75900835e-02f, 1.01076715e-01f, -7.69507419e-03f, 4.02578861e-02f, 1.00370571e-01f,
  1.12635903e-01f, -1.64865449e-01f, -1.05799414e-01f, -3.22023518e-02f, 5.05370460e-02f, 4.86692004e-02f, 4.98522632e-02f, 1.53177623e-02f, -6.91990554e-03f, -1.34603623e-02f,
  6.22524414e-03f, 7.52903372e-02f, -1.17104776e-01f, 2.63501909e-02f, 5.99511724e-04f, -4.07989137e-02f, -1.76299326e-02f, -1.17441220e-02f, -2.43633222e-02f, 5.02395220e-02f,
  -7.04958215e-02f, -7.20142573e-03f, -2.95271222e-02f, -5.35376333e-02f, 2.44945399e-02f, 3.80317904e-02f, -1.44824423e-02f, 5.91651984e-02f, 4.07427326e-02f, 1.30887618e-02f,
  -6.27441779e-02f, 2.74418928e-02f, -1.70975756e-02f, -1.08626327e-02f, 1.94499437e-02f, -2.54885796e-02f, 3.11252866e-02f, -1.73910186e-02f, 3.96432430e-02f, 6.39820099e-02f,
  5.61486781e-02f, -8.42179433e-02f, -5.31863570e-02f, -2.31128791e-03f, 1.74132365e-04f, -5.07241040e-02f, -1.27278809e-02f, 8.44316259e-02f, -4.35127765e-02f, -1.03809508e-02f,
  -8.27862397e-02f, 2.52690706e-02f, 4.42664102e-02f, 7.14514479e-02f, -2.46804655e-02f, 3.89027335e-02f, -7.58731663e-02f, -5.76493852e-02f, -7.35763684e-02f, 7.12673813e-02f,
  3.13091129e-01f, 7.67103489e-03f, 4.96898405e-02f, 2.87824627e-02f, 5.07679651e-04f, 1.70088559e-02f, -4.79479320e-02f, 1.55836735e-02f, 9.28738900e-03f, -1.26176728e-02f,
  7.14202002e-02f, 2.17657257e-03f, 9.25369710e-02f, -4.47613522e-02f, 1.72542967e-03f, 6.10569566e-02f, 2.05924697e-02f, -7.31808553e-03f, 2.04918105e-02f, -3.58776888e-03f,
  6.08409680e-02f, 4.05502804e-02f, -4.66825739e-02f, -2.79810354e-02f, 1.49128279e-02f, 1.38545400e-02f, 2.23372336e-02f, -5.55988438e-02f, 9.12183989e-03f, 3.57519239e-02f,
  2.52189726e-01f, -3.29770327e-01f, 1.55019611e-01f, 3.21581930e-01f, 1.22237235e-01f, 1.62203237e-02f, 1.87126026e-01f, -4.39786576e-02f, 3.67168523e-02f, -3.60429108e-01f,
  -6.28188848e-02f, 4.80012447e-02f, -1.98193505e-01f, -5.92794223e-03f, 3.81643474e-01f, -1.24208361e-01f, -3.35882157e-02f, -4.54611331e-02f, 7.47356191e-02f, 1.79712951e-01f,
  2.37196222e-01f, 3.07197869e-02f, 1.71206668e-01f, -1.07533172e-01f, 1.49975076e-01f, 1.26387730e-01f, 5.79180494e-02f, 7.28061348e-02f, -5.04694767e-02f, 3.08619309e-02f,
  -6.80978745e-02f, -4.81538810e-02f, -3.53475884e-02f, -1.05237588e-01f, 1.56701859e-02f, -1.42663093e-02f, 9.32241231e-03f, -1.64482035e-02f, 7.44552836e-02f, -3.63332294e-02f,
  -2.22060196e-02f, 6.30025938e-02f, -2.86328271e-02f, 4.99106310e-02f, 2.69275997e-02f, -3.16494294e-02f, 1.69943105e-02f, -1.70769438e-03f, 5.18734790e-02f, 8.26106146e-02f,
  -3.50137465e-02f, -4.70282510e-02f, 2.43661157e-03f, -1.13991484e-01f, 3.74502540e-02f, 4.30224044e-03f, 3.83118093e-02f, 3.28315683e-02f, -5.81389628e-02f, 1.75713692e-02f,
  -3.59031116e-03f, 5.17089069e-02f, -2.76450422e-02f, -1.84973720e-02f, 1.27606001e-02f, -1.74341854e-02f, -3.86360511e-02f, -9.46491375e-04f, -9.32324212e-03f, -4.73867245e-02f,
  3.62164713e-02f, 1.11423256e-02f, -4.51471433e-02f, -3.95091847e-02f, 4.31135073e-02f, 1.59552973e-02f, 1.03948070e-02f, -9.08482522e-02f, 1.10226395e-02f, -1.68033298e-02f,
  1.61425155e-02f, -1.32357022e-02f, -2.34411880e-02f, -1.81684084e-02f, 1.14058107e-02f, 5.93081899e-02f, -1.23414686e-02f, -5.30989766e-02f, 4.44920324e-02f, 8.03206488e-02f,
  -1.27946317e-01f, 1.47488969e-03f, 1.64624788e-02f, -1.08394027e-02f, -7.90769905e-02f, -3.80693339e-02f, 5.60232112e-03f, 2.69116485e-03f, -3.63851339e-02f, 4.86861318e-02f,
  -3.67164263e-03f, -1.04938662e-02f, 7.76939606e-03f, -3.92880961e-02f, -1.93004310e-02f, 1.16460407e-02f, -2.29028836e-02f, -1.13717513e-02f, 3.29321274e-03f, -4.39316854e-02f,
  4.15257923e-02f, -2.59863287e-02f, 3.21201123e-02f, 9.24644023e-02f, -2.43022181e-02f, 5.20624127e-03f, 7.35822022e-02f, 8.82846955e-03f, -1.91833470e-02f, -1.88777950e-02f,
  1.36072207e-02f, 4.07378115e-02f, -2.89976507e-01f, -4.37124297e-02f, 1.55034751e-01f, 1.52179807e-01f, 1.29317448e-01f, 5.10326736e-02f, -9.56037045e-02f, 2.20888227e-01f,
  1.73775166e-01f, -1.22153737e-01f, -1.01320826e-01f, 2.79851019e-01f, -2.06398576e-01f, -2.05369830e-01f, 9.27586779e-02f, 1.52092963e-01f, -1.40327156e-01f, 8.96409675e-02f,
  -3.14322785e-02f, 3.09986651e-01f, -1.29399523e-01f, 2.43934542e-01f, 1.11613944e-01f, 1.08229835e-02f, -1.46740936e-02f, -4.99642603e-02f, 1.21086054e-01f, -9.84789245e-03f,
  6.54852018e-02f, 7.92722125e-03f, 5.79626113e-03f, -5.69981113e-02f, 3.65951434e-02f, 1.19087890e-01f, 1.11391768e-02f, -3.35272253e-02f, -1.09968156e-01f, 1.94801278e-02f,
  1.26382904e-02f, -4.15505767e-02f, -1.49291195e-02f, -7.76877105e-02f, 8.28195214e-02f, 1.96794625e-02f, -9.50266123e-02f, 1.84714142e-02f, 2.99527049e-02f, -2.35418174e-02f,
  -1.24607608e-02f, 1.87153323e-03f, -9.75998957e-03f, -6.75122663e-02f, -1.42854648e-02f, -3.05355974e-02f, -3.17717642e-02f, -3.22280452e-02f, -2.67556142e-02f, 1.77904386e-02f,
  2.23159231e-02f, -1.17049785e-02f, 3.08939163e-02f, 2.68783979e-02f, 1.62679218e-02f, 3.31459716e-02f, -1.06649380e-03f, 8.71718768e-03f, -5.26672900e-02f, 7.55348131e-02f,
  -4.37500030e-02f, 5.83084347e-03f, 5.35555370e-02f, -1.18871052e-02f, 5.46268821e-02f, -2.35366309e-03f, -6.57523721e-02f, -6.41309749e-03f, -3.20700705e-02f, -6.42818585e-02f,
  3.95058580e-02f, -3.80260870e-02f, 4.99148704e-02f, 3.57155725e-02f, -3.10777277e-02f, -3.15502286e-02f, 1.39615135e-02f, -1.00620100e-02f, -2.99299620e-02f, 4.89034392e-02f,
  -1.24507593e-02f, -1.78005584e-02f, -1.83285549e-02f, -4.71393466e-02f, -2.74314620e-02f, 1.03245012e-01f, -5.80709353e-02f, -3.36230570e-03f, 6.77749328e-03f, -4.16154340e-02f,
  5.23883030e-02f, 7.85538927e-03f, 5.67148440e-02f, 3.76133397e-02f, -1.64224617e-02f, 4.20128070e-02f, 2.60002781e-02f, 1.22011304e-02f, 1.91912949e-02f, -7.44181965e-03f,
  1.55719668e-02f, 4.97827940e-02f, 5.74641675e-02f, 3.37066315e-02f, 2.89420970e-02f, 2.13656351e-02f, 3.67525183e-02f, -2.74770185e-02f, 5.09543940e-02f, -5.66786081e-02f,
  -1.75192971e-02f, 4.87534069e-02f, 4.09456968e-01f, -7.20941201e-02f, -7.23029226e-02f, -1.51235700e-01f, -2.13614851e-01f, -6.20805658e-02f, -1.13151968e-02f, -2.40381762e-01f,
  -1.74971670e-01f, 6.66790456e-02f, 2.51709688e-02f, -5.48529699e-02f, 2.63639897e-01f, 1.87492102e-01f, -1.71135753e-01f, -6.14068769e-02f, 4.63378318e-02f, -1.21862642e-01f,
  9.19250771e-02f, -2.73257643e-01f, 3.14608246e-01f, -5.51996157e-02f, -1.32913515e-01f, 5.51112629e-02f, -1.21401176e-01f, 9.67426971e-02f, 5.24223670e-02f, 8.28615129e-02f,
  -1.29863918e-01f, 4.55992557e-02f, 5.34019992e-02f, 9.46063921e-02f, -8.20844397e-02f, -1.82126258e-02f, 1.73402932e-02f, 5.65138981e-02f, 4.49890457e-02f, 2.74885516e-03f,
  -6.02419153e-02f, -2.98284553e-02f, 1.22900093e-02f, 2.55010072e-02f, -1.26022354e-01f, 4.39250134e-02f, 6.89917207e-02f, 5.45454165e-03f, 4.95643727e-02f, 6.24757037e-02f,
  9.77169126e-02f, 1.06069244e-01f, 1.84410121e-02f, 1.86842363e-02f, 7.49197230e-02f, -5.80608472e-02f, -6.21106056e-03f, 5.37622347e-02f, -3.59043814e-02f, -8.74375086e-03f,
  3.82776186e-02f, -3.48893292e-02f, -1.94995496e-02f, -2.32158136e-02f, 3.44992615e-02f, 1.76916718e-02f, 1.31515255e-02f, 1.70100834e-02f, 8.27051792e-03f, -5.36497906e-02f,
  -3.28228772e-02f, 5.98198222e-03f, -1.55328242e-02f, -3.64119560e-02f, -5.04559167e-02f, -4.48960289e-02f, -4.44582440e-02f, -6.11713864e-02f, 4.02854346e-02f, 4.10746858e-02f,
  -1.92014258e-02f, -1.12829423e-02f, 2.70671453e-02f, -1.74570344e-02f, -4.53494340e-02f, 3.24246399e-02f, -1.21975951e-02f, 3.31743173e-02f, -7.52279186e-04f, 7.78006949e-03f,
  -3.15018058e-01f, -2.13102788e-01f, -3.21373716e-02f, -1.15870401e-01f, -6.38215989e-02f, -3.09984665e-02f, 2.74718106e-02f, -2.85453396e-03f, -2.91438811e-02f, -7.34071508e-02f,
  -1.80956591e-02f, -2.46463828e-02f, -2.70609017e-02f, -5.48174307e-02f, 3.80745567e-02f, -3.37952115e-02f, -5.15908599e-02f, -2.81156432e-02f, -1.30731404e-01f, -2.33971383e-02f,
  -7.84413442e-02f, -3.95113453e-02f, 3.96236591e-02f, -6.09538145e-02f, 4.79973108e-03f, -3.65698114e-02f, 1.07370140e-02f, 3.14025208e-02f, 3.15946303e-02f, 2.37670932e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.00864090e-01f, 7.25122318e-02f, -8.38627964e-02f, -5.15069366e-02f, -9.49697942e-02f, -4.41255979e-03f, 4.14855666e-02f, -3.73521969e-02f, 1.11475602e-01f, 1.67485952e-01f,
  -2.05013230e-01f, 9.78257284e-02f, -3.10262702e-02f, -3.41749229e-02f, 7.88718686e-02f, 1.45022020e-01f, -1.50857121e-02f, 7.18626156e-02f, -5.59735373e-02f, -5.75896427e-02f,
  2.99605485e-02f, -1.20505802e-01f, -9.06515047e-02f, 3.60587686e-02f, -2.75751829e-01f, -6.74684197e-02f, -4.89775203e-02f, -8.07331279e-02f, -1.04573853e-01f, 1.64703950e-02f,
  2.98839044e-02f, -1.44552261e-01f, -1.44772276e-01f, -1.00156069e-02f, 8.05712268e-02f, -1.42185986e-02f, 3.03255357e-02f, -3.57950740e-02f, -4.89127226e-02f, 4.02819104e-02f,
  -8.37398395e-02f, -2.60623172e-02f, 7.92914480e-02f, -7.27981329e-02f, -8.55673626e-02f, -2.49501429e-02f, 2.14077532e-04f, -7.89552629e-02f, -1.15156341e-02f, 1.94010569e-03f,
  -5.81336468e-02f, 7.68381283e-02f, -6.77511916e-02f, 5.66567034e-02f, -1.03971511e-01f, -4.85082157e-02f, -4.28126492e-02f, -3.68751101e-02f, 3.12817693e-02f, -2.81628482e-02f,
  7.63296112e-02f, 1.94502696e-02f, -3.44419517e-02f, -5.38174435e-02f, -4.30990607e-02f, 2.63565890e-02f, -4.89943326e-02f, -5.97909875e-02f, -3.28003382e-03f, -7.43696913e-02f,
  -4.65545915e-02f, 3.09290681e-02f, 3.57552096e-02f, 5.54840975e-02f, -1.37706026e-02f, 1.38832796e-02f, -1.31268380e-03f, 2.32623052e-02f, 6.03385270e-02f, -2.00167391e-02f,
  4.53207977e-02f, 5.46311140e-02f, -7.71994665e-02f, -6.61914125e-02f, 4.71616387e-02f, -1.23536363e-02f, 6.12098612e-02f, 2.95393565e-03f, -1.60151161e-02f, 2.26321444e-02f,
  1.00663081e-01f, 2.08032995e-01f, 3.01966872e-02f, -1.10325076e-01f, -3.50374170e-02f, 3.20535316e-03f, 5.62827922e-02f, 1.77368596e-02f, 2.57287137e-02f, -5.51816411e-02f,
  2.71238051e-02f, -1.24938898e-02f, 2.04696767e-02f, 6.39041066e-02f, 4.21695448e-02f, -5.80146872e-02f, 3.43175605e-02f, -9.87656694e-03f, 1.73537508e-02f, -2.49743951e-03f,
  -2.25788709e-02f, -1.53597053e-02f, 6.54855669e-02f, 5.39945513e-02f, -1.15763908e-02f, 5.35424836e-02f, 4.78110202e-02f, -7.98242390e-02f, -6.97429925e-02f, 8.84663314e-02f,
  1.80717632e-02f, -5.23645766e-02f, -1.26452446e-01f, -5.24129346e-02f, 7.32061416e-02f, 7.08561838e-02f, 1.37285218e-01f, -5.76997362e-02f, -2.82005250e-01f, 1.66250676e-01f,
  4.75734510e-02f, -8.40728953e-02f, 2.55436637e-02f, -1.55242577e-01f, -2.03158483e-01f, -1.77425101e-01f, -1.00550219e-01f, 3.03837843e-02f, -2.08399490e-01f, 4.42002192e-02f,
  -4.45007980e-02f, -6.12505190e-02f, -7.15750679e-02f, -9.91573650e-03f, 1.24179624e-01f, 4.31815572e-02f, 1.26705363e-01f, 1.22513555e-01f, -4.56071198e-02f, -2.68857125e-02f,
  -4.02484387e-02f, -8.71945471e-02f, 5.16074663e-03f, -1.21183425e-01f, 2.25735432e-03f, 1.36511683e-01f, 1.16395690e-01f, -9.10550356e-03f, 4.99894377e-03f, 7.97973126e-02f,
  1.19852930e-01f, -6.42512292e-02f, -2.33071931e-02f, -3.64176184e-02f, -2.75928043e-02f, -6.35199100e-02f, -9.97217745e-02f, -3.18776928e-02f, -2.76681948e-02f, 1.99503098e-02f,
  5.51561266e-03f, 4.16989811e-02f, -2.57168687e-03f, -5.58439121e-02f, -1.60601512e-02f, -6.39880598e-02f, 7.79628009e-02f, 7.61740133e-02f, 9.03886557e-02f, -1.17218643e-02f,
  4.91686389e-02f, -1.47148259e-02f, -7.84246027e-02f, -9.16701555e-03f, 2.45614052e-02f, 7.11823702e-02f, -6.70808256e-02f, 6.46922213e-04f, -6.34680167e-02f, -4.40948363e-03f,
  -2.71728784e-02f, -4.05577980e-02f, 6.14313856e-02f, 8.43129959e-03f, -6.94864765e-02f, -2.71421876e-02f, 6.93160892e-02f, -1.44764297e-02f, 2.77089272e-02f, 2.34850571e-02f,
  3.15144286e-03f, -7.11543337e-02f, 1.11051053e-02f, 2.55687870e-02f, 6.43414482e-02f, -6.86671818e-03f, -1.77251734e-02f, -5.17005771e-02f, -5.73207857e-03f, 6.71719015e-02f,
  1.05804354e-01f, 5.37352711e-02f, 1.09062931e-02f, -7.31958821e-02f, -4.84415404e-02f, 1.04932718e-01f, 4.89591658e-02f, -1.02725765e-02f, 1.95857622e-02f, -5.46869040e-02f,
  1.18023768e-01f, 9.56963003e-02f, 6.74380586e-02f, -2.24510655e-02f, 1.14848269e-02f, -4.06949483e-02f, -6.59643207e-03f, 2.41944510e-02f, 4.94125560e-02f, -3.05494461e-02f,
  1.24914534e-01f, 9.52056609e-03f, 8.44525397e-02f, -4.97706421e-03f, 1.63853150e-02f, 6.43376112e-02f, 3.57556827e-02f, -6.93471059e-02f, 4.19924781e-02f, 3.95997241e-02f,
  -5.44776767e-02f, -1.05831124e-01f, 1.59856960e-01f, -2.30948582e-01f, -1.16975151e-01f, 2.45077670e-01f, 2.62905240e-01f, -1.29410625e-01f, -2.04472482e-01f, -9.48998053e-03f,
  -3.72147374e-02f, 9.80664324e-03f, 2.11864635e-01f, 4.26335447e-02f, 1.55150667e-01f, 2.29201347e-01f, -2.88537219e-02f, 1.39582217e-01f, -9.75483730e-02f, -4.95517999e-02f,
  -1.20391876e-01f, -1.49534196e-01f, 1.72280073e-01f, -3.10935136e-02f, -1.85492352e-01f, -2.78444290e-01f, -1.00139022e-01f, 7.25316107e-02f, -1.77166954e-01f, -6.10114075e-02f,
  -4.13159840e-03f, -7.48230815e-02f, -5.15896976e-02f, 7.46272039e-04f, 4.69367169e-02f, 2.68110801e-02f, 1.61048714e-02f, -1.89940259e-02f, -6.89531816e-03f, -3.07557303e-02f,
  3.91782671e-02f, -4.76456136e-02f, -7.67388046e-02f, -3.32961380e-02f, -1.94022823e-02f, -1.38173550e-01f, -5.88609613e-02f, -2.58160345e-02f, -3.91545482e-02f, -6.36157840e-02f,
  5.08395545e-02f, 2.80709304e-02f, -6.10103197e-02f, 7.09863799e-03f, -9.83655155e-02f, -3.38857509e-02f, -2.04589241e-03f, 8.30488503e-02f, -8.66393521e-02f, -5.15486933e-02f,
  -1.44514823e-02f, -2.91450471e-02f, 2.35571489e-02f, -3.41264647e-03f, -2.73592002e-03f, -7.25227743e-02f, -2.84180348e-03f, -3.20939869e-02f, 4.27660048e-02f, -3.39940377e-02f,
  3.56635600e-02f, -1.19490057e-01f, -6.40993714e-02f, -1.38761541e-02f, -2.20409762e-02f, -4.82777543e-02f, 9.94162709e-02f, -8.07612389e-02f, 4.65940312e-02f, -6.42259941e-02f,
  6.76684156e-02f, -2.98934411e-02f, 6.01433441e-02f, -5.05631529e-02f, 6.46126270e-02f, -7.76631832e-02f, -1.72736943e-02f, 4.51975651e-02f, -2.91883363e-04f, -3.85732427e-02f,
  -2.70231310e-02f, -9.76927876e-02f, 4.13880963e-03f, -9.02308449e-02f, 3.44145447e-02f, -2.23363843e-03f, -4.31545526e-02f, 3.31253046e-03f, 7.41216764e-02f, 2.46683434e-02f,
  2.83304509e-02f, 5.57552464e-02f, 1.47936633e-02f, -6.37037233e-02f, -2.44855732e-02f, -8.54505152e-02f, -2.93364245e-02f, 3.93110923e-02f, 9.79967043e-03f, 2.51776166e-03f,
  -4.18838859e-02f, 1.85583823e-03f, -1.13255084e-02f, -7.67044276e-02f, 8.43636412e-03f, -8.09515342e-02f, 1.78820714e-02f, -7.34879673e-02f, 1.70514621e-02f, -2.37550102e-02f,
  3.60886194e-02f, -2.09302604e-01f, -1.13346010e-01f, -1.54211167e-02f, 4.43413816e-02f, 8.26611072e-02f, 7.67874569e-02f, -1.10067904e-01f, -1.74270302e-01f, -7.65718073e-02f,
  8.85670036e-02f, 6.44514114e-02f, 2.52782591e-02f, -1.14128791e-01f, 1.27439439e-01f, 3.02058854e-03f, -1.18549921e-01f, 1.14734948e-03f, -9.98540670e-02f, -1.55473933e-01f,
  -1.06801666e-01f, -1.37446448e-01f, -6.19362853e-02f, -4.34527807e-02f, -1.03293017e-01f, 2.44140700e-02f, 1.48748875e-01f, 1.34593323e-01f, 9.62018892e-02f, 1.10222176e-01f,
  -8.63086581e-02f, -1.05263323e-01f, -3.69463721e-03f, 2.61197495e-03f, 3.49523947e-02f, -5.02343774e-02f, 7.67809823e-02f, 1.01300059e-02f, -3.32782045e-02f, -7.56146759e-02f,
  9.64071155e-02f, 7.71320611e-02f, -6.34682970e-03f, 4.32016402e-02f, -1.02060579e-01f, 3.33786197e-02f, -2.19872855e-02f, 2.61908807e-02f, -1.06730564e-02f, -5.13119437e-02f,
  8.27774929e-04f, -2.28014980e-02f, -1.06981499e-02f, 6.47561327e-02f, -6.35706410e-02f, -2.26111598e-02f, -7.34385177e-02f, -7.52743566e-03f, -5.13639487e-02f, -7.04957694e-02f,
  1.04630124e-02f, 2.90442631e-02f, -1.01667166e-01f, -8.62705782e-02f, 2.13829223e-02f, -2.61591040e-02f, -4.72446978e-02f, 5.65145575e-02f, -4.20410782e-02f, 4.58160453e-02f,
  -3.21566942e-03f, 2.68457495e-02f, -7.40066171e-02f, -8.04543868e-02f, 5.90302236e-02f, 2.97889467e-02f, 8.67083222e-02f, 5.87012200e-03f, 4.57984349e-03f, -7.52557144e-02f,
  -1.05776703e-02f, 7.18419498e-04f, -5.84970191e-02f, -3.54094692e-02f, -3.16396914e-02f, 8.37724507e-02f, -6.59520626e-02f, 3.93314511e-02f, -3.27947401e-02f, 8.59470367e-02f,
  -1.07260346e-01f, -1.32064581e-01f, -2.25038528e-02f, -2.67386194e-02f, 3.32595855e-02f, 3.35771367e-02f, 1.92128103e-02f, -9.86421034e-02f, -3.05622537e-03f, -5.23446426e-02f,
  1.39190145e-02f, -6.03134185e-02f, -8.00512061e-02f, 4.43341918e-02f, -3.35951708e-02f, -6.97300285e-02f, 1.03700750e-01f, -5.43798842e-02f, -8.22571516e-02f, -3.56943943e-02f,
  -5.90295121e-02f, -5.99247776e-02f, -5.13322651e-02f, -6.31652772e-02f, 3.71200331e-02f, 6.37550279e-02f, 5.53130321e-02f, 1.11243308e-01f, 7.17561841e-02f, -3.47817428e-02f,
  7.31393229e-03f, -5.37460074e-02f, 2.03295350e-01f, 1.21506222e-01f, 6.67057857e-02f, 6.59227744e-02f, 2.83991456e-01f, 8.61952305e-02f, 1.37688518e-01f, -1.84505984e-01f,
  -1.41460791e-01f, 4.16282080e-02f, 7.64088556e-02f, -1.30320236e-01f, 1.05751939e-01f, -9.15842876e-02f, 5.04913144e-02f, 7.66622946e-02f, 7.77793825e-02f, 5.69065586e-02f,
  8.59470442e-02f, -1.11895449e-01f, -9.43914503e-02f, -1.19452499e-01f, -7.20507056e-02f, 2.38440046e-03f, -1.78000331e-01f, -3.99904847e-02f, -1.42086744e-01f, 1.19018825e-02f,
  -2.35092975e-02f, -5.16358688e-02f, 1.96457393e-02f, 5.98541461e-02f, 9.87421423e-02f, -8.65368471e-02f, -3.39636579e-02f, 7.41159841e-02f, 6.42855018e-02f, 5.81080690e-02f,
  5.42259291e-02f, 4.07602414e-02f, -6.23525493e-02f, 6.14963248e-02f, 3.67255658e-02f, 5.28710112e-02f, 3.92456912e-02f, -8.80317539e-02f, 2.96445494e-03f, 6.55810907e-02f,
  1.10749841e-01f, 6.23464249e-02f, 1.85130984e-02f, 3.71354073e-02f, -9.83049162e-03f, -2.97969896e-02f, -6.84360713e-02f, 4.38664407e-02f, -3.20195332e-02f, 5.11379950e-02f,
  -9.26220119e-02f, -4.82783057e-02f, 6.80904388e-02f, 4.34435643e-02f, -3.85390706e-02f, 4.58144881e-02f, -5.66519536e-02f, -5.06837815e-02f, -1.15914866e-02f, -9.93718207e-02f,
  -3.34912278e-02f, -1.86792370e-02f, 4.77556884e-02f, 4.05813828e-02f, 2.32843012e-02f, -3.11733503e-02f, -2.29586475e-02f, -7.64906481e-02f, -2.65799630e-02f, -3.02672107e-02f,
  1.83352903e-02f, -4.91116568e-02f, -4.52336520e-02f, 8.36116001e-02f, -2.53070258e-02f, -3.42422724e-02f, 7.11754058e-03f, 5.79274893e-02f, 2.97117382e-02f, -5.95802628e-02f,
  2.03591026e-02f, -1.47700146e-01f, -1.20017538e-02f, -8.19171518e-02f, 1.73395756e-03f, -8.51459354e-02f, -5.82143627e-02f, 5.41188270e-02f, -1.29138296e-02f, -1.66986808e-02f,
  -1.83029138e-02f, 6.34882972e-02f, 1.53183769e-02f, -4.66056988e-02f, -7.01825246e-02f, 1.92113454e-03f, 4.12273258e-02f, 4.08129767e-03f, -6.99680373e-02f, 2.52904836e-02f,
  -2.37992369e-02f, 1.07523743e-02f, -5.73423225e-03f, -6.89637735e-02f, -1.24365568e-01f, 4.36841026e-02f, -2.49118507e-02f, 4.20186818e-02f, -8.54703560e-02f, -8.54780078e-02f,
  1.59098953e-03f, 8.65372941e-02f, -9.89227220e-02f, 9.14568827e-02f, 8.91964883e-02f, 2.31047213e-01f, 1.49295107e-01f, 1.38336152e-01f, 3.33403736e-01f, 1.34953037e-01f,
  1.44649282e-01f, -1.92982271e-01f, 3.55625078e-02f, 2.19647706e-01f, 5.17020114e-02f, 1.32626370e-01f, 3.53236049e-01f, 7.75338486e-02f, 6.12117462e-02f, 5.43357506e-02f,
  5.62751340e-03f, -6.16612984e-03f, -3.58261652e-02f, -9.84140262e-02f, -4.83080931e-02f, -1.38300762e-01f, -1.82905510e-01f, -1.71473384e-01f, -1.38234600e-01f, -1.46041829e-02f,
  6.08049668e-02f, 8.14361796e-02f, -2.23276075e-02f, -3.27027738e-02f, -2.65120659e-02f, -5.21942936e-02f, -5.00647984e-02f, -1.67278007e-01f, -2.55932231e-02f, -3.06124818e-02f,
  -7.98410103e-02f, 9.18935332e-03f, -1.34665212e-02f, -4.61144634e-02f, 6.86809197e-02f, -3.27218883e-02f, -3.38269509e-02f, -4.11877315e-03f, 1.33474367e-02f, -1.28319457e-01f,
  4.28770967e-02f, -5.55208400e-02f, 8.56888946e-03f, -4.97187003e-02f, 7.81350508e-02f, -1.26004815e-02f, 3.84884216e-02f, -9.50075686e-02f, -1.97255285e-03f, 1.01110630e-01f,
  -1.11278184e-01f, 2.30344590e-02f, 1.10031635e-01f, -7.18167722e-02f, 8.80755298e-03f, 5.71911819e-02f, -2.69833431e-02f, -1.57366879e-02f, 3.67574096e-02f, -2.96683740e-02f,
  -3.95796336e-02f, 1.29949944e-02f, -1.34686241e-02f, -4.85566072e-02f, -4.17789966e-02f, -5.04856110e-02f, -7.05798641e-02f, -5.41039705e-02f, 3.49506661e-02f, 2.11720206e-02f,
  3.41024902e-03f, 3.88667211e-02f, 3.88710550e-03f, -1.93602983e-02f, -1.90600622e-02f, -1.82682406e-02f, -5.29449023e-02f, 5.74283302e-02f, -3.41509134e-02f, -6.73597455e-02f,
  1.83481842e-01f, -2.67444388e-03f, 6.73306733e-02f, -1.32555943e-02f, 8.75624828e-03f, 8.04346520e-03f, 3.23294774e-02f, 2.81454287e-02f, 1.63139962e-02f, -4.22941670e-02f,
  -5.82815818e-02f, -4.75874031e-03f, -5.27202636e-02f, -6.35395572e-02f, -6.64223507e-02f, 1.04561001e-01f, -4.38789800e-02f, -8.99517071e-03f, -3.07604242e-02f, -7.92422518e-02f,
  -3.85656804e-02f, 1.02804080e-01f, -7.49552203e-03f, 7.39832222e-02f, -4.46984880e-02f, 6.62213787e-02f, 3.19764987e-02f, -7.24820793e-02f, -7.88606033e-02f, 5.70516288e-02f,
  -2.05257386e-02f, 2.52910219e-02f, 1.66440040e-01f, 2.83487707e-01f, -6.51147962e-02f, 4.11609747e-02f, 3.32580470e-02f, 1.57040477e-01f, 3.50015372e-01f, 5.08699790e-02f,
  8.67053196e-02f, 4.93819490e-02f, -4.26809900e-02f, 1.29151702e-01f, 3.62758823e-02f, 1.82123169e-01f, 2.48479202e-01f, 9.79686528e-02f, 7.53543526e-02f, 1.26626775e-01f,
  1.59193799e-01f, 1.14236422e-01f, 8.95429328e-02f, -2.81173643e-02f, -8.00030231e-02f, 5.91469370e-02f, -8.10217783e-02f, -1.23777844e-01f, -9.89000499e-02f, -1.60349071e-01f,
  6.27278686e-02f, 6.25803322e-02f, -4.57898676e-02f, -1.30529583e-01f, -3.77535000e-02f, -2.41262969e-02f, -8.68548900e-02f, -9.78970379e-02f, 4.55074981e-02f, 6.94070831e-02f,
  -5.12172543e-02f, -7.65491948e-02f, -4.52480279e-02f, 1.87186321e-04f, -7.94395804e-02f, -2.01549325e-02f, 7.88261741e-02f, -9.00958607e-04f, -7.36571997e-02f, 4.39954028e-02f,
  2.14475263e-02f, 6.33951975e-03f, -6.52767019e-03f, 7.70052448e-02f, -4.14368957e-02f, -1.70304328e-02f, -3.82745937e-02f, -3.96924466e-02f, -1.78862959e-02f, 1.90419778e-02f,
  1.40418541e-02f, 7.73368329e-02f, -6.22052439e-02f, -7.57459998e-02f, -8.25399309e-02f, 7.50835007e-03f, 2.31830254e-02f, -2.32494660e-02f, 2.48836987e-02f, 5.99139445e-02f,
  3.05791367e-02f, -1.63472686e-02f, -5.26739284e-02f, 1.43948067e-02f, 9.56055429e-03f, -1.60750989e-02f, -1.12157620e-01f, -2.98284534e-02f, 4.86526713e-02f, 5.81622757e-02f,
  3.99160683e-02f, 2.72466224e-02f, 3.99862826e-02f, -2.03852840e-02f, 3.52821033e-03f, 2.58418471e-02f, 3.50550115e-02f, 7.11012706e-02f, 2.77428236e-02f, 4.84783053e-02f,
  6.26476929e-02f, 2.60573119e-01f, -5.41788377e-02f, -7.58716911e-02f, 3.22695705e-03f, -3.09048425e-02f, 3.97417769e-02f, -6.63508251e-02f, 1.09777354e-01f, -2.37178374e-02f,
  -8.61282833e-03f, 7.11442381e-02f, 2.15737876e-02f, 3.59622762e-02f, 2.01920178e-02f, -9.37331375e-03f, 1.06295176e-01f, 1.15861259e-02f, 6.91474751e-02f, -1.15823289e-02f,
  -3.82945947e-02f, -5.56279421e-02f, -5.90385264e-03f, -1.11497231e-01f, -9.83618386e-03f, 5.32641150e-02f, 1.02835502e-02f, 5.28182611e-02f, -5.03281206e-02f, 1.01694934e-01f,
  -2.60990530e-01f, 2.11461574e-01f, -1.46342099e-01f, -2.68589169e-01f, 5.87066449e-02f, -1.19714767e-01f, -2.45450288e-01f, 1.01689786e-01f, 7.87486359e-02f, 1.24980122e-01f,
  1.32593419e-02f, -6.19354174e-02f, 2.40312010e-01f, -1.67662203e-01f, -1.25335023e-01f, 1.17261894e-01f, -3.24469835e-01f, -1.88807741e-01f, 5.52772358e-02f, -2.08371386e-01f,
  -2.13254914e-01f, -7.19255060e-02f, -8.36816207e-02f, 1.46902815e-01f, -1.05922565e-01f, -1.49867490e-01f, -1.46269485e-01f, 1.67498797e-01f, -1.56653509e-01f, 5.31653650e-02f,
  4.40273024e-02f, 1.97913378e-01f, -4.48825024e-03f, 3.56199889e-04f, -1.32683948e-01f, -1.52295515e-01f, -9.10001323e-02f, -2.68001072e-02f, -5.64462095e-02f, 4.12349217e-02f,
  -9.04111788e-02f, 8.46085325e-02f, -1.00827016e-01f, 1.51410669e-01f, 5.84034845e-02f, -3.72801675e-03f, 6.32793978e-02f, -1.00059956e-01f, -5.07685095e-02f, 7.12485388e-02f,
  6.61771861e-04f, -5.62684238e-02f, -1.32647261e-01f, -4.10933373e-03f, -9.08090398e-02f, -7.52985105e-02f, -8.78830627e-02f, 2.07831208e-02f, -1.07734501e-01f, -4.91115525e-02f,
  3.64965312e-02f, -1.18331984e-01f, -1.66022517e-02f, -5.16448356e-02f, -5.00428528e-02f, 2.76474226e-02f, -4.83371243e-02f, -2.02625562e-02f, -8.62998515e-03f, -9.29311961e-02f,
  -3.07165086e-02f, -5.12285531e-02f, -1.65660605e-02f, -4.13598977e-02f, -1.57439411e-02f, -1.06292702e-02f, 1.24166971e-02f, -2.59294156e-02f, -9.81935188e-02f, -2.11148188e-02f,
  4.30479385e-02f, 3.30775417e-03f, 8.95282850e-02f, -7.75007382e-02f, 9.35732329e-04f, -7.21582258e-03f, 8.17038678e-03f, 3.13731357e-02f, 3.95112038e-02f, 1.02320053e-02f,
  -1.43904239e-01f, 5.33531979e-02f, 5.56830838e-02f, 1.40857264e-01f, 3.86919826e-02f, -6.04050122e-02f, -1.24361413e-02f, -9.78043377e-02f, 1.12825865e-03f, -3.10161114e-02f,
  -4.28420044e-02f, -1.53929843e-02f, -9.03310850e-02f, 1.28797293e-02f, -9.62788314e-02f, -7.98599571e-02f, -9.62728262e-02f, -9.61776823e-03f, -7.06561953e-02f, -7.91071728e-02f,
  4.16146545e-03f, -5.07985577e-02f, -5.47534861e-02f, -8.95125568e-02f, -4.96470630e-02f, -5.53193362e-03f, -3.85599732e-02f, 2.82540489e-02f, -7.88383186e-02f, 7.24595785e-02f,
  2.37810180e-01f, 1.14404589e-01f, -3.67494635e-02f, 2.87977830e-02f, -2.57050216e-01f, -3.80417019e-01f, -2.21711338e-01f, -1.18415831e-02f, 3.93824577e-02f, -7.89075419e-02f,
  -1.08387955e-01f, 3.59905511e-02f, 3.77131961e-02f, -7.98385367e-02f, 1.82588011e-01f, 8.10911804e-02f, 5.32152411e-03f, -1.15851350e-01f, 5.16889989e-02f, 4.68619913e-02f,
  1.48374066e-01f, -8.65285322e-02f, 6.33832812e-02f, -2.19543427e-02f, -6.75558224e-02f, 1.55870855e-01f, 1.63851589e-01f, -1.05651446e-01f, -1.10096015e-01f, -2.26814076e-02f,
  1.05115483e-02f, 1.54558688e-01f, -6.25694841e-02f, -5.47872223e-02f, 8.27450231e-02f, -2.77704187e-02f, 1.55884109e-03f, -6.97028590e-03f, 4.16812822e-02f, -4.30410504e-02f,
  6.19640909e-02f, 3.88868228e-02f, 2.10102070e-02f, 3.89554091e-02f, 1.04263015e-02f, -2.82424707e-02f, -5.45204245e-02f, 2.86329584e-03f, 4.92939092e-02f, -3.13783064e-02f,
  1.24199480e-01f, -2.90784277e-02f, 5.89115061e-02f, -4.38510105e-02f, 7.05649033e-02f, -3.51624228e-02f, 1.95302106e-02f, -2.89451368e-02f, 2.44801976e-02f, 1.05795622e-01f,
  8.93165022e-02f, -6.31575510e-02f, -3.09481006e-02f, -1.96855832e-02f, -1.10159162e-02f, -3.59961763e-02f, 6.67341277e-02f, -1.77789312e-02f, 4.74176146e-02f, -1.72726158e-02f,
  -5.08873127e-02f, -3.34016196e-02f, 5.99675924e-02f, 2.86243632e-02f, -3.78554761e-02f, -2.72776727e-02f, -1.62191000e-02f, -1.74446646e-02f, -1.03299953e-01f, 1.50668491e-02f,
  2.99221352e-02f, -4.36616801e-02f, 3.40562314e-02f, 2.21367460e-02f, -8.42562877e-03f, 5.87978661e-02f, -7.50659034e-02f, -2.61771809e-02f, -4.56612743e-02f, -6.03139699e-02f,
  -7.76070580e-02f, 9.40711275e-02f, 9.36757494e-03f, -7.67818913e-02f, -9.53692421e-02f, 4.75934967e-02f, -6.12198561e-02f, -5.39888553e-02f, 7.39802644e-02f, 3.54864001e-02f,
  -1.39720384e-02f, -8.03406313e-02f, 2.69353408e-02f, -4.64882851e-02f, -2.88363229e-02f, -6.94793090e-02f, 1.50924381e-02f, 5.64858280e-02f, 8.35272763e-03f, 8.59078690e-02f,
  -3.24449576e-02f, -2.98390221e-02f, -1.77430380e-02f, -1.70497186e-02f, -6.85566617e-03f, 1.38113117e-02f, -6.51030168e-02f, 6.73277229e-02f, 3.56862955e-02f, -2.05077175e-02f,
  4.00566399e-01f, -5.65576375e-01f, 7.35464618e-02f, 5.95394552e-01f, 2.78946668e-01f, -2.03306344e-03f, 2.61329591e-01f, 1.12519979e-01f, 4.10550505e-01f, -4.62296605e-01f,
  -3.13885286e-02f, -1.10865593e-01f, -3.36466640e-01f, 6.32391199e-02f, 3.01290691e-01f, -2.26278991e-01f, 1.86003223e-01f, -4.27606925e-02f, 1.80773288e-01f, 1.14426032e-01f,
  2.17264295e-01f, 1.30847711e-02f, -9.72388964e-03f, -1.24670900e-01f, 1.12274937e-01f, 3.30946036e-02f, -2.01636348e-02f, -8.84613246e-02f, -4.99602221e-02f, -6.66454509e-02f,
  1.00520112e-01f, 1.13113850e-01f, 7.27729723e-02f, -6.89046606e-02f, 4.16874141e-02f, -2.02462114e-02f, -9.78569612e-02f, 8.90446920e-03f, 4.93905880e-02f, 4.48985100e-02f,
  -1.84097327e-02f, 5.63237742e-02f, 1.02040805e-02f, -2.34383326e-02f, 8.44795704e-02f, 8.84929076e-02f, -1.92311443e-02f, 5.10332920e-02f, -2.51066573e-02f, -8.05954486e-02f,
  -2.84259357e-02f, 8.05262011e-03f, 6.45193681e-02f, -1.14438787e-01f, -4.49624322e-02f, 4.08090688e-02f, 1.58601708e-03f, -1.26411527e-01f, 1.64032876e-02f, 3.33016254e-02f,
  -9.86080244e-02f, 5.00608049e-03f, -2.74834763e-02f, 8.76601413e-02f, 5.30604124e-02f, 7.94178247e-02f, -5.08933403e-02f, -1.63794160e-02f, 1.79136638e-02f, -8.27187486e-03f,
  2.84631625e-02f, 7.87571296e-02f, 3.65743227e-02f, -2.36650580e-03f, 3.81529666e-02f, 1.01096537e-02f, 3.06498762e-02f, -9.39735305e-03f, 4.83575352e-02f, 6.05835319e-02f,
  -5.54521829e-02f, 1.04816798e-02f, -5.34965948e-04f, -4.02973816e-02f, 4.07203026e-02f, -4.84232977e-02f, -3.28529328e-02f, -1.63136330e-02f, -1.02539966e-02f, -1.40415849e-02f,
  -1.78058103e-01f, -2.54566401e-01f, -2.72818115e-02f, -5.22261634e-02f, -1.30624190e-01f, -3.33513543e-02f, -2.86101773e-02f, -3.40559743e-02f, 2.27329340e-02f, -2.19161995e-02f,
  -6.55954853e-02f, -9.59760509e-03f, 4.01039189e-03f, -1.34262666e-02f, 1.76037417e-03f, -6.75643608e-02f, -2.31029801e-02f, -5.87021466e-03f, 5.90389594e-02f, -8.10760260e-02f,
  -3.99144413e-03f, -6.99432194e-02f, -5.61611261e-04f, 2.15813331e-02f, -3.20747979e-02f, -1.21912276e-02f, -6.30164742e-02f, -7.51799159e-03f, -7.19979927e-02f, -9.90999937e-02f,
  -5.66514470e-02f, 4.55572829e-03f, 2.79744208e-01f, -2.24187467e-02f, 1.76187195e-02f, 8.44853669e-02f, 1.83536872e-01f, 1.23977549e-01f, -1.59794744e-02f, -1.46421224e-01f,
  -1.44264670e-02f, 1.49150398e-02f, 1.09939195e-01f, 4.10822257e-02f, -3.07022873e-03f, -7.53077194e-02f, -6.62005544e-02f, -6.49849549e-02f, 7.69274170e-03f, -4.83746491e-02f,
  7.46139511e-02f, -6.10935912e-02f, 8.87247473e-02f, 2.10949052e-02f, -2.07777601e-02f, -6.63472265e-02f, -1.14503965e-01f, -4.45066579e-03f, -6.47229701e-02f, -4.50961664e-03f,
  2.77987178e-02f, -8.27725008e-02f, -7.90293366e-02f, -4.61288206e-02f, -5.01683056e-02f, 6.90296991e-03f, -2.47465130e-02f, 3.94730084e-02f, -8.27553496e-02f, -5.87669648e-02f,
  1.00253485e-02f, -4.62482125e-03f, -4.34798375e-03f, 5.42587675e-02f, -4.21112143e-02f, -3.86055373e-03f, -3.50520201e-02f, 1.26482219e-01f, 1.15475729e-01f, 1.59653425e-01f,
  1.29736185e-01f, 4.93984856e-02f, -7.83467758e-03f, 7.82054067e-02f, -2.71869991e-02f, 6.35849535e-02f, 4.30351160e-02f, 3.06567028e-02f, 4.11831737e-02f, 7.91668072e-02f,
  3.31328548e-02f, 6.21046349e-02f, 5.43950349e-02f, 1.64647400e-02f, 3.48520204e-02f, 1.07000075e-01f, -2.01285556e-02f, 6.51564747e-02f, 3.32171470e-02f, -1.68392751e-02f,
  -1.14188055e-02f, 9.77605116e-03f, 2.40866169e-02f, 8.30189735e-02f, -6.12972006e-02f, -1.61957312e-02f, 8.97196122e-03f, -7.50272572e-02f, 6.78027049e-02f, -3.07451896e-02f,
  -4.44037095e-02f, -6.12057149e-02f, -6.54264092e-02f, -1.08294804e-02f, -2.91319657e-02f, -6.93814009e-02f, -5.26793487e-03f, -2.11698376e-02f, 6.80535939e-03f, 2.76253503e-02f,
  -8.81561264e-02f, -4.91242073e-02f, -7.69335106e-02f, -6.76179910e-03f, -4.01481614e-02f, -6.11520782e-02f, -1.01113729e-01f, -7.59671442e-03f, 4.63870913e-02f, -6.08928502e-02f,
  -2.65531018e-02f, -5.02481125e-02f, -7.44542554e-02f, -3.63745005e-03f, 5.83719276e-02f, 2.72581857e-02f, -5.94799556e-02f, -3.88818271e-02f, 3.00616119e-02f, -7.76396841e-02f,
  -1.15425773e-02f, -9.33551788e-02f, -4.97458726e-02f, 8.30627698e-03f, 4.49543558e-02f, -6.57127798e-02f, -2.91382968e-02f, 6.93872124e-02f, 6.87864125e-02f, -6.00761808e-02f,
  -1.68038368e-01f, 2.88543165e-01f, 1.36978075e-01f, -1.97024375e-01f, -1.50257749e-02f, 5.78640997e-02f, -1.65794343e-01f, 4.78305817e-02f, 1.99459977e-02f, 1.32667916e-02f,
  -1.61546007e-01f, -1.27023952e-02f, 1.41649753e-01f, -7.81030878e-02f, 6.12810813e-02f, 1.64035410e-02f, -1.42885089e-01f, -7.68208206e-02f, 8.66177231e-02f, -1.18693694e-01f,
  -2.20461283e-02f, -3.43948454e-01f, -4.99044172e-02f, -1.64263144e-01f, -3.08721125e-01f, -1.86977256e-02f, -1.63445920e-01f, -3.96044999e-02f, -2.09976703e-01f, 3.94519866e-02f,
  -1.16144486e-01f, -2.19360560e-01f, -8.68959278e-02f, -5.36546633e-02f, -2.33705193e-02f, -2.11188253e-02f, -6.58657402e-02f, -5.63541576e-02f, -1.09553654e-02f, 7.40622729e-02f,
  -2.04245821e-02f, 2.82666162e-02f, 4.56316471e-02f, -5.27005047e-02f, 4.62624356e-02f, 6.04327992e-02f, 4.97951685e-03f, 7.50027299e-02f, 2.84974724e-02f, 1.23481296e-01f,
  7.16143996e-02f, 3.85639705e-02f, -6.57421499e-02f, -5.56183867e-02f, -2.16309112e-02f, -3.46592925e-02f, 2.09648013e-02f, -4.84757908e-02f, 2.72118933e-02f, 9.91409868e-02f,
  -1.02129079e-01f, 2.76121255e-02f, 2.34947279e-02f, 5.84360324e-02f, 1.88446473e-02f, -6.06543086e-02f, 5.87881729e-02f, -2.27844268e-02f, -6.53246641e-02f, 5.56384288e-02f,
  1.25621883e-02f, 4.52557355e-02f, -7.22306147e-02f, 8.65049586e-02f, -2.17177048e-02f, -9.17299762e-02f, 4.64375950e-02f, -6.69242963e-02f, 7.67191648e-02f, 2.40470003e-02f,
  -3.68913636e-02f, -4.18882705e-02f, -2.49100327e-02f, 4.54066433e-02f, -9.58787464e-03f, 7.13078678e-02f, 6.99677393e-02f, 8.81525278e-02f, 3.03909974e-03f, 8.41282587e-03f,
  -7.91082531e-02f, -1.54529467e-01f, -3.55007462e-02f, 1.72984395e-02f, 1.60935707e-02f, -6.06838726e-02f, 4.49014828e-03f, 4.33947444e-02f, 3.46132256e-02f, 4.58733737e-02f,
  -5.86360469e-02f, -9.69283134e-02f, -4.90523782e-03f, -4.23133001e-02f, 7.31807426e-02f, -5.64623848e-02f, -5.42262122e-02f, -8.12221318e-02f, 2.52920855e-03f, -1.70224495e-02f,
  2.18743328e-02f, -2.12896578e-02f, 9.26211253e-02f, 3.70269567e-02f, -6.28547519e-02f, -1.06049649e-01f, 2.18929294e-02f, 4.14543897e-02f, -6.43112585e-02f, -3.44077758e-02f,
  1.52610466e-01f, -4.85343225e-02f, 2.82969445e-01f, -5.74625954e-02f, -5.66075705e-02f, 2.98790820e-02f, 9.69872251e-02f, -2.32340768e-01f, -3.45716417e-01f, -3.03194344e-01f,
  -4.97060940e-02f, 9.29821469e-03f, 1.75613582e-01f, -5.46775088e-02f, 1.49817035e-01f, 1.68744296e-01f, -1.89482838e-01f, 2.92502269e-02f, 1.92588996e-02f, -1.05339341e-01f,
  4.62705037e-03f, -9.43150148e-02f, 2.34701037e-01f, -1.05917953e-01f, 3.68458889e-02f, -1.00201242e-01f, -4.29437384e-02f, 1.79437369e-01f, -1.83531925e-01f, 9.82474312e-02f,
  -8.80310033e-03f, -9.87219140e-02f, 5.50701879e-02f, -5.44831865e-02f, -4.48111966e-02f, 7.70892054e-02f, 1.32447230e-02f, 1.41338244e-01f, -7.38103082e-03f, -5.16030891e-03f,
  4.15225253e-02f, 3.81615832e-02f, -1.21519186e-01f, 6.20051436e-02f, -1.22098774e-01f, -1.12374713e-04f, 8.80093426e-02f, -4.55528311e-02f, -1.20681040e-02f, 6.51990669e-03f,
  -3.69261689e-02f, -4.99949493e-02f, -2.11757571e-02f, 1.07071940e-02f, 3.25705484e-03f, -9.98439789e-02f, -9.36768134e-04f, 7.18404502e-02f, -4.16303687e-02f, -9.31210667e-02f,
  1.68935601e-02f, 5.90117835e-02f, 6.66618645e-02f, 5.56529276e-02f, 2.08889395e-02f, -1.43259708e-02f, 5.25269471e-02f, 6.76586181e-02f, -2.16606893e-02f, 3.74160446e-02f,
  -1.00721642e-01f, 1.73382275e-02f, 3.01684253e-02f, -1.12216234e-01f, -2.36434489e-02f, -3.39428484e-02f, 1.20056681e-01f, -3.89560200e-02f, 1.14555396e-02f, -2.64867563e-02f,
  2.19711922e-02f, 2.54957266e-02f, 8.29453394e-02f, -4.06718953e-03f, 2.77239680e-02f, 8.08878914e-02f, -4.19529527e-02f, -5.81187429e-03f, 1.46082025e-02f, 2.51746248e-03f,
  -2.48304592e-03f, -1.85592219e-01f, 3.76527607e-02f, -7.13886619e-02f, 4.95108441e-02f, -3.33227143e-02f, 4.26650681e-02f, -9.78851616e-02f, -1.66564551e-03f, -5.43312468e-02f,
  -8.94416571e-02f, -1.07667588e-01f, -7.62747079e-02f, 3.37485597e-02f, 3.74331549e-02f, -3.18141691e-02f, -4.21281308e-02f, -3.60467844e-02f, -4.62926552e-02f, -6.97188601e-02f,
  5.01645841e-02f, 3.15806754e-02f, 9.10110474e-02f, -4.65510599e-02f, -5.38605116e-02f, -4.27771406e-03f, 4.37864289e-02f, 2.47437656e-02f, -8.49299654e-02f, 2.38685822e-03f,
  -1.44531533e-01f, 2.12526351e-01f, 7.72584677e-02f, -4.51296791e-02f, 4.01569344e-02f, -1.03226006e-01f, -1.02372281e-02f, 6.66274130e-02f, 2.45193741e-03f, 1.99983492e-01f,
  2.38092113e-02f, 1.12256244e-01f, 1.37956273e-02f, -1.08645372e-02f, -3.52669686e-01f, -1.67659104e-01f, 1.42677985e-02f, 3.33622396e-02f, -5.20176589e-02f, 5.36158122e-02f,
  -1.62674025e-01f, -1.50728270e-01f, 9.43114534e-02f, 6.44434616e-02f, 1.56257555e-01f, 3.74478102e-02f, -1.19090468e-01f, 6.19487911e-02f, 6.13740124e-02f, -1.08910546e-01f,
  -9.08175483e-02f, -2.32717786e-02f, 1.04840480e-01f, -2.86102071e-02f, -3.29929888e-02f, 7.60838687e-02f, 7.47217387e-02f, -7.57963657e-02f, 5.07820360e-02f, 3.05226073e-02f,
  4.31869552e-02f, -5.98868392e-02f, -8.61366317e-02f, 2.69753467e-02f, 4.66079377e-02f, 6.57749772e-02f, 1.29337147e-01f, 6.26002923e-02f, -3.15073133e-02f, 5.06375637e-03f,
  2.89068688e-02f, 1.02971466e-02f, 8.74710530e-02f, 8.56822059e-02f, -8.21687058e-02f, 6.57783896e-02f, -6.13152906e-02f, 6.61673620e-02f, -2.65466683e-02f, 4.82805111e-02f,
  -9.35544893e-02f, 3.81570719e-02f, -2.79270355e-02f, 1.33223517e-03f, 5.10805994e-02f, -5.43030277e-02f, 3.33150886e-02f, -2.42893025e-02f, 7.51358271e-02f, -6.46354854e-02f,
  -9.28354934e-02f, 2.16151690e-04f, -7.95241669e-02f, -7.69852176e-02f, -2.91779190e-02f, -4.72480990e-02f, 4.58152592e-02f, -4.78302985e-02f, -7.11882934e-02f, 1.29142646e-02f,
  1.91880539e-02f, -9.30475444e-02f, 5.66034652e-02f, 5.70101254e-02f, -1.78960469e-02f, 7.12700859e-02f, 3.79494876e-02f, -4.07992974e-02f, -1.56318657e-02f, -7.47121125e-02f,
  -1.21614188e-01f, -1.03297040e-01f, -1.18237250e-02f, 4.38946486e-02f, 8.21100995e-02f, -8.05584192e-02f, -6.91892132e-02f, 7.44301900e-02f, -1.12848558e-01f, -7.20059350e-02f,
  -3.14195617e-03f, 9.30863619e-02f, 7.37841846e-03f, -8.52529183e-02f, 3.57635841e-02f, 8.41428433e-03f, -4.68588434e-02f, 5.87332249e-02f, 3.40086105e-03f, 8.87246132e-02f,
  6.26129210e-02f, -3.64535265e-02f, -3.24050598e-02f, 8.12643096e-02f, -7.35388845e-02f, 5.83874248e-03f, -2.75892690e-02f, -5.02568148e-02f, 2.94681010e-03f, -3.63429412e-02f,
  2.51948714e-01f, 4.23268169e-01f, 1.25365064e-01f, 1.60464019e-01f, -1.45352632e-01f, 1.00382157e-02f, 6.50273263e-03f, -3.43470611e-02f, 6.11624531e-02f, 2.22974017e-01f,
  -1.87075853e-01f, 3.38628978e-01f, -4.69589159e-02f, 8.84652659e-02f, -2.30469152e-01f, -1.44929036e-01f, 5.57661243e-02f, 1.86155990e-01f, 4.42837588e-02f, 9.28174406e-02f,
  -1.56505972e-01f, -2.41733730e-01f, -6.85776696e-02f, -3.01856454e-02f, 1.85400292e-01f, 1.37205124e-01f, -1.89626604e-01f, -1.58895314e-01f, 2.69001983e-02f, -9.82914791e-02f,
  2.73906607e-02f, 6.20204508e-02f, 9.09152851e-02f, 4.69673909e-02f, -2.25185025e-02f, -2.10067835e-02f, -1.20807290e-02f, -9.29269120e-02f, -3.72978207e-03f, -2.88219489e-02f,
  1.08122297e-01f, 7.29999924e-03f, -5.16912760e-03f, -1.08832084e-01f, 1.18436687e-01f, 3.75722498e-02f, 5.09251878e-02f, 1.45914033e-01f, 1.58264652e-01f, 5.11293635e-02f,
  8.88428986e-02f, 1.30640462e-01f, 6.41114488e-02f, 7.36426264e-02f, -1.01852287e-02f, 8.85661095e-02f, 1.18157409e-01f, -2.04727240e-02f, 1.67494059e-01f, 2.09351517e-02f,
  4.05785888e-02f, 2.99981982e-02f, 3.39373276e-02f, -1.46180270e-02f, -1.95115171e-02f, -2.14080252e-02f, -9.32274386e-03f, -2.59084329e-02f, -6.03864193e-02f, -8.24289843e-02f,
  3.07075884e-02f, 6.92340173e-03f, 3.76890437e-03f, 5.07447124e-03f, 1.42966956e-02f, 4.60863858e-02f, 4.26342376e-02f, 9.48940739e-02f, 1.37021560e-02f, -5.78065664e-02f,
  -8.29952657e-02f, -7.36590102e-02f, 3.80856209e-02f, -6.31799102e-02f, 2.00266577e-02f, -5.83637469e-02f, -3.18621881e-02f, 7.79514983e-02f, -5.24941795e-02f, -1.32334858e-01f,
  7.31696337e-02f, 1.10297333e-02f, -1.15598571e-02f, 9.10563618e-02f, 6.59856424e-02f, 1.05749695e-02f, 2.05329303e-02f, 8.59350637e-02f, -7.21480325e-02f, -7.41606764e-03f,
  4.14233319e-02f, -2.69946922e-02f, 7.42572993e-02f, -5.43812513e-02f, -7.48905018e-02f, -4.23060246e-02f, -7.43688941e-02f, -4.56317253e-02f, -1.57704428e-02f, -2.58658603e-02f,
  9.40113235e-03f, 6.43817848e-03f, -7.90456310e-03f, -8.34120139e-02f, 5.50425686e-02f, -5.28779300e-03f, 1.32151823e-02f, 4.40806933e-02f, -7.51373405e-03f, -5.22053167e-02f,
  1.60388678e-01f, -1.53402939e-01f, -1.54974498e-02f, 9.52024683e-02f, 1.21642046e-01f, -1.61968604e-01f, -1.86317027e-01f, 7.68701499e-03f, 2.36532718e-01f, -1.84168294e-01f,
  -2.06004400e-02f, -1.75311863e-01f, -7.91992173e-02f, -1.20062381e-01f, 1.20437160e-01f, -6.02230951e-02f, -1.14157192e-01f, -1.72252785e-02f, 4.14138697e-02f, -1.59381211e-01f,
  8.51393491e-02f, -1.22613981e-01f, -5.83520792e-02f, -9.88026038e-02f, -1.11738972e-01f, 1.06230594e-01f, -5.32327890e-02f, -9.53642353e-02f, -1.57566562e-01f, -8.13714340e-02f,
  2.17829347e-02f, 6.27317727e-02f, -3.18955183e-02f, -7.03236759e-02f, 7.07858875e-02f, -8.02943632e-02f, -1.41728133e-01f, -9.71711054e-02f, 6.14561960e-02f, 9.77490842e-02f,
  2.09237728e-02f, 3.27359000e-03f, -3.41120735e-02f, 4.33422551e-02f, 8.81051049e-02f, -9.55796707e-03f, 5.37702441e-02f, 1.02911964e-01f, -5.16073406e-02f, 5.05116098e-02f,
  -5.82097769e-02f, 3.04816179e-02f, -4.59723733e-02f, -1.58116836e-02f, 2.04542596e-02f, -2.83521675e-02f, -8.71053040e-02f, -1.05676904e-01f, 2.12883260e-02f, 7.62250125e-02f,
  -6.05504997e-02f, 9.90500599e-02f, -3.36544365e-02f, -4.59698401e-03f, 4.34534363e-02f, -5.44496216e-02f, -5.04974881e-03f, 1.50732920e-02f, -8.60940106e-03f, 1.75391007e-02f,
  -7.08919857e-03f, -3.78076434e-02f, 1.38150277e-02f, -8.49936083e-02f, 4.29517068e-02f, -5.26528843e-02f, 6.59186393e-03f, -3.72487232e-02f, 8.11722502e-02f, 3.40861604e-02f,
  -8.15846920e-02f, -5.09856530e-02f, 2.35914569e-02f, -5.35444878e-02f, -1.65351778e-02f, -1.79631207e-02f, -4.12510410e-02f, -3.15335505e-02f, -5.33911446e-03f, 5.10980785e-02f,
  -5.44140227e-02f, -2.09318418e-02f, 9.99714732e-02f, 8.57985541e-02f, 3.78869809e-02f, -2.35261712e-02f, 5.29071596e-03f, -1.32706231e-02f, -1.44152334e-02f, -1.84813924e-02f,
  3.14058065e-02f, -2.73055322e-02f, 5.37221394e-02f, -8.03240761e-02f, 2.43905969e-02f, 2.40041856e-02f, 1.15635106e-02f, -1.38994884e-02f, -4.95665669e-02f, -5.38935773e-02f,
  -1.03618167e-01f, 4.23863269e-02f, -3.47944014e-02f, 1.00328699e-01f, -2.97272317e-02f, 1.03690615e-02f, 6.11171499e-02f, -3.45260510e-03f, -6.63491488e-02f, -7.17136264e-02f,
  -2.46666312e-01f, 1.95758596e-01f, 2.53520608e-01f, -7.51221552e-03f, 1.32465139e-01f, 2.16321364e-01f, 1.01242192e-01f, 2.97824353e-01f, 3.50887954e-01f, -8.51344690e-02f,
  -2.31529489e-01f, -3.46295908e-02f, -8.13062415e-02f, -6.86249584e-02f, 6.02817684e-02f, 1.59447715e-01f, 1.15821443e-01f, -4.04279642e-02f, 2.44704813e-01f, -1.13626182e-01f,
  -3.69028933e-02f, -2.26353884e-01f, -1.02049023e-01f, 1.00374753e-02f, -1.46398574e-01f, -9.90072265e-02f, -2.75640905e-01f, 1.16973892e-01f, -1.58213064e-01f, 9.42160115e-02f,
  -6.25974089e-02f, -2.10712589e-02f, -3.93639617e-02f, 4.77259457e-02f, -1.18064806e-02f, 3.12980935e-02f, -7.46701807e-02f, -3.08917593e-02f, 4.46720310e-02f, 1.48617141e-02f,
  3.78256501e-03f, -4.10893634e-02f, -4.38935868e-02f, -1.56657025e-02f, 4.38288599e-02f, 6.41682670e-02f, 3.23281661e-02f, -2.74851117e-02f, -4.03555892e-02f, 4.01744507e-02f,
  -6.65654615e-02f, -5.22276154e-03f, -6.00145385e-02f, -4.81802458e-03f, 2.66633891e-02f, 7.71676302e-02f, -3.27975042e-02f, 5.77444360e-02f, -1.11945290e-02f, 8.51209611e-02f,
  7.42171779e-02f, 4.81108092e-02f, 2.06886698e-02f, 3.39471288e-02f, 4.55950387e-02f, 1.15624233e-03f, -1.13575615e-01f, -3.11389267e-02f, 5.92233576e-02f, 1.30563574e-02f,
  -1.94825362e-02f, -2.38703340e-02f, 1.20493747e-01f, 3.60320508e-02f, -3.73372473e-02f, 7.93633051e-03f, -4.87398431e-02f, 4.49591167e-02f, -4.95224120e-03f, -5.32390028e-02f,
  4.46022749e-02f, -3.47502455e-02f, -1.05628176e-02f, -6.98920786e-02f, 5.51846661e-02f, -2.26030760e-02f, -4.16238680e-02f, 7.71375664e-04f, 3.00736241e-02f, -3.46284620e-02f,
  1.77828357e-01f, 1.95744276e-01f, -8.17711875e-02f, 1.89266130e-02f, 7.68274069e-02f, -8.94576162e-02f, 8.44842568e-02f, 1.94396731e-02f, 4.08700295e-03f, 1.34429093e-02f,
  3.74509059e-02f, -5.70445275e-03f, -7.58484975e-02f, 3.79315950e-02f, 3.87524068e-02f, 3.37764733e-02f, -9.44195837e-02f, 6.54740706e-02f, 4.94639091e-02f, -8.37226883e-02f,
  -1.09624632e-01f, 3.25843208e-02f, -7.95549750e-02f, -2.55224039e-03f, -8.27602670e-02f, -1.22060552e-02f, -1.34051479e-02f, -7.55140930e-02f, 1.53983280e-03f, -1.05786249e-02f,
  -2.07828090e-01f, -2.88223904e-02f, -1.00723110e-01f, -1.62159562e-01f, 3.54619250e-02f, -4.48100753e-02f, 1.96504556e-02f, -1.07140161e-01f, -1.28915250e-01f, 1.77575842e-01f,
  2.57699601e-02f, -1.27413124e-01f, 6.58969954e-02f, -2.17943303e-02f, -8.52348730e-02f, -2.01373510e-02f, -2.14490034e-02f, -6.68560266e-02f, -1.54715218e-02f, 2.07623634e-02f,
  -6.15586452e-02f, -6.45425469e-02f, -5.67482971e-02f, 4.45864201e-02f, -2.22201925e-02f, 1.06311403e-01f, 3.70322280e-02f, 2.57860348e-02f, -3.09633259e-02f, -4.49457355e-02f,
  -4.52043675e-02f, -9.47816670e-02f, 3.80758420e-02f, 7.04776570e-02f, 7.37404227e-02f, 1.66116767e-02f, 1.00039169e-01f, -9.15831998e-02f, -3.85739952e-02f, -2.68869251e-02f,
  5.88270649e-02f, 5.77807650e-02f, -1.05859734e-01f, 3.01578529e-02f, 4.22760621e-02f, -4.14733076e-03f, 9.91866142e-02f, 4.86943983e-02f, 5.94070293e-02f, -7.39752874e-02f,
  1.81153640e-02f, -3.96977551e-02f, -3.09538171e-02f, -2.04844750e-03f, -8.24521407e-02f, 9.05611068e-02f, 3.63167636e-02f, 2.50792950e-02f, 6.94980100e-02f, -7.51088038e-02f,
  -2.00807415e-02f, -3.88587639e-02f, 3.15910913e-02f, -7.58239850e-02f, -1.19373411e-01f, 5.93312047e-02f, 9.15621817e-02f, -2.00828444e-02f, 7.24110473e-03f, 4.20615710e-02f,
  1.00449093e-01f, -1.02537796e-01f, 1.63517501e-02f, -4.39931899e-02f, -4.21806797e-02f, 8.06498453e-02f, 3.65906619e-02f, -2.33239923e-02f, -8.62212703e-02f, -2.66932212e-02f,
  -3.70536409e-02f, 6.69604749e-04f, -4.95015644e-02f, -2.05023624e-02f, 2.55735107e-02f, -1.70641486e-02f, 8.76625180e-02f, -9.03425068e-02f, -1.80717744e-03f, -6.14948981e-02f,
  5.01195826e-02f, 7.17198923e-02f, -8.64194483e-02f, 7.49091730e-02f, -6.81197867e-02f, 9.52220112e-02f, -6.37405878e-03f, -6.41204864e-02f, -4.76518683e-02f, -9.43152457e-02f,
  1.25768900e-01f, 9.45229530e-02f, 1.77399870e-02f, 8.14511776e-02f, 5.33200577e-02f, -1.80268716e-02f, -1.42411925e-02f, 9.65566263e-02f, -1.93054955e-02f, 3.66040617e-02f,
  -6.03113174e-02f, 8.10339227e-02f, -6.66001663e-02f, -9.38592404e-02f, -7.85271917e-03f, -4.96407263e-02f, -5.30091859e-02f, 6.78466028e-03f, 6.06189258e-02f, -1.37504013e-02f,
  8.45851153e-02f, -6.03635386e-02f, 4.36936244e-02f, -6.05719909e-02f, -4.67991903e-02f, 6.91521838e-02f, -1.27323985e-01f, 3.00540384e-02f, -2.76495934e-01f, -2.88977176e-01f,
  7.98741952e-02f, -2.35217839e-01f, 4.12442908e-02f, 1.93032488e-01f, 2.87934840e-01f, 1.69745579e-01f, 2.45500416e-01f, 6.41017035e-02f, 1.36800662e-01f, 2.75815427e-01f,
  1.86067984e-01f, 3.16743791e-01f, 3.87954891e-01f, 2.95079142e-01f, 2.77590305e-01f, 5.50355576e-02f, 5.69757186e-02f, 1.54172331e-01f, 2.28680428e-02f, 3.22760642e-02f,
  -3.43595706e-02f, -7.95246288e-03f, 1.30586192e-01f, 5.26401550e-02f, 3.50563861e-02f, 7.78385773e-02f, 3.59930359e-02f, -1.82823781e-02f, -4.63741384e-02f, -2.17905156e-02f,
  -3.23016196e-02f, 3.92930992e-02f, -6.56867176e-02f, -7.06820609e-03f, -2.82208296e-03f, -2.92728264e-02f, 1.38895176e-02f, -1.26882391e-02f, 5.20850122e-02f, 1.26745567e-01f,
  3.73886782e-03f, 2.88679991e-02f, -7.87484553e-03f, -1.98415853e-02f, -4.17747162e-02f, -9.61307958e-02f, -7.62421042e-02f, -2.12844200e-02f, 7.97749124e-03f, -1.08007520e-01f,
  1.01100370e-01f, -2.91511565e-02f, 3.25226411e-02f, 5.33232205e-02f, 4.92236055e-02f, 4.23724465e-02f, -7.18124360e-02f, 4.92776446e-02f, -1.48809282e-02f, 2.95136943e-02f,
  -4.77543883e-02f, 7.52475709e-02f, -5.56305312e-02f, -5.98693490e-02f, 3.53025235e-02f, -1.64817534e-02f, 3.84620181e-03f, 9.94516462e-02f, -1.60143655e-02f, 1.96128953e-02f,
  -1.34416029e-01f, -1.86965335e-02f, -4.42658970e-03f, -1.83099844e-02f, -4.66628075e-02f, -5.71506731e-02f, 5.22448905e-02f, 7.24395812e-02f, 1.86463762e-02f, 3.34674306e-02f,
  7.26809949e-02f, 3.48166339e-02f, 2.18901709e-02f, -1.08602285e-01f, 9.79747102e-02f, 6.55765086e-02f, -2.54465640e-02f, 4.04501744e-02f, 2.08294373e-02f, 8.02658722e-02f,
  -5.97673170e-02f, -2.43347436e-02f, -7.68556148e-02f, 7.68907294e-02f, -5.88160492e-02f, 8.52042530e-03f, -6.70409203e-02f, -7.83502758e-02f, -6.23178110e-02f, 9.59693566e-02f,
  -7.37159997e-02f, -7.56036416e-02f, -2.54170038e-02f, -3.86268576e-03f, -6.09748475e-02f, -4.42740768e-02f, -2.43523214e-02f, -6.64968118e-02f, -1.30434390e-02f, -3.60428095e-02f,
  6.45200163e-02f, -2.36025214e-01f, -8.46391395e-02f, 1.58536986e-01f, 1.25078350e-01f, 7.84266088e-03f, -1.18871657e-02f, -1.04607582e-01f, -3.13798636e-01f, -1.06516048e-01f,
  9.80391875e-02f, -1.07384734e-02f, -1.82530314e-01f, 1.72496542e-01f, 2.58352458e-01f, -2.01016262e-01f, 6.36734143e-02f, 8.22820961e-02f, -1.54270783e-01f, 1.42504415e-02f,
  -2.33778283e-02f, 2.34127864e-01f, 8.68556798e-02f, 1.83994517e-01f, 9.80630741e-02f, 4.16446477e-02f, 3.26001734e-01f, 3.27117816e-02f, 4.19647217e-01f, 2.80265659e-01f,
  -5.72394952e-02f, 1.49490321e-02f, -6.83569387e-02f, -5.65012954e-02f, 4.10542749e-02f, 4.55926619e-02f, 1.02111124e-01f, 6.56935126e-02f, 4.11645509e-02f, -7.60413054e-03f,
  4.39156406e-03f, 1.08924523e-01f, 1.08836204e-01f, -3.57511044e-02f, -4.80581410e-02f, -8.15706607e-03f, -6.03502393e-02f, -2.92326417e-03f, -1.02899961e-01f, -2.71041524e-02f,
  -6.17858246e-02f, -8.42894148e-03f, 1.06203770e-02f, 6.82196692e-02f, -2.53513344e-02f, -4.92819026e-02f, 3.91366184e-02f, 4.48958129e-02f, -2.96691544e-02f, -1.98247507e-02f,
  7.94856623e-02f, -4.48063798e-02f, -1.58905089e-02f, 5.01836054e-02f, -3.06619983e-02f, 1.06357299e-02f, -4.41217646e-02f, 6.18224079e-03f, 1.51157919e-02f, 4.00910825e-02f,
  -1.60814784e-02f, 2.06362363e-02f, 4.02674899e-02f, -3.60322068e-03f, -1.44772977e-02f, -1.07007943e-01f, 4.47891280e-02f, 5.69931464e-03f, -2.38803886e-02f, 1.39842918e-02f,
  -8.25736821e-02f, -5.01085892e-02f, -6.53170943e-02f, 7.41920713e-03f, 4.53886129e-02f, 2.99692247e-02f, 1.39381271e-02f, 4.70486246e-02f, 5.11822328e-02f, 2.38810368e-02f,
  2.50218194e-02f, -4.76582795e-02f, 4.08673333e-03f, 8.44510868e-02f, -5.80002666e-02f, -2.02106722e-02f, -4.06187139e-02f, 1.97811611e-02f, 7.42145926e-02f, -8.04595947e-02f,
  1.18704565e-01f, 2.06330866e-02f, -7.14156926e-02f, 6.49149120e-02f, 7.31248707e-02f, 3.94274332e-02f, 6.78333789e-02f, 4.86841612e-02f, 2.82737892e-02f, 1.52158178e-02f,
  2.22829655e-02f, -5.85409217e-02f, 1.33655453e-02f, -1.83176633e-03f, 6.33368716e-02f, 2.09908304e-03f, -2.64689345e-02f, 4.70719784e-02f, 6.72866851e-02f, -7.05091134e-02f,
  -3.71731818e-02f, 1.99099123e-01f, 2.86635816e-01f, 3.17117453e-01f, -2.71610588e-01f, -1.16574228e-01f, -2.18453892e-02f, 1.18898693e-02f, 2.63142549e-02f, -3.07538621e-02f,
  -4.85897586e-02f, 1.21160530e-01f, 6.72217980e-02f, 7.60315219e-03f, 1.83196872e-01f, 2.36706920e-02f, 1.19874768e-01f, 2.17456929e-02f, 5.86186834e-02f, 2.09564179e-01f,
  4.37793583e-02f, 9.11465064e-02f, 6.33588955e-02f, -1.02531068e-01f, -8.62600654e-02f, 1.63503349e-01f, 1.67918503e-02f, -8.23582429e-03f, -3.48630897e-03f, -1.00044571e-01f,
  -1.09096378e-01f, 4.37435471e-02f, 9.71065983e-02f, -3.99278030e-02f, 5.44331446e-02f, -1.52138174e-01f, 8.22677910e-02f, 8.92555993e-03f, -3.85623276e-02f, 6.79881349e-02f,
  2.21532374e-03f, 2.66864132e-02f, 2.22584400e-02f, 6.49581254e-02f, 1.79211944e-02f, -3.41514312e-02f, -5.73359430e-02f, -5.99663146e-02f, -4.13306169e-02f, -1.15490392e-01f,
  1.08326569e-01f, -7.90477023e-02f, -1.27184754e-02f, 6.73068017e-02f, 3.55099253e-02f, 7.38547146e-02f, -3.10477037e-02f, 1.44341215e-01f, -5.11672273e-02f, 6.50357604e-02f,
  -5.15600257e-02f, 7.01319501e-02f, -4.55989428e-02f, -7.93031789e-03f, -2.73528490e-02f, -8.82615000e-02f, 1.55366911e-02f, 2.24322863e-02f, 4.14099284e-02f, 4.55649644e-02f,
  2.88646370e-02f, -3.02675217e-02f, -7.76303709e-02f, -3.44130434e-02f, 6.20729243e-03f, 4.02894281e-02f, -1.70039162e-02f, -3.21022570e-02f, 5.87639920e-02f, -1.94865884e-03f,
  2.23285351e-02f, -3.11606321e-02f, 5.98518252e-02f, -3.74821015e-02f, 1.94480270e-02f, -8.56837109e-02f, -2.45703980e-02f, -7.05889985e-02f, -4.98716943e-02f, 6.02194108e-02f,
  1.13188094e-02f, 3.77046466e-01f, 8.36822614e-02f, 4.19491604e-02f, 3.53587829e-02f, -4.52424511e-02f, -2.73303408e-02f, -4.88278531e-02f, 9.76518318e-02f, 6.85966387e-02f,
  6.20279536e-02f, -1.88207757e-02f, -4.85307246e-04f, -4.56962287e-02f, 8.41633901e-02f, 1.08243804e-02f, 7.90303573e-02f, 1.11864775e-01f, 4.68788110e-02f, 3.24322730e-02f,
  2.26684771e-02f, 7.55092353e-02f, 9.88833755e-02f, 5.46379462e-02f, 3.01968027e-02f, -5.12571521e-02f, 4.37349714e-02f, 7.29069337e-02f, 6.16329052e-02f, 1.55602628e-02f,
  7.39216730e-02f, -1.88068032e-01f, -1.15340352e-01f, 2.57725865e-01f, 6.91825598e-02f, -2.24379435e-01f, -2.97952175e-01f, 1.30581394e-01f, -1.48565859e-01f, -1.57931447e-01f,
  8.31357390e-02f, -4.61004972e-02f, -3.56823027e-01f, 2.09842935e-01f, 2.27620736e-01f, -1.77237168e-01f, 1.73551455e-01f, 6.17796108e-02f, 4.15501697e-03f, 5.08669466e-02f,
  1.75248623e-01f, 3.90151918e-01f, 1.21015646e-01f, 2.35677719e-01f, 6.46696985e-02f, 1.76304445e-01f, 2.15756625e-01f, -5.61159439e-02f, 2.90755779e-01f, 1.36392757e-01f,
  1.66644175e-02f, -4.04071137e-02f, 1.68109071e-02f, -2.01475918e-02f, -2.71256035e-03f, -1.80415362e-02f, -7.35934777e-03f, -4.55842428e-02f, 6.47959411e-02f, -2.14561000e-02f,
  -6.20842129e-02f, 6.58081099e-02f, 5.67113124e-02f, 3.89938541e-02f, 3.43239978e-02f, 1.47307878e-02f, 5.38586527e-02f, -5.19011766e-02f, -2.95104478e-02f, -1.10332690e-01f,
  -2.94365212e-02f, 1.24021126e-02f, -6.25516940e-03f, -2.65441258e-02f, 1.28677278e-03f, 4.56240214e-02f, 6.35865331e-02f, -4.66978922e-02f, 2.59307009e-04f, 5.31378426e-02f,
  3.96823883e-02f, 7.65645923e-03f, -1.31973575e-04f, -3.37772258e-02f, -1.89646671e-03f, 1.64970907e-03f, -2.51732767e-02f, -1.26719307e-02f, -4.29052934e-02f, 1.22315052e-03f,
  -5.52277043e-02f, -2.35660169e-02f, 3.39316428e-02f, -9.74736456e-03f, 4.50147390e-02f, 3.99365984e-02f, 3.22422944e-02f, -2.82668825e-02f, -6.92823976e-02f, -8.17265362e-03f,
  8.54377821e-03f, 2.14591064e-02f, -5.48283234e-02f, 1.48450127e-02f, -5.57883419e-02f, -2.26789676e-02f, -5.95697341e-03f, 2.45637493e-03f, 4.37807851e-02f, -4.02435064e-02f,
  4.85867113e-02f, 5.95962033e-02f, -1.13881707e-01f, 4.00650650e-02f, 1.67646017e-02f, -3.38563435e-02f, 7.23614497e-03f, 8.71396363e-02f, -5.24374954e-02f, -6.68542534e-02f,
  3.49284639e-03f, -5.20556495e-02f, 8.36162195e-02f, 4.39458154e-02f, 7.27405250e-02f, 4.26818319e-02f, -6.39045835e-02f, -1.39579382e-02f, 9.70552042e-02f, 5.05201472e-03f,
  3.52905430e-02f, -8.31561536e-02f, 6.15765974e-02f, -2.83309910e-02f, 1.08376667e-01f, 6.42993068e-03f, 3.00208312e-02f, 2.50233747e-02f, 3.70014310e-02f, 1.52470721e-02f,
  -3.72522146e-01f, 2.06079155e-01f, -2.41606068e-02f, 3.66127975e-02f, -3.70333433e-01f, 9.65478867e-02f, 2.42882535e-01f, -1.73306063e-01f, -3.13707031e-02f, 4.15399551e-01f,
  1.46014795e-01f, -1.04186937e-01f, 2.68855840e-01f, 2.69429535e-01f, -1.63517237e-01f, 3.51106286e-01f, 3.29656571e-01f, 2.71925569e-01f, -2.23323349e-02f, -8.10257252e-03f,
  2.25700042e-03f, 4.57167812e-02f, 2.07621336e-01f, -1.54849976e-01f, -1.12021066e-01f, -1.75649375e-01f, -6.75934032e-02f, -1.98826641e-01f, 7.74694756e-02f, -4.16555479e-02f,
  -1.29066795e-01f, -1.17347412e-01f, -3.02922912e-02f, -3.99929211e-02f, -2.78709438e-02f, -1.06592132e-02f, 7.81409815e-02f, -2.21235515e-03f, 2.95125563e-02f, -2.17730459e-02f,
  1.31070595e-02f, -3.72669138e-02f, -1.17541648e-01f, -1.74431689e-02f, -3.48285921e-02f, -2.16816626e-02f, -9.55478325e-02f, 3.80301550e-02f, -2.52694059e-02f, -4.34227698e-02f,
  -4.54967022e-02f, 5.31753674e-02f, -1.03906076e-02f, 1.45331666e-01f, -4.85662222e-02f, -1.70849934e-02f, 7.25855008e-02f, -2.63558142e-03f, -2.44394988e-02f, -7.76580870e-02f,
  7.76581317e-02f, 9.13836807e-02f, 3.94250378e-02f, -1.21035883e-02f, 3.53759751e-02f, -6.76640794e-02f, -2.58514169e-03f, 1.46107664e-02f, -4.33770828e-02f, 5.19117452e-02f,
  -2.04978213e-02f, -6.21000752e-02f, -2.95351613e-02f, 4.46030162e-02f, 4.68727089e-02f, 2.48917062e-02f, 4.46616635e-02f, -4.59408946e-02f, 7.84933940e-02f, -2.27783266e-02f,
  -1.51628600e-02f, -5.04951514e-02f, 5.31970933e-02f, 6.19147457e-02f, 3.15386578e-02f, 3.08307335e-02f, -2.54225228e-02f, 1.08720083e-02f, 1.05650216e-01f, 4.02507372e-03f,
  -8.28532353e-02f, -9.15952548e-02f, 5.39736226e-02f, -2.24222918e-03f, 4.37805839e-02f, -1.59944855e-02f, -4.08991128e-02f, -1.17516160e-01f, -8.38522315e-02f, -5.48789315e-02f,
  -5.13977893e-02f, 5.29799387e-02f, -1.35482088e-01f, -3.75827476e-02f, -4.80596051e-02f, 3.35724908e-03f, -2.19033547e-02f, 3.64104770e-02f, 1.34170046e-02f, 1.02629270e-02f,
  -2.62960475e-02f, -6.94788620e-02f, -1.41608296e-02f, -4.12063375e-02f, 2.84598116e-02f, 2.11805571e-02f, -1.26922578e-02f, 3.94965038e-02f, -7.31896013e-02f, 1.83370356e-02f,
  7.11570084e-02f, -5.31268828e-02f, 4.45000967e-03f, -2.53342628e-03f, 3.94283421e-02f, -7.88622424e-02f, -7.80268619e-03f, 2.56290846e-02f, 1.85215145e-01f, -3.29319052e-02f,
  1.25380278e-01f, -1.53127402e-01f, 3.26564535e-02f, -7.51333982e-02f, -2.61466861e-01f, -1.19949259e-01f, -2.31035352e-01f, -1.57693237e-01f, -1.27773685e-02f, 4.99930233e-02f,
  -7.41352960e-02f, -2.33469997e-02f, -1.59632206e-01f, 1.27554938e-01f, 1.16672227e-02f, 3.74925090e-04f, 9.33869332e-02f, -1.56828726e-03f, -4.96388739e-03f, -1.27349004e-01f,
  1.02811400e-02f, 1.20728806e-01f, -6.98358752e-03f, -6.33577034e-02f, -5.36649302e-02f, 7.60260895e-02f, -3.91648971e-02f, -3.19976434e-02f, -1.75702740e-02f, 3.55320983e-02f,
  -4.50055152e-02f, 6.19886927e-02f, -8.94323438e-02f, -2.75541004e-02f, -4.17230912e-02f, 8.27188343e-02f, -3.48870456e-02f, 2.84605380e-02f, -5.43444492e-02f, 1.51402373e-02f,
  3.83548550e-02f, 5.83396330e-02f, 4.82045561e-02f, 5.24537079e-02f, 4.13092040e-02f, 1.05152100e-01f, -1.03265181e-01f, -2.30950695e-02f, 3.78494039e-02f, -3.62635143e-02f,
  8.92482698e-02f, -7.65739530e-02f, 4.96468470e-02f, -5.07118367e-02f, -6.22784793e-02f, 3.09866313e-02f, 8.98454040e-02f, -4.96039279e-02f, -7.32158124e-02f, 4.26501743e-02f,
  -7.77588114e-02f, 4.26095612e-02f, 1.62081588e-02f, -4.78233285e-02f, 3.97695415e-02f, 3.38633731e-02f, 3.65601704e-02f, -5.33984229e-02f, 1.72244627e-02f, -5.44630624e-02f,
  6.67618066e-02f, -1.21269614e-01f, -8.29366148e-02f, 2.59470125e-03f, -2.95006949e-02f, 2.76126210e-02f, 9.87320021e-02f, -5.24670742e-02f, 8.48173723e-02f, -3.78210060e-02f,
  2.37492588e-03f, 5.73933460e-02f, 5.65923676e-02f, -4.63339500e-02f, 3.40620466e-02f, -6.81920275e-02f, -2.40296740e-02f, -9.83229205e-02f, -4.85302061e-02f, 3.85991558e-02f,
  -3.62392515e-02f, 4.14381549e-02f, -3.61198969e-02f, -4.45385464e-02f, 2.05462743e-02f, 2.58963573e-05f, 5.88031933e-02f, -4.23673317e-02f, -4.69861552e-02f, -1.16851171e-02f,
  1.16985487e-02f, 1.14039995e-01f, -9.35453624e-02f, 6.72453316e-03f, 3.76639925e-02f, 1.09591689e-02f, 7.15637207e-02f, -2.35846005e-02f, -2.07244493e-02f, -8.20333436e-02f,
  -3.90556723e-01f, 1.16869677e-02f, -9.28145275e-02f, -5.28445058e-02f, 4.67111953e-02f, 2.32362524e-01f, -1.36413649e-01f, 5.25789452e-04f, -2.76315153e-01f, -2.61847340e-02f,
  -7.86525533e-02f, -1.69836402e-01f, -1.79850399e-01f, 1.29657313e-01f, 8.22763219e-02f, 5.00776581e-02f, 1.56484216e-01f, -2.87411604e-02f, 4.86847945e-02f, -9.07320902e-02f,
  3.39557929e-03f, 1.01006001e-01f, 7.61347311e-03f, 2.67458230e-01f, 6.48271432e-03f, -1.37139648e-01f, 2.80280318e-03f, 3.07144728e-02f, 2.30563313e-01f, 1.26668826e-01f,
  -2.02242807e-02f, -2.99679160e-01f, -1.91577598e-01f, -1.28174886e-01f, -8.61898214e-02f, -1.14721671e-01f, -9.51826125e-02f, -1.38592832e-02f, -2.16063280e-02f, 2.33827773e-02f,
  -9.08001512e-02f, 3.40725742e-02f, 5.70645109e-02f, -1.33044999e-02f, 4.69465628e-02f, -1.17489826e-02f, 7.04022422e-02f, -2.25151312e-02f, -8.68132487e-02f, 2.30648071e-02f,
  1.26920212e-02f, -2.99725938e-03f, -4.28370461e-02f, 1.00733265e-01f, -1.69514697e-02f, 6.56597614e-02f, -2.58851722e-02f, -1.20052109e-02f, 9.61897224e-02f, -4.08506440e-03f,
  1.24984058e-02f, -2.11119894e-02f, -1.63046047e-02f, -4.06896994e-02f, -6.68734089e-02f, 2.18710545e-02f, 3.01502664e-02f, 2.94610579e-02f, 1.93159860e-02f, -7.18801003e-03f,
  6.22615851e-02f, 6.72863750e-03f, -8.89735371e-02f, -4.77282777e-02f, -6.69987081e-03f, 2.20720507e-02f, -3.95380966e-02f, -2.52102241e-02f, 8.25034734e-03f, 7.76369944e-02f,
  2.65236082e-03f, -5.08598089e-02f, 2.90440712e-02f, 6.20896555e-02f, 4.57494892e-02f, -1.71303726e-03f, -2.20518988e-02f, 2.58645117e-02f, -7.40319341e-02f, 4.69262674e-02f,
  -2.23506778e-01f, -1.85012564e-01f, -5.97249493e-02f, -5.96365891e-02f, -2.85860039e-02f, -6.55449042e-03f, 7.59107433e-03f, -1.82223767e-02f, -9.95075628e-02f, -4.07578126e-02f,
  -8.37421790e-02f, -2.60768775e-02f, -5.68511859e-02f, -1.92989130e-02f, 1.73348933e-02f, -8.30441788e-02f, -4.99045895e-03f, 3.48503664e-02f, -5.44268489e-02f, 9.20027122e-02f,
  -7.46694505e-02f, -1.60626154e-02f, 6.69320002e-02f, -1.48760211e-02f, -1.46798389e-02f, 5.39029501e-02f, 4.02206741e-02f, -9.90080833e-02f, 7.09709600e-02f, 5.68842627e-02f,
  9.28996280e-02f, -7.15357950e-03f, 1.57507248e-02f, 1.00264072e-01f, -8.95087123e-02f, 1.37984425e-01f, 1.37972996e-01f, -6.41543195e-02f, -1.62559465e-01f, 1.30747214e-01f,
  2.08316058e-01f, 1.32769853e-01f, 9.30798277e-02f, 1.88941225e-01f, 1.40203238e-01f, 5.26804440e-02f, 7.74178356e-02f, 2.07348377e-01f, -8.27030540e-02f, 2.48913970e-02f,
  4.60313186e-02f, 7.10508153e-02f, 9.49381441e-02f, -9.50369611e-02f, 1.09509282e-01f, -7.56484345e-02f, 1.02172211e-01f, -2.99807731e-02f, 1.22433929e-02f, 3.69231626e-02f,
  1.02642462e-01f, -5.83285615e-02f, 6.47897199e-02f, 6.32386655e-03f, -4.06681709e-02f, 3.26330145e-03f, 7.95189217e-02f, -2.96519902e-02f, 2.59901658e-02f, 5.86241074e-02f,
  -4.09873128e-02f, 4.30270433e-02f, 6.85538771e-03f, 1.96769834e-03f, -4.98722866e-02f, -6.87576309e-02f, -5.80515293e-03f, 6.07605949e-02f, 3.43550672e-03f, -6.03771806e-02f,
  7.59491920e-02f, -3.93988602e-02f, 6.67516515e-02f, 6.05741590e-02f, -6.97762370e-02f, 8.10813010e-02f, -8.71189162e-02f, -2.48658974e-02f, 1.86236488e-04f, -9.61343721e-02f,
  -9.51160416e-02f, 2.49531697e-02f, 7.15058818e-02f, 6.13403274e-03f, -2.69006155e-02f, -3.29905599e-02f, 7.65642896e-02f, 6.86961785e-02f, 6.49453923e-02f, 2.33180746e-02f,
  -3.07748877e-02f, 4.55872603e-02f, 1.38957072e-02f, -3.52483541e-02f, 2.26905961e-02f, -5.83099574e-02f, -3.13236900e-02f, -5.22439592e-02f, 6.06603362e-02f, -7.50471577e-02f,
  -1.69337336e-02f, 2.66976133e-02f, -4.43488825e-03f, -6.19448945e-02f, 4.61102352e-02f, 7.17373714e-02f, -4.63656522e-02f, 9.52538010e-03f, 1.68907661e-02f, 1.17452815e-01f,
  -4.90830280e-02f, 1.33653590e-02f, -5.80176488e-02f, -2.85477415e-02f, -7.76837468e-02f, -1.39098894e-02f, 1.43147204e-02f, -7.84668773e-02f, 2.39635855e-02f, -4.35750708e-02f,
  -8.51088762e-02f, -6.46430627e-02f, -8.92060157e-03f, 5.65293506e-02f, -3.16514820e-02f, -2.75013894e-02f, 1.32736843e-02f, -6.44008964e-02f, 4.16513421e-02f, -1.83644500e-02f,
  -1.45406760e-02f, -4.31339182e-02f, -5.80909885e-02f, -3.34084369e-02f, 1.20783048e-02f, 2.08623931e-02f, 2.51488388e-02f, -1.01746134e-02f, -6.62834719e-02f, 6.23656902e-03f,
  4.81005758e-02f, 1.85623437e-01f, -4.00220975e-02f, 2.70443945e-03f, -1.53007051e-02f, -1.80570245e-01f, -1.15382344e-01f, 8.48734900e-02f, -9.24100727e-02f, 1.06182307e-01f,
  7.91711956e-02f, -5.68076968e-02f, 8.79028961e-02f, 2.27640614e-01f, 2.18535051e-01f, 4.77279425e-02f, 1.70085594e-01f, 2.34610066e-02f, -4.83738109e-02f, 1.68516994e-01f,
  1.25414759e-01f, 2.92958230e-01f, 2.25006312e-01f, 9.44927409e-02f, 1.48294628e-01f, 1.76980887e-02f, 2.41481870e-01f, 1.14398904e-03f, 6.42167777e-02f, -9.30714794e-03f,
  3.16552557e-02f, 2.09056258e-01f, -4.13825474e-04f, -4.13874052e-02f, 5.05625978e-02f, -5.69420345e-02f, -1.23584442e-01f, 2.36012880e-02f, -1.08721480e-01f, -9.15439129e-02f,
  3.33424173e-02f, 2.89480835e-02f, 4.34657894e-02f, 3.13304998e-02f, -9.93915871e-02f, 1.90480594e-02f, 6.17564060e-02f, 2.71201544e-02f, -4.26962487e-02f, 5.33264913e-02f,
  3.35640907e-02f, 2.04731487e-02f, -5.80960736e-02f, -8.49149972e-02f, -6.56173229e-02f, 2.62712464e-02f, 1.73070896e-02f, -3.78442258e-02f, 1.94356870e-02f, 1.95195563e-02f,
  2.55508777e-02f, -7.24080354e-02f, -7.85609186e-02f, 2.12789420e-02f, -4.73485775e-02f, -5.98578118e-02f, -1.06875887e-02f, 5.35196438e-02f, 2.44865902e-02f, -1.60742812e-02f,
  2.61941776e-02f, 8.19603726e-02f, -1.50674377e-02f, -7.51660839e-02f, 3.83626446e-02f, 5.03952069e-05f, -1.10801449e-02f, -9.02771577e-03f, -3.59512754e-02f, -4.07553725e-02f,
  3.06268334e-02f, 3.07813548e-02f, -5.23025393e-02f, -3.72752398e-02f, -8.97995085e-02f, 7.88601041e-02f, -2.92330552e-02f, 8.77977461e-02f, 9.00972858e-02f, -2.82517727e-02f,
  9.78489518e-02f, 3.35263610e-01f, -2.64327228e-03f, -9.25408155e-02f, -5.68982288e-02f, -1.94165949e-02f, -4.10314649e-03f, -1.68829036e-04f, 7.28206113e-02f, 6.41113818e-02f,
  7.45460019e-02f, -6.44205976e-03f, -3.81745063e-02f, -1.01783484e-01f, 1.39394682e-02f, 9.47258100e-02f, -1.75120439e-02f, -6.13453873e-02f, -4.06093970e-02f, -1.62381623e-02f,
  -4.76172231e-02f, 7.55112395e-02f, 4.38662358e-02f, -6.97921887e-02f, 3.01055275e-02f, -4.95832376e-02f, 1.83509421e-02f, 4.81331348e-02f, 6.84009343e-02f, -2.13953741e-02f,
  6.93104416e-02f, 3.00231036e-02f, -1.60237432e-01f, 1.70025397e-02f, 3.24954279e-02f, 2.34959587e-01f, 1.73873395e-01f, 8.02280605e-02f, 2.73826540e-01f, 3.97217413e-03f,
  -1.01882517e-02f, 1.89717010e-01f, 1.55397765e-02f, 7.15839565e-02f, 2.30213791e-01f, -3.65724671e-03f, 1.46376178e-01f, 3.40633132e-02f, 7.96543583e-02f, 9.79720280e-02f,
  -4.62423563e-02f, 8.90299827e-02f, -1.97631046e-01f, 7.27662519e-02f, -2.41167173e-02f, -1.26371846e-01f, -1.22596927e-01f, -1.73624888e-01f, -9.97147262e-02f, 1.37860626e-02f,
  -1.15378276e-02f, 9.09778569e-03f, -6.66145310e-02f, -1.75680593e-02f, -1.85322445e-02f, -8.55934694e-02f, -9.06865150e-02f, -8.06907788e-02f, 1.69050805e-02f, 5.41067962e-03f,
  2.39963159e-02f, 1.36114499e-02f, 8.77160928e-04f, -6.27092347e-02f, 6.62670955e-02f, 8.61058310e-02f, -1.55663704e-02f, -9.24500898e-02f, 5.82115017e-02f, -2.61352789e-02f,
  -2.42143571e-02f, -2.41372758e-03f, -4.16955054e-02f, -4.07667048e-02f, -3.27682495e-02f, -4.51099388e-02f, 1.15408273e-02f, -5.60371913e-02f, 6.88582286e-02f, 7.18543455e-02f,
  1.87725127e-02f, -4.80002202e-02f, -1.38516724e-02f, 8.06893874e-03f, -3.97391915e-02f, -3.37195285e-02f, 4.09146175e-02f, 2.54442040e-02f, 5.71790747e-02f, 2.50751916e-02f,
  3.76508124e-02f, -5.99097237e-02f, 4.65177819e-02f, -1.29923588e-02f, 4.47512306e-02f, -1.87648665e-02f, 7.18194470e-02f, -6.96391761e-02f, 5.94609566e-02f, 4.05823886e-02f,
  -6.13076016e-02f, 2.40642503e-02f, 6.67200387e-02f, -8.49127695e-02f, 2.34691873e-02f, 5.00700548e-02f, 3.13496180e-02f, -3.71736614e-03f, -2.80412957e-02f, 2.17739344e-02f,
  6.99678436e-02f, 2.41636291e-01f, 6.99783340e-02f, -6.76778853e-02f, -1.15393018e-02f, 5.16970828e-02f, 1.38163846e-02f, 4.28476147e-02f, 9.96122658e-02f, 1.29150227e-01f,
  -2.79153604e-03f, 1.84781551e-02f, 8.39415491e-02f, -1.08170927e-01f, -5.19127920e-02f, 6.59722537e-02f, 1.10268928e-02f, 8.60219747e-02f, 1.35303605e-02f, 4.94231796e-03f,
  -3.76014523e-02f, 2.53513772e-02f, 4.80847545e-02f, -7.63184996e-03f, 8.82592201e-02f, -6.01138659e-02f, 1.11653037e-01f, -8.08567852e-02f, 7.35894591e-02f, 1.57322045e-02f,
  -1.30966678e-01f, -2.09648043e-01f, 5.39876893e-02f, -3.73352543e-02f, 9.22432616e-02f, 5.95408902e-02f, -6.15830719e-02f, 8.20558444e-02f, -7.91345164e-02f, -1.31486252e-01f,
  -1.44079737e-02f, -2.55420417e-01f, -1.54267058e-01f, -2.40992740e-01f, -9.83279347e-02f, -2.97315598e-01f, -2.08276566e-02f, -1.52344733e-01f, -1.41396597e-01f, -3.13498452e-02f,
  5.61210699e-02f, 5.67582902e-03f, 1.48560107e-01f, 2.17941225e-01f, 1.27351582e-01f, 1.87645555e-01f, 2.60903716e-01f, 1.64053559e-01f, 1.48163110e-01f, 3.70852537e-02f,
  -1.24538176e-01f, -7.18633533e-02f, 5.67297228e-02f, 4.23115939e-02f, 8.92996266e-02f, 1.06384486e-01f, -9.30670649e-03f, -1.19994609e-02f, 6.15601130e-02f, 5.67692295e-02f,
  -6.32739440e-02f, 4.42368425e-02f, -5.54376543e-02f, -4.51737270e-02f, 6.31168410e-02f, -6.62919087e-03f, 1.76331569e-02f, 8.32138583e-02f, -1.26377130e-02f, -1.11438766e-01f,
  -7.97183663e-02f, -1.28905652e-02f, 8.09007436e-02f, -1.67131815e-02f, 6.82426021e-02f, 6.45635650e-02f, 5.54244183e-02f, 4.33254950e-02f, -1.20832436e-02f, -1.74782388e-02f,
  6.24203533e-02f, 5.44312745e-02f, 1.85372103e-02f, 9.98669490e-03f, 4.44010086e-03f, -8.24119672e-02f, -2.64162421e-02f, 5.30053414e-02f, 2.03220663e-03f, 4.00518216e-02f,
  9.47401021e-03f, -2.19653770e-02f, -4.94986773e-02f, 7.56504312e-02f, -4.71076295e-02f, -5.85757196e-02f, -5.46234399e-02f, 7.98530206e-02f, 4.90040109e-02f, -3.29733677e-02f,
  -1.02435268e-01f, -3.67800742e-02f, -1.09626082e-04f, 8.50711614e-02f, -7.72329792e-02f, 2.39229817e-02f, -5.19782938e-02f, -5.87051734e-02f, 5.86387217e-02f, -1.28637459e-02f,
  3.53026874e-02f, 6.25142828e-02f, 3.93069126e-02f, 1.83165318e-03f, -4.61522974e-02f, 2.73929220e-02f, -3.97100076e-02f, -6.18891716e-02f, 1.21947182e-02f, -9.60955620e-02f,
  8.99260119e-02f, -2.65931543e-02f, 4.77632172e-02f, -4.88356240e-02f, 1.23505471e-02f, 5.08803241e-02f, -5.04791085e-03f, 5.40739708e-02f, 1.22028485e-01f, 4.38613780e-02f,
  -3.13428044e-02f, 5.44213969e-03f, 4.12123352e-02f, 1.26489624e-01f, 9.51893926e-02f, 5.72876818e-02f, 1.01436652e-01f, -5.08593768e-03f, 3.13043669e-02f, -4.10760231e-02f,
  2.64497817e-01f, -6.06055707e-02f, -1.44725710e-01f, -6.54055849e-02f, -1.66898116e-01f, -2.11129233e-01f, -2.44871065e-01f, -9.31385756e-02f, -1.20087015e-02f, -3.87670770e-02f,
  -2.33009890e-01f, 1.55569836e-01f, -6.87841475e-02f, -1.89891681e-01f, -5.44701517e-02f, 3.53612304e-02f, -1.48914054e-01f, 6.47183061e-02f, -2.25265063e-02f, -1.56412348e-01f,
  -5.80922104e-02f, -2.63010919e-01f, -1.34963751e-01f, -8.83737206e-02f, -1.34211227e-01f, 1.66474115e-02f, 9.02455002e-02f, -8.08617622e-02f, -5.61749563e-03f, -5.71343713e-02f,
  -3.41258827e-03f, -3.67334709e-02f, 3.84779833e-02f, 1.26370247e-02f, -9.95035022e-02f, 8.47774670e-02f, 4.92314212e-02f, -7.39779100e-02f, 5.07202148e-02f, 1.19118663e-02f,
  1.43657237e-01f, 8.09752475e-03f, 1.09703168e-02f, 3.47835151e-03f, 4.14792411e-02f, 7.17855170e-02f, 3.67481485e-02f, 8.99292007e-02f, 8.35757703e-03f, 1.97797026e-02f,
  -7.02686906e-02f, 8.20207223e-02f, 3.50613594e-02f, 2.91161537e-02f, 2.32241359e-02f, 2.47055590e-02f, -6.05703238e-03f, 5.48030883e-02f, 4.93547991e-02f, -1.66464429e-02f,
  2.87641846e-02f, 9.81788486e-02f, -4.66796719e-02f, -1.31304339e-02f, 5.09238383e-03f, -6.19285665e-02f, -6.40922114e-02f, 7.89972842e-02f, -4.79791202e-02f, 3.73860188e-02f,
  1.74920596e-02f, 2.49224119e-02f, 1.75651554e-02f, 8.03731941e-03f, 2.78769936e-02f, -3.65299620e-02f, -3.44708487e-02f, 2.84978040e-02f, -1.09842243e-02f, 5.36940694e-02f,
  -2.07804311e-02f, -5.01203798e-02f, -5.16098961e-02f, -3.81299220e-02f, -4.87784743e-02f, -6.12688959e-02f, 3.21851037e-02f, 8.28141123e-02f, 7.11844191e-02f, 5.42684644e-02f,
  -7.31186718e-02f, -1.09949939e-01f, -6.27020746e-02f, -2.61200033e-02f, -5.15813157e-02f, 6.21234924e-02f, -1.81017481e-02f, -6.46553561e-02f, -5.69707491e-02f, -6.90699071e-02f,
  -1.66174266e-02f, 7.57020041e-02f, 5.50520681e-02f, -2.50680856e-02f, 4.38552903e-04f, -5.49054425e-03f, -4.38535251e-02f, 9.14504305e-02f, 6.40898868e-02f, -3.05210128e-02f,
  4.57089469e-02f, 8.23318660e-02f, -1.91785600e-02f, 3.11979931e-02f, 5.33265397e-02f, 1.39295054e-03f, 9.80678853e-03f, 5.62988631e-02f, 2.91809123e-02f, -2.50954404e-02f,
  -2.81471536e-02f, 9.56400782e-02f, -1.50232270e-01f, -9.62542836e-04f, 6.42146319e-02f, 3.11670844e-02f, 3.83943915e-02f, 9.81565565e-02f, 6.51085526e-02f, 1.03564508e-01f,
  1.34737268e-01f, 1.43152431e-01f, -4.74360622e-02f, 8.08005556e-02f, 4.88679409e-02f, 1.06397625e-02f, 1.86631247e-01f, 1.85394391e-01f, 6.93600550e-02f, -6.22173306e-03f,
  8.51795152e-02f, 1.53668001e-01f, -6.16456270e-02f, -6.89184070e-02f, 1.24864198e-01f, -2.07824241e-02f, -1.46875838e-02f, -9.83833298e-02f, -1.61371566e-02f, -6.24852292e-02f,
  -1.23474374e-02f, -3.21037904e-03f, -8.01820401e-03f, -9.44082960e-02f, -4.56479900e-02f, -6.32141382e-02f, -2.81183310e-02f, -6.40208647e-02f, 8.74209590e-03f, 5.54417633e-02f,
  -1.84711646e-02f, -4.73298877e-02f, 2.91205179e-02f, -1.15279583e-02f, 2.53972281e-02f, -4.95902523e-02f, 4.68324032e-03f, 5.43844849e-02f, -4.40733247e-02f, 6.22176006e-02f,
  -1.78296026e-02f, -5.38771488e-02f, 4.37338464e-02f, 5.79910688e-02f, -5.74944913e-02f, -3.42042819e-02f, 1.94939543e-02f, 5.22475429e-02f, 5.67021482e-02f, -4.30582874e-02f,
  -2.45417915e-02f, -9.00515467e-02f, 5.70994616e-02f, -2.33208369e-02f, -4.28362228e-02f, -4.25031334e-02f, -3.45467813e-02f, -6.08800948e-02f, -8.32029432e-02f, 9.00253430e-02f,
  1.97402611e-02f, 1.41544389e-02f, -4.95411456e-02f, -4.03303057e-02f, 2.77707409e-02f, -1.03756554e-01f, -9.15211439e-02f, -3.70739959e-02f, -5.22151254e-02f, -4.62809354e-02f,
  -7.24198222e-02f, 3.62984762e-02f, 1.95148531e-02f, 8.84155259e-02f, 5.04577719e-02f, -4.84151579e-02f, 9.77956504e-02f, 2.87393108e-02f, -5.24122939e-02f, -5.07587567e-02f,
  5.30471988e-02f, 9.95064899e-02f, 2.21896879e-02f, 6.43363521e-02f, -2.51590330e-02f, -3.10558807e-02f, 1.71696562e-02f, 3.02675162e-02f, 6.85201809e-02f, -2.29273885e-02f,
  3.53506356e-02f, -5.11902831e-02f, 8.20769593e-02f, 5.67552634e-02f, -9.42620635e-02f, -2.64486279e-02f, 8.56472179e-02f, 4.61494271e-03f, 3.85097191e-02f, -6.80855811e-02f,
  1.32854916e-02f, -2.43892428e-02f, -2.25028861e-02f, -2.76243612e-02f, -6.18790984e-02f, -2.96361092e-02f, 7.17580020e-02f, -7.87744075e-02f, 1.49209891e-02f, 6.44465983e-02f,
  2.45142460e-01f, 2.90729199e-02f, -3.53075057e-01f, -1.70628220e-01f, 1.22954480e-01f, 2.93707371e-01f, 1.24850638e-01f, -1.10992752e-02f, -1.28544830e-02f, 5.78432307e-02f,
  2.22704560e-02f, -1.11604482e-01f, -1.04400218e-01f, 3.03839166e-02f, 9.00296345e-02f, -6.21547960e-02f, 2.12582514e-01f, 7.63676912e-02f, -3.51579487e-02f, 7.07441345e-02f,
  -2.93574482e-02f, 2.29724213e-01f, -2.42236078e-01f, -5.99730909e-02f, 5.09944111e-02f, -1.87663850e-03f, -7.63849020e-02f, -7.85523057e-02f, 6.21135868e-02f, 8.79098326e-02f,
  -7.63658015e-03f, 4.98618558e-02f, -3.13599743e-02f, -3.37514393e-02f, 5.45649305e-02f, -1.24863358e-02f, 4.49068844e-02f, 6.19573332e-02f, 1.81846134e-02f, -1.12573262e-02f,
  -1.67083945e-02f, 5.86515777e-02f, 1.16788797e-01f, -5.93480691e-02f, 6.28572777e-02f, -1.19465575e-01f, -5.07004037e-02f, -7.41911381e-02f, -7.50718862e-02f, -2.81645544e-02f,
  -1.12260014e-01f, -4.80817109e-02f, 4.62265201e-02f, 4.20042127e-02f, -1.18018173e-01f, 1.14181563e-02f, -3.93193997e-02f, -4.88077402e-02f, 6.40682951e-02f, 3.86983342e-02f,
  1.03674829e-01f, 1.55931681e-01f, 8.09811056e-02f, -3.22035439e-02f, 9.15256888e-02f, -2.26750914e-02f, -1.57728549e-02f, 7.90595114e-02f, -2.41623651e-02f, 1.89900938e-02f,
  -3.57857756e-02f, -8.31341371e-02f, 6.25125319e-02f, -2.91264127e-03f, 7.74284825e-02f, 4.27579246e-02f, -4.31818068e-02f, -2.80509330e-02f, -4.34283204e-02f, -7.80164003e-02f,
  -3.10320202e-02f, 7.42571652e-02f, -6.79482240e-03f, -6.56643212e-02f, -6.95469975e-02f, -1.04774743e-01f, -3.16145655e-04f, -1.17522655e-02f, -7.74354637e-02f, -3.07733007e-02f,
  9.37431678e-02f, 2.29675591e-01f, 4.35117111e-02f, 2.76465081e-02f, -1.20569887e-02f, 4.96593527e-02f, 1.28224147e-02f, 4.28500660e-02f, -5.87460659e-02f, 1.06358141e-01f,
  8.94752666e-02f, -3.53816226e-02f, 2.05405038e-02f, 4.58037993e-03f, -6.13767728e-02f, 6.02643713e-02f, -3.33150961e-02f, -1.90064758e-02f, -4.39596409e-03f, 1.90518070e-02f,
  -5.74965179e-02f, 9.48181525e-02f, -5.27659617e-02f, -4.29970473e-02f, 2.45476812e-02f, -5.19614704e-02f, 4.54084314e-02f, 4.49147560e-02f, -3.18659879e-02f, -2.63814698e-03f,
  1.65165812e-01f, -1.93729803e-01f, 8.95260647e-02f, 1.36365578e-01f, -1.16640188e-01f, -1.45528123e-01f, 7.81688932e-03f, -7.68967941e-02f, 9.65765491e-03f, -1.27068713e-01f,
  -1.04375295e-01f, 1.32726774e-01f, 1.95321143e-02f, -1.72352955e-01f, -1.50627643e-02f, -5.63631803e-02f, -6.20314516e-02f, -6.34381697e-02f, 3.59704085e-02f, -7.78733641e-02f,
  -5.69471829e-02f, -7.83306584e-02f, -5.93866445e-02f, -2.25754291e-01f, -8.68668854e-02f, 3.81461494e-02f, -7.19899088e-02f, -4.55893837e-02f, -1.58887625e-01f, 2.63853837e-02f,
  -5.25736343e-03f, -4.61020097e-02f, 1.82828568e-02f, 3.14401239e-02f, -1.10245295e-01f, -7.14958161e-02f, -2.41615642e-02f, 8.16625282e-02f, 3.89640704e-02f, -4.06518066e-03f,
  8.30246806e-02f, 2.07515936e-02f, -7.25607052e-02f, -4.76873154e-03f, -6.68127032e-04f, 3.48647288e-03f, -4.12662998e-02f, -1.45237669e-02f, -2.63124257e-02f, 9.52352062e-02f,
  7.61586577e-02f, -7.55806640e-02f, 2.90139057e-02f, 2.77329255e-02f, 2.95453658e-03f, 6.43291101e-02f, 7.06200451e-02f, 9.54374447e-02f, 1.43961301e-02f, 5.56737222e-02f,
  -8.07871446e-02f, 4.31956071e-03f, -6.47399426e-02f, 4.98565026e-02f, 1.95680019e-02f, -1.88288353e-02f, 3.78623605e-02f, -2.66092345e-02f, 6.28817827e-02f, -9.09690633e-02f,
  6.11589961e-02f, 8.28122348e-02f, 4.93379496e-02f, -2.52079535e-02f, 4.50958200e-02f, 9.56806988e-02f, -8.20109621e-03f, -3.83753479e-02f, -7.08667710e-02f, 2.35259403e-02f,
  5.51417135e-02f, -7.22645149e-02f, -3.18602622e-02f, 6.72935098e-02f, -4.40929085e-03f, 5.31616323e-02f, -1.92541145e-02f, -2.04917397e-02f, 3.20713595e-02f, 8.26708972e-03f,
  -1.36487819e-02f, -1.25546068e-01f, 1.48796691e-02f, 4.99662235e-02f, -7.57988244e-02f, -1.02978371e-01f, -9.32307020e-02f, 3.79381217e-02f, 4.43883352e-02f, -2.82254559e-03f,
  -7.17650950e-02f, 3.12082507e-02f, -3.62238698e-02f, -2.74672676e-02f, -4.35802788e-02f, -5.39901406e-02f, -1.70554232e-03f, -6.99518546e-02f, 1.15762348e-03f, -3.47086117e-02f,
  2.51379795e-02f, 6.96248328e-03f, 4.40367311e-02f, -5.64585514e-02f, -7.77066574e-02f, 3.96379130e-03f, -5.26375212e-02f, -4.21034805e-02f, -5.17511219e-02f, 6.59303591e-02f,
  -3.87309521e-01f, 2.25047573e-01f, -3.01075220e-01f, -2.93713182e-01f, -7.49483034e-02f, -4.00576681e-01f, -1.36807784e-01f, -7.38674551e-02f, 1.64160743e-01f, 3.25813860e-01f,
  1.64359182e-01f, 3.37674432e-02f, 3.75887930e-01f, -6.58416152e-02f, -4.40488458e-01f, 2.14358032e-01f, -3.13492060e-01f, -1.62816584e-01f, 7.70277381e-02f, -1.26992390e-01f,
  -2.03234449e-01f, 8.92165527e-02f, -1.22387543e-01f, 1.85581520e-01f, -2.39748046e-01f, -2.41789147e-02f, 1.42690033e-01f, 2.32898578e-01f, -1.69066504e-01f, 4.35621245e-03f,
  -2.35450968e-01f, -9.96633172e-02f, -7.52938613e-02f, -1.83096807e-02f, -1.76540703e-01f, -1.20888852e-01f, -1.00707620e-01f, 3.02736517e-02f, 9.52354632e-03f, -6.86933026e-02f,
  1.32222846e-02f, -4.55609709e-02f, 2.43647899e-02f, 1.90916210e-02f, 4.47020913e-03f, -5.49654476e-03f, -7.35169053e-02f, -2.41628885e-02f, 3.42670344e-02f, -1.27110630e-01f,
  -1.43751845e-01f, -8.05162117e-02f, -1.01365194e-01f, -1.76589806e-02f, -4.40334678e-02f, 7.22284243e-02f, -2.10796092e-02f, -4.19961810e-02f, -1.15190297e-01f, -7.86061138e-02f,
  1.16812636e-03f, 2.45102476e-02f, -3.56906690e-02f, 1.01773709e-01f, 2.55177189e-02f, 3.94283831e-02f, -3.86022143e-02f, 9.78377461e-02f, 7.33445724e-03f, 3.64249721e-02f,
  1.86596401e-02f, 7.58885732e-03f, 6.46528155e-02f, -9.20588896e-02f, -4.19623367e-02f, 2.97820773e-02f, -6.71692491e-02f, 2.48549767e-02f, -4.41227248e-03f, -2.94151641e-02f,
  8.78414512e-02f, -6.20984919e-02f, 9.55209062e-02f, 1.63874477e-02f, -6.36841776e-03f, 3.38796377e-02f, -5.90159185e-03f, -1.46032302e-02f, -2.25487147e-02f, -8.78996924e-02f,
  -2.59940356e-01f, -2.00471073e-01f, -3.93508114e-02f, -2.62129493e-02f, 4.57932912e-02f, -7.84615427e-02f, -1.94860231e-02f, -2.33206544e-02f, -3.75726670e-02f, 2.26270668e-02f,
  -3.71156149e-02f, 8.55487585e-03f, -5.46057448e-02f, 7.87518993e-02f, -6.85711205e-02f, -7.37752989e-02f, 1.43011650e-02f, 1.46313347e-02f, -4.67487797e-02f, -9.79183763e-02f,
  9.07802805e-02f, 1.30575569e-02f, 5.27886748e-02f, -8.72715469e-03f, -4.54890206e-02f, 8.61060526e-03f, -9.54412669e-02f, -1.70149487e-02f, 8.37851409e-03f, -2.65758093e-02f,
  3.26125085e-01f, -2.85728842e-01f, -3.93543541e-02f, 1.24256633e-01f, 6.96831718e-02f, 1.73539028e-01f, 2.99266934e-01f, -1.95949391e-01f, -3.58796306e-02f, -2.67028719e-01f,
  1.47342250e-01f, 4.25078161e-02f, 2.16055661e-02f, 5.76841272e-02f, 3.83000523e-01f, -3.93295363e-02f, -3.74796651e-02f, 6.73075989e-02f, -7.72737106e-03f, -3.95440087e-02f,
  2.91976649e-02f, 4.14744355e-02f, -8.45637396e-02f, -2.58088320e-01f, 1.71083268e-02f, -1.91008255e-01f, 6.11679479e-02f, 9.32131186e-02f, -8.08353201e-02f, 1.19562186e-01f,
  8.20425227e-02f, -4.45352755e-02f, 4.58706953e-02f, -4.36021425e-02f, -4.07023542e-02f, -1.28254863e-02f, -3.29491426e-03f, 2.30568442e-02f, 2.65606921e-02f, -7.75831565e-02f,
  -1.49983289e-02f, -3.20905470e-04f, -5.80126084e-02f, 1.09356027e-02f, 2.88412757e-02f, -7.96396434e-02f, 3.26057710e-03f, -3.35961170e-02f, -5.05276732e-02f, 2.59449929e-02f,
  -1.23843616e-02f, 4.59526256e-02f, 1.12161888e-02f, -4.21677204e-03f, 1.91402007e-02f, 2.42485851e-02f, -5.25189750e-02f, -2.34048422e-02f, -8.19319338e-02f, -6.83281496e-02f,
  -1.24606136e-02f, -6.94396719e-02f, -9.23403166e-03f, -5.65262735e-02f, -5.18151782e-02f, 3.03841345e-02f, -7.19821006e-02f, -4.96261269e-02f, -6.34185150e-02f, 5.18265925e-02f,
  1.99315790e-02f, -9.06859040e-02f, 3.23372744e-02f, -5.66395447e-02f, -5.94729595e-02f, 6.21847846e-02f, -1.53516298e-02f, 6.38737977e-02f, -1.67093670e-03f, 7.44593665e-02f,
  4.50067446e-02f, -5.56830727e-02f, 4.41521183e-02f, -3.76178175e-02f, 4.69186082e-02f, 3.47305462e-02f, 3.63987908e-02f, 3.95909213e-02f, -1.65963620e-02f, 4.81918156e-02f,
  -3.62512544e-02f, -1.03891037e-01f, -7.48086423e-02f, -8.07737187e-02f, -1.28845824e-02f, -1.16846282e-02f, -5.64333051e-02f, 5.27052209e-02f, -8.02129805e-02f, -1.17910905e-02f,
  -2.01435778e-02f, 2.48194132e-02f, -1.79955754e-02f, -2.23804805e-02f, -1.72572099e-02f, -7.63623118e-02f, -1.48621807e-02f, -7.67977014e-02f, 5.80082349e-02f, -1.14208214e-01f,
  -7.74542615e-02f, 1.58381686e-02f, -2.47293096e-02f, -6.93243444e-02f, 1.37877483e-02f, -6.32388797e-03f, 2.68763751e-02f, -1.63789131e-02f, 9.00781974e-02f, -5.92401065e-02f,
  -4.10566945e-03f, 1.03370808e-01f, 1.41929269e-01f, -2.49480996e-02f, -7.95621276e-02f, 3.88561748e-02f, 1.24112152e-01f, -1.24105625e-01f, 2.24685609e-01f, -8.30906257e-02f,
  -1.04901448e-01f, 9.37826931e-02f, 5.71381375e-02f, -1.59703538e-01f, 1.78167950e-02f, 7.85307214e-02f, -9.88913849e-02f, 9.84530523e-02f, 1.83176380e-02f, 4.21629399e-02f,
  -2.48730239e-02f, -1.64532200e-01f, -1.59547195e-01f, -1.50681823e-01f, -1.78584922e-02f, -7.65314475e-02f, -1.42208040e-01f, 1.12982304e-03f, -7.15440214e-02f, 7.62577504e-02f,
  2.67366543e-02f, 3.82984914e-02f, -1.77809983e-04f, 1.31812125e-01f, -7.47964159e-02f, 5.32366626e-04f, -3.40138166e-03f, 9.76281688e-02f, 4.15010825e-02f, 5.15795425e-02f,
  7.92788267e-02f, -4.14715558e-02f, 4.57959808e-02f, 8.44756961e-02f, 7.40097538e-02f, -1.93524528e-02f, -2.24618427e-02f, 6.39379248e-02f, 4.90675941e-02f, -1.07374966e-01f,
  5.84694557e-02f, 9.06230882e-02f, -1.20791811e-02f, -1.92618314e-02f, -5.99477207e-03f, -3.71145271e-02f, 1.21089377e-01f, -3.90265249e-02f, -7.87919573e-03f, 4.70333137e-02f,
  -3.32859904e-02f, -2.38779262e-02f, -3.07925623e-02f, -1.93893425e-02f, -4.29976992e-02f, 3.19912136e-02f, -1.02138193e-02f, -7.32496604e-02f, 2.09130701e-02f, 2.43136175e-02f,
  8.78718682e-03f, 8.90814736e-02f, 3.28444354e-02f, -6.30656779e-02f, 4.59807254e-02f, -8.71648714e-02f, -6.64119497e-02f, 3.02588344e-02f, -7.64375329e-02f, -9.55878422e-02f,
  -8.68721157e-02f, -3.30731906e-02f, -7.89121911e-02f, 3.81893590e-02f, -3.02016642e-02f, 8.36659446e-02f, -9.91137773e-02f, 3.22328284e-02f, -2.25920510e-03f, -7.47561082e-02f,
  7.39076585e-02f, 1.86739296e-01f, -3.14800553e-02f, 2.30090041e-02f, -1.89218274e-03f, -3.45576853e-02f, 5.11577465e-02f, -4.59949821e-02f, 1.16966657e-01f, 2.87427232e-02f,
  -4.34962194e-03f, -3.26339761e-03f, 1.96346585e-02f, -4.75193076e-02f, 8.69864896e-02f, -1.07940584e-01f, -3.54701281e-02f, 8.17222372e-02f, 4.86056693e-02f, -8.48426891e-04f,
  2.48637013e-02f, -3.81667204e-02f, 4.73917611e-02f, 3.90659599e-03f, 6.14316836e-02f, 7.06341565e-02f, -3.84337194e-02f, 8.79721642e-02f, 6.31872416e-02f, 8.64477530e-02f,
  2.07282901e-01f, 3.01664770e-01f, 3.46324861e-01f, 2.72786796e-01f, -1.89208627e-01f, -1.85012385e-01f, -1.01367697e-01f, -9.90543962e-02f, 1.65496528e-01f, 2.02908292e-02f,
  -1.10305168e-01f, 3.58889639e-01f, -8.81280750e-02f, 8.25462416e-02f, -2.07306355e-01f, -2.22311050e-01f, 1.15422830e-01f, -2.65696552e-02f, -2.28273273e-02f, 2.51799315e-01f,
  4.01170971e-03f, -2.31532738e-01f, 7.42501542e-02f, -1.15905762e-01f, 1.27684593e-01f, 1.92958623e-01f, 4.45606709e-02f, -7.17319623e-02f, 1.84731886e-01f, -4.67367209e-02f,
  3.61420736e-02f, -1.16401799e-02f, 1.33178160e-01f, 7.82348514e-02f, 3.06301005e-02f, 5.36497459e-02f, -3.00733671e-02f, -1.36549518e-01f, 4.48290491e-03f, 7.89989457e-02f,
  1.10311611e-02f, 4.89943065e-02f, -2.41289418e-02f, -6.70183674e-02f, -5.06717078e-02f, 8.66039023e-02f, 1.06738903e-01f, -1.53218477e-03f, -3.76208164e-02f, 5.87638579e-02f,
  5.92768900e-02f, 1.25280634e-01f, 2.91340742e-02f, -4.50928137e-02f, 7.34478831e-02f, -5.29822819e-02f, 8.59347358e-03f, 1.04022443e-01f, 9.40706581e-02f, 7.83663765e-02f,
  3.58804800e-02f, -6.89835697e-02f, -2.18220446e-02f, -3.21158096e-02f, -5.39410338e-02f, 3.50341536e-02f, 1.43801430e-02f, -2.13396759e-03f, 5.41662946e-02f, 3.58562395e-02f,
  -1.49452658e-02f, 3.79140154e-02f, -1.23632401e-01f, 5.88914612e-03f, 6.67369366e-02f, -2.90900678e-03f, 3.01277488e-02f, -2.95540094e-02f, 2.11416185e-02f, 7.52572995e-03f,
  -1.04871206e-02f, -1.62079781e-02f, -3.06532998e-02f, 4.05152701e-02f, -9.83358771e-02f, -6.96266592e-02f, -2.42070761e-02f, -3.12095950e-03f, -6.15513921e-02f, 6.97565600e-02f,
  6.22774567e-03f, 1.17970914e-01f, -1.95545126e-02f, -5.69171794e-02f, -3.73626500e-02f, -1.00440683e-03f, 7.08632842e-02f, -3.16366227e-03f, 1.23850815e-02f, -7.40780011e-02f,
  8.11901763e-02f, 6.01107664e-02f, 2.54868176e-02f, 6.28645644e-02f, -3.66543941e-02f, 6.08766042e-02f, 3.40046883e-02f, 9.72900167e-02f, 5.80632649e-02f, 7.74353072e-02f,
  -1.15199834e-02f, 3.19594406e-02f, 1.18880700e-02f, 3.04242894e-02f, 7.52052246e-03f, -4.69237305e-02f, -1.47051155e-03f, 3.86587791e-02f, 6.25667423e-02f, -3.79477404e-02f,
  -3.04353029e-01f, 2.84139127e-01f, -2.26982012e-01f, -2.25138783e-01f, 2.46862788e-02f, 1.09661244e-01f, 2.37051576e-01f, 1.62633225e-01f, 1.01912372e-01f, 2.49130443e-01f,
  2.25939646e-01f, -4.58050407e-02f, 1.53011292e-01f, 2.49449834e-01f, -7.09992498e-02f, 2.03208610e-01f, 8.19725916e-02f, 1.64486945e-01f, 1.18254699e-01f, 1.32778389e-02f,
  -1.45816058e-01f, 1.48494944e-01f, -6.43067881e-02f, 6.11631013e-02f, 3.86311039e-02f, -1.17858000e-01f, -3.48637961e-02f, -5.97280636e-02f, -3.45922075e-02f, -1.45713962e-03f,
  8.48456472e-02f, 8.23407248e-02f, -1.30188346e-01f, -6.16695955e-02f, -1.36528283e-01f, -3.77958231e-02f, -5.30683808e-02f, -7.50184059e-02f, -8.85808617e-02f, 2.78355386e-02f,
  -1.96834784e-02f, -5.83641306e-02f, -2.73548961e-02f, 6.47154078e-02f, -6.29189238e-02f, -6.89599961e-02f, 7.56652132e-02f, -6.75930604e-02f, 2.12608185e-02f, -2.41970867e-02f,
  -6.18590601e-02f, -4.43950482e-02f, -3.68030556e-02f, 8.01005885e-02f, -3.72167933e-03f, 5.33660594e-03f, 8.69059190e-02f, -7.24587813e-02f, 3.29449326e-02f, -4.15232256e-02f,
  -5.06809093e-02f, -6.16291352e-02f, 4.50376002e-03f, -3.30792889e-02f, -3.86230387e-02f, 2.32291110e-02f, -6.58524036e-03f, -6.25649020e-02f, -3.81246544e-02f, -2.77475808e-02f,
  -5.46537377e-02f, 2.31198198e-03f, -1.10956570e-02f, 6.79363087e-02f, 3.46181877e-02f, -3.24402889e-03f, 2.15701554e-02f, 5.61231710e-02f, -1.94262192e-02f, 2.95284241e-02f,
  2.42198184e-02f, -5.80070689e-02f, -1.25665497e-02f, -4.74855378e-02f, 1.12279793e-02f, 7.00768381e-02f, 1.55750131e-02f, -3.18848491e-02f, -9.00901668e-03f, -5.21849934e-03f,
  2.28890523e-01f, -1.59692559e-02f, 9.45653021e-02f, -2.51690298e-02f, -5.24426103e-02f, 9.62261409e-02f, 8.49506445e-03f, 6.93662232e-03f, 5.01579754e-02f, 2.90828478e-02f,
  -4.96874824e-02f, -5.81328422e-02f, 1.89449079e-02f, -1.14411693e-02f, 5.72357923e-02f, 8.64114836e-02f, -2.63246670e-02f, -1.87256709e-02f, -4.49681282e-02f, -2.63084397e-02f,
  -3.49441171e-02f, 6.51035607e-02f, -5.33732921e-02f, -4.65584360e-02f, 3.13948281e-02f, -2.21996810e-02f, -7.84502551e-02f, -1.15974713e-02f, 4.95679528e-02f, 8.84352345e-03f,
  -2.53937006e-01f, -1.29298553e-01f, -1.95216611e-01f, -6.67807162e-02f, 1.90313041e-01f, -5.97902127e-02f, -2.39837524e-02f, 1.96301956e-02f, -2.60510623e-01f, 6.56297281e-02f,
  1.21827178e-01f, -2.01646954e-01f, -1.26835883e-01f, -2.10368812e-01f, -2.42164597e-01f, -3.25821042e-01f, -1.34616032e-01f, -8.81551020e-03f, -1.43579558e-01f, -4.31446172e-02f,
  9.61138774e-03f, 3.90663035e-02f, -1.10909849e-01f, 1.46712556e-01f, 1.71726327e-02f, 2.07179010e-01f, 2.60223150e-01f, 1.05648965e-01f, 1.44759879e-01f, -2.55581476e-02f,
  3.52416150e-02f, -1.23366885e-01f, -8.52818340e-02f, -1.62979625e-02f, 8.33068714e-02f, 2.10508853e-02f, 6.88782111e-02f, 6.74558580e-02f, 5.14511913e-02f, -9.21703205e-02f,
  3.41615044e-02f, -3.19513492e-02f, -3.73151489e-02f, -5.06810204e-04f, -1.40820295e-02f, -6.87279273e-03f, -5.70446961e-02f, -6.58887178e-02f, 2.91653257e-02f, -8.08474198e-02f,
  -1.27079025e-01f, -2.74635036e-03f, -7.36847892e-02f, 6.20478876e-02f, 3.48317958e-02f, 5.07493913e-02f, 7.01855402e-03f, -4.66522481e-03f, 1.87702887e-02f, -1.48889041e-02f,
  3.25541794e-02f, 5.36303073e-02f, -8.44610408e-02f, -7.69942328e-02f, -1.08762877e-02f, -1.75053719e-02f, 4.89113852e-02f, 3.59051563e-02f, -1.67179329e-04f, -1.42348902e-02f,
  9.28583220e-02f, -1.05857244e-02f, 2.53778580e-03f, 7.26750493e-02f, -7.43575990e-02f, -8.58486369e-02f, 1.05200052e-01f, 6.56457618e-02f, 6.78689927e-02f, 7.48271272e-02f,
  2.03333981e-02f, -5.27026281e-02f, 8.19766074e-02f, 5.38120512e-04f, -1.12224147e-01f, -4.85548750e-03f, 5.22331297e-02f, -4.20728587e-02f, 7.73164928e-02f, -3.13037299e-02f,
  1.33490890e-01f, -1.40117947e-02f, -2.54207198e-02f, 4.14659828e-02f, -2.09070928e-02f, 5.74682131e-02f, -3.43527459e-02f, -5.65649234e-02f, 7.29331151e-02f, -3.47922347e-03f,
  7.17783347e-02f, 8.83242339e-02f, 1.02010496e-01f, -5.77854440e-02f, 6.23098351e-02f, -2.78146565e-02f, 7.89231360e-02f, 4.95874435e-02f, 7.51698529e-03f, 5.24317063e-02f,
  1.21004544e-01f, 7.64138699e-02f, -8.32666084e-02f, -2.04735342e-02f, -3.25519554e-02f, 1.63073954e-03f, -2.59810444e-02f, 7.37145692e-02f, 5.85145131e-02f, -8.50658268e-02f,
  1.57622635e-01f, -1.57287106e-01f, -4.86495160e-02f, 8.60591382e-02f, 3.47854905e-02f, -1.63233876e-01f, -1.67135954e-01f, -1.29715145e-01f, 1.36799216e-01f, -1.76230416e-01f,
  -1.51395962e-01f, 5.19673638e-02f, -9.98454839e-02f, -6.78885579e-02f, 1.51777238e-01f, -2.64443289e-02f, -9.47834775e-02f, 3.49885486e-02f, 5.73407412e-02f, -1.63260832e-01f,
  5.18534444e-02f, -1.07932940e-01f, -5.41946553e-02f, -1.03895113e-01f, -1.91665426e-01f, -8.50722939e-02f, -1.02076903e-02f, -2.10774377e-01f, -1.28668666e-01f, 1.37015851e-02f,
  4.45790365e-02f, -1.37509068e-03f, 4.27663922e-02f, 1.57571081e-02f, -1.57005042e-02f, -4.28473065e-03f, 1.56202484e-02f, 1.15272440e-01f, 5.89614064e-02f, -5.34838736e-02f,
  -1.06074223e-02f, 1.24312826e-02f, 3.44550684e-02f, 1.98167246e-02f, -7.22110271e-02f, -2.14170315e-03f, 7.24458545e-02f, -2.32456103e-02f, -1.10901129e-02f, -1.74178667e-02f,
  6.56163618e-02f, -4.50328924e-02f, -1.74207035e-02f, -4.11240906e-02f, 6.70235828e-02f, -8.14392790e-02f, 1.03026249e-01f, -5.51505126e-02f, 6.25298470e-02f, 1.13942120e-02f,
  -3.39373341e-03f, 9.01456084e-03f, -5.07930235e-04f, 6.20155185e-02f, -7.14249462e-02f, 6.50469437e-02f, 2.47701984e-02f, -1.13409813e-02f, 6.27610832e-03f, -8.43682215e-02f,
  -8.72837603e-02f, 1.51863163e-02f, 4.92257513e-02f, -4.02917862e-02f, 7.13082552e-02f, -4.71187942e-02f, -7.98860490e-02f, -1.00702390e-01f, 7.24455789e-02f, -1.04503157e-02f,
  -4.29347493e-02f, 2.82107964e-02f, 6.50550704e-03f, -5.74735589e-02f, -5.55357561e-02f, -2.02073734e-02f, -2.08487790e-02f, 1.34062255e-02f, 2.98741758e-02f, -3.13989893e-02f,
  -3.28030102e-02f, -2.05790531e-02f, -4.17221263e-02f, -7.58676529e-02f, -2.13829819e-02f, -7.94446841e-03f, 7.97966793e-02f, 1.05400205e-01f, 3.00188903e-02f, -1.70391705e-02f,
  4.65831272e-02f, 2.52634361e-02f, -6.86028600e-02f, 5.46987802e-02f, 2.22979370e-03f, -9.50041264e-02f, -5.12712970e-02f, -6.87961429e-02f, -1.11647192e-02f, -1.85173340e-02f,
  -1.18493669e-01f, 6.89063072e-02f, 6.66985735e-02f, 4.63752588e-03f, 1.61377154e-02f, 4.43274230e-02f, 4.95744310e-02f, -5.23390397e-02f, -5.76617830e-02f, -7.34697608e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.82682127e-01f, 1.56388640e-01f, 2.32432485e-01f, 1.73688531e-01f, 7.60234296e-02f, 1.83042601e-01f, 1.33577496e-01f, 1.21391073e-01f, 1.57957435e-01f, 3.59179944e-01f,
  1.62281170e-02f, 1.78461775e-01f, 1.95130646e-01f, 2.07999945e-01f, 2.48240337e-01f, 9.53688323e-02f, 1.78826720e-01f, 5.90023547e-02f, 2.99722493e-01f, 2.32014850e-01f,
  1.43195927e-01f, 1.94854021e-01f, 6.41129538e-02f, 6.40507042e-02f, 2.16368437e-01f, 8.08646977e-02f, 1.65235266e-01f, 9.52519849e-02f, 1.51890442e-01f, 1.89359542e-02f,
  -1.39021911e-02f, 2.94290394e-01f, 7.23531097e-02f, 1.49695024e-01f, 1.22935601e-01f, 1.60336092e-01f, 1.58279419e-01f, 2.96300352e-01f, 1.94458455e-01f, 1.36460081e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  2.12816577e-02f, -3.24670388e-03f, -1.79736778e-01f, -4.14444417e-01f, 1.47879366e-02f, 2.59920880e-02f, 1.03941206e-02f, -1.48878306e-01f, -1.74151614e-01f, -1.98041171e-01f,
  -1.01842042e-02f, 1.40482932e-01f, 2.44702280e-01f, -2.81302065e-01f, 2.62086242e-01f, 4.49126303e-01f, -2.73634344e-01f, 3.97677481e-01f, 2.28522077e-01f, 2.27074981e-01f,
  -3.24359775e-01f, -3.76650125e-01f, 3.51975203e-01f, -2.04939514e-01f, 4.37684730e-02f, -3.03696301e-02f, 3.03959429e-01f, -9.36227962e-02f, -1.98281869e-01f, 3.41639102e-01f,
  1.37214348e-01f, -4.26187553e-02f, -2.09073499e-01f, -2.75716066e-01f, -7.45442733e-02f, -1.95721105e-01f, -2.81232074e-02f, 1.73033461e-01f, -4.37321654e-03f, -5.82408085e-02f,
  -3.63894850e-01f, 1.28863961e-01f, -2.20386032e-02f, -2.15613917e-01f, -9.49557945e-02f, -1.86394632e-01f, 9.86561775e-01f, -1.87685378e-02f, 1.46838576e-01f, 2.61314303e-01f,
  1.07615851e-01f, -2.25000516e-01f, -1.21976614e-01f, -1.00057580e-01f, 8.69690776e-02f, -7.08796307e-02f, -7.98919499e-02f, 3.20652038e-01f, -1.87069714e-01f, -1.99207857e-01f,
  -1.90852314e-01f, 4.42680955e-01f, 1.90460365e-02f, -2.35088930e-01f, -1.53330952e-01f, -1.57046020e-01f, -4.35453296e-01f, -3.68629664e-01f, 1.54293105e-01f, 3.60721424e-02f,
  1.61355883e-01f, -1.77794769e-02f, 9.81325842e-03f, 4.90996987e-01f, -3.65594178e-01f, -3.89703393e-01f, -3.08462232e-01f, -4.84800696e-01f, 2.61014730e-01f, 1.66883975e-01f,
  6.59523547e-01f, -4.27788943e-02f, -3.68967205e-01f, 2.92099714e-01f, 4.31542158e-01f, -1.89862698e-01f, 4.78958249e-01f, -6.29721642e-01f, -1.50766239e-01f, 4.16070335e-02f,
  8.66709929e-03f, -2.27054693e-02f, -1.10421687e-01f, 2.01706335e-01f, 6.99442700e-02f, -4.97881435e-02f, 1.00506917e-01f, -1.79567039e-01f, -8.29849541e-02f, -1.33929491e-01f,
  1.57392055e-01f, -1.02370843e-01f, 4.08174433e-02f, -2.17058703e-01f, -8.53022560e-02f, -9.57990885e-02f, 3.57821345e-01f, 1.83587894e-01f, -2.80316740e-01f, 1.51087865e-01f,
  -7.91395158e-02f, -1.28893271e-01f, 1.82384308e-02f, 2.67793179e-01f, 3.33131671e-01f, 3.53762537e-01f, -3.15778315e-01f, 9.87471044e-02f, 3.37891519e-01f, 6.13562644e-01f,
  -1.20260194e-02f, -3.68593037e-01f, 2.33613536e-01f, -2.35758096e-01f, -1.90457672e-01f, 3.83042485e-01f, -1.56093866e-01f, -9.30231288e-02f, -4.59934808e-02f, -8.77771601e-02f,
  -1.15628399e-01f, -2.85206974e-01f, 8.06303695e-02f, 9.52162817e-02f, -1.71259921e-02f, 1.31796589e-02f, -1.40102461e-01f, -1.91170886e-01f, -7.39562064e-02f, 6.34632185e-02f,
  2.10470140e-01f, -1.46477863e-01f, 3.86926562e-01f, 4.52421665e-01f, 1.41379863e-01f, -1.39474034e-01f, -4.52288538e-01f, 2.32568070e-01f, -3.24552151e-04f, 3.88086319e-01f,
  1.54343754e-01f, 8.85510147e-02f, 1.17488755e-02f, -1.91383451e-01f, -1.78175703e-01f, 1.15406454e-01f, -2.30501547e-01f, -2.51407892e-01f, -2.55682111e-01f, -9.55076814e-02f,
  -2.36574069e-01f, 4.23793733e-01f, -1.64388552e-01f, -2.15468451e-01f, -1.65251702e-01f, -1.24562353e-01f, -2.57050544e-01f, -1.20163776e-01f, -2.01657325e-01f, -2.13445518e-02f,
  1.13773130e-01f, 6.54085457e-01f, -2.26836249e-01f, 7.34288990e-01f, -2.20753819e-01f, -1.24142408e-01f, 5.13013959e-01f, -4.75014932e-03f, -1.26756370e-01f, -2.94852182e-02f,
  2.18280986e-01f, -3.15595195e-02f, -1.01326413e-01f, 4.33132388e-02f, -2.68217996e-02f, -2.16835052e-01f, 6.39542937e-02f, -1.17293678e-01f, -2.48578042e-01f, -3.42278093e-01f,
  3.40244234e-01f, 1.01023331e-01f, -1.10128902e-01f, -5.44949651e-01f, 1.12359956e-01f, 1.28107920e-01f, 3.06182832e-01f, 1.35256723e-01f, 6.06969707e-02f, -5.31706363e-02f,
  -9.27159970e-04f, -2.04447389e-01f, 6.43164143e-02f, 3.35546061e-02f, 8.70280936e-02f, 4.53649253e-01f, -2.99046427e-01f, -2.05173135e-01f, 3.58651936e-01f, 8.34306329e-02f,
  -7.47246817e-02f, -2.03651100e-01f, -3.36381882e-01f, -3.26346815e-01f, 5.02633937e-02f, -1.43389925e-01f, -1.11329757e-01f, -8.08912143e-02f, -1.82216257e-01f, -1.58566479e-02f,
  -8.50452110e-02f, -3.00877124e-01f, -1.79867193e-01f, 7.19597995e-01f, -1.36158451e-01f, -2.58575529e-01f, -8.12459737e-02f, 4.01660465e-02f, -1.05886534e-02f, 2.42324710e-01f,
  -4.30178754e-02f, -1.10627525e-01f, -5.62217534e-02f, 3.75898741e-02f, -2.69429117e-01f, -2.09105119e-01f, -1.69286072e-01f, -5.80784567e-02f, -2.23739401e-01f, 3.10543329e-01f,
  2.92721614e-02f, -4.35575917e-02f, 1.67573132e-02f, -2.42692865e-02f, -1.60416529e-01f, -1.89816758e-01f, -1.36801213e-01f, -1.11105338e-01f, -1.23748276e-02f, 1.03391218e+00f,
  -1.20494753e-01f, 4.19219770e-02f, -1.90543815e-01f, 2.35372797e-01f, 1.16456389e-01f, -2.00194895e-01f, 3.05297226e-01f, 3.95343125e-01f, 3.20305340e-02f, 2.53423601e-01f,
  2.79381145e-02f, 1.87490657e-01f, 5.27875498e-02f, 1.57843515e-01f, 2.45661642e-02f, 1.54202729e-01f, 2.21535802e-01f, -1.12991616e-01f, 2.94169009e-01f, 5.81666589e-01f,
  1.29881471e-01f, 1.70360859e-02f, -6.69985831e-01f, -3.83195072e-01f, 4.75546002e-01f, -5.63555896e-01f, 1.95205167e-01f, -9.42645669e-02f, -3.16893309e-01f, 5.89528143e-01f,
  2.51222588e-02f, -1.16028272e-01f, 3.29987705e-01f, -4.65889722e-02f, 1.37423337e-01f, 7.77229574e-03f, -2.10296139e-01f, 3.13622952e-01f, -2.04701230e-01f, -5.37336588e-01f,
  3.17963809e-01f, 5.66756189e-01f, 2.77264118e-01f, 9.07421187e-02f, -7.24404454e-02f, -1.09100275e-01f, 4.72675025e-01f, 5.23859933e-02f, 5.63534677e-01f, -1.92196265e-01f,
  -2.25483373e-01f, -1.45849034e-01f, -8.44060481e-02f, -1.61481142e-01f, 5.24749458e-01f, -2.18895689e-01f, 4.09898721e-03f, -1.07584722e-01f, 1.17712498e-01f, -2.51072675e-01f,
  -1.21622987e-01f, -7.65639767e-02f, -1.68359980e-01f, -4.73639891e-02f, -3.26909095e-01f, 1.65744368e-02f, -2.67107248e-01f, 1.20347336e-01f, -9.02906805e-02f, -1.48122594e-01f,
  -3.00317854e-01f, 3.25093538e-01f, 4.30947244e-01f, 3.57466757e-01f, 1.65622652e-01f, -7.96065927e-02f, 9.01256967e-03f, 3.09839427e-01f, 3.73311117e-02f, 2.90317237e-01f,
  1.41128525e-01f, 1.65996298e-01f, -4.23654407e-01f, -2.28619963e-01f, 4.26484346e-01f, 1.02080688e-01f, -1.14354491e-01f, -1.71290487e-01f, -1.90309919e-02f, 2.33344778e-01f,
  -1.29224584e-01f, 2.95066424e-02f, -1.05855174e-01f, -3.49272430e-01f, 3.95971775e-01f, -2.14099750e-01f, 2.16969073e-01f, -1.55091077e-01f, 1.40384853e-01f, 3.36566627e-01f,
  3.77593726e-01f, -9.31491479e-02f, -5.43125868e-02f, -1.15403518e-01f, -4.24074754e-02f, 1.27928048e-01f, -2.96676874e-01f, -2.51084298e-01f, 2.62011856e-01f, -1.47149831e-01f,
  6.31526291e-01f, -1.00557603e-01f, -4.13370639e-01f, -2.69220352e-01f, 3.42985988e-01f, -2.68878758e-01f, 1.24598980e-01f, -1.29369453e-01f, -3.03299725e-01f, -3.97168770e-02f,
  -1.54977798e-01f, 5.06636739e-01f, -1.67551264e-01f, -1.87618788e-02f, 4.51934710e-02f, 3.29251111e-01f, -7.84342289e-02f, -2.29419485e-01f, -1.63632333e-01f, 3.81633073e-01f,
  1.01063386e-01f, 1.09373458e-01f, -2.87938476e-01f, 5.32710850e-02f, 1.07118241e-01f, 1.53587207e-01f, 2.00926155e-01f, 8.50759223e-02f, -5.19125536e-03f, -4.32666600e-01f,
  1.55159116e-01f, 8.66629258e-02f, 1.15799442e-01f, -2.72736698e-01f, 8.11312422e-02f, 1.80299878e-01f, 1.41019542e-02f, 1.47973925e-01f, -4.82641011e-01f, 1.82437256e-01f,
  -1.87884659e-01f, -5.12004733e-01f, 3.93200815e-01f, 1.60035744e-01f, -3.11630368e-01f, 4.54177856e-01f, -4.15047072e-02f, -2.44617695e-03f, -2.65842348e-01f, -1.71888500e-01f,
  -1.75606295e-01f, -2.07138047e-01f, 2.91458219e-01f, 3.00750166e-01f, 2.18648285e-01f, -2.31319919e-01f, 2.25738063e-02f, 1.09874785e+00f, 1.17685430e-01f, -2.19876096e-01f,
  -2.06726581e-01f, 1.99470017e-02f, -2.64873117e-01f, 3.86840761e-01f, 8.54626745e-02f, -1.98320970e-01f, -7.90175200e-02f, -3.24782997e-01f, -1.57742143e-01f, -3.87628749e-02f,
  -3.09862256e-01f, 2.14560241e-01f, -2.63113260e-01f, -1.02139466e-01f, -1.80721492e-01f, 4.13206033e-02f, 2.42794231e-01f, -1.73782468e-01f, -1.37892389e-03f, -6.73913360e-02f,
  1.26441538e-01f, -2.25271598e-01f, 1.91511437e-01f, -1.07327253e-01f, -3.54369655e-02f, -2.39474297e-01f, -8.10106322e-02f, 1.70369908e-01f, -2.14508101e-01f, 3.53433006e-02f,
  -3.62709016e-02f, -1.53517321e-01f, -1.44890547e-01f, -1.15527585e-01f, -1.06734343e-01f, 2.06140000e-02f, -9.83600244e-02f, -2.19170913e-01f, -3.85104418e-01f, -2.56411374e-01f,
  3.34871769e-01f, -3.23431551e-01f, -1.88262403e-01f, -3.24209571e-01f, -2.94867158e-01f, 3.57412249e-01f, -6.36476651e-02f, 1.70489475e-01f, 4.93608490e-02f, -1.49791881e-01f,
  -3.59153718e-01f, 3.76751244e-01f, 1.73240721e-01f, -1.86155230e-01f, 9.48683470e-02f, 1.70329168e-01f, -9.65149775e-02f, -9.77366716e-02f, -1.24795385e-01f, 3.22502971e-01f,
  3.92120361e-01f, -2.36016512e-01f, -1.66474417e-01f, 3.72769475e-01f, 1.25319541e-01f, -2.10306406e-01f, -1.09010637e-01f, 3.39932621e-01f, -6.65482506e-02f, 9.99515206e-02f,
  -2.53860623e-01f, -1.75497115e-01f, -1.64390102e-01f, 6.80393428e-02f, -1.66679025e-01f, 1.38304621e-01f, -3.59432697e-02f, -1.69657871e-01f, 2.82877143e-02f, -1.26544520e-01f,
  -1.82060018e-01f, 5.31259418e-01f, 6.56670425e-03f, -1.48183912e-01f, 3.04614872e-01f, 3.95966142e-01f, -5.00888824e-02f, 6.68385252e-02f, -1.35380000e-01f, -1.57560289e-01f,
  -1.18690573e-01f, 4.02690232e-01f, -1.81285918e-01f, 4.03528437e-02f, 1.58992037e-01f, -2.35187728e-03f, -3.58785659e-01f, 7.08956718e-02f, -2.55833566e-01f, -1.02642529e-01f,
  -1.16598554e-01f, -1.35437191e-01f, -1.26354368e-02f, 2.47192495e-02f, -2.73506790e-01f, 4.80197296e-02f, 4.24235426e-02f, -2.29491279e-01f, 4.14501518e-01f, 2.13172406e-01f,
  -1.31389350e-01f, -2.41940662e-01f, -2.05300212e-01f, 3.15360934e-01f, -1.87446490e-01f, 2.08205447e-01f, -3.92568223e-02f, -1.85040712e-01f, -2.32758611e-01f, -2.61428148e-01f,
  -1.55788049e-01f, -1.55829519e-01f, 3.81020814e-01f, -1.52221337e-01f, 4.02688771e-01f, -8.21067020e-03f, 3.89301777e-02f, -2.02497080e-01f, 5.96032031e-02f, -4.02807351e-03f,
  -8.73315111e-02f, -1.03637256e-01f, -9.75032002e-02f, -1.16821535e-01f, 4.42475349e-01f, 2.66847223e-01f, 5.15212357e-01f, 4.39278930e-01f, -1.13217264e-01f, 2.51463596e-02f,
  -2.13514388e-01f, 7.69009739e-02f, 5.71000457e-01f, -5.78090958e-02f, 1.20338574e-01f, -9.64617059e-02f, 3.61214913e-02f, -3.27103108e-01f, -1.44944862e-01f, -6.05906732e-02f,
  -2.40200847e-01f, -1.55978858e-01f, 3.25447559e-01f, -2.09742859e-01f, -2.48462483e-02f, -1.61402985e-01f, 1.39415577e-01f, 4.64036055e-02f, 2.83953398e-01f, 2.02227503e-01f,
  -1.32261425e-01f, 3.09279740e-01f, -3.40234965e-01f, 2.20229588e-02f, 1.18679121e-01f, -1.82770059e-01f, -3.67372180e-04f, 9.82216522e-02f, -2.18598023e-01f, -2.95634419e-01f,
  3.69304232e-02f, -6.80002421e-02f, -5.91317832e-01f, 2.44200021e-01f, 5.09544015e-01f, 1.36893392e-01f, 4.09262896e-01f, 6.38531625e-01f, -3.29643160e-01f, 3.66451651e-01f,
  -1.97587729e-01f, 1.35286510e-01f, 4.65258598e-01f, 3.64306659e-01f, 2.81899244e-01f, -2.86343426e-01f, -2.71963388e-01f, -2.88602591e-01f, -1.23895004e-01f, 1.90940365e-01f,
  1.77141637e-01f, -2.04660296e-02f, 6.49727285e-01f, -6.98701590e-02f, -2.89985269e-01f, -1.98301330e-01f, -2.10881695e-01f, -5.96807227e-02f, 1.46429101e-02f, 1.99825957e-01f,
  4.34738211e-02f, -3.25028151e-01f, -3.65400538e-02f, -1.87116593e-01f, -2.19494909e-01f, 2.52841920e-01f, -1.87163219e-01f, -1.36989951e-01f, -6.58091456e-02f, -7.28438720e-02f,
  -1.39221177e-01f, -1.04561135e-01f, 2.91372329e-01f, -1.73372790e-01f, 5.52575886e-01f, 1.33303583e-01f, -1.91315591e-01f, -2.91029930e-01f, -1.06622698e-02f, 2.89239921e-02f,
  2.17057317e-01f, 1.65426865e-01f, 2.15355560e-01f, 1.30604208e-01f, -2.49116763e-01f, 4.54908684e-02f, 2.26940423e-01f, 2.36949831e-01f, -3.13942917e-02f, 1.65045992e-01f,
  -1.06646186e-02f, -2.43702739e-01f, 9.52815861e-02f, 5.01014471e-01f, -2.19730139e-01f, -5.34148514e-01f, 5.17574191e-01f, 3.28310728e-01f, 5.17747290e-02f, 1.32826075e-01f,
  3.37755173e-01f, -1.70446530e-01f, 2.58880377e-01f, -6.13704562e-01f, 8.09773058e-02f, 5.06978631e-01f, -1.15837745e-01f, 2.05416307e-01f, -1.05701119e-01f, -1.42394245e-01f,
  -1.43434659e-01f, -1.64704621e-01f, -1.84954643e-01f, -2.07262993e-01f, -1.11747041e-01f, -1.75513223e-01f, -2.28622347e-01f, 1.86597258e-01f, -6.52517453e-02f, -9.62243527e-02f,
  -1.22784786e-01f, 3.47687542e-01f, -3.27909350e-01f, 1.42866135e-01f, -8.50964114e-02f, -8.43137205e-02f, -1.58118650e-01f, 2.38722190e-01f, -2.14633048e-02f, -1.52903646e-01f,
  -1.14500836e-01f, -7.31065944e-02f, 5.31302691e-01f, 1.02103762e-01f, -9.85362381e-02f, 1.64593711e-01f, -1.82545513e-01f, 1.71389524e-02f, -1.53735176e-01f, 6.44459156e-03f,
  1.46346651e-02f, -1.76302299e-01f, 7.28796124e-01f, -1.96596548e-01f, 1.48360968e-01f, -2.72160709e-01f, -2.92802393e-01f, 1.29120529e-01f, 2.48881504e-01f, 1.49386555e-01f,
  -4.86698709e-02f, -1.16451629e-01f, 5.42596541e-02f, 2.89538115e-01f, 1.06669620e-01f, 1.59658194e-01f, -2.34137118e-01f, 4.67455953e-01f, -4.67737675e-01f, -4.58010249e-02f,
  2.38188535e-01f, -2.24334672e-01f, -1.40819699e-01f, -4.19549853e-01f, -3.74820739e-01f, -1.25206038e-01f, -7.44057298e-02f, 2.60713696e-01f, -1.17567562e-01f, 2.00777594e-02f,
  -1.61516517e-01f, -2.88902260e-02f, 1.17980078e-01f, -2.83937842e-01f, -5.99239171e-02f, -1.97987154e-01f, 2.49845739e-02f, -4.26049419e-02f, 1.30775660e-01f, 1.05828278e-01f,
  3.69406752e-02f, 4.54518914e-01f, 8.13021839e-01f, -1.23322606e-01f, 2.41883751e-03f, -3.60927247e-02f, -2.79386103e-01f, -1.17280945e-01f, 1.89864915e-02f, -1.41831353e-01f,
  3.93033586e-02f, 1.31147169e-03f, -1.32675245e-01f, 5.00040725e-02f, -2.39308476e-01f, -2.01827094e-01f, -1.30715907e-01f, 2.67213166e-01f, 6.80151805e-02f, -2.78673083e-01f,
  2.13768274e-01f, -3.35501909e-01f, -2.02263236e-01f, 1.81938902e-01f, 7.25557089e-01f, -3.05978060e-01f, -1.63971052e-01f, 6.40905946e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.70049846e-01f, -4.10983339e-02f, -6.35467246e-02f, -1.30073369e-01f, 1.93327054e-01f, 6.27774894e-02f, -2.66488977e-02f, -1.49507388e-01f, -2.06999943e-01f, 1.37913674e-02f,
  -1.53360190e-02f, 6.71641901e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    