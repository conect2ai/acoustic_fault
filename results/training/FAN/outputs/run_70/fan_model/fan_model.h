/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.97366333e-01f, 4.84864116e-02f, -1.07480191e-01f, -4.91227210e-02f, -1.02874234e-01f, -3.14807668e-02f, 1.23773806e-01f, -1.36557072e-01f, 1.92421064e-01f, -9.59994420e-02f,
  -2.39341348e-01f, 5.18088788e-02f, -4.85493615e-02f, -2.26825342e-01f, 1.65661126e-01f, 1.08988084e-01f, -9.54685807e-02f, -4.05629352e-02f, 5.88882864e-02f, -4.49828282e-02f,
  1.19130604e-01f, -2.69180626e-01f, 3.88558917e-02f, -5.74864484e-02f, -3.62470075e-02f, 3.04830708e-02f, -1.63890913e-01f, 8.87572244e-02f, -1.59249961e-01f, 6.80789677e-03f,
  7.30319768e-02f, 7.77158961e-02f, -6.20999224e-02f, 4.29484025e-02f, -1.81754008e-02f, -1.62601359e-02f, 4.36200909e-02f, -5.54826669e-02f, 6.46277443e-02f, -2.46269275e-02f,
  4.22712322e-03f, -1.06127992e-01f, -8.56757388e-02f, 6.20400198e-02f, 4.74591479e-02f, -6.13682456e-02f, 4.02726680e-02f, 2.56473944e-03f, -2.85128839e-02f, 8.79096985e-02f,
  -4.00183909e-02f, -7.86877871e-02f, -2.55250316e-02f, -2.77074333e-02f, 1.52226407e-02f, -3.11807264e-02f, 1.42972926e-02f, -5.86317256e-02f, 4.02838923e-02f, 4.52374369e-02f,
  2.95322519e-02f, 3.16036157e-02f, 3.72107071e-03f, -6.33084029e-02f, 9.21447650e-02f, -4.40568253e-02f, 2.98103411e-02f, -6.98976219e-04f, 1.01202600e-01f, 5.17230434e-03f,
  -9.64761227e-02f, 1.85411144e-02f, -7.49386996e-02f, -3.79701960e-03f, -3.20396125e-02f, 4.93142940e-02f, -1.54905524e-02f, -2.88236160e-02f, 3.34408358e-02f, -7.30690267e-03f,
  -5.11840470e-02f, -3.79743986e-02f, 1.15266535e-02f, -8.94547999e-02f, 1.26676145e-03f, 2.54238322e-02f, -5.97018600e-02f, 6.94383606e-02f, -2.45406851e-02f, 3.83741148e-02f,
  2.65423149e-01f, 2.37426817e-01f, 2.62307506e-02f, -2.62077525e-02f, 2.46142950e-02f, 4.71917763e-02f, -2.03404482e-02f, 1.79729741e-02f, 4.70177345e-02f, 1.27052769e-01f,
  -7.31756212e-03f, -2.65419129e-02f, -5.25632910e-02f, -8.31260905e-03f, -1.82777978e-02f, -1.88332573e-02f, 4.88459915e-02f, 3.06015424e-02f, 3.88811273e-03f, -3.70920287e-03f,
  -6.61334842e-02f, -1.30843362e-02f, 3.75242382e-02f, -1.16983363e-02f, -4.64373492e-02f, -8.07392132e-03f, 6.34933189e-02f, 3.11873071e-02f, -3.37243229e-02f, -5.95087372e-02f,
  -3.83448035e-01f, 3.60002160e-01f, 9.27863568e-02f, -1.67898104e-01f, -4.19011831e-01f, 5.17116189e-02f, -1.34107754e-01f, -8.59590918e-02f, 1.40206456e-01f, 1.82579741e-01f,
  -7.21154884e-02f, -6.19598068e-02f, 2.01735616e-01f, -1.36469036e-01f, -1.04186073e-01f, 3.32012355e-01f, -5.66470847e-02f, -1.95231903e-02f, 1.04110144e-01f, -1.12441201e-02f,
  -6.51478618e-02f, -1.54270232e-01f, 2.62208413e-02f, 2.91164778e-02f, -2.36883625e-01f, -4.37616110e-02f, -3.21669839e-02f, 1.08105771e-01f, -7.81235844e-02f, -3.73745970e-02f,
  -6.83727413e-02f, 4.70515452e-02f, -1.36059046e-01f, 6.96277171e-02f, 6.80367183e-03f, -1.60835564e-01f, -1.02586843e-01f, -1.23997942e-01f, -7.39384890e-02f, 6.91937357e-02f,
  -4.82653566e-02f, -5.27894422e-02f, -5.62829785e-02f, 3.68371606e-02f, -1.57674346e-02f, 2.78532133e-02f, 5.24717979e-02f, 2.59736031e-02f, 2.56918892e-02f, -4.81529310e-02f,
  1.80850681e-02f, 6.70630932e-02f, -2.58610323e-02f, 1.33192599e-01f, -9.52939019e-02f, -5.33852838e-02f, 1.50926830e-02f, -3.57237197e-02f, -1.05496347e-02f, 6.03650250e-02f,
  -1.57261044e-02f, -9.80416499e-03f, 3.27609740e-02f, -5.26397415e-02f, 1.11269712e-01f, -2.78582275e-02f, 1.15192771e-01f, 1.16767094e-01f, 3.58341150e-02f, 3.20633911e-02f,
  -2.35514622e-02f, -6.46562055e-02f, 9.08508450e-02f, -9.09903552e-03f, -9.12842602e-02f, -1.11954875e-01f, -6.01886660e-02f, -4.81949300e-02f, -9.76539403e-03f, -8.79565924e-02f,
  8.89295116e-02f, -4.44414763e-05f, -2.64250822e-02f, -7.70192966e-02f, 7.64077380e-02f, -7.24640563e-02f, 6.80626035e-02f, 7.13324919e-02f, -4.07006256e-02f, -4.43269731e-03f,
  1.57338113e-01f, 2.83246547e-01f, 5.23402877e-02f, -9.77800936e-02f, 1.41559824e-01f, 1.38949165e-02f, 1.75532531e-02f, -4.45477702e-02f, 1.14449821e-01f, -7.37572238e-02f,
  -1.37090161e-01f, -7.84363504e-03f, 1.22015633e-01f, -2.85491925e-02f, 1.12288306e-02f, -1.80017706e-02f, -3.25142294e-02f, -5.18879704e-02f, -6.54525757e-02f, -2.61504552e-03f,
  -1.06662609e-01f, 9.02921613e-03f, 1.55844530e-02f, -1.61567345e-01f, -1.00205839e-01f, -3.40236239e-02f, -4.42511955e-04f, 6.22487068e-02f, 1.03347734e-01f, 8.90879855e-02f,
  2.30829388e-01f, -2.31302395e-01f, -1.36910796e-01f, 1.10810153e-01f, -1.60778090e-01f, 1.94384366e-01f, 3.29953223e-03f, -1.51441276e-01f, 1.86061814e-01f, -5.43527156e-02f,
  7.05478042e-02f, 1.28408700e-01f, 1.80148572e-01f, 4.23376188e-02f, 5.06655931e-01f, 2.31883734e-01f, 1.39545903e-01f, 1.86400086e-01f, 1.86198831e-01f, 4.51539531e-02f,
  6.69627916e-03f, 1.50479361e-01f, -2.03112334e-01f, -1.95447564e-01f, -2.76764184e-01f, -3.69166642e-01f, -1.03434078e-01f, -5.52500561e-02f, -2.41746128e-01f, 8.23908672e-02f,
  -1.15498744e-01f, -6.99429139e-02f, -1.93507433e-01f, -3.14103775e-02f, -3.15114893e-02f, -6.42400682e-02f, -1.33693926e-02f, 4.05159267e-03f, 1.37657989e-02f, 1.94253549e-02f,
  3.63465212e-02f, 6.66648597e-02f, 6.36890531e-02f, -9.90938768e-03f, -1.37604056e-05f, -2.61072908e-03f, 4.88921180e-02f, -3.13583575e-02f, -5.54214194e-02f, 5.94841084e-03f,
  3.30799557e-02f, 8.40629917e-03f, 3.37897204e-02f, 1.01312488e-01f, -4.66326214e-02f, 6.25258386e-02f, -4.97320034e-02f, -5.27442200e-03f, 2.09673326e-02f, 7.01766536e-02f,
  4.03491259e-02f, 7.80539354e-03f, 1.99644323e-02f, -3.83728482e-02f, 1.04403012e-01f, 5.50059006e-02f, 7.70504922e-02f, 4.68168147e-02f, 7.65486658e-02f, 8.26727599e-02f,
  -4.70078066e-02f, -5.55561520e-02f, 3.70624736e-02f, -3.33591141e-02f, 4.82586063e-02f, -1.08241566e-01f, 2.18337793e-02f, -1.59356631e-02f, 7.12748198e-03f, -1.50307283e-01f,
  -4.64999042e-02f, 1.21395420e-02f, -9.00885761e-02f, -9.18108523e-02f, 5.24816848e-02f, 2.26618182e-02f, 2.21944861e-02f, -1.19371891e-01f, -2.78827995e-02f, -1.70792900e-02f,
  2.15330809e-01f, 1.68471396e-01f, -2.82939877e-02f, -2.14857310e-02f, 4.27939147e-02f, 8.48631114e-02f, -1.68093294e-02f, -6.35869876e-02f, -1.63214058e-02f, -8.06133542e-03f,
  -8.19091946e-02f, -7.71667510e-02f, 1.26134843e-01f, -2.27424875e-02f, -8.55727121e-03f, -1.33325113e-02f, -2.72142910e-03f, -6.41629845e-02f, -2.58434601e-02f, -1.65532473e-02f,
  -7.32471794e-02f, 8.68268833e-02f, 4.19290885e-02f, -1.43740267e-01f, -1.13845980e-02f, -4.14204150e-02f, 6.98194504e-02f, 2.75961142e-02f, -2.38226843e-03f, 4.99289706e-02f,
  -3.85116965e-01f, 5.03989756e-01f, -3.65340650e-01f, 1.46386713e-01f, -1.64548680e-01f, 3.13785166e-01f, 1.80322900e-02f, 3.04366555e-02f, 7.59631172e-02f, 1.84650019e-01f,
  2.51077432e-02f, -1.17586620e-01f, -5.34952469e-02f, 2.13956326e-01f, -1.51316956e-01f, 9.04666707e-02f, 1.72653630e-01f, -4.84816469e-02f, 1.74229339e-01f, 1.67877212e-01f,
  -1.63684964e-01f, 2.35138819e-01f, -2.90011764e-01f, 1.17155299e-01f, -3.20474133e-02f, -5.24513721e-02f, -1.22681946e-01f, -7.06372736e-03f, -3.83503661e-02f, -6.68671578e-02f,
  7.78024122e-02f, -1.86349377e-01f, -1.13289505e-01f, -4.30582426e-02f, -3.02832574e-02f, -1.39074862e-01f, -3.71288583e-02f, 3.05239372e-02f, 6.59419820e-02f, 1.55174658e-02f,
  -5.44138392e-03f, 2.76857987e-02f, -1.33646391e-02f, 2.64883563e-02f, 5.86834438e-02f, 9.06457193e-03f, 6.75878152e-02f, 6.84912428e-02f, 1.30206689e-01f, -7.41147622e-02f,
  1.56766437e-02f, 3.98942120e-02f, -3.91100943e-02f, 2.24040784e-02f, -7.92843848e-02f, 7.64286742e-02f, -3.58766429e-02f, -7.84387365e-02f, 2.07938906e-02f, -3.07496004e-02f,
  -1.13479100e-01f, -2.93173417e-02f, 2.87888329e-02f, 1.09383442e-01f, 6.01440780e-02f, -3.91839147e-02f, -3.51025560e-03f, -3.39681767e-02f, 5.93972541e-02f, 1.36696324e-01f,
  3.97914685e-02f, 1.15362950e-01f, 8.85369405e-02f, 5.02412468e-02f, 3.71263884e-02f, 6.10762611e-02f, -3.51242125e-02f, 2.64966208e-02f, 1.46819592e-01f, 1.04905441e-01f,
  -8.24971497e-02f, -3.69688645e-02f, 1.47281095e-01f, -1.45558752e-02f, 5.15493266e-02f, 2.11039130e-02f, -1.12863876e-01f, 1.02352738e-01f, 5.17720506e-02f, -9.15682167e-02f,
  3.38624157e-02f, -9.71878245e-02f, 4.04609703e-02f, 7.91843086e-02f, 3.08390707e-02f, 1.27385572e-01f, 1.26366168e-01f, 1.04219966e-01f, 1.05005443e-01f, 3.38302739e-02f,
  -7.02243159e-03f, -1.15843773e-01f, -4.85480092e-02f, 2.55931560e-02f, 5.78133389e-03f, 1.06288008e-02f, -6.13398664e-02f, 4.99517135e-02f, -1.96570843e-01f, 6.75216839e-02f,
  -7.29177967e-02f, -1.15328487e-02f, 5.60653061e-02f, 7.71612376e-02f, -6.08093366e-02f, -9.40414146e-02f, -2.00000461e-02f, 2.48748176e-02f, -9.30309072e-02f, -5.70316352e-02f,
  2.49142617e-01f, -7.08545744e-02f, 3.75484735e-01f, -1.97953701e-01f, 7.13298991e-02f, -1.90709397e-01f, -9.23822671e-02f, -2.47122765e-01f, -1.73989117e-01f, -2.74129540e-01f,
  -1.00489274e-01f, 8.62933099e-02f, 4.42449935e-02f, -5.02312243e-01f, 3.61688389e-03f, -2.65105031e-02f, -3.32874507e-01f, -9.03587639e-02f, -4.67311172e-03f, -1.50451660e-01f,
  -1.26793785e-02f, -3.17524999e-01f, 1.72734439e-01f, -2.40961805e-01f, -2.98781861e-02f, 1.71298310e-01f, 5.90648279e-02f, 2.54032880e-01f, -2.30885297e-01f, -4.07015756e-02f,
  -5.02126813e-02f, 1.12040462e-02f, 6.18520416e-02f, 1.90293975e-02f, 2.74428520e-02f, 6.42859191e-02f, 9.47877094e-02f, 1.06775463e-01f, -3.73527501e-03f, -6.13971315e-02f,
  7.15479180e-02f, -7.69900531e-03f, -4.52993400e-02f, -3.47673073e-02f, -1.04722075e-01f, 8.49234313e-03f, -5.70264421e-02f, -1.33097097e-02f, -6.69800937e-02f, 9.02448893e-02f,
  7.93025196e-02f, -4.75580283e-02f, -9.14505348e-02f, -1.12285160e-01f, 3.25533859e-02f, -5.73772676e-02f, -1.46707008e-02f, 9.88618284e-02f, 2.97493096e-02f, -7.36162439e-02f,
  -6.01194315e-02f, -3.21663134e-02f, 6.81875795e-02f, -8.86755902e-03f, 6.63268492e-02f, 2.36692131e-02f, -1.62247360e-01f, -9.05732159e-03f, 5.13732806e-02f, -8.34994763e-02f,
  -1.26051039e-01f, -1.49007943e-02f, -4.65383939e-02f, -4.43800464e-02f, -2.06243601e-02f, -5.41607104e-02f, 4.44669388e-02f, -3.39725241e-02f, 3.68213169e-02f, 3.06900460e-02f,
  -3.58595140e-02f, -3.86854708e-02f, 2.64447611e-02f, 8.32970887e-02f, -1.23283684e-01f, 4.34900969e-02f, -1.43719718e-01f, 9.07589570e-02f, -4.60320525e-03f, 1.52584851e-01f,
  -1.69802055e-01f, -8.37352201e-02f, -3.87627445e-02f, -3.09922080e-02f, -3.78262177e-02f, 7.08298981e-02f, -3.72878946e-02f, -5.89650795e-02f, 6.78098053e-02f, -6.87058456e-03f,
  2.34485175e-02f, -9.00726914e-02f, -1.33012226e-02f, -1.36640593e-01f, -1.17931105e-01f, -2.66728038e-03f, 8.63885209e-02f, 1.75395980e-02f, -3.47244255e-02f, -5.06009348e-02f,
  -6.73625916e-02f, 1.81078929e-02f, 1.03472687e-01f, 5.65938130e-02f, -1.03184357e-01f, 4.30753268e-02f, 1.98099017e-02f, 4.51866053e-02f, 1.63182542e-02f, 7.57854141e-04f,
  5.50079525e-01f, 5.17487936e-02f, -9.63052362e-02f, 3.34515721e-01f, 1.12041056e-01f, 3.63684818e-02f, 6.23090938e-02f, 2.95241058e-01f, 2.06770808e-01f, 1.54010072e-01f,
  1.00323901e-01f, -9.67604946e-03f, -1.79281056e-01f, -3.98647860e-02f, -3.48405600e-01f, -1.62385613e-01f, 1.08975768e-01f, 9.66833755e-02f, -9.17293057e-02f, 2.77474076e-01f,
  1.37817949e-01f, -2.20539011e-02f, -6.44831806e-02f, -8.09885263e-02f, 1.32754758e-01f, 2.04436362e-01f, -1.09866850e-01f, -1.77702874e-01f, -3.68922576e-02f, -1.53409094e-01f,
  -3.51025611e-02f, 2.06391379e-01f, -4.01485860e-02f, -3.82500701e-02f, 9.06359032e-02f, -2.91380286e-02f, 3.88318412e-02f, -2.35235080e-01f, -5.73282018e-02f, -4.69391271e-02f,
  -9.17297415e-03f, 1.16232008e-01f, 1.88930482e-02f, -1.80798508e-02f, 4.96364608e-02f, 8.08910877e-02f, -9.04042944e-02f, 2.20749117e-02f, -3.15934345e-02f, 3.66633497e-02f,
  -9.17331968e-03f, 8.07803008e-04f, -8.08631182e-02f, 7.94529989e-02f, -5.71724959e-02f, 5.25835566e-02f, 1.77128091e-02f, -4.63720262e-02f, 8.61831456e-02f, 3.33841033e-02f,
  -7.34859407e-02f, 1.31308371e-02f, -1.45652503e-01f, 6.06591441e-03f, 5.09651704e-03f, -1.15682455e-02f, -8.13125744e-02f, -6.02162704e-02f, -2.00977355e-01f, 9.38914269e-02f,
  1.48688167e-01f, 6.79257885e-02f, 2.21490078e-02f, -5.05691282e-02f, -4.55261022e-02f, 2.32546907e-02f, -1.62595622e-02f, 2.43818443e-02f, 7.19093606e-02f, 5.83409518e-02f,
  1.55423693e-02f, 7.00143119e-03f, 2.74434313e-02f, 5.31584173e-02f, 6.57132864e-02f, -2.14687988e-01f, 1.06893837e-01f, 2.57441420e-02f, 8.75747278e-02f, -6.22367896e-02f,
  1.88861296e-01f, 2.69687593e-01f, -4.39414233e-02f, 7.73986951e-02f, -4.73739952e-02f, -1.09721228e-01f, -1.69799641e-01f, 5.15659824e-02f, -9.70150307e-02f, -2.21136473e-02f,
  -1.62954666e-02f, 8.94354433e-02f, 1.07584283e-01f, 8.60037133e-02f, -5.17173111e-02f, 8.01527426e-02f, 4.58189696e-02f, -5.88679127e-03f, 5.06650805e-02f, 3.69306542e-02f,
  1.33063525e-01f, -8.81154910e-02f, -1.54882893e-01f, 1.34321779e-01f, -3.69503498e-02f, -9.57884546e-03f, 1.30691558e-01f, -4.42212932e-02f, -1.43169969e-01f, 2.81323977e-02f,
  -6.48574531e-01f, -3.41756701e-01f, -2.88837850e-01f, -3.98744047e-01f, -6.18793592e-02f, -2.35692725e-01f, -3.34459841e-01f, -1.76211372e-02f, -2.30913728e-01f, 3.56746428e-02f,
  6.70727864e-02f, -2.71545321e-01f, 1.83110803e-01f, -3.32386494e-01f, -2.56878048e-01f, -5.39547242e-02f, -3.47264618e-01f, -6.61103055e-02f, 5.60996011e-02f, -9.79302377e-02f,
  -1.68859348e-01f, -1.45522177e-01f, -9.54187736e-02f, 1.06679939e-01f, -2.26617396e-01f, 6.22940920e-02f, -1.59212351e-02f, 7.27261230e-02f, -3.79899554e-02f, -8.05392936e-02f,
  9.11944509e-02f, 3.98833565e-02f, -1.51963942e-02f, 1.50466280e-03f, -3.84051278e-02f, -5.31905750e-03f, -3.96904796e-02f, -6.17346801e-02f, -7.50101777e-03f, -1.58502106e-02f,
  -1.20372139e-01f, -1.51280658e-02f, 7.87561573e-03f, -6.93803802e-02f, -1.22870207e-01f, -4.93032336e-02f, -6.61677867e-02f, -5.02873883e-02f, -2.17492934e-02f, -6.90266639e-02f,
  1.45789767e-02f, 1.02453157e-02f, -4.50665765e-02f, 6.66528121e-02f, 1.01754926e-01f, -9.59428027e-03f, 5.90614863e-02f, 3.47441994e-02f, -1.59229171e-02f, 7.37569586e-04f,
  -1.07101418e-01f, -1.72082949e-02f, -5.90492971e-02f, -4.63694520e-02f, -5.29403016e-02f, 9.86330062e-02f, 7.10176118e-03f, 1.87734459e-02f, 2.92187044e-03f, -1.00308359e-01f,
  -3.98715697e-02f, -3.35396528e-02f, -9.89202484e-02f, 3.38231621e-04f, -1.00099459e-01f, -1.39625007e-02f, -1.03257768e-01f, 4.39701527e-02f, -1.11866660e-01f, -4.09407653e-02f,
  -3.74599621e-02f, -6.75888509e-02f, 3.42892893e-02f, -2.67946459e-02f, -9.42344777e-03f, -9.41899512e-03f, 1.19812007e-03f, -1.35565370e-01f, 1.41446795e-02f, -8.60750228e-02f,
  -1.26204133e-01f, -7.27568641e-02f, 4.00146842e-02f, 7.82866105e-02f, 2.14280263e-02f, -6.53313920e-02f, -3.56376171e-02f, -1.50717134e-02f, -2.95848981e-03f, -4.02334668e-02f,
  2.72778305e-03f, 3.27387489e-02f, 5.92783689e-02f, 1.66131798e-02f, 2.11296733e-02f, -4.35541719e-02f, 5.42970710e-02f, -1.05272895e-02f, -6.18475862e-02f, -2.75151688e-03f,
  -5.24063446e-02f, 9.71450955e-02f, -1.36004575e-03f, 2.16565449e-02f, 6.51757270e-02f, 6.24176450e-02f, -3.47003601e-02f, -1.82639062e-02f, 2.27677468e-02f, -3.47347446e-02f,
  -2.90546328e-01f, -6.57937229e-02f, 7.20376968e-02f, -2.75068611e-01f, -1.58597574e-01f, 2.03016907e-01f, 3.04027259e-01f, -1.92233026e-01f, -4.43966359e-01f, 8.28712620e-03f,
  2.52571353e-03f, -9.87340659e-02f, 1.77923545e-01f, 8.09414461e-02f, 4.15727407e-01f, 1.87002957e-01f, 2.27794603e-01f, -4.35399376e-02f, -3.99511047e-02f, 3.70518342e-02f,
  -7.55940378e-02f, 9.27740149e-03f, 2.52864182e-01f, -6.03320263e-02f, -7.66170472e-02f, -1.26875982e-01f, 1.05763981e-02f, 3.95053104e-02f, 1.08290322e-01f, 8.00173879e-02f,
  1.92491636e-01f, -1.95078388e-01f, -4.65154946e-02f, 1.88913960e-02f, -6.84496611e-02f, 7.04256371e-02f, 2.18346149e-01f, 1.78293914e-01f, -2.62261257e-02f, -3.57409730e-03f,
  2.65656598e-02f, 1.23473726e-01f, -9.97943059e-02f, -2.29012556e-02f, -1.27732202e-01f, 3.95751279e-03f, -1.02572232e-01f, 3.00985686e-02f, 8.80109966e-02f, -4.11005616e-02f,
  -2.03264449e-02f, -4.00907584e-02f, -1.36591777e-01f, 7.34292120e-02f, -2.87270341e-02f, -7.27184117e-02f, -2.32428592e-03f, 1.23600654e-01f, 3.34787443e-02f, -1.66534439e-01f,
  -5.60372919e-02f, -8.91554579e-02f, 4.87350039e-02f, -1.98603328e-02f, 3.88243161e-02f, -2.70038266e-02f, -2.47727451e-03f, 5.64514138e-02f, -1.78205147e-01f, -4.49129008e-03f,
  -4.16747071e-02f, 1.78422369e-02f, -4.16802354e-02f, -9.58055556e-02f, -5.56699075e-02f, -1.40185934e-03f, 4.16531265e-02f, 4.67332043e-02f, -6.88481480e-02f, 1.39500923e-03f,
  6.83408380e-02f, 6.73826635e-02f, -6.41444251e-02f, 6.11976162e-02f, 1.20680913e-01f, -1.44133240e-03f, -6.14054762e-02f, 3.35238911e-02f, 1.55754220e-02f, 1.25577256e-01f,
  6.01959124e-04f, -6.47123344e-03f, -8.18864778e-02f, -7.56392023e-03f, -4.93168309e-02f, -3.81446481e-02f, -5.31334542e-02f, -7.07078129e-02f, -6.90551624e-02f, -3.35483439e-02f,
  -6.34098751e-03f, -5.75286299e-02f, 6.87304884e-02f, -1.86925486e-03f, -8.87187123e-02f, 2.59089023e-02f, 1.01025738e-01f, 7.36068189e-02f, -8.02583434e-03f, 2.16793120e-02f,
  1.61996279e-02f, -2.68025715e-02f, -7.41429329e-02f, -4.58484842e-03f, -7.17046484e-02f, -3.75224128e-02f, -1.15264021e-01f, -3.35130766e-02f, -7.03653395e-02f, -4.36722040e-02f,
  -2.20481064e-02f, -5.98398864e-01f, 7.28662089e-02f, -2.44154900e-01f, 1.47137428e-02f, 3.02532185e-02f, -8.48328024e-02f, -1.38054937e-01f, -1.25190705e-01f, -3.22743773e-01f,
  -4.33257520e-02f, -8.86053070e-02f, -9.33308378e-02f, -2.39981696e-01f, 3.64405811e-01f, -1.67997062e-01f, -2.67244168e-02f, -1.33847401e-01f, -2.42825001e-02f, -1.65960774e-01f,
  2.07581185e-02f, -1.31173551e-01f, 1.07908718e-01f, -9.12106857e-02f, -6.89388067e-02f, -1.26828194e-01f, -6.39206590e-03f, -1.40283937e-02f, 5.80208981e-03f, 5.67318685e-02f,
  5.19966669e-02f, -7.10959313e-03f, -1.01197194e-02f, 2.53102574e-02f, 8.97226930e-02f, 5.40051721e-02f, 2.21772622e-02f, 7.65890777e-02f, 1.30741835e-01f, -1.56142088e-02f,
  2.84328293e-02f, 3.04754917e-02f, -6.92512542e-02f, 6.65953904e-02f, -3.76346260e-02f, -4.29017693e-02f, -3.67575698e-02f, 1.18873328e-01f, -4.81811054e-02f, 1.01124821e-02f,
  -4.58812714e-02f, 1.40924379e-02f, -9.98788923e-02f, -2.97531951e-02f, 8.25959258e-03f, -5.65523319e-02f, 1.28753837e-02f, -7.16743118e-04f, -9.17697772e-02f, -5.13379015e-02f,
  -8.13139454e-02f, -3.82990427e-02f, -3.93978022e-02f, 4.63803746e-02f, -4.89442311e-02f, 4.37603099e-03f, 2.09780913e-02f, -5.29404869e-03f, 3.26713920e-02f, -3.26221846e-02f,
  8.95214677e-02f, 6.10158145e-02f, 2.37606722e-03f, 3.63216586e-02f, -1.05177514e-01f, 6.26208168e-03f, 2.57835519e-02f, -2.68344004e-02f, -4.33773883e-02f, 1.83560904e-02f,
  -3.08599882e-03f, 2.66730078e-02f, -2.59662643e-02f, 7.80519694e-02f, 1.49418190e-02f, -6.41205683e-02f, -1.76143441e-02f, -7.29181170e-02f, 3.69570218e-02f, 6.56288937e-02f,
  -3.70734155e-01f, -3.32578927e-01f, 7.88945984e-03f, 1.47456974e-01f, 4.67340387e-02f, 7.99327344e-03f, 1.36826694e-01f, 5.02660014e-02f, -6.52939007e-02f, 2.17602830e-02f,
  5.56046255e-02f, 1.01549976e-01f, 3.82569581e-02f, 8.18652138e-02f, 4.84535620e-02f, -8.22257530e-03f, 4.17482667e-02f, -1.15348203e-02f, 1.88332312e-02f, -2.75741871e-02f,
  -9.56365243e-02f, -4.73386385e-02f, 5.09037077e-02f, 1.25845186e-02f, 2.61338204e-02f, 1.29330214e-02f, -3.47979032e-02f, -3.23231611e-03f, -6.85478467e-03f, -1.20254897e-01f,
  3.46032888e-01f, 1.02748580e-01f, 2.07172006e-01f, -1.23368911e-01f, 9.88149196e-02f, -3.54862720e-01f, -2.70064831e-01f, 4.71005924e-02f, 2.77195454e-01f, -2.47589827e-01f,
  -3.69443074e-02f, -2.28505999e-01f, 1.05974846e-01f, -3.38412374e-01f, -3.15003872e-01f, -1.26637906e-01f, -5.51389009e-02f, -1.04606636e-01f, 1.31089926e-01f, 1.47092372e-01f,
  1.78468511e-01f, -2.44280249e-01f, -1.29708678e-01f, 1.02095805e-01f, -1.15080200e-01f, 7.04282150e-02f, -6.65509105e-02f, 8.73268992e-02f, -2.74985731e-01f, -2.25886032e-01f,
  1.05278723e-01f, 2.30684251e-01f, -4.04003039e-02f, 6.49004653e-02f, -1.42215434e-02f, -2.24056765e-02f, -5.40768877e-02f, 6.13345988e-02f, 2.46146374e-04f, -1.00387493e-02f,
  -1.82153750e-02f, 1.31704025e-02f, -6.27966970e-02f, 5.53598963e-02f, 8.20840225e-02f, 3.17646265e-02f, -6.13608323e-02f, -1.01682544e-02f, -2.57740151e-02f, -7.27598891e-02f,
  4.61373739e-02f, -6.14778176e-02f, 6.80705756e-02f, -1.30165117e-02f, 1.20705431e-02f, -8.81777927e-02f, -1.01362310e-01f, 1.36054894e-02f, -4.02858779e-02f, -9.28122103e-02f,
  3.55881117e-02f, 1.49960779e-02f, -2.89515592e-02f, -6.44820482e-02f, -4.00171569e-03f, 1.27138449e-02f, -3.72055657e-02f, -9.53466743e-02f, 1.39797106e-02f, -6.61310693e-03f,
  2.71919072e-02f, -6.52701035e-02f, 7.95980170e-02f, -6.05365299e-02f, 3.02527379e-02f, -7.53301010e-02f, 1.88190520e-01f, -8.33394527e-02f, 8.84532705e-02f, -8.56075659e-02f,
  7.56651238e-02f, 1.02653049e-01f, -5.75512499e-02f, 2.79836077e-02f, 3.94232646e-02f, 8.94595683e-02f, -2.16167253e-02f, 1.07515454e-01f, 3.47272269e-02f, 9.45381820e-02f,
  1.79893091e-01f, 1.55371517e-01f, -9.76206828e-03f, -6.65567815e-02f, -1.24599934e-02f, -3.68435457e-02f, 7.24904686e-02f, -9.05858576e-02f, 2.07767673e-02f, 1.81341786e-02f,
  6.69870451e-02f, -5.60654700e-02f, 1.06243347e-03f, 3.10311876e-02f, -6.89134421e-03f, 1.64978877e-02f, -1.49544571e-02f, 8.58560354e-02f, -6.35404214e-02f, 5.13815433e-02f,
  4.91875969e-02f, -3.53174470e-02f, -1.02350861e-02f, 1.65886655e-02f, 4.61624842e-03f, -6.85738400e-02f, -1.62550341e-02f, 7.88191054e-03f, -3.94161092e-03f, 7.75552262e-03f,
  -2.28027672e-01f, -3.21098655e-01f, -2.92852163e-01f, -3.13638806e-01f, 2.02033564e-01f, 2.23058596e-01f, 1.63536854e-02f, -1.90929636e-01f, -4.64174151e-01f, 1.16680406e-01f,
  2.45294869e-01f, -3.10487419e-01f, 8.80135596e-03f, 8.20465982e-02f, -1.10170744e-01f, 1.00940891e-01f, 1.07913584e-01f, -3.66347507e-02f, -1.27767980e-01f, -1.41758338e-01f,
  -1.38080806e-01f, 3.48868489e-01f, 7.97054097e-02f, 1.77915081e-01f, 1.82244331e-01f, -2.12959558e-01f, 1.95397124e-01f, -6.16336055e-02f, 1.16595462e-01f, 3.21278200e-02f,
  5.94353937e-02f, -5.32579571e-02f, 3.65077257e-02f, -7.86970332e-02f, 7.28079602e-02f, 7.28582889e-02f, -4.05464917e-02f, -1.79653093e-02f, -1.01762041e-01f, 4.42348467e-03f,
  6.01900555e-02f, 1.00273646e-01f, -7.91226253e-02f, -5.95845655e-02f, -5.05793914e-02f, -4.53460552e-02f, 4.29674350e-02f, 4.24360856e-02f, -1.06584139e-01f, 4.76361178e-02f,
  -4.12071608e-02f, -1.45710260e-03f, 6.36954233e-02f, -8.54948089e-02f, -5.16303182e-02f, 2.59451941e-02f, 2.04818174e-02f, 8.61199424e-02f, 1.40059134e-02f, 6.95591345e-02f,
  1.04989901e-01f, -9.65075046e-02f, 3.43750603e-02f, 9.65494886e-02f, 6.94957450e-02f, 5.90650588e-02f, 1.79874822e-02f, 4.18687910e-02f, -1.31796703e-01f, 1.17704593e-01f,
  9.36386213e-02f, 2.66005285e-03f, -3.86882834e-02f, -3.99690568e-02f, 5.36231659e-02f, -4.07324024e-02f, 1.28070608e-01f, 2.90500894e-02f, -4.04901579e-02f, -5.56257144e-02f,
  -4.50462960e-02f, 5.89377359e-02f, 3.54137458e-02f, 6.16874509e-02f, 4.78916988e-02f, -7.16034770e-02f, -6.82330355e-02f, 1.06115386e-01f, 8.09498653e-02f, 5.52469119e-02f,
  1.20215364e-01f, -1.73138618e-01f, 1.30090639e-02f, 8.00829008e-02f, 2.47755442e-02f, 4.29468453e-02f, -1.54010445e-01f, -2.04904024e-02f, -8.53849128e-02f, -1.55107556e-02f,
  -2.38715541e-02f, 6.29120171e-02f, 8.44079852e-02f, 1.25937127e-02f, 7.90285971e-03f, 4.16677706e-02f, -8.86974670e-03f, -1.02096096e-01f, 5.49445674e-02f, 4.40388694e-02f,
  7.07630217e-02f, -4.55901437e-02f, -6.15865961e-02f, 3.38596036e-03f, -1.04837045e-02f, 5.81204370e-02f, 3.07136681e-03f, -9.34135243e-02f, 7.94197097e-02f, 4.36139405e-02f,
  1.14752732e-01f, -3.12527299e-01f, 4.67241555e-02f, 2.45816767e-01f, 1.78548008e-01f, -4.97527927e-01f, -5.45600116e-01f, -5.55357337e-02f, 1.22794174e-01f, -3.62523139e-01f,
  -3.06820660e-03f, -2.37997741e-01f, -2.55294412e-01f, -2.18731873e-02f, -7.15450896e-03f, -7.64221027e-02f, 7.07215890e-02f, -8.99220333e-02f, 1.67999119e-01f, -1.35465583e-03f,
  1.56534761e-01f, 1.27806306e-01f, 1.55506954e-01f, 9.06192586e-02f, 3.00327912e-02f, -6.39683753e-02f, 1.86511159e-01f, 9.21420194e-03f, -8.44767503e-03f, -8.82911012e-02f,
  -3.27315852e-02f, 4.68590483e-02f, 3.23561616e-02f, 4.32699919e-02f, -3.60701904e-02f, -1.61479339e-01f, -1.95884600e-01f, -1.45319209e-01f, 5.26144616e-02f, -7.58901313e-02f,
  -7.62243047e-02f, -6.23340458e-02f, -1.80080216e-02f, -5.24822138e-02f, 2.33810227e-02f, 7.43835792e-02f, 1.02125853e-01f, 1.18287757e-01f, 4.63196300e-02f, -1.56912223e-01f,
  2.57198531e-02f, -1.52556961e-02f, 7.94200897e-02f, -4.51986715e-02f, 2.31058076e-02f, 2.56270375e-02f, -5.99207804e-02f, -8.63755792e-02f, 2.61709671e-02f, -8.91544521e-02f,
  -7.25527257e-02f, -3.88597064e-02f, 4.18001078e-02f, 7.35129192e-02f, 4.93506603e-02f, 3.58287990e-02f, 4.70215864e-02f, -8.06987286e-03f, 7.63438568e-02f, -1.71307307e-02f,
  1.27137467e-01f, 2.78084856e-02f, 9.70738381e-02f, -3.95284519e-02f, 3.77173945e-02f, 1.74691598e-03f, 2.50606798e-02f, -6.89047500e-02f, 6.25665411e-02f, -2.57739145e-02f,
  4.35344167e-02f, 2.93981358e-02f, -7.47047737e-02f, -5.41418418e-02f, 2.29596253e-02f, 9.15049389e-02f, 4.01026644e-02f, 2.31833337e-03f, -6.87229447e-03f, 1.15320161e-01f,
  -1.58885598e-01f, -2.71426052e-01f, -3.34565416e-02f, 2.90290583e-02f, -1.37339374e-02f, 9.16807428e-02f, 1.32562872e-02f, -6.42516166e-02f, 1.66733621e-03f, -2.24367213e-02f,
  -3.85817029e-02f, 2.12989077e-02f, -9.22564417e-04f, 1.32597964e-02f, 2.58075092e-02f, -7.38227889e-02f, -7.39612058e-02f, 2.42484678e-02f, -3.15573215e-02f, 2.01131720e-02f,
  -1.19985305e-02f, 2.00086515e-02f, 8.80254316e-04f, 7.74255171e-02f, -1.02973685e-01f, -1.98613126e-02f, -1.59664646e-01f, 1.09807439e-02f, 3.51488143e-02f, -4.56493013e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.91825300e-01f, -1.80034369e-01f, -4.31485146e-01f, -3.43148202e-01f, -2.32904673e-01f, -5.00856876e-01f, -5.26554763e-01f, -1.73398629e-01f, -5.73283434e-03f, 2.51590107e-02f,
  -2.02406481e-01f, 2.50550956e-02f, 3.10542524e-01f, -3.32088172e-01f, 1.45018682e-01f, 4.49669361e-01f, -4.05629456e-01f, -2.13716730e-01f, 1.25849783e-01f, -1.45768583e-01f,
  5.73362075e-02f, -1.40453875e-01f, 7.45792687e-02f, -1.17592670e-01f, -4.27323997e-01f, -2.50436425e-01f, -4.99254651e-02f, -3.78807127e-01f, -2.52861649e-01f, -4.30936776e-02f,
  1.23010814e-01f, 1.39244601e-01f, -2.95478962e-02f, 3.15249711e-02f, -1.50779821e-03f, 2.54032239e-02f, -2.71271199e-01f, -2.62568630e-02f, -5.60512580e-02f, -6.25408515e-02f,
  -5.39454296e-02f, 1.05473652e-01f, -5.04439175e-02f, 1.39419034e-01f, -1.08863428e-01f, -1.67837664e-01f, 7.90478364e-02f, -2.29423176e-02f, -8.60843956e-02f, 1.86710700e-01f,
  -1.23021984e-02f, -1.64061069e-01f, -3.10713142e-01f, 8.23358893e-02f, -8.67930427e-02f, -1.41908482e-01f, 9.40459371e-02f, 1.60087049e-02f, -8.90726447e-02f, -1.69144629e-03f,
  1.50392711e-01f, -3.15211445e-01f, -1.47111446e-01f, -1.37096152e-01f, 6.45295754e-02f, -1.54948570e-02f, -1.24326177e-01f, 4.71394882e-02f, -6.37794062e-02f, -6.36377260e-02f,
  -1.38523281e-01f, -5.99303395e-02f, -7.04130828e-02f, -2.54627228e-01f, -3.84937376e-02f, 2.86478996e-02f, 3.07369977e-03f, 7.34121576e-02f, -1.97751909e-01f, -6.52176738e-02f,
  8.29872563e-02f, -7.91033208e-02f, 8.47314112e-03f, 7.06300810e-02f, -1.68085232e-01f, -1.89153239e-01f, -1.21135168e-01f, -2.94572450e-02f, -3.38117108e-02f, -2.11563427e-02f,
  -9.85905714e-03f, 8.53667483e-02f, -3.76377604e-03f, 4.29763384e-02f, -2.00418402e-02f, -3.04852817e-02f, -1.61218747e-01f, -6.00479990e-02f, -1.98670805e-01f, 5.49389087e-02f,
  -1.17039971e-01f, -2.76606288e-02f, -1.92293525e-01f, -8.26945007e-02f, -6.97935224e-02f, 9.51114483e-03f, 1.68954371e-03f, -8.88382085e-03f, -1.03741717e-02f, -7.87809789e-02f,
  -8.47983137e-02f, -1.28735930e-01f, 3.42357089e-03f, -4.73167822e-02f, 2.78648809e-02f, 3.04815136e-02f, 1.34981871e-01f, -2.89380103e-02f, 9.09632295e-02f, -1.01197042e-01f,
  -8.88404012e-01f, 5.17543077e-01f, 9.05654952e-03f, -4.93082285e-01f, 1.43778756e-01f, -2.23665357e-01f, -2.25844905e-01f, 2.17514694e-01f, -1.46521971e-01f, 2.43937857e-02f,
  -1.12127319e-01f, 1.83565021e-02f, 7.69731104e-02f, -3.00894529e-01f, -5.51014006e-01f, -1.58482417e-01f, -4.46550518e-01f, -3.09956491e-01f, 2.17429668e-01f, -8.40594098e-02f,
  -1.71199426e-01f, -8.66350383e-02f, -2.09749982e-01f, 3.55709165e-01f, -9.76482593e-03f, 1.06706008e-01f, -2.10692301e-01f, 4.05387074e-01f, -1.47887602e-01f, 1.65057749e-01f,
  -1.55408829e-01f, 2.52065897e-01f, 8.41825679e-02f, 2.54382193e-03f, -1.92611650e-01f, 4.67335656e-02f, -1.42643034e-01f, 6.63334224e-03f, 4.91437502e-02f, 1.11130603e-01f,
  5.94380870e-02f, 1.08021341e-01f, 2.14143507e-02f, 1.29239202e-01f, 8.52149203e-02f, 1.66178435e-01f, 1.46367371e-01f, -7.10198432e-02f, 9.59479958e-02f, 5.56548797e-02f,
  9.45703983e-02f, 4.02703285e-02f, -1.21004902e-01f, -1.25799887e-02f, -1.94368721e-03f, 3.34052257e-02f, -1.16768762e-01f, 1.77579746e-02f, -1.64814200e-02f, -7.34556913e-02f,
  -7.54799042e-03f, -7.85031021e-02f, -1.48579609e-02f, 2.73711644e-02f, 3.66736501e-02f, 7.23041371e-02f, 9.66058150e-02f, -2.21438929e-02f, 3.45367640e-02f, -9.84741561e-03f,
  -1.18972868e-01f, 1.41253881e-03f, 9.88710150e-02f, -1.66819245e-01f, -7.11182654e-02f, -2.05612648e-02f, -8.03810880e-02f, 5.66032827e-02f, -7.65887275e-02f, -1.30256161e-01f,
  1.28333271e-01f, -3.24923992e-02f, -2.95744166e-02f, -1.28354743e-01f, 7.20778480e-02f, -3.91278602e-02f, 1.60784319e-01f, -1.15415670e-01f, -1.35457991e-02f, -2.37497129e-02f,
  -3.43546093e-01f, -1.31347075e-01f, -6.03742674e-02f, 1.18548416e-01f, 9.60294809e-03f, 8.73822533e-03f, -5.26259094e-02f, -3.89996730e-03f, -1.23652570e-01f, -6.46741837e-02f,
  -1.62883312e-04f, -1.39662668e-01f, -1.71157077e-01f, 2.80847363e-02f, 1.23437317e-02f, -1.17328741e-01f, -9.27781090e-02f, 3.36213261e-02f, -8.93635079e-02f, -5.38673475e-02f,
  -7.78681459e-03f, -1.31850317e-01f, -8.81423131e-02f, -1.45754265e-02f, -8.34798440e-02f, -9.93311852e-02f, -1.01482375e-02f, 4.48843688e-02f, 3.35613005e-02f, 3.41989100e-03f,
  1.90242276e-01f, 1.36663869e-01f, 3.43156159e-01f, 5.18711030e-01f, -2.24023104e-01f, -5.42955279e-01f, -4.22926724e-01f, 2.68620759e-01f, -2.15723887e-01f, -2.23165080e-01f,
  4.27414961e-02f, 7.58148432e-02f, -6.47913516e-02f, 2.50708014e-01f, 2.64655471e-01f, -6.97106123e-02f, 6.66399375e-02f, -8.45203176e-02f, 6.36300743e-02f, 9.49721485e-02f,
  2.39525974e-01f, 1.06609493e-01f, 3.89569700e-01f, 2.55118757e-01f, 2.38205686e-01f, 3.11952770e-01f, 4.84318733e-01f, 1.43314153e-01f, 3.86250615e-01f, 5.60180098e-02f,
  -2.55238652e-01f, 1.13064321e-02f, 1.68907810e-02f, 3.25214900e-02f, -3.52472700e-02f, -2.13395089e-01f, -8.43654275e-02f, -4.77425531e-02f, -6.46701679e-02f, -4.55748253e-02f,
  -4.14692052e-02f, -4.53464314e-02f, 3.57887596e-02f, -1.31630888e-02f, -1.96072638e-01f, 1.44459486e-01f, 1.00488693e-01f, -3.04205366e-03f, -7.05636069e-02f, 9.59640294e-02f,
  1.35067761e-01f, 3.88624333e-02f, 1.01018194e-02f, 4.52760682e-02f, 9.65784118e-02f, -1.16262091e-02f, 8.64588097e-02f, 7.84124807e-02f, 3.61782908e-02f, 1.02784574e-01f,
  -8.37135389e-02f, -6.42440608e-03f, -3.57929468e-02f, 1.52742803e-01f, 1.05765834e-01f, 9.10185464e-03f, 4.79010046e-02f, 8.82388279e-02f, 9.13855731e-02f, 6.48305565e-02f,
  1.62770208e-02f, 1.32431686e-01f, 1.47018088e-02f, -6.72903843e-03f, 8.96455348e-02f, 4.27964479e-02f, 2.98747118e-03f, 1.65771201e-01f, 4.63826321e-02f, 1.17029950e-01f,
  1.49280764e-02f, -8.85488763e-02f, -1.56902466e-02f, 3.32312919e-02f, -1.18925087e-01f, -6.32504746e-02f, 1.63338725e-02f, -2.53128167e-02f, -5.31453593e-03f, 9.49544087e-02f,
  -1.28867507e-01f, 3.02320212e-01f, 1.48194917e-02f, -3.46383802e-03f, 1.19454809e-03f, -1.67861596e-01f, -6.12712391e-02f, 3.51710580e-02f, 1.76419746e-02f, 6.69686403e-03f,
  -6.15231842e-02f, -3.29831243e-02f, -1.85282066e-01f, -3.65542918e-02f, 5.44690862e-02f, 6.60161003e-02f, -6.42462447e-02f, 1.26507178e-01f, 7.59212822e-02f, 1.43478453e-01f,
  8.32103863e-02f, -6.99141547e-02f, -1.05537931e-02f, -2.27781590e-02f, 1.11838646e-01f, 5.67907058e-02f, -2.29336671e-03f, -3.42838019e-02f, 1.40338227e-01f, 4.41514328e-02f,
  -1.72403052e-01f, -3.66140515e-01f, 4.79265660e-01f, -2.72366375e-01f, 4.50446814e-01f, 5.82430840e-01f, 2.48281598e-01f, 1.92209825e-01f, 1.46675974e-01f, -5.06099284e-01f,
  -2.24009797e-01f, -4.17849630e-01f, -1.98646307e-01f, -1.78957343e-01f, 5.11392295e-01f, 6.37048930e-02f, 1.16969600e-01f, -2.55268306e-01f, 1.86167076e-01f, -1.07793003e-01f,
  6.59476966e-02f, -8.57102200e-02f, 3.52514058e-01f, -1.87165644e-02f, 1.99461386e-01f, -2.08593458e-02f, -1.67172059e-01f, 5.87607436e-02f, -3.89198698e-02f, 1.43930167e-01f,
  2.87237227e-01f, -1.58508137e-01f, 1.68463171e-01f, 1.84215996e-02f, -1.08611686e-02f, -1.36489943e-01f, -1.47725835e-01f, 5.13801090e-02f, 7.08793253e-02f, -6.43040612e-02f,
  -3.19593519e-01f, 6.85780421e-02f, 4.26154658e-02f, 6.16964288e-02f, 5.62501848e-02f, 6.39273897e-02f, 2.67431766e-01f, 1.02458797e-01f, 1.79552089e-03f, 1.30360588e-01f,
  9.93058309e-02f, 8.40921924e-02f, 1.34920388e-01f, -2.25081310e-01f, 5.18060476e-02f, 5.33024035e-02f, -1.33121666e-02f, 3.91838476e-02f, 5.87485777e-03f, 3.58554125e-02f,
  5.65310474e-03f, 3.98163758e-02f, -5.59934117e-02f, -4.80516702e-02f, -6.16373308e-03f, 1.16289467e-01f, -9.57654230e-03f, -1.29630238e-01f, -5.26914485e-02f, -4.13039252e-02f,
  -1.54412305e-02f, -1.24166019e-01f, 1.09967209e-01f, 2.30903979e-02f, -6.92051798e-02f, -3.57579696e-03f, -1.40339851e-01f, 2.64403201e-03f, 1.02821887e-01f, -3.43745970e-03f,
  -1.27216175e-01f, -3.14581655e-02f, -8.61742571e-02f, -4.81107309e-02f, 5.64092584e-02f, 4.42989655e-02f, -1.55785695e-01f, 6.86122403e-02f, -8.13539773e-02f, 9.00459886e-02f,
  -2.15116411e-01f, -7.29895651e-01f, -5.04288636e-02f, -9.85703394e-02f, -1.61091730e-01f, -1.22366585e-01f, -1.06032558e-01f, 3.86145874e-03f, -9.30134654e-02f, -5.39318994e-02f,
  5.23346588e-02f, -1.87794805e-01f, -6.10750131e-02f, 4.25947383e-02f, -2.99842972e-02f, -2.94698775e-02f, -2.06181854e-01f, -2.07812220e-01f, -1.41675457e-01f, -1.10147648e-01f,
  -7.75320008e-02f, -2.17109770e-01f, -3.85573395e-02f, -6.15372322e-02f, -1.17273510e-01f, -1.03542402e-01f, 1.06761102e-02f, 1.22135788e-01f, -5.35476096e-02f, 1.81183461e-02f,
  3.99510562e-01f, 4.01064187e-01f, 3.78091067e-01f, 9.75257158e-02f, -3.16834480e-01f, -3.72800946e-01f, -3.58202934e-01f, -9.47072264e-03f, 7.73108704e-03f, 1.94046214e-01f,
  -2.55400211e-01f, 6.60272956e-01f, -2.34758273e-01f, 7.76632363e-03f, -2.75307000e-01f, -3.54908705e-01f, -1.82157323e-01f, 4.83383760e-02f, -1.23462863e-01f, -4.52287458e-02f,
  -1.33339107e-01f, -5.47661781e-01f, -1.81231380e-01f, -3.87639582e-01f, 1.83779120e-01f, 2.89292961e-01f, -2.55387515e-01f, -2.66476989e-01f, 3.22848320e-01f, 2.59727128e-02f,
  4.17243466e-02f, -6.29737154e-02f, 1.79525182e-01f, -6.93492219e-03f, -1.49075702e-01f, 5.08443080e-03f, 1.43685609e-01f, -4.15609218e-02f, -5.36114760e-02f, 6.90899268e-02f,
  1.04028545e-01f, 9.70642865e-02f, 4.39297520e-02f, -6.53376803e-02f, -1.24342209e-02f, 1.52466699e-01f, 1.71215653e-01f, 1.39854923e-01f, 2.40964759e-02f, 8.18719938e-02f,
  1.67576578e-02f, 2.56231219e-01f, -1.04854275e-02f, 2.20815577e-02f, 7.89556727e-02f, 6.29624873e-02f, -4.97650681e-03f, 1.72562286e-01f, 9.49578211e-02f, 8.09349343e-02f,
  6.31414801e-02f, -1.97846904e-01f, -1.05633236e-01f, -4.20043096e-02f, -3.93199511e-02f, -4.28353250e-02f, -8.32055286e-02f, 9.25081819e-02f, -8.81265402e-02f, 6.15853667e-02f,
  1.25003725e-01f, 5.01660630e-02f, 1.37813454e-02f, 1.05840750e-02f, -3.54589075e-02f, 9.36365053e-02f, -1.62651241e-02f, 6.93009570e-02f, -1.62483249e-02f, 2.34457180e-02f,
  -1.71166256e-01f, -5.52700907e-02f, 6.76904386e-03f, -2.95213517e-02f, 7.01638311e-02f, 9.25497711e-02f, 1.86586268e-02f, 2.54337907e-01f, -6.45302907e-02f, -1.27271459e-01f,
  -2.61780918e-01f, -5.79123378e-01f, -1.81993216e-01f, -4.24097478e-03f, -1.78173393e-01f, 4.66224588e-02f, -1.63313806e-01f, 1.70993313e-01f, -1.58429459e-01f, -1.15486391e-01f,
  2.75921319e-02f, -8.62052739e-02f, 6.05786070e-02f, 9.25925970e-02f, -9.05710459e-02f, -6.83382750e-02f, -6.40310496e-02f, -1.63203791e-01f, -9.76453274e-02f, -3.03298831e-02f,
  7.95546640e-03f, -1.47768214e-01f, 3.58269140e-02f, 6.15099669e-02f, -7.70254200e-03f, -3.18219326e-02f, 5.32647409e-02f, 1.13567099e-01f, -5.22868298e-02f, -3.20355259e-02f,
  2.41580725e-01f, -2.28247583e-01f, -2.97514439e-01f, 2.03691229e-01f, 2.09111404e-02f, -1.48534968e-01f, -4.94111270e-01f, 1.83197662e-01f, -2.77347744e-01f, -6.31175237e-03f,
  1.89677656e-01f, -1.04748026e-01f, -3.43355477e-01f, 2.87862837e-01f, 4.50799257e-01f, -5.02049804e-01f, 2.65858591e-01f, -1.36943310e-01f, -2.51654118e-01f, 1.86873585e-01f,
  2.55092025e-01f, 5.67435920e-01f, 1.85470417e-01f, 4.60917711e-01f, 7.94600546e-02f, 1.84855729e-01f, 3.90720189e-01f, -8.51089042e-03f, 5.92408538e-01f, 1.30305946e-01f,
  -6.01471066e-02f, -2.40109731e-02f, -8.17105174e-02f, 3.93473096e-02f, 2.70720851e-03f, 1.79451659e-01f, -1.99092235e-02f, 5.93802184e-02f, -3.55092622e-02f, -9.64361802e-03f,
  -7.55807236e-02f, 1.64471596e-01f, 1.71246454e-02f, 9.55636203e-02f, 2.06445158e-01f, -7.99747333e-02f, -6.72871023e-02f, -1.25886753e-01f, -1.08966723e-01f, 3.53201889e-02f,
  -9.15960073e-02f, -7.69918486e-02f, 4.37593311e-02f, 6.14522491e-03f, 1.21738734e-02f, -5.09460866e-02f, -1.32518023e-01f, -8.70530978e-02f, -4.88822423e-02f, 9.05284137e-02f,
  1.30280733e-01f, -5.23787849e-02f, -4.67219800e-02f, -1.50073051e-01f, -3.00145075e-02f, 1.23485262e-02f, 2.61529554e-02f, -2.46518515e-02f, -6.09076470e-02f, 1.43940687e-01f,
  3.74384895e-02f, 8.10689256e-02f, 1.33887932e-01f, 8.49143937e-02f, 6.71701431e-02f, -6.88598603e-02f, 6.15280569e-02f, 1.90622434e-02f, -3.18528451e-02f, -1.50917128e-01f,
  2.66718231e-02f, 1.66540459e-01f, -1.22085176e-01f, -1.02113292e-01f, 4.59097214e-02f, 1.68919504e-01f, 2.28091002e-01f, 5.94809614e-02f, -1.55429080e-01f, 4.50223126e-02f,
  7.39967376e-02f, 1.59185290e-01f, 1.10188071e-02f, -1.01819754e-01f, -2.14486141e-02f, 6.72298074e-02f, -1.13925867e-01f, 8.38442817e-02f, 1.39698712e-02f, -1.16738945e-01f,
  1.71978131e-01f, -1.08436808e-01f, 2.42628679e-02f, 1.51507586e-01f, 8.45576450e-02f, 9.41544399e-02f, -1.47412084e-02f, 3.87830175e-02f, 1.20494410e-01f, 3.91617306e-02f,
  1.15870228e-02f, -1.84133038e-01f, -3.91706731e-03f, -2.61692762e-01f, 3.85771431e-02f, -8.85503516e-02f, -8.05751607e-03f, 2.59539746e-02f, 4.37403936e-03f, 1.92571282e-02f,
  1.51536793e-01f, -1.34637564e-01f, -6.11972868e-01f, -2.62997717e-01f, 2.84508318e-01f, 5.14303744e-01f, -1.70466602e-01f, 1.04879081e-01f, -4.34132487e-01f, 2.62779891e-01f,
  2.09552124e-01f, -2.71086872e-01f, -2.55597144e-01f, -4.54512462e-02f, -1.81376010e-01f, -3.40571880e-01f, 3.54766324e-02f, -3.17266211e-02f, -1.25926644e-01f, 2.80425083e-02f,
  -2.16921598e-01f, 4.80486423e-01f, -4.52480823e-01f, 2.55493075e-01f, 1.98175251e-01f, 6.70847595e-02f, 3.89554948e-01f, -5.99569939e-02f, 2.57194281e-01f, 3.12274341e-02f,
  9.57953651e-03f, -1.48098692e-01f, -4.37331460e-02f, -1.46927238e-01f, 1.11897208e-01f, 2.79261798e-01f, 8.95211846e-02f, -9.13250372e-02f, -1.36609718e-01f, -4.55069356e-02f,
  6.56015053e-02f, -8.10937881e-02f, -3.90056968e-02f, -2.66619376e-03f, 9.85323787e-02f, -8.41112286e-02f, -1.71417184e-02f, -6.20237403e-02f, -1.68472528e-01f, 1.81583848e-04f,
  -7.62915611e-02f, -7.57003650e-02f, 2.06075720e-02f, -7.56399110e-02f, -7.69358948e-02f, -8.53861570e-02f, -7.38820061e-02f, -3.92132811e-03f, 7.84810409e-02f, -2.10027620e-02f,
  1.45940095e-01f, 1.09961499e-02f, -2.06203628e-02f, -4.18929681e-02f, -4.53401133e-02f, 8.79374798e-03f, -8.59035403e-02f, 2.10706461e-02f, -1.61670282e-01f, 2.72849966e-02f,
  -4.04855013e-02f, 4.92578512e-03f, -2.56993808e-02f, 4.28925678e-02f, 2.62703430e-02f, -1.96297709e-02f, 5.77574037e-02f, 7.42241740e-02f, -2.59740371e-02f, 3.35067324e-02f,
  1.01422854e-02f, -2.37514880e-02f, -3.47006209e-02f, 1.36269797e-02f, -8.16465616e-02f, -6.28665313e-02f, -1.02451695e-02f, 4.19952869e-02f, -2.97246147e-02f, 1.06252201e-01f,
  6.41902313e-02f, 1.68817431e-01f, -1.23423606e-01f, -1.86756882e-03f, -3.93367112e-02f, 1.88355669e-01f, 1.38595691e-02f, 7.10974121e-03f, 3.24377343e-02f, 1.09528899e-01f,
  8.82390440e-02f, -2.14750674e-02f, 2.33014479e-01f, -1.42466389e-02f, -9.41694751e-02f, -5.48228063e-03f, 7.50049949e-02f, -2.86863428e-02f, 8.52197781e-02f, 5.08258641e-02f,
  5.68076968e-02f, 6.62408695e-02f, -1.22592904e-01f, 3.45974006e-02f, 3.08727361e-02f, -4.73435894e-02f, 1.93747774e-01f, -2.74721254e-02f, 5.41993603e-02f, -1.22879080e-01f,
  -5.85169911e-01f, -2.14809552e-01f, -3.77377957e-01f, -1.08467080e-01f, -2.46706992e-01f, -6.43681526e-01f, -3.66200283e-02f, -3.65692168e-01f, -8.20434019e-02f, 1.95328385e-01f,
  2.67100513e-01f, -1.76084250e-01f, 4.37902123e-01f, 1.58362761e-01f, -1.81283399e-01f, 3.46797973e-01f, -1.49278730e-01f, 1.22838601e-01f, -2.09866628e-01f, -3.53821486e-01f,
  -2.15823382e-01f, -1.39424950e-01f, 6.65286407e-02f, -2.39984974e-01f, -2.48666808e-01f, -1.41019732e-01f, 2.58665621e-01f, -6.77299798e-02f, -9.06958506e-02f, 9.04611312e-03f,
  -4.62323576e-01f, -1.97347552e-01f, -6.51540831e-02f, -1.45360082e-01f, -1.68121293e-01f, -2.99403481e-02f, -1.57068868e-03f, 3.50758247e-02f, -1.85127050e-01f, 3.87458131e-02f,
  -5.85964732e-02f, -4.78328019e-02f, -4.01102789e-02f, 1.12800198e-02f, -5.63376024e-02f, -1.22419611e-01f, -1.64393410e-01f, -4.00923155e-02f, -6.71817884e-02f, -5.31646758e-02f,
  8.37061703e-02f, -3.02158389e-02f, 6.95055202e-02f, 3.28368769e-04f, -3.34342122e-02f, 4.45528254e-02f, -7.97690004e-02f, 1.16552345e-01f, -1.66725457e-01f, -6.12257868e-02f,
  5.03389575e-02f, 3.28067280e-02f, -2.91653350e-02f, 5.53000607e-02f, -1.22683212e-01f, 4.77711558e-02f, -2.98356414e-02f, 5.56928329e-02f, -7.02069625e-02f, 5.33255599e-02f,
  5.63183986e-02f, 6.21252740e-03f, -4.54708226e-02f, 2.51533538e-02f, -3.20154987e-02f, 1.69837162e-01f, -1.94157716e-02f, -6.20406754e-02f, 4.92777787e-02f, -3.35831642e-02f,
  3.14867334e-03f, -4.69856560e-02f, 1.55289695e-01f, 8.89606178e-02f, -1.38901966e-02f, 7.75702819e-02f, 3.37477177e-02f, 4.81871516e-02f, -1.11939244e-01f, 4.24506478e-02f,
  -7.99693286e-01f, -6.64497495e-01f, -6.09220937e-03f, -2.36695092e-02f, -7.19134957e-02f, -7.49397129e-02f, 1.05938070e-01f, -9.85033661e-02f, -7.83601254e-02f, -1.69478580e-01f,
  -5.08329868e-02f, 6.18376248e-02f, -7.46050701e-02f, 6.87285140e-02f, 3.77425514e-02f, 1.46411369e-02f, 9.46087949e-03f, -9.22084004e-02f, -6.91112876e-03f, -1.47194386e-01f,
  7.77043030e-02f, -4.15126756e-02f, 6.91216625e-03f, -6.12238143e-03f, 5.77147491e-02f, -2.93932538e-02f, -6.36874959e-02f, 5.39041460e-02f, -2.42959082e-01f, -7.87576195e-04f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.83290036e-02f, 4.48221773e-01f, -2.30377000e-02f, 6.86844409e-01f, 1.80183545e-01f, 1.65529221e-01f, 3.00416172e-01f, 1.48329407e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -3.41002315e-01f, -7.54787698e-02f, -1.61912054e-01f, 4.35379706e-02f, 2.89651275e-01f, -1.95768178e-01f, -3.28872651e-01f, 1.26616001e-01f, 8.67232382e-02f, 3.17128003e-01f,
  -1.31581768e-01f, -1.28991425e-01f, -1.35361284e-01f, 1.48748696e-01f, -3.46314758e-01f, 3.64269763e-01f, -4.46510501e-02f, 2.21196562e-02f, 1.30283952e-01f, -4.62897658e-01f,
  5.75539805e-02f, 2.27004394e-01f, -2.78525054e-01f, 2.81928271e-01f, 2.17545554e-01f, 2.04192519e-01f, -1.89561889e-01f, 1.05257612e-02f, 3.29619080e-01f, -3.11602771e-01f,
  -3.67315918e-01f, -1.99187383e-01f, -1.99378341e-01f, -5.85766621e-02f, 2.15030953e-01f, -2.48685151e-01f, -1.17611624e-01f, 2.98810583e-02f, -2.13091776e-01f, -4.07914780e-02f,
  -1.17872365e-01f, -4.60844666e-01f, 1.50998135e-03f, -7.38900751e-02f, -4.09034014e-01f, 2.26730704e-01f, -1.61709532e-01f, 3.14439267e-01f, -1.26535207e-01f, -3.34235579e-01f,
  3.74524146e-01f, 1.25036687e-01f, -1.20198205e-01f, -1.66280210e-01f, 3.24595720e-01f, -1.36163384e-02f, 4.30067591e-02f, 3.84731978e-01f, -3.51539999e-01f, -6.99200183e-02f,
  -1.87921211e-01f, 1.09366514e-01f, 3.43010455e-01f, 2.37976640e-01f, -4.46994185e-01f, 9.06552449e-02f, 6.46507517e-02f, -2.94097722e-01f, 2.49361247e-02f, -3.19338888e-01f,
  -3.92909348e-02f, -1.04632840e-01f, -7.25288615e-02f, 2.30034649e-01f, -1.71812251e-01f, 1.12890773e-01f, -8.83876458e-02f, 2.63239145e-01f, -3.53177994e-01f, 9.42526683e-02f,
  2.60564178e-01f, -3.95625502e-01f, 4.89324600e-01f, 1.78094685e-01f, 5.77383451e-02f, -2.44434059e-01f, -2.74605274e-01f, 4.24163491e-02f, 1.45871639e-01f, 2.62031853e-01f,
  -1.28161103e-01f, 1.98420376e-01f, 3.51758242e-01f, -3.66268039e-01f, -3.05893064e-01f, 1.65438876e-01f, -7.71144731e-03f, 5.88087961e-02f, -1.52788043e-01f, -1.51953757e-01f,
  -1.03664547e-01f, -6.83406740e-02f, 5.17389178e-02f, 4.76852022e-02f, -1.44078478e-01f, -2.47900203e-01f, -2.08350252e-02f, -2.58613795e-01f, -1.60250455e-01f, -1.72711983e-01f,
  1.38528496e-01f, 1.08745351e-01f, -9.01224241e-02f, 2.16989502e-01f, -4.13705468e-01f, 2.78146446e-01f, -2.90392470e-02f, -4.37902436e-02f, -9.19063091e-02f, 3.29793572e-01f,
  4.47622547e-03f, -2.96206594e-01f, 2.50124991e-01f, -4.17010784e-02f, -2.44908273e-01f, 2.73311973e-01f, 7.57418666e-03f, -6.09076440e-01f, 7.93673322e-02f, 3.45613547e-02f,
  8.30480270e-03f, -1.00334965e-01f, -2.10724905e-01f, 2.16695324e-01f, 2.04769745e-01f, 1.20089542e-04f, -1.37090921e-01f, -2.57733464e-01f, 5.02838045e-02f, 1.90635100e-01f,
  7.12039992e-02f, 2.21054386e-02f, 5.02243400e-01f, 1.38897866e-01f, -2.24409774e-02f, -1.19920336e-01f, -7.70612434e-02f, 4.29422647e-01f, 9.38327685e-02f, -2.30607092e-01f,
  2.17349902e-01f, -4.36932296e-01f, 1.91175297e-01f, -3.20663095e-01f, -2.29763836e-02f, 5.98414838e-02f, -3.45855594e-01f, 1.23658866e-01f, 4.57618356e-01f, -1.59525216e-01f,
  1.13613464e-01f, 3.00313830e-01f, -1.56453416e-01f, 6.53660893e-02f, -1.27876505e-01f, 1.78561628e-01f, -8.15647021e-02f, -7.28234872e-02f, -6.76896349e-02f, 6.79075718e-02f,
  -1.02428712e-01f, 2.89946944e-01f, 3.55277389e-01f, -3.67013454e-01f, 3.00593793e-01f, -3.06962401e-01f, 3.93987060e-01f, 1.94535300e-01f, -3.97678375e-01f, 1.13998108e-01f,
  -3.25436741e-01f, 2.87488401e-02f, 2.23156181e-04f, -2.74604410e-01f, 2.00688079e-01f, -2.93902278e-01f, 1.71795413e-02f, -2.19611958e-01f, 6.74525276e-02f, 5.15713468e-02f,
  1.63917542e-01f, -1.54973596e-01f, -5.30429631e-02f, -3.87714617e-02f, -2.87112501e-02f, 3.98653224e-02f, -1.49022251e-01f, 1.87019911e-02f, -1.63626760e-01f, 1.85551837e-01f,
  1.51404053e-01f, 1.08748011e-01f, -1.38073415e-01f, 1.36462837e-01f, 4.31356162e-01f, 1.07415644e-02f, 2.84388185e-01f, -6.15362711e-02f, -2.28402801e-02f, 3.28806281e-01f,
  -3.81847560e-01f, -2.85012156e-01f, -2.74876386e-01f, 1.00534886e-01f, -1.17926851e-01f, -1.98960781e-01f, 3.42318326e-01f, -3.87314886e-01f, -1.02496937e-01f, -1.42048359e-01f,
  -1.69845164e-01f, -1.32395804e-01f, 7.86549672e-02f, 4.63208519e-02f, -3.56953084e-01f, 7.02570230e-02f, -8.09453800e-02f, -8.35228339e-02f, -2.68799454e-01f, 2.61969894e-01f,
  -5.59676737e-02f, -3.75230163e-02f, 9.72483456e-02f, -2.87524313e-01f, -9.66948494e-02f, 5.07323071e-02f, 1.34670958e-01f, 2.61521280e-01f, 5.56523681e-01f, 1.88257024e-01f,
  -3.71399492e-01f, -3.22907358e-01f, -3.66215110e-01f, 6.75816415e-03f, -2.35492602e-01f, -3.02045077e-01f, 3.16309370e-02f, -3.01358521e-01f, 2.57645756e-01f, 2.61921510e-02f,
  -2.71927327e-01f, -2.38442227e-01f, -1.75458625e-01f, -1.24211170e-01f, 1.37981504e-01f, 2.50077635e-01f, -3.73263545e-02f, -1.00190736e-01f, -1.20395251e-01f, -5.28770350e-02f,
  -3.24850410e-01f, 8.99155289e-02f, 4.57633547e-02f, -6.93932027e-02f, -2.15307564e-01f, -3.14649135e-01f, 1.43320680e-01f, -1.69235259e-01f, 7.17597604e-02f, -4.07927454e-01f,
  3.31565142e-01f, -3.70969713e-01f, -3.31458300e-02f, 5.41435406e-02f, -5.68825424e-01f, 1.41111627e-01f, 1.27281189e-01f, -6.42678291e-02f, -2.03620363e-02f, 3.46219718e-01f,
  -4.55546565e-02f, -3.72923344e-01f, 1.23521172e-01f, -3.67039070e-02f, -2.46958628e-01f, 3.05303514e-01f, -1.33638635e-01f, 1.56540070e-02f, -9.82350558e-02f, 2.36921236e-01f,
  -1.11380480e-02f, 1.85880456e-02f, -3.10322940e-02f, 9.97243673e-02f, -3.27833354e-01f, 8.51383284e-02f, 1.14293292e-01f, -2.06327498e-01f, 7.44435191e-02f, 1.55428797e-01f,
  -2.08441094e-01f, 1.04314648e-01f, -3.73526037e-01f, 4.06709313e-01f, -1.19368788e-02f, 7.56667107e-02f, 1.52292952e-01f, -1.40659049e-01f, -2.75809139e-01f, 1.74756907e-02f,
  2.72672772e-01f, -1.13445111e-01f, 5.34342378e-02f, 3.50735724e-01f, -2.38019735e-01f, -1.60502300e-01f, 1.63884029e-01f, 1.62869945e-01f, 4.86993134e-01f, -2.30597913e-01f,
  -3.60622332e-02f, 1.49371907e-01f, -8.30740184e-02f, 9.80839804e-02f, -2.85182502e-02f, 1.67482972e-01f, 3.18845302e-01f, -1.51551843e-01f, -2.57869996e-02f, 4.37038802e-02f,
  -3.05534676e-02f, 1.98287070e-01f, 1.16388470e-01f, -7.17683956e-02f, 2.32394576e-01f, -3.01005810e-01f, -1.65698320e-01f, -1.65774181e-01f, -1.32828936e-01f, 1.27361491e-01f,
  -6.02826141e-02f, -2.97768086e-01f, -3.24526161e-01f, -3.57178539e-01f, 6.39402792e-02f, -3.27822208e-01f, -5.22093289e-02f, 5.60791530e-02f, 2.89537072e-01f, -3.07841957e-01f,
  -3.19433987e-01f, 3.37179720e-01f, -3.91059458e-01f, -1.94476053e-01f, -4.62063449e-03f, -1.26374960e-01f, -3.28078210e-01f, 1.28500581e-01f, 1.45764634e-01f, -2.53584236e-03f,
  -9.48464200e-02f, -3.76868129e-01f, -2.40271851e-01f, -3.68671924e-01f, -2.49142438e-01f, 2.77504981e-01f, 3.09460342e-01f, 1.73236594e-01f, -2.98764944e-01f, -3.22935671e-01f,
  -9.64993909e-02f, 4.70935196e-01f, 1.21276245e-01f, -2.53307164e-01f, -2.07000896e-02f, -1.37800172e-01f, 1.83311626e-01f, -2.66768575e-01f, -4.63229492e-02f, 7.86673650e-02f,
  -1.89106643e-01f, 2.31751695e-01f, -1.00963235e-01f, 9.16827396e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  4.61280763e-01f, 4.27912951e-01f, -3.06899399e-01f, 3.14336598e-01f, 3.45529258e-01f, 3.57950598e-01f, -8.35012972e-01f, 1.82269007e-01f, 1.00148052e-01f, 1.78166032e-01f,
  1.98014885e-01f, 6.68073371e-02f, -2.21995078e-02f, 2.08404839e-01f, -4.55586970e-01f, -3.53390902e-01f, 3.27546656e-01f, 1.99052945e-01f, 2.71704882e-01f, -6.22084498e-01f,
  -7.20240057e-01f, 6.37522697e-01f, -3.65906298e-01f, -1.53062031e-01f, 3.46206427e-02f, 6.80660129e-01f, 6.10988855e-01f, -8.71923029e-01f, 2.10965648e-01f, 3.98862541e-01f,
  1.83881313e-01f, 3.88292611e-01f, 6.22852862e-01f, 7.72244632e-01f, 7.35747159e-01f, -1.67480439e-01f, -3.92747670e-02f, 2.33180121e-01f, 1.88177109e-01f, 3.02057266e-01f,
  6.12594306e-01f, -3.59367013e-01f, 2.11076424e-01f, 4.07946557e-01f, -4.70950544e-01f, 4.04217541e-01f, 2.88143605e-01f, 9.33950007e-01f, -4.52976346e-01f, 9.88150090e-02f,
  8.30407366e-02f, 4.58540350e-01f, -8.59670937e-01f, -4.85876560e-01f, 8.28478158e-01f, -6.95637107e-01f, 2.08319098e-01f, 3.92839730e-01f, 1.29942834e-01f, -6.63480237e-02f,
  -4.58451539e-01f, 6.19662821e-01f, 5.55665672e-01f, 3.66619289e-01f, 5.21913290e-01f, 1.27351701e-01f, 1.35202616e-01f, 5.27212441e-01f, 8.93228233e-01f, 1.98972821e-01f,
  3.34889404e-02f, 5.67086995e-01f, 7.85259068e-01f, 8.84391069e-01f, 1.99618399e-01f, -2.27644760e-02f, 4.86641973e-01f, 6.66142166e-01f, 2.79815853e-01f, 5.64606726e-01f,
  -3.74358535e-01f, 5.15705407e-01f, 5.18318832e-01f, -4.55154747e-01f, -4.24746536e-02f, 3.37318331e-01f, -4.57306504e-01f, -2.30595902e-01f, -3.43719572e-02f, 5.20653427e-01f,
  -3.77329439e-01f, 7.41444409e-01f, 4.02892046e-02f, -4.74872500e-01f, 8.40350613e-02f, -3.90219182e-01f, -3.23186256e-02f, 3.15241396e-01f, 5.63546181e-01f, -3.95897835e-01f,
  7.90839866e-02f, 4.71988283e-02f, 3.32634062e-01f, -3.14087063e-01f, -9.91469175e-02f, 8.36408287e-02f, 2.12038845e-01f, 2.53350616e-01f, -4.18542087e-01f, 4.17492032e-01f,
  2.07767889e-01f, 1.42578138e-02f, 4.86393809e-01f, -1.06912422e+00f, 4.18236375e-01f, 8.96993637e-01f, 3.59717458e-01f, -4.46048200e-01f, 4.00259882e-01f, -2.48798102e-01f,
  3.87111425e-01f, 5.97903907e-01f, -1.04239479e-01f, 5.34228146e-01f, -6.14025779e-02f, -4.89170074e-01f, -3.34729612e-01f, 1.14207947e+00f, 5.44151425e-01f, -1.56844229e-01f,
  9.69686806e-02f, 5.24523258e-01f, 5.99627495e-01f, 7.53410608e-02f, 6.32854879e-01f, 1.54144287e-01f, 7.95332491e-02f, 4.38423634e-01f, 2.59502381e-01f, 6.53325245e-02f,
  -3.99157435e-01f, -4.40386951e-01f, -8.24132979e-01f, -5.82857966e-01f, 3.44485879e-01f, 4.23819214e-01f, 2.58258730e-02f, -1.36598408e-01f, 6.28555894e-01f, 3.98887157e-01f,
  1.01441927e-01f, 7.25988507e-01f, -6.27539873e-01f, -2.06993222e-02f, 5.56211948e-01f, 7.35885084e-01f, 6.96383774e-01f, 5.56003630e-01f, 2.66654313e-01f, -3.05155516e-01f,
  7.51860663e-02f, 4.18990135e-01f, -2.69205898e-01f, 3.56303975e-02f, 6.08400740e-02f, 2.42382050e-01f, -3.53442520e-01f, 8.15045089e-02f, 1.96603134e-01f, 1.07799061e-01f,
  1.36409968e-01f, -3.68775934e-01f, 1.08553164e-01f, 4.96191919e-01f, 1.43960137e-02f, 1.15570344e-01f, -1.87851369e-01f, 1.48717407e-03f, -3.97768646e-01f, -3.58449131e-01f,
  -5.92235982e-01f, 1.16178431e-01f, -8.46850753e-01f, -6.89038262e-02f, 5.47350109e-01f, 7.02969730e-01f, 9.01909471e-01f, -2.07603216e-01f, 6.78385854e-01f, 9.55319479e-02f,
  -6.82367444e-01f, 1.42033949e-01f, 7.51908049e-02f, 1.51228085e-01f, 2.58748174e-01f, -1.93566680e-02f, 2.25780666e-01f, -1.69450745e-01f, 4.94530171e-01f, -5.57836518e-02f,
  -8.06293637e-02f, 5.01350164e-01f, -5.86028351e-03f, 4.41097856e-01f, 3.57469231e-01f, -2.71264404e-01f, 2.15844288e-01f, -4.26724762e-01f, 8.44873011e-01f, -3.65596265e-01f,
  -1.89429685e-01f, 4.43591982e-01f, 5.85178792e-01f, 9.06767547e-02f, -4.82415140e-01f, -2.06754565e-01f, 4.73002076e-01f, 6.99489191e-02f, 1.75641365e-02f, 8.42468262e-01f,
  1.03983080e+00f, -5.97802699e-01f, -1.38082549e-01f, 5.15544862e-02f, 2.52952110e-02f, -5.35515308e-01f, -2.48804539e-01f, 3.00169647e-01f, 5.99878915e-02f, 4.08248574e-01f,
  -6.31730771e-03f, 3.97188574e-01f, 8.78146291e-02f, -1.90753594e-01f, 2.73216695e-01f, -1.28903106e-01f, 4.98467274e-02f, -6.56728506e-01f, 4.43151176e-01f, -2.74584740e-01f,
  -5.54924965e-01f, 4.23057020e-01f, -7.86065280e-01f, -5.10627329e-01f, 7.23248541e-01f, 1.34575561e-01f, -1.69422805e-01f, 9.16352034e-01f, 5.76296747e-01f, -4.11455691e-01f,
  4.31908816e-01f, 6.32451117e-01f, -5.10716289e-02f, 7.21607685e-01f, 7.37672225e-02f, 2.02542812e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  6.57088384e-02f, 4.80465591e-01f, 2.59488016e-01f, 3.35437536e-01f, 2.42730260e-01f, 2.65502125e-01f, 2.80665725e-01f, 3.25952381e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -3.40811282e-01f, -5.63763618e-01f, 4.80496198e-01f, -8.83652940e-02f, 2.05075800e-01f, 1.33056000e-01f, 2.40032285e-01f, -3.84174973e-01f, 5.17379567e-02f, 1.65027037e-01f,
  -1.22851498e-01f, -4.37140837e-02f, -2.12971091e-01f, 2.97430396e-01f, -7.77007937e-02f, -4.30915922e-01f, 4.32489902e-01f, -7.61225760e-01f, -3.88031065e-01f, 4.34067369e-01f,
  -4.49203290e-02f, 1.39240146e-01f, 6.22055054e-01f, 5.81546128e-01f, -4.03135568e-01f, 5.84494770e-01f, -6.37061954e-01f, 6.97314739e-01f, -7.72181213e-01f, -5.25848448e-01f,
  -9.09292996e-01f, -9.06735361e-01f, -4.80319709e-01f, 1.71934649e-01f, -6.56035483e-01f, 2.57507831e-01f, -6.08320057e-01f, -8.83154124e-02f, 1.66921616e-01f, 3.52457970e-01f,
  3.25028509e-01f, -5.17385244e-01f, 3.67976665e-01f, 4.15163577e-01f, -2.15414971e-01f, 5.52100599e-01f, -8.30606669e-02f, 7.29919791e-01f, 1.76691428e-01f, 7.70744979e-01f,
  5.32110751e-01f, 6.72335625e-01f, 5.54094672e-01f, 5.51902413e-01f, -7.88463950e-01f, 2.66731203e-01f, -3.10230345e-01f, 8.33038986e-01f, -5.05574048e-01f, -5.35635173e-01f,
  -6.86426759e-01f, -6.24021173e-01f, -6.73094749e-01f, 1.01418927e-01f, -1.70697168e-01f, 1.89344853e-01f, -2.79538065e-01f, -1.19730078e-01f, -2.51849651e-01f, 7.41348937e-02f,
  -1.55134439e-01f, 2.40643322e-01f, -2.97505587e-01f, 1.56109363e-01f, -1.96963832e-01f, 5.19439466e-02f, -1.81000173e-01f, 3.07030231e-01f, -1.65588364e-01f, 4.83557194e-01f,
  5.16799033e-01f, -2.65952349e-01f, -5.34190893e-01f, -4.69063908e-01f, 3.79916966e-01f, -1.49505287e-01f, -1.35195956e-01f, 5.77371895e-01f, -6.42032027e-01f, -6.04194283e-01f,
  -8.67023647e-01f, -4.35183644e-01f, 7.44997382e-01f, -7.94683635e-01f, -7.83564627e-01f, 8.00067663e-01f, -1.53638944e-01f, -5.32227576e-01f, 1.06324283e-02f, -2.36845925e-01f,
  -3.99335742e-01f, -3.11207771e-01f, -2.59850591e-01f, 1.60653010e-01f, -6.73535541e-02f, -4.80449408e-01f, 6.87405318e-02f, -5.61125934e-01f, 6.29602075e-01f, 1.51398346e-01f,
  5.93372703e-01f, 2.06008509e-01f, -4.18292254e-01f, -6.64509416e-01f, -3.81143391e-01f, 2.91558743e-01f, 2.28747472e-01f, -2.85942525e-01f, -5.87818086e-01f, -1.33065373e-01f,
  6.93232775e-01f, -8.21817666e-02f, -8.29642732e-03f, 1.69560522e-01f, -8.92003596e-01f, 5.01777470e-01f, -6.79387867e-01f, -6.13669991e-01f, 4.63323981e-01f, 4.20649976e-01f,
  -1.26393318e-01f, -7.52946734e-03f, 1.01567827e-01f, -4.98110741e-01f, -7.97321022e-01f, -9.75484401e-02f, -7.21202493e-01f, 2.25805700e-01f, 4.25297379e-01f, 3.36774826e-01f,
  2.25294441e-01f, 7.46994138e-01f, 7.13189125e-01f, -3.62155885e-01f, -3.04185539e-01f, -5.58256269e-01f, -4.08382326e-01f, -5.29652119e-01f, -2.59895504e-01f, 4.91658568e-01f,
  -1.17478818e-01f, -3.10495585e-01f, -7.85579145e-01f, -2.33735647e-02f, 4.61673498e-01f, 5.04335225e-01f, 2.11975843e-01f, -2.54532576e-01f, 2.97645628e-01f, -9.01283205e-01f,
  2.85347521e-01f, 2.67267376e-01f, 2.86474913e-01f, 4.64621484e-01f, 5.79196513e-01f, 4.00395662e-01f, 1.40246183e-01f, 2.22544611e-01f, 3.82590562e-01f, 6.78612411e-01f,
  9.30555817e-03f, 5.82841694e-01f, -1.66567907e-01f, -8.25003386e-01f, -6.41140282e-01f, -2.72558004e-01f, 6.15374923e-01f, 1.84311375e-01f, 7.45920122e-01f, 7.15767086e-01f,
  -1.92895114e-01f, -2.14123040e-01f, 9.69620109e-01f, -1.60797000e-01f, -1.32097587e-01f, -6.50786683e-02f, 6.75126791e-01f, -4.01811123e-01f, -6.86692536e-01f, 3.66720855e-01f,
  -3.49078953e-01f, -2.28653073e-01f, 5.21546185e-01f, -1.62585109e-01f, 2.77294725e-01f, 3.20286334e-01f, 3.92459363e-01f, -9.50475503e-03f, 2.65132099e-01f, -3.44679326e-01f,
  2.80996352e-01f, -3.06877624e-02f, 2.25337714e-01f, -3.39711905e-01f, 4.68447894e-01f, -2.85399914e-01f, -3.84346485e-01f, -3.20210397e-01f, -8.78792822e-01f, -2.88329899e-01f,
  2.45796412e-01f, -2.07965121e-01f, 3.05657629e-02f, -5.00611544e-01f, -7.28720240e-03f, -5.38699448e-01f, -7.25857615e-01f, -1.33033061e+00f, 3.19909811e-01f, -8.07044148e-01f,
  6.08543873e-01f, -6.08230412e-01f, 2.52996050e-02f, 5.71491420e-01f, 1.15237363e-01f, -1.27488405e-01f, -6.89174682e-02f, -2.01396331e-01f, 5.24439551e-02f, -1.20986402e-01f,
  -2.20842540e-01f, -4.32771295e-01f, -6.32891357e-02f, 1.33347511e-01f, -2.49146596e-01f, 1.47322014e-01f, 4.70417976e-01f, 5.57979226e-01f, 3.63341689e-01f, 1.87342525e-01f,
  -3.99350137e-01f, 1.84611887e-01f, 3.80017281e-01f, 3.98596376e-01f, 1.77920803e-01f, -2.08919168e-01f, 7.57762492e-02f, 3.69446844e-01f, 6.04083166e-02f, -9.14651990e-01f,
  -4.41270769e-01f, 3.34988236e-01f, -7.31458545e-01f, 3.70822579e-01f, 4.57423776e-01f, 3.91864032e-01f, 8.71073306e-02f, -3.38096976e-01f, -2.35449821e-01f, -2.76444376e-01f,
  7.11178631e-02f, -4.04349476e-01f, 1.46243107e-02f, -4.17548448e-01f, 3.21249142e-02f, 4.43775430e-02f, 1.39858231e-01f, 2.58115411e-01f, -9.92028192e-02f, -5.17740428e-01f,
  3.97493280e-02f, 4.41206932e-01f, -4.25551862e-01f, 1.65629670e-01f, 1.02297895e-01f, -4.26248521e-01f, 4.94346857e-01f, -5.24827302e-01f, -2.85216987e-01f, -1.93307087e-01f,
  5.72302520e-01f, -3.00016522e-01f, -9.64614570e-01f, -5.48578322e-01f, 2.22288266e-01f, 6.25538349e-01f, -7.16852069e-01f, 2.47592274e-02f, -5.75403273e-01f, 2.27886289e-01f,
  4.37811702e-01f, 6.27464056e-02f, 1.53424934e-01f, 9.55384672e-02f, 7.66668469e-02f, 3.55593920e-01f, 1.70707554e-01f, -3.90132904e-01f, -4.35887396e-01f, 4.40493762e-01f,
  -6.81297898e-01f, -5.87630033e-01f, -1.49909630e-02f, -3.15647990e-01f, 6.40196562e-01f, 5.50649583e-01f, -4.38714772e-01f, -5.50280154e-01f, 6.81759179e-01f, -6.49648011e-01f,
  6.28075719e-01f, -2.18094528e-01f, -4.85231817e-01f, -9.00173426e-01f, -6.83290362e-01f, 7.69447446e-01f, 1.08221427e-01f, -9.17536199e-01f, 6.79195702e-01f, -1.91316262e-01f,
  9.74677429e-02f, 2.72027194e-01f, 1.80254672e-02f, -2.45315731e-01f, 4.92726505e-01f, 1.86002031e-01f, 2.92076170e-01f, 5.31331487e-02f, -4.95502591e-01f, -6.47143722e-01f,
  5.21830609e-03f, -5.17856777e-01f, -4.55961227e-01f, 6.60930395e-01f, -6.06745720e-01f, -6.79468930e-01f, 9.91038829e-02f, 4.00270790e-01f, -1.48246914e-01f, -6.03720427e-01f,
  -5.39287090e-01f, 7.35399723e-02f, -7.64678001e-01f, -1.65927127e-01f, 6.93086922e-01f, 2.24854246e-01f, 3.30565244e-01f, -6.90072358e-01f, 3.94782454e-01f, -7.57762432e-01f,
  -8.01266372e-01f, -9.50256109e-01f, -2.19085768e-01f, -1.79005414e-01f, 2.21326306e-01f, -1.49424449e-01f, -3.63796920e-01f, 5.12623563e-02f, 2.26997361e-01f, -8.35724697e-02f,
  -4.94128525e-01f, -2.68023878e-01f, -1.43559352e-01f, -5.63756526e-01f, 5.53121865e-01f, -3.77645373e-01f, 4.72572207e-01f, -3.56654495e-01f, -1.90431297e-01f, 5.64681292e-01f,
  -2.07272455e-01f, -3.78421396e-01f, -4.93572146e-01f, 6.31563962e-01f, 5.71294248e-01f, 1.22761719e-01f, 2.69279987e-01f, -8.36657107e-01f, -2.67324746e-01f, -8.04836392e-01f,
  4.33414817e-01f, 4.14419025e-01f, 4.95376170e-01f, -8.69677961e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.06091662e-02f, 5.13627604e-02f, 1.61331706e-03f, -5.05760349e-02f, -1.71741650e-01f, 2.45606706e-01f, -1.13347106e-01f, -2.18689099e-01f, -4.03612331e-02f, 1.41721014e-02f,
  -4.34777439e-02f, 3.61517668e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    