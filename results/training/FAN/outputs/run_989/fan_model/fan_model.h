/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.13088262e-01f, 8.83151591e-02f, 2.64488399e-01f, -1.00118123e-01f, -2.48398930e-01f, 6.16336688e-02f, 1.55997425e-01f, 2.86631454e-02f, -6.08508661e-02f, 7.20952312e-03f,
  -3.53101909e-01f, -2.67233104e-01f, -1.73651710e-01f, -7.26171955e-02f, 2.76502579e-01f, 1.80814818e-01f, 2.30225220e-01f, 3.60194385e-01f, 1.85700864e-01f, -1.60525322e-01f,
  -2.39322171e-01f, -8.98631513e-02f, 1.59752637e-01f, -1.31545321e-03f, -7.93091506e-02f, 2.98886206e-02f, 7.74148479e-02f, 1.05501547e-01f, 9.87447724e-02f, 2.44926289e-01f,
  2.79203326e-01f, 9.07679612e-04f, -1.27948616e-02f, -6.62662089e-02f, -1.55694455e-01f, -7.23321782e-03f, -1.32755078e-02f, 5.57112582e-02f, -2.26802733e-02f, -2.84005329e-03f,
  -9.11015943e-02f, -7.84505457e-02f, -1.70335192e-02f, -8.81107002e-02f, -1.30724367e-02f, 4.22355868e-02f, -1.55554451e-02f, 7.36535117e-02f, -1.86551884e-02f, -5.85344480e-03f,
  -1.01293527e-01f, -1.80911183e-01f, 1.63294114e-02f, 3.70717905e-02f, 6.59089237e-02f, -1.34198934e-01f, 2.14446355e-02f, 5.39500117e-02f, 5.15106395e-02f, 2.07860947e-01f,
  -2.79279891e-02f, -1.68471672e-02f, -2.32005566e-02f, 9.35660899e-02f, -6.11965694e-02f, -1.12086935e-02f, -1.30683221e-02f, -2.00746674e-03f, -1.96523741e-02f, -5.93123585e-03f,
  1.52558424e-02f, -3.97057086e-02f, 5.46558239e-02f, 2.74156500e-03f, -2.64715720e-02f, -5.60422204e-02f, 5.83478361e-02f, 2.51875110e-02f, -2.17223763e-02f, -3.41392830e-02f,
  2.68675219e-02f, -1.17677622e-01f, -5.28304055e-02f, 6.62681386e-02f, -2.69037066e-03f, -9.57419202e-02f, 4.05597463e-02f, -1.05591558e-01f, 6.92120641e-02f, -5.58106788e-02f,
  1.24099314e-01f, -3.60371917e-02f, 7.40928650e-02f, 2.75746770e-02f, 1.25173196e-01f, -4.97702099e-02f, 3.15114483e-03f, 2.88403146e-02f, -2.31018122e-02f, 1.08714439e-01f,
  1.13179283e-02f, 1.07677810e-01f, 5.49303554e-02f, 3.23545337e-02f, -2.21423954e-02f, -4.01523113e-02f, -4.53721844e-02f, -1.76203549e-02f, 3.78798433e-02f, -8.83172080e-02f,
  -1.47350654e-02f, 3.52248959e-02f, 8.08390006e-02f, 1.05240427e-01f, -7.81424046e-02f, 6.14672154e-02f, 7.26445094e-02f, 5.19964285e-02f, 1.84148058e-01f, 2.52302110e-01f,
  -6.41466379e-01f, -3.87975901e-01f, -1.01566158e-01f, -2.80026525e-01f, 9.18225292e-03f, -1.70891602e-02f, -1.79718807e-01f, -4.86530662e-02f, -7.44702592e-02f, -4.20637727e-02f,
  1.61723554e-01f, 2.34649584e-01f, 7.24276062e-03f, 1.98763385e-01f, -8.49008262e-02f, -2.50075430e-01f, -2.61630863e-01f, -1.37483075e-01f, 6.76597655e-02f, 1.96984157e-01f,
  6.11763634e-02f, -2.87933260e-01f, -2.93200672e-01f, 4.57530096e-02f, -5.88333840e-03f, 8.97593722e-02f, -8.33994821e-02f, -2.30090067e-01f, 8.18903670e-02f, -9.88564268e-02f,
  -3.25594433e-02f, -1.20741434e-01f, 2.10915953e-01f, 1.28467321e-01f, 1.91061825e-01f, 6.91046417e-02f, 1.29355490e-01f, 1.59861207e-01f, 1.92628473e-01f, 1.16124912e-03f,
  1.09831929e-01f, 2.02845305e-01f, 3.82816279e-03f, 8.12750012e-02f, 1.44886356e-02f, 1.87154822e-02f, 3.75498980e-02f, 2.23267376e-02f, 1.65626109e-01f, 1.22686870e-01f,
  1.02165870e-01f, 7.20741525e-02f, -1.46191278e-02f, 6.62272796e-02f, 1.81697518e-01f, 1.21268183e-01f, 1.31665587e-01f, 1.16481721e-01f, 1.24306545e-01f, 8.30779076e-02f,
  -1.29286006e-01f, 5.17297303e-03f, -5.87265156e-02f, -9.88006368e-02f, -1.26008675e-01f, 2.24019345e-02f, -8.91556591e-02f, -4.27032746e-02f, -2.58991774e-02f, -7.45826513e-02f,
  -1.14286384e-02f, -5.74212559e-02f, -1.29622277e-02f, -1.74347922e-01f, -1.38795814e-02f, -7.05891289e-03f, -9.01922509e-02f, -7.12887049e-02f, 6.07711356e-03f, -6.79590628e-02f,
  -7.42766261e-02f, 4.72119302e-02f, -8.35420191e-02f, 1.10453954e-02f, -7.00311065e-02f, -4.79708984e-02f, -9.31602940e-02f, -1.08862109e-02f, -8.78064930e-02f, 2.88671418e-03f,
  -2.38022700e-01f, 2.05289572e-01f, 8.50290619e-03f, 3.57696898e-02f, 4.81062010e-02f, 1.43266782e-01f, 1.09657519e-01f, 1.18474171e-01f, 9.64409932e-02f, 6.24977872e-02f,
  8.52708444e-02f, 6.48294613e-02f, 3.27898338e-02f, 8.09346661e-02f, 8.48620310e-02f, 3.47829089e-02f, -1.09752595e-01f, 4.06482704e-02f, 5.81301898e-02f, 2.00810879e-01f,
  -7.78524205e-03f, -4.02311012e-02f, -1.37047157e-01f, 2.25832108e-02f, -4.99963164e-02f, -6.50262311e-02f, 8.80473703e-02f, 3.34678851e-02f, -1.12433173e-02f, -1.90530270e-01f,
  -6.76803708e-01f, -1.33237392e-01f, -1.80920601e-01f, -1.78240135e-01f, -4.29216214e-02f, -1.04173712e-01f, -1.95928693e-01f, -2.61594445e-01f, -1.17976479e-01f, -9.46151763e-02f,
  8.98524001e-02f, 2.79949725e-01f, 1.85240075e-01f, 2.14783490e-01f, -1.79748312e-01f, -2.91237105e-02f, -1.41714394e-01f, -1.87308371e-01f, -7.65449777e-02f, 9.14923102e-02f,
  2.50063300e-01f, -5.46319708e-02f, -1.27014548e-01f, -5.81480516e-03f, 1.43616974e-01f, 3.19998115e-01f, 1.62992418e-01f, 2.54564229e-02f, 1.55889958e-01f, 1.44926161e-02f,
  2.56250232e-01f, -3.74637216e-01f, 8.07795860e-03f, -8.71827304e-02f, 2.86598951e-02f, -6.52948394e-02f, -9.76447165e-02f, -1.62048385e-01f, -6.14797063e-02f, -3.07782069e-02f,
  -1.17332064e-01f, 2.90127322e-02f, 1.75622404e-02f, 7.90716484e-02f, -3.13082524e-02f, -3.74257304e-02f, 2.20129732e-02f, -9.39804465e-02f, -9.28952172e-02f, 4.92277816e-02f,
  5.43563068e-02f, -1.35180891e-01f, -1.27950490e-01f, -7.54861757e-02f, -7.82342479e-02f, -6.94626495e-02f, -9.17971656e-02f, -2.64583491e-02f, -1.16479300e-01f, -1.60063729e-01f,
  -2.39284616e-02f, -1.44568961e-02f, -2.76853014e-02f, -6.19639345e-02f, -1.15096914e-02f, 3.04158721e-02f, -8.08392372e-03f, -7.84871206e-02f, -3.93487476e-02f, -7.18348697e-02f,
  6.73225289e-03f, -2.25581471e-02f, -5.29033877e-02f, -1.96591299e-02f, 7.22450018e-02f, -5.09059168e-02f, -1.08745970e-01f, 1.38309021e-02f, -4.75098602e-02f, -1.37263234e-03f,
  -1.87723264e-02f, -2.21650973e-02f, 1.22649699e-01f, 4.05398346e-02f, 5.29535860e-02f, -6.89493418e-02f, -8.40092450e-02f, -7.93478042e-02f, -4.19243164e-02f, -9.02897492e-02f,
  3.83326977e-01f, -2.52129305e-02f, 1.04782119e-01f, 1.82849374e-02f, -5.14124408e-02f, 7.16804862e-02f, -2.65705548e-02f, -1.61855184e-02f, -3.95733789e-02f, -8.70650858e-02f,
  -3.47899646e-02f, -5.79705425e-02f, 6.01356104e-02f, -4.04392332e-02f, -1.65672190e-02f, -3.86214815e-02f, 2.03523729e-02f, 3.11775482e-03f, 5.09019829e-02f, -7.86799863e-02f,
  -8.63977429e-03f, -5.11570945e-02f, -1.19450167e-01f, -9.56313908e-02f, 3.42170969e-02f, 3.96717787e-02f, 1.26884758e-01f, 3.25861461e-02f, -2.60117296e-02f, 2.69421339e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.22818112e+00f, -4.81615841e-01f, -6.25340343e-01f, 2.92710423e-01f, -4.95045066e-01f, -1.05392449e-01f, -3.68174225e-01f, 3.95840071e-02f, 1.49414644e-01f, -3.48866820e-01f,
  -4.03869189e-02f, 3.36256444e-01f, 3.38349909e-01f, 1.17861547e-01f, 5.28416395e-01f, -3.57863605e-01f, -2.77851492e-01f, 2.34616309e-01f, 3.54325503e-01f, -1.09482892e-01f,
  -9.87510234e-02f, 1.20900638e-01f, 4.47785467e-01f, 2.07717076e-01f, -5.09222806e-01f, 8.29728246e-02f, -4.68758523e-01f, -2.66275615e-01f, -2.46451020e-01f, -5.44375956e-01f,
  -1.07775502e-01f, -6.23384900e-02f, -6.47444185e-03f, 5.45129627e-02f, -1.06442571e-01f, 1.30511418e-01f, -1.02516115e-01f, -1.15247346e-01f, 9.38090086e-02f, 2.27841251e-02f,
  -5.46228550e-02f, -9.57810581e-02f, 6.30359128e-02f, -7.50282854e-02f, -2.13522673e-01f, -5.59551306e-02f, -2.39563778e-01f, 4.73079495e-02f, 1.44400284e-01f, -2.27907702e-01f,
  -1.56551823e-01f, -8.52217078e-02f, -1.25219509e-01f, -8.98176357e-02f, 8.95616785e-02f, 1.06163964e-01f, -2.51947999e-01f, -8.71658176e-02f, -2.04876721e-01f, -4.03231442e-01f,
  -3.28636169e-02f, -4.34039682e-02f, -4.60274518e-02f, -1.68653727e-02f, 8.61850977e-02f, -3.31206545e-02f, -5.05657047e-02f, -3.03777941e-02f, 3.43936495e-02f, 1.80969965e-02f,
  -9.29895788e-02f, 4.87690307e-02f, 8.67120828e-03f, 8.01672488e-02f, 2.93420572e-02f, -4.71311547e-02f, 8.12071860e-02f, 3.76860611e-02f, 1.73344743e-02f, 1.20838851e-01f,
  8.04469809e-02f, 1.67898517e-02f, 5.05763514e-04f, 3.77134420e-02f, -4.26983945e-02f, -6.86922446e-02f, -7.57559482e-03f, -7.47462586e-02f, 1.53534673e-03f, 6.69803051e-03f,
  1.83067277e-01f, 1.89693421e-01f, 4.62362543e-02f, -5.86346723e-02f, -6.27065226e-02f, 7.92192668e-02f, 3.80661711e-02f, 6.47497997e-02f, 1.33233666e-01f, 2.19993442e-02f,
  -1.06108207e-02f, 1.32424831e-01f, -2.51142263e-01f, -9.43404883e-02f, -1.58565200e-03f, 7.14478781e-03f, -4.74877395e-02f, 1.16959341e-01f, 4.24617752e-02f, -1.72061455e-02f,
  -9.98938456e-03f, 9.69853774e-02f, 1.60162017e-01f, 8.32356289e-02f, 1.00465894e-01f, 1.79603532e-01f, -1.23864543e-02f, -2.05059014e-02f, 1.89779997e-01f, 1.09849544e-02f,
  1.12004328e+00f, 7.00512767e-01f, 1.99268848e-01f, 1.09945633e-01f, 3.06946129e-01f, 2.10815907e-01f, 4.35608774e-01f, 3.07203829e-02f, -1.60513416e-01f, 1.82417706e-01f,
  3.76936555e-01f, -2.46355087e-01f, -2.97700286e-01f, -2.25996763e-01f, 1.20416898e-02f, 1.23551250e-01f, -1.17533460e-01f, -1.09744012e-01f, -3.06214392e-01f, 2.97779907e-02f,
  -1.53168021e-02f, 1.31909877e-01f, 1.14023723e-01f, -1.08837709e-01f, 1.65914372e-01f, -4.04456675e-01f, -6.34036446e-03f, 2.99895376e-01f, 2.92308480e-01f, 1.58278257e-01f,
  4.61124003e-01f, 7.37084568e-01f, -6.08583272e-01f, -1.68670967e-01f, 1.40283912e-01f, -1.42757734e-02f, -8.93610939e-02f, -9.37789213e-03f, 3.83749455e-02f, -1.27753213e-01f,
  -1.76012497e-02f, 1.04269236e-02f, 1.83317110e-01f, 1.17268547e-01f, 1.10738017e-01f, 1.05632454e-01f, 4.61885929e-02f, 3.43273804e-02f, -1.45115517e-02f, 2.60098521e-02f,
  7.43411994e-03f, 3.68997097e-01f, 2.25313857e-01f, 1.87562276e-02f, 1.53252080e-01f, 2.65960507e-02f, 5.14915735e-02f, 1.82029173e-01f, -5.78980632e-02f, 8.46311525e-02f,
  -7.25886822e-02f, 1.81656498e-02f, 9.49184597e-02f, 1.52783409e-01f, 1.73225865e-01f, -5.33454306e-03f, 2.22794693e-02f, -5.34361340e-02f, -3.98560576e-02f, 1.30716398e-01f,
  -2.01818466e-01f, 7.84922689e-02f, -1.52970105e-03f, 3.34382914e-02f, -8.54697451e-03f, 1.08026512e-01f, 6.89673424e-02f, 4.80909050e-02f, 7.82820210e-02f, 1.41864652e-02f,
  1.44892884e-02f, -5.34171052e-02f, 5.54378890e-02f, 5.53371385e-02f, 5.93849085e-02f, -7.07646878e-03f, -1.88420266e-02f, 7.53060728e-02f, -4.07150909e-02f, 2.99793947e-02f,
  -5.70508659e-01f, 4.26984504e-02f, 5.59626594e-02f, -5.96397854e-02f, -1.32384440e-02f, -9.47161987e-02f, 5.77780455e-02f, -7.78688639e-02f, -9.06341076e-02f, -1.41405866e-01f,
  4.22135601e-03f, -7.55094513e-02f, 9.73424464e-02f, -7.43396115e-03f, -1.16662666e-01f, -1.27684787e-01f, -6.91056252e-02f, -1.38285801e-01f, -1.83901221e-01f, 1.54475132e-02f,
  -5.72121888e-02f, -9.73061100e-02f, -1.02928057e-01f, -3.57781976e-01f, -1.16122589e-01f, -3.39467406e-01f, -9.79775488e-02f, 2.96774488e-02f, -1.69936627e-01f, -2.92705178e-01f,
  4.92194653e-01f, -8.30985755e-02f, 2.54769474e-01f, 2.71282434e-01f, 1.42864436e-01f, -9.55257192e-02f, -2.96101332e-01f, -1.86711382e-02f, 1.18702769e-01f, 8.82412568e-02f,
  3.49646717e-01f, 5.93832135e-01f, 5.13454735e-01f, 3.85829180e-01f, 2.30005950e-01f, -5.43439016e-02f, -1.78188756e-02f, 3.04279834e-01f, 3.44707251e-01f, 2.80453831e-01f,
  1.22985497e-01f, -1.31057426e-01f, 1.41281243e-02f, 1.46362841e-01f, 2.09598262e-02f, 3.31313848e-01f, 2.97113191e-02f, -3.22148390e-02f, -1.57862529e-02f, -2.82198638e-02f,
  4.77630109e-01f, -4.68511917e-02f, 7.09727183e-02f, 2.88463347e-02f, 6.28643259e-02f, -1.69613510e-01f, 9.81762260e-02f, -5.36272638e-02f, -5.32437190e-02f, -1.85959473e-01f,
  1.94880348e-02f, -9.40614790e-02f, -2.48215231e-03f, -1.41245857e-01f, -1.67885721e-01f, -1.10289074e-01f, -1.25877857e-01f, -2.19361042e-03f, 1.24344267e-01f, 8.24449211e-02f,
  6.88446090e-02f, 2.26667207e-02f, 4.64384854e-02f, 6.39091209e-02f, 4.01354432e-02f, 7.46890306e-02f, 6.35851547e-02f, 5.33398725e-02f, 8.66040289e-02f, 8.68121535e-02f,
  4.25827652e-01f, 9.01479051e-02f, 3.33392262e-01f, 4.61099483e-02f, 4.24489789e-02f, -1.34626348e-02f, 3.79677936e-02f, 1.06480286e-01f, 5.84426150e-02f, -8.05914700e-02f,
  -4.57085781e-02f, 1.99961007e-01f, 6.43232763e-02f, 2.31990024e-01f, 3.39436442e-01f, 7.20080584e-02f, -2.58695949e-02f, 2.39465814e-02f, -3.60420123e-02f, -7.77083486e-02f,
  -1.55707281e-02f, -1.20881014e-01f, 5.99669553e-02f, -1.17207117e-01f, -1.41724586e-01f, 1.73874810e-01f, 2.58097704e-03f, -1.61622080e-03f, 5.36146685e-02f, -1.38841242e-01f,
  -6.86610043e-02f, 3.14452350e-01f, 1.29675016e-01f, -8.64044055e-02f, -2.08223909e-01f, -1.02193393e-01f, 1.51653171e-01f, -1.41214743e-01f, -2.96869606e-01f, -9.43192393e-02f,
  -3.46715525e-02f, 4.79025058e-02f, -1.13482416e-01f, -8.39139074e-02f, -2.06335217e-01f, -1.97413906e-01f, -2.82352977e-02f, 2.58410275e-02f, -9.82497782e-02f, -1.40786275e-01f,
  -1.16032258e-01f, -1.26441583e-01f, 1.46705776e-01f, 5.59672862e-02f, -7.86707774e-02f, 1.46098152e-01f, 1.02810338e-01f, -6.79564290e-03f, 5.44154979e-02f, -9.02142450e-02f,
  -1.39139533e+00f, 4.18502420e-01f, 1.78549439e-01f, -3.02462220e-01f, -1.50264651e-01f, -2.70548612e-01f, 1.95033997e-01f, 1.76964745e-01f, -2.45747901e-02f, 1.37126803e-01f,
  7.11123496e-02f, -3.14298458e-02f, 3.94774377e-02f, 9.85603034e-02f, -1.40781119e-01f, 2.25171164e-01f, -1.46424875e-01f, -4.03666049e-01f, -4.40789551e-01f, 3.10320240e-02f,
  7.51519129e-02f, -3.46134394e-01f, -6.31538391e-01f, -2.94501990e-01f, 2.79281676e-01f, -1.18152099e-02f, 3.42258662e-01f, -6.37803301e-02f, -4.44849627e-03f, 1.06335804e-01f,
  1.05419740e-01f, 1.83424670e-02f, -1.39418155e-01f, -3.53088439e-01f, 7.60577712e-03f, -1.13882162e-01f, -9.04877707e-02f, -1.45114198e-01f, -8.04161578e-02f, -7.17255920e-02f,
  -3.27986062e-01f, -6.56113103e-02f, -1.84486240e-01f, -3.33440751e-02f, -2.58611381e-01f, -6.94878474e-02f, -7.66358301e-02f, -9.52499881e-02f, 5.60594462e-02f, 1.70419142e-01f,
  9.30345356e-02f, -1.28096968e-01f, 3.62410620e-02f, 1.90087423e-01f, 2.01673470e-02f, -9.70838070e-02f, 2.05685973e-01f, 4.87378612e-02f, -5.30014820e-02f, 1.15238778e-01f,
  7.44794607e-02f, 1.22367488e-02f, 3.93040664e-02f, 8.26055780e-02f, 8.13691691e-03f, 7.95029700e-02f, -7.02976733e-02f, 4.01535518e-02f, -3.24480385e-02f, 4.70724925e-02f,
  6.12433217e-02f, 4.34463806e-02f, 5.52516095e-02f, 3.30666378e-02f, 3.06900926e-02f, -7.77845532e-02f, -8.19340199e-02f, 1.65874064e-01f, 3.00824223e-03f, -1.35241464e-01f,
  -3.79794911e-02f, -6.04479760e-02f, -1.41021581e-02f, 1.66825335e-02f, -3.00582382e-03f, -5.53678200e-02f, -1.99875422e-02f, 3.33185270e-02f, -2.41482053e-02f, -1.67661861e-01f,
  3.05931747e-01f, -1.06763825e-01f, 6.47246316e-02f, 5.71766049e-02f, -6.32673651e-02f, 1.15448132e-01f, -3.22354981e-03f, 8.54591057e-02f, 4.04219888e-02f, 5.18053509e-02f,
  -3.37580480e-02f, -2.07240209e-02f, -3.43466699e-02f, -1.76574178e-02f, -1.22262336e-01f, 7.10990727e-02f, 2.08617643e-01f, 1.11973137e-01f, 4.36782390e-02f, 5.32233119e-02f,
  1.61032960e-01f, 7.69459233e-02f, 2.63274722e-02f, 9.87729505e-02f, 1.29652992e-01f, -3.56391072e-02f, 6.40060455e-02f, 8.55090469e-02f, -6.74220994e-02f, 3.13456625e-01f,
  1.94880635e-01f, 2.00501263e-01f, -1.08795273e+00f, 1.80133894e-01f, -4.49562997e-01f, -4.45673704e-01f, -1.59619510e-01f, 2.90746242e-01f, 3.41109604e-01f, -3.15424055e-01f,
  3.96575406e-02f, 4.71026033e-01f, -1.01412050e-01f, -2.10999280e-01f, -3.15177739e-01f, -6.15681469e-01f, -7.08945334e-01f, -5.20341516e-01f, 4.52017738e-03f, 4.08336639e-01f,
  3.50782663e-01f, 3.50555658e-01f, 1.55214429e-01f, 5.01900241e-02f, 1.67561069e-01f, 3.14696491e-01f, -3.81217629e-01f, -1.97452173e-01f, -1.90936998e-01f, -4.87943411e-01f,
  -2.78517097e-01f, -3.43717486e-01f, -2.35081345e-01f, 1.67077165e-02f, 1.86713129e-01f, -4.64179087e-03f, 1.44858342e-02f, 2.39456035e-02f, 1.21202052e-01f, -4.26254906e-02f,
  1.10921696e-01f, 4.65293080e-02f, -1.16952464e-01f, -7.45567903e-02f, 1.41499653e-01f, -3.69875208e-02f, -1.64687127e-01f, -1.46503836e-01f, -3.49646568e-01f, -6.52635768e-02f,
  -5.43162264e-02f, -4.15781438e-01f, -4.54331249e-01f, -1.81674764e-01f, -3.67349982e-01f, -5.07242203e-01f, 1.08990476e-04f, -8.36375542e-03f, -4.82967257e-01f, 3.84479910e-01f,
  5.15787639e-02f, -1.81227013e-01f, -7.63483047e-02f, 7.86498114e-02f, 1.81851044e-01f, -2.72902157e-02f, -1.51513051e-02f, 1.17745109e-01f, 6.72013452e-03f, 1.48756981e-01f,
  4.31468189e-02f, -9.22647044e-02f, 1.20253406e-01f, 2.31013224e-02f, -6.66300505e-02f, -7.43584931e-02f, 1.00160412e-01f, -8.87341797e-02f, -1.29917353e-01f, 1.75528973e-01f,
  2.01114729e-01f, -4.40597981e-02f, 1.69487309e-03f, 2.96759188e-01f, -2.07773253e-01f, -1.19825296e-01f, 1.61273424e-02f, 4.70818132e-02f, 2.07900926e-02f, -1.76110849e-01f,
  6.34913564e-01f, -9.06581640e-01f, 1.14568487e-01f, 4.76747714e-02f, -1.33107165e-02f, 9.61140245e-02f, 1.51296556e-01f, -1.46853169e-02f, -7.29721738e-03f, 1.61097646e-01f,
  -2.01152116e-02f, 2.96248674e-01f, 1.44376367e-01f, 5.72322197e-02f, -2.98285168e-02f, 3.10761165e-02f, 1.18044615e-01f, -3.77065718e-01f, -1.74115911e-01f, 1.11148044e-01f,
  1.19112715e-01f, 1.76117510e-01f, 6.62886351e-02f, 9.99766588e-02f, 4.05403189e-02f, -5.76145537e-02f, 2.25499719e-01f, 3.10600877e-01f, -1.20938502e-01f, 7.24721491e-01f,
  -7.57700264e-01f, 3.03922474e-01f, -6.69612765e-01f, -1.75035536e-01f, 6.84377611e-01f, 3.96401286e-01f, 4.43615019e-01f, -4.22760606e-01f, -3.14994574e-01f, 1.90787509e-01f,
  4.55428183e-01f, 1.75366253e-01f, -2.42846441e-02f, -9.62628871e-02f, -2.20295966e-01f, 1.71232492e-01f, 1.63194552e-01f, -4.35177654e-01f, -4.93524373e-01f, 3.34627330e-01f,
  8.56752098e-01f, -1.06855355e-01f, -7.48362541e-01f, -3.25616390e-01f, 1.74968347e-01f, 8.86650383e-02f, -2.77869493e-01f, 1.28569946e-01f, 3.54913116e-01f, 5.16488612e-01f,
  1.71000466e-01f, -1.70335382e-01f, 3.09263244e-02f, 2.22719744e-01f, 4.79588471e-02f, -2.74837464e-01f, -1.00394189e-01f, -1.14747465e-01f, -3.67999412e-02f, -8.95138383e-02f,
  4.66325611e-01f, 6.20946363e-02f, 8.91396105e-02f, 7.45679019e-03f, -2.99127728e-01f, -1.38354108e-01f, -4.88939166e-01f, -4.87288207e-01f, -4.95217800e-01f, -2.61982888e-01f,
  6.74563289e-01f, 5.19351065e-01f, -2.92884499e-01f, -1.95020616e-01f, -2.33646885e-01f, -1.30354568e-01f, -1.59561649e-01f, -3.62189025e-01f, -3.01484436e-01f, -5.29233694e-01f,
  2.52971612e-02f, -5.11500053e-04f, -3.31047140e-02f, 3.32726017e-02f, -9.26657841e-02f, 5.16866483e-02f, 6.79000914e-02f, 1.46907091e-01f, 8.11493844e-02f, -2.80127585e-01f,
  1.87518634e-02f, 4.54036705e-02f, -1.17704347e-01f, -3.51714864e-02f, -1.80558823e-02f, 1.50507480e-01f, 5.44269308e-02f, -3.22705060e-02f, 1.49968201e-02f, 8.71499702e-02f,
  7.51194954e-02f, -4.59521171e-03f, -7.78287277e-03f, 6.25425354e-02f, 5.65885156e-02f, -7.74920592e-03f, 9.92656499e-03f, -8.57401490e-02f, -2.22012788e-01f, 1.32459223e-01f,
  -4.81848329e-01f, 5.24977632e-02f, -2.70824712e-02f, -1.70689851e-01f, -3.67706195e-02f, -8.27569142e-02f, 4.71814238e-02f, 4.58091050e-02f, 1.02416322e-01f, -1.78005010e-01f,
  -1.44009560e-01f, -1.71172425e-01f, -6.93399906e-02f, 2.70084273e-02f, 1.26453221e-01f, -1.70988664e-02f, -6.59047347e-03f, 2.16914549e-01f, 2.19104528e-01f, 5.07038943e-02f,
  -1.41934520e-02f, -1.34240568e-01f, -3.68644446e-01f, -3.41864645e-01f, 3.52678038e-02f, -4.47513759e-02f, -1.72684029e-01f, -1.90154433e-01f, -2.98493564e-01f, -5.96179605e-01f,
  -2.78578043e-01f, -2.42643192e-01f, 1.07842140e-01f, -2.29486480e-01f, 1.18044227e-01f, -1.01583354e-01f, -3.68260920e-01f, 1.21041849e-01f, 2.74413645e-01f, -1.07935280e-01f,
  -1.23514161e-02f, -1.19070321e-01f, -5.91735877e-02f, -2.19216898e-01f, -4.97843415e-01f, -2.81390250e-01f, -2.26704150e-01f, -4.91854966e-01f, -4.06825185e-01f, -9.75493938e-02f,
  -1.66743949e-01f, -2.58364469e-01f, -2.20379353e-01f, -4.15930338e-02f, 8.64709541e-02f, -1.46554500e-01f, 1.26582727e-01f, 1.19422004e-01f, 1.97891086e-01f, 3.40129226e-01f,
  -2.13395152e-02f, 8.33667696e-01f, 1.48946196e-01f, 1.29545301e-01f, -1.75435007e-01f, 1.06135696e-01f, 2.39711732e-01f, 9.51890573e-02f, 3.14080864e-01f, 1.82120308e-01f,
  6.18981011e-02f, 1.97896883e-01f, -1.03961844e-02f, -1.61675736e-01f, -3.29728872e-02f, -6.46866560e-02f, -2.55840421e-01f, -7.37217292e-02f, 1.81047425e-01f, 9.86666530e-02f,
  -2.10518420e-01f, -9.95608717e-02f, -2.68791735e-01f, -1.19196653e-01f, 3.96357775e-01f, -1.20705329e-01f, 1.33598447e-01f, 5.02899051e-01f, 1.21496916e-01f, -1.31916150e-01f,
  -5.70876487e-02f, -1.51263654e-01f, 3.47371548e-02f, -1.16297841e-01f, -9.26333070e-02f, 4.34698649e-02f, -1.07887099e-02f, -1.65273890e-01f, 3.50661911e-02f, -2.93956816e-01f,
  1.04217894e-01f, -5.60675710e-02f, 1.84515819e-01f, 1.40951321e-01f, 2.28385944e-02f, -1.71189785e-01f, 3.60022328e-04f, -9.70046744e-02f, -5.24756424e-02f, 2.01263011e-01f,
  -2.17580155e-01f, 7.82803670e-02f, -2.50585228e-02f, 2.39029154e-02f, 1.29141212e-01f, -4.50432412e-02f, -1.07924521e-01f, -1.21853381e-01f, -1.21286854e-01f, -4.27528955e-02f,
  -5.28368831e-01f, -7.21701533e-02f, -2.04111546e-01f, 1.04678683e-02f, -1.57156616e-01f, 1.14528157e-01f, 8.74852240e-02f, -4.55914252e-02f, 2.56820649e-01f, -1.27497315e-01f,
  1.58875093e-01f, 7.18824044e-02f, -1.38638243e-01f, -2.09790617e-01f, -1.22344725e-01f, -7.34075233e-02f, -4.06373620e-01f, -1.28200024e-01f, -1.19054891e-01f, 1.01270087e-01f,
  -3.36292416e-01f, -3.59611601e-01f, -6.06629908e-01f, -1.81631356e-01f, -1.03510074e-01f, -6.28198445e-01f, -2.84173459e-01f, 1.52097037e-03f, -4.85876620e-01f, -1.09139192e+00f,
  4.73182827e-01f, -2.00629845e-01f, 4.08811271e-01f, 1.40984043e-01f, -2.14276403e-01f, -6.73841774e-01f, -1.22009754e+00f, -5.26525736e-01f, -3.64739187e-02f, 2.92690210e-02f,
  -1.54383436e-01f, 7.79453069e-02f, 7.74637014e-02f, 2.89181736e-03f, -4.24598992e-01f, -3.67647409e-01f, 2.17655644e-01f, 4.16127622e-01f, -8.89515206e-02f, -4.76626843e-01f,
  -3.95047605e-01f, -5.02746785e-04f, 3.25206578e-01f, 1.60327896e-01f, 2.68582642e-01f, 1.01042047e-01f, 4.46922302e-01f, 3.74584287e-01f, -2.18941341e-03f, 8.03940415e-01f,
  3.15371603e-01f, -1.40055060e-01f, -1.70585766e-01f, 1.62654400e-01f, 3.17801684e-01f, -1.09770581e-01f, -2.70575974e-02f, 3.47181976e-01f, 3.34979966e-02f, 1.76949739e-01f,
  2.06310481e-01f, 1.37825295e-01f, 9.09308270e-02f, 2.12001242e-02f, -1.04752392e-01f, -2.52649277e-01f, 1.85011238e-01f, 4.45166826e-02f, 1.34414136e-01f, -3.70614566e-02f,
  -1.58750698e-01f, -2.45721056e-03f, -1.10292196e-01f, -4.58651453e-01f, -2.55780607e-01f, 2.22637922e-01f, -1.72072560e-01f, 9.42068845e-02f, -9.63075683e-02f, 1.47367314e-01f,
  -1.01750053e-01f, 9.32738334e-02f, 8.05175304e-02f, 4.72294129e-02f, 5.68745136e-02f, 5.26071638e-02f, 8.15671459e-02f, -8.97203982e-02f, -5.82716055e-03f, 1.20810501e-01f,
  6.94501251e-02f, -8.34211800e-03f, 1.21286290e-03f, 5.30707883e-03f, 8.69388878e-02f, -4.88671027e-02f, -1.02648111e-02f, 4.42727022e-02f, 4.76848781e-02f, 3.71818393e-02f,
  -4.16407697e-02f, 1.34981819e-03f, 1.57026395e-01f, 1.14535533e-01f, -8.93986523e-02f, 1.00982726e-01f, -8.40817206e-03f, -7.48134255e-02f, 9.68294740e-02f, 1.82407517e-02f,
  -9.99941975e-02f, -2.48630062e-01f, 1.35682374e-01f, -1.01832233e-01f, -1.05942553e-02f, 4.85262042e-03f, 1.41215965e-01f, -1.06163517e-01f, 3.73939145e-03f, -9.42682102e-02f,
  -1.39053330e-01f, -5.93792461e-02f, 4.93499264e-02f, 1.19414613e-01f, -1.47234783e-01f, -9.34676751e-02f, 1.22957723e-02f, -1.10073322e-02f, -1.20078757e-01f, 7.13658705e-02f,
  1.85626879e-01f, -3.12751323e-01f, -3.78006697e-01f, -3.96619052e-01f, -8.49779174e-02f, -1.00624286e-01f, -3.32314938e-01f, -5.61538562e-02f, -4.25530732e-01f, -5.10407805e-01f,
  2.90455729e-01f, -8.03249240e-01f, 6.25106096e-01f, 3.00230175e-01f, 3.20624709e-01f, 3.49564433e-01f, 1.21276170e-01f, 1.72545016e-01f, 1.45231754e-01f, -1.07565194e-01f,
  -5.07658005e-01f, -3.99440825e-01f, -4.20436680e-01f, -2.92232782e-01f, -1.50241181e-01f, 1.42055541e-01f, 4.81394917e-01f, 4.33087289e-01f, 4.36957031e-01f, 2.97019482e-01f,
  -5.46792522e-02f, -1.18302926e-02f, 7.04045221e-02f, 1.26222730e-01f, 1.48265973e-01f, 2.35979240e-02f, -8.23039338e-02f, -1.64650843e-01f, -2.51369715e-01f, 2.95657814e-01f,
  -1.92814786e-02f, -1.19479522e-01f, 6.76359236e-02f, -4.27601993e-01f, -1.38012484e-01f, -1.14085026e-01f, -1.75426360e-02f, 8.42114463e-02f, -9.41461399e-02f, -2.99968733e-03f,
  -2.12371394e-01f, -5.84699325e-02f, 4.46596146e-02f, -7.25772558e-03f, 5.49551323e-02f, -8.24037045e-02f, -7.93568715e-02f, -1.38533711e-02f, -1.36783928e-01f, -1.04088806e-01f,
  -2.67065793e-01f, -4.99069691e-03f, 5.50497845e-02f, 3.59870009e-02f, -1.03630930e-01f, -3.00412178e-02f, -6.97468594e-02f, -2.62154229e-02f, -1.08277164e-02f, 6.17964864e-02f,
  1.33129045e-01f, -5.12883142e-02f, -9.47734416e-02f, 9.50260013e-02f, 7.99490213e-02f, 3.11413687e-02f, 9.36894491e-02f, 2.75335237e-02f, -1.81046706e-02f, -5.94072696e-03f,
  8.85528773e-02f, 3.44747417e-02f, 2.56397109e-02f, -1.91545300e-02f, 9.35098529e-02f, 1.13499723e-01f, 1.75750136e-01f, -2.00967863e-01f, 4.30302732e-02f, 4.82980683e-02f,
  8.76525044e-02f, 9.75719914e-02f, 2.22631767e-02f, 4.65805456e-02f, 9.97437537e-03f, 5.33427894e-02f, 6.12219498e-02f, -1.70458168e-01f, -1.27925530e-01f, -3.04149301e-03f,
  -2.46121541e-01f, -3.63502294e-01f, 7.11047351e-02f, -8.86371285e-02f, -3.22949477e-02f, -7.83310682e-02f, -9.67560783e-02f, -1.03286661e-01f, -1.30774364e-01f, 6.25453563e-03f,
  -5.92998676e-02f, -3.42101008e-02f, -1.74769312e-01f, 5.62415682e-02f, 2.16926426e-01f, 8.09253193e-03f, -2.30094180e-01f, -1.35667741e-01f, -9.79404077e-02f, -6.13506287e-02f,
  -3.97837767e-03f, 1.22114360e-01f, 1.14488825e-01f, 8.26062858e-02f, 2.76427297e-03f, 9.38115716e-02f, 2.17182130e-01f, 3.96782681e-02f, 2.63673123e-02f, 1.12606294e-01f,
  -2.38242611e-01f, -4.03630197e-01f, -7.47005343e-02f, 4.20670271e-01f, 3.61007094e-01f, 3.98816317e-01f, 2.86296189e-01f, 2.88499713e-01f, 2.53533542e-01f, 3.46568227e-02f,
  -2.37309322e-01f, 3.77081223e-02f, 6.83925077e-02f, -5.09856734e-03f, 5.42448945e-02f, 2.82931507e-01f, 3.52886945e-01f, -1.52850514e-02f, 8.66855085e-02f, 1.65202692e-01f,
  2.41571039e-01f, -1.22501709e-01f, -4.08824205e-01f, -4.64742519e-02f, 1.10173777e-01f, 3.34300734e-02f, -1.18518069e-01f, -5.63394502e-02f, -2.01609284e-01f, 6.39268160e-02f,
  -3.11809212e-01f, -2.53242224e-01f, 9.71096307e-02f, -4.51072231e-02f, -1.21744275e-01f, -1.21905342e-01f, 5.04777431e-02f, 6.83302199e-03f, -7.87303075e-02f, 1.16981201e-01f,
  -1.39322460e-01f, -1.04840152e-01f, 9.56652015e-02f, 2.09370982e-02f, -8.73675290e-03f, -7.10124373e-02f, -6.04314953e-02f, 1.36296049e-01f, 2.14407369e-01f, -1.96905360e-02f,
  4.72989045e-02f, 2.49710474e-02f, 1.21019274e-01f, 1.60634324e-01f, 1.14671476e-01f, -6.74261898e-03f, -6.94017261e-02f, -3.28038298e-02f, 6.15781266e-03f, 5.40873818e-02f,
  9.47800744e-03f, 1.44458539e-03f, -3.48473550e-03f, 1.00967407e-01f, 1.13259824e-02f, 7.54799098e-02f, 1.36550352e-01f, -2.33207252e-02f, 6.10333756e-02f, -3.29149179e-02f,
  6.56034872e-02f, 8.62281173e-02f, 1.19362406e-01f, 9.90235340e-03f, -1.06759645e-01f, 3.94066684e-02f, -1.37841832e-02f, -2.02938735e-01f, -2.52719522e-01f, -5.57190143e-02f,
  -7.27418289e-02f, 1.53681993e-01f, -1.93448558e-01f, -3.05077657e-02f, 2.09548101e-02f, 8.51370096e-02f, -1.43908933e-02f, -1.13791950e-01f, 9.07641661e-04f, -9.82581154e-02f,
  8.15547407e-02f, -4.17112708e-02f, 1.34056866e-01f, 1.70149997e-01f, -7.67199770e-02f, -3.23277831e-01f, -8.30749869e-02f, -1.19059302e-01f, -3.09431292e-02f, -1.41964294e-02f,
  -1.56262457e-01f, -1.44951105e-01f, -1.85078785e-01f, -4.66543138e-02f, -2.91317143e-02f, -1.19598605e-01f, 5.56963636e-03f, 2.34919071e-01f, 7.62647912e-02f, 1.01079801e-02f,
  -8.27773660e-03f, 2.16831770e-02f, 9.88495275e-02f, 1.43889681e-01f, 1.23571701e-01f, 1.50758028e-01f, -5.68095073e-02f, 5.55071458e-02f, -3.72976437e-02f, 9.20032188e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  4.61152166e-01f, 7.65774906e-01f, 1.96043149e-01f, 7.30576575e-01f, 6.38703763e-01f, 3.55115265e-01f, 5.71201563e-01f, 6.15413725e-01f, 6.18258178e-01f, 3.03681493e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  2.05420002e-01f, 5.74783646e-02f, 1.99729964e-01f, -1.87613204e-01f, 4.46655005e-01f, 1.89393580e-01f, 5.13660073e-01f, -7.88904727e-02f, -2.91018665e-01f, 2.99937069e-01f,
  -1.14636652e-01f, 4.09184813e-01f, -4.67200615e-02f, -5.38895607e-01f, 1.24121033e-01f, -1.33793071e-01f, 5.44255525e-02f, -1.65463954e-01f, 1.15495600e-01f, 6.34607747e-02f,
  3.69825177e-02f, 1.62259769e-02f, -5.62581718e-01f, 3.95982265e-01f, -2.28092298e-02f, 1.96382746e-01f, -3.50016326e-01f, -2.92545170e-01f, 3.19142938e-01f, 3.49854231e-01f,
  -3.08395773e-01f, -1.74540564e-01f, 1.57391906e-01f, 1.71171516e-01f, -2.31599603e-02f, 6.33365959e-02f, -9.86422971e-02f, -5.61788529e-02f, -4.34042990e-01f, 3.12941730e-01f,
  -1.76578492e-01f, 3.48101199e-01f, 1.81573197e-01f, -1.02184623e-01f, -5.37787676e-02f, 3.60858999e-02f, 1.20288923e-01f, -2.60398477e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.51351112e-01f, 2.34330356e-01f, 8.49312961e-01f, -4.65354592e-01f, 4.72420603e-01f, 2.08250657e-01f, -2.98200995e-01f, -1.65898770e-01f, -8.63194987e-02f, 4.75928128e-01f,
  8.44863504e-02f, 4.16759849e-01f, 7.60159433e-01f, 9.69077706e-01f, 3.13897401e-01f, -2.21519191e-02f, 4.42132503e-02f, -1.82739690e-01f, 1.62460119e-01f, -4.33432400e-01f,
  -1.39108449e-01f, 1.34345770e-01f, -1.33457527e-01f, 2.69667238e-01f, 8.23449995e-03f, 7.86513686e-01f, 6.60038769e-01f, -3.79465893e-03f, 8.36514294e-01f, 2.25742355e-01f,
  -6.23956472e-02f, -2.49978274e-01f, 8.34736943e-01f, 9.33483601e-01f, 4.15362149e-01f, -1.63131282e-01f, 5.69094539e-01f, 2.32049406e-01f, 1.82714909e-01f, 7.92236030e-02f,
  1.32248938e-01f, -3.54259014e-02f, -2.19191372e-01f, 1.44845799e-01f, 1.57246128e-01f, 1.00783575e+00f, 2.66732812e-01f, -9.55410421e-01f, -1.02822110e-01f, -1.17050804e-01f,
  -3.75778694e-03f, -9.19005051e-02f, -2.42326841e-01f, -1.24601066e-01f, 2.93005019e-01f, 4.51029599e-01f, 3.14958990e-01f, -1.10790133e+00f, -4.13902462e-01f, -7.46751964e-01f,
  5.70179708e-02f, 9.29450274e-01f, 5.07560551e-01f, -1.53173223e-01f, 1.71544820e-01f, -4.63676825e-02f, 2.31134623e-01f, 2.97714114e-01f, -4.12459046e-01f, -3.76416326e-01f,
  -3.00436854e-01f, 9.51391876e-01f, -5.45181692e-01f, 2.28547037e-01f, -1.95022494e-01f, 6.13114715e-01f, 3.78178686e-01f, -7.09025860e-02f, 2.98349589e-01f, 8.46842900e-02f,
  1.17791452e-01f, 1.53848305e-02f, 2.72667706e-02f, 4.72539872e-01f, -2.06642672e-01f, -1.39767095e-01f, -1.17504306e-01f, -4.40474123e-01f, -2.35875994e-01f, -4.33561176e-01f,
  -7.40936637e-01f, -8.40463161e-01f, 4.30603981e-01f, 5.82645297e-01f, 9.40256655e-01f, 2.48641856e-02f, 1.52888119e-01f, -4.37291414e-02f, 7.32616842e-01f, 8.96434039e-02f,
  -8.80831853e-02f, -1.06763601e-01f, 1.20227087e+00f, -4.60359454e-02f, -2.13962302e-01f, -8.38090777e-01f, 5.38504481e-01f, -7.63119059e-03f, 1.99913636e-01f, 4.68784034e-01f,
  1.49133593e-01f, 1.55615509e-01f, 1.38106540e-01f, -1.81161687e-01f, -1.48160785e-01f, -2.86049664e-01f, -2.40143269e-01f, -1.56783089e-01f, -3.60017717e-01f, 9.43841577e-01f,
  -2.15678364e-02f, -8.82114694e-02f, -3.09257239e-01f, 2.59947479e-01f, 5.21243870e-01f, -8.18804204e-01f, 3.90992612e-01f, 1.34777069e-01f, 3.66140932e-01f, -2.02913761e-01f,
  4.45320010e-01f, 4.22733203e-02f, -1.06858060e-01f, 3.07175349e-02f, -7.67630875e-01f, -2.23054171e-01f, 1.90948129e-01f, 5.43770909e-01f, -3.16962779e-01f, 9.69474673e-01f,
  1.00784786e-01f, -3.44930530e-01f, 6.09990805e-02f, 2.38107800e-01f, 4.59910274e-01f, 4.45527136e-01f, -1.53278187e-01f, 4.00374472e-01f, -9.71053243e-02f, 1.17899869e-02f,
  6.61110044e-01f, 2.13224128e-01f, 9.23302397e-02f, 4.03822690e-01f, 5.49475670e-01f, 1.84203368e-02f, -8.49631190e-01f, -1.02909647e-01f, -1.27960563e-01f, -3.12873691e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  1.66295573e-01f, 2.55227864e-01f, 5.72653770e-01f, 6.64802551e-01f, 6.62702382e-01f, 5.81803679e-01f, 5.78985751e-01f, 1.91323385e-01f, -9.78089273e-02f, 2.88831413e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -4.00525510e-01f, -1.30864233e-01f, -4.48005319e-01f, 3.05431962e-01f, -7.65842736e-01f, -3.34250361e-01f, -1.21329159e-01f, -2.86296725e-01f, 6.88074604e-02f, 1.14875577e-01f,
  -3.70448649e-01f, 1.67547300e-01f, 2.18957722e-01f, 4.34441030e-01f, 1.44613415e-01f, 3.68131548e-01f, 4.39690560e-01f, -4.55817729e-01f, 1.92911312e-01f, 1.51234388e-01f,
  -4.27887827e-01f, -1.72656074e-01f, -2.17863038e-01f, -2.14974031e-01f, -3.08630794e-01f, 2.10734364e-02f, 4.03398693e-01f, 1.96975380e-01f, -3.26238833e-02f, -2.50217944e-01f,
  2.53610492e-01f, 1.65572450e-01f, 7.36318231e-01f, 2.54272401e-01f, 4.48515594e-01f, 3.28486025e-01f, 5.17759979e-01f, 8.32912683e-01f, 3.55363488e-02f, 9.07189101e-02f,
  7.38229528e-02f, -5.78283370e-01f, 3.09673816e-01f, 2.98761725e-01f, -4.06164199e-01f, 4.79644798e-02f, -3.95333439e-01f, -2.45283321e-02f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -7.98403770e-02f, -1.52508214e-01f, -1.17095172e-01f, -1.58407673e-01f, -1.22586858e+00f, -1.32356071e+00f, 3.08046266e-02f, 3.89923483e-01f, -1.11613429e+00f, -7.69794583e-02f,
  1.68483973e-01f, -1.32287979e-01f, 9.74487066e-01f, 4.83919412e-01f, 4.11672026e-01f, 2.99484462e-01f, 7.79799640e-01f, 3.40806991e-01f, 7.11444259e-01f, -7.21043814e-03f,
  1.36123702e-01f, -7.23015487e-01f, 3.79420251e-01f, 1.50020123e-01f, 5.56448162e-01f, 9.68839049e-01f, -4.98254389e-01f, 1.34233642e+00f, 1.30879068e+00f, -7.77117088e-02f,
  -4.97054845e-01f, 1.65887788e-01f, 9.80071068e-01f, -8.54518056e-01f, 2.42818385e-01f, -2.37475723e-01f, 2.30156049e-01f, 6.29916668e-01f, 4.02068719e-03f, -3.25163722e-01f,
  2.97852248e-01f, 1.54084221e-01f, 6.34262145e-01f, 1.05242491e+00f, -1.57245815e-01f, 2.88485050e-01f, -2.50019789e-01f, -3.02202076e-01f, 7.24512994e-01f, 9.32785198e-02f,
  3.15154970e-01f, 1.20285404e+00f, -7.43650138e-01f, 1.35707116e+00f, 4.31530893e-01f, 1.04364514e+00f, -2.43790999e-01f, -1.21500838e+00f, -2.65566468e-01f, -1.87172741e-01f,
  -3.23189616e-01f, -4.68961954e-01f, -9.40304101e-01f, 7.24544942e-01f, -1.92468405e-01f, -2.20623299e-01f, 6.07601583e-01f, 2.87510514e-01f, 2.79326677e-01f, 3.51676047e-01f,
  6.34918213e-01f, 4.04141426e-01f, -1.48653507e-01f, 1.90411508e-01f, 8.63846898e-01f, 1.92324936e-01f, 4.97326523e-01f, -1.43516704e-01f, -4.57602918e-01f, -6.61949337e-01f,
  -5.81878304e-01f, -8.55738342e-01f, -2.35095382e-01f, 3.27383690e-02f, -6.53067708e-01f, -3.51066202e-01f, -2.88838178e-01f, -5.06994009e-01f, -3.02217603e-01f, 3.65842968e-01f,
  7.02056229e-01f, 4.04405475e-01f, 2.36224413e-01f, -9.34736710e-03f, 3.59155715e-01f, 7.08573088e-02f, -3.26138467e-01f, 3.20537657e-01f, -2.75925957e-02f, 5.12489676e-01f,
  6.68507889e-02f, 2.21147388e-01f, 9.03646171e-01f, 4.87555832e-01f, -1.22534316e-02f, -2.90387183e-01f, 3.67009819e-01f, -1.11060238e+00f, -5.16495824e-01f, -3.72850031e-01f,
  8.98360491e-01f, -1.11571565e-01f, -4.91173148e-01f, -2.81518877e-01f, 2.37298921e-01f, -2.86555648e-01f, 5.89625061e-01f, 5.01285017e-01f, -1.61883816e-01f, 5.74713945e-02f,
  3.11163723e-01f, 2.75195390e-01f, 1.19743454e+00f, -1.12191451e+00f, 2.33503938e-01f, 7.35879183e-01f, 5.02361834e-01f, 2.50246257e-01f, 7.75864646e-02f, 4.22069997e-01f,
  1.82629868e-01f, -6.77302659e-01f, 8.93817246e-02f, -2.73829520e-01f, 3.07822108e-01f, -1.54655784e-01f, 8.71098995e-01f, -1.67100444e-01f, -5.63280582e-01f, -4.89837706e-01f,
  4.57100272e-01f, -2.99844295e-01f, 9.18449536e-02f, 1.10671496e+00f, 8.19806904e-02f, 2.97158420e-01f, 3.34678203e-01f, -9.36329663e-01f, 1.50482488e+00f, 2.35885695e-01f,
  5.49992919e-01f, 3.16869974e-01f, 7.48608470e-01f, 4.39339936e-01f, 1.93908080e-01f, -2.35633418e-01f, -6.72621280e-02f, -3.31244826e-01f, -4.46485728e-01f, -7.01136172e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  1.75760351e-02f, 6.71802819e-01f, 3.42161298e-01f, 6.26294434e-01f, 3.68326604e-01f, 3.28587204e-01f, 4.73828226e-01f, 3.94261032e-02f, 3.43214661e-01f, 1.09246761e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  1.17029965e-01f, -5.32053649e-01f, 4.47758853e-01f, -1.05507755e+00f, -8.77966881e-02f, 1.28261060e-01f, 7.40439057e-01f, 1.51662678e-01f, 1.57060966e-01f, 2.85869986e-01f,
  3.58243823e-01f, -4.07474786e-01f, -2.77768709e-02f, -7.07990706e-01f, -4.24422801e-01f, -2.33911276e-01f, -3.86606663e-01f, 4.56831783e-01f, -7.82575965e-01f, -3.62420350e-01f,
  -7.75666475e-01f, 8.10263038e-01f, 3.98037046e-01f, 3.83846372e-01f, -2.80367304e-02f, -9.54446554e-01f, -5.77586830e-01f, 1.64890721e-01f, -5.95281720e-01f, 3.02338153e-01f,
  4.78507221e-01f, -3.88723880e-01f, 1.91825345e-01f, -4.98259336e-01f, 9.26896781e-02f, -1.64221838e-01f, -3.99455249e-01f, -6.42741859e-01f, -5.77398121e-01f, 5.88441849e-01f,
  2.17222810e-01f, -7.67041445e-01f, -1.76864937e-01f, -9.71185148e-01f, -9.80372846e-01f, -1.32940531e+00f, 4.41587180e-01f, 3.52149487e-01f, -6.61268175e-01f, -4.28098828e-01f,
  7.48543069e-02f, -1.34251669e-01f, -1.21074808e+00f, 7.01729655e-01f, -2.90143192e-01f, -1.89960897e+00f, -1.32783401e+00f, -1.43841058e-01f, 3.44687194e-01f, -1.18664229e+00f,
  7.22637773e-01f, 3.83738697e-01f, -7.09330738e-01f, 1.32460698e-01f, -7.79834509e-01f, 5.07047474e-01f, -1.32828856e+00f, 1.32146060e-01f, 8.40863049e-01f, -7.02200085e-02f,
  -5.04253566e-01f, -1.92439780e-01f, -1.00290745e-01f, 3.53048772e-01f, 1.89331770e-01f, 1.34916514e-01f, 4.70114499e-01f, -1.92067340e-01f, -3.39935184e-01f, 2.75383890e-01f,
  1.34508684e-01f, -5.42445742e-02f, 1.16760516e+00f, 1.39593232e+00f, 8.02820206e-01f, -1.53342617e+00f, 4.01634395e-01f, 1.14396594e-01f, -3.93266618e-01f, 4.04972970e-01f,
  -1.14215709e-01f, -2.91464329e-01f, -7.08342016e-01f, 6.89113215e-02f, 3.58041257e-01f, -9.31290925e-01f, 8.02703917e-01f, 5.34352601e-01f, -2.77360082e-01f, -3.40337120e-02f,
  -8.68366897e-01f, -4.32633638e-01f, -1.01025236e+00f, 5.00577986e-01f, 1.75093785e-01f, 1.03847213e-01f, 3.58603746e-01f, 1.91770673e-01f, -6.32097125e-01f, -1.18277155e-01f,
  -7.79900908e-01f, -3.48992907e-02f, 6.44268513e-01f, -5.84105253e-01f, -1.74691640e-02f, -3.04315865e-01f, 3.79422009e-01f, -6.34586930e-01f, 3.29543114e-01f, -6.32431865e-01f,
  8.13359693e-02f, -9.18404996e-01f, -2.19480932e-01f, 3.99977505e-01f, 5.63792586e-01f, 1.54257208e-01f, 1.77676737e-01f, -6.53880894e-01f, -3.13121796e-01f, -8.14267993e-01f,
  2.35352993e-01f, 4.82883602e-01f, 5.54705977e-01f, -3.27509791e-01f, -2.08488464e-01f, 6.00580633e-01f, 6.54692411e-01f, -2.18623489e-01f, -3.14721614e-02f, 5.00993967e-01f,
  -2.02504978e-01f, -2.87508011e-01f, -6.77898467e-01f, -1.05352366e+00f, -4.72419620e-01f, -2.49265045e-01f, -1.88204780e-01f, -4.04930472e-01f, 1.62278220e-01f, 2.00623780e-01f,
  -8.61063182e-01f, -3.60296853e-02f, -1.44281566e-01f, -8.20413888e-01f, 3.01301684e-02f, -7.05465853e-01f, 5.84098361e-02f, 3.89740258e-01f, 4.10069972e-01f, 5.94991922e-01f,
  3.45130950e-01f, 1.61453649e-01f, -9.60315242e-02f, 6.25598371e-01f, -1.62140846e-01f, 8.58961880e-01f, -3.85533720e-01f, -1.61461282e+00f, -7.09065020e-01f, 9.38617229e-01f,
  -8.95196795e-01f, -9.90992665e-01f, 5.17812729e-01f, -5.99386275e-01f, 6.11446798e-01f, -9.22978580e-01f, 1.06968202e-01f, 2.94799358e-01f, -8.94252434e-02f, -2.59001076e-01f,
  -2.65296668e-01f, 3.08839977e-01f, -8.98601115e-01f, -7.56504953e-01f, 5.66003084e-01f, -6.44454241e-01f, 1.93982363e-01f, -5.52104637e-02f, -6.77242160e-01f, 8.58222544e-01f,
  -1.08182502e+00f, 7.87937865e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.54930721e-02f, 2.05664814e-01f, -8.47382005e-03f, -1.05118774e-01f, 3.23439389e-01f, 1.20318741e-01f, -1.85047105e-01f, -6.95679635e-02f, -2.81778544e-01f, 1.18827224e-02f,
  4.25297506e-02f, -3.71790737e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    